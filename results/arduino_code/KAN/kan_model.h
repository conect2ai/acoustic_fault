
#ifndef KAN_MODEL_H
#define KAN_MODEL_H

#include <cmath>


inline float score_0(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.00138593348674476*std::pow(-0.634036597249379*x_1 - 0.408442008887028*x_100 - 0.680515802970541*x_101 + 0.0192861936336495*x_105 + 0.452587142676836*x_106 - 0.0732891944472294*x_108 + 0.285168867068929*x_109 - 0.128726196089296*x_111 + 0.0876051043127021*x_112 - 0.420945284791453*x_113 + 0.138998519867831*x_114 - 0.130022607102451*x_116 - 0.00133458310327016*x_17 + 0.000352245378636182*x_18 - 0.00127867221488798*x_19 + 0.0465962443236351*x_2 - 0.00148038870032518*x_20 + 0.00327746108674858*x_21 + 0.00121618549297961*x_23 + 0.000140145676099834*x_24 - 0.000456903028016776*x_25 + 0.000385739683619969*x_26 + 0.000468787425975217*x_27 + 0.00040057658879161*x_28 + 0.000344012173989454*x_29 + 0.000256251301081826*x_30 + 0.279979132061303*x_31 + 0.00328756947929547*x_32 - 0.631846968896327*x_33 + 0.698031238737541*x_34 - 0.629162769782071*x_35 + 0.302129126318458*x_36 + 0.667168124094653*x_37 - 0.709157751969596*x_38 + 0.339602880230517*x_39 - 0.904927649229791*x_40 + 0.589312982537068*x_41 - 0.371690354750425*x_42 - 0.837772531278445*x_43 + 0.868111446579002*x_44 + 0.267273437519385*x_45 - 0.454102448765688*x_46 + 0.874651746809349*x_47 + 0.170754032186959*x_48 - 0.287356375883863*x_49 - 0.322310597895832*x_50 - 0.536525395176536*x_51 - 0.270423334784324*x_52 - 0.386237943731504*x_53 + 0.289172637901756*x_54 + 0.712646742826008*x_55 + 0.528219469675442*x_56 + 0.831713630154522*x_57 - 0.717464871587348*x_58 + 0.200823498522529*x_59 + 0.413783009303254*x_60 - 0.00419907929219594*x_61 + 0.0161089083262865*x_62 - 0.00262863625610718*x_63 - 0.235785679038766*x_64 + 0.208693032464103*x_70 - 0.272886515933076*x_71 + 0.313154943804846*x_72 + 0.313861143757809*x_73 - 0.179132857272852*x_74 + 0.502926783055121*x_76 + 0.432329116138089*x_77 + 0.196082108242859*x_78 - 0.00762865544594101*x_83 - 0.0902316423644442*x_85 + 0.381131131746002*x_86 + 0.294909852935991*x_90 - 0.235732805823029*x_92 + 0.129866470220078*x_93 + 0.0349876751654392*x_95 + 0.466503059123034*x_98 + 0.00604067088359433*std::pow(-5.06224012374878*x_110 - 6.06215953826904, 2) + 0.00427292763206094*std::pow(-4.91359996795654*x_120 - 9.95232009887695, 2) - 0.0033114422644277*std::pow(-9.72855949401855*x_66 - 3.0403196811676, 2) + 0.00277701760439705*std::pow(-9.34815979003906*x_68 - 7.77871990203857, 2) - 0.00244094904581629*std::pow(9.97795963287354*x_69 + 6.79199981689453, 2) - 0.00251898888314256*std::pow(-7.12376022338867*x_75 - 8.96928024291992, 2) + 0.00506967992867502*std::pow(-4.9159197807312*x_84 - 9.26272010803223, 2) - 0.00353845431708547*std::pow(-9.30655956268311*x_87 - 4.45368003845215, 2) - 0.00394359545289472*std::pow(-7.25176000595093*x_91 - 4.82791996002197, 2) - 0.558511331362756*std::exp(0.383119642734528*x_10) + 1.44549741301842*std::exp(0.226719796657562*x_102) - 0.922598908713936*std::exp(0.325359672307968*x_103) + 0.446670954530824*std::exp(0.290799736976624*x_104) + 0.486851896018075*std::exp(0.386399626731873*x_11) - 0.419192778288001*std::exp(0.310719698667526*x_115) + 2.7549596472752*std::exp(0.193679809570313*x_117) - 0.206988688603932*std::exp(0.563039839267731*x_12) + 0.240498898416008*std::exp(0.749999642372131*x_13) + 0.0433135025518324*std::exp(1.05879998207092*x_14) + 0.137942520982449*std::exp(1.23447978496552*x_15) + 0.0546591336783851*std::exp(1.22799980640411*x_16) + 0.283491159633149*std::exp(0.294799715280533*x_22) + 0.491018221027545*std::exp(0.25279974937439*x_3) - 0.587660714176224*std::exp(0.291599720716476*x_4) - 0.140663667677706*std::exp(0.395119607448578*x_5) + 0.0988675839518856*std::exp(0.332639664411545*x_6) - 0.141318677069178*std::exp(1.60343992710114*x_65) + 0.305420596956702*std::exp(0.318159699440002*x_7) - 0.259563422136148*std::exp(0.960240066051483*x_79) + 0.789524786004354*std::exp(0.301119714975357*x_8) - 0.317193480800803*std::exp(1.0*x_80) - 0.166076994955452*std::exp(1.51543974876404*x_81) - 0.195452138430925*std::exp(1.54271984100342*x_82) + 0.343276973507481*std::exp(0.91376006603241*x_88) - 0.0126885168840852*std::exp(3.14815998077393*x_89) - 0.597982828016277*std::exp(0.326159685850143*x_9) + 0.826940268597499*std::exp(0.413439601659775*x_94) - 0.24740071403628*std::exp(0.486799538135529*x_99) + 0.770545972330304*std::sin(0.879599809646606*x_107 + 8.1738395690918) + 0.489753067305635*std::sin(1.02023994922638*x_118 - 1.39911961555481) + 1.13146926829318*std::sin(0.705280065536499*x_119 - 1.23703980445862) - 0.633659600138557*std::sin(1.2203197479248*x_96 - 7.82216024398804) - 1.0758012746202*std::sin(0.741679608821869*x_97 - 1.1515998840332) - 12.6797718267224 - 0.0266239055397149*std::exp(-2.33999991416931*x_67), 2) - 0.000310348521452397*std::pow(-0.577166439477806*x_1 + 0.461683945605611*x_100 + 0.190442131444295*x_104 - 0.085694510517958*x_108 - 0.052829077192369*x_111 + 0.219167861847103*x_113 + 0.245294444001508*x_114 - 0.293659253583315*x_115 - 0.0309476761623521*x_116 + 0.0274379761555746*x_120 + 0.00123085839008209*x_17 - 0.000137374919295019*x_18 - 0.00053645977910246*x_19 + 0.244206707398381*x_2 - 0.00236409113736705*x_20 - 0.00152766896814285*x_21 - 0.0441174036592512*x_32 - 0.208987451281183*x_33 - 0.619646968642146*x_34 + 0.894332986786839*x_35 + 0.178035206740255*x_36 - 0.7765602092802*x_37 - 0.542168230252082*x_38 - 0.510116594586076*x_39 + 1.02768776247897*x_40 + 0.872178757014971*x_41 - 0.139270493328917*x_42 + 0.671974427572498*x_43 + 0.105034207909307*x_44 - 0.3726646914121*x_45 + 0.869697465731664*x_46 - 0.681561797974442*x_47 + 0.681241201647846*x_48 - 0.577667402604338*x_49 + 0.137780261159301*x_50 - 0.581848938421095*x_51 - 0.50349715042649*x_52 - 0.0403612966928039*x_53 - 0.611182250193631*x_54 - 0.530434073623008*x_55 + 0.229462627741655*x_56 + 0.424166603970453*x_57 - 0.668246293440719*x_58 + 0.334577786795088*x_59 + 0.431654251412205*x_60 + 0.00745090741183056*x_62 - 0.0427671258158563*x_63 + 0.177709882565019*x_65 - 0.212903895281491*x_67 + 0.173110569741941*x_69 + 0.221504199731158*x_70 + 0.237184772379335*x_72 - 0.356154843107488*x_73 + 0.00774952035039501*x_74 + 0.158156178838203*x_75 - 0.0246797502914217*x_76 - 0.174169648111661*x_77 + 0.022180415395659*x_80 + 0.0620321425531837*x_85 + 0.382686510295508*x_87 - 0.0131598808693127*x_88 - 0.288484561874625*x_93 + 0.180077804199653*x_94 + 0.246044297071372*x_96 - 0.198013584669608*x_99 + 0.000916707439273072*std::pow(2.20000004768372 - 9.95748043060303*x_86, 2) + 0.1261355450406*std::pow(8.37551975250244 - 0.210639804601669*x_31, 2) + 0.0177596359012488*std::pow(-2.63048005104065*x_102 - 7.50127983093262, 2) + 0.0019708628113517*std::pow(-9.03791999816895*x_107 - 8.22247982025146, 2) - 0.00308364010029025*std::pow(-8.81511974334717*x_61 - 9.24431991577148, 2) + 0.00309511053182054*std::pow(-8.96744060516357*x_78 - 5.9543194770813, 2) + 0.00248526761542897*std::pow(-9.76488018035889*x_81 - 6.16847991943359, 2) - 0.00346956852393679*std::pow(-8.79600048065186*x_82 - 6.76008033752441, 2) - 0.00253452065856377*std::pow(-8.73871994018555*x_84 - 6.90944004058838, 2) - 0.000871298362275993*std::pow(-9.98104000091553*x_89 - 6.3045597076416, 2) + 0.00170221218423632*std::pow(9.99804019927979*x_90 + 6.80000019073486, 2) + 0.00270419654164147*std::pow(-9.12360000610352*x_92 - 4.86263990402222, 2) + 0.129465385377045*std::exp(0.383999645709991*x_10) + 0.0805839861462319*std::exp(0.390159606933594*x_11) - 0.592507387218281*std::exp(0.438959568738937*x_112) - 2.5091797556449*std::exp(0.17751981317997*x_118) - 0.227155718257688*std::exp(0.559599876403809*x_12) - 0.274009587086431*std::exp(0.756479620933533*x_13) + 0.146824242933036*std::exp(1.05224001407623*x_14) - 0.0718405397756047*std::exp(1.22631978988647*x_15) - 0.126359196961661*std::exp(1.24463975429535*x_16) - 0.22951958725685*std::exp(0.317999690771103*x_22) - 0.514218916663014*std::exp(0.509839773178101*x_23) - 0.572387011960054*std::exp(0.603119909763336*x_24) - 0.483788772920242*std::exp(0.649999976158142*x_25) + 0.516656858697257*std::exp(0.779999673366547*x_26) - 0.368444969993619*std::exp(0.663999974727631*x_27) + 1.79947429533004*std::exp(0.900000095367432*x_28) + 1.89265761857743*std::exp(1.0239999294281*x_29) + 0.354688191565164*std::exp(0.253599762916565*x_3) + 2.18361822484999*std::exp(1.0*x_30) - 0.413470868771662*std::exp(0.291999727487564*x_4) + 0.478362631215681*std::exp(0.391519606113434*x_5) + 0.823745655635397*std::exp(0.33903968334198*x_6) + 0.14585648023545*std::exp(1.52415978908539*x_64) + 0.305719396136076*std::exp(0.965040028095245*x_68) + 0.0223704254985866*std::exp(0.319119691848755*x_7) - 0.631682445774976*std::exp(0.763999700546265*x_71) - 0.518901895048242*std::exp(0.5971999168396*x_79) + 0.651356700349651*std::exp(0.302559703588486*x_8) - 0.0592116162161912*std::exp(2.54519987106323*x_83) - 0.489294485100571*std::exp(0.324639678001404*x_9) - 1.05011694674609*std::exp(0.367199659347534*x_97) - 0.789656277159096*std::sin(0.997919976711273*x_101 + 8.19495964050293) + 0.517486848505992*std::sin(1.221599817276*x_103 + 1.38991963863373) + 1.05942881610826*std::sin(0.743679583072662*x_105 - 4.37695980072021) + 0.6898127365411*std::sin(0.938000082969666*x_106 - 1.35967969894409) - 0.998849248551146*std::sin(0.799759685993195*x_109 - 4.20560026168823) - 0.827271271549392*std::sin(0.914640069007874*x_110 - 1.37599968910217) + 0.145422288273105*std::sin(1.37159967422485*x_117 - 4.98199987411499) + 0.435318293368869*std::sin(1.09279990196228*x_119 + 1.55415987968445) + 0.0251008026481359*std::sin(5.21920013427734*x_66 - 9.41256046295166) + 0.0770200994781711*std::sin(3.36391997337341*x_91 - 8.0447998046875) - 0.524041854546695*std::sin(0.978640019893646*x_95 + 8.21375942230225) + 0.799362363283542*std::sin(1.16767990589142*x_98 - 7.76968002319336) - 11.0913629129935, 2) + 0.0679486468434334*std::log(0.453169812241061*x_1 - 0.0688518864117942*x_101 - 0.283380954718729*x_104 - 0.266575977991299*x_105 - 0.125527134733236*x_106 + 0.15891837188559*x_107 + 0.166554218582882*x_111 - 0.193273244843197*x_112 - 0.091070323232657*x_114 + 0.2245197842403*x_117 - 0.000389761234096614*x_17 - 4.2732399386473e-5*x_18 + 0.000229189461070499*x_19 - 0.0196747699751268*x_2 + 0.00169171895657683*x_20 + 0.000802636236853047*x_21 - 0.000303815051108703*x_22 - 0.000276962854548104*x_23 + 0.000455339344593003*x_24 - 0.000431732099879182*x_26 + 3.87151530535827e-5*x_28 + 0.000125697789329865*x_29 - 7.29986244879695e-5*x_30 + 0.131265681330019*x_33 + 0.250815567938267*x_34 + 0.277023535751013*x_35 - 0.0479230256858987*x_36 + 0.413688205802856*x_37 + 0.26323019171*x_38 - 0.495486509151842*x_39 - 0.078423944386517*x_40 + 0.109849048050992*x_41 - 0.328019139038459*x_42 + 0.0942763508639276*x_43 + 0.00698330910601572*x_44 - 0.015603525346941*x_45 + 0.379265123808576*x_46 - 0.0977425930142986*x_47 + 0.375092734304075*x_48 + 0.444944424113658*x_49 - 0.119330690514147*x_50 - 0.0277510965548658*x_51 - 0.0891877570395896*x_52 - 0.42014706780139*x_53 - 0.444434650659364*x_54 - 0.48112741718021*x_55 - 0.293263067061337*x_56 + 0.108303888341974*x_57 - 0.30328038736475*x_58 + 0.0967998289765534*x_59 + 0.217865000322054*x_60 - 0.0927125736294354*x_62 + 0.0180703153924661*x_63 - 0.27853441289475*x_64 + 0.102388911693081*x_68 + 0.272929193612448*x_69 + 0.0741110985801558*x_70 - 0.218289504451788*x_71 + 0.1731408533133*x_72 - 0.0705654726383677*x_75 + 0.100397273631249*x_76 - 0.118672902918972*x_78 - 0.0305940823885331*x_79 - 0.187459120151092*x_81 - 0.194688799366351*x_82 - 0.0662824719544747*x_83 - 0.233912520065952*x_84 - 0.0558074370589727*x_86 - 0.0292309209751271*x_87 + 0.0894473607603633*x_88 + 0.256662915244558*x_89 + 0.0112603135869495*x_90 + 0.156952166936063*x_92 + 0.138832152393303*x_93 + 0.305087271249256*x_96 + 0.322412774299098*x_97 - 0.43748872282879*x_98 - 0.10681810065397*x_99 + 0.126137411172913*std::pow(8.27943992614746 - 0.201439797878265*x_31, 2) - 0.000496554843528476*std::pow(-9.83440017700195*x_108 - 4.4474401473999, 2) - 0.000463840611135174*std::pow(-9.9629602432251*x_109 - 3.39999985694885, 2) - 0.000379226930997231*std::pow(-9.99868011474609*x_116 - 3.37999987602234, 2) - 0.0146733037213873*std::pow(-2.03575992584229*x_119 - 5.2993597984314, 2) + 0.00165750405782326*std::pow(-5.40767955780029*x_120 - 9.19095993041992, 2) + 0.00173431001962589*std::pow(-8.49944019317627*x_65 - 8.27271938323975, 2) + 0.00142486971233799*std::pow(-9.9993200302124*x_73 - 6.0, 2) - 0.00133619102549728*std::pow(-8.14783954620361*x_74 - 9.39192008972168, 2) + 0.00118974223008692*std::pow(-9.59967994689941*x_77 - 1.02799999713898, 2) - 0.00190683312759989*std::pow(-8.69464015960693*x_80 - 7.84104013442993, 2) - 0.000537801036176698*std::pow(-9.93639945983887*x_91 - 4.7960000038147, 2) + 0.311743049994348*std::exp(0.37863963842392*x_10) - 0.0351678321110347*std::exp(0.398079603910446*x_11) + 0.141078500072291*std::exp(0.554959833621979*x_12) + 0.0783037956979967*std::exp(0.746319591999054*x_13) - 0.0730736231981065*std::exp(1.0595999956131*x_14) - 0.0421928498610591*std::exp(1.26079976558685*x_15) + 0.0172734621590748*std::exp(1.17711985111237*x_16) + 0.45769087810379*std::exp(0.59999942779541*x_25) + 0.484847969821688*std::exp(0.625759959220886*x_27) + 0.136133583848149*std::exp(0.254479765892029*x_3) + 0.0650136174850561*std::exp(0.292959719896317*x_4) + 0.0896076750796075*std::exp(0.39087963104248*x_5) + 0.357265920537676*std::exp(0.33751967549324*x_6) - 0.0501437960532405*std::exp(2.69063973426819*x_61) - 0.115828916739842*std::exp(1.45271956920624*x_67) - 0.0427684614485242*std::exp(0.334319651126862*x_7) + 0.339451294809223*std::exp(0.300399720668793*x_8) + 0.0366912320147907*std::exp(2.24656009674072*x_85) + 0.0980117368721084*std::exp(0.318799704313278*x_9) - 0.760865141204191*std::exp(0.273759722709656*x_94) + 1.82104545593905*std::exp(0.158639833331108*x_95) + 0.391163927444769*std::sin(1.18831980228424*x_100 + 4.79408025741577) + 0.768760085473161*std::sin(0.630799949169159*x_102 + 8.37952041625977) + 0.668399886609492*std::sin(0.748079597949982*x_103 - 1.14335989952087) + 0.396323645110638*std::sin(1.08351993560791*x_110 - 4.62207984924316) + 0.507509366587485*std::sin(0.946880042552948*x_113 - 1.34919965267181) - 0.0812829013708858*std::sin(1.5771199464798*x_115 - 5.18495988845825) + 0.184871171740371*std::sin(1.20855975151062*x_118 + 4.79016017913818) - 0.0596618369619666*std::sin(2.92903971672058*x_66 + 2.37191987037659) - 11.282771687494 + 6.20866007078632*std::exp(-0.0245599746704102*x_32)) - 0.313449800014496*std::sin(-0.0630085504467285*x_1 + 0.0332771051106458*x_101 + 0.0618758222818713*x_102 + 0.0859096157530758*x_104 - 0.0630003659186629*x_105 + 0.0190151865445133*x_106 + 0.0227774198985119*x_108 + 0.00336692704961744*x_111 - 0.0204700882701759*x_113 - 0.033354599854935*x_114 - 0.0246581279265783*x_119 - 0.000148893647412411*x_12 - 0.000125299276999796*x_17 - 2.05739666264817e-5*x_18 - 6.30858124635769e-5*x_19 + 0.0139173505932055*x_2 + 0.000111016916385099*x_20 + 0.00010311400718099*x_21 + 9.69401048769752e-6*x_27 - 4.80210085217091e-5*x_28 - 4.88394076175244e-5*x_29 - 6.77191013536703e-6*x_30 - 0.0150777608403316*x_31 + 0.0268718213143866*x_32 + 0.0609923888219933*x_33 + 0.0103345866407122*x_34 - 0.0876565508460452*x_35 - 0.00594231935009249*x_36 - 0.000917664406512952*x_37 - 0.0686898021699691*x_38 + 0.097776165300234*x_39 + 0.0978761922306176*x_40 - 0.0600330179097268*x_41 + 0.0819600544444609*x_42 - 0.0418865366634814*x_43 - 0.0964869059133303*x_44 - 0.0546441938143924*x_45 + 0.0720472164387187*x_46 - 0.0757250910296523*x_47 + 0.0174049186386948*x_48 + 0.121031901477894*x_50 + 0.0525143796733668*x_51 - 0.0842603039549346*x_53 + 0.0569474790442392*x_54 + 0.0919098927546641*x_55 - 0.0711241679649453*x_56 + 0.0763250893860405*x_57 - 0.00912789495514281*x_58 + 0.0334132347020512*x_59 + 0.0723345682804597*x_60 - 0.0512452676914795*x_62 + 0.0337381537030164*x_63 - 0.0422222312677882*x_64 + 0.0369295243537965*x_65 + 0.0199910763498717*x_67 + 0.0354301571250597*x_68 - 0.0213042310653396*x_69 + 0.0127189193926114*x_70 + 0.0129434824549331*x_73 - 0.0146312778241541*x_76 - 0.0451791667581018*x_78 + 0.0189804623199006*x_79 - 0.0187634749868331*x_80 + 0.0487267092737224*x_81 - 0.0471514042193934*x_82 + 0.0472751715131882*x_83 + 0.0191818615169202*x_85 - 0.0329908329886958*x_87 + 0.0440366887671159*x_88 - 0.00542039240085588*x_90 + 0.0116196786267145*x_91 - 0.00353430851130323*x_92 - 0.086416580572046*x_94 + 0.0374170713126824*x_96 + 0.044334927348925*x_98 + 9.61187431491777e-5*std::pow(-9.66063976287842*x_112 - 2.00952005386353, 2) + 0.000292796701862373*std::pow(-9.87936019897461*x_61 - 6.42767953872681, 2) - 0.000139316218657839*std::pow(-9.61999988555908*x_89 - 9.98340034484863, 2) + 0.000278736879045338*std::pow(-9.5272798538208*x_93 - 3.83999991416931, 2) - 0.0510852549920108*std::exp(0.377839624881744*x_10) + 0.130102496715735*std::exp(0.306799709796906*x_109) + 0.081796689407649*std::exp(0.389359623193741*x_11) + 0.240879370088674*std::exp(0.204399809241295*x_110) + 0.22742944309814*std::exp(0.284239739179611*x_116) - 0.0309091728271621*std::exp(0.753279685974121*x_13) + 0.0133329227832847*std::exp(1.06831991672516*x_14) - 0.0025658272668968*std::exp(1.01175999641418*x_15) + 0.0062174990691468*std::exp(1.3155996799469*x_16) - 0.0358934795359867*std::exp(0.302559703588486*x_22) - 0.038550016141121*std::exp(0.454799562692642*x_23) - 0.0713966493488765*std::exp(0.549359798431396*x_24) - 0.0524072581471462*std::exp(0.551279842853546*x_25) - 0.062161906505731*std::exp(0.568719863891602*x_26) + 0.028041749138486*std::exp(0.254239767789841*x_3) + 0.0789207333122212*std::exp(0.290719717741013*x_4) - 0.00521042894689902*std::exp(0.375039637088776*x_5) - 0.0476466647983826*std::exp(0.336479663848877*x_6) + 0.0770180173080175*std::exp(0.322799682617188*x_7) + 0.0142990760464843*std::exp(1.67871999740601*x_72) - 0.0451818270220949*std::exp(0.906000137329102*x_74) - 0.0232516499108448*std::exp(1.59167993068695*x_75) - 0.019287480415503*std::exp(1.82439970970154*x_77) - 0.0239168434262461*std::exp(0.296319723129272*x_8) + 0.035100550625804*std::exp(0.453119575977325*x_84) + 0.00515998054437358*std::exp(2.19304013252258*x_86) - 0.0786714167021959*std::exp(0.321679681539536*x_9) + 0.00109942559999957*std::sin(8.43152046203613*x_100 + 6.17775964736938) + 0.0846915703653073*std::sin(1.13871991634369*x_103 - 4.73816013336182) + 0.0148016964800255*std::sin(2.24272012710571*x_107 + 0.576879858970642) + 0.11174625137326*std::sin(0.942240059375763*x_115 - 7.77415990829468) - 0.154879687385148*std::sin(0.655439972877502*x_117 - 7.4203200340271) - 0.0678070421113719*std::sin(0.86495977640152*x_118 - 1.23255980014801) - 0.0228175115789158*std::sin(1.39743959903717*x_120 + 7.59143972396851) + 0.00608706809117088*std::sin(3.70088005065918*x_66 - 5.78968000411987) + 0.0246472248599117*std::sin(2.39439988136292*x_71 + 2.39183974266052) + 0.1143265752277*std::sin(1.02312004566193*x_95 - 1.41087961196899) + 0.0622435426640817*std::sin(0.921440064907074*x_97 - 4.54048013687134) + 0.0888592433807274*std::sin(0.982560038566589*x_99 - 1.37295973300934) - 11.2501352968248 + 1.89093788425859*std::exp(-0.012639987282455*x_52) + 0.876003303615448*std::exp(-0.015439985319972*x_49)) + 0.190829738974571*std::sin(-0.0245038254534828*x_1 - 0.0495807125511595*x_103 - 0.0422709069072325*x_104 - 0.00019428372368323*x_107 + 0.000933348022137334*x_109 - 0.0399915429956534*x_112 + 0.00517389399168645*x_116 + 0.0215929718190452*x_117 + 0.0367961853198022*x_118 + 0.0228759305842071*x_119 + 0.000272109419758376*x_15 - 5.48449453602854e-5*x_17 + 0.000106045525033629*x_18 + 0.000381095772500539*x_19 + 0.0260590122196954*x_2 + 0.000164384114984001*x_20 + 0.000350608636698489*x_21 + 6.7386518043901e-6*x_22 + 7.92619491738122e-6*x_23 + 0.000282644708662148*x_24 - 9.79691936854351e-6*x_25 + 0.000116732556165546*x_26 + 1.47415018898436e-5*x_27 + 0.000112413400751004*x_28 + 7.85501474425357e-5*x_29 + 0.00011183673830266*x_30 + 0.0388952291225115*x_31 + 0.0332601535184214*x_32 + 0.0601486869032557*x_33 - 0.0246490238109034*x_34 - 0.0252649230291946*x_35 - 0.08689085537371*x_36 + 0.0597246607587601*x_37 - 0.00472568271523369*x_38 - 0.0681498315661664*x_39 + 0.0518544630825903*x_40 + 0.0436783583459519*x_41 - 0.0536347962710202*x_42 - 0.0338639923165622*x_43 - 0.0471336809985669*x_44 + 0.0688536308633663*x_45 - 0.107719741018579*x_46 + 0.0597639046340568*x_47 + 0.0664941026150963*x_48 - 0.0957303387355875*x_49 - 0.0292443199179033*x_50 + 0.0158751367930957*x_51 + 0.0435130714411779*x_52 - 0.0185984393717894*x_53 + 0.0404338890903758*x_54 + 0.0534589961791999*x_55 + 0.0990380710570148*x_56 + 0.0130701505763037*x_57 + 0.0596608115956685*x_58 + 0.00193225178995087*x_59 - 0.0635479774494691*x_60 + 0.00574996623062241*x_61 + 0.0118145902415235*x_63 - 0.02717086427374*x_64 - 0.0182160079203301*x_65 + 0.0272002697514678*x_68 + 0.0302656904588722*x_69 - 0.0312213434799734*x_70 + 0.0136941450971827*x_71 + 0.023134952187473*x_72 + 0.0156000988065638*x_73 + 0.00720658734280775*x_74 - 0.0152873009992649*x_75 + 0.0391794050194361*x_77 + 0.0426973922560514*x_80 - 0.0224554783162313*x_81 - 0.0474635810180769*x_82 - 0.0195349649749381*x_83 + 0.0371762371436104*x_84 + 0.00771961246507648*x_85 - 0.0204574586139227*x_87 + 0.00452030703513061*x_88 + 0.000825180166629594*x_89 + 0.000332140290893236*x_9 + 0.0250405617415205*x_90 - 0.0612362129280145*x_91 + 0.0352294701125108*x_93 + 0.0214121396855323*x_96 - 0.0117808710272063*x_97 + 0.000237736522965569*std::pow(-5.74399995803833*x_102 - 9.33600044250488, 2) - 0.00114746558079731*std::pow(-3.9255998134613*x_106 - 6.27424001693726, 2) - 0.000348824295429553*std::pow(-9.40464019775391*x_67 - 5.20007991790771, 2) + 0.00030449282083192*std::pow(-8.10671997070313*x_76 - 6.87735986709595, 2) - 0.000621108219936634*std::pow(-8.6048002243042*x_86 - 5.2065601348877, 2) + 0.0607262560665773*std::exp(0.376559644937515*x_10) + 0.0943958993318276*std::exp(0.440959572792053*x_100) - 0.0646966518599272*std::exp(0.390479624271393*x_11) + 0.0259719596063341*std::exp(0.597919881343842*x_113) + 0.0585050642733782*std::exp(0.555519819259644*x_12) + 0.0127226952430893*std::exp(0.735919654369354*x_13) + 0.0120371487763529*std::exp(1.00799989700317*x_14) + 0.0117433932249229*std::exp(1.20743978023529*x_16) - 0.0382468780962782*std::exp(0.256639748811722*x_3) - 0.0400310890279454*std::exp(0.296639710664749*x_4) + 0.032622275463937*std::exp(0.39199960231781*x_5) - 0.0145381444495679*std::exp(0.326959699392319*x_6) + 0.0844573936638915*std::exp(0.531519830226898*x_62) + 0.0137862915255915*std::exp(0.329039663076401*x_7) - 0.0184204467025243*std::exp(1.75759971141815*x_78) - 0.0498829757918712*std::exp(0.718479633331299*x_79) - 0.0442322002388792*std::exp(0.303359717130661*x_8) + 0.233859890615419*std::exp(0.286399722099304*x_98) - 0.0466629338967479*std::sin(1.14503979682922*x_101 - 7.75903987884521) - 0.0674196929181647*std::sin(1.16319978237152*x_105 + 7.80984020233154) - 0.0926948591661549*std::sin(1.21303987503052*x_108 + 4.7760796546936) + 0.0647141907973641*std::sin(1.15967988967896*x_110 + 1.62808001041412) - 0.117880615524168*std::sin(0.790319681167603*x_111 + 8.21183967590332) - 0.0850219036435149*std::sin(0.879999816417694*x_114 - 7.63015985488892) + 0.11556629794967*std::sin(0.722879588603973*x_115 - 4.3699197769165) + 0.0747876616610412*std::sin(1.02160000801086*x_120 + 8.18144035339355) + 0.00651113101757894*std::sin(4.38775968551636*x_66 - 0.206719815731049) - 0.0474104644721685*std::sin(1.18479979038239*x_92 - 1.17983984947205) - 0.0460987808439981*std::sin(1.35383975505829*x_94 - 1.54991984367371) + 0.0216685853700014*std::sin(1.47087955474854*x_95 + 4.54888010025024) - 0.10009294373662*std::sin(0.986720025539398*x_99 - 1.37095963954926) - 1.52340506020891) - 0.3013432957232);
}

inline float score_1(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.0128325852979158*x_1 + 0.00826666306177489*x_100 + 0.0137733012985122*x_101 - 0.000390342964348769*x_105 - 0.00916013860767118*x_106 + 0.00148333683456083*x_108 - 0.0057716759992211*x_109 + 0.00260535416813236*x_111 - 0.00177308372813596*x_112 + 0.00851972314575582*x_113 - 0.00281326089097412*x_114 + 0.00263159288207986*x_116 + 2.70112980609785e-5*x_17 - 7.12927122307354e-6*x_18 + 2.58796894955437e-5*x_19 - 0.000943084803684272*x_2 + 2.99623308077304e-5*x_20 - 6.63341818733513e-5*x_21 - 2.46149893309869e-5*x_23 - 2.8364787624047e-6*x_24 + 9.24748997981764e-6*x_25 - 7.80717929267635e-6*x_26 - 9.4880242820609e-6*x_27 - 8.10747087205546e-6*x_28 - 6.96263525700677e-6*x_29 - 5.18639885000371e-6*x_30 - 0.00566663834453703*x_31 - 6.65387707096196e-5*x_32 + 0.0127882683093805*x_33 - 0.0141278050045843*x_34 + 0.0127339414546852*x_35 - 0.00611494320877737*x_36 - 0.0135031509184757*x_37 + 0.0143530000970098*x_38 - 0.00687339334493011*x_39 + 0.0183152854228954*x_40 - 0.0119274015859398*x_41 + 0.00752282786583593*x_42 + 0.0169560992449352*x_43 - 0.0175701437971419*x_44 - 0.00540948140803563*x_45 + 0.00919080764905145*x_46 - 0.0177025162200336*x_47 - 0.00345597666208592*x_48 + 0.00581595008935938*x_49 + 0.00652340615331029*x_50 + 0.0108590070793546*x_51 + 0.00547323376161799*x_52 + 0.00781726382945161*x_53 - 0.00585271032901918*x_54 - 0.014423615536186*x_55 - 0.0106908992793738*x_56 - 0.0168334701004636*x_57 + 0.0145211320653177*x_58 - 0.00406456770129092*x_59 - 0.00837476225307516*x_60 + 8.49872758506122e-5*x_61 - 0.000326036290413172*x_62 + 5.32022900886619e-5*x_63 + 0.0047721848414089*x_64 - 0.00422384315320994*x_70 + 0.00552308732264697*x_71 - 0.00633810026940628*x_72 - 0.00635239340512288*x_73 + 0.00362555991339586*x_74 - 0.0101789878851785*x_76 - 0.00875012622880583*x_77 - 0.00396860432085117*x_78 + 0.000154400191003397*x_83 + 0.00182624355161212*x_85 - 0.00771390449548149*x_86 - 0.00596882870707292*x_90 + 0.00477111471382659*x_92 - 0.00262843274925803*x_93 - 0.00070813313913436*x_95 - 0.00944178983343516*x_98 - 0.000122260173476819*std::pow(-5.06224012374878*x_110 - 6.06215953826904, 2) - 8.64819295102563e-5*std::pow(-4.91359996795654*x_120 - 9.95232009887695, 2) + 6.70219440040906e-5*std::pow(-9.72855949401855*x_66 - 3.0403196811676, 2) - 5.62054547589824e-5*std::pow(-9.34815979003906*x_68 - 7.77871990203857, 2) + 4.94035943259339e-5*std::pow(9.97795963287354*x_69 + 6.79199981689453, 2) + 5.09830818089425e-5*std::pow(-7.12376022338867*x_75 - 8.96928024291992, 2) - 0.000102607799612971*std::pow(-4.9159197807312*x_84 - 9.26272010803223, 2) + 7.16165550123885e-5*std::pow(-9.30655956268311*x_87 - 4.45368003845215, 2) + 7.9816410045239e-5*std::pow(-7.25176000595093*x_91 - 4.82791996002197, 2) - 0.000984566169790924*std::pow(-0.256079147640698*x_1 + 0.204841486239301*x_100 + 0.084496005587671*x_104 - 0.0380212287304507*x_108 - 0.0234393827026852*x_111 + 0.0972411342953672*x_113 + 0.108833064163843*x_114 - 0.130291725593845*x_115 - 0.0137309690776298*x_116 + 0.0121737735708653*x_120 + 0.000546111391514376*x_17 - 6.09509663661426e-5*x_18 - 0.000238018279615091*x_19 + 0.108350453528273*x_2 - 0.00104890790938852*x_20 - 0.000677801307354443*x_21 - 0.0195741580806451*x_32 - 0.0927242554853108*x_33 - 0.274927051738469*x_34 + 0.396800668400851*x_35 + 0.0789912594941049*x_36 - 0.344546846251275*x_37 - 0.240551024426217*x_38 - 0.226330246881932*x_39 + 0.455967963928212*x_40 + 0.386971205201728*x_41 - 0.0617920010308222*x_42 + 0.298143874763058*x_43 + 0.046601930733995*x_44 - 0.165345124049376*x_45 + 0.38587029753729*x_46 - 0.302397631517984*x_47 + 0.302255388261211*x_48 - 0.256301416646078*x_49 + 0.0611308098081877*x_50 - 0.258156694525286*x_51 - 0.223393309627272*x_52 - 0.0179076359050221*x_53 - 0.271171396979202*x_54 - 0.23534477433556*x_55 + 0.10180875066236*x_56 + 0.188195665882232*x_57 - 0.29648976366883*x_58 + 0.148446598072326*x_59 + 0.191517810490039*x_60 + 0.00330584366772541*x_62 - 0.0189750622643195*x_63 + 0.0788469185695413*x_65 - 0.0944619165355421*x_67 + 0.0768062799826329*x_69 + 0.0982777285479556*x_70 + 0.105234937774979*x_72 - 0.158019979009155*x_73 + 0.00343833326093747*x_74 + 0.0701712655150907*x_75 - 0.0109499946399007*x_76 - 0.0772761754367901*x_77 + 0.00984108132478373*x_80 + 0.0275226297040377*x_85 + 0.169791638368182*x_87 - 0.0058388202181605*x_88 - 0.127995800967209*x_93 + 0.079897526006844*x_94 + 0.109165761496627*x_96 - 0.0878553334274768*x_99 + 0.000406727840754784*std::pow(2.20000004768372 - 9.95748043060303*x_86, 2) + 0.055964242984079*std::pow(8.37551975250244 - 0.210639804601669*x_31, 2) + 0.00787965500578247*std::pow(-2.63048005104065*x_102 - 7.50127983093262, 2) + 0.000874439042755706*std::pow(-9.03791999816895*x_107 - 8.22247982025146, 2) - 0.00136815981405199*std::pow(-8.81511974334717*x_61 - 9.24431991577148, 2) + 0.00137324905370356*std::pow(-8.96744060516357*x_78 - 5.9543194770813, 2) + 0.00110267189685161*std::pow(-9.76488018035889*x_81 - 6.16847991943359, 2) - 0.00153938983544259*std::pow(-8.79600048065186*x_82 - 6.76008033752441, 2) - 0.0011245246527327*std::pow(-8.73871994018555*x_84 - 6.90944004058838, 2) - 0.000386580588702008*std::pow(-9.98104000091553*x_89 - 6.3045597076416, 2) + 0.000755243228690201*std::pow(9.99804019927979*x_90 + 6.80000019073486, 2) + 0.00119980701938076*std::pow(-9.12360000610352*x_92 - 4.86263990402222, 2) + 0.0574416377472047*std::exp(0.383999645709991*x_10) + 0.0357537740837587*std::exp(0.390159606933594*x_11) - 0.262885670946065*std::exp(0.438959568738937*x_112) - 1.11328131567073*std::exp(0.17751981317997*x_118) - 0.100785213301329*std::exp(0.559599876403809*x_12) - 0.121573495454722*std::exp(0.756479620933533*x_13) + 0.0651434740684164*std::exp(1.05224001407623*x_14) - 0.0318744523822784*std::exp(1.22631978988647*x_15) - 0.0560634736208524*std::exp(1.24463975429535*x_16) - 0.101834022651691*std::exp(0.317999690771103*x_22) - 0.228150378942556*std::exp(0.509839773178101*x_23) - 0.253958595160093*std::exp(0.603119909763336*x_24) - 0.214649030389991*std::exp(0.649999976158142*x_25) + 0.229232053266329*std::exp(0.779999673366547*x_26) - 0.163472903853926*std::exp(0.663999974727631*x_27) + 0.798396809361229*std::exp(0.900000095367432*x_28) + 0.839740699718245*std::exp(1.0239999294281*x_29) + 0.157369250118571*std::exp(0.253599762916565*x_3) + 0.96883508039414*std::exp(1.0*x_30) - 0.183450146105346*std::exp(0.291999727487564*x_4) + 0.212241541583229*std::exp(0.391519606113434*x_5) + 0.365482243837138*std::exp(0.33903968334198*x_6) + 0.0647140938588868*std::exp(1.52415978908539*x_64) + 0.135642610215845*std::exp(0.965040028095245*x_68) + 0.00992538564650564*std::exp(0.319119691848755*x_7) - 0.280266992723972*std::exp(0.763999700546265*x_71) - 0.230228138547557*std::exp(0.5971999168396*x_79) + 0.288996132184172*std::exp(0.302559703588486*x_8) - 0.0262712090896848*std::exp(2.54519987106323*x_83) - 0.217091823293143*std::exp(0.324639678001404*x_9) - 0.465919419862823*std::exp(0.367199659347534*x_97) - 0.35035735370716*std::sin(0.997919976711273*x_101 + 8.19495964050293) + 0.229600305937021*std::sin(1.221599817276*x_103 + 1.38991963863373) + 0.470050941389548*std::sin(0.743679583072662*x_105 - 4.37695980072021) + 0.306058435700045*std::sin(0.938000082969666*x_106 - 1.35967969894409) - 0.443172795046696*std::sin(0.799759685993195*x_109 - 4.20560026168823) - 0.367046500967163*std::sin(0.914640069007874*x_110 - 1.37599968910217) + 0.0645214501082725*std::sin(1.37159967422485*x_117 - 4.98199987411499) + 0.193143484952385*std::sin(1.09279990196228*x_119 + 1.55415987968445) + 0.0111368085660829*std::sin(5.21920013427734*x_66 - 9.41256046295166) + 0.0341725368568147*std::sin(3.36391997337341*x_91 - 8.0447998046875) - 0.232508653070305*std::sin(0.978640019893646*x_95 + 8.21375942230225) + 0.354663782653244*std::sin(1.16767990589142*x_98 - 7.76968002319336) - 8.61003132599633, 2) - 0.000888848153408617*std::pow(0.210291731950317*x_1 + 0.425501476637078*x_103 + 0.362768753862841*x_104 + 0.00166734213891065*x_107 - 0.00800998898968917*x_109 + 0.343207261898211*x_112 - 0.044402337524994*x_116 - 0.185310797712036*x_117 - 0.315784715115419*x_118 - 0.196321144698833*x_119 - 0.00233524195108285*x_15 + 0.000470679101531701*x_17 - 0.000910082271326859*x_18 - 0.00327056239403189*x_19 - 0.223638338552372*x_2 - 0.00141074381674525*x_20 - 0.00300892191662201*x_21 - 5.78310828097213e-5*x_22 - 6.80225730515472e-5*x_23 - 0.00242565575828111*x_24 + 8.4077122802709e-5*x_25 - 0.00100179832971963*x_26 - 0.000126511510206806*x_27 - 0.000964731355242072*x_28 - 0.000674117050907076*x_29 - 0.000959782440418831*x_30 - 0.33379870062757*x_31 - 0.285438504351088*x_32 - 0.516195790222019*x_33 + 0.211537823672456*x_34 + 0.216823468298319*x_35 + 0.745696972983655*x_36 - 0.512556799547381*x_37 + 0.0405557901447148*x_38 + 0.584861581689668*x_39 - 0.445014794595747*x_40 - 0.37484749647575*x_41 + 0.460293606891985*x_42 + 0.290620646499501*x_43 + 0.404501061648461*x_44 - 0.590901584440853*x_45 + 0.924450386207635*x_46 - 0.512893590328079*x_47 - 0.570652122459647*x_48 + 0.821557383809877*x_49 + 0.25097463646726*x_50 - 0.136240360408452*x_51 - 0.373429004920642*x_52 + 0.159611732237126*x_53 - 0.347003474312359*x_54 - 0.45878489120773*x_55 - 0.849944329351155*x_56 - 0.112167979924607*x_57 - 0.512008846285323*x_58 - 0.0165825771263448*x_59 + 0.545368488081893*x_60 - 0.0493461871734626*x_61 - 0.101392766157668*x_63 + 0.233180248429319*x_64 + 0.156329707051616*x_65 - 0.233432606121464*x_68 - 0.259740034361198*x_69 + 0.267941444762705*x_70 - 0.117523098404873*x_71 - 0.198544067061169*x_72 - 0.133879985509042*x_73 - 0.0618469037272249*x_74 + 0.131195555978967*x_75 - 0.33623749703739*x_77 - 0.366428849419138*x_80 + 0.19271282501818*x_81 + 0.40733226229527*x_82 + 0.167648991214334*x_83 - 0.319046318345953*x_84 - 0.0662496832728399*x_85 + 0.175565827931257*x_87 - 0.0387932568802112*x_88 - 0.00708169288672941*x_89 - 0.00285042664685212*x_9 - 0.214898000625643*x_90 + 0.525528934213015*x_91 - 0.302339171478175*x_93 - 0.18375889706612*x_96 + 0.101103387995379*x_97 - 0.00204025388840541*std::pow(-5.74399995803833*x_102 - 9.33600044250488, 2) + 0.00984754502097329*std::pow(-3.9255998134613*x_106 - 6.27424001693726, 2) + 0.00299360870699492*std::pow(-9.40464019775391*x_67 - 5.20007991790771, 2) - 0.00261315616946173*std::pow(-8.10671997070313*x_76 - 6.87735986709595, 2) + 0.00533034825713258*std::pow(-8.6048002243042*x_86 - 5.2065601348877, 2) - 0.521152486469573*std::exp(0.376559644937515*x_10) - 0.810105230188715*std::exp(0.440959572792053*x_100) + 0.555226407274176*std::exp(0.390479624271393*x_11) - 0.222891253372986*std::exp(0.597919881343842*x_113) - 0.50209022739201*std::exp(0.555519819259644*x_12) - 0.109186119645863*std::exp(0.735919654369354*x_13) - 0.103302762612647*std::exp(1.00799989700317*x_14) - 0.10078175364621*std::exp(1.20743978023529*x_16) + 0.328234554715856*std::exp(0.256639748811722*x_3) + 0.343546645789034*std::exp(0.296639710664749*x_4) - 0.279964237440998*std::exp(0.39199960231781*x_5) + 0.124766297468422*std::exp(0.326959699392319*x_6) - 0.724813014331404*std::exp(0.531519830226898*x_62) - 0.118313898684605*std::exp(0.329039663076401*x_7) + 0.158084199862016*std::exp(1.75759971141815*x_78) + 0.428095498558873*std::exp(0.718479633331299*x_79) + 0.379600565383764*std::exp(0.303359717130661*x_8) - 2.006984645095*std::exp(0.286399722099304*x_98) + 0.400461111905102*std::sin(1.14503979682922*x_101 - 7.75903987884521) + 0.578595534735342*std::sin(1.16319978237152*x_105 + 7.80984020233154) + 0.795506910296361*std::sin(1.21303987503052*x_108 + 4.7760796546936) - 0.555376926365049*std::sin(1.15967988967896*x_110 + 1.62808001041412) + 1.01165097053951*std::sin(0.790319681167603*x_111 + 8.21183967590332) + 0.729657636716738*std::sin(0.879999816417694*x_114 - 7.63015985488892) - 0.991789506379632*std::sin(0.722879588603973*x_115 - 4.3699197769165) - 0.64182741299193*std::sin(1.02160000801086*x_120 + 8.18144035339355) - 0.0558785003280984*std::sin(4.38775968551636*x_66 - 0.206719815731049) + 0.406876416310915*std::sin(1.18479979038239*x_92 - 1.17983984947205) + 0.395619552664769*std::sin(1.35383975505829*x_94 - 1.54991984367371) - 0.185959712903653*std::sin(1.47087955474854*x_95 + 4.54888010025024) + 0.858997242464753*std::sin(0.986720025539398*x_99 - 1.37095963954926) + 1.12999357853388, 2) + 0.0113039914898574*std::exp(0.383119642734528*x_10) - 0.0292561485109032*std::exp(0.226719796657562*x_102) + 0.0186729429234808*std::exp(0.325359672307968*x_103) - 0.00904039790287342*std::exp(0.290799736976624*x_104) - 0.00985364016873415*std::exp(0.386399626731873*x_11) + 0.00848425328599021*std::exp(0.310719698667526*x_115) - 0.0557590126805725*std::exp(0.193679809570313*x_117) + 0.00418934808138364*std::exp(0.563039839267731*x_12) - 0.00486757805679842*std::exp(0.749999642372131*x_13) - 0.000876643743372542*std::exp(1.05879998207092*x_14) - 0.00279188799888879*std::exp(1.23447978496552*x_15) - 0.00110627367297251*std::exp(1.22799980640411*x_16) - 0.00573772003537297*std::exp(0.294799715280533*x_22) - 0.00993796451419751*std::exp(0.25279974937439*x_3) + 0.0118939604963125*std::exp(0.291599720716476*x_4) + 0.0028469626542423*std::exp(0.395119607448578*x_5) - 0.00200103071299907*std::exp(0.332639664411545*x_6) + 0.00286021971846141*std::exp(1.60343992710114*x_65) - 0.00618156093700329*std::exp(0.318159699440002*x_7) + 0.00525343453237758*std::exp(0.960240066051483*x_79) - 0.0159795888836282*std::exp(0.301119714975357*x_8) + 0.0064198382490501*std::exp(1.0*x_80) + 0.00336131575532561*std::exp(1.51543974876404*x_81) + 0.00395585404526482*std::exp(1.54271984100342*x_82) - 0.00694775516501065*std::exp(0.91376006603241*x_88) + 0.000256809269252679*std::exp(3.14815998077393*x_89) + 0.0121028749452291*std::exp(0.326159685850143*x_9) - 0.0167368596372758*std::exp(0.413439601659775*x_94) + 0.00500726737132988*std::exp(0.486799538135529*x_99) - 0.0155954671367415*std::sin(0.879599809646606*x_107 + 8.1738395690918) - 0.00991235843227445*std::sin(1.02023994922638*x_118 - 1.39911961555481) - 0.0229003750892818*std::sin(0.705280065536499*x_119 - 1.23703980445862) + 0.0128249550639472*std::sin(1.2203197479248*x_96 - 7.82216024398804) + 0.0217736825919221*std::sin(0.741679608821869*x_97 - 1.1515998840332) - 0.205791398882866*std::sin(-0.0603482092255782*x_1 + 0.0318720822396427*x_101 + 0.0592633070051041*x_102 + 0.0822823478591045*x_104 - 0.0603403702639038*x_105 + 0.0182123290873338*x_106 + 0.021815713770727*x_108 + 0.00322476896543367*x_111 - 0.0196058020861639*x_113 - 0.0319463050079669*x_114 - 0.0236170147174285*x_119 - 0.000142607073527275*x_12 - 0.000120008902451905*x_17 - 1.97052945000649e-5*x_18 - 6.04222090926581e-5*x_19 + 0.01332973349664*x_2 + 0.000106329570353326*x_20 + 9.87603370546869e-5*x_21 + 9.28471086858489e-6*x_27 - 4.5993469917095e-5*x_28 - 4.67773146415669e-5*x_29 - 6.48598716854249e-6*x_30 - 0.0144411490090518*x_31 + 0.0257372417466422*x_32 + 0.0584171737915069*x_33 + 0.00989824067419007*x_34 - 0.0839555240192695*x_35 - 0.0056914232890943*x_36 - 0.000878918864352085*x_37 - 0.0657895876611474*x_38 + 0.0936478690428214*x_39 + 0.0937436726453513*x_40 - 0.0574983093496509*x_41 + 0.0784995445647634*x_42 - 0.040118007165389*x_43 - 0.0924130446471597*x_44 - 0.0523370116895813*x_45 + 0.069005245493472*x_46 - 0.0725278332017347*x_47 + 0.0166700497649149*x_48 + 0.115921703666756*x_50 + 0.0502971223653081*x_51 - 0.0807026731519932*x_53 + 0.05454304782232*x_54 + 0.0880292817170643*x_55 - 0.0681211698874521*x_56 + 0.0731024984827101*x_57 - 0.00874249781397184*x_58 + 0.0320024641799617*x_59 + 0.0692804647921829*x_60 - 0.0490815947127813*x_62 + 0.0323136644807556*x_63 - 0.0404395281029915*x_64 + 0.0353702893734752*x_65 + 0.019147014963097*x_67 + 0.0339342282899516*x_68 - 0.0204047257809584*x_69 + 0.0121819023479603*x_70 + 0.012396983929321*x_73 - 0.0140135173577138*x_76 - 0.0432716161350254*x_78 + 0.0181790709857386*x_79 - 0.0179712452718884*x_80 + 0.0466693746368704*x_81 - 0.0451605819676416*x_82 + 0.0452791235701425*x_83 + 0.0183719667243872*x_85 - 0.0315978970728931*x_87 + 0.0421773757446845*x_88 - 0.00519153309149915*x_90 + 0.0111290736245679*x_91 - 0.00338508326244067*x_92 - 0.082767907656121*x_94 + 0.0358372511695098*x_96 + 0.0424630221245259*x_98 + 9.20604264173699e-5*std::pow(-9.66063976287842*x_112 - 2.00952005386353, 2) + 0.000280434266449105*std::pow(-9.87936019897461*x_61 - 6.42767953872681, 2) - 0.000133434022088603*std::pow(-9.61999988555908*x_89 - 9.98340034484863, 2) + 0.000266968076177765*std::pow(-9.5272798538208*x_93 - 3.83999991416931, 2) - 0.0489283380547909*std::exp(0.377839624881744*x_10) + 0.124609321066819*std::exp(0.306799709796906*x_109) + 0.0783430771115088*std::exp(0.389359623193741*x_11) + 0.230708983481964*std::exp(0.204399809241295*x_110) + 0.217826938071639*std::exp(0.284239739179611*x_116) - 0.0296041285752192*std::exp(0.753279685974121*x_13) + 0.0127699813439514*std::exp(1.06831991672516*x_14) - 0.00245749314405028*std::exp(1.01175999641418*x_15) + 0.00595498439536297*std::exp(1.3155996799469*x_16) - 0.0343779883446629*std::exp(0.302559703588486*x_22) - 0.0369223609056155*std::exp(0.454799562692642*x_23) - 0.068382146587455*std::exp(0.549359798431396*x_24) - 0.0501945237143141*std::exp(0.551279842853546*x_25) - 0.0595373122071794*std::exp(0.568719863891602*x_26) + 0.0268577729857678*std::exp(0.254239767789841*x_3) + 0.0755885493697986*std::exp(0.290719717741013*x_4) - 0.00499043469518187*std::exp(0.375039637088776*x_5) - 0.0456349317000211*std::exp(0.336479663848877*x_6) + 0.073766169665704*std::exp(0.322799682617188*x_7) + 0.0136953417729433*std::exp(1.67871999740601*x_72) - 0.0432741640775969*std::exp(0.906000137329102*x_74) - 0.0222699208871011*std::exp(1.59167993068695*x_75) - 0.0184731261915494*std::exp(1.82439970970154*x_77) - 0.0229070286630826*std::exp(0.296319723129272*x_8) + 0.0336185384059887*std::exp(0.453119575977325*x_84) + 0.00494211632046739*std::exp(2.19304013252258*x_86) - 0.0753497593827486*std::exp(0.321679681539536*x_9) + 0.00105300575344652*std::sin(8.43152046203613*x_100 + 6.17775964736938) + 0.081115730671657*std::sin(1.13871991634369*x_103 - 4.73816013336182) + 0.0141767406127729*std::sin(2.24272012710571*x_107 + 0.576879858970642) + 0.107028111426704*std::sin(0.942240059375763*x_115 - 7.77415990829468) - 0.148340371470907*std::sin(0.655439972877502*x_117 - 7.4203200340271) - 0.064944099416544*std::sin(0.86495977640152*x_118 - 1.23255980014801) - 0.0218541127038887*std::sin(1.39743959903717*x_120 + 7.59143972396851) + 0.00583006046214152*std::sin(3.70088005065918*x_66 - 5.78968000411987) + 0.0236065719990397*std::sin(2.39439988136292*x_71 + 2.39183974266052) + 0.109499489084712*std::sin(1.02312004566193*x_95 - 1.41087961196899) + 0.0596155015311615*std::sin(0.921440064907074*x_97 - 4.54048013687134) + 0.0851074365803814*std::sin(0.982560038566589*x_99 - 1.37295973300934) + 1.52745356983724 + 1.81109887884644*std::exp(-0.012639987282455*x_52) + 0.839016772708943*std::exp(-0.015439985319972*x_49)) + 0.0812207832932472*std::sin(0.135270543741547*x_1 - 0.0205521900642408*x_101 - 0.0845888115124714*x_104 - 0.07957254988586*x_105 - 0.0374696709953196*x_106 + 0.0474369077436472*x_107 + 0.0497161971110519*x_111 - 0.0576917884078411*x_112 - 0.027184361821186*x_114 + 0.067018835929796*x_117 - 0.000116343173445056*x_17 - 1.27555603754874e-5*x_18 + 6.84127278150357e-5*x_19 - 0.0058728908251054*x_2 + 0.000504975699908934*x_20 + 0.000239585773926234*x_21 - 9.06883601912979e-5*x_22 - 8.26730177494783e-5*x_23 + 0.000135918146059673*x_24 - 0.000128871417124031*x_26 + 1.15564180647795e-5*x_28 + 3.75206111494393e-5*x_29 - 2.1789985475952e-5*x_30 + 0.0391826189840529*x_33 + 0.0748680899243273*x_34 + 0.0826911310021503*x_35 - 0.0143049549355756*x_36 + 0.123485340432716*x_37 + 0.0785738374445433*x_38 - 0.147902017519908*x_39 - 0.0234094357412269*x_40 + 0.0327897844427569*x_41 - 0.0979132459771247*x_42 + 0.0281413565044544*x_43 + 0.00208450782547614*x_44 - 0.00465763010013329*x_45 + 0.113210099468189*x_46 - 0.0291760248511869*x_47 + 0.111964647141645*x_48 + 0.132815277096629*x_49 - 0.0356200412182715*x_50 - 0.00828366281027563*x_51 - 0.0266224184929084*x_52 - 0.125413301543304*x_53 - 0.132663110446326*x_54 - 0.143615849010509*x_55 - 0.0875386079768231*x_56 + 0.0323285564695768*x_57 - 0.0905287638249693*x_58 + 0.028894611128205*x_59 + 0.065032392405123*x_60 - 0.0276745712264273*x_62 + 0.00539396341656548*x_63 - 0.0831421256784046*x_64 + 0.0305629443614853*x_68 + 0.0814689757032157*x_69 + 0.0221220574085555*x_70 - 0.0651591062834497*x_71 + 0.0516822982001875*x_72 - 0.0210636931131097*x_75 + 0.0299684432356753*x_76 - 0.035423692557654*x_78 - 0.00913229003384964*x_79 - 0.0559562804652603*x_81 - 0.0581143294175698*x_82 - 0.0197852235070022*x_83 - 0.0698225542005991*x_84 - 0.0166584405048006*x_86 - 0.0087253882927848*x_87 + 0.0266999098339418*x_88 + 0.076613514769941*x_89 + 0.00336118757353753*x_90 + 0.0468499983656491*x_92 + 0.0414411998234815*x_93 + 0.0910681160918961*x_96 + 0.0962397540846344*x_97 - 0.130589760878347*x_98 - 0.0318850509601368*x_99 + 0.0376518376436661*std::pow(8.27943992614746 - 0.201439797878265*x_31, 2) - 0.000148220913810264*std::pow(-9.83440017700195*x_108 - 4.4474401473999, 2) - 0.00013845576201861*std::pow(-9.9629602432251*x_109 - 3.39999985694885, 2) - 0.000113198698968381*std::pow(-9.99868011474609*x_116 - 3.37999987602234, 2) - 0.00437996026933296*std::pow(-2.03575992584229*x_119 - 5.2993597984314, 2) + 0.000494762601345355*std::pow(-5.40767955780029*x_120 - 9.19095993041992, 2) + 0.000517689071588934*std::pow(-8.49944019317627*x_65 - 8.27271938323975, 2) + 0.000425321580437253*std::pow(-9.9993200302124*x_73 - 6.0, 2) - 0.000398851118673908*std::pow(-8.14783954620361*x_74 - 9.39192008972168, 2) + 0.000355136361754231*std::pow(-9.59967994689941*x_77 - 1.02799999713898, 2) - 0.000569186973684872*std::pow(-8.69464015960693*x_80 - 7.84104013442993, 2) - 0.000160532843590409*std::pow(-9.93639945983887*x_91 - 4.7960000038147, 2) + 0.0930548565709663*std::exp(0.37863963842392*x_10) - 0.0104975478140202*std::exp(0.398079603910446*x_11) + 0.042111731407363*std::exp(0.554959833621979*x_12) + 0.0233735715287685*std::exp(0.746319591999054*x_13) - 0.0218123724841466*std::exp(1.0595999956131*x_14) - 0.0125945056103492*std::exp(1.26079976558685*x_15) + 0.00515610386093889*std::exp(1.17711985111237*x_16) + 0.136620075464585*std::exp(0.59999942779541*x_25) + 0.144726428676756*std::exp(0.625759959220886*x_27) + 0.0406356809549107*std::exp(0.254479765892029*x_3) + 0.0194064722544456*std::exp(0.292959719896317*x_4) + 0.0267477634299844*std::exp(0.39087963104248*x_5) + 0.106643368613769*std::exp(0.33751967549324*x_6) - 0.0149678517283471*std::exp(2.69063973426819*x_61) - 0.0345747667323837*std::exp(1.45271956920624*x_67) - 0.0127663248496654*std::exp(0.334319651126862*x_7) + 0.101325728197866*std::exp(0.300399720668793*x_8) + 0.0109522805163108*std::exp(2.24656009674072*x_85) + 0.0292563639095425*std::exp(0.318799704313278*x_9) - 0.227117161347744*std::exp(0.273759722709656*x_94) + 0.543579475836559*std::exp(0.158639833331108*x_95) + 0.116761875412359*std::sin(1.18831980228424*x_100 + 4.79408025741577) + 0.229473790971397*std::sin(0.630799949169159*x_102 + 8.37952041625977) + 0.199516414501058*std::sin(0.748079597949982*x_103 - 1.14335989952087) + 0.118302043789337*std::sin(1.08351993560791*x_110 - 4.62207984924316) + 0.151490823346588*std::sin(0.946880042552948*x_113 - 1.34919965267181) - 0.024262830330546*std::sin(1.5771199464798*x_115 - 5.18495988845825) + 0.0551837815493195*std::sin(1.20855975151062*x_118 + 4.79016017913818) - 0.0178089733880413*std::sin(2.92903971672058*x_66 + 2.37191987037659) + 4.75145245416832 + 1.85327619138705*std::exp(-0.0245599746704102*x_32)) - 0.0163160625775518 + 0.000538854602848211*std::exp(-2.33999991416931*x_67));
}

inline float score_2(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.00355290635316818*x_1 + 0.00290459068831214*x_100 + 0.00364978125766284*x_101 - 0.00221201594966635*x_102 - 0.00649200713107581*x_103 - 0.00860608135611504*x_104 + 0.00211506591502289*x_105 - 0.00389830316362154*x_106 - 2.54391527411397e-5*x_107 - 0.000293088214688103*x_108 - 0.00190573634861979*x_109 + 0.00079505705905821*x_111 - 0.00585941306181342*x_112 + 0.00372529723662319*x_113 + 0.000203930074290883*x_114 + 0.00160210169860967*x_116 + 0.00282734393713513*x_117 + 0.00481802469551149*x_118 + 0.00387684245474416*x_119 + 5.32284033947694e-6*x_12 + 3.56295059632612e-5*x_15 + 6.78880438649811e-6*x_17 + 1.21159555690427e-5*x_18 + 6.12483880189953e-5*x_19 + 0.00258321970979275*x_2 + 2.80830008936991e-5*x_20 + 1.89144913252999e-5*x_21 + 8.82346648866673e-7*x_22 - 7.61092880345602e-6*x_23 + 3.60123466247914e-5*x_24 + 1.96642535950911e-6*x_25 + 1.25416001980312e-5*x_26 - 1.75005930534876e-6*x_27 + 1.35872632847211e-5*x_28 + 9.58478012955301e-6*x_29 + 1.30634841994568e-5*x_30 + 0.00364084769565958*x_31 + 0.00337099581622224*x_32 + 0.0101886350107473*x_33 - 0.0085609245936651*x_34 + 0.00429973815748824*x_35 - 0.0133134530984749*x_36 + 0.00310854968690125*x_37 + 0.00687993643837147*x_38 - 0.0148338893855691*x_39 + 0.00972601870079891*x_40 + 0.00367446593169831*x_41 - 0.00730961880533794*x_42 + 0.00302105243759147*x_43 - 0.00889573977696262*x_44 + 0.00906837216538801*x_45 - 0.013450960405629*x_46 + 0.00431250257387744*x_47 + 0.00687010335824537*x_48 - 0.0104912506879389*x_49 - 0.00586392382907502*x_50 + 0.00401675170286239*x_51 + 0.00762060736395556*x_52 + 0.00332368852940747*x_53 + 0.00120208808734061*x_54 - 0.00135379922416165*x_55 + 0.0117541251333596*x_56 - 0.00693182592465262*x_57 + 0.0132403653634415*x_58 - 0.00236962786782503*x_59 - 0.0138493362500186*x_60 + 0.000782751275118907*x_61 + 0.0017174245619372*x_62 + 0.000359559309271309*x_63 - 0.000371524551549192*x_64 - 0.00370537432657622*x_65 - 0.0007146665386598*x_67 + 0.00229495067120893*x_68 + 0.00472454460437828*x_69 - 0.00602685504171718*x_70 + 0.00373368874403829*x_71 + 0.00080228086152425*x_72 - 0.000652061166083302*x_73 + 0.00221750099454541*x_74 - 0.0020016910204694*x_75 - 0.00305345121601725*x_76 + 0.00205561785125869*x_77 + 0.000220706102057465*x_78 - 0.000678537817120247*x_79 + 0.00626149853334555*x_80 - 0.00468222360647715*x_81 - 0.00452916518938082*x_82 - 0.00419367519616127*x_83 + 0.00486778798093817*x_84 + 0.00096672659607607*x_85 - 0.00271037237161739*x_86 - 0.00149926348271735*x_87 - 0.000982399139992977*x_88 + 0.000108047570325941*x_89 + 4.34898376010947e-5*x_9 + 0.00137532094643516*x_90 - 0.00843355198821066*x_91 + 0.00180273705047507*x_92 + 0.003689350689768*x_93 + 0.00308933033116229*x_94 - 0.000248811026486096*x_95 + 0.00146603284016504*x_96 - 0.0015425655417919*x_97 - 0.00490242712557238*x_98 + 3.112878220169e-5*std::pow(-5.74399995803833*x_102 - 9.33600044250488, 2) - 0.000150247028529766*std::pow(-3.9255998134613*x_106 - 6.27424001693726, 2) - 4.29575705189017e-5*std::pow(-5.06224012374878*x_110 - 6.06215953826904, 2) - 3.43617563479488e-6*std::pow(-9.66063976287842*x_112 - 2.00952005386353, 2) - 3.0386457665643e-5*std::pow(-4.91359996795654*x_120 - 9.95232009887695, 2) - 1.04672705855746e-5*std::pow(-9.87936019897461*x_61 - 6.42767953872681, 2) + 2.35489595997956e-5*std::pow(-9.72855949401855*x_66 - 3.0403196811676, 2) - 4.56744104087749e-5*std::pow(-9.40464019775391*x_67 - 5.20007991790771, 2) - 1.97484570624605e-5*std::pow(-9.34815979003906*x_68 - 7.77871990203857, 2) + 1.73585422528941e-5*std::pow(9.97795963287354*x_69 + 6.79199981689453, 2) + 1.79135140233859e-5*std::pow(-7.12376022338867*x_75 - 8.96928024291992, 2) + 3.98697288217166e-5*std::pow(-8.10671997070313*x_76 - 6.87735986709595, 2) - 3.60524745083832e-5*std::pow(-4.9159197807312*x_84 - 9.26272010803223, 2) - 8.13267657022434e-5*std::pow(-8.6048002243042*x_86 - 5.2065601348877, 2) + 2.51633309914189e-5*std::pow(-9.30655956268311*x_87 - 4.45368003845215, 2) + 4.98045417989755e-6*std::pow(-9.61999988555908*x_89 - 9.98340034484863, 2) + 2.80444478817465e-5*std::pow(-7.25176000595093*x_91 - 4.82791996002197, 2) - 9.96464207618544e-6*std::pow(-9.5272798538208*x_93 - 3.83999991416931, 2) - 0.000875221099704504*std::pow(-0.397761521867779*x_1 + 0.318175306575619*x_100 + 0.131245593731268*x_104 - 0.0590574513483093*x_108 - 0.0364078239925368*x_111 + 0.151042292673296*x_113 + 0.169047755860556*x_114 - 0.202378973596484*x_115 - 0.0213279808502825*x_116 + 0.0189092268817423*x_120 + 0.000848261563658714*x_17 - 9.46736560335837e-5*x_18 - 0.000369708014121033*x_19 + 0.168298128479167*x_2 - 0.00162924318587205*x_20 - 0.00105281231221353*x_21 - 0.0304040644432405*x_32 - 0.144026334497345*x_33 - 0.42703751363446*x_34 + 0.616340843037823*x_35 + 0.122695205291422*x_36 - 0.535176249930123*x_37 - 0.373642065135565*x_38 - 0.351553276687649*x_39 + 0.708243966468961*x_40 + 0.601072976531518*x_41 - 0.095980014756067*x_42 + 0.463099641083246*x_43 + 0.0723856474121782*x_44 - 0.256826566244179*x_45 + 0.599362963388795*x_46 - 0.469706898160143*x_47 + 0.469485955163375*x_48 - 0.398106766916659*x_49 + 0.0949530024851198*x_50 - 0.400988524996222*x_51 - 0.346991403365254*x_52 - 0.0278154960146535*x_53 - 0.421203946292412*x_54 - 0.365555323288901*x_55 + 0.158137060264417*x_56 + 0.292319758011957*x_57 - 0.460530350486022*x_58 + 0.230578496177245*x_59 + 0.297479964562316*x_60 + 0.00513488669595386*x_62 - 0.0294735034591004*x_63 + 0.122471004038211*x_65 - 0.146725401212453*x_67 + 0.11930132967234*x_69 + 0.152652409355063*x_70 + 0.163458873511122*x_72 - 0.245448596323768*x_73 + 0.00534067956395268*x_74 + 0.108995322812589*x_75 - 0.0170083607843075*x_76 - 0.120031206871192*x_77 + 0.0152859126587801*x_80 + 0.0427502324095582*x_85 + 0.263733228964475*x_87 - 0.00906929766552683*x_88 - 0.198812769624009*x_93 + 0.124102887059524*x_94 + 0.169564526548949*x_96 - 0.136463556093001*x_99 + 0.000631760478801702*std::pow(2.20000004768372 - 9.95748043060303*x_86, 2) + 0.0869278996927889*std::pow(8.37551975250244 - 0.210639804601669*x_31, 2) + 0.012239276785202*std::pow(-2.63048005104065*x_102 - 7.50127983093262, 2) + 0.00135824493181746*std::pow(-9.03791999816895*x_107 - 8.22247982025146, 2) - 0.0021251294172504*std::pow(-8.81511974334717*x_61 - 9.24431991577148, 2) + 0.00213303440962331*std::pow(-8.96744060516357*x_78 - 5.9543194770813, 2) + 0.0017127534820911*std::pow(-9.76488018035889*x_81 - 6.16847991943359, 2) - 0.00239109685163652*std::pow(-8.79600048065186*x_82 - 6.76008033752441, 2) - 0.00174669683716844*std::pow(-8.73871994018555*x_84 - 6.90944004058838, 2) - 0.000600466241407527*std::pow(-9.98104000091553*x_89 - 6.3045597076416, 2) + 0.00117310096816492*std::pow(9.99804019927979*x_90 + 6.80000019073486, 2) + 0.00186363110926213*std::pow(-9.12360000610352*x_92 - 4.86263990402222, 2) + 0.0892227011039718*std::exp(0.383999645709991*x_10) + 0.0555354691043671*std::exp(0.390159606933594*x_11) - 0.408333929240714*std::exp(0.438959568738937*x_112) - 1.72923283472292*std::exp(0.17751981317997*x_118) - 0.156547224535257*std::exp(0.559599876403809*x_12) - 0.188837158419104*std::exp(0.756479620933533*x_13) + 0.101185776444257*std::exp(1.05224001407623*x_14) - 0.0495098129038844*std::exp(1.22631978988647*x_15) - 0.0870820322313519*std::exp(1.24463975429535*x_16) - 0.158176314631786*std::exp(0.317999690771103*x_22) - 0.354380443620624*std::exp(0.509839773178101*x_23) - 0.394467719191315*std::exp(0.603119909763336*x_24) - 0.333409126756236*std::exp(0.649999976158142*x_25) + 0.356060582082319*std::exp(0.779999673366547*x_26) - 0.253918492076194*std::exp(0.663999974727631*x_27) + 1.24013037715778*std::exp(0.900000095367432*x_28) + 1.30434883812913*std::exp(1.0239999294281*x_29) + 0.244437834939146*std::exp(0.253599762916565*x_3) + 1.50486800493872*std::exp(1.0*x_30) - 0.284948657374132*std::exp(0.291999727487564*x_4) + 0.329669632851793*std::exp(0.391519606113434*x_5) + 0.567694694642942*std::exp(0.33903968334198*x_6) + 0.100518830591087*std::exp(1.52415978908539*x_64) + 0.21069037274864*std::exp(0.965040028095245*x_68) + 0.0154168605146172*std::exp(0.319119691848755*x_7) - 0.43533191430178*std::exp(0.763999700546265*x_71) - 0.357607777162519*std::exp(0.5971999168396*x_79) + 0.448890674662686*std::exp(0.302559703588486*x_8) - 0.040806431156517*std::exp(2.54519987106323*x_83) - 0.33720345765634*std::exp(0.324639678001404*x_9) - 0.723701321329049*std::exp(0.367199659347534*x_97) - 0.544201570069504*std::sin(0.997919976711273*x_101 + 8.19495964050293) + 0.356632580013724*std::sin(1.221599817276*x_103 + 1.38991963863373) + 0.73011871339412*std::sin(0.743679583072662*x_105 - 4.37695980072021) + 0.475393136403795*std::sin(0.938000082969666*x_106 - 1.35967969894409) - 0.688369541340023*std::sin(0.799759685993195*x_109 - 4.20560026168823) - 0.570124417259422*std::sin(0.914640069007874*x_110 - 1.37599968910217) + 0.100219601731069*std::sin(1.37159967422485*x_117 - 4.98199987411499) + 0.300005085229742*std::sin(1.09279990196228*x_119 + 1.55415987968445) + 0.017298534319595*std::sin(5.21920013427734*x_66 - 9.41256046295166) + 0.0530793717156577*std::sin(3.36391997337341*x_91 - 8.0447998046875) - 0.361150044994815*std::sin(0.978640019893646*x_95 + 8.21375942230225) + 0.55089064158193*std::sin(1.16767990589142*x_98 - 7.76968002319336) - 9.18000869390079, 2) + 0.00795138405929457*std::exp(0.376559644937515*x_10) + 0.00182626096377887*std::exp(0.377839624881744*x_10) + 0.00397179226694524*std::exp(0.383119642734528*x_10) + 0.0123600250999662*std::exp(0.440959572792053*x_100) - 0.0102794968061032*std::exp(0.226719796657562*x_102) + 0.00656096126497763*std::exp(0.325359672307968*x_103) - 0.00317645165541377*std::exp(0.290799736976624*x_104) - 0.00465107027613492*std::exp(0.306799709796906*x_109) - 0.00346219402753046*std::exp(0.386399626731873*x_11) - 0.00292417255928145*std::exp(0.389359623193741*x_11) - 0.00847126036758731*std::exp(0.390479624271393*x_11) - 0.00861126347791325*std::exp(0.204399809241295*x_110) + 0.00340072052813591*std::exp(0.597919881343842*x_113) + 0.0029810436094486*std::exp(0.310719698667526*x_115) - 0.0081304383037543*std::exp(0.284239739179611*x_116) - 0.0195915943121427*std::exp(0.193679809570313*x_117) + 0.00766054529924132*std::exp(0.555519819259644*x_12) + 0.00147197742745216*std::exp(0.563039839267731*x_12) + 0.00166588626896829*std::exp(0.735919654369354*x_13) - 0.00171028162061968*std::exp(0.749999642372131*x_13) + 0.00110498060087531*std::exp(0.753279685974121*x_13) + 0.00157612207798082*std::exp(1.00799989700317*x_14) - 0.000308019237622137*std::exp(1.05879998207092*x_14) - 0.000476642358269499*std::exp(1.06831991672516*x_14) + 9.17264713284854e-5*std::exp(1.01175999641418*x_15) - 0.000980963155723647*std::exp(1.23447978496552*x_15) + 0.00153765826742729*std::exp(1.20743978023529*x_16) - 0.000388702452879568*std::exp(1.22799980640411*x_16) - 0.000222271100420073*std::exp(1.3155996799469*x_16) - 0.00201601638561378*std::exp(0.294799715280533*x_22) + 0.00128316596522851*std::exp(0.302559703588486*x_22) + 0.00137813522987376*std::exp(0.454799562692642*x_23) + 0.00255237863980228*std::exp(0.549359798431396*x_24) + 0.00187352162160653*std::exp(0.551279842853546*x_25) + 0.00222224325401218*std::exp(0.568719863891602*x_26) - 0.00349182239230118*std::exp(0.25279974937439*x_3) - 0.00100247227533083*std::exp(0.254239767789841*x_3) - 0.00500797573423778*std::exp(0.256639748811722*x_3) - 0.00282135920635911*std::exp(0.290719717741013*x_4) + 0.00417908491571258*std::exp(0.291599720716476*x_4) - 0.00524159702557713*std::exp(0.296639710664749*x_4) + 0.000186269071021633*std::exp(0.375039637088776*x_5) + 0.00427150063092115*std::exp(0.39199960231781*x_5) + 0.00100031429292452*std::exp(0.395119607448578*x_5) - 0.00190359784244363*std::exp(0.326959699392319*x_6) - 0.000703086013373308*std::exp(0.332639664411545*x_6) + 0.00170333384827288*std::exp(0.336479663848877*x_6) + 0.0110586954830934*std::exp(0.531519830226898*x_62) + 0.00100497232059511*std::exp(1.60343992710114*x_65) - 0.00217196518143789*std::exp(0.318159699440002*x_7) - 0.00275333848366372*std::exp(0.322799682617188*x_7) + 0.00180515160613877*std::exp(0.329039663076401*x_7) - 0.00051118163951386*std::exp(1.67871999740601*x_72) + 0.00161521767828242*std::exp(0.906000137329102*x_74) + 0.000831229688141307*std::exp(1.59167993068695*x_75) + 0.000689513492258995*std::exp(1.82439970970154*x_77) - 0.00241193934490142*std::exp(1.75759971141815*x_78) - 0.00653158492278539*std::exp(0.718479633331299*x_79) + 0.00184585689659464*std::exp(0.960240066051483*x_79) + 0.000855009875804582*std::exp(0.296319723129272*x_8) - 0.00561461919127466*std::exp(0.301119714975357*x_8) - 0.00579168278547182*std::exp(0.303359717130661*x_8) + 0.00225568675768157*std::exp(1.0*x_80) + 0.00118103839123926*std::exp(1.51543974876404*x_81) + 0.00138993651227042*std::exp(1.54271984100342*x_82) - 0.00125481932947334*std::exp(0.453119575977325*x_84) - 0.000184465577073495*std::exp(2.19304013252258*x_86) - 0.00244117666417018*std::exp(0.91376006603241*x_88) + 9.02330004948119e-5*std::exp(3.14815998077393*x_89) + 0.00281244631764822*std::exp(0.321679681539536*x_9) + 0.00425248949969554*std::exp(0.326159685850143*x_9) - 0.00588069530483333*std::exp(0.413439601659775*x_94) + 0.0306211831058568*std::exp(0.286399722099304*x_98) + 0.00175936312777835*std::exp(0.486799538135529*x_99) + 9.06019844672974*std::exp(-0.127887469188604*x_1 + 0.0194304502732006*x_101 + 0.079971949005179*x_104 + 0.075229475245031*x_105 + 0.03542457406009*x_106 - 0.0448477984169221*x_107 - 0.0470026840312123*x_111 + 0.0545429670670952*x_112 + 0.0257006376899113*x_114 - 0.0633609437646952*x_117 + 0.000109993155920827*x_17 + 1.20593611098386e-5*x_18 - 6.46787569455636e-5*x_19 + 0.0055523480845817*x_2 - 0.000477414095314695*x_20 - 0.000226509167728054*x_21 + 8.57385839439593e-5*x_22 + 7.81607193829738e-5*x_23 - 0.000128499725332588*x_24 + 0.000121837607293356*x_26 - 1.09256680598098e-5*x_28 - 3.54727338974815e-5*x_29 + 2.06006867356153e-5*x_30 - 0.0370440292428042*x_33 - 0.0707817849960063*x_34 - 0.0781778440132068*x_35 + 0.0135241896200489*x_36 - 0.11674550299736*x_37 - 0.0742852725898602*x_38 + 0.139829516355378*x_39 + 0.0221317473063373*x_40 - 0.0310001160018705*x_41 + 0.0925691350215944*x_42 - 0.0266053995448202*x_43 - 0.00197073526083643*x_44 + 0.00440341636432532*x_45 - 0.107031085313292*x_46 + 0.0275835956298895*x_47 - 0.105853609850924*x_48 - 0.125566211147373*x_49 + 0.0336758971894291*x_50 + 0.00783153998731606*x_51 + 0.0251693652628694*x_52 + 0.118568235872584*x_53 + 0.125422349762153*x_54 + 0.135777287185441*x_55 + 0.0827607453980449*x_56 - 0.0305640618796833*x_57 + 0.0855876983570686*x_58 - 0.0273175414851242*x_59 - 0.0614829204491248*x_60 + 0.0261640914358247*x_62 - 0.00509956056329953*x_63 + 0.0786042233724404*x_64 - 0.0288948169884674*x_68 - 0.0770223940252566*x_69 - 0.0209146341618218*x_70 + 0.0616027182762203*x_71 - 0.0488614752026216*x_72 + 0.0199140354543697*x_75 - 0.0283327637704743*x_76 + 0.0334902652507203*x_78 + 0.00863384908511041*x_79 + 0.0529021832541946*x_81 + 0.0549424457626628*x_82 + 0.0187053447975773*x_83 + 0.0660116349207531*x_84 + 0.015749221802925*x_86 + 0.00824915606596616*x_87 - 0.0252426271217684*x_88 - 0.0724319444467656*x_89 - 0.00317773375014441*x_90 - 0.0442929225886808*x_92 - 0.0391793366018421*x_93 - 0.0860976127442703*x_96 - 0.0909869824189765*x_97 + 0.123462163740436*x_98 + 0.0301447629280812*x_99 - 0.0355967980416252*std::pow(8.27943992614746 - 0.201439797878265*x_31, 2) + 0.000140131007266698*std::pow(-9.83440017700195*x_108 - 4.4474401473999, 2) + 0.000130898838057241*std::pow(-9.9629602432251*x_109 - 3.39999985694885, 2) + 0.00010702030705346*std::pow(-9.99868011474609*x_116 - 3.37999987602234, 2) + 0.00414090176987725*std::pow(-2.03575992584229*x_119 - 5.2993597984314, 2) - 0.00046775842829553*std::pow(-5.40767955780029*x_120 - 9.19095993041992, 2) - 0.000489433570390628*std::pow(-8.49944019317627*x_65 - 8.27271938323975, 2) - 0.000402107502556828*std::pow(-9.9993200302124*x_73 - 6.0, 2) + 0.000377081800215926*std::pow(-8.14783954620361*x_74 - 9.39192008972168, 2) - 0.00033575299740329*std::pow(-9.59967994689941*x_77 - 1.02799999713898, 2) + 0.00053812071383965*std::pow(-8.69464015960693*x_80 - 7.84104013442993, 2) + 0.000151770951166228*std::pow(-9.93639945983887*x_91 - 4.7960000038147, 2) - 0.0879759168064489*std::exp(0.37863963842392*x_10) + 0.00992459101211604*std::exp(0.398079603910446*x_11) - 0.0398132705308538*std::exp(0.554959833621979*x_12) - 0.0220978405647889*std::exp(0.746319591999054*x_13) + 0.0206218518595329*std::exp(1.0595999956131*x_14) + 0.0119070967236345*std::exp(1.26079976558685*x_15) - 0.00487468339677071*std::exp(1.17711985111237*x_16) - 0.129163343387638*std::exp(0.59999942779541*x_25) - 0.136827251345561*std::exp(0.625759959220886*x_27) - 0.0384177830023977*std::exp(0.254479765892029*x_3) - 0.0183472658115563*std::exp(0.292959719896317*x_4) - 0.0252878688656115*std::exp(0.39087963104248*x_5) - 0.100822767030642*std::exp(0.33751967549324*x_6) + 0.0141509054653164*std::exp(2.69063973426819*x_61) + 0.0326876738489284*std::exp(1.45271956920624*x_67) + 0.0120695380583574*std::exp(0.334319651126862*x_7) - 0.0957953637539602*std::exp(0.300399720668793*x_8) - 0.0103545043756962*std::exp(2.24656009674072*x_85) - 0.0276595497775251*std::exp(0.318799704313278*x_9) + 0.214721092786898*std::exp(0.273759722709656*x_94) - 0.513910874790504*std::exp(0.158639833331108*x_95) - 0.110389005109139*std::sin(1.18831980228424*x_100 + 4.79408025741577) - 0.216949097421519*std::sin(0.630799949169159*x_102 + 8.37952041625977) - 0.188626796391652*std::sin(0.748079597949982*x_103 - 1.14335989952087) - 0.111845111001879*std::sin(1.08351993560791*x_110 - 4.62207984924316) - 0.143222444940484*std::sin(0.946880042552948*x_113 - 1.34919965267181) + 0.0229385635667627*std::sin(1.5771199464798*x_115 - 5.18495988845825) - 0.0521718473763455*std::sin(1.20855975151062*x_118 + 4.79016017913818) + 0.0168369585310115*std::sin(2.92903971672058*x_66 + 2.37191987037659) - 1.75212426348213*std::exp(-0.0245599746704102*x_32)) - 3.93036710137274e-5*std::sin(8.43152046203613*x_100 + 6.17775964736938) - 0.00610995857112832*std::sin(1.14503979682922*x_101 - 7.75903987884521) - 0.00302766246235789*std::sin(1.13871991634369*x_103 - 4.73816013336182) - 0.00882781034556614*std::sin(1.16319978237152*x_105 + 7.80984020233154) - 0.00547965343292118*std::sin(0.879599809646606*x_107 + 8.1738395690918) - 0.000529149956937694*std::sin(2.24272012710571*x_107 + 0.576879858970642) - 0.012137294035454*std::sin(1.21303987503052*x_108 + 4.7760796546936) + 0.00847355688373347*std::sin(1.15967988967896*x_110 + 1.62808001041412) - 0.0154350705591182*std::sin(0.790319681167603*x_111 + 8.21183967590332) - 0.0111326113795118*std::sin(0.879999816417694*x_114 - 7.63015985488892) + 0.0151320380808795*std::sin(0.722879588603973*x_115 - 4.3699197769165) - 0.00399484776504534*std::sin(0.942240059375763*x_115 - 7.77415990829468) + 0.00553683694439825*std::sin(0.655439972877502*x_117 - 7.4203200340271) + 0.00242405277406709*std::sin(0.86495977640152*x_118 - 1.23255980014801) - 0.00348282538993612*std::sin(1.02023994922638*x_118 - 1.39911961555481) - 0.00804631998983418*std::sin(0.705280065536499*x_119 - 1.23703980445862) + 0.00979255859461443*std::sin(1.02160000801086*x_120 + 8.18144035339355) + 0.000815709556381055*std::sin(1.39743959903717*x_120 + 7.59143972396851) - 0.000217608287176169*std::sin(3.70088005065918*x_66 - 5.78968000411987) + 0.000852555496330858*std::sin(4.38775968551636*x_66 - 0.206719815731049) - 0.000881120484456351*std::sin(2.39439988136292*x_71 + 2.39183974266052) - 0.00620783884707877*std::sin(1.18479979038239*x_92 - 1.17983984947205) - 0.00603608941005705*std::sin(1.35383975505829*x_94 - 1.54991984367371) - 0.00408709247890668*std::sin(1.02312004566193*x_95 - 1.41087961196899) + 0.00283724463615205*std::sin(1.47087955474854*x_95 + 4.54888010025024) + 0.00450620096384631*std::sin(1.2203197479248*x_96 - 7.82216024398804) + 0.00765044313940896*std::sin(0.741679608821869*x_97 - 1.1515998840332) - 0.00222516168770214*std::sin(0.921440064907074*x_97 - 4.54048013687134) - 0.00317665376207924*std::sin(0.982560038566589*x_99 - 1.37295973300934) - 0.0131059855954674*std::sin(0.986720025539398*x_99 - 1.37095963954926) - 0.00264603509076572 + 0.000189332993263549*std::exp(-2.33999991416931*x_67) - 0.0675996634154442*std::exp(-0.012639987282455*x_52) - 0.031316485310378*std::exp(-0.015439985319972*x_49));
}

inline float score_3(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.0154637037677089*x_1 + 0.00788396297147163*x_101 + 0.0146595291290398*x_102 - 0.00108415147661991*x_103 + 0.01942926787963*x_104 - 0.0149259543593233*x_105 + 0.00450505012723023*x_106 - 4.24828476793366e-6*x_107 + 0.00539639293948319*x_108 + 2.04089571192901e-5*x_109 + 0.000797687421984857*x_111 - 0.000874470901286641*x_112 - 0.00484974331175201*x_113 - 0.00790232291271136*x_114 + 0.000113134413007354*x_116 + 0.00047216046477901*x_117 + 0.000804599946143988*x_118 - 0.00534175338037911*x_119 - 3.52756647245515e-5*x_12 + 5.95005222905639e-6*x_15 - 3.08849823405508e-5*x_17 - 2.5555206137384e-6*x_18 - 6.61300729233646e-6*x_19 + 0.0038670949762102*x_2 + 2.98964532168906e-5*x_20 + 3.20961666200205e-5*x_21 + 1.47350026416393e-7*x_22 + 1.73317313961337e-7*x_23 + 6.18042102437889e-6*x_24 - 2.14223314938709e-7*x_25 + 2.55252025686214e-6*x_26 + 2.6190342696924e-6*x_27 - 8.91899106302198e-6*x_28 - 9.8533522717536e-6*x_29 + 8.41075342229677e-7*x_30 - 0.00272170253174206*x_31 + 0.0070937121979153*x_32 + 0.0157654623533838*x_33 + 0.00190946981369679*x_34 - 0.0213199143586056*x_35 - 0.00330783541214588*x_36 + 0.00108855135520039*x_37 - 0.016377220905381*x_38 + 0.0216747946013203*x_39 + 0.0243225542200237*x_40 - 0.0132678463536509*x_41 + 0.0182450563021132*x_42 - 0.010664180330729*x_43 - 0.023890180053121*x_44 - 0.0114406415777713*x_45 + 0.014713878450304*x_46 - 0.0166338563995476*x_47 + 0.00557753417033745*x_48 - 0.00209327746127933*x_49 + 0.0280352328428031*x_50 + 0.0127887618883938*x_51 + 0.000951474035524274*x_52 - 0.0203695085535837*x_53 + 0.0143760566882241*x_54 + 0.0229441126479677*x_55 - 0.0146850279889006*x_56 + 0.0183686253978723*x_57 - 0.000858000584425413*x_58 + 0.007958465976864*x_59 + 0.0157478346856996*x_60 + 0.000125731036499558*x_61 - 0.0121409537157583*x_62 + 0.00825153643277051*x_63 - 0.0105973580185481*x_64 + 0.00835097034941043*x_65 + 0.0047362565096394*x_67 + 0.00898883275901179*x_68 - 0.00438556563844412*x_69 + 0.00233064949263048*x_70 + 0.000299441594608763*x_71 + 0.00050587801757991*x_72 + 0.0034076688255769*x_73 + 0.000157582090032159*x_74 - 0.000334278171875497*x_75 - 0.00346642089831433*x_76 + 0.000856712370986646*x_77 - 0.0107037819731761*x_78 + 0.00449682331482725*x_79 - 0.00351177692214702*x_80 + 0.011053240173568*x_81 - 0.0122088990228708*x_82 + 0.0107732050749187*x_83 + 0.000812910309686033*x_84 + 0.00471333861773948*x_85 - 0.00826347068368775*x_87 + 0.0105319505840138*x_88 + 1.80437159955261e-5*x_89 + 7.26271100773939e-6*x_9 - 0.00073664459339688*x_90 + 0.00141390197108426*x_91 - 0.000837343192571085*x_92 + 0.000770341531570473*x_93 - 0.0204736896159049*x_94 + 0.00933300401427547*x_96 - 0.000257605186832188*x_97 + 0.0105037660096818*x_98 + 5.19844086858686e-6*std::pow(-5.74399995803833*x_102 - 9.33600044250488, 2) - 2.50909363698291e-5*std::pow(-3.9255998134613*x_106 - 6.27424001693726, 2) + 2.27723117540678e-5*std::pow(-9.66063976287842*x_112 - 2.00952005386353, 2) + 6.93689654787154e-5*std::pow(-9.87936019897461*x_61 - 6.42767953872681, 2) - 7.62753005174401e-6*std::pow(-9.40464019775391*x_67 - 5.20007991790771, 2) + 6.65816048900991e-6*std::pow(-8.10671997070313*x_76 - 6.87735986709595, 2) - 1.35813980706761e-5*std::pow(-8.6048002243042*x_86 - 5.2065601348877, 2) - 3.3006594340818e-5*std::pow(-9.61999988555908*x_89 - 9.98340034484863, 2) + 6.60379328631561e-5*std::pow(-9.5272798538208*x_93 - 3.83999991416931, 2) - 0.00190938741434366*std::pow(0.371002018714669*x_1 - 0.0563678077424554*x_101 - 0.231998918343689*x_104 - 0.218240984514211*x_105 - 0.102766819703175*x_106 + 0.130103628237795*x_107 + 0.136354959334369*x_111 - 0.158229348168094*x_112 - 0.0745576445112815*x_114 + 0.1838103310161*x_117 - 0.000319090550077604*x_17 - 3.49842509555108e-5*x_18 + 0.000187633311903069*x_19 - 0.0161073822248247*x_2 + 0.00138498004728967*x_20 + 0.000657103929084367*x_21 - 0.000248727947521074*x_22 - 0.000226744534544734*x_23 + 0.000372778176041338*x_24 - 0.000353451347094357*x_26 + 3.16954032456294e-5*x_28 + 0.000102906531568666*x_29 - 5.97626680261401e-5*x_30 + 0.107464865147478*x_33 + 0.205338218735242*x_34 + 0.226794213160055*x_35 - 0.0392337238538865*x_36 + 0.338679133793817*x_37 + 0.215501849137096*x_38 - 0.405645941489661*x_39 - 0.0642042803757802*x_40 + 0.0899314505952216*x_41 - 0.26854340133226*x_42 + 0.0771823619817022*x_43 + 0.00571711024357067*x_44 - 0.012774327076538*x_45 + 0.310497572345357*x_46 - 0.0800201124240408*x_47 + 0.30708171169617*x_48 + 0.364268040595326*x_49 - 0.0976939016666315*x_50 - 0.0227193263215957*x_51 - 0.0730164212454642*x_52 - 0.343966888572109*x_53 - 0.363850698187422*x_54 - 0.393890409756335*x_55 - 0.240089226941567*x_56 + 0.0886664559821708*x_57 - 0.248290227878277*x_58 + 0.0792482883710541*x_59 + 0.178362178466906*x_60 - 0.0759021255335868*x_62 + 0.0147938439594239*x_63 - 0.228031141250177*x_64 + 0.0838239704102893*x_68 + 0.223442248493203*x_69 + 0.0606734306648247*x_70 - 0.17870971240414*x_71 + 0.141747319362582*x_72 - 0.0577706901325168*x_75 + 0.0821934519566555*x_76 - 0.0971553827293514*x_78 - 0.025046827966623*x_79 - 0.153469428289136*x_81 - 0.159388237333932*x_82 - 0.054264274089439*x_83 - 0.1914999958138*x_84 - 0.0456885504040525*x_86 - 0.0239308321024975*x_87 + 0.0732289541677182*x_88 + 0.210125337374128*x_89 + 0.00921861730254936*x_90 + 0.128493931418243*x_92 + 0.113659399653521*x_93 + 0.249769491391925*x_96 + 0.263953570810082*x_97 - 0.358164191325357*x_98 - 0.0874500681806425*x_99 + 0.103266442107357*std::pow(8.27943992614746 - 0.201439797878265*x_31, 2) - 0.00040652056773282*std::pow(-9.83440017700195*x_108 - 4.4474401473999, 2) - 0.000379738010883778*std::pow(-9.9629602432251*x_109 - 3.39999985694885, 2) - 0.000310466304573924*std::pow(-9.99868011474609*x_116 - 3.37999987602234, 2) - 0.0120127712720466*std::pow(-2.03575992584229*x_119 - 5.2993597984314, 2) + 0.00135696892173628*std::pow(-5.40767955780029*x_120 - 9.19095993041992, 2) + 0.00141984858871405*std::pow(-8.49944019317627*x_65 - 8.27271938323975, 2) + 0.00116651534458695*std::pow(-9.9993200302124*x_73 - 6.0, 2) - 0.00109391569000676*std::pow(-8.14783954620361*x_74 - 9.39192008972168, 2) + 0.000974020680966151*std::pow(-9.59967994689941*x_77 - 1.02799999713898, 2) - 0.00156109017101794*std::pow(-8.69464015960693*x_80 - 7.84104013442993, 2) - 0.000440288087817861*std::pow(-9.93639945983887*x_91 - 4.7960000038147, 2) + 0.255218458388062*std::exp(0.37863963842392*x_10) - 0.0287912750465205*std::exp(0.398079603910446*x_11) + 0.115498444314326*std::exp(0.554959833621979*x_12) + 0.0641059167937788*std::exp(0.746319591999054*x_13) - 0.0598240681285085*std::exp(1.0595999956131*x_14) - 0.0345425314108325*std::exp(1.26079976558685*x_15) + 0.0141414744718239*std::exp(1.17711985111237*x_16) + 0.374703334461011*std::exp(0.59999942779541*x_25) + 0.396936359648488*std::exp(0.625759959220886*x_27) + 0.111450129859179*std::exp(0.254479765892029*x_3) + 0.0532254856333382*std::exp(0.292959719896317*x_4) + 0.0733602006330869*std::exp(0.39087963104248*x_5) + 0.292487218162108*std::exp(0.33751967549324*x_6) - 0.0410518288271879*std::exp(2.69063973426819*x_61) - 0.0948270621193886*std::exp(1.45271956920624*x_67) - 0.0350137743206128*std::exp(0.334319651126862*x_7) + 0.277902702756685*std::exp(0.300399720668793*x_8) + 0.0300384552962556*std::exp(2.24656009674072*x_85) + 0.0802404556858266*std::exp(0.318799704313278*x_9) - 0.622906680302478*std::exp(0.273759722709656*x_94) + 1.49085733884934*std::exp(0.158639833331108*x_95) + 0.320238910029538*std::sin(1.18831980228424*x_100 + 4.79408025741577) + 0.629370129946096*std::sin(0.630799949169159*x_102 + 8.37952041625977) + 0.547207030438443*std::sin(0.748079597949982*x_103 - 1.14335989952087) + 0.324463078582532*std::sin(1.08351993560791*x_110 - 4.62207984924316) + 0.415488839800304*std::sin(0.946880042552948*x_113 - 1.34919965267181) - 0.0665448573161855*std::sin(1.5771199464798*x_115 - 5.18495988845825) + 0.151350721220016*std::sin(1.20855975151062*x_118 + 4.79016017913818) - 0.0488440786548701*std::sin(2.92903971672058*x_66 + 2.37191987037659) - 17.4085134889174 + 5.08291893580412*std::exp(-0.0245599746704102*x_32), 2) + 0.00132786434072011*std::exp(0.376559644937515*x_10) - 0.0121030437415168*std::exp(0.377839624881744*x_10) + 0.0020640980813228*std::exp(0.440959572792053*x_100) + 0.0308236928420411*std::exp(0.306799709796906*x_109) + 0.0193791517722064*std::exp(0.389359623193741*x_11) - 0.00141468258597393*std::exp(0.390479624271393*x_11) + 0.057068787325583*std::exp(0.204399809241295*x_110) + 0.00056791314422651*std::exp(0.597919881343842*x_113) + 0.0538822503353674*std::exp(0.284239739179611*x_116) + 0.00127929488218383*std::exp(0.555519819259644*x_12) + 0.000278199487757419*std::exp(0.735919654369354*x_13) - 0.00732295592533992*std::exp(0.753279685974121*x_13) + 0.000263209057488048*std::exp(1.00799989700317*x_14) + 0.00315881652491697*std::exp(1.06831991672516*x_14) - 0.00060789203556457*std::exp(1.01175999641418*x_15) + 0.000256785682379844*std::exp(1.20743978023529*x_16) + 0.00147304076701765*std::exp(1.3155996799469*x_16) - 0.00850383056573224*std::exp(0.302559703588486*x_22) - 0.0091332133247673*std::exp(0.454799562692642*x_23) - 0.0169151895239112*std::exp(0.549359798431396*x_24) - 0.0124162507914871*std::exp(0.551279842853546*x_25) - 0.0147273077840681*std::exp(0.568719863891602*x_26) + 0.00664361010755091*std::exp(0.254239767789841*x_3) - 0.000836321368342497*std::exp(0.256639748811722*x_3) + 0.018697784469115*std::exp(0.290719717741013*x_4) - 0.000875335630474621*std::exp(0.296639710664749*x_4) - 0.00123444718962931*std::exp(0.375039637088776*x_5) + 0.000713331581881464*std::exp(0.39199960231781*x_5) - 0.000317896818365592*std::exp(0.326959699392319*x_6) - 0.0112883779924834*std::exp(0.336479663848877*x_6) + 0.00184677878434475*std::exp(0.531519830226898*x_62) + 0.0182469957820435*std::exp(0.322799682617188*x_7) + 0.00030145650486891*std::exp(0.329039663076401*x_7) + 0.00338771614002788*std::exp(1.67871999740601*x_72) - 0.0107044122390224*std::exp(0.906000137329102*x_74) - 0.00550874681896765*std::exp(1.59167993068695*x_75) - 0.00456956159206781*std::exp(1.82439970970154*x_77) - 0.000402788775412084*std::exp(1.75759971141815*x_78) - 0.00109076088422791*std::exp(0.718479633331299*x_79) - 0.00566634349172058*std::exp(0.296319723129272*x_8) - 0.000967198790328943*std::exp(0.303359717130661*x_8) + 0.0083159710104583*std::exp(0.453119575977325*x_84) + 0.00122249502804079*std::exp(2.19304013252258*x_86) - 0.0186387167432694*std::exp(0.321679681539536*x_9) + 0.00511367289187835*std::exp(0.286399722099304*x_98) + 0.00026047430181995*std::sin(8.43152046203613*x_100 + 6.17775964736938) - 0.00102035017418065*std::sin(1.14503979682922*x_101 - 7.75903987884521) + 0.020065002725921*std::sin(1.13871991634369*x_103 - 4.73816013336182) - 0.0014742256790898*std::sin(1.16319978237152*x_105 + 7.80984020233154) + 0.00350679623649566*std::sin(2.24272012710571*x_107 + 0.576879858970642) - 0.00202690246406536*std::sin(1.21303987503052*x_108 + 4.7760796546936) + 0.00141506609931898*std::sin(1.15967988967896*x_110 + 1.62808001041412) - 0.0025776241770128*std::sin(0.790319681167603*x_111 + 8.21183967590332) - 0.00185912258290037*std::sin(0.879999816417694*x_114 - 7.63015985488892) + 0.0025270183932986*std::sin(0.722879588603973*x_115 - 4.3699197769165) + 0.0264747580986454*std::sin(0.942240059375763*x_115 - 7.77415990829468) - 0.0366938685416772*std::sin(0.655439972877502*x_117 - 7.4203200340271) - 0.016064745038175*std::sin(0.86495977640152*x_118 - 1.23255980014801) + 0.00163533659866435*std::sin(1.02160000801086*x_120 + 8.18144035339355) - 0.00540589140164561*std::sin(1.39743959903717*x_120 + 7.59143972396851) + 0.00144213925087687*std::sin(3.70088005065918*x_66 - 5.78968000411987) + 0.000142374966876284*std::sin(4.38775968551636*x_66 - 0.206719815731049) + 0.00583938439052843*std::sin(2.39439988136292*x_71 + 2.39183974266052) - 0.00103669597349373*std::sin(1.18479979038239*x_92 - 1.17983984947205) - 0.00100801418032927*std::sin(1.35383975505829*x_94 - 1.54991984367371) + 0.0270860846444844*std::sin(1.02312004566193*x_95 - 1.41087961196899) + 0.000473813860599755*std::sin(1.47087955474854*x_95 + 4.54888010025024) + 0.0147466489030575*std::sin(0.921440064907074*x_97 - 4.54048013687134) + 0.0210524017085405*std::sin(0.982560038566589*x_99 - 1.37295973300934) - 0.0021886719082409*std::sin(0.986720025539398*x_99 - 1.37095963954926) + 0.391404002904892*std::sin(-0.0424497764411281*x_1 - 0.0273458536015707*x_100 - 0.0455616344956696*x_101 + 0.00129124188051675*x_105 + 0.0303014417623658*x_106 - 0.00490683019455358*x_108 + 0.0190925172262329*x_109 - 0.00861842718513956*x_111 + 0.005865303531861*x_112 - 0.0281829681612463*x_113 + 0.0093061758889548*x_114 - 0.00870522400084862*x_116 - 8.93524989278223e-5*x_17 + 2.35833982460877e-5*x_18 - 8.56091744529502e-5*x_19 + 0.00311969397841638*x_2 - 9.91144196524337e-5*x_20 + 0.000219431324675179*x_21 + 8.14255872798173e-5*x_23 + 9.38297985548111e-6*x_24 - 3.05903972715916e-5*x_25 + 2.5825896178827e-5*x_26 + 3.13860769510641e-5*x_27 + 2.68192509951684e-5*x_28 + 2.30321718686769e-5*x_29 + 1.71564393772577e-5*x_30 + 0.0187450560673373*x_31 + 0.000220108097917695*x_32 - 0.0423031772787462*x_33 + 0.0467343212708552*x_34 - 0.0421234658033867*x_35 + 0.020228034034962*x_36 + 0.0446679857902991*x_37 - 0.0474792593411796*x_38 + 0.0227369625146079*x_39 - 0.0605863708370311*x_40 + 0.0394554580462389*x_41 - 0.0248852708706864*x_42 - 0.0560902269925284*x_43 + 0.0581214664786435*x_44 + 0.0178943892522457*x_45 - 0.0304028939576976*x_46 + 0.0585593501652328*x_47 + 0.0114322588383753*x_48 - 0.019238974482107*x_49 - 0.0215792162229131*x_50 - 0.0359212436301589*x_51 - 0.0181052799725752*x_52 - 0.0258592554997809*x_53 + 0.0193605761640171*x_54 + 0.0477128529263171*x_55 + 0.0353651484738419*x_56 + 0.0556845737553096*x_57 - 0.0480354344455397*x_58 + 0.0134454582801528*x_59 + 0.0277034422244111*x_60 - 0.000281135155266407*x_61 + 0.00107851748641653*x_62 - 0.000175991452072135*x_63 - 0.0157862328557013*x_64 + 0.0139723363152141*x_70 - 0.0182701939374033*x_71 + 0.0209662303621272*x_72 + 0.0210135115920374*x_73 - 0.0119932347398903*x_74 + 0.0336717621657234*x_76 + 0.0289451340958385*x_77 + 0.0131280145264874*x_78 - 0.000510750829891322*x_83 - 0.00604115450575473*x_85 + 0.0255173461714363*x_86 + 0.0197446919968484*x_90 - 0.0157826929083268*x_92 + 0.00869477038384967*x_93 + 0.00234248148357837*x_95 + 0.0312331348928211*x_98 + 0.000404432693121268*std::pow(-5.06224012374878*x_110 - 6.06215953826904, 2) + 0.000286079421151716*std::pow(-4.91359996795654*x_120 - 9.95232009887695, 2) - 0.000221706419522925*std::pow(-9.72855949401855*x_66 - 3.0403196811676, 2) + 0.000185925823511046*std::pow(-9.34815979003906*x_68 - 7.77871990203857, 2) - 0.000163425489551563*std::pow(9.97795963287354*x_69 + 6.79199981689453, 2) - 0.000168650382976285*std::pow(-7.12376022338867*x_75 - 8.96928024291992, 2) + 0.000339423277037877*std::pow(-4.9159197807312*x_84 - 9.26272010803223, 2) - 0.000236905243891377*std::pow(-9.30655956268311*x_87 - 4.45368003845215, 2) - 0.000264030098697578*std::pow(-7.25176000595093*x_91 - 4.82791996002197, 2) - 0.037393237644389*std::exp(0.383119642734528*x_10) + 0.096778391492008*std::exp(0.226719796657562*x_102) - 0.0617694902622968*std::exp(0.325359672307968*x_103) + 0.0299053433900142*std::exp(0.290799736976624*x_104) + 0.0325955224596885*std::exp(0.386399626731873*x_11) - 0.0280656350142231*std::exp(0.310719698667526*x_115) + 0.184449007578602*std::exp(0.193679809570313*x_117) - 0.0138582277351149*std::exp(0.563039839267731*x_12) + 0.0161017905218516*std::exp(0.749999642372131*x_13) + 0.00289990910332947*std::exp(1.05879998207092*x_14) + 0.00923547505433267*std::exp(1.23447978496552*x_15) + 0.00365951747135596*std::exp(1.22799980640411*x_16) + 0.0189801919978605*std::exp(0.294799715280533*x_22) + 0.0328744646627102*std::exp(0.25279974937439*x_3) - 0.0393448360051093*std::exp(0.291599720716476*x_4) - 0.00941766023004378*std::exp(0.395119607448578*x_5) + 0.00661934477321864*std::exp(0.332639664411545*x_6) - 0.00946151416900479*std::exp(1.60343992710114*x_65) + 0.0204484033217857*std::exp(0.318159699440002*x_7) - 0.0173781912428628*std::exp(0.960240066051483*x_79) + 0.0528599623523501*std::exp(0.301119714975357*x_8) - 0.0212366169508057*std::exp(1.0*x_80) - 0.0111191236254465*std::exp(1.51543974876404*x_81) - 0.0130858370279056*std::exp(1.54271984100342*x_82) + 0.0229829490064091*std::exp(0.91376006603241*x_88) - 0.000849516743095893*std::exp(3.14815998077393*x_89) - 0.0400359182341338*std::exp(0.326159685850143*x_9) + 0.0553649894728765*std::exp(0.413439601659775*x_94) - 0.0165638782489473*std::exp(0.486799538135529*x_99) + 0.0515893000576555*std::sin(0.879599809646606*x_107 + 8.1738395690918) + 0.0327897605732432*std::sin(1.02023994922638*x_118 - 1.39911961555481) + 0.0757536989148924*std::sin(0.705280065536499*x_119 - 1.23703980445862) - 0.0424245358743489*std::sin(1.2203197479248*x_96 - 7.82216024398804) - 0.0720266366339519*std::sin(0.741679608821869*x_97 - 1.1515998840332) - 2.75149037732914 - 0.00178251356949051*std::exp(-2.33999991416931*x_67)) - 0.989537477493286*std::sin(-0.0274290893895073*x_1 + 0.021940933061136*x_100 + 0.00905051626293447*x_104 - 0.00407252090283314*x_108 - 0.00251063364319261*x_111 + 0.0104156694892904*x_113 + 0.0116573015530047*x_114 - 0.0139557766454341*x_115 - 0.00147074832802596*x_116 + 0.00130395436941784*x_120 + 5.84949548312828e-5*x_17 - 6.5285655635636e-6*x_18 - 2.5494557944481e-5*x_19 + 0.0116056082761981*x_2 - 0.000112350377112105*x_20 - 7.26004941012824e-5*x_21 - 0.00209662261322301*x_32 - 0.0099318586293119*x_33 - 0.029447921657053*x_34 + 0.0425020197999654*x_35 + 0.00846089319499605*x_36 - 0.0369050207007058*x_37 - 0.0257658447105658*x_38 - 0.0242426321333442*x_39 + 0.0488395332324626*x_40 + 0.0414491686513122*x_41 - 0.00661865027061494*x_42 + 0.0319347165403885*x_43 + 0.0049916150362226*x_44 - 0.0177104080103894*x_45 + 0.0413312484886763*x_46 - 0.0323903439327281*x_47 + 0.032375108006488*x_48 - 0.0274528970148968*x_49 + 0.00654782891199872*x_50 - 0.0276516191024233*x_51 - 0.0239280516013812*x_52 - 0.00191811848219202*x_53 - 0.0290456468484356*x_54 - 0.0252081940762348*x_55 + 0.0109049149385255*x_56 + 0.0201579698689266*x_57 - 0.0317575417821868*x_58 + 0.0159003770732911*x_59 + 0.0205138106402347*x_60 + 0.000354094748850867*x_62 - 0.00203245240315213*x_63 + 0.00844543258385728*x_65 - 0.0101179825707362*x_67 + 0.00822685618383535*x_69 + 0.0105267009288936*x_70 + 0.011271899886121*x_72 - 0.0169257987989388*x_73 + 0.000368285942975318*x_74 + 0.00751616807585149*x_75 - 0.00117287324860155*x_76 - 0.00827718751512315*x_77 + 0.00105409558659435*x_80 + 0.00294799743493984*x_85 + 0.0181866820055426*x_87 - 0.000625406336941954*x_88 - 0.0137098561072109*x_93 + 0.00855796500040332*x_94 + 0.0116929373514079*x_96 - 0.00941033979583681*x_99 + 4.3565336748611e-5*std::pow(2.20000004768372 - 9.95748043060303*x_86, 2) + 0.00599442882237416*std::pow(8.37551975250244 - 0.210639804601669*x_31, 2) + 0.000844003752368538*std::pow(-2.63048005104065*x_102 - 7.50127983093262, 2) + 9.36627089335468e-5*std::pow(-9.03791999816895*x_107 - 8.22247982025146, 2) - 0.000146546011983053*std::pow(-8.81511974334717*x_61 - 9.24431991577148, 2) + 0.000147091129422773*std::pow(-8.96744060516357*x_78 - 5.9543194770813, 2) + 0.000118109132682983*std::pow(-9.76488018035889*x_81 - 6.16847991943359, 2) - 0.000164886761732345*std::pow(-8.79600048065186*x_82 - 6.76008033752441, 2) - 0.000120449819927501*std::pow(-8.73871994018555*x_84 - 6.90944004058838, 2) - 4.14073290287325e-5*std::pow(-9.98104000091553*x_89 - 6.3045597076416, 2) + 8.08954349521248e-5*std::pow(9.99804019927979*x_90 + 6.80000019073486, 2) + 0.000128513447064922*std::pow(-9.12360000610352*x_92 - 4.86263990402222, 2) + 0.0061526751825121*std::exp(0.383999645709991*x_10) + 0.00382964983440068*std::exp(0.390159606933594*x_11) - 0.0281581481117607*std::exp(0.438959568738937*x_112) - 0.119245526254429*std::exp(0.17751981317997*x_118) - 0.0107952820456177*std::exp(0.559599876403809*x_12) - 0.0130219516307561*std::exp(0.756479620933533*x_13) + 0.00697763246179154*std::exp(1.05224001407623*x_14) - 0.00341412884137607*std::exp(1.22631978988647*x_15) - 0.00600505759098462*std::exp(1.24463975429535*x_16) - 0.0109076218658986*std::exp(0.317999690771103*x_22) - 0.0244375896902227*std::exp(0.509839773178101*x_23) - 0.0272019532713129*std::exp(0.603119909763336*x_24) - 0.0229914364218324*std::exp(0.649999976158142*x_25) + 0.0245534497358002*std::exp(0.779999673366547*x_26) - 0.0175098712014733*std::exp(0.663999974727631*x_27) + 0.0855176911280307*std::exp(0.900000095367432*x_28) + 0.0899461081809635*std::exp(1.0239999294281*x_29) + 0.0168560980791706*std::exp(0.253599762916565*x_3) + 0.103773635099362*std::exp(1.0*x_30) - 0.0196496688715236*std::exp(0.291999727487564*x_4) + 0.0227335660474059*std::exp(0.391519606113434*x_5) + 0.0391474480794208*std::exp(0.33903968334198*x_6) + 0.00693164078985035*std::exp(1.52415978908539*x_64) + 0.0145289193396441*std::exp(0.965040028095245*x_68) + 0.00106312557126018*std::exp(0.319119691848755*x_7) - 0.0300198921590462*std::exp(0.763999700546265*x_71) - 0.0246601421879975*std::exp(0.5971999168396*x_79) + 0.0309548856903557*std::exp(0.302559703588486*x_8) - 0.0028139555646384*std::exp(2.54519987106323*x_83) - 0.0232530882803219*std::exp(0.324639678001404*x_9) - 0.0499054512382863*std::exp(0.367199659347534*x_97) - 0.0375273944077188*std::sin(0.997919976711273*x_101 + 8.19495964050293) + 0.0245928939291888*std::sin(1.221599817276*x_103 + 1.38991963863373) + 0.050347985799633*std::sin(0.743679583072662*x_105 - 4.37695980072021) + 0.0327824591286445*std::sin(0.938000082969666*x_106 - 1.35967969894409) - 0.0474690201147863*std::sin(0.799759685993195*x_109 - 4.20560026168823) - 0.0393149984209575*std::sin(0.914640069007874*x_110 - 1.37599968910217) + 0.00691100637777653*std::sin(1.37159967422485*x_117 - 4.98199987411499) + 0.0206879395006154*std::sin(1.09279990196228*x_119 + 1.55415987968445) + 0.00119288321789295*std::sin(5.21920013427734*x_66 - 9.41256046295166) + 0.00366028072471933*std::sin(3.36391997337341*x_91 - 8.0447998046875) - 0.0249044121228001*std::sin(0.978640019893646*x_95 + 8.21375942230225) + 0.0379886636114004*std::sin(1.16767990589142*x_98 - 7.76968002319336) - 2.12984011660976) - 1.33209586474554 + 0.447998232156268*std::exp(-0.012639987282455*x_52) + 0.207541418811145*std::exp(-0.015439985319972*x_49));
}

inline float score_4(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.000503530287905198*x_1 + 0.00101883644710185*x_103 + 0.000868626899314911*x_104 + 3.99234558323243e-6*x_107 - 1.91794134019903e-5*x_109 + 0.000821788140655904*x_112 - 0.000106318596505288*x_116 - 0.000443715016555803*x_117 - 0.000756126582074538*x_118 - 0.000470078597932877*x_119 - 5.59158955538418e-6*x_15 + 1.12701142031209e-6*x_17 - 2.17913459482513e-6*x_18 - 7.83115536024909e-6*x_19 - 0.000535487895570334*x_2 - 3.37793708586716e-6*x_20 - 7.20467374018723e-6*x_21 - 1.38472880065147e-7*x_22 - 1.62875760616162e-7*x_23 - 5.80807971382704e-6*x_24 + 2.01317367347047e-7*x_25 - 2.39874291161312e-6*x_26 - 3.02923831417227e-7*x_27 - 2.30998837924346e-6*x_28 - 1.61413075814715e-6*x_29 - 2.29813851485433e-6*x_30 - 0.00079925993414278*x_31 - 0.000683464494500854*x_32 - 0.00123599826039453*x_33 + 0.000506513975936038*x_34 + 0.000519170118598149*x_35 + 0.00178552436662229*x_36 - 0.00122728492675515*x_37 + 9.71082814259938e-5*x_38 + 0.00140041416693674*x_39 - 0.00106555985614218*x_40 - 0.000897548686629155*x_41 + 0.00110214400846725*x_42 + 0.000695872807009176*x_43 + 0.000968552278022649*x_44 - 0.00141487657254844*x_45 + 0.00221353813963155*x_46 - 0.0012280913510363*x_47 - 0.00136639051307878*x_48 + 0.00196716733541461*x_49 + 0.000600942936677692*x_50 - 0.000326218949573268*x_51 - 0.000894152198072468*x_52 + 0.000382180225256764*x_53 - 0.0008308779318337*x_54 - 0.00109853148392426*x_55 - 0.00203513808599327*x_56 - 0.000268579152881416*x_57 - 0.00122597288723157*x_58 - 3.9705934975186e-5*x_59 + 0.00130585044533837*x_60 - 0.000118156332652906*x_61 - 0.000242778583168153*x_63 + 0.000558335396910232*x_64 + 0.000374321622965343*x_65 - 0.000558939651486495*x_68 - 0.000621931129053136*x_69 + 0.000641568888951729*x_70 - 0.000281401646305796*x_71 - 0.000475401245317618*x_72 - 0.000320567180758387*x_73 - 0.000148088509952318*x_74 + 0.000314139483570276*x_75 - 0.000805099478317864*x_77 - 0.000877390767262217*x_80 + 0.000461438704054014*x_81 + 0.000975331409392121*x_82 + 0.000401424934923801*x_83 - 0.000763936285282893*x_84 - 0.000158630687866903*x_85 + 0.000420381301084278*x_87 - 9.28880066967541e-5*x_88 - 1.69566669361661e-5*x_89 - 6.82516681388687e-6*x_9 - 0.000514559707705704*x_90 + 0.00125834588498852*x_91 - 0.000723932075919141*x_93 - 0.000439999088346019*x_96 + 0.000242085685411217*x_97 - 4.88525924581376e-6*std::pow(-5.74399995803833*x_102 - 9.33600044250488, 2) + 2.35793254141897e-5*std::pow(-3.9255998134613*x_106 - 6.27424001693726, 2) + 7.16800722562305e-6*std::pow(-9.40464019775391*x_67 - 5.20007991790771, 2) - 6.25703762172246e-6*std::pow(-8.10671997070313*x_76 - 6.87735986709595, 2) + 1.27631826874822e-5*std::pow(-8.6048002243042*x_86 - 5.2065601348877, 2) + 0.000549017684534192*std::pow(-0.470984520697585*x_1 + 0.376747463056869*x_100 + 0.155406291606404*x_104 - 0.0699292010104248*x_108 - 0.0431100561267136*x_111 + 0.178847319081417*x_113 + 0.200167366353381*x_114 - 0.239634450891642*x_115 - 0.0252541995290251*x_116 + 0.0223901827352212*x_120 + 0.00100441607350544*x_17 - 0.000112101910462037*x_18 - 0.00043776670757694*x_19 + 0.199279741800692*x_2 - 0.00192916679671401*x_20 - 0.00124662209638578*x_21 - 0.0360010783642824*x_32 - 0.170539809387623*x_33 - 0.505649862094685*x_34 + 0.729801603688075*x_35 + 0.145281881929448*x_36 - 0.633695608309387*x_37 - 0.442424968946162*x_38 - 0.416269906508045*x_39 + 0.838622960607094*x_40 + 0.711723110940008*x_41 - 0.113648753741092*x_42 + 0.548350583200252*x_43 + 0.0857109538693437*x_44 - 0.30410517497248*x_45 + 0.709698305431849*x_46 - 0.556174154954692*x_47 + 0.555912539072528*x_48 - 0.471393321109214*x_49 + 0.112432681155913*x_50 - 0.47480557537025*x_51 - 0.410868248473999*x_52 - 0.032935986359138*x_53 - 0.498742406829405*x_54 - 0.432849557491651*x_55 + 0.18724814603339*x_56 + 0.346132226343054*x_57 - 0.54530831783787*x_58 + 0.273025158379471*x_59 + 0.352242363385493*x_60 + 0.00608015611458304*x_62 - 0.0348992125602773*x_63 + 0.145016407985947*x_65 - 0.173735741053353*x_67 + 0.141263235595196*x_69 + 0.18075383842011*x_70 + 0.193549639575228*x_72 - 0.290632660878326*x_73 + 0.00632383291580371*x_74 + 0.129060019762873*x_75 - 0.0201393905932196*x_76 - 0.142127474199913*x_77 + 0.0180998609750238*x_80 + 0.0506200238438829*x_85 + 0.312283269262908*x_87 - 0.0107388437021361*x_88 - 0.23541175267589*x_93 + 0.146948700579304*x_94 + 0.200779268162889*x_96 - 0.161584816593987*x_99 + 0.000748059804545412*std::pow(2.20000004768372 - 9.95748043060303*x_86, 2) + 0.102930255746722*std::pow(8.37551975250244 - 0.210639804601669*x_31, 2) + 0.0144923769481142*std::pow(-2.63048005104065*x_102 - 7.50127983093262, 2) + 0.00160828110069083*std::pow(-9.03791999816895*x_107 - 8.22247982025146, 2) - 0.00251633957780545*std::pow(-8.81511974334717*x_61 - 9.24431991577148, 2) + 0.00252569978194583*std::pow(-8.96744060516357*x_78 - 5.9543194770813, 2) + 0.00202805031026593*std::pow(-9.76488018035889*x_81 - 6.16847991943359, 2) - 0.00283126834219999*std::pow(-8.79600048065186*x_82 - 6.76008033752441, 2) - 0.00206824221909335*std::pow(-8.73871994018555*x_84 - 6.90944004058838, 2) - 0.000711004683349975*std::pow(-9.98104000091553*x_89 - 6.3045597076416, 2) + 0.00138905441287177*std::pow(9.99804019927979*x_90 + 6.80000019073486, 2) + 0.00220670265095352*std::pow(-9.12360000610352*x_92 - 4.86263990402222, 2) + 0.105647501843496*std::exp(0.383999645709991*x_10) + 0.0657588651989585*std::exp(0.390159606933594*x_11) - 0.483503178097575*std::exp(0.438959568738937*x_112) - 2.04756330881907*std::exp(0.17751981317997*x_118) - 0.185365641120974*std::exp(0.559599876403809*x_12) - 0.223599754270551*std::exp(0.756479620933533*x_13) + 0.11981283206135*std::exp(1.05224001407623*x_14) - 0.0586239598814548*std::exp(1.22631978988647*x_15) - 0.103112762187914*std::exp(1.24463975429535*x_16) - 0.187294626646482*std::exp(0.317999690771103*x_22) - 0.419617520064547*std::exp(0.509839773178101*x_23) - 0.467084369502561*std::exp(0.603119909763336*x_24) - 0.394785641969876*std::exp(0.649999976158142*x_25) + 0.421606951330726*std::exp(0.779999673366547*x_26) - 0.300661760155155*std::exp(0.663999974727631*x_27) + 1.46842311077624*std::exp(0.900000095367432*x_28) + 1.54446339973758*std::exp(1.0239999294281*x_29) + 0.289435830767558*std::exp(0.253599762916565*x_3) + 1.78189567631129*std::exp(1.0*x_30) - 0.337404196832765*std::exp(0.291999727487564*x_4) + 0.390357753279272*std::exp(0.391519606113434*x_5) + 0.672200298318064*std::exp(0.33903968334198*x_6) + 0.119023109688227*std::exp(1.52415978908539*x_64) + 0.249475876295545*std::exp(0.965040028095245*x_68) + 0.0182549147188555*std::exp(0.319119691848755*x_7) - 0.515471159801983*std::exp(0.763999700546265*x_71) - 0.423438965975712*std::exp(0.5971999168396*x_79) + 0.531525921006254*std::exp(0.302559703588486*x_8) - 0.0483183927127568*std::exp(2.54519987106323*x_83) - 0.399278462471874*std::exp(0.324639678001404*x_9) - 0.856925824181844*std::exp(0.367199659347534*x_97) - 0.644382378764277*std::sin(0.997919976711273*x_101 + 8.19495964050293) + 0.422284247038711*std::sin(1.221599817276*x_103 + 1.38991963863373) + 0.86452457911345*std::sin(0.743679583072662*x_105 - 4.37695980072021) + 0.562907159648518*std::sin(0.938000082969666*x_106 - 1.35967969894409) - 0.815089898511147*std::sin(0.799759685993195*x_109 - 4.20560026168823) - 0.675077302952843*std::sin(0.914640069007874*x_110 - 1.37599968910217) + 0.118668796479266*std::sin(1.37159967422485*x_117 - 4.98199987411499) + 0.355232327677832*std::sin(1.09279990196228*x_119 + 1.55415987968445) + 0.0204829815036596*std::sin(5.21920013427734*x_66 - 9.41256046295166) + 0.0628506305211145*std::sin(3.36391997337341*x_91 - 8.0447998046875) - 0.427633321702586*std::sin(0.978640019893646*x_95 + 8.21375942230225) + 0.652302825984506*std::sin(1.16767990589142*x_98 - 7.76968002319336) - 8.78911699255857, 2) - 0.00124786675691335*std::exp(0.376559644937515*x_10) - 0.00193974587591871*std::exp(0.440959572792053*x_100) + 0.0013294546110514*std::exp(0.390479624271393*x_11) - 0.000533699047231043*std::exp(0.597919881343842*x_113) - 0.00120222337991308*std::exp(0.555519819259644*x_12) - 0.000261439276526201*std::exp(0.735919654369354*x_13) - 0.000247351949205677*std::exp(1.00799989700317*x_14) - 0.000241315552249369*std::exp(1.20743978023529*x_16) + 0.000785936937718297*std::exp(0.256639748811722*x_3) + 0.000822600773975681*std::exp(0.296639710664749*x_4) - 0.000670356707676601*std::exp(0.39199960231781*x_5) + 0.000298745029595279*std::exp(0.326959699392319*x_6) - 0.00173551904489498*std::exp(0.531519830226898*x_62) - 0.000283295167695517*std::exp(0.329039663076401*x_7) + 0.000378522645334387*std::exp(1.75759971141815*x_78) + 0.00102504766897443*std::exp(0.718479633331299*x_79) + 0.000908929610327337*std::exp(0.303359717130661*x_8) - 0.00480559814118015*std::exp(0.286399722099304*x_98) - 9.14788555905588*std::exp(-0.13410583346412*x_1 + 0.0203752310136645*x_101 + 0.083860482525252*x_104 + 0.0788874120569606*x_105 + 0.0371470485699715*x_106 - 0.0470284651333777*x_107 - 0.0492881292987389*x_111 + 0.0571950489328366*x_112 + 0.0269502982569934*x_114 - 0.0664417884453284*x_117 + 0.000115341432148896*x_17 + 1.26457320872826e-5*x_18 - 6.78236786030711e-5*x_19 + 0.00582232389373211*x_2 - 0.000500627743796193*x_20 - 0.000237522885691303*x_21 + 8.99075126968159e-5*x_22 + 8.19611841841258e-5*x_23 - 0.000134747859778374*x_24 + 0.000127761804788343*x_26 - 1.14569146657542e-5*x_28 - 3.71975501177295e-5*x_29 + 2.16023687241682e-5*x_30 - 0.0388452476852843*x_33 - 0.074223458570196*x_34 - 0.0819791414775553*x_35 + 0.0141817860063265*x_36 - 0.12242210344752*x_37 - 0.0778972987578697*x_38 + 0.146628547368219*x_39 + 0.0232078751527764*x_40 - 0.0325074569095132*x_41 + 0.0970701905658618*x_42 - 0.027899052997461*x_43 - 0.00206655973699689*x_44 + 0.00461752684116774*x_45 - 0.112235334654565*x_46 + 0.0289248126134098*x_47 - 0.111000605957013*x_48 - 0.131671707225798*x_49 + 0.0353133445277595*x_50 + 0.00821233858148935*x_51 + 0.0263931933891202*x_52 + 0.124333464372599*x_53 + 0.131520850765109*x_54 + 0.142379283748648*x_55 + 0.0867848805683117*x_56 - 0.0320502002145267*x_57 + 0.0897492904916532*x_58 - 0.0286458219268577*x_59 - 0.0644724486531068*x_60 + 0.0274362868472916*x_62 - 0.00534752015956681*x_63 + 0.0824262529866398*x_64 - 0.0302997904299519*x_68 - 0.0807675092148849*x_69 - 0.0219315814415866*x_70 + 0.0645980714959997*x_71 - 0.0512373018084394*x_72 + 0.0208823299044552*x_75 - 0.0297104080946192*x_76 + 0.035118686473956*x_78 + 0.00905365893084181*x_79 + 0.0554744841100316*x_81 + 0.0576139517679631*x_82 + 0.019614868213659*x_83 + 0.0692213660614503*x_84 + 0.016515007527264*x_86 + 0.00865026070670394*x_87 - 0.0264700175120082*x_88 - 0.0759538549092337*x_89 - 0.00333224698083363*x_90 - 0.0464466091791743*x_92 - 0.0410843816278251*x_93 - 0.0902839988123736*x_96 - 0.0954111078207917*x_97 + 0.129465353210463*x_98 + 0.0316105133888197*x_99 - 0.0373276467218688*std::pow(8.27943992614746 - 0.201439797878265*x_31, 2) + 0.000146944697888679*std::pow(-9.83440017700195*x_108 - 4.4474401473999, 2) + 0.000137263626284313*std::pow(-9.9629602432251*x_109 - 3.39999985694885, 2) + 0.000112224032315663*std::pow(-9.99868011474609*x_116 - 3.37999987602234, 2) + 0.00434224781103043*std::pow(-2.03575992584229*x_119 - 5.2993597984314, 2) - 0.00049050258234392*std::pow(-5.40767955780029*x_120 - 9.19095993041992, 2) - 0.000513231650442293*std::pow(-8.49944019317627*x_65 - 8.27271938323975, 2) - 0.000421659464486177*std::pow(-9.9993200302124*x_73 - 6.0, 2) + 0.000395416919444471*std::pow(-8.14783954620361*x_74 - 9.39192008972168, 2) - 0.00035207855656633*std::pow(-9.59967994689941*x_77 - 1.02799999713898, 2) + 0.000564286143839056*std::pow(-8.69464015960693*x_80 - 7.84104013442993, 2) + 0.00015915061914137*std::pow(-9.93639945983887*x_91 - 4.7960000038147, 2) - 0.0922536330021473*std::exp(0.37863963842392*x_10) + 0.0104071615297*std::exp(0.398079603910446*x_11) - 0.0417491397816199*std::exp(0.554959833621979*x_12) - 0.0231723197393786*std::exp(0.746319591999054*x_13) + 0.021624562975109*std::exp(1.0595999956131*x_14) + 0.0124860640404571*std::exp(1.26079976558685*x_15) - 0.00511170862904132*std::exp(1.17711985111237*x_16) - 0.13544374541079*std::exp(0.59999942779541*x_25) - 0.143480301070311*std::exp(0.625759959220886*x_27) - 0.0402857984606934*std::exp(0.254479765892029*x_3) - 0.0192393780958937*std::exp(0.292959719896317*x_4) - 0.0265174590776592*std::exp(0.39087963104248*x_5) - 0.105725144852643*std::exp(0.33751967549324*x_6) + 0.0148389751063064*std::exp(2.69063973426819*x_61) + 0.034277070093936*std::exp(1.45271956920624*x_67) + 0.0126564038768793*std::exp(0.334319651126862*x_7) - 0.100453290535271*std::exp(0.300399720668793*x_8) - 0.0108579788795629*std::exp(2.24656009674072*x_85) - 0.0290044599341235*std::exp(0.318799704313278*x_9) + 0.225161630714946*std::exp(0.273759722709656*x_94) - 0.538899132395974*std::exp(0.158639833331108*x_95) - 0.115756528996629*std::sin(1.18831980228424*x_100 + 4.79408025741577) - 0.227497969219286*std::sin(0.630799949169159*x_102 + 8.37952041625977) - 0.197798532602626*std::sin(0.748079597949982*x_103 - 1.14335989952087) - 0.117283436172107*std::sin(1.08351993560791*x_110 - 4.62207984924316) - 0.150186452757048*std::sin(0.946880042552948*x_113 - 1.34919965267181) + 0.024053921819766*std::sin(1.5771199464798*x_115 - 5.18495988845825) - 0.054708636586196*std::sin(1.20855975151062*x_118 + 4.79016017913818) + 0.0176556340595981*std::sin(2.92903971672058*x_66 + 2.37191987037659) - 1.83731906009065*std::exp(-0.0245599746704102*x_32)) - 0.523598540052097*std::exp(-0.0127607568634324*x_1 + 0.00673941940300396*x_101 + 0.0125313519874018*x_102 + 0.0173987770085707*x_104 - 0.0127590992983568*x_105 + 0.0038510356211495*x_106 + 0.00461297895667285*x_108 + 0.000681884238765454*x_111 - 0.00414568844286559*x_113 - 0.00675511396482227*x_114 - 0.00499386786313249*x_119 - 3.01545682239713e-5*x_12 - 2.53761370103269e-5*x_17 - 4.16672632484815e-6*x_18 - 1.27764042923098e-5*x_19 + 0.0028186004255596*x_2 + 2.24836132187488e-5*x_20 + 2.08830827803809e-5*x_21 + 1.96327180974682e-6*x_27 - 9.72541678451141e-6*x_28 - 9.89116241434909e-6*x_29 - 1.37147574616072e-6*x_30 - 0.0030536115934158*x_31 + 0.00544219436630911*x_32 + 0.0123524353243997*x_33 + 0.00209300398868409*x_34 - 0.0177525736571133*x_35 - 0.00120346352826368*x_36 - 0.000185849258405624*x_37 - 0.0139113478769731*x_38 + 0.0198020405736829*x_39 + 0.0198222984486756*x_40 - 0.0121581394888904*x_41 + 0.0165988952271438*x_42 - 0.00848303772145718*x_43 - 0.0195409343356639*x_44 - 0.0110667721494924*x_45 + 0.0145913055473143*x_46 - 0.0153361641910436*x_47 + 0.00352491738663287*x_48 + 0.024511890156624*x_50 + 0.0106354332244538*x_51 - 0.0170647514406303*x_53 + 0.0115332431696448*x_54 + 0.0186139783643811*x_55 - 0.0144043658849435*x_56 + 0.0154576783838007*x_57 - 0.00184861970909818*x_58 + 0.00676698894087663*x_59 + 0.0146495012518769*x_60 - 0.0103784073237069*x_62 + 0.0068327929046598*x_63 - 0.0085510240057877*x_64 + 0.00747912272254904*x_65 + 0.00404867693242215*x_67 + 0.00717546455997815*x_68 - 0.00431462255296652*x_69 + 0.00257588909416241*x_70 + 0.00262136855081516*x_73 - 0.00296318797356265*x_76 - 0.00914987502815248*x_78 + 0.00384400312501346*x_79 - 0.00380005793693839*x_80 + 0.0098683382713721*x_81 - 0.00954930086071108*x_82 + 0.00957436673403404*x_83 + 0.00388479133815972*x_85 - 0.00668144236783838*x_87 + 0.00891849557629347*x_88 - 0.00109776068551518*x_90 + 0.00235326622713036*x_91 - 0.000715783036958314*x_92 - 0.0175014496577163*x_94 + 0.00757786278493326*x_96 + 0.00897889610928113*x_98 + 1.94663724629306e-5*std::pow(-9.66063976287842*x_112 - 2.00952005386353, 2) + 5.92984205538831e-5*std::pow(-9.87936019897461*x_61 - 6.42767953872681, 2) - 2.82149070375539e-5*std::pow(-9.61999988555908*x_89 - 9.98340034484863, 2) + 5.64509660538337e-5*std::pow(-9.5272798538208*x_93 - 3.83999991416931, 2) - 0.0103460008782561*std::exp(0.377839624881744*x_10) + 0.0263489052857779*std::exp(0.306799709796906*x_109) + 0.0165658098522231*std::exp(0.389359623193741*x_11) + 0.0487839039832716*std::exp(0.204399809241295*x_110) + 0.0460599681532888*std::exp(0.284239739179611*x_116) - 0.00625985578942496*std::exp(0.753279685974121*x_13) + 0.00270023964541544*std::exp(1.06831991672516*x_14) - 0.000519642138635097*std::exp(1.01175999641418*x_15) + 0.0012591940833027*std::exp(1.3155996799469*x_16) - 0.00726929856493939*std::exp(0.302559703588486*x_22) - 0.00780731154058447*std::exp(0.454799562692642*x_23) - 0.0144595499617951*std::exp(0.549359798431396*x_24) - 0.0106137385220484*std::exp(0.551279842853546*x_25) - 0.0125892909686552*std::exp(0.568719863891602*x_26) + 0.00567913307391704*std::exp(0.254239767789841*x_3) + 0.0159833591177836*std::exp(0.290719717741013*x_4) - 0.00105523800300378*std::exp(0.375039637088776*x_5) - 0.00964960311790818*std::exp(0.336479663848877*x_6) + 0.0155980130633567*std::exp(0.322799682617188*x_7) + 0.00289590907118528*std::exp(1.67871999740601*x_72) - 0.00915041379601443*std::exp(0.906000137329102*x_74) - 0.00470902201498506*std::exp(1.59167993068695*x_75) - 0.00390618172209084*std::exp(1.82439970970154*x_77) - 0.00484373980577672*std::exp(0.296319723129272*x_8) + 0.00710871126430972*std::exp(0.453119575977325*x_84) + 0.00104502098016781*std::exp(2.19304013252258*x_86) - 0.0159328664684529*std::exp(0.321679681539536*x_9) + 0.000222660300412549*std::sin(8.43152046203613*x_100 + 6.17775964736938) + 0.0171520933294234*std::sin(1.13871991634369*x_103 - 4.73816013336182) + 0.00299770187710668*std::sin(2.24272012710571*x_107 + 0.576879858970642) + 0.0226313212105995*std::sin(0.942240059375763*x_115 - 7.77415990829468) - 0.0313668862367698*std::sin(0.655439972877502*x_117 - 7.4203200340271) - 0.0137325675940331*std::sin(0.86495977640152*x_118 - 1.23255980014801) - 0.00462109849254938*std::sin(1.39743959903717*x_120 + 7.59143972396851) + 0.0012327786526094*std::sin(3.70088005065918*x_66 - 5.78968000411987) + 0.004991659728176*std::sin(2.39439988136292*x_71 + 2.39183974266052) + 0.0231538992591656*std::sin(1.02312004566193*x_95 - 1.41087961196899) + 0.012605824267082*std::sin(0.921440064907074*x_97 - 4.54048013687134) + 0.0179961480118276*std::sin(0.982560038566589*x_99 - 1.37295973300934) + 0.382960699997029*std::exp(-0.012639987282455*x_52) + 0.177411876479389*std::exp(-0.015439985319972*x_49)) + 0.155614686989148*std::exp(0.069341796168596*x_1 + 0.044669507485538*x_100 + 0.0744250226308808*x_101 - 0.00210924623848897*x_105 - 0.0494974667585013*x_106 + 0.00801531710435562*x_108 - 0.0311876657273548*x_109 + 0.0140782183386677*x_111 - 0.00958098525058907*x_112 + 0.0460369358216398*x_113 - 0.0152016572453793*x_114 + 0.0142200011136919*x_116 + 0.000145957488760878*x_17 - 3.85235290087097e-5*x_18 + 0.000139842760616444*x_19 - 0.00509602645987447*x_2 + 0.000161903606122386*x_20 - 0.00035844151522761*x_21 - 0.000133008862458812*x_23 - 1.53271166809359e-5*x_24 + 4.99694761706196e-5*x_25 - 4.21866539435643e-5*x_26 - 5.12692205456222e-5*x_27 - 4.38093010567562e-5*x_28 - 3.76230995998956e-5*x_29 - 2.80250786226535e-5*x_30 - 0.030620087217488*x_31 - 0.000359547025695963*x_32 + 0.0691023261386308*x_33 - 0.0763406088636448*x_34 + 0.068808767078059*x_35 - 0.0330425347443003*x_36 - 0.0729652456527837*x_37 + 0.0775574667168846*x_38 - 0.0371408745195043*x_39 + 0.0989679600080535*x_40 - 0.0644505709794542*x_41 + 0.0406501405892818*x_42 + 0.0916234998919307*x_43 - 0.0949415337244795*x_44 - 0.0292305212445958*x_45 + 0.0496631891259515*x_46 - 0.0956568176172731*x_47 - 0.0186746180681696*x_48 + 0.031426903952751*x_49 + 0.0352496935969148*x_50 + 0.0586774245414321*x_51 + 0.0295750116652512*x_52 + 0.0422411464622027*x_53 - 0.0316255405475152*x_54 - 0.0779390423133864*x_55 - 0.0577690419723706*x_56 - 0.0909608645037475*x_57 + 0.078465979881237*x_58 - 0.0219631834515955*x_59 - 0.0452536292283602*x_60 + 0.000459234848017298*x_61 - 0.00176176050799889*x_62 + 0.000287482394964456*x_63 + 0.025786843482395*x_64 - 0.0228238397936519*x_70 + 0.0298443989622686*x_71 - 0.0342483799463755*x_72 - 0.0343256139316139*x_73 + 0.0195909733444405*x_74 - 0.0550028919933455*x_76 - 0.0472819354262062*x_77 - 0.0214446384342339*x_78 + 0.000834312519604971*x_83 + 0.00986823817416333*x_85 - 0.0416826368788343*x_86 - 0.0322529945418197*x_90 + 0.0257810609711579*x_92 - 0.0142029251090592*x_93 - 0.00382644826853851*x_95 - 0.0510193893823652*x_98 - 0.000660641626917036*std::pow(-5.06224012374878*x_110 - 6.06215953826904, 2) - 0.000467311316398655*std::pow(-4.91359996795654*x_120 - 9.95232009887695, 2) + 0.000362157887289438*std::pow(-9.72855949401855*x_66 - 3.0403196811676, 2) - 0.000303710210918573*std::pow(-9.34815979003906*x_68 - 7.77871990203857, 2) + 0.000266955869625218*std::pow(9.97795963287354*x_69 + 6.79199981689453, 2) + 0.000275490743663065*std::pow(-7.12376022338867*x_75 - 8.96928024291992, 2) - 0.000554448613501624*std::pow(-4.9159197807312*x_84 - 9.26272010803223, 2) + 0.000386985197812995*std::pow(-9.30655956268311*x_87 - 4.45368003845215, 2) + 0.000431293703316737*std::pow(-7.25176000595093*x_91 - 4.82791996002197, 2) + 0.0610819297580307*std::exp(0.383119642734528*x_10) - 0.158087699370345*std::exp(0.226719796657562*x_102) + 0.100900587995946*std::exp(0.325359672307968*x_103) - 0.0488504392615153*std::exp(0.290799736976624*x_104) - 0.0532448522442336*std::exp(0.386399626731873*x_11) + 0.0458452718872964*std::exp(0.310719698667526*x_115) - 0.301297829088763*std::exp(0.193679809570313*x_117) + 0.0226374431959383*std::exp(0.563039839267731*x_12) - 0.0263023075719641*std::exp(0.749999642372131*x_13) - 0.00473700741933011*std::exp(1.05879998207092*x_14) - 0.0150861672882033*std::exp(1.23447978496552*x_15) - 0.00597782923370885*std::exp(1.22799980640411*x_16) - 0.0310041822383148*std::exp(0.294799715280533*x_22) - 0.0537005049002982*std::exp(0.25279974937439*x_3) + 0.0642698696502399*std::exp(0.291599720716476*x_4) + 0.0153837671433314*std::exp(0.395119607448578*x_5) - 0.0108127131522295*std::exp(0.332639664411545*x_6) + 0.0154554026418326*std::exp(1.60343992710114*x_65) - 0.0334025084226055*std::exp(0.318159699440002*x_7) + 0.0283873107462105*std::exp(0.960240066051483*x_79) - 0.0863468560311436*std::exp(0.301119714975357*x_8) + 0.0346900569890066*std::exp(1.0*x_80) + 0.0181631110608658*std::exp(1.51543974876404*x_81) + 0.0213757414045025*std::exp(1.54271984100342*x_82) - 0.0375426939542513*std::exp(0.91376006603241*x_88) + 0.00138768732794767*std::exp(3.14815998077393*x_89) + 0.0653987538771618*std::exp(0.326159685850143*x_9) - 0.0904388229282896*std::exp(0.413439601659775*x_94) + 0.0270571288141611*std::exp(0.486799538135529*x_99) - 0.0842712265879584*std::sin(0.879599809646606*x_107 + 8.1738395690918) - 0.0535621405978475*std::sin(1.02023994922638*x_118 - 1.39911961555481) - 0.123743821276861*std::sin(0.705280065536499*x_119 - 1.23703980445862) + 0.0693005656514174*std::sin(1.2203197479248*x_96 - 7.82216024398804) + 0.117655657459295*std::sin(0.741679608821869*x_97 - 1.1515998840332) + 0.00291173954178033*std::exp(-2.33999991416931*x_67)) + 0.000958878873183905*std::sin(1.14503979682922*x_101 - 7.75903987884521) + 0.00138541051273847*std::sin(1.16319978237152*x_105 + 7.80984020233154) + 0.00190479111973236*std::sin(1.21303987503052*x_108 + 4.7760796546936) - 0.00132981501952044*std::sin(1.15967988967896*x_110 + 1.62808001041412) + 0.00242233443859639*std::sin(0.790319681167603*x_111 + 8.21183967590332) + 0.00174711918761983*std::sin(0.879999816417694*x_114 - 7.63015985488892) - 0.00237477741543674*std::sin(0.722879588603973*x_115 - 4.3699197769165) - 0.00153681525684342*std::sin(1.02160000801086*x_120 + 8.18144035339355) - 0.000133797544472959*std::sin(4.38775968551636*x_66 - 0.206719815731049) + 0.000974239914935283*std::sin(1.18479979038239*x_92 - 1.17983984947205) + 0.000947286064966552*std::sin(1.35383975505829*x_94 - 1.54991984367371) - 0.000445268803051499*std::sin(1.47087955474854*x_95 + 4.54888010025024) + 0.00205681471542703*std::sin(0.986720025539398*x_99 - 1.37095963954926) + 1.00149602847461);
}

inline float score_5(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.0119008125459706*x_1 - 0.000983798665359991*x_101 + 0.0109781670309502*x_103 + 0.00531050533139358*x_104 - 0.00380900371845077*x_105 - 0.0017936099365299*x_106 + 0.00231374306849926*x_107 - 0.000206662025570084*x_109 + 0.00237983048092416*x_111 + 0.00609332343279964*x_112 - 0.00130126953841665*x_114 - 0.00114560419805494*x_116 - 0.00157303967385398*x_117 - 0.00814741555248465*x_118 - 0.00506519116042788*x_119 - 6.02504987744986e-5*x_15 + 6.57462262671509e-6*x_17 - 2.40911994098975e-5*x_18 - 8.110746757224e-5*x_19 - 0.00605111483520385*x_2 - 1.22256146738476e-5*x_20 - 6.61632375477633e-5*x_21 - 5.83317185610988e-6*x_22 - 5.71243686747045e-6*x_23 - 5.60770512975611e-5*x_24 + 2.16923500455233e-6*x_25 - 3.20157932294645e-5*x_26 - 3.2640650306666e-6*x_27 - 2.43374017860165e-5*x_28 - 1.55965342546601e-5*x_29 - 2.58059532006248e-5*x_30 - 0.00861218607081163*x_31 - 0.00736446698751081*x_32 - 0.0114425232510645*x_33 + 0.00904159882187119*x_34 + 0.00955244707543351*x_35 + 0.0185546290530599*x_36 - 0.00731320628273859*x_37 + 0.00480755824485971*x_38 + 0.00800992342486513*x_39 - 0.0126021913286267*x_40 - 0.00810167542672746*x_41 + 0.00718888081255809*x_42 + 0.00884524830248805*x_43 + 0.0105361268982254*x_44 - 0.0154685316980944*x_45 + 0.0292704938167097*x_46 - 0.0146295376715788*x_47 - 0.00936357302266886*x_48 + 0.0275542657727823*x_49 + 0.00477020937385933*x_50 - 0.00391159956390473*x_51 - 0.0109090395033036*x_52 - 0.00188525459561342*x_53 - 0.0153032356213852*x_54 - 0.0187115454363585*x_55 - 0.0261193464750679*x_56 - 0.0013464807744867*x_57 - 0.0175435629074688*x_58 + 0.000955296875602044*x_59 + 0.0171837913287337*x_60 - 0.00127315817893827*x_61 - 0.00132473503562721*x_62 - 0.00235778799074409*x_63 + 0.00203630257856787*x_64 + 0.00403339055242802*x_65 - 0.00455969024760175*x_68 - 0.00280165021223259*x_69 + 0.0079719790027939*x_70 - 0.0061512156598312*x_71 - 0.00264859933027324*x_72 - 0.00345417565794503*x_73 - 0.00159568339181977*x_74 + 0.00237663247839109*x_75 + 0.00143453881878369*x_76 - 0.00867510833033723*x_77 - 0.00169567240043087*x_78 - 0.000437147317093649*x_79 - 0.00945406146572154*x_80 + 0.00229356182765003*x_81 + 0.00772755661911286*x_82 + 0.00337834890377885*x_83 - 0.0115738545446193*x_84 - 0.00170927747293606*x_85 - 0.000797411442983706*x_86 + 0.00411202320356383*x_87 + 0.000277192739541758*x_88 + 0.00348464821289565*x_89 - 7.35425411115652e-5*x_9 - 0.00538358965971447*x_90 + 0.0135589292544537*x_91 + 0.0022426303824641*x_92 - 0.00581679297122074*x_93 - 0.000381801333712735*x_96 + 0.0072153564718909*x_97 - 0.0062511115389757*x_98 - 0.00152628359709929*x_99 + 0.00180232994665807*std::pow(8.27943992614746 - 0.201439797878265*x_31, 2) - 5.26396480441933e-5*std::pow(-5.74399995803833*x_102 - 9.33600044250488, 2) + 0.00025407195984247*std::pow(-3.9255998134613*x_106 - 6.27424001693726, 2) - 7.09508508481001e-6*std::pow(-9.83440017700195*x_108 - 4.4474401473999, 2) - 6.62764374305333e-6*std::pow(-9.9629602432251*x_109 - 3.39999985694885, 2) - 5.41863074531147e-6*std::pow(-9.99868011474609*x_116 - 3.37999987602234, 2) - 0.000209661308786593*std::pow(-2.03575992584229*x_119 - 5.2993597984314, 2) + 2.36834510264917e-5*std::pow(-5.40767955780029*x_120 - 9.19095993041992, 2) + 2.47809024784561e-5*std::pow(-8.49944019317627*x_65 - 8.27271938323975, 2) + 7.72367152998815e-5*std::pow(-9.40464019775391*x_67 - 5.20007991790771, 2) + 2.03594265075919e-5*std::pow(-9.9993200302124*x_73 - 6.0, 2) - 1.90923301605436e-5*std::pow(-8.14783954620361*x_74 - 9.39192008972168, 2) - 6.74208351356146e-5*std::pow(-8.10671997070313*x_76 - 6.87735986709595, 2) + 1.69997784967216e-5*std::pow(-9.59967994689941*x_77 - 1.02799999713898, 2) - 2.72460201711429e-5*std::pow(-8.69464015960693*x_80 - 7.84104013442993, 2) + 0.000137525852935752*std::pow(-8.6048002243042*x_86 - 5.2065601348877, 2) - 7.68443639227907e-6*std::pow(-9.93639945983887*x_91 - 4.7960000038147, 2) - 0.00167166243772954*std::pow(-0.33290378871495*x_1 + 0.266294649460271*x_100 + 0.109845103166631*x_104 - 0.04942773049887*x_108 - 0.0304712795975561*x_111 + 0.126413815119721*x_113 + 0.141483364543356*x_114 - 0.169379699549992*x_115 - 0.0178503078863901*x_116 + 0.0158259482743409*x_120 + 0.000709946721435572*x_17 - 7.92364697245721e-5*x_18 - 0.000309424597033004*x_19 + 0.140855969027025*x_2 - 0.00136358395545136*x_20 - 0.000881144073202077*x_21 - 0.025446474052995*x_32 - 0.120541856848664*x_33 - 0.357406130046889*x_34 + 0.515842258505996*x_35 + 0.102688913967527*x_36 - 0.447912106720117*x_37 - 0.312717174157071*x_38 - 0.294230113548733*x_39 + 0.592759949893787*x_40 + 0.50306392192463*x_41 - 0.0803298177339355*x_42 + 0.387588081283521*x_43 + 0.060582673152857*x_44 - 0.214949240298208*x_45 + 0.501632738105513*x_46 - 0.393117979961463*x_47 + 0.392933063229526*x_48 - 0.333192739200325*x_49 + 0.0794702668290374*x_50 - 0.335604606940426*x_51 - 0.290412084832602*x_52 - 0.0232799893885709*x_53 - 0.352523765707643*x_54 - 0.305949030807073*x_55 + 0.132351732392477*x_56 + 0.244655024702883*x_57 - 0.385437731068374*x_58 + 0.192981097349875*x_59 + 0.248973824327089*x_60 + 0.00429760834501549*x_62 - 0.0246676473937549*x_63 + 0.102501270260117*x_65 - 0.122800822299206*x_67 + 0.0998484329508761*x_69 + 0.127761391278211*x_70 + 0.136805787637294*x_72 - 0.205426526093468*x_73 + 0.00446984528016604*x_74 + 0.0912228909074354*x_75 - 0.0142350313784471*x_76 - 0.100459298686841*x_77 + 0.0127934401854116*x_80 + 0.0357795149987317*x_85 + 0.220729724484225*x_87 - 0.00759048673099444*x_88 - 0.166394989495102*x_93 + 0.103867063607808*x_94 + 0.141915872241071*x_96 - 0.114212241122651*x_99 + 0.00052874761733079*std::pow(2.20000004768372 - 9.95748043060303*x_86, 2) + 0.072753711864523*std::pow(8.37551975250244 - 0.210639804601669*x_31, 2) + 0.0102435791018496*std::pow(-2.63048005104065*x_102 - 7.50127983093262, 2) + 0.00113677381784359*std::pow(-9.03791999816895*x_107 - 8.22247982025146, 2) - 0.00177861254952515*std::pow(-8.81511974334717*x_61 - 9.24431991577148, 2) + 0.00178522857889457*std::pow(-8.96744060516357*x_78 - 5.9543194770813, 2) + 0.00143347732743336*std::pow(-9.76488018035889*x_81 - 6.16847991943359, 2) - 0.0020012121769757*std::pow(-8.79600048065186*x_82 - 6.76008033752441, 2) - 0.00146188598660653*std::pow(-8.73871994018555*x_84 - 6.90944004058838, 2) - 0.000502556119107066*std::pow(-9.98104000091553*x_89 - 6.3045597076416, 2) + 0.000981818842138014*std::pow(9.99804019927979*x_90 + 6.80000019073486, 2) + 0.00155975332688575*std::pow(-9.12360000610352*x_92 - 4.86263990402222, 2) + 0.0746743302303817*std::exp(0.383999645709991*x_10) + 0.0464800315176074*std::exp(0.390159606933594*x_11) - 0.341752292848182*std::exp(0.438959568738937*x_112) - 1.44726960905211*std::exp(0.17751981317997*x_118) - 0.131021130238738*std::exp(0.559599876403809*x_12) - 0.158045969838133*std::exp(0.756479620933533*x_13) + 0.0846867444195732*std::exp(1.05224001407623*x_14) - 0.0414368997204064*std::exp(1.22631978988647*x_15) - 0.0728827120398313*std::exp(1.24463975429535*x_16) - 0.13238458606711*std::exp(0.317999690771103*x_22) - 0.296596291601596*std::exp(0.509839773178101*x_23) - 0.330147063064048*std::exp(0.603119909763336*x_24) - 0.279044491201915*std::exp(0.649999976158142*x_25) + 0.298002472010494*std::exp(0.779999673366547*x_26) - 0.212515347487661*std::exp(0.663999974727631*x_27) + 1.03791864813299*std::exp(0.900000095367432*x_28) + 1.09166585038226*std::exp(1.0239999294281*x_29) + 0.204580576256873*std::exp(0.253599762916565*x_3) + 1.25948899734585*std::exp(1.0*x_30) - 0.238485832374253*std::exp(0.291999727487564*x_4) + 0.275914747322165*std::exp(0.391519606113434*x_5) + 0.475128196896918*std::exp(0.33903968334198*x_6) + 0.0841285486435072*std::exp(1.52415978908539*x_64) + 0.176335868297242*std::exp(0.965040028095245*x_68) + 0.0129030360988814*std::exp(0.319119691848755*x_7) - 0.364348072028366*std::exp(0.763999700546265*x_71) - 0.299297386364354*std::exp(0.5971999168396*x_79) + 0.37569598389583*std::exp(0.302559703588486*x_8) - 0.0341526638176328*std::exp(2.54519987106323*x_83) - 0.282220130530605*std::exp(0.324639678001404*x_9) - 0.605696877458502*std::exp(0.367199659347534*x_97) - 0.455465786761003*std::sin(0.997919976711273*x_101 + 8.19495964050293) + 0.298481201772004*std::sin(1.221599817276*x_103 + 1.38991963863373) + 0.611067869911718*std::sin(0.743679583072662*x_105 - 4.37695980072021) + 0.397877038218176*std::sin(0.938000082969666*x_106 - 1.35967969894409) - 0.57612618553949*std::sin(0.799759685993195*x_109 - 4.20560026168823) - 0.477161736643936*std::sin(0.914640069007874*x_110 - 1.37599968910217) + 0.0838781110930755*std::sin(1.37159967422485*x_117 - 4.98199987411499) + 0.251087206821206*std::sin(1.09279990196228*x_119 + 1.55415987968445) + 0.0144778901367012*std::sin(5.21920013427734*x_66 - 9.41256046295166) + 0.0444244175851314*std::sin(3.36391997337341*x_91 - 8.0447998046875) - 0.302262063230224*std::sin(0.978640019893646*x_95 + 8.21375942230225) + 0.461064159471906*std::sin(1.16767990589142*x_98 - 7.76968002319336) - 9.06096349180828, 2) - 0.0134460145480009*std::exp(0.376559644937515*x_10) + 0.00445437899385073*std::exp(0.37863963842392*x_10) - 0.0209011508019832*std::exp(0.440959572792053*x_100) + 0.0143251400376437*std::exp(0.390479624271393*x_11) - 0.000502499903742849*std::exp(0.398079603910446*x_11) - 0.00575071425980868*std::exp(0.597919881343842*x_113) + 0.00201581753696634*std::exp(0.554959833621979*x_12) - 0.0129541980076808*std::exp(0.555519819259644*x_12) - 0.00281706063256737*std::exp(0.735919654369354*x_13) + 0.00111885343619452*std::exp(0.746319591999054*x_13) - 0.00266526685567188*std::exp(1.00799989700317*x_14) - 0.00104412147178297*std::exp(1.0595999956131*x_14) - 0.00060287773573527*std::exp(1.26079976558685*x_15) + 0.000246813993106994*std::exp(1.17711985111237*x_16) - 0.00260022346795251*std::exp(1.20743978023529*x_16) + 0.00653977252464675*std::exp(0.59999942779541*x_25) + 0.00692780997691546*std::exp(0.625759959220886*x_27) + 0.00194516149201018*std::exp(0.254479765892029*x_3) + 0.00846862811259687*std::exp(0.256639748811722*x_3) + 0.000928955086713019*std::exp(0.292959719896317*x_4) + 0.00886368830069077*std::exp(0.296639710664749*x_4) + 0.00128037031000255*std::exp(0.39087963104248*x_5) - 0.00722322795589581*std::exp(0.39199960231781*x_5) + 0.00321903760303473*std::exp(0.326959699392319*x_6) + 0.00510483814054755*std::exp(0.33751967549324*x_6) - 0.000716485810399107*std::exp(2.69063973426819*x_61) - 0.0187005657428624*std::exp(0.531519830226898*x_62) - 0.00165503575337379*std::exp(1.45271956920624*x_67) - 0.00305256224281065*std::exp(0.329039663076401*x_7) - 0.000611102432849987*std::exp(0.334319651126862*x_7) + 0.00407865741091086*std::exp(1.75759971141815*x_78) + 0.0110450941922012*std::exp(0.718479633331299*x_79) + 0.00485029166507817*std::exp(0.300399720668793*x_8) + 0.00979389882442295*std::exp(0.303359717130661*x_8) + 0.000524267191034893*std::exp(2.24656009674072*x_85) + 0.00140045278277049*std::exp(0.318799704313278*x_9) - 0.0108717153508143*std::exp(0.273759722709656*x_94) + 0.0260202324508254*std::exp(0.158639833331108*x_95) - 0.0517812836668435*std::exp(0.286399722099304*x_98) + 0.129555314779282*std::log(-0.434962661593694*x_1 - 0.280199950701428*x_100 - 0.466848390456891*x_101 + 0.0132307411769231*x_105 + 0.310484456316602*x_106 - 0.0502779543343717*x_108 + 0.195631939799799*x_109 - 0.0883089227195028*x_111 + 0.0600989745802618*x_112 - 0.288777465295416*x_113 + 0.0953559564567467*x_114 - 0.0891982883921591*x_116 - 0.000915552542605109*x_17 + 0.000241647860849601*x_18 - 0.000877196477784431*x_19 + 0.0319660198468114*x_2 - 0.00101557829954949*x_20 + 0.00224840837854856*x_21 + 0.000834329250571614*x_23 + 9.61429301584237e-5*x_24 - 0.000313445245934642*x_25 + 0.000264625670186132*x_26 + 0.0003215981970259*x_27 + 0.000274804104351079*x_28 + 0.000235999706433716*x_29 + 0.000175793871266959*x_30 + 0.192071670626574*x_31 + 0.002255342951956*x_32 - 0.433460529728631*x_33 + 0.478864353877991*x_34 - 0.43161911174732*x_35 + 0.207267040260085*x_36 + 0.457691597370907*x_37 - 0.486497379843161*x_38 + 0.232974836643146*x_39 - 0.620799714979071*x_40 + 0.404281305697599*x_41 - 0.254987530203025*x_42 - 0.574729868269155*x_43 + 0.595543012819872*x_44 + 0.183355292519499*x_45 - 0.311523988691224*x_46 + 0.600029798611347*x_47 + 0.117140916849446*x_48 - 0.197132617616397*x_49 - 0.221111961247697*x_50 - 0.368067892154822*x_51 - 0.185516189388936*x_52 - 0.264967487275586*x_53 + 0.198378612192864*x_54 + 0.488890902166265*x_55 + 0.362369849678051*x_56 + 0.570573332557135*x_57 - 0.49219624150949*x_58 + 0.137769213649287*x_59 + 0.283863991179049*x_60 - 0.00288065817194167*x_61 + 0.0110510555248193*x_62 - 0.00180330067267136*x_63 - 0.161754016984669*x_64 + 0.143167882186054*x_70 - 0.187205984320485*x_71 + 0.214830986790823*x_72 + 0.215315455057309*x_73 - 0.122888970000004*x_74 + 0.345018525891762*x_76 + 0.296587016988721*x_77 + 0.134516518545177*x_78 - 0.0052334207387127*x_83 - 0.0619008358398785*x_85 + 0.261464105068456*x_86 + 0.202314464369619*x_90 - 0.16171774482823*x_92 + 0.0890911751526005*x_93 + 0.0240022932098183*x_95 + 0.320031072524898*x_98 + 0.0041440293773867*std::pow(-5.06224012374878*x_110 - 6.06215953826904, 2) + 0.00293131971198732*std::pow(-4.91359996795654*x_120 - 9.95232009887695, 2) - 0.00227172019296357*std::pow(-9.72855949401855*x_66 - 3.0403196811676, 2) + 0.00190509345003313*std::pow(-9.34815979003906*x_68 - 7.77871990203857, 2) - 0.00167454323360651*std::pow(9.97795963287354*x_69 + 6.79199981689453, 2) - 0.00172808023052598*std::pow(-7.12376022338867*x_75 - 8.96928024291992, 2) + 0.00347790882225257*std::pow(-4.9159197807312*x_84 - 9.26272010803223, 2) - 0.00242745531466827*std::pow(-9.30655956268311*x_87 - 4.45368003845215, 2) - 0.00270539079586475*std::pow(-7.25176000595093*x_91 - 4.82791996002197, 2) - 0.383150714444063*std::exp(0.383119642734528*x_10) + 0.991642130471528*std::exp(0.226719796657562*x_102) - 0.632922576801688*std::exp(0.325359672307968*x_103) + 0.306425824758673*std::exp(0.290799736976624*x_104) + 0.333990809698747*std::exp(0.386399626731873*x_11) - 0.287575208364966*std::exp(0.310719698667526*x_115) + 1.88996121984222*std::exp(0.193679809570313*x_117) - 0.141998665858626*std::exp(0.563039839267731*x_12) + 0.164987386247412*std::exp(0.749999642372131*x_13) + 0.0297139888054131*std::exp(1.05879998207092*x_14) + 0.0946315186438223*std::exp(1.23447978496552*x_15) + 0.0374973343310101*std::exp(1.22799980640411*x_16) + 0.194480996628997*std::exp(0.294799715280533*x_22) + 0.336848997732443*std::exp(0.25279974937439*x_3) - 0.403147814276097*std::exp(0.291599720716476*x_4) - 0.0964982834556494*std::exp(0.395119607448578*x_5) + 0.0678252764077213*std::exp(0.332639664411545*x_6) - 0.0969476339024839*std::exp(1.60343992710114*x_65) + 0.209525059490487*std::exp(0.318159699440002*x_7) - 0.178066057124303*std::exp(0.960240066051483*x_79) + 0.541630883460777*std::exp(0.301119714975357*x_8) - 0.217601509515105*std::exp(1.0*x_80) - 0.113932369312262*std::exp(1.51543974876404*x_81) - 0.134084345785258*std::exp(1.54271984100342*x_82) + 0.23549534318429*std::exp(0.91376006603241*x_88) - 0.00870459386653902*std::exp(3.14815998077393*x_89) - 0.410229005060069*std::exp(0.326159685850143*x_9) + 0.567298704473206*std::exp(0.413439601659775*x_94) - 0.169722179325676*std::exp(0.486799538135529*x_99) + 0.528611011508008*std::sin(0.879599809646606*x_107 + 8.1738395690918) + 0.335981075229871*std::sin(1.02023994922638*x_118 - 1.39911961555481) + 0.776212109180033*std::sin(0.705280065536499*x_119 - 1.23703980445862) - 0.434704033515366*std::sin(1.2203197479248*x_96 - 7.82216024398804) - 0.738022675323023*std::sin(0.741679608821869*x_97 - 1.1515998840332) + 4.20312016531469 - 0.0182645684268265*std::exp(-2.33999991416931*x_67)) + 0.00558919399035109*std::sin(1.18831980228424*x_100 + 4.79408025741577) + 0.0103321121483299*std::sin(1.14503979682922*x_101 - 7.75903987884521) + 0.0109845232350958*std::sin(0.630799949169159*x_102 + 8.37952041625977) + 0.00955051416369832*std::sin(0.748079597949982*x_103 - 1.14335989952087) + 0.0149280760994968*std::sin(1.16319978237152*x_105 + 7.80984020233154) + 0.0205245062943868*std::sin(1.21303987503052*x_108 + 4.7760796546936) + 0.00566291925218279*std::sin(1.08351993560791*x_110 - 4.62207984924316) - 0.0143290235111724*std::sin(1.15967988967896*x_110 + 1.62808001041412) + 0.0261011393412352*std::sin(0.790319681167603*x_111 + 8.21183967590332) + 0.0072516101377425*std::sin(0.946880042552948*x_113 - 1.34919965267181) + 0.0188255596069693*std::sin(0.879999816417694*x_114 - 7.63015985488892) - 0.0255887028797928*std::sin(0.722879588603973*x_115 - 4.3699197769165) - 0.00116142075479238*std::sin(1.5771199464798*x_115 - 5.18495988845825) + 0.00264155452377786*std::sin(1.20855975151062*x_118 + 4.79016017913818) - 0.0165594925793357*std::sin(1.02160000801086*x_120 + 8.18144035339355) - 0.000852485511073139*std::sin(2.92903971672058*x_66 + 2.37191987037659) - 0.00144169537292604*std::sin(4.38775968551636*x_66 - 0.206719815731049) + 0.0104976304536435*std::sin(1.18479979038239*x_92 - 1.17983984947205) + 0.0102071973150121*std::sin(1.35383975505829*x_94 - 1.54991984367371) - 0.00479786064532299*std::sin(1.47087955474854*x_95 + 4.54888010025024) + 0.022162591024207*std::sin(0.986720025539398*x_99 - 1.37095963954926) - 0.344015002250671*std::sin(-0.0374991188715632*x_1 + 0.0198046473279945*x_101 + 0.0368249832534289*x_102 + 0.0511285352621879*x_104 - 0.0374942479042316*x_105 + 0.0113167615433482*x_106 + 0.0135558296501988*x_108 + 0.00200380419435663*x_111 - 0.0121826366090378*x_113 - 0.0198507678085867*x_114 - 0.0146751204989351*x_119 - 8.86130619408419e-5*x_12 - 7.45710296368236e-5*x_17 - 1.22444591204854e-5*x_18 - 3.754510084597e-5*x_19 + 0.00828281845196661*x_2 + 6.60709779032123e-5*x_20 + 6.13676141601179e-5*x_21 + 5.7693257350475e-6*x_27 - 2.8579383180865e-5*x_28 - 2.90664479484366e-5*x_29 - 4.03025718498904e-6*x_30 - 0.00897342887687319*x_31 + 0.0159925853653075*x_32 + 0.0362992137175135*x_33 + 0.00615056036333013*x_34 - 0.0521682120401444*x_35 - 0.00353653175802393*x_36 - 0.000546141855669659*x_37 - 0.0408802779713776*x_38 + 0.0581908331393689*x_39 + 0.0582503635003472*x_40 - 0.0357282505129018*x_41 + 0.0487779801716134*x_42 - 0.0249284931382441*x_43 - 0.0574235390076517*x_44 - 0.0325211277669225*x_45 + 0.0428784206975996*x_46 - 0.0450672832488295*x_47 + 0.0103584213309923*x_48 + 0.0720313295353157*x_50 + 0.0312535830752512*x_51 - 0.0501469583375282*x_53 + 0.0338919126209902*x_54 + 0.054699560130235*x_55 - 0.0423290745501825*x_56 + 0.0454243682718847*x_57 - 0.00543240584878134*x_58 + 0.0198856639470701*x_59 + 0.0430494362311266*x_60 - 0.0304982795373551*x_62 + 0.0200790373250393*x_63 - 0.0251282795447269*x_64 + 0.0219783602986411*x_65 + 0.0118975558570917*x_67 + 0.0210860218851418*x_68 - 0.0126790711343511*x_69 + 0.00756958010999805*x_70 + 0.00770322731991574*x_73 - 0.00870770748542603*x_76 - 0.0268880799949938*x_78 + 0.0112960956524931*x_79 - 0.0111669570873518*x_80 + 0.0289993762802123*x_81 - 0.028061843975907*x_82 + 0.0281355032559494*x_83 + 0.0114159570423541*x_85 - 0.0196342743825053*x_87 + 0.0262081418328177*x_88 - 0.00322591041262029*x_90 + 0.00691537429417489*x_91 - 0.00210342015574838*x_92 - 0.0514302519954801*x_94 + 0.0222685206219164*x_96 + 0.0263856365371405*x_98 + 5.7204429392224e-5*std::pow(-9.66063976287842*x_112 - 2.00952005386353, 2) + 0.00017425600574039*std::pow(-9.87936019897461*x_61 - 6.42767953872681, 2) - 8.29131190472933e-5*std::pow(-9.61999988555908*x_89 - 9.98340034484863, 2) + 0.000165888395893932*std::pow(-9.5272798538208*x_93 - 3.83999991416931, 2) - 0.030403049045687*std::exp(0.377839624881744*x_10) + 0.0774296338392244*std::exp(0.306799709796906*x_109) + 0.0486807545587176*std::exp(0.389359623193741*x_11) + 0.14335775174354*std::exp(0.204399809241295*x_110) + 0.135353117333512*std::exp(0.284239739179611*x_116) - 0.0183953882108015*std::exp(0.753279685974121*x_13) + 0.00793500013587005*std::exp(1.06831991672516*x_14) - 0.00152703499768033*std::exp(1.01175999641418*x_15) + 0.00370030313385625*std::exp(1.3155996799469*x_16) - 0.0213617651301463*std::exp(0.302559703588486*x_22) - 0.0229427851859372*std::exp(0.454799562692642*x_23) - 0.0424912400298497*std::exp(0.549359798431396*x_24) - 0.0311898304128432*std::exp(0.551279842853546*x_25) - 0.036995244372622*std::exp(0.568719863891602*x_26) + 0.0166888601127189*std::exp(0.254239767789841*x_3) + 0.0469691484556217*std::exp(0.290719717741013*x_4) - 0.00310095206232037*std::exp(0.375039637088776*x_5) - 0.0283565950087786*std::exp(0.336479663848877*x_6) + 0.0458367597065616*std::exp(0.322799682617188*x_7) + 0.00850999981143789*std::exp(1.67871999740601*x_72) - 0.0268896632333797*std::exp(0.906000137329102*x_74) - 0.0138380644814852*std::exp(1.59167993068695*x_75) - 0.0114788154259379*std::exp(1.82439970970154*x_77) - 0.0142339499689273*std::exp(0.296319723129272*x_8) + 0.0208898587738053*std::exp(0.453119575977325*x_84) + 0.0030709280317758*std::exp(2.19304013252258*x_86) - 0.0468207693367607*std::exp(0.321679681539536*x_9) + 0.000654315818607504*std::sin(8.43152046203613*x_100 + 6.17775964736938) + 0.0504036236674432*std::sin(1.13871991634369*x_103 - 4.73816013336182) + 0.00880913101269565*std::sin(2.24272012710571*x_107 + 0.576879858970642) + 0.0665050367606899*std::sin(0.942240059375763*x_115 - 7.77415990829468) - 0.0921756137360523*std::sin(0.655439972877502*x_117 - 7.4203200340271) - 0.0403549092057465*std::sin(0.86495977640152*x_118 - 1.23255980014801) - 0.0135796899465961*std::sin(1.39743959903717*x_120 + 7.59143972396851) + 0.00362267800658422*std::sin(3.70088005065918*x_66 - 5.78968000411987) + 0.014668631611473*std::sin(2.39439988136292*x_71 + 2.39183974266052) + 0.0680406993058327*std::sin(1.02312004566193*x_95 - 1.41087961196899) + 0.0370438295881921*std::sin(0.921440064907074*x_97 - 4.54048013687134) + 0.0528839864866955*std::sin(0.982560038566589*x_99 - 1.37295973300934) + 6.30773543530286 + 1.12537907947122*std::exp(-0.012639987282455*x_52) + 0.521347527934811*std::exp(-0.015439985319972*x_49)) + 0.113356379905793 + 0.0887132046721548*std::exp(-0.0245599746704102*x_32));
}

inline float score_6(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.000968609853976989*x_1 + 0.000147164735694911*x_101 + 0.00060570138997687*x_104 + 0.000569782258529112*x_105 + 0.000268302998919603*x_106 - 0.000339673775323058*x_107 - 0.000355994713202566*x_111 + 0.000413104236885145*x_112 + 0.00019465465285913*x_114 - 0.000479890914075845*x_117 + 8.33079701794853e-7*x_17 + 9.13366733876798e-8*x_18 - 4.89871929735849e-7*x_19 + 4.20530572819821e-5*x_2 - 3.61589763315552e-6*x_20 - 1.71556301230699e-6*x_21 + 6.49377439408681e-7*x_22 + 5.91983276145908e-7*x_23 - 9.73247034914131e-7*x_24 + 9.22788665363934e-7*x_26 - 8.27501694353367e-8*x_28 - 2.68667757823343e-7*x_29 + 1.56028016641587e-7*x_30 - 0.00028056862789798*x_33 - 0.000536095794718578*x_34 - 0.000592112976777992*x_35 + 0.000102431171843065*x_36 - 0.000884221459132753*x_37 - 0.000562630940251001*x_38 + 0.0010590580005842*x_39 + 0.000167624151628432*x_40 - 0.000234792493935107*x_41 + 0.000701111507835144*x_42 - 0.000201507249550014*x_43 - 1.49261972680915e-5*x_44 + 3.33511368135596e-5*x_45 - 0.000810645206868666*x_46 + 0.000208916031451253*x_47 - 0.0008017270982932*x_48 - 0.000951028824133921*x_49 + 0.000255058654817009*x_50 + 5.9315481427989e-5*x_51 + 0.000190630836364489*x_52 + 0.000898026697717201*x_53 + 0.000949939229068699*x_54 + 0.00102836672856609*x_55 + 0.000626823519330151*x_56 - 0.000231489853556831*x_57 + 0.000648234643580343*x_58 - 0.000206900957824837*x_59 - 0.000465666909949394*x_60 + 0.000198164815879811*x_62 - 3.86236794261663e-5*x_63 + 0.000595342341245882*x_64 - 0.000218847121156302*x_68 - 0.00058336168745147*x_69 - 0.000158405830297481*x_70 + 0.000466574249476448*x_71 - 0.00037007305454856*x_72 + 0.000150827372657621*x_75 - 0.000214590173318787*x_76 + 0.00025365269279284*x_78 + 6.5392108817596e-5*x_79 + 0.000400677066502427*x_81 + 0.000416129857795744*x_82 + 0.00014167284260079*x_83 + 0.000499967044989194*x_84 + 0.000119283394437066*x_86 + 6.24784734828491e-5*x_87 - 0.000191185716048171*x_88 - 0.000548593975461223*x_89 - 2.40679109785637e-5*x_90 - 0.000335471188483408*x_92 - 0.000296741281578252*x_93 - 0.000652096695924187*x_96 - 0.00068912840572894*x_97 + 0.00093509293092621*x_98 + 0.000228314115551686*x_99 - 0.000269607410107537*std::pow(8.27943992614746 - 0.201439797878265*x_31, 2) + 1.06134146955454e-6*std::pow(-9.83440017700195*x_108 - 4.4474401473999, 2) + 9.91417730140519e-7*std::pow(-9.9629602432251*x_109 - 3.39999985694885, 2) + 8.10563573157812e-7*std::pow(-9.99868011474609*x_116 - 3.37999987602234, 2) + 3.13628714689685e-5*std::pow(-2.03575992584229*x_119 - 5.2993597984314, 2) - 3.54276635390805e-6*std::pow(-5.40767955780029*x_120 - 9.19095993041992, 2) - 3.70693221279061e-6*std::pow(-8.49944019317627*x_65 - 8.27271938323975, 2) - 3.0455312925164e-6*std::pow(-9.9993200302124*x_73 - 6.0, 2) + 2.85598854807172e-6*std::pow(-8.14783954620361*x_74 - 9.39192008972168, 2) - 2.54296737475916e-6*std::pow(-9.59967994689941*x_77 - 1.02799999713898, 2) + 4.07568489204776e-6*std::pow(-8.69464015960693*x_80 - 7.84104013442993, 2) + 1.14950150925474e-6*std::pow(-9.93639945983887*x_91 - 4.7960000038147, 2) - 0.000581741333007813*std::pow(-0.497936822117285*x_1 + 0.398307006390429*x_100 + 0.164299486668717*x_104 - 0.073930931047922*x_108 - 0.0455770485136957*x_111 + 0.189081937503373*x_113 + 0.21162203408716*x_114 - 0.253347640321753*x_115 - 0.0266993824764634*x_116 + 0.0236714710311254*x_120 + 0.00106189423589561*x_17 - 0.000118516992800671*x_18 - 0.000462818104673065*x_19 + 0.210683614819485*x_2 - 0.00203956423592687*x_20 - 0.00131796060757184*x_21 - 0.0380612562955469*x_32 - 0.180299026824038*x_33 - 0.534585903295828*x_34 + 0.771564829303321*x_35 + 0.153595703085999*x_36 - 0.669959125034306*x_37 - 0.467742937148125*x_38 - 0.440091139476674*x_39 + 0.886613537406276*x_40 + 0.752451786661686*x_41 - 0.120152354883368*x_42 + 0.579730192407347*x_43 + 0.0906158018253551*x_44 - 0.321507730638236*x_45 + 0.750311110745957*x_46 - 0.588001471580689*x_47 + 0.587724884611786*x_48 - 0.498369016316673*x_49 + 0.118866691996547*x_50 - 0.501976538365337*x_51 - 0.434380369127675*x_52 - 0.0348207630192962*x_53 - 0.527283165790535*x_54 - 0.457619568458507*x_55 + 0.197963505563035*x_56 + 0.365939798960626*x_57 - 0.576513832038777*x_58 + 0.288649146091224*x_59 + 0.37239959134851*x_60 + 0.00642809578792168*x_62 - 0.0368963357244136*x_63 + 0.15331503727646*x_65 - 0.183677847119407*x_67 + 0.149347087904492*x_69 + 0.191097558270289*x_70 + 0.204625604912219*x_72 - 0.30726424585441*x_73 + 0.0066857171038915*x_74 + 0.136445537547468*x_75 - 0.0212918762946043*x_76 - 0.150260782952785*x_77 + 0.0191356336750076*x_80 + 0.0535167775174262*x_85 + 0.330153820059433*x_87 - 0.011353378871849*x_88 - 0.248883296297882*x_93 + 0.155357906184152*x_94 + 0.212268952253436*x_96 - 0.170831580532721*x_99 + 0.000790867863931753*std::pow(2.20000004768372 - 9.95748043060303*x_86, 2) + 0.10882048601158*std::pow(8.37551975250244 - 0.210639804601669*x_31, 2) + 0.0153217097491476*std::pow(-2.63048005104065*x_102 - 7.50127983093262, 2) + 0.00170031571135962*std::pow(-9.03791999816895*x_107 - 8.22247982025146, 2) - 0.00266033824399278*std::pow(-8.81511974334717*x_61 - 9.24431991577148, 2) + 0.00267023409003275*std::pow(-8.96744060516357*x_78 - 5.9543194770813, 2) + 0.00214410640309812*std::pow(-9.76488018035889*x_81 - 6.16847991943359, 2) - 0.0029932889488348*std::pow(-8.79600048065186*x_82 - 6.76008033752441, 2) - 0.00218659831201842*std::pow(-8.73871994018555*x_84 - 6.90944004058838, 2) - 0.000751692246729094*std::pow(-9.98104000091553*x_89 - 6.3045597076416, 2) + 0.00146854367754788*std::pow(9.99804019927979*x_90 + 6.80000019073486, 2) + 0.00233298220448122*std::pow(-9.12360000610352*x_92 - 4.86263990402222, 2) + 0.111693227740617*std::exp(0.383999645709991*x_10) + 0.0695219458905165*std::exp(0.390159606933594*x_11) - 0.511171865327821*std::exp(0.438959568738937*x_112) - 2.16473604178591*std::exp(0.17751981317997*x_118) - 0.19597327345876*std::exp(0.559599876403809*x_12) - 0.236395350961382*std::exp(0.756479620933533*x_13) + 0.126669175363*std::exp(1.05224001407623*x_14) - 0.0619787424012733*std::exp(1.22631978988647*x_15) - 0.109013436466105*std::exp(1.24463975429535*x_16) - 0.198012646050154*std::exp(0.317999690771103*x_22) - 0.443630321727361*std::exp(0.509839773178101*x_23) - 0.493813483012742*std::exp(0.603119909763336*x_24) - 0.417377428219629*std::exp(0.649999976158142*x_25) + 0.445733599094172*std::exp(0.779999673366547*x_26) - 0.317867264856407*std::exp(0.663999974727631*x_27) + 1.55245428495299*std::exp(0.900000095367432*x_28) + 1.63284601371344*std::exp(1.0239999294281*x_29) + 0.305998926601269*std::exp(0.253599762916565*x_3) + 1.88386545929964*std::exp(1.0*x_30) - 0.356712304028813*std::exp(0.291999727487564*x_4) + 0.412696151603525*std::exp(0.391519606113434*x_5) + 0.71066726327871*std::exp(0.33903968334198*x_6) + 0.12583426077123*std::exp(1.52415978908539*x_64) + 0.263752245728881*std::exp(0.965040028095245*x_68) + 0.0192995604391964*std::exp(0.319119691848755*x_7) - 0.544969229189843*std::exp(0.763999700546265*x_71) - 0.447670451602713*std::exp(0.5971999168396*x_79) + 0.561942731338207*std::exp(0.302559703588486*x_8) - 0.0510834345077202*std::exp(2.54519987106323*x_83) - 0.422127352399291*std::exp(0.324639678001404*x_9) - 0.905963790596251*std::exp(0.367199659347534*x_97) - 0.681257450743871*std::sin(0.997919976711273*x_101 + 8.19495964050293) + 0.446449653354232*std::sin(1.221599817276*x_103 + 1.38991963863373) + 0.913997387702771*std::sin(0.743679583072662*x_105 - 4.37695980072021) + 0.595119775501971*std::sin(0.938000082969666*x_106 - 1.35967969894409) - 0.861733785228033*std::sin(0.799759685993195*x_109 - 4.20560026168823) - 0.713708905800075*std::sin(0.914640069007874*x_110 - 1.37599968910217) + 0.125459671829235*std::sin(1.37159967422485*x_117 - 4.98199987411499) + 0.375560657694738*std::sin(1.09279990196228*x_119 + 1.55415987968445) + 0.0216551293497143*std::sin(5.21920013427734*x_66 - 9.41256046295166) + 0.0664472861727998*std::sin(3.36391997337341*x_91 - 8.0447998046875) - 0.452104831226009*std::sin(0.978640019893646*x_95 + 8.21375942230225) + 0.689631149125184*std::sin(1.16767990589142*x_98 - 7.76968002319336) - 10.7216600614518, 2) - 0.000666322826403852*std::exp(0.37863963842392*x_10) + 7.51680888832826e-5*std::exp(0.398079603910446*x_11) - 0.000301542648391646*std::exp(0.554959833621979*x_12) - 0.000167367344576198*std::exp(0.746319591999054*x_13) + 0.000156188319662027*std::exp(1.0595999956131*x_14) + 9.01834346394058e-5*std::exp(1.26079976558685*x_15) - 3.69204770654018e-5*std::exp(1.17711985111237*x_16) - 0.000978273227014707*std::exp(0.59999942779541*x_25) - 0.00103631907634706*std::exp(0.625759959220886*x_27) - 0.000290973333198058*std::exp(0.254479765892029*x_3) - 0.000138960779905653*std::exp(0.292959719896317*x_4) - 0.000191528373535848*std::exp(0.39087963104248*x_5) - 0.000763623881766584*std::exp(0.33751967549324*x_6) + 0.000107177869445427*std::exp(2.69063973426819*x_61) + 0.000247573927254472*std::exp(1.45271956920624*x_67) + 9.14137528129064e-5*std::exp(0.334319651126862*x_7) - 0.000725546716078609*std::exp(0.300399720668793*x_8) - 7.84242196282422e-5*std::exp(2.24656009674072*x_85) - 0.000209491302322724*std::exp(0.318799704313278*x_9) + 0.00162628103949241*std::exp(0.273759722709656*x_94) - 0.0038923214334151*std::exp(0.158639833331108*x_95) + 0.114697835261628*std::exp(-0.0202171330870314*x_1 - 0.0409070765746158*x_103 - 0.0348760462840943*x_104 - 0.000160295783440198*x_107 + 0.000770068380379604*x_109 - 0.0329954336572352*x_112 + 0.00426877442490311*x_116 + 0.0178155033726829*x_117 + 0.0303590709588481*x_118 + 0.018874021690555*x_119 + 0.000224506674026609*x_15 - 4.52503859695204e-5*x_17 + 8.74939505653503e-5*x_18 + 0.000314426984724271*x_19 + 0.0215002559156443*x_2 + 0.000135626803918205*x_20 + 0.000289273259926381*x_21 + 5.55979394381277e-6*x_22 + 6.53958859699892e-6*x_23 + 0.000233198922438279*x_24 - 8.08304903627234e-6*x_25 + 9.63113954622453e-5*x_26 + 1.21626276752365e-5*x_27 + 9.27478318870337e-5*x_28 + 6.48086066343559e-5*x_29 + 9.22720506060013e-5*x_30 + 0.0320909086262132*x_31 + 0.0274416315711001*x_32 + 0.0496262924514289*x_33 - 0.0203369304844444*x_34 - 0.0208450844658719*x_35 - 0.071690193454533*x_36 + 0.0492764453219706*x_37 - 0.00389897310370304*x_38 - 0.056227719106452*x_39 + 0.0427830578244786*x_40 + 0.036037278562056*x_41 - 0.0442519400232224*x_42 - 0.0279398349789028*x_43 - 0.0388881280369335*x_44 + 0.0568083959515863*x_45 - 0.0888752796744903*x_46 + 0.0493088238847068*x_47 + 0.0548616429146598*x_48 - 0.0789833000711685*x_49 - 0.0241283267766642*x_50 + 0.0130979448058069*x_51 + 0.035900906902141*x_52 - 0.0153448335936097*x_53 + 0.0333603958499552*x_54 + 0.0441068943502604*x_55 + 0.0817123786260873*x_56 + 0.0107836620926923*x_57 + 0.0492237659135994*x_58 + 0.00159422420263523*x_59 - 0.0524309120609158*x_60 + 0.00474406874759658*x_61 + 0.00974774913145958*x_63 - 0.0224176008825509*x_64 - 0.0150293045932298*x_65 + 0.0224418621742352*x_68 + 0.0249710190410676*x_69 - 0.0257594903901353*x_70 + 0.0112984951867387*x_71 + 0.0190877301270431*x_72 + 0.0128710218876585*x_73 + 0.00594586897011022*x_74 - 0.0126129448412194*x_75 + 0.0323253708712679*x_77 + 0.0352279224053599*x_80 - 0.0185271232246584*x_81 - 0.0391603154393662*x_82 - 0.0161175236698679*x_83 + 0.0306726366229721*x_84 + 0.00636914562107997*x_85 - 0.0168786365298454*x_87 + 0.00372952578759455*x_88 + 0.000680823379239264*x_89 + 0.00027403576136719*x_9 + 0.0206599728790671*x_90 - 0.0505235669778042*x_91 + 0.029066436471412*x_93 + 0.0176663059619936*x_96 - 0.00971992874705733*x_97 + 0.000196146962178098*std::pow(-5.74399995803833*x_102 - 9.33600044250488, 2) - 0.000946728273257015*std::pow(-3.9255998134613*x_106 - 6.27424001693726, 2) - 0.000287801070819613*std::pow(-9.40464019775391*x_67 - 5.20007991790771, 2) + 0.000251224931980144*std::pow(-8.10671997070313*x_76 - 6.87735986709595, 2) - 0.00051245172178303*std::pow(-8.6048002243042*x_86 - 5.2065601348877, 2) + 0.0501028218269749*std::exp(0.376559644937515*x_10) + 0.0778823071232059*std::exp(0.440959572792053*x_100) - 0.0533786376915111*std::exp(0.390479624271393*x_11) + 0.0214284322620992*std::exp(0.597919881343842*x_113) + 0.0482702047043882*std::exp(0.555519819259644*x_12) + 0.0104969904982211*std::exp(0.735919654369354*x_13) + 0.00993137333849781*std::exp(1.00799989700317*x_14) + 0.00968900730101567*std::exp(1.20743978023529*x_16) - 0.0315559799470421*std::exp(0.256639748811722*x_3) - 0.0330280615177066*std::exp(0.296639710664749*x_4) + 0.0269153437249314*std::exp(0.39199960231781*x_5) - 0.0119948455286448*std::exp(0.326959699392319*x_6) + 0.069682440855128*std::exp(0.531519830226898*x_62) + 0.0113745215447526*std::exp(0.329039663076401*x_7) - 0.0151979789120874*std::exp(1.75759971141815*x_78) - 0.0411564619685979*std::exp(0.718479633331299*x_79) - 0.0364942315092496*std::exp(0.303359717130661*x_8) + 0.192948506806252*std::exp(0.286399722099304*x_98) - 0.0384997333013493*std::sin(1.14503979682922*x_101 - 7.75903987884521) - 0.0556253107091731*std::sin(1.16319978237152*x_105 + 7.80984020233154) - 0.0764788464480115*std::sin(1.21303987503052*x_108 + 4.7760796546936) + 0.0533931083721417*std::sin(1.15967988967896*x_110 + 1.62808001041412) - 0.0972586136380005*std::sin(0.790319681167603*x_111 + 8.21183967590332) - 0.070148195616917*std::sin(0.879999816417694*x_114 - 7.63015985488892) + 0.09534916213223*std::sin(0.722879588603973*x_115 - 4.3699197769165) + 0.0617043290623931*std::sin(1.02160000801086*x_120 + 8.18144035339355) + 0.00537207557976552*std::sin(4.38775968551636*x_66 - 0.206719815731049) - 0.0391164910871322*std::sin(1.18479979038239*x_92 - 1.17983984947205) - 0.0380342730257466*std::sin(1.35383975505829*x_94 - 1.54991984367371) + 0.0178778891101983*std::sin(1.47087955474854*x_95 + 4.54888010025024) - 0.0825827121743705*std::sin(0.986720025539398*x_99 - 1.37095963954926)) + 0.444186584738976*std::exp(-0.013269410336801*x_1 + 0.00700805778586106*x_101 + 0.013030861207945*x_102 + 0.0180923054922247*x_104 - 0.0132676866999208*x_105 + 0.00400454082979248*x_106 + 0.00479685580614182*x_108 + 0.000709064663108246*x_111 - 0.00431093873707111*x_113 - 0.00702437794484945*x_114 - 0.00519292723408601*x_119 - 3.13565522464868e-5*x_12 - 2.6387649130581e-5*x_17 - 4.33281520502919e-6*x_18 - 1.32856814840935e-5*x_19 + 0.00293095198212026*x_2 + 2.33798271408527e-5*x_20 + 2.17154983419784e-5*x_21 + 2.04152931718792e-6*x_27 - 1.01130792939017e-5*x_28 - 1.02854316705974e-5*x_29 - 1.42614381243541e-6*x_30 - 0.00317533087385756*x_31 + 0.00565912437263987*x_32 + 0.0128448127906863*x_33 + 0.00217643271944136*x_34 - 0.0184602047442471*x_35 - 0.00125143449975659*x_36 - 0.000193257351187477*x_37 - 0.0144658647831872*x_38 + 0.0205913649707688*x_39 + 0.0206124303400652*x_40 - 0.0126427721754079*x_41 + 0.0172605398146652*x_42 - 0.00882117805654187*x_43 - 0.0203198508395262*x_44 - 0.0115079021038565*x_45 + 0.0151729260833885*x_46 - 0.0159474753591357*x_47 + 0.00366542327442905*x_48 + 0.0254889527400138*x_50 + 0.0110593696812247*x_51 - 0.0177449654111135*x_53 + 0.011992967013632*x_54 + 0.0193559456982609*x_55 - 0.0149785348639046*x_56 + 0.0160738332000299*x_57 - 0.00192230709661238*x_58 + 0.00703672626648048*x_59 + 0.0152334415129939*x_60 - 0.0107920985326009*x_62 + 0.00710515322630518*x_63 - 0.00889187432587063*x_64 + 0.00777724624228129*x_65 + 0.00421006027404234*x_67 + 0.00746148403441266*x_68 - 0.00448660668927818*x_69 + 0.00267856599246712*x_70 + 0.00272585829485002*x_73 - 0.00308130289974823*x_76 - 0.00951459600542418*x_78 + 0.00399722801301212*x_79 - 0.00395153113631925*x_80 + 0.0102616977399231*x_81 - 0.00992994325543931*x_82 + 0.00995600827353598*x_83 + 0.00403964207535458*x_85 - 0.00694776974198117*x_87 + 0.00927399359264571*x_88 - 0.00114151826130717*x_90 + 0.00244706920864636*x_91 - 0.000744314693177738*x_92 - 0.0181990707512497*x_94 + 0.00787992215864579*x_96 + 0.00933680173681397*x_98 + 2.02423168738401e-5*std::pow(-9.66063976287842*x_112 - 2.00952005386353, 2) + 6.16621006947087e-5*std::pow(-9.87936019897461*x_61 - 6.42767953872681, 2) - 2.93395746900306e-5*std::pow(-9.61999988555908*x_89 - 9.98340034484863, 2) + 5.87011444927454e-5*std::pow(-9.5272798538208*x_93 - 3.83999991416931, 2) - 0.0107584003415888*std::exp(0.377839624881744*x_10) + 0.0273991926892998*std::exp(0.306799709796906*x_109) + 0.0172261356315381*std::exp(0.389359623193741*x_11) + 0.0507284674971079*std::exp(0.204399809241295*x_110) + 0.0478959535133384*std::exp(0.284239739179611*x_116) - 0.00650937840192778*std::exp(0.753279685974121*x_13) + 0.00280787325126399*std::exp(1.06831991672516*x_14) - 0.00054035546947857*std::exp(1.01175999641418*x_15) + 0.00130938651710358*std::exp(1.3155996799469*x_16) - 0.00755905833417416*std::exp(0.302559703588486*x_22) - 0.00811851691619729*std::exp(0.454799562692642*x_23) - 0.0150359186200279*std::exp(0.549359798431396*x_24) - 0.0110368102114821*std::exp(0.551279842853546*x_25) - 0.0130911096810549*std::exp(0.568719863891602*x_26) + 0.00590550763732933*std::exp(0.254239767789841*x_3) + 0.0166204679678593*std::exp(0.290719717741013*x_4) - 0.00109730059233157*std::exp(0.375039637088776*x_5) - 0.01003424363689*std::exp(0.336479663848877*x_6) + 0.0162197617266402*std::exp(0.322799682617188*x_7) + 0.00301134220915525*std::exp(1.67871999740601*x_72) - 0.00951515624898284*std::exp(0.906000137329102*x_74) - 0.00489672721380088*std::exp(1.59167993068695*x_75) - 0.00406188509625697*std::exp(1.82439970970154*x_77) - 0.00503681495818888*std::exp(0.296319723129272*x_8) + 0.00739206990161177*std::exp(0.453119575977325*x_84) + 0.00108667631119512*std::exp(2.19304013252258*x_86) - 0.0165679626431256*std::exp(0.321679681539536*x_9) + 0.000231535709324278*std::sin(8.43152046203613*x_100 + 6.17775964736938) + 0.017835788814019*std::sin(1.13871991634369*x_103 - 4.73816013336182) + 0.00311719255373599*std::sin(2.24272012710571*x_107 + 0.576879858970642) + 0.0235334228855932*std::sin(0.942240059375763*x_115 - 7.77415990829468) - 0.0326171941772657*std::sin(0.655439972877502*x_117 - 7.4203200340271) - 0.0142799581822034*std::sin(0.86495977640152*x_118 - 1.23255980014801) - 0.00480529899289345*std::sin(1.39743959903717*x_120 + 7.59143972396851) + 0.00128191814725342*std::sin(3.70088005065918*x_66 - 5.78968000411987) + 0.00519063108119083*std::sin(2.39439988136292*x_71 + 2.39183974266052) + 0.0240768312926054*std::sin(1.02312004566193*x_95 - 1.41087961196899) + 0.0131083020093309*std::sin(0.921440064907074*x_97 - 4.54048013687134) + 0.0187134881579831*std::sin(0.982560038566589*x_99 - 1.37295973300934) + 0.39822580474762*std::exp(-0.012639987282455*x_52) + 0.184483648800877*std::exp(-0.015439985319972*x_49)) - 0.109754091303133*std::exp(0.121199201916008*x_1 + 0.0780756910891823*x_100 + 0.130083929806375*x_101 - 0.00368665040241603*x_105 - 0.0865142496944921*x_106 + 0.0140095885862211*x_108 - 0.0545114260753822*x_109 + 0.0246066430540284*x_111 - 0.0167461448953111*x_112 + 0.080465753535934*x_113 - 0.0265702480717551*x_114 + 0.0248544583707328*x_116 + 0.000255112098747374*x_17 - 6.73334298911388e-5*x_18 + 0.000244424458507469*x_19 - 0.00890710039263972*x_2 + 0.000282983552973548*x_20 - 0.000626502744081291*x_21 - 0.000232479815471882*x_23 - 2.67895326057945e-5*x_24 + 8.73392523221496e-5*x_25 - 7.37360303882987e-5*x_26 - 8.96110132174418e-5*x_27 - 7.65721775026885e-5*x_28 - 6.57596124857657e-5*x_29 - 4.89836916603735e-5*x_30 - 0.0535193828024723*x_31 - 0.000628435012840935*x_32 + 0.12078064372862*x_33 - 0.133432091167061*x_34 + 0.120267545917164*x_35 - 0.0577534627247635*x_36 - 0.127532455594623*x_37 + 0.135558978683781*x_38 - 0.0649167543811789*x_39 + 0.172981353685554*x_40 - 0.112650063848195*x_41 + 0.0710504323426473*x_42 + 0.160144323874359*x_43 - 0.165943756174288*x_44 - 0.0510906270414491*x_45 + 0.0868039078773543*x_46 - 0.16719396660638*x_47 - 0.0326404698321538*x_48 + 0.054929579102675*x_49 + 0.0616112498923807*x_50 + 0.102559457900647*x_51 + 0.0516927453360147*x_52 + 0.0738312752497572*x_53 - 0.0552767664858544*x_54 - 0.136225916379686*x_55 - 0.100971739547678*x_56 - 0.158986135239992*x_57 + 0.137146925297998*x_58 - 0.0383883956423068*x_59 - 0.0790966494860445*x_60 + 0.000802674579360304*x_61 - 0.00307929674935806*x_62 + 0.000502476698900026*x_63 + 0.0450715877390946*x_64 - 0.0398926956106485*x_70 + 0.0521635944805254*x_71 - 0.0598611017563574*x_72 - 0.0599960953372698*x_73 + 0.0342421232979153*x_74 - 0.0961369185830947*x_76 - 0.0826418286709409*x_77 - 0.0374820556607328*x_78 + 0.00145825486375923*x_83 + 0.017248220512167*x_85 - 0.0728550831187933*x_86 - 0.0563734632481334*x_90 + 0.0450614807648635*x_92 - 0.0248246120407017*x_93 - 0.00668806552388948*x_95 - 0.0891743453017899*x_98 - 0.0011547038346131*std::pow(-5.06224012374878*x_110 - 6.06215953826904, 2) - 0.000816791051332567*std::pow(-4.91359996795654*x_120 - 9.95232009887695, 2) + 0.000632998412679511*std::pow(-9.72855949401855*x_66 - 3.0403196811676, 2) - 0.000530840520594187*std::pow(-9.34815979003906*x_68 - 7.77871990203857, 2) + 0.000466599369112152*std::pow(9.97795963287354*x_69 + 6.79199981689453, 2) + 0.000481517066359648*std::pow(-7.12376022338867*x_75 - 8.96928024291992, 2) - 0.000969094156379344*std::pow(-4.9159197807312*x_84 - 9.26272010803223, 2) + 0.000676392878751025*std::pow(-9.30655956268311*x_87 - 4.45368003845215, 2) + 0.000753837591779338*std::pow(-7.25176000595093*x_91 - 4.82791996002197, 2) + 0.106762177318905*std::exp(0.383119642734528*x_10) - 0.276313912461081*std::exp(0.226719796657562*x_102) + 0.176359301513204*std::exp(0.325359672307968*x_103) - 0.0853833413450495*std::exp(0.290799736976624*x_104) - 0.0930641251698563*std::exp(0.386399626731873*x_11) + 0.0801307533316991*std::exp(0.310719698667526*x_115) - 0.526624034021229*std::exp(0.193679809570313*x_117) + 0.0395669019316411*std::exp(0.563039839267731*x_12) - 0.0459725427146513*std::exp(0.749999642372131*x_13) - 0.00827958821973853*std::exp(1.05879998207092*x_14) - 0.026368388711132*std::exp(1.23447978496552*x_15) - 0.0104483611955211*std::exp(1.22799980640411*x_16) - 0.0541907240793977*std::exp(0.294799715280533*x_22) - 0.0938605386075998*std::exp(0.25279974937439*x_3) + 0.112334224656019*std::exp(0.291599720716476*x_4) + 0.0268885492337142*std::exp(0.395119607448578*x_5) - 0.0188990230568969*std::exp(0.332639664411545*x_6) + 0.0270137574879984*std::exp(1.60343992710114*x_65) - 0.0583826434632504*std::exp(0.318159699440002*x_7) + 0.049616819827067*std::exp(0.960240066051483*x_79) - 0.150921530983799*std::exp(0.301119714975357*x_8) + 0.0606330878892426*std::exp(1.0*x_80) + 0.0317464312510225*std::exp(1.51543974876404*x_81) + 0.0373616338447543*std::exp(1.54271984100342*x_82) - 0.0656190753116501*std::exp(0.91376006603241*x_88) + 0.00242547216756962*std::exp(3.14815998077393*x_89) + 0.114307347287943*std::exp(0.326159685850143*x_9) - 0.158073683792114*std::exp(0.413439601659775*x_94) + 0.0472918585847088*std::exp(0.486799538135529*x_99) - 0.147293637766615*std::sin(0.879599809646606*x_107 + 8.1738395690918) - 0.0936186982752565*std::sin(1.02023994922638*x_118 - 1.39911961555481) - 0.216285894070695*std::sin(0.705280065536499*x_119 - 1.23703980445862) + 0.121127137071243*std::sin(1.2203197479248*x_96 - 7.82216024398804) + 0.205644684344474*std::sin(0.741679608821869*x_97 - 1.1515998840332) + 0.00508928998310088*std::exp(-2.33999991416931*x_67)) - 0.000836077833096696*std::sin(1.18831980228424*x_100 + 4.79408025741577) - 0.00164315577520728*std::sin(0.630799949169159*x_102 + 8.37952041625977) - 0.00142864484588101*std::sin(0.748079597949982*x_103 - 1.14335989952087) - 0.000847106267118337*std::sin(1.08351993560791*x_110 - 4.62207984924316) - 0.00108475578068904*std::sin(0.946880042552948*x_113 - 1.34919965267181) + 0.000173734915921096*std::sin(1.5771199464798*x_115 - 5.18495988845825) - 0.000395145558744193*std::sin(1.20855975151062*x_118 + 4.79016017913818) + 0.000127521828742178*std::sin(2.92903971672058*x_66 + 2.37191987037659) - 0.923958681717621 - 0.0132704543906338*std::exp(-0.0245599746704102*x_32));
}

inline float score_7(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.00287059397708505*x_1 + 0.000539769044113869*x_101 + 0.00138007425994978*x_103 + 0.00339819079733238*x_104 + 0.00208984050144246*x_105 + 0.000984078506143957*x_106 - 0.00124044351140413*x_107 - 2.59796504456782e-5*x_109 - 0.00130571311902669*x_111 + 0.00262833940978066*x_112 + 0.000713951989992417*x_114 - 0.000144014830651487*x_116 - 0.002361176359467*x_117 - 0.00102421820121691*x_118 - 0.000636749279048511*x_119 - 7.5741389499176e-6*x_15 + 4.58216335358481e-6*x_17 - 2.61676321480087e-6*x_18 - 1.24045097253427e-5*x_19 - 0.000571108346745656*x_2 - 1.78379614452547e-5*x_20 - 1.60514782792269e-5*x_21 + 2.19420903613038e-6*x_22 + 1.95064426995511e-6*x_23 - 1.14370514270607e-5*x_24 + 2.72696287561002e-7*x_25 + 1.35353920628267e-7*x_26 - 4.10328255976195e-7*x_27 - 3.43252603361805e-6*x_28 - 3.1718519968366e-6*x_29 - 2.54068693765558e-6*x_30 - 0.00108264487912391*x_31 - 0.000925793103626505*x_32 - 0.00270329901948023*x_33 - 0.00128018254071651*x_34 - 0.00146849819181976*x_35 + 0.00279429423543024*x_36 - 0.00490556687327236*x_37 - 0.0019320720686101*x_38 + 0.00578134403427797*x_39 - 0.000828554039156222*x_40 - 0.00207695189065811*x_41 + 0.00406444762117634*x_42 + 0.000203515035658585*x_43 + 0.00125721525076712*x_44 - 0.00179420914889908*x_45 + 2.50936813778833e-5*x_46 - 0.000897262708013101*x_47 - 0.00479142179933412*x_48 - 0.000823527492236251*x_49 + 0.00174951383057364*x_50 - 0.000224326264092508*x_51 - 0.0005119885817742*x_52 + 0.00381145723149397*x_53 + 0.00235870232867768*x_54 + 0.0022838051907962*x_55 - 0.000457659221764723*x_56 - 0.00121286205167597*x_57 + 0.000716934387957305*x_58 - 0.000812652878394558*x_59 + 6.08842247704002e-5*x_60 - 0.000160049744792885*x_61 + 0.000726826523619035*x_62 - 0.000470521423917244*x_63 + 0.00293988780090257*x_64 + 0.000507040789781893*x_65 - 0.00155980166834723*x_68 - 0.00298208948592689*x_69 + 0.000288044031194745*x_70 + 0.00133012022697844*x_71 - 0.00200130860967172*x_72 - 0.000434227216750811*x_73 - 0.000200594650260957*x_74 + 0.000978723340361091*x_75 - 0.000787071251693326*x_76 - 0.00109055488727958*x_77 + 0.000930344289881632*x_78 + 0.000239844388687231*x_79 - 0.00118847771618356*x_80 + 0.00209464454749816*x_81 + 0.00284742018952867*x_82 + 0.00106337977454555*x_83 + 0.000798976196184566*x_84 - 0.000214874654107616*x_85 + 0.000437506196643678*x_86 + 0.000798589141616049*x_87 - 0.000827050967326038*x_88 - 0.0020350951809648*x_89 - 9.24509234676718e-6*x_9 - 0.000785277568370632*x_90 + 0.00170450396717384*x_91 - 0.00123043718238876*x_92 - 0.00206899293400646*x_93 - 0.00298775720623515*x_96 - 0.00219965747496085*x_97 + 0.00342972258333713*x_98 + 0.00083740776162926*x_99 - 0.000988862809779729*std::pow(8.27943992614746 - 0.201439797878265*x_31, 2) - 6.6173727466341e-6*std::pow(-5.74399995803833*x_102 - 9.33600044250488, 2) + 3.19395916426713e-5*std::pow(-3.9255998134613*x_106 - 6.27424001693726, 2) + 3.89277545190926e-6*std::pow(-9.83440017700195*x_108 - 4.4474401473999, 2) + 3.63631000313069e-6*std::pow(-9.9629602432251*x_109 - 3.39999985694885, 2) + 2.97297530560539e-6*std::pow(-9.99868011474609*x_116 - 3.37999987602234, 2) + 0.000115032362022967*std::pow(-2.03575992584229*x_119 - 5.2993597984314, 2) - 1.2994115739331e-5*std::pow(-5.40767955780029*x_120 - 9.19095993041992, 2) - 1.35962412981936e-5*std::pow(-8.49944019317627*x_65 - 8.27271938323975, 2) + 9.70948997295496e-6*std::pow(-9.40464019775391*x_67 - 5.20007991790771, 2) - 1.11703629732901e-5*std::pow(-9.9993200302124*x_73 - 6.0, 2) + 1.04751603793771e-5*std::pow(-8.14783954620361*x_74 - 9.39192008972168, 2) - 8.47552773542796e-6*std::pow(-8.10671997070313*x_76 - 6.87735986709595, 2) - 9.32706509208897e-6*std::pow(-9.59967994689941*x_77 - 1.02799999713898, 2) + 1.49487479313703e-5*std::pow(-8.69464015960693*x_80 - 7.84104013442993, 2) + 1.72884862453985e-5*std::pow(-8.6048002243042*x_86 - 5.2065601348877, 2) + 4.21612778311356e-6*std::pow(-9.93639945983887*x_91 - 4.7960000038147, 2) - 0.0016903093680658*std::exp(0.376559644937515*x_10) - 0.00244393083289243*std::exp(0.37863963842392*x_10) - 0.0026275005785414*std::exp(0.440959572792053*x_100) + 0.00180082494467357*std::exp(0.390479624271393*x_11) + 0.000275700610562771*std::exp(0.398079603910446*x_11) - 0.000722926942531787*std::exp(0.597919881343842*x_113) - 0.00110599449190973*std::exp(0.554959833621979*x_12) - 0.00162848271285098*std::exp(0.555519819259644*x_12) - 0.000354134971417681*std::exp(0.735919654369354*x_13) - 0.000613867929508977*std::exp(0.746319591999054*x_13) - 0.000335052852907055*std::exp(1.00799989700317*x_14) + 0.000572865636646123*std::exp(1.0595999956131*x_14) + 0.000330773714778607*std::exp(1.26079976558685*x_15) - 0.0001354164808554*std::exp(1.17711985111237*x_16) - 0.000326876196009928*std::exp(1.20743978023529*x_16) - 0.00358809875296897*std::exp(0.59999942779541*x_25) - 0.00380099861964527*std::exp(0.625759959220886*x_27) - 0.00106722848501248*std::exp(0.254479765892029*x_3) + 0.00106459809204328*std::exp(0.256639748811722*x_3) - 0.000509678673935101*std::exp(0.292959719896317*x_4) + 0.00111426142793371*std::exp(0.296639710664749*x_4) - 0.00070248546036497*std::exp(0.39087963104248*x_5) - 0.000908037830684987*std::exp(0.39199960231781*x_5) + 0.000404667821616679*std::exp(0.326959699392319*x_6) - 0.0028008104711863*std::exp(0.33751967549324*x_6) + 0.000393105697961851*std::exp(2.69063973426819*x_61) - 0.0023508632502551*std::exp(0.531519830226898*x_62) + 0.000908048666894619*std::exp(1.45271956920624*x_67) - 0.000383740069386876*std::exp(0.329039663076401*x_7) + 0.000335286260948928*std::exp(0.334319651126862*x_7) + 0.000512731323187409*std::exp(1.75759971141815*x_78) + 0.00138848772754174*std::exp(0.718479633331299*x_79) - 0.00266115150174017*std::exp(0.300399720668793*x_8) + 0.00123119894551*std::exp(0.303359717130661*x_8) - 0.000287643407669819*std::exp(2.24656009674072*x_85) - 0.000768369674099963*std::exp(0.318799704313278*x_9) + 0.00596485399849552*std::exp(0.273759722709656*x_94) - 0.0142762096474926*std::exp(0.158639833331108*x_95) - 0.00650946706625061*std::exp(0.286399722099304*x_98) - 0.00306655620073936*std::sin(1.18831980228424*x_100 + 4.79408025741577) + 0.00129885817792939*std::sin(1.14503979682922*x_101 - 7.75903987884521) - 0.00602674695079471*std::sin(0.630799949169159*x_102 + 8.37952041625977) - 0.00523996634926219*std::sin(0.748079597949982*x_103 - 1.14335989952087) + 0.00187662052484766*std::sin(1.16319978237152*x_105 + 7.80984020233154) + 0.00258015229274653*std::sin(1.21303987503052*x_108 + 4.7760796546936) - 0.00310700615814135*std::sin(1.08351993560791*x_110 - 4.62207984924316) - 0.001801313139273*std::sin(1.15967988967896*x_110 + 1.62808001041412) + 0.0032811953451471*std::sin(0.790319681167603*x_111 + 8.21183967590332) - 0.00397865418012478*std::sin(0.946880042552948*x_113 - 1.34919965267181) + 0.00236657633004513*std::sin(0.879999816417694*x_114 - 7.63015985488892) - 0.00321677654296432*std::sin(0.722879588603973*x_115 - 4.3699197769165) + 0.000637222830952811*std::sin(1.5771199464798*x_115 - 5.18495988845825) - 0.00144931011850123*std::sin(1.20855975151062*x_118 + 4.79016017913818) - 0.00208170721051532*std::sin(1.02160000801086*x_120 + 8.18144035339355) + 0.000467723026707396*std::sin(2.92903971672058*x_66 + 2.37191987037659) - 0.000181236691813361*std::sin(4.38775968551636*x_66 - 0.206719815731049) + 0.00131966561801204*std::sin(1.18479979038239*x_92 - 1.17983984947205) + 0.0012831550331638*std::sin(1.35383975505829*x_94 - 1.54991984367371) - 0.000603142943696238*std::sin(1.47087955474854*x_95 + 4.54888010025024) + 0.00278607724951464*std::sin(0.986720025539398*x_99 - 1.37095963954926) - 0.0226987469941378*std::sin(-0.149593890216953*x_1 - 0.0963673537182365*x_100 - 0.16056014236736*x_101 + 0.00455036309520838*x_105 + 0.106782907530768*x_106 - 0.0172917710993197*x_108 + 0.0672824256181281*x_109 - 0.03037151566545*x_111 + 0.0206694509652171*x_112 - 0.0993173627415535*x_113 + 0.0327951563232065*x_114 - 0.0306773894393289*x_116 - 0.000314880054403978*x_17 + 8.31083832222459e-5*x_18 - 0.000301688501526966*x_19 + 0.0109938661082218*x_2 - 0.000349281264954742*x_20 + 0.000773280526910286*x_21 + 0.000286945453794815*x_23 + 3.30658150898715e-5*x_24 - 0.000107801192722085*x_25 + 9.10109923214288e-5*x_26 + 0.00011060518437052*x_27 + 9.45115952409363e-5*x_28 + 8.11658500665897e-5*x_29 + 6.04596472321752e-5*x_30 + 0.0660579653072344*x_31 + 0.000775665489815406*x_32 - 0.149077271736438*x_33 + 0.164692714819168*x_34 - 0.148443964780088*x_35 + 0.0712840103393129*x_36 + 0.157410905845253*x_37 - 0.167317891987417*x_38 + 0.0801255261966899*x_39 - 0.213507624008528*x_40 + 0.139041850258371*x_41 - 0.0876962092794872*x_42 - 0.197663120101494*x_43 + 0.204821250065068*x_44 + 0.063060197855514*x_45 - 0.107140427165572*x_46 + 0.20636436123387*x_47 + 0.0402875166132268*x_48 - 0.0677985440171757*x_49 - 0.0760456043177356*x_50 - 0.126587205553812*x_51 - 0.0638033811160547*x_52 - 0.0911285512584804*x_53 + 0.0682270708594566*x_54 + 0.168141080613131*x_55 + 0.124627514720583*x_56 + 0.196233589702935*x_57 - 0.169277864559203*x_58 + 0.0473820730874113*x_59 + 0.09762750342155*x_60 - 0.000990726102206331*x_61 + 0.00380071793037153*x_62 - 0.000620197517339424*x_63 - 0.0556310111086249*x_64 + 0.0492388021810024*x_70 - 0.0643845413392177*x_71 + 0.0738854294652221*x_72 + 0.0740520494973984*x_73 - 0.0422644072934869*x_74 + 0.118659986344482*x_76 + 0.102003251259827*x_77 + 0.0462633947334336*x_78 - 0.00179989648899432*x_83 - 0.0212891534345501*x_85 + 0.0899236557132831*x_86 + 0.0695807029994715*x_90 - 0.0556185362608565*x_92 + 0.0306405506768002*x_93 + 0.00825495320041681*x_95 + 0.110066213393792*x_98 + 0.00142522917591417*std::pow(-5.06224012374878*x_110 - 6.06215953826904, 2) + 0.0010081497974542*std::pow(-4.91359996795654*x_120 - 9.95232009887695, 2) - 0.000781298008212195*std::pow(-9.72855949401855*x_66 - 3.0403196811676, 2) + 0.000655206447774379*std::pow(-9.34815979003906*x_68 - 7.77871990203857, 2) - 0.000575914805500413*std::pow(9.97795963287354*x_69 + 6.79199981689453, 2) - 0.000594327438001724*std::pow(-7.12376022338867*x_75 - 8.96928024291992, 2) + 0.00119613464897045*std::pow(-4.9159197807312*x_84 - 9.26272010803223, 2) - 0.000834858979661693*std::pow(-9.30655956268311*x_87 - 4.45368003845215, 2) - 0.000930447529053871*std::pow(-7.25176000595093*x_91 - 4.82791996002197, 2) - 0.131774542906934*std::exp(0.383119642734528*x_10) + 0.341049053398597*std::exp(0.226719796657562*x_102) - 0.217676961335009*std::exp(0.325359672307968*x_103) + 0.105387048673635*std::exp(0.290799736976624*x_104) + 0.11486729535929*std::exp(0.386399626731873*x_11) - 0.0989038783045049*std::exp(0.310719698667526*x_115) + 0.650002117881733*std::exp(0.193679809570313*x_117) - 0.0488366811844915*std::exp(0.563039839267731*x_12) + 0.0567430428511873*std::exp(0.749999642372131*x_13) + 0.0102193396623477*std::exp(1.05879998207092*x_14) + 0.0325460051196099*std::exp(1.23447978496552*x_15) + 0.0128962152631421*std::exp(1.22799980640411*x_16) + 0.0668865891899897*std::exp(0.294799715280533*x_22) + 0.115850293452426*std::exp(0.25279974937439*x_3) - 0.138652015897306*std::exp(0.291599720716476*x_4) - 0.0331880294471652*std::exp(0.395119607448578*x_5) + 0.0233267078964791*std::exp(0.332639664411545*x_6) - 0.0333425716351461*std::exp(1.60343992710114*x_65) + 0.0720605962642355*std::exp(0.318159699440002*x_7) - 0.0612411053933208*std::exp(0.960240066051483*x_79) + 0.186279600694161*std::exp(0.301119714975357*x_8) - 0.0748382773964475*std::exp(1.0*x_80) - 0.0391840216459236*std::exp(1.51543974876404*x_81) - 0.0461147603560249*std::exp(1.54271984100342*x_82) + 0.080992387681824*std::exp(0.91376006603241*x_88) - 0.00299371457421917*std::exp(3.14815998077393*x_89) - 0.14108740396685*std::exp(0.326159685850143*x_9) + 0.195107368081304*std::exp(0.413439601659775*x_94) - 0.0583714495593738*std::exp(0.486799538135529*x_99) + 0.181801760485062*std::sin(0.879599809646606*x_107 + 8.1738395690918) + 0.115551794489111*std::sin(1.02023994922638*x_118 - 1.39911961555481) + 0.266957601878513*std::sin(0.705280065536499*x_119 - 1.23703980445862) - 0.149504941937543*std::sin(1.2203197479248*x_96 - 7.82216024398804) - 0.253823357309287*std::sin(0.741679608821869*x_97 - 1.1515998840332) - 1.13261096798124 - 0.00628161468869934*std::exp(-2.33999991416931*x_67)) + 0.0127054443582892*std::sin(-0.128681502583812*x_1 + 0.0679613775736317*x_101 + 0.126368147313148*x_102 + 0.175452035686018*x_104 - 0.128664787433853*x_105 + 0.0388344559446455*x_106 + 0.0465180137734006*x_108 + 0.00687622915878948*x_111 - 0.0418057818812473*x_113 - 0.0681196440321803*x_114 - 0.0503589581096401*x_119 - 0.00030408346388499*x_12 - 0.000255897003227063*x_17 - 4.20179312305116e-5*x_18 - 0.000128839293746284*x_19 + 0.0284232151608301*x_2 + 0.000226728333081304*x_20 + 0.000210588329479284*x_21 + 1.97979453070391e-5*x_27 - 9.80726502728869e-5*x_28 - 9.97440555760733e-5*x_29 - 1.38301796407509e-5*x_30 - 0.0307931051702835*x_31 + 0.054879953901217*x_32 + 0.12456392321588*x_33 + 0.0211061852412204*x_34 - 0.179019777382754*x_35 - 0.0121359177029356*x_36 - 0.00187413349236793*x_37 - 0.140284245435698*x_38 + 0.199686927861559*x_39 + 0.19989121149623*x_40 - 0.122604613096057*x_41 + 0.167385900532359*x_42 - 0.0855443021252455*x_43 - 0.197053891012579*x_44 - 0.111599091197346*x_45 + 0.147141046771959*x_46 - 0.154652319850306*x_47 + 0.0355458277788792*x_48 + 0.247181800443402*x_50 + 0.107249400846619*x_51 - 0.172083668711865*x_53 + 0.116303059185094*x_54 + 0.187706319509549*x_55 - 0.145255917472511*x_56 + 0.155877688304277*x_57 - 0.0186417752817222*x_58 + 0.0682393931801482*x_59 + 0.147727901516328*x_60 - 0.104657510767916*x_62 + 0.0689029708210525*x_63 - 0.0862298866337797*x_64 + 0.0754206635426374*x_65 + 0.0408275023743664*x_67 + 0.0723585263160097*x_68 - 0.0435093403267297*x_69 + 0.025975675477051*x_70 + 0.0264342975542056*x_73 - 0.0298812590003189*x_76 - 0.0922687956269116*x_78 + 0.0387635391346644*x_79 - 0.0383203888659657*x_80 + 0.099513893286728*x_81 - 0.0962966692753564*x_82 + 0.0965494375301938*x_83 + 0.0391748539658723*x_85 - 0.0673767279262554*x_87 + 0.0899355284194188*x_88 - 0.0110699934182064*x_90 + 0.0237307110642196*x_91 - 0.0072180700334278*x_92 - 0.17648740301632*x_94 + 0.0764163740423203*x_96 + 0.0905446170044374*x_98 + 0.000196301997224344*std::pow(-9.66063976287842*x_112 - 2.00952005386353, 2) + 0.000597974707878569*std::pow(-9.87936019897461*x_61 - 6.42767953872681, 2) - 0.000284523611860307*std::pow(-9.61999988555908*x_89 - 9.98340034484863, 2) + 0.000569260523639592*std::pow(-9.5272798538208*x_93 - 3.83999991416931, 2) - 0.104330719015778*std::exp(0.377839624881744*x_10) + 0.265706553294553*std::exp(0.306799709796906*x_109) + 0.167052262347422*std::exp(0.389359623193741*x_11) + 0.49194464980843*std::exp(0.204399809241295*x_110) + 0.464476047491546*std::exp(0.284239739179611*x_116) - 0.0631253817905988*std::exp(0.753279685974121*x_13) + 0.0272296462213898*std::exp(1.06831991672516*x_14) - 0.00524015400662083*std::exp(1.01175999641418*x_15) + 0.0126979134872766*std::exp(1.3155996799469*x_16) - 0.0733047633520331*std::exp(0.302559703588486*x_22) - 0.0787301718020593*std::exp(0.454799562692642*x_23) - 0.14581240248386*std::exp(0.549359798431396*x_24) - 0.107030628015704*std::exp(0.551279842853546*x_25) - 0.126952413218819*std::exp(0.568719863891602*x_26) + 0.0572692815282191*std::exp(0.254239767789841*x_3) + 0.16117873646719*std::exp(0.290719717741013*x_4) - 0.0106411879219476*std::exp(0.375039637088776*x_5) - 0.0973081331960943*std::exp(0.336479663848877*x_6) + 0.157292845541669*std::exp(0.322799682617188*x_7) + 0.0292028078439523*std::exp(1.67871999740601*x_72) - 0.0922742286477552*std::exp(0.906000137329102*x_74) - 0.0474865272548992*std::exp(1.59167993068695*x_75) - 0.0393905580008727*std::exp(1.82439970970154*x_77) - 0.0488450428922843*std::exp(0.296319723129272*x_8) + 0.0716853754613256*std::exp(0.453119575977325*x_84) + 0.010538157838032*std::exp(2.19304013252258*x_86) - 0.160669560557418*std::exp(0.321679681539536*x_9) + 0.00224534189699643*std::sin(8.43152046203613*x_100 + 6.17775964736938) + 0.172964438215484*std::sin(1.13871991634369*x_103 - 4.73816013336182) + 0.0302293026951883*std::sin(2.24272012710571*x_107 + 0.576879858970642) + 0.228217843973049*std::sin(0.942240059375763*x_115 - 7.77415990829468) - 0.316308671618817*std::sin(0.655439972877502*x_117 - 7.4203200340271) - 0.138481396616674*std::sin(0.86495977640152*x_118 - 1.23255980014801) - 0.0465998924650846*std::sin(1.39743959903717*x_120 + 7.59143972396851) + 0.0124315360811877*std::sin(3.70088005065918*x_66 - 5.78968000411987) + 0.0503366909254011*std::sin(2.39439988136292*x_71 + 2.39183974266052) + 0.233487604162548*std::sin(1.02312004566193*x_95 - 1.41087961196899) + 0.12711913763078*std::sin(0.921440064907074*x_97 - 4.54048013687134) + 0.18147601993098*std::sin(0.982560038566589*x_99 - 1.37295973300934) + 2.84209380479374 + 3.86183663191514*std::exp(-0.012639987282455*x_52) + 1.78904959054604*std::exp(-0.015439985319972*x_49)) + 0.0272988267242908*std::sin(-0.0745701379164759*x_1 + 0.0596497529010557*x_100 + 0.0246052005722256*x_104 - 0.0110717654924473*x_108 - 0.00682553818582966*x_111 + 0.0283165765833238*x_113 + 0.0316921415872467*x_114 - 0.0379408945883438*x_115 - 0.00399845230382591*x_116 + 0.00354499764040569*x_120 + 0.000159027402887659*x_17 - 1.77488952534431e-5*x_18 - 6.93108208968392e-5*x_19 + 0.0315516055772435*x_2 - 0.0003054415331565*x_20 - 0.000197375449875778*x_21 - 0.0056999864343528*x_32 - 0.0270012634119034*x_33 - 0.0800586395026316*x_34 + 0.115548184382112*x_35 + 0.0230022208717138*x_36 - 0.100331893792828*x_37 - 0.0700483550991084*x_38 - 0.0659072707799558*x_39 + 0.132777675452625*x_40 + 0.112685848916078*x_41 - 0.0179938041869331*x_42 + 0.0868193684056938*x_43 + 0.0135704622341369*x_44 - 0.0481484291781485*x_45 + 0.112365265076563*x_46 - 0.0880580605475586*x_47 + 0.0880166393722189*x_48 - 0.0746348625554733*x_49 + 0.0178012655866008*x_50 - 0.0751751186778499*x_51 - 0.0650520359115575*x_52 - 0.00521469589187007*x_53 - 0.0789649944481807*x_54 - 0.0685322973065672*x_55 + 0.0296466645095538*x_56 + 0.0548024971553395*x_57 - 0.086337691964788*x_58 + 0.0432275856643227*x_59 + 0.0557699042396922*x_60 + 0.000962660257595354*x_62 - 0.00552552998969427*x_63 + 0.0229601888564136*x_65 - 0.0275072695641483*x_67 + 0.0223659557754876*x_69 + 0.0286184323849035*x_70 + 0.0306443687266662*x_72 - 0.0460153500854539*x_73 + 0.00100124117029108*x_74 + 0.0204338424094409*x_75 - 0.00318863374079856*x_76 - 0.022502789130119*x_77 + 0.00286571865924061*x_80 + 0.00801457796061492*x_85 + 0.0494432522399083*x_87 - 0.00170026194225172*x_88 - 0.0372723223221855*x_93 + 0.0232661252913695*x_94 + 0.0317890229078022*x_96 - 0.0255834353977822*x_99 + 0.000118438972712101*std::pow(2.20000004768372 - 9.95748043060303*x_86, 2) + 0.0162967635442516*std::pow(8.37551975250244 - 0.210639804601669*x_31, 2) + 0.00229455215674135*std::pow(-2.63048005104065*x_102 - 7.50127983093262, 2) + 0.0002546362740528*std::pow(-9.03791999816895*x_107 - 8.22247982025146, 2) - 0.000398407550812319*std::pow(-8.81511974334717*x_61 - 9.24431991577148, 2) + 0.000399889535215206*std::pow(-8.96744060516357*x_78 - 5.9543194770813, 2) + 0.000321097583237107*std::pow(-9.76488018035889*x_81 - 6.16847991943359, 2) - 0.000448269659571187*std::pow(-8.79600048065186*x_82 - 6.76008033752441, 2) - 0.000327461096373268*std::pow(-8.73871994018555*x_84 - 6.90944004058838, 2) - 0.000112572101558963*std::pow(-9.98104000091553*x_89 - 6.3045597076416, 2) + 0.00021992650414056*std::pow(9.99804019927979*x_90 + 6.80000019073486, 2) + 0.000349383289239596*std::pow(-9.12360000610352*x_92 - 4.86263990402222, 2) + 0.0167269802653645*std::exp(0.383999645709991*x_10) + 0.0104114836722328*std::exp(0.390159606933594*x_11) - 0.0765521945825075*std::exp(0.438959568738937*x_112) - 0.324187041445026*std::exp(0.17751981317997*x_118) - 0.0293486108691934*std::exp(0.559599876403809*x_12) - 0.0354021497125831*std::exp(0.756479620933533*x_13) + 0.0189697516974559*std::exp(1.05224001407623*x_14) - 0.00928182685727159*std::exp(1.22631978988647*x_15) - 0.0163256594631029*std::exp(1.24463975429535*x_16) - 0.0296540237020036*std::exp(0.317999690771103*x_22) - 0.0664372924550411*std::exp(0.509839773178101*x_23) - 0.0739526339439945*std::exp(0.603119909763336*x_24) - 0.0625057055495902*std::exp(0.649999976158142*x_25) + 0.0667522755540071*std::exp(0.779999673366547*x_26) - 0.0476032394605517*std::exp(0.663999974727631*x_27) + 0.232492808315952*std::exp(0.900000095367432*x_28) + 0.244532131448393*std::exp(1.0239999294281*x_29) + 0.0458258581117255*std::exp(0.253599762916565*x_3) + 0.282124359710377*std::exp(1.0*x_30) - 0.0534206038324818*std::exp(0.291999727487564*x_4) + 0.0618046458420481*std::exp(0.391519606113434*x_5) + 0.10642827258703*std::exp(0.33903968334198*x_6) + 0.0188447163646761*std::exp(1.52415978908539*x_64) + 0.0394990698943534*std::exp(0.965040028095245*x_68) + 0.00289026804155337*std::exp(0.319119691848755*x_7) - 0.0816136280263886*std::exp(0.763999700546265*x_71) - 0.0670423351605081*std::exp(0.5971999168396*x_79) + 0.084155549691766*std::exp(0.302559703588486*x_8) - 0.0076501648146654*std::exp(2.54519987106323*x_83) - 0.0632170457948529*std::exp(0.324639678001404*x_9) - 0.135675535150889*std::exp(0.367199659347534*x_97) - 0.102023911070853*std::sin(0.997919976711273*x_101 + 8.19495964050293) + 0.0668595105737055*std::sin(1.221599817276*x_103 + 1.38991963863373) + 0.136878632446749*std::sin(0.743679583072662*x_105 - 4.37695980072021) + 0.0891240851546247*std::sin(0.938000082969666*x_106 - 1.35967969894409) - 0.129051727764382*std::sin(0.799759685993195*x_109 - 4.20560026168823) - 0.106883783592114*std::sin(0.914640069007874*x_110 - 1.37599968910217) + 0.0187886185871553*std::sin(1.37159967422485*x_117 - 4.98199987411499) + 0.0562432999455953*std::sin(1.09279990196228*x_119 + 1.55415987968445) + 0.00324303387594613*std::sin(5.21920013427734*x_66 - 9.41256046295166) + 0.00995102807021192*std::sin(3.36391997337341*x_91 - 8.0447998046875) - 0.0677064200110262*std::sin(0.978640019893646*x_95 + 8.21375942230225) + 0.103277941332183*std::sin(1.16767990589142*x_98 - 7.76968002319336) + 1.81102585688344) + 0.144158266584175 - 0.0486732126930108*std::exp(-0.0245599746704102*x_32));
}

inline float score_8(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.00099784298799932*std::pow(-0.565410151166666*x_1 + 0.452279917231968*x_100 + 0.186563020583531*x_104 - 0.0839490012446839*x_108 - 0.0517530030823655*x_111 + 0.214703637325071*x_113 + 0.240298047801806*x_114 - 0.287677715825362*x_115 - 0.0303173037452491*x_116 + 0.0268790927273369*x_120 + 0.00120578706729852*x_17 - 0.00013457673310905*x_18 - 0.000525532643706013*x_19 + 0.239232467277477*x_2 - 0.00231593702599868*x_20 - 0.00149655191835438*x_21 - 0.0432187774026269*x_32 - 0.204730591279249*x_33 - 0.607025395528728*x_34 + 0.876116341258486*x_35 + 0.174408812208609*x_36 - 0.760742474417589*x_37 - 0.531124819561484*x_38 - 0.499726042835221*x_39 + 1.00675481696595*x_40 + 0.854413370421121*x_41 - 0.136433696244369*x_42 + 0.65828699779851*x_43 + 0.102894768838957*x_44 - 0.365073893929859*x_45 + 0.851982620495931*x_46 - 0.667679083300152*x_47 + 0.667365017191859*x_48 - 0.565900910188202*x_49 + 0.134973818575359*x_50 - 0.569997272409818*x_51 - 0.493241429962898*x_52 - 0.0395391784820476*x_53 - 0.598733094711847*x_54 - 0.519629675665971*x_55 + 0.224788709398788*x_56 + 0.415526765360389*x_57 - 0.654634801934652*x_58 + 0.327762780490104*x_59 + 0.422861897104629*x_60 + 0.00729914007104003*x_62 - 0.0418960033337784*x_63 + 0.174090114553104*x_65 - 0.208567261332784*x_67 + 0.169584485014226*x_69 + 0.216992386403059*x_70 + 0.232353561871624*x_72 - 0.348900334299303*x_73 + 0.00759167057036499*x_74 + 0.154934699712888*x_75 - 0.0241770490946311*x_76 - 0.170621991043965*x_77 + 0.0217286230868613*x_80 + 0.0607686114423438*x_85 + 0.374891578643057*x_87 - 0.0128918275954947*x_88 - 0.282608427278547*x_93 + 0.176409804053069*x_94 + 0.241032627133841*x_96 - 0.193980251073489*x_99 + 0.000898035049099431*std::pow(2.20000004768372 - 9.95748043060303*x_86, 2) + 0.123566293378771*std::pow(8.37551975250244 - 0.210639804601669*x_31, 2) + 0.0173978903358885*std::pow(-2.63048005104065*x_102 - 7.50127983093262, 2) + 0.00193071835760814*std::pow(-9.03791999816895*x_107 - 8.22247982025146, 2) - 0.00302082951466506*std::pow(-8.81511974334717*x_61 - 9.24431991577148, 2) + 0.00303206630527153*std::pow(-8.96744060516357*x_78 - 5.9543194770813, 2) + 0.00243464526350609*std::pow(-9.76488018035889*x_81 - 6.16847991943359, 2) - 0.00339889697220977*std::pow(-8.79600048065186*x_82 - 6.76008033752441, 2) - 0.00248289507267632*std::pow(-8.73871994018555*x_84 - 6.90944004058838, 2) - 0.000853550908419862*std::pow(-9.98104000091553*x_89 - 6.3045597076416, 2) + 0.00166753986818356*std::pow(9.99804019927979*x_90 + 6.80000019073486, 2) + 0.00264911483207034*std::pow(-9.12360000610352*x_92 - 4.86263990402222, 2) + 0.126828308283334*std::exp(0.383999645709991*x_10) + 0.0789425730120013*std::exp(0.390159606933594*x_11) - 0.580438619538511*std::exp(0.438959568738937*x_112) - 2.45807033795505*std::exp(0.17751981317997*x_118) - 0.222528789294567*std::exp(0.559599876403809*x_12) - 0.268428292878267*std::exp(0.756479620933533*x_13) + 0.143833583717737*std::exp(1.05224001407623*x_14) - 0.0703772216748606*std::exp(1.22631978988647*x_15) - 0.123785389739624*std::exp(1.24463975429535*x_16) - 0.224844508707087*std::exp(0.317999690771103*x_22) - 0.50374480481964*std::exp(0.509839773178101*x_23) - 0.560728075684684*std::exp(0.603119909763336*x_24) - 0.473934491889473*std::exp(0.649999976158142*x_25) + 0.506133088475502*std::exp(0.779999673366547*x_26) - 0.360940123908055*std::exp(0.663999974727631*x_27) + 1.7628208498464*std::exp(0.900000095367432*x_28) + 1.85410612438729*std::exp(1.0239999294281*x_29) + 0.347463556944396*std::exp(0.253599762916565*x_3) + 2.13914016157933*std::exp(1.0*x_30) - 0.405048891315844*std::exp(0.291999727487564*x_4) + 0.468618875125263*std::exp(0.391519606113434*x_5) + 0.806966801633664*std::exp(0.33903968334198*x_6) + 0.142885533353564*std::exp(1.52415978908539*x_64) + 0.299492205645695*std::exp(0.965040028095245*x_68) + 0.0219147628789059*std::exp(0.319119691848755*x_7) - 0.618815722338431*std::exp(0.763999700546265*x_71) - 0.508332395738991*std::exp(0.5971999168396*x_79) + 0.638089232529396*std::exp(0.302559703588486*x_8) - 0.0580055363335218*std::exp(2.54519987106323*x_83) - 0.479328058360483*std::exp(0.324639678001404*x_9) - 1.02872714175755*std::exp(0.367199659347534*x_97) - 0.773571788827823*std::sin(0.997919976711273*x_101 + 8.19495964050293) + 0.506946172243243*std::sin(1.221599817276*x_103 + 1.38991963863373) + 1.03784933789299*std::sin(0.743679583072662*x_105 - 4.37695980072021) + 0.675761958712073*std::sin(0.938000082969666*x_106 - 1.35967969894409) - 0.978503713984104*std::sin(0.799759685993195*x_109 - 4.20560026168823) - 0.81042060436809*std::sin(0.914640069007874*x_110 - 1.37599968910217) + 0.142460185436095*std::sin(1.37159967422485*x_117 - 4.98199987411499) + 0.426451306285234*std::sin(1.09279990196228*x_119 + 1.55415987968445) + 0.0245895250467572*std::sin(5.21920013427734*x_66 - 9.41256046295166) + 0.0754512790595112*std::sin(3.36391997337341*x_91 - 8.0447998046875) - 0.513367659535064*std::sin(0.978640019893646*x_95 + 8.21375942230225) + 0.783080171934479*std::sin(1.16767990589142*x_98 - 7.76968002319336) - 9.62594298983767, 2) - 0.000743839598726481*std::pow(0.479431630115301*x_1 - 0.0728419485306772*x_101 - 0.29980327328635*x_104 - 0.282024424896961*x_105 - 0.132801605939376*x_106 + 0.168127911503181*x_107 + 0.176206266085736*x_111 - 0.204473696900969*x_112 - 0.0963479745189522*x_114 + 0.237531016506022*x_117 - 0.000412348437100417*x_17 - 4.52088010789579e-5*x_18 + 0.000242471307572064*x_19 - 0.0208149501280128*x_2 + 0.00178975641170278*x_20 + 0.000849150117747407*x_21 - 0.000321421553845972*x_22 - 0.000293013235327225*x_23 + 0.000481726889869995*x_24 - 0.000456751572649047*x_26 + 4.09587497606062e-5*x_28 + 0.000132982150206091*x_29 - 7.72289958180733e-5*x_30 + 0.13887270925445*x_33 + 0.265350677266589*x_34 + 0.293077433089835*x_35 - 0.0507002313570393*x_36 + 0.437662009935547*x_37 + 0.278484745669592*x_38 - 0.524200638184706*x_39 - 0.0829687205141966*x_40 + 0.116214952433077*x_41 - 0.347028302173338*x_42 + 0.0997397958890772*x_43 + 0.0073880015346547*x_44 - 0.0165077712384115*x_45 + 0.401244062692999*x_46 - 0.10340691156986*x_47 + 0.396829877441501*x_48 + 0.470729569360746*x_49 - 0.126246069200984*x_50 - 0.0293593110118929*x_51 - 0.0943563110092431*x_52 - 0.444495171926928*x_53 - 0.470190253829173*x_54 - 0.509009416958185*x_55 - 0.310258067717535*x_56 + 0.114580248580189*x_57 - 0.320855905598001*x_58 + 0.102409513051201*x_59 + 0.230490578648498*x_60 - 0.0980853955993444*x_62 + 0.0191175151814816*x_63 - 0.294675867655331*x_64 + 0.108322490847279*x_68 + 0.288745818157158*x_69 + 0.0784059393237324*x_70 - 0.230939683380127*x_71 + 0.18317460541567*x_72 - 0.0746548394509405*x_75 + 0.106215434603038*x_76 - 0.125550161904192*x_78 - 0.0323670518097393*x_79 - 0.198322635635337*x_81 - 0.205971284768079*x_82 - 0.0701236329491017*x_83 - 0.247468074373724*x_84 - 0.0590415552823887*x_86 - 0.030924893305607*x_87 + 0.0946309591249661*x_88 + 0.271536886442883*x_89 + 0.0119128643452732*x_90 + 0.166047762255306*x_92 + 0.14687766778898*x_93 + 0.322767500904613*x_96 + 0.341097040837284*x_97 - 0.462841799866614*x_98 - 0.113008357439112*x_99 + 0.133447248743447*std::pow(8.27943992614746 - 0.201439797878265*x_31, 2) - 0.000525330884017201*std::pow(-9.83440017700195*x_108 - 4.4474401473999, 2) - 0.000490720816575311*std::pow(-9.9629602432251*x_109 - 3.39999985694885, 2) - 0.000401203656555372*std::pow(-9.99868011474609*x_116 - 3.37999987602234, 2) - 0.015523641982091*std::pow(-2.03575992584229*x_119 - 5.2993597984314, 2) + 0.00175355871220791*std::pow(-5.40767955780029*x_120 - 9.19095993041992, 2) + 0.00183481568580794*std::pow(-8.49944019317627*x_65 - 8.27271938323975, 2) + 0.00150744288440099*std::pow(-9.9993200302124*x_73 - 6.0, 2) - 0.00141362514491328*std::pow(-8.14783954620361*x_74 - 9.39192008972168, 2) + 0.00125868943910184*std::pow(-9.59967994689941*x_77 - 1.02799999713898, 2) - 0.00201733674668685*std::pow(-8.69464015960693*x_80 - 7.84104013442993, 2) - 0.000568967350620293*std::pow(-9.93639945983887*x_91 - 4.7960000038147, 2) + 0.329808991240577*std::exp(0.37863963842392*x_10) - 0.0372058566594142*std::exp(0.398079603910446*x_11) + 0.149254194425247*std::exp(0.554959833621979*x_12) + 0.0828416090428728*std::exp(0.746319591999054*x_13) - 0.0773083408072722*std::exp(1.0595999956131*x_14) - 0.044637983911729*std::exp(1.26079976558685*x_15) + 0.0182744832002511*std::exp(1.17711985111237*x_16) + 0.484214698002607*std::exp(0.59999942779541*x_25) + 0.512945580775038*std::exp(0.625759959220886*x_27) + 0.144022713461411*std::exp(0.254479765892029*x_3) + 0.0687812466068958*std::exp(0.292959719896317*x_4) + 0.0948005638809095*std::exp(0.39087963104248*x_5) + 0.37796997514236*std::exp(0.33751967549324*x_6) - 0.0530496984410472*std::exp(2.69063973426819*x_61) - 0.122541362789479*std::exp(1.45271956920624*x_67) - 0.0452469529874203*std::exp(0.334319651126862*x_7) + 0.359122967194833*std::exp(0.300399720668793*x_8) + 0.0388175396962065*std::exp(2.24656009674072*x_85) + 0.103691652686766*std::exp(0.318799704313278*x_9) - 0.804958329288248*std::exp(0.273759722709656*x_94) + 1.92657756071028*std::exp(0.158639833331108*x_95) + 0.413832418469635*std::sin(1.18831980228424*x_100 + 4.79408025741577) + 0.813310796505391*std::sin(0.630799949169159*x_102 + 8.37952041625977) + 0.707134585204031*std::sin(0.748079597949982*x_103 - 1.14335989952087) + 0.419291148916063*std::sin(1.08351993560791*x_110 - 4.62207984924316) + 0.536920236850179*std::sin(0.946880042552948*x_113 - 1.34919965267181) - 0.0859933580130341*std::sin(1.5771199464798*x_115 - 5.18495988845825) + 0.195584712032106*std::sin(1.20855975151062*x_118 + 4.79016017913818) - 0.0631193229948277*std::sin(2.92903971672058*x_66 + 2.37191987037659) - 23.242770261312 + 6.56846051560351*std::exp(-0.0245599746704102*x_32), 2) - 0.245314699396146*std::exp(0.0717084646853966*x_1 + 0.0461940990431314*x_100 + 0.0769651840869587*x_101 - 0.00218123581681882*x_105 - 0.0511868388646681*x_106 + 0.00828888369321249*x_108 - 0.0322521156070489*x_109 + 0.0145587146331934*x_111 - 0.00990798883869007*x_112 + 0.0476081983593758*x_113 - 0.0157204970446593*x_114 + 0.0147053365218319*x_116 + 0.000150939087342515*x_17 - 3.98383553947942e-5*x_18 + 0.000144615660615295*x_19 - 0.00526995626916357*x_2 + 0.000167429453281503*x_20 - 0.000370675294796009*x_21 - 0.00013754851825993*x_23 - 1.58502384704826e-5*x_24 + 5.16749581827452e-5*x_25 - 4.36265045276859e-5*x_26 - 5.30190634520738e-5*x_27 - 4.53045333593919e-5*x_28 - 3.89071939015637e-5*x_29 - 2.89815878987592e-5*x_30 - 0.0316651653724166*x_31 - 0.00037181853686298*x_32 + 0.0714608214292972*x_33 - 0.0789461501898557*x_34 + 0.0711572430582249*x_35 - 0.0341702921866441*x_36 - 0.0754555842256006*x_37 + 0.0802045399809715*x_38 - 0.0384085102495917*x_39 + 0.102345783601685*x_40 - 0.0666502996518415*x_41 + 0.0420375492410891*x_42 + 0.0947506535651077*x_43 - 0.0981819334720743*x_44 - 0.0302281728512985*x_45 + 0.0513582174154196*x_46 - 0.0989216303446749*x_47 - 0.019311991673805*x_48 + 0.0324995191469789*x_49 + 0.0364527824217247*x_50 + 0.0606801129772998*x_51 + 0.0305844208940225*x_52 + 0.0436828569019293*x_53 - 0.0327049353032931*x_54 - 0.0805991389342498*x_55 - 0.0597407268786762*x_56 - 0.0940654021156456*x_57 + 0.0811440611321657*x_58 - 0.0227127973594503*x_59 - 0.046798157139136*x_60 + 0.000474908752021424*x_61 - 0.00182189023290948*x_62 + 0.0002972943059747*x_63 + 0.026666960727542*x_64 - 0.0236028283122187*x_70 + 0.0308630025077422*x_71 - 0.035417293459568*x_72 - 0.0354971634774936*x_73 + 0.0202596225919309*x_74 - 0.0568801668839055*x_76 - 0.0488956903931893*x_77 - 0.0221765541537673*x_78 + 0.000862788003114523*x_83 + 0.0102050458413068*x_85 - 0.0431052851205746*x_86 - 0.0333538046011535*x_90 + 0.0266609808564433*x_92 - 0.0146876777050312*x_93 - 0.00395704676971229*x_95 - 0.0527607054322704*x_98 - 0.000683189640174595*std::pow(-5.06224012374878*x_110 - 6.06215953826904, 2) - 0.000483260874113836*std::pow(-4.91359996795654*x_120 - 9.95232009887695, 2) + 0.000374518508405669*std::pow(-9.72855949401855*x_66 - 3.0403196811676, 2) - 0.00031407598501338*std::pow(-9.34815979003906*x_68 - 7.77871990203857, 2) + 0.000276067200552975*std::pow(9.97795963287354*x_69 + 6.79199981689453, 2) + 0.000284893373905179*std::pow(-7.12376022338867*x_75 - 8.96928024291992, 2) - 0.000573372208652917*std::pow(-4.9159197807312*x_84 - 9.26272010803223, 2) + 0.000400193186857654*std::pow(-9.30655956268311*x_87 - 4.45368003845215, 2) + 0.000446013962749479*std::pow(-7.25176000595093*x_91 - 4.82791996002197, 2) + 0.0631666851017238*std::exp(0.383119642734528*x_10) - 0.163483307815265*std::exp(0.226719796657562*x_102) + 0.104344373102926*std::exp(0.325359672307968*x_103) - 0.0505177280111607*std::exp(0.290799736976624*x_104) - 0.0550621244011553*std::exp(0.386399626731873*x_11) + 0.0474099928437023*std::exp(0.310719698667526*x_115) - 0.311581267443186*std::exp(0.193679809570313*x_117) + 0.0234100699098819*std::exp(0.563039839267731*x_12) - 0.0272000178519*std::exp(0.749999642372131*x_13) - 0.00489868373783679*std::exp(1.05879998207092*x_14) - 0.0156010653602602*std::exp(1.23447978496552*x_15) - 0.00618185539149442*std::exp(1.22799980640411*x_16) - 0.0320623697391716*std::exp(0.294799715280533*x_22) - 0.0555333286993071*std::exp(0.25279974937439*x_3) + 0.0664634309002294*std::exp(0.291599720716476*x_4) + 0.0159088224401309*std::exp(0.395119607448578*x_5) - 0.011181756200038*std::exp(0.332639664411545*x_6) + 0.0159829028923015*std::exp(1.60343992710114*x_65) - 0.034542551937973*std::exp(0.318159699440002*x_7) + 0.0293561831771516*std::exp(0.960240066051483*x_79) - 0.0892939153371465*std::exp(0.301119714975357*x_8) + 0.0358740451499461*std::exp(1.0*x_80) + 0.0187830266888139*std::exp(1.51543974876404*x_81) + 0.0221053056356093*std::exp(1.54271984100342*x_82) - 0.0388240439729525*std::exp(0.91376006603241*x_88) + 0.0014350497571272*std::exp(3.14815998077393*x_89) + 0.0676308444832768*std::exp(0.326159685850143*x_9) - 0.0935255430126738*std::exp(0.413439601659775*x_94) + 0.0279806015024629*std::exp(0.486799538135529*x_99) - 0.0871474436728601*std::sin(0.879599809646606*x_107 + 8.1738395690918) - 0.0553902419573387*std::sin(1.02023994922638*x_118 - 1.39911961555481) - 0.127967256811361*std::sin(0.705280065536499*x_119 - 1.23703980445862) + 0.0716658269510368*std::sin(1.2203197479248*x_96 - 7.82216024398804) + 0.121671301064133*std::sin(0.741679608821869*x_97 - 1.1515998840332) + 0.00301111859861785*std::exp(-2.33999991416931*x_67)) + 0.271366029977798*std::sin(-0.0220879368717506*x_1 - 0.0446924359204807*x_103 - 0.0381033208488632*x_104 - 0.000175128843946033*x_107 + 0.000841327091211895*x_109 - 0.0360486846745124*x_112 + 0.00466378786799826*x_116 + 0.0194640710005861*x_117 + 0.0331683646705665*x_118 + 0.0206205399065434*x_119 + 0.000245281525419021*x_15 - 4.94376558938642e-5*x_17 + 9.55902525065335e-5*x_18 + 0.000343522662657822*x_19 + 0.0234897941932164*x_2 + 0.000148177106524775*x_20 + 0.000316041323783836*x_21 + 6.07427260444026e-6*x_22 + 7.14473310710851e-6*x_23 + 0.000254778115927875*x_24 - 8.83101852650779e-6*x_25 + 0.00010522362462781*x_26 + 1.32881032700704e-5*x_27 + 0.000101330304692244*x_28 + 7.08057075117153e-5*x_29 + 0.000100810496722688*x_30 + 0.0350604589108432*x_31 + 0.0299809583876711*x_32 + 0.0542184893440371*x_33 - 0.0222188197887333*x_34 - 0.0227739960847285*x_35 - 0.0783240858399981*x_36 + 0.0538362689136243*x_37 - 0.00425976677348429*x_38 - 0.0614307827286603*x_39 + 0.0467420121507592*x_40 + 0.0393720084089956*x_41 - 0.0483468181901824*x_42 - 0.0305252633281127*x_43 - 0.0424866628439684*x_44 + 0.062065192832358*x_45 - 0.0970994036819474*x_46 + 0.0538716436448801*x_47 + 0.0599382959078823*x_48 - 0.0862920641806326*x_49 - 0.0263610550699591*x_50 + 0.0143099704975438*x_51 + 0.0392230175208053*x_52 - 0.0167647764034647*x_53 + 0.0364474188490698*x_54 + 0.0481883506342677*x_55 + 0.0892736795550578*x_56 + 0.0117815343315155*x_57 + 0.0537787147865612*x_58 + 0.00174174663616435*x_59 - 0.0572826360070157*x_60 + 0.00518306381825103*x_61 + 0.0106497625815924*x_63 - 0.0244920261927499*x_64 - 0.0164200497495125*x_65 + 0.0245185325167101*x_68 + 0.0272817263371625*x_69 - 0.0281431593261238*x_70 + 0.0123440077955735*x_71 + 0.0208540239734381*x_72 + 0.0140620491394937*x_73 + 0.00649607330050867*x_74 - 0.0137800907883638*x_75 + 0.0353166172516566*x_77 + 0.0384877580249818*x_80 - 0.0202415409959339*x_81 - 0.0427840372608226*x_82 - 0.0176089677906583*x_83 + 0.0335109463098377*x_84 + 0.00695851809451871*x_85 - 0.0184405106573492*x_87 + 0.00407463955464569*x_88 + 0.000743823753680244*x_89 + 0.000299393814722588*x_9 + 0.0225717550930916*x_90 - 0.0551987936735329*x_91 + 0.0317561155235768*x_93 + 0.0193010675235577*x_96 - 0.0106193678222673*x_97 + 0.000214297531678941*std::pow(-5.74399995803833*x_102 - 9.33600044250488, 2) - 0.00103433430666865*std::pow(-3.9255998134613*x_106 - 6.27424001693726, 2) - 0.000314432904829794*std::pow(-9.40464019775391*x_67 - 5.20007991790771, 2) + 0.000274472172404443*std::pow(-8.10671997070313*x_76 - 6.87735986709595, 2) - 0.000559871730172475*std::pow(-8.6048002243042*x_86 - 5.2065601348877, 2) + 0.0547391146334531*std::exp(0.376559644937515*x_10) + 0.0850891902307924*std::exp(0.440959572792053*x_100) - 0.0583180599620451*std::exp(0.390479624271393*x_11) + 0.0234113242974813*std::exp(0.597919881343842*x_113) + 0.0527369152543656*std::exp(0.555519819259644*x_12) + 0.0114683354197635*std::exp(0.735919654369354*x_13) + 0.0108503785579391*std::exp(1.00799989700317*x_14) + 0.0105855850428192*std::exp(1.20743978023529*x_16) - 0.0344760303053848*std::exp(0.256639748811722*x_3) - 0.0360843317724095*std::exp(0.296639710664749*x_4) + 0.0294059701995585*std::exp(0.39199960231781*x_5) - 0.0131047953081467*std::exp(0.326959699392319*x_6) + 0.0761305447242106*std::exp(0.531519830226898*x_62) + 0.0124270692954*std::exp(0.329039663076401*x_7) - 0.0166043324413647*std::exp(1.75759971141815*x_78) - 0.0449648983322035*std::exp(0.718479633331299*x_79) - 0.0398712457542474*std::exp(0.303359717130661*x_8) + 0.210803105439754*std::exp(0.286399722099304*x_98) - 0.0420623277830092*std::sin(1.14503979682922*x_101 - 7.75903987884521) - 0.0607726301314138*std::sin(1.16319978237152*x_105 + 7.80984020233154) - 0.0835558595324075*std::sin(1.21303987503052*x_108 + 4.7760796546936) + 0.0583338696952493*std::sin(1.15967988967896*x_110 + 1.62808001041412) - 0.106258494170381*std::sin(0.790319681167603*x_111 + 8.21183967590332) - 0.0766393983649234*std::sin(0.879999816417694*x_114 - 7.63015985488892) + 0.104172350495233*std::sin(0.722879588603973*x_115 - 4.3699197769165) + 0.0674141738681104*std::sin(1.02160000801086*x_120 + 8.18144035339355) + 0.00586918361596228*std::sin(4.38775968551636*x_66 - 0.206719815731049) - 0.0427361575974983*std::sin(1.18479979038239*x_92 - 1.17983984947205) - 0.0415537958789276*std::sin(1.35383975505829*x_94 - 1.54991984367371) + 0.0195322296374218*std::sin(1.47087955474854*x_95 + 4.54888010025024) - 0.0902245499078962*std::sin(0.986720025539398*x_99 - 1.37095963954926) - 1.83186199197091) + 1.19161629676819*std::sin(-0.0144562704464975*x_1 + 0.00763488173819742*x_101 + 0.0141963846916683*x_102 + 0.019710541354719*x_104 - 0.014454392641813*x_105 + 0.00436272025509447*x_106 + 0.00522590251309959*x_108 + 0.000772485760389759*x_111 - 0.00469652340831948*x_113 - 0.00765266162638218*x_114 - 0.00565739988435897*x_119 - 3.41611863707144e-5*x_12 - 2.87478480653367e-5*x_17 - 4.72035658019292e-6*x_18 - 1.44739969392176e-5*x_19 + 0.0031931060569978*x_2 + 2.54709964920725e-5*x_20 + 2.36578046005162e-5*x_21 + 2.22413047638385e-6*x_27 - 1.10176266773557e-5*x_28 - 1.12053948227644e-5*x_29 - 1.55370284925077e-6*x_30 - 0.00345934300805296*x_31 + 0.00616529524257445*x_32 + 0.0139936954863631*x_33 + 0.00237110008676056*x_34 - 0.0201113467371218*x_35 - 0.00136336695568042*x_36 - 0.000210542930215348*x_37 - 0.0157597397503221*x_38 + 0.0224331250089092*x_39 + 0.0224560745347642*x_40 - 0.0137735836877596*x_41 + 0.0188043797938269*x_42 - 0.00961017350472723*x_43 - 0.0221373257524492*x_44 - 0.0125372070696906*x_45 + 0.0165300429603762*x_46 - 0.0173738704945423*x_47 + 0.00399327089984372*x_48 + 0.0277687692862821*x_50 + 0.0120485564182291*x_51 - 0.0193321340237222*x_53 + 0.0130656577952193*x_54 + 0.0210872057355668*x_55 - 0.01631826474492*x_56 + 0.0175115302001839*x_57 - 0.0020942446246296*x_58 + 0.00766611442289141*x_59 + 0.0165959710908927*x_60 - 0.0117573796508383*x_62 + 0.00774066171715317*x_63 - 0.0096871930830683*x_64 + 0.00847286896356011*x_65 + 0.00458662204068098*x_67 + 0.00812886393561457*x_68 - 0.0048879036853198*x_69 + 0.00291814582660881*x_70 + 0.00296966810950851*x_73 - 0.00335690485980375*x_76 - 0.0103656130568298*x_78 + 0.00435475335570563*x_79 - 0.00430496919866586*x_80 + 0.0111795380505434*x_81 - 0.0108181103436742*x_82 + 0.010846506703515*x_83 + 0.00440096107258184*x_85 - 0.00756920133154055*x_87 + 0.010103490365548*x_88 - 0.00124361944398581*x_90 + 0.00266594320196573*x_91 - 0.000810888670164768*x_92 - 0.0198268560529295*x_94 + 0.00858472855472752*x_96 + 0.0101719162786287*x_98 + 2.20528568914901e-5*std::pow(-9.66063976287842*x_112 - 2.00952005386353, 2) + 6.71773636745318e-5*std::pow(-9.87936019897461*x_61 - 6.42767953872681, 2) - 3.19638036460441e-5*std::pow(-9.61999988555908*x_89 - 9.98340034484863, 2) + 6.39515697206661e-5*std::pow(-9.5272798538208*x_93 - 3.83999991416931, 2) - 0.0117206673817575*std::exp(0.377839624881744*x_10) + 0.0298498674378703*std::exp(0.306799709796906*x_109) + 0.0187668983863527*std::exp(0.389359623193741*x_11) + 0.0552657900284171*std::exp(0.204399809241295*x_110) + 0.0521799265911175*std::exp(0.284239739179611*x_116) - 0.00709159881474762*std::exp(0.753279685974121*x_13) + 0.00305901875588123*std::exp(1.06831991672516*x_14) - 0.000588686656434316*std::exp(1.01175999641418*x_15) + 0.0014265023938366*std::exp(1.3155996799469*x_16) - 0.00823516560465466*std::exp(0.302559703588486*x_22) - 0.00884466401943427*std::exp(0.454799562692642*x_23) - 0.0163807810946823*std::exp(0.549359798431396*x_24) - 0.0120239791546243*std::exp(0.551279842853546*x_25) - 0.0142620219882141*std::exp(0.568719863891602*x_26) + 0.00643371584435235*std::exp(0.254239767789841*x_3) + 0.0181070577962583*std::exp(0.290719717741013*x_4) - 0.00119544679991193*std::exp(0.375039637088776*x_5) - 0.0109317396974777*std::exp(0.336479663848877*x_6) + 0.0176705110586389*std::exp(0.322799682617188*x_7) + 0.00328068665280242*std::exp(1.67871999740601*x_72) - 0.0103662234104321*std::exp(0.906000137329102*x_74) - 0.00533470675099309*std::exp(1.59167993068695*x_75) - 0.00442519358311174*std::exp(1.82439970970154*x_77) - 0.00548732440827483*std::exp(0.296319723129272*x_8) + 0.00805324117234861*std::exp(0.453119575977325*x_84) + 0.00118387224780225*std::exp(2.19304013252258*x_86) - 0.0180498562209836*std::exp(0.321679681539536*x_9) + 0.000252245031772853*std::sin(8.43152046203613*x_100 + 6.17775964736938) + 0.0194310809732812*std::sin(1.13871991634369*x_103 - 4.73816013336182) + 0.00339600460358358*std::sin(2.24272012710571*x_107 + 0.576879858970642) + 0.0256383303500995*std::sin(0.942240059375763*x_115 - 7.77415990829468) - 0.0355345843006127*std::sin(0.655439972877502*x_117 - 7.4203200340271) - 0.0155572050458103*std::sin(0.86495977640152*x_118 - 1.23255980014801) - 0.00523510088650231*std::sin(1.39743959903717*x_120 + 7.59143972396851) + 0.00139657716180297*std::sin(3.70088005065918*x_66 - 5.78968000411987) + 0.00565489835592653*std::sin(2.39439988136292*x_71 + 2.39183974266052) + 0.026230343008935*std::sin(1.02312004566193*x_95 - 1.41087961196899) + 0.0142807520554028*std::sin(0.921440064907074*x_97 - 4.54048013687134) + 0.0203872846601827*std::sin(0.982560038566589*x_99 - 1.37295973300934) + 7.52430872253326 + 0.433844442675783*std::exp(-0.012639987282455*x_52) + 0.200984478762083*std::exp(-0.015439985319972*x_49)) - 0.788009773939848);
}

inline float score_9(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.00303264977169104*x_1 - 0.00395418461756403*x_100 - 0.00658816933999467*x_101 + 0.00628372392785457*x_103 + 0.00535729914956371*x_104 + 0.00018671235705001*x_105 + 0.00438155987567624*x_106 + 2.46229878612837e-5*x_107 - 0.000709523014311317*x_108 + 0.00264246999241866*x_109 - 0.00124621643557387*x_111 + 0.00591653615457349*x_112 - 0.00407523059269562*x_113 + 0.00134566424894254*x_114 - 0.00191449234943381*x_116 - 0.00273663420131001*x_117 - 0.0046634479064663*x_118 - 0.00289923288689325*x_119 - 3.44864037636818e-5*x_15 - 5.96938860154846e-6*x_17 - 1.00297827313507e-5*x_18 - 6.06780418965092e-5*x_19 - 0.00285154314465093*x_2 - 3.51654447389898e-5*x_20 - 1.27056174437374e-5*x_21 - 8.54038302516009e-7*x_22 + 1.07695187894052e-5*x_23 - 3.44648474400811e-5*x_24 - 3.18170779893481e-6*x_25 - 1.10599647485418e-5*x_26 + 2.67009946195441e-6*x_27 - 1.03689286334822e-5*x_28 - 6.62480057674942e-6*x_29 - 1.16930774503927e-5*x_30 - 0.0022189575652143*x_31 - 0.00418347348222389*x_32 - 0.0137400796008581*x_33 + 0.00988168861455908*x_34 - 0.00288900613600858*x_35 + 0.0139372640299027*x_36 - 0.00111039160380298*x_37 - 0.00626653597778753*x_38 + 0.0119248666106235*x_39 - 0.0153326248848245*x_40 + 0.000169546293193284*x_41 + 0.00319914073506519*x_42 - 0.00381876409307469*x_43 + 0.0143779030292375*x_44 - 0.00613880909760993*x_45 + 0.0092558756444482*x_46 + 0.00089331291056509*x_47 - 0.00677418689756233*x_48 + 0.00935066380265366*x_49 + 0.000586010840324772*x_50 - 0.0072061493467459*x_51 - 0.00813273407932248*x_52 - 0.00138210858768518*x_53 - 0.00232495949704327*x_54 + 0.000123986504898972*x_55 - 0.00743804721507458*x_56 + 0.00639546165827559*x_57 - 0.0145071265938256*x_58 + 0.00169931226739682*x_59 + 0.0120597884817781*x_60 - 0.000769386874578585*x_61 + 0.000155952610465123*x_62 - 0.00152279705747863*x_63 + 0.00116088666853924*x_64 + 0.00230864703125953*x_65 - 0.00344728780783526*x_68 - 0.0038357908457491*x_69 + 0.00597729433830326*x_70 - 0.00437741129943758*x_71 + 9.96365426263065e-5*x_72 + 0.00106142007691197*x_73 - 0.00264755359539082*x_74 + 0.00193747072477581*x_75 + 0.00486890502457491*x_76 - 0.000780051586779062*x_77 + 0.00189829850829055*x_78 - 0.00541135073642801*x_80 + 0.00284594591619725*x_81 + 0.00601540446675123*x_82 + 0.00240195395373099*x_83 - 0.00471161463534549*x_84 - 0.00185190781312781*x_85 + 0.00368978416919317*x_86 + 0.00259272236280909*x_87 - 0.000572891352632149*x_88 - 0.000104581077823177*x_89 - 4.20945522139656e-5*x_9 - 0.000318508495814812*x_90 + 0.00776091017308228*x_91 - 0.00228216249641072*x_92 - 0.00320763111531051*x_93 + 0.000338720611331076*x_95 - 0.00271371603120289*x_96 + 0.00149307537862107*x_97 + 0.00451628182286479*x_98 - 3.0130076818526e-5*std::pow(-5.74399995803833*x_102 - 9.33600044250488, 2) + 0.000145426649909593*std::pow(-3.9255998134613*x_106 - 6.27424001693726, 2) + 5.84805856595478e-5*std::pow(-5.06224012374878*x_110 - 6.06215953826904, 2) + 4.13668142527743e-5*std::pow(-4.91359996795654*x_120 - 9.95232009887695, 2) - 3.20585389823923e-5*std::pow(-9.72855949401855*x_66 - 3.0403196811676, 2) + 4.42090373256734e-5*std::pow(-9.40464019775391*x_67 - 5.20007991790771, 2) + 2.6884698574305e-5*std::pow(-9.34815979003906*x_68 - 7.77871990203857, 2) - 2.363117152304e-5*std::pow(9.97795963287354*x_69 + 6.79199981689453, 2) - 2.43866861801968e-5*std::pow(-7.12376022338867*x_75 - 8.96928024291992, 2) - 3.85905874617513e-5*std::pow(-8.10671997070313*x_76 - 6.87735986709595, 2) + 4.90802854597764e-5*std::pow(-4.9159197807312*x_84 - 9.26272010803223, 2) + 7.87175573440142e-5*std::pow(-8.6048002243042*x_86 - 5.2065601348877, 2) - 3.4256274639082e-5*std::pow(-9.30655956268311*x_87 - 4.45368003845215, 2) - 3.81785030394482e-5*std::pow(-7.25176000595093*x_91 - 4.82791996002197, 2) + 0.00421744072809815*std::pow(-0.227858382512793*x_1 + 0.182267280081284*x_100 + 0.0751842675960967*x_104 - 0.0338311641517373*x_108 - 0.0208562855622508*x_111 + 0.0865248411609842*x_113 + 0.0968393021952683*x_114 - 0.11593314848997*x_115 - 0.0122177710804934*x_116 + 0.0108321836451376*x_120 + 0.000485928118274086*x_17 - 5.42339692112193e-5*x_18 - 0.000211787881603183*x_19 + 0.0964098768405773*x_2 - 0.000933314804583327*x_20 - 0.000603105371842055*x_21 - 0.0174170214185634*x_32 - 0.082505737266161*x_33 - 0.244629185528352*x_34 + 0.353071928405012*x_35 + 0.0702861626446405*x_36 - 0.306576649485154*x_37 - 0.214041509597879*x_38 - 0.201387908556292*x_39 + 0.405718793176044*x_40 + 0.344325704410766*x_41 - 0.0549823190870161*x_42 + 0.265287438221738*x_43 + 0.0414662445453005*x_44 - 0.147123547033707*x_45 + 0.343346120395332*x_46 - 0.269072416978151*x_47 + 0.268945849396564*x_48 - 0.228056156742031*x_49 + 0.0543939933138745*x_50 - 0.229706976891047*x_51 - 0.198774631456013*x_52 - 0.0159341554731802*x_53 - 0.241287416287836*x_54 - 0.209409005407109*x_55 + 0.0905890911669322*x_56 + 0.167455883928553*x_57 - 0.263815615615721*x_58 + 0.132087294252268*x_59 + 0.170411917263491*x_60 + 0.00294152881211932*x_62 - 0.0168839479335264*x_63 + 0.0701577285651598*x_65 - 0.0840519023479689*x_67 + 0.0683419750686723*x_69 + 0.0874471993142856*x_70 + 0.0936377011801262*x_72 - 0.140605657092594*x_73 + 0.00305941761598021*x_74 + 0.0624381610390958*x_75 - 0.00974326918126225*x_76 - 0.0687600864968023*x_77 + 0.00875656176421019*x_80 + 0.0244895453012821*x_85 + 0.151080040835868*x_87 - 0.00519536300768912*x_88 - 0.113890242315781*x_93 + 0.071092555604086*x_94 + 0.0971353351866808*x_96 - 0.0781733864484539*x_99 + 0.000361905093683532*std::pow(2.20000004768372 - 9.95748043060303*x_86, 2) + 0.0497967991630355*std::pow(8.37551975250244 - 0.210639804601669*x_31, 2) + 0.00701129108292564*std::pow(-2.63048005104065*x_102 - 7.50127983093262, 2) + 0.000778072981435854*std::pow(-9.03791999816895*x_107 - 8.22247982025146, 2) - 0.00121738409831908*std::pow(-8.81511974334717*x_61 - 9.24431991577148, 2) + 0.00122191248700637*std::pow(-8.96744060516357*x_78 - 5.9543194770813, 2) + 0.000981153823627415*std::pow(-9.76488018035889*x_81 - 6.16847991943359, 2) - 0.00136974400763289*std::pow(-8.79600048065186*x_82 - 6.76008033752441, 2) - 0.00100059833386727*std::pow(-8.73871994018555*x_84 - 6.90944004058838, 2) - 0.000343978135135294*std::pow(-9.98104000091553*x_89 - 6.3045597076416, 2) + 0.000672012938494095*std::pow(9.99804019927979*x_90 + 6.80000019073486, 2) + 0.00106758433586783*std::pow(-9.12360000610352*x_92 - 4.86263990402222, 2) + 0.0511113801594196*std::exp(0.383999645709991*x_10) + 0.031813590471973*std::exp(0.390159606933594*x_11) - 0.233914804541628*std::exp(0.438959568738937*x_112) - 0.990594049564583*std::exp(0.17751981317997*x_118) - 0.0896783509927535*std::exp(0.559599876403809*x_12) - 0.108175696014136*std::exp(0.756479620933533*x_13) + 0.0579644487622247*std::exp(1.05224001407623*x_14) - 0.0283617827934098*std::exp(1.22631978988647*x_15) - 0.0498850942569516*std::exp(1.24463975429535*x_16) - 0.0906115780998395*std::exp(0.317999690771103*x_22) - 0.203007456071639*std::exp(0.509839773178101*x_23) - 0.225971521896785*std::exp(0.603119909763336*x_24) - 0.190994000578396*std::exp(0.649999976158142*x_25) + 0.203969926323868*std::exp(0.779999673366547*x_26) - 0.145457651667477*std::exp(0.663999974727631*x_27) + 0.710410852505946*std::exp(0.900000095367432*x_28) + 0.74719851003421*std::exp(1.0239999294281*x_29) + 0.140026640668066*std::exp(0.253599762916565*x_3) + 0.86206626495806*std::exp(1.0*x_30) - 0.163233336054171*std::exp(0.291999727487564*x_4) + 0.188851824964019*std::exp(0.391519606113434*x_5) + 0.325204897334019*std::exp(0.33903968334198*x_6) + 0.057582387665381*std::exp(1.52415978908539*x_64) + 0.120694348010567*std::exp(0.965040028095245*x_68) + 0.00883157547213359*std::exp(0.319119691848755*x_7) - 0.249380647437221*std::exp(0.763999700546265*x_71) - 0.204856239727816*std::exp(0.5971999168396*x_79) + 0.257147806991034*std::exp(0.302559703588486*x_8) - 0.0233760353585291*std::exp(2.54519987106323*x_83) - 0.193167589661514*std::exp(0.324639678001404*x_9) - 0.414573565904705*std::exp(0.367199659347534*x_97) - 0.311746819890182*std::sin(0.997919976711273*x_101 + 8.19495964050293) + 0.204297596337897*std::sin(1.221599817276*x_103 + 1.38991963863373) + 0.418249780157485*std::sin(0.743679583072662*x_105 - 4.37695980072021) + 0.272329788487333*std::sin(0.938000082969666*x_106 - 1.35967969894409) - 0.394333694029232*std::sin(0.799759685993195*x_109 - 4.20560026168823) - 0.326596768178504*std::sin(0.914640069007874*x_110 - 1.37599968910217) + 0.0574109738903017*std::sin(1.37159967422485*x_117 - 4.98199987411499) + 0.171858437048078*std::sin(1.09279990196228*x_119 + 1.55415987968445) + 0.00990949559775467*std::sin(5.21920013427734*x_66 - 9.41256046295166) + 0.0304066107931511*std::sin(3.36391997337341*x_91 - 8.0447998046875) - 0.206885434042299*std::sin(0.978640019893646*x_95 + 8.21375942230225) + 0.31557866618888*std::sin(1.16767990589142*x_98 - 7.76968002319336) - 6.21875680377939, 2) - 0.00146195478737354*std::pow(0.583353795190693*x_1 - 0.0886312551264846*x_101 - 0.36478898407292*x_104 - 0.343156371557188*x_105 - 0.161587838527723*x_106 + 0.204571515711798*x_107 + 0.214400943952685*x_111 - 0.248795656379962*x_112 - 0.117232475005977*x_114 + 0.28901851953524*x_117 - 0.000501729570211355*x_17 - 5.50083140719954e-5*x_18 + 0.00029502967391408*x_19 - 0.0253268232447681*x_2 + 0.00217770612043807*x_20 + 0.00103321289785458*x_21 - 0.000391093268600246*x_22 - 0.000356527129484829*x_23 + 0.000586146578154402*x_24 - 0.000555757581743323*x_26 + 4.98370166218888e-5*x_28 + 0.000161807517782432*x_29 - 9.39692439533129e-5*x_30 + 0.168974921351172*x_33 + 0.322868402743178*x_34 + 0.356605242830109*x_35 - 0.0616900732479042*x_36 + 0.532530142922124*x_37 + 0.338849427289563*x_38 - 0.637826986202161*x_39 - 0.100953118137893*x_40 + 0.141405842462745*x_41 - 0.422250565868409*x_42 + 0.121359511572996*x_43 + 0.0089894334528554*x_44 - 0.0200860151837525*x_45 + 0.488218198522699*x_46 - 0.125821515569841*x_47 + 0.482847189274693*x_48 + 0.572765465493029*x_49 - 0.153611315921291*x_50 - 0.035723269861967*x_51 - 0.114809096167055*x_52 - 0.540844469158518*x_53 - 0.572109247291336*x_54 - 0.619342897962215*x_55 - 0.37750997206427*x_56 + 0.139416798276474*x_57 - 0.390405009771522*x_58 + 0.124607919773006*x_59 + 0.280451988071716*x_60 - 0.119346501527021*x_62 + 0.0232614502990779*x_63 - 0.358550155955515*x_64 + 0.131802601603637*x_68 + 0.351334701940526*x_69 + 0.0954013031200937*x_70 - 0.28099844127417*x_71 + 0.222879748726822*x_72 - 0.0908371104188191*x_75 + 0.129238817365074*x_76 - 0.152764562938834*x_78 - 0.0393829720992841*x_79 - 0.241311283826374*x_81 - 0.250617863157809*x_82 - 0.0853237142563575*x_83 - 0.301109545775539*x_84 - 0.0718394723761956*x_86 - 0.0376282096184486*x_87 + 0.115143277331969*x_88 + 0.33039554190996*x_89 + 0.0144951108581128*x_90 + 0.202040470861839*x_92 + 0.178715044130178*x_93 + 0.392730964729296*x_96 + 0.415033637336131*x_97 - 0.563167933788904*x_98 - 0.137504182159442*x_99 + 0.162373431626787*std::pow(8.27943992614746 - 0.201439797878265*x_31, 2) - 0.000639202225453116*std::pow(-9.83440017700195*x_108 - 4.4474401473999, 2) - 0.000597090039010231*std::pow(-9.9629602432251*x_109 - 3.39999985694885, 2) - 0.000488169033903068*std::pow(-9.99868011474609*x_116 - 3.37999987602234, 2) - 0.0188885649101969*std::pow(-2.03575992584229*x_119 - 5.2993597984314, 2) + 0.00213366216494763*std::pow(-5.40767955780029*x_120 - 9.19095993041992, 2) + 0.00223253249589324*std::pow(-8.49944019317627*x_65 - 8.27271938323975, 2) + 0.00183419798029813*std::pow(-9.9993200302124*x_73 - 6.0, 2) - 0.00172004419705023*std::pow(-8.14783954620361*x_74 - 9.39192008972168, 2) + 0.00153152444508076*std::pow(-9.59967994689941*x_77 - 1.02799999713898, 2) - 0.00245461703699941*std::pow(-8.69464015960693*x_80 - 7.84104013442993, 2) - 0.000692297383975519*std::pow(-9.93639945983887*x_91 - 4.7960000038147, 2) + 0.401298776807726*std::exp(0.37863963842392*x_10) - 0.045270641989913*std::exp(0.398079603910446*x_11) + 0.18160670948047*std::exp(0.554959833621979*x_12) + 0.100798453834265*std::exp(0.746319591999054*x_13) - 0.0940657878558656*std::exp(1.0595999956131*x_14) - 0.0543137659029834*std::exp(1.26079976558685*x_15) + 0.0222356817122209*std::exp(1.17711985111237*x_16) + 0.589173646509313*std::exp(0.59999942779541*x_25) + 0.624132269286133*std::exp(0.625759959220886*x_27) + 0.17524124653847*std::exp(0.254479765892029*x_3) + 0.0836903506688327*std::exp(0.292959719896317*x_4) + 0.115349645814663*std::exp(0.39087963104248*x_5) + 0.459899192329886*std::exp(0.33751967549324*x_6) - 0.0645488135855036*std::exp(2.69063973426819*x_61) - 0.149103572982639*std::exp(1.45271956920624*x_67) - 0.0550547358330919*std::exp(0.334319651126862*x_7) + 0.436966884731544*std::exp(0.300399720668793*x_8) + 0.0472316753408647*std::exp(2.24656009674072*x_85) + 0.126167977506767*std::exp(0.318799704313278*x_9) - 0.979442045256231*std::exp(0.273759722709656*x_94) + 2.34418478292574*std::exp(0.158639833331108*x_95) + 0.503535221130793*std::sin(1.18831980228424*x_100 + 4.79408025741577) + 0.989605003109375*std::sin(0.630799949169159*x_102 + 8.37952041625977) + 0.860413911135069*std::sin(0.748079597949982*x_103 - 1.14335989952087) + 0.510177192421008*std::sin(1.08351993560791*x_110 - 4.62207984924316) + 0.653303700062324*std::sin(0.946880042552948*x_113 - 1.34919965267181) - 0.104633379625018*std::sin(1.5771199464798*x_115 - 5.18495988845825) + 0.237979884676713*std::sin(1.20855975151062*x_118 + 4.79016017913818) - 0.0768011418229637*std::sin(2.92903971672058*x_66 + 2.37191987037659) - 28.4946205298555 + 7.9922477568199*std::exp(-0.0245599746704102*x_32), 2) - 0.00769627963496567*std::exp(0.376559644937515*x_10) - 0.00540702686588896*std::exp(0.383119642734528*x_10) - 0.01196347815112*std::exp(0.440959572792053*x_100) + 0.0139940640554115*std::exp(0.226719796657562*x_102) - 0.00893180998438153*std::exp(0.325359672307968*x_103) + 0.00432428442493277*std::exp(0.290799736976624*x_104) + 0.00471328177900286*std::exp(0.386399626731873*x_11) + 0.00819947674057367*std::exp(0.390479624271393*x_11) - 0.00329161513891508*std::exp(0.597919881343842*x_113) - 0.00405826433039314*std::exp(0.310719698667526*x_115) + 0.0266711523845196*std::exp(0.193679809570313*x_117) - 0.00741477186105303*std::exp(0.555519819259644*x_12) - 0.00200388664897053*std::exp(0.563039839267731*x_12) - 0.00161243960427778*std::exp(0.735919654369354*x_13) + 0.002328303710113*std::exp(0.749999642372131*x_13) - 0.00152555531974389*std::exp(1.00799989700317*x_14) + 0.000419324118961152*std::exp(1.05879998207092*x_14) + 0.0013354409749945*std::exp(1.23447978496552*x_15) - 0.00148832554444455*std::exp(1.20743978023529*x_16) + 0.000529162771942558*std::exp(1.22799980640411*x_16) + 0.00274451784646579*std::exp(0.294799715280533*x_22) + 0.00475361655825124*std::exp(0.25279974937439*x_3) + 0.00484730474196664*std::exp(0.256639748811722*x_3) - 0.00568922614663038*std::exp(0.291599720716476*x_4) + 0.00507343075643423*std::exp(0.296639710664749*x_4) - 0.00413445798509424*std::exp(0.39199960231781*x_5) - 0.00136178477942794*std::exp(0.395119607448578*x_5) + 0.00184252467227237*std::exp(0.326959699392319*x_6) + 0.000957151005851599*std::exp(0.332639664411545*x_6) - 0.0107038991200948*std::exp(0.531519830226898*x_62) - 0.0013681260176056*std::exp(1.60343992710114*x_65) + 0.00295681981798168*std::exp(0.318159699440002*x_7) - 0.00174723688866614*std::exp(0.329039663076401*x_7) + 0.00233455704346699*std::exp(1.75759971141815*x_78) + 0.00632203194442878*std::exp(0.718479633331299*x_79) - 0.00251287004950786*std::exp(0.960240066051483*x_79) + 0.00764350065878618*std::exp(0.301119714975357*x_8) + 0.00560586810316424*std::exp(0.303359717130661*x_8) - 0.00307079476470071*std::exp(1.0*x_80) - 0.00160781478030029*std::exp(1.51543974876404*x_81) - 0.00189219968180924*std::exp(1.54271984100342*x_82) + 0.00332331273148414*std::exp(0.91376006603241*x_88) - 0.000122839319147087*std::exp(3.14815998077393*x_89) - 0.00578915598459759*std::exp(0.326159685850143*x_9) + 0.00800572521578436*std::exp(0.413439601659775*x_94) - 0.0296387630353084*std::exp(0.286399722099304*x_98) - 0.00239512115926155*std::exp(0.486799538135529*x_99) + 0.00591393264000264*std::sin(1.14503979682922*x_101 - 7.75903987884521) + 0.00854458751800596*std::sin(1.16319978237152*x_105 + 7.80984020233154) + 0.00745976409041987*std::sin(0.879599809646606*x_107 + 8.1738395690918) + 0.0117478929721*std::sin(1.21303987503052*x_108 + 4.7760796546936) - 0.00820169957754334*std::sin(1.15967988967896*x_110 + 1.62808001041412) + 0.0149398668612341*std::sin(0.790319681167603*x_111 + 8.21183967590332) + 0.0107754435712321*std::sin(0.879999816417694*x_114 - 7.63015985488892) - 0.0146465565804565*std::sin(0.722879588603973*x_115 - 4.3699197769165) + 0.00474136842687106*std::sin(1.02023994922638*x_118 - 1.39911961555481) + 0.0109539133550996*std::sin(0.705280065536499*x_119 - 1.23703980445862) - 0.00947838372840784*std::sin(1.02160000801086*x_120 + 8.18144035339355) - 0.000825202940162264*std::sin(4.38775968551636*x_66 - 0.206719815731049) + 0.00600867262097259*std::sin(1.18479979038239*x_92 - 1.17983984947205) + 0.0058424334248012*std::sin(1.35383975505829*x_94 - 1.54991984367371) - 0.00274621725598925*std::sin(1.47087955474854*x_95 + 4.54888010025024) - 0.00613454784062795*std::sin(1.2203197479248*x_96 - 7.82216024398804) - 0.0104149836674503*std::sin(0.741679608821869*x_97 - 1.1515998840332) + 0.0126855059801372*std::sin(0.986720025539398*x_99 - 1.37095963954926) + 0.0558575205504894*std::sin(-0.0830317888393084*x_1 + 0.0438521049149778*x_101 + 0.0815390954646802*x_102 + 0.113210493241015*x_104 - 0.0830210033823939*x_105 + 0.0250579475755273*x_106 + 0.030015766208056*x_108 + 0.00443688949895064*x_111 - 0.0269751967744166*x_113 - 0.0439542264079872*x_114 - 0.032494137012457*x_119 - 0.000196209971564322*x_12 - 0.000165117639364854*x_17 - 2.71120862233024e-5*x_18 - 8.31336036473427e-5*x_19 + 0.0183400904712871*x_2 + 0.000146296543778962*x_20 + 0.000135882200271621*x_21 + 1.27746317938399e-5*x_27 - 6.32814151596183e-5*x_28 - 6.43598900718046e-5*x_29 - 8.92392871145257e-6*x_30 - 0.0198692629077774*x_31 + 0.0354113112789381*x_32 + 0.0803749191747307*x_33 + 0.0136187741125491*x_34 - 0.115512579937614*x_35 - 0.00783070554701572*x_36 - 0.00120928535391959*x_37 - 0.0905184631094283*x_38 + 0.128848066701523*x_39 + 0.128979880795054*x_40 - 0.0791106735693151*x_41 + 0.108005816443029*x_42 - 0.0551974937178184*x_43 - 0.127149098666018*x_44 - 0.0720093563480233*x_45 + 0.0949428167984501*x_46 - 0.0997894686297764*x_47 + 0.022935958991713*x_48 + 0.159494151429955*x_50 + 0.0692027169828767*x_51 - 0.111037053160542*x_53 + 0.075044593494179*x_54 + 0.12111757457269*x_55 - 0.0937264363957998*x_56 + 0.100580138094132*x_57 - 0.0120286126420824*x_58 + 0.0440314945915887*x_59 + 0.0953214850470744*x_60 - 0.0675302989166558*x_62 + 0.0444596683185947*x_63 - 0.0556398673845934*x_64 + 0.048665212044086*x_65 + 0.0263439615478287*x_67 + 0.0466893668255182*x_68 - 0.028074418513987*x_69 + 0.016760814552691*x_70 + 0.0170567406236704*x_73 - 0.019280893817285*x_76 - 0.0595364757258812*x_78 + 0.0250121884767191*x_79 - 0.0247262455960732*x_80 + 0.0642113777664307*x_81 - 0.0621354627405942*x_82 + 0.062298561553862*x_83 + 0.0252775895291283*x_85 - 0.0434748595060325*x_87 + 0.058030934166386*x_88 - 0.00714291749394507*x_90 + 0.0153122504052793*x_91 - 0.00465746245426818*x_92 - 0.113878564407535*x_94 + 0.049307694625457*x_96 + 0.0584239488092073*x_98 + 0.000126663938911114*std::pow(-9.66063976287842*x_112 - 2.00952005386353, 2) + 0.000385843409339134*std::pow(-9.87936019897461*x_61 - 6.42767953872681, 2) - 0.000183588969552135*std::pow(-9.61999988555908*x_89 - 9.98340034484863, 2) + 0.000367315570958704*std::pow(-9.5272798538208*x_93 - 3.83999991416931, 2) - 0.0673194364133971*std::exp(0.377839624881744*x_10) + 0.171447255303881*std::exp(0.306799709796906*x_109) + 0.107790536276383*std::exp(0.389359623193741*x_11) + 0.317427473749904*std::exp(0.204399809241295*x_110) + 0.29970334758188*std::exp(0.284239739179611*x_116) - 0.0407316767833351*std::exp(0.753279685974121*x_13) + 0.0175699396558643*std::exp(1.06831991672516*x_14) - 0.00338121138024334*std::exp(1.01175999641418*x_15) + 0.00819333354215894*std::exp(1.3155996799469*x_16) - 0.04729992663551*std::exp(0.302559703588486*x_22) - 0.0508006735163305*std::exp(0.454799562692642*x_23) - 0.0940855085625583*std::exp(0.549359798431396*x_24) - 0.0690615537299177*std::exp(0.551279842853546*x_25) - 0.0819160932641433*std::exp(0.568719863891602*x_26) + 0.0369530258455981*std::exp(0.254239767789841*x_3) + 0.104000641452052*std::exp(0.290719717741013*x_4) - 0.0068662305832113*std::exp(0.375039637088776*x_5) - 0.0627881102229361*std::exp(0.336479663848877*x_6) + 0.101493268843698*std::exp(0.322799682617188*x_7) + 0.0188431229487289*std::exp(1.67871999740601*x_72) - 0.0595399813846619*std::exp(0.906000137329102*x_74) - 0.0306406999030246*std::exp(1.59167993068695*x_75) - 0.0254167726403472*std::exp(1.82439970970154*x_77) - 0.0315172826384864*std::exp(0.296319723129272*x_8) + 0.0462550159786533*std::exp(0.453119575977325*x_84) + 0.00679975038209457*std::exp(2.19304013252258*x_86) - 0.103672095501209*std::exp(0.321679681539536*x_9) + 0.00144880771921382*std::sin(8.43152046203613*x_100 + 6.17775964736938) + 0.111605370020169*std::sin(1.13871991634369*x_103 - 4.73816013336182) + 0.0195054691447329*std::sin(2.24272012710571*x_107 + 0.576879858970642) + 0.147257651252483*std::sin(0.942240059375763*x_115 - 7.77415990829468) - 0.204098291537977*std::sin(0.655439972877502*x_117 - 7.4203200340271) - 0.089355174218293*std::sin(0.86495977640152*x_118 - 1.23255980014801) - 0.0300685984652322*std::sin(1.39743959903717*x_120 + 7.59143972396851) + 0.00802145341883254*std::sin(3.70088005065918*x_66 - 5.78968000411987) + 0.0324797691032963*std::sin(2.39439988136292*x_71 + 2.39183974266052) + 0.15065796603357*std::sin(1.02312004566193*x_95 - 1.41087961196899) + 0.0820236722548322*std::sin(0.921440064907074*x_97 - 4.54048013687134) + 0.117097471382828*std::sin(0.982560038566589*x_99 - 1.37295973300934) - 0.0671775290001895 + 2.49185156618946*std::exp(-0.012639987282455*x_52) + 1.15438493367389*std::exp(-0.015439985319972*x_49)) + 0.0768871203366552 - 0.000257749779537826*std::exp(-2.33999991416931*x_67));
}

inline float score_10(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.0035285408797991*x_1 - 0.000536105206685889*x_101 - 0.00220650461763245*x_104 - 0.00207565510876167*x_105 - 0.000977398790620813*x_106 + 0.00123739480566091*x_107 + 0.00129685021618359*x_111 - 0.00150489403084482*x_112 - 0.000709105835787689*x_114 + 0.00174819066852174*x_117 - 3.0348192018123e-6*x_17 - 3.3272961714154e-7*x_18 + 1.78455042847425e-6*x_19 - 0.000153194736901295*x_2 + 1.31723237827613e-5*x_20 + 6.24961040396387e-6*x_21 - 2.36561173930327e-6*x_22 - 2.1565310134537e-6*x_23 + 3.54543362813998e-6*x_24 - 3.36161924822751e-6*x_26 + 3.01449912432776e-7*x_28 + 9.78727567834706e-7*x_29 - 5.68393180033551e-7*x_30 + 0.00102208114966243*x_33 + 0.00195293896648487*x_34 + 0.00215700349882081*x_35 - 0.000373145674421942*x_36 + 0.00322112308948247*x_37 + 0.00204960363015533*x_38 - 0.00385803369003142*x_39 - 0.000610636644913398*x_40 + 0.000855323647305871*x_41 - 0.00255407335217205*x_42 + 0.00073406910397795*x_43 + 5.43745214073134e-5*x_44 - 0.000121494582314267*x_45 + 0.00295309276454794*x_46 - 0.000761058494701886*x_47 + 0.00292060506008177*x_48 + 0.00346449509061419*x_49 - 0.000929151078293451*x_50 - 0.000216079880009764*x_51 - 0.000694447507735527*x_52 - 0.00327141407970996*x_53 - 0.00346052581370225*x_54 - 0.00374622870732938*x_55 - 0.00228345024913253*x_56 + 0.000843292485803464*x_57 - 0.00236144865776843*x_58 + 0.0007537177995423*x_59 + 0.0016963741607415*x_60 - 0.000721892979819287*x_62 + 0.000140701884483121*x_63 - 0.00216876772411124*x_64 + 0.000797236379803236*x_68 + 0.00212512349882618*x_69 + 0.000577055297866564*x_70 - 0.0016996795004507*x_71 + 0.00134813609021753*x_72 - 0.000549447796788314*x_75 + 0.000781728779497325*x_76 - 0.000924029310785765*x_78 - 0.000238216376007094*x_79 - 0.00145962319394841*x_81 - 0.00151591604040418*x_82 - 0.000516098834449921*x_83 - 0.001821325840898*x_84 - 0.000434536497666465*x_86 - 0.00022760231778203*x_87 + 0.000696468874376805*x_88 + 0.00199846848643811*x_89 + 8.76767951828466e-5*x_90 + 0.00122208523658754*x_92 + 0.00108099637689388*x_93 + 0.00237551769652457*x_96 + 0.00251042020795208*x_97 - 0.00340644235616322*x_98 - 0.000831723615913615*x_99 + 0.000982150619421433*std::pow(8.27943992614746 - 0.201439797878265*x_31, 2) - 3.8663521203845e-6*std::pow(-9.83440017700195*x_108 - 4.4474401473999, 2) - 3.61162750450561e-6*std::pow(-9.9629602432251*x_109 - 3.39999985694885, 2) - 2.9527953817733e-6*std::pow(-9.99868011474609*x_116 - 3.37999987602234, 2) - 0.00011425154682431*std::pow(-2.03575992584229*x_119 - 5.2993597984314, 2) + 1.29059144463735e-5*std::pow(-5.40767955780029*x_120 - 9.19095993041992, 2) + 1.35039529050533e-5*std::pow(-8.49944019317627*x_65 - 8.27271938323975, 2) + 1.10945409260794e-5*std::pow(-9.9993200302124*x_73 - 6.0, 2) - 1.04040572194597e-5*std::pow(-8.14783954620361*x_74 - 9.39192008972168, 2) + 9.26375495870832e-6*std::pow(-9.59967994689941*x_77 - 1.02799999713898, 2) - 1.48472790109688e-5*std::pow(-8.69464015960693*x_80 - 7.84104013442993, 2) - 4.18750960476235e-6*std::pow(-9.93639945983887*x_91 - 4.7960000038147, 2) - 0.00319067318923771*std::pow(-0.252912624043515*x_1 + 0.202308537321613*x_100 + 0.0834511778536437*x_104 - 0.0375510806567864*x_108 - 0.0231495451305311*x_111 + 0.0960387078221459*x_113 + 0.107487298727635*x_114 - 0.128680615015683*x_115 - 0.013561180018282*x_116 + 0.0120232398720692*x_120 + 0.000539358500371724*x_17 - 6.0197282690421e-5*x_18 - 0.000235075086052062*x_19 + 0.107010655770338*x_2 - 0.00103593773326543*x_20 - 0.000669420016438281*x_21 - 0.0193321155948417*x_32 - 0.0915776820695111*x_33 - 0.271527466083587*x_34 + 0.391894065534334*x_35 + 0.0780145002012699*x_36 - 0.340286383308308*x_37 - 0.237576512435726*x_38 - 0.223531580633193*x_39 + 0.45032973320681*x_40 + 0.382186147675604*x_41 - 0.061027917616831*x_42 + 0.294457203577642*x_43 + 0.0460256787638403*x_44 - 0.163300563835062*x_45 + 0.381098853185569*x_46 - 0.298658360887181*x_47 + 0.298517876526567*x_48 - 0.253132144601562*x_49 + 0.0603749022946086*x_50 - 0.254964481209533*x_51 - 0.220630959811191*x_52 - 0.017686200648831*x_53 - 0.267818251534418*x_54 - 0.232434639760866*x_55 + 0.100549843741034*x_56 + 0.185868549354417*x_57 - 0.292823546244919*x_58 + 0.146610995056429*x_59 + 0.189149614282793*x_60 + 0.00326496555609901*x_62 - 0.0187404278437837*x_63 + 0.0778719441113869*x_65 - 0.0932938562287942*x_67 + 0.0758565388568224*x_69 + 0.0970624841620234*x_70 + 0.103933664646016*x_72 - 0.156065997214976*x_73 + 0.00339581686119916*x_74 + 0.0693035690620804*x_75 - 0.0108145934690684*x_76 - 0.0763206238611343*x_77 + 0.00971939232150554*x_80 + 0.0271823011094711*x_85 + 0.167692095182215*x_87 - 0.00576662081351996*x_88 - 0.126413080437884*x_93 + 0.0789095603572074*x_94 + 0.107815882121565*x_96 - 0.0867689662281185*x_99 + 0.000401698484334134*std::pow(2.20000004768372 - 9.95748043060303*x_86, 2) + 0.0552722221864457*std::pow(8.37551975250244 - 0.210639804601669*x_31, 2) + 0.00778221984269578*std::pow(-2.63048005104065*x_102 - 7.50127983093262, 2) + 0.000863626245662719*std::pow(-9.03791999816895*x_107 - 8.22247982025146, 2) - 0.00135124195730407*std::pow(-8.81511974334717*x_61 - 9.24431991577148, 2) + 0.00135626826642188*std::pow(-8.96744060516357*x_78 - 5.9543194770813, 2) + 0.00108903690699202*std::pow(-9.76488018035889*x_81 - 6.16847991943359, 2) - 0.00152035464931322*std::pow(-8.79600048065186*x_82 - 6.76008033752441, 2) - 0.00111061944459179*std::pow(-8.73871994018555*x_84 - 6.90944004058838, 2) - 0.00038180036130897*std::pow(-9.98104000091553*x_89 - 6.3045597076416, 2) + 0.000745904336682424*std::pow(9.99804019927979*x_90 + 6.80000019073486, 2) + 0.00118497091392689*std::pow(-9.12360000610352*x_92 - 4.86263990402222, 2) + 0.0567313483579157*std::exp(0.383999645709991*x_10) + 0.0353116640159627*std::exp(0.390159606933594*x_11) - 0.259634981899021*std::exp(0.438959568738937*x_112) - 1.0995151359999*std::exp(0.17751981317997*x_118) - 0.0995389628388995*std::exp(0.559599876403809*x_12) - 0.120070189364803*std::exp(0.756479620933533*x_13) + 0.0643379483169423*std::exp(1.05224001407623*x_14) - 0.0314803117169971*std::exp(1.22631978988647*x_15) - 0.0553702257957325*std::exp(1.24463975429535*x_16) - 0.100574803231861*std::exp(0.317999690771103*x_22) - 0.22532920601503*std::exp(0.509839773178101*x_23) - 0.250818293063297*std::exp(0.603119909763336*x_24) - 0.211994807169927*std::exp(0.649999976158142*x_25) + 0.226397504992539*std::exp(0.779999673366547*x_26) - 0.161451494409532*std::exp(0.663999974727631*x_27) + 0.788524305644897*std::exp(0.900000095367432*x_28) + 0.829356961855669*std::exp(1.0239999294281*x_29) + 0.155423314853781*std::exp(0.253599762916565*x_3) + 0.956855037613963*std::exp(1.0*x_30) - 0.1811817098742*std::exp(0.291999727487564*x_4) + 0.209617087948805*std::exp(0.391519606113434*x_5) + 0.360962906124075*std::exp(0.33903968334198*x_6) + 0.0639138775696558*std::exp(1.52415978908539*x_64) + 0.133965333756636*std::exp(0.965040028095245*x_68) + 0.00980265418574297*std::exp(0.319119691848755*x_7) - 0.276801376510593*std::exp(0.763999700546265*x_71) - 0.227381273271087*std::exp(0.5971999168396*x_79) + 0.285422576584324*std::exp(0.302559703588486*x_8) - 0.0259463548238243*std::exp(2.54519987106323*x_83) - 0.214407393937818*std::exp(0.324639678001404*x_9) - 0.460158135310863*std::exp(0.367199659347534*x_97) - 0.346025041458461*std::sin(0.997919976711273*x_101 + 8.19495964050293) + 0.226761204068055*std::sin(1.221599817276*x_103 + 1.38991963863373) + 0.464238568880887*std::sin(0.743679583072662*x_105 - 4.37695980072021) + 0.302273897725399*std::sin(0.938000082969666*x_106 - 1.35967969894409) - 0.437692781831743*std::sin(0.799759685993195*x_109 - 4.20560026168823) - 0.362507820573683*std::sin(0.914640069007874*x_110 - 1.37599968910217) + 0.0637236159379597*std::sin(1.37159967422485*x_117 - 4.98199987411499) + 0.19075518661424*std::sin(1.09279990196228*x_119 + 1.55415987968445) + 0.0109990973645004*std::sin(5.21920013427734*x_66 - 9.41256046295166) + 0.0337499794352922*std::sin(3.36391997337341*x_91 - 8.0447998046875) - 0.229633588297247*std::sin(0.978640019893646*x_95 + 8.21375942230225) + 0.350278219645929*std::sin(1.16767990589142*x_98 - 7.76968002319336) - 6.32037282122662, 2) + 0.00242734195037946*std::exp(0.37863963842392*x_10) - 0.000273829213477458*std::exp(0.398079603910446*x_11) + 0.00109848723661455*std::exp(0.554959833621979*x_12) + 0.000609701124612517*std::exp(0.746319591999054*x_13) - 0.0005689771465898*std::exp(1.0595999956131*x_14) - 0.000328528493179456*std::exp(1.26079976558685*x_15) + 0.000134497302595117*std::exp(1.17711985111237*x_16) + 0.00356374350205236*std::exp(0.59999942779541*x_25) + 0.0037751982497311*std::exp(0.625759959220886*x_27) + 0.0010599843651241*std::exp(0.254479765892029*x_3) + 0.000506219083537745*std::exp(0.292959719896317*x_4) + 0.000697717138523688*std::exp(0.39087963104248*x_5) + 0.00278179916561976*std::exp(0.33751967549324*x_6) - 0.000390437380122859*std::exp(2.69063973426819*x_61) - 0.00090188502574388*std::exp(1.45271956920624*x_67) - 0.00033301040914648*std::exp(0.334319651126862*x_7) + 0.00264308817154381*std::exp(0.300399720668793*x_8) + 0.000285690945418742*std::exp(2.24656009674072*x_85) + 0.000763154144233641*std::exp(0.318799704313278*x_9) - 0.00592436583866042*std::exp(0.273759722709656*x_94) + 0.0141793057738701*std::exp(0.158639833331108*x_95) + 0.288062260725305*std::exp(0.0709303069559395*x_1 + 0.0456928151935409*x_100 + 0.0761299820901078*x_101 - 0.00215756573103365*x_105 - 0.0506313753711493*x_106 + 0.00819893533156869*x_108 - 0.0319021257814254*x_109 + 0.0144007280360395*x_111 - 0.00980047045669672*x_112 + 0.047091569148286*x_113 - 0.015549903149784*x_114 + 0.014545758830008*x_116 + 0.000149301143788598*x_17 - 3.9406042078433e-5*x_18 + 0.000143046336901532*x_19 - 0.0052127683594413*x_2 + 0.000165612561457346*x_20 - 0.000366652842955354*x_21 - 0.000136055884954658*x_23 - 1.56782366624163e-5*x_24 + 5.11141977717436e-5*x_25 - 4.31530834070922e-5*x_26 - 5.24437172329794e-5*x_27 - 4.48129027971183e-5*x_28 - 3.84849852571754e-5*x_29 - 2.86670888122943e-5*x_30 - 0.0313215449463318*x_31 - 0.000367783678918597*x_32 + 0.0706853510466509*x_33 - 0.0780894513712346*x_34 + 0.0703850670126835*x_35 - 0.0337994869114301*x_36 - 0.0746367639321603*x_37 + 0.0793341855116971*x_38 - 0.0379917131635186*x_39 + 0.101235159312957*x_40 - 0.0659270315401582*x_41 + 0.0415813709640488*x_42 + 0.0937224492413047*x_43 - 0.0971164939767577*x_44 - 0.0299001462165797*x_45 + 0.0508008941757117*x_46 - 0.0978481638912942*x_47 - 0.0191024240075871*x_48 + 0.0321468445758692*x_49 + 0.0360572082795906*x_50 + 0.0600216314557002*x_51 + 0.0302525283674698*x_52 + 0.043208824263075*x_53 - 0.0323500316205925*x_54 - 0.0797245024011092*x_55 - 0.0590924392798832*x_56 - 0.0930446339252804*x_57 + 0.0802635112745365*x_58 - 0.0224663252183943*x_59 - 0.0462903182408702*x_60 + 0.000469755191450944*x_61 - 0.00180211965250198*x_62 + 0.000294068161569953*x_63 + 0.0263775792479314*x_64 - 0.0233466978348924*x_70 + 0.0305280869010419*x_71 - 0.035032956118322*x_72 - 0.0351119594119067*x_73 + 0.0200397715327155*x_74 - 0.0562629211834472*x_76 - 0.0483650897230518*x_77 - 0.0219359011555029*x_78 + 0.000853425298774778*x_83 + 0.0100943038900502*x_85 - 0.0426375201092306*x_86 - 0.0329918595926937*x_90 + 0.0263716642685151*x_92 - 0.0145282916411392*x_93 - 0.0039141061413892*x_95 - 0.0521881628332362*x_98 - 0.000675775880843402*std::pow(-5.06224012374878*x_110 - 6.06215953826904, 2) - 0.000478016678938473*std::pow(-4.91359996795654*x_120 - 9.95232009887695, 2) + 0.00037045435121838*std::pow(-9.72855949401855*x_66 - 3.0403196811676, 2) - 0.00031066773110016*std::pow(-9.34815979003906*x_68 - 7.77871990203857, 2) + 0.000273071406027149*std::pow(9.97795963287354*x_69 + 6.79199981689453, 2) + 0.000281801800519135*std::pow(-7.12376022338867*x_75 - 8.96928024291992, 2) - 0.000567150153586243*std::pow(-4.9159197807312*x_84 - 9.26272010803223, 2) + 0.000395850416126255*std::pow(-9.30655956268311*x_87 - 4.45368003845215, 2) + 0.000441173959354037*std::pow(-7.25176000595093*x_91 - 4.82791996002197, 2) + 0.0624812200806591*std::exp(0.383119642734528*x_10) - 0.161709238321911*std::exp(0.226719796657562*x_102) + 0.103212060748846*std::exp(0.325359672307968*x_103) - 0.0499695254984035*std::exp(0.290799736976624*x_104) - 0.0544646075265287*std::exp(0.386399626731873*x_11) + 0.0468955144965965*std::exp(0.310719698667526*x_115) - 0.308200085421249*std::exp(0.193679809570313*x_117) + 0.0231560311861771*std::exp(0.563039839267731*x_12) - 0.0269048518038514*std::exp(0.749999642372131*x_13) - 0.00484552476097837*std::exp(1.05879998207092*x_14) - 0.0154317675005011*std::exp(1.23447978496552*x_15) - 0.00611477183899637*std::exp(1.22799980640411*x_16) - 0.0317144389760921*std::exp(0.294799715280533*x_22) - 0.0549306984636796*std::exp(0.25279974937439*x_3) + 0.0657421906295283*std::exp(0.291599720716476*x_4) + 0.0157361848972319*std::exp(0.395119607448578*x_5) - 0.0110604152948306*std::exp(0.332639664411545*x_6) + 0.0158094614516101*std::exp(1.60343992710114*x_65) - 0.0341677070168939*std::exp(0.318159699440002*x_7) + 0.0290376191004156*std::exp(0.960240066051483*x_79) - 0.0883249258221996*std::exp(0.301119714975357*x_8) + 0.035484751282858*std::exp(1.0*x_80) + 0.0185791991844233*std::exp(1.51543974876404*x_81) + 0.0218654258038791*std::exp(1.54271984100342*x_82) - 0.0384027376454655*std::exp(0.91376006603241*x_88) + 0.00141947704802566*std::exp(3.14815998077393*x_89) + 0.0668969358071496*std::exp(0.326159685850143*x_9) - 0.0925106332036815*std::exp(0.413439601659775*x_94) + 0.0276769648058815*std::exp(0.486799538135529*x_99) - 0.0862017469940373*std::sin(0.879599809646606*x_107 + 8.1738395690918) - 0.0547891644540801*std::sin(1.02023994922638*x_118 - 1.39911961555481) - 0.126578596345096*std::sin(0.705280065536499*x_119 - 1.23703980445862) + 0.0708881319128771*std::sin(1.2203197479248*x_96 - 7.82216024398804) + 0.120350962331578*std::sin(0.741679608821869*x_97 - 1.1515998840332) + 0.00297844288561651*std::exp(-2.33999991416931*x_67)) + 0.00304574106970176*std::sin(1.18831980228424*x_100 + 4.79408025741577) + 0.005985838674768*std::sin(0.630799949169159*x_102 + 8.37952041625977) + 0.00520439857256003*std::sin(0.748079597949982*x_103 - 1.14335989952087) + 0.0030859164613992*std::sin(1.08351993560791*x_110 - 4.62207984924316) + 0.0039516479220648*std::sin(0.946880042552948*x_113 - 1.34919965267181) - 0.000632897497954435*std::sin(1.5771199464798*x_115 - 5.18495988845825) + 0.00143947250977798*std::sin(1.20855975151062*x_118 + 4.79016017913818) - 0.000464548222316767*std::sin(2.92903971672058*x_66 + 2.37191987037659) + 0.147758588194847*std::sin(-0.0741383867688744*x_1 + 0.0391551761110168*x_101 + 0.0728055733936297*x_102 + 0.101084698421238*x_104 - 0.0741287565249957*x_105 + 0.0223740308977799*x_106 + 0.0268008255079706*x_108 + 0.00396166136274103*x_111 - 0.0240859266021426*x_113 - 0.0392463595342813*x_114 - 0.0290137419803468*x_119 - 0.00017519423540179*x_12 - 0.000147432153163485*x_17 - 2.42081540411506e-5*x_18 - 7.42292963557009e-5*x_19 + 0.0163757127209179*x_2 + 0.000130626955016288*x_20 + 0.000121328075181416*x_21 + 1.14063614189328e-5*x_27 - 5.65034440178703e-5*x_28 - 5.7466405207529e-5*x_29 - 7.9681009834431e-6*x_30 - 0.0177410979440669*x_31 + 0.0316184623779663*x_32 + 0.071766090163677*x_33 + 0.0121600890043225*x_34 - 0.103140212294584*x_35 - 0.00699197120323846*x_36 - 0.00107976073424522*x_37 - 0.0808231753349128*x_38 + 0.115047356404983*x_39 + 0.115165052101829*x_40 - 0.0706372558825495*x_41 + 0.0964374862287748*x_42 - 0.0492853784692497*x_43 - 0.113530362117796*x_44 - 0.0642965493883236*x_45 + 0.084773643578272*x_46 - 0.0891011782854954*x_47 + 0.0204793251164746*x_48 + 0.14241098802498*x_50 + 0.0617905246755876*x_51 - 0.0991440520307702*x_53 + 0.0670066871394498*x_54 + 0.108144864921025*x_55 - 0.0836875477346152*x_56 + 0.089807160408417*x_57 - 0.0107402471850576*x_58 + 0.0393153516463489*x_59 + 0.08511175327657*x_60 - 0.0602972366329477*x_62 + 0.0396976643704368*x_63 - 0.0496803702002745*x_64 + 0.0434527590354126*x_65 + 0.0235223019708405*x_67 + 0.0416885434372987*x_68 - 0.0250674124596946*x_69 + 0.0149655905194772*x_70 + 0.0152298204224089*x_73 - 0.0172157481255993*x_76 - 0.0531596190558219*x_78 + 0.0223331729828408*x_79 - 0.0220778569866967*x_80 + 0.0573337998175976*x_81 - 0.0554802327291823*x_82 + 0.0556258622894824*x_83 + 0.0225701473531083*x_85 - 0.038818336854316*x_87 + 0.0518153336442371*x_88 - 0.00637785102822638*x_90 + 0.0136721797605187*x_91 - 0.00415860910168151*x_92 - 0.101681213553876*x_94 + 0.0440264263353203*x_96 + 0.0521662531174007*x_98 + 0.000113097167048093*std::pow(-9.66063976287842*x_112 - 2.00952005386353, 2) + 0.000344516339027294*std::pow(-9.87936019897461*x_61 - 6.42767953872681, 2) - 0.000163925048724371*std::pow(-9.61999988555908*x_89 - 9.98340034484863, 2) + 0.000327972987775427*std::pow(-9.5272798538208*x_93 - 3.83999991416931, 2) - 0.0601089592750806*std::exp(0.377839624881744*x_10) + 0.153083814065241*std::exp(0.306799709796906*x_109) + 0.0962452643763787*std::exp(0.389359623193741*x_11) + 0.283428324848952*std::exp(0.204399809241295*x_110) + 0.267602601480178*std::exp(0.284239739179611*x_116) - 0.0363689720445728*std::exp(0.753279685974121*x_13) + 0.0156880515272673*std::exp(1.06831991672516*x_14) - 0.00301905523848145*std::exp(1.01175999641418*x_15) + 0.00731575869394494*std::exp(1.3155996799469*x_16) - 0.0422337071628003*std::exp(0.302559703588486*x_22) - 0.045359494645622*std::exp(0.454799562692642*x_23) - 0.0840081602560267*std::exp(0.549359798431396*x_24) - 0.0616644811928237*std::exp(0.551279842853546*x_25) - 0.0731421915619038*std::exp(0.568719863891602*x_26) + 0.0329950463637871*std::exp(0.254239767789841*x_3) + 0.0928612991237039*std::exp(0.290719717741013*x_4) - 0.00613079960986462*std::exp(0.375039637088776*x_5) - 0.0560629761837794*std::exp(0.336479663848877*x_6) + 0.0906224871841999*std::exp(0.322799682617188*x_7) + 0.0168248661944395*std::exp(1.67871999740601*x_72) - 0.0531627492290989*std::exp(0.906000137329102*x_74) - 0.0273588235546241*std::exp(1.59167993068695*x_75) - 0.0226944227839461*std::exp(1.82439970970154*x_77) - 0.0281415169156254*std::exp(0.296319723129272*x_8) + 0.0413007152147781*std::exp(0.453119575977325*x_84) + 0.00607143999673616*std::exp(2.19304013252258*x_86) - 0.0925679432040564*std::exp(0.321679681539536*x_9) + 0.00129362824217458*std::sin(8.43152046203613*x_100 + 6.17775964736938) + 0.0996514973807416*std::sin(1.13871991634369*x_103 - 4.73816013336182) + 0.0174162695489941*std::sin(2.24272012710571*x_107 + 0.576879858970642) + 0.131485119805875*std::sin(0.942240059375763*x_115 - 7.77415990829468) - 0.182237650042601*std::sin(0.655439972877502*x_117 - 7.4203200340271) - 0.079784484455907*std::sin(0.86495977640152*x_118 - 1.23255980014801) - 0.0268479989866004*std::sin(1.39743959903717*x_120 + 7.59143972396851) + 0.00716228837565858*std::sin(3.70088005065918*x_66 - 5.78968000411987) + 0.0290009129949509*std::sin(2.39439988136292*x_71 + 2.39183974266052) + 0.134521232310497*std::sin(1.02312004566193*x_95 - 1.41087961196899) + 0.0732382479390021*std::sin(0.921440064907074*x_97 - 4.54048013687134) + 0.10455534855257*std::sin(0.982560038566589*x_99 - 1.37295973300934) - 12.040949085184 + 2.22495333133567*std::exp(-0.012639987282455*x_52) + 1.03074061018374*std::exp(-0.015439985319972*x_49)) - 0.272906690835953*std::sin(-0.0257672896482127*x_1 - 0.0521371890970974*x_103 - 0.0444504758670847*x_104 - 0.000204301364763744*x_107 + 0.000981473234644708*x_109 - 0.0420535835844965*x_112 + 0.00544066988013838*x_116 + 0.0227063468225917*x_117 + 0.0386934671439187*x_118 + 0.0240554574000972*x_119 + 0.000286139902858498*x_15 - 5.767285583721e-5*x_17 + 0.000111513435509308*x_18 + 0.00040074580078822*x_19 + 0.0274026648241476*x_2 + 0.000172860074946209*x_20 + 0.000368686689844621*x_21 + 7.08610960406148e-6*x_22 + 8.33488471553426e-6*x_23 + 0.00029721841144592*x_24 - 1.03020673040897e-5*x_25 + 0.000122751510444928*x_26 + 1.55016019750209e-5*x_27 + 0.000118209651100825*x_28 + 8.26003435628435e-5*x_29 + 0.000117603254831642*x_30 + 0.0409007416672935*x_31 + 0.0349751107670975*x_32 + 0.063250068457191*x_33 - 0.0259199747111717*x_34 - 0.026567630873347*x_35 - 0.0913711143774539*x_36 + 0.0628041787121643*x_37 - 0.00496934797140711*x_38 - 0.0716637674707533*x_39 + 0.0545281785629005*x_40 + 0.0459304981989497*x_41 - 0.0564003091420088*x_42 - 0.0356100846507493*x_43 - 0.0495639839086395*x_44 + 0.0724038560083404*x_45 - 0.113273977278584*x_46 + 0.0628454460768705*x_47 + 0.0699226659622502*x_48 - 0.10066637843973*x_49 - 0.030752213090977*x_50 + 0.0166936892661613*x_51 + 0.045756688784642*x_52 - 0.0195574105442179*x_53 + 0.0425187378914885*x_54 + 0.0562154444605853*x_55 + 0.104144663777943*x_56 + 0.0137440725851034*x_57 + 0.0627370373638755*x_58 + 0.00203188239483092*x_59 - 0.066824632937704*x_60 + 0.00604644550758627*x_61 + 0.0124237731535512*x_63 - 0.028571846100635*x_64 - 0.0191552601943044*x_65 + 0.0286027677811413*x_68 + 0.0318262474541934*x_69 - 0.0328311757762895*x_70 + 0.0144002414591802*x_71 + 0.0243278346535659*x_72 + 0.0164044697940146*x_73 + 0.00757817279550028*x_74 - 0.0160755435323868*x_75 + 0.0411995702180027*x_77 + 0.044898951617722*x_80 - 0.0236133258075119*x_81 - 0.0499108942053114*x_82 - 0.0205422252020398*x_83 + 0.0390931151680196*x_84 + 0.0081176504761344*x_85 - 0.0215122843807372*x_87 + 0.00475338272769604*x_88 + 0.000867728037235223*x_89 + 0.000349266080740516*x_9 + 0.0263317010877583*x_90 - 0.064393669407709*x_91 + 0.037045969098392*x_93 + 0.0225161906377635*x_96 - 0.0123883153119309*x_97 + 0.000249994673641543*std::pow(-5.74399995803833*x_102 - 9.33600044250488, 2) - 0.00120663110492229*std::pow(-3.9255998134613*x_106 - 6.27424001693726, 2) - 0.000366810344520695*std::pow(-9.40464019775391*x_67 - 5.20007991790771, 2) + 0.000320193054144623*std::pow(-8.10671997070313*x_76 - 6.87735986709595, 2) - 0.000653133749927128*std::pow(-8.6048002243042*x_86 - 5.2065601348877, 2) + 0.0638574181933143*std::exp(0.376559644937515*x_10) + 0.0992631327832534*std::exp(0.440959572792053*x_100) - 0.0680325352018608*std::exp(0.390479624271393*x_11) + 0.0273111236112307*std::exp(0.597919881343842*x_113) + 0.0615216974949994*std::exp(0.555519819259644*x_12) + 0.0133787017891129*std::exp(0.735919654369354*x_13) + 0.0126578072329041*std::exp(1.00799989700317*x_14) + 0.0123489050823465*std::exp(1.20743978023529*x_16) - 0.0402189604197742*std::exp(0.256639748811722*x_3) - 0.0420951686859918*std::exp(0.296639710664749*x_4) + 0.0343043424978188*std::exp(0.39199960231781*x_5) - 0.01528775903545*std::exp(0.326959699392319*x_6) + 0.088812178718866*std::exp(0.531519830226898*x_62) + 0.0144971391340092*std::exp(0.329039663076401*x_7) - 0.0193702402318551*std::exp(1.75759971141815*x_78) - 0.0524550376096984*std::exp(0.718479633331299*x_79) - 0.0465128972411509*std::exp(0.303359717130661*x_8) + 0.245918154698998*std::exp(0.286399722099304*x_98) - 0.0490689641842028*std::sin(1.14503979682922*x_101 - 7.75903987884521) - 0.0708959814749655*std::sin(1.16319978237152*x_105 + 7.80984020233154) - 0.0974743837270973*std::sin(1.21303987503052*x_108 + 4.7760796546936) + 0.0680509784805201*std::sin(1.15967988967896*x_110 + 1.62808001041412) - 0.123958765943997*std::sin(0.790319681167603*x_111 + 8.21183967590332) - 0.0894057959147556*std::sin(0.879999816417694*x_114 - 7.63015985488892) + 0.121525117720651*std::sin(0.722879588603973*x_115 - 4.3699197769165) + 0.0786438568047618*std::sin(1.02160000801086*x_120 + 8.18144035339355) + 0.00684685740950591*std::sin(4.38775968551636*x_66 - 0.206719815731049) - 0.0498550388685137*std::sin(1.18479979038239*x_92 - 1.17983984947205) - 0.0484757223190204*std::sin(1.35383975505829*x_94 - 1.54991984367371) + 0.0227858591531263*std::sin(1.47087955474854*x_95 + 4.54888010025024) - 0.10525392771426*std::sin(0.986720025539398*x_99 - 1.37095963954926) + 4.65816460533981) - 0.220695653244589 + 0.0483428292811621*std::exp(-0.0245599746704102*x_32));
}

inline float score_11(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.00731187820171685*x_1 + 0.00471026157544003*x_100 + 0.00784788872953187*x_101 - 0.000222413500160318*x_105 - 0.00521935496668889*x_106 + 0.000845190428478235*x_108 - 0.00328864300889792*x_109 + 0.00148450463468286*x_111 - 0.00101028529798136*x_112 + 0.00485445266934886*x_113 - 0.00160296779697206*x_114 + 0.00149945519032693*x_116 + 1.53907663114635e-5*x_17 - 4.06218713064661e-6*x_18 + 1.47459871176854e-5*x_19 - 0.000537360248020279*x_2 + 1.7072235127964e-5*x_20 - 3.77965505163837e-5*x_21 - 1.4025373667609e-5*x_23 - 1.61619710689382e-6*x_24 + 5.26912690110896e-6*x_25 - 4.44845233924038e-6*x_26 - 5.40618093040291e-6*x_27 - 4.61955546479512e-6*x_28 - 3.96723963101039e-6*x_29 - 2.95515796827865e-6*x_30 - 0.00322879360834348*x_31 - 3.79131231802309e-5*x_32 + 0.00728662682680569*x_33 - 0.00804988138032506*x_34 + 0.00725567193070388*x_35 - 0.00348423321684505*x_36 - 0.00769395975659952*x_37 + 0.00817819528194449*x_38 - 0.00391639048592823*x_39 + 0.0104358656601832*x_40 - 0.0067961136150422*x_41 + 0.00428643175248618*x_42 + 0.00966141502876474*x_43 - 0.0100112914466439*x_44 - 0.00308226816902064*x_45 + 0.00523682987840231*x_46 - 0.0100867159235501*x_47 - 0.00196918078738602*x_48 + 0.00331386994073335*x_49 + 0.00371697129970232*x_50 + 0.00618735315702263*x_51 + 0.00311859361971083*x_52 + 0.00445419840699754*x_53 - 0.00333481555604144*x_54 - 0.00821843124986758*x_55 - 0.0060915670212065*x_56 - 0.00959154217403275*x_57 + 0.00827399518863065*x_58 - 0.00231594984833635*x_59 - 0.00477185540880579*x_60 + 4.84248960976175e-5*x_61 - 0.00018577220330091*x_62 + 3.03141304849836e-5*x_63 + 0.00271914298688733*x_64 - 0.00240670340094624*x_70 + 0.00314699967801499*x_71 - 0.00361138586841844*x_72 - 0.00361952995357775*x_73 + 0.00206580762054885*x_74 - 0.00579988505085291*x_76 - 0.00498573403171279*x_77 - 0.00226127087809686*x_78 + 8.79756779112947e-5*x_83 + 0.00104057523141711*x_85 - 0.00439530529672749*x_86 - 0.00340097864146802*x_90 + 0.00271853323894017*x_92 - 0.00149765457838803*x_93 - 0.000403487149607397*x_95 - 0.00537983700599276*x_98 - 6.96626187654065e-5*std::pow(-5.06224012374878*x_110 - 6.06215953826904, 2) - 4.92765347393527e-5*std::pow(-4.91359996795654*x_120 - 9.95232009887695, 2) + 3.81884304700307e-5*std::pow(-9.72855949401855*x_66 - 3.0403196811676, 2) - 3.20253035478776e-5*std::pow(-9.34815979003906*x_68 - 7.77871990203857, 2) + 2.81496717966041e-5*std::pow(9.97795963287354*x_69 + 6.79199981689453, 2) + 2.90496478987518e-5*std::pow(-7.12376022338867*x_75 - 8.96928024291992, 2) - 5.8464893542384e-5*std::pow(-4.9159197807312*x_84 - 9.26272010803223, 2) + 4.0806393670509e-5*std::pow(-9.30655956268311*x_87 - 4.45368003845215, 2) + 4.54785887021426e-5*std::pow(-7.25176000595093*x_91 - 4.82791996002197, 2) + 0.00173985015135258*std::pow(-0.456226054446128*x_1 + 0.36494194827984*x_100 + 0.150536580588003*x_104 - 0.0677379448061334*x_108 - 0.0417591872966675*x_111 + 0.173243075190519*x_113 + 0.193895051253526*x_114 - 0.232125420762727*x_115 - 0.0244628502700205*x_116 + 0.0216885784536786*x_120 + 0.000972942341202528*x_17 - 0.000108589157516723*x_18 - 0.000424049133228176*x_19 + 0.193035240729598*x_2 - 0.00186871567398801*x_20 - 0.00120755875283771*x_21 - 0.0348729718624627*x_32 - 0.165195884246199*x_33 - 0.489805145130897*x_34 + 0.706933012757873*x_35 + 0.140729422863005*x_36 - 0.613838532677519*x_37 - 0.428561426332652*x_38 - 0.403225942010874*x_39 + 0.812344414035147*x_40 + 0.689421015963228*x_41 - 0.110087529915469*x_42 + 0.531167824063833*x_43 + 0.0830251708669907*x_44 - 0.294575931941143*x_45 + 0.687459658450586*x_46 - 0.538746241434998*x_47 + 0.538492823378873*x_48 - 0.456622044952519*x_49 + 0.108909563394117*x_50 - 0.459927375021485*x_51 - 0.397993546838544*x_52 - 0.0319039255975235*x_53 - 0.483114137415242*x_54 - 0.419286063776959*x_55 + 0.181380659263785*x_56 + 0.335286050818092*x_57 - 0.528220889160746*x_58 + 0.26446981864182*x_59 + 0.341204724558937*x_60 + 0.00588963227594868*x_62 - 0.0338056334124734*x_63 + 0.140472267639257*x_65 - 0.168291670264763*x_67 + 0.136836702230542*x_69 + 0.17508985307258*x_70 + 0.187484693280556*x_72 - 0.28152558383301*x_73 + 0.0061256733785656*x_74 + 0.125015878475041*x_75 - 0.0195083156781571*x_76 - 0.137673859613435*x_77 + 0.0175326954406654*x_80 + 0.049033827523797*x_85 + 0.302497762759456*x_87 - 0.0104023382430546*x_88 - 0.228035042286517*x_93 + 0.142344011161947*x_94 + 0.194487778903783*x_96 - 0.156521499313584*x_99 + 0.000724619086444733*std::pow(2.20000004768372 - 9.95748043060303*x_86, 2) + 0.0997048998402437*std::pow(8.37551975250244 - 0.210639804601669*x_31, 2) + 0.0140382531994709*std::pow(-2.63048005104065*x_102 - 7.50127983093262, 2) + 0.00155788504454817*std::pow(-9.03791999816895*x_107 - 8.22247982025146, 2) - 0.00243748918866475*std::pow(-8.81511974334717*x_61 - 9.24431991577148, 2) + 0.00244655608750349*std::pow(-8.96744060516357*x_78 - 5.9543194770813, 2) + 0.00196450063772895*std::pow(-9.76488018035889*x_81 - 6.16847991943359, 2) - 0.00274254954903182*std::pow(-8.79600048065186*x_82 - 6.76008033752441, 2) - 0.00200343311890229*std::pow(-8.73871994018555*x_84 - 6.90944004058838, 2) - 0.000688725100555392*std::pow(-9.98104000091553*x_89 - 6.3045597076416, 2) + 0.00134552790239655*std::pow(9.99804019927979*x_90 + 6.80000019073486, 2) + 0.00213755484424245*std::pow(-9.12360000610352*x_92 - 4.86263990402222, 2) + 0.102337000071169*std::exp(0.383999645709991*x_10) + 0.0636982879397833*std::exp(0.390159606933594*x_11) - 0.468352435296396*std::exp(0.438959568738937*x_112) - 1.98340218958277*std::exp(0.17751981317997*x_118) - 0.179557143307475*std::exp(0.559599876403809*x_12) - 0.216593177021794*std::exp(0.756479620933533*x_13) + 0.116058454665146*std::exp(1.05224001407623*x_14) - 0.0567869573995987*std::exp(1.22631978988647*x_15) - 0.099881687377661*std::exp(1.24463975429535*x_16) - 0.181425683390454*std::exp(0.317999690771103*x_22) - 0.406468656914606*std::exp(0.509839773178101*x_23) - 0.452448115865867*std::exp(0.603119909763336*x_24) - 0.382414894487681*std::exp(0.649999976158142*x_25) + 0.40839574864963*std::exp(0.779999673366547*x_26) - 0.291240417742921*std::exp(0.663999974727631*x_27) + 1.42240955412865*std::exp(0.900000095367432*x_28) + 1.49606709378706*std::exp(1.0239999294281*x_29) + 0.28036625681634*std::exp(0.253599762916565*x_3) + 1.72605934614166*std::exp(1.0*x_30) - 0.326831517194204*std::exp(0.291999727487564*x_4) + 0.378125755252598*std::exp(0.391519606113434*x_5) + 0.651136664629523*std::exp(0.33903968334198*x_6) + 0.11529347852142*std::exp(1.52415978908539*x_64) + 0.241658461626784*std::exp(0.965040028095245*x_68) + 0.0176828905206878*std::exp(0.319119691848755*x_7) - 0.499318689006829*std::exp(0.763999700546265*x_71) - 0.410170356468867*std::exp(0.5971999168396*x_79) + 0.514870368600143*std::exp(0.302559703588486*x_8) - 0.0468043188168255*std::exp(2.54519987106323*x_83) - 0.386766930872922*std::exp(0.324639678001404*x_9) - 0.8300737509174*std::exp(0.367199659347534*x_97) - 0.624190429406916*std::sin(0.997919976711273*x_101 + 8.19495964050293) + 0.409051821057465*std::sin(1.221599817276*x_103 + 1.38991963863373) + 0.837434396180253*std::sin(0.743679583072662*x_105 - 4.37695980072021) + 0.545268265049451*std::sin(0.938000082969666*x_106 - 1.35967969894409) - 0.789548768749039*std::sin(0.799759685993195*x_109 - 4.20560026168823) - 0.653923517308257*std::sin(0.914640069007874*x_110 - 1.37599968910217) + 0.114950267841963*std::sin(1.37159967422485*x_117 - 4.98199987411499) + 0.344100997264478*std::sin(1.09279990196228*x_119 + 1.55415987968445) + 0.0198411400461033*std::sin(5.21920013427734*x_66 - 9.41256046295166) + 0.0608811838224101*std::sin(3.36391997337341*x_91 - 8.0447998046875) - 0.414233280578095*std::sin(0.978640019893646*x_95 + 8.21375942230225) + 0.631862686616945*std::sin(1.16767990589142*x_98 - 7.76968002319336) - 7.8991232021755, 2) - 0.29538282752037*std::pow(0.143327524771745*x_1 - 0.0756964741017253*x_101 - 0.140750872508565*x_102 - 0.19542129588254*x_104 + 0.143308907169201*x_105 - 0.0432544408842148*x_106 - 0.0518125110257937*x_108 - 0.00765885449970319*x_111 + 0.0465639514450341*x_113 + 0.0758727538257158*x_114 + 0.056090616530046*x_119 + 0.000338693047000033*x_12 + 0.00028502219303162*x_17 + 4.68002467983011e-5*x_18 + 0.000143503275103331*x_19 - 0.031658233648641*x_2 - 0.000252533659645462*x_20 - 0.000234556664353712*x_21 - 2.20512695255182e-5*x_27 + 0.000109234893354332*x_28 + 0.00011109653143118*x_29 + 1.54042762577034e-5*x_30 + 0.0342978552120822*x_31 - 0.0611261742698862*x_32 - 0.138741298725212*x_33 - 0.023508408180327*x_34 + 0.199395103898071*x_35 + 0.0135171800940268*x_36 + 0.00208743999066975*x_37 + 0.156250846151527*x_38 - 0.222414508107179*x_39 - 0.222642042501174*x_40 + 0.136558987638569*x_41 - 0.186437104970599*x_42 + 0.0952806179268237*x_43 + 0.219481789366571*x_44 + 0.124300860550443*x_45 - 0.163888061630402*x_46 + 0.172254238249321*x_47 - 0.0395915140032752*x_48 - 0.275315060166487*x_50 - 0.119456105562544*x_51 + 0.191669554635861*x_53 - 0.129540215661721*x_54 - 0.209070314063169*x_55 + 0.161788374333165*x_56 - 0.173619073318189*x_57 + 0.0207635087781177*x_58 - 0.0760061323504232*x_59 - 0.164541709872161*x_60 + 0.116569216755669*x_62 - 0.0767452357868533*x_63 + 0.0960442329659476*x_64 - 0.0840047466431177*x_65 - 0.0454743280147757*x_67 - 0.0805940890086366*x_68 + 0.0484614022082932*x_69 - 0.0289321246305387*x_70 - 0.0294429452675718*x_73 + 0.0332822262996944*x_76 + 0.102770466814077*x_78 - 0.0431754526020202*x_79 + 0.042681864713791*x_80 - 0.110840172975883*x_81 + 0.107256777189175*x_82 - 0.107538314531989*x_83 - 0.0436335816685545*x_85 + 0.0750452819324192*x_87 - 0.100171636315784*x_88 + 0.0123299365022384*x_90 - 0.0264316472034726*x_91 + 0.00803960235735123*x_92 + 0.196574504647607*x_94 - 0.0851137849931776*x_96 - 0.100850048966433*x_98 - 0.000218644317986497*std::pow(-9.66063976287842*x_112 - 2.00952005386353, 2) - 0.000666033835752897*std::pow(-9.87936019897461*x_61 - 6.42767953872681, 2) + 0.000316906969597235*std::pow(-9.61999988555908*x_89 - 9.98340034484863, 2) - 0.000634051516070766*std::pow(-9.5272798538208*x_93 - 3.83999991416931, 2) + 0.116205230852418*std::exp(0.377839624881744*x_10) - 0.295948227481537*std::exp(0.306799709796906*x_109) - 0.186065493400511*std::exp(0.389359623193741*x_11) - 0.547935853762832*std::exp(0.204399809241295*x_110) - 0.517340883235083*std::exp(0.284239739179611*x_116) + 0.0703100643111086*std::exp(0.753279685974121*x_13) - 0.0303288173898979*std::exp(1.06831991672516*x_14) + 0.0058365677126169*std::exp(1.01175999641418*x_15) - 0.014143140026763*std::exp(1.3155996799469*x_16) + 0.0816480230201101*std::exp(0.302559703588486*x_22) + 0.0876909301077973*std::exp(0.454799562692642*x_23) + 0.162408196278415*std::exp(0.549359798431396*x_24) + 0.119212432869011*std::exp(0.551279842853546*x_25) + 0.141401637260196*std::exp(0.568719863891602*x_26) - 0.0637874457640072*std::exp(0.254239767789841*x_3) - 0.179523465920314*std::exp(0.290719717741013*x_4) + 0.0118523260519932*std::exp(0.375039637088776*x_5) + 0.108383361952676*std::exp(0.336479663848877*x_6) - 0.175195298182879*std::exp(0.322799682617188*x_7) - 0.0325265565028079*std::exp(1.67871999740601*x_72) + 0.102776518199971*std::exp(0.906000137329102*x_74) + 0.0528912569000956*std::exp(1.59167993068695*x_75) + 0.0438738362878984*std::exp(1.82439970970154*x_77) + 0.0544043934407829*std::exp(0.296319723129272*x_8) - 0.0798443227729105*std::exp(0.453119575977325*x_84) - 0.0117375694894093*std::exp(2.19304013252258*x_86) + 0.178956337612393*std::exp(0.321679681539536*x_9) - 0.00250089787499325*std::sin(8.43152046203613*x_100 + 6.17775964736938) - 0.192650569858044*std::sin(1.13871991634369*x_103 - 4.73816013336182) - 0.0336698829581605*std::sin(2.24272012710571*x_107 + 0.576879858970642) - 0.254192700804818*std::sin(0.942240059375763*x_115 - 7.77415990829468) + 0.352309679764859*std::sin(0.655439972877502*x_117 - 7.4203200340271) + 0.154242804175175*std::sin(0.86495977640152*x_118 - 1.23255980014801) + 0.0519037088279251*std::sin(1.39743959903717*x_120 + 7.59143972396851) - 0.0138464445926623*std::sin(3.70088005065918*x_66 - 5.78968000411987) - 0.056065814982531*std::sin(2.39439988136292*x_71 + 2.39183974266052) - 0.260062244359531*std::sin(1.02312004566193*x_95 - 1.41087961196899) - 0.141587337588569*std::sin(0.921440064907074*x_97 - 4.54048013687134) - 0.202130906306399*std::sin(0.982560038566589*x_99 - 1.37295973300934) + 17.0800855929881 - 4.30137567879846*std::exp(-0.012639987282455*x_52) - 1.99267217399686*std::exp(-0.015439985319972*x_49), 1/2) + 0.0064409008043379*std::exp(0.383119642734528*x_10) - 0.0166698595487074*std::exp(0.226719796657562*x_102) + 0.0106396553114108*std::exp(0.325359672307968*x_103) - 0.0051511279158692*std::exp(0.290799736976624*x_104) - 0.00561450519008281*std::exp(0.386399626731873*x_11) + 0.00483424229954285*std::exp(0.310719698667526*x_115) - 0.0317709253360309*std::exp(0.193679809570313*x_117) + 0.00238704845551647*std::exp(0.563039839267731*x_12) - 0.00277349708280841*std::exp(0.749999642372131*x_13) - 0.000499502799243282*std::exp(1.05879998207092*x_14) - 0.00159078973774874*std::exp(1.23447978496552*x_15) - 0.000630343626537566*std::exp(1.22799980640411*x_16) - 0.00326929524177886*std::exp(0.294799715280533*x_22) - 0.00566255235510479*std::exp(0.25279974937439*x_3) + 0.00677705921808237*std::exp(0.291599720716476*x_4) + 0.00162217072315406*std::exp(0.395119607448578*x_5) - 0.00114016720026947*std::exp(0.332639664411545*x_6) + 0.00162972446518125*std::exp(1.60343992710114*x_65) - 0.00352219132922495*std::exp(0.318159699440002*x_7) + 0.00299335422673378*std::exp(0.960240066051483*x_79) - 0.00910500923376478*std::exp(0.301119714975357*x_8) + 0.00365795934817603*std::exp(1.0*x_80) + 0.00191524395356596*std::exp(1.51543974876404*x_81) + 0.00225400589914201*std::exp(1.54271984100342*x_82) - 0.00395876110405888*std::exp(0.91376006603241*x_88) + 0.000146327342016769*std::exp(3.14815998077393*x_89) + 0.00689609657256657*std::exp(0.326159685850143*x_9) - 0.00953649450254325*std::exp(0.413439601659775*x_94) + 0.00285309065107413*std::exp(0.486799538135529*x_99) - 8.81568032905076*std::exp(-0.17642353888856*x_1 + 0.0268047277903417*x_101 + 0.110323039034433*x_104 + 0.103780693571192*x_105 + 0.0488689686249408*x_106 - 0.0618685111080392*x_107 - 0.0648412225737143*x_111 + 0.0752432066449603*x_112 + 0.0354545873940158*x_114 - 0.0874077968483459*x_117 + 0.000151737945431191*x_17 + 1.6636150337725e-5*x_18 - 8.92257487277431e-5*x_19 + 0.00765958466797395*x_2 - 0.000658603104315747*x_20 - 0.000312474312102868*x_21 + 0.000118278237067773*x_22 + 0.000107824408467133*x_23 - 0.000177268159525072*x_24 + 0.000168077623122781*x_26 - 1.50721961742059e-5*x_28 - 4.89354061656851e-5*x_29 + 2.84190943842349e-5*x_30 - 0.05110304219148*x_33 - 0.0976450083583123*x_34 - 0.107848032266142*x_35 + 0.0186569130541647*x_36 - 0.161052954748397*x_37 - 0.102478145519298*x_38 + 0.19289785209613*x_39 + 0.0305312256653784*x_40 - 0.042765332723413*x_41 + 0.127701130501517*x_42 - 0.0367027260060873*x_43 - 0.00271867205704478*x_44 + 0.0060746084281985*x_45 - 0.147651704751516*x_46 + 0.0380521687321793*x_47 - 0.146027351800102*x_48 - 0.173221313049659*x_49 + 0.0464566309357838*x_50 + 0.0108037793559894*x_51 + 0.0347216855523631*x_52 + 0.163567454302855*x_53 + 0.173022853146972*x_54 + 0.187307714023309*x_55 + 0.114170244174941*x_56 - 0.0421637865995332*x_57 + 0.118070087126458*x_58 - 0.0376851412661322*x_59 - 0.0848170229316337*x_60 + 0.0360939318933945*x_62 - 0.0070349544569298*x_63 + 0.108436231844586*x_64 - 0.0398610270496851*x_68 - 0.106254063934637*x_69 - 0.0288521916713087*x_70 + 0.0849822866337107*x_71 - 0.0674054653302209*x_72 + 0.0274718440415054*x_75 - 0.0390856624389755*x_76 + 0.046200547648144*x_78 + 0.0119105821664088*x_79 + 0.0729797097702503*x_81 + 0.0757942961741361*x_82 + 0.0258044290520167*x_83 + 0.0910644828178108*x_84 + 0.0217263932333762*x_86 + 0.0113798897987065*x_87 - 0.0348227518764879*x_88 - 0.0999214391288986*x_89 - 0.0043837526647689*x_90 - 0.0611030478622409*x_92 - 0.0540487450291887*x_93 - 0.118773525088684*x_96 - 0.125518516653682*x_97 + 0.170318733994211*x_98 + 0.0415853545970606*x_99 - 0.0491065553447085*std::pow(8.27943992614746 - 0.201439797878265*x_31, 2) + 0.000193313765350612*std::pow(-9.83440017700195*x_108 - 4.4474401473999, 2) + 0.000180577787589191*std::pow(-9.9629602432251*x_109 - 3.39999985694885, 2) + 0.000147636835908191*std::pow(-9.99868011474609*x_116 - 3.37999987602234, 2) + 0.0057124638486219*std::pow(-2.03575992584229*x_119 - 5.2993597984314, 2) - 0.000645282902135981*std::pow(-5.40767955780029*x_120 - 9.19095993041992, 2) - 0.000675184231004176*std::pow(-8.49944019317627*x_65 - 8.27271938323975, 2) - 0.000554716025462157*std::pow(-9.9993200302124*x_73 - 6.0, 2) + 0.000520192526028116*std::pow(-8.14783954620361*x_74 - 9.39192008972168, 2) - 0.000463178545717976*std::pow(-9.59967994689941*x_77 - 1.02799999713898, 2) + 0.000742349201897329*std::pow(-8.69464015960693*x_80 - 7.84104013442993, 2) + 0.000209371320545413*std::pow(-9.93639945983887*x_91 - 4.7960000038147, 2) - 0.121364686301434*std::exp(0.37863963842392*x_10) + 0.0136911886636594*std::exp(0.398079603910446*x_11) - 0.0549232706405513*std::exp(0.554959833621979*x_12) - 0.0304844505796401*std::exp(0.746319591999054*x_13) + 0.02844829213196*std::exp(1.0595999956131*x_14) + 0.0164260983128375*std::exp(1.26079976558685*x_15) - 0.00672473152589552*std::exp(1.17711985111237*x_16) - 0.178183635032446*std::exp(0.59999942779541*x_25) - 0.188756162366293*std::exp(0.625759959220886*x_27) - 0.0529981653131325*std::exp(0.254479765892029*x_3) - 0.0253104513205293*std::exp(0.292959719896317*x_4) - 0.0348851638438599*std::exp(0.39087963104248*x_5) - 0.139087194960832*std::exp(0.33751967549324*x_6) + 0.0195214811623707*std::exp(2.69063973426819*x_61) + 0.0450933553932342*std::exp(1.45271956920624*x_67) + 0.0166501896590453*std::exp(0.334319651126862*x_7) - 0.132151783046596*std::exp(0.300399720668793*x_8) - 0.0142842634777871*std::exp(2.24656009674072*x_85) - 0.0381569491270385*std::exp(0.318799704313278*x_9) + 0.296212406921718*std::exp(0.273759722709656*x_94) - 0.708951203578402*std::exp(0.158639833331108*x_95) - 0.152284027976348*std::sin(1.18831980228424*x_100 + 4.79408025741577) - 0.299285987662614*std::sin(0.630799949169159*x_102 + 8.37952041625977) - 0.260214758801347*std::sin(0.748079597949982*x_103 - 1.14335989952087) - 0.154292757652707*std::sin(1.08351993560791*x_110 - 4.62207984924316) - 0.19757847070543*std::sin(0.946880042552948*x_113 - 1.34919965267181) + 0.0316442462044522*std::sin(1.5771199464798*x_115 - 5.18495988845825) - 0.0719721955785557*std::sin(1.20855975151062*x_118 + 4.79016017913818) + 0.0232269496535293*std::sin(2.92903971672058*x_66 + 2.37191987037659) - 2.41709344236186*std::exp(-0.0245599746704102*x_32)) - 0.00888614052082335*std::sin(0.879599809646606*x_107 + 8.1738395690918) - 0.00564796226683356*std::sin(1.02023994922638*x_118 - 1.39911961555481) - 0.0130484036956804*std::sin(0.705280065536499*x_119 - 1.23703980445862) + 0.00730753057104587*std::sin(1.2203197479248*x_96 - 7.82216024398804) + 0.0124064256281105*std::sin(0.741679608821869*x_97 - 1.1515998840332) - 0.361594438552856*std::sin(-0.0198436456936519*x_1 - 0.040151367180269*x_103 - 0.0342317529729727*x_104 - 0.000157334510243396*x_107 + 0.000755842286557407*x_109 - 0.0323858824188367*x_112 + 0.00418991391456177*x_116 + 0.0174863832205939*x_117 + 0.0297982233733358*x_118 + 0.0185253466764742*x_119 + 0.000220359181297668*x_15 - 4.44144391202605e-5*x_17 + 8.58776043013942e-5*x_18 + 0.000308618321625141*x_19 + 0.0211030643601276*x_2 + 0.000133121260661911*x_20 + 0.000283929281857918*x_21 + 5.45708338941009e-6*x_22 + 6.41877750630901e-6*x_23 + 0.00022889085079897*x_24 - 7.93372435694615e-6*x_25 + 9.45321574323483e-5*x_26 + 1.19379376518037e-5*x_27 + 9.10344264390917e-5*x_28 + 6.36113450119377e-5*x_29 + 9.05674346491166e-5*x_30 + 0.0314980674077087*x_31 + 0.0269346801946884*x_32 + 0.0487095059549962*x_33 - 0.0199612299771926*x_34 - 0.0204599964205779*x_35 - 0.0703658027326171*x_36 + 0.0483661218335173*x_37 - 0.00382694423120713*x_38 - 0.0551889791350456*x_39 + 0.0419926919165686*x_40 + 0.0353715328711763*x_41 - 0.0434344382706192*x_42 - 0.027423679889415*x_43 - 0.0381697163060814*x_44 + 0.0557589286688271*x_45 - 0.0872334150046281*x_46 + 0.0483979022409688*x_47 + 0.0538481395697243*x_48 - 0.0775241779128931*x_49 - 0.0236825847500558*x_50 + 0.0128559759152085*x_51 + 0.0352376805148427*x_52 - 0.0150613561155693*x_53 + 0.0327441023708318*x_54 + 0.0432920721432725*x_55 + 0.0802028400001843*x_56 + 0.0105844468118339*x_57 + 0.0483144156143136*x_58 + 0.00156477281408565*x_59 - 0.0514623135660727*x_60 + 0.00465642774217186*x_61 + 0.00956767110562112*x_63 - 0.0220034624741325*x_64 - 0.0147516561367119*x_65 + 0.0220272755674223*x_68 + 0.0245097092810967*x_69 - 0.0252836145634699*x_70 + 0.0110897689792077*x_71 + 0.0187351071047783*x_72 + 0.012633245127014*x_73 + 0.00583602614059217*x_74 - 0.0123799357458493*x_75 + 0.0317281982427472*x_77 + 0.034577128603058*x_80 - 0.0181848567455186*x_81 - 0.0384368753712613*x_82 - 0.0158197716653043*x_83 + 0.0301059962862303*x_84 + 0.00625148326085158*x_85 - 0.0165668238740058*x_87 + 0.00366062725193403*x_88 + 0.000668245980249543*x_89 + 0.00026897327789017*x_9 + 0.0202783045493055*x_90 - 0.0495902044058935*x_91 + 0.0285294687645761*x_93 + 0.017339942053917*x_96 - 0.00954036466960159*x_97 + 0.000192523381262454*std::pow(-5.74399995803833*x_102 - 9.33600044250488, 2) - 0.000929238598855839*std::pow(-3.9255998134613*x_106 - 6.27424001693726, 2) - 0.00028248428968702*std::pow(-9.40464019775391*x_67 - 5.20007991790771, 2) + 0.000246583851338626*std::pow(-8.10671997070313*x_76 - 6.87735986709595, 2) - 0.000502984788119505*std::pow(-8.6048002243042*x_86 - 5.2065601348877, 2) + 0.0491772320193321*std::exp(0.376559644937515*x_10) + 0.0764435244949961*std::exp(0.440959572792053*x_100) - 0.0523925310972809*std::exp(0.390479624271393*x_11) + 0.0210325675628203*std::exp(0.597919881343842*x_113) + 0.0473784703098365*std::exp(0.555519819259644*x_12) + 0.0103030711327684*std::exp(0.735919654369354*x_13) + 0.00974790307469203*std::exp(1.00799989700317*x_14) + 0.00951001446035358*std::exp(1.20743978023529*x_16) - 0.0309730208971501*std::exp(0.256639748811722*x_3) - 0.0324179075185455*std::exp(0.296639710664749*x_4) + 0.0264181148880601*std::exp(0.39199960231781*x_5) - 0.0117732550800289*std::exp(0.326959699392319*x_6) + 0.0683951409651156*std::exp(0.531519830226898*x_62) + 0.0111643908410371*std::exp(0.329039663076401*x_7) - 0.0149172143989353*std::exp(1.75759971141815*x_78) - 0.0403961454768776*std::exp(0.718479633331299*x_79) - 0.0358200441582982*std::exp(0.303359717130661*x_8) + 0.189384013534465*std::exp(0.286399722099304*x_98) - 0.0377884966994717*std::sin(1.14503979682922*x_101 - 7.75903987884521) - 0.0545976995135966*std::sin(1.16319978237152*x_105 + 7.80984020233154) - 0.0750659910799643*std::sin(1.21303987503052*x_108 + 4.7760796546936) + 0.0524067344493657*std::sin(1.15967988967896*x_110 + 1.62808001041412) - 0.0954618768833386*std::sin(0.790319681167603*x_111 + 8.21183967590332) - 0.0688522914638181*std::sin(0.879999816417694*x_114 - 7.63015985488892) + 0.0935877002141439*std::sin(0.722879588603973*x_115 - 4.3699197769165) + 0.0605644152614335*std::sin(1.02160000801086*x_120 + 8.18144035339355) + 0.00527283289799224*std::sin(4.38775968551636*x_66 - 0.206719815731049) - 0.0383938606216061*std::sin(1.18479979038239*x_92 - 1.17983984947205) - 0.0373316352466748*std::sin(1.35383975505829*x_94 - 1.54991984367371) + 0.0175476164561008*std::sin(1.47087955474854*x_95 + 4.54888010025024) - 0.0810570951753906*std::sin(0.986720025539398*x_99 - 1.37095963954926) - 8.00244107623958) + 0.55399330914862 + 0.000307033940004321*std::exp(-2.33999991416931*x_67));
}

int predict(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120)
{
    float s0 = score_0(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s1 = score_1(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s2 = score_2(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s3 = score_3(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s4 = score_4(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s5 = score_5(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s6 = score_6(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s7 = score_7(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s8 = score_8(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s9 = score_9(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s10 = score_10(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s11 = score_11(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);

    float max_score = s0;
    int max_index = 0;

    if(s1 > max_score) {
        max_score = s1;
        max_index = 1;
    }

    if(s2 > max_score) {
        max_score = s2;
        max_index = 2;
    }

    if(s3 > max_score) {
        max_score = s3;
        max_index = 3;
    }

    if(s4 > max_score) {
        max_score = s4;
        max_index = 4;
    }

    if(s5 > max_score) {
        max_score = s5;
        max_index = 5;
    }

    if(s6 > max_score) {
        max_score = s6;
        max_index = 6;
    }

    if(s7 > max_score) {
        max_score = s7;
        max_index = 7;
    }

    if(s8 > max_score) {
        max_score = s8;
        max_index = 8;
    }

    if(s9 > max_score) {
        max_score = s9;
        max_index = 9;
    }

    if(s10 > max_score) {
        max_score = s10;
        max_index = 10;
    }

    if(s11 > max_score) {
        max_score = s11;
        max_index = 11;
    }

    return max_index;
}

#endif
