#include "fan_model.h"

// Defina o tamanho da entrada conforme o modelo (663)
const int INPUT_SIZE = 663;

void setup() {
  Serial.begin(115200);
  while (!Serial) {
    ; // Espera a porta serial conectar
  }

  Serial.println("Inicializando a rede neural...");
  // Não precisa de setup_network() - o modelo já está configurado no .h
  
  float sample_image[INPUT_SIZE] = {
    -0.942219f, -0.961606f, -0.966557f, -0.944862f, -0.900276f, -0.951914f, -0.937808f, -0.952332f, -0.942167f, -0.912112f, -0.857521f, -0.877435f, 
    -0.844646f, -0.931810f, -0.834406f, -0.882648f, -0.956299f, -0.947311f, -0.924416f, -0.837875f, -0.861465f, -0.890556f, -0.889587f, -0.881854f, 
    -0.939154f, -0.848155f, -0.899469f, -0.914513f, -0.954897f, -0.901691f, -0.910112f, -0.907951f, -0.880693f, -0.845152f, -0.875148f, -0.902626f, 
    -0.951888f, -0.904065f, -0.898459f, -0.887088f, -0.828307f, -0.830677f, -0.864151f, -0.881596f, -0.830786f, -0.877253f, -0.940140f, -0.967722f, 
    -0.893151f, -0.881920f, -1.000000f, 0.010843f, 0.219755f, 0.335886f, -0.479724f, 0.060646f, 0.450727f, -0.106412f, -0.287202f, 0.248259f, 
    0.885742f, -0.186271f, 0.422899f, 0.838227f, 0.457212f, -0.038670f, 0.236983f, 0.156602f, 0.440586f, -0.139910f, 0.369516f, 0.372813f, 
    0.116974f, 0.234900f, 0.524227f, 0.465617f, -0.747087f, 0.287009f, 0.447212f, 0.258097f, -0.278065f, 0.101661f, 0.252244f, 0.855435f, 
    0.286364f, 0.117879f, 0.705159f, 0.088479f, 0.224879f, 0.116895f, 0.708869f, -0.219193f, 0.794876f, 0.627839f, 1.000000f, 0.195766f, 
    0.359582f, 0.496295f, 0.609411f, -0.143069f, 0.078332f, 0.208407f, -0.383877f, 0.192408f, -0.111461f, -1.000000f, 0.190205f, 0.245175f, 
    -0.163613f, -0.004954f, 0.154273f, 0.435069f, 0.048763f, -0.372666f, -0.072515f, -0.190411f, -0.509610f, -0.700986f, -0.343353f, -0.251657f, 
    -0.294498f, -0.110986f, -0.292658f, -0.579773f, -0.644966f, -0.013982f, 0.063948f, -0.656334f, 0.287569f, 0.472006f, 0.070455f, -0.186553f, 
    -0.097357f, -0.495037f, -0.058460f, -0.264826f, -0.001282f, 0.150154f, 0.180202f, 0.085541f, -0.034803f, -0.129389f, -0.560979f, -0.200509f, 
    -0.051360f, 0.333260f, -0.350981f, -0.023440f, 0.458618f, -0.218382f, -0.429757f, -0.132048f, 0.320672f, 0.620877f, 0.982994f, 0.294115f, 
    0.337406f, 0.965535f, 0.125707f, 0.219842f, 0.431638f, 0.974204f, 0.494598f, 0.164366f, 0.197533f, 0.517490f, 0.384879f, 0.558449f, 
    0.179359f, 0.189821f, 0.378987f, 0.102401f, 0.647098f, 0.760387f, 0.697846f, 0.561454f, 0.833020f, 0.682633f, 0.671972f, 0.866050f, 
    1.000000f, 0.694817f, 0.720883f, 0.719228f, 0.150941f, 0.507434f, 0.066584f, 0.946585f, 0.396558f, 0.229437f, 0.399951f, 0.466105f, 
    0.221491f, -0.106428f, -0.267106f, 0.521735f, 0.102772f, 0.262829f, 0.620189f, 0.300543f, 0.235612f, 0.717959f, 0.704463f, 0.530089f, 
    0.146436f, -0.093916f, -0.239848f, 0.297027f, 0.288243f, -0.386141f, -0.372939f, -0.125093f, 0.356707f, -0.017965f, -0.338297f, 0.018904f, 
    -0.276571f, -0.294878f, 0.282238f, -0.218579f, 0.158456f, 0.230427f, -0.456619f, 0.558634f, -0.198761f, 0.394120f, 0.389464f, 0.178351f, 
    0.068329f, 0.064118f, 0.354401f, 0.234502f, -0.278287f, 0.197041f, -0.141536f, -0.415238f, -0.384267f, -0.300306f, 0.168258f, -0.487227f, 
    -0.510665f, -0.473253f, 0.207346f, -0.347238f, -0.462671f, -1.000000f, -0.217348f, -0.441761f, -0.084765f, -0.079301f, -0.545557f, -0.248348f, 
    -0.188748f, -0.055339f, -0.570883f, 0.355934f, 0.288629f, 0.265480f, 0.880968f, 0.497997f, 0.098463f, 0.363315f, 0.072781f, 0.785224f, 
    -0.122876f, -0.638783f, 0.254414f, -0.003212f, 0.347582f, 0.856656f, 0.415359f, 1.000000f, 0.301257f, 0.207211f, 0.429565f, -0.051098f, 
    -0.094549f, 0.288056f, 0.426883f, 0.717363f, 0.236405f, 0.374725f, 0.456692f, 0.139809f, 0.882717f, 0.232027f, 0.292371f, -0.344013f, 
    -0.229793f, 0.283017f, -0.405432f, 0.260221f, -0.070348f, 0.611969f, -0.323033f, -0.066035f, -0.144073f, 0.006637f, 0.142212f, 0.401083f, 
    0.137734f, 0.434761f, -0.057677f, 0.066029f, -0.150809f, 0.396758f, -0.004626f, 0.085641f, -0.345667f, -0.474578f, -0.198747f, -0.245021f, 
    -0.291236f, -0.151062f, 0.531695f, -0.350301f, -0.442255f, -0.333377f, -0.061204f, 0.205379f, -0.162339f, -0.061746f, 1.000000f, -0.259808f, 
    -0.168335f, -0.369324f, 0.102854f, -0.023251f, -0.546199f, 0.547318f, 0.200414f, -0.117279f, -0.690921f, 0.141033f, 0.261806f, 0.646527f, 
    0.736611f, 0.893080f, -0.212529f, -0.749178f, 0.476649f, -0.352587f, 0.119486f, 0.404938f, 0.819689f, 0.253494f, -0.453073f, -0.649330f, 
    0.662086f, -0.137479f, 0.532238f, 0.484222f, -0.055964f, 0.368653f, -0.736280f, -0.415155f, 0.336475f, 0.226807f, 0.087268f, -0.334541f, 
    -0.401118f, -0.079616f, -0.320987f, -0.340005f, 0.195996f, 0.168302f, 0.069093f, -0.306411f, -0.236029f, -0.304727f, -0.253770f, 0.118848f, 
    0.079395f, 0.201733f, -0.019220f, -0.260079f, -0.213519f, -0.348829f, -0.420556f, -1.000000f, 0.162611f, -0.095197f, 0.524374f, -0.650770f, 
    -0.136066f, -0.180780f, 0.259943f, 0.380901f, 0.672667f, 0.010430f, -0.329500f, 0.548320f, 0.238650f, 0.143378f, 0.102617f, 0.711473f, 
    0.261819f, 0.012560f, -0.368882f, 0.206134f, -0.039692f, 0.638346f, 0.381006f, -0.183662f, 0.364145f, -0.105833f, 0.181766f, -0.069064f, 
    -0.596030f, 0.606915f, 0.301700f, 0.098814f, -0.196540f, 0.226300f, 0.683057f, 0.644933f, -0.030884f, -0.392078f, 0.061505f, 0.036768f, 
    -0.522894f, -0.174716f, -0.233744f, -0.240102f, -0.454056f, 0.476021f, -1.000000f, 0.009312f, -0.644558f, -0.951645f, -0.882069f, -0.418445f, 
    0.333329f, 0.240399f, -0.214225f, -0.889544f, -0.634694f, 0.281953f, 0.067860f, 0.342626f, -0.401816f, -0.857260f, 0.116658f, -0.107584f, 
    0.554515f, -0.364657f, 0.816737f, -0.257882f, -0.387380f, -0.490203f, 0.223168f, -0.461776f, 0.889283f, 0.400909f, -0.268523f, -0.090504f, 
    0.699203f, 0.672506f, 0.027339f, -0.238339f, -0.119349f, -0.321455f, -0.473184f, 0.354898f, -0.043610f, 0.532420f, 0.465666f, 0.293283f, 
    -0.366113f, 0.424832f, 0.509393f, -0.126903f, 0.175944f, -0.310819f, 0.071801f, 0.215735f, 0.293401f, -1.000000f, 0.191235f, -0.160074f, 
    0.191835f, -0.243897f, 0.081506f, 0.470820f, -0.344793f, 0.168997f, -0.284350f, -0.052861f, 0.430381f, 0.005643f, 0.286609f, -0.840824f, 
    -0.462771f, -0.094564f, -0.228615f, -0.295144f, 0.015005f, 0.587718f, 0.051228f, -0.331820f, -0.428653f, 0.093510f, -0.395026f, 0.374667f, 
    0.022529f, -0.475507f, -0.027879f, -0.340771f, 0.496631f, -0.112203f, -0.853221f, -0.179631f, 0.374077f, -0.533585f, 0.254703f, 0.128382f, 
    0.143120f, 0.317298f, -0.357922f, 0.009726f, -0.290647f, 0.437902f, 0.226908f, 0.672568f, -0.167257f, 0.308948f, 1.000000f, 0.079416f, 
    -0.306753f, 0.188244f, -0.140871f, -0.461300f, 0.107604f, 0.031616f, -0.109947f, -0.189970f, -0.078716f, -0.076706f, 0.473211f, 0.019802f, 
    -0.265988f, 0.125355f, -0.279605f, -0.792161f, -0.065433f, -0.210072f, -0.122154f, -0.099035f, 0.115210f, 0.390473f, -0.129547f, 0.085400f, 
    0.249600f, -0.548846f, -0.521226f, -0.272168f, -0.144583f, 0.351366f, -0.562819f, 0.228922f, -0.123310f, -0.516144f, -0.000405f, 0.518479f, 
    0.134047f, 0.470464f, -0.006447f, 0.976658f, -0.141736f, -0.161760f, -0.006744f, 0.779679f, 0.441510f, 0.089588f, -0.429858f, 0.752484f, 
    0.309447f, 0.555400f, 0.370029f, 0.113068f, 0.065889f, 0.169163f, 0.341014f, -0.023937f, 0.046180f, -0.015279f, 0.700970f, -0.092936f, 
    0.171434f, 0.193145f, 0.488893f, 0.259872f, -0.005207f, 0.277706f, -0.269196f, -0.066840f, 0.227761f, 0.909334f, -0.541164f, -0.068536f, 
    0.378200f, 1.000000f, 0.487253f, 0.864204f, -0.087163f, 0.039260f, 0.419153f, -0.123534f, 0.063039f, 0.054550f, 0.494961f, -0.441471f, 
    -0.264172f, 0.122473f, 0.583345f, -0.173123f, 0.241001f, -0.046761f, 0.257941f, -0.035004f, -0.141262f, 0.552417f, 0.687331f, 0.088014f, 
    0.062723f, -0.212024f, 0.352631f, 0.451742f, 0.295661f, 0.081821f, -0.297621f, -0.594775f, -0.013857f, 0.414549f, 0.252984f, 0.375560f, 
    0.055327f, -0.219528f, -0.234937f, -0.060576f, 0.157954f, -0.023455f, 0.717878f, 0.332606f, 0.813484f, 0.172430f, -0.138435f, 0.027187f, 
    0.475147f, -0.429021f, -0.788397f, 0.615082f, 1.000000f, 0.266621f, 0.983600f, 0.130146f, -0.212569f, 0.313170f, 0.173647f, -0.514755f, 
    -0.215443f, 0.476725f, 0.330495f
};

  Serial.println("Realizando inferência...");

  // Array para armazenar as saídas (12 valores)
  float predictions[FAN_OUTPUT_SIZE];

  // Chama a função de predição do modelo
  fan_predict(sample_image, predictions);

  // Imprime as probabilidades de saída
  Serial.println("Probabilidades de saída (12 classes):");
  int predicted_class = -1;
  float max_prob = -1.0;

  for (int i = 0; i < FAN_OUTPUT_SIZE; i++) {
    Serial.print("Classe ");
    Serial.print(i);
    Serial.print(": ");
    Serial.println(predictions[i], 6); // Imprime com 6 casas decimais

    if (predictions[i] > max_prob) {
      max_prob = predictions[i];
      predicted_class = i;
    }
  }

  Serial.println("--------------------");
  Serial.print("Classe prevista: ");
  Serial.println(predicted_class);
  Serial.print("Com probabilidade de: ");
  Serial.println(max_prob, 6);
  Serial.println("--------------------");
}

void loop() {
  // Nada a fazer no loop, a inferência foi feita no setup.
}