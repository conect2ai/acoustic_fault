#include "neural_network.h"

// --- Buffers Globais ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Pesos da camada convolucional conv0
const float conv0_weights[] PROGMEM = {
    -0.89386273f, -0.37331823f, -0.75543454f, -0.27807779f, -1.07739902f, -0.20730139f, -0.58588891f, -0.22980366f, 
    0.03845747f, -0.28723171f, -0.66086194f, -1.17124966f, 0.68681958f, 0.02737932f, 0.48074515f, -0.30154064f, 
    -0.01135734f, -0.07933038f, 0.26291099f, -0.54667590f, 0.67440198f, -0.44927518f, 0.21331445f, 0.23846240f, 
    -0.37225856f, -0.68611434f, -0.09464797f, 0.51054398f, 0.30672945f, -0.24352019f, -0.92545757f, -0.39532459f, 
    -0.71384427f, -0.98821243f, -0.58204075f, -0.63942993f, -0.06063374f, -0.04265213f, -0.03149020f, -0.01236389f, 
    -0.00738372f, 0.00193781f, 0.04909451f, -0.00004597f, -0.02049953f, 0.36850181f, 0.46907846f, 1.06112996f, 
    0.86460867f, 0.86880453f, 0.63172629f, 0.23976088f, -0.31691046f, -0.06690045f, -0.14067419f, -0.95749591f, 
    -0.58406504f, -0.04636909f, -1.04924443f, -0.73003375f, 0.46798448f, -0.33760878f, -0.36955820f, 0.58575368f, 
    0.45936169f, 1.08351925f, -0.55994708f, -0.47695382f, -0.22613817f, -0.43049575f, 0.06314987f, -0.14629908f
};;

// Vieses da camada convolucional conv0
const float conv0_biases[] PROGMEM = {
    -1.21784857f, -1.22554173f, -1.08670275f, -1.20506953f, -0.27702431f, -0.89923391f, -1.45485063f, -1.24512415f
};;

// Pesos da camada densa dense0
const float dense0_weights[] PROGMEM = {
    -0.00899088f, 0.49535341f, 0.14859092f, -0.10715874f, 0.14589228f, -0.16706759f, 0.11749276f, -0.03629074f, 
    0.03447669f, -0.34525786f, -0.20382697f, 0.07743356f, -0.11772419f, 0.26354765f, -0.00221540f, 0.27516923f, 
    0.17034948f, 0.35301900f, -0.15506393f, -0.01524655f, -0.00504066f, -0.15597605f, 0.00717157f, -0.17130770f, 
    0.01910799f, 0.03546911f, -0.05415002f, -0.05395622f, -0.24375847f, -0.00495636f, 0.07907800f, -0.14688548f, 
    0.03394765f, -0.28259631f, 0.13450151f, -0.02468296f, 0.28468055f, 0.16958219f, 0.07670805f, -0.04741481f, 
    -0.15575355f, 0.01518073f, 0.17403203f, 0.11292363f, 0.00602064f, -0.20897706f, -0.11217505f, 0.04735608f, 
    -0.02609969f, 0.21088424f, 0.09584552f, 0.13435372f, -0.01793149f, -0.12690818f, 0.11726852f, -0.02481755f, 
    0.15842919f, 0.04622372f, -0.15835794f, 0.07795801f, 0.08978549f, -0.10859747f, 0.51882954f, 0.02681297f, 
    0.13711454f, -0.03021247f, 0.11432274f, 0.05446366f, 0.19031244f, 0.01827176f, -0.07496611f, 0.06409287f, 
    0.07935942f, -0.15120132f, 0.12870698f, -0.05414418f, 0.07488283f, -0.20068947f, 0.03334993f, -0.15377141f, 
    0.14032121f, -0.06925605f, 0.09994265f, 0.02493466f, -0.18005896f, 0.10860592f, -0.01158964f, -0.04287425f, 
    0.19668612f, 0.17924805f, 0.05547941f, -0.01093895f, 0.04438298f, -0.28009151f, -0.15453324f, -0.33154940f, 
    -0.15174775f, -0.19400553f, -0.09723694f, -0.29646833f, -0.45563972f, -0.35373183f, -0.38557402f, -0.26090363f, 
    -0.19818486f, -0.01859924f, -0.07122992f, 0.41896927f, -0.06680504f, -0.00231962f, -0.07498824f, -0.28892956f, 
    -0.13743838f, 0.20520196f, -0.07759336f, 0.02498632f, 0.00396009f, 0.20801787f, 0.15680765f, -0.07038276f, 
    -0.08103530f, 0.10664098f, 0.18659087f, 0.15801835f, -0.11123934f, 0.21095449f, 0.09718220f, 0.09082514f, 
    -0.20825408f, -0.11889073f, -0.09708292f, 0.19212785f, 0.16305250f, 0.10934784f, 0.00756839f, 0.22855928f, 
    0.10025071f, -0.09282198f, 0.28887234f, -0.15492118f, -0.19637953f, 0.07504195f, 0.12163126f, 0.06388316f, 
    -0.13307016f, -0.07305272f, -0.15778462f, -0.12168944f, 0.00008589f, 0.22498233f, -0.18846079f, 0.02037839f, 
    -0.00691519f, -0.00531042f, -0.18311448f, 0.14787113f, 0.03602395f, 0.18384382f, -0.20705650f, -0.19377704f, 
    0.09694222f, 0.01471994f, -0.17267892f, 0.05731171f, 0.16831520f, -0.07381596f, -0.06445469f, 0.01800594f, 
    -0.08851823f, 0.32957951f, 0.01643546f, 0.15481698f, -0.04763773f, 0.30911130f, 0.17029502f, 0.02412888f, 
    0.02531815f, 0.07179057f, 0.12749428f, 0.05095700f, 0.01152332f, -0.07118758f, 0.15371798f, -0.31717390f, 
    -0.10005992f, -0.03988144f, -0.03132026f, 0.07559439f, 0.15912545f, 0.03480207f, -0.06191247f, -0.04595103f, 
    0.03238437f, 0.03540844f, -0.00215017f, 0.02977614f, -0.12224149f, -0.10890956f, -0.07434850f, -0.02937907f, 
    0.14452588f, -0.12008962f, -0.11629331f, -0.01058754f, 0.02916071f, 0.13571005f, 0.17160722f, 0.11884805f, 
    0.23987659f, 0.09014278f, 0.10293181f, 0.27613397f, 0.04723898f, 0.11009677f, 0.11686324f, 0.17463413f, 
    -0.29189530f, 0.06115817f, -0.07505203f, -0.07851545f, -0.06027864f, -0.10397540f, -0.13380392f, 0.12010630f, 
    -0.19095395f, -0.37782458f, -0.23564293f, -0.37309431f, -0.17934333f, -0.08662805f, -0.00085432f, -0.08138051f, 
    -0.13107466f, -0.09195405f, -0.03750634f, 0.07818603f, 0.04053195f, 0.11533142f, 0.24586063f, 0.16842447f, 
    0.10043903f, 0.23499222f, 0.20130834f, 0.07476487f, 0.04564829f, 0.14719102f, 0.00075426f, 0.03767709f, 
    -0.01732031f, -0.10014050f, 0.03224542f, -0.03342807f, -0.12294404f, -0.11600436f, 0.11433384f, 0.00541664f, 
    -0.04094903f, 0.14667613f, -0.04695857f, 0.00589028f, 0.00713257f, -0.05552633f, 0.05423944f, 0.11667636f, 
    0.01052869f, -0.05742847f, -0.04914833f, 0.13239754f, 0.03231442f, -0.17500857f, 0.12578783f, -0.03987196f, 
    0.29283289f, -0.01148925f, 0.19190501f, 0.13269034f, -0.01361373f, 0.01805853f, -0.09817546f, -0.09466776f, 
    0.20843567f, 0.01722836f, -0.06933932f, 0.21102852f, 0.00282407f, 0.03110812f, 0.27407448f, 0.06232476f, 
    0.12538472f, -0.01061292f, 0.09274549f, -0.03503521f, -0.16681543f, -0.11177076f, 0.01767851f, -0.02527576f, 
    0.19182569f, -0.01863984f, 0.07354075f, -0.14057595f, 0.05545852f, -0.05032171f, -0.02890154f, -0.06748203f, 
    -0.03293239f, -0.00689116f, 0.04659045f, -0.06123233f, 0.16545132f, -0.14738308f, 0.04519900f, 0.29165274f, 
    0.07123464f, 0.11287508f, 0.04791432f, 0.25108870f, 0.22011954f, 0.05018578f, 0.07607815f, 0.17843286f, 
    0.08766772f, -0.05755855f, -0.01389723f, 0.04315042f, 0.03141702f, -0.11174130f, -0.15309570f, -0.03480113f, 
    0.14230013f, 0.04801445f, -0.03308102f, -0.24997161f, 0.16103528f, -0.18056103f, -0.06307782f, -0.14028096f, 
    -0.08198517f, -0.25105917f, -0.26822613f, -0.11379883f, -0.01508576f, -0.09550167f, 0.06473759f, 0.02285324f, 
    -0.18603157f, 0.12617782f, 0.17794225f, 0.02923402f, 0.03363831f, -0.10615150f, 0.03093040f, 0.08998601f, 
    -0.02197472f, -0.00766613f, 0.01210352f, 0.06085518f, 0.01082181f, 0.15274347f, -0.02827506f, -0.08578129f, 
    -0.01530804f, 0.03507284f, -0.28475935f, -0.11547493f, -0.11836104f, 0.02010672f, -0.05640503f, 0.02506384f, 
    -0.06903531f, -0.27495654f, -0.09506499f, -0.10154407f, 0.04313149f, -0.08571272f, 0.18091198f, 0.06653508f, 
    0.03023444f, 0.08631455f, -0.07430194f, -0.06001132f, -0.15700953f, -0.19809032f, 0.02396177f, 0.04023726f, 
    -0.06933619f, 0.06370770f, -0.18295582f, 0.25728751f, -0.03564663f, -0.09501658f, -0.05064090f, -0.19532756f, 
    -0.06563471f, -0.32177764f, 0.10515526f, -0.03426453f, 0.00343802f, 0.02047939f, 0.03422679f, 0.07721653f, 
    0.06989008f, -0.00605464f, 0.35018358f, 0.04686848f, 0.18357988f, -0.32524239f, 0.03438484f, 0.29248814f, 
    0.14161050f, 0.17706660f, 0.10728034f, 0.10583898f, 0.27110894f, 0.21529728f, 0.11226385f, -0.02499277f, 
    -0.15445632f, 0.09483627f, -0.28993123f, 0.09708522f, -0.27405393f, -0.27707793f, -0.28220920f, -0.23673391f, 
    0.11010085f, 0.11262453f, 0.09364527f, -0.13415690f, 0.15540942f, 0.16572530f, 0.06348732f, 0.16697602f, 
    -0.09791368f, 0.01242973f, 0.12787936f, 0.14145404f, 0.03539403f, 0.19071684f, -0.09930215f, 0.11688662f, 
    0.38183000f, 0.09722545f, 0.02707009f, 0.02578856f, 0.01731202f, 0.16544571f, 0.19428107f, 0.05265973f, 
    0.17204188f, 0.10321094f, 0.13178681f, 0.11065959f, 0.28638462f, 0.10277699f, 0.35406262f, 0.17431206f, 
    -0.12768962f, 0.14681145f, 0.04194780f, -0.13033218f, -0.25162732f, -0.03512791f, -0.30397755f, -0.08890616f, 
    -0.21573083f, -0.07724980f, -0.22222661f, -0.00526588f, 0.02654129f, 0.00221710f, -0.13029053f, 0.08095844f, 
    0.02942415f, -0.13241327f, 0.01163100f, 0.35249695f, 0.01749912f, 0.16059736f, -0.04450195f, 0.02328611f, 
    -0.16269760f, 0.17651829f, 0.16939851f, 0.02094720f, 0.21842229f, 0.53801955f, -0.22234631f, -0.17328490f, 
    -0.05819749f, -0.20333163f, -0.03115770f, -0.16603135f, -0.12037053f, -0.07973259f, 0.10347187f, -0.17917613f, 
    0.05512837f, -0.01324858f, 0.13476721f, -0.23497245f, 0.08620222f, 0.02675551f, 0.38882988f, 0.01981615f, 
    0.06906566f, -0.00328297f, 0.02408654f, -0.20963448f, -0.04188452f, 0.01284775f, -0.09938768f, 0.01527539f, 
    0.08213065f, -0.15843542f, -0.04086721f, -0.15960174f, 0.15513978f, -0.05371431f, 0.06632943f, 0.00184572f, 
    0.08092697f, -0.14235207f, -0.12010385f, 0.17496856f, 0.11796083f, 0.00792810f, 0.04296046f, 0.02781284f, 
    -0.02401584f, -0.13349868f, -0.05354078f, 0.18797845f, -0.11685923f, -0.05071123f, -0.20173243f, 0.06733327f, 
    -0.00133576f, -0.01193401f, -0.06806603f, -0.13223521f, -0.04317057f, -0.08444362f, 0.01112002f, 0.15876737f, 
    -0.20261129f, 0.00174484f, 0.06813218f, -0.00011772f, -0.03523786f, -0.04217450f, -0.13127953f, -0.05286560f, 
    -0.01706951f, -0.19921475f, 0.03285140f, 0.02503322f, 0.23491693f, 0.20932788f, 0.12681534f, 0.27708248f, 
    0.01049129f, -0.05729986f, -0.03975422f, 0.09944283f, 0.00048362f, 0.09458125f, -0.03640584f, 0.09807406f, 
    0.01398086f, 0.05201736f, -0.11845084f, 0.06567361f, 0.10253485f, -0.06708834f, 0.04792522f, -0.10791950f, 
    0.04880223f, 0.01199540f, -0.12809048f, 0.02373444f, 0.03920050f, -0.04552483f, 0.16705233f, -0.06232371f, 
    0.01516081f, -0.08954765f, -0.11653013f, 0.09657431f, 0.02960253f, 0.08180787f, 0.00860812f, -0.05356495f, 
    0.07679866f, 0.16320694f, -0.15025702f, -0.02281675f, -0.01834847f, 0.17149060f, -0.09232758f, 0.06438001f, 
    0.16592847f, -0.00481526f, -0.03989852f, -0.00184873f, 0.03731110f, -0.15392978f, -0.02803146f, 0.02585776f, 
    -0.13137603f, -0.02081781f, -0.09495101f, -0.04126822f, -0.05299799f, 0.05333194f, 0.07664247f, 0.11964909f, 
    -0.00983783f, -0.07151749f, 0.00361662f, -0.01590614f, 0.13616594f, -0.06164528f, 0.05684311f, 0.19798964f, 
    -0.17919194f, -0.02558855f, -0.05971488f, 0.05962543f, -0.09066081f, 0.11689829f, 0.18784481f, -0.00634402f, 
    0.19800484f, 0.08200160f, -0.06196152f, -0.38324707f, -0.04526524f, -0.14067806f, 0.09437540f, -0.17743078f, 
    0.02484879f, 0.31879394f, 0.00436015f, -0.28329159f, -0.18797780f, 0.01490645f, -0.14327748f, -0.16188941f, 
    -0.11129246f, 0.11634142f, -0.22326857f, 0.42552153f, 0.24477262f, 0.07117286f, -0.03975202f, 0.21647424f, 
    0.34526811f, 0.18080184f, 0.11784661f, 0.20809014f, 0.29820605f, 0.18271599f, 0.16311665f, 0.06104326f, 
    0.22829834f, 0.06184053f, -0.02283489f, -0.09323970f, -0.18846674f, 0.02298471f, -0.09825950f, 0.13075483f, 
    0.08105617f, -0.12418678f, 0.07867472f, 0.08945731f, 0.04303572f, 0.00570008f, -0.28263939f, -0.09012833f, 
    -0.05278365f, 0.08746534f, -0.07286656f, -0.23205276f, -0.21386868f, -0.02214319f, -0.12081726f, -0.04151023f, 
    -0.31338321f, -0.13109136f, -0.20049086f, -0.05652590f, -0.00225122f, -0.04285798f, 0.21159198f, 0.26887131f, 
    -0.29078787f, -0.07200681f, -0.23256685f, 0.15865142f, -0.16642848f, -0.23486357f, -0.14618940f, 0.09534370f, 
    0.01320321f, -0.44620087f, -0.16232322f, -0.42513520f, -0.13421040f, 0.18208377f, 0.01660281f, -0.08269827f, 
    -0.03581611f, -0.07100593f, 0.06915366f, 0.10235136f, 0.03654655f, -0.05961308f, 0.13704058f, 0.08705321f, 
    0.32249267f, 0.33199648f, 0.12795029f, -0.19542878f, 0.13544587f, 0.29093157f, 0.00694302f, 0.16069553f, 
    0.12233030f, 0.29368597f, 0.34168545f, 0.14240316f, 0.28043147f, 0.18488858f, -0.05307586f, -0.00061107f, 
    -0.11144992f, -0.14777053f, 0.07301352f, 0.01026061f, -0.12260172f, 0.03837018f, 0.13007502f, 0.07054175f, 
    -0.21345673f, 0.00647429f, 0.01764438f, -0.21999116f, -0.41176714f, -0.19892996f, -0.23673510f, -0.20459774f, 
    -0.02740751f, 0.02661379f, -0.15483661f, -0.43391494f, -0.11634151f, 0.13989786f, -0.04431675f, -0.21625833f, 
    0.10462505f, -0.06013469f, -0.18633579f, 0.06287689f, 0.02007364f, -0.04247725f, 0.11383212f, -0.03475207f, 
    0.02635054f, 0.06422974f, 0.15556069f, 0.26740348f, 0.02382037f, 0.13896351f, -0.04974864f, 0.37101989f, 
    0.08057982f, -0.11202829f, -0.03843946f, -0.24128670f, 0.01024200f, 0.12570273f, -0.14991856f, -0.05671396f, 
    -0.04002831f, 0.15554085f, 0.19399205f, 0.10023112f, -0.13632042f, -0.16088107f, 0.18125727f, 0.05613268f, 
    0.24556120f, 0.24654725f, 0.20073984f, 0.10155461f, -0.17035791f, 0.08391607f, -0.06658471f, -0.14305545f, 
    -0.05605049f, 0.06148017f, 0.18346895f, 0.20827227f, -0.25065830f, 0.13792668f, 0.24539888f, 0.01630494f, 
    0.28299302f, 0.01555405f, 0.27261501f, -0.05864038f, -0.02876458f, 0.16446522f, -0.25577019f, 0.15597125f, 
    -0.18962132f, -0.03450794f, 0.33879478f, 0.00752034f, 0.06180231f, -0.06794339f, 0.08530462f, -0.04848711f, 
    -0.10275804f, 0.07080786f, 0.02906246f, 0.01205571f, -0.07951099f, 0.03122260f, -0.00519760f, 0.36686566f, 
    0.03456665f, 0.10625712f, -0.01948426f, 0.17766815f, 0.07790163f, 0.13321351f, 0.09768651f, -0.02134341f, 
    0.03758169f, -0.03658561f, -0.23013977f, 0.36489803f, 0.10496749f, -0.03958208f, -0.21843188f, -0.07955676f, 
    -0.24214488f, 0.01467963f, -0.33631603f, 0.01599473f, -0.18792994f, -0.12226589f, -0.26914012f, -0.31269550f, 
    -0.31794977f, -0.28635504f, -0.07651449f, -0.21542470f, -0.21595442f, 0.14355712f, 0.18687331f, 0.15745721f, 
    -0.05348940f, -0.07708293f, -0.01449286f, -0.29844797f, -0.21855265f, -0.31069572f, 0.10770911f, -0.06298550f, 
    -0.09345832f, 0.22230332f, -0.01040036f, -0.17878794f, 0.32801657f, -0.09108501f, 0.20677795f, 0.06888872f, 
    0.25569244f, -0.02722276f, 0.30694929f, 0.14547855f, 0.30107382f, 0.13359700f, -0.12359046f, -0.00230983f, 
    -0.19266844f, -0.22248126f, 0.33980560f, 0.00424825f, 0.05408627f, -0.08912823f, -0.05259612f, -0.33373120f, 
    -0.27492035f, -0.42686153f, -0.15555731f, -0.21563574f, 0.06059938f, 0.20182488f, 0.08758241f, 0.15650662f, 
    0.14733923f, 0.15833501f, -0.20214355f, 0.01266642f, 0.19954041f, -0.11509967f, 0.02753126f, 0.30864651f, 
    0.26023035f, -0.11964341f, 0.12496687f, 0.07565820f, 0.26022312f, 0.17839203f, -0.15270425f, 0.08847206f, 
    0.03437780f, -0.01978527f, -0.11141932f, 0.09067066f, -0.16435010f, 0.00808424f, 0.20690747f, 0.04652754f, 
    0.03643953f, 0.00988689f, -0.00648869f, -0.21689111f, -0.00012696f, -0.05694153f, -0.03048414f, -0.19580416f, 
    0.11212902f, -0.04305110f, -0.14033960f, 0.08494689f, -0.06591454f, 0.11567200f, -0.04905336f, 0.15411584f, 
    0.18143696f, -0.04867748f, -0.03823546f, -0.14616982f, 0.07370667f, -0.07346904f, -0.04368588f, 0.17722439f, 
    0.11695479f, -0.01818216f, 0.03019306f, 0.07958966f, -0.09587857f, -0.09253313f, -0.05614862f, -0.00401087f, 
    0.08871207f, 0.12229304f, 0.16026776f, -0.15495961f, -0.21687957f, -0.12679767f, -0.14086093f, -0.08098004f, 
    -0.08699416f, -0.06789573f, -0.11345271f, 0.13299863f, -0.15708334f, -0.13950982f, 0.10951576f, 0.05588715f, 
    0.12990154f, 0.06269616f, 0.01720900f, 0.13573092f, -0.02379462f, 0.20587955f, 0.39124475f, 0.09791301f, 
    0.29544420f, 0.43763106f, 0.34103248f, 0.37650048f, 0.10534415f, 0.07917982f, -0.31265722f, -0.10564730f, 
    -0.12803917f, -0.28748109f, -0.14464864f, -0.17004893f, -0.14505714f, 0.03512185f, 0.01700971f, -0.32207809f, 
    0.01020229f, -0.05091474f, -0.04987853f, -0.18436404f, 0.00875589f, -0.04896879f, 0.13983643f, -0.28673083f, 
    -0.08451369f, 0.30755619f, 0.01764751f, 0.26608343f, 0.00905986f, 0.13627916f, 0.02841401f, -0.20198239f, 
    0.39180523f, 0.23499940f, 0.08283403f, -0.01624674f, 0.05731977f, -0.34967499f, 0.01029357f, -0.05842568f, 
    0.05175390f, -0.06136445f, -0.19062411f, 0.23175010f, 0.05096901f, 0.07376678f, -0.01930185f, 0.34352878f, 
    0.18759344f, 0.28638705f, 0.22130171f, 0.03354449f, 0.12095275f, 0.22318165f, 0.07376845f, 0.15168612f, 
    -0.13789121f, -0.11145307f, 0.15658753f, 0.06533974f, -0.25801670f, 0.35163869f, 0.28847727f, 0.06136779f, 
    0.27062498f, -0.10823454f, 0.03680343f, -0.05853901f, 0.16923027f, 0.04279828f, -0.28298174f, 0.45883997f, 
    0.04879702f, -0.05922250f, 0.00155164f, -0.09005704f, 0.08684700f, 0.23070981f, -0.22387129f, 0.07745794f, 
    0.11484900f, -0.02473827f, 0.05690258f, -0.15247457f, 0.42536869f, -0.06333529f, -0.26699651f, -0.00065934f, 
    -0.24154454f, 0.25240857f, -0.25174194f, 0.01150619f, 0.32740514f, -0.03381517f, -0.27131831f, -0.27732401f, 
    0.01877439f, -0.21894805f, -0.02274059f, -0.14116881f, -0.25832494f, -0.15117499f, 0.17217486f, -0.09291728f, 
    0.25876330f, -0.28585729f, 0.01142012f, -0.40272986f, 0.09420318f, -0.28257460f, -0.06658812f, -0.07686380f, 
    0.01014801f, -0.06179396f, -0.14930610f, -0.09645403f, -0.06325169f, 0.15562967f, 0.01419714f, 0.03283525f, 
    -0.17334057f, -0.24866062f, -0.15084030f, -0.29028763f, -0.26296767f, -0.14983587f, -0.15762286f, -0.05119197f, 
    -0.08767950f, -0.12553968f, 0.14100106f, -0.30235732f, 0.14031853f, -0.02459663f, 0.01806763f, -0.10531699f, 
    -0.10544026f, -0.03132507f, 0.15353351f, -0.16717852f, 0.10099511f, -0.33319141f, -0.07492330f, -0.11732880f, 
    0.08748942f, -0.01696718f, -0.27975840f, -0.07775027f, -0.00940122f, -0.12717809f, 0.03679625f, 0.35495400f, 
    0.24776311f, 0.10865683f, 0.13795929f, 0.34674054f, 0.04884134f, -0.15421846f, 0.31076975f, 0.11405805f, 
    0.04584200f, -0.02042094f, 0.02622366f, -0.07653552f, 0.10112998f, -0.00195196f, 0.03360612f, -0.14855329f, 
    0.01537072f, 0.11190493f, -0.14523984f, 0.00988709f, -0.05748165f, -0.17322577f, 0.25132659f, -0.05876645f, 
    -0.13052543f, -0.17406083f, -0.20032021f, -0.14285079f, -0.18848199f, -0.16378153f, -0.00627936f, -0.05056011f, 
    0.08929318f, -0.08186037f, 0.14183559f, 0.12779716f, -0.03290921f, -0.18336621f, 0.11372182f, -0.01452975f, 
    0.22399385f, -0.03264354f, 0.08739452f, -0.00868346f, 0.04014335f, 0.33954042f, -0.04031890f, -0.12487714f, 
    0.03140982f, 0.04449166f, 0.17326701f, -0.04795888f, 0.20273251f, -0.18267530f, -0.15368824f, -0.11441147f, 
    0.13922698f, 0.11546540f, -0.05677786f, 0.09907557f, -0.00773182f, 0.31693921f, -0.20632530f, 0.05547642f, 
    -0.19157738f, -0.17779691f, 0.02019016f, 0.07559711f, -0.01539994f, -0.01938914f, -0.06299897f, -0.25499737f, 
    -0.09145600f, -0.25875960f, -0.13541503f, 0.02474109f, -0.10763460f, -0.14192195f, -0.03907884f, -0.22277343f, 
    -0.07053717f, -0.22637920f, 0.07353791f, -0.11690178f, 0.08707834f, 0.06557814f, 0.06623565f, 0.02433698f, 
    0.04011141f, 0.04146568f, -0.06781489f, -0.12098005f, 0.02470214f, -0.07963783f, -0.19244168f, -0.19023854f, 
    -0.04967272f, -0.17797926f, -0.12343262f, -0.10297926f, -0.07225073f, -0.15059045f, -0.14361047f, -0.24562754f, 
    -0.04189176f, -0.13843248f, -0.06551159f, 0.13540390f, 0.14100175f, 0.08440706f, 0.13698395f, -0.29958592f, 
    0.00257341f, 0.09982341f, 0.02658801f, -0.29884056f, 0.23832585f, -0.00387862f, -0.07101640f, 0.00524226f, 
    -0.12216481f, 0.05436664f, -0.00467389f, 0.14978265f, 0.16833061f, 0.13177159f, 0.03460777f, -0.10332361f, 
    0.10398110f, -0.08800266f, 0.02872432f, 0.19389005f, -0.12187197f, 0.05138735f, -0.01170117f, -0.02698255f, 
    0.11592062f, -0.02646630f, 0.26524513f, -0.13342475f, -0.09485907f, 0.22475363f, 0.02443430f, -0.08056037f, 
    -0.13517783f, 0.09257877f, -0.04713204f, 0.09762262f, -0.08613796f, 0.05730887f, 0.13229986f, -0.03480906f, 
    -0.19675427f, 0.14229294f, 0.02778286f, 0.11152999f, -0.08272447f, 0.04451295f, 0.14548827f, -0.10180736f, 
    0.09168379f, -0.07234977f, 0.22054660f, -0.05362139f, -0.11193086f, -0.01946266f, -0.00188166f, -0.17375419f, 
    -0.09508979f, 0.15106322f, -0.06776972f, -0.05210206f, -0.08321760f, -0.09188022f, -0.01168623f, 0.09965046f, 
    0.21026824f, -0.02174851f, -0.23144756f, 0.04389517f, -0.07789854f, -0.20479268f, -0.15933116f, -0.22107987f, 
    -0.11806665f, -0.13180633f, -0.09536194f, 0.08607304f, -0.19609622f, -0.04891248f, 0.09378660f, -0.16870063f, 
    0.03148396f, 0.18755915f, -0.10794909f, 0.08103337f, -0.28522287f, 0.02710175f, -0.16581563f, 0.02827349f, 
    -0.08670976f, -0.06841703f, -0.21150095f, 0.00568892f, -0.02580946f, -0.16020921f, -0.25215373f, -0.10550159f, 
    0.18995775f, -0.14722326f, -0.07154177f, 0.01297369f, 0.05784141f, -0.13210486f, -0.00862104f, -0.09811049f, 
    -0.16788620f, -0.07141318f, 0.07770973f, -0.31646148f, -0.05535439f, 0.12294250f, 0.24370118f, -0.15575626f, 
    0.04054342f, -0.01624572f, 0.17715108f, -0.03799198f, -0.03161039f, 0.13015522f, -0.01043248f, -0.09288861f, 
    -0.12469630f, 0.02470255f, 0.09923213f, 0.08042086f, -0.17023668f, 0.00036281f, 0.06873518f, -0.09768736f, 
    0.08261815f, -0.35634661f, -0.02239205f, 0.16899392f, -0.06809183f, -0.13549139f, 0.17917506f, 0.15288481f, 
    0.04412268f, -0.09349103f, 0.27940215f, 0.00626727f, -0.00256677f, 0.13701824f, 0.13120234f, -0.16537497f, 
    -0.18174931f, -0.15037686f, -0.03654276f, -0.13118179f, 0.14749781f, 0.12250057f, -0.22434174f, -0.04716931f, 
    -0.12741222f, 0.30296620f, 0.07413751f, 0.00976953f, 0.17085928f, 0.31974542f, -0.07408449f, 0.01384896f, 
    0.02959961f, 0.16625540f, 0.14334770f, 0.54707824f, 0.21187102f, 0.35736116f, 0.14732002f, -0.05424371f, 
    0.35843780f, 0.06297565f, -0.02910923f, 0.34138115f, 0.21358979f, -0.02193207f, 0.01522616f, 0.35458490f, 
    0.16977906f, -0.11656915f, 0.03961313f, -0.13674117f, 0.21095143f, 0.11089593f, -0.16661610f, 0.07860014f, 
    0.01564208f, 0.43283752f, 0.04885966f, 0.05824839f, -0.05979542f, 0.04426898f, -0.22392059f, -0.16603275f, 
    -0.01793451f, -0.14831859f, -0.31880069f, -0.07364676f, 0.02470359f, 0.02068859f, 0.08497477f, 0.08478708f, 
    0.04731326f, 0.08787309f, 0.04221687f, 0.00191170f, 0.08571969f, -0.30254467f, -0.04149472f, 0.20852286f, 
    -0.26176754f, -0.30037960f, -0.07346320f, -0.17188425f, -0.14192805f, -0.05608073f, -0.10433333f, -0.16029839f, 
    0.06711109f, -0.07674450f, -0.01750443f, -0.04274193f, -0.03007672f, -0.37373702f, -0.01937018f, -0.01008269f, 
    -0.09757374f, -0.20466948f, 0.11560652f, -0.03887471f, -0.27976023f, -0.28328210f, -0.08209401f, -0.28171389f, 
    0.07990143f, 0.21313328f, 0.07966412f, 0.05136613f, 0.26918741f, -0.18551490f, -0.30851262f, -0.00370802f, 
    0.25676463f, 0.03579974f, -0.03181609f, 0.00933576f, 0.08230244f, -0.08939439f, 0.07103327f, 0.18581478f, 
    0.21937577f, -0.01322107f, 0.13431957f, 0.21532641f, 0.04176181f, 0.16724869f, -0.15428185f, -0.27703265f, 
    -0.25874776f, -0.41185481f, -0.18754176f, -0.16715677f, -0.09507530f, 0.17750349f, -0.15319059f, 0.08847885f, 
    0.03511892f, -0.01428986f, -0.03237017f, 0.00996081f, -0.03041251f, -0.04579382f, 0.07021920f, -0.12757492f, 
    -0.04272012f, -0.02562132f, -0.04122156f, 0.07672896f, 0.08740054f, 0.06273225f, 0.11059388f, -0.09521194f, 
    -0.09356152f, 0.10276585f, -0.08314302f, -0.21011413f, -0.20071345f, 0.14516185f, -0.17281904f, -0.05276695f, 
    -0.13429331f, 0.06769959f, -0.09680927f, 0.02514719f, 0.14047003f, 0.15522573f, -0.06441077f, 0.07071313f, 
    -0.07979293f, 0.14337117f, 0.00576006f, 0.03095738f, -0.21421312f, 0.07839125f, 0.05544685f, 0.20398269f, 
    -0.03783258f, -0.13588284f, 0.04119466f, 0.12154430f, 0.12503909f, -0.00992117f, 0.04115471f, 0.06890879f, 
    -0.07750015f, -0.06193440f, 0.08164545f, -0.02229980f, -0.02230609f, -0.12478062f, 0.07628928f, -0.02750460f, 
    0.04186546f, -0.01839890f, 0.06694767f, -0.16244962f, 0.13357940f, 0.00610903f, 0.02541537f, -0.03825500f, 
    0.07954700f, -0.00762456f, 0.03196854f, 0.04042498f, 0.06352092f, -0.10025742f, 0.00435694f, 0.06572245f, 
    -0.13752208f, -0.02938442f, 0.26454929f, 0.03245764f, 0.02797669f, 0.18957964f, -0.04276395f, -0.27326415f, 
    0.04210889f, -0.15845396f, 0.18740694f, -0.02790605f, -0.01186158f, -0.00062927f, 0.07807343f, 0.07394489f, 
    0.06252015f, 0.03084583f, 0.06750859f, 0.06006626f, -0.06420042f, -0.09748751f, -0.03494854f, 0.09928525f, 
    -0.10813291f, -0.01526798f, 0.12433691f, -0.10142356f, 0.02854071f, 0.06448934f, 0.11024277f, -0.01972186f, 
    0.07838574f, 0.18493788f, -0.11722422f, -0.02993678f, 0.22652453f, 0.23630673f, -0.05248783f, 0.00771436f, 
    0.08448884f, -0.02082495f, -0.07880897f, 0.16195212f, 0.21579008f, -0.11671184f, -0.18559716f, -0.01529262f, 
    0.14657745f, -0.00794476f, -0.03276066f, -0.09532308f, 0.02790652f, 0.04357229f, 0.30058645f, -0.09159686f, 
    -0.10692741f, 0.26699929f, -0.19671804f, 0.25177030f, -0.10460519f, 0.12529637f, -0.03928154f, 0.33847080f, 
    0.22488787f, 0.53790539f, 0.04800243f, 0.11395632f, 0.19052371f, 0.12035641f, -0.15889955f, 0.39785507f, 
    -0.20700117f, -0.00823693f, -0.24966961f, -0.08733498f, -0.13199951f, 0.04365747f, -0.21316180f, 0.17019599f, 
    0.20989372f, -0.24330414f, -0.01595337f, -0.03222136f, -0.41887999f, -0.51234499f, -0.23362311f, -0.21007043f, 
    -0.14078936f, -0.26146793f, -0.08968870f, 0.05810291f, 0.10692917f, 0.06098739f, -0.21687805f, -0.26157028f, 
    -0.08696742f, 0.14233446f, 0.21938555f, 0.07055650f, -0.13842478f, -0.21745179f, 0.11032269f, -0.39376326f, 
    -0.01778085f, -0.07928308f, 0.28656108f, -0.24127608f, 0.11905531f, 0.29215773f, 0.17322575f, -0.16394110f, 
    0.04925823f, 0.14269053f, 0.05483087f, 0.07669359f, 0.23030617f, -0.22578381f, 0.06855472f, -0.08796546f, 
    0.19698170f, 0.29992060f, 0.28422241f, 0.01649861f, 0.36418889f, 0.33438296f, 0.18154887f, 0.18896486f, 
    0.02741067f, -0.09934330f, 0.18103951f, 0.16637362f, 0.15873533f, 0.09655903f, 0.21655652f, 0.23998862f, 
    0.28591501f, 0.01005932f, 0.19242943f, 0.08837659f, 0.08701029f, 0.39840644f, 0.12935752f, -0.25092103f, 
    0.20739121f, -0.13922129f, 0.11684221f, 0.08362411f, -0.09592455f, -0.11230656f, 0.12404017f, 0.02957323f, 
    -0.15339542f, -0.05933617f, -0.03967752f, -0.01535363f, -0.00161961f, 0.24788182f, -0.08398509f, -0.23698158f, 
    0.19970943f, 0.42263003f, 0.31632339f, -0.08889883f, -0.07080737f, 0.01137996f, 0.29222045f, -0.03417332f, 
    -0.09934897f, -0.15377242f, 0.00737636f, 0.14595142f, -0.06806655f, 0.06149716f, 0.30162112f, -0.25942126f, 
    0.21596895f, -0.26676192f, -0.03287399f, -0.16655635f, 0.19480273f, 0.06616958f, -0.05708862f, -0.11103380f, 
    -0.29514810f, -0.04541346f, -0.04552802f, -0.17797249f, -0.01410980f, 0.26047914f, -0.12591441f, 0.18468822f, 
    0.10827777f, -0.05617632f, -0.03418411f, -0.48730153f, -0.18100832f, 0.03852241f, 0.16080697f, 0.42918266f, 
    -0.09849256f, -0.15410433f, -0.11935829f, 0.41195892f, 0.17352202f, 0.20484868f, -0.00509660f, 0.09486051f, 
    0.18607253f, -0.10388708f, -0.08268099f, 0.17337843f, -0.07675992f, -0.05595289f, 0.14421197f, 0.18910570f, 
    0.17154520f, 0.34525647f, 0.08655092f, 0.06763800f, -0.20233448f, 0.03064668f, 0.08022748f, -0.00798828f, 
    0.16167193f, -0.00422943f, 0.04645802f, 0.04442924f, 0.11749022f, -0.00604048f, -0.21890521f, 0.14108566f, 
    0.02667819f, 0.38322459f, 0.13892238f, 0.04048044f, 0.14312659f, 0.10764699f, -0.19482729f, 0.07207134f, 
    -0.03311553f, -0.05441435f, 0.10176807f, -0.01269280f, 0.20459112f, 0.03498774f, -0.11529290f, 0.09038571f, 
    0.12478934f, -0.06239343f, -0.17948485f, -0.24233267f, -0.12525881f, -0.06045509f, -0.13046605f, -0.24263715f, 
    -0.27838817f, -0.17798322f, -0.03951447f, -0.10840493f, -0.14340037f, -0.32639285f, -0.12044036f, -0.23540451f, 
    0.07364557f, -0.29069872f, -0.28089991f, -0.28170679f, 0.06001116f, 0.00697986f, -0.23662248f, 0.10046592f, 
    -0.13804617f, -0.08124613f, -0.13143918f, 0.29963337f, 0.07709118f, 0.06778470f, -0.14985367f, -0.31388837f, 
    -0.25441419f, -0.12167052f, 0.13499390f, -0.11852145f, -0.06236957f, 0.07941102f, -0.05445971f, 0.21240633f, 
    -0.20036662f, -0.03147681f, 0.13661673f, -0.17254189f, 0.25805517f, -0.06609616f, -0.01875203f, 0.24612968f, 
    -0.05245202f, 0.25471500f, -0.03354367f, -0.04316566f, 0.04790943f, 0.23681784f, -0.10797279f, -0.01676031f, 
    -0.08361699f, -0.17818461f, 0.24461700f, -0.07386013f, -0.03722635f, 0.10569164f, 0.06700988f, -0.18471259f, 
    0.12689041f, -0.32375275f, -0.24425425f, 0.44974378f, 0.50069381f, 0.25902012f, 0.05936038f, 0.29352243f, 
    0.47674723f, 0.57575667f, 0.10356316f, 0.44644377f, 0.05827799f, -0.14902483f, -0.03335364f, 0.10084591f, 
    -0.21302410f, -0.29308931f, -0.20964083f, 0.31877451f, 0.19474518f, -0.05535476f, 0.00623626f, -0.11256995f, 
    -0.33825107f, -0.24793676f, -0.10667734f, 0.06885584f, -0.08792230f, 0.01233102f, -0.12706655f, 0.07984068f, 
    -0.21234925f, -0.17595784f, 0.03519570f, -0.10759104f, 0.01176426f, 0.34169601f, 0.09648346f, -0.17206745f, 
    0.02407993f, 0.04544902f, 0.13123947f, 0.03727767f, -0.20995636f, 0.07760607f, 0.22552909f, -0.30709106f, 
    0.13206365f, -0.16174527f, -0.11676182f, -0.04137037f, 0.35046324f, 0.09201803f, 0.07585247f, 0.14957204f, 
    0.11585923f, -0.02184331f, -0.21905020f, -0.14530874f, -0.17254215f, -0.10498943f, -0.12525087f, -0.12853051f, 
    -0.31704402f, -0.21601923f, -0.03027579f, -0.19244002f, 0.05446545f, -0.14646687f, 0.01914242f, -0.10747274f, 
    0.00252439f, 0.04462721f, 0.00770919f, -0.01383315f, -0.05173595f, -0.19147762f, 0.07615594f, -0.10160394f, 
    -0.26589989f, -0.06924217f, -0.01116261f, 0.19193172f, 0.27752340f, -0.14828842f, 0.05586592f, -0.08063026f, 
    -0.22116326f, -0.23313516f, -0.12558518f, -0.02143659f, 0.11785446f, -0.04582948f, -0.11018884f, 0.15802797f, 
    0.09122399f, 0.21912399f, -0.22208089f, 0.03134520f, 0.15074164f, 0.08822590f, 0.45356546f, 0.05405858f, 
    0.09180548f, 0.11505295f, -0.11144086f, -0.14461997f, 0.31002721f, 0.17265433f, -0.00084093f, 0.01483796f, 
    -0.14753291f, -0.26095432f, 0.01511839f, -0.36176993f, -0.21143910f, -0.00006832f, -0.02556970f, -0.04317244f, 
    0.08073637f, 0.22044642f, -0.12208161f, 0.02279469f, -0.10512582f, -0.13485288f, 0.02911518f, 0.22580950f, 
    -0.02531410f, -0.08207990f, -0.03802001f, 0.09539849f, 0.23139028f, 0.17169919f, 0.20232390f, 0.17179861f, 
    0.08843616f, -0.03338633f, 0.24184086f, 0.09900158f, 0.10485902f, 0.27670103f, 0.07753544f, -0.03934261f, 
    -0.04274350f, 0.08582703f, -0.08235185f, 0.15477841f, 0.13991411f, 0.25605841f, 0.45663264f, -0.03311878f, 
    0.34042403f, 0.28587268f, 0.22605242f, 0.22462592f, -0.13311824f, -0.13991221f, -0.17609068f, 0.06483955f, 
    0.05476200f, -0.19749904f, 0.09206299f, -0.12541925f, -0.18669725f, -0.13061894f, -0.08004565f, -0.15640374f, 
    -0.08884637f, -0.20500881f, -0.08056894f, -0.14462498f, -0.15772321f, -0.17136931f, -0.01811125f, -0.05697792f, 
    -0.17377478f, -0.18793606f, -0.02089797f, -0.25171767f, -0.09545873f, 0.13316288f, -0.01793874f, -0.07715771f, 
    -0.16103638f, -0.14656042f, -0.01010022f, -0.07548833f, 0.00111730f, -0.20431364f, -0.32855485f, -0.28419852f, 
    0.06775078f, -0.19694995f, -0.01710622f, -0.04360254f, 0.01759689f, -0.13169854f, -0.00506285f, -0.01139765f, 
    -0.02288118f, -0.13251952f, -0.02171731f, 0.04886915f, -0.09746895f, 0.11553108f, -0.08773707f, 0.08836510f, 
    -0.10776271f, 0.01331784f, 0.00635894f, -0.03800029f, 0.00665246f, -0.16836854f, -0.08069672f, -0.06453893f, 
    0.22726671f, -0.00709999f, -0.11793435f, -0.05910255f, 0.12735867f, -0.18579818f, 0.06682420f, -0.14812062f, 
    -0.06816754f, -0.09874714f, 0.12029469f, 0.10595070f, -0.03824543f, 0.11301168f, 0.05657502f, 0.21071302f, 
    0.00911147f, 0.14644531f, 0.14487719f, 0.24533050f, 0.01306659f, -0.14262656f, 0.02950621f, -0.00135563f, 
    0.04120685f, -0.07307993f, 0.27505339f, 0.24812002f, -0.27151771f, 0.05124226f, 0.13022464f, -0.12923879f, 
    -0.03027836f, 0.18653690f, -0.05017328f, -0.09161468f, -0.03994335f, -0.16759603f, -0.04277209f, 0.01836581f, 
    0.02484868f, -0.00429711f, 0.03712031f, -0.19665051f, -0.03361962f, -0.02640589f, -0.25733421f, 0.02997975f, 
    0.28164842f, 0.17414323f, -0.21609616f, 0.09198042f, 0.15072100f, -0.07086693f, 0.06802717f, 0.20974671f, 
    -0.13934331f, -0.15522739f, -0.00830468f, 0.09531171f, -0.08473072f, 0.08106774f, 0.12623258f, -0.06272834f, 
    0.06515641f, -0.10125126f, -0.06567469f, 0.22522909f, 0.17406600f, 0.15680281f, -0.07214169f, 0.20895478f, 
    -0.00874495f, -0.13029076f, 0.01306806f, 0.07330001f, -0.05205343f, -0.15679881f, -0.21438048f, 0.00842283f, 
    -0.07192484f, 0.08208958f, -0.04446220f, 0.07473006f, -0.08000273f, -0.10640446f, -0.02860184f, 0.10167131f, 
    0.21686701f, -0.09621497f, -0.03615535f, -0.08387364f, 0.20382811f, 0.05813572f, 0.04694555f, -0.00662277f, 
    -0.00594948f, 0.08181013f, 0.08549810f, 0.20383494f, 0.09106553f, 0.02888841f, 0.02517733f, 0.05324027f, 
    0.18385099f, 0.03575721f, 0.03555327f, -0.17090490f, 0.11252810f, 0.04380829f, -0.06390516f, -0.06543759f, 
    -0.10558428f, -0.06932011f, 0.12436920f, 0.16822553f, -0.07861857f, 0.20964409f, -0.12725967f, -0.17860265f, 
    0.10835878f, 0.07573273f, -0.03105444f, -0.07055333f, 0.08996100f, 0.00379853f, 0.06113860f, 0.30131251f, 
    -0.17393374f, 0.19149987f, 0.17143514f, -0.12945977f, -0.01770271f, -0.16651706f, 0.19822083f, 0.11363215f, 
    0.16197253f, -0.12410992f, -0.03733149f, 0.01679000f, -0.01494465f, -0.09318067f, 0.15934440f, 0.14945330f, 
    0.03988160f, 0.05970727f, -0.11340392f, -0.25108383f, -0.12516142f, 0.21217337f, -0.07364990f, 0.13532738f, 
    0.05244897f, 0.14144913f, -0.00603102f, 0.02797423f, 0.11145709f, 0.11177448f, 0.11002702f, 0.11707403f, 
    0.12286854f, 0.17913131f, 0.14568017f, 0.07071927f, -0.16813395f, -0.05245495f, 0.05930120f, -0.02993080f, 
    0.02473189f, 0.24846273f, 0.09668090f, 0.01927283f, -0.16609691f, 0.04716600f, -0.17754654f, -0.00906285f, 
    0.01347118f, -0.04214757f, -0.03685430f, -0.04158458f, 0.12807058f, -0.17432700f, -0.14789842f, -0.08045131f, 
    0.14648919f, 0.03032887f, -0.10259252f, 0.03772125f, 0.00445417f, -0.01206775f, 0.10060841f, -0.01376347f, 
    -0.03053158f, -0.05525028f, -0.05077956f, 0.04012747f, -0.08195704f, -0.01946625f, -0.17563128f, 0.05494236f, 
    0.19755960f, 0.07670642f, 0.15460256f, -0.07870847f, 0.01527937f, 0.10175769f, -0.01833998f, 0.14363285f, 
    0.03874076f, 0.27948472f, -0.07909588f, -0.03982822f, -0.08297523f, -0.04336566f, -0.12728528f, 0.10925390f, 
    0.04739983f, 0.13275413f, -0.08519657f, -0.02595677f, 0.09942505f, 0.03515751f, -0.09971182f, 0.02852696f, 
    -0.03710410f, 0.01852833f, -0.03212018f, -0.01124782f, 0.12260735f, -0.11653936f, 0.08641796f, 0.01598725f, 
    0.17921339f, 0.09688843f, 0.04743024f, -0.08094926f, 0.04837002f, -0.06569584f, 0.03607923f, 0.04084336f, 
    -0.06363835f, -0.12257424f, -0.00160857f, -0.08088138f, 0.19721210f, -0.04938657f, 0.17127677f, 0.04842944f, 
    0.05703913f, -0.06862792f, -0.12419651f, -0.08814375f, 0.06567831f, 0.14906714f, 0.01884271f, -0.07662965f, 
    -0.12046350f, 0.18583331f, 0.03253916f, -0.09896985f, 0.17254491f, -0.04991265f, 0.23910634f, 0.19738067f, 
    0.07636356f, -0.03056255f, -0.09202780f, 0.02414846f, -0.10624943f, -0.17545190f, -0.03018172f, 0.03222117f, 
    0.12586723f, -0.11242267f, 0.10839807f, 0.04245480f, 0.09977056f, 0.02491245f, 0.08924824f, 0.12391166f, 
    0.03582970f, 0.02462440f, 0.26061748f, 0.16303658f, 0.09196605f, -0.04957620f, 0.07192426f, 0.07224845f, 
    0.08688064f, 0.00447396f, -0.06509640f, 0.32585584f, -0.23931103f, 0.14029667f, 0.23458541f, 0.23962141f, 
    0.45456533f, 0.20185572f, 0.13526451f, -0.13767303f, -0.05469715f, -0.08827259f, 0.19124204f, -0.13921188f, 
    -0.09096241f, -0.13323612f, 0.05381199f, 0.07793529f, -0.00948322f, -0.04567931f, 0.23964813f, 0.02001213f, 
    0.14581135f, -0.18550354f, 0.16763188f, -0.06651864f, -0.15756434f, -0.11836361f, -0.00419516f, -0.48899383f, 
    -0.56862199f, -0.20081048f, -0.06109408f, -0.14094401f, -0.21738214f, 0.02402824f, -0.16889599f, 0.05386810f, 
    0.01036331f, -0.09833674f, 0.01464402f, -0.12732564f, -0.13751167f, -0.14040751f, -0.05871856f, -0.12152906f, 
    -0.07826205f, -0.28019154f, -0.08255808f, -0.17364931f, -0.00904571f, -0.19502156f, -0.14363838f, 0.06961324f, 
    -0.05609584f, -0.19119791f, -0.17214853f, 0.07030167f, -0.13950323f, -0.08228819f, 0.02005441f, -0.14407096f, 
    -0.15893390f, -0.19110751f, -0.11757014f, 0.04726754f, 0.02936440f, 0.22692405f, 0.16564590f, 0.15757179f, 
    0.25509718f, 0.09520560f, -0.04529935f, 0.18043532f, 0.18867914f, 0.08027751f, -0.11257985f, 0.17664164f, 
    0.01388392f, -0.00795477f, 0.25251820f, 0.06446569f, -0.01850871f, 0.06800724f, 0.13912773f, 0.04683910f, 
    0.08007577f, -0.05140582f, 0.30744293f, 0.05443045f, -0.08394839f, 0.16148827f, -0.08066518f, 0.09053436f, 
    0.01402913f, -0.01060839f, 0.09143369f, -0.03542142f, -0.04296102f, 0.21432353f, 0.35590184f, 0.07998685f, 
    0.21577177f, -0.07634029f, -0.01218079f, 0.13276204f, 0.19990371f, -0.11812712f, 0.02823258f, -0.03315785f, 
    -0.03285256f, -0.14857794f, -0.15604451f, 0.19500218f, 0.10960605f, 0.48363676f, -0.09441967f, 0.21558457f, 
    -0.13481146f, -0.09730415f, 0.15771260f, 0.15765591f, 0.12903550f, 0.08828111f, 0.04698447f, -0.03295571f, 
    0.02112917f, 0.09722324f, -0.07802495f, -0.16158508f, 0.03296064f, -0.02191234f, 0.06988180f, -0.06649411f, 
    -0.03820395f, -0.00873473f, 0.15193114f, -0.10571504f, 0.26546804f, -0.07467591f, 0.09081199f, -0.01632779f, 
    -0.03335334f, -0.05857138f, 0.06755443f, 0.12332552f, 0.00305535f, -0.08435807f, -0.06721566f, 0.09082272f, 
    -0.01120976f, -0.09406196f, -0.05829426f, -0.11208213f, -0.05408030f, 0.12311537f, 0.01705087f, 0.02943988f, 
    -0.01043571f, -0.08695825f, -0.03208810f, -0.02719960f, 0.06257957f, 0.16539234f, -0.05858216f, -0.07670378f, 
    -0.05278506f, 0.11678072f, -0.03920267f, 0.15398484f, 0.18440909f, 0.10000909f, 0.08954076f, -0.17155764f, 
    -0.06000868f, -0.25622798f, 0.00717833f, 0.02322946f, -0.08043922f, -0.01657167f, -0.03275619f, -0.19924467f, 
    0.17433961f, -0.14834724f, 0.13157587f, 0.07027054f, 0.04745970f, 0.01881527f, -0.00359390f, 0.10006902f, 
    0.03048732f, -0.09578226f, -0.15362328f, -0.12575543f, 0.07568284f, -0.04369255f, 0.08000732f, 0.09945377f, 
    0.05255693f, 0.04630447f, -0.14971907f, -0.02804477f, -0.02281783f, -0.11812504f, 0.08203918f, 0.12468828f, 
    0.07324867f, -0.08700919f, -0.04443445f, 0.07562437f, 0.04702054f, 0.11499393f, 0.02065530f, -0.16364888f, 
    0.10771219f, 0.08745596f, -0.07341067f, 0.13151173f, 0.08881787f, -0.14618469f, 0.20058486f, -0.00101665f, 
    0.00894732f, 0.02157058f, -0.02678475f, 0.03935283f, 0.15920108f, 0.09364391f, -0.20335461f, -0.13545255f, 
    -0.11963838f, 0.12336561f, 0.02892681f, 0.02144667f, 0.03271470f, -0.06023716f, 0.00932139f, 0.05706130f, 
    0.17433267f, 0.12471799f, 0.02231853f, -0.23354056f, 0.02890148f, 0.07754723f, 0.24029204f, 0.46518705f, 
    0.29843812f, -0.18106725f, 0.10284234f, -0.21339349f, -0.01166846f, -0.11539238f, -0.05586800f, -0.29457117f, 
    -0.15714990f, -0.17692310f, -0.21056163f, -0.34270280f, 0.06693131f, -0.06520851f, -0.26632542f, -0.17001842f, 
    -0.29168946f, -0.31311608f, -0.14146627f, -0.18428308f, -0.18126381f, -0.22480915f, -0.27192774f, -0.16026287f, 
    -0.33306655f, -0.22639756f, -0.26086387f, -0.25852163f, -0.34412129f, -0.43189652f, -0.34802542f, -0.30260057f, 
    -0.19001932f, 0.11164128f, -0.05487200f, -0.12078571f, 0.14162967f, 0.06992548f, 0.10700527f, 0.09058466f, 
    0.17876710f, 0.27874053f, 0.25529609f, 0.12195310f, 0.20150972f, 0.22614428f, 0.16205571f, 0.06549503f, 
    0.07896562f, 0.16624729f, 0.36604394f, 0.06557055f, 0.11328478f, 0.42617757f, 0.24882391f, 0.13252194f, 
    -0.08937574f, 0.19336255f, 0.00039952f, 0.19816180f, -0.08146782f, -0.01217288f, 0.25356996f, 0.14638267f, 
    -0.20424307f, 0.22032031f, 0.07701854f, 0.10439632f, 0.25133371f, 0.11781281f, 0.00004231f, -0.05969026f, 
    -0.01819898f, -0.41885742f, -0.17300110f, -0.05075897f, -0.07494773f, -0.13884146f, -0.02569191f, -0.23736870f, 
    0.06287193f, 0.11250969f, -0.04561168f, 0.10771723f, -0.09370064f, -0.26361090f, -0.04854921f, 0.03516081f, 
    0.10511339f, -0.03802839f, 0.03664998f, -0.12422293f, -0.09740992f, 0.06738834f, -0.16075220f, 0.05389003f, 
    0.11578122f, -0.01624291f, -0.01250270f, 0.20673153f, 0.03014579f, 0.02441805f, 0.02750135f, -0.09578795f, 
    -0.23237121f, -0.06797868f, -0.10678748f, -0.07599598f, -0.10040672f, -0.39638808f, -0.38945335f, 0.09826347f, 
    0.02865086f, -0.24522974f, 0.00562644f, -0.10882351f, 0.02928895f, 0.17571206f, 0.01573666f, 0.12995641f, 
    -0.24916565f, -0.15560846f, 0.00401835f, 0.05433828f, -0.03506022f, 0.11307932f, -0.09875986f, -0.42147153f, 
    -0.05362832f, 0.07264220f, 0.16814429f, 0.03391646f, -0.11247188f, -0.09427432f, 0.03199030f, -0.03749902f, 
    0.26242521f, 0.06812173f, -0.11139315f, -0.06256165f, -0.06923218f, -0.05008038f, 0.17443865f, 0.22606772f, 
    0.12012399f, 0.07612765f, 0.28562354f, 0.16204007f, 0.42057579f, 0.13226627f, 0.17404416f, 0.15010507f, 
    0.10931705f, 0.19045800f, 0.26986397f, 0.00398087f, 0.14726013f, -0.13429683f, 0.26799322f, 0.05734003f, 
    -0.13214791f, -0.07262489f, -0.06192443f, -0.03030382f, 0.27616375f, 0.07992348f, 0.07729050f, 0.04929750f, 
    -0.02089321f, 0.06662079f, -0.05747115f, -0.04442549f, 0.00245252f, -0.02679928f, -0.13350406f, -0.04546935f, 
    -0.09986484f, 0.04828570f, -0.26794868f, -0.16448444f, -0.08872573f, -0.08410175f, 0.03374548f, -0.14014373f, 
    -0.01287913f, 0.04926457f, 0.02570545f, 0.00006569f, 0.04410303f, -0.13175897f, -0.00185639f, -0.11337029f, 
    -0.13892466f, -0.01421000f, -0.18648894f, -0.17125162f, -0.08912673f, 0.13943076f, 0.01437187f, -0.03696668f, 
    -0.12297817f, -0.15702141f, 0.03734470f, 0.19279428f, 0.15278488f, -0.05521809f, 0.07859385f, -0.10163377f, 
    0.28503068f, -0.09842543f, 0.00336520f, 0.07320011f, 0.00716183f, 0.01180851f, -0.10993588f, 0.20718642f, 
    -0.09583837f, -0.06663654f, 0.13537166f, 0.00218506f, 0.09747223f, -0.12523458f, -0.07778834f, -0.04218399f, 
    -0.07058711f, -0.07642047f, 0.11431241f, -0.17274631f, -0.19536968f, 0.02082316f, 0.16154173f, 0.06206762f, 
    0.21639256f, -0.06350169f, 0.05215494f, -0.07085216f, 0.13034742f, 0.10565371f, 0.18148851f, 0.10238649f, 
    -0.21098527f, -0.31157834f, 0.25073078f, 0.07426052f, -0.18821799f, 0.14236363f, -0.07007086f, 0.01034160f, 
    -0.13732121f, 0.17906431f, 0.18777084f, 0.15804931f, 0.08633266f, -0.28545796f, 0.09076028f, 0.05661998f, 
    0.00182698f, 0.09139291f, -0.06843225f, -0.02783816f, -0.12355582f, -0.22672590f, -0.08038716f, -0.17837615f, 
    0.13433278f, -0.17518693f, 0.04687994f, -0.17426135f, -0.06022854f, -0.12079469f, -0.13520390f, -0.08330589f, 
    -0.31264684f, -0.46624513f, -0.13833269f, -0.26718117f, -0.42726661f, -0.26749337f, -0.15455613f, -0.14905715f, 
    -0.27666089f, -0.16033187f, -0.16377343f, -0.27716864f, -0.28719689f, -0.21500862f, 0.03370707f, -0.06757627f, 
    -0.02301989f, -0.03982737f, -0.06564152f, 0.08426393f, -0.08168261f, 0.09080467f, 0.15658880f, 0.02502099f, 
    -0.06121459f, 0.16862930f, -0.03147487f, 0.04732050f, -0.06087708f, 0.24157277f, -0.06666271f, 0.00291673f, 
    0.12880179f, -0.13445845f, -0.00923672f, -0.10859298f, 0.00621946f, -0.12997530f, -0.17262439f, 0.09315789f, 
    0.06435121f, 0.00078608f, -0.14303549f, 0.03503758f, -0.05534189f, -0.00203798f, -0.23713542f, -0.05685425f, 
    0.16171726f, -0.17052956f, -0.33632362f, 0.02541037f, 0.26234519f, 0.08897160f, 0.17442111f, 0.01001248f, 
    0.28126460f, -0.12742786f, -0.03183795f, -0.17854610f, 0.24224551f, 0.12184591f, 0.04696652f, 0.12498110f, 
    0.12223207f, 0.27120599f, 0.21552888f, 0.09272539f, -0.00076754f, -0.11046061f, -0.06857046f, 0.03090760f, 
    0.00357592f, 0.07719255f, -0.16394563f, -0.05148892f, 0.01382038f, 0.07588293f, 0.16557395f, 0.00051274f, 
    0.08077803f, 0.34083203f, -0.09136477f, 0.07410312f, 0.17326015f, 0.27615660f, 0.14121539f, 0.09926087f, 
    0.03817130f, -0.07252454f, 0.08868413f, 0.28700530f, 0.02426476f, -0.29782317f, 0.02301515f, -0.00124879f, 
    -0.03935930f, 0.06508160f, -0.16902446f, 0.04948733f, 0.18882619f, 0.20203602f, 0.13643959f, -0.10177923f, 
    -0.11049878f, -0.01004531f, -0.17918843f, -0.28683330f, 0.09265487f, -0.11351381f, -0.32028546f, -0.29248704f, 
    0.06269748f, -0.08459324f, -0.03333924f, 0.09158498f, -0.17148672f, -0.14166771f, -0.24419081f, -0.33435912f, 
    -0.21821304f, -0.17253816f, -0.03494677f, 0.12124849f, 0.06399647f, 0.03324491f, -0.10738737f, -0.16396624f, 
    0.01750226f, -0.03274288f, 0.16369228f, -0.17461964f, 0.05490631f, -0.10686304f, -0.05478529f, 0.22961450f, 
    -0.03862121f, -0.28264454f, 0.10056849f, -0.09844122f, 0.17192676f, 0.00873214f, 0.28652740f, 0.13848978f, 
    0.24275795f, 0.21243411f, -0.04206611f, 0.14162924f, 0.13873471f, 0.38180043f, 0.12846598f, 0.29168142f, 
    -0.23348861f, -0.03373546f, 0.08697136f, 0.14388950f, 0.07594381f, -0.22685799f, -0.09541437f, 0.04154933f, 
    -0.31868871f, -0.08688566f, 0.25997671f, -0.05287772f, 0.14947254f, -0.21418309f, -0.07209126f, 0.23832672f, 
    -0.32957238f, -0.25186697f, 0.06597871f, 0.05052294f, -0.17479185f, 0.02018215f, -0.15897735f, 0.23346493f, 
    -0.16091652f, -0.28219294f, -0.00419410f, 0.35790480f, -0.06073842f, 0.14492688f, 0.06033304f, -0.01140425f, 
    -0.19669917f, 0.13352847f, -0.02146642f, -0.07915285f, 0.17880576f, 0.12751955f, -0.06105265f, 0.09134906f, 
    -0.10885174f, 0.31184034f, 0.15115823f, 0.23540777f, 0.20123797f, 0.27245981f, 0.08150996f, 0.25625582f, 
    0.25264260f, 0.19645954f, -0.27444528f, 0.31738356f, 0.03890248f, 0.01350075f, 0.10830804f, 0.15717270f, 
    0.24879803f, 0.22764132f, 0.01758078f, 0.15476465f, -0.08079089f, 0.16478177f, -0.04864105f, -0.14167565f, 
    0.06864624f, -0.09336569f, -0.23012718f, 0.17903943f, -0.22035882f, -0.38182551f, 0.04111818f, -0.00712838f, 
    -0.11914117f, -0.15848142f, -0.11418068f, -0.23395576f, 0.08797014f, -0.08935904f, 0.13375425f, 0.09565230f, 
    0.14274947f, 0.04672034f, -0.15481038f, -0.07882423f, 0.12553081f, -0.01886341f, 0.07657593f, -0.33075599f, 
    -0.01049626f, -0.14116591f, -0.12027484f, 0.14763630f, 0.08266932f, 0.02940569f, -0.02759492f, 0.12105630f, 
    0.07834307f, 0.02773196f, 0.02849887f, -0.16932716f, -0.00032205f, -0.06774085f, -0.05381777f, 0.00080271f, 
    0.00970991f, -0.13208656f, 0.02844782f, 0.03207875f, 0.18603909f, 0.05349275f, -0.04274792f, -0.24328702f, 
    0.05003906f, 0.05000757f, -0.08875607f, -0.03113334f, -0.10691646f, 0.26394997f, 0.21352176f, 0.08108147f, 
    0.05842776f, 0.16383764f, -0.03314640f, 0.26604759f, 0.29555673f, 0.23672288f, 0.00088769f, -0.01783372f, 
    -0.13895525f, -0.02945013f, -0.14523773f, 0.05561718f, 0.03691836f, 0.36625855f, -0.23963780f, 0.30319817f, 
    0.00992547f, -0.11398006f, 0.10334444f, -0.02549513f, 0.26752186f, 0.22345802f, -0.14626229f, 0.08578763f, 
    0.36511912f, -0.06862785f, -0.18579826f, 0.24591753f, -0.04670037f, 0.02826088f, 0.00936143f, -0.02774769f, 
    0.15546563f, 0.10244462f, -0.28805968f, -0.13159332f, -0.09944714f, -0.03887680f, -0.10484000f, -0.01455555f, 
    -0.03722631f, -0.04268054f, 0.00787635f, -0.09967906f, -0.03087979f, 0.09891708f, 0.05596107f, 0.16661922f, 
    0.10318420f, 0.19990498f, 0.14471069f, -0.14498460f, 0.05310927f, -0.07600960f, 0.24026319f, 0.27061029f, 
    -0.08834871f, 0.09614724f, 0.06524107f, 0.01625782f, 0.11483657f, -0.04587400f, -0.13056867f, -0.14645285f, 
    -0.08932044f, 0.10262878f, -0.02137973f, 0.05873489f, 0.02522377f, -0.07502660f, 0.21057056f, 0.02956032f, 
    -0.00890854f, -0.18684788f, 0.17972230f, 0.06637344f, 0.13852199f, -0.08084763f, 0.22160635f, -0.09574449f, 
    0.08245657f, -0.10683242f, 0.11673580f, 0.11046285f, 0.04435854f, -0.07865392f, 0.05737805f, -0.07566228f, 
    -0.17305968f, -0.04070291f, -0.01906473f, -0.03685633f, -0.14145835f, -0.20203238f, -0.00738530f, -0.01432064f, 
    0.07503970f, 0.03925618f, 0.02114686f, -0.07312374f, 0.02364295f, -0.19558106f, -0.07850810f, -0.02723269f, 
    0.24181713f, 0.03326743f, 0.09708662f, 0.16061321f, 0.10432404f, 0.05904390f, 0.06119293f, 0.21739209f, 
    0.10458122f, 0.09448693f, 0.07589039f, -0.10753962f, 0.02945464f, 0.00512928f, -0.14059095f, -0.00634116f, 
    -0.15984920f, -0.21040900f, 0.05405402f, -0.12042417f, -0.09234998f, 0.01367710f, -0.13768513f, -0.06117210f, 
    -0.13389065f, 0.18678538f, -0.23601418f, -0.15550271f, -0.01205649f, -0.13080146f, -0.12422148f, -0.09956136f, 
    0.11410784f, -0.12268448f, -0.01340096f, 0.01331961f, 0.14617784f, 0.14285871f, -0.23802362f, -0.13113385f, 
    -0.24925011f, -0.06384137f, 0.19519201f, 0.19503645f, -0.14695635f, 0.07400460f, -0.01462145f, -0.06923860f, 
    0.14041990f, -0.14410628f, -0.06981651f, 0.13812722f, 0.10991977f, -0.03711779f, -0.06917120f, -0.03520894f, 
    0.04421368f, -0.12254260f, -0.13011435f, 0.09050606f, -0.24018806f, 0.07203258f, 0.05024689f, -0.23747826f, 
    0.00413090f, 0.06244441f, 0.01492481f, 0.21998827f, 0.05555812f, -0.09463279f, 0.00434029f, -0.02554505f, 
    -0.06073704f, -0.09813533f, 0.04029699f, 0.15758845f, 0.07888711f, -0.00089477f, -0.07131111f, 0.04582869f, 
    -0.04637008f, -0.08859994f, 0.05412409f, -0.23051877f, 0.15878184f, 0.19998059f, -0.01085080f, -0.06686067f, 
    -0.01622599f, 0.05851158f, 0.05152496f, 0.12794433f, 0.13335889f, 0.17819418f, -0.03974301f, 0.09686956f, 
    -0.01869146f, -0.05576045f, 0.10390030f, 0.10757598f, 0.04625577f, -0.01107278f, -0.06840497f, -0.10645992f, 
    0.17397632f, 0.06611418f, -0.21564721f, -0.20486324f, 0.12920716f, -0.06383917f, -0.12998969f, 0.09735206f, 
    0.04024994f, -0.02966046f, 0.08439155f, -0.28698954f, -0.07470520f, 0.25411138f, -0.10953874f, -0.05653372f, 
    -0.14085355f, -0.13577219f, -0.15251667f, -0.14752699f, 0.28612838f, 0.09559581f, 0.25521796f, 0.06150887f, 
    0.29641850f, 0.28315009f, 0.29751269f, 0.37359349f, 0.06095424f, 0.42685119f, -0.04992785f, 0.00715312f, 
    -0.02717773f, 0.16627228f, 0.02564631f, 0.21688455f, 0.00477123f, 0.31460632f, 0.05726530f, 0.06420714f, 
    0.15924892f, -0.09036185f, 0.08240657f, 0.06700884f, 0.12506370f, 0.27349264f, -0.11398821f, 0.08379728f, 
    -0.04212290f, -0.04973467f, -0.14092186f, 0.01758547f, -0.09039838f, -0.09426037f, 0.08701958f, -0.04937682f, 
    -0.21123482f, -0.24389578f, -0.20520915f, -0.05850637f, 0.16051411f, -0.06369276f, -0.00140832f, -0.08881403f, 
    -0.39366637f, 0.10799432f, -0.27484628f, -0.02541201f, -0.05482988f, 0.16695009f, -0.16501342f, -0.32296748f, 
    -0.12217642f, 0.01755371f, 0.31064225f, -0.21722055f, 0.09475602f, 0.19185941f, -0.02474024f, 0.28598212f, 
    0.17642297f, 0.38944788f, 0.11483431f, 0.17844803f, 0.35960180f, 0.10687684f, -0.04946008f, 0.32749331f, 
    0.25960621f, 0.36588398f, 0.00762638f, 0.10673993f, 0.11164574f, 0.48769956f, 0.26766238f, -0.12905567f, 
    0.02433556f, 0.38292712f, -0.20745804f, -0.14469985f, -0.20753624f, 0.15416682f, -0.06764601f, -0.01912488f, 
    -0.19051285f, 0.02594502f, -0.06107442f, -0.00795030f, -0.04960801f, -0.24842400f, 0.21611286f, -0.20706170f, 
    -0.59968360f, -0.33063128f, -0.40695845f, -0.18643702f, -0.27684534f, -0.05841743f, 0.18118171f, 0.15792746f, 
    0.17874838f, -0.19742718f, 0.24254109f, 0.18983651f, -0.24193496f, -0.35122804f, -0.14803061f, -0.10078846f, 
    0.05780857f, -0.07651194f, 0.17356901f, 0.16999427f, -0.05301324f, 0.13288222f, 0.25632499f, -0.13769805f, 
    -0.06909540f, -0.09214771f, -0.31903914f, -0.09867049f, -0.02898652f, -0.11063958f, 0.06959466f, -0.16449217f, 
    -0.15327451f, 0.05716309f, -0.03724196f, 0.22301987f, -0.12993519f, 0.05103040f, -0.04553712f, -0.16751219f, 
    -0.14275989f, -0.10821998f, 0.15424126f, 0.09948256f, -0.11455611f, -0.02750634f, -0.19521081f, 0.04611357f, 
    0.00238782f, -0.29062449f, -0.16702912f, 0.01562431f, -0.08492616f, -0.18195439f, -0.03712738f, -0.09122802f, 
    -0.04610573f, -0.20373746f, 0.18851391f, 0.05117435f, -0.07267408f, 0.11330207f, 0.19453054f, -0.12576585f, 
    0.08140519f, -0.20606857f, 0.01421787f, 0.07718612f, 0.02409215f, 0.11533200f, -0.01957918f, -0.08992666f, 
    -0.02088964f, 0.02236126f, 0.10397828f, -0.03189971f, 0.03832429f, 0.13655522f, 0.10885381f, 0.09398269f, 
    -0.01269780f, -0.01510391f, 0.11755099f, 0.24505323f, -0.15901920f, 0.03343396f, -0.11254383f, -0.11822886f, 
    -0.00746036f, -0.08376549f, -0.19001199f, 0.01506448f, 0.11194925f, 0.06485911f, -0.17644580f, 0.12304614f, 
    0.03064768f, 0.00899763f, -0.06757659f, -0.02053561f, 0.11486020f, -0.09766803f, 0.24402135f, -0.07495411f, 
    0.01536576f, 0.09805291f, -0.03903180f, 0.05107443f, -0.04817249f, 0.03422421f, 0.10029839f, 0.05234185f, 
    -0.02243956f, -0.00128810f, -0.08645815f, 0.11573200f, 0.13261799f, -0.24454796f, 0.02792495f, 0.13273467f, 
    0.11654449f, 0.00208856f, 0.05621390f, -0.09483712f, 0.12283825f, 0.10327773f, 0.00031651f, -0.00803826f, 
    0.11068370f, -0.17229564f, 0.05228908f, 0.19126141f, 0.05733615f, 0.18793296f, 0.10255937f, 0.07145535f, 
    -0.03934525f, 0.02207200f, 0.11944449f, 0.02695854f, -0.02391242f, -0.05259054f, -0.33125177f, -0.18697724f, 
    -0.09809456f, -0.35389285f, -0.18871321f, -0.05093007f, -0.05789871f, 0.09133476f, 0.09979723f, 0.05016342f, 
    -0.02158675f, -0.03759216f, 0.07890235f, 0.13075509f, 0.38330501f, 0.05588272f, -0.15623283f, 0.11761258f, 
    0.40090156f, 0.08990375f, 0.30782086f, 0.17783159f, 0.29701830f, 0.37644300f, 0.53758196f, 0.27480944f, 
    0.19159929f, 0.31567126f, 0.25524248f, 0.10143711f, 0.19374688f, 0.27308972f, -0.03761945f, 0.47425133f, 
    0.06566380f, 0.19219376f, -0.16542112f, -0.19389674f, -0.08984326f, -0.06505718f, 0.04731316f, -0.30084128f, 
    -0.01025469f, -0.06295598f, -0.15203835f, 0.11332690f, -0.00453922f, -0.17977720f, -0.14712770f, 0.21041167f, 
    -0.31154189f, -0.14391381f, -0.03146577f, -0.07530905f, -0.07473434f, 0.08094746f, -0.16042383f, 0.07928955f, 
    -0.24618423f, 0.02800085f, 0.01306011f, -0.14357024f, -0.23898852f, 0.14602300f, -0.00040241f, 0.00234152f, 
    -0.02537810f, -0.07208544f, 0.10787228f, -0.17754625f, 0.00589774f, 0.12592143f, 0.05153490f, -0.10992209f, 
    -0.05146704f, -0.00212255f, -0.14826090f, -0.11174717f, -0.22385199f, -0.12801550f, -0.22836345f, 0.05583635f, 
    0.02725673f, -0.05937349f, 0.04750698f, -0.15604891f, -0.40392601f, -0.31473939f, -0.06748873f, -0.23430564f, 
    -0.29496248f, -0.44840754f, -0.33653032f, -0.08324642f, -0.02601677f, -0.28213042f, -0.11118705f, -0.07759294f, 
    -0.09975792f, -0.17963740f, -0.37172608f, -0.22501493f, -0.40211634f, -0.18920633f, 0.00218461f, -0.06080553f, 
    0.00873312f, -0.03309243f, 0.01983171f, -0.05085468f, 0.22018490f, 0.32057834f, 0.26410252f, -0.03603269f, 
    0.07243604f, 0.20129482f, -0.14027448f, -0.07464632f, 0.08412868f, -0.11696173f, -0.12414820f, 0.04887758f, 
    -0.04844856f, -0.11796120f, -0.15320647f, -0.07763030f, 0.13664225f, 0.01510143f, 0.00172420f, -0.06248222f, 
    -0.01853275f, 0.02197622f, -0.03368671f, -0.09094074f, 0.09342258f, -0.19084757f, 0.05736829f, -0.22510415f, 
    0.05021245f, 0.08176814f, -0.12445831f, 0.01420580f, 0.14419315f, -0.14944360f, -0.13705688f, -0.19667408f, 
    -0.04605342f, -0.01545849f, 0.19599723f, -0.11970463f, -0.04709195f, 0.06983961f, 0.02037341f, -0.10833961f, 
    -0.15245012f, -0.01773011f, 0.15016124f, 0.04039811f, -0.03950128f, -0.13876528f, 0.20633514f, -0.09720260f, 
    0.25749769f, 0.20461672f, 0.27477001f, -0.07354476f, 0.13006913f, 0.11603696f, 0.11305121f, 0.05318996f, 
    0.14135044f, 0.04554621f, -0.03173048f, 0.07837342f, 0.06796781f, -0.06414126f, 0.00092266f, 0.22819573f, 
    0.05497566f, -0.02221937f, -0.10050494f, 0.05095507f, -0.19489117f, -0.09408040f, -0.00376217f, -0.09800829f, 
    -0.18796064f, -0.04276677f, -0.09940399f, 0.14068059f, -0.13789143f, 0.10609382f, 0.17076897f, 0.02865405f, 
    -0.01900084f, -0.20990487f, -0.02864015f, -0.17304496f, 0.09628659f, -0.25042846f, 0.06706927f, 0.05100770f, 
    -0.11169944f, 0.16843594f, 0.19781310f, 0.05116853f, -0.31778394f, -0.00189514f, -0.07956586f, -0.11518986f, 
    0.20511729f, 0.02377328f, 0.26995419f, -0.24918904f, -0.03682497f, 0.14794519f, 0.04499119f, 0.15209904f, 
    0.13589795f, 0.17484081f, 0.31603543f, -0.09354208f, -0.01470380f, 0.01214824f, 0.04755567f, 0.09589595f, 
    -0.00588141f, -0.14374875f, -0.20465257f, -0.01204370f, 0.32479040f, -0.11626169f, -0.04389829f, -0.09325261f, 
    0.27859961f, -0.15014391f, 0.03448227f, -0.03859195f, 0.15496471f, -0.32122551f, -0.15005454f, -0.01178430f, 
    -0.13800460f, -0.35633840f, 0.25016551f, 0.08801588f, -0.03879797f, -0.24862486f, -0.19150996f, -0.28221808f, 
    -0.03073867f, -0.21281969f, -0.25466967f, -0.06891429f, -0.11408993f, 0.04297200f, -0.08992913f, -0.16898236f, 
    -0.11789656f, -0.02769463f, 0.00230102f, -0.28181291f, -0.09391808f, -0.01590798f, -0.14593480f, -0.16839713f, 
    -0.04317462f, -0.07480091f, 0.00510808f, -0.28372803f, 0.03988484f, 0.04924295f, 0.17041157f, 0.19259918f, 
    0.22906682f, 0.10862340f, 0.09005303f, 0.15860574f, -0.10969271f, 0.18642410f, 0.18959118f, 0.18506335f, 
    0.02047540f, 0.10291075f, 0.09130706f, 0.26650512f, -0.08393297f, 0.29193643f, -0.12333440f, -0.33260803f, 
    -0.04699858f, -0.27623889f, 0.02735888f, -0.17384174f, -0.08964464f, 0.09052882f, 0.04718867f, 0.21827876f, 
    -0.04761793f, 0.01558803f, -0.00917398f, 0.13122503f, -0.16783163f, -0.05605931f, -0.02837211f, 0.13083911f, 
    -0.06996690f, -0.09780186f, -0.22442581f, 0.09287201f, -0.09267505f, -0.11193678f, -0.06022031f, 0.02483452f, 
    -0.12049579f, 0.05897329f, -0.15970970f, 0.09692014f, 0.16281054f, 0.03242657f, 0.05382446f, -0.01030242f, 
    -0.03172394f, 0.04703257f, 0.20138275f, -0.16245753f, -0.01440097f, 0.16771941f, 0.13631007f, 0.29339338f, 
    -0.06877291f, 0.04283188f, 0.10395497f, -0.02757204f, 0.08226484f, -0.07068304f, 0.16114126f, 0.09690553f, 
    0.04672215f, 0.22878329f, 0.04731557f, 0.10040993f, -0.14215138f, -0.03086561f, 0.01279300f, -0.16098302f, 
    0.05673602f, 0.03581193f, -0.12462601f, -0.29504128f, -0.15625860f, -0.12932346f, -0.13378624f, -0.04725982f, 
    0.03144560f, -0.10805548f, -0.16467173f, -0.33371033f, 0.02507036f, -0.04207749f, 0.02266463f, -0.03216797f, 
    -0.02794849f, 0.11281604f, -0.00530132f, 0.01191083f, -0.24700657f, 0.20881506f, 0.41125323f, 0.21630274f, 
    0.02419714f, -0.00289470f, 0.01842391f, 0.26429764f, 0.03973707f, 0.16562902f, 0.04966504f, 0.12791366f, 
    -0.07151423f, 0.15164820f, -0.21100921f, 0.07337365f, -0.12456229f, 0.14909721f, 0.22238361f, 0.32813245f, 
    0.21485581f, 0.17803002f, 0.19730758f, -0.01188821f, 0.10903594f, 0.08007014f, -0.04088917f, -0.16279985f, 
    -0.20032381f, -0.04053919f, -0.18870869f, -0.10415002f, -0.03375479f, -0.06143429f, -0.28759043f, 0.06431701f, 
    -0.26758037f, -0.12369711f, -0.13550954f, -0.09982314f, -0.09306946f, -0.31789580f, -0.34309994f, -0.28578206f, 
    -0.04329994f, -0.14461958f, 0.00088120f, -0.04459877f, -0.09497805f, 0.04036998f, 0.05351946f, 0.22423426f, 
    -0.20728462f, 0.03788253f, -0.01485401f, 0.00006493f, -0.04749148f, 0.21045241f, -0.19618654f, 0.12785173f, 
    0.11268855f, 0.32270495f, -0.01387428f, 0.09928623f, 0.18460856f, 0.12007875f, 0.41676071f, 0.12808319f, 
    0.08186704f, -0.18888403f, 0.06136494f, -0.03695639f, 0.03012737f, 0.03042121f, -0.01505588f, 0.05595682f, 
    0.01870513f, 0.10239327f, 0.10156565f, 0.09892401f, 0.23485327f, 0.12141498f, 0.20548633f, -0.01531018f, 
    -0.20174571f, -0.30962666f, -0.16322698f, -0.18163687f, 0.10927010f, -0.11466933f, -0.16703952f, -0.31606060f, 
    -0.13748998f, -0.22706651f, -0.01436084f, -0.17560474f, -0.00321374f, -0.08646138f, -0.05673040f, -0.24730750f, 
    -0.25545127f, -0.26195766f, -0.07316244f, 0.08889822f, 0.13659776f, 0.12973588f, -0.23256800f, -0.04302702f, 
    -0.09136096f, 0.19130898f, -0.00481702f, -0.22452291f, 0.18916644f, -0.03372216f, 0.03179271f, 0.15183124f, 
    0.04702696f, 0.05036080f, -0.20778406f, 0.00090905f, 0.17664488f, 0.24598316f, -0.21982778f, -0.19223401f, 
    -0.00136617f, -0.25663147f, -0.08449948f, -0.04608429f, 0.11276003f, 0.36628897f, -0.07143560f, 0.00027932f, 
    -0.24616911f, -0.09916336f, -0.09447960f, 0.21054749f, -0.05544949f, 0.04147242f, 0.04271165f, -0.11057111f, 
    -0.17934763f, -0.12821827f, 0.00601327f, -0.11015222f, -0.17453038f, 0.10310554f, -0.21608089f, -0.03015234f, 
    0.01696964f, -0.00665033f, -0.15444622f, -0.07325097f, 0.21967525f, 0.14127229f, 0.01971149f, 0.01732781f, 
    -0.02859247f, 0.00770347f, 0.14162031f, 0.21606333f, -0.04183319f, 0.22635082f, 0.22902688f, 0.06284964f, 
    0.11145965f, 0.17891269f, -0.03637171f, 0.19946189f, -0.10888136f, -0.10787340f, 0.01508945f, 0.15074633f, 
    -0.10038910f, -0.19297857f, 0.09703762f, 0.08535378f, 0.07565065f, 0.06338617f, -0.04230253f, -0.01167421f, 
    0.04132416f, 0.05765342f, 0.17152923f, -0.17655697f, 0.16636399f, 0.05616028f, 0.23642164f, 0.06080532f, 
    0.07989093f, 0.01587969f, 0.04739692f, -0.26208028f, -0.03618156f, 0.24133021f, 0.21082357f, 0.19411730f, 
    0.06756049f, 0.06783986f, 0.09311501f, 0.10180251f, 0.07424754f, 0.06668621f, 0.29075931f, 0.31530783f, 
    0.28897193f, 0.37305155f, 0.20824979f, 0.17517643f, 0.02527243f, 0.07896974f, -0.27550414f, -0.03622184f, 
    -0.14644994f, -0.25942680f, -0.23632181f, -0.21078165f, -0.02450541f, -0.05252900f, -0.14883940f, 0.00909621f, 
    -0.06426109f, -0.01543610f, -0.02123808f, -0.28882880f, -0.35756028f, -0.15154406f, -0.18861404f, -0.34833721f, 
    -0.12409834f, -0.22319399f, -0.18111124f, -0.09592343f, -0.21591092f, -0.11977478f, -0.10621433f, -0.28444655f, 
    0.01539889f, 0.02931268f, 0.06064589f, 0.13657756f, -0.27900722f, -0.14288695f, -0.25582550f, 0.10768784f, 
    -0.03661174f, 0.07490621f, 0.13187854f, -0.16451643f, 0.04216276f, -0.03645493f, 0.05380745f, 0.02381225f, 
    0.13208968f, 0.05036614f, -0.28557643f, 0.05852774f, -0.05230955f, 0.27809338f, 0.10554097f, 0.06630136f, 
    -0.07217101f, 0.17613075f, -0.18358749f, 0.25997153f, -0.20710802f, 0.24319530f, -0.04759031f, 0.06260044f, 
    0.10487176f, 0.16669807f, 0.11070689f, -0.01110493f, 0.13079365f, 0.11451296f, 0.04714728f, -0.34029819f, 
    0.13833696f, -0.05766333f, 0.06938317f, -0.10420225f, -0.10884799f, 0.07787083f, 0.03155297f, 0.01182513f, 
    0.06722642f, 0.02636134f, -0.10021185f, 0.10042936f, 0.39089015f, -0.00102741f, 0.08267541f, -0.06676168f, 
    -0.01255328f, 0.04132112f, -0.09559450f, 0.12214274f, 0.11373115f, 0.18563112f, -0.00776666f, -0.10764258f, 
    -0.16741351f, -0.06839555f, -0.08514046f, 0.13590469f, 0.16908794f, 0.07956318f, 0.13362250f, 0.00502175f, 
    -0.06345956f, -0.09288156f, 0.04654165f, 0.20146476f, 0.05147829f, 0.02956156f, -0.00554652f, 0.26756572f, 
    -0.11326884f, 0.19422529f, -0.10209659f, -0.17096772f, -0.05692336f, -0.07410411f, -0.06526874f, -0.06866086f, 
    0.10728347f, 0.06671604f, -0.05431637f, 0.19545337f, 0.03343850f, 0.00241355f, 0.04517816f, -0.27641038f, 
    -0.15424353f, 0.00731821f, -0.25841970f, -0.26836848f, -0.04298663f, -0.13113683f, -0.14989499f, -0.04143178f, 
    0.10353359f, 0.03136692f, -0.18359689f, 0.03423561f, -0.11916582f, 0.18511926f, 0.06499553f, -0.26546995f, 
    0.09121436f, -0.05184747f, -0.02640233f, -0.10570720f, -0.22497576f, -0.02919513f, 0.04007773f, -0.01373111f, 
    -0.04610622f, -0.17825977f, -0.03859969f, -0.13874025f, -0.00114771f, -0.03428052f, 0.07161597f, 0.03284858f, 
    -0.03836416f, 0.00805585f, -0.11180483f, 0.19465001f, -0.11802742f, 0.00024508f, -0.13864294f, -0.17614645f, 
    0.26429354f, 0.01422216f, 0.09642270f, -0.11280082f, -0.05862456f, -0.17936880f, 0.04975867f, -0.13630926f, 
    0.22271210f, 0.09498766f, 0.01689505f, 0.15106118f, 0.08972375f, 0.10789806f, -0.14145557f, -0.18194283f, 
    0.28275167f, -0.00800223f, -0.19803956f, -0.06186783f, 0.03698774f, 0.00258842f, -0.14158636f, 0.26866926f, 
    0.22808448f, 0.48502075f, 0.25580751f, -0.12174542f, 0.00270689f, 0.11194712f, -0.24057301f, -0.11204538f, 
    -0.10191307f, -0.07377470f, -0.07997071f, -0.25194031f, -0.20884548f, 0.08358691f, -0.06470086f, -0.18207683f, 
    -0.18875220f, -0.01317757f, -0.07125758f, -0.51268625f, 0.11329527f, -0.02006215f, -0.10800774f, -0.17549097f, 
    0.08968739f, -0.13899925f, 0.03219581f, -0.26871957f, 0.00883185f, 0.07585022f, 0.08312027f, 0.24903533f, 
    0.11870482f, 0.25327680f, 0.12549758f, 0.02359627f, -0.13606950f, -0.04958384f, 0.08987456f, -0.21712534f, 
    0.10722808f, 0.10533694f, 0.09908477f, 0.02613043f, 0.23589042f, -0.05387186f, 0.17598180f, 0.19268992f, 
    0.16186827f, 0.16316111f, 0.30923688f, -0.15400905f, 0.08677404f, 0.05357555f, 0.01769473f, -0.05537274f, 
    0.01613356f, -0.29512766f, 0.03185540f, -0.10105623f, -0.21371686f, -0.37816707f, -0.20361703f, -0.14764588f, 
    -0.45578956f, -0.38847389f, -0.24179512f, -0.14793537f, -0.08201163f, -0.01634778f, -0.17250792f, -0.18324587f, 
    -0.14730958f, -0.10088926f, -0.04056106f, -0.43564335f, -0.19093169f, -0.05916250f, 0.09817003f, -0.30214401f, 
    -0.06332869f, 0.11399115f, -0.32323671f, -0.13935565f, 0.11251929f, 0.09882254f, 0.17259111f, 0.05513631f, 
    -0.17808083f, 0.17588419f, -0.03455396f, -0.10966341f, 0.02874340f, -0.05270051f, 0.20540219f, -0.04417921f, 
    -0.00983487f, -0.05640726f, 0.11780961f, 0.15767401f, -0.01907790f, 0.22961113f, -0.00582953f, 0.09705346f, 
    -0.23144602f, 0.26757593f, -0.11965451f, 0.03665301f, 0.20868994f, 0.23814795f, 0.10938234f, 0.28331542f, 
    0.03933755f, 0.15424933f, 0.23024991f, 0.15196367f, 0.11270994f, 0.08591350f, 0.22718101f, -0.04757457f, 
    0.00235329f, -0.00822945f, 0.14782388f, -0.05073583f, 0.09599097f, 0.08331135f, -0.06039332f, -0.18701123f, 
    -0.03025294f, 0.02524391f, -0.12300571f, -0.05503700f, -0.06926900f, -0.07928031f, 0.02279625f, 0.09766952f, 
    0.12564577f, 0.07959943f, -0.28395197f, -0.03047492f, -0.06066095f, -0.01596613f, -0.04181742f, 0.03852101f, 
    0.02301546f, -0.23116225f, 0.04685989f, 0.02923463f, -0.06316845f, 0.11469985f, 0.12126603f, -0.02868225f, 
    0.00033766f, -0.03262387f, 0.02821479f, -0.12659188f, 0.01281602f, -0.05567318f, -0.02845052f, -0.06734585f, 
    0.03322477f, 0.03924525f, -0.04594056f, -0.05475367f, -0.18372329f, -0.05577078f, -0.15932076f, 0.03580820f, 
    0.04652073f, 0.04890299f, 0.04893620f, -0.04458121f, -0.07813607f, -0.03047587f, -0.06414873f, 0.00382150f, 
    -0.13504552f, 0.06009589f, -0.11491128f, 0.03948591f, -0.07901211f, 0.11535542f, -0.27000557f, -0.10104255f, 
    0.26295846f, 0.13305365f, 0.08444150f, -0.23996459f, 0.06035884f, 0.07176170f, -0.07495647f, -0.03450710f, 
    0.02501484f, -0.07051451f, -0.09326006f, -0.03527954f, 0.04041715f, -0.03661706f, 0.14851281f, -0.00676434f, 
    0.09543707f, -0.17359341f, -0.03899075f, 0.16223827f, 0.09413930f, 0.08736233f, 0.09849601f, -0.19378806f, 
    -0.07337486f, 0.30163951f, 0.10524872f, -0.06751873f, 0.04119357f, -0.18879575f, -0.04887649f, 0.10758476f, 
    0.10997238f, -0.05711856f, 0.01427207f, 0.11447345f, 0.07147512f, -0.13151505f, -0.10311624f, -0.08303883f, 
    0.05321792f, -0.00806392f, -0.02655547f, -0.11866021f, -0.00687009f, -0.05264026f, 0.02271424f, 0.01593126f, 
    -0.04301268f, 0.07925591f, 0.20297642f, -0.09076814f, 0.03327468f, 0.00154905f, 0.15037846f, 0.01787859f, 
    0.10388943f, -0.00542613f, -0.02374953f, -0.18054743f, -0.05796750f, -0.05283997f, -0.25185261f, 0.08358096f, 
    -0.09190891f, 0.11162085f, 0.03182398f, -0.05127888f, -0.15493164f, -0.12802917f, -0.08307903f, -0.00173592f, 
    0.08717767f, -0.39165451f, 0.34046083f, -0.03394052f, -0.03316537f, -0.03254990f, -0.12138000f, 0.01872758f, 
    0.18863066f, 0.09400052f, 0.11654540f, 0.53577192f, 0.04438051f, 0.00256959f, 0.51093262f, -0.03156984f, 
    0.12618422f, 0.22927691f, 0.20060375f, 0.23659755f, 0.45222202f, 0.07812545f, 0.34012354f, 0.30495119f, 
    0.53957495f, 0.40062697f, -0.23732157f, -0.33166787f, -0.19874352f, 0.03369151f, 0.10238885f, 0.06456611f, 
    -0.15698345f, -0.19614829f, 0.05780296f, -0.11965879f, -0.18359892f, 0.02033024f, -0.06920207f, -0.24267211f, 
    -0.14855116f, 0.03960833f, 0.04596576f, 0.23289108f, -0.01408583f, -0.07546155f, -0.08446948f, -0.09081977f, 
    0.08882630f, -0.30118205f, 0.10942104f, 0.04462679f, -0.12289271f, 0.14311922f, -0.09544919f, -0.24159923f, 
    0.20251663f, -0.22414524f, 0.31540174f, -0.06192093f, -0.03991713f, 0.02058283f, 0.46782055f, 0.21558912f, 
    0.08814652f, 0.15973915f, 0.02118386f, 0.12410621f, 0.27770569f, 0.10282088f, -0.14561549f, 0.14955314f, 
    -0.04725893f, 0.09149151f, 0.08994650f, 0.23641552f, 0.23054260f, 0.26181040f, -0.01510267f, -0.26340482f, 
    -0.33956224f, -0.00960359f, -0.26308143f, -0.13913748f, -0.14658694f, -0.02199146f, -0.38562718f, -0.18190451f, 
    -0.26435840f, -0.10808940f, 0.07908616f, 0.14115812f, 0.23343713f, 0.10571291f, -0.11678395f, -0.30265144f, 
    -0.10130967f, -0.28574081f, -0.16534377f, 0.05721232f, 0.32086044f, 0.10980658f, -0.19627051f, 0.34352445f, 
    0.09134910f, 0.07316958f, 0.14584876f, -0.03283355f, -0.19301450f, 0.28303508f, 0.06635634f, -0.04927067f, 
    0.20283154f, -0.09851806f, 0.14322371f, 0.14202535f, -0.03908958f, 0.24178534f, 0.05924350f, -0.10530360f, 
    -0.03074268f, 0.01775724f, -0.07321546f, 0.13315948f, -0.05295399f, -0.00346619f, 0.03532590f, -0.13593367f, 
    -0.05939920f, 0.20309416f, 0.05021258f, -0.08666990f, 0.02815728f, -0.03006772f, -0.07519494f, -0.18450169f, 
    -0.17745934f, 0.07081087f, -0.03453382f, 0.01201764f, 0.09681268f, -0.03892643f, 0.06299203f, -0.09723136f, 
    -0.01627112f, 0.19146609f, -0.08547446f, 0.04733941f, 0.07609655f, -0.06492583f, -0.21473323f, -0.12170350f, 
    -0.09742760f, -0.00829643f, -0.15445569f, -0.02829724f, 0.10633545f, 0.20117485f, 0.04888341f, 0.11250250f, 
    -0.19491856f, 0.14423351f, 0.07323290f, -0.07588989f, 0.10887033f, 0.06490177f, 0.11331715f, 0.18902051f, 
    0.00017438f, 0.14044064f, -0.04849461f, 0.16653771f, 0.25705032f, -0.02271316f, 0.29760135f, 0.21239163f, 
    0.10627442f, 0.24189241f, 0.13071090f, 0.35408623f, 0.11425870f, -0.23444618f, 0.00238247f, -0.24371690f, 
    0.19508989f, 0.10437276f, 0.14012508f, -0.14831108f, 0.07568671f, -0.18291915f, -0.21512067f, 0.00359713f, 
    0.15083939f, -0.11342126f, -0.02947079f, -0.02300038f, 0.06485032f, -0.06567030f, 0.22877454f, -0.14918302f, 
    0.07455587f, -0.24928004f, -0.05882357f, 0.05270077f, 0.24985979f, -0.01396704f, -0.06835906f, 0.02572501f, 
    0.07540850f, 0.04730013f, 0.11127427f, -0.10205789f, -0.00739313f, 0.11688710f, -0.09819968f, 0.19916920f, 
    -0.09760177f, 0.03187914f, 0.04350609f, -0.01196624f, 0.07944108f, 0.01382107f, -0.02471968f, 0.22248338f, 
    0.06581992f, 0.08336968f, -0.11079089f, -0.13121361f, -0.23495852f, -0.10622329f, 0.20426727f, 0.03444723f, 
    0.05033405f, 0.08702461f, -0.08055834f, 0.08094268f, -0.14735376f, -0.13938789f, -0.01809632f, -0.02973717f, 
    0.06795213f, 0.00777644f, -0.35590814f, 0.34052509f, 0.18263322f, 0.06194541f, 0.26259023f, 0.20612659f, 
    0.29910574f, 0.27487418f, 0.08568028f, -0.19108034f, 0.19053431f, -0.03810321f, -0.27575894f, -0.22892321f, 
    -0.01281050f, -0.19277025f, -0.22627720f, -0.08560919f, 0.24445824f, 0.15375182f, -0.05692646f, -0.05295940f, 
    -0.06056321f, 0.10130176f, 0.03296653f, 0.02371552f, 0.21919549f, 0.42647536f, 0.21420970f, 0.11777644f, 
    0.10129576f, 0.56696088f, 0.25883614f, 0.13597466f, 0.22811977f, 0.34473388f, -0.09143684f, 0.18651754f, 
    0.02541280f, 0.03103477f, -0.09949256f, 0.05594658f, -0.17782390f, -0.06402525f, -0.31220911f, -0.23895915f, 
    0.16041391f, -0.05720470f, 0.00177780f, -0.16347282f, -0.07550246f, -0.38154847f, 0.07414773f, 0.04884534f, 
    -0.09301215f, -0.03465485f, 0.07471708f, -0.14874951f, -0.01599516f, 0.04001926f, -0.23571852f, -0.11512730f, 
    -0.17038152f, -0.30658271f, -0.10745866f, -0.15180705f, -0.28352499f, -0.00029270f, -0.09905705f, -0.16727807f, 
    0.07515737f, 0.02832591f, -0.00740747f, -0.05682668f, -0.00421426f, -0.11034012f, -0.24759396f, -0.16013773f, 
    0.21595262f, 0.07348353f, -0.24960845f, -0.12025740f, -0.01794459f, 0.10149471f, 0.01964825f, -0.03025313f, 
    -0.01081618f, 0.04177522f, -0.35036329f, 0.00987330f, 0.11064015f, 0.18789550f, -0.01301933f, -0.11601335f, 
    -0.07271789f, -0.08286526f, 0.06780840f, 0.29073107f, 0.27651797f, -0.08231810f, 0.18116422f, -0.08620613f, 
    -0.08923905f, -0.16042158f, -0.06148090f, -0.03989118f, -0.03596704f, -0.00516509f, 0.05794829f, -0.07186315f, 
    -0.03421724f, -0.05946175f, -0.15459668f, -0.12088173f, -0.16827977f, 0.02450022f, 0.02823301f, 0.13169888f, 
    0.28512472f, 0.14722361f, 0.17439176f, 0.18222621f, -0.10569953f, -0.10242513f, -0.02496623f, -0.08466678f, 
    -0.15884034f, 0.17400388f, 0.20631469f, 0.07023439f, 0.36705620f, 0.07501909f, -0.07656152f, 0.18487361f, 
    0.07364549f, 0.06917858f, -0.40387310f, -0.30483551f, -0.02501184f, -0.17059169f, -0.09059999f, 0.14550153f, 
    0.26301943f, 0.05230689f, -0.04011877f, -0.12511510f, 0.15735223f, 0.15727439f, -0.00177983f, -0.21479562f, 
    -0.25496082f, -0.13145734f, -0.20678906f, -0.01382532f, -0.06327736f, -0.08139542f, 0.17710541f, -0.08048123f, 
    -0.03751303f, 0.09053057f, -0.12849173f, 0.21975744f, -0.02905749f, -0.08925730f, -0.09319713f, -0.03041795f, 
    0.00198017f, 0.22556664f, 0.13455546f, 0.05226564f, -0.02270251f, 0.04203921f, -0.21312573f, -0.00979494f, 
    -0.00785582f, 0.14329775f, 0.03095659f, -0.21881616f, 0.04565176f, 0.00799156f, -0.08419969f, -0.01239527f, 
    -0.15174403f, 0.02058371f, -0.09051954f, 0.04623143f, 0.04785868f, 0.29081311f, -0.05435518f, 0.13783546f, 
    0.25677368f, -0.13658415f, -0.24321806f, 0.02102037f, -0.01666872f, -0.21122207f, 0.23366027f, 0.28466994f, 
    0.06860424f, 0.16925829f, 0.13601950f, -0.07533433f, -0.17292270f, -0.01796663f, -0.18973946f, -0.07211150f, 
    -0.26630675f, -0.18385168f, -0.08244127f, -0.03531751f, -0.12616520f, -0.22607101f, -0.22952236f, -0.15614229f, 
    -0.38486230f, -0.09069784f, -0.22767708f, -0.20750758f, -0.08619841f, -0.23667147f, 0.12061508f, -0.26660214f, 
    0.01335023f, -0.03711228f, 0.03079484f, -0.15571468f, -0.18538001f, -0.34001186f, -0.46994143f, -0.11480936f, 
    -0.06631954f, -0.19249128f, -0.11282178f, 0.05059603f, -0.14578085f, -0.12915141f, 0.07517795f, -0.04243541f, 
    -0.03547562f, -0.07261679f, -0.03711540f, 0.23765309f, 0.06327095f, 0.22745724f, 0.05659743f, -0.18923432f, 
    -0.18917009f, 0.20546801f, -0.02823064f, 0.17189441f, -0.21287287f, 0.07412249f, 0.01200694f, 0.15880646f, 
    0.08197313f, 0.06234671f, 0.18237690f, 0.01614706f, -0.04834367f, 0.18192336f, 0.03525919f, -0.19085307f, 
    -0.18805222f, 0.35125928f, 0.24174983f, -0.11410987f, -0.08857539f, -0.10815292f, 0.14102727f, 0.02691541f, 
    -0.01021819f, -0.14334910f, -0.00580437f, 0.22002033f, 0.27322702f, -0.10716039f, -0.24780785f, -0.18526475f, 
    -0.19214650f, 0.15016485f, 0.11071931f, 0.09796125f, 0.12009790f, 0.15581340f, 0.17095601f, 0.08478629f, 
    0.10507801f, 0.34757420f, 0.08567779f, 0.06403699f, -0.04888912f, 0.18739670f, -0.19041268f, -0.31045353f, 
    0.00075823f, 0.23197411f, 0.24398030f, 0.01634489f, 0.10261204f, -0.11309105f, 0.13700501f, -0.11560848f, 
    -0.02011498f, -0.12849516f, 0.01400395f, -0.01210652f, -0.09679742f, -0.03578005f, 0.01345584f, -0.08649343f, 
    -0.11630405f, -0.00440276f, -0.16036608f, -0.06835617f, -0.17278640f, -0.15561172f, 0.03221889f, 0.06508334f, 
    -0.04870267f, 0.11951802f, 0.09080079f, 0.10358394f, 0.11972157f, -0.19484358f, 0.18088365f, -0.13800021f, 
    0.01500411f, -0.14176599f, -0.01848509f, -0.06025520f, -0.10844565f, -0.01276917f, -0.23809507f, -0.10854583f, 
    -0.22789911f, -0.00125944f, -0.33265920f, -0.04868146f, 0.10560674f, -0.19025592f, -0.06098221f, -0.32157957f, 
    -0.18711396f, -0.20795630f, -0.27337219f, -0.08120683f, -0.05999293f, -0.05627631f, -0.02685252f, 0.08002875f, 
    -0.05041726f, -0.07644256f, -0.06772895f, -0.10865615f, -0.14912178f, -0.14720465f, -0.00733777f, -0.09242100f, 
    0.36263817f, 0.16152481f, 0.19697887f, -0.04483457f, 0.10593916f, 0.10896432f, 0.11406071f, 0.22171148f, 
    -0.01027442f, 0.04974646f, -0.05052230f, 0.34623158f, -0.04651773f, 0.08361259f, 0.01422278f, 0.08305266f, 
    0.11858080f, 0.13155852f, 0.06787637f, 0.03572757f, -0.08602681f, -0.15505436f, 0.12570683f, -0.19462102f, 
    0.06238896f, 0.12930579f, 0.14519738f, -0.04442555f, -0.11356417f, -0.22078801f, 0.12484105f, 0.04523663f, 
    0.12818077f, 0.05854620f, 0.12682671f, 0.13993381f, 0.11181188f, -0.06348423f, -0.08757574f, -0.13984107f, 
    -0.08491737f, 0.06944941f, 0.14817333f, -0.03747406f, 0.03745489f, 0.09021195f, 0.00014126f, -0.04009207f, 
    0.01102903f, 0.04614976f, 0.00739741f, 0.07806398f, 0.15627993f, -0.36459347f, -0.01808327f, 0.16228825f, 
    -0.07201636f, 0.15469819f, 0.19664577f, 0.11738660f, -0.01153887f, 0.21580806f, 0.09987921f, 0.13038683f, 
    -0.12923173f, -0.03616522f, -0.07275114f, 0.09255646f, 0.02209183f, -0.06978408f, 0.09459717f, -0.10077298f, 
    -0.02257126f, -0.07332179f, -0.04000728f, -0.03066899f, -0.06402891f, 0.08738112f, 0.17394417f, 0.00654869f, 
    -0.15246525f, -0.04707368f, -0.16153344f, -0.05952420f, 0.16573085f, 0.04089913f, 0.17821196f, -0.16732242f, 
    0.02547992f, -0.08272174f, -0.05071244f, -0.13378542f, 0.03864321f, -0.13604011f, 0.06706679f, 0.22064116f, 
    -0.08830034f, -0.05402756f, -0.22828179f, -0.03290206f, -0.03252019f, -0.10093758f, 0.11210506f, 0.09731893f, 
    -0.07019107f, 0.09369941f, 0.14052559f, -0.08811513f, 0.02439398f, 0.04112035f, -0.06800490f, -0.02423819f, 
    0.23131521f, 0.00571159f, -0.14759317f, 0.04296448f, -0.03776140f, -0.02612212f, -0.00386234f, 0.03089104f, 
    0.01128180f, -0.07085129f, 0.06363592f, 0.08570542f, 0.11343189f, -0.14511551f, 0.18146085f, 0.21301799f, 
    -0.09693617f, 0.06059710f, -0.28339547f, 0.03145575f, -0.16469554f, -0.02193250f, 0.11055368f, 0.10712624f, 
    -0.12008102f, 0.22731043f, 0.04474796f, -0.31761052f, -0.19221500f, -0.23196808f, 0.16102735f, 0.05416761f, 
    -0.00749841f, -0.16653565f, 0.11426475f, 0.08328765f, -0.02495288f, 0.10895317f, 0.16929041f, -0.01856187f, 
    -0.08356471f, -0.02144414f, -0.14113578f, -0.11770126f, 0.03130093f, -0.16103194f, -0.17777411f, -0.10234011f, 
    -0.13007123f, 0.04649534f, -0.10534194f, -0.08201966f, -0.10931735f, 0.09637027f, -0.01545255f, 0.13835289f, 
    0.02375827f, 0.08783368f, 0.00642263f, -0.02448030f, -0.01367590f, 0.06760747f, -0.04561556f, -0.06814563f, 
    0.00208552f, -0.00182304f, 0.09072544f, 0.05518327f, -0.13803358f, -0.28662611f, 0.27878034f, 0.14937776f, 
    -0.33354565f, 0.47509430f, 0.15886556f, 0.12601486f, -0.03438441f, 0.05578757f, -0.22413518f, -0.03765268f, 
    0.03834820f, -0.07032640f, 0.08050330f, 0.27818805f, 0.06784916f, 0.21540026f, -0.02427983f, -0.04915163f, 
    0.01254757f, 0.33459531f, 0.06609984f, 0.07031972f, -0.23768735f, -0.05954183f, 0.27032288f, 0.00650470f, 
    -0.22837341f, 0.10764605f, 0.17853591f, 0.06776739f, 0.02126294f, 0.13905936f, -0.19432435f, 0.09658154f, 
    0.15964000f, 0.03359727f, 0.10789584f, 0.01337039f, -0.18411758f, -0.14938373f, -0.10067055f, -0.12732659f, 
    -0.23386027f, -0.23002897f, 0.00574840f, -0.31069357f, -0.17750663f, -0.13045954f, -0.20370057f, -0.18682479f, 
    -0.16826102f, -0.22308990f, 0.06040176f, -0.21793239f, 0.15716204f, 0.08569801f, 0.33706514f, -0.04207171f, 
    0.22022090f, 0.07401726f, -0.20900836f, 0.18679147f, -0.05931390f, 0.14436083f, 0.03218947f, 0.02399788f, 
    -0.15527143f, -0.07235899f, -0.03644336f, -0.29275704f, 0.19027158f, -0.14825329f, -0.04073075f, -0.23117645f, 
    -0.03054580f, 0.02213451f, 0.05063589f, 0.07505768f, 0.12095135f, -0.06167991f, -0.07878422f, -0.04027272f, 
    -0.22829560f, 0.09029258f, -0.32509222f, -0.23270972f, -0.08708845f, -0.19272427f, -0.21997599f, -0.12197487f, 
    -0.08194561f, 0.09154548f, 0.23452686f, -0.11579820f, 0.16546829f, 0.10867508f, 0.10420443f, -0.01859044f, 
    -0.04265585f, 0.00716411f, -0.00956450f, -0.14763762f, 0.08570688f, 0.04717195f, 0.02541517f, 0.02640669f, 
    -0.13199681f, 0.11908975f, -0.04015668f, 0.01408769f, 0.07480982f, 0.11816300f, -0.19110750f, -0.05328866f, 
    -0.10314770f, -0.02178236f, 0.05485188f, -0.16082011f, -0.00857169f, 0.03354218f, -0.23330536f, 0.03933774f, 
    0.11613479f, -0.03690978f, -0.13434974f, 0.13479023f, 0.06897403f, -0.00212517f, -0.12851905f, -0.03620342f, 
    0.12972185f, -0.08447402f, -0.15432110f, -0.01427800f, -0.09997644f, -0.01885501f, -0.13578692f, -0.06046591f, 
    0.11201692f, -0.06899261f, 0.09786350f, 0.14646321f, -0.00158154f, 0.08002847f, -0.00785784f, -0.12993781f, 
    0.08283738f, -0.03667008f, -0.09738379f, 0.20106245f, 0.04259385f, -0.05876264f, -0.06223559f, -0.06910763f, 
    0.00159100f, 0.00839429f, 0.15385285f, -0.03881803f, 0.07224200f, 0.01032501f, 0.00947810f, -0.06004098f, 
    -0.01914492f, 0.15143149f, 0.12020986f, -0.10413799f, 0.05031555f, 0.11610967f, 0.12258938f, 0.07095506f, 
    -0.00930924f, -0.03946560f, -0.10584997f, 0.01418314f, 0.08590398f, 0.02727329f, -0.06428254f, -0.06839027f, 
    -0.00660675f, 0.23303001f, 0.12220037f, 0.05284035f, -0.03743933f, -0.10797716f, -0.16453511f, -0.03221802f, 
    0.00943290f, 0.03519521f, 0.00592940f, -0.00891795f, 0.06444266f, 0.12404718f, 0.08239207f, 0.09827830f, 
    0.13322664f, 0.06937137f, -0.05918187f, 0.05980878f, 0.00407297f, 0.02073091f, -0.05001687f, 0.16906637f, 
    -0.06138573f, -0.06131639f, -0.02699210f, -0.12315331f, 0.11742476f, 0.12814480f, 0.07346116f, -0.07524959f, 
    0.22710856f, -0.05021681f, -0.05916165f, 0.12455797f, 0.12485270f, 0.06249155f, 0.26703169f, -0.22345135f, 
    -0.22690479f, -0.03023068f, 0.09321269f, 0.14810975f, 0.28649394f, 0.52692532f, -0.13752160f, 0.20576401f, 
    0.27910815f, 0.10037130f, 0.26759570f, 0.21456489f, 0.16189114f, 0.29991992f, 0.32776131f, 0.07586341f, 
    0.15924713f, 0.03143545f, 0.09144837f, 0.13858695f, 0.31712352f, 0.35857724f, 0.09069013f, 0.09579571f, 
    0.12015468f, -0.17049104f, 0.10118198f, -0.09555954f, 0.14243094f, 0.00782586f, 0.05508639f, -0.06377315f, 
    0.16819822f, 0.18621439f, 0.45050719f, 0.00243715f, 0.22953487f, 0.00708426f, -0.05060805f, 0.21014522f, 
    0.12284527f, -0.03527915f, 0.17444444f, -0.20891703f, -0.30330993f, -0.04248420f, 0.05781936f, 0.11371826f, 
    0.06058832f, 0.07949466f, 0.07707430f, 0.10343158f, 0.14478443f, 0.05377374f, -0.14993694f, 0.02069607f, 
    -0.11910329f, 0.03310994f, 0.35707765f, 0.06477976f, -0.03839504f, -0.00262994f, -0.14183708f, 0.09582419f, 
    -0.07175653f, -0.01834525f, -0.24058132f, -0.02215923f, 0.08743296f, -0.37765640f, -0.18580008f, -0.16930212f, 
    0.27976463f, 0.35297075f, -0.02417985f, -0.15493502f, 0.17436294f, 0.22094548f, -0.08673656f, 0.05803668f, 
    -0.11541436f, 0.22219832f, -0.04120721f, 0.07989664f, 0.02210776f, -0.10988020f, -0.06230114f, 0.51305344f, 
    -0.00563336f, 0.25412309f, 0.01288175f, 0.25525992f, 0.11215873f, 0.06767562f, 0.19134518f, 0.23208810f, 
    0.17306855f, 0.14674396f, 0.12754689f, 0.10048626f, -0.02145387f, -0.02634398f, -0.15623932f, 0.14858294f, 
    -0.11108708f, -0.09555988f, 0.07470514f, 0.09404521f, 0.12152246f, -0.16112836f, 0.05979063f, -0.02690853f, 
    0.05086548f, -0.03619041f, 0.04722841f, -0.06046414f, 0.07677667f, -0.11690870f, 0.01320574f, 0.07318256f, 
    -0.10820088f, -0.02773279f, 0.18346951f, 0.48179626f, 0.09352575f, -0.18195646f, -0.10274058f, 0.29848512f, 
    0.13448286f, 0.07211734f, 0.00551565f, -0.02138227f, -0.19350195f, 0.20180747f, -0.28980756f, 0.13265284f, 
    -0.24536615f, -0.32190202f, -0.01069001f, 0.15018006f, 0.11780443f, 0.07547998f, -0.09002804f, -0.18463648f, 
    0.13196807f, -0.08848541f, -0.05360320f, -0.05778503f, -0.07603694f, 0.28198379f, -0.25848260f, -0.28403123f, 
    -0.01222222f, 0.05223632f, 0.21586080f, -0.05430429f, 0.02744591f, -0.01257063f, -0.27481548f, 0.16770226f, 
    -0.06733712f, -0.06733193f, -0.08447871f, 0.22483678f, -0.03995655f, 0.23390305f, -0.07930993f, 0.09953598f, 
    0.11966463f, -0.37726458f, -0.07301765f, 0.36926548f, -0.09946593f, 0.08200191f, 0.00947134f, 0.06675119f, 
    -0.12286471f, -0.13313791f, -0.00119628f, -0.14972724f, -0.18153076f, 0.05770372f, 0.15216686f, -0.08904693f, 
    0.18138992f, -0.24613210f, -0.04733214f, 0.07238140f, 0.11645562f, -0.01184797f, -0.12413388f, -0.05039925f, 
    -0.08236393f, 0.10581661f, 0.11689592f, 0.05981067f, -0.15046584f, 0.05737380f, 0.04554732f, 0.07776680f, 
    -0.00924961f, -0.20107049f, -0.09346683f, -0.26739284f, -0.17620614f, -0.00762267f, -0.09519462f, -0.08112018f, 
    -0.34024866f, 0.03485366f, -0.16058993f, 0.03581955f, -0.03912802f, -0.25915499f, -0.01296707f, -0.21823621f, 
    0.02553972f, -0.06326449f, -0.31658641f, -0.07370591f, -0.05886866f, -0.07243445f, 0.15030406f, 0.09381930f, 
    0.04382421f, -0.28411841f, -0.07200082f, -0.07389244f, -0.02927631f, -0.16149834f, -0.01979601f, -0.04578256f, 
    0.08070608f, 0.10084239f, -0.05921166f, -0.04045954f, 0.07220275f, 0.30479734f, 0.03323203f, 0.26418969f, 
    0.09898821f, -0.09464907f, -0.17473062f, -0.11538799f, -0.20293087f, 0.01055800f, 0.02387724f, -0.17793846f, 
    -0.22964517f, -0.02935390f, -0.10927805f, -0.42625398f, -0.10885145f, -0.12725092f, 0.00474823f, -0.21316707f, 
    0.18130463f, 0.15324827f, -0.14473229f, -0.04020075f, 0.17652389f, 0.07400113f, 0.15684641f, 0.04644375f, 
    -0.16886243f, -0.04268666f, 0.02268541f, 0.02909014f, 0.18452640f, 0.03298687f, -0.10029973f, -0.12019432f, 
    0.14703490f, 0.00266469f, 0.06153977f, 0.13574812f, -0.20524819f, -0.17129375f, 0.24526664f, 0.04057541f, 
    0.07927144f, 0.15816991f, 0.08833540f, -0.09123009f, 0.00217617f, -0.14769924f, 0.04736249f, 0.09494774f, 
    -0.11109628f, 0.11681214f, 0.05059584f, -0.00549233f, -0.02594713f, 0.05295140f, 0.00427859f, -0.17650507f, 
    -0.13875061f, 0.21120431f, -0.13784326f, -0.00794248f, 0.32054190f, 0.45332379f, -0.09773607f, 0.00942282f, 
    -0.04366348f, 0.24580465f, 0.03235937f, 0.02497796f, -0.06992509f, 0.28860133f, 0.23065611f, 0.27903415f, 
    0.11171280f, 0.26333224f, 0.18339395f, 0.16792991f, 0.29082617f, -0.01364966f, -0.05843579f, -0.02851473f, 
    -0.11180996f, 0.14769792f, -0.33287199f, 0.09600479f, 0.13351612f, 0.07272756f, 0.07827667f, -0.12488817f, 
    0.03122591f, -0.22351141f, -0.01956700f, -0.15340260f, -0.02589575f, -0.01423725f, -0.05952035f, 0.06325842f, 
    0.08206822f, 0.22708720f, 0.06106743f, 0.16547731f, -0.21230322f, 0.05024440f, 0.09729432f, 0.05270317f, 
    0.11445549f, 0.05600565f, 0.17189998f, 0.01216772f, -0.08513218f, 0.03387100f, -0.09942427f, 0.07845115f, 
    -0.07787831f, -0.04029741f, 0.12342316f, 0.00818028f, -0.02460644f, 0.18757372f, 0.11028774f, -0.03437233f, 
    -0.02641736f, 0.04179693f, 0.00116584f, 0.10117876f, -0.05921143f, 0.03770622f, -0.09542313f, 0.11990567f, 
    -0.10289142f, 0.13752109f, -0.37512977f, 0.07950105f, -0.07511629f, 0.04404222f, -0.05482645f, -0.15922116f, 
    0.03250686f, -0.31337868f, -0.00936580f, -0.11806309f, -0.13218451f, -0.09298082f, 0.23174735f, 0.05592893f, 
    0.03455450f, 0.00993539f, 0.01054759f, -0.04204781f, 0.15417517f, 0.13982453f, 0.31065131f, 0.09679396f, 
    -0.09340282f, 0.19287129f, -0.05242970f, 0.09014346f, -0.06910685f, 0.22453390f, -0.14172518f, 0.22152528f, 
    0.02209383f, 0.08788654f, 0.19481097f, 0.09704856f, 0.06750802f, 0.20385476f, 0.21525739f, 0.05747978f, 
    0.01956919f, 0.17697003f, -0.04039833f, 0.03505350f, -0.14641853f, -0.00337645f, -0.21721118f, 0.01950417f, 
    0.24003880f, -0.15315198f, -0.05081507f, 0.07755040f, -0.10074739f, -0.26630891f, -0.38102531f, -0.15509375f, 
    -0.11901194f, -0.10665745f, -0.35780037f, 0.08358972f, 0.12408517f, -0.10587034f, -0.18553710f, -0.09347038f, 
    -0.14686972f, -0.05974367f, -0.11602310f, -0.19292205f, -0.04111323f, 0.09502967f, 0.11406090f, -0.05605256f, 
    0.09723725f, -0.20293551f, -0.15759838f, -0.17125155f, -0.01681589f, -0.22613042f, -0.09880125f, -0.11960275f, 
    -0.02274513f, 0.13126463f, 0.03917355f, 0.11268946f, 0.01558369f, 0.05129624f, -0.04773252f, -0.10628057f, 
    0.08657641f, -0.03672040f, -0.05720469f, 0.07685402f, -0.13969797f, 0.04353931f, 0.11769736f, -0.24736073f, 
    0.05596356f, 0.14993813f, -0.16720806f, -0.16995538f, -0.08171902f, -0.00624637f, -0.02175537f, -0.09170810f, 
    -0.08929769f, -0.15276495f, 0.00646635f, 0.00326506f, -0.05816374f, -0.00943232f, -0.15545929f, -0.01130585f, 
    0.01954845f, -0.04205192f, 0.03027935f, -0.18543897f, -0.07870846f, -0.15932706f, -0.05659403f, 0.11278872f, 
    0.08309380f, -0.12912532f, 0.22226928f, -0.23157670f, -0.09114973f, -0.05814772f, -0.32053404f, -0.19236730f, 
    -0.29817492f, -0.13719226f, 0.03649083f, -0.15300182f, -0.21831095f, -0.18895252f, 0.12642958f, -0.15894509f, 
    0.13963876f, 0.05673617f, -0.01222875f, 0.15412936f, -0.02721186f, -0.02045594f, -0.19965557f, 0.16544922f, 
    0.03457107f, 0.25778763f, 0.34430395f, -0.15214636f, 0.01634481f, -0.08466316f, 0.14615834f, -0.10937280f, 
    -0.01344633f, -0.01900730f, 0.13270787f, 0.07314534f, -0.07902792f, 0.50643469f, 0.07344804f, -0.03846635f, 
    -0.00197370f, -0.17842122f, -0.06704337f, -0.09344797f, -0.18768545f, -0.07654431f, -0.01810956f, -0.06836379f, 
    -0.20148934f, 0.04955634f, -0.02073192f, -0.05984308f, -0.09552269f, -0.02909102f, -0.15136921f, -0.12913016f, 
    0.01577797f, -0.12488834f, 0.01549565f, -0.31749228f, -0.05489231f, -0.10171251f, -0.23721173f, -0.13875475f, 
    -0.14421439f, -0.22801141f, -0.06977018f, 0.05484469f, -0.18204110f, -0.26106901f, 0.08356088f, -0.10601338f, 
    -0.04666066f, 0.21447544f, 0.13221456f, -0.11117030f, 0.00323453f, 0.10985441f, -0.11066590f, -0.15271383f, 
    -0.09616099f, -0.00766147f, -0.05437955f, -0.42679537f, -0.23667673f, -0.04982426f, -0.12799846f, -0.08627438f, 
    0.18284775f, -0.08910204f, -0.03730132f, 0.04596879f, -0.00563666f, -0.02543465f, 0.06711143f, -0.08974070f, 
    0.24532481f, 0.11402402f, -0.16948034f, -0.01206651f, 0.05252031f, -0.00692235f, 0.03172326f, -0.01776099f, 
    0.00826914f, 0.04529750f, -0.09619053f, 0.20979378f, 0.22840685f, 0.20494034f, 0.13373792f, 0.14443091f, 
    0.07808219f, 0.09187254f, -0.05748461f, 0.09127919f, 0.13385270f, 0.19812808f, -0.09014996f, -0.02937825f, 
    -0.12758521f, -0.22227072f, 0.02236971f, -0.28434870f, -0.15040158f, -0.08731885f, -0.05138317f, -0.13636796f, 
    0.09747572f, -0.09818934f, 0.24412708f, 0.07052292f, 0.09193314f, 0.05215682f, 0.07199791f, 0.00725713f, 
    0.19149712f, -0.21752982f, 0.09751732f, -0.08341849f, -0.06446519f, -0.01062226f, 0.08884269f, 0.09165840f, 
    -0.00941549f, 0.04826867f, 0.08544066f, 0.03411546f, 0.08661303f, -0.04949950f, 0.03682835f, -0.03396032f, 
    0.00896698f, -0.09402375f, 0.15521004f, 0.08133422f, 0.04224665f, 0.18894136f, 0.02639037f, -0.14372918f, 
    -0.06410022f, 0.03262558f, -0.05327186f, -0.18385685f, -0.17935359f, -0.02723486f, -0.09561903f, -0.10241419f, 
    0.03206756f, 0.02436765f, -0.04980933f, -0.15384115f, 0.08074033f, -0.22262276f, -0.00156170f, -0.03134252f, 
    -0.10397088f, 0.00521462f, -0.05273415f, -0.04348350f, -0.03349721f, -0.12047835f, 0.12464487f, 0.09458973f, 
    0.08314265f, 0.05824004f, -0.10344303f, -0.10615230f, -0.07815965f, 0.10421167f, 0.01133336f, -0.13859514f, 
    -0.07321207f, -0.16812619f, -0.05820475f, -0.04637589f, -0.00410677f, 0.11420907f, -0.11405498f, 0.05644467f, 
    0.20593363f, -0.13099122f, 0.06106026f, 0.05726256f, -0.00438203f, -0.02331722f, 0.25391854f, 0.19171897f, 
    0.02276182f, -0.20281947f, 0.02999975f, -0.08226803f, 0.06335082f, 0.05366523f, 0.05968751f, -0.06551776f, 
    0.10696142f, -0.09078506f, -0.18484848f, 0.02014639f, 0.04603997f, 0.20752924f, -0.16264695f, -0.00623181f, 
    -0.06784951f, 0.11857951f, 0.00804691f, -0.02062733f, 0.24189996f, 0.06347008f, -0.09156664f, -0.14462036f, 
    0.02562998f, 0.17029412f, -0.24458224f, -0.10621102f, -0.04574666f, 0.04235761f, 0.00938030f, 0.04095514f, 
    -0.05046019f, 0.18003993f, 0.02367124f, 0.11671852f, 0.09612271f, -0.07769290f, -0.06563126f, -0.08891239f, 
    -0.02369894f, -0.08107385f, -0.07728550f, -0.07002555f, 0.10004552f, -0.09580158f, 0.00455736f, -0.09621524f, 
    -0.12014031f, -0.10224267f, -0.02782305f, 0.10066447f, -0.24268201f, 0.03708125f, 0.12008882f, -0.07607827f, 
    -0.02085566f, -0.04053817f, 0.06634881f, 0.11303528f, 0.22684502f, 0.34080645f, -0.12454780f, 0.11695851f, 
    0.28475369f, 0.18996889f, 0.02739435f, 0.18445689f, -0.01327432f, 0.09312569f, 0.22192058f, 0.34957452f, 
    0.36208493f, 0.24680224f, 0.10930301f, 0.44753233f, 0.07194556f, 0.05505277f, -0.13835202f, -0.11308739f, 
    -0.29263734f, -0.19170623f, -0.05407321f, 0.00850529f, 0.06286307f, -0.09095471f, 0.13980664f, -0.09977342f, 
    -0.11475452f, -0.11198819f, -0.22719223f, -0.07433399f, 0.07019692f, 0.03730154f, -0.14138730f, -0.08227676f, 
    0.11083747f, 0.14315678f, 0.18477538f, -0.12789424f, -0.10755537f, -0.17094699f, 0.09540211f, -0.10753157f, 
    0.03031868f, 0.11547681f, -0.15804570f, -0.12130510f, -0.18122982f, 0.06026269f, 0.15155527f, -0.15931024f, 
    0.05004902f, 0.18647873f, 0.26818953f, 0.05959246f, 0.16270722f, -0.12320748f, -0.17806447f, 0.06802972f, 
    0.03460649f, -0.12051668f, -0.09755496f, 0.00604894f, 0.11265780f, -0.17009753f, 0.09814078f, 0.20052815f, 
    -0.10071033f, -0.03351108f, 0.09641354f, 0.07070920f, -0.25282802f, -0.00500935f, 0.02001613f, -0.12830726f, 
    -0.00227419f, 0.03959859f, 0.08706119f, 0.23571721f, 0.02710840f, 0.02380753f, 0.17139119f, 0.08777575f, 
    -0.00189290f, -0.00601058f, 0.07156694f, -0.03144778f, -0.18646236f, -0.09055983f, -0.19827051f, 0.11001859f, 
    0.13958165f, -0.05165929f, 0.01024813f, -0.04957016f, -0.02256885f, -0.00137629f, -0.10510688f, 0.18095162f, 
    -0.03424656f, -0.13704361f, -0.07569554f, -0.01364270f, 0.08641268f, -0.20987524f, -0.29714738f, 0.14923489f, 
    0.23432294f, 0.17156963f, -0.09232486f, -0.14481555f, 0.15562516f, 0.11519937f, 0.12018804f, -0.01121387f, 
    -0.42882644f, -0.36323290f, -0.19027937f, -0.27232696f, -0.06822314f, -0.24682588f, -0.06739060f, -0.30262606f, 
    0.06317592f, -0.07749492f, 0.02154951f, -0.17272914f, -0.01743740f, -0.00240421f, 0.03902547f, -0.00317313f, 
    0.11713024f, -0.02864749f, -0.08567187f, -0.08008819f, 0.15759272f, -0.04509022f, 0.05395966f, -0.06875273f, 
    0.00898558f, -0.11293669f, -0.08081290f, 0.09599867f, 0.08734822f, 0.08380987f, 0.02979597f, -0.15237121f, 
    -0.14740232f, 0.06811272f, -0.02233168f, 0.10416261f, 0.06717494f, -0.07385328f, 0.00663863f, -0.01736519f, 
    0.03851844f, -0.17568398f, 0.17299569f, -0.14357673f, -0.10150065f, 0.05302019f, -0.22138202f, -0.17298665f, 
    -0.07033466f, 0.02998719f, -0.03656880f, -0.15970793f, 0.04378767f, 0.18340429f, 0.13179637f, -0.09518187f, 
    0.05040589f, 0.08784686f, 0.02822347f, 0.00693597f, -0.00528141f, -0.06919852f, 0.03455720f, 0.01690297f, 
    0.10632439f, -0.10479714f, -0.01551056f, -0.12166771f, -0.04137533f, 0.07533265f, -0.00013879f, 0.06385516f, 
    0.11592528f, 0.01336890f, 0.19995445f, 0.04182883f, -0.06191785f, -0.01885483f, 0.00869123f, -0.04450058f, 
    0.11838240f, -0.12182203f, 0.02721259f, -0.14439734f, 0.08830800f, 0.10191916f, 0.03538871f, 0.14871165f, 
    0.07169734f, -0.13296215f, 0.04900536f, 0.05025464f, 0.01592059f, 0.20894892f, 0.04735525f, -0.02547851f, 
    -0.05612194f, -0.15236854f, 0.01377732f, 0.11071188f, 0.07546249f, -0.00460806f, -0.11151137f, 0.06563383f, 
    0.07646022f, 0.02859654f, 0.04005147f, -0.08742161f, 0.05878597f, -0.12259564f, -0.13509009f, 0.06937174f, 
    0.14025871f, 0.01919310f, -0.25645039f, -0.06409521f, -0.08917536f, -0.09677746f, 0.00375476f, -0.11809500f, 
    -0.11235773f, 0.05928930f, -0.07396466f, 0.07920649f, 0.01293387f, 0.13287101f, 0.05005741f, 0.07442491f, 
    -0.04160903f, 0.02276797f, -0.09223124f, 0.06209504f, -0.04108583f, 0.01581559f, 0.00869262f, -0.10563251f, 
    0.07800327f, 0.15630353f, -0.07003206f, 0.45534994f, -0.14554128f, -0.10112811f, 0.09573416f, -0.18090828f, 
    0.03893679f, -0.01492900f, -0.10870449f, -0.06575438f, 0.00866271f, -0.10922707f, -0.18643130f, -0.17012956f, 
    -0.15171165f, 0.08371276f, -0.26677560f, 0.11863434f, 0.05873421f, -0.03234901f, -0.15930183f, -0.14916543f, 
    0.10283669f, -0.15637159f, -0.18939546f, -0.06942124f, -0.11634373f, -0.14147203f, -0.02091338f, -0.25483666f, 
    -0.09485499f, -0.17687213f, 0.04638165f, 0.04466860f, 0.32198558f, 0.06725367f, 0.00180375f, 0.34951037f, 
    0.18738396f, 0.33634797f, 0.12752687f, 0.11398523f, 0.03786757f, 0.36463765f, 0.04237073f, 0.47792985f, 
    0.04913490f, 0.26062496f, 0.15617360f, 0.23001536f, 0.04739006f, -0.19174202f, 0.17231450f, 0.17549828f, 
    0.25751610f, 0.25858957f, 0.10201291f, -0.08936771f, 0.09826741f, -0.03213209f, -0.00550085f, 0.06885060f, 
    0.16552571f, 0.03389054f, 0.25159746f, 0.04811043f, 0.29645522f, 0.05682332f, 0.35638693f, 0.07057167f, 
    -0.13932518f, 0.27714196f, -0.08635059f, -0.02231520f, 0.18562718f, -0.13305549f, 0.06820556f, 0.12329180f, 
    -0.13736015f, 0.00479270f, 0.21619887f, -0.05890078f, 0.10209732f, 0.27953321f, -0.10061758f, -0.04803494f, 
    0.08508090f, -0.05355722f, 0.08979789f, 0.23866153f, 0.09470537f, -0.01483488f, 0.26789886f, 0.01604295f, 
    0.09895141f, -0.06779036f, -0.01766393f, 0.13454216f, -0.08460252f, -0.07159099f, 0.07740792f, 0.23521948f, 
    0.35931754f, 0.37906456f, 0.11993485f, 0.08182881f, -0.04632420f, 0.00949734f, 0.06687207f, -0.01541626f, 
    -0.15335366f, 0.11957189f, -0.15198816f, 0.04081646f, -0.14232618f, 0.13371438f, -0.01125570f, 0.07046705f, 
    0.21665320f, 0.12017032f, -0.11003112f, 0.10490387f, 0.04235314f, -0.20537801f, -0.15180039f, -0.04832491f, 
    -0.15783196f, 0.00582527f, 0.07259340f, 0.11247803f, 0.09191495f, 0.09514977f, 0.06310264f, 0.17987359f, 
    -0.06837844f, -0.11391257f, 0.13570157f, -0.15552353f, -0.12010967f, -0.18076112f, -0.00692820f, 0.00317408f, 
    -0.08656654f, -0.06562054f, -0.11567746f, 0.02724041f, -0.07798027f, -0.09686839f, 0.01290329f, -0.18843880f, 
    -0.00775664f, 0.04336178f, 0.11376625f, 0.01226910f, 0.34283027f, 0.15410567f, 0.24917638f, 0.18839553f, 
    0.30628089f, 0.05202663f, -0.01226737f, -0.00296395f, 0.07103465f, -0.36245695f, 0.02908894f, 0.00024065f, 
    -0.04146906f, -0.10758142f, 0.04011738f, 0.06010675f, -0.21711786f, -0.04799594f, 0.03176831f, -0.15729801f, 
    -0.23026911f, 0.08813117f, -0.11369880f, 0.03247156f, -0.20363546f, 0.11106039f, -0.08708700f, -0.21042620f, 
    -0.09028135f, -0.05067154f, -0.33536122f, 0.05808889f, 0.10250486f, 0.13171422f, -0.07837031f, 0.10359073f, 
    -0.18112434f, -0.04280371f, 0.00171297f, -0.19155934f, 0.04565609f, 0.26737791f, 0.00717642f, 0.05338611f, 
    0.10953416f, -0.03816476f, -0.01522770f, 0.17502355f, -0.12419184f, -0.15151608f, -0.02380395f, 0.03565102f, 
    0.12102975f, -0.18308691f, -0.05959593f, 0.01184145f, -0.07477430f, -0.02942947f, -0.08465662f, -0.10760900f, 
    -0.05578903f, -0.00377338f, -0.14383322f, -0.06598137f, 0.12798942f, -0.09832459f, -0.05529870f, 0.14843604f, 
    0.03090196f, -0.04272308f, -0.20852527f, 0.01090373f, 0.16411847f, 0.10518951f, -0.06843018f, 0.08722138f, 
    -0.13271490f, 0.38459148f, 0.10473814f, 0.20056545f, 0.06211191f, -0.12108897f, 0.01954741f, -0.05997097f, 
    -0.02888455f, 0.06240873f, -0.09260385f, -0.06578121f, -0.03747947f, 0.02355464f, -0.01523314f, -0.23809948f, 
    -0.07976272f, -0.15807911f, 0.15908553f, -0.01328265f, -0.01259724f, 0.15299172f, -0.04023373f, 0.09452726f, 
    0.05904959f, 0.14218025f, 0.14451162f, 0.05007843f, 0.13618455f, 0.14090417f, 0.14731330f, 0.15973417f, 
    0.05464475f, -0.10886528f, 0.04801446f, -0.12409690f, -0.33219139f, -0.41521436f, -0.31138985f, 0.13184052f, 
    -0.02402913f, -0.28007774f, 0.13209541f, -0.11213493f, -0.03167329f, 0.07337833f, -0.13059163f, -0.05233118f, 
    -0.02340517f, -0.28655293f, -0.13541253f, -0.16654600f, -0.20413387f, -0.09705499f, 0.24482565f, 0.08185438f, 
    0.33567770f, 0.03854855f, 0.01034271f, 0.36492063f, -0.00630378f, -0.08788135f, -0.05234961f, 0.06212660f, 
    -0.22500094f, 0.02239111f, -0.02333930f, 0.08484513f, 0.22921362f, -0.01212997f, 0.08528362f, 0.07525203f, 
    -0.05068631f, 0.14398156f, 0.22129824f, -0.02335395f, -0.25804773f, 0.07104395f, 0.05422824f, -0.10289561f, 
    -0.09614003f, 0.00802102f, -0.07602231f, -0.05018615f, -0.09860938f, 0.02634342f, -0.01295357f, 0.11996533f, 
    0.10496440f, -0.05511321f, 0.05027678f, -0.13412938f, -0.05626840f, 0.00655393f, -0.04674882f, -0.01634240f, 
    0.03566695f, 0.10123240f, -0.13790839f, 0.21748583f, -0.04712668f, 0.05540079f, -0.06765809f, 0.17900358f, 
    0.04789145f, -0.01446711f, 0.06105064f, 0.28146091f, -0.10871854f, 0.04454400f, -0.33595022f, 0.02698430f, 
    -0.05810002f, 0.13701382f, 0.22487998f, 0.18793179f, -0.11481685f, -0.25460614f, -0.08279724f, 0.13884380f, 
    0.01879246f, -0.25915102f, -0.14706514f, -0.08602032f, -0.31866255f, -0.07345233f, 0.02975798f, 0.25326389f, 
    0.29474291f, 0.13111185f, 0.10853286f, 0.08619961f, 0.28871492f, -0.09281767f, 0.02324563f, -0.00846449f, 
    -0.07794108f, -0.04515771f, -0.16308469f, 0.13359823f, -0.16070621f, -0.11013651f, -0.00028548f, 0.01030272f, 
    -0.09820070f, -0.08547876f, 0.04899929f, -0.09328007f, -0.07718364f, 0.04960301f, 0.04192118f, 0.21057860f, 
    0.14129275f, 0.21551213f, 0.28685330f, 0.13019449f, -0.00797642f, -0.09536163f, 0.06252737f, 0.00973562f, 
    -0.06870356f, -0.03617393f, 0.17855938f, -0.00981984f, -0.08987681f, -0.16450203f, 0.23934972f, -0.06384213f, 
    -0.06998292f, -0.06826878f, -0.06771410f, -0.02980354f, 0.04526871f, 0.01871120f, -0.23925463f, -0.15872877f, 
    -0.15754995f, -0.16275930f, -0.22037247f, -0.09113580f, 0.30792019f, -0.08816597f, 0.13940723f, 0.04100051f, 
    0.17703469f, 0.18465336f, 0.04948717f, 0.36189849f, 0.17575893f, 0.09928501f, 0.28539169f, 0.03431574f, 
    -0.10198208f, -0.03936689f, 0.31973652f, 0.10865512f, 0.03832753f, 0.37710389f, -0.02421127f, -0.12114603f, 
    -0.02234760f, -0.15079807f, 0.21184450f, -0.04812582f, -0.10746061f, 0.12078583f, -0.13850937f, -0.14121744f, 
    -0.03279790f, -0.06979342f, 0.05996439f, -0.02228159f, -0.01792462f, -0.08721442f, 0.36161295f, 0.12424648f, 
    0.39947121f, 0.24100623f, 0.10915095f, 0.18991826f, 0.18310692f, -0.03375486f, 0.20550310f, 0.16558917f, 
    0.32949939f, 0.34747103f, -0.06962207f, 0.02381881f, 0.06942190f, 0.21318102f, 0.06346237f, 0.08470074f, 
    0.11521280f, 0.09184351f, 0.16218320f, 0.12609345f, 0.09522883f, 0.16051055f, 0.18904825f, 0.25849801f, 
    0.28169959f, 0.11719605f, -0.12758216f, 0.28732115f, 0.19526024f, 0.51618266f, 0.38758306f, 0.16538882f, 
    0.29086131f, 0.14627194f, 0.17270521f, 0.09274646f, 0.09273025f, -0.12699777f, -0.15097545f, -0.16736749f, 
    0.25671890f, 0.15395392f, -0.19051772f, -0.17095642f, -0.31940514f, 0.02204095f, -0.02912360f, -0.12954882f, 
    0.03910690f, -0.25289969f, 0.02485255f, -0.11934968f, -0.36193567f, -0.12237801f, -0.08338294f, -0.15470896f, 
    0.07741176f, -0.17536263f, -0.08734101f, 0.00870650f, -0.12502621f, -0.14948697f, -0.14165728f, 0.23218657f, 
    0.08809981f, 0.07533788f, -0.05606074f, 0.05013705f, 0.04771565f, 0.05007168f, -0.00356784f, 0.09233106f, 
    0.44708658f, 0.13441448f, 0.13637372f, 0.22290498f, 0.25820032f, 0.17561518f, 0.05228386f, 0.04600789f, 
    0.03075352f, 0.14642180f, -0.03875300f, -0.17159270f, -0.09175260f, -0.05340278f, -0.06063226f, 0.00504097f, 
    -0.04053932f, -0.08768150f, -0.07182785f, -0.04434664f, 0.03717348f, 0.00556223f, 0.20391310f, -0.05459676f, 
    0.00307883f, -0.14526726f, 0.14863234f, 0.10161386f, -0.17306881f, -0.03037307f, -0.06654188f, 0.00425672f, 
    -0.04157728f, -0.09552462f, 0.02784680f, 0.09885256f, -0.00256336f, -0.12633679f, -0.12684519f, -0.08945599f, 
    0.10827851f, -0.08610232f, -0.08833327f, 0.07652952f, 0.01921498f, 0.03935148f, -0.03568038f, -0.17348360f, 
    -0.00003397f, 0.00830375f, -0.10510260f, 0.19596787f, -0.01104151f, -0.08507284f, 0.44257560f, 0.30061351f, 
    -0.07210330f, 0.22013803f, 0.08500649f, -0.01793916f, 0.15504139f, 0.34879424f, 0.27157233f, 0.07925117f, 
    -0.10759694f, -0.06557045f, 0.05172135f, 0.21034925f, 0.06708022f, 0.10976551f, -0.20051299f, -0.11468867f, 
    0.03576235f, -0.10194036f, 0.14174885f, 0.02282353f, -0.06620449f, 0.00775189f, 0.01185217f, -0.30152113f, 
    0.02920650f, 0.08784685f, 0.13039732f, 0.12914315f, 0.10367585f, 0.20066338f, 0.20643600f, 0.07405683f, 
    -0.06523804f, 0.02162441f, 0.28483062f, 0.26239697f, -0.23695595f, -0.10807530f, -0.09751549f, 0.11977159f, 
    -0.06730278f, -0.12661535f, -0.00159615f, -0.09029427f, 0.02984709f, -0.03496990f, -0.05481277f, -0.10566940f, 
    0.16997149f, -0.01448358f, 0.03988476f, -0.03626917f, 0.11959736f, 0.07030467f, -0.13532404f, 0.05490229f, 
    0.06803499f, 0.01163622f, 0.09533632f, -0.07294208f, -0.06929967f, 0.05180698f, -0.16931200f, -0.06922014f, 
    -0.23205508f, -0.01860357f, 0.05291653f, 0.12981674f, 0.12231461f, -0.11008499f, 0.12678387f, -0.00049973f, 
    0.06888331f, 0.03479675f, -0.00414871f, 0.00518393f, -0.01492454f, -0.02752778f, -0.00655510f, 0.20102750f, 
    -0.08598309f, -0.05090517f, 0.04699089f, 0.02324153f, -0.02858275f, 0.01429115f, -0.07820711f, -0.07759859f, 
    0.00977342f, -0.02604713f, -0.04487895f, -0.19329522f, -0.22500585f, 0.06139510f, -0.12327200f, 0.13348187f, 
    0.05083776f, -0.16186406f, 0.06885097f, -0.14617551f, -0.05227804f, -0.06987440f, -0.05451020f, -0.17778453f, 
    0.12664133f, -0.11009541f, 0.10222530f, -0.02416160f, -0.00027579f, -0.06081006f, 0.06153129f, 0.19123308f, 
    -0.04748716f, 0.08998930f, -0.02716457f, 0.12717424f, -0.18140129f, -0.14414540f, 0.00208957f, 0.02549058f, 
    0.00101991f, -0.14570635f, 0.22380943f, -0.04572177f, 0.07869153f, 0.07911106f, 0.12400840f, -0.18502856f, 
    0.07726420f, -0.11763532f, -0.13684661f, -0.01346842f, -0.02609276f, -0.03277237f, 0.21061789f, 0.02627938f, 
    -0.00461701f, 0.17912072f, -0.10551918f, 0.14890565f, 0.16082246f, 0.00889041f, 0.07655650f, -0.07313815f, 
    -0.00398861f, -0.09224908f, -0.07839239f, -0.01767267f, -0.15606357f, 0.06512405f, 0.05400417f, -0.16804010f, 
    -0.11951975f, -0.17920707f, -0.04192340f, -0.24082691f, -0.21578502f, -0.12674936f, 0.09504311f, -0.21947834f, 
    0.02704275f, -0.06065997f, -0.07677167f, -0.00415549f, 0.16585491f, -0.11770927f, -0.04318059f, 0.08032705f, 
    -0.01396513f, 0.04051008f, -0.08015689f, -0.11433180f, 0.00362956f, 0.11688261f, -0.11702343f, -0.17390698f, 
    -0.07415431f, 0.08461255f, 0.04307039f, 0.06249359f, -0.11989287f, -0.19800669f, -0.04084363f, 0.12799139f, 
    0.22328282f, 0.24990672f, -0.08868506f, -0.00826325f, 0.24915674f, 0.13003058f, -0.21634184f, 0.10007755f, 
    0.20282416f, -0.21117423f, 0.06928158f, 0.25343484f, -0.06798185f, 0.26294635f, 0.12420671f, -0.11431737f, 
    -0.02779495f, -0.10672760f, -0.08908804f, 0.01531487f, -0.07075877f, -0.08506441f, -0.06940058f, 0.12123970f, 
    -0.05498722f, 0.06144727f, 0.01581998f, 0.12945006f, 0.11021494f, 0.10563546f, -0.22549029f, -0.00944791f, 
    0.04047812f, 0.13153447f, 0.12464473f, -0.02642751f, -0.09421636f, 0.27797542f, 0.14744054f, 0.12931957f, 
    0.11447768f, -0.40516503f, -0.08539022f, 0.06973134f, 0.11425118f, 0.11920959f, 0.00267921f, 0.00475041f, 
    0.08408159f, 0.14127092f, 0.13165861f, 0.12733421f, -0.05212740f, -0.08065407f, 0.11110437f, 0.00555282f, 
    0.02955723f, 0.07781194f, -0.01968866f, -0.02872359f, 0.07056668f, 0.02672356f, 0.27543456f, 0.27641235f, 
    0.11637342f, 0.19621009f, -0.19633669f, 0.09965435f, -0.06752367f, -0.02136159f, -0.11210798f, 0.10629120f, 
    -0.20494495f, -0.20106007f, 0.01989837f, 0.47693068f, 0.20973817f, 0.28881371f, 0.05420468f, 0.26755669f, 
    0.28242961f, 0.19086033f, 0.32802198f, 0.17870125f, 0.26887489f, 0.15985313f, -0.07967362f, 0.24459473f, 
    0.14649047f, 0.30899158f, 0.27463055f, -0.02030596f, 0.15642929f, -0.00052096f, -0.10429442f, -0.04412042f, 
    0.10224343f, -0.16114114f, -0.08042658f, 0.25154722f, 0.00419841f, 0.11117914f, -0.12388812f, -0.17241690f, 
    -0.10881087f, -0.02388639f, 0.03417699f, -0.07423599f, -0.09542251f, -0.14562301f, -0.05583533f, -0.06012648f, 
    0.02372421f, 0.09962027f, -0.22618047f, -0.17106070f, -0.33870030f, -0.13339021f, -0.13210139f, -0.19205701f, 
    0.04005780f, -0.12909388f, 0.10630941f, 0.04631203f, 0.11757111f, 0.11834144f, 0.08130006f, 0.11658618f, 
    -0.05176514f, -0.17164198f, -0.12925833f, 0.10086813f, 0.12549890f, -0.08071719f, -0.04398494f, 0.08083843f, 
    -0.12636545f, -0.06911870f, 0.05000733f, -0.00975299f, 0.04638216f, -0.08572397f, 0.11199243f, 0.01049630f, 
    -0.06528275f, 0.07626401f, -0.07861631f, -0.01157227f, -0.16612925f, 0.04874326f, -0.03955150f, 0.04292910f, 
    0.08131645f, -0.02376184f, -0.01795158f, 0.11553541f, 0.03710527f, 0.10305359f, -0.08027925f, 0.00101420f, 
    -0.09677547f, 0.09550435f, 0.07177993f, 0.07348395f, 0.06871195f, 0.03809206f, -0.07703863f, -0.11978488f, 
    0.09778170f, 0.01612066f, -0.15714025f, -0.04781107f, 0.04374572f, 0.06009671f, -0.05468008f, -0.09921487f, 
    -0.08882213f, -0.05694351f, 0.02457517f, 0.04939053f, 0.02972395f, -0.01287604f, -0.10107286f, -0.22394622f, 
    0.00339569f, 0.14647909f, 0.06699823f, -0.09147076f, 0.11208501f, -0.25325960f, -0.08441732f, -0.01786745f, 
    -0.08414756f, 0.05017846f, 0.08363291f, 0.18286523f, 0.16921252f, -0.10446508f, 0.05608085f, -0.03616658f, 
    0.02007299f, 0.18695603f, -0.00052126f, -0.25225813f, 0.04997054f, -0.09826972f, 0.24903473f, 0.12559267f, 
    0.04482962f, -0.06123804f, -0.08964987f, -0.22739167f, -0.07680232f, 0.15006670f, -0.01331322f, -0.28790115f, 
    0.08659462f, -0.02821585f, 0.04083465f, 0.01514391f, 0.03725776f, 0.12629454f, 0.04556044f, -0.02519442f, 
    -0.04665944f, -0.16860503f, -0.01931495f, -0.01069306f, 0.04885682f, -0.01554971f, -0.14370247f, 0.00627427f, 
    -0.01667488f, -0.10373888f, 0.01554101f, 0.02147976f, 0.01863880f, -0.10723242f, -0.12593025f, 0.13413704f, 
    -0.05122772f, -0.03740949f, 0.13850064f, -0.04856188f, -0.04577251f, -0.14417190f, 0.20753853f, -0.08813507f, 
    0.03994526f, 0.39768061f, 0.04699600f, -0.28570573f, -0.20973621f, -0.10234648f, -0.27028734f, -0.81816533f, 
    -0.72734845f, -0.42694837f, -0.25936722f, 0.08266303f, -0.35483308f, -0.36581191f, -0.08883851f, 0.08081603f, 
    -0.25782614f, -0.27847078f, -0.11979821f, -0.09835955f, -0.15847996f, -0.12868739f, -0.13067698f, -0.13771190f, 
    -0.23182694f, -0.05225699f, -0.09900742f, 0.18494616f, 0.40608065f, 0.32031519f, 0.19322211f, 0.09273776f, 
    -0.01591697f, -0.22637101f, -0.31291910f, -0.17208816f, 0.02290010f, -0.03158706f, -0.28452324f, -0.14951158f, 
    -0.45231930f, -0.41593461f, -0.19197296f, -0.16511883f, -0.15555239f, -0.24567297f, -0.23728797f, -0.30325900f, 
    0.00416955f, 0.03549776f, -0.35000729f, -0.36401266f, -0.12841017f, -0.46128780f, -0.01316604f, -0.07502845f, 
    -0.31530624f, -0.26436172f, -0.26175052f, 0.01862585f, -0.08259143f, -0.23409893f, -0.07146025f, -0.32041252f, 
    -0.23181563f, -0.22307028f, 0.00133228f, -0.10335234f, 0.00194339f, -0.41250424f, -0.18195656f, -0.27371945f, 
    0.02700307f, 0.14018843f, 0.08914416f, 0.15074128f, -0.11704071f, 0.10085305f, 0.08626456f, 0.01700710f, 
    -0.14462034f, 0.11957342f, 0.17014285f, -0.06636959f, 0.03298720f, -0.01961710f, 0.25588396f, 0.04760613f, 
    0.11146490f, -0.12738283f, 0.01617922f, 0.06313246f, -0.03636972f, -0.14275501f, 0.12214360f, 0.11574031f, 
    -0.06347152f, -0.21557434f, -0.01236579f, -0.45854958f, -0.42668310f, -0.16612670f, -0.25470094f, -0.13972038f, 
    -0.10539915f, -0.13602166f, -0.05615466f, 0.29704763f, 0.03491088f, -0.15704559f, -0.34158924f, -0.34452164f, 
    -0.12639598f, -0.05858564f, -0.06068782f, 0.06647244f, -0.07573577f, 0.04477032f, -0.39302788f, 0.12096653f, 
    -0.07461137f, 0.16798492f, -0.30175920f, -0.18082074f, -0.10161037f, 0.05826510f, -0.05372877f, -0.02930478f, 
    -0.04089863f, 0.12809233f, 0.25780005f, 0.02868304f, -0.02522706f, 0.19498783f, 0.25269224f, 0.23514037f, 
    0.20510420f, -0.08890856f, 0.10062867f, -0.06471859f, -0.16882139f, 0.12643362f, 0.06248483f, -0.17454589f, 
    0.05740985f, -0.01507941f, 0.02487442f, 0.02066303f, -0.12463488f, -0.20614377f, 0.01217055f, -0.17344177f, 
    -0.03935148f, -0.16238728f, -0.13010434f, 0.09475992f, 0.03863444f, -0.30254834f, -0.22871376f, 0.03979556f, 
    0.06227121f, -0.08888623f, 0.07081253f, 0.17636355f, 0.07766923f, 0.05522795f, 0.11920948f, 0.21425658f, 
    -0.08922364f, 0.22039195f, -0.09506017f, -0.04135366f, 0.00968225f, 0.05546250f, 0.35865234f, 0.09249692f, 
    -0.11811230f, -0.02749497f, -0.20851080f, -0.07610423f, 0.06700354f, -0.09443248f, 0.07457391f, -0.00058920f, 
    -0.03029456f, 0.14577793f, 0.04543127f, 0.06650913f, -0.06472374f, -0.13981673f, 0.00582836f, 0.16296752f, 
    -0.13837677f, 0.06718101f, 0.20282856f, 0.11507755f, 0.29133031f, 0.24495909f, 0.05726593f, 0.01103450f, 
    -0.12156507f, -0.01052463f, 0.17560848f, -0.15663546f, 0.17657851f, 0.26597842f, 0.03230763f, 0.02044339f, 
    -0.03480547f, 0.23265722f, 0.35019274f, 0.10533662f, 0.13559156f, 0.10014655f, -0.03215463f, 0.29864372f, 
    0.12633656f, 0.28059351f, 0.13872421f, 0.22572220f, 0.15222006f, -0.01028879f, 0.29857573f, 0.28040307f, 
    0.31617457f, 0.40125585f, 0.23715059f, 0.27127973f, 0.16793641f, 0.19802137f, 0.20796644f, 0.05217711f, 
    0.10616342f, -0.09336498f, -0.07002814f, -0.03667465f, -0.05190604f, -0.06496378f, -0.20580576f, 0.03174327f, 
    0.04051006f, -0.02520940f, 0.15687870f, -0.01198872f, -0.01464314f, -0.30224999f, -0.28932531f, -0.21342266f, 
    0.08049503f, -0.05880542f, 0.20741548f, -0.10424360f, -0.09030882f, 0.16225184f, -0.06815022f, 0.58770680f, 
    0.14706676f, 0.17843994f, -0.03011707f, -0.30162696f, -0.47351958f, -0.21940325f, -0.14189667f, 0.22477702f, 
    -0.18003299f, -0.00221876f, 0.07384071f, 0.14012804f, -0.02650337f, 0.25476587f, 0.33256141f, 0.30617574f, 
    -0.19920342f, -0.07315213f, 0.31150234f, 0.14190314f, 0.13263554f, -0.13559042f, 0.01863798f, -0.16184971f, 
    0.13812586f, 0.17655681f, 0.12246800f, 0.02410482f, 0.05284637f, 0.03953466f, -0.07693006f, -0.13771487f, 
    0.10063722f, -0.00975338f, 0.06269524f, -0.03775027f, 0.08091476f, 0.03500598f, -0.04928744f, -0.01683465f, 
    -0.10085284f, -0.21625986f, -0.10667516f, 0.10780146f, -0.12604808f, -0.13490569f, -0.15827190f, -0.05682993f, 
    -0.01319303f, 0.03947221f, 0.25907776f, 0.10289878f, -0.05239832f, -0.06296129f, -0.06030968f, 0.01901738f, 
    -0.20547200f, 0.03258437f, 0.13492411f, -0.04798682f, 0.05372136f, 0.01931216f, 0.16688600f, 0.05664785f, 
    0.08928983f, -0.19827410f, -0.03172637f, -0.07678664f, 0.04721311f, -0.23161469f, 0.07636601f, -0.15834999f, 
    -0.14770968f, -0.35556159f, 0.00977152f, 0.18867121f, 0.15120423f, 0.16900268f, 0.14587660f, 0.01248054f, 
    0.06295104f, 0.00534323f, 0.12458756f, 0.01386443f, 0.17620580f, 0.05416371f, 0.07101463f, -0.15256286f, 
    -0.01383506f, -0.13223927f, 0.00777538f, 0.11754042f, -0.22623541f, -0.31533725f, -0.07984423f, -0.16999723f, 
    -0.18890613f, -0.29820558f, -0.10772624f, -0.08466609f, -0.03932918f, -0.10045551f, -0.12953837f, 0.02296609f, 
    0.06449757f, -0.28493967f, 0.00462176f, 0.03106942f, -0.16574934f, -0.41868376f, 0.07959891f, -0.10958500f, 
    -0.04404388f, -0.02177321f, -0.08444610f, -0.12894420f, -0.15998213f, -0.11479037f, -0.01427632f, -0.14058319f, 
    0.19932142f, -0.05527818f, 0.22075126f, 0.19342020f, 0.10489616f, -0.02660045f, -0.24123161f, -0.12626402f, 
    -0.30900720f, -0.01884698f, -0.20470397f, -0.16884102f, 0.18193956f, 0.19066943f, -0.07826598f, -0.11134766f, 
    -0.09467445f, -0.05052913f, -0.12350710f, -0.06305956f, -0.11816493f, -0.05633037f, 0.11070377f, -0.23931776f, 
    -0.20081797f, -0.26371062f, -0.13603503f, -0.00303797f, -0.16964025f, -0.24890714f, -0.14841395f, 0.00285252f, 
    -0.07014939f, -0.09124842f, 0.06901787f, -0.25513621f, 0.09688452f, -0.07712384f, -0.38334028f, -0.04912661f, 
    -0.22878539f, -0.26697088f, -0.00142028f, 0.00739253f, -0.05062809f, -0.10692218f, -0.32191808f, -0.08876135f, 
    0.08660438f, -0.21466161f, -0.07821247f, -0.09272168f, 0.11196922f, -0.04086067f, 0.08808190f, -0.02043860f, 
    0.07548506f, -0.06095794f, -0.15404304f, -0.11816819f, -0.08827346f, -0.14015592f, -0.09794215f, 0.00426394f, 
    0.11898032f, -0.00735035f, 0.05875242f, 0.12597640f, -0.17857654f, 0.20721444f, -0.07056751f, 0.17737853f, 
    0.18251155f, 0.14891785f, -0.06349992f, 0.56005992f, 0.04571260f, 0.33870861f, 0.20793978f, 0.37822329f, 
    0.15431591f, 0.26058355f, 0.01080931f, 0.32134039f, 0.03384523f, 0.21380302f, 0.17053709f, 0.45699531f, 
    0.36446715f, 0.16459384f, 0.02445898f, 0.21909708f, 0.03991895f, 0.18603286f, 0.03968319f, 0.02251309f, 
    -0.11468155f, 0.07336024f, 0.07464423f, -0.29420901f, 0.04671822f, 0.06467387f, 0.08887415f, 0.02650763f, 
    -0.06567183f, -0.15648027f, 0.06536212f, 0.00007140f, -0.00567594f, -0.18283246f, 0.03115910f, -0.10597905f, 
    -0.07793050f, -0.24324527f, -0.15289992f, -0.25803822f, 0.07888266f, -0.03223719f, -0.16092906f, -0.19996437f, 
    -0.08845623f, 0.04327684f, 0.03802253f, -0.30778168f, -0.11989501f, -0.22338065f, 0.03168080f, 0.05416801f, 
    0.15253808f, 0.15927951f, -0.00668654f, -0.04815610f, -0.01542542f, 0.08760707f, 0.15777319f, 0.22995673f, 
    0.15091535f, 0.23435745f, -0.08106016f, -0.01874481f, 0.09799048f, -0.14179477f, 0.19385936f, 0.04740786f, 
    0.01016074f, -0.10793944f, -0.14182037f, -0.00235872f, 0.08967895f, -0.03648200f, -0.00331783f, -0.10998540f, 
    0.08858456f, -0.02257670f, -0.22106255f, -0.22494129f, -0.07299414f, -0.27294240f, -0.12859693f, 0.20050381f, 
    -0.05531570f, -0.09847757f, 0.11642036f, -0.07820827f, 0.22916201f, -0.03824459f, -0.09337682f, -0.06971734f, 
    -0.12568637f, 0.05538090f, -0.04450942f, 0.22010818f, 0.03424350f, -0.21087008f, -0.04444674f, 0.03545102f, 
    -0.16229282f, 0.04095631f, -0.09682557f, -0.16579677f, -0.03946021f, 0.14165926f, -0.22406461f, -0.17688499f, 
    -0.06685660f, -0.01166149f, -0.22194309f, -0.17401874f, -0.16497937f, 0.20565453f, -0.10586409f, 0.25223600f, 
    0.09199659f, 0.17543292f, -0.01623723f, -0.07397986f, -0.19591988f, 0.18731459f, 0.03529236f, -0.08517265f, 
    -0.05068370f, 0.15406433f, -0.05497095f, 0.09205174f, 0.14801971f, -0.04919921f, -0.03187462f, 0.15460068f, 
    0.04782114f, 0.17662468f, 0.22540722f, -0.14218022f, -0.07359188f, 0.08035466f, 0.05439166f, 0.01173488f, 
    -0.15485474f, 0.00089666f, 0.06067537f, -0.04661089f, 0.00003812f, -0.00662254f, -0.03725936f, 0.09485962f, 
    0.13446129f, 0.00060119f, 0.13601824f, 0.02576555f, -0.08322212f, -0.11868636f, -0.03128556f, 0.06866738f, 
    0.01661071f, -0.12067275f, -0.09707862f, -0.18203316f, -0.22233522f, -0.01746824f, 0.23231470f, -0.07421397f, 
    0.05839087f, 0.21620137f, 0.10099209f, -0.10681272f, -0.05122139f, -0.01962549f, 0.01858239f, 0.11375756f, 
    0.16665649f, -0.06283847f, -0.07044588f, 0.00561583f, 0.00805823f, 0.12964574f, 0.07402844f, -0.12187463f, 
    -0.08595509f, 0.00639921f, -0.08476781f, 0.07132530f, -0.09170646f, -0.03990815f, -0.06196568f, -0.01757463f, 
    -0.12045423f, -0.13505381f, -0.08659827f, -0.08468765f, -0.22342286f, -0.13225615f, 0.07241551f, -0.02547415f, 
    0.16037387f, 0.11622165f, -0.16581493f, 0.10639278f, -0.12543719f, -0.01579049f, -0.20301608f, -0.02258089f, 
    -0.03926143f, -0.15779600f, -0.17189864f, 0.13157768f, -0.19994518f, 0.05684749f, 0.20150253f, -0.17669747f, 
    0.20610723f, 0.20581049f, -0.16122796f, -0.00696204f, 0.07645763f, -0.01340207f, 0.26534894f, -0.12527662f, 
    -0.02020060f, -0.11888061f, -0.05109975f, -0.15962716f, 0.06367245f, -0.07772496f, 0.16333349f, 0.22830443f, 
    0.12976588f, 0.01021269f, 0.03914238f, 0.03618129f, -0.09060144f, 0.05988375f, 0.22984167f, -0.17887913f, 
    0.18273811f, 0.15162121f, -0.01497667f, 0.10802419f, -0.02808522f, 0.05832371f, 0.10229506f, 0.14178152f, 
    -0.06508058f, 0.23126789f, -0.02026319f, 0.06014781f, 0.01187483f, 0.06894784f, 0.09340917f, 0.02561082f, 
    0.04685620f, -0.13397203f, -0.05227213f, 0.13713064f, 0.03599829f, -0.10118516f, -0.00614364f, -0.07311838f, 
    -0.05041039f, 0.02913393f, -0.09759240f, 0.22923336f, -0.19833790f, -0.20400149f, -0.08845591f, -0.10814255f, 
    -0.17809737f, -0.01258576f, -0.03737009f, 0.02195142f, -0.05643788f, 0.12479680f, -0.13018559f, 0.10004855f, 
    0.22650912f, -0.06381281f, 0.09131776f, 0.07745694f, 0.03479307f, 0.29724876f, 0.01507072f, 0.13199285f, 
    -0.16555079f, 0.10803069f, 0.25945847f, -0.10700624f, -0.04924166f, -0.06243162f, -0.14597727f, -0.14852637f, 
    0.02663015f, 0.10284581f, 0.07608469f, -0.05151840f, 0.01219266f, 0.01557695f, 0.06802242f, 0.00624599f, 
    -0.11748469f, 0.14127545f, -0.04281697f, -0.20018547f, -0.03579053f, 0.05772537f, 0.08205293f, -0.29734251f, 
    -0.08466124f, 0.00364606f, -0.02745423f, -0.15684299f, -0.09106211f, -0.10382062f, 0.22752264f, 0.08379111f, 
    -0.10673343f, -0.02243199f, -0.10925383f, -0.17321151f, 0.18798152f, -0.13201181f, -0.00852957f, 0.03322939f, 
    0.05522058f, 0.17184508f, -0.14163554f, 0.05545492f, 0.10511975f, 0.10064071f, -0.08138565f, -0.05790467f, 
    -0.16906533f, 0.17450183f, -0.32924186f, 0.11729435f, -0.05564792f, -0.19658477f, -0.07233367f, -0.35290926f, 
    -0.14398902f, -0.21266698f, -0.31669765f, -0.22200906f, -0.24539503f, -0.26859479f, -0.35372103f, -0.27309709f, 
    -0.15634969f, 0.02404025f, -0.17092120f, -0.16441057f, 0.09027415f, -0.06756080f, -0.15908018f, 0.06624731f, 
    0.35065975f, 0.07671595f, 0.09927473f, 0.11198919f, -0.00872321f, 0.11902166f, -0.16206636f, 0.22859824f, 
    0.18477288f, -0.06479797f, 0.17259321f, 0.18215717f, 0.12590378f, 0.17807135f, 0.10718675f, 0.31949784f, 
    0.39257093f, 0.15594594f, 0.17594934f, 0.11098195f, 0.01827644f, 0.17647982f, 0.09764881f, 0.04073838f, 
    0.14393662f, 0.14003637f, -0.03414392f, 0.11199057f, 0.19165034f, 0.15140351f, 0.01837385f, 0.22885821f, 
    0.13014404f, -0.07349302f, 0.18810659f, 0.19650765f, 0.10437635f, -0.03944609f, -0.07382501f, -0.20734293f, 
    -0.11715015f, -0.24503774f, 0.00282409f, -0.00553186f, 0.17767740f, -0.20437236f, 0.11951342f, 0.06928223f, 
    -0.01774513f, -0.00796085f, -0.06803123f, -0.10677872f, 0.15206752f, -0.03762311f, 0.00367381f, -0.01349034f, 
    0.02560039f, 0.11775735f, -0.03600355f, -0.09514880f, -0.33405791f, -0.04747381f, -0.04382619f, -0.02467713f, 
    -0.06484789f, -0.04693027f, 0.11434676f, -0.00972348f, 0.08564595f, -0.27416057f, 0.04048288f, 0.10669873f, 
    -0.07566808f, -0.10415105f, -0.01601824f, -0.09053490f, 0.03328426f, 0.14923524f, 0.03240315f, 0.18062114f, 
    -0.07974681f, -0.05069632f, 0.07551281f, -0.07615418f, -0.09794890f, -0.04243129f, -0.06693056f, 0.15591831f, 
    -0.03401418f, -0.03979001f, -0.09495287f, -0.02717059f, -0.05767525f, 0.09149722f, 0.17952369f, 0.09077834f, 
    -0.15301695f, 0.02105770f, -0.00236164f, 0.13263596f, -0.09539330f, -0.19868928f, -0.05238290f, -0.11553479f, 
    -0.01250901f, 0.14781864f, 0.09713923f, -0.06783381f, 0.00514249f, 0.00165726f, -0.03631068f, 0.15278017f, 
    0.09633495f, -0.02059161f, -0.16083989f, -0.05943726f, -0.04705570f, 0.00329571f, 0.03339035f, 0.11785072f, 
    -0.09973206f, -0.02261888f, -0.16451133f, -0.09901656f, 0.01799661f, -0.08511825f, 0.08709027f, 0.09467952f, 
    -0.20492687f, 0.04198530f, -0.00649410f, 0.01447117f, 0.05148123f, -0.03345618f, -0.06734284f, 0.13550133f, 
    -0.00183233f, -0.23759159f, -0.02920875f, -0.09823877f, -0.07401875f, 0.14787164f, 0.06010279f, -0.02420244f, 
    -0.16017382f, 0.01148857f, -0.01604683f, 0.00054778f, -0.13539156f, 0.14075796f, 0.10430431f, 0.10468411f, 
    -0.03209260f, 0.00608209f, -0.17692072f, 0.08383724f, 0.15378957f, -0.11818418f, 0.06279179f, 0.05453374f, 
    0.01320011f, -0.05166322f, 0.02567100f, -0.00029222f, 0.12126528f, -0.00026612f, -0.06790381f, 0.15599569f, 
    0.01038388f, -0.03560472f, 0.07461902f, -0.03974396f, 0.06357176f, -0.00321188f, 0.14799704f, -0.05788895f, 
    0.09570407f, -0.07477870f, -0.10102325f, 0.06047915f, -0.07483050f, 0.04889767f, 0.02313154f, 0.10500324f, 
    0.06728326f, -0.04875005f, -0.10313704f, 0.06614735f, 0.08017469f, 0.04740484f, -0.17084377f, 0.00109790f, 
    -0.02876859f, 0.08358184f, 0.06616412f, 0.03462522f, -0.08214931f, 0.09739330f, -0.04406069f, 0.14854957f, 
    -0.04213819f, -0.20555523f, -0.10972790f, 0.12647771f, 0.07938414f, -0.05057027f, 0.02440946f, 0.08199241f, 
    0.14578425f, 0.20450639f, 0.25632743f, -0.25959600f, -0.17759273f, 0.05809766f, -0.01220071f, -0.18524897f, 
    0.01967424f, 0.18833186f, 0.19136586f, 0.12116861f, -0.01732070f, 0.01185559f, -0.10222421f, 0.07772013f, 
    0.05898976f, 0.10272340f, 0.00024708f, -0.23959883f, -0.15031296f, -0.19207907f, 0.23646815f, -0.08762229f, 
    -0.40294447f, -0.26896836f, -0.00623285f, 0.04315145f, 0.32904866f, 0.21181092f, 0.30323402f, 0.33185946f, 
    0.19060374f, 0.19691851f, 0.23530889f, 0.31598688f, 0.06809766f, 0.12437297f, 0.08921543f, 0.17038095f, 
    0.37354917f, 0.15436122f, 0.05807290f, 0.14553329f, -0.11577561f, -0.10000993f, 0.06686722f, 0.10276069f, 
    0.23106618f, -0.06681058f, 0.04427997f, 0.07373055f, -0.06272951f, 0.28054484f, -0.04251811f, -0.13254685f, 
    -0.07406361f, -0.08844452f, 0.00786288f, 0.04795752f, 0.02283904f, -0.10159687f, 0.04114272f, -0.25625318f, 
    -0.04806005f, -0.22278361f, -0.16929884f, -0.29866614f, -0.32144868f, -0.13579253f, -0.29652167f, -0.14636404f, 
    -0.15110261f, -0.06387017f, -0.23691280f, -0.18689260f, -0.28837582f, -0.26236302f, -0.25019279f, -0.20282799f, 
    -0.21123565f, 0.24969058f, -0.19727670f, 0.12819520f, -0.15393881f, -0.13919571f, -0.11544866f, -0.07453272f, 
    0.00612427f, -0.07579530f, 0.15938001f, 0.16105482f, -0.16109351f, 0.11056813f, 0.00849016f, 0.02735084f, 
    0.04665097f, -0.02271834f, 0.11076096f, 0.19235029f, -0.14108555f, 0.43392463f, -0.12402277f, 0.06902055f, 
    -0.01132704f, 0.10476732f, -0.13699557f, -0.16753633f, -0.00360439f, 0.01600228f, -0.09949616f, 0.11212584f, 
    0.14073164f, -0.25011277f, 0.03849361f, 0.12859206f, -0.02099271f, -0.18763660f, -0.05492527f, 0.18938525f, 
    -0.09026755f, 0.02276161f, 0.07632090f, -0.17321469f, -0.12511305f, 0.06544754f, -0.14952671f, 0.01761268f, 
    0.04881623f, -0.12012388f, -0.12315997f, 0.07559458f, 0.03557201f, -0.23248899f, 0.07831947f, -0.13348202f, 
    0.04710390f, 0.05208552f, 0.15112602f, -0.29694197f, 0.14990221f, 0.02677540f, 0.02140715f, -0.02469848f, 
    -0.18691983f, -0.16183736f, -0.06882923f, -0.11521831f, -0.17611006f, -0.07212921f, 0.19859510f, 0.01755290f, 
    -0.11136168f, -0.06867554f, 0.14196695f, 0.03015865f, -0.12877760f, 0.09623281f, -0.00314143f, -0.04684507f, 
    0.10703939f, -0.25883880f, 0.15468449f, -0.02377826f, 0.04380022f, 0.03523039f, -0.17803229f, 0.14816189f, 
    -0.29768943f, -0.14954499f, 0.10880898f, 0.04909211f, 0.12791626f, -0.18920215f, -0.17365155f, -0.17376312f, 
    -0.12064661f, -0.24563244f, -0.10902338f, -0.16030211f, -0.17255398f, 0.03300563f, 0.12848330f, -0.18189250f, 
    0.09473358f, 0.10029540f, 0.09878406f, 0.16494191f, 0.03722386f, -0.08819563f, 0.25661990f, 0.27996959f, 
    0.11723650f, 0.00154924f, 0.15597190f, 0.25652641f, 0.15448083f, 0.25883818f, 0.06962640f, 0.08528901f, 
    0.00397914f, 0.34534283f, 0.43958056f, 0.18832317f, 0.15839550f, 0.06824979f, 0.12595807f, 0.18599430f, 
    -0.03465011f, -0.21865935f, 0.34681940f, -0.03932216f, -0.14184560f, 0.26476173f, -0.05672339f, 0.00246786f, 
    0.25064818f, 0.10997159f, -0.01363650f, 0.00270004f, -0.11257585f, -0.12537756f, -0.05671190f, -0.17615095f, 
    0.21407107f, -0.12063091f, -0.13932335f, -0.11752807f, -0.00261496f, -0.05725215f, -0.19627680f, -0.10660835f, 
    0.06316184f, 0.19896934f, 0.01207341f, 0.05052462f, 0.05384316f, -0.04228399f, 0.12872179f, 0.09782218f, 
    -0.22661754f, 0.10823075f, -0.19876396f, 0.04638422f, 0.20493672f, 0.03437501f, 0.12777927f, 0.21362478f, 
    0.22779718f, 0.18216084f, 0.12365890f, 0.22481217f, 0.27301287f, 0.13657490f, 0.23736305f, -0.31695503f, 
    -0.10782998f, -0.06232927f, -0.05662848f, -0.17549037f, -0.01773417f, 0.21493158f, -0.00151620f, -0.04382011f, 
    0.39279862f, 0.15675513f, -0.01793988f, 0.12308612f, 0.15770772f, -0.01149197f, -0.08355260f, -0.01460446f, 
    -0.02202804f, -0.09726342f, -0.02093982f, -0.10833972f, -0.08536129f, -0.08857506f, -0.08493221f, -0.06491342f, 
    -0.42347734f, 0.03203235f, -0.24078104f, -0.16021000f, 0.02517462f, 0.01853825f, -0.13233827f, 0.02789043f, 
    0.11059839f, -0.12595466f, -0.08106746f, 0.11204447f, 0.00371682f, -0.08729958f, -0.09473395f, 0.06632475f, 
    0.14979183f, 0.16966092f, 0.01927372f, 0.27081632f, 0.01678786f, 0.17062928f, -0.00120512f, -0.06796204f, 
    0.07733963f, -0.00659634f, 0.10009558f, -0.13876186f, 0.06674867f, -0.09362089f, -0.18852226f, 0.02625128f, 
    0.01714207f, 0.11065010f, 0.00285533f, -0.00301749f, -0.24027150f, -0.04780996f, 0.06285718f, 0.02144056f, 
    -0.17107040f, -0.06661295f, 0.03085549f, -0.02284562f, -0.21452066f, -0.15969295f, 0.05487125f, 0.17062172f, 
    -0.04825473f, -0.05918339f, -0.07714718f, -0.13049490f, -0.11426645f, 0.06077411f, 0.03335132f, -0.21462842f, 
    -0.30269147f, -0.19983953f, -0.03318438f, -0.08827201f, 0.01420027f, -0.03613780f, 0.03919395f, 0.09954126f, 
    -0.01903402f, -0.18492673f, 0.08357383f, -0.08313705f, 0.00244625f, -0.06958065f, -0.05312576f, 0.15696872f, 
    0.26063942f, 0.03771690f, 0.05150159f, -0.19372988f, 0.07596917f, 0.00321372f, -0.13754083f, -0.13195869f, 
    -0.06220993f, 0.22994240f, 0.00885981f, 0.11372772f, 0.19105623f, -0.23747193f, 0.22548100f, 0.32630330f, 
    -0.21031003f, -0.25400746f, 0.03287891f, 0.18833983f, 0.03773503f, 0.21110330f, 0.18581351f, 0.12514651f, 
    0.18163628f, 0.24799595f, 0.09318702f, 0.28965073f, 0.14031625f, 0.05480988f, 0.37172244f, 0.13806465f, 
    0.01993723f, 0.37383583f, 0.13929187f, 0.08037385f, 0.16247421f, 0.24349522f, 0.13061102f, -0.12095917f, 
    -0.20060706f, 0.13389032f, 0.17396846f, 0.00504769f, 0.27370923f, 0.00263675f, -0.05568321f, 0.19935182f, 
    0.04666987f, 0.01296595f, -0.05607287f, -0.10742295f, 0.03405342f, -0.34247199f, 0.04432305f, -0.04041341f, 
    0.11842051f, -0.08693947f, 0.25357331f, 0.09216712f, -0.17514019f, 0.03375341f, 0.20193710f, -0.18535147f, 
    -0.02202671f, -0.09186379f, -0.07017709f, 0.01286410f, -0.00679680f, -0.06607083f, -0.00915355f, -0.08567530f, 
    0.01235402f, -0.07072729f, 0.03598221f, 0.07731701f, 0.07227092f, -0.24330431f, 0.03087837f, -0.00723567f, 
    -0.00183581f, -0.01836713f, 0.03295727f, -0.07608787f, 0.08336964f, 0.11961096f, 0.17248826f, 0.03276163f, 
    0.12426413f, 0.07903638f, 0.12495846f, -0.12910616f, -0.03800240f, -0.03057884f, -0.20023628f, -0.17128804f, 
    -0.18556688f, 0.19688454f, -0.01531994f, 0.15658056f, -0.22128671f, -0.08227355f, -0.08110451f, -0.10075857f, 
    -0.18143588f, -0.15498375f, -0.12036393f, -0.17618571f, -0.16063433f, 0.08069003f, -0.12184953f, -0.15528603f, 
    -0.16350676f, -0.10237628f, -0.15561318f, -0.07608506f, 0.20867588f, 0.10919369f, 0.01727331f, -0.16491476f, 
    -0.08135920f, -0.08495669f, -0.20869217f, -0.21810073f, -0.08311026f, -0.16223949f, 0.18056187f, 0.32836109f, 
    0.29900483f, -0.03586377f, 0.29940613f, 0.03170187f, 0.01782638f, 0.11805013f, 0.18736151f, 0.23095828f, 
    0.06172606f, 0.11221221f, 0.03341872f, 0.09298741f, 0.54510268f, 0.41624878f, -0.04073236f, 0.15888414f, 
    -0.08471824f, -0.04455960f, 0.15043226f, 0.02422181f, 0.00967214f, 0.04092060f, 0.02335298f, -0.09507559f, 
    0.04927473f, 0.07642631f, 0.11818690f, 0.12800752f, 0.05704398f, 0.15831782f, -0.07889880f, 0.08990038f, 
    0.07806377f, -0.18764520f, -0.18408605f, 0.10982951f, 0.09029924f, 0.09858042f, 0.12281870f, 0.04131490f, 
    0.00418854f, 0.17585513f, 0.07156990f, 0.09694429f, -0.00577405f, 0.00472815f, 0.03207025f, 0.00492099f, 
    -0.10614088f, -0.07743050f, 0.00391678f, -0.17744271f, -0.17777451f, 0.06834333f, -0.25151881f, 0.04772547f, 
    0.02909897f, 0.00520566f, -0.07415940f, 0.06473894f, -0.08847728f, -0.09506815f, 0.11206043f, 0.03744690f, 
    -0.40490832f, 0.03618164f, -0.26447330f, -0.03082167f, 0.08450275f, -0.12124719f, -0.22611754f, 0.17112054f, 
    -0.09246536f, 0.06126338f, -0.03333097f, 0.05109659f, -0.03993861f, -0.03910368f, -0.12332471f, 0.03868554f, 
    0.17671536f, 0.05865836f, -0.10685824f, 0.18637977f, -0.07934931f, 0.01349642f, 0.09151040f, 0.28418709f, 
    -0.01294052f, 0.13799102f, -0.03001132f, 0.29299288f, -0.08131702f, 0.03537211f, 0.04453923f, 0.01681626f, 
    -0.03471437f, 0.07927324f, -0.21559583f, 0.13580965f, -0.00404511f, 0.11849548f, 0.03768846f, 0.06587388f, 
    0.07280741f, -0.03831832f, -0.23092591f, 0.00288112f, -0.15482790f, -0.06707666f, -0.08159828f, -0.06752817f, 
    -0.18046493f, 0.16345849f, 0.00180156f, -0.02011476f, 0.03779791f, -0.04364573f, 0.07976760f, 0.01855494f, 
    -0.12749030f, 0.05072729f, -0.30425825f, -0.13447237f, -0.13973068f, 0.01797710f, -0.06660963f, 0.05581528f, 
    0.30070902f, 0.01447700f, -0.04106582f, 0.12528267f, -0.02387784f, -0.01174980f, 0.08867123f, 0.17302990f, 
    -0.14163221f, 0.01715314f, -0.09007231f, 0.11670929f, 0.10961222f, -0.21774946f, -0.17357959f, 0.05421643f, 
    -0.00266604f, 0.01521748f, -0.10812397f, 0.14914818f, -0.11675277f, 0.03356060f, -0.00565974f, -0.13994949f, 
    0.03876032f, 0.10036056f, -0.04193011f, 0.08161355f, 0.10014202f, -0.03840220f, -0.16176731f, -0.07930385f, 
    -0.17952438f, -0.02313515f, -0.08981572f, -0.07355295f, 0.00908529f, 0.02747486f, -0.01823473f, -0.07334332f, 
    0.14138178f, -0.01829035f, -0.27850040f, -0.01023947f, 0.00530566f, -0.00495771f, -0.07113835f, 0.00418382f, 
    -0.19613929f, -0.02388059f, 0.09266516f, -0.04895304f, 0.02611544f, 0.06230729f, -0.03567544f, -0.21127443f, 
    0.01048497f, 0.00884305f, 0.07870403f, 0.01924861f, -0.02893070f, -0.12408073f, -0.13185187f, -0.14139595f, 
    0.05755982f, 0.10166505f, -0.08227768f, 0.08316280f, 0.15998661f, -0.09261971f, -0.12276135f, 0.07306693f, 
    -0.11901721f, 0.19065168f, -0.08235106f, -0.13484428f, 0.02053939f, 0.03343969f, -0.07984345f, -0.24251249f, 
    0.04947854f, -0.03939655f, 0.06491330f, 0.11876771f, 0.17744989f, 0.14593675f, 0.03538258f, 0.04369710f, 
    -0.12865194f, -0.07564941f, -0.04284191f, 0.16850869f, -0.02941958f, -0.01744419f, -0.11377265f, 0.00876636f, 
    -0.15207792f, 0.08017263f, -0.09140591f, -0.17502876f, -0.05744939f, -0.08838518f, -0.14587443f, 0.01407471f, 
    -0.03733243f, 0.11877333f, -0.16880131f, -0.05259709f, 0.09393528f, -0.13123429f, 0.01603020f, -0.21543951f, 
    -0.01969755f, 0.15855981f, 0.16370247f, 0.08998697f, 0.01107256f, -0.05243788f, 0.10556980f, 0.14814658f, 
    0.09424387f, 0.00166809f, -0.04669997f, 0.03448760f, 0.19045009f, 0.04627606f, 0.02816405f, -0.04358076f, 
    0.11846879f, 0.06194973f, 0.06047363f, 0.06875520f, 0.18560183f, -0.12512321f, -0.05406740f, 0.09738560f, 
    0.06026418f, 0.20511217f, 0.24933468f, 0.15947678f, 0.41038851f, 0.21209389f, 0.16026559f, 0.17060919f, 
    0.35997251f, 0.07727965f, 0.27166319f, 0.08850459f, 0.27546126f, 0.21442598f, 0.22188892f, 0.37338203f, 
    0.14997234f, 0.07691328f, 0.26270803f, 0.16971942f, -0.30602461f, -0.24571820f, -0.18658516f, 0.19260450f, 
    -0.19542321f, -0.17720145f, -0.24540676f, -0.44268078f, -0.14264134f, -0.25032389f, -0.20581604f, 0.04179403f, 
    -0.25800630f, 0.09136841f, -0.07662402f, -0.14767915f, -0.18017561f, -0.47473540f, 0.05330931f, -0.07381090f, 
    -0.28331343f, 0.01655709f, 0.10338691f, -0.05135780f, 0.10565424f, -0.16892126f, 0.09128486f, 0.18820325f, 
    0.06353737f, -0.10386574f, 0.03131696f, 0.00219896f, -0.02169557f, -0.13184665f, 0.04897240f, 0.05245560f, 
    0.02803997f, -0.00996615f, -0.07557804f, 0.04315413f, 0.06858079f, 0.29748273f, -0.05089199f, -0.12443611f, 
    0.00844185f, -0.12906651f, -0.04809839f, 0.05812061f, -0.17918643f, 0.07316306f, 0.04259358f, 0.10851095f, 
    0.01163374f, -0.13126417f, 0.10671882f, -0.10102383f, -0.03090980f, -0.26212084f, -0.11950612f, -0.06666210f, 
    -0.24425910f, -0.11981978f, -0.06046136f, -0.19356678f, -0.22379208f, 0.16461962f, -0.25441194f, -0.14262523f, 
    -0.29246606f, -0.04944671f, -0.09680960f, -0.25320778f, -0.24438103f, -0.26460590f, -0.17701425f, 0.04145263f, 
    -0.25591087f, 0.00137172f, -0.20445830f, -0.23655761f, 0.24418683f, 0.15844546f, -0.15140190f, -0.29664765f, 
    0.01013709f, 0.01652452f, -0.25401151f, -0.33730459f, -0.27438229f, -0.08398647f, 0.17876897f, 0.11849852f, 
    0.22456809f, 0.02460594f, 0.10269343f, 0.30708574f, 0.08791649f, 0.00557196f, 0.15681838f, 0.03793068f, 
    0.26114428f, 0.02087716f, 0.17023441f, 0.28873735f, 0.34675274f, 0.27929744f, 0.19958037f, 0.21973764f, 
    -0.00699809f, 0.00372578f, 0.05891146f, 0.06058059f, -0.07416610f, -0.19808611f, 0.07298279f, 0.17334948f, 
    0.05488614f, 0.20489744f, -0.14912667f, 0.00383547f, 0.05474754f, -0.02753055f, 0.13299312f, 0.05969727f, 
    -0.06018775f, 0.00303720f, -0.03314743f, -0.04566031f, 0.11394235f, -0.16658417f, 0.16476523f, -0.01574905f, 
    -0.15517775f, -0.03982974f, 0.04218998f, 0.03188111f, -0.12765335f, 0.00211646f, 0.13184851f, 0.03421052f, 
    0.11610608f, 0.09662772f, 0.17960621f, 0.10652396f, 0.02309941f, -0.09338288f, -0.01152447f, -0.10063081f, 
    0.00703932f, 0.02567268f, -0.08500059f, -0.01992751f, -0.07204332f, 0.11835910f, 0.10864657f, 0.14038432f, 
    0.02987423f, 0.02853625f, 0.00165590f, -0.10808224f, -0.05275694f, 0.00117004f, 0.01413559f, 0.06940800f, 
    -0.03660984f, -0.27777824f, 0.04290057f, 0.15858914f, -0.14943388f, 0.05618116f, -0.01543969f, 0.04815202f, 
    0.00496748f, 0.07575268f, 0.02917674f, -0.10052518f, -0.09665829f, -0.01052882f, -0.06917801f, -0.05700232f, 
    0.10763893f, 0.00311820f, 0.12007110f, 0.07148045f, -0.10871682f, -0.25377800f, 0.01010325f, -0.01910247f, 
    -0.12473810f, 0.01879052f, -0.10139716f, -0.04434935f, 0.02905154f, 0.18880046f, 0.15286640f, 0.00243437f, 
    -0.07378545f, -0.19149445f, 0.21487953f, 0.00521199f, 0.05608755f, -0.00328551f, -0.09821064f, -0.09479009f, 
    -0.00419198f, 0.10694938f, -0.02905532f, -0.17238943f, -0.02963480f, -0.04370352f, -0.00593708f, 0.10163905f, 
    0.09341085f, -0.00832022f, 0.00347358f, 0.13314913f, 0.11757067f, 0.11398473f, 0.01137440f, 0.06298527f, 
    0.18790863f, 0.01544146f, -0.01018026f, 0.04876671f, -0.04715074f, 0.05308813f, -0.08220970f, -0.07001104f, 
    -0.09569498f, 0.00094651f, -0.15723347f, 0.09578086f, 0.10237589f, -0.04742549f, 0.15051183f, 0.10872028f, 
    -0.08406046f, -0.00859291f, 0.08932777f, 0.00109119f, -0.09514575f, -0.15159745f, -0.23086238f, -0.18284223f, 
    -0.13640737f, -0.14182099f, -0.08260088f, -0.10762475f, -0.09961106f, -0.17253187f, 0.05674279f, -0.24982641f, 
    -0.07040533f, -0.16553272f, -0.00252222f, -0.02565685f, -0.35916578f, -0.11478477f, 0.11635100f, -0.05356992f, 
    -0.27656609f, -0.07598965f, -0.17679096f, -0.06802666f, -0.00731619f, 0.11583862f, -0.05673264f, -0.11328741f, 
    -0.30100575f, 0.13950738f, 0.13208302f, 0.10095625f, 0.13503421f, 0.12605699f, -0.29787661f, -0.04228128f, 
    0.19209176f, -0.39014957f, -0.10804461f, 0.40929708f, -0.18126403f, 0.09013450f, -0.01469643f, 0.03137346f, 
    -0.19457545f, -0.18220347f, -0.17408442f, -0.20590689f, 0.07445259f, -0.13286918f, -0.15128496f, 0.09139137f, 
    0.11028673f, -0.16512884f, -0.33240174f, -0.10938420f, -0.00789208f, -0.09462508f, -0.04448140f, 0.22072747f, 
    0.12647415f, -0.01918769f, 0.15081020f, 0.02765845f, -0.25266835f, -0.21002364f, -0.26557290f, 0.12392455f, 
    -0.06286463f, 0.02667649f, 0.21804471f, 0.05521464f, 0.12612144f, 0.26088963f, -0.03027133f, 0.24693173f, 
    0.25098596f, 0.12295262f, 0.15173800f, 0.11386110f, 0.15539470f, 0.14846087f, 0.11620039f, -0.13601938f, 
    0.02578686f, 0.13603800f, 0.23366444f, 0.42225278f, 0.30527619f, 0.29100214f, 0.04803924f, 0.18279340f, 
    0.00428872f, 0.09775626f, -0.02800958f, 0.13810350f, 0.05152191f, -0.09521747f, 0.06376859f, 0.18040085f, 
    0.16884327f, 0.12460329f, -0.05860205f, -0.08952591f, 0.03424256f, -0.24087146f, -0.04079846f, -0.01977278f, 
    -0.03473115f, -0.15791989f, -0.21994851f, -0.25568248f, 0.19732591f, -0.03535095f, -0.00042766f, -0.15111015f, 
    -0.17911277f, -0.21943492f, -0.28923246f, -0.00161879f, 0.13671666f, -0.00587848f, 0.01490313f, 0.18259459f, 
    0.03699650f, -0.15814664f, 0.13457640f, 0.07888587f, 0.10149528f, -0.02336977f, 0.10743748f, 0.11174220f, 
    -0.09816961f, 0.29776439f, 0.12821414f, -0.06440513f, 0.12703360f, 0.02750465f, -0.00783705f, 0.10227907f, 
    0.10379584f, 0.22039130f, -0.06303548f, -0.07646629f, -0.30474598f, 0.04758124f, -0.09321840f, 0.07972770f, 
    0.15717785f, -0.16193650f, -0.26868981f, 0.19351924f, 0.10413416f, 0.13759346f, 0.02841547f, -0.16263986f, 
    -0.02348653f, -0.03073195f, -0.23476061f, -0.03344657f, -0.03924406f, -0.08018794f, -0.04944540f, 0.21468011f, 
    0.19516235f, 0.03341886f, -0.02199611f, -0.01634667f, 0.08747282f, -0.09068740f, -0.11508753f, 0.09247436f, 
    0.07095476f, 0.10777133f, 0.02840065f, 0.11026137f, -0.03154388f, 0.13162865f, 0.11188240f, 0.07813747f, 
    -0.08955657f, -0.22734112f, 0.10700041f, -0.18875243f, -0.00056945f, 0.15224456f, 0.13333899f, -0.19612159f, 
    0.09316144f, 0.21472563f, -0.18584113f, 0.04857554f, 0.03661716f, 0.22210994f, 0.24957139f, -0.02709110f, 
    -0.15611548f, -0.03504408f, -0.14180951f, -0.12358083f, -0.04751360f, -0.23292523f, 0.11124230f, 0.04886868f, 
    -0.24931014f, -0.20933096f, -0.09005189f, 0.16934931f, -0.13084260f, -0.13210240f, 0.09245176f, -0.04666148f, 
    -0.09070767f, 0.01000288f, -0.08356464f, 0.02923223f, -0.09553913f, 0.00167823f, -0.00808693f, 0.11609739f, 
    0.19749489f, -0.02255895f, -0.08857323f, -0.18063923f, -0.07041846f, -0.10600319f, 0.04746977f, 0.02399441f, 
    -0.01992436f, -0.18910348f, 0.28707836f, 0.19408168f, -0.00692886f, 0.17398992f, 0.17151837f, 0.00354121f, 
    0.01716571f, -0.19818854f, 0.18684375f, 0.22090984f, 0.09786939f, -0.07682860f, 0.22105064f, 0.04714726f, 
    0.12249503f, 0.28341350f, 0.01026240f, 0.12523256f, 0.21821902f, 0.02687633f, -0.08360400f, -0.04703252f, 
    -0.07872114f, -0.16104104f, 0.02156630f, 0.03131559f, -0.14979111f, 0.17037433f, 0.07258702f, 0.06790834f, 
    0.04837352f, -0.12948721f, 0.05730002f, 0.00980143f, -0.30345929f, -0.21855524f, -0.13361381f, 0.06640632f, 
    0.08127686f, 0.05590064f, -0.04825067f, -0.18744310f, -0.02680300f, 0.08740687f, 0.11239854f, -0.17309322f, 
    -0.25556026f, -0.02214172f, -0.04541882f, -0.21547440f, -0.17865191f, -0.09241859f, 0.19529425f, 0.01078690f, 
    0.17282148f, -0.00922036f, -0.11634867f, -0.06918415f, 0.33408514f, -0.10679129f, 0.01996595f, 0.05449616f, 
    0.13492577f, -0.00861881f, 0.21114783f, -0.19777540f, -0.14860812f, -0.11166453f, -0.09792061f, 0.00387718f, 
    0.01612042f, -0.05209188f, -0.06543517f, -0.05607818f, 0.07207037f, 0.01784181f, -0.14986081f, 0.07250472f, 
    -0.01442917f, 0.10098224f, 0.13005459f, 0.14146053f, 0.21819058f, 0.23788566f, 0.16086229f, -0.11240098f, 
    -0.04711618f, 0.00514495f, 0.09794545f, -0.12060303f, -0.09252922f, -0.04198943f, -0.12250050f, 0.02240364f, 
    0.00679973f, -0.17018045f, -0.15102052f, 0.02092209f, -0.26362269f, -0.08685806f, -0.03630174f, 0.06106649f, 
    -0.09002623f, -0.08273833f, -0.20805186f, -0.00999109f, 0.06363498f, 0.00460527f, -0.01764060f, -0.17525787f, 
    -0.03516635f, -0.06315843f, -0.07619159f, -0.13138929f, 0.19475912f, -0.21675349f, -0.17348642f, -0.12806986f, 
    -0.17741240f, -0.11437788f, 0.06505053f, 0.12895882f, -0.13619676f, -0.10242815f, 0.07267013f, 0.06211718f, 
    0.12741047f, -0.04956499f, 0.05276827f, 0.11502898f, 0.04306167f, -0.07555866f, 0.06030946f, 0.06844599f, 
    0.08416178f, 0.05430713f, 0.04301148f, -0.01755026f, -0.09635484f, 0.07475679f, -0.14459186f, 0.15945053f, 
    0.22796941f, -0.38866759f, 0.01437385f, 0.30585999f, 0.04499070f, -0.12231729f, 0.09415981f, 0.11029487f, 
    0.10520417f, 0.14300472f, -0.05800660f, 0.05466083f, -0.22092180f, -0.06385126f, -0.06301541f, -0.12537074f, 
    -0.04791093f, -0.37475586f, 0.18839971f, 0.17254689f, 0.08387380f, -0.08706832f, -0.13025964f, 0.18208053f, 
    0.33421674f, 0.17285248f, -0.01951335f, 0.23034363f, -0.02815619f, -0.01007570f, 0.23072985f, -0.14227048f, 
    0.00548991f, 0.13508863f, -0.01028907f, 0.05218747f, 0.29850686f, 0.37448994f, 0.05755425f, -0.21258311f, 
    0.20151214f, 0.17012856f, -0.11547888f, 0.02488986f, 0.19789845f, 0.21234246f, 0.04636034f, 0.00038946f, 
    0.06068690f, 0.16027286f, 0.11689794f, 0.25665019f, -0.03728188f, 0.08665710f, -0.01603661f, 0.25719178f, 
    0.40424957f, -0.00280564f, 0.04426728f, -0.10905249f, -0.03335264f, 0.11672878f, 0.00563587f, 0.06961103f, 
    0.11302736f, 0.22353280f, -0.13369418f, -0.10056133f, 0.09700116f, -0.01212446f, -0.26355794f, 0.08721580f, 
    -0.33107706f, -0.02262316f, -0.31753237f, 0.20959003f, 0.08720859f, 0.09711532f, -0.12979523f, -0.10061625f, 
    -0.00231169f, -0.10483040f, -0.02325430f, 0.09520205f, 0.07376222f, 0.05600833f, -0.14233000f, -0.02912011f, 
    -0.06702731f, -0.10054535f, 0.10838529f, -0.05717727f, -0.24617474f, -0.24921499f, 0.11005166f, -0.09447373f, 
    0.19897668f, -0.07963777f, 0.48867509f, 0.02697022f, -0.05209099f, -0.14477117f, 0.01282869f, 0.03435586f, 
    -0.04856165f, 0.10376530f, 0.22054361f, -0.13870426f, -0.17705536f, -0.10066398f, -0.08367983f, -0.05242402f, 
    -0.10697774f, 0.06608340f, 0.12901322f, 0.12974624f, 0.04927001f, -0.00760046f, 0.16601331f, -0.18963471f, 
    -0.06023626f, 0.20133485f, 0.41652905f, -0.10137958f, 0.36338742f, 0.33132214f, -0.01175620f, -0.05595131f, 
    -0.16766942f, 0.10532038f, 0.07791604f, 0.06264048f, -0.17454607f, 0.10872602f, 0.13925294f, 0.06494375f, 
    -0.07213645f, -0.01089862f, -0.12633328f, -0.19944051f, -0.09484731f, 0.07401241f, -0.01770840f, -0.14940870f, 
    0.03135982f, 0.32010844f, 0.17290786f, -0.10785743f, 0.01379834f, 0.28132689f, 0.07863602f, 0.08207861f, 
    -0.06359996f, 0.14586958f, -0.01328833f, 0.07332162f, 0.12986153f, -0.26583186f, 0.04529524f, -0.07064905f, 
    0.02546083f, 0.00747366f, 0.26781152f, 0.06893351f, 0.03467305f, 0.05595804f, 0.12963548f, -0.04066000f, 
    0.05393245f, -0.06893979f, 0.10210132f, -0.03914862f, 0.08580767f, 0.00640010f, 0.04192142f, -0.00746862f, 
    -0.11281739f, 0.07876487f, 0.07555359f, 0.04220614f, 0.12241110f, 0.10900459f, -0.11529368f, 0.16569514f, 
    0.35090782f, 0.10731879f, 0.06623303f, 0.06386586f, 0.14651595f, 0.04263786f, 0.21652612f, 0.15078091f, 
    0.23739346f, -0.09729563f, 0.18102566f, -0.11885113f, 0.15171295f, -0.10525153f, 0.18084597f, -0.09207214f, 
    -0.15514242f, 0.11911499f, 0.24299764f, 0.03736606f, -0.26604439f, -0.06771522f, -0.00660855f, 0.06448982f, 
    -0.11201129f, 0.04133673f, -0.09046461f, 0.17182626f, -0.01244849f, -0.07222036f, 0.09794064f, -0.01103449f, 
    0.09620976f, -0.18847828f, 0.10487868f, 0.17437815f, 0.22727314f, -0.09400889f, 0.07635241f, 0.05756402f, 
    0.27890508f, -0.04442520f, -0.04058321f, -0.13934834f, -0.02230901f, 0.32853476f, -0.00444641f, 0.17427512f, 
    -0.03189045f, 0.06861140f, 0.00382072f, -0.02162093f, -0.14849569f, -0.13989887f, 0.09263688f, -0.08170720f, 
    -0.20797479f, 0.07009741f, -0.15787258f, -0.05906688f, 0.06082188f, -0.12355709f, -0.02371030f, -0.01141517f, 
    -0.01257792f, -0.04891489f, 0.08402548f, -0.02908582f, -0.10005785f, -0.09536330f, -0.05806161f, -0.07423352f, 
    -0.10906852f, -0.03498917f, -0.03152370f, -0.14416221f, -0.16186593f, -0.10528019f, 0.00903709f, -0.11192569f, 
    -0.02146912f, 0.02868163f, 0.05476788f, 0.09197069f, -0.01049638f, 0.10517610f, -0.14162192f, 0.08659495f, 
    0.08232282f, 0.04894128f, -0.06420662f, -0.05833431f, -0.07928617f, -0.27607927f, -0.08696506f, -0.12435175f, 
    -0.06008746f, 0.03570391f, 0.09052273f, -0.07840534f, -0.18559333f, -0.00037801f, -0.17438472f, -0.04257409f, 
    0.20394649f, -0.26378105f, -0.13273580f, 0.08381908f, 0.07103370f, 0.01304645f, 0.10264960f, -0.18796035f, 
    -0.08333313f, -0.00914725f, 0.08603367f, 0.10325774f, -0.02723211f, -0.00094207f, 0.14641245f, 0.14197431f, 
    -0.13307081f, 0.02297717f, -0.00081947f, -0.17916138f, -0.05177057f, 0.02148825f, 0.21535925f, -0.18194878f, 
    0.15403444f, 0.17698900f, 0.23975921f, -0.05799103f, 0.01162655f, 0.11075826f, 0.18370791f, 0.18749821f, 
    0.08487791f, 0.14932029f, 0.04402478f, 0.07507843f, -0.03299213f, 0.04223716f, 0.14738837f, -0.02508980f, 
    0.01173456f, 0.13612604f, 0.01240464f, -0.00117061f, 0.08908970f, 0.08187626f, -0.11515985f, 0.18666491f, 
    0.03037881f, 0.12535898f, 0.09983359f, 0.20409715f, 0.03713762f, 0.01806535f, 0.01646617f, 0.04902612f, 
    0.08002274f, 0.37418728f, -0.06525680f, -0.06659290f, -0.17193919f, 0.15825584f, -0.13893658f, 0.10190209f, 
    -0.03250352f, 0.17006297f, 0.03710589f, 0.04835959f, 0.06912088f, -0.02799881f, -0.01349377f, -0.04918196f, 
    0.10672356f, -0.02856811f, -0.09040368f, 0.12960587f, -0.00130569f, -0.00972517f, -0.02473256f, 0.13362307f, 
    0.15429412f, 0.15571332f, 0.02371958f, 0.04558845f, 0.18649750f, 0.21683769f, 0.08475501f, -0.22219279f, 
    0.02536962f, 0.29797205f, 0.06352993f, -0.02241992f, -0.09927447f, -0.00128672f, -0.08635934f, 0.06284053f, 
    0.13864319f, 0.07332808f, -0.25192445f, 0.08391179f, -0.09339685f, -0.21557862f, 0.19685443f, -0.07517829f, 
    -0.02110593f, 0.34510078f, 0.29442036f, 0.00393057f, 0.13228573f, 0.03257250f, -0.16212693f, 0.09612121f, 
    0.48753091f, 0.23407142f, -0.08725685f, 0.16999809f, 0.13318817f, 0.17870492f, 0.11458718f, 0.10218850f, 
    -0.18728661f, -0.16115671f, 0.12137524f, 0.02793704f, -0.20271255f, 0.07735475f, -0.05556538f, 0.00401660f, 
    0.20742200f, 0.12402201f, 0.26016504f, -0.18272236f, 0.18418272f, 0.28818238f, 0.23890390f, 0.18268789f, 
    -0.13798205f, -0.11294160f, -0.18757340f, -0.01285542f, 0.15407294f, -0.07015829f, -0.19053409f, -0.04414224f, 
    0.02637659f, -0.26421197f, -0.07285337f, -0.06915836f, -0.17029094f, -0.35407705f, -0.13051110f, -0.18089521f, 
    -0.23458588f, -0.01860115f, -0.23152928f, -0.06765124f, -0.03241999f, -0.06104298f, -0.00949608f, -0.11431635f, 
    -0.09344396f, -0.07987096f, -0.10348714f, -0.27597388f, -0.18092127f, 0.12893472f, -0.08282923f, 0.00278995f, 
    -0.00868755f, -0.10507253f, 0.13808471f, 0.01780748f, -0.10230825f, -0.03234590f, 0.07249739f, -0.06716105f, 
    0.18648236f, -0.13370910f, -0.07707745f, -0.03845097f, 0.24213443f, 0.05921071f, -0.00791583f, 0.21169591f, 
    -0.00211519f, 0.18002819f, -0.19251263f, -0.23687627f, -0.26890272f, 0.13914363f, -0.02640223f, 0.04680946f, 
    0.16733326f, -0.17040069f, 0.02975720f, 0.17591053f, 0.24221420f, 0.11811069f, -0.09088239f, -0.24960183f, 
    -0.05648214f, 0.02611434f, -0.08819541f, -0.11121315f, -0.11255925f, 0.15856779f, -0.03026600f, 0.46782642f, 
    0.44723240f, 0.45453769f, 0.25416373f, 0.32390220f, 0.14122641f, -0.12249312f, 0.34402021f, 0.11093018f, 
    -0.14867356f, 0.13005890f, -0.02879178f, 0.02234684f, 0.10012453f, -0.00921710f, 0.02912554f, 0.03103555f, 
    0.00112681f, 0.11744728f, 0.00543167f, -0.13909090f, 0.12051036f, -0.20919524f, 0.02885912f, 0.08482859f, 
    0.11764376f, -0.07024958f, 0.02521423f, -0.11722580f, -0.21583821f, -0.09881774f, -0.00399159f, 0.17299447f, 
    -0.03190761f, 0.16096603f, 0.07108348f, 0.16108125f, -0.09380367f, 0.10430542f, -0.09450058f, -0.00121244f, 
    0.14036234f, -0.17135538f, -0.09584483f, -0.15415096f, -0.03303341f, -0.04719699f, 0.01133651f, 0.07345591f, 
    0.17545371f, -0.08560368f, 0.00793989f, -0.25529883f, 0.05996054f, -0.08231829f, 0.04040923f, -0.20196047f, 
    0.29079597f, -0.10957104f, -0.09660195f, -0.06991740f, 0.06008885f, -0.15506082f, 0.05180286f, 0.02324112f, 
    0.07990645f, -0.20683519f, -0.08987778f, 0.10071898f, 0.02856167f, -0.02690793f, -0.02176580f, -0.02950562f, 
    -0.02632554f, 0.17169364f, -0.03923621f, 0.13459153f, -0.05009689f, 0.07652001f, -0.05233856f, -0.10185144f, 
    -0.11858711f, -0.07512027f, 0.12691699f, -0.02249970f, 0.18304284f, -0.08118026f, 0.01146827f, -0.05909008f, 
    -0.13890153f, -0.07347911f, -0.18183176f, -0.03666060f, 0.00905084f, -0.11331399f, -0.00714118f, 0.01383468f, 
    0.09590465f, 0.00055187f, -0.00496416f, -0.01886179f, 0.03156447f, -0.05604892f, -0.13847013f, -0.12040321f, 
    0.00685124f, 0.00970272f, -0.01423960f, -0.08248241f, -0.05394551f, 0.15392327f, 0.16627354f, 0.10247208f, 
    -0.08367617f, 0.04192245f, 0.00182213f, -0.01892073f, 0.07479412f, -0.08040267f, -0.01742828f, 0.03002153f, 
    0.08706130f, 0.10173329f, 0.03439565f, -0.03498530f, 0.09539819f, 0.04539965f, 0.13154730f, -0.07759124f, 
    0.15694168f, -0.02600036f, -0.01979484f, -0.00290763f, -0.06753530f, -0.06371239f, -0.05333683f, -0.21882833f, 
    0.03508349f, -0.23242824f, -0.01855434f, 0.20556514f, -0.06362223f, 0.09731229f, 0.03442629f, 0.09264453f, 
    -0.08953550f, 0.41483425f, -0.07423874f, 0.06625001f, 0.44830628f, -0.13587414f, 0.02705697f, -0.13503912f, 
    -0.13882945f, -0.04602497f, -0.25459244f, -0.29322410f, -0.14978938f, -0.22428140f, -0.29782006f, -0.19028241f, 
    -0.05827667f, -0.21773798f, -0.02067193f, -0.30356960f, -0.10676041f, -0.06847994f, -0.07660841f, -0.31922113f, 
    -0.17997642f, -0.16396660f, 0.03871993f, 0.00922446f, 0.10372826f, 0.03941233f, 0.08324936f, -0.10128861f, 
    -0.23420418f, -0.01634164f, -0.01286377f, 0.02385389f, -0.21247573f, 0.14606821f, -0.14244162f, -0.12963632f, 
    -0.03363315f, -0.04218045f, -0.07927813f, 0.04216914f, 0.27941521f, -0.05826348f, 0.04330559f, -0.09047448f, 
    -0.06456592f, 0.07514644f, 0.23054687f, -0.18577863f, 0.14604138f, -0.20907732f, 0.11241635f, 0.02141829f, 
    -0.08006746f, 0.10036997f, -0.04854060f, 0.00919440f, 0.18651688f, 0.14930882f, 0.16482251f, -0.14301130f, 
    -0.07842935f, -0.32528211f, -0.10991870f, -0.32039224f, -0.13779184f, 0.13324652f, -0.03198396f, -0.08550561f, 
    0.02793392f, -0.42893569f, -0.14777366f, -0.28730306f, -0.06878781f, -0.13451931f, 0.17190168f, -0.23526868f, 
    -0.27961952f, 0.01633897f, -0.14614615f, -0.09533936f, 0.16055736f, -0.03040133f, -0.28598921f, -0.14753177f, 
    -0.12984607f, -0.04293000f, 0.13089301f, 0.02847687f, -0.13343512f, -0.00941732f, -0.20001319f, -0.16624439f, 
    -0.13598590f, -0.22596563f, 0.11599360f, -0.04284632f, -0.03037176f, 0.03386504f, 0.18914349f, 0.28654459f, 
    -0.07228437f, 0.22464619f, 0.39736351f, 0.00035638f, -0.01858330f, 0.23728088f, 0.06502792f, 0.08056211f, 
    0.08288083f, 0.40942352f, 0.13838118f, 0.23811723f, 0.07331332f, -0.08872474f, 0.19718477f, 0.31149311f, 
    -0.11368838f, 0.07258075f, -0.17238908f, 0.07420373f, 0.12882965f, -0.00478864f, 0.14977237f, -0.11394937f, 
    0.05395915f, 0.13466732f, -0.10421582f, 0.04035509f, 0.04807480f, 0.01649800f, 0.21344613f, -0.09849224f, 
    0.16530231f, -0.13866944f, -0.14616601f, 0.43487217f, -0.07257998f, -0.05410734f, 0.17758705f, 0.11782139f, 
    -0.04910073f, 0.08493916f, -0.05038400f, -0.17869183f, -0.07509606f, 0.01842342f, -0.10882798f, -0.19343936f, 
    0.01815872f, 0.03886341f, 0.21488362f, 0.03080702f, 0.20612916f, -0.27343211f, 0.07468282f, -0.14085858f, 
    0.17794117f, -0.06770099f, 0.03835678f, 0.07134594f, 0.12349258f, -0.16666388f, 0.23335467f, 0.20407775f, 
    -0.18875481f, 0.21090540f, -0.12997679f, -0.04745779f, -0.03451155f, -0.05233060f, -0.01789341f, -0.45542202f, 
    -0.00096353f, -0.10104432f, -0.07138862f, 0.04996914f, -0.09060297f, 0.21469385f, -0.28561739f, -0.35711405f, 
    -0.05104115f, 0.07747868f, -0.06613234f, 0.02435964f, -0.02234415f, 0.01693688f, 0.11173425f, -0.00006819f, 
    0.19678466f, 0.15104800f, -0.10525768f, -0.12532047f, 0.13499151f, 0.00178019f, -0.01142535f, -0.01787101f, 
    -0.07995114f, 0.01704190f, -0.10988578f, 0.03577446f, 0.03986499f, -0.14495280f, 0.18762479f, -0.03538195f, 
    -0.02848018f, 0.07375420f, 0.04616878f, 0.23333932f, -0.13494013f, 0.10593066f, 0.17511471f, 0.01025945f, 
    -0.20793286f, -0.04527750f, 0.07260998f, -0.04011577f, 0.04022354f, -0.00060323f, 0.39185224f, -0.31086447f, 
    0.20224267f, 0.03574157f, -0.22453318f, 0.08244067f, -0.01834014f, -0.24587087f, -0.10493355f, 0.08438463f, 
    -0.03732628f, 0.07542645f, 0.07203619f, -0.04741342f, -0.08105181f, 0.06057085f, -0.05310590f, 0.14944650f, 
    0.09327348f, 0.28379674f, -0.07252147f, -0.24732176f, -0.06285374f, -0.17010316f, -0.10520367f, -0.24784030f, 
    0.02185283f, -0.01677234f, -0.22838218f, 0.04969236f, -0.06799977f, 0.17712723f, -0.11417979f, -0.06586226f, 
    0.23294931f, 0.00775403f, 0.19300848f, 0.23774259f, -0.15565019f, -0.02860524f, 0.06056834f, 0.04688573f, 
    -0.10286053f, -0.00728601f, -0.13009887f, 0.03380717f, -0.12065745f, -0.02349611f, 0.09296546f, -0.09844981f, 
    -0.20305218f, -0.28149551f, -0.28012273f, -0.10847921f, -0.08855598f, 0.00898382f, 0.18296073f, -0.08652202f, 
    0.02376808f, 0.20197616f, -0.08628528f, -0.14165774f, 0.04854459f, -0.14789284f, -0.00540370f, -0.03831985f, 
    -0.01700379f, -0.03269748f, -0.15045251f, -0.00663234f, 0.15639566f, -0.00016622f, 0.07483164f, -0.09394567f, 
    0.07468820f, 0.04089501f, -0.08368619f, -0.01880158f, -0.09276953f, -0.02164568f, -0.02567107f, 0.00784657f, 
    0.02596838f, -0.03983556f, 0.20009003f, 0.15836817f, -0.12619834f, -0.02913839f, 0.21864854f, 0.09447782f, 
    0.11712188f, 0.36588894f, 0.06237829f, -0.13893080f, 0.08424516f, 0.03492688f, 0.27827388f, 0.05835862f, 
    0.10994268f, 0.01841217f, 0.13485531f, 0.00090913f, -0.00328160f, -0.11057586f, 0.15291659f, 0.06283956f, 
    0.11917523f, 0.19732860f, 0.00792586f, 0.24144411f, 0.06047487f, 0.17199781f, 0.02069695f, 0.06050799f, 
    -0.01421533f, 0.11050010f, 0.01910735f, -0.11088777f, 0.10228094f, 0.06278454f, -0.08499934f, 0.06057821f, 
    -0.11979024f, -0.09701353f, 0.01019647f, 0.01045334f, -0.14760938f, -0.18332995f, -0.07267020f, -0.14838992f, 
    0.06734031f, -0.19748200f, -0.09886741f, 0.20182765f, 0.17396791f, 0.36862916f, 0.24527977f, 0.19407177f, 
    0.09310487f, 0.09890131f, 0.08246780f, 0.05713649f, 0.13207268f, -0.13856392f, 0.16556725f, 0.16166805f, 
    -0.11264764f, -0.16124689f, 0.10290671f, -0.12423035f, 0.02938692f, -0.21458465f, -0.26961260f, -0.28335150f, 
    -0.38832180f, -0.42014006f, -0.29250242f, -0.15392881f, -0.50726481f, -0.29524955f, -0.21253175f, -0.24602596f, 
    -0.14485709f, -0.11981788f, -0.06699952f, -0.04959091f, -0.37901831f, -0.23587116f, -0.25209127f, -0.11923050f, 
    -0.07093515f, -0.01326883f, 0.07576565f, -0.28839512f, -0.10735811f, 0.13519132f, -0.07831114f, -0.06703242f, 
    -0.17198727f, 0.08981626f, -0.14661704f, -0.23482015f, -0.34579164f, -0.40423621f, -0.39701063f, -0.35360405f, 
    -0.00966290f, 0.10352993f, -0.18203835f, 0.00004317f, -0.12351747f, 0.03764912f, 0.09483130f, -0.10200155f, 
    0.05916161f, -0.21434477f, -0.15831622f, -0.17319327f, -0.11727934f, -0.07116692f, -0.09787527f, -0.00042125f, 
    0.19670550f, 0.15108319f, -0.03719401f, 0.08756728f, 0.08319203f, 0.06947093f, 0.18889009f, 0.08945588f, 
    0.04457821f, 0.08030147f, 0.07395568f, -0.12499188f, 0.11759366f, 0.04475802f, 0.28447645f, 0.09234458f, 
    -0.03914304f, 0.06083711f, -0.03454877f, -0.30708376f, 0.12260112f, -0.04587259f, 0.02263256f, 0.08958677f, 
    -0.12169797f, 0.05965368f, 0.22166155f, 0.13083465f, -0.07000533f, -0.07898205f, 0.00112133f, -0.04422135f, 
    0.02059701f, 0.03673488f, -0.01174076f, 0.00363729f, 0.29747921f, 0.00803864f, 0.02891024f, 0.03931357f, 
    0.01586983f, 0.15054704f, -0.13738647f, 0.36675596f, 0.10611283f, 0.14336487f, 0.15143872f, 0.03968264f, 
    0.07699977f, -0.06825829f, -0.05898061f, -0.13722452f, -0.01814652f, 0.25933703f, 0.09746468f, 0.37155973f, 
    0.10639177f, 0.30152571f, 0.18172102f, 0.21621728f, -0.10291955f, 0.07115990f, -0.04829261f, 0.03575473f, 
    -0.02513305f, -0.14217724f, 0.09172520f, 0.06600218f, -0.08789672f, -0.19557443f, 0.09008760f, 0.30072148f, 
    -0.07339850f, 0.21169665f, 0.26789300f, -0.22266825f, -0.13824711f, -0.14929207f, -0.22548914f, -0.15157222f, 
    -0.13179168f, -0.06067442f, -0.01057501f, -0.07402498f, -0.01697458f, -0.08922763f, -0.07198617f, 0.18775994f, 
    -0.12788298f, -0.19798463f, 0.04159940f, -0.04093223f, -0.03132650f, -0.15243682f, -0.27217973f, 0.02935078f, 
    -0.04475120f, -0.14039135f, 0.02519585f, 0.06629018f, 0.01717839f, 0.16562978f, 0.01294968f, 0.04517595f, 
    0.01307954f, -0.24760194f, -0.13998689f, -0.13202146f, -0.00602769f, -0.17329339f, -0.15932786f, -0.07499091f, 
    0.26722333f, -0.01162387f, -0.11390541f, -0.02768584f, 0.05717339f, -0.05417858f, 0.03819166f, -0.28808566f, 
    -0.00811068f, -0.15278655f, -0.07321833f, -0.02661814f, 0.08227787f, -0.13308934f, 0.10176670f, 0.08980922f, 
    -0.17320314f, -0.15142462f, 0.33310693f, 0.10601892f, -0.08493963f, -0.36415989f, 0.37458290f, -0.03076054f, 
    -0.11042071f, 0.02273785f, 0.01164934f, 0.08193295f, -0.16977078f, 0.01121886f, 0.33486658f, 0.14578123f, 
    -0.03512410f, 0.17111462f, 0.01272773f, 0.12297888f, 0.10696893f, 0.10833160f, 0.10491907f, -0.00956095f, 
    -0.01247036f, 0.24626152f, -0.06282497f, 0.05085046f, 0.08546254f, -0.06250072f, -0.02198059f, 0.07023191f, 
    0.36444716f, 0.03642809f, 0.02203729f, -0.11396209f, 0.03562238f, 0.09228972f, -0.05155875f, -0.03232651f, 
    0.08242262f, 0.14852967f, 0.32748249f, -0.00622354f, -0.06084937f, 0.08213808f, -0.05807209f, 0.21768977f, 
    0.03111428f, 0.13723746f, 0.08839722f, 0.00692003f, -0.06955129f, -0.12141571f, -0.23830342f, -0.06801982f, 
    -0.06919017f, 0.06856700f, -0.12242678f, 0.18102558f, 0.15690231f, 0.01297020f, -0.09018317f, 0.01106902f, 
    -0.05970400f, 0.12006262f, -0.02789121f, -0.15593202f, -0.10836847f, -0.23548106f, 0.15739133f, -0.09049486f, 
    0.13445186f, 0.16135678f, -0.03957916f, -0.00745215f, 0.10253185f, 0.27044993f, 0.04905864f, 0.01707995f, 
    -0.01919140f, 0.21843181f, 0.08745689f, 0.07363275f, 0.09522943f, 0.08970427f, -0.00467805f, -0.14966251f, 
    0.01870514f, -0.23639658f, 0.15416901f, 0.14467175f, 0.17968044f, -0.04385287f, 0.10940417f, -0.16937737f, 
    -0.06760162f, -0.04891777f, -0.07284122f, -0.08398667f, 0.12883032f, -0.10392582f, -0.01017568f, -0.01095636f, 
    0.09239499f, 0.05613615f, 0.09725711f, 0.00529665f, -0.00888718f, -0.13143674f, -0.16754109f, 0.06740444f, 
    0.26095202f, -0.03436941f, -0.03808696f, 0.05960688f, 0.00863846f, 0.04125982f, 0.04907203f, 0.05436120f, 
    0.01735114f, -0.01453203f, 0.07790017f, -0.07114210f, -0.09303183f, 0.11259779f, -0.23382229f, -0.00811014f, 
    0.06479037f, 0.00798267f, 0.21613402f, -0.11630097f, 0.08208802f, 0.17639641f, -0.07050164f, 0.01434116f, 
    -0.10593892f, -0.15191292f, 0.07634415f, -0.00515450f, -0.04491083f, -0.11212695f, 0.12050650f, 0.14440133f, 
    0.12084625f, -0.08663173f, -0.17271479f, 0.05909143f, 0.21491413f, 0.31109431f, 0.15938909f, 0.12607086f, 
    -0.00049635f, 0.17442112f, 0.11426275f, 0.06376029f, 0.22356712f, 0.10353787f, -0.01823813f, 0.13243372f, 
    0.09089286f, -0.03140877f, -0.04546320f, 0.04933346f, -0.08540262f, 0.06555505f, 0.18857481f, -0.08578614f, 
    -0.03111237f, -0.03897080f, -0.07719978f, -0.08087002f, -0.14437893f, 0.07990790f, 0.05077099f, -0.05273288f, 
    0.08907708f, -0.03547416f, -0.02004898f, -0.12804222f, -0.13950618f, -0.02115304f, 0.08380479f, -0.17376546f, 
    -0.19607601f, -0.09365781f, -0.23970221f, -0.09796174f, -0.02006852f, 0.16837827f, -0.02711350f, -0.24920411f, 
    -0.06312575f, -0.22160543f, -0.10685554f, -0.18659545f, -0.21900907f, -0.18259296f, -0.14911365f, -0.16042478f, 
    -0.38717975f, -0.42791505f, -0.37794775f, -0.49769028f, -0.14960562f, 0.09979085f, -0.03754826f, 0.07391143f, 
    0.01351697f, -0.06427460f, 0.02892375f, -0.13101704f, -0.05577397f, -0.01803620f, -0.31738940f, -0.07757271f, 
    -0.02670212f, 0.13627859f, -0.04069831f, -0.13373241f, -0.06547146f, -0.42873369f, -0.16268957f, -0.03502356f, 
    -0.09599322f, -0.23077858f, -0.12601511f, -0.28317691f, -0.07591470f, 0.12131691f, 0.01936661f, -0.02370695f, 
    -0.15378240f, 0.20410173f, -0.04835542f, -0.09928469f, -0.01783513f, -0.00197856f, 0.13283725f, -0.10564890f, 
    -0.25977892f, 0.13209151f, 0.01546118f, 0.10561718f, 0.01092142f, 0.27997128f, 0.12434181f, -0.02875028f, 
    -0.08309000f, 0.00748466f, 0.31058797f, 0.07150739f, 0.27083730f, 0.14624207f, -0.03083358f, -0.14174941f, 
    -0.04120090f, -0.04747770f, 0.23650516f, 0.08261688f, 0.20066425f, -0.10646977f, -0.03618122f, -0.24116156f, 
    0.00493814f, 0.04400131f, 0.14789683f, 0.12897353f, 0.15406637f, 0.08476309f, 0.06140847f, 0.16706843f, 
    0.16358031f, -0.12907960f, 0.29823856f, 0.19460486f, 0.27253553f, 0.03887647f, 0.17131186f, 0.07873778f, 
    0.28943423f, 0.13132771f, -0.24877690f, -0.13843252f, 0.18212140f, -0.14201706f, -0.15736891f, -0.39805508f, 
    0.09456402f, -0.19850212f, -0.12912935f, 0.21022050f, -0.04060828f, 0.15273707f, -0.13412958f, -0.03502765f, 
    0.03021863f, 0.05858036f, -0.17122138f, -0.02481100f, -0.16834191f, -0.06389799f, 0.08441480f, 0.26087255f, 
    -0.07914251f, 0.13643798f, 0.09052968f, 0.20344913f, 0.30879794f, 0.05360388f, -0.09806984f, -0.17651259f, 
    0.06718299f, -0.06617169f, -0.29506789f, -0.02964512f, 0.01832761f, -0.20541293f, -0.21565388f, -0.17160948f, 
    -0.01163546f, 0.05144189f, -0.07208147f, 0.05785804f, 0.11186917f, -0.01231863f, -0.05743781f, 0.01272055f, 
    -0.03362107f, -0.01948282f, -0.08901911f, 0.24066203f, -0.08363438f, 0.03194844f, 0.13506332f, -0.08618416f, 
    -0.05845227f, -0.00608452f, -0.05575472f, -0.02744706f, -0.15784442f, 0.11479290f, -0.02624239f, 0.03411455f, 
    -0.14165419f, 0.11535869f, -0.02845553f, -0.22579523f, -0.01384604f, 0.06027164f, 0.27525961f, 0.18082942f, 
    0.09989797f, 0.01916020f, 0.10696339f, 0.01413922f, -0.01306383f, -0.01986159f, 0.03310818f, 0.14175864f, 
    -0.04480486f, 0.10722880f, -0.10066578f, 0.16773458f, 0.01051452f, 0.22291588f, 0.06745144f, -0.03148304f, 
    -0.05679536f, 0.03550064f, 0.00878862f, -0.26020266f, 0.08920680f, -0.13984999f, 0.05013698f, 0.01056910f, 
    0.11764953f, -0.23994395f, -0.17985140f, -0.01579405f, -0.03016127f, 0.04569682f, 0.06029444f, 0.12662309f, 
    -0.13411456f, 0.09247207f, -0.02719733f, -0.13731291f, 0.05708712f, 0.02760826f, 0.13772671f, 0.10706396f, 
    -0.02481896f, 0.02606272f, 0.02638591f, 0.03549826f, -0.11806751f, 0.03719686f, -0.04427301f, 0.02103359f, 
    -0.05186657f, 0.12562928f, -0.09514294f, -0.08305271f, -0.12324644f, -0.05809794f, -0.03772900f, -0.17418158f, 
    0.03166378f, 0.11869756f, -0.08175970f, -0.10971426f, -0.00078821f, -0.10306176f, -0.03757022f, 0.09040597f, 
    -0.08470483f, 0.02582135f, -0.06253895f, -0.06195739f, 0.11596281f, 0.09349422f, 0.10281949f, 0.04994665f, 
    0.01054694f, 0.13298632f, 0.13166035f, 0.12217937f, -0.11217736f, 0.23126340f, 0.08645275f, -0.02579693f, 
    0.21661647f, 0.08274146f, -0.03306280f, 0.02444239f, -0.07133531f, -0.08780148f, 0.14529604f, -0.01606719f, 
    -0.09598884f, 0.11007270f, -0.02499655f, -0.18772271f, 0.00637594f, 0.14877372f, -0.07051049f, -0.36207266f, 
    -0.14105652f, -0.01776387f, 0.06613126f, 0.16686387f, 0.45165593f, 0.06627646f, 0.52972993f, 0.52360098f, 
    0.38897465f, 0.22144030f, 0.18916523f, 0.27112768f, 0.04449315f, 0.44030386f, 0.35546687f, 0.20550568f, 
    0.12836508f, 0.18194259f, 0.11333452f, -0.08357272f, 0.22407209f, 0.07686706f, -0.01425399f, -0.14187443f, 
    -0.17823483f, 0.12875780f, 0.27784950f, 0.52559346f, 0.14685533f, -0.08910250f, 0.01337014f, 0.04751309f, 
    0.07570865f, 0.02485404f, 0.26226674f, 0.25454852f, 0.06127723f, 0.03776898f, 0.13244438f, 0.14859056f, 
    0.18361148f, -0.13358329f, -0.06966230f, 0.03121137f, 0.09533040f, 0.00410533f, -0.10388585f, 0.24755341f, 
    0.33867368f, 0.01869471f, 0.10827674f, -0.03630133f, -0.18681022f, -0.13559054f, -0.24057361f, 0.14509861f, 
    -0.16754200f, -0.08331463f, -0.22985752f, 0.00026106f, 0.10043323f, -0.13732277f, -0.26235548f, 0.07922209f, 
    0.30478329f, -0.26039432f, -0.08889138f, 0.03787881f, -0.02357575f, -0.22415524f, -0.19590756f, 0.22131448f, 
    0.06094216f, -0.09942093f, 0.05202122f, 0.19720857f, 0.24092030f, 0.01195105f, 0.14750870f, 0.02016420f, 
    0.16127677f, 0.02555064f, 0.03832272f, 0.18740941f, -0.07816077f, -0.45231478f, 0.01594190f, 0.04220254f, 
    -0.32999045f, -0.18986565f, 0.11066531f, -0.08698302f, 0.22450443f, 0.10686415f, 0.13159022f, 0.20823603f, 
    0.13138725f, 0.06089233f, -0.00759278f, 0.30949508f, 0.17218854f, -0.21037101f, 0.11620377f, 0.28046662f, 
    0.41674288f, 0.24117012f, -0.13695113f, -0.21514163f, -0.22363907f, -0.10063378f, 0.01486505f, 0.04360985f, 
    0.05671562f, 0.06680145f, -0.03413691f, 0.15454937f, 0.11068128f, -0.04758421f, -0.16204229f, 0.11678292f, 
    -0.04343623f, 0.06321401f, -0.15896329f, -0.05039506f, -0.15276381f, 0.10447894f, -0.04310173f, -0.15259056f, 
    -0.11367986f, -0.07057821f, -0.17538542f, -0.12188830f, -0.06614105f, -0.24443899f, -0.19385253f, -0.04415455f, 
    -0.25507116f, 0.09555935f, 0.06746367f, -0.15668043f, -0.02992587f, 0.12350462f, 0.07643814f, -0.02243542f, 
    -0.26802386f, -0.06396068f, -0.15178330f, 0.08870860f, -0.06827001f, 0.02915310f, -0.08271713f, -0.11385976f, 
    -0.12960227f, 0.11499475f, 0.13083627f, -0.04851291f, 0.17938642f, -0.35250586f, 0.01498241f, -0.03150434f, 
    -0.05632153f, -0.14208421f, -0.19365758f, 0.00746141f, 0.03340153f, -0.07276606f, 0.08174106f, -0.03688754f, 
    -0.30764709f, 0.23096663f, 0.03559989f, -0.24224857f, 0.07506120f, -0.03070752f, 0.10022497f, -0.04839145f, 
    0.11749203f, -0.24586512f, 0.10902387f, 0.16009316f, -0.01400721f, -0.00035742f, 0.21390018f, -0.08131538f, 
    0.04237382f, 0.13642166f, 0.08262249f, 0.07572906f, 0.05897430f, 0.08704185f, 0.10080364f, -0.07393387f, 
    -0.11044524f, 0.12501932f, -0.13240709f, -0.12927470f, -0.08715394f, 0.14333120f, -0.09257944f, -0.30242264f, 
    -0.00924986f, 0.11838730f, -0.05578083f, -0.18489422f, 0.00945910f, 0.13646031f, 0.06990192f, 0.00828030f, 
    0.07287006f, 0.09046161f, -0.32847128f, 0.14435141f, -0.14910328f, 0.05543171f, -0.02555384f, -0.04501521f, 
    0.02176630f, -0.11697575f, -0.15161516f, 0.09103393f, 0.27810009f, -0.15799545f, 0.11929225f, -0.00782655f, 
    0.07715380f, 0.09812833f, -0.00173207f, 0.37721321f, 0.13843884f, 0.24444582f, 0.01153145f, 0.05586958f, 
    0.05723581f, 0.19260728f, 0.03399501f, 0.00662026f, 0.03230561f, 0.23591022f, 0.24622127f, -0.00229539f, 
    -0.09329684f, -0.22305214f, 0.02222454f, 0.01830261f, 0.06024175f, -0.08261550f, -0.09577643f, 0.12387091f, 
    0.13809500f, -0.12067540f, -0.11490445f, -0.10812698f, -0.21893310f, -0.35900089f, -0.10465354f, -0.13341511f, 
    -0.12179149f, -0.20351225f, -0.09880178f, 0.00389368f, -0.27020606f, 0.03475942f, 0.05761697f, -0.04009236f, 
    0.16774132f, 0.23880195f, 0.20790353f, -0.25499444f, 0.35587381f, -0.13689194f, -0.00885867f, 0.10318153f, 
    -0.07562866f, 0.06063752f, 0.07683296f, -0.01329082f, -0.02234625f, -0.28923675f, -0.15271984f, 0.03248571f, 
    -0.13208830f, 0.06830618f, -0.01064090f, -0.17025135f, 0.03940499f, 0.00242202f, -0.05193771f, -0.11060584f, 
    -0.02861387f, 0.21363645f, 0.03879999f, -0.03506714f, 0.32462780f, 0.10501907f, 0.20581745f, 0.10183326f, 
    0.15070986f, -0.11053138f, 0.25846161f, 0.08905365f, 0.31702705f, 0.09988268f, 0.07497502f, 0.24456401f, 
    0.00978481f, -0.15074321f, 0.01220445f, -0.10089838f, -0.12683367f, 0.09768775f, 0.28939433f, 0.17513765f, 
    0.16494315f, 0.22132713f, 0.01872463f, 0.08706758f, -0.25153979f, 0.03330440f, 0.04244681f, -0.12082850f, 
    -0.15971389f, 0.06180356f, -0.05202925f, 0.17464824f, 0.15304929f, 0.12431167f, 0.15389919f, 0.10956685f, 
    -0.12686671f, 0.07670744f, 0.05959882f, 0.11094607f, 0.23476759f, 0.10314222f, -0.04869083f, -0.02713552f, 
    -0.14310346f, -0.24908788f, -0.01523522f, -0.06307329f, -0.13415672f, -0.41006939f, 0.06791471f, 0.30228682f, 
    0.00769047f, -0.06577663f, 0.09837731f, -0.07414215f, -0.08331753f, -0.06147157f, -0.06564626f, 0.11331482f, 
    0.01265271f, 0.02375049f, 0.06297650f, -0.15765437f, -0.10417281f, 0.00358124f, 0.18176530f, 0.13510691f, 
    0.02557033f, -0.16533652f, 0.38791539f, 0.13375448f, 0.03062672f, -0.16212213f, -0.17118127f, -0.04505708f, 
    0.04072441f, -0.03457204f, -0.10899067f, 0.01496306f, -0.14211875f, 0.06477500f, -0.16007525f, -0.06551934f
};;

// Vieses da camada densa dense0
const float dense0_biases[] PROGMEM = {
    -0.06967829f, -0.04792558f, 0.12848344f, -0.12613346f, -0.07135931f, 0.28785051f, 0.07638336f, -0.23056536f, 
    -0.10428109f, -0.06444863f, 0.09666396f, 0.12501045f
};;

// Funções auxiliares

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Função Principal de Inferência ---

void setup_network() {
    // Nenhuma inicialização necessária para esta implementação
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copiar dados de entrada
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Camada Convolucional 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Alternar buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 4440);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Alternar buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implícito - os dados já estão em buffer_a como vetor 1D)

    // Camada Densa 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Alternar buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax na camada final
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
