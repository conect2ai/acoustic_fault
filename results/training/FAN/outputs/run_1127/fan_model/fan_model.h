/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 128 (x2)
    * Saída: 12
    * Buffer Máx: 128
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 128;
    const int FAN_MAX_BUFFER_SIZE = 128;

    // --- Funções de Ativação ---
    static inline float fan_activation(float x) { return x; }

    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 51 x 120)
const int L0_fan_Wp_rows = 51;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -1.52013496e-01f, -8.90630633e-02f, -2.15095319e-02f, 1.78168878e-01f, 1.69675961e-01f, -2.72644795e-02f, -5.10189496e-02f, -9.73394364e-02f, 2.01372921e-01f, -4.20814119e-02f,
  1.91019386e-01f, 2.61925846e-01f, 1.32400334e-01f, 2.47408628e-01f, 1.06826365e-01f, -8.89215097e-02f, 2.76747392e-03f, 1.08547531e-01f, 1.68593690e-01f, 2.27918833e-01f,
  2.36787155e-01f, 2.09439933e-01f, 1.86126590e-01f, 6.87358454e-02f, 1.65147737e-01f, 2.37132609e-01f, -5.14509566e-02f, 1.08035445e-01f, 1.26485005e-01f, 1.88258946e-01f,
  2.99789160e-02f, -3.47695611e-02f, 2.25661084e-01f, 2.64307976e-01f, 1.92585081e-01f, 1.17087282e-01f, 8.96135047e-02f, 1.65257379e-01f, 1.19277552e-01f, 1.46854371e-01f,
  2.30795041e-01f, 1.34954348e-01f, 1.93516672e-01f, 5.58182076e-02f, 5.79514578e-02f, 1.33834817e-02f, 1.55608699e-01f, 3.48169804e-02f, -3.80521314e-03f, 1.91937119e-01f,
  2.58311182e-01f, 2.07847849e-01f, 1.19016081e-01f, 1.37890175e-01f, 5.17736152e-02f, 2.24899590e-01f, 9.95512679e-02f, 9.01860446e-02f, 8.43857415e-03f, 3.27239707e-02f,
  2.29215175e-02f, 1.95026898e-03f, -3.56984586e-02f, -3.35252844e-02f, -1.71157662e-02f, -7.63170072e-04f, 1.15272246e-01f, -7.39935338e-02f, -3.35486070e-03f, -1.04449876e-01f,
  -1.06604837e-01f, -6.42625764e-02f, -5.13696223e-02f, -1.58265382e-01f, 4.16577160e-02f, -7.80467093e-02f, -6.59087151e-02f, 1.99124329e-02f, -8.59582499e-02f, -4.70004417e-02f,
  1.09513141e-02f, -1.65432021e-02f, -9.40869823e-02f, -8.97309855e-02f, -1.15038849e-01f, -1.09279165e-02f, 3.33911665e-02f, -7.51395747e-02f, -5.82833663e-02f, -2.20482200e-02f,
  -1.58280060e-01f, 4.31976095e-02f, 2.67533660e-02f, 8.40112474e-03f, -3.69531964e-03f, 1.13574624e-01f, 1.12869203e-01f, 6.53760582e-02f, 1.70226857e-01f, 2.76713166e-02f,
  1.46730110e-01f, 1.70357287e-01f, 9.65115800e-02f, 9.70494896e-02f, 7.31417239e-02f, 3.29275392e-02f, 1.16048761e-01f, 1.58321053e-01f, 4.58415598e-02f, 1.23115003e-01f,
  1.56042486e-01f, 7.90135488e-02f, 1.04705691e-01f, 1.92807596e-02f, 4.93319072e-02f, 6.36969805e-02f, 7.89635628e-02f, 1.21538259e-01f, 1.87338907e-02f, -2.59443708e-02f,
  -1.88722864e-01f, -1.49977654e-01f, 1.82154924e-02f, -2.06895947e-01f, -1.56981483e-01f, -9.01279896e-02f, -2.99606442e-01f, -1.61578762e-03f, -8.64380300e-02f, -1.13553323e-01f,
  -9.20756459e-02f, 1.29942179e-01f, 1.26101798e-03f, 1.02007657e-01f, 1.01839870e-01f, -1.69295296e-01f, -1.48785695e-01f, 1.93158556e-02f, 1.38419673e-01f, 6.87443540e-02f,
  -4.30172570e-02f, -3.14878821e-02f, 1.09194711e-01f, 1.06042258e-01f, -1.43892884e-01f, -2.29178369e-02f, -8.36684927e-02f, -7.72332177e-02f, -1.27282649e-01f, -2.40998849e-01f,
  7.99828544e-02f, 1.29283458e-01f, 1.04587987e-01f, -2.80796923e-02f, 6.21898323e-02f, 5.34210764e-02f, 5.31422421e-02f, 9.18695852e-02f, -1.73471961e-02f, 9.64085162e-02f,
  8.74769613e-02f, 2.21733600e-02f, -5.25916182e-02f, 7.07469806e-02f, -5.12789153e-02f, 1.34408697e-01f, 6.96431324e-02f, 5.99888414e-02f, 3.69875901e-03f, 2.05357168e-02f,
  8.17598030e-03f, 4.11442257e-02f, 6.38948567e-03f, 8.14410150e-02f, 1.62259683e-01f, 9.31757987e-02f, 1.50972217e-01f, 5.76879755e-02f, 6.10079244e-02f, 4.34097648e-02f,
  1.19344980e-01f, 8.10598489e-03f, -1.60469979e-01f, -1.42702460e-01f, -9.46722031e-02f, -1.13946512e-01f, -8.47090557e-02f, -6.84938654e-02f, 2.83161905e-02f, -1.06259575e-02f,
  -9.87446532e-02f, -1.31565973e-01f, -3.20198536e-02f, -1.42629981e-01f, -9.23213065e-02f, -9.23887864e-02f, -1.12261400e-01f, -4.88823988e-02f, -8.13506693e-02f, -8.13004896e-02f,
  -1.34650007e-01f, 3.80962081e-02f, -5.30570000e-02f, -1.10855829e-02f, -1.59833163e-01f, -8.22206307e-03f, -9.90428999e-02f, 1.22638289e-02f, -1.01842269e-01f, -7.52568692e-02f,
  7.71359354e-02f, 1.62930712e-01f, -4.90305498e-02f, 5.46346642e-02f, 8.75375494e-02f, 3.33767645e-02f, 5.57433330e-02f, 2.23241597e-02f, 2.94271987e-02f, 3.95713262e-02f,
  7.68101588e-02f, -8.73495359e-03f, -7.09802657e-02f, 2.11415882e-03f, -4.40412760e-02f, -1.82382148e-02f, -9.82248783e-02f, -9.67847854e-02f, 4.03340198e-02f, 8.52979943e-02f,
  1.56705745e-03f, -1.07072040e-01f, 5.28154448e-02f, 7.11491157e-04f, 1.25710860e-01f, -2.92399023e-02f, 8.62395689e-02f, 1.11263171e-01f, 8.76515955e-02f, -1.06429949e-01f,
  4.43355560e-01f, -1.60265923e-01f, -1.98918477e-01f, 4.53294776e-02f, -2.25589082e-01f, -4.17267755e-02f, -1.06572598e-01f, 3.37491408e-02f, -2.22762991e-02f, -3.81975062e-02f,
  -2.56622443e-03f, 1.91227183e-01f, 3.62111330e-02f, 1.70685723e-01f, 2.32130855e-01f, -2.32509241e-01f, -1.63094506e-01f, 7.65857846e-02f, 2.78122514e-01f, 1.66879043e-01f,
  -1.83598623e-02f, -3.71849760e-02f, 1.67551428e-01f, 6.00897782e-02f, -1.37408376e-01f, 7.25346804e-02f, -1.74041912e-01f, -1.13918744e-01f, -1.04573265e-01f, -9.45311040e-02f,
  -4.29554209e-02f, 1.47172019e-01f, 3.91835794e-02f, 1.25550985e-01f, -7.84471780e-02f, -5.25220623e-03f, -4.19078469e-02f, -1.03862546e-01f, 5.71488927e-04f, 1.42142819e-02f,
  -3.47048268e-02f, 3.48101743e-02f, -9.48976073e-03f, 8.13878141e-03f, 1.34647102e-03f, -5.09866811e-02f, 6.77186251e-02f, 1.18722424e-01f, 5.02512455e-02f, 5.92657700e-02f,
  -1.59625765e-02f, -7.14391991e-02f, -6.38096780e-02f, -1.31971054e-02f, 1.38811603e-01f, 1.20691992e-01f, -8.65844786e-02f, 3.18589471e-02f, 3.21059227e-02f, -3.54954824e-02f,
  -1.30258799e-02f, -2.65711714e-02f, 5.33434302e-02f, -3.45687047e-02f, 6.06971271e-02f, -1.89158805e-02f, 1.06735872e-02f, -6.99305627e-03f, -2.25752369e-02f, -3.34175229e-02f,
  -4.08419706e-02f, -6.23627231e-02f, -2.02307310e-02f, 2.42613498e-02f, -7.06889480e-02f, -5.05699292e-02f, -6.77542586e-04f, 8.33844841e-02f, -4.36676443e-02f, 6.08492643e-02f,
  -5.47845056e-03f, 7.49163032e-02f, -2.86155473e-02f, 5.51114678e-02f, 2.20520496e-02f, -2.35695746e-02f, -3.23773827e-03f, -1.05418134e-02f, 2.08240002e-02f, -2.34938916e-02f,
  9.46797081e-04f, 7.78194815e-02f, 9.48952660e-02f, 9.41949710e-02f, 5.97619936e-02f, -1.89422313e-02f, 6.58694953e-02f, 4.62288447e-02f, 6.22191466e-02f, 1.98493637e-02f,
  3.84953469e-02f, 4.42579612e-02f, 1.30527280e-03f, -7.48164132e-02f, -1.12244617e-02f, -7.80730993e-02f, 2.66442494e-03f, 6.00060858e-02f, 9.14484710e-02f, -8.23941901e-02f,
  -2.62190383e-02f, -3.24502885e-02f, 3.25463489e-02f, -5.05175218e-02f, -1.33582791e-02f, 1.34331316e-01f, -8.42087120e-02f, 5.76958584e-04f, 8.01945701e-02f, -2.27986034e-02f,
  -2.06178501e-01f, -2.70615846e-01f, 2.43429884e-01f, -8.79665930e-03f, 6.01910539e-02f, -5.71597740e-02f, -1.36540174e-01f, -2.97525041e-02f, -1.44595876e-01f, -1.86495960e-01f,
  -4.79540899e-02f, 1.94129631e-01f, 1.52621090e-01f, 1.80047721e-01f, 1.69489086e-02f, -1.86301693e-01f, -1.26027495e-01f, 1.27371415e-01f, 3.18805724e-01f, 1.78075746e-01f,
  1.37596354e-02f, -6.79016784e-02f, 1.90025374e-01f, 3.33751105e-02f, -1.38991252e-01f, 6.66418746e-02f, -4.24054414e-02f, -3.69274523e-03f, 6.60708845e-02f, -1.78310238e-02f,
  4.80943248e-02f, 2.51961965e-03f, 1.49374142e-01f, 8.75639617e-02f, 5.69795072e-02f, 6.65043145e-02f, 8.93634409e-02f, -1.16038527e-02f, -3.38847376e-02f, 4.73786779e-02f,
  3.95881608e-02f, 1.01873375e-01f, 6.12285398e-02f, 1.35731414e-01f, 8.11736844e-03f, 5.35855517e-02f, 1.28045037e-01f, 9.89606827e-02f, 1.22919627e-01f, -5.99139370e-02f,
  3.96071188e-02f, -3.78944390e-02f, 3.89268957e-02f, 6.87477887e-02f, 1.03043541e-02f, 1.72539011e-01f, 6.87778220e-02f, 1.02096237e-01f, 1.24525428e-02f, -1.12147242e-01f,
  6.64997920e-02f, 4.39668000e-02f, 1.27496943e-01f, 6.30121157e-02f, 5.97874001e-02f, 1.49938790e-02f, 4.43207584e-02f, -2.08112266e-04f, 5.73660247e-02f, 1.41690988e-02f,
  3.82328965e-02f, 3.03906184e-02f, 6.59633428e-02f, -8.27393755e-02f, 2.93845125e-02f, -2.24452261e-02f, -3.52811478e-02f, 2.23229509e-02f, 3.85484286e-02f, -9.17625874e-02f,
  -2.25599157e-03f, 9.54479948e-02f, 1.92335621e-02f, 3.54592651e-02f, 5.37328459e-02f, -3.54771651e-02f, 9.42777395e-02f, 2.86152195e-02f, -4.46383469e-02f, -4.20923680e-02f,
  -2.10082337e-01f, 8.05468187e-02f, -1.22926366e-02f, -9.98845324e-03f, -9.02662426e-02f, 2.65211239e-02f, -8.64818841e-02f, 8.38964656e-02f, 3.48929572e-03f, 3.58072668e-02f,
  1.12025104e-02f, 1.93012338e-02f, -8.09983090e-02f, 1.37841552e-02f, -2.22245865e-02f, 3.07035577e-02f, -9.90129635e-02f, -2.78056692e-02f, 1.14900796e-02f, 3.68331894e-02f,
  -2.50574388e-02f, -9.20926780e-02f, -3.21695060e-02f, -9.85775441e-02f, -7.08389655e-02f, 1.31442565e-02f, -4.35776822e-02f, 1.54709853e-02f, 2.27676257e-02f, -2.44880706e-01f,
  5.48275001e-03f, 7.55771995e-02f, 1.30955487e-01f, -1.86677933e-01f, -1.05621800e-01f, 1.28664508e-01f, 1.63706809e-01f, 8.78616124e-02f, -1.25612199e-01f, 7.87451044e-02f,
  -1.97969660e-01f, -3.21214259e-01f, -1.93282142e-01f, -1.36527091e-01f, -4.86921780e-02f, 2.10263804e-01f, 1.21610574e-01f, 6.88694194e-02f, -8.10734481e-02f, -5.82875386e-02f,
  -4.41055372e-02f, -8.46263021e-02f, -8.47869366e-02f, -1.48576438e-01f, 3.88472825e-02f, -7.88279325e-02f, 3.24690677e-02f, 4.20581922e-02f, -5.31839840e-02f, -3.55474204e-02f,
  4.12343554e-02f, 1.49371587e-02f, -5.86366393e-02f, -1.68706283e-01f, -9.86669287e-02f, -2.97952201e-02f, -7.43896216e-02f, -1.16438739e-01f, -1.44563047e-02f, -1.08241521e-01f,
  -1.12350248e-01f, -1.77176982e-01f, -2.08517849e-01f, -1.38652071e-01f, -8.66275132e-02f, -5.00531606e-02f, -8.28324780e-02f, -5.39531149e-02f, -1.35941371e-01f, -6.28977735e-03f,
  -2.05128938e-01f, -5.60465045e-02f, -4.11362164e-02f, -7.39854351e-02f, -6.96771517e-02f, -6.71615824e-02f, 8.11715331e-03f, -8.89006816e-03f, 2.72821169e-03f, 1.12859078e-01f,
  4.20826115e-02f, 2.76578907e-02f, 2.43221801e-02f, 3.69687274e-04f, -4.13600095e-02f, 2.85161640e-02f, 8.13900400e-03f, 5.70017844e-03f, 5.19668625e-04f, 1.03865467e-01f,
  1.00052200e-01f, 8.84262994e-02f, 1.17615744e-01f, 6.67876378e-02f, 4.01856564e-02f, 1.38486743e-01f, 5.36709428e-02f, 8.30682814e-02f, 6.99175298e-02f, 4.75834645e-02f,
  3.14580426e-02f, 1.24439567e-01f, 1.32719666e-01f, 1.95802283e-02f, 1.37162805e-02f, 6.42742589e-02f, 1.50055602e-01f, 3.45308110e-02f, 9.79858488e-02f, 1.16211675e-01f,
  -6.67581558e-02f, -1.70864344e-01f, 4.88462709e-02f, -6.08803146e-02f, -3.68268713e-02f, -1.03486240e-01f, -3.46319899e-02f, -5.52286766e-02f, -6.13461137e-02f, -5.46009280e-03f,
  -1.49651140e-01f, -1.02498204e-01f, -1.37993544e-02f, -3.27200862e-04f, -1.06492108e-02f, -4.35496084e-02f, -9.68081728e-02f, 2.66354084e-02f, -2.13563293e-02f, -4.78427596e-02f,
  -1.19175263e-01f, -6.17807060e-02f, -4.18408550e-02f, -4.27866392e-02f, -9.64581370e-02f, -1.42762318e-01f, 6.14948124e-02f, 1.09636579e-02f, 4.56633829e-02f, 1.31012693e-01f,
  -2.43517414e-01f, -6.21276051e-02f, -3.34586471e-01f, 9.74886939e-02f, 1.47045672e-01f, 2.01118633e-01f, 2.55851120e-01f, 1.12668760e-01f, 5.76417670e-02f, -9.59929153e-02f,
  -7.27029666e-02f, -8.97186622e-02f, -1.57505006e-01f, -1.14184529e-01f, -7.83486068e-02f, 9.03989002e-02f, -6.37541851e-03f, -2.01108560e-01f, -3.85736413e-02f, 1.57573432e-01f,
  1.99887231e-01f, -4.35100533e-02f, -7.91784972e-02f, -8.82246494e-02f, 2.34852917e-02f, 5.70795909e-02f, -1.33840337e-01f, 4.54731360e-02f, 5.26913777e-02f, -2.54156023e-01f,
  -3.03632498e-01f, -7.78858662e-02f, -1.31088425e-03f, 2.89924140e-03f, -8.48270804e-02f, -9.41449776e-02f, -6.25772849e-02f, -1.22522898e-01f, -6.70610964e-02f, 1.89174805e-03f,
  7.75372144e-03f, -1.28297219e-02f, 4.02307026e-02f, -4.50866409e-02f, 3.43124308e-02f, 6.07928224e-02f, -9.37545970e-02f, -2.46933848e-02f, -1.73732098e-02f, -2.54395530e-02f,
  6.67842701e-02f, 9.28412471e-03f, -1.43383697e-01f, -4.18725945e-02f, -7.95320943e-02f, -5.69424145e-02f, -4.48390506e-02f, 6.55472726e-02f, -8.27688202e-02f, -1.82210433e-03f,
  -2.26061773e-02f, -2.32589524e-02f, 8.28237981e-02f, 4.35900912e-02f, 1.27518982e-01f, -2.01660441e-03f, 7.82991499e-02f, 1.10101961e-01f, 4.07804623e-02f, 1.79986954e-02f,
  5.62831163e-02f, 2.03162543e-02f, 1.47605482e-02f, -1.36036724e-02f, -3.42871509e-02f, -1.85463913e-02f, 1.10313250e-02f, 1.34096041e-01f, -3.40548716e-02f, 8.23325068e-02f,
  -1.52603285e-02f, 8.83679688e-02f, -6.02963082e-02f, 8.19940194e-02f, 7.25464299e-02f, 8.82455558e-02f, 3.30944620e-02f, 6.42921850e-02f, -3.43043581e-02f, 6.15188032e-02f,
  1.13101311e-01f, -2.54979264e-02f, -1.16545528e-01f, -8.98393169e-02f, -1.13945276e-01f, -3.75325494e-02f, -4.47859876e-02f, 5.13433367e-02f, -7.98491091e-02f, -6.06409833e-02f,
  3.23442593e-02f, -4.67962921e-02f, -1.77273173e-02f, 1.17096007e-02f, 7.48276040e-02f, -1.12203516e-01f, -6.38948753e-02f, -9.49915946e-02f, -1.02751389e-01f, 4.17824164e-02f,
  8.68517682e-02f, 8.93830415e-03f, -6.60812929e-02f, 7.18704015e-02f, 5.10543026e-03f, -9.92093235e-02f, 2.35671662e-02f, 8.33210628e-03f, -7.07330182e-02f, 6.62141964e-02f,
  -2.72907436e-01f, -2.75576681e-01f, -2.69496709e-01f, -1.46919399e-01f, 2.21903156e-02f, -8.93668979e-02f, -1.08361676e-01f, -1.09277613e-01f, -1.89066753e-02f, 1.43461525e-02f,
  -2.70213448e-02f, -1.36875764e-01f, -7.44711161e-02f, -2.08198413e-01f, -3.05567861e-01f, -2.43489966e-01f, -2.92956710e-01f, -2.21798047e-01f, -3.46515954e-01f, -2.03813702e-01f,
  2.76904609e-02f, -1.33285359e-01f, -2.56012231e-01f, -1.30356908e-01f, 2.43180664e-04f, -8.44645575e-02f, -1.45747125e-01f, -4.44059111e-02f, -4.79857102e-02f, -5.11264987e-02f,
  -3.73440355e-01f, -2.79462188e-01f, -9.01655257e-02f, -1.24415688e-01f, -2.05131337e-01f, -2.51726210e-01f, -1.76643014e-01f, -1.61797240e-01f, -1.16965413e-01f, -8.98459926e-02f,
  -1.21219091e-01f, -6.08376227e-02f, -1.84661284e-01f, -1.21405356e-01f, -1.85518324e-01f, -1.35014459e-01f, -2.24353820e-01f, -1.97902396e-01f, -2.72580117e-01f, -2.04072118e-01f,
  -1.44297302e-01f, -2.13631749e-01f, -3.81837517e-01f, -2.50820547e-01f, -2.67199993e-01f, -2.00736552e-01f, -2.05445737e-01f, -1.81162238e-01f, -1.62665203e-01f, -1.23279981e-01f,
  6.97004721e-02f, 1.53773993e-01f, 1.29152015e-01f, 4.81183380e-02f, 2.03640878e-01f, 1.65390268e-01f, 1.87305599e-01f, 1.82355270e-01f, 1.25948474e-01f, 1.80622220e-01f,
  9.53052416e-02f, 1.43187657e-01f, 1.67009071e-01f, 1.39267966e-01f, 1.59730867e-01f, 1.53308198e-01f, 1.70456707e-01f, 1.55556023e-01f, 7.39914924e-02f, 1.38812229e-01f,
  2.21767798e-02f, 1.72232762e-01f, 1.54262885e-01f, 1.24682985e-01f, 7.14079291e-02f, 5.61075620e-02f, 1.88051119e-01f, 2.19489649e-01f, 1.75471008e-01f, 8.16807896e-02f,
  9.27774459e-02f, -1.72035381e-01f, -1.72401428e-01f, -2.15056658e-01f, -1.72012858e-02f, -7.86019564e-02f, -7.41300061e-02f, -1.04035199e-01f, -1.16453983e-01f, -1.19376637e-01f,
  -1.09799631e-01f, -2.24084496e-01f, -1.89907596e-01f, -1.73911557e-01f, -1.17258035e-01f, -9.55514982e-02f, -8.78170058e-02f, -1.50498003e-01f, -2.10105419e-01f, -9.18806046e-02f,
  -1.03778154e-01f, -2.00904295e-01f, -2.71412909e-01f, -1.32599682e-01f, -2.17604980e-01f, -1.92093998e-01f, -1.38849333e-01f, -2.05488473e-01f, -2.53549755e-01f, -6.71521947e-02f,
  2.79099256e-01f, 1.86596796e-01f, -3.31023097e-01f, 7.13242125e-03f, -1.26455456e-01f, -9.72115025e-02f, 1.45295754e-01f, 1.53351054e-01f, -1.21354349e-02f, -9.86911077e-03f,
  1.40761659e-01f, -1.30404204e-01f, -1.70736298e-01f, -2.13247418e-01f, -2.39733145e-01f, -7.87758529e-02f, -1.86739743e-01f, -3.91115516e-01f, -1.91236049e-01f, -2.60837171e-02f,
  -9.74556282e-02f, 1.28753036e-02f, 5.03952913e-02f, -5.79282604e-02f, -8.65701288e-02f, -6.20367490e-02f, 2.19554044e-02f, 1.23285148e-02f, -8.75400901e-02f, -2.52379566e-01f,
  -2.15118811e-01f, 1.74270898e-01f, -2.07099706e-01f, -2.59660985e-02f, -1.13844104e-01f, -9.79920924e-02f, -5.07669747e-02f, -1.78144444e-02f, 7.26918830e-03f, -2.12373510e-02f,
  -9.30564776e-02f, 3.04528736e-02f, -1.52263492e-02f, -2.23424714e-02f, -5.29309688e-03f, -8.70426968e-02f, -2.04092078e-02f, -1.47996455e-01f, -3.89346071e-02f, -9.15110484e-02f,
  -6.78475425e-02f, 3.43622938e-02f, -1.10885963e-01f, -4.48646471e-02f, -1.55932307e-02f, -1.79042920e-01f, -4.79583964e-02f, 3.51800732e-02f, -1.22086052e-02f, 1.91773288e-02f,
  -6.14098050e-02f, -2.88783088e-02f, 6.86217844e-02f, 1.61076650e-01f, 1.53684039e-02f, 2.66510211e-02f, -3.54216695e-02f, 7.31100813e-02f, 5.74396141e-02f, 7.99476430e-02f,
  7.29518756e-02f, -4.63276468e-02f, 3.53647731e-02f, 9.64456424e-02f, -8.10961872e-02f, 4.84467782e-02f, 3.47323231e-02f, 1.58206522e-02f, 1.11680463e-01f, 7.75264278e-02f,
  -7.76639953e-03f, -3.27969203e-03f, 5.13455085e-02f, 5.67824952e-02f, -2.50831731e-02f, -1.98107194e-02f, -5.17068282e-02f, 1.72712542e-02f, 1.02522172e-01f, 7.00676516e-02f,
  -3.87084261e-02f, -1.24871135e-01f, -1.58317864e-01f, -6.43481985e-02f, -6.73877150e-02f, -1.45090714e-01f, 4.96329833e-03f, -1.62550524e-01f, -9.67084020e-02f, -5.58255427e-02f,
  -1.02689965e-02f, -1.38759851e-01f, -3.57036516e-02f, -1.14165641e-01f, -1.01249553e-01f, -1.02568761e-01f, -2.06243545e-02f, -1.43219501e-01f, -1.40294671e-01f, -2.18091719e-03f,
  -1.48997039e-01f, -1.48514003e-01f, -1.79516897e-01f, -1.77986115e-01f, -1.82504863e-01f, -2.38182008e-01f, -1.33989409e-01f, -2.25789800e-01f, -2.77423680e-01f, -1.72401488e-01f,
  4.13675934e-01f, 3.68822850e-02f, -9.52785276e-03f, 5.55349290e-02f, 1.81063800e-03f, -5.91956377e-02f, -5.85072394e-03f, 4.26049232e-02f, 6.92457482e-02f, -1.25104412e-02f,
  1.67202026e-01f, 6.32298663e-02f, 1.11813724e-01f, 3.22068930e-02f, -9.46197882e-02f, -2.27627069e-01f, -3.02920341e-01f, -1.72440931e-01f, 1.21904172e-01f, 6.51459470e-02f,
  -8.28064382e-02f, 1.16883777e-02f, 5.92073053e-02f, -9.79130790e-02f, -1.92264199e-01f, -1.05331592e-01f, -1.80708960e-01f, -7.02791661e-02f, -1.54259786e-01f, -3.27213049e-01f,
  6.31178543e-02f, 1.28002539e-01f, -3.46490107e-02f, -3.64471748e-02f, -3.63604166e-02f, 8.29847995e-03f, -1.66645776e-02f, -5.72067425e-02f, 3.00776940e-02f, -4.33056392e-02f,
  3.86406295e-02f, -8.49867240e-02f, -1.22640952e-02f, 8.72938952e-04f, 3.83928493e-02f, 6.44624010e-02f, 2.99780648e-02f, -8.67472738e-02f, -2.24901084e-02f, -4.50256392e-02f,
  -7.75860772e-02f, 1.61144901e-02f, -5.49010448e-02f, -7.51688182e-02f, -9.36530158e-02f, 2.11607199e-03f, -1.14098929e-01f, -7.46281222e-02f, 1.52267171e-02f, -8.06210488e-02f,
  -6.99001402e-02f, 1.01341784e-01f, 6.66594133e-02f, -5.26056532e-03f, 3.28950398e-02f, -4.24887165e-02f, -2.32051071e-02f, 3.47570777e-02f, -1.59299280e-02f, 5.70175201e-02f,
  -5.92596009e-02f, 8.25880188e-03f, -6.18972331e-02f, 1.86178721e-02f, -1.76705755e-02f, -7.78779984e-02f, 3.40076573e-02f, -5.66146262e-02f, -8.61850604e-02f, -1.71971582e-02f,
  -7.31399376e-03f, -8.86715297e-03f, 5.35692796e-02f, -6.01957180e-02f, -1.08954959e-01f, -2.65480094e-02f, -3.52721699e-02f, 1.41001731e-01f, 6.84035867e-02f, 5.59377819e-02f,
  2.49446839e-01f, 6.87830672e-02f, -6.96382746e-02f, -1.04286760e-01f, -3.35124135e-02f, -1.59969516e-02f, -4.09703236e-03f, -2.79973615e-02f, 5.38332295e-03f, -4.62843254e-02f,
  1.10876169e-02f, -2.86484957e-02f, 5.98939620e-02f, -2.62455177e-02f, -7.32769892e-02f, 2.70160139e-02f, 1.24842618e-02f, -1.30583107e-01f, -3.25024836e-02f, -1.32495910e-01f,
  -1.65602788e-02f, -9.60786492e-02f, 1.12921961e-01f, 4.57578935e-02f, -3.07805426e-02f, 7.76742026e-02f, -6.22578375e-02f, 7.89427087e-02f, -3.81061458e-03f, 2.03055944e-02f,
  2.48892903e-01f, 2.87644833e-01f, -1.12697236e-01f, 2.44472742e-01f, 9.14933532e-02f, -1.96905032e-01f, -8.04046541e-02f, -1.57068893e-01f, 1.83406115e-01f, 1.13820158e-01f,
  4.76843566e-02f, 9.16512404e-03f, 7.05275834e-02f, -1.16586007e-01f, -2.23571450e-01f, 1.08180553e-01f, -1.28827442e-03f, -9.68976170e-02f, -1.94480613e-01f, -1.78269461e-01f,
  -1.04302969e-02f, 1.81879491e-01f, 5.71914688e-02f, -7.63874594e-03f, 2.16148347e-01f, 2.87077725e-02f, 1.77131593e-01f, 9.12203193e-02f, -2.03089286e-02f, 1.35183394e-01f,
  1.62738308e-01f, 1.22315213e-01f, -1.97022200e-01f, -1.82171110e-02f, 3.69206816e-02f, -4.41600643e-02f, -7.05573484e-02f, 1.20711988e-02f, 4.32896353e-02f, 1.33785695e-01f,
  -3.38482042e-03f, -4.96072061e-02f, 5.29369758e-03f, 1.06655499e-02f, 1.04618661e-01f, -6.80322200e-02f, 6.71236068e-02f, 6.41921088e-02f, -2.85767596e-02f, -6.17083050e-02f,
  2.07725614e-02f, 8.67619514e-02f, -1.47026200e-02f, -1.94676779e-02f, -1.06476687e-01f, 2.14526081e-03f, 5.87270781e-03f, 1.39177078e-02f, -1.48287281e-01f, 4.17362750e-02f,
  1.07926186e-02f, 3.93264480e-02f, -1.04782246e-01f, 3.55317891e-02f, 4.66073006e-02f, -3.61471511e-02f, 3.03716753e-02f, 7.04405084e-02f, 5.88416262e-03f, 6.88966289e-02f,
  -8.08273256e-02f, -1.07308440e-02f, -7.76847918e-03f, 1.95100773e-02f, 5.13183139e-02f, -1.56466737e-02f, 4.70338725e-02f, 3.91325951e-02f, -5.95792942e-02f, -9.51212198e-02f,
  -1.54722333e-02f, -4.35584858e-02f, 9.26924869e-03f, -1.36156902e-01f, -1.23780422e-01f, -2.03372445e-02f, 1.20547973e-02f, 1.69190876e-02f, 1.68432854e-02f, 8.50121602e-02f,
  2.38160163e-01f, -3.03236336e-01f, 1.28761977e-01f, -3.32983881e-02f, -4.60353307e-02f, -3.24754193e-02f, 2.50547230e-02f, 4.50300165e-02f, 4.97475192e-02f, 5.99834919e-02f,
  -9.43848211e-03f, -3.37120928e-02f, 9.87228230e-02f, -2.16477606e-02f, 2.40688939e-02f, 6.82904944e-03f, 8.90420675e-02f, -1.87277384e-02f, -1.35611314e-02f, -1.77259054e-02f,
  4.31256257e-02f, 9.55745354e-02f, 4.08925153e-02f, -2.28452664e-02f, 1.56499241e-02f, -2.43503433e-02f, 3.16449627e-02f, -3.02264132e-02f, -3.07196453e-02f, 2.29312345e-01f,
  -4.23051268e-01f, 7.71422461e-02f, -2.20971461e-02f, -3.35823968e-02f, 1.93367586e-01f, 2.13464320e-01f, 1.28273770e-01f, 7.25401118e-02f, -6.86452985e-02f, -1.27616897e-02f,
  1.18202083e-01f, 4.86319363e-02f, -9.30975005e-02f, -7.24281669e-02f, -3.29211764e-02f, 8.99646729e-02f, -1.55960256e-02f, -4.52414490e-02f, 2.64580268e-02f, 5.39415441e-02f,
  5.15851341e-02f, -4.90228087e-02f, -8.13819617e-02f, -7.44060334e-03f, 9.79609415e-02f, -8.12402070e-02f, 4.52321246e-02f, 4.46896628e-02f, 9.46711600e-02f, -7.21253902e-02f,
  -2.38006234e-01f, -4.69746850e-02f, -4.54307646e-02f, -3.77430813e-03f, -1.00804381e-02f, -2.15502549e-03f, -6.16607140e-04f, -9.76207927e-02f, -1.63959712e-02f, -2.44194977e-02f,
  4.55529504e-02f, -3.10408194e-02f, 1.16856098e-02f, -6.52943477e-02f, -6.18558712e-02f, -9.22103524e-02f, -1.01685107e-01f, -2.75216941e-02f, -1.62319243e-02f, 1.30253034e-02f,
  5.26951849e-02f, 3.96028385e-02f, -9.23889652e-02f, 2.83815619e-02f, 5.57613000e-02f, -1.01282157e-01f, -5.66048771e-02f, 3.83148082e-02f, -1.56944916e-01f, -2.75949478e-01f,
  -4.60707545e-02f, 1.14298679e-01f, 1.43828854e-01f, -5.07452935e-02f, -2.93234996e-02f, 5.80382310e-02f, 7.14285905e-03f, 1.14041172e-01f, 4.12303731e-02f, 5.82005903e-02f,
  6.12605326e-02f, -4.60855067e-02f, -3.57244574e-02f, 9.63105485e-02f, 9.37051997e-02f, 7.57437497e-02f, 2.06416041e-01f, 2.10815370e-02f, 1.03686355e-01f, 2.97228433e-03f,
  7.06128851e-02f, 5.29701002e-02f, 5.31121977e-02f, 1.08018167e-01f, 8.21909234e-02f, 9.17619243e-02f, -1.16669945e-02f, 6.71952814e-02f, 8.78355745e-03f, 8.05265829e-02f,
  -1.91597641e-01f, 1.26582682e-01f, -1.07140087e-01f, -3.34371068e-02f, -3.26877385e-02f, 7.64892623e-02f, 5.24335820e-03f, -4.92640398e-02f, -3.56629975e-02f, 2.32553259e-02f,
  6.07799888e-02f, 1.57717150e-02f, -5.14093600e-02f, 5.87404380e-03f, -2.69184411e-02f, -4.10915352e-02f, 1.47618847e-02f, -9.71992016e-02f, -5.70726134e-02f, -4.96775135e-02f,
  -1.36888428e-02f, -1.27281234e-01f, -1.94410250e-01f, -4.91254851e-02f, 1.90779511e-02f, -2.06468090e-01f, -1.06290646e-01f, -1.48513168e-01f, -1.88132346e-01f, -2.92983234e-01f,
  -2.42301017e-01f, -5.39948605e-02f, 2.25634038e-01f, -1.79582044e-01f, -5.28738573e-02f, -1.72776386e-01f, -1.70437098e-01f, -1.63149908e-01f, -7.16948360e-02f, 6.47875480e-03f,
  1.76893957e-02f, 4.96584661e-02f, 1.97468624e-01f, 2.02214435e-01f, 1.02937087e-01f, 1.18973747e-01f, 9.00006965e-02f, 2.49334633e-01f, 1.41141161e-01f, -4.12088186e-02f,
  4.73598652e-02f, 8.02950338e-02f, -2.80690845e-02f, 6.05766661e-02f, -2.07046531e-02f, 1.19323425e-01f, 1.03176892e-01f, 8.47548842e-02f, 1.14134811e-01f, 1.62098840e-01f,
  1.85989037e-01f, -1.19114935e-01f, 1.80497423e-01f, 9.06208158e-02f, 1.84987038e-01f, 4.58001085e-02f, 9.66508240e-02f, 1.69312343e-01f, -1.42516941e-03f, 1.22143902e-01f,
  7.07194582e-02f, -7.93779967e-04f, 1.62035525e-01f, 2.10493058e-01f, 2.97320895e-02f, 1.17993094e-01f, 6.22983165e-02f, 2.17504770e-01f, 1.07391037e-01f, 1.09222285e-01f,
  1.20774232e-01f, 1.14815190e-01f, 1.70139037e-02f, 6.19151490e-03f, -1.39740566e-02f, 8.89088660e-02f, 9.62845087e-02f, 1.41525030e-01f, 1.65528469e-02f, -4.09464426e-02f,
  -9.38224122e-02f, -6.60281032e-02f, -1.15004502e-01f, -8.49334151e-02f, -1.63094029e-02f, -8.81807208e-02f, -1.46001890e-01f, -1.12614762e-02f, -8.35885406e-02f, -5.77263311e-02f,
  2.73779426e-02f, -5.60710654e-02f, 2.12935247e-02f, -5.06827570e-02f, -1.08688073e-02f, -4.12720069e-02f, -4.48308736e-02f, 2.49885581e-02f, -1.21498834e-02f, -3.86472903e-02f,
  5.34775928e-02f, -3.82540072e-03f, -8.01565573e-02f, -4.86912429e-02f, -1.27985433e-01f, 4.65713348e-03f, -1.84883885e-02f, -1.01745650e-01f, -6.37798756e-02f, -9.40640736e-03f,
  5.00655035e-03f, 3.55674848e-02f, 8.40018615e-02f, 6.59049600e-02f, 6.79604411e-02f, 3.90019044e-02f, 3.41385864e-02f, 8.14207494e-02f, 1.46213010e-01f, 1.02778018e-01f,
  -2.93599330e-02f, 6.71061948e-02f, 5.78546524e-02f, 1.38732076e-01f, 3.96692976e-02f, 2.10825633e-02f, 1.82809420e-02f, 1.19948812e-01f, 5.16497577e-03f, 6.70385659e-02f,
  8.97306874e-02f, 5.39831705e-02f, 9.02097076e-02f, 2.84971073e-02f, 8.79171714e-02f, -6.60424903e-02f, 1.55389160e-01f, 4.87798341e-02f, 7.49866804e-03f, -2.79281177e-02f,
  3.53317767e-01f, -5.01167104e-02f, 2.63565276e-02f, -3.49292122e-02f, -1.86269701e-01f, -6.47099018e-02f, -6.66233003e-02f, 8.28004554e-02f, 1.22881338e-01f, -6.07925393e-02f,
  -9.80232731e-02f, -1.15502961e-01f, 8.29018801e-02f, 1.29950315e-01f, 1.69564918e-01f, 6.88577145e-02f, 1.54836938e-01f, 1.95464820e-01f, 9.27636996e-02f, -1.47729129e-01f,
  -1.02458723e-01f, 1.41514027e-02f, 8.95814225e-02f, -7.48401806e-02f, -1.37241274e-01f, -1.27612859e-01f, -5.43711632e-02f, -1.53133214e-01f, -2.45091826e-01f, -1.05167046e-01f,
  -2.94998996e-02f, -5.98754436e-02f, -3.69813144e-02f, -1.11006431e-01f, -8.92511159e-02f, 1.27734154e-01f, -1.78314820e-02f, -7.54597690e-03f, -1.00340724e-01f, 8.05984363e-02f,
  -7.97060952e-02f, -8.42627361e-02f, -9.73016322e-02f, -1.16134204e-01f, -3.08047570e-02f, 2.40082163e-02f, 5.92030250e-02f, 1.34172991e-01f, -2.60582869e-03f, -6.60523912e-03f,
  -1.42469421e-01f, -1.78133801e-01f, 4.01128754e-02f, 3.63598913e-02f, 4.80701663e-02f, 5.67364395e-02f, -1.25796735e-01f, -1.46543100e-01f, -1.68859530e-02f, 4.29778434e-02f,
  -2.51069758e-02f, 8.31849575e-02f, -6.48086295e-02f, 1.90030839e-02f, -3.59046496e-02f, 2.33736075e-02f, 6.51178733e-02f, -1.88443139e-02f, 7.73791131e-03f, 3.87413278e-02f,
  9.07702371e-02f, -5.88265359e-02f, 1.12070546e-01f, 6.14077300e-02f, -6.84934901e-03f, -1.65468510e-02f, 5.33254631e-02f, -4.67704497e-02f, -2.51453128e-02f, -2.80928984e-02f,
  7.50074163e-02f, -1.08636171e-02f, -4.23746230e-03f, 2.92513650e-02f, 4.81546409e-02f, 1.66184261e-01f, -2.51635332e-02f, 8.96550938e-02f, -1.29422378e-02f, 9.73915160e-02f,
  4.04101126e-02f, -6.77294508e-02f, 2.55804583e-02f, 1.90604907e-02f, -1.52329072e-01f, -1.70120914e-02f, -8.81784260e-02f, 1.23564703e-02f, -3.37921940e-02f, -4.84764688e-02f,
  -1.77519321e-02f, 1.90252494e-02f, -5.97445481e-02f, -1.92252919e-02f, -7.99146891e-02f, -2.17878670e-02f, -1.46044180e-01f, 4.74779010e-02f, -2.20180359e-02f, -1.26911759e-01f,
  -9.75853875e-02f, 6.21005520e-02f, 9.38314721e-02f, -3.87678519e-02f, -3.12876217e-02f, -6.97189271e-02f, -7.80116320e-02f, -1.54847512e-02f, -2.09836122e-02f, 1.24595784e-01f,
  3.93458307e-02f, 1.32090990e-02f, -2.50480890e-01f, 1.72327198e-02f, -2.63837993e-01f, -4.12438959e-01f, -4.27622378e-01f, -2.34253123e-01f, -1.73414037e-01f, -2.08422661e-01f,
  -1.81615099e-01f, -1.68320149e-01f, -1.33949980e-01f, -1.93877608e-01f, -2.54590839e-01f, -2.62155741e-01f, -1.97689772e-01f, -6.42614067e-02f, -2.16788813e-01f, -2.01541722e-01f,
  -9.42929089e-02f, -1.18480727e-01f, -3.17684710e-02f, -1.40655428e-01f, -8.55483189e-02f, -2.24202573e-01f, -4.44274917e-02f, -1.41969938e-02f, -1.67375103e-01f, -1.61399934e-02f,
  -3.18705082e-01f, -1.09319285e-01f, -3.56424212e-01f, -2.42640749e-01f, -9.62103009e-02f, -1.48080662e-01f, -2.58687705e-01f, -4.21850011e-02f, -8.19806978e-02f, -1.41318113e-01f,
  -2.19394311e-01f, -1.47007421e-01f, -6.15295023e-02f, -1.25840202e-01f, -8.68692324e-02f, -1.66426510e-01f, -1.18410282e-01f, -1.23481907e-01f, -9.12905037e-02f, -1.43356383e-01f,
  -9.22174752e-02f, -1.87295049e-01f, -2.48046562e-01f, -2.94883907e-01f, -2.24822834e-01f, -2.60533422e-01f, -2.47065097e-01f, -2.16114134e-01f, -1.90120816e-01f, -1.41194746e-01f,
  7.95884505e-02f, 1.60217449e-01f, 4.50162515e-02f, 2.33513176e-01f, 2.21055761e-01f, 1.22039050e-01f, 1.09544680e-01f, 1.17447563e-01f, 9.37756598e-02f, 2.24207744e-01f,
  2.01502725e-01f, 1.74006954e-01f, 1.28621235e-01f, 1.62469253e-01f, 1.09953456e-01f, 1.90667287e-01f, 1.27666429e-01f, 1.85159460e-01f, 1.49254709e-01f, 1.66049272e-01f,
  1.28486112e-01f, 8.55767876e-02f, 1.44331723e-01f, 2.17532575e-01f, 1.27120852e-01f, 2.05392957e-01f, 8.73033330e-02f, 8.57857466e-02f, 1.18461095e-01f, 1.10944778e-01f,
  -2.27101952e-01f, -2.25804612e-01f, -1.32572979e-01f, -2.32130855e-01f, -2.31022358e-01f, -1.02555893e-01f, -2.03894064e-01f, -1.55904904e-01f, -1.21367872e-01f, -1.85463563e-01f,
  -1.85126200e-01f, -1.15171179e-01f, -9.78913680e-02f, -1.19743019e-01f, -1.77865848e-01f, -1.48522079e-01f, -1.82539925e-01f, -1.65050551e-01f, -2.08832994e-01f, -8.95251483e-02f,
  -1.16511993e-01f, -3.03473741e-01f, -2.55717933e-01f, -2.15748176e-01f, -2.64193296e-01f, -2.33888403e-01f, -2.61243731e-01f, -2.07812265e-01f, -3.29957128e-01f, -3.47029537e-01f,
  1.55515090e-01f, 2.12344632e-01f, -7.60165155e-02f, 7.45561644e-02f, 1.04267322e-01f, 4.11223806e-02f, 8.04546922e-02f, 1.29847601e-01f, 8.84900913e-02f, 1.86576471e-01f,
  -1.58993661e-01f, -2.62868673e-01f, -1.62986144e-01f, -2.34329566e-01f, -1.77974239e-01f, 2.47253180e-01f, 1.39287323e-01f, -2.01626252e-02f, -1.40229538e-01f, -2.76297498e-02f,
  8.48136917e-02f, 6.77744672e-02f, 1.25997379e-01f, -8.28866661e-03f, 2.04544321e-01f, 2.98483465e-02f, 1.52824357e-01f, 1.76733956e-01f, 1.16791166e-01f, 2.51470000e-01f,
  8.07377920e-02f, 1.68252230e-01f, -2.78172791e-02f, -4.68498748e-03f, 5.45598799e-03f, 1.87542483e-01f, 6.66483343e-02f, 1.46768853e-01f, -3.89941339e-03f, 2.04124346e-01f,
  3.97042818e-02f, 6.69213980e-02f, 1.07606493e-01f, 9.81472507e-02f, 4.02661711e-02f, 1.51597738e-01f, 1.54901043e-01f, 3.62096168e-02f, -2.23547667e-02f, 1.29842073e-01f,
  1.48649156e-01f, 1.15535200e-01f, 4.52465117e-02f, 1.31196037e-01f, -1.40798138e-02f, 9.07072052e-02f, 1.05251543e-01f, 1.52237624e-01f, 1.09327786e-01f, 2.56417990e-01f,
  5.60909696e-02f, 3.72785665e-02f, 7.09588826e-02f, 1.30178239e-02f, 1.06786266e-01f, -6.67599514e-02f, -1.92214809e-02f, -2.48045642e-02f, -2.92546134e-02f, 7.99097493e-02f,
  -4.32448387e-02f, -5.04841357e-02f, 3.30910794e-02f, 4.49664965e-02f, 8.29691216e-02f, -3.41794267e-02f, 1.51293622e-02f, 2.25426853e-02f, 7.68201649e-02f, -2.99729332e-02f,
  -3.75789925e-02f, -3.70029849e-03f, 4.75654788e-02f, 2.47349273e-02f, 1.04472905e-01f, -1.92557555e-02f, 7.21532702e-02f, -4.49998565e-02f, -2.45785378e-02f, 1.85034820e-03f,
  3.23981233e-02f, -1.93435669e-01f, 1.51092321e-01f, 6.46274537e-02f, 1.02658132e-02f, 5.03083691e-03f, 1.39810979e-01f, 4.42069694e-02f, 4.00206447e-02f, 1.00924373e-01f,
  -3.44251953e-02f, 4.66531403e-02f, 1.15851695e-02f, 1.48635179e-01f, 1.52709754e-02f, 9.65948328e-02f, 1.77835554e-01f, 2.58040354e-02f, 1.25275046e-01f, 6.25592694e-02f,
  1.79712996e-01f, 8.07222277e-02f, -4.80931401e-02f, 8.09839293e-02f, 8.36686492e-02f, 4.19349782e-02f, 2.42997613e-02f, 1.26820937e-01f, -1.61725809e-04f, 1.48104995e-01f,
  -7.38263056e-02f, -1.14060313e-01f, -2.58189946e-01f, -1.42562419e-01f, -2.48975426e-01f, -1.86926365e-01f, -1.47123531e-01f, 3.64036709e-02f, 1.14717953e-01f, -1.04447149e-01f,
  -6.91969991e-02f, 5.36099784e-02f, -1.57816056e-02f, 2.18662918e-02f, 7.16289133e-02f, -1.23068206e-01f, -2.08273470e-01f, -1.50144145e-01f, 7.97075257e-02f, -2.35681981e-02f,
  -7.36955088e-03f, -3.18196416e-02f, -2.45573674e-03f, 3.76612321e-02f, 1.00240827e-01f, 5.63750118e-02f, -1.18073590e-01f, -1.38654232e-01f, -4.63690273e-02f, -8.52120966e-02f,
  -1.74502224e-01f, -1.33461148e-01f, 1.11760072e-01f, 1.32914186e-01f, 5.85087575e-02f, 3.68942991e-02f, -5.68784885e-02f, 1.62012398e-01f, 1.16381422e-01f, -1.46289552e-02f,
  2.10984666e-02f, -4.48794961e-02f, -2.35318933e-02f, 2.96332594e-02f, -7.93197900e-02f, 5.17192446e-02f, -9.16606002e-03f, 1.23417668e-01f, 3.73541228e-02f, 9.51703638e-02f,
  2.41644513e-02f, -3.83459739e-02f, 3.44914943e-02f, 9.13609937e-02f, 3.65468301e-02f, 6.48701787e-02f, 3.95983178e-03f, 3.58183496e-02f, -1.96198002e-02f, 5.38935103e-02f,
  -1.25259146e-01f, -1.30009092e-02f, -1.04465120e-01f, 4.12042486e-03f, 3.02297305e-02f, 2.69474704e-02f, 2.93101780e-02f, -4.08420563e-02f, -4.26801220e-02f, -5.55860857e-03f,
  -1.19770588e-02f, -1.11167125e-01f, -4.67230044e-02f, 7.04216734e-02f, -1.24358848e-01f, -4.55877930e-02f, 3.15230154e-02f, -1.44528784e-02f, 5.80493174e-02f, -7.38388300e-02f,
  -7.04763681e-02f, -2.26928107e-02f, -5.60455024e-02f, 1.11533247e-01f, -8.63243416e-02f, -1.62415296e-01f, -8.71591736e-03f, -5.04751913e-02f, -2.33657546e-02f, -9.91436765e-02f,
  9.51263756e-02f, -7.20695704e-02f, 3.23217846e-02f, 1.74886316e-01f, 1.18184667e-02f, 7.47082978e-02f, 7.30322525e-02f, 7.00253621e-02f, 1.62584055e-02f, 5.04240468e-02f,
  -4.84820269e-03f, 1.31065816e-01f, 1.15414105e-01f, 1.31989524e-01f, 4.09423970e-02f, 1.12336829e-01f, 5.29602095e-02f, 6.83759106e-03f, 6.26419932e-02f, 1.93991125e-01f,
  1.51220575e-01f, 1.83460370e-01f, 1.89354733e-01f, 8.78863186e-02f, 1.51793286e-01f, 1.05888128e-01f, 1.50764793e-01f, 1.88182488e-01f, 1.27389923e-01f, 2.10688964e-01f,
  1.19218631e-02f, -3.03757787e-01f, 3.99187915e-02f, -1.18530676e-01f, -1.78216517e-01f, 3.38922702e-02f, -7.75813162e-02f, 2.65829526e-02f, -2.32375294e-01f, -3.10324430e-01f,
  -3.96953613e-01f, -1.79901108e-01f, -1.35326952e-01f, -7.12400898e-02f, 4.65139970e-02f, -2.60453746e-02f, -1.02241151e-01f, 1.10927030e-01f, 1.40594378e-01f, -1.47802249e-01f,
  -1.49956524e-01f, -3.46523151e-02f, -9.48222056e-02f, -1.73499063e-02f, -3.31877381e-01f, -1.23327434e-01f, -1.20204955e-01f, -2.72069544e-01f, -2.70996958e-01f, -2.76008338e-01f,
  -2.75525928e-01f, -1.84841678e-01f, -5.89072406e-02f, -2.33075932e-01f, -2.34618738e-01f, -5.01259230e-02f, -4.29784283e-02f, -3.26777697e-02f, -4.17801924e-02f, -8.67688209e-02f,
  -2.08008602e-01f, -1.39374897e-01f, -2.00166423e-02f, -1.55980408e-01f, -6.97677732e-02f, -7.94287026e-02f, -1.20661601e-01f, -2.33666524e-02f, -2.53864471e-02f, -2.05127284e-01f,
  -3.11334550e-01f, -1.37352318e-01f, -9.29085389e-02f, -6.27634004e-02f, -1.21820390e-01f, -1.12508990e-01f, -1.46289796e-01f, -7.03391507e-02f, -1.75676078e-01f, -2.13274404e-01f,
  9.93165001e-02f, 5.86937480e-02f, -2.43167859e-02f, 1.42736956e-01f, 3.04868929e-02f, 5.35185784e-02f, 1.01344764e-01f, 1.15191162e-01f, 1.13511188e-02f, 5.67787737e-02f,
  8.43497068e-02f, 5.22855595e-02f, 9.52484310e-02f, 2.43944451e-02f, 5.54785356e-02f, 1.10198408e-01f, -1.58748403e-02f, 6.72839060e-02f, 6.99270815e-02f, 1.21364444e-02f,
  7.96115398e-02f, 8.80013183e-02f, 1.26099130e-02f, -2.93048825e-02f, 4.38676924e-02f, -3.99522338e-04f, 1.02982499e-01f, 4.20007296e-02f, 8.41025263e-02f, 7.57525042e-02f,
  -1.81459010e-01f, -7.19949976e-03f, -2.88802952e-01f, -1.57674268e-01f, -2.40946025e-01f, -9.60791111e-02f, -2.26826265e-01f, -1.51592851e-01f, -1.34328872e-01f, -1.26026988e-01f,
  -1.49507985e-01f, -1.34982586e-01f, -1.80337831e-01f, -1.34243816e-01f, -9.96414870e-02f, -1.45424426e-01f, -2.05175266e-01f, -1.97516188e-01f, -1.25609204e-01f, -2.67485082e-01f,
  -1.71656549e-01f, -1.27359256e-01f, -3.50328498e-02f, -9.32427794e-02f, -2.46697158e-01f, -1.83922291e-01f, -8.32327604e-02f, -1.26462638e-01f, -9.55348685e-02f, -1.96041137e-01f,
  1.14183933e-01f, -1.89707518e-01f, 1.48698911e-01f, 1.24332383e-01f, 1.40517995e-01f, 1.22437961e-01f, -8.44734386e-02f, -9.45535749e-02f, 1.08873911e-01f, -1.92202896e-01f,
  -1.50714219e-01f, -8.69821757e-02f, -2.16351241e-01f, -8.11547786e-02f, -1.82646900e-01f, -2.52321839e-01f, -1.69658631e-01f, -5.92206717e-02f, 8.13426524e-02f, 3.13923806e-02f,
  -1.97114944e-02f, 4.14394997e-02f, 1.65346935e-01f, 7.75991008e-02f, 1.03385910e-01f, 5.79273254e-02f, 9.96768475e-02f, 1.59769237e-01f, -4.99567576e-02f, -1.16698265e-01f,
  -1.90456688e-01f, 1.32380173e-01f, 3.54975984e-02f, -1.08033851e-01f, 4.76848260e-02f, -7.39575624e-02f, 2.09406437e-03f, 7.94973373e-02f, 2.23900918e-02f, -1.21349841e-01f,
  4.99606691e-03f, 2.92184595e-02f, -1.93852687e-03f, -5.35312109e-02f, 4.17775586e-02f, -5.04911579e-02f, -5.72344549e-02f, -5.90290464e-02f, 2.45369747e-02f, -4.22924496e-02f,
  -6.28631860e-02f, 1.35545239e-01f, -3.74721438e-02f, 9.02173817e-02f, -6.37678290e-03f, 4.93418686e-02f, 9.44184810e-02f, 8.10458437e-02f, 9.97585654e-02f, -2.92546339e-02f,
  -2.69808676e-02f, 2.72542201e-02f, 5.43975085e-02f, 1.13046672e-02f, -3.97827774e-02f, -4.23362479e-02f, 7.00058509e-03f, 3.05419676e-02f, -1.26336450e-02f, -1.30708585e-03f,
  -1.23511672e-01f, -7.84805864e-02f, -9.07284301e-03f, -3.72445621e-02f, 3.98742259e-02f, 1.19959461e-02f, -1.08193057e-02f, -2.73230467e-02f, 9.47161950e-03f, 3.82316895e-02f,
  -7.85529763e-02f, 5.16082831e-02f, 9.15074944e-02f, -1.41040725e-03f, 3.29031460e-02f, -8.92112777e-02f, 5.25167212e-03f, -2.52981875e-02f, -1.57754142e-02f, 9.90546346e-02f,
  -9.71979871e-02f, 1.27879277e-01f, -1.61788285e-01f, -1.51436757e-02f, 3.13966945e-02f, 8.26758705e-03f, -9.39366315e-03f, 5.67494668e-02f, -8.27528723e-03f, 4.88933586e-02f,
  8.61485675e-02f, -7.05429411e-04f, -1.92178898e-02f, 9.68557373e-02f, -2.12539826e-02f, 1.01051338e-01f, -5.20475060e-02f, 4.21931082e-03f, 2.15156022e-02f, 1.90438703e-03f,
  -5.48992902e-02f, -8.45862627e-02f, -5.11052012e-02f, -2.99980920e-02f, -1.38032194e-02f, 9.41605400e-03f, -1.90530401e-02f, 4.20471914e-02f, 5.63707538e-02f, -1.37849525e-01f,
  2.49234602e-01f, 6.45189509e-02f, 1.27008468e-01f, 1.65828943e-01f, 9.53809619e-02f, 2.00112268e-01f, 1.95873350e-01f, 8.82802755e-02f, 1.34273350e-01f, 4.27950583e-02f,
  6.50925608e-03f, -4.86781523e-02f, -1.48523152e-01f, -1.66274920e-01f, -1.19709354e-02f, 2.04584241e-01f, 2.42543936e-01f, 7.75104091e-02f, -2.37655789e-02f, 9.98605043e-02f,
  1.14160508e-01f, 1.32000223e-02f, -5.21525517e-02f, 7.68783838e-02f, 2.07411796e-01f, 9.41352844e-02f, 1.85391530e-02f, 1.38110146e-01f, 8.83525163e-02f, 1.24379948e-01f,
  5.41661642e-02f, 7.71129057e-02f, -1.30003363e-01f, -3.23696695e-02f, -4.92300875e-02f, 2.16981638e-02f, -8.37254152e-02f, 8.35334957e-02f, -6.12673536e-02f, 1.79610141e-02f,
  -3.41721885e-02f, 2.84027364e-02f, -2.69230828e-02f, 5.32014202e-03f, -3.68599705e-02f, -3.33249494e-02f, 5.64381443e-02f, 9.85641554e-02f, 1.16256289e-02f, 4.43878956e-02f,
  3.89066376e-02f, -1.09808659e-02f, 3.01154405e-02f, 5.45897894e-02f, -1.48396641e-02f, 6.56165481e-02f, 7.20023960e-02f, 3.70317549e-02f, -2.16359794e-02f, 9.58706662e-02f,
  6.94718063e-02f, 7.29400245e-03f, -3.82189825e-02f, -3.79567370e-02f, -6.80428520e-02f, -1.07581206e-02f, 5.03102057e-02f, 1.59012452e-02f, 1.54570639e-02f, -8.81517380e-02f,
  -7.31435046e-02f, -6.24628663e-02f, -3.30577008e-02f, 1.16979815e-01f, 6.75409436e-02f, 2.93881167e-02f, 2.53709536e-02f, -4.01708484e-02f, 4.73938771e-02f, 5.43303089e-03f,
  -2.05975957e-03f, 1.06548138e-01f, 8.93049221e-03f, 2.40322463e-02f, 6.84982091e-02f, -3.34546901e-02f, -6.13962747e-02f, -4.44804579e-02f, 4.35044579e-02f, -4.25663590e-02f,
  -1.33025393e-01f, -1.89975575e-01f, 1.30746067e-01f, -3.07330061e-02f, 5.64375184e-02f, 7.68159553e-02f, 2.47405190e-03f, 1.61266718e-02f, 2.18530577e-02f, 1.26233334e-02f,
  5.64287975e-02f, -6.42541051e-02f, -9.47213322e-02f, 3.32996133e-03f, 1.26065481e-02f, -3.86287947e-03f, -1.85026117e-02f, 2.21969169e-02f, -1.44542363e-02f, 8.65861624e-02f,
  5.71548007e-02f, 8.73384252e-02f, 4.06903923e-02f, -2.52000871e-03f, 4.89135422e-02f, -6.04944229e-02f, 3.00768409e-02f, 3.06236688e-02f, -8.87975246e-02f, 9.15727392e-02f,
  -2.31048867e-01f, 2.77852118e-01f, 8.85766894e-02f, -7.54076093e-02f, 1.23373732e-01f, 8.27187523e-02f, 1.81759030e-01f, 4.61739339e-02f, -9.70684215e-02f, 1.31315500e-01f,
  1.32927060e-01f, -6.77620620e-02f, -9.64798778e-02f, -1.24881886e-01f, -6.06749766e-02f, 1.32367179e-01f, 7.87484285e-04f, -2.48931408e-01f, -2.64472127e-01f, -7.21590370e-02f,
  -1.41051896e-02f, 7.14340527e-03f, -1.68935284e-01f, -7.93908164e-02f, 1.36623576e-01f, -6.69248924e-02f, 2.27826178e-01f, 1.47445858e-01f, 1.65353209e-01f, 9.57736298e-02f,
  -1.40549242e-01f, 4.39134054e-03f, -1.59961432e-01f, -6.19250201e-02f, 4.53967489e-02f, -1.06340110e-01f, -4.89756353e-02f, 4.56855036e-02f, -4.49299179e-02f, 2.68342942e-02f,
  -7.27545656e-03f, 2.99498141e-02f, 3.92374098e-02f, 4.10655513e-02f, 3.14311907e-02f, 7.38674998e-02f, -2.62079332e-02f, 7.11936057e-02f, 6.08738512e-02f, 5.01120165e-02f,
  1.35014519e-01f, 6.97327852e-02f, -1.11329020e-03f, -2.51939502e-02f, 1.10683903e-01f, -5.79769388e-02f, 1.40444547e-01f, 9.22373086e-02f, 8.59071985e-02f, 2.69356407e-02f,
  -8.54409710e-02f, 2.17757979e-03f, 1.28615526e-02f, 5.61051518e-02f, 4.83168960e-02f, -3.04481350e-02f, -5.55895716e-02f, 7.93157816e-02f, 2.17155162e-02f, 5.30789681e-02f,
  7.08537474e-02f, -6.19674176e-02f, -3.66975628e-02f, 1.03762432e-03f, 1.33586124e-01f, -7.68156024e-04f, 7.97324162e-03f, -2.00830586e-02f, 6.15372472e-02f, 7.84815997e-02f,
  -8.54379237e-02f, -4.90140393e-02f, 8.80033523e-02f, -3.56248990e-02f, 1.29500022e-02f, -5.10363393e-02f, 9.25670564e-02f, 1.61905754e-02f, -3.49572562e-02f, -2.56401002e-02f,
  -2.63609514e-02f, -8.88768360e-02f, -1.52029097e-01f, -5.34291491e-02f, 3.00312939e-04f, 5.37924189e-03f, -9.63433683e-02f, -8.50635469e-02f, -3.92329134e-02f, -3.21430191e-02f,
  -2.96996143e-02f, -2.56465692e-02f, -1.62783712e-02f, -2.01151539e-02f, -8.32806081e-02f, -5.07661365e-02f, 2.39184815e-02f, -1.33900106e-01f, -8.00456554e-02f, 6.46874458e-02f,
  -5.33810183e-02f, -9.59413648e-02f, -1.55078024e-01f, -1.30077615e-01f, -2.57837046e-02f, -1.72485143e-01f, -9.57801044e-02f, -9.10844430e-02f, -4.72635478e-02f, 1.58703178e-02f,
  2.18717501e-01f, 1.65324792e-01f, 1.43400311e-01f, -9.73692536e-02f, -3.09848972e-02f, 1.79762214e-01f, 3.29540014e-01f, 1.14530951e-01f, -1.11364387e-01f, 1.64073527e-01f,
  1.18629381e-01f, -1.97619144e-02f, -1.23630650e-01f, 4.52538840e-02f, 1.71672136e-01f, 2.77313709e-01f, 3.24423686e-02f, 1.01329207e-01f, 1.55075435e-02f, 8.22630152e-02f,
  -6.09165877e-02f, 2.66890135e-02f, 5.19952551e-02f, 4.92936745e-02f, -8.41463432e-02f, -2.44684070e-02f, -7.23862723e-02f, 2.68467162e-02f, 4.56625931e-02f, 2.18491163e-03f,
  3.34947258e-02f, 2.60498703e-01f, 8.30656290e-03f, 9.11187206e-04f, 9.73600801e-03f, -2.69045308e-03f, 2.64868122e-02f, 5.53610660e-02f, 8.10580999e-02f, 1.67084351e-01f,
  8.00878108e-02f, 1.43392175e-01f, 9.81782004e-02f, -2.03027092e-02f, 1.27199963e-01f, 8.21351111e-02f, 9.26002786e-02f, 5.61574884e-02f, -2.46997382e-02f, 1.60111293e-01f,
  -5.40702716e-02f, 1.48395851e-01f, 1.59161478e-01f, 9.75447595e-02f, 6.06208667e-02f, -2.30616275e-02f, 1.58697814e-01f, 3.62292714e-02f, 2.50129532e-02f, 9.24961716e-02f,
  -1.22584715e-01f, -3.75742577e-02f, 4.14802469e-02f, -2.36481447e-02f, -1.50213949e-02f, 8.26503113e-02f, -1.28375171e-02f, 6.79527968e-02f, -2.68335156e-02f, -3.36351879e-02f,
  7.50179142e-02f, 5.94324432e-02f, 5.64955026e-02f, 4.39529866e-02f, -5.02341576e-02f, 2.54579037e-02f, 6.79097697e-03f, 9.91773307e-02f, 6.46644598e-03f, 9.77218300e-02f,
  9.97672230e-02f, 2.29890156e-03f, 3.88595797e-02f, -5.23354709e-02f, -9.76123661e-03f, 1.71274468e-02f, 1.25698045e-01f, 6.11328259e-02f, -2.51176041e-02f, 7.38296062e-02f,
  -6.98716044e-02f, 1.04425848e-01f, 1.29859731e-01f, 1.25992581e-01f, 1.25517249e-01f, 4.22742851e-02f, -1.77291203e-02f, 3.85224596e-02f, 7.56704882e-02f, 6.62564859e-02f,
  4.49725464e-02f, 6.78138584e-02f, -1.99011574e-03f, 1.26209795e-01f, 1.07568897e-01f, 2.89884508e-02f, 6.04982674e-03f, -4.29817848e-02f, 2.33307332e-02f, 1.02030911e-01f,
  1.05415799e-01f, 1.86739057e-01f, 1.94829911e-01f, 4.91941646e-02f, 3.47784944e-02f, 5.25082685e-02f, 1.21984847e-01f, 8.75138212e-03f, 1.09332576e-01f, 1.04949377e-01f,
  2.50270605e-01f, -5.98475151e-02f, -1.08909849e-02f, -1.07629299e-02f, -1.53343696e-02f, -1.50273517e-01f, -1.86516047e-01f, 4.06289883e-02f, 1.13449275e-01f, -8.78755152e-02f,
  -1.22204617e-01f, 4.95270342e-02f, -9.24143642e-02f, -3.37801315e-02f, -2.06938460e-02f, -1.62112460e-01f, -1.56515360e-01f, -1.19434081e-01f, 1.69172343e-02f, -1.45314941e-02f,
  -6.46541268e-02f, 1.94884855e-02f, 1.68119162e-01f, 1.16795860e-01f, -5.09130247e-02f, -1.16033358e-02f, 8.17030370e-02f, -3.00981831e-02f, -1.00375704e-01f, -6.03038631e-02f,
  -1.56052783e-01f, 1.41762346e-01f, -9.68831703e-02f, -1.17536820e-03f, -5.29662445e-02f, 8.02426785e-02f, -9.19918716e-02f, 1.19936295e-01f, 3.49061266e-02f, -3.99273597e-02f,
  7.23810196e-02f, 5.57011217e-02f, -3.68566848e-02f, -3.17856260e-02f, 1.01559080e-01f, 1.09141402e-01f, 1.19524218e-01f, 1.42909080e-01f, 7.90223777e-02f, 4.04788889e-02f,
  -4.55726795e-02f, -7.78738856e-02f, -1.68811306e-02f, 2.33688671e-02f, 3.43747064e-02f, -6.29536510e-02f, 6.58274069e-02f, 2.07113177e-02f, 1.01759277e-01f, 5.31760231e-02f,
  -3.58298905e-02f, 3.78043987e-02f, -1.89336985e-02f, 9.82742682e-02f, -8.70553032e-03f, 1.15803316e-01f, -1.18504111e-02f, -4.71440107e-02f, 5.10314740e-02f, 6.70403689e-02f,
  6.35876954e-02f, -1.93129703e-02f, 4.97667305e-02f, 5.43975569e-02f, 1.04964497e-02f, 4.13791612e-02f, -4.71996814e-02f, 8.41942057e-02f, 2.69648079e-02f, 7.10536316e-02f,
  -5.07904589e-02f, -1.24781299e-03f, 2.99520940e-02f, 3.67302187e-02f, 5.29761016e-02f, 9.08063501e-02f, 5.64737283e-02f, 1.56702287e-02f, 1.34188458e-01f, 6.63790107e-02f,
  -1.25859261e-01f, -5.89508638e-02f, -4.20156457e-02f, -2.21304782e-03f, -1.30772907e-02f, 1.18256316e-01f, -2.54766596e-03f, 1.63153782e-02f, 3.95643264e-02f, 6.06760308e-02f,
  -2.09751036e-02f, -9.47186165e-03f, -3.98399457e-02f, 1.73613857e-02f, -1.24045403e-03f, -2.41297800e-02f, -2.74603758e-02f, -4.24656011e-02f, -3.49503607e-02f, 1.68421119e-02f,
  1.27374887e-01f, -1.15156092e-01f, -9.06673893e-02f, -6.92675561e-02f, 4.44000326e-02f, -1.22247115e-01f, -1.67045981e-01f, -7.62318671e-02f, -8.46883282e-02f, -5.21734655e-02f,
  -1.63570955e-01f, -1.47638202e-01f, -3.13961297e-01f, -1.63549379e-01f, -2.21727878e-01f, -1.84583843e-01f, -1.04107618e-01f, 2.13494524e-03f, -2.75568361e-03f, -2.38686278e-02f,
  2.89463419e-02f, -8.39031115e-02f, -1.93868130e-01f, -6.06085658e-02f, -1.25768006e-01f, 6.51127659e-04f, -7.03683123e-02f, -9.57503915e-03f, -6.63924590e-02f, -4.77469675e-02f,
  5.12043796e-02f, -1.27937058e-02f, 9.38545540e-02f, -1.68841202e-02f, -1.92558710e-02f, -4.39513363e-02f, -1.73207134e-01f, -5.88875934e-02f, 7.59687722e-02f, -1.02850929e-01f,
  -2.61671990e-01f, -3.10614109e-01f, -4.64829952e-02f, -2.71490961e-02f, -1.87142398e-02f, 1.17139854e-01f, 7.05207437e-02f, 3.95315923e-02f, 1.25585139e-01f, -4.48042905e-04f,
  2.94241644e-02f, -5.39416634e-02f, 4.17589163e-03f, -8.67440458e-03f, 6.53889924e-02f, -1.22938287e-02f, 2.20591929e-02f, -7.75019825e-02f, 5.88844307e-02f, -7.84517080e-03f,
  2.99980566e-02f, 1.80433318e-02f, -1.16220176e-01f, 6.85405433e-02f, 7.79703781e-02f, -1.09714279e-02f, 5.40901795e-02f, 3.06836106e-02f, 3.45650688e-02f, -3.39873917e-02f,
  1.64282858e-01f, 2.78566126e-02f, 4.80806045e-02f, 8.21480006e-02f, 6.85821176e-02f, 2.59094797e-02f, -2.24521291e-02f, 2.57817488e-02f, 1.06730953e-01f, 1.77013855e-02f,
  2.62251142e-02f, 3.66911143e-02f, 5.29741757e-02f, -1.16345519e-02f, -7.62594342e-02f, 1.43441446e-02f, 1.93933807e-02f, 8.56702700e-02f, 8.54706615e-02f, 1.20086018e-02f,
  3.44134122e-02f, 5.07650040e-02f, 6.67802989e-02f, 1.00813858e-01f, -4.11503986e-02f, -4.41929437e-02f, -4.25709710e-02f, 3.17899622e-02f, -5.38893640e-02f, 4.41033617e-02f,
  -4.20232490e-02f, -1.67066514e-01f, 6.17332272e-02f, 4.05591987e-02f, 2.05364674e-02f, 2.77504232e-02f, -1.15726560e-01f, 6.87983856e-02f, -5.68391308e-02f, -2.82455459e-02f,
  1.52807124e-02f, -2.07871702e-02f, -9.00718421e-02f, -2.89784167e-02f, 1.10221626e-02f, -3.58635969e-02f, 1.06594209e-02f, 1.78525876e-02f, -1.64535139e-02f, 7.03267604e-02f,
  5.71108013e-02f, 4.96650189e-02f, 7.51343695e-03f, 8.99064913e-03f, 4.45567816e-02f, -1.08539701e-01f, -1.74672604e-02f, 3.83352414e-02f, -5.49461357e-02f, 9.47336406e-02f,
  1.13663554e-01f, 1.14279442e-01f, -1.85770944e-01f, 2.65796687e-02f, -7.95818418e-02f, 1.55457929e-01f, 1.92935705e-01f, 2.14957401e-01f, -5.68828024e-02f, -1.78344980e-01f,
  -2.52008975e-01f, -1.70878649e-01f, -2.53376722e-01f, -1.31654590e-01f, -3.97299305e-02f, 5.05225770e-02f, -4.72900793e-02f, -2.06437618e-01f, -2.85744183e-02f, 5.08662127e-02f,
  -9.55573320e-02f, -4.82736435e-03f, 5.42365722e-02f, 6.53074831e-02f, -9.78336185e-02f, -2.04685077e-01f, -1.74954906e-01f, -8.60006958e-02f, -1.48107097e-01f, -2.54269093e-01f,
  -3.56269032e-01f, 4.90834489e-02f, -1.72073767e-01f, -2.48551860e-01f, -7.93775842e-02f, -8.65268484e-02f, -1.14170901e-01f, -8.70322362e-02f, -9.57305208e-02f, -6.18892983e-02f,
  -1.41438484e-01f, -1.81258500e-01f, -1.94927543e-01f, -2.79941261e-02f, -1.38256460e-01f, -5.70325740e-02f, 2.61371932e-03f, -6.52541174e-03f, -9.55804214e-02f, -4.69274400e-03f,
  -1.35716364e-01f, -1.43778682e-01f, -1.28448024e-01f, -4.77018692e-02f, 6.58154264e-02f, -1.79683983e-01f, -1.64776191e-01f, -1.69486344e-01f, -7.51441792e-02f, -1.43058687e-01f,
  -1.01155136e-02f, -3.97945978e-02f, 9.48054567e-02f, 1.28681302e-01f, 3.74279283e-02f, 1.07909836e-01f, 1.69016078e-01f, 8.47672522e-02f, 9.00754854e-02f, 1.08389162e-01f,
  1.82715818e-01f, 3.97121310e-02f, 1.71836242e-01f, 2.11795643e-01f, 2.31549442e-02f, 1.26227424e-01f, 2.17732415e-02f, 1.44313529e-01f, 1.05611555e-01f, 1.09471589e-01f,
  -3.43753360e-02f, 8.46594945e-02f, 1.13020800e-01f, 3.24750319e-02f, 1.31027892e-01f, 1.05594948e-01f, 7.95992389e-02f, 1.68352246e-01f, 1.51124790e-01f, 1.57541841e-01f,
  -1.54326871e-01f, -8.44421536e-02f, -2.75877029e-01f, -1.45190805e-01f, -5.05229980e-02f, -2.04523318e-02f, -1.76901057e-01f, -2.43933722e-02f, -1.19228497e-01f, -8.16853791e-02f,
  -1.30257919e-01f, -6.66924054e-03f, -8.53732750e-02f, -7.04964772e-02f, -3.75792794e-02f, -9.66514945e-02f, -6.75650388e-02f, -6.94166049e-02f, -1.21267952e-01f, 3.15515734e-02f,
  -3.81675586e-02f, -1.28188714e-01f, 9.24481824e-03f, -1.13277562e-01f, -2.53575463e-02f, -1.64560318e-01f, -8.65400881e-02f, -5.01480028e-02f, -1.65143102e-01f, -6.62239343e-02f,
  -1.42753899e-01f, 8.24497640e-02f, -2.85925120e-01f, -2.26871684e-01f, -1.77653342e-01f, -1.07364602e-01f, 5.33851534e-02f, -2.84712482e-02f, -1.10357590e-01f, -8.75521824e-02f,
  -1.75766513e-01f, -1.74621165e-01f, -2.97227502e-01f, -2.41574511e-01f, 1.99778210e-02f, -3.89127210e-02f, 1.96652524e-02f, -2.64322143e-02f, -1.13481030e-01f, 8.81498493e-03f,
  6.93881288e-02f, 9.26403031e-02f, 2.59061344e-02f, -7.16780871e-02f, 1.78991091e-02f, -2.02576563e-01f, -4.73690368e-02f, -1.22457460e-01f, -2.34240945e-02f, 2.41633654e-02f,
  -3.32461923e-01f, -6.71447814e-03f, -1.50361598e-01f, -9.26087573e-02f, -1.70404211e-01f, -1.19067663e-02f, -1.49936721e-01f, -5.25117517e-02f, -1.54694587e-01f, -4.54737768e-02f,
  -1.30636334e-01f, -7.40785152e-02f, -1.57876164e-01f, -6.59913644e-02f, -1.23572312e-01f, -5.10245329e-03f, 6.98720068e-02f, 2.82534342e-02f, -6.25120997e-02f, -1.00334853e-01f,
  1.51873333e-02f, -1.61308214e-01f, -1.88642398e-01f, -3.35940458e-02f, -8.05706438e-03f, -7.71839768e-02f, -1.64804623e-01f, -1.31564960e-01f, -1.44349650e-01f, -7.28769675e-02f,
  -1.05420120e-01f, -7.66995773e-02f, 3.77093367e-02f, 9.40620247e-03f, 9.43493098e-02f, -1.25652626e-02f, -8.48843455e-02f, 3.05177104e-02f, 2.95522492e-02f, -3.28190215e-02f,
  -3.54047120e-02f, -2.97180116e-02f, 2.97587290e-02f, -7.81667754e-02f, 2.46886928e-02f, -1.68522187e-02f, -9.97774187e-04f, 3.50152478e-02f, 7.11655803e-03f, 3.61121283e-03f,
  -7.20249936e-02f, -2.07555443e-02f, -8.83308891e-03f, 1.24718614e-01f, 6.25173673e-02f, 1.01075254e-01f, 3.34960073e-02f, -1.39026847e-02f, -4.31044474e-02f, 7.97589645e-02f,
  -9.68712419e-02f, 6.98285410e-03f, -2.24173531e-01f, -3.53530087e-02f, -6.88135624e-02f, -1.23611234e-01f, -7.24981502e-02f, -8.58687311e-02f, -1.73272192e-01f, -1.06194057e-02f,
  -7.37178922e-02f, -6.04253858e-02f, -1.24530442e-01f, -5.53841032e-02f, 7.89069850e-03f, -8.11505169e-02f, -2.78521013e-02f, -1.51226431e-01f, -6.05236478e-02f, -1.27497688e-01f,
  -6.62691593e-02f, -1.49628773e-01f, -1.45589113e-01f, -2.50228435e-01f, -1.54323027e-01f, -2.51754045e-01f, -2.18177035e-01f, -1.56405807e-01f, -1.36158556e-01f, -9.51249152e-02f,
  -3.22370678e-02f, 1.45750076e-01f, -2.09195271e-01f, -6.45296928e-03f, -1.30871281e-01f, 1.09444847e-02f, -1.12199269e-01f, 1.52824372e-01f, 7.13899583e-02f, -1.73496455e-02f,
  1.50332928e-01f, 2.95464247e-01f, 1.75543651e-01f, 2.29482934e-01f, 2.60917455e-01f, 4.65856306e-02f, 1.54167339e-02f, 3.11576966e-02f, 2.96494905e-02f, 1.11585476e-01f,
  1.64691478e-01f, 7.59519711e-02f, 1.43685620e-02f, 1.93648592e-01f, 7.65972212e-02f, 1.53544411e-01f, -1.42360821e-01f, -5.04151471e-02f, 1.34626880e-01f, -8.68967827e-03f,
  -1.73558146e-01f, 6.62934184e-02f, 9.98345986e-02f, 1.47118464e-01f, 1.27560809e-01f, 7.98072368e-02f, 1.68029055e-01f, 1.18839756e-01f, 9.12030339e-02f, 6.97609261e-02f,
  1.19402349e-01f, 1.65774256e-01f, 1.25045985e-01f, 3.39730084e-02f, 1.27319783e-01f, 2.94701941e-02f, 6.90996572e-02f, 3.19521092e-02f, 1.40654415e-01f, 1.01113603e-01f,
  1.87023252e-01f, 4.49930951e-02f, -2.30961535e-02f, 7.36935660e-02f, 1.73973471e-01f, 9.74220410e-02f, 4.40225005e-02f, 1.02589853e-01f, 1.82203859e-01f, 2.47980151e-02f,
  -6.77986816e-02f, -7.35990983e-03f, 3.33208069e-02f, -8.28253478e-02f, -7.90151134e-02f, -9.81867835e-02f, -2.39308700e-02f, -1.34094078e-02f, 3.67045477e-02f, 2.69882660e-02f,
  3.30876708e-02f, -1.25176489e-01f, -9.77493450e-03f, -6.69799075e-02f, 1.88380815e-02f, -3.86705920e-02f, -1.67302061e-02f, 1.85392611e-02f, 4.31671813e-02f, 3.69367935e-02f,
  -8.28076005e-02f, -1.18196942e-01f, -1.42502964e-01f, -3.98208247e-03f, 2.39533391e-02f, -4.20489442e-03f, 8.32972676e-03f, 2.10402030e-02f, 5.02122659e-03f, -3.13704833e-02f,
  3.90135087e-02f, 1.15282997e-01f, -8.44663009e-03f, 8.54705051e-02f, 5.11822179e-02f, 1.16847418e-01f, 5.30149415e-02f, 1.68844655e-01f, 5.77793792e-02f, 9.30532888e-02f,
  5.71535230e-02f, 6.50887117e-02f, 4.99758832e-02f, 1.24610931e-01f, -5.19555015e-03f, 1.09895803e-01f, 1.07896008e-01f, 8.28110948e-02f, 1.84198007e-01f, 1.49909453e-02f,
  8.55438598e-03f, 4.42072675e-02f, 4.81082350e-02f, 6.42612055e-02f, 4.00773250e-04f, 6.46186396e-02f, 7.56113157e-02f, 3.90379131e-02f, -3.64184985e-03f, -9.78415683e-02f,
  -3.14802200e-01f, -8.68909154e-03f, -7.60136098e-02f, 2.46954933e-02f, 1.76072717e-01f, 2.16348290e-01f, 2.66940027e-01f, 1.31664753e-01f, 4.82297204e-02f, 4.18618619e-02f,
  1.14298783e-01f, -7.19554350e-02f, -1.15115143e-01f, -1.98542327e-02f, -1.46910008e-02f, 1.57751769e-01f, 5.93092409e-04f, -1.36553690e-01f, -7.15957433e-02f, 1.67575210e-01f,
  1.28918156e-01f, 7.85470067e-04f, -1.49783224e-01f, -4.63646576e-02f, 3.58504392e-02f, 1.00698881e-01f, 1.30754918e-01f, 5.92108965e-02f, 4.13856059e-02f, 6.73274472e-02f,
  -9.12420154e-02f, -8.48292708e-02f, 3.43085341e-02f, -2.36580223e-02f, 5.89829357e-03f, -4.76642326e-02f, 9.48452130e-02f, -7.69174099e-02f, -4.89175171e-02f, 8.04833770e-02f,
  2.81243888e-03f, 4.51801307e-02f, 1.88326072e-02f, 2.97806431e-02f, -4.23886850e-02f, 1.35342881e-01f, 5.69567941e-02f, 3.79010290e-02f, 2.44399365e-02f, 8.78479108e-02f,
  7.53991976e-02f, -1.80973969e-02f, -3.02316081e-02f, 6.67545572e-02f, 9.14652497e-02f, -5.99866472e-02f, 4.19349410e-02f, 3.75815071e-02f, -5.61948083e-02f, -4.56677638e-02f,
  9.62722749e-02f, -3.58085595e-02f, -5.18342713e-03f, 1.04030073e-01f, -4.44605481e-03f, 3.17385828e-04f, 7.29508549e-02f, 1.05863966e-01f, 7.25210384e-02f, -6.07230663e-02f,
  9.79468506e-03f, -1.97110437e-02f, 2.54526474e-02f, -6.37356266e-02f, 1.44673893e-02f, -1.18686873e-02f, -5.08741476e-03f, -1.46055203e-02f, -4.23349403e-02f, -7.87193105e-02f,
  -6.59822747e-02f, -5.39754443e-02f, -1.25131421e-02f, -8.27800424e-04f, -3.98440771e-02f, -1.14619164e-02f, -6.46047518e-02f, -4.74529602e-02f, -9.83860716e-02f, -8.16234648e-02f,
  1.54783979e-01f, -5.38962074e-02f, 1.40895873e-01f, 3.69602591e-02f, -6.79878332e-03f, 4.08019051e-02f, 5.38267940e-02f, 3.48682255e-02f, 7.20963627e-02f, 3.48403193e-02f,
  1.21576823e-01f, 5.46484031e-02f, -1.84718091e-02f, -1.83585137e-02f, 5.97717762e-02f, 2.25486662e-02f, 1.50558636e-01f, -2.55056620e-02f, 1.18355647e-01f, 6.31857142e-02f,
  5.60839251e-02f, 8.85844007e-02f, 8.15734193e-02f, 1.06667928e-01f, 9.93917063e-02f, 1.19950801e-01f, 7.76914954e-02f, 1.42364606e-01f, 3.64945866e-02f, 1.08217105e-01f,
  -2.04404816e-01f, 2.02595815e-02f, 9.93967056e-02f, -1.15172230e-01f, 1.84720650e-01f, 7.93072283e-02f, 1.29712462e-01f, 1.48168847e-01f, -2.07191221e-02f, -1.51403295e-02f,
  6.13860898e-02f, 3.25827189e-02f, 3.24756131e-02f, 2.57572420e-02f, 1.37963340e-01f, -8.05980191e-02f, -3.35696936e-02f, 6.59992313e-03f, 1.25003889e-01f, 4.12204936e-02f,
  -5.73539510e-02f, 4.63389879e-04f, -2.12207623e-02f, 2.41695754e-02f, -1.33986011e-01f, -2.02654079e-02f, -8.05677380e-04f, 7.61529654e-02f, -1.81092899e-02f, -1.53579444e-01f,
  -4.31235358e-02f, 1.23363689e-01f, 8.62438455e-02f, 5.28121702e-02f, 1.76940113e-01f, 5.80491871e-02f, 4.04159576e-02f, 7.03700557e-02f, -1.55057255e-02f, 9.82805640e-02f,
  4.33584712e-02f, -1.87355671e-02f, 1.34962723e-01f, 9.77545753e-02f, 2.01950707e-02f, 3.81816253e-02f, 2.05887586e-01f, 2.10144222e-02f, 1.65217325e-01f, 4.54830416e-02f,
  6.78893253e-02f, 6.54814392e-02f, 5.64280488e-02f, 9.20628384e-02f, 1.73028424e-01f, 3.97723056e-02f, 1.16405882e-01f, 2.28043068e-02f, 1.58208072e-01f, -5.69989271e-02f,
  -4.91805598e-02f, -8.38890206e-03f, -9.11408477e-03f, -2.08345339e-01f, -7.24566430e-02f, -1.17756940e-01f, -1.35649741e-01f, -1.45231888e-01f, -1.17398873e-01f, -8.79232734e-02f,
  -3.32238115e-02f, -5.22079691e-02f, -1.49049833e-01f, -1.47638053e-01f, -1.15424752e-01f, -5.73313423e-02f, -6.66835606e-02f, -1.74871668e-01f, -6.47017211e-02f, -7.30339363e-02f,
  -2.30026003e-02f, -6.29023314e-02f, -3.95389721e-02f, -8.97177681e-02f, -5.64198904e-02f, -1.72009528e-01f, -1.88139588e-01f, -1.59334391e-01f, -2.79442668e-02f, -1.41428500e-01f,
  5.47618158e-02f, 2.39402086e-01f, 7.67673086e-03f, 4.00841348e-02f, 1.04830280e-01f, 1.89958259e-01f, 4.69524674e-02f, 1.25416309e-01f, 1.48911417e-01f, 3.88003327e-02f,
  1.70264482e-01f, -1.60980467e-02f, -1.74095167e-03f, 1.22781679e-01f, 7.50826672e-02f, 9.99473408e-02f, 7.76723102e-02f, 7.30947927e-02f, 6.84686527e-02f, 2.83610020e-02f,
  1.70646086e-01f, 1.50943160e-01f, 6.39510602e-02f, 1.49164334e-01f, 9.74500552e-02f, -1.40702091e-02f, -8.20001308e-03f, 1.07423887e-01f, 1.14514373e-01f, -9.70388874e-02f,
  9.14086327e-02f, 1.32379815e-01f, 1.27585769e-01f, 2.95219645e-02f, -9.69130471e-02f, 1.15556218e-01f, 9.29723084e-02f, 3.58123891e-02f, -4.03578542e-02f, -3.85570191e-02f,
  -3.40448314e-04f, -2.16174364e-01f, -2.17954442e-01f, -5.68668619e-02f, -1.13681816e-01f, -6.01874739e-02f, -9.25289020e-02f, -1.64541334e-01f, -1.00409694e-01f, -1.56212643e-01f,
  -1.62517905e-01f, -1.58639625e-01f, -2.02289090e-01f, -1.89202204e-01f, -1.95961043e-01f, -1.64291918e-01f, -1.75307095e-01f, -3.84673439e-02f, -1.53207317e-01f, -1.61943033e-01f,
  1.83701023e-01f, 1.91711396e-01f, -7.13245757e-03f, -4.52411026e-02f, 9.93570462e-02f, 1.39051706e-01f, 3.74239236e-02f, 7.72706270e-02f, 6.96937516e-02f, -1.38599928e-02f,
  -5.63703515e-02f, 7.63510987e-02f, 1.55876847e-02f, 5.93719743e-02f, 4.89583313e-02f, 1.78522877e-02f, 1.14350349e-01f, -3.14640589e-02f, -1.08739277e-02f, 1.80153444e-01f,
  2.53412295e-02f, -2.66323462e-02f, 1.07073702e-01f, 1.24139361e-01f, 9.70583595e-03f, -4.24584188e-02f, 1.17684700e-01f, 1.16989821e-01f, -3.65129262e-02f, 1.38008058e-01f,
  2.36948393e-02f, -1.12395756e-01f, 1.32453479e-02f, 3.16432305e-02f, -1.26918808e-01f, 2.79214676e-03f, -1.25477776e-01f, -9.05361697e-02f, 2.21186541e-02f, -4.08285223e-02f,
  -8.80413689e-03f, 2.46871728e-02f, -8.17034692e-02f, -1.36153400e-01f, -9.20416564e-02f, -5.08598238e-02f, -1.88592076e-02f, -1.14693530e-01f, -1.18715622e-01f, -1.36138380e-01f,
  -4.02405411e-02f, 2.74235234e-02f, -8.45468119e-02f, -4.28232066e-02f, 7.67743308e-03f, -1.58162817e-01f, -4.96084169e-02f, -2.71361265e-02f, -4.78871763e-02f, 9.59386211e-03f,
  -1.13518294e-02f, -4.55618016e-02f, 1.12851322e-01f, 3.46157327e-02f, 1.36791751e-01f, 6.17997684e-02f, -7.45806545e-02f, 6.25075474e-02f, 2.18522269e-02f, -8.65932647e-03f,
  5.89970276e-02f, -9.97228082e-03f, -5.69631532e-03f, 1.20800519e-02f, 1.56990774e-02f, 5.28167896e-02f, 4.77731451e-02f, 5.18494323e-02f, -3.49497162e-02f, 9.89110768e-02f,
  4.15798426e-02f, 2.17813868e-02f, 1.00950971e-01f, 1.41570002e-01f, 7.98719972e-02f, -6.92662150e-02f, -4.22902703e-02f, 8.17166641e-02f, -1.08319568e-02f, 2.01166064e-01f,
  -2.18511149e-01f, 4.45841206e-03f, 4.10090387e-03f, -9.19219702e-02f, -6.69552535e-02f, -1.57654032e-01f, -9.50738341e-02f, -3.45865041e-02f, -9.66635793e-02f, -1.08839341e-01f,
  3.97500284e-02f, 2.54173815e-01f, 1.58278793e-01f, 8.21317211e-02f, -1.08250836e-02f, -1.92575887e-01f, -1.23245828e-01f, -5.13601787e-02f, 3.66133451e-02f, -1.57808196e-02f,
  -7.08164126e-02f, -1.09599195e-01f, -1.03375703e-01f, 2.62715816e-02f, -5.50352670e-02f, 2.64707804e-02f, -1.79517083e-02f, -6.85843676e-02f, 2.50001103e-02f, -1.10463291e-01f,
  1.35562018e-01f, 6.25085309e-02f, 1.25499547e-01f, 1.43922344e-01f, 4.21028771e-02f, 1.04197823e-01f, 1.31158248e-01f, 1.08917236e-01f, 1.33504167e-01f, 8.33280683e-02f,
  1.23639069e-01f, 1.02218963e-01f, 8.81893262e-02f, 8.58903229e-02f, -6.09949883e-03f, 4.15480062e-02f, 1.25687659e-01f, 1.45843148e-01f, 1.35130987e-01f, 4.78632422e-03f,
  3.04657184e-02f, -5.42835845e-03f, 8.85792226e-02f, 1.04120411e-01f, 1.32646188e-01f, 8.08904842e-02f, 7.60449767e-02f, 7.13541731e-02f, 1.20102592e-01f, -8.24589375e-03f,
  1.33218884e-01f, 8.39825198e-02f, 1.49526754e-02f, -1.12014404e-02f, -4.42959368e-02f, 1.14110216e-01f, -2.31647417e-02f, 4.31932993e-02f, 1.43509991e-02f, 6.67737499e-02f,
  2.68792436e-02f, -1.42426081e-02f, 1.83527153e-02f, 5.87800331e-02f, 5.78188747e-02f, -6.70880601e-02f, 2.15958040e-02f, 7.27863312e-02f, -2.16728933e-02f, 3.05836163e-02f,
  2.97026546e-03f, 3.12550254e-02f, 4.88197654e-02f, 5.08772023e-02f, 5.10376021e-02f, 5.14041893e-02f, -3.65683213e-02f, 1.06382249e-02f, 3.23512778e-02f, -3.93925235e-02f,
  1.38934046e-01f, 1.51586354e-01f, -5.59064224e-02f, -2.13514920e-02f, 4.59648892e-02f, 4.71505150e-03f, 7.76386335e-02f, 5.44016510e-02f, 1.28437355e-02f, -5.10958321e-02f,
  -1.55691402e-02f, 8.00132826e-02f, 3.27933505e-02f, 7.45962039e-02f, -5.29083088e-02f, -8.19162058e-04f, -7.97503293e-02f, -5.68323955e-03f, 9.83283520e-02f, 7.77549157e-03f,
  -3.26998234e-02f, 2.55729165e-03f, 3.07482164e-02f, -6.97630122e-02f, -5.33909500e-02f, -5.18094636e-02f, -7.45978504e-02f, -5.66850640e-02f, 1.22480299e-02f, -1.25586092e-01f,
  3.74881566e-01f, -2.55894899e-01f, -6.74598590e-02f, 2.27550745e-01f, -8.14006012e-03f, -1.96249589e-01f, -2.91851282e-01f, -1.69866890e-01f, 3.64435576e-02f, -1.50225624e-01f,
  2.06346903e-02f, 8.20164457e-02f, 2.93086413e-02f, -3.92746739e-02f, 2.86010117e-03f, -1.20126218e-01f, -7.77849033e-02f, 1.52295291e-01f, 1.44313946e-01f, -6.28132522e-02f,
  2.84787957e-02f, 2.35137306e-02f, 2.12688580e-01f, -3.61817405e-02f, -4.51040408e-03f, 8.12443048e-02f, -1.31700644e-02f, -1.21218398e-01f, -4.45040166e-02f, -3.24486233e-02f,
  2.19542056e-01f, -5.71551584e-02f, 6.26123622e-02f, 3.80208530e-02f, 1.33788422e-01f, 6.14578128e-02f, 9.68353301e-02f, 1.59276705e-02f, 9.31424797e-02f, -3.78641896e-02f,
  -1.86816312e-03f, 1.93820540e-02f, -3.18413600e-02f, 6.15801252e-02f, -2.50239950e-02f, -9.08094086e-03f, -1.45207256e-01f, 3.78042050e-02f, 1.51265422e-02f, -3.77373062e-02f,
  3.44294426e-03f, -1.46429660e-02f, 9.55009926e-03f, -6.25103489e-02f, -1.34819463e-01f, 1.14861071e-01f, -6.62261695e-02f, -5.12515232e-02f, -4.70776670e-02f, -6.58955425e-02f,
  6.02130964e-02f, 2.82567274e-02f, 2.91277077e-02f, -3.62267457e-02f, -2.21366473e-02f, -2.98034642e-02f, -6.22949228e-02f, -6.48091957e-02f, -5.52856512e-02f, -2.75218568e-04f,
  7.38362893e-02f, -3.61013487e-02f, -1.18415970e-02f, -2.47297138e-02f, -2.36721523e-02f, 9.67383664e-03f, -1.71814609e-04f, -2.15204898e-02f, 1.02672828e-02f, 2.77271476e-02f,
  4.47707698e-02f, -7.66015798e-02f, 3.05979587e-02f, 3.49769443e-02f, -2.35849321e-02f, -4.78796773e-02f, 8.94820988e-02f, -5.16588911e-02f, 2.58978084e-02f, -2.67800931e-02f,
  2.25501388e-01f, -9.49808732e-02f, 1.32718697e-01f, 6.07823841e-02f, -2.82482132e-02f, -2.34022047e-02f, -5.65518346e-03f, -1.04778800e-02f, 1.14414588e-01f, 2.10368987e-02f,
  -7.45367333e-02f, 8.99103433e-02f, -3.62558803e-03f, -9.61824879e-02f, 1.55209517e-02f, 9.55042988e-02f, -6.51562661e-02f, -2.80188825e-02f, -2.01491136e-02f, 5.21170758e-02f,
  -1.16292447e-01f, -4.14019898e-02f, 2.48165485e-02f, -3.95284668e-02f, 7.95343742e-02f, 1.61009938e-01f, 6.33852556e-02f, 3.61484811e-02f, -6.74060138e-04f, 1.17961958e-01f,
  -3.40560824e-01f, 1.74393386e-01f, -1.96650997e-01f, 9.60337594e-02f, 1.47197813e-01f, -7.02617094e-02f, -5.62953502e-02f, -3.56496647e-02f, 8.38252530e-02f, 9.31293219e-02f,
  1.51011840e-01f, 1.67503491e-01f, 1.28590893e-02f, 7.83007964e-02f, -6.88892603e-02f, -1.53634120e-02f, -1.07385956e-01f, -1.32147178e-01f, -5.90409059e-03f, 4.07859124e-02f,
  1.86716661e-01f, 1.30101681e-01f, 5.57592697e-03f, 1.07775070e-01f, 1.99963614e-01f, 9.27385688e-02f, 1.18038327e-01f, 2.72629410e-02f, 4.88246679e-02f, -1.06257736e-03f,
  -2.13628381e-01f, -1.14236243e-01f, 3.66507918e-02f, 1.00421235e-01f, 5.64897694e-02f, -9.15920138e-02f, 7.75543647e-03f, 2.73538586e-02f, 5.78565821e-02f, -4.80458774e-02f,
  9.19853672e-02f, 9.52827334e-02f, -3.93814333e-02f, 1.50310881e-02f, -1.05165495e-02f, -1.37938913e-02f, 1.20407030e-01f, -1.02393076e-01f, 4.44212928e-02f, 6.74514174e-02f,
  8.73028487e-02f, 1.29751703e-02f, 1.67831383e-03f, -1.27447899e-02f, 1.05603442e-01f, 1.51471123e-01f, 2.27077175e-02f, 1.04701750e-01f, 4.69252355e-02f, 1.13150058e-02f,
  -3.85593027e-02f, -7.88476989e-02f, -4.51111533e-02f, -5.48498333e-02f, 4.00154945e-03f, -9.94559899e-02f, -1.03237718e-01f, 2.28984766e-02f, -7.52549917e-02f, 5.56783676e-02f,
  -7.50779584e-02f, -1.01943590e-01f, 3.68035436e-02f, -1.23973548e-01f, -4.81790528e-02f, -7.36720562e-02f, -1.12518020e-01f, -4.35599573e-02f, -3.34841688e-03f, -8.28819647e-02f,
  1.89020578e-02f, -1.30119726e-01f, -7.75041282e-02f, -1.33545369e-01f, -6.34418279e-02f, -1.15411825e-01f, -1.67344660e-02f, -1.35716731e-02f, -4.68038432e-02f, 3.38805877e-02f,
  1.68522835e-01f, -2.69809160e-02f, -3.91890034e-02f, 2.47444231e-02f, -6.45674951e-03f, 3.39454897e-02f, 7.43085220e-02f, 2.06899866e-02f, 1.06950164e-01f, 3.91169898e-02f,
  1.37825295e-01f, -7.04659149e-02f, 5.38652167e-02f, 6.77619800e-02f, -6.24078093e-03f, 5.32389879e-02f, 1.50163442e-01f, -7.38644898e-02f, 5.79009615e-02f, 4.10490707e-02f,
  1.94731168e-02f, -4.55352329e-02f, -4.21310589e-02f, 3.58504541e-02f, 7.70260394e-02f, -5.35881426e-03f, -1.07758250e-02f, 4.42710146e-02f, -1.03208214e-01f, -5.27276099e-02f,
  -5.48288831e-03f, -2.59713650e-01f, -2.59317607e-01f, -3.91043946e-02f, -1.66842770e-02f, 7.00780377e-02f, 6.05236962e-02f, 1.20112926e-01f, -1.87394898e-02f, -1.98590145e-01f,
  -1.97171539e-01f, -3.92048918e-02f, -1.20987855e-01f, -2.11041346e-02f, 2.04771608e-02f, -1.65152445e-01f, -1.47722036e-01f, 9.76703912e-02f, 2.07991093e-01f, 1.84857100e-01f,
  4.47991006e-02f, 4.95444424e-02f, 1.13885500e-01f, 8.56857002e-02f, -1.58193454e-01f, -5.71292602e-02f, -2.08095744e-01f, -5.01478352e-02f, -1.45273507e-02f, -1.86446324e-01f,
  -2.28271261e-01f, -1.07521333e-01f, 1.44460142e-01f, 1.72838375e-01f, 1.17088467e-01f, 1.00320317e-01f, 1.57162473e-02f, 2.82712821e-02f, 4.21665907e-02f, 5.31092919e-02f,
  -5.29169291e-02f, 6.21252134e-02f, 3.45861400e-03f, -1.92681700e-02f, 9.35782492e-02f, -8.57159123e-03f, -3.40063386e-02f, 1.07328752e-02f, 6.02155849e-02f, -1.14463247e-01f,
  5.92404567e-02f, 4.85650040e-02f, 5.60358167e-02f, -2.09221579e-02f, 4.93938755e-03f, 1.04646184e-01f, -7.83653334e-02f, -1.20602017e-02f, 1.74723938e-02f, -6.04434051e-02f,
  5.14925234e-02f, -2.82716379e-02f, -6.73909038e-02f, -5.05623110e-02f, -2.37925965e-02f, -1.10086650e-01f, -2.65113898e-02f, -1.15912948e-02f, -8.77903700e-02f, -5.39895855e-02f,
  -3.98557559e-02f, -2.60101296e-02f, -1.06343813e-01f, -1.26814127e-01f, -1.03662997e-01f, -8.76104087e-02f, -5.17210066e-02f, -1.25195742e-01f, -8.21571127e-02f, 3.28437351e-02f,
  -1.40691856e-02f, -9.01523381e-02f, -9.93240401e-02f, -3.57542783e-02f, -8.48141164e-02f, -7.57047981e-02f, -8.05383101e-02f, -6.96696639e-02f, 1.02513935e-02f, 9.33447760e-03f,
  -4.58162501e-02f, 1.41597897e-01f, 6.91576973e-02f, 2.70162988e-02f, 1.11544900e-01f, 1.23172924e-01f, 2.31012683e-02f, 8.04143175e-02f, 1.06249020e-01f, 9.80517566e-02f,
  2.88711023e-02f, -4.37454088e-04f, 3.54295559e-02f, 6.40922040e-02f, 1.18022047e-01f, 1.26247644e-01f, 8.94884467e-02f, 3.23351324e-02f, 4.19603884e-02f, -4.63691391e-02f,
  1.12607200e-02f, 1.10463254e-01f, 9.34315547e-02f, -1.71273819e-03f, 2.62503307e-02f, 1.34730875e-01f, 8.84972438e-02f, 3.04443557e-02f, 1.97647423e-01f, 3.43778357e-02f,
  2.62385100e-01f, 4.30864878e-02f, -2.85131335e-02f, 1.56858996e-01f, 1.26604855e-01f, 7.23581240e-02f, 2.11939663e-01f, -1.72803812e-02f, -4.81543355e-02f, 1.54053256e-01f,
  3.53034474e-02f, -1.11037873e-01f, -1.75788090e-01f, -1.45221889e-01f, -2.30796069e-01f, -1.60929654e-02f, 1.29824936e-01f, -1.22482046e-01f, -2.40950122e-01f, 1.96666401e-02f,
  -5.04233688e-02f, 2.35118661e-02f, 1.42763155e-02f, -1.29129097e-01f, -6.29905835e-02f, 1.24999937e-02f, 4.66746278e-02f, 1.05902433e-01f, 8.86028726e-03f, 7.40895048e-02f,
  -7.71625936e-02f, -3.67902145e-02f, -4.71836366e-02f, -7.73757324e-02f, -5.03914580e-02f, -8.37970749e-02f, 5.62060513e-02f, -1.31222263e-01f, -1.15005843e-01f, -7.04499707e-02f,
  -7.59338588e-02f, -9.20529217e-02f, -9.52612162e-02f, -1.46991452e-02f, -6.84770271e-02f, -8.87158066e-02f, -5.30858301e-02f, -1.51752368e-01f, -8.51758346e-02f, -1.46099389e-01f,
  -1.08635863e-02f, 7.87013583e-03f, 2.32812278e-02f, -6.24511167e-02f, -8.96620378e-02f, -2.23604236e-02f, 8.68773181e-03f, -6.24483451e-02f, -8.03121328e-02f, 3.08040380e-02f,
  9.83201116e-02f, 6.81282505e-02f, 1.17624164e-01f, 4.40597236e-02f, 6.84282407e-02f, 3.15787666e-03f, 6.33509830e-02f, 8.12580138e-02f, 3.60130519e-02f, 6.74370006e-02f,
  -1.72487786e-03f, -6.37203082e-03f, 8.13743025e-02f, 2.17178110e-02f, -1.05959782e-03f, 5.44801839e-02f, 6.47794157e-02f, 3.44306119e-02f, -1.16293989e-02f, 1.21321984e-01f,
  1.16140664e-01f, 4.96942922e-02f, 4.07921039e-02f, -3.80535163e-02f, 6.56954348e-02f, 1.39648365e-02f, 9.79102924e-02f, -3.10768951e-02f, 7.80145973e-02f, 1.28820658e-01f,
  1.31650642e-02f, -1.28670307e-02f, -1.38519555e-02f, -4.95927259e-02f, -7.64693841e-02f, -6.06601797e-02f, 3.65076512e-02f, 2.17442065e-02f, -8.46008956e-03f, -4.54191230e-02f,
  -3.34145874e-02f, -1.10386625e-01f, -3.63057740e-02f, -6.00683354e-02f, -5.76517358e-03f, -7.37532154e-02f, 8.69241506e-02f, -4.61198390e-03f, -1.52204065e-02f, -9.57605839e-02f,
  -2.73701977e-02f, 6.67168200e-02f, 1.79669350e-01f, -2.22933199e-02f, -8.44683945e-02f, 7.23251328e-02f, -1.07561253e-01f, -4.37335372e-02f, -2.80883280e-03f, 1.69064224e-01f,
  1.79288968e-01f, 2.06413623e-02f, 1.25017807e-01f, -2.43179679e-01f, -1.75518319e-01f, -9.19876737e-04f, 8.26799795e-02f, 5.04771154e-03f, -1.30706593e-01f, -8.77944827e-02f,
  -9.77840275e-02f, -1.73401073e-01f, -2.28080437e-01f, -1.23825490e-01f, 1.18995449e-02f, 1.05579235e-02f, -1.93566456e-01f, -1.73439264e-01f, -3.74940485e-02f, -1.14197716e-01f,
  -3.11993062e-01f, -9.32220444e-02f, -1.26108438e-01f, -2.03764081e-01f, -3.15022677e-01f, -2.46976346e-01f, -1.63587704e-01f, -2.34987319e-01f, -8.68156478e-02f, -2.14785025e-01f,
  1.75648972e-01f, 4.93644690e-03f, -1.17899254e-01f, -2.01045692e-01f, -1.49269149e-01f, -1.20588720e-01f, -8.49133804e-02f, -1.58822820e-01f, -1.61561176e-01f, -1.73057646e-01f,
  -1.15393721e-01f, -1.51863858e-01f, -1.99099138e-01f, -7.39667416e-02f, -4.10960317e-02f, -3.15212761e-04f, -1.88932702e-01f, -1.71609282e-01f, -1.22701414e-01f, -9.04491991e-02f,
  -2.80619770e-01f, -1.83402494e-01f, -4.80236672e-02f, -1.45702273e-01f, -1.48840237e-03f, -7.23736361e-02f, 1.43741332e-02f, -8.12368840e-03f, -6.18164688e-02f, -8.43179077e-02f,
  6.58733398e-02f, 7.64937028e-02f, 1.46641046e-01f, 1.00848839e-01f, 1.76700220e-01f, 1.10319316e-01f, 1.14976063e-01f, 3.99992056e-02f, 9.75129232e-02f, 1.88532472e-01f,
  3.27525213e-02f, 1.15028962e-01f, 7.84321651e-02f, 1.03366762e-01f, 7.93783367e-02f, 1.51576668e-01f, 1.05969526e-01f, 9.88954008e-02f, 8.25194269e-02f, 1.74550191e-01f,
  1.00181535e-01f, 1.28858641e-01f, 2.20991597e-02f, 3.24588530e-02f, 2.47922875e-02f, 9.48849618e-02f, 1.68780029e-01f, 7.29343146e-02f, 1.45906419e-01f, 1.84211567e-01f,
  3.78250405e-02f, -2.17914451e-02f, -1.01180770e-01f, -1.02300741e-01f, -1.08059898e-01f, -1.95870847e-01f, -1.68485522e-01f, -1.81882262e-01f, -1.21969767e-01f, -1.52519688e-01f,
  -4.57851738e-02f, 7.03666126e-03f, -1.94628316e-03f, -1.43624514e-01f, -1.52751848e-01f, -4.78585996e-02f, -1.47501320e-01f, -2.85027940e-02f, -1.57186583e-01f, -5.63226976e-02f,
  -5.23855090e-02f, -1.27374485e-01f, -1.39549514e-02f, -4.03248295e-02f, -8.65874514e-02f, -6.35378957e-02f, -1.57758683e-01f, -1.14770912e-01f, 4.23589014e-02f, -8.54567587e-02f,
  3.78850728e-01f, -1.37579098e-01f, -1.63378134e-01f, 6.60483837e-02f, -1.99275121e-01f, -1.47742808e-01f, -2.31943220e-01f, 6.71513081e-02f, 1.97331145e-01f, -1.56951562e-01f,
  -4.73346971e-02f, 3.93247545e-01f, 3.33564907e-01f, 1.71066329e-01f, 1.14517167e-01f, -7.03141391e-02f, -1.45443916e-01f, 2.33735517e-01f, 3.06841195e-01f, 1.90069199e-01f,
  1.88672170e-02f, 1.86659873e-01f, 3.09515029e-01f, 2.18101636e-01f, 8.95513408e-03f, 2.82206774e-01f, 3.73831987e-02f, 1.03966147e-01f, -8.92427489e-02f, 5.75495232e-03f,
  1.67889789e-01f, 8.42182711e-03f, 1.45862907e-01f, 1.03050448e-01f, 1.38581172e-01f, 1.67901307e-01f, 7.82481432e-02f, 1.95512518e-01f, 9.92555097e-02f, 1.25792781e-02f,
  1.18806504e-01f, 1.80726890e-02f, 1.97852492e-01f, -1.01846028e-02f, 7.56670684e-02f, 9.19773802e-02f, 1.21656500e-01f, 1.82033062e-01f, 8.90797749e-02f, 4.76014093e-02f,
  7.66441971e-02f, -7.72625282e-02f, -4.86934930e-02f, 7.94698969e-02f, 8.24724585e-02f, 1.34636790e-01f, 1.17911600e-01f, 1.70240656e-01f, 9.15607363e-02f, 1.33641273e-01f,
  1.70967989e-02f, -1.72512144e-01f, -2.04840958e-01f, -7.80057311e-02f, -7.93942213e-02f, -1.58360898e-01f, -1.37346819e-01f, -2.27224350e-01f, -4.28399965e-02f, -8.70581269e-02f,
  -1.72318578e-01f, -1.86075613e-01f, -1.25156984e-01f, -9.28586051e-02f, -1.90923631e-01f, -1.07429728e-01f, -2.31627211e-01f, -1.53935656e-01f, -8.26914459e-02f, -1.03137165e-01f,
  -4.65428308e-02f, -1.03909679e-01f, -1.59475341e-01f, -2.03003585e-02f, -1.64061382e-01f, -4.02792096e-02f, -2.10368022e-01f, -1.19344205e-01f, -1.61052346e-01f, -1.23624571e-01f,
  1.90439835e-01f, 1.02489002e-01f, 2.12408036e-01f, 2.43982092e-01f, 1.23571999e-01f, 5.75934127e-02f, 1.18553750e-01f, 1.91013187e-01f, 7.71604031e-02f, 1.81011990e-01f,
  8.43666568e-02f, 1.31283343e-01f, 9.72160846e-02f, 1.15871295e-01f, 1.42658070e-01f, 9.67179239e-02f, 1.03414655e-01f, 9.94514078e-02f, 3.58464532e-02f, 6.23477772e-02f,
  7.79110044e-02f, 1.13337554e-01f, 7.48767853e-02f, 1.16002627e-01f, 1.05940588e-01f, 6.47540092e-02f, 7.07034916e-02f, 1.40288725e-01f, 3.05944253e-02f, 1.30783901e-01f,
  -1.90898687e-01f, 2.90518135e-01f, 1.72467604e-01f, -3.12871754e-01f, 6.74731657e-02f, 1.70917869e-01f, 2.03127190e-01f, -2.51291487e-02f, -2.38501564e-01f, 6.20037317e-02f,
  5.79056107e-02f, -1.52926579e-01f, -7.73997139e-03f, 3.85667123e-02f, 1.16935745e-01f, 1.29367113e-01f, 7.82142803e-02f, 6.58337176e-02f, -1.77192286e-01f, -3.11350822e-02f,
  -9.65555310e-02f, -1.52201653e-01f, -1.89130798e-01f, -9.10140052e-02f, -6.40641749e-02f, -1.93575278e-01f, 9.65304822e-02f, 1.70029001e-03f, 1.85694411e-01f, 1.08060144e-01f,
  1.48458093e-01f, 2.00289264e-01f, -1.61836892e-01f, -1.39018614e-02f, 2.46059913e-02f, -1.56749375e-02f, 4.63533914e-03f, -3.92708294e-02f, -4.27175947e-02f, -5.67692593e-02f,
  -6.46101683e-02f, 2.87669525e-02f, -3.10983434e-02f, -1.46284618e-03f, -3.43948901e-02f, -8.00733790e-02f, 7.83111230e-02f, 1.80863179e-02f, 6.34049624e-02f, 1.13703243e-01f,
  1.08323254e-01f, 5.73817603e-02f, 8.32027420e-02f, -1.87262241e-02f, -7.81353936e-03f, 5.32937832e-02f, -8.64946935e-03f, 3.35043333e-02f, 7.91286752e-02f, 2.24603042e-02f,
  -5.72837628e-02f, -9.02177021e-03f, -3.16698998e-02f, -1.04575761e-01f, 2.35573035e-02f, -1.12384628e-03f, 3.95863038e-03f, -5.72042428e-02f, 1.53795397e-02f, -3.47732641e-02f,
  2.14167908e-02f, 5.93969822e-02f, 2.50520706e-02f, 5.39017543e-02f, -1.67964101e-02f, -4.66036471e-03f, 6.85232729e-02f, 7.56527716e-03f, 2.61275228e-02f, -3.64479385e-02f,
  6.74096271e-02f, -1.00888340e-02f, -1.94800682e-02f, 8.48492458e-02f, 1.19504303e-01f, 4.66293246e-02f, -9.11286566e-03f, 8.69508535e-02f, -4.83109243e-02f, -4.41404767e-02f,
  -2.95115799e-01f, 5.41157685e-02f, 5.82213467e-03f, -3.08580464e-03f, -3.95745933e-02f, -1.54339820e-02f, -6.14434667e-03f, -9.77156535e-02f, 2.85984203e-02f, 2.11649342e-03f,
  1.15947789e-02f, -4.17127647e-02f, -2.07560742e-03f, 2.30142404e-03f, -8.55431035e-02f, -6.64087236e-02f, -1.25387004e-02f, -6.32884726e-02f, 6.53658137e-02f, -3.68257724e-02f,
  2.59776358e-02f, -8.39362964e-02f, -1.14533797e-01f, -7.91961700e-02f, -7.79657066e-02f, -1.46074504e-01f, -3.81003357e-02f, -6.44744784e-02f, 5.90409758e-03f, -1.91177532e-01f,
  3.10204804e-01f, -4.96586412e-02f, -7.37753287e-02f, 9.63060707e-02f, 7.50167808e-03f, 1.47559032e-01f, 2.61570178e-02f, 2.02028796e-01f, 1.11909509e-01f, 2.41387244e-02f,
  -1.36871994e-01f, -1.41858041e-01f, -8.10498074e-02f, 4.04974669e-02f, 1.66992381e-01f, 1.66031178e-02f, 2.97518987e-02f, -3.46142203e-02f, 8.54507908e-02f, 1.27103105e-01f,
  3.75179946e-02f, 2.30134621e-01f, 2.20308632e-01f, 3.15870345e-02f, 1.46368414e-01f, 1.13311693e-01f, -4.85594198e-02f, 2.85898987e-02f, -6.14974275e-02f, 3.38632986e-02f,
  2.95698270e-02f, 2.34914362e-01f, 8.57061446e-02f, 7.92178214e-02f, 1.36127109e-02f, 1.49500847e-01f, 1.70999989e-01f, 1.42265454e-01f, 6.97194859e-02f, 1.64062664e-01f,
  5.30080386e-02f, 6.59487247e-02f, -1.29368762e-02f, 1.92597508e-02f, 1.84413716e-01f, 1.99753180e-01f, 1.54886901e-01f, 5.62441833e-02f, 2.66182758e-02f, 7.14214370e-02f,
  -5.43742329e-02f, -3.06418602e-04f, 9.68045592e-02f, 7.31807202e-02f, 8.91295820e-02f, 9.86388922e-02f, 1.37735561e-01f, 5.85078895e-02f, 1.03128232e-01f, 2.35244155e-01f,
  6.26208633e-02f, -1.92432120e-01f, -1.80590048e-01f, -7.85877779e-02f, -1.56702280e-01f, -6.81825131e-02f, -8.39432850e-02f, -1.18985675e-01f, -1.63156345e-01f, -5.51666692e-02f,
  -9.31030884e-02f, -1.94386944e-01f, -1.53852612e-01f, -8.17669854e-02f, -2.68299401e-01f, -1.04483888e-01f, -7.51504377e-02f, -1.17299907e-01f, -1.62253439e-01f, -1.64563000e-01f,
  -1.14664376e-01f, -1.14489779e-01f, -1.14483222e-01f, -1.32397786e-01f, -2.20643997e-01f, -1.17421970e-01f, -6.82640150e-02f, -1.62068233e-01f, -1.35295689e-01f, -1.01626165e-01f,
  2.51769423e-01f, 1.21694230e-01f, 6.70142546e-02f, 2.12714642e-01f, 6.85937181e-02f, 4.80188504e-02f, 4.74716723e-02f, 1.63371101e-01f, 6.72492310e-02f, 7.74539262e-02f,
  4.95447330e-02f, 5.47739603e-02f, -2.07421742e-02f, 1.08362414e-01f, 1.09272838e-01f, 8.48723873e-02f, 1.69392034e-01f, 1.35034963e-01f, 8.44852552e-02f, 1.94461390e-01f,
  9.51686129e-02f, 1.47878215e-01f, 2.43538842e-01f, 8.28571618e-02f, 1.72680214e-01f, 4.46442403e-02f, 5.10862693e-02f, 1.65943146e-01f, 2.09472150e-01f, 2.78122753e-01f,
  -3.33151102e-01f, 2.45927289e-01f, 8.84893313e-02f, -1.51864946e-01f, -1.54346108e-01f, -9.89564210e-02f, 6.35298193e-02f, 1.22381300e-02f, -4.35121059e-02f, 9.66963843e-02f,
  2.48768494e-01f, 8.68843496e-02f, 1.43181995e-01f, 1.37936667e-01f, 1.66575968e-01f, 1.88742280e-02f, 9.56363790e-03f, -3.76031697e-02f, -1.36328608e-01f, -1.05556510e-01f,
  -3.41321267e-02f, -1.77556813e-01f, -1.71127304e-01f, 3.81912291e-02f, 5.09453146e-03f, 1.16739329e-02f, 1.40962958e-01f, 2.47296016e-03f, 4.05388558e-03f, 6.84226118e-03f,
  6.97353259e-02f, -4.18502241e-02f, 9.94544625e-02f, -1.09182484e-02f, 1.70167759e-01f, 8.24012905e-02f, 1.75167277e-01f, 1.65943533e-01f, 1.27481520e-01f, 1.27077386e-01f,
  2.01194026e-02f, 7.13782012e-02f, -7.50032952e-03f, 6.29739240e-02f, -2.54358687e-02f, 4.64595295e-02f, 1.54747799e-01f, 3.40975006e-04f, 1.74059689e-01f, 1.82733610e-01f,
  9.53486413e-02f, 1.35616809e-02f, 1.52073242e-02f, 1.48093149e-01f, 1.47851467e-01f, -2.44463272e-02f, 1.50042385e-01f, 1.40734896e-01f, 1.22574121e-01f, 1.48200929e-01f,
  -7.14741722e-02f, -7.09384456e-02f, -1.61373213e-01f, -9.39140171e-02f, -1.04012571e-01f, 4.62257117e-02f, -9.09448862e-02f, 2.67452355e-02f, -1.52066618e-01f, -7.79271275e-02f,
  6.52750209e-02f, 2.18612812e-02f, -5.44179268e-02f, -1.58951283e-02f, 3.48790586e-02f, -2.15219080e-01f, -3.64778116e-02f, -1.55915786e-03f, -2.79788971e-02f, -9.85246897e-02f,
  -1.13683581e-01f, -1.50376596e-02f, -1.08053073e-01f, -2.51100454e-02f, -1.59702525e-02f, -9.30691436e-02f, -6.28735200e-02f, -1.75698064e-02f, -1.38566568e-01f, -1.26555473e-01f,
  1.15257181e-01f, 1.94643885e-01f, 1.10324807e-01f, 3.20010409e-02f, 7.52142370e-02f, 1.07446522e-01f, 4.31392156e-02f, 7.27706328e-02f, 1.06270805e-01f, 3.23681496e-02f,
  1.55994460e-01f, 1.57319561e-01f, 1.29161268e-01f, 1.39019459e-01f, 7.99024850e-02f, 1.09707274e-01f, 9.84010696e-02f, 6.75804541e-02f, 1.53648883e-01f, 8.68717209e-02f,
  1.72751263e-01f, 1.17282838e-01f, 3.60684432e-02f, 1.91472307e-01f, 1.37317017e-01f, 1.14390040e-02f, 6.18653446e-02f, 5.82521595e-02f, 1.14957513e-02f, 2.06388205e-01f,
  1.05616599e-01f, 1.49822906e-01f, 4.02586646e-02f, 2.83646137e-01f, 1.40688166e-01f, -1.51357308e-01f, -8.72797146e-02f, 7.37302154e-02f, 2.14717329e-01f, 3.84140015e-02f,
  1.02207340e-01f, 9.76029113e-02f, 1.01209000e-01f, 9.53256190e-02f, 3.31587568e-02f, -1.63258109e-02f, 6.81459084e-02f, 7.25823082e-03f, -7.36104250e-02f, -4.97790538e-02f,
  5.86632639e-02f, 1.44196868e-01f, 1.32204190e-01f, 1.64989203e-01f, 2.43868992e-01f, 8.12588409e-02f, 7.79752806e-02f, 2.07674026e-01f, 8.51185545e-02f, 2.60180891e-01f,
  -1.12112708e-01f, 1.95867985e-01f, -1.06060646e-01f, 2.70041768e-02f, 1.20252952e-01f, -2.39705723e-02f, -4.05801125e-02f, 4.20200676e-02f, 3.67352925e-03f, 1.47872061e-01f,
  1.82274431e-01f, 9.50028896e-02f, 2.03151196e-01f, 1.29176959e-01f, 4.44222055e-02f, 9.06097442e-02f, 2.13335127e-01f, 2.11467415e-01f, 6.33342266e-02f, 1.46063194e-01f,
  7.22925738e-02f, 4.83102500e-02f, 5.51753789e-02f, 6.96220398e-02f, 1.50840029e-01f, 1.37987984e-02f, 1.32083416e-01f, 4.86466400e-02f, -3.84153537e-02f, 1.15719229e-01f,
  -1.05158821e-01f, -6.09581769e-02f, -2.42968556e-03f, -4.56662988e-03f, -9.11471844e-02f, -7.23274574e-02f, -2.91570332e-02f, -1.24307528e-01f, -1.08063906e-01f, -1.21929154e-01f,
  -1.26977181e-02f, -9.09598544e-02f, -3.77432965e-02f, -1.20401397e-01f, -8.41043219e-02f, 1.68882124e-02f, -4.07565683e-02f, -1.23287784e-02f, -9.91931185e-02f, -6.50621280e-02f,
  -1.76554453e-02f, -5.66427633e-02f, -2.25169118e-02f, -4.41617593e-02f, -5.48590198e-02f, -1.02854915e-01f, -1.46127015e-01f, 2.20121741e-02f, 1.81696117e-02f, -1.68205947e-02f,
  5.99903166e-02f, -7.10556358e-02f, 2.12599691e-02f, -3.33488025e-02f, 1.05509078e-02f, 5.33566773e-02f, 1.95570905e-02f, 1.08292446e-01f, 1.20673284e-01f, -9.07274336e-03f,
  2.62677036e-02f, 9.67562944e-02f, 1.38523653e-01f, -2.86328029e-02f, 3.66741940e-02f, -2.64078863e-02f, 9.99906212e-02f, 6.90613464e-02f, 9.77002233e-02f, -1.43429721e-02f,
  4.51365039e-02f, -2.88504995e-02f, -3.58706489e-02f, 3.69464681e-02f, -3.49121564e-03f, -4.04394418e-02f, 3.47776264e-02f, 4.69216751e-03f, -1.58895478e-01f, -6.72091693e-02f,
  3.05701554e-01f, -1.54044004e-02f, -3.11821669e-01f, 7.75906220e-02f, -1.95307538e-01f, -7.43316785e-02f, -1.39385924e-01f, 1.49742305e-01f, 1.11810237e-01f, -1.03260338e-01f,
  -7.71411136e-02f, 1.64554805e-01f, -3.15497140e-03f, 7.78290257e-02f, 6.15414567e-02f, -6.57730773e-02f, -9.02807936e-02f, 7.44641200e-02f, 8.77362862e-02f, 1.80158898e-01f,
  1.92856535e-01f, 1.93156689e-01f, 1.86182320e-01f, 6.86968118e-02f, 1.19801395e-01f, 5.89017943e-02f, 2.61586886e-02f, 6.86834082e-02f, 1.01938456e-01f, -8.64747241e-02f,
  -1.15417190e-01f, -6.80728778e-02f, 1.38065115e-01f, 1.81963548e-01f, 5.03360629e-02f, 1.50934502e-01f, -4.68507735e-03f, 7.42744058e-02f, 1.98261753e-01f, 2.52903793e-02f,
  4.08428237e-02f, 2.06749544e-01f, 9.57447011e-03f, 1.27028361e-01f, 7.56671727e-02f, 3.91879566e-02f, 1.77445084e-01f, 1.42248154e-01f, 1.16260119e-01f, 4.48382162e-02f,
  1.00597806e-01f, 8.19286555e-02f, 9.35577154e-02f, 7.76814893e-02f, 3.11645214e-02f, 4.04638648e-02f, -2.84155807e-03f, 9.68676880e-02f, 8.52629319e-02f, 1.27912477e-01f,
  -9.80741978e-02f, 2.57447432e-03f, 2.33301502e-02f, 8.94103292e-03f, -8.20528641e-02f, -6.30121455e-02f, -1.42353341e-01f, -1.26210839e-01f, 3.15514095e-02f, -7.53268152e-02f,
  -4.20131423e-02f, -1.67668030e-01f, -1.43172339e-01f, -1.76562682e-01f, -3.60005274e-02f, -4.03302163e-02f, -8.59948322e-02f, -5.70527837e-02f, 2.16200147e-02f, -4.26572524e-02f,
  -1.86917633e-02f, 1.96753237e-02f, -1.46035939e-01f, -3.06881666e-02f, -2.19933614e-01f, -2.42924228e-01f, -7.92670101e-02f, -1.11823268e-02f, -1.20440200e-01f, -3.82206514e-02f,
  2.58768767e-01f, 1.38898205e-03f, 1.23731613e-01f, 1.67250231e-01f, 4.27424572e-02f, 1.58478126e-01f, 1.37832791e-01f, 1.50443345e-01f, 1.29186422e-01f, 8.25885031e-03f,
  1.26595795e-01f, 1.41439945e-01f, 6.26041647e-03f, 3.13496664e-02f, 5.09930514e-02f, 1.24388084e-01f, 1.62395433e-01f, 1.51405886e-01f, 2.13943034e-01f, 1.21637546e-01f,
  2.10515976e-01f, 1.18501656e-01f, 1.21076837e-01f, 9.86426473e-02f, 1.80696666e-01f, 9.98976082e-02f, 1.86743870e-01f, 1.06183484e-01f, 1.89865246e-01f, 1.11609370e-01f,
  -1.26993507e-01f, 9.88975316e-02f, 8.61500576e-02f, 4.35778350e-02f, 6.74120858e-02f, -2.10504793e-02f, 1.45277530e-02f, -1.32897973e-01f, -7.58769736e-02f, -3.17525230e-02f,
  -5.10772914e-02f, -6.35457877e-03f, -1.50612324e-01f, -1.88025370e-01f, -2.71181375e-01f, 4.10099961e-02f, -1.45966196e-02f, -5.69479987e-02f, -2.28649288e-01f, -9.87113938e-02f,
  8.52394626e-02f, -2.95319036e-02f, -2.04593882e-01f, -1.70340255e-01f, 7.17516094e-02f, 3.58328335e-02f, -7.31180161e-02f, -1.06982794e-02f, 1.27714705e-02f, 2.36650631e-01f,
  2.21316591e-01f, 2.58744154e-02f, 1.15361043e-04f, 4.47788723e-02f, -6.89330995e-02f, 5.78290261e-02f, -3.18182707e-02f, 2.42806654e-02f, 3.06654423e-02f, 4.15613130e-02f,
  -8.51148516e-02f, 7.28470227e-03f, -1.74130592e-02f, -4.26825844e-02f, -6.72568828e-02f, -1.25490010e-01f, -4.13039997e-02f, -2.94141676e-02f, 2.28031781e-02f, 2.50014253e-02f,
  2.98323985e-02f, -1.67435352e-02f, 3.07352543e-02f, -7.38655170e-03f, -8.29269458e-03f, -3.70588265e-02f, -6.53140917e-02f, -6.36853604e-03f, -1.73298884e-02f, -2.19645109e-02f,
  -8.78760666e-02f, -1.29009306e-01f, -8.79136994e-02f, -3.77337262e-02f, -1.32272989e-01f, -4.80423830e-02f, -9.79212523e-02f, -6.09392952e-03f, -2.08602361e-02f, -1.13080278e-01f,
  -6.73956722e-02f, 3.68522480e-02f, -5.55319227e-02f, 2.16453206e-02f, -7.88446981e-03f, 2.64143338e-04f, -5.34483902e-02f, -1.04706809e-01f, -2.02528294e-02f, -6.64272457e-02f,
  5.28407767e-02f, -4.74592000e-02f, -2.01192666e-02f, -3.78970504e-02f, 6.71175569e-02f, 7.85282999e-02f, -3.74860689e-02f, 4.79697883e-02f, -5.45728952e-03f, 1.08024307e-01f,
  -6.91770809e-04f, -1.47946075e-01f, 4.13267463e-02f, 5.88540062e-02f, 7.44146630e-02f, -6.14670059e-03f, 2.01294422e-02f, 1.13790361e-02f, 7.19318315e-02f, -1.63528565e-02f,
  -6.48309588e-02f, -4.31773402e-02f, -2.09098752e-03f, -4.72063050e-02f, -8.44824836e-02f, 5.76451654e-03f, -1.34550795e-01f, -5.92888705e-02f, -2.15482395e-02f, -7.85605237e-02f,
  -7.72757232e-02f, 5.10020480e-02f, -2.37427354e-02f, 9.77217332e-02f, 3.13393958e-02f, 2.19399780e-02f, 7.00225085e-02f, -5.75604849e-02f, -1.46480009e-01f, -9.13700163e-02f,
  -3.57155293e-01f, -7.41077811e-02f, -2.55555779e-01f, -3.02157491e-01f, -3.15043360e-01f, -3.15291792e-01f, -2.38566935e-01f, -2.89792687e-01f, -2.61288196e-01f, -7.72710145e-02f,
  7.44873611e-03f, 5.54959662e-02f, -1.48147762e-01f, -8.04765448e-02f, -2.13986501e-01f, -2.48593360e-01f, -3.34855407e-01f, -4.31466579e-01f, -3.73560578e-01f, -1.85304359e-01f,
  -1.10599212e-01f, -2.30230123e-01f, -2.83969939e-01f, -2.61791945e-01f, -2.77593166e-01f, -1.72979280e-01f, -2.50447452e-01f, -2.47412130e-01f, -1.76665694e-01f, -2.51390874e-01f,
  -1.02183543e-01f, -9.83201638e-02f, -1.56218261e-01f, -1.09016411e-01f, -7.19223320e-02f, -1.27148896e-01f, -1.67466596e-01f, -1.63128674e-01f, -1.12690985e-01f, -1.98322937e-01f,
  -1.51080251e-01f, -7.64480084e-02f, -2.10552141e-01f, -7.44663626e-02f, -2.33825013e-01f, -2.06453174e-01f, -2.07345456e-01f, -2.05126137e-01f, -9.51250792e-02f, -1.88947488e-02f,
  -1.10350706e-01f, -2.37662420e-01f, -2.52972782e-01f, -1.15636148e-01f, -1.00365303e-01f, -7.05987737e-02f, -1.25930727e-01f, -1.55181989e-01f, -1.77521825e-01f, -1.17711931e-01f,
  -3.00476030e-02f, 6.00586943e-02f, -3.16700228e-02f, -3.61937098e-02f, 9.05871764e-03f, 1.06076255e-01f, 4.71011214e-02f, -6.63015842e-02f, 1.69540774e-02f, 6.91909790e-02f,
  -2.84032803e-02f, 9.31173414e-02f, 5.58837503e-02f, 2.81239953e-02f, -5.59718609e-02f, -3.17139663e-02f, -1.85382329e-02f, 7.55274445e-02f, 1.06217293e-02f, -1.15597947e-03f,
  7.33013451e-02f, 9.07218829e-02f, 5.03200032e-02f, 1.05548598e-01f, 5.35726175e-02f, 8.07079971e-02f, -1.66671909e-02f, 1.86224803e-02f, 6.69865310e-02f, 1.59058049e-02f,
  -7.25287721e-02f, -1.12885125e-02f, -5.37319370e-02f, -5.34902215e-02f, -7.91710243e-02f, -1.03510991e-01f, -8.25594179e-03f, -1.25524834e-01f, -1.52062550e-01f, -9.64389816e-02f,
  -1.28961250e-01f, -7.24969357e-02f, -4.19537202e-02f, -6.45327345e-02f, -1.08970910e-01f, -5.56837209e-02f, -1.44262105e-01f, -8.27335343e-02f, -1.17907003e-01f, 3.25834863e-02f,
  -8.91256928e-02f, -1.03523538e-01f, -1.19259402e-01f, -9.77417082e-02f, -1.91395968e-01f, -1.99811980e-01f, -9.17911381e-02f, -6.13752455e-02f, -1.25871822e-01f, -1.42915606e-01f,
  -1.26376331e-01f, -1.03016660e-01f, -2.42176391e-02f, 1.99420508e-02f, 5.40193096e-02f, -1.64728582e-01f, -2.18362823e-01f, -1.87799826e-01f, 3.28392871e-02f, -3.58094163e-02f,
  9.56751183e-02f, 1.37744650e-01f, 2.41911307e-01f, 1.17536768e-01f, 1.51296817e-02f, -1.57741442e-01f, -1.23126775e-01f, -1.04554556e-01f, -8.56886283e-02f, -4.50439528e-02f,
  7.06533939e-02f, 1.24647692e-02f, -9.52503085e-02f, 1.38011137e-02f, -1.16634564e-02f, 3.70729677e-02f, -3.44598107e-02f, 2.03642752e-02f, 1.10728601e-02f, 6.20717146e-02f,
  1.27212122e-01f, -2.41648518e-02f, 1.31898791e-01f, 4.20402549e-02f, 1.90366581e-01f, 1.15375720e-01f, 6.30965680e-02f, 8.29452798e-02f, 3.95053662e-02f, 2.09864434e-02f,
  6.83386403e-04f, 1.34632468e-01f, 4.06728350e-02f, 8.71633440e-02f, 4.04741056e-02f, 1.24525756e-01f, -5.04923798e-02f, 3.46031189e-02f, 1.03532240e-01f, -3.41833569e-02f,
  9.26449597e-02f, 3.64263752e-03f, 3.99984010e-02f, 6.19812496e-02f, 4.33838628e-02f, 1.36294097e-01f, 3.22092324e-02f, -3.39680053e-02f, 8.05240646e-02f, -2.67868862e-02f,
  -9.48020816e-02f, -7.40053356e-02f, 4.61712070e-02f, -4.77400050e-02f, 5.09231016e-02f, -2.36737356e-02f, 8.62723514e-02f, -2.18174327e-02f, 5.98734692e-02f, -4.16191295e-02f,
  7.44380206e-02f, 2.62771249e-02f, 9.01304483e-02f, -7.59604648e-02f, -3.46511118e-02f, 1.62218362e-02f, 4.34382595e-02f, -3.93856503e-03f, -8.55717808e-03f, 2.03910582e-02f,
  3.22491974e-02f, -3.69649641e-02f, 1.13045447e-01f, -6.40363693e-02f, 7.71520957e-02f, -6.84720725e-02f, -5.24854437e-02f, 5.37842512e-02f, 7.51786381e-02f, 3.43881436e-02f,
  1.13696888e-01f, 1.96994513e-01f, -4.66339551e-02f, 9.29395109e-02f, 6.59923181e-02f, -1.37665067e-02f, 1.88218765e-02f, 1.33390412e-01f, 7.25461543e-02f, 1.51068019e-02f,
  6.93303645e-02f, -4.29101475e-02f, -6.27592718e-03f, -2.65518669e-02f, -3.83255295e-02f, -1.43557247e-02f, -6.43942580e-02f, 3.71656008e-02f, -5.20074517e-02f, -8.45169723e-02f,
  2.65636388e-03f, -1.25824258e-01f, -7.08642649e-03f, -4.74995226e-02f, -4.67948914e-02f, -7.35064447e-02f, 7.93259218e-03f, -3.80681716e-02f, -8.74894634e-02f, -4.51105498e-02f,
  -2.82230347e-01f, 4.45123881e-01f, -4.09643054e-01f, -1.73481867e-01f, 3.24407257e-02f, -6.90400749e-02f, 1.83378071e-01f, 8.47301707e-02f, 3.75088714e-02f, 2.70428546e-02f,
  1.22448370e-01f, -5.67234792e-02f, 1.00788996e-02f, -6.37928173e-02f, -1.60671517e-01f, 1.87648796e-02f, -3.14032316e-01f, -3.43155593e-01f, -2.60772794e-01f, -8.39094147e-02f,
  1.67781591e-01f, -5.09149693e-02f, -1.40515253e-01f, -5.43038547e-02f, 6.55393153e-02f, -5.58553785e-02f, -1.71890818e-02f, -8.59952271e-02f, -4.90406016e-03f, -1.34412304e-01f,
  -1.04798891e-01f, 3.30948606e-02f, -4.15101871e-02f, 8.01704973e-02f, 5.40728755e-02f, -9.22150686e-02f, 2.28367597e-02f, -1.08976439e-02f, 3.45607325e-02f, 5.23615256e-02f,
  -9.64172855e-02f, -2.99580563e-02f, -4.84764129e-02f, 7.69293383e-02f, -2.88506839e-02f, 6.45367876e-02f, -7.99281243e-03f, -1.28056243e-01f, -1.22059904e-01f, -3.40249576e-02f,
  1.27424076e-01f, -1.94271430e-02f, -9.65807289e-02f, 7.17213470e-03f, -1.06320895e-01f, -1.33213073e-01f, 2.62481291e-02f, -6.52444512e-02f, -1.54429704e-01f, 1.03416696e-01f,
  -3.24555598e-02f, 3.58851701e-02f, -1.08198747e-02f, -1.03028109e-02f, 1.19981028e-01f, 4.15286794e-02f, -8.56293738e-02f, 5.26713766e-02f, -3.03690881e-02f, 7.86044449e-02f,
  7.82046560e-03f, -2.40800511e-02f, -2.27231253e-02f, 8.50222483e-02f, -3.43875145e-03f, 9.58359800e-03f, -5.66359572e-02f, -6.96198083e-03f, 6.25589043e-02f, 4.80499715e-02f,
  -1.50250327e-02f, 6.98388517e-02f, -3.07501648e-02f, -5.32210134e-02f, -4.88821929e-03f, -4.09620702e-02f, -1.64070204e-02f, 5.27058356e-02f, 1.12486951e-01f, -5.76904602e-03f,
  1.60088614e-01f, -8.50456357e-02f, -8.54789093e-02f, -1.59445498e-02f, -9.94669646e-03f, 2.61975033e-03f, -4.83588353e-02f, -4.41946015e-02f, -6.21641753e-03f, -9.29899141e-02f,
  1.44814316e-04f, -8.59477445e-02f, 7.43354261e-02f, -3.84225436e-02f, -5.47436699e-02f, -5.17173186e-02f, 1.37990624e-01f, -6.89783618e-02f, -1.61241982e-02f, -5.82401305e-02f,
  3.84609737e-02f, -9.47765782e-02f, -1.17898934e-01f, -8.68106484e-02f, 1.52295991e-03f, -1.62642092e-01f, -6.76730350e-02f, 1.08835446e-02f, -7.04283342e-02f, 1.31702647e-01f,
  3.82990330e-01f, 5.62848598e-02f, 6.82878643e-02f, 2.36882910e-01f, -8.36014822e-02f, -1.89957488e-02f, -8.37494507e-02f, 3.78476232e-02f, 1.42854720e-01f, 8.28543529e-02f,
  -7.75476098e-02f, 6.39267340e-02f, 2.22775210e-02f, 3.19014676e-02f, -7.27107599e-02f, 1.52243167e-01f, 9.69948545e-02f, 8.25865641e-02f, -8.32846388e-02f, -1.64618224e-01f,
  -2.58724708e-02f, 1.39154211e-01f, -3.04095447e-02f, 7.18847066e-02f, 2.19666466e-01f, 1.82047337e-01f, 1.40059605e-01f, 1.88302428e-01f, 4.98325303e-02f, 3.59178752e-01f,
  1.76809296e-01f, 1.32542895e-02f, -3.14516835e-02f, 6.85353205e-03f, 3.05568464e-02f, -1.91444587e-02f, 6.54088035e-02f, 1.10682689e-01f, -1.62865482e-02f, 9.89876688e-02f,
  -6.04549795e-03f, 9.12914202e-02f, 2.59796763e-03f, -1.67056974e-02f, 1.27332583e-01f, 9.22538992e-03f, 8.62625465e-02f, 1.08699173e-01f, 1.20333582e-01f, 1.00790955e-01f,
  -1.67688448e-02f, 3.85483243e-02f, 8.96876827e-02f, -4.97453623e-02f, 2.87420861e-02f, 2.18467917e-02f, -9.32401512e-03f, 1.70757815e-01f, 1.04018472e-01f, 3.24568897e-01f,
  -7.24280179e-02f, -4.48927395e-02f, -3.50474101e-03f, -2.52607316e-02f, 5.64747564e-02f, -7.04124644e-02f, 3.48831527e-02f, 4.60983776e-02f, 4.41939617e-03f, 2.97786072e-02f,
  -9.61131379e-02f, 2.07100436e-02f, -7.19048828e-02f, 5.18636219e-02f, 2.43196301e-02f, 2.06318405e-02f, -3.60094081e-03f, -4.89351898e-02f, -9.36890300e-03f, 1.15498919e-02f,
  -1.88895110e-02f, -8.65122080e-02f, -1.84717756e-02f, -7.54645048e-03f, 3.21026407e-02f, 6.64139390e-02f, 1.83106947e-03f, -1.06214345e-01f, 4.21859063e-02f, -1.59850027e-02f,
  2.65434384e-01f, -1.93986803e-01f, 1.39970735e-01f, 1.62811831e-01f, 1.29464164e-01f, 2.15958487e-02f, 9.03995559e-02f, 2.24533156e-02f, -1.22778388e-02f, 8.95172730e-02f,
  6.93600550e-02f, 2.39978731e-02f, 5.50967641e-02f, 4.72963080e-02f, 9.45577472e-02f, 9.68037769e-02f, 3.05697718e-03f, 1.87240511e-01f, 9.93901491e-02f, 9.05299708e-02f,
  -5.05122356e-03f, 7.71882012e-02f, 1.93899363e-01f, 7.81369954e-02f, 1.51452422e-01f, 1.05783567e-01f, 7.93829709e-02f, 1.25970989e-01f, 1.61458001e-01f, 2.15963438e-01f,
  9.08582732e-02f, -7.14048669e-02f, -9.90984589e-02f, 1.58695683e-01f, 6.71037287e-02f, 4.77603916e-03f, 1.14787683e-01f, 6.31974638e-02f, 1.04449823e-01f, 1.77843254e-02f,
  -1.53540537e-01f, 3.24612409e-02f, 1.52312562e-01f, 6.55347332e-02f, 1.45036533e-01f, 2.14603588e-01f, 1.71266258e-01f, 1.64095297e-01f, 1.30484521e-01f, 4.70459573e-02f,
  8.06466490e-03f, 3.62279154e-02f, 2.81685647e-02f, -1.18265190e-04f, -3.19616012e-02f, 5.69919161e-02f, -3.14311162e-02f, -1.10020034e-01f, -3.64293605e-02f, 7.67933205e-02f,
  -7.49163479e-02f, -1.94950864e-01f, 7.06141144e-02f, -3.98658551e-02f, 1.88445542e-02f, -1.64127871e-02f, 6.58091828e-02f, 4.65879329e-02f, 9.79864877e-03f, 2.58090068e-02f,
  -1.01736508e-01f, 8.37849453e-02f, -4.31654714e-02f, 3.57779600e-02f, -9.90865380e-02f, -4.79569808e-02f, -1.04419384e-02f, -7.28072301e-02f, -7.00965300e-02f, -1.02464952e-01f,
  6.27108365e-02f, -1.23587713e-01f, -1.66695282e-01f, -4.10299823e-02f, -4.45526801e-02f, 3.22625302e-02f, -1.40059546e-01f, -1.73281178e-01f, -1.35183766e-01f, -1.47452429e-02f,
  1.01184351e-02f, 3.45692225e-02f, 3.44411321e-02f, -1.83119401e-02f, 4.82832789e-02f, 5.69400154e-02f, 3.35302800e-02f, 8.83818269e-02f, -3.74018820e-03f, 4.59425040e-02f,
  -5.38820289e-02f, -3.93825769e-02f, -7.48649091e-02f, 5.25697395e-02f, 5.39475605e-02f, 5.82170626e-03f, 1.99954520e-04f, 2.44147959e-03f, -2.78057228e-03f, -2.01862566e-02f,
  -8.00675005e-02f, 6.56704977e-03f, 5.77742979e-02f, 1.22211590e-01f, -6.34122491e-02f, 4.48917411e-02f, 4.93572690e-02f, 2.77097765e-02f, -7.93064088e-02f, -6.20116219e-02f,
  1.44078165e-01f, 2.06313469e-02f, 8.64915103e-02f, 4.93498109e-02f, 5.78338467e-02f, 3.19558941e-02f, -4.85793129e-03f, 8.33309218e-02f, 5.17529957e-02f, -3.96208502e-02f,
  -8.11720490e-02f, 5.04585495e-03f, -5.66590205e-02f, 7.28982873e-03f, 1.05188988e-01f, 8.53460655e-02f, 8.42829496e-02f, 1.44245073e-01f, 7.70186931e-02f, -7.64527321e-02f,
  1.09436713e-01f, 3.39504369e-02f, 1.49518058e-01f, 7.87680820e-02f, -7.96346664e-02f, 1.65172189e-01f, 1.17894173e-01f, 4.37287316e-02f, 3.07769459e-02f, 1.35508642e-01f,
  -7.54976319e-03f, 3.44263375e-01f, 1.26302123e-01f, -5.15189320e-02f, -1.78143452e-03f, -2.68929899e-01f, -1.36049882e-01f, -1.51745975e-01f, 4.43296554e-03f, 1.89754352e-01f,
  2.86209881e-01f, 9.24867541e-02f, 9.16120186e-02f, 5.41243851e-02f, -4.90931197e-05f, -9.16976947e-03f, -1.06376953e-01f, -1.94863334e-01f, -3.03342253e-01f, -1.25422299e-01f,
  -5.97132519e-02f, 2.02681422e-02f, -1.52916287e-03f, -1.00299055e-02f, 1.41825348e-01f, 3.62192430e-02f, 1.27009735e-01f, 1.50948837e-01f, 1.93542868e-01f, 1.87177479e-01f,
  3.41187000e-01f, 2.78792113e-01f, -1.84238806e-01f, 1.93414222e-02f, 1.52829006e-01f, -7.00823590e-02f, -5.19448966e-02f, -5.86902276e-02f, -5.06978994e-03f, 1.37561029e-02f,
  9.74134505e-02f, 9.84772220e-02f, -4.53314222e-02f, 1.37752229e-02f, -2.71918010e-02f, -4.22610566e-02f, 1.85451686e-01f, 1.45939300e-02f, 1.27981678e-01f, 6.70708790e-02f,
  2.73722522e-02f, 1.11843728e-01f, 1.02222851e-02f, -5.34768887e-02f, 1.81165710e-02f, 3.97221372e-02f, 1.32628813e-01f, 1.35795414e-01f, -4.29994538e-02f, 1.24629736e-01f,
  6.52003288e-03f, 3.27525772e-02f, 5.24740592e-02f, -6.82936609e-02f, -4.63061072e-02f, -9.52201262e-02f, 2.04406753e-02f, 8.99146125e-02f, -7.80362785e-02f, -2.24528350e-02f,
  4.67027724e-02f, -2.05404479e-02f, -8.16258416e-02f, -1.10791968e-02f, 7.19589740e-02f, -1.67145561e-02f, -8.41738209e-02f, 4.62913327e-02f, 6.85408264e-02f, -4.85229455e-02f,
  -6.44354671e-02f, 5.48118167e-02f, 3.36539559e-02f, -1.06535153e-03f, -3.17035206e-02f, -3.63993235e-02f, 2.18324456e-02f, -3.55662890e-02f, -6.41809478e-02f, 4.12446633e-02f,
  3.49692740e-02f, -4.88094501e-02f, 2.15835627e-02f, 3.52278762e-02f, 5.58409654e-02f, 1.32320806e-01f, 9.12457258e-02f, 7.90449977e-02f, 6.38491809e-02f, 2.36952528e-02f,
  3.58039625e-02f, 2.88186334e-02f, 4.92575802e-02f, 7.85253271e-02f, -3.10302321e-02f, -6.62042424e-02f, 4.37535048e-02f, 2.55349372e-02f, 2.94439457e-02f, 1.06139608e-01f,
  6.95308074e-02f, -1.14486478e-01f, 4.55525145e-03f, -6.44274354e-02f, -6.35848269e-02f, -1.04565937e-02f, -7.71477520e-02f, -9.94330123e-02f, -1.40901402e-01f, -6.94428980e-02f,
  -2.35300854e-01f, 8.35635737e-02f, 1.14106245e-01f, -9.13251862e-02f, -1.55158892e-01f, -2.34612226e-01f, -1.96944833e-01f, -2.04498738e-01f, -2.59821992e-02f, -1.03887208e-01f,
  -4.53855358e-02f, -1.16930366e-01f, -3.77030335e-02f, 6.83401302e-02f, -1.63800158e-02f, 1.18882097e-01f, 9.84616801e-02f, 8.54210928e-03f, -1.57485187e-01f, -2.25185752e-01f,
  -1.70258462e-01f, -1.37453377e-01f, -1.27703562e-01f, 3.52702625e-02f, 4.49692411e-03f, -9.92455333e-03f, 1.53392568e-01f, 8.60841200e-02f, 1.03601538e-01f, 2.32994437e-01f,
  1.00912284e-02f, 4.80710827e-02f, 2.32488643e-02f, 6.62173927e-02f, -1.61378868e-02f, 1.24458540e-02f, 6.29467294e-02f, 4.61083576e-02f, 7.17588738e-02f, -6.84133992e-02f,
  -1.16513884e-02f, 2.10372508e-02f, 1.69043411e-02f, 2.84966044e-02f, -1.37451962e-02f, 4.51736897e-02f, 5.69486544e-02f, 1.35346688e-02f, 7.79540911e-02f, 1.15334541e-01f,
  -8.47858563e-03f, -5.78307249e-02f, -2.37079337e-02f, -6.00919649e-02f, 4.67528626e-02f, -1.10534951e-02f, -6.92577437e-02f, -2.99872607e-02f, 4.41698804e-02f, -6.70362934e-02f,
  4.73452508e-02f, -4.95072715e-02f, -7.21946490e-05f, -3.20246965e-02f, -8.96514058e-02f, -2.94728763e-02f, 3.71404700e-02f, -1.49564430e-01f, -7.69617781e-02f, 4.22811718e-04f,
  -1.10302664e-01f, 2.07027961e-02f, 1.61302183e-02f, -4.82290871e-02f, -1.34026054e-02f, -1.90536287e-02f, -1.76357795e-02f, -5.02039865e-02f, -3.07859294e-02f, -7.16358284e-03f,
  -8.32621008e-02f, -1.94373913e-02f, -3.14416289e-02f, -2.67292163e-03f, 7.70068914e-02f, 6.06966838e-02f, -4.73319702e-02f, 4.50369827e-02f, 1.41388299e-02f, 3.63281071e-02f,
  -2.80104429e-01f, 1.02974407e-01f, 1.61077566e-02f, 5.33763804e-02f, 3.56691405e-02f, 7.16216415e-02f, -1.63297709e-02f, 2.66618095e-02f, 8.26969743e-03f, -5.19554168e-02f,
  -9.65147987e-02f, 3.11272591e-03f, -3.48070152e-02f, -6.19578138e-02f, 2.21904200e-02f, -8.13142732e-02f, -2.16395696e-04f, -4.10138676e-03f, 8.24810266e-02f, 6.70970231e-03f,
  -5.83663024e-02f, -3.42881195e-02f, -1.35627136e-01f, -3.01105008e-02f, -1.22683076e-02f, -1.39567509e-01f, -1.72331154e-01f, -7.54367188e-02f, -1.46594554e-01f, -1.21193215e-01f,
  1.57247901e-01f, 1.16816409e-01f, 2.41320357e-01f, -2.65514731e-01f, -1.68044925e-01f, 7.73644894e-02f, 2.32559443e-01f, -4.49246503e-02f, -1.78319350e-01f, 6.58199340e-02f,
  1.24469116e-01f, -1.67966232e-01f, -3.60039957e-02f, -2.28775963e-02f, 9.79765281e-02f, 1.78148463e-01f, 1.21082041e-04f, 1.96958959e-01f, 3.05419266e-02f, -1.11400031e-01f,
  -1.64906546e-01f, -1.75569266e-01f, 2.72945996e-04f, 2.84131244e-02f, -8.30697939e-02f, -2.52978336e-02f, 3.55943404e-02f, 1.41475141e-01f, 1.95389152e-01f, 4.17500995e-02f,
  3.13538522e-01f, 1.77390233e-01f, -6.69066012e-02f, -1.51271030e-01f, 5.36480099e-02f, 4.89197150e-02f, 2.19733883e-02f, -4.89998311e-02f, -6.12776577e-02f, 5.57469986e-02f,
  5.35329878e-02f, -1.01861879e-01f, -1.24043338e-01f, 6.54057339e-02f, 6.55827969e-02f, -3.18000019e-02f, -4.03134786e-02f, 3.88843156e-02f, 6.21021688e-02f, 1.14269480e-01f,
  -3.72064598e-02f, -1.00172058e-01f, 1.67648792e-02f, 5.19708032e-03f, 1.40871629e-01f, 6.60810769e-02f, 1.20198704e-01f, 1.36179119e-01f, 1.26284435e-01f, 1.42541602e-01f,
  -2.08572168e-02f, -2.20690537e-02f, 1.32451737e-02f, 3.54199223e-02f, 3.83296236e-02f, -5.33509590e-02f, 6.41812459e-02f, -7.51127303e-02f, 1.95922051e-02f, -3.43513563e-02f,
  -5.79386540e-02f, 8.95712152e-02f, -6.90075383e-02f, -5.75283319e-02f, -6.78429902e-02f, -4.43979427e-02f, -7.89397433e-02f, -1.01622030e-01f, 5.42861000e-02f, 5.26644662e-02f,
  -5.61149456e-02f, -7.84024131e-04f, -5.23607433e-02f, -2.99500953e-02f, 9.90663934e-03f, 2.43387260e-02f, -8.84783417e-02f, -1.99247524e-02f, -5.44685870e-02f, -3.83342281e-02f,
  -1.88491508e-01f, 9.37908813e-02f, 4.76284139e-02f, 2.20338325e-03f, -2.87128426e-02f, 5.98634966e-02f, 9.82151181e-03f, 7.29113445e-02f, 3.73361306e-03f, 8.54212046e-02f,
  6.41823560e-02f, 4.10563909e-02f, 4.38439548e-02f, 7.83382058e-02f, 1.87846106e-02f, 3.64999250e-02f, 1.68052074e-02f, -1.84398666e-02f, 3.76325361e-02f, 1.57109406e-02f,
  -1.00668252e-01f, 2.54953485e-02f, 2.95314882e-02f, -1.63979679e-02f, -4.16980758e-02f, 4.96583730e-02f, 1.18691668e-01f, 1.32012829e-01f, 2.83984486e-02f, 8.10251683e-02f,
  1.91589981e-01f, 3.71074080e-01f, 2.96719313e-01f, 2.71091253e-01f, 9.52521935e-02f, 1.29274160e-01f, 2.46645644e-01f, 7.00195879e-02f, -6.32229522e-02f, 1.51085630e-01f,
  -3.27317156e-02f, -1.80536702e-01f, -6.67993873e-02f, 4.94198911e-02f, 4.89610545e-02f, 3.13079774e-01f, 3.57332230e-01f, 1.89716160e-01f, 1.23847410e-01f, 1.55276969e-01f,
  7.29440600e-02f, 2.74386436e-01f, 2.37635881e-01f, 2.39789307e-01f, 1.10622786e-01f, 1.18345194e-01f, 1.84003338e-01f, 2.13481769e-01f, 1.79140851e-01f, 3.35583597e-01f,
  -9.11979005e-03f, 7.23381862e-02f, 7.39894956e-02f, 1.77847221e-01f, 1.41570807e-01f, 5.73497750e-02f, 1.28027529e-01f, 1.94417715e-01f, 1.03964411e-01f, 1.60517350e-01f,
  2.96409111e-02f, 1.10619694e-01f, 9.35881287e-02f, 1.96074054e-01f, 1.35743156e-01f, 1.37033433e-01f, 2.69433558e-01f, 1.96632773e-01f, 1.05528265e-01f, 1.69179171e-01f,
  1.42341971e-01f, 1.40613630e-01f, 2.29172975e-01f, 2.04450980e-01f, 1.38973802e-01f, 2.14722425e-01f, 1.13421246e-01f, 1.24328181e-01f, 2.24645108e-01f, 2.92291909e-01f,
  -1.15648367e-01f, -1.52082518e-01f, -1.41312167e-01f, -8.73673558e-02f, -4.17371169e-02f, -1.41436547e-01f, -1.79543301e-01f, -4.81375568e-02f, -1.63518682e-01f, -4.43349257e-02f,
  -8.88847709e-02f, -4.89321090e-02f, -2.26458400e-01f, -9.86954570e-02f, -1.47081807e-01f, -6.29740432e-02f, -5.38702682e-03f, 2.19389098e-04f, -9.99482870e-02f, 1.50814909e-03f,
  -1.10445976e-01f, -1.39146090e-01f, 9.55341570e-03f, -1.63875386e-01f, -9.19650421e-02f, -1.09103777e-01f, -9.25593227e-02f, -1.76687419e-01f, -5.26317842e-02f, -1.46558192e-02f,
  1.70012102e-01f, -5.40221818e-02f, 5.63537143e-02f, 8.94346386e-02f, 4.15204354e-02f, 1.84124291e-01f, 9.86783132e-02f, 9.85755622e-02f, -1.98149364e-02f, 1.94790900e-01f,
  8.54501128e-02f, 1.59061626e-01f, 1.40045974e-02f, 6.83583468e-02f, 7.76120508e-03f, 1.11548398e-02f, 2.11571023e-01f, 1.95702031e-01f, 1.31062910e-01f, 1.84876487e-01f,
  2.08788440e-01f, 2.68728316e-01f, 1.50378540e-01f, 2.36844599e-01f, 1.10788345e-01f, 6.69445992e-02f, 6.45996407e-02f, 2.21673220e-01f, 2.42262721e-01f, 3.35814327e-01f
};

// L0_fan_Wp_bar (Shape: 26 x 120)
const int L0_fan_Wp_bar_rows = 26;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  5.74669659e-01f, 1.19774416e-02f, 1.75406307e-01f, 9.01121721e-02f, -6.61528558e-02f, -2.95094609e-01f, -4.07842994e-01f, -2.33409658e-01f, 1.27980271e-02f, 1.72540903e-01f,
  1.59874827e-01f, 2.88865149e-01f, 1.65521726e-01f, 2.09564492e-01f, 5.26003532e-05f, 6.98321611e-02f, 8.89245123e-02f, 1.15242362e-01f, 1.24953121e-01f, 4.75081876e-02f,
  1.33649841e-01f, 1.52341038e-01f, 9.14666951e-02f, 1.06740221e-01f, 1.54001921e-01f, 1.08046971e-01f, -1.64507087e-02f, 1.24451593e-01f, 6.71893358e-02f, 3.77049088e-01f,
  4.67078000e-01f, 1.22005150e-01f, -3.93711105e-02f, -3.98566993e-03f, -1.99159831e-02f, 4.07888107e-02f, -7.53909908e-03f, -2.81375628e-02f, 5.70396427e-03f, -2.73146201e-02f,
  6.10506125e-02f, 1.12649472e-02f, -1.73034370e-02f, -2.60116551e-02f, -1.10016383e-01f, -3.65938954e-02f, -1.09277137e-01f, -1.64587311e-02f, -4.84786741e-02f, 9.21937674e-02f,
  -3.59681877e-03f, 6.57524541e-02f, 8.10261723e-03f, -1.09761059e-01f, -8.93701687e-02f, 8.10344145e-03f, 1.65156219e-02f, 1.24553785e-01f, -6.29374906e-02f, 1.64163992e-01f,
  1.09668560e-01f, 1.65558398e-01f, 1.52604669e-01f, 1.93548590e-01f, 6.97979629e-02f, 8.37449208e-02f, 5.10615185e-02f, -1.53175853e-02f, 2.69081946e-02f, 6.90078512e-02f,
  2.83835046e-02f, 1.05757587e-01f, -3.46326008e-02f, 9.11469981e-02f, 9.26174521e-02f, 2.08861362e-02f, 1.03918932e-01f, 1.88052747e-02f, 4.82249111e-02f, 5.77104688e-02f,
  8.66683945e-02f, 1.95077006e-02f, 7.96047375e-02f, -1.26270102e-02f, 5.59043102e-02f, 1.43524945e-01f, 6.12329170e-02f, 1.15841784e-01f, 3.07581145e-02f, 3.80190685e-02f,
  -2.27951840e-01f, -3.34813297e-01f, 1.61947891e-01f, 3.15405941e-03f, 6.97864518e-02f, -2.13364381e-02f, 1.39927283e-01f, -1.76433604e-02f, -1.55030102e-01f, -4.78756838e-02f,
  -9.20728147e-02f, 1.23670898e-01f, -1.57079861e-01f, -1.21154264e-01f, -6.48163185e-02f, 9.18017235e-03f, 8.61269012e-02f, -1.06472522e-01f, -1.44139305e-01f, -4.58768383e-02f,
  -8.58101621e-02f, -1.45933405e-01f, -3.44503745e-02f, -1.38952941e-01f, -5.86466230e-02f, 5.65915331e-02f, -1.33906323e-02f, 2.32689939e-02f, -4.67330962e-02f, -1.63605899e-01f,
  -6.20460987e-01f, -1.36500627e-01f, 4.32563990e-01f, 4.63696457e-02f, 2.88710818e-02f, -1.63092285e-01f, -1.91719323e-01f, -2.22032085e-01f, -1.59361035e-01f, -5.12199476e-02f,
  5.82677349e-02f, 1.10654915e-02f, 6.71905726e-02f, -1.54639155e-01f, -3.07801396e-01f, 5.89093789e-02f, 1.31736528e-02f, -9.54896510e-02f, -3.26838195e-01f, -3.88984114e-01f,
  -1.96998075e-01f, -2.22416237e-01f, -2.83022404e-01f, -1.78689077e-01f, 1.71366513e-01f, -4.60784789e-03f, 2.22991973e-01f, 8.75238255e-02f, 5.32257557e-02f, 2.72442639e-01f,
  4.25842166e-01f, 1.26643687e-01f, 7.72099569e-02f, -7.15463385e-02f, 8.18057917e-03f, -7.79126436e-02f, 7.76338298e-03f, 1.04515046e-01f, 5.20824268e-02f, 1.87413111e-01f,
  1.68077469e-01f, 7.13111367e-03f, 5.78730404e-02f, 4.35823649e-02f, 1.86992399e-02f, -2.77421009e-02f, -6.85291961e-02f, 2.30694953e-02f, 1.18876390e-01f, 6.76696897e-02f,
  -8.58046263e-02f, -1.70737542e-02f, 4.12742905e-02f, -6.24727234e-02f, 5.82527742e-02f, 3.51289893e-03f, 1.56629588e-02f, 1.31179497e-01f, 5.56556173e-02f, 8.61484706e-02f,
  -2.23744869e-01f, -9.10915062e-02f, -8.76445621e-02f, 2.94034071e-02f, -1.22824669e-01f, -5.23052774e-02f, 1.48428410e-01f, -8.94811526e-02f, -1.08349964e-01f, -3.19460523e-03f,
  1.85998946e-01f, 5.81573099e-02f, 9.39102005e-03f, 1.86201707e-01f, 7.83559531e-02f, -1.20422253e-02f, 7.06898980e-03f, 3.34220342e-02f, 1.13998719e-01f, 7.48840123e-02f,
  1.28693238e-01f, 4.91388664e-02f, 1.84440613e-01f, 1.01397090e-01f, 6.89500943e-02f, 1.35288447e-01f, 1.34912938e-01f, -8.06226954e-02f, -6.46510348e-02f, 3.91542427e-02f,
  3.12363714e-01f, 4.12930623e-02f, 1.22904167e-01f, -1.04309089e-01f, 1.34078115e-01f, 1.15618236e-01f, 1.42341971e-01f, 7.70324618e-02f, 1.98484212e-01f, -4.22087274e-02f,
  9.72286761e-02f, -5.07487170e-02f, 1.45440385e-01f, 3.64562273e-02f, -9.72400978e-02f, -3.72233950e-02f, -1.34073988e-01f, -3.13792713e-02f, 3.80605366e-03f, 1.27674267e-01f,
  -1.09611303e-01f, -1.84467226e-01f, -1.21006079e-01f, -4.25537955e-03f, -7.22333267e-02f, -1.49050534e-01f, 5.58994561e-02f, 1.66301444e-01f, -5.32642715e-02f, -7.54733896e-03f,
  6.19765282e-01f, 3.65589797e-01f, 1.52046323e-01f, 1.83502242e-01f, 5.38397813e-03f, -1.76845565e-01f, -1.82524666e-01f, -1.86848611e-01f, -1.11774586e-01f, 1.79005817e-01f,
  2.28380919e-01f, 4.89608571e-03f, -6.60230815e-02f, -4.71858531e-02f, -7.39487410e-02f, -2.71612685e-02f, -1.24824293e-01f, -4.66013141e-02f, -5.75513057e-02f, 8.45220536e-02f,
  9.16460678e-02f, 1.50161773e-01f, 2.31163472e-01f, 1.11651361e-01f, 1.86316878e-01f, 1.83269065e-02f, 8.68937373e-02f, 1.84359565e-01f, 2.43836164e-01f, 4.51034486e-01f,
  2.65918672e-01f, 2.92923838e-01f, -1.96351841e-01f, 8.61942023e-03f, 7.57209165e-03f, 2.31523085e-02f, 1.74150299e-02f, -2.12395303e-02f, -1.73302457e-01f, -1.85192078e-01f,
  1.38023168e-01f, 5.00488691e-02f, 6.00608774e-02f, -1.04454517e-01f, -9.91716757e-02f, -1.54660186e-02f, 5.19236214e-02f, -8.63857046e-02f, -6.75738230e-02f, -4.45416346e-02f,
  -3.49930786e-02f, 5.28444014e-02f, -1.21213481e-01f, -2.73167163e-01f, -7.20885247e-02f, -1.44924030e-01f, -5.45559451e-02f, -4.87128980e-02f, -9.00092199e-02f, -4.36063856e-02f,
  -2.84877211e-01f, -1.07934256e-03f, 9.34290700e-03f, -2.02020437e-01f, -8.18767212e-03f, -1.51106536e-01f, -1.29339963e-01f, -4.33768146e-02f, -5.44773750e-02f, -2.35730633e-02f,
  -1.54674187e-01f, -1.27815798e-01f, -9.51583460e-02f, -1.35646060e-01f, -1.16583351e-02f, -4.51379046e-02f, 5.64139783e-02f, -1.26825407e-01f, -1.59217134e-01f, 7.53647387e-02f,
  4.03892025e-02f, 1.69942379e-02f, 4.93187681e-02f, -1.20681979e-01f, -1.86873786e-02f, -2.02412099e-01f, -6.19582832e-02f, -3.84957604e-02f, -1.25151128e-01f, 7.39761144e-02f,
  -2.32501835e-01f, -2.53335208e-01f, 6.40659705e-02f, 2.34031841e-01f, 2.19875380e-01f, 1.91090375e-01f, 2.53053039e-01f, 4.53675576e-02f, 6.16889969e-02f, -7.10315853e-02f,
  1.76941752e-01f, 2.73667611e-02f, 2.69964449e-02f, 4.71357480e-02f, -2.73367427e-02f, -1.14366949e-01f, -2.21862886e-02f, 5.31337149e-02f, -1.30000100e-01f, 2.97947340e-02f,
  3.19218189e-02f, -9.18376744e-02f, -1.14784747e-01f, -1.36334360e-01f, -1.59864888e-01f, -2.31480345e-01f, -1.03427440e-01f, -8.43354240e-02f, -1.06167659e-01f, -1.87496975e-01f,
  1.96596473e-01f, 5.70021532e-02f, -3.44016612e-01f, 1.08403087e-01f, -1.20378658e-01f, -4.06870604e-01f, -4.01103437e-01f, -4.13166434e-01f, -1.00935839e-01f, 6.04495499e-03f,
  9.45121273e-02f, 1.67361423e-02f, -6.15828112e-02f, -3.58181328e-01f, -4.21734810e-01f, -4.21384305e-01f, -3.60234529e-01f, -3.56062740e-01f, -4.93080616e-01f, -4.23744529e-01f,
  -4.89530377e-02f, -1.62970200e-01f, -1.09083071e-01f, -2.44662777e-01f, 1.92068234e-01f, -8.31225235e-03f, 6.02353364e-02f, -1.08208440e-01f, -5.81011735e-02f, 1.99196905e-01f,
  7.47535825e-02f, 1.23604961e-01f, -5.54704964e-02f, 7.88188353e-02f, 4.68180552e-02f, -6.58151694e-03f, -6.82003377e-03f, 1.05557859e-01f, 1.81032017e-01f, 7.78691936e-03f,
  7.90981427e-02f, 3.54803838e-02f, 3.79475653e-02f, 6.44673854e-02f, 7.34231845e-02f, 6.47735000e-02f, 1.13120545e-02f, -3.62131372e-02f, -4.92442632e-03f, 6.76243193e-03f,
  2.25269124e-01f, 9.71326903e-02f, -8.44469946e-03f, 5.99993393e-02f, -6.14280766e-03f, 7.97785260e-03f, 9.90364701e-02f, 7.54106045e-02f, -7.86164701e-02f, 6.69429302e-02f,
  -1.23096876e-01f, -2.78575942e-02f, 8.64533931e-02f, 8.11814144e-02f, 5.22529595e-02f, 7.09792525e-02f, 3.52992788e-02f, -4.80259396e-02f, -6.64024577e-02f, 3.79102938e-02f,
  4.02952880e-02f, 4.92571108e-02f, 6.82501728e-03f, -5.34150004e-02f, -6.34445399e-02f, -7.82351717e-02f, -1.61133975e-01f, 4.44617821e-03f, 5.60269915e-02f, -6.98265107e-03f,
  7.25865588e-02f, -7.59396702e-02f, 2.20175851e-02f, 4.70345095e-03f, 4.24818285e-02f, 4.57641967e-02f, -1.88183167e-03f, -8.93979743e-02f, -9.14199129e-02f, -1.29038796e-01f,
  3.35127383e-01f, -6.95576444e-02f, 1.07315943e-01f, 2.82434542e-02f, 9.56665128e-02f, 1.40402645e-01f, 1.77121803e-01f, -2.53093392e-02f, 5.44344857e-02f, 5.57745397e-02f,
  -2.28768438e-02f, -7.69871473e-02f, 3.48095223e-02f, 1.21949576e-01f, -7.68304318e-02f, 9.96374413e-02f, 1.65441111e-01f, 2.59769596e-02f, 1.22272419e-02f, 1.04448348e-01f,
  3.70001346e-02f, -8.33778605e-02f, 6.99499547e-02f, -5.03339656e-02f, -1.46985784e-01f, -1.40175959e-02f, -1.08427927e-01f, -6.71492741e-02f, -2.10627034e-01f, 8.14409778e-02f,
  -3.51754963e-01f, -2.55436122e-01f, -5.09825468e-01f, 4.88750404e-03f, 2.64034897e-01f, 2.23885462e-01f, 1.18426539e-01f, 1.63172781e-01f, 2.87938893e-01f, 3.97503339e-02f,
  2.00606823e-01f, 3.62710804e-01f, 1.88067392e-01f, 2.72153407e-01f, 7.67369196e-02f, 3.43795903e-02f, -3.38114165e-02f, -1.19730599e-01f, 1.91085134e-02f, 3.72225672e-01f,
  3.64967644e-01f, 1.93088949e-02f, -1.29249632e-01f, 7.43651167e-02f, 1.55265838e-01f, 2.67111301e-01f, -2.74981558e-02f, 1.95977837e-02f, -4.93392795e-02f, -1.40136197e-01f,
  -3.31881046e-01f, -3.21734011e-01f, -9.29972082e-02f, 6.38720468e-02f, -1.74296260e-01f, -2.74561346e-01f, -9.71615985e-02f, -3.96452129e-01f, -1.56143993e-01f, -1.16171397e-01f,
  -1.18961811e-01f, -9.12305117e-02f, 6.07758872e-02f, 6.42374456e-02f, -4.22689542e-02f, -9.38596278e-02f, -1.84000954e-01f, -1.47007406e-01f, -3.87946784e-01f, -3.82951915e-01f,
  4.18448001e-01f, -7.03043565e-02f, -6.28899395e-01f, -2.07087025e-01f, -2.87732869e-01f, -5.37591055e-02f, -2.50364751e-01f, -1.99047774e-01f, -4.07859713e-01f, -5.07872701e-01f,
  2.76220473e-03f, -1.38226645e-02f, -8.06770027e-02f, -4.64910967e-03f, 2.04966635e-01f, -2.46705431e-02f, -6.06270321e-03f, 1.89436689e-01f, 5.91850318e-02f, -7.46261105e-02f,
  6.50954619e-02f, 6.23729359e-03f, 6.56552101e-03f, -1.98666584e-02f, 1.41903326e-01f, 5.45038609e-03f, -1.84275012e-03f, -7.95423239e-02f, -1.05171546e-01f, 9.98632833e-02f,
  9.82738212e-02f, 2.82471273e-02f, 1.50920423e-02f, -6.22080304e-02f, -9.78666395e-02f, -6.73628077e-02f, 1.02035940e-01f, 1.44284725e-01f, -1.62998587e-02f, 6.02547042e-02f,
  2.73694575e-01f, 4.46085408e-02f, -1.69816479e-01f, 1.25788376e-01f, -4.40571569e-02f, 1.72149599e-01f, 7.88505469e-03f, -3.19475271e-02f, -5.61583601e-03f, -1.54483065e-01f,
  -2.10584868e-02f, -1.67610794e-01f, 2.03299318e-02f, 1.54498210e-02f, 2.36376915e-02f, 1.08908378e-01f, 5.33763766e-02f, -3.24027054e-02f, 3.63678187e-02f, -1.53429434e-01f,
  8.61449353e-03f, 2.23710686e-02f, -1.94760337e-01f, -1.67711124e-01f, -7.15345070e-02f, 7.01160505e-02f, -3.13190441e-03f, -6.25729039e-02f, -1.50423482e-01f, -1.03862293e-01f,
  -2.58880276e-02f, -3.01254153e-01f, 1.77125528e-01f, 1.75161049e-01f, 3.45563948e-01f, 3.02579910e-01f, 2.62903512e-01f, 1.92170233e-01f, 1.62188753e-01f, 8.07255134e-02f,
  8.30689892e-02f, 1.66622132e-01f, 5.04330508e-02f, 6.51760548e-02f, 8.62862691e-02f, 1.63662940e-01f, 2.32073039e-01f, 2.12064028e-01f, 2.23289117e-01f, 8.30408707e-02f,
  8.24674666e-02f, -5.38414763e-03f, 2.06374694e-02f, -2.81546135e-02f, 1.15865730e-01f, 1.28739879e-01f, 1.24398850e-01f, 4.28064577e-02f, 5.32730250e-04f, -3.22547443e-02f,
  1.91945165e-01f, -2.08542466e-01f, 6.09229542e-02f, -1.19057551e-01f, -8.28188732e-02f, -1.82737336e-01f, 9.43110064e-02f, -7.46486187e-02f, -2.15272591e-01f, -6.78212196e-02f,
  1.63707230e-02f, -9.62854475e-02f, 3.48747969e-02f, -9.60127786e-02f, -2.05720663e-02f, -1.11264326e-01f, -1.18508898e-01f, 5.58407828e-02f, 6.89603686e-02f, 3.13112475e-02f,
  -1.14906475e-01f, 9.29087866e-03f, 1.87778592e-01f, 6.92999363e-02f, 7.41381422e-02f, 7.80604184e-02f, -2.18443926e-02f, -1.22179359e-01f, 1.33109838e-02f, -4.99120913e-02f,
  1.99422523e-01f, 1.42520159e-01f, 1.08177021e-01f, 1.72283888e-01f, 9.99567583e-02f, 5.92793822e-02f, 1.45458449e-02f, 9.76267159e-02f, 1.95190743e-01f, 8.29875693e-02f,
  4.77607660e-02f, 1.24827825e-01f, 1.06972955e-01f, 2.26173475e-02f, 2.74520181e-02f, 6.85290247e-02f, 2.77267601e-02f, -3.47152539e-02f, -4.29629423e-02f, 4.37582321e-02f,
  1.14326164e-01f, -3.79913636e-02f, -8.13903213e-02f, 1.56011702e-02f, -8.97559077e-02f, -4.60578166e-02f, 5.59480488e-02f, -1.51300784e-02f, -3.10948677e-02f, -1.27233073e-01f,
  3.17322880e-01f, 7.79052004e-02f, 1.49380356e-01f, 6.79015443e-02f, -5.91408322e-03f, -1.91193238e-01f, 1.23364320e-02f, -1.25203058e-01f, -1.76460534e-01f, -6.54269755e-02f,
  -1.83897968e-02f, -7.98201859e-02f, 1.38906846e-02f, -5.40727004e-02f, 2.72159502e-02f, 7.05772359e-03f, -5.66483065e-02f, 6.98948652e-03f, 2.21967716e-02f, -4.24481550e-04f,
  -8.17104876e-02f, 1.37049109e-01f, 2.47006416e-01f, 1.61880523e-01f, 8.43854770e-02f, 1.20948099e-01f, -3.27844499e-03f, 7.75393322e-02f, 1.12737201e-01f, 4.07671370e-02f,
  1.74797311e-01f, -4.78524044e-02f, -1.38453960e-01f, 3.95653725e-01f, 2.44088888e-01f, -7.78002962e-02f, -4.27593708e-01f, -1.44911408e-01f, 2.45624587e-01f, 6.30800053e-02f,
  2.34437317e-01f, 3.62444699e-01f, 5.66065544e-03f, -1.98171616e-01f, -5.37600696e-01f, -4.35386389e-01f, -2.21060723e-01f, -2.46735826e-01f, -2.93566912e-01f, -1.02911115e-01f,
  1.49524048e-01f, -7.60800857e-03f, -5.57345301e-02f, -1.47337034e-01f, 2.36083478e-01f, 1.12058781e-01f, -9.02038291e-02f, -3.19569521e-02f, -4.33326326e-02f, 1.06190249e-01f,
  6.03482351e-02f, 3.00521720e-02f, -4.93111126e-02f, 1.90205589e-01f, 2.07375839e-01f, 4.63537425e-02f, -9.94596747e-04f, 1.40094548e-01f, -1.74748674e-02f, -2.60332804e-02f,
  2.85857379e-01f, 1.12851307e-01f, 1.98447511e-01f, 3.93343046e-02f, -7.55165815e-02f, -1.00975875e-02f, -4.88119833e-02f, -1.28722891e-01f, -2.78524011e-01f, 9.43602100e-02f,
  9.62672755e-02f, 1.93649873e-01f, 1.55098271e-02f, -1.94577873e-01f, -1.64828598e-01f, 2.02545756e-03f, -6.59527481e-02f, 1.10899866e-01f, -2.51096874e-01f, -1.95971549e-01f,
  1.37617961e-01f, -4.29017656e-02f, 7.11715082e-03f, -3.83553095e-02f, -8.23262632e-02f, 1.20121010e-01f, -5.10799773e-02f, -1.55362740e-01f, -1.81486905e-02f, -1.35000460e-02f,
  -3.59759144e-02f, 5.55843057e-04f, 8.01142771e-03f, -1.02230735e-01f, -1.06578924e-01f, 5.05360886e-02f, 2.71114688e-02f, -3.10060412e-01f, -1.51473925e-01f, -1.51542416e-02f,
  -7.05881640e-02f, 9.03878734e-03f, 1.35820597e-01f, -7.11092204e-02f, -9.54708904e-02f, -1.54038429e-01f, 7.72407651e-02f, -2.36607287e-02f, 6.97322376e-03f, 3.31948549e-02f,
  1.71635132e-02f, -5.42890131e-02f, -3.55540030e-02f, -2.36549348e-01f, -9.50186178e-02f, -6.21064082e-02f, -6.76170364e-02f, -1.06818371e-01f, 8.21714774e-02f, -1.62693136e-03f,
  -5.40467240e-02f, -8.46519321e-02f, 6.49281591e-02f, -6.01775385e-02f, -1.00368991e-01f, -4.15160060e-02f, -4.22512740e-01f, 4.72818427e-02f, -2.29142591e-01f, 1.42738581e-01f,
  -2.67022163e-01f, -3.11085343e-01f, -1.73314273e-01f, -2.81120211e-01f, -8.57551247e-02f, -8.72620717e-02f, -8.08426738e-02f, 8.42175856e-02f, -2.91530788e-01f, -4.41951096e-01f,
  -2.16590971e-01f, 3.74778479e-01f, -2.96993226e-01f, -1.36467712e-02f, 1.78114586e-02f, -2.21602499e-01f, 6.97924495e-02f, 8.36670846e-02f, 2.48211369e-01f, 2.32786521e-01f,
  1.79676205e-01f, -1.84120417e-01f, -2.55028307e-01f, -3.26196790e-01f, -3.98510337e-01f, -1.30526766e-01f, -2.58989036e-01f, -5.01338720e-01f, -6.67235255e-01f, -3.19489866e-01f,
  -1.57392830e-01f, -3.26616675e-01f, -4.87057626e-01f, -2.92813003e-01f, 8.86885226e-02f, -1.97389960e-01f, 2.55042575e-02f, -2.04803839e-01f, -4.88179028e-02f, 2.78763268e-02f,
  -3.47300440e-01f, 1.16743729e-01f, 4.05279994e-02f, 9.09479782e-02f, 7.62407482e-02f, -2.68170852e-02f, 1.69257671e-02f, -4.34775874e-02f, 8.19237158e-02f, -5.47818579e-02f,
  -2.36774534e-02f, 7.39743710e-02f, -1.24560140e-01f, -7.81782046e-02f, -2.82262247e-02f, -9.54686180e-02f, 1.47722811e-01f, 1.25847742e-01f, -4.87716049e-02f, 1.19877912e-01f,
  2.54413843e-01f, 4.42858301e-02f, 6.39414936e-02f, 2.44660497e-01f, 1.16945922e-01f, 5.00193611e-02f, 2.73579508e-01f, 1.52152121e-01f, 4.63490933e-02f, 2.95245767e-01f,
  1.28997311e-01f, 6.57115206e-02f, 3.97470109e-02f, 8.83311257e-02f, 7.49155059e-02f, -3.93712102e-03f, -6.80900551e-03f, 8.68790820e-02f, -3.14361900e-02f, -8.04580674e-02f,
  5.53616732e-02f, 5.92523925e-02f, -9.85551625e-03f, 2.08336338e-02f, -1.38406858e-01f, 1.08752288e-01f, -3.25860716e-02f, 5.08739566e-03f, -7.54279569e-02f, 5.36133535e-02f,
  -2.88575944e-02f, 1.80442616e-01f, -3.15787196e-02f, -1.81205198e-02f, 1.30329868e-02f, 2.94986833e-02f, -5.99828586e-02f, 7.64088556e-02f, 6.19701222e-02f, -8.51498265e-03f,
  -2.32672289e-01f, -3.37096721e-01f, -4.74722032e-03f, 3.15382294e-02f, -5.09310663e-02f, 4.58535478e-02f, -5.61768189e-02f, -3.40603106e-02f, -2.39380226e-02f, -2.84538865e-02f,
  -1.28606141e-01f, -2.48973835e-02f, -6.06600493e-02f, 1.47773191e-01f, -1.57021612e-01f, -1.94435678e-02f, 1.47661075e-01f, -8.64275731e-03f, -8.29289705e-02f, 2.71173328e-01f,
  1.90999478e-01f, 3.56658883e-02f, 1.06875189e-01f, 6.29618615e-02f, 1.13321349e-01f, -2.12822288e-01f, -2.24625915e-02f, 8.26471597e-02f, -1.27931118e-01f, 1.76561162e-01f,
  2.63066500e-01f, 3.47345620e-01f, 3.07700425e-01f, -1.56724080e-01f, -2.17817277e-01f, -2.01344535e-01f, 3.82906385e-02f, -6.03253953e-02f, -1.38354897e-01f, 1.94168035e-02f,
  -1.80669025e-01f, -2.29559913e-01f, -6.99385777e-02f, 2.51384377e-02f, 1.74627915e-01f, 2.22805038e-01f, 2.64620334e-01f, 3.35907102e-01f, 3.92758474e-02f, -6.68553486e-02f,
  -2.72779595e-02f, 8.18660259e-02f, 1.82593316e-02f, 6.66398555e-02f, 1.63973179e-02f, -2.05446810e-01f, 1.56520903e-01f, 1.61228403e-01f, 1.30920365e-01f, 3.74073595e-01f,
  1.93095878e-01f, 4.03416485e-01f, -2.84575433e-01f, -6.55460879e-02f, 3.21987867e-02f, 9.70876440e-02f, -4.43696193e-02f, 1.72958702e-01f, 1.02961108e-01f, 6.64484203e-02f,
  3.36851142e-02f, 8.43633637e-02f, 3.14877778e-02f, 7.76229054e-02f, -3.03043779e-02f, -2.96686329e-02f, 1.27895027e-01f, 1.64263591e-01f, 1.05147026e-01f, 1.74930822e-02f,
  -8.19910988e-02f, -1.98680997e-01f, -6.19518906e-02f, -1.52089238e-01f, 1.82249293e-01f, -1.58836767e-01f, 3.69789153e-02f, 8.59959871e-02f, -1.17633037e-01f, 1.96495354e-02f,
  -3.57946120e-02f, 1.35231495e-01f, 9.46856439e-02f, 7.77244121e-02f, 9.39512998e-02f, 6.11415058e-02f, 6.57065883e-02f, 2.95445248e-02f, 1.06392428e-01f, 1.68624550e-01f,
  -3.45432013e-02f, -5.29453456e-02f, 3.75180990e-02f, -1.00142499e-02f, -1.30186081e-01f, -7.03774989e-02f, 3.20154615e-02f, -2.34407326e-03f, -8.48318711e-02f, 5.42971715e-02f,
  -1.43903401e-02f, -4.83773852e-04f, -6.58361837e-02f, 7.98204467e-02f, -8.74342397e-02f, -1.51027918e-01f, 1.04376329e-02f, -5.68618663e-02f, -4.97036763e-02f, -1.18313454e-01f,
  -3.25582802e-01f, -4.97220904e-02f, -1.97462782e-01f, 7.87810683e-02f, -2.49964520e-02f, -1.04310878e-01f, -8.79420042e-02f, -6.52737916e-02f, 1.19635109e-02f, -1.77059412e-01f,
  -1.30802870e-01f, -5.93220741e-02f, -2.22780760e-02f, 4.48699109e-02f, -2.18622327e-01f, -2.13839889e-01f, -4.13311683e-02f, -1.83316186e-01f, -1.31874472e-01f, 1.01965647e-02f,
  -4.45973463e-02f, -3.40938807e-01f, -4.52579975e-01f, -3.05144370e-01f, -3.51601332e-01f, -5.84740162e-01f, -2.87864476e-01f, -1.91582128e-01f, -3.69797319e-01f, -2.84485996e-01f,
  6.52714491e-01f, -1.95453595e-03f, 3.63658965e-01f, 8.10540318e-02f, 9.24638212e-02f, 1.63337901e-01f, 9.13625434e-02f, 1.37883961e-01f, -1.15762101e-02f, 7.70809427e-02f,
  -1.28179222e-01f, -4.86282855e-02f, -5.48270941e-02f, 5.52137606e-02f, 2.01644953e-02f, 6.25151768e-02f, 9.71968547e-02f, 2.18120039e-01f, 3.20841104e-01f, 1.14686146e-01f,
  -1.22084126e-01f, 8.56431648e-02f, 1.33156151e-01f, 1.71848521e-01f, -8.55470970e-02f, 9.65922512e-03f, 5.07730767e-02f, -1.55821424e-02f, -3.62914428e-02f, -1.13995358e-01f,
  -2.14556992e-01f, 1.27470553e-01f, -1.92918684e-02f, -1.10617220e-01f, -1.37234941e-01f, -8.48037899e-02f, -7.00715259e-02f, -1.31654531e-01f, 1.47593068e-02f, 1.80442154e-03f,
  -1.52633399e-01f, -6.29564049e-03f, -9.60275531e-02f, -1.10735267e-01f, -5.78284226e-02f, 3.20817456e-02f, 4.18990254e-02f, 8.37237164e-02f, 5.51513769e-02f, -1.05104364e-01f,
  -2.52221934e-02f, 5.67034744e-02f, -6.22570468e-03f, 6.28822520e-02f, 5.23115024e-02f, -6.72931736e-03f, -4.33587395e-02f, -1.81470420e-02f, 1.53773218e-01f, 1.31315500e-01f,
  6.79789782e-02f, 1.23897672e-01f, 3.89105901e-02f, 4.08751611e-03f, 6.11136667e-02f, 1.04009695e-01f, -1.44903855e-02f, 4.89968210e-02f, 7.74136409e-02f, 8.31538662e-02f,
  -2.62994207e-02f, 1.33591458e-01f, 3.90948057e-02f, 1.05326688e-02f, 3.74989919e-02f, -4.52102795e-02f, 4.82877679e-02f, -9.86314267e-02f, -5.89175895e-02f, -6.67552426e-02f,
  -1.66402981e-02f, 3.04549951e-02f, -7.69504607e-02f, -6.99869916e-02f, -7.95437470e-02f, 2.56775524e-02f, -6.89820945e-02f, -1.25363261e-01f, -8.30626935e-02f, 1.11357495e-02f,
  -5.42225838e-01f, 9.18948501e-02f, -5.35100363e-02f, -1.05340235e-01f, 3.43014002e-02f, -4.30464484e-02f, 5.02084196e-02f, -4.92495559e-02f, -9.42660868e-02f, -5.77562749e-02f,
  1.43539775e-02f, 5.04408255e-02f, -3.74588259e-02f, -3.62832434e-02f, 2.52154320e-02f, -6.36065230e-02f, -5.25201075e-02f, 8.25492851e-03f, 2.49955673e-02f, -1.43913284e-01f,
  -1.28499776e-01f, -1.94284488e-02f, 1.97616480e-02f, 8.57166201e-02f, -8.48173648e-02f, -3.68922837e-02f, -6.24710023e-02f, -5.25871515e-02f, -7.70251965e-03f, 2.79947929e-02f,
  1.31474808e-01f, 3.78073275e-01f, 1.06876396e-01f, 1.14104457e-01f, 1.02795891e-01f, 1.06969111e-01f, 3.66517305e-01f, 2.27234334e-01f, 8.83901939e-02f, -4.67219856e-03f,
  -1.01153046e-01f, -3.99059132e-02f, -4.26303893e-02f, 7.55033270e-02f, 1.81898311e-01f, 2.19751507e-01f, 2.46568367e-01f, 1.79930821e-01f, 3.16569619e-02f, 6.35957271e-02f,
  4.87881824e-02f, 8.32156315e-02f, 1.06853582e-01f, 1.40433356e-01f, 1.96470842e-01f, -4.20582704e-02f, 1.22659981e-01f, 6.13248087e-02f, 1.56437859e-01f, 1.45596623e-01f,
  -4.54663217e-01f, 2.20483504e-02f, -1.39956683e-01f, -8.37444365e-02f, 4.02501272e-03f, 6.63776100e-02f, 5.00856601e-02f, -3.93324159e-02f, -5.09292632e-02f, -7.29423622e-03f,
  -2.04326157e-02f, 1.31721959e-01f, 2.31344789e-01f, 1.00811131e-01f, 1.69574097e-01f, 2.00040545e-03f, 1.19841509e-01f, 1.76899508e-01f, -5.49556827e-03f, -3.95749062e-02f,
  7.64581561e-02f, 2.96495259e-02f, -9.52983946e-02f, 2.75542513e-02f, 1.23669244e-01f, -4.98154387e-02f, 1.49596166e-02f, 1.35060444e-01f, 2.09289566e-02f, 1.64821178e-01f,
  2.92767584e-02f, 7.77600333e-02f, 1.22535720e-01f, 1.79771364e-01f, 8.49036798e-02f, -7.85632133e-02f, 9.59393233e-02f, -6.41058153e-03f, 5.60256392e-02f, 2.17863455e-01f,
  -5.28945960e-02f, 2.51324810e-02f, -1.26446977e-01f, -1.03367537e-01f, -6.07029572e-02f, -5.97959347e-02f, 1.81156804e-03f, -2.52094958e-02f, -1.82448663e-02f, -1.30107835e-01f,
  2.89215744e-02f, 5.91800436e-02f, 1.90467834e-02f, 5.91624416e-02f, -2.07684562e-02f, 5.65337436e-03f, 6.65218756e-02f, 4.13714647e-02f, 6.18515238e-02f, 7.70395622e-02f,
  -1.94512248e-01f, -1.81020856e-01f, -1.53624341e-01f, 7.90629461e-02f, -3.52610201e-02f, -9.90284905e-02f, -1.27625808e-01f, -1.37087971e-01f, -1.08530357e-01f, -1.82224661e-01f,
  -1.65272161e-01f, -6.05676435e-02f, 1.06548645e-01f, 6.97291419e-02f, -9.31478962e-02f, -5.86451439e-04f, -7.06043765e-02f, -1.29995242e-01f, -1.47418216e-01f, -2.62519240e-01f,
  -1.66351609e-02f, -2.03811958e-01f, -3.54984015e-01f, -5.40088080e-02f, -3.04283388e-02f, -2.43408710e-01f, -1.85645461e-01f, -5.97934760e-02f, -1.58760622e-01f, -8.01561177e-02f,
  4.47323592e-03f, 2.32730620e-02f, 3.51399481e-02f, 9.11619216e-02f, 1.68136299e-01f, 6.95229992e-02f, 1.32954970e-01f, 7.37872571e-02f, 1.80564597e-02f, -5.34137413e-02f,
  8.32253695e-02f, -4.10352275e-02f, 7.53877237e-02f, 1.88357569e-02f, 1.09766610e-01f, 1.25105947e-01f, 9.07284841e-02f, 8.41755271e-02f, 4.98595200e-02f, -3.03644454e-03f,
  -4.96858992e-02f, 4.71226089e-02f, -9.61235464e-02f, -5.66241220e-02f, -1.27201125e-01f, 7.58603960e-02f, 1.17943389e-02f, -6.50980398e-02f, -7.44793639e-02f, -2.30300184e-02f,
  7.35702785e-03f, 1.61480188e-01f, 7.22314790e-02f, 2.45568994e-02f, -5.83904460e-02f, -1.49523020e-02f, 4.92121354e-02f, -8.44398215e-02f, 7.27154687e-02f, -1.28862830e-02f,
  -2.05724649e-02f, -1.40440539e-01f, -1.59481376e-01f, -9.70041379e-02f, -5.91597240e-03f, 1.79506391e-02f, -7.12552369e-02f, 6.25809059e-02f, -5.31348698e-02f, 1.72150861e-02f,
  -6.96839839e-02f, 3.66450697e-02f, -4.56916615e-02f, -3.97299826e-02f, -3.25137340e-02f, -2.35139523e-02f, -2.15565925e-03f, 1.65791363e-02f, -1.16065904e-01f, 1.54461516e-02f,
  -2.03568369e-01f, -9.99311805e-02f, -1.51831463e-01f, -1.26600131e-01f, -1.43794179e-01f, 8.41991231e-02f, -3.35183889e-02f, -6.45784661e-02f, -1.60498112e-01f, -1.58155829e-01f,
  -1.73811123e-01f, -2.48539224e-02f, -3.84151302e-02f, -2.23743599e-02f, -1.34905621e-01f, -1.47359550e-01f, -1.16186533e-02f, -4.90184240e-02f, -1.22336812e-01f, -1.31552577e-01f,
  -1.61220744e-01f, 3.55417617e-02f, 2.30964515e-02f, -1.08700573e-01f, -4.53234687e-02f, -6.74025789e-02f, -1.19936533e-01f, -9.17014927e-02f, -1.12945065e-01f, -9.57176685e-02f,
  4.91614789e-02f, 2.03174329e-03f, 2.03857780e-03f, -6.06817603e-02f, 5.88607304e-02f, 1.31437536e-02f, 2.96322908e-02f, 9.77131426e-02f, 2.39637539e-01f, 2.36270353e-01f,
  1.07023753e-01f, -8.49929377e-02f, -6.03361726e-02f, -2.72189099e-02f, -4.85882238e-02f, 6.67090714e-02f, 4.49183322e-02f, -1.33500155e-02f, 1.06923081e-01f, 5.85322417e-02f,
  -1.34894615e-02f, 5.10079414e-02f, 9.52503905e-02f, 4.35212022e-03f, 1.10023752e-01f, 9.79867578e-02f, -4.91010845e-02f, 1.05361335e-01f, 1.18879393e-01f, -1.97579851e-03f,
  -4.41397220e-01f, 1.82892010e-01f, 2.01332215e-02f, -2.18934789e-01f, 2.95435518e-01f, 4.15802449e-01f, 5.22453666e-01f, 2.15785190e-01f, -5.13449237e-02f, 1.74575616e-02f,
  3.62799436e-01f, -2.84872241e-02f, -2.54168749e-01f, -2.18820989e-01f, -2.05584969e-02f, 8.03185180e-02f, -1.36718854e-01f, -1.36153236e-01f, 1.23775229e-01f, 2.57958144e-01f,
  1.21280484e-01f, -2.18020335e-01f, -1.71344087e-01f, -1.36302680e-01f, -3.64901692e-01f, -3.65088761e-01f, -1.68220699e-01f, -1.86053947e-01f, 9.45966020e-02f, -5.79215705e-01f,
  -5.09999841e-02f, 3.19188207e-01f, 1.55544311e-01f, -8.29887763e-02f, 9.94353071e-02f, -1.62622333e-01f, -5.44441026e-03f, -1.18056692e-01f, 8.14750418e-02f, -1.53954074e-01f,
  2.18228269e-02f, 5.94121478e-02f, -9.25081149e-02f, 1.39506161e-01f, 4.82890755e-02f, 2.68211626e-02f, -6.13915641e-03f, 5.33800870e-02f, -1.45511061e-01f, 7.44251087e-02f,
  1.31617233e-01f, 1.22446120e-01f, 1.24069206e-01f, 1.10632949e-01f, 1.19114839e-01f, -1.93418190e-01f, -1.46092959e-02f, -1.60498530e-01f, -9.71083567e-02f, -7.26756811e-01f,
  -5.50524704e-02f, -7.21576735e-02f, 2.18774900e-02f, -1.46915287e-01f, -1.42225787e-01f, 1.14432044e-01f, -8.98183733e-02f, -3.81626971e-02f, 3.22976783e-02f, -8.51802081e-02f,
  8.78481418e-02f, 3.18421945e-02f, -4.44948673e-02f, -3.52143333e-03f, -1.01197511e-01f, 4.08587381e-02f, 1.66528702e-01f, 2.98644807e-02f, 4.37312238e-02f, 6.73862994e-02f,
  5.74965067e-02f, 3.66563834e-02f, -2.97613312e-02f, 4.19929065e-02f, 4.67166752e-02f, 1.20192267e-01f, 2.57564802e-02f, 2.75936816e-02f, -6.39739111e-02f, 7.83375874e-02f,
  -4.12495285e-01f, 2.57734239e-01f, -1.84954911e-01f, 8.86167362e-02f, 1.38142094e-01f, -1.94190978e-03f, 1.19696386e-01f, 1.84551269e-01f, 1.75798927e-02f, -1.01032155e-02f,
  1.78615630e-01f, -3.30414213e-02f, -1.50833232e-02f, -4.62488718e-02f, 2.93904860e-02f, 3.94200832e-02f, -6.35831710e-03f, -6.67181658e-03f, 1.81828722e-01f, -1.65773362e-01f,
  -2.31565505e-01f, 6.83124736e-02f, -2.72257566e-01f, -1.48947075e-01f, -1.44832760e-01f, -2.60734558e-01f, -3.25139135e-01f, -1.07041538e-01f, -2.31104806e-01f, -6.75430357e-01f,
  5.74054718e-01f, 2.02166989e-01f, 2.57366180e-01f, 1.20945588e-01f, -8.39465857e-02f, 4.47870195e-02f, -3.26056406e-02f, 1.64900571e-01f, 4.08388637e-02f, 1.75569996e-01f,
  1.58873960e-01f, 2.57799417e-01f, 6.73657507e-02f, 3.43875661e-02f, 1.28967449e-01f, -2.06032529e-01f, -1.48031354e-01f, 2.09757052e-02f, 2.93390974e-02f, -3.83558981e-02f,
  -1.32660717e-01f, -5.86219542e-02f, 7.56410882e-02f, 5.77968953e-04f, -2.71614380e-02f, 4.74674255e-03f, -1.30124064e-02f, -1.02890849e-01f, -4.23303545e-02f, -2.97947496e-01f,
  1.14295162e-01f, 3.80016923e-01f, 6.15872294e-02f, 9.19562578e-02f, 1.66676179e-01f, 1.01637885e-01f, 1.17187105e-01f, 3.39501984e-02f, 1.29937857e-01f, 1.38567090e-02f,
  1.08811967e-01f, 7.28096254e-03f, 1.28796607e-01f, 5.23920916e-03f, 4.16610464e-02f, 5.34499921e-02f, 1.74205080e-01f, 2.34246091e-03f, 6.24652840e-02f, 6.45916536e-02f,
  8.32919329e-02f, 1.30769119e-01f, 1.20173380e-01f, -7.29766116e-03f, 3.17770615e-02f, 4.06330600e-02f, 5.03188260e-02f, 7.61626363e-02f, 9.36981738e-02f, -3.18573639e-02f,
  1.28432795e-01f, 5.04862927e-02f, 1.24945164e-01f, 8.46688226e-02f, 8.85822624e-02f, 1.23955691e-02f, 3.11362725e-02f, -5.35674654e-02f, 9.71576422e-02f, -8.54341662e-04f,
  -3.24810259e-02f, 1.47346154e-01f, 1.16041474e-01f, -1.70500576e-02f, 1.53943717e-01f, 1.30877703e-01f, 7.05456212e-02f, 1.81815356e-01f, 8.52057263e-02f, 1.14507630e-01f,
  6.03464283e-02f, -1.24673694e-01f, 8.25905651e-02f, 7.59768412e-02f, 8.85251239e-02f, 5.56968153e-02f, 1.59561876e-02f, 7.55779669e-02f, -8.00771788e-02f, -3.34192067e-02f,
  -1.50496632e-01f, 3.25939417e-01f, -5.83848283e-02f, -8.97819735e-03f, 1.61610059e-02f, 7.99412504e-02f, 8.71860757e-02f, -7.00099170e-02f, 6.23517036e-02f, 2.57213023e-02f,
  7.45560750e-02f, 1.25331178e-01f, 2.86722388e-02f, -1.18424475e-01f, -1.62925124e-01f, 5.29576428e-02f, 1.25908092e-01f, -3.06054652e-02f, 2.15912866e-03f, 5.20427972e-02f,
  -6.33673593e-02f, 7.07409903e-02f, 9.87172946e-02f, 4.65805605e-02f, -1.31301105e-01f, 1.35487709e-02f, -1.63992550e-02f, -8.53789821e-02f, -7.95311034e-02f, -1.75820619e-01f,
  2.04970419e-01f, 4.50370997e-01f, -9.75531265e-02f, 1.14054799e-01f, 6.57082126e-02f, -1.07273333e-01f, -9.67567880e-03f, -1.23103924e-01f, 1.08519442e-01f, 2.11342573e-01f,
  6.04674034e-02f, -2.70300478e-01f, -9.81446430e-02f, -8.33894983e-02f, -3.06159645e-01f, 2.11895123e-01f, 2.07665876e-01f, -2.94487625e-01f, -6.48045838e-01f, -4.18563664e-01f,
  -3.55066508e-02f, -4.11398523e-03f, -2.10475013e-01f, -2.45606929e-01f, 2.84562498e-01f, -1.07387565e-01f, 2.23018661e-01f, 1.16135590e-01f, 1.40561894e-01f, 3.86675924e-01f,
  8.96772891e-02f, 7.92575702e-02f, -2.07587004e-01f, 2.05806247e-03f, -3.38653661e-02f, -4.38210666e-02f, -1.61867306e-01f, -1.52199671e-01f, 8.06385279e-03f, 1.22232083e-02f,
  -1.32593578e-02f, -5.67653067e-02f, -5.52554615e-02f, -1.37174860e-01f, -2.44853422e-01f, -2.95345604e-01f, -1.04200780e-01f, -2.88272709e-01f, -3.12942892e-01f, -1.56918615e-01f,
  -8.59381109e-02f, -1.95086673e-02f, -4.70378017e-03f, -1.32536041e-02f, -8.96854848e-02f, -6.69608191e-02f, -1.02020599e-01f, -1.75157547e-01f, -3.76090050e-01f, 1.21017538e-01f,
  1.19081102e-01f, 2.47976426e-02f, 4.68465686e-02f, 1.96164206e-01f, -2.37772521e-02f, 6.49102181e-02f, 9.38130468e-02f, -3.46753635e-02f, -5.04767336e-02f, 2.79768333e-02f,
  -9.10987556e-02f, 3.09238192e-02f, -4.58395816e-02f, 4.67748903e-02f, -5.58941700e-02f, 4.93245162e-02f, -2.18414813e-02f, 1.02592692e-01f, -8.42436552e-02f, 2.33869106e-02f,
  -1.22417189e-01f, -6.64996803e-02f, -1.64196044e-02f, -9.29168090e-02f, 1.05070397e-01f, 2.39179898e-02f, -1.94834974e-02f, -9.03825164e-02f, -3.54103558e-02f, 4.24521379e-02f,
  -1.08469147e-02f, -2.83938274e-02f, 1.13720208e-01f, 1.28696477e-02f, 1.01183824e-01f, -5.11866696e-02f, -2.29926780e-02f, -8.28745440e-02f, 5.31944558e-02f, -1.25277489e-01f,
  -2.14595180e-02f, -2.89872307e-02f, 1.67607784e-01f, -1.40172437e-01f, -2.05902070e-01f, 2.51742974e-02f, 2.57129129e-02f, -8.10005590e-02f, -1.40777320e-01f, -5.57016209e-02f,
  2.15332992e-02f, 2.79858679e-04f, -6.81210868e-03f, -5.54980487e-02f, 9.83651504e-02f, -1.40544057e-01f, -1.36333659e-01f, 6.72665909e-02f, -2.38055632e-01f, 1.79651678e-01f,
  4.71327305e-01f, 2.79947728e-01f, 3.13024551e-01f, 2.02803761e-01f, 2.42795750e-01f, 2.06593096e-01f, 3.31053734e-01f, 2.25458503e-01f, -4.31407243e-04f, 1.45760104e-01f,
  1.59465387e-01f, -5.42184263e-02f, -1.55895665e-01f, -5.95811456e-02f, 1.30061572e-02f, 9.59292427e-03f, 5.47979549e-02f, 5.28972484e-02f, 1.03097990e-01f, 4.81539294e-02f,
  -1.30570188e-01f, 1.20148517e-01f, 2.46324852e-01f, 1.08068950e-01f, -7.09524602e-02f, -1.17177524e-01f, 3.53080742e-02f, 1.81186169e-01f, 7.96379596e-02f, -1.02510162e-01f,
  -8.75222012e-02f, 2.80362844e-01f, -1.67518541e-01f, -1.32792369e-01f, -4.92123067e-02f, -9.09428298e-02f, -3.75182182e-02f, -4.38975804e-02f, -1.42849237e-01f, -1.13943592e-01f,
  1.56611968e-02f, -6.55988604e-02f, -1.02891037e-02f, 3.31855528e-02f, -1.45344175e-02f, 7.42514655e-02f, 7.56101403e-03f, -4.35249731e-02f, -4.31089737e-02f, -1.40176907e-01f,
  -1.70166671e-01f, 1.17965817e-01f, 1.97235852e-01f, -1.16331847e-02f, -7.24062920e-02f, -1.19060867e-01f, -2.22924147e-02f, 2.65540853e-02f, -6.69481605e-03f, -7.72667630e-03f,
  -1.71313271e-01f, 2.94327047e-02f, 1.29075080e-01f, -6.33790642e-02f, 8.62253532e-02f, -2.68492643e-02f, -6.12260848e-02f, 1.25158355e-02f, -1.33869937e-02f, 2.62546632e-02f,
  -2.76531978e-03f, -3.50203328e-02f, -4.07171585e-02f, -9.80521962e-02f, -7.73296878e-02f, -5.38039245e-02f, 2.60918611e-03f, -8.18942711e-02f, -3.35913966e-03f, 7.48004243e-02f,
  6.30895793e-02f, -4.73890677e-02f, -2.75813416e-02f, -6.05371855e-02f, -9.73528102e-02f, -1.07111141e-01f, -8.04418549e-02f, -5.85635304e-02f, 3.33369337e-02f, -1.26707643e-01f,
  -2.93290377e-01f, 6.56661913e-02f, -2.24517539e-01f, -1.06980972e-01f, -5.04968092e-02f, 3.67035978e-02f, -1.33864656e-01f, -5.20364009e-02f, -1.46082435e-02f, -1.76070146e-02f,
  1.27209738e-01f, -2.52132323e-02f, -4.82094251e-02f, -1.71364620e-02f, 3.95229533e-02f, -4.66001332e-02f, -9.21101049e-02f, -9.62495953e-02f, -1.14810847e-01f, -7.86276185e-04f,
  -7.27149425e-03f, 6.68945983e-02f, 2.09622532e-02f, -1.44614697e-01f, -1.89912096e-01f, -1.75924495e-01f, 1.77889653e-02f, 7.82724284e-03f, -4.34512459e-02f, -8.52815211e-02f,
  -7.65630901e-02f, 3.70456418e-03f, -4.56826657e-01f, -2.63251066e-01f, -3.23102444e-01f, -3.41981888e-01f, -3.10170561e-01f, -8.96436721e-02f, -1.95419356e-01f, -2.20799893e-01f,
  1.19011581e-01f, 4.30943400e-01f, 1.65200680e-01f, 9.23347175e-02f, 6.37536943e-02f, -3.94415021e-01f, -3.72455448e-01f, -1.40473738e-01f, 1.30480886e-01f, 1.67582124e-01f,
  2.29867324e-02f, -2.20990911e-01f, -2.29991470e-02f, -4.82963026e-02f, -1.65537715e-01f, -6.50909021e-02f, -4.00404900e-01f, -2.95620471e-01f, -1.14617310e-01f, -3.88987154e-01f,
  1.66137844e-01f, -2.08024189e-01f, -2.19188295e-02f, 4.64993641e-02f, -3.56339775e-02f, 5.55878952e-02f, 1.01106092e-01f, -1.61625519e-01f, 9.45101026e-03f, 1.05999373e-02f,
  -8.36313963e-02f, 5.60892560e-02f, 1.63274948e-02f, 5.54450341e-02f, -4.40944172e-02f, -9.49049592e-02f, -4.98224534e-02f, -4.96662371e-02f, -9.36499760e-02f, 5.69230840e-02f,
  5.36717698e-02f, -5.11349179e-02f, 2.35588904e-02f, -7.83920735e-02f, 5.01590967e-02f, -6.15278706e-02f, -3.98693234e-03f, -8.59886184e-02f, -8.62592310e-02f, -8.99832323e-02f,
  -7.83686936e-02f, 6.37446344e-02f, 1.05255313e-01f, 6.22859523e-02f, 7.79463351e-02f, -4.55920547e-02f, -2.02783998e-02f, 1.20371878e-01f, -2.93478579e-03f, 1.41528904e-01f,
  -5.11467941e-02f, -1.28989026e-01f, 1.66468546e-02f, -1.88845247e-01f, 3.17497877e-03f, -2.33313236e-02f, 1.37933996e-02f, 9.70486253e-02f, 6.29470497e-02f, 2.29110401e-02f,
  1.04667753e-01f, 5.20966016e-02f, -2.26165745e-02f, -1.61674619e-02f, -1.15332697e-02f, -5.65915965e-02f, -2.53832899e-02f, 1.82967290e-01f, -3.65826115e-02f, 7.39784464e-02f,
  2.16739789e-01f, -1.00678429e-01f, -2.28298660e-02f, 1.43836573e-01f, -1.53899854e-02f, 5.16740866e-02f, 1.30383223e-01f, -2.14404287e-03f, -3.78633514e-02f, 1.14757806e-01f,
  3.22577208e-02f, 1.01076499e-01f, 6.53609186e-02f, -2.43875831e-02f, 1.05171986e-01f, -3.71197201e-02f, 2.35388838e-02f, -2.01043580e-03f, 2.62419917e-02f, 1.56967307e-03f,
  6.88432977e-02f, 7.73682073e-02f, 2.59057939e-01f, 1.03261068e-01f, -1.64312311e-03f, 2.01363452e-02f, 3.83654647e-02f, 1.54695332e-01f, 1.54080555e-01f, 8.22494701e-02f,
  -5.68993211e-01f, -1.22480765e-01f, -7.57981539e-02f, -1.66370600e-01f, -8.37140344e-03f, 9.50375721e-02f, -2.43199810e-01f, 1.72734320e-01f, 2.45695904e-01f, -1.93454325e-01f,
  -2.11386625e-02f, -1.62722588e-01f, -2.63158858e-01f, -8.81651044e-02f, -2.70079076e-01f, -4.21927482e-01f, -3.05016339e-01f, -2.65434444e-01f, -1.32675439e-01f, 8.48536268e-02f,
  -1.23778678e-01f, -2.24886909e-01f, -2.21975967e-01f, 4.46953699e-02f, 9.72937942e-02f, 2.54559405e-02f, -5.92200197e-02f, -5.38491793e-02f, 3.31878364e-02f, -1.95133865e-01f,
  -1.61990508e-01f, 2.39350125e-01f, 2.09624588e-01f, -1.51252344e-01f, 1.99171668e-03f, -9.73380208e-02f, 1.59630552e-02f, 1.45717517e-01f, 5.31373993e-02f, -1.00195110e-02f,
  -3.89432795e-02f, 1.36455268e-01f, 8.13854337e-02f, 1.25642091e-01f, -6.84671402e-02f, -1.20855503e-01f, -1.93494055e-02f, 4.58059721e-02f, 1.28298208e-01f, 5.48452921e-02f,
  -1.57097459e-01f, -1.06007725e-01f, -1.58050463e-01f, 1.77995026e-01f, 1.01826407e-01f, -2.60406435e-01f, 1.84263825e-01f, 3.17694783e-01f, 1.46673113e-01f, 1.59337930e-02f,
  -1.12116635e-02f, 6.98762611e-02f, 1.89325690e-01f, 2.27047563e-01f, -7.52950162e-02f, 1.68441609e-01f, -4.06791121e-02f, -6.01939298e-02f, 4.97861281e-02f, -1.22787468e-01f,
  -1.74241560e-03f, 1.87082682e-02f, -2.06348412e-02f, -1.04895256e-01f, 1.01128984e-02f, -1.27104476e-01f, -5.65112792e-02f, -1.04327850e-01f, 4.57752263e-03f, -7.02752843e-02f,
  -7.79234841e-02f, 8.39710087e-02f, 4.18347754e-02f, -8.65077674e-02f, -4.47732657e-02f, -7.80882388e-02f, 4.49904166e-02f, -6.20752387e-02f, -7.97733590e-02f, -6.60706460e-02f,
  -1.84874311e-01f, -8.29340443e-02f, -1.34626746e-01f, -1.08884066e-01f, -1.18488126e-01f, 5.87358214e-02f, -1.67969819e-02f, -1.14749698e-02f, -1.46535501e-01f, -7.89425522e-02f,
  1.44852430e-01f, -1.03673182e-01f, -1.14374077e-02f, 5.48022538e-02f, -6.86188694e-03f, 6.55961782e-02f, -1.97398797e-01f, -1.80219963e-01f, -5.33073656e-02f, 2.08360795e-02f,
  -2.45674074e-01f, -2.29374602e-01f, -4.06090587e-01f, -2.99444348e-01f, 8.01844075e-02f, -3.10014933e-01f, -8.30123574e-02f, 2.63145715e-02f, -6.52573854e-02f, -2.83329129e-01f,
  5.69868326e-01f, 3.67421061e-01f, 1.66901037e-01f, 1.47008626e-02f, -1.57855079e-02f, -2.10425854e-02f, 7.39394352e-02f, 7.23771676e-02f, 1.14918098e-01f, 8.70235339e-02f,
  2.60411561e-01f, 1.65815756e-01f, 1.41022131e-01f, 1.67137459e-01f, 2.20071778e-01f, -3.24455164e-02f, -1.01214431e-01f, 1.04658045e-01f, 1.96425200e-01f, -5.55568887e-03f,
  -2.98755076e-02f, -5.84931523e-02f, 9.09907445e-02f, 7.08231255e-02f, -9.02820528e-02f, 4.83529903e-02f, -6.19337969e-02f, -3.44475657e-02f, -1.20829396e-01f, -1.84256703e-01f,
  -2.31110930e-01f, -4.73947749e-02f, 2.69983690e-02f, 4.20626476e-02f, -6.26294836e-02f, 1.31458240e-02f, 5.44401295e-02f, 1.06753692e-01f, 1.54208168e-01f, 9.27341282e-02f,
  -8.07097033e-02f, -1.27510920e-01f, -1.25086848e-02f, 3.59699279e-02f, -1.00072764e-01f, -8.30462351e-02f, 4.06621471e-02f, 1.39062196e-01f, 6.79496974e-02f, 2.05314979e-02f,
  7.00430498e-02f, 3.82809825e-02f, 5.41437864e-02f, -6.03969209e-02f, 7.90484175e-02f, -2.00080648e-02f, 9.94190872e-02f, -8.30396041e-02f, -5.75691462e-02f, 1.02860264e-01f,
  7.34761357e-02f, 1.66768562e-02f, 4.89411913e-02f, 3.73046137e-02f, -2.81975735e-02f, 4.68819812e-02f, 6.32025301e-02f, 7.12068081e-02f, -7.72364661e-02f, -2.52344180e-02f,
  -5.49604483e-02f, -9.05384049e-02f, 1.44490778e-01f, -4.73314784e-02f, -4.19772118e-02f, 1.13531306e-01f, 7.64555931e-02f, -5.60463741e-02f, 4.14525857e-03f, -9.09737796e-02f,
  -1.27858922e-01f, 9.96776950e-03f, -1.21226244e-01f, -9.91990119e-02f, -4.27710684e-03f, 3.16173770e-02f, -7.90876076e-02f, -4.05890774e-03f, -6.66057169e-02f, 2.20519155e-02f,
  -1.52109504e-01f, -1.19883381e-01f, -3.90748978e-02f, 4.80664261e-02f, -4.56075780e-02f, -7.78950602e-02f, -2.76126955e-02f, -7.26125482e-03f, -9.69971716e-02f, -1.03204027e-01f,
  5.09918965e-02f, 4.27335704e-04f, -1.35885373e-01f, -8.23652521e-02f, -1.18035883e-01f, 1.67044066e-02f, 7.61188492e-02f, 4.72488999e-02f, -5.32587618e-02f, -8.51793438e-02f,
  -5.71174994e-02f, 4.44815727e-03f, 2.80523170e-02f, 8.14627018e-03f, -1.06378645e-01f, 1.19263660e-02f, -3.42996567e-02f, -1.27164777e-02f, 2.32523456e-02f, -1.01681061e-01f,
  -6.62841916e-01f, -1.28790781e-01f, -2.39767004e-02f, 1.23713136e-01f, 1.83561131e-01f, 2.91405857e-01f, 1.60982594e-01f, 1.31558076e-01f, 9.29803699e-02f, 8.89302045e-02f,
  2.24634204e-02f, -6.43817382e-03f, 2.60309447e-02f, 1.71180248e-01f, 1.61431894e-01f, 2.42318600e-01f, 4.04049218e-01f, 1.24929465e-01f, -1.12750851e-01f, 1.59073584e-02f,
  2.25617036e-01f, -1.52016478e-02f, -6.76740482e-02f, 4.32890877e-02f, 6.05179220e-02f, 1.12545229e-01f, 2.15786040e-01f, 2.40875334e-01f, 2.62146503e-01f, 2.94861227e-01f,
  -1.71511769e-02f, -1.35022223e-01f, 2.36862479e-03f, 1.61264569e-03f, -1.75739467e-01f, -2.66813546e-01f, -9.86993611e-02f, -2.74797659e-02f, 2.37075351e-02f, -4.01454940e-02f,
  6.08854927e-02f, -1.30703866e-01f, -3.67528163e-02f, -6.92620268e-03f, -6.45507593e-04f, -1.24254949e-01f, -1.36054933e-01f, 1.17169298e-01f, 1.17114022e-01f, 9.67133865e-02f,
  8.66887271e-02f, 1.24371596e-01f, 9.38271731e-02f, 3.19725485e-03f, 1.24498814e-01f, 3.67320031e-02f, -4.80418578e-02f, -7.75293037e-02f, -8.54530483e-02f, -5.04611135e-02f,
  1.69525370e-01f, 2.45597567e-02f, -5.99893667e-02f, -3.11633963e-02f, -4.39462177e-02f, 2.31315084e-02f, 2.00084932e-02f, 1.08512536e-01f, 1.16750844e-01f, -6.34011999e-02f,
  -2.38002259e-02f, 1.45315781e-01f, 2.35184412e-02f, -9.41620469e-02f, -2.80344356e-02f, 6.93209767e-02f, 3.24378461e-02f, -8.91496092e-02f, 3.18666128e-03f, -1.58587322e-02f,
  9.69556123e-02f, 1.23993240e-01f, -1.18625246e-01f, 9.20030996e-02f, -1.72504988e-02f, 1.48527310e-04f, 1.37074783e-01f, 4.13644463e-02f, -9.06278640e-02f, -1.39709450e-02f,
  1.62903041e-01f, 1.54993758e-01f, 1.93861313e-02f, 1.52912304e-01f, 4.32923846e-02f, -1.05246730e-01f, -4.85506095e-02f, 3.40616889e-02f, 6.81632236e-02f, 5.18700480e-03f,
  -8.88198167e-02f, -1.12273559e-01f, -1.19063668e-01f, -9.98059586e-02f, -6.87282979e-02f, -1.06542096e-01f, -1.62082165e-01f, 6.91895559e-02f, 1.24742702e-01f, 8.05778503e-02f,
  6.80586547e-02f, 4.27419413e-03f, 1.01565890e-01f, -2.82499697e-02f, -3.31528485e-02f, 4.89551537e-02f, -5.85981943e-02f, -9.62020233e-02f, -7.93323591e-02f, -1.29753843e-01f,
  -1.01739526e+00f, -2.01539919e-01f, 4.83430296e-01f, -4.75364029e-01f, -2.67463893e-01f, -2.69397706e-01f, -3.78497809e-01f, -3.43381017e-01f, -3.63323182e-01f, -2.05872819e-01f,
  -2.12315097e-02f, 1.54472217e-01f, 2.72393972e-01f, 2.34968960e-01f, -9.45825055e-02f, -2.82211512e-01f, -1.77477449e-01f, 6.92433342e-02f, 4.24992405e-02f, -1.70591790e-02f,
  -1.22218788e-01f, -1.94860592e-01f, -2.54736304e-01f, -3.19632003e-03f, -6.12784773e-02f, 3.06278164e-03f, 2.36870974e-01f, -1.24815971e-01f, 2.64644306e-02f, -1.45711988e-01f,
  3.39124233e-01f, -2.42539644e-01f, -1.87148713e-02f, -8.64764601e-02f, 6.10534251e-02f, 1.36323506e-02f, -7.93609023e-02f, -1.10863512e-02f, -3.12057678e-02f, 1.14179971e-02f,
  -2.01292653e-02f, 8.76555592e-03f, -8.21569352e-04f, 1.37952462e-01f, -1.76104367e-01f, -3.23128514e-02f, 1.11329734e-01f, -1.08060539e-01f, 2.96085719e-02f, 9.86429304e-02f,
  6.71957508e-02f, -2.00523697e-02f, 1.24437094e-01f, 8.33538845e-02f, 3.90220098e-02f, 1.40782103e-01f, 2.32023410e-02f, 4.56939936e-02f, 1.79826126e-01f, -8.48494470e-02f,
  4.26776148e-03f, 1.54497564e-01f, 4.91344258e-02f, 2.84823291e-02f, -3.42795700e-02f, 2.46219058e-02f, -6.59596995e-02f, 1.00534029e-01f, 1.19308487e-01f, 7.72476569e-03f,
  -4.15038094e-02f, 2.75021810e-02f, 2.68312581e-02f, -2.07405500e-02f, 6.88605979e-02f, -2.52315905e-02f, -1.97761849e-01f, -2.27750931e-02f, 6.44794181e-02f, 3.78318205e-02f,
  -6.15048036e-02f, -1.35324430e-02f, -8.73668939e-02f, -6.51874542e-02f, -1.87182333e-02f, -6.93375021e-02f, 1.00020081e-01f, 7.53930807e-02f, 5.71846925e-02f, 4.28344570e-02f,
  6.09003976e-02f, -3.27952653e-02f, -2.10538700e-01f, -3.23323207e-03f, 3.15166041e-02f, 1.21625334e-01f, 1.93223909e-01f, -5.38284555e-02f, -6.25756830e-02f, 2.04616357e-02f,
  4.46055233e-02f, 1.84974317e-02f, 2.23662499e-02f, 5.20279594e-02f, -3.39146890e-02f, -3.30465436e-02f, -5.35941543e-03f, -1.53972125e-02f, 8.30457285e-02f, 3.02985925e-02f,
  8.88794363e-02f, -1.37103707e-01f, 1.69356316e-02f, 1.05904244e-01f, -9.18623433e-03f, -1.69093683e-02f, 1.39697462e-01f, 7.67017156e-02f, -5.75551465e-02f, -1.90822244e-01f,
  -3.96857232e-01f, -3.06698412e-01f, 3.49149674e-01f, 2.12412640e-01f, -1.01032645e-01f, -2.58011281e-01f, -4.86871272e-01f, -2.50482976e-01f, -5.95757775e-02f, -1.52402759e-01f,
  -2.35144243e-01f, 1.29324570e-01f, 1.80141225e-01f, 2.16078669e-01f, -9.35280696e-02f, 9.10609737e-02f, 5.48744678e-01f, 4.37373281e-01f, 1.62562773e-01f, -2.29629233e-01f,
  -7.57229375e-03f, 2.71512773e-02f, 1.55468732e-01f, 1.66279316e-01f, 1.70225233e-01f, 1.10512361e-01f, 2.65689760e-01f, 1.89409479e-01f, 3.80073860e-02f, 5.08563280e-01f,
  -8.84600803e-02f, -3.12555134e-01f, 4.04601283e-02f, 9.78686512e-02f, 1.06639609e-01f, -5.66502064e-02f, -3.63703854e-02f, 1.31071821e-01f, -1.89429671e-02f, 3.47960070e-02f,
  1.80012450e-01f, -2.59966776e-02f, 1.21244557e-01f, -1.89319868e-02f, -6.93505183e-02f, -9.87049267e-02f, 1.72947213e-01f, 1.25054494e-01f, 1.45233527e-01f, -1.05418555e-01f,
  1.62347108e-01f, 5.78492992e-02f, -1.38227388e-01f, -1.46444023e-01f, -1.33592889e-01f, -1.80058442e-02f, -2.72343129e-01f, -4.97629568e-02f, -2.88374037e-01f, -2.08339244e-01f,
  -1.43988937e-01f, -4.16816361e-02f, 3.63366008e-02f, -2.22738571e-02f, -2.58256886e-02f, 1.76530369e-02f, 1.88102439e-01f, 6.92313090e-02f, 1.70864716e-01f, -5.62426336e-02f,
  6.98967949e-02f, -5.43993600e-02f, 4.73671928e-02f, -1.69224858e-01f, 2.38534044e-02f, 6.40514791e-02f, 2.20498610e-02f, 1.08197629e-01f, -3.62372063e-02f, -3.24108414e-02f,
  9.44508016e-02f, 5.95401321e-03f, 1.22083604e-01f, 1.34448811e-01f, -5.66960424e-02f, -5.58217019e-02f, 5.79762869e-02f, -4.28859442e-02f, 3.96953486e-02f, -2.04057321e-01f,
  -2.94854641e-01f, 1.09510332e-01f, -5.94727732e-02f, 3.73541266e-02f, -9.28245410e-02f, -4.03403044e-02f, -6.95307478e-02f, 2.68196091e-02f, -1.08093925e-01f, -2.06944719e-01f,
  -1.84721902e-01f, -2.06805825e-01f, -9.33684260e-02f, 9.92566869e-02f, -6.94436729e-02f, 2.04342362e-02f, 8.38699639e-02f, 3.93998437e-02f, -8.29855129e-02f, -1.45341128e-01f,
  6.91614896e-02f, -9.95347053e-02f, -2.66625166e-01f, -1.32923380e-01f, -1.71619967e-01f, -2.73527056e-01f, -3.56772631e-01f, -2.48262882e-01f, -5.11046827e-01f, -6.93630040e-01f,
  -2.33042352e-02f, 3.04677486e-01f, 1.88983411e-01f, 1.54897064e-01f, -9.39177349e-03f, -8.00620671e-03f, -4.38227281e-02f, 4.79141101e-02f, 1.45452553e-02f, 2.24092230e-01f,
  2.50987142e-01f, 3.13790143e-01f, 3.49259257e-01f, 2.57389873e-01f, 2.68599868e-01f, 1.06194705e-01f, 6.37591854e-02f, 1.00575186e-01f, 1.82103794e-02f, 1.91644624e-01f,
  8.49372968e-02f, -7.87006244e-02f, -5.01142368e-02f, 3.28689031e-02f, 1.91555038e-01f, 1.87751383e-01f, 9.14030224e-02f, 5.45485280e-02f, 1.66544110e-01f, 2.14986905e-01f,
  2.91828841e-01f, -1.40200835e-02f, -1.89948082e-03f, -1.18461348e-01f, -9.23157483e-02f, -1.94917753e-01f, -1.18637795e-03f, -5.27423359e-02f, -1.82934791e-01f, -9.03545916e-02f,
  -8.33154991e-02f, -9.06862468e-02f, -2.41373223e-03f, -2.62728818e-02f, -5.94909824e-02f, -1.87338009e-01f, -8.36231280e-03f, 5.01786843e-02f, 1.42563000e-01f, 5.89552661e-03f,
  -3.31420638e-02f, -5.15814200e-02f, -4.03872207e-02f, 7.73231611e-02f, 2.31412668e-02f, -4.38824631e-02f, 4.67916913e-02f, -4.23313156e-02f, 6.43036962e-02f, -1.51589131e-02f,
  3.30491424e-01f, 5.60845993e-02f, 1.88928679e-01f, 8.52207392e-02f, 5.39165772e-02f, -5.29190116e-02f, -7.28702173e-02f, 4.23491411e-02f, 1.11346424e-03f, -1.24927491e-01f,
  -5.17387735e-03f, 1.40471756e-01f, 5.30181862e-02f, 1.42839178e-02f, -2.98496801e-02f, 6.80182725e-02f, -1.05188653e-01f, 8.74486119e-02f, -5.94578162e-02f, -9.47446600e-02f,
  -3.70134115e-02f, -2.78685428e-02f, -1.06715344e-01f, -1.17000557e-01f, -9.31213796e-02f, -4.45928611e-02f, 1.60813462e-02f, -9.13014710e-02f, -4.98378873e-02f, -1.08552821e-01f,
  1.40852019e-01f, 9.51442048e-02f, 1.71895429e-01f, 3.39699835e-02f, -1.62607193e-01f, -1.01883925e-01f, 1.99322015e-01f, 4.06436510e-02f, -1.67616263e-01f, -2.34488416e-02f,
  -4.70268913e-02f, 3.26269530e-02f, -2.69617066e-02f, -1.12904839e-01f, -1.13070726e-01f, -1.82411328e-01f, -4.54762671e-03f, 7.61232451e-02f, -2.50298809e-02f, 4.25428674e-02f,
  -1.03647560e-01f, -1.39996400e-02f, 6.00532070e-02f, 6.87217563e-02f, -3.00125331e-02f, -3.06309834e-02f, -4.35803533e-02f, -1.02884591e-01f, 5.71668781e-02f, -1.12095736e-01f,
  -3.92421246e-01f, -3.52174640e-01f, 3.52263413e-02f, 2.80670021e-02f, 7.22619742e-02f, -3.02007832e-02f, -1.02890782e-01f, 1.06650777e-02f, -7.69744143e-02f, -1.79279551e-01f,
  -1.30217925e-01f, -1.17864288e-01f, -1.62123278e-01f, -5.95115423e-02f, -1.87338307e-01f, -5.26665226e-02f, 2.95426510e-03f, 6.89320341e-02f, -2.60344204e-02f, -4.42966931e-02f,
  -1.05431870e-01f, -5.69597855e-02f, -3.48638110e-02f, -1.30176291e-01f, -1.75665945e-01f, 6.39584959e-02f, -8.75304937e-02f, 5.25261201e-02f, -7.23593161e-02f, -3.27467620e-02f,
  2.14954823e-01f, -2.57742912e-01f, -5.78291975e-02f, -5.22866361e-02f, -4.39888686e-02f, -1.25618041e-01f, 2.12807860e-02f, 8.23767632e-02f, 1.42617583e-01f, 4.85740378e-02f,
  2.93484237e-02f, -1.43677101e-01f, -7.64574483e-02f, 5.16507886e-02f, 6.69319034e-02f, 3.46618146e-02f, 5.35710417e-02f, 3.73440534e-02f, 3.71090323e-02f, -4.10322323e-02f,
  -9.04584751e-02f, 7.75612295e-02f, 3.08606289e-02f, 2.72525921e-02f, 1.52312368e-02f, 8.03091526e-02f, 6.96837753e-02f, 2.35608593e-02f, 1.01329446e-01f, 6.66543916e-02f,
  9.14384425e-02f, -9.24507380e-02f, -1.08256266e-01f, -6.61507025e-02f, -6.59524649e-02f, 2.41933446e-02f, 7.93869868e-02f, -8.73035565e-02f, -2.06998080e-01f, -1.69280827e-01f,
  -6.10614084e-02f, -9.11305994e-02f, -8.81273970e-02f, 1.44441379e-02f, 1.93610527e-02f, -3.59501317e-02f, 4.15246654e-03f, 9.94569808e-03f, -8.87022391e-02f, -1.07073486e-01f,
  -8.77540857e-02f, -3.38881873e-02f, -5.21954633e-02f, 2.59755161e-02f, 3.99123020e-02f, 1.00699797e-01f, -1.10075772e-02f, 6.44032797e-03f, -1.45876240e-02f, -7.27009475e-02f,
  1.78173780e-01f, -2.40408614e-01f, -9.57466438e-02f, -2.13440299e-01f, -5.92209734e-02f, -9.39706117e-02f, -1.86624065e-01f, 1.07951071e-02f, 6.48552850e-02f, 1.74544543e-01f,
  1.24526508e-01f, -4.62249741e-02f, -4.11343612e-02f, -2.28574835e-02f, 1.61304668e-01f, 1.87700063e-01f, 2.04971172e-02f, -7.45918155e-02f, 2.82091796e-02f, 2.90401112e-02f,
  7.97424689e-02f, 5.47233187e-02f, 7.78288692e-02f, 1.28738051e-02f, 1.55634284e-02f, 1.17512912e-01f, 9.79025736e-02f, 1.22844847e-02f, 1.23937950e-01f, 1.72769293e-01f,
  -1.02292693e+00f, 1.24843761e-01f, 2.94465333e-01f, -6.28898144e-01f, 2.12577581e-02f, 1.74816191e-01f, 5.18774986e-01f, -4.76788431e-02f, -4.33538973e-01f, 7.38383681e-02f,
  9.63639021e-02f, -1.79622009e-01f, -3.27987745e-02f, 1.50617003e-01f, 2.50092238e-01f, 3.91264647e-01f, 1.61369503e-01f, -3.88024375e-02f, -1.20342642e-01f, 1.10369176e-01f,
  1.85376015e-02f, -3.05376172e-01f, -4.71508801e-01f, -3.24858695e-01f, -2.28048071e-01f, -2.09918588e-01f, -3.95671055e-02f, -1.22439571e-01f, 1.54386267e-01f, -3.67035298e-03f,
  3.62354457e-01f, -2.93815225e-01f, 2.76632551e-02f, -1.60716966e-01f, -1.08309403e-01f, -1.57426760e-01f, -7.36223087e-02f, -2.07248613e-01f, -7.37251565e-02f, -6.90385923e-02f,
  -1.98668107e-01f, -5.50358593e-02f, -1.43539593e-01f, -2.16415315e-03f, -1.04182117e-01f, -6.03449419e-02f, -3.28940153e-02f, -7.27959350e-02f, -3.16844881e-02f, 1.45271853e-01f,
  4.74470370e-02f, 6.56307116e-02f, -6.69166818e-02f, 1.28157556e-01f, -1.04480973e-02f, -2.89559085e-02f, 8.88595283e-02f, -4.54301871e-02f, 9.14798155e-02f, -2.86018960e-02f,
  7.80958869e-03f, 8.46338982e-04f, 5.32720350e-02f, 4.56117801e-02f, -5.39141819e-02f, -1.21927792e-02f, -6.92466088e-03f, 3.38344984e-02f, -1.29581513e-02f, -2.92500630e-02f,
  -6.90140277e-02f, -3.94720398e-03f, 6.11368939e-02f, -7.84327164e-02f, -1.03941359e-01f, -3.29920352e-02f, 3.25775729e-03f, -1.71402525e-02f, -2.72173807e-02f, -1.38119265e-01f,
  -1.44365489e-01f, -4.64517847e-02f, -2.25898586e-02f, 1.53025920e-02f, 9.91074368e-02f, -7.02457950e-02f, -5.33164069e-02f, 2.38781329e-02f, -1.14484109e-01f, -3.17937471e-02f,
  -1.86386257e-02f, 1.08417183e-01f, 9.15819332e-02f, -6.42283112e-02f, -1.03408203e-01f, -9.77570042e-02f, -6.10962175e-02f, -3.34311812e-03f, -3.55191878e-03f, 9.32396203e-02f,
  5.08653596e-02f, 2.31883544e-02f, 2.34775301e-02f, 2.44817585e-02f, -8.72623697e-02f, 7.82730207e-02f, 6.33603111e-02f, -5.08247130e-02f, -2.06287764e-02f, -2.95154680e-03f,
  1.45352811e-01f, -1.68107338e-02f, 2.06102747e-02f, 2.02292223e-02f, -1.49887642e-02f, 2.09736824e-02f, 1.82454750e-01f, 6.46158457e-02f, 1.06913716e-01f, 1.59117058e-01f,
  2.30610117e-01f, -4.04423833e-01f, -3.99697989e-01f, -1.84592023e-01f, -1.96016267e-01f, -1.85334444e-01f, -3.32122117e-01f, 2.69627292e-02f, -4.16244119e-02f, -4.79261339e-01f,
  -1.96641147e-01f, 1.88353479e-01f, -1.32973092e-02f, 7.35979155e-02f, 2.13373929e-01f, -3.88014823e-01f, -4.13699567e-01f, -5.40831089e-02f, 4.31281209e-01f, 1.58876851e-01f,
  2.33220006e-03f, -8.45390186e-02f, 1.14900894e-01f, 6.88032210e-02f, -3.29222381e-01f, -3.80319916e-02f, -3.80268097e-01f, -1.42523363e-01f, -2.17553496e-01f, -4.39732462e-01f,
  -2.41763175e-01f, 1.36144403e-02f, 7.32778460e-02f, 1.89938396e-01f, -1.44976810e-01f, 2.05844175e-02f, 5.05313687e-02f, -1.84086606e-01f, -2.83562951e-02f, -4.01547812e-02f,
  -7.32924864e-02f, 1.52686045e-01f, 1.68246418e-01f, -2.24336255e-02f, -6.27916818e-03f, 1.30109474e-01f, 2.86771469e-02f, 6.88856244e-02f, 5.64538799e-02f, -1.74529657e-01f,
  -1.06359767e-02f, 4.00881022e-02f, 3.40648107e-02f, -6.92218915e-02f, 1.64291754e-01f, 5.87829426e-02f, -1.36929691e-01f, 8.38569552e-02f, -1.86511651e-02f, -3.67135495e-01f,
  -1.41348511e-01f, -5.62855862e-02f, -1.09137297e-01f, 6.01461418e-02f, -6.49839863e-02f, -9.54978019e-02f, -1.09924302e-02f, 3.14093903e-02f, 3.17992531e-02f, -1.26730660e-02f,
  -3.49981971e-02f, -4.90417294e-02f, 2.73333807e-02f, -5.92869148e-02f, -6.12061024e-02f, 6.75146729e-02f, -4.85492870e-02f, -1.29969358e-01f, -4.76378463e-02f, 7.98190478e-03f,
  2.82380003e-02f, 4.25576009e-02f, -5.71808107e-02f, 3.27047706e-02f, 5.72507444e-04f, 5.33635765e-02f, 1.45185962e-02f, 5.91037124e-02f, -2.52850633e-02f, 8.10638592e-02f,
  5.43953814e-02f, 2.43649423e-01f, -2.35392258e-01f, 9.97332335e-02f, -1.02630593e-01f, -7.93030113e-02f, -1.98086321e-01f, -1.70161743e-02f, -3.15997675e-02f, 2.63611935e-02f,
  8.94882008e-02f, -5.63286319e-02f, -3.42566185e-02f, -7.95044601e-02f, 6.54194271e-03f, -2.74933316e-02f, -3.45697366e-02f, -1.01546450e-02f, 7.16497824e-02f, -1.90767959e-01f,
  -1.04496174e-01f, 2.15857923e-02f, 1.51983947e-01f, -2.15598587e-02f, -8.64213780e-02f, 9.03762728e-02f, -1.36658713e-01f, -4.53287065e-02f, 1.40315384e-01f, -2.10993677e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 26)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 26;
const float L0_fan_Bp_bar_data[] = {
  3.74647498e-01f, 2.16676310e-01f, 1.73714772e-01f, 2.53179163e-01f, 3.23481858e-01f, 1.77960813e-01f, 1.26883134e-01f, 2.20946580e-01f, 2.36552462e-01f, 2.46012047e-01f,
  1.35041490e-01f, -2.76259303e-01f, 3.34047437e-01f, 7.18617439e-02f, 3.94961149e-01f, 2.77984947e-01f, 1.19144656e-01f, 3.62916961e-02f, -9.70521495e-02f, 1.69420049e-01f,
  3.45533609e-01f, 4.16081697e-01f, 1.04804799e-01f, -1.21221691e-01f, 3.61402124e-01f, 6.88577741e-02f
};

// L1_fan_Wp (Shape: 51 x 128)
const int L1_fan_Wp_rows = 51;
const int L1_fan_Wp_cols = 128;
const float L1_fan_Wp_data[] = {
  -3.91824208e-02f, -1.00572117e-01f, -1.66851521e-01f, 4.94610667e-02f, 8.62949640e-02f, 1.44888863e-01f, 2.49944981e-02f, -6.55456856e-02f, -1.45817210e-03f, 2.80556772e-02f,
  4.46587540e-02f, 2.64389124e-02f, 3.00821557e-04f, -9.24659446e-02f, 6.30453229e-02f, 5.65020405e-02f, -9.98539198e-03f, -4.33971696e-02f, 1.05893433e-01f, -1.46464840e-01f,
  3.32828052e-02f, -1.18407227e-01f, 2.44350657e-02f, -1.32804915e-01f, -7.44891092e-02f, -9.62000266e-02f, 8.04761723e-02f, -1.00558721e-01f, 9.16796327e-02f, 1.52180374e-01f,
  -1.40303895e-01f, -1.52801387e-02f, -9.32909641e-03f, 1.61280423e-01f, -6.26053736e-02f, 1.36207506e-01f, 9.83113721e-02f, -7.79827610e-02f, -1.47332028e-02f, 4.62017804e-02f,
  -2.75652893e-02f, 4.77594770e-02f, 8.03549141e-02f, 7.64307231e-02f, 1.47546297e-02f, 2.05356613e-01f, -8.71035382e-02f, 7.98999593e-02f, 4.88097891e-02f, 3.94039042e-02f,
  5.52962534e-02f, 8.42097849e-02f, -6.00999519e-02f, -3.91378067e-02f, -4.24629450e-02f, -5.10146916e-02f, -8.16674158e-02f, -1.02767674e-02f, -1.18054010e-01f, 1.76108479e-01f,
  2.18347907e-01f, -6.16786070e-02f, 4.26503047e-02f, 1.51241824e-01f, 1.11010976e-01f, -9.75295752e-02f, 3.62793282e-02f, -1.14762150e-01f, -6.13792725e-02f, -2.52446055e-01f,
  1.54749211e-02f, -3.13600451e-02f, 1.77793317e-02f, -8.82437378e-02f, -6.19504452e-02f, -1.89236784e-03f, -8.96674674e-03f, -1.49000496e-01f, -5.40836267e-02f, -9.16351005e-02f,
  5.75755946e-02f, 1.46541506e-01f, 5.40138111e-02f, -2.22334906e-01f, -1.01417691e-01f, -6.97926991e-03f, 1.48370668e-01f, -1.12016156e-01f, -1.17368475e-01f, -8.00093114e-02f,
  5.64431697e-02f, 2.56543583e-03f, 1.15687869e-01f, 5.21702645e-03f, 1.07451282e-01f, -9.90838781e-02f, -4.95501347e-02f, -5.72338514e-03f, 1.28928944e-01f, 3.80619429e-02f,
  2.49168761e-02f, 6.43463209e-02f, 2.41300315e-01f, 1.32976413e-01f, 6.98755321e-04f, 1.66678369e-01f, -6.76655695e-02f, -4.55214158e-02f, 1.26315966e-01f, -7.90252835e-02f,
  -9.75225791e-02f, -5.08972735e-04f, -8.82933438e-02f, -2.42813919e-02f, -3.42459291e-01f, 9.79939327e-02f, 1.44886047e-01f, -1.99267283e-01f, 2.06143335e-02f, -1.26832664e-01f,
  2.28383392e-02f, -2.01066490e-02f, 1.56707317e-02f, 2.23830268e-01f, 1.66182026e-01f, 3.41857783e-02f, -1.64760053e-01f, -1.28581151e-02f, 1.93878934e-01f, 5.93052767e-02f,
  -3.59905362e-02f, 3.09559051e-02f, -6.48315400e-02f, -1.02503583e-01f, 2.81062517e-02f, -4.80009727e-02f, 1.60345927e-01f, -2.32739300e-02f, 5.82767762e-02f, -8.62252116e-02f,
  3.84315699e-02f, 7.22129866e-02f, 3.58336866e-02f, -8.74027833e-02f, -6.84891716e-02f, 4.74428535e-02f, -1.11588463e-01f, 2.07404103e-02f, -7.37614036e-02f, 3.01077813e-02f,
  -1.76409781e-02f, -3.54574993e-02f, 1.20259654e-02f, 7.81019107e-02f, 1.53589696e-01f, 5.62176518e-02f, 1.01570047e-01f, 6.82724267e-02f, 1.42096296e-01f, 9.83642191e-02f,
  -9.51652154e-02f, 1.72612108e-02f, 1.11406453e-01f, 6.42047003e-02f, -1.31306410e-01f, -2.07335372e-02f, 1.70112140e-02f, 1.01043604e-01f, 2.33967276e-03f, 4.52377740e-03f,
  3.04177068e-02f, -9.89430621e-02f, -9.14475843e-02f, -4.46471758e-02f, 1.04998030e-01f, 5.06870933e-02f, -1.57571837e-01f, 1.07860461e-01f, -2.79785111e-03f, -6.59537166e-02f,
  8.73359218e-02f, 2.05524907e-01f, 1.97581425e-01f, 5.91179309e-03f, -7.21295103e-02f, -7.66418800e-02f, -5.20577766e-02f, -3.27503011e-02f, -1.14345491e-01f, -9.25638229e-02f,
  -2.70301290e-02f, 1.27808869e-01f, 2.99181584e-02f, -6.80658445e-02f, 4.44245823e-02f, -3.65652423e-03f, 7.75067955e-02f, 7.31410161e-02f, -1.32228779e-02f, 1.22279406e-01f,
  3.74017246e-02f, -7.55336210e-02f, 1.21891005e-02f, -3.45050357e-02f, -9.10956934e-02f, -6.46561980e-02f, 1.40073756e-02f, -4.22895327e-03f, -5.95107153e-02f, 1.06541619e-01f,
  -2.12827280e-01f, 1.09169580e-01f, 9.49860886e-02f, 7.05095977e-02f, 4.47590873e-02f, -1.18580773e-01f, 1.03360265e-01f, -2.91340165e-02f, -1.07321382e-01f, -1.19412668e-01f,
  -4.64912094e-02f, -1.75595656e-02f, -3.90583347e-03f, -2.93308347e-01f, 6.66637300e-03f, 3.02249081e-02f, -1.87360883e-01f, 3.15740593e-02f, 1.14296935e-01f, -7.97664821e-02f,
  1.09712817e-02f, -2.26621658e-01f, 8.08175057e-02f, -2.75831699e-01f, -2.42386505e-01f, 9.26552787e-02f, -3.58695239e-01f, -1.74923763e-01f, 2.43911579e-01f, 1.69412419e-01f,
  -1.27836466e-01f, 8.49365219e-02f, 1.15611948e-01f, 1.50258809e-01f, -2.18736440e-01f, 1.88635439e-01f, 4.26734379e-03f, 6.43888563e-02f, 8.05330798e-02f, -2.94274203e-02f,
  -1.61461637e-03f, -1.30779669e-01f, -6.90107420e-02f, 9.50195491e-02f, -1.18083447e-01f, 5.09151280e-01f, -8.06060210e-02f, 2.30997819e-02f, 5.74500635e-02f, -4.66734841e-02f,
  2.97457594e-02f, -1.02230392e-01f, -1.13326818e-01f, 4.86012548e-02f, -7.92729706e-02f, 1.14079215e-01f, 8.02582279e-02f, -5.78341410e-02f, -4.67350148e-02f, -3.51476148e-02f,
  2.24610642e-02f, -4.77410033e-02f, -2.66298652e-02f, 1.89047605e-02f, 1.81609675e-01f, -6.61908016e-02f, -4.59598377e-02f, -1.68170169e-01f, 1.69788897e-02f, -1.40014619e-01f,
  4.48714495e-02f, -1.29129574e-01f, -5.53342849e-02f, 1.55582070e-01f, -1.35056674e-01f, -2.44284458e-02f, 6.86091036e-02f, -7.11191669e-02f, -6.90956041e-02f, -2.91848667e-02f,
  -7.17871934e-02f, 1.32776108e-02f, 6.28520772e-02f, -8.76809657e-02f, 5.41952699e-02f, 1.06929027e-01f, 3.36639360e-02f, -8.03536400e-02f, -5.35517968e-02f, -1.59101766e-02f,
  -7.13810399e-02f, -2.04967372e-02f, -7.51630589e-02f, -1.75582524e-03f, 3.50159705e-02f, -3.51554118e-02f, -5.89282811e-03f, 5.84339760e-02f, -3.83359706e-03f, 5.26246689e-02f,
  8.60476345e-02f, 4.49725352e-02f, -6.93048313e-02f, 3.71235348e-02f, -6.05590269e-02f, -1.20934337e-01f, -7.77520565e-03f, 8.73998031e-02f, -5.09478860e-02f, -4.40462679e-02f,
  1.56920969e-01f, 1.05969064e-01f, 5.05611189e-02f, -7.73686469e-02f, -5.92677444e-02f, 8.79490674e-02f, 6.29936205e-03f, -1.63944960e-01f, 2.19138175e-01f, 6.16362505e-02f,
  1.68219537e-01f, -7.67174885e-02f, -4.89566661e-03f, -1.63891211e-01f, 7.67666623e-02f, 1.03603061e-02f, 6.93435594e-02f, -2.06250977e-02f, 7.50597194e-02f, -5.64825386e-02f,
  1.72360018e-02f, 2.89341491e-02f, 5.85484616e-02f, -3.56778018e-02f, -9.59914643e-03f, -8.96659270e-02f, 8.10088962e-02f, 1.08908892e-01f, -2.02984698e-02f, -9.74355731e-03f,
  4.74499390e-02f, -2.49865856e-02f, -1.25606075e-01f, -1.40448198e-01f, 9.36477929e-02f, 5.68450876e-02f, -2.74104148e-01f, -4.95976843e-02f, 1.24318540e-01f, 2.65882850e-01f,
  7.12320879e-02f, 2.70466596e-01f, 2.17096880e-02f, -1.76832646e-01f, 3.02489966e-01f, 6.87589776e-03f, 1.00238368e-01f, -6.58780755e-03f, -1.05359949e-01f, 1.21183254e-01f,
  -2.07447872e-01f, 1.09073393e-01f, -4.77309301e-02f, -1.63107365e-01f, -1.81530535e-01f, 9.81762558e-02f, -1.01918861e-01f, -3.93676981e-02f, 1.01534679e-04f, 3.35315019e-01f,
  -7.98416808e-02f, 3.05944979e-02f, -3.84042919e-01f, -1.25280499e-01f, 8.94492585e-03f, -7.28456676e-02f, 6.33720607e-02f, 5.94925806e-02f, -1.72660314e-02f, -1.82992786e-01f,
  5.33349365e-02f, 1.90297253e-02f, 1.68166146e-01f, 1.81316450e-01f, 6.55526817e-02f, 1.86673068e-02f, 7.70335123e-02f, -9.91070122e-02f, -1.81831568e-01f, 3.24640721e-02f,
  -9.18162093e-02f, 7.09735304e-02f, -6.69082329e-02f, 1.06306770e-03f, 1.17227986e-01f, -3.73725072e-02f, 9.31240767e-02f, 8.15771669e-02f, -3.44046541e-02f, -1.15102269e-01f,
  -2.25692373e-02f, -8.19063038e-02f, 4.81680892e-02f, 1.35754690e-01f, -1.56096341e-02f, 1.92550421e-01f, -3.68334241e-02f, 1.13133639e-01f, 1.09003391e-03f, 3.59630771e-02f,
  5.44350222e-02f, 1.28665462e-01f, -1.09876290e-01f, 9.45831537e-02f, 1.39015540e-01f, -6.06296510e-02f, -1.48462325e-01f, 1.96642205e-02f, 1.46764219e-02f, 1.65892555e-03f,
  -1.29605308e-01f, -7.30846301e-02f, -1.42865881e-01f, 7.92424157e-02f, -2.80808378e-02f, -1.26441821e-01f, 9.32052359e-02f, -1.15122415e-01f, 6.32059276e-02f, 2.31986985e-01f,
  -1.59598872e-01f, -1.72408402e-01f, 5.66131510e-02f, 8.02009180e-02f, -9.94350687e-02f, -8.35931897e-02f, 1.86622009e-01f, 6.67148754e-02f, -5.56549802e-02f, -1.28640339e-01f,
  1.66970059e-01f, 9.49180424e-02f, -4.93316539e-02f, 6.07493706e-02f, 7.66465589e-02f, 2.23446146e-01f, 3.35065695e-03f, -1.19018942e-01f, -1.85718555e-02f, -6.19359128e-02f,
  -1.03315182e-01f, 1.01897651e-02f, 6.70760497e-02f, 5.02062626e-02f, 1.71572883e-02f, -1.21135317e-01f, -2.93680523e-02f, -6.27242699e-02f, -1.19727336e-01f, 1.58659413e-01f,
  2.97320988e-02f, 1.41679272e-01f, 5.10280356e-02f, 1.87706292e-01f, 1.54903969e-02f, -1.20656028e-01f, -3.00566424e-02f, -3.65203945e-03f, -1.20824821e-01f, -9.80980694e-02f,
  -8.82309228e-02f, -1.25150710e-01f, 5.62544689e-02f, -6.06194371e-03f, 2.44114667e-01f, 1.97052024e-02f, -2.00274377e-03f, 3.04344326e-01f, -5.53412735e-02f, -2.61736929e-01f,
  -3.60179931e-01f, -5.68260066e-02f, -1.02408461e-01f, -4.88393940e-02f, 3.18404496e-01f, 1.27015971e-02f, 5.78436777e-02f, -1.57046825e-01f, 1.08757697e-01f, 2.30111517e-02f,
  1.04809459e-02f, 1.84773728e-02f, -1.16464466e-01f, 1.35554880e-01f, -1.25441670e-01f, -1.42070726e-01f, 2.34043419e-01f, 1.18949831e-01f, -4.64400053e-02f, -1.21391639e-02f,
  1.88117296e-01f, -1.41516730e-01f, 1.73338894e-02f, 9.92862880e-02f, -1.40535191e-01f, 7.90475011e-02f, 1.38074413e-01f, 4.81429100e-02f, 1.03654362e-01f, 8.06014240e-03f,
  -5.76472171e-02f, -8.93509306e-04f, 4.90709282e-02f, 3.33258808e-02f, 6.89710975e-02f, -6.22802414e-02f, 5.04934750e-02f, -7.75389001e-02f, 4.10785601e-02f, 2.68627256e-02f,
  -8.73322487e-02f, -9.22166407e-02f, 1.78300589e-03f, -1.85358688e-01f, 1.20593650e-04f, 5.48019409e-02f, -3.01840412e-03f, -1.47317408e-03f, 1.00118108e-02f, -1.61109626e-01f,
  1.78668529e-01f, -6.41823560e-02f, 5.59647381e-02f, -9.00952145e-03f, -7.19633698e-02f, -1.20569998e-02f, 9.35528502e-02f, 3.78295295e-02f, -2.76647676e-02f, 9.06223953e-02f,
  8.85659978e-02f, -1.15661293e-01f, 9.00495518e-03f, -1.02287613e-01f, -3.34264599e-02f, 5.76482564e-02f, 1.00847095e-01f, 4.47575673e-02f, -3.88331041e-02f, -1.33450136e-01f,
  -5.29317111e-02f, -1.22374762e-02f, -6.96361586e-02f, 9.64332148e-02f, 7.16934055e-02f, 2.39624754e-01f, 2.89347440e-01f, -3.55125149e-03f, -2.11346745e-01f, -2.04711601e-01f,
  1.53180892e-02f, 1.85699183e-02f, 8.77693594e-02f, -5.21732904e-02f, -7.83270877e-03f, -4.39931080e-02f, -4.96040732e-02f, -9.74186733e-02f, 1.60295721e-02f, 2.64082588e-02f,
  1.19010076e-01f, -2.45522428e-02f, 2.61375643e-02f, -4.14094701e-03f, -1.52950928e-01f, -1.08948641e-01f, -5.68056181e-02f, 4.92063491e-03f, -5.36328070e-02f, -1.39786482e-01f,
  -7.88321123e-02f, -3.39955948e-02f, -2.45953742e-02f, 1.31086156e-01f, -1.73011854e-01f, -1.84095308e-01f, 1.05383702e-01f, 6.55611008e-02f, -1.99099761e-02f, 8.64434838e-02f,
  3.96403857e-02f, -1.88081682e-01f, 9.03404951e-02f, -1.29154012e-01f, 1.83332637e-01f, -1.36974022e-01f, 5.38880564e-02f, -2.64867157e-01f, 6.01679422e-02f, -8.95211697e-02f,
  7.96528459e-02f, 1.31899685e-01f, 8.76755193e-02f, -9.89611074e-03f, 2.05400750e-01f, 8.53720605e-02f, 1.59019828e-01f, 1.88816756e-01f, -3.02526712e-01f, -8.87192599e-03f,
  2.81283874e-02f, -1.79617673e-01f, 3.06442946e-01f, 9.37097333e-03f, 2.11439724e-03f, -6.77442923e-02f, -9.77727845e-02f, 8.67769122e-02f, -2.62452215e-02f, 2.37289984e-02f,
  -1.03054345e-01f, -5.52294217e-02f, -2.31974735e-03f, -1.17597327e-01f, -6.29579723e-02f, 2.56249249e-01f, 1.28739038e-02f, 2.94168927e-02f, -1.90265730e-01f, 1.13351561e-01f,
  -1.92769654e-02f, 1.44253954e-01f, 6.57154024e-02f, -1.22040436e-01f, 1.81774661e-01f, 2.90447939e-02f, 5.52063920e-02f, 1.07911699e-01f, 1.19247429e-01f, 9.75223780e-02f,
  -1.33609390e-02f, 2.35372297e-02f, -9.65773463e-02f, -4.16638795e-03f, -2.32368279e-02f, 1.05428308e-01f, -7.55219683e-02f, -1.02184512e-01f, 5.75202517e-02f, 2.11630370e-02f,
  -6.36255518e-02f, 9.47681889e-02f, 5.42350151e-02f, 1.08539639e-02f, 1.16336539e-01f, -2.72734780e-02f, -1.45974718e-02f, 6.97392449e-02f, -2.32129358e-02f, -5.04397824e-02f,
  -2.00182721e-02f, 3.25098261e-02f, -1.17757268e-01f, 8.36422294e-03f, 6.24732673e-02f, -4.19152454e-02f, -9.38155055e-02f, -8.96365270e-02f, 7.61531899e-03f, 1.04916699e-01f,
  6.90612523e-03f, -1.07140057e-01f, 8.20996910e-02f, -5.08120917e-02f, 2.68044556e-03f, -8.96776095e-02f, 7.67534375e-02f, -6.64400682e-02f, 3.84665914e-02f, -2.95705758e-02f,
  -5.16648870e-04f, 3.26304361e-02f, -1.05824496e-03f, -2.92489350e-01f, 7.83870965e-02f, -6.83880374e-02f, 6.84819743e-02f, -1.46986209e-02f, 1.61252588e-01f, -1.39785960e-01f,
  1.47205129e-01f, 6.76288456e-02f, 1.00387730e-01f, -7.76215345e-02f, 7.86895156e-02f, 3.10206879e-02f, -4.86207269e-02f, -1.05952859e-01f, 1.72511593e-01f, 3.64130437e-02f,
  1.93983227e-01f, -1.89803615e-02f, 2.44401589e-01f, -2.71110032e-02f, 1.28996760e-01f, 1.41634271e-01f, 5.25932349e-02f, -2.22019367e-02f, 3.13691199e-02f, 4.35620286e-02f,
  7.46175498e-02f, -2.35393360e-01f, -1.02331657e-02f, -6.88402876e-02f, -1.92436706e-02f, 3.37997964e-03f, -1.05355404e-01f, 2.97896147e-01f, -7.34256953e-02f, -6.87437728e-02f,
  -6.81287125e-02f, 1.87111106e-02f, -4.95940000e-02f, -6.53713420e-02f, 5.24986535e-02f, 1.60521373e-01f, -9.92546305e-02f, -3.59132364e-02f, 2.31788710e-01f, 1.70759395e-01f,
  9.15948972e-02f, -5.90917766e-02f, -6.37702793e-02f, 3.86574626e-01f, 1.10787950e-01f, 3.64755206e-02f, -1.28621370e-01f, -1.56175718e-01f, 5.91578893e-02f, 1.77360862e-01f,
  2.99142033e-01f, 3.72291048e-04f, 1.52902186e-01f, 1.72362719e-02f, 4.05093580e-02f, -3.02514974e-02f, 1.51150808e-01f, 5.93019575e-02f, -2.30440587e-01f, 2.35282220e-02f,
  -1.32277265e-01f, 3.39728035e-02f, 6.54750243e-02f, -2.36744620e-02f, -1.31951123e-01f, -2.41905637e-02f, 1.53136745e-01f, -3.42952222e-01f, -5.42514771e-02f, -7.29109161e-03f,
  1.06667772e-01f, -3.80524690e-03f, -5.29611157e-03f, -8.62683132e-02f, 2.30069719e-02f, -9.53090936e-02f, -3.69917601e-02f, -4.01098654e-02f, 1.51238352e-01f, -9.85342357e-03f,
  -2.53603328e-02f, -3.67355570e-02f, -8.75858217e-02f, 1.88799128e-01f, -7.55512994e-03f, -4.81960969e-03f, 1.12767168e-03f, 1.74673423e-01f, 1.14988219e-02f, -2.86149681e-02f,
  5.69447838e-02f, 7.28694052e-02f, -1.58329513e-02f, -1.15593456e-01f, 1.47755966e-01f, 3.64451185e-02f, -3.71018685e-02f, -1.16252359e-02f, -7.41599947e-02f, 4.47542109e-02f,
  8.09788555e-02f, -1.40254833e-02f, 1.13520801e-01f, -7.71630630e-02f, 5.82847185e-03f, 5.16741164e-02f, -5.73912170e-03f, 1.01294510e-01f, 1.69708356e-01f, 6.68279734e-03f,
  6.44382089e-02f, 4.06609923e-02f, -1.68176144e-02f, -9.28383842e-02f, -5.79001270e-02f, 9.13171284e-03f, -1.68118164e-01f, 1.15694664e-02f, 7.61987865e-02f, -9.41225514e-02f,
  1.35345116e-01f, -5.06942570e-02f, -1.41889006e-01f, 2.13595517e-02f, -9.21674222e-02f, -2.36431342e-02f, -1.72894865e-01f, -4.73647527e-02f, 1.91043820e-02f, -8.28149170e-02f,
  -4.29478416e-04f, -3.33783887e-02f, -6.67661130e-02f, -5.24694920e-02f, -1.37834117e-01f, 1.03057519e-01f, -4.73375320e-02f, -6.80455044e-02f, -1.22237414e-01f, 1.45167634e-01f,
  -1.21742636e-01f, -2.73467973e-02f, -8.74460489e-02f, 1.19322434e-01f, -4.28117886e-02f, 8.99667665e-02f, 3.15152183e-02f, 4.13876846e-02f, -7.54991919e-02f, -1.65387243e-02f,
  7.27571966e-03f, -1.34556785e-01f, -2.15896234e-01f, -4.64946777e-03f, -2.88216192e-02f, 1.95893869e-01f, -2.73357369e-02f, 2.93190479e-02f, -1.75245963e-02f, -8.54032487e-02f,
  -1.50690019e-01f, -1.78291887e-01f, -1.09228026e-02f, -6.47871792e-02f, 8.41640756e-02f, 6.52630851e-02f, -5.94148189e-02f, 5.26733920e-02f, -3.63130830e-02f, 3.20398062e-02f,
  3.59483510e-02f, -1.48023784e-01f, 7.08437040e-02f, -5.85154966e-02f, 5.01008593e-02f, 1.72291741e-01f, -2.58297324e-01f, -1.38346061e-01f, 7.26464763e-02f, 1.50326923e-01f,
  4.82222773e-02f, 1.09444052e-01f, -3.78100462e-02f, 2.44520110e-04f, 1.81422438e-02f, 9.99588799e-03f, -2.33239904e-01f, -1.72519654e-01f, 3.47553045e-02f, 1.28877923e-01f,
  -2.02359647e-01f, 1.31013885e-01f, 8.56459737e-02f, -1.74641535e-02f, 3.06010060e-02f, -3.05903614e-01f, -4.68432605e-02f, -1.72790468e-01f, 1.55840311e-02f, 3.84212919e-02f,
  2.33034994e-02f, 4.29211296e-02f, -7.79027343e-02f, -1.01558454e-02f, -4.37717773e-02f, -1.70587316e-01f, -1.69883892e-02f, -1.16351675e-02f, -8.17001611e-02f, 4.93446216e-02f,
  6.02014326e-02f, -1.96137264e-01f, 3.70321423e-02f, -5.12884706e-02f, 1.24413379e-01f, 5.93477301e-02f, -1.42003200e-03f, -3.86842377e-02f, -2.38630310e-01f, 2.13735834e-01f,
  9.15130377e-02f, 2.82573178e-02f, -5.27460575e-02f, -7.39223929e-03f, 9.87807848e-03f, -6.66985586e-02f, -4.70783263e-02f, -4.11206745e-02f, 5.26798740e-02f, -1.94476172e-01f,
  3.87617573e-02f, -8.63835290e-02f, 6.74173608e-02f, -4.65043187e-02f, 6.29602671e-02f, 4.12235223e-02f, -1.00879654e-01f, -3.71395089e-02f, 6.48681819e-02f, 6.40144423e-02f,
  2.48282142e-02f, 3.49340215e-02f, -5.62078021e-02f, 2.66748965e-02f, 1.25381067e-01f, -9.45698544e-02f, 1.32555872e-01f, 8.77063498e-02f, 2.84943194e-03f, 1.14407040e-01f,
  1.02417707e-01f, -9.33170132e-03f, 1.16745926e-01f, 1.58835903e-01f, 1.96165666e-01f, 1.73421159e-01f, 1.83066607e-01f, 1.23809129e-01f, -2.42451504e-01f, -2.17268214e-01f,
  -4.72830795e-02f, 6.85646534e-02f, 1.05256066e-02f, 4.13170755e-02f, -8.12428072e-03f, -1.08729988e-01f, 1.17228683e-02f, 1.60690859e-01f, 8.83184001e-02f, 3.37936096e-02f,
  2.70765200e-02f, 6.57275543e-02f, 1.99400987e-02f, 1.06367312e-01f, -1.03555754e-01f, 4.53205127e-03f, 2.96029132e-02f, -3.30188759e-02f, 9.01081264e-02f, 4.15024422e-02f,
  5.12967864e-03f, 6.68854415e-02f, -5.85836023e-02f, -6.27471432e-02f, 2.61441413e-02f, 6.76194802e-02f, 2.72610690e-02f, 8.40606689e-02f, 5.16582131e-02f, 4.44388977e-04f,
  3.21565866e-02f, 2.29004413e-01f, -1.67452574e-01f, -5.72923012e-02f, -3.10214460e-02f, -3.16691846e-01f, -9.45125371e-02f, -5.34494556e-02f, -7.02708215e-02f, -1.14450201e-01f,
  5.41232200e-03f, 7.23340735e-02f, 2.11103961e-01f, 8.91818553e-02f, 1.00823388e-01f, 2.90493499e-02f, -3.05675596e-01f, -2.61562504e-02f, 1.17860563e-01f, -7.65831470e-02f,
  7.16509670e-02f, -4.49614227e-02f, 2.60844268e-02f, 4.45625968e-02f, 1.85705334e-01f, -5.02807610e-02f, -5.70584796e-02f, 6.10610656e-02f, -2.69879758e-01f, -2.75027066e-01f,
  4.78653945e-02f, -6.61870316e-02f, -2.00817268e-02f, 1.20096408e-01f, 7.83105642e-02f, -8.70088562e-02f, -4.84901331e-02f, -8.58673081e-02f, -1.44027397e-01f, -1.56230880e-02f,
  -6.40994823e-03f, 8.00603554e-02f, -6.96589947e-02f, -4.34404984e-02f, 6.33191131e-03f, 1.92837510e-02f, -7.56586343e-02f, 9.99668762e-02f, 1.59903362e-01f, -6.18398041e-02f,
  -3.18507031e-02f, 1.02759257e-03f, 6.31400645e-02f, -1.50848076e-01f, 1.04842722e-01f, -4.76697944e-02f, -3.63780223e-02f, 7.52504319e-02f, 4.82312851e-02f, 1.49747152e-02f,
  3.15414555e-02f, -1.16845958e-01f, 2.52999309e-02f, -5.94725423e-02f, -8.71177316e-02f, -9.39056799e-02f, 1.71670988e-01f, -8.86412784e-02f, -2.98338775e-02f, 5.87545447e-02f,
  1.82981510e-02f, -1.86791625e-02f, -9.61016491e-02f, -2.70251259e-02f, -9.64791253e-02f, -8.77311975e-02f, 1.53536089e-02f, -5.38305007e-02f, 8.87493640e-02f, -1.48337051e-01f,
  -1.13846861e-01f, 6.56229556e-02f, 4.14313413e-02f, -7.26473629e-02f, -1.10773809e-01f, 5.48734926e-02f, 1.43607289e-01f, 1.86122358e-01f, 2.27932259e-02f, -6.11241907e-02f,
  6.62968308e-02f, 5.82187949e-03f, -4.74147126e-02f, 1.63976744e-01f, -1.58859879e-01f, 1.28351673e-01f, -2.11389642e-02f, 7.19739422e-02f, -9.14770737e-02f, -1.01449952e-01f,
  1.22036353e-01f, 1.35723008e-02f, -1.04498245e-01f, -3.92634459e-02f, -2.17092142e-01f, -6.69187456e-02f, -1.08135296e-02f, 8.09278190e-02f, 7.13964328e-02f, 9.62997302e-02f,
  1.95269197e-01f, 9.17714015e-02f, -1.11048430e-01f, -5.24407215e-02f, 1.03882231e-01f, -1.23535678e-01f, 1.65116325e-01f, 8.75876918e-02f, -1.37856692e-01f, -3.59168835e-03f,
  7.28721619e-02f, -1.01231188e-01f, 2.17141397e-02f, 1.67996332e-01f, -1.45641893e-01f, 1.28682017e-01f, -3.01094763e-02f, 8.19396749e-02f, -2.45074667e-02f, 1.24365531e-01f,
  -7.14396536e-02f, 6.93733096e-02f, 1.40109975e-02f, -1.34863344e-03f, -4.85796928e-02f, -5.46624810e-02f, -2.14993149e-01f, -3.30879897e-01f, -1.23261735e-01f, -3.68741639e-02f,
  2.60556817e-01f, 1.31217167e-01f, 2.91615780e-02f, 1.07887611e-01f, -2.65709460e-01f, 2.02897917e-02f, 5.89869395e-02f, 3.64872925e-02f, 1.16272181e-01f, 6.52909949e-02f,
  -3.10123086e-01f, -6.62056133e-02f, 1.75407425e-01f, 9.76094231e-02f, 1.07013546e-01f, -3.60715687e-02f, 1.62891429e-02f, -2.18991160e-01f, 1.70297697e-01f, -1.16021574e-01f,
  -5.78848831e-02f, 3.79991263e-01f, -1.03026100e-01f, 2.01881025e-02f, -1.50229111e-01f, -8.12786371e-02f, -1.22415788e-01f, -8.27823728e-02f, -5.45770824e-02f, 1.01716466e-01f,
  -1.48433998e-01f, -1.58416778e-01f, -1.39260128e-01f, 9.82985646e-02f, -1.03380702e-01f, 4.05713357e-02f, -9.29151848e-02f, 2.75032997e-01f, 3.93023677e-02f, -1.39948145e-01f,
  -7.93982297e-02f, 1.33887157e-01f, -1.65032417e-01f, -1.06310599e-01f, -6.79698773e-03f, -1.22599214e-01f, -3.50877806e-03f, 1.33103654e-01f, 5.01083471e-02f, -1.08128041e-01f,
  -5.52385673e-02f, 1.65203989e-01f, 1.29751191e-01f, 6.10667542e-02f, 1.19227981e-02f, -8.25892687e-02f, -1.44022545e-02f, -7.80880228e-02f, -7.08355159e-02f, 2.56886594e-02f,
  2.43763458e-02f, 7.10228970e-03f, 1.73259586e-01f, 7.73406923e-02f, -1.08964890e-01f, -4.48128656e-02f, -1.83707699e-02f, -2.17091158e-01f, -6.61996603e-02f, -9.38230306e-02f,
  -7.17602149e-02f, -9.02744532e-02f, -7.71304220e-02f, 1.14111669e-01f, 8.95659551e-02f, -2.01402321e-01f, 3.34513515e-01f, -6.95158616e-02f, -1.02223717e-01f, -1.00933881e-02f,
  -9.52790082e-02f, -2.11054564e-01f, -1.66499745e-02f, 6.64681867e-02f, -3.52525152e-02f, 1.12799937e-02f, 6.50201514e-02f, 1.55475110e-01f, -1.08371422e-01f, -8.19864869e-02f,
  -6.06206544e-02f, -6.47736266e-02f, 2.29943931e-01f, -7.13166520e-02f, 1.00163452e-01f, 1.68097556e-01f, 2.74014194e-02f, -1.04157347e-03f, -5.23221381e-02f, -1.24405056e-01f,
  4.19414863e-02f, -9.34521630e-02f, 3.39445397e-02f, -9.55189615e-02f, 1.69128850e-01f, 1.17751760e-02f, -4.79809195e-02f, -1.37636349e-01f, 1.71774644e-02f, 1.66497335e-01f,
  -6.53195903e-02f, 5.22735044e-02f, 3.26348916e-02f, 2.98003089e-02f, 1.03434518e-01f, 4.89679612e-02f, 5.97813725e-02f, -6.91829547e-02f, -8.90635848e-02f, -2.04945132e-01f,
  9.09579396e-02f, 1.99871324e-02f, 8.16573277e-02f, 6.70685992e-02f, -9.64958370e-02f, -5.59130125e-02f, -3.70810814e-02f, -7.15063810e-02f, -9.02594030e-02f, -1.73330996e-02f,
  4.19581793e-02f, 7.69084096e-02f, 1.34364977e-01f, -2.75757425e-02f, -1.61262287e-03f, 2.13253796e-01f, 9.63188782e-02f, 6.44230172e-02f, -1.41386598e-01f, -2.00174689e-01f,
  -1.08276799e-01f, 2.86219716e-01f, 1.29699931e-01f, 8.44052434e-02f, 6.56049773e-02f, 2.14046746e-01f, 6.49226457e-02f, 1.45824462e-01f, 7.35158771e-02f, -8.00147727e-02f,
  1.22383632e-01f, -1.00295126e-01f, 9.82820466e-02f, 2.77505778e-02f, -2.45581284e-01f, 5.69110289e-02f, -6.45790016e-03f, 5.42863160e-02f, 9.85096544e-02f, 8.76995251e-02f,
  -6.17798716e-02f, 1.74764078e-02f, 1.33799789e-02f, 1.37570068e-01f, -9.40882564e-02f, 1.24931512e-02f, -7.19437003e-03f, 9.09651350e-03f, 5.69149218e-02f, 4.08200882e-02f,
  -2.25633085e-02f, 1.06596932e-01f, 1.83733385e-02f, 5.65498658e-02f, -4.29084823e-02f, -9.65522975e-02f, -5.14741167e-02f, 1.09527037e-01f, 1.13305002e-02f, -2.81186942e-02f,
  3.27431820e-02f, -4.69794273e-02f, 7.02132732e-02f, 1.12935202e-02f, 1.06105156e-01f, -1.46855693e-02f, -1.03347719e-01f, -1.43322840e-01f, 7.50830173e-02f, 4.61319648e-03f,
  -1.52475946e-02f, 7.09042028e-02f, 2.72654626e-03f, -3.22203115e-02f, 3.02824080e-02f, 3.97721492e-02f, -4.34521735e-02f, 8.67852122e-02f, 1.01757333e-01f, -5.05467616e-02f,
  8.49702284e-02f, -1.01016209e-01f, -6.11771643e-02f, -1.54555157e-01f, -2.47327581e-01f, 6.73427880e-02f, 7.82519504e-02f, 9.15811285e-02f, 1.16092317e-01f, 9.74948257e-02f,
  1.46694809e-01f, 1.01255365e-01f, -1.54036283e-01f, 5.97897917e-02f, 1.04761263e-02f, 5.44813983e-02f, 8.79178420e-02f, -3.59922014e-02f, 6.92894533e-02f, 4.69163135e-02f,
  8.65924880e-02f, 1.41697586e-01f, -3.95473279e-02f, 1.13571296e-02f, 8.99421349e-02f, 8.88964906e-02f, 3.36234346e-02f, 1.92661256e-01f, 1.25179980e-02f, 2.04101399e-01f,
  -1.40555762e-02f, -4.01135460e-02f, 8.43050610e-03f, 1.19021550e-01f, 1.58557832e-01f, 1.18251242e-01f, -9.67450161e-03f, 4.13066074e-02f, 4.59855869e-02f, 5.48787862e-02f,
  -1.72109589e-01f, 4.70957300e-03f, -3.44134569e-02f, 1.68088987e-01f, -1.72657564e-01f, 1.02087840e-01f, 3.73871848e-02f, 4.25561108e-02f, -1.77027602e-02f, -5.84352389e-02f,
  1.90349109e-02f, 7.89035037e-02f, -3.02784711e-01f, 1.19769402e-01f, -6.62302375e-02f, -1.69985309e-01f, 1.27585027e-02f, 4.17045364e-03f, -1.93115890e-01f, 4.63203676e-02f,
  -9.17669982e-02f, 3.02188583e-02f, 1.36874855e-01f, 1.84903480e-02f, 1.67562574e-01f, -1.09554872e-01f, 2.08959594e-01f, 2.19119489e-01f, -7.04583973e-02f, -2.46963352e-01f,
  -3.40734757e-02f, 1.50568187e-01f, -1.24875061e-01f, -3.59867334e-01f, 4.92527820e-02f, 1.02032267e-01f, 2.67300785e-01f, -1.84895456e-01f, -5.69783011e-03f, -7.74408430e-02f,
  3.33801215e-03f, 9.91466194e-02f, -8.69168937e-02f, 2.02599302e-01f, -8.57395753e-02f, -8.88581425e-02f, -5.99663556e-02f, 8.55150297e-02f, 1.29168794e-01f, -1.01259805e-01f,
  -1.43639697e-03f, -5.31483069e-02f, -1.34624373e-02f, 2.75533870e-02f, -5.31681143e-02f, 6.59824312e-02f, 5.72653674e-02f, -1.55488644e-02f, -1.40580878e-01f, -1.69425949e-01f,
  6.94657341e-02f, 7.53505751e-02f, -1.14085441e-02f, -1.23924864e-02f, 5.11342473e-02f, -8.90839659e-03f, 3.82470675e-02f, -1.12066371e-02f, -4.20469716e-02f, 9.12819803e-03f,
  1.02329269e-01f, -7.58611783e-02f, 1.35125056e-01f, -1.95148669e-03f, 1.06248796e-01f, 4.60547619e-02f, 8.69996771e-02f, -5.28714657e-02f, 7.22938552e-02f, -9.41701829e-02f,
  -2.00107709e-01f, -1.18759736e-01f, 1.08026877e-01f, 1.73275024e-01f, 3.37455571e-02f, 2.70529538e-02f, -9.97574404e-02f, -4.70715798e-02f, 4.14223596e-02f, 2.42523011e-02f,
  1.79680526e-01f, 9.45946127e-02f, 2.02702582e-01f, -1.34930000e-01f, -8.50481689e-02f, 1.64147431e-03f, -5.56479320e-02f, 1.20343678e-01f, -1.86740682e-01f, 5.15954047e-02f,
  8.62512551e-03f, -6.67998940e-02f, 9.99514852e-03f, -1.15852743e-01f, 3.49489823e-02f, 1.27165169e-01f, 8.61463323e-02f, -6.63282275e-02f, -1.30113326e-02f, -6.27394244e-02f,
  -2.21442189e-02f, 1.01517454e-01f, -6.53619319e-02f, -1.40570626e-02f, -4.91886474e-02f, 1.12738013e-02f, -1.35251728e-03f, 8.17319006e-02f, 1.08377457e-01f, 1.12875469e-01f,
  -2.01884061e-01f, -1.92490444e-02f, 2.57120258e-03f, 5.75830825e-02f, 7.65113309e-02f, -2.58627325e-01f, 1.45103157e-01f, 8.70059431e-02f, 2.70970520e-02f, -1.09367900e-01f,
  4.00729701e-02f, 8.02804455e-02f, 7.10856393e-02f, -8.72974917e-02f, -7.98123181e-02f, 6.41461536e-02f, 5.20104095e-02f, -1.43340275e-01f, 2.81591201e-03f, -1.09180674e-01f,
  -6.70564547e-02f, 3.12455408e-02f, -2.50668347e-01f, -8.35289806e-02f, -1.61842685e-02f, 2.80884117e-01f, -2.77062003e-02f, -1.48344412e-01f, -1.02361783e-01f, 1.35946855e-01f,
  -1.81537315e-01f, 4.16907668e-02f, 5.26773818e-02f, 1.17323443e-01f, -3.22276264e-01f, 6.24063015e-02f, 5.53816035e-02f, 3.99525687e-02f, 1.60814375e-02f, 1.35315089e-02f,
  1.48304209e-01f, 1.25032306e-01f, 2.34938934e-02f, 8.61118957e-02f, -1.07400201e-01f, 3.89776230e-01f, 1.87706593e-02f, -1.55335125e-02f, -4.08093119e-03f, -8.44454095e-02f,
  1.38182063e-02f, -6.24879263e-03f, -2.36418862e-02f, 8.84215236e-02f, -2.91053299e-02f, 8.31197649e-02f, -6.15264699e-02f, 4.27743904e-02f, -2.86757741e-02f, 6.64366931e-02f,
  -7.82217905e-02f, 2.03183651e-01f, 8.21672082e-02f, -6.00890489e-03f, 7.17557445e-02f, 1.26173988e-01f, -9.13711190e-02f, -2.60061212e-02f, 1.52593562e-02f, -2.32130829e-02f,
  1.84200242e-01f, -2.50572860e-02f, 1.02157436e-01f, -1.36926360e-02f, -5.14824204e-02f, -3.90633158e-02f, 5.70803061e-02f, 1.11350589e-01f, 4.69989367e-02f, 5.90190180e-02f,
  -5.02751544e-02f, 1.11303836e-01f, -1.05570078e-01f, 8.32024217e-02f, 1.08017884e-01f, -2.05991119e-02f, -3.76844575e-04f, -3.35504264e-02f, 1.55726910e-01f, 6.76293597e-02f,
  1.20616846e-01f, -6.71081841e-02f, -1.22439161e-01f, 2.55785853e-01f, 2.89634559e-02f, 6.03422662e-03f, 1.45613384e-02f, -1.46953380e-02f, 4.35106456e-02f, -2.43175700e-01f,
  4.00544405e-02f, -2.37169489e-02f, 3.59732844e-03f, 3.02693024e-02f, 6.04807064e-02f, 1.41924113e-01f, 9.05609801e-02f, 1.42296195e-01f, 4.88741510e-02f, 5.63574582e-03f,
  1.35398045e-01f, -1.96038961e-01f, 8.28650519e-02f, 1.60836894e-02f, 4.09879722e-02f, -1.54379429e-02f, 2.05024213e-01f, -8.22941065e-02f, -3.64087671e-02f, 1.44784316e-01f,
  -2.63866484e-02f, 4.64177467e-02f, -2.90277377e-02f, -4.10406031e-02f, 3.86033691e-02f, 5.03833555e-02f, 1.26497045e-01f, -1.37953892e-01f, 1.93670973e-01f, -1.58788085e-01f,
  -1.48839876e-01f, 1.72647759e-02f, 1.03362389e-01f, 8.34587738e-02f, -1.28307700e-01f, 1.96589351e-01f, -4.05662619e-02f, 3.30847763e-02f, 6.61418587e-02f, 1.51462898e-01f,
  -9.03444886e-02f, 2.55207837e-01f, -1.18742302e-01f, -2.37110496e-01f, 1.50842398e-01f, 1.42734982e-02f, -4.11825348e-03f, -8.01921915e-03f, -1.15497179e-01f, 4.20208663e-01f,
  -1.10572949e-01f, -7.44421221e-03f, 1.37665525e-01f, -1.17268533e-01f, 1.69164762e-01f, 2.20634714e-02f, -3.20188585e-03f, -8.02965537e-02f, 2.84367055e-01f, 3.98658700e-02f,
  2.27378488e-01f, -1.49336709e-02f, 2.54112631e-01f, -2.76612900e-02f, -9.28409323e-02f, 2.69522905e-01f, -2.20007030e-03f, -3.59487534e-02f, 9.56513509e-02f, -2.06659168e-01f,
  4.93447557e-02f, -4.52844091e-02f, 2.77676344e-01f, -1.52461484e-01f, -3.17008570e-02f, -2.21248399e-02f, -5.65470308e-02f, 4.96575050e-02f, -9.37075466e-02f, 5.20517416e-02f,
  -1.71908401e-02f, -2.02690139e-02f, -8.73431265e-02f, -6.74892217e-02f, -9.44959149e-02f, 8.24754238e-02f, -5.47949970e-02f, -3.32060829e-02f, 1.54750161e-02f, -6.64784433e-03f,
  -2.67544556e-02f, -6.80307373e-02f, 1.58457644e-02f, 1.60940699e-02f, 1.88972745e-02f, -4.84588481e-02f, -1.49523169e-01f, 3.07881590e-02f, 4.58428524e-02f, 1.27421945e-01f,
  -1.01446636e-01f, 3.76997367e-02f, -1.59343570e-01f, -7.69115835e-02f, 8.25830996e-02f, -6.25646487e-02f, -2.94889398e-02f, -1.11912183e-01f, -2.35327240e-03f, -1.92065805e-01f,
  -1.00047283e-01f, 2.72904299e-02f, -9.09778923e-02f, -7.68603832e-02f, 6.01290539e-02f, 9.90015119e-02f, -3.90007980e-02f, 1.30854752e-02f, -8.29996765e-02f, -2.01340169e-02f,
  -1.51103195e-02f, -2.78653894e-02f, 5.20162173e-02f, -6.33015577e-03f, 2.73330323e-03f, -1.99449155e-02f, 6.16330430e-02f, -1.49771059e-02f, -2.13611890e-02f, -3.16558518e-02f,
  8.64784271e-02f, 4.32408676e-02f, 2.73867827e-02f, 1.65009852e-02f, -6.92352727e-02f, 1.60793290e-01f, -1.51796967e-01f, -1.23099975e-01f, -8.83828104e-02f, 5.75226098e-02f,
  1.48535371e-01f, -4.42239828e-02f, 9.80322137e-02f, 4.69574779e-02f, -8.20519999e-02f, 2.26216223e-02f, 8.53113458e-02f, 9.33849812e-02f, 8.41695815e-02f, 1.05427019e-01f,
  -7.47821927e-02f, 1.26334816e-01f, -1.09103233e-01f, -4.09639478e-02f, -7.44105503e-02f, 7.19303545e-03f, 7.23480359e-02f, 2.27824435e-01f, -6.06632456e-02f, -3.96288000e-02f,
  1.36797735e-02f, -1.39367059e-01f, 7.72600025e-02f, -2.52574347e-02f, -8.38096812e-02f, 1.13774568e-01f, 6.08035624e-02f, -5.63222095e-02f, -5.19327298e-02f, 1.15753584e-01f,
  -7.87406191e-02f, 1.72150712e-02f, -2.18952179e-01f, -1.21924140e-01f, -3.82101275e-02f, 4.58071046e-02f, -1.61431700e-01f, -6.00541383e-02f, -1.40125290e-01f, 1.15814403e-01f,
  2.75509179e-01f, 2.56355312e-02f, 3.86151448e-02f, 1.17033832e-01f, -2.40034297e-01f, -5.93123101e-02f, 1.63674116e-01f, -8.07575211e-02f, 1.88781887e-01f, -5.60153015e-02f,
  -7.49175251e-02f, 6.59437329e-02f, 6.13641925e-02f, 7.90447369e-02f, -6.39703050e-02f, -1.29078060e-01f, 2.13549938e-02f, -1.69758916e-01f, -1.37021258e-01f, 6.47038035e-03f,
  1.09585389e-01f, -4.52076048e-02f, -1.00451551e-01f, -1.31682232e-01f, 1.57114625e-01f, -1.82316199e-01f, 1.06882630e-02f, 4.74228971e-02f, 1.05044863e-03f, -2.63874028e-02f,
  8.28873590e-02f, 1.21804036e-01f, -4.82161567e-02f, 5.00736933e-04f, 6.88118264e-02f, 1.22526335e-02f, 1.05397990e-02f, 1.89434081e-01f, 8.47766921e-02f, 1.51476353e-01f,
  -6.30470812e-02f, 1.59071386e-01f, 5.08760400e-02f, 2.89303418e-02f, -8.92911777e-02f, -5.16728014e-02f, 9.58435610e-02f, -3.76037881e-02f, 1.44190602e-02f, -2.11468954e-02f,
  -2.34556664e-02f, 2.80941767e-03f, 6.02987185e-02f, -8.15326795e-02f, 1.04623742e-01f, -1.52129531e-01f, -5.03149629e-02f, 1.95600152e-01f, 9.91911292e-02f, -4.74715941e-02f,
  4.30723140e-03f, 6.21647052e-02f, -2.83602681e-02f, -2.37752516e-02f, 5.10146357e-02f, 4.22083996e-02f, -6.90656081e-02f, -1.46070691e-02f, -2.94201225e-02f, 1.10032871e-01f,
  -1.55350324e-02f, -1.07688438e-02f, -6.87334985e-02f, -5.05155474e-02f, 3.11293080e-02f, -1.90674663e-01f, -1.63616970e-01f, -9.19597074e-02f, 2.39839450e-01f, 2.73329578e-02f,
  2.02656552e-01f, -1.85753740e-02f, 1.45421311e-01f, 2.05685332e-01f, 7.13492036e-02f, -2.14579567e-01f, -1.80026721e-02f, -1.09889850e-01f, 1.42883584e-01f, -3.35395336e-02f,
  1.24970451e-01f, -1.67045128e-02f, -3.55503447e-02f, -1.85183838e-01f, -8.03039409e-03f, 1.71030357e-01f, 1.00223228e-01f, 1.06096398e-02f, -1.04752742e-01f, 4.70105410e-02f,
  6.42767996e-02f, -9.41603109e-02f, 2.03640591e-02f, -4.94698919e-02f, 3.69573124e-02f, 3.03678513e-02f, 1.30195737e-01f, 1.95948511e-01f, -1.02188766e-01f, -7.05657303e-02f,
  -2.58298106e-02f, 1.11348979e-01f, 5.75151816e-02f, 1.60497770e-01f, 8.73962231e-03f, -1.33131862e-01f, -3.64929773e-02f, 3.01088423e-01f, 5.67986853e-02f, -2.84912884e-01f,
  -8.31846669e-02f, 1.25511140e-01f, -1.52889311e-01f, 5.05223088e-02f, -1.55707985e-01f, 4.29124534e-02f, 2.04430651e-02f, 1.07111767e-01f, 2.50623852e-01f, 4.83906269e-02f,
  2.61344202e-02f, 2.36211061e-01f, -2.24818736e-01f, -7.39748478e-02f, -9.31914598e-02f, 1.37469098e-01f, 3.56104851e-01f, -6.27632765e-03f, 2.33439967e-01f, 5.03373183e-02f,
  5.31172240e-03f, 1.56191856e-01f, 8.80318787e-03f, 5.91218770e-02f, -7.34663904e-02f, 3.81168947e-02f, 2.57907789e-02f, 7.97295421e-02f, 2.89276451e-01f, -4.08108860e-01f,
  -8.91267061e-02f, 6.77814521e-03f, 2.10713893e-02f, 1.25447512e-01f, -7.56679773e-02f, -9.55096167e-03f, -4.73525412e-02f, 3.58313583e-02f, 1.37237981e-01f, -1.31441429e-01f,
  -1.00885909e-02f, 5.80370948e-02f, 5.30096591e-02f, 1.60470381e-01f, -7.14333057e-02f, 1.49819478e-01f, 8.34288895e-02f, 5.86689226e-02f, 8.42991397e-02f, 1.05843343e-01f,
  1.03363737e-01f, 9.53468606e-02f, -6.34678006e-02f, 5.09966277e-02f, -9.06801596e-02f, 1.13042951e-01f, 4.84988503e-02f, 1.05007373e-01f, -9.50027630e-02f, 1.74318358e-01f,
  1.55734256e-01f, 1.67278856e-01f, 6.20142855e-02f, -2.95972582e-02f, 6.51161298e-02f, 5.08604124e-02f, -4.80905734e-02f, -5.71307652e-02f, 1.89763567e-04f, -2.09733862e-02f,
  9.78241712e-02f, 8.12872499e-02f, 1.93274826e-01f, 5.92024736e-02f, 1.52823836e-01f, -9.40765813e-03f, -5.01942411e-02f, 2.97293991e-01f, 1.68169811e-01f, 1.43633604e-01f,
  1.19728602e-01f, 1.36811018e-01f, -1.23399206e-01f, -2.98739187e-02f, 4.53885179e-03f, -2.05132905e-02f, 5.99263236e-02f, -5.82415871e-02f, -3.33656147e-02f, 3.04491259e-02f,
  1.30787805e-01f, -4.15722355e-02f, 4.13311422e-02f, -8.94151814e-03f, -1.44541964e-01f, -7.25466833e-02f, -1.87277123e-01f, -1.30063593e-02f, -3.21166784e-01f, 1.79263845e-01f,
  -5.20715527e-02f, 4.02254723e-02f, -3.15554053e-01f, -2.15557203e-01f, -1.22705117e-01f, 5.29813431e-02f, -6.45786931e-05f, 1.11515574e-01f, 1.10824652e-01f, -2.20764466e-02f,
  3.30630429e-02f, 6.18984737e-02f, 3.23374011e-02f, -1.72985848e-02f, 6.75494671e-02f, -9.43655372e-02f, -1.17712498e-01f, 1.19548231e-01f, -1.22695453e-01f, -1.19224507e-02f,
  -9.90523100e-02f, 6.86221570e-02f, -3.36557217e-02f, -1.94471091e-01f, -1.25974894e-01f, 1.01354465e-01f, 1.25849739e-01f, 1.99832097e-01f, 7.63051659e-02f, -3.52011174e-01f,
  -2.14856658e-02f, 5.24878092e-02f, -1.31231546e-01f, -3.67730334e-02f, 7.67897442e-02f, -2.23205555e-02f, 1.71870828e-01f, -8.67577642e-02f, -4.72700261e-02f, -2.06559915e-02f,
  1.14163473e-01f, -5.56066670e-02f, 1.29174232e-01f, 6.14110194e-02f, 8.92865583e-02f, -7.07126930e-02f, 1.89002678e-01f, 8.44927281e-02f, -7.52324685e-02f, -2.04558268e-01f,
  -1.54798254e-02f, -1.39711782e-01f, -1.22465722e-01f, -6.16908371e-02f, -1.71621859e-01f, -6.63329959e-02f, 3.76283675e-01f, -3.64158839e-01f, -1.64921835e-01f, -1.23631433e-01f,
  -1.64279342e-02f, 1.12735443e-01f, 1.16178365e-02f, 2.92593911e-02f, -1.07585005e-02f, 9.03069749e-02f, 3.07625234e-02f, 1.84453279e-01f, 9.04547349e-02f, 1.15800602e-02f,
  -2.74601411e-02f, -1.21070258e-01f, -3.31802070e-02f, -1.69841960e-01f, 7.42715523e-02f, -1.87949743e-02f, -8.33903402e-02f, -6.35089278e-02f, 2.23262757e-02f, -3.32856067e-02f,
  -3.01431995e-02f, 6.78339601e-03f, -1.07496820e-01f, -1.06278099e-01f, 8.73658713e-03f, 1.94925442e-02f, 7.27268234e-02f, -8.76000747e-02f, 9.18316022e-02f, -6.85787499e-02f,
  -2.84748990e-02f, 6.42166808e-02f, -1.22278966e-01f, 9.74076763e-02f, 1.02585405e-01f, -1.95431709e-02f, 5.43981977e-02f, 4.46231291e-02f, 1.29423559e-01f, -8.57784897e-02f,
  -3.28586474e-02f, 7.14182630e-02f, 8.78663808e-02f, 1.78348497e-01f, 8.82623019e-04f, -4.08902131e-02f, -3.51572633e-02f, -5.08255586e-02f, -2.77641993e-02f, -9.52172428e-02f,
  4.68809232e-02f, 5.24267182e-02f, -2.18299553e-01f, 1.62550122e-01f, -1.61335528e-01f, -1.09345935e-01f, 5.04821800e-02f, 1.36184350e-01f, 5.75401634e-03f, -1.02769427e-01f,
  6.12882711e-02f, 7.06525892e-02f, -1.27681762e-01f, -8.89392048e-02f, -2.81528570e-03f, 1.74547043e-02f, 3.90866771e-02f, 3.76337990e-02f, -2.42831670e-02f, 6.76353350e-02f,
  1.85451284e-02f, -5.76784052e-02f, 4.37902100e-03f, -1.58388004e-01f, -1.63310319e-01f, -1.32468924e-01f, -7.82257989e-02f, 3.67731117e-02f, 1.10366710e-01f, 1.18979082e-01f,
  -1.01755783e-01f, -1.18370406e-01f, 1.22934170e-01f, 1.90208778e-01f, 4.46459390e-02f, 1.11824855e-01f, 1.39399096e-02f, -7.27753714e-02f, 7.64831528e-02f, -7.38982484e-02f,
  -3.04034948e-02f, 4.04729731e-02f, -6.83140382e-02f, -1.28241763e-01f, 1.43063053e-01f, -1.71665728e-01f, 1.64821625e-01f, -1.89257219e-01f, 1.71420351e-01f, -2.03972799e-04f,
  9.71253142e-02f, 2.11830050e-01f, 5.01364022e-02f, -1.25844613e-01f, -1.46984681e-01f, 3.66016440e-02f, -1.34281263e-01f, -3.44228655e-01f, 1.52645469e-01f, -6.12902804e-04f,
  -1.55254766e-01f, 1.65918812e-01f, -6.89354911e-02f, 1.34054393e-01f, -1.25174865e-01f, 1.25802949e-01f, 2.29016170e-01f, -5.14993034e-02f, 4.46629487e-02f, -2.41881274e-02f,
  -1.86366178e-02f, -3.95403504e-01f, 3.89945023e-02f, 3.24242786e-02f, -6.68786690e-02f, 1.98786169e-01f, 9.16506350e-02f, 7.42418915e-02f, -3.16795856e-02f, 2.82325335e-02f,
  3.67628261e-02f, 1.07178688e-01f, -4.82450873e-02f, -1.98142692e-01f, -3.60079017e-03f, 1.44154191e-01f, 7.65264779e-02f, -1.60449538e-02f, 3.77133526e-02f, -6.19379729e-02f,
  -1.90077312e-02f, -6.07254580e-02f, 1.11234456e-01f, 6.69028535e-02f, 2.70781703e-02f, 8.75503570e-02f, -3.83585617e-02f, 5.99734522e-02f, -6.67163134e-02f, -1.15100227e-01f,
  -7.91736767e-02f, 9.86119062e-02f, -2.01011542e-02f, 1.00355782e-02f, 6.39369041e-02f, 9.79920775e-02f, 2.94101983e-02f, 1.92517899e-02f, -4.63956073e-02f, -5.22958562e-02f,
  3.52340005e-02f, 8.54558423e-02f, 9.85120609e-02f, 2.65059359e-02f, -1.09064626e-02f, 9.42095220e-02f, 1.90751664e-02f, 1.48414046e-01f, 2.74201129e-02f, 9.48659144e-03f,
  1.58379711e-02f, 1.27710551e-01f, 4.73662931e-03f, -4.84137572e-02f, -6.37016296e-02f, 9.56683159e-02f, 5.58029525e-02f, -4.83534019e-03f, -1.10971294e-01f, 2.77695000e-01f,
  -1.26266047e-01f, 7.75414780e-02f, 1.07316708e-03f, -2.62602344e-02f, 1.74406413e-02f, 6.55057505e-02f, 4.67015542e-02f, 6.89827204e-02f, 7.37304464e-02f, 1.07742622e-01f,
  -1.11669987e-01f, 6.11593165e-02f, -9.55825299e-02f, 2.60096435e-02f, 1.54929385e-01f, 3.34383957e-02f, -1.70460716e-01f, -4.06681411e-02f, 8.15418214e-02f, -1.48254588e-01f,
  7.28719309e-02f, -3.65951797e-03f, -1.20341577e-01f, -6.39206320e-02f, 6.12094346e-03f, 1.20342679e-01f, -5.25959544e-02f, 2.44211644e-01f, -9.20905843e-02f, 3.32447290e-02f,
  1.12311013e-01f, 1.52033448e-01f, 1.49729162e-01f, -1.48926750e-01f, -1.67438027e-03f, -3.15483920e-02f, 5.99895045e-02f, 3.51103544e-02f, 3.04426160e-02f, -1.22327283e-02f,
  -9.87264216e-02f, -1.76571026e-01f, 3.71335037e-02f, 1.88363239e-01f, -1.88445076e-02f, -8.20898488e-02f, 1.69837549e-01f, -3.59539129e-02f, 1.61793202e-01f, -1.07438475e-01f,
  -3.97094302e-02f, 7.42276013e-02f, -7.83398151e-02f, 2.15219073e-02f, 1.91807859e-02f, -9.59721953e-02f, -7.83694685e-02f, 8.41742009e-02f, -1.04893610e-01f, 3.10745016e-02f,
  -2.47293085e-01f, 1.07663624e-01f, -1.40696213e-01f, 5.73395342e-02f, -8.21341425e-02f, -8.20969716e-02f, 9.85728800e-02f, -7.52195790e-02f, -1.24550857e-01f, -1.48923129e-01f,
  7.37631985e-04f, -4.39448394e-02f, -4.32029575e-01f, 3.89927506e-01f, 9.51724127e-03f, 5.80440052e-02f, -3.61418575e-02f, 2.06851568e-02f, 4.68956418e-02f, 7.72497244e-03f,
  4.10937071e-02f, 2.08653547e-02f, 2.08926752e-01f, 5.38363457e-02f, 7.60378689e-02f, -7.27031380e-02f, 5.48147224e-02f, 1.42504141e-01f, 2.66202372e-02f, -1.14075921e-01f,
  -3.42398807e-02f, 8.94492716e-02f, 3.55195664e-02f, -4.23040539e-02f, 6.62250519e-02f, 1.10061266e-01f, -1.92280963e-01f, 7.69730983e-03f, -5.15781231e-02f, 1.60941377e-01f,
  -8.75967368e-03f, 4.45939153e-02f, 9.22583789e-02f, -4.27917056e-02f, 3.98140550e-02f, -1.10357799e-01f, 6.83474466e-02f, 5.54842539e-02f, 1.41747683e-01f, -2.88405479e-03f,
  5.94091080e-02f, 1.61329374e-01f, -1.13436393e-01f, 7.75365084e-02f, -1.16170585e-01f, -2.23287642e-02f, -3.85588482e-02f, -1.25913518e-02f, 7.59623051e-02f, 4.00506780e-02f,
  -3.14852484e-02f, 8.55997354e-02f, 9.25455689e-02f, 1.19181499e-01f, -4.67081331e-02f, 1.88832846e-03f, -8.72706920e-02f, 1.65496230e-01f, -2.03913465e-01f, 1.09888343e-02f,
  3.05671636e-02f, -3.20289955e-02f, 9.05303434e-02f, 2.20562756e-01f, 1.63409889e-01f, -7.35692400e-03f, -1.64611861e-01f, -6.40483713e-03f, -7.46232718e-02f, -5.68915568e-02f,
  -4.81826216e-02f, 6.18720846e-03f, -1.50285825e-01f, -9.02396366e-02f, 1.35286013e-02f, 2.13449255e-01f, -1.16480343e-01f, 3.57051492e-02f, 1.19502030e-01f, -7.41458386e-02f,
  2.23301984e-02f, -2.38054600e-02f, 3.56413051e-02f, 1.80359811e-01f, 6.49996027e-02f, -7.20132887e-02f, -6.88449992e-03f, 9.26136374e-02f, 7.07545802e-02f, 1.10101759e-01f,
  -7.95126799e-03f, 9.64771733e-02f, 1.44076079e-01f, 8.25985670e-02f, 4.42013657e-03f, 3.85370106e-02f, 3.73188853e-02f, 2.18046829e-02f, -8.07690471e-02f, 2.28289738e-01f,
  -6.70291856e-02f, 1.73996016e-02f, 8.10735673e-03f, -1.46205276e-01f, 5.53706288e-02f, -1.32917045e-02f, -1.53646439e-01f, 2.57761218e-02f, -1.12498552e-01f, 2.05464829e-02f,
  -1.49255574e-01f, -7.65999630e-02f, 6.49698973e-02f, 1.47422388e-01f, -6.51242137e-02f, 1.13156490e-01f, 5.07848598e-02f, 2.92567722e-02f, 2.58456022e-01f, 2.09356591e-01f,
  1.66497990e-01f, 2.97626816e-02f, 6.64392263e-02f, -3.93821709e-02f, 5.64088598e-02f, 7.94184357e-02f, -2.28857115e-01f, -4.16611820e-01f, -6.46793982e-03f, -4.47574146e-02f,
  -1.83297396e-02f, 6.74789324e-02f, 1.17869124e-01f, 1.14514448e-01f, -5.93100823e-02f, 1.34473726e-01f, 3.36535610e-02f, 1.02129253e-02f, 9.75961685e-02f, 1.99306887e-02f,
  -1.62378196e-02f, -1.33026931e-02f, 1.10233109e-02f, 9.73189548e-02f, 7.92648345e-02f, -6.10118620e-02f, -1.48133766e-02f, 1.88187286e-01f, 7.17739612e-02f, 1.53329875e-02f,
  4.18230938e-03f, -2.74219960e-02f, -2.41224263e-02f, -8.12230036e-02f, 1.13929190e-01f, -1.41446767e-02f, 4.01152298e-02f, -3.30562629e-02f, -1.02267511e-01f, 9.31569934e-03f,
  -7.04253837e-03f, -3.97559926e-02f, 5.76238483e-02f, 1.14016689e-01f, -3.78119126e-02f, 3.87348584e-03f, -1.29165918e-01f, 1.14250248e-02f, -6.87340349e-02f, -1.81458760e-02f,
  5.18198349e-02f, -4.17842828e-02f, 1.93246529e-02f, -5.97009622e-02f, 4.19646800e-02f, 4.19916362e-02f, -9.78454649e-02f, -1.41376898e-01f, -3.75667699e-02f, -1.79157127e-02f,
  -1.15117371e-01f, -1.12304324e-02f, 6.40883967e-02f, -2.55664159e-02f, -3.60261165e-02f, -2.78395683e-01f, -2.91117765e-02f, 9.89671703e-03f, -2.53880657e-02f, -1.10654943e-01f,
  6.18400238e-02f, -1.91566885e-01f, 9.36021656e-02f, -1.04187839e-01f, 4.29403596e-02f, 5.65297119e-02f, 1.03059739e-01f, 2.24985242e-01f, 2.67822035e-02f, -3.30539495e-02f,
  -4.45756577e-02f, 2.34756321e-01f, 1.27378041e-02f, 1.77195549e-01f, -1.40672894e-02f, 3.26268598e-02f, -1.32116660e-01f, 6.37389421e-02f, -1.29419118e-01f, 3.94094102e-02f,
  3.47437188e-02f, -7.53099546e-02f, -8.02180693e-02f, -8.99281353e-02f, -3.08813807e-02f, -9.12710056e-02f, -1.40678231e-02f, 1.67497154e-02f, -1.39185086e-01f, 1.44780830e-01f,
  7.18499953e-03f, -6.67464137e-02f, -6.86676726e-02f, -5.94586432e-02f, 7.90807083e-02f, -1.44254491e-02f, -9.63636786e-02f, 1.36706121e-02f, 6.03274517e-02f, -1.52882800e-01f,
  1.38228774e-01f, 5.83002083e-02f, 2.63598021e-02f, -5.15261330e-02f, 9.98513997e-02f, 2.31845975e-01f, 1.38713673e-01f, 5.86864026e-03f, -2.32645988e-01f, 9.58468020e-03f,
  -4.26621102e-02f, -1.41226519e-02f, 2.29777619e-01f, -5.57016432e-02f, 1.14638202e-01f, -2.58710259e-03f, -6.64154300e-03f, -1.90972269e-01f, 2.84953207e-01f, 4.91075478e-02f,
  -9.72862467e-02f, 2.54147984e-02f, -1.33229405e-01f, -7.16468394e-02f, 2.91572064e-02f, 6.77375421e-02f, -5.41209243e-02f, 6.82209507e-02f, 3.54272813e-01f, -4.32707578e-01f,
  1.60044094e-03f, 3.75648513e-02f, 1.43364653e-01f, -1.39280230e-01f, -6.15319819e-04f, -1.14354298e-01f, -3.99627052e-02f, -4.35430817e-02f, -7.50470310e-02f, 4.89160269e-02f,
  1.37241840e-01f, -2.27932036e-02f, -3.09377778e-02f, -2.69976333e-02f, 1.27211853e-03f, -2.12850124e-02f, 3.42211090e-02f, 3.46403979e-02f, -5.33096418e-02f, 8.79242867e-02f,
  -3.65766734e-02f, 1.86527297e-02f, -6.67760819e-02f, 3.42462920e-02f, 5.26524745e-02f, -6.65910915e-02f, -1.58382446e-01f, -1.19528510e-02f, -5.18872663e-02f, 7.46945366e-02f,
  7.28609487e-02f, -2.73027793e-02f, 7.38433897e-02f, -6.34688810e-02f, 8.08431953e-02f, 1.00627638e-01f, 5.23329079e-02f, -7.45900795e-02f, 1.21582635e-01f, 1.71524435e-02f,
  -6.45066798e-02f, 4.38977405e-03f, 4.71864603e-02f, 3.68985198e-02f, 1.55640421e-02f, 4.16571908e-02f, -8.76421332e-02f, 1.94312409e-02f, -1.05389468e-02f, 1.01648107e-01f,
  -4.95346673e-02f, -1.16387017e-01f, -5.15943281e-02f, -6.82919146e-03f, -1.63374558e-01f, 5.76041713e-02f, -9.68533158e-02f, 9.09952521e-02f, 1.70213982e-01f, 5.63861057e-02f,
  9.72689763e-02f, -7.64934495e-02f, -5.02677262e-03f, 1.62884548e-01f, 1.73568763e-02f, 1.72202155e-01f, -1.32239357e-01f, -1.64955407e-02f, -8.66785571e-02f, 6.84658512e-02f,
  -1.10596836e-01f, -8.66634399e-02f, 1.09703705e-01f, -8.22283514e-03f, -3.25274430e-02f, -3.51486653e-02f, -1.66862682e-01f, 2.05680286e-03f, 9.39333886e-02f, -1.30905649e-02f,
  -1.02779858e-01f, 1.05132952e-01f, -6.90957308e-02f, -3.38123888e-02f, 4.75644618e-02f, -2.02119090e-02f, 3.00986401e-04f, -1.58578269e-02f, 1.56625524e-01f, -1.98099688e-02f,
  2.47429293e-02f, -3.52119282e-02f, -5.02506234e-02f, -4.99548130e-02f, -1.05683893e-01f, 4.92977090e-02f, 4.82015572e-02f, 5.52591309e-02f, 8.42955336e-02f, 1.22584403e-01f,
  -6.22975864e-02f, 6.66677505e-02f, 2.23065108e-01f, 1.55869782e-01f, 2.54451305e-01f, 2.29499072e-01f, -2.86597788e-01f, -1.68905035e-01f, 1.84643921e-02f, 9.05705467e-02f,
  1.82126030e-01f, -1.45834535e-02f, 1.63771555e-01f, 3.65108997e-02f, -2.03911260e-01f, -4.83810119e-02f, 3.11336935e-01f, -2.64003817e-02f, -2.26425990e-01f, -5.22715971e-02f,
  -1.64154265e-02f, -1.33581191e-01f, -1.90893874e-01f, 5.39127141e-02f, -2.00132549e-01f, 1.48862069e-02f, -3.62688184e-01f, -2.55925566e-01f, -1.51513144e-02f, -1.19917303e-01f,
  6.46406263e-02f, 1.30481750e-01f, -1.95268150e-02f, -8.65579173e-02f, 4.60638106e-02f, -1.05826408e-01f, -1.64298892e-01f, 5.54775186e-02f, -3.51354592e-02f, 1.00607323e-02f,
  2.67644078e-02f, -7.27162287e-02f, -1.03608042e-01f, -4.19706590e-02f, 3.50843966e-02f, 4.86995503e-02f, -8.95609185e-02f, 5.12225963e-02f, 2.91792769e-02f, -1.55010313e-01f,
  -2.92888563e-02f, -9.70595405e-02f, 2.27290578e-02f, 1.07176493e-04f, -1.28110439e-01f, -1.06229046e-02f, 3.50208655e-02f, 4.70659845e-02f, 6.59418255e-02f, 8.60584676e-02f,
  4.54569086e-02f, -7.21041262e-02f, 2.73971837e-02f, 6.44621104e-02f, 1.50267139e-01f, -1.57455638e-01f, 1.04095802e-01f, 3.49800736e-02f, 1.47582479e-02f, 4.23466153e-02f,
  -6.26601465e-03f, -5.48444428e-02f, -8.20495635e-02f, -2.25040000e-02f, 1.22208819e-01f, -5.34346700e-02f, -6.75753206e-02f, -9.53310877e-02f, 7.14826286e-02f, -1.01220489e-01f,
  -2.98828073e-02f, -4.19319374e-03f, -3.17101590e-02f, -2.09645610e-02f, -3.51518355e-02f, -2.09561680e-02f, 9.05016363e-02f, -7.20370887e-03f, 1.10324040e-01f, -1.03223480e-01f,
  5.43273985e-02f, 6.03392720e-02f, -7.61988983e-02f, 2.13473409e-01f, -4.17811871e-02f, 3.08026392e-02f, 8.30725878e-02f, 2.38249302e-02f, -2.21754238e-01f, 1.26099885e-02f,
  1.11799985e-02f, -1.48767769e-01f, 1.21835291e-01f, 6.63272617e-03f, -1.03316687e-01f, 1.06049716e-01f, 4.34387103e-02f, 3.92136090e-02f, -1.56943411e-01f, 1.70085728e-01f,
  -1.30513057e-01f, 5.38899824e-02f, 1.54623333e-02f, -1.61910453e-03f, 3.27029712e-02f, -2.71672249e-01f, 6.67451993e-02f, -8.47476423e-02f, 1.00990810e-01f, 6.14535548e-02f,
  1.27882853e-01f, -1.30397946e-01f, -7.35228881e-02f, -9.73753408e-02f, 1.86177030e-01f, 9.06957015e-02f, -1.67842016e-01f, -4.72033024e-02f, -1.74797829e-02f, 2.74919178e-02f,
  1.29376456e-01f, -2.22632170e-01f, 1.81389302e-02f, 1.65120289e-02f, -2.14447662e-01f, 1.87236235e-01f, -1.92481112e-02f, -1.75937131e-01f, -9.65597481e-02f, 8.15937966e-02f,
  -1.75985724e-01f, 5.02072535e-02f, -2.52001017e-01f, -1.07691726e-02f, -7.77335539e-02f, -1.02847204e-01f, 1.40041903e-01f, -2.76387811e-01f, -4.00030799e-02f, 4.07186635e-02f,
  -2.29604498e-01f, 1.29617244e-01f, 1.10855617e-01f, -2.24518199e-02f, -2.87446707e-01f, 1.84985399e-01f, 6.23667762e-02f, 1.43474951e-01f, -6.01550527e-02f, -1.91897422e-01f,
  -1.25861373e-02f, -5.69246300e-02f, -9.17490125e-02f, -9.69577804e-02f, 5.46963029e-02f, -1.29131258e-01f, -1.92506775e-01f, -1.29277259e-02f, -3.58678214e-02f, -7.78008923e-02f,
  -6.91784918e-02f, 4.61210385e-02f, -1.82392299e-02f, 3.96430753e-02f, 1.66329332e-02f, 2.69829389e-02f, -5.32218367e-02f, 1.49377182e-01f, 4.76407483e-02f, 3.97142721e-03f,
  -5.68475109e-03f, -4.07054909e-02f, 5.77062070e-02f, 8.76409188e-02f, -1.36707742e-02f, -3.49648716e-03f, 2.73237517e-03f, 1.68075168e-03f, -4.64723632e-02f, -6.58231527e-02f,
  -3.23882438e-02f, -9.50429142e-02f, -1.13507971e-01f, -2.80419067e-02f, -1.24742262e-01f, 1.02753863e-02f, 2.23038550e-02f, 2.67146192e-02f, 1.89265870e-02f, -1.07356198e-01f,
  -1.58309653e-01f, -3.47474031e-02f, -8.25030282e-02f, 4.82784472e-02f, -1.41111583e-01f, -6.21961355e-02f, -3.58607695e-02f, 2.74335295e-02f, 2.14398578e-02f, -1.61953002e-01f,
  6.21140264e-02f, 4.99829166e-02f, 2.96135936e-02f, 1.42610138e-02f, -1.88279107e-01f, -7.77261853e-02f, -1.13588944e-02f, -9.38126370e-02f, 8.02671686e-02f, 6.33766577e-02f,
  1.96106620e-02f, 8.44374821e-02f, 7.48485625e-02f, 8.64483118e-02f, -6.03626296e-02f, 2.11121347e-02f, 2.69935936e-01f, 7.09117800e-02f, -1.32131487e-01f, -8.91437903e-02f,
  -3.03074401e-02f, 1.26528442e-01f, -5.75766414e-02f, 1.39957517e-01f, -4.19598743e-02f, 7.19644055e-02f, -8.97614006e-03f, -3.41753885e-02f, -2.81684864e-02f, -6.32518232e-02f,
  8.64639059e-02f, -4.54920866e-02f, -1.88238621e-01f, 1.50429428e-01f, 1.62462201e-02f, -5.23799285e-02f, 2.68794931e-02f, -1.09745041e-01f, 1.14364244e-01f, -7.99907967e-02f,
  1.72935799e-02f, -1.72610983e-01f, 1.21628091e-01f, -4.19896543e-02f, -8.52487683e-02f, 2.91667525e-02f, 2.03578994e-01f, 1.80540569e-02f, -1.35884553e-01f, 9.90270227e-02f,
  -1.21032692e-01f, -2.15993136e-01f, -1.64365068e-01f, 6.16785698e-02f, -2.20463499e-01f, -5.52767590e-02f, 1.47996321e-01f, 6.53317198e-02f, 2.30455790e-02f, -1.57732032e-02f,
  4.72575203e-02f, -6.04131036e-02f, 1.74165800e-01f, 1.14331152e-02f, -7.78534189e-02f, -1.80469528e-01f, -2.06982829e-02f, 1.55187696e-01f, -1.08860880e-01f, 6.06583022e-02f,
  4.34625149e-02f, 2.71065589e-02f, 3.22011918e-01f, -2.49054268e-01f, -6.17941618e-02f, -1.83207672e-02f, -5.96277006e-02f, 1.41851395e-01f, -8.68323669e-02f, 6.24114797e-02f,
  -1.52273789e-01f, 8.36353283e-03f, -7.23349154e-02f, 1.11557499e-01f, 1.71729639e-01f, 4.70413826e-02f, 1.11834750e-01f, -9.37137231e-02f, 1.47082293e-02f, -1.88076228e-01f,
  4.91162343e-03f, -3.77097018e-02f, 4.79220822e-02f, -4.74069491e-02f, 1.49344876e-01f, -1.39448971e-01f, -7.48079941e-02f, -1.14711352e-01f, -3.39905173e-02f, 1.11206606e-01f,
  -8.44506249e-02f, 4.82968725e-02f, 3.43144052e-02f, -3.58760793e-04f, 7.54136369e-02f, 1.12846531e-01f, -1.96875655e-03f, -2.80832574e-02f, 8.46736282e-02f, 1.37468264e-01f,
  -6.56485781e-02f, -4.16929722e-02f, -7.33784884e-02f, 1.90991312e-02f, -4.15385440e-02f, 1.56532884e-01f, -4.57609184e-02f, 8.59532878e-02f, -1.94244664e-02f, 8.04792345e-02f,
  1.05434217e-01f, 3.82552668e-02f, 1.14122875e-01f, -4.39425670e-02f, 8.84528831e-02f, 4.66253348e-02f, -3.51359136e-02f, 1.33150667e-01f, -8.24998394e-02f, 1.15074575e-01f,
  -1.63413718e-01f, 1.04898117e-01f, -1.55129045e-01f, 5.46690598e-02f, -6.91894442e-02f, -1.58468395e-01f, 1.15393966e-01f, 1.56769238e-03f, 3.62217352e-02f, -1.34760663e-01f,
  1.17474496e-02f, 3.29598375e-02f, 1.17463861e-02f, 1.98355950e-02f, -1.92413077e-01f, -1.53724134e-01f, 2.94174440e-02f, -4.49782657e-03f, -6.89871162e-02f, -1.41662076e-01f,
  -7.45724142e-02f, -1.89405233e-01f, -1.62424996e-01f, -1.64447594e-02f, 5.34680597e-02f, 2.83843756e-01f, -9.41249505e-02f, -3.81067395e-02f, 1.46855125e-02f, 2.16077105e-03f,
  2.20549181e-01f, -2.09498018e-01f, 5.41678704e-02f, -1.86732598e-02f, -6.99490830e-02f, -2.30524577e-02f, -4.26185206e-02f, 2.20936239e-01f, -1.07994162e-01f, -1.80511922e-01f,
  4.59582321e-02f, 2.70924009e-02f, -1.05477609e-01f, -1.08050078e-01f, 1.27789214e-01f, 3.86565900e-03f, 8.44092146e-02f, -4.96357679e-02f, -9.62053463e-02f, -3.47439237e-02f,
  1.18290216e-01f, -2.20344663e-01f, -6.45307750e-02f, -2.01369330e-01f, 2.45004124e-03f, 3.55769135e-02f, -2.29887351e-01f, -1.43297976e-02f, -1.87756896e-01f, 2.68035773e-02f,
  -2.58653492e-01f, -8.69617388e-02f, 1.11163802e-01f, -9.39759612e-02f, 1.19371794e-01f, -2.40303099e-01f, 1.26466155e-02f, 8.47613364e-02f, -6.22365177e-02f, 9.98133719e-02f,
  -3.28645222e-02f, 3.90236109e-01f, 1.43197700e-01f, 1.24931343e-01f, -5.80619797e-02f, -3.88300698e-03f, 1.77491046e-02f, 7.72647709e-02f, 7.32110953e-03f, 9.01041403e-02f,
  3.06582730e-02f, -1.31471962e-01f, -1.13832811e-02f, 1.29087001e-01f, 5.76671548e-02f, 1.26258612e-01f, -3.65376882e-02f, 1.76335245e-01f, 8.19717813e-03f, 4.10406198e-03f,
  -9.37943235e-02f, 5.49248233e-02f, 5.96658587e-02f, 1.36949137e-01f, -8.29541087e-02f, 9.25546661e-02f, -6.48626983e-02f, 1.04876712e-01f, 1.09542692e-02f, 1.07376166e-01f,
  6.53405878e-05f, -6.07077889e-02f, -1.38342097e-01f, 2.56659277e-02f, 6.90761283e-02f, 4.31688316e-02f, 1.36150084e-02f, -3.57116424e-02f, 6.16207253e-03f, 1.10700801e-01f,
  -1.02629304e-01f, -1.91980898e-01f, 1.51700690e-01f, 7.76943266e-02f, 1.26535282e-01f, 1.61366940e-01f, -1.51975691e-01f, -4.54373732e-02f, 1.03369191e-01f, 5.40573969e-02f,
  -1.21675842e-01f, 5.40414788e-02f, 8.78769085e-02f, -1.13349393e-01f, -3.94810289e-02f, -1.65599316e-01f, 8.93885791e-02f, 1.79743379e-01f, -1.40895754e-01f, 2.47179065e-02f,
  -1.24609530e-01f, 5.35842106e-02f, 1.52798146e-02f, -1.07178606e-01f, 1.76875666e-01f, 6.68400526e-02f, -6.91632694e-03f, -1.01539813e-01f, -1.72096398e-02f, 5.46208434e-02f,
  -6.13923222e-02f, -6.81265220e-02f, -6.66040108e-02f, 2.36632787e-02f, -1.22344166e-01f, 1.27785036e-03f, 1.36141896e-01f, 1.54824451e-01f, -2.67318152e-02f, 6.03345484e-02f,
  -5.02900369e-02f, 2.47090999e-02f, -6.15790784e-02f, -3.41482623e-03f, -2.68789697e-02f, 1.06613986e-01f, 5.48337363e-02f, 5.90126291e-02f, -6.72242716e-02f, -8.57082829e-02f,
  -1.08356424e-01f, -4.38723564e-02f, -1.38290569e-01f, -1.90173090e-01f, 1.99776404e-02f, -7.14774877e-02f, 5.09302802e-02f, 8.86679292e-02f, 1.26552194e-01f, 1.57615453e-01f,
  -1.47798538e-01f, 8.35922062e-02f, 2.65723988e-02f, -1.73910372e-02f, -5.44276610e-02f, -1.15806330e-02f, -8.71759653e-02f, -1.10793598e-01f, 2.24862974e-02f, 1.25656396e-01f,
  -3.26499939e-01f, -1.25061855e-01f, 1.44198582e-01f, 8.43242854e-02f, -5.65497838e-02f, -5.90953492e-02f, 7.99784884e-02f, -1.51637539e-01f, 5.99319786e-02f, -2.17983946e-01f,
  8.41293111e-02f, -6.41585216e-02f, 2.39239894e-02f, 1.14891380e-01f, 2.44761795e-01f, 1.93393111e-01f, 5.67577146e-02f, 1.62830185e-02f, 4.46497738e-01f, -2.31153578e-01f,
  -1.71344057e-02f, -8.12538788e-02f, -1.04729339e-01f, 2.78702192e-02f, 9.52826664e-02f, -1.70102715e-02f, 8.08491092e-03f, 2.83656381e-02f, -1.68982930e-02f, -9.00945533e-03f,
  1.19071476e-01f, -1.71356380e-01f, -2.06628051e-02f, -5.06479032e-02f, 7.33291672e-04f, 5.84694594e-02f, -1.64433164e-04f, -1.77701011e-01f, 7.09315836e-02f, -1.48205310e-01f,
  -1.10574318e-02f, 3.57082821e-02f, -1.04615785e-01f, -1.85260251e-02f, -2.53556594e-02f, -1.50950462e-01f, -1.71477161e-02f, -3.70898172e-02f, 6.50966614e-02f, 9.89918262e-02f,
  5.50672002e-02f, -2.00086646e-02f, 3.47022526e-02f, 3.25585194e-02f, -5.94832096e-03f, -7.25274831e-02f, 3.95414606e-02f, 1.65926248e-01f, 5.15519194e-02f, 5.07084355e-02f,
  -2.09370740e-02f, 7.60766417e-02f, 8.92758071e-02f, -7.27195442e-02f, 9.39626247e-03f, -1.35569647e-02f, -1.08554006e-01f, -1.32690012e-01f, -3.22961397e-02f, -2.18393244e-02f,
  2.48035304e-02f, 5.49850203e-02f, -1.42536178e-01f, 2.08055470e-02f, 2.12270588e-01f, -4.05732878e-02f, -1.25464350e-01f, -1.98776901e-01f, -1.40528530e-01f, 9.15461555e-02f,
  -1.21883169e-01f, -3.22421908e-01f, 3.07771079e-02f, 2.24632069e-01f, 1.23692933e-03f, -1.52708054e-01f, -4.56054844e-02f, -1.24577656e-01f, -4.11490053e-02f, -1.78398922e-01f,
  -7.39403442e-02f, 1.23504780e-01f, -2.40348931e-02f, -6.79641515e-02f, -8.38756263e-02f, -1.24242745e-01f, 9.10373256e-02f, -4.20949720e-02f, -1.70589425e-02f, -4.17362116e-02f,
  -5.46981255e-03f, 1.49734080e-01f, -7.19565898e-02f, -3.24510038e-02f, -5.50327115e-02f, -7.53725246e-02f, 1.55368567e-01f, 2.80070156e-02f, -1.71553958e-02f, 8.49024951e-03f,
  -3.51813175e-02f, -2.34177597e-02f, -4.83659692e-02f, 3.16521968e-03f, 1.50785789e-01f, 3.17806751e-03f, -8.34162533e-02f, -1.46296263e-01f, 1.75335586e-01f, 1.59250766e-01f,
  6.94932342e-02f, 2.70895399e-02f, 1.48012534e-01f, 1.60744146e-01f, 9.22749937e-02f, -1.63731407e-02f, -1.02581181e-01f, 6.54039979e-02f, -1.05858371e-02f, -1.16938993e-01f,
  -5.38227687e-05f, -1.03826627e-01f, -1.97390512e-01f, 4.63974141e-02f, -3.03214848e-01f, -3.77540141e-02f, -1.98147416e-01f, -1.04601063e-01f, 1.14740528e-01f, 1.04348376e-01f,
  7.38866180e-02f, 4.52094264e-02f, 3.37043077e-01f, 3.28652948e-01f, 1.74359486e-01f, 7.70949423e-02f, -1.00272577e-02f, -3.95237654e-03f, 4.46789116e-02f, -4.49678535e-03f,
  -8.41919929e-02f, -2.67741717e-02f, 4.92158681e-02f, -5.39557375e-02f, -3.71067487e-02f, 1.73230946e-01f, 6.41080737e-02f, -1.32747486e-01f, -6.49778247e-02f, -2.74034329e-02f,
  -4.10060845e-02f, 7.73144001e-03f, -9.41927060e-02f, 7.54170418e-02f, 3.58502637e-03f, -8.19818024e-03f, -9.22515802e-03f, 4.58310023e-02f, -5.01144603e-02f, 5.86066134e-02f,
  -3.25383469e-02f, 5.27961515e-02f, -1.65317003e-02f, -1.69473849e-02f, 3.58327031e-02f, -1.51600791e-02f, -1.41821593e-01f, 2.46957373e-02f, -6.67402744e-02f, -1.83135122e-02f,
  -4.78571095e-02f, 8.86225253e-02f, 9.70218237e-03f, -1.51150540e-01f, -1.60958301e-02f, 3.09447777e-02f, -5.04208915e-02f, -4.11747769e-02f, 1.19034477e-01f, 3.61431241e-02f,
  2.00376399e-02f, -7.75694773e-02f, 7.93416724e-02f, -1.79589286e-01f, 2.21705269e-02f, 7.34934062e-02f, 8.63255840e-03f, -1.48151247e-02f, 1.20939743e-02f, -9.77561921e-02f,
  1.48856252e-01f, -1.93248123e-01f, 1.74051940e-01f, 4.25301082e-02f, 5.86184710e-02f, 2.91460613e-03f, 7.67491460e-02f, 6.35765940e-02f, -8.62589329e-02f, 1.65090278e-01f,
  -6.11819588e-02f, 1.99689460e-03f, 1.28224147e-02f, -1.05405420e-01f, 8.61596540e-02f, -1.27651140e-01f, -1.30186692e-01f, 7.69973546e-03f, 2.06858307e-01f, 4.39878330e-02f,
  8.74473248e-03f, 1.39898688e-01f, -1.52952531e-02f, 4.20276495e-03f, 1.75907582e-01f, 7.21681938e-02f, 7.28761479e-02f, 6.00250848e-02f, 2.51292419e-02f, -2.54643679e-01f,
  5.47823496e-02f, 8.87714792e-03f, 2.94447020e-02f, -9.05413702e-02f, 5.96129219e-04f, 3.47450912e-01f, 9.76915732e-02f, 1.93562448e-01f, -9.05325413e-02f, 5.63957319e-02f,
  -1.28926896e-02f, 1.74106538e-01f, -5.11962101e-02f, 1.47361472e-01f, -1.23379685e-01f, -9.59749892e-02f, 1.23384759e-01f, 2.46115793e-02f, 2.27296531e-01f, 3.34878974e-02f,
  -1.74811333e-01f, -2.35672947e-02f, 4.45438623e-02f, -2.04305336e-01f, -2.35863291e-02f, 4.18232158e-02f, -9.94527563e-02f, 1.23474300e-01f, -4.97925542e-02f, 3.91022973e-02f,
  1.71139523e-01f, -7.21916631e-02f, 2.48952433e-01f, 2.04721298e-02f, 1.96162611e-01f, 1.08015038e-01f, 1.36134624e-01f, 5.81557862e-02f, 6.80889636e-02f, 5.89806065e-02f,
  1.77123770e-01f, -3.31027150e-01f, 8.65949467e-02f, 1.35348737e-02f, 3.09677601e-01f, -2.42884472e-01f, 2.03770205e-01f, -2.55144071e-02f, -1.29364446e-01f, 7.91840404e-02f,
  -1.39833416e-03f, 5.61880209e-02f, 3.87547463e-02f, -3.64972353e-02f, -9.54788774e-02f, -1.32697225e-01f, 1.73155069e-01f, -1.04050720e-02f, 4.32540663e-02f, -5.07699735e-02f,
  6.75914064e-02f, -8.47871453e-02f, 1.39628509e-02f, -7.62816751e-03f, 8.22506025e-02f, -2.58216988e-02f, 2.96131726e-02f, -6.90196157e-02f, -1.61593318e-01f, 6.35759346e-03f,
  9.26806033e-02f, -6.25609839e-03f, 1.08255059e-01f, 5.23793995e-02f, -1.01743288e-01f, 4.77704965e-02f, -1.07565764e-02f, 9.42000225e-02f, 1.23739997e-02f, 8.44794288e-02f,
  1.98214483e-02f, 1.89233031e-02f, -1.11909047e-01f, -7.58795664e-02f, 1.16467074e-01f, -2.34063100e-02f, -6.27795905e-02f, 1.64193109e-01f, 6.35949224e-02f, 5.11087924e-02f,
  9.09081250e-02f, 3.30590494e-02f, 2.27101911e-02f, 9.80169885e-03f, 9.38800275e-02f, -3.83423194e-02f, 6.09399118e-02f, 3.63794826e-02f, 5.59155084e-02f, 2.00323805e-01f,
  1.85543835e-01f, -3.41141410e-02f, -9.73680988e-02f, -6.04534633e-02f, -3.34891491e-02f, 1.01077929e-01f, 2.37039775e-02f, -1.07583448e-01f, 2.90628988e-02f, -1.83774997e-02f,
  -3.59978303e-02f, -5.03971288e-03f, -1.38165578e-01f, 1.35460682e-02f, 1.73829813e-02f, -1.51277557e-01f, -1.34141311e-01f, -3.04864198e-02f, -1.82145108e-02f, -8.46601352e-02f,
  -9.26459432e-02f, -2.54049934e-02f, 9.98665765e-02f, -1.82395890e-01f, -2.63406262e-02f, -5.50546646e-02f, 3.21461596e-02f, 1.19387023e-01f, 9.61341038e-02f, 4.00641076e-02f,
  -7.24593699e-02f, -1.50157303e-01f, 3.09682846e-01f, -8.63143280e-02f, 5.07648010e-03f, -4.94176112e-02f, -3.73438820e-02f, -7.36233499e-03f, -5.22862608e-03f, 1.26956701e-01f,
  3.21085826e-02f, 1.50222909e-02f, -6.55072108e-02f, -6.18619248e-02f, 1.69581354e-01f, -1.49630696e-01f, -2.51223110e-02f, -3.81195508e-02f, 2.19591975e-01f, -2.68139243e-01f,
  1.11141212e-01f, -5.49697950e-02f, 4.07525245e-03f, -9.67714638e-02f, 8.33874792e-02f, 1.16704833e-02f, -1.49526551e-01f, 8.54874477e-02f, -8.71608220e-03f, -1.27497420e-01f,
  -1.09680705e-01f, 5.75914886e-03f, -2.51571506e-01f, -3.09915487e-02f, 2.03385025e-01f, 5.00846729e-02f, 9.75837260e-02f, 2.67950092e-02f, 1.01999909e-01f, -5.17403446e-02f,
  1.07040688e-01f, -1.75563410e-01f, 4.15590778e-02f, 2.81491697e-01f, -5.70935793e-02f, 1.08631343e-01f, -5.38935214e-02f, -2.07553040e-02f, 1.40435278e-01f, 3.26813422e-02f,
  -6.15320355e-02f, 2.51693539e-02f, 1.68255463e-01f, -1.69335663e-01f, 1.71165336e-02f, 4.01921831e-02f, 5.27405553e-02f, 3.04237157e-02f, 5.71674369e-02f, 3.04070744e-03f,
  -5.94668314e-02f, 2.60157194e-02f, 1.37407526e-01f, 1.32411299e-02f, 3.77702788e-02f, 6.52637631e-02f, 7.76879191e-02f, 6.86067194e-02f, -7.83345178e-02f, 1.40123460e-02f,
  8.86554345e-02f, -7.45698363e-02f, -3.36425640e-02f, 1.21933958e-02f, -1.11318216e-01f, -6.81881532e-02f, -1.36764094e-01f, 2.26079691e-02f, -1.61320612e-01f, -1.46808520e-01f,
  -4.79592010e-02f, 8.07043314e-02f, -1.20737329e-01f, 3.98753285e-02f, 1.70273080e-01f, -1.04670063e-01f, 8.25713128e-02f, -7.17888996e-02f, -4.43233512e-02f, -1.24973521e-01f,
  2.49027964e-02f, 5.68965338e-02f, -1.24949992e-01f, -7.61157647e-02f, -1.18360251e-01f, -2.42840406e-02f, 6.55054748e-02f, -1.84595421e-01f, 2.38416702e-01f, -1.79362938e-01f,
  -7.53651932e-02f, 5.83822280e-02f, -5.13669737e-02f, -6.10515568e-03f, -2.60032229e-02f, 1.54384121e-01f, 7.57148787e-02f, 4.61291261e-02f, -2.93685198e-02f, -2.18446534e-02f,
  -5.78313991e-02f, 5.89108840e-02f, 4.43259999e-02f, 3.98365455e-03f, 1.48806810e-01f, -4.78403084e-02f, 4.25323807e-02f, 1.61771104e-01f, 2.28349622e-02f, -9.02123097e-03f,
  4.21961583e-02f, -1.98582381e-01f, 1.11556590e-01f, 2.38029640e-02f, 3.24217975e-02f, -2.93400258e-01f, 9.66438130e-02f, 2.76309699e-02f, -2.60729645e-03f, 2.80657131e-02f,
  -1.98263451e-01f, 3.73683840e-01f, 3.41089144e-02f, 8.53168890e-02f, -2.74584405e-02f, -6.64948905e-03f, 6.53757825e-02f, 7.03702271e-02f, 6.31025285e-02f, 8.60341862e-02f,
  -1.21788569e-01f, -5.77134229e-02f, 2.17950687e-01f, 2.25184128e-01f, 1.09490298e-01f, 5.79331594e-04f, 2.69704349e-02f, 1.51892319e-01f, 2.19133705e-01f, -7.79941380e-02f,
  -2.22034499e-01f, -8.39906856e-02f, 8.51221085e-02f, 8.24304447e-02f, 2.15827867e-01f, 1.87503584e-02f, 1.53478514e-02f, -1.42921209e-01f, 8.82392153e-02f, 1.35082111e-01f,
  1.49056718e-01f, 3.12883779e-02f, -1.60517439e-01f, 2.47239526e-02f, 1.49518123e-03f, 1.25540391e-01f, 5.34442589e-02f, 2.68951058e-01f, 1.56619832e-01f, -1.08244665e-01f,
  1.28324389e-01f, -2.25657597e-01f, -3.24673764e-02f, 1.26693457e-01f, 1.97869956e-01f, 8.52702260e-02f, 9.67617482e-02f, 5.64762950e-02f, -4.77122050e-03f, 4.70754281e-02f,
  1.51888236e-01f, -1.17274396e-01f, -4.37881351e-02f, 3.56280617e-02f, 2.12324977e-01f, 9.20101702e-02f, -2.42398009e-02f, -1.14691198e-01f, 1.03747752e-03f, 3.06793619e-02f,
  -1.10691465e-01f, -8.95389318e-02f, 5.50555103e-02f, 2.46498305e-02f, 3.82330851e-03f, 5.52216694e-02f, 1.99853554e-02f, 3.24674286e-02f, -1.86609589e-02f, 7.42681772e-02f,
  1.28167808e-01f, -1.66395940e-02f, 1.06751593e-03f, 1.01898983e-02f, 5.69776744e-02f, 8.30622017e-03f, -1.96263995e-02f, 9.73127335e-02f, 2.88972002e-03f, -4.20629978e-03f,
  2.38641147e-02f, 3.01369503e-02f, -1.00616850e-01f, 1.16841875e-01f, 4.80747558e-02f, 3.62792285e-04f, 7.54779503e-02f, -1.15338108e-02f, 7.61660710e-02f, -6.04699599e-03f,
  4.71854061e-02f, -2.34300438e-02f, 6.20038100e-02f, -5.44334799e-02f, -1.82578191e-01f, 1.22226298e-01f, -1.27492085e-01f, 6.83356971e-02f, 4.15069610e-02f, 1.38495006e-02f,
  3.54809240e-02f, -6.86692968e-02f, 2.40018189e-01f, -3.86593826e-02f, -2.00672105e-01f, 3.37865241e-02f, 6.71036988e-02f, 2.52980590e-01f, -4.95049264e-03f, -5.11304997e-02f,
  1.11672901e-01f, 1.20006025e-01f, 1.28512874e-01f, 8.87916014e-02f, -5.64527586e-02f, -1.11005224e-01f, 7.19422102e-02f, 1.65308751e-02f, 2.60139927e-02f, 1.12323025e-02f,
  -6.11871630e-02f, 6.35441691e-02f, -9.66901705e-02f, -5.27229235e-02f, -1.16331570e-01f, -4.02640440e-02f, 9.67590138e-02f, 3.72833237e-02f, -9.02815536e-02f, -1.34893984e-01f,
  -2.85313744e-02f, -1.18642017e-01f, 1.53236449e-01f, 1.34999231e-02f, -1.03937974e-02f, -5.50891683e-02f, -7.56425485e-02f, 2.37354353e-01f, 6.34659529e-02f, -4.47713062e-02f,
  -2.76169647e-02f, -5.61135411e-02f, 3.54893543e-02f, 7.03909844e-02f, 1.50292516e-02f, -2.17932463e-01f, 2.27477103e-01f, 2.43501235e-02f, -2.02882662e-01f, -7.66879786e-03f,
  -9.66044664e-02f, 2.73868412e-01f, 1.86213821e-01f, 1.06782965e-01f, 1.28600791e-01f, 9.86535177e-02f, -9.26215053e-02f, -8.20430741e-02f, 3.68592411e-01f, 1.36826500e-01f,
  1.01067759e-01f, -7.47869462e-02f, 8.98892283e-02f, 1.28223419e-01f, -1.14651993e-01f, -2.94155747e-01f, 5.15414253e-02f, 2.52988711e-02f, -2.08217927e-04f, -1.91567272e-01f,
  2.43343189e-02f, 5.03402241e-02f, 1.51570514e-01f, -6.10130243e-02f, 1.99855138e-02f, -3.22865397e-02f, 1.55594394e-01f, -1.39112979e-01f, 2.25705534e-01f, 6.73512444e-02f,
  1.71881616e-01f, -1.40531082e-02f, 1.78625390e-01f, 4.49513122e-02f, 3.31475921e-02f, -1.64097659e-02f, 3.05190012e-02f, 1.11567462e-03f, 8.51225406e-02f, 6.54473379e-02f,
  1.04481451e-01f, 2.06263419e-02f, 5.75853847e-02f, -5.58885708e-02f, -5.06762005e-02f, 8.58621001e-02f, -1.31986812e-02f, 1.94619566e-01f, 1.20193087e-01f, -1.23011746e-01f,
  -2.98949927e-02f, -5.89033775e-02f, 6.15775436e-02f, 6.53845370e-02f, -7.79229030e-02f, 7.27770254e-02f, 3.53485718e-02f, -7.06298463e-03f, -7.60785714e-02f, -7.20592821e-03f,
  -7.55490288e-02f, -9.99880508e-02f, -1.05208844e-01f, 3.21977884e-02f, 6.77039400e-02f, 1.49616659e-01f, 5.62168173e-02f, -8.33303481e-02f, -7.26240873e-02f, 1.34751290e-01f,
  -5.41355871e-02f, -1.80471271e-01f, -4.44666259e-02f, -9.43277031e-02f, -2.34522715e-01f, 1.34761259e-01f, 1.12869717e-01f, 3.37248854e-02f, 7.71484524e-02f, 1.29347980e-01f,
  1.02898948e-01f, -1.84335157e-01f, -8.59535113e-02f, -1.37822077e-01f, -1.17760740e-01f, 6.40576407e-02f, 3.83227766e-02f, 1.65376171e-01f, -7.92569071e-02f, 1.92768592e-02f,
  3.97207476e-02f, 6.31607994e-02f, -1.15489587e-01f, -1.75350845e-01f, 5.87570928e-02f, -1.56278051e-02f, -8.47235247e-02f, 9.32215005e-02f, 2.56089047e-02f, 6.82181567e-02f,
  -4.81983796e-02f, -1.15534915e-02f, -1.22259088e-01f, 1.00424416e-01f, 1.23673312e-01f, 1.24224216e-01f, -1.66114479e-01f, -1.54042318e-01f, -7.90288597e-02f, 1.55003175e-01f,
  1.36466436e-02f, -8.89668390e-02f, -7.68335760e-02f, 9.59094055e-03f, -1.05277792e-01f, 8.33598226e-02f, 3.00946720e-02f, 1.96980104e-01f, 1.52061610e-02f, -1.54940918e-01f,
  3.90913412e-02f, 1.40241802e-01f, -8.60341340e-02f, -3.29447798e-02f, -5.04553504e-02f, 2.17676789e-01f, 4.70957905e-02f, 1.55743480e-01f, -2.59299010e-01f, -3.02323885e-02f,
  -2.24983796e-01f, -5.10897934e-02f, -1.03350114e-02f, -1.31119341e-01f, -5.47285341e-02f, 8.61727968e-02f, 2.35454604e-01f, 1.12065874e-01f, 6.56003058e-02f, -1.24327049e-01f,
  -9.17560831e-02f, -1.11684054e-01f, -3.61857563e-02f, -2.26414382e-01f, -4.16537859e-02f, -3.26455198e-02f, 9.37700868e-02f, -2.30783761e-01f, -2.12580472e-01f, -8.27191398e-03f,
  7.62521178e-02f, 1.69653118e-01f, -5.29576354e-02f, -2.57664081e-02f, 8.69093761e-02f, -2.55658366e-02f, 4.74538421e-03f, 1.28595755e-01f, 5.53674772e-02f, -4.00383770e-02f,
  4.81524467e-02f, -6.70666620e-02f, -1.25911921e-01f, 1.86355487e-02f, 8.18809867e-02f, -6.97104335e-02f, -3.76036502e-02f, 9.94141698e-02f, -5.76425269e-02f, -8.01759288e-02f,
  4.80895117e-02f, -1.21116318e-01f, 2.93652546e-02f, -6.13195002e-02f, 1.16196543e-03f, -6.33842079e-03f, 1.94916837e-02f, -6.91049844e-02f, 1.45736560e-01f, -7.60865211e-02f,
  4.85058986e-02f, -8.33853520e-03f, -8.50814581e-03f, 1.73629910e-01f, -3.01151387e-02f, 6.43762574e-02f, -1.08644798e-01f, -4.66384552e-02f, -7.89936185e-02f, 1.37809098e-01f,
  -6.44349307e-02f, -4.96370136e-04f, -6.15321621e-02f, 1.72051825e-02f, 3.59818409e-03f, 5.11366762e-02f, -1.88126773e-01f, -6.53258013e-03f, 5.81678376e-02f, 9.03479084e-02f,
  1.94280520e-02f, -9.76697206e-02f, -1.09664150e-01f, 2.15646341e-01f, -4.83657718e-02f, -7.13540688e-02f, 1.76942777e-02f, -7.36365914e-02f, 2.17045292e-01f, -1.31222412e-01f,
  1.39766745e-02f, -6.21217396e-03f, 1.06725600e-02f, 4.26565371e-02f, 6.97382316e-02f, -2.06674486e-02f, -2.52463408e-02f, -3.71998549e-02f, -5.00489697e-02f, -8.00264329e-02f,
  -5.63251078e-02f, -1.21255279e-01f, 6.99385330e-02f, -4.74707074e-02f, -7.66756833e-02f, 3.68998758e-02f, 7.65924081e-02f, 6.29773960e-02f, 9.27940756e-03f, 1.36048898e-01f,
  -3.30957882e-02f, -1.85128246e-02f, 4.82767783e-02f, 1.28918970e-02f, 6.38851970e-02f, -7.70599246e-02f, -3.20846098e-03f, 1.08186282e-01f, -3.66869383e-02f, -1.14268661e-02f,
  7.54815638e-02f, -1.40937781e-02f, 4.10657823e-02f, -5.42095229e-02f, 1.26700565e-01f, 1.91894919e-02f, -1.18479557e-01f, -8.76458287e-02f, 7.41592571e-02f, -1.66846085e-02f,
  1.50647998e-01f, -2.08323359e-01f, 2.87501931e-01f, 7.20445663e-02f, -2.35112697e-01f, -9.22052842e-03f, -9.38257724e-02f, -8.69521946e-02f, 1.50265291e-01f, 7.60980546e-02f,
  1.34663343e-01f, -4.35073581e-03f, -3.21123540e-01f, -6.28092736e-02f, 5.15750498e-02f, 3.74820307e-02f, 6.94817305e-02f, -2.51924902e-01f, -2.70061567e-02f, -2.48115435e-01f,
  1.05050005e-01f, -1.81271315e-01f, -4.05524969e-02f, 2.44000107e-02f, -7.00970143e-02f, -1.98239550e-01f, 5.09084761e-02f, -5.99420406e-02f, -2.53088940e-02f, 3.54268067e-02f,
  -9.41153616e-02f, 1.13422520e-01f, -4.61091958e-02f, 8.05163698e-04f, -5.88239431e-02f, 4.47882786e-02f, -4.29275259e-02f, 6.30633309e-02f, 2.20431332e-02f, 5.64848669e-02f,
  5.86142838e-02f, 1.80439055e-01f, 1.77436566e-03f, 1.84047133e-01f, 9.09905136e-02f, -1.48283103e-02f, -1.11284200e-02f, -7.57103134e-03f, 2.93296389e-02f, 8.45671922e-04f,
  3.78745943e-02f, 9.11775753e-02f, 4.44704257e-02f, -2.79531758e-02f, -7.95608684e-02f, 9.03743878e-02f, -6.57703802e-02f, -5.15280329e-02f, 1.01761431e-01f, 5.55786714e-02f,
  4.15463112e-02f, 6.10862346e-03f, -7.68101066e-02f, -4.17269245e-02f, -3.09848543e-02f, 5.47198355e-02f, 3.81911034e-03f, -7.41530210e-02f, 9.67038125e-02f, 9.98078659e-03f,
  -6.81295618e-02f, -1.33286864e-01f, 5.87119125e-02f, -3.44500318e-02f, 3.04504633e-02f, 7.93923140e-02f, 1.39987916e-01f, 2.45838352e-02f, 1.28336893e-02f, 6.69647381e-02f,
  -1.57211974e-01f, -9.16157290e-02f, -1.75566256e-01f, 1.53576480e-02f, -8.81717205e-02f, 1.54618457e-01f, -2.43424140e-02f, 1.19250454e-01f, -1.68630853e-01f, 8.10737461e-02f,
  1.11861020e-01f, 8.95965174e-02f, 1.59273311e-01f, -9.07569826e-02f, -3.66274416e-02f, -6.19327165e-02f, -1.34608373e-01f, -3.73288877e-02f, -1.68846607e-01f, 9.59470645e-02f,
  -7.22461790e-02f, -3.22054587e-02f, -1.02733113e-02f, -8.13026503e-02f, -4.76538651e-02f, -5.90596832e-02f, 4.40026000e-02f, -2.74485350e-02f, 1.85516067e-02f, 4.44625020e-02f,
  2.85264067e-02f, -7.44406208e-02f, -1.85117438e-01f, -1.22154422e-01f, 8.39312002e-02f, 1.69625543e-02f, -1.80373937e-01f, 8.65017325e-02f, -8.73177275e-02f, 2.97910385e-02f,
  4.02600877e-02f, -2.71831248e-02f, -1.10414073e-01f, 1.42593682e-01f, -1.14534043e-01f, 1.35074956e-02f, -8.17192346e-02f, 7.77734490e-03f, -9.44645032e-02f, -2.34917045e-01f,
  -2.81415939e-01f, 4.24051285e-02f, 1.29474416e-01f, 6.65543973e-02f, 7.09256008e-02f, 1.42074347e-01f, -2.30184898e-01f, 1.40273795e-01f, -2.16097198e-02f, 5.29148802e-02f,
  -6.45243600e-02f, -2.39336374e-03f, 1.46645755e-01f, 9.67873856e-02f, -8.50297287e-02f, -4.87901196e-02f, -4.34033088e-02f, 1.64839372e-01f, -3.08082718e-02f, 9.22660604e-02f,
  -7.96563849e-02f, 1.32878408e-01f, -1.90880120e-01f, -6.79360181e-02f, 2.90446426e-03f, -1.08715735e-01f, -1.90388277e-01f, 1.17273945e-02f, 1.84530675e-01f, 3.13896276e-02f,
  -2.04636389e-03f, 3.23648416e-02f, 2.30706885e-01f, 4.16864119e-02f, 3.32518965e-02f, -7.60261342e-02f, -4.06421795e-02f, -2.40759701e-02f, -3.03606018e-02f, -1.89341843e-01f,
  1.21857859e-01f, -6.68356568e-02f, 1.41152777e-02f, -3.96568477e-02f, -4.20997813e-02f, 1.21787973e-01f, -8.79870430e-02f, -2.13814415e-02f, -5.86865880e-02f, -3.94121297e-02f,
  3.93320993e-02f, 2.61775516e-02f, 1.58028036e-01f, -1.45318463e-01f, 1.80024710e-02f, -7.18954057e-02f, 1.53838575e-01f, -3.00617125e-02f, 6.34300616e-03f, 6.64147735e-02f,
  2.27032248e-02f, 1.14002869e-01f, 2.64917724e-02f, 2.91547365e-02f, -1.91936597e-01f, -4.00564820e-03f, -6.21143617e-02f, 1.65247153e-02f, 1.57994449e-01f, 3.21908966e-02f,
  4.36508358e-02f, 6.16330653e-02f, 2.50687860e-02f, 1.30313680e-01f, 1.06931888e-01f, -9.23319608e-02f, -1.38518065e-01f, 1.04628392e-01f, -5.64910024e-02f, 5.11397496e-02f,
  -1.45240068e-01f, -6.51937574e-02f, 1.35728300e-01f, 2.30951503e-01f, 1.87848538e-01f, -8.00613612e-02f, -1.74905404e-01f, 1.25912026e-01f, -6.82940632e-02f, -1.20454796e-01f,
  5.68203703e-02f, -7.73295984e-02f, -1.79932669e-01f, -8.27168673e-02f, 1.06315210e-01f, 1.22161604e-01f, -1.71745196e-01f, -1.45555198e-01f, 5.15840128e-02f, -1.11845508e-01f,
  4.94193882e-02f, -4.54216786e-02f, 6.47179410e-02f, 1.89922005e-01f, -1.99057423e-02f, 8.76028743e-03f, -7.88966790e-02f, -1.56164855e-01f, 6.20349459e-02f, 6.86863214e-02f,
  2.99979616e-02f, 1.28583834e-01f, -3.97594692e-03f, 8.75970796e-02f, 3.23189087e-02f, 8.12840536e-02f, -5.79240313e-03f, -8.29300955e-02f, -5.92778660e-02f, 1.48753151e-01f,
  2.25589238e-02f, 6.48838058e-02f, 2.81411111e-01f, -7.61454627e-02f, 1.97119862e-01f, 3.59357819e-02f, 5.49281575e-02f, 1.19231589e-01f, 1.30518840e-03f, 1.02401339e-02f,
  3.87990549e-02f, -3.42636406e-02f, -1.37180761e-01f, -2.01247424e-01f, -1.13520302e-01f, -7.84429982e-02f, -1.37644976e-01f, 1.39436945e-01f, -9.55891535e-02f, 1.12365440e-01f,
  1.90265793e-02f, 2.23534722e-02f, 2.71165580e-01f, -2.15950385e-01f, 8.99538845e-02f, 2.40712091e-02f, -4.85155731e-02f, -3.74873132e-01f, 8.22316036e-02f, -1.41047798e-02f,
  7.26756752e-02f, -7.48237083e-03f, 1.53715819e-01f, 4.91781831e-02f, 8.38913489e-03f, 1.00843705e-01f, 9.22054574e-02f, 9.64828730e-02f, 8.50325674e-02f, 8.58925506e-02f,
  -1.12180442e-01f, 7.78657421e-02f, -8.29118192e-02f, 2.58239768e-02f, 1.96446016e-01f, 5.62438853e-02f, 1.91831082e-01f, 1.38282821e-01f, 6.93525672e-02f, 5.59656695e-02f,
  1.48327291e-01f, 1.18826449e-01f, 9.47328657e-02f, 7.21402168e-02f, 1.19099692e-01f, -1.11041114e-01f, 9.29951519e-02f, 2.98242029e-02f, -6.54094890e-02f, 6.81177601e-02f,
  -2.35765558e-02f, 1.08187959e-01f, 1.49618924e-01f, 3.85939218e-02f, 2.70193703e-02f, 2.22259834e-01f, 2.17042521e-01f, 7.42309242e-02f, -3.93190123e-02f, 8.47458914e-02f,
  1.92334682e-01f, 8.83982629e-02f, 6.90078782e-03f, 7.50927478e-02f, 9.35384631e-02f, 1.65545627e-01f, -3.30787264e-02f, 1.61217332e-01f, 9.61229652e-02f, 6.53294027e-02f,
  1.09085433e-01f, 1.67595401e-01f, 1.00422785e-01f, -3.98228411e-04f, -5.56823760e-02f, 2.27032304e-02f, -1.08933926e-01f, -7.06794560e-02f, 2.40515321e-02f, 3.37166376e-02f,
  -4.33853045e-02f, 1.49982467e-01f, -6.22950457e-02f, -1.46773398e-01f, -6.17755838e-02f, 1.74880907e-01f, 6.55870363e-02f, -9.21966657e-02f, 6.93674609e-02f, 8.85789394e-02f,
  -1.41754448e-01f, -2.56070316e-01f, 3.94763276e-02f, -5.06454427e-03f, -5.95129505e-02f, -4.26647477e-02f, -1.49596129e-02f, 7.43457302e-02f, 1.32186323e-01f, 7.73424283e-03f,
  -1.26253366e-01f, -1.26610920e-02f, -7.74678122e-03f, -1.05427541e-01f, 4.28042412e-02f, 3.66780572e-02f, 2.59712785e-01f, -6.32774532e-02f, 1.14519903e-02f, -1.01403698e-01f,
  -9.42265391e-02f, 1.05558529e-01f, 6.68941485e-03f, 7.03833774e-02f, -1.02634355e-01f, 8.08820054e-02f, -6.81302175e-02f, 1.09762266e-01f, -4.52442616e-02f, 2.00243682e-01f,
  -4.24387082e-02f, -3.82337421e-02f, -1.42421946e-01f, 1.56991228e-01f, 8.54176749e-03f, 1.97587788e-01f, -1.60492644e-01f, -2.31046788e-02f, 1.79801121e-01f, -4.93697822e-02f,
  -3.27105880e-01f, -7.95122236e-02f, 3.15540731e-02f, -5.97147606e-02f, 1.82516068e-01f, 1.18046487e-02f, -1.97786972e-01f, -1.82919517e-01f, 1.36699662e-01f, -1.51205864e-02f,
  8.41706172e-02f, -6.31628484e-02f, -7.24502131e-02f, 6.63811341e-02f, 1.26871228e-01f, 1.87073782e-01f, -8.41809660e-02f, 2.26112548e-02f, 3.98731560e-01f, -1.22709483e-01f,
  5.22046685e-02f, -1.32413074e-01f, -4.04454283e-02f, 5.51390089e-02f, 2.45118095e-03f, -2.72252429e-02f, -2.13672575e-02f, -6.12122640e-02f, -1.79007307e-01f, -7.25269783e-04f,
  -7.76164159e-02f, -5.57161011e-02f, -4.96979393e-02f, 3.23042683e-02f, -2.79218666e-02f, -8.30282569e-02f, 8.09289515e-02f, -8.48551765e-02f, -1.15395010e-01f, -1.01135492e-01f,
  4.57121022e-02f, -8.44708756e-02f, 3.36652324e-02f, -1.79617424e-02f, -1.90584719e-01f, -5.09351958e-03f, 1.10639103e-01f, -5.15504554e-02f, 1.22791026e-02f, -2.62989849e-02f,
  -1.38441205e-01f, 1.06361480e-02f, 1.52132902e-02f, -1.04504853e-01f, 2.89729070e-02f, -8.37715995e-03f, 8.83983355e-03f, -8.73123035e-02f, 7.22077712e-02f, 1.01794340e-01f,
  4.91871797e-02f, -8.65383819e-02f, -3.95976752e-02f, -6.34790063e-02f, -9.22663603e-03f, -4.89431284e-02f, 1.44898556e-02f, -1.05395392e-02f, 2.42711529e-02f, 1.34262899e-02f,
  -2.17921529e-02f, 1.05141141e-01f, 1.75309658e-01f, 1.51816815e-01f, 1.26717225e-01f, -2.06776820e-02f, -5.40238172e-02f, 3.05104572e-02f, -6.58337846e-02f, -2.10113347e-01f,
  1.50149211e-03f, 1.56639785e-01f, 3.50238793e-02f, 1.60859004e-02f, 7.02663362e-02f, -9.43302959e-02f, -1.30582333e-01f, 6.06895871e-02f, 6.45336658e-02f, -3.65222953e-02f,
  1.88625883e-02f, 4.11332548e-02f, -1.21349983e-01f, -3.90306078e-02f, -1.26648098e-01f, -7.30520040e-02f, -6.99999258e-02f, 2.01672278e-02f, -3.68272774e-02f, -6.88025653e-02f,
  5.33779114e-02f, -1.95176043e-02f, -2.71544494e-02f, -1.29532114e-01f, -3.04271162e-01f, -1.11997407e-02f, 2.00722385e-02f, 9.72137451e-02f, 3.99944931e-02f, 4.80660275e-02f,
  1.15033858e-01f, -4.34166426e-03f, -1.05716139e-01f, -2.73112543e-02f, 1.26901895e-01f, 7.49298022e-04f, -1.67517047e-02f, 3.95744182e-02f, 4.32603732e-02f, 1.33039728e-01f,
  1.05999194e-01f, -7.73585662e-02f, 4.63851765e-02f, -1.81421548e-01f, 6.50015175e-02f, -2.57204711e-01f, 3.68553512e-02f, -1.26259066e-02f, -2.07206219e-01f, -1.30918801e-01f,
  3.46588530e-02f, -6.05682470e-03f, 1.41123254e-02f, 1.21052042e-02f, 1.51968598e-01f, -9.84512791e-02f, -2.76418030e-01f, -1.46186473e-02f, 1.12062581e-01f, 1.72277510e-01f,
  -5.28435856e-02f, 6.74115792e-02f, 3.01475227e-01f, 1.68800429e-01f, 1.48990467e-01f, -9.51678157e-02f, 1.41285136e-01f, 2.51706362e-01f, -2.28291042e-02f, -8.09288323e-02f,
  -6.34446219e-02f, 5.62479421e-02f, -6.45036772e-02f, 7.84739703e-02f, 1.92745179e-02f, -3.64080667e-02f, 2.05379236e-03f, -3.43386712e-03f, 4.72766906e-02f, -4.40158397e-02f,
  -3.56245879e-03f, 1.35771269e-02f, -1.46671772e-01f, -1.20430522e-01f, -3.44058461e-02f, -1.16243780e-01f, -1.50839359e-01f, 3.92465070e-02f, 1.05082735e-01f, -1.22829704e-02f,
  -8.23650211e-02f, -5.33475019e-02f, 1.03148995e-02f, 5.55871474e-03f, -8.39938968e-02f, -1.97617547e-03f, 1.31591573e-01f, 1.01270244e-01f, 7.46618733e-02f, -3.40486923e-03f,
  -1.38346657e-01f, 1.21604986e-01f, 3.71548869e-02f, 1.70017499e-02f, -2.24833991e-02f, 1.26449605e-02f, 8.70607868e-02f, -1.16008951e-03f, 1.27328992e-01f, 3.12780216e-02f,
  -1.98633015e-01f, -9.71009508e-02f, 1.27556995e-01f, -1.98181555e-01f, 1.29716054e-01f, 2.43413579e-02f, -1.26764253e-01f, -6.06490076e-02f, -9.70280319e-02f, -5.93076907e-02f,
  3.93232144e-02f, -6.11646392e-04f, -4.79296967e-02f, 4.81333956e-02f, 7.08655408e-03f, -5.78912906e-02f, -1.65657662e-02f, 4.53819409e-02f, -1.63850501e-01f, -7.65817016e-02f,
  -6.99338615e-02f, 8.65936093e-03f, -1.43097773e-01f, -6.61267191e-02f, -8.18352401e-02f, -1.25776809e-02f, 6.59421459e-02f, -3.05978935e-02f, -4.84520756e-02f, 9.76731479e-02f,
  -1.53895244e-01f, -1.69604290e-02f, -2.69745290e-02f, -9.28961039e-02f, -9.52152759e-02f, -2.87311673e-02f, 1.10550839e-02f, 2.90785190e-02f, 5.24557531e-02f, -6.39204821e-03f,
  -1.29208252e-01f, -2.95885727e-02f, 3.21342237e-02f, -8.14522058e-02f, -1.75809544e-02f, -8.22020918e-02f, 3.44577595e-04f, -2.47695018e-03f, -1.73874255e-02f, 1.16723571e-02f,
  -2.52617765e-02f, -7.44534135e-02f, -3.39786056e-03f, -2.12577313e-01f, 1.20907210e-01f, -1.71342134e-01f, -2.27390230e-01f, -2.04426259e-01f, 7.25114578e-03f, 1.99937169e-02f,
  6.72422349e-02f, 1.00163206e-01f, -1.17144443e-01f, -2.20891267e-01f, 3.18113156e-02f, 4.80955355e-02f, -1.41220927e-01f, -6.17471673e-02f, 9.21680033e-02f, -9.66400430e-02f,
  -2.20150545e-01f, 1.53809816e-01f, 3.07312429e-01f, 1.61072195e-01f, -3.46962601e-01f, -1.40266269e-02f, 3.89166735e-02f, 7.94427916e-02f, -2.96856910e-02f, -6.91459002e-03f,
  1.60505518e-01f, -3.67932916e-01f, 3.24383192e-02f, 1.45668104e-01f, 1.17719628e-01f, 3.31160665e-01f, 1.31988719e-01f, -1.89896079e-03f, -4.17038538e-02f, -3.75623107e-02f,
  -1.17268758e-02f, 8.34400505e-02f, -6.17677765e-03f, 4.65543196e-03f, 2.37348620e-02f, 6.84205815e-02f, -2.89957020e-02f, 6.80870488e-02f, 6.31441101e-02f, 9.73531678e-02f,
  -2.58686543e-02f, -4.55625728e-02f, -4.36345721e-03f, 4.94111329e-02f, -2.24024523e-02f, -8.57139453e-02f, 1.69980243e-01f, 6.17236905e-02f, -3.69158424e-02f, 3.33976559e-02f,
  -5.94864599e-02f, 7.78700113e-02f, -7.68081471e-03f, -2.46089343e-02f, 5.09587079e-02f, -9.97935701e-03f, -6.59080893e-02f, -5.18884463e-03f, -5.93499094e-02f, 5.05845658e-02f,
  -1.95905901e-02f, -9.96283069e-02f, -1.24641890e-02f, 2.30787341e-02f, 7.73227541e-03f, -5.01761436e-02f, -2.90737152e-02f, 7.03885108e-02f, 1.91581041e-01f, 1.16537549e-01f,
  7.89205730e-02f, 6.12981915e-02f, 4.87868935e-02f, 6.67424425e-02f, 1.62227482e-01f, -8.43808204e-02f, -1.20173559e-01f, 1.36419773e-01f, 4.32764478e-02f, 1.44900262e-01f,
  1.60396192e-02f, -3.72786000e-02f, 1.66866943e-01f, 1.18834041e-01f, -3.42993475e-02f, 3.02378871e-02f, -1.27169281e-01f, 1.08372241e-01f, -4.17607352e-02f, 4.95490618e-02f,
  -8.74028206e-02f, -1.32902518e-01f, -1.57307073e-01f, 1.00021042e-01f, 1.04179569e-01f, -1.84585080e-01f, -1.00472488e-01f, 7.04887509e-02f, -1.81895047e-01f, 2.58375034e-02f,
  7.60451481e-02f, 4.79058176e-02f, 2.02786848e-01f, 6.56548366e-02f, -4.82007116e-02f, -9.35256332e-02f, -9.53111723e-02f, -1.48228437e-01f, 8.58209133e-02f, 1.03895932e-01f,
  -2.50456040e-03f, 6.96206987e-02f, -1.50691584e-01f, 1.76101491e-01f, -1.50868416e-01f, 2.98804268e-02f, 2.69776713e-02f, 1.11453839e-01f, -3.79618965e-02f, 3.22737359e-02f,
  2.27307212e-02f, 2.14482397e-02f, -5.96011467e-02f, 2.18635332e-02f, -4.38809097e-02f, 1.23931598e-02f, -2.86962390e-02f, 9.77331400e-02f, -2.10985184e-01f, -1.32068083e-01f,
  -1.78758845e-01f, -2.17943668e-01f, 1.35401249e-01f, 4.49131504e-02f, -1.60402939e-01f, 9.60222036e-02f, -8.39948729e-02f, 4.46573682e-02f, 1.32736824e-02f, -1.57194061e-03f,
  1.51837468e-01f, 9.88698676e-02f, -8.90244916e-02f, 2.16230914e-01f, 1.11961737e-01f, -3.80686298e-02f, 8.05133879e-02f, 1.67112544e-01f, -1.42891139e-01f, -1.98604852e-01f,
  1.47981822e-01f, -2.94082221e-02f, 1.11634277e-01f, 3.28997582e-01f, 7.73386210e-02f, 5.69843352e-02f, 9.08995196e-02f, -1.80609636e-02f, -2.63967011e-02f, 2.66118031e-02f,
  -8.06438848e-02f, -3.80282700e-02f, 1.92415833e-01f, 9.06372294e-02f, 5.56447282e-02f, 6.30479082e-02f, -1.36190746e-02f, 4.92544696e-02f, -1.26914559e-02f, 1.26090676e-01f,
  -2.00557783e-02f, -8.81943777e-02f, 5.21318354e-02f, -2.50139330e-02f, -1.28604323e-01f, -8.05554017e-02f, 8.89044181e-02f, 7.48685449e-02f, 5.62108420e-02f, -1.27556518e-01f,
  -5.07210530e-02f, -2.15801820e-02f, 1.49528190e-01f, -1.62341893e-01f, 2.14580316e-02f, -3.76828872e-02f, 8.55518356e-02f, -5.22307493e-02f, -4.70673665e-02f, -5.62496036e-02f,
  -6.67362893e-03f, 8.30408931e-02f, -1.66207720e-02f, 2.42754277e-02f, -1.21542916e-01f, -7.37420842e-02f, -5.14615141e-02f, -2.00620480e-02f, 8.40841755e-02f, 6.87438324e-02f,
  -7.50048310e-02f, 4.41236608e-02f, -6.80819824e-02f, 5.52649014e-02f, -2.76069026e-02f, -5.81617802e-02f, -4.82573099e-02f, -1.65472463e-01f, -1.43880472e-01f, -1.41715594e-02f,
  -3.52968797e-02f, 6.02755845e-02f, 3.43179591e-02f, 1.05916925e-01f, 3.26222815e-02f, -2.31023524e-02f, -1.48466006e-01f, -9.62933749e-02f, -5.44524640e-02f, -1.54291829e-02f,
  1.81415841e-01f, 2.63556764e-02f, 1.41845373e-02f, 1.43707972e-02f, 1.32317275e-01f, 2.38648430e-02f, 2.00494360e-02f, -2.87637115e-02f, -9.63472277e-02f, -9.92671922e-02f,
  -5.96484318e-02f, 4.70373221e-02f, 2.44405698e-02f, 1.76524043e-01f, -5.49592078e-02f, -7.12846145e-02f, 3.37758139e-02f, -9.74906012e-02f, 8.32900703e-02f, 3.84376049e-02f,
  -1.33790866e-01f, 5.25849052e-02f, 2.03371402e-02f, 3.95509750e-02f, 5.11179753e-02f, 1.22418106e-02f, 8.62458721e-02f, 2.02275738e-02f, -7.64023811e-02f, 3.59555557e-02f,
  1.32754548e-02f, -4.74343542e-03f, 1.58191994e-01f, -3.30596827e-02f, 2.93922778e-02f, -7.08132833e-02f, -7.38363639e-02f, 2.03986257e-01f, 1.94804162e-01f, 7.12602139e-02f,
  -4.35116775e-02f, 6.57368153e-02f, -1.12590343e-02f, 6.14507012e-02f, 2.05304045e-02f, -1.00303814e-01f, 1.42712221e-01f, -1.87021662e-02f, 1.18103884e-02f, -1.51037320e-01f,
  3.39246660e-01f, 7.48675317e-02f, 4.72753793e-02f, -8.75890534e-03f, -5.60539030e-02f, -1.20034032e-01f, 1.38279349e-01f, -2.25560024e-01f, 9.75239743e-03f, -8.12499672e-02f,
  2.15281159e-01f, -4.64761496e-01f, -2.36810986e-02f, -1.75972823e-02f, -4.38468205e-03f, 8.87276046e-03f, 1.45213023e-01f, 1.06997736e-01f, 1.19357452e-01f, -5.63826971e-02f,
  -3.71976830e-02f, 5.54147996e-02f, 2.53145583e-02f, -1.70468986e-02f, -2.46322043e-02f, 5.58538102e-02f, 6.44718558e-02f, -6.89604059e-02f, 2.34887525e-02f, 1.12805687e-01f,
  9.38100442e-02f, 5.29553182e-02f, -7.83922374e-02f, -1.33229867e-02f, 9.43102613e-02f, -1.73685417e-01f, 8.35087523e-02f, 1.00245878e-01f, -8.07887912e-02f, 1.67674750e-01f,
  -1.48668757e-03f, 3.21229547e-02f, -1.38557747e-01f, -5.03274426e-02f, 1.00261375e-01f, -1.56756397e-02f, 3.86059731e-02f, -1.43540986e-02f, -2.84341238e-02f, -1.51878417e-01f,
  -4.33125235e-02f, 4.26708953e-03f, -1.74829036e-01f, 2.21907757e-02f, 8.81808475e-02f, 1.24214709e-01f, 1.94233492e-01f, 8.73069018e-02f, 4.30567563e-02f, 4.61594537e-02f,
  1.11536898e-01f, 3.11413314e-02f, 8.43019858e-02f, -6.94106668e-02f, 2.45760828e-02f, 1.95449322e-01f, -6.87345192e-02f, -2.00986952e-01f, -3.41294892e-02f, 3.91039066e-02f,
  -1.06788218e-01f, 9.52339247e-02f, -4.32355925e-02f, -1.00366756e-01f, -3.63309756e-02f, 1.52806610e-01f, 2.83582751e-02f, -1.29400820e-01f, 2.58759797e-01f, -1.51721276e-02f,
  -1.15468109e-03f, -1.16142608e-01f, -1.04154468e-01f, -2.67177727e-02f, 7.76757300e-02f, 6.32794127e-02f, -4.19001505e-02f, -1.37631120e-02f, 1.89939827e-01f, -3.50914970e-02f,
  -3.78382695e-03f, -1.97947305e-02f, 1.41987398e-01f, 8.57710019e-02f, 2.37077381e-02f, 2.68100016e-02f, -1.73807684e-02f, -9.38823149e-02f, 2.30902016e-01f, -2.54745334e-01f,
  3.07970680e-02f, 1.21859089e-01f, 5.46227861e-03f, -6.66914582e-02f, -1.02637291e-01f, 3.50105204e-02f, 4.01759706e-02f, 8.62123296e-02f, -1.15125269e-01f, 2.07946837e-01f,
  -1.12264775e-01f, 3.18463966e-02f, -1.18590809e-01f, -1.49928257e-01f, 1.25965948e-04f, -8.20679292e-02f, -2.71727324e-01f, 1.32259205e-01f, 1.43486425e-01f, 1.39741646e-02f,
  -3.53252172e-01f, -3.59092951e-02f, -1.69432461e-01f, -1.95157081e-02f, -5.50851459e-04f, -8.32369402e-02f, -2.84441084e-01f, -1.51558235e-01f, -1.86483935e-01f, -1.28414854e-01f,
  2.70031691e-01f, -3.39855142e-02f, -6.48089796e-02f, -9.74709913e-02f, 1.86924145e-01f, 4.38930020e-02f, -4.24692146e-02f, -2.71315854e-02f, 1.25726536e-01f, 2.70554870e-01f,
  3.84165943e-02f, -8.18497986e-02f, 8.26829392e-03f, -2.48384458e-04f, -7.53160119e-02f, -6.74065948e-02f, 8.29610452e-02f, -6.79232478e-02f, 3.42150033e-02f, 5.90557456e-02f,
  5.92103787e-02f, -2.58152317e-02f, 3.03698555e-02f, -1.12884209e-01f, 3.08587421e-02f, -5.81729505e-03f, 7.62699097e-02f, -8.53317901e-02f, -1.17591262e-01f, 9.63030308e-02f,
  -1.06854677e-01f, -2.46616378e-02f, -1.75523549e-01f, -2.19231378e-02f, -2.59375926e-02f, 2.13828813e-02f, 1.10775694e-01f, -6.85189962e-02f, -8.52011964e-02f, -1.13728538e-01f,
  -5.88160791e-02f, -4.94588204e-02f, 4.48916107e-02f, -3.32299136e-02f, -5.91518991e-02f, 8.58713463e-02f, 1.03363711e-02f, 6.21920265e-02f, 5.68769239e-02f, -1.44004166e-01f,
  -7.89377019e-02f, 2.28661716e-01f, -5.79437688e-02f, -1.29504094e-03f, 6.91308528e-02f, -1.78502984e-02f, -4.17956710e-02f, -6.83055371e-02f, 3.43061984e-02f, -7.20041618e-02f,
  1.66311458e-01f, 1.32089676e-02f, 1.50552869e-01f, 2.28475586e-01f, 6.83868229e-02f, 2.31458023e-01f, 2.79445890e-02f, -6.38872311e-02f, -1.99118748e-01f, -2.10215300e-01f,
  6.73659295e-02f, -1.93427682e-01f, 4.21150550e-02f, 2.23155826e-01f, -2.62044743e-02f, -7.08156265e-03f, 2.64643990e-02f, 6.40948191e-02f, -1.12836435e-01f, 9.87198427e-02f,
  -1.67759508e-01f, 6.26926357e-03f, 1.36348335e-02f, -1.00917973e-01f, -3.86920646e-02f, 1.58334047e-01f, -1.19045869e-01f, 3.60580422e-02f, 7.52379149e-02f, -4.76540029e-02f,
  -9.47721675e-03f, 3.08121234e-01f, -3.17121595e-02f, 8.72635692e-02f, -1.58157200e-01f, 1.38458526e-02f, 1.49790242e-01f, -2.15662017e-01f, 6.58346191e-02f, -5.30113876e-02f,
  -6.19270131e-02f, 5.40694334e-02f, -1.00068972e-01f, -1.57602757e-01f, -1.92794129e-02f, -2.01922089e-01f, 1.36342376e-01f, 2.10992470e-01f, -2.04204127e-01f, -1.37569994e-01f,
  -2.45513283e-02f, 1.84001222e-01f, -5.59081510e-02f, -1.64340258e-01f, -8.71948451e-02f, -1.10049427e-01f, 6.67660162e-02f, 2.15491906e-01f, -1.77665487e-01f, -6.23118132e-02f,
  1.89439267e-01f, 7.49897510e-02f, 2.03197636e-02f, -6.93554506e-02f, -1.48344070e-01f, -9.57869887e-02f, -3.25033009e-01f, 8.47048014e-02f, 6.11900166e-02f, -1.91440955e-02f,
  -1.22360159e-02f, 6.72240853e-02f, -1.16073519e-01f, 3.77657898e-02f, -4.85932454e-02f, -3.63418125e-02f, -9.43851024e-02f, 3.53082746e-01f, 2.66256511e-01f, -7.05075711e-02f,
  2.17134785e-02f, -1.01476006e-01f, -4.84055169e-02f, -1.01617195e-01f, -4.31968421e-02f, 4.00355347e-02f, -1.32724702e-01f, -7.05535486e-02f, -2.16734689e-02f, 6.72004744e-02f,
  -3.87558639e-02f, 1.19470824e-02f, -4.92727458e-02f, -1.28844440e-01f, -6.59824535e-02f, 5.32239042e-02f, -2.15495955e-02f, -1.37004897e-01f, 1.00142583e-01f, -7.40565062e-02f,
  1.03075571e-01f, 2.14852616e-01f, -3.91405784e-02f, 1.17902644e-02f, -5.95433861e-02f, -5.94933853e-02f, -6.93427911e-03f, 3.89868859e-03f, -7.36803189e-02f, -6.21723384e-02f,
  5.47191985e-02f, 4.83972864e-04f, -4.26187217e-02f, 3.94600853e-02f, -7.78143108e-02f, 1.37536107e-02f, 1.41560748e-01f, -5.70022427e-02f, 7.47606605e-02f, 9.17659998e-02f,
  -1.05570801e-01f, 1.36691099e-02f, 1.52350767e-02f, -1.03397764e-01f, -4.12421161e-03f, -5.80395982e-02f, 6.86802715e-02f, -7.59463981e-02f, -2.34984718e-02f, -1.67645682e-02f,
  1.48644120e-01f, 1.27519503e-01f, 1.98315367e-01f, 1.31327853e-01f, 1.76707253e-01f, -1.02794230e-01f, 4.03340571e-02f, -2.62578160e-01f, -2.42333040e-01f, 1.55969650e-01f,
  1.06680043e-01f, -2.28681508e-02f, -7.07207946e-03f, 3.54550295e-02f, -1.46818876e-01f, -6.17071241e-02f, 1.93339989e-01f, 5.73116988e-02f, 2.98771132e-02f, 1.02348357e-01f,
  4.95044477e-02f, -2.04615090e-02f, 9.96696502e-02f, 9.70662460e-02f, 8.99583548e-02f, 3.00103612e-03f, -5.07668369e-02f, -5.77128120e-02f, 4.42378521e-02f, -1.01400696e-01f,
  -4.66590049e-03f, -4.22848277e-02f, -5.07856312e-04f, 1.58228248e-01f, -1.36059165e-01f, 1.52135938e-01f, 2.95726471e-02f, -7.99227878e-02f, -8.83237123e-02f, -4.53661382e-03f,
  -1.42112687e-01f, -2.17802431e-02f, -9.38157514e-02f, -1.60798535e-01f, 4.82545681e-02f, -2.11005151e-01f, -1.89763799e-01f, 7.35733807e-02f, -4.54041697e-02f, 1.67666713e-03f,
  -9.47640911e-02f, -1.38155833e-01f, 3.50597911e-02f, -2.76014566e-01f, -2.53375918e-01f, 9.41883326e-02f, -5.43793663e-02f, -1.17158540e-01f, 9.51062366e-02f, 1.88263759e-01f,
  2.96408147e-01f, 1.40377566e-01f, 1.88573807e-01f, -1.38239758e-02f, -1.90502331e-01f, 1.54923469e-01f, 3.46005745e-02f, 6.29725456e-02f, 1.52548671e-01f, 1.22015677e-01f,
  1.44786254e-01f, -1.76223263e-01f, 5.68037853e-03f, -2.75647268e-02f, 8.38993192e-02f, 2.56148368e-01f, -2.99242008e-02f, -5.01329415e-02f, -5.42302802e-02f, -1.04879208e-01f,
  -1.56446416e-02f, -4.07315157e-02f, 1.07606359e-01f, 3.63773527e-03f, -1.92266330e-01f, -1.31560951e-01f, -6.05378188e-02f, -1.10128276e-01f, -1.28244072e-01f, 7.39105716e-02f,
  -1.25481755e-01f, 1.25066459e-01f, 4.46250997e-02f, 1.62909757e-02f, -2.07856279e-02f, -1.18758827e-01f, -1.02926955e-01f, -1.01170644e-01f, 8.39425158e-03f, 2.38665808e-02f,
  1.24396689e-01f, -9.23848674e-02f, 6.28598630e-02f, -7.48592764e-02f, -1.47400692e-01f, 2.88461559e-02f, 1.67521060e-01f, -4.12071459e-02f, -6.76601008e-02f, -1.04058431e-02f,
  -1.03871897e-02f, -5.82561418e-02f, -1.75569087e-01f, -7.99671859e-02f, -2.11667456e-03f, 6.80398569e-02f, -3.21634822e-02f, -7.46760219e-02f, 1.17245145e-01f, -1.43361032e-01f,
  2.14404482e-02f, -1.40442073e-01f, -2.97290012e-02f, -2.27264747e-01f, -5.67405112e-02f, -7.51801357e-02f, -4.70889471e-02f, 1.33000895e-01f, 1.06508657e-01f, -3.93416211e-02f,
  3.32203060e-01f, -6.19594343e-02f, -4.15255465e-02f, 8.42894986e-03f, 1.16607659e-01f, -1.02010369e-01f, 3.98966782e-02f, 1.71530128e-01f, -1.04876056e-01f, -1.14766963e-01f,
  -1.38351880e-02f, -9.75039229e-03f, 9.26318914e-02f, -8.08639005e-02f, 1.48483604e-01f, 1.62561923e-01f, 5.56847155e-02f, -1.33619890e-01f, -2.27296744e-02f, 1.04241736e-01f,
  5.28246090e-02f, 4.65445966e-02f, -7.18454123e-02f, -8.75050426e-02f, -4.43909019e-02f, -1.29893720e-01f, 5.59705906e-02f, -4.69502173e-02f, 1.10565498e-02f, 1.71817467e-03f,
  5.71266469e-03f, -2.91445237e-02f, 1.58441290e-02f, 1.47877177e-02f, -7.59443343e-02f, 1.61145270e-01f, 1.28900498e-01f, -2.38008448e-03f, 1.13410279e-01f, 5.84339425e-02f,
  6.92969412e-02f, 5.81269152e-02f, 3.35846134e-02f, -1.64816648e-01f, 9.42522138e-02f, 5.24352454e-02f, 3.61355487e-03f, -9.04547647e-02f, 1.74774826e-01f, -4.73006517e-02f,
  1.53883044e-02f, 4.81073558e-02f, 3.15159075e-02f, -1.03854708e-01f, 3.38748097e-01f, 7.20912665e-02f, -1.71524379e-02f, -9.28220451e-02f, -5.49353883e-02f, -1.26554772e-01f,
  1.34425834e-02f, -6.12956844e-02f, -1.63192689e-01f, -1.35107055e-01f, 1.34464443e-01f, 1.11311644e-01f, -1.05420850e-01f, 3.67301255e-02f, 1.27400324e-01f, 1.41143426e-01f,
  -1.16027199e-01f, -8.01247954e-02f, -3.14290971e-01f, 6.53994754e-02f, -4.85165827e-02f, -7.57405236e-02f, -4.03801277e-02f, -5.64434156e-02f, 4.27972488e-02f, 1.41261537e-02f,
  -1.34632975e-01f, -8.64978060e-02f, -9.02786702e-02f, 1.01598054e-01f, 6.05571717e-02f, -8.31819028e-02f, -8.85979906e-02f, -2.93003712e-02f, -4.56435829e-02f, 5.63382031e-03f,
  -3.63128334e-02f, -8.10976699e-02f, 4.27202731e-02f, 3.04153375e-02f, 2.31240168e-02f, -2.46479195e-02f, 1.21655323e-01f, 5.67225441e-02f, -8.19173157e-02f, 3.78833115e-02f,
  -2.63448525e-02f, 2.60442495e-02f, 2.00755280e-02f, 1.00998767e-01f, -9.39914435e-02f, -1.12367325e-01f, 9.52909365e-02f, 4.82323095e-02f, 2.55675837e-02f, 1.94055066e-02f,
  1.53329521e-01f, 4.87923482e-03f, 2.24932488e-02f, 8.46115574e-02f, 1.27779037e-01f, -1.91501290e-01f, -9.20574218e-02f, -4.02268618e-02f, 6.22273870e-02f, 8.63403007e-02f,
  5.39291650e-03f, -3.41280736e-02f, 6.78132027e-02f, 1.27511516e-01f, 9.18138213e-03f, 1.81469694e-01f, 9.72610563e-02f, -7.60000432e-03f, 1.04647666e-01f, -7.75799155e-02f,
  -3.16339009e-03f, 8.23865160e-02f, -4.66544181e-03f, -8.89673363e-03f, -1.02773711e-01f, 7.14442581e-02f, -5.76533601e-02f, -4.07819748e-02f, 3.83455865e-02f, -3.24186832e-02f,
  1.80562783e-03f, 1.42690288e-02f, -2.95953918e-02f, -1.69643566e-01f, -3.44605278e-03f, -5.31633906e-02f, 7.75334835e-02f, 4.59855273e-02f, -1.11707084e-01f, -3.39136273e-02f,
  -1.18606329e-01f, -1.26788244e-01f, -1.20227367e-01f, -4.36173566e-02f, 7.11355880e-02f, 1.83655396e-02f, 1.30187377e-01f, -4.98036779e-02f, -5.19260131e-02f, 2.70558875e-02f,
  6.46357313e-02f, -7.85609633e-02f, 6.02433400e-04f, 7.51607418e-02f, -1.28757469e-02f, -6.38681278e-03f, -7.84035698e-02f, 1.51450723e-01f, 5.90140149e-02f, 2.83146128e-02f,
  -7.07536563e-02f, 8.39155018e-02f, 1.48670077e-01f, -5.98880537e-02f, -9.26593617e-02f, 3.26716155e-02f, 5.92173003e-02f, 1.45960942e-01f, -1.11621723e-01f, 1.94550008e-01f,
  7.56619200e-02f, 1.19900659e-01f, 2.76127279e-01f, 1.09270371e-01f, -2.68187404e-01f, 2.93286555e-02f, -1.90360546e-01f, -6.22591823e-02f, -6.68372512e-02f, 6.13238253e-02f,
  -9.64924991e-02f, -4.86177653e-02f, 5.56789897e-02f, 1.46014780e-01f, 9.88353714e-02f, -2.38737874e-02f, 2.89330363e-01f, 3.13398749e-01f, 6.06289506e-02f, 1.31211989e-02f,
  -2.04699710e-01f, 4.20982353e-02f, 8.65431800e-02f, -7.74833560e-02f, 5.90196848e-02f, -3.15534584e-02f, -3.16797979e-02f, -1.96361840e-02f, 4.35483605e-02f, 4.20146473e-02f,
  4.37103622e-02f, 1.39218226e-01f, -7.20766634e-02f, 9.04196315e-03f, -3.61757725e-02f, 4.22154479e-02f, 3.54604945e-02f, -1.64378524e-01f, 6.25086725e-02f, -6.36442506e-04f,
  6.33614510e-02f, -3.20785157e-02f, 9.35568586e-02f, 2.17920449e-02f, -1.96569040e-01f, 7.18294084e-02f, 2.31714789e-02f, 1.40563846e-01f, 1.00332856e-01f, 6.12563826e-02f,
  8.50816444e-02f, 1.36974184e-02f, -6.78894147e-02f, 2.99375411e-02f, -5.91615727e-03f, 5.94996326e-02f, 1.33602068e-01f, 8.88859183e-02f, -3.20441872e-02f, -7.26479292e-02f,
  5.82266524e-02f, -3.61074097e-02f, -7.16796741e-02f, 2.62762278e-01f, -1.31033901e-02f, 4.00613099e-02f, 9.54800919e-02f, -7.99379349e-02f, -1.92716923e-02f, -7.46189207e-02f,
  4.36423458e-02f, -5.12554012e-02f, 6.94285929e-02f, -1.69094905e-01f, 8.10305029e-02f, 3.69097181e-02f, -8.36269185e-02f, 1.81486174e-01f, 2.38722265e-01f, 1.15002684e-01f,
  5.40963039e-02f, 1.54344559e-01f, -1.21883027e-01f, -6.35507256e-02f, 6.89544082e-02f, -8.19322392e-02f, -1.55881211e-01f, -1.05483986e-01f, 6.67988136e-02f, -5.13461381e-02f,
  -1.01828404e-01f, 4.95964773e-02f, -1.06860049e-01f, 1.75082624e-01f, 2.24459195e-03f, -1.42758965e-01f, 7.96806142e-02f, -4.10426669e-02f, -9.34020728e-02f, 1.09981060e-01f,
  -9.29411277e-02f, -7.42277887e-04f, 9.35664251e-02f, 1.17713936e-01f, -7.55214542e-02f, 1.86477363e-01f, 1.44994274e-01f, 1.26840279e-01f, -1.58327557e-02f, 8.56990889e-02f,
  1.40174687e-01f, -1.12516815e-02f, -1.45137966e-01f, 1.44480780e-01f, -7.53773823e-02f, 7.36546218e-02f, -1.68385938e-01f, 8.84920806e-02f, 6.83968812e-02f, 2.17970192e-01f,
  -1.12790212e-01f, -2.20194370e-01f, 1.02046430e-01f, 9.80665460e-02f, -1.84074163e-01f, -6.27136603e-02f, 1.03906251e-01f, -1.97077245e-01f, 4.76763137e-02f, -1.96182798e-03f,
  -2.38807544e-01f, -3.43815088e-02f, -4.46386859e-02f, 1.15266427e-01f, 1.03187419e-01f, -1.39002547e-01f, 1.55395448e-01f, 3.12185865e-02f, -9.81006697e-02f, 1.84186652e-01f,
  2.72723526e-01f, -4.28514443e-02f, 1.69211850e-02f, 6.82866154e-03f, -6.16620779e-02f, -4.32205796e-01f, 3.42568196e-02f, -1.35896608e-01f, 3.80640149e-01f, 2.36258581e-01f,
  -9.71207488e-03f, 6.99606314e-02f, 1.30924016e-01f, 6.04652949e-02f, -1.26143187e-01f, -7.20955580e-02f, 5.07326350e-02f, -1.66232273e-01f, 5.88189289e-02f, -1.91541612e-02f,
  -3.51288676e-04f, 7.43828043e-02f, 9.81353521e-02f, -1.73438750e-02f, -4.66374680e-03f, 5.25045656e-02f, 9.68210846e-02f, -1.31643727e-01f, 2.43000891e-02f, -3.15347873e-02f,
  -3.77347507e-02f, 6.54088110e-02f, -1.52233578e-02f, 1.81484390e-02f, 5.52750677e-02f, 2.17141639e-02f, -5.11475326e-03f, 1.55925620e-02f, 2.17398815e-02f, -2.97659431e-02f,
  4.27586548e-02f, 4.20018621e-02f, 7.19338432e-02f, 2.54395287e-02f, 1.71534091e-01f, -1.20572165e-01f, -2.07971875e-02f, -1.15916893e-01f, 4.01630923e-02f, 5.46175316e-02f,
  -6.25870898e-02f, -3.14544588e-02f, 3.95819061e-02f, -5.00732251e-02f, 1.82190798e-02f, 1.26018301e-01f, 9.83313657e-04f, -7.06420653e-03f, -7.53194988e-02f, 9.14805904e-02f,
  4.94138636e-02f, 5.20185456e-02f, -1.25027224e-01f, -2.85009027e-01f, -4.12579954e-01f, -6.20554760e-02f, -2.14009341e-02f, 2.46368125e-02f, -3.94840427e-02f, 2.01273233e-01f,
  2.31214926e-01f, -3.15838568e-02f, -1.55051351e-01f, 1.40097188e-02f, 1.31748438e-01f, 2.52963066e-01f, 3.17655802e-02f, -3.65608223e-02f, -2.58071851e-02f, -3.82522284e-03f,
  1.10254727e-01f, 1.03944890e-01f, -7.13183507e-02f, -1.09752484e-01f, -3.96485776e-02f, 5.30715808e-02f, -3.55205834e-02f, 6.35775402e-02f, -2.07361970e-02f, 1.90961152e-01f,
  2.26858817e-02f, 1.20350473e-01f, 1.46730632e-01f, -2.06881855e-02f, 1.01588167e-01f, -3.92772965e-02f, -1.19633816e-01f, -1.31712124e-01f, 6.53004199e-02f, -8.39715600e-02f,
  -6.56852648e-02f, -1.50295850e-02f, -1.07862972e-01f, 2.35544462e-02f, -8.44378248e-02f, 4.28071171e-02f, -2.75336336e-02f, 1.12007827e-01f, -4.67665028e-03f, -2.28747338e-01f,
  -3.98906916e-02f, 7.04755634e-03f, -1.51755974e-01f, 1.72068790e-01f, -1.34928197e-01f, 5.03280945e-02f, -1.57797914e-02f, -3.00864521e-02f, -8.77915099e-02f, 2.68862792e-03f,
  -1.04955651e-01f, 7.43535385e-02f, 2.82038510e-01f, 3.09946984e-02f, -6.39241785e-02f, -2.02907566e-02f, 3.61942410e-01f, 2.66514659e-01f, -1.44543752e-01f, -1.47105873e-01f,
  -4.33213376e-02f, 4.98080216e-02f, -2.45609075e-01f, -3.34273070e-01f, -1.36560827e-01f, 1.04332291e-01f, -3.23726952e-01f, -3.49848121e-02f, -4.25035581e-02f, -1.19818702e-01f,
  2.38565709e-02f, 5.94654027e-03f, -1.34574980e-01f, 8.14148225e-03f, 5.79358041e-02f, -4.72552143e-02f, -6.17578067e-02f, -5.90097420e-02f, 2.37477832e-02f, -1.13500599e-02f,
  1.79849323e-02f, -1.41205490e-01f, -8.71203318e-02f, -3.55897732e-02f, 1.35623887e-01f, -7.32392222e-02f, 7.58233815e-02f, 7.53665939e-02f, -4.15760241e-02f, 5.60927019e-02f,
  5.25344163e-02f, -2.95176934e-02f, -1.41993389e-01f, 8.91034156e-02f, 1.12316109e-01f, -1.65627673e-02f, 1.74870253e-01f, 1.81085039e-02f, -3.79485898e-02f, 9.43743885e-02f,
  -2.72319671e-02f, -8.61481279e-02f, -2.70774737e-02f, -6.11613579e-02f, -4.53295559e-02f, -2.61696149e-02f, -4.52812836e-02f, -7.35477656e-02f, -7.67217502e-02f, 3.90406512e-02f,
  1.53780682e-03f, -1.34948403e-01f, -1.21819656e-02f, -9.20366030e-03f, 9.61094275e-02f, -4.54719104e-02f, -3.28741893e-02f, -1.64947473e-02f, -9.58860889e-02f, -1.14655271e-01f,
  3.79143506e-02f, 1.30892113e-01f, -2.49119312e-01f, 9.86469984e-02f, -9.38509405e-02f, -1.94904089e-01f, 5.27229309e-02f, 3.79468910e-02f, 5.07621281e-02f, -1.12637088e-01f,
  -5.04053645e-02f, 1.29332915e-01f, 5.10927336e-03f, 2.95921773e-01f, -2.71097906e-02f, 2.81688967e-03f, -1.35179469e-02f, 6.74691470e-03f, -1.66597851e-02f, 8.12392160e-02f,
  1.19595893e-01f, -1.62549302e-01f, 1.87572911e-01f, 1.87044352e-01f, -1.93170551e-03f, -1.47567660e-01f, -7.24536479e-02f, 9.39452574e-02f, -1.12652257e-02f, 7.57005215e-02f,
  -1.78837299e-01f, -2.65500303e-02f, 4.45823036e-02f, 8.56083483e-02f, 8.02631751e-02f, 3.39262523e-02f, 1.82769910e-01f, 2.09372807e-02f, 3.88563722e-02f, 2.33771205e-02f,
  8.02325234e-02f, -4.60317694e-02f, -2.69018356e-02f, 1.57982688e-02f, 1.98270515e-01f, -1.79900780e-01f, -2.41953526e-02f, 3.67553160e-02f, 1.83370754e-01f, 1.51050195e-01f,
  8.23994279e-02f, 3.67133729e-02f, 1.14499442e-01f, 1.45379618e-01f, -5.43498755e-01f, 3.14604454e-02f, -1.05564319e-01f, -2.62770746e-02f, 1.33625388e-01f, 1.01102993e-01f,
  8.80527347e-02f, 2.21754819e-01f, -1.27602413e-01f, 1.52768120e-01f, 1.50758967e-01f, 1.92576453e-01f, -1.14354827e-01f, 6.85156286e-02f, 6.60103038e-02f, -4.95425239e-02f,
  -2.91075528e-01f, -8.09146911e-02f, 1.51529506e-01f, 1.79358736e-01f, -3.79235357e-01f, 1.46134585e-01f, -5.85059933e-02f, 2.35209311e-03f, 1.82783455e-02f, 4.52358425e-02f,
  1.29440561e-01f, 1.60821229e-01f, 1.09439166e-02f, -1.02835223e-01f, 5.74069917e-02f, 2.79667657e-02f, 1.01329871e-01f, 3.90742607e-02f, -9.72323120e-03f, -1.08054079e-01f,
  1.68377999e-02f, 2.27521136e-02f, -5.82357273e-02f, 3.03246435e-02f, -1.63083002e-01f, 5.77525236e-02f, 2.38923505e-02f, 8.28464851e-02f, 8.13201349e-03f, 1.05485646e-02f,
  8.71476904e-02f, -5.04450910e-02f, -7.66603500e-02f, 5.16606681e-03f, 1.27003506e-01f, 5.37193147e-03f, -1.53671056e-02f, 7.05713108e-02f, -6.52299146e-04f, 4.59528342e-02f,
  1.36654332e-01f, 2.11228505e-01f, 1.80235691e-02f, 5.23942895e-02f, 7.88587928e-02f, 7.05163402e-04f, 6.00355975e-02f, 2.04818305e-02f, 3.52860764e-02f, -7.62757808e-02f,
  -1.66446306e-02f, 1.24907888e-01f, 7.21055865e-02f, -3.33701707e-02f, -1.00849368e-01f, 3.16083208e-02f, 1.08847599e-02f, -3.05808149e-02f, -1.86775878e-01f, 2.50614524e-01f,
  -5.21994829e-02f, 8.54844972e-02f, -8.56570154e-02f, -4.24117260e-02f, -5.89016564e-02f, 5.23946658e-02f, -2.31452081e-02f, -1.24679133e-01f, 1.06546700e-01f, 8.03668797e-02f,
  1.66615933e-01f, -3.79213244e-02f, -5.35605066e-02f, -2.51460131e-02f, -9.53730717e-02f, 2.42947359e-02f, -6.47297278e-02f, 9.35030058e-02f, -5.33762462e-02f, -1.65748045e-01f,
  -5.53751830e-03f, -1.32521823e-01f, -1.07837163e-01f, 4.18560803e-02f, -1.16836376e-01f, 8.49559307e-02f, 1.48876950e-01f, 1.08320467e-01f, -1.25884175e-01f, -5.16302735e-02f,
  9.41688754e-03f, 4.39343005e-02f, -4.97288741e-02f, 9.33594722e-03f, 1.03076793e-01f, 1.16391018e-01f, 3.20258178e-02f, -1.17291220e-01f, 8.53934959e-02f, -1.33751184e-01f,
  -3.02641112e-02f, -4.82834801e-02f, 7.91834146e-02f, 3.68789546e-02f, 7.00931996e-02f, -6.36177436e-02f, 2.06720039e-01f, -9.15580317e-02f, 2.56774783e-01f, -1.66198954e-01f,
  2.61808544e-01f, 1.43905487e-02f, -2.45532915e-01f, 1.24402560e-01f, -2.93605596e-01f, -1.56889632e-01f, 2.35069901e-01f, 2.03523591e-01f, -5.52354567e-02f, 8.65665674e-02f,
  -2.70789832e-01f, -1.76964775e-02f, -2.38079019e-02f, 4.87281792e-02f, 1.64152086e-01f, -2.25692376e-01f, 5.56122959e-02f, -1.41122313e-02f, 3.16508710e-02f, -1.43343583e-01f,
  7.10215047e-02f, 9.76972133e-02f, 1.20176651e-01f, 1.29458174e-01f, 5.56003936e-02f, -1.39509887e-01f, -1.11711353e-01f, 9.72935632e-02f, -1.14586547e-01f, -6.77615553e-02f,
  1.06937729e-01f, -7.26937652e-02f, -3.59594710e-02f, 1.79429561e-01f, 8.28992277e-02f, 8.24786946e-02f, -1.09062567e-01f, -1.52523592e-01f, -7.66741037e-02f, -1.68493345e-01f,
  -1.41480520e-01f, -3.22930589e-02f, -1.86194465e-01f, 4.65542637e-02f, -3.58889215e-02f, -3.01446319e-02f, -9.23888851e-03f, -6.78775460e-02f, 3.81183401e-02f, 7.30526000e-02f,
  3.77640575e-02f, 6.52576461e-02f, 2.36253619e-01f, -9.30324867e-02f, 2.90939882e-02f, -1.72441855e-01f, -2.43445002e-02f, -5.76481037e-02f, -5.37117757e-02f, -5.58104441e-02f,
  -1.61777027e-02f, 6.58467710e-02f, 5.51938787e-02f, -1.37154516e-02f, -1.32239044e-01f, 3.46412463e-03f, -6.52773008e-02f, 2.07620692e-02f, -3.91158648e-02f, 2.71634907e-02f,
  -1.28358871e-01f, 8.79619569e-02f, -3.79929021e-02f, 3.65334414e-02f, -9.19464082e-02f, -1.34305507e-01f, 7.44449049e-02f, 1.52463526e-01f, 7.07304552e-02f, -4.02358323e-02f,
  -1.92169353e-01f, -1.14876933e-01f, 4.95733581e-02f, -6.66902810e-02f, -1.92186743e-01f, -1.00806922e-01f, -1.25359595e-01f, 1.40427858e-01f, -1.59903944e-01f, -1.30505443e-01f,
  -1.95157900e-01f, 8.06356966e-02f, 2.12864220e-01f, 1.57809049e-01f, -1.66594818e-01f, -4.23177741e-02f, 3.23262177e-02f, -5.53929918e-02f, -1.14978477e-01f, -9.01117623e-02f,
  -1.59920767e-01f, -8.15912336e-02f, 7.41281733e-02f, 1.60939157e-01f, -6.60954267e-02f, 1.58205017e-01f, -3.56407285e-01f, 8.71756226e-02f, -1.15983328e-02f, 1.77154601e-01f,
  -4.34908010e-02f, -1.27034739e-01f, 8.65148604e-02f, -2.71462768e-01f, 6.77992329e-02f, -1.44171566e-01f, -7.15169534e-02f, 1.49254762e-02f, -1.84876487e-01f, -4.19589370e-01f,
  1.57773852e-01f, -1.45321786e-01f, -1.14365056e-01f, -1.01336062e-01f, 1.39926404e-01f, -1.22907041e-02f, 5.58895320e-02f, -1.00100450e-01f, 1.49106443e-01f, 1.10473499e-01f,
  -1.34103954e-01f, 9.97937694e-02f, -9.67320129e-02f, -2.96449959e-01f, 6.08711950e-02f, 9.33934376e-02f, -1.37395069e-01f, 9.98814553e-02f, 6.43912554e-02f, 1.99486911e-01f,
  -3.74836564e-01f, 1.13328017e-01f, 3.82947549e-02f, -5.42677790e-02f, 3.17314384e-03f, -1.15257680e-01f, -8.53638649e-02f, -1.96515888e-01f, -1.19126600e-03f, 4.58976962e-02f,
  -1.92126438e-01f, 3.54179472e-01f, -2.85482518e-02f, 7.95190334e-02f, 1.69497177e-01f, 1.31106079e-01f, 3.22618447e-02f, 2.12609172e-02f, -1.59123971e-04f, 6.08318821e-02f,
  5.25184907e-02f, 7.80014545e-02f, 1.18737362e-01f, -4.05623764e-03f, -2.12937761e-02f, -2.35580448e-02f, 1.28943115e-01f, 2.05389604e-01f, 2.77680121e-02f, 1.18933804e-02f,
  7.17343166e-02f, 8.78217742e-02f, -1.33905441e-01f, 6.85592089e-03f, 1.95197031e-01f, -8.05245340e-02f, 8.84973630e-02f, 2.83209793e-03f, 9.17815492e-02f, -4.30842489e-02f,
  -4.17533703e-03f, -6.62597734e-03f, -3.69240344e-02f, 9.55877081e-03f, -1.04585867e-02f, 1.45014822e-01f, 7.99857453e-02f, 1.51618674e-01f, 4.24036793e-02f, -1.09605819e-01f,
  8.00631847e-03f, 3.95302810e-02f, 1.08050562e-01f, 1.10967923e-02f, 8.08371454e-02f, 2.11063176e-02f, 1.69183850e-01f, 4.46349122e-02f, 3.65013629e-02f, -1.06818285e-02f,
  -1.95474327e-02f, -1.00299409e-02f, -1.69355068e-02f, -8.83332416e-02f, -5.38274795e-02f, -6.53708801e-02f, -1.80353686e-01f, -1.36479372e-02f, -9.88691002e-02f, 5.41436337e-02f,
  5.43013774e-02f, 1.63801610e-01f, 2.01884225e-01f, -7.52987564e-02f, -4.92474772e-02f, 1.81477800e-01f, 1.87271163e-01f, 1.49877310e-01f, 8.26021954e-02f, -7.18513578e-02f,
  -9.54557396e-03f, 1.00183645e-02f, -1.89701647e-01f, -5.75886928e-02f, 2.09951371e-01f, 5.83007894e-02f, 9.32714194e-02f, -9.53054875e-02f, -8.92028511e-02f, -2.82859728e-02f,
  -3.73205543e-02f, 1.38722155e-02f, 6.21239794e-03f, -9.47868153e-02f, 2.21716911e-02f, -9.71991867e-02f, -5.75099923e-02f, -1.93337779e-02f, 1.32813975e-01f, 6.91168085e-02f,
  -7.19604939e-02f, 1.12679839e-01f, 9.48357284e-02f, 9.23197716e-02f, 5.84428012e-03f, 1.08940955e-02f, -6.93585053e-02f, 1.13063063e-02f, 2.55071670e-02f, 4.59392816e-02f,
  1.42311826e-01f, 1.63699627e-01f, -5.98012432e-02f, 2.24959478e-01f, 1.69808269e-01f, 6.12652674e-02f, 1.03461236e-01f, 1.42903611e-01f, -2.87003487e-01f, -9.61545333e-02f,
  1.14394866e-01f, 1.64568961e-01f, 9.51324776e-02f, 9.35688540e-02f, 1.36636747e-02f, 3.35282460e-02f, -1.32444724e-01f, 8.52493495e-02f, 2.72136927e-01f, 1.59470916e-01f,
  -1.70186728e-01f, 3.97801921e-02f, 9.03307572e-02f, -1.44051790e-01f, -1.64667293e-01f, 2.04965770e-01f, -8.11656937e-02f, 8.65034759e-03f, -1.63372263e-01f, -1.70736656e-01f,
  -9.97479726e-03f, 2.07967892e-01f, 5.43686608e-03f, -8.47963989e-02f, -7.48319030e-02f, 7.83480555e-02f, 1.17008060e-01f, 9.60402340e-02f, 6.99559301e-02f, -5.82815409e-02f,
  2.47567669e-02f, -2.59585567e-02f, 7.91018456e-02f, 1.11649722e-01f, 3.04941460e-02f, 1.48441315e-01f, -4.16630097e-02f, 7.32187256e-02f, -3.85549515e-02f, -9.99193937e-02f,
  -5.94878457e-02f, 7.71812499e-02f, -8.72963108e-03f, 5.35711236e-02f, 3.52245905e-02f, 2.44831089e-02f, 6.03820803e-03f, 6.84678555e-02f, 5.10980263e-02f, -9.03908983e-02f,
  8.99565890e-02f, 7.45966285e-02f, 4.71404083e-02f, 4.34742458e-02f, 1.18930131e-01f, -4.02679071e-02f, -1.88123193e-02f, -8.22592452e-02f, 1.18388981e-01f, 3.73481549e-02f,
  -5.06603234e-02f, -2.63850950e-02f, -4.41266224e-02f, -9.81670544e-02f, -1.40092559e-02f, 1.19488910e-01f, 2.78659184e-02f, 5.13060987e-02f, -2.69769989e-02f, -6.00864775e-02f,
  -2.73881909e-02f, -7.10183382e-02f, 3.11088338e-02f, -7.55280778e-02f, 2.64843106e-02f, 5.31329848e-02f, -2.58304089e-01f, -3.42820063e-02f, 1.72504615e-02f, -2.46909365e-01f,
  -5.55864982e-02f, -3.38903479e-02f, 2.76288446e-02f, 1.34821579e-01f, 1.42067969e-01f, 9.08131152e-02f, 3.06576816e-03f, 4.11699899e-02f, 9.48233530e-02f, -1.13083804e-02f,
  1.65361509e-01f, 1.11832218e-02f, 2.44336557e-02f, -3.83357517e-02f, -2.35534403e-02f, 1.46714151e-01f, 1.53482985e-02f, -1.96893364e-01f, 1.38144074e-02f, 3.84328626e-02f,
  -3.27566043e-02f, -3.74239832e-02f, -1.28051415e-01f, -1.19993491e-02f, 4.20168741e-03f, -1.77661404e-02f, 1.35590248e-02f, 2.06392720e-01f, 4.59193178e-02f, 3.29207517e-02f,
  5.63048758e-02f, 3.16983163e-02f, -1.70870069e-02f, 3.70010920e-02f, -3.80986445e-02f, -1.41979575e-01f, 1.85556151e-02f, -2.00771376e-01f, 1.16951123e-01f, -2.40349155e-02f,
  1.37547255e-01f, 7.52446875e-02f, 8.40538554e-03f, 4.19881523e-01f, -1.24821384e-02f, -1.04745790e-01f, -3.98225844e-01f, 1.91310365e-02f, -1.69188380e-01f, -1.55127421e-02f,
  4.80291575e-01f, -7.99932145e-03f, 1.05609447e-01f, -2.45988760e-02f, -1.16172619e-01f, -9.83682051e-02f, 1.29934683e-01f, 4.49254960e-02f, -1.18135594e-01f, -1.86768577e-01f,
  -2.56555472e-02f, 6.70196936e-02f, 7.85348937e-02f, 2.19179407e-01f, -6.20626397e-02f, 3.12227495e-02f, 2.08945796e-01f, -1.40953586e-01f
};

// L1_fan_Wp_bar (Shape: 26 x 128)
const int L1_fan_Wp_bar_rows = 26;
const int L1_fan_Wp_bar_cols = 128;
const float L1_fan_Wp_bar_data[] = {
  1.63328543e-01f, 1.55631110e-01f, 2.08067775e-01f, 8.23842213e-02f, 1.37147874e-01f, 2.27644622e-01f, 5.47511429e-02f, 2.26858288e-01f, 2.76385486e-01f, 5.70255071e-02f,
  -1.47449970e-02f, 9.99355223e-03f, 1.53298870e-01f, 1.17640257e-01f, 2.32917458e-01f, -6.99195191e-02f, 2.14723442e-02f, 7.22933561e-02f, 1.05233081e-01f, 2.72668093e-01f,
  1.18932553e-01f, 2.56435156e-01f, -1.95713267e-01f, 8.95229280e-02f, 1.01159617e-01f, 1.27327010e-01f, 1.77041858e-01f, -1.27695993e-01f, 1.09341241e-01f, 2.87919104e-01f,
  1.75256103e-01f, 1.59585670e-01f, 1.55183658e-01f, 1.48818329e-01f, 1.53239518e-01f, 8.24600160e-02f, 9.83706564e-02f, 2.07732484e-01f, -6.05349429e-02f, 1.23463191e-01f,
  2.21217677e-01f, 2.38384366e-01f, 1.69644892e-01f, 1.49732903e-01f, 2.64329195e-01f, -3.25036310e-02f, 7.32267424e-02f, 3.37720245e-01f, 2.02507406e-01f, 2.33222604e-01f,
  -4.15788963e-02f, 3.71386856e-02f, 1.46837756e-01f, -1.97834045e-01f, -1.64469019e-01f, -1.30468579e-02f, 1.55508295e-01f, -4.85789627e-02f, 1.95333943e-01f, 1.61950663e-01f,
  6.65174723e-02f, -2.37414730e-03f, -1.25121936e-01f, -3.34635586e-01f, -2.01485783e-01f, 6.83685914e-02f, 2.75577873e-01f, -1.51937962e-01f, -2.86799431e-01f, 4.41304743e-02f,
  1.35122627e-01f, 4.82404791e-02f, 9.99961272e-02f, 7.58947954e-02f, 1.25625044e-01f, -3.79675291e-02f, 1.76607490e-01f, 1.53053313e-01f, 7.53474794e-03f, 2.26410776e-01f,
  1.23955935e-01f, -3.77268225e-01f, 2.78368831e-01f, 4.19934355e-02f, 3.16297263e-02f, -2.57209763e-02f, -1.09093800e-01f, 1.91411540e-01f, 4.91894856e-02f, 1.40048012e-01f,
  -1.25809193e-01f, 1.80491403e-01f, 7.09273443e-02f, 1.19940743e-01f, 7.74837583e-02f, 3.03012550e-01f, -1.57276522e-02f, -1.61157146e-01f, 1.96521223e-01f, -1.03013515e-01f,
  -5.73632587e-03f, 1.65534988e-02f, -2.39861846e-01f, 1.21324383e-01f, -1.71912625e-01f, 2.26955563e-01f, 5.48760295e-01f, -2.27219909e-01f, 7.87157565e-02f, 4.83285844e-01f,
  -1.51476208e-02f, -1.39780581e-01f, 5.41010052e-02f, -1.34463251e-01f, 4.16446060e-01f, 9.41483825e-02f, 4.42787409e-01f, -8.51563876e-04f, 2.53724575e-01f, 2.96130776e-01f,
  2.59672012e-02f, -1.17713667e-01f, 3.10065299e-01f, -3.92913043e-01f, 1.08859390e-01f, -3.40605574e-03f, 5.94144762e-01f, -1.18817285e-01f, 5.66026457e-02f, 5.58494367e-02f,
  3.60659868e-01f, -5.33787981e-02f, 4.18639295e-02f, 8.91574249e-02f, 8.75330493e-02f, 8.20968896e-02f, -3.56767140e-02f, 4.08917256e-02f, -3.12099606e-02f, 1.90932542e-01f,
  1.22565061e-01f, 4.31276578e-03f, 1.03047416e-02f, 1.53717712e-01f, 2.16076031e-01f, 1.30380213e-01f, -1.31013710e-02f, 7.08119944e-02f, 1.53337523e-01f, -1.28052058e-02f,
  2.03761414e-01f, 1.76061630e-01f, 1.60675317e-01f, 2.85008430e-01f, -1.55741662e-01f, 5.72291128e-02f, -1.19677477e-01f, 9.37471092e-02f, 1.53986499e-01f, 9.44454893e-02f,
  2.29963921e-02f, 1.63104996e-01f, -2.39169747e-02f, 7.91342407e-02f, 1.74348485e-02f, -7.12232962e-02f, 2.18837440e-01f, 5.29045165e-02f, 7.43010789e-02f, 3.12700599e-01f,
  1.50374398e-01f, 5.74224740e-02f, 3.26646119e-02f, 9.65400115e-02f, 2.04790890e-01f, 7.11798444e-02f, 1.73692610e-02f, 2.12877728e-02f, 1.21333949e-01f, 2.52729088e-01f,
  -3.41763720e-02f, -1.64775044e-01f, 2.31299505e-01f, -5.90108298e-02f, 2.03007907e-01f, -7.74652371e-03f, 2.03225315e-02f, -2.14311078e-01f, 1.27310812e-01f, 3.12070567e-02f,
  1.58258349e-01f, -2.55082902e-02f, 2.72990972e-01f, 2.61985362e-01f, 1.69412047e-02f, 1.24346793e-01f, 3.72903377e-01f, -1.26276150e-01f, -1.05031177e-01f, -3.09633017e-01f,
  6.02257214e-02f, 2.58026812e-02f, 1.71120450e-01f, 2.81312615e-01f, 1.96693167e-01f, -3.67889367e-02f, -1.29842371e-01f, -2.07788870e-01f, 4.91563194e-02f, -2.33662687e-02f,
  1.84685513e-01f, 1.34999767e-01f, -5.72677180e-02f, -3.66521180e-01f, -3.55972946e-02f, -3.14226329e-01f, -7.65923262e-02f, -6.96102604e-02f, 2.35901803e-01f, -4.58675846e-02f,
  1.35425135e-01f, 5.16590811e-02f, 9.21387523e-02f, -1.99224591e-01f, 1.68811813e-01f, 3.44468988e-02f, -2.64388382e-01f, 1.59715470e-02f, -2.99780399e-01f, 1.91551358e-01f,
  1.11585587e-01f, -1.14630640e-01f, 7.24010766e-02f, 1.27305277e-02f, 2.16871593e-03f, -2.27481294e-02f, -2.84905615e-03f, -2.97445834e-01f, 3.51798415e-01f, 2.99012568e-02f,
  1.06854714e-01f, 1.00065023e-01f, -2.92863309e-01f, -2.89868325e-01f, 2.20658019e-01f, -2.26692185e-02f, -2.63413399e-01f, -2.97107697e-01f, -8.96164104e-02f, 7.15647042e-02f,
  -6.41814172e-02f, 6.19952917e-01f, -1.06712960e-01f, 8.97690058e-02f, -1.56427592e-01f, -1.75509229e-01f, 2.40731433e-01f, -1.97445732e-02f, 3.30581404e-02f, 1.29614413e-01f,
  4.82496060e-02f, 1.88559070e-02f, -5.01951613e-02f, 3.74468528e-02f, -3.90186608e-02f, 8.26474279e-02f, -2.87477851e-01f, 1.63583428e-01f, 7.85729438e-02f, 1.57693088e-01f,
  4.22396362e-02f, -7.98041094e-03f, 1.47878557e-01f, 2.10023344e-01f, -3.27957757e-02f, -4.37736288e-02f, 1.37722328e-01f, 2.60264566e-03f, -5.44816181e-02f, 1.46222576e-01f,
  -4.06882316e-02f, 1.54383957e-01f, 1.05192689e-02f, 3.29790898e-02f, 1.63945645e-01f, -8.28043297e-02f, -6.08348176e-02f, -1.26416180e-02f, 1.02482498e-01f, 1.11059383e-01f,
  7.94881359e-02f, 7.50560910e-02f, 1.98053457e-02f, 7.29668513e-02f, -5.03448285e-02f, -4.72512394e-02f, 3.74903008e-02f, 1.20285377e-01f, -1.08681275e-02f, 5.91455512e-02f,
  -4.09338884e-02f, 3.64246443e-02f, -1.08576212e-02f, 4.25993167e-02f, 3.05866059e-02f, 8.83191731e-03f, 5.55286780e-02f, -4.34062406e-02f, -6.53124303e-02f, -1.61356091e-01f,
  -4.52928655e-02f, 1.35873958e-01f, 8.66756439e-02f, -5.71996458e-02f, -3.07991020e-02f, -1.98488280e-01f, -2.44614273e-01f, -1.75539847e-03f, 1.02806650e-01f, 7.35511631e-02f,
  -1.15054071e-01f, 1.64006650e-02f, -1.23692498e-01f, 8.45550671e-02f, -1.32631272e-01f, 2.19986401e-02f, -1.33787561e-02f, 1.34951457e-01f, -2.45295972e-01f, -7.90927038e-02f,
  -9.08594728e-02f, 1.85560752e-02f, 5.28462492e-02f, 1.38482928e-01f, -1.73395723e-01f, -1.26727968e-02f, 7.17759505e-02f, -1.88272372e-01f, -9.78465825e-02f, 8.53634179e-02f,
  -8.31598863e-02f, -2.72387229e-02f, -3.21055621e-01f, 1.50362179e-01f, -4.67658900e-02f, -1.38873503e-01f, -1.46235302e-01f, 3.08601502e-02f, 2.30704695e-01f, -7.12392628e-02f,
  -3.72557044e-02f, 6.81875274e-02f, 1.11006349e-01f, 1.46949336e-01f, -3.66217703e-01f, -1.45496728e-04f, 9.65546966e-02f, -9.08650011e-02f, -1.77822992e-01f, -5.22268228e-02f,
  -1.93779513e-01f, -4.21198070e-01f, 1.41044453e-01f, 2.13999778e-01f, -2.97765076e-01f, -3.44470106e-02f, -5.67808896e-02f, -5.41047081e-02f, 1.70220420e-01f, -7.23091466e-03f,
  4.36377913e-01f, -2.29266614e-01f, 1.03663117e-01f, -1.90288946e-01f, 2.22845793e-01f, -9.61560905e-02f, -6.29217997e-02f, 2.69660860e-01f, 1.10502698e-01f, -3.82056795e-02f,
  1.56281535e-02f, 5.98986484e-02f, 8.69532764e-01f, 1.29961058e-01f, -8.48221965e-03f, -9.81112123e-02f, -3.39242369e-02f, 5.16668633e-02f, 2.04324853e-02f, 4.03526910e-02f,
  -8.59740227e-02f, 9.83443670e-03f, -1.24862440e-01f, -3.07425335e-02f, -1.33107722e-01f, -1.02144182e-01f, 1.60729870e-01f, -8.58812854e-02f, 3.50653529e-02f, -3.02541517e-02f,
  7.26713687e-02f, 1.07282154e-01f, 6.62389696e-02f, 5.45631945e-02f, 3.25690918e-02f, 1.19079109e-02f, -3.06334477e-02f, 1.17816143e-01f, 1.37026295e-01f, -3.60193127e-03f,
  -3.21842730e-02f, 1.27507970e-01f, 1.41807333e-01f, 1.06723756e-01f, -3.42950486e-02f, 5.95060252e-02f, -8.20965245e-02f, 5.75022437e-02f, -5.37910424e-02f, -8.01459476e-02f,
  1.93893164e-01f, -2.33031780e-01f, 1.70222744e-01f, 8.15255344e-02f, -1.26541078e-01f, 5.00031896e-02f, 8.25474411e-02f, -1.90974434e-03f, 4.17002216e-02f, 4.23276909e-02f,
  1.24369241e-01f, 1.15588047e-01f, 1.84668392e-01f, 4.99871094e-03f, 3.05447169e-02f, 1.69564247e-01f, -1.18058614e-01f, -1.66154265e-01f, 9.45824459e-02f, -1.63248211e-01f,
  1.24356538e-01f, 1.67204142e-01f, -9.04444605e-02f, -1.86940268e-01f, -3.92509028e-02f, 2.14654237e-01f, 9.30791125e-02f, -7.29385689e-02f, 1.95133820e-01f, 1.10973679e-01f,
  -1.24722034e-01f, 9.20460373e-02f, -8.43825266e-02f, 5.33860028e-02f, 2.24168956e-01f, -1.57853127e-01f, -2.98680544e-01f, -1.06933981e-01f, -6.36030510e-02f, 2.96831787e-01f,
  1.48464426e-01f, 1.28905475e-01f, -6.93378672e-02f, -1.05035923e-01f, -1.19690537e-01f, -1.28300488e-01f, 8.88374001e-02f, -5.40320724e-02f, -4.21104357e-02f, -1.57004982e-01f,
  -1.50243044e-01f, 1.46742150e-01f, -1.11046307e-01f, -2.69281417e-01f, 5.73051758e-02f, -9.54065621e-02f, 1.28223598e-01f, 7.71834254e-02f, 8.61519277e-02f, -6.05834387e-02f,
  2.81836316e-02f, 6.07106723e-02f, 8.57746080e-02f, -1.12137953e-02f, -2.76067853e-01f, 3.96539830e-02f, -6.44770563e-02f, 3.23772550e-01f, -1.39931589e-01f, 3.96938734e-02f,
  1.87715054e-01f, 1.32381558e-01f, 3.25797737e-01f, -2.34411672e-01f, 1.50996685e-01f, -2.67442495e-01f, 8.91780257e-02f, 1.13621026e-01f, -1.66558549e-01f, -1.85160637e-01f,
  4.61314857e-01f, -1.75338164e-01f, -5.63434124e-01f, -3.57841045e-01f, -2.16308534e-01f, 3.82884294e-01f, -4.51205522e-01f, 5.40986657e-01f, -1.91183221e-02f, -8.41351524e-02f,
  2.40917072e-01f, -2.04852834e-01f, -9.33685377e-02f, -8.17319099e-03f, 1.24586225e-01f, 2.38699093e-01f, -1.35864004e-01f, 1.17237456e-01f, -1.25952631e-01f, -1.94986507e-01f,
  1.02948308e-01f, -5.54145612e-02f, -7.88034573e-02f, 1.30131453e-01f, 1.13897696e-01f, 8.07438418e-02f, 1.36106431e-01f, 1.22968266e-02f, 1.14023820e-01f, 1.25041127e-01f,
  2.66336948e-02f, 1.13579363e-01f, -6.12224229e-02f, -3.38027924e-02f, 8.27377811e-02f, 2.76999432e-03f, -3.06356722e-03f, 7.19689652e-02f, -1.43058235e-02f, 8.56860727e-02f,
  2.06422463e-01f, -9.00766477e-02f, 4.11924943e-02f, 1.03551693e-01f, 8.49770904e-02f, -5.02989963e-02f, 1.42668813e-01f, 2.31792200e-02f, 2.63742179e-01f, -1.27558410e-01f,
  7.08559230e-02f, 9.81702805e-02f, 1.70060992e-02f, -1.36405319e-01f, -9.49461013e-03f, -3.08506358e-02f, 4.06615622e-02f, 1.15953378e-01f, 5.85220903e-02f, 1.12466598e-02f,
  1.40008330e-01f, 1.25723034e-01f, 7.35588893e-02f, 1.07392736e-01f, -9.21654031e-02f, -8.06594789e-02f, 1.70497876e-02f, -4.72084135e-02f, 5.65823540e-02f, 1.23402208e-01f,
  9.80076566e-02f, -1.21023029e-01f, 1.75803810e-01f, 2.46847048e-02f, 1.09702669e-01f, -1.16193041e-01f, -1.30723760e-01f, 1.09213091e-01f, -5.75492606e-02f, -2.09449325e-02f,
  3.24667469e-02f, 2.46814802e-01f, 1.08587928e-02f, 5.88503629e-02f, -2.54778087e-01f, -1.81557193e-01f, -1.64023966e-01f, 3.07992212e-02f, -8.84647295e-02f, 2.38281772e-01f,
  -1.00476861e-01f, 2.28948578e-01f, -1.76591322e-01f, 2.78526694e-01f, -1.40797198e-01f, 9.60640982e-02f, 1.78703204e-01f, -1.90853421e-02f, -1.53832763e-01f, -3.31179321e-01f,
  -3.79282609e-02f, -2.07752630e-01f, 3.64153534e-02f, -4.36813384e-02f, 5.58174178e-02f, 6.85052723e-02f, 2.39603762e-02f, -1.19273447e-01f, 1.33177876e-01f, 1.68657839e-01f,
  -1.06350752e-02f, -9.99746546e-02f, -2.26001576e-01f, -1.60448134e-01f, 4.33758229e-01f, 1.99857533e-01f, -7.72882253e-02f, 1.44008547e-01f, 3.08076620e-01f, 3.98156375e-01f,
  3.29411894e-01f, -2.50854552e-01f, -2.23202914e-01f, -6.71390370e-02f, -5.28202616e-02f, 7.82393441e-02f, -1.45003468e-01f, -1.41859233e-01f, 2.89052844e-01f, -1.09504431e-01f,
  1.16398461e-01f, -1.70754567e-01f, -1.46875098e-01f, 3.58528465e-01f, 1.67364441e-02f, 2.54873514e-01f, 1.28968507e-01f, -2.63862573e-02f, 8.71400721e-03f, -2.28522420e-01f,
  3.73542085e-02f, 1.31655261e-01f, 1.46202490e-01f, 1.31789580e-01f, 7.19781383e-04f, 1.22705631e-01f, -3.52813117e-02f, 1.50327265e-01f, -1.97235998e-02f, 2.06411570e-01f,
  1.47665620e-01f, -2.02154275e-02f, 7.26341084e-02f, 1.74821056e-02f, 1.34118289e-01f, 3.89419571e-02f, 9.95303392e-02f, -7.44414516e-03f, 1.46647347e-02f, -3.68680954e-02f,
  4.52489071e-02f, 9.06468630e-02f, 5.78413419e-02f, -3.92334536e-02f, 1.57841057e-01f, 1.47931263e-01f, 1.19836070e-01f, 3.27017047e-02f, 2.47747893e-03f, 2.40100920e-01f,
  9.20836255e-02f, 7.29900599e-02f, 4.16300297e-02f, 2.41313130e-01f, -5.78792021e-02f, 9.93403345e-02f, 1.13829449e-01f, -2.23511718e-02f, 2.97748037e-02f, 1.71868220e-01f,
  1.72929376e-01f, -4.36862409e-02f, 1.45035535e-01f, 1.54254632e-02f, 1.14219368e-01f, 1.84458286e-01f, 1.51808217e-01f, -2.97393271e-04f, 6.09155111e-02f, 5.94115034e-02f,
  6.39346763e-02f, 3.27131927e-01f, -4.43347245e-02f, 1.74695358e-01f, 1.30789191e-01f, 4.83633112e-03f, 8.51507187e-02f, 6.43870467e-03f, 4.44008224e-02f, 1.60605893e-01f,
  7.75263086e-02f, 8.22688490e-02f, -1.20318070e-01f, -1.97155729e-01f, 1.67633668e-01f, -1.51139706e-01f, 1.64851859e-01f, -6.27493635e-02f, 2.01298296e-02f, -2.02586353e-02f,
  -9.12140012e-02f, -1.07395783e-01f, 1.34649426e-01f, 1.54486537e-01f, 7.70526230e-02f, 1.08558144e-02f, -2.54681371e-02f, -1.08872674e-01f, -1.03654921e-01f, -5.40361851e-02f,
  -3.45059857e-02f, 1.84791565e-01f, 1.29258230e-01f, 4.33915444e-02f, -4.73523363e-02f, -2.28512481e-01f, 8.25435817e-02f, -8.24097320e-02f, 1.90020248e-03f, 1.26601771e-01f,
  -3.72610576e-02f, 1.91450715e-01f, -1.62343830e-02f, 1.50512040e-01f, 1.50456682e-01f, 1.94006525e-02f, 2.99486481e-02f, -6.34095892e-02f, 1.63045138e-01f, 3.59184705e-02f,
  -2.23875403e-01f, -4.06960435e-02f, 6.85972497e-02f, 1.94244102e-01f, -2.17496753e-01f, 4.86878037e-01f, 3.71991217e-01f, -1.69019461e-01f, 7.36014009e-01f, 4.66347039e-01f,
  1.27866231e-02f, -1.11397080e-01f, -3.04242402e-01f, -1.09209130e-02f, 1.33206114e-01f, 8.84840339e-02f, 1.61834449e-01f, -2.64215380e-01f, 7.78347477e-02f, 3.65364134e-01f,
  -1.11292176e-01f, -2.37413034e-01f, 2.11576939e-01f, 3.21673602e-01f, -9.81300697e-02f, 9.67732966e-02f, -4.11288112e-01f, 2.90432096e-01f, 1.17417865e-01f, 1.28096327e-01f,
  2.45174110e-01f, 9.63135734e-02f, -1.02308124e-01f, 2.43806943e-01f, 1.02455907e-01f, 3.81711801e-03f, 2.28880301e-01f, 1.06040157e-01f, 2.33964935e-01f, 2.47891381e-01f,
  1.92339778e-01f, 3.50157879e-02f, -6.17220849e-02f, 1.17921367e-01f, 8.98694545e-02f, 1.78795997e-02f, 8.45108554e-02f, 1.19310677e-01f, -4.80346702e-04f, 2.17881575e-01f,
  1.44286200e-01f, 2.08865002e-01f, 1.40038133e-01f, 2.08335698e-01f, 4.36809398e-02f, 1.73088253e-01f, 5.93423657e-02f, 4.63982709e-02f, 2.32069835e-01f, 9.58109125e-02f,
  -4.38513532e-02f, 1.12470455e-01f, 1.44793883e-01f, -2.64284778e-02f, 5.23665622e-02f, 1.17282495e-01f, 9.39154532e-03f, 1.12606913e-01f, 6.30865693e-02f, -3.36617641e-02f,
  1.21912390e-01f, -7.88173825e-03f, 6.11229837e-02f, 5.37380688e-02f, -1.78795606e-02f, -5.30454367e-02f, -2.61370223e-02f, 1.10755011e-01f, 1.42241539e-02f, -1.10990014e-02f,
  -1.41055197e-01f, -2.73771316e-01f, 8.68599787e-02f, -5.17371781e-02f, -5.85421920e-02f, -2.11255010e-02f, 2.26602238e-03f, -9.74444970e-02f, -9.14011896e-02f, 1.24714054e-01f,
  -4.53095958e-02f, -5.90588525e-02f, 9.45279226e-02f, 6.58094138e-02f, -4.41163778e-02f, 5.33808209e-02f, 3.37365597e-01f, 6.38461038e-02f, 1.13484338e-01f, 9.66244489e-02f,
  -9.50791240e-02f, -7.80143067e-02f, 4.18224074e-02f, 1.21841095e-01f, -1.62304655e-01f, -1.14942297e-01f, 9.66061875e-02f, 3.54438871e-02f, 3.05416971e-03f, -7.58477822e-02f,
  -1.23372674e-01f, 4.73060273e-02f, 1.81958705e-01f, 6.43887520e-02f, -2.70362198e-01f, 1.54980823e-01f, 8.54443163e-02f, -1.79925129e-01f, 1.04213096e-01f, -1.25744492e-01f,
  -3.53892781e-02f, -6.14857338e-02f, -2.43268646e-02f, -1.33234456e-01f, -8.21677223e-03f, 7.77049921e-03f, -2.83005182e-02f, 3.87544073e-02f, 5.38012981e-02f, 3.93996574e-02f,
  1.39487490e-01f, 4.10706073e-01f, 1.92691252e-01f, -3.82048525e-02f, -2.94414878e-01f, 5.79404384e-02f, 2.28474826e-01f, 7.68726543e-02f, 2.17045546e-01f, 3.48382443e-02f,
  -1.08514018e-02f, -6.82208762e-02f, 3.27334315e-01f, 4.04858217e-02f, 2.11146057e-01f, 2.43685007e-01f, -3.31955969e-01f, 3.27291596e-03f, -2.09317997e-01f, 5.72241470e-02f,
  2.51671430e-02f, 2.81266361e-01f, -3.88458282e-01f, -1.19519055e-01f, -6.55420572e-02f, 7.99491710e-04f, -1.17414715e-02f, 1.26409024e-01f, 1.94020003e-01f, 1.39406472e-01f,
  7.27290139e-02f, 2.62227212e-03f, -9.81412176e-03f, 1.44808460e-02f, 4.54340428e-02f, 1.22670002e-01f, 4.29704264e-02f, 5.82536310e-02f, 1.45620227e-01f, 7.34526524e-03f,
  9.88521874e-02f, -1.60794288e-01f, -4.54688482e-02f, 8.39950815e-02f, -2.21713819e-02f, 1.84287742e-01f, -2.94503514e-02f, 2.38284767e-01f, -1.87495932e-01f, 6.70551211e-02f,
  -2.41047665e-02f, 3.06670219e-02f, 1.43556178e-01f, -1.19541302e-01f, 9.39496532e-02f, 9.79843289e-02f, 1.90889299e-01f, 1.32547483e-01f, 1.38362288e-01f, 1.08437143e-01f,
  8.23296681e-02f, 3.66082415e-02f, 1.59543678e-01f, -5.38108386e-02f, 1.65496856e-01f, 6.36607260e-02f, 4.47528884e-02f, 7.39996508e-02f, 6.25774413e-02f, 8.29338133e-02f,
  2.17725769e-01f, -2.61947531e-02f, 1.02103911e-01f, 1.16667621e-01f, 6.11771606e-02f, 9.51097757e-02f, -1.12559862e-01f, -3.49364430e-02f, 4.83772196e-02f, 2.80947566e-01f,
  -1.39597535e-01f, -7.58770183e-02f, 1.82160467e-01f, 3.88589762e-02f, 2.22149342e-01f, 9.41088721e-02f, -1.32602192e-02f, 1.96587250e-01f, -7.90753365e-02f, -1.28942832e-01f,
  -2.86073033e-02f, 1.57832265e-01f, 1.78633824e-01f, -1.47647604e-01f, 8.77706930e-02f, 1.61135405e-01f, -2.13335589e-01f, -2.82951593e-02f, 2.45118171e-01f, 2.08291009e-01f,
  1.82359651e-01f, -6.64024353e-02f, 8.28651935e-02f, 1.49735153e-01f, -7.66388923e-02f, 1.13093518e-01f, -9.92396995e-02f, 7.34359920e-02f, 7.30826482e-02f, 1.73515677e-01f,
  -2.02879161e-02f, -9.76996124e-02f, -2.07893196e-02f, -1.55415237e-01f, 3.14369574e-02f, 8.53195600e-03f, -2.12485984e-01f, 2.62499571e-01f, -1.03573970e-01f, 9.88719761e-02f,
  5.97613584e-03f, 1.43999711e-01f, -1.35448441e-01f, 1.06276453e-01f, -1.18862510e-01f, 1.64083079e-01f, -1.21642642e-01f, 1.88939273e-01f, -1.97332993e-01f, -7.64587745e-02f,
  -3.21013391e-01f, 2.57471263e-01f, 4.07201618e-01f, 9.69014503e-03f, 3.90959203e-01f, 4.60649490e-01f, -1.47196516e-01f, 1.23243541e-01f, 5.76588511e-03f, -9.22303926e-03f,
  3.65138948e-01f, 6.24689385e-02f, 2.33177409e-01f, 1.48558840e-01f, 2.01662317e-01f, 3.78625870e-01f, 8.29987451e-02f, -3.66100483e-02f, -3.07872612e-02f, -2.74452090e-01f,
  -1.83606483e-02f, 4.50287350e-02f, -2.84521520e-01f, 3.23948562e-01f, 1.84232503e-01f, 9.67980474e-02f, -3.13028954e-02f, 6.28240183e-02f, 1.12743720e-01f, 8.15999657e-02f,
  -5.94590232e-02f, 1.13869801e-01f, -1.11621983e-01f, 1.49428815e-01f, -9.28315893e-02f, -3.54690291e-02f, 1.00285888e-01f, 8.09133276e-02f, 6.62466809e-02f, -4.24680412e-02f,
  1.85485408e-02f, 2.64477849e-01f, 2.11337977e-03f, 1.19382441e-02f, 9.86486077e-02f, -1.46526778e-02f, 9.09464359e-02f, -6.58313856e-02f, 2.26771622e-03f, 1.79802645e-02f,
  1.14931636e-01f, 1.33559510e-01f, 1.22152910e-01f, -1.62607804e-02f, -7.99708515e-02f, 1.33080095e-01f, 1.36256069e-01f, 2.26879761e-01f, -9.85050108e-04f, -2.88802125e-02f,
  1.11291902e-02f, 1.09891333e-01f, 1.77249014e-01f, 4.40057032e-02f, -1.03930598e-02f, 1.10977605e-01f, 9.61049348e-02f, 7.98099563e-02f, 1.84951901e-01f, 1.03620313e-01f,
  6.99587464e-02f, 6.79766163e-02f, 6.57174736e-02f, 1.06409043e-01f, 3.70675735e-02f, -1.60623536e-01f, -8.88982564e-02f, 1.93664536e-01f, -2.91592866e-01f, -3.16582099e-02f,
  6.34476601e-04f, -4.15055715e-02f, 1.54325083e-01f, 3.90934013e-02f, 8.39968994e-02f, -1.41076714e-01f, 2.49947011e-02f, 4.03474420e-01f, 1.34428054e-01f, -9.40045435e-03f,
  -1.41488150e-01f, -9.24552046e-03f, -1.09389663e-01f, 7.64135942e-02f, 2.93542352e-02f, -3.26535758e-03f, 1.00675568e-01f, -2.24258821e-03f, 1.34147182e-01f, 1.60756513e-01f,
  2.41657183e-01f, -1.96374521e-01f, -9.84229892e-02f, -6.01419732e-02f, 4.56157625e-02f, -7.08373189e-02f, -5.54432794e-02f, 1.35172363e-02f, -3.61337364e-02f, 9.14910138e-02f,
  1.93341061e-01f, -2.03171428e-02f, 1.60903689e-02f, -5.69148213e-02f, 1.12828858e-01f, 3.83638367e-02f, 2.58484613e-02f, -2.26642177e-01f, 2.38350015e-02f, 4.58142906e-02f,
  -1.12544699e-03f, 4.36068662e-02f, 2.63689935e-01f, -2.56112143e-02f, 1.35926362e-02f, 1.99663311e-01f, -1.67621776e-01f, 1.04264781e-01f, -1.74336225e-01f, -2.58420080e-01f,
  8.12624320e-02f, -8.08060467e-02f, -3.85025889e-01f, -3.09658125e-02f, 2.25351706e-01f, -1.67411920e-02f, 2.68467218e-01f, -8.34007747e-03f, -2.19685063e-01f, -5.55063374e-02f,
  4.06062081e-02f, -1.44147292e-01f, 4.88539003e-02f, -1.82541490e-01f, 9.30218622e-02f, 2.98015863e-01f, -2.20527187e-01f, 1.14895739e-01f, 2.06207648e-01f, -1.14412136e-01f,
  -1.15133300e-02f, 3.50837320e-01f, -8.43556002e-02f, 1.89028785e-01f, 1.64507568e-01f, 3.30601215e-01f, 8.25763196e-02f, 1.92960575e-01f, 5.68825342e-02f, 4.11920510e-02f,
  2.13035300e-01f, 1.20234929e-01f, 1.67817444e-01f, -1.01436293e-02f, 1.65731311e-01f, 6.34284243e-02f, 1.32444292e-01f, -9.47366953e-02f, 6.17412739e-02f, 1.55252531e-01f,
  9.29482803e-02f, 3.15855145e-01f, 1.64213344e-01f, 1.38521269e-01f, -2.83478945e-02f, 4.04001363e-02f, 1.36884138e-01f, -1.87947992e-02f, 1.38312146e-01f, 7.22477064e-02f,
  2.55189329e-01f, 4.69838381e-02f, 2.12828174e-01f, 1.17176846e-01f, 5.07279970e-02f, 8.15494210e-02f, 4.02333029e-02f, 2.67664760e-01f, 2.15025157e-01f, 7.25621879e-02f,
  -1.15724243e-01f, 8.05115700e-02f, -3.77881713e-02f, 1.07646018e-01f, -1.91294495e-02f, 1.76118448e-01f, 2.72126108e-01f, 1.29881635e-01f, 1.68464199e-01f, 1.24642484e-01f,
  3.76366563e-02f, 1.92296207e-01f, 6.60671219e-02f, -1.07196443e-01f, -1.52156845e-01f, -5.39654680e-02f, -4.49468821e-01f, 4.04099375e-02f, -2.79841274e-01f, 1.46924620e-02f,
  1.59432620e-01f, 2.40235329e-01f, 3.99108469e-01f, -1.48478374e-01f, -4.64690477e-02f, -1.06275510e-02f, -3.95841487e-02f, 1.75464824e-02f, 1.62582085e-01f, -1.56532392e-01f,
  -1.65154666e-01f, 4.66687419e-02f, -5.49879782e-02f, 3.37126590e-02f, -8.57943520e-02f, -9.26619023e-02f, 5.67755066e-02f, -1.84125602e-01f, -2.27215052e-01f, 4.68626246e-02f,
  -4.57188413e-02f, 1.76961884e-01f, 4.61023673e-02f, 3.54097068e-01f, -5.49334995e-02f, -1.50374234e-01f, 1.45372540e-01f, 1.38157904e-01f, 1.20277993e-01f, -2.17375606e-01f,
  -1.04015972e-02f, 9.96791273e-02f, -7.05250651e-02f, -6.26740754e-02f, 1.18174970e-01f, 8.39706585e-02f, -5.86977527e-02f, 9.32421982e-02f, 1.63129449e-01f, 4.12805192e-02f,
  1.78464577e-01f, -1.06394365e-01f, 9.58702266e-02f, -9.18995682e-03f, 4.97398883e-01f, 2.33389243e-01f, 3.09808314e-01f, 2.45971188e-01f, -1.55820295e-01f, 8.54122415e-02f,
  2.01624602e-01f, 1.14381716e-01f, 6.37492761e-02f, -4.45795842e-02f, 2.86059845e-02f, -3.70619267e-01f, -3.44588667e-01f, 1.02986963e-02f, 4.33005005e-01f, 1.02663539e-01f,
  1.63890570e-01f, -1.02405146e-01f, 3.00674234e-02f, -1.99958384e-02f, -2.25391790e-01f, -1.77672729e-01f, 6.90045804e-02f, -1.90846175e-01f, -2.28647850e-02f, -3.22636396e-01f,
  -8.18160083e-03f, 3.47020507e-01f, 3.20890307e-01f, 1.56101864e-02f, 7.77561069e-02f, 8.34371299e-02f, 5.48436260e-03f, 1.63077503e-01f, 5.54813398e-03f, 1.52526557e-01f,
  3.17196399e-02f, -3.61059196e-02f, 4.02734466e-02f, -1.42007489e-02f, 6.31618574e-02f, 8.07831530e-03f, 2.19907969e-01f, 2.57649541e-01f, 1.80645272e-01f, 3.55922341e-01f,
  1.21878460e-02f, 2.03129724e-01f, -3.09295133e-02f, 1.41143035e-02f, 2.58896798e-01f, 6.73522949e-02f, 5.61907031e-02f, -7.70029053e-02f, -8.35731626e-02f, 7.43125677e-02f,
  1.08867757e-01f, -4.93487949e-03f, -3.29223834e-02f, 3.85795138e-03f, 8.47997442e-02f, 2.02627227e-01f, 8.45739022e-02f, 8.64557847e-02f, -1.03702873e-01f, 4.72520962e-02f,
  5.94554581e-02f, -5.12179211e-02f, 3.85235623e-02f, 1.99254543e-01f, 8.51862952e-02f, -6.84879571e-02f, 8.46279785e-03f, 1.99470103e-01f, -1.44109679e-02f, 1.11826994e-01f,
  -6.28122911e-02f, -1.81108773e-01f, -1.69436052e-01f, -1.05006136e-01f, -5.21270275e-01f, 1.35558337e-01f, 1.22647583e-01f, 2.41979174e-02f, 2.49304965e-01f, 6.66266531e-02f,
  3.71814311e-01f, -9.65781659e-02f, -7.94816390e-02f, 6.06133044e-02f, 1.23581842e-01f, 4.71807480e-01f, 2.34587386e-01f, -1.60027653e-01f, -2.55577475e-01f, 1.84260949e-01f,
  3.69342603e-02f, -7.79426917e-02f, 1.56748921e-01f, 2.65610784e-01f, 9.13978741e-02f, 1.67312369e-01f, 6.47026524e-02f, 7.05495998e-02f, -1.05731443e-01f, 1.02895446e-01f,
  -9.53629091e-02f, -9.21622887e-02f, 2.01070219e-01f, -1.64623812e-01f, -6.52097315e-02f, -9.31044854e-03f, 1.50437757e-01f, -1.03416495e-01f, 8.10173526e-02f, 8.72677788e-02f,
  -8.85322317e-02f, 2.92325497e-01f, 2.43959740e-01f, -1.38912408e-03f, -1.30891502e-01f, 3.91705483e-01f, 2.26225138e-01f, 6.27237707e-02f, 2.16414571e-01f, 2.00671583e-01f,
  -9.81983822e-03f, 1.91002756e-01f, 5.57466559e-02f, 1.75431073e-01f, 4.79898863e-02f, 2.07483113e-01f, 1.90260410e-01f, -2.09778562e-01f, 2.19535351e-01f, 3.28317732e-01f,
  1.70175031e-01f, -1.18742712e-01f, 2.88857549e-01f, -1.87778041e-01f, -2.39242464e-01f, -1.05741628e-01f, 6.95760369e-01f, -5.28929755e-03f, 7.38155469e-02f, 2.54062176e-01f,
  -8.06310028e-02f, -8.83968696e-02f, -2.19025567e-01f, 9.34724733e-02f, -4.06932756e-02f, -6.85417429e-02f, -1.05166957e-01f, -3.54042053e-01f, 6.96022213e-02f, 5.64688146e-02f,
  1.36927918e-01f, 3.27514764e-03f, 1.07101791e-01f, 2.08230726e-02f, 4.50579748e-02f, 2.64131110e-02f, -5.36865601e-03f, 2.04815850e-01f, 1.38801172e-01f, 1.51352072e-03f,
  1.10956110e-01f, -8.66852421e-03f, 8.47678408e-02f, -6.22951053e-02f, 3.31373177e-02f, 8.40440858e-04f, -1.83267482e-02f, 4.54915427e-02f, 7.91037157e-02f, 6.18683472e-02f,
  -3.71442437e-02f, 3.59743126e-02f, 1.02437638e-01f, 1.40855432e-01f, 1.86701089e-01f, 2.20083836e-02f, -6.65518343e-02f, 1.27451062e-01f, 3.57958302e-02f, 9.68459547e-02f,
  6.13393709e-02f, 4.69030160e-03f, -1.06469281e-02f, 5.56628443e-02f, 9.83098075e-02f, 1.27852321e-01f, 2.50718147e-01f, 4.70519178e-02f, 5.49403541e-02f, 2.35653237e-01f,
  1.24668874e-01f, 1.49598405e-01f, -5.94055317e-02f, 1.35659635e-01f, -6.45793453e-02f, -3.97168249e-02f, 2.15293705e-01f, -8.06077197e-03f, -5.93402470e-03f, 2.21427724e-01f,
  1.04276843e-01f, 1.88632444e-01f, 8.70135352e-02f, -4.47907150e-02f, 1.27287596e-01f, 7.65914097e-03f, 2.26980392e-02f, -1.29780665e-01f, -1.62306100e-01f, 7.81378523e-02f,
  6.27554655e-02f, 5.09985629e-03f, 1.37612581e-01f, -1.98580354e-01f, -1.53652117e-01f, 1.46168351e-01f, 1.80689529e-01f, -7.40851909e-02f, -1.37689169e-02f, -9.84257907e-02f,
  1.74141228e-01f, 6.22128658e-02f, 1.34204090e-01f, 2.04642102e-01f, 6.88647479e-02f, -1.62716910e-01f, -2.81520076e-02f, -1.13206349e-01f, 1.01926386e-01f, -1.14734415e-02f,
  7.67888278e-02f, 1.13065034e-01f, -1.31133750e-01f, -2.00430155e-01f, 1.84267238e-01f, -2.18733341e-01f, 6.51835799e-02f, -2.39530012e-01f, 3.37720141e-02f, 1.75495893e-01f,
  -8.98174718e-02f, 4.27724943e-02f, -7.98465982e-02f, 5.34543768e-02f, -1.05836235e-01f, -6.71302602e-02f, -1.74963832e-01f, -1.05236366e-01f, -3.05706501e-01f, 1.67270303e-01f,
  -3.48532528e-01f, 1.12209983e-01f, -4.78095949e-01f, 2.04953566e-01f, 2.55750775e-01f, -1.13880336e-01f, 1.18267454e-01f, 1.29577913e-03f, 1.20867625e-01f, -1.17923900e-01f,
  1.16083674e-01f, 7.73207843e-02f, 6.15460277e-02f, 1.39236644e-01f, -2.01712027e-01f, -8.45553055e-02f, -3.13372537e-02f, 3.24151069e-02f, -5.41317351e-02f, -1.85123846e-01f,
  -7.30760917e-02f, 3.94608915e-01f, -2.89576173e-01f, 1.08244158e-01f, -2.42165491e-01f, 3.20739418e-01f, 1.44019514e-01f, -4.03980166e-02f, 6.84246570e-02f, 1.05271921e-01f,
  4.66040298e-02f, 6.22131005e-02f, 1.94116414e-01f, 3.96064408e-02f, -2.15164367e-02f, 1.21930122e-01f, 1.46394614e-02f, 1.16968654e-01f, 3.72874737e-02f, 2.77809296e-02f,
  -6.01486191e-02f, -9.19231325e-02f, 1.42519265e-01f, 2.48233564e-02f, -1.53676510e-01f, -2.28958111e-02f, 4.84592468e-02f, -2.74987682e-03f, -1.43268267e-02f, 1.70361191e-01f,
  1.04967475e-01f, -5.57337247e-04f, 1.34826764e-01f, 4.95490730e-02f, 1.69976100e-01f, 4.52031828e-02f, -8.52451399e-02f, 1.81286097e-01f, -2.57204641e-02f, 1.17667057e-02f,
  2.59552207e-02f, -1.14012687e-02f, 1.07473657e-01f, 1.74622208e-01f, 1.29391432e-01f, 8.31504315e-02f, -2.80714091e-02f, -9.60068479e-02f, -7.82252997e-02f, 9.25410688e-02f,
  1.76012933e-01f, 5.86392023e-02f, -1.01132758e-01f, -9.76107363e-03f, 1.02238730e-01f, 4.38360311e-02f, 1.86377298e-02f, -1.15750369e-03f, -3.99992801e-02f, 4.07789424e-02f,
  -1.35112241e-01f, -5.08687198e-02f, 6.66202083e-02f, -2.69162562e-02f, 1.45068750e-01f, -5.13098575e-02f, 4.50184662e-03f, -1.12616129e-01f, -7.42770615e-04f, 7.42376596e-02f,
  -6.64811507e-02f, 8.53123516e-02f, -2.78353095e-01f, 3.17360796e-02f, -1.78126127e-01f, 1.27717927e-01f, 4.22943741e-01f, 2.50151634e-01f, -2.07730427e-01f, -2.65261173e-01f,
  -1.83550358e-01f, 1.18956447e-01f, 5.80059290e-02f, 3.05697620e-01f, 3.83013636e-02f, -7.88497366e-03f, -1.79102108e-01f, -1.29214168e-01f, -9.56534036e-03f, -1.95011437e-01f,
  1.63782150e-01f, 5.29646985e-02f, -3.47505778e-01f, 2.17241436e-01f, -2.17702284e-01f, -3.19058120e-01f, 1.10836096e-01f, -2.35060707e-01f, 2.62984425e-01f, -2.16502383e-01f,
  -8.18449035e-02f, 1.79231837e-01f, 1.00137599e-01f, -2.49168739e-01f, 1.59080580e-01f, -2.96799596e-02f, 1.14447303e-01f, -4.26219814e-02f, 2.38278285e-01f, -1.61155343e-01f,
  1.65933043e-01f, -2.03145385e-01f, 1.95504159e-01f, 2.83558607e-01f, 1.29048213e-01f, 9.77549609e-03f, 2.67194241e-01f, 1.11556530e-01f, 3.51636559e-01f, -5.81005923e-02f,
  2.91316867e-01f, 6.88490570e-02f, 1.53813094e-01f, 1.13264598e-01f, -1.06663957e-01f, -1.92904875e-01f, 3.02261114e-02f, 2.26620793e-01f, -5.20846605e-01f, -7.67124742e-02f,
  1.73095435e-01f, -1.74105480e-01f, 7.31347576e-02f, -1.39924303e-01f, 1.29952714e-01f, 2.18906522e-01f, 1.34901598e-01f, 2.09911883e-01f, -8.83688219e-03f, 2.00310782e-01f,
  7.45213032e-02f, 1.27660677e-01f, 2.28095010e-01f, 4.66946177e-02f, 1.01281166e-01f, 6.29562140e-02f, 6.82149827e-02f, 2.53066625e-02f, 2.27016136e-02f, 1.23113349e-01f,
  8.90327096e-02f, 7.02167600e-02f, 2.49599162e-02f, 1.64272651e-01f, 7.07655922e-02f, 1.69076517e-01f, 1.92288924e-02f, 2.15243295e-01f, 2.46810000e-02f, 3.35436799e-02f,
  1.36780590e-01f, -4.51143160e-02f, 1.73587710e-01f, -2.47251820e-02f, 2.70647615e-01f, 1.04252614e-01f, 7.26208910e-02f, 1.27785936e-01f, 7.56733194e-02f, 4.44803871e-02f,
  2.31975645e-01f, 1.40153110e-01f, -3.98884453e-02f, -7.49398991e-02f, 1.04695551e-01f, 7.69870356e-02f, 2.93271820e-04f, 1.46280918e-02f, 2.56741852e-01f, 6.62786961e-02f,
  -4.96101715e-02f, 9.31079462e-02f, 1.50702029e-01f, 1.23387605e-01f, 6.56532170e-03f, 1.75879598e-02f, -6.96770996e-02f, -1.26124769e-01f, 1.94928814e-02f, -1.16213471e-01f,
  -7.26118833e-02f, -8.13448876e-02f, 2.48893961e-01f, 5.24715967e-02f, 3.13772529e-01f, -2.67495010e-02f, -1.22963466e-01f, 1.04255393e-01f, 7.55221024e-02f, 4.91942614e-02f,
  7.20191672e-02f, -4.63713445e-02f, -1.49260804e-01f, 1.78122967e-02f, 2.60488182e-01f, 1.03352234e-01f, -9.19494219e-03f, -4.67962399e-02f, -9.98162404e-02f, 6.82324916e-02f,
  -3.67171504e-02f, -1.60021201e-01f, 9.96096209e-02f, 1.70623124e-01f, 8.06197599e-02f, -3.63197811e-02f, -1.93327349e-02f, -2.16533005e-01f, -1.88581273e-02f, 1.45978451e-01f,
  -2.26740763e-02f, 3.11997592e-01f, 1.38702197e-02f, -2.11926475e-02f, 1.89504221e-01f, -1.61730498e-01f, 3.20350491e-02f, 8.66004005e-02f, 3.88028398e-02f, 1.26952469e-01f,
  5.44520915e-02f, -1.70589432e-01f, 3.29055130e-01f, -4.12543006e-02f, 7.37700984e-02f, -4.68394123e-02f, 4.23618942e-01f, 3.02299619e-01f, 5.17505646e-01f, 1.22214384e-01f,
  -2.98104525e-01f, -2.02417955e-01f, 1.65644735e-01f, 1.05012655e-01f, 3.82576823e-01f, -2.02135235e-01f, 1.10833623e-01f, -5.62359951e-02f, 2.50733886e-02f, -2.31995787e-02f,
  3.61392766e-01f, 1.20128617e-01f, -9.57895070e-02f, 4.83917147e-02f, -1.18970111e-01f, -2.53087610e-01f, 2.16773137e-01f, -6.53425679e-02f, 1.86613854e-02f, -1.47466123e-01f,
  3.02459508e-01f, -3.90234917e-01f, 6.83204681e-02f, 1.24345616e-01f, 1.04527436e-01f, 1.80778190e-01f, 7.67987445e-02f, -2.97258627e-02f, -1.12657413e-01f, 4.11563478e-02f,
  8.56798962e-02f, -1.43416882e-01f, -1.05501004e-01f, -7.25229383e-02f, 8.11284184e-02f, -8.58142823e-02f, 1.47712126e-01f, 1.73697367e-01f, 1.05171293e-01f, 1.13329895e-01f,
  2.66200185e-01f, 5.55380844e-02f, 1.71244904e-01f, -9.70534682e-02f, 1.88709840e-01f, 1.15512542e-01f, 4.45905142e-02f, 4.24028784e-02f, 7.76750147e-02f, 1.06680408e-01f,
  -7.84893706e-02f, 1.22406796e-01f, 1.66311279e-01f, 1.89578369e-01f, 3.28523070e-02f, 2.18139485e-01f, 4.03643064e-02f, 1.88356385e-01f, 1.72870561e-01f, 7.10075861e-03f,
  5.87730296e-02f, -1.24402590e-01f, 1.26801759e-01f, 1.05486006e-01f, 1.05786100e-01f, 8.37990046e-02f, 3.27024236e-02f, 9.15860981e-02f, 1.39661785e-02f, 6.43283352e-02f,
  1.27940431e-01f, 1.98883116e-01f, 3.65020446e-02f, 2.71744132e-01f, -2.55821884e-01f, 1.09617203e-01f, 1.40867785e-01f, 6.37138635e-02f, -5.56078665e-02f, 7.40940198e-02f,
  1.63299171e-03f, -1.31148413e-01f, 3.20916325e-02f, -6.54583499e-02f, 1.94252804e-01f, -1.16042783e-02f, 6.13900274e-02f, 9.45453998e-03f, -1.79690719e-01f, 5.95213696e-02f,
  -1.43458456e-01f, -1.71516895e-01f, -1.97041899e-01f, -1.39226764e-01f, -1.36703417e-01f, -1.76002562e-01f, 2.15855464e-02f, 1.18842967e-01f, 3.72124203e-02f, -7.28407353e-02f,
  -1.40801638e-01f, -1.54397234e-01f, -7.81834051e-02f, 1.94051445e-01f, -1.89604855e-03f, 1.29472008e-02f, -1.42332807e-01f, -1.18693180e-01f, 1.00294814e-01f, 2.63335407e-02f,
  -1.44416779e-01f, -8.86178687e-02f, 1.52382612e-01f, -1.20245907e-02f, 2.45163724e-01f, 7.98618495e-02f, 1.11931480e-01f, -2.16577113e-01f, 1.55833915e-01f, 1.20596699e-01f,
  4.63909209e-02f, 1.41599715e-01f, 2.59494334e-02f, -8.55296571e-03f, 5.75278699e-01f, -4.01289985e-02f, 2.10095823e-01f, -3.88999395e-02f, 1.06282704e-01f, -1.39980778e-01f,
  -4.43643592e-02f, -2.90187359e-01f, 3.33617896e-01f, -1.85507879e-01f, -9.46964324e-02f, -8.60409141e-02f, -4.01276380e-01f, -4.43409085e-02f, 3.26985829e-02f, -2.85307109e-01f,
  -4.73134667e-02f, -2.93194264e-01f, -5.88081591e-02f, 6.76310062e-02f, 2.31877729e-01f, 4.62911218e-01f, 5.05791828e-02f, 8.06152374e-02f, 3.47791702e-01f, -2.32210249e-01f,
  -7.51826614e-02f, 1.54615730e-01f, -1.51560724e-01f, 1.95936874e-01f, 6.19493648e-02f, 3.14793736e-01f, -9.04823393e-02f, -1.25786001e-02f, 1.17539093e-01f, 5.66381845e-04f,
  1.97069556e-01f, 2.61686519e-02f, 4.49847728e-02f, 2.31513396e-01f, 1.92985848e-01f, -1.99460164e-01f, -2.37727929e-02f, 8.80803391e-02f, 1.01075672e-01f, -1.49028664e-02f,
  4.75078858e-02f, 4.49543409e-02f, -3.31510268e-02f, -1.61277652e-02f, 1.34618640e-01f, 1.31282602e-02f, 1.33559972e-01f, 9.37242210e-02f, 1.00374110e-01f, 2.22955659e-01f,
  1.33061081e-01f, 2.74268091e-02f, 9.39666778e-02f, 1.85572103e-01f, 9.54332873e-02f, -6.83274791e-02f, 9.55796316e-02f, 5.29549867e-02f, 1.11904905e-04f, -1.81174034e-03f,
  -4.81082648e-02f, -2.83421315e-02f, 9.94512662e-02f, 2.24691201e-02f, 2.27628008e-01f, 1.16213650e-01f, 8.50988925e-02f, 6.09832443e-02f, 5.59779257e-02f, 5.96538633e-02f,
  6.81551844e-02f, 1.43602133e-01f, -5.99950328e-02f, 4.34195936e-01f, 5.63175883e-03f, -2.12382615e-01f, -2.21069697e-02f, 6.49452955e-02f, 1.16405755e-01f, 1.70878783e-01f,
  1.34383067e-02f, -6.23635501e-02f, -1.95939727e-02f, -2.45300960e-02f, -1.08914204e-01f, -1.53826147e-01f, -8.11124817e-02f, -8.20270181e-02f, -3.75708565e-04f, 7.08875284e-02f,
  -1.35982811e-01f, 1.17431484e-01f, -1.23270445e-01f, 1.82204574e-01f, -8.50113481e-02f, -3.95038426e-02f, 1.21396175e-02f, -2.41551563e-01f, -1.99129775e-01f, 1.19930178e-01f,
  6.65417090e-02f, 2.04159647e-01f, 5.34814456e-03f, 6.73651099e-02f, 1.20134309e-01f, 2.66008452e-02f, -7.92628303e-02f, -8.96243080e-02f, -2.80792192e-02f, -1.07904598e-01f,
  -7.82743394e-02f, 1.61971733e-01f, -1.10481232e-01f, 9.10641477e-02f, 1.49800748e-01f, -1.02770843e-01f, -6.19436800e-02f, -9.62996781e-02f, 2.92058527e-01f, -2.65225708e-01f,
  -1.83583304e-01f, -1.28606707e-01f, 3.55710119e-01f, -2.78173923e-01f, 2.04073668e-01f, 1.19911373e-01f, 7.38420617e-03f, 3.47263999e-02f, 3.55173469e-01f, 2.04713464e-01f,
  -5.98252788e-02f, 1.58478931e-01f, 1.14588358e-01f, -7.57715404e-02f, 8.63912925e-02f, -3.43984086e-03f, -1.46557018e-01f, 3.02105159e-01f, 1.66500509e-01f, 3.05725876e-02f,
  1.17651843e-01f, -2.19370127e-02f, -1.66273564e-01f, -1.46257162e-01f, 1.72546860e-02f, -3.25581431e-01f, -3.85003120e-01f, 6.26348794e-01f, 1.20199382e-01f, 1.02599904e-01f,
  -3.32101807e-02f, 1.28506035e-01f, 1.26235932e-01f, -4.55183797e-02f, -2.33524106e-02f, 1.37714654e-01f, 1.96763024e-01f, 2.14889087e-02f, -1.14716835e-01f, -3.57958153e-02f,
  7.42539093e-02f, 4.04685326e-02f, 5.78605104e-03f, 1.87639520e-01f, -1.81099232e-02f, 1.24302484e-01f, 2.60756135e-01f, 6.42858297e-02f, 2.24994779e-01f, 4.90316674e-02f,
  3.36622417e-01f, 3.45157124e-02f, -1.29680112e-01f, -8.59697070e-03f, 1.27476767e-01f, 8.06980580e-03f, 1.10177197e-01f, 1.38249457e-01f, -1.22007310e-01f, 2.63442621e-02f,
  6.41856343e-02f, 1.94798023e-01f, 1.44489706e-01f, 1.44408941e-01f, 4.90222499e-02f, 9.17298719e-02f, -1.61833525e-01f, 6.73390999e-02f, 7.96987787e-02f, 3.16105224e-02f,
  6.34417459e-02f, 1.16562881e-01f, 9.10355747e-02f, 1.04427099e-01f, 3.50300521e-02f, 3.11994702e-01f, 3.38440910e-02f, 1.67017817e-01f, 1.50376752e-01f, 1.14790164e-01f,
  5.50432131e-02f, -2.26371154e-01f, 1.23854704e-01f, 4.77975197e-02f, -3.49890918e-01f, 1.30578220e-01f, -1.35959685e-01f, -7.94274956e-02f, -2.68210322e-01f, -1.72067843e-02f,
  2.05062360e-01f, 1.92024663e-01f, 1.56454723e-02f, -4.76380497e-01f, -4.59701791e-02f, -3.27924243e-03f, -4.16632175e-01f, -1.78236559e-01f, -6.27096137e-03f, -4.13846038e-02f,
  -1.39567792e-01f, -6.39472976e-02f, -2.92970277e-02f, -5.35206608e-02f, 8.30354318e-02f, -2.14985967e-01f, 1.69724107e-01f, -4.54184525e-02f, 8.12501237e-02f, -4.82094288e-02f,
  -5.23244143e-02f, -1.96141005e-02f, -1.55090719e-01f, -2.15784330e-02f, 3.51448841e-02f, 4.04653639e-01f, -6.17900789e-02f, 2.17748970e-01f, -1.11612648e-01f, -5.63628301e-02f,
  3.26155946e-02f, 2.42698174e-02f, 3.29361409e-02f, -1.04447939e-01f, -1.71081096e-01f, 2.74771694e-02f, 8.53381231e-02f, 2.54860103e-01f, 2.30413437e-01f, -1.43637866e-01f,
  9.06881839e-02f, 1.53995439e-01f, -1.76642165e-01f, -6.84405267e-02f, 1.66327894e-01f, -2.92294975e-02f, -1.71919599e-01f, -1.05382659e-01f, 3.35326582e-01f, -1.25969737e-03f,
  -1.48369614e-02f, -4.92428709e-03f, -1.08972248e-02f, -1.03752524e-01f, -6.33638427e-02f, -2.51516521e-01f, 5.66789173e-02f, 3.59917805e-02f, 5.75056672e-02f, 1.47148833e-01f,
  3.64261329e-01f, 4.15159225e-01f, 2.37058595e-01f, -1.02358900e-01f, 7.66843915e-01f, -1.47153705e-01f, 1.48799583e-01f, 1.16818339e-01f, 1.85120866e-01f, 9.79434475e-02f,
  1.71142519e-01f, 2.59095207e-02f, -3.77342813e-02f, -1.37631977e-02f, 1.27802538e-02f, 2.20788736e-02f, 7.20891356e-02f, -7.27107422e-03f, 1.35624528e-01f, 1.23160370e-01f,
  -1.21060992e-02f, 2.84738969e-02f, -1.28622307e-02f, -1.13306278e-02f, 1.45301521e-01f, -7.58594871e-02f, 1.30301908e-01f, 4.77646217e-02f, 3.51116396e-02f, -9.48209036e-03f,
  7.98079893e-02f, 4.61936295e-02f, 2.09128141e-01f, 4.33677398e-02f, 2.45938338e-02f, 5.91115505e-02f, 1.22757919e-01f, 1.76131893e-02f, 1.10974990e-01f, -7.92045370e-02f,
  7.33346418e-02f, 1.01998739e-01f, 1.46651715e-01f, 1.50065362e-01f, 4.07499969e-02f, 1.13960905e-02f, -1.02735311e-01f, -1.85416907e-01f, -5.71987033e-02f, 6.92234710e-02f,
  3.12400132e-01f, 2.82082081e-01f, 1.68263584e-01f, 2.32698873e-01f, 1.46751180e-01f, 7.76639506e-02f, -1.94975995e-02f, -4.88430336e-02f, -2.06537873e-01f, 2.63150781e-01f,
  -1.57915577e-01f, -8.58376101e-02f, -9.51390788e-02f, 7.16684461e-02f, 6.20976649e-02f, 1.47951752e-01f, 1.54699102e-01f, 1.69303156e-02f, -1.11417867e-01f, 1.09711863e-01f,
  -9.40560549e-03f, 6.52390048e-02f, -4.88739237e-02f, -9.41518247e-02f, -1.91077784e-01f, 1.60334203e-02f, 3.87873128e-02f, -4.71984589e-04f, 6.26945719e-02f, -3.26280408e-02f,
  -9.71917883e-02f, 1.09585166e-01f, 3.52497143e-03f, 8.88801813e-02f, 1.55692160e-01f, -3.85174640e-02f, -8.01101848e-02f, 4.12021624e-03f, -5.47198672e-03f, -2.18957826e-01f,
  1.54501632e-01f, 2.48144753e-02f, 6.50506243e-02f, 4.30119166e-04f, -1.05936803e-01f, -1.00892104e-01f, 1.61711857e-01f, -6.63427934e-02f, 5.11300787e-02f, -9.02592689e-02f,
  -1.96371097e-02f, -1.53322458e-01f, 7.69994929e-02f, -3.63756977e-02f, 3.29677761e-01f, 7.39468485e-02f, -8.36683959e-02f, -7.56853893e-02f, 3.23375702e-01f, -2.64152974e-01f,
  6.29553556e-01f, 9.07747597e-02f, 1.21199489e-01f, -3.94288488e-02f, 3.71668011e-01f, 1.97129503e-01f, 1.25747070e-01f, 1.31421909e-01f, 1.89429194e-01f, 1.64862156e-01f,
  -2.11735293e-01f, 6.78545460e-02f, 4.64042693e-01f, -5.42627238e-02f, 2.63033584e-02f, -2.46799421e-02f, 1.63086146e-01f, 2.93213204e-02f, -2.55277574e-01f, 1.40010536e-01f,
  2.01284558e-01f, -1.47669509e-01f, -3.44456941e-01f, 1.12141468e-01f, 1.74071059e-01f, 1.41113058e-01f, 3.03349495e-01f, 6.49319515e-02f, 1.05846673e-01f, 2.56970555e-01f,
  1.21671028e-01f, 1.41314983e-01f, 2.98981100e-01f, 6.10637479e-02f, 4.25862931e-02f, 1.19012974e-01f, 1.26362041e-01f, 9.30016637e-02f, -1.74184933e-01f, 2.40298510e-01f,
  3.24301794e-02f, 9.36141014e-02f, -1.16204388e-01f, 9.99554098e-02f, 1.49419814e-01f, 2.79855520e-01f, 9.87036973e-02f, 1.01090245e-01f, 1.03829570e-01f, 2.21240640e-01f,
  2.66416520e-01f, 1.30729064e-01f, -3.38016427e-03f, 1.28686532e-01f, 1.08465217e-01f, 3.59259337e-01f, 1.80135518e-02f, 6.30234778e-02f, 2.75256373e-02f, -5.60190678e-02f,
  1.53867593e-02f, 2.17446670e-01f, 1.02558628e-01f, 3.14232484e-02f, 1.46642119e-01f, 9.32637602e-02f, -1.60423443e-02f, 1.33839756e-01f, 7.39654824e-02f, -8.92498121e-02f,
  1.23390153e-01f, 1.18722543e-01f, -8.25665817e-02f, 2.49043405e-01f, -1.13849141e-01f, -3.03269196e-02f, 1.86115235e-01f, -7.06222057e-02f, 3.02843958e-01f, -1.41980201e-02f,
  8.21741018e-03f, -9.39898007e-03f, -1.36594519e-01f, -1.67577326e-01f, -4.30619955e-01f, 1.80742934e-01f, 1.68274432e-01f, -1.51029691e-01f, -3.57474051e-02f, -1.48674205e-01f,
  -6.23997883e-04f, 1.42065808e-01f, 2.73296267e-01f, 4.86990847e-02f, 7.12571740e-02f, 1.84916198e-01f, -1.18767232e-01f, 1.38865402e-02f, -6.82749227e-02f, -1.56941661e-03f,
  -1.15444295e-01f, -8.96736048e-03f, -2.09726244e-02f, -3.67496461e-02f, 1.66041225e-01f, -4.09801334e-01f, -4.33254689e-02f, -2.57198252e-02f, -3.42350155e-02f, 7.99462870e-02f,
  -2.01703250e-01f, 4.85263169e-01f, -1.01786498e-02f, 5.28773740e-02f, -3.06249596e-02f, -1.49514005e-01f, -1.12622283e-01f, 5.73522560e-02f, 5.00772335e-02f, -1.24085248e-01f,
  -1.36643276e-01f, -1.81976333e-01f, 9.09005404e-02f, -4.18652361e-03f, 3.23844880e-01f, 4.16320004e-02f, -1.96577743e-01f, 3.98513794e-01f, 8.94017518e-02f, -4.13722008e-01f,
  -2.42385581e-01f, 1.27635509e-01f, -1.07139871e-01f, 2.08754078e-01f, 5.73022544e-01f, 8.72537717e-02f, 2.24304367e-02f, -1.63915902e-01f, 6.86621547e-01f, 7.11809173e-02f,
  -1.09813521e-02f, 2.87618965e-01f, -2.08833199e-02f, 3.32766414e-01f, -1.61298245e-01f, 2.18134448e-02f, 4.53839570e-01f, 3.16373222e-02f, -3.54508907e-01f, 4.90928767e-03f,
  4.53358740e-01f, 5.83521910e-02f, 1.52498528e-01f, 4.05602716e-02f, 1.65203676e-01f, -1.30804237e-02f, 3.29188481e-02f, 5.97614683e-02f, 1.58617079e-01f, -2.12284401e-02f,
  1.11766852e-01f, 7.62160420e-02f, 1.33329093e-01f, -9.03499126e-02f, 5.53295910e-02f, 1.57822505e-01f, 5.98718366e-03f, -2.50921875e-01f, -2.38750428e-02f, 7.37457499e-02f,
  -1.01755094e-02f, 1.61614299e-01f, 7.07511678e-02f, 1.35188207e-01f, -2.37255469e-02f, -5.66960014e-02f, 1.05807506e-01f, 3.76593471e-02f, 1.30141720e-01f, -7.64860306e-03f,
  5.33603169e-02f, 3.77569981e-02f, 9.08619091e-02f, 7.91522786e-02f, 1.28311977e-01f, -4.74574603e-02f, -2.08205450e-02f, -3.67702954e-02f, 4.24358733e-02f, -1.52118094e-02f,
  2.90949613e-01f, 5.99277914e-02f, -7.93876722e-02f, 7.74591863e-02f, 3.04403622e-02f, 3.22752073e-02f, 1.52634755e-01f, 7.47866631e-02f, 2.06349418e-02f, 2.97830731e-01f,
  8.92845690e-02f, 2.99477857e-02f, 1.27460748e-01f, -1.26692191e-01f, 1.12386495e-01f, 3.53417695e-01f, -2.81723022e-01f, 3.65836360e-02f, 9.67482477e-02f, 7.82785639e-02f,
  1.51362449e-01f, 1.61371708e-01f, 1.16521344e-01f, -7.94849247e-02f, -6.67107478e-02f, 1.75360844e-01f, 9.30467620e-02f, 1.79258928e-01f, 1.31914452e-01f, 5.44286035e-02f,
  2.58423239e-02f, 1.90616269e-02f, -1.95684299e-01f, 1.08119257e-01f, 9.30534154e-02f, 3.42748384e-03f, 5.50268479e-02f, 2.01432243e-01f, 9.29790735e-02f, 1.79165095e-01f,
  -3.72862183e-02f, -4.60897665e-03f, 6.30892394e-03f, 1.62081525e-01f, 8.19762647e-02f, 1.84201017e-01f, 4.89339456e-02f, 2.96960920e-02f, 1.08139835e-01f, -3.04046929e-01f,
  4.69689816e-02f, -1.06315650e-01f, -5.51583357e-02f, 1.52799487e-01f, -5.76210842e-02f, -9.17517692e-02f, -1.33158982e-01f, 1.54268816e-01f, 1.25604374e-02f, 1.00979798e-01f,
  -1.75851583e-01f, -6.30532876e-02f, -1.60428941e-01f, 1.18135393e-01f, -2.55690873e-01f, -3.66192609e-01f, -1.17326684e-01f, 6.80151507e-02f, 2.92118013e-01f, 1.50697187e-01f,
  8.62189680e-02f, 2.46934608e-01f, -2.97931999e-01f, 2.55030036e-01f, 3.74331594e-01f, 1.72632724e-01f, 6.61213603e-03f, 1.31133184e-01f, -5.77054620e-02f, 2.83068925e-01f,
  2.19817027e-01f, 7.09560066e-02f, 2.00174138e-01f, -1.54345129e-02f, -3.37103307e-01f, -4.40240264e-01f, 6.12300262e-02f, 3.01520769e-02f, -4.47670758e-01f, 4.37879473e-01f,
  1.32309228e-01f, 4.51565087e-02f, -2.19185315e-02f, 5.02178967e-02f, 3.19163054e-02f, 9.72504243e-02f, 5.01709431e-02f, 1.79832473e-01f, 1.52320452e-02f, 9.38489735e-02f,
  2.23803684e-01f, 1.81794003e-01f, 4.90153953e-03f, 5.30298240e-02f, 2.62199361e-02f, 3.71148549e-02f, -2.14636810e-02f, 1.22873329e-01f, -8.84966403e-02f, -1.21244468e-01f,
  7.83513263e-02f, 1.56927943e-01f, -6.74436837e-02f, 2.23463681e-02f, -9.84687209e-02f, 2.00659939e-04f, -7.95737877e-02f, -2.76644789e-02f, 1.23034850e-01f, 6.00881241e-02f,
  8.90405476e-02f, -3.46318707e-02f, -4.39133532e-02f, 5.83632849e-02f, -3.36941667e-02f, -2.42976397e-02f, 1.55959323e-01f, 1.73636466e-01f, -2.69620754e-02f, 1.29895329e-01f,
  1.15774393e-01f, 1.41448778e-04f, -1.08270667e-01f, 2.83779074e-02f, 1.48156732e-01f, 1.01837181e-01f, 1.21744998e-01f, 1.59745932e-01f, 6.40830174e-02f, 1.16551243e-01f,
  -8.96096826e-02f, -1.76408932e-01f, 8.41545463e-02f, 2.14249417e-01f, 3.05163357e-02f, 1.46057578e-02f, -5.23607880e-02f, -7.14332461e-02f, 1.21917419e-01f, 5.00470726e-03f,
  -2.00144965e-02f, 5.16588315e-02f, -1.95757553e-01f, -3.29682007e-02f, -8.22749212e-02f, -1.81929395e-02f, -1.96657240e-01f, 1.53822020e-01f, 9.23900008e-02f, -6.80618435e-02f,
  1.42836511e-01f, 8.80594477e-02f, 1.70844778e-01f, -8.43955651e-02f, 1.69177160e-01f, 2.41209865e-02f, -2.24551056e-02f, -1.28789634e-01f, 6.18931688e-02f, 8.15367177e-02f,
  -7.16584409e-03f, -3.07678401e-01f, -3.03014606e-01f, -7.01334476e-02f, -2.64520440e-02f, 3.05275232e-01f, -1.68664500e-01f, 4.31766987e-01f, -1.46504873e-02f, 9.74548981e-02f,
  2.78453752e-02f, -2.88186878e-01f, 6.13518618e-02f, -5.42669743e-02f, -2.96816062e-02f, -6.67199641e-02f, 8.88960287e-02f, -3.14792693e-01f, 2.71855801e-01f, 1.03214204e-01f,
  3.92503411e-01f, 6.22976758e-02f, -4.60252305e-03f, -7.18559995e-02f, 3.29662621e-01f, -1.92167923e-01f, -3.68506819e-01f, 1.31762743e-01f, -2.35298365e-01f, 8.18634406e-02f,
  3.62675130e-01f, 1.21630080e-01f, 2.23171458e-01f, -2.64718104e-02f, 2.63472170e-01f, 1.96440130e-01f, 1.33233383e-01f, 1.86858773e-01f, -8.77576917e-02f, 2.39984840e-01f,
  -8.36400781e-03f, -1.63639467e-02f, 6.38127979e-03f, -1.69442385e-01f, 1.46530867e-01f, -2.64121741e-01f, 4.40086285e-03f, 9.56256241e-02f, 1.94942549e-01f, 1.76385388e-01f,
  1.26203090e-01f, 1.62417844e-01f, -2.76558679e-02f, 1.23256601e-01f, 3.99951683e-03f, -1.71309933e-02f, 3.18983138e-01f, 1.10488512e-01f, 1.99865773e-01f, -4.70845141e-02f,
  2.46299416e-01f, 2.84338538e-02f, 2.33406201e-02f, -1.63408458e-01f, 6.65020198e-02f, 1.04732871e-01f, 9.92864594e-02f, 2.42424443e-01f, 1.21984921e-01f, 7.60223120e-02f,
  2.13846564e-01f, 2.45196316e-02f, -5.90532012e-02f, 1.25577092e-01f, 5.62571287e-02f, 1.64414346e-02f, 5.92765734e-02f, 1.03185132e-01f, 2.49536484e-01f, 6.67943954e-02f,
  1.94388330e-01f, 2.64774106e-04f, 1.21398665e-01f, 1.74834475e-01f, 2.62800872e-01f, 1.88452527e-02f, 1.02825515e-01f, 1.05873108e-01f, 1.49369940e-01f, 2.54262537e-01f,
  1.73792150e-02f, 2.29406610e-01f, 8.90877098e-02f, 1.71496108e-01f, 2.24274144e-01f, 1.91394344e-01f, 6.77145794e-02f, 1.67180359e-01f, -6.55873418e-02f, -2.23982587e-01f,
  -9.70498659e-03f, -6.08093441e-02f, -4.57049340e-01f, 1.44061849e-01f, 2.61444505e-02f, -4.16193083e-02f, -4.39917035e-02f, 2.36927658e-01f, 1.51109621e-01f, -1.57797843e-01f,
  1.69450659e-02f, 2.97053337e-01f, 1.60772223e-02f, 1.30427733e-01f, 2.23497495e-01f, 1.74497753e-01f, -7.49955177e-02f, -5.09969890e-02f, -2.79775649e-01f, 1.23691507e-01f,
  -3.92654613e-02f, -2.37093791e-01f, 1.00647241e-01f, 4.51391637e-02f, -3.50481778e-01f, 5.32985590e-02f, -1.40006188e-02f, 1.64032474e-01f, -1.11052312e-01f, 3.34160358e-01f,
  -1.94638625e-01f, -2.32415274e-02f, 1.98852509e-01f, -2.05159467e-02f, 8.30081701e-02f, -3.08276355e-01f, 2.96467915e-02f, -1.25815943e-01f, -1.49961188e-01f, 4.28004973e-02f,
  -7.19964653e-02f, -1.18067451e-01f, -2.02229217e-01f, -2.23989338e-01f, 2.22012982e-01f, 1.89757228e-01f, -2.11482957e-01f, -1.63646355e-01f, 2.25471705e-01f, 2.05458030e-01f,
  2.17399478e-01f, 1.75268218e-01f, -2.43475232e-02f, 8.77851695e-02f, -1.36053756e-01f, 1.63748205e-01f, -5.54102123e-01f, -3.56513932e-02f, 1.37773842e-01f, 1.56213462e-01f,
  1.87643319e-01f, -2.39135772e-01f, -2.86840856e-01f, 9.79174301e-02f, -2.48415917e-02f, 1.68700740e-01f, 1.08315282e-01f, -4.28987145e-01f, -2.00261059e-03f, -2.09475994e-01f,
  -7.32965861e-03f, -2.54959077e-01f, 8.40416178e-03f, -1.30014554e-01f, 2.92266905e-01f, 2.16841232e-02f, 8.49524885e-02f, 6.60929754e-02f, 1.07460916e-01f, 1.55705512e-01f,
  -8.43404979e-02f, 2.11661264e-01f, 4.60167862e-02f, 2.87428871e-02f, 6.54266030e-02f, 1.35886818e-01f, 2.15335160e-01f, 3.05025373e-02f, 1.76533669e-01f, 1.64086763e-02f,
  1.49089962e-01f, 2.09726065e-01f, 6.97622150e-02f, 1.52672343e-02f, -2.01937053e-02f, 4.39214073e-02f, 1.91234410e-01f, -3.84217054e-02f, 3.79632831e-01f, -9.84866265e-03f,
  -2.83216536e-02f, 1.49585560e-01f, -5.89706302e-02f, 7.44296759e-02f, 6.46170303e-02f, -1.02506682e-01f, 1.60568669e-01f, 4.57848348e-02f, 1.93885505e-01f, 4.33036350e-02f,
  2.13721305e-01f, 1.38240308e-01f, 2.27727145e-01f, 9.00667235e-02f, -2.68281437e-02f, 7.13716969e-02f, 2.18989611e-01f, -9.61519033e-02f, -1.40835658e-01f, 1.46385133e-01f,
  -3.45135853e-02f, 1.71238869e-01f, 1.97626486e-01f, 2.76156634e-01f, -6.75735325e-02f, 2.55385507e-02f, 1.36904463e-01f, -1.76014930e-01f, 3.34950089e-02f, -2.45801270e-01f,
  -1.12322941e-01f, 1.64944440e-01f, -2.18910813e-01f, 1.67603679e-02f, -1.00037031e-01f, -1.43639548e-02f, -5.75249717e-02f, -9.63890851e-02f, 4.15723585e-02f, 9.18168053e-02f,
  -2.05358416e-02f, 4.15929146e-02f, 2.21120626e-01f, -1.36264667e-01f, -1.40941665e-01f, -1.98136438e-02f, -1.84506461e-01f, -5.07193506e-02f, -7.49414861e-02f, 7.09820613e-02f,
  -1.80048153e-01f, -2.21289366e-01f, -1.33184776e-01f, 2.05202013e-01f, -5.91201149e-03f, 8.37255716e-02f, -1.69639200e-01f, 1.61955148e-01f, -2.01671332e-01f, -3.84829156e-02f,
  1.56986773e-01f, 6.44944459e-02f, -5.28193489e-02f, -1.34011403e-01f, 9.04700905e-03f, 1.71865657e-01f, -2.29112804e-01f, -1.74506649e-01f, 5.14089651e-02f, 1.89143151e-01f,
  2.12938944e-03f, -1.72985360e-01f, -1.42009789e-02f, 3.20772499e-01f, -2.64831752e-01f, 5.48364520e-02f, 6.09565005e-02f, -1.12152718e-01f, -5.59782563e-03f, -7.28394017e-02f,
  -1.28295362e-01f, 1.10190414e-01f, -2.16473360e-02f, 1.52052224e-01f, -1.34913698e-01f, 9.00923461e-02f, -1.26775220e-01f, 9.65230167e-02f, -1.98427767e-01f, 1.05984353e-01f,
  -9.15335864e-02f, -2.24512503e-01f, 5.15910797e-02f, 3.59395817e-02f, 8.73797312e-02f, -8.08624998e-02f, -4.72764745e-02f, -2.48532116e-01f, 3.05508435e-01f, 6.33369014e-02f,
  -1.33123517e-01f, 1.91928521e-01f, 3.67080450e-01f, -1.57485500e-01f, -1.72537770e-02f, 3.30295675e-02f, 5.26122283e-03f, 1.28812641e-01f, 3.56899612e-02f, 1.58933282e-01f,
  -1.21116444e-01f, -5.48195140e-03f, -1.87726244e-01f, 2.72093922e-01f, -3.38458307e-02f, 1.01964347e-01f, 3.29504460e-02f, -6.23828173e-02f, 5.16362786e-02f, 6.55964315e-02f,
  1.48124143e-01f, 8.75629783e-02f, 4.61038053e-02f, -6.99399188e-02f, -5.40024461e-03f, -1.25427827e-01f, 5.06980345e-02f, 1.27670094e-01f, 1.11119216e-02f, 5.86564690e-02f,
  -9.02825594e-02f, 2.41581082e-01f, 6.19304460e-03f, 2.52515133e-02f, 9.85365510e-02f, -9.88990366e-02f, 2.52006878e-03f, 1.58045039e-01f, 3.24145821e-03f, 1.28110990e-01f,
  3.30291271e-01f, -1.60084013e-02f, 2.67863888e-02f, 9.59413201e-02f, 1.05947956e-01f, -9.80852619e-02f, 5.41986302e-02f, 1.24928430e-01f, 7.10091218e-02f, 1.37807310e-01f,
  5.76051250e-02f, 4.57141176e-03f, 1.59013316e-01f, -2.28279773e-02f, -4.81437966e-02f, 1.47019207e-01f, 2.03696061e-02f, -4.40376192e-01f, 5.57991974e-02f, 7.45080113e-02f,
  9.21200067e-02f, 8.25191215e-02f, -1.99363735e-02f, -1.63081866e-02f, 1.37919471e-01f, -3.27226855e-02f, 7.19087198e-02f, -1.13289282e-01f, 6.80399984e-02f, -1.70640871e-01f,
  1.70052081e-01f, -5.09535931e-02f, 1.03814907e-01f, 1.23135867e-02f, 2.34874599e-02f, -1.29599363e-01f, -1.51320798e-02f, 1.06047736e-02f, -1.35252729e-01f, -2.01962784e-01f,
  -1.39491573e-01f, 1.09300777e-01f, -4.17293757e-02f, 6.18347377e-02f, 1.25064673e-02f, 1.65541723e-01f, -2.90320516e-02f, -2.14279950e-01f, 1.31581679e-01f, -1.63829625e-02f,
  4.26075943e-02f, -1.30576715e-01f, 3.84402904e-03f, 6.58956170e-02f, 1.31841466e-01f, 2.60987878e-03f, 1.52331397e-01f, 3.58704850e-02f, -3.59980613e-02f, -3.53581235e-02f,
  -7.87938982e-02f, 3.93314064e-02f, 1.81563526e-01f, -9.13537387e-03f, -1.50663376e-01f, -1.13762751e-01f, 6.81731328e-02f, 3.54607880e-01f, -2.26303637e-01f, 1.37168288e-01f,
  2.70608276e-01f, 3.03074509e-01f, 3.64952117e-01f, -1.04708202e-01f, -1.42974347e-01f, -7.05070123e-02f, -7.72894472e-02f, -1.35224462e-02f, -1.01276554e-01f, 9.07709543e-03f,
  3.62744570e-01f, -1.13882907e-01f, 1.36008710e-01f, 1.82057515e-01f, -3.57344896e-02f, 3.89716834e-01f, 2.37657353e-01f, 6.13256514e-01f, 1.96542069e-01f, 3.44947316e-02f,
  -1.15446240e-01f, -2.28148967e-01f, 2.67798275e-01f, 8.43372494e-02f, 3.39655936e-01f, 1.01759667e-02f, -1.71152666e-01f, 1.78938154e-02f, -1.72536131e-02f, 2.26217210e-02f,
  1.48486808e-01f, 2.44142070e-01f, -1.91353604e-01f, 3.00040662e-01f, 1.41481832e-01f, -1.53488204e-01f, 8.46394151e-02f, 2.59653240e-01f, 6.27318583e-03f, 2.09766358e-01f,
  -5.28577268e-02f, 1.97577626e-01f, 7.99572319e-02f, -9.19881612e-02f, 3.18761170e-01f, 3.84336151e-02f, 5.94923757e-02f, 7.99537972e-02f, -9.04867128e-02f, 1.26979575e-01f,
  3.86000797e-02f, -6.34219646e-02f, 2.36195743e-01f, 7.02091679e-02f, 3.60339023e-02f, 1.78905856e-02f, 5.08541986e-02f, 2.01102048e-01f, 6.88511431e-02f, 9.32467058e-02f,
  1.02863938e-01f, 7.98129141e-02f, 1.84576437e-02f, 2.74974287e-01f, -1.38325557e-01f, 9.87176448e-02f, -8.40822086e-02f, -2.12288737e-01f, 2.06865564e-01f, 3.72286066e-02f,
  1.00624776e-02f, 1.20665602e-01f, 8.07375759e-02f, -2.19490469e-01f, 6.24492988e-02f, -2.90498286e-01f, -2.38918588e-01f, 1.95875809e-01f, 2.67694473e-01f, -2.05660518e-02f,
  -3.42401229e-02f, -3.06298941e-01f, 7.66800195e-02f, -2.25677535e-01f, 3.38696204e-02f, 1.94231331e-01f, -2.11339556e-02f, 5.59598327e-01f, 1.18658848e-01f, 1.90553844e-01f,
  2.24191248e-02f, 1.99732006e-01f, -2.23915964e-01f, 1.82320941e-02f, -1.44033805e-01f, -1.32193521e-01f, 1.25652835e-01f, 2.16462255e-01f, -1.97391465e-01f, 5.63949384e-02f,
  -1.04973845e-01f, -2.80325580e-02f, -2.22869024e-01f, 2.51011550e-02f, -2.23103151e-01f, 2.33888835e-01f, 9.53924730e-02f, -7.88718313e-02f, -2.15435192e-01f, -3.51039529e-01f,
  6.99387863e-02f, -7.79581666e-02f, 8.26931223e-02f, 7.34165162e-02f, 4.93583791e-02f, -1.46439999e-01f, -3.02846879e-01f, -3.71304117e-02f, 2.72393733e-01f, 2.56727904e-01f,
  -5.07405698e-01f, 7.51225874e-02f, 7.54512474e-02f, 2.85740882e-01f, -2.27345154e-01f, -1.75295755e-01f, -8.92107934e-02f, -2.39239916e-01f, 7.42173493e-02f, 8.37219879e-02f,
  -6.14374220e-01f, 2.97133736e-02f, 2.09483698e-01f, 9.17334631e-02f, 2.14015707e-01f, 9.91057791e-03f, -1.11736238e-01f, -4.84380931e-01f, 2.63358921e-01f, 2.91576628e-02f,
  -1.64312154e-01f, -4.04387206e-01f, -4.11862656e-02f, 8.09565857e-02f, -8.89265984e-02f, 1.92871466e-01f, -2.19462320e-01f, 1.57675549e-01f, 7.91974962e-02f, -2.12498039e-01f,
  1.17843024e-01f, 1.33390501e-01f, 1.92213841e-02f, 2.70881683e-01f, -3.02076228e-02f, 1.66742474e-01f, -1.22728612e-04f, 4.05667089e-02f, 5.82015291e-02f, 9.41051915e-02f,
  1.61214560e-01f, -9.62064788e-02f, 1.83782488e-01f, -1.23279639e-01f, 9.32820365e-02f, 1.28137022e-01f, 2.89953463e-02f, 2.76305526e-01f, -6.66254759e-02f, -1.26377001e-01f,
  1.86041266e-01f, 4.08264250e-02f, 2.90656179e-01f, -1.93920138e-03f, -9.57225040e-02f, 1.47142693e-01f, -4.60694209e-02f, 3.18141305e-04f, 9.71596465e-02f, 1.50254339e-01f,
  8.00020993e-02f, 2.22019896e-01f, -6.31580921e-03f, 1.90917790e-01f, -1.97327305e-02f, 2.82878280e-02f, 1.88669622e-01f, 2.63546612e-02f, 2.59895772e-01f, 3.43212555e-03f,
  5.57284728e-02f, 9.40848142e-02f, -1.53883398e-01f, 8.44661146e-02f, 4.53679524e-02f, 1.80238113e-01f, 7.44897425e-02f, 4.21842709e-02f, -6.77020242e-03f, 2.45338753e-01f,
  2.64620185e-02f, 5.10094240e-02f, 5.91451786e-02f, 4.03926790e-01f, 3.20354372e-01f, -5.04185148e-02f, -4.74414796e-01f, -9.21947584e-02f, -3.39919180e-01f, -8.34242627e-02f,
  -3.41751605e-01f, -2.49956921e-01f, 1.22230157e-01f, 3.14226210e-01f, 8.84357095e-03f, -2.34530017e-01f, -1.78514361e-01f, 2.74005830e-01f, -2.16353238e-02f, -1.00087494e-01f,
  -2.81380445e-01f, 4.71971482e-02f, -9.45324153e-02f, -8.55475217e-02f, -2.01141447e-01f, -2.68375009e-01f, 2.80590951e-02f, -2.46073648e-01f, 1.81918684e-02f, -8.31887871e-02f,
  1.89902484e-01f, 3.78244340e-01f, -3.48998666e-01f, 1.20631695e-01f, -1.44135684e-01f, -7.28255743e-03f, 2.28928059e-01f, -7.05719963e-02f, -1.46468068e-02f, -9.19494927e-02f,
  -9.37373266e-02f, 2.54053604e-02f, -5.17444536e-02f, -7.74246082e-02f, 1.05494164e-01f, -6.73847377e-01f, -2.32898872e-02f, 1.54513046e-01f, -2.05109224e-01f, 8.54625106e-02f,
  1.89594835e-01f, 4.99107018e-02f, 3.83966953e-01f, 7.90592097e-03f, -7.57117793e-02f, -1.80334672e-01f, -2.43109256e-01f, 1.22430407e-01f, -3.14309716e-01f, -4.37902808e-01f,
  2.82922775e-01f, 1.79041922e-01f, 1.52347714e-01f, -1.11817338e-01f, -4.42455113e-01f, -6.39970182e-03f, -7.79386461e-01f, -7.49649946e-03f, 2.60982990e-01f, -2.77598917e-01f,
  -1.21135980e-01f, -1.05404429e-01f, 3.64721745e-01f, 3.12783450e-01f, 2.89767161e-02f, -1.33639514e-01f, -6.09247796e-02f, 4.53008533e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 26)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 26;
const float L1_fan_Bp_bar_data[] = {
  2.04033837e-01f, 2.60003030e-01f, 1.54218316e-01f, 6.18159473e-02f, 8.37020054e-02f, 5.00740968e-02f, 7.51186311e-02f, 1.93716854e-01f, 6.88640773e-02f, 6.06317967e-02f,
  2.03800291e-01f, 5.18050492e-02f, 6.96925074e-02f, 7.23781958e-02f, 1.05361054e-02f, 9.58295539e-02f, 1.07395306e-01f, 2.57903665e-01f, 1.33514106e-01f, 1.32062420e-01f,
  9.97745767e-02f, 1.87082261e-01f, 2.29091212e-01f, -6.81824563e-03f, 2.14656562e-01f, 4.47590426e-02f
};

// L2_linear_W (Shape: 12 x 128)
const int L2_linear_W_rows = 12;
const int L2_linear_W_cols = 128;
const float L2_linear_W_data[] = {
  8.01788270e-02f, 1.29523098e-01f, -6.18401449e-03f, -3.68587635e-02f, -1.81156576e-01f, 2.22866982e-02f, 6.00597113e-02f, -9.58791748e-03f, -2.88939804e-01f, -3.85708399e-02f,
  -2.30893150e-01f, -6.51539266e-02f, -1.83476314e-01f, -2.67278701e-01f, -2.02807337e-02f, -9.54289362e-02f, 3.37078087e-02f, 6.79664090e-02f, 2.27079034e-01f, -2.46406198e-01f,
  -1.65942982e-01f, -2.36219734e-01f, -1.51207417e-01f, 2.47480290e-04f, 1.46382019e-01f, 3.90331261e-02f, 7.83961043e-02f, -8.87249969e-03f, -1.01149734e-02f, 1.24451011e-01f,
  -1.61221549e-01f, -6.90391809e-02f, -6.53868029e-03f, -1.03431813e-01f, 2.21202727e-02f, 1.71825424e-01f, -1.05153769e-02f, -1.07016504e-01f, -1.56815067e-01f, -2.57781055e-02f,
  3.75832945e-01f, 1.13761507e-01f, -5.91150336e-02f, -1.59951150e-01f, 7.41059780e-02f, -2.81299651e-01f, 5.64583205e-03f, 1.42516075e-02f, 2.15813726e-01f, 1.83648363e-01f,
  -3.48681688e-01f, -4.16712224e-01f, -1.25270756e-02f, 9.28903148e-02f, -2.22019374e-01f, -1.29833221e-01f, -4.03475881e-01f, 1.52705554e-02f, 3.27702612e-01f, 2.08003148e-01f,
  9.31826904e-02f, 5.23358304e-03f, 2.29655668e-01f, 2.00172171e-01f, 1.00160010e-01f, 1.32003546e-01f, -1.28089517e-01f, -1.06639624e-01f, -1.39202192e-01f, -5.81674501e-02f,
  -2.00259313e-01f, -2.58878857e-01f, -2.76197374e-01f, 2.22296074e-01f, 2.80420035e-01f, -1.87613636e-01f, -6.16605394e-02f, -2.69877259e-02f, 4.29377139e-01f, -2.19242111e-01f,
  -9.52611938e-02f, -1.82335049e-01f, -2.12078854e-01f, 1.56785268e-02f, -3.13840985e-01f, -5.71994744e-02f, 1.42592877e-01f, 9.38065052e-02f, 8.25486407e-02f, -3.21426094e-01f,
  1.91532746e-01f, 3.06408815e-02f, 1.73897650e-02f, 2.50060827e-01f, -1.21438935e-01f, 1.71527401e-01f, -1.99902341e-01f, -1.96704552e-01f, -1.60466313e-01f, -2.63072662e-02f,
  -2.62728602e-01f, 2.79979054e-02f, 1.24051459e-01f, 2.84909885e-02f, -1.24657735e-01f, -1.72846556e-01f, -4.01239276e-01f, 2.34556839e-01f, -2.06740737e-01f, 2.34960899e-01f,
  -1.10274017e-01f, -3.29600692e-01f, -4.22002189e-02f, 3.28486323e-01f, -2.73859918e-01f, -3.20724934e-01f, -5.68672121e-02f, 1.13132350e-01f, -2.41767362e-01f, -2.20621690e-01f,
  -5.31023927e-02f, 1.44728586e-01f, -3.24628800e-01f, -4.31301296e-01f, -2.78481305e-01f, -4.88257483e-02f, -1.51675045e-01f, -1.61613062e-01f, 2.77364627e-02f, -8.35241824e-02f,
  -7.52163902e-02f, 1.44234002e-01f, 1.71926603e-01f, -3.22744966e-01f, -2.08894014e-01f, 1.05714977e-01f, -7.35309944e-02f, -1.50064737e-01f, 4.81715500e-02f, -7.83794001e-02f,
  1.33412227e-01f, -6.77682161e-02f, 2.29059458e-01f, -1.19554184e-01f, -1.22454442e-01f, -1.34039894e-01f, -4.70718145e-02f, -1.98145226e-01f, 1.66703790e-01f, -3.15508209e-02f,
  -6.43459335e-02f, -1.61762640e-01f, 7.90305843e-04f, 1.11614801e-01f, 4.24324460e-02f, -1.29446983e-01f, -3.85519527e-02f, 2.13521048e-01f, 2.86048204e-01f, 1.56720251e-01f,
  1.41936839e-01f, -1.76279191e-02f, -1.51791617e-01f, -3.08925845e-02f, -2.60274142e-01f, -1.55451357e-01f, 5.59673533e-02f, -2.26366386e-01f, 9.72703695e-02f, 1.31553605e-01f,
  -1.28602743e-01f, -6.71686679e-02f, -7.45377019e-02f, 1.49445310e-01f, 1.49182528e-01f, -1.16685480e-01f, -1.18114233e-01f, 1.05793647e-01f, -7.33161205e-03f, 3.12450320e-01f,
  1.66068390e-01f, -7.28831366e-02f, -3.06028843e-01f, 1.66833118e-01f, -1.03180751e-01f, 8.94288868e-02f, 5.91744334e-02f, 2.39132106e-01f, -1.20819487e-01f, -2.82290339e-01f,
  2.30176613e-01f, -2.60637194e-01f, -2.20677838e-01f, -2.70585716e-01f, -2.68123120e-01f, 2.95418769e-01f, 2.19835252e-01f, 1.59225091e-01f, -2.50205815e-01f, -3.15645158e-01f,
  1.92019254e-01f, -5.96252829e-02f, -2.39702649e-02f, -9.37958583e-02f, 2.61857480e-01f, -1.06702104e-01f, 4.40074831e-01f, -6.60809278e-02f, 8.57357960e-03f, 8.13714042e-02f,
  -2.07176894e-01f, 1.65045574e-01f, 3.80358160e-01f, 4.46222052e-02f, 1.64347410e-01f, 3.53601456e-01f, 1.48119062e-01f, -3.71961921e-01f, -1.65702313e-01f, 1.89213976e-01f,
  4.97903116e-02f, -7.61369243e-02f, 2.21499979e-01f, 2.17025101e-01f, -4.98575382e-02f, -4.47609127e-02f, 2.62698531e-01f, 2.95323998e-01f, 7.50857368e-02f, -2.81700373e-01f,
  -1.43049046e-01f, -3.97681952e-01f, -8.00670087e-02f, -1.56350285e-01f, 1.89632885e-02f, 6.89514205e-02f, -3.04368109e-01f, 8.32496583e-02f, 5.57451546e-02f, 4.03647348e-02f,
  -6.28784359e-01f, 5.88238351e-02f, 1.95536688e-01f, -3.47989261e-01f, -2.10554805e-02f, 3.37901831e-01f, -4.87122731e-03f, 1.30345926e-01f, -4.98115778e-01f, 1.58654168e-01f,
  1.29844740e-01f, 1.00615226e-01f, 7.21396655e-02f, -6.25242814e-02f, -4.79558140e-01f, 3.85657072e-01f, -1.92287326e-01f, 1.82589181e-02f, -1.19503634e-02f, 1.05948992e-01f,
  -1.26395330e-01f, 3.68055701e-02f, 1.26437113e-01f, -3.42461348e-01f, 7.20261782e-02f, 5.49711064e-02f, -1.64291024e-01f, 2.89925057e-02f, -2.72967275e-02f, -1.82897866e-01f,
  5.25986142e-02f, 1.41505241e-01f, -6.53007394e-03f, 8.32328051e-02f, -1.48536146e-01f, 1.57592874e-02f, 6.52118251e-02f, -4.12057526e-02f, -1.30887758e-02f, 2.12446190e-02f,
  -2.96490610e-01f, 2.63248198e-02f, 8.64853188e-02f, 6.97668493e-02f, -1.59325808e-01f, 1.78921074e-01f, 2.17643641e-02f, 1.62889790e-02f, -2.69905124e-02f, -2.17638507e-01f,
  -1.64664209e-01f, 4.67931367e-02f, -5.76210096e-02f, 7.80269355e-02f, -9.16818902e-03f, 1.19591542e-02f, 1.50851272e-02f, 1.18799791e-01f, -7.14923367e-02f, -3.07850037e-02f,
  -2.60757040e-02f, -1.35768116e-01f, 2.88386624e-02f, 2.25384627e-02f, -6.57475442e-02f, -1.50985956e-01f, -1.89095419e-02f, 1.62038326e-01f, 3.42181236e-01f, 3.38709474e-01f,
  6.01942688e-02f, 1.97596297e-01f, 3.17556597e-03f, 1.47680044e-01f, -4.15197462e-02f, -1.72659352e-01f, 7.82487467e-02f, -2.10556984e-01f, 1.75036103e-01f, 4.49067317e-02f,
  -2.48622820e-01f, 1.55742228e-01f, -7.77236521e-02f, -1.54272422e-01f, 1.68577552e-01f, -1.88259318e-01f, -2.98992157e-01f, 1.24960400e-01f, -1.34063438e-01f, -6.71557263e-02f,
  2.83260167e-01f, 1.60467908e-01f, 2.33350039e-01f, -2.46509716e-01f, 1.47203729e-01f, 2.17753828e-01f, -1.94916949e-01f, -2.86657196e-02f, -1.10175177e-01f, 8.42693672e-02f,
  -2.62849540e-01f, 4.44254167e-02f, 1.97686598e-01f, -2.98139662e-01f, 1.20221399e-01f, -3.59558105e-01f, 1.74113512e-01f, 1.37228966e-01f, -5.96610224e-03f, -5.86342476e-02f,
  2.20736936e-01f, -2.04901502e-01f, -5.83264828e-02f, -1.36977255e-01f, -5.82693145e-02f, 1.82265211e-02f, -2.42944174e-02f, 5.14101572e-02f, -2.66240597e-01f, 2.33510122e-01f,
  -1.89745411e-01f, -4.68009996e-04f, -2.07086563e-01f, 1.31835073e-01f, 1.81215286e-01f, -2.76387691e-01f, 2.46269796e-02f, -3.81371528e-01f, -3.99661303e-01f, 2.74381578e-01f,
  -5.17008007e-01f, -1.26730859e-01f, 1.84381738e-01f, -2.10904434e-01f, 2.77690053e-01f, -1.29753770e-02f, 3.04792911e-01f, -8.07467476e-02f, -2.54455879e-02f, -4.01262678e-02f,
  4.62159775e-02f, 1.93733089e-02f, -4.59770225e-02f, 3.70583087e-01f, -1.29788011e-01f, 9.34753641e-02f, -3.48715931e-02f, -2.53687166e-02f, -2.00035632e-01f, -1.78230941e-01f,
  5.41367708e-03f, 8.89368877e-02f, 3.77199799e-02f, -9.75896697e-03f, 4.34506200e-02f, 2.78978292e-02f, 5.57008490e-04f, -8.21673423e-02f, 1.00894399e-01f, 4.36587334e-02f,
  -2.39798889e-01f, -2.30227798e-01f, -4.29115482e-02f, 2.32586893e-03f, -2.13623852e-01f, 1.58784036e-02f, 1.96053401e-01f, -2.34107003e-01f, -6.85133711e-02f, 3.52957845e-02f,
  -4.58442539e-01f, -1.21632516e-01f, -1.81801960e-01f, -3.17311138e-02f, 9.88844484e-02f, -3.03205550e-01f, -6.85237423e-02f, 2.48065703e-02f, -1.36849716e-01f, 8.10578838e-02f,
  -4.77214791e-02f, -8.71933252e-02f, 2.81558353e-02f, 1.61178187e-01f, -1.53640121e-01f, 9.96328369e-02f, 6.65616319e-02f, 2.52744198e-01f, 9.30231586e-02f, -1.69031501e-01f,
  -3.48799169e-01f, 6.37086034e-02f, -2.28152320e-01f, 2.63233989e-01f, 3.81414555e-02f, -4.60930139e-01f, -4.71526794e-02f, -4.50664610e-01f, 3.52861106e-01f, -2.23731458e-01f,
  2.11535811e-01f, -1.62328809e-01f, -8.24558064e-02f, 1.58406571e-01f, 1.59755036e-01f, 1.51581571e-01f, -2.58651257e-01f, 4.64520184e-03f, 2.18214184e-01f, -4.55719605e-02f,
  2.47552201e-01f, -2.85508931e-01f, 2.04680488e-01f, 1.76817983e-01f, 2.35932067e-01f, -2.76060611e-01f, 2.57791251e-01f, 1.52176678e-01f, -3.66254538e-01f, 3.74819875e-01f,
  -1.68135837e-01f, -1.95121676e-01f, -1.47067413e-01f, 3.07496548e-01f, -4.16511670e-02f, -1.57633260e-01f, -1.26087353e-01f, 7.76140913e-02f, -2.48756513e-01f, 1.91964820e-01f,
  1.53544873e-01f, 8.91028047e-02f, 3.79490912e-01f, 9.34825465e-02f, -8.26269239e-02f, 4.39998461e-03f, 1.60102025e-01f, -3.05025876e-02f, 2.69292574e-02f, 3.44801873e-01f,
  -1.23065777e-01f, -1.48631632e-01f, -2.36533239e-01f, -8.59591886e-02f, -1.06361412e-01f, 7.69730732e-02f, 2.57928461e-01f, -2.82199413e-01f, 3.59369159e-01f, -9.80954319e-02f,
  -6.19814754e-01f, -3.86127569e-02f, -4.01958376e-02f, 5.16113117e-02f, -8.44000280e-02f, -5.38298368e-01f, -5.83446436e-02f, -3.98432314e-01f, -1.26144633e-01f, 2.48287674e-02f,
  -3.97747047e-02f, -1.78575531e-01f, 2.58195072e-01f, -5.25771141e-01f, 4.46744502e-01f, -5.21014929e-01f, 1.33810893e-01f, -3.72471452e-01f, 1.44054387e-02f, -4.76016939e-01f,
  -1.37710627e-02f, -2.62081265e-01f, 1.94963470e-01f, -1.65690213e-01f, -1.68558866e-01f, 1.47417290e-02f, 1.13927230e-01f, -1.24198928e-01f, -1.28141046e-01f, 1.11840710e-01f,
  1.90162122e-01f, 1.62575260e-01f, 5.88754341e-02f, -5.30696139e-02f, -1.46485031e-01f, 2.78842986e-01f, -9.28370953e-02f, 5.10017462e-02f, 9.16615352e-02f, -1.69981882e-01f,
  1.27355471e-01f, 2.07473278e-01f, 1.91342384e-01f, -2.98302203e-01f, -1.43432736e-01f, -2.40745023e-02f, 1.60379902e-01f, -1.35840803e-01f, -4.01634490e-03f, 1.84052259e-01f,
  9.45379734e-02f, -1.26774013e-01f, 1.56849191e-01f, -6.80151656e-02f, 4.39265482e-02f, 5.72732091e-02f, 1.15517050e-01f, 1.04647078e-01f, 2.90254354e-01f, -1.03590749e-01f,
  -1.28295958e-01f, 2.74595737e-01f, -3.02607268e-01f, -1.53679579e-01f, 1.87372863e-01f, -2.07544923e-01f, -1.50097199e-02f, 5.48802838e-02f, 5.25222421e-02f, -7.22118467e-02f,
  -1.27226949e-01f, 2.62980703e-02f, -8.15283321e-03f, 1.24988645e-01f, -1.83001965e-01f, 3.28943402e-01f, 3.90880376e-01f, -3.42031829e-02f, 2.18506753e-01f, -2.75005162e-01f,
  -1.84288487e-01f, -2.10360922e-02f, 2.68001348e-01f, -1.27344877e-01f, 7.77053460e-02f, -3.21678996e-01f, 1.83920711e-01f, -9.16809291e-02f, -1.78826973e-01f, -5.49080037e-02f,
  -4.81839865e-01f, 3.99719831e-03f, 2.54425019e-01f, 6.83207735e-02f, 1.20973907e-01f, 7.32370513e-03f, -2.13899642e-01f, -1.33667797e-01f, 1.33968785e-01f, 3.62296581e-01f,
  -2.60209352e-01f, 2.82070577e-01f, 1.82250235e-02f, -3.96687388e-02f, -1.86816186e-01f, 1.40405521e-01f, -2.35294253e-01f, 2.19295099e-01f, -2.27512509e-01f, 6.14381097e-02f,
  -3.64782304e-01f, 4.06627566e-01f, 8.65306780e-02f, -4.03942242e-02f, -2.95922577e-01f, 2.86485553e-01f, -1.09608769e-01f, -4.98072743e-01f, -1.26338392e-01f, -2.46986058e-02f,
  -2.59620726e-01f, -1.56859621e-01f, 1.65002093e-01f, -6.20389134e-02f, 8.85754302e-02f, -4.53229368e-01f, -4.88708884e-01f, -2.75285333e-01f, -5.17704152e-02f, 1.41119733e-01f,
  -1.57870464e-02f, 5.21422513e-02f, 6.76908195e-02f, -4.06269617e-02f, 2.44378403e-01f, -2.22009882e-01f, 6.28513172e-02f, 1.12922214e-01f, -3.54696274e-01f, -1.50168957e-02f,
  -2.40681134e-02f, 3.53396162e-02f, -3.95271555e-03f, -6.87236190e-02f, 1.42045632e-01f, -5.15690088e-01f, 3.03954743e-02f, 2.56999522e-01f, -1.31592929e-01f, -2.10721552e-01f,
  5.64980842e-02f, 1.82331949e-01f, 2.07896158e-01f, -2.39523277e-02f, 1.81276686e-02f, 1.74696431e-01f, 2.70376764e-02f, -6.12093788e-03f, 1.22631505e-01f, -4.42967229e-02f,
  9.93176773e-02f, 2.74550945e-01f, 1.45830989e-01f, 1.72415406e-01f, -5.50874248e-02f, 7.59341121e-02f, 2.36518174e-01f, 1.29810616e-01f, -2.31415510e-01f, 9.17179585e-02f,
  2.43731245e-01f, 8.46703127e-02f, -4.79045548e-02f, 1.89060196e-01f, -3.78713645e-02f, 3.35174426e-02f, 1.97418392e-01f, 3.52166183e-02f, 1.35917841e-02f, -2.07059771e-01f,
  -1.50153339e-01f, 2.35128269e-01f, -1.05977647e-01f, 1.88117713e-01f, -1.97861433e-01f, -1.72327936e-01f, 2.18214974e-01f, 1.98915541e-01f, 1.75185084e-01f, -4.29913662e-02f,
  1.08487993e-01f, -3.25941354e-01f, 9.21415165e-02f, 2.19645813e-01f, -5.26088737e-02f, 9.96565893e-02f, 5.14604757e-03f, 4.11969572e-01f, 1.83000579e-01f, -2.05207154e-01f,
  4.53815013e-02f, 1.16720416e-01f, -2.78087258e-01f, -4.27101329e-02f, -2.01259121e-01f, -2.68696696e-01f, -3.24160397e-01f, -1.39230371e-01f, 1.87151521e-01f, 2.39518806e-01f,
  -2.22261205e-01f, 1.99392915e-01f, -5.87743670e-02f, 1.33614674e-01f, 3.39321166e-01f, 1.50776476e-01f, 1.39802411e-01f, -3.17780115e-02f, 1.82242200e-01f, 2.16321722e-01f,
  -4.29514885e-01f, 3.15046281e-01f, -3.88680734e-02f, -2.80133784e-01f, 1.12486258e-01f, 2.80393772e-02f, -2.52852827e-01f, -4.38685305e-02f, -5.15029430e-02f, -3.33873987e-01f,
  2.06488803e-01f, 1.87201738e-01f, -2.48033833e-02f, 2.25776821e-01f, 1.39706388e-01f, -1.07178010e-01f, -3.38630944e-01f, -2.01311961e-01f, 9.64185745e-02f, 7.53203183e-02f,
  2.65662909e-01f, -1.81760997e-01f, -2.48696774e-01f, -2.32122421e-01f, 3.11124772e-02f, 8.08089077e-02f, 3.39465708e-01f, -4.05126400e-02f, -9.40234214e-02f, -3.19431424e-01f,
  1.78508669e-01f, -2.48078868e-01f, 1.36959508e-01f, -4.50423807e-02f, -1.24661759e-01f, -2.23195672e-01f, -5.20532988e-02f, -4.45478894e-02f, -3.09221029e-01f, 8.38405639e-02f,
  1.47315999e-02f, 2.68467903e-01f, 3.50853860e-01f, -3.79506610e-02f, -1.70870125e-01f, -1.44053802e-01f, -7.41278604e-02f, 4.04029861e-02f, -1.58562332e-01f, 7.07745180e-02f,
  -6.45279586e-01f, 2.50503778e-01f, -2.85845131e-01f, 1.07501768e-01f, 2.96626836e-02f, -2.10843310e-01f, 9.16571617e-02f, -5.29462039e-01f, 3.09441108e-02f, 2.62279883e-02f,
  2.12211564e-01f, -1.86118007e-01f, -1.59143314e-01f, 8.69870782e-02f, -1.63494825e-01f, -1.82193443e-01f, 7.44213611e-02f, -2.83324029e-02f, -1.03354014e-01f, -2.05454737e-01f,
  1.83713913e-01f, -1.12076215e-01f, -1.24151833e-01f, 9.21824276e-02f, 9.40579250e-02f, -9.83872265e-03f, 1.22473001e-01f, -1.81900784e-01f, -3.52047652e-01f, 5.02266102e-02f,
  -1.35468408e-01f, 1.64409131e-01f, 3.00487448e-02f, 2.96286773e-02f, 7.72077069e-02f, -4.85476740e-02f, 5.61272688e-02f, -3.18458736e-01f, -1.15361422e-01f, -1.96289495e-01f,
  -9.48161855e-02f, 6.64074197e-02f, 4.93730307e-02f, 1.20377928e-01f, 7.69607276e-02f, 7.22843111e-02f, 2.72081997e-02f, -1.42766908e-01f, 1.14733249e-01f, 3.83703858e-02f,
  1.67649001e-01f, 1.30313873e-01f, 9.77576058e-03f, 1.10523298e-01f, -4.12984610e-01f, -3.24240863e-01f, 1.28371730e-01f, -2.44876802e-01f, -2.06649572e-01f, 1.69585377e-01f,
  3.30656737e-01f, 2.21964732e-01f, 3.66730809e-01f, -4.20409478e-02f, 1.68347433e-01f, 2.25987792e-01f, -5.54029038e-03f, -8.48788992e-02f, 2.21133798e-01f, -4.41546828e-01f,
  -2.26612091e-01f, -2.62496978e-01f, 4.26514670e-02f, -2.66531348e-01f, 2.09176034e-01f, 2.83453017e-01f, 5.06095178e-02f, -2.73129970e-01f, 1.48987800e-01f, 5.09109236e-02f,
  2.42540836e-01f, 8.47501457e-02f, -9.85300243e-02f, 5.26456721e-02f, 1.60028860e-01f, -2.98910141e-01f, -1.44133970e-01f, 3.85428853e-02f, -5.36659881e-02f, -1.91781491e-01f,
  3.65577847e-01f, -3.54635537e-01f, 2.39053331e-02f, 2.32900511e-02f, -1.11127486e-02f, -1.72642514e-01f, -3.93267632e-01f, -5.49277812e-02f, -6.00953400e-02f, 1.11881956e-01f,
  3.03675920e-01f, -1.67977035e-01f, -3.21062535e-01f, -2.02134952e-01f, -2.74751335e-01f, 1.35964826e-01f, -1.73038885e-01f, 1.75008297e-01f, -1.48608968e-01f, -8.96355435e-02f,
  -6.99422956e-01f, 1.50253639e-01f, -1.01463579e-01f, -1.18401289e-01f, -2.50832826e-01f, -4.28740919e-01f, -6.58760732e-03f, -6.35850489e-01f, 1.48952052e-01f, 1.60268486e-01f,
  2.60133773e-01f, -2.48978153e-01f, -7.86123872e-02f, 2.24285305e-01f, 1.73606694e-01f, -1.67987436e-01f, -4.45032679e-02f, 1.97216302e-01f, -6.90330416e-02f, -6.89198151e-02f,
  1.76295593e-01f, 1.42154902e-01f, -3.37144226e-01f, -5.33519328e-01f, 2.33365521e-01f, 1.95009321e-01f, 3.64762060e-02f, -1.56250790e-01f, 9.17590111e-02f, -1.65505365e-01f,
  2.06765249e-01f, 1.31447881e-01f, -2.14344844e-01f, 8.37064236e-02f, 1.28381178e-01f, 1.18236512e-01f, 1.40147023e-02f, -1.06666833e-01f, -9.45635363e-02f, 3.92796881e-02f,
  -8.82861987e-02f, -1.90787055e-02f, -1.05318345e-01f, -9.95243713e-03f, -9.93063971e-02f, -5.40383011e-02f, 2.96467561e-02f, 6.76919594e-02f, -1.59651726e-01f, -3.32115084e-01f,
  4.47285622e-02f, -1.30044356e-01f, 9.68551561e-02f, 4.70762514e-03f, 4.05376367e-02f, 8.34636018e-02f, 1.33446619e-01f, -1.74045980e-01f, 1.45346187e-02f, -8.72048438e-02f,
  -9.95219499e-02f, -1.18995167e-01f, -1.29479066e-01f, -1.79480910e-01f, -3.01510729e-02f, -8.77869502e-02f, 1.19440388e-02f, -5.07670920e-04f, -7.78975710e-02f, 2.10823733e-02f,
  7.54129663e-02f, -3.05132456e-02f, 1.08223982e-01f, 1.33407757e-01f, -5.51893301e-02f, 2.25204509e-02f, 2.14006439e-01f, 4.32977825e-02f, -6.86749145e-02f, -1.71438709e-01f,
  -1.70197174e-01f, -7.42916018e-02f, 9.48841274e-02f, 1.95884272e-01f, 1.70509294e-01f, -4.48319651e-02f, 6.46354351e-03f, 3.05834055e-01f, -3.76556478e-02f, 1.23890638e-01f,
  -4.18573171e-02f, 1.29728332e-01f, -1.32322803e-01f, 2.19591726e-02f, -2.60336310e-01f, -2.04193577e-01f, 2.92004719e-02f, -6.52482063e-02f, 2.53772344e-02f, 2.05306903e-01f,
  -1.97458472e-02f, 5.81500307e-02f, -1.33664817e-01f, 1.31699219e-02f, -3.18584353e-01f, 1.32635400e-01f, 9.59713385e-03f, -2.08286211e-01f, -2.51822889e-01f, 8.15144274e-03f,
  -2.18659148e-01f, -7.66419768e-02f, 9.34613273e-02f, -1.80329368e-01f, 1.80108741e-01f, -5.98689467e-02f, -5.03708944e-02f, -3.48589420e-02f, 1.50843531e-01f, -7.88967870e-03f,
  -7.26175308e-02f, -1.79666638e-01f, 5.12235351e-02f, 3.19053382e-02f, -1.64702266e-01f, -2.41212025e-02f, -1.76979378e-01f, 4.29917499e-02f, -1.02916613e-01f, 1.36795416e-01f,
  3.70797843e-01f, 4.46876258e-01f, 1.87280610e-01f, -3.01052123e-01f, -1.34814247e-01f, -2.26456732e-01f, 2.22086534e-01f, -4.37906772e-01f, 1.32229686e-01f, -3.66187212e-03f,
  1.46499664e-01f, -2.90706724e-01f, -5.05004916e-03f, -3.54269266e-01f, 7.46211633e-02f, -6.72728941e-02f, -2.28766128e-01f, -4.51742932e-02f, -1.23961590e-01f, -4.21217144e-01f,
  -3.26226622e-01f, 2.43780687e-01f, 2.69767195e-01f, -1.54370874e-01f, 1.90946907e-01f, -1.62832767e-01f, 4.52342667e-02f, 1.21130213e-01f, 1.06895261e-01f, 2.25601375e-01f,
  3.66977118e-02f, 3.54213379e-02f, 8.25917423e-02f, -1.01181958e-02f, 1.09171562e-01f, 1.37590528e-01f, -7.35760406e-02f, 2.85006523e-01f, 2.01222859e-02f, 2.01482087e-01f,
  6.26938138e-03f, 5.58550209e-02f, 3.22406679e-01f, 1.28816351e-01f, 1.44755542e-01f, -5.95886894e-02f, 9.64196324e-02f, 1.52825058e-01f, 7.22211450e-02f, 2.25486066e-02f,
  1.32515639e-01f, -7.87120983e-02f, -7.44336322e-02f, -8.45751986e-02f, -1.61122233e-01f, 1.09594844e-01f, 7.68775493e-02f, 1.49519548e-01f, 2.43518963e-01f, 7.38900155e-02f,
  -1.38848051e-01f, 1.96322471e-01f, 2.39231959e-01f, 3.11280519e-01f, -5.96241541e-02f, 5.35400994e-02f, -1.49024010e-01f, 2.40453884e-01f, -5.60368374e-02f, 2.13725697e-02f,
  7.02923536e-02f, -1.56615511e-01f, -7.49538168e-02f, 1.61438301e-01f, 1.86515972e-01f, -3.15334976e-01f, 3.32563579e-01f, -6.71127662e-02f, -1.37019409e-02f, -7.35947564e-02f,
  -2.02717930e-01f, 3.09157193e-01f, -1.84297830e-01f, -3.41392636e-01f, -2.33535752e-01f, 2.72927672e-01f, 1.22368321e-01f, -2.56044060e-01f, 4.69392762e-02f, 1.11796416e-01f,
  1.20855644e-01f, 1.08924292e-01f, 1.44941598e-01f, -4.92969342e-02f, 3.83070230e-01f, 2.33384266e-01f, 2.63439596e-01f, 1.56889051e-01f, 5.69058172e-02f, -2.60886680e-02f,
  -3.27490270e-01f, -2.56467044e-01f, -3.85794461e-01f, -4.06034172e-01f, 2.26838127e-01f, 1.41059920e-01f, 2.83095717e-01f, 3.14714372e-01f, -2.09918246e-01f, 2.52266258e-01f,
  -9.96359140e-02f, 3.35240275e-01f, -9.72177386e-02f, 2.01913528e-02f, -2.58534104e-01f, 2.40084499e-01f, 3.23397249e-01f, -9.66779068e-02f, -2.71784633e-01f, 1.74271151e-01f,
  3.08926225e-01f, 1.81974351e-01f, 2.08490983e-01f, 3.01180452e-01f, 1.44000396e-01f, 1.01791091e-01f, -7.60086715e-01f, 3.39005768e-01f, 8.31984878e-02f, -2.40278132e-02f,
  2.30409846e-01f, -3.36559594e-01f, 3.01557511e-01f, -3.13464068e-02f, -3.92601222e-01f, 2.53034085e-02f, -4.52358574e-01f, -8.10165405e-02f, 3.58406949e-04f, -5.22363722e-01f,
  -1.31049693e-01f, -3.93109232e-01f, -3.73247921e-01f, -3.58253151e-01f, 9.51910987e-02f, -5.83115965e-02f, -9.32554975e-02f, 2.81017989e-01f, 3.05648029e-01f, 4.06262167e-02f,
  5.63702941e-01f, 1.90886140e-01f, -2.68401742e-01f, 1.06847718e-01f, -1.98805362e-01f, 1.09259441e-01f, -3.52148354e-01f, -9.60917249e-02f, 2.76154801e-02f, 1.16571784e-01f,
  -3.79224539e-01f, 4.13798913e-02f, -6.38976246e-02f, 1.78295776e-01f, -1.53345754e-02f, -4.49735112e-02f, 1.28084555e-01f, -1.18773907e-01f, -5.09301163e-02f, 1.27320364e-01f,
  1.79606564e-02f, 7.50435814e-02f, -1.54326618e-01f, 8.81947204e-02f, -1.18812606e-01f, 5.93673289e-02f, -9.30737406e-02f, 2.75762286e-02f, -6.66012689e-02f, 3.15631330e-02f,
  -2.09299877e-01f, -2.26784833e-02f, 6.60457474e-04f, 1.83949947e-01f, -4.99470793e-02f, -9.95894521e-02f, 2.37754941e-01f, -1.38599217e-01f, -4.02062505e-01f, 4.59576137e-02f,
  1.13642193e-01f, -6.37013391e-02f, -2.25187749e-01f, -8.27642158e-03f, 1.16867334e-01f, 1.61378503e-01f, -2.48945370e-01f, 4.30228859e-02f, 2.73687392e-01f, 9.69527438e-02f,
  -2.24989802e-02f, -1.60590678e-01f, 1.38791502e-01f, 9.48407799e-02f, -5.40773988e-01f, 1.92107335e-01f, -2.64916539e-01f, 2.48973116e-01f, 3.43247429e-02f, -2.83727616e-01f,
  -1.98479798e-02f, -1.37229145e-01f, -9.77044627e-02f, -1.60544202e-01f, -2.73972422e-01f, 2.73845166e-01f, -1.33011818e-01f, 7.94734806e-02f, 6.88716173e-02f, -1.38648525e-01f,
  -1.81549247e-02f, -3.18971053e-02f, 3.58861238e-01f, 1.97120965e-01f, -5.26000224e-02f, -6.66124895e-02f, -9.77583975e-02f, -7.57714063e-02f, 3.77064720e-02f, -3.26332361e-01f,
  3.24990630e-01f, 6.53254241e-02f, 2.82688558e-01f, -1.79729015e-01f, 1.01551399e-01f, -1.90688059e-01f, -9.50863585e-02f, 7.45558143e-02f, -2.11465612e-01f, -3.00096860e-03f,
  -3.72150421e-01f, 1.55656144e-01f, -2.94037730e-01f, -2.05043375e-01f, -3.44373941e-01f, 2.03809306e-01f, 3.15727055e-01f, -1.87692404e-01f, -1.91247866e-01f, 1.58403218e-01f,
  2.13278130e-01f, -3.64132196e-01f, -1.00347092e-02f, 3.71454775e-01f, -2.75056958e-01f, 1.29593626e-01f, -2.15386912e-01f, 2.44847596e-01f, 3.06389660e-01f, 1.16021246e-01f,
  1.81766048e-01f, -2.87714720e-01f, -2.07395092e-01f, 1.98833361e-01f, 1.51707688e-02f, -1.30158558e-01f, -5.02554327e-02f, 2.20796838e-01f, 1.93794280e-01f, 2.96097547e-01f,
  -8.90968591e-02f, 6.12254106e-02f, -4.26971793e-01f, -4.85887438e-01f, -3.45600873e-01f, -2.97852576e-01f, -2.36712739e-01f, 7.96585009e-02f, -5.30731499e-01f, -1.80538371e-01f,
  8.19819197e-02f, 6.66274205e-02f, 1.13765942e-02f, -1.00571662e-02f, 2.18764767e-02f, -9.62256512e-04f, 1.13575675e-01f, 1.72739718e-02f, 6.88073933e-02f, 2.62975171e-02f,
  -4.02790902e-04f, 8.09876993e-02f, -5.74526973e-02f, 1.39447615e-01f, -4.37996276e-02f, -1.33401006e-01f, -3.70791592e-02f, 6.13443665e-02f, 1.52643502e-01f, -6.25245497e-02f,
  -8.60358626e-02f, 5.01804873e-02f, 1.73935145e-01f, 1.34803176e-01f, -3.71208817e-01f, -1.44796446e-01f, -3.27735506e-02f, 6.82361796e-02f, 1.86808765e-01f, 1.25388563e-01f,
  -1.23923965e-01f, 8.59911516e-02f, -4.33841459e-02f, -1.61174193e-01f, -2.02282652e-01f, 1.96305327e-02f, -7.98110515e-02f, 4.20698933e-02f, -2.15150744e-01f, -1.81297183e-01f,
  1.23197436e-01f, -4.45401110e-02f, -1.26304120e-01f, -8.96159336e-02f, -2.41418499e-02f, -9.45283696e-02f, 1.89768281e-02f, -6.72719777e-02f, 6.99927732e-02f, 1.49070516e-01f,
  2.23483741e-02f, 2.38874927e-01f, -2.82414287e-01f, -2.30260476e-01f, 2.09436640e-01f, -1.80535659e-01f, -3.77811790e-02f, -1.81986779e-01f, -7.02956542e-02f, -1.65930152e-01f,
  -1.30823344e-01f, 2.21424773e-01f, 7.91285560e-02f, 2.53470927e-01f, -1.96492206e-02f, 1.84137166e-01f, 1.44847035e-01f, 3.52438539e-01f, -3.90261501e-01f, -3.05951089e-01f,
  2.11370096e-01f, -2.90525287e-01f, -2.95916975e-01f, 9.21682734e-03f, 2.22868577e-01f, 1.00117266e-01f, 2.23300129e-01f, 3.41506779e-01f, 1.53561726e-01f, -1.92270815e-01f,
  -2.91990563e-02f, 1.60902858e-01f, 3.26791674e-01f, -3.91632617e-01f, 4.10067230e-01f, -4.60175388e-02f, 8.39949325e-02f, 9.02435631e-02f, -2.68750161e-01f, 2.43127733e-01f,
  2.35037968e-01f, 1.12639993e-01f, -1.42909050e-01f, -1.27694860e-01f, 1.32004052e-01f, 2.02469364e-01f, -3.19415331e-01f, -2.35506758e-01f, 1.65821269e-01f, -3.05892020e-01f,
  -1.93507776e-01f, 1.49345845e-02f, 1.72262579e-01f, -1.87860027e-01f, 1.83132440e-01f, -2.69535571e-01f, 2.94061820e-03f, -2.59861737e-01f, -4.94886965e-01f, -3.14210445e-01f,
  -2.54240870e-01f, 1.73392937e-01f, -2.78270036e-01f, -4.18859839e-01f, -1.90104946e-01f, 6.79708198e-02f, 2.51891077e-01f, -4.61964816e-01f, 3.37450027e-01f, -4.89384413e-01f,
  1.21038146e-02f, -4.12655294e-01f, -3.43531489e-01f, 1.99103236e-01f, 2.99694926e-01f, 1.32082149e-01f, 9.73701710e-04f, 8.04031491e-02f, 1.63849682e-01f, 7.28298575e-02f,
  -2.08024252e-02f, 7.24902004e-02f, 1.43668398e-01f, -4.56503220e-02f, -3.15230861e-02f, 2.04965562e-01f, 8.03071074e-03f, 1.31466404e-01f, 4.87700803e-03f, 7.46607259e-02f,
  4.11088839e-02f, 1.38234505e-02f, 2.72953123e-01f, -6.48098961e-02f, -2.22815783e-03f, 2.48546764e-01f, 1.06759526e-01f, 4.23320569e-02f, -2.74762437e-02f, 1.06905587e-01f,
  5.75355515e-02f, -3.17883819e-01f, 4.26581614e-02f, -5.07490430e-03f, -2.46550310e-02f, 3.92337665e-02f, -3.49316634e-02f, -1.83394790e-01f, -8.51726532e-02f, 4.31708582e-02f,
  7.67907500e-02f, 2.76676744e-01f, 1.87718824e-01f, -3.27321701e-02f, 1.24391183e-01f, 1.25998482e-01f, 2.55084950e-02f, -1.41653761e-01f, -9.44637787e-03f, 8.21036920e-02f,
  -1.46808729e-01f, -1.56419665e-01f, 3.95371392e-02f, -9.19599161e-02f, 1.13285407e-01f, -5.78785641e-03f, 1.29561856e-01f, 1.32067269e-02f, 6.46773875e-02f, -3.87298465e-01f,
  9.44329351e-02f, -2.58536249e-01f, 4.12629366e-01f, 1.85802877e-01f, 2.91321278e-01f, 7.60756880e-02f, 7.59684965e-02f, -1.75378844e-01f, -2.13174358e-01f, 3.85316879e-01f,
  -9.92655531e-02f, 2.46848494e-01f, -1.76782876e-01f, 2.52444278e-02f, 9.22318399e-02f, 3.12894821e-01f, 1.16170846e-01f, 3.96252185e-01f, 1.28554657e-01f, 1.69115707e-01f,
  -3.19033623e-01f, 1.22661732e-01f, -2.19246164e-01f, -1.55554160e-01f, -2.74251580e-01f, 4.26397115e-01f, -6.07195832e-02f, 2.49780536e-01f, -2.45255843e-01f, 2.71958590e-01f,
  7.02051744e-02f, -2.57780522e-01f, 3.11470419e-01f, -5.55920191e-02f, -1.00793093e-01f, -1.22466609e-01f, 2.87014365e-01f, 3.19817513e-01f, -2.70044021e-02f, -2.87158847e-01f,
  9.90165174e-02f, -4.81123738e-02f, -3.17027599e-01f, 3.05410922e-01f, 2.73953199e-01f, 2.31550887e-01f, -2.38514263e-02f, 2.70990491e-01f, 1.00704834e-01f, 4.71752226e-01f,
  9.82732400e-02f, -1.91933140e-01f, -1.45986810e-01f, -2.93621153e-01f, -4.41446990e-01f, -3.48772079e-01f, 3.04581165e-01f, -2.21114770e-01f, 5.76139539e-02f, 1.68684304e-01f,
  -2.01249301e-01f, -1.28783584e-01f, 2.06907928e-01f, 2.24632502e-01f, -3.34043950e-01f, 1.91702276e-01f, -2.75284618e-01f, -2.86347717e-02f, 4.71793771e-01f, -6.12332076e-02f,
  2.95528620e-01f, 9.72753987e-02f, -4.42928612e-01f, -3.79138201e-01f, -2.78692186e-01f, -2.38846764e-01f
};

// L2_linear_B (Shape: 1 x 12)
const int L2_linear_B_rows = 1;
const int L2_linear_B_cols = 12;
const float L2_linear_B_data[] = {
  -1.12350792e-01f, 9.28073600e-02f, 1.34638071e-01f, 1.62685812e-02f, -4.95358091e-03f, -2.19557565e-02f, -3.71954516e-02f, 2.66370289e-02f, 7.40652904e-02f, 1.50760741e-03f,
  -5.19875698e-02f, 1.92739628e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 51, 26
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        128, 51, 26
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_linear
    linear_forward_pgm(
        buffer1, x_out,
        L2_linear_W_data, L2_linear_B_data,
        128, 12
    );
    }
    