/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 64 (x1)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 64;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    static inline float fan_activation(float x) { return x; }

    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 6 x 120)
const int L0_fan_Wp_rows = 6;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  3.77231598e-01f, 2.50914186e-01f, 6.19061384e-03f, -2.63402890e-03f, -7.83669055e-02f, -4.38740999e-02f, -2.65981462e-02f, -8.81216079e-02f, -3.20480689e-02f, 8.52770209e-02f,
  -2.88605280e-02f, -1.64122656e-01f, -8.66953358e-02f, -1.54908314e-01f, -6.55653179e-02f, -6.62199557e-02f, -1.83048442e-01f, -1.86964333e-01f, -2.22377300e-01f, -1.25509262e-01f,
  -1.19460523e-01f, 4.76264954e-02f, 1.11717351e-01f, -1.42807320e-01f, 7.72048766e-03f, -1.19438589e-01f, -6.08023852e-02f, 4.35682107e-03f, -5.79320490e-02f, -7.06131384e-02f,
  2.05347553e-01f, 1.96181640e-01f, -8.75226185e-02f, 5.23286266e-03f, 4.60480824e-02f, 1.00570187e-01f, 7.03981379e-03f, 5.71212322e-02f, -1.18884828e-03f, 1.77859198e-02f,
  1.58188045e-02f, -7.95200616e-02f, -7.97982235e-03f, -6.19337261e-02f, 4.85960692e-02f, 4.82543297e-02f, -3.44243683e-02f, 6.03698231e-02f, 3.83440070e-02f, 1.05698863e-02f,
  -7.13256896e-02f, 4.76677343e-02f, 8.16784352e-02f, -1.12888059e-02f, 1.00864414e-02f, -2.98019983e-02f, 7.98619092e-02f, 5.88988177e-02f, 9.14228857e-02f, 1.49112433e-01f,
  -1.07119707e-02f, 1.10613339e-01f, 6.36976510e-02f, 6.67860359e-02f, 4.95087281e-02f, 5.02880141e-02f, 3.54041457e-02f, -3.49102840e-02f, 9.73204747e-02f, 8.31189677e-02f,
  1.66696906e-02f, 3.39562297e-02f, 1.41965179e-02f, -4.19840999e-02f, -3.44292521e-02f, 7.62983784e-02f, -3.57220438e-03f, 3.95477712e-02f, 1.20931743e-02f, 8.32091197e-02f,
  -7.67368684e-03f, 1.75870676e-02f, 5.74986078e-02f, -3.28098424e-02f, 9.91682336e-02f, 5.22955768e-02f, 2.46364027e-02f, -2.33932100e-02f, 7.98864141e-02f, 4.38961461e-02f,
  6.77450001e-02f, -1.75529316e-01f, -4.27926145e-02f, 2.79210862e-02f, 4.81046885e-02f, -3.94290909e-02f, 3.37698534e-02f, -1.02729546e-02f, -2.27523446e-02f, 7.52623603e-02f,
  2.62428503e-02f, -5.90332188e-02f, -1.67840847e-03f, -3.83217004e-03f, -9.16172378e-03f, 6.63810596e-02f, 1.49956644e-01f, 3.28692384e-02f, 2.43893974e-02f, 5.06392121e-02f,
  -9.09862109e-03f, 4.28922735e-02f, 1.62737519e-01f, -2.75563486e-02f, 6.47459924e-02f, -3.48001346e-02f, 3.66298780e-02f, -1.61633417e-02f, 1.01334207e-01f, 9.67803597e-02f,
  -1.82212755e-01f, -4.94822040e-02f, -2.47108653e-01f, -4.06527370e-02f, 2.32041478e-02f, -4.92810458e-02f, -1.60352495e-02f, 1.74287590e-03f, 7.42562348e-03f, -3.94000709e-02f,
  7.34021217e-02f, 1.51492178e-01f, 6.72866851e-02f, 7.55293667e-02f, -1.19353414e-01f, -1.07565150e-01f, -2.79252529e-01f, -1.68920308e-01f, -1.28008515e-01f, -4.52394895e-02f,
  -1.14669790e-02f, -3.76690999e-02f, -2.23598048e-01f, -1.36529043e-01f, -2.89877802e-01f, -1.50933012e-01f, -3.06411982e-01f, -2.67784864e-01f, -2.99609870e-01f, -3.92144352e-01f,
  -1.56950250e-01f, 9.03796479e-02f, 7.86263049e-02f, 2.18260232e-02f, -4.09307070e-02f, -3.49166505e-02f, -6.45751357e-02f, 4.24351059e-02f, 4.21769917e-03f, -3.18413153e-02f,
  9.52012464e-02f, 8.05207789e-02f, 3.56977433e-02f, -5.71027845e-02f, 6.76064715e-02f, -4.89603654e-02f, -2.54260655e-02f, -4.11281548e-02f, -3.13743912e-02f, 5.06931823e-03f,
  1.13686964e-01f, -9.38738063e-02f, -5.49269170e-02f, -7.01683536e-02f, -3.85055281e-02f, -1.10992253e-01f, -1.21718653e-01f, -2.01344132e-01f, -2.13889703e-02f, -2.25550622e-01f,
  -4.91251908e-02f, 2.84256320e-02f, 2.78816577e-02f, 5.55946343e-02f, -3.58830765e-02f, 1.78941954e-02f, -2.13238075e-02f, 1.14514746e-01f, -1.75362248e-02f, -7.12715909e-02f,
  7.57736340e-02f, -7.08897933e-02f, 3.26861739e-02f, -4.31125760e-02f, -6.89426139e-02f, -1.77881587e-02f, -2.23525660e-03f, 2.66325288e-03f, -7.02766702e-02f, 3.85691002e-02f,
  1.84021294e-02f, -4.08880860e-02f, 8.71438608e-02f, 5.18154018e-02f, 4.82146591e-02f, 1.67869348e-02f, 6.67016627e-03f, 7.01648593e-02f, 8.50147977e-02f, 1.28602251e-01f,
  -9.69324484e-02f, 7.15896860e-02f, -1.76290795e-01f, 1.52682466e-02f, -8.19083229e-02f, -1.12525202e-01f, -3.33283134e-02f, -4.60080951e-02f, 6.96090013e-02f, -5.56437187e-02f,
  -2.21036673e-02f, -1.07069790e-01f, -1.68696456e-02f, -4.33203988e-02f, -1.10988535e-01f, 1.65773872e-02f, 6.83532134e-02f, -1.04497559e-01f, -5.83754107e-02f, -3.39936726e-02f,
  -4.79171127e-02f, -1.42768517e-01f, -6.96413144e-02f, -8.55325833e-02f, -1.44769371e-01f, -1.66227311e-01f, -1.98588774e-01f, -1.96645677e-01f, -1.85432017e-01f, -2.30761409e-01f,
  -8.83970875e-03f, -8.34221616e-02f, -3.41259390e-01f, 4.65997532e-02f, 2.93408707e-02f, -2.48158619e-01f, -2.00133398e-01f, -9.95432809e-02f, -1.81660056e-02f, 1.18396001e-05f,
  8.71303398e-03f, -5.65857738e-02f, -2.53216535e-01f, -1.21741161e-01f, -2.33054325e-01f, -3.04818869e-01f, -2.05456153e-01f, -3.56323272e-01f, -2.64310420e-01f, 6.37043500e-04f,
  2.07877815e-01f, 1.31737053e-01f, 3.81531976e-02f, -4.31968793e-02f, 1.79851234e-01f, 4.08067740e-02f, 6.29715994e-02f, 1.86713874e-01f, 9.90530625e-02f, 2.26989627e-01f,
  -1.97852515e-02f, -3.00401915e-02f, -1.80511221e-01f, -1.67049095e-02f, 2.29328778e-02f, -1.76006123e-01f, -1.92828670e-01f, -1.07750704e-03f, -8.96876305e-02f, 5.51381987e-03f,
  7.18054920e-02f, -8.88668224e-02f, -8.13461915e-02f, 1.82332948e-03f, -2.88440976e-02f, -3.18587990e-03f, -1.23267666e-01f, -7.43491352e-02f, -1.59414917e-01f, 8.46089609e-03f,
  -2.43373271e-02f, 7.98187330e-02f, -1.06742330e-01f, -9.14164484e-02f, -1.23451129e-01f, -9.23971534e-02f, -7.23904893e-02f, 5.94086759e-02f, -3.93812582e-02f, 1.66229188e-01f,
  3.75872478e-02f, 1.49463778e-02f, 1.02728099e-01f, 4.16247994e-02f, 8.93492550e-02f, 7.57019669e-02f, 8.40815753e-02f, 7.27243423e-02f, 8.45842585e-02f, 2.83825267e-02f,
  8.18026811e-02f, 6.21771254e-02f, 6.11112639e-02f, 1.27063915e-01f, 1.20674975e-01f, 3.80364880e-02f, 6.03197888e-02f, 1.07463285e-01f, 1.29504770e-01f, 6.86603710e-02f,
  6.76667690e-02f, 4.12786230e-02f, 2.97068246e-02f, 1.21957034e-01f, 3.82166915e-02f, 5.46064489e-02f, 8.81804153e-02f, 8.83510038e-02f, -2.50495933e-02f, 5.69974333e-02f,
  -1.56324338e-02f, -1.39964685e-01f, -1.87819246e-02f, 6.43579811e-02f, -2.67217923e-02f, 6.28933236e-02f, 5.43499626e-02f, 7.59681836e-02f, 1.64071247e-02f, 1.87517013e-02f,
  1.64724619e-03f, -5.19437045e-02f, -3.46599147e-02f, 1.11299735e-02f, -3.34966704e-02f, -3.50080468e-02f, 1.14182578e-02f, -2.57494263e-02f, -5.70247211e-02f, -3.71031277e-03f,
  3.37910540e-02f, -9.01350230e-02f, -1.35325402e-01f, -1.36724591e-01f, 1.97378155e-02f, -1.07800417e-01f, -6.01728307e-03f, 3.74492072e-02f, -9.79248062e-02f, -2.03081593e-02f,
  -2.20338225e-01f, -3.62381160e-01f, -1.09967299e-01f, -2.31634557e-01f, -1.14243582e-01f, 9.38232765e-02f, 4.24855798e-02f, -4.08738293e-02f, -5.58960736e-02f, -2.55843490e-01f,
  -1.16657078e-01f, 2.82013137e-02f, 9.06869769e-02f, 2.24813670e-02f, 1.83504939e-01f, -1.01751387e-01f, -9.41578895e-02f, 2.29889825e-01f, 3.78787965e-01f, 1.57248557e-01f,
  3.53536643e-02f, 4.56998236e-02f, 1.36122823e-01f, 1.51352540e-01f, -2.05999672e-01f, 4.33756299e-02f, -1.60556689e-01f, -1.29631430e-01f, -3.48571166e-02f, -2.62475103e-01f,
  -3.85663249e-02f, -2.44452059e-01f, 4.00326401e-02f, 2.31239777e-02f, -5.48254550e-02f, -2.52218917e-02f, -2.43175384e-02f, 3.19568627e-03f, -4.85994183e-02f, 3.68387066e-02f,
  -9.52375308e-03f, 2.99798660e-02f, -3.27831693e-02f, -2.48546004e-02f, -7.12919682e-02f, -2.38910690e-03f, 6.29855990e-02f, 9.45710093e-02f, 2.56730523e-02f, -4.56714667e-02f,
  -1.61681488e-01f, 3.20007801e-02f, 8.47785771e-02f, 1.12127349e-01f, 8.13245848e-02f, 5.30604199e-02f, 1.82360001e-02f, 5.18991426e-02f, 3.32470099e-03f, -6.88374555e-03f,
  5.67369796e-02f, 2.46292073e-02f, 1.04807846e-01f, -3.65969799e-02f, 2.20298376e-02f, -6.19295659e-03f, -1.18243784e-01f, 2.31616497e-02f, 2.34899502e-02f, 5.03186136e-02f,
  1.12481918e-02f, -3.17407139e-02f, 1.27471853e-02f, -8.45346823e-02f, 6.71190843e-02f, 3.07704378e-02f, 1.03651345e-01f, -7.72302523e-02f, -3.37821767e-02f, -2.49375273e-02f,
  4.11706120e-02f, 4.89043929e-02f, -6.58090319e-03f, 1.19420746e-02f, -2.30635796e-02f, -3.03673875e-02f, 5.93933277e-02f, -5.13973497e-02f, 3.65795977e-02f, 3.49522568e-02f,
  1.38492301e-01f, 1.40670896e-01f, -8.87236819e-02f, -4.99910153e-02f, -4.65903468e-02f, -3.61330733e-02f, -9.15708840e-02f, -1.75423163e-03f, -1.10580593e-01f, -5.09590060e-02f,
  1.05029922e-02f, -8.22408274e-02f, -6.86966535e-03f, -3.53075527e-02f, 8.40524957e-03f, -5.13779074e-02f, -8.50173235e-02f, -5.30406088e-02f, 4.94015701e-02f, -1.08740352e-01f,
  -6.34149015e-02f, 1.11333266e-01f, 6.91433623e-02f, -1.85747128e-02f, 3.75650972e-02f, 4.83445674e-02f, 5.46449795e-02f, 1.05587669e-01f, 9.18060392e-02f, -6.83244839e-02f,
  -2.29891792e-01f, 3.54338825e-01f, 1.17512450e-01f, 1.68145355e-02f, 9.28889960e-02f, 4.75061350e-02f, 2.21469298e-01f, 7.90286157e-03f, -1.03951968e-01f, 2.34184805e-02f,
  1.00637749e-01f, -1.06487364e-01f, -5.96667230e-02f, 1.81329250e-02f, 2.61286162e-02f, 1.90230891e-01f, 2.16719821e-01f, -1.10625602e-01f, -2.30052382e-01f, -2.55724341e-02f,
  1.43530756e-01f, -4.65362556e-02f, -1.46068051e-01f, -1.08185455e-01f, 2.15557694e-01f, 9.98999178e-02f, 6.96891621e-02f, 5.33357896e-02f, 2.04400882e-01f, 2.14260817e-01f,
  1.33149013e-01f, -2.44933572e-02f, -1.28024921e-01f, -1.38735577e-01f, -7.49028102e-02f, -3.17278691e-02f, 3.29984799e-02f, -1.72365814e-01f, -6.64347410e-02f, 2.93501895e-02f,
  6.39126599e-02f, -7.17743784e-02f, 3.18330713e-03f, -6.06017141e-03f, -3.76149337e-03f, -7.77184730e-03f, -1.32540418e-02f, -9.29096192e-02f, -7.93282539e-02f, 3.86200938e-03f,
  1.33292586e-01f, 6.32499605e-02f, 1.32478550e-02f, -2.19706856e-02f, -7.54976198e-02f, -1.77083146e-02f, 1.53073698e-01f, 4.55613732e-02f, -9.35501382e-02f, 1.67473972e-01f,
  7.93126002e-02f, -7.34070987e-02f, 5.84549643e-02f, -4.24359599e-03f, -1.26860908e-03f, -3.49114090e-02f, 1.14593923e-01f, 8.01948383e-02f, -6.01615459e-02f, 2.09074523e-02f,
  -6.76284507e-02f, -1.56370476e-02f, 2.55111996e-02f, 1.11387540e-02f, -9.10011232e-02f, -6.07390404e-02f, 3.18823420e-02f, -6.75752684e-02f, -2.02203095e-02f, -1.20755672e-01f,
  -5.50980344e-02f, 7.44490474e-02f, -6.73656836e-02f, 1.91153735e-02f, -7.56400526e-02f, 2.34501455e-02f, -3.14186444e-03f, -4.15521003e-02f, -7.05467314e-02f, -7.10230172e-02f,
  -6.91409260e-02f, -2.29757160e-01f, 3.44045125e-02f, -7.33676106e-02f, 7.58888423e-02f, -1.52542353e-01f, 8.73954371e-02f, -5.95877357e-02f, -8.73044431e-02f, 5.08066639e-02f,
  8.88090581e-02f, -3.98469456e-02f, -1.67909137e-03f, -2.60676704e-02f, 5.46646155e-02f, -7.07337037e-02f, 7.24689439e-02f, -4.18942384e-02f, -8.55470374e-02f, 2.65113395e-02f,
  -2.39455551e-02f, -3.42265442e-02f, 1.00285985e-01f, 1.22204773e-01f, 1.09542464e-03f, 3.74305248e-02f, 1.80256948e-01f, 1.15840659e-01f, -1.44529939e-02f, 1.35055736e-01f,
  3.65129977e-01f, -1.84295192e-01f, -2.93245837e-02f, 2.48272754e-02f, -2.04193041e-01f, -1.70852736e-01f, -2.05398872e-01f, 3.46377667e-04f, 8.52542594e-02f, -8.09513405e-02f,
  3.84753235e-02f, 2.04444274e-01f, 5.81175741e-03f, 9.59953442e-02f, 1.15126036e-01f, -5.53709865e-02f, -7.36272708e-02f, 1.69954091e-01f, 3.33911628e-01f, 2.83358425e-01f,
  2.00518623e-01f, 1.74342230e-01f, 2.25314572e-01f, 1.44821212e-01f, 4.30889055e-02f, 2.10884530e-02f, -1.40255332e-01f, 4.57876036e-03f, 1.26474932e-01f, 1.93605512e-01f,
  2.60463983e-01f, 6.13446124e-02f, 8.63623545e-02f, 1.40816286e-01f, -1.25539958e-01f, 6.95757717e-02f, 2.55844276e-02f, 5.81822358e-02f, -4.90158163e-02f, -1.48027455e-02f,
  6.97323084e-02f, 7.10253045e-02f, -8.68396983e-02f, 4.65735793e-02f, -3.52902785e-02f, 7.83561394e-02f, 1.12625673e-01f, 1.82860345e-01f, 9.93284136e-02f, 2.85342056e-02f,
  -8.87065679e-02f, -3.12006529e-02f, 2.26826519e-02f, -6.17076233e-02f, 5.26983431e-03f, 1.84129462e-01f, -8.30769539e-02f, 4.48656790e-02f, -2.45712269e-02f, 1.48083726e-02f,
  -6.38047531e-02f, -2.82673445e-03f, 7.04808235e-02f, 1.76359750e-02f, 1.07196055e-01f, -4.18463089e-02f, 7.50926882e-02f, 9.72170532e-02f, 9.11488757e-02f, 6.71749264e-02f,
  -1.88587476e-02f, 9.64214951e-02f, 2.77726725e-02f, 9.04936939e-02f, 6.10143468e-02f, -2.79135127e-02f, 3.31418402e-02f, 1.80706531e-02f, -6.93219826e-02f, -5.08043915e-02f,
  8.54353309e-02f, 4.74941544e-02f, 5.25166392e-02f, 4.56840843e-02f, 1.18170299e-01f, 1.18999861e-01f, 2.68858280e-02f, 7.45366886e-02f, 9.26800221e-02f, -8.34911538e-04f,
  -1.16664924e-01f, -1.62830815e-01f, -3.47758718e-02f, 3.02545130e-02f, -2.82378104e-02f, -9.19205397e-02f, -3.94888744e-02f, -2.41283774e-02f, -5.21917678e-02f, 1.07047558e-02f,
  5.02878986e-02f, 6.71201572e-02f, -1.58887729e-01f, -1.63946748e-02f, 6.03493899e-02f, -8.78681391e-02f, -8.12702253e-02f, -4.37369272e-02f, 3.45419496e-02f, -2.73958016e-02f,
  -1.57783478e-01f, 1.90300681e-02f, -1.61178969e-02f, -9.99234021e-02f, -7.16140866e-02f, -6.21817112e-02f, -5.21451645e-02f, -5.80129437e-02f, -1.09379053e-01f, -3.62034738e-02f
};

// L0_fan_Wp_bar (Shape: 52 x 120)
const int L0_fan_Wp_bar_rows = 52;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  4.34718490e-01f, 5.75737581e-02f, 1.88032925e-01f, 2.70843476e-01f, 3.30242753e-01f, 4.37516183e-01f, 5.66909969e-01f, 3.12384009e-01f, 1.90920070e-01f, 1.43233702e-01f,
  -1.67227581e-01f, -4.12818730e-01f, -2.42183656e-01f, -2.16412827e-01f, -1.30543545e-01f, 2.00894758e-01f, 2.43371949e-01f, 7.21133649e-02f, 1.01021953e-01f, 2.15470016e-01f,
  1.83823079e-01f, 2.99023449e-01f, 1.51288271e-01f, 1.13641821e-01f, 1.43927289e-02f, -2.22197324e-02f, 6.84106424e-02f, 2.59746075e-01f, 3.54190283e-02f, -7.03689009e-02f,
  -3.57941449e-01f, 1.68174937e-01f, -1.79263338e-01f, -1.85893670e-01f, -1.79829657e-01f, -2.23333776e-01f, -4.26312834e-02f, -8.23433027e-02f, -2.04459317e-02f, 2.09588632e-02f,
  -4.90264036e-02f, -7.79070929e-02f, -9.29692574e-03f, -3.66613679e-02f, 2.27461867e-02f, -2.09154263e-02f, -6.58050925e-03f, -1.72746375e-01f, -2.82249928e-01f, -1.23947032e-01f,
  -2.30554849e-01f, -1.95563212e-02f, 8.25685337e-02f, -8.15293938e-02f, -1.73430607e-01f, -7.19493255e-02f, -6.09748736e-02f, -9.90906209e-02f, -1.13694459e-01f, 5.28158024e-02f,
  -4.03086245e-01f, -1.40511289e-01f, -1.07453242e-01f, -5.68567403e-02f, 8.62662401e-03f, -5.21383388e-03f, -6.45508319e-02f, -1.33980989e-01f, -1.52647600e-01f, -5.93969263e-02f,
  -1.20845228e-01f, -1.93887293e-01f, -1.46296531e-01f, -6.26726225e-02f, -1.96885258e-01f, -1.37126436e-02f, -4.71389219e-02f, -1.23868711e-01f, -9.61967707e-02f, -4.18495201e-02f,
  -6.53377026e-02f, 5.60934015e-04f, 3.23829725e-02f, -1.07051142e-01f, 1.28417416e-02f, -1.48506925e-01f, -5.11511154e-02f, -1.53535679e-01f, -2.86761508e-03f, -3.58404964e-02f,
  -1.03642635e-01f, -2.62593806e-01f, -1.42932966e-01f, -1.53783694e-01f, 3.75042902e-03f, -2.31170714e-01f, -3.82069945e-01f, -1.53531238e-01f, -2.82125287e-02f, -1.42834917e-01f,
  -8.11199751e-03f, -8.76517370e-02f, -2.63712406e-02f, -1.04163200e-01f, 6.29974082e-02f, 6.66883141e-02f, -9.39232633e-02f, -6.11543097e-03f, -1.29801765e-01f, -8.27990696e-02f,
  -1.01612583e-01f, 7.62936994e-02f, 1.59296319e-01f, 1.44864293e-02f, -9.62047428e-02f, -8.24979693e-02f, 7.17871450e-03f, 6.16161078e-02f, 1.87218368e-01f, 2.19912395e-01f,
  -3.70767355e-01f, -4.70199764e-01f, -8.14515799e-02f, -2.13742912e-01f, -3.60048443e-01f, -3.57601315e-01f, -4.63777512e-01f, -1.25556529e-01f, -1.56891078e-01f, -1.42538965e-01f,
  3.92343178e-02f, 1.21078476e-01f, 1.84190661e-01f, -4.14021760e-02f, -1.89870968e-01f, -3.09691966e-01f, -1.86041832e-01f, -4.42594230e-01f, -4.52943265e-01f, -3.83275479e-01f,
  -4.53730643e-01f, -5.58435619e-01f, -4.67850953e-01f, -3.47573906e-01f, -2.65707731e-01f, -2.30092794e-01f, -2.72959992e-02f, -2.78659910e-01f, -2.54832566e-01f, -3.28228801e-01f,
  2.26565972e-01f, 1.44943878e-01f, 1.74765028e-02f, -1.36245251e-01f, 5.47986180e-02f, 3.24708153e-03f, -3.95432375e-02f, 7.93617517e-02f, 9.31203514e-02f, 1.51206851e-01f,
  1.30737228e-02f, -5.46353050e-02f, 1.49448989e-02f, 4.29734401e-02f, 1.39911715e-02f, -9.90422908e-03f, 2.49842390e-01f, 1.80612039e-02f, 1.42911673e-01f, 3.27031352e-02f,
  -9.30370390e-03f, -8.37071016e-02f, 1.36143833e-01f, 2.14070633e-01f, 2.80328989e-01f, 1.41937405e-01f, 1.50954142e-01f, 8.40557888e-02f, 8.19423869e-02f, 1.24748208e-01f,
  4.73429170e-03f, 6.12242483e-02f, -2.57951040e-02f, -4.09854203e-03f, 9.91865546e-02f, 5.02785333e-02f, -7.82421138e-03f, -2.65499689e-02f, 2.70766318e-02f, -7.30532184e-02f,
  4.89222780e-02f, 1.10359609e-01f, 3.36151123e-02f, -2.70214677e-01f, -6.15646169e-02f, -8.65161121e-02f, -6.09566718e-02f, -1.36795605e-03f, 4.12879325e-02f, -3.50663699e-02f,
  -5.63046969e-02f, -6.19824007e-02f, -4.32523340e-02f, -1.86147347e-01f, -3.81350704e-02f, 3.63077931e-02f, 3.46674062e-02f, 3.15183625e-02f, 1.26578845e-02f, 1.01764202e-01f,
  1.55070975e-01f, -9.02442932e-02f, 3.62097546e-02f, 7.34441206e-02f, -2.86822487e-02f, 1.78502008e-01f, 1.93392321e-01f, 3.41085270e-02f, 1.20834103e-02f, 2.21799016e-02f,
  -7.36984387e-02f, 2.72131357e-02f, 3.98774911e-03f, 6.11292124e-02f, -6.57968894e-02f, 5.61203100e-02f, 1.25885174e-01f, -1.09261729e-01f, -5.21008670e-03f, 1.41493389e-02f,
  1.06485067e-02f, -4.77773882e-02f, 6.17788583e-02f, 1.23618446e-01f, 5.16133308e-02f, 3.76469642e-02f, -3.91241051e-02f, 2.39292588e-02f, -1.39116511e-01f, -9.29647237e-02f,
  -4.64475930e-01f, 6.10613897e-02f, -3.89977366e-01f, -6.79243505e-02f, -2.25408256e-01f, -2.26542741e-01f, -2.26460472e-01f, 1.46683365e-01f, 1.73409685e-01f, 1.59766167e-01f,
  1.90900266e-02f, -1.87923893e-01f, -2.00347111e-01f, -1.86631441e-01f, -2.46053651e-01f, -5.07341735e-02f, -1.85453787e-01f, -3.91202688e-01f, -5.46696961e-01f, -3.70546907e-01f,
  -3.55944604e-01f, -3.67814720e-01f, -3.14900696e-01f, -1.53267071e-01f, 5.76111563e-02f, -2.31955245e-01f, -2.18300354e-02f, -1.67675599e-01f, -2.33956799e-01f, -1.97093531e-01f,
  -3.51417691e-01f, -2.26408675e-01f, 1.82681773e-02f, 2.18200535e-02f, 2.24630423e-02f, 8.05772394e-02f, -8.49691182e-02f, 1.34423494e-01f, 1.22108541e-01f, 1.66969076e-01f,
  -7.12125143e-03f, -1.29753370e-02f, -6.61574025e-03f, 2.91000064e-02f, -1.27982020e-01f, 5.71080018e-03f, 6.42949045e-02f, 4.71560508e-02f, 1.45950392e-01f, 1.67233229e-01f,
  6.75291568e-02f, 3.33773978e-02f, 5.37373386e-02f, 1.83476239e-01f, 8.36164951e-02f, -8.91739726e-02f, 5.06555624e-02f, 3.85584980e-02f, 1.61550213e-02f, 1.38973340e-01f,
  3.37873138e-02f, 1.03132248e-01f, -6.33483008e-03f, -1.10623688e-01f, 9.23195407e-02f, 1.37573168e-01f, 3.99963465e-03f, 5.86894974e-02f, -5.84291965e-02f, 4.53841761e-02f,
  2.44525626e-01f, 6.24513216e-02f, -2.91172438e-03f, 9.36149061e-02f, 3.19959112e-02f, 4.74126413e-02f, -3.60475518e-02f, 3.10419127e-02f, 5.61012439e-02f, 9.25380811e-02f,
  2.31360514e-02f, 6.96872026e-02f, -1.50480894e-02f, 1.45504534e-01f, 7.63913468e-02f, 1.25205174e-01f, -3.23247537e-02f, -4.29964699e-02f, 1.46273803e-03f, 1.89284869e-02f,
  -3.46934423e-02f, -1.81418672e-01f, -2.06978805e-02f, 5.10755170e-04f, 5.79490475e-02f, 2.35648692e-01f, -5.02831787e-02f, 6.37711063e-02f, -6.35222793e-02f, -1.03891723e-01f,
  -1.59021132e-02f, 3.15617695e-02f, -3.21622640e-02f, 1.01483732e-01f, -1.02572680e-01f, -5.19263558e-02f, 5.36906309e-02f, -1.43011296e-02f, -1.03308670e-02f, 2.09535971e-01f,
  2.48254046e-01f, -2.60408912e-02f, -2.34835446e-02f, 1.12826318e-01f, 1.33389920e-01f, -1.60240799e-01f, -8.34843237e-03f, 7.78559074e-02f, 9.10642929e-03f, 1.23280764e-01f,
  1.15350015e-01f, -2.79425710e-01f, -5.01022816e-01f, 1.03635415e-01f, -2.21141443e-01f, -2.60325581e-01f, -1.68277532e-01f, 8.81061256e-02f, 1.60433576e-01f, -1.95990846e-01f,
  -2.22301170e-01f, -2.03124676e-02f, -7.20689744e-02f, -7.51038129e-03f, 5.48626594e-02f, -2.95318007e-01f, -2.90676564e-01f, -3.34287696e-02f, 2.32424632e-01f, 2.90228426e-01f,
  1.58242270e-01f, 3.29191238e-01f, 3.81048143e-01f, 1.02531128e-01f, -8.28394145e-02f, 7.90294111e-02f, -1.53492078e-01f, -9.41038504e-02f, -2.02269107e-01f, -3.98660541e-01f,
  -6.60557672e-02f, -3.94903362e-01f, -1.61470883e-02f, 3.66443843e-02f, 3.68860774e-02f, -1.27858207e-01f, -9.83420610e-02f, 2.06271699e-03f, -1.72608361e-01f, -1.88979760e-01f,
  -1.69255450e-01f, -1.35222062e-01f, -1.81034327e-01f, -6.48104474e-02f, 7.35879913e-02f, -1.48806581e-02f, 9.75732282e-02f, -1.29844084e-01f, 4.31267023e-02f, -7.16303363e-02f,
  -2.34018818e-01f, -2.70797431e-01f, -2.52315789e-01f, -1.47994280e-01f, -3.15708742e-02f, -3.42158265e-02f, -2.12528259e-02f, -1.69927746e-01f, -9.15605798e-02f, -1.25952184e-01f,
  5.54015450e-02f, -3.49278823e-02f, 4.91211843e-03f, 5.56200966e-02f, 1.53852820e-01f, -6.76179901e-02f, 4.22408246e-02f, 6.42577857e-02f, 5.38913310e-02f, 1.56434089e-01f,
  -3.27597968e-02f, 5.91411106e-02f, 1.25658303e-01f, -4.40511331e-02f, -1.06496820e-02f, 8.06767680e-03f, -8.13251287e-02f, 1.38040319e-01f, 1.14358757e-02f, 1.22159451e-01f,
  9.08573121e-02f, -2.90942471e-02f, 6.84256181e-02f, 1.28584683e-01f, -8.83946493e-02f, -6.12108819e-02f, 1.04588857e-02f, 1.54684171e-01f, 1.06000610e-01f, -7.67595395e-02f,
  4.83845472e-01f, -1.63145065e-01f, -1.11098804e-01f, 7.28541985e-02f, 1.57542117e-02f, -7.78880045e-02f, -8.86695608e-02f, 2.57921237e-02f, -9.47342068e-02f, -6.89533725e-02f,
  -1.51806965e-01f, -1.18080556e-01f, -8.44809860e-02f, -3.04619092e-02f, 7.57977366e-02f, -8.68773386e-02f, 1.51002863e-02f, -1.48965299e-01f, 3.93589325e-02f, 4.11117785e-02f,
  7.90729150e-02f, 6.24397397e-02f, 1.42586052e-01f, 1.50677674e-02f, 9.48766842e-02f, 4.24802490e-02f, 6.11106865e-02f, 1.41001001e-01f, -1.95038430e-02f, 2.98517644e-01f,
  1.71944278e-03f, 9.42360163e-02f, 2.25223854e-01f, -3.79933938e-02f, -3.21576774e-01f, -4.59824353e-01f, -6.20102644e-01f, -4.69192356e-01f, -9.38260779e-02f, -1.56431302e-01f,
  -6.26385808e-02f, 1.36957303e-01f, 4.32658732e-01f, 3.69887017e-02f, -1.91627696e-01f, -5.39339371e-02f, -1.83830000e-02f, -7.51504228e-02f, -4.59258825e-01f, -6.89074993e-01f,
  -3.43957514e-01f, -1.60981596e-01f, -1.66129500e-01f, -1.68347299e-01f, -8.50475766e-03f, -1.22152350e-03f, 1.84259623e-01f, -1.54758382e-04f, -6.71565086e-02f, 2.42685810e-01f,
  1.60863042e-01f, -2.13400662e-01f, -2.54246034e-02f, -9.28519815e-02f, 1.12620313e-02f, -9.68227386e-02f, -1.80627868e-01f, 5.68830073e-02f, -6.51003048e-02f, -1.25141665e-01f,
  4.51407768e-02f, -1.47694454e-01f, 2.28638612e-02f, -1.14286512e-01f, -2.27865472e-01f, -2.92184412e-01f, -1.05741516e-01f, -1.69576809e-01f, 7.90001824e-02f, -1.54723629e-01f,
  -1.63318485e-01f, -1.37675047e-01f, 1.07002772e-01f, -3.01854983e-02f, -8.25347677e-02f, 5.94302639e-02f, -1.12905763e-01f, -1.31805405e-01f, -6.42258599e-02f, 9.21564326e-02f,
  -1.58573806e-01f, 2.43766725e-01f, -6.49362132e-02f, -5.25839329e-02f, -1.05919592e-01f, 1.27240047e-01f, -1.20705524e-02f, -1.05106145e-01f, -2.89059598e-02f, 3.35077345e-02f,
  -2.91888639e-02f, -2.26541935e-03f, 1.35923214e-02f, -1.55140609e-02f, 4.26007323e-02f, -4.91024218e-02f, -3.23806470e-03f, -7.85342790e-03f, -3.51333022e-02f, -2.45543364e-02f,
  -2.12228391e-02f, 1.02130741e-01f, 1.54476076e-01f, -4.93989736e-02f, -5.08510992e-02f, -1.72997154e-02f, 2.23120134e-02f, -9.55009982e-02f, -5.32515123e-02f, -7.98891410e-02f,
  2.71039814e-01f, 9.66487527e-02f, 2.56864578e-01f, -8.05965587e-02f, -5.91970868e-02f, -3.29089612e-02f, 2.70915106e-02f, -1.01840422e-01f, 1.44092798e-01f, -1.09906077e-01f,
  -1.38273299e-01f, -8.91001299e-02f, 2.78699607e-01f, 4.58626300e-02f, -2.81788886e-01f, -1.77056134e-01f, -1.47966087e-01f, -1.68400332e-02f, -1.41617958e-03f, -4.19032611e-02f,
  7.11850822e-02f, -1.94945350e-01f, 2.04523310e-01f, 1.99861795e-01f, -2.89070066e-02f, 9.74942893e-02f, 2.11416975e-01f, 5.79017289e-02f, 9.05528218e-02f, 1.38935864e-01f,
  -8.81520361e-02f, -3.33308756e-01f, -4.01029699e-02f, 2.87561834e-01f, 4.33188796e-01f, 3.70569587e-01f, 2.08888397e-01f, 1.95707992e-01f, 3.92141849e-01f, 1.62264779e-01f,
  4.58067358e-02f, 2.72831500e-01f, 2.24482223e-01f, 2.65148610e-01f, 7.44068921e-02f, 2.12287888e-01f, 3.21608096e-01f, 1.20795280e-01f, 1.00234315e-01f, 8.78960118e-02f,
  2.21527472e-01f, -1.16901979e-01f, -1.44420326e-01f, 3.94461490e-02f, 1.24632791e-01f, 3.06853145e-01f, 1.12883881e-01f, -2.64294390e-02f, -1.57844287e-03f, 6.08327873e-02f,
  -1.69465899e-01f, -2.20993057e-01f, 1.08521692e-01f, -6.31973222e-02f, -1.83561012e-01f, -8.53155553e-02f, -6.99710101e-02f, -8.11609998e-02f, -1.57389462e-01f, -1.24099389e-01f,
  -1.64543584e-01f, -8.91439095e-02f, -8.22376236e-02f, -5.18842898e-02f, -1.46245301e-01f, -6.58707842e-02f, -1.84212536e-01f, 3.34193520e-02f, -7.19598010e-02f, -8.94694217e-03f,
  -4.63507622e-02f, 1.92363914e-02f, -6.22920925e-04f, 5.93882538e-02f, 1.21355519e-01f, 6.32739440e-02f, -5.37342243e-02f, -3.20122987e-02f, 1.48670040e-02f, -9.65017602e-02f,
  2.09523901e-01f, 3.27144526e-02f, 6.32119551e-02f, 1.01313427e-01f, 3.40616629e-02f, 7.25849196e-02f, 1.84442159e-02f, 1.34918451e-01f, 7.21923485e-02f, -1.11361900e-02f,
  4.18654568e-02f, 2.05726027e-01f, 6.35362491e-02f, 5.19328602e-02f, 2.59596668e-02f, -2.88810860e-02f, -5.31461090e-04f, 3.01789418e-02f, -8.25065672e-02f, -1.48383081e-01f,
  -4.51417118e-02f, -9.86871570e-02f, -2.12495059e-01f, -1.09492674e-01f, 6.27855510e-02f, 2.34103054e-02f, 1.14400342e-01f, 8.14352632e-02f, -9.94197875e-02f, -6.94340514e-03f,
  -7.12544518e-03f, 1.81307629e-01f, 1.42888844e-01f, 1.23099992e-02f, -1.50161445e-01f, -2.33513609e-01f, 5.48928510e-03f, -1.94822222e-01f, -9.72463340e-02f, -5.58880679e-02f,
  -9.34220329e-02f, -1.60836279e-01f, -2.04388604e-01f, -1.16661653e-01f, -3.49551328e-02f, -2.01842934e-02f, -6.69832155e-03f, -3.32082920e-02f, 5.24092019e-02f, -3.88749912e-02f,
  -6.27515167e-02f, 1.53737381e-01f, 2.15654120e-01f, 1.36025310e-01f, 2.59805769e-01f, 2.52367824e-01f, 4.90595624e-02f, 8.67535099e-02f, 8.25154632e-02f, 7.83509910e-02f,
  -3.92479718e-01f, -1.08301148e-01f, 2.80140191e-01f, 1.52645558e-01f, 2.70273760e-02f, -1.00986972e-01f, -2.93410063e-01f, -1.03967637e-01f, 4.75690365e-02f, 2.61979806e-03f,
  -1.34113714e-01f, 8.65762755e-02f, 1.81518152e-01f, 1.11241758e-01f, 9.40871891e-03f, 1.34804502e-01f, 3.71377289e-01f, 2.53718257e-01f, -8.96616653e-02f, -1.87407404e-01f,
  4.69573624e-02f, 2.10953839e-02f, -3.78053226e-02f, 1.14492485e-02f, 2.02743724e-01f, 8.35322961e-02f, 8.86500478e-02f, 2.38882340e-02f, -1.05274230e-01f, 3.31304312e-01f,
  -1.83778584e-01f, -3.44289392e-01f, -6.65615723e-02f, -7.06049148e-03f, 8.70920569e-02f, 3.23924534e-02f, -2.49385219e-02f, 9.90621597e-02f, 3.40898372e-02f, 4.66961153e-02f,
  4.62026000e-02f, 2.15153750e-02f, 1.13559514e-01f, 1.54843666e-02f, -9.18614417e-02f, -3.79185379e-02f, 1.59183249e-01f, 1.55318350e-01f, 1.06285013e-01f, 5.57690561e-02f,
  2.23130986e-01f, -6.99484944e-02f, -2.12143451e-01f, -7.10363314e-02f, -5.34830941e-03f, -8.03929716e-02f, -2.48978540e-01f, -1.49642855e-01f, -3.10117155e-01f, -8.80744606e-02f,
  4.49161418e-02f, -1.00091539e-01f, 7.09103188e-03f, 8.80278870e-02f, 6.12807088e-03f, 1.52154878e-01f, 1.31202936e-01f, 6.89058155e-02f, 1.74557924e-01f, 1.77702010e-01f,
  1.31589711e-01f, -3.69073562e-02f, 5.98037541e-02f, -1.24181226e-01f, 5.52083366e-02f, 3.98068391e-02f, 1.16276979e-01f, 3.39692980e-02f, -3.36333327e-02f, 3.91477831e-02f,
  1.51314527e-01f, 2.07270250e-01f, 9.07727778e-02f, 1.43925563e-01f, 5.35381138e-02f, 7.41490722e-02f, 3.54922600e-02f, -7.56535307e-02f, -1.01483539e-01f, -1.97931692e-01f,
  -1.18340530e-01f, -2.05082282e-01f, -1.41344175e-01f, 1.29809707e-01f, 3.62578183e-02f, -6.28638174e-03f, -1.06444350e-02f, -7.39924014e-02f, -8.56757462e-02f, -1.29351348e-01f,
  -2.34818950e-01f, -3.18979025e-02f, -4.90304977e-02f, 3.08840275e-02f, -1.03501864e-01f, 1.79870166e-02f, 8.95010903e-02f, 6.36381805e-02f, 3.68974879e-02f, 5.29366396e-02f,
  1.99113891e-01f, -2.20924333e-01f, -3.20402473e-01f, -1.72834694e-01f, -1.51675582e-01f, -3.26698780e-01f, -3.19477379e-01f, -2.55457640e-01f, -3.80455136e-01f, -3.76252085e-01f,
  5.25979340e-01f, -6.31765366e-01f, -3.83165330e-02f, 3.58659744e-01f, 2.83759594e-01f, -2.26679146e-02f, -1.56314567e-01f, 1.94481146e-02f, 1.59760460e-01f, -2.07370207e-01f,
  -4.03471828e-01f, -2.76212811e-01f, -2.81151861e-01f, -2.18696669e-01f, -1.63802236e-01f, 8.11983889e-04f, 1.59751996e-01f, 9.32751298e-02f, 2.53586531e-01f, 6.86128810e-02f,
  2.49689203e-02f, 1.98885381e-01f, 8.52113441e-02f, -1.40107479e-02f, -1.44566804e-01f, -4.45848890e-02f, -2.00443521e-01f, -1.29791871e-01f, -3.77982676e-01f, -2.08804101e-01f,
  -4.31764156e-01f, -4.06794816e-01f, 1.72052220e-01f, -1.70275234e-02f, -8.91511440e-02f, -8.24903771e-02f, -1.36369959e-01f, 1.23726539e-01f, 6.36215061e-02f, 1.08497337e-01f,
  -1.12386011e-01f, -4.76983301e-02f, -5.55749089e-02f, -1.86288312e-01f, 6.97140768e-02f, 1.30073145e-01f, -3.94945927e-02f, -1.08997263e-01f, -2.21238837e-01f, -1.90230578e-01f,
  -3.03945184e-01f, -1.07737623e-01f, -2.45260932e-02f, -1.55602708e-01f, -2.02751711e-01f, -1.44891413e-02f, -1.69065922e-01f, -1.75161913e-01f, -5.83366957e-03f, 4.59241085e-02f,
  1.21629998e-01f, -1.34228557e-01f, -2.02288866e-01f, -4.63616103e-02f, 1.35357464e-02f, 9.02993679e-02f, 3.09105199e-02f, 2.79390998e-02f, -2.00891811e-02f, 1.05312258e-01f,
  -2.02974863e-02f, -1.29368238e-03f, -1.69199437e-01f, 7.46005103e-02f, -1.48436636e-01f, -1.31416842e-01f, -1.68640330e-01f, -1.59967050e-01f, -1.01734206e-01f, -1.14276074e-01f,
  -1.69072762e-01f, -8.93180668e-02f, -4.00574170e-02f, -1.65539578e-01f, -1.90487728e-01f, 8.89898371e-03f, -9.32315812e-02f, -1.02949187e-01f, 3.85379083e-02f, -5.11163138e-02f,
  -2.06059352e-01f, -1.82384893e-01f, 1.56650648e-01f, -1.47218212e-01f, 3.79134826e-02f, -2.28633508e-02f, -1.74742684e-01f, 1.35398448e-01f, 1.27282426e-01f, 3.30856107e-02f,
  -1.03155851e-01f, -2.24307645e-02f, -7.48981833e-02f, -8.81186649e-02f, 3.08100671e-01f, 1.06400505e-01f, -1.15904585e-01f, 3.47445607e-02f, 1.35625564e-02f, -5.06993420e-02f,
  -6.81746081e-02f, 2.00217500e-01f, 2.44640127e-01f, 2.46058285e-01f, 1.76767617e-01f, 3.00634652e-01f, 1.60847276e-01f, 2.04352692e-01f, 1.48165777e-01f, 4.95896995e-01f,
  -3.99136007e-01f, 6.53866649e-01f, 1.01624280e-01f, -1.68423787e-01f, 3.71376634e-01f, 5.49117029e-01f, 8.43617857e-01f, 4.81652796e-01f, -6.11136705e-02f, 2.37105921e-01f,
  2.68567979e-01f, -3.49864423e-01f, -2.49681413e-01f, -2.36906677e-01f, 4.04619612e-02f, 4.65797842e-01f, 2.44132295e-01f, -3.43281895e-01f, -3.28095019e-01f, 4.45396826e-03f,
  1.43227682e-01f, -1.65573165e-01f, -2.99629360e-01f, -1.47502363e-01f, -1.05286062e-01f, -3.23665470e-01f, 1.17962904e-01f, 1.67386979e-01f, 2.53110945e-01f, -3.25250000e-01f,
  -5.09049237e-01f, 3.38278949e-01f, -2.40108773e-01f, -2.05684841e-01f, -1.31720662e-01f, -7.34095126e-02f, 6.58428343e-03f, -9.02096927e-02f, -2.28815861e-02f, -4.17463556e-02f,
  -4.45073359e-02f, 1.66127086e-02f, -4.15520510e-03f, -3.38948555e-02f, -4.77271201e-03f, 2.21514795e-02f, 5.37464656e-02f, -5.23870811e-02f, -3.07366550e-01f, 3.44906148e-04f,
  1.00264937e-01f, 2.84557156e-02f, 1.52858287e-01f, 1.62649706e-01f, 7.50874728e-02f, -2.98715681e-01f, 9.21421126e-02f, -1.36532664e-01f, -1.22060567e-01f, -2.66213655e-01f,
  -1.84068635e-01f, -2.89251329e-03f, 1.01254337e-01f, 1.39098689e-01f, 3.18873650e-03f, 4.22075652e-02f, -3.45237693e-03f, -6.57786354e-02f, 1.73722254e-03f, 1.36897936e-01f,
  1.93086546e-02f, -7.14984536e-02f, 1.32878898e-02f, 1.40783817e-01f, -1.91042170e-01f, 6.79843724e-02f, 9.77730155e-02f, -4.36440706e-02f, -6.40561581e-02f, 1.31403580e-01f,
  -2.54533309e-02f, 1.17173521e-02f, -5.47372214e-02f, -3.40749249e-02f, 9.99714062e-02f, 7.78656155e-02f, -5.48919179e-02f, 7.15550920e-03f, 1.17446437e-01f, 4.00153309e-01f,
  -3.56843174e-01f, 3.21521640e-01f, -3.97387892e-01f, 7.26529136e-02f, -2.70779151e-02f, -3.08336224e-02f, -3.39481942e-02f, -1.01184219e-01f, 7.87058026e-02f, -4.11842130e-02f,
  6.90184236e-02f, -3.05292290e-02f, 8.27617645e-02f, 7.69421309e-02f, -4.90402291e-03f, -3.56805585e-02f, 7.02579916e-02f, -1.30059630e-01f, -1.01958528e-01f, -9.37793851e-02f,
  1.27449244e-01f, 2.83327755e-02f, -1.65757313e-01f, -3.72508690e-02f, 1.27560797e-03f, -3.02452475e-01f, -1.09314822e-01f, -4.91269901e-02f, -1.40547365e-01f, -1.05389945e-01f,
  -4.93586570e-01f, -5.03732145e-01f, -2.36216336e-01f, -6.87911093e-01f, -4.31680262e-01f, -1.02957763e-01f, -2.76573002e-01f, -2.40244314e-01f, -3.41634393e-01f, -5.31881452e-01f,
  -1.84854388e-01f, 7.73278475e-02f, -1.14174604e-01f, 1.86130881e-01f, 2.36703947e-01f, -3.43579173e-01f, -3.04457426e-01f, 2.50390708e-01f, 4.27002579e-01f, 2.09197894e-01f,
  -1.60680935e-01f, -2.21496671e-01f, 8.24956968e-02f, -4.47325036e-02f, -6.14981174e-01f, -5.82943037e-02f, -3.60297084e-01f, -2.30536237e-01f, -1.13183986e-02f, -4.02187645e-01f,
  -2.92135179e-01f, -1.86109975e-01f, 2.90248334e-01f, 1.28766656e-01f, -1.93794519e-01f, 1.99421898e-01f, -3.89366895e-02f, 5.06039858e-02f, 1.16090022e-01f, -9.57060754e-02f,
  -7.50988051e-02f, 8.89748260e-02f, -2.07162555e-02f, -5.17263860e-02f, -1.84886321e-01f, -5.02529554e-02f, -8.03856552e-03f, 8.54812860e-02f, 6.28909245e-02f, -3.54428478e-02f,
  2.26397589e-02f, -3.43937390e-02f, 2.18838193e-02f, 6.24617264e-02f, 5.68456985e-02f, 1.85453832e-01f, -8.37651193e-02f, 1.00098580e-01f, 1.20732680e-01f, -5.13224661e-01f,
  5.51347658e-02f, -1.06648982e-01f, -4.25224826e-02f, -3.36065330e-02f, 4.85681230e-03f, -8.57671127e-02f, -8.95808712e-02f, -9.12286416e-02f, 8.66428111e-03f, 2.50551291e-02f,
  -1.10726863e-01f, -1.21433608e-01f, -5.71340360e-02f, -1.74128145e-01f, -2.70920806e-02f, -8.93852487e-02f, -4.69072983e-02f, -6.69615418e-02f, -5.87413497e-02f, -5.11291400e-02f,
  6.41049072e-02f, -4.04195078e-02f, -1.32594898e-01f, 2.12887898e-02f, 4.16278094e-02f, -2.00920328e-02f, 6.78487569e-02f, 1.30701840e-01f, -7.25555196e-02f, 2.93634720e-02f,
  -2.52542496e-01f, 3.48828554e-01f, -3.78264457e-01f, 1.04374684e-01f, -1.81246340e-01f, 7.53036663e-02f, -1.21785499e-01f, 1.34870172e-01f, -2.33224854e-02f, -1.30081043e-01f,
  2.13770643e-02f, -9.43682417e-02f, -1.40104309e-01f, 6.94155246e-02f, -3.66104208e-02f, -3.88618074e-02f, -1.78100839e-02f, -1.24052621e-01f, 1.38097599e-01f, -2.28914637e-02f,
  -1.01907276e-01f, -3.28321308e-02f, -1.44333303e-01f, -6.35559410e-02f, -1.17422670e-01f, 6.57954440e-02f, -6.99689686e-02f, -6.89638034e-02f, 1.48118675e-01f, -4.45339084e-01f,
  1.06391752e+00f, -4.05199081e-01f, -4.40786630e-01f, 3.81722689e-01f, -2.57283509e-01f, -1.90117434e-01f, -3.44297647e-01f, 2.65851110e-01f, 3.30871940e-01f, -3.57866347e-01f,
  1.72572163e-05f, 6.15833998e-01f, 4.26095605e-01f, 2.90601015e-01f, 2.87288487e-01f, -5.72919428e-01f, -5.35429060e-01f, 1.67883616e-02f, 2.51495659e-01f, 6.24526925e-02f,
  -1.96581870e-01f, -9.84529406e-02f, 2.84463495e-01f, 9.57130939e-02f, -2.55999297e-01f, 4.72251251e-02f, -5.18052280e-01f, -3.24477822e-01f, -3.55538040e-01f, -5.88208973e-01f,
  -1.33859277e-01f, 1.98873460e-01f, -2.90098833e-03f, 1.71481252e-01f, -9.70733613e-02f, 8.52783471e-02f, -8.05784017e-02f, -1.49672300e-01f, -4.60885391e-02f, -2.33265042e-01f,
  -1.15721375e-01f, 1.37810372e-02f, -8.45896546e-03f, -1.55325338e-01f, -1.15087815e-01f, 1.00467540e-01f, -9.67343599e-02f, -6.20542443e-04f, 3.94697189e-02f, -1.65335104e-01f,
  -2.53746927e-01f, -1.64539173e-01f, -1.67627856e-01f, -2.41893873e-01f, 3.17789018e-02f, 1.21317375e-02f, -3.39816213e-01f, -9.89056081e-02f, -6.70720488e-02f, -3.68220747e-01f,
  2.88814567e-02f, -4.94241901e-02f, -1.56466775e-02f, -9.37827304e-02f, -1.24421259e-02f, -2.53094696e-02f, 8.45571086e-02f, -1.63355861e-02f, 3.15478258e-03f, -1.51032612e-01f,
  1.76847633e-02f, 2.92779002e-02f, 5.20882457e-02f, -8.59136414e-03f, -2.06304807e-02f, -1.03016503e-01f, -7.33412653e-02f, 2.22574230e-02f, 2.49056295e-02f, -3.51454839e-02f,
  4.58698086e-02f, 3.42065357e-02f, -3.27177793e-02f, 3.97862382e-02f, -3.91315445e-02f, 1.03183091e-01f, 5.23172542e-02f, 8.66213664e-02f, 1.53903171e-01f, 1.57291312e-02f,
  3.51187348e-01f, 2.87944637e-02f, 7.22124353e-02f, 1.06192045e-01f, -6.38600737e-02f, -7.64086992e-02f, -2.63773594e-02f, -6.96461648e-02f, 1.43527016e-02f, 8.25636759e-02f,
  -2.25504227e-02f, 5.95655255e-02f, -8.59125704e-03f, -1.00175485e-01f, -7.64430165e-02f, -2.88098995e-02f, -1.37089163e-01f, -1.49472887e-02f, -1.04501314e-01f, -2.09342882e-01f,
  -1.44288555e-01f, -2.15416849e-02f, 1.62760943e-01f, -3.58602032e-02f, -9.20674205e-02f, 1.41345471e-01f, -3.08571249e-01f, -1.44549385e-01f, 1.57923996e-01f, -2.60634482e-01f,
  5.27419508e-01f, 2.20090434e-01f, 9.83284190e-02f, 3.25693548e-01f, 3.63087296e-01f, 2.11234570e-01f, 2.51318425e-01f, -6.64091408e-02f, -7.80853704e-02f, 2.31490031e-01f,
  3.50152999e-01f, 8.42721760e-02f, -9.87472385e-02f, -1.48676589e-01f, -2.90540278e-01f, -2.30131596e-01f, -2.05016553e-01f, -2.01576263e-01f, -1.02950677e-01f, 1.79284111e-01f,
  1.37666672e-01f, 1.83388904e-01f, 2.18170509e-01f, -1.04342408e-01f, 1.78736970e-01f, 9.02234837e-02f, 2.14095667e-01f, 2.49783531e-01f, 1.51938349e-01f, -3.19698304e-02f,
  5.85176907e-02f, 3.29188585e-01f, -2.39450291e-01f, -8.76191184e-02f, 2.42898792e-01f, -1.01387203e-01f, -2.41069365e-02f, -2.71130726e-02f, -2.69187745e-02f, -1.88342899e-01f,
  3.20617110e-02f, 4.48586233e-02f, 1.35595322e-01f, 2.67339926e-02f, 7.42839873e-02f, -3.78591120e-02f, 1.31029440e-02f, -1.11812852e-01f, -1.07265875e-01f, 6.15650006e-02f,
  1.06227152e-01f, 3.23009908e-01f, 9.16733071e-02f, -1.36337832e-01f, 2.60626501e-03f, 5.15941158e-02f, -3.47481780e-02f, -4.66891974e-02f, -1.04958408e-01f, -5.79329580e-02f,
  2.50110477e-01f, 3.95157099e-01f, 2.56466746e-01f, 1.37656823e-01f, 2.07580194e-01f, 1.52238145e-01f, 2.38538519e-01f, 1.97240338e-01f, 1.93365231e-01f, 1.97635099e-01f,
  -1.59312598e-02f, 1.96757317e-01f, 2.30878517e-01f, 3.01698744e-01f, 7.09255934e-02f, 4.14311081e-01f, 2.73399025e-01f, 2.66000867e-01f, 2.23069996e-01f, 2.12537467e-01f,
  1.06341556e-01f, 1.47108763e-01f, 2.35978529e-01f, 9.27704275e-02f, 1.02861650e-01f, 2.18921021e-01f, 1.30662441e-01f, 2.27705464e-01f, 3.49733979e-01f, 2.21184805e-01f,
  -1.77799270e-01f, 9.50377882e-02f, -2.42952332e-01f, -2.91397244e-01f, 8.26227814e-02f, 5.30159138e-02f, 4.78284471e-02f, 1.55232137e-03f, 5.37124164e-02f, -1.26931131e-01f,
  -3.88142094e-02f, -2.23632553e-03f, 3.07473540e-02f, -1.45998478e-01f, -9.78786591e-03f, -3.44544537e-02f, 1.70674354e-01f, -7.61958733e-02f, -8.92087147e-02f, -9.05186832e-02f,
  -6.26227260e-02f, -9.50654522e-02f, -1.31300362e-02f, -2.30354339e-01f, -2.16399785e-02f, -4.35680896e-02f, -7.98504055e-02f, -7.84775615e-02f, -1.41543508e-01f, -1.25798985e-01f,
  4.89073575e-01f, -1.99372247e-01f, -1.90191731e-01f, 2.28796363e-01f, -1.53853402e-01f, -4.21940714e-01f, -6.87431753e-01f, -3.85991931e-01f, 1.52159035e-01f, -2.38572463e-01f,
  8.18016846e-03f, 2.17151567e-01f, 2.17784822e-01f, -2.46871859e-01f, -4.64630276e-01f, -4.87829119e-01f, -3.38675827e-01f, -3.14808369e-01f, -5.37826240e-01f, -5.85277259e-01f,
  -3.57886434e-01f, -7.60678947e-02f, -1.28595307e-01f, -1.88519031e-01f, -1.42925978e-02f, 9.62874480e-03f, 4.61029150e-02f, -1.30188331e-01f, -3.55380803e-01f, 2.44102366e-02f,
  -3.63171101e-01f, -2.25096583e-01f, -1.98950201e-01f, 1.04744621e-01f, 1.22739546e-01f, 5.55339754e-02f, -1.55553803e-01f, 6.25236481e-02f, 1.07408457e-01f, -1.22826800e-01f,
  3.03328573e-03f, -1.17953598e-01f, 3.32832485e-02f, -1.10750958e-01f, -1.79892913e-01f, -3.36168110e-01f, 5.58628514e-02f, -1.46785960e-01f, -3.14537399e-02f, -1.43578514e-01f,
  -1.64364755e-01f, -1.17781170e-01f, -1.23282358e-01f, -7.66629055e-02f, -2.46374428e-01f, 1.17632121e-01f, -2.75329858e-01f, -1.90381348e-01f, -1.01082899e-01f, -8.52917582e-02f,
  4.68792906e-03f, 7.89726153e-02f, -2.40802672e-02f, -3.37496921e-02f, -1.88121572e-02f, 1.38022721e-01f, 3.09493262e-02f, -1.47947684e-01f, -4.66829948e-02f, 3.60863879e-02f,
  -1.75258201e-02f, 7.24036014e-03f, 6.35784268e-02f, -5.60512841e-02f, -1.04354903e-01f, -1.81564707e-02f, 1.03351194e-02f, -1.24351159e-01f, -7.52883032e-02f, 2.02304795e-02f,
  -2.23548170e-02f, -5.72531670e-03f, 2.05083191e-01f, 3.94725576e-02f, -8.71113911e-02f, -1.95281859e-02f, 6.07801042e-02f, -1.22901306e-01f, -5.17853424e-02f, -3.66963483e-02f,
  1.52797520e-01f, -2.78713051e-02f, -1.54767158e-02f, -1.55502766e-01f, 8.71779993e-02f, 1.07791290e-01f, 1.65739626e-01f, -1.02047520e-02f, 1.73214346e-01f, -1.04640037e-01f,
  -2.68426716e-01f, -2.09661834e-02f, 7.97576010e-02f, -6.48110062e-02f, -1.55559704e-01f, -1.13923185e-01f, -4.87210266e-02f, 4.81358729e-02f, -8.16810280e-02f, 1.34909362e-01f,
  1.49937540e-01f, -1.93259567e-01f, -4.08260105e-03f, 1.04588278e-01f, 1.43379010e-02f, 3.44705209e-02f, -1.28176212e-01f, -1.12482212e-01f, -3.57677601e-02f, -1.46150425e-01f,
  4.34451282e-01f, 2.22160667e-01f, 2.27196440e-01f, 6.18672296e-02f, -3.99144083e-01f, -1.98394537e-01f, -8.30181502e-03f, 2.06809282e-01f, -1.71136349e-01f, -1.84553042e-01f,
  -2.49495357e-01f, -2.80544043e-01f, -1.49255320e-01f, -1.70312990e-02f, 1.05945855e-01f, 1.30582020e-01f, 1.39806449e-01f, 2.97068089e-01f, 2.46611997e-01f, 3.45155448e-02f,
  -7.95398876e-02f, 1.90093145e-01f, 2.60217547e-01f, 2.25369230e-01f, 1.15265556e-01f, -1.81267247e-01f, -8.31685308e-03f, -6.43860251e-02f, -5.64774424e-02f, 1.79887012e-01f,
  -1.10497519e-01f, 2.83118278e-01f, -2.76958644e-01f, -2.06543386e-01f, -1.28902972e-01f, 2.09415063e-01f, 5.01055196e-02f, 1.06804132e-01f, 4.24291240e-03f, 1.06618881e-01f,
  -1.19483918e-01f, 3.10181510e-02f, -1.84947979e-02f, 3.60994302e-02f, 6.88350946e-02f, 1.47381211e-02f, 1.56395406e-01f, 2.73245245e-01f, 1.59738541e-01f, -2.56741745e-03f,
  -1.19128123e-01f, -1.31746829e-01f, -3.88153978e-02f, -1.69884115e-01f, 9.83955190e-02f, -1.94609269e-01f, -3.86076272e-02f, 5.90934232e-02f, -3.56396325e-02f, 7.59723783e-02f,
  -5.11950217e-02f, 1.29973695e-01f, 5.68058342e-02f, 2.69232839e-01f, 8.56754780e-02f, 8.52584168e-02f, 1.03162043e-01f, 8.88813436e-02f, 1.76344991e-01f, 2.30318189e-01f,
  1.79721221e-01f, 9.66839045e-02f, 2.57679194e-01f, 1.86667427e-01f, -1.27098098e-01f, 3.57459188e-02f, 1.54807076e-01f, -5.47034256e-02f, -7.94089958e-02f, 1.13353014e-01f,
  5.23340777e-02f, 8.71635973e-02f, 7.36670569e-02f, 2.81593800e-01f, 2.94518359e-02f, 5.18873446e-02f, 1.09956771e-01f, 5.80056868e-02f, -3.60275176e-03f, 9.12422128e-03f,
  -2.39816800e-01f, -3.45189303e-01f, -1.70845523e-01f, 7.85225332e-02f, -8.51673782e-02f, -1.83420613e-01f, -1.21142179e-01f, -3.31659652e-02f, 1.35038793e-02f, 6.39422610e-02f,
  6.97017089e-02f, 1.47726610e-01f, -3.66208367e-02f, 1.24333173e-01f, 8.24705046e-03f, -1.66233703e-01f, -5.98183051e-02f, -1.86235681e-01f, 6.53314888e-02f, 1.18130883e-02f,
  -9.42632835e-03f, -1.60073459e-01f, -2.49087721e-01f, -2.62755901e-01f, -1.73475698e-01f, -4.09505308e-01f, -2.17925414e-01f, -1.11939095e-01f, -2.84798712e-01f, -1.84055239e-01f,
  7.12787449e-01f, 2.12515995e-01f, 2.45848581e-01f, 3.69991586e-02f, 9.56237167e-02f, 1.52942836e-01f, 1.60149485e-01f, -3.40422126e-03f, -5.65577000e-02f, 1.01090588e-01f,
  6.10902831e-02f, 1.07638530e-01f, 1.01719357e-01f, 9.69546884e-02f, 1.61644414e-01f, -1.55489519e-01f, -9.20751989e-02f, 1.46719113e-01f, 9.99146402e-02f, -1.47944372e-02f,
  -1.08142428e-01f, -1.02193439e-02f, 1.45279348e-01f, 2.77633201e-02f, -1.23098180e-01f, -9.17112455e-02f, -4.07619625e-02f, 5.81224635e-02f, 1.61820799e-02f, -3.54368716e-01f,
  -1.94698825e-01f, 2.63861418e-01f, -1.81053907e-01f, -1.37862653e-01f, 5.02355844e-02f, -3.69170532e-02f, 5.35627361e-04f, -2.28142571e-02f, -1.44898057e-01f, -1.99924529e-01f,
  -4.82938923e-02f, 2.59571075e-02f, 8.92096758e-02f, 4.93629687e-02f, -2.43289080e-02f, 5.56588359e-02f, 8.93765166e-02f, -1.23755503e-02f, -9.91460285e-04f, 2.44715996e-02f,
  2.61575617e-02f, -1.04159294e-02f, 4.82033864e-02f, 6.55347779e-02f, 6.93269372e-02f, 3.20277847e-02f, 1.17943339e-01f, 4.55020964e-02f, 1.68635830e-01f, 5.52373305e-02f,
  -1.00964531e-01f, 1.49563774e-01f, 1.14180349e-01f, -3.99832800e-03f, 8.44649747e-02f, 4.81725782e-02f, -1.38042290e-02f, 2.52811816e-02f, 1.02265351e-01f, 5.55862598e-02f,
  -9.83306989e-02f, 7.56433830e-02f, 2.95885447e-02f, 4.52090390e-02f, -1.27799679e-02f, -1.38290238e-03f, -1.57034546e-02f, -5.74573614e-02f, 7.39614591e-02f, 6.40597269e-02f,
  -3.74953933e-02f, -6.03243038e-02f, 5.43608190e-03f, -5.82769439e-02f, -5.83202913e-02f, 5.62728345e-02f, -9.87042785e-02f, 7.91748315e-02f, -8.04896802e-02f, -1.78014129e-01f,
  -4.37199414e-01f, 4.26356971e-01f, -1.67325497e-01f, -1.01685137e-01f, -3.69828641e-02f, -2.08467171e-02f, 9.43735167e-02f, -1.73202515e-01f, -1.97713509e-01f, -2.17233598e-01f,
  -1.52115554e-01f, -4.73177209e-02f, 9.92027745e-02f, -3.29529978e-02f, -1.74771190e-01f, -1.54086351e-01f, -7.69842789e-02f, -8.34085271e-02f, -2.34067794e-02f, -1.05355702e-01f,
  -3.35074798e-03f, -1.13425337e-01f, 2.67751683e-02f, -3.34618725e-02f, -3.75364833e-02f, -1.02427945e-01f, 2.14303415e-02f, -3.04726884e-02f, 1.01950012e-01f, -1.23851635e-01f,
  -1.60899118e-01f, -4.98035662e-02f, -2.88357288e-01f, 5.97651415e-02f, 8.53120312e-02f, 1.61403984e-01f, 1.70440599e-01f, 1.84992850e-01f, 1.08637571e-01f, 8.76067206e-02f,
  8.63707718e-03f, 1.08698837e-01f, 1.26543492e-01f, 2.31604036e-02f, 4.24737334e-02f, 9.29341093e-02f, 5.21395430e-02f, -1.15411445e-01f, -5.79458363e-02f, 8.30473900e-02f,
  1.56906039e-01f, 2.92312237e-03f, -1.09861039e-01f, -4.96734418e-02f, 4.24826667e-02f, 1.05527509e-02f, -8.69557410e-02f, -1.08148307e-01f, -3.82399634e-02f, -4.35583703e-02f,
  -2.73081422e-01f, -5.08516729e-02f, 2.02275943e-02f, -1.11391306e-01f, -6.18752241e-02f, 6.45696297e-02f, 9.46166068e-02f, 2.68105883e-02f, 1.05922528e-01f, 7.85836801e-02f,
  -1.34231701e-01f, -3.32809500e-02f, 4.00901586e-02f, -5.42038865e-02f, 3.97952460e-03f, -8.87839645e-02f, -3.40583734e-03f, 1.34135243e-02f, 6.07685372e-03f, -8.97833481e-02f,
  2.28021536e-02f, -8.28252137e-02f, -1.36826158e-01f, 6.11847229e-02f, 1.95772815e-02f, -1.04854129e-01f, -1.47012457e-01f, -5.94459623e-02f, -1.17696337e-01f, -1.72681753e-02f,
  9.10959840e-02f, -8.50900188e-02f, -2.39173844e-02f, 3.81774493e-02f, 9.34680626e-02f, 1.13925092e-01f, 5.05285040e-02f, -6.75859973e-02f, -1.53386302e-03f, -9.84591171e-02f,
  1.00785322e-01f, 8.41808692e-02f, 1.80000439e-02f, 6.43412098e-02f, 9.87983868e-02f, -4.99458462e-02f, -1.03733525e-01f, 5.55315316e-02f, -4.53043496e-03f, 7.82930776e-02f,
  -5.27045242e-02f, -7.79655501e-02f, -7.37703443e-02f, -1.23406854e-02f, 2.75050104e-02f, 4.27551307e-02f, 8.72842073e-02f, 3.98624968e-03f, 4.43031676e-02f, 7.35954121e-02f,
  8.51872638e-02f, -3.55917681e-03f, -5.98145649e-03f, -9.07411873e-02f, -9.51090977e-02f, -7.97966570e-02f, 6.44098818e-02f, -1.05932407e-01f, 1.44971423e-02f, 3.58535424e-02f,
  1.00883236e-02f, -6.12867884e-02f, -3.78189497e-02f, 3.32980528e-02f, -2.49973014e-02f, -7.47759193e-02f, -1.77795719e-02f, -1.06903508e-01f, 1.29951369e-02f, -7.75825530e-02f,
  -5.15772812e-02f, -9.68250334e-02f, -7.20925629e-02f, -6.09924309e-02f, 2.77785901e-02f, -5.40184183e-03f, -1.54469475e-01f, -1.04106419e-01f, 2.59650573e-02f, 1.34929949e-02f,
  -3.09697330e-01f, 3.42277251e-02f, 2.31889546e-01f, 8.72108862e-02f, -1.03983730e-02f, 9.65200439e-02f, 5.93303367e-02f, 2.03287806e-02f, 3.12604755e-02f, 1.67439599e-02f,
  -4.32489030e-02f, -1.78942680e-01f, -3.38699482e-02f, 1.02630459e-01f, 2.95474418e-02f, 1.46492645e-01f, 1.31780162e-01f, 2.38205239e-01f, 6.93908483e-02f, -5.25018200e-02f,
  -1.56412050e-02f, -2.58537624e-02f, 1.40319914e-01f, 2.03371212e-01f, 5.87717108e-02f, -1.53894708e-01f, 5.15986606e-02f, 1.43193290e-01f, 8.82264599e-02f, -2.42409809e-03f,
  3.01947117e-01f, 1.92449957e-01f, -2.17393618e-02f, 4.04897667e-02f, 1.18221253e-01f, 1.00251958e-01f, 1.54085532e-01f, 2.02632681e-01f, 8.23073536e-02f, 2.00875267e-01f,
  1.20143883e-01f, 1.87863573e-01f, 5.34486100e-02f, 1.62812009e-01f, 1.51100338e-01f, 1.37016609e-01f, 7.32934177e-02f, -3.78981531e-02f, 1.66114628e-01f, 4.45152633e-02f,
  4.22643758e-02f, 1.37005195e-01f, 1.46922082e-01f, 7.79660419e-02f, -3.50323110e-03f, 6.88924119e-02f, 1.44532919e-01f, 5.98378591e-02f, 2.01993808e-02f, -3.60269547e-02f,
  2.08709598e-01f, 4.31170911e-02f, -4.84305881e-02f, -3.80957015e-02f, -9.29467678e-02f, -1.06874272e-01f, 1.73335280e-02f, -6.14229143e-02f, -8.36774111e-02f, -1.25071988e-01f,
  -1.71016194e-02f, -1.70459315e-01f, -3.20948213e-02f, 1.27356471e-02f, 8.44764560e-02f, 5.05473278e-02f, -3.28715444e-02f, 5.47736958e-02f, 1.18752427e-01f, 3.59404609e-02f,
  -4.00081538e-02f, 1.33146092e-01f, 1.91014186e-01f, 5.56956381e-02f, 1.58335477e-01f, 1.24667272e-01f, 1.53445274e-01f, -2.92152278e-02f, 5.37650399e-02f, 6.45615254e-03f,
  2.17607826e-01f, -3.95964719e-02f, -2.05506176e-01f, -2.08118819e-02f, 3.63648571e-02f, 3.96349654e-02f, -6.79673702e-02f, -2.07074676e-02f, 7.21305236e-02f, 1.10590428e-01f,
  1.46341607e-01f, 1.26081631e-01f, 2.82128230e-02f, 1.02735972e-02f, 4.36422601e-03f, 4.79748063e-02f, -1.42017186e-01f, -7.04297647e-02f, 1.47940978e-01f, 2.25084856e-01f,
  1.38366565e-01f, -4.51303869e-02f, 6.30826578e-02f, -4.91220653e-02f, -1.60357371e-01f, -1.50075108e-01f, -1.96505170e-02f, 6.65524751e-02f, -1.05305919e-02f, -1.43409371e-01f,
  -1.23208091e-01f, -4.25611913e-01f, 3.90078783e-01f, 2.21733525e-01f, 2.24487141e-01f, -1.46610774e-02f, -8.14149901e-02f, -1.50926590e-01f, 9.60179232e-03f, 1.19289383e-01f,
  -1.44483402e-01f, -2.37969980e-01f, -3.11721023e-02f, -1.23066999e-01f, -2.59846628e-01f, -3.25906760e-04f, -4.05078009e-02f, 5.34148654e-04f, -1.60781696e-01f, -2.17019051e-01f,
  -2.25393564e-01f, -6.19955957e-02f, -1.29676923e-01f, -7.11105242e-02f, 1.98850781e-01f, 6.88569322e-02f, 1.28421471e-01f, -6.91142082e-02f, -2.19203830e-01f, 6.50365278e-02f,
  3.33518565e-01f, -3.61448735e-01f, 7.69612193e-02f, -2.27520436e-01f, 1.66901313e-02f, -1.65507495e-01f, 3.78149040e-02f, 5.06999381e-02f, -8.82085115e-02f, 1.12116165e-01f,
  -4.38497439e-02f, -1.22360267e-01f, -1.61921084e-01f, 2.33357660e-02f, -2.53960025e-02f, 2.51577087e-02f, -1.38982937e-01f, -2.04025865e-01f, -7.66351297e-02f, -1.13631599e-01f,
  -2.64899373e-01f, -1.09926172e-01f, 1.54317036e-01f, 3.40989442e-03f, -1.44537032e-01f, -1.39572332e-02f, -8.48571304e-03f, -1.37850806e-01f, -8.25681258e-03f, 1.50514275e-01f,
  3.26902606e-02f, 1.53533667e-01f, -1.32363169e-02f, 1.66078031e-01f, 6.39714450e-02f, 9.44765657e-02f, 1.15837567e-01f, 1.21455695e-02f, 4.32247296e-02f, 8.72588605e-02f,
  1.36615299e-02f, 3.40661407e-02f, -3.23492079e-03f, 5.24879582e-02f, 5.71159869e-02f, -2.08573625e-03f, 1.07380733e-01f, 5.29610999e-02f, 9.45235416e-02f, 1.38809577e-01f,
  1.96621679e-02f, 6.87777251e-02f, 9.12637338e-02f, -8.45562294e-03f, -1.33086190e-01f, -6.75246492e-03f, 6.48196563e-02f, -5.01748398e-02f, -3.59565243e-02f, -1.16465893e-02f,
  1.82435676e-01f, -3.32391709e-01f, 1.44134656e-01f, -4.75536026e-02f, -6.35472313e-02f, -1.27856433e-01f, -1.94262415e-02f, -1.96308404e-01f, -2.68958416e-02f, 1.31125236e-02f,
  -2.04561055e-01f, -1.10027425e-01f, 2.77403574e-02f, 1.74935870e-02f, 7.05341175e-02f, 2.45967675e-02f, -8.73448849e-02f, 6.14530891e-02f, -7.98199847e-02f, 3.67989321e-03f,
  -1.38590306e-01f, 6.31901398e-02f, 2.36893728e-01f, 2.23242655e-01f, 5.36325201e-02f, 1.06749289e-01f, 2.50817806e-01f, 1.70527443e-01f, 1.82096697e-02f, 1.99626520e-01f,
  -5.28537035e-01f, 5.21740973e-01f, 3.49709362e-01f, -3.61285627e-01f, 1.92618400e-01f, 3.40822548e-01f, 4.99736041e-01f, 5.25843576e-02f, -2.41801098e-01f, 2.50283003e-01f,
  2.41480827e-01f, -2.38396823e-01f, -1.76672079e-02f, -7.51894712e-02f, 1.92814227e-02f, 3.79950970e-01f, 2.86585987e-01f, -1.87570333e-01f, -4.32685077e-01f, -2.64204413e-01f,
  -1.18952058e-01f, -2.90266335e-01f, -3.84185255e-01f, -2.40647793e-01f, 3.90656441e-02f, -1.63759589e-01f, 1.62304521e-01f, 1.03344634e-01f, 2.87385255e-01f, 1.13744408e-01f,
  -3.62260416e-02f, 8.00705627e-02f, -2.41608381e-01f, -2.04283312e-01f, 1.39184996e-01f, -1.27105281e-01f, 5.93555495e-02f, -4.85630818e-02f, 3.87416892e-02f, -2.94053066e-03f,
  4.13468964e-02f, 1.64796375e-02f, 4.91814539e-02f, 2.35948022e-02f, -1.26686513e-01f, -1.41993612e-01f, -1.66538328e-01f, -2.65015900e-01f, -2.29277104e-01f, 1.65311582e-02f,
  1.59757689e-01f, -1.00443941e-02f, -8.35440494e-03f, 1.68526378e-02f, -7.71562904e-02f, -2.58909732e-01f, -2.48809215e-02f, -1.45843059e-01f, -1.08925574e-01f, -2.36364737e-01f,
  5.11786854e-03f, 9.66444518e-03f, 6.79300725e-02f, -6.20871969e-03f, 3.37735675e-02f, 6.46308064e-02f, 1.11603662e-01f, 6.42865747e-02f, -9.03321896e-03f, -2.59927455e-02f,
  5.33741899e-02f, -9.13289282e-03f, -8.01483765e-02f, 1.24388039e-01f, 3.40874717e-02f, 5.08475155e-02f, -1.31741567e-02f, -3.22867408e-02f, 4.80994359e-02f, -1.28160715e-02f,
  -1.52043447e-01f, -5.77998683e-02f, -6.65452704e-02f, -1.18129931e-01f, 1.09817579e-01f, 1.57864153e-01f, -8.35964233e-02f, -1.62888080e-01f, -7.55712241e-02f, 1.66753381e-01f,
  -3.94935578e-01f, 2.79515237e-01f, -3.10386598e-01f, -2.35773064e-02f, 1.33115873e-01f, -3.27027924e-02f, 2.08856151e-01f, 1.13254391e-01f, -2.00360399e-02f, -5.06584644e-02f,
  -5.53379348e-03f, 1.69753358e-02f, 1.56318173e-01f, -3.18764336e-02f, -1.54319003e-01f, -9.73013788e-02f, 4.76795882e-02f, -1.72369361e-01f, -1.83710232e-01f, -1.46744817e-01f,
  -4.78726579e-03f, -3.27095658e-01f, -4.01165694e-01f, -7.22237006e-02f, -1.35539964e-01f, -3.09734553e-01f, -2.45285988e-01f, -2.46234581e-01f, -1.50946304e-01f, -2.81897694e-01f,
  -2.77603418e-01f, -1.05831482e-01f, 4.10316914e-01f, -2.69495300e-04f, -4.54037525e-02f, -3.32543224e-01f, -7.28487909e-01f, -4.00950849e-01f, -3.27759869e-02f, -1.63158655e-01f,
  -1.82703227e-01f, 1.84169859e-02f, 1.28520295e-01f, -6.91300258e-02f, -4.27986532e-01f, -3.65774602e-01f, 1.28388107e-02f, 6.87275007e-02f, -1.56080320e-01f, -5.10214269e-01f,
  -3.44097048e-01f, -2.79517882e-02f, -1.19007556e-02f, 9.20182988e-02f, 3.29926461e-01f, 2.09796578e-01f, 4.78982002e-01f, 2.83369660e-01f, -1.84064973e-02f, 4.30142164e-01f,
  2.40513876e-01f, 1.08502753e-01f, 4.99878824e-02f, 3.52735259e-02f, 2.19603539e-01f, -2.81514991e-02f, -1.18467733e-01f, 2.33040258e-01f, -1.67927191e-01f, 2.94217393e-02f,
  8.64025354e-02f, -1.69244945e-01f, 8.65263119e-02f, -1.31826671e-02f, -1.64292127e-01f, -1.93149626e-01f, 2.50163637e-02f, -7.53711239e-02f, 1.06769174e-01f, 5.07834889e-02f,
  -2.29074657e-01f, -2.12136447e-01f, 2.52359677e-02f, -1.00784570e-01f, 5.51464148e-02f, 8.02752078e-02f, 1.58842176e-01f, 1.56632498e-01f, 1.55553550e-01f, 1.20084174e-01f,
  -6.46057054e-02f, 5.23583516e-02f, 6.70767874e-02f, 4.48340252e-02f, -4.41719368e-02f, 2.47132890e-02f, 7.74725601e-02f, 6.08136468e-02f, -2.79223192e-02f, -6.85014278e-02f,
  -4.68865111e-02f, -9.77361575e-03f, 3.32731567e-02f, 8.43855143e-02f, 1.26191571e-01f, 6.95284456e-02f, 4.70940024e-02f, 9.59641859e-02f, 1.64731771e-01f, 2.93367151e-02f,
  8.27213842e-03f, 2.57262234e-02f, 1.50240615e-01f, -4.81199622e-02f, 1.43256977e-01f, 1.76291391e-01f, 1.04941487e-01f, 3.93238589e-02f, 1.94653392e-01f, 2.37192772e-02f,
  1.20863043e-01f, -1.42019346e-01f, 7.31305033e-02f, -2.22133175e-02f, -4.11645509e-02f, 1.27762362e-01f, 2.12606013e-01f, -8.21943954e-02f, 1.26505479e-01f, -3.65147851e-02f,
  -3.94336879e-02f, -1.18878275e-01f, 7.51809701e-02f, -4.73973677e-02f, -2.58081287e-01f, 3.38935293e-03f, -3.07092905e-01f, -1.35113016e-01f, -1.23185650e-01f, -8.43480080e-02f,
  -1.35741994e-01f, -5.22770822e-01f, -4.22091395e-01f, -2.03778744e-01f, -5.73841557e-02f, -2.31692106e-01f, -1.36998165e-02f, -4.00578976e-02f, -3.04326087e-01f, -4.39417064e-01f,
  -7.25263715e-01f, -4.43520576e-01f, 2.19827835e-02f, -3.42802823e-01f, -3.56438845e-01f, -5.94407283e-02f, -8.57620984e-02f, 2.32910607e-02f, -2.52954751e-01f, -3.57748181e-01f,
  -3.73477489e-01f, -3.59852403e-01f, -3.13843071e-01f, -1.45099834e-02f, 9.78232995e-02f, 2.67983451e-02f, 9.59420428e-02f, 2.32195199e-01f, 3.53846312e-01f, 2.30071440e-01f,
  -1.09969243e-01f, -1.30677208e-01f, 1.93169191e-01f, 2.77240247e-01f, -1.36905774e-01f, -1.49303988e-01f, -1.22154176e-01f, -1.13110788e-01f, 2.15446111e-03f, -3.16572905e-01f,
  -1.94323555e-01f, 4.02058139e-02f, 2.13698313e-01f, -4.15525585e-02f, -1.37268528e-01f, 4.45940271e-02f, 3.27075236e-02f, 8.35825875e-02f, -8.10533836e-02f, -6.25749398e-03f,
  -1.82299078e-01f, 8.57446492e-02f, -1.58572793e-01f, 4.20982298e-03f, -9.62410793e-02f, 1.16133712e-01f, 1.47545442e-01f, 2.71071106e-01f, 1.30047444e-02f, 1.38347894e-01f,
  -9.71127450e-02f, -2.84549683e-01f, -1.88508332e-01f, 8.71109441e-02f, 2.88113534e-01f, 3.84703092e-03f, 2.02319115e-01f, 1.58410996e-01f, 1.90658212e-01f, -2.74999529e-01f,
  2.35915445e-02f, 6.45565242e-02f, 9.38594788e-02f, 5.85458055e-02f, 1.36253536e-02f, -8.57837200e-02f, -2.00039498e-03f, -8.35650936e-02f, -9.67402663e-03f, -7.18355402e-02f,
  4.24290188e-02f, -7.47661591e-02f, -6.52136654e-02f, 6.92472830e-02f, 2.62084436e-02f, -8.45608339e-02f, -1.40653446e-01f, 7.97218904e-02f, 3.68989035e-02f, 4.75613698e-02f,
  -3.85336801e-02f, 1.20262444e-01f, -6.41414374e-02f, 2.35323776e-02f, 7.14999363e-02f, 1.72355965e-01f, -1.47543531e-02f, 5.01908436e-02f, -4.03070413e-02f, -7.22838417e-02f,
  -4.24465954e-01f, 2.96030998e-01f, -3.82374406e-01f, 9.85004902e-02f, -8.81525129e-02f, 1.14853047e-01f, -1.07372731e-01f, 1.19379207e-01f, -8.65648687e-02f, 2.62968279e-02f,
  1.17631651e-01f, 4.42441925e-03f, -1.03906363e-01f, 6.49129748e-02f, -4.69872877e-02f, -2.05904357e-02f, -7.39434138e-02f, -2.90509135e-01f, -7.16601163e-02f, -1.70168132e-01f,
  -1.46128148e-01f, -2.96854079e-01f, -5.74962080e-01f, -3.97730321e-01f, -2.15372264e-01f, -2.30975255e-01f, -2.23303914e-01f, -1.90281674e-01f, -1.64969027e-01f, -5.74160755e-01f,
  7.73106158e-01f, -2.95647949e-01f, -5.95587194e-01f, 2.57627144e-02f, -2.30200425e-01f, -3.43457401e-01f, -3.66436213e-01f, -2.42051035e-01f, -5.17647713e-02f, -2.16222331e-01f,
  -1.46840438e-01f, -2.12283041e-02f, -1.33572087e-01f, -1.69725239e-01f, -1.16907567e-01f, -3.81428659e-01f, -3.23502719e-01f, -1.12889998e-01f, -5.07341735e-02f, -5.08925021e-02f,
  -1.68938309e-01f, -2.59453394e-02f, -1.59210879e-02f, -1.00322753e-01f, -2.73048460e-01f, -4.59105745e-02f, -3.39706719e-01f, -2.86560476e-01f, -3.61930072e-01f, -3.30946624e-01f,
  -5.23276806e-01f, -2.55990215e-02f, 9.42331553e-02f, 1.78395092e-01f, 7.12406188e-02f, 1.08109742e-01f, 4.29574214e-02f, 7.81715959e-02f, 3.25227194e-02f, -2.51233689e-02f,
  -5.25798462e-02f, 9.48508829e-02f, 2.95476858e-02f, 4.17994186e-02f, -1.94079578e-02f, 6.63174316e-02f, 1.42692238e-01f, 1.38817728e-01f, -1.31292176e-02f, -1.13279797e-01f,
  2.96317339e-02f, -6.49962798e-02f, -1.10537551e-01f, 1.50851235e-02f, 8.62230808e-02f, 7.25683495e-02f, 9.43372622e-02f, 1.27458125e-01f, 4.16383781e-02f, 1.53852880e-01f,
  -1.80463582e-01f, 1.68027312e-01f, 7.56370500e-02f, 1.78811669e-01f, 1.29989475e-01f, 4.60292026e-02f, 3.21234167e-02f, -3.28765549e-02f, 5.95442578e-02f, 1.04835503e-01f,
  -1.33381099e-01f, -9.84920040e-02f, 4.76421341e-02f, -3.75383981e-02f, -1.22447452e-02f, -9.93562210e-03f, -1.67664904e-02f, -4.58554476e-02f, 4.22680378e-02f, -4.37588543e-02f,
  9.56028923e-02f, -1.76459759e-01f, -1.98206976e-01f, -1.08426914e-01f, -1.71768636e-01f, -2.49048565e-02f, -3.89007889e-02f, -1.23923451e-01f, -1.75520539e-01f, -1.16811834e-01f,
  -5.20354696e-02f, 1.35649234e-01f, 2.17240468e-01f, 2.92549040e-02f, 4.72388156e-02f, 1.41164735e-02f, 1.85840353e-01f, 1.11981660e-01f, -1.30485222e-01f, -1.52514968e-02f,
  3.89483646e-02f, 1.16514275e-02f, 6.40209811e-03f, 1.51574507e-01f, 1.76611394e-01f, 1.24873333e-01f, 2.37895891e-01f, 1.36760533e-01f, 8.45633913e-03f, -4.74039093e-02f,
  2.95225158e-02f, 1.80498138e-02f, 1.11885004e-01f, 7.11167753e-02f, 2.29299441e-01f, 1.51634514e-01f, 6.07128665e-02f, -1.94628094e-03f, -1.50618479e-02f, 2.56949306e-01f,
  -2.16451451e-01f, 2.46425882e-01f, 7.24306852e-02f, 2.31358528e-01f, 3.35206449e-01f, 3.97315979e-01f, 3.22990328e-01f, 3.06009203e-01f, 1.82326347e-01f, 1.55852288e-01f,
  1.57868862e-01f, 2.82942593e-01f, 2.69655108e-01f, 2.12218955e-01f, 1.61206871e-01f, 2.36750096e-01f, 2.80866534e-01f, -6.61299676e-02f, -7.51188863e-03f, 1.15818851e-01f,
  2.03046218e-01f, 1.48552299e-01f, -5.14773950e-02f, 5.31834038e-03f, 8.99070948e-02f, 1.05148315e-01f, 1.44066587e-01f, 2.47338742e-01f, 1.16007514e-01f, 1.17999472e-01f,
  -4.21857722e-02f, -5.43664545e-02f, -1.66382287e-02f, -8.86511654e-02f, -2.96332184e-02f, -2.96146691e-01f, -8.48387405e-02f, -1.50958925e-01f, -1.44278198e-01f, -6.19357079e-02f,
  -1.01391543e-02f, -4.54995260e-02f, -6.98318658e-03f, -2.02725362e-02f, -1.64805546e-01f, -1.13415383e-01f, -4.43395227e-02f, -1.22686150e-02f, 1.48593545e-01f, -2.13561170e-02f,
  6.53570443e-02f, 2.26049572e-02f, 7.13863969e-02f, 6.29213676e-02f, 1.08024053e-01f, 5.64299412e-02f, -1.57346670e-02f, -9.86039937e-02f, -4.11448516e-02f, -8.84943157e-02f,
  1.76844001e-01f, 6.87938631e-02f, 1.11952387e-01f, 1.83316737e-01f, 1.30377173e-01f, -4.43191491e-02f, 6.78627566e-02f, 1.71001032e-01f, 1.29424214e-01f, -1.49416542e-02f,
  -1.42558105e-02f, 8.67553428e-02f, 6.86651617e-02f, -3.93403359e-02f, -3.02538974e-03f, 6.57235319e-03f, -1.35471940e-01f, 6.63371682e-02f, -1.64890452e-03f, -4.72370982e-02f,
  -5.22722639e-02f, -2.98567768e-02f, -2.21840844e-01f, -3.51997092e-02f, -6.41027614e-02f, 3.55489291e-02f, -7.72813242e-03f, -6.22738712e-02f, -1.07314214e-02f, -1.30591795e-01f,
  1.92604855e-01f, 2.58871198e-01f, 1.11493260e-01f, -8.28244444e-03f, -2.20685266e-02f, -2.43273154e-01f, 1.38639808e-01f, -5.89169823e-02f, -1.32476330e-01f, -3.50747369e-02f,
  -2.08498295e-02f, -1.23497382e-01f, -4.90579084e-02f, -1.12885712e-02f, -1.16801530e-01f, -1.86395407e-01f, 8.72389153e-02f, 2.14936346e-01f, 1.83035195e-01f, -1.48968119e-02f,
  -3.07415742e-02f, 1.05464898e-01f, -1.82081461e-02f, 3.34620401e-02f, 1.12731993e-01f, -4.33240533e-02f, -1.46910354e-01f, -1.41493380e-02f, -1.01188108e-01f, -9.05078724e-02f,
  -7.62384236e-01f, 2.43750840e-01f, 3.37125570e-01f, -4.17058527e-01f, -3.72643143e-01f, -3.16480458e-01f, 3.51341954e-03f, -2.06364825e-01f, -1.90811664e-01f, 2.00555950e-01f,
  -1.18035637e-02f, -1.84130028e-01f, -9.50569436e-02f, -2.66544130e-02f, -9.66163948e-02f, 3.59760940e-01f, 1.30321637e-01f, -3.32633704e-01f, -5.52608013e-01f, -3.85942042e-01f,
  -1.83735877e-01f, -4.90819454e-01f, -4.72386122e-01f, -2.18953848e-01f, 1.58051565e-01f, -1.77362010e-01f, 1.57793954e-01f, -2.15826169e-01f, 7.89880306e-02f, 1.21452667e-01f,
  3.30594033e-01f, -4.57557678e-01f, -9.09455195e-02f, -1.11930907e-01f, 9.22978111e-03f, 9.48224124e-03f, -1.17082618e-01f, -1.63802435e-03f, -1.03430636e-01f, -4.51693535e-02f,
  -1.26405165e-01f, -7.92481676e-02f, -6.77413270e-02f, 1.96977071e-02f, -1.54543072e-01f, 5.27695864e-02f, 1.04138628e-01f, -4.38462198e-02f, -8.03897083e-02f, 2.77078271e-01f,
  1.04993083e-01f, -1.54137954e-01f, -8.44857767e-02f, 9.91001129e-02f, -7.14508770e-03f, -1.60196796e-01f, 7.60785444e-03f, -6.64072856e-02f, -2.61739604e-02f, 6.86637387e-02f,
  1.72977239e-01f, 1.83620647e-01f, -7.13850111e-02f, -1.78529397e-02f, -2.77268747e-03f, -1.38329297e-01f, -1.98337063e-02f, -2.52485387e-02f, -6.29439726e-02f, 2.67760623e-02f,
  1.22663062e-02f, -4.46594926e-03f, -4.14206050e-02f, -1.60092190e-02f, 1.42176040e-02f, -1.11324735e-01f, -1.38917536e-01f, 8.15692618e-02f, -1.93811359e-03f, -4.04151902e-02f,
  -8.97257850e-02f, -7.81177133e-02f, -6.22801632e-02f, 9.22634527e-02f, 1.59471277e-02f, -8.55393857e-02f, 5.32638505e-02f, -7.13448077e-02f, -3.06282379e-02f, -1.38304189e-01f,
  -2.24261414e-02f, -2.03866825e-01f, 1.32081121e-01f, -3.62276249e-02f, 2.94048730e-02f, 1.12674579e-01f, 4.36134078e-02f, 8.37330073e-02f, -2.47987621e-02f, -1.22556360e-02f,
  -1.51095418e-02f, 4.64566946e-02f, 1.58018336e-01f, 1.16453111e-01f, -1.81104183e-01f, 2.12037303e-02f, 1.09160468e-01f, -1.70447342e-02f, 1.16081424e-01f, 1.78385630e-01f,
  3.16165686e-01f, -6.29352555e-02f, -4.04607877e-02f, 8.52366164e-02f, 9.83349085e-02f, -8.38988945e-02f, 1.34168804e-01f, -5.70345335e-02f, -8.17869306e-02f, 1.78513125e-01f,
  -9.63647842e-01f, -1.51239201e-01f, -6.60073683e-02f, -3.62004519e-01f, -6.22945018e-02f, 2.00755388e-01f, 2.52768964e-01f, 7.34241083e-02f, 7.59926997e-03f, -1.00765303e-01f,
  3.79005298e-02f, 9.18204561e-02f, 1.34971797e-01f, 1.21921703e-01f, 8.14286768e-02f, 1.33357212e-01f, 7.17334747e-02f, -2.26061761e-01f, -1.51698649e-01f, 1.49141341e-01f,
  1.00030646e-01f, -1.62900805e-01f, -4.06203389e-01f, -1.23574071e-01f, 1.62975982e-01f, 1.38261214e-01f, 5.22028729e-02f, -5.12169451e-02f, 1.31469637e-01f, 3.58761735e-02f,
  2.84360319e-01f, -2.05662683e-01f, 1.01961702e-01f, -9.18025151e-02f, -5.08443117e-02f, -1.85715213e-01f, -4.78711389e-02f, -8.37532803e-03f, -1.01061724e-02f, -1.01706712e-02f,
  -1.79427534e-01f, -1.21592790e-01f, -3.52889001e-02f, 7.16212168e-02f, -5.70348091e-02f, -9.26122814e-02f, -1.46363348e-01f, -8.84339362e-02f, 7.58638158e-02f, 1.53582826e-01f,
  1.80801362e-01f, -1.10027798e-01f, -8.00552294e-02f, 1.04416624e-01f, -5.40772686e-03f, -1.20884955e-01f, -4.80522364e-02f, 8.91521480e-03f, -2.20732670e-02f, 1.74883362e-02f,
  -3.28722447e-02f, -8.17803666e-03f, -8.67314041e-02f, 2.95344479e-02f, 1.07357644e-01f, 7.15358704e-02f, 7.67179281e-02f, 1.22184325e-02f, -2.62096450e-02f, -7.79578788e-03f,
  5.10080829e-02f, 1.36091933e-01f, 1.20340437e-01f, -1.02606550e-01f, -3.16250660e-02f, 3.65124666e-03f, -1.72254190e-01f, 2.82344501e-02f, 1.40822241e-02f, -8.91816914e-02f,
  -4.67147715e-02f, 1.89207681e-02f, -7.38435239e-02f, 1.51838347e-01f, -3.46215367e-02f, -7.80621124e-03f, -3.21268067e-02f, -1.66603923e-02f, 4.41322289e-02f, -5.55790663e-02f,
  2.19814554e-01f, -2.07745045e-01f, 1.85811650e-02f, 1.01918109e-01f, 7.46308360e-03f, -4.97164950e-02f, -7.10870773e-02f, -1.68670788e-02f, -3.40817459e-02f, 2.81524528e-02f,
  3.11865993e-02f, -1.56937093e-01f, -9.74525139e-02f, -5.31392507e-02f, -1.22000732e-01f, -1.02225825e-01f, -1.09602302e-01f, -3.21945921e-02f, 1.62689805e-01f, 6.67287335e-02f,
  7.38206878e-02f, -1.07427314e-01f, -1.72000736e-01f, 1.22740999e-01f, 2.41273325e-02f, -1.02663733e-01f, 1.20144077e-01f, 9.60539356e-02f, -5.41050732e-02f, -2.24299245e-02f,
  6.92479789e-01f, 7.35509336e-01f, -2.30289817e-01f, -1.69785377e-02f, -3.84010643e-01f, -1.06504120e-01f, 2.77412921e-01f, 2.81135380e-01f, 1.54885635e-01f, 1.14678256e-01f,
  5.10405423e-03f, -1.37778297e-01f, -1.52417002e-02f, -1.18317101e-02f, 1.19718194e-01f, 1.43484443e-01f, 4.26624417e-02f, -8.73280987e-02f, -1.67141706e-01f, 1.24917869e-02f,
  1.95769928e-02f, 2.25757882e-01f, 1.93645120e-01f, 1.15959696e-01f, 1.71229225e-02f, -2.33611867e-01f, 5.00565320e-02f, -8.71381238e-02f, -5.79084866e-02f, -4.79791611e-02f,
  -6.35702729e-01f, -9.11398456e-02f, -1.78729042e-01f, -3.94495726e-02f, 2.01091133e-02f, 2.02546507e-01f, -2.73153596e-02f, 9.48799103e-02f, 1.90720573e-01f, 9.97302532e-02f,
  -1.18615910e-01f, 6.79333555e-03f, 3.61283049e-02f, -1.17970012e-01f, -2.17060409e-02f, -2.92066634e-02f, 2.54814629e-03f, 1.38498008e-01f, 4.10136059e-02f, -1.34700174e-02f,
  -1.61683261e-01f, -1.86312765e-01f, -1.37043104e-01f, -2.55997367e-02f, -9.60356072e-02f, -2.58436024e-01f, -7.78259113e-02f, -1.61467016e-01f, -1.85066745e-01f, -2.81580482e-02f,
  -2.21622735e-02f, 2.07196012e-01f, -1.17440201e-01f, -1.15162566e-01f, 3.20014767e-02f, 5.66818453e-02f, 3.90269123e-02f, 4.47075069e-02f, 3.61676067e-02f, 1.52447894e-01f,
  7.43772183e-03f, -5.86558655e-02f, -2.66264882e-02f, -6.76063402e-03f, -1.53300986e-01f, -4.34431061e-02f, 3.68379876e-02f, -5.68562234e-03f, -1.16192840e-01f, -6.87371998e-04f,
  1.92893259e-02f, 3.21395099e-02f, 7.98031315e-02f, 1.29144602e-02f, -9.16338712e-02f, -1.39192529e-02f, -2.43560933e-02f, 1.53325414e-02f, 1.58626392e-01f, 1.55778825e-01f,
  6.70424998e-02f, -6.29085302e-01f, -8.45777169e-02f, -2.32432242e-02f, -1.03191167e-01f, 1.55947283e-02f, -2.23355383e-01f, -7.53969997e-02f, -5.07107377e-03f, 2.33660117e-02f,
  -8.15831423e-02f, 1.14543838e-02f, 5.27777411e-02f, 2.33174991e-02f, -1.05517775e-01f, -1.22297354e-01f, 4.43929099e-02f, -7.34591484e-03f, 2.46482659e-02f, 2.07095575e-02f,
  1.51601732e-01f, -1.71930878e-03f, -3.82378101e-02f, -4.15037051e-02f, -1.65407494e-01f, -6.66880161e-02f, -3.78833548e-03f, -4.55459692e-02f, -2.10619764e-03f, 3.22939366e-01f,
  -4.17305231e-01f, -2.21513197e-01f, -7.11295247e-01f, -1.12680376e-01f, 3.37039143e-01f, 5.49645275e-02f, -7.59448037e-02f, -2.08028466e-01f, -1.19827665e-01f, -9.39056352e-02f,
  1.68800905e-01f, 3.55935782e-01f, 1.98313035e-02f, 2.06329212e-01f, -5.46826199e-02f, -1.26612812e-01f, -4.63765152e-02f, -1.34295881e-01f, 1.08591147e-01f, 5.31972885e-01f,
  5.43081462e-01f, 1.22412823e-01f, -1.36683777e-01f, 8.84595066e-02f, 1.49593189e-01f, 2.71058232e-01f, -1.95731878e-01f, 3.56092751e-02f, 1.68092161e-01f, 9.31295529e-02f,
  -2.81979024e-01f, -4.52563822e-01f, -1.54291214e-02f, 2.30555594e-01f, 6.87366202e-02f, -2.66941637e-01f, -1.64044783e-01f, -3.09127748e-01f, -6.34747669e-02f, -2.39374310e-01f,
  9.89077836e-02f, -3.11406348e-02f, 5.16828671e-02f, -5.91422096e-02f, -1.25337452e-01f, -7.55446032e-02f, -1.75225899e-01f, -2.92125642e-01f, -3.67088914e-01f, -1.44752383e-01f,
  5.07706404e-01f, 1.70972675e-01f, -3.26763570e-01f, -2.05389053e-01f, -2.77145147e-01f, -4.39540520e-02f, -2.40256503e-01f, -1.18729644e-01f, -4.97804016e-01f, -2.27419451e-01f,
  3.76063809e-02f, 9.09011364e-02f, -5.85491806e-02f, -9.91109982e-02f, 1.55906692e-01f, -1.75898764e-02f, 6.10933155e-02f, 2.02657506e-01f, 8.02573189e-02f, -1.95466466e-02f,
  2.76948698e-02f, -8.47905278e-02f, -5.01827225e-02f, -6.68309033e-02f, 9.70622003e-02f, -7.85176307e-02f, 1.12039149e-01f, 2.55973395e-02f, 6.34847060e-02f, -1.78691484e-02f,
  -2.21429337e-02f, -6.82462826e-02f, -1.90301090e-02f, 6.30572885e-02f, -4.99754138e-02f, -1.05232760e-01f, -7.65567496e-02f, 6.61158115e-02f, 6.39787540e-02f, -6.52937172e-03f,
  -1.90859988e-01f, -3.41581166e-01f, -1.61937535e-01f, -2.64706984e-02f, 5.46912365e-02f, -1.81379840e-02f, -5.33152977e-03f, 1.04723023e-02f, -1.04902774e-01f, -1.01250440e-01f,
  -1.11203060e-01f, -1.39514402e-01f, -2.04613075e-01f, -1.01528995e-01f, -7.54366294e-02f, -1.55724734e-01f, 2.58345883e-02f, 1.42489951e-02f, -5.42694107e-02f, 8.39826837e-03f,
  -6.59479722e-02f, -6.97585866e-02f, -2.28891090e-01f, -2.56983846e-01f, -9.95539501e-02f, -3.24660242e-02f, -1.61577523e-01f, -1.94519356e-01f, -3.82618695e-01f, -3.04669648e-01f,
  1.55437320e-01f, 6.66713357e-01f, -4.86726075e-01f, 3.40123594e-01f, -3.47393095e-01f, -2.82999277e-01f, 2.20974222e-01f, 3.41249675e-01f, 2.93882906e-01f, 3.04159492e-01f,
  -2.72010237e-01f, -5.09253561e-01f, -2.80405760e-01f, -2.34115943e-01f, -1.27530083e-01f, 4.49163944e-01f, 5.15294492e-01f, -3.33353102e-01f, -6.51576459e-01f, -3.00178438e-01f,
  1.53661728e-01f, 2.56072134e-01f, 6.31803423e-02f, 6.86880797e-02f, 2.91756839e-01f, -1.02527868e-02f, 2.92112470e-01f, 7.89587200e-02f, -4.78647910e-02f, 2.19968855e-01f,
  -4.53684479e-01f, -1.09828087e-02f, -2.91857362e-01f, -2.16317073e-01f, -2.26251051e-01f, -4.39843461e-02f, -6.15857542e-02f, -4.43834551e-02f, -1.87614173e-01f, 9.21968371e-02f,
  -3.81007254e-01f, -2.74184525e-01f, -2.75050431e-01f, -2.68457346e-02f, -1.04502678e-01f, -1.93558469e-01f, 1.88480228e-01f, 5.80766127e-02f, 4.00040001e-02f, -2.59454429e-01f,
  -5.02896793e-02f, -4.37259912e-01f, -4.68874991e-01f, 3.99139859e-02f, -2.07789183e-01f, -3.62864912e-01f, -2.35911638e-01f, -2.89632142e-01f, -2.06873894e-01f, 5.40862858e-01f,
  3.32652479e-02f, -6.20109513e-02f, 7.15198293e-02f, 2.06991345e-01f, 1.95166439e-01f, -9.77482423e-02f, 8.89065415e-02f, -1.62903350e-02f, -4.51857224e-02f, 6.73714578e-02f,
  -1.55076087e-01f, -1.09543703e-01f, -2.01923743e-01f, -3.14423144e-02f, -3.09522767e-02f, -3.66133191e-02f, -1.34670138e-01f, 2.27490455e-01f, -1.60836205e-02f, 9.69035625e-02f,
  -9.37825590e-02f, -5.71930595e-02f, -1.00324169e-01f, 7.59577602e-02f, 1.38494655e-01f, 5.58191445e-03f, 7.15445206e-02f, 4.23041955e-02f, 1.03993803e-01f, 7.85713568e-02f,
  3.24027717e-01f, -1.09632917e-01f, 1.07211784e-01f, 8.07579830e-02f, -2.31231321e-02f, -3.10669951e-02f, 1.03766315e-01f, -2.90997233e-02f, -1.19553924e-01f, -1.20846607e-01f,
  -2.03755185e-01f, -1.64964110e-01f, 5.50575834e-03f, -1.59194563e-02f, -1.91662028e-01f, -1.11975633e-01f, 3.20672899e-01f, -6.31444976e-02f, 8.53786618e-03f, -8.25133175e-02f,
  4.73915666e-01f, 2.24537611e-01f, 2.60362420e-02f, 1.75017461e-01f, 3.83460103e-03f, -2.07816452e-01f, 2.58242642e-03f, 1.62872076e-02f, -1.91571668e-01f, 8.26054275e-01f,
  6.07944548e-01f, -3.17930490e-01f, 4.63438854e-02f, 3.47134382e-01f, -4.77471538e-02f, 6.48757070e-02f, 1.00885592e-01f, 1.12999111e-01f, 1.78867221e-01f, 1.28891198e-02f,
  -4.12831783e-01f, -3.97470325e-01f, -3.24234605e-01f, -3.11890900e-01f, 4.95589375e-02f, 1.88574165e-01f, 3.12973589e-01f, 2.80125290e-01f, 1.39207259e-01f, -8.48849788e-02f,
  -1.08217373e-01f, 1.15922652e-01f, 2.09801316e-01f, -6.50972361e-04f, -1.78313166e-01f, -4.19249646e-02f, -4.61676344e-02f, -5.59668727e-02f, -1.45291954e-01f, -2.27293652e-02f,
  -1.28195718e-01f, -3.57913151e-02f, 8.50845501e-02f, -2.47564614e-01f, -1.51308596e-01f, -7.60929892e-03f, 1.10355191e-01f, -3.79781239e-02f, -1.36502862e-01f, 5.37901483e-02f,
  -2.25914195e-01f, -2.18039140e-01f, -1.82529792e-01f, -1.46353945e-01f, -1.01437978e-01f, 8.44137818e-02f, -1.15441799e-01f, 2.13343557e-02f, -6.30394742e-02f, -1.77600890e-01f,
  -2.82814562e-01f, -1.19329490e-01f, -2.99344324e-02f, 3.76799639e-04f, -8.95488188e-02f, -2.43967006e-04f, -1.56411290e-01f, -1.51614144e-01f, -8.27180296e-02f, 1.27561897e-01f,
  1.47398949e-01f, 6.31326018e-03f, -2.82994118e-02f, 5.09670302e-02f, 9.61696613e-04f, -9.46256295e-02f, -9.49072931e-03f, -6.80546239e-02f, 1.46036902e-02f, 1.42195523e-01f,
  1.00973621e-01f, 1.40623242e-01f, 1.08598255e-01f, 1.09855533e-01f, 3.14698778e-02f, -1.71393435e-02f, 1.59864843e-01f, -7.91760013e-02f, 3.20564285e-02f, 1.45869642e-01f,
  -1.36204604e-02f, -4.73683281e-03f, -5.50043769e-02f, -2.97856834e-02f, 7.34239817e-02f, -2.81477775e-02f, 6.16773702e-02f, -9.29081813e-02f, -2.90831253e-02f, 5.33315539e-02f,
  6.20090812e-02f, -1.76382706e-01f, 1.78380221e-01f, -3.29977833e-02f, -4.97533605e-02f, -1.11297332e-01f, 4.55157645e-03f, 2.84930263e-02f, -1.43995404e-01f, -2.54067071e-02f,
  -1.60950989e-01f, -1.53825447e-01f, -1.19703040e-01f, -2.91548856e-02f, 8.66428092e-02f, 3.23034730e-03f, -6.29202574e-02f, 6.41385987e-02f, -5.74428141e-02f, -5.63692041e-02f,
  -3.63365263e-02f, 7.84784332e-02f, 2.76301920e-01f, 1.36292174e-01f, -1.70789752e-02f, 1.36844009e-01f, 7.23208785e-02f, 2.31091827e-02f, 5.60816377e-02f, 3.79356652e-01f,
  -2.23228753e-01f, 2.03151047e-01f, -6.47943676e-01f, -8.17666128e-02f, -1.69362664e-01f, -1.40733615e-01f, 2.60825366e-01f, 3.22308093e-01f, 1.89389065e-01f, 2.52788186e-01f,
  -3.03303115e-02f, -4.24109966e-01f, -5.14256299e-01f, -3.67967546e-01f, -3.15061510e-01f, -2.24227328e-02f, -2.68435329e-01f, -5.34076810e-01f, -3.74276608e-01f, 1.50824457e-01f,
  1.22714564e-01f, -8.84537771e-02f, -2.75080591e-01f, -4.70082611e-02f, -4.92545739e-02f, -4.43373233e-01f, -2.88548023e-01f, -2.99561560e-01f, -3.46391886e-01f, -4.00404364e-01f,
  -1.96947441e-01f, -4.99236733e-02f, -2.93858126e-02f, -1.55206203e-01f, 6.79354668e-02f, -3.98933478e-02f, 7.94773847e-02f, -9.62076038e-02f, -1.85097471e-01f, 1.05231265e-02f,
  -1.61785752e-01f, 1.17175624e-01f, -1.14625923e-01f, -1.08867504e-01f, 9.92226694e-03f, -6.38401210e-02f, -5.21901734e-02f, -1.65620849e-01f, -2.46860594e-01f, 7.25214928e-02f,
  -1.42835146e-02f, -3.01193327e-01f, -3.78547430e-01f, 4.44550514e-02f, -5.52729741e-02f, -3.04842114e-01f, -8.45504552e-02f, -7.49122351e-02f, -2.60251969e-01f, 4.27826531e-02f,
  2.40957037e-01f, -1.86370127e-02f, -7.77740031e-02f, 1.58089027e-03f, 1.87327594e-01f, -6.68388791e-03f, 1.37217948e-02f, -1.35604627e-02f, -7.75709525e-02f, -5.06118499e-03f,
  7.71843791e-02f, 9.91179049e-02f, -2.48962659e-02f, -8.75213009e-04f, -1.02891617e-01f, -6.71532750e-02f, -5.57838678e-02f, 1.45959452e-01f, -1.87567167e-03f, -1.82701349e-02f,
  -1.41929328e-01f, -1.19821692e-03f, -7.40340725e-02f, 4.07393314e-02f, -1.26389027e-01f, -1.47728426e-02f, 2.86630094e-02f, -4.68732715e-02f, -8.98979604e-02f, -3.01085077e-02f,
  1.82658181e-01f, -1.93137854e-01f, 2.71640103e-02f, -7.19978213e-02f, 2.96750795e-02f, 4.51862924e-02f, 2.25745961e-02f, 7.18029737e-02f, -1.79822475e-01f, 4.45846133e-02f,
  -4.50071553e-03f, 1.73532650e-01f, 1.44099826e-02f, 2.62047979e-03f, 6.33065253e-02f, -8.46045092e-02f, 2.31017902e-01f, -2.01331720e-01f, -1.52736932e-01f, 1.12845272e-01f,
  1.35993317e-01f, -8.21935758e-02f, -8.89358371e-02f, -7.91999400e-02f, -1.27087394e-02f, -1.98376060e-01f, -9.19650719e-02f, 1.09808467e-01f, -1.64410874e-01f, 3.70358407e-01f,
  -5.97485602e-01f, -2.05638528e-01f, 2.48759687e-01f, 7.55596533e-02f, 3.11234325e-01f, 3.19921523e-01f, 4.36413497e-01f, 2.41689235e-01f, 8.56128260e-02f, 1.13472983e-01f,
  -2.26156890e-01f, -2.27804288e-01f, -6.97982460e-02f, -1.27650544e-01f, -1.19894281e-01f, 2.22650051e-01f, 3.60588282e-01f, 1.58952940e-02f, 2.14313552e-01f, 6.29302785e-02f,
  6.14211103e-03f, -2.47375965e-02f, -2.02714995e-01f, -1.54980654e-02f, 3.45737450e-02f, 9.63281244e-02f, 3.50515135e-02f, -4.31387238e-02f, 3.20841037e-02f, -6.82008266e-02f,
  2.21715152e-01f, -2.23576650e-01f, 7.19463872e-03f, -2.31488436e-01f, -1.69594795e-01f, -1.44294769e-01f, 6.27704039e-02f, -1.12741336e-01f, -9.08018351e-02f, 1.03399135e-01f,
  -8.55595246e-02f, -1.09919123e-01f, 3.15276086e-02f, 3.95777775e-03f, -1.45961195e-02f, -1.76454498e-03f, -1.06239758e-01f, -2.03533974e-02f, 6.02117255e-02f, 1.31474975e-02f,
  -8.62829611e-02f, 5.17903976e-02f, 1.89174965e-01f, 1.29602000e-01f, -8.23024951e-04f, -5.34605458e-02f, 1.02056365e-03f, -1.20899370e-02f, -4.85242307e-02f, 1.16686989e-02f,
  1.23792842e-01f, 1.27661955e-02f, -1.33153036e-01f, 6.43335059e-02f, -3.25568542e-02f, 3.24689709e-02f, 7.38650411e-02f, 1.50160745e-01f, 8.46559182e-02f, 8.29837769e-02f,
  5.31865237e-03f, 1.51601866e-01f, 6.33997172e-02f, 6.96473792e-02f, -1.09144755e-01f, 7.90612772e-03f, 2.31648106e-02f, 6.38157651e-02f, -7.53130242e-02f, 8.86219665e-02f,
  8.84890258e-02f, 1.36715755e-01f, -3.08931293e-03f, -1.37887383e-02f, -7.46725351e-02f, -2.81871147e-02f, -4.41036839e-03f, -8.20365474e-02f, 7.67341480e-02f, 2.70104539e-02f,
  2.42866635e-01f, -7.61688352e-02f, 8.98038447e-02f, -8.95231888e-02f, 3.61050665e-03f, -6.62448257e-02f, 8.26994330e-03f, -1.22385286e-01f, -5.48346639e-02f, 1.17139019e-01f,
  -5.86473458e-02f, -2.91482769e-02f, -5.36625907e-02f, 5.74251171e-03f, 5.15516847e-02f, -9.22585279e-03f, -3.88618782e-02f, 1.25378415e-01f, -2.17044167e-03f, 4.97796722e-02f,
  3.25918421e-02f, 1.32564247e-01f, 2.27847382e-01f, 1.87358603e-01f, 5.74650131e-02f, 1.45377725e-01f, 1.65353894e-01f, 8.79738294e-03f, 8.03617463e-02f, 5.28419241e-02f,
  5.37914336e-01f, 2.77161360e-01f, 1.81571290e-01f, 8.32122788e-02f, -3.68247867e-01f, -2.66847551e-01f, -3.84815842e-01f, 6.14123512e-03f, 3.41438316e-02f, -4.24997993e-02f,
  -3.22676986e-01f, -2.54676580e-01f, -4.81847562e-02f, -1.13624990e-01f, -1.62619427e-01f, -4.02665464e-03f, 1.00466413e-02f, 1.26284406e-01f, -7.70509467e-02f, -3.32517445e-01f,
  -3.11804831e-01f, -4.84819598e-02f, 3.24584357e-02f, 1.46818995e-01f, 3.05928737e-01f, -1.77391335e-01f, 2.18874097e-01f, 7.30621116e-03f, -1.41226724e-01f, 2.89075613e-01f,
  1.53841957e-01f, 5.32702267e-01f, -5.12296438e-01f, -2.16924042e-01f, -1.17892921e-01f, 1.26420468e-01f, -5.82204796e-02f, 3.01911980e-01f, -1.18467361e-01f, 8.05446580e-02f,
  -6.65139556e-02f, 7.78378397e-02f, 2.35706065e-02f, 7.10780546e-02f, 2.78408322e-02f, -1.21123299e-01f, 2.06950188e-01f, 1.17109850e-01f, 6.20068759e-02f, 4.39783558e-02f,
  -2.71177173e-01f, -1.57580256e-01f, -3.54647301e-02f, -2.25976557e-01f, 2.15516806e-01f, -2.92402148e-01f, -4.74004485e-02f, 1.73079014e-01f, 3.23308893e-02f, 3.92746538e-01f,
  -1.01417422e-01f, -4.56458591e-02f, 3.92883979e-02f, 1.67416200e-01f, -5.07096872e-02f, 3.45322378e-02f, 1.50381595e-01f, -9.58888978e-02f, -3.95290032e-02f, 8.17014277e-02f,
  -5.73240966e-02f, -8.67565051e-02f, 1.18458658e-01f, 1.18147060e-01f, -3.33426110e-02f, -1.11589292e-02f, -7.54896551e-02f, -1.14398442e-01f, -8.93757716e-02f, 8.22251812e-02f,
  -1.56508654e-01f, -1.11531287e-01f, 2.41738949e-02f, 1.37303472e-01f, -4.02820148e-02f, 7.44677009e-03f, -1.78810186e-03f, -3.47281769e-02f, 2.07102448e-02f, 1.71297882e-02f,
  -2.09260300e-01f, -4.84037906e-01f, -8.57911408e-02f, 1.91450752e-02f, 7.00876936e-02f, -1.73835680e-01f, -1.52619660e-01f, -1.17275305e-01f, -9.82624814e-02f, -4.13851440e-02f,
  -1.59783170e-01f, -7.93543551e-03f, 5.62181771e-02f, -1.40910208e-01f, -1.79832369e-01f, -1.61683470e-01f, -3.51761758e-01f, -2.13442028e-01f, -2.53237277e-01f, 7.58492202e-02f,
  -1.71126842e-01f, -3.41909558e-01f, -3.55760247e-01f, -2.97257543e-01f, -1.25298470e-01f, -4.67885792e-01f, -2.49967515e-01f, -2.18963891e-01f, -3.75493854e-01f, -2.29209825e-01f,
  3.52843970e-01f, 2.09181279e-01f, 5.69443524e-01f, -2.39710510e-01f, -9.31263566e-02f, -1.04625814e-01f, -1.09407537e-01f, -1.04360126e-01f, -2.57931471e-01f, 9.16941166e-02f,
  1.09591372e-01f, -2.36311868e-01f, -1.76864900e-02f, 5.64326346e-02f, 2.90012538e-01f, 8.05605948e-02f, 2.24693641e-01f, 4.13682252e-01f, 1.76806256e-01f, -2.32460558e-01f,
  -3.49259317e-01f, -8.88951868e-03f, 2.91915625e-01f, 3.30106691e-02f, -1.89268678e-01f, -2.74671167e-01f, 1.55255541e-01f, 1.98615775e-01f, 1.51801467e-01f, 1.55438796e-01f,
  2.32577205e-01f, 2.73386776e-01f, -3.60434920e-01f, -3.10628917e-02f, 1.95556059e-01f, 6.85830880e-03f, -1.21368177e-01f, 7.52954111e-02f, -5.06027020e-04f, 1.27080716e-02f,
  5.66621013e-02f, 5.71869537e-02f, -5.65359462e-03f, 1.16176710e-01f, 1.01662092e-01f, -6.54722154e-02f, 1.81409210e-01f, 1.31041661e-01f, 1.76249549e-01f, 9.22237039e-02f,
  -2.11597845e-01f, 2.70921011e-02f, 1.94118381e-01f, -1.65136069e-01f, 6.00795485e-02f, -1.31049663e-01f, 1.25330672e-01f, -1.22409478e-01f, -9.83317047e-02f, -1.66988775e-01f,
  -2.03026131e-01f, 1.39342427e-01f, 1.72139660e-01f, 9.88171473e-02f, 1.03242705e-02f, 2.90051568e-02f, 1.06664546e-01f, 5.28635271e-02f, 1.52113102e-02f, 6.36346713e-02f,
  -4.68996130e-02f, -2.81160325e-03f, 1.26495332e-01f, 1.63884498e-02f, -2.60964185e-01f, -8.00300017e-02f, 2.85534393e-02f, 7.62233287e-02f, 1.19384885e-01f, -2.74862465e-03f,
  -8.05331469e-02f, -7.70689026e-02f, 5.07253408e-02f, 1.64571907e-02f, -1.80931855e-02f, -1.87355503e-02f, -2.05509633e-01f, -8.68913659e-04f, -2.05845922e-01f, -8.05769712e-02f,
  -2.52151638e-01f, 3.23457539e-01f, -2.40481198e-01f, -9.09946486e-03f, 8.36944953e-02f, 5.65416329e-02f, -1.06115229e-01f, 2.23691277e-02f, -3.34844366e-02f, -1.28949970e-01f,
  1.33103086e-02f, -8.29459652e-02f, -4.20949906e-02f, 1.01412637e-02f, -2.31036365e-01f, -1.80783555e-01f, -1.30186558e-01f, -6.74321353e-02f, -9.53423083e-02f, 6.09845743e-02f,
  -1.25862643e-01f, -3.69977474e-01f, -3.83097678e-01f, -4.94632304e-01f, -4.78942811e-01f, -5.63574493e-01f, -2.60620356e-01f, -2.44928375e-01f, -2.41907582e-01f, -3.81099582e-01f,
  5.94565928e-01f, 2.77581632e-01f, 2.35649094e-01f, 5.42449020e-02f, -2.19868764e-01f, -2.86768079e-01f, -4.13048059e-01f, -3.88954610e-01f, -6.71843514e-02f, 8.81337970e-02f,
  2.52073258e-01f, 1.20510422e-01f, 1.45653963e-01f, 3.51398923e-02f, -4.97767106e-02f, -1.94310442e-01f, -1.21548615e-01f, 1.55561119e-01f, 1.40634095e-02f, 3.14644948e-02f,
  8.98077488e-02f, 9.46170166e-02f, 3.57755572e-01f, 2.02773716e-02f, 1.92499340e-01f, 2.29860976e-01f, 1.79474607e-01f, 2.41937578e-01f, 2.01646477e-01f, 3.92240494e-01f,
  5.25182366e-01f, 2.33818710e-01f, -2.58757919e-01f, 1.22293718e-02f, 8.24774057e-02f, 4.86503989e-02f, 8.82477909e-02f, 7.09086135e-02f, -1.81756243e-01f, -1.49414614e-01f,
  5.42712733e-02f, 1.44365542e-02f, -1.73486210e-02f, -3.61909643e-02f, -1.57947555e-01f, -1.65001452e-01f, -8.16933513e-02f, -1.70364738e-01f, -1.35080054e-01f, -2.60439459e-02f,
  3.76649424e-02f, 7.73973912e-02f, -1.96370974e-01f, -3.56506824e-01f, -2.50474930e-01f, -1.41728342e-01f, -2.83839926e-02f, -6.40520453e-02f, -2.28557259e-01f, 1.08590862e-02f,
  -1.62416875e-01f, -1.82354301e-01f, -7.39911646e-02f, -1.52053922e-01f, -2.66322583e-01f, -2.02430472e-01f, -1.84784785e-01f, -8.15460980e-02f, -2.39048302e-01f, -1.70745954e-01f,
  -7.27875978e-02f, -2.18005478e-02f, -1.02872767e-01f, -4.38589305e-02f, -7.52642285e-03f, -2.18429305e-02f, -1.74652874e-01f, -1.00543596e-01f, -7.28813335e-02f, -5.98382726e-02f,
  -7.42347091e-02f, -2.09525898e-01f, -7.27327093e-02f, -1.66156054e-01f, -7.36943483e-02f, -1.64739266e-01f, -1.47560745e-01f, -5.54966368e-02f, -2.65868288e-02f, 1.49635589e-02f,
  7.79248402e-02f, -7.35375583e-02f, 1.98183775e-01f, 1.33488417e-01f, 2.14930564e-01f, 2.12936908e-01f, 3.02953154e-01f, 6.19425848e-02f, -4.54413326e-04f, -8.76379311e-02f,
  3.79414484e-02f, 1.58778831e-01f, -6.10006158e-04f, 3.29584628e-02f, 7.50181228e-02f, -3.82387936e-02f, 1.15350634e-01f, -2.96709631e-02f, -8.94033909e-02f, 3.29153761e-02f,
  -7.34678879e-02f, -1.26114398e-01f, -1.50235191e-01f, -2.05926776e-01f, -1.63389266e-01f, -1.11349024e-01f, -2.41280440e-02f, -1.18938178e-01f, -9.16371569e-02f, -2.86007345e-01f,
  -1.57222047e-01f, -2.73494184e-01f, -5.21485090e-01f, -4.98076081e-01f, -2.91488916e-01f, -1.08552363e-03f, 1.39087990e-01f, 2.81457417e-02f, -2.95573801e-01f, -3.24540466e-01f,
  -8.40935037e-02f, -1.40213203e-02f, -2.11856663e-01f, 7.57747814e-02f, 2.05829129e-01f, -1.28598794e-01f, -3.07126760e-01f, -1.10684991e-01f, 1.23856604e-01f, 2.07718194e-01f,
  5.44190481e-02f, -2.28787184e-01f, -7.45989457e-02f, -1.26379877e-01f, -3.21842134e-01f, -1.56669468e-01f, -4.44031805e-01f, -1.39387891e-01f, 3.11416667e-02f, -3.81918371e-01f,
  -3.93140823e-01f, -1.38024271e-01f, 4.73017320e-02f, 7.48469308e-02f, -1.65870473e-01f, 4.30770963e-02f, 3.20341415e-03f, -1.69493943e-01f, 6.55680075e-02f, -1.34654775e-01f,
  -4.86285500e-02f, -1.26137650e-02f, -4.27291729e-02f, -1.22417763e-01f, -2.26271570e-01f, 2.76390836e-02f, -7.67100081e-02f, -2.01483388e-02f, 5.73334619e-02f, 2.96697346e-03f,
  2.16732442e-01f, 4.41012867e-02f, -7.43825454e-03f, 5.05217537e-02f, 1.45196199e-01f, -4.80352566e-02f, 6.48108274e-02f, 1.56046793e-01f, 7.76424557e-02f, -1.29594654e-01f,
  1.73408613e-01f, -6.40873089e-02f, 6.10787980e-02f, 2.90870443e-02f, 8.34273845e-02f, 4.09767218e-02f, -8.50254521e-02f, 3.94868553e-02f, 7.97128305e-02f, 9.13270935e-02f,
  -5.77667402e-03f, 2.92753633e-02f, -1.94667857e-02f, 3.31581831e-02f, -5.32213263e-02f, -3.27014066e-02f, 9.79187563e-02f, 1.80942155e-02f, -1.39110303e-02f, 3.48553271e-03f,
  8.72867405e-02f, 1.33967265e-01f, -4.89415638e-02f, 1.24652646e-01f, 1.86498225e-01f, -2.85751335e-02f, 5.83267305e-03f, 1.26740202e-01f, -5.27074113e-02f, 3.24666388e-02f,
  -4.12237704e-01f, 2.75487542e-01f, -1.76271424e-01f, 1.48944110e-01f, -1.76829904e-01f, -1.45373821e-01f, -1.29603773e-01f, -1.09599851e-01f, -1.66969985e-01f, -5.83795533e-02f,
  4.05109674e-02f, -2.15169787e-02f, -1.60304174e-01f, 1.32665681e-02f, 5.62743880e-02f, 1.13389373e-01f, 4.04405370e-02f, -9.39434916e-02f, 2.24554285e-01f, 7.94182569e-02f,
  1.61164582e-01f, 1.80627882e-01f, 1.66838348e-01f, 5.87053001e-02f, 1.45946130e-01f, 1.08217403e-01f, -1.74922813e-02f, 1.31390467e-01f, 1.88617066e-01f, 2.59703528e-02f,
  -3.95937979e-01f, -1.93836495e-01f, 6.23149276e-02f, 2.62419134e-01f, 2.03848079e-01f, -3.56832176e-01f, -5.77908874e-01f, -4.08719450e-01f, -3.39907184e-02f, -1.91408083e-01f,
  9.30319633e-03f, 3.34266454e-01f, 1.95669830e-01f, 2.52171606e-01f, -1.33429050e-01f, -1.04113437e-01f, 4.02076989e-01f, 3.86107713e-01f, 1.94379985e-01f, 1.28642529e-01f,
  4.29828048e-01f, 4.04766798e-01f, 3.55489135e-01f, 2.56216407e-01f, 1.52589023e-01f, 3.62027735e-01f, 2.03865841e-01f, 2.73106128e-01f, 1.01194456e-01f, 3.83618712e-01f,
  -3.68487656e-01f, -4.10998493e-01f, -1.89794991e-02f, 3.18416744e-01f, 1.09545320e-01f, -1.30888566e-01f, -1.57938138e-01f, 9.62469354e-02f, 3.93690774e-03f, -7.18330443e-02f,
  2.34472647e-01f, 2.08652578e-02f, 8.00460726e-02f, 8.99711028e-02f, 6.81732744e-02f, -3.32630426e-01f, 4.62168008e-02f, -1.28728107e-01f, -2.16825664e-01f, -1.86007515e-01f,
  3.31321925e-01f, 1.56089276e-01f, -2.98141778e-01f, -2.22647995e-01f, -3.89050961e-01f, 2.84723908e-01f, -2.14295432e-01f, -2.49907687e-01f, -3.12903285e-01f, -2.50289798e-01f,
  -2.34745815e-02f, 8.45310166e-02f, -4.77659479e-02f, -6.54267818e-02f, -4.50070277e-02f, -4.06449847e-02f, 8.43919888e-02f, -3.64846811e-02f, 1.01049589e-02f, -1.21895961e-01f,
  -9.77310613e-02f, -9.57214087e-02f, -4.14966270e-02f, -2.36174405e-01f, 1.26541927e-01f, -5.60587831e-03f, -6.07158728e-02f, -4.41253558e-02f, 9.30444151e-03f, -4.05129232e-02f,
  -2.21308973e-02f, -8.43610615e-02f, 1.91289902e-01f, -1.49662457e-02f, 2.43199766e-02f, 4.63820919e-02f, 2.49682236e-02f, 7.81841800e-02f, 3.14598978e-02f, 1.19568012e-03f,
  -1.10355252e-02f, 2.41919234e-01f, -2.69670695e-01f, -3.24546359e-02f, -9.57612023e-02f, 3.22325490e-02f, 8.85793641e-02f, 5.91555797e-02f, 1.27721240e-03f, -1.00447148e-01f,
  -1.51099131e-01f, -9.76301655e-02f, 6.99447421e-03f, 7.37674311e-02f, -1.26114590e-02f, -1.93211049e-01f, 2.53860857e-02f, 1.98441511e-03f, -1.03412634e-02f, -4.22527082e-02f,
  1.05837598e-01f, -2.38306299e-01f, -2.97401607e-01f, -1.87346280e-01f, -1.72525287e-01f, -4.76911515e-02f, -1.01757005e-01f, -2.97770023e-01f, -3.52306545e-01f, -4.07473534e-01f,
  -4.42147881e-01f, -6.41276836e-01f, 5.76519430e-01f, -1.42477363e-01f, 1.67841643e-01f, 3.29951435e-01f, 1.60671845e-01f, 9.39035714e-02f, -1.37795404e-01f, -3.06981772e-01f,
  -4.48578328e-01f, -2.92972893e-01f, -1.56861052e-01f, -6.27194494e-02f, 2.03814153e-02f, 1.62707627e-01f, 3.65844488e-01f, 4.75308359e-01f, 4.76517379e-01f, 5.82429441e-03f,
  -1.09458409e-01f, -1.39933154e-01f, 1.88464131e-02f, 1.09522849e-01f, -1.90186486e-01f, -6.10490553e-02f, -1.11758360e-03f, 4.56524780e-03f, -8.08476955e-02f, -7.86725581e-02f,
  -1.92949101e-01f, -2.84616828e-01f, 1.75455183e-01f, -7.96919465e-02f, -1.88683197e-01f, -9.72990021e-02f, -9.51055586e-02f, -6.13539629e-02f, -1.08553275e-01f, -6.57916740e-02f,
  -8.03364962e-02f, -3.35173905e-02f, -2.36089807e-02f, -1.48975044e-01f, -2.29148082e-02f, -1.62785470e-01f, 4.41820882e-02f, 2.20173132e-02f, 1.15550812e-02f, -1.82479829e-01f,
  -1.58302441e-01f, 2.47015301e-02f, 3.45036015e-02f, 9.29943696e-02f, -1.16351590e-01f, 1.14276089e-01f, -4.41633649e-02f, -1.38540808e-02f, 1.13039449e-01f, -2.24583209e-01f,
  1.25099793e-01f, -1.47197815e-03f, 3.99329960e-02f, -5.91998594e-03f, -6.35935226e-03f, 4.69700135e-02f, 1.52473733e-01f, 1.11646261e-02f, 7.36068785e-02f, -6.16290383e-02f,
  -6.03268519e-02f, 7.84649476e-02f, -8.21956247e-03f, -8.72028023e-02f, -2.57866830e-01f, -9.18415748e-03f, -2.39179898e-02f, -1.49922073e-01f, -9.11042616e-02f, 3.78784426e-02f,
  -9.85965058e-02f, 7.83333778e-02f, 2.80159470e-02f, 2.24473956e-03f, -3.85514311e-02f, 7.36602545e-02f, 2.61649699e-03f, -2.11865798e-01f, -1.23863146e-01f, 3.73943113e-02f,
  -3.15248132e-01f, 3.60637039e-01f, -6.69743344e-02f, -3.57300788e-02f, -1.28245912e-02f, 7.97563465e-04f, -1.07487269e-01f, -4.40963693e-02f, -3.94481234e-02f, -1.59205198e-02f,
  -1.18939891e-01f, 4.04441636e-03f, -4.99683544e-02f, 7.30279237e-02f, 1.51218086e-01f, -1.73998550e-02f, -1.42728329e-01f, 1.18405543e-01f, 1.12261167e-02f, -1.41482092e-02f,
  2.91479155e-02f, 8.36374909e-02f, 5.96260931e-03f, 1.16649576e-01f, -7.94326738e-02f, 2.36016959e-01f, 6.87207654e-02f, 6.77620843e-02f, 1.48174465e-01f, -7.62373656e-02f,
  -8.02630067e-01f, 3.39867949e-01f, -1.60727240e-02f, -4.68282342e-01f, -8.17174315e-02f, 2.69107550e-01f, 6.19368434e-01f, 1.08971052e-01f, -3.14548552e-01f, 6.10332042e-02f,
  9.99431685e-02f, -2.55396124e-02f, 4.61694002e-02f, 1.18840650e-01f, 2.60491341e-01f, 4.60266024e-01f, 1.27146199e-01f, 1.65865049e-02f, -9.34051350e-03f, 9.00113732e-02f,
  1.72515675e-01f, -1.29512936e-01f, -4.14649636e-01f, -2.79301137e-01f, -1.53714657e-01f, 1.88108366e-02f, -9.06153172e-02f, -1.37239024e-01f, 9.18253511e-02f, -3.91142769e-03f,
  2.94000655e-01f, -4.88885850e-01f, -3.96792069e-02f, -3.76116991e-01f, -1.73143744e-01f, -1.72801182e-01f, 8.97506997e-03f, -1.56285897e-01f, -1.51689976e-01f, -7.22052902e-02f,
  -1.60752267e-01f, -1.12173885e-01f, 1.64921731e-02f, 8.47156271e-02f, -6.69307485e-02f, -1.47558004e-01f, -2.76571631e-01f, -2.26994187e-01f, -1.35419071e-01f, -1.02293387e-01f,
  1.36239111e-01f, -9.16698202e-02f, -6.15863465e-02f, 2.74496544e-02f, -1.81316733e-01f, -3.70663442e-02f, -9.93734226e-02f, -1.55524775e-01f, -9.61886346e-02f, -1.26118943e-01f,
  9.31170136e-02f, 7.17337728e-02f, 7.02041853e-03f, -6.97797090e-02f, -5.64589864e-04f, 1.53516969e-02f, 6.98736683e-02f, 5.52117378e-02f, 1.05454840e-01f, 1.13771722e-01f,
  -5.04143536e-02f, 4.88934666e-02f, 1.67491332e-01f, 8.48119557e-02f, 1.29889874e-02f, -2.88147368e-02f, 2.04794407e-01f, 6.08544461e-02f, -1.11613899e-01f, -7.28406757e-02f,
  -4.45547178e-02f, -9.50890481e-02f, -6.91348454e-03f, 4.83081974e-02f, 1.12169333e-01f, -7.46646747e-02f, 9.57399607e-03f, 1.08870566e-01f, 1.11150346e-03f, -3.19544896e-02f,
  3.37466478e-01f, -4.44651321e-02f, 1.40949756e-01f, -2.09665149e-02f, -5.03344126e-02f, -6.65371642e-02f, -7.57598132e-02f, 1.18215149e-02f, -1.37821408e-02f, 1.13159709e-01f,
  9.35290083e-02f, 4.29618098e-02f, 1.12593710e-01f, 1.78163603e-01f, 2.55031586e-01f, 3.64208557e-02f, 5.75509034e-02f, 1.11194640e-01f, -3.93430926e-02f, -3.84668005e-03f,
  8.04020539e-02f, 1.58467546e-01f, 1.23227082e-01f, 2.09490672e-01f, 1.08068071e-01f, 9.34617817e-02f, 3.24912399e-01f, 1.29594862e-01f, 2.78927982e-01f, 3.96190166e-01f,
  8.09874237e-01f, 6.77206516e-01f, 9.17008594e-02f, 1.83303475e-01f, -1.87177286e-02f, 1.92334756e-01f, 4.92039889e-01f, 3.16795677e-01f, 1.45581350e-01f, 1.76767528e-01f,
  2.26974398e-01f, 1.33876845e-01f, 1.88183323e-01f, 1.73320279e-01f, 2.31642008e-01f, 1.56327084e-01f, 7.96142295e-02f, -8.13747868e-02f, -5.33162430e-02f, 2.57348716e-02f,
  3.22094262e-02f, 1.21264182e-01f, 2.43778527e-01f, 6.32781982e-02f, 2.60514282e-02f, -7.98121169e-02f, 1.26706615e-01f, -6.72367588e-03f, 1.24510922e-01f, 8.25678259e-02f,
  -4.28675473e-01f, 6.87665045e-02f, -6.36246204e-02f, -1.15569465e-01f, -1.10233709e-01f, 1.02923408e-01f, 6.37982879e-03f, -5.09592053e-03f, -9.94717255e-02f, -6.92099258e-02f,
  -8.99653286e-02f, -1.38832286e-01f, -7.90901557e-02f, -1.41122580e-01f, -1.79208517e-01f, -7.61511177e-02f, -2.26311907e-02f, 1.85416147e-01f, -3.25649418e-02f, 2.51249038e-02f,
  -6.04061633e-02f, -1.68476719e-02f, -1.11018009e-01f, -3.25096748e-03f, 1.38311669e-01f, -1.38360798e-01f, -5.61794415e-02f, 4.08729166e-02f, -4.48845811e-02f, 1.30252630e-01f,
  -5.86818205e-03f, 1.67367890e-01f, -5.40037677e-02f, -5.53285107e-02f, -3.89281996e-02f, -5.50862588e-02f, -4.69820499e-02f, 5.69639318e-02f, 7.28840008e-02f, -2.95961853e-02f,
  4.72086947e-03f, -1.28906950e-01f, -2.92789824e-02f, -1.25721440e-01f, -1.58707529e-01f, -1.19260013e-01f, 3.67591418e-02f, -9.24811661e-02f, -2.44551465e-01f, -1.16677411e-01f,
  -2.96612103e-02f, 1.85590591e-02f, -1.92568734e-01f, -9.26280692e-02f, -1.46165371e-01f, -1.93644851e-01f, -1.91003740e-01f, -6.86420798e-02f, 6.67543188e-02f, 9.68280062e-03f,
  -9.40306112e-02f, -3.53434563e-01f, 5.55168837e-02f, 1.18383266e-01f, -1.80146769e-02f, 5.07357754e-02f, 2.76658647e-02f, -6.73135146e-02f, -1.71327353e-01f, -1.25687972e-01f,
  -7.08667785e-02f, 2.72563566e-02f, 5.79853430e-02f, -2.88195312e-02f, -7.01539144e-02f, -5.92716299e-02f, 8.51318464e-02f, 1.03388600e-01f, 1.80324391e-02f, -9.77225602e-02f,
  1.41589835e-01f, -4.86174747e-02f, -6.45906925e-02f, 5.70485592e-02f, 1.06794916e-01f, -3.44892927e-02f, 4.94927773e-03f, -7.86835030e-02f, -5.77215329e-02f, 4.11587767e-02f,
  9.53732610e-01f, 1.96780324e-01f, -2.71448404e-01f, 2.44218409e-02f, -1.72347739e-01f, -5.71824983e-02f, 3.08393747e-01f, 2.74978161e-01f, -6.23876303e-02f, 1.75057918e-01f,
  3.33008677e-01f, 2.83071011e-01f, 3.72370750e-01f, 1.22458696e-01f, 3.81517291e-01f, -8.43635350e-02f, -2.45057955e-01f, -9.48377997e-02f, 5.32372892e-02f, -8.01937431e-02f,
  -9.17292610e-02f, 3.52391936e-02f, 2.35413775e-01f, -9.93644297e-02f, -2.95852125e-01f, -1.21265352e-01f, -1.91737980e-01f, -1.66593254e-01f, -1.81367591e-01f, -5.96037149e-01f,
  1.48813263e-01f, 4.24567871e-02f, -2.44405657e-01f, -1.43317714e-01f, -1.38189659e-01f, 3.90588045e-02f, 1.97033919e-02f, -1.92286640e-01f, 8.48247930e-02f, 7.47430744e-03f,
  -9.59456265e-02f, -1.33615538e-01f, -9.59535763e-02f, -1.97029337e-02f, -7.98820630e-02f, 6.69033602e-02f, -8.63542110e-02f, -8.12297091e-02f, -2.72922833e-02f, -7.84803852e-02f,
  -1.82431757e-01f, -1.36043668e-01f, 8.16203952e-02f, -9.98982042e-02f, -4.68349308e-02f, 8.77103594e-04f, 2.45278180e-02f, -1.21700808e-01f, 1.35650737e-02f, 3.56522463e-02f,
  -8.66757706e-02f, -7.52196014e-02f, 3.10148187e-02f, 2.75082663e-02f, 1.72356978e-01f, 2.45242566e-02f, -1.80572674e-01f, -5.21365181e-03f, -1.08288579e-01f, -3.68000343e-02f,
  -2.17099160e-01f, 4.55741026e-02f, 2.34179758e-02f, 1.01896875e-01f, 6.86186031e-02f, -3.60195828e-03f, -5.59603460e-02f, 1.22624613e-01f, 5.59118204e-02f, 6.93345964e-02f,
  -6.30721599e-02f, -2.17569679e-01f, -5.30695282e-02f, -4.59803641e-02f, -1.50741026e-01f, 5.13980575e-02f, 6.24455065e-02f, -5.85928932e-02f, -3.12568583e-02f, -1.19139016e-01f,
  1.80771098e-01f, 2.71345735e-01f, 6.51656911e-02f, -8.63921642e-02f, -3.08992952e-01f, -7.41434321e-02f, 1.15350626e-01f, -9.91033390e-02f, -1.17006831e-01f, 8.53938460e-02f,
  3.60944122e-02f, 1.84312940e-01f, 1.63796209e-02f, -1.02724977e-01f, -4.04054411e-02f, -1.66314971e-02f, 3.33017446e-02f, -3.56468186e-02f, -1.27983898e-01f, -1.39851689e-01f,
  -1.44647444e-02f, 1.02956720e-01f, 6.54974356e-02f, 1.21624038e-01f, -7.58195147e-02f, 8.75798147e-03f, 1.38911217e-01f, -1.36500606e-02f, 1.95086464e-01f, 1.70574009e-01f,
  8.86692286e-01f, 3.45159799e-01f, 4.04897213e-01f, 2.06657529e-01f, -7.09875524e-02f, 5.47744893e-02f, 2.29264855e-01f, 1.95610955e-01f, 5.48563991e-03f, 2.22366173e-02f,
  1.33043490e-02f, 2.10025571e-02f, 1.01582162e-01f, 8.12873542e-02f, 2.46943444e-01f, 6.34036865e-03f, 1.15696369e-02f, 2.56604493e-01f, 1.82150096e-01f, -4.10102718e-02f,
  -4.20952253e-02f, -4.48624492e-02f, 1.42878115e-01f, 8.86425078e-02f, -2.10463945e-02f, -1.17692344e-01f, -7.11361831e-03f, 7.25456178e-02f, 4.63431003e-03f, -3.25562544e-02f,
  -2.66140103e-01f, 3.85291904e-01f, -1.47770822e-01f, -4.11334336e-02f, -2.17272025e-02f, -7.26250038e-02f, 2.91257091e-02f, -1.66669283e-02f, -7.24905357e-03f, -8.64397734e-02f,
  -1.25654995e-01f, -5.15702628e-02f, -5.78578077e-02f, 4.19977531e-02f, -3.82616296e-02f, 1.61961094e-02f, -5.58244847e-02f, 1.24172427e-01f, 6.58429712e-02f, 3.57313529e-02f,
  -1.03901856e-01f, 6.21534027e-02f, 5.07364087e-02f, 8.59252959e-02f, 1.77135408e-01f, -3.02072112e-02f, 8.96511227e-02f, 6.33167922e-02f, 1.50739998e-01f, 1.95279002e-01f,
  -3.89383398e-02f, 1.66197062e-01f, 2.04755083e-01f, 1.07510172e-01f, 1.44603834e-01f, 1.85799763e-01f, 6.71121329e-02f, -8.19673296e-03f, 1.72441393e-01f, 1.09719820e-01f,
  -2.01762300e-02f, 2.33457312e-01f, 2.04316348e-01f, 1.49976805e-01f, 1.84878558e-02f, 5.76310838e-03f, -4.95213270e-02f, -1.84458271e-02f, 8.22191760e-02f, -1.07535720e-01f,
  1.13295287e-01f, -9.58157144e-03f, -4.97824326e-02f, 3.53049599e-02f, 3.89349088e-02f, 5.27714826e-02f, 2.12491956e-02f, 1.38993058e-02f, 8.55982155e-02f, -9.45745707e-02f,
  -6.09671295e-01f, 2.20114216e-01f, 3.49256350e-03f, -5.11950590e-02f, -1.08102486e-01f, 2.20793509e-03f, -3.85423042e-02f, -1.29369065e-01f, -1.50266796e-01f, -1.73145965e-01f,
  -5.28066084e-02f, 1.26867905e-01f, 3.11448108e-02f, 3.32408659e-02f, -1.08058602e-01f, -1.67556554e-01f, -1.20127149e-01f, -1.72539114e-03f, -1.10256113e-01f, -1.38978750e-01f,
  -1.15974575e-01f, -7.81826116e-03f, 6.06638659e-03f, -3.25030796e-02f, -1.01743490e-01f, 7.41032371e-03f, -1.20487556e-01f, -6.63790032e-02f, 6.41575232e-02f, -4.48661037e-02f,
  -4.38008994e-01f, 2.96474069e-01f, 1.35296062e-01f, -2.85502285e-01f, -9.73054990e-02f, 3.66426408e-02f, 1.33239940e-01f, 3.01672500e-02f, -5.49758337e-02f, 1.78261936e-01f,
  1.84076041e-01f, -1.22782908e-01f, -6.27719834e-02f, -1.12575486e-01f, -1.68610796e-01f, 3.98561694e-02f, -1.44504011e-01f, -4.03743714e-01f, -4.58206952e-01f, -2.97104657e-01f,
  -1.61785394e-01f, -2.39052802e-01f, -3.84589374e-01f, -3.03020626e-01f, -1.49457976e-01f, -2.83748358e-01f, -1.32353738e-01f, -2.96402901e-01f, -2.57239729e-01f, -1.93682328e-01f,
  2.73958266e-01f, 4.66748187e-03f, -1.40764132e-01f, -1.37222081e-01f, 7.87022263e-02f, -1.04371294e-01f, 2.97529753e-02f, -1.00808106e-02f, 1.15605973e-01f, 8.95461962e-02f,
  5.54022603e-02f, 2.75039393e-02f, 4.72285524e-02f, -9.88342706e-03f, 8.43444169e-02f, 7.44697545e-03f, -1.84728317e-02f, 5.02530448e-02f, -3.92367737e-03f, 1.58919811e-01f,
  -1.63707824e-03f, 3.96413989e-02f, 1.59435302e-01f, -2.80061997e-02f, 1.36005040e-02f, -3.15799341e-02f, 1.78684920e-01f, -5.68306893e-02f, -9.43258181e-02f, 9.42565426e-02f,
  -5.62772937e-02f, 8.58523697e-02f, -5.98409995e-02f, -6.89904466e-02f, 1.25057176e-01f, 1.35164812e-01f, 4.11747247e-02f, 4.13971394e-02f, -7.56133944e-02f, -4.20431234e-02f,
  2.99817733e-02f, 8.30330327e-02f, 4.00302224e-02f, -2.44551934e-02f, -1.02386303e-01f, -1.30556986e-01f, 2.58874963e-03f, 9.01750252e-02f, -2.66892035e-02f, 8.10653262e-04f,
  4.92480863e-03f, -3.70121486e-02f, -7.54791945e-02f, 8.74879956e-02f, -5.59970504e-03f, 4.74988818e-02f, 9.03594047e-02f, 8.69465172e-02f, 3.63073647e-02f, -4.68030348e-02f,
  6.16323166e-02f, -9.02145877e-02f, 1.05290867e-01f, -7.66993165e-02f, 4.26760949e-02f, -4.34778724e-03f, -9.06210989e-02f, -4.57347780e-02f, 1.15115426e-01f, 4.49559540e-02f,
  3.66962701e-02f, -1.08659053e-02f, 7.66014308e-02f, -3.07146013e-02f, -1.94681063e-02f, -3.56931761e-02f, 3.53560410e-02f, 6.50148094e-02f, 6.48891181e-02f, 2.06705317e-01f,
  1.87176824e-01f, -6.52813166e-02f, -6.65595904e-02f, 2.18721274e-02f, 2.41775047e-02f, -1.45896420e-01f, 9.94001031e-02f, -2.94420868e-03f, -1.10540070e-01f, 6.29530400e-02f,
  -3.90286833e-01f, 1.42201483e-01f, 1.48092353e-04f, -5.34849107e-01f, -5.08049829e-03f, 7.66338632e-02f, -5.51016219e-02f, -3.18056107e-01f, -1.30425006e-01f, 1.43755898e-01f,
  2.70099252e-01f, -1.02043641e-03f, -1.56243533e-01f, -1.72089353e-01f, -3.51591736e-01f, -4.57175225e-02f, -1.79459557e-01f, -3.53212237e-01f, -4.32836741e-01f, -1.19603992e-01f,
  -2.41871886e-02f, -2.57652760e-01f, -2.98815042e-01f, -1.41781524e-01f, 4.17602547e-02f, -4.03108820e-02f, 5.33874445e-02f, 3.84126743e-03f, 2.69856691e-01f, 1.73532426e-01f,
  1.51133001e-01f, -5.91335706e-02f, 8.44574068e-03f, -8.36633742e-02f, 6.61615357e-02f, 1.83213592e-01f, -5.40641062e-02f, -1.51413172e-01f, -2.29179692e-02f, -1.19907685e-01f,
  -4.34866436e-02f, 1.24021679e-01f, -1.08195931e-01f, 6.97503760e-02f, -1.90464050e-01f, -7.52771050e-02f, -2.06934094e-01f, -1.91375792e-01f, -4.89951018e-03f, 1.33291945e-01f,
  1.75769821e-01f, 6.65535852e-02f, -2.20086604e-01f, 1.65547393e-02f, 3.36262919e-02f, -1.14737190e-01f, 1.02706380e-01f, 1.73739329e-01f, 8.71982276e-02f, 6.42739087e-02f,
  3.72462310e-02f, 7.74942413e-02f, 9.45335254e-02f, 2.10691220e-03f, -1.55539485e-02f, 1.66204840e-01f, -2.84122154e-02f, -5.50951026e-02f, 2.04267614e-02f, -1.82318427e-02f,
  -3.60914096e-02f, 1.77046791e-01f, -1.17845520e-01f, 3.91467800e-03f, 1.10344058e-02f, -1.51082620e-01f, 1.34396285e-01f, 1.11596592e-01f, 7.87393674e-02f, 6.49551004e-02f,
  3.11833434e-02f, -1.34339649e-02f, 1.52701291e-03f, -1.31188005e-01f, 3.73723775e-01f, 9.63272005e-02f, 2.47917041e-01f, 1.20636806e-01f, -6.43980727e-02f, 6.36912733e-02f,
  -3.42805386e-01f, 6.70432299e-02f, -2.39291601e-02f, -1.53832853e-01f, -7.75958374e-02f, 3.09035480e-01f, 1.00668766e-01f, 3.37987840e-02f, -2.18005702e-02f, -1.13633536e-01f,
  3.41505446e-02f, -1.11981900e-02f, -1.40325844e-01f, 3.52059081e-02f, -1.79360211e-01f, 7.14841709e-02f, -3.05058397e-02f, -2.54628938e-02f, 1.12306461e-01f, 8.66613910e-02f,
  -8.00880194e-02f, -1.18220411e-01f, -3.54883105e-01f, -2.08331883e-01f, -9.71898213e-02f, -1.62575036e-01f, -2.93193348e-02f, 3.99614871e-02f, -5.65734096e-02f, -1.09196715e-01f,
  6.27335310e-01f, -5.15299559e-01f, 4.06802803e-01f, 1.15917005e-01f, 3.83936465e-01f, 3.08783829e-01f, 1.55313820e-01f, 6.51391372e-02f, 1.99816525e-01f, 9.56680104e-02f,
  -1.44191355e-01f, -4.93158698e-02f, 3.74022126e-02f, -6.22041896e-02f, -5.93861267e-02f, 2.37543648e-03f, 2.06452221e-01f, 4.34665650e-01f, 4.02828485e-01f, 9.22966227e-02f,
  -8.43248591e-02f, 2.01362148e-02f, 1.84610173e-01f, 5.59142530e-02f, 1.30992560e-02f, 3.72629166e-02f, 6.10418804e-02f, -9.11568701e-02f, 9.29300487e-03f, -8.52928311e-02f,
  6.09282032e-02f, -1.43745542e-01f, 1.80571601e-01f, -1.77218273e-01f, -2.98912395e-02f, -5.70390280e-03f, 1.18184179e-01f, -4.12773862e-02f, -1.71852887e-01f, -8.28106180e-02f,
  -3.41280513e-02f, -5.12180552e-02f, -5.39783798e-02f, 2.61247363e-02f, -3.98261249e-02f, 5.58391586e-02f, 5.59512861e-02f, -2.97473986e-02f, -3.84489708e-02f, -1.31846160e-01f,
  -8.81855115e-02f, 4.49170545e-02f, 1.38666704e-01f, -2.97361854e-02f, -1.05453301e-02f, 1.66171134e-01f, 8.36337432e-02f, 6.08637854e-02f, 9.80437994e-02f, 8.49133078e-03f,
  2.29634494e-01f, 2.80714512e-01f, 1.81644022e-01f, 1.63223386e-01f, 1.39521241e-01f, 1.32070482e-01f, 3.53379399e-02f, -1.44979702e-02f, 2.32336402e-01f, 1.49215728e-01f,
  1.05796559e-02f, 7.37558678e-02f, 5.61178662e-02f, 5.46247289e-02f, 1.36926487e-01f, 8.81630853e-02f, 9.91842002e-02f, -1.02408744e-01f, 1.09584332e-01f, 5.34633361e-02f,
  1.24597080e-01f, -2.94868127e-02f, 1.92729160e-01f, -5.33945374e-02f, -6.47757649e-02f, 2.12120280e-01f, 1.79353818e-01f, 7.29296431e-02f, 1.27287969e-01f, 1.13812871e-01f,
  -3.68181527e-01f, 2.23303869e-01f, 1.47628620e-01f, -5.89881390e-02f, -4.07415256e-02f, 8.99669714e-03f, -5.37038594e-02f, -2.53535569e-01f, -2.01528296e-01f, -5.27292825e-02f,
  -9.66910645e-02f, 4.56452742e-02f, 5.75709082e-02f, 1.04698151e-01f, 1.68151036e-01f, 1.33137286e-01f, 8.54883622e-03f, -4.73057292e-02f, -1.16114788e-01f, -1.10296756e-01f,
  -3.37263420e-02f, 9.81394649e-02f, 1.53715089e-01f, 1.79337412e-01f, 2.62989663e-02f, 2.81939715e-01f, 7.53442124e-02f, 4.79864068e-02f, 1.59348562e-01f, 2.07209095e-01f,
  2.80616939e-01f, 3.83728705e-02f, -6.08324111e-01f, -3.30105484e-01f, -4.49210495e-01f, -3.03520977e-01f, 2.02928837e-02f, 2.74838991e-02f, -2.18175307e-01f, -2.25958139e-01f,
  -6.87221587e-02f, 1.54841840e-01f, -1.02634117e-01f, -8.88789445e-02f, 1.48394555e-01f, -2.84592927e-01f, -3.87206316e-01f, -3.05354416e-01f, -6.79823905e-02f, 5.76395132e-02f,
  3.45411040e-02f, -8.93839747e-02f, 2.99568716e-02f, -3.58568206e-02f, -3.26128781e-01f, -1.81281626e-01f, -4.22709644e-01f, -2.84480631e-01f, -1.86898574e-01f, -4.74833667e-01f,
  -4.75639611e-01f, -3.09803843e-01f, 2.39928421e-02f, 1.25668183e-01f, -1.02542974e-01f, 4.46010716e-02f, 6.87020123e-02f, 5.59141710e-02f, 1.53087139e-01f, -1.12587802e-01f,
  -7.55646527e-02f, 4.26033065e-02f, -3.50867361e-02f, -1.01315409e-01f, -1.67584226e-01f, -1.11516118e-01f, -7.91596025e-02f, -1.25111341e-01f, 1.70467962e-02f, -7.78625309e-02f,
  -6.94565549e-02f, -1.97679363e-02f, 6.43463247e-03f, -1.36710387e-02f, -1.72365069e-01f, -1.44175902e-01f, -1.05495036e-01f, -1.15620926e-01f, -1.65692374e-01f, -1.04463436e-01f,
  -2.65505519e-02f, 1.31053150e-01f, 6.39833510e-02f, 8.99687037e-02f, 2.47298107e-01f, 7.19833001e-02f, 5.62139787e-02f, 1.67831242e-01f, 1.30580097e-01f, 5.55063710e-02f,
  -4.83987629e-02f, -1.80801004e-02f, 5.02237752e-02f, 4.14049290e-02f, -7.46850073e-02f, -2.36432534e-02f, 6.49710149e-02f, 4.13136557e-02f, 5.07893376e-02f, 7.53026679e-02f,
  1.99550390e-02f, 1.36126950e-01f, -5.51579297e-02f, 1.50724173e-01f, -7.29347840e-02f, -2.57669054e-02f, -5.31383343e-02f, 5.63063733e-02f, -3.74929756e-02f, -3.07984818e-02f,
  1.08703282e-02f, -3.36888880e-02f, 8.65192562e-02f, 7.44073391e-02f, -4.49754931e-02f, -3.83138917e-02f, -1.10781759e-01f, 2.91170031e-02f, -8.10598657e-02f, -1.71486642e-02f,
  -3.18962932e-02f, 1.34244531e-01f, -1.95421968e-02f, 9.17686820e-02f, 6.76822439e-02f, -2.08553374e-02f, 1.09316528e-01f, -1.84877533e-02f, -1.43906036e-02f, 1.19223855e-02f,
  2.21967250e-02f, 2.00712398e-01f, 2.48319879e-01f, 1.62433431e-01f, 9.50334296e-02f, 1.05537936e-01f, 9.01384726e-02f, 4.83296961e-02f, 6.57425001e-02f, 2.65832722e-01f,
  -1.02387868e-01f, -4.37492818e-01f, -3.80326688e-01f, -4.31367457e-01f, -3.47600311e-01f, -2.59101599e-01f, -3.93332452e-01f, -4.93007079e-02f, -3.59262615e-01f, -4.99018073e-01f,
  -3.33945788e-02f, 5.15843689e-01f, 2.97940195e-01f, 4.81936276e-01f, 4.71742958e-01f, -4.89701331e-01f, -3.78521830e-01f, 2.52459854e-01f, 6.96947277e-01f, 2.37069771e-01f,
  -5.51351830e-02f, -4.78701107e-02f, 1.85322955e-01f, 7.42830932e-02f, -5.91665566e-01f, 3.49897109e-02f, -5.23111403e-01f, -3.51049900e-01f, -1.50273651e-01f, -6.54417992e-01f,
  1.28567442e-01f, -4.16552097e-01f, 1.27860337e-01f, 5.26861697e-02f, -8.36321861e-02f, 5.28417043e-02f, 2.03843247e-02f, -1.87739819e-01f, -1.10091977e-01f, -2.55467564e-01f,
  -1.35625392e-01f, 3.01652849e-02f, 2.05178391e-02f, -9.18679833e-02f, -9.47836041e-02f, -2.97362637e-02f, -3.80008444e-02f, 1.17962338e-01f, -3.40197459e-02f, -6.56262711e-02f,
  -7.09626377e-02f, -2.07447827e-01f, -6.58846647e-02f, -5.88130280e-02f, -4.78670176e-04f, 1.89489722e-01f, -1.46916658e-01f, -5.76482937e-02f, 5.06861089e-03f, -3.87414962e-01f,
  4.57965722e-03f, -9.88646597e-02f, 2.15681978e-02f, 6.59562647e-02f, -1.35077313e-02f, -2.63139289e-02f, 4.27021496e-02f, 9.84909013e-03f, -4.40202132e-02f, 5.98407611e-02f,
  6.11422807e-02f, -4.74084765e-02f, 3.78724225e-02f, -9.61971283e-02f, -1.73052885e-02f, -1.01175174e-01f, -2.95846052e-02f, 4.80895378e-02f, 2.65466422e-02f, -2.22718436e-02f,
  3.37426774e-02f, 9.91477515e-04f, -7.71544054e-02f, 7.17474148e-02f, -1.47059634e-02f, 7.27878362e-02f, -3.85392979e-02f, 1.74818173e-01f, 1.36431292e-01f, -1.85883060e-01f,
  3.90467286e-01f, 2.72531003e-01f, -1.75497338e-01f, 1.85112104e-01f, -2.35406965e-01f, -5.62986024e-02f, -2.54534353e-02f, -9.40388534e-03f, -7.14527816e-02f, 1.03018269e-01f,
  6.82636648e-02f, 1.24250658e-01f, -1.33388281e-01f, -1.03452414e-01f, 2.32678764e-02f, -5.20847216e-02f, -5.49034739e-04f, 6.54857606e-02f, -2.77399495e-02f, -6.32506236e-02f,
  -1.98085219e-01f, -4.39093895e-02f, 2.18841478e-01f, 4.56380621e-02f, -1.70520738e-01f, 2.86430657e-01f, 6.08097315e-02f, 1.06576987e-01f, 2.79001236e-01f, -1.53111726e-01f,
  1.40049681e-01f, -4.47984874e-01f, 1.09944576e-02f, 3.07419121e-01f, 1.20776802e-01f, 1.03534564e-01f, -1.81044847e-01f, 1.38156772e-01f, 2.79033929e-01f, 9.84456018e-02f,
  -3.38850841e-02f, 2.09151819e-01f, 2.19303161e-01f, 2.65144557e-01f, 2.42412135e-01f, 1.71959117e-01f, 2.35465407e-01f, 3.32094997e-01f, 1.85516492e-01f, 1.08170666e-01f,
  1.73383012e-01f, 3.20981592e-02f, 9.19921249e-02f, 1.10615551e-01f, -1.47254482e-01f, 2.68279970e-01f, -1.63842589e-02f, -1.16358548e-01f, -1.22334629e-01f, -1.43384598e-02f,
  -3.69497657e-01f, -1.26173988e-01f, 2.62946188e-01f, 1.32854894e-01f, -1.99835226e-01f, -6.40349165e-02f, 8.96133110e-02f, -1.24870300e-01f, -1.69450626e-01f, -8.49102587e-02f,
  -1.17602320e-02f, -1.55241147e-01f, -2.84446240e-03f, -7.00798780e-02f, -5.29808328e-02f, -5.83741851e-02f, -5.88887818e-02f, -1.53766349e-02f, 5.70661314e-02f, -1.84750274e-01f,
  -2.33612098e-02f, -1.57314464e-01f, -9.30594951e-02f, 7.46723488e-02f, -2.20588986e-02f, -1.75917856e-02f, -9.11392123e-02f, -7.77798519e-02f, -4.10466269e-02f, -1.75846200e-02f,
  6.90966100e-02f, 6.89000189e-02f, 4.10325788e-02f, 5.06605878e-02f, 1.11538559e-01f, 4.66473354e-03f, -3.26429047e-02f, -3.81383523e-02f, 1.11796826e-01f, -3.02814096e-02f,
  6.14056326e-02f, 1.96958780e-01f, -1.57143921e-03f, 2.02250052e-02f, 1.07939363e-01f, -6.20932020e-02f, -7.46328607e-02f, 2.50907727e-02f, -1.86620131e-02f, -2.64097042e-02f,
  1.06695257e-02f, 1.93929095e-02f, -1.13997042e-01f, -1.04334079e-01f, -3.33762988e-02f, 1.40068933e-01f, 8.53480697e-02f, 6.54343218e-02f, 1.12196699e-01f, 3.93278990e-03f,
  -1.20109767e-01f, 3.45618010e-01f, 1.83211528e-02f, -1.44108966e-01f, -1.72324270e-01f, -1.31097943e-01f, 1.41443864e-01f, -1.20697349e-01f, -1.72493085e-01f, 5.63451741e-03f,
  -1.28710344e-01f, -1.24274299e-01f, -9.86959338e-02f, -9.73920673e-02f, 3.38659855e-03f, -7.07306787e-02f, -1.50262147e-01f, -3.19830328e-02f, -1.09054931e-01f, -9.29461345e-02f,
  -8.32039043e-02f, 7.75273666e-02f, 1.13174371e-01f, 1.95715308e-01f, 1.68608472e-01f, 1.84776694e-01f, 6.06355444e-02f, -2.45435983e-02f, 2.25368664e-02f, 1.97355673e-01f,
  4.82920378e-01f, 1.63495436e-01f, 1.63396765e-02f, 1.82631075e-01f, -8.69482607e-02f, -3.17042172e-01f, -3.66500795e-01f, -1.58569977e-01f, 1.64323732e-01f, 2.34832555e-01f,
  8.52344111e-02f, 3.71766299e-01f, 2.37268567e-01f, 2.70707250e-01f, 1.18813239e-01f, 1.57456592e-01f, 2.12136641e-01f, 3.35410476e-01f, 9.71255824e-02f, 7.54246414e-02f,
  1.24922082e-01f, 4.28786241e-02f, 1.45064905e-01f, 1.13372862e-01f, 4.11855191e-01f, 2.60551214e-01f, 5.30933402e-02f, 7.03620985e-02f, 2.49942228e-01f, 5.81661463e-01f,
  2.93304890e-01f, 4.54710126e-02f, -4.78105173e-02f, 1.98144056e-02f, -1.64552368e-02f, 2.46647224e-02f, -5.01602795e-03f, -6.51325285e-02f, -5.33182546e-03f, 1.12383114e-02f,
  5.89321516e-02f, -1.14776148e-02f, -8.93695354e-02f, -4.22205403e-02f, -1.83236569e-01f, -5.62394932e-02f, 1.12498179e-01f, 8.02760571e-02f, -4.75492701e-03f, 2.22904623e-01f,
  8.00340101e-02f, -6.49925992e-02f, -2.11259678e-01f, -2.70863533e-01f, -1.61828492e-02f, 4.04569246e-02f, 1.23146456e-02f, 2.03295439e-01f, -1.72469974e-01f, 2.06089124e-01f,
  1.79467037e-01f, 1.14302777e-01f, 2.37603515e-01f, 3.12909603e-01f, 1.96780771e-01f, 9.15605426e-02f, 3.60814855e-02f, -6.52896836e-02f, 2.19313558e-02f, -6.87066093e-02f,
  8.87492299e-02f, 3.87131236e-02f, -5.83588630e-02f, 2.48227473e-02f, 2.73733765e-01f, 1.32328033e-01f, 3.89579050e-02f, -5.07127903e-02f, 5.65591408e-03f, -1.92198921e-02f,
  1.17714956e-01f, 2.87798475e-02f, -1.98319294e-02f, -5.99303916e-02f, -4.75159995e-02f, 1.21276174e-02f, 7.39623234e-02f, -1.04002424e-01f, 5.47706941e-03f, -5.14504015e-02f,
  -5.53151965e-01f, -4.38894063e-01f, 2.64745235e-01f, 6.04443140e-02f, -6.23159707e-02f, -2.08035931e-02f, 7.42792105e-03f, -1.44899935e-01f, -1.03200804e-02f, -1.54424235e-01f,
  -2.03951344e-01f, -6.68756738e-02f, -1.51405185e-01f, -1.80892661e-01f, -1.83414519e-01f, -4.43546064e-02f, -5.91295026e-02f, 8.23074207e-02f, -1.35798499e-01f, 1.01791779e-02f,
  -1.62659779e-01f, -3.07214588e-01f, -2.86206782e-01f, -2.01352075e-01f, -1.42181858e-01f, -1.31248623e-01f, -1.41696796e-01f, -2.39048973e-01f, -2.97187388e-01f, -3.26606274e-01f,
  -8.43954086e-01f, -2.69042462e-01f, 3.62607986e-01f, -4.08665329e-01f, -1.91145539e-02f, -1.15665945e-03f, 1.45599097e-01f, -2.44642287e-01f, -2.54824668e-01f, -3.41005698e-02f,
  2.84887869e-02f, 1.08189091e-01f, 1.70269161e-01f, 1.73936531e-01f, -4.01005428e-03f, 2.74437129e-01f, 1.78757578e-01f, 4.64860089e-02f, 1.61502779e-01f, 5.60645536e-02f,
  -4.11837026e-02f, -2.49225855e-01f, -4.05828387e-01f, -2.57917285e-01f, -1.08992904e-01f, 8.75880495e-02f, -3.59434783e-02f, -1.98800042e-01f, 2.72164308e-02f, 4.51329723e-02f,
  4.14362848e-01f, -1.88559666e-01f, 3.32136415e-02f, -2.45226339e-01f, -1.63299337e-01f, -1.49934337e-01f, -7.86997080e-02f, -1.41085237e-01f, -2.11734906e-01f, -2.06770480e-01f,
  -1.87234133e-01f, -1.34650350e-01f, -5.47777973e-02f, 9.18949780e-04f, -1.59307182e-01f, 3.83699359e-03f, -7.80762061e-02f, -1.33138299e-01f, -8.32189918e-02f, 8.29008147e-02f,
  6.85247630e-02f, -1.94086637e-02f, -6.42503649e-02f, -1.39096156e-02f, -5.06916046e-02f, 4.67116833e-02f, 5.73629886e-03f, -7.75513723e-02f, -1.14745043e-01f, -1.56316221e-01f,
  -4.27659862e-02f, -1.72809348e-01f, -1.14747435e-01f, 5.98477833e-02f, 7.89115727e-02f, 4.04525502e-03f, 7.15409294e-02f, 3.31344903e-02f, -1.28236741e-01f, -1.11465640e-02f,
  -2.93098334e-02f, 1.45315662e-01f, -3.95861194e-02f, -1.25681505e-01f, -9.25848559e-02f, -3.54016684e-02f, -1.71830460e-01f, -4.01420780e-02f, -9.17546749e-02f, -1.04855277e-01f,
  1.02211423e-02f, -3.10555361e-02f, -1.35792956e-01f, -7.34136030e-02f, -1.08115889e-01f, -5.06502204e-02f, -6.62281141e-02f, -7.32648447e-02f, -6.22771494e-02f, -1.62842169e-01f,
  1.91559464e-01f, 1.00151494e-01f, 2.59983450e-01f, 6.39646277e-02f, -3.83512601e-02f, -3.17826122e-02f, 1.27637357e-01f, 7.30217174e-02f, -5.61108161e-03f, 8.64571780e-02f,
  7.42029324e-02f, 3.33800279e-02f, 8.64390284e-02f, -3.65212224e-02f, -6.82295347e-03f, -6.00376353e-03f, -1.09561585e-01f, -3.02878325e-03f, 1.17618434e-01f, 8.90073851e-02f,
  -1.28417790e-01f, -1.90334748e-02f, 2.21258223e-01f, 1.39263943e-01f, 4.91539277e-02f, 1.44838676e-01f, 2.18178496e-01f, 9.18570384e-02f, 1.98998928e-01f, 1.37887985e-01f,
  -1.64016008e-01f, 3.74636173e-01f, 3.36661130e-01f, -2.08535522e-01f, 5.32518744e-01f, 2.43987665e-01f, 3.82626057e-02f, -2.17254579e-01f, -5.60072623e-02f, 7.23588318e-02f,
  4.44841027e-01f, 7.67787546e-02f, -8.41210037e-02f, -2.61862844e-01f, -7.48811781e-01f, -5.50265014e-01f, -5.88475883e-01f, -6.21704698e-01f, -4.92712379e-01f, -6.06119372e-02f,
  5.58143593e-02f, -1.47599742e-01f, -3.64603996e-01f, -4.09317940e-01f, 4.07188945e-02f, -1.46941453e-01f, 6.17807433e-02f, 1.13187097e-01f, 5.55608161e-02f, -9.20214951e-02f,
  1.19812042e-02f, 2.52650023e-01f, -2.02565379e-02f, 7.68868811e-03f, 1.53466091e-01f, -1.69994414e-01f, -1.09905742e-01f, -3.93672436e-02f, 1.79451667e-02f, -1.08534142e-01f,
  2.25821212e-01f, 7.75455907e-02f, 1.06459118e-01f, -5.24175055e-02f, -1.25421703e-01f, -1.27207235e-01f, -1.29895315e-01f, -2.69593149e-01f, -3.19386363e-01f, 2.51593534e-02f,
  5.32823578e-02f, 1.82860374e-01f, -2.96164788e-02f, -1.36438742e-01f, -2.91661233e-01f, -1.72803521e-01f, 4.94914688e-02f, -7.49801397e-02f, -2.94718802e-01f, -2.61752248e-01f,
  -1.51949942e-01f, -4.91831265e-02f, 8.59900266e-02f, 1.10331580e-01f, -8.04263577e-02f, -3.56409736e-02f, -6.18700273e-02f, -1.52768776e-01f, 1.66662782e-02f, -1.73266828e-02f,
  -1.27511984e-02f, 4.55689803e-02f, 6.66568130e-02f, -5.37669957e-02f, -1.56951338e-01f, 3.21183912e-02f, -4.31875177e-02f, -1.85001835e-01f, -8.89469609e-02f, -5.78998774e-02f,
  -7.62894973e-02f, -4.88341041e-02f, 8.35739449e-02f, -1.62473053e-01f, 9.12712608e-03f, -1.06636070e-01f, 9.84655321e-03f, 8.32821354e-02f, 8.11630487e-02f, 7.40895793e-02f,
  -1.30887255e-01f, 1.29771205e-02f, -2.09126383e-01f, -2.06537515e-01f, -1.04618464e-02f, -1.26501337e-01f, 4.83404137e-02f, -2.30702180e-02f, 2.05889255e-01f, -6.32689595e-02f,
  1.20951839e-01f, -1.22483052e-01f, 3.44922729e-02f, -4.66728732e-02f, -7.24909753e-02f, 3.99287976e-02f, -2.56622732e-01f, 1.17111810e-01f, -1.32753566e-01f, 1.11429840e-01f,
  -1.83816880e-01f, -4.27347004e-01f, -3.98611188e-01f, -2.98146814e-01f, -2.58028299e-01f, -3.44445974e-01f, -3.31083030e-01f, -2.18721464e-01f, -4.67665404e-01f, -6.14741266e-01f,
  5.42019188e-01f, -1.85882702e-01f, -8.43069911e-01f, 3.63532931e-01f, 1.57730747e-02f, -3.86489868e-01f, -5.33803642e-01f, -2.76232839e-01f, 4.05457526e-01f, 3.27867791e-02f,
  1.42396644e-01f, 3.19670528e-01f, -9.52119008e-02f, -2.57599324e-01f, -5.75686634e-01f, -4.76959109e-01f, -5.44188082e-01f, -5.45309246e-01f, -2.87485600e-01f, 2.36196488e-01f,
  3.39564443e-01f, 3.94845754e-01f, 2.50999510e-01f, 5.71896993e-02f, 3.35738063e-01f, 9.41010341e-02f, -1.70257047e-01f, 8.86662230e-02f, -2.14334652e-01f, -4.91691865e-02f,
  -9.68864858e-02f, -8.60328600e-02f, -3.10932159e-01f, 2.49181882e-01f, -2.53690798e-02f, 5.35847805e-02f, -3.69568653e-02f, -1.56766832e-01f, -5.50216204e-03f, 7.86794990e-04f,
  8.57876986e-02f, 1.99466437e-01f, 1.09484851e-01f, 6.94921464e-02f, 2.82277524e-01f, -2.61678714e-02f, -1.41692251e-01f, -3.37367058e-01f, -3.92693520e-01f, -9.05252695e-02f,
  8.03228170e-02f, -5.05696647e-02f, -3.88730377e-01f, -2.33822301e-01f, -2.87740648e-01f, -1.52617812e-01f, -2.48247549e-01f, -6.24948628e-02f, -4.69359994e-01f, 2.50642393e-02f,
  1.98983811e-02f, -2.70882919e-02f, 1.37174595e-02f, 1.13535397e-01f, 1.97591797e-01f, -3.28925289e-02f, -2.45091673e-02f, 1.40325967e-02f, 1.12895608e-01f, 6.94060773e-02f,
  -6.95267245e-02f, -1.69654369e-01f, -6.63586035e-02f, 1.26308557e-02f, -5.05435131e-02f, -1.45901620e-01f, -8.51698741e-02f, -1.64155275e-01f, -1.66629165e-01f, 3.16162920e-03f,
  -4.04462181e-02f, -3.79390828e-02f, 8.40292647e-02f, 7.46545568e-03f, -1.85204044e-01f, -2.24358425e-01f, 9.49860066e-02f, -8.01406428e-02f, -7.41408691e-02f, 4.80709597e-02f,
  6.52404070e-01f, -4.14766997e-01f, 1.00311458e-01f, -1.91440016e-01f, -1.45192435e-02f, 1.11929290e-01f, 1.38039961e-01f, -1.41204253e-01f, 3.99593934e-02f, 9.64457393e-02f,
  -5.41208684e-02f, -2.63058450e-02f, 1.51596621e-01f, 1.20184034e-01f, 4.35231254e-02f, 9.97647736e-03f, -1.12424619e-01f, -1.76688731e-01f, -1.18014947e-01f, 2.65270114e-01f,
  8.54938924e-02f, -1.11098126e-01f, -6.75404072e-02f, -2.65385807e-01f, 1.41020179e-01f, -6.73225224e-02f, -1.21161841e-01f, 2.48581581e-02f, -4.34368759e-01f, -3.50262201e-03f,
  -4.11444485e-01f, 2.19047046e-03f, 3.22182268e-01f, -5.90191007e-01f, 1.67416215e-01f, 3.54109675e-01f, 3.55015814e-01f, 7.67278895e-02f, -2.00669259e-01f, -2.57008802e-02f,
  5.21740429e-02f, -3.72492313e-01f, -4.38185513e-01f, -3.29242259e-01f, -6.46184906e-02f, -4.37059067e-02f, -1.94197878e-01f, -7.31352493e-02f, 1.24439083e-01f, 3.02563787e-01f,
  9.97097138e-03f, -1.18252307e-01f, -9.82542336e-02f, -2.12849155e-01f, -4.12333995e-01f, -3.98625046e-01f, -1.05513893e-01f, -8.02761838e-02f, 1.70530379e-01f, -5.47068357e-01f,
  -2.80838966e-01f, 1.03818074e-01f, 2.27810264e-01f, -2.54069984e-01f, -4.37711142e-02f, -3.99224414e-03f, -7.27792010e-02f, -1.49565712e-01f, -9.43160653e-02f, 3.01799625e-02f,
  -1.66308343e-01f, -1.13993719e-01f, -2.33104438e-01f, -7.01322779e-02f, -4.62624878e-02f, -9.40307006e-02f, 3.76889184e-02f, 7.15196580e-02f, 9.45776477e-02f, 1.90436721e-01f,
  -4.13541868e-02f, 7.79243261e-02f, 2.19204482e-02f, 1.39054358e-01f, 1.13948062e-01f, -7.03740716e-02f, 7.97876194e-02f, 1.43135667e-01f, 1.99512124e-01f, -3.26644540e-01f,
  -2.18086824e-01f, -6.12102263e-02f, 2.17785276e-02f, 2.79567316e-02f, -8.55926424e-03f, -2.36467328e-02f, -1.77909419e-01f, 3.41593064e-02f, 3.20586227e-02f, -1.73134863e-01f,
  1.28991120e-02f, 2.30709672e-01f, 6.50955662e-02f, -1.04490764e-01f, -1.31655768e-01f, 6.93996763e-03f, 8.69225115e-02f, 9.29041207e-03f, 1.14866897e-01f, 4.01471462e-03f,
  -3.68521549e-02f, 5.33227287e-02f, 1.02967909e-02f, -1.38445273e-02f, 1.52603433e-01f, 3.88616347e-04f, 5.70544153e-02f, 1.47478625e-01f, -1.45361304e-01f, 4.96718250e-02f,
  -5.65902531e-01f, 5.18384397e-01f, -2.81940013e-01f, -1.04235955e-01f, -4.46857587e-02f, 1.16689913e-01f, 9.16541275e-03f, 1.58522516e-01f, -6.58207983e-02f, 1.03450976e-01f,
  5.08773252e-02f, -1.48315489e-01f, -3.51335965e-02f, 1.19208388e-01f, 1.28014624e-01f, -1.08288467e-01f, 2.30763983e-02f, -1.05737232e-01f, 9.68548954e-02f, 7.76682198e-02f,
  7.71473274e-02f, 1.45423308e-01f, -1.69836700e-01f, -7.77247399e-02f, 1.46428108e-01f, -1.46095246e-01f, -1.38103038e-01f, -8.59105885e-02f, 5.03823012e-02f, -4.40080434e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 52)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 52;
const float L0_fan_Bp_bar_data[] = {
  5.51377594e-01f, 1.83696002e-01f, 4.70583886e-01f, 4.91805345e-01f, 2.82635540e-01f, 2.45265096e-01f, 3.97597313e-01f, 7.54433632e-01f, 7.22921550e-01f, 2.82632977e-01f,
  3.72781366e-01f, 4.59019154e-01f, 3.79584104e-01f, 1.25214294e-01f, 3.45029354e-01f, 1.21921897e-02f, -3.55826095e-02f, 5.15098035e-01f, 3.43027413e-01f, 4.85345036e-01f,
  4.90732342e-01f, 2.66980976e-01f, 1.28765583e-01f, 5.77690721e-01f, 4.36013401e-01f, 4.94745076e-01f, 2.27783605e-01f, 7.03776240e-01f, 5.45828998e-01f, 3.96690398e-01f,
  4.10666168e-01f, 3.09203982e-01f, 6.80301368e-01f, 4.71425980e-01f, -5.40359728e-02f, 3.41330945e-01f, 8.38359356e-01f, 6.29695773e-01f, 1.92223698e-01f, 7.55147517e-01f,
  4.53749835e-01f, 4.65269059e-01f, 3.45010579e-01f, 4.35853630e-01f, 1.62629157e-01f, 4.56985176e-01f, 4.29815620e-01f, 3.28561634e-01f, 5.40972233e-01f, 3.38252962e-01f,
  4.60874647e-01f, 6.37577474e-01f
};

// L1_linear_W (Shape: 12 x 64)
const int L1_linear_W_rows = 12;
const int L1_linear_W_cols = 64;
const float L1_linear_W_data[] = {
  -3.08408171e-01f, -1.99539080e-01f, -3.31234783e-01f, -1.41508088e-01f, -4.11744118e-01f, -1.45913944e-01f, -8.72499645e-02f, -9.28691626e-02f, 1.23938501e-01f, 2.58771181e-01f,
  3.50841023e-02f, 2.04309151e-01f, -7.23924115e-02f, 1.64879009e-01f, -2.11982578e-02f, 3.94189656e-01f, -5.92558920e-01f, -2.84348696e-01f, -5.02775490e-01f, -2.40942180e-01f,
  -2.44135875e-02f, 3.73074204e-01f, 4.31729823e-01f, -4.72474635e-01f, -8.65398794e-02f, 1.44806609e-01f, 3.68378982e-02f, 1.03894398e-01f, 1.22736990e-01f, -4.38170224e-01f,
  -7.31820464e-01f, -3.99539709e-01f, 3.53126585e-01f, 2.89670199e-01f, -3.70764524e-01f, -4.52576041e-01f, 5.37563376e-02f, -2.16292769e-01f, 6.74388528e-01f, -8.63022327e-01f,
  -3.72442633e-01f, 3.04106534e-01f, -2.24520057e-01f, -3.75290751e-01f, -5.62003076e-01f, -5.87948799e-01f, 3.41677845e-01f, 6.68768063e-02f, -1.99563995e-01f, -4.38908994e-01f,
  -1.13912329e-01f, -9.51963812e-02f, -5.48848175e-02f, -3.62480506e-02f, -5.76832071e-02f, -3.92478943e-01f, 1.98534146e-01f, 5.08675516e-01f, -1.46157950e-01f, -2.16842070e-01f,
  -6.88185394e-01f, 9.65638608e-02f, 5.16172886e-01f, 2.30822951e-01f, 2.67040461e-01f, 1.76712990e-01f, -1.09451422e-02f, -9.76895541e-02f, -1.17726535e-01f, 2.90492531e-02f,
  1.94125608e-01f, 2.91706830e-01f, -2.89060503e-01f, 1.48272052e-01f, -2.74472266e-01f, 2.39081457e-01f, -2.99341194e-02f, 1.75251663e-01f, -1.02299012e-01f, 4.04965617e-02f,
  3.46995056e-01f, 1.15062609e-01f, -1.73842102e-01f, 3.58116291e-02f, -1.02984619e+00f, 5.74767351e-01f, 1.02737236e+00f, -1.35420496e-02f, 3.72459501e-01f, -2.79929399e-01f,
  3.29244375e-01f, 6.76748063e-03f, -1.33144304e-01f, -2.75411308e-01f, -3.71849954e-01f, -6.11640036e-01f, -7.77945817e-01f, 3.28498155e-01f, 7.28638917e-02f, -6.22993231e-01f,
  -2.69525200e-01f, -9.02696624e-02f, -7.63767213e-02f, -1.32818985e+00f, -5.15016578e-02f, -9.50157106e-01f, -7.84554258e-02f, -4.04352576e-01f, -3.29936981e-01f, -1.16343066e-01f,
  5.02869785e-01f, -4.89671975e-01f, -2.23296300e-01f, -1.36440009e-01f, 1.00637592e-01f, 5.70873439e-01f, 4.92110223e-01f, -3.93227935e-01f, -3.41552883e-01f, 1.41258761e-01f,
  3.92689407e-01f, 7.74389327e-01f, 1.80313796e-01f, 2.45582104e-01f, -3.35392535e-01f, -7.77297378e-01f, -2.42977485e-01f, -2.73798913e-01f, 4.53561209e-02f, 2.61520982e-01f,
  2.99760759e-01f, -3.50701027e-02f, 1.31275281e-02f, -1.43451700e-02f, -3.39845002e-01f, 7.87828937e-02f, -9.00868773e-02f, 2.87178010e-01f, -3.30665916e-01f, 1.76676288e-01f,
  -5.11984229e-01f, -1.50838718e-01f, -2.82777756e-01f, 3.04840535e-01f, 1.29791722e-01f, -3.54490280e-01f, 3.62735152e-01f, 1.93303674e-01f, -3.78246397e-01f, 5.36494195e-01f,
  -6.68003783e-02f, -3.30559880e-01f, 6.35498464e-02f, 4.91298065e-02f, 1.33342832e-01f, -2.24262804e-01f, 1.86023489e-01f, -1.03672914e-01f, -1.14920348e-01f, 5.28767228e-01f,
  6.70541406e-01f, 7.68855438e-02f, -4.55451727e-01f, 5.72027005e-02f, -3.38085651e-01f, -3.10311288e-01f, -9.61753875e-02f, -3.01476151e-01f, -3.17192897e-02f, -5.88091016e-01f,
  -3.70784402e-01f, -2.30756715e-01f, 4.54543173e-01f, -1.96612664e-02f, -3.09268177e-01f, 6.40957654e-01f, 4.19203550e-01f, -2.29777187e-01f, -3.57175946e-01f, -3.10601950e-01f,
  -1.27049163e-01f, -3.95510465e-01f, -2.32842356e-01f, 2.10714117e-01f, -4.95365679e-01f, 4.71257955e-01f, 1.86453149e-01f, -1.28761321e-01f, -2.39208043e-02f, -5.52753150e-01f,
  -5.72405338e-01f, 2.72908896e-01f, -2.29007363e-01f, -1.09138377e-01f, -8.26206282e-02f, -1.64043531e-02f, 1.02603532e-01f, -1.71421826e-01f, -2.16282010e-01f, 1.70482442e-01f,
  -1.58472314e-01f, 3.62646654e-02f, -4.70073000e-02f, -1.28408551e-01f, -3.58562320e-01f, 5.38599379e-02f, 1.83539122e-01f, -5.55000126e-01f, -3.05792063e-01f, 4.65340242e-02f,
  -2.68260390e-01f, -6.11699462e-01f, 5.33297241e-01f, 3.85116309e-01f, -7.65418887e-01f, -4.83316660e-01f, -4.06889051e-01f, -1.91316575e-01f, -6.44645989e-02f, 4.72817905e-02f,
  -3.77385736e-01f, -3.44379544e-01f, 6.37518585e-01f, -2.96097636e-01f, 4.79603916e-01f, -6.42511249e-01f, -4.15791810e-01f, 4.31983739e-01f, 2.94613808e-01f, -3.90463054e-01f,
  1.01556577e-01f, -1.49490610e-01f, -9.71496180e-02f, 1.55122697e-01f, -2.60864310e-02f, -6.58039629e-01f, 2.40688235e-01f, -3.94148111e-01f, 4.05415475e-01f, -4.34157163e-01f,
  2.90551513e-01f, 4.50228989e-01f, -2.68828094e-01f, -2.72180676e-01f, -6.31406084e-02f, 2.04201043e-01f, 4.59772050e-01f, 5.40106706e-02f, 2.24437062e-02f, -2.96567559e-01f,
  -7.54233450e-02f, -2.59365827e-01f, 2.08722234e-01f, 1.80487216e-01f, -7.25340247e-01f, 6.44197404e-01f, 2.84732487e-02f, -5.13704717e-01f, -2.43720517e-01f, -4.59194332e-02f,
  3.35993208e-02f, 1.30367622e-01f, -1.56571805e-01f, 1.66243538e-01f, 1.12344767e-03f, -2.01668456e-01f, -2.95891076e-01f, -3.44553590e-01f, -4.31379884e-01f, 3.56676996e-01f,
  3.63049477e-01f, -2.01659009e-01f, 5.46322525e-01f, 4.58201878e-02f, 2.74236560e-01f, -4.45462018e-01f, 4.31438275e-02f, -3.18869650e-01f, -4.92037721e-02f, -1.30154699e-01f,
  4.16806698e-01f, -3.87502193e-01f, 4.00077924e-02f, -7.30224773e-02f, 8.04948360e-02f, 4.20466751e-01f, 7.58599192e-02f, 6.39824390e-01f, -9.71963853e-02f, -2.78937042e-01f,
  1.29728451e-01f, 3.67232114e-01f, 2.60498393e-02f, 9.70137492e-02f, -5.43652296e-01f, 1.23918824e-01f, -4.38368261e-01f, 3.66018377e-02f, -6.56435192e-02f, 5.78663111e-01f,
  -1.81470942e-02f, -3.53244208e-02f, -4.46904123e-01f, -5.60938954e-01f, -5.11670053e-01f, -9.28426087e-01f, 1.60523787e-01f, -4.93435800e-01f, -3.41435745e-02f, 2.73186624e-01f,
  1.59332901e-01f, -1.01045154e-01f, -3.37483466e-01f, -7.44559705e-01f, -1.08769564e-02f, -4.57689792e-01f, -2.73154974e-01f, 3.34332287e-01f, 1.81861430e-01f, -2.38217667e-01f,
  2.13920102e-01f, 1.29902408e-01f, 2.24885687e-01f, 4.16246921e-01f, 3.13453466e-01f, 8.59303996e-02f, 6.56973571e-02f, 3.03401440e-01f, 2.26319090e-01f, -1.04999036e-01f,
  -1.93834230e-02f, 2.02796757e-02f, 2.56221265e-01f, -8.00107941e-02f, 3.28277707e-01f, 4.54655886e-01f, 8.28483254e-02f, -1.00323662e-01f, -4.34679747e-01f, 1.86871365e-01f,
  -1.52007222e-01f, -5.27589798e-01f, -7.38366395e-02f, 2.21315041e-01f, 1.67940736e-01f, -2.73163587e-01f, -2.47097343e-01f, 1.97196230e-01f, -5.47196902e-02f, 5.70639595e-02f,
  -6.58574522e-01f, -6.35424554e-01f, -3.88947368e-01f, 1.17410071e-01f, -1.00745738e-01f, -2.98480829e-03f, -2.80435860e-01f, 5.85561752e-01f, -2.26941258e-01f, 1.18007863e+00f,
  3.17939073e-01f, 5.51889002e-01f, -1.04674429e-01f, -2.89290786e-01f, -7.31210947e-01f, -2.55758792e-01f, -3.50455418e-02f, 1.00518562e-01f, -6.59553170e-01f, 5.22744097e-02f,
  2.43163511e-01f, 4.33260620e-01f, -3.87213051e-01f, 1.18955262e-01f, -1.89853743e-01f, -5.06180525e-01f, 4.13408458e-01f, -4.88840580e-01f, 2.44872272e-02f, -5.22675991e-01f,
  -4.50786471e-01f, -7.22049475e-01f, 6.78073168e-01f, -6.43218637e-01f, 7.27387816e-02f, -1.81652844e-01f, 9.64040831e-02f, -5.87111413e-02f, -8.81394893e-02f, -1.79707199e-01f,
  2.16891110e-01f, -3.45910132e-01f, 2.57055789e-01f, -2.84959853e-01f, 2.76811179e-02f, 2.85103798e-01f, -1.73868075e-01f, -4.49298650e-01f, -4.11415160e-01f, -5.00019968e-01f,
  -3.38741094e-01f, -4.94116217e-01f, 1.93859547e-01f, -2.28946865e-01f, -6.31936491e-01f, -4.60464448e-01f, -2.63652474e-01f, -2.19362676e-01f, -6.48843229e-01f, 7.71072447e-01f,
  -1.36492640e-01f, -1.24131255e-01f, -7.28725865e-02f, -3.63332182e-01f, -1.93060040e-01f, 1.45878077e-01f, 2.68027991e-01f, 6.24224730e-02f, -2.49668673e-01f, 3.16147916e-02f,
  -4.23903465e-01f, 3.71000826e-01f, -7.01397181e-01f, 4.02069777e-01f, 3.04518282e-01f, -2.91391730e-01f, -4.19663936e-01f, 8.46490502e-01f, 3.90652120e-01f, 4.46161091e-01f,
  -2.51714468e-01f, -1.69968396e-01f, -2.45043188e-01f, -2.67154932e-01f, 2.08593234e-01f, -1.05767667e-01f, 2.64563054e-01f, -2.96290636e-01f, -7.28345275e-01f, -2.10233241e-01f,
  -2.11654142e-01f, -3.99160385e-01f, -2.52882093e-01f, 3.28290552e-01f, -3.64693910e-01f, -8.77391338e-01f, -3.88062954e-01f, -6.05645061e-01f, -2.90779531e-01f, 2.13772684e-01f,
  1.81294996e-02f, -1.76413715e-01f, -2.75249481e-01f, -2.19150603e-01f, -1.99701831e-01f, 9.82917622e-02f, -1.55078635e-01f, 3.49027514e-02f, 2.12647915e-01f, -1.65353194e-01f,
  1.29891103e-02f, -1.92848563e-01f, -3.01152200e-01f, -3.79587978e-01f, -1.83681533e-01f, 1.44443631e-01f, 4.22100246e-01f, -3.08270395e-01f, 6.22376025e-01f, -2.12893918e-01f,
  -4.06010628e-01f, -5.48192799e-01f, -1.68484107e-01f, -1.09844223e-01f, -1.90924630e-01f, 1.16853833e-01f, 5.16944006e-02f, -2.95636386e-01f, 4.28385258e-01f, -2.62813449e-01f,
  1.06605142e-01f, -3.94975752e-01f, 3.07522774e-01f, -5.10612912e-02f, 3.55045855e-01f, -1.11626044e-01f, 4.91552383e-01f, 6.81881547e-01f, -3.12211812e-01f, -3.64882320e-01f,
  2.30248407e-01f, -2.91603267e-01f, -5.15653729e-01f, -6.11670196e-01f, -2.15981677e-01f, 1.69178292e-01f, 2.76754707e-01f, 2.92107433e-01f, -3.67415673e-03f, -6.38600171e-01f,
  -4.46727991e-01f, -3.43326956e-01f, -3.14923674e-01f, -2.83894330e-01f, -6.12298772e-02f, -2.92505771e-01f, 1.35295495e-01f, -9.19596925e-02f, 2.62464553e-01f, 1.35953858e-01f,
  -2.44498521e-01f, -4.01184708e-01f, 1.76359251e-01f, -2.86490619e-01f, 7.25101382e-02f, 2.67108083e-01f, 7.88651407e-02f, 1.97572216e-01f, 1.50697574e-01f, -2.27442697e-01f,
  -2.73340553e-01f, 2.86232680e-01f, 1.26762733e-01f, -1.01427406e-01f, 5.80431998e-01f, -2.53459245e-01f, -4.68472660e-01f, 4.25231531e-02f, -5.22695959e-01f, 6.87542632e-02f,
  -6.56497478e-02f, 6.80806398e-01f, -3.49722430e-02f, -2.08095565e-01f, -6.53260469e-01f, 7.88391978e-02f, -3.48393202e-01f, -1.16253264e-01f, -2.13976815e-01f, -1.60483956e-01f,
  -1.50973380e-01f, 4.59669858e-01f, -2.07080781e-01f, -2.67730236e-01f, -2.65626401e-01f, -5.12816012e-02f, -2.78482467e-01f, -4.49673414e-01f, -3.14639032e-01f, -2.38136917e-01f,
  -2.66465217e-01f, 1.07107677e-01f, 7.30435610e-01f, -3.13390255e-01f, 2.91260064e-01f, -1.49188280e-01f, -2.27411866e-01f, -3.58416557e-01f, -3.66107315e-01f, -1.43635005e-01f,
  6.86697900e-01f, 1.87905192e-01f, -4.22964156e-01f, -3.36089671e-01f, -6.55531585e-02f, -3.74687493e-01f, -3.00257266e-01f, 3.95825058e-01f, -2.60525465e-01f, -2.23648161e-01f,
  1.44492239e-01f, -2.88442880e-01f, 9.12398174e-02f, -1.17715590e-01f, -3.07594031e-01f, -5.97625747e-02f, 2.05412894e-01f, 4.00850996e-02f, -3.15702289e-01f, 1.48752913e-01f,
  4.22605053e-02f, -1.22228548e-01f, -1.20104045e-01f, 2.26390168e-01f, 3.62087011e-01f, -4.15596187e-01f, 3.11405450e-01f, 3.38522106e-01f, -4.44891363e-01f, -3.86136949e-01f,
  -4.56495523e-01f, -2.85363555e-01f, 2.60572970e-01f, -2.60191616e-02f, 1.66530818e-01f, 4.24190871e-02f, -6.04992986e-01f, -5.00213861e-01f, -3.61644208e-01f, 3.69743139e-01f,
  4.28095400e-01f, -1.87584668e-01f, -2.85878986e-01f, -2.57618517e-01f, -1.69840440e-01f, -3.01563814e-02f, 2.08058320e-02f, 3.30513030e-01f, -7.69622684e-01f, 1.01461351e-01f,
  -8.91762227e-02f, -4.04376268e-01f, -1.97952688e-01f, -7.11925328e-01f, 7.12345183e-01f, -4.07448113e-01f, -4.72015232e-01f, -2.32766256e-01f, -3.62041444e-01f, -1.81506574e-01f,
  7.50813559e-02f, 5.17790914e-01f, -2.06711590e-01f, 6.13515913e-01f, -5.80316544e-01f, -3.74814540e-01f, -4.18445915e-01f, -7.00559556e-01f, -4.40811843e-01f, -1.03752129e-01f,
  3.10782224e-01f, -3.07032596e-02f, -1.59911975e-01f, -7.95298338e-01f, -1.66597784e-01f, 4.04105783e-01f, 6.70143440e-02f, 5.86842775e-01f, 7.98948348e-01f, -3.33324969e-01f,
  1.51156798e-01f, 2.14161217e-01f, 8.44298825e-02f, -6.44209906e-02f, -6.13234080e-02f, 4.68461365e-02f, 5.02179489e-02f, -1.37881875e-01f, -1.08520031e-01f, 1.12581432e-01f,
  4.46330488e-01f, -1.73412427e-01f, -2.14866042e-01f, 2.54139364e-01f, -3.19914132e-01f, 2.09361747e-01f, 2.65096068e-01f, -2.43337095e-01f, -2.17504278e-01f, -1.21757396e-01f,
  -3.17921311e-01f, -2.02399880e-01f, -4.35350478e-01f, -7.28506967e-02f, -7.34505177e-01f, -4.26963978e-02f, -1.40608460e-01f, -1.32143542e-01f, -4.42303061e-01f, 4.07448590e-01f,
  -4.15731877e-01f, -4.06795479e-02f, -4.89449859e-01f, -4.85127032e-01f, -4.17693943e-01f, 4.84970093e-01f, 5.73115468e-01f, -2.80105174e-01f, -1.37416616e-01f, -6.50826767e-02f,
  -2.77961850e-01f, -1.46655664e-01f, 2.19987080e-01f, -2.20155358e-01f, -2.72028893e-01f, 7.81493559e-02f, -3.70662063e-01f, -3.10393602e-01f, -1.97061747e-01f, 8.14728379e-01f,
  -2.87470967e-01f, 1.88122019e-01f, -1.97411418e-01f, 3.50795597e-01f, -6.59171268e-02f, -2.44910434e-01f, 1.04397297e-01f, 6.03146255e-01f, -2.61627078e-01f, -1.48921330e-02f,
  6.89641118e-01f, -5.27594209e-01f, -4.90382552e-01f, -5.24117172e-01f, -1.24432378e-01f, 2.24200353e-01f, 1.84980601e-01f, 3.24103646e-02f, 7.76379555e-02f, -6.39409013e-03f,
  3.72520566e-01f, 1.41635984e-01f, -1.60399005e-01f, -5.33718653e-02f, 2.59490043e-01f, -4.15818006e-01f, 4.67820108e-01f, -1.99934945e-01f, -2.38686085e-01f, -2.42127046e-01f,
  -1.99144959e-01f, -5.79730451e-01f, -5.16885400e-01f, -5.60310304e-01f, 7.85045028e-01f, -2.83501297e-01f, -4.10471916e-01f, 3.76677632e-01f, -3.38295460e-01f, 8.53816122e-02f,
  3.76062930e-01f, -2.19359249e-01f, -3.61276194e-02f, -7.37179741e-02f, 4.15369779e-01f, -3.21710825e-01f, -2.76502788e-01f, -5.10752916e-01f, -6.76695723e-03f, -3.92307550e-01f,
  -2.80025512e-01f, 1.93466485e-01f, -3.70249718e-01f, -5.49217582e-01f, -1.27798781e-01f, -2.88352579e-01f, 2.11851466e-02f, -1.36714101e-01f, 5.53869605e-01f, -1.15694171e-02f,
  -1.58472821e-01f, -3.99174720e-01f, -1.21913426e-01f, -7.43179321e-02f, 1.20057128e-01f, 3.41060638e-01f, 2.64134765e-01f, 2.56268919e-01f, -2.12177157e-01f, -5.25382534e-02f,
  -2.54337400e-01f, -1.23919904e-01f, -7.82418549e-01f, -5.66898227e-01f, -2.88555145e-01f, 4.73901749e-01f, -5.04539728e-01f, 7.03368306e-01f
};

// L1_linear_B (Shape: 1 x 12)
const int L1_linear_B_rows = 1;
const int L1_linear_B_cols = 12;
const float L1_linear_B_data[] = {
  -1.14266872e-01f, 1.31458178e-01f, 2.25038365e-01f, -1.54094070e-01f, -4.30196747e-02f, 2.34647438e-01f, -3.56583074e-02f, -5.24852909e-02f, 1.23435713e-01f, 1.67664811e-02f,
  3.40510122e-02f, 1.34537861e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 6, 52
    );
    
    // Camada 1: L1_linear
    linear_forward_pgm(
        buffer1, x_out,
        L1_linear_W_data, L1_linear_B_data,
        64, 12
    );
    }
    