/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 32 (x4)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 32;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    return (x > 0.0f) ? x : 0.0f;
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 6 x 120)
const int L0_fan_Wp_rows = 6;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  5.35447717e-01f, 1.97822958e-01f, 8.32756683e-02f, -4.13028300e-02f, -6.38819337e-02f, -5.13227917e-02f, 2.22522750e-01f, 4.19220552e-02f, -2.30247825e-01f, 2.06342772e-01f,
  -6.55487180e-02f, -2.04251230e-01f, -9.15074795e-02f, -9.81561914e-02f, -3.54669653e-02f, 1.75164029e-01f, 6.14280887e-02f, 1.71005681e-01f, -9.14221108e-02f, -5.33405580e-02f,
  -7.65760764e-02f, 2.27390349e-01f, 1.18660413e-01f, -1.60378478e-02f, 1.48505971e-01f, -2.35018820e-01f, 1.39789209e-01f, 1.33673683e-01f, -9.51338261e-02f, 1.07992366e-01f,
  9.99761969e-02f, 2.82971144e-01f, 7.12097622e-03f, 1.11895368e-01f, 1.03656817e-02f, -2.50922982e-02f, 9.25965682e-02f, 6.31626397e-02f, 5.11033796e-02f, 8.17504451e-02f,
  -5.69407083e-03f, 4.88445275e-02f, 2.61821738e-03f, 8.02094769e-03f, 1.48751065e-01f, 1.50980085e-01f, 8.48069564e-02f, 1.93947226e-01f, 1.18260637e-01f, 1.88319869e-02f,
  1.57178883e-02f, 8.46254081e-02f, 2.48315543e-01f, 1.06634110e-01f, 1.03869721e-01f, 1.07388817e-01f, 4.65555675e-02f, 5.32709993e-02f, 7.60212168e-02f, 1.65322646e-01f,
  6.97098821e-02f, -1.14419304e-01f, -1.62777603e-01f, -4.13260376e-03f, -2.53609009e-02f, -9.10251960e-02f, -8.33688229e-02f, -9.84839574e-02f, -6.48433790e-02f, -3.02600134e-02f,
  -9.25756693e-02f, 2.20267810e-02f, -5.25915399e-02f, 3.49826515e-02f, -1.37463838e-01f, -5.55549469e-03f, -4.36676294e-02f, 1.29005183e-02f, -5.74003085e-02f, -9.77564752e-02f,
  -4.98728864e-02f, -1.26921413e-02f, -8.59161168e-02f, -8.33943710e-02f, -3.50385644e-02f, -7.40368143e-02f, -6.22413531e-02f, -5.90814054e-02f, 1.83932427e-02f, -1.92911271e-02f,
  -1.02833733e-01f, -1.02611473e-02f, 1.14978358e-01f, 1.36110023e-01f, 7.67838657e-02f, 1.24090001e-01f, 6.30833209e-02f, 4.47584726e-02f, 1.37977183e-01f, 6.70873150e-02f,
  1.66542515e-01f, 1.89357236e-01f, 1.25536278e-01f, 8.54052156e-02f, 1.11177012e-01f, 1.51224554e-01f, 9.18570086e-02f, -2.06221510e-02f, 6.69656768e-02f, 1.44756049e-01f,
  6.15754798e-02f, 5.64563870e-02f, 9.66139212e-02f, 5.77020422e-02f, 1.93469748e-01f, 8.25737193e-02f, 1.43373817e-01f, 1.25890553e-01f, 1.71033233e-01f, 2.20699951e-01f,
  3.42916518e-01f, 4.26877558e-01f, -1.83337424e-02f, -5.13862185e-02f, -2.31726859e-02f, -8.10501724e-02f, -1.58340484e-02f, -2.18362361e-02f, -6.01817556e-02f, 2.24428356e-01f,
  2.07531050e-01f, -9.04076397e-02f, -8.22186377e-03f, -2.00153384e-02f, -1.85291432e-02f, -1.49692580e-01f, -1.47938147e-01f, -8.92881155e-02f, -2.31580168e-01f, -3.24511714e-02f,
  -4.90761250e-02f, 8.55241343e-02f, 2.26189390e-01f, 1.26894608e-01f, 9.08704773e-02f, -1.61614433e-01f, -1.41011961e-02f, 2.44958755e-02f, 5.60835078e-02f, 1.00482032e-01f,
  3.35086524e-01f, 2.84536630e-01f, -1.73855379e-01f, 1.82125166e-01f, 7.57380426e-02f, 1.14316627e-01f, 6.69072419e-02f, 3.15049989e-03f, -1.80825405e-02f, 5.04760928e-02f,
  1.19411930e-01f, 5.87062612e-02f, 4.57160361e-02f, 6.58983886e-02f, 2.01394275e-01f, -2.66202632e-02f, 8.06464776e-02f, 1.02495790e-01f, 7.57533610e-02f, 1.19451322e-01f,
  1.25318870e-01f, 2.18867704e-01f, 2.53135175e-01f, 7.23074377e-02f, 1.60262451e-01f, 6.20201156e-02f, 2.02853441e-01f, 1.90174192e-01f, 3.59120965e-02f, 1.25895426e-01f,
  8.00382644e-02f, -9.61795971e-02f, -7.00025782e-02f, -8.34842771e-02f, -1.61970317e-01f, -9.62964445e-02f, -2.75982507e-02f, -7.79286698e-02f, -9.88325570e-03f, -2.67613474e-02f,
  -1.02770850e-02f, -3.92554440e-02f, -6.18526340e-02f, 8.70140642e-02f, -3.13068442e-02f, -8.92937556e-02f, -1.50279671e-01f, -2.22135857e-02f, 6.04638979e-02f, -1.36547172e-02f,
  -5.58985844e-02f, -2.03254353e-02f, -2.78856000e-03f, -1.21250682e-01f, -8.39284137e-02f, 3.51642109e-02f, -3.95346731e-02f, -6.42933920e-02f, -1.01179600e-01f, -2.06137691e-02f,
  1.71586536e-02f, 4.95769307e-02f, 2.68069021e-02f, -1.58945955e-02f, -2.52723489e-02f, -3.23606580e-02f, 1.14074282e-01f, 3.17479745e-02f, 7.79196844e-02f, 7.72024840e-02f,
  4.43466380e-02f, 5.71097322e-02f, 8.63537639e-02f, 1.25087634e-01f, 2.09327936e-02f, -5.25442548e-02f, -1.20901922e-02f, -5.56608588e-02f, 3.34612317e-02f, 1.23640455e-01f,
  -1.38822664e-02f, -7.12272301e-02f, -1.39094040e-01f, -6.07208163e-02f, -9.21272207e-03f, -9.20371339e-02f, -1.69902258e-02f, -6.28603175e-02f, -1.28809109e-01f, -1.53849661e-01f,
  -2.10330456e-01f, 1.79980993e-01f, 1.87319547e-01f, -5.13571035e-03f, -8.87287594e-03f, -8.66455771e-03f, -1.26625568e-01f, -4.58545648e-02f, -9.34869424e-02f, -1.91595871e-02f,
  -1.08138628e-01f, -8.47583413e-02f, -4.72599128e-03f, 8.39271247e-02f, -7.97258765e-02f, -5.13915792e-02f, 8.75467137e-02f, 7.79436380e-02f, -2.96561956e-01f, -3.28868210e-01f,
  -7.53104091e-02f, -9.92747918e-02f, -1.21080540e-01f, -2.12952271e-01f, 6.25208169e-02f, -9.91087034e-02f, 2.81205863e-01f, 1.77474812e-01f, 1.68978587e-01f, 5.21352351e-01f,
  1.04564078e-01f, 1.13925256e-01f, -1.41367987e-01f, 3.85910533e-02f, 9.09264907e-02f, -1.41669765e-01f, -2.50706282e-02f, 4.90540452e-02f, 2.44587217e-03f, 5.13692014e-03f,
  5.31438664e-02f, -4.04725187e-02f, 7.85998628e-02f, 9.26561132e-02f, -1.92370191e-02f, 5.98955527e-03f, -1.61757751e-03f, -2.55372860e-02f, 4.32836153e-02f, -3.76332104e-02f,
  -5.12508415e-02f, 6.09746091e-02f, -7.51279518e-02f, 6.81376318e-03f, 3.07506304e-02f, -2.83392649e-02f, -1.61212776e-02f, 2.72731073e-02f, 1.36813700e-01f, 1.05844885e-01f,
  -8.07743669e-02f, 1.44446446e-02f, 1.64294392e-01f, 4.31855209e-02f, 4.21174094e-02f, -1.73582267e-02f, 7.34990016e-02f, 7.20116589e-03f, 9.01981257e-03f, -7.48134851e-02f,
  -1.60371307e-02f, -5.60196005e-02f, -2.45068874e-02f, 4.97609526e-02f, 3.63992490e-02f, 1.49230793e-01f, 7.01091290e-02f, 4.96932752e-02f, 1.23327270e-01f, 5.78043051e-02f,
  1.14437267e-02f, 1.11215323e-01f, 3.39185633e-02f, 5.03886864e-02f, -3.71353445e-03f, 1.79289430e-01f, -3.30852829e-02f, 6.61138222e-02f, 8.86892155e-02f, -3.25724259e-02f,
  -6.83866888e-02f, 4.13187891e-02f, -1.38622552e-01f, -1.34296849e-01f, -1.57690402e-02f, -5.27391136e-02f, -7.18754455e-02f, -1.11750111e-01f, 7.97053392e-04f, -1.64384648e-01f,
  -1.15790278e-01f, -1.79170236e-01f, 3.76834981e-02f, -6.39576167e-02f, -1.33544669e-01f, -1.34549141e-01f, -4.89906892e-02f, -8.56065527e-02f, -2.37787627e-02f, -1.74786031e-01f,
  -1.23841092e-01f, -2.30176672e-01f, -2.88190931e-01f, -1.66582882e-01f, -1.55922934e-01f, -2.24827558e-01f, -1.90074533e-01f, -8.24217275e-02f, -1.55069530e-01f, -4.11249876e-01f,
  -2.64371186e-01f, 5.97916320e-02f, -4.28683273e-02f, -8.85701105e-02f, -3.09560657e-01f, -3.10688496e-01f, -3.54547292e-01f, -2.47664556e-01f, 1.10932343e-01f, -7.95355905e-03f,
  9.59268436e-02f, 1.98160455e-01f, 2.92813331e-01f, 2.02822030e-01f, -7.93904364e-02f, -1.29069373e-01f, 1.00904293e-02f, 3.39621454e-02f, -1.31948143e-01f, -1.78464383e-01f,
  1.01076849e-01f, -2.08617784e-02f, 4.66331355e-02f, 7.00019002e-02f, 7.34638143e-03f, 1.61613688e-01f, -1.85329076e-02f, -2.12357957e-02f, 6.58772662e-02f, 1.24754317e-01f,
  3.90682429e-01f, -1.08904220e-01f, -8.39529410e-02f, 5.73038235e-02f, -5.62653132e-02f, 9.20031592e-02f, 1.44770846e-01f, 7.92365596e-02f, 2.86497697e-02f, 1.37996137e-01f,
  -1.71056781e-02f, 1.00932987e-02f, -4.11842810e-03f, -7.42631331e-02f, -4.38162833e-02f, -7.12857693e-02f, 2.60326974e-02f, -7.17433691e-02f, -4.89517301e-02f, 7.67108146e-03f,
  9.86946747e-02f, -2.61269379e-02f, 4.76811528e-02f, 2.87751481e-02f, 4.92919683e-02f, 8.86650309e-02f, 1.63775329e-02f, -5.94070666e-02f, -3.61180231e-02f, 1.14974827e-01f,
  -1.02012828e-02f, -1.21648319e-01f, -1.56172946e-01f, -6.17082752e-02f, -4.50165197e-02f, 3.35645601e-02f, -5.32596232e-03f, 3.98341715e-02f, -2.56363954e-02f, 3.42965126e-02f,
  -4.39404249e-02f, -6.24880046e-02f, -2.43852548e-02f, 3.14845406e-02f, 7.19145834e-02f, -1.12017140e-01f, 6.13022037e-02f, -9.33050066e-02f, 1.20282747e-01f, 5.04550710e-02f,
  -4.88820486e-02f, -1.15527898e-01f, 4.59813466e-03f, -7.12940171e-02f, -4.88036405e-03f, -1.29400551e-01f, 2.26665474e-02f, -7.73043111e-02f, -2.02087276e-02f, -1.17367813e-02f,
  3.09824437e-01f, -9.74060129e-03f, 3.34952086e-01f, 9.04349461e-02f, 6.27571717e-02f, 1.43718719e-01f, 9.74847376e-02f, 1.07049599e-01f, 1.51837096e-01f, 1.00717999e-01f,
  8.75140727e-02f, 6.03815131e-02f, 1.30227908e-01f, 5.15451143e-03f, 2.58866698e-02f, -3.97095904e-02f, 1.11209832e-01f, -3.95683832e-02f, 4.38119620e-02f, 9.61113647e-02f,
  3.18592712e-02f, 2.28601377e-02f, 1.92145571e-01f, 8.76014680e-02f, 3.68358456e-02f, 1.02652550e-01f, 1.23973936e-01f, 3.72271240e-02f, 3.25634331e-02f, -5.00347931e-03f,
  9.70719829e-02f, -8.99775773e-02f, -2.07836218e-02f, 2.69572198e-01f, -1.08470052e-01f, -1.54587030e-01f, -2.15925157e-01f, -6.60761371e-02f, 1.29597023e-01f, 1.22768320e-01f,
  5.69524094e-02f, 1.95092186e-01f, 2.64807612e-01f, 1.50021603e-02f, 1.11471035e-01f, 8.01142529e-02f, 4.62780707e-02f, 1.48392376e-02f, -1.73308283e-01f, -1.81516483e-01f,
  -5.04124910e-02f, 1.21836647e-01f, -2.95826867e-02f, 3.31761762e-02f, 1.49951696e-01f, 6.78827474e-03f, 4.58183326e-02f, 2.93105002e-02f, -2.32665110e-02f, 3.01557600e-01f,
  2.23148018e-01f, 5.21173328e-02f, 3.00075002e-02f, 1.32208034e-01f, -3.47969532e-02f, -4.53579985e-02f, -7.59182498e-02f, 7.27873519e-02f, -5.84252477e-02f, -7.91507680e-03f,
  9.66359675e-02f, 1.14594281e-01f, 2.43396506e-01f, 4.84458208e-02f, 5.03938012e-02f, -3.31253819e-02f, 6.32182732e-02f, 1.01680145e-01f, 1.62200242e-01f, 1.96036756e-01f,
  2.42631823e-01f, 2.24154517e-01f, 6.70732111e-02f, 3.32536846e-02f, 1.45358384e-01f, 1.15222454e-01f, 1.51704267e-01f, 1.54875174e-01f, 7.16109648e-02f, 2.18653902e-01f,
  -1.12356588e-01f, 7.36963004e-02f, -3.98274101e-02f, -9.17877555e-02f, -1.63326994e-01f, 6.26147613e-02f, 4.71322127e-02f, -5.62621802e-02f, 9.75631922e-02f, 2.12231558e-02f,
  4.85708676e-02f, 1.04695391e-02f, -2.13739350e-02f, -1.99338198e-02f, 7.52514508e-03f, 1.56822912e-02f, -8.50159675e-02f, -4.82305922e-02f, 1.12000614e-01f, -2.32117604e-02f,
  -4.16225474e-03f, 6.01995969e-03f, -5.77302314e-02f, -3.33228260e-02f, -8.34497660e-02f, 5.89024164e-02f, -5.61582968e-02f, -8.36540908e-02f, 2.38769595e-03f, -2.17103641e-02f,
  4.38182652e-02f, 1.46592353e-02f, 2.74767756e-01f, 2.30617255e-01f, -3.38701112e-03f, 9.17997882e-02f, 6.03864864e-02f, -3.02222855e-02f, 2.09290627e-02f, 7.48865008e-02f,
  4.11293842e-02f, 1.31717518e-01f, 2.76353478e-01f, 1.58030227e-01f, 1.91503063e-01f, 9.54541266e-02f, -1.26452539e-02f, 9.29954425e-02f, 6.65029064e-02f, 6.37980625e-02f,
  2.12345168e-01f, 9.78945196e-02f, -2.63382308e-02f, 1.19208008e-01f, 9.17577595e-02f, 1.22556603e-03f, -1.00941420e-01f, -1.05209313e-01f, -4.92635891e-02f, -1.80954739e-01f,
  -5.31248689e-01f, -2.15139329e-01f, -2.13632993e-02f, -3.14822532e-02f, 1.00536849e-02f, 7.84830898e-02f, -1.29720941e-01f, -7.69540593e-02f, 9.76371020e-02f, -1.39436975e-01f,
  -1.75256133e-02f, 1.67819664e-01f, 5.56784682e-02f, 1.27749696e-01f, -1.98366884e-02f, -5.87303750e-02f, 3.36367413e-02f, 3.67214084e-02f, 8.08714256e-02f, 7.62047991e-02f,
  6.15652613e-02f, -6.22530095e-02f, -9.25075449e-03f, 2.47685499e-02f, -1.25170678e-01f, 1.19417667e-01f, -9.53816622e-02f, -9.59607884e-02f, 9.22444090e-02f, -1.99294910e-01f,
  -2.57326275e-01f, -1.71326935e-01f, 1.37169421e-01f, 4.18455191e-02f, 1.33503508e-02f, -4.87685837e-02f, -5.90115413e-02f, -4.67829667e-02f, 1.48813939e-02f, -4.85554570e-03f,
  -5.57809174e-02f, -6.87723607e-02f, 4.81945463e-02f, 1.64548378e-03f, -4.54378389e-02f, -4.78746556e-02f, 6.50564209e-02f, -7.41205364e-02f, -2.72465106e-02f, -9.16909892e-03f,
  7.86186382e-02f, -7.91586787e-02f, -1.79855123e-01f, 6.45896718e-02f, 7.82957766e-03f, 5.73220029e-02f, -6.58321753e-02f, 4.18097246e-03f, -3.72074954e-02f, -1.20610684e-01f,
  9.22396183e-02f, -6.18773662e-02f, -2.59921458e-02f, -1.25263900e-01f, -6.61005154e-02f, -2.33826656e-02f, -8.84473100e-02f, 2.02735402e-02f, 8.89726263e-03f, -7.54884332e-02f,
  4.22346629e-02f, -7.52315745e-02f, -6.21272773e-02f, -3.81079577e-02f, 9.53818932e-02f, -1.43981606e-01f, 8.26565176e-02f, -2.73726461e-03f, -5.86461313e-02f, -9.40546300e-03f,
  3.77926193e-02f, -5.14455512e-02f, -7.09066689e-02f, -9.31726769e-03f, 5.86500242e-02f, -7.35611320e-02f, 8.54693726e-02f, 3.57115455e-02f, 3.61918695e-02f, 5.08470982e-02f,
  -5.82823232e-02f, 3.19824845e-01f, -2.12247949e-02f, -3.32890153e-02f, 2.61331070e-02f, 1.08601160e-01f, -2.95431204e-02f, 8.25951919e-02f, 4.06086668e-02f, 3.60988220e-03f,
  -6.42306209e-02f, -6.25274777e-02f, -6.19823672e-03f, -4.84462753e-02f, 1.60670318e-02f, 1.19709224e-02f, -3.78593653e-02f, -2.51688040e-03f, 8.26873481e-02f, 2.34793909e-02f,
  -5.02965339e-02f, -1.33672565e-01f, -9.80195478e-02f, -6.69230446e-02f, -3.81975248e-02f, -7.56804366e-03f, -7.52425492e-02f, -1.03196025e-01f, -7.29540177e-03f, -3.15367669e-01f
};

// L0_fan_Wp_bar (Shape: 20 x 120)
const int L0_fan_Wp_bar_rows = 20;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -1.71343803e-01f, -3.54387552e-01f, 1.25518069e-01f, 1.87566414e-01f, -3.38064536e-04f, -3.92317861e-01f, -7.90347099e-01f, -4.39716995e-01f, 8.29754397e-02f, -1.52228624e-01f,
  -5.55693321e-02f, 1.07765079e-01f, 1.32134244e-01f, 1.14233280e-02f, -2.38481596e-01f, -2.44450137e-01f, 1.13128811e-01f, 2.14126498e-01f, -1.02695554e-01f, -1.48292035e-01f,
  1.80099264e-01f, 1.55015364e-01f, 1.50585666e-01f, -7.23370584e-03f, 7.09373131e-02f, 1.12895809e-01f, 1.97766080e-01f, 1.47526920e-01f, 6.30950853e-02f, 2.93680280e-01f,
  4.55786586e-02f, 2.80247834e-02f, 1.08833566e-01f, 6.00577295e-02f, 3.50096598e-02f, -2.44750455e-01f, -1.92788139e-01f, 4.73338254e-02f, -9.70062837e-02f, -6.25563646e-03f,
  8.12751725e-02f, -1.74303830e-01f, -1.01295589e-02f, 9.64623690e-02f, -8.72794688e-02f, -2.07565725e-01f, -1.25203416e-01f, 4.11454812e-02f, -1.27841577e-01f, -2.16321945e-01f,
  1.59749594e-02f, -2.02895124e-02f, -1.77052408e-01f, -1.02812573e-01f, -1.67652607e-01f, 1.51022568e-01f, 5.00709191e-02f, 3.30877304e-03f, -1.31204575e-01f, -1.15915075e-01f,
  1.40569046e-01f, -2.29192954e-02f, -1.50560420e-02f, 5.20305987e-03f, -3.75606939e-02f, 5.76534159e-02f, 1.52396252e-02f, 5.19039147e-02f, -2.19600257e-02f, -4.72616069e-02f,
  1.22105047e-01f, 2.88042217e-03f, 4.19581421e-02f, 5.09381108e-03f, 8.78929794e-02f, 6.86823949e-02f, -9.41428542e-02f, -3.43131237e-02f, -3.58883524e-03f, -4.54858467e-02f,
  -2.14018598e-02f, 4.97199632e-02f, 8.52215686e-04f, -5.39385974e-02f, -1.06802635e-01f, 2.21457407e-02f, 1.15460247e-01f, -2.36176670e-01f, -5.01906872e-03f, -1.34027712e-02f,
  -3.44968736e-02f, 3.45921181e-02f, -6.46656752e-02f, -9.55783874e-02f, 7.19445720e-02f, -8.11929703e-02f, 5.61672077e-02f, 6.80876672e-02f, 4.12055515e-02f, -5.76765873e-02f,
  -7.58702457e-02f, -6.92366138e-02f, -3.91348302e-02f, 5.22773415e-02f, -7.88234621e-02f, 9.23328288e-03f, -9.34185758e-02f, 4.44828682e-02f, -1.59895141e-02f, -7.84290358e-02f,
  -1.56386953e-03f, -2.59673268e-01f, -2.22977027e-01f, -6.73237070e-02f, 6.06755018e-02f, -1.29144162e-01f, 1.61923673e-02f, -6.08833283e-02f, -1.87710837e-01f, -3.01558942e-01f,
  -7.77175575e-02f, 2.56200641e-01f, 3.48640710e-01f, -1.43684849e-01f, -4.73106690e-02f, -5.78892380e-02f, 4.12373960e-01f, 2.16061890e-01f, -2.74910778e-01f, 1.24375470e-01f,
  -1.76859885e-01f, -3.90607655e-01f, -1.30336970e-01f, -1.33698031e-01f, 2.29285851e-01f, 3.59782368e-01f, 4.43643719e-01f, 1.62400275e-01f, -9.03906003e-02f, -1.55083999e-01f,
  -1.19982131e-01f, -5.86274117e-02f, -1.05499849e-01f, -5.18117994e-02f, 4.10069339e-02f, -2.21986383e-01f, -6.62581548e-02f, 4.42271642e-02f, 4.26465757e-02f, 1.10908113e-01f,
  -8.95826072e-02f, 2.22217590e-01f, -2.28029769e-02f, -1.28616855e-01f, -1.69105396e-01f, -2.07448732e-02f, -1.87511500e-02f, -1.60537716e-02f, -8.04083273e-02f, 7.95234069e-02f,
  -2.48321384e-01f, -7.82200992e-02f, -3.32106739e-01f, -1.00186333e-01f, -1.56938910e-01f, -5.40680513e-02f, -2.10405309e-02f, 2.81105459e-01f, 2.35392358e-02f, -9.48715732e-02f,
  6.53240085e-02f, -1.43537242e-02f, 1.32384226e-01f, 6.88481554e-02f, 2.12277565e-02f, -2.87173450e-01f, -1.55321732e-01f, 4.68693003e-02f, 3.83738093e-02f, -1.22074425e-01f,
  7.14263041e-03f, 7.82255232e-02f, 1.08511783e-02f, 1.17838413e-01f, 2.39167307e-02f, -1.85768120e-02f, -8.93513090e-04f, -1.26638025e-01f, -1.65094882e-02f, 6.58250451e-02f,
  -1.40174732e-01f, -1.24370962e-01f, 4.20594960e-02f, -1.01948120e-02f, -3.72136794e-02f, 4.13601883e-02f, -7.45856017e-02f, 1.21499179e-02f, -2.00425852e-02f, -5.78574724e-02f,
  -3.83623713e-03f, 9.10703167e-02f, -9.03861150e-02f, -1.29743051e-02f, 1.34594619e-01f, 1.20127760e-01f, -8.97941291e-02f, 5.56601137e-02f, 2.46140342e-02f, 1.89533785e-01f,
  -3.31417203e-01f, 1.32032007e-01f, 6.72456343e-03f, -4.39711986e-03f, 1.92375630e-02f, -5.84156625e-02f, -3.98127325e-02f, 6.75585046e-02f, -7.05545992e-02f, 9.90242437e-02f,
  -4.67760004e-02f, 8.60585272e-03f, -1.76301092e-01f, -9.38061550e-02f, -1.09183066e-01f, -2.38698255e-02f, 1.67698227e-02f, -4.21767943e-02f, -8.86172876e-02f, -3.48008908e-02f,
  6.14253059e-02f, 1.04841582e-01f, -3.08648627e-02f, 1.16293050e-01f, -1.50796667e-01f, -2.64242560e-01f, -1.94478318e-01f, -1.86420098e-01f, -1.99921951e-01f, -1.17563583e-01f,
  1.35672972e-01f, 8.16990584e-02f, -6.68839633e-01f, -1.84526090e-02f, -3.59143138e-01f, -2.28410274e-01f, -2.18845367e-01f, 9.53907073e-02f, 3.11570108e-01f, -1.90812871e-01f,
  5.06872907e-02f, 4.80840892e-01f, 2.12239027e-01f, 1.21680982e-02f, -1.11893378e-01f, -5.26772738e-01f, -5.91357052e-01f, -3.96980524e-01f, -2.10015938e-01f, -7.95942396e-02f,
  -1.45523474e-01f, -3.03709060e-01f, -1.05793759e-01f, -1.24149872e-02f, 5.51207028e-02f, 2.67268777e-01f, -3.39687690e-02f, -4.67665456e-02f, 1.98941622e-02f, -2.60122150e-01f,
  -2.86946267e-01f, 2.85151482e-01f, 5.57572357e-02f, -4.19218503e-02f, -1.88364655e-01f, 5.36326133e-02f, -5.12427762e-02f, 1.46745574e-02f, 1.03664972e-01f, 6.90319911e-02f,
  3.49687152e-02f, -5.03772683e-02f, 4.74190898e-02f, 6.44298196e-02f, -3.31808180e-02f, -2.91125998e-02f, 4.78706881e-02f, 7.26338103e-02f, -4.72719260e-02f, -5.64245209e-02f,
  -1.58511654e-01f, -1.10501766e-01f, 2.05407724e-01f, 2.53307074e-01f, 1.46726102e-01f, 4.14770953e-02f, 1.97137877e-01f, 1.54741421e-01f, 2.19549820e-01f, 3.35049301e-01f,
  -3.33411619e-02f, 2.23962158e-01f, 2.59343833e-02f, 1.46408513e-01f, 4.23552804e-02f, 4.56609502e-02f, 6.85933791e-03f, -4.45909090e-02f, 6.03505485e-02f, 8.82943273e-02f,
  8.09185579e-02f, -1.61187211e-03f, 8.96820351e-02f, -5.62463477e-02f, -2.56493658e-01f, 4.12765034e-02f, 4.38110530e-02f, -8.63763224e-03f, 9.22487006e-02f, 2.04499047e-02f,
  -1.06423376e-02f, 9.69597511e-03f, -4.28466126e-02f, 1.37871519e-01f, -8.93115401e-02f, 8.49054381e-02f, -9.29311514e-02f, 8.27952549e-02f, 2.61551235e-02f, -1.18022308e-01f,
  2.40057483e-01f, -1.37552872e-01f, -7.26499557e-02f, 1.82114661e-01f, -6.14888482e-02f, -2.66744830e-02f, 9.43410583e-03f, -6.21216558e-02f, -6.31518885e-02f, 4.15808242e-03f,
  9.83040966e-03f, 5.07177636e-02f, 4.55409251e-02f, 3.66423354e-02f, 1.17402151e-02f, -8.62204507e-02f, 2.29533371e-02f, -6.21998124e-03f, -1.37496412e-01f, -1.52913079e-01f,
  -4.80582602e-02f, 1.51525522e-02f, 2.12178424e-01f, 1.90807506e-01f, 2.55049076e-02f, -6.23852089e-02f, 4.28725742e-02f, -2.12251525e-02f, 3.89009267e-02f, 1.93743557e-01f,
  2.55230367e-01f, -3.33055556e-01f, -4.78464663e-01f, -5.26981875e-02f, -1.87074974e-01f, -9.73145440e-02f, 3.40210721e-02f, 1.07178316e-01f, 1.46505818e-01f, -4.71682195e-03f,
  -1.91646740e-01f, -8.75210389e-03f, 1.43545687e-01f, -3.88151333e-02f, 2.04866715e-02f, -1.36314761e-02f, -1.34240627e-01f, -1.09128237e-01f, 1.07332267e-01f, 7.23880529e-02f,
  2.69166023e-01f, 2.57710427e-01f, 7.33940303e-02f, 6.95850849e-02f, -7.45007992e-02f, 1.71674117e-01f, -7.53554553e-02f, -1.86342701e-01f, -1.60590813e-01f, -4.25964057e-01f,
  8.75800774e-02f, -4.53447670e-01f, -2.96681095e-02f, -2.74813827e-02f, -1.45410001e-01f, 2.82716751e-02f, 6.39579520e-02f, -1.60097808e-01f, -1.44489154e-01f, 7.86915347e-02f,
  -2.54822999e-01f, 3.10210381e-02f, -1.09375797e-01f, 8.74779448e-02f, -3.99850793e-02f, 5.56145534e-02f, -1.00422092e-01f, -2.45529786e-01f, 2.54977178e-02f, 3.87127921e-02f,
  8.29701778e-03f, -2.90665329e-01f, -1.92592189e-01f, -1.97431788e-01f, -2.65326500e-01f, -2.02835202e-01f, -1.47310466e-01f, -1.92621768e-01f, -2.51945108e-01f, -1.35385096e-01f,
  1.34968460e-02f, -7.52640963e-02f, -1.04903057e-01f, 8.55529904e-02f, 2.02039536e-02f, 2.84456704e-02f, -8.05574283e-02f, -4.10181209e-02f, 9.94170830e-02f, 1.21734947e-01f,
  -7.52240419e-02f, 5.74674904e-02f, -1.20854102e-01f, 6.18646108e-02f, 8.98743197e-02f, -1.98758189e-02f, -4.79582585e-02f, 3.78456376e-02f, 2.66511156e-03f, 3.48815955e-02f,
  5.58871252e-04f, -6.81098178e-02f, -2.93871742e-02f, -4.65865247e-02f, -1.87782601e-01f, -8.74975473e-02f, 2.93954425e-02f, 4.12621051e-02f, 1.42491549e-01f, 5.32125309e-02f,
  5.19637764e-01f, -3.60954285e-01f, 3.02563965e-01f, 2.11518556e-02f, -2.97951815e-03f, -4.52392735e-03f, -1.15539782e-01f, 1.84001755e-02f, -2.68850103e-03f, 1.20724924e-01f,
  -1.27067581e-01f, 6.34805337e-02f, -5.35795325e-03f, -1.66028682e-02f, 2.95543354e-02f, 9.23100263e-02f, 1.21941492e-01f, 1.82173364e-02f, 4.21837457e-02f, 4.46870066e-02f,
  5.30768745e-02f, 9.70629081e-02f, 1.42053887e-01f, 6.93973154e-02f, 8.64899606e-02f, 3.66902389e-02f, 2.17707604e-01f, 2.09952876e-01f, 1.53702209e-02f, 5.60986400e-01f,
  -5.51884592e-01f, -3.99850368e-01f, 5.14613032e-01f, -1.23451248e-01f, 1.82550728e-01f, 3.85352343e-01f, 5.26278973e-01f, 6.85521960e-02f, -2.35477850e-01f, -8.90036970e-02f,
  -2.82004863e-01f, -2.54691660e-01f, -3.34754795e-01f, -2.92156816e-01f, -7.68171996e-02f, 2.61933684e-01f, 2.29607150e-01f, 1.52607173e-01f, 3.32332104e-01f, 2.31238723e-01f,
  7.78245507e-03f, 9.91818085e-02f, -2.26459816e-01f, -1.16180919e-01f, 8.62045866e-03f, -1.18151985e-01f, 1.24376670e-01f, -1.98025797e-02f, -4.14636964e-03f, -1.37022555e-01f,
  3.16838413e-01f, -1.97603241e-01f, -2.10516080e-02f, -3.15817803e-01f, -1.80902169e-03f, -2.07439914e-01f, -5.48042729e-03f, -2.89880903e-04f, -7.29993060e-02f, 2.98086256e-02f,
  -4.97852154e-02f, -7.88813829e-03f, 1.32219687e-01f, 9.68085900e-02f, 6.57989904e-02f, 2.01672167e-02f, -1.72036499e-01f, -7.28089958e-02f, 7.40858261e-03f, -2.92378757e-02f,
  -2.00675026e-01f, 1.42081780e-02f, 1.10539176e-01f, 8.29658732e-02f, 2.92894989e-03f, -4.30817939e-02f, -9.50973332e-02f, -5.21238707e-02f, -4.45339903e-02f, -7.50797540e-02f,
  8.30610842e-02f, 1.17578730e-02f, -6.52590543e-02f, 4.45728749e-02f, 3.30741033e-02f, 1.39147997e-01f, 7.76262730e-02f, 7.27044046e-02f, 7.73180053e-02f, 1.32107630e-01f,
  1.06678955e-01f, 8.83960351e-02f, 1.39679953e-01f, -3.25641744e-02f, -1.25214651e-01f, -1.60307083e-02f, 1.03048868e-01f, -2.90859360e-02f, -1.84746943e-02f, -9.53983963e-02f,
  4.83592972e-02f, 2.64990758e-02f, -9.77873802e-02f, 1.36411488e-01f, -7.20130280e-02f, -6.47806749e-02f, 6.81911856e-02f, -2.46780142e-02f, 5.28880171e-02f, -1.46182820e-01f,
  1.68824613e-01f, -1.44111991e-01f, 6.89526126e-02f, -2.52770982e-03f, 1.17433161e-01f, -8.27610046e-02f, -2.68366728e-02f, -9.06171277e-02f, 3.95947807e-02f, 1.99407358e-02f,
  -3.13206501e-02f, 4.50427569e-02f, 1.60087407e-01f, 2.56129298e-02f, 2.84945697e-01f, 8.03039446e-02f, -8.06551427e-02f, 1.00647375e-01f, -7.82554504e-03f, 6.02749549e-02f,
  -3.12395934e-02f, 3.00119333e-02f, 2.81569175e-02f, 1.53999761e-01f, 8.61257091e-02f, 1.66071042e-01f, 1.97873488e-01f, 9.51133743e-02f, 5.41628562e-02f, 1.33880749e-01f,
  -1.66116133e-02f, -4.46015000e-02f, -2.49104768e-01f, 1.11952975e-01f, 1.51926070e-01f, 5.35640568e-02f, 1.12046011e-01f, 1.20064653e-01f, 1.26053944e-01f, 6.72834367e-02f,
  1.66157320e-01f, 3.31352174e-01f, 2.47526690e-01f, 1.47438109e-01f, 6.91091791e-02f, -1.21461311e-02f, 1.76456533e-02f, 8.45080893e-03f, 4.52299044e-03f, 9.81475338e-02f,
  7.40735680e-02f, -3.27506848e-02f, -1.19756676e-01f, -1.83368544e-03f, 2.55073309e-01f, -8.29181671e-02f, -1.63872227e-01f, 4.74170968e-02f, -1.22080572e-01f, 4.43547130e-01f,
  2.82779217e-01f, 6.05759397e-02f, 3.35489064e-02f, -2.54757367e-02f, -2.61973199e-02f, -3.14955972e-02f, -2.27216078e-04f, -1.08094290e-01f, -1.05742656e-01f, -4.35606623e-03f,
  8.29348043e-02f, 1.48436740e-01f, 9.38940272e-02f, 7.24465726e-03f, -6.47572353e-02f, -4.08993255e-05f, 4.05894555e-02f, 3.39733511e-02f, -2.50974912e-02f, 6.32459745e-02f,
  8.93994495e-02f, 3.46868136e-03f, -3.59588601e-02f, -9.96892676e-02f, -9.98163372e-02f, -3.06235105e-02f, -7.93756247e-02f, -2.60954257e-02f, -1.10897221e-01f, 1.41069070e-01f,
  2.43847609e-01f, 1.34201884e-01f, 2.09903270e-02f, 2.13217288e-01f, 1.92428932e-01f, 1.03513442e-01f, 1.02356253e-02f, 1.10052027e-01f, 7.85965845e-02f, 2.00201303e-01f,
  1.48224622e-01f, -4.81342152e-02f, 3.86306718e-02f, -5.93284294e-02f, 3.04018669e-02f, -6.96743431e-04f, 1.10850528e-01f, 2.47856267e-02f, -3.66105698e-02f, -8.14686790e-02f,
  1.32856190e-01f, -4.52560596e-02f, 6.24255799e-02f, 2.07099795e-01f, -6.34808466e-02f, -7.84579962e-02f, -1.12076597e-02f, -5.01828343e-02f, -1.59800187e-01f, -1.62622422e-01f,
  -1.19597346e-01f, -2.72262454e-01f, 1.73092023e-01f, 3.44555937e-02f, -1.40120070e-02f, 5.27528711e-02f, 1.20591119e-01f, -1.02410436e-01f, -6.75531775e-02f, -7.97194615e-02f,
  -1.79139704e-01f, 1.06173024e-01f, -9.94063541e-03f, 3.67324352e-02f, -9.46961716e-02f, 3.85228321e-02f, 2.34004974e-01f, 9.80854481e-02f, -5.81769571e-02f, -2.90919282e-02f,
  1.62514355e-02f, -8.51332545e-02f, -1.23304054e-01f, 5.96153848e-02f, -8.61861557e-02f, -5.66859059e-02f, -3.04791212e-01f, -3.00813526e-01f, -2.65850693e-01f, -2.49011472e-01f,
  -2.72295065e-02f, 6.86162710e-02f, 1.45249501e-01f, 3.85913432e-01f, 3.71571839e-01f, 3.26438218e-01f, 2.98059911e-01f, 1.33201540e-01f, 2.17074141e-01f, 1.97411940e-01f,
  2.56867707e-01f, 2.48782858e-01f, 3.35165024e-01f, 2.48478159e-01f, 1.33900061e-01f, 2.42803454e-01f, 2.76801825e-01f, 7.29307085e-02f, 8.14931691e-02f, 1.80491403e-01f,
  1.41716197e-01f, 6.32804334e-02f, -2.40021735e-01f, 1.27329811e-01f, 7.17722997e-02f, 2.44587302e-01f, -1.37223974e-02f, 1.04589751e-02f, 9.51711386e-02f, 2.46194098e-02f,
  1.66474842e-02f, -1.79401524e-02f, 1.88410208e-01f, 3.65743078e-02f, -8.73874575e-02f, -1.63871318e-01f, -6.08628169e-02f, -1.78305373e-01f, 2.87541915e-02f, -3.58226113e-02f,
  -4.01303321e-02f, -1.77777454e-01f, -6.17822669e-02f, -1.43625751e-01f, -7.60316029e-02f, -1.46951169e-01f, -1.47540897e-01f, 8.35343301e-02f, 1.44472197e-01f, -8.14126059e-02f,
  9.28709209e-02f, -1.20824277e-01f, -9.29282159e-02f, 5.77840656e-02f, -5.10367230e-02f, 1.30827064e-02f, -2.25977842e-02f, -4.58341949e-02f, 3.03089004e-02f, -6.17088862e-02f,
  1.86308131e-01f, 8.56460035e-02f, 9.52021033e-02f, 5.34144863e-02f, -1.92596465e-02f, -1.18295625e-02f, 1.02285393e-01f, 1.13404199e-01f, 4.67928685e-02f, -1.27860650e-01f,
  1.11320792e-02f, -3.69014442e-02f, 3.46870646e-02f, 7.70433396e-02f, 1.22167625e-01f, -4.81972955e-02f, -3.68077457e-02f, 2.03496553e-02f, -9.47561562e-02f, -1.14664480e-01f,
  -2.02517986e-01f, 1.87205169e-02f, -1.89521670e-01f, -1.58439204e-02f, -4.11925502e-02f, 2.02218965e-01f, -7.85114896e-03f, -4.76647317e-02f, 4.37327549e-02f, -9.12431106e-02f,
  -1.01538740e-01f, 8.20547193e-02f, 6.98723346e-02f, -5.78462631e-02f, -1.17561288e-01f, -1.18568815e-01f, 1.28155455e-01f, -3.17402780e-02f, -7.93228298e-02f, 1.16015144e-01f,
  -1.36081129e-01f, -1.14427157e-01f, -1.52979910e-01f, -1.11252449e-01f, -3.28549258e-02f, -1.70780122e-01f, -1.31283943e-02f, 1.46743253e-01f, 9.59118381e-02f, -1.85081325e-02f,
  5.59513196e-02f, -9.93295107e-03f, 1.02580212e-01f, 2.22689644e-01f, 7.73692429e-02f, 9.87328142e-02f, -1.33606881e-01f, -4.46341559e-02f, -6.59610797e-03f, -5.80242984e-02f,
  -4.13974404e-01f, -4.35410053e-01f, -1.03447475e-01f, 3.11906099e-01f, 1.90540656e-01f, 7.79831037e-02f, -5.31291902e-01f, -2.11645335e-01f, 1.09295376e-01f, -2.65644073e-01f,
  3.65260337e-03f, 1.55419603e-01f, 3.53029743e-02f, -5.41804284e-02f, -2.39440426e-01f, -3.08630735e-01f, -8.46025497e-02f, -7.62445852e-02f, 8.62676576e-02f, 2.15707377e-01f,
  2.60583013e-01f, 2.19599172e-01f, 9.69664156e-02f, 1.37184560e-01f, 4.69996631e-02f, 6.32359684e-02f, -1.64823040e-01f, -4.95781302e-02f, -1.43380210e-01f, 2.77923886e-02f,
  -4.73827906e-02f, -1.62983268e-01f, 5.02009764e-02f, 1.00365557e-01f, 1.02553062e-01f, -1.61734477e-01f, -7.26083219e-02f, -1.00665398e-01f, 8.42074454e-02f, 1.01715453e-01f,
  1.98910683e-01f, 1.60143450e-01f, 8.86874273e-02f, 6.94345087e-02f, 8.76309872e-02f, -6.65097637e-03f, -3.01316823e-03f, -1.17577016e-01f, -1.12908043e-01f, -6.17289543e-02f,
  1.99097499e-01f, 2.16596127e-01f, -1.09597878e-03f, -2.15543702e-01f, -2.51279652e-01f, -6.71969261e-03f, -2.48075962e-01f, -2.19522238e-01f, -3.19258600e-01f, -4.71249640e-01f,
  -1.01167575e-01f, -1.54612130e-02f, -1.99172832e-02f, -1.04126774e-01f, 3.27137560e-02f, 7.49572963e-02f, -2.51617469e-02f, 5.27325682e-02f, 3.67967673e-02f, -1.19670846e-01f,
  4.68836986e-02f, -2.47418582e-02f, -1.25678713e-02f, -1.66880544e-02f, 1.65929064e-01f, 1.19128190e-02f, 4.80342917e-02f, -2.55133100e-02f, 1.53213724e-01f, -5.61208688e-02f,
  2.72531509e-02f, -8.12938809e-02f, 9.86146703e-02f, -2.33870838e-02f, -1.25808969e-01f, -5.99869564e-02f, 4.33440022e-02f, -3.30253541e-02f, 7.46586621e-02f, -1.73355360e-02f,
  1.24089256e-01f, 6.20812410e-03f, -1.01464763e-01f, 8.09051022e-02f, 8.11310709e-02f, 1.32522136e-01f, -2.89926417e-02f, 2.75777429e-02f, 8.40305761e-02f, -1.03820950e-01f,
  -6.12196773e-02f, 9.88994837e-02f, -5.23854159e-02f, -1.67829040e-02f, -5.10513000e-02f, -9.09547962e-05f, -3.07154912e-03f, 9.91139188e-02f, 5.63220773e-03f, 1.01348482e-01f,
  8.71268101e-03f, -6.15552859e-03f, -1.94050968e-01f, -1.76404148e-01f, -1.04828946e-01f, -7.79691190e-02f, -8.63322839e-02f, -1.09634332e-01f, -3.93489987e-01f, -6.45007491e-01f,
  4.13501561e-02f, 4.66725290e-01f, 1.16715156e-01f, 2.37658825e-02f, 1.15643024e-01f, 1.43267214e-01f, 2.82754004e-01f, 2.43118688e-01f, -2.76547242e-02f, 2.05179416e-02f,
  3.96446511e-02f, -2.31571160e-02f, 3.14162746e-02f, 7.19927177e-02f, 1.01944700e-01f, 9.33738127e-02f, 1.43620953e-01f, 1.97202295e-01f, 1.66045390e-02f, 5.71402162e-02f,
  6.45014569e-02f, 4.95784618e-02f, 1.91522792e-01f, -4.84597113e-04f, 2.78492928e-01f, -8.65468904e-02f, -4.06887792e-02f, 2.42285296e-01f, 1.23411171e-01f, 2.87374705e-01f,
  -3.26782942e-01f, 1.87122539e-01f, -2.05226019e-01f, -6.38341829e-02f, -7.60059357e-02f, -4.27580718e-03f, -2.68082246e-02f, -5.21888211e-02f, -1.60652697e-01f, -6.48882687e-02f,
  2.54267305e-02f, -2.22894317e-03f, 2.21642122e-01f, 2.45715491e-02f, -4.21381183e-02f, 1.01706879e-02f, 1.10639192e-01f, 5.74980676e-03f, -4.57994603e-02f, -4.25892416e-04f,
  6.55378914e-03f, 4.62964363e-02f, -5.20687923e-02f, 5.46028242e-02f, 5.58292214e-03f, -5.86224049e-02f, 1.16581274e-02f, 6.70842975e-02f, -6.50023445e-02f, -2.05773711e-02f,
  -4.18263264e-02f, -4.86906245e-02f, -1.18464725e-02f, -8.18186924e-02f, 1.03953458e-01f, -9.11648497e-02f, 7.45469034e-02f, 5.48017696e-02f, 1.70761943e-01f, 2.81906277e-01f,
  3.31227593e-02f, 2.61285156e-02f, -7.24102333e-02f, -4.83262092e-02f, -4.03691716e-02f, -4.73624356e-02f, -4.30225506e-02f, -4.43417132e-02f, -9.17120278e-02f, 7.12508261e-02f,
  1.40541987e-02f, -1.28008634e-01f, -8.98913294e-02f, -1.34930182e-02f, -1.55747071e-01f, -8.44264999e-02f, 5.29306149e-03f, -4.16996256e-02f, 3.87717709e-02f, -9.79026631e-02f,
  -3.04881126e-01f, -2.02648953e-01f, -6.25947714e-02f, 1.69052258e-01f, 7.86109194e-02f, 5.65204732e-02f, 8.97694938e-03f, -1.42116109e-02f, -1.79972798e-02f, -1.66786849e-01f,
  -4.48292308e-03f, -4.51919548e-02f, 3.05008609e-02f, 1.12510860e-01f, -7.16462284e-02f, -9.22524333e-02f, 5.46621438e-03f, -9.23670754e-02f, -5.34110591e-02f, -8.53471458e-02f,
  5.34002371e-02f, -2.63151340e-02f, -2.33069897e-01f, -3.69392000e-02f, -8.84375945e-02f, -1.52410775e-01f, -1.85947716e-01f, -1.52706444e-01f, -1.37566105e-01f, -2.06079006e-01f,
  -2.73498744e-01f, -9.67313349e-02f, -2.69768208e-01f, -1.30829111e-01f, -6.27849922e-02f, 1.57490432e-01f, -2.66620517e-01f, 5.36226556e-02f, 1.95663691e-01f, -2.62699366e-01f,
  -1.77238956e-01f, -1.03765979e-01f, -2.84635633e-01f, -2.46654510e-01f, -2.91063637e-01f, -3.57600749e-01f, -3.55826169e-01f, -2.55691648e-01f, 8.18569884e-02f, 1.97905123e-01f,
  9.73971281e-03f, -9.52735022e-02f, -8.56480449e-02f, 1.15168348e-01f, -3.71283777e-02f, -1.40540838e-01f, -3.82270426e-01f, -2.52396941e-01f, -1.04550548e-01f, -4.35133785e-01f,
  -1.39458269e-01f, 3.03847063e-02f, 6.94406629e-02f, -2.84428090e-01f, -2.14717705e-02f, 1.01849986e-02f, 1.08999819e-01f, -1.59603760e-01f, -3.60118672e-02f, -1.16110250e-01f,
  -3.17518324e-01f, 1.45720243e-01f, -2.08981410e-01f, 2.82545425e-02f, 3.15474533e-02f, -4.92015947e-03f, -7.06951767e-02f, -1.41145363e-01f, -4.10904326e-02f, 2.74851680e-01f,
  -1.15663253e-01f, -1.06212579e-01f, -3.09711426e-01f, 1.01497337e-01f, 3.11077833e-02f, -1.06210165e-01f, -1.91315055e-01f, -4.08595838e-02f, -1.55306980e-01f, -3.01593393e-01f,
  4.77977842e-02f, 1.47184823e-03f, -3.72716486e-02f, 2.95733605e-02f, 2.44496204e-02f, -3.70713361e-02f, -7.54838511e-02f, -6.63618967e-02f, 9.02860705e-03f, -6.00957274e-02f,
  -8.18549097e-02f, 4.82037343e-04f, 1.51253253e-01f, 4.45844494e-02f, -1.57180235e-01f, -3.44126858e-02f, -6.67099282e-03f, -1.89153284e-01f, -9.03530642e-02f, -4.71642204e-02f,
  -1.16288036e-01f, -1.60414770e-01f, -3.85332592e-02f, 7.20487535e-02f, 1.22340338e-04f, 9.25871506e-02f, 5.05811013e-02f, -1.01557896e-01f, 7.44970189e-03f, 1.38697624e-01f,
  -1.23436458e-01f, -8.10996816e-02f, -1.29186451e-01f, -6.01715446e-02f, -5.47036044e-02f, 4.85324189e-02f, 3.44657782e-03f, 3.84116545e-02f, 9.88226533e-02f, -7.85619095e-02f,
  -2.23398283e-01f, 1.21540213e-02f, -2.74714470e-01f, -7.46697783e-02f, 1.50253847e-01f, -1.06437221e-01f, -1.13647953e-01f, -2.26854041e-01f, -1.22628212e-01f, 1.54606402e-01f,
  -1.71040386e-01f, -1.47150174e-01f, -3.32152754e-01f, -2.47527629e-01f, 9.06364396e-02f, -1.92943707e-01f, -2.29257613e-01f, -5.42497449e-02f, -2.85154313e-01f, -2.51147658e-01f,
  7.28468478e-01f, -4.90385175e-01f, -2.20259979e-01f, -6.85808957e-02f, -3.57422046e-02f, 4.78012562e-02f, -1.90488920e-01f, 3.32024135e-02f, 3.52948438e-03f, -1.88432395e-01f,
  7.09341792e-03f, 2.76772350e-01f, 2.15163201e-01f, 1.22165471e-01f, 1.57661542e-01f, -2.99106926e-01f, -3.72132659e-01f, 6.89273179e-02f, 4.57536668e-01f, 4.03682321e-01f,
  -5.08919619e-02f, -5.44568384e-03f, 1.44781079e-02f, 1.44718662e-01f, -1.79490000e-01f, 1.28020987e-01f, -3.25058192e-01f, -2.39371821e-01f, -5.82835600e-02f, -4.83429193e-01f,
  -1.01077199e-01f, 1.05455630e-01f, 3.27969119e-02f, 3.51347029e-02f, -1.39139086e-01f, 4.47436124e-02f, -2.11116094e-02f, 3.34355584e-03f, -3.96888331e-02f, -1.85781151e-01f,
  6.44506216e-02f, -8.09695572e-02f, 4.10314836e-02f, -7.00968271e-03f, -4.09137420e-02f, 3.80389625e-03f, -8.73562321e-02f, 7.07332641e-02f, 2.34779660e-02f, -1.37598887e-02f,
  -9.39224381e-03f, 4.55555320e-02f, -6.05524033e-02f, -1.05451934e-01f, 6.08361289e-02f, 3.80707439e-03f, -2.29549319e-01f, -7.66164660e-02f, -1.77239086e-02f, -2.37378627e-01f,
  3.43760796e-04f, -9.85966027e-02f, 3.56889181e-02f, 1.04278825e-01f, 1.12610571e-01f, 1.94866881e-02f, -2.65900400e-02f, 5.75753227e-02f, 8.10239241e-02f, -3.62538509e-02f,
  4.01183963e-02f, -7.90214762e-02f, -6.08001661e-04f, -2.57038996e-02f, -1.54484790e-02f, -3.85978483e-02f, -9.97717977e-02f, -1.51356608e-01f, 1.49669386e-02f, 1.15918815e-02f,
  5.13811074e-02f, 9.11509916e-02f, 8.78613889e-02f, 5.60843013e-02f, 1.43450638e-02f, -1.42092779e-02f, 6.86688274e-02f, -1.20507237e-02f, 5.28625846e-02f, 1.10739827e-01f,
  -1.79668237e-02f, -3.57037112e-02f, 3.32408957e-02f, 1.10736176e-01f, -1.18811093e-02f, -1.90422833e-02f, -8.33478495e-02f, 4.04896066e-02f, -5.52945808e-02f, -3.22851017e-02f,
  6.84611592e-03f, 6.44377172e-02f, -2.43907329e-02f, -1.64550558e-01f, 1.15332678e-01f, 4.74481471e-02f, -5.99227920e-02f, 2.18865395e-01f, 1.02277718e-01f, -5.17340451e-02f,
  -1.80037349e-01f, 9.25291628e-02f, 1.26275599e-01f, 9.73536819e-02f, 3.55853997e-02f, 2.65613437e-01f, 3.20686139e-02f, -4.17851955e-02f, 1.61292195e-01f, 1.05571831e-02f,
  1.50111198e-01f, -4.70092177e-01f, 1.48327306e-01f, 1.53954238e-01f, 8.86756852e-02f, 1.00930765e-01f, -9.00774449e-02f, -1.34512529e-01f, -8.67043361e-02f, -9.81156230e-02f,
  -2.01624632e-02f, 1.10064201e-01f, 1.05256982e-01f, 5.64673962e-03f, 9.04051661e-02f, 3.65546718e-02f, 2.26973975e-03f, 5.22407740e-02f, 2.93405920e-01f, 2.47691616e-01f,
  3.04377098e-02f, -1.72554314e-01f, -9.68240499e-02f, -1.88603505e-01f, -1.89412773e-01f, 7.83747286e-02f, -8.50223154e-02f, -1.21883154e-01f, -1.18769348e-01f, -3.16891581e-01f,
  2.31921166e-01f, -3.56406346e-02f, 1.88762128e-01f, -8.20626467e-02f, -5.33013977e-02f, 1.15938229e-03f, 1.39620453e-01f, -6.43234327e-02f, -1.97474156e-02f, 7.37931281e-02f,
  7.81799704e-02f, -1.47979915e-01f, 4.19256054e-02f, -5.12341373e-02f, -9.45656151e-02f, -3.14293131e-02f, -1.11521713e-01f, 1.36666372e-02f, -1.13074973e-01f, 3.58648710e-02f,
  -6.29847646e-02f, 4.84334268e-02f, 6.36380389e-02f, -2.13077944e-02f, 1.94166869e-01f, 1.67525057e-02f, -8.73051360e-02f, -7.27824345e-02f, -6.34383336e-02f, -5.43393120e-02f,
  2.44971931e-01f, -1.09099962e-01f, -9.10494551e-02f, -6.30691648e-02f, 3.38267908e-02f, 3.90507802e-02f, -3.86592336e-02f, -4.36825268e-02f, -3.22056673e-02f, 3.08544282e-02f,
  -8.09553191e-02f, 4.54149134e-02f, 7.47530237e-02f, 1.40736535e-01f, -7.79057890e-02f, -1.51729524e-01f, -5.80603033e-02f, -6.02677055e-02f, -4.71889637e-02f, -1.51858494e-01f,
  -2.89681964e-02f, -2.45054681e-02f, -1.39835253e-01f, -2.23898426e-01f, -1.55953407e-01f, 6.54200092e-02f, 1.65936276e-02f, -1.26601562e-01f, -1.75889041e-02f, -6.96912259e-02f,
  -2.62132175e-02f, 7.98508674e-02f, 7.87640586e-02f, -1.56098485e-01f, -1.16742507e-01f, -1.34539932e-01f, 6.26945868e-03f, 1.49537409e-02f, 5.54031841e-02f, 1.09632067e-01f,
  -3.79017889e-02f, 7.81876072e-02f, -9.73747522e-02f, -5.83460443e-02f, 1.00695990e-01f, 8.70070159e-02f, -1.10832214e-01f, 5.17088994e-02f, -4.62663509e-02f, 2.60681286e-02f,
  -7.31099769e-02f, 8.97794291e-02f, 1.62401915e-01f, 1.68829709e-01f, 9.71320942e-02f, 1.89192057e-01f, -4.15750891e-02f, 7.17294663e-02f, 1.30836621e-01f, 1.10871315e-01f,
  4.40309271e-02f, -1.69812277e-01f, 2.34521076e-01f, 3.17343660e-02f, -1.18240505e-01f, -3.74391884e-01f, -5.83981276e-01f, -2.99905151e-01f, -8.83452371e-02f, -1.37854904e-01f,
  -1.42602026e-01f, 3.14797019e-03f, 9.73236710e-02f, 1.79901809e-01f, 2.70053893e-02f, -8.58715549e-02f, 2.15293676e-01f, 5.35383940e-01f, 1.97950631e-01f, -4.80300374e-02f,
  3.70606259e-02f, 2.89640337e-01f, 3.65668058e-01f, 4.50921617e-02f, -1.15560986e-01f, -1.04891583e-01f, 7.05015659e-02f, 9.03775394e-02f, -9.19567198e-02f, 4.00773287e-01f,
  2.00006396e-01f, -9.41086859e-02f, 2.67244037e-02f, -1.01581924e-01f, 3.94186750e-02f, 3.77319902e-02f, 6.26311079e-02f, 1.29193529e-01f, 4.44575436e-02f, 1.04886472e-01f,
  3.88607644e-02f, 3.22390236e-02f, -1.31367207e-01f, 7.70032331e-02f, -5.84193915e-02f, 1.87685750e-02f, 2.72668283e-02f, 2.06482589e-01f, 7.90924206e-02f, -1.52283400e-01f,
  -9.20637548e-02f, -1.44436404e-01f, -9.90732163e-02f, -1.83671936e-01f, -1.15970097e-01f, 1.48338810e-01f, -1.67370901e-01f, 1.04351426e-02f, -9.95340273e-02f, 8.21586922e-02f,
  2.85204826e-03f, 3.74569446e-02f, 5.46439141e-02f, 2.95905638e-02f, 8.59483983e-03f, -3.04219127e-02f, -3.51939201e-02f, -1.17297200e-02f, 6.57050908e-02f, -1.61519814e-02f,
  -6.80448562e-02f, 1.15484983e-01f, -2.01858692e-02f, -3.61397862e-02f, -6.80231601e-02f, -1.60755217e-03f, -3.20815668e-02f, 1.34108230e-01f, 4.61026356e-02f, -8.15275386e-02f,
  1.02470145e-01f, 4.76381406e-02f, -2.20629089e-02f, 7.92909935e-02f, -1.39460489e-01f, 1.48432866e-01f, 2.86351480e-02f, -8.70569348e-02f, -6.76150769e-02f, -2.46138722e-02f,
  -2.10429296e-01f, -1.90075510e-03f, -4.72022071e-02f, 9.80555862e-02f, -1.09757297e-01f, 8.04217681e-02f, -6.23952039e-02f, -3.37837115e-02f, -5.32038212e-02f, 1.61871053e-02f,
  -1.45099819e-01f, 5.40007353e-02f, -1.02653436e-01f, 8.70734379e-02f, -1.92712191e-02f, -1.11557640e-01f, 6.23290874e-02f, 4.38014418e-02f, 5.41609302e-02f, -3.12303305e-02f,
  -3.06494329e-02f, -8.64688754e-02f, -1.70180991e-01f, -7.79264569e-02f, -1.45260245e-01f, -1.58694983e-02f, -1.48047563e-02f, -1.51093394e-01f, -1.06936395e-01f, -2.82842278e-01f,
  9.18044448e-01f, 6.81158453e-02f, -6.27131462e-02f, 4.06085581e-01f, -1.12070449e-01f, -1.83786258e-01f, -8.79334584e-02f, -2.65132606e-01f, 1.11762412e-01f, 8.34091770e-05f,
  -1.42146617e-01f, -1.39199108e-01f, 8.68305638e-02f, -2.19511151e-01f, -2.74713159e-01f, -1.04557410e-01f, -1.30104482e-01f, -1.77396014e-01f, -1.25382438e-01f, -3.74644786e-01f,
  -3.47856373e-01f, -2.25900915e-02f, 3.83574702e-02f, -1.96940690e-01f, -1.68407094e-02f, -8.09551403e-02f, -1.64879430e-02f, 9.16126277e-03f, -2.00019792e-01f, -9.37646851e-02f,
  -1.18440494e-01f, 2.61847526e-01f, -1.79810792e-01f, 2.70022079e-02f, 2.15316508e-02f, -1.59291197e-02f, 2.64110486e-03f, 1.46929221e-03f, 1.24074914e-01f, -7.07716569e-02f,
  7.93206447e-04f, -1.42746374e-01f, -2.71933638e-02f, -2.42904857e-01f, 1.00982808e-01f, -2.05891833e-01f, 5.06981276e-02f, -1.32029757e-01f, -3.39515135e-02f, -8.27595070e-02f,
  -2.45058656e-01f, 5.89669570e-02f, 2.47917697e-01f, -5.51533177e-02f, -5.04257157e-02f, 4.74388637e-02f, 6.33073822e-02f, -1.84166640e-01f, -1.30642012e-01f, -1.56124428e-01f,
  -2.48504840e-02f, 1.25702694e-01f, -1.95345636e-02f, 3.55388969e-02f, -1.69307664e-02f, 2.19824575e-02f, 1.76910423e-02f, -3.60998102e-02f, -5.94631508e-02f, -1.88025590e-02f,
  -5.47230318e-02f, -5.45837684e-03f, -1.35096654e-01f, 1.49511486e-01f, 3.92629206e-02f, 6.12909831e-02f, 2.73322733e-03f, -8.34603608e-02f, 4.23399284e-02f, -4.34533469e-02f,
  5.12378551e-02f, 1.30037516e-01f, 8.78283009e-02f, -4.06348892e-03f, -1.31565109e-02f, -9.66094658e-02f, 1.14356494e-02f, -6.85487539e-02f, -4.93647940e-02f, -4.05022912e-02f,
  6.09304793e-02f, -3.76803763e-02f, 2.16991026e-02f, -9.94540974e-02f, 1.49398923e-01f, 1.13664223e-02f, -2.71354541e-02f, -5.34789190e-02f, 1.62846223e-01f, -4.29372936e-02f,
  -3.05031966e-02f, 5.73209561e-02f, -2.67565344e-03f, 1.31649245e-02f, -3.66261788e-02f, -3.24018039e-02f, -4.39037159e-02f, -6.40467703e-02f, -3.93686220e-02f, 2.62028947e-02f,
  -1.31612932e-02f, 1.33718532e-02f, 2.08228499e-01f, 3.97076309e-02f, 1.10499784e-01f, 2.27719411e-01f, 9.11122635e-02f, -1.82352227e-03f, 1.31749958e-01f, 1.81834772e-02f,
  3.03182155e-01f, -6.74181759e-01f, 1.44057661e-01f, -1.62008315e-01f, 6.50207400e-02f, 2.85527632e-02f, -3.34994972e-01f, -2.00680181e-01f, -6.33059889e-02f, -2.96441555e-01f,
  -2.44532540e-01f, 1.75167248e-01f, 1.60638675e-01f, 1.07663244e-01f, 6.40310422e-02f, -2.17177585e-01f, -4.10921574e-02f, 4.45550650e-01f, 5.86764336e-01f, 1.08417459e-01f,
  -1.24744192e-01f, -1.54476628e-01f, 2.74318084e-02f, 3.62312351e-03f, -1.21187389e-01f, 1.90754697e-01f, -1.55089274e-01f, -1.69003859e-01f, -8.82441700e-02f, -2.87101805e-01f,
  6.90937489e-02f, -1.29290700e-01f, 2.16477707e-01f, -1.31334871e-01f, 4.86879572e-02f, -1.51290130e-02f, 1.12532556e-01f, -1.86379422e-02f, -2.54017040e-02f, 3.95790301e-02f,
  -5.25219031e-02f, -1.02441005e-01f, 6.45416975e-02f, -4.26932797e-02f, -1.35507047e-01f, -5.21496683e-02f, -1.13173947e-01f, -1.61288291e-01f, -1.51119202e-01f, -1.46293819e-01f,
  -1.75384760e-01f, -1.49677545e-01f, 1.55676886e-01f, -5.54184280e-02f, -1.69337466e-01f, 1.49839828e-02f, -1.05777599e-01f, -1.00556044e-02f, 8.80170465e-02f, -1.33354962e-01f,
  -5.54603860e-02f, 3.38634998e-02f, 4.62894477e-02f, 3.88933010e-02f, -2.16380283e-02f, -3.39394026e-02f, 2.15709899e-02f, -1.27759978e-01f, 2.08218750e-02f, -1.58945732e-02f,
  3.92965227e-02f, 1.30926194e-02f, 7.15141697e-03f, -6.30256115e-03f, -5.51252142e-02f, 7.34744221e-02f, 7.92301074e-02f, 2.79234052e-02f, 1.11932857e-02f, -9.27025154e-02f,
  2.41516773e-02f, 7.43697211e-02f, -2.84977350e-02f, -2.27132179e-02f, -1.15328267e-01f, -1.40924356e-03f, 2.19766274e-02f, -6.49841130e-02f, 9.24978852e-02f, -6.42943978e-02f,
  -2.57806987e-05f, 5.35293221e-02f, -3.18979919e-02f, 2.99937464e-03f, 4.78287339e-02f, -3.32710259e-02f, 3.74445952e-02f, -6.96929321e-02f, -5.97961172e-02f, 1.63999900e-01f,
  -7.92457759e-02f, 3.94544005e-02f, 9.25407279e-03f, -6.95987940e-02f, -6.43690452e-02f, 4.08391692e-02f, 4.75255921e-02f, -2.62825619e-02f, -1.28684297e-01f, -7.75252953e-02f,
  -1.18915521e-01f, 2.35634837e-02f, 2.26228848e-01f, 3.57158370e-02f, -4.92237657e-02f, 2.08503723e-01f, 8.58042389e-02f, -9.17174816e-02f, 1.71536595e-01f, 6.42309487e-02f,
  -5.00255406e-01f, -3.61685082e-03f, -6.94691092e-02f, -7.25282669e-01f, -1.57594174e-01f, 3.57979648e-02f, 1.42781213e-01f, -5.39538860e-02f, -2.79909492e-01f, -2.22393706e-01f,
  2.03326076e-01f, 2.82703102e-01f, -5.70103154e-03f, 1.70363128e-01f, 1.76455706e-01f, -1.77631199e-01f, -3.24952483e-01f, -2.06127167e-02f, 3.59918326e-01f, 3.54373872e-01f,
  4.89077568e-02f, -2.52638608e-01f, -2.20152617e-01f, 3.43791880e-02f, -6.78905398e-02f, 9.68627781e-02f, -3.04157257e-01f, -9.33601558e-02f, 2.94006050e-01f, -3.47830564e-01f,
  2.24114746e-01f, -6.69145733e-02f, -4.67389785e-02f, -1.17227674e-01f, -2.45340355e-02f, -2.99474560e-02f, 2.62789577e-02f, -8.49656537e-02f, -1.93762109e-02f, -1.69493645e-01f,
  -9.92236286e-02f, 8.71940181e-02f, -2.55397409e-02f, 4.74423636e-03f, -2.04890165e-02f, 3.60955745e-02f, -1.24859214e-01f, -2.70167738e-02f, -2.04026848e-02f, 4.42921370e-03f,
  7.29246065e-02f, -2.49623712e-02f, -2.78583653e-02f, -9.04869139e-02f, 1.66672170e-02f, 7.30410442e-02f, 2.47854277e-01f, 1.41493633e-01f, 7.67547563e-02f, -5.21217398e-02f,
  4.39847168e-03f, 5.88985980e-02f, 9.53289121e-02f, 9.55236554e-02f, -9.72188935e-02f, 1.18919145e-02f, 3.80920954e-02f, -4.68688011e-02f, 6.65105954e-02f, 1.80495661e-02f,
  -5.88732101e-02f, -5.77151999e-02f, -3.37062962e-02f, 1.54657653e-02f, -8.93627945e-03f, -4.40409072e-02f, 9.83150676e-03f, 2.22532488e-02f, 1.13226613e-02f, -1.63793862e-02f,
  -3.41359898e-02f, -2.38160994e-02f, -1.12945072e-01f, 2.29889881e-02f, 7.91673735e-03f, -5.73970452e-02f, -2.68045664e-02f, 1.08992167e-01f, -5.02600148e-02f, 2.78101936e-02f,
  -3.66449095e-02f, 1.08568771e-02f, -1.08737618e-01f, 7.41123036e-02f, -8.38095620e-02f, -3.56597118e-02f, -6.19174391e-02f, -8.83195258e-04f, -1.47367761e-01f, -5.82115836e-02f,
  6.09470904e-02f, -2.90014315e-02f, -1.07141644e-01f, 1.49040408e-02f, -7.80791342e-02f, 1.04189686e-01f, 2.61095744e-02f, -5.13694696e-02f, -5.29005677e-02f, -1.72506757e-02f,
  -6.84649646e-02f, 2.11609956e-02f, 7.11627528e-02f, -8.78200755e-02f, -1.67662501e-02f, 1.00585490e-01f, 2.63613492e-01f, 9.22717229e-02f, 1.69043735e-01f, -2.50580087e-02f,
  -5.20371795e-01f, -3.86102736e-01f, 9.01414976e-02f, -2.03545690e-01f, -6.41325936e-02f, 6.89549372e-02f, -3.69318575e-01f, -1.35297656e-01f, -2.45413072e-02f, -3.59487534e-01f,
  -2.60587007e-01f, 2.11214423e-02f, -2.30977863e-01f, 1.68426901e-01f, 2.98007261e-02f, -4.11877275e-01f, -1.21189006e-01f, -1.42886490e-02f, 2.38649517e-01f, 1.74097955e-01f,
  -1.30671002e-02f, -1.22007564e-01f, -8.33206438e-03f, 2.30500057e-01f, -3.12698573e-01f, -1.15419894e-01f, -3.15609455e-01f, -2.08244532e-01f, -1.39644682e-01f, -4.18718576e-01f,
  -3.05314571e-01f, -2.19785306e-03f, 3.32212746e-01f, -4.98178750e-02f, -8.22423324e-02f, -1.54618556e-02f, -2.00605586e-01f, 2.37618317e-03f, -3.16029415e-02f, -4.03395258e-02f,
  -9.95910615e-02f, 8.16445332e-03f, -1.18431740e-01f, 4.47843894e-02f, -4.42953557e-02f, 5.86971268e-03f, 1.44747704e-01f, 9.14397463e-03f, 9.79647487e-02f, 9.28995013e-02f,
  -1.45205557e-01f, -1.22148454e-01f, 5.39655499e-02f, 1.68693677e-01f, 2.37756610e-01f, 1.75482377e-01f, 1.31369559e-02f, 1.52761281e-01f, 2.46136278e-01f, -4.65065539e-01f,
  -8.04549828e-02f, 8.90053064e-03f, 3.10388785e-02f, 1.76385008e-02f, 2.75584292e-02f, -1.31660476e-01f, 3.60157201e-03f, -1.73876286e-01f, -1.39922932e-01f, 3.00012678e-02f,
  9.75007936e-02f, 1.84279156e-03f, -1.04077950e-01f, -1.06946275e-01f, -7.36304894e-02f, 1.16571613e-01f, 1.53599931e-02f, 6.91592842e-02f, 2.09220629e-02f, 4.79901396e-02f,
  1.44760072e-01f, 6.59307167e-02f, -2.35124137e-02f, -3.31504382e-02f, -4.25302461e-02f, -9.25840586e-02f, 1.73599795e-01f, 1.12721413e-01f, 1.74018234e-01f, 3.02543249e-02f,
  -2.97015280e-01f, 2.03103021e-01f, -2.02722490e-01f, 1.87638611e-01f, 2.83712540e-02f, 1.58336982e-01f, -9.84703973e-02f, 9.26103443e-02f, 1.77415535e-01f, 6.73932359e-02f,
  1.52033523e-01f, -2.55473778e-02f, -1.19297929e-01f, 9.79584903e-02f, -8.78628939e-02f, 3.31306644e-02f, 2.40139030e-02f, -3.33795846e-02f, 1.88493729e-01f, 2.27729812e-01f,
  3.52931656e-02f, 4.74567115e-02f, -1.55511111e-01f, 2.67952885e-02f, 2.08534766e-03f, 1.01232663e-01f, -1.00868754e-01f, -2.78237113e-03f, -7.03860745e-02f, -4.35587108e-01f,
  -5.74880600e-01f, 5.29137813e-02f, -2.70098567e-01f, -3.36101532e-01f, -3.94890398e-01f, -2.13188708e-01f, -1.72230124e-01f, 4.76663038e-02f, -2.20320560e-02f, -5.38415909e-02f,
  -5.21971807e-02f, 1.25667095e-01f, 5.41717634e-02f, 9.43353325e-02f, -1.14386417e-01f, -7.33725578e-02f, -3.58417988e-01f, -1.85264766e-01f, 1.69443581e-02f, 1.37224123e-01f,
  1.33020692e-02f, -3.13409358e-01f, -2.13518888e-01f, 4.18365840e-03f, -9.78519469e-02f, -6.98940232e-02f, -3.54427040e-01f, -7.61137307e-02f, -1.30728707e-01f, -4.42454427e-01f,
  1.75097212e-01f, -3.43165159e-01f, -9.80655029e-02f, -1.89291701e-01f, -1.21677734e-01f, -1.82447210e-02f, -4.88965958e-02f, -1.39726892e-01f, -7.21642822e-02f, -8.02143216e-02f,
  -1.48328498e-01f, 6.86267987e-02f, 1.23035507e-02f, -8.35367590e-02f, -5.62530793e-02f, 1.39314914e-02f, -1.05162254e-02f, -1.68263733e-01f, -1.53116032e-01f, 4.23795804e-02f,
  -2.98294500e-02f, -4.60242257e-02f, -6.31586313e-02f, -2.41902380e-04f, -2.89387107e-02f, -1.05878346e-01f, 2.59143729e-02f, 8.27105641e-02f, -4.02675755e-02f, -8.71178880e-02f,
  -1.10481299e-01f, -5.32280561e-03f, 4.04814295e-02f, 8.10435191e-02f, 5.36346734e-02f, 1.30771875e-01f, -9.18080807e-02f, -1.72716174e-02f, -1.02252038e-02f, 1.76160466e-02f,
  2.84122489e-02f, -3.92022077e-03f, -2.46577691e-02f, 1.58100188e-01f, -7.48599172e-02f, 6.62417784e-02f, 2.44206865e-03f, 9.65888351e-02f, 1.97168402e-02f, 2.85560489e-02f,
  1.77418552e-02f, 4.65685688e-02f, 1.57882832e-02f, 5.20478375e-03f, -3.63159552e-02f, -9.56652761e-02f, -8.51186812e-02f, 1.10201903e-01f, 3.36261764e-02f, 3.90433148e-02f,
  2.51087666e-01f, -2.87608892e-01f, -3.72925885e-02f, -6.70501590e-02f, 3.08477785e-02f, -1.20823719e-01f, 1.91909000e-02f, 2.78392751e-02f, -1.35172522e-02f, 2.75586601e-02f,
  -1.56669493e-03f, 2.41608903e-01f, -1.78811476e-02f, 1.45842591e-02f, 3.94170620e-02f, -6.57305643e-02f, 2.00867012e-01f, -1.94980688e-02f, 5.52385226e-02f, 1.29004598e-01f,
  8.84696394e-02f, 1.82567820e-01f, 1.10106841e-01f, -5.19940332e-02f, -1.98464491e-03f, 2.04919633e-02f, 1.69077113e-01f, 2.16352381e-02f, -8.06914493e-02f, 1.98987961e-01f,
  5.26638091e-01f, 8.77911821e-02f, 2.84669608e-01f, 8.28531832e-02f, -1.41974762e-01f, -4.28687930e-01f, -4.24715340e-01f, -2.47838169e-01f, -1.28871620e-01f, 1.36388555e-01f,
  -1.48124062e-02f, 6.35263138e-03f, 1.23188779e-01f, -5.23052402e-02f, -1.40115514e-01f, -7.29123596e-03f, -6.84558973e-02f, 2.10941285e-02f, -2.60262907e-01f, -2.00707272e-01f,
  -1.60030201e-01f, 5.35596497e-02f, 1.98005408e-01f, -1.04690507e-01f, 1.59060404e-01f, -1.34707898e-01f, 2.73149878e-01f, 2.14358240e-01f, 1.11933008e-01f, 3.81009012e-01f,
  3.83260787e-01f, 4.25477535e-01f, -2.76148200e-01f, -9.31024477e-02f, 1.17149092e-01f, 1.94062591e-02f, 2.58040596e-02f, 1.13768503e-02f, 4.50182753e-03f, -1.22698508e-02f,
  -2.38213539e-02f, -4.20845598e-02f, -7.82975778e-02f, -8.08635950e-02f, -7.01662526e-02f, -8.53886306e-02f, 5.56453727e-02f, -3.65861394e-02f, -1.09027755e-02f, -4.73118126e-02f,
  -2.04675868e-01f, -1.00910580e-02f, 1.32802531e-01f, -2.56980836e-01f, -5.24410121e-02f, -9.93449613e-03f, 3.72579545e-02f, 1.79064825e-01f, 3.25280009e-03f, 2.23510116e-01f,
  -6.97730407e-02f, -2.42356900e-02f, 9.50772390e-02f, 7.47562712e-03f, -7.32670277e-02f, 1.04205823e-02f, 1.41581958e-02f, -1.37007445e-01f, -1.41539156e-01f, -4.48928475e-02f,
  -3.89569029e-02f, 3.21633704e-02f, -6.38690367e-02f, 3.50025408e-02f, -1.69943068e-02f, 3.51754427e-02f, -4.02801521e-02f, 9.15792305e-03f, 5.27702384e-02f, 7.44197238e-03f,
  -1.02121964e-01f, 7.63034299e-02f, 1.16339803e-01f, 6.78904802e-02f, 3.40326835e-04f, 2.50606779e-02f, 1.00073218e-02f, 3.49786729e-02f, 1.37874559e-01f, 1.47107303e-01f,
  -1.56119362e-01f, -3.32745761e-01f, -9.15931258e-03f, -4.23244908e-02f, 7.82262832e-02f, -3.97995450e-02f, 1.04838930e-01f, 2.37813853e-02f, 1.06970772e-01f, 4.42052968e-02f,
  -3.79157402e-02f, 1.22398384e-01f, 1.33470874e-02f, -1.15910038e-01f, -5.96339367e-02f, 7.35608442e-03f, -5.50883114e-02f, -1.14145465e-01f, -1.55447543e-01f, 6.96727484e-02f,
  -1.80972457e-01f, -1.89176604e-01f, -2.24387005e-01f, -4.63379622e-02f, -3.23056392e-02f, -1.52312160e-01f, -1.48618624e-01f, -2.82765590e-02f, -1.96608678e-01f, -1.22937597e-01f,
  4.80675787e-01f, -5.29152751e-02f, 5.40690541e-01f, 2.25328386e-01f, 2.62464792e-01f, 3.61099154e-01f, 2.48071849e-01f, -2.12195888e-02f, 9.80456769e-02f, 2.37355046e-02f,
  1.03571802e-01f, -1.37827536e-02f, -1.41927078e-01f, -4.38806228e-02f, -1.12845898e-02f, -6.99574202e-02f, -5.92802763e-02f, 1.83384474e-02f, 2.50897378e-01f, 1.89627305e-01f,
  -1.22493006e-01f, -8.98410901e-02f, 4.57592234e-02f, -1.47666246e-01f, -3.11494395e-02f, -9.70356911e-02f, 1.77827068e-02f, 7.93427527e-02f, 1.14422776e-02f, -2.80979782e-01f,
  5.88358641e-01f, 4.43975657e-01f, -3.58427949e-02f, -8.57575685e-02f, 1.80205345e-01f, 9.30821374e-02f, 1.14226922e-01f, 2.41047572e-04f, 3.28541063e-02f, -2.29495671e-03f,
  1.55259803e-01f, -1.67569909e-02f, -3.60061340e-02f, -2.03758553e-02f, 2.26607989e-03f, 3.14962678e-02f, -5.07997200e-02f, -7.86621422e-02f, 9.00485367e-02f, 6.29493296e-02f,
  -1.27361789e-01f, 9.20747872e-03f, 1.47853762e-01f, -2.63297893e-02f, -7.17297895e-03f, -9.58206318e-03f, 3.63558680e-02f, -1.45586031e-02f, 9.94868875e-02f, -6.41903430e-02f,
  -4.22447883e-02f, -1.27421737e-01f, 2.46186629e-01f, -6.89316839e-02f, -5.74550405e-02f, -4.42312937e-03f, -1.83174126e-02f, -1.29467547e-02f, -2.46631920e-01f, -9.11375955e-02f,
  -1.36419401e-01f, 8.53989795e-02f, 2.86605433e-02f, 4.78560999e-02f, -6.55831024e-03f, 9.58631635e-02f, 1.86000213e-01f, 5.37737720e-02f, -1.17814802e-02f, -1.10634491e-02f,
  8.89371336e-02f, 7.49767125e-02f, 1.04836032e-01f, -1.43940717e-01f, -6.05318807e-02f, 1.28145769e-01f, 3.35800573e-02f, -3.55366096e-02f, -5.81127331e-02f, -9.50227492e-03f,
  2.14953944e-01f, 2.49228522e-01f, -1.54545397e-01f, -1.35684133e-01f, 1.84002519e-01f, 8.86674970e-02f, 6.75355569e-02f, -3.48286075e-03f, 5.02966158e-02f, 9.62078199e-02f,
  2.24046692e-01f, 2.82248352e-02f, -1.45813003e-01f, -1.34208590e-01f, -8.86367634e-02f, 4.64224480e-02f, 4.18677181e-02f, 8.54509324e-02f, 1.03097931e-02f, 2.31824532e-01f,
  1.76403448e-02f, 2.90291905e-02f, 8.37305933e-02f, -1.16866054e-02f, 1.92628607e-01f, 1.76105633e-01f, 1.45156875e-01f, 1.75435945e-01f, 2.68360853e-01f, -1.10934608e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 20)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 20;
const float L0_fan_Bp_bar_data[] = {
  -5.23193553e-02f, 3.27769756e-01f, 6.33908138e-02f, 2.31763557e-01f, 2.52684325e-01f, 9.66278166e-02f, -6.10545948e-02f, 1.09509295e-02f, 5.81351779e-02f, 1.74650475e-02f,
  -3.31765227e-03f, -1.11282818e-01f, -2.32074916e-01f, 2.95464516e-01f, 2.23421201e-01f, 6.85198279e-03f, 1.44343734e-01f, 2.51270264e-01f, 1.21940143e-01f, 3.34122062e-01f
};

// L1_fan_Wp (Shape: 6 x 32)
const int L1_fan_Wp_rows = 6;
const int L1_fan_Wp_cols = 32;
const float L1_fan_Wp_data[] = {
  -6.15575612e-02f, -1.34116843e-01f, 2.08804794e-02f, -2.84579936e-02f, 1.34320736e-01f, 5.25564663e-02f, 5.62521964e-02f, -2.38047820e-03f, 1.01840841e-02f, -1.17991425e-01f,
  -1.82257756e-03f, -1.93688199e-01f, 1.53860375e-01f, -2.54816413e-01f, 2.59286109e-02f, 7.71901512e-04f, -1.60556823e-01f, 1.24014452e-01f, -4.30463105e-02f, 6.32613897e-02f,
  1.48874044e-01f, 4.59354632e-02f, 3.17999214e-01f, -6.54968321e-02f, 8.67175236e-02f, 3.88989866e-01f, 1.50131494e-01f, -4.56040591e-01f, -1.09153278e-02f, -1.64951205e-01f,
  3.97483617e-01f, 1.79066733e-01f, 5.87561056e-02f, -2.39161663e-02f, -6.39718666e-04f, 1.82984501e-01f, -1.78876594e-02f, -1.31860971e-01f, 1.37325332e-01f, 4.03445102e-02f,
  -8.97388384e-02f, 1.37812033e-01f, -1.54686496e-01f, 2.37668511e-02f, 1.56260625e-01f, 1.75544307e-01f, -8.54046792e-02f, 1.60859391e-01f, -9.96084884e-02f, -6.98389485e-02f,
  -2.33482093e-01f, 1.58689842e-01f, 1.12768844e-01f, 3.80216151e-01f, -5.25734127e-01f, -2.27056608e-01f, 1.15894459e-01f, -2.55545601e-02f, -5.07012069e-01f, -3.46599370e-01f,
  1.39857503e-02f, 1.12755045e-01f, 3.92620385e-01f, 5.51573820e-02f, 7.69586787e-02f, -7.47949034e-02f, 1.94084644e-01f, -2.95323431e-01f, 9.16241780e-02f, 2.25075513e-01f,
  2.93318719e-01f, -2.13250834e-02f, -1.70629039e-01f, -6.98788688e-02f, 7.39192069e-02f, -2.03338370e-01f, -6.71408791e-03f, 1.32898673e-01f, -5.00826091e-02f, 4.37349796e-01f,
  2.72851139e-01f, -1.28087506e-01f, -2.10324869e-01f, -2.81318516e-01f, 1.71003416e-01f, -2.11048797e-01f, -1.49469912e-01f, 8.19601119e-02f, -1.48424253e-01f, 2.38125816e-01f,
  1.73354387e-01f, -1.23807356e-01f, -3.86444002e-01f, 3.29623856e-02f, 1.07583359e-01f, 3.50614563e-02f, -7.10179284e-02f, -8.73863548e-02f, -5.70124239e-02f, -1.47578865e-01f,
  -3.90447825e-02f, -6.63049743e-02f, 6.55824617e-02f, 1.01909995e-01f, 9.35895666e-02f, 8.40869993e-02f, 6.41212761e-02f, -5.41013367e-02f, 3.98784168e-02f, -1.01470932e-01f,
  1.00396268e-01f, 1.16543867e-01f, -2.35120401e-01f, 1.33803815e-01f, -1.67585034e-02f, -3.63210626e-02f, 2.72360407e-02f, 7.24576861e-02f, -3.09053093e-01f, -1.30519733e-01f,
  -7.43661374e-02f, 3.24071735e-01f, -4.17919606e-01f, -4.30489331e-01f, -2.45410219e-01f, -3.07846349e-02f, 4.94649887e-01f, 1.72527358e-01f, 3.11900694e-02f, -6.26591919e-03f,
  -7.67020434e-02f, -1.39340814e-02f, 6.98738992e-02f, -1.37500748e-01f, 1.49603814e-01f, 1.19372472e-01f, -5.05041033e-02f, 5.66496365e-02f, 2.30608322e-02f, -1.16659291e-01f,
  2.19598278e-01f, -2.75273472e-02f, 1.01311475e-01f, 3.30463916e-01f, -1.46776125e-01f, 7.09570572e-02f, -8.58989954e-02f, 9.05661937e-03f, 6.42514303e-02f, -1.95942242e-02f,
  -1.93714157e-01f, -3.13314199e-01f, 3.02170634e-01f, 3.09243172e-01f, -2.67453253e-01f, -3.49295855e-01f, -2.00836375e-01f, -6.33593053e-02f, 1.41828537e-01f, -3.09618741e-01f,
  2.07245555e-02f, -2.88182888e-02f, 4.77053151e-02f, -1.09026462e-01f, 1.68523401e-01f, 1.40797704e-01f, 2.73857445e-01f, -2.63859471e-03f, -1.56749174e-01f, -2.18344018e-01f,
  -2.03266442e-01f, 2.86705885e-02f, -2.08094344e-01f, 1.13563783e-01f, 1.26871273e-01f, 4.82851863e-01f, -1.91149786e-01f, -1.65122062e-01f, 2.36649975e-01f, -1.53269008e-01f,
  -1.23975746e-01f, -4.43106949e-01f, 2.40064964e-01f, 3.56878079e-02f, -3.94199431e-01f, 3.07700992e-01f, 1.90385312e-01f, -1.03606284e-01f, -4.37984616e-01f, 1.35947675e-01f,
  -3.45564276e-01f, -2.77141277e-02f
};

// L1_fan_Wp_bar (Shape: 20 x 32)
const int L1_fan_Wp_bar_rows = 20;
const int L1_fan_Wp_bar_cols = 32;
const float L1_fan_Wp_bar_data[] = {
  -4.77059186e-02f, 3.51661108e-02f, 1.35519147e-01f, -1.45691827e-01f, 1.35706486e-02f, 1.53779127e-02f, -7.43451193e-02f, -1.82837561e-01f, 2.46771723e-01f, 2.51678779e-04f,
  1.76013876e-02f, 1.59036592e-01f, 3.06413859e-01f, 5.11797130e-01f, -1.02603056e-01f, -2.69067049e-01f, 4.02765393e-01f, -6.12637736e-02f, 1.01540461e-01f, 3.12152449e-02f,
  3.10898334e-01f, 6.99858293e-02f, -4.74691540e-01f, 1.80704579e-01f, 1.96447998e-01f, -5.82303898e-03f, 2.11888507e-01f, 5.21789724e-03f, 1.93788707e-01f, -9.91708785e-02f,
  1.40779182e-01f, -9.11211595e-02f, -5.32648116e-02f, 1.16399430e-01f, -1.05560506e-02f, 3.32807690e-01f, 1.81175277e-01f, 1.52319029e-01f, 3.18363011e-02f, 1.13281436e-01f,
  1.09984666e-01f, -4.69589010e-02f, 4.84729223e-02f, -8.23389832e-03f, 4.96002555e-01f, 1.54984877e-01f, 1.39463544e-01f, -2.19399288e-01f, 8.28501433e-02f, -1.00728519e-01f,
  -3.71947765e-01f, 3.74723077e-01f, -5.33369705e-02f, 3.57298613e-01f, -2.31073782e-01f, 2.01157451e-01f, 5.57712436e-01f, -3.60358208e-01f, -9.17034522e-02f, 5.91777712e-02f,
  3.29856843e-01f, 2.06812844e-01f, 3.76302660e-01f, 5.41050918e-02f, 1.46563858e-01f, -7.53448829e-02f, 3.54639255e-02f, 6.37872368e-02f, 1.26143828e-01f, 5.52234612e-02f,
  -1.81135714e-01f, -3.54034528e-02f, -2.20642120e-01f, -1.04245327e-01f, 1.03359424e-01f, 1.06227033e-01f, 2.95364290e-01f, -4.27263826e-01f, 1.19179405e-01f, 5.22368141e-02f,
  -5.66716909e-01f, 1.75128683e-01f, 4.15729105e-01f, 3.00825030e-01f, 7.58776665e-02f, 3.12158149e-02f, 5.37899077e-01f, 1.69370994e-01f, 1.70148581e-01f, 1.02214016e-01f,
  1.31999537e-01f, -1.34395242e-01f, 2.55837053e-01f, -1.52458340e-01f, -2.53253341e-01f, 3.08498502e-01f, 1.37313008e-01f, 3.56307477e-01f, -9.92649719e-02f, -9.34805870e-02f,
  2.05882192e-01f, 2.16482297e-01f, -7.74746612e-02f, -8.20421800e-03f, -2.62526631e-01f, 3.26489955e-02f, -7.96006471e-02f, 3.82783189e-02f, -2.93673147e-02f, 7.13320002e-02f,
  2.75660545e-01f, 2.88669527e-01f, 1.30742237e-01f, 1.25828966e-01f, 2.34377146e-01f, 2.41910592e-01f, -4.50131446e-02f, 1.25353724e-01f, 3.09575409e-01f, -1.09767564e-01f,
  -3.49637359e-01f, 3.13921481e-01f, 2.96588480e-01f, 3.02300394e-01f, 4.87438627e-02f, 3.01043332e-01f, -2.06624359e-01f, -2.92160034e-01f, -7.97336251e-02f, 4.40431051e-02f,
  -3.87990917e-03f, -3.01925205e-02f, 1.00382097e-01f, 7.53188208e-02f, -4.14007977e-02f, 8.72702226e-02f, 3.93287003e-01f, -3.55376154e-02f, 1.68437406e-01f, -2.09946230e-01f,
  4.27776724e-02f, 1.33594841e-01f, -2.47890905e-01f, -2.15190649e-01f, 1.59916729e-01f, 2.30155051e-01f, 2.18010470e-01f, 2.63952047e-01f, 2.97032595e-01f, 1.50080785e-01f,
  -1.54033124e-01f, -9.83377919e-02f, 3.58388536e-02f, 1.50260493e-01f, -2.31395334e-01f, -2.33892187e-01f, -9.24615934e-02f, -5.23146093e-02f, 5.88388562e-01f, 4.52829041e-02f,
  1.10947862e-01f, 6.38489649e-02f, 2.55199343e-01f, 2.26805329e-01f, 9.79897976e-02f, 2.03159019e-01f, -1.98766053e-01f, -9.99813601e-02f, 6.23829305e-01f, 1.99762031e-01f,
  2.90990144e-01f, 6.66158944e-02f, 4.77227986e-01f, 4.77559566e-01f, -1.93943143e-01f, -4.45892185e-01f, 2.12497339e-01f, 3.86349678e-01f, -3.33467424e-02f, 2.27372780e-01f,
  2.28294089e-01f, 9.75579917e-02f, -3.46124828e-01f, -2.68322706e-01f, 5.48522115e-01f, -3.12038846e-02f, -5.82281034e-03f, 5.54989651e-02f, 1.32713154e-01f, -1.28428802e-01f,
  4.06719118e-01f, -3.08911353e-01f, 4.31947000e-02f, 9.31162983e-02f, 1.44317552e-01f, 2.49868348e-01f, 1.40159100e-01f, 1.28431261e-01f, -2.81314249e-03f, -2.38029677e-02f,
  -2.13328734e-01f, 1.00619316e-01f, -9.16936025e-02f, -2.35067382e-02f, 4.60829049e-01f, -1.71109021e-01f, 1.81296840e-01f, 1.52638748e-01f, -5.87818444e-01f, 2.93603837e-01f,
  2.69050628e-01f, 3.71384561e-01f, 1.97014958e-01f, 2.13443875e-01f, 1.59094661e-01f, -8.04672688e-02f, 2.35404238e-01f, 2.41187871e-01f, -9.68871042e-02f, -2.88448185e-02f,
  4.66159493e-01f, 1.00163423e-01f, 1.16764635e-01f, -6.28833659e-03f, 2.86395013e-01f, 1.14906132e-01f, 1.34829938e-01f, 1.89651862e-01f, 1.14537194e-01f, -5.52878007e-02f,
  -2.47325301e-02f, -1.09957002e-01f, -2.43891224e-01f, 1.77453771e-01f, -9.84885618e-02f, 2.84465045e-01f, 3.03761899e-01f, -2.30641007e-01f, 3.23097795e-01f, 4.03323114e-01f,
  -3.05811554e-01f, -3.31097171e-02f, 2.17066824e-01f, 4.30501550e-01f, 2.53202736e-01f, 3.05870682e-01f, 6.46748543e-02f, 8.93605053e-02f, 1.42853990e-01f, -3.64651568e-02f,
  -3.08556557e-01f, 6.67768866e-02f, 1.30723342e-01f, 4.08121258e-01f, 8.64489656e-03f, -2.48104230e-01f, 2.58803964e-01f, 1.99572191e-01f, 2.21133724e-01f, 1.30447537e-01f,
  2.35711604e-01f, 1.23748049e-01f, -2.75170505e-01f, 1.26438262e-02f, 1.21190771e-01f, 9.89049394e-03f, 4.63538580e-02f, 1.33846663e-02f, 4.14774656e-01f, -4.91122529e-02f,
  -2.59488046e-01f, -2.06429511e-01f, -9.69356596e-02f, -1.73461303e-01f, -2.46284798e-01f, 3.45838577e-01f, -1.43231899e-01f, -1.77494101e-02f, -3.46132249e-01f, -7.27098882e-02f,
  5.07453263e-01f, -5.53165793e-01f, 3.15828651e-01f, 5.22445083e-01f, 2.36666545e-01f, 2.32776463e-01f, 2.78332740e-01f, 1.95984021e-01f, 1.31014526e-01f, 9.69721898e-02f,
  -9.06772912e-02f, -2.30617508e-01f, 1.18424758e-01f, 1.96982354e-01f, -2.31375277e-01f, 2.44964182e-01f, -6.80663213e-02f, 2.82508373e-01f, 2.86611795e-01f, 2.79810335e-02f,
  9.70359966e-02f, -2.25880101e-01f, 2.69307047e-01f, 4.41447608e-02f, 3.31581794e-02f, 3.93059194e-01f, 2.95625240e-01f, 2.36330971e-01f, 4.33821082e-02f, -4.25801724e-02f,
  4.85162675e-01f, -1.14900127e-01f, -3.98828208e-01f, 1.34114459e-01f, 1.52448207e-01f, 1.01453990e-01f, -1.55585930e-01f, 2.29251664e-02f, 3.20378423e-01f, -2.18830094e-01f,
  8.86531323e-02f, 2.29762942e-02f, 4.81924936e-02f, -1.93572983e-01f, 5.41419815e-03f, 9.86004695e-02f, -1.85883492e-01f, 3.78036201e-02f, 8.91296938e-02f, 3.00164551e-01f,
  -1.99769765e-01f, -9.80188847e-02f, 3.85007352e-01f, -2.70964772e-01f, 4.81256038e-01f, -5.57362735e-02f, 1.22980237e-01f, 3.83582115e-02f, -2.10436538e-01f, 4.62147087e-01f,
  -2.09372625e-01f, 4.65806723e-01f, -2.72618443e-01f, -2.18190372e-01f, -1.61531627e-01f, -1.56931385e-01f, -1.12694636e-01f, 2.51878947e-01f, 2.25491881e-01f, 4.61048484e-01f,
  3.00063282e-01f, 7.10515827e-02f, 3.33948493e-01f, 1.24245323e-02f, -1.10480353e-01f, 1.03596032e-01f, 6.58296943e-02f, 5.88697307e-02f, -5.99141978e-03f, 5.91831617e-02f,
  -2.23885745e-01f, 2.13233948e-01f, 2.94954032e-02f, -2.20177948e-01f, 3.21051478e-01f, -2.29425311e-01f, 4.53403145e-01f, 1.68763414e-01f, -2.41820633e-01f, 1.26350299e-01f,
  -9.93119031e-02f, 3.99405539e-01f, -3.29571143e-02f, 2.79650599e-01f, 1.36769310e-01f, -2.81786531e-01f, 3.29541005e-02f, 2.37239167e-01f, 1.31394014e-01f, -1.18975779e-02f,
  2.11452678e-01f, 4.28203732e-01f, 1.34122550e-01f, -1.88204631e-01f, 4.65683127e-03f, -6.10793754e-02f, -8.58251825e-02f, 5.19795001e-01f, -3.53030741e-01f, -2.49107361e-01f,
  3.39185307e-03f, -1.35368422e-01f, -2.75209993e-01f, 5.92150539e-03f, -9.91063565e-03f, 2.80455947e-01f, -1.67525411e-01f, 2.39548117e-01f, -4.40635197e-02f, -1.42213702e-01f,
  -2.23228514e-01f, 8.37836191e-02f, -7.81453028e-02f, 9.13043991e-02f, 1.06245160e-01f, 2.53872752e-01f, 2.70975560e-01f, -1.33950099e-01f, 4.27976213e-02f, -3.70676130e-01f,
  -2.73853898e-01f, 4.48589742e-01f, 6.00797459e-02f, -1.21273659e-01f, -3.86401206e-01f, -2.63968349e-01f, 2.01203153e-01f, -3.65684852e-02f, 1.90892950e-01f, -1.69266399e-03f,
  -8.13036051e-04f, 2.72074435e-02f, 1.63381338e-01f, 1.01508433e-02f, -3.26423645e-02f, 1.30642682e-01f, -1.93634316e-01f, -1.01449162e-01f, -2.71105856e-01f, 5.95433749e-02f,
  1.80481657e-01f, 1.98793665e-01f, 2.47259513e-01f, 6.36188388e-02f, 2.11462125e-01f, 3.67016345e-03f, 1.77950622e-03f, 5.03247492e-02f, 4.79824394e-01f, 1.38502941e-01f,
  -4.65983808e-01f, 4.80584323e-01f, 2.12209970e-01f, 8.45624506e-02f, -2.65495628e-02f, 1.61653504e-01f, -1.07342653e-01f, 1.53899595e-01f, 1.09839514e-01f, -1.32530510e-01f,
  2.14865319e-02f, -9.46658403e-02f, 2.87967116e-01f, 2.35087022e-01f, 2.58300841e-01f, -3.22154373e-01f, 1.21340245e-01f, -8.69020149e-02f, -2.01243430e-01f, -5.32436892e-02f,
  6.58567846e-02f, 3.02875936e-01f, -2.89754421e-01f, 4.02409673e-01f, 5.30718088e-01f, 2.96571590e-02f, 8.53239819e-02f, -2.24746689e-01f, 4.85536754e-01f, -5.41199557e-02f,
  -4.91174795e-02f, -2.45073900e-01f, 8.32558572e-02f, 3.12539786e-01f, -5.37098385e-02f, -1.65787175e-01f, -9.52206776e-02f, 1.03653617e-01f, 2.04890236e-01f, -9.44971219e-02f,
  2.21035872e-02f, -1.03883997e-01f, -6.40977770e-02f, 3.32043916e-02f, -1.90002974e-02f, 1.26192551e-02f, 3.03347319e-01f, -2.13435609e-02f, 1.25214964e-01f, -2.05030069e-01f,
  1.34915821e-02f, -3.08987260e-01f, -1.51455775e-01f, 3.35622430e-01f, -5.26343465e-01f, -1.66735783e-01f, 1.19627200e-01f, 1.00581497e-01f, -2.83756465e-01f, -3.73869807e-01f,
  1.19642600e-01f, -2.32431442e-02f, 2.32852221e-01f, -5.90234026e-02f, 1.99527919e-01f, 2.96612263e-01f, 4.16311860e-01f, -1.59382164e-01f, -1.30171359e-01f, -4.04920638e-01f,
  4.03799117e-01f, 1.86078206e-01f, 2.26633325e-01f, -1.82975475e-02f, -9.45135858e-03f, 9.84128714e-02f, 3.43808644e-02f, 1.88564777e-01f, 1.56935677e-01f, 7.25584552e-02f,
  -7.71864578e-02f, -1.82034284e-01f, -6.59201294e-02f, -4.89154071e-01f, -1.62762597e-01f, 3.68854642e-01f, -4.87971157e-02f, 4.80776072e-01f, 5.82590520e-01f, 3.26604433e-02f,
  -1.15872979e-01f, -2.94983774e-01f, 3.09992403e-01f, 1.59355924e-02f, -4.09410615e-03f, 8.82763937e-02f, -2.26905555e-01f, 2.58316070e-01f, 1.38580382e-01f, 3.47002931e-02f,
  -2.97211945e-01f, 1.30816653e-01f, 2.32668385e-01f, -6.40551597e-02f, 2.85971141e-03f, 2.18054857e-02f, -5.51255569e-02f, -1.02044577e-02f, 8.90101958e-03f, -5.57428449e-02f,
  -2.68914193e-01f, -1.43850207e-01f, -7.15870336e-02f, -1.27890892e-02f, 8.29166025e-02f, -1.07658193e-01f, -2.29871348e-01f, 3.45968962e-01f, -1.37830153e-01f, 1.07319035e-01f,
  6.29914403e-01f, -2.79885709e-01f, -1.01271540e-01f, -1.73453018e-01f, -4.23514605e-01f, 1.04021162e-01f, 1.72955152e-02f, 2.67492980e-01f, -1.73422381e-01f, -7.34104440e-02f,
  4.11169492e-02f, 2.78415799e-01f, -1.83800962e-02f, -6.27283007e-02f, -1.46518365e-01f, 1.81216076e-01f, -4.16266322e-02f, 2.13086829e-01f, -1.17700756e-01f, -1.12901494e-01f,
  1.07015103e-01f, -4.23441306e-02f, -2.88028475e-02f, 1.93897456e-01f, -4.27760631e-02f, -1.33565336e-01f, 1.27419382e-01f, -4.89859283e-03f, 1.55095965e-01f, -2.08231077e-01f,
  1.93405285e-01f, 3.49138618e-01f, 5.62094525e-02f, 3.45861763e-02f, 1.33832142e-01f, 4.04789925e-01f, -1.34513348e-01f, 2.20371485e-01f, 5.54735601e-01f, 1.46489963e-01f,
  -1.62083507e-01f, 3.55598778e-01f, 5.81618138e-02f, -2.02239573e-01f, 2.39159614e-01f, 4.61868905e-02f, 4.59455885e-02f, 1.64062098e-01f, 1.56914979e-01f, -6.65521771e-02f,
  1.37521610e-01f, -1.77508593e-01f, -1.39838438e-02f, 2.97840219e-02f, 1.52524471e-01f, 4.24624920e-01f, 2.12652329e-02f, -1.02504194e-01f, 2.48155370e-01f, -4.92809057e-01f,
  6.99830428e-02f, 1.30289584e-01f, -3.84626418e-01f, -1.62897721e-01f, -2.08652228e-01f, 1.30058825e-01f, -7.36845061e-02f, -2.67851781e-02f, 1.00076897e-02f, 3.01775523e-02f,
  1.36776835e-01f, -3.70945185e-02f, 1.76736712e-01f, -2.66101956e-02f, -5.17133139e-02f, -1.99284062e-01f, -6.29210353e-01f, -3.64682853e-01f, 4.35415417e-01f, 5.28696999e-02f
};

// L1_fan_Bp_bar (Shape: 1 x 20)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 20;
const float L1_fan_Bp_bar_data[] = {
  3.03057969e-01f, 2.92893767e-01f, -1.49030417e-01f, 1.41286463e-01f, 6.31673867e-03f, 4.13566798e-01f, 1.75093636e-01f, 1.59389243e-01f, 1.88259501e-02f, -6.63138032e-02f,
  9.32156071e-02f, 1.28162012e-01f, 1.80542409e-01f, 8.79624858e-02f, 2.22528309e-01f, 1.91167787e-01f, 2.89034992e-01f, -1.62032709e-01f, -1.50015831e-01f, 2.22400218e-01f
};

// L2_fan_Wp (Shape: 6 x 32)
const int L2_fan_Wp_rows = 6;
const int L2_fan_Wp_cols = 32;
const float L2_fan_Wp_data[] = {
  -1.14904799e-01f, -2.72106498e-01f, 2.21680060e-01f, -2.58112311e-01f, -2.71657288e-01f, 3.26953351e-01f, -5.63409477e-02f, -6.62499905e-01f, 2.14832664e-01f, 5.02800085e-02f,
  -3.74899447e-01f, 3.88498992e-01f, -2.68841181e-02f, -1.37004614e-01f, 1.48614958e-01f, 1.18953720e-01f, -8.79877284e-02f, -1.56267211e-02f, -1.74168706e-01f, -7.56312981e-02f,
  -3.30518633e-02f, 2.61979222e-01f, 5.07608950e-02f, -1.01374939e-01f, -3.48279238e-01f, 1.35509476e-01f, -2.74920434e-01f, -2.78332960e-02f, -1.19616710e-01f, 9.81375128e-02f,
  1.39414877e-01f, 8.04385617e-02f, -9.53401774e-02f, -1.57639340e-01f, -3.44136149e-01f, 6.14721794e-03f, -8.89561176e-02f, 1.09884672e-01f, -1.46861836e-01f, -3.14399153e-02f,
  1.45003796e-01f, -1.79095846e-02f, -2.93832153e-01f, -1.74822584e-02f, 4.68144476e-01f, 4.48835604e-02f, -2.80713260e-01f, -7.10353851e-02f, -1.21760689e-01f, 5.71086351e-03f,
  -1.67912856e-01f, 4.04978208e-02f, -2.59688962e-02f, -1.90232769e-01f, 1.93335097e-02f, -1.67826444e-01f, 4.87435609e-02f, -5.93597293e-02f, 1.50365651e-01f, 8.85526389e-02f,
  1.31501406e-01f, 9.89619717e-02f, -1.59900874e-01f, 4.14816402e-02f, 1.23080350e-01f, 6.04962464e-03f, -1.51657248e-02f, -5.93145341e-02f, -7.85433725e-02f, 1.94638968e-01f,
  1.48106277e-01f, -6.35809377e-02f, 4.69376087e-01f, -2.61267543e-01f, -1.20908193e-01f, 3.29836071e-01f, -3.01158011e-01f, 6.30482659e-02f, 1.41946763e-01f, 1.84545293e-01f,
  7.00724497e-02f, -3.51464152e-01f, -1.19368881e-02f, -1.95318505e-01f, 5.94296977e-02f, -1.33083547e-02f, -1.28738701e-01f, 8.73227045e-02f, 9.42149609e-02f, 9.45397280e-03f,
  -1.03146538e-01f, 2.65634477e-01f, -3.38864885e-02f, 3.62569422e-01f, 1.72822267e-01f, -9.09663737e-02f, -1.16221726e-01f, -2.31343225e-01f, 1.06359757e-01f, -1.13946341e-01f,
  -2.45334104e-01f, -3.42232175e-02f, 1.71673417e-01f, -4.39134657e-01f, -2.08309609e-02f, 4.51714359e-02f, -4.16942835e-01f, -1.43213853e-01f, -2.65435167e-02f, 1.81061432e-01f,
  -2.09528059e-02f, 6.49614185e-02f, -5.99650517e-02f, 8.74286070e-02f, -5.20050004e-02f, 2.71562627e-03f, 1.36894763e-01f, 3.94192100e-01f, 1.41447261e-01f, 7.04903081e-02f,
  8.06547925e-02f, -2.47247800e-01f, -3.48273702e-02f, -2.85319746e-01f, 1.54335067e-01f, -1.86413050e-01f, -1.67986229e-01f, 1.43446535e-01f, 4.49961156e-01f, 2.91459352e-01f,
  -1.07674114e-02f, 5.08861780e-01f, 1.38266787e-01f, -1.41602218e-01f, 5.24984822e-02f, 6.15124524e-01f, 1.22137658e-01f, 1.91712245e-01f, 5.95272243e-01f, -2.13720351e-01f,
  9.02832672e-02f, 1.79565907e-01f, -5.54748764e-03f, -3.04396957e-01f, -1.59787863e-01f, 6.17086925e-02f, -1.07555896e-01f, 3.72443162e-02f, 9.61677060e-02f, -1.46601871e-01f,
  -8.31217156e-04f, 1.46197021e-01f, -1.37174368e-01f, -2.28006005e-01f, -7.93473944e-02f, 2.57674102e-02f, 8.73041973e-02f, -3.37146185e-02f, -2.05379963e-01f, -8.07979405e-02f,
  -8.89644772e-02f, 2.05948368e-01f, 1.76310599e-01f, 6.06572665e-02f, 5.43533325e-01f, 4.30688851e-06f, 1.76243424e-01f, -9.62079838e-02f, -6.29571900e-02f, -2.43233629e-02f,
  1.97055399e-01f, 1.12174149e-03f, 3.58094215e-01f, -1.91187084e-01f, -4.86548580e-02f, -1.52169824e-01f, -2.85778567e-02f, 2.13383764e-01f, -3.55233178e-02f, -1.81320950e-01f,
  -2.04879522e-01f, -9.84186158e-02f, -1.17691599e-01f, 5.36420345e-02f, -3.15772835e-03f, -1.78565517e-01f, 2.13319778e-01f, 7.24247843e-02f, -7.49859959e-02f, -3.56249839e-01f,
  -1.88385338e-01f, 7.65318004e-03f
};

// L2_fan_Wp_bar (Shape: 20 x 32)
const int L2_fan_Wp_bar_rows = 20;
const int L2_fan_Wp_bar_cols = 32;
const float L2_fan_Wp_bar_data[] = {
  1.11855008e-02f, 3.93896326e-02f, 9.67283994e-02f, -2.10921317e-02f, -3.78476107e-03f, -2.03357898e-02f, 4.47992086e-02f, 8.52871407e-03f, 2.67581884e-02f, 3.43160778e-02f,
  -1.16060609e-02f, -8.28696564e-02f, -5.80303781e-02f, -8.65021124e-02f, 1.23051405e-02f, -1.40492255e-02f, -2.42237584e-03f, 1.75890559e-03f, 6.98151812e-02f, -4.89993617e-02f,
  -6.16060607e-02f, -9.27126873e-03f, -6.74024299e-02f, -1.82826240e-02f, 3.75161394e-02f, -2.90171094e-02f, -1.21115297e-02f, -1.99129581e-02f, -7.70444945e-02f, -6.43233210e-02f,
  -3.10112461e-02f, 2.09178533e-02f, 1.90013647e-01f, 2.14372337e-01f, -2.18779907e-01f, 2.70062417e-01f, -6.25503659e-02f, 1.56796396e-01f, 5.25577009e-01f, 3.89443338e-01f,
  5.47042251e-01f, 1.19087011e-01f, -1.71565264e-01f, 1.80923641e-01f, 3.46635804e-02f, 2.87541837e-01f, -1.78050101e-01f, -2.29640156e-01f, 2.06627324e-02f, -2.89192572e-02f,
  -1.15183108e-01f, -2.49716833e-01f, -7.01591969e-02f, -3.59835923e-01f, -2.26706877e-01f, -1.72411218e-01f, -2.59262264e-01f, 1.24957547e-01f, 2.59116292e-01f, 4.08364296e-01f,
  4.46884274e-01f, 1.83532104e-01f, 1.63578764e-02f, 2.92141706e-01f, -4.48942324e-03f, 8.56566876e-02f, 3.13273191e-01f, 1.58424396e-02f, -5.09975515e-02f, 7.72514343e-02f,
  7.70263970e-02f, -2.96275407e-01f, -4.73490089e-01f, -3.67765576e-01f, 1.40623957e-01f, -5.89277565e-01f, 2.67411023e-01f, -9.43850353e-02f, 2.57741123e-01f, -1.00551188e-01f,
  2.74795830e-01f, 6.98547184e-01f, 2.49313980e-01f, 1.09585300e-01f, 2.12817281e-01f, 2.72059329e-02f, -8.10602233e-02f, 1.17002569e-01f, 5.78868985e-02f, -1.40957505e-01f,
  7.92658329e-03f, 2.68513352e-01f, -1.69496998e-01f, 5.14128953e-02f, 5.82189597e-02f, 2.91705430e-01f, 5.67305624e-01f, 9.16754007e-02f, 2.52277404e-01f, 2.21402705e-01f,
  3.23168039e-01f, 2.90234573e-02f, 2.94942290e-01f, 3.29728514e-01f, 1.84697390e-01f, 5.58279395e-01f, 4.15208817e-01f, 5.75235546e-01f, -6.29909709e-03f, -1.19283050e-01f,
  1.63332969e-02f, 2.13706121e-01f, -4.51069139e-02f, -1.41994193e-01f, 2.16926426e-01f, 3.05041045e-01f, -5.31199992e-01f, 3.21317285e-01f, 1.38634667e-01f, 3.08489561e-01f,
  -5.05412281e-01f, 1.29071832e-01f, 6.56527430e-02f, -1.54552400e-01f, 2.44993374e-01f, -3.27986002e-01f, 2.45076656e-01f, -1.96629599e-01f, 6.40826702e-01f, 3.70679259e-01f,
  2.75562853e-01f, 5.50723255e-01f, 2.35919595e-01f, -9.49465185e-02f, 7.42960453e-01f, 1.85601413e-01f, 1.60283167e-02f, 5.31092405e-01f, 8.23234141e-01f, 1.18155323e-01f,
  3.21920007e-01f, 5.36167733e-02f, -4.20042090e-02f, 1.11698084e-01f, -6.71270536e-03f, 3.80043417e-01f, 9.18327868e-02f, 1.19476728e-01f, -1.23736739e-01f, -1.40449569e-01f,
  1.01292528e-01f, 1.43810650e-02f, -4.17244464e-01f, -5.61401471e-02f, 1.62450224e-01f, -1.42450288e-01f, -7.29257017e-02f, 2.96569858e-02f, 6.56901225e-02f, -6.22588545e-02f,
  -5.61742783e-01f, 6.29980043e-02f, 2.97517747e-01f, 1.52763858e-01f, -4.05679345e-01f, 1.47105023e-01f, 7.20187187e-01f, 4.20244753e-01f, 1.56091094e-01f, 1.15691662e+00f,
  2.15535939e-01f, -1.06169909e-01f, -3.21468115e-02f, 5.90567030e-02f, -1.83881726e-02f, -3.16607118e-01f, 2.54493028e-01f, 1.34122059e-01f, 1.76342174e-01f, -6.61236942e-02f,
  -1.52047649e-01f, 3.34668785e-01f, -2.24782497e-01f, -1.21181756e-01f, -6.57266974e-01f, -9.24422890e-02f, 9.22126397e-02f, 3.45935374e-01f, 1.63002804e-01f, -3.02167684e-01f,
  -1.03234276e-01f, 7.90935516e-01f, -6.86784685e-02f, 3.02526265e-01f, -2.28855330e-02f, -1.82671189e-01f, 1.56737387e-01f, 4.65337932e-02f, -4.98864651e-01f, -8.72982293e-02f,
  -5.72038054e-01f, -5.67964196e-01f, 2.09044993e-01f, -1.48321643e-01f, 6.71208277e-02f, 3.44808310e-01f, 1.60297602e-02f, 1.91772953e-01f, -1.47532359e-01f, 4.54036891e-01f,
  3.02013278e-01f, 4.83625829e-01f, 3.37587655e-01f, 1.63461864e-01f, 1.42647073e-01f, 2.38731384e-01f, 5.18493235e-01f, 2.96199787e-03f, 1.96728975e-01f, -3.21279824e-01f,
  -1.00360932e-02f, -1.81955211e-02f, -9.26602539e-03f, -4.57549989e-01f, 3.77547055e-01f, 3.00007612e-01f, 2.73059815e-01f, 3.57230872e-01f, -1.38060018e-01f, 1.52784809e-01f,
  3.84204388e-01f, -1.75070763e-01f, -8.04286227e-02f, 1.50867522e-01f, 1.15932554e-01f, -1.67255312e-01f, 3.99853736e-01f, -2.54004896e-01f, -1.97200611e-01f, 2.24818047e-02f,
  1.76712483e-01f, 2.32097954e-01f, -2.16677174e-01f, -3.84640366e-01f, -3.99008304e-01f, 4.51726280e-02f, -3.78439128e-01f, -2.88996488e-01f, -9.71799996e-03f, 2.36128513e-02f,
  1.40379697e-01f, 2.71626592e-01f, 3.56825083e-01f, 2.42518112e-01f, -2.64445767e-02f, 4.84366059e-01f, 1.06306568e-01f, -2.45517284e-01f, 4.08079922e-01f, 2.82210976e-01f,
  1.32386580e-01f, 6.85084313e-02f, 7.00173557e-01f, -3.87503430e-02f, -1.17183909e-01f, 2.82931775e-01f, -2.86165088e-01f, 2.12077856e-01f, -8.17761645e-02f, -6.86682835e-02f,
  2.83000827e-01f, 6.34805337e-02f, 2.68079400e-01f, 1.76583566e-02f, 3.18614781e-01f, -1.91660435e-03f, -2.52674222e-01f, 3.16988081e-01f, -1.37312308e-01f, 2.42864951e-01f,
  -4.24804777e-01f, 1.82595968e-01f, -8.03552270e-02f, 1.27796784e-01f, -1.08211629e-01f, -8.45645592e-02f, 2.03943297e-01f, 3.54047358e-01f, -6.36857376e-02f, 7.90657997e-02f,
  1.33670419e-01f, 1.66670635e-01f, 1.05200619e-01f, 2.86344737e-02f, 4.24517989e-02f, 5.68887830e-01f, -5.16539216e-01f, 4.67501640e-01f, 3.17715198e-01f, -7.36613929e-01f,
  -3.92094888e-02f, 3.97305220e-01f, -1.85084015e-01f, -4.35150564e-02f, 8.57429113e-03f, 4.75035250e-01f, 1.29704818e-01f, -3.15329507e-02f, 3.34447294e-01f, 7.40040094e-02f,
  3.77489835e-01f, 3.09335560e-01f, 3.44715536e-01f, -3.09053212e-01f, -2.27776289e-01f, 5.15785031e-02f, -3.51954758e-01f, -1.20198198e-01f, 1.85034275e-01f, 7.13212863e-02f,
  3.85090828e-01f, 2.06996471e-01f, 4.55686569e-01f, 4.39425468e-01f, 3.28805536e-01f, -7.47812837e-02f, 6.80065215e-01f, 1.59065962e-01f, -7.45435134e-02f, 5.96767128e-01f,
  6.05514169e-01f, -1.41050383e-01f, 5.10258116e-02f, 1.19005419e-01f, -1.34305775e-01f, 1.07831724e-01f, 1.30025059e-01f, 1.88061789e-01f, 2.73254178e-02f, 1.58458471e-01f,
  -1.14364937e-01f, 2.97631081e-02f, 1.56859189e-01f, 5.17331883e-02f, -4.22803193e-01f, -8.77253339e-02f, 1.25854164e-01f, -1.71728164e-01f, -8.68486613e-02f, 3.74103361e-03f,
  1.29456460e-01f, 1.23844035e-01f, 3.35618734e-01f, 2.23564819e-01f, 4.84364107e-02f, 3.78612101e-01f, 3.78161132e-01f, -1.10573702e-01f, -4.06052500e-01f, 2.71051347e-01f,
  2.97493841e-02f, -8.77823979e-02f, 9.94251743e-02f, 1.23698160e-01f, -6.02144636e-02f, 9.40989777e-02f, 8.09170678e-02f, 3.83573323e-01f, -1.37762919e-01f, -7.26993382e-02f,
  2.26579562e-01f, 4.58817512e-01f, -1.31621256e-01f, 2.34024853e-01f, 3.06431353e-01f, 4.14309531e-01f, 2.38251910e-01f, -8.15299228e-02f, -5.09047806e-02f, -2.18712524e-01f,
  -1.92008391e-02f, -2.00576559e-01f, -1.85522977e-02f, -3.33860993e-01f, -2.57593933e-02f, -2.59437174e-01f, 3.43016356e-01f, 1.69463828e-02f, -5.12050698e-03f, 1.76357657e-01f,
  -2.15303779e-01f, -2.28949964e-01f, 7.30442852e-02f, -8.77187103e-02f, -3.03857446e-01f, 3.62220377e-01f, -1.37703985e-01f, -5.91147952e-02f, -1.31427139e-01f, 3.17961931e-01f,
  2.87108481e-01f, -4.60890502e-01f, 5.96408732e-02f, 2.98366159e-01f, -1.82938650e-01f, 3.04432899e-01f, 5.85185409e-01f, 4.32504356e-01f, -2.37874568e-01f, 1.84925199e-01f,
  2.08465680e-01f, -1.57300994e-01f, 2.84109235e-01f, -4.95592947e-04f, 1.67664796e-01f, -4.85937111e-02f, -2.03893661e-01f, 5.02817214e-01f, 1.28827076e-02f, 8.27064365e-02f,
  2.63222158e-01f, -8.57795682e-03f, -6.78459644e-01f, 4.21578586e-01f, -4.40996498e-01f, -6.07751966e-01f, -1.34174734e-01f, -3.10944289e-01f, 1.52956203e-01f, 2.12818801e-01f,
  -2.22634628e-01f, 1.95214435e-01f, -7.35111088e-02f, 1.65389359e-01f, 1.02937840e-01f, 3.05395007e-01f, 4.01784003e-01f, -5.35330735e-03f, 2.93140382e-01f, 2.42787197e-01f,
  4.61339623e-01f, -2.86585569e-01f, -1.51803633e-02f, -2.05514714e-01f, 1.03024453e-01f, 6.38543665e-02f, 1.05234431e-02f, -2.11614504e-01f, -2.00682119e-01f, 7.29693472e-02f,
  3.28862697e-01f, 3.94989908e-01f, -1.80334330e-01f, 5.20933121e-02f, 2.45792553e-01f, 3.09358478e-01f, -1.58149347e-01f, 5.50191939e-01f, 1.87979415e-01f, -5.93467712e-01f,
  1.70539364e-01f, 3.44135791e-01f, -3.90252739e-01f, -1.80093542e-01f, 1.81961313e-01f, 5.34650981e-01f, 1.27704814e-02f, -1.17443845e-01f, 4.29152906e-01f, 1.46615714e-01f,
  1.23459876e-01f, 8.70023444e-02f, -2.66332805e-01f, -4.78061102e-02f, 1.11006014e-01f, 3.50225210e-01f, 2.29273975e-01f, -1.08371161e-01f, -1.70894638e-01f, 6.14591181e-01f,
  -2.34973058e-02f, 7.02785105e-02f, -3.67265582e-01f, -1.33549526e-01f, -1.26672134e-01f, 9.38385427e-02f, -6.96301520e-01f, 1.39895767e-01f, 1.33608222e-01f, -5.94260275e-01f,
  -1.92201242e-01f, 1.67085648e-01f, 1.12387978e-01f, 8.42321217e-02f, -2.87471503e-01f, 2.00346246e-01f, -1.84281215e-01f, 8.93229395e-02f, 3.26729156e-02f, -1.43839866e-01f,
  2.69879960e-02f, 2.02952381e-02f, 8.76567885e-02f, -1.07586652e-01f, 5.48858523e-01f, 1.52305868e-02f, 3.13921243e-01f, 2.48220325e-01f, 3.96825790e-01f, 2.11328670e-01f,
  1.38432413e-01f, 3.28588188e-02f, 6.26088977e-01f, 2.97719151e-01f, 3.90824646e-01f, 2.52781332e-01f, 3.78451794e-02f, 2.30794221e-01f, 7.33097076e-01f, 3.17009278e-02f,
  -1.65699154e-01f, 8.86231810e-02f, 4.35105711e-01f, -2.74458736e-01f, 5.24392784e-01f, 2.19461471e-02f, -5.72879240e-03f, -4.41325689e-03f, 3.30061913e-01f, 3.54371816e-01f,
  1.39162272e-01f, -7.74734244e-02f, -1.70320138e-01f, -1.08319633e-01f, -7.30548128e-02f, -3.58507372e-02f, -4.77007449e-01f, -2.04130448e-02f, 4.10947233e-01f, 4.04926389e-02f,
  2.75218517e-01f, -1.03525661e-01f, 4.29283455e-02f, 2.00073153e-01f, 2.42589846e-01f, -3.15099031e-01f, -1.44469798e-01f, -1.19055435e-01f, -1.05188638e-01f, 1.14904754e-01f,
  3.71286333e-01f, -3.57403040e-01f, 1.35258928e-01f, 2.24714875e-01f, -5.87386012e-01f, 4.83074039e-01f, 3.16603899e-01f, -5.32959774e-02f, -1.09725788e-01f, 3.29155266e-01f,
  3.62791479e-01f, 8.79215524e-02f, -1.11132041e-01f, -4.46460955e-03f, -4.89622951e-01f, 2.52336532e-01f, -1.95362475e-02f, 3.70625332e-02f, -9.44682658e-02f, 1.13739640e-01f,
  4.22168255e-01f, -1.15501329e-01f, 3.44741791e-01f, 3.81946424e-03f, 1.30907640e-01f, -1.62069753e-01f, 1.16648495e-01f, -6.13702051e-02f, -5.52496947e-02f, 1.05780371e-01f,
  6.96448311e-02f, 4.68439348e-02f, -5.33327460e-01f, 9.43537336e-03f, 2.77002305e-01f, -1.76199138e-01f, -3.42023164e-01f, 4.69823420e-01f, 2.75047004e-01f, 5.64550571e-02f,
  -3.48004431e-01f, 3.42348069e-01f, 3.01167443e-02f, 2.19198823e-01f, -1.16780505e-01f, -1.34390816e-01f, -3.03944409e-01f, 5.77178858e-02f, -1.28602562e-02f, -1.02913894e-01f,
  3.93063784e-01f, 1.83599755e-01f, 3.34233999e-01f, 1.01139374e-01f, 3.90744776e-01f, 3.33813041e-01f, -9.50638801e-02f, -2.33962193e-01f, 3.78742516e-01f, -1.42145470e-01f,
  -1.11970872e-01f, 9.01203081e-02f, 2.22118929e-01f, 4.46240827e-02f, -3.77244055e-01f, -1.56930774e-01f, 2.69854724e-01f, -6.18708432e-01f, -1.73197508e-01f, 3.95750403e-01f,
  -5.89285456e-02f, 2.72406548e-01f, 2.37592220e-01f, 2.81037778e-01f, 1.66503057e-01f, -3.70315194e-01f, 2.52619892e-01f, 3.36346887e-02f, -1.00662939e-01f, -1.10511258e-01f,
  1.02395639e-01f, 1.28004208e-01f, 2.33742177e-01f, 2.43343487e-01f, 6.61608204e-02f, 1.66268095e-01f, 2.37082973e-01f, 2.39541437e-02f, 3.60511154e-01f, -2.53976077e-01f
};

// L2_fan_Bp_bar (Shape: 1 x 20)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 20;
const float L2_fan_Bp_bar_data[] = {
  -3.35523486e-02f, 3.16590607e-01f, 7.67953647e-03f, 5.28861806e-02f, 2.74197370e-01f, 7.01055229e-02f, 2.43389547e-01f, 2.51479268e-01f, -1.04857367e-02f, -8.75457600e-02f,
  7.88886547e-02f, 6.18456900e-02f, -3.64330783e-02f, 1.30946219e-01f, 3.75565350e-01f, 1.24484666e-01f, 2.89202750e-01f, 1.52926996e-01f, 3.04935306e-01f, -1.41869085e-02f
};

// L3_fan_Wp (Shape: 6 x 32)
const int L3_fan_Wp_rows = 6;
const int L3_fan_Wp_cols = 32;
const float L3_fan_Wp_data[] = {
  -1.78515445e-02f, 2.14514330e-01f, -1.65517718e-01f, 4.32297498e-01f, 8.83020833e-02f, -5.89732118e-02f, 3.67471069e-01f, 1.24852300e-01f, 5.18459082e-01f, 1.92692295e-01f,
  2.35706061e-01f, -4.28720087e-01f, -7.74354041e-02f, -2.18931153e-01f, -5.39493933e-02f, 3.68970190e-03f, -1.03819653e-01f, 1.65364612e-02f, -1.10307053e-01f, -3.68106514e-02f,
  2.51665153e-02f, 6.28587604e-02f, -1.01114266e-01f, 2.74274826e-01f, -2.09162496e-02f, 4.63797040e-02f, -2.09189937e-01f, 2.78486684e-03f, -9.48425159e-02f, -2.16866601e-02f,
  2.31382176e-01f, 1.96802795e-01f, 1.33271039e-01f, 8.52303877e-02f, -2.18764424e-01f, -6.65480047e-02f, 2.86509991e-01f, 2.99120575e-01f, -2.23181605e-01f, -2.66492635e-01f,
  -2.35927831e-02f, -5.29695094e-01f, -8.81924555e-02f, -3.51782858e-01f, 9.84442886e-03f, -3.16197090e-02f, -9.92140025e-02f, 5.15390523e-02f, 1.95576772e-01f, 1.13612236e-02f,
  1.66532502e-01f, 1.64723650e-01f, -1.08144745e-01f, 1.70374259e-01f, 2.82395214e-01f, 1.99294433e-01f, -2.21442744e-01f, 5.70610613e-02f, -1.09036595e-01f, -8.00418481e-02f,
  1.71707749e-01f, 8.37034136e-02f, -1.45178914e-01f, -2.46422276e-01f, -2.40339562e-01f, -7.93377832e-02f, -3.49669933e-01f, -9.48356986e-02f, -4.32674259e-01f, -2.47417718e-01f,
  3.73822719e-01f, -6.95612933e-03f, 2.31416672e-01f, -1.01148505e-02f, 6.91048056e-02f, 6.86174557e-02f, 1.68268308e-02f, -1.74397990e-01f, -1.20342351e-01f, -1.71128586e-01f,
  -1.67317122e-01f, 4.28794622e-01f, 7.66547769e-02f, -1.19452357e-01f, -1.97816603e-02f, -1.95528358e-01f, -1.88727766e-01f, -1.57176480e-02f, 1.98807612e-01f, -4.50205505e-02f,
  1.59440845e-01f, -5.77135198e-02f, -3.38956974e-02f, 1.37906954e-01f, 6.22879155e-02f, -2.34715134e-01f, -1.57187469e-02f, 2.08017573e-01f, -2.40576081e-02f, 4.33114469e-01f,
  1.67832807e-01f, 3.83459598e-01f, -3.82650159e-02f, -4.78797913e-01f, -8.85046199e-02f, -2.85658330e-01f, 1.50162563e-01f, -2.37507120e-01f, 5.06512560e-02f, -1.73751041e-01f,
  6.18206859e-02f, 1.56198665e-01f, 1.36215299e-01f, -1.83266148e-01f, 2.31124032e-02f, 1.13435671e-01f, -1.88945130e-01f, 1.55590594e-01f, 2.25451156e-01f, 1.10732757e-01f,
  -3.81085649e-02f, -1.33465538e-02f, 6.71554357e-02f, -1.73386976e-01f, 1.85974583e-01f, 3.16154584e-02f, -1.56959593e-01f, -1.50259227e-01f, -7.12723052e-03f, -3.60378996e-02f,
  1.98064987e-02f, 2.02441454e-01f, 3.32200617e-01f, 2.35210322e-02f, -4.80174273e-02f, -1.94578469e-01f, 4.38741446e-02f, 5.18300086e-02f, 1.55506596e-01f, 1.82108790e-01f,
  2.85598170e-02f, -5.68198450e-02f, -3.07324082e-01f, 8.13586563e-02f, 2.03555986e-01f, -2.67914012e-02f, -1.47893941e-02f, -2.38970518e-01f, -3.14211309e-01f, -1.91693176e-02f,
  2.95074701e-01f, -3.59050408e-02f, 1.20505936e-01f, 6.43805638e-02f, 2.73558944e-01f, -2.37701058e-01f, 1.69155702e-01f, -3.32507677e-02f, -1.58990264e-01f, -1.76708013e-01f,
  1.67342827e-01f, 7.20627457e-02f, -2.10326705e-02f, -5.58213098e-03f, 4.10767496e-01f, -3.74104649e-01f, -6.13221154e-02f, -2.07080022e-01f, -1.42547861e-01f, -4.98815566e-01f,
  -1.77828819e-01f, -2.53397673e-01f, -6.07912987e-02f, 2.31328338e-01f, -2.15280041e-01f, 9.63629559e-02f, 2.04369605e-01f, -1.33177549e-01f, 4.14383685e-04f, 3.03844847e-02f,
  -2.43941963e-01f, 1.23344712e-01f, 1.57919019e-01f, -6.02061208e-03f, 2.10235640e-02f, -2.46367961e-01f, 1.34595931e-01f, 5.29692546e-02f, 1.85451135e-01f, -9.14368927e-02f,
  1.44706294e-01f, -1.50514603e-01f
};

// L3_fan_Wp_bar (Shape: 20 x 32)
const int L3_fan_Wp_bar_rows = 20;
const int L3_fan_Wp_bar_cols = 32;
const float L3_fan_Wp_bar_data[] = {
  1.88651636e-01f, -2.58881181e-01f, -9.27362368e-02f, 6.57572523e-02f, 2.42866680e-01f, 2.65820295e-01f, -4.57106173e-01f, -1.01584487e-01f, 3.77705880e-02f, -4.55328137e-01f,
  -1.92655101e-01f, 2.41209809e-02f, -5.09683695e-03f, 1.74553886e-01f, 3.28144431e-02f, 5.28426409e-01f, 3.83666128e-01f, -2.93823838e-01f, -1.19032353e-01f, 1.63131401e-01f,
  5.00746369e-01f, -2.12424040e-01f, 3.94549787e-01f, 8.40795562e-02f, 9.04149041e-02f, -1.51825845e-01f, -3.35967571e-01f, -1.88797042e-01f, 3.79535526e-01f, 2.40691513e-01f,
  -7.76004195e-02f, 1.76651210e-01f, -9.71124414e-03f, 1.50656104e-02f, -8.04104283e-02f, -1.21413153e-02f, -4.36744578e-02f, 1.09789655e-01f, 1.06177382e-01f, 1.49615882e-02f,
  8.81152228e-02f, 1.89503670e-01f, -3.31605785e-02f, 3.01763192e-02f, 4.64697070e-02f, -7.41411671e-02f, 9.04512405e-02f, -1.33432209e-01f, 4.12707701e-02f, -7.45186061e-02f,
  7.22982436e-02f, -1.10305808e-01f, -6.35764748e-02f, 5.99096827e-02f, -4.84379038e-04f, 1.50984796e-02f, -2.03593373e-01f, 1.06674358e-01f, 5.91631979e-02f, -1.00756951e-01f,
  7.43498057e-02f, -1.67917728e-01f, -1.65007278e-01f, -7.08662197e-02f, -1.36341661e-01f, -3.21951747e-01f, 7.85102844e-02f, -1.38050005e-01f, -1.20789625e-01f, 3.49694759e-01f,
  1.27584368e-01f, -6.33768022e-01f, 3.86636220e-02f, 2.25247890e-01f, 1.65505558e-01f, -5.89960039e-01f, 5.25431558e-02f, -1.15892656e-01f, 1.36999637e-01f, 8.68603364e-02f,
  1.47233844e-01f, 3.24950457e-01f, 3.78705800e-01f, -3.05519700e-01f, 2.09691629e-01f, 6.19283438e-01f, 2.61019140e-01f, 3.76617461e-01f, 3.82942036e-02f, 1.63920745e-01f,
  1.73868194e-01f, -1.28843054e-01f, -6.69096857e-02f, -2.95373976e-01f, -2.85954237e-01f, 1.96690992e-01f, -8.62729996e-02f, -2.52759576e-01f, -2.66151845e-01f, 2.80618787e-01f,
  -5.82278550e-01f, 3.60586107e-01f, 4.45654005e-01f, 5.63938916e-01f, 5.06688774e-01f, -6.68147027e-01f, -2.21302494e-01f, -3.51968050e-01f, -1.26712946e-02f, 2.90866852e-01f,
  -1.60381615e-01f, 2.34383658e-01f, -1.19714141e-01f, 3.03117722e-01f, 1.82889163e-01f, -6.96642906e-04f, -1.16840973e-01f, -1.07273050e-01f, -2.45256633e-01f, 3.12139094e-02f,
  1.80975020e-01f, -1.01582177e-01f, -6.83122098e-01f, 4.78607804e-01f, -2.38892958e-01f, 3.34710240e-01f, 1.78523082e-02f, 3.64727080e-01f, 2.02137008e-01f, 4.46398519e-02f,
  3.25876027e-01f, -2.49320507e-01f, 7.21492708e-01f, 3.83366555e-01f, -5.01414716e-01f, -5.42498827e-01f, 1.07300855e-01f, 2.24793162e-02f, -4.08690661e-01f, -1.15041368e-01f,
  9.09032952e-03f, -7.46910870e-02f, -9.94060487e-02f, 3.98294538e-01f, 8.61603096e-02f, -1.91442400e-01f, 1.97157398e-01f, -3.20390880e-01f, -1.21514343e-01f, 4.17543679e-01f,
  3.01530570e-01f, 3.21162939e-01f, 2.61049598e-01f, 4.59266067e-01f, 4.33017761e-02f, 2.29268372e-02f, -1.52088225e-01f, -1.88926205e-01f, 8.11080565e-04f, -4.41933200e-02f,
  1.38255641e-01f, -1.50881484e-01f, -5.76805435e-02f, -5.04946820e-02f, -2.49200493e-01f, -1.45153999e-01f, -1.55574575e-01f, 1.51060462e-01f, 8.92894492e-02f, 1.63567275e-01f,
  -4.54949588e-03f, -3.00952971e-01f, 3.33030568e-03f, -3.53184342e-01f, 5.05848415e-02f, 4.29518670e-01f, -1.65216744e-01f, -5.38567364e-01f, 1.85711846e-01f, -1.47008106e-01f,
  1.44790679e-01f, -3.72884236e-03f, 7.58914789e-03f, 2.95157105e-01f, 5.25459230e-01f, 1.95997730e-01f, -4.24553484e-01f, -3.71640101e-02f, -5.53332157e-02f, 2.81009108e-01f,
  3.61939520e-01f, 3.63001764e-01f, -1.99286733e-02f, 6.83554113e-01f, 7.67395794e-02f, 5.42879105e-01f, -3.12844008e-01f, 2.23922476e-01f, 1.12291902e-01f, 6.35058880e-02f,
  -4.83380914e-01f, 5.67028821e-01f, -1.49052918e-01f, 9.17797312e-02f, 7.43891820e-02f, -5.38314283e-01f, 1.05262034e-01f, -6.86355829e-02f, 2.45660201e-01f, -6.97435737e-01f,
  4.01094556e-01f, -1.78333779e-03f, -4.50726837e-01f, -2.26800278e-01f, -6.07688203e-02f, 1.89565822e-01f, -2.46375069e-01f, 1.07013874e-01f, -2.68875454e-02f, 2.10152239e-01f,
  3.55493486e-01f, -9.49568748e-02f, 3.36302310e-01f, -5.64857088e-02f, 2.47641858e-02f, 4.14381266e-01f, 4.66580838e-01f, -2.29269803e-01f, 2.54884779e-01f, -7.19828531e-02f,
  -2.16199741e-01f, -3.55850846e-01f, -2.15658903e-01f, 2.49522179e-01f, -1.90998182e-01f, 3.70127827e-01f, -1.30774630e-02f, 7.00348988e-02f, 3.13557595e-01f, -6.58819675e-02f,
  3.00765008e-01f, 1.11996904e-01f, 1.89162657e-01f, 3.05601418e-01f, -4.59870026e-02f, 3.50902945e-01f, 2.27132946e-01f, 2.00399179e-02f, -5.87792881e-02f, 4.19910014e-01f,
  5.01966834e-01f, 7.70952329e-02f, 1.42062396e-01f, -3.05915624e-01f, -1.35952473e-01f, -3.33385058e-02f, 2.01262578e-01f, 3.11389089e-01f, -4.40354533e-02f, 1.74006075e-01f,
  3.23650539e-01f, -8.35138440e-01f, -1.79768130e-01f, 4.00042534e-01f, 1.78296696e-02f, -2.21160054e-01f, -3.03362664e-02f, 3.48304242e-01f, 3.63169685e-02f, 3.48740011e-01f,
  4.39181626e-02f, 4.54300158e-02f, 9.52186435e-02f, 3.10916066e-01f, -7.76083320e-02f, 7.56659806e-01f, -3.60723063e-02f, -1.50736675e-01f, 1.39143392e-02f, -4.22451459e-02f,
  1.39996976e-01f, -1.03392549e-01f, 3.53940487e-01f, 3.04372907e-01f, 3.39862674e-01f, 4.86428350e-01f, 5.14740705e-01f, 1.80789120e-02f, 2.30190068e-01f, -2.08950073e-01f,
  -1.48672491e-01f, -2.62947865e-02f, -2.51251429e-01f, 3.86804827e-02f, 2.42226630e-01f, 1.27341837e-01f, 1.04278870e-01f, -1.92138299e-01f, 4.35668379e-01f, -6.40697964e-03f,
  1.20940454e-01f, 1.03419483e-01f, 3.65933150e-01f, 1.88506413e-02f, 3.71452048e-02f, 1.02184153e+00f, 1.35246083e-01f, 2.14867339e-01f, 4.08269882e-01f, 1.53291062e-01f,
  3.40922117e-01f, -2.22623348e-01f, 1.54578552e-01f, -1.34720683e-01f, 5.07227719e-01f, -3.13051701e-01f, 4.28345591e-01f, -4.94882315e-02f, -3.92239988e-01f, -1.74061023e-02f,
  -3.73254716e-01f, 6.37358055e-02f, -2.02581301e-01f, -5.37406743e-01f, 1.54145360e-01f, -1.67781636e-01f, -4.69108149e-02f, -5.74826837e-01f, -6.01714909e-01f, 4.25750613e-01f,
  1.74986959e-01f, -3.63850623e-01f, 8.89098924e-03f, -3.87644470e-01f, 2.40216270e-01f, 1.32858127e-01f, 2.20215559e-01f, -3.56165349e-01f, 5.16538918e-01f, -1.30226746e-01f,
  9.73381773e-02f, 1.85003683e-01f, 1.64212242e-01f, 2.82633603e-01f, 2.58689970e-01f, 6.88755214e-01f, -1.65534750e-01f, -7.99271688e-02f, -9.66458768e-02f, 1.87772870e-01f,
  1.08789653e-02f, 1.29127145e-01f, 2.79410571e-01f, 1.69171721e-01f, 8.97202641e-02f, 5.74628711e-02f, 3.62012759e-02f, -4.69305031e-02f, -1.12534903e-01f, 1.62929103e-01f,
  2.45297924e-01f, -2.51836807e-01f, -1.56464055e-01f, -9.87401679e-02f, -5.30610699e-03f, 2.86259260e-02f, -2.19340473e-01f, 3.82273078e-01f, 2.74989828e-02f, 8.42149630e-02f,
  -1.30383089e-01f, 1.55625641e-01f, 6.89435899e-02f, -4.76282477e-01f, -6.17808364e-02f, -1.14773214e-01f, 2.31461734e-01f, -2.54252195e-01f, -2.13726804e-01f, 2.08548099e-01f,
  1.85614213e-01f, 5.06723583e-01f, 3.87744039e-01f, -3.40685211e-02f, 5.30051850e-02f, 4.71040845e-01f, 4.48528007e-02f, -1.73131555e-01f, 2.62540132e-01f, -8.39287877e-01f,
  -2.79521406e-01f, -5.27004004e-02f, -7.50972152e-01f, 7.24074394e-02f, -1.42690107e-01f, 3.06968927e-01f, -1.11939711e-02f, -1.11149698e-01f, 2.57376768e-02f, -1.03930257e-01f,
  -1.31571159e-01f, -1.83496073e-01f, 5.50062880e-02f, 6.22279763e-01f, -1.36499062e-01f, 9.33606103e-02f, -7.13996068e-02f, -1.83958590e-01f, 8.58587995e-02f, -2.89001111e-02f,
  2.98146993e-01f, 2.65076995e-01f, 1.97974458e-01f, 4.68305856e-01f, 5.11672556e-01f, -4.22418863e-02f, 6.66604787e-02f, 1.54914260e-01f, 1.03657126e-01f, 3.97329718e-01f,
  1.64860517e-01f, -1.70390271e-02f, -5.92637211e-02f, -7.44518042e-01f, -1.95291966e-01f, 6.86754882e-02f, 5.22070788e-02f, 2.42636472e-01f, -3.79290394e-02f, 4.42653447e-01f,
  7.49948844e-02f, -1.67168758e-03f, 5.26334524e-01f, 1.37491092e-01f, 1.73983917e-01f, 4.34906751e-01f, 3.34693253e-01f, -1.05940484e-01f, 2.00012118e-01f, -1.61947951e-01f,
  -1.87263414e-01f, -1.83007360e-01f, 3.27346385e-01f, -2.62328804e-01f, 5.07610917e-01f, 3.30247097e-02f, 1.10434599e-01f, 2.42380071e-02f, 1.13797247e-01f, 9.80299786e-02f,
  -1.71401739e-01f, -2.53131986e-01f, 6.65640458e-02f, -2.18943059e-01f, -1.21807776e-01f, -2.95896441e-01f, -6.17565513e-01f, -2.45604664e-02f, 2.57320911e-01f, 1.13751672e-01f,
  5.29049039e-02f, -1.10697970e-02f, 3.40429753e-01f, -2.46616945e-01f, 2.29254842e-01f, 4.60522950e-01f, -4.44185846e-02f, 4.22266543e-01f, 2.18559414e-01f, 2.06833676e-01f,
  2.84532934e-01f, -1.04167901e-01f, 1.83552075e-02f, -1.16514876e-01f, 6.34325445e-01f, -2.75127202e-01f, 3.65347177e-01f, -4.97439131e-02f, -1.58803284e-01f, -1.14067182e-01f,
  3.19164395e-01f, -5.39980866e-02f, 1.31499231e-01f, 3.07753414e-01f, 1.77130654e-01f, 8.08125287e-02f, -2.07960397e-01f, 3.50805148e-02f, 5.93002200e-01f, -5.05461618e-02f,
  3.74420583e-02f, -1.83036923e-01f, -9.51169233e-04f, -1.14180543e-01f, -1.17521353e-01f, 6.13438249e-01f, 1.30485550e-01f, 2.60856539e-01f, 1.21204183e-01f, 9.41585377e-02f,
  9.36291516e-02f, -1.63260147e-01f, 4.21076035e-03f, 4.67831105e-01f, 4.80109692e-01f, -1.96908806e-02f, -3.66353452e-01f, -7.47829825e-02f, -1.78207215e-02f, 2.74386019e-01f,
  7.56952390e-02f, 2.10702464e-01f, 1.34494877e-03f, -8.49340670e-03f, -1.28123956e-02f, -9.62709542e-03f, -7.54662731e-04f, -9.71195661e-03f, -3.11621395e-03f, 3.06523684e-03f,
  -4.83427150e-03f, -6.20317971e-03f, 1.75789953e-03f, -2.24528695e-03f, -4.93392985e-40f, -1.46170985e-02f, -1.61661003e-02f, -4.65229277e-05f, -1.43946265e-03f, 4.21485832e-11f,
  -3.17684785e-02f, 7.02157923e-14f, -1.15788663e-02f, -3.60703515e-03f, -1.68378174e-03f, -3.19187180e-03f, -2.02678386e-02f, -5.32339967e-04f, -6.20976061e-05f, -8.80195480e-03f,
  -6.37011230e-03f, -8.09498690e-03f, -8.44992687e-11f, -2.07665376e-02f, 8.48619938e-01f, 4.09346670e-01f, 8.32462132e-01f, 3.83536696e-01f, 8.55407476e-01f, 3.90540659e-01f,
  -5.91961324e-01f, 2.99339145e-01f, 4.10460293e-01f, -6.84195638e-01f, -4.90273476e-01f, 1.85669228e-01f, 5.82167916e-02f, 2.45958596e-01f, -3.27706128e-01f, 2.64403969e-01f,
  1.07578397e-01f, -5.14202304e-02f, -1.38525099e-01f, 8.49423409e-02f, -1.66222960e-01f, -8.31986442e-02f, 8.23958442e-02f, 4.91399914e-02f, 6.53676316e-02f, -4.06816378e-02f,
  1.09547433e-02f, 2.41354257e-01f, 1.19711198e-01f, 1.56097874e-01f, 3.05519104e-01f, -1.42208440e-02f, 7.50623792e-02f, 4.23321903e-01f, 3.68687272e-01f, -2.05580313e-02f,
  3.64414006e-01f, -1.80487022e-01f, -3.67536634e-01f, 1.75956354e-01f, 2.97939420e-01f, 3.71633887e-01f, -3.08850139e-01f, -1.27740428e-01f, -1.35782892e-02f, -1.20645650e-01f,
  -1.13069057e-01f, -1.04649238e-01f, -2.28940353e-01f, 2.82506227e-01f, 2.59122610e-01f, -3.46907228e-01f, -5.62218785e-01f, -2.09558778e-03f, -1.63659006e-01f, 1.45935476e-01f,
  1.57891214e-01f, 3.63247216e-01f, 2.59694997e-02f, 3.69408488e-01f, -4.98081684e-01f, -5.10008670e-02f, 4.08812821e-01f, 7.11228251e-02f, -2.58063048e-01f, 5.04939556e-01f,
  2.59739339e-01f, -2.93142032e-02f, -2.77644426e-01f, 4.94672775e-01f, 1.37769982e-01f, 2.92348027e-01f, -7.59887919e-02f, 7.63303488e-02f, -2.22040638e-01f, 2.51459420e-01f,
  -3.14033702e-02f, 4.03040677e-01f, 2.06379890e-01f, -2.62680382e-01f, -2.17263460e-01f, -7.31849730e-01f, 2.74444789e-01f, -1.65772781e-01f, -3.56793553e-01f, 2.05562621e-01f,
  -1.45991474e-01f, -2.07456425e-02f, 9.45293829e-02f, 3.61843079e-01f, -1.25326276e-01f, 4.08602506e-01f, 2.61542574e-02f, -3.23304594e-01f, 1.53231099e-01f, 2.21183091e-01f
};

// L3_fan_Bp_bar (Shape: 1 x 20)
const int L3_fan_Bp_bar_rows = 1;
const int L3_fan_Bp_bar_cols = 20;
const float L3_fan_Bp_bar_data[] = {
  1.42840728e-01f, -6.70369044e-02f, -1.15393914e-01f, -1.00989908e-01f, 1.22555788e-03f, 5.08339591e-02f, 4.28151116e-02f, 3.43791127e-01f, 2.07700014e-01f, 1.08439647e-01f,
  2.15797246e-01f, 3.70858759e-02f, 1.64270565e-01f, 3.62266243e-01f, 5.92757240e-02f, -2.17161059e-01f, -6.62984233e-03f, 6.82943314e-02f, -1.19505832e-02f, 5.46394549e-02f
};

// L4_linear_W (Shape: 12 x 32)
const int L4_linear_W_rows = 12;
const int L4_linear_W_cols = 32;
const float L4_linear_W_data[] = {
  1.01866268e-01f, -2.77434308e-02f, -5.01729548e-02f, -2.33341772e-02f, 7.84233063e-02f, -5.65194964e-01f, -4.73903686e-01f, 3.05145793e-02f, 3.75660151e-01f, -5.01046218e-02f,
  -3.84929404e-02f, 1.28287161e-02f, -1.45858616e-01f, -1.03586562e-01f, 1.44524515e-01f, 2.18600199e-01f, 2.01001570e-01f, 2.66943369e-02f, -4.29047383e-02f, -1.21202115e-02f,
  -5.16237140e-01f, -1.58380017e-01f, 1.49770468e-01f, -3.98826152e-01f, -5.29906332e-01f, -5.88735223e-01f, -5.36493599e-01f, 1.44370511e-01f, 5.53366356e-03f, -1.41209930e-01f,
  1.90445948e-02f, 2.15544358e-01f, 1.00587923e-02f, 1.19077219e-02f, 3.88540685e-01f, 3.74517381e-01f, -5.72446227e-01f, -4.05712128e-01f, -3.10297251e-01f, -5.93512654e-01f,
  1.05147339e-01f, -1.06817424e-01f, -2.63318151e-01f, -8.46696496e-01f, 1.63264558e-01f, 2.93320082e-02f, 1.58222929e-01f, 1.28659219e-01f, -3.20917636e-01f, 1.32022396e-01f,
  -2.11792707e-01f, -6.42522752e-01f, -1.20965406e-01f, 1.64088085e-01f, 9.79884565e-02f, 6.94433302e-02f, -2.35418960e-01f, -2.15187863e-01f, -5.78426421e-02f, 2.67394453e-01f,
  -1.63901225e-02f, -6.03891850e-01f, -2.57322371e-01f, -2.20865682e-01f, 1.07161738e-01f, -4.85486388e-02f, -1.15076303e-01f, -4.89978120e-02f, -3.65386814e-01f, 2.82378495e-01f,
  -7.44399369e-01f, -1.39975205e-01f, -1.81905717e-01f, -2.47691631e-01f, 1.57357201e-01f, -5.37890732e-01f, -3.15299243e-01f, 2.93730557e-01f, 1.32528797e-01f, 8.58072266e-02f,
  -3.20006497e-02f, -2.84564555e-01f, 6.36934519e-01f, 9.20976475e-02f, -5.98239005e-01f, -1.13863342e-01f, 2.42242768e-01f, -1.10859737e-01f, -2.31011003e-01f, 1.13219924e-01f,
  5.06622866e-02f, -6.80252850e-01f, -1.06922267e-02f, -2.91948408e-01f, -5.42213023e-01f, 4.14632022e-01f, -2.04289198e-01f, -1.77358598e-01f, -1.76934689e-01f, 6.44164234e-02f,
  1.86761990e-01f, 6.48391619e-02f, 3.83776039e-01f, 4.99807537e-01f, -4.55690682e-01f, 4.00170326e-01f, -4.78727464e-03f, -3.25321019e-01f, -8.19405735e-01f, -8.30148011e-02f,
  8.12328681e-02f, -4.17865396e-01f, 7.50067085e-02f, -4.62755114e-02f, 1.75326109e-01f, 1.80963114e-01f, -9.34501439e-02f, -8.41208696e-01f, 2.08377212e-01f, -3.59979391e-01f,
  2.51263291e-01f, -3.40906918e-01f, -3.35784316e-01f, -1.00682370e-01f, -3.40186876e-15f, 1.68664724e-01f, 3.07798654e-01f, 3.10424685e-01f, 7.65260011e-02f, -4.15661521e-02f,
  -3.92480046e-01f, -2.77804673e-01f, 1.11620920e-02f, 2.86595941e-01f, 6.30883396e-01f, 1.09214984e-01f, 3.55868727e-01f, 8.12440142e-02f, 1.51028767e-01f, 1.71271697e-01f,
  -1.02257133e-01f, -1.37703717e-01f, 1.52620316e-01f, -7.61395931e-01f, 1.59077510e-01f, 1.16164818e-01f, -2.21122846e-01f, -1.74161978e-02f, -7.49519393e-02f, -1.73046738e-02f,
  2.42120877e-01f, -4.30532396e-01f, 1.51097655e-01f, -1.53783530e-01f, 7.62238353e-03f, 7.09889010e-02f, -5.33388034e-02f, -2.25749090e-01f, -9.99424607e-02f, -1.90491185e-01f,
  1.91666894e-02f, 1.25306964e-01f, -5.78866422e-01f, -3.95734489e-01f, 5.15048146e-01f, 2.07420900e-01f, 5.80528677e-01f, 4.15319890e-01f, -1.91468060e-01f, 5.73351204e-01f,
  1.79038972e-01f, 6.56726897e-01f, 3.37863326e-01f, -1.34835439e-02f, -2.82514207e-02f, -1.26366362e-01f, 1.63282901e-01f, -8.86081439e-03f, -1.00641791e-02f, -2.40039542e-01f,
  -1.65422916e-01f, -3.58417153e-01f, -8.85301158e-02f, -1.01995151e-02f, -2.88553983e-01f, 5.36690094e-02f, -4.13837790e-01f, 2.39911661e-01f, -4.53787390e-03f, 3.63478571e-01f,
  -6.71548173e-02f, -2.16022134e-01f, 2.98573345e-01f, -8.64845365e-02f, 4.66596857e-02f, -2.02517927e-01f, 1.49093375e-01f, 8.43932331e-02f, 5.32299995e-01f, 4.72929895e-01f,
  1.77146897e-01f, 5.97791135e-01f, 2.99297661e-01f, 2.82647848e-01f, -1.95431903e-01f, -7.17109442e-02f, -1.37355685e-01f, -4.14240919e-02f, -8.84040833e-01f, -2.48073429e-01f,
  -6.26617253e-01f, 2.56067157e-01f, 6.39794841e-02f, 3.23174357e-01f, -4.62180227e-01f, -6.46106184e-01f, 1.23050526e-01f, 1.62782982e-01f, 2.22541571e-01f, -2.76934236e-01f,
  -1.97114088e-02f, -5.74945807e-01f, -2.18630433e-01f, -2.66161896e-02f, 3.73380303e-01f, -2.78368473e-01f, -1.21248230e-01f, -2.34703913e-01f, -3.40885296e-02f, -7.23990984e-03f,
  -1.41697899e-01f, 1.56686246e-01f, -3.18322957e-01f, 1.99976489e-01f, -5.99654540e-02f, 1.36515543e-01f, 2.57218450e-01f, -2.31855903e-02f, -4.29785669e-01f, -3.98314238e-01f,
  -2.50583082e-01f, 3.41138383e-03f, 5.85493803e-01f, -1.03524126e-01f, 6.73177615e-02f, -8.37559402e-02f, 1.24410450e-01f, -7.22717959e-03f, 3.65170807e-01f, 3.30159552e-02f,
  6.80345669e-02f, -9.25697759e-02f, 8.68938584e-03f, -1.76962480e-01f, -4.66612279e-01f, -5.73374212e-01f, -1.52800158e-01f, 2.73417473e-01f, -8.38151500e-02f, 9.31749269e-02f,
  -4.22695816e-01f, 2.19846681e-01f, 2.27654755e-01f, -3.75810832e-01f, -2.66057551e-02f, -4.56760079e-01f, 9.46774986e-03f, 5.03493190e-01f, 7.16699436e-02f, 1.05150801e-04f,
  -5.71070254e-01f, 4.09308523e-01f, -6.90898418e-01f, -2.20758896e-02f, -4.59240913e-01f, -2.02814311e-01f, 3.08142871e-01f, -3.45271260e-01f, -5.09703040e-01f, 1.10995680e-01f,
  2.64928967e-01f, -1.90368071e-01f, -3.01770240e-01f, 7.97070116e-02f, -1.00703677e-04f, 2.28735745e-01f, -4.79741365e-01f, 9.21910256e-02f, -2.62237281e-01f, 3.49293947e-01f,
  3.02922018e-02f, 8.99795368e-02f, -1.70878589e-01f, 3.74860138e-01f, -1.83175832e-01f, -1.72439665e-01f, -2.21725196e-01f, -2.83901751e-01f, 1.26145780e-01f, 4.13354218e-01f,
  -1.51493147e-01f, -9.06014629e-03f, 2.04595059e-01f, -8.38650614e-02f, 2.26070225e-01f, -6.75819576e-01f, -5.37319541e-01f, 1.52424127e-01f, -1.98850557e-01f, 2.51401246e-01f,
  6.67734444e-02f, -3.68096918e-01f, -3.53267305e-02f, -3.74547322e-04f, 1.66371301e-01f, -4.82796550e-01f, -2.40041476e-09f, -1.50599107e-01f, -1.29010648e-01f, -6.53149128e-01f,
  -3.05293381e-01f, -4.44977850e-01f, 7.15847909e-02f, 2.11381540e-01f, 2.28429362e-01f, 5.12601025e-02f, -5.37977479e-02f, -2.25444064e-01f, 7.55331278e-01f, -2.12495327e-01f,
  -4.72269952e-01f, -3.08232307e-01f, -6.52842104e-01f, 4.22191918e-02f, -4.14266080e-01f, 2.72334814e-01f, -1.31204650e-01f, 1.06355391e-01f, 2.85006076e-01f, -3.42018545e-01f,
  2.53087804e-02f, -5.30485511e-01f, 9.50328931e-02f, 5.65692373e-02f, 2.02776641e-01f, -9.58848894e-01f, -2.95582414e-01f, 1.91498652e-01f, 8.64035590e-26f, -4.12937440e-02f,
  3.65592718e-01f, 2.29938924e-01f, -9.65030268e-02f, 2.36905560e-01f, 1.56101480e-01f, 4.19803202e-01f, -1.07993409e-01f, -2.10860521e-01f, -7.01987207e-01f, 1.38090760e-01f,
  -9.19833407e-02f, 1.00194447e-01f, -1.58607766e-01f, -2.17533335e-01f, 1.02283806e-01f, -3.31644416e-02f, -7.15094268e-01f, -3.37368190e-01f, -1.34219229e-01f, -5.63973784e-01f,
  -4.32486802e-01f, 5.83961867e-02f, 2.11335242e-01f, 2.16222063e-01f, -7.78279960e-01f, 2.17416912e-01f, 5.57582937e-02f, 1.09130561e-01f, 1.00477360e-01f, -1.26708001e-01f,
  -1.40038736e-28f, 5.94657779e-01f, -1.87103391e-01f, -2.57668048e-01f
};

// L4_linear_B (Shape: 1 x 12)
const int L4_linear_B_rows = 1;
const int L4_linear_B_cols = 12;
const float L4_linear_B_data[] = {
  -4.70441431e-02f, -1.83543712e-01f, -3.17142941e-02f, 1.10975094e-01f, 4.31701094e-02f, 2.04568028e-01f, 6.00530580e-03f, -3.98304760e-02f, 1.68522656e-01f, -2.16578078e-02f,
  1.66139811e-01f, 1.00722108e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 6, 20
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        32, 6, 20
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        32, 6, 20
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L3_fan_Wp_data, L3_fan_Wp_bar_data, L3_fan_Bp_bar_data,
        32, 6, 20
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 4: L4_linear
    linear_forward_pgm(
        buffer1, x_out,
        L4_linear_W_data, L4_linear_B_data,
        32, 12
    );
    }
    