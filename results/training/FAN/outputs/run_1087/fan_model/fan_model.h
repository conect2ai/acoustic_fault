/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 64 (x3)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 64;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    return (x > 0.0f) ? x : 0.0f;
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 19 x 120)
const int L0_fan_Wp_rows = 19;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  2.78823853e-01f, -2.37131223e-01f, 3.25823486e-01f, -2.40156818e-02f, -1.11391604e-01f, 1.60110146e-01f, 3.25587653e-02f, 3.72141860e-02f, -8.25717002e-02f, -1.98472254e-02f,
  -1.82206690e-01f, -8.39215219e-02f, -1.45695163e-02f, 1.52160361e-01f, 1.78772822e-01f, 1.60251074e-02f, -2.82366183e-02f, 3.20507407e-01f, 4.12693918e-01f, 1.11211896e-01f,
  -2.34849155e-01f, 6.68573081e-02f, 2.20593318e-01f, 1.62438616e-01f, -1.26023158e-01f, -5.32633550e-02f, -4.93815355e-02f, -3.45020257e-02f, -4.55741212e-02f, -1.91941261e-01f,
  1.41666159e-01f, -9.02867690e-02f, 7.83106014e-02f, -5.32602482e-02f, 4.49541584e-02f, 2.68690456e-02f, -4.71682986e-03f, 2.30572242e-02f, 1.54233705e-02f, 5.25115319e-02f,
  -2.77752709e-02f, 3.79693657e-02f, -1.37459338e-02f, 3.22370157e-02f, 6.37602136e-02f, 6.67743012e-02f, 4.03279401e-02f, 2.30015725e-01f, 1.18943289e-01f, 1.05018273e-01f,
  -8.25399011e-02f, -1.55808134e-02f, 1.07653283e-01f, -3.68267782e-02f, 6.47855774e-02f, 8.40274245e-02f, 6.01588516e-03f, -4.97281067e-02f, 1.65561602e-01f, -8.14624056e-02f,
  7.82902092e-02f, 1.30034238e-02f, 8.40522908e-03f, 1.24225514e-02f, 2.81833597e-02f, -5.19874878e-02f, -2.38915347e-02f, 6.69825599e-02f, 3.00054979e-02f, 1.19942296e-02f,
  -5.33193648e-02f, 3.38496305e-02f, -4.70588729e-02f, -1.89849958e-02f, 1.68318562e-02f, 5.16409054e-02f, 7.54773319e-02f, -9.40319616e-03f, 3.81219536e-02f, -7.70249367e-02f,
  3.52328010e-02f, 3.59613374e-02f, -1.02300689e-01f, 1.02778845e-01f, 1.74646508e-02f, 8.44016150e-02f, -1.41709987e-02f, -5.96426763e-02f, 3.80509757e-02f, 2.28324551e-02f,
  -1.46534458e-01f, 1.07620105e-01f, 3.77205573e-02f, 3.98324095e-02f, -2.65309457e-02f, 2.34396406e-03f, 4.54212725e-02f, 1.14597775e-01f, -2.64334399e-02f, 3.93575020e-02f,
  -7.13687614e-02f, 1.12301648e-01f, 5.86018264e-02f, 7.21475556e-02f, 6.17578253e-02f, 6.93491772e-02f, 2.44394578e-02f, 3.50473076e-02f, -2.34784149e-02f, -1.68320276e-02f,
  1.82440877e-02f, 1.04846835e-01f, 1.16331823e-01f, 8.84609576e-03f, 6.18269593e-02f, 3.17129642e-02f, 5.34233116e-02f, 5.07277856e-03f, 1.55735001e-01f, 8.04018825e-02f,
  -7.36840889e-02f, 1.67724073e-01f, 1.52895495e-01f, -1.16042152e-01f, 2.02025339e-01f, 2.25623697e-01f, 3.73667538e-01f, 8.56286734e-02f, -8.99120644e-02f, 1.98224057e-02f,
  -5.87334968e-02f, -1.45627797e-01f, -1.86260507e-01f, -1.26419008e-01f, 1.09323375e-02f, 2.29967430e-01f, 2.45514393e-01f, 4.62381020e-02f, -1.10824935e-01f, -1.58816844e-01f,
  -4.05916199e-02f, -1.23848341e-01f, -7.45783523e-02f, -6.21696860e-02f, -3.48309651e-02f, -7.28052482e-02f, 1.73107088e-02f, -4.65164930e-02f, -5.50754517e-02f, 8.05334672e-02f,
  -2.88023297e-02f, 1.41627014e-01f, -4.52851877e-02f, -4.38087694e-02f, 3.39859091e-02f, 3.94887514e-02f, 4.15708572e-02f, -8.47243294e-02f, 5.51605187e-02f, -5.69132417e-02f,
  8.79976433e-03f, 2.29185969e-02f, -4.24770750e-02f, 4.19291072e-02f, 2.61301715e-02f, 1.59736387e-02f, -9.69708711e-03f, -1.71063421e-03f, -1.52797410e-02f, 2.17081942e-02f,
  -2.73128250e-03f, 2.95697190e-02f, 9.12259445e-02f, 3.52333747e-02f, -6.45305170e-03f, 4.13804241e-02f, -2.13606451e-02f, -1.15159065e-01f, -3.71257178e-02f, -4.15619723e-02f,
  -4.55120355e-02f, -1.03058787e-02f, -1.08823192e-03f, -2.11158879e-02f, -6.76959055e-03f, -7.85392709e-03f, 2.16477159e-02f, -1.82532240e-03f, -1.26703694e-01f, -3.19689400e-02f,
  -4.90876101e-02f, -3.66383158e-02f, -5.63290566e-02f, 2.25198083e-02f, -8.23699385e-02f, -1.06701413e-02f, 1.86759103e-02f, -2.69829780e-02f, -6.51346371e-02f, -7.22056180e-02f,
  -9.66198444e-02f, 2.68072542e-02f, -5.77622019e-02f, -5.40324412e-02f, 2.55405381e-02f, -1.07099809e-01f, -5.11476509e-02f, -1.28423572e-01f, -5.79315200e-02f, 3.48675214e-02f,
  -2.86418438e-01f, -4.96173017e-02f, -8.87142792e-02f, -3.50101888e-02f, 8.62553641e-02f, -6.25255629e-02f, -8.61023515e-02f, -4.27331366e-02f, 6.78815991e-02f, -4.44609076e-02f,
  -3.54549028e-02f, -1.30250543e-01f, -3.56887095e-02f, -1.13052599e-01f, -1.75644830e-02f, -5.84236793e-02f, -1.51463300e-02f, -2.92817540e-02f, 4.93396930e-02f, 3.03635886e-03f,
  2.81869583e-02f, -8.91200360e-03f, -3.90892737e-02f, 9.30422023e-02f, -5.34725115e-02f, -5.90130463e-02f, -1.01087868e-01f, -7.52275139e-02f, 6.97804987e-02f, -4.25788537e-02f,
  2.17755765e-01f, -8.43571872e-02f, 1.60931587e-01f, -2.33637244e-01f, -2.20273986e-01f, 1.96278207e-02f, 1.72496855e-01f, 2.68550906e-02f, -1.05898395e-01f, -4.23647948e-02f,
  -6.18702956e-02f, -2.47405633e-01f, -2.94714440e-02f, -4.31829952e-02f, 1.54267684e-01f, 2.82522365e-02f, -2.71259993e-02f, 5.04861400e-02f, 1.13263145e-01f, -1.12019762e-01f,
  -1.73917562e-01f, 1.18378093e-02f, 8.51039290e-02f, -4.06817487e-03f, 8.64847600e-02f, 7.79305696e-02f, 1.38412118e-01f, 8.87020677e-02f, 3.63394879e-02f, 9.15099457e-02f,
  8.92054215e-02f, 2.80590169e-02f, -2.73221042e-02f, -1.27109915e-01f, -1.77366827e-02f, 4.92068799e-03f, 1.15503808e-02f, 2.91459914e-02f, -6.64010048e-02f, -4.35083769e-02f,
  -3.69117446e-02f, -9.48544741e-02f, -1.02757774e-01f, 4.63805385e-02f, -5.07095829e-02f, 3.76871936e-02f, -7.19777271e-02f, -5.22815734e-02f, 3.32690403e-02f, 4.09320183e-02f,
  -2.06851721e-01f, -5.82920462e-02f, 6.59502596e-02f, 5.88698871e-03f, 1.80981588e-02f, -7.15821087e-02f, 9.33405831e-02f, 1.04122482e-01f, 1.11290291e-01f, 1.77014574e-01f,
  -2.94820890e-02f, 6.02963567e-02f, 5.29671134e-03f, 1.17982596e-01f, 1.69384759e-02f, 1.97712723e-02f, 6.69688806e-02f, 1.11624077e-02f, 7.91654140e-02f, 1.31262004e-01f,
  8.25781152e-02f, 7.26731941e-02f, 1.70044247e-02f, 1.62078708e-01f, 1.91378482e-02f, 1.30471706e-01f, 1.62494034e-01f, 1.37389153e-01f, 5.42133525e-02f, 4.22626063e-02f,
  1.35999322e-01f, 9.86830071e-02f, 5.39632663e-02f, 2.00090379e-01f, 1.93213090e-01f, 7.20969737e-02f, 1.40374258e-01f, 8.33365396e-02f, 7.01523945e-02f, 8.70005041e-02f,
  -1.39726009e-02f, -2.56982353e-02f, -5.66672087e-02f, -7.59015558e-03f, -1.45195603e-01f, -8.22007731e-02f, -1.05921984e-01f, -1.30095124e-01f, -9.27558262e-03f, -7.10546076e-02f,
  -7.00343475e-02f, -1.57382768e-02f, -8.38321522e-02f, -1.34940743e-01f, -8.88480917e-02f, -1.55126244e-01f, -1.56645119e-01f, -4.53060586e-03f, -1.29346773e-01f, -1.74134374e-01f,
  -8.14258754e-02f, -7.76920840e-02f, -3.98819745e-02f, -7.07787350e-02f, -1.33927882e-01f, -5.38040996e-02f, -2.64333468e-02f, 7.92386457e-02f, 1.95503589e-02f, 2.30704490e-02f,
  2.65323967e-01f, 2.68421266e-02f, -1.40851349e-01f, -1.52069069e-02f, -6.04375266e-02f, -7.33552873e-02f, -4.38794009e-02f, -7.94936554e-04f, -1.26288176e-01f, -7.81969458e-04f,
  -4.92379218e-02f, -3.12266573e-02f, 3.07689924e-02f, -1.38952397e-02f, -1.53338630e-02f, 2.32645739e-02f, 2.73093190e-02f, 8.93021226e-02f, -8.84765685e-02f, -1.45333502e-02f,
  1.55596167e-01f, 4.12500054e-02f, 8.74406546e-02f, 1.23030551e-01f, 1.48115695e-01f, 1.50225759e-01f, 1.30211741e-01f, 4.70888019e-02f, 5.01716025e-02f, 2.77522266e-01f,
  1.17255941e-01f, -1.27610378e-02f, -5.45299090e-02f, 1.67852923e-01f, -9.56426188e-02f, 7.71713257e-02f, -3.72595005e-02f, -5.71832713e-03f, 7.13548958e-02f, -3.80604342e-02f,
  1.54896826e-02f, 3.72730680e-02f, -4.79472578e-02f, -7.87234083e-02f, -3.85673493e-02f, 2.18492281e-03f, 4.26475070e-02f, 8.08130577e-02f, 5.66188470e-02f, 5.99437356e-02f,
  4.76770848e-02f, 1.46765411e-01f, 1.12541363e-01f, 1.61722675e-02f, -3.71266119e-02f, -9.69647430e-03f, 7.15885386e-02f, -4.80724424e-02f, 2.71964576e-02f, 1.43270329e-01f,
  4.65869196e-02f, 6.67981952e-02f, 7.59980306e-02f, -1.71129126e-02f, 1.45084977e-01f, 6.36327639e-02f, 8.82228743e-03f, 1.21715002e-01f, 9.84362438e-02f, 5.48795648e-02f,
  -6.81378543e-02f, -5.24759926e-02f, -1.37096671e-02f, 6.59368336e-02f, 4.86946441e-02f, 9.77800190e-02f, 7.06526265e-02f, 4.47324328e-02f, 1.11993954e-01f, 1.45285904e-01f,
  1.27399445e-01f, 1.34832459e-02f, 4.45224643e-02f, 1.31796524e-01f, 1.07579075e-01f, -2.71184146e-02f, -7.23997131e-02f, -6.89433813e-02f, -5.49873598e-02f, -2.90231984e-02f,
  -9.03733149e-02f, 7.74144242e-03f, 2.02895731e-01f, 4.69548143e-02f, 2.29103607e-03f, -7.66192600e-02f, 1.20019354e-02f, 7.55328778e-03f, -5.21109775e-02f, 3.79476808e-02f,
  4.56595980e-03f, 8.28497519e-04f, 7.88019374e-02f, -5.62550090e-02f, 7.77792335e-02f, 1.12975396e-01f, 1.77741125e-02f, 8.68138671e-02f, 8.62160921e-02f, -2.15555578e-02f,
  -3.03867296e-03f, 1.53091997e-01f, 1.59235552e-01f, 4.74660471e-02f, 1.15936056e-01f, 1.56123564e-01f, 1.22523017e-01f, 1.23261742e-01f, 1.78983733e-02f, 4.89458255e-02f,
  1.10226601e-01f, -3.74078751e-01f, -1.77994117e-01f, 1.55496818e-03f, 7.91426301e-02f, 5.30724563e-02f, -6.24673627e-02f, 1.44917503e-01f, 1.58689067e-01f, -9.67059359e-02f,
  -1.22496963e-01f, 7.84845352e-02f, -1.97182707e-02f, 3.20201479e-02f, -4.92766313e-02f, -1.18038669e-01f, -2.57979900e-01f, -1.52519166e-01f, 1.71518877e-01f, 2.10448027e-01f,
  2.47877911e-02f, 4.74321693e-02f, 4.37590899e-03f, 8.09950382e-02f, -3.69617343e-02f, 1.14134066e-01f, -1.15144439e-01f, -7.55976960e-02f, -1.76975816e-01f, -3.83160710e-01f,
  -5.85746318e-02f, -1.29041255e-01f, 1.53621808e-01f, 8.35673325e-03f, -6.65827096e-02f, 6.55661449e-02f, 9.00305286e-02f, -1.23218233e-02f, 1.05714835e-01f, -2.73064394e-02f,
  -1.25680253e-01f, 3.00932433e-02f, -8.44169632e-02f, -4.55971286e-02f, 2.08442267e-02f, 3.55153754e-02f, -1.33345857e-01f, -2.71583926e-02f, -9.17285383e-02f, -6.04207478e-02f,
  -9.15712328e-04f, -1.44524649e-01f, -7.72634596e-02f, 2.42169928e-02f, -8.42807144e-02f, 6.64539337e-02f, 7.99378846e-03f, -1.46417180e-02f, -2.26203185e-02f, -2.37652548e-02f,
  5.98369166e-02f, -7.28996769e-02f, 6.64278399e-03f, -8.73568803e-02f, 3.91976722e-03f, -1.83652341e-02f, -1.10745758e-01f, -4.96776663e-02f, -9.72568914e-02f, -5.86784817e-02f,
  -3.00376806e-02f, -3.61142494e-02f, -7.04062060e-02f, -9.26338136e-03f, -9.01833102e-02f, -6.42810389e-02f, 5.37907146e-03f, 2.70131808e-02f, -1.07638925e-01f, -3.30433063e-02f,
  -9.51286592e-03f, -1.68030653e-02f, -3.79196294e-02f, -1.31416991e-02f, -1.47241384e-01f, -7.19469041e-03f, -8.64497572e-02f, -7.94040635e-02f, -9.72901508e-02f, -9.93275829e-03f,
  3.24815959e-01f, -1.14520267e-02f, 1.27254754e-01f, 1.15049675e-01f, 5.46105613e-04f, 6.85009509e-02f, 1.26812840e-02f, 4.15162817e-02f, -3.38751227e-02f, 1.28361151e-01f,
  3.80054787e-02f, 7.93141499e-02f, 3.97517309e-02f, 2.64564641e-02f, 1.13639645e-01f, 6.82523325e-02f, 8.58504400e-02f, 1.90030485e-02f, 2.19833925e-02f, 2.49695871e-02f,
  4.51149493e-02f, 1.92523763e-01f, 2.27160871e-01f, 1.01062782e-01f, 5.04161827e-02f, 2.53795892e-01f, 1.31190225e-01f, 1.70360416e-01f, 2.11267680e-01f, 2.27102831e-01f,
  -3.08500230e-01f, -5.87275214e-02f, -9.92236137e-02f, -2.65949909e-02f, 5.76860607e-02f, 3.09390370e-02f, -2.20197931e-01f, -2.77451184e-02f, 5.37018152e-03f, 8.10534321e-03f,
  2.94099888e-03f, 1.53757259e-01f, 1.21893905e-01f, 1.23611301e-01f, 2.04839502e-02f, -2.16236532e-01f, -1.16607413e-01f, -5.38153127e-02f, 6.20769374e-02f, 1.27470180e-01f,
  5.81756011e-02f, -8.09802860e-02f, -1.49305612e-01f, 8.12350735e-02f, 4.58409674e-02f, 3.96887735e-02f, 2.00196821e-03f, -2.16052625e-02f, 1.14837721e-01f, -8.48964825e-02f,
  1.93120111e-02f, -6.43323511e-02f, 5.88454865e-02f, 1.98159646e-02f, 3.08511015e-02f, -7.92151541e-02f, -2.84239221e-02f, -4.36629467e-02f, 2.34770738e-02f, 5.41584231e-02f,
  -3.13780829e-02f, 4.69073132e-02f, -4.83619571e-02f, 9.10772085e-02f, -1.47187291e-02f, 4.68613096e-02f, 3.22385207e-02f, -5.54469377e-02f, 1.03297763e-01f, 6.48706481e-02f,
  1.33714423e-01f, -3.07071116e-02f, -3.16652022e-02f, -4.00198624e-02f, -4.22820784e-02f, 3.40881608e-02f, 7.70701319e-02f, 7.23411664e-02f, 5.19409403e-02f, -4.93877269e-02f,
  -1.56311393e-01f, -4.46097925e-02f, -2.48782262e-02f, -1.28483579e-01f, -1.09692164e-01f, 3.54506560e-02f, -9.01523307e-02f, -1.00158110e-01f, 6.94367290e-03f, -6.31015822e-02f,
  -1.11213066e-01f, -5.33377789e-02f, -4.85272780e-02f, -9.35582146e-02f, -1.21986996e-02f, -1.20666854e-01f, -8.53116736e-02f, -2.74617337e-02f, -5.67136779e-02f, -5.50945327e-02f,
  -1.54071199e-02f, 5.14084511e-02f, -7.25172535e-02f, -2.32948102e-02f, 2.14219876e-02f, 4.95977104e-02f, -3.81968506e-02f, -4.19957051e-03f, -7.39437491e-02f, -1.01956531e-01f,
  -4.97107506e-02f, 1.67161107e-01f, 4.55663465e-02f, 2.07270887e-02f, 4.42915708e-02f, 1.80659294e-01f, 1.32224455e-01f, 8.46200883e-02f, 4.78232317e-02f, -2.61004884e-02f,
  3.64406966e-02f, -6.03762455e-02f, 5.19673117e-02f, -1.61862765e-02f, 1.29507124e-01f, 2.03466285e-02f, -2.35533025e-02f, 5.50162196e-02f, 8.03901553e-02f, 1.17252313e-01f,
  1.78231169e-02f, -4.39123437e-02f, 2.92955022e-02f, 9.24483538e-02f, 9.33768004e-02f, 2.55451556e-02f, 4.82780412e-02f, -5.82572445e-03f, -1.84993800e-02f, -1.15787633e-01f,
  2.07966372e-01f, 1.35487318e-01f, 2.86535751e-02f, 5.10526299e-02f, 1.47890255e-01f, 7.90653750e-02f, 1.17188558e-01f, -6.09403029e-02f, 5.47732003e-02f, 1.71498194e-01f,
  -1.33101165e-01f, -2.02599213e-01f, -1.67405844e-01f, -2.51110286e-01f, -5.31671122e-02f, 8.06555226e-02f, 2.30468050e-01f, 6.74385503e-02f, -1.99481964e-01f, -6.27679825e-02f,
  -9.54374485e-03f, 1.22161694e-02f, -5.44270910e-02f, -3.76960002e-02f, 1.69352993e-01f, -1.85087115e-01f, 1.52372733e-01f, 1.04046211e-01f, -1.13878231e-02f, 2.62726665e-01f,
  8.32707249e-03f, 1.14921078e-01f, -1.49717495e-01f, -1.21029168e-01f, -3.07556186e-02f, -6.30659610e-02f, -8.85040164e-02f, 4.18581814e-03f, -6.50440902e-02f, 5.85028492e-02f,
  3.77027243e-02f, 4.25914116e-02f, -8.26213881e-03f, 8.87998939e-03f, -1.53982462e-02f, -2.45504938e-02f, 7.27807805e-02f, 3.55730504e-02f, -4.39564437e-02f, -1.77018084e-02f,
  -1.34488177e-02f, -8.73238407e-03f, 8.07817578e-02f, 2.55317390e-02f, -1.94893647e-02f, -1.00031413e-01f, 1.24756359e-02f, 8.87221918e-02f, 5.17557226e-02f, 1.93972036e-01f,
  5.35862371e-02f, 2.25033704e-02f, -1.40691204e-02f, 8.65145475e-02f, 4.87084463e-02f, -2.98938062e-02f, 9.43417326e-02f, 6.55237213e-02f, 2.38275658e-02f, 1.27065793e-01f,
  -5.67044504e-02f, 3.38056833e-02f, 9.31568220e-02f, 2.69448254e-02f, -9.50744003e-02f, 1.34328529e-02f, 4.52826172e-02f, -6.28330484e-02f, 8.97569507e-02f, 2.44348776e-02f,
  -6.00554561e-03f, 4.34140861e-02f, 5.80743998e-02f, 6.84780106e-02f, 1.39092766e-02f, 1.01948127e-01f, 8.02035034e-02f, 9.66735184e-02f, -2.51574013e-02f, 4.57856245e-02f,
  -1.84006765e-01f, -1.88638628e-01f, 4.15049866e-02f, -7.62859061e-02f, -6.99761063e-02f, -9.40832198e-02f, -2.01533251e-02f, -2.79987417e-02f, -1.03664562e-01f, -1.30690515e-01f,
  -7.99705833e-02f, -1.20672680e-01f, -1.27664983e-01f, 2.48888470e-02f, 7.64127355e-03f, -9.94487852e-02f, -5.71416840e-02f, 1.77441165e-03f, -4.98850010e-02f, -3.58231068e-02f,
  -1.10757932e-01f, -1.17373839e-02f, 7.72869438e-02f, -9.74545032e-02f, -8.29622447e-02f, -2.97561064e-02f, 8.26638006e-03f, 4.29440849e-02f, -1.40605301e-01f, 4.57534790e-02f,
  -3.82031262e-01f, -2.25632370e-01f, -2.02192903e-01f, -2.23198570e-02f, 2.86291875e-02f, -3.67765315e-02f, -3.12637448e-01f, -8.88099596e-02f, 3.25262137e-02f, -2.01072201e-01f,
  -2.37443596e-02f, 9.75565240e-02f, 1.15016267e-01f, 5.06031550e-02f, -1.00265190e-01f, -1.08611979e-01f, -2.99109761e-02f, -7.42137758e-03f, -6.40151873e-02f, -6.96961815e-03f,
  1.06628105e-01f, 9.22933370e-02f, 4.70829895e-03f, -4.32127342e-02f, -1.45279774e-02f, 1.49292545e-02f, -1.30709380e-01f, -7.97710419e-02f, 4.77363244e-02f, -1.39590129e-01f,
  -2.21143961e-01f, -1.93809167e-01f, 2.14062277e-02f, 4.13447153e-03f, 7.99230952e-03f, -7.96296299e-02f, -1.00640446e-01f, -5.28670028e-02f, -7.34723434e-02f, 1.38167273e-02f,
  3.26414499e-03f, -3.22852954e-02f, 4.55086306e-02f, 1.03015520e-01f, -1.97312608e-02f, -2.99255513e-02f, -1.31023116e-02f, 1.36509854e-02f, -1.42276073e-02f, 6.17759116e-02f,
  9.06820819e-02f, 2.56559122e-02f, 6.35099504e-03f, 2.82369591e-02f, -9.86667722e-02f, 5.68757392e-02f, -1.22749761e-01f, -6.37558624e-02f, -9.75463688e-02f, -6.05761148e-02f,
  3.60438973e-02f, 1.28105637e-02f, 2.96574682e-02f, 7.13584423e-02f, 4.79164347e-02f, 3.16830166e-02f, 2.98465211e-02f, 3.25707868e-02f, 5.00555336e-02f, 3.98716182e-02f,
  -4.02088836e-02f, 4.03812826e-02f, 5.08341305e-02f, -1.11840129e-01f, -5.72781339e-02f, 7.66773671e-02f, 1.90093704e-02f, -6.49124086e-02f, 3.36256921e-02f, -2.08753608e-02f,
  5.67944497e-02f, 1.11106252e-02f, 2.62171049e-02f, 6.12538196e-02f, 3.88551690e-02f, 1.43012991e-02f, -3.01814601e-02f, 4.37402092e-02f, 5.82033396e-02f, -2.06433479e-02f,
  -1.04102865e-01f, 6.35389164e-02f, -1.53330237e-01f, -6.48630857e-02f, -1.02569051e-01f, -7.07754195e-02f, -1.82832181e-01f, -5.11347130e-03f, -9.01422203e-02f, -1.34473264e-01f,
  -1.13751248e-01f, -1.66917950e-01f, -2.87760589e-02f, -5.71310930e-02f, -6.63057715e-02f, -7.39486795e-03f, 1.29212607e-02f, -7.07379282e-02f, -3.17782275e-02f, -7.43139237e-02f,
  -5.10905590e-03f, -1.94712915e-02f, 1.21559936e-03f, -8.71704817e-02f, -3.05966493e-02f, -1.92776471e-02f, -2.22007036e-02f, -1.38621330e-01f, -1.62158102e-01f, -1.37330636e-01f,
  -4.27838825e-02f, -1.68641731e-01f, 2.06678048e-01f, -1.58651799e-01f, -8.76399800e-02f, -1.10203519e-01f, 3.04836202e-02f, -8.77633616e-02f, -2.51503885e-01f, -5.46077713e-02f,
  -1.92564607e-01f, -3.10566485e-01f, -1.62308931e-01f, -6.25523850e-02f, 3.14950943e-02f, 4.64543365e-02f, 1.02889255e-01f, 2.10066177e-02f, -1.02189919e-02f, -1.60703510e-01f,
  -2.60022968e-01f, -1.35870710e-01f, -8.90208036e-03f, -9.63460803e-02f, -2.04441696e-01f, -1.33915365e-01f, -9.90739390e-02f, -2.31922597e-01f, -8.41974095e-02f, -8.72509703e-02f,
  1.12625845e-01f, -1.36664212e-01f, -1.31868403e-02f, -2.00623065e-01f, -5.65971434e-02f, -1.22855514e-01f, -4.83209565e-02f, -4.34496664e-02f, -8.37260634e-02f, -8.78167897e-02f,
  -1.81838602e-01f, -1.70297965e-01f, -7.87942335e-02f, -7.01337382e-02f, -3.05572171e-02f, -7.94737637e-02f, -2.96342932e-02f, -6.61347508e-02f, 3.56210619e-02f, -2.21357346e-02f,
  -8.36235955e-02f, -1.52285501e-01f, 1.57800391e-02f, -1.17720865e-01f, -1.02100171e-01f, -1.18607722e-01f, -1.59487769e-01f, -4.83897552e-02f, -1.28564863e-02f, -1.00097187e-01f,
  -2.35571861e-02f, -1.56898573e-02f, 4.96674739e-02f, 1.05920762e-01f, 6.80069849e-02f, -2.23973691e-02f, 2.49478756e-03f, 5.09509593e-02f, 1.07328728e-01f, 8.98757353e-02f,
  1.82753488e-01f, 5.76605871e-02f, 9.01732594e-02f, 1.69991732e-01f, 1.88127264e-01f, 8.24545249e-02f, 9.62300003e-02f, 8.85032192e-02f, 2.32548833e-01f, 1.35705173e-01f,
  1.49536788e-01f, 1.44431427e-01f, 1.48689002e-01f, 9.73360017e-02f, 1.08741112e-01f, 1.57635719e-01f, 3.52479257e-02f, 1.75083563e-01f, 1.15025125e-01f, 1.20143928e-01f,
  -2.50309497e-01f, -3.63371000e-02f, -1.48763796e-02f, -2.19000839e-02f, -1.42772317e-01f, -9.14274901e-02f, -1.49527922e-01f, -1.85520239e-02f, -5.98677397e-02f, -1.02105020e-02f,
  -1.41382799e-01f, 1.56043498e-02f, -1.27547339e-01f, -4.66779359e-02f, -5.40737063e-03f, -9.17705894e-02f, -1.18509851e-01f, -2.51458399e-02f, -1.42702043e-01f, -8.39404017e-02f,
  -1.50346562e-01f, -6.61584660e-02f, -2.20675319e-01f, -1.01961635e-01f, -1.94725528e-01f, -1.00015491e-01f, -1.06408998e-01f, -2.07034558e-01f, -1.72748774e-01f, 6.73468504e-03f,
  6.27722144e-02f, -3.62084091e-01f, 1.03071757e-01f, -1.67499214e-01f, -1.72912061e-01f, -2.35349387e-02f, 6.81111589e-02f, -5.26238605e-02f, -2.45219901e-01f, -1.69660404e-01f,
  -1.68120325e-01f, -1.88120734e-02f, 1.03251353e-01f, 3.20515363e-03f, 1.99826494e-01f, 9.95643958e-02f, 2.12681610e-02f, 2.75037587e-01f, 3.55016410e-01f, 1.19549304e-01f,
  -2.15331048e-01f, -1.64468706e-01f, 1.32766012e-02f, -4.27371487e-02f, -2.29929835e-01f, 2.10825428e-02f, -1.17397338e-01f, -8.41960385e-02f, -9.00152475e-02f, -2.35602349e-01f,
  7.58922920e-02f, -1.09478422e-01f, 9.46266055e-02f, -1.97878741e-02f, -1.00452825e-01f, -2.87330560e-02f, -6.43735752e-02f, -3.17964554e-02f, -8.23687688e-02f, -7.10728988e-02f,
  -1.17953189e-01f, -1.59785952e-02f, 6.67390926e-03f, -1.45269439e-01f, -1.52334824e-01f, 4.35145460e-02f, -2.23132968e-02f, 2.34489832e-02f, -1.05409464e-02f, -1.04986638e-01f,
  -1.47509769e-01f, -6.62368163e-02f, -1.51992552e-02f, -4.76601906e-02f, 4.26831879e-02f, -2.75771562e-02f, -6.10512123e-02f, -1.51870102e-01f, -3.70591320e-02f, -2.05188841e-01f,
  7.11807162e-02f, 5.51657081e-02f, -9.71989054e-03f, -1.99687518e-02f, 5.28325289e-02f, -6.01964295e-02f, 1.92422569e-02f, -1.45440083e-02f, 3.36940587e-02f, -4.88441475e-02f,
  -3.49431559e-02f, 3.17905322e-02f, 1.79892667e-02f, -5.21335900e-02f, -2.83503756e-02f, -8.45505223e-02f, 6.37763366e-02f, -7.15510473e-02f, 3.96937579e-02f, -2.17931736e-02f,
  2.17467137e-02f, 4.76829074e-02f, -2.98873372e-02f, -8.84408206e-02f, -4.11126241e-02f, 4.71450128e-02f, 1.27217481e-02f, -1.50029128e-02f, 7.63424113e-02f, 3.94035913e-02f,
  -1.24246985e-01f, 9.04998556e-03f, 3.05492580e-02f, 4.23588715e-02f, -1.34924337e-01f, -5.86995035e-02f, -1.31231666e-01f, -1.19897336e-01f, -1.17686711e-01f, -7.05807358e-02f,
  -1.34661406e-01f, -1.50397522e-02f, -1.50507957e-01f, -9.55202244e-03f, 2.08350383e-02f, -1.68605447e-01f, -8.31791237e-02f, -7.79596791e-02f, -1.13399051e-01f, -1.07350022e-01f,
  -1.11623906e-01f, -1.25401109e-01f, 4.61579859e-02f, -4.87307310e-02f, -7.32222423e-02f, 8.95306170e-02f, -1.12012271e-02f, -7.77838659e-03f, 1.16141692e-01f, 4.44929749e-02f,
  2.26797715e-01f, -1.35033891e-01f, 2.40414426e-01f, -1.30452551e-02f, -6.69757426e-02f, 2.31394947e-01f, 4.50079069e-02f, 9.73532125e-02f, -3.98832373e-03f, 5.41801099e-03f,
  1.30185392e-02f, -6.80560842e-02f, -1.80229601e-02f, -3.11797503e-02f, 1.00239843e-01f, 1.69612914e-02f, -1.14880092e-01f, 1.10959075e-01f, 3.21456790e-01f, 7.76378438e-02f,
  -6.98273480e-02f, 6.35875687e-02f, 1.19104408e-01f, 9.54181477e-02f, -1.84653342e-01f, 1.02339499e-02f, 8.65456648e-03f, -3.69520336e-02f, -6.50271401e-02f, -1.53703704e-01f,
  6.88223466e-02f, 9.92530957e-03f, 1.37256116e-01f, 1.79317035e-02f, 7.16623440e-02f, 1.03213347e-01f, 1.19944051e-01f, 8.35276917e-02f, -4.12754752e-02f, 4.27170731e-02f,
  4.84813675e-02f, 2.14790031e-02f, -7.79155120e-02f, -4.51871753e-02f, 5.55826314e-02f, 1.47606403e-01f, -2.25177146e-02f, 1.54383751e-02f, 7.78655112e-02f, 1.31517857e-01f,
  1.32542895e-02f, 8.64644721e-02f, 1.33773789e-01f, 1.32449314e-01f, 6.00801781e-02f, 4.65562604e-02f, 6.15470260e-02f, -2.65302043e-02f, 1.62362292e-01f, 7.24352598e-02f,
  5.64609878e-02f, -1.27381578e-01f, -4.46630530e-02f, -1.37252420e-01f, -1.07601933e-01f, -3.99718508e-02f, -1.84405148e-01f, 2.50563025e-03f, -9.21872035e-02f, 8.45567062e-02f,
  2.10689032e-03f, 3.14894877e-02f, -5.43834344e-02f, 5.08391783e-02f, -3.41283791e-02f, -4.80081700e-02f, 1.10944863e-02f, -7.60519654e-02f, -3.78889516e-02f, 6.02206141e-02f,
  -6.88852966e-02f, -2.07694676e-02f, -1.47915231e-02f, -1.42276206e-03f, -1.06627055e-01f, 6.30965969e-03f, 3.50542553e-02f, -7.33070299e-02f, -1.63901318e-02f, -3.79258627e-03f,
  2.99555417e-02f, 1.41801894e-01f, 1.10903867e-01f, 4.96585853e-02f, 1.38902932e-01f, -1.93190688e-04f, 4.69005387e-03f, 6.62843809e-02f, 5.43874875e-02f, 1.43798003e-02f,
  4.04665060e-02f, 8.03001691e-03f, 5.37549704e-02f, 1.04603589e-01f, 3.29095908e-02f, -1.92883927e-02f, 4.21107858e-02f, 1.60264105e-01f, -3.01844552e-02f, 1.13478839e-01f,
  -2.50733108e-03f, 2.21798077e-01f, 1.58231109e-01f, 1.35375902e-01f, -8.07896908e-03f, 1.30173862e-01f, 2.08202839e-01f, 1.16557665e-01f, 1.97593302e-01f, 1.16339825e-01f,
  -1.63116753e-01f, 2.71496952e-01f, 7.26179928e-02f, 7.96918664e-03f, 2.25244105e-01f, 8.43925178e-02f, 1.73773035e-01f, 6.18490987e-02f, 9.80137289e-02f, 1.83360800e-01f,
  1.30483851e-01f, 2.10707504e-02f, -4.86617349e-02f, -6.54882863e-02f, -1.21571369e-01f, 9.55118537e-02f, 9.87155288e-02f, -3.84026840e-02f, -1.31156549e-01f, 6.01381958e-02f,
  1.66418165e-01f, 1.06120422e-01f, -1.05885416e-01f, -4.45948690e-02f, 1.31292403e-01f, 2.60740332e-03f, 7.11803287e-02f, 2.40670934e-01f, 2.26460651e-01f, 3.02319795e-01f,
  1.30645698e-02f, 2.20028266e-01f, 8.60967711e-02f, 8.71627256e-02f, 1.11559033e-01f, -5.09386184e-03f, 7.17447475e-02f, 5.44067211e-02f, 2.26980895e-02f, 1.02290697e-01f,
  1.89916089e-01f, 8.81900936e-02f, 1.46776557e-01f, 1.19283922e-01f, 1.55015886e-01f, 7.12853298e-02f, 8.97174999e-02f, 1.28979340e-01f, 5.24003692e-02f, 1.27734154e-01f,
  2.88356304e-01f, 2.83458143e-01f, 8.99643824e-02f, 1.99664786e-01f, 2.21837863e-01f, 3.97070684e-02f, 2.68290937e-01f, 1.62249252e-01f, 6.21097349e-02f, 9.55482051e-02f,
  -1.23277560e-01f, -5.61642200e-02f, 5.33182779e-03f, -1.47966787e-01f, -7.32174069e-02f, -7.95832351e-02f, 3.07797976e-02f, -1.13564834e-01f, -2.79288329e-02f, -2.83553340e-02f,
  -4.23022360e-02f, -1.26601951e-02f, -8.62866268e-02f, -9.51555669e-02f, -7.94964358e-02f, -1.06641315e-01f, -7.06613138e-02f, -1.70568712e-02f, -9.53549221e-02f, -1.29276842e-01f,
  1.91814713e-02f, -2.43185721e-02f, -9.67517029e-03f, -6.65074438e-02f, -1.17690921e-01f, -5.16958311e-02f, -7.95857608e-02f, -2.12033257e-01f, -1.17990479e-01f, -7.69242868e-02f,
  -3.25376540e-02f, 1.15145385e-01f, 1.19199447e-01f, 1.37790263e-01f, 1.59481481e-01f, 2.00590536e-01f, 2.09044665e-01f, 7.25703537e-02f, 1.29915208e-01f, 9.88401994e-02f,
  1.38135135e-01f, 8.96064192e-03f, 1.43132135e-01f, 1.06249020e-01f, 3.59018184e-02f, 1.14605464e-01f, 9.79666263e-02f, 9.46918502e-02f, 8.96601081e-02f, 1.20851308e-01f,
  9.72022191e-02f, 1.38305277e-01f, 1.02258727e-01f, 4.67770584e-02f, 1.11533880e-01f, 7.71280527e-02f, 1.26643822e-01f, 1.49267390e-01f, 5.44584952e-02f, -8.21012929e-02f,
  2.83601701e-01f, -1.41874984e-01f, -1.77580461e-01f, 2.99496472e-01f, -2.59009749e-01f, -2.54874468e-01f, -3.89993131e-01f, -1.10885054e-01f, 1.27486616e-01f, -8.77419040e-02f,
  -7.52913505e-02f, 9.29605067e-02f, 3.05798221e-02f, 6.09375015e-02f, 1.53077664e-02f, -1.09148763e-01f, -3.26969214e-02f, 1.34648934e-01f, 1.08833581e-01f, 8.01732857e-03f,
  3.55403610e-02f, 1.78989857e-01f, 2.45040163e-01f, 6.74031377e-02f, -2.89328806e-02f, 2.17657816e-02f, -3.55246887e-02f, 1.05609879e-01f, -2.47110892e-02f, 1.79390520e-01f,
  -6.22853599e-02f, 3.59626263e-02f, 7.42681223e-05f, 1.76873401e-01f, 5.44025674e-02f, 3.78254354e-02f, -6.16731457e-02f, 1.00464925e-01f, 6.52739778e-04f, -3.63674685e-02f,
  2.91246194e-02f, 1.26879632e-01f, 9.55349654e-02f, 6.91775000e-03f, -1.78677533e-02f, 2.67302990e-02f, 5.47866896e-02f, 1.84601977e-01f, 8.56414139e-02f, 7.46537969e-02f,
  1.69632018e-01f, 1.45696938e-01f, -7.55183324e-02f, -4.73769866e-02f, -2.37696525e-02f, 1.12604327e-01f, 2.12997124e-02f, 7.65126571e-02f, 9.19023901e-02f, 2.62666177e-02f,
  -4.59003076e-02f, -2.12849267e-02f, -3.64255495e-02f, -6.15005828e-02f, -2.46529672e-02f, -3.65708806e-02f, -3.55769172e-02f, 2.91434377e-02f, -1.21358417e-01f, 9.28660762e-03f,
  1.61637925e-02f, -3.64886709e-02f, -9.26381424e-02f, 2.59427913e-02f, -6.88933879e-02f, -2.44250279e-02f, -7.02613126e-03f, 2.57529747e-02f, -4.35528345e-02f, -4.92152339e-03f,
  -2.51784828e-02f, -4.36466336e-02f, 4.28887755e-02f, -5.84949702e-02f, -5.16519025e-02f, 4.31140065e-02f, 6.23430707e-04f, -2.89433300e-02f, 2.04513222e-02f, 5.92470393e-02f,
  8.05926025e-02f, 9.60080251e-02f, 1.15148716e-01f, -1.21178222e-03f, 5.18827289e-02f, 9.79948640e-02f, 3.76635976e-02f, 9.42695886e-02f, 1.21917233e-01f, 3.03165708e-02f,
  3.67451720e-02f, 5.28783761e-02f, -4.05497849e-02f, -9.87725146e-03f, 9.52245966e-02f, 7.33785843e-03f, -4.93970551e-02f, 8.42854008e-02f, 1.49262473e-02f, 7.39428252e-02f,
  3.02948039e-02f, 3.07466695e-03f, 5.28493971e-02f, 8.12549330e-03f, 3.60425338e-02f, 9.59228203e-02f, -1.32601544e-01f, 6.52768984e-02f, -1.91508289e-02f, -8.94995257e-02f,
  -2.83679873e-01f, -1.25666335e-01f, -2.05860093e-01f, -4.42749858e-01f, -2.37822250e-01f, 1.86282545e-02f, -6.32166341e-02f, 2.12287474e-02f, -1.33502945e-01f, -1.70009956e-01f,
  -9.74319205e-02f, -3.98781113e-02f, -8.90127209e-04f, -8.30767900e-02f, -1.53066106e-02f, -7.33840391e-02f, -2.40541324e-01f, -4.69063297e-02f, 1.26570538e-01f, 5.48539609e-02f,
  -5.24273925e-02f, -1.63082138e-01f, -4.27852245e-03f, 6.23069219e-02f, -1.75314352e-01f, -8.25881958e-02f, -3.80667895e-02f, -9.51291844e-02f, -3.13426591e-02f, -1.08377792e-01f,
  -5.12381531e-02f, -1.92701876e-01f, 2.52418366e-04f, -6.44885078e-02f, -3.15520018e-02f, 5.10709733e-02f, -7.10526779e-02f, 2.10586260e-03f, -2.83057094e-02f, -1.72187146e-02f,
  3.12466151e-03f, 7.36586750e-02f, -4.78340834e-02f, 8.78516734e-02f, -5.02360761e-02f, -8.27908143e-02f, -8.20981413e-02f, 2.05069482e-02f, -4.02088948e-02f, -1.00046787e-02f,
  2.86652874e-02f, -1.03030361e-01f, 2.48114541e-02f, -1.29801035e-02f, 7.09415376e-02f, -3.31756882e-02f, 9.25625674e-03f, -2.48989090e-02f, 9.05506536e-02f, -6.54309094e-02f,
  1.05224617e-01f, 1.71632886e-01f, 1.37956753e-01f, 2.40401942e-02f, 3.83836441e-02f, -2.00580917e-02f, -2.16698311e-02f, 5.38192913e-02f, 2.17304584e-02f, 1.21668488e-01f,
  -7.79277906e-02f, 3.96207487e-03f, -6.91512274e-03f, 7.35766292e-02f, 8.35380480e-02f, 5.29548526e-02f, 1.17068432e-01f, 1.21360309e-01f, 1.42672986e-01f, -2.21457779e-02f,
  -7.01785237e-02f, 1.37981251e-01f, 6.32606372e-02f, 7.65680149e-02f, 3.59871648e-02f, 2.45476756e-02f, -3.19157951e-02f, 1.22007374e-02f, 2.08767876e-03f, 7.36923963e-02f,
  -1.58754990e-01f, -5.10341451e-02f, -9.25079361e-02f, 4.08081375e-02f, 3.72057706e-02f, -2.38257926e-03f, -3.43283527e-02f, -4.47748154e-02f, 4.10565771e-02f, 4.97246124e-02f,
  -9.54459235e-02f, -3.54097784e-02f, -9.03948620e-02f, -6.30020276e-02f, -1.36570543e-01f, -2.47330917e-03f, -2.77704336e-02f, -1.51772976e-01f, -6.76112324e-02f, 3.25078592e-02f,
  -8.94764513e-02f, -2.78473925e-03f, -1.61423385e-01f, -2.59483270e-02f, -1.17278427e-01f, -1.09957762e-01f, -6.88584447e-02f, 3.88382981e-03f, 5.48570454e-02f, 1.19508039e-02f,
  -7.82155320e-02f, -2.77897753e-02f, -5.56978807e-02f, -1.95833459e-01f, -1.41925991e-01f, -1.69718772e-01f, -2.93842375e-01f, -1.71022117e-01f, -7.99428672e-02f, -1.31866232e-01f,
  5.17441295e-02f, 1.98627748e-02f, -1.35523796e-01f, -1.67944685e-01f, -2.33661830e-01f, -2.13754311e-01f, -1.02123313e-01f, -1.94427714e-01f, -2.71597832e-01f, -1.84054896e-01f,
  -1.89523652e-01f, 6.24141656e-03f, -1.04206763e-01f, -1.25872549e-02f, 9.90716182e-03f, -4.86214831e-03f, 3.96161042e-02f, -2.92166993e-02f, 5.18380702e-02f, 3.59299518e-02f,
  -2.40328342e-01f, -9.81886908e-02f, -3.26562561e-02f, 1.01113372e-01f, 7.98067078e-02f, 5.01187555e-02f, -7.40572959e-02f, -1.44394897e-02f, 1.77957099e-02f, -1.08323254e-01f,
  5.43918163e-02f, 1.75212957e-02f, -1.33568812e-02f, -5.32123307e-03f, 2.29624696e-02f, -1.09847277e-01f, 1.08890519e-01f, 3.83322239e-02f, -5.33377118e-02f, -2.21379083e-02f,
  8.24190006e-02f, 7.43040591e-02f, -4.35312241e-02f, -2.42596362e-02f, -4.19639423e-02f, 8.86998400e-02f, 9.36192945e-02f, -7.16867298e-02f, -2.60386914e-02f, 7.74152055e-02f,
  -1.28138170e-01f, -4.07115035e-02f, -8.48086327e-02f, 7.65178204e-02f, -4.13770638e-02f, -3.05153374e-02f, -1.51551925e-02f, -7.53848776e-02f, -9.52764750e-02f, 7.77888596e-02f,
  -1.00457249e-02f, -9.20728371e-02f, -1.19107543e-02f, -1.08857952e-01f, -2.80923862e-02f, -2.98420023e-02f, -7.06365705e-03f, -1.11166917e-01f, 2.36682370e-02f, 2.32963525e-02f,
  -6.69935066e-03f, 7.06148148e-03f, 8.00220892e-02f, -7.23985583e-02f, 8.73655546e-03f, -1.19016133e-01f, -3.38302702e-02f, -1.22517437e-01f, -3.78557146e-02f, -7.98374489e-02f,
  -1.28722385e-01f, 1.07082896e-01f, 2.88968738e-02f, -5.56570590e-02f, -3.83304842e-02f, 3.59323099e-02f, 8.82880613e-02f, 5.41971400e-02f, 5.83709925e-02f, -2.85549033e-02f,
  2.26897504e-02f, -8.00678283e-02f, 3.44069079e-02f, 1.46371499e-01f, -2.34145168e-02f, -9.28278640e-02f, 1.53413676e-02f, -2.83382908e-02f, 7.31023997e-02f, 4.11183275e-02f,
  -4.36877608e-02f, -4.46509160e-02f, -2.03441661e-02f, -2.27817502e-02f, 9.37690143e-04f, 5.62196150e-02f, -5.73313907e-02f, 8.14395025e-02f, 6.07981486e-03f, -1.59575298e-01f,
  2.09710732e-01f, 1.04519986e-01f, 3.31003331e-02f, 1.93578899e-01f, 1.60802454e-01f, 2.13631638e-03f, 8.95670429e-02f, 4.88041341e-02f, 1.22734010e-01f, -1.67755280e-02f,
  -6.18004575e-02f, 5.12642972e-02f, 2.06384324e-02f, -2.03380436e-02f, -2.61242837e-02f, -2.67025419e-02f, 4.23361314e-03f, -1.22158816e-02f, 6.50164932e-02f, -7.69279106e-03f,
  -4.81401011e-02f, 1.69440463e-01f, 7.78485015e-02f, 1.09692924e-01f, 4.77485964e-03f, 1.81939695e-02f, -5.12188021e-03f, 1.48839638e-01f, 2.19973586e-02f, 8.04905295e-02f,
  -2.69424245e-02f, 2.06358805e-01f, -4.54064272e-02f, 1.59866605e-02f, 3.18928668e-03f, -6.10262677e-02f, -2.75448170e-02f, 1.27492964e-01f, -2.75331847e-02f, 4.71206456e-02f,
  8.96751881e-02f, 1.32014528e-01f, 2.83385646e-02f, -4.10503298e-02f, 9.05119535e-03f, -9.18691512e-03f, -7.18881264e-02f, -6.68627545e-02f, 3.27947587e-02f, -1.65898935e-03f,
  -7.88377225e-03f, 1.19617686e-01f, 1.08890817e-01f, 5.31483144e-02f, -6.88241571e-02f, 6.26103953e-02f, -1.48796150e-02f, 1.15065262e-01f, 3.38675156e-02f, -1.11851498e-01f,
  -6.71614781e-02f, -4.22792956e-02f, -3.00955568e-02f, 3.24496394e-03f, -5.85521245e-03f, 2.64923065e-03f, 7.99398795e-02f, -5.25922738e-02f, 7.55277425e-02f, -5.06524602e-03f,
  4.11774181e-02f, 8.63587558e-02f, -4.60900664e-02f, 3.44776101e-02f, 1.36227444e-01f, 1.73605770e-01f, 2.05565225e-02f, 9.26082656e-02f, 9.84961689e-02f, 1.16292536e-01f,
  1.67097226e-01f, 3.48783955e-02f, -1.58398338e-02f, 7.56862313e-02f, 3.78169715e-02f, 1.13226354e-01f, -8.27456545e-03f, 1.52831525e-01f, 6.56724498e-02f, 1.93748623e-01f,
  -8.90412927e-02f, -6.00453056e-02f, -4.11283858e-02f, 6.00091591e-02f, 4.29587923e-02f, -1.79828275e-02f, -9.76945832e-02f, -6.70601353e-02f, 3.30450535e-02f, -3.15136611e-02f,
  -1.55341523e-02f, -5.47599420e-02f, -2.81886291e-02f, -7.48698041e-02f, -9.66827124e-02f, -4.10347357e-02f, -1.58156857e-01f, -9.57007799e-03f, -6.74854368e-02f, -8.61426294e-02f,
  -2.24962104e-02f, -1.34474918e-01f, 2.08092127e-02f, -4.03957963e-02f, -1.14437371e-01f, -6.57744184e-02f, -4.33518626e-02f, -9.58334431e-02f, -7.83402994e-02f, -2.64653414e-01f,
  1.10715427e-01f, 3.56766045e-01f, 1.02043107e-01f, -4.61251512e-02f, 1.27217636e-01f, 1.82721153e-01f, 3.42969179e-01f, 1.53294345e-02f, -1.82962790e-02f, 1.26617834e-01f,
  -5.30083962e-02f, -2.39743099e-01f, -1.57495171e-01f, -1.72428682e-01f, -1.32873535e-01f, 2.16131300e-01f, 2.67983437e-01f, 4.22183685e-02f, -6.23734444e-02f, -1.62505619e-02f,
  -4.41654846e-02f, 4.48382981e-02f, -1.12957299e-01f, 5.62319756e-02f, 8.46268758e-02f, -3.28470804e-02f, 4.31965254e-02f, -8.33582506e-02f, 2.47575287e-02f, 1.48875087e-01f,
  -7.68030481e-03f, 9.21284705e-02f, 6.26894981e-02f, 2.54177628e-03f, 4.24984694e-02f, 1.45554185e-01f, 9.71842408e-02f, 2.93158684e-02f, 2.19607409e-02f, 8.46020430e-02f,
  1.42060397e-02f, 3.35725024e-02f, 6.03720844e-02f, 3.16573456e-02f, 1.18349627e-01f, 8.71790722e-02f, 5.61568923e-02f, -5.27386963e-02f, 1.16551504e-01f, 1.74735427e-01f,
  1.17524646e-01f, 1.09426528e-01f, 8.62303078e-02f, 3.59521285e-02f, 8.23404491e-02f, 8.17104895e-03f, 1.11960836e-01f, 3.11162155e-02f, -4.39291410e-02f, 1.92677081e-01f,
  1.01117060e-01f, -6.04330227e-02f, -1.25039548e-01f, -9.48705226e-02f, -3.95413488e-02f, -1.39824077e-01f, -4.70315553e-02f, -9.16777253e-02f, -6.93834051e-02f, -5.58244474e-02f,
  -1.25773847e-01f, -1.20332301e-01f, -1.50199775e-02f, -4.17771265e-02f, -3.00054979e-02f, -4.92515266e-02f, -4.17810865e-02f, -9.44524109e-02f, -7.61009380e-02f, -4.74758074e-02f,
  -1.16270542e-01f, -1.16641618e-01f, -1.63402036e-01f, -9.32823196e-02f, -1.07376799e-01f, -1.05798386e-01f, -8.00406784e-02f, -2.42026616e-02f, -1.03288054e-01f, -7.68744424e-02f,
  -1.17543172e-02f, -1.33282959e-01f, 5.08909710e-02f, 1.64496645e-01f, 7.49563500e-02f, 2.45705191e-02f, 1.31571442e-01f, 6.47985116e-02f, 1.25103235e-01f, 7.77817145e-02f,
  6.00379892e-02f, 5.50584979e-02f, 1.01936631e-01f, 8.57412219e-02f, 5.40576838e-02f, 4.79908548e-02f, 1.29544452e-01f, 9.50762331e-02f, 4.27051894e-02f, 1.57692656e-01f,
  1.51557639e-01f, 1.14530519e-01f, 1.14049770e-01f, 1.04683377e-01f, 3.99729945e-02f, -3.96974105e-03f, 1.25383675e-01f, -2.19376590e-02f, 6.90624043e-02f, 2.06389025e-01f,
  3.86630833e-01f, -7.42436722e-02f, 1.97365671e-01f, -1.55399079e-02f, -1.67247653e-01f, -3.27151939e-02f, 1.57563481e-02f, 1.00496620e-01f, -2.63120569e-02f, 6.80513009e-02f,
  -2.73052961e-01f, -2.26137862e-01f, -1.93541080e-01f, -6.68322518e-02f, 1.43581122e-01f, 9.49869826e-02f, 1.57928079e-01f, 2.94892699e-01f, 2.36404777e-01f, -1.04126342e-01f,
  -9.56683308e-02f, -9.85933468e-03f, 2.40721613e-01f, 4.03804444e-02f, 1.06286854e-02f, -1.27988234e-01f, 8.51024911e-02f, 3.77955623e-02f, 4.76187542e-02f, 1.22862644e-01f,
  3.47089991e-02f, 6.85214251e-02f, 5.89623787e-02f, -1.04894795e-01f, -1.47210389e-01f, 6.55068317e-03f, -6.11930527e-02f, 1.41763628e-01f, -7.34998882e-02f, 1.93234570e-02f,
  -7.39263222e-02f, -7.03658015e-02f, -8.44063610e-02f, 2.82119885e-02f, 7.52127692e-02f, 2.58052535e-02f, 1.08773179e-01f, 1.69041291e-01f, 8.62227827e-02f, -2.88332291e-02f,
  -1.83323070e-01f, -2.89087687e-02f, -5.43734524e-03f, 4.38323505e-02f, 7.13549834e-03f, 6.85308874e-02f, 9.19789914e-03f, 4.67987396e-02f, 1.68947816e-01f, 1.80196688e-01f,
  1.24935266e-02f, 5.23754582e-02f, 3.98177058e-02f, 3.23613063e-02f, -4.22872081e-02f, -6.02035150e-02f, 3.01400330e-02f, -5.37416479e-03f, 5.98372566e-03f, 2.21038144e-03f,
  1.32673383e-02f, 6.48413375e-02f, 4.94935736e-02f, 5.47363348e-02f, -3.11947148e-02f, 3.55904549e-02f, 5.92793301e-02f, -7.91978743e-03f, -5.24575226e-02f, -6.62613735e-02f,
  4.93632257e-02f, 2.38239579e-02f, -4.60332781e-02f, -3.51967812e-02f, 6.04495741e-02f, 4.31292802e-02f, 1.64267644e-01f, 5.04334606e-02f, 4.78820354e-02f, 1.42345533e-01f,
  -1.49312243e-01f, -1.30183920e-01f, 8.69063884e-02f, -2.57890970e-02f, 1.71855707e-02f, 2.00792104e-02f, -3.47253680e-02f, -3.79795767e-02f, 9.15747602e-03f, -5.41029908e-02f,
  1.07344594e-02f, 6.08433820e-02f, -1.25923201e-01f, -1.02686062e-02f, -1.42396623e-02f, -2.53887605e-02f, -2.50161020e-03f, -9.32744332e-03f, -5.75788971e-03f, 4.46535945e-02f,
  3.14062573e-02f, 1.25803381e-01f, 4.27343063e-02f, 4.22734879e-02f, -3.93918762e-03f, 1.22097261e-01f, 2.11819839e-02f, 5.90267219e-02f, 1.80969864e-01f, 1.92243487e-01f,
  4.73668128e-01f, -1.95140272e-01f, 6.17442057e-02f, 1.97444065e-03f, -1.96518362e-01f, -1.15495883e-02f, -1.16918683e-01f, 9.23707262e-02f, 6.16167895e-02f, -1.17671594e-01f,
  -7.91356713e-02f, 7.51905367e-02f, 8.21005851e-02f, 9.77287591e-02f, 1.74082205e-01f, -4.61846739e-02f, 2.45800354e-02f, 1.89669281e-01f, 3.65748227e-01f, 1.50363445e-01f,
  7.28347898e-02f, 1.19274549e-01f, 3.09627980e-01f, 6.81372285e-02f, 2.90152971e-02f, 9.57399160e-02f, -6.87093213e-02f, -2.33204607e-02f, -5.08792326e-02f, -9.05002952e-02f,
  -1.01884017e-02f, 8.53666738e-02f, 1.43878087e-01f, 1.46182388e-01f, -1.58024300e-02f, 1.77139506e-01f, 1.17044270e-01f, 7.81384334e-02f, 1.12992413e-01f, 6.45554811e-02f,
  -7.06654340e-02f, 7.49400482e-02f, 1.09205678e-01f, 1.26335518e-02f, 1.67527929e-01f, 2.59464588e-02f, 1.65377900e-01f, 8.63971338e-02f, 2.24221125e-02f, 3.88835594e-02f,
  -5.64576387e-02f, -6.79360852e-02f, 7.62706995e-02f, 7.68321976e-02f, 2.32031406e-03f, 1.10527053e-01f, -5.98561345e-03f, 4.18399684e-02f, 1.05018906e-01f, 1.31696388e-01f,
  4.41963598e-02f, -1.33004934e-01f, -1.48238152e-01f, -9.22465399e-02f, -9.24206302e-02f, -7.07376674e-02f, -8.08626115e-02f, -2.14381590e-01f, -1.21846244e-01f, -9.44438651e-02f,
  -7.87732229e-02f, -4.32285145e-02f, -6.21464513e-02f, -1.03973515e-01f, -1.10424489e-01f, -1.12720460e-01f, -5.55101372e-02f, -1.56052839e-02f, -4.30259705e-02f, -1.03827685e-01f,
  -5.52379079e-02f, -2.03201830e-01f, -1.84776649e-01f, -4.36245613e-02f, -1.26703367e-01f, -1.38799682e-01f, -1.28989026e-01f, -1.57043755e-01f, -1.22759208e-01f, -1.16801381e-01f,
  3.17052230e-02f, 1.03278353e-03f, 1.14548057e-01f, 6.24318048e-02f, 5.55751808e-02f, 1.14795730e-01f, 5.10496907e-02f, 1.70781955e-01f, 9.56071820e-03f, 2.14709088e-01f,
  1.13926291e-01f, 4.13895436e-02f, 8.79298449e-02f, 4.63914797e-02f, 1.74518749e-01f, 1.70978397e-01f, 2.04017293e-02f, 8.80511478e-02f, 9.69057679e-02f, 8.55456144e-02f,
  1.10587761e-01f, 1.87759414e-01f, 1.92032427e-01f, 1.37628511e-01f, 1.24984443e-01f, 1.20770954e-01f, 1.17915407e-01f, 1.97467417e-01f, 1.64290234e-01f, 2.02216014e-01f
};

// L0_fan_Wp_bar (Shape: 26 x 120)
const int L0_fan_Wp_bar_rows = 26;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -2.02895678e-03f, 7.38891885e-02f, 6.07040077e-02f, 1.55081227e-01f, -1.44228870e-02f, -2.11009771e-01f, -2.36189127e-01f, -1.67909339e-01f, 1.67180933e-02f, 5.22241779e-02f,
  -4.07526530e-02f, -6.25216812e-02f, 1.26093864e-01f, -1.38145790e-01f, -2.80057341e-01f, 2.26193249e-01f, 2.75402069e-01f, 2.85054017e-02f, -3.13895494e-01f, -2.83205062e-01f,
  -8.75504315e-02f, -1.45149454e-01f, -1.79002002e-01f, -2.50818599e-02f, 2.35823780e-01f, 5.57356626e-02f, 4.43279855e-02f, 1.05164066e-01f, 2.12322995e-02f, 4.14802134e-01f,
  2.98077703e-01f, -6.29450232e-02f, -1.21248186e-01f, -1.66638773e-02f, 7.53677338e-02f, -4.62764204e-02f, -9.74003896e-02f, 4.27706242e-02f, -7.36216223e-03f, 9.42635313e-02f,
  1.32824376e-01f, 3.04404786e-03f, 1.61545217e-01f, -3.16514750e-03f, -1.74798891e-01f, -1.70448855e-01f, 5.51445223e-03f, -1.40959337e-01f, -6.38786107e-02f, -1.94974225e-02f,
  1.54073030e-01f, -4.36396291e-03f, -8.42718706e-02f, -3.10393646e-02f, -1.10751480e-01f, -1.14393927e-01f, -1.49619669e-01f, -6.04937151e-02f, -2.26290241e-01f, 1.39274955e-01f,
  -4.85993959e-02f, -1.29493445e-01f, 6.76791370e-02f, 3.63263823e-02f, -5.90683073e-02f, 5.85791878e-02f, 1.23933241e-01f, 4.64383252e-02f, 3.60808475e-03f, -6.86358735e-02f,
  3.78920808e-02f, -7.04566091e-02f, 3.46342474e-02f, -4.90941182e-02f, -8.41121972e-02f, -3.36026400e-02f, -2.55124029e-02f, -5.13520762e-02f, -1.61909282e-01f, -6.85885409e-03f,
  -2.62029637e-02f, 7.01210350e-02f, 4.63134907e-02f, 1.22787468e-02f, 7.12551735e-03f, -5.05604446e-02f, 1.36763789e-02f, -1.20111622e-01f, -1.18321210e-01f, -1.87544804e-02f,
  1.65120959e-02f, -2.18314484e-01f, 2.15508446e-01f, -9.35955942e-02f, 7.19464794e-02f, 6.67215809e-02f, 4.82472554e-02f, -3.72147225e-02f, -3.20437737e-02f, -1.11699648e-01f,
  -7.66929463e-02f, 3.96317579e-02f, 8.54643062e-02f, 2.41925456e-02f, -1.04412764e-01f, 4.22640033e-02f, 1.74874719e-03f, -3.84792984e-02f, 7.21788849e-04f, 5.71330190e-02f,
  -6.26682639e-02f, -1.23804234e-01f, -1.53518170e-01f, -6.97426647e-02f, 7.19442740e-02f, -2.69591540e-01f, -1.11207753e-01f, -5.06541952e-02f, -2.47455716e-01f, -3.41634452e-01f,
  4.99912649e-01f, 4.42155540e-01f, 2.68241912e-01f, -2.03378186e-01f, 4.88917679e-02f, 1.52810499e-01f, 3.74116540e-01f, 2.08330035e-01f, -9.50551555e-02f, 6.63194656e-02f,
  7.40255713e-02f, -1.65578589e-01f, -7.01955557e-02f, -8.01466182e-02f, 1.64719000e-01f, 7.75172422e-03f, -1.61647752e-01f, 2.11700015e-02f, 1.34404227e-01f, 1.46125071e-02f,
  -2.54516065e-01f, 7.61363357e-02f, 2.25636691e-01f, 1.09712696e-02f, -8.52666646e-02f, -2.16862947e-01f, -1.34919733e-01f, 6.03386573e-02f, -7.91739374e-02f, -1.84318319e-01f,
  3.84984128e-02f, 4.03188080e-01f, -2.17814729e-01f, 8.18887353e-02f, 1.50549829e-01f, 1.27361372e-01f, 1.16007790e-01f, 7.21540228e-02f, 1.09098688e-01f, -7.02686161e-02f,
  9.86462608e-02f, 2.31246632e-02f, 1.60366759e-01f, 1.27747312e-01f, 1.25677526e-01f, 6.13656044e-02f, 1.72829628e-01f, 1.68943509e-01f, 1.22378662e-01f, 1.22821249e-01f,
  -4.73363996e-02f, 1.33915380e-01f, 2.83199400e-01f, -2.93400488e-03f, 6.31833598e-02f, -1.05413929e-01f, 1.51915610e-01f, 1.14567332e-01f, 1.21457558e-02f, 6.93728402e-02f,
  -2.27867499e-01f, 2.74111256e-02f, 8.12909752e-02f, -6.32553324e-02f, 8.65038019e-03f, 5.78309931e-02f, -2.31084935e-02f, -1.20506756e-01f, -2.41778847e-02f, 5.16581796e-02f,
  1.11899618e-02f, -8.56143609e-02f, -6.38217293e-03f, -1.24832755e-02f, -5.50488122e-02f, 8.92282203e-02f, 6.87158033e-02f, 3.65325101e-02f, -1.15938358e-01f, -9.67199821e-03f,
  2.42745411e-02f, 5.72022200e-02f, -3.04952245e-02f, 1.70933276e-01f, -6.25196993e-02f, 7.12079778e-02f, 1.04387626e-02f, -4.75748032e-02f, 3.91144156e-02f, -1.43780023e-01f,
  -9.92869288e-02f, 3.33451666e-02f, -2.80833304e-01f, -2.66910419e-02f, 2.93056555e-02f, 5.08120246e-02f, -1.78756043e-01f, -6.25222772e-02f, -1.26704261e-01f, -1.21834241e-01f,
  8.46458673e-02f, -1.05398357e-01f, 6.55637234e-02f, 3.45824733e-02f, -9.94795263e-02f, -4.10363153e-02f, -2.91825291e-02f, -8.03325549e-02f, -1.31971478e-01f, -6.23341389e-02f,
  -6.77723810e-02f, -1.35248631e-01f, -9.01388675e-02f, -1.80224001e-01f, -1.63945645e-01f, -2.93301076e-01f, -3.04661710e-02f, -8.21810886e-02f, 2.81862523e-02f, -1.95361257e-01f,
  5.13319433e-01f, -1.92549184e-01f, 9.34225768e-02f, 2.42751330e-01f, 2.81193614e-01f, 1.91684425e-01f, 1.69945613e-01f, 1.13845214e-01f, 2.42856339e-01f, 1.83566347e-01f,
  1.11526117e-01f, 2.53557533e-01f, 1.01149492e-01f, 5.41331843e-02f, 1.72850192e-01f, 1.47995008e-02f, 1.99287638e-01f, 2.14323670e-01f, 1.12916343e-01f, 1.87811583e-01f,
  1.76285729e-01f, -6.32943760e-04f, 9.61397588e-02f, 1.35148749e-01f, 3.32253017e-02f, 2.09039941e-01f, 4.70624417e-02f, -1.04122264e-02f, 8.74346048e-02f, 4.48656734e-03f,
  -2.54731536e-01f, -2.31182836e-02f, 8.63513052e-02f, -9.46690217e-02f, -1.50485486e-01f, -1.66306749e-01f, 5.36164343e-02f, -1.10869400e-01f, -9.37865302e-02f, -7.90249482e-02f,
  2.24857163e-02f, -1.99137554e-02f, 3.32985595e-02f, -1.78181883e-02f, -7.88293183e-02f, -4.91263978e-02f, -1.22258402e-01f, -6.58926144e-02f, -2.41560880e-02f, -1.20980524e-01f,
  -3.06363087e-02f, -8.30379594e-03f, 2.05062386e-02f, 3.42929922e-02f, 6.57351166e-02f, 1.08048707e-01f, 1.61155872e-02f, -2.40365556e-03f, -7.30717853e-02f, -6.80986121e-02f,
  4.38098647e-02f, -7.96318650e-02f, 8.69923458e-02f, 6.09494597e-02f, 8.06354731e-02f, 1.10936671e-01f, 5.60290962e-02f, -6.88516349e-02f, 1.01484224e-01f, 1.19757637e-01f,
  5.70728853e-02f, -3.03002987e-02f, -1.08717710e-01f, 5.75372949e-02f, 5.27534336e-02f, -1.16428584e-01f, -1.84532508e-01f, 1.87566876e-02f, 4.92734239e-02f, 6.98082820e-02f,
  1.01816863e-01f, -4.91023585e-02f, 2.41654180e-02f, -3.49477716e-02f, 4.57770377e-02f, 4.66813857e-04f, 1.60306200e-01f, -5.06343767e-02f, 5.68110533e-02f, 2.63613705e-02f,
  -4.65356618e-01f, 1.73218489e-01f, 1.34112552e-01f, -9.56300795e-02f, -1.01538904e-01f, -1.03424177e-01f, 3.11358087e-02f, -1.61315918e-01f, -1.71665087e-01f, -1.17366694e-01f,
  -8.48370641e-02f, 1.03645748e-03f, -8.66421685e-02f, 3.36469524e-02f, -7.44981505e-03f, -1.31231740e-01f, -1.29147664e-01f, -1.78323179e-01f, -1.45494580e-01f, -1.32531434e-01f,
  -7.52093038e-03f, 4.01142649e-02f, -3.46570089e-02f, -1.44976703e-02f, 2.45083142e-02f, 6.86776415e-02f, -6.38604611e-02f, -6.70359805e-02f, -1.97942797e-02f, -6.48490563e-02f,
  4.62770730e-01f, -3.71553376e-02f, -5.90187609e-01f, 1.66262135e-01f, -8.72893333e-02f, -6.89337999e-02f, 6.89358916e-03f, 3.37825686e-01f, 2.01194942e-01f, -1.43315166e-01f,
  -7.58641288e-02f, 2.46373385e-01f, -1.48126647e-01f, -7.15918168e-02f, -9.35811847e-02f, -2.83090144e-01f, -3.16203177e-01f, -1.69050291e-01f, -6.01499937e-02f, 1.34122640e-01f,
  2.48086499e-03f, 9.71370041e-02f, -4.64702351e-03f, 2.95089446e-02f, -1.55836597e-01f, -1.24774039e-01f, -3.15119982e-01f, -1.21049233e-01f, -3.17081332e-01f, -3.37341428e-01f,
  -6.03181601e-01f, 1.79538392e-02f, 2.41378807e-02f, 1.16354443e-01f, -6.88248267e-03f, 1.67568982e-01f, 9.79848672e-03f, 9.03865471e-02f, 9.16808546e-02f, 7.21295476e-02f,
  -3.70582230e-02f, -6.46011010e-02f, 9.24428478e-02f, -5.22422008e-02f, 2.16250252e-02f, 6.71368018e-02f, 3.81034091e-02f, -2.91510485e-02f, -8.50380138e-02f, -3.16646844e-02f,
  5.42917661e-02f, -2.67809276e-02f, -4.81491908e-02f, 2.34586243e-02f, -2.82716490e-02f, -1.70363940e-03f, 1.34228580e-02f, 1.87695120e-02f, -3.03714792e-03f, 1.81677729e-01f,
  6.70190006e-02f, 5.48101515e-02f, -1.11010112e-01f, 1.67094544e-01f, 5.68928123e-02f, 2.11495487e-03f, -1.24681613e-03f, -1.28790895e-02f, 8.74027982e-03f, 1.08575746e-01f,
  7.65807135e-03f, -9.73840728e-02f, 1.20345987e-02f, 5.08940369e-02f, -1.86508998e-01f, -1.19933359e-01f, -7.09121153e-02f, -5.76654868e-03f, 9.89497919e-03f, 4.43339236e-02f,
  4.56825420e-02f, -1.51022211e-01f, -2.03919336e-01f, -4.61690612e-02f, -3.92486937e-02f, -5.06527387e-02f, -1.07969992e-01f, -9.41570383e-04f, 4.26167529e-03f, -7.76698217e-02f,
  3.70043591e-02f, -4.85252030e-02f, -4.48801219e-02f, -1.40406311e-01f, -6.67473376e-02f, -1.33927956e-01f, -1.70900732e-01f, 3.73493060e-02f, -7.20801875e-02f, -1.15971337e-03f,
  -1.22037707e-02f, -6.61011180e-03f, -4.82314862e-02f, 5.38002737e-02f, 1.12922966e-01f, 3.11672427e-02f, 1.77596718e-01f, -1.02491900e-02f, -1.58960670e-01f, 1.47036733e-02f,
  4.05712053e-02f, 6.00719862e-02f, 1.88992217e-01f, 1.75480515e-01f, 1.40801162e-01f, 7.32416213e-02f, 4.31383923e-02f, -5.09404168e-02f, 1.32425269e-02f, 2.89593220e-01f,
  -6.05445027e-01f, -5.43892793e-02f, 8.82720202e-02f, -3.37670863e-01f, -1.31297007e-01f, 4.91057634e-02f, 3.48918945e-01f, 4.02562544e-02f, -1.70670062e-01f, 2.57542223e-01f,
  8.77586380e-02f, -1.62766233e-01f, -8.85748193e-02f, -3.73194292e-02f, -1.26040325e-01f, 3.15682411e-01f, 1.59429774e-01f, -2.07842931e-01f, -1.06124990e-01f, -8.44043642e-02f,
  -2.54513156e-02f, -8.39792863e-02f, -2.37414390e-01f, -1.34631366e-01f, 2.84120124e-02f, 1.66129656e-02f, 1.57284036e-01f, -1.68350622e-01f, 5.65956160e-02f, -8.80397931e-02f,
  3.74547303e-01f, -2.71029204e-01f, -4.50188182e-02f, -2.94030279e-01f, -7.95105379e-03f, -1.39784634e-01f, -9.11728963e-02f, -1.28404856e-01f, -1.48353085e-01f, 7.69170523e-02f,
  -2.08337620e-01f, -1.01813436e-01f, -1.95841029e-01f, 8.05300921e-02f, 1.67271178e-02f, -8.45805258e-02f, -5.62942075e-03f, -1.69769615e-01f, -5.41674234e-02f, 1.10973559e-01f,
  -5.75831272e-02f, -1.32565469e-01f, -1.06707448e-02f, 1.02788076e-01f, -1.42136037e-01f, -1.45479500e-01f, 1.88307520e-02f, -1.74253330e-01f, 5.04976027e-02f, 2.16845706e-01f,
  1.23595171e-01f, 9.69798043e-02f, -5.67880794e-02f, 8.82428065e-02f, 1.10878333e-01f, 8.60060006e-02f, 8.24571252e-02f, -4.67431881e-02f, 9.30884257e-02f, -6.30285442e-02f,
  -7.86219351e-03f, -2.31868010e-02f, -3.05327121e-03f, 5.03320694e-02f, 3.82864177e-02f, -9.98636708e-04f, 4.89130579e-02f, 4.40708771e-02f, 1.96704902e-02f, -1.35113001e-01f,
  -1.41014278e-01f, -3.37970331e-02f, 3.13554965e-02f, -5.01493849e-02f, 6.05956502e-02f, -6.25716224e-02f, 1.44431386e-02f, -1.11054312e-02f, -7.32515985e-03f, -1.95727628e-02f,
  2.94722050e-01f, -1.71026140e-01f, 1.18260577e-01f, -3.75913829e-02f, -4.02651429e-02f, -7.06081018e-02f, 3.18958648e-02f, 2.39477959e-02f, -1.02687314e-01f, 4.57332842e-02f,
  -1.89760566e-01f, -1.29788861e-01f, -2.43780669e-02f, 3.44776846e-02f, 1.54358856e-02f, 1.02987707e-01f, -3.72072961e-03f, -5.13831228e-02f, -6.86369613e-02f, 3.66108827e-02f,
  8.13122764e-02f, 4.35283594e-02f, 7.93189704e-02f, 5.24269305e-02f, 4.63323407e-02f, 1.27179503e-01f, 1.89471856e-01f, 7.63159320e-02f, 1.57205209e-01f, 4.14222032e-01f,
  -2.34593064e-01f, -3.63839567e-01f, -1.85694918e-01f, -4.72484194e-02f, 1.00489438e-01f, 6.54197708e-02f, -2.58497596e-01f, -8.21587220e-02f, 8.76651034e-02f, -2.44129851e-01f,
  -8.53161961e-02f, 1.05241515e-01f, -6.95731118e-02f, -5.04629463e-02f, -2.14400515e-01f, -3.59365284e-01f, -4.00463670e-01f, -7.89125785e-02f, 8.48625228e-02f, 2.10634828e-01f,
  2.28564382e-01f, 1.07772276e-01f, -6.63647428e-02f, 3.86604406e-02f, -1.23016678e-01f, -1.93860643e-02f, -9.22239497e-02f, -1.48595095e-01f, -8.55684653e-02f, -1.22924350e-01f,
  -1.64533764e-01f, -8.78667608e-02f, 1.28061295e-01f, -1.80754382e-02f, 5.09637669e-02f, 2.14797761e-02f, -1.16182640e-01f, 1.82402898e-02f, 2.52660718e-02f, -9.49449018e-02f,
  5.55064715e-02f, 1.90694183e-02f, 6.84200078e-02f, 2.16616243e-01f, -5.00433594e-02f, 3.14027928e-02f, -1.47245198e-01f, 3.03976587e-03f, -5.67130260e-02f, -2.33359620e-01f,
  -7.81809986e-02f, 4.99009266e-02f, -7.26321489e-02f, -1.73708230e-01f, -2.05696061e-01f, 7.15616718e-02f, -1.38052374e-01f, 9.93668437e-02f, -1.30408138e-01f, -2.64497787e-01f,
  -5.69774471e-02f, -7.35169277e-02f, -2.10033003e-02f, -5.08970208e-02f, 1.44471610e-02f, 7.24606887e-02f, -1.56392287e-02f, 5.83614521e-02f, 7.32656270e-02f, -9.78723168e-02f,
  -5.19018136e-02f, 2.56120339e-02f, 2.04865802e-02f, -1.53538346e-01f, -5.83407320e-02f, 2.87445146e-03f, 6.15487397e-02f, -1.01538964e-01f, 6.85430542e-02f, 1.25364646e-01f,
  -1.73778646e-02f, 1.26114950e-01f, -3.01388819e-02f, 7.89584890e-02f, -1.30870000e-01f, -1.29712448e-01f, 4.50633690e-02f, -1.23447411e-01f, -1.45119159e-02f, 1.56320482e-02f,
  -1.37989353e-02f, 4.62359600e-02f, -2.93590575e-02f, -1.04594178e-01f, -4.25997190e-02f, 2.51493580e-03f, -1.95060536e-01f, 1.20774873e-01f, 6.60688058e-02f, -1.32745340e-01f,
  -1.36660278e-01f, -3.96447033e-02f, 4.46951613e-02f, 4.14216854e-02f, 1.19863590e-02f, -3.82019281e-02f, -1.65028006e-01f, 5.87305836e-02f, 8.19891989e-02f, 1.79004207e-01f,
  -1.99694764e-02f, -2.23990023e-01f, -2.13296503e-01f, -3.01451445e-01f, -1.38528764e-01f, -1.01090617e-01f, -2.51736224e-01f, -2.94633880e-02f, -1.15415290e-01f, -3.04459453e-01f,
  8.32303092e-02f, 1.30491629e-01f, 4.13631111e-01f, -1.07993595e-01f, 5.32706119e-02f, -4.46111783e-02f, -5.96631356e-02f, -1.90634161e-01f, -3.05911243e-01f, 3.90716754e-02f,
  1.43737093e-01f, -1.24821559e-01f, 6.43326789e-02f, -6.47321641e-02f, -7.06406161e-02f, -4.93153790e-03f, 1.15353085e-01f, 2.02583447e-01f, -1.74895331e-01f, -3.20989817e-01f,
  -3.07060778e-01f, -1.53641803e-02f, 1.16609126e-01f, 1.37297437e-01f, 3.52939963e-02f, -1.44518763e-01f, 2.45182514e-01f, 2.31374592e-01f, 4.68539931e-02f, 8.51681679e-02f,
  1.28613934e-01f, 2.07068354e-01f, -2.92558260e-02f, -1.43312458e-02f, 2.04436228e-01f, -1.73990890e-01f, -1.44509360e-01f, 3.82553949e-03f, -4.19095680e-02f, 2.87628751e-02f,
  -3.82580645e-02f, 1.66385566e-04f, 6.25269637e-02f, -9.83232707e-02f, -6.80394769e-02f, -1.13541424e-01f, 1.37624383e-01f, 1.07346319e-01f, 7.52601400e-02f, -7.18734637e-02f,
  -1.32469594e-01f, -9.20552537e-02f, 2.54721045e-01f, -6.75930604e-02f, 1.78281497e-02f, -1.04949936e-01f, 1.00910589e-01f, -1.03955790e-02f, 1.51333883e-01f, -1.15619510e-01f,
  -2.71904394e-02f, 7.04717413e-02f, 6.49197772e-02f, 5.21605983e-02f, -9.29163322e-02f, 1.74255557e-02f, 4.22558486e-02f, -1.26837362e-02f, -3.89519967e-02f, 8.64403918e-02f,
  -1.80091597e-02f, -2.81899981e-02f, -1.23553649e-02f, 9.00226086e-02f, -7.23198056e-02f, 1.10957630e-01f, 3.93363973e-03f, -2.74503287e-02f, 1.14745773e-01f, -1.11209918e-02f,
  -1.87457236e-03f, -1.06740274e-01f, -5.49107157e-02f, -1.81182519e-01f, 4.15077023e-02f, 3.84761281e-02f, -2.28404254e-01f, 4.32863384e-02f, 4.96424437e-02f, 1.06331967e-01f,
  -1.26127169e-01f, 3.31308722e-01f, -6.59316331e-02f, 1.07890684e-02f, 9.06858314e-03f, 2.39161812e-02f, 3.28632034e-02f, -4.13744431e-03f, -3.51128727e-02f, -2.17045713e-02f,
  -1.94118749e-02f, -3.14824097e-02f, 4.93648872e-02f, -2.15864349e-02f, -2.60116279e-01f, -1.29363954e-01f, -2.99333315e-02f, -1.17600895e-01f, -6.60838708e-02f, -1.52428836e-01f,
  -9.31010321e-02f, -2.31913105e-01f, -2.46197730e-01f, -1.08612441e-01f, -1.42919943e-01f, -2.95395970e-01f, -1.45974502e-01f, -2.42404357e-01f, -8.53290483e-02f, -1.92354634e-01f,
  6.19611979e-01f, 3.71669114e-01f, -4.03851748e-01f, 3.61572325e-01f, -3.11161727e-01f, -3.37756187e-01f, -2.07897052e-02f, -3.65279131e-02f, 1.76805899e-01f, 2.86177099e-01f,
  -1.40115857e-01f, -2.01736838e-01f, -1.32246628e-01f, -2.08783120e-01f, -2.88535863e-01f, 1.01233408e-01f, 1.40775606e-01f, -1.39621168e-01f, -5.01163900e-01f, -3.51367265e-01f,
  1.56601742e-01f, 2.72966743e-01f, 1.87535703e-01f, 4.25561816e-02f, 1.66685760e-01f, -1.08339734e-01f, -9.17364359e-02f, -3.73368710e-02f, -1.07974432e-01f, 2.47135788e-01f,
  -1.01510128e-02f, -4.41302583e-02f, -3.21478963e-01f, -1.42042171e-02f, -1.96430832e-01f, 4.47434746e-02f, -1.30003154e-01f, -1.86210796e-01f, 8.17185044e-02f, 6.36480600e-02f,
  -1.77497327e-01f, -1.77243296e-02f, -1.11964852e-01f, -1.26584619e-01f, -1.32241845e-02f, -1.47380337e-01f, 8.03853758e-03f, -2.63996795e-02f, -6.82730451e-02f, -4.08692993e-02f,
  8.47829282e-02f, -1.60518050e-01f, -2.93360084e-01f, -1.38169497e-01f, -1.92467347e-01f, -1.96638674e-01f, -2.04760000e-01f, -1.64080530e-01f, -3.41236115e-01f, 3.72954965e-01f,
  7.44165257e-02f, -5.87966666e-02f, -8.59654993e-02f, 6.16944022e-02f, -2.26989985e-02f, -4.41964865e-02f, -1.05353789e-02f, 2.43365131e-02f, -3.91200278e-03f, -3.36597897e-02f,
  -9.94528607e-02f, 3.96199636e-02f, -7.72653967e-02f, 2.42596008e-02f, 3.66491266e-02f, -1.93896629e-02f, -2.65888274e-02f, 9.74508524e-02f, -4.84394170e-02f, -6.09057443e-03f,
  -1.95308570e-02f, 2.62120813e-02f, 3.31234862e-03f, -8.70938692e-03f, -3.85100245e-02f, -6.61453307e-02f, -1.37439659e-02f, -4.13190089e-02f, 7.73763508e-02f, 4.13617529e-02f,
  2.88761765e-01f, -3.56478244e-01f, 8.91726762e-02f, -6.73908144e-02f, 1.17849745e-02f, 2.29124334e-02f, 6.76025450e-02f, -6.61797747e-02f, -3.15263774e-03f, -3.72952409e-02f,
  -1.07193239e-01f, -8.42619538e-02f, 6.30846666e-03f, 5.13734631e-02f, -5.95324002e-02f, -1.52239442e-01f, 1.73229322e-01f, -2.64491886e-02f, 1.47961592e-02f, 1.38766453e-01f,
  1.67415440e-01f, 1.92448311e-02f, 3.87981422e-02f, 1.93319730e-02f, 1.01380460e-01f, -1.02653742e-01f, -5.88660091e-02f, 1.21700510e-01f, -1.41907915e-01f, 4.95676368e-01f,
  1.96258873e-01f, 3.30405742e-01f, -1.96771666e-01f, 1.38178065e-01f, -4.86886464e-02f, -7.72263259e-02f, -1.04023792e-01f, -3.00954252e-01f, -1.06856197e-01f, 1.78791985e-01f,
  -3.14408913e-02f, -2.07821280e-01f, -1.31515935e-01f, -1.73365712e-01f, -2.97495633e-01f, -6.28864160e-03f, 7.87480846e-02f, -2.56431729e-01f, -5.00723839e-01f, -2.30842218e-01f,
  -3.27933170e-02f, -3.40929851e-02f, -1.97212577e-01f, -9.21774656e-02f, 9.19318050e-02f, 4.39366847e-02f, 7.26230666e-02f, 1.53590277e-01f, 1.77937716e-01f, 4.15269852e-01f,
  8.56524929e-02f, 2.35081930e-02f, -1.11343779e-01f, -6.92727938e-02f, 1.29581526e-01f, 5.81999915e-03f, 2.88463160e-02f, -1.41624615e-01f, 1.44096101e-02f, -5.45159951e-02f,
  -5.12313191e-03f, 2.90414281e-02f, -2.18728706e-02f, -5.34956753e-02f, -4.59202379e-02f, 6.50319159e-02f, -8.88416469e-02f, -2.07065344e-01f, -2.07558095e-01f, 3.37539241e-02f,
  1.36703283e-01f, 2.87058689e-02f, -1.47242561e-01f, -2.04678416e-01f, -8.33367705e-02f, 2.54608728e-02f, -1.13722803e-02f, 2.32154354e-02f, -1.43674031e-01f, 3.44501100e-02f,
  2.17065573e-01f, 5.03958501e-02f, 1.06139407e-01f, -1.33955795e-02f, 1.56898275e-01f, 3.35314847e-03f, 7.75358453e-02f, -2.44986117e-02f, 3.69789563e-02f, 1.03171133e-01f,
  6.24959841e-02f, 9.79034007e-02f, -1.22533277e-01f, -2.36795619e-02f, 7.26762265e-02f, 8.02371874e-02f, 1.46048918e-01f, 4.18477803e-02f, -2.02428848e-02f, 8.76353160e-02f,
  1.29019609e-02f, -6.29648864e-02f, 3.20614018e-02f, -1.10951416e-01f, -1.81499068e-02f, 9.21540111e-02f, 5.61727434e-02f, 3.21123004e-02f, -5.56005836e-02f, 2.49597561e-02f,
  -1.76576361e-01f, -1.69109136e-01f, 1.54033706e-01f, -1.29757240e-01f, 1.01882525e-01f, -3.69259901e-02f, 1.24286205e-01f, -9.94411204e-03f, 1.25613794e-01f, 8.04249793e-02f,
  -2.11864039e-02f, 1.28059104e-01f, -8.33293274e-02f, -8.78564790e-02f, -9.33008790e-02f, 3.02378391e-03f, 8.56830403e-02f, -1.84929762e-02f, -1.67123839e-01f, 3.96257639e-02f,
  5.27515775e-03f, -8.55565444e-02f, -1.20494552e-01f, -9.52972546e-02f, -2.35760007e-02f, 3.14044356e-02f, -5.53051103e-03f, -4.94459495e-02f, -1.27340052e-02f, 5.62366471e-02f,
  2.31444329e-01f, 1.66618034e-01f, 2.78252631e-01f, -9.95653048e-02f, -1.61005586e-01f, -3.49319726e-01f, -2.81434029e-01f, -1.90727472e-01f, -8.58395770e-02f, 4.53520790e-02f,
  -1.43432543e-01f, -4.42529730e-02f, 1.25588989e-02f, 1.83099583e-02f, -6.47607893e-02f, 1.30231857e-01f, 3.01192373e-01f, 2.66563058e-01f, -1.47393227e-01f, -2.83899546e-01f,
  -1.50854871e-01f, 2.41845399e-02f, 1.38529167e-01f, 1.29818723e-01f, 5.90431094e-02f, -1.92196116e-01f, 1.56853974e-01f, 1.44747347e-01f, 1.62567630e-01f, 3.61257434e-01f,
  2.30065465e-01f, 1.26735628e-01f, -1.39085189e-01f, 3.62464525e-02f, 1.23249948e-01f, 4.71340343e-02f, 1.03235438e-01f, 1.01702884e-01f, 6.24325722e-02f, 5.45033589e-02f,
  9.47857182e-03f, 1.86288767e-02f, -8.11784044e-02f, 2.32758429e-02f, 9.05866548e-03f, -9.59121585e-02f, 5.11633120e-02f, 1.79488301e-01f, 7.43180141e-02f, 1.11471511e-01f,
  -1.75917134e-01f, -1.62162811e-01f, -1.36567712e-01f, -2.69777805e-01f, 2.17220008e-01f, -9.35573056e-02f, -9.83448774e-02f, -9.13320482e-02f, -3.31324451e-02f, 1.36337727e-01f,
  2.02951580e-02f, 2.91250572e-02f, 1.48545071e-01f, 4.45704497e-02f, -3.35346870e-02f, -3.50230634e-02f, 3.97284329e-02f, -9.05736834e-02f, 4.47787717e-03f, 1.01100523e-02f,
  -5.36883287e-02f, -8.22992530e-03f, -1.14087239e-02f, 4.64695357e-02f, -8.87763202e-02f, 2.79037952e-02f, 6.25758385e-03f, 5.28442487e-02f, -2.02129614e-02f, 4.28420566e-02f,
  -1.23698730e-02f, 7.99683407e-02f, 5.14317974e-02f, -1.87418237e-02f, 2.80852374e-02f, -9.48565826e-03f, 1.07652950e-03f, -9.57203060e-02f, -4.85182405e-02f, 3.82391326e-02f,
  -1.48065984e-01f, -2.62825936e-01f, 9.60088074e-02f, 1.89266056e-02f, -2.96772383e-02f, -6.96705207e-02f, -3.46606113e-02f, 6.59048976e-03f, 3.18790860e-02f, -4.50762957e-02f,
  -8.72432739e-02f, -3.16092521e-02f, 4.23482023e-02f, 1.05631858e-01f, -5.68098798e-02f, -1.43112019e-01f, -7.47512951e-02f, -3.72972339e-03f, -1.29397601e-01f, -7.64828548e-02f,
  -1.00975111e-01f, -3.66303355e-01f, -2.43427113e-01f, -1.41853690e-01f, -8.83258507e-02f, -2.33455360e-01f, -1.57630354e-01f, -1.92503676e-01f, -1.23917520e-01f, -1.36213318e-01f,
  -5.34674585e-01f, 4.69364703e-01f, 1.29598707e-01f, -4.01911676e-01f, 7.45494589e-02f, 3.89160812e-01f, 6.42471194e-01f, 1.61954910e-01f, -1.92009270e-01f, 5.73139936e-02f,
  1.27890825e-01f, -1.60996228e-01f, -1.79551378e-01f, -7.30823874e-02f, 2.77653456e-01f, 3.77039969e-01f, 4.70013916e-02f, 2.53889896e-03f, -1.95334017e-01f, -5.28294966e-02f,
  4.30575199e-02f, -2.18539268e-01f, -2.58405536e-01f, -2.38541633e-01f, -1.56631976e-01f, -1.48928925e-01f, 1.56288259e-02f, 7.92817026e-02f, 1.40589327e-01f, -7.76956826e-02f,
  1.05310082e-01f, 1.17583096e-01f, -1.50190517e-01f, -1.23964526e-01f, -6.21436946e-02f, -7.40166008e-02f, -1.86607186e-02f, -6.03240877e-02f, 1.07188046e-01f, 1.53261488e-02f,
  1.93237923e-02f, 6.20883889e-02f, 1.47080822e-02f, -9.21502560e-02f, 2.33451836e-02f, 3.25254761e-02f, -1.13147669e-01f, -2.90964432e-02f, -3.19114886e-02f, 8.38861614e-03f,
  6.20670691e-02f, 7.76072294e-02f, 6.81460649e-02f, 1.00033786e-02f, -2.73225475e-02f, -5.74211702e-02f, 2.01033559e-02f, -1.74353644e-02f, -8.52554664e-03f, -6.83370680e-02f,
  -2.72290520e-02f, -1.32755572e-02f, -6.28031567e-02f, -1.42275766e-01f, -8.33571479e-02f, -7.49363750e-02f, 4.04004194e-02f, 1.55566931e-01f, -3.58265117e-02f, -1.72422379e-02f,
  8.41104314e-02f, 4.68506776e-02f, -2.19207276e-02f, 1.14392683e-01f, 3.14220898e-02f, 8.04831162e-02f, 5.03549911e-02f, 4.47576493e-02f, -7.33998716e-02f, 1.64156444e-02f,
  7.22076325e-03f, 7.97261372e-02f, -7.51012862e-02f, 1.74608588e-01f, 1.05289042e-01f, -1.62363239e-02f, 5.15547283e-02f, 1.13536596e-01f, 4.63416092e-02f, 4.30713035e-02f,
  -1.94426030e-01f, 3.03834796e-01f, -1.20450974e-01f, -1.27740288e-02f, 6.77063456e-03f, 5.32556847e-02f, 7.11807190e-03f, 4.96285073e-02f, 3.90394852e-02f, 5.06074764e-02f,
  5.20104468e-02f, 1.01927117e-01f, 1.07598081e-01f, 6.38957173e-02f, 4.42650393e-02f, -7.58675113e-03f, -4.99350913e-02f, -1.82548493e-01f, -2.29021180e-02f, -5.64221852e-02f,
  8.19923803e-02f, -2.66664103e-02f, -5.94877079e-02f, -2.44227480e-02f, 3.92886065e-02f, -1.03206225e-01f, 5.11082448e-02f, -1.44976480e-02f, 3.56442593e-02f, -8.05402920e-02f,
  6.57312691e-01f, -1.59553155e-01f, 3.31249326e-01f, 2.76660472e-01f, 2.16642901e-01f, 3.34775060e-01f, 1.87946856e-01f, 4.82593514e-02f, 6.76409453e-02f, 3.80690433e-02f,
  6.41334131e-02f, 2.38707680e-02f, -6.39374629e-02f, -1.22142017e-01f, 6.13585971e-02f, -9.16153044e-02f, -1.12271026e-01f, 2.12605536e-01f, 1.94559082e-01f, 4.98431139e-02f,
  -1.62671223e-01f, -2.37219799e-02f, 2.01734081e-02f, -1.40968248e-01f, -2.83799738e-01f, -1.32975116e-01f, -1.13943040e-01f, -8.58418420e-02f, -1.48314446e-01f, -3.22655350e-01f,
  6.40174199e-04f, 2.53206551e-01f, 4.89760041e-02f, -1.01190388e-01f, -2.01961454e-02f, 1.21034803e-02f, -2.08581556e-02f, -2.68868748e-02f, -1.27497882e-01f, -4.94633913e-02f,
  -2.76010651e-02f, -5.36419339e-02f, 3.43386456e-02f, -8.02371204e-02f, -2.58684512e-02f, 1.65325683e-02f, 1.02586849e-02f, 4.17494476e-02f, 1.24363964e-02f, -3.17195952e-02f,
  -3.54448110e-02f, 9.36748832e-02f, 1.69587165e-01f, 1.32354423e-01f, 2.06140697e-01f, 8.10634345e-02f, -1.16439620e-02f, 5.99809811e-02f, 1.22204565e-01f, 3.76042314e-02f,
  -3.55335092e-03f, 5.64050525e-02f, 7.80759305e-02f, 1.18178032e-01f, 1.69982255e-01f, 1.58666268e-01f, 5.03816567e-02f, -9.65577587e-02f, 1.71944708e-01f, -4.11990695e-02f,
  -3.17312106e-02f, 1.88048631e-01f, 2.29436114e-01f, -3.60410251e-02f, -6.78105578e-02f, 1.13016993e-01f, 1.03499673e-01f, 1.77348889e-02f, 5.38671426e-02f, 5.52152358e-02f,
  1.15674296e-02f, -3.10909357e-02f, -7.22993985e-02f, -4.59415875e-02f, -5.70945907e-03f, -3.86681221e-02f, -4.38736267e-02f, -1.72966301e-01f, -4.72784676e-02f, -1.21192317e-02f,
  -2.03284711e-01f, 3.93152624e-01f, 6.39925599e-02f, -7.49401078e-02f, -4.18553054e-02f, -1.74628332e-01f, 1.53542697e-01f, -1.35644704e-01f, -5.59883304e-02f, -7.56627247e-02f,
  4.14112546e-02f, -3.13094556e-02f, 2.99467146e-02f, -6.60016164e-02f, 3.45913619e-02f, 3.32166813e-02f, -4.53937687e-02f, -4.20477018e-02f, -2.13842690e-02f, -9.27299410e-02f,
  -9.11025852e-02f, 5.91504760e-02f, 8.98249000e-02f, 1.92046523e-01f, 5.06491512e-02f, 2.14681879e-01f, 9.29809436e-02f, 1.29764766e-01f, 3.72419842e-02f, -7.98054859e-02f,
  -6.38563454e-01f, -1.15612678e-01f, 2.48491883e-01f, -1.31910354e-01f, 2.33646464e-02f, 1.67126179e-01f, 2.47606307e-01f, -3.60674523e-02f, -5.62040210e-02f, -7.61165693e-02f,
  7.55357444e-02f, -2.06828490e-02f, -3.09027731e-02f, 1.22824244e-01f, 1.70280054e-01f, 2.52137393e-01f, 1.45351589e-01f, -1.06553221e-02f, 4.20912839e-02f, 7.45865852e-02f,
  -1.69455353e-02f, -8.41028243e-02f, -1.05842605e-01f, 2.14341823e-02f, -4.09878604e-02f, -3.16974148e-02f, 9.33671147e-02f, -2.34441981e-02f, 1.08123526e-01f, 2.80606747e-03f,
  5.98433435e-01f, -1.20585985e-01f, -1.25370070e-01f, -9.71832648e-02f, 6.48245215e-03f, -1.46475285e-01f, -4.70465422e-02f, 2.72918232e-02f, 2.58942153e-02f, 5.68881482e-02f,
  5.61738312e-02f, -1.04481816e-01f, 4.04287456e-03f, -1.09379806e-01f, 1.73078161e-02f, -4.40601148e-02f, -1.27128690e-01f, 5.35699017e-02f, 1.39782727e-01f, 1.15692727e-01f,
  -1.72612533e-01f, -4.19928804e-02f, 7.44322389e-02f, -8.09499761e-04f, -1.61554664e-01f, -1.26954630e-01f, 4.13390398e-02f, -5.60634583e-02f, 2.32926011e-02f, -1.26831546e-01f,
  -8.31568986e-02f, 4.64053228e-02f, 1.02274297e-02f, -5.62359653e-02f, -1.38622010e-02f, 1.52928889e-01f, 2.14500040e-01f, 8.12189952e-02f, -1.21146508e-01f, -1.13469869e-01f,
  -9.01996046e-02f, 4.72595245e-02f, 2.26663444e-02f, 1.07969910e-01f, -1.82028130e-01f, -1.49491653e-01f, 6.40362501e-02f, -1.25751682e-02f, -2.20537990e-01f, -6.63636774e-02f,
  -1.19790770e-01f, -9.78917181e-02f, 5.00025321e-03f, -4.21170108e-02f, 6.63497075e-02f, -1.12322129e-01f, 5.08658066e-02f, -1.31056204e-01f, -1.66281223e-01f, -2.86556780e-02f,
  3.63166064e-01f, -2.37854570e-01f, 5.56480996e-02f, -1.44099683e-01f, -5.57614602e-02f, -1.03269890e-01f, -8.72043893e-02f, 6.05623797e-02f, 1.34966090e-01f, 1.24519564e-01f,
  1.89436413e-02f, -7.55701214e-02f, -3.43183503e-02f, 4.12335470e-02f, 3.37214284e-02f, -3.50529552e-02f, -1.42174736e-01f, 8.43857229e-02f, 1.10350296e-01f, 1.19721003e-01f,
  -8.65097493e-02f, 7.24429488e-02f, 1.55472055e-01f, 1.01441965e-01f, -3.38930599e-02f, 4.29387242e-02f, 8.94753188e-02f, 1.54572189e-01f, 1.03777364e-01f, 1.10591359e-01f,
  -3.11312109e-01f, 1.80923678e-02f, 1.03745982e-02f, 4.18515205e-01f, 2.75545716e-01f, 3.55397880e-01f, 3.13691944e-01f, 2.74214536e-01f, 2.12871522e-01f, 1.45300940e-01f,
  1.29148006e-01f, 1.49918824e-01f, 1.72770113e-01f, 1.84540346e-01f, 4.77431007e-02f, 2.02941850e-01f, 1.90551743e-01f, 8.75236243e-02f, 2.24956758e-02f, 9.72861126e-02f,
  2.16167867e-01f, 1.16934411e-01f, -1.74100399e-01f, 5.41707948e-02f, 1.15964636e-01f, 1.41720697e-01f, 1.05558909e-01f, 8.19080770e-02f, 2.55508661e-01f, 1.32378891e-01f,
  -2.17101753e-01f, -4.86141853e-02f, 3.82610522e-02f, -1.43316045e-01f, -1.69579893e-01f, -1.48939967e-01f, -1.22511722e-01f, -1.35901589e-02f, -2.73763388e-02f, -8.38363320e-02f,
  -4.69557792e-02f, -1.54803157e-01f, -1.29864989e-02f, -1.23330995e-01f, -1.23329982e-01f, -1.09660961e-01f, -9.76369232e-02f, 4.38613370e-02f, 1.54602379e-01f, 3.22950259e-02f,
  7.66713321e-02f, 1.12523511e-01f, 6.89443573e-02f, 1.61880165e-01f, 1.32867008e-01f, 8.74823779e-02f, 2.87583247e-02f, -8.06158483e-02f, 2.20009815e-02f, -8.33412856e-02f,
  1.52947694e-01f, 6.57307208e-02f, 1.64854694e-02f, -1.74216516e-02f, -9.90993604e-02f, 3.76768522e-02f, 3.80631946e-02f, 1.03316784e-01f, 9.52046737e-02f, -4.26327623e-02f,
  5.25307618e-02f, 6.37706965e-02f, 9.17169526e-02f, 2.36215461e-02f, 4.48890030e-02f, -3.56384926e-02f, -9.38383713e-02f, -5.04469946e-02f, -5.61298095e-02f, -8.63581970e-02f,
  1.99959613e-02f, 2.57871449e-02f, -1.38850898e-01f, -2.59938631e-02f, 1.54691134e-02f, 3.74714658e-02f, 8.26624259e-02f, 7.84143358e-02f, -1.97522677e-02f, -1.94169243e-03f,
  2.05502823e-01f, 9.96857584e-02f, -8.00360069e-02f, 6.29527569e-02f, -5.38415797e-02f, -1.64856300e-01f, 8.21765289e-02f, -4.44033518e-02f, -1.15866408e-01f, -6.81090727e-02f,
  6.60812110e-02f, -1.39923319e-01f, -2.31445837e-03f, -5.95699325e-02f, -1.94355667e-01f, -2.50023194e-02f, 1.33689567e-02f, 1.70273945e-01f, 1.39136225e-01f, -5.98775409e-02f,
  6.39949040e-03f, 1.66488901e-01f, 4.09280881e-02f, -3.06656235e-03f, 8.65022838e-02f, -3.60387117e-02f, -3.32195386e-02f, 3.50687690e-02f, -1.53271500e-02f, -7.40585327e-02f,
  -3.16116571e-01f, -1.26722291e-01f, -1.75152160e-02f, -3.09624821e-01f, -7.41633028e-03f, -3.91048640e-02f, -1.75488979e-01f, 3.16565856e-02f, -1.53112272e-02f, -3.36217344e-01f,
  -2.01853678e-01f, -4.26549911e-02f, -1.16710961e-01f, 4.26969193e-02f, -2.03136608e-01f, -3.32183450e-01f, -2.77772218e-01f, -1.11024812e-01f, 1.62241399e-01f, 1.08882919e-01f,
  6.39562234e-02f, -1.84805557e-01f, -8.95233080e-02f, 6.95595006e-03f, -7.82975480e-02f, 1.42501725e-03f, -2.23715350e-01f, -6.09408468e-02f, -1.09511778e-01f, -2.37589583e-01f,
  -3.23109418e-01f, 1.23015948e-01f, 2.04446286e-01f, -2.40694303e-02f, -1.25789091e-01f, 2.15845078e-01f, 4.29599173e-02f, -8.07893723e-02f, 8.54638964e-02f, -1.07953236e-01f,
  -8.85759890e-02f, 1.51126906e-02f, -7.77092157e-03f, -6.49457946e-02f, -2.65557002e-02f, -9.50302705e-02f, -5.66606410e-02f, -4.71096560e-02f, 4.88020554e-02f, 3.20381559e-02f,
  -7.91720599e-02f, -2.05681436e-02f, 4.76379395e-02f, 1.61269203e-01f, 4.78160605e-02f, -8.49829838e-02f, 4.76464592e-02f, 1.14114590e-01f, 1.09517567e-01f, -1.48699522e-01f,
  1.02991819e-01f, 4.76339757e-02f, 1.29015490e-01f, 1.03920005e-01f, -3.93842626e-03f, 2.88895573e-02f, 5.80767170e-02f, -1.17921740e-01f, 8.69953185e-02f, -7.63496011e-02f,
  1.54508427e-01f, 5.85819446e-02f, 1.37295097e-01f, -2.82951631e-02f, 1.19880080e-01f, 5.89582808e-02f, 1.48646371e-03f, -6.83260337e-02f, 2.95057315e-02f, 1.56599492e-01f,
  -7.14821070e-02f, 1.71363950e-01f, -3.81802991e-02f, 1.13564320e-01f, -8.20757672e-02f, -1.41155928e-01f, -3.28177819e-04f, 1.17270295e-02f, -4.83504385e-02f, -1.42012881e-02f,
  -3.22895765e-01f, 1.36344433e-01f, -2.16355205e-01f, -5.60628846e-02f, -1.67409033e-02f, -8.45161304e-02f, -2.25499757e-02f, -2.23740309e-01f, -6.29471615e-02f, -1.44559696e-01f,
  7.70962909e-02f, -9.53247026e-02f, 2.66660042e-02f, 1.44717261e-01f, 2.97325267e-03f, 7.73324668e-02f, -6.53235614e-03f, -9.79666486e-02f, 9.37021747e-02f, 1.29786357e-01f,
  9.93246096e-04f, -2.25857958e-01f, -2.30172545e-01f, -1.08132079e-01f, -4.96352613e-02f, -2.99336463e-01f, -5.52724116e-02f, -6.92592114e-02f, -1.54572735e-02f, -2.68215090e-01f,
  -5.56671321e-01f, 3.04762274e-01f, 1.20681204e-01f, -3.05421084e-01f, 1.16918169e-01f, 1.22397080e-01f, 3.16439480e-01f, 7.41542205e-02f, -1.47939473e-01f, 1.76499799e-01f,
  2.75172256e-02f, -2.51856238e-01f, -1.20439775e-01f, -1.47842824e-01f, -1.43843517e-01f, 9.84064937e-02f, -1.61393180e-01f, -4.52998042e-01f, -4.00075287e-01f, -2.31382877e-01f,
  -1.43351614e-01f, -3.42089444e-01f, -3.66045564e-01f, -2.56141275e-01f, -5.90058379e-02f, -2.33301297e-01f, -5.11068888e-02f, -7.61412606e-02f, 3.51679660e-02f, -3.33219627e-03f,
  -3.11998352e-02f, -1.76632017e-01f, -3.10133621e-02f, -7.46743307e-02f, -6.86113769e-03f, -9.60879866e-03f, -6.88783899e-02f, 8.62864554e-02f, -1.47644328e-02f, 4.01417688e-02f,
  -6.57543242e-02f, 9.68269482e-02f, -1.74965918e-01f, 8.61564875e-02f, -8.19966868e-02f, 8.98883492e-02f, 1.37502566e-01f, -4.17757221e-02f, 6.58034086e-02f, 2.30213419e-01f,
  2.33490720e-01f, -2.33767238e-02f, 5.71457148e-02f, 1.37206495e-01f, 5.07441871e-02f, -1.02495067e-01f, 1.57650203e-01f, 5.14834598e-02f, 1.63842086e-02f, 1.12047568e-01f,
  1.44884109e-01f, -7.02936277e-02f, 1.16013363e-02f, 1.23022767e-02f, 3.50835957e-02f, 1.14700722e-03f, -4.15841155e-02f, 2.80232951e-02f, -5.54937460e-02f, 1.94517467e-02f,
  1.70524061e-01f, 1.09340914e-01f, -4.79199737e-02f, -1.04373984e-01f, -1.09098874e-01f, 4.59454060e-02f, -3.97228524e-02f, 2.94073252e-03f, -7.58748641e-03f, 4.69735377e-02f,
  5.24013601e-02f, 1.24827906e-01f, -2.23535988e-02f, -8.35458860e-02f, 5.02952076e-02f, 6.97229058e-02f, 8.01322013e-02f, 7.85411298e-02f, -1.36429695e-02f, 6.27195090e-02f,
  -2.77441084e-01f, -2.58624315e-01f, -9.77541432e-02f, 6.53985441e-02f, -7.51352811e-04f, 1.76074892e-01f, 7.55012333e-02f, 4.68761995e-02f, -8.53323564e-03f, -2.27910420e-03f,
  -6.06649928e-02f, -1.07616745e-01f, 4.82004276e-03f, 1.66217178e-01f, 4.50604828e-03f, 3.78715694e-02f, 1.77130848e-01f, -5.00665978e-02f, 2.84360722e-02f, 8.74869525e-02f,
  1.90113425e-01f, 5.01267500e-02f, -3.76818329e-02f, 4.72017527e-02f, -2.95088068e-02f, -2.19177023e-01f, -8.88322964e-02f, -5.85361831e-02f, -5.04910797e-02f, 9.42439511e-02f,
  6.61618114e-01f, -3.66729558e-01f, -3.44637670e-02f, 3.72549966e-02f, -1.13995105e-01f, 7.93865249e-02f, -1.81833953e-02f, 8.93668830e-02f, 1.21086046e-01f, -1.19674832e-01f,
  1.08156174e-01f, 2.06172168e-01f, 2.93569416e-01f, 1.14229761e-01f, 2.29041696e-01f, -7.62311295e-02f, -1.80161119e-01f, 3.93572710e-02f, 3.14356923e-01f, 9.27531794e-02f,
  -3.97184342e-02f, -1.50642842e-01f, 4.62766998e-02f, -1.31360829e-01f, -3.37522209e-01f, 5.26410080e-02f, -3.31880659e-01f, -1.46844387e-01f, -1.33769795e-01f, -3.80722076e-01f,
  9.07852650e-02f, -6.20588474e-02f, 1.08434431e-01f, 5.00891209e-02f, -2.52521969e-02f, 4.91997972e-02f, -2.49108095e-02f, -1.45365462e-01f, -6.06618673e-02f, 5.63169084e-02f,
  -8.60449970e-02f, 9.09035094e-03f, -6.11450784e-02f, -5.26906960e-02f, -2.13445634e-01f, -1.25910640e-01f, -7.91344494e-02f, -1.63017027e-02f, -9.23599526e-02f, 3.31032127e-02f,
  4.00368683e-02f, -1.06244490e-01f, -4.79273126e-03f, 1.19215194e-02f, 4.68351729e-02f, 5.83934560e-02f, -1.16219737e-01f, -2.40220875e-02f, -7.84433931e-02f, -2.04534054e-01f,
  6.58949688e-02f, -6.84738234e-02f, 1.35319019e-02f, -3.85114551e-03f, 7.75322923e-03f, 6.13326542e-02f, 3.09320930e-02f, 1.49951046e-02f, -1.22743426e-02f, -7.80281425e-03f,
  -7.32207447e-02f, 4.19139350e-03f, -4.44688536e-02f, -8.80691409e-03f, -2.12026872e-02f, 1.16204340e-02f, -1.82205327e-02f, -6.12049690e-03f, -5.66630587e-02f, 5.36993444e-02f,
  1.08922929e-01f, 9.06746536e-02f, -6.65453598e-02f, 2.20035482e-02f, 9.30948183e-03f, 5.93144372e-02f, 1.29705489e-01f, 1.61854979e-02f, 5.03286868e-02f, -1.18617211e-02f,
  -1.09082840e-01f, 1.57293022e-01f, 1.42558515e-01f, 6.18078820e-02f, -1.13012850e-01f, -1.10896900e-01f, 3.93748358e-02f, -5.90653606e-02f, -2.34179851e-02f, -3.10838632e-02f,
  -1.51941851e-02f, 1.01968363e-01f, -1.26735821e-01f, -7.63923824e-02f, 2.25002673e-02f, 1.24397706e-02f, -1.46482103e-02f, 1.89843237e-01f, 6.92424253e-02f, -1.25359699e-01f,
  -7.07485750e-02f, 1.15666166e-01f, 1.29581645e-01f, 9.10539925e-02f, 3.09400652e-02f, 2.14098632e-01f, 7.23962709e-02f, 4.50654216e-02f, 1.29482970e-01f, 3.56176719e-02f,
  -4.34365034e-01f, 1.86538577e-01f, -2.20446542e-01f, -2.36613140e-01f, 2.12681279e-01f, 1.84322476e-01f, 3.36034715e-01f, 3.06161698e-02f, -6.61861897e-02f, 2.37831324e-01f,
  2.49647722e-01f, 3.09243798e-02f, -5.54068647e-02f, 6.31867573e-02f, -7.44288638e-02f, 9.09048989e-02f, 8.20229650e-02f, -2.85550952e-01f, -9.73804966e-02f, 8.51275623e-02f,
  2.96030045e-01f, -1.21029079e-01f, -2.73891866e-01f, -4.33849357e-02f, -9.86629911e-03f, -1.47095636e-01f, -8.25350508e-02f, -1.07746571e-01f, 1.23773761e-01f, 5.00209741e-02f,
  -1.86633244e-01f, 2.60730144e-02f, 1.80967450e-01f, 2.39462957e-01f, -3.28776520e-03f, -1.96591660e-01f, -1.09040134e-01f, -1.55440688e-01f, 9.49910842e-04f, -5.26531599e-02f,
  -1.12792112e-01f, 1.28825366e-01f, 2.45491788e-02f, 3.23253796e-02f, -2.93149706e-02f, -1.20010950e-01f, -6.44518882e-02f, -3.04767966e-01f, -2.46779457e-01f, -1.90389425e-01f,
  2.92671800e-01f, 1.13855623e-01f, -5.08585013e-02f, 7.66726062e-02f, -8.09320286e-02f, -5.43274917e-02f, -8.79332051e-02f, -2.40275621e-01f, -2.49440983e-01f, -2.15409011e-01f,
  1.11404441e-01f, -3.37597467e-02f, 5.78364395e-02f, 7.32846558e-02f, 2.94265058e-02f, 8.39299187e-02f, 5.38689420e-02f, -3.65233421e-02f, 2.45884676e-02f, -1.35672325e-02f,
  -7.87591934e-03f, 5.42046363e-03f, -5.78743890e-02f, 4.62127104e-02f, -7.56015107e-02f, 6.80785254e-02f, 2.22159103e-02f, 1.14404023e-01f, 1.33171037e-01f, -9.09388810e-02f,
  -7.09076822e-02f, -8.62667151e-03f, 8.38674158e-02f, -6.21596724e-02f, 7.99167603e-02f, -4.04867809e-03f, 1.58892106e-02f, -9.98221785e-02f, -1.38552859e-01f, -5.01800701e-02f,
  -2.66604215e-01f, 9.17940065e-02f, 1.41497049e-02f, 1.12194367e-01f, -1.36297168e-02f, -8.17535520e-02f, 5.95421083e-02f, -5.19560501e-02f, 2.24564467e-02f, -8.58939588e-02f,
  2.00715885e-02f, -2.14263350e-01f, 5.08086309e-02f, -1.19215935e-01f, -1.94181249e-01f, -1.54992014e-01f, 2.30113730e-01f, -4.50515077e-02f, -4.62718196e-02f, -1.46838874e-01f,
  -7.03932643e-02f, -2.40700468e-02f, -1.65500432e-01f, -4.97250408e-02f, 6.64982758e-03f, -6.78254068e-02f, -1.17325768e-01f, -2.31180415e-01f, -9.28845257e-02f, -1.34519517e-01f,
  3.68523657e-01f, -1.10578742e-02f, 5.10877520e-02f, 2.13509262e-01f, 1.67585909e-02f, -5.94636984e-02f, -1.53436869e-01f, -3.15636545e-02f, 3.84504087e-02f, 3.96063961e-02f,
  9.77048054e-02f, 1.94241673e-01f, 1.19310185e-01f, 7.68912137e-02f, 4.22962718e-02f, -1.26921982e-01f, -4.77158502e-02f, 1.00003414e-01f, 1.19860388e-01f, -8.74123871e-02f,
  -1.15030721e-01f, -2.07094535e-01f, 4.70758714e-02f, -4.91600819e-02f, -6.58974499e-02f, -1.76997355e-03f, -4.04306948e-02f, -7.61560798e-02f, -8.43571126e-02f, -1.35968640e-01f,
  2.42555663e-02f, 2.65895575e-01f, 1.75147191e-01f, 8.54875594e-02f, -3.44380401e-02f, 4.05365452e-02f, 4.19780426e-02f, 2.38919128e-02f, 1.48284659e-02f, 1.19301341e-01f,
  1.75387394e-02f, -6.65962920e-02f, -9.79878753e-02f, -9.73691717e-02f, -9.73288491e-02f, -7.00094774e-02f, 4.76169884e-02f, -5.21541536e-02f, -4.88838851e-02f, 3.21023865e-03f,
  3.05619054e-02f, 2.13879272e-02f, -7.38828555e-02f, 2.42577549e-02f, 1.28087576e-03f, 1.49278566e-01f, -4.31647226e-02f, -5.51043227e-02f, -3.62562798e-02f, -6.99686930e-02f,
  -7.52332434e-02f, -1.29772097e-01f, -2.26054918e-02f, 7.57430494e-02f, -7.69691169e-02f, 2.78211050e-02f, 1.08463891e-01f, -1.57096628e-02f, -2.20921353e-01f, -1.61269322e-01f,
  -3.06962188e-02f, -1.93360925e-03f, 5.47547378e-02f, 6.10826649e-02f, 4.16527130e-02f, -5.32879606e-02f, -3.01251691e-02f, 1.19208008e-01f, 7.75995804e-03f, -7.70542398e-02f,
  -5.88769652e-02f, -4.59582396e-02f, 6.84352741e-02f, -9.80995521e-02f, 9.61274952e-02f, 6.86238036e-02f, -7.83548877e-02f, -4.41834405e-02f, -1.49288997e-01f, -8.91956910e-02f,
  1.53405163e-02f, 3.04173052e-01f, 1.12958953e-01f, -1.22548947e-02f, 4.55701351e-02f, 3.90683301e-03f, 1.78356320e-01f, 1.26146823e-01f, 1.46308616e-01f, 7.22662210e-02f,
  7.31995255e-02f, 5.92595339e-02f, -9.62362364e-02f, -1.02080241e-01f, -7.81643614e-02f, 7.58096501e-02f, -1.17121069e-02f, -1.20398728e-02f, 1.15614563e-01f, 1.08986869e-01f,
  2.51762699e-02f, 1.58802941e-02f, 1.91190526e-01f, 1.56082273e-01f, 2.86060274e-02f, 1.61871910e-01f, 1.60591468e-01f, -2.10537333e-02f, 1.47544071e-01f, 4.22851890e-02f,
  -6.04043961e-01f, 2.50225663e-01f, 7.24212825e-02f, -2.77564168e-01f, 1.44995883e-01f, 2.75719464e-01f, 5.75618327e-01f, 1.02397472e-01f, -1.33765191e-01f, 9.44260955e-02f,
  -8.82116854e-02f, -2.34881610e-01f, -1.97713464e-01f, 3.24396826e-02f, 1.82580471e-01f, 3.48489583e-01f, 2.71658987e-01f, -7.98401460e-02f, -6.75799400e-02f, 6.51203096e-02f,
  3.42547745e-02f, -1.86595261e-01f, -3.16802859e-01f, -1.56743422e-01f, -6.83523715e-02f, -1.67628899e-01f, 3.05878147e-02f, -1.05997339e-01f, 4.61133160e-02f, -2.04560868e-02f,
  -2.02088088e-01f, 3.43991071e-02f, -9.06822383e-02f, -1.54043540e-01f, -7.67090097e-02f, -8.78438056e-02f, -2.38827895e-02f, -1.84386373e-01f, -1.67177185e-01f, -1.48417532e-01f,
  -1.57272980e-01f, 1.26409214e-02f, -1.79790899e-01f, -4.90613468e-02f, -1.59618422e-01f, -3.38721201e-02f, -5.62808849e-02f, -1.67665146e-02f, 3.41398530e-02f, 7.05231950e-02f,
  1.45075530e-01f, 9.33310762e-02f, 1.97700839e-02f, 6.17448539e-02f, -4.03355574e-03f, 3.15430807e-03f, 5.05191498e-02f, -4.94603477e-02f, 8.54190439e-02f, -1.28648132e-01f,
  3.14684324e-02f, 4.00227960e-03f, 3.68726701e-02f, 1.75702460e-02f, 4.98240329e-02f, 1.80271659e-02f, -7.19809085e-02f, -2.46247575e-02f, -7.21815974e-02f, -4.29777801e-02f,
  -1.01504572e-01f, 3.06827873e-02f, -8.67344961e-02f, -1.71247870e-01f, -8.82448480e-02f, 8.19676146e-02f, 1.53857945e-02f, -8.35406035e-03f, 2.57612430e-02f, -7.37770796e-02f,
  1.20770507e-01f, -2.29354221e-02f, -1.45336717e-01f, 1.81112550e-02f, 3.35924439e-02f, -1.42002329e-01f, -7.88562931e-04f, 7.50248283e-02f, -4.78130206e-02f, -1.80694775e-03f,
  -2.49268740e-01f, 2.08607078e-01f, -3.27342041e-02f, -1.65126026e-02f, 3.24847922e-02f, -2.88993865e-02f, -6.56869933e-02f, -6.56600669e-02f, 1.84631906e-02f, -1.77971683e-02f,
  -1.03190958e-01f, -3.79857793e-02f, -3.83065268e-02f, -1.17465876e-01f, -7.11344555e-02f, 4.90899198e-03f, 1.27514184e-01f, 4.02283035e-02f, 8.17303136e-02f, 6.80384710e-02f,
  8.84773508e-02f, 4.40841392e-02f, 5.66321909e-02f, -1.79176163e-02f, 5.03056236e-02f, 5.61468191e-02f, -1.92229822e-02f, -4.81411219e-02f, 5.38445637e-02f, -2.05570757e-02f,
  5.57821691e-01f, -7.63456449e-02f, -3.23848337e-01f, 1.54463083e-01f, -1.54768497e-01f, -7.66964257e-02f, 7.13611990e-02f, 4.92585674e-02f, 1.18241921e-01f, -2.60211304e-02f,
  -3.00090313e-01f, -7.59908631e-02f, -2.03315616e-01f, -1.91753983e-01f, 1.76601365e-01f, 1.95121001e-02f, 1.59680117e-02f, 1.20825462e-01f, -4.53962497e-02f, -1.68107525e-02f,
  2.15459149e-03f, 2.23226007e-03f, 1.43158287e-01f, -1.61651760e-01f, -1.22871697e-01f, -7.98546448e-02f, -2.56278127e-01f, -1.98419183e-01f, -2.14039832e-01f, -1.88034609e-01f,
  -1.82209685e-01f, -2.35262707e-01f, -2.74269059e-02f, 1.11362480e-01f, -1.37005979e-02f, 2.97257900e-02f, 6.44218475e-02f, -9.41516310e-02f, -1.04683511e-01f, -1.43674374e-01f,
  -1.55067831e-01f, -1.07069172e-01f, -3.16070169e-02f, -1.12109422e-03f, -5.95489517e-02f, 4.41902801e-02f, -1.81989834e-01f, -1.08756587e-01f, -1.19895980e-01f, -1.71858758e-01f,
  -6.02700040e-02f, -5.85825592e-02f, -1.03195809e-01f, -5.45167364e-02f, -2.33441144e-01f, -1.14046827e-01f, -3.15337360e-01f, -2.66092688e-01f, -2.70463049e-01f, -8.48585926e-03f,
  3.48509066e-02f, 1.73777100e-02f, -1.05556130e-01f, 5.36932983e-02f, 1.36544332e-01f, 5.38127124e-02f, -7.30789779e-03f, 1.45612270e-01f, -1.09128073e-01f, 1.52688742e-01f,
  2.25424394e-02f, -1.44846141e-01f, -5.93422130e-02f, 5.40859997e-02f, -2.47821081e-02f, 1.56236410e-01f, -1.04421303e-01f, 7.44820535e-02f, 5.81263267e-02f, 7.09134638e-02f,
  1.19401023e-01f, 7.21477866e-02f, -1.15631765e-03f, 1.84981134e-02f, -7.07047805e-02f, -1.15124481e-02f, 1.07001461e-01f, -1.70454960e-02f, -3.63835804e-02f, 5.51274084e-02f,
  1.97111070e-01f, -8.68175104e-02f, 1.05709873e-01f, 1.18611567e-01f, 4.72440906e-02f, -3.20752040e-02f, -3.89756709e-02f, 3.20059620e-02f, -7.59632662e-02f, -1.93676114e-01f,
  -2.09546492e-01f, 2.15946697e-02f, -1.46412715e-01f, -3.83928157e-02f, 4.39269096e-02f, 6.81085289e-02f, 5.75309806e-02f, 1.93803925e-02f, 6.41808882e-02f, 1.01126425e-01f,
  1.86371341e-01f, 1.54893577e-01f, 3.27822566e-01f, 2.87352260e-02f, 2.55080052e-02f, 2.07224175e-01f, -1.72211658e-02f, 1.02506734e-01f, 2.13357538e-01f, 4.81129259e-01f,
  -8.83401185e-02f, -1.24539115e-01f, -2.53000259e-01f, -1.22263268e-01f, -1.05903007e-01f, -1.73484027e-01f, -3.35355282e-01f, 4.61655147e-02f, 1.80195346e-01f, -2.94425994e-01f,
  -7.62862563e-02f, 1.03779919e-01f, -1.51164636e-01f, -1.32566407e-01f, -1.35459676e-01f, -2.58682817e-01f, -3.24662834e-01f, -5.00199646e-02f, 8.37608203e-02f, 1.31637245e-01f,
  1.35386558e-02f, 4.44728620e-02f, 7.58932605e-02f, 6.65351599e-02f, -8.47093314e-02f, 2.71004383e-02f, -6.77549094e-02f, -7.85485059e-02f, -1.48759723e-01f, -8.00838619e-02f,
  -3.06884617e-01f, -8.69293213e-02f, -9.77030620e-02f, -4.44234023e-03f, -2.36854747e-01f, -1.08207732e-01f, -1.63846448e-01f, -7.91023299e-02f, 4.25389186e-02f, -1.67382509e-01f,
  -1.39328226e-01f, -2.15009004e-02f, -9.18697044e-02f, -2.39767488e-02f, -6.24221808e-04f, 1.91688649e-02f, 4.68117185e-02f, 1.00361139e-01f, 3.15247476e-02f, -8.17242637e-02f,
  -9.18516368e-02f, -9.06836316e-02f, -8.06844085e-02f, 4.90546878e-03f, 8.08716640e-02f, -1.23445066e-02f, 1.12196721e-01f, 2.25648731e-01f, 1.09759524e-01f, -4.43753302e-02f,
  2.79501323e-02f, 1.23222180e-01f, -5.15865907e-02f, -5.86012825e-02f, 2.94468906e-02f, -6.91717491e-02f, 5.66099323e-02f, -3.26832384e-02f, -3.71181518e-02f, -8.25779792e-03f,
  1.05802409e-01f, -2.47999430e-02f, 8.86810049e-02f, 7.29420111e-02f, -2.68934388e-02f, 3.54117081e-02f, 9.74436570e-03f, -1.02837086e-01f, -2.81506833e-02f, 1.73921615e-01f,
  9.13087428e-02f, -2.36109998e-02f, 1.27419651e-01f, 1.85079247e-01f, 1.23713605e-01f, 7.21536204e-02f, 1.14288695e-01f, 1.34335190e-01f, 1.23070791e-01f, 1.83321208e-01f,
  -9.99575853e-03f, -1.07852846e-01f, -1.68228909e-01f, -1.57911196e-01f, 3.33177065e-03f, -1.42270997e-01f, -1.64486930e-01f, -1.10006686e-02f, -5.47566339e-02f, -6.86429739e-02f,
  1.33498851e-02f, -1.19512521e-01f, -1.75187051e-01f, -1.35930166e-01f, -1.20980032e-01f, -1.58097446e-01f, -1.95074365e-01f, -1.56868771e-01f, 1.63739547e-02f, 5.15927635e-02f,
  -1.37069849e-02f, -1.47107869e-01f, -1.47946417e-01f, -1.28187105e-01f, 2.60297712e-02f, -1.61455691e-01f, -3.83925475e-02f, -2.95458976e-02f, -8.65125880e-02f, -1.31459191e-01f,
  -1.21010728e-02f, -2.00232416e-01f, -3.95313263e-01f, -2.43380129e-01f, -4.08965170e-01f, -3.28296423e-01f, -2.21369088e-01f, 6.59168661e-02f, -4.62423079e-02f, -3.40858281e-01f,
  -1.50872067e-01f, 2.55378366e-01f, 7.41024464e-02f, 3.06732785e-02f, 1.60333708e-01f, -3.65503073e-01f, -2.67939746e-01f, -1.39355659e-01f, 2.68061191e-01f, 1.70690462e-01f,
  8.43078047e-02f, -8.55529755e-02f, -2.29459442e-02f, 3.05962637e-02f, -1.87654793e-01f, -1.07820094e-01f, -3.47136736e-01f, -1.40139282e-01f, -2.47963250e-01f, -3.46946329e-01f,
  -6.73686713e-02f, -1.23973131e-01f, -1.65581629e-01f, 8.16546157e-02f, -1.24416433e-01f, 3.82779427e-02f, -2.29630116e-02f, -2.20898017e-01f, -9.42012966e-02f, 3.61426850e-03f,
  -6.29536510e-02f, 1.05266184e-01f, 7.05299452e-02f, 2.06916593e-02f, -2.42938735e-02f, 9.44048539e-02f, -1.03973024e-01f, 5.28300852e-02f, -9.36201513e-02f, -3.53002064e-02f,
  7.93516561e-02f, -8.82405937e-02f, -1.04017042e-01f, -1.12601735e-01f, -2.97340043e-02f, -4.90660667e-02f, -9.01421756e-02f, -9.14841890e-02f, -1.45584062e-01f, -6.88986257e-02f,
  -9.96853784e-02f, -4.61730845e-02f, 7.33259087e-03f, 7.85856023e-02f, 7.62543082e-02f, -3.41295488e-02f, 6.34833723e-02f, 7.62773082e-02f, 1.41872853e-01f, 4.73232474e-03f,
  -2.19272431e-02f, -7.62519240e-02f, 6.33663833e-02f, -4.01816517e-02f, -1.36809170e-01f, 8.66611395e-03f, 5.30481525e-02f, -2.69174594e-02f, -1.16910994e-01f, -9.32890773e-02f,
  -1.20232180e-01f, -8.88617933e-02f, -1.17666140e-01f, 3.83318625e-02f, -1.79242730e-01f, -6.25719829e-03f, 8.65252316e-02f, 1.24279894e-01f, 9.20316055e-02f, -4.94095683e-03f,
  2.34232754e-01f, -9.44472030e-02f, 1.03182485e-02f, 2.07146958e-01f, -1.41472176e-01f, -5.90761676e-02f, -1.49127573e-01f, -3.11784968e-02f, -4.50836727e-03f, 8.50492343e-02f,
  -5.85779324e-02f, 1.76131457e-01f, 7.97643289e-02f, 6.03460409e-02f, -5.21533042e-02f, 3.18828039e-02f, 8.51152986e-02f, 1.70720406e-02f, -7.86613375e-02f, -1.17947549e-01f,
  -4.26261425e-02f, 1.08774655e-01f, 2.00281769e-01f, 5.91162108e-02f, -4.77128774e-02f, 1.35468971e-02f, -2.08185501e-02f, 1.34403566e-02f, 1.13775402e-01f, 4.86562178e-02f,
  1.49620935e-01f, 1.15927123e-01f, -2.06835166e-01f, 4.29299653e-01f, 2.18936250e-01f, -1.27086475e-01f, -3.34560156e-01f, -6.09781817e-02f, 1.77744627e-01f, 6.35702834e-02f,
  1.53684855e-01f, 3.36908191e-01f, 1.18077829e-01f, 1.91225141e-01f, -7.58941397e-02f, -9.93821584e-03f, 1.41458318e-01f, -6.58360869e-02f, -1.49598941e-01f, 9.99752283e-02f,
  3.73501658e-01f, 1.24548748e-01f, -1.39113039e-01f, 8.58005658e-02f, 2.68224031e-01f, 3.46544445e-01f, 3.44980322e-02f, 3.63428087e-04f, 1.45257369e-01f, 3.45584482e-01f,
  1.65116880e-02f, -8.54779929e-02f, 1.21826433e-01f, 1.95515752e-01f, 3.71858813e-02f, -9.82154682e-02f, 9.04640928e-02f, -2.25393232e-02f, -5.16095106e-03f, -3.63477692e-02f,
  9.72501040e-02f, 1.48686096e-02f, 6.24149777e-02f, 7.65080974e-02f, 9.99293569e-03f, 1.51132159e-02f, -6.19277619e-02f, -1.66739106e-01f, -1.92770675e-01f, -9.98177603e-02f,
  2.41054222e-01f, 1.69957235e-01f, -1.88024685e-01f, -1.29949912e-01f, -1.87841535e-01f, -3.36962752e-02f, -1.51600152e-01f, -1.23096555e-01f, -1.73271328e-01f, 2.14307122e-02f,
  1.71797052e-01f, -6.89158542e-03f, -3.52402613e-03f, -7.30744656e-03f, 5.92530333e-02f, 3.59523818e-02f, 5.15568927e-02f, 3.27765644e-02f, 1.99326836e-02f, -1.18482420e-02f,
  1.24731166e-02f, 8.90431106e-02f, -1.39713839e-01f, -5.88634703e-03f, 1.90065250e-01f, 3.93330418e-02f, 1.22136138e-02f, -2.96868775e-02f, -6.37272224e-02f, 2.54145823e-02f,
  3.33803520e-02f, -1.72971144e-01f, 8.68018493e-02f, -5.16763516e-02f, -2.51010284e-02f, 1.39083669e-01f, 1.56710207e-01f, 6.03911243e-02f, 1.48016348e-01f, 2.09577516e-01f,
  -7.05640344e-03f, -1.08824603e-01f, 2.21771270e-01f, -4.38972153e-02f, -6.21135719e-02f, -4.11078408e-02f, 4.38377261e-02f, -8.34450871e-02f, -5.09715872e-03f, -2.49999929e-02f,
  -1.08047932e-01f, 2.60249916e-02f, -1.14440009e-01f, -1.18413247e-01f, -1.39102846e-01f, 7.28334263e-02f, -8.82332921e-02f, -1.43768653e-01f, -1.66832551e-01f, -1.09525532e-01f,
  -1.37819007e-01f, -1.35913387e-01f, -1.01461999e-01f, -1.33579552e-01f, -2.14531161e-02f, 5.49371801e-02f, -1.30824298e-01f, -1.99997127e-01f, -2.48624191e-01f, -2.42745340e-01f,
  -6.32243514e-01f, 1.52408645e-01f, -4.84969355e-02f, -3.28860998e-01f, -3.66611332e-01f, -3.56775194e-01f, -2.12851197e-01f, -1.53191879e-01f, -2.45344400e-01f, -1.99275002e-01f,
  -4.46217954e-02f, 2.06518233e-01f, 4.28912416e-02f, 1.79077056e-03f, -1.37588888e-01f, -1.61949724e-01f, -2.12427810e-01f, -3.75774652e-01f, -2.96705693e-01f, -2.46971816e-01f,
  -1.85303628e-01f, -4.83444005e-01f, -4.72105682e-01f, -9.55183953e-02f, 1.27398483e-02f, -6.18904270e-02f, -5.94259277e-02f, -1.36485487e-01f, -1.99946500e-02f, 1.03302989e-02f,
  2.42621928e-01f, -9.53428894e-02f, -1.27942236e-02f, -1.84507117e-01f, -1.24047026e-01f, -5.16058132e-03f, 3.35608274e-02f, -2.16431599e-02f, 6.98277578e-02f, 1.17364321e-02f,
  -1.56366512e-01f, 6.29131275e-04f, -2.47867890e-02f, -5.91023378e-02f, -1.38665259e-01f, -3.45931426e-02f, 2.86479499e-02f, -7.78347328e-02f, 3.21093425e-02f, 1.85016245e-01f,
  2.21493021e-02f, -1.49584278e-01f, 6.96509480e-02f, -4.56432160e-03f, 1.01374552e-01f, 1.57326814e-02f, 1.33646861e-01f, 5.71869202e-02f, 1.25430837e-01f, 1.26869172e-01f,
  3.86073664e-02f, 1.05678320e-01f, 6.53705224e-02f, -5.28991856e-02f, -1.05714975e-02f, -7.05117434e-02f, 8.96623358e-04f, 1.26851192e-02f, -1.41003414e-03f, -2.66254470e-02f,
  4.79338653e-02f, -6.53307140e-02f, 2.32046545e-02f, -2.87689492e-02f, 2.77914084e-03f, -1.16429059e-02f, -5.41010238e-02f, -9.23666544e-03f, 1.09452857e-02f, -7.39661604e-02f,
  -4.96207438e-02f, 5.88007458e-02f, -7.25971684e-02f, 1.14473507e-01f, -6.12286367e-02f, -1.30975753e-01f, -1.08868005e-02f, 8.44014362e-02f, -7.02263461e-03f, -7.87557065e-02f,
  3.36060375e-02f, -1.68175697e-01f, -8.63779709e-02f, 9.83442087e-03f, 2.70408876e-02f, -1.32276199e-03f, 1.54875115e-01f, -5.12359925e-02f, -6.49098679e-02f, -1.15802912e-02f,
  2.97500584e-02f, -4.75101396e-02f, -2.39701848e-02f, 3.71181220e-02f, -3.71155478e-02f, -5.24960160e-02f, -9.67727378e-02f, -4.35123034e-02f, -1.78380124e-02f, 1.98848620e-01f,
  -7.11082853e-03f, -1.18348792e-01f, -2.87493747e-02f, 4.89102080e-02f, 1.22906789e-01f, -2.12089233e-02f, 1.93658665e-01f, 1.86906546e-01f, 7.52032027e-02f, 1.09292582e-01f,
  -2.64015228e-01f, -4.23071444e-01f, 1.55187979e-01f, 2.47591257e-01f, 4.17929769e-01f, 4.22876686e-01f, 3.77088070e-01f, 1.40507057e-01f, 1.27887636e-01f, -1.09091632e-01f,
  -4.52710211e-01f, -4.13475305e-01f, -4.08214509e-01f, -1.76714316e-01f, -8.96034837e-02f, 2.64710784e-01f, 4.57057774e-01f, 4.81627770e-02f, 1.12807967e-01f, 1.95966929e-01f,
  1.04652233e-01f, -2.24876963e-02f, -1.78179145e-01f, -1.02305233e-01f, 1.23009205e-01f, 1.05929367e-01f, -1.25381015e-02f, -1.85524318e-02f, -9.73411724e-02f, 5.10662124e-02f,
  -3.71355414e-01f, -3.49339217e-01f, 1.54791996e-01f, -1.55900821e-01f, -7.89256021e-02f, -1.35563344e-01f, -8.02901853e-03f, -6.82841688e-02f, -6.56401142e-02f, -1.86772980e-02f,
  2.76932064e-02f, -4.83222231e-02f, 3.45100425e-02f, 3.73314172e-02f, 8.13324749e-02f, 1.21953093e-01f, -1.46900833e-01f, -1.54612139e-01f, -8.61327872e-02f, -4.02026251e-02f,
  -1.39409769e-02f, -7.04330131e-02f, -5.27404360e-02f, 1.44679606e-01f, -5.07602505e-02f, -1.95083786e-02f, -1.57057364e-02f, -6.22644350e-02f, -1.56331569e-01f, -1.05966710e-01f,
  -1.52430050e-02f, -7.42979422e-02f, 9.45050362e-03f, -6.76572174e-02f, -1.12255681e-02f, 1.01448022e-01f, 2.95277946e-02f, -9.97876525e-02f, 1.37005627e-01f, 3.82381566e-02f,
  6.07880279e-02f, -5.93415052e-02f, -1.50283664e-01f, -2.80547608e-02f, -1.21926017e-01f, 4.60886629e-03f, 6.30913451e-02f, -8.84220004e-03f, -1.19828336e-01f, 2.74673454e-03f,
  -3.77664939e-02f, 7.75382817e-02f, -3.01049352e-02f, 6.25945553e-02f, -4.70176600e-02f, -4.32637110e-02f, -6.15544505e-02f, -4.30958569e-02f, -6.82099536e-02f, 5.83762303e-02f,
  -4.30728346e-02f, -1.86813429e-01f, -2.81424038e-02f, -4.05813120e-02f, -7.54650831e-02f, -2.17167318e-01f, -1.83163598e-01f, -8.42467844e-02f, 2.14492399e-02f, 1.57422908e-02f,
  -1.15643568e-01f, -4.76853512e-02f, -1.11006297e-01f, 2.55626403e-02f, 9.90085751e-02f, 1.46262124e-01f, -1.35045439e-01f, 6.73662350e-02f, -7.33133405e-02f, -5.21098785e-02f,
  1.08437367e-01f, 2.68424690e-01f, 1.48925021e-01f, 8.74706879e-02f, -7.95845911e-02f, -1.69651210e-02f, 2.03009769e-02f, 1.14938997e-01f, 1.64442226e-01f, 1.41167954e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 26)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 26;
const float L0_fan_Bp_bar_data[] = {
  1.70146301e-01f, 6.08105473e-02f, 5.53994030e-02f, 5.33256605e-02f, 3.42002124e-01f, 1.87817976e-01f, 2.99323291e-01f, 2.50476867e-01f, 2.47119695e-01f, 1.82520404e-01f,
  2.62563139e-01f, 1.66962087e-01f, 1.77121505e-01f, 6.39655278e-04f, 1.96830288e-01f, 2.22649246e-01f, 2.33793318e-01f, 1.36069611e-01f, -1.48073614e-01f, 1.90652356e-01f,
  9.12947655e-02f, 3.96080017e-02f, 2.07362011e-01f, 1.47752985e-01f, 2.10894063e-01f, 1.90288886e-01f
};

// L1_fan_Wp (Shape: 19 x 64)
const int L1_fan_Wp_rows = 19;
const int L1_fan_Wp_cols = 64;
const float L1_fan_Wp_data[] = {
  -3.56742628e-02f, -2.22326256e-02f, 1.97224244e-02f, -4.20483425e-02f, 4.65890346e-03f, -2.31687576e-02f, 7.08736703e-02f, 3.27616781e-02f, -1.00088648e-01f, -1.21829614e-01f,
  9.09047425e-02f, -6.71223029e-02f, 4.26214598e-02f, -1.10855870e-01f, -1.03496678e-01f, -3.14696468e-02f, 1.07265478e-02f, 7.41087720e-02f, -4.13556956e-02f, -1.22994989e-01f,
  -1.23968914e-01f, -1.75427683e-02f, 1.23864156e-03f, 1.34937480e-01f, 8.29667747e-02f, -1.43812716e-01f, 3.46901529e-02f, -4.00013328e-02f, -3.24174501e-02f, -7.78238624e-02f,
  -4.00849357e-02f, 1.31991506e-01f, -7.25372508e-02f, 1.34938911e-01f, -7.46253580e-02f, -4.67991121e-02f, -1.34181321e-01f, 6.43589944e-02f, -1.50196210e-01f, 7.62230232e-02f,
  5.26779331e-02f, 7.45107904e-02f, -3.55011761e-01f, 1.52090669e-01f, 9.26176261e-04f, -6.89437017e-02f, 7.36560076e-02f, -2.29155406e-01f, -3.82659405e-01f, 1.89004093e-01f,
  -2.73916632e-01f, -5.93690984e-02f, 2.24876747e-01f, -1.72372431e-01f, 2.14382395e-01f, -1.54818758e-01f, 5.12933619e-02f, -6.79483041e-02f, 5.92482649e-02f, 9.37179998e-02f,
  2.08192512e-01f, 1.47711605e-01f, -1.76172629e-01f, -3.99933904e-01f, 1.54475152e-01f, -2.29659937e-02f, -3.57481325e-03f, -3.79906222e-02f, 2.44922221e-01f, -3.30808647e-02f,
  1.10800192e-01f, 8.65142718e-02f, 7.47267902e-02f, -2.32590251e-02f, 3.28558125e-02f, -1.73372000e-01f, -5.51073737e-02f, -2.19919775e-02f, -7.69050792e-02f, 9.14438888e-02f,
  -6.71167392e-03f, 1.64586887e-01f, -1.01738811e-01f, 1.16871789e-01f, -1.90227702e-01f, -4.63293381e-02f, 8.59721936e-03f, -4.46784273e-02f, 1.35235474e-01f, -2.11659789e-01f,
  2.11799577e-01f, -6.87501580e-02f, 1.67076305e-01f, 9.07169282e-02f, -1.39690444e-01f, 9.36164614e-03f, 1.39676675e-01f, 9.41187367e-02f, -9.86796990e-02f, -1.33127823e-01f,
  -5.57879955e-02f, -7.55652562e-02f, -7.01568127e-02f, -2.73589402e-01f, -3.55583765e-02f, 1.28344800e-02f, 2.12376684e-01f, 2.37354726e-01f, 2.28991985e-01f, -3.31089675e-01f,
  3.49582732e-02f, 2.54896153e-02f, 9.36750323e-02f, -2.02801079e-01f, 8.52719471e-02f, -4.70751636e-02f, 2.81816751e-01f, 2.73805689e-02f, 1.82047144e-01f, -8.19224343e-02f,
  7.82783516e-03f, -1.02297589e-01f, -1.62191555e-01f, -3.61334346e-02f, 2.71165729e-01f, 7.52260163e-02f, 3.99661720e-01f, -2.61189997e-01f, -7.21811429e-02f, -1.28809437e-02f,
  1.80609133e-02f, -3.57628800e-02f, -9.91037339e-02f, 7.19221979e-02f, -1.91443637e-02f, -3.06649506e-02f, 4.92730439e-02f, 9.62965842e-03f, -2.43770659e-01f, -9.12320912e-02f,
  2.66832765e-03f, -6.25785291e-02f, -7.94420540e-02f, 3.07243094e-02f, 1.41123369e-01f, -1.38265931e-03f, -2.44350191e-02f, -7.89219812e-02f, 8.45056996e-02f, 8.62623602e-02f,
  7.15251341e-02f, 2.98656598e-02f, -2.64893714e-02f, 4.17161435e-02f, 2.69846600e-02f, -5.31816781e-02f, -5.96702248e-02f, 1.56801715e-02f, 8.04418400e-02f, 4.06793579e-02f,
  -1.56250164e-01f, 2.36745849e-02f, -3.59197892e-03f, -5.18741794e-02f, 3.56081501e-02f, -2.82851961e-02f, 3.06441754e-01f, -1.15741201e-01f, 2.10821912e-01f, 3.17104489e-01f,
  -2.08284542e-01f, 2.58730557e-02f, -3.19658697e-01f, 2.32273757e-01f, 1.50979057e-01f, 3.05611230e-02f, -3.88303876e-01f, 5.16661853e-02f, -2.92293280e-02f, -1.66374385e-01f,
  7.85932988e-02f, -2.10829541e-01f, 1.56992957e-01f, -6.64804131e-02f, 7.63981715e-02f, -1.80136293e-01f, 4.47501034e-01f, -8.30935873e-03f, -8.05327445e-02f, 3.08263570e-01f,
  -3.01229715e-01f, 2.86586195e-01f, -1.66019186e-01f, -5.58342338e-02f, -9.00086090e-02f, -1.06360130e-01f, -3.22371088e-02f, 4.01144773e-02f, 1.01841100e-01f, 1.56822726e-01f,
  -7.82833919e-02f, -2.11811468e-01f, -1.43099174e-01f, -1.03783555e-01f, -4.29153927e-02f, -7.86613375e-02f, -2.41899677e-02f, -6.39027730e-02f, 1.21337533e-01f, -5.21664098e-02f,
  3.26835201e-04f, -1.11953169e-01f, -1.26640946e-01f, -1.35245800e-01f, 8.97965655e-02f, -7.70849064e-02f, 4.05351594e-02f, 2.06402838e-02f, 2.17379063e-01f, -9.20635909e-02f,
  -1.17364831e-01f, 2.12629754e-02f, 1.10891275e-01f, 1.08632013e-01f, 1.18960142e-01f, -6.21703826e-02f, -1.08087815e-01f, -1.27091900e-01f, -1.27714336e-01f, 2.82213204e-02f,
  1.86105460e-01f, -2.63198495e-01f, -1.47876248e-01f, -1.22875281e-01f, -2.04792559e-01f, 2.51195759e-01f, -5.13705686e-02f, -1.49788871e-01f, 8.31953138e-02f, 2.80176513e-02f,
  3.78425904e-02f, -3.93415280e-02f, -6.11258745e-02f, 2.91939735e-01f, 3.49218816e-01f, 2.68060595e-01f, 9.31363925e-02f, 1.97472826e-01f, -1.05009880e-02f, 2.03555062e-01f,
  -3.77809525e-01f, 3.92384343e-02f, -2.37265691e-01f, 1.51840240e-01f, 6.38925433e-02f, -1.05859794e-01f, -1.92265183e-01f, -1.72853053e-01f, 9.44130942e-02f, -4.60787937e-02f,
  7.30050504e-02f, -1.02225885e-01f, -3.70745361e-02f, 5.22704050e-03f, -6.57237545e-02f, 6.26891628e-02f, -8.18374828e-02f, 7.56109925e-03f, -3.24956998e-02f, -5.85856661e-02f,
  -5.70174269e-02f, -9.91506130e-02f, 6.28331006e-02f, 4.33639102e-02f, -1.48383513e-01f, -2.39124060e-01f, 1.05524408e-02f, 1.32163912e-01f, 1.39022134e-02f, 1.92482211e-02f,
  -1.17612481e-01f, 1.70728564e-01f, 1.49160614e-02f, -1.56283498e-01f, -2.74100304e-01f, -1.59862682e-01f, 1.51307210e-01f, -6.58358727e-03f, -1.87501043e-01f, -7.44192824e-02f,
  1.10024974e-01f, 2.92830449e-02f, -1.91095009e-01f, -2.02642336e-01f, 4.46980074e-03f, 6.26711026e-02f, -4.23458144e-02f, 2.66231000e-01f, -1.86313480e-01f, -2.37679467e-01f,
  -2.33248435e-02f, 5.05965948e-01f, 1.13618553e-01f, -1.19026806e-02f, 1.65642314e-02f, 3.94118614e-02f, -1.88204274e-01f, -9.87866446e-02f, -2.78367311e-01f, -3.01373508e-02f,
  -2.29136661e-01f, 5.89450588e-03f, -2.55965590e-01f, -1.85233906e-01f, 1.22791380e-01f, -2.35602915e-01f, -1.01012006e-01f, 1.22661456e-01f, -1.36691213e-01f, -6.02922291e-02f,
  -1.26456851e-02f, -1.34358183e-01f, 1.31585732e-01f, 1.74093843e-01f, 6.10216297e-02f, 9.41540450e-02f, 1.48090005e-01f, 3.12092453e-02f, 3.54952142e-02f, 2.59837713e-02f,
  -4.03246731e-02f, -8.39324445e-02f, 7.60521740e-02f, -3.50634684e-03f, 3.93693596e-02f, -1.48596674e-01f, -1.08660974e-01f, 9.10768360e-02f, -5.13890125e-02f, 5.33342063e-02f,
  1.41963527e-01f, -7.75971413e-02f, 8.12021345e-02f, -3.11755478e-01f, 8.06266814e-02f, 6.79264516e-02f, 1.13867104e-01f, 7.02450946e-02f, -1.33303672e-01f, -1.01958349e-01f,
  -1.22081998e-04f, 6.54997602e-02f, -9.20717046e-02f, 1.70757309e-01f, 1.48762673e-01f, 4.68422920e-02f, -1.35293946e-01f, -1.60033166e-01f, 2.11695135e-01f, -1.13508627e-01f,
  -1.43917277e-01f, -2.17048451e-01f, 6.16886169e-02f, -1.23242535e-01f, 1.88822925e-01f, 3.31337899e-02f, 1.19770542e-01f, -1.22987159e-01f, 2.34044507e-01f, -2.03859538e-01f,
  3.80163379e-02f, 1.15536258e-01f, 4.06294204e-02f, 9.01464671e-02f, -7.79630840e-02f, 1.13659561e-01f, 5.68545610e-02f, 3.01289797e-01f, -1.26873050e-02f, -2.08226174e-01f,
  -2.52069145e-01f, -5.06237149e-02f, -1.42042264e-01f, -9.04114246e-02f, 1.59705460e-01f, 8.57811123e-02f, 6.87449723e-02f, 9.77758765e-02f, 8.93452093e-02f, 1.36937760e-02f,
  5.89507669e-02f, -1.93143353e-01f, 9.08275396e-02f, 3.03378496e-02f, 1.49891436e-01f, 1.33973658e-02f, -7.30889365e-02f, -1.10139837e-02f, 1.35100365e-01f, -8.83502290e-02f,
  1.24511637e-01f, 6.68894500e-02f, 1.18714765e-01f, 2.55024910e-01f, -2.14018628e-01f, -2.01105028e-02f, 8.55532959e-02f, 7.65960990e-03f, -9.71924141e-02f, 3.51978391e-02f,
  -1.17838614e-01f, 4.54607904e-02f, 1.16351202e-01f, 6.77832812e-02f, -7.89371494e-04f, 1.68842152e-01f, -1.84813768e-01f, 3.94465774e-02f, 3.74880135e-02f, -2.71449913e-03f,
  3.15540969e-01f, 2.67781019e-01f, -8.61454308e-02f, 8.43180791e-02f, 1.20082892e-01f, 1.43222257e-01f, 3.50903757e-02f, -1.57622874e-01f, 1.08551174e-01f, 1.41414881e-01f,
  9.84422863e-02f, 3.20865452e-01f, 7.71641731e-02f, 1.00343928e-01f, 3.60336900e-02f, -1.86943784e-02f, -2.58109599e-01f, -2.32594103e-01f, 7.24697933e-02f, -3.78559500e-01f,
  -1.20593697e-01f, -5.85343428e-02f, 4.03008401e-01f, -1.08607307e-01f, 1.17802903e-01f, 2.54932866e-02f, -1.62186325e-01f, -1.35339171e-01f, -3.07009462e-02f, 7.70674124e-02f,
  4.99545299e-02f, -6.06053770e-02f, 8.65685493e-02f, 1.06093436e-01f, -1.26841828e-01f, -1.50770359e-02f, 6.53711846e-03f, -5.78725338e-02f, -6.13939017e-02f, 1.69288795e-02f,
  -5.99807054e-02f, 8.29907730e-02f, -1.75765261e-01f, 5.38398512e-02f, 3.54186702e-03f, -1.62930071e-01f, -4.32404631e-04f, -2.37677082e-01f, -2.32245058e-01f, 8.15972462e-02f,
  1.54111579e-01f, 2.49489784e-01f, -6.90205991e-02f, 1.55223146e-01f, -5.76051660e-02f, 2.21343786e-02f, 1.39589151e-02f, -4.60255332e-02f, 8.03714022e-02f, 1.03986925e-02f,
  -1.17290229e-01f, 1.43677264e-01f, 1.70011129e-02f, 6.69412464e-02f, 1.22902475e-01f, -5.49377762e-02f, 2.36468360e-01f, -1.07266046e-01f, 2.33710222e-02f, -3.23657133e-02f,
  1.78023234e-01f, -1.57352597e-01f, -2.61976510e-01f, 3.20551783e-01f, 1.64827332e-01f, 2.60219216e-01f, -3.36843103e-01f, -1.35901988e-01f, 1.81523666e-01f, -1.66158691e-01f,
  -2.17173755e-01f, -1.45899668e-01f, -3.17959227e-02f, -2.39983782e-01f, -2.73237266e-02f, -2.06449211e-01f, 2.67054796e-01f, 8.92783608e-03f, 7.08566904e-02f, 1.32029474e-01f,
  1.00670993e-01f, 2.42986530e-01f, 2.80828085e-02f, -2.06461176e-02f, 1.54543100e-02f, -1.45039139e-02f, 1.63759775e-02f, 2.51980964e-02f, -7.15948418e-02f, -2.21259501e-02f,
  -9.76916477e-02f, 4.93327416e-02f, -8.29244256e-02f, -3.24463248e-02f, 4.31180261e-02f, 9.25773531e-02f, -1.56923458e-01f, 2.03889593e-01f, -1.84307564e-02f, 4.12989818e-02f,
  -4.09596972e-02f, 2.11183131e-02f, -1.76733255e-01f, 2.84050182e-02f, 1.26872048e-01f, 3.69794630e-02f, 3.39079276e-02f, 3.70882414e-02f, -9.51602384e-02f, 1.75878257e-01f,
  -9.25335567e-04f, -1.14093997e-01f, -5.51470518e-02f, -3.40925790e-02f, -9.02397037e-02f, -2.23537050e-02f, 2.26782560e-02f, -1.14240147e-01f, -9.49102640e-03f, -7.80792441e-03f,
  1.01389349e-01f, -2.04527989e-01f, -3.94898243e-02f, 2.48421654e-01f, -1.25642568e-01f, -8.95302929e-03f, -1.73877686e-01f, 5.53570613e-02f, 9.58143473e-02f, 3.26791465e-01f,
  -3.80509198e-01f, -1.14702858e-01f, 1.74585745e-01f, -2.33235285e-01f, -5.16009852e-02f, -1.65900141e-02f, 7.60411695e-02f, -2.71000683e-01f, 7.63649642e-02f, -3.83091241e-01f,
  -3.29488404e-02f, -1.29047912e-02f, 1.51952744e-01f, 2.56913751e-01f, 1.95390165e-01f, -2.43428573e-01f, 2.76630893e-02f, -6.77669719e-02f, -2.56455559e-02f, -1.43032551e-01f,
  -1.15407273e-01f, -5.90167232e-02f, -3.99426296e-02f, 1.32158753e-02f, 6.94129691e-02f, -1.47389490e-02f, -9.26634744e-02f, 6.72250837e-02f, -1.57471821e-01f, 1.70586500e-02f,
  2.94667874e-02f, 2.98608933e-02f, -5.26957680e-03f, 2.22985856e-02f, 5.06893173e-02f, -3.58785614e-02f, -1.24093900e-02f, 1.43878739e-02f, 1.56568006e-01f, -1.78766534e-01f,
  1.36058018e-01f, 1.03511289e-01f, 1.37797430e-01f, 7.33493362e-03f, 6.24342076e-03f, -1.04205579e-01f, 2.16820687e-02f, 2.84145046e-02f, -3.38151902e-02f, 4.25890088e-02f,
  -3.36268395e-02f, -9.85299647e-02f, -1.54947251e-01f, -1.11849554e-01f, 2.85860896e-01f, -6.93743676e-02f, -1.24490306e-01f, -3.69897112e-02f, 1.09378718e-01f, 8.22381526e-02f,
  -9.65994410e-03f, -1.08965905e-02f, 2.31856018e-01f, 2.59112427e-03f, 4.50645834e-02f, -1.31100073e-01f, -1.94423005e-01f, -6.99923886e-03f, 3.63909677e-02f, 3.77647102e-01f,
  -1.73369378e-01f, 1.38263747e-01f, -1.58414811e-01f, 1.05953023e-01f, -3.45479220e-01f, -6.54538646e-02f, -2.56063521e-01f, 1.74278438e-01f, 4.51139035e-03f, 1.94776043e-01f,
  4.40585315e-02f, -7.33314129e-03f, 8.94341245e-02f, -4.42392826e-02f, 3.23524214e-02f, -8.09156671e-02f, -5.53672425e-02f, 4.99960892e-02f, -1.04363188e-02f, 1.96824729e-01f,
  9.29955021e-02f, -2.73206625e-02f, 3.59480642e-02f, -2.47979201e-02f, 2.52435971e-02f, -4.60699992e-03f, 9.32526868e-03f, -1.39250785e-01f, -1.41905183e-02f, 1.16592884e-01f,
  2.51140356e-01f, 1.53688222e-01f, 8.06774795e-02f, -1.43158674e-01f, -3.51014175e-03f, 8.05321336e-02f, -2.11496830e-01f, 1.24610662e-01f, 8.53578001e-02f, -1.81146972e-02f,
  2.69075092e-02f, -1.80262566e-01f, 4.60725613e-02f, -8.56921449e-02f, -3.12506817e-02f, 4.75277454e-02f, 1.69508420e-02f, -2.27153618e-02f, 7.23075122e-02f, 1.34173229e-01f,
  -1.81586705e-02f, -2.09214851e-01f, 3.81275088e-01f, -1.01612985e-01f, 1.51830241e-01f, -2.32479915e-01f, -9.41080824e-02f, 1.56380132e-01f, 2.59824485e-01f, 1.07099558e-03f,
  2.54411474e-02f, -1.67732045e-01f, -2.84341804e-04f, 9.96267721e-02f, -1.89933628e-01f, 1.55634791e-01f, -1.20525777e-01f, 2.62382984e-01f, 2.89051607e-02f, -1.85408682e-01f,
  -3.55485687e-03f, -1.90638170e-01f, -6.35964423e-02f, 5.33265471e-01f, -3.70648168e-02f, -1.18559953e-02f, 9.96565819e-02f, 4.54233065e-02f, -2.17132773e-02f, 6.68420515e-04f,
  -1.46106601e-01f, 1.24523779e-02f, 7.09532276e-02f, -1.65104464e-01f, 3.01566310e-02f, -2.87967101e-02f, 1.27381766e-02f, 5.26861474e-02f, -3.11775114e-02f, 3.67630720e-02f,
  3.07178851e-02f, -1.02417454e-01f, -6.73913881e-02f, 6.22335039e-02f, 1.11230791e-01f, -5.54588139e-02f, -1.98377036e-02f, -4.28563863e-01f, 1.41354939e-02f, 1.46458834e-01f,
  1.12366214e-01f, 1.63783121e-03f, -2.11718515e-01f, -7.38273486e-02f, 1.54160693e-01f, 3.77487019e-02f, 3.30825225e-02f, 1.56143516e-01f, -1.36225969e-01f, -1.19977230e-02f,
  -5.20186648e-02f, 2.91787758e-02f, 1.92742243e-01f, 2.39124581e-01f, 8.97486508e-02f, -7.79524166e-03f, -7.92909265e-02f, -8.30315948e-02f, 4.26273614e-01f, 6.10431656e-02f,
  1.97791547e-01f, 4.27585632e-01f, 9.75542068e-02f, 1.87697317e-02f, 1.19781112e-02f, -4.45140265e-02f, 3.58733647e-02f, 9.92572606e-02f, -6.75763190e-02f, -2.48800978e-01f,
  5.89233190e-02f, -3.42682719e-01f, -1.24197692e-01f, -6.82968497e-02f, -1.20342866e-01f, -2.50549614e-01f, 4.43008617e-02f, -3.07563901e-01f, -1.61110610e-02f, -2.15396266e-02f,
  -2.34802868e-02f, -1.56425551e-01f, -3.89442071e-02f, -1.48147926e-01f, -3.30579728e-02f, -8.94893557e-02f, 5.38233854e-02f, -1.67344511e-01f, 1.18321225e-01f, 1.82944760e-01f,
  -6.92978129e-02f, -7.81470351e-03f, -7.68751279e-02f, -5.21823317e-02f, -6.28175959e-02f, 3.79474759e-02f, 2.06261948e-02f, -7.77509287e-02f, 8.78839847e-03f, -1.85610745e-02f,
  -1.12358972e-01f, -3.45562175e-02f, 1.66736558e-01f, 4.36146855e-02f, 4.57090773e-02f, -5.25734499e-02f, 2.26418823e-02f, 6.34623542e-02f, -1.25950828e-01f, -6.43975884e-02f,
  5.59131950e-02f, -1.31727476e-02f, 1.07447609e-01f, -9.77884382e-02f, -1.37999862e-01f, -1.16229348e-01f, -3.47426138e-03f, 1.18223347e-01f, 8.70024860e-02f, -9.09002870e-02f,
  1.72005534e-01f, 2.11798847e-01f, 2.79502779e-01f, -2.97109425e-01f, -1.47655636e-01f, -3.34847644e-02f, 4.74670492e-02f, -1.06347516e-01f, -1.24290742e-01f, -3.04284915e-02f,
  1.11484624e-01f, 3.06301117e-01f, -1.16063572e-01f, 4.06490490e-02f, -1.40419841e-01f, -1.07436500e-01f, -3.62848788e-01f, 1.56901672e-01f, -1.71367496e-01f, -2.84332275e-01f,
  2.67895371e-01f, -3.28210294e-01f, 2.89731100e-02f, 1.29673973e-01f, 3.12998109e-02f, 4.10718657e-02f, -1.25496551e-01f, 2.74549630e-02f, 4.14755642e-02f, -1.66972131e-02f,
  4.70198051e-04f, 1.83685392e-01f, 1.06410459e-02f, -1.34766940e-02f, 8.08420256e-02f, 1.09013714e-01f, 1.05286352e-01f, 5.47133945e-02f, 2.14341246e-02f, 1.60322323e-01f,
  9.60138142e-02f, 1.28972888e-01f, 7.80582987e-03f, 1.48657784e-01f, -1.31523848e-01f, 9.50868353e-02f, -1.58447430e-01f, -9.76074710e-02f, -1.64240673e-01f, 2.08851933e-01f,
  1.84858665e-01f, 9.87430364e-02f, -1.22986048e-01f, -1.51439101e-01f, -3.19513157e-02f, -6.56908602e-02f, -4.82890010e-02f, 6.37604967e-02f, 1.31949648e-01f, 5.99551871e-02f,
  -3.61077674e-02f, 2.77520031e-01f, 2.24994756e-02f, -2.97574729e-01f, 1.64493352e-01f, -3.26503098e-01f, 2.48528183e-01f, -2.31058091e-01f, -1.72155350e-01f, 2.12104008e-01f,
  2.52740569e-02f, -7.75474310e-02f, -2.82844864e-02f, -1.25413507e-01f, -1.26021922e-01f, -1.52568474e-01f, 1.41592696e-01f, -2.99527794e-01f, -1.14600480e-01f, -2.39452422e-01f,
  1.27758473e-01f, -3.93860303e-02f, 1.30012423e-01f, -1.69178545e-01f, 3.04438844e-02f, 1.27466097e-01f, -5.49205467e-02f, -7.34714717e-02f, 5.93420975e-02f, -3.43451239e-02f,
  6.99366629e-02f, -1.60801500e-01f, -3.35033536e-02f, -4.65029199e-03f, -1.23659030e-01f, 3.13572921e-02f, 6.54984713e-02f, -8.32346752e-02f, -9.31574628e-02f, -2.92048380e-02f,
  1.79846007e-02f, 7.91310742e-02f, -3.05152610e-02f, 2.30172306e-01f, 1.70494750e-01f, 8.30308646e-02f, -2.23516449e-01f, -7.04320287e-03f, -6.46944866e-02f, 6.22396283e-02f,
  4.18244116e-02f, -2.90810704e-01f, -2.24951521e-01f, 1.09752983e-01f, 7.62459338e-02f, 1.31232813e-01f, -1.58002377e-02f, 7.79113993e-02f, 1.29449978e-01f, -6.71635708e-03f,
  8.78804103e-02f, -7.29209483e-02f, -6.21795468e-02f, 8.26889127e-02f, -2.21990183e-01f, 1.20839283e-01f, -6.53772801e-02f, -7.37117007e-02f, -2.16406271e-01f, 1.15515143e-01f,
  -1.48213476e-01f, -3.59242797e-01f, -2.53748089e-01f, -3.53717387e-01f, -3.29931110e-01f, 2.60530025e-01f, -1.28093436e-02f, 1.00845061e-01f, 1.68587506e-01f, -4.51266393e-02f,
  2.43325755e-01f, -4.66439165e-02f, -8.15365911e-02f, -2.33887032e-01f, -3.91850509e-02f, 2.51663923e-02f, 2.46652305e-01f, -1.54715732e-01f, -1.63332596e-02f, -2.52050102e-01f,
  3.57275493e-02f, 1.55687612e-02f, -1.12038560e-01f, -1.13315143e-01f, 4.14337069e-02f, 3.20131816e-02f, -7.34207556e-02f, -1.36680603e-01f, 7.69134983e-02f, -4.09468710e-02f,
  5.69573604e-02f, 9.78445187e-02f, 3.29663418e-03f, -2.24796429e-01f, -3.33274789e-02f, 1.32448785e-02f, -4.98377997e-03f, -1.97765976e-02f, -3.03639155e-02f, -3.41090523e-02f,
  -6.91723526e-02f, -8.85795895e-03f, 9.66319963e-02f, 1.75262392e-01f, -5.90957142e-02f, 1.08368665e-01f, -1.97259448e-02f, -3.61066833e-02f, -1.22779727e-01f, -8.47301930e-02f,
  7.98431858e-02f, 8.21495801e-02f, -3.84508632e-02f, -2.00008541e-01f, 4.66844067e-02f, -7.13273808e-02f, -3.93381305e-02f, -1.27406508e-01f, -5.54079078e-02f, -7.62398019e-02f,
  1.17759734e-01f, 7.67432898e-02f, -1.68394223e-01f, 1.20979689e-01f, -3.26448590e-01f, -1.18841216e-01f, 1.44927502e-02f, -3.10937226e-01f, 9.82666984e-02f, -9.34600160e-02f,
  -1.83991328e-01f, -7.96925053e-02f, 3.58285606e-02f, 1.36978582e-01f, -1.43828258e-01f, 2.09868252e-01f, -1.03512995e-01f, 1.38011500e-01f, -8.47591162e-02f, -6.52744249e-02f,
  8.13265070e-02f, 1.64915770e-01f, 4.42364886e-02f, 1.12554757e-02f, -2.03594759e-01f, -1.01437151e-01f, 1.70506556e-02f, 9.24949050e-02f, -3.85319255e-02f, -1.86223872e-02f,
  1.06078550e-01f, 1.56052131e-02f, -9.37501341e-02f, -5.43283634e-02f, 1.14879996e-01f, 5.32586239e-02f, 7.93168619e-02f, 1.00599445e-01f, 5.92791848e-02f, -8.12904257e-03f,
  -6.53509200e-02f, 1.54171512e-02f, 1.24174356e-02f, -2.09765837e-01f, -1.16936125e-01f, -1.17669895e-01f, 3.20771188e-02f, 1.22932166e-01f, 8.41144100e-02f, -2.49410290e-02f,
  1.61905453e-01f, -9.96362045e-02f, -1.16261311e-01f, -8.12045708e-02f, 1.31802037e-02f, 6.55418336e-02f, -3.49002890e-02f, 1.25977889e-01f, 5.28687946e-02f, 1.34315595e-01f,
  -1.80207282e-01f, 2.39860006e-02f, 1.48839295e-01f, -1.00899935e-01f, 6.93944097e-02f, 2.46537387e-01f, 1.01992749e-02f, 7.51033053e-02f, -1.26027390e-01f, 2.05542773e-01f,
  3.32476884e-01f, -1.21311024e-01f, 3.70269082e-02f, -2.33949989e-01f, -2.58197695e-01f, 1.37003124e-01f, 2.02664733e-02f, 1.44404873e-01f, -1.35019511e-01f, 3.68158847e-01f,
  -6.78304583e-02f, 1.80890113e-01f, -3.24427262e-02f, 9.10009742e-02f, 1.51032973e-02f, 1.06723174e-01f, -3.70838307e-02f, -4.67258319e-02f, -6.20664507e-02f, 1.00253761e-01f,
  -4.11404781e-02f, 5.93162924e-02f, -7.61011541e-02f, 3.80489118e-02f, -1.28282398e-01f, -1.52839599e-02f, 6.53581545e-02f, 9.42748040e-02f, -4.18995991e-02f, 4.78661470e-02f,
  -3.11702420e-03f, -1.04165345e-01f, -2.96065304e-02f, -5.18206544e-02f, -4.61340621e-02f, -5.06441817e-02f, -6.65692240e-02f, 9.35478359e-02f, 9.55714956e-02f, 5.19596376e-02f,
  -4.61098552e-02f, 4.48808491e-01f, -6.17104173e-02f, -1.72219291e-01f, -8.09637904e-02f, -6.98484853e-02f, 1.44932956e-01f, 1.78860530e-01f, 6.50469363e-02f, -5.24554960e-02f,
  1.92390569e-02f, 3.86840962e-02f, -5.69325797e-02f, -1.71321779e-02f, 1.12598486e-01f, 6.89725354e-02f, -2.65818626e-01f, -9.42684337e-02f, 1.06521316e-01f, 1.77131504e-01f,
  -1.21139012e-01f, 4.63166572e-02f, -4.51013327e-01f, 1.73132885e-02f, -2.35865653e-01f, -4.79812413e-01f, 3.70619260e-02f, 2.55647600e-02f, -3.46011575e-03f, 1.72533303e-01f,
  -6.63376376e-02f, -4.38788719e-02f, 1.41224369e-01f, 2.45130748e-01f, -9.38182622e-02f, 1.48007080e-01f, 4.37207073e-01f, 5.39083369e-02f, 1.97311714e-01f, -1.30292047e-02f,
  -1.13434702e-01f, 5.08074820e-01f, -1.34761542e-01f, 1.76599443e-01f, -1.10826112e-01f, -2.06154302e-01f, -3.40342000e-02f, 3.11569534e-02f, -8.08359608e-02f, -1.03834048e-01f,
  6.56865686e-02f, -1.11207329e-01f, -1.72728509e-01f, 6.10839874e-02f, -7.80732632e-02f, -1.81918889e-01f, -1.55669913e-01f, 4.91700061e-02f, 7.96498880e-02f, 3.74495201e-02f,
  1.58494525e-02f, -2.97236349e-02f, -3.22089791e-02f, -1.38238966e-02f, -2.62488034e-02f, 5.84274381e-02f, -3.26529890e-02f, 5.89806959e-02f, -5.07183783e-02f, -9.91454273e-02f,
  -2.82545872e-02f, 8.07609633e-02f, 6.72817975e-02f, -2.00719684e-01f, 2.42355973e-01f, -2.00319085e-02f, -7.16578886e-02f, 1.06759161e-01f, 1.99605301e-02f, -6.45935461e-02f,
  5.73965237e-02f, -3.33800495e-01f, -9.71598476e-02f, -8.61929953e-02f, -1.29312977e-01f, 1.04025193e-01f, -1.36763826e-01f, -3.85877788e-01f, -1.88986942e-01f, -3.22186798e-01f,
  -1.44117326e-01f, 3.21659073e-02f, 1.51355462e-02f, 8.91382843e-02f, 1.16757251e-01f, -4.60697077e-02f, 1.67594522e-01f, 1.16203062e-01f, 1.68647349e-01f, -3.73466723e-02f,
  -4.51656915e-02f, 1.83807492e-01f, 1.98921621e-01f, -9.44929048e-02f, 1.04596399e-01f, 3.26724142e-01f
};

// L1_fan_Wp_bar (Shape: 26 x 64)
const int L1_fan_Wp_bar_rows = 26;
const int L1_fan_Wp_bar_cols = 64;
const float L1_fan_Wp_bar_data[] = {
  1.97080821e-01f, 2.23861665e-01f, 2.52915949e-01f, 9.82145816e-02f, -2.93906797e-02f, 8.34979564e-02f, -6.38671732e-03f, 2.15093225e-01f, 5.19066378e-02f, 1.61587894e-01f,
  -1.90288294e-02f, 1.00392893e-01f, 1.72400892e-01f, 2.97568113e-01f, 1.50892779e-01f, -8.13538358e-02f, 7.99748972e-02f, -8.86893868e-02f, 1.05756588e-01f, -3.12368333e-01f,
  3.55371535e-02f, -9.32807773e-02f, 1.77946180e-01f, -2.35753685e-01f, -8.24959204e-02f, 3.11892509e-01f, -6.56945556e-02f, 4.26979437e-02f, -2.32705027e-01f, -7.78700486e-02f,
  1.16448112e-01f, 1.25357747e-01f, -2.14672714e-01f, -1.05774999e-01f, -4.52895127e-02f, 3.10975194e-01f, 1.13714479e-01f, -7.92240128e-02f, 3.22276354e-01f, 1.72441974e-01f,
  -9.91954878e-02f, 7.24247694e-02f, 2.56176323e-01f, -1.70043558e-02f, 2.15460747e-01f, 5.96857429e-01f, 3.57131660e-01f, 2.49947622e-01f, 3.42202544e-01f, -7.76596665e-02f,
  1.13335297e-01f, -5.53648397e-02f, -1.09742925e-01f, 1.09589949e-01f, -3.69846731e-01f, 1.53234243e-01f, -1.92559317e-01f, 7.03511313e-02f, 1.31450668e-01f, -1.85582191e-02f,
  -1.39076322e-01f, 1.89937353e-01f, -1.40563935e-01f, -2.66397430e-04f, 1.55225366e-01f, -6.68516606e-02f, 1.19372949e-01f, 9.79926139e-02f, 1.71344250e-01f, 1.00703858e-01f,
  -6.72997208e-03f, 1.55420229e-01f, 7.08941519e-02f, 2.10111886e-01f, 1.74298868e-01f, -4.66925874e-02f, -8.39541033e-02f, -4.17591520e-02f, 5.39388806e-02f, 4.14129011e-02f,
  1.43797090e-02f, 6.43350184e-02f, 1.69514287e-02f, -1.13881625e-01f, -3.55708927e-01f, -1.21266261e-01f, -4.58593331e-02f, 1.82150289e-01f, 4.06108350e-02f, -1.76929817e-01f,
  7.90127611e-04f, -1.12051211e-01f, -1.16942175e-01f, -1.21198602e-01f, -5.00055775e-02f, -6.42138869e-02f, 6.99982941e-02f, 1.09892800e-01f, -6.66114613e-02f, -8.12036619e-02f,
  -2.97513127e-01f, -1.65676456e-02f, -1.85157314e-01f, 2.13235617e-01f, 1.35887519e-01f, 7.60585144e-02f, 1.35324404e-01f, 2.02043638e-01f, -9.69519913e-02f, -5.47844172e-02f,
  2.04658881e-01f, -1.49861217e-01f, 4.60509844e-02f, 6.01214468e-02f, -1.16605833e-01f, 7.14523867e-02f, -1.35239875e-02f, 9.06745121e-02f, 1.18434250e-01f, -2.97369831e-03f,
  -1.33326799e-01f, 4.38619824e-03f, 2.77514923e-02f, 9.91993770e-02f, 2.11340472e-01f, 2.11054355e-01f, 4.67291335e-03f, -3.53566051e-01f, 1.20007455e-01f, 1.73992872e-01f,
  1.27933249e-01f, 3.52696851e-02f, 2.29407027e-01f, 1.10096179e-01f, 1.82415947e-01f, 1.45839915e-01f, -2.36116275e-02f, 1.03955157e-01f, 1.14360899e-01f, 1.86898857e-01f,
  1.74775213e-01f, 1.89437583e-01f, 1.33876786e-01f, 1.80882290e-01f, 4.85280193e-02f, 3.19586307e-01f, 1.16486929e-01f, -2.12646592e-02f, -3.80886227e-01f, -6.96268007e-02f,
  4.58357632e-02f, 5.63289151e-02f, 8.09697956e-02f, -1.64935946e-01f, 7.20747411e-02f, -4.31981236e-02f, 1.80683255e-01f, 1.59502402e-01f, 1.72867794e-02f, 2.83715501e-02f,
  -5.31201065e-03f, 1.11819908e-01f, -9.42836143e-03f, -1.71293065e-01f, -2.37385795e-01f, 4.92318682e-02f, -2.34126560e-02f, -2.59820789e-01f, 4.01053354e-02f, 7.29742572e-02f,
  1.96210608e-01f, 3.20776820e-01f, 1.57356903e-01f, -3.83940548e-01f, -9.27441567e-02f, 1.92870311e-02f, -4.89505455e-02f, -2.47640505e-01f, 1.34789065e-01f, -1.23038866e-01f,
  1.68999165e-01f, 1.83156416e-01f, 2.62898237e-01f, 1.49504274e-01f, -1.31502271e-01f, -1.46052152e-01f, -2.91430980e-01f, 2.38748506e-01f, 3.68318975e-01f, 1.12944163e-01f,
  2.16888979e-01f, -1.91253275e-01f, 1.28981546e-01f, -5.56568429e-02f, 6.50406675e-03f, -8.54751691e-02f, -1.17230952e-01f, 2.06946552e-01f, 3.51812541e-02f, 5.23635894e-02f,
  -4.58124653e-02f, 1.15556881e-01f, -1.83962956e-01f, -4.15746123e-02f, 4.69379462e-02f, 6.63226694e-02f, -1.61391616e-01f, 1.19611658e-01f, 1.49915159e-01f, 1.57657433e-02f,
  -1.24989264e-02f, -2.28811309e-01f, 1.59817532e-01f, 1.64286852e-01f, 7.05715045e-02f, -3.28321248e-01f, 6.46938831e-02f, 2.18146533e-01f, -1.31094202e-01f, -9.06882957e-02f,
  -9.42155346e-02f, 1.22593313e-01f, 1.18281759e-01f, -8.26045796e-02f, -1.94713101e-01f, -7.75842667e-02f, -2.56453454e-02f, 1.04257174e-01f, -3.91268171e-02f, -2.22332314e-01f,
  2.40777731e-01f, 1.82883814e-03f, -1.81863055e-01f, -2.37816021e-01f, 3.88519794e-01f, -1.30796596e-01f, 5.69461510e-02f, 2.50736713e-01f, 3.25704813e-01f, 1.78936154e-01f,
  4.32463437e-01f, -4.98591736e-02f, 2.37736672e-01f, 5.81323393e-02f, -1.13770002e-02f, 9.65835154e-02f, -1.34689743e-02f, 1.23159558e-01f, -1.44292504e-01f, 2.24728942e-01f,
  -1.48544595e-01f, 1.31371934e-02f, -1.26659898e-02f, 4.38484130e-03f, 1.52840897e-01f, 2.49430314e-01f, 8.39847550e-02f, 6.14952594e-02f, 7.36702904e-02f, 1.31783813e-01f,
  5.56365736e-02f, 6.51538521e-02f, -4.78739813e-02f, 1.09422266e-01f, -8.51238668e-02f, 8.52411985e-02f, -3.42686549e-02f, -3.88237066e-03f, 2.40862757e-01f, -6.36017397e-02f,
  -3.80667783e-02f, 1.64688542e-01f, 1.67122066e-01f, 1.17339075e-01f, 4.84714918e-02f, -2.23674625e-01f, -1.45780936e-01f, -1.58690453e-01f, 2.79461276e-02f, 1.47072062e-01f,
  1.87732443e-01f, -2.39455536e-01f, 1.77143708e-01f, -1.87120840e-01f, 4.88046631e-02f, -8.11571106e-02f, 5.21973781e-02f, 1.73090219e-01f, 7.61756971e-02f, 6.69096364e-03f,
  4.86095902e-03f, -4.33272719e-02f, -3.39892626e-01f, -5.82156852e-02f, 1.31499633e-01f, -3.41676801e-01f, 1.14352182e-02f, 6.91067651e-02f, -3.40986885e-02f, 3.94987553e-01f,
  -1.75345298e-02f, 4.97636832e-02f, 8.62355977e-02f, -2.96500176e-01f, -2.22831041e-01f, -2.16943577e-01f, 5.94991259e-02f, 2.68140018e-01f, 2.52775848e-01f, 6.61606044e-02f,
  1.11847498e-01f, 3.40784639e-01f, -8.19177181e-02f, 2.37632379e-01f, 1.02617763e-01f, 2.15544015e-01f, 3.30204785e-01f, 2.45670363e-01f, 3.08662981e-01f, 2.49127820e-01f,
  1.25133872e-01f, 2.32805982e-02f, 8.53899121e-02f, 4.41828407e-02f, 6.87913746e-02f, 2.43942272e-02f, -1.59244128e-02f, 1.07093610e-01f, 1.25574678e-01f, 3.29829752e-02f,
  -7.36723701e-03f, -1.53883919e-01f, 2.85270400e-02f, 8.31123665e-02f, 1.57909244e-02f, 2.39145439e-02f, 1.38012499e-01f, 1.52430430e-01f, 3.04297078e-02f, -1.48732243e-02f,
  1.65618733e-01f, 5.00361882e-02f, 1.24763064e-01f, 2.51988977e-01f, -1.28893912e-01f, -2.00420693e-02f, -1.50633648e-01f, -7.20247775e-02f, 1.24192990e-01f, 1.75155386e-01f,
  -6.27966002e-02f, -2.48363584e-01f, 5.09412214e-02f, -6.12815260e-04f, -1.03748834e-03f, 5.66871427e-02f, 5.26028015e-02f, 3.07099000e-02f, -2.01352596e-01f, -5.29630557e-02f,
  2.78964043e-01f, 2.10135534e-01f, 2.39669397e-01f, -2.04005301e-01f, -3.83343816e-01f, 2.48925686e-01f, -2.87938658e-02f, -4.71881151e-01f, 2.06256017e-01f, 1.30759984e-01f,
  1.68213964e-01f, 3.48869234e-01f, -2.11271167e-01f, -1.05693623e-01f, 2.64027923e-01f, -3.42128910e-02f, -1.05801977e-01f, 1.34266660e-01f, 3.37679327e-01f, -2.06661701e-01f,
  2.29742870e-01f, 3.41977775e-02f, 4.34147976e-02f, 3.18547070e-01f, -1.12829395e-02f, -2.02031303e-02f, 8.54826421e-02f, -4.09766212e-02f, 1.72302559e-01f, -6.82435483e-02f,
  4.36923169e-02f, 4.91962694e-02f, -5.42412065e-02f, -5.66315055e-02f, 2.14783862e-01f, 4.69160490e-02f, 2.13264331e-01f, 5.52910417e-02f, -2.93132607e-02f, 5.04994877e-02f,
  -3.88967991e-02f, 2.16570258e-01f, 9.54209864e-02f, -2.47663721e-01f, -1.46350160e-01f, -1.36073440e-01f, -5.26220426e-02f, 2.92701125e-01f, 1.61305159e-01f, -4.28929515e-02f,
  -9.28230882e-02f, -1.69549391e-01f, -3.71429138e-02f, 4.80927806e-03f, 1.07469065e-02f, -7.36385807e-02f, 7.28040561e-02f, -3.22985649e-02f, 7.35941692e-04f, -4.44264039e-02f,
  -6.71600178e-02f, 9.86842215e-02f, -2.08333194e-01f, -1.64448768e-01f, 1.85525592e-03f, 3.16258550e-01f, 1.48646578e-01f, 1.29051760e-01f, -2.10283250e-01f, 3.32575738e-01f,
  1.94174528e-01f, -1.44552559e-01f, 1.19342871e-01f, -3.29100013e-01f, -1.31858110e-01f, -1.21667773e-01f, 1.77366406e-01f, 2.19730482e-01f, 2.23971121e-02f, 2.56286591e-01f,
  -4.95582409e-02f, -1.34455003e-02f, 7.03544393e-02f, 2.10485280e-01f, 1.28460094e-01f, 1.57183006e-01f, 1.03307590e-01f, -1.54975563e-01f, 7.30233118e-02f, -2.09633838e-02f,
  -6.96571767e-02f, 1.16001301e-01f, 2.29661748e-01f, -2.86682695e-02f, -2.09855158e-02f, 1.22738164e-02f, 3.77812721e-02f, 3.14346738e-02f, 1.81391656e-01f, 3.42210829e-02f,
  9.70637146e-03f, 4.12049405e-02f, 2.48674661e-01f, 7.87235051e-02f, 9.78920329e-03f, 1.12971209e-01f, 7.21920133e-02f, -6.75905868e-02f, 5.89241758e-02f, -1.02601692e-01f,
  1.18444359e-03f, 1.88230842e-01f, -1.22653000e-01f, 3.33071239e-02f, -7.00371712e-02f, 2.98321303e-02f, -2.27887809e-01f, -4.30251807e-02f, 6.16448782e-02f, -2.62061656e-01f,
  6.26136288e-02f, -2.24668402e-02f, -1.12096757e-01f, 1.37986973e-01f, -3.63289602e-02f, -3.30099314e-02f, -2.46023700e-01f, 2.52020746e-01f, 1.60995647e-02f, 2.77656585e-01f,
  2.11624026e-01f, -5.64676262e-02f, -2.74849832e-01f, 4.96542513e-01f, 1.50469780e-01f, -4.27911490e-01f, 1.13996424e-01f, -1.37547702e-01f, -1.07495770e-01f, -3.66377272e-02f,
  1.63851737e-03f, 2.37890527e-01f, -1.22728884e-01f, 1.86187461e-01f, -5.22271134e-02f, 1.77880019e-01f, 1.96880922e-01f, -1.23973392e-01f, 2.10048735e-01f, 1.96159601e-01f,
  1.43532176e-03f, -8.37323368e-02f, 8.94035958e-03f, 1.07544184e-01f, 2.14337166e-02f, 3.30786668e-02f, -3.95344049e-02f, 1.08212531e-01f, -4.00482118e-02f, 1.09931789e-01f,
  2.64766905e-03f, 4.26158533e-02f, 2.48929430e-02f, -9.98251364e-02f, 5.48440032e-02f, -1.19601563e-01f, -1.38006419e-01f, 8.29366446e-02f, 1.48643246e-02f, -5.39024360e-02f,
  8.40877742e-02f, -1.73063911e-02f, -5.16391210e-02f, -7.78315030e-03f, 4.70837764e-02f, 2.13205084e-01f, -1.02229230e-02f, -7.41440803e-02f, -3.22264503e-03f, -1.61336184e-01f,
  1.21889539e-01f, 1.21042728e-01f, -4.16704221e-03f, -3.00322678e-02f, -1.61128063e-02f, 1.57860219e-01f, -2.88306102e-02f, 2.21891049e-03f, -1.28204271e-01f, 7.31532946e-02f,
  -2.31658399e-01f, 2.04149500e-01f, 2.81667024e-01f, 2.01778024e-01f, -2.52771854e-01f, 1.44768566e-01f, -1.25854924e-01f, -7.57687986e-02f, -2.22332373e-01f, -2.69308686e-01f,
  -4.90093410e-01f, 7.90135711e-02f, -2.41298258e-01f, 4.95238183e-03f, 1.32739052e-01f, -2.32652485e-01f, 2.41083443e-01f, -6.24509938e-02f, 5.18936813e-02f, -1.88176051e-01f,
  7.34684765e-02f, 1.15890428e-01f, 3.43925655e-01f, 2.44596854e-01f, 4.43721823e-02f, -1.65754214e-01f, 1.67983770e-01f, 1.47759676e-01f, -4.45930697e-02f, -7.14379773e-02f,
  7.29682595e-02f, 1.94883179e-02f, -9.28567722e-02f, 8.04000273e-02f, 1.18169360e-01f, 1.66390479e-01f, -3.28316391e-02f, 5.73555082e-02f, -8.25601369e-02f, -1.01796672e-01f,
  -1.91191453e-02f, 1.22979902e-01f, 8.46535712e-02f, 2.63940275e-01f, 7.63466805e-02f, 4.96703461e-02f, -2.58791447e-01f, -2.47502178e-02f, -2.39541158e-02f, 1.03941195e-01f,
  6.21959530e-02f, -3.37346673e-01f, -1.64616689e-01f, -7.03982562e-02f, 1.55434653e-01f, 2.29027659e-01f, -2.58408755e-01f, -2.72370011e-01f, 2.96660177e-02f, -9.58112255e-02f,
  -1.53077260e-01f, -9.57303122e-02f, -5.92019260e-02f, -1.25091106e-01f, -2.62148827e-01f, -1.79264486e-01f, -1.60249263e-01f, 3.60421985e-02f, 3.31458062e-01f, -5.91878183e-02f,
  -1.95658997e-01f, -6.25249073e-02f, -3.27583626e-02f, -3.64290833e-01f, 3.25356603e-01f, -1.71003476e-01f, 2.29384229e-01f, -1.39502510e-01f, -7.57736415e-02f, -2.53685191e-02f,
  2.69510031e-01f, 1.25563055e-01f, -2.13509202e-01f, 1.46088362e-01f, 1.73464760e-01f, 1.98051389e-02f, 3.44841897e-01f, 1.14551127e-01f, 2.67478138e-01f, -3.14922035e-01f,
  5.98103441e-02f, -6.62441831e-03f, 7.88269490e-02f, 6.36124238e-02f, 1.45560369e-01f, 1.20009646e-01f, 6.25370294e-02f, 1.72176450e-01f, -1.10405818e-01f, 5.52536994e-02f,
  -1.38338819e-01f, 1.44622207e-01f, 1.75558656e-01f, 2.76570618e-02f, 3.94237377e-02f, 1.91617459e-01f, 1.36699945e-01f, 1.40442863e-01f, -3.49158794e-02f, -3.39870006e-01f,
  1.65901661e-01f, -2.39028484e-02f, 1.01913199e-01f, -3.91564704e-02f, -1.11523673e-01f, 2.62973189e-01f, -2.05196470e-01f, -1.63904116e-01f, -1.28874853e-01f, 1.04617616e-02f,
  5.16290180e-02f, -9.16925520e-02f, -8.54254365e-02f, -1.49260938e-01f, 3.94583121e-02f, 1.70213759e-01f, -6.93674982e-02f, -1.10855006e-01f, 3.14233124e-01f, 1.26001120e-01f,
  -2.13856548e-01f, 4.56217863e-02f, 2.23278984e-01f, -2.26559862e-01f, -4.06240374e-02f, 4.92373884e-01f, 2.23055586e-01f, 4.22663316e-02f, 3.41571420e-01f, -1.54307440e-01f,
  1.87476978e-01f, 9.88136902e-02f, -1.08902119e-01f, -7.42781116e-03f, -1.85555935e-01f, 5.52236848e-02f, -1.21499568e-01f, 2.65304834e-01f, 8.41613263e-02f, -1.37895316e-01f,
  8.46283659e-02f, 1.45882800e-01f, 8.98475945e-02f, 1.10732295e-01f, 1.57333657e-01f, 6.50289729e-02f, 1.88214257e-02f, 7.62853026e-02f, 1.37926430e-01f, 2.27082714e-01f,
  4.79876734e-02f, 5.99696394e-03f, 7.28034973e-02f, 4.51604612e-02f, -1.49749950e-01f, 1.96967661e-01f, -2.23850086e-03f, 2.69958019e-01f, -9.06073153e-02f, 9.22717825e-02f,
  1.01177342e-01f, 2.02490270e-01f, -3.32465097e-02f, -3.45607661e-02f, -3.41522344e-03f, -1.61942951e-02f, 4.70946394e-02f, 3.18528652e-01f, -1.64375246e-01f, -6.74952986e-03f,
  -1.95101142e-01f, 9.94735360e-02f, 2.46842921e-01f, 3.27903658e-01f, -4.99762669e-02f, -2.54799217e-01f, 3.07040848e-02f, -9.96343791e-03f, -1.19621210e-01f, -1.81761861e-01f,
  4.42144386e-02f, -6.89719394e-02f, -3.61413769e-02f, -2.00766176e-01f, 1.10057674e-01f, 2.24887073e-01f, 3.23712975e-01f, -2.19616815e-01f, -3.53681333e-02f, 9.32805240e-02f,
  -1.23997964e-01f, -5.55248670e-02f, -2.81586319e-01f, 1.20223694e-01f, 1.27482042e-01f, -1.38903737e-01f, -2.36221328e-02f, -4.56369817e-02f, 1.59335792e-01f, -1.27252579e-01f,
  -1.76813230e-02f, -2.82756478e-01f, 3.95483524e-01f, 7.86375585e-06f, 2.16270506e-01f, -9.42821726e-02f, 1.24649636e-01f, 5.19667447e-01f, -1.94146652e-02f, 1.13242015e-01f,
  1.30911410e-01f, 1.47157282e-01f, 2.52754688e-01f, 3.26043427e-01f, 2.20151797e-01f, 1.72745585e-01f, 1.59168020e-02f, -7.53033087e-02f, 2.32361853e-01f, -3.28202695e-02f,
  1.89990923e-01f, 2.55157828e-01f, 6.26990281e-04f, 1.99508026e-01f, 2.01845676e-01f, 1.92012340e-01f, 1.11096196e-01f, 1.28909266e-02f, -2.59772748e-01f, -1.87987044e-01f,
  -1.74530093e-02f, 1.28257900e-01f, -1.54648796e-02f, -6.10577278e-02f, 8.68497491e-02f, -3.01943272e-02f, -1.28220916e-01f, -9.43845585e-02f, 3.82485725e-02f, 9.51022357e-02f,
  9.96476486e-02f, 2.00928584e-01f, -1.69222176e-01f, -3.50383073e-01f, -4.64855395e-02f, 1.65016577e-01f, 1.59647107e-01f, -1.86608303e-02f, -7.07383156e-02f, 4.79977548e-01f,
  -1.54008538e-01f, 2.39080414e-01f, 5.98486587e-02f, 4.53665018e-01f, 2.46228591e-01f, -3.02640237e-02f, -5.07127762e-01f, 1.86925326e-02f, -5.86542040e-02f, -1.06853902e-01f,
  2.77921706e-02f, -1.01960893e-03f, -2.60377326e-03f, -1.54961422e-01f, 1.25443920e-01f, -4.66282219e-01f, 3.24350059e-01f, 2.94362247e-01f, 2.30864778e-01f, 2.71355867e-01f,
  3.92081775e-02f, -3.37461710e-01f, -5.02490997e-03f, 1.35348126e-01f, 2.93391868e-02f, -9.66908783e-02f, 2.80311316e-01f, -2.98838154e-03f, 1.03201479e-01f, 8.53589177e-02f,
  1.29409477e-01f, -7.92769715e-03f, 2.29133256e-02f, 4.19061519e-02f, 7.54275322e-02f, -5.57144284e-02f, 1.88596159e-01f, 6.95783505e-03f, 2.23172680e-02f, 2.14392364e-01f,
  1.10120371e-01f, 1.63523406e-02f, 8.13026577e-02f, -6.71342090e-02f, 1.57507118e-02f, -2.20863253e-01f, 1.00637950e-01f, -2.17312783e-01f, -8.29032063e-03f, -7.00403079e-02f,
  -9.84900165e-03f, -6.08113818e-02f, 1.06155267e-02f, -1.63334250e-01f, 1.98208243e-01f, 1.02635682e-01f, -6.44521788e-02f, 8.13249033e-03f, 9.15132836e-03f, -8.91739409e-03f,
  4.24323753e-02f, 3.49526435e-01f, -3.16471420e-02f, -1.34757370e-01f, 2.74611294e-01f, 2.32324563e-02f, 4.85582083e-01f, -4.81844664e-01f, 2.74011157e-02f, 4.21273559e-02f,
  5.29598832e-01f, 1.73920155e-01f, 6.89755827e-02f, -1.74273267e-01f, 2.08623633e-01f, 3.65440398e-01f, -5.09909913e-02f, 2.38446102e-01f, -6.42865002e-02f, 3.97589743e-01f,
  -4.31184560e-01f, 5.27978875e-02f, 1.33875301e-02f, -4.23933774e-01f, 1.85536414e-01f, -2.71618158e-01f, 8.33441913e-02f, 6.49872869e-02f, 8.44325051e-02f, -9.24588218e-02f,
  1.88330621e-01f, -7.08827674e-02f, 7.91902468e-02f, -8.88214819e-03f, 1.84912920e-01f, 3.84003893e-02f, 8.60405788e-02f, -5.74346520e-02f, 1.00761369e-01f, -1.13281168e-01f,
  8.19961950e-02f, -1.13631956e-01f, -1.55816730e-02f, 7.18217052e-04f, 1.26262978e-01f, -5.76102994e-02f, 3.72148842e-01f, 4.66504283e-02f, -4.32587788e-02f, -6.35323068e-03f,
  -8.22737589e-02f, 6.12766370e-02f, -1.40742287e-01f, 4.51024286e-02f, -6.39930218e-02f, -5.86814582e-02f, 4.25340794e-02f, -1.27601221e-01f, -1.26737177e-01f, -3.61975431e-02f,
  2.85619080e-01f, 1.36559069e-01f, -1.15080312e-01f, -2.79013485e-01f, -1.41885445e-01f, 9.18071568e-02f, -7.07105547e-02f, -1.60508826e-01f, 2.54483193e-01f, -1.50730506e-01f,
  3.09364766e-01f, -4.22942907e-01f, -1.32732078e-01f, -3.48393291e-01f, 5.86945355e-01f, 9.67908874e-02f, -8.10722932e-02f, 1.62570521e-01f, 1.30358264e-01f, 1.46438509e-01f,
  -7.47561455e-02f, 4.93633956e-01f, -1.59083039e-01f, 4.26041782e-01f, -2.87350327e-01f, -2.35597849e-01f, 6.92737773e-02f, -1.42228067e-01f, -8.13802183e-02f, 2.24999309e-01f,
  1.53253088e-02f, -1.38917640e-01f, 2.03256514e-02f, 2.12859824e-01f, 8.98153558e-02f, 1.64971858e-01f, 1.93669051e-01f, 2.37404317e-01f, 1.62593007e-01f, 3.81053016e-02f,
  1.22014731e-01f, -9.48596448e-02f, 2.10628256e-01f, -1.54735781e-02f, 3.69560450e-01f, 1.67308390e-01f, 2.31569290e-01f, 1.95601255e-01f, 9.90642011e-02f, -1.49470627e-01f,
  5.96071966e-02f, -1.44206315e-01f, 5.15881144e-02f, -1.78932503e-01f, -8.49538296e-03f, 7.85164684e-02f, 2.73060352e-01f, -1.11256711e-01f, -2.98591889e-02f, -2.54184455e-01f,
  -1.18740182e-02f, 2.19173893e-01f, -5.25046848e-02f, 2.42889583e-01f, 8.24213475e-02f, -4.02303524e-02f, 5.01807965e-02f, 1.14852011e-01f, 2.25873590e-01f, -6.49632365e-02f,
  2.29037609e-02f, 1.12346336e-01f, 4.37301695e-02f, 2.69543350e-01f, 2.78519131e-02f, 3.70262712e-01f, 3.79939169e-01f, 1.56258270e-01f, 1.07703209e-01f, -1.84722498e-01f,
  -2.94199884e-01f, -1.52137317e-02f, -1.88283436e-02f, 1.48913264e-01f, -2.39944067e-02f, 2.15341762e-01f, -1.35458738e-01f, 3.55528176e-01f, 1.05355896e-01f, -4.69446508e-03f,
  -5.31626120e-02f, 1.48621753e-01f, -1.17838621e-01f, -2.53750681e-04f, 1.07960105e-01f, -7.26742968e-02f, -1.14309169e-01f, 4.82855253e-02f, 9.32475701e-02f, 1.81173421e-02f,
  4.14192043e-02f, 3.95967625e-02f, 3.04646324e-03f, 2.19405219e-01f, 2.38691449e-01f, -8.94140378e-02f, 6.70594722e-02f, -1.04462348e-01f, 2.62674004e-01f, 1.11382559e-01f,
  1.25303090e-01f, 4.45242971e-02f, 3.05371284e-01f, -6.07290789e-02f, -2.06916705e-02f, -4.79583954e-03f, 9.98204425e-02f, 4.80459630e-01f, -1.19765610e-01f, -1.28459007e-01f,
  -1.05592102e-01f, -1.19766884e-01f, -7.23607764e-02f, 2.08865702e-01f, -1.87897906e-01f, -1.18035249e-01f, 1.83148514e-02f, -4.86279950e-02f, -1.19628496e-02f, 9.21823904e-02f,
  -1.45362347e-01f, 9.00742710e-02f, -3.38576049e-01f, 1.10629842e-01f, 1.19572550e-01f, 3.75943482e-01f, 2.32711017e-01f, -6.72570756e-03f, -4.97540683e-01f, 3.01549077e-01f,
  -1.19417489e-01f, -3.42307240e-01f, 4.03817624e-01f, -1.54678419e-01f, -5.04730828e-02f, 7.08881244e-02f, 1.25566512e-01f, 1.28871247e-01f, -5.46387732e-02f, 6.73163161e-02f,
  -2.74376839e-01f, 2.26286680e-01f, 3.38658214e-01f, 6.46064505e-02f, 2.30844647e-01f, -7.62899220e-02f, -5.86676225e-02f, 1.52522281e-01f, 4.96768132e-02f, 9.66261178e-02f,
  2.44206246e-02f, 5.70536368e-02f, -3.81789207e-02f, 1.05228379e-01f, 7.99598452e-03f, -2.40616240e-02f, 4.22482789e-02f, 5.12530580e-02f, -1.84197351e-02f, 7.78407380e-02f,
  -4.51683626e-02f, 1.16204731e-01f, 1.84017997e-02f, 1.53748423e-03f, -6.81890994e-02f, -1.01046532e-01f, -5.49558923e-02f, 1.72184378e-01f, -4.05700468e-02f, 2.25402579e-01f,
  4.82904464e-02f, 6.63401783e-02f, -1.69993583e-02f, -2.42834449e-01f, -1.04601145e-01f, -1.64402789e-03f, 3.65256935e-01f, 2.34518312e-02f, -5.69956750e-02f, 1.64602593e-01f,
  1.13768883e-01f, -1.24616802e-01f, 5.52324541e-02f, 3.64592746e-02f, 1.53216481e-01f, 6.05848171e-02f, 1.19908422e-01f, -1.28160730e-01f, 4.00732368e-01f, 1.32034317e-01f,
  -3.31318915e-01f, 9.62942466e-02f, 7.41392141e-05f, -3.27663422e-01f, -3.31263602e-01f, 8.78495649e-02f, -2.27536276e-01f, 3.11644912e-01f, -2.62056857e-01f, -1.40661905e-02f,
  1.20665625e-01f, -1.22128077e-01f, 4.07410413e-01f, -1.20865792e-01f, 7.58213252e-02f, -1.90334141e-01f, 6.39193282e-02f, 2.83091992e-01f, 3.14289093e-01f, 1.05213681e-02f,
  7.55926371e-02f, 1.50019631e-01f, -4.66692969e-02f, 1.23131879e-01f, -2.61196587e-03f, 1.08277142e-01f, 8.02429765e-02f, 8.87990817e-02f, -1.17347809e-02f, 1.32537872e-01f,
  8.07293653e-02f, -2.73618987e-03f, 5.86275645e-02f, -2.92973761e-02f, 1.12179473e-01f, -7.60166496e-02f, -8.14525038e-02f, -1.79033633e-02f, -5.02393767e-02f, 4.11942638e-02f,
  -3.07058636e-02f, -1.37840956e-01f, 2.24875480e-01f, -2.26222143e-01f, -1.28729731e-01f, -2.76076972e-01f, -2.51652915e-02f, 1.63669914e-01f, 1.77201614e-01f, -1.81368589e-01f,
  -1.66306585e-01f, -1.22100890e-01f, 1.76188245e-01f, -1.87136814e-01f, 6.24726824e-02f, 1.47636756e-01f, -7.59567076e-04f, -5.41871190e-02f, -2.20012888e-01f, -2.33448803e-01f,
  2.65908659e-01f, -3.64956439e-01f, -1.23665415e-01f, -1.22069590e-01f, 2.24363759e-01f, -4.46272604e-02f, 2.22905651e-01f, -1.68010905e-01f, 2.93978840e-01f, 4.29932475e-02f,
  1.21438354e-01f, -1.42604038e-01f, 7.80246407e-02f, 7.17393756e-02f, 2.13271290e-01f, 1.88074499e-01f, -2.81871170e-01f, 3.28134656e-01f, -2.77998336e-02f, 4.31031227e-01f,
  -2.04654992e-01f, -8.78699124e-02f, 8.58390927e-02f, -4.58022440e-03f, 1.85594708e-01f, 2.07335129e-01f, -2.19323542e-02f, -2.04139785e-03f, -1.30075276e-01f, -4.39344347e-02f,
  3.50830588e-03f, 1.86001688e-01f, 7.58500174e-02f, 7.09672123e-02f, -1.09901400e-02f, 7.61394156e-03f, -1.57775208e-01f, 2.24979445e-01f, 1.08730197e-01f, -2.42832750e-02f,
  -1.35553822e-01f, 1.19586423e-01f, 3.67552936e-01f, 7.92671368e-02f, -1.54446354e-02f, -2.38549516e-01f, -7.52286091e-02f, -3.32521051e-01f, -2.70468891e-02f, 1.91454217e-01f,
  -1.76675782e-01f, 7.51887262e-03f, -6.33456260e-02f, 1.26757354e-01f, -8.04822706e-03f, -3.91374007e-02f, 2.66995788e-01f, -7.79840276e-02f, -1.39975250e-01f, -2.44930893e-01f,
  1.66392654e-01f, 1.11280069e-01f, -1.59488171e-01f, -1.85190067e-01f, 3.04600865e-01f, -3.82413298e-01f, 1.22754380e-01f, -1.11569129e-01f, -1.76157311e-01f, 2.18213256e-02f,
  -2.12209731e-01f, -5.59812114e-02f, 2.68510669e-01f, -4.56774533e-02f, 4.62172693e-03f, 1.53850138e-01f, 2.03616366e-01f, 9.36174169e-02f, -9.33390111e-02f, 2.37682927e-02f,
  1.14639655e-01f, 3.00237596e-01f, -1.48786604e-02f, -2.06978675e-02f, -1.78486004e-01f, -1.65862978e-01f, -3.11592877e-01f, 2.66925454e-01f, -4.44333375e-01f, 5.56996226e-01f,
  6.07999489e-02f, -6.27803504e-02f, -8.82675424e-02f, -1.70273826e-01f, 4.66003306e-02f, 3.01538836e-02f, -7.30698705e-02f, 1.43006817e-01f, -1.60768647e-02f, -1.69153959e-01f,
  4.11994383e-03f, -3.18027399e-02f, 1.32061467e-01f, 6.94659874e-02f, 7.36901686e-02f, 4.27912548e-02f, 8.95567387e-02f, 2.42321007e-03f, 1.24035394e-02f, -2.68589795e-01f,
  -1.47057334e-02f, -7.28620887e-02f, -7.47097656e-02f, 7.82204121e-02f, 1.44650847e-01f, 3.81043670e-03f, -3.80434878e-02f, 7.26941749e-02f, -1.77891687e-01f, 8.39613751e-02f,
  1.63106974e-02f, -1.93030432e-01f, 4.04631011e-02f, -7.08200783e-02f, 1.41791413e-02f, 6.68778494e-02f, -1.84693351e-01f, -8.67785141e-02f, -8.65171626e-02f, 1.14074871e-01f,
  -1.94968715e-01f, 1.04557775e-01f, 2.80721605e-01f, 8.93137679e-02f, -2.10244387e-01f, 5.94006479e-02f, -5.16250469e-02f, -6.99135661e-02f, -2.70716131e-01f, 5.54799149e-03f,
  8.61146376e-02f, -6.72077164e-02f, 1.09542049e-01f, 3.20393622e-01f, -1.20248839e-01f, 1.16504461e-01f, 1.47430852e-01f, -9.21095088e-02f, -1.55372843e-01f, 2.45188043e-01f,
  1.60809308e-01f, -4.91858162e-02f, 3.23281735e-01f, -1.67082712e-01f, 6.11531958e-02f, 3.41008678e-02f, 6.49522915e-02f, 5.74134775e-02f, -9.96589735e-02f, 6.08394332e-02f,
  6.58231676e-02f, 2.04308219e-02f, -5.66942245e-02f, 8.69195256e-03f, -1.62914574e-01f, -1.62560061e-01f, -2.79772584e-03f, -1.01549193e-01f, 5.01040220e-02f, -3.65576707e-02f,
  -1.04741357e-01f, -4.24954183e-02f, 4.27963324e-02f, -2.08944574e-01f, -2.13625724e-03f, -1.26762360e-01f, -5.62113263e-02f, -1.16172329e-01f, -1.64701119e-01f, -3.29407002e-03f,
  -6.66737929e-02f, 1.93327025e-01f, -1.14017986e-01f, -8.63051787e-02f, 4.02283296e-03f, -1.00864843e-01f, -1.32973790e-01f, -1.49118006e-01f, 1.07884943e-01f, 1.00889690e-01f,
  -1.93025067e-01f, -6.72678202e-02f, 1.05043732e-01f, -6.29663765e-02f, 1.79473281e-01f, -2.06621364e-01f, -1.44172639e-01f, 1.29981533e-01f, 8.97980556e-02f, -2.13943478e-02f,
  -1.75501760e-02f, -4.01860088e-01f, 1.00737281e-01f, 1.56465262e-01f, 9.17892829e-02f, 4.96143550e-01f, 5.30992076e-02f, -1.72537360e-02f, 1.89308107e-01f, 4.22488421e-01f,
  -3.46503705e-02f, 2.14024857e-01f, -2.99488276e-01f, -4.70652550e-01f, -1.57429799e-01f, 9.89492238e-02f, -5.09309351e-01f, 1.92597911e-01f, -2.19535418e-02f, -4.65022326e-02f,
  1.05518572e-01f, 7.70507902e-02f, 2.05006033e-01f, 1.24105982e-01f, 7.90226161e-02f, 2.51227200e-01f, -6.32431433e-02f, 5.29927127e-02f, -5.92184719e-04f, 1.58935532e-01f,
  7.13015497e-02f, 6.37847409e-02f, -1.35419313e-02f, 9.53696966e-02f, 2.30399653e-01f, 2.15366222e-02f, 7.91047662e-02f, -1.79785550e-01f, -2.24983040e-02f, -1.23549640e-01f,
  1.22949462e-02f, -1.35198226e-02f, 7.99380988e-02f, 1.68451741e-01f, 2.27463171e-01f, 7.97488540e-02f, -1.83061317e-01f, -1.35476828e-01f, 3.77043672e-02f, 1.51928470e-01f,
  -1.13207109e-01f, 4.85214144e-02f, -6.58364668e-02f, -3.04212477e-02f, -2.87244190e-02f, 1.38417808e-02f, 3.04711193e-01f, -3.06736171e-01f, -2.55796779e-02f, 1.18751256e-02f,
  -2.66119875e-02f, 1.49170905e-01f, 1.29397204e-02f, 1.35322526e-01f, 3.70428950e-01f, 8.74569789e-02f, 2.92129647e-02f, -5.16822100e-01f, -1.37972027e-01f, -3.15672196e-02f,
  2.17590317e-01f, 2.58921921e-01f, -3.40755850e-01f, 2.23068595e-01f, 3.20484824e-02f, 2.78753549e-01f, 6.78639710e-02f, 1.74507916e-01f, -5.66326939e-02f, 2.96456337e-01f,
  7.10209683e-02f, 1.15033895e-01f, -2.41280161e-02f, 1.69949278e-01f, 4.57120761e-02f, -7.61162117e-02f, -2.04900041e-01f, 9.05965567e-02f, 5.93473054e-02f, -1.33095577e-01f,
  -5.86143434e-02f, -1.26161659e-02f, -1.54399186e-01f, 2.51989901e-01f, 1.73073679e-01f, 2.58104026e-01f, -5.27016120e-03f, 1.47922471e-01f, 6.92201033e-03f, -6.08782023e-02f,
  3.51299420e-02f, 1.32226674e-02f, 4.26199198e-01f, 1.83282018e-01f, 9.26314294e-02f, 2.52295062e-02f, -1.73304472e-02f, 1.70505330e-01f, -2.98001528e-01f, 9.75686163e-02f,
  3.14455107e-02f, -1.50194364e-02f, 9.63870808e-02f, 1.59945097e-02f, -1.05269939e-01f, -1.73522949e-01f, 1.40098944e-01f, 4.08316612e-01f, 3.13173592e-01f, 2.41923839e-01f,
  1.56683460e-01f, 1.04542784e-01f, 1.98181435e-01f, 3.73653099e-02f, 7.44269881e-03f, -3.16687554e-01f, 4.37045209e-02f, 6.85735717e-02f, -9.65937227e-02f, 1.44720212e-01f,
  2.11113662e-01f, 1.49291024e-01f, 3.91749628e-02f, -1.63016859e-02f, -3.48378301e-01f, -3.30145091e-01f, -1.22936191e-02f, -1.39863282e-01f, -7.99841955e-02f, 1.05248936e-01f,
  4.82138246e-02f, 1.14390273e-02f, -4.59658414e-01f, -6.86260611e-02f, -2.70948231e-01f, 3.86568010e-01f, 2.77785193e-02f, 2.18949899e-01f, -3.15267174e-03f, 1.48409996e-02f,
  4.83848900e-02f, 2.07391426e-01f, 2.29759440e-02f, 7.85872862e-02f, 5.24592958e-03f, 2.90834755e-01f, 1.28019582e-02f, 4.20033038e-02f, 7.90362358e-02f, 2.45843247e-01f,
  1.19356466e-02f, 1.22673713e-01f, -8.93141180e-02f, 5.90724722e-02f, 8.71392936e-02f, 7.84577429e-02f, 1.96390375e-01f, 2.75650080e-02f, 1.71084050e-02f, -1.31235182e-01f,
  -1.61082298e-01f, 4.28834185e-02f, -5.99636063e-02f, 1.98600650e-01f, 1.45328835e-01f, 1.02393758e-02f, 3.70151959e-02f, 2.51890630e-01f, -1.58581436e-01f, -5.96392266e-02f,
  1.02763683e-01f, 4.52533774e-02f, 3.35404038e-01f, 6.78386167e-02f, 3.01855743e-01f, 2.14353621e-01f, 2.62329996e-01f, -1.58110067e-01f, -6.19799346e-02f, 6.84575588e-02f,
  3.68726879e-01f, 3.45817327e-01f, 1.30556956e-01f, 4.82226014e-01f, -1.73930854e-01f, 3.17048207e-02f, -1.89309821e-01f, 8.56566057e-03f, 4.11379337e-02f, -1.74798325e-01f,
  1.24937512e-01f, -3.53880256e-01f, -3.77564952e-02f, -2.85809003e-02f, 2.64196843e-01f, 1.84591845e-01f, -1.23260066e-01f, 8.85142460e-02f, 6.29536211e-02f, 3.36403819e-03f,
  1.54394969e-01f, 2.22230792e-01f, 1.48706615e-01f, 2.09356263e-01f, 1.26865759e-01f, 1.37012107e-02f, 3.17021132e-01f, 1.98589981e-01f, 4.67520021e-02f, 2.73495018e-01f,
  1.30593970e-01f, 1.27141759e-01f, 1.06037669e-01f, 1.28647476e-01f, 1.71056420e-01f, 1.44326955e-01f, 1.25159159e-01f, 6.30868524e-02f, 1.99313811e-03f, 3.46429169e-01f,
  -1.18922263e-01f, 6.91025052e-03f, 1.26933102e-02f, 2.17205286e-01f, -1.77496076e-01f, -1.26768380e-01f, -3.34328525e-02f, 1.12627275e-01f, 1.72538161e-01f, 2.24917457e-01f,
  -2.67291754e-01f, -1.68091461e-01f, 1.46151394e-01f, -7.14891553e-02f, -6.95252120e-02f, -5.57723977e-02f, 2.75318295e-01f, -3.85196060e-02f, -1.14999540e-01f, -2.91825354e-01f,
  1.31050944e-01f, -1.00570962e-01f, 4.09134656e-01f, -1.14169143e-01f, 1.37404084e-01f, -7.68644065e-02f, -5.37931696e-02f, 9.81425047e-02f, 2.34595701e-01f, 2.80614069e-04f,
  1.82903185e-01f, -1.81831837e-01f, -4.95008267e-02f, -5.95827848e-02f, 7.90366977e-02f, -1.23539880e-01f, -1.90750003e-01f, -5.87699525e-02f, 2.58095175e-01f, -1.15124166e-01f,
  1.77882656e-01f, -3.19408834e-01f, 1.03754230e-01f, 5.46027899e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 26)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 26;
const float L1_fan_Bp_bar_data[] = {
  1.09932467e-01f, 2.10934356e-01f, 2.70834208e-01f, 1.99405998e-01f, 6.21782802e-02f, 2.31572896e-01f, 1.04576819e-01f, 4.48605344e-02f, 6.22964371e-03f, 2.05063950e-02f,
  1.30951121e-01f, 2.60145590e-02f, -7.40657700e-03f, 2.20646277e-01f, 2.25103796e-02f, 2.04565115e-02f, 1.57149747e-01f, 1.50764704e-01f, 1.21100679e-01f, 2.49445766e-01f,
  -3.12458314e-02f, 1.15330897e-01f, 5.69231845e-02f, 5.15922531e-02f, 2.63503790e-01f, 2.26095840e-01f
};

// L2_fan_Wp (Shape: 19 x 64)
const int L2_fan_Wp_rows = 19;
const int L2_fan_Wp_cols = 64;
const float L2_fan_Wp_data[] = {
  -3.70079130e-02f, 2.04955995e-01f, -1.68527681e-02f, -1.05155259e-01f, 3.05045582e-02f, 3.35148014e-02f, -1.47647247e-01f, 1.13415398e-01f, -1.39051713e-02f, 2.45603368e-01f,
  -3.26250069e-04f, -2.81629413e-02f, -8.78581926e-02f, 3.20213027e-02f, 1.69482172e-01f, -6.67960048e-02f, -1.08697385e-01f, -1.03853963e-01f, 1.33532152e-01f, -3.01879402e-02f,
  -1.89348370e-01f, 2.76735753e-01f, -1.52925849e-02f, 1.98197052e-01f, 3.74672599e-02f, 1.11566000e-01f, -1.12041989e-02f, 3.43699217e-01f, 1.06697075e-01f, 1.16699822e-01f,
  7.23793432e-02f, -1.34950355e-01f, -1.43457979e-01f, -3.43963206e-01f, -9.04460996e-02f, 8.11770093e-03f, -3.74736667e-01f, -8.70959759e-02f, 1.87798023e-01f, -1.58960417e-01f,
  -2.19512761e-01f, 9.00095701e-02f, -1.08706594e-01f, -2.00608656e-01f, -1.38075888e-01f, 1.18446365e-01f, 6.13020547e-02f, 2.24162769e-02f, 2.70528309e-02f, 2.58732885e-02f,
  1.04427226e-01f, -1.60530493e-01f, -1.97878733e-01f, -9.05091092e-02f, -5.92950471e-02f, -1.08922407e-01f, -2.60634005e-01f, -8.91100019e-02f, 8.19933508e-03f, -5.75287379e-02f,
  5.56782298e-02f, -1.04880100e-02f, 1.14220694e-01f, -1.04441650e-01f, -1.76438868e-01f, -2.33844668e-01f, -1.80415332e-01f, -1.69105634e-01f, -1.04930669e-01f, -2.53490001e-01f,
  -1.36676282e-01f, -1.04488619e-01f, -9.55413803e-02f, 2.03735065e-02f, 1.26113929e-02f, -9.57141146e-02f, -1.64953828e-01f, -1.36438832e-01f, -8.49478915e-02f, 2.63871737e-02f,
  4.33279993e-03f, -1.88070253e-01f, -9.01710540e-02f, -9.79228597e-03f, 1.25814527e-01f, -2.84503460e-01f, 1.08824082e-01f, 4.15292047e-02f, -6.10848330e-03f, 3.47690210e-02f,
  -1.05385393e-01f, -2.88672924e-01f, -2.01872423e-01f, -2.03570127e-02f, -4.86905843e-01f, 2.11517051e-01f, 1.78065747e-02f, 4.04953025e-02f, 2.78164726e-02f, 2.61243373e-01f,
  1.64559036e-01f, 1.14409113e-02f, -1.52962983e-01f, -1.42362565e-01f, 1.01026520e-02f, -1.28595173e-01f, 6.25511929e-02f, -9.00225490e-02f, -1.63256526e-02f, -5.15547208e-02f,
  1.28132075e-01f, -1.98354393e-01f, -1.68239743e-01f, 3.74004655e-02f, 2.15146821e-02f, -5.41778794e-03f, 2.87638098e-01f, 5.19306436e-02f, 4.92541939e-02f, 3.35994482e-01f,
  1.61660671e-01f, -1.36575460e-01f, 9.32234973e-02f, 1.78695410e-01f, 9.12304521e-02f, 2.36186609e-01f, -7.68243968e-02f, 2.35804114e-02f, 1.28178954e-01f, -1.10064000e-01f,
  -1.22754656e-01f, -1.19621955e-01f, -3.79375927e-02f, 9.48996246e-02f, 6.85482696e-02f, -1.04987651e-01f, -1.75333798e-01f, 1.37115598e-01f, 5.76344086e-03f, 2.56420285e-01f,
  -1.97468877e-01f, -1.93273425e-01f, 1.03740636e-02f, 1.39298767e-01f, -1.28198087e-01f, 1.37343287e-01f, 6.02875799e-02f, -2.44716346e-01f, -2.96891369e-02f, -1.08942643e-01f,
  -1.60962835e-01f, 1.63092569e-01f, 8.07893872e-02f, 4.66610640e-02f, -3.05189304e-02f, -3.26434046e-01f, 1.50996029e-01f, 3.28396887e-01f, -5.66919930e-02f, 2.73999223e-03f,
  -3.53568904e-02f, -2.34000131e-01f, 1.35294748e-02f, -3.54280733e-02f, 6.79001957e-02f, 2.74591237e-01f, 8.69437233e-02f, -1.96770318e-02f, -4.17850055e-02f, 1.02568321e-01f,
  5.43290898e-02f, 1.27459869e-01f, 4.48636040e-02f, -3.46794240e-02f, -1.59788147e-01f, 4.27057892e-02f, 4.02830243e-02f, -9.53803770e-03f, -2.00426385e-01f, -4.31220755e-02f,
  5.98304532e-02f, -6.73267152e-03f, 6.54463889e-03f, -1.07504658e-01f, 1.31033227e-01f, -8.42096806e-02f, -1.96835607e-01f, -4.99417558e-02f, -1.53350895e-02f, 5.05684055e-02f,
  -1.86580122e-01f, 8.43225047e-02f, -8.16712081e-02f, 9.15462896e-02f, -2.41286963e-01f, 5.75706037e-03f, -3.55384569e-03f, -1.47845969e-01f, 4.81622405e-02f, -6.05655275e-02f,
  8.62704888e-02f, -2.35188082e-02f, -1.68046683e-01f, -9.02297050e-02f, 1.66858420e-01f, 5.38542084e-02f, -1.84941683e-02f, 1.71455890e-01f, 5.71693666e-02f, -1.66484401e-01f,
  -1.30900079e-02f, 1.25969768e-01f, 3.96442860e-01f, 2.72368103e-01f, -3.16597451e-03f, -8.80295411e-02f, 2.51099071e-03f, 1.74491525e-01f, 2.98495829e-01f, 3.16395909e-01f,
  -6.45306930e-02f, -8.61487910e-02f, -2.68375248e-01f, -8.02960321e-02f, -9.66303498e-02f, 9.99175757e-03f, -1.01753592e-01f, 1.02268718e-01f, 1.52689174e-01f, -1.76123485e-01f,
  -8.57909843e-02f, 2.10197553e-01f, 3.11575867e-02f, 1.39183598e-02f, -1.51197076e-01f, 1.66770145e-01f, 1.30595446e-01f, 3.09434850e-02f, 1.30878165e-01f, 1.55840650e-01f,
  5.78173809e-02f, 1.92522436e-01f, 1.84061438e-01f, -1.21978067e-01f, 2.77718287e-02f, -7.68849850e-02f, 5.08164354e-02f, 6.37730118e-03f, -4.02763300e-02f, 6.25630841e-02f,
  6.68142140e-02f, -1.05924860e-01f, -5.94888674e-03f, -1.56224608e-01f, 9.56395362e-03f, -2.29198802e-02f, -1.72126323e-01f, -1.88000485e-01f, 1.60731729e-02f, -2.31737792e-01f,
  -3.76484841e-02f, -1.25331834e-01f, -1.32774979e-01f, -2.11004570e-01f, -7.51319304e-02f, 6.97537959e-02f, -2.20958248e-01f, -9.28856879e-02f, -5.64259179e-02f, 3.75078581e-02f,
  -3.20480168e-01f, -2.01726317e-01f, -6.94309771e-02f, -1.94683269e-01f, -1.12191871e-01f, 9.16675329e-02f, -3.80447358e-02f, -1.79464057e-01f, -1.66425053e-02f, 4.17490304e-02f,
  3.38805863e-03f, -1.20770626e-01f, -4.95637693e-02f, -3.91784191e-01f, 1.13425128e-01f, -7.56259263e-02f, -2.25222230e-01f, 2.74322659e-01f, -5.43564223e-02f, 3.49468321e-01f,
  2.40193605e-01f, -7.53768757e-02f, 2.80182157e-02f, 1.42482772e-01f, -1.17268600e-01f, 1.15278296e-01f, 1.13925867e-01f, 8.91240239e-02f, 6.84402362e-02f, -1.30358949e-01f,
  3.35957818e-02f, 2.75059156e-02f, 5.99931069e-02f, 5.87229729e-02f, -5.54606551e-03f, -2.74205282e-02f, -3.98137607e-02f, 9.04642791e-02f, 3.40492040e-01f, -9.69653353e-02f,
  9.13228467e-02f, 1.12407692e-01f, 4.68351804e-02f, 7.91541487e-02f, 1.56460971e-01f, 6.17691204e-02f, -1.29707187e-01f, -9.72242467e-03f, -5.29458262e-02f, -1.16860315e-01f,
  -1.96899801e-01f, -1.59813970e-01f, 6.75663427e-02f, 7.26060793e-02f, 1.53113365e-01f, 1.22988097e-01f, 2.59172469e-02f, -3.84714641e-02f, -6.01187833e-02f, -2.23068103e-01f,
  9.75921378e-02f, -1.59599874e-02f, 1.92271203e-01f, 1.40977100e-01f, -2.43178502e-01f, 6.08652085e-03f, 1.93981230e-01f, 3.25201862e-02f, -1.43103849e-03f, 1.68004811e-01f,
  -7.14448988e-02f, 7.76882097e-02f, -1.64061144e-01f, -1.31086439e-01f, -1.32408559e-01f, 8.25914219e-02f, 6.99591963e-03f, -2.04696447e-01f, -3.22169811e-02f, 2.74427496e-02f,
  2.98406929e-01f, -3.03703755e-01f, 7.98059106e-02f, -5.74884750e-02f, -4.35163975e-01f, -9.18279961e-02f, -2.07852855e-01f, -3.62399891e-02f, -5.58093041e-02f, 1.70712605e-01f,
  1.02453306e-01f, -6.84715947e-03f, -6.82920441e-02f, -1.39455259e-01f, -1.00257955e-01f, -3.86950523e-02f, 1.50807336e-01f, 2.45132446e-01f, -1.56429224e-02f, -1.91447660e-01f,
  -2.03276295e-02f, 1.62480950e-01f, 8.86003971e-02f, -2.65884362e-02f, -1.77835092e-01f, 1.97783604e-01f, -1.22918360e-01f, 4.92879190e-02f, -9.45171937e-02f, -4.32146154e-02f,
  -8.93684551e-02f, -8.23935047e-02f, 1.29362613e-01f, -5.24415635e-02f, -2.90948357e-02f, -6.06362941e-03f, -2.26740744e-02f, -1.00136355e-01f, 7.37365261e-02f, -1.37975235e-02f,
  5.80076361e-03f, -2.71421876e-02f, -1.68977782e-01f, 1.46987721e-01f, -2.56541908e-01f, -2.05031931e-01f, 1.75525919e-01f, 1.69811007e-02f, -9.79452431e-02f, 2.70918101e-01f,
  1.19090686e-02f, 1.16706803e-01f, 1.28972083e-01f, -1.65348174e-03f, -1.18431740e-01f, -1.36792898e-01f, -2.64373779e-01f, 1.38831109e-01f, -7.56179839e-02f, 1.63928837e-01f,
  -9.45306793e-02f, -5.24463803e-02f, -1.31211713e-01f, 2.09795877e-01f, -2.73528039e-01f, -8.67298096e-02f, 8.08611512e-02f, -1.00243278e-01f, 5.31956702e-02f, -7.38098919e-02f,
  2.94908613e-01f, 6.82670847e-02f, -3.79413478e-02f, 1.15439527e-01f, -1.02792121e-01f, 3.24839130e-02f, -9.25180390e-02f, 2.40823209e-01f, 9.25281420e-02f, 1.38616666e-01f,
  9.73742530e-02f, 1.36145368e-01f, 5.77406362e-02f, 2.35304260e-03f, -8.64535868e-02f, -1.06089711e-01f, 2.88278222e-01f, -5.68567170e-03f, 1.03208505e-01f, -1.61346331e-01f,
  -1.11863673e-01f, -1.68641359e-01f, -3.94435711e-02f, 2.24919736e-01f, -2.04395637e-01f, 1.64511502e-01f, -2.98444815e-02f, 9.50795636e-02f, -1.00285560e-01f, -5.66111133e-02f,
  6.78113997e-02f, 1.85565069e-01f, -1.29281327e-01f, 5.57881705e-02f, 1.87569916e-01f, 3.58059257e-02f, -7.65229985e-02f, -9.01399553e-02f, 7.42992982e-02f, 6.15151338e-02f,
  -5.41103743e-02f, 6.80410936e-02f, -1.93986639e-01f, -2.80201524e-01f, 5.39232343e-02f, -2.04399735e-01f, 3.09010092e-02f, 2.71378249e-01f, 3.63900065e-01f, 2.53474385e-01f,
  -2.26272881e-01f, -2.68851757e-01f, -1.26164123e-01f, 7.74804652e-02f, 5.48694991e-02f, -1.60588413e-01f, -8.05188641e-02f, -9.94021371e-02f, -2.00847521e-01f, -6.52889013e-02f,
  2.50344485e-01f, 1.03142977e-01f, 1.08631037e-01f, -4.83678989e-02f, 3.00386906e-01f, 8.87422189e-02f, -1.13124736e-01f, 1.45361736e-01f, 1.47840336e-01f, -2.14795947e-01f,
  1.06371351e-01f, -6.02071779e-03f, 6.54424056e-02f, -1.71285927e-01f, 1.43210664e-01f, 1.88451573e-01f, 7.10584084e-03f, 1.19429745e-01f, -4.37001251e-02f, -2.17433530e-03f,
  -3.92385647e-02f, -6.72764704e-02f, -2.39256285e-02f, 1.42884776e-01f, -1.36056736e-01f, 1.02581419e-01f, -1.78116947e-01f, -3.94774601e-02f, -1.05876654e-01f, -5.60389943e-02f,
  9.63697303e-03f, 2.07793236e-01f, -2.28086975e-03f, 1.48865683e-02f, -8.16395953e-02f, 5.94167858e-02f, 1.29839227e-01f, -6.20718747e-02f, -4.12732102e-02f, 1.43841401e-01f,
  -1.94390006e-02f, -1.42226860e-01f, -6.39451891e-02f, 1.41374057e-03f, 5.28903268e-02f, 1.76900730e-01f, 1.64264545e-01f, -2.13153750e-01f, -9.72467959e-02f, -1.80274531e-01f,
  8.19908082e-03f, 1.81373760e-01f, -1.90925673e-01f, 3.12721431e-01f, -1.59971088e-01f, 2.28512716e-02f, 1.78945493e-02f, 2.79739320e-01f, 9.43454355e-02f, 3.99833471e-01f,
  -6.89886287e-02f, -1.41898692e-01f, 1.79533705e-01f, -1.38850212e-01f, -1.25978068e-01f, 7.27538019e-02f, -1.98052987e-01f, -1.52011991e-01f, -1.58676818e-01f, 8.07165802e-02f,
  6.67106407e-03f, 7.99927637e-02f, 5.93413832e-03f, 5.39815724e-02f, -7.10948482e-02f, -3.16300727e-02f, -2.18627661e-01f, 5.46541950e-03f, 2.22120248e-02f, -4.78320532e-02f,
  -1.20454989e-02f, 8.13600421e-02f, 1.46404460e-01f, -2.54699081e-01f, -1.68889657e-01f, 3.46380956e-02f, -1.35574430e-01f, -7.70661309e-02f, -1.56315923e-01f, 1.77833825e-01f,
  3.22004827e-03f, -1.17708951e-01f, -5.26822768e-02f, 2.49387264e-01f, 9.36287940e-02f, -1.16231233e-01f, 1.84665695e-01f, 1.47035643e-01f, 8.57494175e-02f, -8.23278874e-02f,
  2.09888607e-01f, 1.06726326e-01f, 2.06502631e-01f, 1.75930217e-01f, 7.26379156e-02f, -3.28152128e-05f, 1.02262251e-01f, 3.40695083e-02f, 6.72356486e-02f, -2.24835128e-01f,
  1.02107443e-01f, 4.86239567e-02f, 2.36526597e-02f, -7.82587845e-03f, 1.14298850e-01f, -1.14771396e-01f, -3.77713352e-01f, 5.71788996e-02f, -3.29649687e-01f, 1.24714687e-01f,
  5.22948056e-02f, -6.91703195e-03f, 3.17233168e-02f, 1.02124348e-01f, -1.00748442e-01f, 1.91827193e-02f, 1.83377296e-01f, -1.30630225e-01f, -2.24220529e-01f, -7.23229498e-02f,
  -1.60603732e-01f, 9.33091796e-04f, -7.90741444e-02f, 1.61661491e-01f, 3.39524716e-01f, 2.77182609e-02f, -1.35148570e-01f, 1.15030371e-01f, -7.38214403e-02f, 7.85268843e-02f,
  -1.36436552e-01f, -7.29471073e-02f, -1.22408003e-01f, 3.31138931e-02f, 2.47040421e-01f, 5.18059209e-02f, -3.52010541e-02f, -2.30371922e-01f, -2.49182150e-01f, -5.99139966e-02f,
  -1.78175457e-02f, -2.63516366e-01f, -1.27477527e-01f, 1.06654696e-01f, -7.56169483e-02f, -1.98247552e-01f, -8.80174711e-03f, 1.70281380e-01f, -4.01606597e-02f, 5.89187443e-02f,
  3.34786600e-03f, -2.13266000e-01f, 6.09642044e-02f, -1.79609567e-01f, 2.65977997e-02f, -2.91830786e-02f, 6.34053722e-02f, 5.15978597e-02f, -6.43400699e-02f, -2.01441169e-01f,
  -1.90876443e-02f, -8.16444457e-02f, 2.95279413e-01f, 3.46480280e-01f, -2.64717132e-01f, -2.78325621e-02f, 1.50455877e-01f, -1.02212518e-01f, -1.51041046e-01f, 2.99137831e-01f,
  4.24989685e-02f, -1.75713107e-01f, 1.45821020e-01f, 2.49714982e-02f, 1.31169632e-01f, 1.03953131e-01f, -1.40621841e-01f, -3.35868061e-01f, 1.15792543e-01f, -9.07430127e-02f,
  2.23684192e-01f, -1.14811137e-01f, 1.21901438e-01f, 6.73800707e-02f, -6.51430264e-02f, -1.52725847e-02f, -1.05053239e-01f, -1.63450107e-01f, -4.28440236e-03f, 2.17410121e-02f,
  2.43058026e-01f, 1.00680657e-01f, 9.89029557e-02f, 3.49151692e-03f, -5.80266081e-02f, -8.02868381e-02f, 1.00933962e-01f, 1.75122559e-01f, 1.09438725e-01f, -8.27887729e-02f,
  1.67983010e-01f, 1.64990366e-01f, 7.86901414e-02f, -1.39476312e-02f, -2.31087446e-01f, 1.24792948e-01f, 9.91355032e-02f, -1.01538613e-01f, -1.65643528e-01f, 2.28921890e-01f,
  -6.41185790e-02f, -1.96529180e-01f, -1.10537000e-02f, -1.71079710e-01f, -4.73795161e-02f, 2.77435873e-02f, -7.18985051e-02f, 5.98320328e-02f, -3.18525136e-02f, -7.20658107e-03f,
  2.50541400e-02f, -1.41549125e-01f, -1.25774607e-01f, -2.94054002e-01f, -2.07267538e-01f, -8.51254985e-02f, 1.12402685e-01f, -2.59610582e-02f, -2.08888635e-01f, 3.54264863e-02f,
  3.75627466e-02f, 1.33711249e-02f, 6.80471494e-05f, -8.10888708e-02f, 3.32656056e-01f, -1.83814347e-01f, 3.91717821e-01f, 1.39426574e-01f, 1.66995272e-01f, -8.82209912e-02f,
  2.80764997e-02f, -2.58763760e-01f, 1.54554918e-01f, -6.12355694e-02f, -7.15461448e-02f, 8.28518346e-02f, -1.35734290e-01f, -1.53074458e-01f, 1.27019256e-01f, 1.67050511e-02f,
  5.64095080e-02f, 7.39740953e-02f, 3.62077355e-02f, 3.91057059e-02f, 1.20637573e-01f, 1.03979617e-01f, 1.65992856e-01f, 1.35588869e-01f, 4.26428095e-02f, -6.79295287e-02f,
  -1.12874314e-01f, 4.25759479e-02f, -3.22935618e-02f, -2.12092668e-01f, -1.38311043e-01f, 1.14336535e-01f, 2.18973547e-01f, 2.89647467e-02f, -1.53893739e-01f, -2.57180519e-02f,
  -8.01808573e-03f, 2.25623384e-01f, -1.93279982e-01f, 1.39709800e-01f, 1.40039384e-01f, -1.57153308e-01f, -2.15000600e-01f, -7.67072290e-02f, -1.19103000e-01f, 4.88576107e-02f,
  -5.62798120e-02f, 8.15098807e-02f, 1.81007162e-01f, -7.75747523e-02f, -3.75151902e-01f, -6.25017136e-02f, 6.81694523e-02f, 1.19265638e-01f, -8.39369670e-02f, -9.14061815e-02f,
  1.12330963e-04f, 1.17138095e-01f, -3.04723736e-02f, 2.18467236e-01f, 2.95981318e-02f, -1.51470795e-01f, -4.58967574e-02f, 3.17210741e-02f, 4.19848375e-02f, 2.46286571e-01f,
  2.98425332e-02f, 7.11205825e-02f, -4.83815074e-02f, -8.05182084e-02f, 8.04427117e-02f, 3.96251440e-01f, -6.35522977e-02f, -5.78192100e-02f, -1.62460029e-01f, 1.05952613e-01f,
  2.00279459e-01f, 6.11810088e-02f, 2.34052047e-01f, 1.44818500e-01f, 2.34715983e-01f, 1.54104605e-01f, -9.77237746e-02f, -1.01113409e-01f, -9.03478116e-02f, -3.39828320e-02f,
  -4.92065772e-02f, 6.47424161e-02f, 1.76411554e-01f, 1.12884328e-01f, 1.39919937e-01f, 9.97173321e-03f, 2.79051382e-02f, 1.58785228e-02f, 1.17185116e-01f, -1.90925300e-01f,
  -1.19082473e-01f, -1.93920173e-02f, 1.33123666e-01f, 1.18510269e-01f, -9.22868252e-02f, 8.65890980e-02f, 1.92651853e-01f, -2.37830624e-01f, 4.59601507e-02f, 1.04981169e-01f,
  -1.75404549e-01f, -1.69749590e-04f, 5.34194000e-02f, -9.51945856e-02f, -2.37536564e-01f, -6.45248815e-02f, -3.22336443e-02f, 1.35152072e-01f, 1.17891096e-01f, 2.80594863e-02f,
  -1.32124454e-01f, -1.21926740e-01f, -3.86920385e-02f, -6.21655546e-02f, 2.64334790e-02f, 1.39407977e-01f, 2.02353716e-01f, -8.00564736e-02f, 7.78596252e-02f, -2.19786167e-02f,
  -1.58215225e-01f, -1.52147993e-01f, 9.13651288e-02f, -2.02023700e-01f, -1.02399923e-01f, -1.70840085e-01f, 1.84727740e-02f, 2.19950125e-01f, -2.40670666e-01f, -4.38798845e-01f,
  5.23392297e-02f, 3.26627642e-01f, -1.31584452e-02f, 8.57504830e-02f, 1.35301352e-01f, -1.22524366e-01f, -1.72251135e-01f, 5.18695638e-02f, 1.01078756e-01f, -7.23521709e-02f,
  3.23625319e-02f, -2.05826014e-02f, -2.82127205e-02f, -5.27628511e-02f, -3.28098536e-02f, 1.60501733e-01f, 1.14311285e-01f, 5.77686615e-02f, -2.11625367e-01f, 1.75352255e-03f,
  -7.76890367e-02f, 2.46935025e-01f, 5.70057854e-02f, -2.35780682e-02f, 9.87613872e-02f, 8.84922743e-02f, 1.45431668e-01f, -1.64877608e-01f, 2.48408288e-01f, -1.16392508e-01f,
  -1.05627678e-01f, 7.74250478e-02f, -1.06194265e-01f, -1.25824437e-01f, -3.20946164e-02f, 2.42295310e-01f, 1.32062688e-01f, 6.48319870e-02f, 2.13932954e-02f, 1.04023255e-01f,
  3.82694937e-02f, 1.69358462e-01f, -9.02648792e-02f, 2.01658100e-01f, 5.55710532e-02f, 5.93901724e-02f, 1.88849926e-01f, 1.05790183e-01f, -2.80682087e-01f, 3.65596898e-02f,
  -1.46138310e-01f, -7.49452710e-02f, -2.61232480e-02f, -1.79840364e-02f, 7.39137828e-03f, -1.13438517e-01f, -6.25069961e-02f, 2.65067577e-01f, -2.49124646e-01f, -1.45030275e-01f,
  -2.56014973e-01f, 1.11057274e-01f, 5.17799519e-02f, 8.35215300e-02f, 1.59757704e-01f, 4.63442951e-02f, 1.86519757e-01f, -8.81273821e-02f, -2.74577066e-02f, -2.39485964e-01f,
  -1.73103303e-01f, 1.07361143e-02f, -1.65006667e-01f, 2.98263952e-02f, 2.14479059e-01f, -7.36997873e-02f, -1.35385439e-01f, -1.64480843e-02f, -7.36553892e-02f, -4.59966920e-02f,
  -1.21874161e-01f, -1.22070864e-01f, 7.25976452e-02f, -4.23749983e-02f, 7.47255012e-02f, 2.09344447e-01f, 3.07191033e-02f, -1.58138096e-01f, -1.58865556e-01f, 4.10292763e-03f,
  -7.25563467e-02f, 1.70221869e-02f, -1.07232966e-01f, -6.32714033e-02f, -2.36218423e-02f, -1.36283845e-01f, -1.99205782e-02f, 1.31206036e-01f, 2.05946907e-01f, 1.31102413e-01f,
  -7.85360299e-03f, -2.07858473e-01f, -9.72040817e-02f, -8.90164971e-02f, 2.25598544e-01f, -1.74767286e-01f, 7.39103928e-02f, 7.48642534e-02f, -2.40437135e-01f, -1.29648283e-01f,
  9.84510109e-02f, 5.26899360e-02f, 6.01237714e-02f, 2.31425315e-01f, -6.99378550e-02f, -7.25470856e-02f, 2.92376578e-01f, 7.97512755e-02f, -6.46002665e-02f, 3.04874063e-01f,
  -5.18997125e-02f, 1.58847809e-01f, -1.79748371e-01f, -2.76921362e-01f, -1.19306177e-01f, 1.04737841e-02f, -2.22707480e-01f, -6.95622526e-03f, -1.82907939e-01f, -9.93979424e-02f,
  3.05432528e-01f, -2.12720633e-01f, 1.85283244e-01f, 2.52592769e-02f, -3.87289435e-01f, -1.46261021e-01f, -1.64134935e-01f, -9.89514124e-03f, 5.68319559e-02f, 2.90132519e-02f,
  -1.16722882e-01f, -5.80745079e-02f, -4.21624951e-04f, -1.20110966e-01f, -7.22721145e-02f, -6.04277551e-02f, 1.36566848e-01f, -1.54496178e-01f, -3.70894819e-02f, -6.67343847e-03f,
  5.50653748e-02f, 8.19735676e-02f, 1.69959486e-01f, -3.07592787e-02f, -1.09109595e-01f, 1.41792178e-01f, -1.33023247e-01f, 2.72118356e-02f, -9.85415801e-02f, -1.13267586e-01f,
  -1.10441856e-01f, 2.08144352e-01f, 1.57482997e-01f, -5.14317565e-02f, -3.42316702e-02f, -1.86690465e-01f, 8.31409767e-02f, 1.35456875e-01f, 9.60846152e-03f, -7.94104561e-02f,
  2.00198516e-01f, -4.68514152e-02f, 3.36020410e-01f, 2.29690447e-01f, -4.05979939e-02f, -7.06171319e-02f, 3.17888558e-01f, 1.46764657e-02f, -4.61424179e-02f, -1.42353401e-01f,
  -1.91578567e-01f, 1.75659090e-01f, -3.03519908e-02f, 1.78953022e-01f, -3.26388068e-02f, -7.91312829e-02f, -2.20837176e-01f, 1.60904914e-01f, 7.27560967e-02f, -7.25967586e-02f,
  7.78340846e-02f, 1.70027822e-01f, -1.31238475e-01f, 4.29897644e-02f, -1.15926482e-01f, -1.52340569e-02f, 9.25138295e-02f, 3.43525618e-01f, 3.44095051e-01f, -9.60468575e-02f,
  -1.80502295e-01f, -2.69313753e-01f, 5.41050592e-03f, 4.07381058e-02f, 5.95623069e-02f, -1.10126592e-01f, -3.54921035e-02f, 1.80316269e-01f, -1.06133454e-01f, -5.73828891e-02f,
  1.81392655e-01f, 8.68126750e-04f, 5.63271716e-02f, -7.50035271e-02f, 3.05930153e-03f, -4.17841896e-02f, 1.45275861e-01f, -5.18896878e-02f, 1.16280138e-01f, -2.31766030e-01f,
  -5.37218153e-02f, 6.55384734e-02f, 1.08280435e-01f, 2.21591428e-01f, -5.13455570e-02f, -2.13620663e-01f, -1.30992502e-01f, -3.78187634e-02f, -6.93533495e-02f, 2.39649490e-01f,
  -7.21816048e-02f, -9.64374747e-03f, 1.07435666e-01f, 1.14327893e-01f, -3.06376349e-03f, 9.00145769e-02f, -6.47016242e-02f, -2.68128753e-01f, 1.68110907e-01f, -5.02021573e-02f,
  1.79545954e-02f, 5.12608141e-02f, 1.30757745e-02f, -4.58124764e-02f, 2.71817832e-03f, -3.45628187e-02f, -2.00225145e-01f, -1.42321944e-01f, 2.97638237e-01f, -1.89938694e-02f,
  8.29945654e-02f, -2.09899828e-01f, -1.16667084e-01f, -9.36103463e-02f, 5.98066710e-02f, -1.44168541e-01f, 2.05446765e-01f, 5.41951172e-02f, 1.77873056e-02f, 1.53250605e-01f,
  7.48897567e-02f, -4.65415828e-02f, 4.18272614e-02f, 7.47374445e-02f, -5.53158037e-02f, -2.64852196e-02f, -6.09130003e-02f, -7.02418685e-02f, 1.60057202e-01f, -1.58389062e-01f,
  1.71603516e-01f, -1.27249971e-01f, 2.26291671e-01f, 5.13770096e-02f, -1.65899415e-02f, 1.24840796e-01f, -1.05263041e-02f, 2.10281789e-01f, -3.88808474e-02f, 8.89608413e-02f,
  -2.71152645e-01f, 9.83884558e-02f, 1.94613397e-01f, -7.32683986e-02f, 1.65384486e-02f, 3.78094311e-03f, 7.23353699e-02f, -2.46663406e-01f, 7.92865381e-02f, -2.19229922e-01f,
  3.55469435e-02f, 1.99318051e-01f, -1.73046384e-02f, -6.33482337e-02f, 5.84382825e-02f, 6.78751711e-03f, -2.95174848e-02f, 8.16770867e-02f, -1.25744883e-02f, -2.40021143e-02f,
  2.70197004e-01f, 1.34002669e-02f, 1.22925974e-01f, -2.75447756e-01f, 3.48625779e-01f, 1.86919138e-01f, -4.80845682e-02f, -2.01903909e-01f, 2.57292148e-02f, 4.82158475e-02f,
  -1.13032654e-01f, 2.43695065e-01f, -1.38419613e-01f, 1.01529676e-02f, -2.14009330e-01f, -9.05767083e-02f, -1.31356835e-01f, 1.35234833e-01f, 1.88094229e-02f, -4.64240573e-02f,
  -1.61220938e-01f, 1.57285914e-01f, 9.84776691e-02f, -1.04454800e-01f, 3.59664708e-01f, 1.51417926e-01f, -1.11981630e-01f, -2.17602402e-01f, 1.12850115e-01f, -1.49640456e-01f,
  9.88278259e-03f, -8.86208564e-02f, 4.17978503e-02f, -1.87451854e-01f, -1.73668899e-02f, 4.07308377e-02f, 2.86414698e-02f, -2.83822021e-03f, 1.58552542e-01f, 1.06052198e-01f,
  -1.68233767e-01f, 4.23073247e-02f, -3.57040167e-02f, -1.17411509e-01f, -7.52899870e-02f, -1.44479144e-02f, 1.05099529e-01f, 3.03234816e-01f, -1.48618460e-01f, -5.70910377e-03f,
  7.92429131e-03f, 7.48671517e-02f, -1.54808372e-01f, 9.90428552e-02f, 1.26349747e-01f, 1.83093414e-01f
};

// L2_fan_Wp_bar (Shape: 26 x 64)
const int L2_fan_Wp_bar_rows = 26;
const int L2_fan_Wp_bar_cols = 64;
const float L2_fan_Wp_bar_data[] = {
  7.18452409e-02f, 2.43443966e-01f, -2.51296550e-01f, 2.28327606e-02f, -9.51060504e-02f, -1.54645443e-01f, 4.28852320e-01f, 3.04965496e-01f, -1.58580393e-02f, -3.36616665e-01f,
  -5.01517355e-02f, 2.40568832e-01f, -4.46159095e-01f, -1.62876278e-01f, -1.22392207e-01f, -1.28161848e-01f, 3.25130858e-02f, -1.75598025e-01f, 3.18616986e-01f, -4.16866802e-02f,
  5.95000573e-02f, 3.56713593e-01f, 2.89965849e-02f, -8.34319741e-02f, -1.38646230e-01f, 1.80682182e-01f, 3.90818834e-01f, -2.86711324e-02f, 2.38355383e-01f, -2.60462195e-01f,
  -2.42495194e-01f, -3.96401495e-01f, -2.20709682e-01f, -1.70927402e-03f, -2.22716153e-01f, -5.30979484e-02f, 3.77842158e-01f, 1.41522840e-01f, -1.32145584e-01f, -4.82629500e-02f,
  -2.67550396e-03f, 8.67530033e-02f, 1.25402406e-01f, 3.93562675e-01f, -1.54565856e-01f, -1.60384491e-01f, -1.87234178e-01f, 7.48749152e-02f, -5.09894602e-02f, 2.88958788e-01f,
  8.32853019e-02f, -1.37692049e-01f, 9.01329070e-02f, -8.71265084e-02f, 1.75130554e-02f, 1.14131257e-01f, 1.37104794e-01f, 4.65646267e-01f, -2.03198165e-01f, 1.44739598e-01f,
  6.71888217e-02f, -3.09781637e-03f, 2.07042489e-02f, 3.21603745e-01f, 1.54587686e-01f, 2.02463806e-01f, -1.04722552e-01f, 9.57986861e-02f, 2.45045140e-01f, 6.97841346e-02f,
  3.39010544e-02f, 1.57599553e-01f, 1.72361322e-02f, 4.65446301e-02f, 1.04753286e-01f, -4.21612784e-02f, 3.61046158e-02f, 4.47118767e-02f, 3.66709530e-01f, 1.43524185e-01f,
  4.39164415e-02f, 2.23443508e-01f, 1.29374862e-01f, -3.52650195e-01f, -3.40792239e-01f, 1.77094296e-01f, -3.70126426e-01f, 1.13477655e-01f, 7.86050484e-02f, 5.59311323e-02f,
  1.44797653e-01f, -2.72406056e-03f, -1.80276155e-01f, 1.80360213e-01f, 7.25272596e-02f, -2.78572619e-01f, -2.48691142e-01f, -5.73423088e-01f, -4.26399969e-02f, 1.96281582e-01f,
  1.89166903e-01f, -8.23374838e-02f, 4.91796136e-01f, -1.65724549e-02f, -2.04369411e-01f, 2.87976265e-01f, 8.68811309e-02f, 8.41536671e-02f, 4.19845209e-02f, 2.87484139e-01f,
  -3.27263355e-01f, 1.56777218e-01f, 4.22759116e-01f, 5.41493222e-02f, -2.58920137e-02f, -4.19156924e-02f, 1.52491897e-01f, 1.56921279e-02f, 1.99246988e-01f, -3.94409388e-01f,
  2.37457737e-01f, 3.05660330e-02f, -7.70503134e-02f, -5.36289550e-02f, 6.23260364e-02f, 1.85880631e-01f, -8.16175565e-02f, 1.22184716e-01f, -1.30457450e-02f, -1.04123868e-01f,
  -2.18576998e-01f, -2.67619416e-02f, 4.66412567e-02f, 2.27331370e-01f, 2.12160900e-01f, -1.08611532e-01f, -2.14277908e-01f, -4.04367521e-02f, -2.24923700e-01f, -1.59242768e-02f,
  -6.25592694e-02f, 8.30366090e-02f, 1.42013282e-01f, -7.29945302e-02f, 1.73813611e-01f, 2.29958922e-01f, 1.45489991e-01f, -4.28150624e-01f, -3.36321652e-01f, -1.36869639e-01f,
  -5.38188219e-01f, -1.28774755e-02f, -1.26241902e-02f, -2.05175262e-02f, 6.24965876e-02f, -3.72200727e-01f, -1.49525955e-01f, 1.94275707e-01f, -8.00345093e-02f, -1.67963162e-01f,
  1.47108361e-01f, -3.21876779e-02f, -1.56288445e-01f, 2.45686322e-02f, 3.09739172e-01f, 2.93943705e-03f, 1.70017675e-01f, 3.39983702e-02f, -1.20705605e-01f, 4.17605639e-01f,
  -3.76733504e-02f, 4.14031237e-01f, 8.68937075e-02f, 2.14989543e-01f, -1.44687340e-01f, 2.87705034e-01f, 3.23549449e-01f, 2.33728796e-01f, -3.03066969e-01f, 1.65511429e-01f,
  4.45115417e-01f, 1.22305095e-01f, 2.76821733e-01f, -5.00043295e-02f, 1.72604561e-01f, 3.25763285e-01f, -7.16880187e-02f, 1.61631554e-01f, -4.39772941e-02f, 2.59424388e-01f,
  -2.32242979e-02f, 3.54862899e-01f, 3.60931873e-01f, 9.85944271e-02f, 2.28760883e-01f, 9.79718640e-02f, 1.08301207e-01f, 4.29549426e-01f, 1.15256727e-01f, 1.69214770e-01f,
  2.30739146e-01f, 1.57629505e-01f, 3.11101228e-01f, -5.94810508e-02f, 2.08806381e-01f, 3.70407522e-01f, 4.02847201e-01f, 7.18668252e-02f, 6.84829503e-02f, 2.55054355e-01f,
  -1.09105237e-01f, -3.33492234e-02f, 1.06912561e-01f, -7.65266716e-02f, -2.65129983e-01f, -1.37142286e-01f, -9.37986001e-02f, 2.39623323e-01f, -1.33809671e-01f, -2.93639779e-01f,
  -2.14355290e-01f, 2.31902331e-01f, 4.70915139e-01f, -2.51879040e-02f, 1.97366342e-01f, -3.83036137e-01f, -3.37039709e-01f, 3.85563001e-02f, -3.57299030e-01f, -5.08425295e-01f,
  4.20554906e-01f, 2.00888216e-01f, 1.26154602e-01f, 1.93019539e-01f, -1.93253994e-01f, -1.56605676e-01f, -5.19193783e-02f, 2.11665943e-01f, -7.15052113e-02f, -6.60346821e-02f,
  2.27876514e-01f, -1.50407612e-01f, 7.79695436e-02f, 3.20432782e-01f, 3.87159213e-02f, 3.33434939e-01f, 9.13005844e-02f, -2.25935578e-01f, -1.06694326e-02f, -4.20322597e-01f,
  -7.29222894e-02f, -3.31492960e-01f, 1.20725967e-01f, -5.84742166e-02f, 2.95222461e-01f, 1.81882277e-01f, -1.14215069e-01f, -1.50646672e-01f, -3.84804644e-02f, 1.82068936e-04f,
  -1.85272083e-01f, 2.23567098e-01f, -8.40467289e-02f, -1.23459287e-01f, 1.85567021e-01f, 1.85326830e-01f, 1.41778931e-01f, 1.26527160e-01f, 3.17780972e-02f, 5.69347106e-02f,
  1.09345980e-01f, -5.08197322e-02f, -1.53513238e-01f, 1.73251405e-02f, -5.56072295e-02f, 4.96296957e-02f, 2.49035195e-01f, 2.09176764e-02f, 4.21862483e-01f, -3.29920530e-01f,
  -1.00686885e-01f, 2.88784858e-02f, -3.55318278e-01f, -4.21810269e-01f, 1.74859241e-01f, -1.08068556e-01f, 1.06067751e-02f, 2.49809742e-01f, -2.08126947e-01f, 2.51699705e-02f,
  3.19611937e-01f, 3.63490522e-01f, -2.09404439e-01f, -2.49289840e-01f, 4.43663336e-02f, -1.19677919e-03f, 1.74527466e-01f, -7.95265436e-02f, 2.41992995e-01f, -3.90754312e-01f,
  1.42417476e-02f, -1.06054671e-01f, -2.80789249e-02f, -5.44363670e-02f, -2.52159119e-01f, -2.25273967e-01f, 1.81610420e-01f, 4.10776675e-01f, -8.50736126e-02f, 3.58157158e-01f,
  5.82391471e-02f, 1.33838519e-01f, 1.80881262e-01f, -2.41740987e-01f, 7.44009092e-02f, -3.32092196e-01f, 3.91291142e-01f, -3.70295160e-02f, 1.31580427e-01f, 1.34496644e-01f,
  -1.91919580e-02f, -4.24133837e-02f, 4.37765867e-01f, 1.91498041e-01f, 2.75401980e-01f, 1.75797105e-01f, -3.74999374e-01f, 2.67055869e-01f, 1.54922426e-01f, 2.35243917e-01f,
  2.26665422e-01f, -2.37815782e-01f, -5.48473969e-02f, 2.04880890e-02f, -2.44954333e-01f, 2.07320571e-01f, -6.22354187e-02f, 5.75809777e-02f, 3.57489705e-01f, 2.69311517e-01f,
  -1.01023227e-01f, 2.92866737e-01f, 1.62641644e-01f, -5.03911152e-02f, -1.64693624e-01f, -3.43400866e-01f, -6.99595213e-02f, 5.84373176e-01f, -1.25095114e-01f, -1.02081209e-01f,
  2.66141891e-01f, -1.84050247e-01f, -2.54499704e-01f, -7.52321035e-02f, -1.02947846e-01f, 8.96582454e-02f, 7.14198276e-02f, 8.68512243e-02f, 1.99549675e-01f, 7.10222945e-02f,
  -9.24403593e-02f, 1.84585918e-02f, 1.54386044e-01f, 2.00664654e-01f, 1.26185209e-01f, 4.73609567e-02f, 2.73981661e-01f, -1.09557860e-01f, 1.39685273e-01f, 1.54759958e-01f,
  2.49262050e-01f, -3.00370574e-01f, -2.56427974e-01f, -2.48325784e-02f, -1.33029833e-01f, 2.31568724e-01f, -1.71578556e-01f, 4.30672690e-02f, 1.94456920e-01f, 2.41477072e-01f,
  1.42744884e-01f, 2.35072300e-01f, 2.27014422e-01f, -1.77581444e-01f, -2.30344990e-03f, -3.05910587e-01f, 2.93156475e-01f, 1.04067437e-01f, 9.51129347e-02f, -8.41351226e-02f,
  -1.04273837e-02f, -4.24679928e-03f, 8.13280866e-02f, 1.65961906e-01f, 1.77773863e-01f, -2.43416689e-02f, 1.84469834e-01f, 1.10800140e-01f, -3.11748870e-02f, 8.94673467e-02f,
  2.70155936e-01f, 1.61182106e-01f, 2.58873582e-01f, 7.40431175e-02f, 1.51611686e-01f, -1.54840648e-01f, 4.51538190e-02f, -1.79441631e-01f, -2.96498060e-01f, 4.12507467e-02f,
  -1.85996726e-01f, 3.17594469e-01f, -3.16847116e-01f, -2.39455611e-01f, -6.70596883e-02f, 1.06123097e-01f, 2.73485720e-01f, 2.48727843e-01f, -1.38096973e-01f, 2.70944744e-01f,
  1.39297336e-01f, -9.36293229e-02f, -3.06883449e-04f, 1.33768171e-01f, 2.41766423e-01f, -1.01340748e-01f, 2.67177401e-03f, 7.11987615e-02f, 2.49217033e-01f, 3.72335941e-01f,
  3.15622628e-01f, 3.05977941e-01f, 7.31413439e-02f, 1.29827634e-01f, 4.27833974e-01f, 6.86322302e-02f, -7.94795603e-02f, -1.42926857e-01f, 2.04823896e-01f, 1.60985500e-01f,
  -2.27734163e-01f, -1.75111547e-01f, 1.01098284e-01f, 1.35620475e-01f, -1.57228738e-01f, -6.76695332e-02f, 1.81331947e-01f, 5.75208925e-02f, -2.18423977e-02f, 8.92428160e-02f,
  1.79474398e-01f, 1.91357568e-01f, 1.93025172e-01f, -7.67219812e-02f, -7.28162527e-02f, 1.52902424e-01f, 1.49645194e-01f, -1.69248223e-01f, 1.86057180e-01f, 1.07441209e-01f,
  3.15904468e-02f, -2.16957107e-02f, -8.05598274e-02f, 9.83102247e-02f, -1.07759023e-02f, 6.49842098e-02f, 6.36931583e-02f, 1.38008237e-01f, -3.43568981e-01f, 4.00535375e-01f,
  2.72287905e-01f, -1.16495900e-01f, -7.63275176e-02f, -6.34378642e-02f, 2.44461179e-01f, 3.69968414e-01f, -2.82887984e-02f, -2.48680606e-01f, 1.82404682e-01f, -5.11447072e-01f,
  -3.41966480e-01f, -1.10083083e-02f, -1.08531706e-01f, -1.76547036e-01f, 1.62007347e-01f, 1.71480030e-01f, 6.47621527e-02f, -4.08723317e-02f, -1.57476477e-02f, 3.62729728e-02f,
  2.83836454e-01f, 1.63750634e-01f, -7.09202886e-02f, 2.71523045e-03f, 1.66917682e-01f, 1.35830820e-01f, 8.67581666e-02f, 7.68147409e-02f, 1.75851166e-01f, -4.52641636e-01f,
  -2.56802768e-01f, 1.86796173e-01f, -2.71362383e-02f, 2.21513525e-01f, -1.22938689e-03f, 4.54107672e-01f, 8.06131680e-03f, 8.50248858e-02f, 1.26492739e-01f, 2.21079320e-01f,
  2.26880625e-01f, 7.79025406e-02f, -8.74142200e-02f, -1.35542035e-01f, -2.29275282e-02f, 2.37350434e-01f, 1.56810619e-02f, -2.41640329e-01f, 3.69521640e-02f, -4.73504104e-02f,
  4.10490949e-03f, 2.14896947e-01f, 2.13005513e-01f, -3.10067330e-02f, 2.28471577e-01f, 1.87970735e-02f, 2.29154583e-02f, -1.40956551e-01f, -1.31039128e-01f, -2.67859753e-02f,
  -9.45781618e-02f, 1.49213135e-01f, -4.45030704e-02f, -1.01090875e-02f, 1.14086799e-01f, -7.42688328e-02f, 6.71176836e-02f, -1.45486280e-01f, 5.40166162e-03f, 1.12394281e-01f,
  -1.71469241e-01f, 1.90802626e-02f, -1.60021394e-01f, 8.13698545e-02f, 3.46929356e-02f, 1.21091112e-01f, 2.38620818e-01f, 3.52320783e-02f, 2.91155547e-01f, -1.14079311e-01f,
  -6.21028729e-02f, 1.20986290e-01f, 2.61768159e-02f, -3.86912934e-02f, 1.65589005e-01f, -2.02777088e-01f, 1.22933783e-01f, -1.24879519e-03f, -2.95612272e-02f, 9.21198912e-03f,
  -1.74625799e-01f, -6.38730302e-02f, -7.81247951e-03f, -8.35323557e-02f, -1.00618415e-01f, 6.18972629e-03f, 1.46098688e-01f, 1.05118781e-01f, 9.00937244e-02f, -7.91713297e-02f,
  -9.60732028e-02f, -3.38702723e-02f, -6.90283626e-02f, -5.63919246e-02f, 5.71867749e-02f, -4.68352251e-02f, 5.67835011e-02f, 2.05520928e-01f, 5.13350219e-02f, 5.81492223e-02f,
  2.90396959e-01f, -1.37173146e-01f, 3.03255171e-01f, 3.31598185e-02f, -2.59041876e-01f, -4.28936392e-01f, 9.50483456e-02f, 1.48567855e-01f, -8.20887163e-02f, 8.76943581e-03f,
  6.83447206e-03f, -1.29403556e-02f, -2.38323852e-01f, 3.07123624e-02f, -1.33154839e-01f, 3.10504939e-02f, 1.08799368e-01f, 3.50585043e-01f, 1.55387163e-01f, 8.46894737e-03f,
  1.18080609e-01f, 1.65687934e-01f, 1.23060577e-01f, -2.33758744e-02f, 7.96794370e-02f, -3.29762936e-01f, 2.72798054e-02f, -2.45378628e-01f, -4.60131705e-01f, -2.56045870e-02f,
  6.13956377e-02f, -4.48356792e-02f, 1.65991262e-01f, -4.84243706e-02f, 2.73304526e-02f, -2.06307080e-02f, 8.83956552e-02f, -2.81170029e-02f, 3.18900794e-01f, 1.80567697e-01f,
  9.26581677e-03f, 5.44288754e-02f, -6.97265659e-03f, 1.40906787e-02f, -2.79409792e-02f, 1.02659829e-01f, 1.19715236e-01f, -2.52329886e-01f, 1.16745047e-01f, 1.32967144e-01f,
  1.22948863e-01f, -1.17308475e-01f, 1.76004127e-01f, 3.81906629e-01f, -2.15405658e-01f, 1.73792183e-01f, 3.60203981e-02f, -2.10768461e-01f, -9.72239822e-02f, 3.24227586e-02f,
  3.85990292e-01f, 1.98001862e-01f, 3.85150641e-01f, 1.47274286e-01f, 6.43114299e-02f, 4.17142391e-01f, -1.25584960e-01f, 3.11826855e-01f, 3.33372392e-02f, 3.10865819e-01f,
  3.84050131e-01f, -1.34392918e-04f, 2.22386166e-01f, 2.02070698e-01f, -3.91269773e-02f, 2.33365372e-01f, 1.87765732e-01f, 8.87822360e-02f, 1.65948033e-01f, -1.97092116e-01f,
  1.05193123e-01f, 6.84113577e-02f, 2.55343407e-01f, -2.55823046e-01f, 1.20313400e-02f, -6.80730864e-02f, 1.88116223e-01f, 2.70458817e-01f, 1.00107931e-01f, 1.46932811e-01f,
  5.69078743e-01f, 2.20109355e-02f, 9.83334631e-02f, -5.29014170e-01f, -3.48176599e-01f, -1.60818785e-01f, -4.89773095e-01f, 2.81161088e-02f, 2.96104372e-01f, 3.72629846e-03f,
  9.48069319e-02f, 3.71280164e-01f, -6.78762048e-02f, -4.13501054e-01f, -9.56850275e-02f, -1.63591221e-01f, -1.86793640e-01f, -1.29080370e-01f, 1.06109373e-01f, 1.10142462e-01f,
  1.58975065e-01f, -2.51637157e-02f, -1.45429090e-01f, 1.55490130e-01f, -3.49143714e-01f, -5.08316644e-02f, 2.18522474e-01f, 1.02284789e-01f, 5.90888634e-02f, -2.26275384e-01f,
  1.37074456e-01f, 1.55263379e-01f, 2.81871289e-01f, 6.05414025e-02f, 7.06441924e-02f, -9.17476416e-02f, -1.76406857e-02f, -6.17177933e-02f, 1.34611398e-01f, -2.36983858e-02f,
  2.70022690e-01f, -5.27219698e-02f, -2.35919267e-01f, 3.56145017e-02f, 9.59109440e-02f, 1.92545339e-01f, -4.85130958e-02f, -1.39062583e-01f, -1.08990632e-01f, 3.06443214e-01f,
  6.06096946e-02f, 7.25392848e-02f, 5.89988828e-02f, 1.33942753e-01f, 2.77939439e-01f, -3.35037112e-01f, 3.58428299e-01f, -1.15861505e-01f, 9.04346257e-02f, -7.79121593e-02f,
  -1.08352154e-01f, 6.24225661e-02f, 5.49192019e-02f, -1.24662168e-01f, 6.91296756e-02f, 1.66576326e-01f, -4.22147989e-01f, 1.50365895e-02f, 7.73854777e-02f, 1.10340439e-01f,
  -2.42282506e-02f, -1.39382422e-01f, 4.66177836e-02f, 2.67837644e-01f, 4.38093126e-01f, 1.76868677e-01f, 4.96648878e-01f, 6.31631725e-03f, 3.55410993e-01f, 2.76690304e-01f,
  7.52561912e-02f, 2.34340474e-01f, 1.54212773e-01f, 8.82032812e-02f, 7.46364519e-02f, 4.06009883e-01f, 2.23471463e-01f, 1.42151922e-01f, -3.76183689e-02f, -4.38577384e-02f,
  3.01328897e-01f, 1.12653733e-03f, 5.82167394e-02f, -3.80710773e-02f, 2.62362152e-01f, -1.27298489e-01f, -7.54900128e-02f, -9.97162834e-02f, 2.94181406e-01f, -9.92896929e-02f,
  7.09144995e-02f, 3.39348853e-01f, -2.92552412e-02f, 1.86476439e-01f, 2.01062113e-01f, 9.89436433e-02f, 9.67829600e-02f, 4.14460987e-01f, 2.03920379e-01f, 1.67415485e-01f,
  3.90808523e-01f, 3.43839191e-02f, 2.12207839e-01f, -2.08937787e-02f, 2.38481060e-01f, 3.85369174e-02f, -1.03694081e-01f, 1.32398352e-01f, 1.78225234e-01f, 2.09810119e-03f,
  -1.13520972e-01f, -2.95091897e-01f, 4.00430769e-01f, 3.16287607e-01f, -3.38697404e-01f, -2.42109373e-01f, -1.08851809e-02f, 3.01032454e-01f, 1.87847063e-01f, -6.07333966e-02f,
  5.22837102e-01f, -1.18983932e-01f, -2.26470634e-01f, 1.54817924e-01f, -3.40277255e-01f, -3.52368861e-01f, 3.22301894e-01f, 6.42855912e-02f, 2.07759961e-01f, -1.01588145e-02f,
  -1.94177866e-01f, -1.31567448e-01f, -3.21691424e-01f, -4.87951159e-01f, -1.58953935e-01f, -3.34301770e-01f, -1.84502572e-01f, 1.19337188e-02f, 8.20925925e-03f, 2.82783628e-01f,
  -2.51618475e-02f, 3.31841975e-01f, -2.98383802e-01f, 2.10597441e-01f, -6.98601529e-02f, 7.62016252e-02f, -5.49790561e-01f, -1.82754517e-01f, 1.06838971e-01f, 2.57151902e-01f,
  4.15325820e-01f, 2.65101939e-01f, -4.13216129e-02f, -3.62945199e-02f, 1.79591313e-01f, -7.90119097e-02f, 2.26821080e-01f, -6.95499331e-02f, 2.41848454e-01f, 1.51702061e-01f,
  2.07062922e-02f, -3.38119030e-01f, 6.17977157e-02f, 3.66584435e-02f, 6.50015846e-02f, 2.64219731e-01f, 9.13984329e-02f, -1.62327260e-01f, 1.96605727e-01f, -4.36780676e-02f,
  -6.76808530e-04f, 4.73837227e-01f, 1.64820775e-01f, 1.84443697e-01f, 1.76891685e-01f, -6.35649264e-02f, 4.88032401e-02f, 3.21717173e-01f, -1.95998222e-01f, -2.86891580e-01f,
  -1.01117924e-01f, -3.11203927e-01f, 1.33569807e-01f, -3.65503669e-01f, -5.31449877e-02f, 1.02051578e-01f, -3.16713005e-01f, 1.07159279e-01f, 2.57735133e-01f, -3.04668903e-01f,
  -2.35716589e-02f, 1.80509984e-01f, -6.21379400e-03f, -2.98612446e-01f, 1.23420924e-01f, -1.11127883e-01f, 1.82221428e-01f, 1.80269673e-01f, 3.14128637e-01f, 2.58194823e-02f,
  -1.53065562e-01f, -4.05566990e-02f, 2.55852282e-01f, -1.61241964e-01f, 1.38414636e-01f, 2.44599417e-01f, 3.63817625e-02f, 1.57461613e-01f, -7.26128668e-02f, 9.68272984e-02f,
  -2.35217601e-01f, -2.60357726e-02f, 2.16789562e-02f, -1.76480591e-01f, 8.52422565e-02f, -1.46724489e-02f, -1.03281282e-01f, -1.69969112e-01f, 6.67060241e-02f, 5.55313788e-02f,
  -1.97753891e-01f, 1.27579227e-01f, -5.51472940e-02f, -1.27329230e-01f, -9.63317007e-02f, 1.65263012e-01f, 9.40362215e-02f, -9.43992585e-02f, 1.17212281e-01f, -2.12255314e-01f,
  -4.48820665e-02f, 9.84039754e-02f, 5.38252033e-02f, 8.66828188e-02f, 1.50190160e-01f, -1.86425835e-01f, 1.06189243e-01f, -3.14940661e-01f, 5.10004014e-02f, -1.54838771e-01f,
  -1.31475344e-01f, -1.34065196e-01f, -3.38230538e-03f, 1.18494801e-01f, -1.87939197e-01f, -7.37402588e-02f, -4.29026663e-01f, 3.08004111e-01f, 2.36886978e-01f, -1.82802957e-02f,
  6.21012300e-02f, 4.46574330e-01f, 2.73755670e-01f, -8.46731067e-02f, 4.30336548e-03f, 1.47707611e-01f, 3.80194068e-01f, -1.16182283e-01f, 2.70406038e-01f, 6.12136386e-02f,
  3.35411340e-01f, 1.86799124e-01f, 2.32005082e-02f, 4.08763885e-01f, -6.37281546e-03f, 2.31952831e-01f, 2.91826218e-01f, 3.85588765e-01f, -1.91291839e-01f, 1.55256957e-01f,
  4.14487451e-01f, 1.13306567e-02f, 1.92243397e-01f, -5.49244583e-01f, 3.11163604e-01f, -9.93237123e-02f, 2.00845465e-01f, -2.44690329e-01f, -2.26816610e-01f, 2.75963664e-01f,
  1.47038221e-01f, 2.76229084e-01f, 9.88163427e-02f, 2.44898140e-01f, 2.05773085e-01f, -1.22674607e-01f, 1.60272434e-01f, 2.39738733e-01f, 2.17914164e-01f, -2.73558527e-01f,
  -1.65978730e-01f, 1.20827198e-01f, 7.68853799e-02f, 3.15989107e-01f, 1.49907112e-01f, -3.52755226e-02f, 1.37516320e-01f, 3.68851051e-02f, -1.48881925e-02f, 3.73271704e-01f,
  2.66981926e-02f, 4.62731123e-01f, -1.94931235e-02f, 4.54930700e-02f, -5.05837500e-02f, 1.75503030e-01f, 9.48716328e-02f, 3.79275143e-01f, -2.13285446e-01f, -2.77963638e-01f,
  3.07144582e-01f, -4.42072541e-01f, -1.78958848e-02f, 9.70505551e-02f, -2.57940114e-01f, -2.40872707e-02f, 2.20493734e-01f, -4.89619151e-02f, 3.12051922e-02f, 1.98642045e-01f,
  -1.38149515e-01f, -1.00289643e-01f, 9.47309881e-02f, 1.05575636e-01f, 1.01804473e-02f, 4.82265018e-02f, 1.01703018e-01f, -2.36451216e-02f, 5.70587069e-03f, 5.67856953e-02f,
  2.19277844e-01f, -3.12307328e-01f, -1.82515219e-01f, 2.45498031e-01f, 1.96470976e-01f, 2.51191258e-02f, -2.38305852e-01f, 1.00955248e-01f, -9.11877900e-02f, -3.79115227e-03f,
  -1.22818137e-02f, -9.40552820e-03f, 2.07948372e-01f, -1.17268367e-02f, -1.08317256e-01f, -2.61831760e-01f, 8.39568151e-04f, 1.55783802e-01f, -2.11421937e-01f, 1.71906576e-01f,
  1.23284511e-01f, 2.23473907e-01f, -7.43775070e-02f, -1.76805466e-01f, -2.51873042e-02f, 1.00159459e-01f, -2.70437688e-01f, 8.35817866e-03f, -7.33183175e-02f, -6.39772713e-02f,
  2.93170154e-01f, -1.00210220e-01f, 4.47925359e-01f, 2.56971158e-02f, 3.61123472e-01f, -9.90444049e-03f, 6.18548924e-03f, -3.80176246e-01f, -2.17958286e-01f, -2.73106962e-01f,
  2.38238052e-01f, 7.18966350e-02f, 2.30358645e-01f, 3.03729884e-02f, -2.28900269e-01f, -4.94015366e-02f, 1.94268689e-01f, -1.39959517e-03f, -4.58041430e-01f, -1.90420061e-01f,
  -8.15043077e-02f, 3.96735698e-01f, -1.86104745e-01f, -4.64508645e-02f, 2.76201248e-01f, 2.85419166e-01f, 1.30120993e-01f, 5.92624396e-02f, -6.80754855e-02f, -9.48398188e-02f,
  5.79348169e-02f, 1.88332215e-01f, -4.07472551e-02f, 2.56344885e-01f, -3.10328119e-02f, 2.21018046e-01f, -4.79448102e-02f, -1.32444233e-01f, -2.39347339e-01f, 3.57462227e-01f,
  2.22175077e-01f, 2.84856886e-01f, -4.15004455e-02f, 1.63881127e-02f, 1.22407965e-01f, 1.27218932e-01f, 6.29978180e-02f, 3.08285564e-01f, 6.42569661e-02f, -2.81586766e-01f,
  3.13864127e-02f, 7.69909471e-02f, -6.74445108e-02f, -5.58164865e-02f, 2.71912396e-01f, 2.38595083e-01f, -7.13522583e-02f, -5.41070290e-03f, 8.08456093e-02f, -8.72117747e-03f,
  1.81667253e-01f, 2.04988152e-01f, 1.85234144e-01f, -3.06281867e-03f, 2.91078120e-01f, -4.66281883e-02f, 6.20775372e-02f, 1.11743182e-01f, 1.44680887e-01f, 1.84263140e-01f,
  -2.51480997e-01f, -3.25571626e-01f, -2.49678090e-01f, 1.60509720e-01f, 3.11828759e-02f, 1.80265114e-01f, -1.87873587e-01f, -5.42019436e-04f, -2.08395630e-01f, -8.46655518e-02f,
  3.85822475e-01f, 1.62561536e-01f, -4.64383245e-01f, -2.41208538e-01f, 1.24174498e-01f, 7.27727413e-02f, -1.72890455e-01f, 2.75382578e-01f, 9.71810967e-02f, -4.30408778e-04f,
  5.62857185e-03f, 2.39501432e-01f, 4.55241576e-02f, 1.24687701e-01f, 1.97355866e-01f, 1.02141507e-01f, -7.93382060e-03f, 3.83727431e-01f, 1.87085032e-01f, -3.47909108e-02f,
  1.87069207e-01f, -1.43398523e-01f, 1.08381808e-01f, 4.54373002e-01f, -2.05103472e-01f, 1.26864374e-01f, 6.66815639e-02f, -1.15173317e-01f, -1.73473299e-01f, 2.27541804e-01f,
  1.60485432e-01f, 3.53490204e-01f, 1.49684906e-01f, 6.58964962e-02f, -8.18116143e-02f, 8.50487873e-02f, 2.40075082e-01f, 3.38032506e-02f, 1.02837667e-01f, -2.37188637e-02f,
  -7.57571757e-02f, -6.95115179e-02f, -1.16768375e-01f, 3.03224862e-01f, 7.88186118e-02f, -5.39038368e-02f, -1.89685255e-01f, 2.19084248e-01f, -3.08874622e-02f, 1.03647538e-01f,
  -1.01823779e-02f, -1.65687546e-01f, -3.07189703e-01f, -3.18206310e-01f, 3.15071374e-01f, 1.69507682e-01f, 2.36874834e-01f, -2.63540465e-02f, -1.98858231e-01f, -3.19466829e-01f,
  1.75081074e-01f, 2.39844009e-01f, 2.94122875e-01f, -4.08185348e-02f, -2.90037930e-01f, -3.13502908e-01f, -2.04667509e-01f, 5.36647253e-02f, -8.09725299e-02f, -8.73547420e-02f,
  2.87289023e-01f, 1.21061027e-01f, -8.05154741e-02f, 2.12752402e-01f, 8.69764015e-02f, -5.32120951e-02f, -7.99809471e-02f, -6.04723878e-02f, -1.50123492e-01f, 3.43605429e-02f,
  3.08888644e-01f, -3.87310922e-01f, -2.91621685e-01f, 1.64739519e-01f, 1.74483404e-01f, 1.49287343e-01f, -1.17096983e-01f, -3.43059689e-01f, 2.21913114e-01f, 6.56196401e-02f,
  1.42402602e-02f, 3.69970612e-02f, 2.37482503e-01f, -1.10509126e-02f, -8.16945061e-02f, -1.58459574e-01f, 1.37325317e-01f, 1.04652397e-01f, -1.37358889e-01f, 1.46815516e-02f,
  9.69706774e-02f, 1.75138965e-01f, 2.47978523e-01f, -8.06223750e-02f, 1.23187758e-01f, 1.71550840e-01f, -9.93968546e-02f, -9.98552889e-04f, 2.28502136e-02f, -7.39000589e-02f,
  4.20265585e-01f, -2.18331739e-02f, 2.24394992e-01f, 1.19328089e-01f, 3.01052053e-02f, -2.75080472e-01f, -4.83444870e-01f, 2.14682922e-01f, -4.28119153e-01f, 5.29497415e-02f,
  -2.24814922e-01f, 1.43500134e-01f, 1.39407992e-01f, -1.68203026e-01f, -4.35314894e-01f, 2.23101571e-01f, 5.61931990e-02f, -3.93768579e-01f, 4.14968580e-01f, -3.05108935e-01f,
  -2.81776607e-01f, 6.95656519e-03f, 2.06197351e-01f, -7.49286311e-03f, 2.91804373e-01f, -3.18243206e-02f, -4.00164723e-02f, 1.38465911e-01f, -2.71733582e-01f, 2.14580655e-01f,
  -4.82228696e-02f, 2.10935190e-01f, -1.92888603e-01f, 2.09310040e-01f, 2.98554063e-01f, 1.31139651e-01f, -1.89790159e-01f, 1.68622047e-01f, 3.83447677e-01f, 1.16762601e-01f,
  4.52984929e-01f, -1.14095114e-01f, -5.30611090e-02f, -9.51109678e-02f, 5.99115435e-03f, -2.58797288e-01f, -5.15779331e-02f, 2.83522218e-01f, 6.92348406e-02f, 3.66190076e-01f,
  -3.56939852e-01f, -2.73447603e-01f, -2.19543606e-01f, 1.83698401e-01f, -4.17295396e-01f, -2.70941257e-01f, 1.30146340e-01f, -1.62364870e-01f, -4.88599651e-02f, 1.14877865e-01f,
  -2.16009408e-01f, 2.81440690e-02f, 1.46058962e-01f, -1.36789814e-01f, -1.60832077e-01f, -2.03359365e-01f, -3.97410803e-02f, -4.22961451e-02f, -2.46513337e-02f, 5.61241470e-02f,
  9.66586918e-02f, -2.29383409e-01f, -2.47806013e-02f, -2.87126079e-02f, -4.50118557e-02f, 8.56620818e-02f, -6.04161806e-02f, 4.01631594e-01f, -1.93024665e-01f, 1.99283734e-01f,
  -5.67137420e-01f, 2.31277585e-01f, 2.59548873e-01f, 3.14868659e-01f, 1.84169739e-01f, 4.11434844e-03f, 2.72529334e-01f, 1.28205016e-01f, -3.40490311e-01f, 8.08261707e-02f,
  2.81735450e-01f, 6.32965267e-02f, 2.67056257e-01f, -1.10056669e-01f, 1.41732395e-01f, 1.21138945e-01f, 8.49792510e-02f, 4.02389824e-01f, -2.90673375e-02f, 2.28850748e-02f,
  -9.71520618e-02f, 3.24159682e-01f, 3.45056713e-01f, -5.78075424e-02f, 2.81040430e-01f, 1.40699238e-01f, -1.63775627e-02f, -2.47296646e-01f, 1.90585628e-01f, -2.97658354e-01f,
  -1.87280010e-02f, -2.18464166e-01f, -3.97687405e-01f, 1.68112427e-01f, 6.41818270e-02f, 1.18731953e-01f, 2.77086914e-01f, 7.83362836e-02f, 1.43163532e-01f, -1.41455337e-01f,
  -1.57749206e-01f, 2.48401359e-01f, 4.86397207e-01f, 2.96168029e-01f, 1.20009087e-01f, -1.18595492e-02f, 2.17962012e-01f, 1.03586562e-01f, -3.25957052e-02f, -1.51765525e-01f,
  -2.21493334e-01f, 1.44080166e-02f, -1.71572715e-01f, 3.26722920e-01f, -1.81772679e-01f, 4.76530105e-01f, -9.05521438e-02f, 1.89447075e-01f, 1.26172110e-01f, 1.23174600e-01f,
  5.14832847e-02f, 3.64317149e-01f, -1.46571472e-01f, -3.88106644e-01f, -3.01860832e-02f, -7.87779018e-02f, -1.54903010e-01f, 5.27727231e-02f, 2.80167818e-01f, 1.17395900e-01f,
  3.28229219e-02f, -2.07068980e-01f, 2.12208644e-01f, 1.53257608e-01f, 5.97593561e-03f, -1.31866664e-01f, 9.41502154e-02f, -1.26830205e-01f, 1.80522099e-01f, 1.21866494e-01f,
  1.84713364e-01f, -4.73755002e-02f, 1.41548991e-01f, -1.34603828e-01f, 3.01663101e-01f, -2.29117081e-01f, -4.40977722e-01f, 2.16488123e-01f, 1.17263414e-01f, 1.40144408e-01f,
  -2.07491994e-01f, 7.70639926e-02f, 1.46471784e-01f, 1.03276327e-01f, 1.60141915e-01f, 1.20313339e-01f, 5.59328869e-02f, -7.28081837e-02f, 2.60119259e-01f, 1.01242699e-01f,
  1.61247835e-01f, 6.69678301e-02f, 1.88284278e-01f, 2.39110482e-03f, 2.25852728e-01f, -3.53836343e-02f, -4.53413308e-01f, -4.18843120e-01f, -1.04331085e-02f, 1.55238912e-01f,
  -1.10486157e-01f, -7.96369836e-02f, -2.17674181e-01f, -2.85389367e-02f, -1.83982551e-01f, 3.28583151e-01f, 2.48255692e-02f, -4.32715341e-02f, -3.73695552e-01f, -3.69607270e-01f,
  1.10688478e-01f, -1.03517942e-01f, 6.53037727e-02f, 8.94424021e-02f, -4.30942714e-01f, -6.77361310e-01f, -1.63067713e-01f, -1.21309936e-01f, 2.59804517e-01f, -2.75939703e-01f,
  -3.40219527e-01f, 2.46095017e-01f, -1.36268763e-02f, -2.87688643e-01f, 4.33973253e-01f, -2.26504803e-01f, 1.04919620e-01f, 1.41542405e-01f, -2.10997000e-01f, 2.60935009e-01f,
  2.54147530e-01f, 1.43828273e-01f, -8.53737965e-02f, 6.86580688e-02f, -5.19163422e-02f, -1.99063122e-01f, 9.12901312e-02f, -1.06795788e-01f, -4.46737915e-01f, 1.41678229e-01f,
  5.15082002e-01f, 2.80866921e-01f, -6.93298876e-02f, 9.89340059e-03f, 1.95541695e-01f, 2.79246688e-01f, -2.56047636e-01f, 3.67004365e-01f, 3.96297798e-02f, 2.12013021e-01f,
  1.44574299e-01f, -1.67459875e-01f, 2.95556515e-01f, 3.38959187e-01f, 2.29684070e-01f, 3.09322402e-02f, 8.98072869e-02f, -1.11983027e-02f, -6.33990392e-02f, 1.08017251e-01f,
  6.52148426e-02f, 2.95597374e-01f, 1.76122919e-01f, 2.37143517e-01f, -1.98885933e-01f, -1.22581057e-01f, -1.76159471e-01f, 2.94090599e-01f, -3.52473676e-01f, -6.66103885e-02f,
  -4.17455025e-02f, -1.15276530e-01f, -1.70139968e-02f, 5.24230227e-02f, 3.63986999e-01f, 2.51960307e-01f, 1.34192675e-01f, -2.55248338e-01f, -2.00241834e-01f, -4.93313819e-02f,
  3.34810287e-01f, -2.15839952e-01f, 1.07699119e-01f, 3.56532425e-01f, -6.40505850e-01f, -3.80317122e-01f, 4.57963377e-01f, 4.77068305e-01f, -3.92159028e-03f, 5.78013957e-02f,
  3.20950866e-01f, -6.36528730e-02f, -3.64890066e-03f, 2.06679091e-01f, 3.75130981e-01f, 5.18097430e-02f, 2.98486501e-01f, 1.15223892e-01f, 1.13904893e-01f, -2.66602248e-01f,
  2.68971562e-01f, -8.27071518e-02f, 2.74936378e-01f, -7.57579431e-02f, -8.18586424e-02f, 3.69055152e-01f, -1.07080061e-02f, -3.08828145e-01f, 3.14220369e-01f, 1.56079784e-01f,
  1.29762650e-01f, 1.50950700e-01f, 4.19171005e-01f, -2.24073932e-01f, -1.50995910e-01f, -2.71689147e-01f, 1.67262882e-01f, -5.73638938e-02f, -8.27331282e-03f, 4.29566763e-02f,
  -1.97908729e-02f, 1.49537623e-01f, -1.97900131e-01f, 1.36246085e-02f, 5.41211069e-02f, 2.55370885e-01f, -4.52619307e-02f, -1.34921819e-01f, 2.43509095e-02f, 1.92584679e-03f,
  3.45102437e-02f, 2.27848869e-02f, 1.59418106e-01f, -2.70043820e-01f, -8.69806558e-02f, -4.96919692e-01f, -3.24072033e-01f, 1.72759250e-01f, -4.32142824e-01f, 8.04146305e-02f,
  1.98406819e-02f, 1.60877287e-01f, 4.40806150e-01f, -1.43030703e-01f, -8.09876248e-02f, 3.52925569e-01f, 3.03485077e-02f, -1.28196508e-01f, 4.15520251e-01f, -4.47892584e-02f,
  -3.16328377e-01f, -2.69546390e-01f, -5.82918040e-02f, 1.21706255e-01f, 2.00606838e-01f, -1.98253915e-01f, -5.48888743e-01f, 1.65837035e-01f, -3.34012359e-01f, 1.82176828e-02f,
  -2.91716427e-01f, -1.96026802e-01f, -5.93664460e-02f, -2.66074747e-01f, 1.66084647e-01f, 1.90669954e-01f, -4.28102821e-01f, -1.12572697e-03f, 2.49969408e-01f, -9.33142081e-02f,
  6.69971853e-02f, 1.44982785e-01f, -2.63827950e-01f, 6.10962436e-02f, -3.42299819e-01f, -2.51626526e-03f, 2.34367531e-02f, 4.13444936e-01f, 2.52902180e-01f, 1.30386829e-01f,
  2.02136964e-01f, 4.35176998e-01f, -1.30160466e-01f, 1.64501920e-01f, 2.70236582e-01f, 1.01492163e-02f, 1.91342905e-01f, -3.01969685e-02f, 2.48936310e-01f, -4.62859694e-04f,
  2.87546366e-02f, 1.61457226e-01f, 1.82903558e-01f, -5.85365668e-02f, -6.08412437e-02f, 2.99400389e-01f, -1.52908131e-01f, -1.38542922e-02f, -6.12840429e-02f, -3.04863639e-02f,
  1.47825301e-01f, 2.60716945e-01f, 1.40954060e-02f, 1.06947320e-02f, -1.87074044e-03f, 2.11793691e-01f, 2.98551917e-01f, 8.83056670e-02f, -1.47655413e-01f, -1.71335712e-01f,
  6.40482903e-02f, -7.15930313e-02f, -4.30667728e-01f, -4.13773596e-01f, 1.26175299e-01f, 1.32464156e-01f, -1.09365128e-01f, -3.73737872e-01f, 2.17134535e-01f, 1.70260012e-01f,
  -1.29433185e-01f, 3.93243767e-02f, -4.35581282e-02f, 2.54348963e-02f, 1.78705454e-01f, 1.29856110e-01f, -1.47235231e-03f, -5.69987297e-02f, 6.45749569e-02f, -2.90531684e-02f,
  -2.60819495e-02f, -1.84134856e-01f, -3.95204574e-01f, 2.30396196e-01f, 1.27507925e-01f, -2.72853851e-01f, 9.51496586e-02f, -1.20521754e-01f, -1.02620877e-01f, -1.99909717e-01f,
  2.64997426e-02f, -2.17998371e-01f, -1.15259133e-01f, -5.78439496e-02f
};

// L2_fan_Bp_bar (Shape: 1 x 26)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 26;
const float L2_fan_Bp_bar_data[] = {
  -4.29473408e-02f, 1.54593289e-01f, -6.67106509e-02f, 6.49570599e-02f, 1.51610926e-01f, 1.37595117e-01f, -6.58469871e-02f, 1.89937782e-02f, 4.05776910e-02f, 1.14665955e-01f,
  1.25775993e-01f, 7.20993504e-02f, 1.68740302e-01f, 2.67412700e-02f, -1.28003538e-01f, 6.61475807e-02f, 1.65250406e-01f, 1.53113216e-01f, 2.87962542e-03f, -7.06120133e-02f,
  1.51436701e-02f, 5.64250117e-03f, 1.96744666e-01f, 3.90365832e-02f, 1.21265575e-01f, 7.03066960e-02f
};

// L3_linear_W (Shape: 12 x 64)
const int L3_linear_W_rows = 12;
const int L3_linear_W_cols = 64;
const float L3_linear_W_data[] = {
  -5.48949912e-02f, -2.95624882e-01f, -2.80882925e-01f, -2.33819038e-01f, -2.75024563e-01f, 6.28507137e-02f, 2.63757966e-02f, 5.81214018e-02f, -1.00382902e-01f, -2.11773068e-01f,
  5.71265183e-02f, 4.67430837e-02f, -2.54420608e-01f, -2.18916506e-01f, -2.66676575e-01f, -1.36969201e-02f, 1.32574514e-01f, 8.59186575e-02f, 1.29422441e-01f, 1.91476539e-01f,
  5.68861440e-02f, 8.94100517e-02f, 1.38114899e-01f, 1.28031418e-01f, -1.41410336e-01f, -3.47234815e-01f, 3.27896625e-01f, 8.14477429e-02f, 1.32439047e-01f, -1.14385605e-01f,
  7.44062439e-02f, 2.13732064e-01f, -2.32167929e-01f, -3.44866663e-02f, -2.58551538e-02f, 3.45896542e-01f, -6.72333017e-02f, -1.80125564e-01f, -2.66444027e-01f, -4.53141838e-01f,
  -3.13291520e-01f, -4.01038319e-01f, 1.17614344e-01f, -5.47752567e-02f, 1.43539906e-01f, -9.35647041e-02f, 2.73895741e-01f, 9.45811048e-02f, -6.24727547e-01f, 1.11398295e-01f,
  -2.77756929e-01f, -2.99094878e-02f, 1.56546891e-01f, -2.97438353e-01f, -1.75043225e-01f, 3.55380327e-02f, -4.07369822e-01f, -2.67703533e-01f, 2.95256972e-01f, 2.31734723e-01f,
  -3.05746228e-01f, 7.89667889e-02f, -8.39139521e-02f, -1.67367570e-02f, -3.23563188e-01f, 7.07434714e-02f, -2.04746276e-01f, -2.17414930e-01f, 7.83983022e-02f, -3.90341505e-02f,
  8.65088776e-02f, -2.70051360e-01f, 2.03029215e-01f, -7.16776624e-02f, 4.38625953e-04f, 1.78729549e-01f, -1.31396100e-01f, 2.76420414e-01f, 2.66138315e-01f, 1.28967417e-02f,
  4.96934913e-02f, -2.83816531e-02f, -3.16043317e-01f, -1.00335144e-01f, 1.03781089e-01f, -4.90144864e-02f, -4.95201014e-02f, 1.85733825e-01f, 3.20689261e-01f, 4.08218861e-01f,
  -1.54733151e-01f, 1.96373105e-01f, -2.51605242e-01f, 2.18557656e-01f, -1.27848461e-01f, -1.80652961e-01f, 2.37345006e-02f, 6.58276305e-02f, 3.66747558e-01f, -3.83522362e-02f,
  -6.79854006e-02f, 1.12252891e-01f, 1.21681973e-01f, -5.25652528e-01f, -3.88540626e-02f, -5.70272684e-01f, -4.30993110e-01f, 1.23421550e-01f, 1.91970333e-01f, 2.62703478e-01f,
  -1.70630664e-01f, 8.43225420e-02f, -3.21477741e-01f, -2.00071912e-02f, -1.61449075e-01f, 3.18532407e-01f, -2.13174634e-02f, 2.45229349e-01f, 1.02771655e-01f, 2.16938093e-01f,
  -1.39136523e-01f, -2.36128181e-01f, -3.82488258e-02f, -2.27247495e-02f, 1.62011981e-01f, -4.16613191e-01f, -9.52422842e-02f, -3.51736158e-01f, 1.26049414e-01f, 9.26735476e-02f,
  -6.52465746e-02f, 1.23141021e-01f, -1.90554202e-01f, -1.58917978e-01f, -1.80068165e-02f, 1.93722963e-01f, 2.47519195e-01f, -7.67463967e-02f, -1.93816237e-02f, 2.74277598e-01f,
  1.65367037e-01f, -3.55179906e-02f, 7.35767186e-02f, 1.31973535e-01f, 6.06283844e-02f, -1.18974365e-01f, 5.82210273e-02f, -3.36383015e-01f, 1.41951546e-01f, -3.25842708e-01f,
  5.81096951e-03f, -2.83661000e-02f, 3.66535038e-01f, -4.06074315e-01f, 5.06186366e-01f, -2.21869364e-01f, -5.65072954e-01f, 2.95822948e-01f, -2.86514312e-01f, -6.23183958e-02f,
  2.09366649e-01f, 3.50635648e-01f, 4.65168208e-01f, -9.14304480e-02f, 3.69293332e-01f, 3.78905147e-01f, -2.12834805e-01f, -4.49093074e-01f, -3.97616476e-01f, 3.04717720e-01f,
  3.03293586e-01f, -1.06468126e-01f, 6.88371956e-02f, -2.14740410e-01f, 6.16530664e-02f, -3.70831221e-01f, 7.00126067e-02f, -8.82877037e-02f, 3.80893022e-01f, 2.86221117e-01f,
  1.47846462e-02f, -1.71834439e-01f, 1.61953241e-01f, 1.31671056e-01f, -2.77891606e-01f, -2.40517676e-01f, -4.09245819e-01f, -3.45440186e-03f, -5.09521484e-01f, -1.53219178e-01f,
  -3.66520554e-01f, -2.04903588e-01f, -2.11571798e-01f, -5.39831482e-02f, -1.85691848e-01f, -3.78894843e-02f, -2.45290771e-01f, 4.65341136e-02f, 7.14131892e-02f, 1.06386207e-01f,
  2.25396648e-01f, -2.80529916e-01f, -5.97188808e-02f, -2.43736923e-01f, -1.38382077e-01f, -7.44320303e-02f, -3.37670058e-01f, -1.02004223e-01f, 1.10694490e-01f, -2.59893723e-02f,
  -1.20275103e-01f, 1.55686110e-01f, 2.58747935e-01f, 1.94920719e-01f, 7.21376762e-02f, -1.49557248e-01f, 6.97993860e-03f, -1.00007772e-01f, -1.04785942e-01f, 1.61006764e-01f,
  -8.33307113e-03f, -2.56727755e-01f, 1.09609384e-02f, -3.67532186e-02f, -8.81248713e-02f, -7.00779036e-02f, 3.69041264e-02f, -2.38585606e-01f, 5.01798205e-02f, 8.39025080e-02f,
  -1.97496995e-01f, 8.50434080e-02f, 2.28774577e-01f, -9.61846858e-03f, 1.83196753e-01f, -7.80673265e-01f, -2.03424171e-01f, -7.03735828e-01f, -6.26794696e-02f, -1.54687643e-01f,
  -4.82506901e-01f, 1.02994770e-01f, -1.85598508e-01f, -2.82450885e-01f, 1.15423627e-01f, -1.71065018e-01f, 7.84971099e-03f, -3.36620510e-01f, 1.94234699e-01f, -4.74550053e-02f,
  1.50512695e-01f, -3.25154424e-01f, -1.26951572e-03f, 3.97887342e-02f, -2.67497808e-01f, -2.69993860e-02f, -1.36326164e-01f, -7.32564926e-02f, 3.45911652e-01f, 1.24651231e-01f,
  9.78212878e-02f, 4.71116193e-02f, -4.88406837e-01f, 6.26196638e-02f, -3.67680907e-01f, -1.75981626e-01f, -2.37901025e-02f, 3.35365497e-02f, 3.28307569e-01f, 2.67525166e-01f,
  9.48329046e-02f, -1.01626121e-01f, -9.53335539e-02f, -3.75480413e-01f, -3.29998374e-01f, -2.83803731e-01f, 1.45912185e-01f, -2.00434834e-01f, 1.30864054e-01f, 8.49979371e-02f,
  -2.90514946e-01f, -2.78976828e-01f, -1.00238949e-01f, -3.88842583e-01f, -1.55286983e-01f, 2.00998243e-02f, 4.52501744e-01f, 1.00034000e-02f, -1.06922142e-01f, -2.44509786e-01f,
  -3.13616663e-01f, -2.63273299e-01f, -1.99619029e-02f, -3.30868751e-01f, -9.21271741e-02f, -4.32217196e-02f, -1.16237491e-01f, -7.23266043e-03f, 7.92625025e-02f, 1.43304721e-01f,
  1.32985801e-01f, -1.16909854e-01f, -1.41630739e-01f, -1.21904403e-01f, 3.59589249e-01f, 1.12903118e-01f, -5.63361883e-01f, -4.03434694e-01f, 7.29346499e-02f, -5.40848017e-01f,
  3.74356098e-02f, -5.37530556e-02f, -1.39434664e-02f, -4.10444707e-01f, -3.02742898e-01f, -7.71763325e-02f, -1.08153798e-01f, 2.01316118e-01f, -5.24311773e-02f, 4.50403579e-02f,
  2.10639775e-01f, 1.41963527e-01f, 8.90861154e-02f, -1.85964838e-01f, 2.52553299e-02f, -2.92651802e-01f, 7.04230070e-02f, -6.15707263e-02f, 2.55444795e-01f, 3.93776000e-01f,
  1.63613170e-01f, 4.25614566e-02f, 1.27387345e-01f, -1.29556403e-01f, -3.57645638e-02f, -2.66938776e-01f, -1.67055786e-01f, 8.68348256e-02f, 3.36648077e-01f, -5.83353303e-02f,
  -2.04686210e-01f, -1.75684378e-01f, -6.17407337e-02f, -1.44196659e-01f, -1.97086588e-01f, 3.86665225e-01f, 2.31144190e-01f, 4.26165834e-02f, 2.83155680e-01f, -2.42138043e-01f,
  6.85768872e-02f, 2.98613876e-01f, 6.63640350e-02f, -6.15854338e-02f, -3.15240711e-01f, 2.52669692e-01f, -2.05874011e-01f, 1.12598710e-01f, -1.74794346e-02f, 3.62577379e-01f,
  1.01371713e-01f, 8.97499397e-02f, -1.71433777e-01f, 4.60723266e-02f, 1.18227035e-01f, 2.90253777e-02f, -1.30727127e-01f, 1.36468694e-01f, -5.29425859e-01f, -8.09910968e-02f,
  -4.11695749e-01f, 2.16668129e-01f, 1.08998731e-01f, 2.36386061e-01f, -6.44023418e-01f, -2.01607272e-02f, -3.31684411e-01f, 2.23908752e-01f, -4.41456407e-01f, 2.41888225e-01f,
  -2.68992633e-01f, 9.51420292e-02f, -4.03709620e-01f, 2.99333721e-01f, -1.96775556e-01f, -1.44497901e-01f, -9.30071920e-02f, 1.97828874e-01f, -2.12054476e-01f, -7.61630833e-02f,
  2.53214359e-01f, 1.36379227e-01f, -1.27938390e-02f, -6.80685118e-02f, 4.14399445e-01f, -1.47117555e-01f, 2.14146867e-01f, 1.82621762e-01f, -9.39522535e-02f, 8.55151117e-02f,
  -8.07420760e-02f, 2.54099965e-01f, 1.32289991e-01f, 2.72313476e-01f, -6.10757843e-02f, -8.41962397e-02f, -1.16732106e-01f, -2.29152203e-01f, 4.50265780e-02f, -3.17882389e-01f,
  -2.29552388e-01f, 3.58234495e-01f, -9.33452547e-02f, 5.69388084e-03f, -4.75823909e-01f, -8.21113512e-02f, -3.35364401e-01f, -6.91410005e-02f, -1.08247809e-03f, 1.78233594e-01f,
  -2.44444177e-01f, 6.24598622e-01f, -4.21695560e-01f, 1.39764979e-01f, -1.53143555e-01f, 2.03007385e-01f, -3.51556569e-01f, 2.07861200e-01f, -1.61841691e-01f, 2.18981266e-01f,
  -2.87930429e-01f, -5.04896700e-01f, 2.76802927e-01f, -5.87392092e-01f, 1.15943067e-01f, -1.54692695e-01f, -4.44574416e-01f, 9.87995937e-02f, -2.61117429e-01f, -8.03845972e-02f,
  -1.12172570e-02f, 1.98262915e-01f, -2.42891982e-01f, 2.40269408e-01f, -3.65752459e-01f, -1.08723670e-01f, 3.36354434e-01f, -1.43007055e-01f, -1.77228019e-01f, 2.25156859e-01f,
  -1.44002840e-01f, -1.71619624e-01f, -1.10767931e-01f, -4.84924838e-02f, 8.99856240e-02f, -6.51600165e-03f, 8.76818001e-02f, 1.26839802e-01f, -7.09674507e-02f, 7.32380450e-02f,
  -3.06321885e-02f, 1.01293847e-01f, 7.71543663e-03f, -8.78382474e-02f, 6.11882657e-03f, 4.59732255e-04f, -2.25511491e-01f, -1.68186966e-02f, 3.05722684e-01f, 1.91937402e-01f,
  -3.66713315e-01f, 5.98935112e-02f, -4.11962897e-01f, 4.25358638e-02f, -9.47551504e-02f, -3.50640535e-01f, -1.11392617e-01f, 2.40930304e-01f, 9.11180601e-02f, -2.05566227e-01f,
  1.73237666e-01f, -9.24976543e-02f, -2.19460741e-01f, -4.04190738e-03f, -3.07218790e-01f, -1.65323585e-01f, 9.74298567e-02f, 1.89104080e-01f, 1.10630713e-01f, -6.07646167e-01f,
  -4.50868934e-01f, -2.38441695e-02f, -2.53232777e-01f, 1.85418099e-01f, -5.41546524e-01f, 1.98581174e-01f, -1.41184285e-01f, -1.93316881e-02f, -2.32582211e-01f, -6.48332387e-02f,
  -3.57435733e-01f, -2.28454590e-01f, -7.38975927e-02f, -2.63343126e-01f, 2.67048270e-01f, -2.12634861e-01f, -4.96969700e-01f, -1.28592640e-01f, 2.33699769e-01f, 2.27409676e-01f,
  -1.62809417e-01f, -4.90464538e-01f, 2.19044045e-01f, 9.86462012e-02f, 8.90394393e-03f, 1.95442475e-02f, 1.41443610e-01f, 1.73980072e-02f, 1.63323488e-02f, -9.70409885e-02f,
  -9.48497001e-03f, 8.94559696e-02f, -8.25323313e-02f, -4.53597680e-02f, 1.52304173e-01f, -2.72497445e-01f, -3.09147328e-01f, 9.02817622e-02f, 5.33130430e-02f, 3.11258197e-01f,
  5.83834387e-02f, -1.19321667e-01f, -4.17324752e-02f, 3.33591521e-01f, 2.97430545e-01f, -3.10425848e-01f, -2.89292842e-01f, -1.51522877e-03f, 3.00994396e-01f, 3.17116767e-01f,
  4.41996694e-01f, -5.50679982e-01f, -1.80054441e-01f, 2.56154209e-01f, 1.86683163e-01f, 3.32834303e-01f, 1.26639977e-01f, -2.64440686e-01f, 4.65170145e-02f, -6.99040815e-02f,
  2.63683110e-01f, 8.24244097e-02f, 2.13308960e-01f, -3.81592959e-01f, -2.99059033e-01f, -2.06940204e-01f, -2.44110227e-01f, 8.11253339e-02f, -9.66820270e-02f, 6.48776591e-02f,
  -5.91671094e-02f, -3.14602673e-01f, 5.43586025e-03f, -1.98148221e-01f, -2.44757563e-01f, -1.41757205e-01f, 2.61775672e-01f, 2.15924740e-01f, -2.15241760e-01f, 2.64638603e-01f,
  -2.87435770e-01f, -4.36925411e-01f, -8.95117223e-02f, -2.90856749e-01f, 2.63737500e-01f, -2.09430009e-01f, -1.14747258e-02f, -1.83487788e-01f, 9.52977613e-02f, -7.68984854e-02f,
  1.85615793e-02f, 1.19756281e-01f, -2.02942893e-01f, 3.84556428e-02f, -1.42593473e-01f, 1.46352768e-01f, -2.59870946e-01f, 1.43087223e-01f, 1.07739486e-01f, 4.53807972e-02f,
  -1.50894701e-01f, 2.19857782e-01f, 1.19686812e-01f, 2.43322432e-01f, 1.28856257e-01f, 4.11361426e-01f, -1.12559296e-01f, -7.12826103e-02f, 1.55672505e-01f, -3.00716370e-01f,
  1.41429320e-01f, -3.17940503e-01f, -2.71288127e-01f, 4.34741616e-01f, 3.65404546e-01f, -5.90376444e-02f, 3.58411461e-01f, -1.89296424e-01f, -9.24763680e-02f, 4.10356641e-01f,
  -1.54481515e-01f, -1.93274677e-01f, 2.70320386e-01f, -6.64553821e-01f, 4.00974452e-02f, 1.21840101e-03f, -3.59577566e-01f, 1.19982800e-02f, -6.12178929e-02f, -6.75701201e-02f,
  -4.43118870e-01f, 1.62504852e-01f, -2.38394588e-01f, 3.77984941e-01f, 1.45133927e-01f, 4.77908812e-02f, 6.17451221e-02f, 1.65079415e-01f, -4.96467113e-01f, 2.13681668e-01f,
  -2.78483182e-01f, -2.51523465e-01f, 2.04872400e-01f, -2.95735866e-01f, -7.26562679e-01f, 1.37341127e-01f, -1.16915740e-01f, 2.08612770e-01f, -4.95874912e-01f, 2.73195416e-01f,
  -1.93975821e-01f, 1.67772770e-02f, 1.21934451e-01f, -2.71326721e-01f, 8.67164880e-02f, -2.36573759e-02f, -1.93515286e-01f, -9.01416764e-02f, -2.23385304e-01f, 1.88587695e-01f,
  -4.53315675e-02f, 2.72465587e-01f, 1.00335181e-01f, -1.63365141e-01f, 2.62955785e-01f, -2.28118911e-01f, 6.65534660e-02f, -3.23142469e-01f, 2.34979182e-01f, -8.81134570e-02f,
  -4.74624336e-01f, 4.15632725e-01f, 1.20838419e-01f, -5.19167334e-02f, 2.16876548e-02f, 2.38225609e-01f, 2.23480061e-01f, -1.96406066e-01f, 1.97976127e-01f, -6.62659034e-02f,
  -9.77619663e-02f, -2.58484989e-01f, 9.59586278e-02f, -1.98712662e-01f, -3.82279754e-01f, 3.31299722e-01f, 3.66256535e-02f, 1.24815218e-01f, -9.58107179e-04f, 1.34512395e-01f,
  2.07945749e-01f, 3.34940106e-02f, -4.38761324e-01f, -5.98244190e-01f, 1.35269597e-01f, -3.02989781e-01f, -1.35887638e-01f, -5.71893096e-01f, -8.47426578e-02f, 5.00941873e-02f,
  -2.06578791e-01f, -4.20962274e-01f, 9.13926288e-02f, -5.99689484e-01f, 2.47618943e-01f, 2.04538673e-01f, -1.38416931e-01f, 1.33750871e-01f, 2.42219329e-01f, -3.49398196e-01f,
  -7.48262107e-01f, -4.40245271e-01f, -3.69386464e-01f, -2.62800939e-02f, 2.04655379e-01f, 2.28765383e-01f, 1.55682890e-02f, 1.07915904e-02f, 2.29526296e-01f, -9.22698528e-03f,
  -1.58616915e-01f, -1.00165218e-01f, 1.30637556e-01f, 1.18254036e-01f, -3.21493775e-01f, 1.71581581e-01f, -3.23913872e-01f, -3.87500003e-02f, 2.15403676e-01f, -1.53122440e-01f,
  6.43996075e-02f, -9.15643573e-02f, 9.37037468e-02f, -5.49441986e-02f, -2.02862173e-02f, 1.71702117e-01f, -2.71175385e-01f, 1.44190311e-01f, 2.57324010e-01f, 2.32378379e-01f,
  -2.57912129e-01f, -4.04121131e-02f, 1.74392372e-01f, 2.23626032e-01f, -1.54078901e-01f, -1.34367809e-01f, 3.38554263e-01f, 9.52545553e-02f, 3.46754879e-01f, 1.60253674e-01f,
  -9.31958333e-02f, 7.81678855e-02f, -4.78118449e-01f, 2.12003633e-01f, 2.77871370e-01f, 2.91517556e-01f, -3.63331795e-01f, -4.30876106e-01f, -1.58524737e-02f, -3.67043823e-01f,
  -9.24632251e-02f, -2.89966166e-01f, 6.59646317e-02f, -7.41892233e-02f, 1.44484878e-01f, 9.98850241e-02f, -3.23763907e-01f, -3.59463722e-01f, -6.62811577e-01f, 1.38241062e-02f,
  2.57297218e-01f, 2.91831493e-01f, -2.37194702e-01f, -2.99018443e-01f, 2.39512473e-01f, -1.74720287e-01f, 1.61194593e-01f, -4.17737842e-01f
};

// L3_linear_B (Shape: 1 x 12)
const int L3_linear_B_rows = 1;
const int L3_linear_B_cols = 12;
const float L3_linear_B_data[] = {
  1.85256824e-02f, 1.29600922e-02f, 1.61488935e-01f, -2.66341791e-02f, 8.77026543e-02f, 3.37405540e-02f, 5.56736924e-02f, 9.14653167e-02f, -1.22944750e-01f, -4.96144965e-02f,
  4.94638644e-03f, -7.63947591e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 19, 26
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        64, 19, 26
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        64, 19, 26
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_linear
    linear_forward_pgm(
        buffer1, x_out,
        L3_linear_W_data, L3_linear_B_data,
        64, 12
    );
    }
    