/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 32 (x2)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 32;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    static inline float fan_activation(float x) { return x; }

    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 3 x 120)
const int L0_fan_Wp_rows = 3;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -3.36411506e-01f, 6.41071126e-02f, 1.63306981e-01f, 4.77898382e-02f, -2.63738483e-01f, -2.70652503e-01f, 1.94809675e-01f, -1.81878105e-01f, 1.97092928e-02f, 6.34654611e-02f,
  1.39022842e-02f, 1.27169043e-01f, 1.42529190e-01f, 6.61623254e-02f, -4.52162810e-02f, 1.79410666e-01f, -8.35906565e-02f, 5.14188521e-02f, -2.09431816e-02f, -8.44642892e-02f,
  -4.91917413e-03f, 6.59498498e-02f, 3.92043479e-02f, 5.16015245e-03f, -1.37679920e-01f, -1.25771351e-02f, -1.14521813e-02f, 1.69359699e-01f, -1.76591098e-01f, -1.81406960e-02f,
  -1.17691897e-01f, 1.55160367e-01f, -1.68428402e-02f, 7.46981576e-02f, -1.13256834e-01f, -2.08985079e-02f, -7.17453286e-02f, 1.29430935e-01f, 8.92057940e-02f, -9.78597789e-04f,
  2.20329463e-02f, -1.07568018e-01f, -1.79973934e-02f, 7.92892352e-02f, -3.59198526e-02f, 2.76338570e-02f, -5.23439646e-02f, -1.07399166e-01f, -3.19665149e-02f, -6.16833270e-02f,
  4.70177131e-03f, 3.52720730e-02f, -9.94232669e-03f, 5.57973653e-05f, -4.18906147e-03f, -1.48279332e-02f, 5.33898398e-02f, -1.18675996e-02f, -2.97867693e-02f, -1.48405343e-01f,
  7.52978376e-04f, -2.04028115e-02f, 2.04072352e-02f, -5.08068837e-02f, 3.53320949e-02f, -3.15482989e-02f, 7.65985474e-02f, 5.55195846e-03f, 8.91930908e-02f, 2.24859104e-05f,
  -1.16495721e-01f, -2.67987344e-02f, 3.28714103e-02f, -5.86918332e-02f, -5.27281910e-02f, -1.53551316e-02f, 1.28806587e-02f, -6.56764507e-02f, -1.33579105e-01f, -8.96369889e-02f,
  8.25897306e-02f, -5.89360036e-02f, 5.24220802e-03f, 2.42121108e-02f, -5.13666682e-03f, -1.52740870e-02f, 4.93509211e-02f, -3.51028405e-02f, 3.74131091e-02f, 1.75592788e-02f,
  -2.77684569e-01f, 6.16421923e-04f, 1.76939033e-02f, -5.50448783e-02f, 1.45867523e-02f, -1.79230478e-02f, 7.87587985e-02f, -5.20781465e-02f, 7.98979700e-02f, 3.54720056e-02f,
  -3.67866457e-02f, -5.13322391e-02f, -4.39980887e-02f, -6.21435903e-02f, 4.60841171e-02f, -2.10298151e-02f, 4.26746793e-02f, 6.87143952e-02f, -5.85708208e-02f, -4.33874689e-02f,
  -2.78832857e-02f, 2.38351300e-02f, 9.49682947e-03f, -6.88680485e-02f, -4.39443700e-02f, 1.14878705e-02f, -1.12801269e-01f, 4.18632440e-02f, -8.05333164e-03f, 7.83112496e-02f,
  -4.37905714e-02f, -2.92959780e-01f, 2.53960460e-01f, -1.32777169e-02f, 2.74360087e-02f, 2.50830442e-01f, 2.49145776e-01f, -7.34083354e-02f, -2.42273286e-01f, -1.32344216e-01f,
  1.09655075e-02f, 3.09751686e-02f, -3.59026976e-02f, 1.73932724e-02f, 1.44444615e-01f, -7.74523839e-02f, -5.67209208e-03f, 1.09952455e-02f, -1.74062490e-01f, -3.78590822e-02f,
  -7.73552619e-03f, -1.02160729e-01f, 3.10601771e-01f, -2.26026863e-01f, 1.00591063e-01f, -2.18084939e-02f, 2.86439415e-02f, 6.21727668e-02f, 8.49000216e-02f, 5.03789894e-02f,
  -9.69257131e-02f, -2.03689501e-01f, 8.97080898e-02f, 4.78123911e-02f, 4.17816006e-02f, 6.26621023e-02f, 1.03396140e-01f, 8.62497762e-02f, 2.10753805e-03f, 1.19424809e-03f,
  -2.61368579e-04f, -5.12947030e-02f, -4.11541425e-02f, -1.02981761e-01f, -1.58092882e-02f, -2.56297290e-02f, 4.47634123e-02f, 1.08251490e-01f, -5.52900415e-03f, 9.83801335e-02f,
  -6.64754771e-03f, 1.35784626e-01f, 1.28795207e-01f, 4.36371416e-02f, 6.70420453e-02f, -8.87238793e-03f, 1.23412609e-01f, 9.36581790e-02f, 2.59459391e-02f, -2.75551192e-02f,
  -3.07879765e-02f, -5.91348745e-02f, -3.59489536e-03f, -3.00452504e-02f, -1.13452680e-01f, 9.88493189e-02f, -4.89280820e-02f, 5.34795895e-02f, 1.94305014e-02f, -6.60844296e-02f,
  -2.14542840e-02f, -3.67103219e-02f, -1.09391309e-01f, 2.60678753e-02f, -3.19739394e-02f, -2.49340129e-03f, 6.41141832e-02f, 2.25951336e-02f, 2.17191689e-02f, 7.31821731e-02f,
  -4.48535830e-02f, 7.58725277e-04f, -1.16655594e-02f, 6.43775538e-02f, -4.18339483e-02f, -1.55388741e-02f, -8.53110850e-03f, 2.31986735e-02f, 3.02764261e-03f, 8.45319852e-02f,
  -1.20028839e-01f, -2.58655250e-01f, -4.18486297e-02f, 2.29735132e-02f, -1.04292696e-02f, 8.49724934e-03f, -2.18113661e-02f, 1.54557182e-02f, -4.68525402e-02f, -6.55617863e-02f,
  2.11903825e-02f, 6.10718094e-02f, -2.72316337e-02f, -5.37537271e-04f, 2.72086505e-02f, 7.18596508e-04f, 6.24857172e-02f, -4.60143127e-02f, 5.98496161e-02f, -3.94978859e-02f,
  3.75999585e-02f, -9.74481329e-02f, 1.03038855e-01f, 4.77026254e-02f, 7.77316242e-02f, 4.24431972e-02f, -8.96171778e-02f, -1.03485789e-02f, 5.81986010e-02f, -3.11152567e-03f,
  7.44531751e-02f, -1.16175644e-01f, -9.48477760e-02f, -2.58025974e-02f, -1.16235100e-01f, 4.00763482e-01f, 2.15442628e-01f, -1.69716865e-01f, 8.60991050e-03f, 9.40669887e-03f,
  1.92423314e-01f, -1.35212228e-01f, 1.97519079e-01f, 6.43489584e-02f, 4.15558547e-01f, 2.70110965e-01f, 4.37861755e-02f, 1.33992657e-01f, -6.60485998e-02f, -3.94458175e-02f,
  3.14948009e-03f, 4.37445492e-02f, -1.14957012e-01f, -2.93857634e-01f, -1.45732835e-01f, -2.38463104e-01f, -1.00352205e-01f, -3.30707952e-02f, -8.39637369e-02f, -5.50043881e-02f,
  1.38367340e-01f, -2.54314952e-02f, -1.32602006e-01f, -4.53895107e-02f, 7.93618709e-02f, -1.43708605e-02f, 7.55286068e-02f, -1.43436426e-02f, 1.13666831e-02f, 3.70045863e-02f,
  7.56009743e-02f, 1.29052952e-01f, -7.67430812e-02f, -3.51719707e-02f, -4.57491688e-02f, -6.59608319e-02f, 3.07246968e-02f, -3.39192785e-02f, -1.18340239e-01f, -1.18549848e-02f,
  -4.69566695e-02f, 1.19571395e-01f, 4.43146899e-02f, 1.06822424e-01f, -8.84404872e-04f, 1.87182147e-02f, -6.27400307e-03f, 3.57524939e-02f, 8.71215835e-02f, -5.35326228e-02f,
  2.37955898e-02f, -3.08004121e-04f, -1.33453861e-01f, -4.08160985e-02f, 4.26498614e-02f, -1.06600620e-01f, 8.28734934e-02f, -4.88351611e-03f, 3.00719426e-03f, 9.11836848e-02f,
  2.64992416e-02f, -2.37129238e-02f, 2.32357290e-02f, -1.17987767e-02f, -1.35265226e-02f, -1.48446158e-01f, 2.64530201e-02f, 1.09724246e-03f, -2.88334116e-02f, -1.05889328e-01f,
  2.66231149e-02f, 5.30029163e-02f, -3.74160148e-02f, 6.00845693e-03f, 1.94343273e-02f, 6.99347556e-02f, 2.74025202e-02f, -7.02914149e-02f, -3.92135493e-02f, -2.44462751e-02f,
  1.66150093e-01f, 2.52282666e-03f, -5.79906143e-02f, 2.39059539e-03f, -4.31965888e-02f, -8.75942931e-02f, 1.34065223e-03f, -6.34373212e-03f, -5.51891699e-03f, -3.32658663e-02f,
  1.84364021e-02f, -1.07114844e-01f, 6.46416843e-02f, 5.91445267e-02f, 4.67122160e-03f, 2.68643238e-02f, 2.65590847e-03f, -1.56296361e-02f, 5.02302637e-03f, 7.20809177e-02f,
  3.59426476e-02f, 6.81825355e-02f, -9.97133851e-02f, -6.06405437e-02f, -1.11632375e-02f, 6.10331148e-02f, -1.26941148e-02f, -5.12379669e-02f, -1.72250904e-02f, 6.80417120e-02f
};

// L0_fan_Wp_bar (Shape: 26 x 120)
const int L0_fan_Wp_bar_rows = 26;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -2.35630244e-01f, 3.39390665e-01f, 3.89717557e-02f, -2.11019307e-01f, 4.02857810e-02f, -2.58639485e-01f, -1.93262696e-01f, 1.57898724e-01f, 5.21635674e-02f, 1.77417979e-01f,
  -4.82702348e-03f, 1.52838781e-01f, -4.82982723e-03f, -1.75536543e-01f, -5.03998935e-01f, -2.97980428e-01f, -3.86894464e-01f, -1.29733711e-01f, -8.34201798e-02f, -1.05468608e-01f,
  -2.17616960e-01f, -2.94099569e-01f, -2.00497523e-01f, 8.51384848e-02f, 1.13301218e-01f, 1.14454143e-01f, -2.42832288e-01f, 1.56991467e-01f, -2.97386870e-02f, 7.57449344e-02f,
  1.62306845e-01f, 8.53291824e-02f, 2.06503764e-01f, 1.25088930e-01f, -6.35447055e-02f, -2.56759804e-02f, 5.88222034e-03f, -8.19042325e-03f, 8.34282264e-02f, -4.91164951e-03f,
  -5.73160276e-02f, -1.07743450e-01f, 4.49050441e-02f, 3.95972766e-02f, 3.93764265e-02f, 9.31440294e-02f, -2.49447823e-02f, 2.39855312e-02f, 1.15897655e-01f, -2.23783473e-03f,
  9.78231779e-04f, 8.23423192e-02f, -7.81787857e-02f, -5.83825335e-02f, -5.89968935e-02f, -3.23612392e-02f, -1.02943420e-01f, -6.02375995e-03f, -7.80006777e-03f, -4.84383665e-02f,
  -9.59978774e-02f, -9.43255350e-02f, -9.53947753e-03f, 1.96467474e-01f, -5.96657731e-02f, 9.99108255e-02f, -8.67099613e-02f, 1.25259897e-02f, -2.36939061e-02f, 1.93578433e-02f,
  7.68911764e-02f, 1.13615081e-01f, 2.83602457e-02f, -8.93803015e-02f, -1.07520573e-01f, 5.94081618e-02f, -6.87604547e-02f, -1.05137946e-02f, -4.48101759e-02f, 4.33399305e-02f,
  6.32549748e-02f, -2.87690237e-02f, 6.75717369e-02f, -1.87014807e-02f, 1.87350772e-02f, -6.51895441e-03f, -6.37940913e-02f, -1.18050743e-02f, 1.94201749e-02f, -1.09377600e-01f,
  3.06587443e-02f, -5.78384660e-02f, 8.74422789e-02f, 1.64501384e-01f, 6.78139403e-02f, -1.11815601e-03f, -1.07149847e-01f, 4.34187241e-02f, -1.06840963e-02f, -1.04632519e-01f,
  -9.10852626e-02f, -1.98954921e-02f, -3.95485610e-02f, 2.68461392e-03f, 7.50628188e-02f, -5.86268455e-02f, -3.44509371e-02f, 1.67920943e-02f, -5.50815724e-02f, 4.98689264e-02f,
  1.41176973e-02f, -6.56256899e-02f, -9.71688777e-02f, 2.42188689e-03f, -7.47054676e-03f, -2.80134566e-02f, 6.69446290e-02f, 5.66165261e-02f, -6.76056519e-02f, 3.24291922e-02f,
  -3.69320959e-01f, 2.23992690e-01f, -3.55788618e-01f, 6.04561120e-02f, -6.65843040e-02f, 3.36476624e-01f, 3.34718257e-01f, -1.35329336e-01f, -1.38738751e-01f, 3.18984449e-01f,
  3.40388298e-01f, -1.32335946e-01f, 2.46555403e-01f, 4.54739511e-01f, 4.14166972e-02f, 3.22018743e-01f, 2.74593532e-01f, 2.41383553e-01f, -1.07510202e-01f, -1.43025815e-01f,
  -1.00552350e-01f, 3.30901563e-01f, 1.66560978e-01f, -1.31484345e-01f, 1.61673948e-01f, -3.00566673e-01f, 5.18406928e-02f, -2.62168646e-01f, 1.76658690e-01f, 8.28107521e-02f,
  2.09673662e-02f, -2.42482811e-01f, -6.51427507e-02f, -2.07342908e-01f, -8.59631673e-02f, -9.26296562e-02f, -8.29478577e-02f, -9.14869481e-04f, -4.02994975e-02f, -8.32305774e-02f,
  2.83216778e-02f, -5.16394936e-02f, 4.99774702e-02f, -1.50797833e-02f, -3.93384248e-02f, -2.65163425e-02f, 5.19131199e-02f, 5.65666184e-02f, 9.12140608e-02f, -4.44803946e-03f,
  5.96388355e-02f, -3.60960024e-04f, 1.23688474e-01f, 8.71532038e-02f, 2.31198445e-02f, 6.49925545e-02f, 5.01157455e-02f, 3.11734490e-02f, 5.02995811e-02f, -1.00483117e-03f,
  1.59815624e-02f, 1.72717571e-02f, 2.46083960e-02f, 1.90666690e-02f, 2.37485617e-02f, 9.09840092e-02f, 5.27741611e-02f, 8.58613178e-02f, -1.34341955e-01f, 8.74619111e-02f,
  2.08008359e-03f, 2.27546925e-03f, -3.22596021e-02f, -1.56321749e-02f, 7.29951039e-02f, -1.73744019e-02f, -1.21710286e-01f, 1.44014433e-02f, 2.83219833e-02f, 8.06271657e-02f,
  -4.46319543e-02f, -8.03954974e-02f, 7.42572546e-02f, 1.05205914e-02f, 1.73861859e-04f, -5.61078414e-02f, 1.88685706e-04f, 3.87578569e-02f, -2.31568012e-02f, -7.36722797e-02f,
  -3.01803909e-02f, -2.73129225e-01f, 5.07680094e-03f, -1.23954788e-02f, -3.75159904e-02f, 2.74118017e-02f, -5.07381484e-02f, 5.71225211e-03f, -1.65454168e-02f, -1.25340551e-01f,
  -6.46420196e-02f, 1.99875142e-02f, -1.18229412e-01f, -3.75390612e-02f, 5.18745966e-02f, 8.51082429e-03f, 3.91779654e-03f, -6.13669492e-02f, 4.02894011e-03f, -5.56738190e-02f,
  -4.08292599e-02f, -4.98171300e-02f, -6.00891712e-04f, 3.82445124e-03f, 2.99539454e-02f, 7.61124566e-02f, -1.02444619e-01f, -9.03060958e-02f, 4.80931886e-02f, 6.84629083e-02f,
  1.90262109e-01f, 3.02759767e-01f, -1.52640492e-01f, 2.92082101e-01f, 1.96302861e-01f, 4.45141554e-01f, 4.36685264e-01f, 1.40955314e-01f, 4.30731922e-01f, 1.96785212e-01f,
  -4.90621291e-02f, 3.51976715e-02f, -1.43994957e-01f, 1.80502072e-01f, 6.30570427e-02f, 7.81287476e-02f, 3.33870053e-01f, 1.85021818e-01f, -1.17623452e-02f, 2.30016202e-01f,
  1.38641940e-02f, 1.74643651e-01f, -3.17910671e-01f, -1.02443308e-01f, 5.53835221e-02f, -1.93396777e-01f, -2.78025955e-01f, -2.95493931e-01f, -2.50916451e-01f, -1.21716544e-01f,
  1.05562851e-01f, 8.73241276e-02f, -6.63143247e-02f, -5.50583899e-02f, 1.58012123e-03f, 1.62803959e-02f, -1.29264593e-01f, -7.81868324e-02f, -1.81072921e-01f, 6.06234791e-03f,
  3.86864990e-02f, -4.01755199e-02f, 9.76321027e-02f, -5.75143993e-02f, 1.59487888e-01f, 4.97558899e-02f, 4.65228455e-03f, -6.77268654e-02f, -8.79705884e-03f, -4.05183658e-02f,
  5.86656518e-02f, 4.43644263e-02f, 8.77185091e-02f, 3.86557239e-03f, -1.40899941e-01f, 1.24490028e-02f, 5.12948893e-02f, -4.92739752e-02f, 3.78565006e-02f, 3.75923999e-02f,
  -1.06519923e-01f, 1.18331254e-01f, 5.79556301e-02f, 2.30937824e-03f, 8.43152031e-03f, -6.32237121e-02f, 6.19652085e-02f, 2.78925151e-02f, 1.01755030e-01f, 9.80293304e-02f,
  9.84025374e-02f, -9.65504255e-03f, 5.58966696e-02f, 4.97403517e-02f, 6.71633407e-02f, 8.84084776e-02f, -4.28312607e-02f, 3.75809297e-02f, 1.06863715e-01f, -2.56589614e-02f,
  -3.36859189e-02f, 2.15534735e-02f, -9.30586010e-02f, -9.18768048e-02f, 5.34151569e-02f, -7.84045085e-02f, -3.80270630e-02f, -7.20841214e-02f, 8.25559348e-03f, 7.72325248e-02f,
  2.54794002e-01f, 2.10618600e-01f, 6.61426187e-02f, -1.52334580e-02f, -8.68131872e-03f, 3.84090953e-02f, 6.06622733e-02f, 6.71523064e-02f, 4.92732376e-02f, 3.50472257e-02f,
  3.09843887e-02f, 5.55649325e-02f, 1.48277536e-01f, -8.53751376e-02f, 5.42257586e-03f, 1.41059980e-01f, 9.37073305e-02f, -3.24332155e-02f, 5.69866747e-02f, -1.01271808e-01f,
  -3.57425474e-02f, 1.18601203e-01f, 8.70742574e-02f, 1.22989818e-01f, 2.36479472e-02f, 6.90061366e-03f, 1.07441343e-01f, -8.96892101e-02f, -5.61884567e-02f, 6.21015318e-02f,
  1.45712629e-01f, -2.83092499e-01f, 2.17137281e-02f, -1.57303587e-01f, 7.41212294e-02f, -2.16242559e-02f, 1.44074500e-01f, -3.87781382e-01f, -2.94553846e-01f, -3.41478556e-01f,
  -9.11934301e-02f, 3.80903715e-03f, 3.61776918e-01f, -2.78599709e-01f, 5.98808527e-01f, 1.82981595e-01f, -1.33918643e-01f, -8.09934959e-02f, -9.20482054e-02f, -1.75747439e-01f,
  -9.13580507e-02f, -2.80751258e-01f, 1.85899153e-01f, -3.52849811e-01f, -1.80949166e-01f, -1.72229797e-01f, -2.08173729e-02f, 8.81472901e-02f, -2.63272464e-01f, 4.54037227e-02f,
  1.58666342e-01f, -4.26433645e-02f, 6.00577109e-02f, 4.21226434e-02f, 2.40379125e-02f, 1.12669475e-01f, 1.92309693e-02f, 1.69395000e-01f, 1.20743580e-01f, 1.81495515e-03f,
  5.61436601e-02f, -4.42745775e-04f, -1.28378510e-01f, 6.30266517e-02f, -1.39565289e-01f, -1.10559568e-01f, 3.44136730e-02f, -1.91854369e-02f, -2.88524907e-02f, -3.65233906e-02f,
  -5.73344948e-03f, 6.96218060e-03f, -8.17880109e-02f, -1.08573407e-01f, -3.93915065e-02f, -4.95360978e-02f, 2.33527478e-02f, 7.55800009e-02f, -3.46625075e-02f, -7.90029950e-03f,
  -2.14438438e-01f, 9.64197982e-03f, 7.17195421e-02f, 3.09695047e-03f, 3.17320079e-02f, -2.88591813e-03f, -7.67268240e-03f, -4.74791508e-03f, -5.33631034e-02f, -7.51042040e-03f,
  -5.57815935e-03f, -1.71591211e-02f, -7.41784573e-02f, -2.57412046e-02f, -6.09301031e-02f, 6.28589420e-03f, 1.02402568e-02f, -4.88301143e-02f, -2.49550976e-02f, 7.02142343e-02f,
  -2.48210225e-03f, 4.03048657e-02f, 2.86760274e-03f, 3.56367715e-02f, -1.11451931e-02f, 6.57129940e-03f, -9.64220613e-02f, -8.93086344e-02f, 3.98784652e-02f, 9.75812301e-02f,
  6.97339233e-03f, -1.05579846e-01f, -1.62780844e-02f, 8.04527923e-02f, 1.69116631e-02f, 4.56420556e-02f, -4.54751626e-02f, -1.93924800e-01f, -4.89286594e-02f, 3.05424966e-02f,
  -1.29140735e-01f, -8.56933370e-03f, -3.71213481e-02f, -8.18426535e-02f, -9.13401321e-02f, -5.87901063e-02f, -4.94953841e-02f, 4.81634922e-02f, -4.62279469e-02f, -9.31789577e-02f,
  -9.68576316e-03f, 3.33777405e-02f, 4.71898504e-02f, -7.50039667e-02f, -1.80162638e-01f, 1.29078165e-01f, 8.81844237e-02f, -6.88739643e-02f, 3.24345119e-02f, 3.01077850e-02f,
  -7.02035487e-01f, 3.44286323e-01f, -9.22090784e-02f, -3.97859126e-01f, 5.08603267e-02f, -1.43841088e-01f, -2.10311651e-01f, 2.53327135e-02f, -9.07445997e-02f, 1.38870371e-03f,
  -1.03995956e-01f, -8.62011164e-02f, 3.21342200e-01f, -2.46170592e-02f, -4.35026847e-02f, 2.74868190e-01f, -2.73251176e-01f, -1.97021380e-01f, 5.19473292e-02f, -1.37548223e-01f,
  -1.94846857e-02f, 2.53145657e-02f, 4.32582274e-02f, 1.49919629e-01f, -1.46491155e-01f, -1.40548289e-01f, -1.87640578e-01f, 1.20550260e-01f, -2.69837379e-01f, 3.05503532e-02f,
  -2.54653841e-01f, -2.63195843e-01f, -4.62003350e-02f, -2.27406770e-01f, -1.83186814e-01f, -9.63395238e-02f, -1.48988798e-01f, 1.78995766e-02f, -5.36359176e-02f, -2.62057763e-02f,
  2.41236258e-02f, 7.47329183e-03f, -4.06113155e-02f, 2.97037251e-02f, -1.59508139e-02f, -4.77349013e-02f, 6.34407252e-02f, -1.63329821e-02f, 5.40352091e-02f, 3.73417735e-02f,
  7.94546381e-02f, 4.83627319e-02f, -5.92979565e-02f, -1.48051753e-04f, 5.49777923e-03f, 2.21216474e-02f, -4.51102965e-02f, 4.04418372e-02f, -8.79539400e-02f, -6.28914535e-02f,
  5.01769930e-02f, -2.25719381e-02f, 4.80685085e-02f, -1.16538992e-02f, 5.95194437e-02f, -4.49384898e-02f, -5.22107221e-02f, -3.45229730e-02f, -9.68845636e-02f, 3.02783512e-02f,
  4.91162017e-03f, -4.43814807e-02f, 3.22899595e-02f, -5.68585135e-02f, -6.96074292e-02f, -2.52990350e-02f, -5.09768771e-03f, 5.73047344e-03f, 1.85153633e-03f, -5.84182739e-02f,
  -5.42304553e-02f, -2.38798559e-02f, 4.27382020e-03f, -7.22237453e-02f, -4.77397740e-02f, 1.02667296e-02f, -4.04490940e-02f, -1.01749338e-02f, 1.39818536e-02f, 9.05346051e-02f,
  -4.65060979e-01f, -4.45820600e-01f, -2.37339810e-02f, -6.42030463e-02f, -4.15618494e-02f, 7.90847372e-03f, 2.91640423e-02f, -6.88699111e-02f, -1.17484562e-01f, -2.29013134e-02f,
  -1.03620850e-01f, -6.80115297e-02f, -4.78074923e-02f, -1.32817412e-02f, 3.79795730e-02f, 7.19210040e-03f, -3.52947526e-02f, -3.38756256e-02f, -1.66233078e-01f, -7.15998635e-02f,
  -5.97953685e-02f, -8.66473019e-02f, 2.01064348e-02f, -5.95918372e-02f, -4.01783846e-02f, -1.35540381e-01f, -5.81623204e-02f, -5.18632270e-02f, -3.56491208e-02f, 5.15497522e-03f,
  9.96503830e-02f, 3.79381806e-01f, 9.91430432e-02f, -2.75689453e-01f, -1.63140982e-01f, -2.03109875e-01f, -3.01095933e-01f, -8.22045933e-03f, 1.33974344e-01f, 1.61729939e-02f,
  -2.76775301e-01f, 3.43337357e-01f, 6.45344704e-02f, -2.05043614e-01f, -1.54924735e-01f, 6.15737459e-04f, -2.53312349e-01f, -1.96304858e-01f, 8.23147967e-02f, -1.77824453e-01f,
  -6.24808334e-02f, -4.25157070e-01f, -1.80180162e-01f, -2.35902414e-01f, -1.64395943e-01f, 1.43208764e-02f, -1.59329355e-01f, -1.01512805e-01f, -1.84199631e-01f, 4.03544232e-02f,
  -8.03198665e-02f, -2.01864317e-01f, 5.30038774e-02f, 7.12664574e-02f, -1.21027455e-01f, 2.10423172e-02f, 1.56947747e-02f, -9.02109146e-02f, -5.50208762e-02f, 9.85058546e-02f,
  1.14326730e-01f, 4.20709029e-02f, -6.10744171e-02f, 7.12630451e-02f, 3.08698304e-02f, 9.04501081e-02f, -1.26717202e-02f, 9.46688280e-02f, -1.52950262e-04f, 1.23065799e-01f,
  2.90215705e-02f, 1.46434888e-01f, -2.32295394e-02f, 3.77486944e-02f, 9.77014005e-03f, -4.05301563e-02f, 4.95065749e-02f, 5.57260886e-02f, 1.07166655e-01f, -5.89813525e-03f,
  -1.61603943e-01f, -1.06681526e-01f, -1.03347756e-01f, -6.92592636e-02f, -9.46278423e-02f, 1.21998573e-02f, 5.24999164e-02f, -3.57658751e-02f, 6.70984313e-02f, -5.06005324e-02f,
  -4.58918400e-02f, 3.59751917e-02f, -1.06096238e-01f, 3.10777947e-02f, -4.52232751e-04f, 1.46242408e-02f, -1.96354222e-02f, 7.41818622e-02f, 1.09076783e-01f, 2.84744613e-02f,
  -3.14538106e-02f, -1.07423060e-01f, -6.95718378e-02f, -2.20610783e-03f, -8.50863233e-02f, 2.44256239e-02f, 1.42544344e-01f, 3.81455123e-02f, -6.04720600e-02f, -2.67475396e-02f,
  -1.58451557e-01f, -2.84312695e-01f, -3.37386578e-02f, 3.46566178e-02f, -2.62734462e-02f, 6.43358901e-02f, -1.00821540e-01f, 1.34212166e-01f, -1.68617256e-02f, -6.84616044e-02f,
  4.01360802e-02f, -3.29987593e-02f, 9.14597698e-03f, 2.18355898e-02f, -7.31137246e-02f, 6.05843849e-02f, -1.42702684e-01f, 7.34514818e-02f, -8.68831575e-02f, 1.48451030e-01f,
  -5.08324802e-03f, -4.46218587e-02f, 3.50412615e-02f, -7.75451167e-03f, -6.42244564e-03f, 1.17899990e-03f, 5.24423569e-02f, 1.29829630e-01f, 2.12582164e-02f, -7.20530674e-02f,
  -4.91610616e-01f, 6.00169264e-02f, -1.82090282e-01f, -1.46930844e-01f, 3.29821669e-02f, 3.09768289e-01f, 5.21659153e-03f, -6.37231469e-02f, -3.50694507e-01f, 2.41550282e-01f,
  7.12850094e-02f, -3.36228639e-01f, -5.00486121e-02f, -5.19728772e-02f, -4.03677046e-01f, -1.54350728e-01f, 1.24548979e-01f, 1.15850896e-01f, -1.82422772e-01f, 7.33820349e-02f,
  -1.43318966e-01f, 9.60797891e-02f, -5.04008532e-02f, 1.22795492e-01f, -2.83481255e-02f, 7.35620484e-02f, 2.37472430e-01f, -2.88364594e-03f, 2.43574828e-01f, -1.09412372e-01f,
  8.13090801e-02f, -1.88882276e-01f, 1.99538823e-02f, -2.31486782e-02f, 1.81352943e-01f, 2.02599645e-01f, 1.64751977e-01f, -8.09241384e-02f, -8.04118887e-02f, -9.31284055e-02f,
  -4.19692546e-02f, -9.94014516e-02f, -6.08685575e-02f, -1.32426158e-01f, -1.14587210e-01f, -5.81639744e-02f, -4.54644635e-02f, -1.29318805e-02f, -1.51536672e-03f, -1.58199266e-01f,
  -9.99855101e-02f, -6.72040582e-02f, 4.21430171e-02f, 8.58954340e-03f, -8.12218934e-02f, -9.30012763e-02f, 6.21234290e-02f, 4.31385487e-02f, 3.80125083e-02f, -4.72224019e-02f,
  3.11941151e-02f, 9.52171832e-02f, -1.26901350e-03f, -3.29083391e-02f, -8.99887905e-02f, 4.71347757e-02f, -5.07208891e-02f, 7.29950592e-02f, -1.49846345e-01f, -2.18458567e-02f,
  1.25685055e-02f, -3.03176586e-02f, -1.04915030e-01f, 8.08075741e-02f, 1.52612356e-02f, 3.64896096e-02f, 2.65642628e-02f, -1.04564885e-02f, 1.24178836e-02f, 9.18076560e-02f,
  -8.69239196e-02f, 4.01887856e-03f, -1.00411968e-02f, 1.11190721e-01f, 5.68236075e-02f, -1.45661488e-01f, -5.55838533e-02f, -1.32619161e-02f, 4.23801579e-02f, 5.24163619e-02f,
  2.25165382e-01f, 7.74758086e-02f, -6.46500615e-03f, 3.94242769e-03f, 3.65206115e-02f, 8.62796083e-02f, -3.24360542e-02f, -2.96195224e-03f, 5.81036322e-02f, -3.15629616e-02f,
  1.28812224e-01f, 6.53874576e-02f, 1.01805277e-01f, -9.15893465e-02f, -1.02314982e-03f, 1.06671385e-01f, 2.14446392e-02f, -4.41774614e-02f, 2.00773943e-02f, 4.10720482e-02f,
  8.36308450e-02f, 1.06639184e-01f, -1.08474500e-01f, 6.83531677e-03f, 5.10758646e-02f, 1.03106385e-03f, 1.74126588e-02f, 2.61981767e-02f, 3.58652398e-02f, 1.10269906e-02f,
  -3.52520287e-01f, 7.90724382e-02f, -1.26111001e-01f, -4.40112114e-01f, 1.16425455e-01f, -2.77582794e-01f, -2.60665089e-01f, 1.14131264e-01f, -1.40915409e-01f, 2.26367727e-01f,
  -3.18235569e-02f, -2.00343296e-01f, 1.67314827e-01f, -4.22716945e-01f, -4.23776567e-01f, -2.05219135e-01f, -4.95140672e-01f, -1.93329006e-01f, -9.86078605e-02f, -1.14600390e-01f,
  -1.57468393e-01f, -2.34226793e-01f, -3.35366666e-01f, 1.23432346e-01f, -1.52813196e-01f, 8.45087543e-02f, 1.80516332e-01f, 1.05691530e-01f, -5.89810759e-02f, -1.29399091e-01f,
  -4.14898656e-02f, 2.09562376e-01f, 4.01361547e-02f, -3.66927609e-02f, -1.05249779e-02f, 3.58218849e-02f, -1.97735103e-03f, -5.26448563e-02f, -1.58006810e-02f, -7.95056671e-02f,
  2.55904105e-02f, 1.11803622e-03f, -8.97989720e-02f, -4.74003404e-02f, 5.80905937e-02f, 6.97480589e-02f, 2.73967683e-02f, -2.86569297e-02f, -3.85845974e-02f, -1.17598534e-01f,
  -6.63167238e-02f, -1.44887939e-02f, -1.67525858e-02f, -4.39069495e-02f, -4.57654372e-02f, 2.48615481e-02f, -1.87199786e-02f, 6.72347704e-03f, 4.75027412e-02f, 3.32266763e-02f,
  9.15059224e-02f, -1.21477584e-03f, -8.84223264e-03f, -8.47068876e-02f, 2.50728764e-02f, 6.23984970e-02f, -5.38760889e-03f, 2.21426692e-02f, 1.91020276e-02f, -1.65198464e-02f,
  3.78800109e-02f, -3.98828760e-02f, -4.62673185e-03f, -3.16611578e-04f, -4.18180376e-02f, -4.19906229e-02f, 1.53881265e-03f, 4.71685678e-02f, -1.17664374e-01f, -2.34713480e-02f,
  2.57262606e-02f, 2.61388235e-02f, 8.82176608e-02f, 1.55070648e-02f, -7.21008107e-02f, 6.17169403e-02f, 7.69294845e-03f, -3.69248986e-02f, 1.20411636e-02f, -5.43189794e-02f,
  2.44151577e-02f, 1.24038219e-01f, 5.96931344e-03f, -1.80322155e-02f, 3.99957597e-02f, -1.81362983e-02f, -6.52037561e-02f, -2.90241018e-02f, -2.68854164e-02f, -1.00936890e-02f,
  -1.69580188e-02f, -4.53362279e-02f, 1.60882734e-02f, 7.88433943e-03f, -3.48325185e-02f, -4.81254980e-02f, 4.78355773e-02f, 2.67757364e-02f, 4.80610318e-02f, 1.71821509e-02f,
  1.06686115e-01f, 6.11992329e-02f, -1.88503657e-02f, -1.81983523e-02f, 3.02233081e-02f, 5.67632765e-02f, 4.51959716e-03f, -9.01426096e-03f, 7.57983997e-02f, 9.22061950e-02f,
  -1.05007157e-01f, 1.72713488e-01f, 1.17731549e-01f, 4.48908269e-01f, -6.41365126e-02f, -3.49854827e-01f, -1.78170964e-01f, 1.93150535e-01f, -1.10471092e-01f, -7.74352849e-02f,
  2.24787414e-01f, -4.68240939e-02f, 8.09672996e-02f, 3.65127176e-01f, 2.78726846e-01f, 8.49475488e-02f, 1.94175199e-01f, -9.09068361e-02f, 6.02200702e-02f, 1.44322008e-01f,
  2.18245476e-01f, 1.35662258e-01f, 2.96620041e-01f, 2.17310656e-02f, 7.50845904e-03f, 1.68420181e-01f, 3.70089114e-01f, 4.65676226e-02f, 2.79051632e-01f, -3.29149626e-02f,
  -1.57459959e-01f, 6.40518144e-02f, 1.01632280e-02f, -1.88818827e-01f, 9.39362645e-02f, -4.41425964e-02f, -6.52638599e-02f, 1.62528642e-02f, 3.38864475e-02f, 7.20054060e-02f,
  -1.02753833e-01f, -4.48643677e-02f, -1.96309499e-02f, -4.32875492e-02f, -3.53507549e-02f, 1.76101271e-02f, -4.41060141e-02f, -1.62351374e-02f, -5.31963855e-02f, -1.60489641e-02f,
  1.69514064e-02f, 1.53652336e-02f, 2.92515941e-02f, 1.61807165e-02f, 8.71398449e-02f, -2.85750348e-02f, -5.87611981e-02f, -5.00505008e-02f, 5.12872636e-02f, 5.08784875e-02f,
  -2.31947973e-02f, -1.87675972e-02f, 3.11121857e-03f, 4.07063328e-02f, 5.19258082e-02f, 5.24433181e-02f, -1.31435851e-02f, 5.43953553e-02f, 6.47382960e-02f, 4.63930443e-02f,
  2.66960617e-02f, 5.78029491e-02f, -6.83826655e-02f, 1.43714370e-02f, 5.57596348e-02f, -2.30718907e-02f, 1.19217001e-02f, -1.42614767e-02f, -5.04861511e-02f, 9.56068337e-02f,
  -7.17978701e-02f, 1.19692143e-02f, -2.86542941e-02f, -1.10361554e-01f, -4.76593375e-02f, 1.30247399e-01f, 4.21867967e-02f, -1.92482129e-03f, 6.49954230e-02f, 5.85564598e-02f,
  5.42229116e-02f, 3.99019390e-01f, -4.23806086e-02f, -1.27680153e-01f, 4.07064408e-02f, 4.22624871e-02f, 1.95963960e-02f, 7.87394643e-02f, 4.10190523e-02f, 6.09710030e-02f,
  5.48935458e-02f, -5.03148697e-02f, -4.66863904e-03f, -4.24842611e-02f, 1.30870007e-02f, 7.77704865e-02f, 9.49511603e-02f, 1.92170478e-02f, 1.14774093e-01f, 1.00175925e-01f,
  1.03074148e-01f, -5.11443876e-02f, -1.47158671e-02f, -1.32947341e-01f, 3.82550135e-02f, -1.05649410e-02f, -7.04174116e-02f, -1.26869485e-01f, 5.72864972e-02f, -4.79111634e-03f,
  -1.90569296e-01f, 3.96251939e-02f, 2.02879846e-01f, 1.76838115e-01f, -3.27176690e-01f, -1.83803085e-02f, 4.59606886e-01f, -1.67505190e-01f, 1.41976655e-01f, 3.00241679e-01f,
  5.42246662e-02f, 1.05590940e-01f, 2.65102863e-01f, 2.28233561e-01f, -4.29846197e-01f, 1.36877492e-01f, 1.59884498e-01f, 2.96439469e-01f, -6.87732249e-02f, -8.31000879e-02f,
  -2.36020029e-01f, -2.29935482e-01f, -7.92700012e-05f, -2.30602369e-01f, -7.31946528e-02f, 1.23402877e-02f, -1.91775903e-01f, -1.49423942e-01f, 1.99875538e-03f, -1.34346902e-01f,
  -3.76959324e-01f, -1.08821578e-02f, -8.45023524e-03f, -6.88768476e-02f, -1.00760706e-01f, 1.05720595e-01f, 2.75383312e-02f, 9.56666004e-03f, -1.72944993e-01f, 2.30914857e-02f,
  6.21707849e-02f, -8.69238824e-02f, -6.64725080e-02f, -6.93251640e-02f, -7.41458982e-02f, -8.82803202e-02f, -2.85601653e-02f, 2.56810151e-02f, -1.12843223e-01f, -1.08558089e-02f,
  1.55321613e-01f, -7.17548700e-03f, -6.01425543e-02f, 4.76233810e-02f, -1.95169941e-01f, 1.88691877e-02f, 1.08366512e-01f, -2.02029515e-02f, -1.96498744e-02f, -1.16883479e-01f,
  2.58328742e-03f, -3.54985148e-02f, 6.38523549e-02f, 1.75041368e-03f, 3.13057145e-03f, 5.25928512e-02f, 4.16408218e-02f, -7.61544555e-02f, 8.93516913e-02f, -8.69599357e-02f,
  4.74674180e-02f, -2.35441439e-02f, -2.31719781e-02f, 6.43268749e-02f, 7.53602087e-02f, 8.98381993e-02f, 9.81446207e-02f, -4.18512896e-02f, -4.04425152e-03f, -2.81276871e-02f,
  3.96807641e-02f, 9.88253043e-04f, -6.25699479e-03f, -1.92221738e-02f, 1.67689025e-02f, -6.47430541e-04f, -9.54416096e-02f, 8.06824714e-02f, -3.82379070e-02f, -1.90253034e-01f,
  -5.35369456e-01f, -3.63930911e-01f, -1.81589238e-02f, -4.38557044e-02f, -9.43272747e-03f, -8.03731605e-02f, -1.07630827e-02f, -1.16251551e-01f, -2.13458762e-01f, 4.10901196e-02f,
  -4.73628864e-02f, 1.34274185e-01f, -2.63095088e-02f, 6.71934932e-02f, 2.96775103e-02f, -1.30069494e-01f, -1.90479346e-02f, -1.16095366e-02f, -1.98903114e-01f, -4.14189510e-02f,
  -8.96585509e-02f, 9.60191805e-03f, -6.25044256e-02f, -4.58229035e-02f, 4.54363925e-03f, -6.72616884e-02f, -7.31411725e-02f, 7.25834491e-03f, -1.33709282e-01f, 1.13374656e-02f,
  -3.53629738e-01f, 1.58998638e-01f, -3.51888984e-01f, 8.38179886e-02f, -2.72338420e-01f, -4.09529179e-01f, -1.11132778e-01f, -7.35316575e-02f, -2.55392939e-02f, 3.12570035e-01f,
  2.88678497e-01f, -1.43434167e-01f, 3.58461767e-01f, 2.84287423e-01f, -2.34512210e-01f, 4.49726224e-01f, -3.57176736e-02f, -1.23445047e-02f, 9.30713117e-02f, -1.12638250e-02f,
  1.15062790e-02f, 2.48565495e-01f, 2.43115008e-01f, 1.96980517e-02f, -8.38785544e-02f, -6.73362054e-03f, 2.82935053e-01f, -7.42784352e-04f, -8.09216797e-02f, -2.52994918e-03f,
  -4.74127606e-02f, 3.09793502e-01f, -3.47225629e-02f, -3.44848037e-02f, 4.03251424e-02f, -1.15911420e-02f, -3.50369811e-02f, 1.96417398e-03f, 5.13315573e-02f, -3.27898376e-02f,
  -5.48294894e-02f, 7.36365393e-02f, -3.37203108e-02f, -5.09706028e-02f, -1.34966433e-01f, -4.06052433e-02f, 1.24585198e-03f, -1.28541961e-01f, 6.17733002e-02f, 3.95894535e-02f,
  -7.40858763e-02f, -2.79874378e-03f, 7.82509074e-02f, 1.39237806e-01f, -4.25987393e-02f, 2.91795526e-02f, -4.03554291e-02f, -6.97916076e-02f, -5.85431196e-02f, -1.35632440e-01f,
  -3.51483375e-02f, 2.71154307e-02f, -2.72975639e-02f, -3.06733549e-02f, 2.65586171e-02f, 8.60686377e-02f, -2.56833769e-02f, 7.89272636e-02f, -1.11335330e-01f, 5.20506166e-02f,
  -4.06551361e-02f, -8.33665729e-02f, 3.13096270e-02f, -5.42923473e-02f, 1.20362276e-02f, 8.74079950e-03f, -3.30469310e-02f, -9.68098291e-04f, -1.95592921e-02f, -5.49331354e-03f,
  1.08279422e-01f, -1.02719434e-01f, 2.14104615e-02f, 7.57419392e-02f, -1.75296720e-02f, 4.10396606e-02f, 5.40513955e-02f, 3.40833366e-02f, 7.08076134e-02f, -1.19585849e-01f,
  7.12382421e-02f, 1.74995571e-01f, 8.55249539e-02f, 9.55213979e-02f, 3.37897092e-02f, -1.80223718e-01f, 7.79836699e-02f, -6.29617646e-02f, 6.95554763e-02f, -5.06345704e-02f,
  -9.03825238e-02f, -2.50581596e-02f, -4.62321192e-02f, 1.62071530e-02f, -4.79249470e-02f, -4.25498262e-02f, 1.04971081e-01f, -7.42751285e-02f, 8.58680308e-02f, 4.67702225e-02f,
  7.52511853e-03f, -7.32770748e-03f, 9.04243588e-02f, 9.98733342e-02f, 7.31767640e-02f, 1.01963496e-02f, -1.88674912e-01f, -8.72748252e-03f, -7.29030743e-02f, 1.50745567e-02f,
  -5.89546204e-01f, 2.59582400e-01f, 1.28923655e-01f, -3.88046652e-02f, -6.74923882e-02f, 4.27502692e-01f, 2.10154057e-01f, 2.42013950e-02f, 2.80344728e-02f, 3.20465297e-01f,
  1.59664303e-01f, -1.38806090e-01f, 1.87882826e-01f, 2.45153248e-01f, 5.44855632e-02f, 3.33783358e-01f, 2.99170554e-01f, 9.11164656e-02f, -7.32864514e-02f, -1.31658226e-01f,
  -1.22272521e-01f, 4.81381379e-02f, 1.51750579e-01f, -4.65123653e-02f, -4.20322781e-03f, -1.77217767e-01f, -7.93059319e-02f, -1.74588844e-01f, -1.14961155e-02f, -1.70624610e-02f,
  -6.64103851e-02f, -1.55275583e-01f, 4.92269285e-02f, 9.58246291e-02f, 7.82932714e-02f, -4.31240834e-02f, -6.89265355e-02f, -7.74642751e-02f, -7.67892823e-02f, 5.97447827e-02f,
  -5.02101108e-02f, -9.01993811e-02f, 1.03725446e-02f, -2.65189577e-02f, 8.56440328e-03f, 3.43096703e-02f, 8.59642401e-02f, 1.64209574e-01f, 1.12444118e-01f, 6.69716448e-02f,
  7.98240602e-02f, 6.61531538e-02f, 9.07226577e-02f, 4.22586240e-02f, 8.99229497e-02f, 1.06669320e-02f, 1.43180182e-02f, 4.14401367e-02f, 1.01865269e-01f, 4.47042137e-02f,
  -5.03108725e-02f, -1.10813066e-01f, 5.40819168e-02f, -2.33312510e-02f, 6.71280399e-02f, -5.91323897e-02f, -3.73463407e-02f, -8.09461698e-02f, -2.56016720e-02f, 7.38693625e-02f,
  2.98386104e-02f, -4.34961915e-02f, -4.48674932e-02f, 4.85960431e-02f, -5.13245575e-02f, -3.46884355e-02f, -1.60326753e-02f, -9.22523513e-02f, 5.53300269e-02f, 1.66138206e-02f,
  -5.83566353e-02f, 4.35555652e-02f, 7.03094080e-02f, 8.05767905e-03f, -9.77253541e-03f, 1.29968571e-02f, 2.71045119e-02f, 2.33358657e-03f, 5.89965396e-02f, -2.10975241e-02f,
  -2.10688673e-02f, -1.13576382e-01f, 5.54725155e-02f, 2.97384374e-02f, -2.05787532e-02f, 2.67131180e-02f, -4.06693518e-02f, 5.05243912e-02f, 5.64579219e-02f, 3.64419259e-02f,
  -3.01385042e-03f, -4.46074121e-02f, -9.35373828e-02f, -5.28267734e-02f, -6.58569783e-02f, 1.75166458e-01f, -2.33330727e-02f, 1.42187830e-02f, 2.40220372e-02f, -2.61592213e-02f,
  8.54483992e-03f, -6.77138008e-03f, -4.94191349e-02f, 6.94304332e-03f, 9.77318734e-02f, 4.18414809e-02f, -8.54611546e-02f, -6.96858913e-02f, 2.20623445e-02f, 8.82027671e-02f,
  5.72249889e-01f, -3.80855381e-01f, 6.09657057e-02f, 3.69465679e-01f, 2.67892778e-01f, 8.47370774e-02f, 1.98949352e-01f, 2.77414322e-01f, 4.12071258e-01f, -3.39693278e-01f,
  5.99813014e-02f, -2.86099911e-01f, -2.68067509e-01f, 2.20674351e-02f, 2.23772407e-01f, -1.44785181e-01f, 1.58685550e-01f, -1.73137859e-01f, 2.50590354e-01f, 1.14667993e-02f,
  2.11386204e-01f, 8.70319977e-02f, 4.78874035e-02f, -1.31019518e-01f, 1.04203254e-01f, 4.53974418e-02f, -8.69231820e-02f, -1.20927818e-01f, -8.33649039e-02f, 2.54358966e-02f,
  1.82245355e-02f, 1.44651666e-01f, 1.07277311e-01f, -1.37237504e-01f, -1.73706152e-02f, -5.59114888e-02f, -1.15252800e-01f, -2.60665510e-02f, 1.24086566e-01f, 2.23183427e-02f,
  -1.44102558e-01f, -3.07601020e-02f, 5.11129312e-02f, 1.25920046e-02f, 1.47156060e-01f, 6.03549667e-02f, 3.05668991e-02f, 9.69807710e-03f, -1.03375874e-02f, 2.63701193e-03f,
  -6.65409118e-03f, 1.97759783e-03f, 6.19160123e-02f, -7.44671524e-02f, 4.21734303e-02f, 6.08454943e-02f, 5.99639267e-02f, -5.94360083e-02f, -9.26134065e-02f, 1.79117873e-01f,
  6.99285567e-02f, 2.70184614e-02f, -1.62973423e-02f, -9.75511596e-03f, -6.61570653e-02f, 5.84821180e-02f, -7.41070285e-02f, -6.91220164e-02f, -6.44387975e-02f, -4.74317819e-02f,
  8.73489752e-02f, 9.54073761e-03f, 1.86662506e-02f, 1.93373058e-02f, 5.06545566e-02f, 3.87846231e-02f, -5.19182198e-02f, -7.73730800e-02f, 1.19932531e-03f, 1.07952677e-01f,
  3.99113409e-02f, 1.12294229e-02f, -1.47354743e-02f, -3.64413932e-02f, -4.71943170e-02f, -4.11764160e-02f, -4.14868221e-02f, -3.11253704e-02f, 7.71779269e-02f, -5.16045205e-02f,
  -5.13747334e-01f, -4.38497782e-01f, -3.56409624e-02f, -1.80499088e-02f, -1.70076251e-01f, -1.06758662e-01f, -2.26201192e-02f, 2.46772040e-02f, -1.47860944e-01f, 3.78218144e-02f,
  -5.63698635e-02f, -7.23402053e-02f, -1.06744114e-02f, 9.02933851e-02f, -1.00019671e-01f, -1.03097297e-02f, -9.08835903e-02f, -1.09745301e-01f, -6.99617565e-02f, -7.31659681e-02f,
  -3.63122262e-02f, -6.91629574e-02f, -3.98976505e-02f, 1.24429181e-01f, 2.64128391e-02f, -7.57324100e-02f, 1.00272773e-02f, 1.93429012e-02f, -6.24406198e-03f, -5.07210121e-02f,
  2.62578011e-01f, -3.52573335e-01f, -3.07010859e-01f, 8.15959554e-03f, 4.71705869e-02f, 1.14880085e-01f, -3.63227874e-01f, 8.93728882e-02f, -1.45974457e-01f, -1.82697132e-01f,
  1.70838851e-02f, -1.85462102e-01f, -4.48897570e-01f, 6.56735003e-02f, 2.41178825e-01f, -1.75264820e-01f, 3.17554355e-01f, 1.58388689e-01f, 1.31767839e-01f, -8.89322385e-02f,
  1.48135200e-01f, 2.93060064e-01f, -3.64224166e-02f, 3.23027968e-01f, 2.80591603e-02f, 1.49226308e-01f, 1.75221071e-01f, -1.68437451e-01f, 2.14356229e-01f, 1.68977365e-01f,
  6.78655729e-02f, -8.95203128e-02f, -4.32257261e-03f, -6.11829907e-02f, 3.71230021e-02f, -5.04141748e-02f, 7.37811700e-02f, 4.18019928e-02f, 1.10730538e-02f, -3.80434021e-02f,
  -3.36762667e-02f, 3.00711710e-02f, 9.88680199e-02f, -2.78065689e-02f, 5.87133579e-02f, 6.53304672e-03f, -5.50464615e-02f, -8.38737469e-03f, -9.03417394e-02f, -1.37742445e-01f,
  -2.15422705e-01f, -1.53100006e-02f, 5.61059490e-02f, 3.57170962e-02f, -3.61298285e-02f, 2.75041461e-02f, -1.00741155e-01f, -1.84130952e-01f, 1.47493422e-01f, -6.78526983e-02f,
  5.46691269e-02f, -6.35711243e-03f, -9.01123434e-02f, 4.99066003e-02f, 5.45160361e-02f, 1.45594120e-01f, 2.27203503e-01f, 9.53372344e-02f, 1.19614825e-01f, -2.78853271e-02f,
  4.80085760e-02f, 3.90958413e-02f, 9.05391201e-02f, -3.93054150e-02f, 4.12018038e-02f, 5.33776395e-02f, -2.05216296e-02f, 2.46598721e-02f, -1.45884141e-01f, 5.30050434e-02f,
  6.39438257e-02f, 7.86909685e-02f, -9.64778811e-02f, 1.01561099e-01f, 1.45389795e-01f, -1.09200604e-01f, 1.95503812e-02f, -9.39889997e-02f, -9.19405371e-03f, 3.10381223e-02f,
  1.04282372e-01f, -1.32870981e-02f, -9.45633799e-02f, 3.68226655e-02f, 8.20750520e-02f, 6.37864769e-02f, 1.21355290e-02f, 1.23530380e-01f, 3.04006487e-02f, 4.19994220e-02f,
  -6.28357939e-03f, 1.87295442e-03f, 1.46037087e-01f, 5.75768668e-03f, 1.63618967e-01f, -8.29817131e-02f, -6.36950806e-02f, 1.44901425e-02f, 7.33606145e-02f, 7.63694420e-02f,
  -1.39138117e-01f, 2.99772099e-02f, -1.18489647e-02f, -7.57756680e-02f, 2.23380085e-02f, -6.50714114e-02f, 1.59868822e-01f, -1.22591212e-01f, -1.52425179e-02f, -3.22903320e-02f,
  -5.32745659e-01f, 4.70023900e-01f, 2.30322033e-01f, -5.52574731e-02f, 2.51735989e-02f, 5.91031134e-01f, 3.05431157e-01f, 3.78343135e-01f, 3.69454354e-01f, 2.28952453e-01f,
  -1.14365757e-01f, -8.52240175e-02f, 6.62625656e-02f, -1.30437938e-02f, 1.90467924e-01f, 1.84257165e-01f, 1.81476176e-01f, 8.91577303e-02f, 2.70830452e-01f, -1.32991090e-01f,
  1.30622117e-02f, -8.47892389e-02f, -1.08470984e-01f, 1.37302780e-03f, -1.70045435e-01f, -1.28553465e-01f, -2.95936346e-01f, 9.91478413e-02f, -5.64095750e-02f, 2.07261980e-01f,
  -9.04596373e-02f, -6.41987249e-02f, -2.71633297e-01f, -3.38865183e-02f, -1.38587639e-01f, -6.07790612e-02f, -1.03123663e-02f, -8.56585521e-03f, 5.14895376e-03f, 7.47183114e-02f,
  -6.76779598e-02f, 6.31387671e-03f, -2.35002134e-02f, 3.46726812e-02f, -1.20022306e-02f, -7.62758553e-02f, -3.29147726e-02f, 7.99267739e-03f, 1.65888611e-02f, -9.71200541e-02f,
  -1.96253415e-02f, -3.33536230e-02f, -1.44979626e-01f, 5.31102121e-02f, -4.62400317e-02f, 2.89729121e-03f, 5.11509478e-02f, -6.64632162e-03f, 1.96313355e-02f, 8.10390338e-02f,
  -6.20082989e-02f, 1.04452029e-01f, -5.63575961e-02f, -2.43211794e-03f, -2.70418404e-03f, -3.32010947e-02f, -2.05762461e-02f, -9.24607888e-02f, -3.45817721e-03f, -1.59900129e-01f,
  -7.40067288e-02f, -5.78638203e-02f, -7.02655166e-02f, 5.44239394e-02f, -2.29540896e-02f, -3.40457004e-03f, -1.17968746e-01f, -2.91733332e-02f, -2.25600153e-02f, -4.98929881e-02f,
  6.43004477e-02f, 7.64966086e-02f, -6.51968643e-02f, -6.76085204e-02f, -2.26642843e-03f, 3.87145430e-02f, 2.65708156e-02f, -4.64774203e-03f, -4.96551991e-02f, -3.39138508e-02f,
  2.84038544e-01f, 3.11132848e-01f, -8.81799906e-02f, -4.24505845e-02f, -3.92838791e-02f, 2.57118791e-02f, 1.92258488e-02f, -2.51843482e-02f, 1.42882466e-01f, 2.33517475e-02f,
  -6.19233288e-02f, -7.06051514e-02f, -4.90529686e-02f, 3.61069106e-02f, 7.64860362e-02f, 1.11849569e-01f, 3.26739927e-03f, 4.41078730e-02f, 6.55391812e-02f, -4.05769385e-02f,
  -2.04544336e-01f, -4.48094308e-03f, -1.53765250e-02f, -5.70367649e-02f, -4.12120856e-02f, -9.62589309e-02f, 2.90640686e-02f, -7.24874213e-02f, -5.08063510e-02f, 8.16616565e-02f,
  -2.70697534e-01f, -2.20813721e-01f, 5.39001703e-01f, -2.11541623e-01f, 2.63469279e-01f, 3.60606819e-01f, 3.12454581e-01f, -8.18404555e-03f, -1.61395431e-01f, -3.71490031e-01f,
  -1.66951120e-01f, -8.88800919e-02f, 1.52461290e-01f, -2.36612067e-01f, 5.53117216e-01f, 1.35681659e-01f, 6.05656430e-02f, -1.17780700e-01f, 1.45499676e-01f, 1.72956512e-04f,
  5.41103780e-02f, -1.52686685e-01f, 2.70277858e-01f, -6.53074831e-02f, 6.64957091e-02f, -6.71350434e-02f, -1.20168306e-01f, 3.27906311e-01f, -2.25204304e-01f, 9.15202051e-02f,
  9.62136686e-03f, -1.49691701e-01f, 3.61840799e-02f, 4.13087197e-02f, 6.73034266e-02f, 5.03077637e-03f, 1.62085563e-01f, 2.29254559e-01f, 5.32099158e-02f, -9.66525916e-03f,
  -1.42214643e-02f, 6.88641667e-02f, -6.81034550e-02f, -1.08950958e-02f, 1.80772245e-02f, -7.16221407e-02f, 3.17144841e-02f, -9.89053398e-03f, -8.27343296e-03f, 1.80763248e-02f,
  9.24479887e-02f, 8.36170837e-02f, -1.77950077e-02f, -6.16325140e-02f, 4.80174273e-02f, -2.61392817e-02f, 7.78619274e-02f, 4.92450260e-02f, -6.68537840e-02f, -5.77985831e-02f,
  2.40550237e-03f, 5.70488125e-02f, -1.72872581e-02f, -9.75400507e-02f, -1.73957944e-02f, -1.97411343e-01f, -3.57661257e-03f, 4.93000597e-02f, -2.56867316e-02f, 1.02913007e-02f,
  1.44175421e-02f, -2.14542262e-02f, 5.25004454e-02f, -2.30612624e-02f, -1.65602624e-01f, -1.67747930e-01f, 2.18032207e-02f, -4.98237386e-02f, -2.39289682e-02f, -2.56683454e-02f,
  -5.02748638e-02f, -1.32956104e-02f, 2.27387510e-02f, -6.10811403e-04f, 1.14949845e-01f, 1.04188360e-01f, -9.11333188e-02f, -1.74242910e-02f, -1.20020481e-02f, 1.30536646e-01f,
  -3.39490250e-02f, -2.55421937e-01f, 8.89226645e-02f, -1.30925491e-01f, 3.21503216e-03f, 1.31799867e-02f, 1.37440592e-01f, -4.35502268e-02f, -3.89187410e-02f, -6.16558641e-02f,
  -9.92116407e-02f, -2.16869935e-02f, 4.99290787e-02f, 4.52329777e-02f, 3.20069026e-03f, 9.75597426e-02f, 4.28556874e-02f, -6.21002503e-02f, 1.31316511e-02f, -1.03534266e-01f,
  -4.80202772e-02f, -7.96848722e-03f, -5.93544878e-02f, -4.16903235e-02f, -9.80065316e-02f, -4.87286188e-02f, -1.65525764e-01f, 4.99765296e-03f, 4.70384769e-02f, -6.67866841e-02f,
  3.34626079e-01f, 1.46441786e-02f, -2.27318943e-01f, -7.14104921e-02f, -1.37011632e-01f, -3.31737131e-01f, -4.31822270e-01f, -9.47826505e-02f, -2.85690546e-01f, -9.14455205e-02f,
  -9.77468193e-02f, -4.04762328e-02f, 3.01514547e-02f, -7.23567680e-02f, 1.75630793e-01f, -1.44317243e-02f, 2.32449789e-02f, -1.29704058e-01f, 1.42475560e-01f, 1.82769209e-01f,
  1.53468162e-01f, 2.26038471e-01f, 2.29463354e-01f, 2.58922040e-01f, 1.30100012e-01f, 2.68541157e-01f, 2.91962236e-01f, 7.25309327e-02f, 4.54939492e-02f, -4.05857563e-02f,
  -5.11144139e-02f, 1.05714306e-01f, -4.09748591e-02f, -1.98287852e-02f, 2.65316777e-02f, -1.70698129e-02f, 3.28175235e-03f, 1.66477787e-03f, -1.80632696e-02f, 1.34487757e-02f,
  4.14895117e-02f, 1.32687062e-01f, 1.96525343e-02f, -1.64808165e-02f, 4.37906161e-02f, -5.18649817e-02f, 1.90061163e-02f, -5.62557997e-03f, -1.62874326e-01f, 1.15385957e-01f,
  -7.43807107e-03f, -1.33618843e-02f, 1.03803858e-01f, -1.93628334e-02f, 1.98937543e-02f, 5.75890206e-02f, 3.10447961e-02f, -6.67914748e-02f, -9.09035429e-02f, -7.61383260e-03f,
  6.32103458e-02f, 8.74539539e-02f, 2.75239833e-02f, -9.96959582e-02f, 1.69756673e-02f, 3.48837152e-02f, -1.88675616e-02f, -5.07553183e-02f, 2.46667545e-02f, -3.73347513e-02f,
  -5.50457649e-02f, 1.93901416e-02f, -3.45487759e-04f, 1.70287378e-02f, 1.18263640e-01f, 9.35246274e-02f, -5.53697767e-03f, 1.89327449e-02f, -7.70783871e-02f, -7.09556788e-02f,
  -4.51039262e-02f, 1.80725455e-02f, -6.49142042e-02f, -1.60764456e-02f, -2.56587062e-02f, -1.70313846e-02f, -1.25551326e-02f, -1.65083334e-02f, 4.59683919e-03f, -4.05489989e-02f,
  -8.56214613e-02f, 2.30104417e-01f, -3.57783064e-02f, -1.23164266e-01f, 6.41188258e-03f, -6.28298223e-02f, -5.92213571e-02f, -5.92679642e-02f, -5.86212650e-02f, 2.63149273e-02f,
  8.43244046e-02f, 3.86090390e-02f, -1.98016316e-02f, 6.21673651e-02f, -1.28445759e-01f, -3.44848223e-02f, 5.11108860e-02f, 2.16617528e-02f, -5.59911802e-02f, 8.74321088e-02f,
  3.75727937e-02f, 7.01883733e-02f, 3.34321372e-02f, -1.25810325e-01f, -6.46848753e-02f, -3.11715025e-02f, 7.38657638e-02f, 1.91601494e-03f, 7.01933056e-02f, -7.92335942e-02f,
  -4.23659146e-01f, 7.08638737e-03f, 4.38785732e-01f, -4.61433291e-01f, 1.61200196e-01f, 1.07478917e-01f, -2.08782628e-01f, 1.70270782e-02f, -7.20764250e-02f, -2.29935065e-01f,
  -1.92448735e-01f, -2.53300164e-02f, 8.11874270e-02f, -1.72800869e-01f, 2.99382567e-01f, 3.56539115e-02f, -1.46992862e-01f, -6.19071163e-02f, 1.63447574e-01f, -2.04312459e-01f,
  -1.73922330e-02f, -2.32242361e-01f, 1.43169522e-01f, 7.29195252e-02f, -9.97344404e-02f, -5.13779894e-02f, -1.21159643e-01f, 8.58776122e-02f, -3.05066612e-02f, 1.32770747e-01f,
  -2.12675244e-01f, -2.08671391e-01f, -2.51481146e-01f, 4.35634628e-02f, -3.69164944e-02f, -3.52725498e-02f, -1.66960940e-01f, 4.49680910e-02f, -1.02496952e-01f, -4.13424894e-02f,
  -3.79282273e-02f, 5.43430522e-02f, -7.78733343e-02f, -1.13178222e-02f, -6.46076277e-02f, 3.12744342e-02f, 5.84135316e-02f, -6.38926104e-02f, 6.77203899e-03f, 1.98026538e-01f,
  1.90753952e-01f, 1.97624303e-02f, -2.41533648e-02f, -5.34077771e-02f, 5.28994910e-02f, -1.31864715e-02f, -1.83197614e-02f, 9.60265025e-02f, 2.54219566e-02f, 3.02601457e-02f,
  8.95608068e-02f, 1.04809143e-01f, 5.49078435e-02f, -1.03045804e-02f, 6.03104606e-02f, 1.14548370e-01f, -3.21231559e-02f, -4.23931852e-02f, 7.02154031e-03f, -3.69281285e-02f,
  -8.26602578e-02f, -8.90144929e-02f, -4.69728783e-02f, -3.64532769e-02f, -4.47202288e-02f, -1.09958619e-01f, 3.19677703e-02f, -2.47602593e-02f, 1.65179670e-02f, 5.13943322e-02f,
  -5.22986874e-02f, 1.86541248e-02f, 8.83263722e-02f, -4.65652123e-02f, -3.05187535e-02f, 3.29642231e-03f, -7.35872015e-02f, 1.12278894e-01f, -2.31312821e-03f, -1.55226672e-02f,
  -3.48547310e-01f, -2.71252900e-01f, -1.33559689e-01f, -1.21016853e-01f, 2.90945545e-02f, -2.13755388e-02f, 1.00855175e-02f, -2.80493069e-02f, -5.12174368e-02f, -5.04692681e-02f,
  -2.34673582e-02f, -1.22029640e-01f, 2.14244165e-02f, -1.85221676e-02f, -1.47727912e-03f, -2.66491827e-02f, -1.61468908e-01f, -1.81511819e-01f, -1.48748845e-01f, -3.64499278e-02f,
  -7.24376692e-03f, -4.01253328e-02f, 9.63481218e-02f, 2.61630882e-02f, -4.38175127e-02f, -3.52885611e-02f, -5.88377938e-02f, 7.80867413e-02f, 1.11353867e-01f, 7.29403794e-02f,
  -7.12078333e-01f, 3.62069130e-01f, 1.98455706e-01f, -3.41453969e-01f, 1.15673937e-01f, 1.47580430e-01f, -5.48503175e-02f, 1.59009695e-01f, -1.18563116e-01f, 8.32044780e-02f,
  -1.09222107e-01f, -8.20010081e-02f, 1.92024872e-01f, -7.98407272e-02f, -3.37028772e-01f, -1.53893113e-01f, -1.31591663e-01f, -1.17954731e-01f, 4.54476140e-02f, 4.77967411e-03f,
  -3.25192735e-02f, -8.74780789e-02f, 9.09601077e-02f, 2.74597079e-01f, 8.47424045e-02f, 6.43327162e-02f, -1.51216969e-01f, 1.78520247e-01f, 6.51777834e-02f, -4.72254418e-02f,
  -8.42508599e-02f, -5.69935143e-02f, 1.34606138e-01f, 7.24678487e-02f, 9.38686579e-02f, 7.18447752e-03f, -6.83497563e-02f, -3.41292731e-02f, 2.35090367e-02f, 6.02092333e-02f,
  4.31371480e-02f, 1.29813910e-01f, -2.31984947e-02f, 2.00926345e-02f, 6.52444810e-02f, 3.77701372e-02f, 8.05834159e-02f, 6.55849278e-02f, 1.08414017e-01f, 2.86986101e-02f,
  4.24872711e-02f, 7.46123940e-02f, 4.12223823e-02f, -4.62449230e-02f, 5.47573194e-02f, 2.64635943e-02f, -1.32708875e-02f, -1.75963920e-02f, -2.74666585e-02f, -1.19691575e-02f,
  -6.99639544e-02f, 2.47696768e-02f, 9.02143419e-02f, 2.15708017e-02f, -5.64846881e-02f, 2.49977689e-02f, -6.28655031e-02f, -5.85450754e-02f, 2.68284623e-02f, -5.26091084e-03f,
  -1.24795102e-01f, 3.46561074e-02f, 2.85399985e-02f, -1.15042422e-02f, -4.93989997e-02f, -3.56541239e-02f, -1.60584617e-02f, -3.06747202e-02f, -4.19654697e-02f, -6.13844655e-02f,
  -1.98593140e-02f, -1.72708910e-02f, -2.48495638e-02f, -3.24233584e-02f, 3.72568294e-02f, 4.38720882e-02f, 5.41535169e-02f, 4.34749275e-02f, -6.32616645e-03f, -6.61909208e-02f,
  -1.32029951e-01f, -1.46058127e-01f, -2.08208151e-02f, 2.96841078e-02f, -2.77002174e-02f, 5.58733158e-02f, 1.59758050e-02f, 5.06167933e-02f, 3.69574390e-02f, 3.00300810e-02f,
  1.31446436e-01f, 1.12412587e-01f, -7.36022964e-02f, -1.97456256e-02f, -2.79252380e-02f, -1.93742458e-02f, -1.07308134e-01f, -9.27828103e-02f, -7.06830714e-03f, 7.79009843e-03f,
  -2.43873745e-02f, -3.16608548e-02f, 3.14071439e-02f, 7.68435420e-03f, -2.32836232e-02f, -4.29074913e-02f, -8.64919275e-02f, 4.93760332e-02f, -3.76276262e-02f, -4.14376780e-02f,
  4.87427324e-01f, -3.50937724e-01f, 1.79225102e-01f, 4.27740753e-01f, 3.40218604e-01f, 5.88150471e-02f, 2.38553286e-01f, 8.22490305e-02f, 3.56132179e-01f, -3.37876320e-01f,
  -3.33128124e-02f, -1.12263143e-01f, -1.75325334e-01f, -4.68252935e-02f, 1.49861306e-01f, -2.30482936e-01f, 7.83167481e-02f, -8.17706436e-02f, 1.11786708e-01f, 2.23887004e-02f,
  2.28988454e-01f, -1.37974203e-01f, 3.65292206e-02f, -2.16683343e-01f, 1.92383900e-01f, 1.30007446e-01f, -1.30678952e-01f, 7.64292059e-03f, -8.25862959e-02f, 4.06184457e-02f,
  3.73609774e-02f, 1.59899741e-01f, 1.25381842e-01f, -7.03198165e-02f, 1.00910906e-02f, 1.36398464e-01f, -1.11550177e-02f, -1.04160689e-01f, 2.15960771e-01f, 1.85970422e-02f,
  -9.42565501e-02f, 1.60536766e-02f, -1.30399829e-02f, 3.21011208e-02f, 6.99433610e-02f, 6.10367246e-02f, 6.77939430e-02f, 1.20925188e-01f, 1.62184890e-02f, 1.17113702e-01f,
  1.38541773e-01f, 9.08857882e-02f, 1.14860080e-01f, -1.05929829e-01f, 8.10912400e-02f, 9.62329060e-02f, -2.11910158e-02f, 3.81055400e-02f, 3.20453160e-02f, -4.83867619e-03f,
  -9.62298289e-02f, 2.56792344e-02f, 2.04741005e-02f, 6.74968446e-03f, 3.50995325e-02f, 8.40459466e-02f, -5.31168319e-02f, -3.72891873e-02f, 2.47889142e-02f, -6.68092147e-02f,
  1.83142945e-02f, 3.91882844e-02f, 4.90982458e-02f, 4.89263749e-03f, -5.87192141e-02f, 4.64159586e-02f, -4.64588031e-02f, -9.08298194e-02f, 5.21413349e-02f, 4.17647883e-02f,
  -6.83730319e-02f, -2.65665408e-02f, -1.81872130e-03f, 8.06915686e-02f, -7.15770647e-02f, 4.26308773e-02f, -5.65420277e-02f, 1.67597889e-03f, 8.29266477e-03f, -7.83378035e-02f,
  -4.45818126e-01f, -4.60027158e-01f, -8.35622102e-02f, -1.31243825e-01f, -1.85756713e-01f, -8.41650143e-02f, -5.66760898e-02f, -1.05365133e-03f, -1.01939343e-01f, 9.67351627e-03f,
  3.46350367e-03f, 4.69501354e-02f, -8.77874866e-02f, -3.04579604e-02f, -2.19048820e-02f, 1.26365526e-02f, -4.97859642e-02f, -9.04680490e-02f, 3.69376084e-03f, -6.82271719e-02f,
  -2.31739739e-03f, -4.70157340e-02f, 8.51361174e-03f, 4.44923341e-02f, -4.37312052e-02f, 2.33089793e-02f, -9.13445950e-02f, -1.63729228e-02f, -4.11836915e-02f, -1.75234545e-02f,
  2.67166823e-01f, -1.06779542e-02f, -3.60305607e-01f, -1.27508026e-02f, 7.12179169e-02f, 1.04350850e-01f, 1.25077739e-01f, 5.33496663e-02f, -1.90146670e-01f, 1.81220695e-01f,
  2.12626189e-01f, -3.38724675e-03f, -5.97919151e-02f, 2.77666152e-01f, 2.05358699e-01f, -2.44086459e-01f, 2.70716727e-01f, 1.31752655e-01f, -2.31197655e-01f, 3.32830340e-01f,
  6.16867915e-02f, 3.89496893e-01f, -5.81408152e-04f, 9.80502442e-02f, 2.75758117e-01f, -2.00421706e-01f, 2.04968676e-01f, -1.40125573e-01f, 2.63415247e-01f, 1.71692550e-01f,
  -2.30112020e-02f, 1.80900376e-02f, 1.80657096e-02f, -2.55824123e-02f, 1.00928977e-01f, 6.60760254e-02f, 4.87530231e-03f, -9.35218558e-02f, -5.05649000e-02f, -3.56667675e-03f,
  -1.22035574e-03f, -9.45294090e-03f, -6.78709894e-02f, -9.16393474e-03f, -4.93705831e-03f, -4.46098186e-02f, -1.15338035e-01f, -9.52023715e-02f, -4.40100357e-02f, 1.05063878e-01f,
  -5.69338202e-02f, 6.72884099e-03f, -6.74261227e-02f, -9.50689688e-02f, -1.19831152e-01f, -6.33082613e-02f, -1.11060694e-01f, 3.74351218e-02f, -5.74758574e-02f, 1.23941079e-01f,
  1.44679517e-01f, -1.17163351e-02f, 8.88217688e-02f, -6.09381758e-02f, 2.39421092e-02f, -6.32066131e-02f, -6.92930073e-02f, 1.44124322e-03f, -1.07702361e-02f, 1.10496767e-01f,
  -6.96447771e-03f, -1.68802273e-02f, 6.84021488e-02f, 1.54541032e-02f, 4.64122668e-02f, -3.57614495e-02f, 1.79616548e-02f, -2.26921812e-02f, -8.47298559e-03f, -1.54626340e-01f,
  -2.92037763e-02f, 5.23168407e-03f, 1.24278076e-01f, -3.02790608e-02f, -9.07504857e-02f, 5.52798510e-02f, 1.29322767e-01f, 1.51215605e-02f, -1.96328610e-01f, 1.28423665e-02f,
  9.68164206e-02f, 1.68229207e-01f, -6.22572713e-02f, -2.91818548e-02f, -1.27799898e-01f, 1.62844092e-01f, 1.24427071e-02f, 1.08464733e-02f, 9.51234438e-03f, 5.76958396e-02f,
  9.23017859e-02f, -6.19172640e-02f, -6.46506399e-02f, -3.56846042e-02f, -1.61797274e-02f, 1.04899094e-01f, 6.00023828e-02f, -7.42223114e-02f, -5.43632619e-02f, 1.03404075e-01f,
  8.01166054e-03f, 5.52306138e-02f, -4.00814787e-02f, -6.71473965e-02f, -7.79062733e-02f, 4.07043733e-02f, -4.17347699e-02f, 1.88666638e-02f, 1.13516990e-02f, -5.59348427e-03f,
  -2.99223900e-01f, -3.09313208e-01f, -1.04349926e-01f, 1.32152557e-01f, 1.17946483e-01f, -5.46219461e-02f, -3.43136042e-01f, 4.30308841e-03f, -2.92396307e-01f, -1.92858368e-01f,
  3.75967324e-02f, 6.17670305e-02f, -4.07822192e-01f, 2.43433505e-01f, 2.02154145e-01f, -3.78672868e-01f, 3.10030341e-01f, 1.68102667e-01f, -1.32418543e-01f, 1.53358519e-01f,
  1.01746395e-01f, 2.92698622e-01f, 2.28019536e-01f, 2.85182625e-01f, 1.59647599e-01f, 1.26704037e-01f, 3.67732227e-01f, 8.52609426e-02f, 4.32174623e-01f, 2.38860980e-01f,
  -3.52623649e-02f, -1.68556213e-01f, -8.69626254e-02f, 3.41666527e-02f, -5.67710735e-02f, 6.46701828e-02f, 6.68270662e-02f, 7.94456303e-02f, 7.52355605e-02f, 2.18657646e-02f,
  -7.28054196e-02f, 1.40525416e-01f, 8.92440081e-02f, 2.30914019e-02f, -1.60767455e-02f, 7.78140202e-02f, 2.05666292e-02f, 3.02730333e-02f, -9.44134500e-03f, -7.73822740e-02f,
  -5.98972887e-02f, -5.53158075e-02f, 1.12949982e-02f, 6.37128130e-02f, 3.44657525e-03f, 1.22295190e-02f, 7.12305494e-03f, 1.02860428e-01f, 8.75441357e-03f, -2.70699430e-03f,
  -5.75281717e-02f, -1.89862158e-02f, -3.49594094e-02f, 1.25875482e-02f, -2.18700133e-02f, -2.95112748e-03f, -8.03039968e-02f, 5.73694613e-03f, -1.84139349e-02f, -9.75302905e-02f,
  6.67438582e-02f, -3.06178369e-02f, 2.26961914e-02f, -2.73779519e-02f, -3.58695872e-02f, -7.36836419e-02f, 3.20733488e-02f, 5.68983853e-02f, 8.65037292e-02f, -5.93274012e-02f,
  -8.36455822e-02f, 5.54947704e-02f, 1.14481617e-02f, -6.96660429e-02f, -3.38290036e-02f, 2.25218590e-02f, 1.06211137e-02f, -5.21923695e-03f, 2.29575615e-02f, 4.14234921e-02f,
  -7.41518161e-04f, 5.62849902e-02f, 3.18655968e-02f, 6.17798604e-02f, 3.37462462e-02f, -1.38409548e-02f, -5.15309274e-02f, -8.59355205e-05f, 3.38831432e-02f, -1.10429987e-01f,
  8.60468224e-02f, 1.41976401e-01f, -4.10828143e-02f, 1.28535464e-01f, 8.72077048e-02f, -9.08373389e-03f, 4.43873554e-02f, 8.85817334e-02f, 1.29977241e-01f, 8.76603574e-02f,
  6.99422956e-02f, -5.76762222e-02f, 4.34607677e-02f, 1.01519823e-01f, -1.78856663e-02f, -5.22946306e-02f, 8.30572285e-03f, -2.70861387e-03f, 6.96919486e-02f, -1.91179942e-02f,
  -4.75123405e-01f, 1.26983270e-01f, -1.83666885e-01f, -3.02827358e-01f, 2.64715970e-01f, -6.99601620e-02f, -5.47850952e-02f, -1.87637061e-02f, -2.22166970e-01f, 1.32788971e-01f,
  -4.66732346e-02f, -1.23072468e-01f, -3.84343863e-02f, -3.58621389e-01f, -4.88563806e-01f, -3.36524636e-01f, -2.87336051e-01f, -1.64580032e-01f, -1.79944456e-01f, 9.97359455e-02f,
  -1.84984207e-01f, 4.74970751e-02f, -2.37020835e-01f, 2.02251688e-01f, 7.26614892e-02f, 1.25611588e-01f, 2.74995506e-01f, 2.36012787e-01f, 7.91914612e-02f, -5.60213886e-02f,
  -1.00317918e-01f, -7.48453960e-02f, -7.13290721e-02f, -3.22350068e-03f, -2.27147690e-03f, 9.53767970e-02f, 6.09584339e-02f, -5.31958044e-03f, -6.13574609e-02f, -6.10097088e-02f,
  2.03887653e-02f, -7.01307207e-02f, 7.97371659e-03f, -9.00489651e-03f, -5.92566989e-02f, -6.29561990e-02f, -7.40942284e-02f, 6.22654483e-02f, -6.37663230e-02f, -1.32521436e-01f,
  -6.90916553e-02f, -2.67623812e-02f, 6.06371090e-02f, -3.77852656e-02f, -1.47176571e-02f, 4.30985820e-03f, 4.91669849e-02f, 5.01620024e-02f, 3.30158919e-02f, -2.46686283e-02f,
  4.79266532e-02f, 1.09764330e-01f, -3.06057557e-02f, -4.06523198e-02f, 2.34141340e-03f, 3.26942764e-02f, 5.95747866e-02f, 2.81597972e-02f, 3.12006008e-02f, -1.75613873e-02f,
  5.54232812e-03f, -1.87951308e-02f, 4.29115817e-02f, 2.79054344e-02f, -5.98411709e-02f, -4.11574021e-02f, 1.12002254e-01f, -1.16519900e-02f, 3.86667438e-02f, -1.74582470e-02f,
  -3.44480984e-02f, 6.65023625e-02f, 3.32957171e-02f, 1.28407076e-01f, -1.03269227e-01f, -1.25723248e-02f, 5.59038557e-02f, -6.71707243e-02f, -4.23673242e-02f, 6.15996569e-02f,
  6.71918392e-02f, 1.09288365e-01f, 1.14557585e-02f, -6.73650652e-02f, -4.71299812e-02f, -3.69442441e-02f, -1.60015106e-01f, -1.64509509e-02f, -1.76736563e-02f, 6.24318495e-02f,
  7.29170889e-02f, 7.18175843e-02f, 1.35612994e-01f, 1.71552245e-02f, -3.44859026e-02f, 4.49809991e-02f, 9.32852030e-02f, 8.96114111e-02f, 7.37660006e-02f, 1.15541006e-02f,
  1.62888601e-01f, 8.46529901e-02f, 1.13625769e-02f, 8.39729309e-02f, 7.50942901e-02f, 1.08498693e-01f, 5.05197123e-02f, -2.87254341e-02f, 4.17432897e-02f, -2.37180665e-02f,
  4.14294094e-01f, 2.54186600e-01f, 2.55516320e-01f, 2.89584398e-01f, -2.58380860e-01f, -1.62924044e-02f, 1.52888238e-01f, -1.13986291e-01f, 4.93951797e-01f, 2.29756441e-02f,
  -3.70173991e-01f, 4.74430889e-01f, -3.94409411e-02f, -1.49217784e-01f, 1.84972554e-01f, 7.25549087e-02f, 2.53677845e-01f, 1.59945101e-01f, 1.12495787e-01f, 1.81171700e-01f,
  1.17276512e-01f, -2.61299998e-01f, -1.08427912e-01f, -3.24751645e-01f, -1.78984761e-01f, 4.65890244e-02f, -3.93030971e-01f, -1.32301539e-01f, -2.30448321e-01f, -1.69684500e-01f,
  -1.29035607e-01f, 1.24439687e-01f, 5.97152933e-02f, 8.98535624e-02f, 7.61809619e-03f, -1.01651274e-01f, 3.32623124e-02f, -9.10914689e-02f, 8.58550444e-02f, 2.84995716e-02f,
  1.60965130e-01f, 2.23808619e-03f, 6.01647012e-02f, -5.39620034e-02f, 5.67845777e-02f, 1.04105081e-02f, 1.71832442e-02f, -9.14378613e-02f, 1.01545155e-01f, -1.09927624e-01f,
  -4.74696644e-02f, -2.49314215e-02f, 2.26078201e-02f, 8.76642540e-02f, 1.39755502e-01f, 1.33673489e-01f, 8.64116699e-02f, -3.50535922e-02f, 4.95090103e-03f, 6.38681576e-02f,
  1.49213850e-01f, 5.06911278e-02f, -2.91585326e-02f, -1.59020975e-01f, -8.63466859e-02f, -1.32995266e-02f, -3.82949486e-02f, -7.02302903e-02f, 4.57778722e-02f, 2.99690012e-02f,
  2.14949232e-02f, -6.21402189e-02f, 3.92577704e-03f, 2.43800227e-02f, -2.40641013e-02f, 9.27980244e-02f, -1.92315057e-02f, -2.47182790e-02f, 1.11806743e-01f, -5.74785955e-02f,
  -8.36066753e-02f, 1.03998363e-01f, -9.79078561e-03f, -9.72642973e-02f, -7.37646222e-02f, -1.93094164e-02f, 1.66053046e-02f, 1.72166545e-02f, -4.18168083e-02f, -8.19286034e-02f,
  1.64770812e-01f, 3.44337493e-01f, 1.39205411e-01f, 7.18410388e-02f, 6.77437661e-03f, 1.40909869e-02f, 3.90687324e-02f, 1.25252783e-01f, 1.04530737e-01f, -5.96641051e-03f,
  4.62276526e-02f, 8.26575514e-03f, 4.31598984e-02f, -1.53158039e-01f, 9.37188715e-02f, -1.16307043e-01f, 1.12412572e-01f, 4.37477417e-03f, 8.90949219e-02f, 3.27126607e-02f,
  -1.87891144e-02f, 1.02125794e-01f, 8.56181458e-02f, 3.19593120e-03f, 9.09446552e-02f, -5.50822988e-02f, 1.24774231e-02f, -2.40517817e-02f, -9.47703607e-03f, 1.35819569e-01f,
  3.60265523e-02f, -3.45842481e-01f, -9.30030122e-02f, -1.73019841e-01f, 3.32125882e-03f, -1.73356786e-01f, 1.03241451e-01f, -3.23855013e-01f, -6.64374977e-02f, -1.99987814e-01f,
  -4.08307314e-02f, 2.20191002e-01f, 2.68313110e-01f, -3.37441176e-01f, 4.35004234e-01f, 2.43347719e-01f, -2.74824113e-01f, 2.79843360e-02f, -2.15745568e-02f, -2.75350928e-01f,
  -1.37341589e-01f, -2.22886115e-01f, -2.73480676e-02f, -3.60905439e-01f, -2.71166444e-01f, -1.63901463e-01f, 1.29804596e-01f, -4.94025694e-03f, -2.19791442e-01f, 1.55576333e-01f,
  -2.85688847e-01f, -3.10414463e-01f, -1.21103458e-01f, -3.06075662e-02f, -2.08061695e-01f, 1.77467000e-02f, 8.98179971e-03f, 2.42185682e-01f, 6.46315813e-02f, 6.83496008e-03f,
  1.00453787e-01f, 1.16841681e-02f, -6.58606514e-02f, 1.21555485e-01f, -2.10964121e-03f, -3.83088514e-02f, -7.22585097e-02f, -1.12353675e-01f, 4.33436632e-02f, 6.78318441e-02f,
  -1.44123361e-01f, -1.29779562e-01f, -1.19046181e-01f, 1.70717854e-02f, 7.75499642e-02f, -7.83893839e-02f, -1.47988098e-02f, 4.05395962e-02f, -5.43306805e-02f, -1.03913195e-01f,
  1.13149971e-01f, 8.94999057e-02f, 8.50385427e-03f, -3.51929106e-02f, -2.62716375e-02f, -1.12204783e-01f, -3.43779325e-02f, 5.42862527e-02f, 8.14857986e-03f, -6.17380477e-02f,
  -5.07236831e-03f, 5.18268943e-02f, -7.21871182e-02f, 2.63767280e-02f, -3.55353728e-02f, 4.22871001e-02f, 9.48849842e-02f, -1.61210466e-02f, -1.45850241e-01f, 1.09748151e-02f,
  -9.70358215e-03f, 4.97033410e-02f, 2.35040002e-02f, 8.89253919e-04f, -4.90907840e-02f, 9.41050947e-02f, -1.54057130e-01f, -6.61066994e-02f, 5.26799075e-03f, 1.03484981e-01f,
  -2.17681512e-01f, -2.87205338e-01f, -2.11180933e-02f, -7.96517506e-02f, 5.65642230e-02f, -4.52882461e-02f, -6.80818707e-02f, -1.91958677e-02f, 1.11227799e-02f, -1.12689041e-01f,
  -1.84783675e-02f, 6.19373694e-02f, 8.72832071e-03f, 1.02721071e-02f, 4.19864431e-02f, -4.61243698e-03f, 4.84542772e-02f, 1.13451006e-02f, 3.80866937e-02f, -1.07608415e-01f,
  -8.73070396e-03f, 2.75341943e-02f, 7.76756182e-02f, -5.70562035e-02f, 6.74713403e-02f, 1.04715563e-02f, -7.75314495e-03f, 1.96035001e-02f, 6.62378520e-02f, -4.92967572e-03f,
  2.12736309e-01f, 4.46711719e-01f, 4.72266465e-01f, 5.82594097e-01f, -2.94251651e-01f, -2.52416968e-01f, -6.28940985e-02f, -2.43087616e-02f, 1.13784648e-01f, -2.95468327e-02f,
  -2.63498574e-01f, 4.95484501e-01f, -3.05824578e-01f, 2.20425874e-01f, -2.43045434e-01f, -2.92687386e-01f, 1.16742931e-01f, 1.88698873e-01f, 9.01637971e-02f, 2.21592873e-01f,
  -4.53609414e-02f, -1.76813528e-01f, 6.82273731e-02f, 8.28987919e-03f, 2.60495663e-01f, 3.23387861e-01f, -5.99133782e-02f, -2.72723865e-02f, 3.56718570e-01f, -1.57991439e-01f,
  -1.26722232e-01f, 7.91138262e-02f, 1.64885059e-01f, 6.57489710e-03f, 2.84316223e-02f, 4.81847376e-02f, 6.12465814e-02f, -5.64328395e-02f, -9.87365916e-02f, 5.00691310e-02f,
  2.19393242e-02f, -2.04902608e-03f, 8.77448618e-02f, -1.92422047e-02f, -1.13696912e-02f, 1.30790904e-01f, 9.93150249e-02f, 7.72685111e-02f, 1.51899412e-01f, 4.78926711e-02f,
  1.38706833e-01f, 5.46745621e-02f, 4.39998023e-02f, 2.07137167e-02f, 5.22313528e-02f, 4.54007946e-02f, 3.62059064e-02f, 1.03021048e-01f, 1.59021914e-01f, 1.77244827e-01f,
  -1.72237992e-01f, -2.96842046e-02f, 3.94666158e-02f, 7.94212446e-02f, 9.02999938e-03f, 2.30701640e-03f, 1.01927957e-02f, -1.49694532e-01f, -3.08822282e-03f, -3.99200246e-02f,
  -4.57399376e-02f, 3.08280066e-02f, 5.67155285e-03f, 7.90149420e-02f, -3.18824053e-02f, 6.17697015e-02f, -6.25978634e-02f, 5.09734936e-02f, 7.37625035e-03f, -1.38980150e-03f,
  -2.51262821e-02f, -3.97679470e-02f, 1.70525789e-01f, -3.72139029e-02f, -1.13251375e-03f, -2.19477229e-02f, 5.25956377e-02f, 1.08752906e-01f, -1.37523547e-01f, -4.88522463e-02f,
  1.48305567e-02f, 2.07505241e-01f, -2.22010389e-02f, -9.28535312e-02f, 2.96144113e-02f, -7.34623000e-02f, -5.27174063e-02f, 2.57061943e-02f, 1.12966143e-01f, -9.95459482e-02f,
  -9.73327011e-02f, 6.23300206e-03f, 1.32260462e-02f, -5.92618994e-02f, -6.33710250e-02f, 6.62093461e-02f, 4.32317443e-02f, -1.20301899e-02f, -2.99635506e-03f, 8.05603527e-03f,
  5.03334813e-02f, -1.18776083e-01f, -7.04086199e-02f, -1.73342116e-02f, -1.16648182e-01f, -2.05353498e-02f, 3.80457155e-02f, 2.33879238e-02f, -3.89439240e-02f, 2.13409625e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 26)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 26;
const float L0_fan_Bp_bar_data[] = {
  2.58736938e-01f, 2.65761733e-01f, 5.14555275e-01f, 3.00673455e-01f, 3.11395139e-01f, 4.91665840e-01f, 4.60731059e-01f, 3.58355105e-01f, 8.53751041e-03f, 5.39783835e-01f,
  3.87095213e-01f, 3.80080014e-01f, 3.21034968e-01f, 5.44246793e-01f, 4.05850500e-01f, 3.77513468e-01f, 3.02079648e-01f, 4.09259528e-01f, 3.74185741e-01f, 4.81739491e-01f,
  3.08282048e-01f, 3.09836864e-01f, 1.73694313e-01f, 4.84515548e-01f, 2.52616286e-01f, 4.22848493e-01f
};

// L1_fan_Wp (Shape: 3 x 32)
const int L1_fan_Wp_rows = 3;
const int L1_fan_Wp_cols = 32;
const float L1_fan_Wp_data[] = {
  -1.70583073e-02f, 1.54503584e-01f, 3.44860554e-02f, 1.53743386e-01f, -1.52655849e-02f, -2.95348167e-01f, 2.09305659e-01f, -2.40248412e-01f, -6.60453411e-03f, -1.44890115e-01f,
  1.85558692e-01f, 1.28023224e-02f, -4.24107872e-02f, 2.25053608e-01f, 1.21457376e-01f, 5.31244613e-02f, 2.99714915e-02f, -1.20631449e-01f, 1.78481981e-01f, -3.86183485e-02f,
  -9.66828689e-02f, -2.13243021e-03f, 3.63505073e-02f, 5.99373691e-02f, 2.27672592e-01f, 1.78849414e-01f, -1.82854563e-01f, 1.84200369e-02f, 1.11556351e-01f, 1.09238654e-01f,
  -2.04752058e-01f, 2.07054466e-02f, -7.85565004e-02f, -4.09433171e-02f, 1.22353867e-01f, 2.39018872e-01f, -4.41631395e-03f, 2.57507265e-01f, -9.24796164e-02f, 2.31463268e-01f,
  -2.99965516e-02f, 1.74284410e-02f, 1.15646526e-01f, -2.02750146e-01f, -2.81747989e-02f, -1.44027278e-01f, 2.50951797e-01f, 5.89755550e-02f, 7.85721689e-02f, 2.51810700e-01f,
  -2.12909251e-01f, -6.64635897e-02f, 2.70598531e-01f, 2.43967414e-01f, 1.48272753e-01f, -3.14923488e-02f, 1.77818781e-03f, -2.65515208e-01f, 9.98062789e-02f, 3.03359842e-03f,
  -2.09540755e-01f, -1.49455354e-01f, -4.01744805e-02f, 4.96776216e-02f, -4.66345251e-02f, -6.80319667e-02f, -4.84989174e-02f, 2.45085701e-01f, 2.02760860e-01f, 4.40550111e-02f,
  -2.00623889e-02f, -5.92948915e-03f, -5.89242205e-02f, 1.34908199e-01f, -1.65513717e-02f, 1.07765235e-01f, -1.08633444e-01f, -2.37243280e-01f, -1.20844886e-01f, 2.93577552e-01f,
  6.67467564e-02f, -3.26017141e-02f, 2.57803857e-01f, 7.54172653e-02f, -1.52402241e-02f, 1.40965462e-01f, -2.34012216e-01f, 8.28098059e-02f, -1.40240847e-03f, 2.75106400e-01f,
  -1.88225895e-01f, 4.89598513e-03f, -1.77663147e-01f, 1.86078072e-01f, 5.58085777e-02f, 5.98242916e-02f
};

// L1_fan_Wp_bar (Shape: 26 x 32)
const int L1_fan_Wp_bar_rows = 26;
const int L1_fan_Wp_bar_cols = 32;
const float L1_fan_Wp_bar_data[] = {
  6.51821145e-04f, -1.10616609e-02f, 2.54017681e-01f, 8.17415789e-02f, 2.52792329e-01f, 4.99212980e-01f, -1.68587938e-01f, 4.86069441e-01f, -1.61188722e-01f, 5.53693593e-01f,
  2.22873151e-01f, 8.54762569e-02f, 2.21226126e-01f, -2.40515709e-01f, -3.94058488e-02f, 2.31650069e-01f, 2.36248970e-01f, 4.55108702e-01f, -1.91921145e-01f, 9.44398195e-02f,
  3.11823070e-01f, 4.45411295e-01f, 1.16123848e-01f, 3.03216040e-01f, -6.11233041e-02f, -1.11417785e-01f, 2.77396560e-01f, 1.61012392e-02f, -3.75433236e-01f, -2.83204526e-01f,
  4.98208910e-01f, -2.48234525e-01f, 2.24158615e-01f, 2.80451536e-01f, 3.59195620e-01f, 1.66873768e-01f, -9.70568582e-02f, -1.84772506e-01f, 3.37857962e-01f, -5.74244149e-02f,
  7.59300441e-02f, -1.09855086e-01f, 4.32367116e-01f, 3.04083586e-01f, 3.75689179e-01f, 4.62740213e-01f, -1.49854764e-01f, -2.22426690e-02f, 1.31531656e-01f, 2.33462840e-01f,
  -1.75488755e-01f, 4.98427451e-02f, 2.87333548e-01f, 2.13076115e-01f, 7.04792282e-03f, 3.17939013e-01f, 5.42532086e-01f, -1.67667642e-01f, -2.57026881e-01f, -2.28513237e-02f,
  2.69109219e-01f, 9.81851816e-02f, -1.69653997e-01f, 2.02480238e-02f, -4.74244133e-02f, 5.26250973e-02f, -8.43353197e-02f, 6.68320134e-02f, 5.59047982e-02f, 8.33170675e-03f,
  1.97979406e-01f, 2.31964797e-01f, 2.80404210e-01f, 3.77268374e-01f, 2.05865324e-01f, -6.12015091e-02f, -6.90725446e-02f, 2.57001799e-02f, -4.77336608e-02f, 2.28704780e-01f,
  2.66910732e-01f, 5.31238317e-02f, 4.23862964e-01f, -3.63019258e-02f, -7.00895265e-02f, 2.46209860e-01f, 9.23959762e-02f, 2.51751803e-02f, 1.05733112e-01f, 3.76497746e-01f,
  1.08420756e-02f, -3.93389106e-01f, -5.23614325e-02f, -4.59719785e-02f, 1.20495837e-02f, -2.55234182e-01f, 1.74474642e-01f, 3.36742193e-01f, 1.49258554e-01f, -1.17760815e-01f,
  2.71224767e-01f, -3.90479505e-01f, 5.59610307e-01f, 2.37490669e-01f, 1.06003624e-03f, -2.07235888e-01f, 7.74013251e-02f, 1.99976102e-01f, 4.52409387e-01f, 3.06129128e-01f,
  -2.74951160e-01f, 3.47005963e-01f, -6.03865385e-02f, 2.35116079e-01f, 2.42075711e-01f, 2.43281394e-01f, -2.36383349e-01f, -1.67663973e-02f, -1.74078077e-01f, 1.88227966e-01f,
  4.92948085e-01f, 4.05947417e-01f, -7.70632401e-02f, 1.52250752e-01f, 3.35549980e-01f, -7.08778650e-02f, -3.77011746e-01f, 1.06228657e-01f, 2.10201085e-01f, 2.31989801e-01f,
  1.26056761e-01f, -1.76552430e-01f, 1.20105095e-01f, -3.16703916e-01f, 1.71062484e-01f, -8.16298127e-02f, -4.50044461e-02f, -3.25846612e-01f, -2.44432136e-01f, 2.87633538e-01f,
  3.05572987e-01f, 3.14758986e-01f, 2.19855860e-01f, 6.19590189e-03f, -8.51709321e-02f, -7.36520886e-02f, -1.63899049e-01f, 2.22890154e-01f, -2.26053879e-01f, -2.31789753e-01f,
  1.74476504e-01f, -7.38111213e-02f, 6.76252842e-02f, -3.79918516e-02f, 2.45283589e-01f, 3.85634333e-01f, 3.59308332e-01f, 1.13048792e-01f, -1.23387903e-01f, 4.60929871e-01f,
  1.18447579e-01f, 5.20102940e-02f, 1.58468466e-02f, -4.31872569e-02f, -3.63018334e-01f, 2.28182763e-01f, -4.14757967e-01f, 3.82727146e-01f, 2.82926172e-01f, 7.94940218e-02f,
  -1.14304245e-01f, -2.47984827e-01f, -9.66848657e-02f, -1.19722918e-01f, 3.86128813e-01f, -1.04951829e-01f, 2.27694869e-01f, 2.68679202e-01f, -1.30018488e-01f, 2.03401491e-01f,
  4.15189773e-01f, -6.71768486e-02f, 4.44871783e-01f, -2.51469642e-01f, -2.15698868e-01f, -1.92915335e-01f, 4.30369705e-01f, 3.35440300e-02f, -1.03560843e-01f, 2.69270986e-01f,
  -2.21554246e-02f, 2.66802460e-01f, 1.95736796e-01f, -8.54119435e-02f, 1.58633083e-01f, 5.14612734e-01f, -2.46126056e-01f, 1.66535705e-01f, 3.02747667e-01f, -8.80947858e-02f,
  3.59483287e-02f, 1.03900105e-01f, 5.44583917e-01f, 3.74971509e-01f, 9.24435630e-03f, 4.83906232e-02f, -1.95015863e-01f, 4.62797672e-01f, 3.52237672e-01f, 1.69641927e-01f,
  -2.88723469e-01f, -1.05031975e-01f, 4.40317780e-01f, 2.10760474e-01f, -1.04681969e-01f, 2.19546989e-01f, 1.78030267e-01f, -1.65333614e-01f, -3.77739668e-01f, -1.23345889e-01f,
  -1.10598929e-01f, 4.39692438e-01f, 4.24828291e-01f, 4.37120050e-01f, 2.38231033e-01f, 1.61584735e-01f, -1.55873388e-01f, -1.09773293e-01f, 2.33627215e-01f, -3.55975509e-01f,
  2.51078922e-02f, -3.06124032e-01f, 1.68665007e-01f, 2.50039369e-01f, -2.41461113e-01f, 3.99298400e-01f, -2.38748461e-01f, -8.15176889e-02f, 2.20548540e-01f, 4.48422432e-01f,
  8.49456936e-02f, -2.78665483e-01f, 5.68407059e-01f, 1.33474573e-01f, -2.54767716e-01f, 8.14844221e-02f, -6.42229617e-02f, 7.82291591e-03f, -3.07520211e-01f, 5.84089279e-01f,
  6.59399573e-03f, 2.86797583e-01f, -1.67689115e-01f, 6.46392047e-01f, 4.54305798e-01f, 4.98773038e-01f, 2.63624527e-02f, -6.42477125e-02f, -1.84840009e-01f, -7.54268095e-02f,
  -2.94796944e-01f, -2.70548373e-01f, 1.65722847e-01f, -2.99815089e-01f, -2.44012415e-01f, 1.37759864e-01f, 1.96222171e-01f, 5.31046391e-01f, -3.25415969e-01f, 3.18579137e-01f,
  3.66168916e-01f, 1.55824140e-01f, 3.11621517e-01f, -3.12901765e-01f, -9.92946401e-02f, -8.23206902e-02f, -2.95181692e-01f, -1.48650780e-01f, 3.70602280e-01f, 9.65104923e-02f,
  -5.40983304e-02f, 7.66193792e-02f, 5.76931685e-02f, -3.19435000e-02f, -1.44834006e-02f, 2.95580328e-01f, 3.00422877e-01f, 3.81631583e-01f, 6.31653666e-02f, 1.24783270e-01f,
  -4.11002636e-02f, 3.49154085e-01f, -4.45757136e-02f, -2.33709902e-01f, 2.34487101e-01f, 1.39287576e-01f, 1.01223879e-01f, -2.76685953e-01f, 2.25377902e-01f, 7.69562349e-02f,
  3.06387156e-01f, 1.40696362e-01f, 3.82522702e-01f, 5.12278855e-01f, 3.95311624e-01f, 3.06430757e-01f, -2.30964229e-01f, -7.25552663e-02f, 2.33548298e-01f, -7.27415532e-02f,
  4.18119729e-02f, -1.74127251e-01f, 2.48573855e-01f, -6.46105632e-02f, -2.37067997e-01f, 4.51149866e-02f, 7.86883906e-02f, 2.16311619e-01f, -7.81813264e-02f, 6.03878617e-01f,
  1.71026066e-01f, 1.59035563e-01f, -1.07434513e-02f, 1.44507661e-01f, -1.49051487e-01f, -3.08632076e-01f, 3.31385761e-01f, -2.19285518e-01f, 6.49095923e-02f, -1.84087142e-01f,
  1.59206018e-01f, 1.75862536e-01f, 1.22115172e-01f, 4.85991269e-01f, 2.70170718e-01f, 7.01083764e-02f, 1.61829516e-01f, -1.21294454e-01f, -1.97164044e-01f, 8.62941518e-02f,
  3.80580015e-02f, -1.68050393e-01f, 1.41532496e-01f, 6.34590238e-02f, 2.30047747e-01f, -1.37137889e-03f, -2.41637714e-02f, 2.87056863e-01f, 2.89963752e-01f, 3.83487254e-01f,
  2.04419225e-01f, 4.20631975e-01f, 3.00599784e-01f, 4.16399181e-01f, 2.64521360e-01f, -3.50847840e-01f, -1.98393017e-01f, 2.91737080e-01f, -2.23474368e-01f, 2.65210658e-01f,
  4.32038367e-01f, -1.69654295e-01f, -4.36703920e-01f, -3.89527641e-02f, 4.72555667e-01f, 1.89120770e-01f, 1.76628232e-01f, -1.07013807e-01f, -1.76195707e-02f, 1.20769121e-01f,
  -1.78886101e-01f, 5.64897180e-01f, 2.44928569e-01f, -2.10361287e-01f, 3.31216872e-01f, -2.53369480e-01f, -9.43695605e-02f, -2.43771493e-01f, 4.52798784e-01f, 4.44519877e-01f,
  3.99362624e-01f, 1.48799941e-01f, -2.50635799e-02f, 3.10646612e-02f, 2.36123219e-01f, 1.25547841e-01f, 5.27129648e-03f, -1.37889281e-01f, 9.30876657e-02f, -9.55588222e-02f,
  -8.78826994e-03f, 1.22062691e-01f, -1.24727964e-01f, 3.15055937e-01f, 1.69780731e-01f, 3.48113418e-01f, -1.38883308e-01f, -1.07804902e-01f, 2.12993085e-01f, -1.12312116e-01f,
  -5.91989309e-02f, -9.32472646e-02f, 5.07590652e-01f, 5.25086999e-01f, -6.20547086e-02f, 2.02536881e-01f, 3.22510421e-01f, 2.92190075e-01f, -1.22902386e-01f, 4.05784935e-01f,
  1.33659601e-01f, 5.50525725e-01f, -2.06330821e-01f, -4.06813286e-02f, 3.08551878e-01f, -6.60418421e-02f, 8.10823739e-02f, 3.22515637e-01f, 1.52312547e-01f, -1.95010573e-01f,
  -4.29711699e-01f, 1.32760704e-01f, -3.36508639e-02f, -1.62971511e-01f, 3.07042152e-01f, 1.58068731e-01f, 3.56846839e-01f, 3.10705483e-01f, -2.43940845e-01f, 2.56197572e-01f,
  -2.64483333e-01f, -3.33631396e-01f, 6.93106130e-02f, 2.52478957e-01f, 1.53078407e-01f, 2.57831007e-01f, 4.68483984e-01f, 4.88916673e-02f, 4.77626681e-01f, 3.31065387e-01f,
  6.53193891e-02f, 1.95050798e-02f, 1.83186308e-01f, -1.80555180e-01f, -2.38331005e-01f, 1.80855662e-01f, 8.62280428e-02f, -2.32473210e-01f, 3.83281320e-01f, -1.67282417e-01f,
  -2.07723156e-02f, 4.61641312e-01f, -1.79360360e-01f, 1.00547159e-02f, 1.46726340e-01f, -2.01149553e-01f, 3.25645320e-02f, 2.91998446e-01f, 3.66126031e-01f, 2.98045844e-01f,
  -3.02211970e-01f, 2.16608629e-01f, 4.40985948e-01f, 2.68075138e-01f, 3.04266483e-01f, -1.62553638e-01f, -2.15465948e-01f, -2.09146798e-01f, 2.80120730e-01f, 3.04134935e-01f,
  1.41974360e-01f, 1.94223851e-01f, -1.02765240e-01f, -8.86087772e-03f, -1.19312085e-01f, 2.32479334e-01f, -4.53363322e-02f, 5.09126842e-01f, 5.18096983e-01f, 5.14836609e-01f,
  1.33132800e-01f, 8.11854675e-02f, 2.97765702e-01f, 1.69438854e-01f, 6.74987733e-02f, -1.12292826e-01f, 3.48571122e-01f, 7.84476697e-02f, -3.49006474e-01f, 1.36746317e-01f,
  4.71306413e-01f, 2.43152946e-01f, 1.64760560e-01f, 4.79048014e-01f, -1.24861255e-01f, 3.05912588e-02f, 2.39427909e-01f, 1.51251003e-01f, -1.27675384e-01f, 1.29699588e-01f,
  2.31575623e-01f, 3.79811704e-01f, 6.69183061e-02f, 5.13620794e-01f, 4.30937022e-01f, -1.44706324e-01f, -1.94473356e-01f, 3.80540080e-02f, 2.62120634e-01f, -3.11084628e-01f,
  8.08756426e-02f, -1.70466706e-01f, 6.41068146e-02f, 1.10919155e-01f, 5.74052781e-02f, 1.09414667e-01f, -2.35143155e-02f, -2.42661878e-01f, 2.49226213e-01f, 1.09735824e-01f,
  3.56588006e-01f, -8.55712667e-02f, 2.88534369e-02f, 8.35826024e-02f, -6.34205416e-02f, -9.91573706e-02f, -2.42427498e-01f, 3.93257946e-01f, 4.01058532e-02f, -7.57592218e-03f,
  4.44861174e-01f, -1.60100982e-01f, 1.60041451e-01f, 5.79459965e-03f, -1.57717079e-01f, -1.08342372e-01f, 1.47796452e-01f, 3.22673917e-01f, -1.39569432e-01f, -3.08454305e-01f,
  3.05597321e-03f, 4.00974691e-01f, -1.80881456e-01f, 4.63834882e-01f, 2.50216305e-01f, 4.63009000e-01f, 2.98376232e-01f, -2.48933017e-01f, -5.70445210e-02f, -9.49903671e-03f,
  1.16843782e-01f, -2.29608208e-01f, 4.83125627e-01f, -1.66826904e-01f, 4.08873297e-02f, 2.28223726e-01f, -1.75060064e-01f, -2.65321702e-01f, -3.18529814e-01f, 1.77935749e-01f,
  -3.14530164e-01f, 8.22890401e-02f, 3.87570977e-01f, 1.36617154e-01f, 4.30694818e-01f, -8.14176723e-03f, -1.15080550e-02f, 1.51079297e-01f, 8.66093263e-02f, 2.18582168e-01f,
  2.99782027e-02f, 1.30269406e-02f, -2.77439743e-01f, 4.98838633e-01f, -3.11433583e-01f, 4.89583731e-01f, 1.16393164e-01f, -1.78528149e-02f, 1.63739920e-01f, 5.23788519e-02f,
  3.96704823e-01f, 1.94183990e-01f, 6.78357929e-02f, 7.97024965e-02f, -2.33639836e-01f, 5.12671888e-01f, 1.68382317e-01f, 2.29062676e-01f, -4.73440625e-03f, -5.52925020e-02f,
  -1.93402037e-01f, 1.60586499e-02f, -1.08079620e-01f, 1.55399457e-01f, 1.44626752e-01f, 3.92425150e-01f, -4.84189242e-02f, 4.11388874e-01f, 6.54354468e-02f, 4.28577900e-01f,
  -1.54586714e-02f, 1.78738222e-01f, -1.13357596e-01f, 3.24925274e-01f, -2.98208654e-01f, -6.97871074e-02f, 4.02798384e-01f, -1.46399960e-01f, 1.23249270e-01f, 1.95823193e-01f,
  2.76429474e-01f, 1.73991501e-01f, 2.53084451e-01f, 4.45049144e-02f, -6.08616471e-02f, -2.88581401e-02f, 1.12333640e-01f, 4.31642592e-01f, 4.67764735e-02f, 2.88449556e-01f,
  -5.94304614e-02f, -2.46411771e-01f, -1.55874431e-01f, 4.60878789e-01f, 1.50143221e-01f, 2.47306541e-01f, 2.42664769e-01f, -1.01222254e-01f, 1.85908839e-01f, 5.31015217e-01f,
  -5.92708811e-02f, 2.91452885e-01f, 1.27193555e-02f, 4.99769568e-01f, -3.37581724e-01f, -3.07014644e-01f, -4.09594804e-01f, 4.46952969e-01f, 1.49201438e-01f, 2.22133204e-01f,
  2.83204913e-01f, 1.91257596e-01f, 3.20440710e-01f, 8.68054777e-02f, 1.20483227e-01f, 4.13674861e-01f, -1.86214358e-01f, 2.40802273e-01f, 3.99387658e-01f, 4.36822742e-01f,
  1.02631010e-01f, -1.25628769e-01f, 3.65052931e-02f, -3.41649324e-01f, -2.00804844e-02f, 2.34615132e-01f, 1.35627985e-01f, 3.91514570e-01f, 1.93692103e-01f, -3.12655307e-02f,
  4.28754836e-01f, 5.66593230e-01f, 7.32950643e-02f, 2.46137276e-01f, 8.36941507e-03f, 2.68152446e-01f, 1.61719069e-01f, -2.61357188e-01f, -2.44855836e-01f, 5.58224060e-02f,
  2.39440687e-02f, -1.59358397e-01f, 2.10514933e-01f, 4.98180956e-01f, 2.79460788e-01f, -5.04504144e-01f, 2.39766479e-01f, -4.40737121e-02f, 4.85247783e-02f, 1.61045641e-01f,
  1.80760622e-01f, -1.28992990e-01f, -4.24981788e-02f, 1.66845024e-01f, 4.38240856e-01f, 1.46489173e-01f, -7.58554041e-03f, -2.47512251e-01f, -2.47482270e-01f, 1.40866652e-01f,
  2.63391137e-01f, 5.91534197e-01f, 8.41010958e-02f, 1.26092043e-02f, 3.44744295e-01f, 1.71005309e-01f, 2.98440695e-01f, 2.61426598e-01f, 3.97270590e-01f, 4.53435957e-01f,
  1.88780487e-01f, 8.10158178e-02f, -5.01275301e-01f, 2.95012951e-01f, -2.67662555e-01f, -1.86563134e-01f, -1.29781947e-01f, 4.28046703e-01f, 2.25539450e-02f, -1.48148984e-01f,
  2.95520127e-01f, 3.27386409e-01f, -1.07582435e-01f, -1.46813756e-02f, 6.33263111e-01f, 1.25094250e-01f, 1.90796092e-01f, 2.40189776e-01f, 2.82706618e-02f, 5.10229290e-01f,
  5.75153828e-01f, 2.37261608e-01f, -9.64676216e-02f, -1.72394812e-01f, 1.30546331e-01f, -2.09356800e-01f, -2.45347977e-01f, 1.45215139e-01f, 2.46569365e-01f, -1.42641187e-01f,
  -2.13670701e-01f, -2.34173238e-01f, -1.54746339e-01f, -2.81591177e-01f, 4.73301932e-02f, 1.14018418e-01f, 1.57167688e-01f, 2.07402140e-01f, 5.95376976e-02f, -2.20479771e-01f,
  -3.26564193e-01f, 2.90495694e-01f, -3.24294209e-01f, 4.25174475e-01f, 7.06242800e-01f, -4.42365408e-02f, -1.68377131e-01f, -3.41380626e-01f, 9.68648568e-02f, -3.16879004e-01f,
  -1.47526458e-01f, 3.98078591e-01f, 2.11910591e-01f, 3.70794117e-01f, 2.39150375e-01f, 2.05841690e-01f, 3.23461890e-01f, -2.06941664e-01f, 1.28316179e-01f, -5.02084315e-01f,
  -1.42539307e-01f, 1.14887916e-01f, 3.20763171e-01f, -4.42595005e-01f, -1.43398717e-01f, 3.64629865e-01f, -2.36143485e-01f, 2.58325227e-02f, -1.89591199e-02f, -1.00641556e-01f,
  -7.00025633e-02f, 3.76533866e-02f, 2.83835620e-01f, -3.32311727e-02f, -1.81739062e-01f, 5.35811782e-01f, 8.24560225e-02f, 1.84688210e-01f, -7.28637055e-02f, -3.68251920e-01f,
  1.62581652e-01f, -3.06305408e-01f, 3.89609247e-01f, 1.34251475e-01f, 2.33557120e-01f, 1.83330134e-01f, 5.53111315e-01f, 4.83304411e-01f, -3.35175514e-01f, 2.51040548e-01f,
  9.79941785e-02f, -7.43963048e-02f, -2.25727946e-01f, 4.30507183e-01f, 2.74903595e-01f, 4.70089853e-01f, -2.65276935e-02f, -1.01600252e-01f, 5.32558076e-02f, -1.96131483e-01f,
  -1.03650071e-01f, -6.57382747e-03f, 7.48101715e-03f, -2.01012090e-01f, -2.33777180e-01f, 1.54152662e-01f, 1.73044607e-01f, 4.80496854e-01f, 2.61917740e-01f, -2.11923793e-02f,
  1.35124624e-01f, -1.28617018e-01f, 3.82796764e-01f, 4.44548517e-01f, 3.14076662e-01f, 1.52218482e-02f, 4.96400803e-01f, 3.44379306e-01f, -3.48394752e-01f, -3.01476326e-02f,
  -7.65504986e-02f, -3.04579228e-01f, 3.80953819e-01f, -2.45332718e-01f, 9.72430184e-02f, -2.64562845e-01f, 4.83274221e-01f, -1.18059769e-01f, 4.26331341e-01f, -3.85572076e-01f,
  -2.65455633e-01f, -8.03244188e-02f
};

// L1_fan_Bp_bar (Shape: 1 x 26)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 26;
const float L1_fan_Bp_bar_data[] = {
  1.10500082e-01f, 1.95826158e-01f, 1.63798988e-01f, 2.04150826e-01f, 8.51593688e-02f, 9.82022211e-02f, 2.21752450e-01f, 2.10966170e-01f, 8.61349422e-03f, -4.81163524e-03f,
  9.80032086e-02f, 3.38177234e-01f, 1.39014438e-01f, 1.53984874e-01f, 9.58038345e-02f, 1.57894626e-01f, 2.99944192e-01f, 1.98018685e-01f, 2.02690735e-01f, 2.04815656e-01f,
  2.58827180e-01f, 2.00282320e-01f, -5.02475910e-02f, 3.04895312e-01f, 2.06645414e-01f, 2.20022142e-01f
};

// L2_linear_W (Shape: 12 x 32)
const int L2_linear_W_rows = 12;
const int L2_linear_W_cols = 32;
const float L2_linear_W_data[] = {
  -4.82479334e-02f, -2.62057513e-01f, 5.87305948e-02f, -3.01167279e-01f, -1.24737605e-01f, 1.05559498e-01f, 3.54298949e-01f, -8.73248354e-02f, 2.07806334e-01f, 1.75123081e-01f,
  -3.51683825e-01f, 3.85638028e-02f, 1.15005247e-01f, -1.53630614e-01f, -1.74481317e-01f, 4.75417465e-01f, -2.83545047e-01f, -6.52330518e-02f, -5.96828640e-01f, -4.94995356e-01f,
  -4.55713540e-01f, -1.63357630e-01f, 6.77059218e-02f, -6.18709207e-01f, -1.26516104e-01f, 2.26943586e-02f, 1.02330610e-01f, -4.33964878e-01f, 6.88249052e-01f, 3.72070491e-01f,
  2.77445138e-01f, 3.98903161e-01f, -6.44707978e-02f, -1.12771410e-02f, 1.20060749e-01f, -4.31640893e-01f, 4.05796707e-01f, -4.72502172e-01f, 2.10111856e-01f, -4.39581662e-01f,
  7.21007660e-02f, -2.68701464e-01f, -1.17067806e-01f, 5.45573711e-01f, -6.83011055e-01f, -6.37827754e-01f, 1.26087159e-01f, -3.78183842e-01f, -4.08400685e-01f, 4.04314756e-01f,
  -1.04560480e-01f, 3.36509377e-01f, -6.76433325e-01f, -3.85719925e-01f, -5.65264411e-02f, -5.65841012e-02f, -2.18910560e-01f, -5.19360662e-01f, 1.90779328e-01f, 2.44707122e-01f,
  -5.39220273e-01f, 4.93611157e-01f, 1.27496153e-01f, 5.19596756e-01f, 1.63718283e-01f, 1.07233785e-01f, 1.68046936e-01f, -6.46711290e-02f, -1.06720783e-01f, 2.56504536e-01f,
  -1.33588433e-01f, -3.30958724e-01f, -4.00895625e-01f, 2.18152449e-01f, 1.75925955e-01f, -1.24727048e-01f, -1.67344704e-01f, 1.85734302e-01f, -4.76702362e-01f, -4.05133516e-01f,
  -6.05838671e-02f, 2.54002124e-01f, 5.53957283e-01f, -3.24216098e-01f, -3.99970263e-01f, -1.65451646e-01f, -3.49562824e-01f, -3.33780907e-02f, 3.41848165e-01f, -5.07249296e-01f,
  -3.40017408e-01f, 3.81855905e-01f, -1.58543251e-02f, -3.09496939e-01f, 5.34097552e-01f, -5.82566559e-01f, -3.43390763e-01f, 1.40051752e-01f, 1.03156053e-01f, -1.17862970e-01f,
  -1.10632509e-01f, -2.03474775e-01f, -5.10131836e-01f, 2.49939263e-01f, 1.14043906e-01f, 1.99786842e-01f, -2.15948731e-01f, 2.83414172e-03f, 4.20201898e-01f, -4.89926010e-01f,
  1.58620387e-01f, 2.60743916e-01f, 2.67140806e-01f, -6.31378174e-01f, -4.87209350e-01f, -4.68515977e-02f, 3.63435775e-01f, 2.99912661e-01f, 1.22154906e-01f, -4.94308889e-01f,
  -2.76609600e-01f, -6.92882121e-01f, -6.51258230e-01f, -5.26396811e-01f, 5.74362695e-01f, -3.42535526e-01f, -1.00145988e-01f, 2.21656203e-01f, -2.75032106e-03f, 7.52565190e-02f,
  1.06246240e-01f, 1.90267205e-01f, 4.59029377e-01f, 2.02886358e-01f, 2.85662949e-01f, 4.05640364e-01f, -7.55321234e-04f, 1.84166983e-01f, -4.12039936e-01f, -4.18905854e-01f,
  1.70358136e-01f, -7.27908850e-01f, -5.20204902e-01f, -1.19253725e-01f, -2.12050021e-01f, -3.95626605e-01f, 4.18065637e-02f, 3.74593586e-01f, -2.03781649e-01f, 4.58067745e-01f,
  -1.57266304e-01f, 7.89069235e-02f, 3.80916536e-01f, 2.30693415e-01f, 2.09382221e-01f, 3.22653741e-01f, 5.96690141e-02f, -5.64344764e-01f, -2.29197189e-01f, -1.89383090e-01f,
  2.51288384e-01f, 2.37819359e-01f, 1.05917484e-01f, -3.28275114e-01f, 4.45202291e-01f, 3.15205038e-01f, -1.11460641e-01f, 3.80223878e-02f, -1.54634133e-01f, -6.84400976e-01f,
  -2.66422957e-01f, 2.78456002e-01f, 4.79817331e-01f, 1.02794291e-02f, -3.76075894e-01f, 1.26514226e-01f, 8.14654306e-03f, 1.63647547e-01f, -4.38366950e-01f, 2.28243008e-01f,
  3.04395348e-01f, -4.55033958e-01f, 2.50380665e-01f, 4.59292471e-01f, -2.05074713e-01f, 1.93831235e-01f, 2.54929930e-01f, -2.37199470e-01f, -4.31517273e-01f, 4.65648800e-01f,
  -6.45951807e-01f, -6.39031172e-01f, -4.77484874e-02f, -1.21949621e-01f, -1.16168916e-01f, 2.77581215e-01f, -5.04200935e-01f, 1.03348501e-01f, -6.71081364e-01f, -3.22781324e-01f,
  4.32085186e-01f, 3.05523187e-01f, -4.82769310e-01f, -3.33994716e-01f, -6.33414090e-01f, 5.49578428e-01f, -1.48165509e-01f, -5.35917938e-01f, -3.04812133e-01f, -5.22752643e-01f,
  1.88880309e-01f, 1.48062065e-01f, -4.92645770e-01f, -4.56023216e-01f, 4.13521767e-01f, 3.24473232e-01f, -3.92083637e-02f, 2.90812671e-01f, 1.58221886e-01f, 9.36815888e-02f,
  -1.80868104e-01f, 3.24221432e-01f, 2.14358836e-01f, -1.90916374e-01f, 1.21467523e-01f, 2.81567480e-02f, 1.04793787e-01f, -4.81692627e-02f, -2.78825998e-01f, 6.66505769e-02f,
  1.69642065e-02f, -1.14080064e-01f, -4.19096239e-02f, -4.70912158e-01f, -1.73524022e-01f, -5.85215501e-02f, 3.90016109e-01f, 2.74358958e-01f, 5.48603058e-01f, -2.74796635e-01f,
  1.38189897e-01f, -1.18949369e-01f, 3.58344376e-01f, 4.82114017e-01f, 4.28424358e-01f, 8.36876184e-02f, -4.16671365e-01f, -3.21347892e-01f, 2.31371418e-01f, -3.39274704e-02f,
  -4.97052968e-01f, -4.47334915e-01f, 9.31609124e-02f, -3.27066898e-01f, -4.85587448e-01f, -1.15091927e-01f, 1.61511470e-02f, -2.47147933e-01f, -6.38783574e-02f, 1.73979729e-01f,
  3.26144248e-01f, -6.99485317e-02f, -4.43666130e-01f, -3.12718362e-01f, -2.74822205e-01f, -4.43488359e-01f, 2.72464216e-01f, 4.50477868e-01f, -2.03229293e-01f, 2.92281955e-01f,
  4.22785401e-01f, 3.76600176e-01f, 3.31686467e-01f, 1.74688831e-01f, 1.30823731e-01f, -3.72401834e-01f, 4.87444282e-01f, -3.29407960e-01f, -2.75895894e-01f, -3.59656602e-01f,
  -5.35776019e-01f, -2.33413741e-01f, -2.90368766e-01f, 1.17494157e-02f, -4.31163497e-02f, -2.85637915e-01f, 2.15887427e-01f, 1.22949630e-01f, 2.27931693e-01f, 3.32911164e-01f,
  -2.24548995e-01f, -3.89847100e-01f, 1.64807215e-01f, 1.30391270e-01f, 5.36331058e-01f, -5.96344173e-01f, 3.02775443e-01f, -5.10119379e-01f, -1.81744352e-01f, -3.02557409e-01f,
  -5.32347523e-02f, 2.49777734e-01f, -1.37378916e-01f, -4.15440053e-01f, -4.95205939e-01f, -4.83227670e-01f, 1.17473193e-01f, -3.28867316e-01f, 3.35897267e-01f, -1.29176140e-01f,
  -1.86794981e-01f, -4.09874231e-01f, 4.71506476e-01f, 4.26278800e-01f, 5.10199308e-01f, -7.56508350e-01f, -4.34360266e-01f, -6.10079587e-01f, 2.89260298e-01f, -2.02279553e-01f,
  -1.31887808e-01f, -1.47232309e-01f, -2.57186711e-01f, 2.10996792e-01f, -3.54513109e-01f, -2.58295655e-01f, -3.07178795e-01f, 3.17803383e-01f, -4.13284510e-01f, 4.37395006e-01f,
  3.95878106e-01f, -3.01351249e-01f, -2.46341795e-01f, -2.95858890e-01f, -2.62976140e-01f, 4.66121100e-02f, 2.96664476e-01f, 5.46456695e-01f, -5.08607864e-01f, -2.05108121e-01f,
  -4.89760965e-01f, 1.23043872e-01f, -3.12211961e-01f, -3.11862320e-01f, -2.70936400e-01f, -2.52589047e-01f, -3.16348165e-01f, 4.37534451e-01f, -4.73790139e-01f, -2.12357968e-01f,
  -4.05483156e-01f, 3.12318593e-01f, 3.25259827e-02f, -9.06287432e-02f, 8.38939473e-02f, -2.61233039e-02f, -2.50732839e-01f, 1.80052578e-01f, -3.51041317e-01f, -5.49423583e-02f,
  -2.58908004e-01f, 3.23805243e-01f, 3.18066657e-01f, -4.96346295e-01f, 2.27628797e-01f, 5.16612887e-01f, 3.36302221e-01f, 2.92575687e-01f, 1.85461953e-01f, -3.15420777e-01f,
  -2.84383863e-01f, -5.28534591e-01f, 1.43747494e-01f, -3.91564071e-01f, 4.35471147e-01f, 3.86074454e-01f, -1.49307609e-01f, 1.44050866e-01f, -4.98465657e-01f, 7.12333322e-02f,
  -1.18547864e-02f, -2.49127045e-01f, -4.89865541e-01f, -3.02512348e-01f
};

// L2_linear_B (Shape: 1 x 12)
const int L2_linear_B_rows = 1;
const int L2_linear_B_cols = 12;
const float L2_linear_B_data[] = {
  -1.45170033e-01f, 1.38132662e-01f, 2.02325359e-02f, 6.65764362e-02f, 8.97591710e-02f, 8.05340037e-02f, -8.47178549e-02f, -2.38165334e-01f, 2.55291574e-02f, 2.76173111e-02f,
  4.27329838e-02f, -6.94569200e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 3, 26
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        32, 3, 26
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_linear
    linear_forward_pgm(
        buffer1, x_out,
        L2_linear_W_data, L2_linear_B_data,
        32, 12
    );
    }
    