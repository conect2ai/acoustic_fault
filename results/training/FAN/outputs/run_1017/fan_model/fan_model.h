/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 32 (x1)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 32;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    float x3 = x * x * x;
    return 0.5f * x * (1.0f + tanhf(0.79788456f * (x + 0.044715f * x3)));
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 12 x 120)
const int L0_fan_Wp_rows = 12;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -7.21082509e-01f, 1.80711746e-01f, -4.92136747e-01f, -2.18873769e-01f, 3.08853805e-01f, 1.46924347e-01f, 2.02085897e-01f, -2.01554857e-02f, 1.04947202e-02f, -2.84175929e-02f,
  3.82073045e-01f, 1.91651568e-01f, 1.68111771e-01f, 4.60310914e-02f, -8.12936127e-02f, -9.36046094e-02f, -2.81573862e-01f, -4.80655819e-01f, -1.95791140e-01f, 1.20066799e-01f,
  2.01286525e-01f, -1.25004709e-01f, -2.51132846e-01f, -1.37618467e-01f, 8.89230072e-02f, 1.99559867e-01f, -5.71490563e-02f, 1.83530792e-04f, 1.23261146e-01f, -2.95178056e-01f,
  -9.71336365e-02f, -1.41508222e-01f, 1.24977581e-01f, -2.58125793e-02f, -3.00265243e-03f, -9.35834795e-02f, -8.77649859e-02f, -1.16138048e-01f, 1.30720511e-02f, -6.01432249e-02f,
  -3.14038876e-03f, 8.86512082e-03f, -1.91812124e-03f, 2.98032667e-02f, 4.05517593e-03f, 9.37141757e-03f, -5.34602553e-02f, -1.62276059e-01f, -6.08542338e-02f, -4.64965440e-02f,
  1.25650913e-01f, -3.89724076e-02f, -1.41955152e-01f, 2.14260966e-02f, -3.07116527e-02f, -9.15992707e-02f, -1.46407038e-02f, 1.95630873e-03f, -1.10316530e-01f, -1.42369375e-01f,
  2.12365314e-02f, 3.43625643e-03f, 7.63696656e-02f, -4.11257846e-03f, 3.56829278e-02f, 2.43292768e-02f, -4.02183346e-02f, 9.76702422e-02f, 2.77196113e-02f, -5.25293835e-02f,
  6.20749146e-02f, 2.60828286e-02f, 3.66471969e-02f, -6.67471439e-02f, 6.13147654e-02f, -9.81107131e-02f, -8.27341229e-02f, 5.27598523e-02f, 1.67321973e-02f, -3.24445255e-02f,
  2.97531150e-02f, 1.88383609e-02f, -3.27484198e-02f, -5.58352061e-02f, -2.31058244e-02f, -9.74118989e-03f, 5.63751953e-03f, 7.34078288e-02f, 7.10222870e-02f, -2.99166702e-02f,
  7.00703859e-02f, -2.71352790e-02f, -7.52705261e-02f, -1.25690326e-02f, -1.66633502e-02f, 5.60232215e-02f, 5.77452257e-02f, 8.47156495e-02f, 8.55688229e-02f, 1.14540076e-02f,
  7.74582848e-02f, 1.73552837e-02f, 2.68533584e-02f, 5.68684265e-02f, 1.91390477e-02f, 1.13652356e-01f, 9.99408886e-02f, -5.44667132e-02f, -2.28637941e-02f, 5.62532023e-02f,
  5.46613447e-02f, -4.92127016e-02f, 1.34593369e-02f, 1.21935971e-01f, 5.31984977e-02f, 8.28619003e-02f, 8.73399228e-02f, 9.85950455e-02f, -1.41855394e-02f, 9.48943838e-04f,
  8.44964623e-01f, -3.20247680e-01f, 8.08725432e-02f, 2.50117600e-01f, 4.23967615e-02f, 1.11689299e-01f, -1.56976674e-02f, 2.75037616e-01f, 3.86958450e-01f, -8.18491876e-02f,
  -4.27660197e-02f, 5.21222055e-02f, 1.35313869e-01f, 5.45297153e-02f, 1.23346917e-01f, -1.37069017e-01f, -1.49588749e-01f, 1.34643137e-01f, 2.96937436e-01f, 1.55463099e-01f,
  -5.33040501e-02f, -6.54379651e-02f, 1.24237739e-01f, 1.51061475e-01f, -1.16338067e-01f, 5.88663667e-02f, 2.53473073e-02f, -8.87638479e-02f, -1.28765732e-01f, -3.03069055e-01f,
  6.16799369e-02f, 1.69566408e-01f, 2.12838098e-01f, 1.25630433e-02f, -5.83974905e-02f, 1.90782622e-01f, 1.38578668e-01f, 1.55791610e-01f, 1.02907039e-01f, 1.78437769e-01f,
  5.01014106e-02f, 1.26821518e-01f, 9.10058320e-02f, 5.28349653e-02f, 1.59664929e-01f, 8.45029876e-02f, 1.36723489e-01f, 1.85211614e-01f, 1.66520685e-01f, 1.51599348e-01f,
  -1.75851628e-01f, -1.16582967e-01f, 9.64138731e-02f, 6.36689216e-02f, 1.17092632e-01f, 9.86589864e-02f, 4.27139252e-02f, 6.59529045e-02f, 2.49572098e-01f, 1.41822338e-01f,
  -6.40041614e-03f, -1.06988586e-01f, -7.71639422e-02f, -8.14540088e-02f, -1.05336621e-01f, -3.38019687e-03f, 2.42715725e-03f, -1.29484013e-01f, -3.12287770e-02f, -1.02488361e-02f,
  -2.62686815e-02f, -3.86499576e-02f, -4.29180749e-02f, 4.06714855e-03f, -1.40093341e-01f, -7.09548518e-02f, -9.47578251e-02f, -1.04564019e-01f, -1.33360863e-01f, -5.27443998e-02f,
  -7.36117214e-02f, 1.05145583e-02f, 2.03159894e-03f, -1.24888569e-01f, -1.39982194e-01f, -6.25317320e-02f, -9.72111598e-02f, -9.05439928e-02f, -4.46844473e-02f, 3.52237420e-03f,
  3.56709749e-01f, -9.65937302e-02f, 1.84353337e-01f, 1.56256244e-01f, 6.40717596e-02f, 6.57897070e-02f, -1.35823814e-02f, 1.29775435e-01f, -6.63033407e-03f, 4.63034697e-02f,
  3.31897400e-02f, 1.61952108e-01f, -2.39171330e-02f, 4.33438122e-02f, 1.54262692e-01f, 1.23739950e-01f, -6.05952889e-02f, 1.08351819e-01f, 3.48014608e-02f, 1.23822078e-01f,
  -5.67116477e-02f, 1.91670656e-01f, 2.72984773e-01f, 1.07372612e-01f, 8.43699202e-02f, 1.48887724e-01f, 1.62237734e-01f, 1.65487558e-01f, 1.71238691e-01f, 1.96610257e-01f,
  -4.98733819e-01f, 5.78077659e-02f, -3.51969987e-01f, -5.44535995e-01f, -2.83960789e-01f, 7.66851082e-02f, 2.40161985e-01f, 2.11516365e-01f, -7.16019943e-02f, -1.72580540e-01f,
  1.19823165e-01f, 5.00712208e-02f, -1.20388821e-01f, 1.56667456e-01f, 3.19028139e-01f, -2.48791818e-02f, -1.61405101e-01f, -4.28427197e-02f, 1.06558055e-01f, 1.81430027e-01f,
  -4.34293672e-02f, -1.24771632e-01f, -5.35563342e-02f, 9.44408178e-02f, -1.81461930e-01f, -8.82240310e-02f, -1.02202818e-01f, -1.48117840e-01f, 6.95264190e-02f, -4.42409307e-01f,
  -3.43682885e-01f, -1.51027232e-01f, 9.53977108e-02f, 2.82095820e-02f, -2.84727309e-02f, 1.30692810e-01f, 3.39603201e-02f, 5.04641384e-02f, 7.40141124e-02f, -4.58153747e-02f,
  -5.26973233e-02f, 1.05379662e-02f, -7.41479620e-02f, -8.10289569e-03f, -8.32096338e-02f, 6.04945235e-02f, 3.39431018e-02f, 9.07691941e-02f, -3.50388116e-03f, 5.17683327e-02f,
  -9.22511593e-02f, -8.76569077e-02f, -1.06599800e-01f, 3.26009914e-02f, 9.19232816e-02f, -3.96510549e-02f, 1.07549950e-01f, -4.22329716e-02f, 4.67043780e-02f, -1.44179344e-01f,
  6.11014627e-02f, -6.05997667e-02f, 1.43737309e-02f, 6.36629462e-02f, 3.53563540e-02f, 2.43714415e-02f, 6.96959123e-02f, -1.55195892e-02f, -4.69135940e-02f, 5.71645573e-02f,
  3.16793174e-02f, -1.83820967e-02f, 2.06674300e-02f, 5.25394119e-02f, -3.87966335e-02f, 1.34125538e-02f, 1.69480816e-02f, 4.91132103e-02f, -7.63966888e-02f, 7.56143406e-02f,
  1.13810925e-02f, -1.84629839e-02f, -4.63058390e-02f, -4.09904197e-02f, 8.34164694e-02f, -8.02986976e-03f, -5.29106706e-02f, 6.04974218e-02f, -9.01518464e-02f, -6.59316853e-02f,
  -4.84870374e-02f, 2.05704048e-01f, -1.17877036e-01f, 5.48703857e-02f, -1.30655184e-01f, -3.02818045e-02f, -1.51512951e-01f, 1.07013974e-02f, -1.28116027e-01f, -7.22008720e-02f,
  7.70623013e-02f, -5.37798069e-02f, -8.26046020e-02f, -7.39827305e-02f, 2.98952349e-02f, -2.77694147e-02f, 3.55148502e-02f, -6.95197508e-02f, 1.56877488e-01f, -5.18567078e-02f,
  1.23123102e-01f, 1.80705816e-01f, 5.86754791e-02f, 1.55876298e-02f, -4.69166674e-02f, 4.48567197e-02f, 7.12219800e-04f, 3.34556103e-02f, 1.86794594e-01f, 2.01039642e-01f,
  1.54030636e-01f, 5.78397838e-03f, 3.42718005e-01f, -1.17893763e-01f, 4.80307676e-02f, 2.11631417e-01f, 2.57398218e-01f, 2.85843164e-02f, -5.77887371e-02f, 1.04049288e-01f,
  1.29823521e-01f, 1.28282784e-02f, 1.05788037e-01f, -3.90128680e-02f, -1.66573040e-02f, 1.42096370e-01f, -1.91721767e-02f, 3.79870757e-02f, -7.41617084e-02f, -2.52744168e-01f,
  -3.47224414e-01f, -2.24222466e-01f, -1.03706472e-01f, -7.81066567e-02f, -7.34823570e-02f, -6.27097636e-02f, 2.09056094e-01f, -2.30845585e-02f, -7.77422190e-02f, -2.45566726e-01f,
  1.38393030e-01f, -6.36279583e-02f, -2.40960494e-02f, -1.84724599e-01f, -2.37251893e-02f, -3.45342644e-02f, 1.10696994e-01f, -8.46725777e-02f, 4.65518199e-02f, -4.51999605e-02f,
  -6.72478154e-02f, -9.15208831e-02f, -1.03587277e-01f, -1.37228131e-01f, -3.93716395e-02f, 3.18048783e-02f, -1.84232425e-02f, -1.38573408e-01f, 4.56484733e-03f, -8.50643888e-02f,
  -1.31549373e-01f, -1.50798168e-02f, 2.17125237e-01f, 8.38633925e-02f, -1.59024224e-01f, -9.96386781e-02f, 1.51808728e-02f, -2.26906370e-02f, -1.86153110e-02f, 2.21641995e-02f,
  -3.37194768e-03f, -8.43050424e-03f, -7.08842799e-02f, -5.88472225e-02f, 2.54623475e-03f, -3.88680138e-02f, 2.52828728e-02f, -6.67474493e-02f, -1.01692215e-01f, -9.92678944e-03f,
  -3.87424678e-02f, 5.74234128e-02f, -1.72740072e-02f, 6.51629493e-02f, -1.46825435e-02f, 3.05077806e-02f, -4.17429656e-02f, -6.32664515e-03f, -1.93140598e-03f, -4.07759063e-02f,
  -7.09271654e-02f, -5.27629256e-02f, 8.67947191e-03f, -8.90960023e-02f, -3.20990346e-02f, -9.99566913e-03f, -4.49805101e-03f, -7.73128495e-02f, -4.86130603e-02f, -7.79466005e-03f,
  1.99679986e-01f, 1.22202449e-01f, -4.73497249e-02f, -9.79615226e-02f, 4.35765721e-02f, -1.38399499e-02f, -2.20317813e-03f, -1.04794130e-02f, 6.16256408e-02f, 1.43287028e-03f,
  -1.28977001e-02f, 7.90696591e-03f, 4.70004901e-02f, 1.04200207e-02f, 8.65120888e-02f, 2.16977354e-02f, -4.28188033e-02f, 7.74036199e-02f, 1.38141206e-02f, -4.17901836e-02f,
  -7.49628842e-02f, -2.55959574e-03f, 1.37851894e-01f, 1.79198325e-01f, -5.25166765e-02f, 1.71958551e-01f, 1.89779416e-01f, 9.94791389e-02f, 1.99914753e-01f, 1.49704948e-01f,
  6.87631845e-01f, -2.55309522e-01f, 7.19162226e-02f, 2.58857787e-01f, -4.91943732e-02f, -1.63184941e-01f, -3.28504294e-01f, -1.45130038e-01f, -4.90385219e-02f, -3.33161317e-02f,
  -1.03812195e-01f, -1.86909303e-01f, -2.18361437e-01f, -2.64927596e-01f, -8.05104673e-02f, -3.42139930e-01f, -2.18157843e-01f, 5.50231151e-02f, 2.38288879e-01f, 6.56971708e-02f,
  -1.16341390e-01f, 1.76292375e-01f, 4.08999979e-01f, 1.83532536e-01f, -9.48750377e-02f, -2.70759314e-02f, -4.35185507e-02f, 1.86877668e-01f, -1.18463889e-01f, -1.37591392e-01f,
  -2.76366342e-02f, 4.53604072e-01f, -3.08522489e-02f, -5.19593023e-02f, -3.61034796e-02f, 7.86641315e-02f, -7.32459575e-02f, 2.88413670e-02f, 3.86012234e-02f, -1.59855967e-03f,
  -4.37745312e-03f, 8.86027236e-03f, -1.15415052e-01f, -1.11288719e-01f, 1.16418200e-02f, 2.55638920e-03f, 1.60831586e-02f, 1.06524425e-02f, -2.65145879e-02f, -1.39046401e-01f,
  -2.32498005e-01f, -1.30212680e-03f, 8.58322755e-02f, -1.03484362e-01f, -5.38943782e-02f, -1.18581932e-02f, 1.58796720e-02f, 3.29583958e-02f, 1.05755202e-01f, 9.08109397e-02f,
  -1.01090278e-02f, 1.35737080e-02f, -3.67602482e-02f, -3.77539992e-02f, -7.14082420e-02f, -6.02467135e-02f, -2.07488369e-02f, 5.18118516e-02f, 3.94102074e-02f, 3.55960466e-02f,
  7.78175332e-03f, -1.83750445e-03f, 4.79351841e-02f, 1.16531678e-01f, 3.56355011e-02f, 9.30010807e-03f, 1.30550079e-02f, 6.68662265e-02f, 8.04810300e-02f, 8.49606544e-02f,
  1.12332083e-01f, 1.49758141e-02f, 3.77124026e-02f, -1.12560309e-01f, 2.59187594e-02f, 5.02873622e-02f, 8.29550773e-02f, 5.24017885e-02f, 9.73886549e-02f, 7.67901540e-02f,
  -1.76101014e-01f, -2.01545045e-01f, -1.48053765e-01f, -6.73438534e-02f, 2.57434174e-02f, -6.47365376e-02f, -7.18702525e-02f, 3.58028114e-02f, -4.55413163e-02f, -3.72349285e-03f,
  2.31309969e-04f, 1.62605830e-02f, -6.15469813e-02f, -1.04412608e-01f, -4.41490002e-02f, -9.83048156e-02f, -1.07165843e-01f, -7.98588246e-02f, -1.15434863e-01f, -7.81295262e-03f,
  -8.20594579e-02f, -2.57869214e-02f, -4.53700311e-02f, -1.59052700e-01f, -1.02099851e-01f, -2.96578445e-02f, -2.28427991e-01f, -1.66860774e-01f, -2.36332178e-01f, -1.59754023e-01f,
  2.98859328e-01f, -9.67991352e-02f, -3.74423295e-01f, -1.63582459e-01f, -1.27767012e-01f, -1.56931728e-01f, -1.70550779e-01f, -8.85166973e-02f, 2.00259667e-02f, -2.20226645e-01f,
  9.27650854e-02f, 1.75158784e-01f, -6.84929043e-02f, 3.44812647e-02f, -7.72547796e-02f, -3.85426521e-01f, -4.26086903e-01f, -3.51743013e-01f, -1.04352549e-01f, 2.16404479e-02f,
  8.34487453e-02f, 4.51010242e-02f, 1.37474835e-01f, 8.24246630e-02f, -1.30458072e-01f, -4.12370898e-02f, -5.20893373e-02f, -7.26701170e-02f, -1.48705661e-01f, -4.78428781e-01f,
  -3.06800097e-01f, 6.36968836e-02f, -8.45753625e-02f, 1.15379229e-01f, 2.85067223e-02f, 7.41210058e-02f, -6.72040954e-02f, 5.59258014e-02f, 4.72800210e-02f, -1.12327583e-01f,
  5.70604764e-02f, 7.18828738e-02f, -2.78685559e-02f, 6.40281066e-02f, 5.90155423e-02f, -2.77123936e-02f, -6.40820935e-02f, 3.62740457e-02f, 1.70670412e-02f, -2.23324373e-02f,
  9.96716917e-02f, -7.45413899e-02f, -1.18218742e-01f, 9.98637266e-03f, -5.32265417e-02f, 4.68733646e-02f, -3.42369452e-02f, -6.62884042e-02f, -3.43185402e-02f, -6.05079085e-02f,
  2.31014728e-03f, -6.60387576e-02f, -5.35292290e-02f, 2.24736892e-02f, 3.65631804e-02f, -1.18462287e-03f, -6.15832619e-02f, -6.07146099e-02f, -5.03428690e-02f, -4.07467186e-02f,
  -5.90107664e-02f, -6.49898425e-02f, 4.34540696e-02f, -8.77990648e-02f, -1.32358089e-01f, -1.56844899e-01f, 9.05172434e-03f, -1.47435680e-01f, -1.42896503e-01f, -7.55523937e-03f,
  -4.63539995e-02f, -8.78557637e-02f, 1.34195676e-02f, 1.46259377e-02f, -6.61411807e-02f, -1.84113324e-01f, -8.48072395e-02f, -1.53796552e-02f, -4.89320084e-02f, -1.16434909e-01f,
  1.86018690e-01f, 2.03373909e-01f, -5.70324771e-02f, -5.68135455e-02f, -2.99186483e-02f, -2.72721611e-02f, 3.75940800e-02f, -3.69924940e-02f, 9.01388600e-02f, 2.32125428e-02f,
  4.85064602e-03f, 7.84634575e-02f, 4.60524857e-02f, 5.10843731e-02f, -1.81841291e-02f, 3.32181118e-02f, -6.57600388e-02f, -5.49464189e-02f, -8.77304841e-03f, 9.77820903e-02f,
  2.99299806e-02f, -8.55260193e-02f, -1.91914752e-01f, -3.30128744e-02f, -3.78093086e-02f, -6.73931912e-02f, -9.78599414e-02f, -1.71053018e-02f, -1.78598300e-01f, -1.54783860e-01f,
  2.65930861e-01f, -6.57343268e-01f, -1.38096929e-01f, -1.37799278e-01f, -1.15679801e-01f, 4.64812703e-02f, -3.39742422e-01f, 3.26745678e-03f, 9.99041572e-02f, -2.37605050e-01f,
  -8.46768096e-02f, 4.27474409e-01f, 2.74327338e-01f, 2.70260662e-01f, 7.06922188e-02f, -3.08782071e-01f, -2.14219674e-01f, 3.08677465e-01f, 5.39228618e-01f, 2.19423816e-01f,
  1.22218378e-01f, -2.17354987e-02f, 2.64595412e-02f, -2.50816103e-02f, -1.67178422e-01f, 1.19761556e-01f, -2.71229029e-01f, -1.03166670e-01f, -2.17158586e-01f, -2.16476873e-01f,
  1.59594357e-01f, -3.68251264e-01f, 1.84145510e-01f, -5.13590593e-03f, -1.47815809e-01f, -2.22997530e-03f, -8.46802294e-02f, -4.82457690e-02f, -1.87035017e-02f, -1.74729049e-01f,
  -6.57566786e-02f, -4.58376482e-02f, -1.04068719e-01f, -1.31227653e-02f, -1.73598260e-01f, -3.56260240e-02f, -1.90444395e-01f, -6.63341582e-02f, -2.85900291e-03f, -1.16031028e-01f,
  -1.24427132e-01f, -1.47734448e-01f, -4.45000716e-02f, -1.01463959e-01f, -3.57815158e-03f, 9.40765813e-02f, -1.70109540e-01f, -5.39487228e-02f, -1.87995713e-02f, -2.66447723e-01f,
  4.97805402e-02f, 1.65309338e-03f, -1.44631546e-02f, -1.09411761e-01f, -6.26616627e-02f, 1.28148338e-02f, -3.73044796e-02f, 8.45252648e-02f, -1.91103369e-02f, -7.85811245e-02f,
  3.15732211e-02f, 3.71784670e-04f, -5.09265400e-02f, -2.39559673e-02f, 1.06853107e-02f, -1.21763438e-01f, 5.84880225e-02f, -5.63000068e-02f, 7.70109370e-02f, -9.51601192e-02f,
  1.37121230e-01f, 5.31481989e-02f, -1.28492638e-02f, 6.91892803e-02f, -6.68129697e-02f, 5.10527417e-02f, 2.95128077e-02f, -3.23832705e-06f, 2.26307716e-02f, -4.68399562e-02f,
  1.50366485e-01f, 6.42916784e-02f, -5.51393591e-02f, 3.36386412e-02f, 3.64413634e-02f, -3.57799837e-03f, -6.63427860e-02f, -5.01033559e-04f, -2.51814052e-02f, 7.57373944e-02f,
  3.52731906e-02f, 3.02400924e-02f, -5.98918907e-02f, -9.60672647e-02f, 3.37610990e-02f, -4.22021560e-02f, -7.45311901e-02f, 5.40393330e-02f, -1.23954238e-02f, -6.30467609e-02f,
  -1.11039206e-01f, 5.87216467e-02f, 1.36056483e-01f, 7.36871213e-02f, 5.33370003e-02f, 1.63273752e-01f, 6.67371899e-02f, 4.59067896e-02f, 2.39761114e-01f, -4.82617319e-02f,
  1.14982173e-01f, 3.12999070e-01f, 4.30338055e-01f, 4.10789847e-01f, -1.46390185e-01f, -3.11276406e-01f, -1.86427131e-01f, -1.81468353e-01f, 6.59327433e-02f, 1.55992493e-01f,
  -2.24760622e-02f, -1.36623383e-01f, 1.66357623e-03f, 5.62141351e-02f, -8.63235369e-02f, 3.21014225e-01f, 3.69587004e-01f, 3.18178892e-01f, -2.51175821e-01f, -4.04269487e-01f,
  -1.02134980e-01f, 1.02164567e-01f, 1.69224441e-01f, -5.03350087e-02f, 1.15363061e-01f, 3.33638154e-02f, 3.42911661e-01f, 1.43297061e-01f, 5.08989692e-02f, 6.73437476e-01f,
  1.29309729e-01f, 1.81438282e-01f, 1.31502906e-02f, 8.22929963e-02f, 7.90838599e-02f, 9.24244896e-02f, 1.02540450e-02f, 1.58544570e-01f, 9.24859866e-02f, 1.21885404e-01f,
  1.33627430e-01f, 7.45852366e-02f, 1.64799497e-01f, 9.18530151e-02f, 8.28022286e-02f, 5.41995950e-02f, 1.26942828e-01f, 2.49257922e-01f, 2.03663364e-01f, -3.88463028e-02f,
  1.01166688e-01f, 1.09470963e-01f, 7.63722062e-02f, 1.52582619e-02f, 9.70914885e-02f, 3.56291160e-02f, 2.46975292e-02f, 5.03136553e-02f, -4.81774323e-02f, 1.54289514e-01f,
  -5.37466183e-02f, -1.80963978e-01f, -8.51235911e-02f, 7.24468427e-03f, -1.35823209e-02f, -1.29147805e-02f, 3.72038106e-03f, -4.84440550e-02f, -9.42797139e-02f, -5.27723283e-02f,
  -1.15229422e-02f, -1.26907872e-02f, -2.06663460e-02f, -7.34293759e-02f, -3.71675305e-02f, -6.16195872e-02f, -6.32646382e-02f, -2.07662247e-02f, -9.23697427e-02f, 1.16246417e-02f,
  8.97287577e-03f, -1.35947123e-01f, -1.48246111e-02f, -1.33646536e-03f, -1.17628453e-02f, -2.89607104e-02f, -1.14498310e-01f, -7.97384456e-02f, -5.81645779e-02f, -6.87818825e-02f,
  -1.89085081e-01f, 6.94839805e-02f, 1.69235379e-01f, -2.10755430e-02f, 3.40442732e-02f, 9.26266834e-02f, 1.15235575e-01f, -3.25672254e-02f, 2.75147497e-03f, -4.69887210e-03f,
  -8.24665725e-02f, -1.51112238e-02f, 1.27568185e-01f, 8.42650607e-02f, -6.22805394e-02f, -4.30648439e-02f, 3.37310024e-02f, 8.78189728e-02f, 2.31409655e-03f, 7.91984424e-02f,
  1.50444910e-01f, -1.50662094e-01f, -7.89929256e-02f, -8.52612779e-02f, -6.49574921e-02f, -1.07466258e-01f, -5.92684448e-02f, -1.19511321e-01f, -1.84547663e-01f, -7.80395567e-02f,
  -4.00623083e-01f, -1.81845233e-01f, 3.84133846e-01f, 4.46927408e-03f, 1.67068630e-01f, 1.38231784e-01f, -6.19409494e-02f, -1.72745347e-01f, -1.07388003e-02f, -7.51087219e-02f,
  1.54707760e-01f, 3.32629919e-01f, 3.16393822e-01f, 3.30362260e-01f, 6.36358978e-03f, 1.60860084e-02f, 3.88413295e-02f, 2.73439139e-01f, 3.18006158e-01f, 1.44866765e-01f,
  1.61632150e-01f, 2.69952536e-01f, 1.86138321e-02f, 3.57780643e-02f, 8.27645045e-03f, 3.40965003e-01f, 1.64782390e-01f, -2.66546123e-02f, 9.25602466e-02f, 1.57358348e-01f,
  3.49180579e-01f, -3.32166851e-01f, 2.52025545e-01f, 1.30686581e-01f, 6.56865463e-02f, -1.24269992e-01f, 1.69846360e-02f, -1.45791126e-02f, -1.92803680e-03f, -1.12214787e-02f,
  1.09679721e-01f, 7.24783912e-02f, 5.56450523e-02f, 3.17860879e-02f, 6.23127855e-02f, 2.67208181e-02f, -4.08315146e-03f, 6.96717128e-02f, 1.87111720e-01f, -4.54337113e-02f,
  -6.18912615e-02f, 7.42546618e-02f, -2.47448608e-02f, 9.09199044e-02f, 2.19167341e-02f, 2.26279169e-01f, -1.74773037e-02f, -3.00388411e-02f, 1.00553729e-01f, -6.48603290e-02f,
  -1.15493350e-01f, 3.15037258e-02f, 4.17457111e-02f, -1.16186149e-01f, -7.43837208e-02f, -1.15660161e-01f, -1.05737105e-01f, -6.42379895e-02f, -1.32236732e-02f, -1.33629590e-01f,
  9.89510491e-03f, -1.01069361e-01f, -1.30062744e-01f, -1.33606598e-01f, -2.48386562e-02f, -2.70033311e-02f, -5.10779992e-02f, -8.42375755e-02f, -8.57863054e-02f, -8.70596692e-02f,
  -3.88376252e-03f, -7.20383748e-02f, 4.37246775e-03f, -1.62523147e-02f, -9.48215872e-02f, -2.25770613e-03f, -1.47117645e-01f, -7.32702613e-02f, 8.87019560e-02f, 1.65577177e-02f,
  2.49132752e-01f, 1.24666048e-02f, -2.60315724e-02f, -3.42712887e-02f, -4.60405834e-02f, -3.56925046e-03f, 1.35996928e-02f, -8.88085738e-02f, -2.73767784e-02f, 9.22970772e-02f,
  -6.85006455e-02f, 5.58205359e-02f, -4.01522629e-02f, 6.55696020e-02f, 5.69511764e-02f, 8.95372555e-02f, 2.48058084e-02f, 1.33128986e-01f, -2.58038454e-02f, -8.16994160e-03f,
  7.87914637e-03f, -1.25636533e-01f, -3.69829386e-02f, 2.74085514e-02f, 9.40737547e-04f, 9.67563689e-02f, 8.38192254e-02f, 4.20584977e-02f, 1.42728854e-02f, -5.32420464e-02f,
  -6.65648282e-01f, 2.88161546e-01f, -2.83410132e-01f, 1.37010649e-01f, 4.82983261e-01f, 3.92268986e-01f, 4.09980118e-01f, 3.03926587e-01f, 1.51801497e-01f, 1.06493406e-01f,
  1.05505072e-01f, -1.07604198e-01f, -1.64078444e-01f, -1.84782133e-01f, -2.25614578e-01f, 1.37295797e-01f, 1.62864566e-01f, -4.56321806e-01f, -2.26044506e-01f, 9.60666463e-02f,
  2.89806217e-01f, 1.33583043e-02f, -3.19886357e-01f, -7.16079632e-03f, 2.56030589e-01f, 1.67558566e-01f, 1.00968041e-01f, 1.89417154e-01f, 2.20270138e-02f, 6.17965348e-02f,
  -3.46385121e-01f, 1.80204451e-01f, -8.70739296e-03f, 9.58650932e-03f, 4.00805324e-02f, -9.32041556e-02f, 2.26528998e-02f, -1.73063036e-02f, 3.51353139e-02f, 2.58037206e-02f,
  1.68537632e-01f, 7.95791391e-03f, 7.25327209e-02f, 9.04543772e-02f, 1.94008827e-01f, 8.80569667e-02f, 1.56732611e-02f, -4.57566231e-02f, 3.69170532e-02f, 7.45932683e-02f,
  1.91248760e-01f, 1.19803160e-01f, 9.38723087e-02f, 2.19884902e-01f, 1.93795413e-01f, -7.70052597e-02f, 1.04034998e-01f, 1.06251560e-01f, 8.69249851e-02f, 1.84011698e-01f,
  2.78265737e-02f, 3.92367952e-02f, 1.01315929e-02f, -1.97838666e-03f, -2.79367957e-02f, 1.13009438e-02f, -2.05008239e-02f, 3.77680957e-02f, 7.20600924e-03f, -2.95548141e-02f,
  2.16852259e-02f, -4.66815792e-02f, -1.05168354e-02f, 3.54173128e-03f, -5.92833348e-02f, -6.07128032e-02f, -3.73945907e-02f, -4.53628376e-02f, 5.83558232e-02f, -1.69787519e-02f,
  -2.82166023e-02f, -5.19614927e-02f, -4.44910005e-02f, -8.61292705e-03f, -1.75182614e-02f, -7.23582059e-02f, 1.14150448e-02f, -5.76555263e-03f, -2.42593884e-02f, 2.25523207e-02f,
  -1.86208205e-03f, -9.12285000e-02f, -2.05655880e-02f, -7.55424751e-03f, 1.13465756e-01f, 3.54124755e-02f, -1.99562833e-02f, 5.00607118e-02f, 4.96720113e-02f, 1.34123536e-02f,
  8.90721977e-02f, -2.92874146e-02f, 4.66437265e-02f, 5.06926998e-02f, 1.85215231e-02f, 1.58359915e-01f, 7.07747638e-02f, -7.09365010e-02f, 7.53567591e-02f, 1.82884842e-01f,
  1.57125026e-01f, 1.28609717e-01f, -7.77803035e-03f, 7.34896287e-02f, 1.86267182e-01f, -6.50954023e-02f, 7.96263963e-02f, 1.11979447e-01f, 3.05665545e-02f, 9.76082087e-02f,
  -2.74015009e-01f, -1.62949190e-01f, -3.26399207e-01f, 1.15276985e-01f, -2.65765816e-01f, -3.27680856e-01f, -4.14734930e-01f, -9.54134911e-02f, 1.85790092e-01f, 2.80510243e-02f,
  2.25461721e-02f, 3.98493230e-01f, 2.41035417e-01f, 2.87086785e-01f, -1.05735427e-02f, -1.26644507e-01f, -1.84834108e-01f, -2.71998905e-03f, -3.80207710e-02f, 4.11517955e-02f,
  1.70705110e-01f, 1.93843290e-01f, 1.47008777e-01f, 1.17375031e-01f, 2.94724137e-01f, 1.79532781e-01f, 1.66324854e-01f, 6.94548562e-02f, 1.17574297e-02f, 3.49920690e-01f,
  2.64996111e-01f, 1.44094765e-01f, 6.41361848e-02f, 2.07301468e-01f, 4.37914431e-02f, 5.39265610e-02f, 5.37916794e-02f, 1.12511754e-01f, 7.10432008e-02f, 8.83166939e-02f,
  3.87670845e-02f, 1.36853084e-01f, 9.52784866e-02f, 1.52379170e-01f, 5.28659448e-02f, 4.21640687e-02f, 1.99487582e-01f, 1.56845033e-01f, 1.57294184e-01f, 1.50457159e-01f,
  1.88859612e-01f, 3.65818082e-03f, -1.18975490e-01f, 3.99810299e-02f, 1.85248464e-01f, 4.49071042e-02f, 1.53630702e-02f, 2.59684116e-01f, 1.41348466e-01f, 2.00167045e-01f,
  -1.44784763e-01f, -8.22535381e-02f, -3.43101546e-02f, -7.19193891e-02f, -4.78270724e-02f, -2.96989661e-02f, -2.64723748e-02f, -3.39114815e-02f, -3.53756249e-02f, -7.13214427e-02f,
  5.88919744e-02f, -5.65953553e-03f, 7.70894438e-02f, -3.07868724e-03f, 1.07982114e-01f, -9.04094949e-02f, -4.78803106e-02f, 5.99758774e-02f, 7.04140738e-02f, -3.75996567e-02f,
  -5.12809381e-02f, 1.41628552e-03f, 6.92088827e-02f, 1.02904648e-01f, 6.59705326e-02f, -2.80376971e-02f, -7.44728791e-03f, 3.86629552e-02f, 3.63704562e-03f, -2.06988435e-02f,
  1.71666309e-01f, -5.77392839e-02f, 2.59764969e-01f, 1.86647505e-01f, 5.22628091e-02f, 1.78354457e-01f, 2.97214240e-02f, 9.72051099e-02f, 7.75549859e-02f, 7.05782250e-02f,
  5.16114756e-02f, 1.23016417e-01f, 1.22460455e-01f, 1.49057254e-01f, 2.79846974e-02f, 5.21610267e-02f, 2.23454311e-02f, -8.64871126e-03f, 1.61793679e-01f, 1.65544569e-01f,
  9.19772610e-02f, -1.00541420e-01f, -1.10275313e-01f, -4.47081439e-02f, 1.17843755e-01f, -1.01204790e-01f, 6.11167029e-02f, 1.01782791e-02f, -6.29646853e-02f, -4.92631420e-02f,
  2.74505407e-01f, -1.42016649e-01f, -9.07959193e-02f, 1.20651916e-01f, -3.37983161e-01f, -2.33221367e-01f, -3.49937499e-01f, -3.82016711e-02f, 9.25765410e-02f, -1.20390542e-01f,
  -3.13908488e-01f, -2.28391942e-02f, 9.08106044e-02f, 3.17176431e-01f, 4.55929250e-01f, 1.58177361e-01f, 2.39231542e-01f, 5.38209856e-01f, 4.22563791e-01f, 4.14145328e-02f,
  2.20045671e-02f, 3.38584989e-01f, 3.74220341e-01f, 2.63233781e-01f, -1.08160578e-01f, 6.31718412e-02f, -9.50124040e-02f, 1.29906647e-02f, -1.68678164e-01f, 2.75594234e-01f,
  2.82989815e-02f, -1.55581295e-01f, 5.37778309e-04f, 1.63770318e-02f, -7.14913234e-02f, 2.23900508e-02f, -7.32870400e-02f, 2.69238241e-02f, -1.41050726e-01f, -1.22540561e-03f,
  -8.57252702e-02f, 5.38779004e-03f, 7.32733235e-02f, 3.30161639e-02f, 2.81289406e-02f, -1.21075027e-01f, 5.73002510e-02f, 1.02278069e-01f, 4.90816422e-02f, -1.50255218e-01f,
  -1.02604859e-01f, -1.41443923e-01f, -8.55788440e-02f, -1.16757147e-01f, -1.16731368e-01f, -6.63550869e-02f, -1.73978016e-01f, -7.93567672e-02f, -1.59620699e-02f, 1.98808312e-02f,
  -3.66846211e-02f, -5.48776425e-03f, -5.06971404e-02f, 5.08601554e-02f, 2.32024435e-02f, -9.89269000e-03f, 9.36334208e-03f, 4.20057997e-02f, 1.10743968e-02f, 2.80805212e-02f,
  -7.52790570e-02f, 1.39444126e-02f, 1.15284063e-01f, -2.05641631e-02f, 4.99702729e-02f, -1.44438297e-02f, 1.23711988e-01f, 2.16089450e-02f, -4.53125946e-02f, 7.82608241e-02f,
  1.86127611e-02f, -2.52619013e-02f, 1.44750783e-02f, 6.31385595e-02f, 5.49302064e-02f, 3.29800062e-02f, 8.71933848e-02f, 7.54185691e-02f, 1.48258386e-02f, -7.15023791e-03f,
  1.49135310e-02f, -4.34454493e-02f, 1.20360274e-02f, 5.64921498e-02f, -8.03069621e-02f, -3.15945931e-02f, -1.21293820e-01f, 2.99386214e-02f, -1.08910516e-01f, 2.64994055e-02f,
  -1.08506382e-01f, 1.83003657e-02f, -1.94906499e-02f, -2.59447042e-02f, 1.65446531e-02f, -4.40850630e-02f, -4.77107987e-02f, -2.74018687e-03f, -7.36040100e-02f, -7.19962418e-02f,
  -2.11030915e-02f, 1.87090989e-02f, 6.10170439e-02f, -6.55000983e-03f, 2.07995363e-02f, 6.83356822e-02f, -1.16709778e-02f, -4.86129187e-02f, 4.00559977e-02f, 7.65882507e-02f
};

// L0_fan_Wp_bar (Shape: 8 x 120)
const int L0_fan_Wp_bar_rows = 8;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  4.57614511e-01f, -1.28417537e-01f, -5.21202683e-01f, 4.93851572e-01f, 5.49169034e-02f, -6.17068857e-02f, 8.05689767e-02f, 2.66743064e-01f, 4.12084103e-01f, 1.50090277e-01f,
  -3.54882807e-01f, -3.97773862e-01f, -4.41598535e-01f, -3.03096324e-01f, -1.42080024e-01f, 3.71363401e-01f, 4.68341291e-01f, -5.58401085e-02f, -1.53181762e-01f, 1.09327130e-01f,
  3.70184690e-01f, 4.16624725e-01f, 9.52187702e-02f, 7.85363615e-02f, 2.14241549e-01f, 9.11612362e-02f, -2.43801046e-02f, -2.05350086e-01f, -3.25188607e-01f, 3.87252510e-01f,
  -7.65403748e-01f, -3.78554136e-01f, 5.69338687e-02f, -4.36590686e-02f, -2.33887434e-01f, 2.52514541e-01f, 1.41885638e-01f, 1.45898148e-01f, 1.74073696e-01f, 2.59260476e-01f,
  -5.19275926e-02f, -1.32338092e-01f, -1.86114013e-01f, -9.18376744e-02f, 9.87935215e-02f, -8.88211057e-02f, -7.90705085e-02f, 5.95720224e-02f, 2.01259349e-02f, -1.41924605e-01f,
  -1.64341360e-01f, -1.82090908e-01f, -2.50862807e-01f, 8.31517577e-03f, -8.46522674e-02f, -2.08425805e-01f, -1.92674890e-01f, -2.70480514e-01f, -1.94462478e-01f, 2.50145286e-01f,
  -1.19161326e-02f, -7.81156821e-03f, -5.31013533e-02f, -8.86630341e-02f, -5.84431691e-03f, 1.19469255e-01f, 3.84898894e-02f, -3.90857738e-03f, -8.54961202e-02f, 7.39377663e-02f,
  8.97204727e-02f, -1.07864767e-01f, 1.57171849e-03f, 1.15589425e-01f, -9.07017067e-02f, -1.56900659e-01f, 1.32124275e-01f, -7.43747056e-02f, -2.67012268e-01f, 3.12759280e-02f,
  -6.60976619e-02f, 4.50613350e-02f, 5.85766062e-02f, -7.37839937e-02f, -1.78469089e-03f, 2.38537863e-02f, 5.13237678e-02f, -7.77486041e-02f, 7.09679872e-02f, 8.95533562e-02f,
  4.54946101e-01f, -5.00339508e-01f, 2.72160262e-01f, -9.39880386e-02f, 3.44462018e-03f, -1.90850459e-02f, -2.04053298e-01f, -3.62108946e-02f, -1.19721234e-01f, 1.31188646e-01f,
  -1.38129219e-01f, -6.99796900e-02f, -3.50128114e-02f, 9.57286730e-02f, 1.56624958e-01f, -2.01315489e-02f, -1.24402242e-02f, -1.10695601e-01f, -3.54776941e-02f, 1.10262185e-01f,
  1.24799415e-01f, 2.40489587e-01f, 7.75660127e-02f, 1.45036831e-01f, 6.59312978e-02f, 1.18711196e-01f, 1.40523374e-01f, 8.23701099e-02f, 1.25140240e-02f, 6.18681312e-01f,
  4.46770191e-01f, 9.53422308e-01f, 8.79100740e-01f, -5.53552568e-01f, -3.93021941e-01f, 1.31336600e-01f, 6.59310579e-01f, 4.13745612e-01f, -2.43292972e-01f, 4.32214379e-01f,
  2.52179056e-01f, -7.46563494e-01f, -3.18844438e-01f, -3.11251551e-01f, 2.06346765e-01f, 5.32146513e-01f, -2.04703659e-02f, -1.47911951e-01f, -5.75995803e-01f, -6.23123169e-01f,
  -7.53477633e-01f, -5.39347410e-01f, -2.73861259e-01f, -1.21185645e-01f, 2.22564153e-02f, -4.90822434e-01f, 5.34023285e-01f, 2.33409613e-01f, 3.15841019e-01f, 1.10001266e-01f,
  7.16248810e-01f, 8.55631411e-01f, -4.41615731e-01f, -3.46550077e-01f, -2.89244781e-04f, 7.13494569e-02f, -3.76565121e-02f, 1.71947181e-01f, 2.96710543e-02f, 2.74352729e-02f,
  -2.02005103e-01f, 3.38647864e-03f, -9.67849419e-02f, -1.87517911e-01f, 4.21510674e-02f, 4.42622788e-02f, 6.60109520e-02f, 1.76357090e-01f, 8.73794872e-03f, 2.17226192e-01f,
  -6.53485358e-01f, -1.23005837e-01f, 2.00621396e-01f, 1.08486429e-01f, 3.04731518e-01f, -4.58003491e-01f, 3.21819305e-01f, 1.52154669e-01f, 2.96702921e-01f, 3.26615542e-01f,
  -9.14111063e-02f, 1.41387716e-01f, 1.71482265e-01f, -2.98346896e-02f, -1.19063936e-01f, -5.74372374e-02f, 1.79976802e-02f, -8.31025913e-02f, -5.95755987e-02f, 4.65003327e-02f,
  2.47966917e-03f, 2.56578494e-02f, -1.06813394e-01f, 1.84828117e-02f, -1.64536700e-01f, 6.42125681e-02f, -1.18991226e-01f, 3.80443037e-02f, -2.07859911e-02f, -1.86559483e-02f,
  -1.03897899e-01f, 1.34219909e-02f, 4.88328654e-03f, 2.68596719e-04f, 6.82320744e-02f, 2.22435910e-02f, -5.21631017e-02f, -5.01570664e-02f, -1.12819985e-01f, 4.80230451e-02f,
  -3.29361826e-01f, -3.25852007e-01f, 1.18589483e-01f, 1.20861046e-01f, 3.28363627e-01f, 1.73273444e-01f, -4.59569059e-02f, -1.46835074e-02f, 1.03140689e-01f, -1.29431169e-02f,
  2.57347245e-02f, -2.98027508e-02f, 3.13195258e-01f, -8.45114738e-02f, -2.31233612e-01f, 2.67097298e-02f, -1.46137327e-01f, -1.45203471e-01f, -1.65975764e-01f, -1.09187789e-01f,
  -7.14963377e-02f, -1.47874117e-01f, -4.73663300e-01f, -1.59662783e-01f, -2.31281057e-01f, -6.21623576e-01f, -1.57150671e-01f, -2.54143149e-01f, -1.70035344e-02f, -3.26218486e-01f,
  -1.21264720e+00f, -2.26724520e-01f, 7.50511289e-01f, -9.71999705e-01f, 4.80833590e-01f, 7.88814247e-01f, 9.58804786e-01f, 1.67819485e-02f, -4.84551549e-01f, -4.60655503e-02f,
  -1.80553108e-01f, -5.77054262e-01f, -6.25380099e-01f, -1.83309466e-01f, 1.26121119e-01f, 5.45080602e-01f, 4.49585080e-01f, 3.68859529e-01f, 5.00527203e-01f, 4.72032666e-01f,
  -1.15808032e-01f, -3.40067923e-01f, -4.47805047e-01f, -2.76804239e-01f, -2.51546174e-01f, -8.06559548e-02f, 8.43019038e-02f, -9.84086692e-02f, 3.11313927e-01f, -4.24387902e-01f,
  3.48959625e-01f, -3.39477867e-01f, 6.67089000e-02f, -2.70307809e-01f, -3.86632830e-02f, -1.80880636e-01f, -5.54772541e-02f, -2.11794049e-01f, -1.63723096e-01f, -4.06033173e-02f,
  -2.74404228e-01f, -7.71188214e-02f, -9.04536098e-02f, 5.08127967e-04f, 5.92709333e-02f, 4.09696661e-02f, -1.81806743e-01f, -3.48283388e-02f, 1.35808066e-02f, 1.29738301e-02f,
  -3.04544587e-02f, 1.83773767e-02f, 2.58830160e-01f, 2.70175278e-01f, 1.27270311e-01f, 3.99888530e-02f, 7.92851597e-02f, 6.83815102e-04f, 1.45380169e-01f, -1.29910201e-01f,
  9.36873034e-02f, 3.99796255e-02f, 5.29850610e-02f, 4.58589606e-02f, 4.16926341e-03f, -2.68927552e-02f, -2.13212855e-02f, 1.17960490e-01f, 9.37552974e-02f, -3.46575677e-02f,
  -1.04495771e-02f, -8.14472511e-03f, 4.81651872e-02f, -1.22448921e-01f, -1.52243242e-01f, -1.32068880e-02f, 9.83100012e-02f, -1.06454670e-01f, -3.86808924e-02f, -9.08041373e-02f,
  -1.63781255e-01f, 1.41662639e-02f, -1.39430135e-01f, 3.76720377e-03f, 9.26089510e-02f, -9.31469426e-02f, -7.16134533e-02f, -4.33989838e-02f, -1.79867044e-01f, -8.08950290e-02f,
  -1.74968004e-01f, 3.13379377e-01f, -1.52795017e-01f, -1.29357949e-01f, -8.59674662e-02f, -1.80103242e-01f, -1.09165497e-01f, -1.11534029e-01f, -1.25332162e-01f, 2.08782707e-03f,
  -3.49796680e-03f, -4.20923792e-02f, -5.44102341e-02f, -2.55530607e-02f, 8.35656226e-02f, 1.63984653e-02f, -2.05407321e-01f, -1.13522291e-01f, -7.50748906e-03f, -2.36149086e-03f,
  -7.18039721e-02f, 1.34464875e-01f, 3.30849476e-02f, 3.86339091e-02f, -8.72814208e-02f, 1.64630845e-01f, 1.95655107e-01f, 1.29662588e-01f, 2.21950695e-01f, 1.73020829e-02f,
  1.21498966e+00f, 3.55755627e-01f, -1.25345206e+00f, 5.48617467e-02f, -7.63196349e-01f, -5.16291618e-01f, -1.58088803e-02f, 1.51992202e-01f, -1.39319813e-02f, -1.33370250e-01f,
  9.72394198e-02f, 3.83980244e-01f, 5.03404856e-01f, 2.74369389e-01f, 3.12908739e-01f, -3.45674336e-01f, -8.01302671e-01f, -4.06027317e-01f, 4.64989245e-02f, -1.94998290e-02f,
  2.12462083e-01f, 1.58518121e-01f, 3.52029681e-01f, 1.27825830e-02f, -3.59528482e-01f, 1.02237433e-01f, -4.06968057e-01f, -3.64787489e-01f, -4.29265261e-01f, -7.31482267e-01f,
  4.99739915e-01f, -3.40108454e-01f, -1.12668648e-01f, -8.78919214e-02f, -2.01682985e-01f, 3.80262621e-02f, -3.71210091e-02f, -2.30262965e-01f, -3.57014011e-03f, -1.14392824e-01f,
  -1.71944484e-01f, -2.87023913e-02f, -8.22635069e-02f, -2.98025627e-02f, 4.90489230e-02f, 6.61273524e-02f, -2.02391714e-01f, -9.74883735e-02f, -1.10236079e-01f, -7.64607638e-02f,
  -1.14363141e-01f, -3.32322836e-01f, -8.79478157e-02f, 1.96039286e-02f, -1.43872768e-01f, -4.25448343e-02f, -8.81324112e-02f, -2.01152354e-01f, -2.03365937e-01f, 1.44894898e-01f,
  -8.17502886e-02f, 1.40001342e-01f, 2.03365297e-03f, 8.16473141e-02f, 1.30480930e-01f, 3.19639668e-02f, -5.80634065e-02f, 1.56596974e-01f, 1.24460973e-01f, 2.21676677e-01f,
  2.91532315e-02f, -3.42232026e-02f, -1.15747526e-01f, 3.44319604e-02f, -5.31268790e-02f, -1.94086447e-01f, -1.59665063e-01f, 2.67698199e-01f, -6.95753694e-02f, 2.25918405e-02f,
  -2.13054530e-02f, -1.69311032e-01f, -1.36323556e-01f, -1.35980114e-01f, -2.17951238e-01f, -1.84280868e-03f, -3.23188119e-02f, 6.16893210e-02f, 1.44913509e-01f, -1.84412058e-02f,
  1.00821233e+00f, -1.42423525e-01f, 1.47321895e-01f, 1.67364657e-01f, -2.37821952e-01f, -1.47209302e-01f, -6.54455423e-02f, -1.63357884e-01f, -1.00734755e-01f, -2.59150825e-02f,
  -3.15691054e-01f, 4.96019050e-02f, -3.19403526e-03f, -2.53904685e-02f, 2.59297080e-02f, -1.33594140e-01f, -3.55770402e-02f, 9.19309556e-02f, -8.50086883e-02f, -1.39250010e-01f,
  -1.74639434e-01f, 1.19116642e-01f, 6.06040835e-01f, 2.69152105e-01f, 5.60419774e-03f, 2.58733630e-01f, 2.15264738e-01f, 2.10404858e-01f, 2.15280622e-01f, 6.25204206e-01f,
  -5.15743017e-01f, 4.34983075e-02f, -8.18951055e-02f, 3.15337539e-01f, 3.20872903e-01f, -5.63544571e-01f, -1.01720285e+00f, -7.44778275e-01f, 1.93587407e-01f, 2.56602615e-01f,
  4.62503046e-01f, 4.76323932e-01f, 3.96966308e-01f, -2.13625312e-01f, -9.48413610e-01f, -3.64219069e-01f, -3.16957265e-01f, -6.50406063e-01f, -8.44996393e-01f, -7.98101306e-01f,
  -2.42998544e-02f, 5.19444235e-02f, -4.60145980e-01f, -4.82852548e-01f, 6.35638475e-01f, 4.64167655e-01f, 4.80464160e-01f, 4.43118989e-01f, -1.27140880e-01f, 7.28909850e-01f,
  7.95145094e-01f, -1.51917845e-01f, -2.16576427e-01f, -1.00107297e-01f, 3.15194547e-01f, -2.35859871e-01f, -9.49675143e-02f, 1.03836939e-01f, 6.81143031e-02f, -3.26743014e-02f,
  2.82505155e-01f, -1.06437102e-01f, -3.55783224e-01f, 1.56476617e-01f, -2.03872576e-01f, -2.90542275e-01f, -2.04205588e-01f, -7.07235813e-01f, -1.24083936e-01f, 9.07268655e-03f,
  3.30317505e-02f, 3.07128578e-02f, -1.57084376e-01f, -4.57608372e-01f, -4.22777086e-01f, 4.33923602e-02f, 5.26470691e-02f, -2.28918508e-01f, -3.73410791e-01f, 5.12132943e-01f,
  -3.59762311e-02f, 3.77429314e-02f, -4.34989333e-02f, 8.56606439e-02f, 3.95426266e-02f, 1.93366662e-01f, 1.57033846e-01f, 6.47913143e-02f, -4.40332443e-02f, -2.62771584e-02f,
  -1.46471849e-02f, 7.71168843e-02f, 3.50498669e-02f, -1.13575593e-01f, -9.49191023e-03f, 3.12317312e-02f, 4.53349687e-02f, 2.79446896e-02f, -2.62618095e-01f, 6.59757629e-02f,
  -1.23027340e-01f, -1.06549077e-01f, 3.12176764e-01f, -1.97590172e-01f, 2.39148177e-02f, -2.45322943e-01f, 2.18001120e-02f, -1.04509450e-01f, -1.04618132e-01f, 1.08351842e-01f,
  4.23465759e-01f, -7.41575956e-01f, 4.44848895e-01f, -3.16479295e-01f, 1.47779629e-01f, 3.13165039e-02f, 1.47500634e-01f, -1.95857197e-01f, 1.00802243e-01f, -2.94761896e-01f,
  -3.57406408e-01f, -1.53132558e-01f, 3.27172756e-01f, -1.38217002e-01f, -2.64198422e-01f, 8.52457061e-02f, -2.61845827e-01f, -1.37571380e-01f, -4.11244661e-01f, 2.45918110e-01f,
  6.13044947e-02f, -3.49590957e-01f, -2.14308098e-01f, -2.25465558e-02f, 5.56625798e-02f, -2.91013062e-01f, 1.99772194e-02f, 8.24021623e-02f, -5.73557138e-01f, -1.14180684e-01f,
  -1.46059501e+00f, -1.26151741e+00f, 3.23256522e-01f, -5.31964123e-01f, -4.02315527e-01f, -5.97840883e-02f, -9.41758931e-01f, 7.82265291e-02f, 1.79252580e-01f, -1.40320134e+00f,
  -5.76880753e-01f, 4.08661544e-01f, 1.14129722e-01f, 3.05914730e-01f, -1.38232373e-02f, -1.25327420e+00f, -6.74692750e-01f, 3.85054290e-01f, 1.34301829e+00f, 3.96974891e-01f,
  -4.72024471e-01f, -3.27053040e-01f, 6.06090069e-01f, 5.26805818e-01f, -9.50300634e-01f, -1.81171983e-01f, -3.21417063e-01f, -3.73370051e-01f, -5.26488602e-01f, -1.44982028e+00f,
  -6.43389702e-01f, -3.65877062e-01f, 6.14956021e-01f, 1.02843247e-01f, -2.38893881e-01f, -1.26796186e-01f, -1.51943669e-01f, -5.86187728e-02f, 6.73813820e-02f, 4.89689149e-02f,
  3.77110648e-03f, 2.84129441e-01f, 2.67403364e-01f, 1.35388777e-01f, -1.81886479e-02f, -2.29503796e-01f, 7.55270198e-02f, 1.40729740e-01f, 9.88091007e-02f, -3.94610465e-01f,
  -3.32162917e-01f, -3.59473586e-01f, 2.54785210e-01f, 1.82906643e-01f, 4.39818203e-01f, 2.48577744e-01f, 1.48932010e-01f, 4.62649673e-01f, 4.02790368e-01f, -1.21686161e+00f,
  -1.26326950e-02f, -1.11291125e-01f, -4.03126627e-02f, 1.95199400e-01f, -4.18951139e-02f, 7.16318637e-02f, 2.43014395e-02f, -2.67561525e-01f, -8.41465741e-02f, -9.63822082e-02f,
  1.73988506e-01f, -1.81335378e-02f, 1.28590493e-02f, -2.45837137e-01f, -1.05284251e-01f, -7.31191933e-02f, -9.41127613e-02f, -4.96606575e-03f, -1.01133607e-01f, -2.73445904e-01f,
  1.68197930e-01f, 2.11244106e-01f, 6.04990944e-02f, 2.27511108e-01f, -1.75471827e-01f, 4.94856620e-03f, 6.26420900e-02f, 1.24975681e-01f, -1.22210635e-02f, 1.69557497e-01f,
  1.29536986e-01f, 5.41689217e-01f, -6.98859394e-01f, 1.28619848e-02f, -1.08296104e-01f, -8.65076333e-02f, -5.17465211e-02f, 1.75406963e-01f, -3.38325314e-02f, -1.87319770e-01f,
  1.58856764e-01f, -3.40594918e-01f, -1.32217363e-01f, 1.45103812e-01f, -7.30651766e-02f, 1.20708451e-01f, -3.43932867e-01f, -2.48151701e-02f, 3.08651514e-02f, -3.20874333e-01f,
  -1.91350609e-01f, -1.42492384e-01f, -6.22439504e-01f, -3.26703519e-01f, -2.32225612e-01f, 3.46443243e-02f, -1.37995198e-01f, -2.61539668e-01f, -2.11974055e-01f, -1.04377151e+00f,
  -3.05411518e-01f, 4.31997448e-01f, 2.01874062e-01f, 3.86188596e-01f, 5.31838298e-01f, 6.40494525e-01f, 9.13884103e-01f, 5.39360404e-01f, 1.49138048e-01f, 1.86538264e-01f,
  2.79188603e-01f, 1.74260378e-01f, 2.68630952e-01f, 1.91033080e-01f, 3.04573923e-01f, 2.23934084e-01f, 2.48018846e-01f, 9.42816678e-03f, -9.65898857e-02f, -9.94344428e-02f,
  -1.98937370e-03f, 6.34214804e-02f, 5.13122380e-02f, 3.34938453e-03f, -9.37884673e-03f, -1.11665949e-01f, 3.27511877e-01f, 4.01425749e-01f, 1.63285062e-01f, -2.39996761e-01f,
  -1.75536409e-01f, 2.32917443e-01f, -1.30443349e-01f, -2.04988837e-01f, -8.80553648e-02f, -2.83318728e-01f, -1.97926626e-01f, -3.62376660e-01f, -2.48904318e-01f, -1.77598327e-01f,
  -8.27135891e-02f, -1.89210922e-01f, 2.69475561e-02f, -1.18576344e-02f, 1.87138590e-04f, -1.55283168e-01f, 1.41597027e-03f, 8.83014873e-02f, 8.84376913e-02f, 6.62189722e-02f,
  6.63602317e-04f, -6.64649978e-02f, 6.58422634e-02f, 5.74368313e-02f, 1.71792626e-01f, 8.46409798e-03f, 5.00853732e-02f, 3.85007523e-02f, 7.81216845e-02f, -1.24981374e-01f,
  6.38307184e-02f, -1.23025611e-01f, 1.46888524e-01f, 4.45152866e-03f, 4.58621457e-02f, -1.02615148e-01f, -4.93390486e-02f, 1.40586391e-01f, 1.64084807e-01f, -1.09974310e-01f,
  -3.23453434e-02f, 3.98202203e-02f, 2.37168577e-02f, 7.07659265e-03f, -7.11898208e-02f, 3.17131616e-02f, -1.10666685e-01f, -5.18881455e-02f, -2.89392173e-02f, -8.44642892e-02f,
  -1.02340005e-01f, -5.39567098e-02f, -5.71003072e-02f, -1.33154951e-02f, -1.43897384e-01f, 5.39850630e-02f, -2.57729352e-01f, -1.06863149e-01f, -4.03269641e-02f, -1.65901929e-01f,
  3.10392737e-01f, 5.08520126e-01f, -1.20091334e-01f, -8.97272155e-02f, -2.61796322e-02f, -2.01506615e-01f, 2.33433135e-02f, -7.24540651e-02f, -7.07653388e-02f, 2.69431788e-02f,
  -6.97868541e-02f, -1.44106060e-01f, 5.78111922e-03f, -1.50517166e-01f, -2.43296415e-01f, -2.04502791e-01f, -4.50339075e-03f, 1.79196864e-01f, 1.05066761e-01f, -8.33147541e-02f,
  -1.12491705e-01f, -3.01312972e-02f, 1.15284587e-04f, 3.42277326e-02f, 7.00774491e-02f, -2.52783835e-01f, -2.00838476e-01f, -8.98675025e-02f, -6.24060221e-02f, -2.07416326e-01f,
  1.39581239e+00f, -7.52958834e-01f, 6.32750914e-02f, 1.73128024e-01f, -6.24054484e-03f, 1.27019003e-01f, -2.40465611e-01f, -1.08946137e-01f, 2.04504505e-01f, -2.92652767e-05f,
  1.63826942e-01f, 4.13978249e-01f, 2.23863900e-01f, 1.93091616e-01f, 1.86675400e-01f, -1.59208059e-01f, -2.65454888e-01f, 3.68574202e-01f, 4.81242478e-01f, 1.65640861e-01f,
  -1.62370250e-01f, -9.37253162e-02f, 1.61723495e-02f, -9.41819921e-02f, -1.81565151e-01f, 2.39339426e-01f, -1.75314635e-01f, -1.01353571e-01f, -2.00286001e-01f, -2.52972931e-01f,
  -2.60277867e-01f, 1.42322391e-01f, 1.71330854e-01f, 1.66760236e-02f, -7.63638988e-02f, 8.56815022e-04f, -1.94640867e-02f, -1.96261048e-01f, -1.59586877e-01f, -2.60866702e-01f,
  -1.49048626e-01f, -6.16083108e-02f, 4.05945256e-02f, -1.37768835e-01f, -1.90595865e-01f, 6.05572313e-02f, -5.02671078e-02f, -3.51442141e-03f, -9.10383910e-02f, -1.79562375e-01f,
  -3.30600329e-02f, -1.18919089e-03f, 2.70502195e-02f, 2.75602769e-02f, 8.94975662e-02f, 1.69176266e-01f, -5.21345697e-02f, 4.59082499e-02f, 1.43289104e-01f, -5.31996004e-02f,
  9.57479849e-02f, 9.98930782e-02f, 4.76188548e-02f, 1.16367444e-01f, 1.33077934e-01f, 1.35929331e-01f, 5.94426095e-02f, 6.93038628e-02f, 2.95865148e-01f, 1.27729112e-02f,
  -1.28358483e-01f, 1.60682634e-01f, 2.02345140e-02f, 9.26072616e-03f, 2.25225270e-01f, -6.76913038e-02f, -2.69222241e-02f, -1.90248296e-01f, 3.16133350e-02f, -4.12602164e-02f,
  1.37172312e-01f, 1.70620661e-02f, -1.73692837e-01f, -2.60284483e-01f, -2.09108949e-01f, 7.16343746e-02f, 2.82884222e-02f, -4.83238958e-02f, 2.49643475e-02f, -7.94525146e-02f,
  -5.50758719e-01f, 4.23917860e-01f, 1.99203908e-01f, 2.15965323e-03f, 8.05026889e-02f, -1.00277342e-01f, 1.60194978e-01f, -1.45040810e-01f, -2.55191803e-01f, -1.38157621e-01f,
  -1.22132771e-01f, 2.07482968e-02f, -8.28655362e-02f, -6.58987612e-02f, 1.34706438e-01f, 1.92298070e-02f, -6.44036606e-02f, 8.77588764e-02f, -1.32250547e-01f, -1.53865755e-01f,
  -1.92031845e-01f, 1.35464653e-01f, 1.92621872e-01f, 1.88129336e-01f, 1.09794766e-01f, 3.98052603e-01f, 6.75061047e-02f, -2.91391164e-02f, 1.34221718e-01f, 1.04443217e-03f
};

// L0_fan_Bp_bar (Shape: 1 x 8)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 8;
const float L0_fan_Bp_bar_data[] = {
  1.08917129e+00f, 9.60799277e-01f, 1.71165836e+00f, 1.21227610e+00f, 9.30027783e-01f, 4.93306518e-01f, 2.63234288e-01f, 8.85959148e-01f
};

// L1_linear_W (Shape: 12 x 32)
const int L1_linear_W_rows = 12;
const int L1_linear_W_cols = 32;
const float L1_linear_W_data[] = {
  -5.88835239e-01f, 5.01144864e-02f, -9.62215781e-01f, -4.87941951e-01f, 8.69213864e-02f, -2.73548812e-01f, -8.33243877e-02f, -9.69637632e-01f, -1.92706525e-01f, 1.02406226e-01f,
  -5.20038068e-01f, -4.09995839e-02f, 5.18582880e-01f, 6.01835728e-01f, 7.94753611e-01f, -8.31822634e-01f, 4.05025601e-01f, -6.54362440e-01f, 6.91512823e-01f, -4.96775806e-01f,
  -3.92893195e-01f, 5.25673866e-01f, 1.96684420e-01f, -2.59980530e-01f, -4.50031161e-01f, -1.13120282e+00f, -1.03585446e+00f, -4.10777666e-02f, -5.98044038e-01f, 8.79852712e-01f,
  -4.63210702e-01f, -3.28761339e-01f, 6.07444882e-01f, -5.16802967e-01f, -6.60654128e-01f, -7.53005445e-02f, 4.08594795e-02f, 6.83749244e-02f, -7.65236676e-01f, -1.02174088e-01f,
  -3.61042134e-02f, -6.08972371e-01f, 2.25118995e-01f, 2.73334116e-01f, -1.64655387e-01f, 6.43615365e-01f, 9.19170678e-02f, 5.17496049e-01f, -9.92614031e-02f, 2.39587203e-01f,
  4.29570735e-01f, -3.26119542e-01f, 4.62844670e-02f, -5.03163218e-01f, 2.40965001e-02f, 2.46789679e-01f, -4.42334026e-01f, -9.80525553e-01f, -1.59562731e+00f, 5.97799957e-01f,
  -1.55174959e+00f, 2.79826909e-01f, 2.45435506e-01f, 1.00471520e+00f, 3.56120437e-01f, 3.78425449e-01f, 5.68058193e-01f, 3.13797803e-03f, 5.21992967e-02f, 4.36820775e-01f,
  8.77577066e-03f, 4.12921339e-01f, 4.05388847e-02f, -5.14035523e-01f, 3.29011619e-01f, -3.76409531e-01f, -7.78053820e-01f, -3.80371720e-01f, 3.48145038e-01f, -2.20807478e-01f,
  2.74154276e-01f, 4.41603243e-01f, 4.06510770e-01f, 8.30998540e-01f, 7.58587122e-01f, -7.66559362e-01f, 2.77036279e-01f, 9.68689203e-01f, -6.18331671e-01f, -9.07729805e-01f,
  -3.13619561e-02f, -1.49301410e+00f, -8.30426097e-01f, 8.37769747e-01f, -7.17308164e-01f, 3.35891128e-01f, -6.13028884e-01f, -8.55589062e-02f, -1.58347213e+00f, 2.22717240e-01f,
  -9.26470477e-03f, 1.68011621e-01f, -4.61718328e-02f, 1.48178786e-02f, 2.32941464e-01f, -1.82672545e-01f, -4.73636761e-02f, -7.06182301e-01f, 3.23971301e-01f, -4.57865298e-01f,
  6.09057903e-01f, 4.23778333e-02f, -7.40028322e-01f, 3.79850984e-01f, -5.16422689e-01f, -5.31026363e-01f, -4.78296310e-01f, 5.06892204e-01f, -1.19458519e-01f, -1.22234330e-01f,
  -8.47404957e-01f, 6.48466289e-01f, 1.40621090e+00f, -1.07806683e+00f, -8.76716435e-01f, 2.30522320e-01f, -1.45598340e+00f, -5.93064547e-01f, 1.97696760e-01f, 1.94140058e-03f,
  1.39762223e+00f, 1.93265736e-01f, -1.54416054e-01f, -4.35473800e-01f, -5.53141125e-02f, 1.01114893e+00f, -4.41156439e-02f, -1.95746869e-01f, -3.89968663e-01f, -4.72320825e-01f,
  7.41388500e-01f, 2.79761702e-01f, 1.49437636e-01f, 3.93206239e-01f, 1.06697418e-01f, 3.06496561e-01f, -1.27232403e-01f, -3.94142844e-04f, -3.40920836e-02f, 3.68165523e-01f,
  2.51634508e-01f, -9.19674575e-01f, -5.42260885e-01f, 2.81727344e-01f, -1.67625606e+00f, -7.05082536e-01f, 9.69261229e-01f, 4.42951955e-02f, 2.77280718e-01f, -2.16726944e-01f,
  1.44729763e-01f, 5.69523036e-01f, 3.28961909e-01f, 3.24722439e-01f, 5.26529789e-01f, 3.31888556e-01f, 8.29973340e-01f, 5.05811691e-01f, -5.00821710e-01f, 5.71119070e-01f,
  1.78115964e-01f, 9.09880772e-02f, 3.92490506e-01f, 4.11957473e-01f, 8.71052504e-01f, 3.49966466e-01f, 3.74909401e-01f, 3.26373249e-01f, -6.45801201e-02f, -4.57473397e-01f,
  -6.25215173e-01f, 1.84332937e-01f, -3.07657808e-01f, 1.61352113e-03f, 9.14590359e-01f, -1.01555288e+00f, -1.33393836e+00f, 1.02686381e+00f, 5.54938242e-02f, -1.34921920e+00f,
  -8.71881992e-02f, -8.48502994e-01f, -1.09871960e+00f, 3.03552091e-01f, -2.10504860e-01f, 3.03443503e-02f, -3.78636867e-01f, 5.90148009e-02f, 1.17385849e-01f, -1.13264883e+00f,
  3.92348677e-01f, 2.91363839e-02f, 3.45563650e-01f, -8.30395937e-01f, -7.12339103e-01f, -2.92237569e-02f, -1.00451767e+00f, -5.30021012e-01f, 6.59235537e-01f, -3.69263798e-01f,
  -5.29958904e-01f, -5.86807393e-02f, 2.84873061e-02f, -8.03547442e-01f, 7.19822228e-01f, 8.52437973e-01f, 4.37092155e-01f, 8.04459870e-01f, -1.34507775e+00f, -9.51253921e-02f,
  -5.93143582e-01f, -8.44590783e-01f, -3.06470960e-01f, -3.22518378e-01f, 2.15700284e-01f, -7.87918687e-01f, 3.12856704e-01f, -1.55077040e-01f, -2.87121236e-01f, -2.57639319e-01f,
  -2.19622597e-01f, -5.07476181e-02f, -3.00185412e-01f, -4.48235899e-01f, 2.60157347e-01f, 2.24307910e-01f, 5.57416916e-01f, -2.70478845e-01f, -4.80880681e-03f, -6.18240535e-01f,
  -7.80413747e-01f, -3.42052877e-01f, -3.61973643e-01f, 6.42171204e-01f, 2.97322989e-01f, 4.46934491e-01f, -1.88039109e-01f, 3.49040866e-01f, 3.46893281e-01f, -1.00434017e+00f,
  2.56497532e-01f, -5.81340671e-01f, 4.01242435e-01f, -2.74886549e-01f, 3.47414374e-01f, -6.79285586e-01f, 5.93101457e-02f, -2.15903819e-01f, 2.66973674e-01f, -6.15790039e-02f,
  2.75674403e-01f, -2.06694588e-01f, -1.52228214e-02f, -1.19482525e-01f, 1.88772678e-01f, 1.49103940e-01f, -2.39188135e-01f, 3.25774372e-01f, -7.90754676e-01f, 2.34904379e-01f,
  -5.88538408e-01f, 5.14208019e-01f, 3.09145711e-02f, -3.03911626e-01f, 2.35910282e-01f, -5.67064583e-01f, 1.54395491e-01f, 2.38063201e-01f, -2.76316553e-01f, -6.30132854e-02f,
  7.81718135e-01f, -8.75713289e-01f, 9.77717221e-01f, -4.08133388e-01f, -1.38476396e+00f, -1.21188605e+00f, -7.01624453e-01f, 4.31228161e-01f, 8.00873518e-01f, -1.13616414e-01f,
  -1.14046240e+00f, -5.13267100e-01f, 5.33071697e-01f, 1.78637374e-02f, 6.20708764e-01f, -5.13229631e-02f, -1.12262137e-01f, 6.38598680e-01f, 2.36343145e-01f, 3.33275557e-01f,
  -7.60384023e-01f, -7.48313844e-01f, -9.75791633e-01f, -9.24705088e-01f, 5.58073640e-01f, 6.02099478e-01f, -1.14230581e-01f, 9.08530712e-01f, -4.68150936e-02f, -3.77883971e-01f,
  3.97338659e-01f, -1.45752952e-01f, -4.79157239e-01f, -1.60983276e+00f, -1.41443110e+00f, -6.80033624e-01f, 1.70893991e+00f, -1.49194753e+00f, -1.34849757e-01f, -1.50143281e-01f,
  -1.86300412e-01f, 4.12787229e-01f, 5.06222129e-01f, -5.05452454e-01f, -4.11372542e-01f, 3.94906104e-01f, -4.27170694e-01f, -1.94288954e-01f, 1.40142485e-01f, 3.69398355e-01f,
  1.79649562e-01f, 3.32455009e-01f, 3.82536888e-01f, 9.27359164e-02f, 1.18681885e-01f, 4.69309598e-01f, -3.48403782e-01f, -6.67936325e-01f, 5.27632773e-01f, -2.10173234e-01f,
  8.57429564e-01f, -1.09248877e-01f, 1.96741417e-01f, 1.12677151e-02f, -1.26937294e+00f, -7.89349735e-01f, 1.07201636e+00f, 8.45104098e-01f, 2.91795254e-01f, -1.32600129e+00f,
  -8.99864018e-01f, -1.62418175e+00f, 3.77038300e-01f, 3.61753643e-01f, 3.27627003e-01f, 1.69397205e-01f, -2.00888991e-01f, 2.96049509e-02f, -8.00683558e-01f, 6.51506305e-01f,
  -3.45234387e-02f, 1.87088892e-01f, -3.78412306e-01f, 3.10988426e-01f, -6.37510777e-01f, 4.88497838e-02f, -7.37390280e-01f, 9.24352825e-01f, 5.71304381e-01f, -2.68208593e-01f,
  -1.93715408e-01f, 2.61593133e-01f, -5.19095719e-01f, 7.14902699e-01f, -6.60158992e-01f, -8.36686313e-01f, -1.24231279e+00f, 1.50315583e+00f, 1.17941298e-01f, -5.83435953e-01f,
  -1.47330844e+00f, -1.21503472e+00f, 1.75482899e-01f, -5.77850461e-01f
};

// L1_linear_B (Shape: 1 x 12)
const int L1_linear_B_rows = 1;
const int L1_linear_B_cols = 12;
const float L1_linear_B_data[] = {
  4.57985640e-01f, 4.82373722e-02f, 5.27787864e-01f, -5.13861895e-01f, -9.18105186e-04f, -1.76681504e-01f, 3.53400797e-01f, -3.61020237e-01f, -4.96493995e-01f, 2.83322930e-01f,
  -7.51407266e-01f, -9.78442132e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 12, 8
    );
    
    // Camada 1: L1_linear
    linear_forward_pgm(
        buffer1, x_out,
        L1_linear_W_data, L1_linear_B_data,
        32, 12
    );
    }
    