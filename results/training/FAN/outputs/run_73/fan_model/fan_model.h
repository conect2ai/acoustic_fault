/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 32 (x3)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 32;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    return (x > 0.0f) ? x : 0.0f;
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 3 x 120)
const int L0_fan_Wp_rows = 3;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -3.42461377e-01f, -9.25905108e-02f, -2.30514020e-01f, -1.01793669e-01f, 1.03611402e-01f, 1.63964555e-01f, -3.13006520e-01f, 1.02680691e-01f, -1.67797878e-01f, -7.66356513e-02f,
  -5.71547709e-02f, -2.21881539e-01f, -2.23970309e-01f, 1.38272762e-01f, -4.06797230e-02f, -2.48435721e-01f, 1.24400534e-01f, 2.14734636e-02f, -7.83861428e-02f, -1.37763396e-02f,
  -4.42460226e-03f, 2.68752277e-01f, -7.06146359e-02f, 1.32898033e-01f, 4.02898118e-02f, -1.31494597e-01f, 7.41108507e-02f, -4.56795767e-02f, 2.21873164e-01f, 1.11618966e-01f,
  2.90666558e-02f, -1.57939047e-01f, 2.94414926e-02f, 3.76046076e-02f, 4.70164083e-02f, -1.82394050e-02f, 5.91017157e-02f, 1.00643719e-02f, -5.38066477e-02f, -1.03317365e-01f,
  -1.18917562e-01f, 9.43952054e-02f, 1.10227637e-01f, 1.82195827e-02f, -3.13995145e-02f, 1.03557914e-01f, -5.67264156e-04f, 4.27852385e-03f, 7.56945163e-02f, -3.87424603e-02f,
  -2.59243716e-02f, 6.76769717e-03f, -2.92824972e-02f, 2.51038764e-02f, -4.64826040e-02f, -9.12738889e-02f, 5.53097203e-02f, 9.25797448e-02f, 1.46183698e-02f, -4.60716374e-02f,
  -4.42868695e-02f, -9.51195136e-02f, -2.95166001e-02f, 9.09692645e-02f, -4.22774665e-02f, 2.46582367e-02f, -1.45579712e-03f, 8.25939029e-02f, -5.37024345e-04f, -6.06582016e-02f,
  -1.41006131e-02f, -8.82769451e-02f, 8.17602053e-02f, -7.83781335e-02f, -6.28147796e-02f, 1.00628793e-01f, -6.88566789e-02f, 5.59072047e-02f, 2.07856279e-02f, -1.58974007e-02f,
  -1.02312565e-01f, 7.85265490e-02f, -7.17592100e-03f, 4.47095595e-02f, 1.43893473e-02f, -4.57943715e-02f, 2.01028660e-02f, -9.83800143e-02f, 3.46027054e-02f, 3.45953628e-02f,
  6.78137466e-02f, -8.40686709e-02f, -5.50746135e-02f, 9.17285010e-02f, -3.22851390e-02f, -4.13332246e-02f, -4.04872894e-02f, 4.13495973e-02f, -2.90580317e-02f, -3.80555764e-02f,
  2.68207677e-02f, 1.28196508e-01f, -5.51170185e-02f, 5.39678074e-02f, 1.19388945e-01f, 4.25439747e-03f, -6.84834123e-02f, 6.83969706e-02f, 7.17099532e-02f, 1.23866610e-01f,
  -4.39086780e-02f, -7.87618756e-02f, -3.38763744e-02f, 9.51215178e-02f, 9.63745043e-02f, -5.20656630e-02f, 7.15409443e-02f, -1.69497039e-02f, -5.58403619e-02f, 1.01049198e-02f,
  4.75575984e-01f, -3.01873125e-02f, -1.82357375e-02f, 2.08197497e-02f, 2.70903945e-01f, 2.29497969e-01f, 1.47840977e-01f, 1.80173993e-01f, 2.04725474e-01f, -7.08094388e-02f,
  1.53397366e-01f, 1.00974016e-01f, -1.62173033e-01f, 1.27639264e-01f, 2.96635181e-01f, -1.99239299e-01f, 2.55180560e-02f, 5.94405793e-02f, -9.77025740e-03f, 7.16240406e-02f,
  7.89036378e-02f, 1.74999312e-01f, 4.13522571e-02f, 5.14888279e-02f, 6.77013323e-02f, -4.14527627e-03f, -9.23967212e-02f, -3.04618888e-02f, 6.37160391e-02f, 1.02846041e-01f,
  7.79803246e-02f, -9.34112370e-02f, 4.35810313e-02f, -4.66289185e-02f, -1.40432948e-02f, -1.37382776e-01f, 2.54410692e-02f, -1.06700674e-01f, 7.58029148e-02f, 4.25060000e-03f,
  1.09100360e-02f, 1.15677401e-01f, 5.80250323e-02f, 3.04349791e-02f, 2.12738261e-01f, 1.60370618e-02f, 1.43014744e-01f, -2.27348693e-02f, -4.66595516e-02f, -1.16489874e-02f,
  1.40847927e-02f, -4.60357182e-02f, 7.68972700e-03f, -7.98039362e-02f, 4.41661483e-04f, 6.08404726e-02f, -1.76884774e-02f, -8.18342566e-02f, -4.86034043e-02f, 1.26793748e-02f,
  -1.45631749e-02f, -1.25025036e-02f, -1.95223093e-02f, -2.24586949e-03f, 8.95786360e-02f, -1.54170254e-02f, 4.62465212e-02f, -5.35481758e-02f, 3.86066884e-02f, -3.82302590e-02f,
  7.95078948e-02f, 7.85966590e-02f, -8.21258277e-02f, -4.29248111e-03f, -4.74072574e-03f, -4.72981557e-02f, 1.74607988e-02f, -6.20682128e-02f, 3.50529253e-02f, 9.09199119e-02f,
  -8.08398202e-02f, 1.19637273e-01f, 3.38790230e-02f, -2.24467814e-02f, -8.61991721e-04f, 1.15729645e-01f, -6.87808990e-02f, -2.57763695e-02f, -3.70999798e-02f, -2.96776108e-02f,
  -1.52504537e-02f, -1.32943049e-01f, 7.21838558e-03f, -1.89587492e-02f, -1.31166264e-01f, -8.53023231e-02f, -2.48382390e-02f, 7.31895939e-02f, -1.05487041e-01f, -1.00545967e-02f,
  -9.31355730e-02f, 1.68868229e-02f, -1.16644446e-02f, -3.17566879e-02f, 3.14200670e-02f, -7.10311681e-02f, -1.36808688e-02f, -9.35213119e-02f, 3.00736744e-02f, -5.42903990e-02f,
  -5.82501367e-02f, 7.56848976e-02f, -1.49139911e-02f, 3.82762775e-02f, 5.69920009e-03f, -4.44703735e-02f, 1.06153145e-01f, -4.84455749e-02f, -7.37114102e-02f, -3.22620422e-02f,
  4.08889830e-01f, -2.58866698e-01f, -1.41864896e-01f, 1.11318551e-01f, -9.65207592e-02f, 2.72073835e-01f, 3.14291984e-01f, -1.14534177e-01f, 5.17816879e-02f, -1.61915720e-02f,
  5.21940365e-02f, -1.91088557e-01f, 3.43547128e-02f, -3.27131152e-02f, 2.04536915e-01f, 1.10448509e-01f, 1.51943550e-01f, 2.42242813e-02f, 6.59761503e-02f, -5.39039522e-02f,
  1.48022193e-02f, 4.87414300e-02f, 2.63883527e-02f, -5.34216650e-02f, -1.16900586e-01f, -6.50596479e-03f, -1.11963660e-01f, -8.38052556e-02f, -9.70482603e-02f, -4.96772006e-02f,
  2.43238404e-01f, -6.88087940e-02f, 7.23105343e-03f, 8.16089511e-02f, 7.50070363e-02f, 3.70838121e-02f, 4.40225452e-02f, 9.75859240e-02f, 1.24812694e-02f, -2.30598617e-02f,
  3.97548340e-02f, -2.91775540e-02f, -2.00798996e-02f, -1.86265688e-02f, 5.17660268e-02f, -1.97509266e-02f, -8.32124352e-02f, -1.74402427e-02f, 7.01449364e-02f, -1.67709477e-02f,
  -2.92733591e-02f, -1.17467001e-01f, -7.51991943e-03f, 1.82568431e-02f, -6.90613538e-02f, -9.08687189e-02f, -3.10554914e-02f, -5.65380827e-02f, -5.28498292e-02f, -1.03760451e-01f,
  -8.32215697e-02f, 3.49621214e-02f, 1.31340523e-03f, -2.84125637e-02f, -1.74582358e-02f, -1.51923671e-02f, -2.65228748e-02f, 5.03879460e-03f, 1.98028777e-02f, 3.81513014e-02f,
  2.32420247e-02f, 1.33352736e-02f, 4.49775569e-02f, 5.28760068e-02f, -1.00801580e-01f, -8.34902376e-03f, -6.92724064e-03f, -4.32935543e-02f, 1.22595169e-02f, 3.20151486e-02f,
  4.22613230e-03f, -1.18212611e-03f, 1.09203467e-02f, 1.72468647e-01f, -6.50886400e-03f, -1.02609470e-02f, -6.03625067e-02f, -4.99084294e-02f, 3.17024440e-02f, 7.66468868e-02f,
  6.14459515e-02f, -2.51958042e-01f, 1.00064449e-01f, 1.31320938e-01f, 7.61824399e-02f, -5.65974116e-02f, 8.44010189e-02f, 3.60663072e-03f, -1.60491355e-02f, 1.96090117e-02f,
  -4.75727022e-02f, 1.31163485e-02f, 4.67911102e-02f, 4.93441895e-02f, 1.61863770e-02f, 8.47380459e-02f, 8.24899692e-03f, -5.48451915e-02f, 1.39689296e-02f, -2.05644630e-02f,
  -1.61230445e-01f, -2.40738709e-02f, 3.09104478e-04f, -2.13222299e-02f, -6.84728473e-02f, 2.45492980e-02f, -1.33271217e-01f, 2.09505279e-02f, -5.84856942e-02f, 1.38231274e-02f
};

// L0_fan_Wp_bar (Shape: 26 x 120)
const int L0_fan_Wp_bar_rows = 26;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  6.17852360e-02f, -2.58612573e-01f, -8.18041861e-02f, -4.18500751e-01f, -1.31762698e-01f, -2.51172900e-01f, -1.24991484e-01f, -1.97024390e-01f, -7.70057086e-03f, 2.31340602e-02f,
  -2.48580752e-03f, 7.40676522e-02f, 2.46617034e-01f, -3.02011430e-01f, 1.04750410e-01f, 5.44515774e-02f, -2.59554029e-01f, -9.51394439e-02f, -1.75718173e-01f, -2.09646150e-01f,
  -1.72106668e-01f, -1.35307819e-01f, -1.67218491e-01f, -1.49355695e-01f, -1.60019234e-01f, -3.01011410e-02f, -8.26679990e-02f, 1.48925707e-02f, -2.53764451e-01f, 1.16843909e-01f,
  -3.96436051e-04f, 3.83821540e-02f, -1.27520571e-02f, -5.28071832e-04f, -2.20605452e-02f, 8.21873769e-02f, -3.37538607e-02f, 5.99363446e-02f, -9.54627618e-03f, -4.67255749e-02f,
  -4.04323079e-02f, 2.90662982e-02f, -6.60691410e-02f, 1.26078233e-01f, -1.59366056e-01f, -9.56770107e-02f, -1.04814611e-01f, -1.27102003e-01f, -1.41034514e-01f, 8.50367844e-02f,
  5.16234152e-03f, -6.48782402e-02f, -1.69149712e-01f, 1.91966463e-02f, 2.61556730e-02f, -4.15542396e-03f, 7.13293627e-02f, 4.19260748e-02f, 8.94704536e-02f, -2.11703219e-02f,
  7.06065446e-02f, -1.53866103e-02f, 4.86303680e-02f, 1.77675020e-02f, -2.07938310e-02f, 1.69368088e-01f, 6.14188835e-02f, -4.08927165e-02f, -3.95689569e-02f, 1.69837940e-02f,
  -5.17984629e-02f, -2.84711067e-02f, 1.00622281e-01f, -8.13362747e-02f, -4.08136286e-02f, 7.46985525e-02f, -2.06462778e-02f, -1.21830152e-02f, -1.91725828e-02f, -1.79100242e-02f,
  -8.20600465e-02f, -3.45782861e-02f, 5.52431978e-02f, -5.27248681e-02f, 3.17743681e-02f, -3.89402993e-02f, 9.19796005e-02f, 1.19924195e-01f, -2.97685917e-02f, -9.65721384e-02f,
  -1.23858452e-01f, -8.56351852e-02f, -1.35561362e-01f, 1.34626811e-04f, 5.27168214e-02f, -3.68393539e-03f, -9.52418447e-02f, -1.50735155e-01f, -1.33103997e-01f, -1.62271202e-01f,
  -1.13850191e-01f, 3.67420651e-02f, -1.05222389e-01f, 5.61604090e-02f, 2.57273689e-02f, -9.75726172e-02f, -4.27370109e-02f, -5.50958477e-02f, -1.80092275e-01f, 5.45152985e-02f,
  -7.53975064e-02f, -3.24569643e-02f, 6.24081865e-02f, -1.94736943e-02f, -2.01707147e-02f, -1.42509155e-02f, 4.30295169e-02f, 7.39734545e-02f, 3.06678712e-02f, -2.45544780e-02f,
  -9.75048319e-02f, 2.75146693e-01f, 1.77150359e-03f, -1.53304622e-01f, -1.72252834e-01f, -1.94197729e-01f, -2.59237170e-01f, 1.47216944e-02f, 1.47638530e-01f, 2.36976638e-01f,
  -5.33518232e-02f, 2.80889273e-01f, 6.85727447e-02f, -1.88046575e-01f, -2.67116487e-01f, -8.87372643e-02f, -1.87549308e-01f, -1.07703954e-01f, -8.33807141e-02f, -1.06641032e-01f,
  -2.17526913e-01f, -3.84452909e-01f, -2.52850682e-01f, -1.38794869e-01f, -2.58328076e-02f, 9.00607780e-02f, -2.21741080e-01f, -1.56577304e-01f, -9.81744751e-02f, -2.18421104e-03f,
  -2.91583706e-02f, 1.86624173e-02f, 8.85353312e-02f, 3.33613604e-02f, 2.63754628e-03f, -7.43764341e-02f, -1.05568610e-01f, -1.04035720e-01f, -8.12378749e-02f, -1.70525946e-02f,
  -4.18300703e-02f, -9.78841707e-02f, -1.60788908e-03f, 3.84692550e-02f, -5.50672151e-02f, -5.06824553e-02f, -7.47820735e-02f, -5.06817698e-02f, 7.66873956e-02f, 5.78712076e-02f,
  9.52909142e-03f, 1.05644591e-01f, -1.76579989e-02f, 9.47399661e-02f, -5.03058732e-02f, 3.90407518e-02f, -4.60371152e-02f, 2.16720570e-02f, -6.78510405e-04f, 9.16394347e-04f,
  -7.54693104e-03f, -1.43758222e-01f, -2.91375406e-02f, -3.36228982e-02f, -1.08498350e-01f, 2.54835393e-02f, 1.24113709e-02f, 7.58942543e-03f, 7.93846324e-02f, 3.93660404e-02f,
  -6.35688454e-02f, 4.79487926e-02f, -8.66240561e-02f, -5.88787161e-02f, -2.52893977e-02f, 9.41380337e-02f, -1.34763876e-02f, -7.90738687e-02f, 4.45763767e-03f, -5.81345335e-02f,
  -1.80676952e-01f, -9.49281156e-02f, -2.19275095e-02f, -1.52697964e-02f, -7.17171058e-02f, 6.50554374e-02f, 5.19444160e-02f, 8.84629488e-02f, -5.00221439e-02f, -2.85402890e-02f,
  2.58788876e-02f, 5.02762850e-03f, -4.28489633e-02f, 1.04478538e-01f, -1.61769073e-02f, -1.45265320e-02f, -1.21322408e-01f, 3.57495658e-02f, 4.19962555e-02f, -3.06545645e-02f,
  -4.46374081e-02f, -4.88444455e-02f, 1.54818848e-01f, 6.99390545e-02f, 2.92587988e-02f, -8.24180022e-02f, 2.02932637e-02f, 8.49382579e-02f, -6.15654476e-02f, -3.56767774e-02f,
  2.79060639e-02f, 7.34286234e-02f, 1.15221672e-01f, 7.63955563e-02f, 7.54746841e-03f, -3.61939222e-02f, 9.17757452e-02f, 5.02359271e-02f, -5.72987646e-02f, 5.27955852e-02f,
  1.97351754e-01f, -9.92886648e-02f, -1.76194742e-01f, -2.34143138e-02f, 2.34141797e-01f, 1.79288000e-01f, 9.77487937e-02f, -2.26778444e-02f, -1.88073292e-01f, 2.79830936e-02f,
  6.85201436e-02f, -6.97631463e-02f, -2.26958811e-01f, 2.93984562e-01f, 1.98314965e-01f, -1.70698762e-01f, 1.44949362e-01f, 1.33810848e-01f, -6.58269227e-03f, -3.86883840e-02f,
  -4.74843197e-02f, 2.27582708e-01f, -2.04311579e-01f, -8.89017154e-03f, 2.04674572e-01f, -2.52452105e-01f, -5.11766560e-02f, -1.00598805e-01f, 1.43630728e-01f, 1.70391843e-01f,
  7.80524686e-02f, 2.40657534e-02f, 8.12509749e-03f, -4.08342779e-02f, -8.55148956e-02f, 8.73617902e-02f, -2.06559878e-02f, 6.72303606e-03f, -3.99446022e-03f, 4.63989796e-03f,
  -4.60060537e-02f, 4.71633114e-02f, 7.72351027e-02f, 2.38584056e-02f, 1.08409069e-01f, 1.16616637e-01f, 3.39743271e-02f, 1.47428112e-02f, -8.11735466e-02f, 7.86920413e-02f,
  -5.39520644e-02f, -7.01747695e-03f, 6.27789423e-02f, -4.61133942e-02f, -3.89961526e-02f, -4.99113277e-02f, -1.29241854e-01f, -2.30790481e-01f, -3.69684771e-02f, -1.05603203e-01f,
  6.21882752e-02f, 1.23139704e-02f, -8.88094977e-02f, -5.16641932e-03f, 5.52115068e-02f, -9.22556892e-02f, 8.75831544e-02f, 6.52819723e-02f, 4.41274233e-02f, 5.81032038e-02f,
  4.49981429e-02f, 3.85658555e-02f, 1.26791224e-01f, -2.30384525e-02f, -1.95808224e-02f, 1.10856272e-01f, 1.14018135e-02f, 9.08164978e-02f, -4.43726294e-02f, 1.06407322e-04f,
  1.18235908e-02f, 2.76494790e-02f, 3.10650133e-02f, 9.08105168e-03f, 8.31388757e-02f, -5.23185581e-02f, 7.33151734e-02f, 4.62477542e-02f, -1.08581029e-01f, 4.55016755e-02f,
  -7.38292113e-02f, -1.26046196e-01f, -1.26175344e-01f, 3.91037352e-02f, 2.18931921e-02f, 1.15644194e-01f, 3.02775651e-02f, 4.93560620e-02f, -2.36188788e-02f, 5.72591946e-02f,
  1.00804374e-01f, -7.36827552e-02f, 8.25541466e-03f, 1.49237616e-02f, -1.02138363e-01f, 1.45465042e-02f, 7.58084580e-02f, -2.14770753e-02f, 6.31668940e-02f, 7.92522505e-02f,
  -4.09678333e-02f, -3.41194123e-02f, 6.88500181e-02f, 1.22063712e-03f, 4.42271270e-02f, -9.18231085e-02f, -9.00631994e-02f, -2.11655870e-01f, 1.33625850e-01f, -1.12084977e-01f,
  -9.33756158e-02f, 4.20786470e-01f, 3.52814078e-01f, -3.10019660e-03f, -1.18105903e-01f, 2.92930990e-01f, 2.14591492e-02f, 1.62600577e-01f, 3.00436288e-01f, 1.33781567e-01f,
  -4.14908886e-01f, 3.13927531e-01f, -4.42409627e-02f, -1.22495815e-01f, 1.56983994e-02f, 1.98302075e-01f, 1.78378634e-02f, -6.28491212e-03f, 5.28917424e-02f, -7.00075179e-02f,
  -1.44645855e-01f, -2.27440447e-01f, -1.79336742e-01f, -6.62062466e-02f, -1.65420339e-01f, 1.48644764e-02f, -2.77241766e-01f, 6.28623888e-02f, -2.93481164e-02f, -3.13297696e-02f,
  -6.10758141e-02f, -3.06244977e-02f, -7.99160749e-02f, 1.89060211e-01f, -4.31388384e-03f, 2.54252963e-02f, 7.02492669e-02f, -3.80188902e-03f, 4.23564017e-02f, 1.21551380e-02f,
  -4.96339947e-02f, 1.54654145e-01f, 3.44137177e-02f, -5.92478998e-02f, 8.90349150e-02f, 6.96737692e-02f, 2.26696171e-02f, -1.21537954e-01f, 3.26897725e-02f, 4.66108248e-02f,
  -1.15059756e-01f, 7.84243196e-02f, 3.35822143e-02f, -3.73869017e-02f, -7.71828517e-02f, -2.80688200e-02f, 1.74678102e-01f, 4.30621468e-02f, 7.17771426e-02f, 1.07516058e-01f,
  -1.71638932e-02f, 1.16952479e-01f, -6.52272254e-02f, -5.46788201e-02f, -5.99074773e-02f, -2.13953197e-01f, 2.41262428e-02f, -9.27275196e-02f, 9.87251289e-03f, -4.28118818e-02f,
  -1.53639745e-02f, -1.46050811e-01f, -1.37204118e-02f, 6.65887445e-02f, -1.59636155e-01f, -2.06193235e-02f, -6.94771931e-02f, 9.04871300e-02f, -5.73610812e-02f, -6.96040168e-02f,
  5.37615046e-02f, 8.62791762e-02f, -4.95222807e-02f, -9.90328118e-02f, -2.08778623e-02f, 2.95602735e-02f, -1.63852721e-02f, -1.02496641e-02f, -2.58109607e-02f, -1.02611817e-02f,
  9.06459168e-02f, 2.64625102e-01f, -1.41614109e-01f, 3.45053039e-02f, -1.08563080e-02f, 1.38175460e-02f, 9.32416618e-02f, -7.01763183e-02f, 1.06983244e-01f, -4.82375547e-02f,
  9.32041556e-02f, -9.97639894e-02f, 6.42210320e-02f, -1.93561497e-03f, 3.61985043e-02f, 1.51885767e-02f, 4.74629141e-02f, -1.60291344e-01f, 2.67125573e-02f, -1.41435890e-02f,
  -1.61226079e-01f, 7.04861060e-02f, 1.60888117e-02f, -1.24927454e-01f, -1.13694280e-01f, -7.86605850e-02f, 1.48748569e-02f, 1.43189788e-01f, 2.25605182e-02f, 1.99353043e-02f,
  -2.48149056e-02f, -3.75315249e-01f, 2.97902495e-01f, -3.08201462e-02f, 2.26914912e-01f, 1.68799043e-01f, 4.40937787e-01f, -3.54591221e-01f, -4.14922446e-01f, -3.48384500e-01f,
  -3.60575244e-02f, 2.07708433e-01f, 2.57430851e-01f, -1.77131563e-01f, 5.17988443e-01f, 1.41188234e-01f, -7.16110691e-02f, 7.87359178e-02f, 2.11419538e-02f, 3.78458686e-02f,
  1.01086445e-01f, -5.75416684e-02f, 2.63841033e-01f, -2.04861656e-01f, 5.56320138e-02f, -1.18535221e-01f, 1.09299585e-01f, 3.07741433e-01f, -1.20998293e-01f, 1.80696651e-01f,
  -1.31729677e-01f, -2.55440086e-01f, -2.81556658e-02f, -1.03118427e-01f, -6.81775138e-02f, -3.55794132e-02f, -7.10649462e-03f, 1.34655371e-01f, -4.20230161e-03f, -9.65544432e-02f,
  5.83541021e-02f, -3.27128507e-02f, -1.10475414e-01f, 4.47496735e-02f, -4.79277149e-02f, -8.58940035e-02f, -2.12339219e-02f, -6.46571144e-02f, -4.66110036e-02f, 5.52403703e-02f,
  -5.60481437e-02f, -4.28011864e-02f, -9.82650146e-02f, -8.47905055e-02f, 1.01935707e-01f, -1.57691464e-01f, 1.50052503e-01f, 2.07026005e-01f, 1.14425169e-02f, -1.47572681e-01f,
  -2.36252397e-02f, -8.40096455e-03f, -2.03466807e-02f, -7.86087941e-03f, 1.45480931e-02f, -1.97378490e-02f, -3.10429297e-02f, -4.26861905e-02f, 1.14044528e-02f, -1.29996598e-01f,
  -1.16773538e-01f, -9.58475620e-02f, -6.38515204e-02f, 5.62558286e-02f, 5.60101718e-02f, -7.20585659e-02f, 9.43901986e-02f, 5.23630157e-02f, -2.17435081e-02f, -4.56840806e-02f,
  1.19693145e-01f, 3.96704264e-02f, 5.17743789e-02f, 6.78069890e-02f, -2.45031398e-02f, 1.83586076e-01f, -3.26170996e-02f, 1.96725409e-02f, 4.23458442e-02f, 1.87675282e-01f,
  -9.23273563e-02f, -2.64575124e-01f, -5.04850000e-02f, -1.40777454e-01f, -8.49062353e-02f, 2.27602366e-02f, -5.91049604e-02f, -3.53278853e-02f, -1.93902701e-02f, -7.60792717e-02f,
  -7.41389990e-02f, -6.24317266e-02f, -7.62987765e-04f, 1.70074718e-03f, -8.17611255e-03f, -5.44144697e-02f, 3.29801850e-02f, -3.91948745e-02f, -3.26814782e-03f, 6.46573841e-04f,
  5.95782660e-02f, -4.96900128e-03f, 8.33568722e-02f, -3.46827880e-02f, 3.04757692e-02f, 2.73805931e-02f, 5.67899495e-02f, -8.42403993e-02f, 9.98689756e-02f, 7.50045627e-02f,
  -6.54741585e-01f, -3.59477811e-02f, 4.25791204e-01f, -3.06319624e-01f, 9.41626132e-02f, 5.80432773e-01f, 3.82297486e-01f, 1.40673637e-01f, 4.37809154e-02f, 1.11691661e-01f,
  -7.94195198e-03f, -7.96992779e-02f, 1.66343600e-01f, -5.19696958e-02f, 2.28857040e-01f, 2.45053440e-01f, 1.87475324e-01f, 1.46828637e-01f, -4.02650796e-02f, -1.19732633e-01f,
  -6.61837682e-02f, -1.32252142e-01f, 1.13123246e-01f, -5.53648621e-02f, -8.41361955e-02f, -2.21411854e-01f, -1.94650382e-01f, 1.02962106e-01f, -1.42931983e-01f, -8.67858343e-03f,
  -2.77059615e-01f, -2.16877386e-01f, -1.63455158e-01f, 1.00233525e-01f, 4.44617076e-03f, 2.90489327e-02f, -3.11970599e-02f, 9.39324200e-02f, -6.34350255e-02f, -2.49813534e-02f,
  6.09121891e-03f, 2.50889268e-02f, -1.12335496e-01f, -5.01320045e-03f, 1.89820789e-02f, 4.15556580e-02f, 1.49153136e-02f, 4.59787212e-02f, -5.11951745e-03f, 5.88395894e-02f,
  -2.18185335e-02f, 1.16524309e-01f, -1.40641946e-02f, 7.49281421e-02f, 2.89157405e-02f, 1.66590270e-02f, 1.70556009e-01f, 2.98837591e-02f, -1.00402208e-02f, -2.27290560e-02f,
  3.25870849e-02f, 3.47802900e-02f, -2.66596861e-02f, -1.69908822e-01f, -4.58646156e-02f, -7.61312172e-02f, 3.98174897e-02f, -3.31869125e-02f, 3.44348922e-02f, -7.88939819e-02f,
  -1.20091245e-01f, -7.53777400e-02f, -7.91483149e-02f, 5.97412437e-02f, -2.60677245e-02f, -7.82374740e-02f, -3.64816003e-02f, -3.51678580e-02f, 1.06240764e-01f, -8.18907246e-02f,
  -3.97661179e-02f, 9.44245085e-02f, 4.91041653e-02f, 2.07178071e-02f, -3.58363823e-03f, 1.14355519e-01f, -4.19647992e-02f, 5.51746562e-02f, -3.84024950e-03f, 1.22231850e-02f,
  -9.74994823e-02f, -1.19148627e-01f, -1.97939992e-01f, -5.96636534e-02f, -5.53054884e-02f, -9.09985602e-02f, -4.09657955e-02f, -1.37864843e-01f, -4.76481132e-02f, -4.85069528e-02f,
  7.56537616e-02f, -4.99654114e-02f, -5.91384210e-02f, 1.74572635e-02f, 1.26581326e-01f, 9.94098559e-02f, 2.52198474e-03f, -1.25262875e-03f, -3.18997656e-04f, -1.66439340e-02f,
  -4.83131334e-02f, -4.64542210e-02f, 5.58932349e-02f, -3.27898711e-02f, 2.05813479e-02f, -4.53631990e-02f, -6.60777092e-02f, -3.17136422e-02f, 2.61934046e-02f, 4.22566086e-02f,
  -4.44559246e-01f, 3.21612269e-01f, 4.31270182e-01f, 2.79717036e-02f, -2.93732341e-02f, -2.16247648e-01f, -3.04494530e-01f, 3.35314274e-01f, 1.51751107e-02f, 3.61041538e-02f,
  1.69235453e-01f, -2.27731299e-02f, 2.01364905e-01f, 1.63608968e-01f, 3.88310626e-02f, 8.56625587e-02f, -1.46081150e-01f, -1.11969873e-01f, 4.71145622e-02f, 1.05718739e-01f,
  -2.99324971e-02f, 6.32504895e-02f, 2.36944988e-01f, 6.91670626e-02f, 8.99433568e-02f, 1.03751123e-01f, 1.40486419e-01f, 1.90923586e-01f, -1.30976904e-02f, -1.32710710e-01f,
  -1.33839011e-01f, 1.26177028e-01f, 8.60070139e-02f, 1.91123299e-02f, -1.20835623e-03f, -1.22056432e-01f, -6.94596320e-02f, -3.47428620e-02f, -5.61742149e-02f, 4.07037915e-05f,
  -6.19200394e-02f, 1.36818230e-01f, 2.56720427e-02f, -2.25018095e-02f, -3.69134359e-02f, 8.27380046e-02f, 1.21456675e-01f, 5.20279594e-02f, -1.39692472e-02f, 8.23566243e-02f,
  6.85213283e-02f, 1.12918511e-01f, -1.35951504e-01f, 1.98402274e-02f, 2.69542057e-02f, -6.35799626e-03f, -9.43825617e-02f, 3.36764604e-02f, -2.53081247e-02f, -2.60809511e-02f,
  -1.53422520e-01f, 1.55181617e-01f, 5.49990721e-02f, 9.30255800e-02f, 2.16383114e-02f, 6.68842345e-02f, -7.55077042e-03f, -7.67314285e-02f, -3.69833931e-02f, 5.00751548e-02f,
  3.39008830e-02f, 1.28385779e-02f, -2.57524550e-02f, -4.87817675e-02f, -1.63489655e-02f, 6.73437193e-02f, -6.13951264e-03f, 2.85863802e-02f, -5.33246584e-02f, 7.10476488e-02f,
  -1.62115656e-02f, -3.74750122e-02f, 3.05290334e-02f, 2.41548847e-02f, 5.14897145e-02f, 5.62888011e-02f, 4.93119210e-02f, -6.29795641e-02f, 7.37750232e-02f, 4.29403111e-02f,
  9.68909636e-02f, 2.59255856e-01f, 2.60912590e-02f, -1.05958253e-01f, -6.96247735e-04f, 3.17725316e-02f, -2.36297715e-02f, 9.51975584e-02f, -4.95851375e-02f, 5.83567936e-03f,
  -3.73474620e-02f, 7.19378283e-03f, -3.54389078e-03f, 5.31597249e-02f, -1.15091959e-02f, -1.45234575e-03f, 7.70761222e-02f, 1.73118502e-01f, 4.52453531e-02f, 1.25216529e-01f,
  2.00775713e-01f, 3.60837113e-03f, -3.02387159e-02f, 3.98820499e-03f, -9.80320759e-03f, 9.48355496e-02f, -5.53329587e-02f, 3.80302370e-02f, -2.45764777e-02f, 5.03977016e-02f,
  -6.91236436e-01f, 2.25032181e-01f, -3.43899757e-01f, -1.26992062e-01f, 6.89838007e-02f, 2.34340504e-01f, 1.46998286e-01f, -4.25236076e-02f, -7.45745450e-02f, 2.40555316e-01f,
  1.27895549e-01f, -1.98726192e-01f, 5.55350818e-02f, 7.22710192e-02f, -3.94352973e-01f, 9.67335254e-02f, 9.90724862e-02f, 9.93659198e-02f, 4.33377363e-02f, 1.95662351e-03f,
  -1.17146499e-01f, 1.40102759e-01f, -6.22677840e-02f, 1.01062052e-01f, -4.71397080e-02f, -2.59024918e-01f, 1.49232566e-01f, -8.79283175e-02f, 5.47362193e-02f, -5.15179448e-02f,
  -8.01667944e-02f, -3.50010067e-01f, -5.34601919e-02f, -2.32669368e-01f, -3.25855538e-02f, -4.00931276e-02f, -4.13384177e-02f, -9.97798070e-02f, -1.13611348e-01f, -4.31627706e-02f,
  -2.04578236e-01f, -1.13810413e-01f, 7.48187862e-03f, -5.46429679e-02f, -1.84507873e-02f, -8.95053446e-02f, 6.96635246e-02f, 1.40544714e-03f, 6.09758683e-02f, -7.77659863e-02f,
  1.56975258e-02f, -9.63538662e-02f, 1.35330707e-01f, 2.92117428e-02f, 5.91839328e-02f, 1.67417340e-02f, -2.60107648e-02f, 2.18247399e-02f, 3.64769250e-04f, -1.16148256e-02f,
  -1.95609909e-02f, -8.52290094e-02f, 1.64401792e-02f, -7.47521892e-02f, 6.04789481e-02f, -9.65542346e-02f, 2.26174966e-02f, -4.47422527e-02f, 1.29927665e-01f, 2.39045527e-02f,
  1.00559872e-02f, -6.08933009e-02f, -9.63440314e-02f, 5.39245009e-02f, 1.35783283e-02f, -2.71980390e-02f, -2.95820106e-02f, 6.67112991e-02f, 2.79916581e-02f, -4.81803529e-02f,
  -2.38274653e-02f, -2.82856007e-03f, -3.73469462e-04f, 3.27066355e-03f, -1.19294107e-01f, -3.96564975e-02f, 6.89713508e-02f, -1.59574486e-02f, -4.96509150e-02f, 5.13247587e-02f,
  1.64219052e-01f, -8.72323811e-02f, -5.28936721e-02f, -6.77538887e-02f, -2.40315124e-03f, -4.20418456e-02f, -8.65035579e-02f, -3.95454541e-02f, -3.19895111e-02f, -1.29172383e-02f,
  -6.44031763e-02f, 2.71337051e-02f, -4.41756062e-02f, 3.09044141e-02f, 4.16810587e-02f, 2.83934698e-02f, 1.19272321e-01f, -3.55470479e-02f, 2.61539482e-02f, -8.39948505e-02f,
  3.25231664e-02f, -7.37872496e-02f, -8.26828256e-02f, 1.29250497e-01f, 4.51414958e-02f, 1.01366326e-01f, 6.26453087e-02f, -2.05633566e-02f, 1.00480363e-01f, 3.87453809e-02f,
  -1.23802193e-01f, 3.95872116e-01f, -1.28905132e-01f, 1.51156232e-01f, -1.57105535e-01f, 3.93233359e-01f, 4.06389058e-01f, 2.95710545e-02f, 3.21355402e-01f, 5.38254619e-01f,
  6.69513121e-02f, 1.86397851e-01f, 2.35728160e-01f, 4.24436927e-01f, 1.41420305e-01f, 3.39747399e-01f, 3.97348017e-01f, 2.36161664e-01f, 5.35591953e-02f, 1.91160783e-01f,
  1.71435974e-03f, 2.22694725e-01f, -8.35165158e-02f, -1.54973775e-01f, 1.25711206e-02f, -2.44896546e-01f, -7.57090524e-02f, -1.68380395e-01f, 5.44684976e-02f, -1.94356050e-02f,
  4.10828069e-02f, 9.86397937e-02f, -1.22229174e-01f, -6.44925088e-02f, -8.88173357e-02f, -7.65480474e-02f, -1.22830540e-01f, -1.02004543e-01f, -1.17324658e-01f, -8.39767531e-02f,
  5.17323725e-02f, -8.01662877e-02f, 6.27072230e-02f, -1.12521881e-02f, -4.01854254e-02f, -1.36808544e-01f, -7.73493722e-02f, 2.11907029e-02f, 1.14431772e-02f, 4.46582846e-02f,
  -2.99318302e-02f, -1.49860298e-02f, 2.98618730e-02f, 3.51533182e-02f, -1.12026855e-01f, -2.14788653e-02f, 1.36067614e-01f, -5.72881624e-02f, 4.01906371e-02f, 9.45771262e-02f,
  5.85115999e-02f, 1.03562295e-01f, 7.30856210e-02f, -7.64809698e-02f, 6.49149641e-02f, -3.89288738e-02f, 9.50174704e-02f, -1.73773859e-02f, -2.87265740e-02f, 1.06643885e-01f,
  3.34986346e-03f, 3.40681933e-02f, -1.04144441e-04f, -1.09937899e-02f, 1.68699652e-01f, -9.78719667e-02f, -3.15009132e-02f, 6.34833938e-03f, -5.65493032e-02f, 1.08383829e-03f,
  1.32743968e-02f, 6.44513816e-02f, -1.01747036e-01f, -7.17629045e-02f, 2.56077461e-02f, -3.03508192e-02f, 5.74491359e-02f, 1.63075384e-02f, -7.73035139e-02f, 2.33836714e-02f,
  2.07479641e-01f, 4.17786688e-01f, 6.11267686e-02f, 9.11481399e-03f, -4.80002239e-02f, -1.57253612e-02f, 4.36505452e-02f, 7.77278170e-02f, 3.24676856e-02f, 2.69268658e-02f,
  -7.84489289e-02f, -7.04278843e-03f, 6.22879937e-02f, -9.42106619e-02f, 3.20864134e-02f, 1.54161721e-01f, 1.88049123e-01f, 7.41099715e-02f, -6.69992529e-04f, -4.52953875e-02f,
  1.02704987e-02f, 1.62958235e-01f, 2.51888894e-02f, 1.88215338e-02f, 9.88441780e-02f, 1.34238508e-02f, 1.34782270e-02f, -6.60497695e-02f, -5.22381738e-02f, 8.23071525e-02f,
  1.21030964e-01f, -2.95833617e-01f, -3.53867501e-01f, -1.32737949e-01f, 3.05308998e-01f, 1.61623910e-01f, -1.05709329e-01f, -7.48131098e-03f, -2.39361361e-01f, 4.70623747e-02f,
  1.22814856e-01f, -2.01822147e-01f, -3.77290368e-01f, 1.87633969e-02f, 1.04255311e-01f, -3.49737734e-01f, 1.72410294e-01f, 6.91116676e-02f, -1.33780733e-01f, 2.25769021e-02f,
  -3.52134630e-02f, 3.04359913e-01f, -1.69030666e-01f, 2.32134342e-01f, 1.19267568e-01f, -7.84729272e-02f, 1.15921378e-01f, -6.02716766e-02f, 1.32041693e-01f, 9.79683399e-02f,
  4.18500938e-02f, -8.83377418e-02f, -9.75305438e-02f, -4.42732573e-02f, 1.43652052e-01f, 1.30260810e-01f, 3.09329424e-02f, -1.13332950e-01f, -3.92862633e-02f, -4.65661287e-02f,
  2.63330061e-02f, -4.69369292e-02f, -2.61768457e-02f, -1.43584177e-01f, 9.30766240e-02f, 9.78910271e-03f, -1.88030869e-01f, -1.26123071e-01f, -1.57825917e-01f, -1.49436248e-02f,
  3.26625034e-02f, -9.61649269e-02f, -2.73348987e-02f, 5.46653122e-02f, -1.75633430e-02f, 2.30231080e-02f, 3.65418084e-02f, -8.08387548e-02f, -1.82573106e-02f, 1.79071173e-01f,
  2.09899936e-02f, 1.74931381e-02f, 5.74221686e-02f, -5.62743619e-02f, -2.27691550e-02f, -1.07845301e-02f, -1.07397303e-01f, -5.44028766e-02f, -1.15039632e-01f, 2.71879858e-03f,
  -5.01116831e-03f, -9.49389935e-02f, 2.46283435e-03f, 5.06474711e-02f, 7.28679448e-02f, 2.22836751e-02f, -2.01489055e-03f, 1.24719985e-01f, 8.43467657e-03f, -4.61757518e-02f,
  -3.54399942e-02f, 1.43105283e-01f, 8.46725926e-02f, -4.46489919e-03f, 3.14998627e-02f, 2.00050045e-02f, 7.23336339e-02f, -2.47529335e-02f, -6.32558912e-02f, 7.19132796e-02f,
  -3.55350561e-02f, -4.89660576e-02f, -2.93436199e-02f, -2.51758564e-02f, -8.72156918e-02f, 1.18666805e-01f, -2.94103809e-02f, 1.05255255e-02f, 4.95708026e-02f, 4.22167107e-02f,
  1.47043467e-01f, -1.10856801e-01f, 8.08749255e-03f, -1.01098297e-02f, -1.24318935e-01f, 9.93600488e-02f, 9.31246504e-02f, 1.80642530e-02f, 9.10796598e-02f, 3.66070867e-02f,
  9.87873003e-02f, 5.10489158e-02f, 3.91357020e-03f, -1.63645055e-02f, 7.37498328e-02f, -2.87388284e-02f, 9.02655348e-03f, 6.61700666e-02f, -1.57978274e-02f, -2.36351276e-03f,
  -3.71388137e-01f, 1.58259094e-01f, 2.04108898e-02f, -2.12064639e-01f, 4.65132631e-02f, -1.34811038e-02f, -2.03696117e-01f, 2.04464179e-02f, -1.40792206e-01f, 2.78465778e-01f,
  -1.59800172e-01f, 5.66490553e-02f, -1.48248570e-02f, -2.95042396e-01f, -6.82948530e-01f, -4.39833611e-01f, -3.22813690e-01f, -1.21565543e-01f, -1.82073444e-01f, 7.70782009e-02f,
  -3.05099308e-01f, -3.18734884e-01f, -2.95866907e-01f, -2.29275823e-02f, 1.97107866e-01f, 1.50899053e-01f, 9.62489024e-02f, 2.33147860e-01f, 1.18168406e-01f, -1.00312583e-01f,
  -7.53161088e-02f, -1.22423349e-02f, 1.22899801e-01f, 1.70670066e-03f, 1.12682879e-01f, 9.76685360e-02f, 1.79240182e-01f, -1.40698090e-01f, -9.94534194e-02f, -2.19126977e-02f,
  4.45040641e-03f, -7.69771412e-02f, -1.86221600e-02f, -2.00360809e-02f, 9.91120376e-03f, 4.15101387e-02f, 1.04963675e-01f, 7.52062798e-02f, -1.74177997e-02f, -1.21011976e-02f,
  1.21802429e-03f, 6.17526798e-03f, 5.27800396e-02f, -1.60140041e-02f, -2.16419064e-02f, 9.43032280e-03f, 4.92855944e-02f, 1.05215900e-01f, 8.95745158e-02f, -5.45885507e-03f,
  3.89365777e-02f, 3.38463895e-02f, -6.07741019e-03f, -5.31847449e-03f, -2.69015133e-02f, 1.29328877e-01f, -7.54061788e-02f, 1.15966536e-02f, 6.10870011e-02f, 7.44496509e-02f,
  -5.20085543e-03f, 3.60914283e-02f, -8.99393633e-02f, 1.00445822e-02f, 2.31046285e-02f, 5.85820116e-02f, -6.00407459e-02f, 2.81172048e-04f, -2.94952039e-02f, -1.01448156e-01f,
  2.07130406e-02f, 2.45639179e-02f, 5.66610433e-02f, 6.26892522e-02f, -7.93841928e-02f, -3.21234316e-02f, -2.43050810e-02f, -8.72591883e-03f, 1.05276100e-01f, 8.41416512e-03f,
  -3.44926566e-02f, 6.75788447e-02f, -7.30777951e-03f, -5.99575713e-02f, -7.44889751e-02f, -7.76368901e-02f, -9.66358036e-02f, 3.19603621e-03f, 8.35603103e-02f, -7.97342062e-02f,
  1.18656822e-01f, 1.21977236e-02f, 5.88936023e-02f, -5.83367683e-02f, -1.56830214e-02f, 3.89015935e-02f, 3.37528624e-02f, 7.80648291e-02f, 1.42255947e-01f, -1.26969331e-04f,
  9.08453614e-02f, 4.12068516e-02f, -1.68035164e-01f, -2.15764549e-02f, -4.02987786e-02f, 1.55105814e-01f, 7.40413964e-02f, 5.23546077e-02f, -2.69501936e-02f, 3.16869654e-02f,
  3.20373058e-01f, -1.69285476e-01f, 7.01894313e-02f, -2.58369204e-02f, -1.54437246e-02f, 1.90531418e-01f, 4.09919053e-01f, -1.29854843e-01f, -1.83416665e-01f, -2.39606977e-01f,
  -1.56881567e-02f, -2.00503767e-02f, 2.40879551e-01f, -5.78602254e-02f, 1.83894306e-01f, 1.96319833e-01f, 7.71917403e-02f, 4.30947430e-02f, 1.30167417e-02f, 1.53326783e-02f,
  -1.24035135e-01f, 3.31271887e-02f, 2.48379502e-02f, -1.24038912e-01f, 1.28401473e-01f, -1.12302244e-01f, -1.41137213e-01f, 1.79948404e-01f, -1.14454225e-01f, -8.04099347e-03f,
  1.06665291e-01f, 7.20278472e-02f, 9.29758027e-02f, 6.93095326e-02f, -5.32904677e-02f, 5.49782924e-02f, 5.65750189e-02f, 2.11530685e-01f, -3.27278040e-02f, -6.52617542e-03f,
  -3.56616080e-02f, -9.18721557e-02f, -5.13500385e-02f, -4.15959489e-03f, -7.89226964e-02f, -2.10824281e-01f, -5.30630872e-02f, 4.91111428e-02f, -8.88035372e-02f, 1.47294566e-01f,
  2.16298271e-02f, -7.73467124e-03f, 1.25812531e-01f, -2.41528198e-01f, -1.35862315e-02f, -6.09344617e-02f, 1.08698113e-02f, 7.81572983e-02f, -1.25407323e-01f, 5.22096753e-02f,
  3.58238667e-02f, 3.59783359e-02f, 1.36792585e-01f, -7.38872141e-02f, 5.49493730e-02f, -6.08546883e-02f, -4.14376939e-03f, -2.61197947e-02f, -3.46062593e-02f, 1.53161228e-01f,
  -4.70201485e-02f, -1.17695123e-01f, 1.02753811e-01f, -4.26370874e-02f, -1.98142789e-02f, -1.34913158e-02f, 1.21204302e-01f, -1.70193762e-02f, -2.31644846e-02f, 1.98071096e-02f,
  -9.98138711e-02f, 5.67170158e-02f, -7.55278990e-02f, -1.26710892e-01f, -6.49349838e-02f, -3.00920792e-02f, -1.52202651e-01f, -7.47860447e-02f, -3.46883349e-02f, 8.87875110e-02f,
  2.10134666e-02f, -1.36268148e-02f, 3.48663218e-02f, -5.06075062e-02f, -1.36231417e-02f, 4.36860658e-02f, 2.50228971e-01f, -6.06573485e-02f, -3.60724702e-02f, 2.13460997e-01f,
  -8.46338347e-02f, 6.93551153e-02f, -8.20196196e-02f, -1.35250866e-01f, -1.60206646e-01f, -9.26389545e-02f, -1.03849582e-02f, -4.99229319e-02f, -2.22267490e-02f, -1.30783208e-02f,
  7.64324367e-02f, 6.14051372e-02f, 8.50748941e-02f, -1.29249290e-01f, -1.03753999e-01f, 1.05843075e-01f, -1.14485443e-01f, 2.58122366e-02f, -1.16092615e-01f, 5.94339566e-03f,
  1.85379013e-01f, -1.93100423e-01f, -2.04390377e-01f, -2.45818704e-01f, -8.38332698e-02f, -2.47672155e-01f, -2.31495544e-01f, -2.60700732e-01f, 1.15044519e-01f, -2.18628161e-02f,
  -1.28073961e-01f, 1.39802203e-01f, 2.23691389e-01f, -2.64759213e-01f, 3.41933310e-01f, 2.33552188e-01f, -1.78664044e-01f, -1.55222863e-01f, -1.35868173e-02f, -8.57734829e-02f,
  -9.34338570e-02f, -2.08798483e-01f, -1.10114671e-01f, -3.77628833e-01f, -4.03969467e-01f, -2.77220845e-01f, -5.09096123e-02f, -2.14414060e-01f, -2.37270907e-01f, -4.73316498e-02f,
  -1.22698128e-01f, -8.93843621e-02f, -1.42080367e-01f, 1.17417671e-01f, -7.07675889e-02f, -4.09866422e-02f, 2.79678926e-02f, -9.56568867e-02f, 1.49293810e-01f, 1.38926193e-01f,
  8.50942284e-02f, 1.28440693e-01f, -2.53838813e-03f, 4.47832830e-02f, 2.74896305e-02f, -2.87386347e-02f, 9.93695110e-02f, 6.55660853e-02f, 3.08534550e-03f, -5.05571030e-02f,
  2.07873303e-02f, -2.73342021e-02f, -8.37054923e-02f, 1.33563086e-01f, -4.88764420e-02f, -7.23742619e-02f, 6.16250560e-02f, 5.16577102e-02f, 1.43753411e-02f, 6.38941750e-02f,
  -1.53022319e-01f, 7.90370349e-03f, 1.01352379e-01f, -2.44551916e-02f, -3.65095064e-02f, 5.54731451e-02f, 6.87562823e-02f, 5.43834493e-02f, 1.59011185e-01f, 3.53502147e-02f,
  6.85006678e-02f, -1.53928790e-02f, 8.81493092e-02f, 1.04390152e-01f, 6.02882169e-02f, 3.17534804e-02f, 1.81728683e-03f, 2.41111442e-02f, -3.56995761e-02f, -4.87338379e-02f,
  -4.61850762e-02f, 1.11304097e-01f, -9.32193100e-02f, -1.02232784e-01f, -3.42297554e-02f, 3.69000398e-02f, 6.98612630e-02f, -1.11270793e-01f, 2.27728952e-02f, -2.88710799e-02f,
  -3.80033478e-02f, -1.42990679e-01f, -1.10673361e-01f, 4.65643257e-02f, -3.98216359e-02f, 7.19508678e-02f, 4.83785979e-02f, -4.71383221e-02f, 1.38468994e-02f, 3.10392696e-02f,
  -2.31687259e-02f, -2.79061534e-02f, 2.85014994e-02f, -2.85196993e-02f, 4.71113808e-02f, -3.66580561e-02f, 7.20439032e-02f, 1.22852951e-01f, 3.08098421e-02f, -1.25813246e-01f,
  8.73062294e-03f, 2.03185737e-01f, 4.83661629e-02f, 7.83419237e-02f, 1.45144318e-03f, 1.06080882e-01f, 9.83602107e-02f, -3.19118202e-02f, 7.20065534e-02f, 7.59673640e-02f,
  3.85491818e-01f, -3.16594392e-01f, 2.36880749e-01f, 3.49409550e-01f, 4.70880359e-01f, 3.00618976e-01f, 3.49511296e-01f, 2.45406464e-01f, 6.09891415e-01f, -1.85363546e-01f,
  -1.55198589e-01f, -1.31510258e-01f, -1.12470269e-01f, -3.77322659e-02f, 1.76700458e-01f, -1.13358989e-01f, 2.30493277e-01f, 1.37061670e-01f, 1.94603622e-01f, 7.50142112e-02f,
  1.87967524e-01f, 7.18257353e-02f, -2.22921148e-01f, -6.20104447e-02f, 1.78211052e-02f, 7.09346980e-02f, -2.39883989e-01f, 4.02313508e-02f, -2.21700326e-01f, 8.48428756e-02f,
  1.16787598e-01f, 1.20906988e-02f, -1.48778260e-01f, -1.46569058e-01f, 6.64504245e-02f, -6.05971739e-02f, -1.54289991e-01f, -7.64323175e-02f, 7.50529021e-02f, 3.98395471e-02f,
  9.90612525e-03f, -5.09458706e-02f, 5.49101420e-02f, 1.52644962e-02f, 9.75248590e-02f, 4.18658480e-02f, 1.02538336e-02f, -7.03864247e-02f, -2.82659624e-02f, -1.33530185e-01f,
  6.05845340e-02f, -6.56269118e-03f, 8.92643109e-02f, -5.78683876e-02f, 7.06726760e-02f, -5.48133440e-02f, 3.21019650e-03f, 5.07368520e-02f, 8.17443207e-02f, -1.65060572e-02f,
  -4.84185331e-02f, 1.17569596e-01f, 1.33587243e-02f, -6.14308193e-02f, -2.79295519e-02f, -5.84513433e-02f, -5.79946935e-02f, -5.27891964e-02f, 1.03912048e-01f, -1.01698264e-01f,
  -1.01219065e-01f, 5.97139783e-02f, 6.53069317e-02f, -9.85191017e-02f, 1.34071529e-01f, -6.42384961e-03f, -2.61010528e-02f, 8.38048980e-02f, 5.91752790e-02f, -9.28874239e-02f,
  -8.11760500e-02f, -4.84036729e-02f, -1.06082689e-02f, 3.19498242e-03f, 6.68934286e-02f, -3.42348851e-02f, -3.69653180e-02f, 1.60588816e-01f, -5.86245488e-03f, 1.55456830e-02f,
  7.69084841e-02f, -6.79588169e-02f, -3.50062102e-02f, -6.70163333e-02f, -2.90131639e-03f, 4.28961366e-02f, 2.64667273e-02f, 1.54136829e-02f, -5.02327420e-02f, 4.58402894e-02f,
  6.63595796e-02f, -2.92273816e-02f, -6.19849339e-02f, -4.06542718e-02f, -2.89977790e-04f, 7.03204870e-02f, 4.93052378e-02f, -8.80415514e-02f, -1.44225294e-02f, -1.39814869e-01f,
  -6.56521097e-02f, -7.29269236e-02f, 2.37493720e-02f, 4.28153276e-02f, -2.16335710e-02f, -5.52681573e-02f, 5.83675094e-02f, -5.94131872e-02f, -2.48813089e-02f, 4.64674383e-02f,
  -7.48453438e-01f, -3.58777046e-02f, -1.17320225e-01f, -1.94830656e-01f, -2.02100843e-01f, -1.16604656e-01f, 3.84541973e-02f, -2.16566101e-02f, 9.35682356e-02f, 3.56327981e-01f,
  1.89081252e-01f, -3.28693449e-01f, 2.37242013e-01f, 3.64897251e-02f, -4.19978678e-01f, 2.98059061e-02f, -9.87957492e-02f, 2.51162685e-02f, -8.76344964e-02f, -1.22158274e-01f,
  -1.42766491e-01f, 1.22818619e-01f, -2.24663198e-01f, 1.76458910e-01f, -7.65943602e-02f, -3.75277959e-02f, 6.50176629e-02f, 7.45489448e-03f, 3.91389616e-03f, -7.16088340e-02f,
  -1.59561768e-01f, 6.70703426e-02f, 1.21235056e-02f, 4.22801310e-03f, -8.28009471e-02f, -8.10275599e-03f, 3.45051065e-02f, -3.59658562e-02f, 4.06149663e-02f, -7.18918517e-02f,
  -2.92761438e-02f, 2.05459613e-02f, -4.64975163e-02f, 8.55035558e-02f, 2.62692943e-02f, -2.92414567e-03f, -1.14507806e-02f, -9.18651596e-02f, -5.80268092e-02f, -1.10679619e-01f,
  -1.26607940e-01f, -3.48866209e-02f, 1.29116312e-01f, 3.02974582e-02f, -2.49236245e-02f, 7.84632862e-02f, -6.18173648e-03f, 7.98785314e-02f, -2.89187133e-02f, -2.50614118e-02f,
  5.93214147e-02f, -6.19245134e-02f, 5.91238812e-02f, 4.82297987e-02f, -8.69932398e-03f, 5.55024520e-02f, 4.00796458e-02f, 3.74220833e-02f, -5.85839786e-02f, -5.33433119e-03f,
  -1.83691774e-02f, -5.73910251e-02f, -1.65098589e-02f, -1.53800100e-02f, 4.97335233e-02f, -6.12050258e-02f, -3.47548388e-02f, 4.93526533e-02f, -8.65411833e-02f, -5.53379953e-02f,
  5.59230819e-02f, 5.46986386e-02f, 5.72228655e-02f, -1.75516540e-03f, 2.38309298e-02f, 1.35004520e-01f, 2.03968938e-02f, 4.04863656e-02f, -2.04415619e-02f, -3.13507728e-02f,
  -1.95755497e-01f, -8.80835652e-02f, -1.49323689e-02f, -6.04867414e-02f, 9.60897096e-03f, -8.26406553e-02f, 9.39377993e-02f, 9.22835432e-03f, 8.21666569e-02f, 3.90813909e-02f,
  -4.25122641e-02f, 6.37205243e-02f, -2.52001099e-02f, 8.10332149e-02f, -1.92379113e-02f, 1.24833375e-01f, -3.38623933e-02f, -7.97784179e-02f, -1.40202437e-02f, -1.15897357e-01f,
  -5.37560247e-02f, -3.97349745e-02f, 7.76625052e-02f, 3.59388487e-03f, 6.31445274e-02f, -3.78604308e-02f, -9.73016117e-03f, -7.62237459e-02f, -7.29291216e-02f, 1.14110773e-02f,
  1.00646272e-01f, -3.92596833e-02f, -2.13765010e-01f, 2.31537879e-01f, -4.41155657e-02f, -1.60927877e-01f, -1.63942292e-01f, 1.55862151e-02f, -1.86597228e-01f, 5.42879738e-02f,
  2.04780787e-01f, -1.87402200e-02f, -2.39108200e-03f, 3.75307143e-01f, 3.95344526e-01f, -1.03682011e-01f, 4.55973923e-01f, 1.12155832e-01f, 3.36937346e-02f, 1.87011793e-01f,
  1.03731900e-01f, 3.23136419e-01f, 1.33678854e-01f, 2.36634865e-01f, 1.11887842e-01f, -9.78062600e-02f, 3.04148972e-01f, 5.09166978e-02f, 3.30555797e-01f, 8.89535770e-02f,
  1.08486135e-02f, 9.83304251e-03f, 2.31240280e-02f, -7.97312930e-02f, -4.62080501e-02f, 1.58946700e-02f, 8.58028792e-03f, 1.57043077e-02f, -9.58210416e-03f, 5.94824436e-04f,
  -8.79379809e-02f, 5.04708551e-02f, 5.05617782e-02f, 5.36226854e-03f, -3.84075358e-03f, -5.95050119e-02f, -8.03833604e-02f, -3.08847725e-02f, -8.34352374e-02f, 1.20421529e-01f,
  -1.11653313e-01f, -1.20135890e-02f, -4.34053540e-02f, 7.76359662e-02f, -4.24753167e-02f, -2.25159563e-02f, -4.92931493e-02f, -1.46255805e-03f, 1.13810608e-02f, 1.61325876e-02f,
  1.26806512e-01f, -1.67000100e-01f, -1.87063292e-01f, -8.95072147e-02f, 3.46450582e-02f, 4.38350625e-02f, 9.21280980e-02f, 5.02325594e-02f, 1.58025716e-02f, -3.76496203e-02f,
  -4.14603092e-02f, -6.96163028e-02f, -6.18265271e-02f, -7.03524426e-02f, -6.54170755e-03f, -7.00624213e-02f, -5.47307245e-02f, 5.74348159e-02f, -5.75094707e-02f, 2.60348041e-02f,
  6.76768348e-02f, 1.25299960e-01f, -1.01317782e-02f, -1.76101681e-02f, -2.93277167e-02f, 2.34233942e-02f, 7.17850327e-02f, 6.23794049e-02f, 1.28216911e-02f, -2.51915529e-02f,
  2.70500351e-02f, 1.21860720e-01f, -4.79966104e-02f, -3.53978500e-02f, -3.44660580e-02f, -5.35782464e-02f, 2.50027189e-03f, 4.74857986e-02f, 1.59466155e-02f, -7.79343098e-02f,
  1.05876908e-01f, 3.90201285e-02f, -1.11948974e-01f, 9.78048071e-02f, 8.89993161e-02f, -5.07767200e-02f, 1.88929942e-02f, -2.58047730e-02f, 1.25108995e-02f, 1.11173011e-01f,
  -3.61753181e-02f, -5.12568839e-02f, -8.00192263e-03f, -1.40147924e-01f, -6.14443049e-02f, -5.35814650e-02f, -1.36278104e-02f, -1.00262210e-01f, 1.27003625e-01f, -8.34953487e-02f,
  6.06624894e-02f, 1.08034782e-01f, -3.17941278e-01f, -1.90645784e-01f, -2.61421889e-01f, 3.15502554e-01f, 3.03850710e-01f, -5.34483492e-02f, -1.11631215e-01f, 4.22958732e-01f,
  2.57215738e-01f, 4.90655471e-03f, 2.95776695e-01f, 2.56185055e-01f, -1.00203693e-01f, 3.22157979e-01f, 2.43226603e-01f, 2.11742863e-01f, -7.39570186e-02f, 4.45567518e-02f,
  -6.17136694e-02f, 2.70301491e-01f, 5.96431121e-02f, 4.02491428e-02f, 1.48260221e-01f, -2.63745844e-01f, -2.67131831e-02f, -2.15767905e-01f, 6.97789490e-02f, -7.89690390e-02f,
  5.54596148e-02f, -4.52616513e-02f, -5.32404780e-02f, -5.00598922e-02f, -9.85844713e-03f, -8.52366462e-02f, -8.33519846e-02f, -1.88818216e-01f, -1.04289524e-01f, 1.85938664e-02f,
  2.23153569e-02f, -1.13943912e-01f, 3.81547026e-02f, -7.32251257e-02f, -4.42514010e-03f, -1.30308181e-01f, 3.27472650e-02f, 1.71692595e-02f, 5.04932040e-03f, 3.15078162e-02f,
  -5.57136126e-02f, -7.35854954e-02f, -1.53797502e-02f, -8.66416916e-02f, -1.00574851e-01f, -1.61339492e-02f, 8.94477367e-02f, -1.14717275e-01f, -1.78143401e-02f, -1.49404975e-02f,
  -5.99280884e-03f, -1.80859361e-02f, 1.31690249e-01f, 3.81651372e-02f, 3.58485691e-02f, -3.03724743e-02f, 9.22906995e-02f, 1.45905986e-01f, -4.88689169e-02f, 6.88871369e-02f,
  -1.23825325e-02f, 2.27552168e-02f, 2.49572191e-02f, -1.91065408e-02f, 1.59699962e-01f, -4.73264195e-02f, 7.76141125e-04f, 6.92399293e-02f, 1.69734545e-02f, -1.41995167e-02f,
  4.05695140e-02f, 4.13093641e-02f, -8.78314488e-03f, -5.59390336e-02f, -3.24746147e-02f, -3.86953019e-02f, 1.13440052e-01f, 3.79782473e-03f, 5.98296262e-02f, 1.67103298e-02f,
  7.92225450e-02f, -7.70717040e-02f, 2.96431202e-02f, -5.84464194e-03f, -7.78027922e-02f, 4.71012890e-02f, 3.88101898e-02f, -2.20480505e-02f, -4.57428321e-02f, -1.61785707e-02f,
  -2.79590972e-02f, -4.52784933e-02f, 8.28296766e-02f, -8.22602436e-02f, -5.49386516e-02f, 6.23673908e-02f, 1.01271793e-01f, -4.28313427e-02f, -1.26296580e-02f, -4.06389721e-02f,
  -4.28233016e-03f, 3.31324004e-02f, -5.92200980e-02f, -2.78080478e-02f, 7.00380355e-02f, -2.54037771e-02f, -8.87655392e-02f, 4.26046969e-03f, -4.74720225e-02f, 8.85963161e-03f,
  -2.17714056e-01f, -2.53079645e-02f, -3.16477299e-01f, -3.06895316e-01f, -3.71461958e-02f, -2.43588656e-01f, -1.66822851e-01f, -2.15702299e-02f, 1.76913857e-01f, 1.59434676e-01f,
  6.80707991e-02f, 1.11225300e-01f, 1.77567393e-01f, -9.06347856e-02f, -3.12897474e-01f, 8.48653540e-02f, -3.80757540e-01f, -1.21031627e-01f, 8.00049752e-02f, -1.07981294e-01f,
  -2.05331996e-01f, -3.48091237e-02f, -1.88672870e-01f, 1.37942940e-01f, -9.39429775e-02f, -8.47907364e-03f, -1.46986172e-01f, 7.73547739e-02f, -1.37479022e-01f, 1.10880181e-01f,
  1.00051001e-01f, 1.85081899e-01f, -2.00328473e-02f, 5.04219346e-03f, -1.68109521e-01f, -9.49558467e-02f, 1.14814937e-02f, 1.17380759e-02f, -8.15350655e-03f, -6.59010280e-03f,
  -5.99469393e-02f, -2.72936001e-02f, 7.72726014e-02f, 5.81843853e-02f, -5.74221350e-02f, 6.54251575e-02f, 2.22566146e-02f, 1.35984570e-02f, 3.57461870e-02f, -9.77688096e-03f,
  -6.99534863e-02f, -2.40203924e-02f, -2.23064646e-01f, -3.46238948e-02f, 3.65837291e-02f, 6.05917722e-02f, -4.26448137e-02f, -5.26996851e-02f, 5.13571687e-03f, -6.77939728e-02f,
  3.82739902e-02f, -1.61721289e-01f, -5.80713805e-03f, 7.12423921e-02f, 3.78599763e-02f, 1.16803581e-02f, -2.16843877e-02f, 8.38779733e-02f, -8.48699510e-02f, 5.96907400e-02f,
  5.75732701e-02f, -3.08248959e-02f, -8.53215605e-02f, -2.00313792e-01f, -1.31918788e-01f, 3.21558565e-02f, -1.36690959e-01f, 7.48464838e-03f, -4.57223691e-02f, -7.40403756e-02f,
  5.74735254e-02f, -9.13254619e-02f, -6.69912994e-02f, -6.59843013e-02f, 4.09798771e-02f, -3.09992898e-02f, 3.64428237e-02f, -1.14945576e-01f, -5.60036041e-02f, -6.68871477e-02f,
  8.31141323e-02f, -7.30863065e-02f, 1.03034325e-01f, 1.13538086e-01f, 1.49089778e-02f, 2.76847556e-02f, 1.33685321e-01f, -1.77512951e-02f, -4.87753451e-02f, -3.70671600e-02f,
  -2.77252458e-02f, 1.47373229e-02f, -8.57919734e-03f, -1.60445608e-02f, -8.06891546e-02f, 3.64773063e-04f, 5.39180338e-02f, -3.12102307e-02f, -9.78774652e-02f, 5.81616685e-02f,
  -4.65558060e-02f, 8.65066797e-02f, -4.06069234e-02f, -9.01804790e-02f, 2.13211980e-02f, 4.88669723e-02f, 4.75464128e-02f, 1.32664993e-01f, -4.60944697e-02f, -4.49523181e-02f,
  -4.52903301e-01f, 5.05424917e-01f, -2.96624564e-02f, 2.20014885e-01f, -1.61161751e-01f, 3.95191580e-01f, 3.35200727e-01f, -9.08625661e-04f, 8.27590823e-02f, 2.45300069e-01f,
  1.68626875e-01f, -4.70633656e-02f, 9.86102670e-02f, 2.48972610e-01f, -8.84336978e-02f, 2.20457077e-01f, 2.36625776e-01f, 1.14772685e-01f, 5.40336184e-02f, -2.51785845e-01f,
  -6.91671371e-02f, 1.33912548e-01f, -6.09630980e-02f, -1.83128133e-01f, -1.46225095e-01f, -1.41779944e-01f, -1.27767548e-01f, -2.24739626e-01f, -8.93734097e-02f, 1.99105013e-02f,
  9.99618471e-02f, 7.49401599e-02f, -1.25947490e-01f, 6.15620054e-02f, 6.12858534e-02f, 1.52311400e-02f, -1.66371763e-02f, -2.71779462e-03f, -3.86274680e-02f, 1.00882791e-01f,
  1.33744091e-01f, -6.65993318e-02f, 1.56270847e-01f, -1.19927928e-01f, -9.93596688e-02f, -7.21571594e-02f, -6.40573911e-03f, -2.61141229e-02f, 8.05341229e-02f, 2.49722730e-02f,
  -7.12120607e-02f, 1.34270713e-02f, -2.47476809e-02f, 1.15257494e-01f, 3.17282341e-02f, 7.28294104e-02f, 7.91479126e-02f, -7.10072666e-02f, 1.12902924e-01f, 6.22263141e-02f,
  -9.37268957e-02f, 9.96131971e-02f, 5.92089333e-02f, -2.71532945e-02f, 6.21620053e-03f, -7.55715296e-02f, -1.33858636e-01f, -6.52590096e-02f, -4.98363525e-02f, 1.62126701e-02f,
  1.21900730e-01f, -5.15116192e-03f, -3.62982973e-02f, -1.90006401e-02f, -1.83448959e-02f, 1.36222064e-01f, 2.72475160e-03f, 6.16738535e-02f, -6.86143264e-02f, -2.19890513e-02f,
  -1.17693748e-02f, -3.83243673e-02f, 2.06022430e-03f, 6.48841634e-02f, -9.31656174e-03f, 1.26590794e-02f, 8.46341476e-02f, -3.23583372e-02f, -8.76340666e-04f, 4.62713391e-02f,
  8.15479308e-02f, 2.64815420e-01f, 3.17720287e-02f, 4.82469723e-02f, 5.78764342e-02f, 2.87174210e-02f, 1.47103705e-02f, 1.29798248e-01f, 1.11388288e-01f, 1.09741598e-01f,
  2.61452999e-02f, 4.78808992e-02f, 5.75028993e-02f, -5.96638359e-02f, -3.88100147e-02f, 1.01179697e-01f, 5.67825027e-02f, 2.75637601e-02f, 1.12936301e-02f, 4.78085093e-02f,
  -3.52712348e-02f, -6.34540096e-02f, -2.27981620e-02f, 3.19598094e-02f, 2.78529022e-02f, -3.76066961e-03f, -6.02469705e-02f, 3.31019610e-02f, 6.61058770e-03f, -4.44371700e-02f,
  3.18350308e-02f, 3.26382875e-01f, 3.22320759e-01f, 2.40847349e-01f, -2.80837864e-01f, -4.16460216e-01f, -3.63415867e-01f, 1.24586076e-02f, 1.87597468e-01f, -7.87773281e-02f,
  -2.08129570e-01f, 4.18249846e-01f, -3.11155349e-01f, 1.74617454e-01f, 3.58749539e-01f, -1.41272411e-01f, 1.84127808e-01f, 2.65483614e-02f, -4.85471450e-02f, 1.37162283e-01f,
  3.59182917e-02f, -1.31453529e-01f, 1.93971843e-01f, -8.54099840e-02f, 8.64110515e-02f, 2.01959088e-01f, 2.41020352e-01f, -1.53203204e-01f, 1.72643930e-01f, 3.85621302e-02f,
  -1.25649840e-01f, 1.45385697e-01f, 4.56525274e-02f, 2.86752507e-02f, -6.09722510e-02f, -8.76277760e-02f, 5.25096990e-02f, -3.89971547e-02f, -2.18790472e-02f, -3.15446518e-02f,
  7.37869292e-02f, -2.91574486e-02f, -5.58043905e-02f, -3.94901596e-02f, -2.48275064e-02f, -3.55461054e-02f, 5.25973737e-02f, 7.11528808e-02f, 5.61865643e-02f, -9.05741379e-02f,
  1.04533143e-01f, 8.21734741e-02f, -6.74754232e-02f, 1.29947111e-01f, 7.41044283e-02f, -8.08458030e-02f, -4.78374586e-03f, 2.29952037e-02f, 1.20706826e-01f, 1.21398918e-01f,
  7.08434358e-02f, -2.30233639e-01f, -1.06279805e-01f, -1.73949629e-01f, -2.52455287e-02f, -3.13137770e-02f, 7.13847354e-02f, -4.88428473e-02f, 7.47338012e-02f, -1.82480644e-02f,
  -6.19615093e-02f, 3.60835418e-02f, -6.23720661e-02f, -8.33136365e-02f, 3.75553668e-02f, -9.23691913e-02f, -5.61212823e-02f, -1.03051819e-01f, 8.22132826e-03f, 1.00298002e-01f,
  6.11419138e-03f, -6.58291802e-02f, 3.16966176e-02f, -4.82577533e-02f, -1.94201618e-01f, 1.55499866e-02f, -5.00722528e-02f, -3.12916003e-02f, 6.65185787e-03f, -3.10522169e-02f,
  1.09688200e-01f, 3.92154098e-01f, 5.96173704e-02f, 9.77239534e-02f, 6.38036579e-02f, 9.71907377e-02f, -3.28344479e-02f, -2.43101306e-02f, 2.16043711e-01f, 3.74538712e-02f,
  -1.96837112e-02f, -6.86935475e-03f, -6.55010566e-02f, -3.38430703e-02f, 5.59126884e-02f, 4.86561991e-02f, 4.22174819e-02f, 9.00537968e-02f, 1.04288898e-01f, 1.66097227e-02f,
  1.27149254e-01f, -6.46411851e-02f, 4.99450006e-02f, -4.10657749e-02f, 1.45213753e-02f, -3.36986706e-02f, -1.01064935e-01f, 4.03739996e-02f, 1.04098529e-01f, 5.03308363e-02f,
  -3.23455222e-02f, -1.28811806e-01f, -2.82008827e-01f, -1.65455014e-01f, 2.35020190e-01f, 1.36223093e-01f, -9.92604867e-02f, 6.86124898e-03f, -3.06906074e-01f, 9.12996680e-02f,
  1.50711015e-01f, -1.21414140e-01f, -3.41556340e-01f, -5.62769286e-02f, -2.16917619e-02f, -2.62516022e-01f, 1.54889345e-01f, 6.14220351e-02f, -8.20844769e-02f, 1.09140813e-01f,
  3.54659148e-02f, 1.86682612e-01f, -1.45492673e-01f, 2.27242455e-01f, 4.03034650e-02f, 2.78515313e-02f, 2.62263924e-01f, -8.03259015e-03f, 3.58381569e-01f, 1.25465333e-01f,
  -4.45752144e-02f, -9.99574438e-02f, -3.55441421e-02f, -1.13278612e-01f, 1.27973005e-01f, 1.67447075e-01f, -9.67896730e-03f, 2.35314369e-02f, -2.67573539e-02f, 5.98265696e-03f,
  -2.85512116e-02f, 1.02986895e-01f, 3.29896212e-02f, -1.64150577e-02f, 4.47783507e-02f, -2.77825501e-02f, -3.23183388e-02f, -8.53745192e-02f, -8.21414366e-02f, -5.71855828e-02f,
  -5.42521700e-02f, -4.53727785e-04f, 3.02523724e-03f, -3.03860307e-02f, 1.20922877e-02f, 3.06495801e-02f, 1.02512226e-01f, 1.40418753e-01f, 4.19149138e-02f, 5.57816438e-02f,
  8.34163949e-02f, 4.91748787e-02f, -1.53103126e-02f, -5.64097501e-02f, 3.73035669e-02f, -8.82347003e-02f, -8.22441280e-02f, -2.86104344e-02f, 1.45036466e-02f, -3.31176892e-02f,
  3.75823979e-03f, -8.90405383e-03f, 1.95285920e-02f, 1.84308495e-02f, 1.59389284e-02f, 2.89857890e-02f, -8.12536199e-03f, 8.89797807e-02f, 1.58957541e-02f, 1.50525188e-02f,
  -8.29935893e-02f, 7.70180970e-02f, 2.80178152e-02f, 1.11366948e-02f, -1.20289139e-01f, 1.09554911e-02f, -4.41309027e-02f, -5.17810695e-02f, -7.91252926e-02f, -3.78624313e-02f,
  3.97102982e-02f, 9.10851881e-02f, -3.30811068e-02f, -5.82795180e-02f, -5.63021787e-02f, -3.33495066e-02f, -1.00969307e-01f, 6.02505729e-02f, -2.41735522e-02f, 2.02608891e-02f,
  1.52655408e-01f, 9.82454121e-02f, 5.98274693e-02f, 6.99355826e-02f, 5.34427017e-02f, 7.46245608e-02f, -7.85851181e-02f, 5.93355000e-02f, 1.65433645e-01f, 5.02109826e-02f,
  1.01717070e-01f, 1.36306122e-01f, -3.82377766e-02f, -6.13829941e-02f, 5.99514879e-02f, -3.42484005e-02f, 7.49163851e-02f, 5.01444610e-03f, -2.39459332e-02f, -4.16525900e-02f,
  3.68521392e-01f, 1.07358024e-01f, 3.00110519e-01f, 9.05105099e-02f, -9.34933722e-02f, -2.08369531e-02f, 1.09362341e-01f, -2.40748793e-01f, -2.03368708e-01f, -7.64270052e-02f,
  -1.53469602e-02f, 3.08682770e-01f, 5.89094125e-02f, -1.14379495e-01f, 1.12665631e-01f, -5.55820465e-02f, -2.02929914e-01f, 1.43398792e-02f, -1.59886088e-02f, 1.41983517e-02f,
  6.36300892e-02f, -2.66335338e-01f, 6.86366782e-02f, -2.31711596e-01f, 1.73857912e-01f, 1.53504387e-01f, -1.54887170e-01f, 1.21800087e-01f, 1.09516539e-01f, 4.14497033e-02f,
  1.67025011e-02f, -1.29514948e-01f, 6.43664785e-03f, 3.57508771e-02f, 7.96826184e-02f, -1.64170302e-02f, 1.01180568e-01f, 2.89518386e-02f, -5.29776588e-02f, 8.19770526e-03f,
  1.11438781e-01f, 6.46414608e-02f, -9.36356559e-02f, 6.70533627e-02f, -3.03558045e-04f, 9.02772322e-03f, 4.92190085e-02f, 1.07354224e-01f, 4.10221666e-02f, 8.94696712e-02f,
  9.73186940e-02f, 6.22261949e-02f, -7.09402049e-03f, -3.80022861e-02f, -5.80086894e-02f, -6.39918447e-02f, -6.38682246e-02f, 2.11618319e-01f, 4.35794666e-02f, -1.68175306e-02f,
  1.56207651e-01f, 1.18411919e-02f, 1.19237825e-01f, 1.44058019e-01f, 2.36671977e-02f, -1.01436757e-01f, -1.54306833e-02f, 7.26368465e-03f, 1.33083491e-02f, 3.55861858e-02f,
  2.59242095e-02f, -4.43102196e-02f, -1.63113371e-01f, 4.61182967e-02f, 7.26058260e-02f, -4.05121641e-03f, 8.85970220e-02f, 7.58059323e-04f, 3.00229341e-02f, 1.25246774e-02f,
  -1.20205097e-01f, -1.36316277e-03f, -3.06524616e-02f, -6.63748458e-02f, -4.19765636e-02f, -1.46990800e-02f, -8.80650505e-02f, 7.96739161e-02f, -1.38613045e-01f, 1.18523300e-01f,
  -7.14878589e-02f, -1.58345997e-01f, 6.70434022e-03f, 2.52025370e-02f, 2.60621831e-02f, 6.60686791e-02f, -1.14649966e-01f, -4.81689461e-02f, 3.97996344e-02f, 2.07135621e-02f,
  5.11751994e-02f, 1.53336814e-02f, -8.36588070e-02f, 1.02871910e-01f, -7.32656866e-02f, -2.45033447e-02f, 1.18829407e-01f, 2.96370275e-02f, -4.06389460e-02f, 1.09430172e-01f,
  -1.40393164e-03f, 6.37439787e-02f, 8.50722939e-02f, 4.35322300e-02f, 2.07309984e-02f, -5.27074374e-03f, -1.26183420e-01f, 1.22504984e-03f, 1.12800345e-01f, 6.05668779e-03f,
  -7.96495140e-01f, 4.50042516e-01f, 8.44990909e-02f, -2.95257717e-01f, 1.25773028e-01f, 9.39762071e-02f, -1.74347013e-01f, 1.50205001e-01f, 1.77390389e-02f, 1.16211668e-01f,
  -7.97008071e-03f, 8.33941773e-02f, 1.29487649e-01f, -2.30023488e-02f, -3.09033155e-01f, 1.31936729e-01f, -9.81954634e-02f, 1.54752610e-02f, 1.52634010e-01f, -3.84137668e-02f,
  6.56816992e-04f, -2.17648391e-02f, -5.43152429e-02f, 2.49808475e-01f, -3.11279856e-02f, -1.09510899e-01f, -3.32080394e-01f, 1.17709622e-01f, -1.17158569e-01f, 5.81593364e-02f,
  -1.61526725e-01f, -1.41378284e-01f, -1.15775570e-01f, 4.41005416e-02f, -1.62108123e-01f, -1.03675000e-01f, -2.12528124e-01f, -7.57186934e-02f, 4.98789269e-03f, 5.23208268e-02f,
  8.10832009e-02f, 1.47037311e-02f, -4.13153395e-02f, 3.39517631e-02f, -1.08292764e-02f, 8.59364420e-02f, 1.56353936e-01f, -5.40632941e-02f, 4.01230715e-02f, 5.68394251e-02f,
  7.12700710e-02f, 1.74155720e-02f, -1.10458925e-01f, 1.34547111e-02f, -1.10428520e-01f, 4.55203205e-02f, -1.29619300e-01f, -1.33103147e-01f, -4.14869227e-02f, -7.50474259e-02f,
  -9.04341862e-02f, 3.86568205e-03f, 6.22462742e-02f, 3.24509256e-02f, 9.30759609e-02f, 3.72651324e-04f, 5.68410195e-02f, -5.81733824e-04f, 1.33272763e-02f, -1.95578244e-02f,
  -3.80116031e-02f, 5.21525852e-02f, 6.08779490e-03f, -1.31611347e-01f, 7.83531889e-02f, 1.75448190e-02f, -3.19638811e-02f, 7.20255747e-02f, -1.15868799e-01f, -4.28606160e-02f,
  3.66055481e-02f, 2.05499828e-02f, 6.00403287e-02f, -3.53350267e-02f, 1.27460539e-01f, 9.81143955e-03f, -9.89492908e-02f, 6.69037774e-02f, 3.24303396e-02f, -9.34328511e-02f,
  -2.63579160e-01f, -2.98668057e-01f, -4.92367707e-02f, 3.37677188e-02f, -5.35947494e-02f, -5.20442165e-02f, -4.77598570e-02f, -2.09465586e-02f, -1.65620103e-01f, 1.51863147e-03f,
  -1.02171771e-01f, -9.04826075e-02f, -1.87968478e-01f, 1.05669722e-01f, -5.64394370e-02f, -1.65552683e-02f, -3.33284214e-02f, -5.29583618e-02f, -6.05236441e-02f, -1.77036561e-02f,
  -1.11361384e-01f, -2.81536542e-02f, 9.30790976e-02f, -2.83356011e-02f, -1.44274771e-01f, -1.94399536e-01f, -1.81367714e-03f, -7.05202371e-02f, -1.23378769e-01f, -3.97475250e-02f,
  -2.67882437e-01f, 1.99026644e-01f, -1.60743266e-01f, -4.16917086e-01f, 1.45221204e-01f, -7.01175779e-02f, -2.19809785e-01f, 2.69636381e-02f, -4.91119102e-02f, -1.68042675e-01f,
  -2.05154344e-01f, 3.30215357e-02f, 7.06545487e-02f, -1.91038266e-01f, 8.48900378e-02f, 1.88304096e-01f, -2.52203852e-01f, -1.33494377e-01f, 1.30518034e-01f, -1.80680752e-01f,
  7.17053711e-02f, -5.85060716e-02f, -5.87057397e-02f, 1.49506941e-01f, -1.63297310e-01f, -9.88467634e-02f, -8.84259641e-02f, 5.45703731e-02f, -1.86705545e-01f, 6.49493709e-02f,
  -2.48964265e-01f, -3.08535635e-01f, -1.39204472e-01f, -9.56655741e-02f, -2.14518309e-01f, 2.72536390e-02f, -9.46803540e-02f, 1.86496321e-02f, -5.64932860e-02f, 2.73979884e-02f,
  1.83489379e-02f, 8.18542540e-02f, 2.12023426e-02f, 1.57502461e-02f, -5.26717305e-02f, 2.80077662e-02f, 2.68005189e-02f, -7.10744262e-02f, -3.66531685e-02f, 4.47129868e-02f,
  -1.46501595e-02f, -6.11661598e-02f, -5.27041852e-02f, -1.51936159e-01f, 6.58512190e-02f, -3.24502289e-02f, -1.16016045e-01f, 8.21445212e-02f, 9.20261741e-02f, -1.10353068e-01f,
  2.04946205e-01f, 9.22311395e-02f, -1.48533275e-02f, 7.09602535e-02f, -2.14872509e-03f, -6.21839252e-04f, 2.35892273e-02f, -7.40211755e-02f, -5.04609123e-02f, 2.11611092e-02f,
  5.24208248e-02f, -3.19136232e-02f, 1.62024777e-02f, -6.42186329e-02f, 1.11561520e-02f, -1.19128585e-01f, 3.59790251e-02f, 1.33257797e-02f, -5.28913774e-02f, 6.61498085e-02f,
  2.68331710e-02f, -2.63179224e-02f, 9.80933532e-02f, -6.94510937e-02f, 2.56212074e-02f, 9.34595391e-02f, 2.31145192e-02f, 7.90934935e-02f, 3.81803364e-02f, 2.30266973e-02f,
  -3.25250030e-01f, -4.16093379e-01f, -1.76377851e-03f, -1.10872105e-01f, -2.39966027e-02f, -4.02136557e-02f, 1.63955167e-01f, -3.20034958e-02f, -8.90952647e-02f, 6.26769140e-02f,
  6.74553216e-02f, -1.17246464e-01f, -9.11326781e-02f, -5.92436781e-03f, 2.20850874e-02f, 1.05056733e-01f, 5.00508063e-02f, -1.74974933e-01f, -1.78486153e-01f, 4.90553714e-02f,
  1.05776126e-02f, -5.21502458e-02f, 3.81578803e-02f, -2.16609761e-02f, -8.63891244e-02f, -7.59922192e-02f, -4.24970351e-02f, -3.49353924e-02f, -3.80060151e-02f, 6.63948059e-02f,
  1.02749884e-01f, -6.01727441e-02f, -8.92157853e-02f, -3.56805548e-02f, -1.79567695e-01f, -1.19461440e-01f, -2.66658127e-01f, -4.74296659e-02f, -2.69585401e-01f, -4.34780680e-02f,
  -4.73902076e-02f, -1.55449435e-01f, -1.09837219e-01f, -2.26192921e-02f, -9.96027216e-02f, -6.06204160e-02f, -2.39556823e-02f, -9.12849829e-02f, -6.84138462e-02f, 2.22616717e-01f,
  5.71118407e-02f, 3.84368338e-02f, 2.08646338e-02f, 2.74651319e-01f, 1.00020096e-01f, 1.86747730e-01f, 2.39392370e-01f, 1.65852487e-01f, 2.19400704e-01f, -1.43772200e-01f,
  -3.26291136e-02f, -1.10861026e-02f, -8.23985636e-02f, -6.31389767e-02f, 1.38820279e-02f, 1.38621628e-01f, 1.61750749e-01f, -1.12668686e-01f, -1.15002438e-01f, -8.75083823e-03f,
  8.46203975e-03f, -2.78178137e-02f, 8.53517056e-02f, -3.44987921e-02f, 3.56749110e-02f, 1.49971135e-02f, 1.02645904e-02f, -4.59094606e-02f, 4.68466524e-03f, 4.21727300e-02f,
  -7.32233226e-02f, 3.22304229e-04f, 1.57069162e-01f, -9.74489078e-02f, -7.49427453e-02f, 7.60530457e-02f, 1.83814447e-02f, 4.84410161e-03f, 9.45709869e-02f, -4.11161073e-02f,
  9.93062854e-02f, 4.20154445e-02f, 9.77738108e-03f, -8.13792497e-02f, -5.76986596e-02f, -7.52470046e-02f, -2.37542633e-02f, 5.80078810e-02f, -1.18625332e-02f, -3.70520055e-02f,
  -6.58099800e-02f, 1.10738743e-02f, -3.90865374e-03f, -4.54955325e-02f, -4.41789366e-02f, 1.05775729e-01f, -3.55463922e-02f, 1.00222476e-01f, -5.33161536e-02f, 7.41244555e-02f,
  -5.74748255e-02f, 4.80960049e-02f, 4.11585271e-02f, 6.94871172e-02f, 1.26943039e-02f, -1.45079410e-02f, 1.10535314e-02f, -7.09506683e-03f, -2.34747306e-02f, 1.05622806e-01f,
  8.23919475e-02f, 2.03798503e-01f, -6.10010922e-02f, -1.54331654e-01f, 4.91838567e-02f, 4.98671271e-02f, 2.09408365e-02f, 8.57478753e-02f, 3.59327346e-02f, -1.31492922e-02f,
  1.19701304e-01f, -3.14756297e-02f, 9.53578800e-02f, 8.84440169e-02f, -3.51864994e-02f, -5.01387976e-02f, 5.28373942e-02f, -3.63299763e-03f, 5.50096072e-02f, 4.64533344e-02f,
  1.16609871e-01f, 2.11840458e-02f, 5.14533818e-02f, -6.67012259e-02f, -5.75080002e-03f, 7.61219785e-02f, 6.12566173e-02f, 3.06976531e-02f, 8.51109996e-02f, -6.50663450e-02f,
  6.57384992e-01f, 1.96398780e-01f, 3.24747235e-01f, 3.03886741e-01f, -1.16976025e-02f, -2.80470047e-02f, 2.53811833e-02f, 8.51172060e-02f, 4.70967203e-01f, -7.32755959e-02f,
  -1.52754992e-01f, 2.05387339e-01f, -1.11655235e-01f, 3.21144052e-02f, -3.06860298e-01f, -2.24514186e-01f, -9.77179315e-03f, 7.91157931e-02f, 2.75526613e-01f, 1.37232751e-01f,
  5.20766596e-04f, -3.63464355e-01f, -1.60162225e-01f, -2.06005499e-01f, 1.19625553e-01f, 3.02738287e-02f, -3.89020711e-01f, -8.81336629e-02f, -1.48528293e-01f, -1.46899328e-01f,
  -2.33423989e-02f, 1.72902737e-02f, 5.38603924e-02f, -5.28637320e-02f, -1.27622637e-03f, 4.86578159e-02f, -1.03482626e-01f, -1.27153397e-01f, 8.87306482e-02f, 2.80701965e-02f,
  8.85972008e-02f, -8.61054584e-02f, 5.15123308e-02f, 5.67039773e-02f, 7.65800476e-02f, 1.00946002e-01f, 7.72810802e-02f, 1.98222235e-01f, 4.02763076e-02f, 1.85686409e-01f,
  1.27301678e-01f, 9.06173661e-02f, 9.32641476e-02f, -2.98504326e-02f, 2.09595393e-02f, -5.95251424e-03f, 9.72169638e-02f, -9.01617184e-02f, 4.34350595e-02f, 1.37369677e-01f,
  -4.81570214e-02f, -6.96836486e-02f, -9.20302868e-02f, 5.05139418e-02f, -1.21729724e-01f, 1.30399495e-01f, -1.35368913e-01f, -1.24310762e-01f, -9.01024267e-02f, -1.42351966e-02f,
  -3.05265794e-03f, -6.04036450e-02f, -8.23256746e-02f, 1.45660922e-01f, 5.42084351e-02f, 4.60792780e-02f, -2.78413482e-02f, 4.96315099e-02f, 7.41721690e-02f, 8.11500549e-02f,
  6.52435571e-02f, 1.55352065e-02f, -1.48613662e-01f, 1.78414304e-02f, 1.16688758e-03f, -1.25601161e-02f, 5.44263013e-02f, 9.50855762e-02f, -1.03786945e-01f, 1.49236443e-02f,
  -3.22769016e-01f, -1.14321649e-01f, 1.23853572e-02f, 4.39448394e-02f, -1.66618988e-01f, 8.09050500e-02f, 7.71626681e-02f, 7.13570789e-02f, 4.57800645e-03f, -6.13709651e-02f,
  3.28351595e-02f, -4.32459079e-03f, 3.39306742e-02f, -4.56075110e-02f, -2.83240806e-02f, -4.81207371e-02f, -1.40214205e-01f, -5.44899330e-02f, -6.13294318e-02f, 3.16137113e-02f,
  1.29787801e-02f, -4.39157225e-02f, -3.59422080e-02f, -2.88557298e-02f, -3.11173592e-03f, -1.36931702e-01f, 1.10449292e-01f, 1.83976386e-02f, 6.52561635e-02f, -3.04608103e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 26)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 26;
const float L0_fan_Bp_bar_data[] = {
  1.41781986e-01f, 2.76890814e-01f, 2.11723700e-01f, 3.16256285e-01f, 2.62315899e-01f, 3.02338958e-01f, 1.92909658e-01f, 2.15235621e-01f, 2.42641136e-01f, 2.81105310e-01f,
  3.45179439e-01f, 1.97074264e-01f, 6.12419611e-03f, 3.21138501e-01f, 1.33680552e-01f, 1.26858920e-01f, 3.90225723e-02f, 4.60258089e-02f, 2.26099640e-01f, 2.70145148e-01f,
  2.89608538e-01f, 3.17856610e-01f, 2.70634919e-01f, 2.12743253e-01f, 2.75131047e-01f, 3.78274828e-01f
};

// L1_fan_Wp (Shape: 3 x 32)
const int L1_fan_Wp_rows = 3;
const int L1_fan_Wp_cols = 32;
const float L1_fan_Wp_data[] = {
  5.28518818e-02f, 3.22239776e-03f, 3.44737694e-02f, -1.81016967e-01f, 1.96240962e-01f, 8.76410604e-02f, -4.05777432e-02f, 8.27381089e-02f, -6.58775568e-02f, 2.29023188e-01f,
  3.27838361e-02f, -1.56851888e-01f, -5.24476543e-02f, -1.56157926e-01f, 1.33476347e-01f, -5.63147180e-02f, -1.56551644e-01f, -7.16168508e-02f, 3.70567799e-01f, 1.06810816e-01f,
  -2.93259233e-01f, 1.39377132e-01f, -9.52420458e-02f, -2.17936561e-01f, 4.47156727e-02f, 3.08750123e-01f, 1.13900602e-01f, 1.79255664e-01f, -2.25631356e-01f, -6.07611053e-02f,
  3.81292962e-02f, -5.64489327e-02f, -3.76809984e-02f, 7.43480101e-02f, 2.60481220e-02f, -1.02290139e-01f, -2.24313699e-02f, 6.38025850e-02f, 3.13955158e-01f, 1.24659017e-01f,
  2.83192936e-02f, 4.55606729e-02f, 2.63638467e-01f, 1.14603564e-01f, -1.36024818e-01f, -1.47460401e-01f, -3.96713316e-01f, 1.23324759e-01f, -9.01966915e-03f, 1.89660192e-01f,
  3.32033157e-01f, -1.84529692e-01f, 8.34614635e-02f, -2.15665121e-02f, -3.61135423e-01f, 2.40971759e-01f, -1.57451808e-01f, -2.87480831e-01f, -6.12704232e-02f, 1.83427230e-01f,
  6.86133280e-02f, 2.73506880e-01f, -6.94989339e-02f, -2.49050304e-01f, 1.03204712e-01f, 9.24041495e-02f, 1.04171798e-01f, -1.09516084e-01f, 6.07499443e-02f, 1.74880117e-01f,
  2.03453749e-01f, 2.95492504e-02f, 1.95945725e-01f, -1.58702120e-01f, 2.30847463e-01f, 1.23881049e-01f, -1.89935043e-01f, -6.27820939e-02f, -1.05464108e-01f, 1.52875364e-01f,
  9.29233581e-02f, 2.58391500e-01f, 2.24710032e-01f, 8.49816799e-02f, -1.35513112e-01f, -1.51213527e-01f, 1.94145635e-01f, 8.11585784e-02f, -1.93584874e-01f, -8.61644521e-02f,
  3.85335460e-02f, 2.64105707e-01f, -3.46376032e-01f, 2.22338852e-03f, -9.37087238e-02f, -1.17909126e-01f
};

// L1_fan_Wp_bar (Shape: 26 x 32)
const int L1_fan_Wp_bar_rows = 26;
const int L1_fan_Wp_bar_cols = 32;
const float L1_fan_Wp_bar_data[] = {
  3.06544453e-01f, 6.52306229e-02f, 2.13256031e-01f, 1.54812485e-01f, -9.17858854e-02f, 9.64896306e-02f, 2.07451820e-01f, -4.50896695e-02f, 2.09760144e-01f, -1.02917299e-01f,
  3.35961193e-01f, 3.18410456e-01f, 5.35757560e-03f, 3.18859667e-01f, 6.75348043e-02f, 2.14644611e-01f, 4.50063273e-02f, 2.93691933e-01f, 1.10856362e-01f, -1.19487472e-01f,
  4.58667465e-02f, 1.62772939e-01f, 3.02972168e-01f, -3.21647674e-02f, 2.25425765e-01f, -4.48230833e-01f, 5.51315211e-02f, 3.43526416e-02f, 7.19111413e-02f, 1.71855405e-01f,
  1.58336326e-01f, -2.84107178e-01f, 1.54938728e-01f, 8.36205557e-02f, 1.53542727e-01f, -2.87034422e-01f, -3.71872522e-02f, 1.59810811e-01f, 2.82147080e-01f, -1.29548565e-01f,
  1.15978196e-01f, 1.07385907e-02f, 2.39820540e-01f, 2.90022314e-01f, 6.91984966e-02f, -9.54220723e-03f, 3.82522702e-01f, 1.50637060e-01f, -4.39519614e-01f, 3.39239895e-01f,
  3.04107279e-01f, -1.50726307e-02f, -3.67840193e-02f, 1.44903839e-01f, 3.04054439e-01f, -7.35899806e-02f, 2.36043900e-01f, 2.10409760e-01f, -2.25571208e-02f, 1.82117969e-01f,
  1.22771844e-01f, 1.27959102e-01f, 1.63061067e-01f, -2.44948998e-01f, 1.16739459e-01f, 2.20982313e-01f, 1.43977538e-01f, 9.50472206e-02f, -1.23057783e-01f, -1.57271430e-01f,
  -1.01120435e-01f, 3.26301545e-01f, -1.37758359e-01f, 4.52772468e-01f, -8.72132108e-02f, -1.18105762e-01f, 2.14833200e-01f, 4.57313843e-02f, 9.79133770e-02f, -1.21858202e-01f,
  2.95004845e-01f, -2.31687561e-01f, 6.17497079e-02f, 7.70275518e-02f, 2.50443280e-01f, -1.03404224e-02f, -2.74542123e-01f, 2.43650720e-01f, -6.64324015e-02f, 3.61746520e-01f,
  1.11627325e-01f, 1.18431002e-01f, 3.88224661e-01f, 1.50357738e-01f, 1.57141834e-01f, 4.69371885e-01f, 2.49241125e-02f, 1.67899832e-01f, 4.28393595e-02f, 1.12050623e-01f,
  1.31171599e-01f, -1.40529349e-01f, 7.75649399e-02f, 6.14189841e-02f, 8.99325833e-02f, 7.02163437e-03f, 5.24278939e-01f, 2.22994611e-01f, 2.96968013e-01f, -2.88999490e-02f,
  -2.37143934e-02f, 5.61742894e-02f, 1.58612564e-01f, 2.44385257e-01f, -9.12865624e-02f, 1.19506977e-01f, -2.20067039e-01f, 4.08006161e-01f, -1.78759813e-01f, -3.13924283e-01f,
  -1.67249694e-01f, 3.83722156e-01f, 2.68931478e-01f, 2.45273247e-01f, 2.22292356e-02f, -1.02100279e-02f, 1.25670910e-01f, 3.97969596e-02f, 1.07839130e-01f, 1.73029676e-01f,
  2.95088023e-01f, -2.36383021e-01f, 1.97317719e-01f, 2.46471748e-01f, -1.79791436e-01f, 2.63539135e-01f, -1.40326619e-01f, 5.35480857e-01f, 1.95278794e-01f, 1.03293344e-01f,
  -2.38848373e-01f, -3.78930837e-01f, 1.42774418e-01f, -2.36118183e-01f, -7.30841653e-03f, -3.10021006e-02f, 1.81433126e-01f, 4.19240713e-01f, -1.36309981e-01f, -2.24547669e-01f,
  -1.99971110e-01f, -8.56756605e-03f, -6.22495450e-02f, 3.21177065e-01f, -8.38030875e-02f, 1.67353287e-01f, 1.70291513e-01f, 2.65174061e-01f, -8.63752589e-02f, 6.01767838e-01f,
  2.32878998e-01f, 6.89176694e-02f, 1.63139403e-01f, -3.10561985e-01f, -6.56190366e-02f, 2.02434942e-01f, 2.57156253e-01f, 3.70307356e-01f, -2.08645985e-01f, 2.67930418e-01f,
  3.95607054e-01f, 3.35038483e-01f, -2.79770587e-02f, -2.81052917e-01f, -2.23848403e-01f, -3.15602511e-01f, -6.62862957e-02f, 2.92810768e-01f, 3.68505687e-01f, 3.58263046e-01f,
  -4.00729440e-02f, -2.72385031e-01f, 2.83720214e-02f, 2.07631811e-01f, 8.14530775e-02f, 3.33959430e-01f, -1.09808430e-01f, 9.11325887e-02f, 3.37220818e-01f, 5.05938530e-01f,
  -9.63620618e-02f, 4.01458204e-01f, 3.42079878e-01f, 1.53432891e-01f, 1.53405294e-01f, -9.19165537e-02f, 7.49986768e-02f, 1.06615767e-01f, -1.37387976e-01f, 1.69903152e-02f,
  -3.01780552e-02f, 3.37160408e-01f, -8.40929896e-02f, 3.46287817e-01f, 3.77061181e-02f, -1.84596807e-01f, 1.21014610e-01f, -5.88347390e-02f, -1.32872537e-01f, 2.33535394e-01f,
  -1.67060211e-01f, 4.06804293e-01f, -8.40221271e-02f, -2.62098640e-01f, 1.92193538e-01f, -1.31018698e-01f, 2.81556785e-01f, 1.41172775e-03f, -1.80863604e-01f, 1.29026681e-01f,
  7.44841695e-02f, -1.06599495e-01f, -1.68636385e-02f, 3.37504774e-01f, 2.45795920e-01f, 7.22361580e-02f, 2.18704477e-01f, 2.04120036e-02f, 1.53837055e-01f, -1.60714649e-02f,
  1.64764509e-01f, -2.25431487e-01f, 2.92758405e-01f, -9.13941711e-02f, 1.66974753e-01f, 3.55525881e-01f, 1.40225902e-01f, 3.20353389e-01f, 2.67478049e-01f, 3.30558807e-01f,
  5.37221394e-02f, 2.88828194e-01f, -1.76290214e-01f, 1.22562319e-01f, -8.54983851e-02f, 2.92663902e-01f, 2.52324730e-01f, -3.07160318e-01f, 5.38710654e-02f, -2.40296453e-01f,
  2.96970636e-01f, 2.19697058e-01f, -3.61310318e-02f, -1.58397973e-01f, 2.39456117e-01f, -2.03118727e-01f, 2.51641840e-01f, 1.30895689e-01f, -3.86614129e-02f, 1.73403427e-01f,
  -3.12332362e-01f, 5.41477874e-02f, 4.78968583e-02f, -1.85770214e-01f, 1.13829160e-02f, 1.44788742e-01f, 4.09300923e-02f, 4.85563040e-01f, 1.91533357e-01f, 2.63020366e-01f,
  7.18289316e-02f, 1.18918546e-01f, 1.51701190e-03f, 1.46368414e-01f, -2.01175272e-01f, -8.31698328e-02f, 1.53249696e-01f, -4.22393903e-03f, 4.10226405e-01f, 7.89166912e-02f,
  4.52279955e-01f, -3.52104008e-01f, -1.68244615e-01f, 1.27834268e-02f, 4.48797494e-01f, 1.46694109e-01f, 1.26401126e-01f, -2.79866070e-01f, 2.33952746e-01f, 3.73137891e-01f,
  -2.13656705e-02f, -5.74368760e-02f, -3.51441950e-01f, -2.69351006e-01f, 2.50252843e-01f, 3.26963514e-01f, -8.06383863e-02f, 2.39581719e-01f, 4.53210413e-01f, 3.62919033e-01f,
  3.75187546e-01f, 9.23291966e-02f, 1.56002701e-03f, -3.11868310e-01f, 3.76427993e-02f, 1.35115460e-01f, -1.92340448e-01f, -2.04951271e-01f, 1.51349440e-01f, 5.31549305e-02f,
  -9.52477604e-02f, 2.63363630e-01f, 2.28764594e-01f, 3.89973164e-01f, -1.25880063e-01f, 5.36558032e-02f, 5.16739964e-01f, 2.94077843e-01f, 1.33704141e-01f, -1.10137969e-01f,
  -4.08199318e-02f, 1.91551328e-01f, 2.17474163e-01f, 3.18875685e-02f, 2.61418521e-01f, -2.67684966e-01f, -2.21402291e-02f, 1.14455864e-01f, 2.88557112e-01f, 1.42893851e-01f,
  -2.04848811e-01f, -4.11517680e-01f, 1.07432358e-01f, 4.77242693e-02f, 1.26068160e-01f, 4.14562970e-01f, 2.43561924e-01f, 3.11242566e-02f, -8.29040706e-02f, 5.74443899e-02f,
  -2.38750443e-01f, 4.09497499e-01f, -1.82869565e-02f, -2.21986294e-01f, -4.63650897e-02f, 2.82155931e-01f, 3.54097694e-01f, 2.88875520e-01f, -2.92159200e-01f, -3.14904332e-01f,
  3.51891637e-01f, 2.89442480e-01f, 6.70146123e-02f, 1.89672887e-01f, 1.37165219e-01f, 3.29161704e-01f, -3.65476012e-02f, -2.53971457e-01f, -1.20564602e-01f, 2.03628317e-01f,
  7.97327794e-03f, 1.62248164e-01f, 4.55344766e-02f, 2.45815590e-01f, 1.60515428e-01f, 2.44146079e-01f, -2.39313111e-01f, 2.98578292e-01f, 3.47858310e-01f, -2.77687311e-01f,
  -1.36344030e-01f, -4.41270620e-02f, 1.29417405e-01f, 1.00460432e-01f, -1.58843711e-01f, -1.73260212e-01f, -1.59673750e-01f, 4.06132825e-03f, 2.51128465e-01f, 1.01270929e-01f,
  1.43214157e-02f, 1.22011848e-01f, 5.91795892e-02f, 4.19035479e-02f, 1.50064856e-01f, 1.41448215e-01f, -3.36257629e-02f, 1.62578672e-01f, -2.48299316e-01f, -2.65657812e-01f,
  -6.18633367e-02f, 1.12289853e-01f, 1.70461059e-01f, 1.52447686e-01f, -4.44355905e-02f, 8.69181678e-02f, 3.57817411e-01f, 3.22762638e-01f, 5.59122600e-02f, 2.42786676e-01f,
  4.38946158e-01f, -1.16882417e-02f, -3.79856229e-01f, -1.36408478e-01f, 2.32330516e-01f, 3.18416953e-01f, -7.04499707e-02f, 8.85010287e-02f, 6.77336603e-02f, 2.41061077e-01f,
  2.64810383e-01f, -2.15997510e-02f, 2.19400719e-01f, -5.75389974e-02f, 3.65661532e-01f, -1.50549980e-02f, 3.77676189e-01f, 1.15274452e-01f, 1.60483524e-01f, -1.19411126e-01f,
  1.98517993e-01f, 2.89647251e-01f, -2.52125692e-03f, -1.52939083e-02f, -5.52694872e-02f, 2.72778362e-01f, 1.31318003e-01f, 4.13381279e-01f, -7.83259347e-02f, 6.52494356e-02f,
  1.79443449e-01f, -1.67414472e-02f, -2.73846567e-01f, 4.03875470e-01f, 1.05903670e-01f, 5.02954245e-01f, -9.09345448e-02f, -2.45925725e-01f, 1.23567291e-01f, -6.24754615e-02f,
  1.07534714e-01f, -1.02794692e-01f, -4.64721546e-02f, 3.47820260e-02f, 1.46719143e-01f, 3.74213047e-02f, -7.00035766e-02f, 2.36814126e-01f, 4.53495281e-03f, 3.43774818e-02f,
  1.54244438e-01f, 1.36318579e-01f, -1.95434406e-01f, -5.76959439e-02f, 4.29043055e-01f, 1.52218506e-01f, -4.17465456e-02f, -2.55998727e-02f, 2.91181505e-01f, 9.26416516e-02f,
  -1.80748850e-02f, 1.61212206e-01f, -4.82582510e-01f, -1.42625287e-01f, 1.44982129e-01f, -1.99845973e-02f, 3.33369225e-01f, -8.40201601e-02f, 2.70794570e-01f, -1.23110063e-01f,
  -1.67266205e-01f, 3.67773414e-01f, -1.97659299e-01f, 1.60648182e-01f, -3.31964120e-02f, -7.14004859e-02f, 3.93114895e-01f, 5.67746818e-01f, -1.09238131e-02f, -5.57442708e-03f,
  3.37051749e-01f, 9.23419297e-02f, 1.17557973e-01f, -2.41153881e-01f, 1.51475996e-01f, 2.18303084e-01f, 9.76657718e-02f, -1.01152491e-02f, 1.62109826e-02f, 2.45717183e-01f,
  -1.06186643e-01f, 2.29533568e-01f, -1.70031656e-02f, -3.41338553e-02f, 4.51214015e-01f, 2.78392043e-02f, -2.77752876e-01f, 2.63606012e-01f, 2.02237129e-01f, 4.42145020e-01f,
  -2.40731388e-01f, 8.14366117e-02f, 1.21453032e-01f, -1.09497048e-01f, 2.29074851e-01f, 2.91583002e-01f, 7.63838217e-02f, 7.67395198e-02f, 2.56302450e-02f, 4.37344983e-02f,
  9.02126506e-02f, 6.66090995e-02f, 2.40983397e-01f, -2.80666049e-03f, 1.68545544e-01f, -5.73895276e-02f, -1.68490484e-01f, -5.72671331e-02f, 4.22565676e-02f, 2.50388652e-01f,
  1.38937920e-01f, 2.47398615e-01f, -4.04204071e-01f, 3.12135164e-02f, -1.75651148e-01f, 3.97189736e-01f, 4.32345301e-01f, 2.50589877e-01f, 4.03292984e-01f, 1.43518075e-01f,
  7.56890848e-02f, 1.70815811e-01f, 2.46068463e-01f, -2.43200079e-01f, 2.80689240e-01f, 2.19923660e-01f, 4.13930416e-01f, -2.52947927e-01f, 2.34399885e-01f, 8.53046924e-02f,
  1.53410837e-01f, 1.56142302e-02f, 9.47071910e-02f, 2.80981302e-01f, 1.09459246e-02f, 1.76260486e-01f, 3.59301567e-02f, 2.65052319e-01f, -1.90396786e-01f, -2.92401880e-01f,
  1.69986174e-01f, 3.98860633e-01f, -2.11222414e-02f, 1.08294591e-01f, 1.99356809e-01f, 2.27350611e-02f, 2.39074409e-01f, 1.78856805e-01f, -5.09015679e-01f, 1.60061851e-01f,
  5.36624551e-01f, -1.47541150e-01f, 3.88137437e-02f, -1.55104905e-01f, 2.05967829e-01f, 9.18014050e-02f, -3.54963690e-01f, 1.90652549e-01f, -3.07746202e-01f, 1.57821909e-01f,
  3.10420305e-01f, 1.18321985e-01f, 3.88083220e-01f, 3.60749006e-01f, 2.30507463e-01f, 1.82608262e-01f, 1.05668284e-01f, 5.43548316e-02f, 1.54225633e-01f, 1.42939955e-01f,
  4.13310736e-01f, 1.54481873e-01f, -1.19840309e-01f, 7.06666782e-02f, 3.23605508e-01f, 9.47303623e-02f, -4.42974478e-01f, -2.35695079e-01f, -2.11926475e-01f, 1.56979442e-01f,
  3.26079279e-01f, 4.79872614e-01f, 2.32176080e-01f, 9.98409688e-02f, 3.14589255e-02f, 4.53011692e-01f, -1.77539319e-01f, -1.20293526e-02f, 2.47492597e-01f, -1.50993034e-01f,
  3.47205773e-02f, -2.37727966e-02f, 1.77942187e-01f, 1.20716222e-01f, -2.59845078e-01f, -2.33812496e-01f, 2.23783627e-01f, 3.86478245e-01f, 2.50970542e-01f, 1.42681628e-01f,
  2.05798209e-01f, -2.13284180e-01f, 2.70547897e-01f, 2.04473674e-01f, 1.49166971e-01f, 8.99954736e-02f, 1.72836095e-01f, 1.84650555e-01f, 4.79756206e-01f, 5.69141582e-02f,
  4.48088460e-02f, -1.93017989e-01f, 4.84052077e-02f, 6.69370145e-02f, -1.20893642e-01f, 3.20691794e-01f, 3.84251833e-01f, 4.77173597e-01f, -2.92245805e-01f, 9.33694094e-02f,
  -8.04542303e-02f, -1.80719361e-01f, -1.52815655e-01f, 4.70492572e-01f, 1.02066256e-01f, 4.15681154e-01f, -3.62494141e-02f, 1.46786928e-01f, -2.90888883e-02f, 3.78167272e-01f,
  -1.57052711e-01f, -1.61572173e-02f, 8.48323852e-02f, 3.83554608e-01f, 4.46189791e-01f, 1.01834342e-01f, -1.04453526e-01f, -7.47254491e-02f, 3.97313625e-01f, -1.82758689e-01f,
  6.70181364e-02f, -2.36016259e-01f, -2.01282963e-01f, 5.28558604e-02f, -8.03939551e-02f, 5.31164110e-01f, 3.48642886e-01f, -8.69788677e-02f, 6.17115274e-02f, 2.22571298e-01f,
  -5.51778674e-02f, 3.88789713e-01f, -9.95748560e-04f, -4.99267764e-02f, -1.67972445e-01f, -8.15792009e-02f, 4.28376824e-01f, -2.12156758e-01f, -2.29477525e-01f, -1.35903075e-01f,
  2.07409799e-01f, -7.25447983e-02f, 5.50279394e-02f, 8.27673972e-02f, -1.63804293e-02f, -9.35208499e-02f, -4.04675864e-02f, -3.52384672e-02f, 1.23051688e-01f, -8.65282193e-02f,
  2.18932807e-01f, 1.18890703e-01f, -3.70111853e-01f, -3.58498283e-02f, -9.68745053e-02f, 1.99944168e-01f, 5.40846050e-01f, 2.68763393e-01f, -9.31492895e-02f, 5.63295186e-02f,
  1.04648042e-02f, -3.13281603e-02f, -5.05038276e-02f, 2.59387285e-01f, 3.27758938e-01f, -5.57077602e-02f, 3.05577904e-01f, 1.46400323e-02f, 1.98757425e-01f, 5.46805896e-02f,
  -6.07543886e-02f, -2.21835166e-01f, 1.44385293e-01f, -2.84614205e-01f, 1.25509933e-01f, 1.49671301e-01f, 2.05690768e-02f, -3.75012308e-02f, -3.26438069e-01f, -2.11003274e-01f,
  1.70977578e-01f, 2.74084628e-01f, -1.58207610e-01f, 3.18042904e-01f, -2.90831327e-01f, 8.89139995e-02f, 3.11411738e-01f, 3.36757183e-01f, 2.99789071e-01f, -1.66379005e-01f,
  2.35812679e-01f, -1.69895172e-01f, -9.29549783e-02f, -1.67833388e-01f, 2.29543179e-01f, 9.31599513e-02f, 2.59472072e-01f, 2.26550892e-01f, 2.89298981e-01f, 2.04295814e-01f,
  6.72625825e-02f, 1.44309849e-01f, 3.69571507e-01f, 7.24280700e-02f, 2.67194331e-01f, 3.71279344e-02f, 1.22196764e-01f, 9.94734019e-02f, -1.00554805e-02f, -3.48276794e-02f,
  -2.55965292e-01f, -7.93193877e-02f, -1.94874778e-01f, -2.95840912e-02f, -2.06294075e-01f, 4.32682574e-01f, -1.67477369e-01f, 3.00541192e-01f, 4.38044071e-01f, 6.90113455e-02f,
  5.31825602e-01f, -2.05391943e-01f, -2.99720973e-01f, -1.52608380e-01f, -1.34998918e-01f, -7.95111656e-02f, 8.84298533e-02f, 2.26817712e-01f, 6.29319400e-02f, -1.10609822e-01f,
  5.22992969e-01f, 3.37197244e-01f, -1.15076609e-01f, -1.75958171e-01f, 2.06020668e-01f, 8.78375918e-02f, 1.82885215e-01f, -1.91640645e-01f, 2.39312500e-01f, 1.60474870e-02f,
  -7.31660426e-02f, 3.64574715e-02f, -3.50148380e-01f, -8.64969417e-02f, -4.94278893e-02f, -9.39985663e-02f, -3.23049054e-02f, -1.25258282e-01f, -2.08319165e-03f, 1.76057637e-01f,
  4.24295604e-01f, 3.64861131e-01f, 2.60895818e-01f, -1.49218747e-02f, 1.66347101e-01f, 6.26295879e-02f, -3.93635839e-01f, -1.67537063e-01f, 4.62612838e-01f, 1.93744957e-01f,
  7.97491893e-02f, 1.39347211e-01f, 2.72055358e-01f, 7.64973536e-02f, -1.51474312e-01f, -1.82821557e-01f, 2.55900711e-01f, -2.96099000e-02f, 2.02336594e-01f, -1.42001912e-01f,
  1.04197077e-01f, -1.14392571e-01f, 2.09732488e-01f, -7.96066225e-02f, -1.80471256e-01f, -2.02884853e-01f, 3.39698464e-01f, 1.76325664e-01f, 2.94674039e-01f, -2.11824421e-02f,
  -2.78021783e-01f, -3.08697253e-01f, -1.78022340e-01f, 2.58045375e-01f, 1.58066750e-01f, 1.52409822e-01f, 4.81182933e-01f, -6.70956522e-02f, 3.35626930e-01f, -1.86713710e-01f,
  3.78638715e-01f, -1.83590334e-02f, 1.34257212e-01f, 1.32844999e-01f, 5.29846512e-02f, -5.19328676e-02f, 2.71365523e-01f, 1.84708863e-01f, -1.00393660e-01f, -4.53632930e-03f,
  2.10860401e-01f, 2.06132904e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 26)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 26;
const float L1_fan_Bp_bar_data[] = {
  1.89133450e-01f, 2.21735165e-02f, 5.54999299e-02f, 1.97251365e-01f, 3.08324218e-01f, 6.93189874e-02f, 8.15547109e-02f, 2.32064724e-01f, 6.19935580e-02f, 2.17825383e-01f,
  7.90001079e-02f, 9.44404453e-02f, 3.96753885e-02f, 3.27349424e-01f, 1.80765539e-01f, 1.48026079e-01f, 3.05233747e-01f, 1.09259449e-01f, 1.37113273e-01f, 2.74251163e-01f,
  2.78837502e-01f, -6.90068007e-02f, 8.04357082e-02f, 6.12715706e-02f, -3.83668467e-02f, -4.50546145e-02f
};

// L2_fan_Wp (Shape: 3 x 32)
const int L2_fan_Wp_rows = 3;
const int L2_fan_Wp_cols = 32;
const float L2_fan_Wp_data[] = {
  -6.52175844e-02f, -8.32869709e-02f, -2.15561688e-01f, 6.94212466e-02f, 1.43704429e-01f, 1.21699892e-01f, 1.01250298e-01f, 1.35757625e-01f, -1.87765017e-01f, -6.49895146e-02f,
  -2.57208776e-02f, -3.09422729e-03f, -8.49859044e-02f, 6.21464774e-02f, -8.63185525e-02f, 1.41381010e-01f, -1.42071083e-01f, -1.36221454e-01f, -1.35246599e-02f, 1.60926767e-02f,
  7.89689869e-02f, -6.39533028e-02f, -6.71223924e-02f, 2.90588359e-04f, -2.74375618e-01f, -2.38083154e-02f, -2.09039580e-02f, -1.20656565e-01f, 1.66878980e-02f, -1.32069498e-01f,
  5.22924624e-02f, 1.62056372e-01f, 2.89753154e-02f, -1.96215376e-01f, -9.40004289e-02f, -7.32818618e-02f, 3.30963522e-01f, -6.79716915e-02f, 5.56293093e-02f, -1.62286282e-01f,
  -1.26011401e-01f, 3.18074703e-01f, -6.92934468e-02f, -1.03581898e-01f, 1.50057049e-02f, 4.86875810e-02f, -1.32268712e-01f, 1.15536533e-01f, -1.09250151e-01f, 1.52220517e-01f,
  9.79859903e-02f, -1.18203573e-01f, -2.44575795e-02f, -1.01727836e-01f, -1.76521495e-01f, 9.68296826e-02f, -1.44131765e-01f, 1.43063113e-01f, 1.57667145e-01f, 7.99700338e-03f,
  -2.22873501e-02f, 8.39826465e-02f, 6.82932362e-02f, -1.20472781e-01f, 7.10913017e-02f, 4.89441073e-03f, -5.24921250e-03f, -6.47229850e-02f, 1.07019588e-01f, -2.72756889e-02f,
  1.95992649e-01f, 1.50000319e-01f, -1.85013950e-01f, 8.84537771e-02f, -1.30708262e-01f, -2.03535601e-01f, 4.66957353e-02f, 2.79115915e-01f, 5.79539463e-02f, 4.87508299e-03f,
  1.26366943e-01f, 1.60492063e-01f, 1.64759029e-02f, 9.92508754e-02f, -1.18607573e-01f, -4.47006188e-02f, 1.00661419e-01f, 5.52959889e-02f, 1.09912094e-03f, 1.99710742e-01f,
  -3.41083072e-02f, 4.75503132e-02f, -7.13361502e-02f, -9.04588774e-02f, 1.78871304e-01f, -1.25697106e-01f
};

// L2_fan_Wp_bar (Shape: 26 x 32)
const int L2_fan_Wp_bar_rows = 26;
const int L2_fan_Wp_bar_cols = 32;
const float L2_fan_Wp_bar_data[] = {
  9.35856551e-02f, 1.90471515e-01f, 1.59065187e-01f, 2.35613827e-02f, -1.99048445e-02f, -1.69526264e-01f, 1.76686328e-02f, -2.24446759e-01f, 2.59044647e-01f, 2.06184909e-01f,
  -1.12923115e-01f, -3.81195188e-01f, -1.36704147e-01f, 3.50234419e-01f, -1.87392145e-01f, 7.22869560e-02f, 5.09196758e-01f, 3.46157461e-01f, 4.59611386e-01f, -3.57612282e-01f,
  -1.45403191e-01f, -1.90027237e-01f, 2.08308831e-01f, 3.76870304e-01f, 1.92368865e-01f, -5.91600016e-02f, 4.07109350e-01f, 1.32553786e-01f, 1.40044764e-01f, -2.52862126e-02f,
  1.67298079e-01f, 4.24481899e-01f, 4.16424304e-01f, 1.08113244e-01f, 1.72605217e-01f, 2.72709727e-01f, 4.04455543e-01f, 4.02195156e-01f, 3.90344471e-01f, 3.08309555e-01f,
  -5.91069907e-02f, 4.16918337e-01f, 1.15186706e-01f, 1.77240849e-01f, -1.04220770e-02f, 3.33635539e-01f, -1.34890348e-01f, -2.38562077e-02f, 1.34951353e-01f, 1.87272087e-01f,
  -1.71788521e-02f, 3.78238261e-01f, 2.93693781e-01f, 3.69178683e-01f, -9.95045453e-02f, 1.11546822e-01f, 2.86774129e-01f, 6.13384724e-01f, 6.62349701e-01f, -5.46415076e-02f,
  -3.10687691e-01f, -3.63543540e-01f, -3.66454989e-01f, -5.56160994e-02f, -4.63760830e-02f, 4.03171331e-01f, 3.29437196e-01f, -3.95747215e-01f, 3.68524075e-01f, -1.01800319e-02f,
  -1.35348246e-01f, -2.99626738e-01f, 4.51393902e-01f, -3.66175845e-02f, 3.23483557e-01f, 2.90321231e-01f, 1.02031961e-01f, -7.93102235e-02f, 1.93111673e-02f, 1.13019578e-01f,
  -6.08514529e-03f, 3.92014235e-01f, 1.61987528e-01f, -4.28048223e-02f, 3.30260783e-01f, -1.92126215e-01f, 3.70011270e-01f, 4.74511176e-01f, -8.04835930e-02f, -2.84259081e-01f,
  2.62866527e-01f, -2.23747611e-01f, 1.84956238e-01f, -3.06104105e-02f, 7.50520453e-02f, 2.08168685e-01f, -3.52857739e-01f, -1.17835306e-01f, -1.85730934e-01f, 2.30454683e-01f,
  -1.69630617e-01f, -6.13570027e-02f, -8.63721222e-02f, 7.27900192e-02f, 1.75697997e-01f, -3.51694405e-01f, -8.54555145e-03f, 2.07135305e-01f, -4.59936827e-01f, -4.58436042e-01f,
  -1.63331106e-01f, 1.19532548e-01f, -3.72800261e-01f, -2.98105329e-01f, -8.88042301e-02f, -2.51052648e-01f, 5.12415111e-01f, -1.54195532e-01f, 3.49274613e-02f, 1.82152718e-01f,
  -2.88744092e-01f, -4.07475531e-02f, -2.50270933e-01f, -1.53176278e-01f, 1.41578615e-01f, -1.83121532e-01f, 1.45535588e-01f, 2.92416334e-01f, 1.17862664e-01f, 6.35661110e-02f,
  8.27519074e-02f, -3.15380432e-02f, 7.82573447e-02f, 8.68550763e-02f, 1.06722347e-01f, -7.75330421e-03f, -6.01087287e-02f, 5.60655259e-03f, -7.07207993e-02f, -6.11587651e-02f,
  -1.42388819e-02f, 9.59263891e-02f, 1.21615948e-02f, -1.20633483e-01f, 6.15416393e-02f, 6.83082938e-02f, 8.63300171e-03f, 4.63081077e-02f, 6.63251802e-02f, 4.61770594e-03f,
  8.56867135e-02f, 5.62235042e-02f, 1.40057325e-01f, 2.70600244e-02f, 2.09508792e-01f, 3.41188014e-02f, -5.93421087e-02f, -1.58323392e-01f, -2.20676810e-02f, 8.26136395e-02f,
  7.81265795e-02f, -2.36784995e-01f, 1.74638722e-02f, -2.90713131e-01f, 6.94343001e-02f, 8.04873034e-02f, 3.95234197e-01f, 1.74103733e-02f, 1.89002529e-02f, -2.41052151e-01f,
  -5.67558706e-01f, -3.19653839e-01f, -8.33191648e-02f, 2.81741887e-01f, 4.18273300e-01f, 4.15548310e-02f, -8.97487327e-02f, 1.48605391e-01f, 2.83391714e-01f, 3.78676914e-02f,
  3.89439404e-01f, -6.88843951e-02f, 3.49382639e-01f, 6.21085949e-02f, 1.10623974e-03f, -3.68091822e-01f, -1.42226279e-01f, 2.28739768e-01f, 1.28802240e-01f, -1.01140998e-01f,
  2.28548095e-01f, 3.83557141e-01f, -7.38388114e-03f, -1.21144697e-01f, 2.26461869e-02f, 2.50408262e-01f, 7.77317360e-02f, 1.91447392e-01f, 1.37033075e-01f, 3.08972806e-01f,
  -6.01508878e-02f, 1.04171159e-02f, 3.66353869e-01f, 3.97232115e-01f, 1.56694266e-03f, -1.11058056e-01f, -1.07573189e-01f, 2.46828254e-02f, -3.16787586e-02f, -1.66829899e-01f,
  -3.19791615e-01f, 2.53085434e-01f, 1.49799839e-01f, 2.71258622e-01f, 1.16716586e-01f, -7.42120892e-02f, -3.76845933e-02f, 3.21356058e-01f, 8.68300870e-02f, 4.58661653e-02f,
  -1.03627421e-01f, -8.00209120e-03f, -3.62880111e-01f, 1.07164569e-01f, -1.22270294e-01f, -1.04187123e-01f, 1.32589033e-02f, -9.38505530e-02f, -4.53320235e-01f, -7.07743764e-02f,
  4.81212623e-02f, 7.64900669e-02f, -1.48137048e-01f, -2.01199174e-01f, -6.22057244e-02f, 5.18534333e-02f, 1.76920786e-01f, 1.18818350e-01f, 2.41736606e-01f, -1.72591761e-01f,
  5.07818237e-02f, -2.29250759e-01f, -1.09542154e-01f, 2.05711365e-01f, -2.99320042e-01f, 3.83026600e-01f, 2.85576850e-01f, -4.04776484e-01f, 2.33477890e-01f, -4.09517810e-02f,
  -1.69218928e-01f, 4.10100341e-01f, 2.17472628e-01f, 4.58171576e-01f, 2.22763449e-01f, 5.65006770e-02f, 3.00033897e-01f, 1.38980180e-01f, -1.88727230e-02f, -3.47853273e-01f,
  3.12828839e-01f, 1.79411843e-01f, 4.00679857e-01f, -3.29009928e-02f, -2.61429161e-01f, 3.79377641e-02f, -4.65039513e-04f, 9.28441212e-02f, 3.88422936e-01f, 3.77453327e-01f,
  5.23946106e-01f, 2.02920288e-01f, -3.77423853e-01f, 2.09092036e-01f, 7.92924315e-02f, 3.95755857e-01f, -1.73417911e-01f, 3.46724167e-02f, 1.44020319e-01f, -2.17368484e-01f,
  -4.58123647e-02f, 4.42688614e-02f, -1.26591951e-01f, 1.41395285e-04f, -6.75251782e-02f, 9.28917453e-02f, 9.88063589e-02f, -2.27985308e-01f, -1.21314377e-01f, 3.34110439e-01f,
  2.79789329e-01f, -9.03679878e-02f, -3.62109691e-02f, -2.39521693e-02f, -2.46755943e-01f, -6.10104799e-02f, 4.00866091e-01f, -2.48230547e-01f, 5.29350877e-01f, 4.26149279e-01f,
  3.90885264e-01f, -3.20950538e-01f, -2.99873799e-02f, 3.13574940e-01f, -2.52236664e-01f, -4.33679931e-02f, -5.31877801e-02f, 3.07243735e-01f, 1.61997408e-01f, 2.53777206e-01f,
  1.05893396e-01f, -2.38090549e-02f, -5.52665852e-02f, 1.24969497e-01f, -4.65603977e-01f, -2.92666376e-01f, 1.29860997e-01f, 1.66532159e-01f, -8.01820680e-03f, -4.51295562e-02f,
  1.15427323e-01f, -4.53574955e-02f, 6.64033443e-02f, -3.70308965e-01f, 3.88504267e-02f, 5.38167283e-02f, 4.15082514e-01f, 2.15665296e-01f, 1.49683446e-01f, -2.83965141e-01f,
  -7.53078833e-02f, 2.07348973e-01f, 1.96960419e-02f, -6.09011315e-02f, 4.62972611e-01f, 3.04618597e-01f, -2.82680780e-01f, 1.86077550e-01f, 1.05448484e-01f, 6.83559328e-02f,
  2.83261120e-01f, -1.49220899e-01f, 4.76650357e-01f, 3.61084968e-01f, -9.85690281e-02f, -2.54767537e-01f, -1.81671634e-01f, 1.54600572e-02f, 3.96680832e-01f, 1.78085193e-02f,
  2.84274131e-01f, 4.14418757e-01f, 7.20503628e-02f, 5.05755730e-02f, 4.81208861e-02f, 5.23541383e-02f, -4.06768411e-01f, 1.10348389e-01f, 1.64278761e-01f, 2.15601489e-01f,
  -6.61733896e-02f, -2.78071433e-01f, 2.79059703e-03f, -1.39254928e-01f, 3.45154285e-01f, 1.34195000e-01f, 2.69163132e-01f, -3.03366035e-01f, -4.33379821e-02f, -2.90490448e-01f,
  -2.36223042e-01f, 3.72585118e-01f, -4.30442721e-01f, 3.63988936e-01f, 3.08417082e-01f, -6.30985439e-01f, 2.78202474e-01f, -8.24861452e-02f, -1.05333723e-01f, 2.96372592e-01f,
  -5.39799370e-02f, 2.20631525e-01f, 9.37081575e-02f, -9.37370677e-03f, 2.17618838e-01f, -7.13625923e-02f, 1.14848115e-01f, 3.71168971e-01f, -2.99139291e-01f, 1.05049029e-01f,
  -6.76296130e-02f, 3.65968198e-01f, -4.96558286e-02f, 1.31410405e-01f, 3.73048186e-01f, 4.06416595e-01f, 3.41572553e-01f, 2.07932726e-01f, -2.11455628e-01f, 8.21806118e-02f,
  5.30682690e-02f, -1.87549770e-01f, -2.97661513e-01f, 4.18527156e-01f, -2.55094230e-01f, 4.94443864e-01f, 1.99050546e-01f, -2.69718111e-01f, 3.03468257e-01f, 5.06862462e-01f,
  -1.99067920e-01f, 1.63860932e-01f, 9.90631618e-03f, 1.73634619e-01f, -2.26415664e-01f, 1.10255145e-01f, -4.34112363e-02f, -4.00558561e-02f, 3.62622850e-02f, 2.28668287e-04f,
  -1.60140768e-01f, -2.50710636e-01f, -1.96975589e-01f, -6.15948439e-03f, 4.03546363e-01f, 9.79769230e-02f, -1.53509341e-03f, -9.88491327e-02f, 1.24652877e-01f, -9.01257768e-02f,
  -7.02436566e-02f, 3.47094864e-01f, 1.49239644e-01f, 7.18555674e-02f, 3.91148061e-01f, -1.93318024e-01f, -2.06983626e-01f, 3.04729622e-02f, 8.52127001e-02f, 1.86650530e-02f,
  -2.33400896e-01f, 7.85646364e-02f, -2.23999828e-01f, 1.19943805e-01f, 4.03388321e-01f, 4.34836209e-01f, 2.71998972e-01f, 8.34925249e-02f, -1.97550595e-01f, -1.01769947e-01f,
  -7.02648535e-02f, -3.40323031e-01f, 1.89231262e-01f, -2.27761850e-01f, 3.01581204e-01f, 2.92815417e-01f, -3.10827401e-02f, -8.32752511e-02f, -1.87353775e-01f, -2.70854738e-02f,
  2.88078755e-01f, 2.02226207e-01f, 5.02295971e-01f, 4.00266886e-01f, -1.97675094e-01f, -9.06087011e-02f, 2.01835364e-01f, 2.66273469e-01f, -6.30679876e-02f, 1.05909660e-01f,
  1.40942425e-01f, -3.06945313e-02f, -6.10577911e-02f, -2.64423966e-01f, -2.25457221e-01f, 1.10202752e-01f, 2.86911756e-01f, 4.43835735e-01f, 2.43070334e-01f, -2.58642584e-01f,
  -2.77048268e-04f, -2.80602864e-04f, -1.68848073e-05f, -1.23947699e-10f, 6.20220056e-11f, -3.08533781e-05f, -1.01374765e-03f, 3.56231819e-12f, -8.40559043e-03f, -3.67829436e-03f,
  -2.39185337e-03f, -8.60124710e-04f, -8.51794466e-05f, -3.31774820e-03f, -1.93305238e-09f, -3.04380315e-03f, -9.39887017e-03f, -5.79636497e-03f, -8.56332202e-03f, -7.41447459e-10f,
  -2.22901945e-04f, -8.16469781e-10f, -1.14547871e-02f, -1.08714094e-02f, -4.91142971e-03f, -4.09970246e-03f, -4.26369457e-04f, -2.02945521e-10f, -8.13756045e-03f, 5.86282412e-11f,
  -5.38401364e-05f, -1.12273050e-02f, 3.03733975e-01f, 3.06689918e-01f, 9.30756778e-02f, 1.13991678e-01f, 2.25387633e-01f, 1.72191247e-01f, -1.12604976e-01f, 8.64860043e-02f,
  2.70779014e-01f, 3.74492675e-01f, 5.57489336e-01f, 2.84507215e-01f, 3.64299059e-01f, 1.74798012e-01f, -5.31820431e-02f, 1.81333870e-01f, 2.29111612e-01f, 4.50212359e-02f,
  -7.23590190e-03f, 4.06492382e-01f, -4.28226404e-02f, 2.55281389e-01f, -3.45971435e-02f, -5.90129755e-02f, 1.13610163e-01f, 5.19888103e-01f, 1.22161932e-01f, -2.17483286e-02f,
  -1.37401327e-01f, -5.11115883e-03f, -3.62530440e-01f, -3.43319803e-01f, -2.00088933e-01f, 2.45743152e-02f, -8.58107954e-02f, 2.77761314e-02f, 3.71830702e-01f, -6.71694428e-03f,
  -2.68065363e-01f, -5.79558052e-02f, 3.27892184e-01f, 3.15252483e-01f, 2.66975194e-01f, 3.25758815e-01f, -1.40658990e-01f, -1.61805272e-01f, -2.73879826e-01f, 4.25518185e-01f,
  1.97835177e-01f, 2.28543326e-01f, 2.84624726e-01f, -1.42170727e-01f, 3.44677538e-01f, -1.21742971e-01f, -6.68400303e-02f, 5.14223814e-01f, -1.84709266e-01f, 2.85298616e-01f,
  -2.22114623e-01f, -1.43848985e-01f, 2.41243243e-01f, 9.04817134e-02f, -1.68810543e-02f, 2.33376727e-01f, -1.18918590e-01f, -2.27187514e-01f, 6.63733259e-02f, -2.31760982e-02f,
  4.89109643e-02f, -3.91511828e-01f, -4.94479649e-02f, 2.92045653e-01f, 2.15436667e-01f, -1.68635976e-03f, -1.18164949e-01f, -1.92857102e-01f, 8.15549269e-02f, 2.03331023e-01f,
  3.02556634e-01f, 3.83067429e-01f, 1.65707439e-01f, 2.68502366e-02f, 3.72592539e-01f, 6.39512949e-03f, -1.38574809e-01f, 2.43617147e-01f, 1.24868490e-01f, -2.95523945e-02f,
  -4.11487743e-02f, -1.79972857e-01f, -2.02434584e-01f, 2.74694353e-01f, 3.62855703e-01f, 5.86044312e-01f, 2.66254574e-01f, 3.08112204e-02f, -1.39325514e-01f, -3.76930773e-01f,
  -4.93209720e-01f, 9.75485444e-02f, 2.37785980e-01f, -1.64920405e-01f, 2.35237241e-01f, 3.52780521e-01f, -1.30143195e-01f, 3.59292865e-01f, -3.01702976e-01f, 9.26269144e-02f,
  -1.12189919e-01f, 2.64644831e-01f, 3.27513129e-01f, 3.14876288e-01f, -1.02894455e-01f, -7.71600902e-02f, 3.39938141e-02f, -5.10261580e-02f, 1.34109661e-01f, 1.53197959e-01f,
  -2.38855287e-01f, 1.47777230e-01f, -3.66281152e-01f, 4.45964001e-02f, -1.57339960e-01f, 3.86787578e-02f, 1.37800723e-01f, 1.16715163e-01f, 3.48948658e-01f, -1.44135386e-01f,
  4.10602719e-01f, 3.41690540e-01f, 3.33527684e-01f, 5.54298833e-02f, -4.51591104e-01f, 2.60394335e-01f, -9.72427726e-02f, -1.37340978e-01f, 1.30075980e-02f, 2.80959960e-02f,
  1.28462061e-01f, -2.11363703e-01f, 2.74301767e-01f, 7.02111423e-02f, -2.27795154e-01f, -4.08741236e-01f, 4.25936848e-01f, 1.51721671e-01f, 1.51070550e-01f, 8.83508325e-02f,
  -3.36051911e-01f, 8.54751766e-02f, 3.59231442e-01f, 1.41676664e-01f, 6.26134515e-01f, 1.21903650e-01f, 3.57811987e-01f, 7.51330703e-02f, 7.00708330e-02f, -3.41934711e-01f,
  -1.83350027e-01f, 3.74628097e-01f, -2.88471073e-01f, -2.62038708e-01f, -1.98070377e-01f, -1.93218812e-02f, -6.68952018e-02f, -1.67011976e-01f, -6.56829216e-03f, 1.01934046e-01f,
  3.15256149e-01f, 5.24222739e-02f, 8.19777399e-02f, 1.50547504e-01f, -1.42857000e-01f, -4.78980280e-02f, 9.36405081e-03f, 2.97230422e-01f, 1.37744993e-02f, 1.05381384e-02f,
  2.10237160e-01f, -8.05581510e-02f, 2.81296164e-01f, -8.87198746e-03f, 1.55895665e-01f, 1.86659992e-01f, -2.06061751e-01f, -2.72121234e-03f, -3.13267678e-01f, 1.21434771e-01f,
  3.10602486e-01f, 2.97344744e-01f, 2.59386241e-01f, 2.34761268e-01f, -1.92530334e-01f, -4.42511022e-01f, -2.40327194e-01f, 1.34517536e-01f, 2.33790129e-01f, -1.56453595e-01f,
  3.33944798e-01f, 3.38636786e-01f, -1.71671808e-01f, 1.43695340e-01f, -1.25164926e-01f, -9.61139202e-02f, -6.87717423e-02f, 2.43295714e-01f, 2.80015588e-01f, 2.42239967e-01f,
  8.39613304e-02f, -4.09692377e-02f, 1.74948052e-01f, -4.03180383e-02f, 1.85674280e-01f, 1.57530874e-01f, -1.23647623e-01f, -6.66014552e-02f, -9.09013078e-02f, 6.01046644e-02f,
  1.86686907e-02f, 2.86727726e-01f, 1.13964476e-01f, 3.58643651e-01f, 1.38954222e-01f, 6.57213554e-02f, 1.81458473e-01f, -1.10652566e-01f, -9.90449265e-02f, 9.32733119e-02f,
  -1.62061289e-01f, 2.65631437e-01f, 2.03521606e-02f, 1.46323815e-01f, 3.84375453e-02f, -3.84357087e-02f, 1.38247892e-01f, 3.16157818e-01f, 1.65722027e-01f, 1.12984918e-01f,
  3.19264829e-02f, 1.71986505e-01f, -8.92246366e-02f, -1.98014826e-01f, -1.29784301e-01f, 4.03750502e-02f, 1.96951479e-01f, -2.63784993e-02f, 2.30240628e-01f, 4.47781384e-02f,
  8.53289105e-03f, 2.39208147e-01f, -2.12811783e-01f, -1.47109970e-01f, 1.68060064e-01f, -3.40031058e-01f, -9.71013457e-02f, 3.06708097e-01f, 6.90673888e-02f, -7.49103278e-02f,
  9.40887555e-02f, 3.24490964e-01f, -1.81417704e-01f, -1.21585868e-01f, 7.20745623e-02f, 2.08107725e-01f, 3.47689241e-02f, -3.99317108e-02f, -3.69275287e-02f, -3.00302416e-01f,
  -3.88589762e-02f, 2.88591474e-01f, -1.84853509e-01f, -1.84074640e-01f, 4.05534863e-01f, -8.49646777e-02f, -9.53360051e-02f, -3.44178602e-02f, -2.54222512e-01f, 1.65882051e-01f,
  2.56104171e-01f, -1.74260497e-01f, 4.06038970e-01f, 1.50408536e-01f, 3.89636576e-01f, 3.48748356e-01f, 6.91623464e-02f, 2.06647798e-01f, -2.20648929e-01f, 2.69285113e-01f,
  -3.36596407e-02f, -9.71936807e-02f, 9.27561820e-02f, -1.84016209e-02f, 5.28536588e-02f, -1.14610955e-01f, 1.95030972e-01f, 9.88419503e-02f, 8.46655667e-02f, 4.15628552e-02f,
  -2.11303398e-01f, -3.05812091e-01f, -1.29544869e-01f, 9.22890529e-02f, 7.42336884e-02f, -2.80629527e-02f, 2.76865035e-01f, 1.64062202e-01f, 3.04436475e-01f, -1.31443128e-01f,
  1.88942570e-02f, 2.86689196e-02f, 1.98961228e-01f, 1.66598246e-01f, 2.43516400e-01f, -1.05656713e-01f, 2.16009006e-01f, 3.64241779e-01f, 1.67585865e-01f, 9.29200426e-02f,
  9.07074288e-02f, 2.28304684e-01f
};

// L2_fan_Bp_bar (Shape: 1 x 26)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 26;
const float L2_fan_Bp_bar_data[] = {
  1.65028512e-01f, 1.82998285e-01f, 8.26640129e-02f, -5.88139854e-02f, 4.49351855e-02f, -7.02672154e-02f, -4.47291471e-02f, -1.05590068e-01f, 1.20120592e-01f, 1.28591761e-01f,
  4.11746837e-02f, 9.72298607e-02f, 1.69986844e-01f, 4.90042530e-02f, -1.24608457e-01f, -2.74244841e-04f, 1.98796526e-01f, 7.63408989e-02f, 2.41637491e-02f, -1.47192432e-02f,
  5.30362837e-02f, -5.67110851e-02f, -5.80989495e-02f, 1.22032858e-01f, -6.86737075e-02f, 4.91380766e-02f
};

// L3_linear_W (Shape: 12 x 32)
const int L3_linear_W_rows = 12;
const int L3_linear_W_cols = 32;
const float L3_linear_W_data[] = {
  1.18460141e-01f, 1.83964789e-01f, -1.87421829e-01f, 1.75417900e-01f, -1.64929613e-01f, -5.57008572e-02f, -9.44039226e-02f, -5.11128128e-01f, -3.67733687e-01f, -7.66275898e-02f,
  -1.57815710e-01f, 2.56576955e-01f, -5.52053690e-01f, 2.35663638e-01f, 2.47830406e-01f, -1.72729954e-01f, 2.56196082e-01f, 1.36149362e-01f, -1.99927360e-01f, 2.07635798e-02f,
  3.85479420e-01f, -1.99707845e-13f, -5.05500197e-01f, -5.65071523e-01f, 9.22655687e-02f, 2.00831026e-01f, -2.18762040e-01f, -5.62045313e-02f, 1.06404483e-01f, -1.26077205e-01f,
  -2.05169305e-01f, -8.99481401e-03f, -1.28853485e-01f, 1.39141688e-02f, -3.68191689e-01f, -5.41180596e-02f, -2.48239547e-01f, 8.51323977e-02f, -2.14550626e-02f, -1.05887083e-02f,
  -6.08973861e-01f, 3.90052982e-02f, 1.30095795e-01f, 3.21947008e-01f, -6.31447807e-02f, 1.91355288e-01f, -1.04855262e-01f, -6.41669631e-01f, -1.30674616e-01f, 1.37236953e-01f,
  1.06728248e-01f, -2.93556005e-01f, -7.27798343e-02f, 1.66940697e-11f, -2.20440790e-01f, -2.68396139e-01f, 7.84438923e-02f, 9.30625107e-03f, 2.26554111e-01f, -2.02335179e-01f,
  1.89061388e-01f, -8.80300440e-03f, 3.40672612e-01f, 1.93768442e-01f, 1.16002530e-01f, -7.58364201e-02f, 4.16534357e-02f, -3.05250734e-01f, 2.23187938e-01f, 6.69330582e-02f,
  3.39587867e-01f, 4.13686544e-01f, 3.37843522e-02f, -6.18117042e-07f, 1.52702957e-01f, -4.61619079e-01f, -3.23265567e-02f, -4.62131172e-01f, -3.94742519e-01f, -3.89561415e-01f,
  -5.79063773e-01f, -2.35358223e-01f, -1.38733983e-01f, -2.52365708e-01f, -6.04968071e-01f, 4.16802391e-11f, 1.03908762e-01f, -1.46834224e-01f, -1.19165197e-01f, -3.20490330e-01f,
  1.72902599e-01f, -5.47063172e-01f, 1.99883170e-02f, -5.75417042e-01f, 3.02068472e-01f, 2.53552914e-01f, -1.71783626e-01f, -1.57461926e-01f, -4.74983566e-02f, -1.44706845e-01f,
  -1.70523245e-02f, -3.07706803e-01f, -6.25776500e-02f, -8.81053329e-01f, 2.83687592e-01f, 7.60199666e-01f, -1.13444701e-01f, 1.83749706e-01f, -5.34601450e-01f, -3.37954730e-01f,
  -3.67830843e-01f, 1.10524334e-01f, 1.54918924e-01f, -1.52884439e-01f, -5.64943969e-01f, 4.98728678e-02f, 1.14701137e-01f, -2.79089642e-12f, -5.69395840e-01f, 1.75291359e-01f,
  4.72431816e-02f, -2.30211336e-02f, -4.59845126e-01f, 2.52648890e-01f, -1.27696201e-01f, 7.97986314e-02f, -4.78526473e-01f, -2.48088464e-02f, 8.20587650e-02f, 1.89899489e-01f,
  -8.29441696e-02f, 2.12043598e-01f, -1.43720672e-01f, 9.22638401e-02f, -2.99840271e-01f, 7.49211339e-03f, 3.07691753e-01f, -6.20307326e-01f, 4.24567610e-02f, -4.41308366e-03f,
  -1.46119535e-01f, -3.10111970e-01f, 3.05315435e-01f, 2.83931762e-01f, 1.81659654e-01f, -4.98051882e-01f, -2.03378752e-01f, -1.82801127e-01f, 2.87802428e-01f, 1.25777930e-10f,
  1.62087590e-01f, 1.91976339e-01f, 6.79219067e-02f, 8.97881761e-02f, -4.04150665e-01f, -7.08043426e-02f, 1.94489993e-02f, -5.03530838e-02f, -6.05857193e-01f, -9.26713124e-02f,
  1.06044993e-01f, -2.40446851e-01f, 3.85028869e-02f, 2.60602729e-03f, 5.50349839e-02f, -2.61093155e-02f, -4.31650668e-01f, -3.14498454e-01f, -1.08235851e-01f, -1.73399728e-02f,
  -2.26771504e-01f, -5.42351425e-01f, 1.78002030e-01f, 2.44145498e-01f, -1.52974473e-02f, 2.63900697e-01f, -1.15504466e-01f, 2.00134665e-01f, 2.93987393e-01f, 1.02281682e-01f,
  2.08927557e-01f, 9.04034039e-08f, 1.89787164e-01f, -1.31418779e-01f, 2.02772856e-01f, -2.66997278e-01f, -9.14720595e-02f, -7.54016638e-02f, -3.89274433e-02f, -5.39653599e-02f,
  -1.19351745e-02f, -9.33023691e-02f, 2.02665970e-01f, 1.47438556e-01f, 8.52647573e-02f, -3.15258175e-01f, -3.65875453e-01f, 1.25242606e-01f, -3.47971201e-01f, 2.82473147e-01f,
  -2.43947670e-01f, -1.16949464e-04f, 9.08660814e-02f, -1.24061257e-01f, 9.81351957e-02f, -6.76597818e-04f, 1.08354166e-01f, 2.00858027e-01f, -5.96039832e-01f, 2.17771560e-01f,
  3.04593414e-01f, -6.35986149e-01f, -4.11793858e-01f, 1.34684111e-10f, 2.93817163e-01f, -2.72722483e-01f, -7.16714323e-01f, -5.19731045e-01f, 4.11166698e-01f, -7.32164800e-01f,
  -6.03770733e-01f, 1.01195231e-01f, -3.78944427e-02f, -4.18665707e-01f, -1.11866489e-01f, -1.26960382e-01f, -1.78206339e-01f, -7.37086870e-03f, 3.53481248e-02f, -3.30690414e-01f,
  -4.25760239e-01f, 8.36908966e-02f, -1.64204594e-02f, 6.41230881e-01f, -4.41985726e-02f, -7.64706656e-02f, 3.45018119e-01f, -1.88355729e-01f, -4.59559441e-01f, 2.32005209e-01f,
  2.32196912e-01f, -3.53966564e-01f, 1.49689149e-02f, -2.41692200e-01f, -3.51937443e-01f, -1.17813192e-12f, -2.53210604e-01f, 2.17130482e-01f, -3.93794239e-01f, 6.58197701e-03f,
  -3.06538969e-01f, 2.33153835e-01f, -9.92073491e-03f, 3.42409253e-01f, -7.99278989e-02f, -2.46663958e-01f, 1.48549989e-01f, -5.99839278e-02f, 1.76210329e-02f, -2.00542063e-01f,
  2.83586383e-01f, 1.08844444e-01f, 1.87482327e-01f, -1.92591161e-01f, -3.18642139e-01f, -1.30896077e-01f, -4.76300381e-02f, -4.33571309e-01f, -2.69311607e-01f, -7.41143897e-02f,
  -5.27571559e-01f, -2.03672558e-01f, -4.62967068e-01f, -3.73347759e-01f, -7.74424076e-02f, 3.41433644e-01f, -6.10610172e-02f, 7.33828959e-14f, -8.55104160e-03f, 3.53842676e-01f,
  2.98262775e-01f, 3.53763252e-01f, -1.53144270e-01f, 2.26048231e-01f, 2.25433677e-01f, -3.16391259e-01f, 4.23966534e-02f, 9.96236876e-02f, -1.13844000e-01f, 3.60353105e-03f,
  -2.27127552e-01f, 3.35264266e-01f, 3.71165067e-01f, 1.34316012e-01f, -3.35072905e-01f, 3.67421418e-01f, -5.75809419e-01f, -2.03921795e-01f, -7.68928453e-02f, -4.25805420e-01f,
  2.08543643e-01f, -5.37974954e-01f, 2.46656790e-01f, -2.07770184e-01f, -2.80814707e-01f, -2.59258509e-01f, 2.04427257e-01f, -3.89232188e-01f, 1.21551920e-02f, -2.88318523e-12f,
  2.41447926e-01f, 6.66308627e-02f, -3.73832971e-01f, 3.99897635e-01f, -4.95119095e-01f, -2.62607336e-01f, 1.12489924e-01f, 2.33348235e-01f, -3.55875522e-01f, -4.45512563e-01f,
  1.91305786e-01f, 1.27797380e-01f, -3.81201580e-02f, 1.69532806e-01f, 2.73503751e-01f, 8.51960108e-02f, 3.33448619e-01f, -3.02456856e-01f, 2.85327971e-01f, -4.30545539e-01f,
  1.42811373e-01f, 3.24044019e-01f, -2.76787013e-01f, -1.09728694e-01f, -1.69251990e-02f, -2.94158280e-01f, 1.22104220e-01f, -1.30513579e-01f, -5.18059254e-01f, 1.05715573e-01f,
  -1.93589896e-01f, 6.23953067e-09f, -3.78868550e-01f, 1.39629945e-01f, 6.50497759e-03f, -3.26803327e-01f, 3.55007768e-01f, 2.20145956e-02f, -1.43885210e-01f, -9.37196463e-02f,
  -1.02182820e-01f, 2.04273954e-01f, 1.56720787e-01f, -2.45263381e-03f, 1.24832787e-01f, -1.45850047e-01f, -1.20298207e-01f, -1.55477419e-01f, 1.94430023e-01f, -2.17518359e-01f,
  1.41467154e-01f, -1.76547185e-01f, -6.09667525e-02f, -3.65693480e-01f, -1.88553855e-01f, -4.07571763e-01f, -3.31238538e-01f, 2.52415657e-01f, -1.33933192e-02f, -4.48051780e-01f,
  1.60952672e-01f, 1.27709568e-01f, -4.21569854e-01f, -5.32522915e-09f, 2.86373943e-01f, 2.74911404e-01f, -1.72389567e-01f, -4.86070037e-01f, 3.36494684e-01f, 2.80360063e-03f,
  -4.69285011e-01f, 2.59811282e-01f, -8.09702575e-02f, -5.29360920e-02f
};

// L3_linear_B (Shape: 1 x 12)
const int L3_linear_B_rows = 1;
const int L3_linear_B_cols = 12;
const float L3_linear_B_data[] = {
  -1.63131222e-01f, 3.83052975e-02f, 6.23529851e-02f, 6.27684873e-03f, 1.21479914e-01f, -1.44279718e-01f, 1.31553918e-01f, 2.47848649e-02f, -9.33547765e-02f, -1.96938757e-02f,
  1.23770302e-02f, -8.36422667e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 3, 26
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        32, 3, 26
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        32, 3, 26
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_linear
    linear_forward_pgm(
        buffer1, x_out,
        L3_linear_W_data, L3_linear_B_data,
        32, 12
    );
    }
    