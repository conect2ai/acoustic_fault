/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 64 (x1)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 64;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    float x3 = x * x * x;
    return 0.5f * x * (1.0f + tanhf(0.79788456f * (x + 0.044715f * x3)));
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 25 x 120)
const int L0_fan_Wp_rows = 25;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  4.67773348e-01f, 3.42485189e-01f, 1.04190871e-01f, 1.50721624e-01f, 5.32916449e-02f, 1.03121564e-01f, 1.94886737e-02f, 3.24945688e-01f, 1.20605506e-01f, -2.82667428e-02f,
  -1.37577176e-01f, 2.78463244e-01f, -1.30553439e-01f, 3.51449847e-02f, -3.70109677e-01f, -2.88104236e-01f, -8.78979824e-03f, 5.13214730e-02f, 1.03529148e-01f, 2.29827374e-01f,
  1.01111978e-02f, -7.03212321e-02f, -2.43460417e-01f, 1.43232420e-01f, 2.18201414e-01f, 1.79796264e-01f, -1.29060388e-01f, -1.18650571e-02f, 1.33264825e-01f, -5.94867803e-02f,
  6.88695684e-02f, 1.52824163e-01f, -3.82059924e-02f, -4.00739610e-02f, 1.66863445e-02f, 3.33424844e-02f, 6.24718033e-02f, -9.77882445e-02f, -3.72960456e-02f, 1.09289207e-01f,
  -2.24658921e-02f, 2.17407588e-02f, -1.81587432e-02f, -1.48482397e-02f, 5.66682480e-02f, 9.03611444e-03f, 5.28677516e-02f, -2.22040452e-02f, 3.12304199e-02f, -9.70837995e-02f,
  1.02940481e-03f, 2.44859643e-02f, -1.36819780e-02f, -3.55193280e-02f, -4.54951860e-02f, 1.88481733e-02f, -2.60713194e-02f, 1.60258147e-03f, -4.11771461e-02f, 1.33844331e-01f,
  -2.72430796e-02f, 4.94488440e-02f, -9.14089903e-02f, -4.84227352e-02f, -1.02435425e-03f, -5.94743080e-02f, -1.16030209e-01f, -2.13386435e-02f, -2.64492147e-02f, 5.98626770e-02f,
  1.03292249e-01f, 6.22899942e-02f, 3.28991860e-02f, 3.47649530e-02f, -3.15518230e-02f, 3.06283198e-02f, -3.20574753e-02f, 6.18088171e-02f, -6.97488105e-03f, 1.88393630e-02f,
  8.53329077e-02f, -3.27668898e-02f, 7.47698694e-02f, -5.17159514e-02f, -4.07758541e-02f, -1.68484449e-02f, 1.49204331e-02f, 2.74784416e-02f, -6.14591949e-02f, -4.15461510e-02f,
  1.51838362e-01f, 2.64193594e-01f, 1.49694213e-03f, 1.17231533e-01f, -8.23835060e-02f, -5.73719330e-02f, -5.19542880e-02f, 3.92891914e-02f, 7.04375431e-02f, 4.91352417e-02f,
  -4.64743748e-03f, -5.84804565e-02f, 1.85250238e-01f, -1.27870552e-02f, 8.25611688e-03f, 6.88006030e-03f, -1.64422933e-02f, 6.33195564e-02f, 3.91069800e-02f, 1.33652002e-01f,
  -2.63971593e-02f, -3.55778821e-02f, -1.06749482e-01f, 4.34808880e-02f, -5.79379462e-02f, 1.74529012e-02f, 8.75152722e-02f, -2.47933641e-02f, -3.27131525e-02f, -3.58683541e-02f,
  -1.08058691e-01f, -4.64932263e-01f, -5.12715578e-01f, 5.85634038e-02f, 2.91593522e-01f, 1.07066393e-01f, 4.26597819e-02f, -1.83292180e-02f, -2.80992895e-01f, -1.69759750e-01f,
  1.45521581e-01f, -3.36414129e-01f, -9.78587493e-02f, 2.12248936e-01f, 1.66097224e-01f, -1.77344039e-01f, 2.34281287e-01f, 3.79873998e-02f, 5.37171662e-02f, 1.99259996e-01f,
  1.19147338e-01f, 4.08375651e-01f, 6.19315617e-02f, 3.12750220e-01f, 1.81847081e-01f, -2.11704016e-01f, 1.69279650e-01f, -5.26084676e-02f, 2.16971025e-01f, -2.77580116e-02f,
  8.46415535e-02f, -9.47582871e-02f, -1.92260444e-02f, -1.13219760e-01f, 4.24080938e-02f, -1.27450898e-02f, 5.08097000e-02f, -6.15621684e-03f, 5.91657311e-02f, -5.81911132e-02f,
  -2.72189267e-02f, -4.44627041e-03f, -3.49587016e-02f, -2.71151587e-02f, 5.57480082e-02f, -5.23820519e-02f, 2.12318031e-03f, 8.51526484e-02f, -3.62943560e-02f, -4.46076728e-02f,
  -6.83438554e-02f, 4.73583024e-03f, 6.46046624e-02f, -4.39706035e-02f, -8.97984579e-02f, -1.65294707e-02f, -1.46180511e-01f, -5.58687113e-02f, 5.80488890e-02f, -5.48576713e-02f,
  5.23485765e-02f, 3.26739810e-02f, -1.15678385e-02f, 5.25027663e-02f, 2.35816948e-02f, -5.32336347e-02f, 8.90809149e-02f, -1.78639404e-02f, 2.06115982e-03f, -3.50638106e-02f,
  3.40275578e-02f, -8.15324634e-02f, 8.29689577e-02f, -4.18783389e-02f, 7.50015900e-02f, -5.07436395e-02f, 6.72890618e-02f, -4.94155325e-02f, -7.54673174e-03f, 1.01587251e-01f,
  2.99256388e-02f, 8.64863843e-02f, 2.53139734e-02f, 5.46016544e-02f, -3.89044806e-02f, -7.27242827e-02f, 2.13657822e-02f, -1.08547963e-01f, 7.67169297e-02f, 6.15659133e-02f,
  -5.28426608e-03f, -2.05314625e-02f, -7.66479522e-02f, 8.59942734e-02f, -2.04748474e-02f, 1.45061705e-02f, 3.96905057e-02f, 2.59575038e-03f, -4.94486801e-02f, 7.23692477e-02f,
  3.21437576e-04f, -4.70415056e-02f, 4.69009690e-02f, 9.19940621e-02f, 3.42005901e-02f, -6.28346354e-02f, 4.56420220e-02f, -4.70249429e-02f, 1.12064883e-01f, 1.32249603e-02f,
  2.47511715e-02f, -8.28037038e-03f, -8.15236941e-02f, 1.11724697e-01f, 1.03899308e-01f, 3.92840989e-03f, 1.24580331e-01f, -1.23184547e-01f, 6.73236400e-02f, -6.38110787e-02f,
  -6.40507340e-01f, 4.35891837e-01f, -8.68887529e-02f, -3.97167802e-01f, -1.29777446e-01f, 5.21296203e-01f, 2.86071092e-01f, 1.87235743e-01f, -2.14910865e-01f, 4.36380357e-01f,
  4.74571809e-03f, -7.47813955e-02f, 2.65015066e-01f, 7.76765570e-02f, -4.13966119e-01f, 1.07869245e-01f, 1.49266079e-01f, 1.53954521e-01f, 2.78864689e-02f, 1.28644183e-01f,
  -2.01277167e-01f, -9.78497863e-02f, -2.44855564e-02f, 3.08146805e-01f, -1.16770146e-02f, -3.27411853e-02f, 3.22646163e-02f, -3.66334133e-02f, -9.46492553e-02f, 3.45760658e-02f,
  -7.31425360e-03f, 6.13765568e-02f, -9.42765400e-02f, 2.65231989e-02f, 2.72169784e-02f, 7.99001455e-02f, 6.99264405e-04f, -8.46685842e-02f, -1.00373857e-01f, 4.24991287e-02f,
  -8.98321718e-03f, -2.13990062e-02f, 3.75164412e-02f, -1.01778992e-01f, -6.24931045e-02f, 6.15575053e-02f, -8.20168331e-02f, 9.28077381e-03f, -1.37761962e-02f, 1.06207967e-01f,
  -3.70465256e-02f, -5.61595485e-02f, -1.75639521e-02f, 7.40597695e-02f, -3.65533121e-03f, 3.75482626e-02f, 4.52184193e-02f, -2.70214528e-02f, 4.54474390e-02f, -8.56614113e-03f,
  6.07131422e-02f, -2.99312770e-02f, 1.41991507e-02f, -4.00975719e-02f, -3.78324129e-02f, -1.11666627e-01f, -2.08133906e-02f, 5.93215190e-02f, -8.74153897e-03f, 7.96388835e-02f,
  -9.83801931e-02f, -3.53155807e-02f, -2.68056076e-02f, -9.97315720e-02f, -1.45874641e-04f, 3.39507498e-02f, -3.77528630e-02f, 4.00374904e-02f, -1.47350654e-02f, -2.84911972e-02f,
  1.18150730e-02f, -5.11541553e-02f, 2.28382032e-02f, 8.70496035e-02f, 1.38917014e-01f, -6.53075054e-02f, 6.02845615e-03f, -1.42107606e-02f, 4.28135060e-02f, 1.53662753e-03f,
  2.99704909e-01f, 2.84451395e-01f, 8.29912126e-02f, 5.89898415e-02f, 6.44744858e-02f, 3.79290245e-02f, -3.40381116e-02f, 4.12033685e-03f, 7.88104534e-02f, -2.03652363e-02f,
  6.74390644e-02f, 4.06900682e-02f, -5.42090461e-02f, 2.25434154e-02f, -4.73975316e-02f, -5.46676526e-03f, 4.27414961e-02f, -8.96854848e-02f, 2.96937749e-02f, 1.05519183e-01f,
  -3.89583409e-02f, -1.14131637e-03f, -8.06991570e-03f, 9.07800794e-02f, 8.63454565e-02f, 5.83709292e-02f, -3.05007268e-02f, 2.26492155e-02f, 2.03721318e-02f, -3.55811976e-02f,
  5.03389239e-01f, -2.38316879e-01f, 2.06119508e-01f, -1.52062550e-01f, 3.17001909e-01f, 1.77373402e-02f, 3.85654643e-02f, 1.88011061e-02f, 3.49788629e-02f, -1.54359296e-01f,
  -1.20070577e-01f, 2.50258356e-01f, -1.92156136e-01f, -3.20933759e-01f, -2.76590586e-01f, -2.39486217e-01f, -2.76769787e-01f, -3.97288054e-02f, -1.44400876e-02f, 6.80836216e-02f,
  3.56591605e-02f, -2.87111938e-01f, -1.24498829e-01f, -5.02378792e-02f, 2.86267251e-01f, 1.45755932e-01f, -1.62803039e-01f, 9.91521683e-03f, -1.45424223e-02f, 5.40313870e-02f,
  -3.47056389e-02f, 1.59156799e-01f, 8.05855691e-02f, 4.78319414e-02f, 3.55304927e-02f, -1.68117136e-02f, 3.71760353e-02f, 6.12079864e-03f, 4.76607047e-02f, 8.57720077e-02f,
  7.03617036e-02f, 2.49909982e-02f, 1.55275539e-02f, -8.05125386e-02f, 5.37184589e-02f, 6.34786859e-02f, 4.47449759e-02f, 2.33437605e-02f, 1.07262567e-01f, 1.24782808e-01f,
  2.03389656e-02f, 1.04250550e-01f, 8.08617398e-02f, 9.70690101e-02f, 6.39896393e-02f, 5.93849570e-02f, 7.97795132e-02f, 3.76121476e-02f, 1.56659205e-02f, 1.79902427e-02f,
  -1.47156632e-02f, 1.85535755e-04f, 7.22806901e-02f, 4.87764739e-02f, -4.82253507e-02f, 8.73258486e-02f, -6.39575124e-02f, 7.20047131e-02f, 9.26516131e-02f, -2.42758915e-02f,
  5.39325885e-02f, 4.71442528e-02f, 9.03325379e-02f, -1.99517957e-03f, -3.87431458e-02f, -2.17677280e-02f, 5.37393615e-02f, 8.16317201e-02f, -7.58831799e-02f, -7.02110492e-03f,
  -3.99676934e-02f, -7.01871375e-03f, -7.94118494e-02f, 1.32800549e-01f, -4.59136814e-02f, -1.42806217e-01f, 1.91485770e-02f, 2.95216888e-02f, -1.37951085e-02f, -8.77633691e-03f,
  -3.43234032e-01f, -3.92960638e-01f, -1.28625572e-01f, 2.16210522e-02f, -5.38923666e-02f, -4.17546555e-02f, -6.83117136e-02f, 6.35613352e-02f, -1.69317454e-01f, -1.70047153e-02f,
  2.82996818e-02f, 7.37527907e-02f, 1.08892657e-02f, -2.34102514e-02f, -1.71704739e-01f, -5.65681159e-02f, 9.01157688e-03f, -4.73562926e-02f, -7.32536316e-02f, 3.58338282e-02f,
  -3.03341411e-02f, 1.98123399e-02f, 9.49343741e-02f, 2.49579474e-02f, 5.16262390e-02f, 4.11987789e-02f, -9.06998059e-04f, -6.15828531e-03f, 5.79656363e-02f, -2.27329973e-02f,
  1.00534312e-01f, -2.12694719e-01f, 2.81606376e-01f, -8.91297497e-03f, 3.08669925e-01f, 2.44286761e-01f, 3.70688252e-02f, 2.05938309e-01f, 4.25990283e-01f, -3.05251539e-01f,
  -2.89217979e-01f, -1.08631834e-01f, -2.17007145e-01f, -8.49805921e-02f, 2.03695640e-01f, 1.75651580e-01f, 5.21138348e-02f, -1.37696713e-02f, 3.14670682e-01f, -1.45368546e-01f,
  1.32133901e-01f, -2.08551571e-01f, 2.14829016e-02f, -2.29763836e-02f, -3.68626602e-02f, -6.99224100e-02f, -3.13724726e-01f, 1.64160907e-01f, -2.67280817e-01f, 1.22237846e-01f,
  -1.52426153e-01f, 9.24469605e-02f, -4.76868525e-02f, -3.21018100e-02f, -9.18354318e-02f, -7.82733858e-02f, -8.81822482e-02f, 4.58715111e-02f, 6.65725246e-02f, -9.45849344e-03f,
  -1.14654027e-01f, 4.29825997e-03f, 5.49841672e-02f, 8.92791897e-02f, 4.43798564e-02f, -1.13474384e-01f, 6.93170056e-02f, 1.01585197e-03f, -5.51936999e-02f, 1.01433188e-01f,
  -3.57468687e-02f, 1.80996433e-02f, -5.89853637e-02f, -7.40271388e-03f, 3.62654775e-02f, 7.44098797e-02f, 7.34775513e-02f, 2.12354306e-02f, -7.22632706e-02f, 7.11688921e-02f,
  3.83806489e-02f, 1.12668499e-01f, 3.01346164e-02f, 3.49902660e-02f, 1.82935409e-02f, -3.48788546e-03f, -1.99496802e-02f, -4.62065861e-02f, 4.82748374e-02f, -9.90933776e-02f,
  -2.44432259e-02f, 5.18810898e-02f, 3.86916660e-02f, -5.04531227e-02f, 1.38016585e-02f, 2.62481682e-02f, 1.09482268e-02f, 1.02192098e-02f, -5.44578880e-02f, 3.85934003e-02f,
  6.36831298e-02f, -2.66032126e-02f, -1.20190315e-01f, -8.65594149e-02f, 4.13979776e-02f, -3.68543044e-02f, -1.18348263e-01f, 1.29045233e-01f, -5.41633628e-02f, -6.32357150e-02f,
  -1.51688188e-01f, -6.89263940e-02f, -2.35164724e-02f, -1.40769094e-01f, 2.13733912e-02f, 3.46553815e-03f, 1.29369050e-01f, 7.75915533e-02f, -3.77657302e-02f, 1.57166310e-02f,
  -3.86485048e-02f, -2.36171838e-02f, -1.54938415e-01f, 1.88540518e-02f, -5.84258996e-02f, -3.60615477e-02f, -4.06858400e-02f, -2.89503839e-02f, -8.02547410e-02f, -4.35307994e-02f,
  -1.13112874e-01f, -7.36973658e-02f, 5.96896000e-02f, -3.04605849e-02f, -6.06368370e-02f, -1.50140151e-01f, -7.65061304e-02f, 8.57181847e-02f, 7.25412592e-02f, -6.80714846e-02f,
  -1.33259401e-01f, 4.29093875e-02f, 3.37557167e-01f, 2.24033952e-01f, 3.06577422e-02f, -1.82671204e-01f, -1.87294930e-01f, 1.73027083e-01f, -1.19431742e-01f, -5.82178012e-02f,
  8.06779489e-02f, -1.39856815e-01f, 4.51826900e-02f, 2.55154669e-01f, -8.31097662e-02f, -4.43959311e-02f, -1.59172103e-01f, -1.54707745e-01f, 1.40726537e-01f, -5.11381514e-02f,
  1.53646708e-01f, -1.38393283e-01f, 2.39945844e-01f, 1.02974445e-01f, 2.23343596e-01f, 1.57402679e-01f, -8.81197304e-02f, 1.40062705e-01f, 1.02120098e-02f, -8.17620009e-02f,
  -2.97617950e-02f, 2.72068769e-01f, 1.13797866e-01f, -5.48759997e-02f, 3.55840586e-02f, -9.24446806e-02f, 1.80761050e-02f, -4.49437276e-02f, 1.57788545e-01f, -3.86234224e-02f,
  -1.31363556e-01f, 1.19310156e-01f, 4.98556420e-02f, 1.06710512e-02f, 7.16412216e-02f, 1.87963903e-01f, 1.55657053e-01f, 8.64579678e-02f, 4.18033563e-02f, 1.22309528e-01f,
  5.29496484e-02f, 5.73213659e-02f, 8.52954108e-03f, -5.83950244e-02f, 4.37761582e-02f, 4.76258434e-02f, -9.14677978e-02f, -4.32604551e-02f, -1.11402579e-01f, -1.57679152e-02f,
  4.49975394e-02f, -1.49089739e-01f, 6.72668219e-02f, -5.85761182e-02f, -3.31831314e-02f, 4.45168391e-02f, -6.41169772e-02f, -1.78551469e-02f, 5.83349392e-02f, 1.00479886e-01f,
  -5.31519055e-02f, -7.91934282e-02f, -5.89879323e-03f, -6.94230571e-02f, -7.02853277e-02f, -5.57114184e-02f, 1.32957734e-02f, -1.19573176e-01f, -3.31432261e-02f, 3.25935557e-02f,
  -3.58828381e-02f, -5.06548099e-02f, -2.63177585e-02f, 1.31136971e-02f, -2.10448187e-02f, -8.77693072e-02f, 7.63314515e-02f, -8.55740905e-03f, 7.04249293e-02f, -8.26465264e-02f,
  -3.51569712e-01f, -3.27565491e-01f, -4.57986668e-02f, -5.60418479e-02f, -4.09645140e-02f, -8.66466016e-02f, 4.20464575e-02f, -1.99875385e-02f, -1.13224924e-01f, -1.02573745e-01f,
  -4.19813953e-02f, -5.87783679e-02f, -6.65923283e-02f, 2.03330237e-02f, -1.93597563e-02f, -6.41947016e-02f, -1.75884351e-01f, -1.23403557e-01f, -1.33061633e-01f, 5.33836149e-02f,
  -2.71777622e-02f, -5.20608313e-02f, 1.12407140e-01f, -1.66354366e-02f, -8.82145464e-02f, -2.21643932e-02f, -1.17841996e-01f, 2.42593493e-02f, -3.86367813e-02f, 7.23761618e-02f,
  2.08580270e-01f, -3.69896322e-01f, -3.99865240e-01f, -1.15745887e-01f, 3.48431140e-01f, 1.65090397e-01f, -5.42696845e-03f, 4.42452803e-02f, -2.38626152e-02f, -3.23920660e-02f,
  3.81707400e-01f, -2.49964997e-01f, 3.59402262e-02f, 2.27682188e-01f, 2.61894554e-01f, 4.86022383e-02f, -1.01529494e-01f, -2.03360796e-01f, -2.28036083e-02f, -1.98392928e-01f,
  9.11585465e-02f, 3.86853248e-01f, -5.65069169e-02f, 9.94104370e-02f, 9.87745374e-02f, -2.87108600e-01f, 8.03251714e-02f, -4.19874340e-02f, 6.52264804e-02f, 1.39454052e-01f,
  1.49625376e-01f, 1.47770703e-01f, 7.22757867e-03f, -1.34008333e-01f, -4.59300634e-03f, -3.86052728e-02f, -6.54219538e-02f, -7.18035996e-02f, 3.59990373e-02f, -2.59044338e-02f,
  -8.57938975e-02f, 1.04891121e-01f, 7.92381074e-03f, 8.51612315e-02f, 2.82070842e-02f, 6.16963804e-02f, 5.83789088e-02f, 1.04422849e-02f, -6.25196248e-02f, 4.83380370e-02f,
  -6.85947239e-02f, -3.71313072e-04f, 4.20169458e-02f, -1.36283234e-01f, 1.57026872e-02f, 5.23758121e-02f, -4.50857133e-02f, -5.99931888e-02f, -5.87775419e-03f, 3.89684699e-02f,
  2.63409764e-02f, -3.43785211e-02f, 2.78383046e-02f, 7.14429021e-02f, 2.06915922e-02f, -1.89977828e-02f, 9.57135856e-02f, 1.07284682e-02f, -4.07553613e-02f, -4.67032380e-02f,
  1.75984558e-02f, 7.81338010e-03f, 1.06810324e-01f, 5.41279651e-02f, 1.18428588e-01f, -1.00268396e-02f, -1.50174601e-02f, -7.42333680e-02f, -1.87376544e-01f, 4.85712662e-02f,
  -2.75628082e-03f, -5.12751713e-02f, 3.47555764e-02f, 8.76337290e-03f, 5.21943048e-02f, 7.93885812e-02f, -5.41773178e-02f, 4.44268137e-02f, -1.33855967e-02f, -2.05200091e-02f,
  -1.09816790e-01f, -4.41154748e-01f, -1.05255716e-01f, 4.29335646e-02f, -9.81485993e-02f, 3.50961462e-02f, 1.19990939e-02f, 3.17072012e-02f, -4.21494693e-02f, 3.55917541e-03f,
  3.04499455e-02f, -7.37960711e-02f, -8.38114396e-02f, 5.82799539e-02f, -9.31553990e-02f, -3.94797660e-02f, -1.20579511e-01f, -4.97680604e-02f, -7.59045407e-02f, -9.43377018e-02f,
  3.62165389e-03f, -5.53106982e-03f, -4.80733402e-02f, 1.59416631e-01f, -4.40073907e-02f, -4.34315540e-02f, -3.25546116e-02f, -2.59823073e-02f, -5.42494357e-02f, -1.15062192e-01f,
  -4.20401275e-01f, 5.34368008e-02f, 3.57867964e-02f, -2.30020076e-01f, -1.36026397e-01f, -6.66907609e-01f, -2.94073701e-01f, -1.27638206e-01f, -2.49239743e-01f, 1.12739712e-01f,
  3.75401825e-02f, 2.81981025e-02f, 2.13447765e-01f, -2.85824448e-01f, -3.49362791e-01f, -4.17108424e-02f, -3.29619020e-01f, -1.52442232e-01f, 8.49202368e-03f, -6.57153428e-02f,
  -6.70123026e-02f, -2.96436787e-01f, 1.12044392e-02f, 6.09989986e-02f, -9.57337245e-02f, 1.16345175e-01f, 2.73897976e-01f, 1.70880854e-01f, -2.91632116e-02f, -7.94316158e-02f,
  -1.61255196e-01f, 9.20243338e-02f, 4.80961474e-03f, -1.92317516e-02f, -5.88414036e-02f, 2.89876014e-02f, 1.73139069e-02f, 4.84015085e-02f, -2.43214983e-02f, -4.30224948e-02f,
  1.12337545e-02f, -6.45024702e-02f, -9.84303877e-02f, -2.56869644e-02f, -3.21935676e-02f, 4.46876213e-02f, 1.07985665e-03f, -1.78810302e-02f, 4.17093001e-02f, -2.56677214e-02f,
  3.11819813e-03f, 1.84226353e-02f, 2.72719208e-02f, 7.57358298e-02f, 3.86772975e-02f, -5.31665934e-03f, -2.55983397e-02f, 5.52442782e-02f, -5.34364767e-02f, -6.84320107e-02f,
  -1.77358519e-02f, -5.60490452e-02f, 7.79921515e-03f, 4.65609459e-03f, -7.47255087e-02f, 5.87182492e-02f, -3.44156288e-02f, 3.22236568e-02f, 3.58798914e-02f, 2.27165818e-02f,
  -3.73163633e-02f, 1.78902000e-02f, -2.57788915e-02f, -1.46101043e-02f, -3.73148769e-02f, 9.75021918e-04f, -1.73464362e-02f, 7.81223625e-02f, -6.89357072e-02f, -7.36015290e-02f,
  8.06015432e-02f, -4.32147086e-02f, -9.43770912e-03f, 8.26649219e-02f, -3.44204307e-02f, 1.62672158e-02f, 1.14505803e-02f, 5.02210017e-03f, 1.74244102e-02f, -7.00232759e-02f,
  1.06234262e-02f, -3.44320945e-02f, 2.96656229e-03f, -1.58508290e-02f, 7.27723315e-02f, 8.67991988e-03f, -6.55881837e-02f, -7.52174482e-02f, -2.28053033e-02f, -5.77329993e-02f,
  3.73111782e-03f, 4.96329330e-02f, 4.25144099e-02f, 6.12502396e-02f, -2.13634335e-02f, -3.17042209e-02f, 5.34382351e-02f, 2.71706353e-03f, 1.58950612e-02f, 8.18010718e-02f,
  6.56389026e-03f, -3.59534868e-03f, -3.94690670e-02f, -9.61340964e-02f, -2.20016781e-02f, 2.07967646e-02f, -2.31703278e-02f, -3.40637229e-02f, 6.70792386e-02f, 7.03090802e-02f,
  -1.51520938e-01f, -2.83974022e-01f, -4.07738119e-01f, -1.79642349e-01f, 5.48727661e-02f, 5.85835706e-03f, 2.49993533e-01f, -1.49998114e-01f, -3.44736725e-01f, 2.07934156e-01f,
  2.18960881e-01f, -7.04554319e-02f, 4.35206033e-02f, 1.62484527e-01f, 2.68315762e-01f, 4.36924733e-02f, -3.50007638e-02f, -1.05995625e-01f, -2.93502033e-01f, -6.64881393e-02f,
  -1.85482025e-01f, 3.50683868e-01f, -2.11102534e-02f, 1.02076773e-02f, 1.30166486e-01f, -1.65257812e-01f, 3.89835566e-01f, 6.69401065e-02f, 2.36181691e-01f, 6.29236624e-02f,
  -6.11366816e-02f, -3.14604230e-02f, 6.74903579e-03f, -1.18336342e-01f, -3.90884690e-02f, 2.22799946e-02f, 4.64227684e-02f, 1.43927559e-01f, -9.45940390e-02f, -7.66518712e-02f,
  5.58003634e-02f, 1.12812452e-01f, -2.78787669e-02f, 2.61167884e-02f, -6.82398602e-02f, -8.70141163e-02f, -6.19626194e-02f, -9.65898931e-02f, -7.26835430e-02f, -4.79501262e-02f,
  -1.34681538e-01f, -8.83376077e-02f, 6.56643212e-02f, 1.22756764e-01f, 5.09290211e-02f, -6.37262911e-02f, -1.02858946e-01f, 1.10713713e-01f, 5.43262213e-02f, -1.84827477e-01f,
  9.12995562e-02f, 4.53277212e-03f, 2.33095445e-04f, -6.61672130e-02f, 2.43710279e-02f, 6.95424061e-03f, 1.53111266e-02f, 1.36851326e-01f, -7.56534562e-02f, 2.32202448e-02f,
  4.28248197e-02f, -5.99593148e-02f, 5.03344089e-02f, -1.36199042e-01f, -3.76587883e-02f, -2.83025056e-02f, 5.53042144e-02f, -2.36066151e-02f, -3.46570127e-02f, -8.62087961e-03f,
  7.40984231e-02f, 5.30834422e-02f, -5.84987476e-02f, -1.44601837e-02f, 1.72067136e-02f, 2.83459257e-02f, 5.30011207e-02f, -6.48880824e-02f, -1.57595444e-02f, 5.40202707e-02f,
  4.00706455e-02f, 2.18996003e-01f, -2.19193958e-02f, -4.62445244e-02f, -8.80679637e-02f, 4.11499850e-02f, -4.80197519e-02f, -2.95396335e-02f, 2.56370399e-02f, 3.81907076e-02f,
  8.27771612e-03f, -9.70989019e-02f, 9.81391519e-02f, 1.24875084e-02f, 2.46937405e-02f, 9.91617367e-02f, 4.37273867e-02f, 1.87307075e-02f, 1.13094136e-01f, -3.63523723e-03f,
  4.91986126e-02f, 1.54154766e-02f, 5.22393559e-04f, 4.54921834e-02f, 4.27247696e-02f, 4.61928360e-02f, 2.13559554e-03f, -8.18281993e-02f, 8.72605853e-03f, -1.94905384e-03f,
  -7.86148131e-01f, 4.64072824e-01f, -2.24537015e-01f, 1.86803505e-01f, -2.49008715e-01f, -9.86722298e-03f, 3.72075289e-02f, 8.71941075e-02f, 1.22820415e-01f, 3.59723121e-01f,
  2.75606140e-02f, -7.00025111e-02f, 2.18080372e-01f, 3.37480634e-01f, -1.61864474e-01f, 3.83532822e-01f, 1.55359745e-01f, -2.22048685e-02f, 7.26799294e-02f, -1.40913680e-01f,
  -1.06313363e-01f, 1.95028588e-01f, -3.24513391e-03f, 1.78734601e-01f, -1.04356781e-01f, -1.74861982e-01f, -2.88944580e-02f, 4.75339964e-02f, -1.00190099e-02f, 3.64752486e-02f,
  3.34047340e-02f, -4.56294045e-02f, -6.75415844e-02f, -6.48637265e-02f, -2.18393162e-01f, -1.66261241e-01f, -8.48063082e-02f, -9.92868915e-02f, -8.75481591e-02f, -1.68278534e-03f,
  3.65496404e-03f, -3.14709395e-02f, -7.80352810e-03f, 2.63195243e-02f, 5.07224677e-03f, -1.48432879e-02f, 7.19347820e-02f, 7.28046373e-02f, 1.07201837e-01f, -6.69410229e-02f,
  5.06410375e-02f, -2.20018881e-03f, -3.60579253e-03f, 1.13039926e-01f, 6.90557063e-03f, 7.40735829e-02f, -5.03337346e-02f, -1.63647205e-01f, 1.21232860e-01f, -9.61066335e-02f,
  1.62230805e-02f, -7.99764618e-02f, -1.39827654e-02f, 1.02549158e-01f, -1.74147601e-03f, 1.28343166e-03f, 1.33740380e-01f, -3.00802868e-02f, -3.59090269e-02f, 7.87172467e-02f,
  -4.36802655e-02f, 2.11336240e-02f, 5.73505424e-02f, -1.39673091e-02f, -7.13507086e-02f, -2.18880884e-02f, -7.70781338e-02f, 6.39624754e-03f, -2.11418234e-02f, 1.04019307e-02f,
  7.01342076e-02f, 7.35633168e-03f, 5.67192025e-03f, 1.76429078e-02f, 5.14225177e-02f, -7.21468851e-02f, 3.64560671e-02f, 5.56447282e-02f, -1.02473527e-01f, -3.04375496e-02f,
  9.27976146e-02f, 2.11673081e-01f, 4.72977059e-03f, 2.71035302e-02f, 9.33600441e-02f, 2.72618532e-02f, 1.40981376e-01f, 1.22275546e-01f, 4.00221460e-02f, -3.54928784e-02f,
  -1.85872123e-01f, -1.67595223e-02f, 1.51271764e-02f, -5.68597466e-02f, 1.94371454e-02f, 1.37460921e-02f, -2.89835371e-02f, -6.27627596e-02f, -3.39672230e-02f, 3.79943661e-03f,
  -2.25844386e-04f, -1.07368939e-01f, 3.91774476e-02f, -3.68862227e-02f, -6.53545856e-02f, -4.91333343e-02f, -6.55145720e-02f, -8.73166695e-03f, 4.07084748e-02f, 1.40555456e-01f,
  -4.41196352e-01f, 7.63571039e-02f, 1.27800509e-01f, -1.94186166e-01f, -2.41296306e-01f, -1.41981065e-01f, -1.72095060e-01f, -1.28772050e-01f, 4.81021926e-02f, 1.52411880e-02f,
  -3.67310047e-01f, 1.87242001e-01f, -6.43919185e-02f, -3.40387464e-01f, -2.39241362e-01f, -7.30305538e-02f, -2.88853347e-01f, -1.40673727e-01f, -4.85718362e-02f, -5.26034422e-02f,
  -6.66320324e-02f, -3.44692379e-01f, -2.95129001e-01f, -6.14681244e-02f, -2.96031296e-01f, 1.24029472e-01f, -8.18000734e-02f, 1.52580827e-01f, -1.73482478e-01f, -7.00276643e-02f,
  -1.87090099e-01f, -7.37359971e-02f, -1.17582344e-01f, 9.98902470e-02f, -8.15810263e-02f, 5.70833795e-02f, 9.35141221e-02f, 3.30325626e-02f, 2.33051386e-02f, 1.19067114e-02f,
  1.06016882e-01f, -8.51872470e-03f, -7.74048492e-02f, 1.34156570e-01f, 6.01817966e-02f, -4.30900604e-02f, -1.40807098e-02f, -8.78104866e-02f, 1.92031842e-02f, -1.09718949e-01f,
  -3.12215798e-02f, 3.11370417e-02f, -6.61012307e-02f, -2.80772913e-02f, -1.35796508e-02f, -5.79280360e-03f, 2.66106762e-02f, 7.80071169e-02f, 1.73005536e-02f, -4.00571749e-02f,
  1.43597284e-02f, 1.03655256e-01f, 1.26755303e-02f, -2.03902996e-03f, 3.40557285e-02f, -5.44603504e-02f, 1.80726144e-02f, -7.29954243e-02f, 3.20868604e-02f, -5.99960573e-02f,
  3.32435768e-04f, -1.25051085e-02f, -1.03548123e-03f, 5.69392368e-02f, -3.32510248e-02f, -2.60093752e-02f, 4.22568098e-02f, 2.59190220e-02f, -6.81953579e-02f, -5.75536117e-02f,
  -7.12272106e-03f, 1.51778022e-02f, 3.47576402e-02f, -7.46872276e-02f, 2.58637443e-02f, 1.94049980e-02f, 6.13290183e-02f, 5.63232265e-02f, -1.77131537e-02f, 3.09734568e-02f,
  2.01563194e-01f, 3.65422726e-01f, 5.72941527e-02f, -1.55877266e-02f, 4.66765016e-02f, 2.98581552e-02f, -2.55775172e-02f, -8.80547315e-02f, 1.46434337e-01f, -6.53174296e-02f,
  1.12324599e-02f, 3.64438593e-02f, 1.37003645e-01f, -9.11692083e-02f, 6.73686862e-02f, 3.32403369e-03f, 9.33925956e-02f, 1.61962613e-01f, -1.04540335e-02f, -1.02423485e-02f,
  1.05616208e-02f, -4.48384183e-03f, 6.00299984e-03f, -7.98604637e-02f, -7.52310827e-02f, -5.28186467e-03f, -1.24681238e-02f, 4.67426106e-02f, -1.71043668e-02f, 5.28809801e-02f,
  -6.00070417e-01f, -1.99524015e-01f, -7.35214949e-02f, -3.41509551e-01f, -6.22937009e-02f, 6.47679018e-03f, -7.95403421e-02f, -2.07042649e-01f, -2.72726089e-01f, 8.48830640e-02f,
  8.73479620e-02f, -3.90918046e-01f, 3.41594964e-01f, -2.07405865e-01f, -3.37904513e-01f, 2.50503540e-01f, -4.00472283e-01f, -1.72234386e-01f, 2.13832185e-02f, -2.99263567e-01f,
  -1.19360365e-01f, -2.97788624e-02f, -1.13841824e-01f, 8.44011232e-02f, -1.60912454e-01f, -3.88831496e-02f, 1.64089605e-01f, 1.94016710e-01f, -6.73430413e-02f, 3.48707549e-02f,
  -1.92414477e-01f, -1.74581528e-01f, 1.57339964e-02f, 1.30552044e-02f, -6.27990887e-02f, 6.96204677e-02f, 4.54518162e-02f, 8.68226439e-02f, -3.75441685e-02f, -3.48445289e-02f,
  6.07816735e-03f, -2.92951125e-03f, 5.87404985e-03f, 8.14369768e-02f, -6.37803748e-02f, -4.15653884e-02f, -6.28610048e-03f, 4.10281904e-02f, 9.77578387e-03f, -8.68374929e-02f,
  1.02883335e-02f, 5.23502268e-02f, -2.14182194e-02f, 3.46481078e-03f, 1.14614610e-02f, 3.21069686e-03f, -4.37670315e-05f, 3.14800851e-02f, -2.47947481e-02f, -6.68170303e-02f,
  1.52420800e-03f, 5.31978719e-03f, 2.75444370e-02f, -1.84526257e-02f, 3.24254017e-03f, 8.85868911e-03f, 1.68057494e-02f, -4.34132069e-02f, -4.72474890e-03f, -3.59556079e-02f,
  -9.99343488e-03f, -6.93880916e-02f, -2.72654034e-02f, 8.87599867e-03f, -2.08188929e-02f, -9.47843641e-02f, 4.94674854e-02f, 2.60661673e-02f, -1.94457192e-02f, -5.65817095e-02f,
  2.22300217e-02f, -6.33378625e-02f, 4.00324985e-02f, 1.76438857e-02f, 2.58819237e-02f, 5.50220162e-03f, 1.01715796e-01f, -2.38652825e-02f, 1.86566189e-02f, -1.43268320e-04f,
  -1.82058156e-01f, -2.65602678e-01f, -7.52336858e-03f, -1.93191860e-02f, 6.31726831e-02f, -3.38088255e-03f, -1.11227363e-01f, 1.46169616e-02f, -2.83656269e-02f, 5.74825797e-03f,
  -6.54095970e-03f, -4.09652144e-02f, -2.48432513e-02f, -7.74456095e-03f, 1.95639897e-02f, -2.42748000e-02f, 5.89076877e-02f, -2.93297321e-02f, -1.03058018e-01f, -2.01035924e-02f,
  -1.44499671e-02f, 2.87712049e-02f, 2.29430739e-02f, -2.72343941e-02f, -3.14363581e-03f, -3.07374671e-02f, -1.12781353e-01f, -2.73068808e-02f, 8.55723023e-02f, -6.83220336e-03f,
  5.63216686e-01f, -6.98194057e-02f, 1.18236609e-01f, 1.13326050e-01f, 3.63344043e-01f, 3.33740592e-01f, 1.62754744e-01f, 2.21176282e-01f, 2.58327305e-01f, -2.27690607e-01f,
  1.23385005e-01f, -7.84551576e-02f, 1.55498758e-02f, 7.03414455e-02f, 5.36883414e-01f, -9.78784710e-02f, 1.31235674e-01f, -1.20699830e-01f, 1.40245169e-01f, 2.87090749e-01f,
  1.17988460e-01f, 2.42314428e-01f, -1.59017220e-02f, 9.20381472e-02f, 1.24732085e-01f, -1.08572133e-01f, -1.37759507e-01f, -5.63127697e-02f, -1.21949241e-01f, 3.48839201e-02f,
  1.97292596e-01f, 1.15346842e-01f, -4.81714793e-02f, -2.21474227e-02f, 7.10606873e-02f, -1.09097129e-02f, -4.96241339e-02f, -4.86967750e-02f, 1.14096984e-01f, -1.01173650e-02f,
  -5.14737368e-02f, 1.67107627e-01f, 2.77993307e-02f, -4.58376035e-02f, 2.56124549e-02f, 6.45092651e-02f, 1.55827152e-02f, 2.29877941e-02f, 3.87845635e-02f, 2.00575814e-02f,
  2.75645610e-02f, 4.98822238e-03f, -1.08839720e-02f, -5.98271117e-02f, 2.93951784e-03f, -3.94049622e-02f, -2.18260754e-02f, -2.65171286e-02f, 5.33305034e-02f, 7.97402188e-02f,
  9.74326059e-02f, -4.33993302e-02f, -4.00448740e-02f, -1.16938930e-02f, 2.96510961e-02f, -2.85243951e-02f, -6.09224699e-02f, -2.15016529e-02f, -8.00423250e-02f, 3.18245739e-02f,
  6.82477131e-02f, -6.58431053e-02f, 6.06333986e-02f, -2.32552532e-02f, -9.41014513e-02f, -5.41578904e-02f, -8.17911401e-02f, -2.43473034e-02f, 3.35267745e-02f, -3.35345194e-02f,
  6.66334704e-02f, 6.76693618e-02f, -4.64794151e-02f, -3.50438361e-03f, 4.79174331e-02f, -3.57202254e-02f, 8.12802836e-03f, 2.74917483e-03f, 2.93791741e-02f, -8.14009085e-03f,
  1.19553581e-01f, 5.97373955e-02f, 3.59310373e-03f, 4.52578552e-02f, -1.03327222e-01f, -9.92086157e-02f, 1.91979893e-02f, 1.91575997e-02f, 9.08957049e-03f, 1.21336862e-01f,
  -3.41399573e-02f, -1.61022082e-01f, 5.90738468e-02f, -7.08805490e-03f, 4.94127870e-02f, 6.48929849e-02f, 6.54814346e-03f, -5.63194491e-02f, 2.55249441e-02f, -9.70505364e-03f,
  -1.46424514e-03f, 2.33806316e-02f, -3.67750078e-02f, 3.92136015e-02f, -3.06134601e-03f, 3.83349322e-02f, -2.27185953e-02f, -4.89100628e-02f, -3.27491388e-02f, -3.03686969e-02f,
  1.74758703e-01f, -3.85563001e-02f, 2.27644905e-01f, 2.73389429e-01f, -2.56381720e-01f, -1.46456450e-01f, -1.56297222e-01f, -9.54934955e-02f, -3.35916102e-01f, 8.34875330e-02f,
  -2.45696157e-01f, 3.70585829e-01f, -3.05159450e-01f, 2.57067949e-01f, 3.48477453e-01f, -1.09765023e-01f, 1.39368221e-01f, 8.25845599e-02f, -2.51577348e-01f, 4.86699902e-02f,
  3.87205333e-02f, 1.98643595e-01f, 1.47493064e-01f, -6.64338768e-02f, 1.83692679e-01f, -8.05399045e-02f, 3.48368287e-01f, -1.21574506e-01f, 4.20801580e-01f, 7.12070763e-02f,
  -6.57900497e-02f, -1.42199233e-01f, 1.97442509e-02f, 2.95648128e-02f, 7.66072469e-03f, -5.73185459e-02f, 7.54855722e-02f, 3.30756493e-02f, -1.42035395e-01f, -1.17193684e-01f,
  1.68709718e-02f, 1.38446510e-01f, -8.57695565e-03f, 1.70580689e-02f, -5.50601967e-02f, 1.14963809e-02f, -3.44707677e-03f, -2.59224046e-02f, -1.28727537e-02f, -1.31967496e-02f,
  2.14977283e-03f, -2.38192943e-03f, 3.99805121e-02f, 5.57405502e-02f, 7.47414231e-02f, -2.85038091e-02f, 2.63325386e-02f, 2.71485597e-02f, 6.52035698e-02f, 2.57139327e-03f,
  -5.02199493e-03f, -1.23666085e-01f, 1.26913958e-03f, 2.01550615e-03f, -6.98705539e-02f, 2.86460691e-03f, -1.74935926e-02f, 3.53152007e-02f, 5.65851256e-02f, -4.70493920e-02f,
  -2.04542000e-02f, 3.36733386e-02f, -1.19586540e-02f, -7.91538209e-02f, 1.45679247e-02f, -7.65184686e-02f, 4.08922583e-02f, -3.73843648e-02f, 1.49187054e-02f, 8.51501804e-03f,
  -1.30195394e-02f, 5.81326988e-03f, 2.93479417e-04f, 2.64921766e-02f, -6.89902753e-02f, 3.65511738e-02f, 5.01563698e-02f, 3.02889626e-02f, -1.58537492e-01f, 1.69971660e-02f,
  7.31809661e-02f, 3.13218266e-01f, -1.07349627e-01f, 5.65775447e-02f, -4.63061850e-04f, 1.26299439e-02f, -1.29519720e-02f, 1.24417022e-02f, 1.34778559e-01f, -9.89646930e-03f,
  8.60300437e-02f, -7.08237961e-02f, 8.73429701e-02f, -1.62008740e-02f, 8.89669582e-02f, -3.33786011e-02f, 4.77532260e-02f, 8.59530717e-02f, 1.50570765e-01f, 2.16852501e-02f,
  7.67537504e-02f, 5.08364737e-02f, 2.62036733e-02f, -3.07685994e-02f, -2.06530038e-02f, 7.24129528e-02f, -8.29526335e-02f, -7.00748712e-02f, -2.83009615e-02f, -2.06671748e-02f,
  4.25175250e-01f, -4.30611342e-01f, -3.83979559e-01f, -2.42921621e-01f, 2.85953462e-01f, -1.02876179e-01f, -1.26528114e-01f, -1.45417377e-01f, 3.20402123e-02f, -1.82600349e-01f,
  -3.28784585e-02f, 5.15910462e-02f, -1.47891939e-01f, -3.89562041e-01f, 2.34647125e-01f, -2.89007068e-01f, -2.30556861e-01f, -6.29597828e-02f, -1.12979002e-02f, 4.98731546e-02f,
  5.81303425e-02f, -9.67820883e-02f, -2.60992408e-01f, 5.01342751e-02f, -7.61539936e-02f, 2.09106281e-02f, 1.25159368e-01f, 1.00146599e-01f, -4.52615432e-02f, 6.30760193e-02f,
  -3.38361599e-02f, -1.05773255e-01f, -1.10878572e-01f, -3.11119240e-02f, -6.75753877e-03f, 9.67665017e-02f, 4.55800295e-02f, -5.36243431e-02f, -2.11496688e-02f, -1.01764826e-02f,
  -4.07109782e-02f, 4.10094373e-02f, 4.91990931e-02f, -4.94218543e-02f, 3.92463617e-02f, -5.32317236e-02f, -1.15451768e-01f, -1.61063060e-01f, -4.59523462e-02f, -5.07793278e-02f,
  -1.51589021e-01f, -3.96312550e-02f, -1.33965656e-01f, -7.57750273e-02f, -1.80266518e-02f, -5.38282543e-02f, -7.11660609e-02f, 1.77645646e-02f, 2.96902074e-03f, 3.67607959e-02f,
  3.37095335e-02f, 8.50302055e-02f, -3.97857614e-02f, 3.22816260e-02f, 1.29491417e-02f, -2.12569330e-02f, 1.54479118e-02f, -4.37388988e-03f, 1.03680491e-01f, 3.88766117e-02f,
  6.01559803e-02f, 4.27583382e-02f, 1.00766435e-01f, -3.71009530e-03f, 4.03531380e-02f, -2.70469505e-02f, 1.94572713e-02f, 5.92641756e-02f, 2.72842124e-02f, 5.64807951e-02f,
  2.43277214e-02f, 2.70481575e-02f, -1.07876375e-01f, 9.77249350e-03f, 1.19891856e-02f, 3.25675458e-02f, -2.50897296e-02f, -9.77174789e-02f, -1.96152497e-02f, 1.32200688e-01f,
  1.55128837e-01f, 2.13463336e-01f, 3.87761882e-03f, 5.91028072e-02f, 2.44073346e-02f, 3.22973356e-02f, -4.27127257e-02f, 6.21630661e-02f, 4.20087762e-02f, 6.95604682e-02f,
  6.44303933e-02f, -9.94600262e-03f, 8.74480456e-02f, 6.28428683e-02f, 9.23007727e-03f, -3.28889191e-02f, 7.82610103e-03f, 7.25558996e-02f, 9.60429758e-02f, 1.51900761e-02f,
  5.34853972e-02f, 4.53644171e-02f, 1.31527260e-01f, 7.47147901e-03f, 4.07230854e-02f, 7.03264400e-02f, 5.78911826e-02f, -2.22941320e-02f, 9.32489336e-02f, -3.18223573e-02f,
  2.89258778e-01f, 1.57626852e-01f, 4.07746077e-01f, 2.92196572e-02f, 2.04940856e-01f, 4.27607484e-02f, -2.80652270e-02f, 1.61510944e-01f, 1.35175720e-01f, -2.90317565e-01f,
  9.35376156e-03f, -1.53969061e-02f, 1.99572682e-01f, -2.67012846e-02f, 3.37300450e-01f, 1.75925002e-01f, 7.71988034e-02f, -8.74088705e-02f, 1.74682125e-01f, 3.80381376e-01f,
  1.09445743e-01f, 8.02802593e-02f, 2.32338265e-01f, 1.75518215e-01f, 1.66575953e-01f, -6.95104003e-02f, -3.93367298e-02f, 5.10184988e-02f, -2.55978435e-01f, -1.50638178e-01f,
  9.73684415e-02f, 2.27996290e-01f, -2.22626217e-02f, -1.57329310e-02f, 6.18102103e-02f, -1.25874311e-01f, -5.24897166e-02f, -3.62012233e-03f, 6.02652542e-02f, -1.36251235e-02f,
  -1.38670295e-01f, 6.77890852e-02f, -6.07575886e-02f, -3.19954543e-03f, 5.02338223e-02f, 3.91060114e-02f, 2.70610098e-02f, -1.55180171e-02f, 1.05362207e-01f, -5.06316870e-02f,
  8.56268033e-02f, -9.48141888e-02f, 6.53989054e-03f, -9.96225476e-02f, 9.88742784e-02f, -3.67784463e-02f, -9.19951275e-02f, -7.17421472e-02f, 5.61171919e-02f, -1.68533176e-02f,
  -1.13448538e-01f, -2.04352830e-02f, 4.40246612e-02f, 1.06935669e-02f, 3.45791988e-02f, -9.71850902e-02f, 4.44407761e-02f, -4.80541028e-02f, 5.85758761e-02f, -1.04973642e-02f,
  -5.48067130e-02f, 2.66616773e-02f, 2.63638701e-02f, 4.76721441e-03f, -1.15082227e-02f, -1.35682717e-01f, 7.81262517e-02f, -1.98601056e-02f, -1.56099042e-02f, -6.60911947e-02f,
  1.05505530e-02f, 8.34030211e-02f, 3.87826748e-02f, -4.65057604e-02f, 5.13732061e-02f, 1.21466041e-01f, 4.31861505e-02f, 1.07681779e-02f, 2.41056439e-02f, 3.45173962e-02f,
  1.68532878e-01f, 2.39207342e-01f, -2.09063687e-03f, 4.11694031e-03f, -2.35509928e-02f, 6.04919791e-02f, 7.71661401e-02f, 1.18474811e-01f, -4.50773863e-03f, 1.61528930e-01f,
  5.39112277e-02f, -1.50165632e-01f, -9.95367467e-02f, 7.68002793e-02f, 1.50341084e-02f, -1.75149925e-02f, -4.17200476e-02f, -1.40776969e-02f, 1.40378261e-02f, -2.47379784e-02f,
  2.60741133e-02f, 1.36638060e-01f, -1.30063351e-02f, 1.17890507e-01f, -6.18378557e-02f, -1.04197152e-01f, -7.21685588e-03f, -1.55647397e-01f, 7.85472095e-02f, 5.75925782e-03f,
  6.89887702e-01f, 2.90638864e-01f, 1.68659627e-01f, 1.09105878e-01f, 3.26461233e-02f, 3.31302434e-01f, -2.08472717e-03f, 1.10475652e-01f, 3.78281653e-01f, 2.44401004e-02f,
  -1.10779792e-01f, 1.54653594e-01f, -2.16075823e-01f, -8.72260630e-02f, -2.70738542e-01f, -2.35419244e-01f, -1.60544768e-01f, -1.97034195e-01f, -5.63385673e-02f, -1.25177279e-01f,
  -1.11092508e-01f, -2.73611039e-01f, -4.02858287e-01f, -1.58631757e-01f, -9.47348550e-02f, 9.32667032e-02f, -1.62767097e-01f, -1.31662861e-01f, -1.55661315e-01f, 3.69201712e-02f,
  1.02127958e-02f, 1.24971621e-01f, 2.93348134e-02f, 3.72829922e-02f, 1.58385020e-02f, 8.44012499e-02f, -3.51797380e-02f, -6.14634901e-03f, 3.74602750e-02f, -5.58575951e-02f,
  -3.67015786e-02f, -3.42270508e-02f, 3.06728799e-02f, -6.18852787e-02f, 1.36737272e-01f, 7.16836080e-02f, 2.56139189e-02f, -2.33719386e-02f, -5.22807129e-02f, 5.71765490e-02f,
  -3.70351672e-02f, 8.12498759e-03f, 1.17140086e-02f, -3.32257263e-02f, -2.27406640e-02f, 1.62162051e-01f, 2.29322258e-02f, -2.58935485e-02f, 8.62536021e-03f, 1.34152800e-01f,
  1.99466180e-02f, -5.89981154e-02f, -9.56260189e-02f, 2.42790952e-03f, -3.63336466e-02f, 3.82140395e-03f, -3.48687135e-02f, -5.58285937e-02f, 4.68036346e-02f, -3.82915288e-02f,
  5.55257592e-03f, 4.99414690e-02f, 7.35610276e-02f, 4.59219366e-02f, 1.81081216e-03f, 1.26558557e-01f, -1.46113276e-01f, -1.11660138e-01f, 1.82565507e-02f, -4.67855930e-02f,
  4.45673056e-03f, 3.75616029e-02f, -6.46754913e-03f, -5.64013384e-02f, -6.05562981e-03f, -2.58025583e-02f, 2.68898166e-05f, 5.10026850e-02f, -3.96902673e-03f, -1.41904756e-01f,
  7.16587454e-02f, -2.45362315e-02f, -2.49124691e-03f, 8.20304500e-04f, -1.61684319e-01f, 3.22645195e-02f, 2.25323439e-03f, 8.67644474e-02f, -1.24922782e-01f, 3.41926627e-02f,
  1.10186853e-01f, -1.66436862e-02f, 4.44617309e-03f, 5.69613688e-02f, -1.11452833e-01f, 8.41747075e-02f, -5.50894998e-02f, 5.18055484e-02f, -7.05696866e-02f, -6.40289858e-02f,
  1.22231394e-02f, -1.07786385e-02f, -1.08977765e-01f, -4.30673808e-02f, -2.86627421e-03f, -7.06425682e-02f, 7.89712220e-02f, 1.20674849e-01f, -1.29443154e-01f, -4.90401201e-02f,
  8.09420705e-01f, -8.91942605e-02f, 2.32826233e-01f, 3.28095615e-01f, 9.42258537e-02f, 3.09684157e-01f, 1.74842522e-01f, 5.20617841e-03f, 2.80426741e-01f, -3.71381789e-01f,
  -2.18615532e-01f, 2.86743969e-01f, -3.24359864e-01f, 5.54878265e-03f, 4.82972294e-01f, -1.41326919e-01f, 4.01640952e-01f, 1.17413498e-01f, -7.26577491e-02f, 5.00327758e-02f,
  1.11335106e-01f, -4.06957678e-02f, -4.51217778e-03f, -1.37562811e-01f, 8.30978677e-02f, 1.35523751e-01f, -1.56930745e-01f, -7.23377317e-02f, -2.50859074e-02f, 1.65960174e-02f,
  1.25145111e-02f, -1.17874704e-01f, 2.31884662e-02f, -1.41634969e-02f, 7.04428297e-04f, -4.64478396e-02f, 4.00940739e-02f, 1.16813369e-03f, 1.96937695e-02f, -1.79017764e-02f,
  1.88553426e-02f, 1.84754618e-02f, -2.60956166e-03f, -8.04435695e-04f, 3.61115932e-02f, -1.35058584e-02f, 1.26384078e-02f, 1.03486646e-02f, -3.92607599e-02f, 7.91565999e-02f,
  -1.94150228e-02f, 4.39512469e-02f, 6.15966832e-03f, -1.40306689e-02f, 1.19938076e-01f, 4.91917171e-02f, -9.40011144e-02f, 4.67563458e-02f, 2.95747966e-02f, 6.50308132e-02f,
  -3.89645179e-03f, 2.76616178e-02f, -4.62688804e-02f, -8.06823745e-02f, 8.28803983e-03f, -9.07710046e-02f, 1.72312688e-02f, -9.48353037e-02f, 6.49476349e-02f, -1.53751625e-02f,
  1.93574540e-02f, 5.86530752e-03f, -6.61394419e-03f, 1.72918774e-02f, -3.27311791e-02f, -1.61657352e-02f, 9.00543388e-03f, -4.27707992e-02f, 2.96022128e-02f, 1.76869277e-02f,
  -2.96783801e-02f, 1.51156783e-02f, -7.99248368e-02f, -7.49743218e-03f, -5.39275669e-02f, 4.50101756e-02f, -4.41456549e-02f, 3.96103524e-02f, -3.24344151e-02f, 5.24968691e-02f,
  -3.76594216e-02f, 2.73264460e-02f, -4.38466407e-02f, 2.03568712e-02f, -5.72844176e-03f, 9.65751894e-03f, 5.17782569e-02f, 8.48936215e-02f, 4.95139547e-02f, -2.87859719e-02f,
  6.56768307e-02f, -3.90760116e-02f, -6.38793781e-03f, 6.51754439e-02f, 1.54888760e-02f, -9.25081149e-02f, -1.95821486e-02f, 4.87846360e-02f, 6.65095523e-02f, -5.11686578e-02f,
  9.99907963e-03f, -1.44315399e-02f, 4.65918668e-02f, 5.13669848e-03f, 1.19253788e-02f, 1.03459191e-02f, 1.22660562e-01f, 2.23267451e-03f, -1.32530667e-02f, -7.04736169e-03f,
  -5.37822068e-01f, 3.54179949e-01f, 7.30012134e-02f, -3.02075922e-01f, 8.63751695e-02f, -4.46455389e-01f, -3.41457725e-01f, 2.04689205e-01f, -2.64571309e-01f, 1.45453632e-01f,
  -1.89276814e-01f, -6.05520196e-02f, 1.76995978e-01f, -3.69704515e-01f, -3.14674228e-01f, -8.67414102e-02f, -3.88908535e-01f, -1.63402423e-01f, 1.91683806e-02f, -2.92351246e-02f,
  -5.86647056e-02f, -1.33094057e-01f, -2.93880198e-02f, 2.42394015e-01f, -2.09031720e-02f, 1.84083179e-01f, 2.24700838e-01f, 2.00817883e-01f, -5.88354729e-02f, -1.05360262e-02f,
  -7.65217841e-02f, 5.02318256e-02f, 1.01920240e-01f, -1.47620812e-02f, 4.16799728e-03f, 2.40046736e-02f, 9.92278289e-03f, 1.85842123e-02f, -6.77953288e-02f, 1.63226984e-02f,
  -1.11751175e-02f, 1.76238660e-02f, -3.99259590e-02f, 2.31008101e-02f, -2.64348439e-03f, 2.97097936e-02f, -2.07200460e-03f, -8.02008808e-02f, 3.36619504e-02f, -7.03751147e-02f,
  -2.17920840e-02f, -5.73669784e-02f, -4.03820015e-02f, -3.51114501e-03f, 4.16956283e-02f, -3.35377641e-02f, 1.13580131e-03f, 1.07609304e-02f, 1.05507169e-02f, -3.82367335e-02f,
  5.01414873e-02f, -1.00236917e-02f, -2.92455051e-02f, 6.50618151e-02f, -2.90327575e-02f, 4.19304073e-02f, -2.71345284e-02f, -1.51642980e-02f, -2.19679344e-02f, -2.47306004e-02f,
  -8.02123994e-02f, 3.24389189e-02f, -6.27530515e-02f, -1.16841425e-03f, -3.55899669e-02f, -1.67857334e-02f, 1.51152192e-02f, 2.94978097e-02f, -1.06088527e-01f, 1.85230782e-03f,
  1.49566224e-02f, -3.80321443e-02f, 1.60795245e-02f, 3.80050726e-02f, -3.00031109e-03f, 3.45074460e-02f, -3.72659713e-02f, -4.04293882e-04f, -2.04010699e-02f, -5.17190397e-02f,
  1.51622584e-02f, 2.26579323e-01f, -2.31686272e-02f, 1.29891736e-02f, -2.28041261e-02f, -5.14939576e-02f, -4.59068939e-02f, -3.44509794e-03f, 1.26573682e-01f, -2.08631139e-02f,
  -6.33499166e-03f, 1.98817533e-02f, 6.77209869e-02f, -4.62419130e-02f, -4.86967154e-02f, 2.54394226e-02f, -5.07816710e-02f, -2.13018246e-02f, 1.64353345e-02f, 4.52438816e-02f,
  3.05908155e-02f, -6.67136721e-03f, -2.00338829e-02f, 5.67394793e-02f, -6.91086724e-02f, 2.34110523e-02f, -1.49143869e-02f, -4.33387943e-02f, -2.65925657e-02f, 1.78830810e-02f,
  4.21813548e-01f, 3.00385565e-01f, 2.14866251e-01f, 4.27585304e-01f, -5.52056469e-02f, -3.65662843e-01f, -1.84955195e-01f, 2.57861167e-01f, 4.89648819e-01f, -1.76599562e-01f,
  -2.00050697e-01f, 1.84073806e-01f, -3.27120535e-02f, -1.24793239e-01f, 1.58867076e-01f, 7.16072991e-02f, -3.57356668e-02f, -1.05580963e-01f, 1.36371136e-01f, 1.50950596e-01f,
  1.36988744e-01f, -3.23680431e-01f, -2.93865278e-02f, -4.57906500e-02f, -2.97073741e-02f, 1.34461775e-01f, -1.60659268e-01f, -5.00361174e-02f, -1.32552579e-01f, -6.53045028e-02f,
  -1.29880697e-01f, 2.02262565e-01f, 4.86787409e-02f, 3.70617807e-02f, -1.77964866e-02f, -1.32154197e-01f, -1.31272212e-01f, -1.00149654e-01f, 7.19752163e-02f, 5.87898493e-03f,
  2.18915138e-02f, 2.41453201e-02f, 7.42560476e-02f, 3.61532085e-02f, 3.60177495e-02f, 5.51058426e-02f, 6.15511201e-02f, -2.19698139e-02f, -1.69442371e-02f, 8.80792886e-02f,
  1.70949996e-02f, -7.03421468e-03f, 1.72309240e-03f, 7.07034543e-02f, 1.97277367e-02f, 5.06203286e-02f, 1.27481036e-02f, -1.56800598e-02f, -2.45727319e-03f, 9.87163782e-02f,
  1.89598612e-02f, -1.77855566e-02f, 4.78199869e-02f, -4.96411361e-02f, 1.45669794e-02f, -8.20835158e-02f, 1.70135144e-02f, -9.99177471e-02f, 5.46791628e-02f, -1.22314440e-02f,
  1.20972749e-02f, 3.26338671e-02f, 8.20122752e-03f, -9.55187064e-03f, 9.07986388e-02f, -5.30682830e-03f, -1.09409783e-02f, -4.22399789e-02f, 4.72808555e-02f, -4.57575656e-02f,
  -1.05577512e-02f, -3.18092443e-02f, -8.08323771e-02f, -1.29676715e-01f, -3.52993533e-02f, 3.66401561e-02f, -8.35675932e-03f, 4.11752723e-02f, -3.95417623e-02f, -2.81169694e-02f,
  1.47374738e-02f, 1.77590847e-01f, 5.11559881e-02f, 1.93840768e-02f, 6.50646584e-03f, 1.52528863e-02f, 8.55804682e-02f, 8.04920122e-02f, -3.97938676e-03f, -6.46033045e-03f,
  -2.05027405e-02f, -2.72699017e-02f, -3.44693363e-02f, 5.63435769e-03f, 6.67923316e-02f, 9.36252810e-03f, -6.51251227e-02f, 1.26737980e-02f, -3.20277400e-02f, -2.60066148e-02f,
  -1.02224387e-01f, -2.40082871e-02f, 5.22236302e-02f, -5.37453331e-02f, -4.78398465e-02f, -3.13610397e-02f, -3.15087140e-02f, 8.19783136e-02f, -4.15116735e-02f, -4.71417094e-03f,
  5.18462718e-01f, -2.34693363e-01f, -1.37667090e-01f, 2.20584422e-01f, -1.30985277e-02f, 2.19511449e-01f, 5.14149904e-01f, -1.96454272e-01f, 2.31234014e-01f, 1.55835152e-01f,
  6.08102530e-02f, 5.53515926e-02f, 6.46000728e-02f, -1.74505979e-01f, 2.30486870e-01f, -6.50665760e-02f, 1.36318415e-01f, 4.79001775e-02f, 2.21531969e-02f, 8.05619545e-03f,
  8.03628489e-02f, -2.19095778e-02f, -2.93793857e-01f, -1.85085356e-01f, -1.86786358e-03f, -2.29378436e-02f, -7.54380524e-02f, -1.25930412e-02f, -1.73027128e-01f, -1.27299830e-01f,
  -1.56411052e-01f, -7.34258890e-02f, -3.52582224e-02f, -1.38710842e-01f, 8.30324292e-02f, 7.55479187e-02f, 9.40902755e-02f, 8.53302255e-02f, 1.00626806e-02f, -1.59482900e-02f,
  7.32259303e-02f, -1.73369907e-02f, -2.28161998e-02f, -7.28427023e-02f, -3.50201875e-03f, -6.50834888e-02f, -2.03815717e-02f, -1.15148135e-01f, -6.22607470e-02f, -3.89243942e-04f,
  1.05624169e-01f, -5.91760166e-02f, 1.03033401e-01f, 1.56903584e-02f, 6.83171675e-02f, 6.65418953e-02f, 4.16400619e-02f, -2.96245534e-02f, 8.79058987e-02f, 9.92908925e-02f,
  1.39388114e-01f, 6.12878166e-02f, -6.72131637e-03f, -1.32702485e-01f, 4.26562056e-02f, -1.08170398e-01f, 1.07282780e-01f, -9.15862769e-02f, 8.77118632e-02f, 1.16003163e-01f,
  -8.73351544e-02f, -4.97265235e-02f, -3.79189663e-02f, 7.74239451e-02f, 3.63395922e-02f, -2.81170122e-02f, -5.80279157e-03f, 3.59278768e-02f, -9.14086699e-02f, -9.74915177e-02f,
  -3.23730409e-02f, -1.01304250e-02f, -1.15542375e-02f, -9.97282658e-03f, -1.29156867e-02f, 5.43944687e-02f, -4.18906137e-02f, -1.39683515e-01f, 3.37093212e-02f, 5.63542433e-02f,
  1.39291450e-01f, 3.64848405e-01f, -1.81360412e-02f, -3.54490057e-02f, 2.57478580e-02f, 6.44991593e-03f, -1.41467582e-02f, -1.69209167e-02f, 1.77502669e-02f, 7.12687373e-02f,
  4.25668433e-02f, 1.17924660e-02f, 8.28957334e-02f, -4.83438447e-02f, -5.78048714e-02f, 4.81256694e-02f, 2.97977738e-02f, 1.05077289e-02f, 1.41116217e-01f, 6.26308545e-02f,
  2.27891817e-03f, 1.39443725e-01f, 5.80616184e-02f, -2.50790883e-02f, 3.08593810e-02f, 9.99557599e-02f, 4.63468470e-02f, -3.00374683e-02f, 8.67185369e-02f, -7.04033077e-02f,
  2.46018529e-01f, -1.63876280e-01f, -3.09839189e-01f, 7.12122023e-02f, 4.76918966e-02f, 5.49117863e-01f, 5.13206065e-01f, -1.43479943e-01f, -2.03608871e-01f, 6.88209534e-02f,
  1.97311565e-01f, -2.51318097e-01f, -1.24951057e-01f, 4.73420769e-01f, 2.54472584e-01f, -7.32796937e-02f, 3.50365281e-01f, 1.40586317e-01f, -1.37446374e-01f, -3.25727917e-04f,
  -6.17507659e-02f, 2.44497299e-01f, 5.21903411e-02f, -1.43625706e-01f, 2.27707058e-01f, -2.25390598e-01f, 1.92039460e-01f, -2.70712554e-01f, 2.22795457e-01f, 7.81367496e-02f,
  4.18400615e-02f, -9.40573961e-02f, -8.06457400e-02f, -6.65879063e-03f, 7.60738403e-02f, 6.39506727e-02f, 4.26548272e-02f, -8.37666169e-03f, 1.62331816e-02f, -2.86339712e-03f,
  4.32687302e-05f, 3.13914716e-02f, -3.81175838e-02f, -7.95706064e-02f, 5.64722717e-02f, -3.08672562e-02f, -6.02142923e-02f, 4.87410054e-02f, -9.59434509e-02f, -2.01703217e-02f,
  -5.68926744e-02f, -3.39946011e-03f, 3.22672240e-02f, 1.18100932e-02f, -7.54551291e-02f, -5.24649657e-02f, -7.24378042e-03f, -1.96555331e-02f, 5.45469299e-02f, -1.36108324e-02f,
  6.52713329e-02f, 6.70788214e-02f, 6.71945214e-02f, 6.66729361e-02f, -7.19977543e-03f, 6.14313548e-03f, 2.81098019e-02f, -8.66549741e-03f, -2.46728733e-02f, -1.61295962e-02f,
  1.72872134e-02f, 2.96251476e-02f, -9.25056450e-03f, 9.79867801e-02f, 3.25911194e-02f, 3.16759162e-02f, -1.15800491e-02f, 4.50628735e-02f, 5.19467925e-04f, 2.04353202e-02f,
  -6.42928779e-02f, 5.45885898e-02f, -1.25300279e-02f, 9.52679738e-02f, -1.12756351e-02f, -3.31306010e-02f, 5.43620065e-02f, 1.77425630e-02f, 3.46198231e-02f, 1.00604128e-02f,
  4.36921343e-02f, -1.11967824e-01f, -6.29183277e-02f, -3.62463966e-02f, -3.53077501e-02f, -2.98161316e-03f, -5.04948683e-02f, -3.39027382e-02f, -7.11234286e-02f, 6.56869784e-02f,
  4.59708013e-02f, 2.31899172e-02f, -4.97259060e-03f, 7.75467828e-02f, -7.14329109e-02f, 1.75325051e-02f, 5.03433794e-02f, -4.13079970e-02f, 7.71075934e-02f, 1.80230744e-03f,
  2.38396022e-02f, 5.37562594e-02f, -8.07819664e-02f, -9.93514899e-03f, 5.93468621e-02f, 2.38750298e-02f, -5.73345162e-02f, -9.27032009e-02f, 7.63372928e-02f, -9.80981216e-02f,
  1.34324983e-01f, -2.12181479e-01f, -3.59016091e-01f, 1.90003193e-03f, 1.35890260e-01f, -4.37637746e-01f, -1.52075142e-01f, -2.04739571e-02f, -1.79266974e-01f, 3.37964483e-03f,
  1.44679487e-01f, -4.59069945e-02f, 1.89974651e-01f, -1.28495842e-01f, 1.06605366e-01f, -1.67166069e-01f, -1.59299389e-01f, -9.96002629e-02f, -3.38053890e-02f, 1.45669773e-01f,
  -5.21523133e-02f, 1.95222110e-01f, -1.82878062e-01f, 5.37414402e-02f, -4.74167615e-02f, -1.47914499e-01f, 3.32034856e-01f, 1.25637174e-01f, 4.39655110e-02f, 1.56710863e-01f,
  -7.25549832e-02f, 3.56028043e-02f, -6.83219060e-02f, -7.71134645e-02f, -2.50372607e-02f, -5.73000463e-04f, -6.21365681e-02f, 1.46238636e-02f, 3.79344337e-02f, -3.94078791e-02f,
  2.56760437e-02f, 3.70073458e-03f, 3.00961211e-02f, 9.34513845e-03f, -9.96659771e-02f, -4.15281951e-02f, -1.21459246e-01f, -7.77793378e-02f, -6.73047677e-02f, -1.21132120e-01f,
  -1.77893490e-01f, -1.86646506e-01f, -7.00256228e-02f, 5.61332842e-03f, -1.56130809e-02f, -7.45657533e-02f, -1.32461801e-01f, -4.00913544e-02f, -4.33272161e-02f, 2.66695060e-02f,
  -9.25389156e-02f, 1.15759790e-01f, -2.33309120e-02f, 9.26685892e-03f, 4.03791107e-02f, 8.24453607e-02f, -7.87647907e-03f, 6.68298900e-02f, 2.32867338e-02f, 4.09063660e-02f,
  4.49244715e-02f, -5.13913902e-03f, 1.39898174e-02f, -1.02257401e-01f, 7.27581680e-02f, -1.21433567e-03f, -2.18944829e-02f, -2.14704908e-02f, -2.23278012e-02f, -3.26101258e-02f,
  9.96427014e-02f, -3.37330848e-02f, 1.17979780e-01f, -3.00923381e-02f, -1.81667600e-02f, 8.12520534e-02f, 5.31629175e-02f, -1.20109506e-01f, 5.55743240e-02f, 1.43123537e-01f,
  8.68453979e-02f, 2.70432591e-01f, 6.63421750e-02f, -6.20790012e-02f, 5.15543669e-02f, -4.11318569e-03f, 3.49174701e-02f, -5.55513687e-02f, 9.87844821e-03f, 8.85537118e-02f,
  -7.03692436e-02f, -6.53726533e-02f, 9.96163189e-02f, 4.01916727e-02f, 1.76032558e-02f, 2.06557028e-02f, 1.26536861e-01f, 3.32882665e-02f, 7.92973042e-02f, 9.74912196e-02f,
  2.92435307e-02f, 6.22464605e-02f, 6.84579313e-02f, 3.98812070e-02f, 4.93894629e-02f, 4.31307927e-02f, 5.67917302e-02f, 1.37887243e-02f, 1.29874470e-02f, -3.17457132e-02f,
  2.15651412e-02f, 3.03279787e-01f, -3.70479047e-01f, -1.99244589e-01f, 1.97544768e-01f, 2.69899279e-01f, -2.87798315e-01f, 2.24593833e-01f, 1.30518362e-01f, 1.06415406e-01f,
  5.58995903e-02f, -3.88934650e-02f, -1.23336822e-01f, 6.96468726e-02f, -3.07979226e-01f, -2.74983168e-01f, -7.68656284e-03f, 9.49716568e-02f, 7.96188638e-02f, 6.97723031e-02f,
  -6.04398474e-02f, 1.77025944e-01f, -5.55315375e-01f, 2.24144682e-01f, 5.81260920e-02f, 8.08596425e-03f, -2.39584953e-01f, 3.52821797e-02f, 9.64448228e-03f, 6.81440979e-02f,
  5.92232682e-02f, 8.90758447e-03f, -1.21083055e-02f, -1.11997854e-02f, 2.54865550e-02f, -1.03295021e-01f, -2.50817258e-02f, -8.46196860e-02f, -9.15756375e-02f, -8.68495367e-03f,
  4.79157828e-02f, 6.09621443e-02f, 3.25990245e-02f, -3.75850615e-03f, 8.88184756e-02f, 3.67633663e-02f, 5.79566637e-04f, -2.49576382e-03f, 4.12627310e-02f, -9.38667264e-03f,
  -9.37223583e-02f, -1.31165698e-01f, 2.58117300e-02f, -1.62482020e-02f, -1.63981710e-02f, -1.48872770e-02f, -1.15300030e-01f, -3.64000686e-02f, 5.31249382e-02f, 1.25238225e-01f,
  -6.25321865e-02f, 1.54059594e-02f, -2.73553692e-02f, -3.39336470e-02f, 7.31063038e-02f, 8.92621931e-03f, 8.40920489e-03f, 1.64627749e-02f, 4.66008112e-02f, -2.55646799e-02f,
  -1.73480064e-03f, -3.76038887e-02f, 1.44164208e-02f, -5.83809279e-02f, -2.11315462e-03f, -5.60848527e-02f, -4.80443100e-03f, 1.17251657e-01f, -9.87075549e-03f, -1.06665976e-01f,
  4.05226685e-02f, 3.97451259e-02f, 2.31792592e-02f, -9.16737970e-03f, -1.13665387e-02f, -1.00405723e-01f, 1.33579850e-01f, -3.76414098e-02f, -1.38641791e-02f, -3.99983414e-02f,
  3.26013714e-01f, 3.31222177e-01f, 2.19376348e-02f, 9.71399620e-02f, 1.00892864e-01f, 1.01052463e-01f, 4.19454984e-02f, 3.91129814e-02f, 1.10649280e-01f, 7.90282786e-02f,
  8.91953111e-02f, -6.88547567e-02f, -2.69721408e-04f, 6.52032122e-02f, -4.44077477e-02f, -4.05178107e-02f, -9.66644436e-02f, 1.25493795e-01f, 4.11250144e-02f, 6.41255826e-02f,
  2.91977148e-03f, 5.84921613e-02f, -1.27604753e-01f, 1.41194806e-01f, -1.66686613e-03f, -1.91453174e-02f, 1.51055947e-01f, -4.59338240e-02f, -8.24829489e-02f, 6.40571415e-02f,
  -1.10265851e-01f, -1.91844046e-01f, 4.18030113e-01f, -1.32035777e-01f, -2.57677078e-01f, 2.35902831e-01f, 3.79852057e-01f, -2.72859156e-01f, 2.44693562e-01f, -2.54778028e-01f,
  -1.68686569e-01f, -1.49565294e-01f, 2.40180984e-01f, -1.56273499e-01f, 4.83993560e-01f, 3.58076960e-01f, 9.16402191e-02f, -6.92825392e-03f, 8.55883658e-02f, -1.38210461e-01f,
  1.51404336e-01f, -3.11415941e-01f, 9.42399427e-02f, -1.79029360e-01f, -2.85211951e-01f, -8.90402496e-02f, -2.49835595e-01f, 1.57537565e-01f, -2.67934114e-01f, -4.71271500e-02f,
  -5.66149205e-02f, -2.60870485e-03f, -1.14351645e-01f, 4.72108088e-02f, -1.02544665e-01f, 1.26418937e-02f, 4.18175310e-02f, 5.22619076e-02f, 5.26172295e-02f, -2.40485853e-04f,
  -7.61607438e-02f, -7.94448927e-02f, -1.05994053e-01f, -5.29778153e-02f, -1.00177689e-03f, 1.56881064e-02f, -2.17583403e-02f, -3.71465087e-02f, -3.63770127e-02f, 6.89949393e-02f,
  1.33620501e-01f, -2.41642110e-02f, 7.63544738e-02f, -5.42118773e-02f, 6.55874833e-02f, 1.39539480e-01f, 8.55324641e-02f, -2.59392988e-02f, 4.90395613e-02f, -4.21608351e-02f,
  2.82079764e-02f, 1.15403943e-01f, -1.18313655e-02f, -4.50690202e-02f, 3.74857299e-02f, -1.26647726e-01f, 1.02097027e-01f, -9.67995226e-02f, 8.60127881e-02f, -1.23100439e-02f,
  -9.43767577e-02f, -7.03863353e-02f, -5.75579004e-03f, 1.95212290e-02f, -6.59662485e-02f, -1.18627502e-02f, 3.60758305e-02f, -1.10399716e-01f, 2.78995968e-02f, -5.71125150e-02f,
  8.50800276e-02f, 3.58260348e-02f, -1.42601160e-02f, 1.87945794e-02f, 5.96135594e-02f, 2.43238895e-03f, -7.35243782e-02f, 4.53635938e-02f, 3.65232751e-02f, 8.24553147e-03f,
  -1.02339573e-01f, -1.08312003e-01f, -2.16954928e-02f, -5.38201667e-02f, -4.05449308e-02f, -5.18728495e-02f, 1.06082663e-01f, -4.25523613e-03f, 8.91904309e-02f, -8.32682848e-03f,
  -2.33694334e-02f, -2.93454994e-02f, -3.01174168e-02f, 6.10597781e-04f, 4.38178778e-02f, 3.27603519e-02f, 8.28290358e-03f, -3.11903134e-02f, -1.05815195e-01f, -4.79850620e-02f,
  -1.32198902e-02f, 1.30884573e-02f, 1.35957273e-02f, -6.79999739e-02f, -2.00275541e-03f, -5.74945547e-02f, -7.39188343e-02f, 1.44371301e-01f, -3.65155637e-02f, 6.31137565e-02f
};

// L0_fan_Wp_bar (Shape: 14 x 120)
const int L0_fan_Wp_bar_rows = 14;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  6.32359803e-01f, -7.93695077e-02f, 4.03182507e-01f, 4.51987796e-02f, -1.92947596e-01f, 1.17281549e-01f, 4.72073913e-01f, -5.78307211e-01f, -7.31020153e-01f, -1.18386254e-01f,
  -2.35014617e-01f, 6.21998727e-01f, 3.83452058e-01f, -2.21819833e-01f, 6.12967052e-02f, -2.18627274e-01f, -3.62814724e-01f, 6.77592382e-02f, -3.16083908e-01f, 1.02141105e-01f,
  -1.54200494e-01f, -5.24008512e-01f, 3.75221759e-01f, -5.21924675e-01f, 2.57107615e-01f, -3.91343273e-02f, -2.49378845e-01f, 3.87929112e-01f, -1.26297221e-01f, -5.76746538e-02f,
  7.21963942e-02f, -1.78186461e-01f, 2.22000182e-01f, -3.05811558e-02f, 3.52989137e-02f, 2.32479736e-01f, 3.47056866e-01f, 1.55583546e-01f, -5.58706261e-02f, 7.27084279e-02f,
  3.34001184e-01f, -6.18811697e-02f, -1.16332181e-01f, 4.17103022e-02f, -1.55831799e-01f, -1.04375631e-01f, -6.94272071e-02f, 1.35330960e-01f, 4.71981429e-02f, 2.76529133e-01f,
  2.31489718e-01f, 1.19382359e-01f, -1.88665628e-01f, -7.50628673e-03f, -1.22159801e-01f, -2.65261054e-01f, 2.15305164e-01f, 3.87369603e-01f, 6.26694560e-02f, -1.23478010e-01f,
  4.49877828e-02f, 7.56312013e-02f, 1.21458583e-01f, 4.16047163e-02f, -7.17007648e-03f, -2.06511125e-01f, -5.35358712e-02f, -2.92857997e-02f, -4.53970060e-02f, 3.69322039e-02f,
  -1.16038561e-01f, 4.49820310e-02f, -2.09698513e-01f, 1.45776737e-02f, 1.40100718e-01f, 5.72592132e-02f, 2.20777497e-01f, -7.24007795e-03f, -5.44343367e-02f, -4.95816469e-02f,
  -9.83831361e-02f, -7.13015199e-02f, -8.86892378e-02f, -1.74764898e-02f, -3.12332604e-02f, -2.05088425e-02f, -1.31900281e-01f, 1.32616952e-01f, -6.70139641e-02f, 1.34951979e-01f,
  -2.67377734e-01f, -4.65885013e-01f, -1.25792414e-01f, -2.72539128e-02f, 5.62427975e-02f, 7.90005773e-02f, 7.95418993e-02f, -1.48202375e-01f, -3.20714712e-02f, -6.80943131e-02f,
  1.46562114e-01f, 1.53662071e-01f, -1.10436060e-01f, 1.48634166e-01f, -7.22611696e-02f, -1.93635508e-01f, 1.06203727e-01f, 3.89400832e-02f, 4.95165819e-03f, -9.36707333e-02f,
  4.99966703e-02f, 7.34531786e-03f, 3.44975293e-02f, -1.07546389e-01f, -2.16737315e-01f, -1.52111808e-02f, -1.50487609e-02f, 4.18465734e-02f, -5.38964272e-02f, -2.53656004e-02f,
  -9.59938288e-01f, 3.01996797e-01f, -3.68034810e-01f, -3.07369083e-01f, -6.03528261e-01f, -1.94321916e-01f, -1.21562935e-01f, 7.20329359e-02f, 9.67120677e-02f, 7.00361073e-01f,
  5.17110005e-02f, 1.18880920e-01f, 6.60311520e-01f, -8.63323547e-03f, -2.39061445e-01f, 6.50415361e-01f, -2.70003378e-01f, -3.68574169e-03f, 7.84911513e-02f, -2.36192122e-01f,
  -2.07039490e-01f, -1.53754115e-01f, -2.97907978e-01f, 3.15667018e-02f, -7.14818537e-01f, -2.53752738e-01f, -3.74171585e-01f, -1.39707655e-01f, -4.65578169e-01f, -3.71530861e-01f,
  -5.58653414e-01f, -2.05911919e-01f, -2.57320642e-01f, -1.93365097e-01f, -2.06185848e-01f, -1.95551649e-01f, -1.62213579e-01f, 4.75893468e-02f, 3.77554111e-02f, 7.01138824e-02f,
  5.00201508e-02f, 7.29264915e-02f, 8.49865451e-02f, 1.55186221e-01f, -7.38843456e-02f, -6.07171729e-02f, -8.19432586e-02f, -1.64985344e-01f, 8.01065043e-02f, -8.74789283e-02f,
  -1.42914936e-01f, -1.30282044e-01f, -2.49745473e-01f, 9.54119582e-03f, -3.83599252e-01f, -1.41721264e-01f, -7.20150545e-02f, -1.42974034e-01f, -2.34970927e-01f, -1.38189867e-01f,
  7.46428519e-02f, -2.18209112e-03f, 1.89713147e-02f, 8.79706219e-02f, 6.84023127e-02f, -2.19255194e-01f, -3.99123244e-02f, -1.17337937e-02f, -1.85680594e-02f, -1.77213073e-01f,
  -4.38377559e-02f, -1.08700909e-01f, -4.92851473e-02f, -1.39015943e-01f, 4.06688116e-02f, 8.98761228e-02f, 1.04097590e-01f, -1.30778775e-01f, -1.84628938e-03f, -4.59399372e-02f,
  -1.99934710e-02f, -7.84168951e-03f, -1.63216099e-01f, -4.45685117e-03f, -8.59463364e-02f, 4.32096794e-02f, -1.52015146e-02f, -8.37411582e-02f, 7.72049651e-02f, -1.28155768e-01f,
  -7.58473933e-01f, -5.03540933e-01f, 7.80896321e-02f, -6.05395138e-02f, 5.73189743e-03f, 1.19166188e-02f, 8.65884423e-02f, -1.36687219e-01f, -1.01934448e-01f, 1.03515238e-01f,
  -1.57219190e-02f, 7.40427449e-02f, -2.91379869e-01f, 5.79913408e-02f, 1.86926633e-01f, -5.40573075e-02f, -5.15277013e-02f, 8.25857371e-02f, -2.05386236e-01f, -8.67330655e-02f,
  -1.48544135e-02f, 1.32944763e-01f, 2.12333158e-01f, -4.79734950e-02f, 4.82712574e-02f, -9.78733599e-02f, -1.25441998e-01f, 3.46347578e-02f, -2.96431869e-01f, 5.79824252e-03f,
  6.04046404e-01f, -8.37344587e-01f, 2.68464796e-02f, 3.70851457e-01f, 5.65922074e-02f, -5.66750467e-01f, 1.56396747e-01f, -4.61384714e-01f, 3.78071278e-01f, -7.75503516e-01f,
  -1.28396541e-01f, 7.82677010e-02f, 3.49696487e-01f, -6.35791004e-01f, 8.04255366e-01f, 4.06782985e-01f, -2.50513852e-01f, -3.15256625e-01f, 2.23959520e-01f, -2.36245841e-01f,
  2.58651346e-01f, -4.04515266e-01f, 3.19467366e-01f, -6.92246675e-01f, -2.65777081e-01f, -2.08722129e-01f, 1.81962714e-01f, 3.36602852e-02f, -6.75062299e-01f, 4.56600897e-02f,
  -1.35087505e-01f, 1.22318983e-01f, -2.60549374e-02f, -1.22561455e-01f, -1.03755735e-01f, -3.51878926e-02f, -1.40051380e-01f, 1.20520771e-01f, 1.48519725e-01f, 1.69435423e-02f,
  8.73337127e-03f, 1.18494919e-02f, -2.24682555e-01f, -1.56630576e-02f, -7.69986138e-02f, -1.63257599e-01f, 7.65255243e-02f, -7.45222252e-03f, -8.23528841e-02f, 5.63048432e-03f,
  8.27823505e-02f, -8.95927399e-02f, -3.18452083e-02f, -1.41189158e-01f, 1.93813220e-01f, -7.02579990e-02f, -1.99048314e-02f, 1.58061102e-01f, -6.72416314e-02f, 6.91525266e-02f,
  2.00838707e-02f, -1.91047825e-02f, -8.21436271e-02f, -1.66772261e-01f, -4.40674787e-03f, -2.00062711e-02f, -2.63766963e-02f, 2.32468341e-02f, 7.02849030e-02f, -2.32402068e-02f,
  -4.85108010e-02f, 1.17492126e-02f, -7.23343566e-02f, -2.36777812e-02f, -2.16014013e-02f, 1.33313000e-01f, 3.14374417e-02f, -2.63226125e-02f, 6.21979944e-02f, -8.62751901e-03f,
  6.64529577e-02f, -2.06288062e-02f, 2.08452158e-03f, 7.86393806e-02f, -4.92218882e-02f, 9.38536301e-02f, -3.57301645e-02f, 2.23257747e-02f, 2.85111321e-03f, 8.47572386e-02f,
  -1.93288848e-02f, -3.16104352e-01f, 1.59162947e-03f, -9.33550820e-02f, -6.61904588e-02f, -1.95244819e-01f, -6.91926181e-02f, -1.88320324e-01f, 3.32311355e-02f, -4.54515442e-02f,
  -2.31154203e-01f, 9.00519490e-02f, -7.79561102e-02f, 1.31658480e-01f, -5.06142788e-02f, -6.16525523e-02f, -1.73337162e-02f, -6.82250336e-02f, -5.38837798e-02f, -1.11098930e-01f,
  -4.07588072e-02f, 8.16119015e-02f, 5.03163338e-02f, 6.04208708e-02f, -1.06221601e-01f, -4.11164016e-04f, -2.42838766e-02f, -2.53084172e-02f, 6.19088560e-02f, -2.26944312e-02f,
  -2.56619424e-01f, -5.71018279e-01f, -1.12976231e-01f, 7.28475153e-02f, 2.79673517e-01f, -1.69821605e-01f, -3.58335078e-01f, 1.51124179e-01f, -4.32598293e-01f, -1.14764132e-01f,
  -2.31816550e-03f, -6.37022972e-01f, -2.95317411e-01f, -5.84130883e-01f, -1.00384936e-01f, -6.50692582e-01f, -7.11991414e-02f, -3.01777303e-01f, -2.97985405e-01f, 3.15131456e-01f,
  1.73811004e-01f, 1.95632279e-01f, 2.00504601e-01f, 7.18707204e-01f, 2.38174573e-01f, 5.06871045e-01f, 7.27429271e-01f, 3.37364316e-01f, 5.15801072e-01f, -8.86100158e-02f,
  -1.37215480e-01f, -1.86902359e-01f, -8.31838101e-02f, -1.34299397e-01f, 3.05902928e-01f, 1.95902586e-01f, 2.20351979e-01f, -3.86546887e-02f, 7.01841787e-02f, -6.77806437e-02f,
  -5.34210317e-02f, 1.70139167e-02f, -8.36201161e-02f, -4.22023423e-02f, -9.35790613e-02f, -6.13913164e-02f, -1.42426506e-01f, -2.83244066e-03f, -6.59055859e-02f, -1.48179159e-01f,
  -2.10499056e-02f, -1.08031854e-02f, 9.97946486e-02f, 7.38143176e-02f, 1.19701348e-01f, -2.41505988e-02f, 1.18254714e-01f, 2.19824210e-01f, -1.01323031e-01f, 1.02983169e-01f,
  1.43593848e-01f, 1.01621471e-01f, -5.84999509e-02f, -1.87418938e-01f, -9.61657092e-02f, -4.78044897e-02f, -6.64534420e-02f, 7.15193674e-02f, -7.07238391e-02f, -1.93020720e-02f,
  1.58731669e-01f, -2.48535573e-02f, -2.12436900e-01f, 8.65766928e-02f, 1.92405999e-01f, -1.04728274e-01f, 1.25092804e-01f, 1.75989624e-02f, 1.94284335e-01f, -3.81460935e-02f,
  -1.36854559e-01f, 2.80116033e-02f, 2.85270587e-02f, 6.40949458e-02f, -2.31203288e-01f, 1.64766595e-01f, 1.18759833e-01f, -5.01815341e-02f, 5.06372042e-02f, 6.46601841e-02f,
  1.96719751e-01f, 2.87691295e-01f, -6.60591060e-03f, 5.74021088e-03f, -1.33276999e-01f, 3.02861575e-02f, -1.32732436e-01f, -1.91423930e-02f, 7.29428008e-02f, -1.00951292e-01f,
  3.35697442e-01f, 1.99828595e-01f, 1.73728075e-02f, -8.86930451e-02f, 1.32078126e-01f, 3.23402844e-02f, 1.84051439e-01f, 2.43876234e-01f, 2.28108868e-01f, 2.57954419e-01f,
  2.46101603e-01f, 1.23592511e-01f, -1.30729705e-01f, 1.72930390e-01f, 5.68378493e-02f, 4.98440750e-02f, 1.84981618e-02f, 4.57965657e-02f, -4.82862704e-02f, -9.57192406e-02f,
  -8.68035555e-02f, -7.06407130e-01f, -2.56435186e-01f, 2.84358859e-01f, 7.27883130e-02f, 3.84005189e-01f, 2.95784444e-01f, -4.21389639e-01f, -1.80502072e-01f, -3.47457260e-01f,
  -2.24602267e-01f, 2.29895025e-01f, -5.45998931e-01f, 4.07905817e-01f, 2.28118420e-01f, -4.25113410e-01f, 8.37090313e-02f, 1.65147632e-01f, -1.43215716e-01f, -4.15815771e-01f,
  -2.52511054e-01f, 1.09239921e-01f, -1.23492271e-01f, 1.55306652e-01f, 9.84248444e-02f, 3.34436029e-01f, 1.05464391e-01f, 5.47354221e-02f, 6.24406457e-01f, 4.52404320e-01f,
  -3.87240052e-02f, -1.53209239e-01f, -3.85038066e-03f, -1.09841079e-02f, -1.86631009e-01f, 2.94400156e-02f, 1.50422692e-01f, 2.98990607e-01f, 2.09212437e-01f, -4.66651134e-02f,
  -7.45667284e-03f, 2.98752457e-01f, 2.51327634e-01f, 4.96417433e-02f, 2.41123252e-02f, 1.55319542e-01f, 9.94640142e-02f, -2.06194714e-01f, -7.15150610e-02f, -2.39297479e-01f,
  -2.43176669e-01f, -2.09689990e-01f, 2.72391830e-02f, 1.01110764e-01f, -1.39293931e-02f, 1.00821024e-02f, -1.10221570e-02f, -8.79488662e-02f, 6.48281127e-02f, 1.71109483e-01f,
  -8.73094425e-02f, 6.71921745e-02f, -1.21914089e-01f, 1.73537016e-01f, 4.83780541e-02f, 2.23650977e-01f, -2.65851337e-02f, 9.55522284e-02f, 7.23545626e-02f, -1.73085451e-01f,
  -4.88232858e-02f, 7.66549185e-02f, -1.21546216e-01f, 1.40613958e-01f, -8.09800103e-02f, -5.62414750e-02f, 1.33728966e-01f, 1.29932314e-01f, -9.79474932e-02f, -2.27034092e-02f,
  5.05619980e-02f, 1.27489671e-01f, -6.04069866e-02f, 6.36707544e-02f, 9.65710543e-03f, -2.53310114e-01f, 9.26016271e-03f, -2.21444201e-02f, -1.90329596e-01f, -1.46927470e-02f,
  -2.91439742e-01f, -4.47883070e-01f, 2.63806637e-02f, 7.11415410e-02f, 1.43352062e-01f, -8.47419053e-02f, 5.32306544e-02f, -6.93085268e-02f, -1.38063714e-01f, -5.28982840e-02f,
  -1.97482735e-01f, 1.37375876e-01f, -1.72544806e-03f, 1.67022750e-01f, 1.73745558e-01f, -2.49294922e-01f, -1.32265044e-02f, -6.84568509e-02f, -4.80886139e-02f, -1.35690800e-03f,
  -1.44441668e-02f, -2.20010127e-03f, 2.18063384e-01f, -1.39148682e-01f, 5.11542335e-03f, 2.65534483e-02f, 1.26662897e-02f, 3.95119339e-02f, 2.64773183e-02f, 1.02022372e-01f,
  -1.82036117e-01f, 1.15858644e-01f, 5.04517376e-01f, 5.76700151e-01f, -4.77359802e-01f, -9.15705144e-01f, -7.35036612e-01f, -3.61560553e-01f, -9.30369645e-02f, -5.05682647e-01f,
  -5.20001352e-01f, 7.38797843e-01f, -7.40080833e-01f, 5.95621049e-01f, 4.92616475e-01f, -2.13375956e-01f, 8.83744285e-02f, 5.47042228e-02f, 2.28997067e-01f, -4.40268923e-04f,
  3.67358327e-01f, 4.12088856e-02f, 4.34313446e-01f, 1.87943399e-01f, 2.48697579e-01f, 4.72244322e-01f, 4.54778284e-01f, 2.63605416e-01f, 7.40881741e-01f, 2.06415653e-01f,
  -2.92436719e-01f, -6.86002895e-02f, 1.48171932e-01f, 1.04170658e-01f, -2.16906622e-01f, -1.69017091e-01f, 5.11578619e-02f, -8.67510960e-03f, 1.06036946e-01f, -2.40709889e-03f,
  -3.03473696e-02f, 1.06050968e-01f, 1.91602260e-01f, 3.94052751e-02f, -1.64165825e-01f, 2.05571428e-01f, 1.73207089e-01f, -1.48545906e-01f, 7.15733469e-02f, -1.17351394e-02f,
  1.39667422e-01f, -6.38800487e-02f, -6.75861761e-02f, 7.61396438e-02f, 1.96171209e-01f, -1.61307186e-01f, 1.82861149e-01f, 5.73745407e-02f, 2.63154984e-01f, 1.19244106e-01f,
  -9.70410630e-02f, 1.27291027e-02f, -1.26128942e-01f, -1.45199105e-01f, -8.21179822e-02f, -6.33117091e-03f, 8.58473480e-02f, -2.15930976e-02f, 1.36846185e-01f, -1.86293572e-01f,
  -4.63077165e-02f, 9.71621424e-02f, -3.85039742e-03f, -1.28510907e-01f, -5.70428595e-02f, -5.65052219e-02f, -8.73943120e-02f, -5.63199446e-02f, 1.66886337e-02f, 8.89492109e-02f,
  -4.34880378e-03f, 2.22108457e-02f, 1.41291181e-02f, -4.72569317e-02f, -1.77357852e-01f, -1.09343044e-01f, 6.85478896e-02f, -3.13276537e-02f, 1.20433317e-02f, 5.37756830e-02f,
  -2.80244768e-01f, 2.97169626e-01f, 6.33526072e-02f, -4.85748462e-02f, 1.87127352e-01f, 4.99795415e-02f, 1.56167895e-01f, 4.02371213e-02f, 8.93803835e-02f, 5.03302738e-02f,
  -1.73880056e-01f, 6.07361225e-03f, -1.08058549e-01f, -3.15869972e-03f, 1.07645191e-01f, -5.21054305e-02f, -4.66625951e-02f, 8.32537860e-02f, 4.75750193e-02f, 1.31417215e-01f,
  -3.18879411e-02f, -1.40111357e-01f, 3.81961428e-02f, 1.88385323e-01f, -5.84013164e-02f, -8.78846347e-02f, 4.30735014e-02f, 9.48986337e-02f, 1.75726846e-01f, 8.56530294e-02f,
  -2.54582584e-01f, 6.06479704e-01f, -2.00129330e-01f, 6.36214137e-01f, -3.92431021e-01f, 2.79273570e-01f, 4.53798652e-01f, 2.13320807e-01f, 2.02116832e-01f, 6.10003114e-01f,
  4.64822173e-01f, -7.31378645e-02f, 4.50328737e-01f, 7.98444986e-01f, 1.18089415e-01f, 5.91831088e-01f, 6.33926630e-01f, 3.82076502e-01f, -8.96345973e-02f, 2.76697457e-01f,
  2.36710444e-01f, 5.41024268e-01f, 2.74505287e-01f, -2.50332430e-02f, 3.16523947e-02f, -1.83003709e-01f, 1.86479971e-01f, -3.32780331e-01f, 2.11454734e-01f, -1.50026917e-01f,
  2.83591077e-02f, 9.15311351e-02f, -8.20871741e-02f, -1.48699328e-01f, 2.34243553e-02f, -2.15050414e-01f, -4.68928255e-02f, -1.51827186e-01f, -1.45130664e-01f, 1.25696836e-02f,
  -4.81425412e-02f, -9.75007564e-02f, 1.06207706e-01f, -1.80938803e-02f, -1.68071479e-01f, -1.13142379e-01f, -3.33988518e-02f, 3.06070317e-02f, 4.61775400e-02f, -7.44393393e-02f,
  -7.27698654e-02f, -2.81787999e-02f, 8.02136734e-02f, 7.74193555e-02f, -6.77814484e-02f, 5.48548065e-02f, 1.44408956e-01f, -5.68316765e-02f, 3.32474778e-03f, 3.56236584e-02f,
  -7.41105005e-02f, 4.99532484e-02f, 8.36588889e-02f, -2.22737071e-04f, -6.06694929e-02f, 9.29568894e-03f, 6.01886734e-02f, 9.95776132e-02f, -1.51427969e-01f, 9.86654907e-02f,
  -8.43103454e-02f, -1.75867435e-02f, 7.36363903e-02f, 5.85537739e-02f, 1.29779652e-01f, 3.69716808e-02f, -7.53462315e-02f, -4.28416915e-02f, 3.13619338e-02f, -9.28139035e-03f,
  3.48061919e-02f, 7.05583915e-02f, 3.42225330e-03f, -7.88805708e-02f, 5.52442595e-02f, -1.93738341e-02f, 1.38428926e-01f, -6.75881933e-03f, -3.67880017e-02f, -8.66859034e-03f,
  3.15085173e-01f, 6.72843814e-01f, 1.63454175e-01f, -1.06284857e-01f, 3.77309024e-02f, 8.35837945e-02f, 9.29642916e-02f, -1.56162307e-02f, 1.70539767e-01f, 8.66032764e-02f,
  -1.08007044e-01f, -2.57858657e-03f, 8.02467912e-02f, -9.53234732e-02f, -2.99628228e-02f, 2.34818742e-01f, 2.54103392e-01f, -7.45695978e-02f, 1.29440263e-01f, 3.22581292e-03f,
  7.24841431e-02f, 2.69527547e-02f, -2.01498922e-02f, -6.83657825e-02f, 5.67529947e-02f, -2.09824555e-02f, 2.83182841e-02f, -9.43210050e-02f, -3.83687951e-02f, 1.63592190e-01f,
  5.67875266e-01f, -4.04385030e-01f, -3.56258512e-01f, 3.57091159e-01f, 5.47006190e-01f, -1.55961186e-01f, -1.14236355e-01f, 4.15827602e-01f, -1.03074580e-01f, -1.94462344e-01f,
  3.25658649e-01f, -4.93621022e-01f, -4.85778362e-01f, 3.03228170e-01f, 2.35281274e-01f, -6.74513161e-01f, 5.31807780e-01f, -2.93852594e-02f, -2.64210682e-02f, 3.33198369e-01f,
  3.37676555e-01f, 6.03020430e-01f, 1.03641495e-01f, 3.96810174e-01f, 2.57903963e-01f, 2.29245499e-01f, 3.79169405e-01f, -3.15752417e-01f, 2.11221740e-01f, 5.59516512e-02f,
  -5.07582561e-04f, 6.94882944e-02f, 7.23421350e-02f, -1.93997204e-01f, 1.48773164e-01f, 1.60185844e-01f, -1.37839466e-01f, -3.04633696e-02f, -8.16604570e-02f, -8.56445208e-02f,
  -1.43200561e-01f, 4.17794026e-02f, 2.21070480e-02f, -4.92682606e-02f, 2.36389890e-01f, 9.63580981e-02f, -2.48599704e-02f, -1.42970711e-01f, -1.34692073e-01f, -1.13407880e-01f,
  -1.33007050e-01f, -1.27747223e-01f, 1.69082254e-01f, -1.46768391e-01f, -1.26162231e-01f, 7.78251812e-02f, -2.44323328e-05f, -1.21525213e-01f, -4.82109934e-03f, 9.30628255e-02f,
  6.85026795e-02f, -2.13845205e-02f, -8.73413123e-03f, -7.40365833e-02f, 3.39721479e-02f, 4.18650173e-03f, 1.06486417e-01f, -8.85288715e-02f, 2.95443758e-02f, 3.94569486e-02f,
  1.70857444e-01f, 2.49921018e-03f, 8.74862447e-02f, -3.07050291e-02f, 4.95751388e-02f, 1.12805150e-01f, 1.18788760e-02f, -1.70829773e-01f, 2.09806599e-02f, -1.22010596e-01f,
  2.02905722e-02f, 7.74014592e-02f, -1.00116901e-01f, -1.20151350e-02f, 9.74318236e-02f, -1.81267068e-01f, 3.50917876e-02f, 3.06043532e-02f, -4.60241884e-02f, 1.00409351e-01f,
  -1.59445088e-02f, -5.41220009e-02f, -9.59821641e-02f, -1.36895284e-01f, -8.46888348e-02f, 2.80197948e-01f, -5.91858625e-02f, 3.43838967e-02f, -1.54084787e-02f, -1.51838483e-02f,
  1.63760945e-01f, 8.35136771e-02f, 6.47900254e-02f, 6.70661032e-02f, 1.31841049e-01f, 1.05121247e-01f, -5.95499650e-02f, 4.18496281e-02f, 1.56650379e-01f, 7.43856505e-02f,
  4.66546975e-02f, 6.33258522e-02f, 1.51622921e-01f, -9.68786329e-03f, 2.61266548e-02f, 5.67767164e-03f, 3.51250842e-02f, 3.65414657e-02f, -2.50265487e-02f, -9.06138197e-02f,
  -8.57616842e-01f, 6.88250959e-01f, 1.25666596e-02f, 4.29160930e-02f, 7.55183548e-02f, -7.71603286e-01f, -3.63422446e-02f, 2.53738791e-01f, 2.36643195e-01f, 4.91120398e-01f,
  4.00445998e-01f, 4.30083424e-01f, 3.49416316e-01f, 2.76432574e-01f, -6.70059562e-01f, -1.94144487e-01f, -4.14026499e-01f, -1.92809835e-01f, -6.52459562e-02f, 3.30584608e-02f,
  -3.41892153e-01f, 1.25549018e-01f, 5.18638454e-02f, 3.72075468e-01f, 2.97380656e-01f, 8.66280049e-02f, -6.71856403e-02f, 3.61542076e-01f, -3.87846516e-03f, 2.28302032e-01f,
  -1.39581457e-01f, 4.46040422e-01f, 2.14223936e-01f, 4.32364084e-02f, -2.89937317e-01f, -7.78957978e-02f, -9.99493301e-02f, 1.22527242e-01f, 2.55349688e-02f, -3.98455895e-02f,
  5.83296232e-02f, 7.24565014e-02f, 7.47084022e-02f, 4.08866778e-02f, 9.61127132e-02f, 6.92282170e-02f, 1.73557296e-01f, -1.44016609e-01f, 1.88218623e-01f, 2.11818200e-02f,
  2.04810917e-01f, -1.05725318e-01f, -1.84397742e-01f, -2.62716692e-02f, 7.04376996e-02f, 1.73352718e-01f, -2.08293557e-01f, -6.53870683e-03f, -1.19762786e-01f, -4.36472632e-02f,
  2.12489530e-01f, -2.71646440e-01f, -1.41105838e-02f, -1.47957979e-02f, 1.03122115e-01f, 5.85379452e-02f, 1.97056666e-01f, 4.12299894e-02f, -7.05827624e-02f, 1.13128461e-01f,
  -9.95123908e-02f, -1.81882852e-03f, 5.96201941e-02f, -2.22780690e-01f, -8.44526589e-02f, -7.12704808e-02f, 1.06443549e-02f, 8.84532928e-02f, -1.21935837e-01f, -1.08424976e-01f,
  1.88494369e-01f, -5.57283983e-02f, 6.68600947e-02f, -1.42131060e-01f, -1.24411337e-01f, 6.37895241e-02f, -8.52327719e-02f, -5.05482145e-02f, -6.38110787e-02f, -9.67053995e-02f,
  -5.66616833e-01f, -9.73803550e-03f, 1.41514927e-01f, 1.22206114e-01f, -3.07806078e-02f, -5.23830615e-02f, -1.31327912e-01f, -9.87028107e-02f, -6.55481815e-02f, -9.32621285e-02f,
  -1.37775242e-01f, -8.51966441e-02f, -4.73280847e-01f, 2.85468455e-02f, 1.80611853e-02f, -1.61985576e-01f, 2.56385170e-02f, 2.07813736e-03f, -1.80260509e-01f, -5.46489544e-02f,
  4.35774699e-02f, 1.49617642e-01f, -6.49595410e-02f, 4.63113785e-02f, 5.01428656e-02f, -4.44772616e-02f, 3.14525887e-02f, 5.82654104e-02f, 2.04405878e-02f, -1.56422496e-01f,
  5.63767850e-01f, 3.75032902e-01f, -3.06229532e-01f, -3.04493785e-01f, -9.60774347e-02f, 3.28730404e-01f, -4.71099585e-01f, 1.07293762e-01f, -5.51784039e-01f, 2.17696369e-01f,
  1.07508756e-01f, 2.75439411e-01f, -5.87795198e-01f, 5.77080309e-01f, 1.15579747e-01f, -3.24964851e-01f, 4.77706909e-01f, 3.60040605e-01f, 6.25859052e-02f, 4.90946889e-01f,
  1.28007114e-01f, 6.08714044e-01f, 1.33861795e-01f, 6.25945270e-01f, 6.65055096e-01f, 2.83269376e-01f, -4.05692756e-02f, -2.65362233e-01f, 5.05722821e-01f, 1.62585571e-01f,
  8.59112740e-02f, -1.28941955e-02f, -9.38084413e-05f, 4.60045598e-02f, -7.01060593e-02f, 8.25706497e-02f, 7.78651685e-02f, -2.88334526e-02f, -1.90971389e-01f, -6.74012378e-02f,
  2.92922426e-02f, 5.80528229e-02f, 2.25466803e-01f, -1.84059903e-01f, 8.11456144e-02f, -4.11436185e-02f, -1.04846105e-01f, 2.19199620e-02f, -1.23322643e-01f, 2.45506689e-01f,
  -1.20503843e-01f, 1.33960098e-01f, -3.32651287e-02f, -1.07905604e-01f, -6.19071089e-02f, -3.37714441e-02f, -1.18264623e-01f, -6.69758813e-03f, 1.40292779e-01f, 9.02555436e-02f,
  1.42852172e-01f, -8.44729915e-02f, 4.71987799e-02f, -3.48258466e-02f, 4.15056646e-02f, -1.80085570e-01f, 4.66949381e-02f, -1.94943696e-02f, -7.88770914e-02f, 7.66929910e-02f,
  -1.44404903e-01f, -1.83865428e-03f, -1.35820702e-01f, 1.31664025e-02f, 1.69199720e-01f, 1.06144793e-01f, -5.13493977e-02f, 1.49464402e-02f, -1.27238095e-01f, 1.12064630e-02f,
  -1.47866786e-01f, 2.79298648e-02f, -3.48421298e-02f, -6.79605603e-02f, 5.08099869e-02f, -1.00918412e-01f, 1.85715303e-01f, 5.77532127e-02f, -2.28273980e-02f, -3.94372791e-02f,
  1.20826654e-01f, 1.12200163e-01f, -1.36039734e-01f, -2.94197556e-02f, -1.15071379e-01f, 2.32910007e-01f, 5.34788147e-02f, 2.16490164e-01f, 3.95109877e-02f, -1.10788243e-02f,
  5.59173385e-03f, -6.18711710e-02f, -4.49393922e-03f, -3.16791236e-02f, -1.35702565e-01f, 2.30067298e-02f, -1.20145455e-01f, -2.24438995e-01f, -4.75334525e-02f, 1.64419606e-01f,
  8.75518546e-02f, -1.00159191e-01f, 1.67817175e-02f, -7.68159926e-02f, -1.52157359e-02f, -1.79937795e-01f, 1.38622448e-01f, 1.20624050e-01f, 8.66957828e-02f, -9.37544182e-02f,
  8.23572695e-01f, 1.88581347e-01f, 4.14963454e-01f, 8.48765373e-01f, 2.20068887e-01f, -6.18714273e-01f, -1.49726808e-01f, 1.88372642e-01f, 6.98348463e-01f, -2.03928024e-01f,
  -1.32168412e-01f, 2.70396583e-02f, -5.06764650e-01f, 1.94300696e-01f, -7.63674498e-01f, -5.25569558e-01f, -3.89056504e-02f, -1.53467596e-01f, 1.94516867e-01f, 1.32259697e-01f,
  2.83244103e-01f, -2.73221791e-01f, 7.28619397e-02f, -5.62867597e-02f, 5.99708915e-01f, 4.78465706e-01f, -1.62888706e-01f, -1.59734324e-01f, 4.19194661e-02f, -4.75699246e-01f,
  -1.15167245e-01f, 3.62447917e-01f, 2.19605088e-01f, -2.51247007e-02f, 1.42971158e-01f, 2.89059035e-03f, -4.47393730e-02f, -2.70976216e-01f, 5.50317466e-02f, 4.24508238e-03f,
  5.18261502e-03f, -4.51037213e-02f, 5.49610443e-02f, -1.28074914e-01f, 1.81479037e-01f, 1.49805382e-01f, 2.42926762e-01f, 3.52182031e-01f, 2.12119505e-01f, 2.07806960e-01f,
  2.92489588e-01f, 7.70874768e-02f, 2.31864095e-01f, -4.88488264e-02f, 2.01673329e-01f, 6.73381761e-02f, -8.39263201e-02f, -7.29142949e-02f, 5.00824563e-02f, 9.20005366e-02f,
  9.89493099e-04f, -6.06484450e-02f, -6.82227835e-02f, 1.05647847e-01f, 3.94521281e-02f, 2.04848260e-01f, -7.08700642e-02f, -9.89511535e-02f, 1.63278207e-02f, -8.91174003e-02f,
  9.16723460e-02f, 1.31276116e-01f, 5.64267002e-02f, 1.32128954e-01f, 1.14733599e-01f, 2.35543817e-01f, -2.53441572e-01f, -9.76468902e-03f, 1.51877284e-01f, 4.83352877e-02f,
  -8.79200324e-02f, -1.14764430e-01f, -7.64582232e-02f, -2.52258163e-02f, -9.77458730e-02f, 6.86114305e-04f, 1.81903929e-01f, 1.26913831e-01f, -6.40413314e-02f, -8.22724253e-02f,
  -2.92980105e-01f, -2.35804796e-01f, 1.32854627e-02f, -3.66832137e-05f, -1.43486351e-01f, -2.47719698e-02f, -5.32222055e-02f, 1.02369860e-01f, -2.07348466e-01f, -5.18342182e-02f,
  6.69521242e-02f, 1.06003724e-01f, -5.83814755e-02f, -5.16987592e-02f, -2.36744240e-01f, -3.77226854e-03f, 6.49906397e-02f, 1.80242583e-02f, -1.14182904e-01f, -3.60760577e-02f,
  1.47676423e-01f, -7.89544806e-02f, -6.98101893e-02f, 1.88107550e-01f, 1.07697723e-02f, -4.41550612e-02f, -9.19315070e-02f, -6.02926463e-02f, -4.84118275e-02f, -9.89055261e-02f,
  -7.97647655e-01f, -1.91919714e-01f, 6.29505992e-01f, -7.14023530e-01f, 3.92098308e-01f, 8.51905227e-01f, 1.11138493e-01f, 1.48404315e-01f, -5.20143986e-01f, -4.59357291e-01f,
  -8.78456980e-02f, -2.07598373e-01f, 6.96495548e-02f, -1.23866953e-01f, 7.98633337e-01f, 2.10044861e-01f, -1.14351235e-01f, -3.74071985e-01f, 4.26529441e-03f, -2.27946654e-01f,
  -5.14769107e-02f, -2.53584236e-02f, 4.43138182e-01f, 1.94081724e-01f, 3.12711820e-02f, -2.60442019e-01f, -2.02750713e-01f, 3.92996669e-01f, 8.69354233e-02f, 3.15813184e-01f,
  2.18056127e-01f, -5.84951222e-01f, 4.05875072e-02f, -4.88090105e-02f, 5.73480949e-02f, -7.71639869e-02f, 2.95224264e-02f, 1.34656906e-01f, -2.70846747e-02f, 1.97371561e-02f,
  -1.31504968e-01f, 1.55329868e-01f, -1.87065512e-01f, 2.66744047e-02f, -1.36507064e-01f, 9.19150282e-03f, 2.02950001e-01f, 7.70886168e-02f, 1.80322491e-02f, 2.23272815e-01f,
  1.68096423e-01f, 6.14399910e-02f, -1.08126197e-02f, -9.09065083e-02f, 1.54715791e-01f, 2.47924048e-02f, 4.06778455e-02f, 1.02659255e-01f, -1.55104147e-02f, 3.17572206e-02f,
  -1.07505053e-01f, -2.65015699e-02f, 2.41631716e-02f, -4.75811884e-02f, 7.10200891e-02f, 1.93656236e-02f, -1.09917641e-01f, 7.51907751e-02f, -4.44337130e-02f, 4.18557152e-02f,
  4.12157737e-02f, -7.05768168e-02f, -6.17060363e-02f, 1.75537448e-02f, -1.04938827e-01f, -1.91006407e-01f, -3.06433737e-02f, -1.01043070e-02f, 4.54793572e-02f, 8.95262063e-02f,
  -1.13724105e-01f, 9.92499478e-03f, 2.73504630e-02f, -5.82927167e-02f, 8.49284604e-02f, 1.33071363e-01f, -9.87525377e-03f, 8.18250477e-02f, -7.40431100e-02f, 1.19113684e-01f,
  -1.87814817e-01f, -5.65916359e-01f, -6.06747679e-02f, -5.98113760e-02f, 1.86136495e-02f, 7.59350657e-02f, -1.17387705e-01f, -2.95158904e-02f, -8.64234939e-02f, -8.97906795e-02f,
  -2.21065488e-02f, -1.31774336e-01f, -2.00106129e-02f, 4.69379239e-02f, -2.26034503e-02f, 1.07498221e-01f, -1.35874957e-01f, -1.20612502e-01f, 3.51779498e-02f, -3.15780751e-03f,
  -2.77474336e-02f, -2.26410925e-01f, 7.32335225e-02f, -1.03817843e-01f, -9.77366492e-02f, -5.46162874e-02f, -1.45133346e-01f, -6.00345060e-02f, 5.31680994e-02f, 2.68883945e-04f,
  6.63978830e-02f, 5.51400818e-02f, -2.93539673e-01f, -3.25598568e-02f, -3.16958070e-01f, -7.17871562e-02f, -2.28806119e-02f, -3.40550810e-01f, 3.52918245e-02f, 3.47504437e-01f,
  5.94102889e-02f, 1.57431573e-01f, -1.58584371e-01f, 6.01599574e-01f, 1.91293374e-01f, 3.72088641e-01f, 4.18946177e-01f, 3.87211442e-01f, 1.05775930e-01f, -6.19295798e-02f,
  1.53384954e-01f, 5.61776996e-01f, -1.25108743e-02f, -5.98974666e-03f, -1.82228863e-01f, -2.84635454e-01f, 7.30644017e-02f, -3.30086410e-01f, 1.59923360e-01f, 1.18908688e-01f,
  1.25865132e-01f, 2.98143029e-02f, -8.66694003e-02f, 1.37962952e-01f, 7.29798079e-02f, -6.21321239e-02f, -7.20387101e-02f, -9.93176624e-02f, -2.06468329e-01f, 2.90071480e-02f,
  5.85512817e-02f, 5.24028726e-02f, 1.45347416e-01f, 7.49880541e-03f, -1.37305353e-02f, -1.52459731e-02f, 4.80085649e-02f, -7.52764866e-02f, -1.20072745e-01f, -6.39965385e-02f,
  -9.81025696e-02f, 1.28591180e-01f, -1.73232794e-01f, 2.11620271e-01f, -1.28759816e-01f, 8.55724886e-02f, 8.67371857e-02f, -1.20954365e-01f, 1.04506262e-01f, 1.47663862e-01f,
  6.84704036e-02f, 1.08436026e-01f, 1.35737369e-02f, 5.48884198e-02f, 1.21554427e-01f, -5.03848940e-02f, 3.37349214e-02f, -1.06938649e-02f, -1.67281348e-02f, 4.27332856e-02f,
  1.06862979e-02f, -1.72387868e-01f, -3.08635295e-03f, 1.72647946e-02f, 7.51750171e-02f, 1.14107758e-01f, -7.19726905e-02f, 1.81341395e-02f, -1.18799187e-01f, -6.61612973e-02f,
  4.51707281e-02f, -6.60866275e-02f, 4.84834798e-02f, -1.31781712e-01f, 2.08641961e-02f, -9.21955854e-02f, 1.25771448e-01f, -2.00362895e-02f, -1.87287956e-01f, -1.98000312e-01f,
  6.85987398e-02f, 2.22931653e-01f, -8.79160687e-02f, 8.06887075e-02f, -2.22843830e-02f, 1.06947131e-01f, -3.00078299e-02f, 5.55080734e-02f, 1.00626394e-01f, -1.70395877e-02f,
  1.67436495e-01f, -1.97555032e-03f, 2.49810517e-02f, -1.29800454e-01f, -6.03600219e-02f, 3.35557237e-02f, 3.59563641e-02f, 6.08539432e-02f, -7.14670867e-02f, -2.35715900e-02f,
  -4.78617586e-02f, -1.65443607e-02f, 8.95123929e-02f, -4.66610305e-02f, 7.90348202e-02f, 2.95787100e-02f, -1.13187864e-01f, -2.58280616e-02f, -8.65210369e-02f, 9.47527066e-02f,
  1.55644029e-01f, 3.35976452e-01f, -4.35747266e-01f, -6.67988360e-01f, -1.51281767e-02f, -4.74758148e-01f, -6.32277369e-01f, -1.50832996e-01f, -3.13840121e-01f, -2.20134526e-01f,
  -3.46946806e-01f, -2.61058509e-01f, 2.07133234e-01f, -3.98114234e-01f, -5.45906089e-02f, 3.06111395e-01f, -6.38260961e-01f, -3.90671819e-01f, 2.87653327e-01f, -2.33138546e-01f,
  -3.98284644e-02f, -5.12309223e-02f, -1.33483633e-01f, 3.54320377e-01f, -3.61082733e-01f, -7.26376250e-02f, -1.42293647e-01f, 7.32533932e-02f, -3.91966254e-01f, -6.64202422e-02f,
  -3.99219543e-02f, 2.06046179e-02f, -2.07103029e-01f, -9.16589573e-02f, -1.70439273e-01f, -1.16397291e-01f, -2.34779283e-01f, 7.88544193e-02f, -8.29409882e-02f, -8.89995322e-02f,
  7.09273443e-02f, 2.07658216e-01f, -1.01249628e-01f, 1.60437226e-01f, -2.91048363e-02f, -1.05925165e-01f, 8.58530924e-02f, -1.84783190e-01f, 1.44431204e-01f, 1.08259097e-01f,
  2.45052371e-02f, 8.85510631e-03f, -1.29633769e-01f, -6.90201819e-02f, -1.25721171e-01f, -7.83862025e-02f, -9.23321173e-02f, -1.00114681e-01f, -3.12345996e-02f, -1.23506442e-01f,
  9.22562927e-02f, 5.17242253e-02f, 1.62401348e-01f, 5.93507029e-02f, -4.07291763e-02f, 1.65489882e-01f, -1.50196543e-02f, -2.04835534e-02f, 4.07366268e-03f, -1.49970233e-01f,
  -1.48310751e-01f, 9.11447182e-02f, 5.31252101e-02f, -1.85221851e-01f, 7.99304396e-02f, 2.30314806e-02f, 3.85230444e-02f, 4.81040925e-02f, -1.26939341e-01f, -1.00252055e-01f,
  -4.23519872e-02f, 3.56863104e-02f, -3.78297945e-03f, -1.80461761e-02f, -1.34251505e-01f, -4.79096808e-02f, 2.46911589e-02f, 1.30577847e-01f, -7.47639388e-02f, 3.48603353e-02f,
  -8.46193805e-02f, 1.89611949e-02f, -5.99561781e-02f, 6.01585805e-02f, -1.79689042e-02f, 3.04930471e-02f, 1.94362774e-02f, -1.32716015e-01f, -2.20876798e-01f, 3.27766943e-03f,
  -8.26016068e-02f, -4.81062979e-02f, -2.27018774e-01f, -3.04647069e-02f, 6.92304643e-03f, -5.79729863e-02f, 4.90991063e-02f, -9.28661302e-02f, -2.52767414e-01f, 7.09896237e-02f,
  -2.76192762e-02f, 8.20165873e-02f, 2.45630313e-02f, -1.50455534e-01f, -1.52597383e-01f, -2.35174417e-01f, 5.65675460e-02f, 1.13023013e-01f, 6.11213669e-02f, -1.45351708e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 14)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 14;
const float L0_fan_Bp_bar_data[] = {
  5.47622144e-01f, 4.52892125e-01f, 7.43075430e-01f, 4.95306551e-01f, 2.74912924e-01f, 5.26179790e-01f, 4.68474120e-01f, 5.69151402e-01f, 5.46072423e-01f, 6.06149375e-01f,
  7.56950021e-01f, 6.14812255e-01f, 4.72429574e-01f, 5.23434818e-01f
};

// L1_linear_W (Shape: 12 x 64)
const int L1_linear_W_rows = 12;
const int L1_linear_W_cols = 64;
const float L1_linear_W_data[] = {
  -3.91092300e-01f, 1.77170739e-01f, -3.26128930e-01f, -3.40211034e-01f, 1.10473074e-01f, 2.26505361e-02f, 5.17239654e-03f, 2.13718221e-01f, 1.55726090e-01f, -4.24777955e-01f,
  6.52124733e-02f, 8.71053115e-02f, -1.98493719e-01f, 2.37993196e-01f, -7.26589203e-01f, -1.00781187e-01f, -4.31567252e-01f, -4.06177104e-01f, 1.58460602e-01f, -3.04198563e-01f,
  2.82957754e-03f, -3.62455726e-01f, -6.49383143e-02f, 1.75404519e-01f, 7.73697942e-02f, -5.67788363e-01f, 3.56501848e-01f, 4.30846363e-02f, -2.17757002e-01f, -6.68097615e-01f,
  -4.02306253e-03f, 7.54492655e-02f, -3.27042453e-02f, 3.98630142e-01f, 2.03493565e-01f, -4.54361379e-01f, 5.61332524e-01f, -7.87923455e-01f, -1.35313431e-02f, -3.57965112e-01f,
  -6.06152713e-01f, -5.24287283e-01f, -5.83197176e-01f, -2.49419942e-01f, -5.17866075e-01f, -2.82497883e-01f, 4.77543533e-01f, -3.03398699e-01f, -5.49875617e-01f, 3.52968991e-01f,
  -1.90024480e-01f, 5.11256695e-01f, -2.73909718e-01f, -3.06099296e-01f, -2.51316816e-01f, -5.24853528e-01f, 6.51927829e-01f, -5.23302794e-01f, 2.09737495e-01f, -2.67953038e-01f,
  -3.83414984e-01f, -5.67148805e-01f, 4.29457605e-01f, -7.87476063e-01f, 2.60219067e-01f, -2.63391793e-01f, 2.71986753e-01f, 9.71918553e-02f, -2.51199186e-01f, -2.50030726e-01f,
  -2.98894465e-01f, -3.48239750e-01f, -3.49837452e-01f, -5.80970272e-02f, -4.10213172e-01f, -7.15020020e-03f, -1.75327927e-01f, 3.37149277e-02f, 2.25427732e-01f, 2.33846884e-02f,
  2.58682191e-01f, 3.53306860e-01f, -1.74350128e-01f, 7.24676624e-02f, -1.26131279e-02f, -6.32810414e-01f, -7.88764358e-02f, -2.39045501e-01f, 1.42033890e-01f, 3.51718277e-01f,
  5.54285765e-01f, 5.88827252e-01f, -2.85464734e-01f, -2.97410518e-01f, -4.33391631e-01f, 6.23179793e-01f, -1.89783797e-01f, 5.70758700e-01f, 4.70784038e-01f, -4.39280897e-01f,
  -5.43145657e-01f, 5.34838855e-01f, 6.01197779e-01f, -1.78665578e-01f, 1.92536294e-01f, -1.26705557e-01f, 2.79788256e-01f, -3.35723609e-01f, -5.16253889e-01f, 4.18347090e-01f,
  2.95089036e-01f, 2.36832201e-01f, 6.55070961e-01f, -8.60716999e-01f, 2.25324169e-01f, -9.01871145e-01f, -4.28457379e-01f, -4.30408239e-01f, -3.58630002e-01f, -1.07950962e+00f,
  4.91735190e-01f, 4.84847516e-01f, -1.58009291e-01f, 5.73888361e-01f, -6.08603358e-01f, -1.33878306e-01f, 3.40962738e-01f, 3.23908746e-01f, -2.85070986e-01f, -6.19504035e-01f,
  -3.30884606e-01f, 7.87605718e-02f, 2.21667543e-01f, -1.80921569e-01f, -1.72075614e-01f, -2.56362885e-01f, 7.91034102e-03f, -2.30647549e-01f, -2.36855537e-01f, -6.57949373e-02f,
  8.54882002e-02f, -4.21422154e-01f, 9.58797801e-03f, 2.57989112e-02f, -1.36297122e-01f, -3.04599494e-01f, -2.76549101e-01f, -5.63247539e-02f, -8.78762081e-02f, -3.51336688e-01f,
  6.27801642e-02f, -1.33881513e-02f, -7.48113021e-02f, -6.58120885e-02f, -1.24641918e-01f, -5.75481057e-01f, 1.86541811e-01f, 3.64044309e-01f, 1.34972289e-01f, 3.47064018e-01f,
  -4.54993874e-01f, 2.92864591e-01f, -2.39677697e-01f, -1.30501732e-01f, 1.47185385e-01f, 4.06887941e-02f, 2.42369637e-01f, 2.79731959e-01f, -5.11593699e-01f, -1.82857215e-01f,
  3.72939438e-01f, -2.85280973e-01f, -3.44594210e-01f, -4.67956394e-01f, 2.50410438e-01f, 2.33854488e-01f, -2.57516146e-01f, -1.62163794e-01f, -7.21172392e-01f, -3.50778788e-01f,
  -5.90464711e-01f, 2.96045750e-01f, 6.60173118e-01f, 4.40139174e-01f, -7.61853218e-01f, 4.82463956e-01f, -6.34127319e-01f, 1.20526768e-01f, -3.27128887e-01f, 1.80195451e-01f,
  1.51869342e-01f, -5.30332685e-01f, -9.46248695e-02f, 1.48925915e-01f, -1.88885197e-01f, 1.33350372e-01f, 1.32292539e-01f, 3.43866348e-02f, 2.60193348e-02f, -6.05904937e-01f,
  6.00292496e-02f, -1.56442985e-01f, -1.28176466e-01f, -4.10279721e-01f, -2.20324248e-01f, -4.43023294e-01f, 2.34490842e-01f, -7.49528110e-02f, 2.04360873e-01f, -6.77772880e-01f,
  -6.50460362e-01f, 1.30732581e-01f, -2.86160707e-01f, -5.26223838e-01f, 2.63936251e-01f, -3.91982585e-01f, 2.12798908e-01f, 1.68737695e-01f, -4.65565532e-01f, -2.35839710e-01f,
  1.55392483e-01f, -1.09860294e-01f, 4.39097315e-01f, 2.97093336e-02f, 3.26773077e-01f, 1.13649353e-01f, 5.95593870e-01f, 2.73723960e-01f, 2.28213221e-01f, -3.75410438e-01f,
  -2.15109214e-01f, -1.74218878e-01f, 7.93319382e-03f, 5.51679432e-02f, -1.55588821e-01f, 3.18316706e-02f, -9.89197418e-02f, -3.55555028e-01f, -3.11139226e-01f, 5.22739291e-01f,
  4.54197258e-01f, -5.43924510e-01f, -5.38776815e-01f, 3.95920843e-01f, -6.71741962e-01f, -5.25062501e-01f, -2.86394358e-02f, -4.34747875e-01f, -5.77291131e-01f, -5.58584511e-01f,
  9.39329028e-01f, -7.52976358e-01f, 4.95415926e-02f, -5.07920682e-01f, -3.80303055e-01f, 4.79600281e-01f, 3.66499156e-01f, -3.31723541e-01f, 1.49568006e-01f, 2.74976224e-01f,
  -5.40572815e-02f, 1.04581481e-02f, 3.50000918e-01f, 6.47946954e-01f, 2.15677798e-01f, 7.17589073e-03f, 1.93322897e-01f, 1.18341193e-01f, 3.36447924e-01f, -1.75965559e-02f,
  3.67943347e-02f, -2.21064895e-01f, -4.44196433e-01f, 4.18480992e-01f, 4.82228011e-01f, 1.18103139e-01f, 1.24291375e-01f, 3.54174912e-01f, -2.56897062e-01f, 3.96685451e-01f,
  -1.18995957e-01f, -2.88886398e-01f, -4.42325287e-02f, 6.91927254e-01f, -5.02984598e-02f, 6.73663139e-01f, 6.53572798e-01f, -6.46102354e-02f, 9.16550085e-02f, -4.39568490e-01f,
  4.62889850e-01f, 4.34557721e-02f, 7.25505948e-01f, 1.18166044e-01f, -5.07579327e-01f, -7.13267028e-01f, 3.24265361e-01f, 8.28276388e-03f, -7.45780528e-01f, 8.07682216e-01f,
  -1.45828128e-01f, -6.45444512e-01f, -5.35360813e-01f, -7.11520314e-01f, -3.86599451e-01f, 6.23123705e-01f, -6.15851860e-03f, 1.24412134e-01f, -5.45085788e-01f, -3.00366461e-01f,
  -5.45634270e-01f, -1.88915303e-03f, -7.54702032e-01f, -2.82053918e-01f, -1.86015069e-02f, 2.25815192e-01f, -6.12333715e-01f, 1.08981884e+00f, -3.87685716e-01f, 1.77599788e-01f,
  2.84536451e-01f, 5.38502038e-01f, 2.02485949e-01f, 3.03123951e-01f, -2.06817314e-01f, -1.25602543e-01f, 1.42595500e-01f, -2.49765888e-01f, 1.38754845e-01f, 3.09084445e-01f,
  5.24603724e-01f, 1.84552044e-01f, 2.40024105e-01f, -1.43919140e-01f, 4.25311029e-01f, 4.59113836e-01f, 3.02706122e-01f, 3.68126370e-02f, 1.94968000e-01f, 1.61928862e-01f,
  -1.10629059e-01f, 5.97720802e-01f, 1.54177556e-02f, 1.64579585e-01f, -1.48941381e-02f, 3.68201166e-01f, -6.97495043e-01f, 3.51929188e-01f, -6.89887881e-01f, 7.63576210e-01f,
  -6.92030668e-01f, -8.68316770e-01f, -6.60003185e-01f, -5.23037314e-01f, 5.74770629e-01f, 5.65442383e-01f, -5.84833443e-01f, 7.14097679e-01f, 2.36459933e-02f, -2.73421377e-01f,
  3.82696867e-01f, 5.99241257e-01f, 5.38496137e-01f, -7.81487346e-01f, 7.41509974e-01f, 7.11600840e-01f, 2.93208212e-01f, -4.90710109e-01f, 6.42911255e-01f, 7.61224568e-01f,
  -2.76058763e-01f, 4.74862099e-01f, -2.85200089e-01f, -3.57991785e-01f, 2.95198932e-02f, 2.70966679e-01f, 3.63946497e-01f, -7.63066769e-01f, -5.86223483e-01f, -3.38580042e-01f,
  -2.80039102e-01f, -8.51177037e-01f, 2.39940897e-01f, -2.45755687e-01f, 4.07002956e-01f, 4.25043076e-01f, -3.91156018e-01f, -1.77718222e-01f, -5.48681498e-01f, 1.97776034e-01f,
  7.35706463e-02f, -2.92099535e-01f, -1.25392407e-01f, -9.41903219e-02f, -1.55580610e-01f, -2.55215138e-01f, -6.47377372e-01f, 1.24844238e-01f, 2.00616181e-01f, 1.71432540e-01f,
  -5.05946428e-02f, -3.37947875e-01f, -3.36080104e-01f, -1.76678836e-01f, -1.24719099e-03f, 1.58466414e-01f, 1.43120408e-01f, 2.84439743e-01f, 1.81839809e-01f, 3.04750979e-01f,
  3.80783409e-01f, -4.79228467e-01f, 5.54761827e-01f, 2.63421953e-01f, 5.30928195e-01f, 5.46987712e-01f, -4.27675396e-01f, -5.31534731e-01f, -5.75080514e-01f, -5.74409664e-01f,
  -3.03915292e-01f, 4.75615650e-01f, -6.10339224e-01f, 3.07397395e-02f, 4.76056814e-01f, 6.95792794e-01f, 1.85330734e-01f, 9.21402127e-02f, 6.34016216e-01f, 1.52004674e-01f,
  6.96644560e-02f, -3.73988181e-01f, -4.87483382e-01f, 2.81397700e-01f, -5.90148985e-01f, -5.61550140e-01f, 5.34669876e-01f, 1.86991125e-01f, -1.35046229e-01f, -5.68305671e-01f,
  -4.64136362e-01f, 7.00657666e-01f, -6.78406417e-01f, -8.16994429e-01f, 8.86133969e-01f, -4.93865371e-01f, -2.72449374e-01f, -5.66265047e-01f, -3.57237071e-01f, -3.04948181e-01f,
  -5.13096415e-02f, -6.87273294e-02f, 4.54401188e-02f, -1.60631701e-01f, -2.99604107e-02f, -2.48096421e-01f, 1.57529637e-02f, 1.06476992e-01f, -3.77605468e-01f, -1.23567730e-01f,
  -2.78508067e-01f, -3.09672594e-01f, -4.55474794e-01f, -8.71621817e-02f, 1.80628779e-03f, 4.35266644e-02f, 1.31736234e-01f, -9.97825786e-02f, -8.35105218e-03f, -2.93816090e-01f,
  2.76795924e-02f, 1.75354034e-02f, -4.57404293e-02f, -2.99726158e-01f, -2.84167737e-01f, -3.30518484e-01f, -1.71316639e-01f, 2.05872282e-01f, -2.66759783e-01f, 4.06757891e-02f,
  2.03996986e-01f, -8.05824250e-02f, -1.25143111e-01f, 2.59510040e-01f, -8.76719225e-03f, -2.37508103e-01f, 3.24976951e-01f, 4.23991621e-01f, -2.67640084e-01f, 4.29292358e-02f,
  -1.82389930e-01f, 2.54957229e-01f, 3.18331182e-01f, 2.46252380e-02f, -2.85950512e-01f, 4.82038379e-01f, -2.46756077e-01f, 7.30266422e-02f, -2.51039356e-01f, 3.78885537e-01f,
  6.32014096e-01f, -3.95357341e-01f, -4.78351980e-01f, 3.69764030e-01f, -7.14381099e-01f, -5.35486519e-01f, -7.59757698e-01f, -2.76318491e-01f, -4.26640630e-01f, -4.84101802e-01f,
  3.02904159e-01f, 5.39676070e-01f, -1.73763081e-01f, 2.54438128e-02f, 1.28578559e-01f, -1.97561964e-01f, -1.31803557e-01f, -2.65167058e-01f, -1.68909073e-01f, 1.62143663e-01f,
  -7.34947324e-02f, -4.89700064e-02f, 1.89426333e-01f, -1.99994966e-01f, 5.53997234e-02f, -6.57371819e-01f, 2.21562944e-02f, -4.90947515e-01f, -3.56475711e-01f, 9.52723995e-02f,
  -1.98307262e-05f, -3.42660666e-01f, -2.01790228e-01f, 2.47427344e-01f, -3.66103351e-01f, 5.66221923e-02f, -8.69163573e-02f, 2.06167877e-01f, 1.24849543e-01f, -5.25658011e-01f,
  -4.36568499e-01f, -4.02596831e-01f, 4.25373763e-01f, -4.82280254e-01f, 4.64244366e-01f, 1.66762210e-02f, 3.10922474e-01f, -2.12012663e-01f, -2.52956510e-01f, 2.04220135e-02f,
  1.02851011e-01f, -2.95282751e-01f, 5.71738839e-01f, -5.33069372e-01f, 1.51039436e-01f, 5.22245586e-01f, 4.99159336e-01f, -4.89972174e-01f, -2.61903882e-01f, 4.43122029e-01f,
  -2.36521184e-01f, -1.75837472e-01f, -6.33350611e-01f, -5.62409699e-01f, 3.06610502e-02f, 4.09040660e-01f, -8.47110152e-01f, 5.04557610e-01f, 4.11367059e-01f, 3.07516307e-01f,
  -2.80333683e-02f, 9.63222235e-02f, 1.35738000e-01f, -6.11927807e-01f, -4.21480685e-02f, -3.92809898e-01f, -1.18570430e-02f, 1.58419341e-01f, 6.32465631e-03f, 1.77651584e-01f,
  2.00445086e-01f, -3.98372905e-03f, -6.93041608e-02f, 2.06369087e-01f, 9.39239487e-02f, -2.08965316e-01f, 2.17094690e-01f, 4.60350811e-01f, 2.17344776e-01f, 2.74261981e-01f,
  1.72650814e-01f, 1.99991867e-01f, 2.89555490e-01f, 1.06838737e-02f, -7.33066052e-02f, 1.50418580e-01f, 8.73644575e-02f, -7.49239624e-02f, 2.00209141e-01f, -6.69395864e-01f,
  -3.27057660e-01f, -4.38951164e-01f, 1.72196746e-01f, -5.58324456e-01f, 1.40260011e-01f, 1.25627056e-01f, -1.41425401e-01f, 1.62595972e-01f, -3.39081526e-01f, 5.69534302e-01f,
  -5.21809101e-01f, -1.52776361e-01f, 2.17842400e-01f, 3.37419808e-01f, 1.18736662e-01f, 2.18688771e-01f, -5.29993586e-02f, -4.73335862e-01f, 4.38905120e-01f, -6.44068301e-01f,
  -4.92662489e-01f, 4.17463899e-01f, 1.00261077e-01f, 7.50144273e-02f, -3.61993879e-01f, 1.59561247e-01f, 7.89606571e-01f, -6.02298975e-01f, 6.24647021e-01f, -5.12828648e-01f,
  2.77965784e-01f, -1.82540551e-01f, -6.71122134e-01f, -6.48505151e-01f, -1.71048507e-01f, -7.34755695e-01f, -1.00530636e+00f, 5.26983917e-01f, -6.38089716e-01f, -4.50690508e-01f,
  2.20797524e-01f, 2.39742681e-01f, -9.61090326e-02f, 2.55592942e-01f, -4.06023264e-01f, 9.16652605e-02f, 1.01707131e-01f, -1.04719356e-01f, 2.61313133e-02f, 1.66680738e-01f,
  -3.97703517e-03f, 7.74644464e-02f, 1.16322547e-01f, 4.03037965e-01f, -5.35793900e-02f, 1.32551566e-01f, 3.04092467e-01f, -3.18527184e-02f, -2.36308962e-01f, -8.39934051e-02f,
  2.80714691e-01f, 3.86604339e-01f, 1.77908912e-02f, -1.22429319e-01f, -1.02073953e-01f, 2.66430140e-01f, 4.51353401e-01f, 6.99935496e-01f, 2.17306823e-01f, -4.84810024e-01f,
  -4.46677774e-01f, -3.84519488e-01f, 5.06075442e-01f, 5.84982991e-01f, -5.06863058e-01f, 5.46249688e-01f, 6.54141128e-01f, -4.54745263e-01f, -2.28903711e-01f, 6.01643026e-01f,
  -4.51703995e-01f, 8.90829861e-02f, -6.96690798e-01f, 5.61060369e-01f, -5.57837129e-01f, 3.14232141e-01f, -1.89614832e-01f, 5.04119158e-01f, 4.85311359e-01f, -5.21654904e-01f,
  -1.11744188e-01f, -5.67660987e-01f, -5.80211997e-01f, 1.06596720e+00f, -1.56355396e-01f, -7.07220078e-01f, -2.42888585e-01f, 2.18895867e-01f, -3.26492131e-01f, -2.34070078e-01f,
  8.73488933e-03f, -2.39722192e-01f, -5.37975311e-01f, -1.31911635e-01f, -3.28604907e-01f, -5.00938356e-01f, 2.49039173e-01f, -4.89524752e-01f, 1.91344097e-01f, 1.39096633e-01f,
  -3.71501476e-01f, 2.18731031e-01f, -4.92761433e-01f, 2.66042948e-01f, 1.95923895e-01f, -1.43640302e-02f, 5.71643794e-03f, 3.17179799e-01f, 1.74899772e-02f, 2.08277017e-01f,
  -2.96930999e-01f, 2.27177516e-01f, 2.58102387e-01f, 3.04488558e-02f, 1.03145376e-01f, -8.99415314e-02f, -2.41701812e-01f, 1.95136309e-01f, 1.47606060e-01f, 4.19401616e-01f,
  -3.28631461e-01f, -2.07962081e-01f, 4.73793596e-01f, 2.46045962e-02f, 2.27520019e-01f, -3.90061647e-01f, 3.28437895e-01f, -4.05365944e-01f, -4.56449658e-01f, 3.77634466e-01f,
  -4.95883048e-01f, -5.41112959e-01f, 1.99814677e-01f, -3.68791074e-01f, -2.05392480e-01f, 3.90709698e-01f, 4.38484758e-01f, 3.90761793e-01f, 2.00594470e-01f, -1.90877229e-01f,
  -2.40312651e-01f, -5.45904815e-01f, 8.81609842e-02f, -2.96625465e-01f, 6.04366601e-01f, -3.48905116e-01f, -7.28814960e-01f, -9.40948963e-01f, 2.92061064e-02f, 3.02786857e-01f,
  -6.83528244e-01f, -6.72373712e-01f, 3.78857315e-01f, 4.22127336e-01f, 7.74541855e-01f, -7.27051854e-01f, -3.67477864e-01f, -4.65095490e-01f
};

// L1_linear_B (Shape: 1 x 12)
const int L1_linear_B_rows = 1;
const int L1_linear_B_cols = 12;
const float L1_linear_B_data[] = {
  -1.11761619e-03f, -3.04918550e-02f, -2.59415567e-01f, -8.90931487e-02f, 7.98024759e-02f, 4.08911370e-02f, 9.89202112e-02f, -1.36726171e-01f, -1.48365885e-01f, 5.51123694e-02f,
  2.42278203e-01f, 1.39736801e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 25, 14
    );
    
    // Camada 1: L1_linear
    linear_forward_pgm(
        buffer1, x_out,
        L1_linear_W_data, L1_linear_B_data,
        64, 12
    );
    }
    