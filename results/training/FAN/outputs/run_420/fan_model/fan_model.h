/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 16 (x4)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 16;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    float x3 = x * x * x;
    return 0.5f * x * (1.0f + tanhf(0.79788456f * (x + 0.044715f * x3)));
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 1 x 120)
const int L0_fan_Wp_rows = 1;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -1.05985940e-01f, 1.43611684e-01f, -2.94452514e-02f, 1.13153823e-01f, -3.82431969e-02f, 4.40530032e-01f, 4.31155086e-01f, -3.40387002e-02f, 2.07689062e-01f, 2.28391469e-01f,
  6.37557060e-02f, 1.62054747e-01f, -9.92973000e-02f, 3.04949194e-01f, 3.51671837e-02f, 5.76803982e-02f, 1.73854426e-01f, 8.89863074e-02f, -4.02032845e-02f, -4.60290834e-02f,
  -5.85720278e-02f, 2.55730208e-02f, 2.54980121e-02f, 1.52659779e-02f, 9.39237550e-02f, -1.01691596e-01f, -2.10201666e-01f, 3.72232907e-02f, -5.88789284e-02f, 5.06737418e-02f,
  -1.13061450e-01f, -1.23417571e-01f, 2.40956582e-02f, 2.62065548e-02f, 3.20357345e-02f, 3.32302367e-03f, -5.39325625e-02f, 2.94698495e-02f, -6.62389845e-02f, 4.38948087e-02f,
  -3.67150120e-02f, -5.85018322e-02f, -5.13850860e-02f, 1.37945667e-01f, 8.95026922e-02f, -1.89119671e-02f, 1.37175713e-02f, 3.72608341e-02f, -3.26448493e-02f, 5.27635887e-02f,
  1.01728171e-01f, -2.47051213e-02f, 2.53518601e-03f, -1.00435950e-02f, 2.67578587e-02f, 7.86790028e-02f, 3.47320586e-02f, 5.82282022e-02f, -3.51761468e-02f, 2.77098902e-02f,
  -1.16892243e-02f, -9.42204595e-02f, 3.41414176e-02f, -1.27178719e-02f, 1.32089723e-02f, -5.98123185e-02f, 7.28362054e-02f, -1.11742578e-01f, -1.95034705e-02f, 2.74430662e-02f,
  7.48933181e-02f, -4.90851440e-02f, 2.28373148e-02f, 3.48283909e-02f, -3.82487872e-03f, -2.41287034e-02f, 1.61323175e-02f, 3.05082556e-02f, 2.44458355e-02f, -3.55780055e-03f,
  4.51264083e-02f, 6.98935017e-02f, 1.54504152e-02f, -5.12507893e-02f, -2.31628660e-02f, 3.62404883e-02f, 2.53907777e-02f, 4.08469997e-02f, -2.23557558e-02f, -3.94501910e-02f,
  -1.71184223e-02f, -1.78328291e-01f, 2.85432972e-02f, 1.04503527e-01f, -8.80912039e-03f, 1.73012465e-02f, -3.69096585e-02f, 1.20588718e-02f, 3.69091853e-02f, -4.53759544e-02f,
  -4.36367244e-02f, -3.42599675e-02f, -3.55288461e-02f, 8.22355300e-02f, 3.21290046e-02f, 2.47066338e-02f, 4.37534600e-03f, 7.71635473e-02f, -4.81704138e-02f, -7.39974380e-02f,
  -6.67114137e-03f, -9.52751096e-03f, -2.28160024e-02f, -8.33877698e-02f, -7.75266588e-02f, 1.64444856e-02f, -3.59539641e-03f, 5.36783449e-02f, -8.09728280e-02f, 2.40689400e-03f
};

// L0_fan_Wp_bar (Shape: 14 x 120)
const int L0_fan_Wp_bar_rows = 14;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -1.14184786e-02f, 3.56006384e-01f, 9.71505940e-02f, 7.57196471e-02f, -3.80102023e-02f, -1.40685946e-01f, -6.28159717e-02f, 9.17546973e-02f, -1.97958592e-02f, 1.97791785e-01f,
  -1.36947498e-01f, 3.75085950e-01f, -1.48091987e-01f, -1.43034384e-01f, -8.29342842e-01f, -4.08352435e-01f, -4.23271567e-01f, -2.97696237e-02f, -4.69646864e-02f, 5.08970656e-02f,
  -1.12333432e-01f, -2.24465936e-01f, -3.89446281e-02f, -3.06900293e-02f, 3.60481799e-01f, 2.68474877e-01f, -1.44172356e-01f, 9.38259512e-02f, 1.27100453e-01f, -1.53701276e-01f,
  -2.64259223e-02f, 5.49675971e-02f, 1.40505210e-01f, 5.48979528e-02f, -1.38304876e-02f, 1.59944240e-02f, -1.00547690e-02f, -8.00406262e-02f, -7.25603336e-03f, 1.11866862e-01f,
  1.26309156e-01f, -1.06018588e-01f, -1.11338207e-02f, 1.70683619e-02f, 7.31552243e-02f, -7.71953240e-02f, 1.35159269e-01f, 2.71080639e-02f, 2.06970498e-02f, 9.05911326e-02f,
  -3.67394574e-02f, 3.69940363e-02f, 1.22204058e-01f, -1.35271978e-02f, 1.50371790e-02f, -2.80202460e-02f, 3.47991511e-02f, 5.26887178e-02f, 8.60947520e-02f, 1.03402153e-01f,
  5.89565549e-04f, -3.02334633e-02f, -1.23668937e-02f, 9.99184921e-02f, -4.76897471e-02f, 3.61600146e-02f, -1.36488006e-01f, -4.30553444e-02f, 4.59336005e-02f, -1.13886856e-02f,
  -3.87327634e-02f, 9.25774947e-02f, 4.55661640e-02f, -5.77913597e-02f, 6.33911490e-02f, 6.30829930e-02f, 2.08712630e-02f, -2.50432044e-02f, 5.48219532e-02f, -1.18723838e-02f,
  -4.81201522e-02f, -1.12492576e-01f, 6.87749088e-02f, -3.93281393e-02f, -5.78797124e-02f, 2.53513940e-02f, 4.08784375e-02f, -8.59170184e-02f, 4.59667109e-02f, -5.62368110e-02f,
  -1.19726509e-01f, -5.08180745e-02f, 1.40805081e-01f, 2.52467878e-02f, -1.44957341e-02f, -6.25012890e-02f, -1.71825752e-01f, 2.17952374e-02f, -6.03023171e-02f, -6.29472136e-02f,
  5.79039119e-02f, 8.83100033e-02f, 1.72015186e-02f, -8.96369442e-02f, 1.56434532e-02f, -6.80578649e-02f, -3.09258047e-02f, 1.53314508e-02f, 8.57684165e-02f, 7.08426582e-03f,
  1.21877797e-01f, -3.70255159e-03f, -9.76729393e-02f, -3.18024047e-02f, 5.92851220e-03f, 3.74585800e-02f, -4.96548880e-03f, 6.83013871e-02f, -5.68410233e-02f, 1.07339323e-02f,
  1.23961344e-01f, -4.06054199e-01f, 3.30845773e-01f, -1.25517011e-01f, 1.35694921e-01f, -1.12476675e-02f, 2.17423782e-01f, -1.84542730e-01f, -7.31639117e-02f, -2.42668569e-01f,
  -1.47816136e-01f, 1.88991010e-01f, 2.73383141e-01f, -3.23380053e-01f, 3.95082414e-01f, 1.05652381e-02f, -3.26580197e-01f, 1.75413154e-02f, 3.33097652e-02f, -1.45083606e-01f,
  5.76276481e-02f, -2.54347682e-01f, 1.36669412e-01f, -3.14930886e-01f, 1.34177715e-01f, -1.26256853e-01f, -4.70340326e-02f, 1.56878248e-01f, -2.54084349e-01f, 6.55930415e-02f,
  -2.53241092e-01f, -1.69488266e-01f, -5.25158318e-03f, 1.57064181e-02f, -5.08158132e-02f, 4.18734504e-03f, 9.22313631e-02f, 1.53031260e-01f, -7.04887584e-02f, 1.57888740e-01f,
  3.72174978e-02f, -1.26941085e-01f, -1.54130599e-02f, 1.69506431e-01f, 5.16856648e-03f, -6.60988502e-03f, -1.57342386e-02f, 1.09066390e-01f, 7.91185200e-02f, 1.38498172e-01f,
  1.11913174e-01f, -8.96259248e-02f, -1.81456551e-01f, -1.01302370e-01f, 4.94134650e-02f, -1.41406849e-01f, -4.73921262e-02f, 2.96056923e-02f, -6.61466494e-02f, -7.11937249e-02f,
  -1.62898414e-02f, 1.04666539e-01f, 3.82418968e-02f, -1.38674855e-01f, -2.12247111e-02f, 3.29800583e-02f, 6.19623763e-03f, 3.13246846e-02f, -8.29638392e-02f, -9.27565992e-02f,
  -1.48488104e-01f, 1.24521377e-02f, -5.26226610e-02f, -8.73091072e-02f, -1.03761228e-02f, 2.94810254e-02f, -1.34261906e-01f, -2.58343853e-02f, -6.32315129e-02f, 3.31890360e-02f,
  -4.33255080e-03f, -1.79131273e-02f, 2.75097368e-03f, 6.17744885e-02f, -1.13647103e-01f, 6.84845001e-02f, 1.78709924e-02f, 2.23879330e-02f, 1.74676925e-01f, 1.54055879e-01f,
  -6.84473395e-01f, -4.92517382e-01f, -2.09693894e-01f, 3.45318951e-02f, -1.44810110e-01f, 5.51506020e-02f, 3.02359201e-02f, -4.26398441e-02f, 6.83958060e-04f, 7.90702403e-02f,
  6.10986166e-02f, -9.33329314e-02f, -1.94840841e-02f, -3.57738361e-02f, -3.51213887e-02f, 7.25088790e-02f, -1.29419221e-02f, -8.27496946e-02f, -1.33850664e-01f, -1.29348442e-01f,
  -1.17698960e-01f, 1.99973397e-02f, -6.43898845e-02f, 6.62909672e-02f, -5.21720424e-02f, -1.81381274e-02f, 2.12881882e-02f, -1.19194746e-01f, 3.71941850e-02f, 3.37781049e-02f,
  -1.28715605e-01f, 2.97266036e-01f, -1.15778610e-01f, 2.74692982e-01f, -2.67865807e-01f, -4.74905362e-03f, 2.05464121e-02f, 6.53694496e-02f, 5.27005605e-02f, 4.00723696e-01f,
  3.91447335e-01f, 1.63138122e-03f, 3.80925089e-01f, 5.34326136e-01f, 1.84152257e-02f, 2.86577493e-01f, 2.29612246e-01f, 1.20137095e-01f, -2.19952874e-02f, 1.34049356e-01f,
  1.61576003e-01f, 3.82956952e-01f, 2.39556253e-01f, 2.76966766e-02f, 2.73418337e-01f, 1.08170427e-01f, 3.19867522e-01f, -5.58683798e-02f, 1.86955065e-01f, -2.66869776e-02f,
  3.17787379e-02f, 8.62261206e-02f, 1.19422767e-02f, -1.13349721e-01f, -7.66579527e-03f, 1.89694837e-02f, -4.73131761e-02f, -1.33250356e-01f, -9.62992311e-02f, 4.42333706e-02f,
  -7.16610476e-02f, 1.29458634e-02f, 4.24935371e-02f, -6.60904422e-02f, 1.66550074e-02f, -1.57885179e-01f, -8.05260148e-03f, 7.22031994e-03f, -7.81485066e-03f, -7.85403475e-02f,
  -2.83352491e-02f, 1.27389403e-02f, 5.12388200e-02f, -1.06677962e-02f, -2.39032842e-02f, -5.45712449e-02f, 1.01375699e-01f, 3.25440168e-02f, -2.99007595e-02f, -6.21181633e-03f,
  -5.60943596e-02f, -1.73561014e-02f, 1.37760311e-01f, -8.32604021e-02f, 2.62206383e-02f, -1.59824900e-02f, -2.00339723e-02f, 4.55587469e-02f, -1.32830543e-02f, 1.26076624e-01f,
  3.74685898e-02f, -3.06323264e-02f, -3.75626376e-03f, 6.83329478e-02f, 6.33708239e-02f, 2.57474147e-02f, -2.95165721e-02f, 1.53714763e-02f, -2.89490633e-02f, 3.16731259e-02f,
  5.20251170e-02f, 2.33703144e-02f, 7.98670799e-02f, 4.94945683e-02f, -1.16470426e-01f, -3.71872522e-02f, 2.43623443e-02f, 5.97811863e-02f, 1.70167610e-02f, 1.76412868e-03f,
  1.14960462e-01f, 1.73895821e-01f, 1.73774324e-02f, -7.43673816e-02f, 6.25668243e-02f, -1.88979227e-02f, 6.18793033e-02f, 3.04678790e-02f, 7.64342695e-02f, 5.42263547e-03f,
  4.39006984e-02f, -1.84333976e-02f, 1.15320005e-01f, -1.82347521e-02f, -1.00325286e-01f, 1.24070980e-01f, 1.15425676e-01f, -6.41653389e-02f, 1.82279013e-02f, 7.59257819e-05f,
  5.76902553e-02f, 3.85202505e-02f, 1.02928700e-02f, -8.86881202e-02f, -6.45845905e-02f, 8.19507241e-02f, -5.53994030e-02f, -1.37243077e-01f, -8.75072479e-02f, 1.68638781e-01f,
  -1.33947775e-01f, 2.09103033e-01f, 5.93642704e-03f, 1.37652382e-02f, 1.70645699e-01f, -2.60995656e-01f, -2.22100496e-01f, -1.12167113e-02f, -2.11317852e-01f, 2.95447737e-01f,
  -1.74689949e-01f, 1.55180082e-01f, -3.48168552e-01f, -2.39951953e-01f, -7.37220407e-01f, -4.41386223e-01f, -3.89008880e-01f, -1.76967472e-01f, -1.45553187e-01f, 9.02121142e-03f,
  -2.11577594e-01f, -2.88755357e-01f, -3.28272343e-01f, 7.94201568e-02f, 3.00028086e-01f, 2.43862316e-01f, 5.67448586e-02f, 2.67001748e-01f, 1.10913001e-01f, 4.12091473e-03f,
  1.84497144e-02f, -6.55385107e-02f, 1.45017644e-02f, 3.99390943e-02f, -6.71325997e-02f, 1.52430475e-01f, 1.00275531e-01f, -6.78525344e-02f, -2.36901902e-02f, -1.46382317e-01f,
  5.67541085e-02f, 1.06798738e-01f, -1.20339200e-01f, -1.79177709e-02f, 2.10400760e-01f, 9.44360867e-02f, -5.03583960e-02f, 2.74773818e-02f, 9.43062156e-02f, -3.28983814e-02f,
  -1.13992333e-01f, -6.78061992e-02f, 4.77803722e-02f, 4.05589826e-02f, -4.24648672e-02f, -1.47971949e-02f, -1.20302252e-01f, 1.53533118e-02f, -1.90021154e-02f, 6.41558766e-02f,
  -2.72623193e-03f, 6.33735731e-02f, -1.40983805e-01f, -4.32345234e-02f, -9.14935395e-02f, 4.62925509e-02f, 7.35406950e-02f, -3.89303416e-02f, 7.01571777e-02f, 1.30852759e-01f,
  5.87416478e-02f, 9.88300890e-02f, -3.34323719e-02f, 1.36330068e-01f, -3.39019150e-02f, 9.74148735e-02f, 1.16468318e-01f, -6.96462989e-02f, -1.06011197e-01f, 2.12168936e-02f,
  5.73949628e-02f, 1.31110139e-02f, 1.29290208e-01f, 4.21566293e-02f, -9.36474502e-02f, -1.60786398e-02f, 1.34136319e-01f, 7.84580782e-02f, -2.71129422e-02f, 1.89080257e-02f,
  4.88308165e-03f, -4.54661176e-02f, 3.44304815e-02f, 9.64846760e-02f, -1.28200322e-01f, -1.43412426e-02f, -3.82324494e-02f, -6.30678907e-02f, -3.22663039e-02f, 3.35657522e-02f,
  8.27798247e-02f, 1.01445271e-02f, 1.23767003e-01f, -4.44880426e-02f, -1.11064836e-01f, -7.63003603e-02f, -5.42610995e-02f, 1.17956899e-01f, -4.48672986e-03f, 3.94731164e-02f,
  4.89409454e-02f, -1.62559971e-02f, -1.93163997e-03f, 1.33447368e-02f, -1.25852264e-02f, 1.93848442e-02f, -2.83070877e-02f, -2.74353139e-02f, -1.60822202e-03f, -4.59570400e-02f,
  7.79181838e-01f, -2.34128967e-01f, -2.59828538e-01f, 2.72865623e-01f, 3.65640789e-01f, 1.55963421e-01f, 1.74395919e-01f, 3.04650456e-01f, 4.13258642e-01f, -7.40810782e-02f,
  5.96770551e-03f, -2.07125798e-01f, -3.52990508e-01f, 1.90108940e-01f, 2.86123157e-01f, -2.24335432e-01f, 3.57580662e-01f, -6.75913244e-02f, -4.94226697e-04f, -1.11584505e-02f,
  2.15953171e-01f, 3.98222864e-01f, -2.94126898e-01f, 1.12542719e-01f, 2.85939902e-01f, 3.14989523e-03f, 2.56897025e-02f, -2.80487031e-01f, 8.45901519e-02f, -6.81089563e-03f,
  1.91193357e-01f, -3.07911169e-02f, 5.24463281e-02f, -9.50728208e-02f, -4.89929207e-02f, -3.06144003e-02f, -1.02096193e-01f, -1.13677710e-01f, -3.36625539e-02f, -1.04399398e-02f,
  -1.38716877e-01f, -4.43162723e-03f, 1.18995011e-02f, 5.81973419e-02f, 1.98835209e-01f, 8.96914303e-02f, 6.50746822e-02f, -4.44949009e-02f, -4.70399596e-02f, 2.32278313e-02f,
  4.09452710e-03f, -1.68766171e-01f, 2.88904253e-02f, -3.29888389e-02f, 4.41944003e-02f, 9.40777659e-02f, -8.99020806e-02f, -1.50295138e-01f, -7.36304279e-03f, 3.50372493e-02f,
  2.74332298e-04f, -3.81086655e-02f, -4.14936021e-02f, 6.88588321e-02f, 5.23928963e-02f, -7.75007717e-03f, 4.84295897e-02f, -7.43559822e-02f, -1.85571536e-02f, -4.99784537e-02f,
  1.11618228e-02f, 7.02626556e-02f, 4.29352559e-02f, 6.03393232e-03f, -2.18621865e-02f, -4.06603441e-02f, -7.36573488e-02f, 5.44805545e-03f, -4.98846509e-02f, 5.44616655e-02f,
  -5.57977892e-02f, 4.89140451e-02f, -7.54668890e-03f, -4.88172434e-02f, -1.06148077e-02f, 1.71040632e-02f, 5.95481955e-02f, 1.25979679e-02f, -3.99009138e-02f, -6.23586308e-03f,
  -9.54230949e-02f, -1.08721592e-01f, -1.24934129e-02f, 9.77285672e-03f, -9.95472595e-02f, 1.53619628e-02f, -4.36179750e-02f, 1.06636785e-01f, 3.50376312e-03f, 8.95360932e-02f,
  1.01718726e-03f, -5.53239658e-02f, -2.19277311e-02f, 9.49115213e-03f, -1.13063119e-01f, 1.06680401e-01f, -1.10720769e-01f, -5.27401790e-02f, 2.33349223e-02f, -4.19077389e-02f,
  -4.61020283e-02f, 3.36654335e-02f, -1.14574045e-01f, 2.55972780e-02f, 3.68089117e-02f, -1.99919939e-01f, 8.01940039e-02f, -2.26632468e-02f, -2.61882581e-02f, -8.39778930e-02f,
  3.79257053e-01f, 4.80208024e-02f, 1.54886827e-01f, 2.98315734e-01f, 2.78071225e-01f, 2.95524329e-01f, 5.82394123e-01f, 1.00995928e-01f, 4.15874094e-01f, -1.13853104e-01f,
  -1.01011410e-01f, 1.48466974e-01f, -2.24610809e-02f, -3.71839218e-02f, 9.76318195e-02f, 1.82898995e-02f, 2.54421592e-01f, 1.36986852e-01f, 1.60070285e-01f, 1.03375129e-01f,
  8.44727159e-02f, 1.23936646e-01f, -1.70259640e-01f, -2.77225614e-01f, -5.11212554e-03f, -2.25404203e-01f, -4.38093990e-01f, -2.89120562e-02f, -3.10918212e-01f, 6.03712350e-03f,
  1.10864148e-01f, 2.89206505e-02f, -4.59047221e-02f, -3.41526140e-03f, 4.23677452e-02f, -1.36020869e-01f, -8.41401964e-02f, -1.24090845e-02f, 1.07194530e-02f, -9.86776277e-02f,
  6.84025064e-02f, 4.43779640e-02f, 6.92597702e-02f, -5.47551960e-02f, 6.28534779e-02f, -8.29258710e-02f, -8.28948244e-02f, -4.71681692e-02f, -1.32997660e-02f, -1.82537585e-02f,
  3.96661721e-02f, 3.00697256e-02f, 1.41190976e-01f, -4.18463685e-02f, 1.77803915e-02f, -4.52769101e-02f, 8.86963680e-02f, 5.08381054e-02f, 1.93956085e-02f, 7.86371082e-02f,
  6.51766453e-03f, 3.96746211e-02f, 4.67488021e-02f, -2.66945306e-02f, 8.36727247e-02f, -1.12447934e-02f, -7.08734244e-02f, -3.65243889e-02f, 4.25420254e-02f, 4.47354354e-02f,
  2.62407027e-02f, 3.81315351e-02f, 8.52107108e-02f, 2.10645460e-02f, 1.19348571e-01f, 2.40180008e-02f, -3.01024131e-02f, -6.96790218e-02f, 1.94700193e-02f, -4.85381534e-05f,
  -3.21456157e-02f, 4.74565551e-02f, -4.30679955e-02f, -9.35996622e-02f, 3.56418081e-02f, 5.27951345e-02f, -7.79549256e-02f, -2.40273628e-04f, -4.60075140e-02f, 2.74885595e-02f,
  1.24428108e-01f, 2.86988039e-02f, 6.86141616e-03f, -1.60029239e-03f, -4.13164310e-02f, -2.97722276e-02f, 5.71354479e-02f, 6.28958493e-02f, 5.44493012e-02f, 4.20109816e-02f,
  1.19859744e-02f, 9.18612033e-02f, 3.47395502e-02f, -5.30000776e-02f, -1.33551667e-02f, -2.26095747e-02f, 4.63274121e-02f, 2.34498475e-02f, 1.26380354e-01f, -1.81565993e-02f,
  -1.25231609e-01f, 7.25800246e-02f, 6.72540590e-02f, 8.20667371e-02f, -1.94688477e-02f, -2.34128833e-02f, -2.22403165e-02f, -9.94290225e-03f, -8.43703300e-02f, -3.46618816e-02f,
  -6.60751641e-01f, 1.93253428e-01f, -1.05677508e-01f, 8.42655376e-02f, 4.45976518e-02f, -6.11403823e-01f, -2.24984929e-01f, 2.32834250e-01f, -8.03020895e-02f, 2.01017171e-01f,
  7.47156143e-02f, -1.21618882e-01f, 1.29662901e-01f, -5.00745773e-02f, -2.30777144e-01f, -2.71372110e-01f, 3.05522066e-02f, -9.44209099e-02f, 3.03139002e-03f, 9.28497240e-02f,
  -7.19045177e-02f, 3.00020665e-01f, -2.21148416e-01f, 2.36181945e-01f, 5.60206026e-02f, 1.59431189e-01f, 3.79514873e-01f, 1.52519211e-01f, 6.05695546e-02f, 2.62679886e-02f,
  -2.84991831e-01f, 2.40234256e-01f, -3.04997098e-02f, -9.63770300e-02f, -1.00745119e-01f, -6.11925013e-02f, -1.12848580e-01f, -2.27406584e-02f, 2.17887033e-02f, 2.32923906e-02f,
  -2.50494741e-02f, -4.51604836e-02f, -1.39239281e-02f, 8.07853863e-02f, -1.55904340e-02f, 1.27734646e-01f, 6.15172312e-02f, 7.08129024e-03f, -2.83344686e-02f, -8.75447020e-02f,
  1.84224658e-02f, -9.23539251e-02f, 4.51670177e-02f, -7.25440681e-02f, 7.84682259e-02f, 1.50421937e-03f, -1.25012249e-01f, -2.94630211e-02f, -6.12743432e-04f, 3.69075872e-02f,
  -8.80298987e-02f, -7.25141019e-02f, 9.30233151e-02f, -3.70620226e-04f, 5.27850837e-02f, -6.32748427e-03f, 2.40664389e-02f, -1.52508365e-02f, 2.47503892e-02f, 1.24222878e-02f,
  -2.88058743e-02f, -4.34089079e-02f, 3.04626860e-02f, -3.00287176e-02f, 4.82576787e-02f, 5.06620593e-02f, -1.35734707e-01f, 8.04773867e-02f, -9.32219103e-02f, -5.28633827e-03f,
  1.49501577e-01f, -2.55901907e-02f, -2.25571115e-02f, -1.57571640e-02f, -4.96256445e-03f, 1.00630239e-01f, 1.51343778e-01f, -6.14310894e-03f, -3.69294584e-02f, 8.66709352e-02f,
  -2.57420004e-03f, 3.52818877e-01f, 3.95827144e-02f, 8.95416886e-02f, -3.14570926e-02f, -6.83645308e-02f, 4.41050753e-02f, -7.66496286e-02f, 1.78548023e-02f, 6.30995142e-04f,
  1.51519030e-02f, -4.58302535e-02f, -1.56156287e-01f, 4.37501445e-02f, 3.15128118e-02f, 1.87009107e-02f, 2.80118771e-02f, -5.96927144e-02f, -5.15881851e-02f, 1.02359474e-01f,
  1.45889372e-01f, -8.28627944e-02f, 1.14887226e-02f, -1.56302727e-03f, -4.96780537e-02f, -1.54400733e-03f, -5.74514158e-02f, 8.32098350e-03f, 4.56251055e-02f, -2.36820411e-02f,
  3.21640633e-02f, -2.02511117e-01f, -5.40245712e-01f, -2.83062570e-02f, -7.31570087e-03f, 4.00769949e-01f, 8.66021961e-02f, -2.83442438e-01f, -4.60268289e-01f, 1.21060140e-01f,
  1.60554647e-01f, -2.07262158e-01f, -1.13614634e-01f, 3.77015859e-01f, 1.12405039e-01f, -3.79212126e-02f, 3.05195063e-01f, 2.88563997e-01f, -1.29453167e-01f, 2.93304831e-01f,
  -7.07110995e-03f, 5.00153124e-01f, 1.88785329e-01f, 4.99529809e-01f, 1.49387702e-01f, -1.86578721e-01f, 7.85882249e-02f, -4.13765013e-02f, 3.38685960e-01f, 1.01787545e-01f,
  9.29324925e-02f, -9.39968824e-02f, -1.86330497e-01f, 5.39871491e-02f, -1.82323270e-02f, 1.34708628e-01f, 1.06733434e-01f, 1.42320767e-01f, -2.02753782e-01f, -3.53528783e-02f,
  6.98636286e-03f, 3.18540521e-02f, 7.01472908e-02f, -1.84440449e-01f, -2.47619022e-02f, -1.15754373e-01f, -1.42315388e-01f, -9.70451310e-02f, -1.38701260e-01f, 1.03203319e-01f,
  -1.99831814e-01f, -4.02792506e-02f, 7.22564906e-02f, 4.68118042e-02f, -1.72100872e-01f, 9.85262822e-03f, -1.55513287e-02f, -9.65544283e-02f, -8.33958164e-02f, 1.25625161e-02f,
  6.88778311e-02f, 1.11543752e-01f, 4.08311859e-02f, 1.27642021e-01f, -5.51812537e-02f, -7.71071315e-02f, 5.05994409e-02f, -8.96274752e-04f, -1.22553609e-01f, 1.41149610e-02f,
  4.93129622e-03f, -1.17882818e-01f, -9.31371227e-02f, 1.43129393e-01f, 7.73004144e-02f, -4.57653888e-02f, -5.83775304e-02f, 2.59284414e-02f, -1.56067684e-02f, -6.68481514e-02f,
  1.36017963e-01f, -5.92255220e-02f, -9.84124020e-02f, 1.30544797e-01f, 4.89546880e-02f, 3.82917784e-02f, 3.35734040e-02f, -3.13970819e-02f, 3.88181536e-03f, 2.27009896e-02f,
  3.26628052e-02f, -1.85500264e-01f, -2.17070375e-02f, 2.10106522e-02f, -9.03598517e-02f, 5.09989224e-02f, -7.71519635e-03f, -2.84085562e-03f, 3.88449281e-02f, -4.69641872e-02f,
  8.85672420e-02f, 1.04958750e-01f, -2.51287464e-02f, -1.23095557e-01f, -3.16851474e-02f, -4.02926803e-02f, -1.56193906e-02f, 2.84655821e-02f, -7.36187622e-02f, -8.88752844e-03f,
  4.83871549e-02f, -1.07044756e-01f, 1.14556029e-01f, 1.82267372e-02f, 5.95904402e-02f, -6.46971166e-02f, -3.26111950e-02f, 3.59234698e-02f, 2.89856941e-02f, -2.87446603e-02f,
  -5.10324895e-01f, 9.84600112e-02f, -4.46482226e-02f, -7.97410905e-01f, 1.56049326e-01f, -3.90056297e-02f, -5.15407026e-01f, -2.07573939e-02f, -1.85332522e-01f, -6.33946955e-02f,
  -2.34818712e-01f, 4.29465212e-02f, 1.52603582e-01f, -3.74211401e-01f, -3.12218785e-01f, 7.18415827e-02f, -5.19581735e-01f, -1.88554898e-01f, 9.79185328e-02f, -2.42256582e-01f,
  -2.24703893e-01f, -3.85491610e-01f, -1.45755664e-01f, 1.59365371e-01f, -1.40027717e-01f, 8.91913921e-02f, -2.66840070e-01f, 2.44725998e-02f, -2.85145622e-02f, 6.20252714e-02f,
  3.92499864e-02f, -2.57279724e-01f, -3.14236991e-03f, 8.87158886e-03f, -3.81164961e-02f, 6.91304356e-02f, -9.99853238e-02f, -5.90592995e-02f, 3.54959555e-02f, -9.89531353e-02f,
  1.65482257e-02f, 1.40077412e-01f, -2.59402930e-03f, 3.64380889e-02f, 7.46299922e-02f, 4.41840664e-03f, 1.82709768e-01f, 7.83233345e-02f, 5.16546145e-02f, 1.16521612e-01f,
  1.32846795e-02f, 7.24954978e-02f, -9.88274999e-03f, 2.84409262e-02f, 3.37737873e-02f, 5.27577214e-02f, -8.68925676e-02f, 4.84490991e-02f, -3.90608609e-03f, -5.87443672e-02f,
  7.70977233e-03f, -1.02292262e-01f, 4.30834666e-02f, -1.89596768e-02f, -8.57452378e-02f, 2.22817808e-02f, -5.71619086e-02f, -1.10830748e-02f, -4.81385589e-02f, -1.88537091e-02f,
  -1.29204607e-02f, -3.79346386e-02f, 2.66179279e-03f, -1.21646844e-01f, -4.96566407e-02f, -1.39633760e-01f, 7.23283796e-04f, -4.39729504e-02f, 7.03130960e-02f, 5.27044106e-03f,
  -6.89321086e-02f, -2.58383006e-02f, 7.03311488e-02f, -4.91838418e-02f, -3.39107253e-02f, -3.96623602e-03f, 4.55669425e-02f, 2.23593619e-02f, -1.90935917e-02f, -4.07904014e-02f,
  -1.28517821e-01f, -5.79953790e-01f, 2.52706353e-02f, 3.39965113e-02f, 4.50401083e-02f, -4.08449285e-02f, -1.71697093e-03f, -3.18156332e-02f, -1.47617862e-01f, -2.91314218e-02f,
  -6.58575632e-03f, -4.56137918e-02f, -1.01226106e-01f, -1.35584220e-01f, 1.70307485e-05f, 3.47608179e-02f, -7.70525187e-02f, 3.42457257e-02f, -1.19415343e-01f, -3.33388075e-02f,
  3.42815481e-02f, 3.02809440e-02f, -3.87009569e-02f, -4.23315614e-02f, -1.07947722e-01f, -1.82092831e-01f, -1.00103924e-02f, -4.42441478e-02f, -7.24977627e-02f, 3.02157179e-02f,
  -7.34478235e-02f, -5.10851480e-02f, -4.48463149e-02f, -3.18269044e-01f, 8.07711110e-03f, -1.69065565e-01f, -2.53831949e-02f, -3.60616535e-01f, 4.94229347e-02f, -2.98056155e-01f,
  -4.81873117e-02f, 8.63829702e-02f, 2.08235875e-01f, -2.67017663e-01f, 1.20029092e-01f, 4.74788584e-02f, -4.58598197e-01f, -1.04771957e-01f, -7.63782188e-02f, -2.49188498e-01f,
  3.28748934e-02f, -2.52586663e-01f, -4.82446551e-02f, -1.51542470e-01f, -1.18936054e-01f, -8.00131038e-02f, -1.84455942e-02f, 1.88255608e-01f, -1.55184716e-01f, 1.59904748e-01f,
  -2.69475818e-01f, -2.90389180e-01f, -4.02849093e-02f, -1.30806506e-01f, -1.58022091e-01f, -2.43665241e-02f, -3.64312306e-02f, 2.16407105e-01f, -1.18407175e-01f, 4.35022712e-02f,
  -2.65983734e-02f, 6.03729524e-02f, -1.20503947e-01f, 2.99076401e-02f, -8.73316154e-02f, -1.07125804e-01f, -1.26872599e-01f, -2.86851257e-01f, -3.65506485e-02f, -8.99741277e-02f,
  -2.84086224e-02f, -9.34253484e-02f, 1.73130240e-02f, 7.69854486e-02f, 4.73316647e-02f, -7.04459026e-02f, -7.28494227e-02f, 1.55303627e-01f, 1.20357173e-02f, -2.16364577e-01f,
  -2.00664042e-03f, 9.17199701e-02f, 5.04690595e-03f, 1.11298241e-01f, -1.23693179e-02f, -1.01745389e-01f, -1.49305105e-01f, -7.21604377e-02f, -1.23455152e-01f, 7.37884687e-03f,
  9.98596177e-02f, -7.11726164e-03f, 7.75778443e-02f, -1.75856017e-02f, 1.76135637e-02f, -5.20626456e-02f, 1.48159608e-01f, 2.78455112e-03f, 3.72636802e-02f, -1.21696062e-01f,
  -6.24043904e-02f, 1.14923805e-01f, -3.80583778e-02f, -1.50939613e-03f, 8.88776705e-02f, 9.57397893e-02f, -1.35911733e-01f, 7.64066353e-02f, -4.46304977e-02f, 6.18791813e-03f,
  -5.11721849e-01f, -5.39143682e-01f, 8.79773591e-03f, -4.74076457e-02f, 2.53765490e-02f, -3.26503180e-02f, -5.34275696e-02f, 1.30191043e-01f, -1.08708642e-01f, -1.76999643e-01f,
  -1.57417089e-01f, 2.13299580e-02f, -7.44479448e-02f, 7.21985623e-02f, 1.02649838e-01f, -1.50315598e-01f, -1.18568704e-01f, -1.52020425e-01f, -4.85767014e-02f, -4.68788408e-02f,
  -1.24143869e-01f, -4.48865183e-02f, 1.31534621e-01f, -6.87027946e-02f, 5.95130026e-02f, 3.85545380e-02f, 4.20229882e-02f, 3.13461237e-02f, -8.87843072e-02f, -4.35085557e-02f,
  3.39204997e-01f, 1.34686753e-01f, -1.52943984e-01f, 2.27408428e-02f, -2.21651122e-01f, -5.99960208e-01f, -3.72212440e-01f, -2.03079849e-01f, -2.03039914e-01f, -1.20219253e-01f,
  -2.20613033e-01f, 1.90512642e-01f, 9.54743251e-02f, -2.34494153e-02f, 2.06169724e-01f, 7.85573348e-02f, 1.25981355e-02f, -1.66622549e-01f, 1.81978762e-01f, 1.90026775e-01f,
  5.20166829e-02f, 1.45220459e-01f, 3.15137535e-01f, -1.76087413e-02f, 9.99200866e-02f, 8.64563435e-02f, 4.36282575e-01f, -2.10666671e-01f, -1.18002094e-01f, 1.41963689e-02f,
  3.87887545e-02f, 1.15687788e-01f, -3.99220996e-02f, -8.03619921e-02f, 1.75354198e-01f, 5.92035465e-02f, -2.26776954e-02f, 1.65027496e-03f, -1.03086464e-01f, -2.51085255e-02f,
  3.98180783e-02f, 8.69661197e-02f, -1.05888978e-01f, 5.18594906e-02f, -1.91629559e-01f, -1.12359226e-01f, -4.18112613e-02f, -1.14266211e-02f, 1.44855957e-02f, 6.00959212e-02f,
  -4.91245603e-03f, 1.80096664e-02f, 6.77097868e-03f, 5.13106249e-02f, 1.29309110e-02f, -3.97469066e-02f, -1.80611163e-02f, -5.25503531e-02f, 4.38331952e-03f, 6.01095110e-02f,
  -4.51794602e-02f, 3.41714211e-02f, -2.04177084e-03f, -5.28328829e-02f, -1.66387502e-02f, 2.51976419e-02f, -1.54388458e-01f, -1.42797995e-02f, -2.53890478e-03f, -1.45406811e-03f,
  1.04555421e-01f, -2.20361277e-02f, -2.42322609e-02f, -2.21689567e-02f, -2.16210540e-03f, 1.62353471e-01f, -2.84113493e-02f, -6.54976219e-02f, 2.87631582e-02f, -3.58954780e-02f,
  -9.87936929e-03f, -1.16445562e-02f, 3.35409716e-02f, -1.83906034e-02f, 6.24215268e-02f, -2.72822194e-02f, -7.86175951e-02f, 5.93509711e-02f, -4.07487666e-03f, -9.83997881e-02f,
  7.99152926e-02f, 2.10231394e-01f, -4.51908447e-02f, -4.20106351e-02f, 3.99338733e-03f, -9.44744423e-02f, -5.04064858e-02f, -1.01411782e-01f, 2.76007131e-02f, 5.98983765e-02f,
  4.79151569e-02f, -4.74653207e-02f, 1.73200294e-02f, -1.39233753e-01f, -8.44678283e-02f, -6.24923743e-02f, 8.61285999e-02f, -9.94794630e-03f, -3.63499150e-02f, 1.71195492e-01f,
  3.91687267e-02f, 2.58173048e-02f, 6.22542240e-02f, -1.35387257e-01f, -1.22230209e-01f, 8.60381424e-02f, -4.61932123e-02f, -4.36761640e-02f, 2.43503153e-02f, -5.71573749e-02f,
  -1.57521278e-01f, -2.45255545e-01f, -2.21718311e-01f, -4.72037718e-02f, 2.22881004e-01f, 1.30931854e-01f, -4.31735128e-01f, 1.92154780e-01f, -6.00395918e-01f, -1.12413466e-01f,
  1.55430719e-01f, -2.74298906e-01f, -2.81300843e-01f, -2.16651950e-02f, -1.12977289e-01f, -4.58757192e-01f, 1.92827440e-03f, 6.07741959e-02f, -1.95882440e-01f, 1.82289749e-01f,
  7.89013207e-02f, 3.38078648e-01f, -6.78545283e-03f, 2.97386646e-01f, 7.65900910e-02f, 3.80552173e-01f, 5.60801566e-01f, 1.28853291e-01f, 4.07349378e-01f, 1.38495058e-01f,
  -1.67020470e-01f, -2.14707896e-01f, -1.48611426e-01f, -5.93350455e-02f, 1.37365222e-01f, 2.08177507e-01f, 3.22059654e-02f, 6.40447764e-03f, 9.57438797e-02f, -4.84902859e-02f,
  6.23694398e-02f, -4.27353522e-03f, 7.52666965e-02f, 3.29353735e-02f, 1.56054683e-02f, 1.89974345e-02f, -4.13110405e-02f, -8.24509859e-02f, -1.20347276e-01f, -2.29019925e-01f,
  -2.85161957e-02f, 1.11538582e-02f, 7.89099652e-03f, -1.67062376e-02f, 2.41467580e-02f, -6.15930967e-02f, 4.06180620e-02f, 9.14367661e-02f, 4.24468555e-02f, -6.68037906e-02f,
  9.60189104e-02f, 2.28570718e-02f, 8.34414512e-02f, -1.01538435e-01f, 1.71025116e-02f, -6.73307106e-02f, -9.02626961e-02f, -7.89724104e-03f, -2.40578149e-02f, -4.51157093e-02f,
  1.44227028e-01f, -6.33089757e-03f, 1.11906789e-02f, -4.62104945e-04f, 9.79706496e-02f, 6.07243702e-02f, 1.60123091e-02f, 5.55506162e-02f, 5.78018166e-02f, 2.13862006e-02f,
  -2.04986513e-01f, 1.49442166e-01f, 3.76840457e-02f, -7.60102551e-03f, 1.01911472e-02f, 5.09152131e-04f, 1.44080315e-02f, -6.37061372e-02f, 6.81540696e-03f, 5.42108454e-02f,
  1.26185015e-01f, 1.85438767e-01f, -1.06265284e-01f, -3.71209905e-02f, 2.50858366e-02f, 2.18654163e-02f, -1.72406211e-01f, 7.21490085e-02f, 5.98543212e-02f, -1.55691607e-02f,
  1.59932762e-01f, 1.15802422e-01f, 6.74359798e-02f, 3.15909721e-02f, 8.25519189e-02f, 4.28738669e-02f, 6.79898262e-02f, 6.86723143e-02f, 1.47851512e-01f, 1.24713406e-01f,
  1.75267249e-01f, 1.57987028e-01f, 5.19057661e-02f, 4.04815450e-02f, 1.31410688e-01f, 1.11583345e-01f, 8.92349556e-02f, 3.08611058e-02f, 2.26624217e-02f, 6.26955554e-02f,
  4.42842990e-01f, -1.70062825e-01f, 3.85776579e-01f, 1.64324164e-01f, 1.71692699e-01f, 6.57017753e-02f, 1.69331431e-01f, -2.26777226e-01f, 4.17445824e-02f, -2.60834873e-01f,
  5.89590482e-02f, 2.38320917e-01f, -1.21760987e-01f, 1.67698354e-01f, 1.18041009e-01f, -1.64435133e-01f, 4.03351262e-02f, 1.53209403e-01f, -1.46943303e-02f, 4.89370786e-02f,
  9.78116877e-04f, -1.20671846e-01f, 5.13528623e-02f, -2.06077054e-01f, 3.08815956e-01f, 8.57988894e-02f, -2.52005458e-01f, -5.78336827e-02f, 9.91378650e-02f, 7.73975179e-02f,
  5.09893820e-02f, -2.77211145e-03f, 3.04490235e-02f, -6.72944635e-02f, 2.61233319e-02f, -2.37363204e-02f, 3.87386195e-02f, 8.56223702e-02f, 1.00134034e-02f, 1.08215790e-02f,
  3.34138870e-02f, 3.66737954e-02f, 7.95277208e-02f, 8.23166743e-02f, -7.91438743e-02f, 5.15470393e-02f, 1.07555144e-01f, -3.31178401e-03f, 4.66926545e-02f, 6.06745705e-02f,
  4.92749885e-02f, 5.36137111e-02f, 4.21880372e-02f, 6.80601001e-02f, -3.47326393e-03f, 2.01895609e-02f, 6.59694821e-02f, 2.07536846e-01f, 4.72433791e-02f, -8.12753662e-03f,
  -7.25245401e-02f, -4.08206619e-02f, 2.58894078e-02f, 4.05043662e-02f, 9.40610319e-02f, 4.36153710e-02f, 8.32901299e-02f, -5.92546165e-03f, 8.68342072e-02f, 3.63996401e-02f,
  -3.31754331e-03f, -4.06201892e-02f, 8.59736092e-03f, 2.42395755e-02f, -1.19791040e-02f, 5.12075704e-03f, 5.57567291e-02f, 8.54667872e-02f, 1.39648151e-02f, 1.32292192e-02f,
  1.34408446e-02f, -1.94431134e-02f, -5.96044492e-03f, 9.93052498e-02f, -4.42520343e-02f, -3.69543135e-02f, -1.01761051e-01f, 1.27432242e-01f, -3.90699469e-02f, 1.24414656e-02f,
  -4.44744229e-01f, -4.31566298e-01f, -4.35375273e-02f, -9.85864550e-03f, 7.08808051e-03f, -7.19821895e-04f, -4.89503220e-02f, -7.68067501e-03f, -1.92435756e-01f, -1.15030527e-01f,
  -2.88483258e-02f, -1.02138314e-02f, -4.69226800e-02f, 8.48575234e-02f, -2.32375618e-02f, -1.29983053e-01f, 1.01984739e-02f, -1.58094943e-01f, -1.64963737e-01f, -6.74501583e-02f,
  3.33844237e-02f, -6.62233755e-02f, 9.89185497e-02f, 1.66893564e-02f, -5.25157228e-02f, 4.83071506e-02f, -4.16931137e-02f, -3.56485844e-02f, 4.75121103e-02f, -2.87367171e-03f,
  -9.96049166e-01f, 2.63230860e-01f, -9.22273397e-02f, 1.63162529e-01f, 1.16677545e-02f, 5.36482453e-01f, 4.47008848e-01f, 4.85822707e-02f, -9.50663015e-02f, 1.71581134e-01f,
  -1.39211211e-02f, -1.35893956e-01f, 6.96284696e-03f, 2.68344522e-01f, -5.53451069e-02f, 9.37377214e-02f, 3.44365001e-01f, 1.11651681e-01f, 7.87082687e-03f, -1.98559865e-01f,
  -1.66323274e-01f, 1.35128677e-01f, -1.66804016e-01f, -1.42197356e-01f, -1.76873039e-02f, -2.43293181e-01f, -1.02474183e-01f, -1.93012178e-01f, 1.05092235e-01f, -2.29610093e-02f,
  -1.88863352e-01f, -4.00236607e-01f, -3.45321447e-02f, -1.51465490e-01f, 6.94188625e-02f, 7.55156577e-02f, -2.78826356e-02f, -1.29863592e-02f, -4.55524772e-02f, -5.96875735e-02f,
  6.08105510e-02f, -1.01626605e-01f, 2.89636869e-02f, 7.42011517e-02f, -9.84202251e-02f, 3.73183601e-02f, 3.80924642e-02f, -1.68833230e-02f, 4.52983044e-02f, 7.34747052e-02f,
  4.46448624e-02f, -3.83190345e-03f, 4.92082238e-02f, 8.66587982e-02f, 5.36960782e-03f, -2.56567597e-02f, 2.87172310e-02f, 1.52927255e-02f, 1.65823102e-01f, 6.31592795e-02f,
  -5.04410863e-02f, 4.35820594e-03f, -1.21021561e-01f, 9.23414975e-02f, 1.28619328e-01f, 5.95858917e-02f, 6.38701692e-02f, -5.64569570e-02f, -5.37620578e-03f, -1.32098179e-02f,
  -1.15702890e-01f, 6.26096725e-02f, 2.06121840e-04f, -1.80132594e-02f, -2.10431665e-02f, -6.42196760e-02f, -5.01812696e-02f, -2.07073130e-02f, -2.26407815e-02f, 3.35982665e-02f,
  -1.03211761e-01f, -4.58038077e-02f, 3.64204086e-02f, 3.73218507e-02f, 2.59067807e-02f, 1.53726079e-02f, -8.92094150e-02f, 3.00232023e-02f, -1.65562183e-02f, 2.91627087e-02f,
  2.16311052e-01f, -2.21953228e-01f, -1.29767898e-02f, -3.54722105e-02f, -3.22076753e-02f, 8.77545172e-05f, 1.69407204e-02f, 2.25016437e-02f, -1.00777969e-01f, 7.16532022e-02f,
  1.53576853e-02f, -2.25137249e-02f, -8.31389874e-02f, -3.91117809e-03f, 3.49406451e-02f, 3.16155143e-02f, 8.12465604e-03f, -1.94087476e-01f, 1.26046702e-01f, -4.32956666e-02f,
  -6.41873181e-02f, -3.52068096e-02f, 5.03178127e-02f, 1.11823320e-01f, 1.09420605e-01f, -2.43524555e-02f, -7.61384815e-02f, -7.15682954e-02f, 1.92628071e-01f, -1.25779808e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 14)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 14;
const float L0_fan_Bp_bar_data[] = {
  1.49019554e-01f, 6.53089285e-01f, 7.96720982e-02f, 2.75213569e-01f, 4.05796081e-01f, 3.18593413e-01f, 1.48880735e-01f, 3.40985745e-01f, 6.55509830e-01f, 3.60092103e-01f,
  -2.55518883e-01f, 3.28167498e-01f, 2.84222007e-01f, 4.87114161e-01f
};

// L1_fan_Wp (Shape: 1 x 16)
const int L1_fan_Wp_rows = 1;
const int L1_fan_Wp_cols = 16;
const float L1_fan_Wp_data[] = {
  1.36895347e-02f, 2.82811821e-01f, 3.09394151e-01f, -4.32450615e-04f, -7.95926377e-02f, 4.94751297e-02f, 2.57985920e-01f, 2.54213810e-01f, -3.69924903e-01f, 3.01336229e-01f,
  -1.84029043e-01f, -1.89705953e-01f, -1.94134563e-01f, -7.18370033e-03f, 3.66341293e-01f, -4.74941824e-03f
};

// L1_fan_Wp_bar (Shape: 14 x 16)
const int L1_fan_Wp_bar_rows = 14;
const int L1_fan_Wp_bar_cols = 16;
const float L1_fan_Wp_bar_data[] = {
  1.22330084e-01f, 1.01150297e-01f, 1.53483793e-01f, -3.68135944e-02f, -1.09602481e-01f, 6.97402954e-02f, -5.40090315e-02f, 3.25590782e-02f, 4.32787985e-01f, -2.51582325e-01f,
  2.22760946e-01f, 3.15810263e-01f, -5.69982767e-01f, -2.17882738e-01f, -3.62621784e-01f, -1.47811428e-01f, -3.73198658e-01f, -6.09816378e-03f, 4.54660989e-02f, -6.87278807e-01f,
  4.61947143e-01f, 2.68941373e-01f, 3.70896608e-01f, -1.44973382e-01f, -1.88698068e-01f, 7.46570945e-01f, -1.44565389e-01f, -5.39074957e-01f, 3.19898427e-02f, 9.18383300e-01f,
  -2.28986546e-01f, 5.35195887e-01f, 5.41266203e-01f, -1.15856640e-01f, 5.57402372e-01f, 1.09408036e-01f, 5.90988714e-03f, 5.94105840e-01f, 4.47764754e-01f, -2.15330914e-01f,
  4.50938076e-01f, 5.88737965e-01f, 3.45090449e-01f, 2.72744060e-01f, -2.36649618e-01f, 6.72885001e-01f, 5.37311316e-01f, 2.58935869e-01f, 2.58834243e-01f, 1.34534568e-01f,
  3.28581840e-01f, 5.74610353e-01f, -1.79092046e-02f, 4.18851405e-01f, -6.75029218e-01f, -1.62457913e-01f, 3.99588317e-01f, 3.63610536e-01f, 7.94631600e-01f, 4.10183132e-01f,
  -7.26179779e-01f, -2.59263115e-03f, 1.28305092e-01f, 4.85993981e-01f, 3.21646810e-01f, 3.93760979e-01f, 2.85835385e-01f, 3.09581101e-01f, 6.42207125e-03f, 3.60485494e-01f,
  8.72595191e-01f, 6.79436088e-01f, -3.80237162e-01f, 4.56788465e-02f, -5.56778431e-01f, 1.93790972e-01f, -7.58770928e-02f, 2.52756625e-01f, 2.91089654e-01f, -1.61252409e-01f,
  6.09455351e-03f, -3.90797049e-01f, 1.77327186e-01f, -8.35881010e-02f, 4.70421433e-01f, 3.59384984e-01f, 2.38510713e-01f, -3.60202253e-01f, 5.59908628e-01f, 1.93199232e-01f,
  2.75748104e-01f, 6.06505647e-02f, 1.81457877e-01f, 5.48530638e-01f, -3.00701648e-01f, 5.32343149e-01f, -3.50643575e-01f, 6.35410786e-01f, -1.40523463e-01f, -9.60691869e-02f,
  5.08173347e-01f, -2.25690961e-01f, -1.49688467e-01f, 2.89195150e-01f, -1.38382018e-01f, 3.60530645e-01f, 1.44487128e-01f, -1.45628542e-01f, -4.52980511e-02f, -2.56074786e-01f,
  -2.57241577e-01f, 5.67537069e-01f, 1.75187439e-02f, 4.85388637e-01f, -5.20057917e-01f, 5.82002103e-01f, 5.49231172e-01f, -2.01542363e-01f, 5.02220571e-01f, 6.33733511e-01f,
  -1.94685087e-01f, 2.06927672e-01f, 1.39021158e-01f, 2.33594209e-01f, 3.65792334e-01f, -7.57031562e-03f, 1.65795796e-02f, 1.40801325e-01f, 1.16253078e-01f, 2.22423345e-01f,
  -4.67379451e-01f, 4.82571572e-01f, 1.53272465e-01f, -3.96256179e-01f, -3.41984749e-01f, -2.28353348e-02f, -3.47634465e-01f, 2.06205726e-01f, 6.34825289e-01f, 4.80554998e-01f,
  3.26730371e-01f, -1.24847725e-01f, -1.91090733e-01f, 2.27441028e-01f, 7.91752696e-01f, 2.29606982e-02f, 5.16112089e-01f, 1.04612999e-01f, -2.99658924e-01f, 4.67251658e-01f,
  6.59807682e-01f, 2.56789953e-01f, -1.19772866e-01f, 4.52135205e-01f, 3.61816704e-01f, -2.14017466e-01f, -3.48532170e-01f, 4.25873011e-01f, 3.46771210e-01f, 8.24482217e-02f,
  6.31928325e-01f, 1.92066714e-01f, 3.48688811e-01f, 4.51513827e-01f, -1.45361185e-01f, -6.76048268e-03f, 1.86019167e-01f, 5.32373607e-01f, 1.81522265e-01f, -3.18246454e-01f,
  2.62229770e-01f, 6.03388488e-01f, 2.07762480e-01f, -6.75387740e-01f, 6.31573677e-01f, -3.78314182e-02f, 1.14554040e-01f, 8.36796939e-01f, -2.44574174e-01f, -1.85014918e-01f,
  3.32884699e-01f, -3.79797190e-01f, 1.00315854e-01f, 2.68535584e-01f, 8.09049308e-02f, 2.33363107e-01f, 2.42818380e-03f, 1.27680048e-01f, -8.06592330e-02f, -4.82695788e-01f,
  -5.78947008e-01f, 7.29928851e-01f, -2.16011897e-01f, -5.09967446e-01f, -1.06488280e-01f, 3.23516876e-02f, 1.29240304e-01f, 1.04278080e-01f, 1.66604966e-01f, -6.34434000e-02f,
  6.09522939e-01f, -1.24513939e-01f, 2.74510384e-01f, 2.59889781e-01f, 5.40032566e-01f, 4.16845717e-02f, -6.16230607e-01f, -1.70210719e-01f, -8.53138864e-02f, -4.10141051e-01f,
  5.73109806e-01f, 4.99737352e-01f, -3.77625339e-02f, 6.44094706e-01f, -1.05921276e-01f, -1.51695207e-01f, 4.90609825e-01f, -1.87152073e-01f, 4.80934232e-01f, 3.06660771e-01f,
  -2.52455175e-01f, -2.57223934e-01f, 1.22488879e-01f, 1.20696254e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 14)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 14;
const float L1_fan_Bp_bar_data[] = {
  -5.79580605e-01f, 1.40711188e-01f, 5.96504509e-01f, 5.07721424e-01f, 2.37671927e-01f, 2.47837767e-01f, 1.23741180e-02f, 5.43432713e-01f, 4.57226366e-01f, 2.85261959e-01f,
  4.17973518e-01f, 3.93908381e-01f, 3.20662081e-01f, 5.38579747e-02f
};

// L2_fan_Wp (Shape: 1 x 16)
const int L2_fan_Wp_rows = 1;
const int L2_fan_Wp_cols = 16;
const float L2_fan_Wp_data[] = {
  -3.08964580e-01f, -1.33466581e-02f, 1.96656600e-01f, 2.88905054e-01f, -7.50452653e-02f, 5.42127043e-02f, -3.19936097e-01f, 8.34533796e-02f, 1.59178466e-01f, 1.50279507e-01f,
  2.74774104e-01f, -3.40466052e-01f, -2.61687547e-01f, 1.64389834e-01f, 1.22572958e-01f, 5.58035746e-02f
};

// L2_fan_Wp_bar (Shape: 14 x 16)
const int L2_fan_Wp_bar_rows = 14;
const int L2_fan_Wp_bar_cols = 16;
const float L2_fan_Wp_bar_data[] = {
  -1.89969823e-01f, 3.36659066e-02f, 2.20215589e-01f, 6.53560102e-01f, 4.26621646e-01f, 6.30390306e-04f, 4.10461664e-01f, 6.56452239e-01f, -7.48869926e-02f, -1.61412045e-01f,
  -5.25755525e-01f, 4.32348281e-01f, -3.23072106e-01f, -1.12426840e-01f, 2.32225925e-01f, 2.53505260e-01f, 3.85658816e-02f, 2.59117126e-01f, -2.29314994e-02f, -5.86438835e-01f,
  3.03730816e-01f, 3.24538797e-01f, 6.05147481e-01f, -7.75592476e-02f, -1.33335963e-01f, 4.33425546e-01f, 5.94531834e-01f, 3.65276821e-02f, 3.78774434e-01f, -5.04481077e-01f,
  7.72891007e-03f, 1.94324944e-02f, 5.45524776e-01f, -1.55164063e-01f, -2.94691443e-01f, 1.90416738e-01f, 3.65049630e-01f, 9.23293114e-01f, -3.22744697e-02f, 5.55599272e-01f,
  -2.87078172e-01f, 1.70223773e-01f, 3.26540112e-01f, 5.85358202e-01f, 2.33188018e-01f, -2.33253837e-01f, 3.40770155e-01f, 4.42761809e-01f, 4.18728232e-01f, 6.04303658e-01f,
  -4.62743163e-01f, -1.36683553e-01f, 1.56500593e-01f, -1.58401847e-01f, 5.29797733e-01f, -4.37038749e-01f, -1.02771528e-01f, 5.43929636e-01f, 1.04600839e-01f, 4.35161024e-01f,
  2.22286239e-01f, 1.63374409e-01f, -3.08226109e-01f, -4.44101244e-01f, 4.14280653e-01f, 2.23353758e-01f, -2.12404709e-02f, 4.25342739e-01f, -2.68940389e-01f, 5.23691535e-01f,
  -2.71057844e-01f, 6.56282753e-02f, 4.73371148e-01f, 5.82273483e-01f, 8.16709518e-01f, -3.43016893e-01f, -1.43730462e-01f, 6.69704378e-01f, -7.17803091e-02f, 9.66837183e-02f,
  2.46797726e-01f, -3.61704022e-01f, -1.44199744e-01f, 5.63905299e-01f, 4.42256093e-01f, -6.89453036e-02f, -1.04928404e-01f, 7.55484879e-01f, 5.31231761e-01f, 3.35896552e-01f,
  -9.08678100e-02f, -2.92512327e-01f, -6.14691913e-01f, 5.06692350e-01f, 2.63408124e-01f, -9.62663367e-02f, -2.22301260e-01f, 5.70747912e-01f, -4.51189965e-01f, -5.11099137e-02f,
  5.63420542e-02f, -3.97518903e-01f, 8.10662150e-01f, -7.73342401e-02f, -3.28518935e-02f, 3.37948680e-01f, -4.41773295e-01f, 5.62801242e-01f, 4.97922391e-01f, 1.46016143e-02f,
  -4.32099074e-01f, 9.86113474e-02f, 6.88993692e-01f, 2.67726958e-01f, -7.60683358e-01f, 8.83173525e-01f, 1.81422099e-01f, -2.57533714e-02f, 1.32592410e-01f, 3.26013803e-01f,
  7.16409385e-01f, 1.65115789e-01f, 4.50772434e-01f, 3.33731472e-01f, -3.50788116e-01f, 8.63595247e-01f, -1.44075558e-01f, -2.93149620e-01f, -2.78542876e-01f, 5.09211421e-01f,
  1.13430522e-01f, 5.15507817e-01f, 5.02840638e-01f, -2.83942260e-02f, 4.37769473e-01f, 1.24211736e-01f, -2.19164640e-01f, 9.28191245e-02f, -4.68552411e-01f, 7.93291330e-01f,
  4.72086258e-02f, -1.16059147e-01f, -2.34830022e-01f, 2.32310012e-01f, 7.61010766e-01f, 6.72900736e-01f, -7.37606645e-01f, 2.22922504e-01f, 3.10140550e-01f, 3.47961038e-02f,
  4.51633036e-01f, -3.94620180e-01f, 5.71938336e-01f, 3.69557202e-01f, 4.10620213e-01f, 1.87659860e-01f, 1.96688056e-01f, 6.99631810e-01f, -3.05170715e-01f, -1.11914389e-01f,
  8.06978762e-01f, 6.10144019e-01f, -6.06313586e-01f, -1.70348492e-02f, -1.37977779e-01f, 4.94816333e-01f, 9.45573449e-02f, -2.15827137e-01f, 2.44776443e-01f, 4.58895415e-01f,
  1.53581098e-01f, 4.39133458e-02f, 3.65819603e-01f, 6.19608939e-01f, -4.01879638e-01f, -3.09956789e-01f, 2.09169894e-01f, 1.67635560e-01f, -4.38339353e-01f, -1.02633044e-01f,
  -1.74679175e-01f, -4.49293196e-01f, 3.93339813e-01f, 3.60412985e-01f, -3.01902205e-01f, 7.86526084e-01f, 4.43790793e-01f, -1.24297641e-01f, 1.80484548e-01f, -1.72253810e-02f,
  6.77918375e-01f, 5.14127016e-02f, 7.23465025e-01f, 4.53429341e-01f, -7.82974005e-01f, -7.18253572e-03f, 3.75841826e-01f, 3.92448813e-01f, 8.84481966e-02f, -1.41292006e-01f,
  -2.09338889e-01f, -2.71270007e-01f, -5.81976920e-02f, 4.45288062e-01f, 2.98648983e-01f, 3.55026424e-02f, -4.29143459e-01f, -1.14011221e-01f, -1.33309383e-02f, -4.43612933e-01f,
  5.49904168e-01f, -4.06455517e-01f, 5.60737669e-01f, 7.48419046e-01f, -2.53813177e-01f, 2.65650183e-01f, -5.65652132e-01f, -2.23922968e-01f, 5.06666303e-01f, 2.18710110e-01f,
  4.84705180e-01f, -4.42290723e-01f, 5.75014770e-01f, 5.29142141e-01f
};

// L2_fan_Bp_bar (Shape: 1 x 14)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 14;
const float L2_fan_Bp_bar_data[] = {
  1.36698514e-01f, 8.07511061e-02f, 5.96728623e-01f, 3.34698319e-01f, 2.04579830e-01f, -6.54603094e-02f, 5.19388728e-02f, 2.91282713e-01f, 1.03415363e-01f, 2.74257541e-01f,
  4.42206502e-01f, 8.28840137e-02f, 2.46654898e-01f, 5.48519611e-01f
};

// L3_fan_Wp (Shape: 1 x 16)
const int L3_fan_Wp_rows = 1;
const int L3_fan_Wp_cols = 16;
const float L3_fan_Wp_data[] = {
  8.34415630e-02f, -8.11310261e-02f, 3.23078036e-02f, 1.48295000e-01f, -1.46930158e-01f, 1.74891770e-01f, -2.03261271e-01f, 1.87016979e-01f, 1.42132238e-01f, -1.59378961e-01f,
  -1.50012061e-01f, -1.37870148e-01f, 1.46827981e-01f, 2.38891795e-01f, -2.43695676e-01f, 1.99215829e-01f
};

// L3_fan_Wp_bar (Shape: 14 x 16)
const int L3_fan_Wp_bar_rows = 14;
const int L3_fan_Wp_bar_cols = 16;
const float L3_fan_Wp_bar_data[] = {
  2.93506384e-01f, 3.38475496e-01f, 2.13806555e-01f, -5.97854316e-01f, -2.74329036e-02f, -3.98188382e-02f, 7.88280725e-01f, 5.84413648e-01f, -3.53439689e-01f, 6.02113008e-01f,
  -2.31802732e-01f, 5.19836307e-01f, 5.68958402e-01f, 1.71093166e-01f, -4.51287925e-01f, -2.97070473e-01f, -1.65934354e-01f, 7.93836832e-01f, 4.84350294e-01f, -5.87581657e-02f,
  1.10398173e-01f, 1.21020973e-02f, -2.50388563e-01f, 3.29081595e-01f, 4.91577297e-01f, -1.55253867e-02f, 6.87912852e-02f, -1.92355290e-01f, -3.08172941e-01f, 6.10800743e-01f,
  -3.15337181e-01f, -1.76883221e-01f, 1.07836775e-01f, -3.89549077e-01f, 1.14317253e-01f, 1.05246911e-02f, 6.25134468e-01f, -1.74586773e-01f, 4.07902360e-01f, -2.84358084e-01f,
  -2.20579639e-01f, -1.39359757e-01f, 2.07849473e-01f, -2.57672489e-01f, 2.34744862e-01f, -5.90694308e-01f, 5.89997947e-01f, 7.18661070e-01f, -7.38423407e-01f, -6.40784442e-01f,
  -3.79095301e-02f, 2.53286541e-01f, -7.56362081e-02f, 1.11959398e-01f, 2.11464569e-01f, 8.51276368e-02f, 6.21629000e-01f, 4.19251651e-01f, 3.77278596e-01f, 5.30692220e-01f,
  -3.70735675e-02f, -2.71663755e-01f, 1.63021773e-01f, -5.11502147e-01f, -1.44389123e-01f, 4.29679155e-01f, 1.92612454e-01f, -2.65225433e-02f, 4.66126889e-01f, -3.05792212e-01f,
  3.76728803e-01f, 5.10834873e-01f, -5.00681281e-01f, 6.32028222e-01f, -3.21310945e-02f, 1.76341400e-01f, 2.01122776e-01f, 2.59364039e-01f, -5.70086241e-01f, 3.17651838e-01f,
  -1.09426022e-01f, 3.40397447e-01f, -3.04406434e-01f, 3.81657064e-01f, 8.41865242e-02f, 5.36234558e-01f, 5.43835521e-01f, 4.08745185e-02f, 3.00508767e-01f, 3.12138647e-01f,
  4.98779565e-01f, 7.04812288e-01f, 1.80023313e-01f, 1.95015743e-01f, 4.58802491e-01f, -1.78943232e-01f, 3.95612001e-01f, -3.23903710e-01f, -7.04405069e-01f, 4.48822737e-01f,
  4.32127178e-01f, -1.94067970e-01f, 3.64285052e-01f, -1.67828664e-01f, -5.23498535e-01f, 1.16870761e-01f, -4.80074346e-01f, 3.17997277e-01f, 5.27239442e-01f, 3.25839460e-01f,
  -2.23452542e-02f, 3.21982980e-01f, -2.54145205e-01f, -4.70758051e-01f, 1.87474489e-01f, 4.27773207e-01f, 3.85418236e-01f, -1.76475480e-01f, -2.51255095e-01f, -1.19554415e-01f,
  3.04099265e-02f, -5.89068174e-01f, 9.64381173e-02f, 2.45667785e-01f, 1.42506912e-01f, -3.79472494e-01f, 4.67179924e-01f, 4.83124286e-01f, 5.50846279e-01f, 6.10771179e-01f,
  1.19281083e-01f, 2.23776788e-01f, 3.54843646e-01f, -2.08917022e-01f, 2.13422209e-01f, 1.94303498e-01f, -8.77053559e-01f, -1.82042971e-01f, 5.17774224e-02f, -2.71020889e-01f,
  -4.10808355e-01f, 4.98593986e-01f, -2.30641767e-01f, 5.73956966e-01f, -4.04444873e-01f, 9.47960317e-02f, 9.44180906e-01f, 7.16746375e-02f, 5.86500801e-02f, -1.19270548e-01f,
  -2.74951339e-01f, -1.01092577e-01f, 1.42439991e-01f, 1.37116686e-01f, 6.19023681e-01f, 3.60636525e-02f, -3.33736032e-01f, 6.59307614e-02f, 2.97872145e-02f, -1.26090169e-01f,
  2.97785878e-01f, -2.11106077e-01f, 7.50210404e-01f, -4.35239404e-01f, 5.20119429e-01f, -1.93820044e-01f, -4.44593191e-01f, 5.20959496e-01f, -5.24875298e-02f, 2.73613006e-01f,
  5.98831058e-01f, -8.68351683e-02f, -3.28093439e-01f, -6.07110202e-01f, 2.25322604e-01f, 3.39745849e-01f, 2.14704424e-01f, -2.00042486e-01f, 1.53192490e-01f, 2.15291023e-01f,
  9.31972861e-02f, 8.18636239e-01f, -5.29640675e-01f, -5.14512837e-01f, 9.10645425e-01f, 1.76936403e-01f, 4.25751388e-01f, 2.35211700e-01f, 5.79141498e-01f, 3.53137195e-01f,
  3.35157901e-01f, -1.24120720e-01f, 8.03365648e-01f, -7.68534541e-01f, -4.51110192e-02f, 9.76944044e-02f, 3.16770762e-01f, 5.03429174e-01f, -7.33118281e-02f, -2.74042815e-01f,
  5.77834472e-02f, 5.27071476e-01f, 9.69758034e-02f, 5.96729696e-01f, 5.01101792e-01f, -7.41139473e-03f, 7.37331271e-01f, -2.92437345e-01f, -3.86706203e-01f, -9.65418071e-02f,
  -3.70669693e-01f, 3.75729769e-01f, 3.85550261e-01f, 5.41724823e-02f, -1.45627633e-01f, -5.73644698e-01f, 4.47781175e-01f, -9.50756311e-01f, 1.89648151e-01f, 1.96458045e-02f,
  -1.54937524e-02f, 5.17313302e-01f, -7.59207085e-02f, 5.02344549e-01f
};

// L3_fan_Bp_bar (Shape: 1 x 14)
const int L3_fan_Bp_bar_rows = 1;
const int L3_fan_Bp_bar_cols = 14;
const float L3_fan_Bp_bar_data[] = {
  1.67451069e-01f, -5.06367721e-02f, 2.83568770e-01f, -4.31543559e-01f, 1.17541797e-01f, 2.98471123e-01f, 2.94569701e-01f, -9.72174108e-03f, 1.09722391e-01f, 4.67847697e-02f,
  2.20002010e-01f, 2.90831506e-01f, 2.41935775e-01f, 8.98661092e-03f
};

// L4_linear_W (Shape: 12 x 16)
const int L4_linear_W_rows = 12;
const int L4_linear_W_cols = 16;
const float L4_linear_W_data[] = {
  -2.80208856e-01f, 6.66746497e-02f, 3.84713382e-01f, -5.46341181e-01f, 3.42478715e-02f, 3.07727277e-01f, 3.22743356e-01f, 4.69021983e-02f, 2.00048923e-01f, -6.88343704e-01f,
  -6.06069088e-01f, -7.22273529e-01f, -1.08051293e-01f, -7.56705701e-01f, -1.87289536e-01f, -5.76070845e-01f, -9.53507349e-02f, -5.22653043e-01f, 2.88615406e-01f, 2.88259745e-01f,
  -9.26317990e-01f, 8.91125277e-02f, 2.92553753e-01f, 1.65280089e-01f, -5.97555101e-01f, -4.66508299e-01f, -4.38638240e-01f, 2.85554707e-01f, -1.63226977e-01f, 2.03592349e-02f,
  -2.92383552e-01f, -3.72311741e-01f, -1.50063753e-01f, -4.13430005e-01f, -6.47763550e-01f, -4.34702262e-02f, -2.64739692e-01f, 3.91191512e-01f, -3.11682314e-01f, -5.48072308e-02f,
  -4.37254697e-01f, -3.52737725e-01f, -6.08128667e-01f, 5.51896095e-01f, 3.00291568e-01f, 6.40942678e-02f, 2.86525488e-01f, -6.66603625e-01f, 4.79674228e-02f, 6.03903353e-01f,
  -2.89164394e-01f, -3.55916262e-01f, 4.55951750e-01f, -2.69682407e-01f, -7.18715787e-02f, -6.79122627e-01f, 4.86828089e-02f, 3.35358351e-01f, 4.09084231e-01f, -4.42154035e-02f,
  1.98882863e-01f, -2.78769612e-01f, -7.77460754e-01f, 3.35335970e-01f, 3.30545932e-01f, -1.50114477e-01f, -1.59700215e-02f, -2.95149148e-01f, 3.75930130e-01f, -6.92266285e-01f,
  2.35268950e-01f, 9.86646712e-02f, 3.59035641e-01f, 1.16309442e-01f, 8.35566893e-02f, -6.20764315e-01f, -3.09685618e-02f, -1.60273686e-01f, 1.55686364e-01f, -2.27859721e-01f,
  4.29004610e-01f, -9.72626433e-02f, 8.15700814e-02f, -4.62887406e-01f, -4.69576567e-01f, 9.14869159e-02f, -4.16142434e-01f, 5.11228070e-02f, 2.99634755e-01f, -4.94359344e-01f,
  -6.36500895e-01f, -4.58198845e-01f, -5.40920675e-01f, 4.04560298e-01f, 5.70465624e-01f, -7.00349450e-01f, 3.90653834e-02f, 1.99975729e-01f, -4.00251865e-01f, 4.41175312e-01f,
  -6.77816153e-01f, 1.83165371e-01f, -7.01792479e-01f, 1.67743117e-01f, -4.64089602e-01f, 1.34600967e-01f, -3.86912793e-01f, 4.66881067e-01f, -3.39943290e-01f, 3.82387042e-01f,
  -2.40496576e-01f, 4.82089818e-01f, -1.32000983e-01f, 3.00928563e-01f, -4.88386989e-01f, -1.17314719e-01f, 1.66366234e-01f, -1.53944090e-01f, 3.81676137e-01f, -1.90868363e-01f,
  4.19707984e-01f, -7.84331635e-02f, 5.02539396e-01f, -6.95906520e-01f, -5.49638689e-01f, -7.16808200e-01f, -7.08858132e-01f, 6.24725699e-01f, 2.89143294e-01f, 3.40303361e-01f,
  2.41743267e-01f, 5.83797336e-01f, -3.32604617e-01f, -4.90045577e-01f, 4.59800661e-01f, -6.19926214e-01f, -2.73308277e-01f, -1.55615762e-01f, 3.19172472e-01f, -4.35045362e-02f,
  3.44096929e-01f, -4.14246202e-01f, -6.76175535e-01f, -4.07543659e-01f, 1.50925145e-02f, 5.67617893e-01f, -6.56324327e-01f, -5.70986032e-01f, 4.01226990e-02f, 1.80012584e-01f,
  -5.69241568e-02f, -4.09619808e-02f, 2.68372893e-01f, 2.70991743e-01f, -5.38961470e-01f, -5.86891294e-01f, -6.01696730e-01f, 1.95418492e-01f, 2.50631779e-01f, 3.79263639e-01f,
  -2.05456525e-01f, -6.74459994e-01f, -5.31642616e-01f, -3.11985552e-01f, 2.20945820e-01f, -4.31211382e-01f, 1.36225030e-01f, -3.71375859e-01f, -5.55410504e-01f, 2.81184670e-02f,
  1.95418864e-01f, 3.61486435e-01f, 4.29853559e-01f, -1.22791544e-01f, 8.48702043e-02f, -5.19426882e-01f, 1.79518878e-01f, -3.91948581e-01f, -4.29764032e-01f, -2.79395953e-02f,
  5.02338409e-01f, -6.59762397e-02f, -3.74666840e-01f, -1.54361323e-01f, -3.92227709e-01f, 4.97489512e-01f, -6.05937600e-01f, 4.40027863e-01f, -4.34805863e-02f, 6.35995120e-02f,
  -3.31847817e-01f, 4.64194506e-01f
};

// L4_linear_B (Shape: 1 x 12)
const int L4_linear_B_rows = 1;
const int L4_linear_B_cols = 12;
const float L4_linear_B_data[] = {
  -8.47560987e-02f, 6.16629981e-02f, -1.35118693e-01f, -1.21110238e-01f, 1.39412686e-01f, 2.17946619e-02f, 2.32801139e-02f, -5.95083758e-02f, -6.64511397e-02f, -8.10888112e-02f,
  -2.51908571e-01f, 1.20814845e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 1, 14
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        16, 1, 14
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        16, 1, 14
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L3_fan_Wp_data, L3_fan_Wp_bar_data, L3_fan_Bp_bar_data,
        16, 1, 14
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 4: L4_linear
    linear_forward_pgm(
        buffer1, x_out,
        L4_linear_W_data, L4_linear_B_data,
        16, 12
    );
    }
    