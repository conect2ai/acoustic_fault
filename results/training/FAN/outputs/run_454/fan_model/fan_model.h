/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 32 (x2)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 32;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    return (x > 0.0f) ? x : 0.0f;
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 12 x 120)
const int L0_fan_Wp_rows = 12;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  5.62938035e-01f, -1.22096516e-01f, -1.75743029e-02f, 1.90258503e-01f, 2.37230405e-01f, 3.09031934e-01f, 3.97990406e-01f, -1.70594286e-02f, -4.04365808e-02f, 2.12042648e-02f,
  1.83914617e-01f, -1.16588049e-01f, 6.68177679e-02f, 1.92448542e-01f, 1.35643661e-01f, -2.36270159e-01f, 3.22174698e-01f, 3.92035618e-02f, -1.15948141e-01f, 1.61766022e-01f,
  -2.68455539e-02f, 2.95040637e-01f, 3.03365663e-03f, -1.14635192e-02f, 3.78378212e-01f, -1.35055423e-01f, 1.62639059e-02f, -4.78641465e-02f, 1.02768473e-01f, 4.57707085e-02f,
  3.03332899e-02f, -2.48898361e-02f, 5.02963513e-02f, -8.29535574e-02f, 1.02939047e-01f, 6.48907423e-02f, 4.90708463e-02f, 1.76896565e-02f, -5.71827367e-02f, -2.49341521e-02f,
  -5.80342300e-02f, -7.29841441e-02f, -1.92168187e-02f, -3.44930105e-02f, 1.16465457e-01f, -6.21256046e-02f, 3.43786590e-02f, 7.76157752e-02f, -1.57073978e-02f, 6.80297166e-02f,
  3.84239890e-02f, -4.85854223e-02f, 1.04388520e-01f, -5.69812469e-02f, -8.04123748e-03f, 3.54997553e-02f, 6.47700531e-03f, 6.43389532e-03f, -4.54842523e-02f, 7.57486618e-04f,
  9.34067275e-03f, 3.97712290e-02f, -6.49350509e-03f, -2.97236606e-03f, 5.04918024e-02f, 3.64588499e-02f, -3.14648845e-04f, 1.00973500e-02f, -4.30811057e-03f, 7.00723603e-02f,
  5.22588240e-03f, 6.90090191e-03f, -2.52033621e-02f, -7.50459218e-03f, 9.26941782e-02f, -2.01899689e-02f, 1.38333617e-02f, -2.57743895e-02f, 2.74296384e-02f, -3.91021110e-02f,
  2.03140527e-02f, 2.21871864e-02f, 1.43230222e-02f, 7.72789074e-03f, 5.54929338e-02f, -6.96424544e-02f, 2.56633889e-02f, -3.38680036e-02f, 2.31984816e-02f, 2.48312578e-02f,
  1.53147439e-02f, 3.49809751e-02f, -1.01899497e-01f, -4.20920663e-02f, -8.62285644e-02f, -3.85946929e-02f, -5.07144406e-02f, 1.44929783e-02f, -5.26488200e-02f, 7.27516040e-02f,
  9.11638979e-03f, -8.05923063e-03f, 3.29374559e-02f, -2.52384646e-03f, -7.11035356e-02f, 2.35383697e-02f, -7.33939037e-02f, -8.27914178e-02f, 4.79341708e-02f, 2.59673875e-02f,
  3.26681286e-02f, 5.44224940e-02f, -6.32806644e-02f, 2.85420138e-02f, 2.98136286e-02f, 9.16421115e-02f, -9.86357592e-03f, -7.78023899e-02f, 7.44066760e-02f, -9.30699483e-02f,
  3.47161174e-01f, -6.23649694e-02f, -1.39676735e-01f, -1.48623474e-02f, -2.04461031e-02f, 4.89326000e-01f, 4.64631677e-01f, 2.78495178e-02f, 3.00956756e-01f, 1.52804658e-01f,
  2.62774438e-01f, -1.35903105e-01f, 3.44331652e-01f, 1.30869463e-01f, 3.99348050e-01f, 3.92840892e-01f, 8.21348876e-02f, 2.33604461e-02f, 1.64726824e-01f, -7.59219974e-02f,
  -5.91588207e-02f, 2.51879916e-02f, 6.21271785e-03f, -8.63356963e-02f, -1.54084049e-03f, -2.90924639e-01f, -1.85892090e-01f, -6.69194236e-02f, -1.44048318e-01f, 1.45421317e-02f,
  3.23892012e-02f, 1.37019336e-01f, -9.78061706e-02f, 2.13919971e-02f, -1.07305147e-01f, -5.67097105e-02f, -5.60775436e-02f, 2.59976406e-02f, 7.78930187e-02f, -1.80047266e-02f,
  2.63439659e-02f, -4.93137091e-02f, 1.75260846e-02f, 8.38776678e-02f, -6.10684156e-02f, -1.05145141e-01f, -7.16672242e-02f, 2.07800381e-02f, -1.58022363e-02f, 2.34031063e-02f,
  4.76007443e-03f, -4.23793420e-02f, -5.70523255e-02f, -4.51033562e-02f, 8.13540909e-03f, 6.34987373e-03f, -1.36156119e-02f, -2.81021409e-02f, -1.09847397e-01f, 1.03003211e-01f,
  -6.80916663e-03f, 3.11718415e-02f, 3.98363993e-02f, -7.64321089e-02f, 3.58051583e-02f, -6.40009344e-02f, -3.12918075e-03f, -2.29789279e-02f, -2.56634224e-02f, 7.30238259e-02f,
  2.38504335e-02f, -5.31201661e-02f, 6.75522685e-02f, 4.11076508e-02f, 4.18422855e-02f, 1.05000082e-02f, 2.52541271e-03f, 1.33709377e-02f, 3.62229645e-02f, -2.72660796e-02f,
  4.96732406e-02f, -1.63766526e-04f, 2.10803431e-02f, -5.26448935e-02f, 6.07561879e-02f, 6.11340404e-02f, 2.91979853e-02f, -7.03533366e-02f, -6.30361959e-02f, 1.59095768e-02f,
  4.52943221e-02f, -1.54641047e-01f, 1.17640838e-01f, -3.52289453e-02f, -6.39067357e-03f, 8.35789591e-02f, 8.26472342e-02f, -6.18945211e-02f, -6.78370222e-02f, 4.16853055e-02f,
  -4.74812165e-02f, -7.61107355e-02f, -1.14758067e-01f, -1.44926589e-02f, 7.55625777e-03f, 1.16473556e-01f, 7.70115200e-03f, -1.49296165e-01f, -6.31819516e-02f, 1.42289698e-02f,
  -1.06641069e-01f, -1.62465789e-03f, -4.54368331e-02f, 4.42373119e-02f, -9.29019973e-02f, 3.69312316e-02f, 2.46467534e-02f, 6.01743069e-03f, 2.72568651e-02f, -4.62295562e-02f,
  -1.52060881e-01f, -3.57152820e-01f, 9.75174308e-02f, 2.11145818e-01f, 5.49258105e-02f, -1.62165940e-01f, 7.91493207e-02f, 2.66544167e-02f, 1.37070911e-02f, -1.01846091e-01f,
  6.88429624e-02f, -1.19850375e-01f, -1.86651662e-01f, 8.43111724e-02f, -2.33411178e-01f, -2.71448940e-01f, -3.69608402e-02f, -1.47792576e-02f, 7.56411674e-03f, 2.70747468e-02f,
  -7.93427508e-03f, -7.81329051e-02f, -2.68438477e-02f, -1.29912153e-01f, 6.25212938e-02f, 1.47062361e-01f, 1.26087710e-01f, 5.70152944e-04f, 6.48341402e-02f, -1.07391432e-01f,
  9.60613191e-02f, -3.41121182e-02f, 1.23905636e-01f, 1.23893917e-02f, -1.86844226e-02f, 1.62101313e-02f, 8.07092860e-02f, -4.80423942e-02f, 1.12939969e-01f, -4.83329035e-02f,
  -6.26761466e-02f, -4.44279984e-02f, -3.67361121e-02f, -1.48491468e-02f, 8.53030235e-02f, 4.60152440e-02f, 1.55274821e-02f, 9.95284542e-02f, 9.09884796e-02f, -4.54541966e-02f,
  1.24527030e-02f, -2.30714567e-02f, 1.32494733e-01f, -7.78045803e-02f, -3.24511416e-02f, 3.30971815e-02f, -3.13606709e-02f, -6.42925650e-02f, -3.69963124e-02f, -3.53958048e-02f,
  -1.02167673e-01f, -6.76747859e-02f, -1.71696041e-02f, 5.76754883e-02f, 4.74093594e-02f, 7.12689757e-02f, 1.74597632e-02f, -4.41743527e-03f, -1.33699412e-02f, -3.98942977e-02f,
  1.79143511e-02f, 6.73883259e-02f, 8.43435973e-02f, 1.12569202e-02f, 4.66310456e-02f, 4.70984951e-02f, 2.46046390e-02f, -9.20756906e-02f, 1.93638764e-02f, 2.90729734e-03f,
  2.88815219e-02f, -4.64807414e-02f, 5.96733717e-03f, 7.63584599e-02f, -4.67520393e-02f, 9.77424160e-03f, 4.87455837e-02f, -2.59602070e-02f, 5.26388474e-02f, -2.20123623e-02f,
  -8.44048262e-02f, -3.51444989e-01f, 1.29948230e-02f, -2.89084874e-02f, -3.09344828e-02f, 1.40140799e-03f, -6.94490969e-02f, -4.25008945e-02f, -9.42241251e-02f, 8.89883656e-03f,
  2.40365230e-02f, 5.55380620e-02f, 3.02002747e-02f, -2.02682079e-03f, 3.21634151e-02f, -1.05806835e-01f, -3.02468129e-02f, -9.51464102e-02f, -3.73766832e-02f, -6.17133267e-03f,
  -2.86655538e-02f, -3.70618626e-02f, -3.30602913e-03f, 4.96566556e-02f, -3.11978851e-02f, 3.93754393e-02f, 5.45342304e-02f, -3.09002642e-02f, -4.91655059e-03f, -2.56272033e-02f,
  4.34165388e-01f, 1.14132315e-01f, -1.43256500e-01f, 1.28065452e-01f, 1.98104843e-01f, 3.35105866e-01f, 2.09678546e-01f, -3.60443853e-02f, 8.57331827e-02f, 6.31604493e-02f,
  8.45195055e-02f, 9.43255350e-02f, -3.21866840e-01f, 1.62101507e-01f, -8.67917463e-02f, -2.83520490e-01f, 3.17264766e-01f, 1.04772344e-01f, -9.90547314e-02f, 2.26422325e-01f,
  -2.87989676e-02f, 1.13753639e-01f, -1.37871981e-01f, -2.53799651e-02f, 1.66523740e-01f, 3.93428020e-02f, -2.10217722e-02f, -2.01005116e-01f, 1.65365204e-01f, 6.48252107e-03f,
  2.49757573e-01f, -8.48309398e-02f, 2.82941014e-02f, -4.31627780e-02f, 1.10662177e-01f, -1.74424995e-03f, 3.94957140e-02f, -8.16604495e-02f, 1.92495883e-02f, -2.03403533e-02f,
  6.02307320e-02f, -2.27697263e-03f, -7.69877946e-03f, -1.16383083e-01f, 1.06310047e-01f, -4.04708274e-03f, -2.08902713e-02f, 7.27231801e-02f, 2.96038240e-02f, 1.00653507e-02f,
  -9.29168910e-02f, -2.67093256e-02f, 1.59755107e-02f, 3.39734298e-03f, -5.51021472e-02f, -3.35864276e-02f, -2.48202980e-02f, 4.27366719e-02f, 7.53274933e-02f, 1.14160754e-01f,
  -1.13207892e-01f, -1.22895069e-01f, 7.20755802e-03f, 2.31884606e-02f, -1.26166258e-03f, 8.01441725e-03f, 4.34363373e-02f, -2.17863508e-02f, -7.78578222e-03f, -1.36633357e-02f,
  7.55107999e-02f, 5.86446598e-02f, -2.33230181e-02f, 6.46752790e-02f, 8.27126056e-02f, 6.31310865e-02f, 4.93635610e-02f, -3.18592123e-04f, 4.46957685e-02f, 1.51546309e-02f,
  -8.31992850e-02f, 5.15989289e-02f, -4.56743799e-02f, 6.41366541e-02f, -2.94062700e-02f, -2.40330510e-02f, -7.63260573e-02f, -2.18291041e-02f, -1.21963220e-02f, 6.50513694e-02f,
  2.39439145e-01f, 6.19174801e-02f, -3.56129254e-03f, 4.43381257e-02f, 5.04391594e-03f, 3.15036252e-02f, -3.70669328e-02f, 3.22342701e-02f, 2.09809206e-02f, 4.57834899e-02f,
  3.28594670e-02f, 6.39064461e-02f, 4.82537374e-02f, 4.92542125e-02f, -3.02724652e-02f, 6.92868158e-02f, 6.04025088e-02f, 3.29321809e-02f, 1.53361231e-01f, 1.44592291e-02f,
  3.40277106e-02f, -1.21443952e-03f, -6.04827367e-02f, -8.70924909e-03f, 9.06517655e-02f, 5.73697947e-02f, 7.84689784e-02f, -9.40671414e-02f, -3.14953066e-02f, 5.43977274e-03f,
  -3.29161227e-01f, 5.38251817e-01f, -2.78821886e-01f, 2.88593620e-01f, -1.88100770e-01f, 1.95186570e-01f, 1.25065520e-01f, 8.76514688e-02f, -9.66003351e-03f, 3.70942473e-01f,
  -1.97899789e-02f, -1.09216815e-03f, 8.52132123e-03f, 1.31817505e-01f, -4.93584096e-01f, 8.03190023e-02f, 4.76172231e-02f, 1.22982413e-02f, -8.14243630e-02f, -2.95748133e-02f,
  -1.85501501e-01f, 7.64252022e-02f, -3.20239305e-01f, 7.28913769e-03f, -1.15809225e-01f, 3.02021746e-02f, -7.83544965e-03f, -1.29254982e-01f, 1.46458214e-02f, -1.35884807e-01f,
  -1.16609238e-01f, 5.21508493e-02f, -2.20001992e-02f, -1.16973594e-02f, -2.16376763e-02f, -5.45229763e-02f, 2.26805941e-03f, -1.17711008e-01f, -1.09295495e-01f, -2.08194647e-02f,
  -7.99172819e-02f, -7.26527497e-02f, -3.74921337e-02f, -6.66787699e-02f, 2.00912952e-02f, 4.91287373e-03f, -8.93808156e-02f, 4.81688678e-02f, -3.12525630e-02f, 3.62932235e-02f,
  -5.35495505e-02f, 1.04980525e-02f, -4.38170433e-02f, 7.05350041e-02f, -8.20477903e-02f, 2.31227782e-02f, 3.84992734e-02f, -6.31040037e-02f, 6.30098209e-02f, 1.05411284e-01f,
  4.83954847e-02f, -3.00175175e-02f, 1.73113775e-02f, -2.29421575e-02f, -7.77185261e-02f, 7.99703151e-02f, -8.10004920e-02f, -6.79471642e-02f, -6.07788004e-02f, 7.20485374e-02f,
  4.56073470e-02f, -6.54976293e-02f, 1.34864151e-02f, 3.76435146e-02f, 4.18438241e-02f, 5.79525903e-02f, -8.64055678e-02f, 7.91029260e-03f, 1.43973185e-02f, 3.62976617e-03f,
  1.63667777e-03f, -2.00800672e-02f, 4.78603765e-02f, 1.95939802e-02f, -1.91650223e-02f, -1.15101330e-01f, 6.10801717e-03f, 4.82181609e-02f, -6.21201620e-02f, -6.75959215e-02f,
  2.78093576e-01f, 3.06817383e-01f, -3.47483158e-02f, -6.08737115e-03f, 1.90518126e-02f, -1.49791716e-02f, -5.34310043e-02f, 6.17929585e-02f, 2.36717202e-02f, -2.44110785e-02f,
  7.78494626e-02f, -9.25726548e-04f, 1.75922036e-01f, -5.30330166e-02f, -5.86250797e-02f, 9.73845497e-02f, 9.40945521e-02f, -1.32436007e-02f, -1.86575055e-02f, 3.88621760e-04f,
  8.68833885e-02f, 1.40914582e-02f, -8.58419016e-03f, -4.30655219e-02f, 3.29477601e-02f, 4.08707373e-02f, 3.84030752e-02f, 5.81739172e-02f, -2.49009430e-02f, 3.68529782e-02f,
  -6.54619277e-01f, -3.74610685e-02f, -1.33257806e-01f, -4.28165376e-01f, -7.94436783e-02f, 4.93864194e-02f, -2.93141335e-01f, -1.28878877e-01f, -4.08874035e-01f, 1.03381462e-01f,
  -4.35393117e-02f, -8.31875857e-03f, 1.41407788e-01f, -1.97121084e-01f, -2.02378005e-01f, 1.70305520e-01f, -1.61868766e-01f, -5.73634431e-02f, -6.70806840e-02f, -1.67111933e-01f,
  -1.64758652e-01f, -2.68809855e-01f, -6.04964793e-03f, 9.92516950e-02f, -1.47241741e-01f, 4.72463779e-02f, 1.08515561e-01f, 8.49443153e-02f, 7.62675852e-02f, 9.13465954e-03f,
  9.85885412e-02f, -9.04453471e-02f, -6.07713461e-02f, -1.07754087e-02f, -1.60718374e-02f, 6.24192245e-02f, 9.12998915e-02f, 4.61655296e-02f, -5.50580285e-02f, 3.10718175e-02f,
  9.41273272e-02f, -4.70325649e-02f, -9.17041302e-02f, 6.66990578e-02f, -7.96028003e-02f, -1.22519039e-01f, 4.26757731e-04f, -5.54541573e-02f, -7.53737381e-03f, 6.73848838e-02f,
  -2.53905598e-02f, 1.65933110e-02f, -1.24476604e-01f, 3.54358256e-02f, 4.43857443e-03f, -8.34681168e-02f, 6.54468220e-03f, 9.42182168e-02f, 3.11484709e-02f, 3.09614949e-02f,
  -1.20860268e-03f, 1.73421775e-03f, 5.77206537e-02f, 1.04477601e-02f, -2.94196289e-02f, -2.12186296e-02f, 1.71239264e-02f, 3.52546796e-02f, 1.79944455e-03f, -2.16930229e-02f,
  -2.57828441e-02f, 3.98383178e-02f, -2.96279434e-02f, -4.20141555e-02f, 3.09509896e-02f, 4.86007780e-02f, 1.18068780e-03f, 7.31390491e-02f, -1.63893607e-02f, -1.63359735e-02f,
  -6.92662923e-03f, -5.65102696e-02f, 1.72583498e-02f, 2.73528844e-02f, -2.53813583e-02f, 3.91181968e-02f, 2.35414933e-02f, 3.06856316e-02f, 2.92100236e-02f, 5.39104678e-02f,
  -6.93013668e-02f, -5.10027213e-03f, -1.35710556e-02f, 1.34635242e-02f, 6.66360781e-02f, 1.35360518e-02f, -4.03940752e-02f, 3.52375465e-03f, -7.82037079e-02f, -1.77460834e-02f,
  -2.61985650e-03f, -8.06886121e-04f, 5.02168089e-02f, -5.74090108e-02f, 1.99309252e-02f, 1.18738048e-01f, -4.91959006e-02f, -3.40856016e-02f, -3.85517068e-02f, 5.89825772e-02f,
  2.50612944e-02f, 4.12414828e-03f, -1.46963755e-02f, -3.73825841e-02f, -2.39985120e-02f, 3.38842981e-02f, -2.29296423e-02f, -7.55944997e-02f, 7.73553327e-02f, -7.72889927e-02f,
  -4.17277068e-01f, 5.41300029e-02f, 1.41885892e-01f, -2.27157753e-02f, -2.14678288e-01f, 3.73331070e-01f, 2.74798632e-01f, -1.82405099e-01f, -1.17964149e-01f, 1.61461487e-01f,
  -1.75955892e-01f, 2.31377676e-01f, -7.23760352e-02f, 1.08069777e-01f, -5.00660799e-02f, 7.01238513e-02f, 5.57887554e-03f, 1.15573667e-02f, -7.55832195e-02f, -1.03093497e-01f,
  -7.91920051e-02f, -1.83046069e-02f, 9.30764601e-02f, -1.27348661e-01f, 2.84659285e-02f, -8.46331939e-02f, -8.96844342e-02f, 6.40677288e-02f, 7.90169090e-02f, 4.22610678e-02f,
  5.96212856e-02f, -2.63879567e-01f, 3.15181687e-02f, 1.85972042e-02f, -7.71422610e-02f, 7.08874017e-02f, 9.08796117e-02f, 4.63275500e-02f, 3.22727636e-02f, 5.95603958e-02f,
  1.23443501e-02f, -8.76102373e-02f, -1.67376138e-02f, 6.33176342e-02f, 6.09514527e-02f, 2.98583340e-02f, 4.62132553e-03f, 4.00399715e-02f, -4.86216508e-02f, 9.65107083e-02f,
  -1.66667160e-02f, 6.87790811e-02f, 6.20693453e-02f, 1.86305474e-02f, -5.54222353e-02f, -1.73984505e-02f, 9.69407186e-02f, 8.42444897e-02f, -8.38294812e-03f, 6.02815598e-02f,
  -6.89026639e-02f, -3.50587070e-02f, -3.65172676e-03f, -1.07338741e-01f, 1.09900832e-02f, -7.56545812e-02f, 7.20315352e-02f, -4.41218447e-03f, 3.76377106e-02f, -1.45688877e-02f,
  -3.36872563e-02f, 1.65842287e-02f, -1.11561529e-01f, 4.47256714e-02f, -5.93052758e-03f, -5.38686141e-02f, 3.47481221e-02f, -5.36519215e-02f, -2.52027102e-02f, 1.50392018e-02f,
  -3.95432264e-02f, -4.16353829e-02f, 8.20574388e-02f, -3.50109376e-02f, -3.35649215e-02f, 3.98247913e-02f, -6.42475346e-03f, 2.77842209e-02f, -5.12172095e-02f, 4.61780140e-03f,
  -5.30679300e-02f, -2.46652380e-01f, -2.84767281e-02f, -8.32443610e-02f, 5.86278364e-02f, -9.39498655e-03f, -2.91138887e-02f, -6.75521791e-02f, 5.58890328e-02f, -6.98475540e-03f,
  -6.29097149e-02f, 9.48934928e-02f, 5.95625564e-02f, 5.25463885e-03f, 1.02356551e-02f, -7.80436993e-02f, -1.50100142e-02f, 8.65418762e-02f, 2.80890837e-02f, -2.99470648e-02f,
  -9.65346524e-04f, -1.02350287e-01f, 2.55856961e-02f, -1.34435035e-02f, 4.10580030e-03f, 4.97998297e-02f, -2.45305300e-02f, -2.71586096e-03f, -7.68846192e-04f, 3.09132971e-02f,
  -7.01766968e-01f, 1.75571337e-01f, 3.00305843e-01f, -1.45897761e-01f, -2.64341950e-01f, 6.49355277e-02f, 4.70837653e-02f, -3.54732201e-02f, -1.87307924e-01f, 1.60376996e-01f,
  -3.51634398e-02f, -1.75305922e-02f, -3.12921181e-02f, 1.06860548e-01f, -4.39242631e-01f, -2.72987802e-02f, -2.04027519e-02f, 2.24894434e-02f, 1.22651029e-02f, 4.73726876e-02f,
  -9.97310132e-02f, -4.99905758e-02f, 1.04117453e-01f, 8.65606889e-02f, -3.41972969e-02f, 1.22388959e-01f, -1.75373666e-02f, 1.72683939e-01f, 1.05599403e-01f, -1.38394637e-02f,
  1.38240293e-01f, -1.78753026e-02f, -6.12601917e-03f, 8.86600465e-02f, 2.01662164e-02f, 3.88431326e-02f, 4.56984639e-02f, 4.19010036e-02f, -1.05636884e-02f, -4.18226160e-02f,
  -6.58539534e-02f, 2.82888375e-02f, 7.73110287e-03f, -2.50631850e-02f, -3.03000733e-02f, 3.00214924e-02f, -4.20699082e-02f, -4.72161657e-04f, 9.68381464e-02f, -5.56517206e-02f,
  4.75988202e-02f, 5.65271527e-02f, -1.33980159e-02f, 1.36345131e-02f, 5.84151186e-02f, 1.65078044e-02f, 4.57944274e-02f, -1.88508499e-02f, -5.40119968e-02f, -6.73637586e-03f,
  -4.01917621e-02f, 7.63551742e-02f, 2.41640471e-02f, -1.99918710e-02f, 1.33680413e-02f, 3.16388458e-02f, 2.23436262e-02f, -1.33397123e-02f, 2.17275554e-03f, -1.20303417e-02f,
  -3.41132209e-02f, -1.09125469e-02f, 4.16142792e-02f, 6.49113357e-02f, 1.05843218e-02f, -2.67413054e-02f, 2.92460080e-02f, 2.40645949e-02f, 4.96381074e-02f, 3.37267742e-02f,
  3.35325785e-02f, 4.67053317e-02f, 2.91882567e-02f, 1.98572222e-02f, -1.55900856e-02f, -2.56718285e-02f, 7.00871497e-02f, -4.22722772e-02f, 2.70617735e-02f, 1.69901084e-02f,
  -2.11491194e-02f, -1.10881321e-01f, 1.00821905e-01f, -6.02832623e-03f, 6.07385896e-02f, -7.64174312e-02f, 1.21938521e-02f, 2.28577387e-02f, -6.20196946e-02f, -1.03352778e-01f,
  7.09517077e-02f, 4.86351587e-02f, -4.89017032e-02f, 2.99261827e-02f, 9.00558233e-02f, 7.45119387e-03f, 8.06563646e-02f, 3.15900482e-02f, -8.77320990e-02f, 1.34130167e-02f,
  -5.29461205e-02f, -5.91023313e-03f, 2.98794117e-02f, -2.62703486e-02f, -8.79354775e-02f, 1.47220381e-02f, -1.15686715e-01f, 6.37837499e-02f, 1.56387705e-02f, 7.50361606e-02f,
  -3.54041457e-01f, -3.15214694e-01f, -5.70416786e-02f, -2.92952776e-01f, -2.97345705e-02f, 1.75264731e-01f, 1.65415987e-01f, -1.79885462e-01f, -1.92326814e-01f, -6.66354448e-02f,
  1.27775609e-01f, -1.98377490e-01f, 6.06063828e-02f, -3.36165726e-02f, 4.27576214e-01f, 2.59656698e-01f, 1.82728082e-01f, -6.12680353e-02f, -6.36301562e-02f, -1.51356161e-01f,
  1.69837940e-02f, 1.28337950e-01f, 2.15893805e-01f, -4.85703647e-02f, -9.69073400e-02f, -1.49644881e-01f, 1.36712730e-01f, -4.62888442e-02f, 2.00286862e-02f, 1.36340424e-01f,
  1.16257831e-01f, -1.89766318e-01f, -8.84073228e-02f, -1.32933054e-02f, 5.30309081e-02f, 1.20413890e-02f, 1.74144022e-02f, 3.67589407e-02f, 2.34192703e-02f, -2.65697427e-02f,
  -9.34544653e-02f, -1.66676808e-02f, 6.39851950e-03f, 6.00962481e-03f, -1.16324633e-01f, -2.80513018e-02f, -4.55794632e-02f, 4.05760929e-02f, -5.40578105e-02f, 1.17214874e-03f,
  8.06256372e-04f, 2.92674918e-02f, -8.05207714e-02f, 4.09123339e-02f, -2.62457170e-02f, -7.01967953e-03f, 1.01452403e-01f, -2.85746697e-02f, 6.15930595e-02f, -1.20460264e-01f,
  -2.51663104e-02f, 2.45499313e-02f, -3.31039578e-02f, 1.31831720e-01f, -5.99623285e-02f, 1.24426059e-01f, 1.70613825e-02f, 1.22368976e-01f, -1.54132431e-03f, 4.95754518e-02f,
  1.79402309e-03f, -8.47136229e-03f, -3.49544385e-03f, -3.50600369e-02f, -4.83384542e-03f, 3.38202789e-02f, -1.98957091e-03f, -9.94857680e-03f, -2.39293166e-02f, 5.48462011e-02f,
  -1.98940579e-02f, -4.75955941e-03f, -3.86653915e-02f, 6.19343705e-02f, 1.18095212e-01f, -3.43701541e-02f, -6.57316595e-02f, -1.39878867e-02f, 3.00355703e-02f, 3.04839667e-03f,
  1.29641695e-02f, -1.52698189e-01f, 4.79406975e-02f, 1.75954569e-02f, 1.32772699e-03f, 4.57144622e-03f, -9.28340759e-03f, -1.04898460e-01f, -1.19364206e-02f, 6.30320981e-02f,
  -1.36030437e-02f, -6.06711162e-03f, -4.32922319e-02f, -9.36746523e-02f, 7.11918250e-02f, 1.15332073e-02f, 7.34753460e-02f, 9.79683828e-03f, 3.71855721e-02f, -5.62145822e-02f,
  -1.40842330e-02f, -2.17509083e-02f, 4.13049310e-02f, -3.72683220e-02f, -1.03417374e-02f, -1.35756109e-03f, -1.27274739e-02f, -5.44584729e-02f, 3.83554772e-02f, 7.24694133e-02f,
  -9.93890837e-02f, 1.70273762e-02f, 1.05116725e-01f, -1.32147104e-01f, 1.80518374e-01f, -3.45585085e-02f, -1.32931396e-01f, 1.12860814e-01f, 4.75478351e-01f, -3.66926968e-01f,
  -2.05988184e-01f, -2.11648419e-01f, -4.56730947e-02f, -3.78980130e-01f, 2.08691992e-02f, 2.34316513e-01f, -5.93866371e-02f, -2.84657981e-02f, 3.36337447e-01f, -8.36684108e-02f,
  1.19386196e-01f, -1.86668053e-01f, -3.40888090e-02f, -2.63004210e-02f, -1.18499272e-01f, -5.69036938e-02f, -2.75256276e-01f, 9.32406783e-02f, -3.97463530e-01f, 6.61353767e-02f,
  -1.19600557e-02f, 1.05674535e-01f, -2.85558272e-02f, 7.87442699e-02f, -6.14770576e-02f, -1.63158383e-02f, -7.63904527e-02f, 2.45467070e-02f, 8.21051896e-02f, 1.03951488e-02f,
  -6.65749162e-02f, -1.68931097e-01f, -3.72254290e-02f, 1.12528419e-02f, 1.29884258e-01f, -7.89257064e-02f, 6.77511990e-02f, -1.04808332e-02f, -9.32828896e-03f, -1.84258912e-02f,
  5.59428036e-02f, 2.46697441e-02f, -9.62555483e-02f, -3.17214355e-02f, -2.88049392e-02f, -2.45620089e-04f, -1.83566697e-02f, -2.19395310e-02f, 3.28706484e-03f, 9.91908014e-02f,
  9.40664578e-03f, 2.02424005e-02f, 3.36349532e-02f, -1.04883434e-02f, -2.91793384e-02f, 2.94066556e-02f, -7.78659880e-02f, -1.15874819e-02f, 2.59909872e-02f, -1.31931081e-01f,
  -1.09588623e-01f, 1.33556025e-02f, 7.26895221e-03f, -2.49100421e-02f, -3.67703699e-02f, 2.12259088e-02f, -2.21723691e-02f, -8.03567376e-03f, 1.36810280e-02f, 4.26419601e-02f,
  2.58373860e-02f, -4.60538268e-02f, -2.63781231e-02f, -3.88689972e-02f, 5.60700409e-02f, 1.01784006e-01f, -9.51948017e-02f, -2.95180306e-02f, 8.10688138e-02f, -5.20237833e-02f,
  2.10345141e-03f, 2.64351778e-02f, 1.63421519e-02f, -1.00576699e-01f, 6.13174066e-02f, -1.08032912e-01f, 1.53612765e-02f, 4.72347960e-02f, 6.09496832e-02f, -4.54568211e-03f,
  -5.10085858e-02f, 1.27188079e-02f, -1.12801030e-01f, 3.79344895e-02f, -2.97234841e-02f, 5.71764931e-02f, -5.04567176e-02f, 6.19429909e-02f, 3.09158247e-02f, 7.14861555e-04f,
  -1.27866983e-01f, -6.26768693e-02f, -1.09717948e-02f, -7.73331001e-02f, -7.14090317e-02f, -6.46713004e-02f, 4.47481573e-02f, 1.89900082e-02f, -3.35761085e-02f, 1.56719703e-02f,
  1.73633039e-01f, -5.49037993e-01f, 1.18105628e-01f, -1.83338553e-01f, 3.37306485e-02f, -5.14049083e-02f, 1.69718459e-01f, -3.14106196e-01f, -1.21104922e-02f, -3.14226955e-01f,
  -1.55906826e-01f, 4.36900333e-02f, -1.65095463e-01f, -3.34751904e-01f, 3.15136582e-01f, -1.68702096e-01f, -1.36493042e-01f, -1.47167072e-01f, -1.14807934e-02f, -1.29468814e-01f,
  5.50067872e-02f, -2.52650946e-01f, -7.89700523e-02f, -1.30021393e-01f, -1.52342573e-01f, 5.51277548e-02f, 5.84305823e-02f, 1.59333482e-01f, -9.97501761e-02f, -5.65745644e-02f,
  -2.26471052e-01f, -1.67527467e-01f, 3.44411694e-02f, 3.43500338e-02f, -5.58319082e-03f, 5.56172021e-02f, 1.03066996e-01f, 8.51938352e-02f, 1.17455460e-01f, -3.06152664e-02f,
  3.08913365e-02f, -3.13979834e-02f, -3.92071605e-02f, 5.15062660e-02f, -1.19157573e-02f, -4.38027494e-02f, -6.74939901e-02f, 1.68246757e-02f, -1.10495113e-01f, 8.99222568e-02f,
  3.29323276e-03f, -3.03670968e-04f, -7.17437267e-02f, -5.35190590e-02f, 8.18393156e-02f, -6.76559210e-02f, 7.08924606e-02f, 4.68594618e-02f, 4.97390225e-04f, 1.83862206e-02f,
  6.34310618e-02f, 1.01624906e-01f, -4.78690527e-02f, -3.80690880e-02f, -7.04642087e-02f, -5.57189854e-03f, -5.99189401e-02f, -6.82786405e-02f, 3.70998830e-02f, -8.07241276e-02f,
  -2.19710320e-02f, -8.13907459e-02f, -9.25560147e-02f, -3.93349379e-02f, -4.55072038e-02f, -2.87282970e-02f, -9.13857762e-03f, -7.05384761e-02f, -2.68828869e-02f, 6.23799767e-03f,
  1.02246944e-02f, 2.71252636e-03f, -1.12639785e-01f, 2.58725695e-02f, -2.18721144e-02f, 9.17904172e-03f, -4.07059714e-02f, -9.18538496e-02f, -1.01868175e-02f, 8.78263712e-02f,
  -2.81630695e-01f, -1.25569075e-01f, 4.18435372e-02f, -3.48275043e-02f, -4.76242937e-02f, -4.58595008e-02f, 3.07746120e-02f, -1.18722118e-01f, -9.90679637e-02f, -1.09338993e-02f,
  8.88400804e-03f, -2.71455608e-02f, 9.46165323e-02f, 1.92446094e-02f, 3.31486873e-02f, -5.63254301e-03f, 1.31877288e-01f, -4.96813171e-02f, 4.09528688e-02f, -5.23756631e-02f,
  -1.47590358e-02f, 1.53337708e-02f, 6.07055016e-02f, 1.34108830e-02f, 2.96307988e-02f, 2.16979980e-02f, 4.25457081e-04f, 7.92113990e-02f, -2.84778103e-02f, 2.57087834e-02f,
  3.39759827e-01f, -1.22977188e-02f, 2.47968182e-01f, 1.58564344e-01f, -1.34221911e-01f, 7.36595597e-03f, -1.21310120e-02f, -1.07001558e-01f, 2.08358511e-01f, -1.28847510e-01f,
  -2.90378511e-01f, 1.90234229e-01f, -1.54591113e-01f, -1.71178877e-01f, -3.75395343e-02f, -2.62554139e-01f, 8.70104134e-02f, 1.75385550e-02f, -1.77825615e-02f, -5.94093986e-02f,
  2.17265729e-02f, -3.89231980e-01f, -4.98654321e-02f, -2.68041432e-01f, 8.97973627e-02f, 2.02337876e-01f, -1.06180772e-01f, -6.92110732e-02f, 9.17534679e-02f, -8.07034746e-02f,
  3.28546464e-02f, 3.68361385e-03f, 6.92457408e-02f, 6.28273040e-02f, 1.17752872e-01f, -2.03365390e-03f, 7.17775151e-02f, 4.14914154e-02f, 6.03552535e-02f, 7.10626617e-02f,
  2.52510365e-02f, -2.94009317e-03f, -3.85263190e-02f, -4.28238772e-02f, -1.79941244e-02f, 8.23931172e-02f, 4.53184023e-02f, 9.00949016e-02f, -1.44474609e-02f, -1.23426896e-02f,
  3.88081782e-02f, 2.68931929e-02f, 6.77444562e-02f, -4.06144094e-03f, 7.68820643e-02f, 2.02512089e-02f, -1.51826150e-03f, 3.72157879e-02f, 6.01464696e-02f, 5.37448153e-02f,
  -2.94846483e-02f, -4.34444584e-02f, -1.39313779e-04f, -2.13699564e-02f, -1.79585535e-02f, -4.23644595e-02f, -5.97098991e-02f, -7.69463405e-02f, 6.83885366e-02f, -4.44178022e-02f,
  2.92814821e-02f, 1.47211486e-02f, -9.49186534e-02f, 3.36316787e-02f, -2.89596058e-02f, 1.76733336e-03f, 3.78382765e-02f, -9.64718778e-03f, 3.92269529e-02f, 4.01054472e-02f,
  -3.74660492e-02f, -4.92170872e-03f, -6.51859716e-02f, -1.87031347e-02f, -6.77974820e-02f, 2.19135564e-02f, -7.44487951e-03f, 6.64668605e-02f, 6.79156631e-02f, -2.44229399e-02f,
  -9.10787284e-02f, -1.87877551e-01f, -4.40931804e-02f, 2.51003052e-03f, -3.77917327e-02f, -1.01867877e-02f, -4.01894189e-03f, -8.32435768e-03f, -4.38260660e-02f, -5.61789386e-02f,
  1.27705680e-02f, -1.60259046e-02f, 2.88873427e-02f, 9.41358879e-03f, 5.36288973e-03f, -4.01301906e-02f, 5.51474141e-03f, 7.10090622e-02f, -7.96322944e-04f, 1.42098470e-02f,
  1.34919947e-02f, 3.48397940e-02f, -2.30490956e-02f, -6.90393290e-03f, -2.12949738e-02f, 4.33366559e-02f, 7.20990449e-02f, 8.55712891e-02f, -2.52122991e-02f, -3.30943689e-02f
};

// L0_fan_Wp_bar (Shape: 8 x 120)
const int L0_fan_Wp_bar_rows = 8;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -4.36370581e-01f, 6.78434074e-01f, 3.69557351e-01f, -3.72996062e-01f, 1.64226532e-01f, -1.32973716e-01f, -3.23663116e-01f, 1.77101120e-01f, 6.60364935e-03f, 7.00300559e-02f,
  -1.31253317e-01f, 2.74805546e-01f, 8.94779488e-02f, -1.46870106e-01f, -6.65876925e-01f, -1.92267761e-01f, -5.27166009e-01f, -3.25436234e-01f, -2.68269554e-02f, -1.84121266e-01f,
  -2.87008196e-01f, -4.16704476e-01f, -2.15693370e-01f, 1.59068316e-01f, 1.02091886e-01f, 1.91580206e-01f, -3.60345274e-01f, 1.98437080e-01f, 8.87218583e-03f, 6.21378981e-02f,
  -2.06835210e-01f, 1.66519880e-02f, 1.59858465e-01f, 3.91327329e-02f, -1.18078813e-01f, 8.69336128e-02f, -6.27980307e-02f, 1.55571960e-02f, 8.36242437e-02f, 1.22541241e-01f,
  2.40757596e-02f, 8.33330601e-02f, 5.92896119e-02f, 2.80422140e-02f, 8.30358863e-02f, 1.86876014e-01f, 8.39963108e-02f, -1.96188092e-02f, 1.06059693e-01f, 1.13987900e-01f,
  1.90011814e-01f, 2.44830605e-02f, -3.63106839e-02f, -1.89272091e-02f, 4.60563302e-02f, 1.57615051e-01f, -1.51955048e-02f, 6.92196488e-02f, -2.43663099e-02f, -5.51782362e-02f,
  -6.44061565e-02f, -1.23087458e-01f, -1.27871642e-02f, 5.47624379e-02f, 7.69045800e-02f, 2.91469507e-02f, 3.43157873e-02f, -5.37412576e-02f, 1.95652544e-02f, -2.29282025e-02f,
  -1.63824558e-01f, 2.52962168e-02f, -1.12352788e-01f, -1.85117964e-02f, -1.21927291e-01f, -2.35463344e-02f, -3.98673899e-02f, -3.92748695e-03f, -8.17987695e-02f, -9.61824134e-02f,
  -9.45270509e-02f, -5.49804792e-02f, 6.38531446e-02f, -1.16246514e-01f, 4.15120944e-02f, 5.83821796e-02f, -2.75904629e-02f, 6.62380680e-02f, -7.40101635e-02f, -1.63512737e-01f,
  -5.41164517e-01f, -5.52626133e-01f, -5.56784607e-02f, 4.98591997e-02f, 3.47346021e-03f, -6.28714114e-02f, -9.55140516e-02f, 6.10334650e-02f, -1.09288946e-01f, -6.89111650e-02f,
  -7.24901333e-02f, -9.23453048e-02f, -2.13281989e-01f, -2.16718353e-02f, -1.03223816e-01f, -1.06592454e-01f, -9.70458910e-02f, 6.41595945e-02f, -6.43659234e-02f, -2.04942208e-02f,
  2.62361318e-02f, -5.21597266e-02f, 4.76283999e-03f, -7.15296194e-02f, -4.62258458e-02f, -1.10976785e-01f, -6.02627508e-02f, 3.11299972e-02f, -3.12951952e-02f, -1.00204736e-01f,
  -2.99897552e-01f, -4.38873768e-01f, -6.16443813e-01f, -4.26257372e-01f, 1.31046981e-01f, -5.08562922e-01f, -4.14069831e-01f, -1.21865146e-01f, -3.31781767e-02f, 2.40496889e-01f,
  -4.19329479e-02f, -5.80179617e-02f, 1.72798365e-01f, -6.18634701e-01f, -4.06280875e-01f, -2.01816410e-01f, -8.04888189e-01f, -3.90174121e-01f, 1.55851664e-02f, -3.69651705e-01f,
  -6.93577230e-02f, -2.46863604e-01f, -5.68179786e-01f, 1.21529080e-01f, -3.76641601e-01f, 1.82995424e-01f, 4.87954974e-01f, 1.54927239e-01f, -2.71454781e-01f, -1.63754262e-02f,
  -1.18403077e-01f, 9.28946808e-02f, -9.60213244e-02f, -7.55719915e-02f, -1.75978318e-01f, 5.21208979e-02f, -2.48652436e-02f, 6.43452629e-02f, 5.04207537e-02f, -6.45925775e-02f,
  1.87046162e-03f, 3.74079458e-02f, -1.06337391e-01f, 1.11263692e-01f, 6.97989315e-02f, 5.52205555e-02f, -4.23578136e-02f, -5.59417494e-02f, -1.01134919e-01f, -1.60927445e-01f,
  -2.44643465e-01f, -1.30421221e-01f, -9.11972523e-02f, -5.30281523e-03f, -1.19366929e-01f, -2.19307598e-02f, -1.24469303e-01f, 5.84152900e-02f, -7.98294470e-02f, -4.60268417e-03f,
  5.64290732e-02f, 9.50136557e-02f, -1.66434776e-02f, 4.55663279e-02f, -1.24752939e-01f, 4.00896035e-02f, -6.64518699e-02f, 6.69689402e-02f, 5.82959168e-02f, 4.85219527e-03f,
  2.38220077e-02f, 3.96036953e-02f, 1.25547484e-01f, -7.79534653e-02f, -8.32469482e-03f, 2.71169562e-02f, 3.76687646e-02f, 1.05776310e-01f, -1.49609640e-01f, -1.84977502e-02f,
  5.57968505e-02f, -1.28844827e-01f, 7.03050196e-02f, 7.49472380e-02f, -6.83674589e-02f, 6.58436045e-02f, 4.83851135e-02f, 2.86655594e-03f, 4.25552540e-02f, -2.32186280e-02f,
  -1.31095663e-01f, 7.26555884e-02f, 1.75951160e-02f, 1.00185432e-01f, 3.57432440e-02f, -5.54920398e-02f, -2.85635330e-02f, -2.26742491e-01f, 6.21670811e-03f, 1.31172808e-02f,
  5.50923273e-02f, -6.20787637e-03f, 6.90709508e-04f, 5.89297302e-02f, 5.73795885e-02f, -2.64668688e-02f, -6.04650937e-02f, 9.71341208e-02f, 2.69666850e-03f, 3.19777429e-02f,
  7.94356093e-02f, 6.11925274e-02f, 4.79696430e-02f, -6.75852895e-02f, 1.06554269e-03f, 8.00093263e-03f, 1.18877858e-01f, 5.08028902e-02f, 3.81506830e-02f, -5.63321672e-02f,
  3.19722891e-01f, 4.35990244e-01f, 1.76056609e-01f, 5.88331342e-01f, -2.65685081e-01f, 3.44985723e-01f, 3.55733246e-01f, 1.50017425e-01f, 4.86221075e-01f, 3.64465922e-01f,
  -1.71770573e-01f, 3.96518618e-01f, -1.16982497e-01f, 3.37019920e-01f, -4.43913490e-01f, -2.44695470e-02f, 1.78598791e-01f, 2.19846845e-01f, 1.52122453e-01f, 7.21395463e-02f,
  -5.20840660e-02f, -1.18374132e-01f, -2.30536968e-01f, -2.70953476e-01f, -4.77227904e-02f, 1.75165311e-01f, -4.44693208e-01f, -1.94586635e-01f, -3.32067646e-02f, -1.19883396e-01f,
  5.75868264e-02f, 2.15586498e-01f, -8.41471553e-02f, 3.70442495e-02f, -9.21300054e-03f, 1.44523084e-01f, -1.12448506e-01f, -2.40359735e-02f, 3.86152081e-02f, 7.21741393e-02f,
  1.08043045e-01f, 4.62915003e-02f, 1.60477281e-01f, -2.57188571e-03f, 1.22865602e-01f, 8.46981108e-02f, 2.15194784e-02f, -3.92729463e-03f, 1.01515636e-01f, 1.36731553e-03f,
  9.48246196e-02f, 3.83197926e-02f, -3.31063122e-02f, 3.95860858e-02f, -5.30205928e-02f, 8.89207795e-02f, 6.54116720e-02f, -6.92142919e-03f, 5.16180880e-02f, 1.89293116e-01f,
  2.64477897e-02f, 4.10154760e-02f, 3.44183333e-02f, -3.99774686e-02f, 4.61577997e-02f, -9.30589512e-02f, 4.97420356e-02f, -1.24181628e-01f, 8.22587346e-04f, -1.01236574e-01f,
  8.37037619e-03f, 3.65454070e-02f, 1.13209993e-01f, 3.87676172e-02f, 1.00746430e-01f, 1.17116764e-01f, -7.43919760e-02f, 6.35250332e-03f, 9.88707542e-02f, -1.10108368e-01f,
  5.71913682e-02f, -6.77838549e-02f, 1.05034672e-02f, -1.95367262e-02f, 1.30565530e-02f, -3.71538103e-02f, 6.37523085e-02f, 1.09237872e-01f, -3.47046070e-02f, -1.53481647e-01f,
  5.06018698e-02f, 2.05235407e-01f, -3.23487185e-02f, 4.49723117e-02f, -1.02706077e-02f, -6.81501254e-02f, 8.68582651e-02f, 4.93602678e-02f, 5.61527461e-02f, 1.32134231e-02f,
  8.77016857e-02f, -7.02238875e-03f, -1.03413567e-01f, -8.23506564e-02f, 2.95392107e-02f, 1.44682191e-02f, 1.10660665e-01f, 2.59182248e-02f, -1.13728970e-01f, -9.19304192e-02f,
  -3.70910540e-02f, 2.89722923e-02f, 8.54947641e-02f, -4.21407893e-02f, 1.01941889e-02f, -5.58510832e-02f, 1.10809691e-01f, -3.41024660e-02f, -2.20155995e-03f, -2.95444168e-02f,
  -1.46648556e-01f, 1.30083829e-01f, 4.28074121e-01f, 5.86725593e-01f, -1.44598052e-01f, -5.92690110e-01f, -3.02136660e-01f, 2.72447973e-01f, -2.42797881e-01f, -1.34248450e-01f,
  -2.21754387e-02f, -1.05102938e-02f, -1.43222421e-01f, 1.18184298e-01f, 1.05279997e-01f, -2.96258330e-01f, 9.62908566e-02f, -2.39785954e-01f, -5.34363836e-02f, 2.36705437e-01f,
  2.03626528e-01f, 6.01985343e-02f, 2.71368295e-01f, 1.89735010e-01f, -4.68297042e-02f, 4.22339529e-01f, 5.61203301e-01f, 1.96561590e-01f, 5.44930339e-01f, -1.05673164e-01f,
  -2.05083027e-01f, 1.22471802e-01f, 5.96465282e-02f, -4.66543548e-02f, 1.60830811e-01f, 3.94056328e-02f, 5.57890488e-03f, -7.44659677e-02f, 1.02965839e-01f, 1.53736711e-01f,
  -6.68930560e-02f, -3.08474135e-02f, 8.27547908e-02f, 4.01211083e-02f, -1.32173866e-01f, 1.70630012e-02f, 1.13539658e-02f, -3.79984491e-02f, 1.06781572e-01f, 6.22753166e-02f,
  1.35531649e-01f, 1.34363165e-02f, 1.31354677e-02f, 1.44508258e-01f, 1.00598775e-01f, -9.24228057e-02f, 1.15233965e-01f, 1.02319658e-01f, 5.77671342e-02f, 2.94045340e-02f,
  4.53535132e-02f, -9.66743231e-02f, -9.50054377e-02f, -1.15181491e-01f, -1.18352726e-01f, -1.94789246e-02f, -1.66069940e-01f, -1.42203616e-02f, -6.72606099e-03f, -6.27960041e-02f,
  3.46643031e-02f, 1.11116350e-01f, -5.79156168e-02f, -5.57425208e-02f, 7.56470934e-02f, 8.41368735e-03f, -6.53372929e-02f, -2.08464693e-02f, 1.07380360e-01f, 1.30877458e-03f,
  -1.02283619e-01f, -4.09657918e-02f, 1.86363496e-02f, -1.07823750e-02f, -8.79501775e-02f, 9.58188772e-02f, 3.63601595e-02f, 2.88508497e-02f, -1.10832304e-02f, 6.56108484e-02f,
  1.42013296e-01f, 5.29568732e-01f, 2.45668218e-02f, -1.75633788e-01f, 2.65059117e-02f, -6.00951463e-02f, -4.74534295e-02f, 5.32191247e-02f, 4.11299542e-02f, -4.03263755e-02f,
  1.06287442e-01f, -1.71410106e-02f, -2.75180433e-02f, 1.92358065e-02f, 1.29215315e-01f, 8.01835805e-02f, 1.18426807e-01f, 9.57729369e-02f, 1.88287467e-01f, 2.26437330e-01f,
  1.96729541e-01f, -9.68086198e-02f, -6.68067783e-02f, -5.62068000e-02f, 8.48409832e-02f, 8.96597430e-02f, 6.15765788e-02f, -2.47703884e-02f, 8.13708603e-02f, 9.71075296e-02f,
  -4.21022952e-01f, -1.36430994e-01f, -1.73756182e-01f, -2.73045421e-01f, 3.64840478e-01f, 4.77097958e-01f, 2.50332087e-01f, 2.00962171e-01f, 1.37382165e-01f, 1.46905363e-01f,
  -1.05261520e-01f, -2.54394323e-01f, 5.72994724e-02f, -4.74950582e-01f, -3.19939494e-01f, -2.84016699e-01f, -1.62202701e-01f, -1.22845076e-01f, -8.48895963e-03f, 1.81019098e-01f,
  -9.76382941e-02f, -2.79511720e-01f, -5.48100889e-01f, 1.05784476e-01f, -1.95898354e-01f, 2.05001533e-01f, 3.19742337e-02f, 2.35615909e-01f, -9.08391625e-02f, -1.11664012e-01f,
  -2.32148007e-01f, -1.82516024e-01f, -2.02294320e-01f, 2.91143972e-02f, 1.18281506e-01f, 8.14899877e-02f, 1.04985595e-01f, -1.43251037e-02f, 7.90645853e-02f, 2.13696025e-02f,
  -7.89148957e-02f, -7.95240328e-03f, -4.87345830e-02f, -1.24964572e-01f, 2.08612084e-01f, -5.65448292e-02f, -1.76164910e-01f, 2.15023151e-03f, -2.70635113e-02f, -1.62235081e-01f,
  -8.97802263e-02f, -6.94385394e-02f, 7.22738579e-02f, 5.52146621e-02f, -5.92297688e-02f, 1.96700189e-02f, 9.34693813e-02f, 1.39178215e-02f, 2.06881184e-02f, 5.32719940e-02f,
  -4.95312214e-02f, 1.88908800e-01f, -9.00590569e-02f, -6.39028698e-02f, 1.42433038e-02f, 4.59783562e-02f, 4.04973365e-02f, 7.65745342e-02f, 6.56248555e-02f, -3.52543686e-03f,
  7.51765519e-02f, 6.77907020e-02f, -5.19144982e-02f, 1.47741199e-01f, -4.50890400e-02f, -1.61307111e-01f, 1.03689916e-01f, -4.12310287e-02f, 4.04441878e-02f, -7.71584213e-02f,
  -6.44195303e-02f, 5.27818352e-02f, -1.56435966e-01f, -2.36885473e-02f, 7.63172954e-02f, -2.05580425e-02f, -1.21139176e-02f, -1.66423038e-01f, 3.61214578e-02f, 3.54936756e-02f,
  2.21786380e-01f, 5.62941730e-01f, 1.04117014e-01f, -1.47753432e-01f, 3.47640589e-02f, 2.46907882e-02f, -4.81076948e-02f, 3.26082669e-02f, 1.25960812e-01f, 2.60732304e-02f,
  1.43830627e-01f, 1.53005421e-01f, 2.06760988e-01f, -4.17515673e-02f, 7.89545476e-03f, -3.80296707e-02f, 6.33934960e-02f, 1.18751593e-01f, 2.34597728e-01f, 1.39594540e-01f,
  4.36997116e-02f, 1.86980188e-01f, 7.35361576e-02f, 1.42676100e-01f, -8.31979886e-03f, 1.17639162e-01f, 1.19848408e-01f, 1.11549878e-02f, 4.21992801e-02f, 8.36782232e-02f,
  8.14909637e-02f, -5.46669245e-01f, -6.23591840e-01f, -1.80649862e-01f, 3.87911916e-01f, 3.21000874e-01f, -3.99659902e-01f, 1.49800971e-01f, -5.57220459e-01f, -2.06368603e-02f,
  2.47385591e-01f, -1.70076758e-01f, -6.18279994e-01f, 6.78469688e-02f, 9.83669385e-02f, -5.75126648e-01f, 2.37788007e-01f, 8.52602571e-02f, -3.39495212e-01f, 1.57231241e-01f,
  -1.18815027e-01f, 4.13904637e-01f, -2.50195235e-01f, 5.13338983e-01f, 1.91967756e-01f, 1.63949013e-01f, 3.84046853e-01f, -1.27380071e-02f, 6.13673747e-01f, 2.73888290e-01f,
  8.24247662e-04f, -1.67208388e-01f, -1.28538162e-01f, -2.97561735e-02f, 3.16223763e-02f, 1.78549007e-01f, 1.12513408e-01f, 1.09655522e-01f, 5.19061908e-02f, -4.04291302e-02f,
  -5.04242107e-02f, 5.19818626e-02f, 1.44527152e-01f, -8.54171440e-03f, 1.60304662e-02f, 1.36596486e-01f, -2.08331928e-01f, -5.08008376e-02f, -1.83848321e-01f, -8.29956234e-02f,
  -2.52469212e-01f, 6.17333092e-02f, -1.23311533e-02f, 4.45431992e-02f, -6.32962957e-02f, -1.07706804e-02f, 5.80265485e-02f, 1.23334989e-01f, 1.31643921e-01f, 1.28919944e-01f,
  1.60501316e-01f, 6.13307431e-02f, 3.34006995e-02f, -4.12420370e-02f, 2.05724612e-02f, -2.87983473e-02f, -9.38562453e-02f, 1.88864768e-03f, -8.35205689e-02f, -4.91616204e-02f,
  3.86989638e-02f, 2.63632368e-02f, 3.45343240e-02f, 6.20848313e-02f, 5.69224469e-02f, -6.08719699e-02f, 1.71240978e-02f, 6.02092333e-02f, 1.15687549e-02f, -5.63873276e-02f,
  -8.24469849e-02f, 9.40877199e-02f, -1.35694062e-02f, 8.30601677e-02f, -1.45847909e-02f, 3.66954654e-02f, 8.13668296e-02f, -2.56360155e-02f, -8.83699730e-02f, 5.22147045e-02f,
  4.80777621e-02f, 4.14991677e-02f, -8.09002817e-02f, 5.40821701e-02f, -3.68710347e-02f, 1.03330001e-01f, -2.59455889e-02f, 6.81552216e-02f, 9.29058120e-02f, -7.39824921e-02f,
  2.23462701e-01f, 9.46207121e-02f, 6.65742680e-02f, 1.05469234e-01f, 1.08929932e-01f, -1.11208577e-03f, 1.01824686e-01f, 1.72902077e-01f, 8.70296732e-02f, 6.89046383e-02f,
  1.20977663e-01f, 9.17050168e-02f, 6.38235137e-02f, 2.98287310e-02f, 1.32712245e-01f, -3.10912021e-02f, 1.22526996e-01f, 9.72284377e-03f, -2.64239833e-02f, 7.72648081e-02f,
  1.54622674e-01f, -4.24671888e-01f, 4.03046429e-01f, -1.78670838e-01f, 3.73921871e-01f, 4.46734965e-01f, 4.78078276e-01f, -4.64512892e-02f, -2.79782731e-02f, -4.29544628e-01f,
  -6.59626871e-02f, -1.21416196e-01f, 3.33043516e-01f, -3.99539948e-01f, 6.92091703e-01f, 1.32974207e-01f, -1.56282157e-01f, -1.81941703e-01f, -8.12261645e-03f, -2.42985472e-01f,
  -1.21618956e-01f, -4.13879246e-01f, 3.44902761e-02f, -3.03978175e-01f, -2.50721037e-01f, -1.82263881e-01f, -2.37311408e-01f, 2.46831104e-01f, -3.05150539e-01f, 1.28576741e-01f,
  -7.43134990e-02f, -2.23196119e-01f, -1.98620990e-01f, -1.09461121e-01f, -1.02609083e-01f, 7.91518241e-02f, 1.29782502e-02f, 2.69173414e-01f, 1.18247062e-01f, 1.20465830e-01f,
  -8.62990841e-02f, 1.00968905e-01f, -1.01871617e-01f, 2.09671669e-02f, 3.73821445e-02f, 1.43715916e-02f, -5.45976572e-02f, 1.10039217e-02f, -2.31016576e-02f, 6.46430328e-02f,
  7.06880242e-02f, -6.37956113e-02f, -2.52073910e-02f, -4.23805043e-03f, 6.88671693e-02f, -2.44442727e-02f, 8.66658539e-02f, 2.27166995e-01f, -2.66890228e-02f, -2.37053391e-02f,
  -2.74071191e-02f, 3.49025093e-02f, 5.70173282e-03f, -1.26140043e-01f, 1.24463765e-03f, -3.94205339e-02f, -6.72064871e-02f, -5.89093147e-03f, 8.57535470e-03f, -9.84567404e-03f,
  8.72776750e-03f, 4.09815311e-02f, 6.81576729e-02f, 8.10845047e-02f, 2.04575318e-03f, -8.78550038e-02f, -6.17410280e-02f, 2.00217329e-02f, -4.79956307e-02f, -1.14878252e-01f,
  -4.79211248e-02f, 2.05328595e-02f, 4.52369452e-02f, 1.20320551e-01f, -4.19443436e-02f, 1.22068159e-01f, -9.65047404e-02f, 6.58838600e-02f, -2.79915575e-02f, 2.38122176e-02f,
  -1.41533628e-01f, -3.62286478e-01f, -1.82854310e-01f, -7.73931965e-02f, -1.44491661e-02f, -1.30022898e-01f, -7.28957653e-02f, -8.44185576e-02f, -2.83194482e-02f, -6.25537857e-02f,
  -1.37922214e-02f, -3.22396937e-03f, -7.53366724e-02f, 1.76377501e-02f, -9.43235029e-03f, -1.69977304e-02f, -5.14280312e-02f, -1.41828597e-01f, -5.31992223e-03f, -7.23095015e-02f,
  -2.42128018e-02f, 5.16435169e-02f, -2.03998620e-03f, -1.88801274e-01f, -1.28737152e-01f, 3.82973626e-02f, -6.86020078e-03f, -1.03246227e-01f, 7.89140090e-02f, 7.05701485e-02f,
  -3.81549783e-02f, -3.54858518e-01f, 2.85767555e-01f, 2.85814870e-02f, 5.89310408e-01f, 2.51480788e-01f, -2.07903340e-01f, 3.49678695e-01f, 1.62564382e-01f, -4.57407057e-01f,
  -1.87026829e-01f, -4.01593924e-01f, -4.75116551e-01f, 3.11218314e-02f, 1.65385991e-01f, -1.45750001e-01f, 2.04746634e-01f, -1.31626204e-01f, 2.50195861e-01f, 5.79214096e-02f,
  2.20277131e-01f, 9.17757824e-02f, 2.19273847e-02f, 3.09160620e-01f, 1.45674616e-01f, 8.87243226e-02f, -2.10053325e-01f, -6.32026568e-02f, 1.13248490e-01f, 9.11135301e-02f,
  7.37861395e-02f, -1.26962021e-01f, -7.95454606e-02f, -1.66862875e-01f, 5.81708103e-02f, 2.40820702e-02f, -1.22638911e-01f, -6.75566867e-02f, 1.39186636e-01f, 8.49126875e-02f,
  -1.32731631e-01f, -2.62756981e-02f, 1.07904337e-01f, 4.92251255e-02f, -3.39128659e-03f, 1.01241380e-01f, 2.01619506e-01f, 9.90922749e-02f, 4.29234914e-02f, 1.75367028e-01f,
  1.10935420e-01f, 1.32797897e-01f, -4.77688666e-03f, -1.09374309e-02f, 1.03479713e-01f, -1.84737127e-02f, 1.32505313e-01f, -5.25570624e-02f, -2.12974790e-02f, 1.44710302e-01f,
  9.43560451e-02f, 5.77062415e-03f, -6.11493140e-02f, -9.20163840e-02f, -4.47592102e-02f, 4.32901867e-02f, 2.38746963e-02f, -6.51887953e-02f, -2.53937077e-02f, 2.25465265e-04f,
  5.88607453e-02f, -1.96855771e-03f, -1.12862056e-02f, 3.61993536e-02f, -4.59768102e-02f, 4.18620855e-02f, -1.42526552e-01f, -1.35820080e-02f, 3.48932552e-03f, 1.84099540e-01f,
  -6.05761930e-02f, 1.54239936e-02f, -2.86860913e-02f, -3.20227593e-02f, 4.86658290e-02f, -9.08617526e-02f, -3.83721367e-02f, -1.95989236e-02f, -3.12151406e-02f, -7.21497834e-02f,
  -7.06442952e-01f, -6.40931249e-01f, -1.14954919e-01f, -5.45221195e-02f, -5.22788949e-02f, -7.38631142e-03f, -2.28199139e-02f, 2.50961073e-02f, -1.35188580e-01f, -1.03901926e-04f,
  -3.06424946e-02f, 5.12895687e-03f, -9.05429721e-02f, 1.37443349e-01f, -8.36258680e-02f, 2.42536962e-02f, -2.74567783e-01f, -1.19989678e-01f, -1.66166529e-01f, 4.05937014e-03f,
  -1.08167067e-01f, -8.55344757e-02f, 3.40453424e-02f, 9.41838846e-02f, -1.16983196e-02f, -3.06705968e-03f, -3.15952487e-02f, -2.01753844e-02f, 9.04653221e-02f, -2.33179461e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 8)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 8;
const float L0_fan_Bp_bar_data[] = {
  4.17573214e-01f, 3.04827720e-01f, 5.15001714e-01f, 1.43988535e-01f, 5.53883076e-01f, 2.90998161e-01f, 5.13013780e-01f, 3.09841543e-01f
};

// L1_fan_Wp (Shape: 12 x 32)
const int L1_fan_Wp_rows = 12;
const int L1_fan_Wp_cols = 32;
const float L1_fan_Wp_data[] = {
  1.08852386e-01f, -9.02623832e-02f, 2.42047384e-01f, 1.80676192e-01f, -2.54373789e-01f, 1.54993862e-01f, -1.95833519e-01f, 2.84852907e-02f, -1.38911992e-01f, 2.68896878e-01f,
  -3.50633115e-01f, 9.48904380e-02f, 3.15294117e-01f, -6.16828166e-02f, -1.03140786e-01f, -2.21709162e-01f, 6.79136887e-02f, 2.37692595e-01f, 5.63425757e-02f, 1.41893908e-01f,
  4.03903365e-01f, -3.67926836e-01f, -3.63675356e-01f, -5.21402478e-01f, -2.08889216e-01f, 3.05370182e-01f, -2.92620510e-01f, 2.94835627e-01f, 2.05623433e-02f, -2.01714095e-02f,
  -5.70556801e-03f, -9.63789076e-02f, 1.21609122e-03f, -1.88927010e-01f, 1.83685105e-02f, 1.64474696e-01f, 1.75927401e-01f, 4.60024141e-02f, -8.85197371e-02f, -4.11598524e-03f,
  3.61386180e-01f, -9.88785923e-02f, -2.74186850e-01f, 3.33569080e-01f, 3.29123735e-01f, 4.17862535e-01f, -4.14991975e-01f, 4.60668989e-02f, 3.53735387e-01f, -1.15686476e-01f,
  2.40835428e-01f, -3.60799551e-01f, 5.34110516e-02f, -5.77174798e-02f, -1.64972037e-01f, -3.29745650e-01f, -3.78090918e-01f, 3.80728990e-01f, 3.15101491e-03f, 1.16824694e-01f,
  1.99904710e-01f, -7.56263807e-02f, -5.93737848e-02f, -3.81276548e-01f, -3.82860489e-02f, 9.27404389e-02f, -1.52675554e-01f, -2.35001072e-01f, 1.97202414e-01f, 5.48286512e-02f,
  2.79733419e-01f, -7.63131604e-02f, -1.47571683e-01f, -1.45700667e-02f, 4.98652995e-01f, -3.96819739e-03f, -3.10610563e-01f, -4.45619076e-01f, -5.01704067e-02f, 3.18601653e-02f,
  1.45805225e-01f, 3.87630075e-01f, 1.00371391e-02f, 2.55489230e-01f, -3.83556932e-01f, 5.75406194e-01f, 1.04749136e-01f, 1.77951276e-01f, 1.94039419e-01f, 3.02224010e-01f,
  1.36423498e-01f, -2.08895549e-01f, 1.75114796e-01f, -1.96861386e-01f, -2.19464138e-01f, 1.96518272e-01f, 1.30667582e-01f, -2.30024695e-01f, 1.06038876e-01f, 5.05930707e-02f,
  -3.05075012e-02f, 1.57017633e-01f, 2.31125757e-01f, 1.40081018e-01f, -2.29191240e-02f, -1.95806343e-02f, -6.97209984e-02f, -9.44807604e-02f, 2.19179139e-01f, 5.57874218e-02f,
  -2.36018136e-01f, 3.61457705e-01f, -4.54366431e-02f, -4.97094750e-01f, 4.10192043e-01f, -1.00060821e-01f, 1.05566829e-01f, -2.24368095e-01f, 2.56254703e-01f, 4.57099915e-01f,
  -1.74627453e-01f, -3.00563782e-01f, 2.67524451e-01f, -2.52109051e-01f, -1.66463614e-01f, 1.37638688e-01f, 2.07327828e-01f, -2.31889650e-01f, 2.43232623e-02f, 3.13479640e-03f,
  -2.48147264e-01f, 1.34731978e-01f, 7.44595006e-02f, -2.66930819e-01f, 5.89754209e-02f, -2.73938347e-02f, -8.39599073e-02f, -1.87414467e-01f, 4.19226110e-01f, -1.14526466e-01f,
  -2.80069768e-01f, -5.55088997e-01f, -1.20654865e-03f, 1.15547344e-01f, 1.34009734e-01f, -5.94570674e-02f, -5.72278857e-01f, -3.87415349e-01f, -5.62597394e-01f, 3.54942262e-01f,
  -4.71910313e-02f, 9.12652388e-02f, -2.11196579e-02f, 3.56150955e-01f, -1.08951062e-01f, 1.58063173e-01f, 2.41611302e-01f, -1.54703408e-01f, -1.40400112e-01f, -2.98232902e-02f,
  -8.45948681e-02f, -1.94935709e-01f, -5.72334044e-02f, 5.02653271e-02f, 5.50237186e-02f, 3.84372801e-01f, -5.00971172e-03f, -1.32114187e-01f, 7.87047371e-02f, -1.38735827e-02f,
  -4.05174911e-01f, -1.32659867e-01f, 3.62763345e-01f, 2.09165484e-01f, -4.68765259e-01f, -7.24568516e-02f, 2.38580182e-01f, -2.14459985e-01f, 4.57714200e-01f, -2.12415770e-01f,
  1.88216120e-01f, -2.77786106e-01f, -1.63419157e-01f, 2.27140695e-01f, -2.46345535e-01f, 5.76501228e-02f, 2.93167055e-01f, 1.21591784e-01f, -2.47924894e-01f, -2.63119400e-01f,
  1.32342279e-01f, -3.00611854e-01f, 1.20270692e-01f, 1.67203382e-01f, -1.19372837e-01f, 1.66728973e-01f, -1.68392640e-02f, -2.81537145e-01f, 1.74049675e-01f, -4.97516654e-02f,
  2.56495774e-01f, -2.98319571e-02f, -1.12432599e-01f, 1.34434104e-01f, 1.91571694e-02f, 3.39998692e-01f, -2.75576293e-01f, -1.11898921e-01f, -5.09654164e-01f, -3.30965191e-01f,
  -1.88720897e-01f, -2.82244176e-01f, 1.35726094e-01f, 3.88532072e-01f, 3.53989273e-01f, 5.70020139e-01f, -1.31182149e-01f, -1.64057195e-01f, 1.07043654e-01f, -5.17072678e-02f,
  -1.17138557e-01f, -2.85469621e-01f, 3.79239768e-01f, -1.15306303e-01f, -3.16210032e-01f, 3.00751656e-01f, -8.48620608e-02f, -1.67764246e-01f, -1.01668313e-01f, -6.17899001e-02f,
  -1.51268378e-01f, -2.19853401e-01f, 7.92884976e-02f, 8.03186148e-02f, -4.36124414e-01f, 2.84774363e-01f, 8.02993253e-02f, 2.52317935e-01f, -6.17335103e-02f, -3.50364953e-01f,
  -5.35944998e-01f, 1.39130400e-02f, -2.54777938e-01f, -2.84490705e-01f, 1.62223041e-01f, 1.57524511e-01f, 1.11363970e-01f, 1.29299043e-02f, 1.14310704e-01f, -4.90214229e-02f,
  -4.36415911e-01f, 2.00907826e-01f, -1.82981148e-01f, -1.11147046e-01f, 3.02415222e-01f, 4.69961157e-03f, 4.39105570e-01f, -4.24387977e-02f, 1.46788239e-01f, 2.95209140e-01f,
  -1.96330473e-01f, 3.80068481e-01f, 4.77610081e-02f, 1.85514763e-02f, -2.91954756e-01f, 3.79151374e-01f, -1.78228363e-01f, 2.12017298e-01f, 2.68301338e-01f, -1.44545764e-01f,
  6.06857389e-02f, -8.32963828e-03f, -1.89300403e-01f, -1.15769859e-02f, 3.04035276e-01f, 2.67713964e-01f, 3.45129639e-01f, -3.38089705e-01f, 2.68035173e-01f, 2.66367912e-01f,
  7.95976073e-03f, -2.46040866e-01f, -4.36839670e-01f, 1.59442827e-01f, 8.87472630e-02f, 4.10205483e-01f, 2.15686768e-01f, -1.22168846e-01f, -1.32790104e-01f, -3.22827846e-01f,
  -1.50785789e-01f, 4.59015183e-02f, 1.18853703e-01f, -3.12626034e-01f, 1.46782890e-01f, -1.43193170e-01f, 1.46243453e-01f, -4.92982306e-02f, 9.76363271e-02f, -9.77714360e-02f,
  -1.34932920e-02f, -3.92864347e-01f, 1.83147237e-01f, 5.32808602e-01f, -2.75541127e-01f, 1.92681304e-03f, -3.94738168e-01f, -7.01747715e-01f, -8.51353183e-02f, -1.82889298e-01f,
  3.53796631e-01f, 2.39787966e-01f, -7.99712986e-02f, 1.37402758e-01f, -4.78397980e-02f, -2.59895444e-01f, 1.44641459e-01f, 2.98529834e-01f, -1.60026148e-01f, 9.35146883e-02f,
  -8.27533156e-02f, 2.01997489e-01f, -5.43738157e-02f, 9.65318270e-03f, -4.97092783e-01f, 3.67095433e-02f, -5.05493246e-02f, -9.17982087e-02f, -3.31410259e-01f, 9.13547650e-02f,
  -3.34000766e-01f, 3.78217846e-01f, -1.19661182e-01f, -5.12057170e-02f, 2.71199703e-01f, -2.14786619e-01f, -4.32548463e-01f, 1.88884214e-01f, 3.66464374e-03f, 8.12050793e-03f,
  1.65081710e-01f, -1.57073215e-01f, -2.09443886e-02f, -2.67244816e-01f, 1.27367631e-01f, 2.86201864e-01f, -4.52413082e-01f, -6.53450238e-03f, -1.32376388e-01f, 3.06627601e-01f,
  1.72533765e-01f, -7.80411437e-02f, 3.65665220e-02f, 1.88069910e-01f, 1.53382838e-01f, 1.67988464e-01f, -1.59448251e-01f, -5.07023990e-01f, 6.36225492e-02f, 1.04267992e-01f,
  -2.32426524e-01f, -4.66199778e-02f, 3.32941294e-01f, -1.07541882e-01f, -2.32999697e-01f, -1.18069716e-01f, 5.20800829e-01f, 7.00519681e-02f, -4.03597206e-01f, 3.71108174e-01f,
  -3.03619444e-01f, 3.58649254e-01f, -4.49972488e-02f, 2.22847700e-01f, 1.61644593e-01f, 1.07634002e-02f, 4.51383919e-01f, -5.68227172e-02f, -1.11031272e-02f, -2.33019978e-01f,
  -3.09493002e-02f, 1.53373122e-01f, -1.56397194e-01f, 3.98457259e-01f
};

// L1_fan_Wp_bar (Shape: 8 x 32)
const int L1_fan_Wp_bar_rows = 8;
const int L1_fan_Wp_bar_cols = 32;
const float L1_fan_Wp_bar_data[] = {
  1.49951205e-01f, -7.77073950e-03f, -1.47656621e-02f, 1.60669103e-01f, 4.28095758e-01f, -6.50495589e-02f, 4.96262193e-01f, 4.68335778e-01f, 7.29432344e-01f, 1.28210932e-01f,
  5.88946939e-01f, 4.58770365e-01f, 4.37389910e-01f, -3.60496461e-01f, -1.85283005e-01f, 1.03150749e+00f, 9.44778472e-02f, -1.18568683e+00f, -2.13109970e-01f, -9.77020025e-01f,
  -1.72718406e-01f, -2.69637972e-01f, -3.31496179e-01f, -2.08797082e-01f, -2.75826037e-01f, -2.82142997e-01f, 7.27764130e-01f, 6.22100770e-01f, 4.20921415e-01f, 1.08795512e+00f,
  -4.39837396e-01f, 5.08379281e-01f, 6.61995053e-01f, -9.41848308e-02f, -1.16241798e-01f, 9.56424415e-01f, -3.21610987e-01f, -4.12529826e-01f, 2.89482296e-01f, 4.06409472e-01f,
  2.14034066e-01f, 1.59109131e-01f, 3.26472223e-01f, 5.67927778e-01f, 3.41425329e-01f, -5.44215441e-01f, 8.20483506e-01f, 3.25927466e-01f, -4.70530748e-01f, -4.10964072e-01f,
  -6.16255462e-01f, -4.66448486e-01f, -8.61117020e-02f, -1.08765528e-01f, 7.00953245e-01f, 5.45385838e-01f, -5.51303089e-01f, 1.73314109e-01f, -5.75144172e-01f, 8.70823443e-01f,
  4.88872647e-01f, 3.74690771e-01f, 8.63755703e-01f, 2.92884652e-02f, 5.34283340e-01f, 2.92543679e-01f, 5.60020149e-01f, 6.41506433e-01f, 1.25432406e-02f, 8.13058674e-01f,
  2.28467017e-01f, 4.80511159e-01f, -2.70739973e-01f, 4.30695087e-01f, 1.54860154e-01f, 2.44332567e-01f, -1.28005862e-01f, -4.35470611e-01f, 5.73910058e-01f, -2.69483507e-01f,
  -6.09934151e-01f, 2.83547014e-01f, 8.38654041e-01f, 8.16361845e-01f, 6.92628443e-01f, -2.32374072e-01f, 4.23449546e-01f, 3.90647978e-01f, 7.00807869e-01f, -6.89616859e-01f,
  2.19272465e-01f, 7.58631587e-01f, -3.58365953e-01f, 3.80329192e-01f, 6.55986905e-01f, 6.76940382e-01f, 7.16985643e-01f, 4.50221777e-01f, 7.67030120e-01f, 6.98204577e-01f,
  2.34127715e-01f, 7.22325563e-01f, 3.05115879e-01f, 4.88323599e-01f, 3.06186765e-01f, 2.10825190e-01f, 7.38367856e-01f, 5.29150188e-01f, -6.00824058e-01f, 1.42405599e-01f,
  -6.38617933e-01f, -2.42638573e-01f, 1.21803534e+00f, 6.98031902e-01f, 9.78493273e-01f, 1.16169012e+00f, 4.03213292e-01f, 1.55276418e-01f, -4.38187003e-01f, -4.09363866e-01f,
  9.09860969e-01f, 5.18822551e-01f, 7.20647693e-01f, -1.86437026e-01f, 7.83953130e-01f, 1.34140134e-01f, 4.15919423e-01f, -3.57873112e-01f, -3.65976840e-01f, -2.60214299e-01f,
  3.11388671e-01f, 9.26290825e-02f, 1.75438076e-01f, 1.50994703e-01f, 1.41626194e-01f, 3.70777965e-01f, -3.43917996e-01f, 4.05779451e-01f, 8.41415860e-03f, -4.61387336e-01f,
  7.88772851e-02f, -7.64424682e-01f, 2.43305758e-01f, 3.79292637e-01f, 1.75319806e-01f, -6.18928432e-01f, -6.35421336e-01f, -3.97072643e-01f, -7.75527894e-01f, -7.54223287e-01f,
  -3.41664344e-01f, -2.45016947e-01f, 9.31396484e-01f, 8.51927936e-01f, -1.49172554e-02f, 6.38180614e-01f, 1.67818740e-01f, 8.59721065e-01f, -5.93572557e-01f, -4.30974960e-02f,
  4.37834740e-01f, 7.00124949e-02f, -1.47664294e-01f, 2.50092119e-01f, 2.68079758e-01f, -2.54098028e-01f, 4.21143115e-01f, 2.97031969e-01f, 4.47975487e-01f, -3.29951160e-02f,
  6.36939883e-01f, 3.54894340e-01f, -2.46455014e-01f, 1.46534339e-01f, -1.94969311e-01f, 3.65949810e-01f, -1.61749106e-02f, -7.62204602e-02f, -3.95472378e-01f, -1.38146147e-01f,
  -4.34408456e-01f, 8.05704236e-01f, 5.91608644e-01f, 6.86578631e-01f, -5.45037925e-01f, 7.22561777e-02f, 3.11093003e-01f, -2.24096879e-01f, 8.41783881e-01f, 2.21898913e-01f,
  2.37657651e-01f, 5.68161905e-01f, -3.64084765e-02f, 4.49128658e-01f, 1.56879291e-01f, 1.10382460e-01f, 6.48334205e-01f, -5.13854504e-01f, 3.84190887e-01f, 1.00982353e-01f,
  4.87029523e-01f, 6.89768121e-02f, 4.84656274e-01f, 1.46550059e-01f, -2.49712795e-01f, 1.97731793e-01f, 2.74887849e-02f, -4.79317546e-01f, -4.42570001e-01f, 1.09890521e-01f,
  -6.78635001e-01f, -9.07919407e-02f, -6.98076963e-01f, 1.00590777e+00f, 1.70208424e-01f, 4.75316226e-01f, 8.61019850e-01f, 7.68418968e-01f, 7.32465863e-01f, 6.80153742e-02f,
  4.45006907e-01f, -6.67449594e-01f, 6.38017714e-01f, 7.63249815e-01f, -7.12501526e-01f, 3.16150844e-01f, 2.48392463e-01f, -5.17051697e-01f, 2.25811094e-01f, -7.48340413e-02f,
  5.84960639e-01f, -5.20140911e-03f, 9.48637366e-01f, 6.13456331e-02f, -1.29285544e-01f, 9.32566822e-01f, 3.90365392e-01f, 6.87454581e-01f, -5.03929675e-01f, 9.19151902e-02f,
  -6.30579948e-01f, -1.29434869e-01f, -4.37376350e-01f, -8.92253220e-01f, 3.39391142e-01f, 1.83856487e-01f, 2.63498336e-01f, -1.22483268e-01f, 2.01477587e-01f, 1.09015322e+00f,
  -1.41116932e-01f, -5.76953709e-01f, 3.68678540e-01f, 7.95539379e-01f, 9.24930930e-01f, 8.14267576e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 8)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 8;
const float L1_fan_Bp_bar_data[] = {
  4.01483506e-01f, -2.18517166e-02f, 2.97084481e-01f, 5.67646861e-01f, 4.41160262e-01f, 1.36497483e-01f, 2.27016658e-01f, 6.26366854e-01f
};

// L2_linear_W (Shape: 12 x 32)
const int L2_linear_W_rows = 12;
const int L2_linear_W_cols = 32;
const float L2_linear_W_data[] = {
  -1.20451748e-01f, 2.68456876e-01f, 4.26078886e-01f, 5.50736129e-01f, -4.94997680e-01f, 3.14616747e-02f, 2.98713833e-01f, -8.86620581e-02f, 3.54392290e-01f, -2.07879528e-01f,
  3.86880189e-01f, 4.84925479e-01f, 7.35172451e-01f, 6.92745388e-01f, -6.64040029e-01f, 3.30320388e-01f, -5.27524650e-01f, 7.68853068e-01f, -6.69578314e-01f, -5.37179172e-01f,
  5.39431453e-01f, -6.06753230e-01f, -4.33744848e-01f, -5.05987942e-01f, -6.00264609e-01f, -5.52272081e-01f, 4.68032956e-01f, 7.88123369e-01f, -7.15898395e-01f, -6.61970675e-01f,
  -8.61808002e-01f, -1.13895071e+00f, 3.71552318e-01f, -1.39918849e-01f, -1.65957019e-01f, 2.09893331e-01f, 5.94258048e-02f, 3.95558804e-01f, 1.80730507e-01f, 2.20890507e-01f,
  4.16548938e-01f, 4.19327408e-01f, 3.30581009e-01f, 1.06105730e-01f, 3.85138690e-01f, 4.82188553e-01f, -6.01741731e-01f, 6.91831529e-01f, -5.52547574e-01f, 2.87411273e-01f,
  -6.86065197e-01f, -2.10032508e-01f, 1.43543214e-01f, 4.88617539e-01f, -4.72983539e-01f, -5.56409836e-01f, 4.30897832e-01f, -1.00907540e+00f, -6.42493069e-01f, -4.37379211e-01f,
  3.62002790e-01f, -5.60987830e-01f, -9.00079727e-01f, 6.88107550e-01f, 1.78727552e-01f, -4.49303463e-02f, 5.34506282e-03f, 1.96959972e-01f, 1.05135120e-01f, -5.68886459e-01f,
  9.96748284e-02f, 9.94277373e-02f, -2.87569761e-01f, -5.93275666e-01f, -3.90671939e-01f, -5.29318392e-01f, -9.14932862e-02f, -8.63837421e-01f, -2.29801342e-01f, 3.14549685e-01f,
  -5.25752544e-01f, -2.62113959e-01f, -1.15335368e-01f, -4.15662937e-02f, -2.39728704e-01f, 3.37292254e-01f, 5.62508047e-01f, 6.64417207e-01f, 3.10609341e-01f, 3.55777204e-01f,
  3.35306376e-01f, -1.08777511e+00f, -1.47880497e-03f, 3.32987914e-03f, -9.81677532e-01f, 1.11358061e-01f, 8.73925909e-02f, 3.43352035e-02f, 2.70483680e-02f, -5.71935892e-01f,
  -3.21596444e-01f, -4.03565049e-01f, -6.11538410e-01f, 2.34263182e-01f, -5.04329056e-03f, 2.86941797e-01f, 1.34696737e-01f, -4.28825408e-01f, 9.28142853e-03f, -1.36726528e-01f,
  -4.10282165e-02f, 1.97641596e-01f, 3.97091925e-01f, -2.87468493e-01f, -4.25938904e-01f, -2.62476921e-01f, -8.25900674e-01f, -7.50803471e-01f, 6.72708273e-01f, 6.71405420e-02f,
  -1.29598248e+00f, -8.51754367e-01f, -6.19980395e-01f, 3.00591111e-01f, 3.43824089e-01f, -4.73525405e-01f, 4.91693318e-01f, -1.96774110e-01f, -5.62490262e-02f, -8.11056569e-02f,
  2.26185411e-01f, 4.02203351e-01f, 3.33452463e-01f, -2.52349824e-01f, 6.53721988e-01f, 5.85456073e-01f, -1.91437136e-02f, -5.69813773e-02f, 4.37343776e-01f, -3.21334511e-01f,
  -5.11650145e-02f, -7.73093104e-01f, 8.26820910e-01f, -1.10574317e+00f, -5.61318696e-01f, -7.38621354e-01f, 2.41153702e-01f, 4.75642711e-01f, 1.79074660e-01f, -6.81905270e-01f,
  4.24251735e-01f, 5.52851498e-01f, -8.92119765e-01f, -6.86292171e-01f, 3.66847962e-01f, 2.93588549e-01f, -1.13134205e+00f, 4.59068939e-02f, 3.33066404e-01f, 2.02587277e-01f,
  3.12258095e-01f, -1.50891975e-01f, 4.65673268e-01f, -7.61293247e-02f, 4.70036060e-01f, 1.63423434e-01f, 2.02902362e-01f, -2.92661667e-01f, -3.28453146e-02f, 1.57693461e-01f,
  -8.36827219e-01f, 6.71699345e-02f, -6.64437056e-01f, 6.73253119e-01f, 5.17649114e-01f, 5.44114172e-01f, 2.55472511e-02f, 6.23161912e-01f, 1.00781536e+00f, -3.29049826e-01f,
  -2.75977641e-01f, -2.54108965e-01f, -4.79569256e-01f, -8.17084789e-01f, 6.77713379e-02f, -1.74616575e-01f, -3.52410883e-01f, 3.67294341e-01f, -1.14329743e+00f, 7.13083625e-01f,
  9.04734582e-02f, -3.40664119e-01f, -3.77364486e-01f, 6.87211752e-02f, 4.29996759e-01f, 2.40765318e-01f, 1.63489684e-01f, -1.35302916e-01f, -3.87020439e-01f, 5.29026389e-01f,
  4.71012145e-01f, -1.12661272e-01f, -3.00699775e-03f, -3.09571922e-01f, -5.85306585e-01f, -4.00189489e-01f, -2.99235404e-01f, 1.19583264e-01f, -4.08327347e-03f, -3.27709258e-01f,
  4.38467473e-01f, 1.88937679e-01f, -1.01645067e-01f, 8.69374931e-01f, -9.34701502e-01f, 5.17788887e-01f, -1.45383671e-01f, 3.35206568e-01f, -2.68302768e-01f, -1.03308821e+00f,
  -5.95264077e-01f, 4.63631004e-01f, 6.01816237e-01f, 2.13964671e-01f, 3.44250910e-02f, -1.03569433e-01f, -2.16911465e-01f, -3.62578660e-01f, -3.06194633e-01f, 3.80149573e-01f,
  3.28742385e-01f, 1.37979805e-01f, 5.84220141e-02f, -1.29083589e-01f, -3.35524768e-01f, 3.46535832e-01f, -4.86964956e-02f, 4.17360663e-01f, 6.71674848e-01f, -5.57668746e-01f,
  5.66543877e-01f, -2.78566256e-02f, 1.85989842e-01f, 6.84979618e-01f, -5.70134640e-01f, 8.29570532e-01f, 4.67662632e-01f, -9.16891173e-02f, -9.46086764e-01f, -4.00870085e-01f,
  -8.02479982e-01f, -4.57396060e-01f, -1.93999082e-01f, -9.65319946e-03f, 3.51444006e-01f, 8.60346437e-01f, -3.81642133e-01f, 7.98473507e-02f, -5.12305237e-02f, -1.07296295e-01f,
  1.01863034e-01f, 2.37228140e-01f, 8.39373469e-02f, 4.11377907e-01f, -3.31842266e-02f, 2.71368146e-01f, 4.93179560e-02f, -1.81022823e-01f, 3.72653455e-01f, 3.44204724e-01f,
  -5.18487573e-01f, -5.73535264e-01f, 6.32374287e-01f, -1.61504492e-01f, -3.83595526e-01f, 3.56053770e-01f, 2.74487436e-01f, -6.68287575e-01f, 9.99586135e-02f, -6.33618295e-01f,
  2.92548120e-01f, 6.07322872e-01f, 1.87939018e-01f, -7.72895634e-01f, 5.94025075e-01f, -6.26735866e-01f, -3.19743574e-01f, -1.25496686e+00f, 4.06029046e-01f, 3.07999760e-01f,
  -2.89901078e-01f, -4.32986319e-01f, -4.61777240e-01f, 1.99702054e-01f, -6.76680088e-01f, -1.75008729e-01f, -8.53859067e-01f, 2.08866417e-01f, -2.81435028e-02f, 3.50767404e-01f,
  7.48729892e-03f, -9.52693596e-02f, -7.73327649e-01f, 7.77076423e-01f, -2.85955727e-01f, 5.02147079e-01f, 3.51440400e-01f, 7.34966338e-01f, 4.10659313e-02f, -4.59676147e-01f,
  9.05996501e-01f, -2.60155529e-01f, -8.95131111e-01f, 5.04262209e-01f, 4.33980078e-01f, -2.45695099e-01f, -8.29606771e-01f, -1.44767180e-01f, -1.27030492e-01f, 3.08454692e-01f,
  1.66277774e-02f, -4.39934758e-03f, -2.05563530e-01f, -1.76881105e-01f, -2.83638328e-01f, -6.82239652e-01f, -5.85595667e-01f, -6.69756949e-01f, -3.24920677e-02f, -1.70762926e-01f,
  1.25297293e-01f, 2.12237194e-01f, 5.28636396e-01f, 6.77499175e-01f, 6.41272366e-01f, -5.89977503e-01f, 4.43567991e-01f, -3.22384506e-01f, -4.75545041e-02f, -3.50616544e-01f,
  4.41437781e-01f, 8.20225835e-01f, 4.26040322e-01f, 5.14460146e-01f, -2.88858384e-01f, 5.71804762e-01f, -3.57357025e-01f, 1.52639121e-01f, 2.62762696e-01f, 2.95260936e-01f,
  -3.27503800e-01f, -2.85028070e-01f, -2.16703758e-01f, -5.84589660e-01f, -3.54800045e-01f, 4.12604272e-01f, 4.44968611e-01f, 3.88459086e-01f, 1.18194960e-01f, -5.87795496e-01f,
  1.96034193e-01f, 1.01711482e-01f, -3.72378618e-01f, -2.15848923e-01f, -5.01904607e-01f, -7.36650229e-01f, 4.98565078e-01f, 3.03711563e-01f, 1.99331477e-01f, -2.39140660e-01f,
  -3.61052513e-01f, -2.47697338e-01f, 1.24803916e-01f, 1.90880373e-01f, -6.30418777e-01f, 4.29728538e-01f, -2.62677521e-01f, -6.05419517e-01f, 5.16865134e-01f, 1.89960882e-01f,
  4.39623684e-01f, -2.20316976e-01f, 1.68388158e-01f, -1.42351294e+00f
};

// L2_linear_B (Shape: 1 x 12)
const int L2_linear_B_rows = 1;
const int L2_linear_B_cols = 12;
const float L2_linear_B_data[] = {
  3.53027642e-01f, 2.59280324e-01f, -3.24113339e-01f, -1.16598599e-01f, 9.20521468e-02f, -1.15723116e-02f, 2.54637916e-02f, 1.65588893e-02f, -5.81485182e-02f, 1.17659412e-01f,
  -1.56273469e-01f, -1.83320623e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 12, 8
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        32, 12, 8
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_linear
    linear_forward_pgm(
        buffer1, x_out,
        L2_linear_W_data, L2_linear_B_data,
        32, 12
    );
    }
    