/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 16 (x2)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 16;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    float x3 = x * x * x;
    return 0.5f * x * (1.0f + tanhf(0.79788456f * (x + 0.044715f * x3)));
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 4 x 120)
const int L0_fan_Wp_rows = 4;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -4.13990438e-01f, 1.99174196e-01f, -2.36640409e-01f, -7.42766708e-02f, -3.77238393e-01f, 2.80201603e-02f, 3.90393548e-02f, -2.08744764e-01f, -1.45925388e-01f, 2.07344443e-01f,
  -1.26679495e-01f, 6.58505708e-02f, 2.35286076e-02f, 1.07991338e-01f, 2.60042474e-02f, 1.89021334e-01f, -4.48745340e-02f, 3.18765901e-02f, -5.61146885e-02f, -2.34611467e-01f,
  -2.13993397e-02f, -7.26826862e-02f, 1.10779986e-01f, -3.02928705e-02f, -3.07412684e-01f, -1.08033270e-01f, -1.07577713e-02f, -3.64883393e-02f, -3.32157761e-05f, 3.87084819e-02f,
  1.06511191e-01f, 1.03509866e-01f, 3.64974439e-05f, 5.99428527e-02f, -1.62371889e-01f, -7.10689500e-02f, 9.16161109e-03f, 1.34277537e-01f, 1.39549433e-03f, -7.16011226e-02f,
  -8.68968293e-02f, -1.27096504e-01f, 8.66489485e-02f, -3.41615528e-02f, -7.54663423e-02f, -4.16115075e-02f, -6.05974607e-02f, -8.01382065e-02f, -3.19413282e-02f, -2.88728308e-02f,
  -9.77491811e-02f, -4.03240472e-02f, -1.46288007e-01f, 3.57384495e-02f, -8.67830366e-02f, -2.27130111e-02f, 9.91691202e-02f, 4.54773381e-02f, -1.97877996e-02f, -7.57606924e-02f,
  -4.78588901e-02f, -4.24480885e-02f, -1.34280780e-02f, -3.21331061e-02f, -1.04860365e-01f, -3.03425156e-02f, -9.32905376e-02f, -1.21877184e-02f, -9.89876017e-02f, -3.39278579e-03f,
  -1.58251002e-01f, 3.06179170e-02f, -2.63504311e-02f, 1.39574697e-02f, 2.29432136e-02f, 2.69887801e-02f, 3.62561904e-02f, -5.35941534e-02f, -3.70032676e-02f, 5.81747852e-02f,
  9.68361646e-03f, 7.32843392e-03f, -6.42175367e-03f, -6.94188997e-02f, -2.37618163e-02f, -1.16201304e-02f, -5.54410480e-02f, -7.07557239e-03f, 2.76500359e-02f, -1.61554161e-02f,
  -6.77675530e-02f, 4.29201722e-02f, 5.51013388e-02f, 2.13405415e-02f, 8.33921134e-02f, -2.81145535e-02f, 2.42200103e-02f, -1.43266067e-01f, 1.76198278e-02f, -2.48470735e-02f,
  3.47335227e-02f, 3.98548599e-03f, -6.23060539e-02f, -5.72112249e-03f, 4.32030577e-03f, -3.59068438e-02f, 9.08744037e-02f, 8.65188465e-02f, 2.85631660e-02f, -9.88751068e-04f,
  4.98943664e-02f, -6.33444786e-02f, 9.47541669e-02f, -7.76097039e-03f, 9.62134451e-02f, 4.31248173e-02f, -1.30429929e-02f, 2.01190300e-02f, -2.49479301e-02f, 2.73598358e-02f,
  -2.74075419e-01f, 1.69958845e-01f, 4.85980175e-02f, -1.24045074e-01f, -2.09110275e-01f, -3.15234184e-01f, -2.45496944e-01f, -1.65089443e-02f, 3.34769726e-01f, -3.12778763e-02f,
  -1.24921605e-01f, 5.64315356e-02f, 7.33797401e-02f, -1.65974334e-01f, -2.40376797e-02f, 8.56180117e-02f, -8.97632167e-02f, -6.65612072e-02f, 9.56746340e-02f, -6.82792738e-02f,
  -7.76800420e-03f, -1.35827094e-01f, -2.25799859e-01f, -5.57848327e-02f, -1.32396027e-01f, 3.60141285e-02f, 2.26857904e-02f, 1.38345696e-02f, -1.97765157e-01f, -3.32701989e-02f,
  -5.45321554e-02f, -2.67804065e-03f, -8.96209851e-02f, 5.33202291e-02f, -2.58944463e-02f, -8.19478706e-02f, -4.39857692e-02f, -9.40138474e-02f, -2.28725635e-02f, 5.18814288e-03f,
  7.55766556e-02f, -1.32328169e-02f, 1.58400778e-02f, 4.65448312e-02f, -2.31122896e-02f, 1.53367603e-02f, -1.48418816e-02f, -5.44552468e-02f, -6.09185696e-02f, -1.06955849e-01f,
  -4.54602018e-02f, -2.12174300e-02f, -6.98801503e-02f, 4.53989580e-02f, -1.01405652e-02f, 7.74164917e-03f, -5.26058041e-02f, -4.02460471e-02f, -2.81766448e-02f, -1.74780898e-02f,
  3.20080528e-03f, 4.62647947e-03f, -3.57045382e-02f, 2.97287423e-02f, -1.15213320e-02f, -1.62331648e-02f, 1.68262031e-02f, -8.13891087e-03f, 7.79031366e-02f, -9.12235975e-02f,
  3.35586369e-02f, -6.34505302e-02f, 6.11465499e-02f, -8.57275128e-02f, 1.67327859e-02f, -3.85687873e-02f, 2.76903026e-02f, -1.30715994e-02f, -2.33413558e-02f, -7.69006088e-02f,
  4.77375388e-02f, 2.19155103e-02f, -3.46636996e-02f, -3.38312238e-02f, 1.47784911e-02f, 1.31334434e-03f, 3.61040644e-02f, 3.19257230e-02f, -2.69894097e-02f, -6.13281913e-02f,
  2.13610277e-01f, 2.95726627e-01f, -3.04726008e-02f, -9.91619378e-02f, 8.73565599e-02f, -2.75120027e-02f, 2.96505801e-02f, 2.12089028e-02f, 5.95026948e-02f, 3.83378528e-02f,
  -7.94769675e-02f, -9.10426378e-02f, 1.07130995e-02f, -4.84041460e-02f, 5.00161014e-02f, 2.34157033e-02f, 3.89288389e-03f, 5.53390533e-02f, 5.95388524e-02f, -2.30783597e-02f,
  -3.22353281e-02f, -2.29854025e-02f, 2.24058665e-02f, -8.79842341e-02f, -6.92232549e-02f, -8.59592482e-02f, 5.52767739e-02f, 2.56801061e-02f, -1.15176672e-02f, 4.57556397e-02f,
  -3.70253295e-01f, 2.29663670e-01f, 2.10905641e-01f, 1.39305368e-01f, 1.26658425e-01f, 3.35874647e-01f, 2.51806200e-01f, 1.86838463e-01f, 3.67676735e-01f, -8.45376998e-02f,
  8.77623167e-03f, 6.22511953e-02f, 2.01720864e-01f, 8.21420997e-02f, -4.22489550e-03f, 3.38982403e-01f, 6.56247139e-03f, 3.07319630e-02f, 1.90044656e-01f, -7.15910131e-03f,
  1.21158682e-01f, -3.97921279e-02f, 1.32065505e-01f, -6.32627755e-02f, -5.87982051e-02f, -5.28227538e-02f, -2.49186456e-01f, 6.01393054e-04f, -3.42786372e-01f, -3.96468155e-02f,
  -1.00318395e-01f, 2.13633198e-02f, 5.24045080e-02f, 3.96152437e-02f, -1.88899674e-02f, -1.56497005e-02f, -1.95284728e-02f, 2.77365521e-02f, 7.12445602e-02f, -7.97583833e-02f,
  4.73848544e-02f, -1.83080077e-01f, 4.31636907e-02f, 1.09326586e-01f, 1.22966163e-01f, -8.50134864e-02f, 2.49783583e-02f, 2.30423380e-02f, -4.13730145e-02f, 4.93753180e-02f,
  4.42251116e-02f, -8.76658112e-02f, -1.03471175e-01f, 3.78149450e-02f, 7.63421133e-02f, -6.56207278e-03f, 7.23492280e-02f, -2.24635564e-02f, -1.15729354e-01f, 3.63086239e-02f,
  8.85953158e-02f, 1.72336008e-02f, 6.56522736e-02f, -2.50799321e-02f, 3.84193510e-02f, -8.14006254e-02f, -7.02614561e-02f, -2.70797014e-02f, -7.64600337e-02f, 7.28208646e-02f,
  -8.48977938e-02f, 4.49797958e-02f, 2.74922997e-02f, 1.12064064e-01f, -2.51833554e-02f, -5.14681786e-02f, -4.68767919e-02f, 3.20600048e-02f, -2.70836838e-02f, 1.52256206e-01f,
  -4.88228574e-02f, -4.78015281e-02f, 6.22663461e-02f, -1.21755615e-01f, -1.22448169e-01f, 1.08259387e-01f, 6.40253350e-02f, -1.18958494e-02f, 1.21989287e-01f, 6.31684139e-02f,
  -1.20340651e-02f, -1.47539496e-01f, 8.94192532e-02f, 4.23900550e-03f, 3.28418799e-02f, 4.50924970e-02f, 7.93621317e-02f, 9.56165418e-03f, 1.83380209e-02f, 3.26854885e-02f,
  3.84677318e-04f, 3.69553752e-02f, -2.81296194e-01f, 2.84695271e-02f, 4.02158545e-03f, 5.11772670e-02f, -1.41011328e-01f, 1.39613682e-02f, -1.22506348e-02f, -2.28792429e-02f,
  -1.61042050e-01f, -5.20454049e-02f, -3.42263915e-02f, 1.47204101e-03f, 7.74925798e-02f, -1.61392838e-01f, -5.04967794e-02f, 6.52836412e-02f, 2.36267447e-02f, -8.02628100e-02f,
  -4.71691072e-01f, 4.39986408e-01f, 2.71166563e-01f, -6.23487495e-02f, -1.23694807e-01f, 2.71621346e-01f, 8.60637426e-02f, -1.99533510e-03f, -2.26472646e-01f, 2.04739809e-01f,
  9.09690037e-02f, 1.34489760e-01f, 1.37247920e-01f, 2.41785124e-01f, -1.18829392e-01f, 1.62135467e-01f, 1.27387363e-02f, 9.78158787e-02f, -4.90540755e-04f, 1.30986506e-02f,
  -9.92121324e-02f, 6.88697994e-02f, 1.01162031e-01f, 7.57986307e-02f, 3.33407260e-02f, 3.29164080e-02f, -1.22131862e-01f, 1.29993513e-01f, -1.46701178e-02f, 1.08804062e-01f,
  2.24216282e-02f, 9.00915265e-02f, 3.42270471e-02f, 8.11344460e-02f, 3.93342227e-02f, 2.08753087e-02f, 1.60070416e-02f, -1.04724169e-02f, -4.53184843e-02f, -8.14674143e-03f,
  4.79361787e-02f, 2.09505875e-02f, 6.85172807e-03f, -6.00244058e-03f, 2.96439324e-02f, 3.69263850e-02f, -1.05590113e-02f, -3.02609783e-02f, 1.12999097e-01f, 5.32446057e-02f,
  3.55419628e-02f, 8.70618504e-03f, 4.76034768e-02f, -1.40007026e-02f, 3.51348077e-04f, -6.19799318e-03f, 1.59698576e-02f, 5.74590378e-02f, 4.79183532e-02f, -2.54229363e-03f,
  3.57544571e-02f, 9.02459491e-03f, 5.46811223e-02f, -1.57207977e-02f, 6.43392578e-02f, -8.60531926e-02f, 6.39777035e-02f, 4.60010916e-02f, -1.79847665e-02f, -2.38759536e-03f,
  -3.70551646e-02f, 1.36715332e-02f, 2.35561989e-02f, -1.41382124e-02f, -3.99960615e-02f, 4.94567119e-03f, -9.11305025e-02f, 5.03024086e-02f, -3.81818153e-02f, 4.50297445e-02f,
  -8.06354452e-03f, 3.48659344e-02f, 5.55808023e-02f, 5.07871807e-03f, 6.75025359e-02f, 3.06327529e-02f, 1.06352856e-02f, 5.79462573e-02f, -4.11341935e-02f, 4.64870036e-02f,
  1.33285850e-01f, 2.35403329e-01f, -3.87265235e-02f, -1.01744691e-02f, -5.05951941e-02f, -3.56746726e-02f, -4.27681841e-02f, -1.01442011e-02f, 1.03103682e-01f, 9.63666737e-02f,
  -6.02323711e-02f, 1.91290639e-02f, -5.75222354e-03f, 3.46814282e-02f, 9.15845763e-03f, 3.56433094e-02f, 5.25010601e-02f, 6.88554812e-03f, -7.50792846e-02f, 3.06488760e-02f,
  8.42438545e-03f, 1.55927287e-02f, -2.77699940e-02f, 4.67856638e-02f, -2.49505602e-02f, -7.06232339e-03f, -7.15588853e-02f, -2.02765167e-02f, -4.96774726e-03f, 2.71292357e-03f
};

// L0_fan_Wp_bar (Shape: 8 x 120)
const int L0_fan_Wp_bar_rows = 8;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -9.25301731e-01f, 1.63147748e-01f, -1.45355985e-01f, -7.49681592e-01f, 3.77326429e-01f, -2.41336212e-01f, -3.30511987e-01f, 9.40710008e-02f, -4.24090505e-01f, 1.59719929e-01f,
  3.17921698e-01f, -2.17699617e-01f, 1.76602393e-01f, -5.08414745e-01f, -9.44973707e-01f, -6.07750058e-01f, -7.19843805e-01f, -3.24044794e-01f, -2.26854503e-01f, 9.94905233e-02f,
  -2.61810869e-01f, -1.39210910e-01f, -4.17062312e-01f, 4.65829313e-01f, 1.94044858e-01f, 2.75305986e-01f, 1.45781562e-01f, 3.70950758e-01f, 1.08918898e-01f, -1.80018932e-01f,
  -4.43791777e-01f, 4.02151756e-02f, 8.83943960e-02f, 1.58511072e-01f, -1.01014236e-02f, 2.23424196e-01f, 7.95534924e-02f, -9.03969109e-02f, -6.64149225e-02f, 2.83157695e-02f,
  1.26961261e-01f, 3.88032049e-02f, -7.91172981e-02f, 1.06886201e-01f, 3.86543348e-02f, 6.09877668e-02f, -6.80168048e-02f, -1.02216884e-01f, 1.53291291e-02f, 1.45199016e-01f,
  7.18603358e-02f, -1.22757256e-02f, 1.07427806e-01f, -1.52336538e-01f, 2.71316003e-02f, -4.77181980e-03f, -1.28672197e-01f, 5.53598590e-02f, -3.72271687e-02f, -1.77814156e-01f,
  -1.62610933e-02f, 2.10308433e-01f, -2.07839906e-02f, -1.72145948e-01f, -5.79738095e-02f, 2.92397458e-02f, -7.80387688e-03f, 9.98361269e-04f, 1.57880113e-02f, 2.74307746e-02f,
  2.14704201e-02f, -1.19642243e-02f, -1.75039489e-02f, 3.83563861e-02f, 2.96282265e-02f, -2.31785662e-02f, 4.23841849e-02f, 8.03977102e-02f, -9.70813558e-02f, -7.62999728e-02f,
  -4.69180336e-03f, -4.61007357e-02f, 7.42437169e-02f, 4.04139385e-02f, -1.39777586e-01f, 4.73942533e-02f, 1.87416971e-01f, -8.68166797e-03f, 2.33308841e-02f, -1.05696516e-02f,
  -5.35455383e-02f, -5.64945824e-02f, 4.87731546e-02f, 1.11966871e-01f, -5.59278913e-02f, -1.11597016e-01f, -1.00702569e-01f, 5.05823568e-02f, -1.43958926e-01f, -2.58883797e-02f,
  5.03985658e-02f, -9.16059408e-03f, 9.68562290e-02f, -7.13877454e-02f, -3.43239233e-02f, -1.59063190e-01f, 6.80149645e-02f, -2.87905280e-02f, -1.53826550e-01f, 9.12868753e-02f,
  1.35230824e-01f, 1.47288084e-01f, -6.13776855e-02f, 4.00915965e-02f, 8.93797353e-02f, -1.66096278e-02f, -9.08019468e-02f, -6.24063648e-02f, 2.68488545e-02f, -3.23738419e-02f,
  -1.43927085e+00f, 5.54480195e-01f, 9.23249056e-04f, -9.56921205e-02f, -4.08631265e-01f, -4.22073808e-03f, -7.69773498e-03f, 8.51867497e-02f, -1.78972125e-01f, 2.93745697e-01f,
  1.26140296e-01f, -2.30518490e-01f, 3.34233075e-01f, 4.67192084e-01f, -5.04095733e-01f, 2.95383662e-01f, -1.74539387e-02f, -4.27905992e-02f, 1.32708490e-01f, -2.43249666e-02f,
  -1.80462345e-01f, 2.45592773e-01f, 1.42115608e-01f, 2.86772311e-01f, -2.86764670e-02f, -1.29621103e-01f, -1.17902264e-01f, -2.20592003e-02f, 5.77568188e-02f, -1.75003782e-02f,
  -3.85578573e-01f, -1.77470505e-01f, -1.57347858e-01f, -2.09006339e-01f, -1.46309972e-01f, -1.31316826e-01f, -1.89835086e-01f, -1.11138247e-01f, -1.18091755e-01f, 5.26740856e-04f,
  -1.16338365e-01f, 1.04011083e-02f, 1.43709973e-01f, -2.75460538e-02f, -1.43230304e-01f, 9.22913626e-02f, 1.31887585e-01f, 1.31771475e-01f, 1.40820637e-01f, 1.07229508e-01f,
  2.19279483e-01f, 1.18144274e-01f, 2.01278944e-02f, 1.64001644e-01f, -1.00206688e-01f, 3.22650522e-02f, 6.93686157e-02f, -8.99030343e-02f, -5.05352020e-02f, -1.00813597e-01f,
  -1.87317003e-02f, -1.14151299e-01f, 5.32573275e-03f, -9.22400579e-02f, 2.19271444e-02f, -3.83717846e-03f, 5.56683876e-02f, -2.22026873e-02f, -2.09828578e-02f, 6.55969679e-02f,
  5.91995195e-02f, -1.07899494e-01f, -6.10573590e-02f, -3.76486294e-02f, -1.35664135e-01f, 7.59410411e-02f, 4.34143245e-02f, -5.64325079e-02f, -1.65016633e-02f, -1.40939787e-01f,
  9.01027489e-03f, -1.12385564e-02f, 5.45394495e-02f, 1.00413151e-02f, -7.72623047e-02f, -5.88962846e-02f, 2.09977999e-02f, 5.78076765e-02f, -2.71726120e-02f, -1.41232992e-02f,
  -9.88762677e-01f, -7.12270021e-01f, -1.35221891e-02f, -5.41866943e-02f, -1.18612014e-01f, 1.75212491e-02f, 2.83210892e-02f, -4.17928956e-02f, -1.77022979e-01f, -1.39355108e-01f,
  -3.08669201e-04f, -4.68373150e-02f, -1.66919410e-01f, 4.47680010e-03f, 4.13158759e-02f, 8.57197642e-02f, -1.45032093e-01f, -1.24180928e-01f, -1.23538181e-01f, 2.35017613e-02f,
  -5.38437702e-02f, 2.99378503e-02f, 1.20826244e-01f, 6.98829591e-02f, -3.72927748e-02f, -1.00784093e-01f, -1.50891155e-01f, -3.13207274e-03f, -1.49832621e-01f, 1.76627673e-02f,
  -1.03368171e-01f, -4.16989505e-01f, 4.06040758e-01f, -3.80452007e-01f, 2.09761411e-01f, -4.43510264e-02f, 2.02324107e-01f, -3.86461169e-01f, -3.20948809e-01f, -5.56154609e-01f,
  8.10953137e-03f, 2.01796532e-01f, 3.72632831e-01f, -5.19680977e-01f, 8.66372526e-01f, 2.42852092e-01f, -4.41563100e-01f, -2.36493144e-02f, -8.12757462e-02f, -2.71266431e-01f,
  -3.39079015e-02f, -5.31495214e-01f, 2.00721160e-01f, -5.23588240e-01f, -1.85713410e-01f, -2.86133081e-01f, 3.21577936e-02f, 2.25742802e-01f, -3.23684335e-01f, 2.84926504e-01f,
  -2.39128247e-02f, -1.73526406e-01f, -7.10402876e-02f, -3.28687392e-02f, -1.21716470e-01f, 4.34895046e-02f, 6.57463446e-02f, 1.96922123e-01f, -3.77266780e-02f, -3.18836942e-02f,
  2.10261326e-02f, -5.42654321e-02f, -1.89203486e-01f, 1.79733953e-03f, -9.32477489e-02f, 1.16798831e-02f, -4.97230440e-02f, -4.82313000e-02f, -5.63878566e-02f, 2.32209280e-01f,
  8.20127428e-02f, 6.00066148e-02f, 1.06124319e-01f, 3.25248055e-02f, 4.91614044e-02f, -8.21080953e-02f, 6.36217967e-02f, 1.83291733e-01f, 5.59219159e-02f, -2.12166429e-01f,
  -5.14898561e-02f, -4.68458198e-02f, 6.63266778e-02f, -1.91210061e-01f, -6.96996134e-03f, 6.82279700e-03f, 1.81078650e-02f, 3.14569883e-02f, -2.97211893e-02f, -1.20422833e-01f,
  -1.22768067e-01f, -3.14267050e-03f, 1.60850082e-02f, 6.59454092e-02f, -1.10526368e-01f, -2.74922717e-02f, 2.38051824e-02f, 7.06337541e-02f, -1.69467404e-01f, -9.77376755e-03f,
  2.62924340e-02f, 1.65423140e-01f, 5.01459613e-02f, -4.99562398e-02f, 4.68336418e-02f, 4.59434018e-02f, 5.64756896e-03f, -2.41525881e-02f, 4.41902271e-03f, 1.72964364e-01f,
  -3.71794224e-01f, -7.56821513e-01f, -1.66622967e-01f, -8.14966187e-02f, 3.87676358e-02f, -9.96918902e-02f, 4.16884199e-02f, -1.46383226e-01f, -5.11494763e-02f, -1.39986826e-02f,
  -3.01302839e-02f, -1.13477819e-01f, 3.84257920e-02f, -3.47075723e-02f, -7.12939948e-02f, -9.61121619e-02f, 1.25411600e-01f, -1.28693596e-01f, -3.98619510e-02f, -1.19877681e-01f,
  -9.41125676e-02f, -6.57340139e-02f, 1.71038434e-01f, -1.73587456e-01f, -2.72890683e-02f, 3.92842181e-02f, -5.54333851e-02f, 7.88573269e-03f, -1.27509031e-02f, 7.47009441e-02f,
  4.92794424e-01f, 2.27272540e-01f, -1.43458202e-01f, 2.96864986e-01f, -4.44671838e-03f, -5.23273200e-02f, -3.77783060e-01f, 1.71585783e-01f, -3.48541230e-01f, 3.06521952e-02f,
  5.25890410e-01f, -2.00671673e-01f, 6.51438609e-02f, 8.08521807e-01f, 2.28658050e-01f, -1.19638540e-01f, 3.44457865e-01f, -8.71890225e-03f, -2.36085624e-01f, 1.26465365e-01f,
  2.28123337e-01f, 6.66406453e-01f, 3.10685426e-01f, 2.52376556e-01f, 2.03143224e-01f, 6.06795140e-02f, 3.69351417e-01f, -1.75348163e-01f, 5.17014921e-01f, 1.36896789e-01f,
  5.79944812e-02f, 3.68168503e-02f, -5.81962354e-02f, -1.45268932e-01f, 1.48257554e-01f, 9.77909490e-02f, -1.62405953e-01f, 4.35691439e-02f, -4.90549356e-02f, 3.49209673e-04f,
  -1.17983155e-01f, 2.67124493e-02f, 2.63462421e-02f, 2.67563947e-02f, 1.83528699e-02f, -9.47425514e-02f, -2.03264076e-02f, -6.76121935e-03f, -1.32512286e-01f, 6.22828007e-02f,
  -1.02878064e-01f, 6.88557476e-02f, -1.65879726e-02f, -1.00975549e-02f, -1.30922571e-02f, -7.69336224e-02f, -1.31844655e-01f, -5.02313711e-02f, -3.17353047e-02f, -9.98950526e-02f,
  2.09181294e-01f, -5.31436242e-02f, -3.58193088e-03f, 3.90265360e-02f, 1.34801775e-01f, 4.87019718e-02f, -3.89344408e-03f, 9.44334082e-03f, -1.03637695e-01f, 8.72348100e-02f,
  4.35658731e-02f, 5.37492009e-03f, 7.13803545e-02f, 1.70367565e-02f, -2.45476644e-02f, -1.74844369e-01f, -7.56332427e-02f, 1.03801832e-01f, -1.09856129e-02f, -8.35010856e-02f,
  -4.66277152e-02f, 7.22519681e-02f, -8.37560464e-03f, -5.01424558e-02f, 1.83168650e-02f, 3.05776317e-02f, 2.43234470e-01f, 8.18784684e-02f, -1.46282092e-01f, -5.24804033e-02f,
  1.43219782e-02f, 2.09772259e-01f, -2.31456637e-01f, -3.57262939e-02f, -1.31179824e-01f, 1.22105069e-01f, -2.02371720e-02f, -1.63950343e-02f, 9.47689638e-02f, 1.36650950e-01f,
  -2.34873947e-02f, -1.10729598e-04f, -1.08520240e-02f, 8.59423578e-02f, 5.06490432e-02f, 9.64687690e-02f, 3.76715958e-02f, -2.94206720e-02f, 4.89329919e-02f, 9.00873467e-02f,
  9.82561931e-02f, -5.18141799e-02f, -6.87321201e-02f, -7.27586374e-02f, 4.55690473e-02f, -3.47866002e-03f, -4.42421697e-02f, -1.34343922e-01f, 1.24058336e-01f, -7.68013522e-02f,
  3.68362010e-01f, 7.60266721e-01f, 6.84848487e-01f, 5.06146312e-01f, -3.13125938e-01f, -7.81909883e-01f, -4.39734668e-01f, 2.21860737e-01f, -6.18102923e-02f, 1.96905583e-01f,
  -1.47091195e-01f, 5.07747829e-01f, 1.23166833e-02f, 1.17653534e-01f, -3.06646287e-01f, -4.66938257e-01f, 2.88869232e-01f, 1.45955101e-01f, 8.76171142e-02f, 4.07094747e-01f,
  2.27405936e-01f, -2.54353940e-01f, 3.96473974e-01f, -5.23721837e-02f, 2.82772183e-01f, 6.05590582e-01f, 1.39411077e-01f, -2.41329875e-02f, 3.43435854e-01f, -1.90371588e-01f,
  -1.21280566e-01f, 7.25653172e-02f, 2.28369355e-01f, -1.23778820e-01f, 7.82659501e-02f, 3.97914574e-02f, 7.64909899e-03f, -2.32175678e-01f, -7.84863085e-02f, 5.09760007e-02f,
  -3.54412384e-02f, -5.35486750e-02f, 1.35755062e-01f, -1.27142936e-01f, -1.39720514e-01f, 1.07854061e-01f, 4.69233096e-02f, 9.86346081e-02f, 7.97626823e-02f, 1.31291315e-01f,
  1.59130976e-01f, 2.32380256e-01f, -1.16362069e-02f, 1.22602530e-01f, 1.07129768e-01f, -1.64046898e-01f, -2.80529074e-02f, 1.78210661e-01f, -8.25033411e-02f, 5.33965118e-02f,
  2.82545928e-02f, -1.21840723e-01f, -8.80668312e-02f, -4.05417271e-02f, -1.62997037e-01f, -7.54395723e-02f, -9.11273882e-02f, 3.97300087e-02f, -1.68777764e-01f, -1.16609624e-02f,
  -6.78717270e-02f, -1.08250475e-03f, -1.15113810e-01f, -1.46584854e-01f, 2.79072244e-02f, -9.10434499e-02f, -3.01127508e-03f, -5.24060056e-02f, 1.95903219e-02f, 1.21959113e-03f,
  -3.29314508e-02f, -7.80439004e-02f, -6.72882050e-02f, -5.56340143e-02f, -2.20787168e-01f, 2.36496255e-02f, 8.38180855e-02f, 2.02878043e-02f, 5.45389950e-02f, 7.97021389e-02f,
  7.92339444e-02f, 2.17052370e-01f, 2.18806528e-02f, -5.13009308e-03f, -1.17956161e-01f, -8.01356584e-02f, -1.45304620e-01f, 1.50749683e-01f, 1.65114120e-01f, -4.29008454e-02f,
  1.65848777e-01f, -2.31032493e-03f, -1.23899400e-01f, 4.59561199e-02f, 7.79387802e-02f, 1.08147962e-02f, -3.33697908e-02f, 8.37847404e-03f, 1.06928326e-01f, 1.04168557e-01f,
  8.58250447e-03f, -1.78543955e-01f, 6.05491437e-02f, 8.57426971e-03f, 2.48323437e-02f, 9.65243950e-02f, -5.73617592e-02f, 3.09187546e-02f, 8.69573280e-02f, -2.27181725e-02f,
  3.37518483e-01f, 4.09021229e-01f, -6.43191934e-01f, 3.05201337e-02f, -3.28189075e-01f, 5.62761664e-01f, 5.29593289e-01f, -2.03863308e-01f, -3.09984945e-02f, 7.06091225e-01f,
  2.90486723e-01f, 4.25210595e-02f, 3.34251970e-01f, 5.40575624e-01f, -2.23180532e-01f, 4.32893187e-01f, 4.13293898e-01f, 4.63405818e-01f, -1.37867972e-01f, 2.57868946e-01f,
  -1.22135051e-01f, 6.19101524e-01f, -2.31597245e-01f, -1.24685049e-01f, 7.86852241e-02f, -3.95971417e-01f, -6.76397830e-02f, -3.90194386e-01f, 3.87076735e-02f, -8.87285396e-02f,
  1.31893650e-01f, 7.77838156e-02f, -1.71582252e-01f, -6.24283403e-02f, 1.80593191e-03f, 2.02283803e-02f, 4.13012989e-02f, -3.49472836e-02f, -2.09718183e-01f, 1.22653119e-01f,
  1.22303754e-01f, -8.48555788e-02f, -1.92168988e-02f, -1.19365573e-01f, 4.11491804e-02f, -1.63573667e-01f, -2.08742499e-01f, -2.02673942e-01f, -1.07918307e-01f, 7.33582005e-02f,
  -4.14330587e-02f, -2.20651347e-02f, 4.31921929e-02f, -3.94104840e-03f, -1.21125780e-01f, 1.10799477e-01f, 1.47202732e-02f, -3.36883515e-02f, -1.55533860e-02f, -5.70327118e-02f,
  5.68619221e-02f, 6.48812354e-02f, 1.38633564e-01f, -4.90585417e-02f, -2.67122537e-02f, 2.08587795e-02f, 6.33051768e-02f, -3.14429738e-02f, -1.12564363e-01f, 1.00631028e-01f,
  1.87853537e-03f, 7.79704973e-02f, -2.54479107e-02f, 1.66994259e-01f, 1.84398651e-01f, 5.13943769e-02f, 1.23958446e-01f, 2.90701874e-02f, 4.98274378e-02f, -8.60682949e-02f,
  1.00567110e-01f, -2.52219336e-03f, 1.56349577e-02f, 5.68814762e-03f, 6.11190349e-02f, -5.29653132e-02f, 8.01742226e-02f, -2.04492763e-01f, -6.89984486e-02f, 5.86831681e-02f,
  1.06479444e-01f, 3.05007666e-01f, 5.86225316e-02f, -1.56361014e-02f, 1.18874316e-03f, 6.46293014e-02f, 8.36882964e-02f, -1.58936884e-02f, -3.82133238e-02f, 4.27089669e-02f,
  6.00234754e-02f, -1.34204794e-02f, 4.96870577e-02f, -1.18570469e-01f, -2.32260093e-01f, 1.46388024e-01f, 2.22794086e-01f, -5.91623262e-02f, 6.06908724e-02f, -2.76735369e-02f,
  3.25908549e-02f, 1.36723816e-01f, 4.17730734e-02f, -3.05870101e-02f, 2.96717491e-02f, -1.92691907e-02f, 4.78478409e-02f, -1.12143240e-03f, -6.68406114e-02f, 6.51199594e-02f,
  2.64818311e-01f, -1.68053282e-03f, -2.60770321e-01f, 4.81368989e-01f, 6.33463025e-01f, 5.43795109e-01f, 1.49227053e-01f, 4.76568371e-01f, 5.55219531e-01f, -1.30351618e-01f,
  -7.55857527e-02f, -8.35117847e-02f, -7.42352962e-01f, 4.06049669e-01f, 4.93061095e-01f, -2.91774839e-01f, 7.11926639e-01f, 3.12331676e-01f, 2.59544671e-01f, 2.05512226e-01f,
  2.84203470e-01f, 4.55143869e-01f, -2.89060861e-01f, 9.49383676e-02f, 2.85774022e-02f, -1.04460724e-01f, -1.73387185e-01f, -2.92564362e-01f, -5.14954403e-02f, 1.84516534e-01f,
  2.86419205e-02f, 8.37837830e-02f, -2.12141443e-02f, -9.07769725e-02f, -8.33067521e-02f, -1.54841542e-01f, -1.45287082e-01f, -1.90375045e-01f, 4.61179502e-02f, -7.41385967e-02f,
  -1.60527363e-01f, 6.39965236e-02f, 1.02454416e-01f, 1.00965768e-01f, 1.00259766e-01f, 8.99699777e-02f, -5.28801829e-02f, -2.08692215e-02f, -1.20519986e-02f, -6.52488768e-02f,
  -5.94858751e-02f, -1.12913549e-01f, 1.30585402e-01f, -6.23228252e-02f, -6.74582943e-02f, 9.09834132e-02f, 9.51695889e-02f, -1.07191168e-01f, -6.25629276e-02f, 2.60341853e-01f,
  8.81587937e-02f, 7.98848569e-02f, -7.11846054e-02f, -5.65414093e-02f, 4.97332886e-02f, -6.56805411e-02f, 5.06544709e-02f, -7.51058012e-02f, 7.31278071e-03f, -9.75716561e-02f,
  3.66427936e-02f, 8.20457712e-02f, 2.73630628e-03f, 5.03849648e-02f, 9.87026617e-02f, 1.21311814e-01f, -2.86978334e-02f, -1.64763525e-01f, -3.90041284e-02f, 2.74759810e-02f,
  -2.24766266e-02f, 2.49041528e-01f, -1.67831272e-01f, -9.53383893e-02f, 5.88861145e-02f, -1.48236617e-01f, 1.22555725e-01f, 2.67670564e-02f, -5.11994548e-02f, 8.22793543e-02f,
  2.76782751e-01f, 3.95512640e-01f, -2.05665961e-01f, 1.95433013e-02f, -9.78781059e-02f, -7.50535587e-03f, 5.76833077e-02f, 1.01608895e-01f, 1.46725504e-02f, 1.81526095e-02f,
  7.71908239e-02f, -1.56631451e-02f, -6.16932064e-02f, 5.65227307e-02f, 4.92096273e-03f, 5.65497167e-02f, 1.54167293e-02f, 1.72858164e-01f, 2.47367382e-01f, 7.33183846e-02f,
  -5.19850031e-02f, 7.30454400e-02f, 3.00391205e-02f, 1.49319604e-01f, 7.04305097e-02f, -1.77180052e-01f, 1.67860910e-01f, 1.44028161e-02f, -8.74682143e-02f, 1.54514359e-02f,
  5.65967500e-01f, 6.33350372e-01f, 7.36942172e-01f, 7.62864828e-01f, -2.60843962e-01f, 3.75145555e-01f, 3.14098597e-01f, 2.24481732e-01f, 6.78158462e-01f, 2.65135616e-01f,
  -5.87708294e-01f, 4.12382126e-01f, -3.72004300e-01f, 3.13457370e-01f, -2.00037450e-01f, -8.92491490e-02f, 3.08786631e-01f, 8.15312490e-02f, 3.29889096e-02f, 1.79104224e-01f,
  2.96582151e-02f, -5.72888792e-01f, -1.12906761e-01f, -6.30285203e-01f, 1.67356148e-01f, 1.88011721e-01f, -6.47419333e-01f, -3.80699694e-01f, 4.04225811e-02f, -1.18628308e-01f,
  -1.96301043e-02f, 1.13936625e-01f, 3.29066589e-02f, 1.82138279e-01f, 1.83916278e-03f, -1.62883904e-02f, -4.12995461e-03f, -1.02907240e-01f, -1.18195498e-02f, 1.78465873e-01f,
  -1.20454542e-01f, -3.09758317e-02f, 3.19962800e-02f, 1.57610942e-02f, 1.44668326e-01f, 5.94826527e-02f, 1.30574882e-01f, 1.15400970e-01f, 1.71455666e-01f, 8.77315775e-02f,
  1.94434240e-01f, 9.87466127e-02f, 2.53435552e-01f, 4.91986889e-03f, 1.24336936e-01f, 1.21767543e-01f, 1.57909378e-01f, -3.76304239e-02f, 7.24812970e-02f, 7.27173313e-02f,
  -6.15826063e-02f, -3.56127545e-02f, -1.05467528e-01f, -1.80508330e-01f, -5.16923741e-02f, -9.30507034e-02f, -2.16953009e-02f, -1.96204618e-01f, -4.63466384e-02f, -2.09590957e-01f,
  -2.65744831e-02f, 7.85604641e-02f, -4.71433774e-02f, 1.49107367e-01f, -1.06833473e-01f, 4.19359840e-02f, 3.82951950e-03f, -7.23144561e-02f, 1.94731712e-01f, -8.46176818e-02f,
  -6.09924234e-02f, 7.46928379e-02f, -3.20278034e-02f, 2.51702685e-02f, -3.04960571e-02f, -1.10684000e-01f, 2.15205848e-01f, -1.44830188e-02f, -2.73966007e-02f, -1.91029727e-01f,
  -1.33727536e-01f, -9.31312889e-02f, -3.31995040e-02f, -3.27779539e-02f, -1.21842220e-01f, -5.74058034e-02f, -1.61354467e-02f, 9.43920538e-02f, -3.55283618e-02f, 6.08238019e-03f,
  7.58001134e-02f, -8.16914532e-03f, 5.17968573e-02f, -1.22011319e-01f, 1.14538316e-02f, -3.18616107e-02f, 7.94708431e-02f, -2.34219655e-01f, -7.29844421e-02f, -4.71639819e-02f,
  3.46970409e-02f, -2.79047322e-02f, -1.61335319e-02f, -6.15184344e-02f, -6.04815148e-02f, -1.22735664e-01f, 1.22755781e-01f, -5.24585247e-02f, 7.72376060e-02f, 5.75067997e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 8)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 8;
const float L0_fan_Bp_bar_data[] = {
  6.68361962e-01f, 1.49558365e-01f, 4.66341406e-01f, 6.84080869e-02f, -9.28598940e-02f, 3.16715717e-01f, 7.10037708e-01f, 8.16725314e-01f
};

// L1_fan_Wp (Shape: 4 x 16)
const int L1_fan_Wp_rows = 4;
const int L1_fan_Wp_cols = 16;
const float L1_fan_Wp_data[] = {
  5.43531001e-01f, -2.23327413e-01f, -1.07259408e-01f, -2.29489356e-02f, 2.14832798e-02f, -4.99594867e-01f, -5.12362242e-01f, -1.74096689e-01f, -2.62094408e-01f, -3.94427150e-01f,
  3.10952693e-01f, 3.14622074e-01f, 1.51531875e-01f, -4.47574034e-02f, 1.91228285e-01f, -3.20801288e-01f, 7.69010305e-01f, 3.90100360e-01f, -1.24091543e-01f, 6.02689266e-01f,
  -2.68067598e-01f, -7.97905102e-02f, -5.25734186e-01f, 5.14346302e-01f, 8.38807002e-02f, -6.39311969e-01f, 8.07709917e-02f, 2.59093583e-01f, 2.28256837e-01f, 3.01123798e-01f,
  5.10057025e-02f, -1.72087505e-01f, -5.27660608e-01f, 8.07711065e-01f, 3.63529697e-02f, 2.24083662e-01f, -3.92730653e-01f, -6.47579491e-01f, 5.41495144e-01f, 5.31969309e-01f,
  -2.29293093e-01f, 1.02980480e-01f, -1.27195969e-01f, 1.57731190e-01f, 1.54820293e-01f, 4.92819697e-01f, -1.95522770e-01f, 2.41808742e-01f, -3.74875456e-01f, 4.58698124e-01f,
  4.46760803e-02f, 2.03694493e-01f, -3.04484628e-02f, 4.12798554e-01f, 5.18107593e-01f, 6.77175939e-01f, 2.65714943e-01f, 2.73608506e-01f, -2.47421309e-01f, -6.09269030e-02f,
  -5.70247054e-01f, 3.31029266e-01f, -6.29049465e-02f, 3.28592174e-02f
};

// L1_fan_Wp_bar (Shape: 8 x 16)
const int L1_fan_Wp_bar_rows = 8;
const int L1_fan_Wp_bar_cols = 16;
const float L1_fan_Wp_bar_data[] = {
  6.46596670e-01f, -8.78576279e-01f, 1.68101534e-01f, -2.49400303e-01f, 9.13497448e-01f, 1.72287166e+00f, 6.84619188e-01f, 3.36360097e-01f, 6.10825837e-01f, 6.86603606e-01f,
  7.88299620e-01f, -2.27179408e-01f, -2.76272953e-01f, 6.52356073e-02f, 1.63535699e-01f, 1.58804893e-01f, 3.57371509e-01f, 2.64453411e-01f, 4.39485729e-01f, -3.11010014e-02f,
  6.82090580e-01f, 2.12131873e-01f, 1.13628082e-01f, 1.58254170e+00f, -1.52890775e-02f, 9.29210603e-01f, -7.34093249e-01f, 6.52680695e-01f, -4.13856536e-01f, 9.67051625e-01f,
  5.42682886e-01f, -4.77550477e-02f, 2.47629076e-01f, 6.43618882e-01f, 2.38815770e-01f, 6.42819226e-01f, -8.26225936e-01f, -5.01942635e-01f, -7.16152906e-01f, -6.10275090e-01f,
  2.17415035e-01f, -1.10357118e+00f, -2.07850665e-01f, 7.09476233e-01f, 1.51091838e+00f, -2.23932695e-02f, 1.33872986e+00f, 1.15413630e+00f, -2.77854353e-01f, -1.32905245e+00f,
  1.46911860e-01f, -1.11831546e+00f, 9.24031317e-01f, 1.23756075e+00f, -4.73364741e-01f, -6.90116346e-01f, 1.49745364e-02f, -1.58440799e-01f, 2.35705659e-01f, -1.91278577e-01f,
  6.21122420e-01f, 1.82634834e-02f, -1.76389545e-01f, 1.31114125e-01f, 1.02515590e+00f, 6.34319067e-01f, 7.56338000e-01f, 3.52262765e-01f, -1.18205599e-01f, -9.30899322e-01f,
  1.13129628e+00f, 3.38790238e-01f, 7.78853968e-02f, 1.15091646e+00f, 1.34216487e+00f, -3.76495004e-01f, 2.22328082e-01f, -6.53567493e-01f, -8.75993192e-01f, 3.02384913e-01f,
  -6.65338337e-01f, 1.02458239e+00f, 2.29447156e-01f, 3.39302272e-01f, -5.51213741e-01f, -6.44817650e-01f, 1.23273695e+00f, 5.84320307e-01f, -5.62089562e-01f, 4.79256183e-01f,
  1.49787933e-01f, -5.18600166e-01f, -4.49234992e-01f, 1.07441473e+00f, 5.72831511e-01f, 1.45522451e+00f, 8.17685008e-01f, -1.88646972e-01f, -8.79007354e-02f, 5.09018838e-01f,
  -3.78617525e-01f, -3.36632848e-01f, -6.45646811e-01f, -7.84215689e-01f, 1.32345223e+00f, -1.75869092e-01f, -6.01338625e-01f, -8.79231561e-03f, -9.62596178e-01f, 1.65887520e-01f,
  1.16878784e+00f, -1.90616474e-01f, 8.15593600e-01f, 3.80388588e-01f, -1.16903096e-01f, 1.09204710e+00f, 5.49743652e-01f, 1.20989835e+00f, -2.49108016e-01f, 1.28144407e+00f,
  1.30884635e+00f, 2.86460102e-01f, -4.53420401e-01f, -1.25428629e+00f, 3.60628068e-01f, 7.07252026e-02f, -7.89088160e-02f, 1.07420707e+00f
};

// L1_fan_Bp_bar (Shape: 1 x 8)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 8;
const float L1_fan_Bp_bar_data[] = {
  6.91644371e-01f, 1.28475770e-01f, 6.45816267e-01f, 1.42272398e-01f, 5.44539630e-01f, 7.29140282e-01f, 5.42501688e-01f, 5.18330455e-01f
};

// L2_linear_W (Shape: 12 x 16)
const int L2_linear_W_rows = 12;
const int L2_linear_W_cols = 16;
const float L2_linear_W_data[] = {
  -2.37115785e-01f, -1.52187705e-01f, -4.22128290e-01f, -5.63238502e-01f, -2.49818295e-01f, -7.22924769e-01f, -8.96624446e-01f, -4.86360371e-01f, -4.52080756e-01f, 6.79878354e-01f,
  -1.18576419e+00f, -3.68862599e-01f, 1.71248615e-02f, 5.42685747e-01f, -9.27253485e-01f, -6.93075180e-01f, -3.50494653e-01f, -7.19071448e-01f, -9.67354834e-01f, 5.01505792e-01f,
  1.11622012e+00f, -3.26578528e-01f, 1.21381678e-01f, 8.55439365e-01f, -1.31730008e+00f, 7.91726410e-01f, -1.29907653e-01f, 7.22598955e-02f, -8.19364488e-01f, 1.38014063e-01f,
  3.26102585e-01f, -1.47098267e+00f, -8.60322475e-01f, -4.25865948e-02f, 5.62659562e-01f, -2.13620886e-01f, 2.42973432e-01f, 7.70753264e-01f, -9.38971758e-01f, -7.30770826e-01f,
  -6.09474719e-01f, -5.02392292e-01f, 3.32804829e-01f, -3.54035884e-01f, -8.15551996e-01f, -1.03887260e+00f, 1.25147223e+00f, -1.29030418e+00f, -5.69948196e-01f, 3.44380587e-01f,
  -2.37626374e-01f, -3.85136425e-01f, -2.08741650e-01f, 1.19465128e-01f, -8.36132467e-01f, 1.67083010e-01f, 6.25758469e-01f, 2.96035230e-01f, -1.54214954e+00f, -2.04552919e-01f,
  -1.51540965e-01f, -1.76984131e+00f, 3.29001665e-01f, 4.38847631e-01f, 5.44627249e-01f, 6.47953272e-01f, 6.96812570e-01f, 4.25769761e-03f, -1.23990154e+00f, -6.95324123e-01f,
  1.32795835e+00f, 1.68248475e+00f, 1.88705608e-01f, -9.36291590e-02f, -8.85096312e-01f, 2.43727565e-01f, 6.88763082e-01f, -3.14013422e-01f, -5.33839881e-01f, 6.11124150e-02f,
  2.23927900e-01f, 1.83935791e-01f, 5.88092301e-03f, -2.42750660e-01f, -6.91349804e-01f, 8.09997857e-01f, 6.93178177e-01f, 8.49438488e-01f, -4.89921570e-02f, -6.84716273e-03f,
  -2.17610925e-01f, -8.54580164e-01f, -1.34375834e+00f, 3.17862719e-01f, -2.46069282e-01f, 4.58310455e-01f, 9.35340464e-01f, 9.24461722e-01f, 2.23004334e-02f, 4.38600570e-01f,
  -1.94351897e-01f, -5.63597560e-01f, 6.27628863e-01f, -2.24592268e-01f, -1.04718196e+00f, -1.63052797e+00f, 3.58089685e-01f, -4.75256622e-01f, -4.07246590e-01f, 7.48005271e-01f,
  2.07085818e-01f, -1.45542324e+00f, 4.46701437e-01f, 2.53535390e-01f, -6.35521472e-01f, 3.17796797e-01f, 8.16194117e-01f, -7.78104007e-01f, -7.51705766e-01f, -7.50358999e-01f,
  9.43016469e-01f, -3.81833851e-01f, -5.65527856e-01f, 1.37148392e+00f, 1.17060073e-01f, -1.00466287e+00f, -9.61568207e-02f, -5.52360058e-01f, -4.92840230e-01f, -5.02589941e-01f,
  -1.97491258e-01f, -3.43207836e-01f, 6.05532467e-01f, -5.82151771e-01f, 5.91746330e-01f, -5.93796730e-01f, -4.08748776e-01f, -1.39098719e-01f, 9.37408149e-01f, 1.88916132e-01f,
  -7.26770818e-01f, -9.96616960e-01f, -1.32348049e+00f, -5.27725220e-01f, -4.79752958e-01f, 3.15560736e-02f, 6.91941559e-01f, 3.32414687e-01f, 1.20519519e+00f, 1.11265469e+00f,
  -1.42498970e-01f, -1.19074011e+00f, -3.92500870e-02f, -9.82917964e-01f, -3.41883272e-01f, -7.51974463e-01f, 1.10331750e+00f, -9.63534638e-02f, -8.23409796e-01f, -1.29368460e+00f,
  6.55626953e-01f, -9.65040624e-01f, 2.89860249e-01f, 5.65928698e-01f, -5.70027292e-01f, -1.27752990e-01f, -4.61130649e-01f, 6.82570398e-01f, -4.96118069e-01f, -8.09440911e-01f,
  -1.15732387e-01f, -5.37190020e-01f, -1.03903496e+00f, -1.22973096e+00f, 9.46333230e-01f, 6.97400093e-01f, -3.41564640e-02f, -3.52568738e-02f, -4.91125554e-01f, -5.38720489e-02f,
  -5.39436281e-01f, 2.46283874e-01f, -5.63916788e-02f, -6.14210129e-01f, -1.20538819e+00f, -7.19774008e-01f, 1.92539036e-01f, -4.42102514e-02f, 8.30918252e-02f, -3.28134209e-01f,
  -1.18800771e+00f, 9.06670332e-01f
};

// L2_linear_B (Shape: 1 x 12)
const int L2_linear_B_rows = 1;
const int L2_linear_B_cols = 12;
const float L2_linear_B_data[] = {
  -2.89596796e-01f, 4.07517888e-02f, 1.72476873e-01f, -5.25524497e-01f, 2.45578572e-01f, -4.02738303e-01f, 3.09003890e-01f, 3.81857753e-02f, -1.71168651e-02f, 1.86474472e-01f,
  6.25214502e-02f, -4.08783078e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 4, 8
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        16, 4, 8
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_linear
    linear_forward_pgm(
        buffer1, x_out,
        L2_linear_W_data, L2_linear_B_data,
        16, 12
    );
    }
    