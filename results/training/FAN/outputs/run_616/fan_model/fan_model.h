/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 16 (x4)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 16;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    return (x > 0.0f) ? x : 0.0f;
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 3 x 120)
const int L0_fan_Wp_rows = 3;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  5.93947828e-01f, 1.19484097e-01f, -2.50763223e-02f, -4.95566316e-02f, 1.45395592e-01f, 1.27994627e-01f, -2.21992619e-02f, -4.59646098e-02f, -6.09844401e-02f, -4.83742356e-02f,
  -2.25746725e-02f, 8.22815299e-03f, -5.45645356e-02f, -3.14624561e-03f, 1.32329464e-01f, 8.51424690e-03f, 1.55651048e-01f, 2.63859004e-01f, 1.14730537e-01f, 1.85500144e-03f,
  3.93890664e-02f, 1.39620766e-01f, 2.30243132e-01f, -6.73743784e-02f, -3.31230797e-02f, -5.04657999e-02f, -8.21919739e-02f, 6.79627508e-02f, 7.80549869e-02f, -3.65695283e-02f,
  -7.10399449e-02f, 7.94233903e-02f, -8.45368579e-02f, 5.92930540e-02f, -1.29235685e-01f, -4.00863402e-03f, -3.67328674e-02f, -1.38517097e-01f, -8.17421898e-02f, 2.42943149e-02f,
  -7.67236277e-02f, 3.14958170e-02f, -1.47324428e-02f, -7.98389241e-02f, 4.27830629e-02f, -7.23774284e-02f, -3.93596999e-02f, 9.18565225e-03f, -1.26934677e-01f, -7.84840658e-02f,
  -4.27024551e-02f, -1.63358860e-02f, -6.08806722e-02f, -1.49973199e-01f, -8.61619189e-02f, 5.96556887e-02f, -1.02109544e-01f, -1.29633203e-01f, 3.64376716e-02f, -1.14397794e-01f,
  -2.34842412e-02f, 4.40519974e-02f, 2.53114719e-02f, 4.16468233e-02f, 4.15388495e-02f, -3.94657515e-02f, -1.93363726e-02f, -6.69804364e-02f, 3.75304818e-02f, 3.01740854e-03f,
  3.85697782e-02f, -1.96404736e-02f, -3.08543630e-02f, -1.12821143e-02f, -2.95131281e-02f, -7.38049746e-02f, -5.28138168e-02f, -6.34410307e-02f, -3.56478617e-04f, 7.47612044e-02f,
  8.64825174e-02f, 9.39811114e-03f, 2.88290996e-03f, -6.16671816e-02f, -1.13521283e-03f, -5.29286359e-03f, -3.29635404e-02f, -2.13987734e-02f, 4.82701696e-02f, 4.90834638e-02f,
  -1.92793295e-01f, 1.28839239e-01f, -5.37187792e-02f, 1.24312323e-02f, 4.90529276e-02f, 4.20545042e-03f, 1.67158861e-02f, 4.48033139e-02f, 3.47690098e-02f, 1.10650426e-02f,
  7.13576451e-02f, -2.19771490e-02f, 3.27986628e-02f, 5.19214664e-03f, -5.15164472e-02f, 1.67738423e-02f, -7.04649184e-03f, 1.48597984e-02f, -1.30902566e-02f, -1.75328907e-02f,
  -6.33008182e-02f, 5.94641194e-02f, -3.82467099e-02f, -1.83212776e-02f, 3.24952118e-02f, 1.21274717e-01f, -1.37166172e-01f, -1.17055103e-01f, 1.10460602e-01f, -1.00219913e-01f,
  -1.37906075e-01f, 5.07766962e-01f, -8.98308158e-02f, -2.78254542e-02f, -8.89005214e-02f, -7.16976747e-02f, 2.73982882e-01f, 2.42544115e-01f, -1.57323793e-01f, 2.23873526e-01f,
  1.65498421e-01f, -2.04244211e-01f, 7.17870146e-02f, -6.92189857e-02f, 1.21520355e-01f, 9.72846672e-02f, -5.90768158e-02f, -2.62366354e-01f, -3.74064654e-01f, -2.03857660e-01f,
  -1.04320534e-01f, -1.07876519e-02f, -5.46306707e-02f, -1.12254761e-01f, -1.46232557e-03f, -2.18826875e-01f, 1.63582608e-01f, 1.03847466e-01f, -6.58574700e-02f, -3.73276323e-01f,
  -1.39583409e-01f, 3.24863553e-01f, -2.64790714e-01f, -9.25753191e-02f, -8.77540465e-03f, -7.50298202e-02f, -7.93436021e-02f, -4.85334024e-02f, -2.93448707e-03f, -4.12524752e-02f,
  -3.00468542e-02f, -2.33435016e-02f, -6.53224438e-02f, -2.69541759e-02f, 3.55955772e-02f, 4.59631346e-02f, 2.96444935e-03f, 1.40064374e-01f, 3.98487933e-02f, 5.16210087e-02f,
  -1.09740220e-01f, -1.13633998e-01f, 1.16712384e-01f, 1.39316276e-01f, 8.18537362e-03f, -1.79806188e-01f, 1.37422502e-01f, 1.42361550e-03f, 5.11551052e-02f, 8.30668658e-02f,
  -7.91345835e-02f, 7.22764712e-03f, 2.66652890e-02f, 1.03167985e-02f, 8.63900036e-03f, 2.73207435e-03f, -4.80625406e-02f, 1.39236366e-02f, -4.64346521e-02f, -5.36375456e-02f,
  1.68669410e-02f, 1.15774544e-02f, -2.49702614e-02f, 5.13200127e-02f, -4.38798070e-02f, 9.89304557e-02f, -8.79496038e-02f, 2.59275753e-02f, 4.03276049e-02f, 3.32782045e-02f,
  1.01607721e-02f, -1.74749158e-02f, 8.18494782e-02f, 6.65748045e-02f, -2.91645024e-02f, 2.00136565e-02f, -6.64213449e-02f, -1.40688429e-02f, 6.02904297e-02f, 4.19878289e-02f,
  1.43691795e-02f, 7.94210657e-02f, -8.42020586e-02f, 2.73933616e-02f, 1.76964570e-02f, 1.29665554e-01f, -2.07952457e-03f, -2.20961086e-02f, -1.86562054e-02f, 4.62698229e-02f,
  -4.38659266e-02f, -1.66973863e-02f, 5.34120761e-02f, -6.87185302e-02f, -1.46490872e-01f, -1.23193458e-01f, 3.69161665e-02f, -1.16610229e-01f, -2.48975307e-02f, 4.16513868e-02f,
  2.70027239e-02f, -8.44762623e-02f, -1.11389980e-01f, -6.96915984e-02f, -3.78382718e-03f, -2.29437217e-01f, 5.77047542e-02f, -7.95223936e-02f, -7.93843195e-02f, 1.34094045e-01f,
  4.55379486e-01f, -2.17995048e-02f, 3.86609077e-01f, -1.15127461e-02f, 3.67481001e-02f, 5.06560504e-02f, 6.67578653e-02f, 4.90010791e-02f, 5.57605475e-02f, 9.72836390e-02f,
  -1.76447272e-01f, -3.82719278e-01f, -3.48587304e-01f, -2.30249569e-01f, -1.04968712e-01f, 7.28293657e-02f, 1.49926037e-01f, 5.78026772e-02f, -1.48397654e-01f, -1.62199289e-01f,
  -3.88859659e-01f, 2.79397937e-04f, -4.64222627e-03f, -7.30303675e-02f, 4.39420789e-02f, -2.31518418e-01f, 1.41285449e-01f, 9.95176062e-02f, -1.21199496e-01f, 2.72863477e-01f,
  -4.41740006e-02f, 2.56112903e-01f, -1.00399323e-01f, -7.56895393e-02f, 7.05952942e-02f, 1.11468025e-01f, 3.33613232e-02f, 1.27807662e-01f, -2.74088588e-02f, 8.41417238e-02f,
  7.39799663e-02f, 4.56870068e-03f, -4.72815558e-02f, -1.65617410e-02f, 1.14871189e-01f, -3.17096747e-02f, 1.38171166e-01f, 8.08202848e-02f, 8.89676064e-02f, 5.37689216e-02f,
  -2.16639221e-01f, 5.97107932e-02f, 1.51930422e-01f, -3.08197066e-02f, 7.77958613e-03f, -1.30260736e-01f, 8.56149122e-02f, 1.08970083e-01f, 1.23847261e-01f, 2.11300671e-01f,
  -4.25388813e-02f, 6.24251924e-02f, -2.18889844e-02f, -3.38753387e-02f, -8.87053981e-02f, 5.83975716e-03f, 2.82757753e-03f, -1.12181948e-02f, -4.24640551e-02f, 9.15898085e-02f,
  -6.03223257e-02f, -2.64881440e-02f, -2.86195725e-02f, 8.52626190e-02f, -1.52374312e-01f, 4.32166383e-02f, -2.44510118e-02f, 3.95497568e-02f, 8.70441273e-03f, 7.82021135e-02f,
  -2.13528201e-02f, 3.07538174e-02f, 3.05367820e-02f, -2.48865075e-02f, -1.69039872e-02f, -3.00317761e-02f, -2.76965201e-02f, -3.16746198e-02f, 2.44979840e-02f, 5.33552794e-03f,
  -1.50829703e-01f, -1.09833755e-01f, 5.19983396e-02f, 3.18877511e-02f, -1.46639310e-02f, -2.71757320e-02f, -1.32044569e-01f, -4.11592610e-02f, -2.77548302e-02f, -7.26940855e-03f,
  -5.34080155e-02f, 2.18628477e-02f, -2.18183100e-02f, 7.78652402e-03f, -2.81207785e-02f, -6.35395199e-02f, -7.59759918e-02f, -3.49938534e-02f, 7.59903528e-03f, 1.47534106e-02f,
  -3.71062122e-02f, -4.85339239e-02f, -4.74157296e-02f, -7.29167776e-04f, -4.60077710e-02f, -1.51964098e-01f, -8.39965492e-02f, -5.02493270e-02f, -1.50097996e-01f, -1.13412984e-01f
};

// L0_fan_Wp_bar (Shape: 10 x 120)
const int L0_fan_Wp_bar_rows = 10;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  5.57635128e-01f, -1.34392222e-02f, 5.22432685e-01f, 3.96831810e-01f, 1.93257600e-01f, 2.31700987e-02f, -1.15155920e-01f, -1.22435078e-01f, -2.40670200e-02f, 3.00908327e-01f,
  5.43578789e-02f, -6.53648153e-02f, -2.60512114e-01f, -2.50575960e-01f, -1.88958794e-01f, -7.73548111e-02f, -1.48750961e-01f, -7.96542764e-02f, 8.91540870e-02f, 3.90121758e-01f,
  -1.19669773e-01f, 1.60285488e-01f, 2.55686283e-01f, -3.46392952e-02f, 1.04919381e-01f, -4.73793224e-02f, 5.65431379e-02f, 1.77565098e-01f, 1.27210289e-01f, 2.12892443e-01f,
  3.47496867e-01f, 3.45023990e-01f, -1.86244354e-01f, -1.06918834e-01f, -3.57018858e-02f, -7.70901591e-02f, -3.55604477e-02f, 1.18218414e-01f, -4.41549569e-02f, 3.81622016e-02f,
  8.91207978e-02f, 1.13950275e-01f, -3.36433351e-02f, 4.40108962e-02f, 1.27968907e-01f, 1.38868824e-01f, -3.90948430e-02f, 3.35734300e-02f, 6.42388240e-02f, 8.30807388e-02f,
  -4.75202054e-02f, 2.40846530e-01f, 2.04314619e-01f, -1.71973139e-01f, -1.11451440e-01f, -7.42671415e-02f, -1.82997633e-03f, 1.48914754e-02f, 5.50717190e-02f, 1.38867557e-01f,
  2.83974521e-02f, -3.95941585e-02f, 4.82276641e-02f, 6.52143136e-02f, 1.98581945e-02f, -1.04935139e-01f, -3.55425403e-02f, 9.63454992e-02f, -8.71003717e-02f, -8.85339156e-02f,
  -5.62083349e-02f, 1.23456836e-01f, -8.42590928e-02f, -7.42695406e-02f, -7.55607188e-02f, 5.19858375e-02f, 6.76203147e-02f, 7.01554725e-03f, 8.99900272e-02f, -3.88709866e-02f,
  9.15622488e-02f, -2.88485866e-02f, 1.11568071e-01f, -6.05097190e-02f, 2.03761589e-02f, -7.98673034e-02f, 1.72568396e-01f, 4.72802334e-02f, 2.20380370e-02f, 6.33834749e-02f,
  -3.07283074e-01f, -1.32723689e-01f, 2.02299329e-03f, -2.81517711e-02f, 2.20252573e-01f, 1.00693978e-01f, 1.35260269e-01f, 1.08758464e-01f, 7.80764595e-02f, 4.81913052e-02f,
  8.18566754e-02f, 6.41618446e-02f, -1.04030244e-01f, -3.49242724e-02f, 5.20510003e-02f, 6.22772351e-02f, 7.25984052e-02f, -2.85913446e-03f, 1.31793812e-01f, 4.62291203e-02f,
  -3.97173651e-02f, 1.40325069e-01f, 3.86808142e-02f, -1.78417698e-01f, -3.26645821e-02f, -8.70720949e-03f, -7.63735473e-02f, 2.60823146e-02f, -2.47936370e-03f, -9.79291052e-02f,
  -6.93832695e-01f, 3.37114066e-01f, -1.64515346e-01f, -1.24246567e-01f, 2.99617708e-01f, 3.49208534e-01f, 6.14055395e-01f, 2.19294667e-01f, -3.35653052e-02f, 4.62448457e-04f,
  5.78753501e-02f, -1.17894888e-01f, -1.14487559e-01f, 8.78029317e-02f, 2.43067876e-01f, 2.46984854e-01f, 2.86852658e-01f, -1.13789991e-01f, -3.18282813e-01f, -1.41132817e-01f,
  2.30170533e-01f, -1.13650948e-01f, -4.89602774e-01f, -1.70810103e-01f, -9.34776887e-02f, -9.30995122e-02f, -8.74965712e-02f, -3.52679603e-02f, 2.44299490e-02f, -5.67103177e-03f,
  -3.29958797e-01f, -6.67361841e-02f, 2.24976912e-02f, -1.23317629e-01f, 1.31672283e-03f, -3.26786414e-02f, 4.47423905e-02f, -1.72492564e-01f, -5.52787520e-02f, -1.93969216e-02f,
  -1.93907395e-02f, 3.48984823e-02f, 2.28582472e-02f, 1.00531973e-01f, -1.01641223e-01f, -2.61557605e-02f, 1.05026327e-01f, -1.06899969e-01f, -3.15865278e-02f, -1.50720449e-03f,
  3.06294441e-01f, 6.85373787e-03f, -2.29198769e-01f, 1.21252544e-01f, 1.42102435e-01f, -2.78915286e-01f, -2.13370267e-02f, -1.91105425e-01f, -1.35778740e-01f, -2.23935157e-01f,
  -7.12102726e-02f, 7.65600428e-02f, 3.31483595e-02f, 1.21070869e-01f, 4.71297838e-02f, 3.45115140e-02f, 6.48330152e-02f, -4.88301367e-02f, 3.22865397e-02f, -2.63441745e-02f,
  1.35952905e-02f, -1.69176143e-02f, -6.95795044e-02f, -3.62080634e-02f, 2.14972608e-02f, -5.60309254e-02f, 9.93686169e-02f, -5.97075820e-02f, -8.99436593e-04f, -5.04628848e-03f,
  -4.66330759e-02f, 6.28946647e-02f, -5.38649857e-02f, 1.34154744e-02f, 4.69896831e-02f, 1.61965311e-01f, -9.63148326e-02f, -1.75237685e-01f, -1.37242019e-01f, 8.48447382e-02f,
  -1.26899332e-01f, 8.50878507e-02f, -1.83884263e-01f, 5.81756094e-03f, -9.90358554e-03f, -1.21775597e-01f, 4.68852408e-02f, -1.74947336e-01f, 7.10498616e-02f, -1.00968257e-02f,
  -3.84275839e-02f, -8.63522291e-02f, 6.34668618e-02f, 7.77514279e-02f, -1.51000202e-01f, -1.54303452e-02f, 1.27599001e-01f, -8.33327174e-02f, 1.30117191e-02f, -6.74671158e-02f,
  1.42952353e-01f, -8.66537243e-02f, -3.25108021e-01f, -4.16719504e-02f, -1.46352470e-01f, -1.20485425e-01f, -1.87022045e-01f, -2.30951130e-01f, -2.54354812e-02f, -1.80176958e-01f,
  8.40638816e-01f, -1.97025687e-01f, -5.64157426e-01f, 5.12062192e-01f, -3.02730184e-02f, -3.26551031e-03f, -3.16921085e-01f, 2.94376328e-03f, 3.75578910e-01f, -1.82496861e-01f,
  4.40587960e-02f, 3.19631100e-01f, 1.04866453e-01f, -1.21413916e-01f, -2.87470669e-01f, -3.94965112e-01f, -2.51877576e-01f, -3.45646352e-01f, -9.56846699e-02f, 1.86413288e-01f,
  1.65864334e-01f, 2.27481984e-02f, 6.30378425e-02f, -7.40579590e-02f, 6.84157526e-03f, 9.56111252e-02f, -8.29705074e-02f, -1.82055503e-01f, -2.82156736e-01f, -3.41750503e-01f,
  -2.39998788e-01f, -1.12509005e-01f, 8.07126090e-02f, -2.17472874e-02f, -5.06687053e-02f, 1.05068102e-01f, 2.59618219e-02f, -8.48600864e-02f, 1.83928773e-01f, -2.93324664e-02f,
  3.36384214e-02f, 9.15691536e-03f, -9.22538224e-04f, -4.35291752e-02f, -2.50578560e-02f, 1.20986970e-02f, 2.30564903e-02f, -1.99516322e-02f, -5.90656288e-02f, -6.06454094e-04f,
  9.02683958e-02f, -1.38016880e-01f, -7.28694648e-02f, -3.74674834e-02f, -6.26025274e-02f, -9.47228223e-02f, -1.78662196e-01f, -1.32512942e-01f, -2.40417719e-01f, -1.99745327e-01f,
  -1.50877848e-01f, 1.02781251e-01f, -1.13374386e-02f, 9.22886934e-03f, 7.89416134e-02f, 4.38420735e-02f, -7.89002404e-02f, -4.76603694e-02f, 1.12079792e-01f, -5.97099289e-02f,
  -5.49038639e-03f, -9.60804075e-02f, -2.36968026e-02f, -6.29608557e-02f, -2.81360578e-02f, 1.97054949e-02f, -7.71328434e-02f, 2.56725755e-02f, 1.08457565e-01f, 9.15853679e-02f,
  -6.48255600e-03f, -1.65643450e-02f, 1.30359158e-01f, 6.34114817e-03f, -8.81392416e-03f, -1.75759438e-02f, -3.57553437e-02f, -5.07105105e-02f, 1.14380077e-01f, 9.20857340e-02f,
  1.32133633e-01f, -4.56044041e-02f, 4.12941016e-02f, -1.19353093e-01f, 4.82241884e-02f, 1.29715726e-01f, 4.63474654e-02f, 3.17729339e-02f, 5.80456443e-02f, 2.01709956e-01f,
  2.02509370e-02f, 1.96892489e-02f, 3.23803276e-02f, -1.92703661e-02f, -1.25232026e-01f, 1.38458163e-02f, 1.79079071e-01f, -3.19810049e-03f, 6.23057075e-02f, 2.04884186e-01f,
  3.56226042e-02f, -2.08722651e-02f, 1.10143684e-01f, -2.37471797e-02f, 6.55791089e-02f, 5.65297529e-02f, -1.41265750e-01f, 1.27128465e-02f, -3.01042143e-02f, 1.30230546e-04f,
  8.48465204e-01f, -3.47298265e-01f, 3.48337263e-01f, 2.30400618e-02f, -4.07566041e-01f, -5.92029274e-01f, -6.80142581e-01f, -2.79324114e-01f, 9.79101583e-02f, -1.28690004e-01f,
  -1.29337817e-01f, 3.27841371e-01f, 3.92420799e-01f, 2.53510594e-01f, 2.39729986e-01f, -2.69722998e-01f, 1.63147584e-01f, 7.27250814e-01f, 3.79150867e-01f, -1.80104181e-01f,
  -8.69429931e-02f, 6.98183551e-02f, 4.54688966e-01f, 2.28938237e-01f, 1.07945465e-01f, 1.46422982e-01f, -4.64644283e-02f, -1.11212589e-01f, -6.99750409e-02f, 4.44030643e-01f,
  -2.14749649e-01f, 6.44624829e-02f, 1.23678952e-01f, 1.01411477e-01f, -1.12782104e-03f, 9.76049304e-02f, -1.71928585e-01f, 9.08939168e-03f, -7.54682301e-03f, -5.64869158e-02f,
  -1.41437784e-01f, -3.73265073e-02f, -6.15306990e-03f, -1.16731755e-01f, -9.47273970e-02f, -5.63263521e-02f, 8.97473916e-02f, 1.74754024e-01f, 1.09950900e-01f, -4.20031361e-02f,
  -2.07666643e-02f, -1.42504632e-01f, -4.86551523e-02f, -1.73665032e-01f, 2.96514854e-02f, 2.39133880e-01f, -1.07962616e-01f, 7.24215731e-02f, 1.25047356e-01f, 2.41692573e-01f,
  -5.20559698e-02f, 1.57206580e-02f, 2.10909676e-02f, -2.48811170e-02f, 7.64839798e-02f, -3.70814689e-02f, -1.70248076e-02f, -6.26626164e-02f, 4.61543165e-02f, 1.39047951e-02f,
  3.71878548e-03f, -6.26364956e-04f, 5.73045611e-02f, -9.97824073e-02f, 8.91024545e-02f, -6.26125485e-02f, -1.43375043e-02f, -1.42929748e-01f, -9.09054652e-02f, -1.10570872e-02f,
  1.01875931e-01f, 6.95944503e-02f, 1.24417819e-01f, 7.01845363e-02f, 2.87678428e-02f, -2.49200361e-03f, 3.22667100e-02f, -7.11883679e-02f, -5.16806059e-02f, -4.77581732e-02f,
  -3.94692957e-01f, 2.47063994e-01f, 1.81958064e-01f, 1.86907262e-01f, 7.86108673e-02f, 9.96530503e-02f, 1.15961492e-01f, 3.09624616e-02f, -1.17560521e-01f, -7.59925134e-03f,
  -9.71291661e-02f, 2.02379860e-02f, -1.55693129e-01f, 9.36815217e-02f, -3.64651307e-02f, -8.04176852e-02f, -1.08037656e-02f, 5.58607616e-02f, -9.11579803e-02f, -3.06116827e-02f,
  -3.51051101e-03f, -1.43444419e-01f, -3.27956498e-01f, -1.55979231e-01f, -8.07118043e-02f, 5.96862212e-02f, -6.45566434e-02f, -3.55756581e-02f, -1.47778511e-01f, -1.52873367e-01f,
  2.43699998e-01f, -2.30300874e-02f, 1.51348472e-01f, 3.03222269e-01f, 9.49863940e-02f, -1.49982050e-01f, -4.65567470e-01f, -3.62110585e-01f, 7.17765391e-02f, -3.88468318e-02f,
  3.53042603e-01f, 9.73079577e-02f, 2.19011441e-01f, 9.12354887e-03f, -3.57836157e-01f, -8.99037048e-02f, -1.40773326e-01f, -4.52283859e-01f, -6.70948207e-01f, -3.01749110e-01f,
  -1.03459947e-01f, -2.87981868e-01f, -3.63124639e-01f, -8.44741613e-02f, 2.80555308e-01f, -3.10758594e-02f, 3.21480691e-01f, 2.81037837e-01f, 1.80517361e-01f, 2.29214177e-01f,
  2.28555098e-01f, 1.18853115e-01f, -8.01205188e-02f, 1.29055575e-01f, 9.98057500e-02f, 7.29496358e-03f, -1.02181666e-01f, -1.16500638e-01f, -3.25034186e-02f, 9.53721777e-02f,
  2.93548316e-01f, 4.31192964e-02f, 7.43281841e-02f, 3.32097374e-02f, -1.83504090e-01f, -1.71883807e-01f, -1.38032183e-01f, -3.23962539e-01f, -2.47414157e-01f, -2.50453129e-02f,
  2.23270848e-01f, 2.34602779e-01f, -4.80235703e-02f, -3.29172309e-03f, -9.53633040e-02f, -8.12585503e-02f, 2.23211888e-02f, 8.55432227e-02f, 1.27021074e-02f, -7.65876547e-02f,
  -8.87364894e-02f, 8.30885768e-02f, 9.57073197e-02f, 5.82265891e-02f, -1.70931548e-01f, 1.87847108e-01f, 5.14498428e-02f, -4.88488264e-02f, -1.92234255e-02f, 6.29900768e-02f,
  -7.32020363e-02f, -4.51718159e-02f, -1.20727159e-01f, -8.65550637e-02f, 8.82397890e-02f, 5.34777306e-02f, 6.21699393e-02f, -1.39475212e-01f, -5.69322109e-02f, -8.64195749e-02f,
  -1.46651387e-01f, 5.80659620e-02f, 1.04096249e-01f, -1.05555914e-01f, 7.65352398e-02f, 3.77172679e-02f, -5.05326688e-02f, -8.03306699e-02f, -8.62387642e-02f, 1.87580854e-01f,
  -1.39368117e-01f, -2.29264982e-02f, -1.49668958e-02f, -5.50347008e-02f, 3.93160107e-03f, 3.81684154e-02f, 2.03463048e-01f, -5.53320795e-02f, 1.04485154e-01f, -1.38506815e-01f,
  -2.03659981e-01f, -1.19111054e-01f, 2.25389645e-01f, -2.09286604e-02f, -2.99286991e-01f, 2.34473869e-03f, -4.13686521e-02f, 5.02122752e-03f, -6.71998635e-02f, -3.09078284e-02f,
  2.05052681e-02f, -3.87477845e-01f, -2.66541123e-01f, -9.83593762e-02f, -1.07923746e-01f, -2.45936006e-01f, -6.81254566e-02f, -8.08153376e-02f, -3.17838013e-01f, -5.48934042e-01f,
  5.60818970e-01f, 3.08301330e-01f, -8.42523456e-01f, 2.92518556e-01f, -3.42233449e-01f, -4.14899200e-01f, -2.51709044e-01f, 1.43561810e-01f, 2.64609158e-01f, -1.12424150e-01f,
  -7.16438442e-02f, -1.85852628e-02f, -8.13341513e-02f, -1.17027551e-01f, -6.88804686e-02f, -3.10474336e-01f, -3.68161917e-01f, -3.92915756e-01f, -3.20487082e-01f, 3.40157077e-02f,
  1.47065818e-01f, 4.79382649e-03f, 4.97927219e-02f, -2.50161923e-02f, 1.20953090e-01f, 1.62662476e-01f, -6.53059557e-02f, 5.64123057e-02f, -9.86575186e-02f, 2.14747433e-02f,
  -5.87811410e-01f, 3.10932342e-02f, -2.52045020e-02f, 1.39693975e-01f, 7.02764690e-02f, -1.32467166e-01f, -4.40463386e-02f, 2.60922778e-02f, 2.30587497e-02f, -7.89752826e-02f,
  -1.23174135e-02f, 1.01340316e-01f, -1.52177572e-01f, 4.88314666e-02f, 3.25876940e-03f, -1.01095267e-01f, 7.48423976e-04f, -1.59450412e-01f, -8.75402987e-02f, -7.65611380e-02f,
  7.51682976e-03f, -2.30620831e-01f, -2.73430586e-01f, -2.77839997e-03f, -1.77266136e-01f, -2.03064397e-01f, 1.41439596e-02f, 5.89802191e-02f, -1.40888259e-01f, 3.62491846e-01f,
  1.08620889e-01f, -9.97780561e-02f, -5.71602443e-03f, -1.50611410e-02f, 1.05067670e-01f, 3.88881303e-02f, -1.29334759e-02f, 1.43580705e-01f, 1.17484452e-02f, 8.08002613e-03f,
  2.77946820e-03f, 7.84410164e-02f, 3.55324592e-03f, 2.67734509e-02f, -1.17141120e-01f, -7.21551403e-02f, 1.12412646e-01f, -4.64283936e-02f, -8.49458948e-02f, 5.31331785e-02f,
  2.79762018e-02f, 4.45327461e-02f, -3.60467024e-02f, 4.43765819e-02f, -1.05679423e-01f, -1.11134239e-01f, 1.36481881e-01f, 4.36328463e-02f, -2.48484481e-02f, -4.77216393e-02f,
  1.62956327e-01f, 6.66704774e-03f, -1.62163377e-02f, 1.15932241e-01f, -2.51882542e-02f, -5.12789004e-02f, -9.25111622e-02f, 1.21914716e-02f, -1.75665319e-02f, -1.12904124e-01f,
  -1.23878814e-01f, -4.90885042e-02f, -5.74035235e-02f, 8.10824111e-02f, 5.34029342e-02f, -5.38118742e-02f, 4.77007553e-02f, 5.54168224e-02f, 7.94175565e-02f, -8.16010982e-02f,
  6.13099709e-02f, 1.39987260e-01f, 8.47998634e-02f, 7.37648830e-02f, 9.46702063e-02f, 9.88223031e-03f, -1.34647995e-01f, 1.03857279e-01f, -9.86962244e-02f, 3.80114853e-01f,
  -3.79898362e-02f, 1.07700422e-01f, -4.16524820e-02f, -8.92215744e-02f, -3.72427702e-02f, 3.04530591e-01f, 3.24716210e-01f, 3.32893759e-01f, 6.96245357e-02f, 3.60514484e-02f,
  4.26122010e-01f, 2.16751285e-02f, -1.99309379e-01f, -9.30315331e-02f, 4.56510074e-02f, 5.41615710e-02f, -4.02621925e-01f, -2.73568004e-01f, 2.22490117e-01f, 4.45441544e-01f,
  -5.68118319e-02f, -2.73593187e-01f, -1.09968573e-01f, 2.14588214e-02f, -1.35894403e-01f, -4.21810895e-01f, -3.65139753e-01f, -1.17985882e-01f, -6.46548271e-02f, -9.91225839e-01f,
  1.15562849e-01f, 3.76640916e-01f, 2.86089815e-02f, -1.86570957e-01f, -1.55688018e-01f, 1.13545127e-01f, 1.20620660e-01f, -1.14685751e-01f, 6.53175488e-02f, -7.87269771e-02f,
  -1.84151642e-02f, 1.67073563e-01f, -6.11884613e-03f, 3.10312919e-02f, 2.37773061e-01f, 2.46857956e-01f, 1.49374204e-02f, 9.79191735e-02f, 8.58102962e-02f, 1.85234919e-01f,
  -1.84782043e-01f, -2.57586148e-02f, 3.94760557e-02f, 1.15054980e-01f, 3.16070735e-01f, -7.23039284e-02f, 2.22093791e-01f, 1.00031070e-01f, 1.36175994e-02f, -5.40932894e-01f,
  3.32535580e-02f, 7.00088916e-03f, 2.13005990e-02f, 1.20575584e-01f, 2.15165671e-02f, -7.13886023e-02f, 1.93295553e-02f, 9.02188718e-02f, 5.78531288e-02f, -1.38036221e-01f,
  -4.49678563e-02f, 8.39762837e-02f, 1.05025053e-01f, -4.34115380e-02f, -2.11445391e-02f, 1.75572149e-02f, -2.63297111e-02f, -7.01854527e-02f, -6.88566873e-03f, -1.81078464e-02f,
  2.23537609e-02f, -4.67169620e-02f, 1.21371038e-02f, 9.82774347e-02f, -2.22655796e-02f, -5.90586588e-02f, -7.80008212e-02f, 1.36362612e-01f, -4.84832302e-02f, 9.20490474e-02f,
  -1.11876115e-01f, 1.62453637e-01f, -1.38201779e-02f, -1.68437362e-02f, 3.78217958e-02f, -1.68307066e-01f, -1.23717591e-01f, -2.66049467e-02f, -3.25043723e-02f, 3.60003822e-02f,
  -7.32203871e-02f, 9.51522067e-02f, -1.40320780e-02f, -1.11367349e-02f, 1.97621018e-01f, 6.55299276e-02f, -1.52535275e-01f, -2.08436653e-01f, 5.77147678e-02f, -1.22568728e-02f,
  -2.08891034e-01f, -2.15219334e-01f, -2.37240314e-01f, -1.81671441e-01f, -1.59556761e-01f, -1.80082619e-01f, -1.79841205e-01f, -1.38811767e-01f, -5.53451069e-02f, -5.75879753e-01f,
  6.60849988e-01f, -9.71347511e-01f, 1.70792118e-01f, -8.33959877e-02f, -3.69700864e-02f, 2.67061770e-01f, -3.17225903e-01f, -1.02744393e-01f, 2.00376362e-01f, -2.91388363e-01f,
  -4.55299079e-01f, 7.17646033e-02f, 5.93713373e-02f, 6.59923181e-02f, 1.13240033e-01f, -3.07731241e-01f, -8.05959702e-02f, 6.07632101e-01f, 8.61504376e-01f, 4.07656617e-02f,
  -2.37510636e-01f, -2.67247949e-02f, 1.98102325e-01f, 1.17813960e-01f, -3.90617996e-01f, 4.33395319e-02f, -3.69117409e-01f, -2.27175936e-01f, -4.66317713e-01f, -4.35254633e-01f,
  -1.21697456e-01f, -8.92584175e-02f, 9.02543217e-03f, 1.06025096e-02f, -1.69572949e-01f, -1.45810068e-01f, -9.59940404e-02f, -6.27539605e-02f, -2.66151540e-02f, 2.66140159e-02f,
  -1.38376221e-01f, -6.94819912e-02f, 7.13358149e-02f, 9.54179689e-02f, 8.04830417e-02f, 3.61594446e-02f, 9.13647376e-03f, -2.12646127e-02f, -4.56035472e-02f, -1.47974417e-01f,
  -2.80025184e-01f, -4.22762223e-02f, 1.28873616e-01f, -1.99105024e-01f, -1.51558518e-01f, 5.42674661e-02f, -1.88598081e-01f, -8.99295360e-02f, -1.32766254e-02f, -1.48102134e-01f,
  -2.33417358e-02f, 7.64126182e-02f, 1.87233016e-02f, 1.08931484e-02f, 5.81111722e-02f, -2.65862867e-02f, 1.24323294e-01f, -5.31009808e-02f, -2.33851578e-02f, -8.36840570e-02f,
  -3.91766429e-04f, -1.40969427e-02f, -8.56904611e-02f, -1.41557217e-01f, -1.21977635e-01f, -6.35811165e-02f, -4.47269119e-02f, -4.74321172e-02f, -1.01964429e-01f, 8.93731695e-03f,
  1.54288029e-02f, 6.68889284e-02f, 5.94198219e-02f, -6.21500202e-02f, -1.82123452e-01f, -1.53318075e-02f, 2.22844537e-02f, -4.23438400e-02f, 7.90022239e-02f, 7.02616349e-02f,
  -1.01818278e-01f, 2.26044580e-01f, -1.31089883e-02f, -6.14947006e-02f, 4.99187298e-02f, -3.12980115e-02f, -1.34769768e-01f, 3.08477487e-02f, -1.34497061e-02f, 2.71007791e-02f,
  -5.37023135e-02f, 1.13785855e-01f, -9.55068786e-03f, -2.43055522e-02f, 1.19394496e-01f, -3.35777327e-02f, -1.18263490e-01f, 5.29406704e-02f, -2.40556989e-02f, -1.25012040e-01f,
  -5.05037531e-02f, 1.68012738e-01f, 2.35970989e-01f, 2.15054840e-01f, 1.54797146e-02f, 3.13306868e-01f, 2.68862322e-02f, -8.61904304e-03f, 2.70347834e-01f, -1.58692207e-02f,
  5.56420326e-01f, -6.91545308e-01f, -1.34968609e-01f, 5.61926425e-01f, 1.46013245e-01f, 2.49237075e-01f, -2.35642850e-01f, 1.69462249e-01f, 3.39729667e-01f, 8.10924023e-02f,
  1.27619967e-01f, 3.62080544e-01f, 1.32172465e-01f, 8.01135674e-02f, 1.16742916e-01f, 6.37952313e-02f, 3.56277488e-02f, 4.93519977e-02f, 3.69461775e-01f, 3.26586694e-01f,
  2.31171213e-02f, -8.31862688e-02f, 5.50902896e-02f, -1.72522180e-02f, -1.33014336e-01f, 2.35003039e-01f, -3.37997898e-02f, -2.63355702e-01f, -2.40455508e-01f, -4.33823645e-01f,
  -1.51378825e-01f, -1.56535462e-01f, 3.80873948e-01f, 1.13324597e-01f, -1.74173415e-01f, -1.75524913e-02f, 6.02629036e-02f, -2.74854172e-02f, 1.06705673e-01f, -4.21731686e-03f,
  -6.27198443e-02f, -7.70722926e-02f, -8.03560540e-02f, -1.84701353e-01f, -4.87052388e-02f, -4.23815474e-02f, -1.97920352e-01f, -4.65405844e-02f, 2.99498588e-02f, -6.78773522e-02f,
  -1.04544535e-01f, 9.77112055e-02f, 7.76894987e-02f, 2.16374204e-01f, 1.15349002e-01f, 1.62639648e-01f, -7.86920264e-02f, -7.63877630e-02f, 1.82130575e-01f, -5.51916398e-02f,
  2.21258953e-01f, 7.84939528e-02f, -9.43649374e-03f, 5.66088259e-02f, -1.18409684e-02f, -6.84045404e-02f, -2.99834204e-03f, -3.34590599e-02f, 5.97880855e-02f, -6.49508163e-02f,
  -5.02516106e-02f, 9.63498130e-02f, 4.17318828e-02f, 2.46202886e-01f, 1.11993112e-01f, -7.65433237e-02f, -8.51332769e-02f, -8.68451372e-02f, 1.15899341e-02f, -7.04702213e-02f,
  5.59692085e-02f, -4.53786552e-02f, -5.42921461e-02f, -3.23673993e-01f, -1.89262629e-01f, 1.14541650e-02f, 1.97816774e-01f, -1.38519974e-02f, 6.62996694e-02f, 9.06516239e-03f,
  8.43063593e-02f, 3.81051809e-01f, 3.06038111e-02f, -6.00506589e-02f, -9.36672240e-02f, -2.11934179e-01f, -2.78805122e-02f, -6.45772740e-02f, -8.93383697e-02f, 8.01504925e-02f,
  3.68271135e-02f, 4.88383994e-02f, -2.27478445e-01f, -4.50739674e-02f, 2.42036223e-01f, 1.17571697e-01f, -2.09549725e-01f, -1.62654743e-02f, 2.91401893e-02f, -8.84897262e-02f,
  -1.01786286e-01f, 1.73500106e-01f, 4.07988369e-01f, 1.96112081e-01f, 1.17462792e-01f, 4.24666703e-01f, 8.12466368e-02f, 4.08831798e-02f, 1.01542674e-01f, 1.34528771e-01f,
  -7.45207965e-01f, -4.64615822e-01f, -2.13280573e-01f, -5.58540165e-01f, -1.70263261e-01f, -3.85330543e-02f, -3.76414984e-01f, 3.07357218e-02f, -6.55778348e-02f, -3.51801634e-01f,
  -8.26147199e-02f, -1.09385140e-02f, -2.34106645e-01f, 1.81246027e-01f, 1.36034846e-01f, -3.55366647e-01f, -3.36606771e-01f, 3.37035432e-02f, 2.41027847e-01f, 1.74910054e-01f,
  -1.33386850e-02f, -3.40714365e-01f, 1.44740399e-02f, 1.58592582e-01f, -2.59916008e-01f, -1.08518198e-01f, -2.51062751e-01f, -2.07807735e-01f, 1.78637043e-01f, -3.57545435e-01f,
  -3.95197839e-01f, -1.61015242e-01f, 1.36744291e-01f, 9.20894742e-02f, -1.99265644e-01f, 8.33924860e-02f, -1.32700056e-01f, -9.60149914e-02f, 1.32676244e-01f, -1.81864593e-02f,
  9.21967532e-03f, 1.31600246e-01f, -9.09138098e-02f, 1.51390610e-02f, -8.23181868e-02f, -1.72696225e-02f, 6.97872415e-02f, 3.54276150e-02f, -7.41555765e-02f, 7.92206228e-02f,
  7.47686028e-02f, 1.08669579e-01f, 8.75058398e-02f, 1.95313200e-01f, 1.01036131e-01f, 1.98028505e-01f, 1.28690928e-01f, 2.82978833e-01f, 3.33209783e-01f, -2.56777644e-01f,
  -3.14624212e-03f, -1.82122667e-03f, -5.83232976e-02f, -1.62970498e-02f, 2.85507049e-02f, -1.20448001e-01f, -3.69183384e-02f, -9.61296484e-02f, 7.26652285e-03f, -6.58364296e-02f,
  4.43746820e-02f, 1.09417085e-02f, 1.33512374e-02f, -9.36139822e-02f, 1.62503570e-02f, -1.98927782e-02f, -1.09687243e-02f, -4.37686481e-02f, 1.82758614e-01f, -2.72737653e-03f,
  1.27389267e-01f, 4.80562262e-02f, -8.58666599e-02f, -1.04144299e-02f, 2.17225235e-02f, -2.03306004e-02f, 9.33756456e-02f, 1.26658395e-01f, -6.01972863e-02f, 1.10708855e-01f,
  -5.07664144e-01f, 3.43116313e-01f, -3.87968808e-01f, 3.75938192e-02f, -4.71833944e-02f, 8.01685229e-02f, -9.83912498e-02f, 1.95475012e-01f, 1.83129758e-02f, -2.99188048e-02f,
  2.25255564e-01f, -4.85274531e-02f, -1.97562855e-02f, 7.85201266e-02f, -1.29458457e-01f, 7.75489509e-02f, 2.28680689e-02f, -1.09043486e-01f, 1.12045713e-01f, 1.24498531e-02f,
  3.55921760e-02f, 3.52994613e-02f, -8.95662159e-02f, -8.85532126e-02f, -1.07559763e-01f, -6.90762922e-02f, -1.49147943e-01f, 1.21336374e-02f, -6.20970018e-02f, -4.33296353e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 10)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 10;
const float L0_fan_Bp_bar_data[] = {
  2.25252956e-01f, -3.27071726e-01f, 3.76987487e-01f, 6.06847227e-01f, -1.02231823e-01f, 9.06663015e-02f, 8.66416097e-02f, 4.99257445e-01f, 1.58876404e-01f, 1.97173521e-01f
};

// L1_fan_Wp (Shape: 3 x 16)
const int L1_fan_Wp_rows = 3;
const int L1_fan_Wp_cols = 16;
const float L1_fan_Wp_data[] = {
  3.08958814e-02f, -2.22180155e-03f, -7.73085207e-02f, 2.36784250e-01f, -1.72616631e-01f, -7.63891041e-02f, 3.23311597e-01f, -5.48104584e-01f, 6.92828536e-01f, -1.56302065e-01f,
  2.80046552e-01f, 5.89982033e-01f, 2.54278451e-01f, -2.40927972e-02f, -5.16552851e-02f, -2.55832314e-01f, 4.34023261e-01f, 4.34109457e-02f, -6.55237436e-02f, 2.72648245e-01f,
  -3.89034301e-01f, 4.49618340e-01f, -2.34984644e-02f, -2.46753424e-01f, -1.43017638e-02f, 1.72199905e-01f, 7.66738057e-02f, -2.32738838e-01f, -2.45056599e-01f, 4.84017074e-01f,
  -2.28266403e-01f, -2.21665606e-01f, -7.08127841e-02f, 7.16825873e-02f, 2.31184170e-01f, -4.18527611e-02f, -2.73852170e-01f, -4.09219801e-01f, -4.24847491e-02f, -2.87901849e-01f,
  3.70672554e-01f, 9.67835635e-02f, 8.57044905e-02f, -2.11306930e-01f, 1.09559231e-01f, -7.13567138e-02f, 3.15704584e-01f, 5.10187507e-01f
};

// L1_fan_Wp_bar (Shape: 10 x 16)
const int L1_fan_Wp_bar_rows = 10;
const int L1_fan_Wp_bar_cols = 16;
const float L1_fan_Wp_bar_data[] = {
  3.75600681e-02f, 4.74173687e-02f, 2.78916270e-01f, 2.20310137e-01f, 1.84437558e-01f, -1.99917451e-01f, -9.50598810e-03f, 5.95072925e-01f, 2.31481969e-01f, 1.66313231e-01f,
  -1.17460743e-01f, 5.83883047e-01f, -3.79925370e-01f, -2.95431465e-01f, -2.06838042e-01f, -4.45320547e-01f, 2.79213011e-01f, 3.99090290e-01f, 2.86387831e-01f, 1.37403518e-01f,
  -8.47428218e-02f, -5.89426637e-01f, -6.82056367e-01f, 4.93278772e-01f, 1.32110298e-01f, 1.11863203e-02f, -5.35358250e-01f, 2.92960078e-01f, 9.66732800e-02f, 4.65567499e-01f,
  2.59492308e-01f, 2.88930535e-01f, 6.95963278e-02f, 3.31798762e-01f, 3.42497975e-02f, 5.65226562e-02f, -3.92297894e-01f, -4.73684549e-01f, -5.07700443e-01f, 5.26142836e-01f,
  -3.17590714e-01f, 7.82653987e-01f, -1.16308957e-01f, -2.23499849e-01f, -1.87522247e-02f, 1.07038796e-01f, -2.26052292e-02f, 5.73680401e-01f, -1.43610775e-01f, 3.67632322e-02f,
  -3.81402262e-02f, 5.75282276e-01f, 8.10650587e-01f, 4.56770539e-01f, 2.04118043e-01f, 1.69508114e-01f, -5.83759308e-01f, 4.71409336e-02f, -2.49805778e-01f, -4.68106195e-02f,
  6.53652608e-01f, -3.26116920e-01f, -5.07642806e-01f, -7.94791058e-02f, 6.16039410e-02f, 1.76416382e-01f, 2.85198778e-01f, 1.34348914e-01f, -9.36764851e-03f, -3.57659400e-01f,
  1.36474699e-01f, -4.46545571e-01f, 4.07700509e-01f, -2.54029989e-01f, 4.48049605e-01f, 3.46477836e-01f, -3.59445848e-02f, 1.03464894e-01f, 7.03921258e-01f, -1.26166448e-01f,
  3.53374124e-01f, 1.81918934e-01f, 1.18623987e-01f, 1.55537933e-01f, 8.54694471e-02f, -3.17157745e-01f, 6.89823702e-02f, -1.78739697e-01f, 2.14873597e-01f, 8.54050756e-01f,
  9.18574870e-01f, 5.06149590e-01f, 8.34248841e-01f, -9.75680575e-02f, -1.28459007e-01f, 8.35883141e-01f, 2.24624336e-01f, 3.54264170e-01f, 7.53523707e-02f, 2.89910018e-01f,
  -2.73089439e-01f, -3.71708423e-01f, -1.57832563e-01f, -7.15942979e-01f, 4.47394490e-01f, 6.79354906e-01f, -1.71365857e-01f, 1.60961300e-01f, -6.05522275e-01f, 8.67194295e-01f,
  2.76583782e-03f, -1.88933611e-01f, 4.71711755e-01f, 3.12421888e-01f, 2.73955554e-01f, 2.69482452e-02f, -2.91248918e-01f, -4.43548143e-01f, -1.34412751e-01f, 1.64542310e-02f,
  2.28181314e-02f, 7.89552867e-01f, -2.56166458e-01f, -2.90820096e-02f, -1.56723768e-01f, 7.82314003e-01f, 6.57923371e-02f, 1.97647586e-02f, 3.23788911e-01f, 8.46897364e-02f,
  -2.67421991e-01f, -8.95037800e-02f, 6.27000332e-02f, 5.05862311e-02f, -2.40602449e-01f, -1.66535810e-01f, 5.54312527e-01f, -3.85946631e-01f, -4.76016939e-01f, 8.12217534e-01f,
  2.17180684e-01f, 1.42993614e-01f, -1.31435230e-01f, 2.83801943e-01f, 3.62859964e-01f, -1.53881341e-01f, 3.06507081e-01f, 2.98604041e-01f, -2.97099203e-01f, 4.15405959e-01f,
  4.67416137e-01f, -3.41430604e-01f, -2.70118471e-02f, 5.51874995e-01f, 4.61650252e-01f, 1.11189254e-01f, -2.91519791e-01f, 4.28213894e-01f, 8.59908909e-02f, 9.85416472e-02f
};

// L1_fan_Bp_bar (Shape: 1 x 10)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 10;
const float L1_fan_Bp_bar_data[] = {
  -1.12966947e-01f, 5.02197444e-01f, 3.14360052e-01f, 3.92720461e-01f, 6.26364201e-02f, 3.26190859e-01f, 2.72175997e-01f, 2.69102216e-01f, 6.65125949e-03f, 6.83440045e-02f
};

// L2_fan_Wp (Shape: 3 x 16)
const int L2_fan_Wp_rows = 3;
const int L2_fan_Wp_cols = 16;
const float L2_fan_Wp_data[] = {
  -3.45524013e-01f, 2.24987373e-01f, 7.97570124e-02f, 2.86386132e-01f, -3.43814284e-01f, -3.61672938e-01f, 7.72557735e-01f, -8.41597766e-02f, 4.61005121e-02f, -1.71229377e-01f,
  -2.63264745e-01f, -4.85656187e-02f, -2.14633629e-01f, -9.67228115e-02f, 2.51793504e-01f, -2.38720462e-01f, -4.17262077e-01f, 9.81404260e-03f, 9.38109234e-02f, 1.15187496e-01f,
  -2.30621278e-01f, -2.42108986e-01f, 4.54625428e-01f, 2.51631021e-01f, -5.99003509e-02f, 4.05919664e-02f, -2.85706699e-01f, 1.12392284e-01f, -3.15193012e-02f, 9.72869620e-02f,
  1.02146953e-01f, -3.24246377e-01f, 4.11211029e-02f, -4.53236461e-01f, 3.11858326e-01f, -7.00571358e-01f, 5.33479154e-01f, 7.87910819e-03f, 3.42638642e-01f, 2.55932122e-01f,
  1.86511159e-01f, 4.12838578e-01f, -4.11359251e-01f, -1.11138560e-01f, -6.50397837e-02f, 1.30846314e-02f, -5.01917720e-01f, 9.01211128e-02f
};

// L2_fan_Wp_bar (Shape: 10 x 16)
const int L2_fan_Wp_bar_rows = 10;
const int L2_fan_Wp_bar_cols = 16;
const float L2_fan_Wp_bar_data[] = {
  -3.79679680e-01f, -5.36623457e-03f, -4.57338631e-01f, -3.46776783e-01f, -6.80568039e-01f, 6.08823240e-01f, -6.57472432e-01f, 3.26707214e-01f, 3.82518768e-01f, 1.78011790e-01f,
  1.24350317e-01f, 7.26106644e-01f, -1.93475530e-01f, -1.80593073e-01f, 5.69820642e-01f, -2.25440841e-02f, 6.92156315e-01f, 3.21513414e-01f, 1.04739152e-01f, -7.49862015e-01f,
  -6.38381660e-01f, 5.42372286e-01f, -1.22925222e-01f, 9.60156858e-01f, 7.07804978e-01f, -2.15399593e-01f, 2.38617256e-01f, -4.00492102e-01f, 1.49413690e-01f, 4.48673308e-01f,
  4.93132114e-01f, -5.58872879e-01f, 6.78664222e-02f, 4.75932449e-01f, 5.03420532e-01f, 1.01857769e+00f, 9.19187441e-02f, 7.15512931e-01f, 3.80525380e-01f, -5.18676527e-02f,
  -2.02149957e-01f, -4.66777205e-01f, 4.76071358e-01f, 1.45911962e-01f, 6.43374205e-01f, 2.46912748e-01f, -2.17508301e-01f, 5.09623587e-01f, 2.87144184e-01f, -8.40025172e-02f,
  -4.51865584e-01f, -3.39603961e-01f, -8.31836611e-02f, 3.50268990e-01f, 7.30014890e-02f, 1.07861064e-01f, 1.50098810e-02f, 2.90418088e-01f, 1.18924879e-01f, -2.78702497e-01f,
  -1.87039301e-01f, -1.64372250e-01f, 4.51979898e-02f, 2.02483758e-01f, 4.62772071e-01f, 3.26172620e-01f, -7.16931343e-01f, 4.97067571e-01f, 2.08349004e-02f, -3.73424321e-01f,
  -6.69125199e-01f, -2.03541547e-01f, 3.66785884e-01f, 1.23684812e+00f, -4.50235248e-01f, 9.22749221e-01f, 3.52391809e-01f, 2.53659695e-01f, -1.96742415e-01f, 4.90805477e-01f,
  -3.34815472e-01f, 3.42125505e-01f, -3.85547012e-01f, 1.96366802e-01f, -3.25581729e-01f, -2.43841842e-01f, -1.13646172e-01f, 1.16766274e-01f, 3.96435767e-01f, 2.78722465e-01f,
  2.14909852e-01f, 7.69126296e-01f, -1.41587272e-01f, -1.31967977e-01f, 8.11074615e-01f, -2.15646610e-01f, 1.39771491e-01f, 2.58639246e-01f, -7.65588999e-01f, 1.87492490e-01f,
  -6.24991536e-01f, -2.46722609e-01f, -4.57184553e-01f, 4.82448518e-01f, 4.58103746e-01f, -9.34868991e-01f, 1.08203508e-01f, 5.84395289e-01f, 2.88634598e-01f, 1.71584010e-01f,
  7.36852765e-01f, -4.12598193e-01f, 1.65537357e-01f, -1.08507752e-01f, -1.13134734e-01f, -2.35099912e-01f, 6.06811702e-01f, 4.55961913e-01f, 2.49340059e-03f, 9.89441693e-01f,
  7.70711660e-01f, -5.57264537e-02f, -3.11919570e-01f, 3.18665951e-01f, 8.55187595e-01f, 8.52822006e-01f, 1.15917347e-01f, 2.12145656e-01f, -4.01850313e-01f, 2.48138994e-01f,
  5.16502894e-02f, 8.02479506e-01f, -7.36213103e-02f, 2.80157298e-01f, -5.12169115e-02f, 2.97369659e-01f, -2.85339594e-01f, -9.56742704e-01f, 8.51312816e-01f, 3.82082760e-02f,
  2.79473424e-01f, 2.37314880e-01f, 5.46774209e-01f, 9.38513502e-02f, -1.81544006e-01f, 1.70362741e-01f, 1.01813090e+00f, 1.28173485e-01f, -6.83775306e-01f, 2.32986525e-01f,
  9.81129527e-01f, 2.01418683e-01f, -2.68829346e-01f, -9.90165547e-02f, 1.84955727e-02f, -6.13088831e-02f, 1.91407233e-01f, -6.49764836e-02f, 2.51004517e-01f, -4.15982366e-01f
};

// L2_fan_Bp_bar (Shape: 1 x 10)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 10;
const float L2_fan_Bp_bar_data[] = {
  2.80756559e-02f, 4.09190685e-01f, -1.02070486e-03f, 4.76257540e-02f, 2.54557014e-01f, 2.08128765e-01f, -1.51173785e-01f, -3.62978540e-02f, 1.33677170e-01f, 1.11322373e-01f
};

// L3_fan_Wp (Shape: 3 x 16)
const int L3_fan_Wp_rows = 3;
const int L3_fan_Wp_cols = 16;
const float L3_fan_Wp_data[] = {
  1.48416489e-01f, 1.93208396e-01f, 7.20400363e-02f, 2.01806352e-01f, -2.17262760e-01f, 4.66105435e-03f, 1.96304768e-01f, -2.54447639e-01f, 2.90115178e-01f, 1.11907400e-01f,
  6.48605749e-02f, -9.01323780e-02f, -1.62203774e-01f, -2.66115695e-01f, 4.56861824e-01f, 1.55125156e-01f, 2.42108583e-01f, 2.10624442e-01f, 3.65717202e-01f, -4.91123796e-02f,
  -1.85928628e-01f, -6.02017045e-02f, -4.03921753e-01f, 3.28187138e-01f, -2.48792276e-01f, -1.20687798e-01f, -3.93163748e-02f, 2.52588868e-01f, 3.11510354e-01f, -1.86320528e-01f,
  3.23277414e-01f, -1.29634410e-01f, -6.16236866e-01f, -5.91930747e-01f, -1.33111224e-01f, 3.26129079e-01f, 3.69504333e-01f, -6.30807817e-01f, 4.25961502e-02f, 1.31723732e-01f,
  1.54663563e-01f, 1.40299857e-01f, 2.60974430e-02f, -1.98691655e-02f, 2.51728803e-01f, -1.93505615e-01f, 2.43803859e-01f, -8.78235340e-01f
};

// L3_fan_Wp_bar (Shape: 10 x 16)
const int L3_fan_Wp_bar_rows = 10;
const int L3_fan_Wp_bar_cols = 16;
const float L3_fan_Wp_bar_data[] = {
  -2.60043144e-01f, -2.67609715e-01f, 5.42250037e-01f, -2.72181481e-01f, 1.85041055e-01f, 1.71329543e-01f, 2.06839032e-02f, 1.08908832e+00f, 2.22034883e-02f, -5.54654934e-02f,
  -5.98252356e-01f, -2.15868965e-01f, 2.52262533e-01f, 7.21584678e-01f, 3.36718023e-01f, 5.45681417e-01f, -1.44595549e-01f, 7.33803213e-01f, 7.01507211e-01f, -4.85777318e-01f,
  -3.02179456e-01f, 8.64574909e-01f, 1.42043486e-01f, 3.67191941e-01f, -3.10725063e-01f, -2.77529985e-01f, 6.88953042e-01f, 8.35905820e-02f, -1.10502187e-02f, 5.96814096e-01f,
  -1.03831959e+00f, -4.62281734e-01f, 4.37578022e-01f, 3.50622796e-02f, -3.38317215e-01f, 3.39743376e-01f, 1.38755903e-01f, -4.74878140e-02f, 2.95985695e-02f, 1.81888223e-01f,
  1.66301001e-02f, 1.49760172e-01f, -6.81297183e-02f, 1.00586951e-01f, -8.15124288e-02f, 2.28033289e-02f, -4.82136644e-02f, 8.73489022e-01f, 2.03100741e-01f, 5.92621148e-01f,
  -7.19585657e-01f, 1.02269754e-01f, 1.89301461e-01f, -4.05755639e-01f, 7.78333485e-01f, -6.40105605e-01f, -2.39659362e-02f, -1.27925307e-01f, 6.62429035e-01f, 7.81791985e-01f,
  2.85156578e-01f, -8.58205706e-02f, 1.71519771e-01f, 2.26241574e-01f, 1.44012943e-01f, -1.14632785e+00f, -1.03564315e-01f, 5.70794702e-01f, 3.76093090e-01f, 1.06701660e+00f,
  2.44777456e-01f, 3.65980536e-01f, -9.01333928e-01f, -5.17107174e-02f, 6.30589202e-02f, 1.90433443e-01f, 2.97281176e-01f, 4.68690008e-01f, -7.62300968e-01f, -1.77755103e-01f,
  1.02024627e+00f, 6.78787410e-01f, -4.56925407e-02f, 3.36820543e-01f, 5.78745067e-01f, 6.45098567e-01f, 3.60168517e-01f, -1.00680031e-01f, -3.34389389e-01f, 1.74442932e-01f,
  7.48114109e-01f, 2.26870701e-01f, 1.90611370e-02f, -2.69026011e-01f, -5.56331933e-01f, -2.77933478e-01f, -9.63033140e-01f, -1.21495819e+00f, -6.13186657e-01f, 1.08050478e+00f,
  9.95738804e-02f, 5.67823529e-01f, 9.15140882e-02f, -9.85777974e-02f, 1.54039621e-01f, -3.44161928e-01f, 4.15711254e-01f, 2.47728657e-02f, 3.80188137e-01f, 5.39057374e-01f,
  1.85235441e-01f, -7.18905091e-01f, 7.62167156e-01f, -7.39999190e-02f, -1.24539578e+00f, 8.88547182e-01f, 8.83257926e-01f, 7.36504868e-02f, 4.03634489e-01f, 6.16267741e-01f,
  -2.70103693e-01f, 1.37629643e-01f, -1.29578695e-01f, 3.03100258e-01f, 6.29435480e-01f, 3.31834331e-02f, 2.83499688e-01f, 6.90617800e-01f, 3.20511788e-01f, 8.83918226e-01f,
  6.29927158e-01f, -7.51056314e-01f, 6.06558740e-01f, -1.25695384e+00f, 5.35391450e-01f, 1.65024847e-01f, -2.19000161e-01f, -2.49494001e-01f, 1.51385769e-01f, 5.22575974e-01f,
  8.16888094e-01f, -9.64378864e-02f, -1.78418890e-01f, 6.96086168e-01f, -4.43314731e-01f, 7.55680278e-02f, 7.52874970e-01f, -1.73801020e-01f, -7.69660711e-01f, -8.78864080e-02f,
  -3.21440697e-01f, -9.90588143e-02f, 4.24389809e-01f, -3.48842889e-01f, 7.27014422e-01f, -1.46114841e-01f, -7.10460544e-02f, 7.48712182e-01f, 2.07641929e-01f, 2.39231512e-01f
};

// L3_fan_Bp_bar (Shape: 1 x 10)
const int L3_fan_Bp_bar_rows = 1;
const int L3_fan_Bp_bar_cols = 10;
const float L3_fan_Bp_bar_data[] = {
  1.17911398e-01f, 4.11544561e-01f, 3.04725945e-01f, 2.67638445e-01f, -1.13081403e-01f, 3.29304218e-01f, -5.55730641e-01f, 5.57348020e-02f, 1.38329016e-02f, 2.21993953e-01f
};

// L4_linear_W (Shape: 12 x 16)
const int L4_linear_W_rows = 12;
const int L4_linear_W_cols = 16;
const float L4_linear_W_data[] = {
  4.38324809e-01f, -5.06455541e-01f, -2.27628753e-01f, -7.57655799e-01f, 3.37452926e-02f, -3.09689969e-01f, -2.90954888e-01f, -2.59393603e-01f, -4.25492942e-01f, 1.87856659e-01f,
  2.34425247e-01f, 1.68092903e-02f, 3.29702318e-01f, 3.58327955e-01f, -7.05518574e-02f, -7.09592581e-01f, 1.03599936e-01f, -4.10316676e-01f, -8.09909284e-01f, -2.50387400e-01f,
  2.81285733e-01f, -1.02498606e-01f, 3.41243930e-02f, -3.04471910e-01f, -4.74069774e-01f, -1.31480843e-01f, -9.61631954e-01f, -2.80566365e-01f, 5.35142720e-01f, 9.62395072e-02f,
  -1.65442213e-01f, 1.63910016e-01f, -2.50193328e-01f, -3.61642212e-01f, 3.07651401e-01f, -5.67185640e-01f, -8.06604981e-01f, 7.82830194e-02f, 2.13410184e-01f, 4.48860258e-01f,
  -9.45336401e-01f, 7.05228224e-02f, 3.16936940e-01f, -1.81256935e-01f, 4.47581381e-01f, -1.51630402e-01f, -9.92140174e-01f, -2.66673833e-01f, -4.51258123e-01f, 1.81430534e-01f,
  5.60230136e-01f, -4.15951282e-01f, -2.90465653e-02f, 6.33794010e-01f, -3.39872688e-01f, 5.50258815e-01f, -2.80801415e-01f, -1.21692076e-01f, 6.47374630e-01f, 4.27089304e-01f,
  -4.35237646e-01f, -8.40158314e-02f, 2.09627122e-01f, -6.56806767e-01f, -1.97625607e-01f, 3.91879529e-01f, 3.56196500e-02f, 9.37933862e-01f, 6.08017385e-01f, 6.51418746e-01f,
  -7.73022592e-01f, -6.18921161e-01f, -7.15568215e-02f, 4.34199423e-01f, -8.99937809e-01f, 4.69820082e-01f, -3.13920200e-01f, 2.84994096e-01f, 2.35176951e-01f, -2.97765791e-01f,
  1.07179403e-01f, -5.71206100e-02f, 2.40659490e-01f, 8.97139311e-01f, 2.92514622e-01f, 7.86555529e-01f, 2.15694785e-01f, -1.39216673e+00f, 4.53684598e-01f, -4.11568806e-02f,
  -6.35078490e-01f, -6.27127767e-01f, -4.40339565e-01f, 3.98664087e-01f, 3.41257721e-01f, -1.73522502e-01f, 7.47004926e-01f, -5.11919498e-01f, -9.41675156e-02f, -2.10090399e-01f,
  -4.82873291e-01f, -1.28825176e+00f, -4.83605415e-01f, 7.80477047e-01f, -8.44424143e-02f, 1.14346437e-01f, -9.18235600e-01f, -5.00037335e-02f, -1.37775153e-01f, -4.42240447e-01f,
  -9.83639479e-01f, 2.54316628e-01f, -5.54635227e-01f, 3.16635877e-01f, -4.99272674e-01f, -3.35784294e-02f, 6.40196979e-01f, -5.76876581e-01f, 4.33655351e-01f, -1.84399143e-01f,
  5.38282633e-01f, -3.50735366e-01f, 5.98030746e-01f, -5.24829447e-01f, -1.20874360e-01f, 4.05148804e-01f, -8.72490644e-01f, -3.04307610e-01f, -7.10274205e-02f, -1.42925454e-03f,
  2.79418290e-01f, 5.95034242e-01f, -2.53344774e-01f, 4.17549402e-01f, 3.91354799e-01f, -6.64658129e-01f, -2.05278024e-01f, -1.21101320e+00f, -4.82942522e-01f, -2.97612771e-02f,
  2.88577557e-01f, -7.91196525e-01f, -1.24688351e+00f, 7.34431803e-01f, -4.88207415e-02f, 9.63697806e-02f, 2.98617065e-01f, 4.09018964e-01f, -1.13963401e+00f, 1.15974987e+00f,
  -1.71950147e-01f, 3.40708941e-01f, -3.19650471e-01f, 2.86598414e-01f, -1.03107595e+00f, -1.37157881e+00f, -2.35234126e-01f, -1.18404162e+00f, 3.98831099e-01f, 2.94371784e-01f,
  4.35333788e-01f, -9.29166749e-02f, 6.48829758e-01f, -9.77652967e-01f, 6.99527621e-01f, -3.58662248e-01f, 6.34558380e-01f, 5.23241222e-01f, -2.00258672e-01f, -9.42888379e-01f,
  -7.80880988e-01f, -2.06153005e-01f, -1.14426899e+00f, -5.28801121e-02f, 3.73450756e-01f, -1.19412400e-01f, 2.42593378e-01f, 9.04536605e-01f, 2.79586554e-01f, 7.33126402e-02f,
  1.28833249e-01f, -4.34673846e-01f, -2.79635876e-01f, 5.11020482e-01f, 6.27446324e-02f, 5.13573647e-01f, -9.13091302e-01f, 7.91952491e-01f, -1.63238227e+00f, -4.48701054e-01f,
  -1.79998919e-01f, -3.12128533e-02f
};

// L4_linear_B (Shape: 1 x 12)
const int L4_linear_B_rows = 1;
const int L4_linear_B_cols = 12;
const float L4_linear_B_data[] = {
  -2.16120645e-01f, -3.93523216e-01f, 5.47701456e-02f, -3.36931199e-01f, 2.37037927e-01f, 1.32372677e-01f, -4.86603053e-03f, 2.87225723e-01f, 2.54395843e-01f, -2.58549869e-01f,
  -1.05983093e-01f, 6.84489429e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 3, 10
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        16, 3, 10
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        16, 3, 10
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L3_fan_Wp_data, L3_fan_Wp_bar_data, L3_fan_Bp_bar_data,
        16, 3, 10
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 4: L4_linear
    linear_forward_pgm(
        buffer1, x_out,
        L4_linear_W_data, L4_linear_B_data,
        16, 12
    );
    }
    