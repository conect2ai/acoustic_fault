/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 64 (x2)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 64;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    return (x > 0.0f) ? x : 0.0f;
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 25 x 120)
const int L0_fan_Wp_rows = 25;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -2.09475890e-01f, 2.39822701e-01f, 2.56948527e-02f, 2.56767608e-02f, 8.89345109e-02f, 9.09831524e-02f, 2.49463812e-01f, -5.48160039e-02f, -7.97326118e-02f, 3.60936485e-02f,
  -1.16446074e-02f, -3.52536470e-01f, -3.60511720e-01f, -2.37600893e-01f, -8.16530436e-02f, 1.97132960e-01f, 2.13598162e-01f, -1.70840636e-01f, -1.61015615e-01f, -8.90928805e-02f,
  4.67048138e-02f, 2.72175521e-02f, -2.27293205e-02f, 3.95974005e-03f, 2.00550020e-01f, -1.22777358e-01f, 1.79328904e-01f, 1.66953370e-01f, 9.13892761e-02f, 1.44955635e-01f,
  -1.94039568e-01f, 1.81224808e-01f, -9.00798440e-02f, -5.58549426e-02f, -6.92210123e-02f, -6.48048520e-02f, -8.20937082e-02f, -1.03418887e-01f, -1.33976460e-01f, -3.33519392e-02f,
  5.44704422e-02f, -6.01868890e-02f, -1.12227919e-02f, 3.06624491e-02f, 3.08073238e-02f, -1.44227184e-02f, 1.00501589e-01f, 1.50797237e-02f, -4.57946397e-02f, 4.47430722e-02f,
  -1.54127413e-02f, 9.28391367e-02f, -1.90136302e-02f, 3.08329370e-02f, -1.97118409e-02f, -1.25769794e-01f, 4.67632413e-02f, -2.15953682e-03f, -2.05876958e-02f, 1.51906624e-01f,
  -4.88373004e-02f, -2.65695024e-02f, -2.76396852e-02f, 1.38714552e-01f, -2.91385106e-03f, 4.32029739e-02f, 4.18907665e-02f, -2.16935035e-02f, -2.96448395e-02f, 4.25262377e-02f,
  -2.18521561e-02f, 1.11421406e-01f, 1.02810580e-02f, -2.12670248e-02f, -4.51256195e-03f, -1.78765673e-02f, -3.34742777e-02f, -2.89325621e-02f, -1.02454409e-01f, -1.69568378e-02f,
  -8.26274753e-02f, -6.12486852e-03f, -3.05771604e-02f, 7.61796534e-03f, 5.05680293e-02f, 2.88690757e-02f, -1.67361870e-02f, 1.90306567e-02f, -2.61082295e-02f, 1.92824975e-02f,
  -1.06687881e-01f, -1.26421049e-01f, -1.13997623e-01f, -1.52187034e-01f, -5.73910289e-02f, -1.28815189e-01f, -4.19131145e-02f, -2.06393516e-03f, -8.49009529e-02f, 7.64119206e-03f,
  -1.36482090e-01f, -2.52481475e-02f, -4.21087295e-02f, -5.34806401e-02f, -6.66415785e-03f, -4.35959995e-02f, -3.91084924e-02f, -7.13470727e-02f, -1.51015446e-01f, -2.99749672e-02f,
  -7.81353377e-03f, -7.33198673e-02f, -1.99810743e-01f, -8.67191181e-02f, -7.62256533e-02f, -2.19048828e-01f, -1.37986168e-01f, -1.70541048e-01f, -2.36134037e-01f, -6.58282116e-02f,
  -6.96645677e-01f, -3.35187763e-01f, 2.04808548e-01f, -4.87008870e-01f, 2.45507956e-02f, 1.09653786e-01f, 1.40714034e-01f, -1.46233290e-01f, -2.61060208e-01f, -1.87905461e-01f,
  -1.40036121e-01f, -2.05963627e-01f, -1.88932046e-01f, -7.78187290e-02f, -6.38032332e-02f, 7.05906674e-02f, -3.61617133e-02f, -3.15839052e-02f, 4.88917045e-02f, 8.36088136e-02f,
  -1.72664255e-01f, -2.44338065e-01f, -1.93554372e-01f, -2.23006427e-01f, -1.51421726e-01f, -5.05646206e-02f, 2.23116353e-02f, -2.08067119e-01f, 4.99044470e-02f, -1.04771927e-01f,
  1.62273154e-01f, -2.42325515e-02f, 3.54798213e-02f, -1.83461085e-01f, 1.54553754e-02f, -1.08083457e-01f, -7.58296177e-02f, -4.94636409e-02f, -3.43732759e-02f, -8.06446746e-02f,
  -5.45354635e-02f, -8.64177942e-02f, -5.87367453e-02f, -6.57852814e-02f, 1.47611899e-02f, -7.34896809e-02f, -6.18294068e-02f, -7.50696361e-02f, -3.54199372e-02f, 2.02990994e-02f,
  -1.57377258e-01f, -7.67451078e-02f, -2.17650831e-02f, -1.95324365e-02f, -6.15940467e-02f, -5.55875115e-02f, -1.58137865e-02f, 1.47700310e-02f, 3.07289511e-02f, -1.72833741e-01f,
  -1.00544780e-01f, 2.75834687e-02f, 9.60992128e-02f, 7.20008370e-03f, -8.59072804e-03f, 1.30406454e-01f, 7.38906190e-02f, 9.21548009e-02f, 9.38178673e-02f, 2.26564687e-02f,
  6.82252124e-02f, 1.26176938e-01f, 8.22079554e-02f, 6.87290132e-02f, 9.02943760e-02f, 5.64530529e-02f, -3.44691146e-03f, 7.48589113e-02f, -3.74943786e-03f, -2.03807708e-02f,
  6.87814578e-02f, 9.83104333e-02f, 4.35168967e-02f, 9.82797071e-02f, 8.96064490e-02f, 9.49662253e-02f, 2.86387615e-02f, 6.95945919e-02f, -2.18187664e-02f, -3.15044969e-02f,
  -1.60369381e-01f, 5.07918820e-02f, -4.86432910e-02f, -4.94164526e-02f, -8.73065442e-02f, -3.15373354e-02f, -2.51648556e-02f, -8.06095172e-03f, -3.50606628e-02f, 6.67008385e-03f,
  -9.84483883e-02f, -1.16874613e-01f, -5.94341122e-02f, -5.42053059e-02f, -2.54208110e-02f, -3.73689122e-02f, -1.02959007e-01f, -1.06740244e-01f, -9.23515018e-03f, -7.27536827e-02f,
  -1.43642128e-01f, -1.54382259e-01f, -1.18321046e-01f, -4.25253548e-02f, -1.08651124e-01f, -2.74414495e-02f, 4.40699533e-02f, -8.31774846e-02f, -7.76448147e-03f, -1.39790311e-01f,
  3.13613147e-01f, 1.69782460e-01f, 6.53203428e-02f, 1.67016238e-01f, 1.89081743e-01f, 1.02591857e-01f, 1.91480771e-01f, 3.48151699e-02f, -1.35744771e-03f, 1.17538340e-01f,
  -1.61928162e-01f, -8.38286206e-02f, -1.70270205e-01f, -5.75741678e-02f, -6.43163994e-02f, 9.07515511e-02f, 2.45959312e-01f, 1.81089446e-01f, 8.52270499e-02f, 1.28399983e-01f,
  6.71865493e-02f, 9.02442783e-02f, 1.23492815e-01f, 7.42332116e-02f, 3.30887645e-01f, 1.66700125e-01f, 7.49893412e-02f, 2.96721816e-01f, 2.22177684e-01f, 4.03398514e-01f,
  8.36581215e-02f, 1.45200640e-01f, -3.62429768e-03f, 5.72915114e-02f, 1.11152746e-01f, 1.48072794e-01f, 1.14280423e-02f, 1.37509167e-01f, -3.31828706e-02f, 1.03028245e-01f,
  6.86395094e-02f, -4.06055339e-02f, 9.00496319e-02f, -6.11620992e-02f, 5.59567148e-03f, 4.27565277e-02f, -9.24615264e-02f, 8.56199041e-02f, -5.29063009e-02f, -7.31637925e-02f,
  5.79198487e-02f, 8.15284327e-02f, 7.70655945e-02f, -9.50476504e-04f, -4.20805402e-02f, 4.25613523e-02f, 1.58099122e-02f, 1.47504061e-01f, 1.74576968e-01f, 3.07476908e-01f,
  1.39004275e-01f, 2.99477652e-02f, -1.19019501e-01f, -7.31724948e-02f, -1.82436392e-01f, -2.29055658e-01f, -1.50955513e-01f, -1.25791788e-01f, -4.24270704e-02f, -8.99576917e-02f,
  -1.39570042e-01f, -1.57996528e-02f, -8.93250555e-02f, -1.82862710e-02f, -5.51903211e-02f, 4.37930375e-02f, -9.60018206e-03f, -1.46131456e-01f, -1.52531430e-01f, -1.31418377e-01f,
  -8.99302363e-02f, 2.33578179e-02f, 3.35726626e-02f, -4.64096619e-03f, -2.50561349e-02f, -9.37893838e-02f, 4.24865671e-02f, -1.49226133e-02f, -5.95721267e-02f, 7.17775384e-03f,
  -6.11215532e-02f, -6.47345260e-02f, 4.95550111e-02f, 1.34985328e-01f, 1.10582240e-01f, -1.26910787e-02f, 1.35519095e-02f, 1.20869623e-02f, 9.32200551e-02f, 6.15689810e-03f,
  -2.44386289e-02f, 5.03710248e-02f, -1.13161802e-01f, 3.55028696e-02f, -4.25668433e-02f, -1.03075691e-02f, -4.90019051e-03f, 4.76518236e-02f, -1.43424226e-02f, 2.57411301e-02f,
  -5.14071956e-02f, 1.35415122e-02f, 3.25857103e-02f, -8.07054061e-03f, -6.86823111e-03f, 4.35490161e-02f, 7.90713280e-02f, 1.29002899e-01f, 1.14577301e-01f, 4.90166135e-02f,
  -2.61554539e-01f, 1.07115783e-01f, 2.17499603e-02f, -1.13244131e-01f, 1.00846909e-01f, 7.71353990e-02f, 1.28074273e-01f, -1.40853435e-01f, -1.84155241e-01f, 4.05213051e-02f,
  1.01091743e-01f, -7.10874572e-02f, -8.93671624e-03f, -3.90589759e-02f, -6.25759885e-02f, 1.85677886e-01f, 1.21365480e-01f, -1.07864387e-01f, -9.49874893e-02f, -6.76081404e-02f,
  -5.48183098e-02f, -1.69055283e-01f, -2.82131016e-01f, -1.78764790e-01f, -1.19926883e-02f, -7.68078044e-02f, -3.50573249e-02f, -7.18797222e-02f, -9.39420536e-02f, -6.40395805e-02f,
  1.51347801e-01f, -1.90576285e-01f, -1.98334590e-01f, -1.76541775e-01f, -1.28616095e-01f, -2.56216675e-01f, -6.09460250e-02f, -1.72432736e-01f, -1.73977882e-01f, -1.58616126e-01f,
  -1.08742841e-01f, -7.39168003e-02f, -1.83480293e-01f, -3.55208926e-02f, -3.39092277e-02f, -1.63727358e-01f, -1.86930567e-01f, -2.34614432e-01f, -1.94859669e-01f, -6.59156442e-02f,
  1.77137572e-02f, -1.12115145e-01f, -1.04443580e-01f, -1.67654887e-01f, -1.48339838e-01f, -1.76842734e-01f, -1.88884754e-02f, -2.45531872e-01f, -2.73718208e-01f, -2.03894466e-01f,
  7.48641044e-02f, 1.39457077e-01f, 3.56176756e-02f, 1.97099984e-01f, 1.23463340e-01f, 1.22807488e-01f, 1.40447453e-01f, 2.13455483e-01f, 4.87601124e-02f, 1.70629129e-01f,
  9.26603600e-02f, 1.05100602e-01f, 6.86246902e-02f, 7.40505606e-02f, 7.89614692e-02f, 1.63399383e-01f, 5.49873039e-02f, 9.59019735e-02f, 7.23306984e-02f, 3.63220870e-02f,
  6.92230761e-02f, 1.02169164e-01f, 1.50628194e-01f, 5.40383719e-02f, 1.59025863e-01f, 9.07716528e-02f, 1.64746284e-01f, 1.01801664e-01f, 2.05113977e-01f, 8.25372711e-02f,
  -1.42282516e-01f, -3.22183192e-01f, -5.24546690e-02f, -1.66461408e-01f, -1.75924912e-01f, -1.39691561e-01f, -1.43138543e-01f, -1.56426266e-01f, -9.26188752e-02f, -9.44529995e-02f,
  -9.74540189e-02f, -1.42823949e-01f, -9.01703835e-02f, -5.84746785e-02f, -1.20362766e-01f, -3.15781832e-02f, -1.20623417e-01f, -8.65327567e-03f, -9.31174532e-02f, -1.48780763e-01f,
  -5.50187528e-02f, -4.91535440e-02f, -7.41345063e-03f, -1.13909915e-01f, -1.28967136e-01f, -1.48437515e-01f, -6.25023916e-02f, -1.09009542e-01f, -1.23401217e-01f, -2.31959298e-02f,
  3.75911832e-01f, -2.96691973e-02f, 3.24899733e-01f, -2.09423438e-01f, -5.09572513e-02f, 2.48591632e-01f, 1.81858197e-01f, 1.04225148e-02f, -2.34026425e-02f, -4.67892848e-02f,
  2.49717738e-02f, 8.51624161e-02f, 4.90477495e-02f, 1.82875618e-01f, 2.27151290e-01f, 1.14911176e-01f, 1.27482414e-02f, 3.24222505e-01f, 4.29509789e-01f, 7.72139207e-02f,
  -1.33937718e-02f, -3.70684862e-02f, 2.60316968e-01f, 1.48830846e-01f, -3.13696593e-01f, -3.37221436e-02f, 7.80039802e-02f, -3.05004399e-02f, 8.82186741e-02f, -2.57551253e-01f,
  6.73195496e-02f, 1.90055102e-01f, 1.68973163e-01f, 2.25459803e-02f, -9.29741282e-03f, 1.05182849e-01f, 1.37557760e-01f, 6.54797927e-02f, 7.84203112e-02f, 2.04175971e-02f,
  6.34383410e-02f, 9.80305597e-02f, 1.06053174e-01f, 3.28673981e-02f, 1.58785403e-01f, 1.10367663e-01f, 4.95017208e-02f, 1.49125412e-01f, 2.39092469e-01f, 2.53227428e-02f,
  5.28608225e-02f, 1.66251481e-01f, 1.97501451e-01f, 1.11412115e-01f, 2.34685645e-01f, 1.08909734e-01f, 8.47276822e-02f, 4.37425524e-02f, 3.01050991e-01f, -1.15001820e-01f,
  -2.39578560e-02f, -6.70200363e-02f, -1.18567124e-01f, -1.29632831e-01f, -1.70676291e-01f, -5.48130041e-03f, -8.26255307e-02f, -8.63565952e-02f, -6.39733002e-02f, -8.04309249e-02f,
  2.24617459e-02f, -1.06029831e-01f, 2.20255144e-02f, -9.19958577e-03f, -5.01179509e-02f, -3.62064987e-02f, -2.63426709e-03f, -9.06603634e-02f, -1.18799955e-01f, -9.44398493e-02f,
  2.18912065e-02f, -1.00361332e-01f, -4.50168438e-02f, -2.48341803e-02f, -6.20359890e-02f, -6.77413121e-02f, 1.54051315e-02f, -5.27819656e-02f, -1.10644110e-01f, -3.10490392e-02f,
  -1.51232913e-01f, 4.26083505e-01f, -6.91181514e-03f, 1.68283239e-01f, 1.49183162e-02f, 9.21561942e-02f, 7.21654594e-02f, 7.16452897e-02f, 7.82619119e-02f, 5.33916354e-02f,
  1.49372026e-01f, 9.56108794e-02f, 1.07705310e-01f, 1.39887348e-01f, 5.63166253e-02f, 4.20423560e-02f, 3.28249410e-02f, 7.38925412e-02f, 1.90220475e-01f, 7.01655541e-03f,
  -1.39663881e-02f, 5.10787293e-02f, -4.37770151e-02f, 1.06221503e-02f, 4.09430861e-02f, 1.11457765e-01f, -1.47413909e-02f, -6.19172305e-02f, 1.20627448e-01f, -1.61166057e-01f,
  -5.60805202e-01f, -4.04840797e-01f, 1.50095493e-01f, -2.21776888e-01f, -1.17834829e-01f, 7.40332603e-02f, -1.59636438e-01f, -1.29568726e-01f, -1.81138162e-02f, -1.37990698e-01f,
  -9.22561064e-02f, 1.36721492e-01f, 8.73652399e-02f, 1.79440156e-01f, 1.42108291e-01f, 3.47300582e-02f, 1.49961701e-02f, 2.87374228e-01f, 4.03285146e-01f, 2.96468794e-01f,
  9.24431384e-02f, 1.58408955e-01f, 1.37069076e-01f, 7.30531737e-02f, -4.77078743e-02f, 1.03471257e-01f, 8.08907021e-03f, -8.36835941e-04f, -3.61925289e-02f, -3.75544392e-02f,
  7.52307698e-02f, -2.50207037e-01f, 2.13741511e-01f, 1.62847593e-01f, 3.95973921e-02f, 5.63951358e-02f, -2.58357003e-02f, 1.12969995e-01f, -4.29770770e-03f, 1.19633168e-01f,
  1.26913637e-01f, -1.07797375e-03f, 5.80419078e-02f, 6.59464300e-02f, -3.15128937e-02f, 9.05338451e-02f, 3.89451720e-02f, 1.29676566e-01f, 1.34934694e-01f, 2.93189706e-03f,
  1.13313071e-01f, -6.17384389e-02f, -6.82731858e-03f, 7.78809935e-02f, 8.61560553e-02f, 1.62983835e-01f, -2.18411740e-02f, 2.91483533e-02f, -3.19199316e-04f, -1.70104012e-01f,
  -6.35893364e-03f, -1.49049416e-01f, -1.33398384e-01f, -1.59384340e-01f, -1.43993840e-01f, -1.15845270e-01f, -9.78125855e-02f, -9.88837257e-02f, -1.10055704e-03f, -1.55773997e-01f,
  -9.48308334e-02f, -1.29818797e-01f, -1.54123783e-01f, -8.19151551e-02f, -4.61301170e-02f, -1.76906660e-01f, -6.59477562e-02f, -8.65756497e-02f, -5.19394614e-02f, -1.68051049e-01f,
  -7.99225569e-02f, 2.97593931e-03f, -1.28799945e-01f, -1.21142134e-01f, -2.80801672e-02f, -8.54175612e-02f, -9.24169645e-02f, -5.57532273e-02f, -1.00405045e-01f, 7.76810711e-03f,
  -1.52363837e-01f, 1.86570600e-01f, -2.72513870e-02f, 1.07174851e-01f, 9.81539637e-02f, 1.20735064e-01f, 8.00338537e-02f, 2.13120326e-01f, 1.28189489e-01f, 9.22211856e-02f,
  8.05882663e-02f, 1.33967251e-01f, 7.08322898e-02f, 8.12758282e-02f, 1.30100653e-01f, 4.72732931e-02f, 5.63469715e-02f, 6.84816241e-02f, 1.06399938e-01f, 9.19869170e-02f,
  1.39193073e-01f, 9.59802344e-02f, 9.93036032e-02f, 4.38972861e-02f, 6.02821894e-02f, 6.95729852e-02f, 1.48122609e-01f, 1.37964204e-01f, 7.72687942e-02f, -4.04020436e-02f,
  1.87777832e-01f, -1.58293545e-01f, -5.36282212e-02f, 2.26936504e-01f, 1.31532848e-01f, 1.81367010e-01f, -1.07879722e-02f, 1.36494964e-01f, 1.46779016e-01f, 2.94201914e-02f,
  -6.05293959e-02f, -1.98270187e-01f, -1.17591798e-01f, -2.63187677e-01f, -2.79074043e-01f, -1.43445179e-01f, -1.60945639e-01f, -3.22681546e-01f, -8.83851349e-02f, -3.64124477e-02f,
  -1.38507992e-01f, -2.15795866e-04f, 7.59717599e-02f, -3.15596201e-02f, -3.54481041e-02f, -7.27285668e-02f, 1.21143743e-01f, -3.41374464e-02f, -1.04301825e-01f, -2.08933368e-01f,
  -3.04593831e-01f, -3.08686048e-02f, -6.15080632e-02f, -9.45445299e-02f, -1.96028519e-02f, 2.60299388e-02f, -4.30948474e-02f, -6.45888001e-02f, 4.11377996e-02f, 2.84815338e-02f,
  -7.18854219e-02f, -3.47215682e-02f, -5.98048083e-02f, -8.85359645e-02f, -4.30516228e-02f, -4.73716259e-02f, -1.54932560e-02f, -7.52167553e-02f, -5.97378761e-02f, 1.36959367e-02f,
  -2.80591697e-02f, -5.00335544e-02f, 1.84156299e-02f, 3.64704579e-02f, -2.09685881e-02f, -1.77017048e-01f, -3.12406514e-02f, -4.35281023e-02f, 3.33450809e-02f, -1.70723330e-02f,
  5.08159697e-02f, -1.03649339e-02f, 3.14593203e-02f, 3.68587524e-02f, -4.62807901e-02f, 1.02412909e-01f, 2.90259738e-02f, -5.99685051e-02f, 3.89707349e-02f, 2.75850482e-02f,
  -1.85247958e-02f, -7.33852088e-02f, -2.31554750e-02f, 3.00940070e-02f, -1.70568138e-01f, -3.14033516e-02f, 1.97821502e-02f, -7.65212476e-02f, 5.62238917e-02f, -1.24956947e-02f,
  -1.08437881e-01f, 4.95994240e-02f, -7.94058479e-03f, -2.26491373e-02f, 7.64025524e-02f, -9.10772905e-02f, -3.63505702e-03f, 1.96648240e-02f, 9.65553615e-03f, 9.44869146e-02f,
  3.66331600e-02f, -1.18004777e-01f, -1.29389480e-01f, -1.12133436e-01f, -1.31048173e-01f, -8.18905756e-02f, -6.14709482e-02f, -5.12470603e-02f, -8.98223743e-02f, -1.08928606e-01f,
  -1.36890829e-01f, -3.98345925e-02f, -1.20944642e-01f, -1.49925873e-02f, -3.55647355e-02f, -1.28414467e-01f, -5.86327612e-02f, -1.52132288e-01f, -1.52124390e-01f, -8.08576345e-02f,
  -9.93986428e-02f, -5.06352708e-02f, -4.13604416e-02f, -1.12417415e-01f, 8.56460028e-05f, -5.29396534e-02f, -1.30968034e-01f, -8.07294026e-02f, -1.09617099e-01f, 3.77951488e-02f,
  -3.12238336e-01f, -3.07733357e-01f, 8.37682262e-02f, -6.00785799e-02f, -1.69770345e-01f, -1.80101648e-01f, -3.06028247e-01f, -1.04908951e-01f, -6.46211430e-02f, -5.40098771e-02f,
  1.20240552e-02f, 2.08258837e-01f, 1.26821399e-01f, 9.42387581e-02f, -5.76672256e-02f, -7.24844486e-02f, -7.29366243e-02f, -5.19882701e-02f, -2.59615593e-02f, -8.36871266e-02f,
  -8.38514343e-02f, -3.49074416e-02f, -2.96890307e-02f, -2.32967623e-02f, -1.37088463e-01f, 8.46307445e-03f, 5.93405664e-02f, -1.06721178e-01f, -1.86872315e-02f, -1.71599790e-01f,
  1.91633895e-01f, -1.71718240e-01f, 4.15439755e-02f, -4.56955992e-02f, 8.15732181e-02f, -8.77257064e-02f, 2.19627265e-02f, -7.34985694e-02f, -7.87652358e-02f, -4.83334437e-02f,
  5.19755520e-02f, 4.60485853e-02f, -1.92020852e-02f, -4.08561677e-02f, 3.52301411e-02f, -2.94533167e-02f, 3.28709260e-02f, -1.08180366e-01f, 4.95442599e-02f, -2.41464805e-02f,
  -8.91432092e-02f, -1.09374948e-01f, -1.08177043e-01f, 3.51342484e-02f, 3.91445495e-02f, 6.80992529e-02f, -7.99321383e-02f, -1.00314483e-01f, -3.98177803e-02f, -1.36654347e-01f,
  1.35676816e-01f, 1.97173670e-01f, 6.17371462e-02f, 2.57922919e-03f, -5.42032942e-02f, 5.58356270e-02f, 3.15851197e-02f, -6.21537529e-02f, 8.19797516e-02f, 2.00750455e-02f,
  4.39253189e-02f, 1.54360887e-02f, 6.11209199e-02f, -3.75387892e-02f, 8.12120885e-02f, -3.92494015e-02f, -1.39491996e-02f, 4.25271727e-02f, 9.96965822e-03f, -1.72219835e-02f,
  -2.88585611e-02f, -1.81604829e-02f, -7.20430985e-02f, 5.99036738e-03f, -3.03551741e-02f, 1.42732263e-02f, 3.34972665e-02f, 5.26082739e-02f, -1.58518683e-02f, 2.01628786e-02f,
  1.43097803e-01f, 3.03341988e-02f, -4.08528000e-02f, -1.11357100e-01f, -1.99620932e-01f, 3.14719998e-03f, -3.64768654e-02f, -1.27569050e-01f, -3.78657617e-02f, -1.39089808e-01f,
  -9.98155996e-02f, 1.51073339e-03f, -6.06472902e-02f, -8.71505886e-02f, -1.08317889e-01f, -4.44268212e-02f, -4.80414703e-02f, -7.41421804e-02f, -6.26608729e-02f, -6.35238215e-02f,
  -6.30816594e-02f, -8.13050047e-02f, 8.99648108e-03f, -8.20630640e-02f, -1.30048260e-01f, -3.99713740e-02f, 1.22233089e-02f, -1.05463192e-01f, -8.48568529e-02f, -1.33219212e-01f,
  4.53140974e-01f, -1.56935260e-01f, 5.69410503e-01f, 1.12653337e-01f, 3.23850513e-02f, 1.68383852e-01f, 6.76086396e-02f, 9.71278846e-02f, 1.25026733e-01f, 9.30528492e-02f,
  1.16654620e-01f, 1.31750315e-01f, 1.44824862e-01f, 1.57124802e-01f, 2.22328886e-01f, 1.23096347e-01f, 1.64986834e-01f, 4.02427465e-01f, 4.39473987e-01f, 1.16920628e-01f,
  -1.69682071e-01f, 7.21251070e-02f, 1.70539111e-01f, 1.74730346e-01f, 1.11038417e-01f, 1.64925218e-01f, 2.19384730e-01f, 1.48729265e-01f, 1.18726179e-01f, 2.99636602e-01f,
  3.45380276e-01f, 3.27983350e-01f, 2.08850056e-01f, 1.28604695e-01f, 9.75115672e-02f, 1.38326943e-01f, 2.53739208e-01f, 1.30792201e-01f, 6.50737584e-02f, 1.90443292e-01f,
  1.20431416e-01f, 1.40583694e-01f, 1.12229601e-01f, 1.68360561e-01f, 2.25719258e-01f, 1.70226753e-01f, 8.60389322e-02f, 2.36659616e-01f, 2.44138613e-01f, 1.47837907e-01f,
  -1.20963767e-01f, 1.87932625e-01f, 2.99952716e-01f, 1.76992223e-01f, 2.02420071e-01f, 2.57735550e-01f, 2.23805383e-01f, 3.10017973e-01f, 2.77457744e-01f, 2.08039984e-01f,
  -4.75252047e-02f, -7.80618116e-02f, -1.55985460e-01f, -9.37930495e-02f, -1.92729548e-01f, -3.81542444e-02f, -1.47828935e-02f, -1.49701923e-01f, -8.89462233e-02f, -5.65882660e-02f,
  -4.92518544e-02f, -9.42067131e-02f, -9.79301855e-02f, -2.97319125e-02f, -1.91451162e-02f, -3.16929743e-02f, -4.01783064e-02f, -1.21020727e-01f, -2.55101323e-02f, -6.46633729e-02f,
  -3.74362580e-02f, -1.76263917e-02f, -6.32786676e-02f, -4.05217931e-02f, -1.01842202e-01f, -6.33020001e-03f, -3.26121859e-02f, -9.95417535e-02f, -1.50895327e-01f, -6.49021119e-02f,
  -1.19397052e-01f, 3.86536494e-02f, 2.54728556e-01f, 1.75938889e-01f, 1.71189159e-01f, 7.52126500e-02f, 1.36412352e-01f, 9.92311016e-02f, 1.30461827e-01f, 1.31213784e-01f,
  1.23413786e-01f, 1.46015853e-01f, 5.68028130e-02f, 5.63348532e-02f, 2.18402386e-01f, 1.68661729e-01f, 6.03110576e-03f, 1.34027585e-01f, 1.11935869e-01f, 1.48661748e-01f,
  -2.82774698e-02f, 6.96861073e-02f, 1.22425482e-01f, 2.12759867e-01f, 6.48928955e-02f, 2.27334499e-01f, 1.43177509e-01f, 1.51112616e-01f, 2.05612779e-01f, 7.05390945e-02f,
  1.20192587e-01f, -1.14343904e-01f, -2.25909334e-02f, 1.10972777e-01f, -1.67547598e-01f, -1.47749826e-01f, -4.37026173e-01f, -2.35645100e-01f, -1.03969537e-01f, 6.24464303e-02f,
  8.86880457e-02f, 3.49018276e-01f, 2.72847384e-01f, 1.49011001e-01f, -8.03081598e-03f, -2.21387818e-01f, -1.90240592e-01f, 1.47754475e-01f, 1.01966402e-02f, 9.56906155e-02f,
  3.81089300e-02f, 1.19690590e-01f, 1.73021510e-01f, 9.46752280e-02f, 6.61684349e-02f, 1.85410529e-01f, 5.10429665e-02f, -5.22015914e-02f, -3.66426259e-03f, 1.65484652e-01f,
  2.88823456e-01f, 1.63640808e-02f, 1.16327647e-02f, 6.67233840e-02f, -2.37798914e-02f, 4.90970956e-03f, -3.91463265e-02f, 4.42723595e-02f, 9.23469514e-02f, -6.72019422e-02f,
  7.10685924e-02f, 1.40506119e-01f, 8.97535533e-02f, 1.20770060e-01f, 4.68192026e-02f, 3.65922265e-02f, -4.68713930e-03f, 3.79888229e-02f, -9.92469341e-02f, 9.03572440e-02f,
  1.10111661e-01f, -6.04436640e-03f, -1.27713904e-02f, -1.27660289e-01f, -1.42238468e-01f, 2.87273526e-02f, -1.99435689e-02f, -1.23638250e-02f, -9.52354670e-02f, -1.21994251e-02f,
  -8.67184177e-02f, 2.69457009e-02f, -8.47323239e-03f, -3.88597101e-02f, -6.89733922e-02f, -3.19038779e-02f, 3.95404659e-02f, -1.96923483e-02f, -1.34752151e-02f, -4.14387286e-02f,
  -3.12001593e-02f, -5.18608699e-03f, -5.24693690e-02f, 1.26962680e-02f, 6.26413850e-03f, -3.36836092e-02f, -3.23793329e-02f, -2.66454928e-02f, 4.09934781e-02f, -1.12412773e-01f,
  2.84929853e-02f, -8.91257972e-02f, -2.66042296e-02f, 1.63082872e-02f, 1.23671815e-02f, -2.60998812e-02f, -3.15816253e-02f, 5.03164530e-02f, -5.73276691e-02f, 4.11313474e-02f,
  7.94230551e-02f, -1.50796458e-01f, 1.76256984e-01f, -2.33575497e-02f, 6.92286268e-02f, 1.05083361e-01f, 9.14588124e-02f, 5.54081313e-02f, -6.45084633e-03f, 8.50508288e-02f,
  4.05970551e-02f, 3.27154100e-02f, 1.34520046e-02f, -2.13456862e-02f, 5.23973890e-02f, -3.65828834e-02f, 5.84232844e-02f, 7.11279586e-02f, 4.86539118e-03f, -2.68361792e-02f,
  -3.42909917e-02f, -1.81033388e-02f, 4.84331995e-02f, -4.42109853e-02f, 5.37784845e-02f, 4.81241345e-02f, 3.34520601e-02f, 5.93463108e-02f, -4.78263479e-03f, -1.61419049e-01f,
  5.93944609e-01f, 1.40931860e-01f, 1.81179084e-02f, 2.39465818e-01f, 8.03317353e-02f, 2.22696602e-01f, 2.25739419e-01f, 1.98361367e-01f, 1.91349596e-01f, 1.67529002e-01f,
  7.46472925e-02f, 1.88780576e-03f, -1.25765931e-02f, -5.24574928e-02f, 9.32950005e-02f, 1.28441423e-01f, 8.58701542e-02f, 4.50995006e-02f, 2.30118986e-02f, -4.88750339e-02f,
  7.71305477e-03f, 2.00499907e-01f, 8.84757116e-02f, 1.24346375e-01f, 2.16438305e-02f, -4.04287875e-02f, 6.98111625e-03f, 2.82022227e-02f, -4.47483771e-02f, 6.15481474e-02f,
  -5.73910959e-02f, 7.49711245e-02f, -8.04479346e-02f, 1.10930307e-02f, -8.69599655e-02f, 2.53401417e-02f, -4.72881831e-03f, -8.77856240e-02f, -3.78871784e-02f, 2.56683640e-02f,
  7.50414357e-02f, 1.03065312e-01f, 7.84372240e-02f, -9.81958676e-03f, 1.27086535e-01f, 1.77149232e-02f, -4.06482443e-03f, -1.27993347e-02f, -4.97350097e-02f, -1.06150433e-02f,
  -4.83306274e-02f, 8.19950625e-02f, 1.16060555e-01f, 2.68434249e-02f, 3.16053368e-02f, 3.76273207e-02f, 2.23604180e-02f, 9.74750966e-02f, 7.10525960e-02f, 2.48644557e-02f,
  -2.12390646e-02f, 4.74583544e-02f, 5.46779670e-02f, 3.51762362e-02f, 6.29604906e-02f, -2.31308416e-02f, 2.96281651e-02f, 4.67426181e-02f, 3.56049975e-03f, 1.11423850e-01f,
  -1.71689340e-03f, 1.17923878e-02f, 4.58971411e-03f, 1.06434330e-01f, -6.13828339e-02f, 9.91762709e-03f, 2.30435245e-02f, -2.39250008e-02f, -4.28504981e-02f, -1.68629270e-02f,
  1.54469488e-02f, 1.13943651e-01f, -1.33785838e-02f, -6.55125901e-02f, 3.30744386e-02f, -5.63797206e-02f, 6.32401416e-03f, -5.67376502e-02f, 7.68750980e-02f, 1.26163453e-01f,
  -2.17796154e-02f, -1.05909035e-02f, 8.24400783e-02f, 4.80388291e-03f, 4.02271301e-02f, 4.55768816e-02f, 1.33469194e-01f, 1.08264812e-05f, 8.63588303e-02f, 8.49805623e-02f,
  3.79825570e-02f, 1.42364383e-01f, 6.80931509e-02f, 8.05222392e-02f, 5.49505390e-02f, 3.34146358e-02f, 2.35755816e-02f, 1.02390759e-01f, 5.97860068e-02f, 3.40794213e-03f,
  6.76373318e-02f, 1.75190270e-01f, 2.12440133e-01f, 8.73791128e-02f, 7.59943873e-02f, 2.64299750e-01f, -6.62527222e-04f, 1.04361258e-01f, 6.10236712e-02f, 1.44815266e-01f,
  2.08260164e-01f, 3.08460928e-02f, 2.36158922e-01f, 8.43846723e-02f, -2.14257035e-02f, -1.23956777e-01f, -2.60565788e-01f, -2.37079680e-01f, -5.51451482e-02f, 3.10138911e-02f,
  1.69199288e-01f, 1.40951276e-01f, 2.28600189e-01f, 1.64638117e-01f, 1.69315450e-02f, -1.27262801e-01f, 3.18424255e-02f, 2.03169659e-01f, -7.45163411e-02f, -1.77341208e-01f,
  -4.38710041e-02f, -1.21295098e-02f, 4.04834487e-02f, 5.83060421e-02f, 1.01556756e-01f, 3.88198905e-02f, 2.31239364e-01f, 8.79109055e-02f, 1.50263086e-01f, 3.94443989e-01f,
  4.18709308e-01f, 4.30547506e-01f, 8.34090486e-02f, 1.97971299e-01f, 2.88305342e-01f, 2.05573097e-01f, 1.30032271e-01f, 2.27842569e-01f, 2.14007154e-01f, 1.92791522e-01f,
  2.06989765e-01f, 1.94990948e-01f, 1.81797311e-01f, 1.36847287e-01f, 1.21265694e-01f, 1.10916935e-01f, 1.59425408e-01f, 1.71756268e-01f, 1.54228136e-01f, 1.24896921e-01f,
  1.68627635e-01f, 2.05386341e-01f, 1.16126709e-01f, 1.52201056e-01f, 1.14811853e-01f, 1.78408936e-01f, 1.47959903e-01f, 2.66817242e-01f, 1.78430617e-01f, 9.51643959e-02f,
  -1.87605550e-03f, -5.61863855e-02f, -6.63249493e-02f, -9.89167392e-02f, -1.76327214e-01f, -5.68964444e-02f, -2.57380661e-02f, -2.59975120e-02f, -9.47853401e-02f, -1.40580863e-01f,
  -1.08429737e-01f, -2.67994851e-02f, -7.45865330e-02f, -1.40294656e-01f, -5.10422252e-02f, -3.43790390e-02f, -8.45163763e-02f, -1.20160826e-01f, -4.85826395e-02f, -7.99406990e-02f,
  1.97312459e-02f, -1.09738819e-01f, 1.56567432e-02f, -1.39296144e-01f, -4.98587750e-02f, -3.86525318e-02f, -1.11205094e-01f, -1.06998309e-01f, -6.02943301e-02f, -1.55064493e-01f,
  -2.08061218e-01f, 2.60895729e-01f, 1.73800528e-01f, 1.65173352e-01f, 1.39758572e-01f, 1.84672102e-01f, 2.21907452e-01f, 2.09076852e-01f, 1.69255346e-01f, 1.49524361e-01f,
  1.51233584e-01f, 8.94337371e-02f, 1.60504431e-01f, 1.25628024e-01f, 1.15413740e-02f, 1.40168071e-01f, 1.69325501e-01f, 7.97365010e-02f, 9.37438086e-02f, 1.33193240e-01f,
  3.17276716e-02f, -3.08229923e-02f, 3.63381989e-02f, -4.98705134e-02f, 5.48770055e-02f, 5.05200736e-02f, -4.01340686e-02f, -5.74518815e-02f, 3.49993482e-02f, -2.40587026e-01f,
  1.75781175e-01f, 2.84418967e-02f, 9.98404343e-04f, 1.37443289e-01f, 1.15037091e-01f, 1.79335952e-01f, 3.36322784e-02f, 8.95060599e-02f, -2.18790770e-02f, 8.37568939e-02f,
  -1.55640975e-01f, -1.96345299e-01f, -6.19847476e-02f, -1.25626475e-01f, 1.97595172e-02f, 8.91463757e-02f, 1.42336816e-01f, -3.18837054e-02f, 1.13383114e-01f, -6.19489551e-02f,
  2.37092506e-02f, 1.88133381e-02f, 1.96460336e-02f, -2.24400479e-02f, -1.01659700e-01f, -1.53949901e-01f, -1.63369641e-01f, -1.14491381e-01f, -1.02683112e-01f, -1.15490369e-01f,
  9.01288725e-03f, 1.57819986e-01f, -2.23366898e-02f, -1.23203687e-01f, -1.55588407e-02f, -8.09654370e-02f, -5.77607304e-02f, -4.20040339e-02f, -1.23352811e-01f, -3.22507769e-02f,
  -1.45024046e-01f, -1.04159243e-01f, -5.05235940e-02f, -1.17145896e-01f, -1.02615714e-01f, -9.92622375e-02f, -1.82196796e-01f, -1.14358328e-01f, -1.31964274e-02f, -7.04261512e-02f,
  -1.38674080e-01f, -1.45078063e-01f, -1.49129368e-02f, -1.20497674e-01f, -1.17789656e-02f, -1.49350852e-01f, -1.56205460e-01f, -7.35535473e-02f, -1.71010911e-01f, -1.95329636e-01f,
  -1.60662606e-02f, 1.22088850e-01f, 1.85733259e-01f, 3.87912877e-02f, 8.52027237e-02f, 6.83676228e-02f, 1.74920142e-01f, 2.28858851e-02f, 8.38903040e-02f, 1.12321340e-01f,
  4.42368649e-02f, 9.52726975e-02f, 1.07824057e-01f, 1.47139847e-01f, 1.81169748e-01f, 1.70717970e-01f, 1.86707050e-01f, 1.04807779e-01f, 1.19182244e-01f, 7.11826235e-02f,
  2.00644493e-01f, 1.00628071e-01f, 1.37242317e-01f, 2.33899191e-04f, 1.70095205e-01f, 1.99873343e-01f, 1.12517051e-01f, 1.05263121e-01f, 2.01865971e-01f, 1.47064343e-01f,
  -1.63373977e-01f, -8.11835602e-02f, -6.47438541e-02f, -4.95215468e-02f, 2.71097408e-03f, -9.06132236e-02f, -5.23985140e-02f, -1.23145752e-01f, -4.60906997e-02f, -8.30459893e-02f,
  -6.76263124e-02f, -3.29498425e-02f, -1.05136603e-01f, -2.38426268e-01f, -8.12543482e-02f, -1.17676416e-02f, -4.98323180e-02f, -9.18280408e-02f, -1.36160061e-01f, -1.16753474e-01f,
  -1.53716028e-01f, 5.96707361e-03f, -1.17087118e-01f, -7.01476038e-02f, -3.79148312e-02f, -1.18708955e-02f, -1.64330065e-01f, -1.32582724e-01f, -1.28851071e-01f, -1.51782662e-01f,
  -5.44617295e-01f, -1.59408133e-02f, -1.82603955e-01f, -1.61051869e-01f, -3.18334252e-02f, -1.41183391e-01f, -2.04832722e-02f, -1.66731194e-01f, -1.07588850e-01f, -1.90768600e-01f,
  -1.53059974e-01f, -7.84791261e-02f, -2.55833622e-02f, -2.32384354e-03f, -8.10827240e-02f, 4.41852435e-02f, 9.02667865e-02f, -1.69055477e-01f, -2.70556241e-01f, -1.62985504e-01f,
  1.16447501e-01f, -1.40603602e-01f, -2.56751865e-01f, -1.67635977e-01f, -5.51640689e-02f, -1.02023162e-01f, -1.52389109e-01f, -9.55964252e-02f, -8.32625031e-02f, 2.10776180e-01f,
  2.75865681e-02f, -2.80014634e-01f, -1.33533016e-01f, -1.73283026e-01f, -2.34455898e-01f, -2.19279438e-01f, -1.61037564e-01f, -2.23996937e-01f, -1.13991931e-01f, -1.60518825e-01f,
  -1.36723027e-01f, -1.47299364e-01f, -1.45832002e-01f, -6.51353821e-02f, -1.68956935e-01f, -1.73861489e-01f, -1.79746777e-01f, -1.22630857e-01f, -1.10063359e-01f, -9.57890153e-02f,
  -3.03267147e-02f, -2.14191422e-01f, -1.29839748e-01f, -1.31102234e-01f, -1.14076614e-01f, -1.94532603e-01f, -1.80525154e-01f, -2.81384319e-01f, -2.00451747e-01f, -2.56223343e-02f,
  -1.37413472e-01f, 3.91782261e-02f, 3.38599943e-02f, 4.37558815e-02f, 1.11217976e-01f, 8.14328715e-02f, 5.57106771e-02f, 9.68038812e-02f, 2.36861091e-02f, 2.30325367e-02f,
  -1.27993897e-02f, 5.25035057e-03f, 1.46738822e-02f, -2.12917645e-02f, 1.13273427e-01f, -3.50399278e-02f, -6.33505639e-03f, 1.00974359e-01f, 2.56554708e-02f, 5.55907786e-02f,
  -7.80065544e-03f, 5.92796840e-02f, -7.03976080e-02f, 8.46822560e-02f, -2.19315551e-02f, 7.83672091e-03f, 4.46908027e-02f, -5.86046278e-02f, -2.22242065e-02f, -1.64682104e-04f,
  4.45633270e-02f, -2.44297013e-01f, 2.71050935e-03f, -5.20912185e-02f, -1.41900554e-01f, -8.29121396e-02f, -1.14551067e-01f, -1.11320905e-01f, -1.03654891e-01f, -1.30658403e-01f,
  -1.84284419e-01f, -1.69939905e-01f, -9.70109180e-02f, -8.04458857e-02f, -1.17898934e-01f, -1.70380041e-01f, -4.14326191e-02f, -3.66715007e-02f, -1.10401899e-01f, -1.30912811e-01f,
  -1.04951233e-01f, -4.05074060e-02f, -7.42063969e-02f, -3.75234559e-02f, -1.29669145e-01f, -7.13604614e-02f, 5.23887053e-02f, 2.96352319e-02f, -1.62022009e-01f, 1.40000418e-01f,
  6.70903981e-01f, 8.11889470e-02f, 2.62442082e-02f, 2.45322376e-01f, 6.70280606e-02f, 6.82272539e-02f, -5.91769591e-02f, 2.98989099e-03f, 2.84708887e-01f, 1.66521728e-01f,
  -5.90616316e-02f, -5.13087064e-02f, 5.84886372e-02f, -5.83119467e-02f, 6.13609962e-02f, -4.40813005e-02f, 1.04835995e-01f, 3.63757275e-02f, 8.66610706e-02f, 3.60378474e-02f,
  6.06978498e-02f, 1.25583515e-01f, 1.49912268e-01f, 6.02599904e-02f, 1.46348983e-01f, 2.04869658e-01f, -3.24380472e-02f, -1.92219876e-02f, -8.47417712e-02f, 6.96306955e-03f,
  1.43079504e-01f, 1.63841750e-02f, 1.91429943e-01f, 1.49556637e-01f, 5.29626459e-02f, 2.19515681e-01f, 1.43181860e-01f, 1.99676082e-01f, 1.14793189e-01f, 1.88196659e-01f,
  1.46923393e-01f, 1.61892742e-01f, 8.56008828e-02f, 1.52790502e-01f, 6.33209422e-02f, 2.44894758e-01f, 1.31465599e-01f, 1.42366722e-01f, 3.29030491e-02f, 1.25357206e-03f,
  2.18369085e-02f, -6.59402367e-03f, 1.00082286e-01f, 1.13574922e-01f, 3.61185148e-02f, 1.65776655e-01f, 4.95896153e-02f, 5.80192022e-02f, 5.11610284e-02f, 2.96273381e-01f,
  5.43338507e-02f, -5.67114018e-02f, -1.05674103e-01f, -2.86854245e-02f, -2.54017133e-02f, -5.10804728e-02f, -1.15905024e-01f, -4.70462106e-02f, -5.50707988e-02f, 3.87766883e-02f,
  -5.46709970e-02f, -8.53117257e-02f, -1.18309662e-01f, -1.13948146e-02f, -8.33098739e-02f, -6.02169037e-02f, -4.21168320e-02f, -8.40314850e-02f, -9.06151235e-02f, -8.17777961e-02f,
  -6.36005178e-02f, -1.55356809e-01f, -6.33232878e-04f, -1.74198106e-01f, -2.11921528e-01f, -1.38796672e-01f, -5.95616326e-02f, -5.16729765e-02f, -2.41731666e-03f, -5.98807707e-02f,
  2.68317133e-01f, -1.00839600e-01f, 1.84805021e-01f, 2.83864867e-02f, 6.64516911e-02f, 1.37935996e-01f, 1.29317835e-01f, 8.82013217e-02f, -1.03144022e-02f, 9.46033746e-02f,
  1.10043764e-01f, 1.98494926e-01f, 1.00499548e-01f, 7.52199143e-02f, 1.53028384e-01f, 8.97644311e-02f, 1.02149248e-01f, 1.09686129e-01f, -1.07725998e-02f, 1.06398068e-01f,
  1.12791568e-01f, 2.03927577e-01f, 2.80699164e-01f, 1.40865266e-01f, 6.48525357e-02f, 5.40769473e-02f, 1.51773483e-01f, 1.92408606e-01f, 2.37193152e-01f, 3.28394741e-01f,
  -5.12082696e-01f, 5.40581755e-02f, -4.70624924e-01f, -3.89186270e-03f, 3.17120224e-01f, 4.18924168e-02f, 2.44938537e-01f, 3.54941376e-02f, 1.25221416e-01f, -2.55721901e-02f,
  -4.31329198e-02f, -1.18890435e-01f, -1.17092833e-01f, -4.64000478e-02f, -1.85949996e-01f, 5.77894673e-02f, 1.90664917e-01f, -2.39643544e-01f, -2.31910005e-01f, 1.51713595e-01f,
  2.69389868e-01f, 8.10454711e-02f, -9.20230895e-02f, -9.51219499e-02f, 2.00403854e-01f, -4.00455184e-02f, -4.65293927e-03f, 5.47755808e-02f, 1.15284428e-01f, 1.95747931e-02f,
  -3.20832074e-01f, -1.38154671e-01f, 6.64687231e-02f, 1.17209200e-02f, 5.68180569e-02f, -5.18023632e-02f, 2.59860000e-03f, -4.99160849e-02f, 7.68097714e-02f, 2.71603484e-02f,
  -1.54886739e-02f, -5.66681661e-03f, -3.84106375e-02f, 1.87885296e-02f, 8.27501193e-02f, 2.87291408e-02f, -7.66136050e-02f, -1.62753955e-01f, -1.29865035e-01f, -3.48172225e-02f,
  1.60271138e-01f, 7.53052011e-02f, -5.40464781e-02f, 7.13438019e-02f, -1.38132796e-01f, -8.32248405e-02f, -9.99810323e-02f, -7.01071844e-02f, -8.91723260e-02f, 8.50530639e-02f,
  2.05007568e-01f, 2.40469803e-04f, 1.59266684e-02f, 1.65374309e-01f, 8.43599588e-02f, -7.17314892e-03f, 4.28167507e-02f, 1.07831939e-03f, 1.30839907e-02f, 9.61623061e-03f,
  5.09088188e-02f, 6.28897473e-02f, -1.89266503e-02f, 1.75624210e-02f, -1.38989314e-02f, 8.06497559e-02f, -4.79989238e-02f, 5.82975596e-02f, -4.13921587e-02f, 7.44668692e-02f,
  2.14471426e-02f, -5.37960716e-02f, 3.33389565e-02f, 3.07657290e-03f, 2.79175863e-02f, 2.35616416e-02f, -3.97235453e-02f, 7.11224601e-02f, -1.53845344e-02f, -5.41266464e-02f,
  1.34700060e-01f, -1.22560441e-01f, 4.57696840e-02f, -5.06814606e-02f, -5.33183813e-02f, 9.57354961e-04f, -2.93664206e-02f, 5.24768606e-02f, 5.68360873e-02f, -2.18877685e-03f,
  -3.96442823e-02f, -4.51547385e-04f, -2.26048995e-02f, -1.82292461e-02f, 6.88440949e-02f, 1.34848068e-02f, 1.46735296e-01f, -2.40778122e-02f, 2.66785696e-02f, 7.70405680e-02f,
  7.96737522e-02f, 2.30498333e-02f, 4.46052663e-02f, -1.87738426e-02f, 9.64460298e-02f, 5.79028167e-02f, 8.40796158e-02f, -4.31952700e-02f, 2.69030351e-02f, 2.72470057e-01f,
  -3.04734081e-01f, 3.71501356e-01f, 2.34554544e-01f, -4.85918336e-02f, 2.58760422e-01f, 1.88095540e-01f, 3.96374494e-01f, -8.80148336e-02f, -1.07715428e-01f, 2.26830333e-01f,
  -6.54282346e-02f, -2.18468457e-01f, -1.75898567e-01f, -1.58240840e-01f, -1.24492906e-01f, 3.57986629e-01f, 1.89886436e-01f, -1.12870045e-01f, -2.08431527e-01f, -1.54659122e-01f,
  6.15933388e-02f, -6.66982308e-02f, -1.80630580e-01f, -1.65692881e-01f, 2.31156528e-01f, -3.05798706e-02f, 1.92993641e-01f, 1.82808906e-01f, 2.77665079e-01f, 3.73438418e-01f,
  2.64254004e-01f, 1.91296320e-02f, -5.85333928e-02f, -4.90998989e-03f, 8.10230672e-02f, 4.04291600e-02f, 5.35538048e-02f, 1.01520844e-01f, 1.32501116e-02f, -1.92835219e-02f,
  -2.90147234e-02f, 6.74268380e-02f, -3.97205651e-02f, 1.20408013e-02f, 4.09769788e-02f, 1.15032062e-01f, 5.45106363e-03f, -4.19799685e-02f, 4.34942767e-02f, 5.37443087e-02f,
  1.29560575e-01f, 2.52743512e-01f, 1.33087650e-01f, 1.28708154e-01f, 7.49291778e-02f, -7.06750304e-02f, 1.70606613e-01f, 3.49478703e-03f, 7.79716000e-02f, 3.12537074e-01f,
  -8.87416080e-02f, 3.40857613e-03f, 2.53926571e-02f, -2.87209079e-02f, -3.96986417e-02f, -5.80285154e-02f, 3.91799025e-02f, -3.05842049e-02f, -1.12221278e-02f, 4.72645797e-02f,
  -4.70093004e-02f, 6.30487427e-02f, 4.69295010e-02f, -3.09170522e-02f, -4.24410664e-02f, 3.62156294e-02f, 5.89405112e-02f, -3.63729633e-02f, -1.31292604e-02f, -1.63944848e-02f,
  -2.55872179e-02f, 4.10893410e-02f, -1.09595386e-02f, -4.15560305e-02f, -2.24177968e-02f, 2.77944468e-02f, -6.88604079e-04f, -1.45496335e-02f, -6.79183081e-02f, -5.14797680e-02f,
  -3.54895345e-03f, -1.60103545e-01f, 1.26884937e-01f, -2.17804220e-04f, 8.40869993e-02f, 4.26678769e-02f, 6.34207726e-02f, 1.71042196e-02f, 4.15915921e-02f, 5.43719679e-02f,
  1.33064750e-03f, 1.54256793e-02f, 9.85355750e-02f, 1.58140391e-01f, 8.16366002e-02f, 4.03933646e-03f, 6.58625364e-02f, 8.52189437e-02f, 3.69975828e-02f, 6.57505617e-02f,
  -3.07561713e-04f, 1.85398936e-01f, 5.66402860e-02f, 9.41897184e-02f, 1.05807975e-01f, 8.05465356e-02f, 9.79445800e-02f, 1.65069297e-01f, 1.10637397e-01f, 1.92906395e-01f,
  3.73999685e-01f, -2.31756158e-02f, -1.06649041e-01f, 3.66118997e-02f, 5.71334660e-02f, 2.37473056e-01f, 3.82209182e-01f, 1.31556004e-01f, 6.77503124e-02f, 9.40987095e-02f,
  -2.00285360e-01f, -2.15253741e-01f, -1.30137503e-01f, -1.05754584e-01f, 1.24398425e-01f, 2.14911520e-01f, 2.33973905e-01f, 1.72310084e-01f, 8.46998841e-02f, 3.14339176e-02f,
  -4.53662761e-02f, 2.70928047e-03f, 1.07571989e-01f, 1.13142394e-01f, -6.32789731e-02f, -5.29382676e-02f, -5.41667975e-02f, -1.33014843e-01f, -2.85536032e-02f, -8.87497514e-02f,
  -1.78727061e-01f, -3.20531465e-02f, 2.92531066e-02f, -4.11254503e-02f, -1.31482407e-01f, 6.22864328e-02f, 5.08290865e-02f, -2.66453270e-02f, -6.02145121e-03f, -6.14682073e-03f,
  -3.29577774e-02f, -4.16893177e-02f, 1.33295190e-02f, 3.24349962e-02f, 1.83652803e-01f, 7.46381208e-02f, 8.87355581e-02f, 1.43901110e-01f, 9.32617635e-02f, 1.64812375e-02f,
  2.23165862e-02f, -6.77103773e-02f, -2.00798362e-02f, 3.41500752e-02f, 7.59254694e-02f, -3.79975177e-02f, -2.18050815e-02f, -3.40262689e-02f, 8.98467898e-02f, 5.94053380e-02f,
  -1.11752944e-02f, 1.12575904e-01f, -6.54057190e-02f, 3.93916629e-02f, 3.65323504e-03f, -2.25222912e-02f, -6.32761195e-02f, 5.37960092e-03f, 1.08424120e-01f, -7.31513947e-02f,
  5.52311763e-02f, 9.71657485e-02f, -3.16991955e-02f, 2.35564727e-02f, -1.79921519e-02f, -3.45306583e-02f, 7.34997839e-02f, -3.91267128e-02f, -6.82365522e-02f, -1.23408899e-01f,
  -3.98928523e-02f, -4.99027073e-02f, -9.17786509e-02f, -5.15099391e-02f, 1.13511179e-02f, -1.76831093e-02f, 4.20431234e-02f, -2.29693279e-02f, 8.36304575e-02f, -4.71070930e-02f,
  3.71396914e-02f, -1.41599290e-02f, -1.82733107e-02f, 1.86355375e-02f, -4.64486964e-02f, -5.66134527e-02f, -1.40098676e-01f, -4.01196927e-02f, -7.22852573e-02f, -5.53069897e-02f,
  -5.42294458e-02f, 7.30732754e-02f, 2.54223496e-02f, -1.11429691e-01f, 1.42278537e-01f, -6.40239194e-02f, 2.54626013e-02f, -5.58736250e-02f, 7.82018974e-02f, -3.29772756e-02f,
  9.23958644e-02f, 5.85495010e-02f, 9.55434442e-02f, 3.96025255e-02f, -4.14881995e-03f, 9.77203250e-02f, 3.06612290e-02f, 2.95171347e-02f, 1.24628231e-01f, 1.98335797e-01f,
  2.20902979e-01f, -4.59829926e-01f, -2.02827111e-01f, 1.18367568e-01f, -1.28327861e-01f, -5.76353958e-03f, -9.68746096e-02f, 2.22442508e-01f, 1.13409162e-01f, -2.21583664e-01f,
  -3.47094506e-01f, -5.23447245e-02f, -1.99536625e-02f, 4.98272739e-02f, 1.75642386e-01f, -1.38185337e-01f, -1.46324232e-01f, 1.95622936e-01f, 3.69707316e-01f, 2.09246278e-01f,
  3.72578204e-02f, 1.34770274e-01f, 2.26729423e-01f, 1.40824094e-01f, -3.87875177e-02f, 9.80688483e-02f, -2.19743788e-01f, -1.39771312e-01f, -1.72847718e-01f, -2.30669990e-01f,
  -7.25952014e-02f, -1.30817771e-01f, 1.54130191e-01f, -3.40332277e-02f, -5.88964745e-02f, 5.43343425e-02f, -3.39433625e-02f, 9.38962251e-02f, -4.71956208e-02f, -9.24051367e-03f,
  -8.53719860e-02f, -2.70532388e-02f, -1.38828037e-02f, 5.23834564e-02f, -1.43717574e-02f, -5.17519750e-03f, 6.88638724e-03f, 7.02010393e-02f, 3.39284129e-02f, -1.30507007e-01f,
  -1.19118020e-01f, -1.72439903e-01f, -6.43042848e-02f, 3.98843810e-02f, -4.03059199e-02f, -2.09830962e-02f, -8.53328705e-02f, 8.83707255e-02f, 7.70204887e-02f, 1.18737467e-01f,
  4.21825163e-02f, -8.08855444e-02f, -9.79153812e-03f, 1.78013071e-02f, 1.82457622e-02f, -2.06957255e-02f, 2.30022706e-02f, -7.39430785e-02f, 4.84934002e-02f, -2.98298988e-03f,
  -1.24504259e-02f, -6.61694109e-02f, -1.00642694e-02f, -1.77089311e-02f, -5.28285243e-02f, -8.69408622e-02f, -4.34397832e-02f, 1.31283700e-02f, -2.35496145e-02f, -2.26833820e-02f,
  -2.41300482e-02f, 5.95600195e-02f, -7.32766017e-02f, 3.41063999e-02f, -7.87375793e-02f, 5.79894483e-02f, -3.17618862e-04f, -3.12494487e-02f, 1.21822059e-02f, -9.15778726e-02f,
  1.49371415e-01f, -4.68149316e-03f, 7.04969019e-02f, 9.29953605e-02f, 1.25558032e-02f, 2.36600861e-02f, -1.43741379e-02f, 5.52633107e-02f, -2.64278520e-02f, 3.34381722e-02f,
  3.56779471e-02f, 5.43688610e-02f, -3.05628106e-02f, 6.36988208e-02f, 9.67286155e-02f, 1.15005337e-01f, -7.40697458e-02f, 7.57388771e-02f, -9.78724752e-03f, -1.12379063e-02f,
  6.34216517e-02f, 4.89885993e-02f, 1.82220135e-02f, 4.07937579e-02f, 3.43275331e-02f, 1.85564578e-01f, 6.58506528e-02f, 3.77146415e-02f, 5.30461445e-02f, 2.35074699e-01f,
  -2.55711563e-02f, -4.00694460e-02f, -3.01543653e-01f, -1.02716595e-01f, 7.70839304e-02f, 2.25652959e-02f, -2.51960922e-02f, -6.98713064e-02f, -3.94121520e-02f, 3.69634433e-03f,
  1.59862250e-01f, 9.22286436e-02f, 1.92557052e-02f, 4.70250845e-02f, -7.39982352e-02f, -2.30671391e-01f, -2.54566908e-01f, -2.45759368e-01f, -1.47396654e-01f, 6.36044070e-02f,
  1.77564770e-01f, -6.61798120e-02f, -9.98778790e-02f, -1.76271051e-01f, -2.29370281e-01f, -1.42464340e-01f, -2.82668173e-01f, -1.73013076e-01f, -1.12937987e-01f, -3.35453749e-01f,
  -2.75614500e-01f, -1.25490874e-01f, -1.73788086e-01f, 5.90230513e-04f, -1.65332049e-01f, -2.28167847e-01f, -1.08257107e-01f, -1.64142445e-01f, -1.10547774e-01f, -1.94599539e-01f,
  -3.75813730e-02f, -6.23094253e-02f, -1.51837930e-01f, -1.34039119e-01f, -9.96562541e-02f, -1.49416670e-01f, -2.18576491e-01f, -2.35061422e-01f, -2.56416410e-01f, -1.91295624e-01f,
  -1.56142712e-01f, -1.64984763e-01f, -2.66170263e-01f, -1.16689734e-01f, -2.99834430e-01f, -2.10950151e-01f, -2.51197070e-01f, -3.68331254e-01f, -3.37834984e-01f, -3.83007944e-01f,
  -5.89716993e-02f, 3.16492096e-02f, 2.93871965e-02f, 9.34778340e-03f, 1.13722764e-01f, -7.18748430e-04f, 1.05829886e-03f, 8.55060592e-02f, -2.57749259e-02f, 1.41969919e-02f,
  2.97551919e-02f, 8.66610333e-02f, -4.58740480e-02f, -6.42581657e-02f, 7.62224710e-03f, -1.75104700e-02f, 1.34719387e-02f, -4.65288684e-02f, -1.68125127e-02f, 2.93642450e-02f,
  2.38429792e-02f, -1.00283399e-02f, 2.71239039e-02f, -6.26639277e-02f, 3.99919860e-02f, -5.56374714e-02f, 5.54572269e-02f, 6.52012676e-02f, 1.68756302e-02f, 7.77417794e-02f,
  -2.15821475e-01f, 5.83653413e-02f, -2.41788045e-01f, -1.88088074e-01f, -1.38085306e-01f, -1.68370426e-01f, -1.27630889e-01f, -1.62737176e-01f, -5.92290126e-02f, -1.46627963e-01f,
  -1.31353542e-01f, -2.02820644e-01f, -1.38864398e-01f, -9.04234871e-02f, -1.92580372e-01f, -9.51297283e-02f, -6.06090240e-02f, -1.94573313e-01f, -1.56782210e-01f, -8.87050629e-02f,
  -1.64213687e-01f, -2.28826314e-01f, -1.16746671e-01f, -2.03936726e-01f, -1.85784265e-01f, -1.48103356e-01f, -1.89799085e-01f, -2.20679000e-01f, -1.22295760e-01f, -1.67127743e-01f,
  1.76385026e-02f, -2.02966854e-01f, 1.14874095e-01f, -1.95758477e-01f, -3.03625911e-01f, -1.96679160e-01f, -2.81560451e-01f, -2.42923632e-01f, -1.59569636e-01f, -1.64897248e-01f,
  4.18691672e-02f, 6.68982789e-02f, 9.40718725e-02f, 1.25662550e-01f, 5.32874186e-03f, -1.32551596e-01f, -8.02840963e-02f, 7.82534182e-02f, -1.52598310e-03f, -9.84383598e-02f,
  -1.30485192e-01f, -1.04035161e-01f, 1.14592493e-01f, -2.80912500e-02f, -2.20210552e-01f, -2.01830372e-01f, -1.64932936e-01f, -2.63559204e-02f, -8.79603624e-02f, -1.88869417e-01f,
  -8.87882058e-03f, 4.66651767e-02f, -9.35688540e-02f, -4.21278663e-02f, -1.01945363e-01f, -1.25564188e-01f, -1.88471764e-01f, -2.53582187e-02f, -1.15158275e-01f, -1.34382442e-01f,
  -8.29297900e-02f, -6.37383908e-02f, -3.59228253e-02f, -3.09827421e-02f, -6.93157688e-02f, -7.26175159e-02f, 8.07268769e-02f, 9.20032114e-02f, -5.81546277e-02f, -4.06682752e-02f,
  -3.26220654e-02f, -5.69567317e-03f, -8.37178752e-02f, -7.68956989e-02f, -1.06468368e-02f, -3.00531834e-02f, -1.15493484e-01f, -5.85939810e-02f, -8.77412930e-02f, -2.18828753e-01f,
  6.41837856e-03f, 7.15241954e-02f, 1.17920510e-01f, 5.94065115e-02f, 1.81770504e-01f, 8.35467577e-02f, 7.02441633e-02f, 1.29685983e-01f, 8.99154320e-02f, 6.08082525e-02f,
  6.11751191e-02f, 1.00802734e-01f, 4.86577265e-02f, 3.93145196e-02f, 1.83961496e-01f, 1.20946340e-01f, 4.93181981e-02f, 8.05334896e-02f, 1.39408559e-01f, 6.25710264e-02f,
  9.89626050e-02f, 7.52367917e-03f, 1.30013734e-01f, 8.52789655e-02f, 1.81996554e-01f, 1.72610745e-01f, 3.80372852e-02f, 8.45168009e-02f, 1.50603026e-01f, 1.16112441e-01f,
  -3.75367433e-01f, 7.49412701e-02f, -1.94187745e-01f, -6.89312592e-02f, -1.92262769e-01f, -1.50251046e-01f, -7.78761283e-02f, -4.84240092e-02f, -1.06075518e-01f, -1.22084148e-01f,
  -4.20602150e-02f, -1.14723928e-01f, -8.66620615e-02f, -1.52029559e-01f, -2.15239048e-01f, -1.65308952e-01f, -1.58220410e-01f, -1.52239159e-01f, -7.54227042e-02f, -1.80439383e-01f,
  -1.98276252e-01f, -3.00375372e-01f, -2.26032645e-01f, -2.96294093e-01f, -2.14760974e-01f, -1.64851695e-01f, -2.63322473e-01f, -3.02362561e-01f, -1.80693194e-01f, -3.92026722e-01f,
  -2.77988672e-01f, -4.91014183e-01f, 2.74532735e-01f, -2.53990263e-01f, 1.32544592e-01f, 4.14461046e-01f, 2.90243745e-01f, 5.78212850e-02f, -2.09967598e-01f, -9.75800902e-02f,
  -6.57988945e-03f, 5.72517626e-02f, -3.83467674e-02f, 1.12001963e-01f, 1.63464278e-01f, -9.19144601e-03f, 7.18672052e-02f, 1.43834189e-01f, 3.86651456e-01f, 2.93229491e-01f,
  -3.22558638e-03f, -2.43280008e-01f, -2.29229182e-01f, -8.76838490e-02f, -1.52246401e-01f, -7.88580999e-02f, -9.17095542e-02f, -1.23593025e-01f, 8.94506723e-02f, -2.26283461e-01f,
  1.46259442e-01f, 5.84876463e-02f, 1.23912953e-01f, -7.85965174e-02f, -3.45523581e-02f, -3.53147201e-02f, 3.54660824e-02f, -1.50350958e-01f, 2.29911935e-02f, -1.10323884e-01f,
  -9.66166630e-02f, -5.75877503e-02f, 7.12248161e-02f, 4.27378640e-02f, -3.55034098e-02f, -5.27235083e-02f, -1.51003197e-01f, 2.22154222e-02f, -5.08883074e-02f, 9.91943032e-02f,
  -2.86945980e-02f, 4.76804562e-02f, 1.79379523e-01f, 3.88569497e-02f, 2.07364410e-01f, 9.41384733e-02f, 3.62334251e-02f, 3.68170068e-02f, 1.54643431e-01f, -2.22526655e-01f,
  5.17108552e-02f, 1.80852897e-02f, 5.80290183e-02f, 1.49958469e-02f, -1.77736487e-02f, -2.33467557e-02f, 2.91361753e-02f, 4.58266176e-02f, 8.78365412e-02f, -1.69592649e-02f,
  -2.22224165e-02f, 3.18430178e-02f, 2.74121743e-02f, -4.86956090e-02f, -4.78515774e-02f, 4.34296429e-02f, 1.13048516e-01f, -1.11138016e-01f, 4.63633332e-03f, 2.74106786e-02f,
  1.70512646e-02f, 8.14427808e-02f, 1.35672670e-02f, 8.13648924e-02f, -2.39497721e-02f, 1.10050216e-01f, -1.66252546e-03f, 5.78778200e-02f, -5.49228862e-02f, -2.28323303e-02f,
  -1.73808873e-01f, 1.80877402e-01f, -1.01297110e-01f, 8.68156902e-04f, -4.60566580e-03f, 1.94694437e-02f, 1.31285493e-03f, 8.84012133e-02f, -4.15186659e-02f, 7.26944283e-02f,
  5.39634451e-02f, 8.93403962e-02f, -7.96166528e-03f, -1.09177396e-01f, 8.44164044e-02f, 7.11229518e-02f, -8.73982459e-02f, 3.01410872e-02f, 4.77010943e-02f, -4.39361446e-02f,
  -9.96117517e-02f, 1.60929561e-02f, 6.63795471e-02f, 8.67751539e-02f, 1.02623343e-01f, 8.64322931e-02f, 8.80945548e-02f, 4.38292585e-02f, 1.33774117e-01f, -2.35258386e-01f,
  1.18383564e-01f, -5.21860003e-01f, 1.91048789e-03f, -5.11827841e-02f, -5.69586083e-02f, 7.64752775e-02f, -3.11761759e-02f, 9.72676501e-02f, 1.76702961e-02f, -2.67365813e-01f,
  -1.77979663e-01f, -1.31920783e-03f, -1.01040326e-01f, 1.90989934e-02f, 1.83227554e-01f, -8.04500803e-02f, 4.00149897e-02f, 2.78633446e-01f, 4.24334496e-01f, 2.10169643e-01f,
  -1.96806053e-04f, 2.64393594e-02f, 7.60119781e-02f, 8.47741440e-02f, -1.47655442e-01f, -5.70787862e-02f, -1.28671318e-01f, -1.89570829e-01f, -8.97880271e-02f, -1.90943599e-01f,
  -1.10641375e-01f, -7.22840577e-02f, 2.42887616e-01f, 3.31973806e-02f, -6.80398867e-02f, 2.96404939e-02f, 6.62238896e-02f, -9.55556110e-02f, 3.91120911e-02f, -5.01129515e-02f,
  5.90082407e-02f, 1.02664322e-01f, 6.73342869e-02f, 1.10911867e-02f, 2.52717938e-02f, -2.67025977e-02f, 1.49354581e-02f, 5.61826639e-02f, 8.50825906e-02f, -6.71078712e-02f,
  -1.40240759e-01f, -6.37133643e-02f, -8.39913711e-02f, 4.80050519e-02f, -5.25906333e-04f, 1.11763932e-01f, -8.85155573e-02f, -4.29087952e-02f, 1.39720336e-01f, -1.41097844e-01f,
  -1.47318216e-02f, -3.98545116e-02f, 8.82273689e-02f, 1.61329806e-02f, 2.97624767e-02f, 1.02475043e-02f, 8.52151215e-02f, 3.13397981e-02f, 1.15080237e-01f, -1.44018820e-02f,
  5.07780872e-02f, 1.57227479e-02f, 2.61697341e-02f, 1.09847551e-02f, -4.93069068e-02f, 2.01364420e-02f, 4.85109091e-02f, 8.69119260e-03f, 9.36332904e-03f, 1.96089540e-02f,
  2.87781395e-02f, 2.98201814e-02f, -5.15287220e-02f, 1.60745382e-02f, 3.76825593e-02f, 4.35850434e-02f, 1.69867501e-02f, -1.31097827e-02f, 2.79755648e-02f, 6.35637790e-02f,
  -2.17196122e-01f, 1.73485562e-01f, 6.27057329e-02f, 1.03057303e-01f, -5.40039362e-03f, 7.90902004e-02f, -6.28077313e-02f, 5.24539314e-02f, -2.05723438e-02f, 2.52352580e-02f,
  6.01214953e-02f, 3.28893363e-02f, -2.58161090e-02f, 3.70995365e-02f, 1.71386287e-01f, 8.78870785e-02f, -7.11598899e-03f, -3.33182290e-02f, 5.72852828e-02f, -2.20235679e-02f,
  -6.70031384e-02f, 4.84403409e-02f, -2.59493734e-03f, -5.58732972e-02f, 5.87819070e-02f, 1.95346579e-01f, 5.57030179e-02f, -1.97807848e-02f, 1.28321156e-01f, -1.82974845e-01f,
  -3.81418049e-01f, 4.17355925e-01f, -3.78005691e-02f, -1.02169730e-01f, 5.35289943e-02f, 9.59507190e-03f, 2.97578663e-01f, -5.82253039e-02f, -2.31541678e-01f, 2.02084437e-01f,
  -3.74651290e-02f, -2.05947772e-01f, -1.97917759e-01f, -5.04657067e-02f, -8.28974247e-02f, 3.07061523e-01f, 2.19712287e-01f, -9.82848927e-02f, -4.27589238e-01f, -2.64841706e-01f,
  9.63984728e-02f, 8.07960629e-02f, -1.86220825e-01f, -6.65017366e-02f, 1.53720975e-01f, -1.93264186e-01f, 1.91464543e-01f, 1.08841091e-01f, 4.92789112e-02f, 2.38075003e-01f,
  1.81993190e-02f, 3.20520476e-02f, -1.82111189e-01f, -3.68364155e-02f, 2.97975894e-02f, -1.90902073e-02f, -1.15674464e-02f, -4.67094146e-02f, -8.35074112e-03f, 1.87458731e-02f,
  8.15813150e-03f, -5.32193258e-02f, 8.49028230e-02f, 3.34968716e-02f, -6.16221502e-02f, -7.23681897e-02f, 6.30451813e-02f, 1.42938027e-03f, -5.59867024e-02f, 1.37117431e-02f,
  6.21878318e-02f, 5.39357290e-02f, 1.00349806e-01f, -4.32115346e-02f, 1.49375126e-02f, 2.93042623e-02f, -2.82034110e-02f, -1.07570589e-01f, -1.16450347e-01f, -3.42957824e-02f,
  -4.33252901e-02f, 1.57678016e-02f, 2.69659646e-02f, 1.49443261e-02f, 2.79506221e-02f, 1.79934204e-02f, 6.30335733e-02f, 3.20227630e-02f, 3.57673168e-02f, 3.32089178e-02f,
  6.28010696e-03f, 7.11370865e-03f, 6.34504855e-03f, 3.72767933e-02f, -2.16803793e-02f, 7.58971274e-02f, 6.72298595e-02f, 9.86824334e-02f, 6.22695014e-02f, 1.13419956e-02f,
  4.33313921e-02f, 2.79600993e-02f, -3.06274579e-03f, 4.83369678e-02f, 1.13571286e-01f, 4.31829169e-02f, 2.85762572e-03f, 4.84399088e-02f, -1.01408614e-02f, 1.46575794e-01f,
  -1.01679154e-01f, 8.95218030e-02f, 8.73933956e-02f, 1.80011876e-02f, 7.20658666e-03f, 6.47205161e-03f, -6.26594871e-02f, 4.46142047e-04f, 4.30415459e-02f, 1.91861913e-02f,
  1.37129854e-02f, -6.23234808e-02f, 5.06499782e-02f, -2.76447684e-02f, -8.39322135e-02f, 2.21327897e-02f, 1.10792793e-01f, -7.47634517e-03f, -7.71667883e-02f, -6.54373923e-03f,
  7.99796507e-02f, -1.06905453e-01f, -1.24238566e-01f, -5.15983105e-02f, 6.14700317e-02f, -7.36209005e-02f, 3.83359231e-02f, 2.21802797e-02f, -7.74218664e-02f, -2.48503126e-02f,
  -6.00717902e-01f, 1.77517071e-01f, -9.47853327e-02f, -1.96103334e-01f, 5.55308238e-02f, -2.98545286e-02f, -1.27742318e-02f, -7.83064663e-02f, 3.26461643e-02f, 4.57340218e-02f,
  1.92443371e-01f, 1.59734979e-01f, 5.99519946e-02f, -8.24922137e-03f, -1.69261768e-01f, 5.94067276e-02f, -8.75143055e-03f, -1.43973067e-01f, -2.24279672e-01f, -5.92686981e-02f,
  1.83051884e-01f, 1.25824660e-02f, -3.17738473e-01f, -1.78780198e-01f, 8.96869972e-02f, 4.60553616e-02f, 9.44195762e-02f, -3.14517207e-02f, 1.92389175e-01f, 1.87817156e-01f,
  1.67933419e-01f, -7.04004467e-02f, -1.07217737e-01f, -5.40720187e-02f, -1.13039114e-01f, -1.49386346e-01f, -1.61554024e-01f, -1.71705976e-01f, -1.06440000e-01f, -7.27403313e-02f,
  5.40805906e-02f, -1.35109335e-01f, -1.39772639e-01f, 2.14112774e-02f, -1.19542003e-01f, -1.04123928e-01f, -1.55289054e-01f, -1.45562917e-01f, -1.43520162e-01f, -6.89443350e-02f,
  3.11226342e-02f, -4.67769764e-02f, -1.87230825e-01f, -6.12205155e-02f, -1.15538217e-01f, -1.17886469e-01f, -1.19250529e-01f, -1.43552599e-02f, -1.44936830e-01f, -2.07163393e-02f,
  1.73516363e-01f, 1.27759129e-01f, 1.87208608e-01f, 9.38597992e-02f, 2.06562459e-01f, 4.78561334e-02f, 1.83173835e-01f, 1.60259113e-01f, 1.26329646e-01f, 2.37861928e-02f,
  1.85503766e-01f, 7.29228333e-02f, 1.27736315e-01f, 1.49451688e-01f, 2.07712159e-01f, 9.30073857e-02f, 1.99130327e-01f, 2.45832622e-01f, 9.79083255e-02f, 1.92753702e-01f,
  1.90205589e-01f, 8.09023604e-02f, 1.34041086e-01f, 1.66030198e-01f, 6.42276183e-02f, 8.57995749e-02f, 1.34481594e-01f, 2.32527509e-01f, 1.22851789e-01f, 1.22016877e-01f,
  7.03407153e-02f, -1.57126009e-01f, 5.24497405e-02f, -5.42604849e-02f, -7.29470104e-02f, -1.18876942e-01f, 4.35058959e-02f, -3.76523547e-02f, 3.82016897e-02f, 7.92777315e-02f,
  -1.12193607e-01f, -5.58484159e-02f, 2.07941234e-03f, -4.08857502e-02f, -1.62468746e-01f, -7.83744454e-02f, -6.78149983e-02f, -2.45200451e-02f, -2.33089887e-02f, 1.56203341e-02f,
  -4.22311900e-03f, -1.43678471e-01f, 5.98406000e-03f, 2.29407735e-02f, -1.05447220e-02f, -2.68031228e-02f, 8.35040063e-02f, 3.03586554e-02f, -9.01572704e-02f, -8.22556615e-02f
};

// L0_fan_Wp_bar (Shape: 14 x 120)
const int L0_fan_Wp_bar_rows = 14;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -9.22690630e-01f, -1.39317811e-01f, 1.55732244e-01f, -4.57087308e-01f, -4.24203202e-02f, 2.27769583e-01f, 6.93857437e-03f, -2.63655744e-02f, 3.20025422e-02f, -5.28989919e-02f,
  -6.16151877e-02f, -2.30298504e-01f, -2.44044960e-01f, -2.08547592e-01f, -3.59576225e-01f, -1.68468520e-01f, -3.68471056e-01f, -4.41495240e-01f, -3.35498720e-01f, 1.18630052e-01f,
  -2.68946260e-01f, -6.33928418e-01f, -6.25667274e-01f, -2.98781097e-01f, -8.47551599e-02f, -3.79223287e-01f, -2.01235220e-01f, -1.55166522e-01f, 2.50910342e-01f, -2.90342927e-01f,
  1.39209956e-01f, 1.93912983e-01f, -9.16549191e-02f, -1.13221288e-01f, -8.90270919e-02f, -5.81213310e-02f, -5.77373430e-02f, -3.94891612e-02f, -1.21122571e-02f, 8.47899076e-03f,
  -8.65199268e-02f, 5.01960665e-02f, -2.00275570e-01f, 8.42115730e-02f, -1.16278879e-01f, 1.10847000e-02f, 7.22710267e-02f, 1.22504756e-01f, 5.34585193e-02f, 2.87755430e-01f,
  1.23652004e-01f, 7.63821751e-02f, 8.84775594e-02f, 2.07486629e-01f, 1.95601270e-01f, 2.63866223e-02f, 1.76598355e-01f, 2.75704116e-01f, 2.44045213e-01f, 7.08835497e-02f,
  -1.16327368e-01f, 2.24481970e-02f, 5.69055229e-02f, 5.04131988e-02f, 2.64535975e-02f, 2.11392958e-02f, -1.07742541e-01f, 1.22256167e-02f, -1.05653349e-02f, -1.39773965e-01f,
  -2.33399842e-04f, 1.95753306e-01f, 1.45028261e-02f, -6.30139038e-02f, -2.40388568e-02f, 3.67943496e-02f, 2.06803065e-02f, 3.05692274e-02f, -1.16413580e-02f, 6.28024980e-04f,
  1.62631348e-02f, 8.66304487e-02f, 9.82048959e-02f, 7.29896650e-02f, 1.46397963e-01f, -4.62367833e-02f, 1.56681284e-01f, 1.60696611e-01f, -2.66999919e-02f, 1.76539257e-01f,
  -2.84020901e-01f, -8.52514878e-02f, -3.56176108e-01f, -1.03730364e-02f, 3.83887775e-02f, 8.84210393e-02f, 1.17527014e-02f, -2.63375472e-02f, -7.10200071e-02f, 1.02078214e-01f,
  2.29393587e-01f, -8.18291456e-02f, -9.88342091e-02f, 2.46551409e-02f, -1.33054808e-01f, -2.35038903e-02f, -6.48961812e-02f, -1.73674166e-01f, 1.12079009e-01f, 1.63549170e-01f,
  1.11290738e-01f, 1.03729097e-02f, -1.23784199e-01f, -7.49680549e-02f, 1.51075602e-01f, -1.86664015e-01f, -1.56249270e-01f, -6.37129843e-02f, -4.76509184e-02f, -3.50919574e-01f,
  8.93500209e-01f, -2.64028221e-01f, -7.49068916e-01f, -7.14678541e-02f, -6.86666906e-01f, -3.18793893e-01f, -4.42470223e-01f, -2.82679573e-02f, -9.53000858e-02f, -4.85690385e-01f,
  5.43001816e-02f, 5.35178483e-01f, 4.20515686e-01f, 2.68871218e-01f, 6.07331216e-01f, -6.00553751e-01f, -4.41751659e-01f, 1.22714989e-01f, 4.02721494e-01f, -7.57437050e-02f,
  8.81810300e-03f, 1.64134994e-01f, 5.79632103e-01f, 1.73247457e-01f, -2.97433436e-01f, -1.01464121e-02f, -6.62487030e-01f, -2.84243494e-01f, -3.06205988e-01f, -5.31052232e-01f,
  -2.39376083e-01f, -1.49515361e-01f, -1.19685248e-01f, 2.28936389e-01f, -5.75079247e-02f, 2.29888439e-01f, 1.14468196e-02f, -1.18170664e-01f, 1.39007598e-01f, 3.40778977e-02f,
  1.14452746e-02f, 9.16495100e-02f, 2.04903498e-01f, -2.10182872e-02f, -1.03638291e-01f, 2.40267403e-02f, -1.11637652e-01f, 6.87972978e-02f, 5.22789024e-02f, -1.33264139e-01f,
  8.76948312e-02f, -4.99123000e-02f, -2.95444764e-02f, -6.82361200e-02f, 2.50391383e-02f, 9.10052434e-02f, -2.85264224e-01f, -1.24505125e-01f, -1.52046561e-01f, -3.30302238e-01f,
  -2.58898363e-02f, -4.66807783e-02f, -4.58377600e-02f, -3.90804224e-02f, 8.28771368e-02f, 1.99923050e-02f, 4.90924306e-02f, -4.62614223e-02f, -5.56203239e-02f, 3.98503467e-02f,
  -5.18190302e-02f, -1.15817055e-01f, 5.15284464e-02f, -1.45932091e-02f, 2.84730084e-02f, 1.47800418e-02f, 3.93231995e-02f, 1.47755807e-02f, -7.53042474e-02f, 7.78736472e-02f,
  1.21079311e-01f, -3.36180255e-02f, 7.15734763e-03f, 1.00625642e-02f, -2.84876674e-02f, 5.17293438e-02f, 6.78716451e-02f, 4.80809361e-02f, 1.33667002e-03f, 2.06726044e-02f,
  2.91552812e-01f, 1.41674429e-01f, -3.00593283e-02f, -4.62366305e-02f, -1.58408266e-02f, -1.04925126e-01f, -1.03235714e-01f, -1.05739810e-01f, 5.06037511e-02f, -7.62370974e-02f,
  6.26675561e-02f, 7.93938413e-02f, -3.59908901e-02f, -6.83609396e-02f, -1.03760615e-01f, 5.62156290e-02f, -2.15891525e-02f, 5.55423498e-02f, -3.36924717e-02f, -2.41554871e-01f,
  -2.35866793e-02f, 1.89424716e-02f, 2.11859524e-01f, 6.72557428e-02f, -2.87780538e-02f, 1.75824836e-01f, -6.32597357e-02f, -1.44006893e-01f, 2.12071911e-01f, -3.50267044e-03f,
  -9.61800039e-01f, -2.32070938e-01f, 2.07243010e-01f, -8.16140890e-01f, 1.28722712e-01f, 3.50892782e-01f, 1.12192586e-01f, -1.94484517e-01f, -4.86751258e-01f, -2.04403579e-01f,
  2.05360293e-01f, 1.41687766e-01f, -4.12740000e-02f, 1.70618847e-01f, 2.53547817e-01f, 1.31849244e-01f, -1.84103493e-02f, 7.08070248e-02f, 2.56448150e-01f, 4.08558488e-01f,
  2.63775468e-01f, -1.56027526e-01f, -1.04154363e-01f, 8.86861756e-02f, -3.64319414e-01f, -3.57644781e-02f, -1.55295923e-01f, -4.48655151e-02f, 3.41452032e-01f, -4.00835723e-01f,
  -1.75048992e-01f, -4.55356210e-01f, 3.89050394e-01f, 1.08140483e-01f, 6.34601936e-02f, -1.40933678e-01f, -1.05127349e-01f, -1.82243749e-01f, -6.58244640e-02f, -1.89966634e-01f,
  -1.30540147e-01f, 3.69867533e-01f, -2.32842758e-01f, -1.43191672e-03f, -2.43627593e-01f, -2.64479853e-02f, 4.62551825e-02f, 3.74375135e-02f, -2.67570257e-01f, -1.08847776e-02f,
  8.01202655e-02f, 1.23994395e-01f, -3.04321915e-01f, 5.79765886e-02f, -8.61163661e-02f, -5.30769788e-02f, -4.39538807e-02f, -1.46503389e-01f, -2.85040848e-02f, -7.35224664e-01f,
  -5.28057441e-02f, 2.01711860e-02f, 1.39197499e-01f, -9.69509110e-02f, -3.41155268e-02f, -3.41027626e-03f, 4.71984334e-02f, -2.23470461e-02f, 6.51291059e-03f, -1.13013439e-01f,
  6.36992082e-02f, -8.08909088e-02f, 1.42689701e-02f, -9.98869911e-02f, -4.35119048e-02f, -4.29938920e-02f, -3.20662521e-02f, -6.88862354e-02f, 6.51065633e-02f, -3.35290134e-02f,
  1.41726926e-01f, -1.60340995e-01f, -9.50855091e-02f, -9.31301638e-02f, 1.59786731e-01f, -4.05847281e-03f, 2.28344779e-05f, 1.00639232e-01f, -1.25736371e-01f, -1.21845296e-02f,
  -2.84281105e-01f, 6.02147341e-01f, -2.38373131e-01f, 2.65633166e-02f, -1.05271697e-01f, 2.89097503e-02f, -2.05902383e-01f, 4.40637469e-02f, -1.00179076e-01f, -1.89751416e-01f,
  1.04825664e-02f, -2.69188106e-01f, -1.26478136e-01f, 2.43206844e-02f, -1.65358007e-01f, -5.27693518e-02f, -1.32012546e-01f, 4.65611182e-02f, -1.35404719e-02f, -1.85903370e-01f,
  -2.30803430e-01f, -1.48831636e-01f, -4.48103160e-01f, -3.21924448e-01f, -3.87466133e-01f, -3.08106720e-01f, -3.32134783e-01f, -8.85091722e-02f, -1.61220491e-01f, -6.64931417e-01f,
  1.28972903e-01f, 1.99945942e-01f, -3.85646112e-02f, 2.96054184e-01f, 3.96443933e-01f, -2.75788218e-01f, -7.30053961e-01f, -4.92707670e-01f, 1.70655981e-01f, -1.07337825e-01f,
  1.44343138e-01f, 2.34616131e-01f, -5.17694578e-02f, -3.79343987e-01f, -1.02535701e+00f, -4.88014638e-01f, -4.73306000e-01f, -6.86599135e-01f, -7.68270671e-01f, -2.53593892e-01f,
  -1.07600719e-01f, -1.85064644e-01f, -4.97417927e-01f, -2.64506489e-01f, 4.18139935e-01f, 2.04759851e-01f, 2.98618972e-01f, 1.63228378e-01f, 2.11475626e-01f, 4.13259774e-01f,
  1.49656549e-01f, -2.51248311e-02f, -7.46514241e-04f, 5.74268401e-02f, 2.24200279e-01f, 7.89390653e-02f, -4.91154045e-02f, 9.42302286e-04f, 1.08556479e-01f, -1.91342965e-01f,
  2.80454755e-01f, 2.16937542e-01f, 1.31442130e-01f, 1.29129216e-01f, -1.16017357e-01f, -9.89663675e-02f, -2.74886936e-01f, -3.08264762e-01f, -2.89736122e-01f, -7.58573413e-02f,
  -1.08843096e-01f, -2.76801456e-02f, -3.05509627e-01f, -2.84911126e-01f, -1.20464809e-01f, -1.63584407e-02f, -1.06051460e-01f, 6.62831366e-02f, -1.64057896e-01f, 2.86370844e-01f,
  5.42834587e-02f, -4.24673818e-02f, 2.50389185e-02f, -7.22933039e-02f, -1.26393244e-01f, 1.58830196e-01f, 4.74811494e-02f, -6.64445013e-02f, -8.48966017e-02f, -4.62352000e-02f,
  7.20471591e-02f, -5.67459501e-03f, -1.00000478e-01f, 8.48340453e-04f, 5.18075153e-02f, -6.20824471e-02f, 1.42325044e-01f, -1.18979156e-01f, -1.27732366e-01f, 6.43561780e-02f,
  -1.99635610e-01f, 4.31475006e-02f, 4.04732265e-02f, -9.52963158e-02f, 4.07871008e-02f, 3.01026199e-02f, 4.11699489e-02f, -2.43383814e-02f, -4.72717211e-02f, 2.13710945e-02f,
  1.48592189e-01f, -2.57911116e-01f, 1.96056843e-01f, -1.52972028e-01f, -3.64087187e-02f, 7.83221796e-02f, 1.19236730e-01f, -4.09637094e-02f, 1.87482238e-01f, -2.05466315e-01f,
  -4.85396199e-03f, 9.50143412e-02f, 2.77784407e-01f, 2.06006896e-02f, -5.39243221e-02f, 5.99737018e-02f, -2.33604386e-03f, 4.38295826e-02f, -2.30561092e-01f, 3.23241681e-01f,
  -1.55942991e-01f, -2.24294379e-01f, -2.51258314e-01f, -5.09806536e-02f, 2.95631904e-02f, -1.07479520e-01f, -1.12228200e-01f, 6.19416907e-02f, -3.29874754e-01f, -5.71751297e-02f,
  2.07288250e-01f, -1.96504127e-02f, 2.79832184e-01f, -5.48600964e-02f, -3.21844727e-01f, -4.53210056e-01f, -6.09163165e-01f, -3.13443542e-01f, -1.04774676e-01f, 6.99196151e-03f,
  -3.48273516e-01f, -8.44206885e-02f, 1.49794683e-01f, 1.04109891e-01f, -1.64300501e-02f, 2.15834215e-01f, 4.46128219e-01f, 4.06919271e-01f, -7.85788447e-02f, -3.53662759e-01f,
  -3.90165225e-02f, 3.90027612e-02f, 1.81669176e-01f, 6.58299699e-02f, 6.90218955e-02f, -2.18850940e-01f, 2.74356425e-01f, 1.18988700e-01f, 6.43420666e-02f, 6.03437603e-01f,
  2.38366470e-01f, 1.98181897e-01f, -4.85820733e-02f, 9.62634385e-02f, 1.24459267e-01f, 7.81313479e-02f, 2.14530155e-02f, 3.69158417e-01f, 1.11441419e-01f, 1.73762828e-01f,
  9.43855047e-02f, 8.28287452e-02f, 7.89339766e-02f, 6.85023218e-02f, -1.04353227e-01f, -5.74011654e-02f, 1.64279953e-01f, 2.62343943e-01f, 3.03042889e-01f, 6.70310855e-02f,
  -3.37734595e-02f, -3.82080764e-01f, -1.43677905e-01f, -1.76063702e-01f, 4.18265983e-02f, 6.10752739e-02f, -2.07619250e-01f, -8.03915039e-02f, -3.04733396e-01f, 1.03414170e-01f,
  -7.46525452e-02f, 1.43899322e-01f, 1.93085283e-01f, 1.03184372e-01f, -8.83290693e-02f, 5.73646426e-02f, 1.13031432e-01f, -1.21949971e-01f, 1.73449435e-03f, 2.15114169e-02f,
  -6.88442811e-02f, -5.59883453e-02f, 3.58097702e-02f, -7.81971216e-02f, -5.11156470e-02f, -1.83264725e-02f, -1.10078447e-01f, -6.37777969e-02f, -1.58626840e-01f, 5.30558154e-02f,
  -5.60405292e-02f, 2.31730361e-02f, 5.92979193e-02f, -6.94946200e-02f, -3.65442261e-02f, 1.29964650e-01f, 5.46714552e-02f, 3.36468522e-03f, -2.12236922e-02f, -4.65043448e-02f,
  -2.33986080e-01f, 5.82757071e-02f, -1.06516005e-02f, 1.70289129e-01f, 1.18444208e-02f, -1.81943048e-02f, 2.16740035e-02f, -6.46585152e-02f, 3.02887633e-02f, -1.25495540e-02f,
  -1.64443910e-01f, -2.31368765e-02f, 1.00053549e-01f, -1.00466043e-01f, -2.62000382e-01f, -2.50745773e-01f, -1.10765174e-01f, -2.04255134e-01f, -8.05151686e-02f, -1.13918176e-02f,
  -4.35787812e-02f, -5.59523463e-01f, -5.63827276e-01f, -3.84472013e-01f, -2.92131692e-01f, -5.22160232e-01f, -2.27215260e-01f, -2.90966570e-01f, -6.00721776e-01f, -6.66651428e-01f,
  -4.12239641e-01f, 6.50742948e-01f, -2.40307022e-03f, -1.74583241e-01f, 2.04443589e-01f, 3.36177766e-01f, 7.38298953e-01f, 2.08585888e-01f, -1.84001863e-01f, 1.42876387e-01f,
  9.58743170e-02f, -2.73989767e-01f, -1.68109193e-01f, -3.53147686e-02f, 7.44802579e-02f, 3.61320496e-01f, 1.51886180e-01f, -2.56597787e-01f, -2.74201483e-01f, -9.02076885e-02f,
  7.36597693e-03f, -1.43458694e-02f, -2.25424826e-01f, -1.31848827e-01f, 8.89223069e-02f, -1.66779950e-01f, 2.20565796e-01f, 2.13283300e-01f, 2.69398153e-01f, -2.26669475e-01f,
  -2.19374403e-01f, 2.80132592e-01f, -3.58210266e-01f, -1.00393742e-01f, 7.59382620e-02f, -2.20496491e-01f, -7.55820423e-02f, -8.92203748e-02f, 7.72587722e-03f, -7.71985762e-03f,
  5.53517006e-02f, 7.80697763e-02f, 2.38175139e-01f, 1.14617191e-01f, 1.71389073e-01f, 7.62559697e-02f, -1.65860541e-02f, -3.33370198e-03f, -8.52958038e-02f, -6.95558563e-02f,
  1.01738550e-01f, 3.54279131e-02f, 2.16010168e-01f, 1.42599076e-01f, 8.98070931e-02f, -2.49595702e-01f, 7.24975914e-02f, -7.46306553e-02f, -5.56395911e-02f, -2.49060005e-01f,
  -2.59383857e-01f, -5.43094091e-02f, 1.28960207e-01f, -6.96408227e-02f, 1.84672826e-03f, -5.81266247e-02f, -3.69883813e-02f, 9.01615918e-02f, 9.50171202e-02f, 8.67262855e-03f,
  2.76524033e-02f, -1.02462396e-01f, -3.15713510e-02f, -4.15167324e-02f, -1.22673273e-01f, 3.83938812e-02f, 1.12805791e-01f, -6.82566687e-02f, 7.82145038e-02f, 9.40418094e-02f,
  -5.82220480e-02f, 6.04485087e-02f, 1.32441102e-02f, 3.21651846e-02f, -2.21971935e-03f, -9.65171903e-02f, -1.07094258e-01f, 4.92827641e-03f, -1.26856700e-01f, -8.20946395e-02f,
  -6.55863434e-02f, 1.97109759e-01f, -2.59152025e-01f, -6.74649030e-02f, 4.03767340e-02f, 4.34438251e-02f, -5.14364764e-02f, -1.08303793e-01f, 9.85209122e-02f, -5.96714532e-03f,
  1.76310569e-01f, -1.72440976e-01f, 1.57907441e-01f, 4.42528091e-02f, -1.73388943e-01f, -8.34365711e-02f, -5.65081984e-02f, 5.53337149e-02f, 6.09222502e-02f, -4.53152470e-02f,
  -1.87272783e-02f, -1.26659557e-01f, -2.39100322e-01f, -6.62194490e-02f, -2.48011336e-01f, -3.27854633e-01f, -4.16349210e-02f, -1.46093026e-01f, 3.37542780e-02f, -1.67571425e-01f,
  -4.16943789e-01f, 2.89766252e-01f, -3.46434653e-01f, 4.33626890e-01f, 1.46050319e-01f, 4.06872965e-02f, 5.75498752e-02f, 3.99230234e-02f, 3.06120485e-01f, 2.21498892e-01f,
  -1.08143538e-01f, 3.00830901e-01f, 9.72831547e-02f, 1.85421735e-01f, 1.18455207e-02f, 2.08130151e-01f, 3.81794900e-01f, -3.15664671e-02f, -9.91303325e-02f, 9.39774960e-02f,
  3.94786745e-01f, 1.30950332e-01f, -6.28901199e-02f, 1.08067296e-01f, 2.18698725e-01f, 1.94628656e-01f, 6.89448044e-02f, 1.95793927e-01f, 2.83811986e-02f, 5.37188053e-01f,
  -6.20012105e-01f, -6.52449057e-02f, 1.95101187e-01f, 7.36045688e-02f, -2.22743019e-01f, 8.61593802e-03f, 4.02306579e-03f, 3.91186066e-02f, 3.93824046e-03f, 1.14866076e-02f,
  -1.05226515e-02f, -4.95092608e-02f, 2.15593427e-01f, -3.76112908e-02f, 3.08549125e-02f, -8.19104314e-02f, -2.66108718e-02f, -3.99864130e-02f, -2.41424218e-01f, -2.41010711e-01f,
  3.25978667e-01f, 1.49329484e-01f, -3.01497251e-01f, -4.72307727e-02f, -1.65020823e-01f, -4.42690812e-02f, -2.08880290e-01f, -5.38160428e-02f, -4.49246019e-01f, -4.69821692e-03f,
  2.08626807e-01f, -1.60721391e-01f, -7.30236918e-02f, 1.74236540e-02f, 2.01671440e-02f, 7.29471892e-02f, 9.42573547e-02f, -8.30992125e-03f, 2.25878088e-03f, 5.57823153e-03f,
  -8.64430238e-03f, -4.76435833e-02f, -1.64937451e-01f, -3.01647056e-02f, 1.27103291e-02f, -1.41894802e-01f, -5.55763468e-02f, -1.31496146e-01f, -1.39723852e-01f, -1.11645617e-01f,
  -2.15303432e-02f, -3.62919942e-02f, -6.68805093e-02f, 8.72649774e-02f, 7.83954468e-03f, -1.29359230e-01f, 1.20597407e-01f, 2.59180386e-02f, -2.16662250e-02f, 1.48746759e-01f,
  -1.82437420e-01f, -1.84511498e-01f, 1.29290357e-01f, 3.57997268e-02f, -1.62542000e-01f, -1.39112115e-01f, -7.31109828e-02f, -1.87811479e-01f, -1.50668010e-01f, -1.04151502e-01f,
  -7.36375973e-02f, -1.59456953e-01f, -7.02835992e-02f, 5.24334721e-02f, -1.50185041e-02f, 4.07712311e-02f, -1.96058787e-02f, 1.64723247e-02f, 7.44602978e-02f, -1.63474172e-01f,
  4.34267558e-02f, -5.33861443e-02f, -1.33911058e-01f, 8.54725484e-03f, 6.20186068e-02f, 9.65569541e-02f, -1.44357756e-01f, -1.94991514e-01f, -3.63744706e-01f, -8.74958709e-02f,
  4.05363142e-01f, -1.84269610e-03f, -8.14028233e-02f, 3.05521972e-02f, -1.01211593e-02f, 4.07725908e-02f, 2.80900933e-02f, 3.42674996e-03f, 5.84280528e-02f, -8.62157494e-02f,
  -4.29387502e-02f, 1.06194846e-01f, -1.75280292e-02f, -2.02740747e-02f, 1.81548800e-02f, -3.64500098e-02f, -1.36331439e-01f, -2.85985991e-02f, 2.71904282e-02f, -1.37948632e-01f,
  -1.06149785e-01f, -1.34022996e-01f, -4.06421125e-02f, -9.66905802e-02f, -1.74421743e-01f, -3.15476358e-02f, -1.17580287e-01f, -3.27372581e-01f, -1.43466324e-01f, -2.46024325e-01f,
  3.27053577e-01f, 3.07332516e-01f, 2.21279457e-01f, 1.93184033e-01f, 1.05510801e-01f, 1.54708296e-01f, 2.24897191e-01f, 7.15761557e-02f, 5.70394956e-02f, -7.13124424e-02f,
  7.93041140e-02f, 1.74819846e-02f, 7.71353487e-03f, -3.06924898e-02f, 1.10409722e-01f, -9.05714631e-02f, -8.76213051e-03f, -7.33832195e-02f, -2.50186361e-02f, 9.15524289e-02f,
  2.06669811e-02f, -1.35789253e-02f, -8.01295694e-03f, 8.51880312e-02f, 6.37150183e-02f, 1.44573554e-01f, -2.34399214e-02f, 9.98951867e-03f, -9.81236063e-03f, 1.00485217e-02f,
  -2.55553663e-01f, -4.40112650e-02f, -1.75930653e-02f, -1.63907170e-01f, -2.05805618e-02f, -3.27717252e-02f, 1.38143629e-01f, -3.56455334e-02f, -1.03725884e-02f, -1.01454042e-01f,
  -6.82303905e-02f, -8.66257120e-03f, 1.22544944e-01f, -1.13782942e-01f, -3.05315536e-02f, 1.01789281e-01f, 1.10683233e-01f, 2.80322991e-02f, -9.13837478e-02f, 7.77357891e-02f,
  9.94915143e-02f, 3.77221704e-02f, 2.84239240e-02f, -6.16725273e-02f, -4.77381609e-03f, -8.56984630e-02f, 6.13352023e-02f, -8.20786655e-02f, -9.23811942e-02f, -2.79964134e-02f,
  4.06532496e-01f, 2.48283431e-01f, 1.05354987e-01f, 8.29823539e-02f, 4.21862043e-02f, 1.99512802e-02f, 2.45305449e-02f, 8.54679421e-02f, 1.56814292e-01f, 5.54112792e-02f,
  5.26143573e-02f, 1.73873276e-01f, 8.68312567e-02f, -5.27095310e-02f, 2.28027739e-02f, -2.87482515e-02f, 1.37444928e-01f, 1.25403613e-01f, 6.79205880e-02f, 1.19577676e-01f,
  8.94431472e-02f, 5.12442663e-02f, 1.07605129e-01f, 9.59731266e-02f, 6.78973645e-02f, 1.37161851e-01f, -3.00131589e-02f, -4.80746552e-02f, 1.39665399e-02f, -1.32098526e-01f,
  -5.75294077e-01f, -2.44110331e-01f, -7.47404456e-01f, 2.57713318e-01f, 3.15093815e-01f, -9.95063409e-02f, -5.19618511e-01f, -5.60355894e-02f, 4.06822920e-01f, -3.19193676e-02f,
  -1.03151808e-02f, 2.70473808e-01f, 7.16160834e-02f, 1.41707435e-01f, -2.72169143e-01f, -2.42716372e-01f, 1.51627958e-01f, -9.90283489e-02f, 1.21433720e-01f, 1.61186025e-01f,
  4.10121053e-01f, 2.02542171e-01f, 1.70132264e-01f, 5.99348843e-02f, 3.24142724e-01f, 3.48518819e-01f, 6.92039281e-02f, 2.73763061e-01f, -1.05572999e-01f, -1.22097554e-03f,
  -4.76123542e-01f, -1.13421179e-01f, -1.93684354e-01f, 3.04081917e-01f, -2.32020784e-02f, -2.14453951e-01f, -2.81674027e-01f, -5.49534559e-02f, -7.16774762e-02f, -1.36918560e-01f,
  1.35711819e-01f, -4.73435596e-02f, 2.07692891e-01f, 1.40494451e-01f, 5.93029968e-02f, -2.34095752e-01f, -1.57966271e-01f, -2.21278295e-01f, -3.21989894e-01f, -3.32680017e-01f,
  2.95425445e-01f, 1.20874062e-01f, -3.97046208e-01f, -2.09706709e-01f, -4.54378575e-01f, 2.87222918e-02f, -2.71344572e-01f, -8.33551735e-02f, -4.10134703e-01f, -3.53845596e-01f,
  -5.09581901e-02f, 4.58235070e-02f, -7.56495371e-02f, -1.03673443e-01f, 1.24173835e-01f, -5.69828879e-03f, -6.88977465e-02f, 9.14711207e-02f, 3.38859379e-01f, -1.32050991e-01f,
  -7.77877495e-02f, -2.62162313e-02f, 1.31304532e-01f, -2.66494602e-01f, 8.55953619e-02f, -4.32709046e-02f, 8.35784897e-02f, -5.61191142e-02f, 1.23311453e-01f, -9.60056782e-02f,
  8.33394937e-03f, 3.59715521e-03f, 1.31601840e-01f, 8.11757967e-02f, -7.26493001e-02f, -2.33465582e-01f, 6.40207306e-02f, 8.76707286e-02f, 2.43579838e-02f, -8.65735784e-02f,
  3.41157615e-01f, 1.18376106e-01f, -1.07157409e-01f, 1.16109634e-02f, 1.27229452e-01f, 8.72902051e-02f, 3.52822281e-02f, -2.12590378e-02f, 6.12093210e-02f, -1.12068288e-01f,
  5.07921353e-02f, -1.05100840e-01f, 6.54755607e-02f, 5.05798534e-02f, 2.23498400e-02f, -3.55255231e-02f, 5.46224602e-02f, -8.13327134e-02f, 1.53803200e-01f, 1.94118723e-01f,
  1.69453602e-02f, -1.00008637e-01f, -2.65438437e-01f, -2.69957423e-01f, 1.97198004e-01f, 5.92485908e-03f, -2.92922556e-02f, -2.32273005e-02f, -2.89561272e-01f, -4.68481064e-01f,
  -3.29304904e-01f, 6.90872595e-02f, -2.38880664e-02f, 2.39564870e-02f, 3.38233449e-02f, 7.20914155e-02f, 4.84163575e-02f, 3.67545635e-01f, 2.10820824e-01f, -1.59027681e-01f,
  1.57044068e-01f, 8.69249329e-02f, -1.52396172e-01f, -1.90976739e-01f, -2.95359612e-01f, -3.05368483e-01f, -4.05223578e-01f, -2.66145557e-01f, 2.30941385e-01f, 3.11449647e-01f,
  1.96959779e-01f, -1.42872818e-02f, -7.08346888e-02f, -5.77760637e-02f, -5.34063466e-02f, -1.83268130e-01f, -3.48502874e-01f, -1.34038597e-01f, -1.41244769e-01f, -6.38005733e-01f,
  -2.13984787e-01f, 2.59070277e-01f, 1.59132138e-01f, -1.25375748e-01f, 7.50865564e-02f, 2.24330679e-01f, 1.84918940e-01f, 1.19366281e-01f, 5.27306534e-02f, -1.53795118e-02f,
  -3.53098698e-02f, 1.89257771e-01f, 1.61700487e-01f, 4.05168906e-02f, 1.00580737e-01f, 1.21254750e-01f, 1.69499367e-01f, 1.95587113e-01f, -1.40937462e-01f, 1.85080558e-01f,
  -3.34636793e-02f, -2.03410760e-02f, -2.72171885e-01f, 6.16480485e-02f, 1.61685869e-01f, -8.14513639e-02f, 1.38157234e-01f, 8.89428146e-03f, -2.81498879e-01f, -4.27975297e-01f,
  8.84204637e-04f, -4.32159798e-03f, 1.49729475e-01f, 2.00534746e-01f, -7.13167191e-02f, 2.24641263e-02f, -1.06257178e-01f, -1.06385089e-01f, -2.02682838e-02f, -8.15816410e-03f,
  1.20099299e-01f, -7.45266005e-02f, -8.61376897e-02f, -1.19005688e-01f, -2.53888309e-01f, -7.48253986e-02f, -8.68892744e-02f, -2.93399602e-01f, -9.20269564e-02f, -1.57878503e-01f,
  -6.95774704e-02f, -5.24057820e-02f, -6.47878647e-02f, -2.23857492e-01f, -7.34861419e-02f, -3.28737907e-02f, -1.49147697e-02f, 1.15044482e-01f, 1.57549575e-01f, 7.79387876e-02f,
  -1.47572616e-02f, 2.46057436e-02f, -1.71842650e-01f, -4.47482243e-02f, -1.37010083e-01f, 3.52954343e-02f, -8.79811719e-02f, 1.25202909e-01f, -4.25451994e-02f, 7.94307739e-02f,
  -1.29622117e-01f, -1.85848475e-01f, -1.04986504e-01f, 4.38332893e-02f, -4.75796834e-02f, -2.05098748e-01f, -1.40669331e-01f, -2.18209088e-01f, -1.22416750e-01f, 1.29149660e-01f,
  -1.80352241e-01f, -3.48219544e-01f, -3.17787975e-01f, -2.61712790e-01f, -2.37717167e-01f, -3.51722360e-01f, -2.82213837e-01f, -2.56197825e-02f, -1.92072526e-01f, -4.36099887e-01f,
  3.51669252e-01f, -1.72028840e-01f, -8.19404840e-01f, -7.52526596e-02f, -3.11014920e-01f, -3.21680963e-01f, -3.77156585e-01f, 1.48136886e-02f, 1.45189494e-01f, -3.66229594e-01f,
  -1.77526802e-01f, 5.43434322e-02f, -1.83824624e-03f, -1.29782066e-01f, -1.55029759e-01f, -4.91833210e-01f, -5.79819381e-01f, -4.95249838e-01f, -1.86126977e-01f, -2.51665384e-01f,
  -3.96685988e-01f, -2.69324899e-01f, -1.17652535e-01f, -1.51577666e-01f, -3.13579381e-01f, 7.21047521e-02f, -2.46104151e-01f, -3.48419212e-02f, -2.32703447e-01f, -5.56040764e-01f,
  -5.23395240e-01f, 2.02869698e-01f, 8.81777853e-02f, 1.21169232e-01f, 8.82781446e-02f, 2.06927478e-01f, 4.20660190e-02f, 1.70656770e-01f, 2.17802659e-01f, 2.59547736e-02f,
  8.34208727e-03f, 1.13533117e-01f, 1.64774418e-01f, 1.75649866e-01f, 1.54886050e-02f, -1.24402598e-01f, -2.35130135e-02f, 5.79207875e-02f, -2.31247973e-02f, -1.53539404e-01f,
  -6.56116307e-02f, -2.15780109e-01f, 1.01638921e-02f, 2.44081900e-01f, 1.76804796e-01f, 2.18931586e-03f, 1.84582561e-01f, 1.47409722e-01f, 1.24821015e-01f, 2.49273375e-01f,
  -8.84154290e-02f, 3.85040650e-03f, -9.47880298e-02f, 1.89553365e-01f, 2.18042042e-02f, 4.78972904e-02f, -3.69219743e-02f, 4.48342005e-04f, 1.29071087e-01f, -7.73197934e-02f,
  7.72488788e-02f, -7.91771710e-03f, 8.83280262e-02f, 1.91829968e-02f, -2.07010359e-01f, -2.48021968e-02f, -2.55317986e-02f, -7.50090778e-02f, 9.21608061e-02f, 7.21173063e-02f,
  6.52361214e-02f, 1.06019989e-01f, -6.72487319e-02f, -2.91935988e-02f, -2.06327513e-01f, -2.16449890e-02f, -6.73680007e-02f, -4.61803116e-02f, 1.39714837e-01f, -1.55490572e-02f,
  6.45240545e-02f, -4.04448584e-02f, 6.30400628e-02f, 2.36973211e-01f, 4.48143817e-02f, -2.05933060e-02f, -1.00321263e-01f, 4.13621217e-02f, 7.08717927e-02f, 1.84298363e-02f,
  -7.87380859e-02f, -6.49368539e-02f, -8.70273113e-02f, 8.62271413e-02f, 4.01872024e-02f, -1.44197568e-01f, -5.38147613e-02f, 3.38393673e-02f, -9.24383625e-02f, -5.95119707e-02f,
  -1.05332434e-01f, -6.10697269e-02f, 8.76627490e-03f, 6.70111254e-02f, 2.11037844e-01f, -5.56356497e-02f, -3.54466997e-02f, -7.54256500e-03f, -1.24214210e-01f, -1.97743531e-02f,
  3.16479862e-01f, -1.08730674e-01f, 2.77983159e-01f, 3.60062808e-01f, 4.41038668e-01f, 4.10877526e-01f, 1.19014807e-01f, 2.66826510e-01f, 2.86133021e-01f, 2.51726449e-01f,
  4.04831350e-01f, 4.60109890e-01f, 3.68531674e-01f, 3.60317081e-01f, 2.34675214e-01f, 2.19797373e-01f, 2.25943699e-01f, 1.31332427e-01f, 9.21751633e-02f, 2.58898795e-01f,
  8.58908743e-02f, 5.65434806e-02f, -6.36318848e-02f, 5.03695309e-02f, -7.08814412e-02f, 2.27719024e-01f, 9.86889377e-02f, 1.11652195e-01f, 1.60194382e-01f, -1.07867802e-02f,
  2.32423291e-01f, -1.13540534e-02f, 7.26062432e-02f, -8.55084285e-02f, -2.30808347e-01f, -1.74198583e-01f, 1.59851499e-02f, -7.91040659e-02f, -1.09528229e-01f, -1.63846090e-01f,
  -8.75144079e-02f, -2.20001146e-01f, -7.22515807e-02f, -1.98183239e-01f, -1.76103204e-01f, -1.71532080e-01f, -1.79098830e-01f, 1.50993615e-01f, 1.87990502e-01f, 5.61257154e-02f,
  -2.63508298e-02f, 6.62761778e-02f, 5.05931750e-02f, 7.53852278e-02f, 1.03492774e-01f, 6.60150424e-02f, -3.86325642e-02f, -1.69691369e-01f, -9.08418224e-05f, -1.90118235e-02f,
  5.39040267e-01f, 2.03465670e-01f, 1.95057675e-01f, 7.71560371e-02f, 4.79553752e-02f, 4.48116101e-02f, -2.15778835e-02f, 1.37633041e-01f, 1.69331878e-01f, -5.41885085e-02f,
  5.57900071e-02f, 3.30689043e-01f, 8.93011913e-02f, 7.72016495e-02f, 7.04965591e-02f, -1.24739446e-01f, -1.73435926e-01f, -2.54927482e-02f, -1.47536278e-01f, -1.21126138e-01f,
  7.27236038e-03f, -1.57705061e-02f, -6.67173266e-02f, -1.52468860e-01f, -1.39426187e-01f, 1.22231670e-01f, 5.07024899e-02f, -1.87218022e-02f, -9.79422256e-02f, -4.81526516e-02f,
  2.11043701e-01f, 4.09504920e-01f, 1.79816186e-01f, -7.07707461e-03f, -6.67948499e-02f, -1.71451762e-01f, 1.69627234e-01f, -7.52583817e-02f, -1.19818978e-01f, -3.48528549e-02f,
  -2.42976705e-03f, -1.16219088e-01f, -7.45306388e-02f, -8.09053555e-02f, -1.57076240e-01f, -1.59299999e-01f, -5.00459187e-02f, 9.08601359e-02f, 1.06562227e-01f, -6.40861914e-02f,
  -7.04559609e-02f, 7.41367936e-02f, 1.83461800e-01f, 1.76398575e-01f, 1.55633926e-01f, 9.31426659e-02f, -3.69447027e-03f, -2.07840912e-02f, 1.35809195e-03f, -1.61438450e-01f,
  8.56079936e-01f, 3.49185407e-01f, 3.52916360e-01f, 5.61649865e-03f, -1.16575517e-01f, -1.21576443e-01f, 2.12061293e-02f, 7.42952675e-02f, 1.27663428e-03f, 1.64569151e-02f,
  -4.66524735e-02f, -2.61906505e-01f, -8.93798657e-03f, -9.01910812e-02f, 1.29763931e-01f, 6.24789372e-02f, 1.25241339e-01f, 2.38460422e-01f, 1.84113547e-01f, 4.66072448e-02f,
  -1.30901456e-01f, 2.08306864e-01f, 3.63106340e-01f, 1.71189234e-01f, 1.22054867e-01f, -1.08157136e-01f, 3.57148051e-02f, 1.57602906e-01f, 4.21396047e-02f, 1.11372575e-01f,
  -5.03359288e-02f, 3.41614813e-01f, -2.22175390e-01f, -1.51544169e-01f, 5.61925732e-02f, 8.61027241e-02f, -6.06402420e-02f, -3.91864777e-02f, -7.30489045e-02f, -1.31337166e-01f,
  -5.66654839e-02f, 6.56080395e-02f, 1.84030622e-01f, 1.02933198e-01f, 9.78082865e-02f, -9.83948354e-03f, 2.03566805e-01f, 2.53243387e-01f, -2.46873312e-02f, -7.44805261e-02f,
  -1.16698921e-01f, -1.03554148e-02f, -5.14350412e-03f, -1.05244130e-01f, 2.40737259e-01f, -1.35844365e-01f, 3.95302251e-02f, 2.11899370e-01f, 1.71754092e-01f, 2.38698557e-01f,
  -1.27888545e-01f, -7.78641850e-02f, 4.07861881e-02f, -1.38953933e-03f, 8.27993229e-02f, 1.07904105e-02f, -4.41932641e-02f, -3.74414981e-03f, 1.09434031e-01f, 2.08455890e-01f,
  1.32714078e-01f, -1.74746364e-02f, -5.00236731e-03f, -2.28886493e-02f, -1.11540534e-01f, 6.07677698e-02f, 1.20159671e-01f, -1.83201972e-02f, -1.75933298e-02f, 2.21804511e-02f,
  1.52193993e-01f, 5.46059161e-02f, 1.03393130e-01f, 1.74916357e-01f, -2.69083343e-02f, 9.93884727e-02f, 7.80798867e-02f, 4.78099147e-03f, 1.30666822e-01f, 5.55707216e-02f,
  -5.57834268e-01f, -5.51476665e-02f, 3.33485939e-02f, 7.16412291e-02f, 5.88224344e-02f, 1.08348683e-01f, 9.69790816e-02f, -1.42175376e-01f, -2.73998290e-01f, -8.74984935e-02f,
  -2.31902301e-02f, 1.75414950e-01f, 1.29734233e-01f, 1.04946665e-01f, 2.65812268e-03f, -2.04188656e-02f, -9.43313688e-02f, -1.38524115e-01f, -9.82796922e-02f, -8.36154222e-02f,
  -6.37565702e-02f, -9.96157676e-02f, -2.99274236e-01f, -1.19308732e-01f, -5.78357279e-02f, -1.79940298e-01f, -1.02475109e-02f, -1.00564018e-01f, -9.93093941e-03f, -5.01244329e-02f,
  -6.67548776e-01f, 2.53322482e-01f, 1.75020576e-01f, -7.84789085e-01f, -6.01507664e-01f, -2.73020774e-01f, 1.70217678e-01f, -2.06767723e-01f, -5.29258192e-01f, 3.39241885e-03f,
  1.50639892e-01f, 9.37007964e-02f, 3.07768732e-01f, 3.06016207e-01f, 3.32121521e-01f, 2.74691135e-01f, -2.27053225e-01f, -2.96839084e-02f, -1.58289537e-01f, -2.63580620e-01f,
  -7.35797808e-02f, -2.85267144e-01f, -4.18341756e-01f, -3.23902011e-01f, -2.01762770e-03f, 1.87854007e-01f, 1.47616148e-01f, -2.93652952e-01f, -1.97584286e-01f, -7.07899313e-03f,
  6.23564661e-01f, -3.70340288e-01f, -9.08504426e-02f, -1.93573028e-01f, 3.96908261e-02f, -1.70169666e-01f, 2.89993379e-02f, -9.57451016e-02f, -8.25985372e-02f, -1.57850802e-01f,
  -8.96446593e-03f, -1.79171324e-01f, 1.43565284e-02f, 6.23478815e-02f, -4.89853229e-03f, 1.57320146e-02f, 2.31779367e-03f, -5.70347123e-02f, -8.62523839e-02f, 9.55450311e-02f,
  4.87748859e-03f, -9.03658047e-02f, -2.54755020e-02f, 1.18511088e-01f, 2.02290826e-02f, -8.34526271e-02f, -3.23970355e-02f, -1.89844400e-01f, -4.35521044e-02f, 2.48090643e-02f,
  -1.35161713e-01f, 8.91410485e-02f, -6.25820830e-02f, -7.97383580e-03f, 1.44051937e-02f, -2.81999186e-02f, 6.86343163e-02f, 5.06986212e-03f, 5.24788909e-02f, 1.78313345e-01f,
  -1.58611551e-01f, 2.66302172e-02f, -2.54651271e-02f, -7.84917846e-02f, 6.45772368e-03f, -5.00294752e-02f, 1.35659918e-01f, 2.71143373e-02f, -1.45146459e-01f, -1.06685139e-01f,
  -1.82204902e-01f, -1.28729874e-02f, 2.69032549e-02f, 2.90888567e-02f, -4.27811965e-02f, -3.09814811e-02f, -6.14579245e-02f, 1.16278477e-01f, 1.53841060e-02f, -1.01806872e-01f,
  4.86700565e-01f, -2.51301557e-01f, 2.06300199e-01f, 1.13802440e-02f, 9.00857616e-03f, -4.93830033e-02f, 1.22505538e-02f, -1.63274303e-01f, 2.62087062e-02f, -8.16953182e-03f,
  -1.11160174e-01f, 4.94187418e-03f, 1.30263567e-01f, 1.19459651e-01f, -6.19671680e-02f, -9.01445076e-02f, -3.54461285e-04f, -4.67229038e-02f, -1.56196430e-01f, -8.17389507e-03f,
  -1.19687364e-01f, -1.02728270e-01f, 1.41067341e-01f, 2.03763992e-01f, 7.41948411e-02f, 1.08037680e-01f, 2.79309839e-01f, 2.18424723e-01f, 1.19397439e-01f, 2.23978043e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 14)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 14;
const float L0_fan_Bp_bar_data[] = {
  8.22741389e-02f, 2.60504752e-01f, 2.90790319e-01f, -4.22181562e-02f, 6.17241859e-01f, 4.00569618e-01f, 7.26852566e-02f, -1.53391376e-01f, 1.98558062e-01f, 9.04355049e-02f,
  8.96418020e-02f, 2.57315308e-01f, 4.09385443e-01f, 3.22626263e-01f
};

// L1_fan_Wp (Shape: 25 x 64)
const int L1_fan_Wp_rows = 25;
const int L1_fan_Wp_cols = 64;
const float L1_fan_Wp_data[] = {
  -9.31070594e-04f, -2.12282073e-02f, -8.61660019e-03f, -1.17885247e-02f, -4.92199138e-02f, -1.15948685e-01f, -5.46703860e-02f, 3.44743058e-02f, -2.98441723e-02f, 1.61874697e-01f,
  -6.20436817e-02f, -7.45158866e-02f, -1.13413639e-01f, 1.96545664e-02f, 1.65841863e-01f, -7.89037794e-02f, -1.77458115e-02f, 3.25520746e-02f, 2.75704637e-02f, -3.04164458e-02f,
  -5.81917353e-03f, 1.10229857e-01f, -1.80976391e-01f, 2.17674486e-02f, -5.09790368e-02f, -1.06243521e-01f, -1.09899476e-01f, -1.83289461e-02f, -8.34291354e-02f, -2.90815122e-02f,
  -2.91985422e-01f, -3.16535272e-02f, 6.73747361e-02f, 1.23582773e-01f, 5.02768438e-03f, 1.30438492e-01f, 7.89465085e-02f, -8.99344683e-02f, 5.58828562e-02f, 3.69725525e-02f,
  2.09873379e-03f, -9.86019298e-02f, -7.42815733e-02f, -2.07433447e-01f, 1.94890611e-02f, -5.08980500e-03f, -2.57445127e-01f, -3.26299369e-01f, -4.09280695e-02f, -6.62037358e-02f,
  3.12332846e-02f, -2.19455212e-02f, -2.33793586e-01f, 4.41928953e-01f, -4.23178524e-02f, 7.86883384e-03f, -1.82116672e-01f, 2.13153481e-01f, 1.63224846e-01f, 7.13989362e-02f,
  2.11537674e-01f, 1.58386249e-02f, -4.65735830e-02f, 3.65543738e-02f, -5.07474355e-02f, -3.18691251e-04f, 1.00570016e-01f, 2.71590836e-02f, -3.23597826e-02f, -5.61810471e-02f,
  -4.52883765e-02f, 1.27532944e-01f, -1.13638908e-01f, -1.39019927e-02f, -8.42739940e-02f, 2.81375665e-02f, 8.03855062e-02f, 1.49300560e-01f, 9.48201586e-03f, 9.03930664e-02f,
  -4.45608310e-02f, -8.08669329e-02f, 7.52415657e-02f, 3.35392430e-02f, -6.94136918e-02f, 2.79191226e-01f, -5.54517768e-02f, 1.99735649e-02f, 3.30745280e-02f, -8.95793885e-02f,
  -8.68843272e-02f, -1.58678696e-01f, -9.16097090e-02f, -3.10671260e-03f, -1.94464341e-01f, -9.25100408e-03f, 1.49411902e-01f, -1.78561006e-02f, 1.77376211e-01f, -1.32981464e-02f,
  4.74474840e-02f, -3.82613763e-02f, 9.77554843e-02f, 4.22787592e-02f, -1.23696178e-01f, -7.01576546e-02f, -1.98564455e-01f, -1.09694570e-01f, -9.35284495e-02f, -1.02089122e-02f,
  -2.85692751e-01f, -3.49211600e-03f, -2.44668782e-01f, 5.17010130e-02f, -2.47429594e-01f, 6.45460427e-01f, -1.54791117e-01f, -1.16641317e-02f, 1.47423699e-01f, -3.71905982e-01f,
  8.23246390e-02f, 1.33308023e-01f, 4.92249340e-01f, 1.02943003e-01f, 3.44105214e-02f, -2.54588485e-01f, 4.19825986e-02f, -2.21652448e-01f, -2.14259520e-01f, 1.91021971e-02f,
  -1.03295125e-01f, -9.93169099e-02f, -8.87255669e-02f, -1.72230139e-01f, -1.55891581e-02f, 8.09296370e-02f, -4.86147925e-02f, -2.50774950e-01f, -8.10914114e-02f, -6.40827939e-02f,
  -2.95084920e-02f, -8.84368122e-02f, -7.46315122e-02f, 1.18213765e-01f, 8.33292399e-03f, 6.61342666e-02f, -1.37691751e-01f, 1.50955737e-01f, -6.53347224e-02f, -3.86840850e-02f,
  -1.58163486e-03f, -1.81717221e-02f, 3.41264084e-02f, -3.83998975e-02f, 2.57441383e-02f, -8.50260034e-02f, -1.02490917e-01f, 2.41320897e-02f, 1.28810585e-01f, 3.50630730e-01f,
  1.57073438e-01f, -2.31417403e-01f, -8.54976252e-02f, 1.68212727e-02f, -3.29905935e-02f, -2.06785604e-01f, -7.32004866e-02f, -9.47936922e-02f, 3.53326127e-02f, -9.09016728e-02f,
  -4.74262945e-02f, 2.16695830e-01f, -3.67074609e-02f, 1.99841827e-01f, 1.09661616e-01f, -2.25004889e-02f, -9.25734863e-02f, 5.29234260e-02f, -1.10464834e-01f, 4.14882213e-01f,
  2.56734729e-01f, -1.38855174e-01f, -4.86021310e-01f, 2.73526944e-02f, -2.33610436e-01f, 8.25467259e-02f, 3.91032398e-02f, 2.07217544e-01f, 4.93451282e-02f, -9.74315181e-02f,
  -2.95703262e-01f, 1.52712055e-02f, 1.81322366e-01f, 3.10791489e-02f, 9.35016572e-03f, 1.35197639e-01f, -6.78718761e-02f, 2.86535416e-02f, -5.57856411e-02f, -6.01895414e-02f,
  -1.63719997e-01f, 8.18461366e-03f, 3.86034623e-02f, -4.12077345e-02f, -2.53204145e-02f, -2.08011568e-02f, -7.48196170e-02f, -3.96214835e-02f, -2.06426904e-01f, 1.43852577e-01f,
  -9.05088484e-02f, -3.28861214e-02f, -5.04072085e-02f, -3.92016768e-02f, 1.98440298e-01f, -2.21048683e-01f, -1.66149735e-01f, 5.91455493e-03f, 6.44326359e-02f, 3.26454230e-02f,
  -2.87189167e-02f, 1.44107163e-01f, 2.69729227e-01f, -3.65045741e-02f, 5.39777391e-02f, 2.38926224e-02f, -1.06670253e-01f, -1.86957672e-01f, -2.71971710e-02f, -2.25032158e-02f,
  -1.65158480e-01f, -3.80638167e-02f, 1.65975243e-01f, 1.70023087e-02f, 2.21659213e-01f, 4.06318963e-01f, -4.10717763e-02f, 5.75950630e-02f, 3.54312569e-01f, 2.78487384e-01f,
  -3.21364015e-01f, -1.08602718e-01f, 1.36828035e-01f, -1.35772273e-01f, 4.51157838e-01f, -8.17641914e-02f, -6.32646084e-02f, -1.11373901e-01f, -3.45475644e-01f, 2.67636194e-03f,
  5.92572726e-02f, 5.54446802e-02f, -1.07054107e-01f, -1.37572676e-01f, -6.11477196e-02f, -2.00803667e-01f, 6.58631464e-03f, 1.22177554e-02f, -4.63455431e-02f, -2.04703342e-02f,
  1.89835191e-01f, 2.27080792e-01f, 2.90902331e-02f, -8.12262148e-02f, 3.17271389e-02f, 5.45801818e-02f, 1.02644391e-01f, 3.99004519e-02f, 6.23244606e-02f, -6.87908530e-02f,
  -5.92306182e-02f, -1.53851230e-02f, 7.99658895e-02f, 9.61647183e-02f, 1.46025330e-01f, -1.57721005e-02f, -4.54027615e-02f, -1.60265967e-01f, 7.03833774e-02f, 4.78736088e-02f,
  -7.27519020e-02f, 7.26389512e-02f, 2.22153708e-01f, -9.55388770e-02f, 7.26866648e-02f, -5.06951734e-02f, 1.08343273e-01f, -9.89952013e-02f, -1.25024289e-01f, 6.70073926e-02f,
  -1.15078062e-01f, -8.27080831e-02f, -1.42401353e-01f, -2.77312100e-02f, 1.11633331e-01f, 6.72046989e-02f, 2.50007898e-01f, 1.73791677e-01f, 4.58501518e-01f, 1.67477250e-01f,
  1.26206085e-01f, 6.18495094e-03f, -7.35380054e-02f, 4.55622822e-02f, 8.95092785e-02f, -3.07110399e-02f, -3.03823411e-01f, -2.14775473e-01f, 2.72260550e-02f, -2.15479776e-01f,
  3.09098363e-01f, -2.02452838e-02f, 3.48254532e-01f, 5.25352247e-02f, 1.53162489e-02f, -2.54648894e-01f, -4.90946136e-02f, -2.19954401e-01f, -2.93587185e-02f, 5.13905942e-01f,
  -5.58538325e-02f, 4.39688005e-02f, 1.19466754e-02f, 1.29069701e-01f, 2.24257745e-02f, -8.12876746e-02f, 6.27047420e-02f, 4.83451299e-02f, 6.67019710e-02f, -5.36949560e-02f,
  3.95443924e-02f, -9.82801393e-02f, 6.04882278e-02f, 1.72620729e-01f, 1.41389117e-01f, 1.93887815e-01f, 7.78224915e-02f, 3.83617878e-02f, 1.36433825e-01f, 3.97455059e-02f,
  -1.38796315e-01f, 3.03502809e-02f, 6.01700433e-02f, 3.75478119e-02f, -8.99435300e-03f, -1.39359981e-02f, 8.41723755e-02f, -7.83916470e-03f, -1.58070266e-01f, 7.71555975e-02f,
  -3.23940776e-02f, -9.10892114e-02f, 2.31207777e-02f, 1.76646546e-01f, 6.05760477e-02f, -2.23174319e-02f, 6.89688101e-02f, -1.56507358e-01f, -9.70365778e-02f, -2.01637059e-01f,
  -3.70736480e-01f, 8.26278776e-02f, -1.18796550e-01f, -2.31362939e-01f, -9.11619887e-02f, -4.00993712e-02f, -1.39345810e-01f, -2.32654974e-01f, 3.31479236e-02f, -5.51512390e-02f,
  1.19905651e-01f, -4.38456088e-01f, 2.25018382e-01f, -6.48694485e-02f, 4.79930222e-01f, 7.97396451e-02f, -2.46931806e-01f, -5.16172722e-02f, -4.09675211e-01f, -2.49654591e-01f,
  -1.48874998e-01f, -1.07218668e-01f, 1.86932892e-01f, 3.80850285e-01f, -9.13082287e-02f, 4.43752334e-02f, -8.65559839e-03f, 2.79507115e-02f, -1.76959604e-01f, -1.83019623e-01f,
  1.33141711e-01f, -2.84931690e-01f, -8.47580060e-02f, 2.51974426e-02f, -5.16275130e-02f, -8.19666013e-02f, 4.36356029e-04f, -2.70892717e-02f, 7.90707022e-02f, 2.12906599e-02f,
  -8.52347389e-02f, 6.32904992e-02f, -1.62781075e-01f, -3.72885205e-02f, 5.23790112e-03f, 1.23771671e-02f, 6.77412227e-02f, -2.00441182e-01f, -5.57643026e-02f, -1.45763699e-02f,
  -1.68272052e-02f, 5.82813732e-02f, -8.70913193e-02f, 1.24137923e-01f, -1.27697721e-01f, 1.06123194e-01f, -6.93420470e-02f, -6.35535046e-02f, -2.39662185e-01f, 1.47635425e-02f,
  -1.35292724e-01f, -1.59016754e-02f, -3.74480598e-02f, 9.01438519e-02f, -2.85398914e-03f, -1.75645563e-03f, 1.18442222e-01f, 1.16991736e-01f, 5.34972213e-02f, 8.60508159e-02f,
  3.25426042e-01f, 2.53779262e-01f, -5.39004840e-02f, -7.46961087e-02f, 1.79055214e-01f, -5.35612963e-02f, 2.51649946e-01f, -7.05742687e-02f, -3.45692366e-01f, 3.36790979e-01f,
  -1.63433060e-01f, -1.01092733e-01f, -4.28987890e-01f, 3.13570619e-01f, 3.44903618e-02f, 7.21572060e-03f, 1.44992024e-01f, -2.83253372e-01f, 2.79470216e-02f, -3.31200566e-03f,
  -5.06246388e-02f, 3.74352187e-02f, 1.91805959e-01f, 2.26794466e-01f, -7.02939555e-02f, 1.25144911e-03f, 1.90760207e-03f, 2.24429823e-04f, -5.04225865e-02f, 1.00740558e-02f,
  2.15464830e-02f, 3.21431980e-02f, 8.47818479e-02f, 1.17414296e-02f, 1.40243173e-01f, -6.22048266e-02f, 8.77171606e-02f, 1.21538639e-02f, 1.75592154e-02f, -5.95785007e-02f,
  -3.13659422e-02f, -1.71384662e-01f, -7.50299990e-02f, 9.95642766e-02f, -2.59468332e-02f, -6.38243482e-02f, 1.11347288e-01f, 1.11018851e-01f, -7.42353424e-02f, 5.28983250e-02f,
  6.69409037e-02f, 7.69299120e-02f, 1.51852533e-01f, 4.45230380e-02f, 5.85250780e-02f, -1.65759660e-02f, 1.02076925e-01f, 2.00900987e-01f, -9.54419971e-02f, 8.23863745e-02f,
  1.04016773e-01f, 1.24956079e-01f, -8.51823837e-02f, -6.73451722e-02f, 8.08177665e-02f, 1.53815195e-01f, -1.33302668e-02f, 5.99560887e-02f, -2.07158923e-01f, 3.88843715e-01f,
  -3.91963303e-01f, 9.83095244e-02f, 2.81787097e-01f, -3.58708590e-01f, 1.08253725e-01f, 1.98692679e-01f, -1.44061938e-01f, -7.28588030e-02f, -9.16976407e-02f, 1.50584221e-01f,
  -1.47797570e-01f, 1.22204132e-01f, -5.61205707e-02f, 1.82159439e-01f, -1.27586827e-01f, -1.02913395e-01f, 5.71276434e-02f, -2.14052126e-02f, -4.20526527e-02f, 5.16223488e-03f,
  1.85365113e-03f, 2.16707662e-01f, 2.52250712e-02f, 1.47667646e-01f, -6.14282265e-02f, 1.40053362e-01f, 1.07262723e-01f, 2.44721830e-01f, -1.02441944e-01f, 4.37153578e-02f,
  -2.23455541e-02f, 5.28288539e-03f, -4.89830300e-02f, 3.09192091e-01f, 7.25259818e-03f, 2.18279406e-01f, 4.24644016e-02f, -1.51015595e-02f, 3.55260968e-02f, -1.18657157e-01f,
  1.07658636e-02f, 4.14078198e-02f, 8.06373358e-02f, 5.12514710e-02f, -8.48499313e-02f, 1.72273234e-01f, -8.96379165e-03f, -8.55016429e-03f, -7.98504949e-02f, 1.43844143e-01f,
  -1.01244211e-01f, 1.45205893e-02f, -3.14202398e-01f, -1.48327753e-01f, 3.75328250e-02f, 2.94067174e-01f, -5.21803759e-02f, -3.85057144e-02f, 7.93363079e-02f, 1.41150594e-01f,
  -2.92352468e-01f, -6.67560846e-02f, -1.99100282e-03f, 3.02408099e-01f, -6.94024339e-02f, -6.83597028e-02f, -5.37925437e-02f, -2.26130456e-01f, -1.23584852e-01f, -1.42690971e-01f,
  1.49252638e-01f, 1.55026972e-01f, 2.09190801e-01f, -1.20371103e-01f, 1.12822026e-01f, -2.19264165e-01f, 1.52715489e-01f, -1.42997503e-02f, 1.40325963e-01f, -9.70610380e-02f,
  -1.87694669e-01f, -1.61689982e-01f, -1.39297530e-01f, -9.71126407e-02f, -8.70871264e-03f, -4.07424681e-02f, 8.16003159e-02f, -7.14785755e-02f, 4.58295383e-02f, -4.58440296e-02f,
  -3.20350900e-02f, 9.01301578e-02f, 5.38214110e-02f, -2.08510339e-01f, -8.64547566e-02f, 8.94903615e-02f, 7.15202987e-02f, 1.02248736e-01f, 9.07562226e-02f, -7.41949165e-03f,
  8.95059407e-02f, -1.15225427e-01f, 6.15899526e-02f, 7.22364383e-03f, -6.28921613e-02f, -3.34113747e-01f, -4.30116728e-02f, -1.05605952e-01f, 6.75498396e-02f, -1.16874352e-01f,
  8.44258722e-03f, -5.04094213e-02f, 1.56493872e-01f, -7.81790093e-02f, 2.99261928e-01f, -4.35092561e-02f, 4.44139719e-01f, -1.35472372e-01f, -1.40888765e-01f, -1.41529977e-01f,
  3.37422043e-02f, -8.37054923e-02f, -2.86492020e-01f, -3.04165900e-01f, 1.59721047e-01f, 2.23460585e-01f, 1.80973142e-01f, -2.12911233e-01f, 2.53331587e-02f, 3.99887353e-01f,
  -3.68619920e-04f, -1.25809774e-01f, -4.88406457e-02f, 8.71265680e-02f, 4.68374550e-01f, 1.10118553e-01f, 6.41650558e-02f, -2.88475454e-02f, -1.12502538e-01f, -1.84976250e-01f,
  -3.94084938e-02f, -8.35175291e-02f, 1.75027223e-03f, -9.51786339e-02f, 1.04554176e-01f, 8.91268924e-02f, -1.39620835e-02f, 3.85142900e-02f, 2.14236844e-02f, -8.88963193e-02f,
  2.63775364e-02f, -5.01334444e-02f, 1.51845850e-02f, -3.34290043e-02f, 4.08800468e-02f, -2.02772021e-01f, 1.32395148e-01f, -1.07337110e-01f, 1.45559506e-02f, 3.94708626e-02f,
  -1.09933853e-01f, -6.08842894e-02f, -7.86570683e-02f, 3.96589041e-02f, 1.94046095e-01f, -4.73560840e-02f, -2.86144856e-02f, 2.36309636e-02f, -2.87138647e-03f, -1.41232938e-01f,
  -2.18721088e-02f, -8.51003155e-02f, 3.15959491e-02f, -1.37637079e-01f, 1.11513376e-01f, -3.95932142e-03f, -4.41672206e-02f, -8.42518806e-02f, 5.28148562e-02f, -5.71325421e-02f,
  -1.52121373e-02f, 5.52266724e-02f, 3.57533805e-02f, -1.34343356e-01f, -8.61813128e-03f, -9.94968880e-03f, -6.48707524e-02f, -2.89073825e-01f, 7.92191699e-02f, 6.71143234e-02f,
  -2.17119642e-02f, -3.08022439e-01f, -1.80100560e-01f, 1.25067726e-01f, 4.56418127e-01f, -3.30094099e-01f, 1.53640313e-02f, 9.93341282e-02f, -2.29829084e-02f, -1.83803797e-01f,
  -3.68212104e-01f, 1.03379235e-01f, 4.95540053e-02f, 1.60769716e-01f, -5.37366346e-02f, 2.32241210e-02f, 7.01010376e-02f, 6.09518699e-02f, 4.57507409e-02f, 1.00965053e-01f,
  9.39240959e-03f, -9.03466120e-02f, -1.27086546e-02f, 1.75549253e-03f, 8.00758079e-02f, -1.03647299e-01f, -1.38484472e-02f, 2.71684732e-02f, -5.04136011e-02f, 4.24184278e-02f,
  2.39456166e-02f, -3.81430835e-02f, 1.08921386e-01f, -8.06961954e-02f, -6.58886284e-02f, -1.73484415e-01f, 2.38987915e-02f, 4.80756350e-02f, -4.09073755e-02f, -2.33639125e-02f,
  -4.00367491e-02f, 4.05369624e-02f, -5.41542359e-02f, -2.14059770e-01f, -1.46569610e-02f, 8.61160681e-02f, -2.08207488e-01f, -2.13291906e-02f, -1.15033224e-01f, 1.69423269e-03f,
  1.69595703e-01f, -2.01706099e-03f, 5.39892912e-02f, -1.89497560e-01f, 1.09579265e-01f, 2.59264618e-01f, 1.06220223e-01f, -1.33322328e-01f, -1.27222210e-01f, 9.84097947e-04f,
  -1.91985101e-01f, -1.44822866e-01f, 8.32511187e-02f, 1.26349345e-01f, -1.57187581e-01f, -4.47224230e-01f, -1.51829064e-01f, 1.39357120e-01f, 3.16189736e-01f, 1.84939116e-01f,
  2.39612833e-01f, -4.93596494e-02f, -2.57848114e-01f, -2.12932318e-01f, -1.15673179e-02f, -2.54020661e-01f, 7.80959502e-02f, 4.08598900e-01f, -7.53986314e-02f, 1.06781304e-01f,
  -7.34545216e-02f, -3.09570543e-02f, 1.07013568e-01f, 2.39034265e-01f, 4.22961591e-03f, -1.55775204e-01f, -1.18281424e-01f, -5.69770150e-02f, -6.85991123e-02f, -9.40919295e-02f,
  -4.99222092e-02f, -1.28611833e-01f, 1.63424350e-02f, -9.70049854e-03f, 3.16185877e-02f, 7.46965930e-02f, -1.64709434e-01f, 1.11756101e-01f, 8.78651813e-02f, -2.13675514e-01f,
  1.30943537e-01f, -1.13701180e-01f, 8.28490332e-02f, 8.04919191e-03f, 8.37947801e-02f, -1.68428831e-02f, 6.91048428e-02f, 3.40286419e-02f, -1.52469561e-01f, 4.22322750e-02f,
  5.87307755e-03f, -2.37532258e-02f, 1.43035322e-01f, 1.19806752e-01f, 4.33201349e-04f, 9.35996249e-02f, -2.44497105e-01f, 8.45918208e-02f, -2.62598693e-01f, 1.49543881e-01f,
  3.45351517e-01f, -2.04537868e-01f, -6.40885010e-02f, 1.19636536e-01f, 2.14581981e-01f, 8.61223489e-02f, 5.50847389e-02f, -1.02334164e-01f, -1.10376924e-01f, -3.26733112e-01f,
  -7.05219433e-03f, 6.10688180e-02f, 4.75217283e-01f, 5.28375447e-01f, -5.28401993e-02f, 8.85950476e-02f, -3.12317669e-01f, -2.96558052e-01f, -1.28543317e-01f, -1.57942086e-01f,
  2.11977303e-01f, -9.05022323e-02f, 4.13262025e-02f, -9.93390456e-02f, -2.53840033e-02f, -6.03711419e-02f, -4.59572859e-03f, 7.99977556e-02f, 1.15393139e-02f, -2.47642919e-02f,
  2.21686922e-02f, -3.50049175e-02f, -1.61040127e-02f, 5.87615333e-02f, -6.20315522e-02f, -3.18596028e-02f, -7.08978102e-02f, -5.49479648e-02f, 2.40385383e-02f, -1.30916402e-01f,
  -2.09783763e-03f, 6.76054228e-03f, 1.17324613e-01f, -9.30982530e-02f, -9.85297114e-02f, -1.00929052e-01f, -4.31110933e-02f, 1.15603000e-01f, -1.66653227e-02f, 3.57235447e-02f,
  4.22316827e-02f, -1.39550254e-01f, -5.61887249e-02f, 1.17392778e-01f, -1.05553880e-01f, 1.40833795e-01f, 1.40361162e-03f, 1.76965818e-02f, 2.23157436e-01f, -6.62953034e-02f,
  2.87397560e-02f, -1.29926175e-01f, 1.75467297e-01f, 6.40107542e-02f, -1.26584992e-01f, -2.80352712e-01f, -7.11983740e-02f, -9.85649899e-02f, -1.87558070e-01f, -1.24378428e-01f,
  1.62140325e-01f, 1.14373490e-01f, 1.92621857e-01f, -5.81975639e-01f, 1.11155167e-01f, 1.49319842e-01f, 1.77258909e-01f, 4.83742863e-01f, 1.10613622e-01f, -2.45704819e-02f,
  -5.76163381e-02f, -1.71817794e-01f, -3.41470279e-02f, -2.24480897e-01f, -1.31094202e-01f, 3.81814651e-02f, 2.52281651e-02f, 1.32146135e-01f, -8.66727084e-02f, -3.93937789e-02f,
  2.15642247e-02f, 1.73911974e-01f, -4.43745777e-02f, -5.10003455e-02f, -5.64148054e-02f, -5.55849224e-02f, 2.61311326e-02f, -1.05246482e-02f, -8.92831832e-02f, -5.50447851e-02f,
  -2.93564759e-02f, 3.36673073e-02f, 2.00135529e-01f, 1.10101081e-01f, 3.62822600e-02f, 5.65675497e-02f, 4.07159589e-02f, -1.42633170e-01f, 5.88870235e-02f, 1.64872948e-02f,
  -3.13515961e-02f, 1.57242462e-01f, 8.80094245e-02f, 6.54143170e-02f, 6.29157275e-02f, -9.51163545e-02f, -1.22364044e-01f, -9.71990265e-03f, -2.37339407e-01f, 1.01901088e-02f,
  -1.71642840e-01f, 6.12136759e-02f, -8.86497498e-02f, 5.72345406e-02f, 3.08891814e-02f, 1.72553375e-01f, 3.09223771e-01f, 1.74522415e-01f, 3.07149887e-01f, 8.05870518e-02f,
  -1.38745382e-01f, -9.71190855e-02f, 4.75960150e-02f, 2.19817851e-02f, -1.52579740e-01f, -3.00377305e-03f, 7.51492009e-02f, -1.22301996e-01f, -1.21219166e-01f, -2.21188322e-01f,
  7.00687394e-02f, 3.76255102e-02f, 3.46265793e-01f, 2.45226488e-01f, -2.15289652e-01f, -3.51670593e-01f, -5.65159880e-02f, -4.84255552e-02f, -1.19943671e-01f, 1.45733312e-01f,
  2.68139280e-02f, 1.64618522e-01f, -1.02267057e-01f, 1.06101021e-01f, 1.09553605e-01f, 1.73960060e-01f, -8.52312613e-03f, -1.38129726e-01f, -5.89179434e-02f, -2.69094650e-02f,
  -4.46757190e-02f, 9.81204435e-02f, -6.14085346e-02f, 3.65204178e-02f, -9.88813210e-03f, 1.26889542e-01f, 1.13187015e-01f, 1.15290217e-01f, 4.13210504e-02f, -1.54215586e-03f,
  1.15160793e-01f, 2.92727612e-02f, 6.63778111e-02f, -5.17022684e-02f, 2.95572821e-02f, 4.79404368e-02f, -4.13124226e-02f, -9.67167914e-02f, 7.58782681e-03f, 1.14716282e-02f,
  3.73487100e-02f, 1.22064628e-01f, -1.79296091e-01f, 9.80652720e-02f, -6.93537816e-02f, -2.33134604e-03f, 3.48722003e-02f, -1.45340756e-01f, -1.13960415e-01f, -2.08578054e-02f,
  3.97627754e-03f, 2.44784623e-01f, 3.07649642e-01f, 1.96240678e-01f, 3.61978710e-02f, -1.41710103e-01f, 7.15902597e-02f, 2.95535028e-02f, -1.05614088e-01f, -1.18503943e-01f,
  -7.87934884e-02f, -2.07406823e-02f, 6.51111081e-02f, -8.56798738e-02f, -2.50686824e-01f, -5.96966781e-03f, -1.14931367e-01f, 2.35570177e-01f, -2.24154219e-01f, -9.21555609e-03f,
  -3.00070465e-01f, 3.83397043e-02f, -2.59848088e-01f, 4.49194252e-01f, 2.30337068e-01f, 4.64223400e-02f, -5.58233412e-04f, 5.30157797e-02f, -4.99216616e-02f, 2.18626216e-01f,
  1.75312180e-02f, 1.46324486e-02f, -1.65705070e-01f, -4.97269519e-02f, 2.41434649e-01f, -2.46484905e-01f, 1.75839782e-01f, -9.27112475e-02f, -2.01277867e-01f, -2.43730843e-02f,
  1.39127001e-01f, 2.16172412e-02f, 2.30855718e-01f, 1.09437138e-01f, -6.99436814e-02f, -1.52391583e-01f, 1.18054003e-01f, 1.77058026e-01f, -4.97955680e-02f, -1.09973274e-01f,
  -2.27305084e-01f, 1.33746326e-01f, 1.22572199e-01f, -1.07027702e-01f, -4.34096018e-03f, -1.18255928e-01f, -1.30609989e-01f, -1.42620116e-01f, 3.57381403e-02f, 4.90136556e-02f,
  6.30279332e-02f, 2.17137679e-01f, 2.14158863e-01f, 2.04770356e-01f, 2.71193385e-01f, 1.93355829e-01f, 3.83780561e-02f, -1.62391633e-01f, 1.14230603e-01f, 1.03657246e-01f,
  -1.69554532e-01f, -2.19939724e-01f, 3.14939886e-01f, 1.08062573e-01f, -1.83485538e-01f, -2.99979467e-02f, -3.97728562e-01f, -7.83953350e-03f, 2.01228499e-01f, 1.69598639e-01f,
  4.20574963e-01f, -9.87942666e-02f, -6.82116719e-03f, -1.79920167e-01f, 8.39967579e-02f, -1.05038568e-01f, 3.60811323e-01f, 1.39529362e-01f, -9.13353935e-02f, 3.85156423e-02f,
  -7.30613396e-02f, 7.05524581e-03f, 4.33787331e-02f, -4.36714366e-02f, -7.25908354e-02f, -7.70150870e-02f, -6.69343024e-03f, 6.01699948e-02f, -3.60371433e-02f, -4.20116708e-02f,
  9.44206640e-02f, 3.58791091e-02f, 1.64703786e-01f, 1.31694138e-01f, -1.03578031e-01f, -1.48250908e-02f, 1.51462227e-01f, -4.27788049e-02f, 7.50855356e-02f, 2.12373897e-01f,
  -1.26233056e-01f, 4.05258732e-03f, -4.13307399e-02f, 2.85989512e-02f, 9.64913294e-02f, -1.43160746e-01f, 1.03103004e-01f, 9.85578448e-02f, 2.56996572e-01f, -6.27286434e-02f,
  1.11463815e-01f, 8.49435180e-02f, 1.56316578e-01f, -1.57329738e-01f, -1.01134390e-01f, -1.10535948e-02f, -9.00076181e-02f, -8.81911442e-02f, -2.77675509e-01f, -1.23188563e-01f,
  -1.94788307e-01f, 2.18694031e-01f, -2.08218619e-01f, -1.68462113e-01f, 3.55806768e-01f, 1.57558188e-01f, -2.80107498e-01f, -5.17347967e-03f, -1.69643268e-01f, -2.98380684e-02f,
  2.09933192e-01f, -1.31427854e-01f, 2.29416177e-01f, -5.77378869e-01f, -8.58794153e-02f, -1.29659250e-01f, -2.97804829e-02f, 7.29090497e-02f, -3.46828252e-02f, -2.36215838e-03f,
  7.49110579e-02f, 1.23334579e-01f, -3.35577037e-03f, -7.65406191e-02f, 4.40227762e-02f, -3.33188400e-02f, -1.14939682e-01f, 1.27417967e-01f, -1.70588359e-01f, -1.05694413e-01f,
  -1.00415729e-01f, 2.90813926e-03f, -1.03249624e-01f, 2.07329780e-01f, -1.07727639e-01f, -1.80791482e-01f, -1.21336870e-01f, 3.26550603e-02f, 6.34161308e-02f, -1.25721857e-01f,
  -1.25366757e-02f, 1.01940714e-01f, 6.45472482e-03f, 1.10030003e-01f, -1.62958682e-01f, 3.16208079e-02f, -2.16361042e-02f, 1.03013620e-01f, 1.74821466e-01f, 1.17344856e-02f,
  7.67118260e-02f, -3.00098926e-01f, -1.85153291e-01f, 1.14055052e-01f, -1.33798912e-01f, 7.91014731e-02f, 1.59045700e-02f, -3.29303346e-03f, 1.05463779e-02f, 7.93538615e-02f,
  4.71768156e-02f, 8.96039605e-03f, 4.43752334e-02f, 1.20854676e-01f, 1.92900568e-01f, 4.13656756e-02f, 5.68782352e-02f, 1.64476112e-02f, 4.50055338e-02f, -2.40649045e-01f,
  1.85117170e-01f, -7.29892403e-02f, -6.59722760e-02f, -5.99451482e-01f, -1.28369614e-01f, 3.34053665e-01f, 1.83695346e-01f, 2.44480729e-01f, -1.17791951e-01f, -4.42115888e-02f,
  -4.26827148e-02f, -1.23218596e-01f, -1.66433528e-01f, 2.27660909e-01f, 1.26405984e-01f, 1.04944885e-01f, 7.93225169e-02f, 2.87526026e-02f, 7.57597107e-03f, -2.38548573e-02f,
  3.34792025e-02f, -1.71420481e-02f, -3.17280786e-03f, -1.27893075e-01f, -8.28812942e-02f, -6.61900872e-03f, -1.00072762e-02f, -1.20705709e-01f, -9.57912356e-02f, -1.01460017e-01f,
  -1.02823354e-01f, -9.96119604e-02f, 5.38943196e-03f, -7.15755001e-02f, -9.36758444e-02f, -2.27346942e-02f, -1.19838342e-02f, -5.29739261e-02f, -1.28062069e-01f, 9.06982496e-02f,
  4.06001695e-02f, 5.39799631e-02f, -6.60205111e-02f, 1.40205353e-01f, 1.04298564e-02f, -1.14190482e-01f, 1.16142541e-01f, 1.07803062e-01f, -1.48782477e-01f, 3.52898799e-02f,
  -1.97206184e-01f, 6.04088698e-03f, 1.35178849e-01f, -9.60687771e-02f, -1.02953881e-01f, 6.09513093e-03f, 1.47476524e-01f, 1.83844045e-01f, -1.94283277e-02f, -2.31376626e-02f,
  1.05433732e-01f, -8.54030028e-02f, 5.42228669e-02f, -2.79612723e-03f, 1.58452064e-01f, -1.17062507e-02f, 3.99842232e-01f, -4.86780822e-01f, 2.04204962e-01f, 3.73724610e-01f,
  -2.30027452e-01f, 2.08761960e-01f, -5.34005500e-02f, -1.15558840e-01f, -8.66541937e-02f, -1.04961500e-01f, -3.58351246e-02f, 2.11660966e-01f, -3.70429680e-02f, -2.95297086e-01f,
  5.28633632e-02f, 9.29962657e-03f, -6.90952614e-02f, -2.35050321e-02f, 2.75995076e-01f, 1.41219258e-01f, -8.43271390e-02f, 8.33999813e-02f, -1.32471934e-01f, 8.49946812e-02f,
  3.81514914e-02f, -4.34631296e-02f, -6.93564415e-02f, 1.33097470e-01f, 1.49925187e-01f, 2.26727519e-02f, 6.58609346e-03f, 3.30567986e-01f, 7.48329312e-02f, -9.23126489e-02f,
  -1.32051498e-01f, -1.42655522e-01f, 1.63348019e-01f, -2.90432721e-02f, -2.00871646e-01f, -5.04811071e-02f, -5.20169586e-02f, 2.39647031e-02f, 5.15290909e-02f, -1.06761865e-01f,
  -1.62037805e-01f, -2.29331497e-02f, -8.00320506e-02f, 9.19050425e-02f, 5.54835983e-02f, 1.79427247e-02f, -1.57000765e-01f, 1.10926874e-01f, -6.02678694e-02f, 3.51015657e-01f,
  -1.89225271e-01f, 2.12831706e-01f, 5.13473213e-01f, 3.50894660e-01f, -5.37546389e-02f, 1.25865892e-01f, 8.82870480e-02f, 5.31327017e-02f, -2.51696616e-01f, -4.98732477e-02f,
  -2.94788927e-01f, 8.86701941e-02f, -4.22261834e-01f, -2.90824682e-01f, 1.11411773e-01f, -1.14195123e-01f, 3.17946412e-02f, 4.51064147e-02f, -3.23284358e-01f, -7.91959837e-02f,
  1.32577613e-01f, 9.49090123e-02f, 6.33337125e-02f, 4.60908800e-01f, 7.39842504e-02f, -2.15172581e-02f, -8.24952647e-02f, -1.34402111e-01f, -1.72633514e-01f, -1.41803105e-03f,
  -9.04555526e-03f, -2.17817407e-02f, 8.58105347e-02f, 9.29425433e-02f, -9.66139808e-02f, 5.57448752e-02f, -1.51953354e-01f, -8.10748264e-02f, 3.94661315e-02f, -2.31463552e-01f,
  -4.39545140e-02f, -2.77184755e-01f, 6.80472925e-02f, 8.64566769e-03f, 9.95040983e-02f, -4.13505547e-02f, -1.25672892e-01f, 4.01605330e-02f, -1.03320852e-01f, -1.90846831e-01f,
  -2.76081771e-01f, 2.33277678e-02f, 1.64917976e-01f, -3.80369365e-01f, -1.43988550e-01f, 1.85491860e-01f, -1.58787191e-01f, -4.69360314e-02f, -8.48364606e-02f, 1.75981019e-02f,
  5.50297461e-02f, 2.75943577e-02f, 1.43749148e-01f, 1.01915687e-01f, 2.90546000e-01f, 1.47043332e-01f, -1.02016091e-01f, 1.10803120e-01f, 5.97160719e-02f, -1.06534459e-01f,
  -2.34465361e-01f, -2.29171365e-01f, 4.12320271e-02f, 5.91957420e-02f, -3.95501219e-02f, -1.07602395e-01f, -2.26589665e-01f, 1.63540021e-01f, -4.33757335e-01f, -2.33513534e-01f,
  1.20241821e-01f, 7.22310767e-02f, 4.99176800e-01f, 4.99492511e-02f, 8.98070186e-02f, 6.83261640e-03f, -3.75708580e-01f, 2.64664292e-01f, 4.47393134e-02f, 6.66694790e-02f,
  -2.86722165e-02f, 2.03407317e-01f, 2.13164464e-02f, 4.39555198e-02f, 9.34775472e-02f, -1.39914528e-01f, 5.05518168e-03f, 2.70598438e-02f, 7.51073798e-03f, 5.26655018e-02f,
  1.50556248e-02f, -2.64351722e-02f, -2.42908057e-02f, 7.62774199e-02f, -3.52660986e-03f, 1.92316025e-01f, -1.02946259e-01f, -6.86428621e-02f, 5.66169545e-02f, -9.94570851e-02f,
  8.40222239e-02f, -9.47289094e-02f, 3.47019881e-02f, 9.53113362e-02f, 1.79750249e-01f, 1.95152666e-02f, -4.22463007e-02f, 3.03140998e-01f, -5.68498559e-02f, 3.16822529e-02f,
  -5.99734485e-02f, -5.86553179e-02f, -1.72608659e-01f, 8.57300963e-03f, -1.30694643e-01f, 1.64340094e-01f, -1.82527363e-01f, -6.20778874e-02f, -1.01949438e-01f, 1.60954162e-01f,
  2.36698613e-01f, 1.14959590e-01f, 3.64088863e-02f, -9.84743312e-02f, 1.46953300e-01f, 9.42776948e-02f, -8.68598521e-02f, -1.03154577e-01f, 1.94319308e-01f, -2.26255774e-01f,
  2.73276925e-01f, -1.79928228e-01f, 5.94367422e-02f, 2.18727201e-01f, -3.25519800e-01f, 1.11451484e-01f, -4.72195953e-01f, 3.54139768e-02f, -2.21778732e-02f, 8.34476203e-02f,
  1.52051196e-01f, -1.89081132e-01f, 1.29594460e-01f, 1.75156966e-02f, 1.98679809e-02f, -4.13070433e-04f, 2.69409958e-02f, 2.27392614e-02f, -8.13990552e-03f, 5.47503382e-02f,
  7.54157379e-02f, 1.77346841e-01f, 1.69354510e-02f, 2.73482576e-02f, 2.60246005e-02f, 5.39958291e-02f, 1.63335223e-02f, 1.72797516e-01f, 1.73465073e-01f, -9.95787233e-02f,
  9.12813768e-02f, 7.99626112e-02f, -9.60953981e-02f, -1.23146251e-01f, 1.50453433e-01f, 1.71075583e-01f, 2.63464525e-02f, -5.32194860e-02f, -6.90632612e-02f, -1.11983508e-01f,
  -7.26409405e-02f, -2.80643683e-02f, -1.95669308e-01f, 2.81946757e-03f, -7.83048272e-02f, 3.17221042e-03f, 4.46719825e-02f, 9.96236950e-02f, 7.07741901e-02f, -1.37146503e-01f,
  6.34331256e-02f, 3.40346619e-02f, 1.43312454e-01f, -8.92009363e-02f, 9.24862362e-03f, -1.64691702e-01f, 7.75689408e-02f, 4.69496548e-02f, -3.53319615e-01f, -2.09970012e-01f,
  1.49613902e-01f, 4.23963107e-02f, -1.10912494e-01f, -8.40651542e-02f, -3.15787911e-01f, 3.75734925e-01f, 5.79855621e-01f, -4.10390124e-02f, -2.18609378e-01f, -1.88997969e-01f,
  -7.62651041e-02f, -2.70375516e-02f, -1.71975285e-01f, -2.90218126e-02f, 1.24952465e-01f, 7.67521113e-02f, 2.07815602e-01f, 2.28301380e-02f, -2.60836277e-05f, -2.41034944e-02f,
  1.41533419e-01f, -1.59825303e-03f, 4.99202833e-02f, 4.81601246e-02f, 4.53393422e-02f, -8.26466829e-02f, -2.09627803e-02f, 9.03890748e-03f, -5.58927050e-03f, 6.29875436e-02f,
  7.21808821e-02f, -1.94881022e-01f, 1.71452593e-02f, 6.57178611e-02f, -6.86965287e-02f, 4.61723097e-03f, 5.11457473e-02f, -1.47520564e-02f, -7.65954182e-02f, -4.93909307e-02f,
  4.43702750e-03f, -9.31114703e-02f, -9.08254236e-02f, 1.10493731e-02f, -3.80474739e-02f, 2.41398811e-01f, -1.31852245e-02f, -1.06065139e-01f, 6.11963235e-02f, 6.85584471e-02f,
  2.56355852e-02f, 6.51530130e-03f, 9.73660424e-02f, -5.08308373e-02f, -5.99501692e-02f, -8.52746889e-02f, -2.57318228e-01f, -1.44238189e-01f, -2.09225997e-01f, -1.56768054e-01f,
  5.02879284e-02f, 3.41680236e-02f, 4.07535508e-02f, -3.24545726e-02f, 2.19934985e-01f, -6.47357898e-03f, 1.75364628e-01f, -1.01114623e-01f, 8.12139586e-02f, 1.52553380e-01f,
  6.34819329e-01f, 7.75963906e-03f, -3.08387876e-01f, 1.39464304e-01f, -1.69259816e-01f, -1.04047514e-01f, -2.58537322e-01f, 1.16075017e-01f, -6.22297786e-02f, -2.90287226e-01f
};

// L1_fan_Wp_bar (Shape: 14 x 64)
const int L1_fan_Wp_bar_rows = 14;
const int L1_fan_Wp_bar_cols = 64;
const float L1_fan_Wp_bar_data[] = {
  -2.61010885e-01f, -1.00348517e-01f, 1.19710505e-01f, 1.52618334e-01f, -8.65336731e-02f, -6.88510984e-02f, 1.64825842e-01f, 1.74254581e-01f, 3.19704354e-01f, 3.77172291e-01f,
  -1.37806134e-02f, 2.53351480e-01f, 2.42428645e-01f, 5.40682971e-02f, 9.70780179e-02f, 1.61359261e-03f, -6.00057058e-02f, 4.84195471e-01f, 1.39240563e-01f, 1.24712899e-01f,
  -5.14368266e-02f, 4.60925132e-01f, 3.85186136e-01f, -1.17434561e-02f, 1.21931493e-01f, -9.71657857e-02f, 2.31228277e-01f, -1.45121545e-01f, 1.44887138e-02f, 4.12457526e-01f,
  1.49103150e-01f, -2.06110671e-01f, 3.24550569e-01f, -4.26375680e-02f, 2.26534028e-02f, -9.04187486e-02f, -1.32128820e-01f, -4.91974913e-02f, 3.75999697e-02f, -2.14970365e-01f,
  -8.11448336e-01f, -2.53542066e-01f, -1.37042254e-01f, -4.26007845e-02f, -2.41596140e-02f, 3.39014590e-01f, 5.71464598e-01f, 2.89777783e-03f, 1.30055800e-01f, -1.66107006e-02f,
  5.77979982e-02f, 2.04945683e-01f, 5.24863064e-01f, -6.03865325e-01f, 6.85879767e-01f, 6.32600069e-01f, -1.42277926e-01f, -6.16957247e-02f, -4.78548199e-01f, -1.12000592e-01f,
  -2.14177534e-01f, 4.43665534e-02f, 2.68744349e-01f, 6.97582603e-01f, 4.51029539e-02f, 1.91142693e-01f, 8.09890181e-02f, -9.45498049e-03f, 1.89629897e-01f, -1.93399191e-01f,
  8.60508755e-02f, 7.16862455e-02f, -7.65964836e-02f, -7.73009434e-02f, 1.04099914e-01f, 8.53480864e-03f, -1.49292961e-01f, 9.94138122e-02f, 5.73603846e-02f, 1.63525730e-01f,
  1.05759300e-01f, -2.01492116e-01f, 1.18514940e-01f, -2.05639184e-01f, 2.12940827e-01f, 2.86692023e-01f, -6.81975707e-02f, 8.46940130e-02f, 2.18257174e-01f, -4.92033251e-02f,
  1.57784119e-01f, 4.91683781e-02f, 7.68401474e-03f, -6.48638085e-02f, 3.62045467e-01f, -2.31870469e-02f, 1.20523125e-01f, -6.22990318e-02f, 2.70437390e-01f, -1.70436859e-01f,
  1.28932536e-01f, -2.46835843e-01f, 1.50345594e-01f, -2.47785181e-01f, 3.77276033e-01f, -1.78598881e-01f, -4.07463729e-01f, -2.28618324e-01f, 6.12706207e-02f, -4.21198234e-02f,
  5.68515547e-02f, -6.16440475e-02f, 2.38920413e-02f, 3.12584490e-01f, 7.11971462e-01f, -1.12470798e-01f, 9.65138018e-01f, 9.03947413e-01f, 8.82924497e-02f, -3.48154634e-01f,
  1.84532523e-01f, 2.26876531e-02f, 9.64809954e-01f, 5.89349508e-01f, 2.94979006e-01f, -8.34852010e-02f, -2.52042890e-01f, -1.05539106e-01f, 4.26580131e-01f, 3.66779238e-01f,
  -4.94634360e-02f, 1.88797280e-01f, 3.81814778e-01f, 1.99146956e-01f, 2.45200172e-01f, -4.81013954e-03f, 3.10961813e-01f, 3.36135209e-01f, 2.53221154e-01f, 3.26660395e-01f,
  -1.10914312e-01f, 2.94243783e-01f, 2.80084640e-01f, 6.58017755e-01f, 1.28118575e-01f, 2.53806233e-01f, 4.53074247e-01f, 1.45021453e-02f, 2.12261975e-01f, -4.10001650e-02f,
  3.14191580e-01f, 8.03098559e-01f, 9.70832407e-02f, -4.22628105e-01f, 4.04172689e-01f, 1.15734801e-01f, -2.85937339e-01f, -1.69177711e-01f, 5.10732293e-01f, 5.74495532e-02f,
  1.34074926e-01f, -1.08536772e-01f, -4.35832053e-01f, -2.80435562e-01f, -1.26091182e-01f, -3.23043555e-01f, -2.61924323e-02f, -1.61520034e-01f, 8.77801716e-01f, 6.87025860e-02f,
  1.34791091e-01f, 3.44747752e-01f, 1.29594162e-01f, -3.77369344e-01f, 1.76640496e-01f, 1.05016612e-01f, -1.15991034e-01f, 1.67242408e-01f, 5.38648486e-01f, -3.29480141e-01f,
  9.07260239e-01f, 3.96580845e-01f, 2.58603036e-01f, -1.12224683e-01f, -3.03528041e-01f, -3.52668285e-01f, 4.75639224e-01f, 6.88573539e-01f, 3.61358851e-01f, -1.24737963e-01f,
  -4.64921653e-01f, 7.74160981e-01f, 1.56972017e-02f, 7.77520016e-02f, 1.92339167e-01f, 7.40836263e-02f, -7.22932909e-03f, -1.57783963e-02f, 2.72277772e-01f, 2.27152810e-01f,
  1.93177760e-01f, 3.00240815e-01f, -1.32150352e-01f, 8.26663971e-02f, 1.62866578e-01f, 1.28640547e-01f, 3.71250510e-02f, -2.92316359e-02f, 6.30931556e-02f, 3.38843375e-01f,
  2.06907108e-01f, 4.27119061e-02f, -8.10719728e-02f, 1.49651110e-01f, 5.75602762e-02f, 2.44008109e-01f, -2.00818926e-02f, 7.14838654e-02f, -4.43213373e-01f, 1.14299342e-01f,
  -9.15709510e-02f, 1.26332417e-02f, -4.30422962e-01f, 2.35317692e-01f, -8.26945156e-03f, -2.58138776e-01f, -1.30479753e-01f, 5.57781681e-02f, -4.88814898e-02f, 1.43402204e-01f,
  3.20416018e-02f, 4.64693680e-02f, -2.13940412e-01f, -2.43762195e-01f, 8.70376453e-03f, -1.23588823e-01f, 1.61597997e-01f, 1.47756219e-01f, -6.41913652e-01f, -2.53374547e-01f,
  1.01634726e-01f, -3.13562937e-02f, -2.97794074e-01f, 7.38479972e-01f, -5.39785862e-01f, -8.95935111e-03f, 4.33048606e-02f, 6.65318429e-01f, 6.13497794e-01f, -1.61796138e-01f,
  3.63119662e-01f, -2.56063100e-02f, 4.57716852e-01f, 1.00053940e-02f, 1.93144217e-01f, -6.54803440e-02f, 3.31996292e-01f, 4.79177870e-02f, 1.09777324e-01f, -4.35927287e-02f,
  2.88269699e-01f, -1.28033042e-01f, -1.15615716e-02f, 3.88246357e-01f, -8.07049870e-02f, -1.60894185e-01f, 1.02709502e-01f, -1.01882063e-01f, 1.24776416e-01f, 2.66026169e-01f,
  1.32683411e-01f, 4.14611846e-01f, 3.03034484e-01f, -2.11957544e-01f, 8.92357454e-02f, 2.01073475e-02f, 6.00551292e-02f, 1.11104669e-02f, 2.03388687e-02f, 4.85385805e-01f,
  1.74723759e-01f, -2.16294035e-01f, -3.21117520e-01f, 2.11831063e-01f, 6.43365160e-02f, -2.29521006e-01f, -1.13522381e-01f, -9.29494724e-02f, 1.67628899e-02f, -2.16437820e-02f,
  4.66250777e-01f, -1.08917393e-02f, 2.49975801e-01f, -3.54423404e-01f, 5.14951022e-03f, 7.99941421e-02f, 2.13116948e-02f, -4.23364431e-01f, -5.25933385e-01f, -2.65765488e-01f,
  1.69199899e-01f, 1.83845341e-01f, -7.69315541e-01f, -3.01805735e-01f, -1.81306332e-01f, 1.35392576e-01f, -2.78808530e-02f, 3.04656446e-01f, -2.11926118e-01f, 8.96336555e-01f,
  2.66679198e-01f, -9.00439978e-01f, 5.69779612e-02f, -2.77601033e-01f, 6.27286792e-01f, 4.14751768e-02f, 1.13390513e-01f, 2.29909942e-02f, 2.11649179e-01f, -3.16751450e-01f,
  6.49772072e-03f, 5.37829148e-03f, 2.09510233e-02f, 9.86905992e-02f, 3.25650692e-01f, 3.81141216e-01f, -1.47023797e-02f, 1.21672407e-01f, -1.30612954e-01f, -2.72802591e-01f,
  1.51796117e-01f, -1.04690447e-01f, 1.07149675e-01f, 9.48184878e-02f, -9.30668563e-02f, 4.76938672e-02f, 4.66892809e-01f, 1.65901974e-01f, 4.26377244e-02f, 9.27775130e-02f,
  3.39985162e-01f, -3.78482997e-01f, 2.15117365e-01f, -4.05622050e-02f, 2.40590096e-01f, 2.47906804e-01f, -1.64024293e-01f, 4.63839263e-01f, 3.04241657e-01f, -4.19434786e-01f,
  -4.43098247e-01f, -1.59898669e-01f, -5.11205494e-01f, 1.73370585e-01f, 3.54816854e-01f, 3.42610866e-01f, 1.73227102e-01f, 3.58871937e-01f, -9.66756344e-02f, -8.39216262e-02f,
  -2.18107039e-03f, 6.02348566e-01f, 3.85832116e-02f, -1.40020519e-01f, -2.46445820e-01f, 1.42202586e-01f, -1.21524364e-01f, 7.49756619e-02f, 2.46018216e-01f, -1.81649745e-01f,
  -4.65275019e-01f, -5.61621666e-01f, -2.24914849e-01f, 3.72088999e-01f, 6.06648147e-01f, 3.32146101e-02f, 5.69428623e-01f, -2.30951291e-02f, 3.33373696e-01f, -5.40660977e-01f,
  -4.31950867e-01f, -2.17870891e-01f, 1.39117241e-01f, -2.90017247e-01f, 1.19164973e-01f, -2.32233424e-02f, 1.13703541e-01f, 2.48351708e-01f, -3.60250324e-02f, 1.30164698e-01f,
  1.44671053e-01f, 2.19393879e-01f, 1.92370251e-01f, -3.10019311e-02f, 5.74172474e-02f, -6.79135695e-02f, 9.37670022e-02f, 6.91233873e-02f, -9.28071141e-02f, 5.92142381e-02f,
  1.78913265e-01f, 3.18402678e-01f, 1.49218421e-02f, 1.58091277e-01f, 2.96406478e-01f, 1.16121896e-01f, 4.91895497e-01f, -2.15087727e-01f, -1.13453969e-01f, -1.33075684e-01f,
  1.44504860e-01f, 1.87777981e-01f, 1.50168613e-01f, 6.90651685e-02f, 2.49152929e-01f, -1.86485112e-01f, 1.53367653e-01f, -5.99629339e-03f, -2.58479506e-01f, 2.82439828e-01f,
  8.19982495e-03f, -2.06861552e-02f, 5.24244271e-02f, -1.80456072e-01f, 1.45840481e-01f, 2.10629135e-01f, -2.44378194e-01f, -1.78748578e-01f, 1.79906130e-01f, -3.43041262e-03f,
  5.11443734e-01f, -1.15598172e-01f, 1.09826729e-01f, 8.66620690e-02f, 2.60416955e-01f, -3.23247433e-01f, 5.57363451e-01f, -1.79242522e-01f, -7.65201598e-02f, 6.03193402e-01f,
  5.85051700e-02f, -2.44031623e-01f, 1.58118188e-01f, -7.58620203e-02f, -3.19971651e-01f, -1.20133996e-01f, -9.93236303e-02f, 6.51988447e-01f, -9.78244394e-02f, 2.01612681e-01f,
  -2.19526477e-02f, -4.85657342e-02f, 5.82439601e-02f, 2.32466273e-02f, 2.93713897e-01f, 7.09704822e-03f, -1.13620900e-01f, 5.15640974e-02f, 1.13942914e-01f, 4.81490083e-02f,
  7.05799237e-02f, 1.58173367e-01f, 1.11290678e-01f, 4.24439788e-01f, -2.49566883e-02f, 1.25075668e-01f, 1.18652418e-01f, 1.84636399e-01f, -9.76724997e-02f, 2.56369282e-02f,
  1.06478706e-01f, 1.09452881e-01f, 2.94083953e-01f, -1.40611067e-01f, -1.36076957e-01f, 7.08604008e-02f, -2.48184189e-01f, 6.91942126e-02f, 2.46612027e-01f, -1.88447714e-01f,
  3.99354585e-02f, -1.92900196e-01f, 1.80708259e-01f, -1.04926676e-01f, 1.20199330e-01f, 2.30678301e-02f, -1.93044171e-02f, 3.22891138e-02f, -2.07725480e-01f, -3.28017801e-01f,
  3.56330514e-01f, 5.19571841e-01f, -1.41505495e-01f, 3.40120763e-01f, 1.82777107e-01f, 5.13755858e-01f, -3.64356041e-01f, -1.80380508e-01f, -3.93685848e-01f, 7.44640052e-01f,
  1.46030471e-01f, -1.43229619e-01f, 5.84283769e-01f, -5.94249010e-01f, 4.16569889e-01f, 9.24768597e-02f, 3.04253072e-01f, -2.66990006e-01f, 2.62981504e-01f, 1.98663652e-01f,
  3.63878876e-01f, -2.78764278e-01f, -1.92985702e-02f, 8.76890495e-02f, 7.23572895e-02f, 6.26423508e-02f, 1.79277584e-01f, -4.38997475e-03f, 2.39000320e-01f, -7.99157321e-02f,
  8.21987689e-02f, 2.89242789e-02f, 1.67254806e-01f, 1.39809921e-01f, -1.18370131e-01f, 1.67014748e-01f, -1.10889219e-01f, -1.11300498e-04f, 2.94713110e-01f, 1.78154379e-01f,
  -8.81504454e-03f, 6.08496889e-02f, 2.33027786e-01f, -1.51961937e-03f, 6.61679208e-02f, 2.09416583e-01f, 1.43325105e-01f, 2.13225693e-01f, -2.02116091e-02f, 2.06525117e-01f,
  -9.17030349e-02f, -7.48571660e-03f, -2.19930455e-01f, 3.37250233e-02f, -2.68059760e-01f, -1.32770330e-01f, -3.00823569e-01f, -8.35336372e-02f, 1.29922241e-01f, 3.85759771e-02f,
  9.06500965e-02f, -1.46361783e-01f, -7.26011209e-03f, 7.32646286e-02f, -2.37856910e-01f, -5.03054857e-01f, -1.88225910e-01f, -3.28699350e-02f, -4.40689102e-02f, -3.75311077e-01f,
  4.42966431e-01f, -2.03193486e-01f, 4.98442113e-01f, -5.63599586e-01f, 5.08321941e-01f, 4.79228139e-01f, 8.59257936e-01f, 6.40695333e-01f, 1.90933943e-01f, -1.96662590e-01f,
  5.65392710e-02f, -3.95460501e-02f, -2.44577318e-01f, -3.31856936e-01f, 3.65405530e-01f, -2.41217703e-01f, 1.73828140e-01f, 1.32418111e-01f, 2.57181972e-01f, 3.72973643e-02f,
  5.37189096e-02f, -1.75850634e-02f, 5.52593619e-02f, 2.29638085e-01f, 2.91115731e-01f, 1.16122343e-01f, 3.23588364e-02f, 1.13034628e-01f, 1.23807952e-01f, 6.73174262e-02f,
  -1.13322705e-01f, -2.88501242e-03f, 9.53065977e-02f, 1.85560182e-01f, 1.00216446e-02f, 1.48323193e-01f, 1.17708929e-01f, 1.46237701e-01f, 2.43492573e-01f, 2.38421917e-01f,
  3.33459944e-01f, 1.53755754e-01f, -2.22625241e-01f, -1.97424740e-02f, -1.15882671e-02f, -7.66676813e-02f, -1.23374164e-01f, -2.62640826e-02f, 1.03649348e-01f, -2.95729846e-01f,
  9.24833789e-02f, 7.92301372e-02f, 1.79420233e-01f, 9.56813693e-02f, 3.69428098e-02f, -1.31950378e-01f, 8.13060105e-02f, -5.76059408e-02f, 8.83833766e-02f, -2.45702401e-01f,
  -4.84719053e-02f, 7.15905800e-02f, -4.61664319e-01f, -1.45560846e-01f, 1.89923897e-01f, -1.73725262e-01f, -2.36120075e-01f, 1.74163729e-01f, 1.09508699e-02f, -2.61280507e-01f,
  6.94382608e-01f, 5.74103892e-01f, 4.48616654e-01f, 1.21513218e-01f, 6.34774864e-01f, 6.07354939e-02f, -8.96644741e-02f, -3.60636264e-01f, 6.81921318e-02f, 4.11930634e-03f,
  -2.52294987e-01f, -3.68615310e-03f, 1.74808688e-02f, 6.40374050e-02f, 8.20314735e-02f, 1.52655199e-01f, -3.74030285e-02f, 1.88825697e-01f, -8.25846419e-02f, 3.73734254e-03f,
  3.99104580e-02f, 1.28322378e-01f, 1.33901060e-01f, -3.90139855e-02f, 1.22692578e-01f, 9.53354090e-02f, -1.76774502e-01f, -4.57885787e-02f, 2.47502178e-02f, 2.02515304e-01f,
  8.31366424e-03f, 5.11055529e-01f, 1.15106143e-01f, -1.15523852e-01f, 3.06080393e-02f, -2.02778950e-01f, 6.58437312e-02f, -1.06371135e-01f, 1.09275840e-01f, -4.29623900e-03f,
  1.11194752e-01f, -1.73388168e-01f, 3.30250770e-01f, -1.36737853e-01f, 3.48967314e-01f, -3.52931321e-02f, -2.60329694e-02f, -1.07893482e-01f, 1.70465279e-02f, 1.92745384e-02f,
  -3.58524442e-01f, -4.53617752e-01f, -4.37289417e-01f, 2.86070779e-02f, 1.88564867e-01f, -1.99722853e-02f, 3.72205257e-01f, 1.49423435e-01f, -3.86568218e-01f, -1.38896883e-01f,
  -1.62441552e-01f, 6.37723207e-01f, 2.66250540e-02f, 2.69302517e-01f, -6.05529621e-02f, -4.72558916e-01f, 4.76168126e-01f, -2.53852755e-01f, 6.20779932e-01f, -1.10275373e-01f,
  2.20520243e-01f, 1.04244500e-01f, -9.64569952e-03f, 3.64948899e-01f, -1.62503600e-01f, 2.84946322e-01f, -9.39881504e-02f, 1.09541267e-01f, 1.74409181e-01f, 1.68905798e-02f,
  6.79624304e-02f, -4.06486727e-02f, 6.57496005e-02f, 3.34028840e-01f, 7.13430271e-02f, 2.13002667e-01f, 3.38387280e-03f, 9.26807746e-02f, 3.03943068e-01f, 1.57142013e-01f,
  7.32545778e-02f, -2.25376859e-02f, -5.72180003e-02f, 2.06854388e-01f, -1.96034648e-02f, 2.79398203e-01f, -1.51112959e-01f, 2.24336147e-01f, 2.08049580e-01f, 9.33127627e-02f,
  6.35609478e-02f, -7.71761313e-02f, -2.83095539e-02f, 1.96749538e-01f, 9.20974165e-02f, 2.26699576e-01f, -7.81097338e-02f, 1.78855598e-01f, -1.47673845e-01f, 1.60090029e-01f,
  1.90863460e-01f, 2.23402768e-01f, -2.19946951e-01f, -7.22849146e-02f, -3.65931094e-01f, 1.84873976e-02f, 1.71084523e-01f, -8.78045559e-02f, -3.87998410e-02f, 7.02706873e-02f,
  2.84561813e-01f, 1.65369600e-01f, -1.30300194e-01f, -1.91563934e-01f, 3.44435751e-01f, -3.09092849e-01f, 4.66505177e-02f, 3.26482803e-01f, 7.65429854e-01f, 2.53896773e-01f,
  -3.55015367e-01f, 8.14310312e-02f, -3.58695984e-02f, 2.21882224e-01f, 6.44569546e-02f, -9.82197821e-02f, 7.22807944e-01f, -2.20375553e-01f, -1.72526270e-01f, 1.52439743e-01f,
  3.96640673e-02f, -2.47538418e-01f, 4.70181257e-02f, -3.06976214e-02f, -2.01269332e-02f, -1.10869393e-01f, 1.42499372e-01f, 1.58362478e-01f, 7.29967952e-02f, 1.07357897e-01f,
  -8.51491764e-02f, -1.63227171e-01f, -3.88462865e-03f, 4.76491172e-03f, 1.49727732e-01f, 2.24788278e-01f, 8.37614685e-02f, 2.01225970e-02f, 1.76092908e-01f, 2.06253994e-02f,
  2.31023073e-01f, 8.15374404e-02f, 3.62604260e-02f, 1.35618374e-01f, -3.32674161e-02f, 4.00224403e-02f, 1.70466363e-01f, -1.19001150e-01f, -2.72643417e-02f, -1.97309420e-01f,
  -1.74443349e-01f, -9.32739675e-02f, -3.99719954e-01f, 8.62320513e-02f, -2.12189704e-01f, 4.12007049e-02f, 6.91247880e-02f, -4.04822230e-02f, 1.81577891e-01f, 8.74511749e-02f,
  3.74945313e-01f, 7.75289237e-02f, 4.63915570e-03f, -1.14658959e-01f, 2.60263443e-01f, 1.88838020e-01f, 1.84256896e-01f, -2.40279604e-02f, 2.29631379e-01f, 5.82863748e-01f,
  3.81249100e-01f, -5.82142249e-02f, -6.50547326e-01f, 4.98257667e-01f, 3.93792808e-01f, -7.98740536e-02f, 2.95614868e-01f, 3.09643865e-01f, 3.81956339e-01f, 5.40962458e-01f,
  -2.58010834e-01f, 1.58693135e-01f, 7.49931931e-02f, 1.27183840e-01f, -7.31330588e-02f, -1.15173481e-01f, 1.15485884e-01f, 6.01790249e-02f, -9.60470438e-02f, 6.34694695e-02f,
  1.69186041e-01f, 2.07794785e-01f, 1.06207430e-01f, 6.62453100e-02f, 4.44853827e-02f, -2.96477135e-02f, -6.81345239e-02f, 3.46870005e-01f, 8.50426257e-02f, 3.15803111e-01f,
  8.35158229e-02f, -4.31826450e-02f, -1.44349737e-02f, 1.90319732e-01f, 1.03666387e-01f, 1.01934411e-01f, -3.00931856e-02f, -3.93039249e-02f, -1.71444789e-01f, 4.84631322e-02f,
  -1.51951090e-01f, -1.57798320e-01f, -4.85168606e-01f, 2.40368888e-01f, -6.00554459e-02f, -4.70763631e-02f, -2.55083740e-01f, 2.90716320e-01f, -3.12135190e-01f, 6.71259463e-02f,
  -3.62152219e-01f, 2.79890835e-01f, 1.58807859e-01f, -3.73373926e-02f, 1.87762707e-01f, 9.05514881e-02f, 2.38446161e-01f, -2.89149433e-02f, -2.43098870e-01f, -2.30694056e-01f,
  -3.10539752e-01f, -2.08073393e-01f, -5.12381829e-02f, 7.11650133e-01f, -2.94938564e-01f, 5.16222082e-02f, -8.00932467e-01f, 5.94289660e-01f, 2.08503947e-01f, -5.99111915e-02f,
  8.15735832e-02f, 4.41118836e-01f, 4.89269048e-01f, -6.71788752e-02f, 3.96986336e-01f, -1.21226214e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 14)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 14;
const float L1_fan_Bp_bar_data[] = {
  2.38580450e-01f, 1.81866046e-02f, 3.09756815e-01f, 3.43029052e-01f, 1.63898975e-01f, 3.46773535e-01f, 2.24616840e-01f, 3.60985011e-01f, 2.53107935e-01f, 3.46919060e-01f,
  -1.88872516e-01f, 2.02620611e-01f, 2.98990488e-01f, 1.64483994e-01f
};

// L2_linear_W (Shape: 12 x 64)
const int L2_linear_W_rows = 12;
const int L2_linear_W_cols = 64;
const float L2_linear_W_data[] = {
  -3.95496905e-01f, -1.47444427e-01f, -4.72902387e-01f, -1.37585357e-01f, -2.91537911e-01f, -2.47794822e-01f, -2.85164922e-01f, -7.92972464e-03f, -6.79695606e-01f, -3.80454934e-03f,
  -1.55536145e-01f, -4.72503155e-01f, -1.02257706e-01f, 1.27757579e-01f, -7.04071447e-02f, -2.81132609e-01f, -4.55306709e-01f, 2.81257600e-01f, -7.44815707e-01f, -7.02979043e-02f,
  -1.05869621e-01f, -2.41164774e-01f, 3.56312767e-02f, -1.81891192e-02f, -5.42612858e-02f, 4.28914100e-01f, -3.67180139e-01f, 2.04078034e-01f, 5.04511118e-01f, 5.99811301e-02f,
  -3.36311728e-01f, 2.93846548e-01f, -5.42215168e-01f, 7.23274378e-03f, -1.19569965e-01f, 4.03976470e-01f, 1.68007296e-02f, 2.67968893e-01f, -4.90336776e-01f, 2.26215020e-01f,
  -3.65988404e-01f, -2.08222225e-01f, 7.40713000e-01f, 1.77995086e-01f, -2.16863211e-02f, -1.92971841e-01f, 1.77690107e-02f, -1.64924592e-01f, -8.77285182e-01f, -6.45655811e-01f,
  -5.92641056e-01f, 2.80369759e-01f, 2.22806588e-01f, -3.39868993e-01f, 1.21763125e-01f, -1.63034752e-01f, -4.89960313e-01f, -1.05935365e-01f, -5.60704291e-01f, 1.47759281e-02f,
  1.43632829e-01f, 1.45740390e-01f, -3.37486826e-02f, 1.48008913e-01f, 2.53307879e-01f, 1.47322789e-01f, -2.28476688e-01f, 1.31710082e-01f, 1.88601032e-01f, 7.18959570e-02f,
  2.94353634e-01f, -7.05453634e-01f, -3.58305484e-01f, 2.95428168e-02f, -4.98587281e-01f, -6.71457648e-01f, 2.50306856e-02f, -7.76405394e-01f, 1.68459490e-01f, 1.85655713e-01f,
  2.22831070e-01f, 1.98038667e-01f, 2.54538842e-03f, -3.20171379e-02f, -1.05967862e-03f, 1.63595721e-01f, -1.51815206e-01f, 1.03581570e-01f, -2.70666808e-01f, 4.55336690e-01f,
  2.44150013e-01f, 1.88435122e-01f, -3.53614658e-01f, -6.43674314e-01f, -2.69134164e-01f, 9.39602256e-02f, 3.30639869e-01f, -2.25840911e-01f, -6.03673100e-01f, 1.14270240e-01f,
  -2.77444541e-01f, -6.59240857e-02f, 2.00527042e-01f, -1.88313574e-01f, 2.33873278e-01f, -1.31972745e-01f, 3.65028232e-01f, 4.83361453e-01f, -5.18549345e-02f, 2.42184877e-01f,
  -2.63291210e-01f, -9.32089388e-02f, -6.20778024e-01f, 2.65749544e-01f, 1.06085889e-01f, -2.25179791e-01f, -6.45099640e-01f, 3.27360690e-01f, -1.70945823e-01f, -2.24995971e-01f,
  -4.50129747e-01f, 3.52075934e-01f, -3.52367789e-01f, -3.33585739e-01f, 4.52191800e-01f, -6.09622523e-02f, 2.27902412e-01f, 1.66399106e-01f, 4.30795044e-01f, -3.20201427e-01f,
  2.48247609e-01f, 5.76419681e-02f, -9.05144885e-02f, -2.58097029e-03f, 4.44706082e-02f, -1.58490092e-01f, -4.08606559e-01f, 1.44412324e-01f, 9.74375084e-02f, -1.04457363e-01f,
  -7.33050779e-02f, 3.90889123e-03f, -1.40825072e-02f, -2.55167156e-01f, 3.04007053e-01f, -5.01215816e-01f, -3.04239839e-01f, -3.48531097e-01f, 2.97951072e-01f, -2.25192085e-01f,
  -5.42057827e-02f, -6.61027059e-02f, -3.16611439e-01f, -4.34422880e-01f, 1.44124448e-01f, -3.11961889e-01f, 4.91908103e-01f, 2.35055625e-01f, 2.29049027e-01f, -1.55178800e-01f,
  -3.21380645e-01f, 1.33868828e-01f, -2.55260527e-01f, 1.44296452e-01f, -4.47610259e-01f, 1.31928176e-01f, -4.06527042e-01f, -7.48785198e-01f, -5.17593443e-01f, -2.17419770e-02f,
  4.75439668e-01f, -3.14097106e-01f, -2.63978392e-01f, -2.90201932e-01f, -1.09316841e-01f, -2.56607700e-02f, 4.68097329e-01f, 2.33914286e-01f, 2.83724636e-01f, -1.97362080e-02f,
  2.00704977e-01f, -1.82854399e-01f, -2.98021752e-02f, -3.75199616e-01f, -6.91072568e-02f, 1.91996291e-01f, -2.71252185e-01f, 1.63999155e-01f, 1.22345820e-01f, 2.22633138e-01f,
  -7.58625627e-01f, -3.66264075e-01f, 1.46471471e-01f, -7.76813626e-01f, -1.44808203e-01f, -4.16701883e-02f, -9.49756205e-02f, -2.96660542e-01f, -3.71188074e-01f, -4.58540380e-01f,
  2.31819555e-01f, -1.46379739e-01f, -4.76001114e-01f, 5.79710864e-02f, -8.68237466e-02f, -2.24612713e-01f, 1.72876194e-01f, 3.92286420e-01f, -1.32601053e-01f, 4.72699329e-02f,
  -3.90523255e-01f, -5.70540905e-01f, -1.65224209e-01f, -1.82904527e-01f, -1.21711455e-02f, 1.90919742e-01f, 4.66564037e-02f, 2.12466136e-01f, -2.74582386e-01f, 6.54935017e-02f,
  7.81334341e-01f, -1.04889371e-01f, 4.97645557e-01f, 2.73184925e-01f, -3.94914478e-01f, -2.12324873e-01f, 2.37879306e-01f, -1.42000407e-01f, -1.78869873e-01f, -3.02244186e-01f,
  8.19165334e-02f, -9.40287411e-02f, -4.43870574e-02f, -2.48788252e-01f, -4.62499112e-01f, -7.18048066e-02f, 1.73314244e-01f, -2.95666933e-01f, -5.42685211e-01f, 7.77267039e-01f,
  -2.38023698e-01f, 1.72349170e-01f, 2.18583673e-01f, 2.09645882e-01f, 3.15649331e-01f, -8.98329854e-01f, -5.22947013e-01f, -5.94667375e-01f, 3.94482285e-01f, -8.06510806e-01f,
  2.23721743e-01f, -7.06094682e-01f, -5.90184391e-01f, -1.46221012e-01f, 1.10876195e-01f, -3.80886376e-01f, -1.94366336e-01f, 6.85674131e-01f, 2.42216393e-01f, -1.38489515e-01f,
  -3.08386564e-01f, 6.44761920e-02f, 3.00541073e-01f, 4.89931107e-01f, 4.39000875e-01f, -3.76390219e-01f, 2.34184384e-01f, 2.58459657e-01f, -9.38642472e-02f, 6.55013099e-02f,
  -3.65593404e-01f, 4.97352928e-02f, 1.85823783e-01f, 2.52097994e-02f, 3.47608536e-01f, 8.68035555e-02f, -2.89872527e-01f, 1.98418111e-01f, 9.04444233e-02f, -2.59160429e-01f,
  3.61197233e-01f, -5.71996212e-01f, -2.94995397e-01f, -3.29513133e-01f, -4.69421655e-01f, -5.16138852e-01f, 1.83342487e-01f, -2.86666118e-02f, -2.43820697e-01f, 3.00753415e-01f,
  -1.44379109e-01f, -5.62446177e-01f, 1.16604206e-03f, -3.80978376e-01f, 1.02984798e+00f, -2.13504896e-01f, -2.55785048e-01f, -2.40136370e-01f, -1.03168644e-01f, 2.42738314e-02f,
  7.00923681e-01f, -2.88493216e-01f, 7.00637400e-02f, -4.63473499e-01f, 7.02960551e-01f, 1.92997262e-01f, -1.27629116e-01f, 1.96731761e-01f, 8.14383700e-02f, -2.56555885e-01f,
  2.13777140e-01f, -5.69722652e-01f, -4.82118994e-01f, -2.66851485e-01f, 7.58137852e-02f, -5.24434626e-01f, -4.57533859e-02f, 3.80038738e-01f, -7.81756267e-03f, -1.92180768e-01f,
  9.66756716e-02f, 2.28766143e-01f, 3.38378519e-01f, -2.23929256e-01f, 3.27174336e-01f, -6.40980974e-02f, -6.07045852e-02f, 4.24329102e-01f, 1.47048727e-01f, 1.30274212e-02f,
  -1.56378046e-01f, 5.93759492e-02f, -1.40954167e-01f, 2.95578074e-02f, 3.22258711e-01f, 5.63435018e-01f, -1.59401655e-01f, -6.40845895e-02f, 3.63637321e-02f, 2.85954237e-01f,
  1.69268802e-01f, -8.79177358e-03f, -7.94419646e-02f, 2.36283988e-01f, -5.58087751e-02f, -1.00997478e-01f, 7.50640810e-01f, 2.02197954e-01f, -3.94954711e-01f, -1.24333464e-02f,
  -3.60230744e-01f, -8.41253027e-02f, 3.74776691e-01f, 6.49221420e-01f, 3.41292500e-01f, -3.83846551e-01f, -1.02808759e-01f, -2.38507152e-01f, -4.67379332e-01f, 1.17499232e-02f,
  4.14054431e-02f, 4.91883099e-01f, -5.99849463e-01f, -5.11688471e-01f, -4.66211140e-01f, 2.17737541e-01f, 6.39270902e-01f, -5.83910286e-01f, 7.96581626e-01f, -6.30203843e-01f,
  -6.35871589e-01f, -8.30784366e-02f, 6.82810694e-02f, 4.57093716e-01f, 1.81519359e-01f, -3.52190852e-01f, -2.41584271e-01f, -4.89035621e-02f, -8.56579602e-01f, 1.05441839e-01f,
  -1.28330946e-01f, -3.49029243e-01f, -8.04834627e-03f, 4.23867345e-01f, 1.02966279e-01f, 2.81621903e-01f, -9.70317423e-02f, -4.12446298e-02f, 2.52831187e-02f, -4.36289273e-02f,
  -1.02654673e-01f, 1.85049295e-01f, 1.11415975e-01f, 3.01253736e-01f, -3.50219190e-01f, -3.23072910e-01f, -1.00403138e-01f, 1.25452608e-01f, -2.95663122e-02f, -1.06776729e-01f,
  -1.96881935e-01f, 2.34094650e-01f, 3.77399832e-01f, 6.68484271e-02f, 8.78582895e-02f, -2.02158615e-01f, 2.57721126e-01f, -1.49533927e-01f, 7.20748976e-02f, 1.06218018e-01f,
  5.80506563e-01f, 6.54938757e-01f, -1.46196961e-01f, 2.78039604e-01f, 2.78510839e-01f, -5.42611539e-01f, 7.12173223e-01f, 3.65174003e-02f, -2.11253375e-01f, 4.25465018e-01f,
  3.97911042e-01f, 1.96219265e-01f, -8.90169442e-02f, 5.40765345e-01f, 3.99237275e-02f, -2.18003597e-02f, 1.85350582e-01f, 9.45240725e-03f, -7.76813090e-01f, 6.61150634e-01f,
  1.52845472e-01f, 3.68442744e-01f, -2.57903457e-01f, 3.36530596e-01f, 2.71439135e-01f, -5.66006303e-01f, -8.71084392e-01f, 5.96212409e-02f, -8.40772614e-02f, 4.50428426e-01f,
  -4.26453769e-01f, 1.42587289e-01f, 2.20645338e-01f, 2.41157994e-01f, -4.30909723e-01f, 3.64794321e-02f, -7.04086781e-01f, -5.66478133e-01f, -5.28289557e-01f, 1.17629044e-01f,
  6.63432851e-02f, -7.54468814e-02f, -5.29504299e-01f, -1.44551188e-01f, 3.02474409e-01f, -1.56043082e-01f, -2.99863428e-01f, -1.20357074e-01f, -2.70997912e-01f, -3.20297748e-01f,
  -1.24918848e-01f, -1.48652747e-01f, -5.61134517e-01f, -4.62715805e-01f, -2.73197740e-01f, -2.10389066e-02f, 1.25014961e-01f, -2.74346739e-01f, 2.95867939e-02f, 2.10316107e-01f,
  -2.06498086e-01f, -3.79561782e-01f, -2.33342648e-01f, -1.79691911e-01f, -4.22617137e-01f, -2.87722349e-01f, -7.21797198e-02f, 8.63770470e-02f, -3.63380462e-01f, -1.24697402e-01f,
  -3.31028014e-01f, -1.40037268e-01f, 5.22868752e-01f, 2.03865781e-01f, -2.58449148e-02f, -2.18831569e-01f, 9.90665182e-02f, 4.79405135e-01f, -2.37396300e-01f, -1.79996416e-01f,
  -3.50463420e-01f, 3.08261991e-01f, 4.86100733e-01f, -2.38719761e-01f, 4.10926759e-01f, -2.82429308e-01f, -3.92882586e-01f, -2.62213826e-01f, -3.31624635e-02f, -3.38814147e-02f,
  -4.11473334e-01f, -5.01326658e-03f, -6.29314363e-01f, 2.08804950e-01f, 2.93419778e-01f, 4.74362914e-03f, 3.28732997e-01f, 3.28783467e-02f, 1.36012686e-02f, -5.21936297e-01f,
  4.81953561e-01f, -3.56238514e-01f, 1.93392280e-02f, -2.84431484e-02f, 4.49568667e-02f, 2.20246002e-01f, 1.29490364e-02f, 4.36573565e-01f, 3.25481385e-01f, 2.44790435e-01f,
  1.43230304e-01f, -1.85715631e-01f, 8.63622546e-01f, 6.94867194e-01f, 2.27654368e-01f, 2.62395233e-01f, -3.56418520e-01f, -1.44489259e-01f, 3.82806361e-01f, 4.60835636e-01f,
  3.24836850e-01f, 1.85289830e-01f, -8.69823396e-02f, 2.67122090e-01f, 4.64724839e-01f, 2.15317026e-01f, 5.41263163e-01f, -9.54384089e-01f, -5.51864624e-01f, 2.49743778e-02f,
  8.24196160e-01f, 8.07874918e-01f, -5.55937767e-01f, 4.47519064e-01f, 5.27737558e-01f, 2.27646589e-01f, -2.99923986e-01f, -2.03900784e-01f, -9.85729694e-02f, 3.85536164e-01f,
  -5.01940191e-01f, 2.88546860e-01f, 6.82575226e-01f, 7.43359774e-02f, -8.11172351e-02f, 6.37058243e-02f, 3.48677158e-01f, 3.00857961e-01f, -1.04377024e-01f, 8.61983478e-01f,
  -3.30742210e-01f, -3.01424325e-01f, -2.86409587e-01f, -4.92068172e-01f, 8.26308727e-02f, -1.15457058e-01f, -6.33528233e-01f, 2.48296261e-01f, -5.46114482e-02f, 5.78455441e-02f,
  -1.36403695e-01f, -3.18350673e-01f, -2.60049850e-01f, 2.81036735e-01f, -4.72881310e-02f, 1.21857554e-01f, -2.96973199e-01f, -3.70751560e-01f, -1.60464406e-01f, -2.06303716e-01f,
  1.70568585e-01f, 3.63153964e-01f, -3.51829350e-01f, 3.44433933e-02f, 2.73141325e-01f, -5.44559896e-01f, -6.06949106e-02f, 3.64381969e-01f, 3.81282508e-01f, 9.26119238e-02f,
  7.99771622e-02f, -4.74816799e-01f, -2.60215819e-01f, 1.97215751e-01f, 9.07746479e-02f, 1.80641398e-01f, 2.91934818e-01f, 1.93126798e-01f, -1.37533754e-01f, -3.60263973e-01f,
  -2.49508977e-01f, 2.55995393e-01f, 3.37513000e-01f, -1.72800794e-01f, -4.09573764e-01f, -2.35631019e-01f, 1.09094687e-01f, 3.46623026e-02f, 2.40542248e-01f, -5.35353720e-01f,
  5.10565460e-01f, 5.33028007e-01f, 5.03709121e-03f, 4.24914718e-01f, 2.48465076e-01f, -2.84292281e-01f, -1.78617835e-01f, 2.82578290e-01f, -2.36276299e-01f, -9.00683925e-02f,
  -1.77547798e-01f, -3.56763840e-01f, -3.32460761e-01f, -1.84641957e-01f, 1.91776663e-01f, 5.95647871e-01f, -5.63470006e-01f, 2.07189351e-01f, -5.64114094e-01f, -8.92801359e-02f,
  5.86101353e-01f, 3.27959955e-01f, 2.72948742e-02f, -1.01371463e-02f, 6.08724579e-02f, 1.34838879e-01f, 3.03906024e-01f, -1.44313946e-01f, -7.55718231e-01f, -2.20608190e-01f,
  7.61548802e-02f, 6.06699921e-02f, 1.18793756e-01f, -2.47411686e-03f, -3.32419604e-01f, -4.60240126e-01f, -4.12038416e-01f, -3.16122398e-02f, 1.48921952e-01f, 9.10615847e-02f,
  2.65515357e-01f, -7.99677074e-02f, -3.81149724e-02f, 1.57103270e-01f, 4.72498201e-02f, -2.16570795e-01f, 1.65325731e-01f, 1.75501090e-02f, 1.42689288e-01f, -9.97424498e-03f,
  -1.98330969e-01f, -8.35335329e-02f, -1.44209757e-01f, 1.57476366e-01f, -1.91837832e-01f, 3.58404279e-01f, -2.20033005e-01f, -2.93467790e-01f, -3.96451563e-01f, 3.13315153e-01f,
  6.06267571e-01f, -3.52292955e-01f, 2.70246863e-01f, -4.11972493e-01f, -1.55221805e-01f, 2.23157972e-01f, 5.30804098e-01f, -3.19850087e-01f, 2.50285387e-01f, 2.33183950e-02f,
  3.09260011e-01f, 3.60688895e-01f, 5.59837461e-01f, 1.89052820e-01f, -5.22630930e-01f, 2.70566821e-01f, 3.07694882e-01f, -5.48026860e-01f, -9.85221118e-02f, -5.92471004e-01f,
  6.12540007e-01f, -1.99603930e-01f, 2.25983456e-01f, -4.70807701e-01f, -4.18145508e-01f, -4.71775502e-01f, 6.32492542e-01f, -9.12809849e-01f, -6.13938391e-01f, -5.22034705e-01f,
  3.92344713e-01f, -5.29144824e-01f, -1.09716520e-01f, -3.61051708e-01f, 7.95085579e-02f, 2.20363718e-02f, -4.55832094e-01f, 6.18085377e-02f, 1.83929890e-01f, -1.10487990e-01f,
  -4.16743010e-01f, 1.38798743e-01f, 5.65626174e-02f, 2.51095258e-02f, 3.12719047e-01f, 1.72197029e-01f, -6.53975070e-01f, 1.99751511e-01f, 1.37144744e-01f, 1.53014645e-01f,
  2.05339849e-01f, -2.92291105e-01f, 7.15805590e-02f, 4.77534272e-02f, 3.97857994e-01f, -4.97393161e-01f, -5.83260775e-01f, -5.38566113e-02f, 1.50526324e-02f, 1.87750176e-01f,
  -5.45393169e-01f, -2.98684299e-01f, -2.17436492e-01f, -3.74046683e-01f, 4.62814331e-01f, 7.16122091e-01f, -1.01854980e+00f, 7.49756247e-02f, -3.39369059e-01f, -3.10465336e-01f,
  1.13362774e-01f, 1.94263570e-02f, 2.96263576e-01f, 1.19154202e-02f, -6.81044906e-02f, 4.16929156e-01f, -3.95815551e-01f, 4.20233637e-01f, 5.68226814e-01f, -7.83446282e-02f,
  -1.52583569e-01f, 3.58119488e-01f, 3.05047333e-01f, 5.31748295e-01f, 4.19505805e-01f, -6.44469142e-01f, -4.30530339e-01f, 2.02881381e-01f, -5.57305276e-01f, -4.04985622e-02f,
  3.14378202e-01f, -6.85559571e-01f, 3.16578269e-01f, 1.14224933e-01f, -5.71974099e-01f, 2.97528654e-01f, -1.74644306e-01f, 2.99870729e-01f
};

// L2_linear_B (Shape: 1 x 12)
const int L2_linear_B_rows = 1;
const int L2_linear_B_cols = 12;
const float L2_linear_B_data[] = {
  -1.82690576e-01f, 5.38408943e-03f, -1.73786640e-01f, -1.33135125e-01f, 5.14615737e-02f, -4.33093822e-03f, 1.58721238e-01f, -7.03328550e-02f, 2.56203413e-01f, 1.35556668e-01f,
  -1.44255966e-01f, -9.14081261e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 25, 14
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        64, 25, 14
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_linear
    linear_forward_pgm(
        buffer1, x_out,
        L2_linear_W_data, L2_linear_B_data,
        64, 12
    );
    }
    