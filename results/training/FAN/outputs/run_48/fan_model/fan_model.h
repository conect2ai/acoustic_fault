/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 32 (x1)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 32;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    float x3 = x * x * x;
    return 0.5f * x * (1.0f + tanhf(0.79788456f * (x + 0.044715f * x3)));
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 3 x 120)
const int L0_fan_Wp_rows = 3;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -1.44572929e-01f, 3.06257725e-01f, 1.39058847e-02f, -4.36938733e-01f, 7.92517960e-02f, -1.02783054e-01f, -4.07339811e-01f, 1.86233010e-05f, -1.23031206e-01f, 5.64191602e-02f,
  -2.71500826e-01f, 1.37178093e-01f, -2.35210615e-03f, -3.67368340e-01f, -4.11907405e-01f, -1.11428298e-01f, -4.20039505e-01f, -1.51135772e-01f, 8.65330324e-02f, -6.32051320e-04f,
  -7.36716688e-02f, -2.22039461e-01f, -2.25874260e-01f, 1.91295132e-01f, 1.07326180e-01f, 1.73438177e-01f, -1.41317183e-02f, 1.06459685e-01f, -9.94949788e-03f, 1.97961684e-02f,
  2.42675636e-02f, -1.83677092e-01f, 1.08928587e-02f, 8.11780896e-03f, -1.41513571e-01f, -1.91870949e-03f, 2.40559597e-03f, 2.16927882e-02f, -3.23015638e-02f, -1.96762010e-02f,
  6.27109259e-02f, -2.50077546e-02f, -1.34553788e-02f, 3.32370624e-02f, 9.03838407e-03f, -1.48614757e-02f, 6.76247291e-03f, 6.53901473e-02f, -7.65009876e-03f, 5.74367959e-03f,
  -2.16826727e-03f, -5.25028817e-02f, -3.67428027e-02f, -4.88459766e-02f, 1.01885600e-02f, -1.05242506e-01f, -6.28811419e-02f, 1.16813213e-01f, 2.26832870e-02f, -3.74588296e-02f,
  -4.61519649e-03f, -4.54077087e-02f, -1.69511773e-02f, 6.01100773e-02f, -9.58533213e-02f, 1.14651859e-01f, -9.42057967e-02f, 7.48134917e-03f, 3.09440140e-02f, -1.27889086e-02f,
  -9.18784179e-03f, -9.49723925e-03f, -5.87395653e-02f, -7.73749948e-02f, -8.25330094e-02f, -1.17238127e-02f, -2.37340759e-03f, 3.34242880e-02f, 3.33956704e-02f, -2.02237256e-02f,
  2.78055016e-03f, -3.94007005e-02f, 3.27298306e-02f, 3.06037888e-02f, -6.81580827e-02f, -2.04033628e-02f, 8.65118857e-03f, 2.48273332e-02f, 1.34957358e-02f, -1.00481935e-01f,
  -8.45371932e-02f, -2.11670160e-01f, 7.24283466e-03f, 1.20558823e-02f, 1.04214642e-02f, 2.93071326e-02f, -1.64390495e-03f, 8.35691988e-02f, 1.33692063e-02f, -4.02864031e-02f,
  -5.23371212e-02f, -3.45125003e-03f, 6.82113320e-02f, -3.94270476e-03f, 3.36723030e-02f, 4.37880307e-02f, -3.23676392e-02f, 4.82546948e-02f, -7.54545927e-02f, -1.78250694e-03f,
  1.10982973e-02f, 8.20915666e-05f, -4.22212109e-02f, 2.28435639e-02f, 7.20476732e-02f, 7.43575487e-03f, 1.32810427e-02f, -1.07828211e-02f, -2.50372291e-02f, 7.35088438e-02f,
  -3.04585010e-01f, -4.56797600e-01f, 2.47650027e-01f, 1.55850738e-01f, 7.45173078e-03f, -1.87365338e-01f, -7.51641318e-02f, -1.37173265e-01f, -7.35123008e-02f, -2.58962572e-01f,
  6.42657131e-02f, -3.38609427e-01f, -1.10745586e-01f, 8.27411488e-02f, 4.06946242e-03f, 6.95431978e-02f, 6.83089793e-02f, -1.52465925e-01f, 3.84067371e-02f, 3.65954936e-02f,
  1.72001094e-01f, 4.41635326e-02f, 2.98314929e-01f, 5.66918105e-02f, 1.18442707e-01f, 1.03781177e-02f, 2.38660071e-02f, 1.02032274e-01f, -8.60233605e-02f, 1.23724551e-03f,
  1.42855328e-02f, 3.81982252e-02f, 2.69146152e-02f, 2.71081757e-02f, 4.57776561e-02f, 1.10351678e-03f, 3.85702290e-02f, -5.53859444e-03f, 1.52999118e-01f, -4.23107222e-02f,
  -5.85587509e-02f, -1.07424006e-01f, 6.49993867e-02f, 1.87860411e-02f, -5.73049821e-02f, -4.77888733e-02f, -4.57256138e-02f, 5.60402684e-02f, -1.99967548e-02f, 6.64532334e-02f,
  6.54951157e-03f, 2.06134003e-03f, 1.46857798e-01f, -8.02163221e-03f, 2.01062150e-02f, -4.61991323e-04f, 8.33394825e-02f, 3.04226158e-03f, -1.34363919e-01f, -2.63971128e-02f,
  8.03067237e-02f, -1.41767869e-02f, -2.63871122e-02f, 5.96238161e-03f, -6.45051077e-02f, 2.09504534e-02f, -4.79049757e-02f, -2.08770353e-02f, 3.96115286e-03f, -8.27404782e-02f,
  6.39416724e-02f, -5.37303686e-02f, 4.40327488e-02f, -8.73938575e-03f, -4.23870794e-02f, 4.06445526e-02f, 5.36128692e-02f, -8.25993940e-02f, 7.31963143e-02f, 8.48871693e-02f,
  -1.40077382e-01f, 7.47761652e-02f, -4.47511114e-02f, -1.12402439e-02f, 8.82683508e-03f, -4.20578979e-02f, -2.02664733e-03f, -3.18802595e-02f, 3.36544588e-02f, 4.65902174e-03f,
  -3.47812176e-01f, -4.60318267e-01f, 1.12063354e-02f, -1.11281633e-01f, -7.86027908e-02f, -8.99975225e-02f, 4.74778749e-02f, 4.42926399e-02f, -1.33889839e-01f, 5.39670922e-02f,
  6.10606838e-03f, 4.90792245e-02f, 2.02952605e-02f, 5.25291152e-02f, 2.06709281e-02f, -4.10064012e-02f, 1.55234672e-02f, -2.70265378e-02f, -2.61307098e-02f, -1.15235649e-01f,
  -6.77988008e-02f, -2.69834250e-02f, 4.43958268e-02f, 4.23153117e-02f, 3.75630939e-03f, -2.03281883e-02f, -3.17071192e-02f, -3.63776572e-02f, -3.64855565e-02f, -7.23975338e-03f,
  -4.88971353e-01f, 2.22293541e-01f, -2.90555149e-01f, 1.21943109e-01f, -3.54744762e-01f, -2.17933506e-01f, -6.09393306e-02f, -1.62836477e-01f, 1.58715934e-01f, 2.14938983e-01f,
  -1.84900448e-01f, -2.60607339e-02f, 8.82958844e-02f, 1.61486581e-01f, -3.77754956e-01f, 3.88738275e-01f, 1.19683526e-01f, 3.18023050e-03f, 1.26993120e-01f, -1.98463723e-01f,
  -9.76739153e-02f, -2.68595293e-02f, -1.15491226e-01f, -8.75290632e-02f, -2.34810695e-01f, -1.82913885e-01f, -9.70275179e-02f, 2.09315792e-02f, -2.08491459e-01f, -3.64829041e-02f,
  -1.37971789e-01f, 1.74177498e-01f, -1.25476539e-01f, 1.92963220e-02f, -2.02590197e-01f, -1.02700479e-02f, -8.72076601e-02f, -8.93631503e-02f, 1.74869280e-02f, 1.26626026e-02f,
  1.06927857e-01f, 6.88526547e-03f, 2.05956027e-02f, 6.45189881e-02f, 1.06438119e-02f, 4.07387987e-02f, 7.12575912e-02f, -6.33650739e-03f, 5.64905927e-02f, 1.92721896e-02f,
  -1.90654062e-02f, 7.78607000e-03f, 1.88861077e-03f, -1.78233497e-02f, -9.93163362e-02f, 9.41658467e-02f, -6.25622272e-03f, -2.04333186e-01f, 2.30153520e-02f, -1.04485549e-01f,
  -5.34051172e-02f, -3.15572321e-02f, 4.64982260e-03f, 6.53463602e-02f, -2.14227960e-02f, -7.65962601e-02f, 4.74909581e-02f, 4.96404357e-02f, 3.91504392e-02f, -1.31552322e-02f,
  -6.33229762e-02f, 2.84214709e-02f, 7.73944259e-02f, -6.54658154e-02f, -1.44898584e-02f, 4.61133868e-02f, -1.89991929e-02f, -8.96064267e-02f, -3.54004167e-02f, -1.97052583e-02f,
  9.70129669e-02f, 2.70853378e-02f, -1.02114104e-01f, 3.85659039e-02f, 9.69110951e-02f, -5.63576967e-02f, 8.78568143e-02f, 8.10470805e-02f, 1.91516187e-02f, -2.03628708e-02f,
  -1.91548496e-01f, -1.44288555e-01f, 3.64827947e-03f, -2.38595773e-02f, 1.73069276e-02f, 4.19647805e-02f, 8.06744918e-02f, 4.84315939e-02f, -4.97102812e-02f, -2.13019736e-03f,
  -1.64205506e-01f, -2.92934868e-02f, -4.59887125e-02f, -4.06602621e-02f, -2.36802604e-02f, -7.69364834e-02f, 1.54306348e-02f, -7.52378777e-02f, -4.56659049e-02f, -1.48827761e-01f,
  -4.93029617e-02f, -7.29494616e-02f, 2.38566604e-02f, -7.13673905e-02f, 5.29821403e-03f, -1.29022807e-01f, -7.89903328e-02f, 5.14908843e-02f, 1.74858719e-02f, 1.66549142e-02f
};

// L0_fan_Wp_bar (Shape: 26 x 120)
const int L0_fan_Wp_bar_rows = 26;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -2.23693788e-01f, -3.53897437e-02f, 3.05145860e-01f, 4.47616607e-01f, -1.85404032e-01f, -6.53639913e-01f, -4.93075192e-01f, -1.16526388e-01f, 1.04224965e-01f, -5.99005282e-01f,
  -3.61265212e-01f, 1.29428729e-01f, -6.67151272e-01f, 1.91704363e-01f, 3.04773867e-01f, -2.58616358e-01f, 3.47640872e-01f, 8.89687159e-04f, 2.99882174e-01f, 2.16917977e-01f,
  4.71919686e-01f, 3.62726413e-02f, 3.47119540e-01f, 2.60617405e-01f, 1.40746042e-01f, 3.78488421e-01f, 4.25484538e-01f, 1.22941688e-01f, 4.19663250e-01f, 3.40581462e-02f,
  -2.05294684e-01f, 8.66664276e-02f, 7.26541653e-02f, -1.32843095e-03f, 2.56065670e-02f, -1.62480935e-01f, -4.99700829e-02f, -1.59253418e-01f, 3.31774838e-02f, 1.41555034e-02f,
  -9.80766267e-02f, 2.68302243e-02f, 1.04717575e-01f, 1.58800706e-02f, -9.98039022e-02f, 2.27363437e-01f, 1.28781989e-01f, -3.22452709e-02f, 1.07993491e-01f, 4.76546213e-02f,
  8.86506587e-02f, -4.79108579e-02f, 5.21348715e-02f, 9.28443372e-02f, 2.42990166e-01f, 2.50349604e-02f, 4.95339148e-02f, 4.20428067e-02f, 7.20610246e-02f, 1.35992020e-01f,
  5.83331585e-02f, -4.90604248e-03f, -6.06806912e-02f, -1.69473991e-01f, -2.00772453e-02f, 1.14602953e-01f, 5.12398072e-02f, 5.63921733e-03f, 1.10405460e-01f, -7.92075172e-02f,
  3.78996581e-02f, 2.78788037e-03f, 3.52815799e-02f, -4.76951636e-02f, 4.13959585e-02f, -1.28868148e-01f, -1.12252399e-01f, 2.99974140e-02f, 1.15244888e-01f, -1.27001544e-02f,
  4.54737805e-02f, -1.19395539e-01f, -2.49562748e-02f, 7.84657225e-02f, -1.94809169e-01f, -5.86290099e-02f, 2.67546605e-02f, 1.44291238e-03f, -1.34809539e-01f, 1.86026439e-01f,
  1.52363092e-01f, 3.45491201e-01f, 2.34834123e-02f, -4.36245017e-02f, 6.85960501e-02f, -7.59946108e-02f, 8.15389827e-02f, 8.64936188e-02f, 1.56939015e-01f, -5.29182404e-02f,
  -7.40530565e-02f, 1.20573088e-04f, -2.04708353e-02f, -1.14128953e-02f, -2.70064618e-03f, 2.25343425e-02f, -4.40721996e-02f, 7.37844110e-02f, 3.16248424e-02f, 1.31503031e-01f,
  -1.06737100e-01f, -1.92390293e-01f, 7.38487914e-02f, 7.72050321e-02f, -2.56029349e-02f, 4.51482348e-02f, -4.20486443e-02f, -3.17471591e-03f, 2.22356945e-01f, 4.92583625e-02f,
  5.59812002e-02f, -2.66294718e-01f, -4.03678626e-01f, -6.27385020e-01f, 3.19619924e-01f, 7.91650057e-01f, -2.78807878e-01f, -1.10059664e-01f, -5.87765515e-01f, -3.32677305e-01f,
  -5.52449487e-02f, -5.36251180e-02f, -3.82120401e-01f, 1.99000910e-01f, 6.29742563e-01f, -7.86796734e-02f, 2.35300064e-01f, 7.36844987e-02f, 2.59233862e-02f, 6.94379508e-02f,
  9.53721926e-02f, 3.94522578e-01f, -1.85784549e-02f, 5.06871402e-01f, 2.66647011e-01f, 2.09985171e-02f, -4.68671583e-02f, 1.80842012e-01f, 2.92660177e-01f, 3.04897189e-01f,
  1.79474160e-01f, -2.98688561e-01f, 7.05865398e-02f, -4.43255156e-02f, 3.67780216e-02f, -1.81380063e-02f, 7.76164085e-02f, 2.29386628e-01f, -1.11655528e-02f, -9.09614656e-03f,
  1.50184920e-02f, 1.19828060e-01f, 6.92800619e-03f, 1.85918082e-02f, -2.50989478e-02f, 3.50340903e-02f, 1.11876331e-01f, -7.48091564e-02f, 2.07333695e-02f, -3.13031338e-02f,
  -1.48706302e-01f, -1.70284182e-01f, -1.54697865e-01f, -1.23678952e-01f, -5.28215207e-02f, -9.77567025e-03f, -1.54217035e-01f, -1.54061496e-01f, -2.27504354e-02f, 4.76549659e-03f,
  3.68133560e-02f, -7.10278153e-02f, 4.89526661e-03f, -3.90522070e-02f, 1.24899186e-02f, -7.32609183e-02f, 1.17359236e-01f, 4.12673540e-02f, -1.10480208e-02f, 7.53139844e-03f,
  -4.48320210e-02f, -4.25351597e-02f, -1.16493724e-01f, -1.16395773e-02f, -4.06824201e-02f, -5.51015697e-02f, 9.94770527e-02f, 9.72519740e-02f, -6.81217909e-02f, -1.08262002e-02f,
  -1.95448231e-02f, 6.96986616e-02f, 2.64059696e-02f, -4.32579145e-02f, 3.79982106e-02f, -2.88823638e-02f, -3.92833650e-02f, -3.81362662e-02f, -7.15692714e-02f, 5.57450727e-02f,
  -8.07209536e-02f, -2.55741030e-01f, -2.34885160e-02f, 3.72968726e-02f, 7.66525716e-02f, 1.52794629e-01f, 1.25550121e-01f, 5.08340225e-02f, -4.28822786e-02f, 6.83841333e-02f,
  4.16228324e-02f, -8.17516148e-02f, -1.66633558e-02f, 4.36792150e-02f, 4.11850549e-02f, -1.09833404e-01f, -2.39305403e-02f, -6.12994917e-02f, -6.70558447e-03f, 3.75128165e-02f,
  -4.25692685e-02f, 4.21933159e-02f, -1.19039491e-01f, 3.71801406e-02f, -1.12094946e-01f, -6.78938627e-02f, 1.28630012e-01f, -4.92404886e-02f, 3.76912728e-02f, -1.23505741e-01f,
  -5.54214895e-01f, 5.34783602e-01f, 5.78234680e-02f, -3.06379735e-01f, 2.21576035e-01f, 8.47384632e-01f, 9.19127762e-02f, 3.30926538e-01f, 2.51818985e-01f, 4.80086692e-02f,
  -4.56706770e-02f, -4.03176159e-01f, -2.11053684e-01f, -1.09753035e-01f, 1.11866876e-01f, 2.14322403e-01f, 1.60910264e-01f, -1.74970418e-01f, 6.88375086e-02f, -2.36893177e-01f,
  -1.63005412e-01f, -1.80652454e-01f, -3.83416831e-01f, -1.10703684e-01f, -1.90470919e-01f, -1.02742210e-01f, -2.85000592e-01f, -5.44363409e-02f, -9.32614505e-02f, 1.50000885e-01f,
  1.10640325e-01f, -2.22012401e-02f, -1.44839361e-01f, 3.60118113e-02f, 7.95981735e-02f, -1.12715503e-02f, -2.26284880e-02f, 1.69939585e-02f, -8.31574574e-02f, -6.98005110e-02f,
  -1.72964796e-01f, -1.23930871e-01f, 4.83345278e-02f, -1.25810876e-01f, -5.88650741e-02f, -7.19904080e-02f, 6.42244564e-03f, 1.02548532e-01f, -4.58980203e-02f, -4.99145798e-02f,
  -1.64372608e-01f, 1.28131688e-01f, -7.09839817e-03f, 1.53943291e-02f, -7.71674886e-02f, 4.21849340e-02f, 1.01732172e-01f, 2.78925430e-02f, 8.14787000e-02f, 1.62856922e-01f,
  -7.81859383e-02f, 3.26293349e-01f, 1.09065190e-01f, 7.97704980e-02f, 3.93571146e-02f, 5.00718653e-02f, -6.98060468e-02f, 4.95716743e-02f, 4.51646410e-02f, -1.34946436e-01f,
  1.93818025e-02f, -3.94665562e-02f, 1.33912545e-02f, -8.57093465e-03f, 4.77186479e-02f, 3.76371230e-04f, -5.07033058e-02f, -1.80125348e-02f, -6.36155903e-02f, 8.87849703e-02f,
  -8.25100914e-02f, 2.98355762e-02f, -9.51800570e-02f, 5.16864611e-03f, 1.16424128e-01f, -5.82444929e-02f, 7.24538341e-02f, -5.65811135e-02f, -6.10451065e-02f, -1.93622503e-02f,
  4.24298465e-01f, 6.46854043e-01f, 2.09985953e-02f, -5.57630658e-02f, 8.99534822e-02f, 6.00645281e-02f, 4.08748612e-02f, 5.20164967e-02f, 1.59806609e-01f, 9.75251123e-02f,
  -5.09460159e-02f, -2.50579510e-02f, 4.44837362e-02f, -6.46470860e-02f, 7.19909519e-02f, 1.77121699e-01f, 3.79763381e-03f, 1.91565249e-02f, 1.54506579e-01f, -2.91684121e-02f,
  -1.05502211e-01f, 6.91540092e-02f, -1.05888411e-01f, 3.75473350e-02f, -8.42282083e-03f, -2.05976870e-02f, 8.83226320e-02f, -6.08540587e-02f, 2.46646325e-03f, 4.99668941e-02f,
  -2.65217185e-01f, 4.17414606e-01f, -4.26595449e-01f, -2.77628392e-01f, -3.76721025e-01f, -1.77412689e-01f, -2.21330538e-01f, 4.15598787e-02f, 1.67195678e-01f, 2.23512471e-01f,
  -8.64753872e-02f, 3.73464078e-01f, 4.93609339e-01f, -2.10941121e-01f, -4.06796485e-02f, 3.83945256e-01f, -2.84179419e-01f, -1.46600917e-01f, 1.70798883e-01f, 4.68473434e-02f,
  -1.47140706e-02f, -8.08163509e-02f, -3.15313578e-01f, 2.13483781e-01f, -4.11789060e-01f, -2.31744468e-01f, -3.65234673e-01f, -2.04356566e-01f, -4.38228160e-01f, -3.07903796e-01f,
  -1.66502044e-01f, -2.74998188e-01f, -7.72117153e-02f, -6.11078702e-02f, -1.41861767e-01f, -1.33439243e-01f, -2.76732355e-01f, -6.46981075e-02f, 1.50150899e-03f, -2.36755591e-02f,
  2.00565875e-01f, 1.42926231e-01f, 4.61544469e-02f, 1.79165021e-01f, -4.84082997e-02f, -2.76657492e-02f, -7.24447146e-02f, -2.12926298e-01f, 1.24887004e-02f, -8.50190967e-02f,
  1.44868970e-01f, -1.04465596e-01f, -2.23879844e-01f, -8.87866169e-02f, -1.78491101e-01f, -1.52467981e-01f, -1.35533407e-01f, -1.37019992e-01f, -1.65936664e-01f, -1.82880327e-01f,
  -7.72996098e-02f, -1.90795213e-02f, 2.01470237e-02f, -1.31365329e-01f, 1.21447325e-01f, -2.04226803e-02f, 9.86458361e-02f, -1.50760775e-02f, -3.36819515e-02f, 1.69331825e-03f,
  -6.00708425e-02f, -1.38150528e-01f, 9.67060849e-02f, 3.69672440e-02f, 4.18504402e-02f, 5.12697734e-02f, -4.26871441e-02f, -9.58959386e-03f, -7.14032771e-03f, -3.41292992e-02f,
  1.13882087e-02f, -9.76678133e-02f, -5.67542564e-04f, -3.89438658e-03f, 1.35910474e-02f, -3.51160318e-02f, -4.36522551e-02f, 7.10553536e-03f, 5.10797948e-02f, 1.26789473e-02f,
  -1.39803573e-01f, -4.19042975e-01f, 7.38893449e-02f, 5.09777814e-02f, 3.10902279e-02f, 4.20318432e-02f, 2.36469619e-02f, 1.95811614e-02f, -1.92550898e-01f, -4.26979037e-03f,
  8.36881325e-02f, -2.22141743e-02f, -5.22916727e-02f, -5.85504472e-02f, 1.83454394e-01f, 2.38405745e-02f, 3.99819352e-02f, 4.93405350e-02f, -1.75844759e-01f, 5.98978018e-03f,
  5.97126149e-02f, 8.37889388e-02f, 1.16858520e-01f, -5.11389747e-02f, 1.55704925e-02f, -6.70233965e-02f, 2.47671511e-02f, 3.98928486e-02f, -1.69072762e-01f, -4.17313538e-02f,
  -1.09075248e+00f, 8.03740859e-01f, 4.19261992e-01f, -1.17339537e-01f, -6.13810942e-02f, -6.96935579e-02f, -5.13872057e-02f, 1.48769259e-01f, -1.22713976e-01f, 3.98706734e-01f,
  -4.33364920e-02f, 3.28809261e-01f, 2.09636480e-01f, 2.51733780e-01f, -6.20042682e-01f, 1.21504411e-01f, -1.83805645e-01f, -5.02343923e-02f, -4.70600612e-02f, -1.46480381e-01f,
  -2.39536896e-01f, -2.83417881e-01f, 1.60863116e-01f, 4.13560867e-02f, 8.93944129e-02f, 5.95898181e-03f, -3.69605392e-01f, 1.20014317e-01f, 6.93495870e-02f, 7.31141418e-02f,
  -2.96922773e-01f, 2.76389033e-01f, 8.12416300e-02f, 4.31623571e-02f, -1.27510488e-01f, -7.08385184e-02f, -1.20338626e-01f, -4.40326780e-02f, -3.90253775e-02f, 4.37512696e-02f,
  3.98646574e-03f, 5.17917378e-03f, -1.51132550e-02f, 4.42499481e-02f, -5.70904352e-02f, 1.66532293e-01f, 2.43365467e-01f, 2.53567286e-02f, 1.40783593e-01f, 1.35009259e-01f,
  2.16848269e-01f, 9.03792828e-02f, 3.27595137e-02f, 1.12771474e-01f, 2.17931252e-02f, 1.49628863e-01f, 6.09296747e-02f, 1.61454882e-02f, 2.57584993e-02f, 3.31311934e-02f,
  1.96599844e-03f, -1.04957052e-01f, 1.16994046e-01f, -9.21639428e-02f, 3.91461104e-02f, 3.06926928e-02f, 7.38980025e-02f, -7.87392110e-02f, -1.57468468e-02f, 1.00653227e-02f,
  -1.41562209e-01f, 6.63815886e-02f, -9.71585605e-03f, -1.26747102e-01f, -2.56664902e-02f, -3.91572714e-02f, -3.27510014e-02f, -8.29014345e-04f, -1.01340204e-01f, -3.93539667e-02f,
  -1.86011046e-02f, -2.22727954e-02f, 9.93210524e-02f, -7.01974779e-02f, 4.91020642e-03f, -5.85545301e-02f, -6.89972267e-02f, 1.10154480e-01f, -3.26826833e-02f, -2.29636595e-01f,
  -7.07009733e-01f, -4.89608675e-01f, -1.04272895e-01f, 7.73474108e-03f, -5.69852702e-02f, -5.00071272e-02f, -3.87042686e-02f, 7.53684491e-02f, -3.81227583e-02f, -1.00806400e-01f,
  -5.87079749e-02f, 9.46435183e-02f, -1.50900692e-01f, -8.51727650e-02f, -1.43627688e-01f, -1.51671499e-01f, -1.27939850e-01f, -9.34268013e-02f, -2.28509143e-01f, -9.53608677e-02f,
  -1.10528424e-01f, -1.03014298e-01f, 5.93184382e-02f, -6.72204643e-02f, -8.78396034e-02f, -6.85222372e-02f, -1.65800378e-01f, 1.14324741e-01f, -4.01123427e-02f, 1.85244642e-02f,
  4.85913247e-01f, 5.85717618e-01f, 3.12023032e-02f, 1.64651364e-01f, -3.52428734e-01f, -1.53580919e-01f, -2.03611627e-02f, 3.77455093e-02f, -2.04919055e-01f, 4.44652230e-01f,
  -4.44488190e-02f, 2.09393531e-01f, 1.00175038e-01f, 4.53950256e-01f, 5.52075766e-02f, 1.27706811e-01f, 4.12098587e-01f, 2.13670626e-01f, -1.01648897e-01f, 4.38011795e-01f,
  1.33736879e-02f, 2.31346712e-01f, 1.63745195e-01f, 1.32932980e-02f, 3.38728487e-01f, 9.59698204e-03f, 5.74053302e-02f, -2.57990211e-01f, 2.28215694e-01f, -4.11967039e-02f,
  7.81073496e-02f, 8.39594752e-02f, 5.38076907e-02f, -7.79246679e-03f, 2.30496407e-01f, 1.56885199e-02f, -1.80455968e-02f, -5.87400235e-02f, -2.83468276e-01f, 4.19735089e-02f,
  8.12405422e-02f, -4.63734828e-02f, 7.87923411e-02f, -1.54576957e-01f, 1.98107236e-03f, -9.54599977e-02f, -3.18505950e-02f, 3.83607522e-02f, -9.91666783e-03f, 9.25403312e-02f,
  1.00283824e-01f, 8.06642473e-02f, 4.15312685e-02f, 1.11900762e-01f, -9.18419510e-02f, -1.09681576e-01f, -6.49586879e-03f, -9.12906311e-04f, 5.84505983e-02f, 5.38957678e-02f,
  5.70803508e-02f, -8.43265560e-03f, 9.70957875e-02f, -6.47231638e-02f, 3.80093902e-02f, -4.31381986e-02f, -3.71877253e-02f, 2.05010697e-02f, -1.42773658e-01f, 8.94658267e-02f,
  -5.41653261e-02f, 3.48375700e-02f, -2.45861486e-02f, -3.50793749e-02f, 9.04821381e-02f, 4.22879755e-02f, -6.56992197e-02f, -3.66077684e-02f, 7.62833729e-02f, 3.27146379e-03f,
  -9.48335826e-02f, -2.69806990e-03f, 6.00057431e-02f, -5.94846755e-02f, -2.73781810e-02f, -1.63981151e-02f, 1.01339199e-01f, 6.30422607e-02f, -8.52199495e-02f, -6.61949813e-02f,
  7.03606606e-02f, 3.64889890e-01f, 6.89695776e-02f, -6.06545322e-02f, 6.32168353e-02f, 1.91631064e-01f, 3.59332673e-02f, 1.39360145e-01f, 6.32667169e-02f, 9.49757099e-02f,
  1.31597713e-01f, -1.07387602e-01f, 5.85147962e-02f, 9.81594622e-03f, -6.95570633e-02f, 2.04595014e-01f, 1.62168350e-02f, -8.88477340e-02f, -3.38193960e-02f, 1.15023561e-01f,
  3.73710990e-02f, -5.30455597e-02f, 4.47302498e-02f, -5.31010889e-02f, 1.65644046e-02f, 1.22183971e-02f, -1.83744859e-02f, 3.56270047e-03f, 1.38226803e-02f, -2.21988000e-02f,
  3.13032001e-01f, 7.17845798e-01f, 5.42821467e-01f, 1.90258011e-01f, -6.74252212e-02f, -5.52116990e-01f, -3.78978431e-01f, 1.87386945e-01f, -1.63936511e-01f, -9.13988873e-02f,
  -9.17175710e-02f, 3.42275709e-01f, 2.10245386e-01f, 1.83073565e-01f, -1.35389373e-01f, -1.64690446e-02f, -2.94492003e-02f, 5.37168458e-02f, 2.25173056e-01f, 2.55444884e-01f,
  1.29541144e-01f, -2.77005583e-01f, 4.51690763e-01f, 1.00211635e-01f, 2.78210193e-01f, 3.64847332e-01f, -4.44936901e-02f, 1.72538087e-01f, -1.27717510e-01f, -1.37640864e-01f,
  -7.70595223e-02f, 2.58360714e-01f, 9.62159783e-02f, -7.62334913e-02f, -8.62259939e-02f, -9.97158960e-02f, 1.56937912e-01f, 6.54297397e-02f, 3.82534182e-03f, -2.98466925e-02f,
  6.01452263e-03f, 5.87649569e-02f, 1.72714218e-02f, -1.10756882e-01f, 1.71302054e-02f, 1.12011082e-01f, 1.40049279e-01f, 4.03924547e-02f, 1.63110241e-01f, 1.75322846e-01f,
  1.20238796e-01f, 2.27005348e-01f, 1.57767106e-02f, 3.23825851e-02f, 1.23932146e-01f, -8.45984444e-02f, -5.06553240e-02f, 2.59550922e-02f, 8.12444687e-02f, -1.90053508e-02f,
  7.21945763e-02f, -8.20032209e-02f, -6.28607860e-03f, 6.06797859e-02f, 2.02050451e-02f, -5.24422759e-03f, 8.60382840e-02f, 1.10477798e-01f, 6.67069433e-03f, -5.40727228e-02f,
  -1.49278224e-01f, 6.43313825e-02f, -9.31139216e-02f, -1.62052795e-01f, -2.46819947e-02f, 5.52779585e-02f, 8.88234898e-02f, -3.37331393e-03f, -8.66269097e-02f, -1.38650127e-02f,
  -6.32829368e-02f, -7.80864507e-02f, 4.48065735e-02f, 7.15529770e-02f, -1.23874322e-01f, -6.30664304e-02f, 8.42342302e-02f, 9.64972451e-02f, 7.75255635e-02f, -2.94207651e-02f,
  -2.83730000e-01f, 4.92377430e-02f, -6.12847880e-02f, -4.89378832e-02f, -3.22768721e-03f, -5.36874384e-02f, 4.75130863e-02f, -2.19447799e-02f, -9.05499607e-02f, -9.88329351e-02f,
  -1.08975075e-01f, -9.79374424e-02f, -1.11874737e-01f, -1.96108837e-02f, -7.36151189e-02f, -1.00223951e-01f, -2.29268521e-02f, -1.85637683e-01f, 1.78305767e-02f, 7.30058327e-02f,
  6.06190003e-02f, 8.58020708e-02f, -1.06732668e-02f, -2.36092620e-02f, -1.08551756e-01f, -7.85001554e-04f, -3.29008587e-02f, 1.20395869e-02f, 7.17283562e-02f, 4.83186077e-03f,
  -5.28518796e-01f, 2.32215881e-01f, -3.86446267e-01f, -1.37023732e-01f, 4.11818415e-01f, 1.32121056e-01f, 9.88967419e-02f, 1.46090567e-01f, 3.70550811e-01f, 3.15118253e-01f,
  3.01744014e-01f, 2.04204097e-01f, 1.96408913e-01f, -4.08704728e-02f, -4.98809993e-01f, -1.63878232e-01f, -1.21874586e-01f, 8.78235400e-02f, 1.54546261e-01f, 1.08793207e-01f,
  -2.17340782e-01f, 1.81526259e-01f, -5.74357748e-01f, 2.28764668e-01f, -4.47619241e-03f, -5.70377670e-02f, -1.08654194e-01f, 3.14637512e-01f, -9.73275304e-02f, 2.11702645e-01f,
  -1.56548396e-01f, 2.21674114e-01f, -1.60575122e-01f, -1.22167945e-01f, -2.09831923e-01f, 1.06529612e-02f, 1.76704247e-02f, -7.82054439e-02f, -5.84794693e-02f, -7.59141594e-02f,
  1.17183961e-01f, -1.32763594e-01f, 7.93476179e-02f, 5.89341745e-02f, 1.21313184e-01f, 4.25129533e-02f, -1.28458664e-01f, -1.13348491e-01f, 1.23310380e-01f, -9.26622897e-02f,
  -2.00048029e-01f, -2.73623884e-01f, -1.65336672e-02f, -5.05280793e-02f, -9.81726795e-02f, 1.29856393e-01f, -9.04590264e-02f, 3.27841751e-02f, 3.90124284e-02f, -1.01790473e-01f,
  1.11923859e-01f, 1.47192344e-01f, -3.92646044e-02f, 4.05496545e-02f, 3.11962701e-02f, 2.81040035e-02f, 4.20151353e-02f, -7.33034387e-02f, -4.36959695e-03f, 6.69180229e-02f,
  6.47426918e-02f, 7.71578997e-02f, 1.06091663e-01f, -8.66615847e-02f, -5.17363511e-02f, 4.95333076e-02f, 7.16808662e-02f, 1.60222888e-01f, -6.25776732e-03f, -1.83958128e-01f,
  6.96071014e-02f, -6.67712372e-03f, -3.25534306e-02f, 1.46769988e-03f, -3.38769294e-02f, -1.04579376e-02f, 9.53775272e-02f, -1.24919005e-01f, 1.66534365e-03f, 1.45534068e-01f,
  2.92502701e-01f, 6.76758230e-01f, 6.70487434e-02f, 4.56243083e-02f, 5.52800521e-02f, -2.56576333e-02f, 3.65052037e-02f, -8.12440813e-02f, 1.05378807e-01f, 1.16035379e-01f,
  -4.55076098e-02f, 5.85406683e-02f, -5.37913404e-02f, 1.78317130e-02f, -1.02872960e-01f, -3.88776213e-02f, 1.45236179e-01f, 1.16428740e-01f, 1.17220230e-01f, 6.07281625e-02f,
  2.77596265e-02f, 1.34311900e-01f, -4.60752174e-02f, 8.42060670e-02f, -1.52022503e-02f, 2.06613690e-02f, 1.91738218e-01f, 1.42720556e-02f, -8.29301029e-02f, -1.47686824e-02f,
  1.76213846e-01f, -5.05939603e-01f, 5.77975929e-01f, -2.45687917e-01f, 4.89753634e-01f, 6.09201312e-01f, 4.23364699e-01f, 1.66423559e-01f, 1.79998189e-01f, -4.75820035e-01f,
  -2.15198159e-01f, -3.08797568e-01f, 3.22838187e-01f, -3.94546151e-01f, 7.79809713e-01f, 3.89241040e-01f, -8.26879814e-02f, -2.44949490e-01f, 1.48489386e-01f, -1.12223446e-01f,
  1.66485876e-01f, -4.00323629e-01f, 3.06723893e-01f, -4.04707879e-01f, -1.28099948e-01f, -3.64860564e-01f, -3.33787441e-01f, 2.06947759e-01f, -4.40241665e-01f, 1.46524101e-01f,
  -1.75285921e-01f, -2.61468977e-01f, -2.14569002e-01f, -8.55504442e-03f, 1.48769543e-02f, -1.92736778e-02f, -7.89969563e-02f, 1.35716721e-01f, 1.07978627e-01f, 5.63412495e-02f,
  -1.34510025e-01f, 8.49869326e-02f, -1.29209712e-01f, 4.81391363e-02f, 3.36485393e-02f, -5.84237240e-02f, 1.63269818e-01f, 5.98418862e-02f, 5.81560284e-03f, 2.88444817e-01f,
  2.68764257e-01f, -6.88309839e-04f, 5.35710342e-02f, -7.81358331e-02f, 8.03015009e-02f, -7.07208589e-02f, 1.49013465e-02f, 9.00950059e-02f, -3.93048413e-02f, 3.41194458e-02f,
  5.33273555e-02f, 8.57599601e-02f, -3.62998657e-02f, -3.58122177e-02f, -1.45166339e-02f, 1.25594791e-02f, -6.11062795e-02f, -8.19538385e-02f, 3.96866351e-02f, 2.01377422e-02f,
  1.59473084e-02f, -3.77567708e-02f, 1.42825870e-02f, 8.86335820e-02f, -1.06817551e-01f, -1.10973611e-01f, -1.97805185e-02f, -1.34406686e-02f, -3.56798619e-02f, 1.92398019e-02f,
  8.23255908e-03f, -1.98635887e-02f, 3.10633946e-02f, -1.98316537e-02f, -2.35508438e-02f, 6.31458312e-02f, -1.74192294e-01f, 9.91710648e-02f, 4.23704187e-05f, 7.23662227e-02f,
  -3.56413126e-01f, -5.03192127e-01f, -1.43789098e-01f, -1.95753977e-01f, -2.06381544e-01f, -1.28028780e-01f, -7.40301982e-02f, -2.17750631e-02f, -2.22910475e-02f, -5.34227341e-02f,
  -3.81776728e-02f, -5.07222153e-02f, -1.21963061e-01f, -1.77683160e-02f, -7.10340738e-02f, 6.43481016e-02f, -1.06668696e-01f, -1.81014478e-01f, -1.27720952e-01f, -8.12026784e-02f,
  -8.04972500e-02f, -9.42581818e-02f, 1.17194680e-02f, -7.09729344e-02f, -2.12178320e-01f, 3.54880914e-02f, -8.95072371e-02f, -1.57212988e-02f, 5.46930507e-02f, -3.34229618e-02f,
  8.42748523e-01f, 3.37064654e-01f, 3.34136069e-01f, 5.37551224e-01f, -1.76242515e-01f, 2.39494562e-01f, 3.63001019e-01f, -1.05417192e-01f, 4.62520570e-01f, 6.16090633e-02f,
  -4.03577060e-01f, 5.62488854e-01f, -4.14591700e-01f, 1.91328466e-01f, -5.32877862e-01f, -2.40025416e-01f, 2.52469391e-01f, 4.38001424e-01f, 7.64741078e-02f, 2.39552096e-01f,
  -9.46944492e-05f, -3.29153866e-01f, -1.77873448e-01f, -3.73544872e-01f, 1.69800684e-01f, 1.98413387e-01f, -5.84259987e-01f, -9.63200480e-02f, 1.46393850e-01f, -1.06831469e-01f,
  3.65065858e-02f, 1.44015536e-01f, 9.23297107e-02f, 7.48522058e-02f, -1.44781414e-02f, 6.89345896e-02f, 7.84730762e-02f, -3.46303545e-02f, -2.51874258e-03f, 1.38445064e-01f,
  2.16961410e-02f, -6.15161918e-02f, 6.29489943e-02f, -4.89654317e-02f, 1.80425256e-01f, 1.04476109e-01f, 5.75729869e-02f, 5.47104925e-02f, 6.29012361e-02f, 5.25685437e-02f,
  1.55581802e-01f, 1.13434128e-01f, -4.15349603e-02f, 1.08392738e-01f, -2.16363501e-02f, 1.01428196e-01f, 1.71439558e-01f, 7.93667734e-02f, 1.35779828e-01f, 1.18161775e-01f,
  -7.52395988e-02f, -3.26036811e-02f, -5.88472374e-02f, 7.19916746e-02f, 6.21692138e-03f, -5.99775314e-02f, 7.44877905e-02f, -1.48381904e-01f, 5.63154928e-02f, 3.82545963e-02f,
  3.81954052e-02f, 5.58330975e-02f, 1.27120819e-02f, 1.16201326e-01f, 4.24019620e-02f, 1.58394352e-01f, -4.88159768e-02f, 1.28523543e-01f, -2.87920400e-03f, -1.38946688e-02f,
  -7.41433278e-02f, 4.56224829e-02f, 2.39111837e-02f, -6.11195341e-02f, -2.15213280e-03f, -7.68847987e-02f, -7.78180435e-02f, 1.30666539e-01f, -7.60158002e-02f, -1.05914168e-01f,
  -1.29679278e-01f, -6.03409894e-02f, -5.41600538e-03f, 1.15322217e-01f, -2.84366459e-02f, -8.29247832e-02f, 7.23785236e-02f, 9.74507630e-02f, -5.31805716e-02f, -6.64126724e-02f,
  -1.20765204e-02f, 1.20958194e-01f, -9.90466401e-02f, -2.05031806e-03f, -1.71482167e-03f, -2.04557851e-01f, -1.02630835e-02f, -3.40141356e-02f, -7.75259659e-02f, -1.32423937e-02f,
  1.09040202e-03f, 1.43934354e-01f, 4.85660993e-02f, -8.62948690e-03f, 5.29179350e-02f, -3.47120613e-02f, 1.74218714e-01f, 4.51406091e-02f, -3.61452177e-02f, -7.16948602e-03f,
  4.94430631e-01f, -4.01844621e-01f, -6.07551455e-01f, 1.92108542e-01f, 2.34161049e-01f, 2.44018510e-01f, -1.46751225e-01f, -5.68606816e-02f, -1.08837813e-01f, 8.34210142e-02f,
  4.02812093e-01f, -3.37205529e-01f, -3.18795800e-01f, 6.57914460e-01f, 2.48832136e-01f, -9.92067754e-02f, 4.12733227e-01f, 3.74603778e-01f, 3.25835720e-02f, -1.52612016e-01f,
  1.81916535e-01f, 5.06784022e-01f, -1.03079699e-01f, 2.68837176e-02f, 2.33578786e-01f, -2.75669694e-01f, 1.25300929e-01f, -4.74646926e-01f, 2.13938892e-01f, 2.02843264e-01f,
  2.96343744e-01f, 8.24168921e-02f, -6.51089847e-02f, 4.74031968e-03f, -4.40615267e-02f, 1.07564695e-01f, 3.48537900e-02f, -3.33822258e-02f, -5.49615249e-02f, -1.80385098e-01f,
  -1.18874587e-01f, 2.57642698e-02f, 9.24612582e-02f, -1.31613329e-01f, 6.68703690e-02f, 3.57375182e-02f, -4.50344607e-02f, -2.84374990e-02f, -1.13706492e-01f, -1.57183595e-02f,
  -2.05333874e-01f, 1.52713567e-01f, 2.04746410e-01f, -2.58593517e-03f, -9.10350904e-02f, -5.02914675e-02f, -3.46589461e-02f, -1.15294091e-01f, 1.07274326e-02f, -1.85559746e-02f,
  -5.01960516e-02f, 6.76192418e-02f, 2.02890374e-02f, 1.31750867e-01f, -2.35606916e-02f, 5.81103936e-02f, 1.36757657e-01f, 7.86893070e-02f, -1.24131963e-01f, -6.33015409e-02f,
  3.43355648e-02f, -6.49343953e-02f, 4.64575700e-02f, -1.83251314e-02f, 8.65177512e-02f, 6.51739985e-02f, 5.10862842e-02f, -1.66556239e-02f, -1.51700556e-01f, 7.57037103e-02f,
  -2.15034634e-02f, -1.50819376e-01f, -1.47798926e-01f, 1.30824745e-01f, 7.94003755e-02f, -2.63349295e-01f, 8.40882659e-02f, -2.64486950e-02f, 2.77832150e-02f, -4.48756739e-02f,
  -1.40749112e-01f, -6.59780383e-01f, -1.96451291e-01f, 9.89376232e-02f, -8.63807499e-02f, -3.67117375e-02f, 4.42212671e-02f, 1.20133953e-02f, -1.26554206e-01f, 4.11596708e-02f,
  -2.78874729e-02f, 3.10064834e-02f, 3.55595700e-03f, 4.31977995e-02f, 1.38919249e-01f, -6.10369407e-02f, -4.67671715e-02f, -1.15939341e-02f, -1.63045805e-02f, -6.47057742e-02f,
  -4.54999832e-03f, -4.81036082e-02f, 6.65280595e-02f, -1.52297607e-02f, 1.67226139e-02f, -3.63111794e-02f, -4.38814610e-02f, -4.43907380e-02f, 7.36929104e-02f, -4.08886448e-02f,
  -9.01942790e-01f, 4.17339623e-01f, 4.48152781e-01f, -5.30299783e-01f, -2.67038733e-01f, 6.39089406e-01f, 1.93273827e-01f, 1.22085623e-01f, -1.45143554e-01f, 2.32903987e-01f,
  -1.64045587e-01f, -1.84201404e-01f, 3.36554617e-01f, 3.36682163e-02f, -3.06432545e-02f, 3.22729468e-01f, 2.13156089e-01f, 1.21514380e-01f, 2.52861261e-01f, 2.74673365e-02f,
  -5.64418621e-02f, -1.46703660e-01f, 2.66403079e-01f, 1.85426012e-01f, -7.25148767e-02f, -1.98482975e-01f, -2.24036694e-01f, 2.17350990e-01f, -1.36276245e-01f, -4.84479666e-02f,
  -2.37131745e-01f, -3.81965429e-01f, 5.61163668e-03f, 1.69860452e-01f, 6.11928068e-02f, -2.88106464e-02f, -4.03913036e-02f, -8.47256482e-02f, -1.44198850e-01f, 8.58313404e-03f,
  -1.47512639e-02f, 3.57673131e-02f, -1.84249016e-03f, -5.84239513e-02f, 3.88639346e-02f, -5.09217083e-02f, 8.52693543e-02f, 3.80422845e-02f, -3.00430274e-03f, 5.55587076e-02f,
  8.98496658e-02f, 1.96950078e-01f, 1.25403255e-01f, 3.42574492e-02f, 2.43923515e-02f, 1.16328105e-01f, 4.73141186e-02f, 2.43120324e-02f, -3.72114815e-02f, -5.73436134e-02f,
  1.78295851e-01f, -4.86790314e-02f, 4.78979684e-02f, -2.45811529e-02f, -1.41653344e-01f, -9.57685411e-02f, 2.37054862e-02f, -1.82456970e-01f, 4.26982250e-03f, 5.37164286e-02f,
  -1.32051513e-01f, -5.27228080e-02f, -5.07806987e-02f, 1.19759634e-01f, -3.21840458e-02f, -5.47337793e-02f, 3.42089608e-02f, -3.66528183e-02f, 7.81829953e-02f, 4.94671576e-02f,
  -3.32395509e-02f, -2.25470476e-02f, -7.69677535e-02f, -5.93097741e-03f, 4.76321131e-02f, 2.21630521e-02f, 7.46627897e-03f, 7.94267356e-02f, 7.38049075e-02f, 4.45923507e-02f,
  -7.19769150e-02f, -2.43458971e-01f, -8.85788165e-03f, 5.98025396e-02f, 9.09327716e-02f, 9.28115100e-02f, 8.32310840e-02f, -6.50140122e-02f, -1.05211720e-01f, 4.14746664e-02f,
  6.21705577e-02f, 1.76824480e-02f, -2.03887690e-02f, -8.92265141e-02f, 4.74510677e-02f, 9.35505517e-03f, -9.14212242e-02f, -3.51627618e-02f, -1.12999626e-01f, -5.16213775e-02f,
  2.88393050e-02f, -1.06318243e-01f, 9.44242403e-02f, 5.47882952e-02f, 8.40229075e-03f, -3.42486799e-02f, -1.92332461e-01f, 5.66885844e-02f, -3.60033698e-02f, 8.72408226e-02f,
  -5.10354042e-01f, 4.96646881e-01f, 4.27841455e-01f, -1.24993920e-01f, -8.70671347e-02f, -2.20891610e-01f, -3.02910089e-01f, 4.61339504e-01f, -4.65127341e-02f, 5.10393083e-01f,
  8.83717090e-02f, -7.29836449e-02f, 1.56203449e-01f, -1.38795763e-01f, -4.78157461e-01f, -4.23773229e-01f, -2.30109751e-01f, -1.21621877e-01f, -3.11261356e-01f, 8.27504620e-02f,
  -1.32099018e-01f, -3.29955310e-01f, -1.25297764e-02f, -5.69635676e-03f, 9.87965837e-02f, 2.49953389e-01f, 2.90305048e-01f, 1.61131456e-01f, 1.68160230e-01f, -9.31705236e-02f,
  9.72997695e-02f, -7.83730019e-03f, 2.74059325e-01f, 9.90335792e-02f, 5.16989753e-02f, -5.20824548e-03f, 1.29897326e-01f, -8.95891991e-03f, -1.67293083e-02f, 3.23822573e-02f,
  8.48946720e-03f, -6.72708675e-02f, -1.18970469e-01f, -1.09074742e-01f, -4.52538282e-02f, 2.17694417e-02f, 1.05097587e-03f, 1.86687838e-02f, 9.31801349e-02f, -3.11797000e-02f,
  3.53625454e-02f, 7.79005438e-02f, -1.05497904e-01f, -8.35569650e-02f, -6.78429455e-02f, -7.12707788e-02f, -7.16730431e-02f, 6.37124060e-03f, 2.77713202e-02f, -1.89704791e-01f,
  -1.76879644e-01f, -1.09921522e-01f, 8.59082788e-02f, 1.85334295e-01f, -5.34279384e-02f, 3.81542817e-02f, -1.10010505e-01f, -5.88612743e-02f, -6.06168173e-02f, -2.87430361e-02f,
  1.20500654e-01f, 9.22035798e-03f, -5.15457094e-02f, -1.30512258e-02f, -1.80423647e-01f, -3.56374644e-02f, 7.70710176e-03f, 9.95405614e-02f, -3.86678725e-02f, 1.00438133e-01f,
  1.18781917e-01f, -4.39351909e-02f, 2.96478085e-02f, -4.83080409e-02f, 4.29617241e-02f, 1.28070125e-02f, -7.58164981e-03f, 2.38811388e-03f, 1.05183937e-01f, -5.42819127e-02f,
  1.46335110e-01f, 2.15295359e-01f, 1.19621933e-01f, 5.40278628e-02f, 1.09385349e-01f, 1.06981315e-01f, 2.60727806e-03f, -8.45299289e-02f, -1.21290404e-02f, -1.03208788e-01f,
  6.08328590e-03f, 4.71741473e-03f, 9.04309079e-02f, -2.75132656e-02f, -2.54955534e-02f, 9.22921151e-02f, 5.01972996e-02f, 2.37366781e-02f, 1.99958727e-01f, 1.38741344e-01f,
  2.24309519e-01f, 1.42460549e-02f, -9.49293822e-02f, -1.55421406e-01f, -7.73981884e-02f, 4.19865884e-02f, -1.34720569e-02f, 1.01482615e-01f, -1.05714306e-01f, 7.39713609e-02f,
  1.42514274e-01f, 1.14842489e-01f, -1.48727834e-01f, 1.72542334e-01f, -2.51101941e-01f, -3.23746651e-01f, -2.73215443e-01f, -5.34275621e-02f, 5.04209280e-01f, 5.23209274e-02f,
  -3.54406327e-01f, 4.50943410e-01f, -9.89638865e-02f, -2.52177566e-01f, 3.72655094e-01f, 1.58644095e-01f, -4.91567925e-02f, -2.92978045e-02f, 3.60206455e-01f, -1.68494239e-01f,
  1.62014291e-01f, -4.09774750e-01f, -1.52671456e-01f, -2.13054776e-01f, -4.85779107e-01f, 1.34810433e-02f, -1.08980864e-01f, -1.44624308e-01f, -3.36870313e-01f, -1.29445359e-01f,
  -1.44149780e-01f, 2.47883499e-01f, -4.55765836e-02f, 9.52716097e-02f, -5.69151938e-02f, -9.17678624e-02f, 5.47906868e-02f, -7.31159598e-02f, 1.20397843e-01f, 5.22299856e-02f,
  1.39193371e-01f, 1.04619712e-01f, 3.43282484e-02f, -2.14658961e-01f, 4.02765237e-02f, -8.69287178e-02f, 1.27729297e-01f, -8.86000767e-02f, -5.92359938e-02f, -1.28883317e-01f,
  -8.49490985e-02f, 3.29915248e-02f, 3.48781273e-02f, 2.54566997e-01f, 8.67349356e-02f, 6.07083598e-03f, 2.01524254e-02f, -3.17592584e-02f, 1.21287130e-01f, 1.49837449e-01f,
  3.15704979e-02f, 7.44605483e-03f, -1.38436899e-01f, -2.09620818e-02f, 5.53028919e-02f, -2.64267381e-02f, 1.03174850e-01f, -5.30442968e-02f, 1.39909744e-01f, -1.89335570e-02f,
  2.70027611e-02f, -5.23693711e-02f, -6.35722950e-02f, -2.36483850e-02f, -1.39749587e-01f, 1.14162698e-01f, 4.35026474e-02f, -3.94616090e-02f, 1.65930241e-02f, 4.33221981e-02f,
  -5.56002408e-02f, 2.56864931e-02f, 3.68226320e-02f, -1.49991840e-01f, -1.27523705e-01f, -9.99665447e-03f, -1.70257643e-01f, -3.00051365e-02f, -2.00601364e-03f, -1.63038045e-01f,
  1.04875155e-01f, 2.26767331e-01f, 1.04800172e-01f, 1.44691348e-01f, 8.40352699e-02f, -7.76768029e-02f, -5.41625870e-03f, 1.30510926e-01f, 1.35849029e-01f, -9.71862208e-03f,
  -3.86629277e-03f, 9.14292410e-02f, 1.72706485e-01f, -7.03999177e-02f, 1.00417316e-01f, -5.90183996e-02f, 6.16463013e-02f, 2.76880503e-01f, 8.25935602e-02f, -2.07335707e-02f,
  -6.11896208e-03f, -3.88007076e-03f, 1.76757604e-01f, 1.35184288e-01f, 6.77555352e-02f, 8.81664455e-02f, 1.46112787e-02f, 1.30253837e-01f, -9.07284096e-02f, 1.09403595e-01f,
  -2.96715140e-01f, -4.83839005e-01f, -2.81563759e-01f, -3.53388153e-02f, 1.34245679e-01f, -1.27814859e-01f, -5.06616652e-01f, 9.90189984e-02f, -5.10516644e-01f, -2.41104454e-01f,
  -1.29854232e-01f, -3.57077181e-01f, -4.17206943e-01f, -1.95741564e-01f, -1.32864260e-03f, -5.79432666e-01f, 1.63532540e-01f, 4.01144139e-02f, -2.01215908e-01f, 2.04874381e-01f,
  2.72296250e-01f, 3.66106451e-01f, 2.10912466e-01f, 5.49806535e-01f, 1.90597907e-01f, 4.78858680e-01f, 5.46122372e-01f, 1.74208999e-01f, 5.15035331e-01f, 9.33754072e-02f,
  -2.03147605e-01f, -2.46346846e-01f, -1.54380381e-01f, 1.79002639e-02f, 1.64895907e-01f, 1.65031075e-01f, 1.50572821e-01f, -5.82638197e-02f, -1.04909778e-01f, -5.05627319e-02f,
  7.00014308e-02f, 8.85708481e-02f, 1.03659935e-01f, -6.30768314e-02f, 6.80170953e-02f, 4.61411625e-02f, -3.81119624e-02f, -6.93386197e-02f, -7.69276023e-02f, -2.52463639e-01f,
  -1.58442914e-01f, -1.66257340e-02f, 2.20338833e-02f, 5.60678169e-02f, 9.10305884e-03f, 5.44069596e-02f, 3.67624462e-02f, 6.52743205e-02f, -6.95392638e-02f, 2.96898233e-03f,
  6.66139573e-02f, -5.51241101e-04f, -1.20998165e-02f, -1.55161530e-01f, -5.88982366e-02f, -7.72827044e-02f, -8.58845785e-02f, -3.38064060e-02f, -2.24058405e-02f, -3.26238498e-02f,
  1.11032233e-01f, -5.37113845e-03f, -1.33648247e-01f, -1.15330731e-02f, 1.06822833e-01f, 1.84825482e-03f, 5.42266257e-02f, 1.38827693e-02f, 8.47026557e-02f, -1.62607245e-02f,
  -2.54036993e-01f, 7.68458024e-02f, 1.86039961e-03f, 1.00538485e-01f, -2.81384047e-02f, 9.58772227e-02f, 3.22152711e-02f, 7.48511823e-03f, 7.13679790e-02f, 6.58743829e-02f,
  1.61540419e-01f, 2.14609578e-01f, 1.52688297e-02f, -3.42471860e-02f, -1.11949481e-01f, 3.42433564e-02f, -9.27169994e-02f, -2.95641068e-02f, 1.28133073e-01f, -2.17241179e-02f,
  2.88006544e-01f, 5.98979481e-02f, 8.72984976e-02f, 6.32770592e-03f, 1.26070246e-01f, 4.86928150e-02f, 1.00374565e-01f, 1.14869766e-01f, 2.16498777e-01f, 1.81515291e-01f,
  1.24908090e-01f, 2.18631718e-02f, 8.82987604e-02f, 1.20751433e-01f, 1.11012980e-01f, 2.28062179e-02f, 1.18482783e-01f, 5.00912219e-02f, -4.52249311e-03f, -1.15396440e-01f,
  1.66864321e-01f, -4.17812675e-01f, -1.37824252e-01f, -5.24344623e-01f, 8.03381279e-02f, -3.24058980e-01f, -1.38193414e-01f, -5.47944427e-01f, -3.98982555e-01f, -3.18290085e-01f,
  -1.66305289e-01f, 1.81413889e-01f, 4.05848980e-01f, -5.67645073e-01f, 1.36617437e-01f, 8.82142708e-02f, -5.13741076e-01f, -2.38221958e-01f, -3.93956825e-02f, -8.36780220e-02f,
  -1.10042222e-01f, -2.32155591e-01f, -1.28176004e-01f, -3.66573185e-01f, -1.90199777e-01f, -2.47108772e-01f, 2.01835111e-01f, 2.67702252e-01f, -4.54184175e-01f, 6.97385147e-02f,
  -1.74211368e-01f, -2.17610374e-01f, -2.48168427e-02f, 1.54398214e-02f, -2.28223810e-03f, 1.24623075e-01f, 2.08518252e-01f, 2.10906953e-01f, 2.96129156e-02f, -2.10864432e-02f,
  1.73771128e-01f, 5.26780300e-02f, -1.20485969e-01f, 2.33575448e-01f, -7.18865842e-02f, -1.91575006e-01f, -4.44239192e-02f, -5.18096127e-02f, -3.56335542e-04f, 3.25444750e-02f,
  -6.78551495e-02f, -3.94659787e-02f, -3.06095481e-02f, 4.77724621e-04f, -1.81898288e-02f, -2.04252210e-02f, 1.31825730e-01f, 2.54589707e-01f, 4.37068529e-02f, -9.02153850e-02f,
  -7.46948868e-02f, 2.39406109e-01f, 7.38739520e-02f, -8.92048776e-02f, -7.98598211e-03f, -5.54238558e-02f, 1.56574380e-02f, -4.65329736e-02f, 1.08118663e-02f, 2.63783336e-02f,
  -2.95484923e-02f, 1.16014080e-02f, 1.09921172e-02f, -7.26209953e-02f, -3.27275321e-02f, 4.74257506e-02f, 1.19804151e-01f, 1.96049642e-02f, -3.98271009e-02f, -1.26009122e-01f,
  -1.03887096e-01f, -8.94302726e-02f, 9.11670551e-03f, 7.35828355e-02f, 7.97694549e-02f, 4.31750156e-02f, -1.89215932e-02f, 9.08345282e-02f, -1.93938583e-01f, 1.35195076e-01f,
  -6.65069669e-02f, -2.33123049e-01f, -1.75677732e-01f, -9.52439979e-02f, 9.14387032e-02f, 4.72325012e-02f, -3.01087983e-02f, -2.80121058e-01f, -9.42108110e-02f, -2.33104881e-02f,
  -1.23342924e-01f, 5.81893213e-02f, 1.61704049e-02f, -1.42850978e-02f, -9.05064940e-02f, -2.14642510e-01f, 1.60928160e-01f, 9.50425863e-02f, 5.69112077e-02f, -1.19806319e-01f,
  -5.70047572e-02f, -7.20709488e-02f, 1.41937677e-02f, 1.41824661e-02f, -1.40274502e-02f, 1.07601054e-01f, 3.75172123e-02f, -2.08829660e-02f, 1.66462719e-01f, 6.15319191e-03f,
  6.68402910e-01f, -8.59885737e-02f, 2.71135628e-01f, 5.45591772e-01f, 4.58449513e-01f, -1.20842800e-01f, 3.29303443e-01f, 2.89007843e-01f, 6.37794852e-01f, -3.84744942e-01f,
  -1.34720922e-01f, -3.04991729e-03f, -2.97963560e-01f, -5.12456968e-02f, -3.25307757e-01f, -3.85113090e-01f, 1.03724234e-01f, -2.69298911e-01f, 2.03773096e-01f, 5.39461374e-02f,
  1.18231431e-01f, -3.12510997e-01f, -6.57741949e-02f, -2.38470152e-01f, 3.04955482e-01f, 2.36035481e-01f, -4.19818550e-01f, -1.02657527e-01f, -1.63338304e-01f, -1.50043204e-01f,
  1.45133793e-01f, 2.33014226e-01f, 2.29039669e-01f, -3.71689051e-02f, 1.27191186e-01f, -5.68856150e-02f, -4.52460647e-02f, -1.87694028e-01f, 9.58765969e-02f, 4.72070351e-02f,
  -8.83638859e-03f, -1.57850921e-01f, 6.44995943e-02f, -7.53025189e-02f, 3.00539702e-01f, 1.34652555e-01f, 2.12552801e-01f, 1.98722482e-01f, 9.58735943e-02f, 2.37126704e-02f,
  1.58739254e-01f, 1.02645375e-01f, 2.44418800e-01f, -1.78028271e-01f, 3.64210345e-02f, 1.58524960e-01f, -8.28896835e-02f, -9.77619439e-02f, -3.49000245e-02f, 2.29200982e-02f,
  -2.10542008e-01f, 5.15251607e-02f, -6.39183745e-02f, 9.53714103e-02f, -8.69342759e-02f, 5.46480455e-02f, 3.44792716e-02f, -7.42475837e-02f, 6.25877678e-02f, -8.30463767e-02f,
  4.95557487e-02f, 5.20829074e-02f, 1.00110076e-01f, 7.63239488e-02f, 2.00364068e-02f, 1.08820237e-01f, -9.31718946e-02f, -3.10120843e-02f, 1.60347044e-01f, 8.47801119e-02f,
  -4.40540798e-02f, -3.35008949e-02f, -6.16305843e-02f, 1.66089963e-02f, -8.79304111e-03f, 2.40362529e-02f, -2.41928897e-03f, -8.29959512e-02f, 4.98425886e-02f, -5.22788763e-02f,
  -1.04592919e-01f, -6.82408631e-01f, 8.56816620e-02f, -2.07485575e-02f, -2.99010072e-02f, -9.68046039e-02f, -6.26188293e-02f, -1.09431455e-02f, -6.41091540e-02f, -8.91661122e-02f,
  4.70086969e-02f, -1.65599138e-02f, -1.87463667e-02f, -2.44003925e-02f, -7.87524879e-02f, -9.60503668e-02f, 2.06760634e-02f, 3.03797913e-03f, 9.15244594e-03f, -1.52992532e-01f,
  -1.59837939e-02f, -1.11369165e-02f, -5.59276789e-02f, 8.23081881e-02f, -4.42463756e-02f, -5.39895855e-02f, -5.61771542e-02f, -3.56474258e-02f, -1.72517687e-01f, -7.57442787e-02f,
  -8.93324912e-01f, 5.14679849e-01f, -3.62578869e-01f, -9.96125638e-02f, 1.24416485e-01f, 1.31640494e-01f, -2.50580348e-03f, -1.13119036e-01f, -2.05450788e-01f, 3.59879762e-01f,
  4.19791967e-01f, -2.75400400e-01f, 3.12837362e-01f, 4.46616918e-01f, -2.85840064e-01f, 4.77633357e-01f, 2.30651796e-01f, 1.07478328e-01f, 6.84874207e-02f, -1.70252487e-01f,
  -1.47477999e-01f, 4.96274650e-01f, 7.25144371e-02f, 1.66151211e-01f, -2.68089101e-02f, -2.67220289e-01f, -5.83481044e-02f, -1.14448369e-01f, 2.26855367e-01f, 3.72986533e-02f,
  -2.02033490e-01f, -2.68168539e-01f, -1.91307798e-01f, -2.36822873e-01f, -9.61435586e-02f, -1.45907924e-01f, -1.31305054e-01f, -3.54811512e-02f, -1.67115122e-01f, -1.87197104e-02f,
  -3.63758691e-02f, -6.98672757e-02f, 7.16516152e-02f, 8.07242692e-02f, -1.00956343e-01f, -2.57433429e-02f, 1.86183169e-01f, 4.41921800e-02f, 3.35689634e-02f, 8.04422647e-02f,
  1.41058668e-01f, 5.74816614e-02f, -4.21693698e-02f, 1.23116657e-01f, 5.29857650e-02f, 3.13035101e-02f, -3.22973449e-03f, -3.25497538e-02f, -3.25646922e-02f, -6.57688677e-02f,
  2.56712884e-02f, -6.19949810e-02f, 5.75368702e-02f, -1.66191328e-02f, 2.92701391e-03f, 1.05783239e-01f, -1.02936029e-02f, 1.95160229e-02f, -6.48756325e-02f, 9.08951610e-02f,
  8.20164010e-02f, -9.77301598e-02f, -1.14923008e-01f, -5.55650331e-02f, -2.13929396e-02f, -8.18740353e-02f, -3.94036733e-02f, 2.68327147e-02f, 1.26511669e-02f, -1.56415012e-02f,
  -1.41981617e-01f, -7.74743259e-02f, 1.27593473e-01f, 1.33148227e-02f, -1.00165550e-02f, 3.49461436e-02f, -4.72884737e-02f, 8.66257101e-02f, -1.28158480e-02f, 4.74021733e-02f,
  -4.56172705e-01f, -4.13982451e-01f, -5.77043556e-02f, -5.06689996e-02f, 9.76739824e-03f, 6.50697351e-02f, -6.19822089e-03f, -4.24995609e-02f, -2.06649471e-02f, -6.46833610e-03f,
  -8.09948593e-02f, -9.50717926e-02f, -9.72057879e-02f, -1.15865227e-02f, -9.18489397e-02f, 1.19974494e-01f, -4.72317785e-02f, -1.50373474e-01f, -1.55599773e-01f, -6.94084615e-02f,
  -1.11655377e-01f, -4.31222767e-02f, -9.13418233e-02f, 7.93045983e-02f, 4.93675359e-02f, 6.47416711e-02f, -1.05669163e-01f, 3.00010014e-02f, 7.01124147e-02f, 9.23385844e-02f,
  -7.72005975e-01f, -1.03028692e-01f, -5.75570107e-01f, -1.22564070e-01f, -9.39262733e-02f, -3.78021181e-01f, 1.52185127e-01f, -1.30041838e-01f, -1.78083047e-01f, 6.02899611e-01f,
  4.00052130e-01f, -5.62364042e-01f, 3.99839491e-01f, -1.94749281e-01f, -8.47175598e-01f, 3.79486419e-02f, -1.31087482e-01f, 3.94531265e-02f, -2.29658827e-01f, -3.70357335e-02f,
  -2.85807133e-01f, 4.11827601e-02f, -2.58321494e-01f, 2.02390820e-01f, -1.48348898e-01f, -2.30913125e-02f, 3.89928937e-01f, 3.55138369e-02f, 4.47587892e-02f, -4.05808717e-01f,
  -4.05067392e-02f, -2.81062145e-02f, -4.15757298e-02f, -1.62291422e-01f, 6.94263726e-02f, 1.62922695e-01f, 1.12306848e-01f, -1.06209200e-02f, -2.27588229e-02f, -7.91887864e-02f,
  -1.10842269e-02f, -1.81603059e-02f, -1.53986856e-01f, -1.49824306e-01f, -8.33682492e-02f, -5.77112474e-02f, -1.15824245e-01f, -3.54791037e-03f, -4.11198139e-02f, -1.51536986e-01f,
  -2.11848430e-02f, -5.88188060e-02f, -2.31880695e-02f, 8.12315270e-02f, -1.20670147e-01f, -1.84647236e-02f, -9.37491432e-02f, -2.26350408e-02f, 1.24981469e-02f, -9.71695781e-02f,
  -3.22469100e-02f, 1.12194158e-02f, -3.43703888e-02f, 3.74003164e-02f, -1.92672666e-02f, 1.12239644e-01f, 4.78881523e-02f, 7.95236602e-02f, 5.41772135e-02f, -1.13415020e-02f,
  6.44137897e-03f, -9.70190689e-02f, -7.29095265e-02f, 1.02855511e-01f, 1.32583268e-02f, -6.44601583e-02f, -1.84247717e-02f, 5.79221100e-02f, -2.30051074e-02f, -1.46676870e-02f,
  3.89711224e-02f, 3.05191670e-02f, -1.19487438e-02f, 1.71247706e-01f, 4.15659361e-02f, 5.26987463e-02f, 6.77756965e-02f, -4.86474112e-02f, 2.50965524e-02f, -2.56730728e-02f,
  1.42046377e-01f, -7.07299486e-02f, -1.32820709e-02f, 3.77394818e-02f, 6.25352114e-02f, -5.58932871e-02f, -7.91412890e-02f, -1.25946671e-01f, -7.01499805e-02f, -2.16476321e-02f,
  8.84016529e-02f, 1.74894884e-01f, 9.96650308e-02f, 2.19001304e-02f, -2.65553072e-02f, -4.44086129e-03f, 1.49477497e-01f, 5.53426035e-02f, 4.23153117e-02f, 1.45279756e-02f,
  1.05973862e-01f, 1.90525830e-01f, -3.56024057e-02f, 1.34283707e-01f, 6.48988634e-02f, 6.10290095e-02f, -6.14541732e-02f, -1.99893862e-02f, 4.31034192e-02f, 1.29131123e-01f,
  -7.00634941e-02f, -1.60646319e-01f, 4.48699802e-01f, -3.18460613e-02f, -5.92552781e-01f, 1.80431545e-01f, 4.30772036e-01f, -4.11317199e-01f, 3.94050926e-01f, -1.10903449e-01f,
  -3.75178874e-01f, 2.15406388e-01f, 3.77781332e-01f, -1.25505000e-01f, 5.19680560e-01f, 5.88975430e-01f, 1.49576321e-01f, 2.45789662e-01f, -2.17398480e-02f, -2.63746500e-01f,
  -1.82500228e-01f, -4.54241872e-01f, -1.01833860e-03f, -5.45629621e-01f, -3.86934221e-01f, -2.55884081e-01f, -2.31942967e-01f, -4.51137051e-02f, -3.43463182e-01f, -3.56676169e-02f,
  -1.73158914e-01f, -2.88576365e-01f, -1.81602135e-01f, 7.25146849e-03f, -1.98906556e-01f, -3.61368991e-02f, 1.66777506e-01f, 1.74714878e-01f, -1.90679394e-02f, -1.65840276e-02f,
  9.64194834e-02f, -7.72878155e-02f, -1.14835910e-01f, 4.71783802e-02f, -9.52745900e-02f, -5.25642708e-02f, -3.52324359e-02f, -1.18871123e-01f, -7.14750290e-02f, 2.17291769e-02f,
  7.11923018e-02f, -2.86074616e-02f, 7.18230940e-03f, 2.88452837e-03f, -1.51960470e-03f, -9.24977958e-02f, 1.79927409e-01f, 5.93188629e-02f, -2.59625725e-02f, -5.67500181e-02f,
  -8.12898502e-02f, 4.92248945e-02f, 3.18902098e-02f, -8.57625753e-02f, -5.25678769e-02f, -1.26224115e-01f, 1.07524000e-01f, -8.68702978e-02f, -2.46665496e-02f, -1.19695425e-01f,
  -8.49304944e-02f, -6.66752085e-02f, -1.28193870e-01f, -8.55979249e-02f, -5.35601452e-02f, 2.04535387e-02f, 1.04744844e-01f, -4.83398922e-02f, -2.30569616e-02f, -7.18582198e-02f,
  4.25452255e-02f, 7.88192153e-02f, -8.51767957e-02f, 6.47134706e-02f, 5.02692163e-03f, -1.99535582e-02f, -3.85418423e-02f, 6.12428971e-02f, 3.37222181e-02f, -3.13734449e-02f,
  -8.74974430e-02f, -6.23316094e-02f, -1.83273405e-01f, -1.25818968e-01f, 1.14807859e-01f, -5.37105761e-02f, 9.46397707e-02f, -4.75104041e-02f, 1.06542572e-01f, 7.15798885e-02f,
  -1.48869604e-01f, -4.89081740e-02f, 2.30826363e-02f, 1.01386741e-01f, -3.24902683e-02f, -1.77436753e-03f, 7.23101944e-02f, -5.26654087e-02f, -4.02324162e-02f, -2.04692379e-01f,
  -1.56046271e-01f, 3.67224514e-02f, 3.83837074e-02f, -9.29647610e-02f, -1.29594028e-01f, -1.15742169e-01f, -6.29160628e-02f, -9.22881439e-02f, -4.69366424e-02f, 8.65352005e-02f,
  -3.78563464e-01f, -6.56113923e-01f, 9.01147127e-02f, 1.11830801e-01f, 1.37947336e-01f, 2.45812386e-01f, 4.71136749e-01f, -4.63501453e-01f, -5.20684838e-01f, -2.34550834e-01f,
  8.88494551e-02f, 5.83070107e-02f, -1.69957072e-01f, 1.81713253e-01f, 4.53750223e-01f, -8.89513865e-02f, 2.34036967e-01f, 2.87285924e-01f, -1.88480273e-01f, -2.47914106e-01f,
  -6.89320788e-02f, 2.54912406e-01f, 2.85656601e-01f, -2.92787224e-01f, -5.96023798e-02f, -2.34081149e-01f, 1.45941958e-01f, -3.68956700e-02f, 1.44383878e-01f, 3.59347254e-01f,
  -1.84007645e-01f, -3.87693375e-01f, 1.60205457e-02f, -5.93390875e-02f, -9.59946364e-02f, 9.04121101e-02f, 1.44661114e-01f, 2.32974231e-01f, 6.21948615e-02f, 1.88482795e-02f,
  6.57794103e-02f, -3.08190603e-02f, 1.88157987e-02f, 5.62261082e-02f, -1.34026125e-01f, -3.32079306e-02f, -8.40246379e-02f, -1.37854461e-02f, -1.09608620e-01f, -6.60632104e-02f,
  -6.76376820e-02f, -1.31810280e-02f, -6.03267737e-02f, -6.56791148e-04f, 4.80451807e-02f, 2.03184206e-02f, 7.56511390e-02f, 8.73728245e-02f, 2.56345253e-02f, -7.40913004e-02f,
  2.49594301e-02f, 2.81260419e-03f, -9.58678126e-02f, -4.31471504e-02f, 4.98542115e-02f, -1.29974941e-02f, 5.98622262e-02f, 1.10552527e-01f, 6.80428278e-03f, -7.18981996e-02f,
  6.30066171e-02f, 2.69878991e-02f, -2.79708728e-02f, -3.67796756e-02f, 5.41934855e-02f, 7.84691498e-02f, 9.73441154e-02f, -6.82918802e-02f, -3.35369743e-02f, -2.14966387e-02f,
  1.97697617e-02f, -4.94933408e-03f, 2.15451531e-02f, 4.29739058e-02f, -7.39271333e-03f, 4.65259552e-02f, -1.08057782e-01f, -8.93629566e-02f, -8.22430011e-03f, 1.64611906e-01f,
  -6.20355546e-01f, -5.51979363e-01f, 3.98888299e-03f, 1.10673485e-02f, 5.19606061e-02f, -5.20482361e-02f, 4.60050255e-03f, -5.45077845e-02f, -1.20100118e-01f, 9.18086991e-03f,
  -1.00597799e-01f, 6.77514747e-02f, -1.42798960e-01f, 3.64892147e-02f, 1.39352843e-01f, -1.19981833e-01f, 3.23216394e-02f, 8.12343061e-02f, 1.12596877e-01f, -2.91149616e-02f,
  -8.25126097e-02f, 1.89742781e-02f, 4.65836525e-02f, -1.42738119e-01f, 2.62442939e-02f, 3.75818647e-02f, -1.21858366e-01f, 1.68921743e-02f, -9.32020694e-03f, 2.84334533e-02f,
  6.17803745e-02f, 3.19579333e-01f, -4.03964162e-01f, 2.84144104e-01f, -3.72677535e-01f, 4.60368574e-01f, 6.12230062e-01f, 6.18069023e-02f, 2.28402644e-01f, 5.82053840e-01f,
  2.85709977e-01f, 5.51855639e-02f, 2.08529457e-01f, 7.15678990e-01f, 1.89789549e-01f, 4.68187183e-01f, 6.66615605e-01f, 5.45869410e-01f, -5.39232604e-02f, 2.13530779e-01f,
  4.23492901e-02f, 5.17418742e-01f, 1.05890827e-02f, -1.44625872e-01f, 2.84686070e-02f, -3.93349320e-01f, -1.15910716e-01f, -4.71481532e-01f, 1.24875799e-01f, -3.43804881e-02f,
  -4.72127534e-02f, 3.52336839e-02f, -6.96326569e-02f, -2.23788470e-02f, 5.61087951e-02f, -1.50260702e-01f, -5.54413497e-02f, -1.91305220e-01f, -1.46750018e-01f, 5.36103267e-03f,
  3.16205285e-02f, -4.24859412e-02f, 1.39196187e-01f, 5.08151902e-03f, -5.22325076e-02f, -1.10407680e-01f, -1.78323984e-02f, -3.09920367e-02f, 6.98151067e-02f, -8.69332328e-02f,
  -2.55985167e-02f, 2.19749846e-02f, -2.86567993e-02f, 1.03309214e-01f, -1.09938018e-01f, 1.23090670e-02f, 5.26991934e-02f, -1.59090295e-01f, 1.07299676e-02f, 5.63184097e-02f,
  -2.05923859e-02f, 1.39492258e-01f, 1.25530183e-01f, -2.77059712e-02f, 1.87462289e-02f, -2.93335039e-02f, 9.61140916e-02f, -2.83974949e-02f, -9.67294797e-02f, 1.12002403e-01f,
  -6.25948757e-02f, -9.91512388e-02f, 7.42639899e-02f, 8.98842141e-02f, 1.19858526e-01f, 4.69166972e-03f, -1.22581147e-01f, -7.57534662e-03f, 7.87770078e-02f, -1.02345474e-01f,
  -2.81863324e-02f, 7.12458789e-02f, 3.07287788e-03f, -9.81688946e-02f, 7.94052184e-02f, -7.95441195e-02f, 7.77048524e-03f, -4.30171490e-02f, -2.50097848e-02f, -5.59627376e-02f,
  2.64152855e-01f, 3.35839748e-01f, 9.73198712e-02f, 3.02517824e-02f, -2.03035679e-02f, 1.82997659e-02f, 1.17300086e-01f, -5.37371896e-02f, 1.08593693e-02f, 8.37391913e-02f,
  -7.98168220e-03f, 1.09907143e-01f, -5.48262000e-02f, -5.83081506e-02f, 1.43816788e-02f, 1.25037342e-01f, 2.43518412e-01f, -2.83820729e-04f, 5.77675030e-02f, -2.61580087e-02f,
  -2.50928998e-02f, 4.16107699e-02f, -2.03806181e-02f, -2.51186676e-02f, 3.37051637e-02f, 2.23390758e-02f, -2.49776319e-02f, -1.27473414e-01f, -4.44396362e-02f, 1.31998658e-01f,
  8.73977304e-01f, -3.57017398e-01f, -2.63301939e-01f, 4.65748131e-01f, 5.51639259e-01f, 3.89698803e-01f, 3.33730131e-01f, 5.22850573e-01f, 6.11909509e-01f, -2.21582443e-01f,
  2.29336932e-01f, -3.05603683e-01f, -2.44194075e-01f, 2.51897454e-01f, 3.47073644e-01f, -1.71016783e-01f, 4.14045662e-01f, 1.09734125e-01f, 9.52457041e-02f, 3.81520569e-01f,
  3.21091443e-01f, 4.21005875e-01f, -2.39741534e-01f, 2.76211090e-02f, 2.55448014e-01f, -1.80528983e-01f, -2.02424273e-01f, -3.55287701e-01f, -1.98999092e-01f, -1.24482691e-01f,
  -1.09027261e-02f, 1.34890318e-01f, -1.55414075e-01f, -1.95151091e-01f, 8.47325400e-02f, 6.33367524e-03f, -1.90537572e-01f, -1.47165686e-01f, 9.47502702e-02f, 7.62722194e-02f,
  -5.48223890e-02f, 4.77820970e-02f, 1.27504259e-01f, -4.31246571e-02f, 7.73005933e-02f, 9.95704066e-03f, -1.06486296e-02f, -4.15197462e-02f, -6.15502335e-02f, -3.54413763e-02f,
  7.02620065e-03f, -4.98574898e-02f, 1.15921885e-01f, -1.25860721e-01f, -2.05858219e-02f, 1.23518191e-01f, -1.32630631e-01f, -1.82024688e-01f, -3.29955034e-02f, 1.31848201e-01f,
  1.01681128e-01f, -1.58259362e-01f, -2.57844082e-03f, -1.89458150e-02f, 1.66996531e-02f, 3.67940329e-02f, 2.16460284e-02f, -1.19059496e-01f, 1.81216132e-02f, -3.60232033e-02f,
  1.04222156e-01f, 1.06606647e-01f, 4.04802077e-02f, 3.07185613e-02f, 9.87017527e-02f, 1.13963306e-01f, 1.76283978e-02f, 1.82209890e-02f, 1.51958475e-02f, 7.02905729e-02f,
  4.77817404e-04f, 4.58366275e-02f, -4.16964889e-02f, -6.74046576e-02f, 3.97407077e-02f, -1.54589526e-02f, -2.41740067e-02f, 9.89517346e-02f, -1.88228246e-02f, 5.52305877e-02f,
  6.79010525e-02f, -4.11683097e-02f, -7.85090104e-02f, -8.73028487e-02f, -1.50811613e-01f, 1.08899072e-01f, 2.81979125e-02f, 1.38725176e-01f, -1.41681703e-02f, 1.99516237e-01f,
  9.53963920e-02f, 2.48524919e-02f, -4.38008457e-02f, -7.53873214e-02f, -2.91516185e-01f, 2.29455039e-01f, -1.05718877e-02f, -6.82115778e-02f, -1.55638866e-02f, -5.47339246e-02f,
  -1.26911506e-01f, 6.85212165e-02f, -4.90861125e-02f, 1.81123018e-01f, 3.61668468e-02f, -1.08088583e-01f, 3.48120555e-02f, -2.17814445e-02f, 1.59921939e-03f, -5.27018532e-02f,
  1.03284374e-01f, 7.37228841e-02f, -2.03452006e-01f, -3.24933678e-01f, 1.27722900e-02f, -6.27040565e-01f, -3.44988108e-01f, 1.64359361e-01f, 1.95662424e-01f, -1.42277526e-02f,
  -1.44864276e-01f, -2.14953318e-01f, 2.77287930e-01f, -4.45631146e-01f, -3.35601181e-01f, 5.50718307e-02f, -6.47080362e-01f, -5.19297063e-01f, 2.65934974e-01f, -5.14205873e-01f,
  -1.25870496e-01f, -5.91542721e-02f, -2.66226143e-01f, 3.39276910e-01f, -2.08270967e-01f, 8.50016996e-02f, -2.22745575e-02f, 3.57265681e-01f, -3.78796220e-01f, 6.49727434e-02f,
  1.07544521e-02f, 2.46338978e-01f, -1.35726742e-02f, 9.31404382e-02f, -1.92015976e-01f, -7.66757950e-02f, -1.78696007e-01f, 7.57434219e-02f, 2.10325811e-02f, 3.35541479e-02f,
  -8.94376338e-02f, -2.06963485e-03f, 8.43876600e-03f, 2.80559033e-01f, 1.76926240e-01f, 4.12559099e-02f, -6.24645315e-02f, -2.15077102e-01f, -5.82886450e-02f, -1.36182010e-01f,
  -1.48433954e-01f, -5.79204746e-02f, -7.77947009e-02f, -5.43287024e-02f, -3.56006920e-02f, 5.06951585e-02f, -1.48544863e-01f, -1.79193094e-01f, -8.06219429e-02f, -5.71197458e-02f,
  7.74908364e-02f, 1.05388761e-01f, 7.93250874e-02f, 2.73440689e-01f, -5.66056278e-03f, -4.21172380e-02f, -2.54799193e-03f, -8.23932439e-02f, 1.04784332e-01f, -1.58598214e-01f,
  -6.40591979e-02f, 4.60483916e-02f, 1.96762189e-01f, 5.39100170e-02f, -4.32246476e-02f, 2.07298044e-02f, -1.34814933e-01f, 2.11452711e-02f, -1.25919372e-01f, -7.26654902e-02f,
  1.32666320e-01f, -4.60872948e-02f, 7.32561946e-02f, -1.80535391e-02f, -8.76591057e-02f, 9.92355496e-02f, 8.42431411e-02f, -6.23684600e-02f, 2.42757844e-03f, -2.40833499e-02f,
  -2.12572441e-01f, -4.51524518e-02f, 9.16682482e-02f, 4.49370295e-02f, -1.07901871e-01f, -5.51655442e-02f, 6.99944911e-04f, -1.00914486e-01f, 3.38694863e-02f, 7.14447722e-02f,
  -1.13545537e-01f, -1.64773732e-01f, -1.04294412e-01f, 5.72050177e-02f, 1.06136752e-02f, -5.80444746e-03f, -1.58147708e-01f, -3.10965069e-02f, -2.01276511e-01f, -1.13055393e-01f,
  -1.59005132e-02f, -2.49324217e-02f, 1.18668033e-02f, -2.04557702e-02f, -9.80471075e-02f, -1.31558314e-01f, -3.36699225e-02f, 3.14004421e-02f, -9.60790366e-02f, -8.86087194e-02f,
  2.30370909e-01f, 1.33647814e-01f, -4.22674775e-01f, -3.77396464e-01f, 8.45700949e-02f, 2.32571676e-01f, 3.29712406e-02f, -6.90671727e-02f, -3.89669478e-01f, 4.54110175e-01f,
  2.54455507e-01f, -2.12162256e-01f, -4.91471589e-02f, -1.47534981e-01f, -4.38132852e-01f, -2.67859876e-01f, 2.12175265e-01f, 2.22765252e-01f, -2.24377289e-01f, 2.09810242e-01f,
  -1.46072268e-01f, 1.57088012e-01f, -3.35101843e-01f, 1.09551229e-01f, 2.84208745e-01f, 9.61937681e-02f, 3.35905522e-01f, -1.16844840e-01f, 1.07036598e-01f, -8.56562629e-02f,
  -3.52825001e-02f, -1.16132513e-01f, -1.01640560e-01f, -5.65991774e-02f, 6.29992485e-02f, 2.21756458e-01f, 1.42386138e-01f, -3.83353867e-02f, -1.70421019e-01f, -9.48419049e-02f,
  1.74832121e-01f, -4.95597795e-02f, -1.07312359e-01f, -9.68794748e-02f, 1.21882543e-01f, 1.93376038e-02f, -1.58618838e-01f, 9.43418667e-02f, -1.08200781e-01f, 6.67513981e-02f,
  -4.18303646e-02f, 1.13308482e-01f, 1.99100316e-01f, -5.08647785e-02f, -5.94826788e-02f, 1.10329064e-02f, 1.91422701e-02f, 1.62767097e-01f, 1.03576526e-01f, 4.56735231e-02f,
  2.12343395e-01f, 1.80109426e-01f, -2.58295275e-02f, -6.32003546e-02f, -9.47300196e-02f, -2.80954968e-02f, 2.04893537e-02f, -1.27573160e-03f, -8.40613525e-03f, -5.39255366e-02f,
  -1.21824108e-01f, -7.14041516e-02f, 8.46364200e-02f, 3.45742702e-02f, 4.67457473e-02f, -6.95379376e-02f, 1.01453690e-02f, 1.20158702e-01f, -1.40994405e-02f, -3.62442918e-02f,
  -9.28546041e-02f, 6.47860467e-02f, -6.15490153e-02f, 1.40925720e-01f, 2.29675230e-02f, -6.80897608e-02f, 3.76804471e-02f, -2.38341391e-02f, -2.79708374e-02f, 1.16552740e-01f,
  1.00204021e-01f, 3.84940207e-02f, -5.23375049e-02f, -3.68993282e-02f, -1.10130548e-01f, 9.73071158e-02f, -1.04297251e-01f, -1.17088789e-02f, -2.49656215e-02f, 1.43082822e-02f,
  1.82922781e-01f, 9.69985314e-03f, 2.49911800e-01f, -5.45033254e-02f, -8.31374452e-02f, 1.01403981e-01f, 8.82931054e-02f, -4.90503795e-02f, -1.14124855e-02f, 1.07278824e-01f,
  1.24352999e-01f, 8.78436565e-02f, 6.22331016e-02f, -3.44182663e-02f, 1.05252303e-01f, 1.38881788e-01f, 1.17404796e-01f, -4.22006585e-02f, 1.35386303e-01f, -6.89859465e-02f,
  9.62412059e-02f, -2.65368104e-01f, -1.99926540e-01f, 2.24806622e-01f, -1.65481165e-01f, 1.17363110e-01f, 4.31813896e-01f, -5.54643534e-02f, -3.70776147e-01f, 2.44008407e-01f,
  4.00612235e-01f, 2.11849317e-01f, 3.17475945e-01f, 5.50697207e-01f, 5.49306691e-01f, 3.21128756e-01f, 3.00962359e-01f, 1.43638104e-01f, -2.72504777e-01f, -9.79550257e-02f,
  1.24240212e-01f, 3.21210533e-01f, 4.71772730e-01f, -1.67167798e-01f, 2.03319743e-01f, 3.02719977e-02f, 3.59377563e-01f, 2.05444723e-01f, 3.55178237e-01f, 2.74701685e-01f,
  3.71849947e-02f, -6.68391213e-02f, -8.35523456e-02f, -3.90083343e-02f, 2.61332411e-02f, 2.15605833e-02f, 3.05270405e-05f, 2.89144009e-01f, 1.49963558e-01f, -1.29310731e-02f,
  9.90750417e-02f, -3.38222943e-02f, 6.75118389e-03f, -4.77649942e-02f, -1.33721367e-01f, -7.59635717e-02f, -5.01601100e-02f, -9.58347470e-02f, -1.19466558e-01f, -1.42438151e-02f,
  -1.52952485e-02f, -8.61064196e-02f, 9.95659009e-02f, 5.32656312e-02f, 6.19611628e-02f, -8.08435157e-02f, -6.78672642e-02f, -3.02683078e-02f, -1.19660504e-01f, -1.27421781e-01f,
  1.10999262e-02f, -6.42892197e-02f, -6.50926679e-02f, 7.19540194e-02f, -2.69744154e-02f, 1.12648923e-02f, -4.50696982e-02f, 1.04316182e-01f, 7.56141543e-02f, 1.06835678e-01f,
  -4.97478992e-02f, -6.01937547e-02f, 1.25974333e-02f, 6.11090288e-02f, 3.74559797e-02f, -4.28324752e-02f, 1.33983597e-01f, 3.05978954e-02f, -1.66430682e-01f, 1.42524801e-02f,
  -9.16586816e-03f, 2.73845363e-02f, 3.96426991e-02f, 5.73543720e-02f, -6.88853711e-02f, 6.86347038e-02f, 6.83493838e-02f, -2.11520959e-02f, 1.44765270e-03f, 1.00277305e-01f,
  1.59179226e-01f, 2.26789355e-01f, -3.42241395e-03f, -5.88799827e-02f, -1.04009598e-01f, -7.65797347e-02f, 1.12754107e-02f, -1.46692563e-02f, 2.15209261e-01f, -8.98601040e-02f,
  -5.08369356e-02f, -7.28550330e-02f, 2.99429428e-02f, -5.05839512e-02f, 7.27156252e-02f, 4.71613789e-03f, 1.35640129e-01f, -2.36553475e-02f, 2.58893371e-02f, 7.15627009e-03f,
  9.77328196e-02f, 5.01874089e-02f, 1.31982729e-01f, -1.29197985e-01f, -3.33522744e-02f, 1.46631837e-01f, -9.69231501e-02f, -3.81869674e-02f, 7.54960999e-02f, 6.50409237e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 26)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 26;
const float L0_fan_Bp_bar_data[] = {
  3.85085881e-01f, 5.16201019e-01f, 5.53436816e-01f, 3.44362706e-01f, 5.41308224e-01f, 5.65505207e-01f, 5.89045584e-01f, 7.01233506e-01f, 6.41656637e-01f, 5.86869895e-01f,
  3.46167564e-01f, 5.10927737e-01f, 5.22958875e-01f, 3.33919764e-01f, 5.31945109e-01f, 5.25195181e-01f, 5.05531907e-01f, 3.85144860e-01f, 3.56486380e-01f, 7.98402786e-01f,
  3.27405512e-01f, 4.62645322e-01f, 4.26387072e-01f, 3.15371662e-01f, 5.03210723e-01f, 3.77867579e-01f
};

// L1_linear_W (Shape: 12 x 32)
const int L1_linear_W_rows = 12;
const int L1_linear_W_cols = 32;
const float L1_linear_W_data[] = {
  -4.86319419e-03f, 1.01112999e-01f, -7.58463681e-01f, -3.81526768e-01f, 4.31100994e-01f, 3.22712958e-01f, -4.79922384e-01f, -8.44581783e-01f, -1.05585195e-01f, -9.94837955e-02f,
  4.11262304e-01f, 1.54560208e-01f, -5.23775101e-01f, -2.05704480e-01f, -7.69660711e-01f, -4.97832716e-01f, 3.09666246e-01f, 3.79291624e-01f, 1.38019398e-01f, -5.20885885e-01f,
  -7.08293557e-01f, -6.97686017e-01f, -2.37461179e-01f, 5.75100780e-01f, 6.62153184e-01f, 2.00512618e-01f, 3.90151560e-01f, 4.75083262e-01f, -7.73409128e-01f, -7.27990031e-01f,
  -1.09285362e-01f, 3.00470501e-01f, 1.71127506e-02f, -2.57948488e-01f, 4.07829769e-02f, -1.58304423e-01f, -7.36429155e-01f, -2.86962479e-01f, -1.01048827e+00f, 3.11027557e-01f,
  1.95492551e-01f, -5.53055406e-01f, -6.32941723e-01f, 5.60589433e-01f, 3.83277945e-02f, 4.03968483e-01f, -4.53646332e-01f, -2.04385221e-01f, 5.33400536e-01f, -6.23337328e-01f,
  -9.94322956e-01f, -8.92096281e-01f, -1.77382365e-01f, 2.44739711e-01f, -7.42156506e-01f, 2.44413167e-01f, -7.65085757e-01f, -1.00423658e+00f, -2.07767159e-01f, 5.54389954e-01f,
  5.79960346e-01f, 2.02821821e-01f, 4.85837549e-01f, 4.08145785e-01f, -1.90578520e-01f, -4.47605193e-01f, -4.27114740e-02f, 1.54976487e-01f, 3.87037456e-01f, -9.76478606e-02f,
  3.87989700e-01f, 7.27104843e-01f, -5.18131077e-01f, -2.45299682e-01f, -1.34859636e-01f, -5.76502919e-01f, -7.93064296e-01f, -4.99539137e-01f, -5.75276792e-01f, -2.16711938e-01f,
  6.63677812e-01f, -5.88517368e-01f, -2.36661553e-01f, -4.71265726e-02f, 6.62682235e-01f, -5.62875509e-01f, -2.87791669e-01f, -2.71610916e-01f, -2.84416169e-01f, -4.01283503e-01f,
  6.66840851e-01f, -2.89620370e-01f, 9.14247558e-02f, -3.13132256e-01f, -4.64056849e-01f, -1.88350007e-02f, -3.35655242e-01f, -3.18141192e-01f, -1.96635395e-01f, -4.22054648e-01f,
  9.63406190e-02f, 5.93791366e-01f, -3.88859212e-01f, -3.84838909e-01f, -4.11387801e-01f, 5.10519028e-01f, 6.62541687e-01f, -7.03819394e-01f, 2.05596179e-01f, 6.69956446e-01f,
  -9.58108187e-01f, -3.06796521e-01f, -4.93278891e-01f, 5.53141423e-02f, 3.27246279e-01f, -1.31754830e-01f, -8.27389479e-01f, 1.33282449e-02f, -2.26266235e-01f, 4.07515466e-01f,
  3.24451417e-01f, -9.17521358e-01f, -3.27896893e-01f, -6.73568010e-01f, -2.64716327e-01f, 7.47228682e-01f, -3.11464876e-01f, -2.82564402e-01f, 5.22751391e-01f, 1.01700813e-01f,
  3.06056410e-01f, 8.35491896e-01f, 4.07310665e-01f, 6.00989819e-01f, 6.64443150e-02f, 7.51097560e-01f, 7.87366271e-01f, 6.61768913e-02f, 6.28650427e-01f, -1.79736897e-01f,
  1.22635514e-01f, -4.86132979e-01f, 6.09807909e-01f, -8.20676327e-01f, -5.37140608e-01f, 7.76834846e-01f, 3.87001514e-01f, -4.81304049e-01f, -1.04572736e-01f, -2.45586991e-01f,
  -1.30032718e-01f, 4.14409578e-01f, -6.34235263e-01f, 2.71968152e-02f, -1.47607878e-01f, -9.19183433e-01f, -8.82323980e-01f, -2.50843108e-01f, -4.10536259e-01f, -5.22624969e-01f,
  4.16589051e-01f, 2.01631635e-01f, 1.98553026e-01f, -6.39244974e-01f, -6.33885026e-01f, 3.33981067e-01f, 3.79086047e-01f, -5.09305656e-01f, 7.18205750e-01f, 6.58834457e-01f,
  -6.44557476e-01f, 7.90982470e-02f, -7.60978043e-01f, 5.29762149e-01f, -1.78283975e-01f, 5.41422129e-01f, -9.67682421e-01f, 2.10358128e-01f, -7.92668700e-01f, 5.12995601e-01f,
  -3.88032019e-01f, -6.64470494e-01f, -2.13872954e-01f, -6.39841139e-01f, -5.96079290e-01f, 6.09637618e-01f, -4.47959185e-01f, 4.93630350e-01f, -1.78138465e-02f, -7.36668527e-01f,
  -4.16668564e-01f, -3.20315480e-01f, -3.76452766e-02f, 7.87843466e-02f, 1.45842716e-01f, -3.39978427e-01f, 6.31382227e-01f, -7.44440556e-02f, -1.63977146e-01f, -4.60058779e-01f,
  -4.37701732e-01f, -7.03589261e-01f, -6.87839270e-01f, -4.60567415e-01f, -1.04097776e-01f, -7.59007871e-01f, 5.42445779e-01f, 2.90946305e-01f, 3.84494364e-01f, -8.75736296e-01f,
  -3.48596692e-01f, 3.34963381e-01f, -1.09925635e-01f, -8.50150049e-01f, 9.59216774e-01f, -2.49908611e-01f, -1.80943787e-01f, 3.54064326e-03f, -2.85208166e-01f, -2.41455376e-01f,
  8.78820598e-01f, 4.94719386e-01f, -3.84903908e-01f, -8.26173544e-01f, -4.64723557e-01f, 3.88415158e-02f, -2.01705948e-01f, 2.88589448e-01f, -1.63200095e-01f, 2.66182601e-01f,
  1.70494094e-01f, -4.24785376e-01f, -9.01377946e-02f, 5.95616341e-01f, -6.06516957e-01f, -2.66750008e-01f, 1.99643802e-02f, -6.19215548e-01f, 1.33320376e-01f, -1.75411060e-01f,
  -1.16867214e-01f, -5.44483244e-01f, -4.41806972e-01f, 7.14130163e-01f, -1.11687034e-01f, 5.94247520e-01f, -5.33880532e-01f, -3.12639445e-01f, 8.08080584e-02f, 2.97622204e-01f,
  -2.61935085e-01f, -3.39389831e-01f, -5.13879836e-01f, 5.06109357e-01f, -1.59834787e-01f, -3.93395782e-01f, -3.29451524e-02f, -1.51115119e-01f, 4.71167341e-02f, -4.08766091e-01f,
  8.03156942e-02f, -2.24708050e-01f, 7.79490173e-01f, -5.71085334e-01f, -5.74270308e-01f, -3.97737265e-01f, -3.10469009e-02f, 5.13142586e-01f, 6.41385257e-01f, -2.94503391e-01f,
  -2.03788579e-01f, -5.42595863e-01f, -5.09915054e-01f, -3.61268401e-01f, 2.42196694e-01f, 4.99765985e-02f, 4.63138431e-01f, -4.64499831e-01f, -5.16732574e-01f, -4.73148555e-01f,
  -4.31763738e-01f, -4.83394265e-01f, -4.03310776e-01f, 3.79059874e-02f, -2.99744811e-02f, -2.45672375e-01f, -3.22951049e-01f, 3.70878875e-01f, 2.16643587e-01f, 2.19018772e-01f,
  3.46837901e-02f, -2.59422660e-01f, 2.35137478e-01f, -5.98569334e-01f, -6.20209098e-01f, 1.63511619e-01f, -7.18706191e-01f, -5.24160922e-01f, -4.94022548e-01f, -4.19936061e-01f,
  6.00048043e-02f, -3.31369668e-01f, 7.49883115e-01f, -4.35723156e-01f, -3.18084329e-01f, -1.66868135e-01f, -4.57717299e-01f, -4.37461257e-01f, -6.95958316e-01f, 9.02551949e-01f,
  -2.16712996e-01f, -7.26157367e-01f, -1.68514550e-01f, 7.35119641e-01f, 7.83119738e-01f, -4.69760001e-01f, -3.87306541e-01f, -7.84412384e-01f, -2.41252229e-01f, 7.03704178e-01f,
  -6.33978248e-02f, 3.18554252e-01f, 1.74287289e-01f, 6.42595708e-01f, -2.11317301e-01f, -7.09399819e-01f, -1.99090540e-01f, -1.01851091e-01f, 1.93841547e-01f, -5.35553157e-01f,
  -8.03030968e-01f, -5.89255452e-01f, -3.75978798e-01f, 4.30653602e-01f, -3.93672347e-01f, -5.68610728e-01f, -4.12738383e-01f, -4.10715267e-02f, 4.91862446e-01f, -4.25792813e-01f,
  7.72174478e-01f, 2.16135338e-01f, -2.10479289e-01f, -5.99243224e-01f, 7.73722947e-01f, -2.75640786e-01f, -3.61738324e-01f, -4.60387319e-01f, -2.66206503e-01f, -2.65113264e-01f,
  7.53506243e-01f, -4.89134640e-01f, -1.36885777e-01f, 5.07744364e-02f, 3.10764343e-01f, 5.97263336e-01f, -2.74690330e-01f, -2.28092019e-02f, -1.18289061e-01f, -3.06682587e-01f,
  -6.44697249e-01f, -1.83196262e-01f, 6.97300851e-01f, 2.77272642e-01f, 6.30236804e-01f, -2.64363170e-01f, -6.11119092e-01f, 1.02333403e+00f, -2.70183563e-01f, -1.53334141e-01f,
  3.82466316e-01f, 1.42678156e-01f, -6.07815802e-01f, -2.43610278e-01f, 5.60747206e-01f, -3.34429324e-01f, -4.39913779e-01f, -1.13995172e-01f, -3.21143389e-01f, -6.07005179e-01f,
  -4.62984711e-01f, -4.90810424e-01f, 1.23961158e-01f, -5.34473062e-01f
};

// L1_linear_B (Shape: 1 x 12)
const int L1_linear_B_rows = 1;
const int L1_linear_B_cols = 12;
const float L1_linear_B_data[] = {
  -1.72336027e-01f, 6.50507361e-02f, -7.78894871e-02f, -1.20329969e-01f, 5.91716580e-02f, 2.25320473e-01f, -8.93034623e-04f, -1.56990200e-01f, -4.68952879e-02f, 1.32309645e-01f,
  -8.50585401e-02f, -9.19301808e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 3, 26
    );
    
    // Camada 1: L1_linear
    linear_forward_pgm(
        buffer1, x_out,
        L1_linear_W_data, L1_linear_B_data,
        32, 12
    );
    }
    