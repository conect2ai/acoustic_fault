/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 32 (x4)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 32;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    float x3 = x * x * x;
    return 0.5f * x * (1.0f + tanhf(0.79788456f * (x + 0.044715f * x3)));
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 6 x 120)
const int L0_fan_Wp_rows = 6;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  7.37996474e-02f, 1.84714466e-01f, 2.07109034e-01f, 5.55639807e-03f, -7.79400170e-02f, -2.52558976e-01f, 5.95728261e-03f, -1.56368464e-01f, -4.95144837e-02f, 1.76252037e-01f,
  1.44259900e-01f, -1.64645374e-01f, 7.01227458e-03f, -1.23902969e-01f, -6.83573335e-02f, 2.51874685e-01f, 1.48734987e-01f, 2.13626046e-02f, -2.11949602e-01f, -2.31867820e-01f,
  -7.37125948e-02f, -1.09768696e-02f, -3.66967581e-02f, -3.87835950e-02f, 1.23411387e-01f, -4.75254059e-02f, 6.75969645e-02f, 8.01083520e-02f, -4.93628904e-02f, 3.52866828e-01f,
  2.74397209e-02f, 5.75772338e-02f, -1.59915775e-01f, -2.62290407e-02f, 7.88931176e-02f, 2.74319518e-02f, 4.78268005e-02f, -3.55312750e-02f, -3.48410644e-02f, 6.31996691e-02f,
  -5.54054901e-02f, 5.78245483e-02f, -2.78757755e-02f, -3.76226939e-02f, -1.90033857e-02f, 3.39791477e-02f, 1.22752436e-01f, -2.74558458e-03f, -3.75766233e-02f, -1.87104121e-02f,
  1.34978592e-01f, -1.50543945e-02f, -1.67777669e-02f, -1.74872652e-02f, 2.12512296e-02f, -7.94584304e-02f, -2.76458021e-02f, -5.25020696e-02f, -3.09180487e-02f, 4.45235223e-02f,
  -1.32640898e-01f, -6.96579367e-02f, -2.72096749e-02f, 9.44988336e-03f, 6.31781593e-02f, -9.58150849e-02f, 5.61473593e-02f, -9.16171670e-02f, -3.25025991e-02f, -3.24197747e-02f,
  -5.70946257e-04f, 2.53891926e-02f, -2.24122070e-02f, 2.91770771e-02f, -3.50258499e-02f, -3.14163906e-03f, -1.51336581e-01f, -3.13055217e-02f, -5.69675677e-02f, -1.14237651e-01f,
  -4.00750935e-02f, -3.37370392e-03f, -7.81261101e-02f, -2.39922442e-02f, 1.68535369e-03f, -8.11128095e-02f, -5.17897354e-03f, -2.54821833e-02f, 2.98034456e-02f, -1.20958984e-02f,
  -1.33117288e-01f, -4.75335456e-02f, 4.00769114e-02f, -2.43981578e-03f, -1.32155996e-02f, 5.43855913e-02f, 2.62365658e-02f, -4.26708050e-02f, -3.32248770e-02f, 4.89310138e-02f,
  5.20482697e-02f, 6.52006641e-02f, 4.79523540e-02f, 4.71756607e-02f, 1.05297513e-01f, 2.84494255e-02f, 9.46936533e-02f, -3.60865667e-02f, -5.09210750e-02f, 1.54503910e-02f,
  3.23646665e-02f, 5.35314120e-02f, 6.16071597e-02f, 5.98547282e-03f, -1.11580811e-01f, -4.35032584e-02f, 7.36884177e-02f, -2.76357103e-02f, 8.80265608e-04f, 1.08504370e-01f,
  5.65715373e-01f, 8.97453874e-02f, 2.50452816e-01f, 7.76854977e-02f, -2.09470436e-01f, 3.54463235e-02f, 1.90328091e-01f, 2.56048478e-02f, 1.17373792e-02f, -1.13131888e-01f,
  -1.78412616e-01f, -2.04188406e-01f, -1.37165874e-01f, -1.31738603e-01f, 1.20444477e-01f, 2.16533970e-02f, 1.19436271e-01f, 8.73084590e-02f, 1.98115930e-01f, -1.58120647e-01f,
  -8.23562667e-02f, 1.33116826e-01f, 3.11432630e-01f, 8.68625194e-02f, -1.43816382e-01f, -7.57680982e-02f, -1.89020503e-02f, -3.27842496e-02f, 3.17487027e-03f, -1.72542706e-01f,
  -4.77521457e-02f, 1.62486807e-01f, -1.26177743e-01f, -4.74361591e-02f, 6.55700415e-02f, 2.52495855e-02f, 2.74008065e-02f, 5.29292114e-02f, 2.27899048e-02f, 2.28118766e-02f,
  -1.31315693e-01f, -6.58307374e-02f, -1.00624099e-01f, 2.19717454e-02f, -6.15924830e-03f, 1.06832482e-01f, 5.67748956e-02f, 1.50384426e-01f, -5.37108630e-03f, -1.44623555e-02f,
  -1.35782346e-01f, -3.32733952e-02f, 1.00571431e-01f, 1.98214110e-02f, 7.70038366e-03f, -9.94933397e-02f, -1.06364470e-02f, 6.03892952e-02f, 3.81453447e-02f, 4.26313505e-02f,
  -1.21953767e-02f, 6.16071150e-02f, -3.00798360e-02f, 8.94321427e-02f, 9.41638574e-02f, -4.12130319e-02f, -2.83365995e-02f, 3.03554293e-02f, 3.65756568e-03f, 3.05116754e-02f,
  4.05182131e-02f, -3.35226618e-02f, 1.07737938e-02f, 2.61079520e-02f, -4.04501222e-02f, 7.80390808e-03f, 6.11428805e-02f, 2.21275855e-02f, 1.05955554e-02f, -2.25048084e-02f,
  6.58204630e-02f, -6.84802458e-02f, 1.08559867e-02f, -1.68512785e-03f, -7.19371140e-02f, -2.36401241e-02f, -6.43070787e-02f, -9.55317691e-02f, 3.32926922e-02f, -1.66937206e-02f,
  1.41601786e-01f, 9.02816430e-02f, -4.73199412e-02f, -9.04407203e-02f, 1.61549030e-03f, 4.70713750e-02f, 7.33835855e-04f, -5.80426119e-02f, -4.25105207e-02f, -3.15373577e-02f,
  -5.52902594e-02f, 1.21177688e-01f, 9.08466871e-04f, -2.68055703e-02f, -9.37964246e-02f, -5.67513816e-02f, 2.60051270e-03f, 4.01144847e-03f, -5.98060479e-03f, -2.75871623e-02f,
  6.45065010e-02f, 1.69068679e-01f, 1.60572886e-01f, 2.88322531e-02f, 2.41268855e-02f, 3.42098586e-02f, 1.04300186e-01f, -3.25698182e-02f, 2.13963404e-01f, 1.74372584e-01f,
  -4.30173606e-01f, -1.35728612e-03f, -3.28442156e-01f, -3.05811733e-01f, -3.29100698e-01f, -2.74288565e-01f, -2.10068360e-01f, -1.61611810e-01f, 4.10317034e-02f, -1.78532973e-02f,
  1.33900553e-01f, 5.05932085e-02f, 2.05826774e-01f, 7.93431476e-02f, -5.30701093e-02f, -1.22671373e-01f, -2.69958228e-01f, -1.80110469e-01f, -1.76702797e-01f, -2.83225775e-01f,
  2.93035321e-02f, -3.36621255e-02f, -7.09290579e-02f, -6.52528256e-02f, -1.24511398e-01f, 6.67914823e-02f, 1.25990257e-01f, -1.54350653e-01f, 3.62263992e-02f, -1.51297942e-01f,
  -2.12790277e-02f, -3.27000648e-01f, 1.29717570e-02f, -3.68821658e-02f, -4.55082506e-02f, -4.78331484e-02f, -8.05203617e-02f, -7.96372816e-02f, -6.04393370e-02f, 4.16119099e-02f,
  -7.06444383e-02f, -1.29894957e-01f, -1.51371792e-01f, -4.33160104e-02f, -1.77313268e-01f, -1.56995431e-01f, -9.17049274e-02f, -1.56788528e-01f, -9.29083824e-02f, -1.11408532e-01f,
  -8.00173059e-02f, -1.98075071e-01f, -1.60559416e-01f, -1.23326980e-01f, -8.12530592e-02f, -3.86165753e-02f, -1.38131604e-01f, -1.25222474e-01f, -9.44169834e-02f, -1.78660620e-02f,
  8.59815925e-02f, 6.42139763e-02f, 7.62111172e-02f, -3.22054513e-02f, 1.12088218e-01f, 7.07490668e-02f, -4.61740531e-02f, -2.55934894e-02f, 8.22055992e-03f, 2.77507752e-02f,
  -1.73709244e-02f, -4.72625047e-02f, -2.47695241e-02f, 4.31293063e-02f, 4.40854840e-02f, -5.28202765e-02f, -3.01515441e-02f, 7.25200400e-02f, -2.11927444e-02f, -4.95329872e-02f,
  5.24149984e-02f, -3.23574655e-02f, 4.83123772e-02f, 1.91425206e-03f, 7.04110088e-03f, -4.10063565e-02f, 3.57360654e-02f, 7.75764287e-02f, 3.08320653e-02f, -2.67885961e-02f,
  4.35484648e-01f, 6.09782524e-02f, 2.31483933e-02f, 3.25360261e-02f, -1.36969704e-02f, -1.08803967e-02f, -3.79156619e-02f, 3.86746824e-02f, -4.42782268e-02f, -1.06715269e-01f,
  -1.64642915e-01f, -2.66678985e-02f, 2.17701569e-02f, 1.81348640e-02f, -1.19498625e-01f, -5.18959202e-02f, 2.98357289e-02f, -7.10708126e-02f, -4.88044620e-02f, -6.62759226e-03f,
  7.80690536e-02f, -3.51620489e-03f, 5.94870299e-02f, 4.74159010e-02f, 7.05786571e-02f, -5.21473102e-02f, -2.89143454e-02f, -7.58537725e-02f, -4.43463847e-02f, 2.28770167e-01f,
  -9.44380090e-02f, -1.65198475e-01f, -3.53746474e-01f, -6.77306056e-02f, 5.55867776e-02f, 1.42616257e-01f, 3.19409549e-01f, 2.40569144e-01f, 7.27218911e-02f, 4.60939407e-02f,
  9.82621610e-02f, 2.32881308e-01f, -6.71484740e-03f, 1.09949894e-01f, 2.14705557e-01f, 5.02628461e-02f, -5.27927317e-02f, 1.07375495e-02f, 1.97485119e-01f, 3.72295350e-01f,
  9.13605765e-02f, 5.63741066e-02f, -5.66404499e-02f, -4.60337102e-03f, -1.50150076e-01f, -4.49812636e-02f, -2.18678415e-01f, -2.74482131e-01f, -1.18435301e-01f, -5.20401359e-01f,
  -4.82723080e-02f, -7.89767653e-02f, 1.92083448e-01f, 1.40211970e-01f, 1.45137146e-01f, 5.19909486e-02f, 1.59847006e-01f, -4.64675985e-02f, 9.79835019e-02f, 9.07263607e-02f,
  2.24566430e-01f, 1.22148909e-01f, 9.48836952e-02f, 7.18782172e-02f, 9.20214504e-02f, 1.80983424e-01f, 1.32634521e-01f, 9.50893387e-02f, 7.53693357e-02f, 1.63194790e-01f,
  1.11886591e-01f, 4.61955182e-02f, 5.23523055e-02f, -7.49075320e-03f, 2.21540928e-02f, 2.34200712e-02f, 6.28545731e-02f, -3.80118005e-02f, 2.64979582e-02f, -8.11740309e-02f,
  -6.04405217e-02f, -7.87053406e-02f, -7.94528611e-03f, -1.10197388e-01f, 1.07898861e-01f, -1.65526435e-01f, -8.65852684e-02f, -1.11756943e-01f, 4.81790863e-02f, 6.38844073e-02f,
  2.70484947e-02f, -4.61489297e-02f, 7.59765878e-02f, -8.18081573e-02f, -4.71285246e-02f, -1.15754418e-01f, -9.91104264e-03f, 4.28539189e-03f, 2.59226020e-02f, 3.13308300e-03f,
  -3.43985409e-02f, 3.20288278e-02f, -3.91060635e-02f, 8.74744058e-02f, -1.34247765e-01f, -1.02832407e-01f, 4.89360914e-02f, -1.03220306e-02f, 2.03721430e-02f, -6.73275739e-02f,
  3.17163497e-01f, 1.68068111e-01f, 1.73149019e-01f, 1.53015956e-01f, 1.16755823e-02f, 2.07657143e-02f, -4.28320020e-02f, 1.56995580e-02f, -2.02862706e-04f, 3.14208344e-02f,
  1.62754431e-01f, 3.99856120e-02f, 3.69090736e-02f, 1.17674738e-01f, 1.32611200e-01f, 6.54702559e-02f, 1.59348115e-01f, 1.03580773e-01f, 1.24198988e-01f, 1.24996223e-01f,
  1.08375281e-01f, 1.90651536e-01f, 1.33938193e-01f, 9.21707079e-02f, -7.05071585e-03f, 1.27483249e-01f, 7.12906271e-02f, -5.40272519e-03f, 1.41940072e-01f, 2.11955115e-01f,
  2.34606341e-01f, -2.46125296e-01f, 2.80307978e-01f, -2.02664584e-02f, -3.03185403e-01f, -5.38003296e-02f, -1.28269717e-01f, 2.30567269e-02f, -8.04092810e-02f, -1.04536481e-01f,
  -3.09454411e-01f, -8.22087824e-02f, -1.12521742e-02f, 7.19116554e-02f, 2.14286521e-01f, 1.33923054e-01f, 2.08000243e-01f, 3.72231185e-01f, 3.26086849e-01f, 3.96562964e-02f,
  -1.81959480e-01f, -7.91812912e-02f, 3.80133055e-02f, 1.27471402e-01f, -2.26529110e-02f, 5.18426485e-02f, 7.96401724e-02f, 3.31683084e-04f, -8.85776728e-02f, 1.01933546e-01f,
  1.49050429e-02f, -4.25758846e-02f, 1.27677128e-01f, 7.32417125e-03f, 1.18004102e-02f, 5.11808917e-02f, 4.18890491e-02f, 8.12264085e-02f, 7.04191923e-02f, 1.75914183e-01f,
  6.33135214e-02f, -3.08030751e-02f, 3.92093882e-02f, 1.54929357e-02f, 2.60742996e-02f, 4.53318544e-02f, 7.19371662e-02f, 1.08836249e-01f, 1.89762667e-01f, 2.83577908e-02f,
  -1.52823314e-01f, -8.81329849e-02f, 1.42010078e-01f, 2.87062414e-02f, 1.56096354e-01f, 8.72309282e-02f, -5.55541217e-02f, 1.35911942e-01f, 1.88067690e-01f, 9.88053605e-02f,
  -3.48940529e-02f, -5.42389527e-02f, -4.49200943e-02f, -6.85004890e-02f, -7.82758817e-02f, -8.03250596e-02f, -2.67962702e-02f, -4.16764095e-02f, -3.50428261e-02f, -8.60451609e-02f,
  -9.85476151e-02f, -4.21400036e-05f, -7.87403584e-02f, -3.12961824e-02f, 3.19251679e-02f, 4.84561324e-02f, -1.86629426e-02f, 4.85911556e-02f, 4.01266962e-02f, -4.53704223e-02f,
  1.38812177e-02f, -2.72348374e-02f, -3.99510451e-02f, -1.19249141e-02f, -3.73018421e-02f, 8.58921111e-02f, 6.67269379e-02f, 5.36393933e-02f, -2.71561276e-02f, 8.38981867e-02f,
  -1.12222515e-01f, 6.69664145e-02f, 2.03482389e-01f, 1.78866297e-01f, 1.17239475e-01f, 1.03983231e-01f, -1.54639278e-02f, 1.00612175e-02f, 4.74354364e-02f, 5.68553843e-02f,
  -1.94083918e-02f, 1.25280574e-01f, -3.68985068e-03f, 8.43686459e-04f, 1.01555120e-02f, 2.65857223e-02f, -6.02982147e-03f, -2.36503016e-02f, 1.89844258e-02f, -8.25301781e-02f,
  -1.52988462e-02f, 6.56302506e-03f, 4.11701528e-03f, 8.10688436e-02f, -2.07580328e-02f, 5.32632023e-02f, 1.57896012e-01f, 1.64413631e-01f, 2.41103724e-01f, 1.58830479e-01f,
  3.29107404e-01f, -2.22295091e-01f, -2.57232636e-02f, 2.00798046e-02f, -3.76187600e-02f, 8.96846652e-02f, -4.81084734e-02f, 4.15805168e-02f, 9.10180584e-02f, -5.95951937e-02f,
  -1.90339997e-01f, 8.19624737e-02f, 6.79393411e-02f, 1.07373670e-01f, 1.19634926e-01f, -4.37142774e-02f, 4.13429588e-02f, 2.92903513e-01f, 3.46861243e-01f, 9.13629755e-02f,
  -1.24249496e-01f, 3.37222815e-02f, 1.90004051e-01f, 2.01547798e-02f, -1.53855667e-01f, 8.47513154e-02f, 1.56608671e-02f, -6.02299124e-02f, -2.71102507e-02f, -9.57369357e-02f,
  5.17520793e-02f, -4.44588112e-03f, 1.06111221e-01f, -1.62918027e-02f, -6.82015568e-02f, 1.14263892e-01f, 9.84691009e-02f, 1.08986184e-01f, 8.62991884e-02f, 1.11753903e-01f,
  8.58389586e-02f, 6.00792505e-02f, 2.77142711e-02f, 6.68321678e-04f, 6.04841905e-03f, 8.02766234e-02f, 5.48167974e-02f, 6.26377016e-03f, 1.52987055e-02f, 9.92674008e-02f,
  2.56462730e-02f, -9.78018343e-02f, -5.10162450e-02f, 6.02405667e-02f, 8.59255418e-02f, 9.89909172e-02f, -4.71110828e-02f, -7.09882826e-02f, 3.23853642e-02f, 9.49110016e-02f,
  7.35850856e-02f, -4.09896709e-02f, -1.18977033e-01f, -1.26544148e-01f, -1.04057960e-01f, -5.46706580e-02f, 8.50779563e-03f, -6.12026118e-02f, -4.56636362e-02f, -3.96256074e-02f,
  -1.01591639e-01f, -1.48844227e-01f, -1.54343350e-02f, -9.83911827e-02f, -1.69924393e-01f, 2.41437759e-02f, 2.50070505e-02f, -9.92008671e-02f, -5.05659804e-02f, -1.31208859e-02f,
  -1.15499701e-02f, 3.34259681e-02f, -9.23802797e-03f, 3.75663154e-02f, -3.80173363e-02f, -4.86441106e-02f, 5.48057929e-02f, -5.63542023e-02f, -5.86867444e-02f, -1.69868562e-02f,
  -6.77136406e-02f, -1.33169964e-01f, 5.90483993e-02f, 6.49353936e-02f, 9.81807485e-02f, 2.87156925e-02f, 6.01415671e-02f, 6.81622252e-02f, 1.36806369e-01f, -9.89405811e-03f,
  1.21959567e-01f, 8.26819837e-02f, 6.59132302e-02f, 7.98268765e-02f, 6.27764612e-02f, 9.05206278e-02f, 3.32032330e-02f, 6.99856132e-02f, 8.44714865e-02f, 7.48592801e-03f,
  6.42878413e-02f, 1.83259740e-01f, 1.49649695e-01f, 8.26218873e-02f, 3.05714328e-02f, 1.10914774e-01f, 1.73360929e-01f, 1.38808042e-01f, 7.68463016e-02f, 5.19444719e-02f
};

// L0_fan_Wp_bar (Shape: 20 x 120)
const int L0_fan_Wp_bar_rows = 20;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  8.11226480e-03f, -4.35145557e-01f, -2.86222190e-01f, 1.40257031e-01f, -9.30367224e-03f, -1.39054030e-01f, -6.42650545e-01f, -1.88106209e-01f, 1.27619371e-01f, -4.32370394e-01f,
  -5.32463863e-02f, 4.38497066e-01f, 1.51340649e-01f, 6.55449703e-02f, -1.46970674e-01f, -6.23996437e-01f, -4.13254797e-01f, 7.52310231e-02f, 2.53495306e-01f, 3.15253884e-02f,
  6.63869753e-02f, 9.94698778e-02f, 3.71032119e-01f, 6.91098869e-02f, 5.68735264e-02f, 2.92572647e-01f, 4.50370368e-03f, 5.67715019e-02f, 4.33287211e-02f, -7.33061060e-02f,
  -1.23018533e-01f, -1.33240134e-01f, 3.81578766e-02f, 1.54349521e-01f, -3.10069975e-02f, -1.76898390e-01f, -2.39630789e-01f, -1.92664396e-02f, 2.92102564e-02f, -7.08279461e-02f,
  1.29858658e-01f, 9.63191316e-02f, 1.55246526e-01f, 2.24404469e-01f, -5.84628433e-02f, -3.30488384e-02f, 5.17248139e-02f, -8.09620246e-02f, -3.28252912e-02f, -2.29248732e-01f,
  4.76984903e-02f, 1.60721857e-02f, -9.89277810e-02f, -1.78737283e-01f, 6.47645369e-02f, 1.51362300e-01f, 9.93909538e-02f, 9.25463587e-02f, 1.37253955e-01f, -2.33376697e-01f,
  -2.00728420e-03f, -1.68012176e-02f, 1.10594042e-01f, -1.00383244e-01f, -8.70526582e-02f, -3.46700549e-02f, 4.12340127e-02f, -9.66313481e-02f, 2.28177011e-02f, -6.38663247e-02f,
  -3.23469043e-02f, -1.28319949e-01f, -7.51653686e-02f, -7.06234723e-02f, 3.72287538e-03f, 3.30510139e-02f, -3.61069827e-03f, -4.25627269e-02f, 3.04892436e-02f, 4.42856066e-02f,
  1.74017884e-02f, 7.29883136e-03f, -7.34114796e-02f, 4.67047095e-02f, 1.84919946e-02f, -2.48085968e-02f, 1.03236541e-01f, 6.70763329e-02f, 8.41650218e-02f, -4.06709686e-02f,
  1.27463415e-01f, 2.07012713e-01f, -2.31246307e-01f, 9.67721548e-03f, 1.11461934e-02f, 6.93987533e-02f, -9.06028897e-02f, -3.40687297e-02f, 4.54833917e-02f, 2.24229395e-02f,
  2.05205187e-01f, -1.30691715e-02f, -2.91092880e-02f, 2.24804957e-04f, 3.48763801e-02f, 4.25292477e-02f, -1.29099503e-01f, 1.27983587e-02f, -2.52129864e-02f, 2.25375667e-02f,
  -4.82859695e-03f, -1.33728668e-01f, -1.36828959e-01f, -1.04045287e-01f, 3.49898450e-02f, -4.56385575e-02f, -3.09368391e-02f, -2.62748506e-02f, -8.91763717e-02f, -3.81459922e-01f,
  -4.76423562e-01f, 1.44361973e-01f, -1.81287572e-01f, -4.43692237e-01f, -3.72277141e-01f, -1.72928214e-01f, 5.80330826e-02f, -1.86488599e-01f, -2.43473649e-01f, -8.32405686e-02f,
  2.62105558e-02f, 5.30524999e-02f, 1.07273422e-01f, 4.32326160e-02f, 2.31899902e-01f, 7.22894520e-02f, -8.44160244e-02f, -2.13519186e-02f, 9.07196328e-02f, 6.67012110e-02f,
  -4.57858294e-02f, -8.98156166e-02f, -2.26763219e-01f, -8.29685703e-02f, -4.66013737e-02f, -1.20857790e-01f, -1.60930932e-01f, -1.66042432e-01f, 3.14802863e-02f, -1.98469847e-01f,
  4.92706627e-01f, -8.71969834e-02f, 6.09667897e-02f, 8.65781233e-02f, 1.14205465e-01f, 7.40899667e-02f, 6.43917844e-02f, 7.43998736e-02f, 6.73801005e-02f, 1.61731675e-01f,
  1.80548113e-02f, -3.08303162e-02f, -8.60788375e-02f, -8.74054991e-03f, 1.88343786e-02f, 1.05889380e-01f, 1.00315310e-01f, 2.55485214e-02f, 1.25165969e-01f, 1.68972269e-01f,
  6.13786019e-02f, 1.55552151e-02f, -1.26951694e-01f, -5.25435582e-02f, -2.04228964e-02f, 3.83055098e-02f, 8.95457193e-02f, 2.55043246e-02f, 3.21649276e-02f, -7.40607381e-02f,
  -5.45062572e-02f, -1.60895869e-01f, -8.55019018e-02f, -1.19277075e-01f, -1.55635744e-01f, 3.07343174e-02f, 5.67391776e-02f, 3.05969436e-02f, -6.43713102e-02f, -2.05937009e-02f,
  -3.04511003e-02f, 2.83113923e-02f, -7.73427486e-02f, -2.72085555e-02f, 1.60278324e-02f, -9.87191200e-02f, -2.03991570e-02f, 1.29917394e-02f, -7.05908388e-02f, -1.15454905e-01f,
  -8.99780616e-02f, 2.00387253e-03f, -1.97726283e-02f, 9.37993228e-02f, 1.10890143e-01f, -1.28675485e-02f, -4.83237356e-02f, 7.89645016e-02f, -8.75748172e-02f, -8.26031044e-02f,
  1.42643347e-01f, -2.01964378e-01f, -9.32455808e-02f, 3.15036848e-02f, -2.45338352e-03f, 1.11973435e-01f, -2.85745300e-02f, 2.56695691e-02f, 1.37916699e-01f, 8.15445259e-02f,
  8.29805061e-02f, 3.07661146e-02f, -7.86986873e-02f, 7.86068570e-03f, -2.26797275e-02f, 1.79089785e-01f, 6.48850873e-02f, -3.33897509e-02f, 1.03067666e-01f, 1.82026759e-01f,
  7.65111716e-03f, -1.43976798e-02f, -5.33909872e-02f, -2.77220225e-03f, -9.36360732e-02f, 1.62304174e-02f, 1.95341647e-01f, 1.35355711e-01f, -4.75963131e-02f, 1.27857462e-01f,
  -7.91775584e-01f, -3.01458202e-02f, -6.44635707e-02f, -1.42804012e-01f, 1.84180260e-01f, 1.50481299e-01f, 3.82604510e-01f, 1.31184831e-01f, -7.11370409e-02f, 6.34002239e-02f,
  -2.56468225e-02f, -2.60766029e-01f, -7.27377385e-02f, 1.04671717e-01f, 1.61943704e-01f, 3.91570747e-01f, 3.12847614e-01f, 7.32457498e-03f, -2.36490611e-02f, 4.04698029e-02f,
  9.95333567e-02f, -3.05916462e-02f, -2.87523389e-01f, -1.71822220e-01f, 8.30042437e-02f, -1.75023928e-01f, 1.24429045e-02f, -1.13804422e-01f, 2.68550720e-02f, 2.09362611e-01f,
  -2.78429389e-02f, -2.16584831e-01f, 1.00513205e-01f, -2.06426769e-01f, -6.72660694e-02f, -1.85404778e-01f, -1.09580807e-01f, -6.80505410e-02f, -5.10615073e-02f, -1.26535386e-01f,
  8.67354590e-03f, 9.82385278e-02f, 1.17772825e-01f, -1.43814646e-02f, -1.26390800e-01f, -1.53860264e-02f, -5.31113297e-02f, -6.09166361e-02f, -5.16619310e-02f, 2.00809781e-02f,
  1.73473924e-01f, 4.00706083e-02f, -6.21140376e-02f, 5.54908216e-02f, 9.62376520e-02f, -2.49490738e-02f, 7.49042556e-02f, 5.94066419e-02f, -8.87808129e-02f, -1.28872991e-01f,
  2.17553433e-02f, 1.16904274e-01f, 3.80304046e-02f, -5.18597588e-02f, 8.11372846e-02f, 1.64451748e-02f, 1.09316804e-01f, 1.60749070e-02f, 2.70592347e-02f, -2.19923481e-02f,
  -6.57268316e-02f, 9.09220129e-02f, -1.31213097e-02f, -1.37113824e-01f, -1.65510923e-01f, -3.21060866e-02f, -8.15354940e-03f, -6.26026168e-02f, -9.87753645e-02f, 5.91732115e-02f,
  1.33770347e-01f, -5.28707020e-02f, -1.34023666e-01f, 9.51636583e-02f, -5.26841134e-02f, -8.87307525e-02f, -9.02442858e-02f, -1.25562355e-01f, -8.16129148e-02f, -5.30606359e-02f,
  -5.60809411e-02f, 1.70731112e-01f, -5.65158315e-02f, -2.70408764e-02f, 3.34820873e-03f, -2.12648317e-01f, -8.74655843e-02f, -7.73678720e-02f, 1.34996489e-01f, -3.74005139e-02f,
  -4.81924638e-02f, -9.99895390e-03f, -5.25819603e-03f, -7.81493112e-02f, -1.98694356e-02f, -2.59796903e-02f, -7.17118103e-03f, 1.24462396e-01f, 5.20384945e-02f, -5.07831164e-02f,
  2.01628860e-02f, -2.75506638e-02f, -4.35715169e-02f, 1.53186157e-01f, -2.29534209e-02f, -4.17721383e-02f, -1.59796770e-03f, 2.34682690e-02f, 1.39347389e-01f, 4.29936051e-02f,
  -3.91624212e-01f, -2.87084758e-01f, 2.11437881e-01f, 8.37721452e-02f, 2.94183403e-01f, 2.07160823e-02f, -4.51203823e-01f, -2.70524830e-01f, -1.10121794e-01f, -1.42925128e-01f,
  3.42387296e-02f, 1.05075702e-01f, 1.50418177e-01f, -2.45651826e-02f, -5.49284577e-01f, -2.92278290e-01f, -2.10637629e-01f, -1.10347107e-01f, -1.84312478e-01f, -9.79009792e-02f,
  -3.58780958e-02f, -4.67185825e-02f, -2.53445238e-01f, -1.73891410e-01f, 9.87137705e-02f, -2.06926302e-03f, 8.98327772e-03f, -2.23345235e-02f, 1.28040742e-02f, 8.97256061e-02f,
  2.07217112e-01f, 5.43175079e-02f, 3.25309873e-01f, 4.53092717e-02f, 1.74425930e-01f, 5.60493991e-02f, 1.04211988e-02f, 4.59480807e-02f, 5.02859764e-02f, -2.81256717e-02f,
  1.06802620e-02f, 2.09300090e-02f, 1.58955202e-01f, 7.96952471e-02f, 2.31085569e-02f, -7.44558126e-02f, 1.01171220e-02f, -4.41732956e-03f, -5.33890026e-03f, 5.62480316e-02f,
  1.65079325e-01f, -4.91723716e-02f, -1.30383492e-01f, -1.12863965e-01f, -1.18377261e-01f, 7.23431557e-02f, -1.17177047e-01f, -1.03773296e-01f, -2.04627499e-01f, -2.09431723e-01f,
  -2.28823591e-02f, 7.46549070e-02f, 1.58317417e-01f, -1.87989958e-02f, -8.11684951e-02f, 9.90745127e-02f, 1.41447494e-02f, 1.50473472e-02f, 1.67651866e-02f, -7.64127523e-02f,
  -1.21335853e-02f, 5.46791665e-02f, -6.15348555e-02f, -1.29844874e-01f, -9.36781988e-03f, -5.74437901e-03f, -8.55287686e-02f, -1.77237436e-01f, -9.95204970e-02f, 1.03671417e-01f,
  -5.58367036e-02f, 8.18048269e-02f, 6.33203983e-02f, 2.82274708e-02f, -2.23768670e-02f, -1.38735339e-01f, 3.58890370e-02f, -1.59171805e-01f, -1.26156453e-02f, -7.87689462e-02f,
  -1.84135705e-01f, -9.94918775e-03f, 1.18586896e-02f, -1.72033712e-01f, 1.60145964e-02f, 9.68955737e-03f, 5.57298064e-02f, 2.96598151e-02f, 1.21961214e-01f, -8.08218047e-02f,
  -8.77467822e-03f, -1.22735657e-01f, -2.01983415e-02f, 1.11742191e-01f, 3.13777141e-02f, 3.84262693e-03f, -1.37942314e-01f, -9.73651260e-02f, -3.28802154e-03f, 9.89518017e-02f,
  -8.90689567e-02f, -3.70037556e-01f, -1.77591413e-01f, -1.77603051e-01f, -6.63717538e-02f, -2.34868139e-01f, -1.49186611e-01f, -9.95780304e-02f, -3.20935637e-01f, -4.69973177e-01f,
  1.38670921e-01f, 5.72482049e-02f, 2.67267764e-01f, 1.01835623e-01f, -1.48272574e-01f, -5.20710170e-01f, -5.13919592e-01f, -2.37387538e-01f, -7.11914198e-03f, -3.51362973e-02f,
  -1.08534433e-01f, 7.52030984e-02f, 1.63810864e-01f, 2.61254925e-02f, -2.64793426e-01f, -2.20051091e-02f, 2.70842284e-01f, 8.67605358e-02f, -1.74467698e-01f, -1.84823468e-01f,
  -1.00329660e-01f, -3.47993821e-02f, 1.32807177e-02f, -5.71361072e-02f, 1.64691299e-01f, -6.59149140e-02f, 1.39945313e-01f, 1.64433807e-01f, 5.37109673e-02f, 4.99489844e-01f,
  3.29275221e-01f, 8.29701573e-02f, -1.48600191e-01f, 3.45627032e-02f, 1.76436886e-01f, 1.46292493e-01f, -1.19737443e-02f, 2.06754908e-01f, 9.12432149e-02f, 7.23401979e-02f,
  8.92974585e-02f, 5.77076636e-02f, 9.02388915e-02f, 9.25687701e-03f, -4.11083065e-02f, -1.50211230e-02f, 4.74936999e-02f, 1.00485221e-01f, -1.73618533e-02f, 2.51990408e-02f,
  2.19338872e-02f, 1.55041469e-02f, -1.32023573e-01f, -1.70308739e-01f, 3.83630842e-02f, 9.67705920e-02f, -1.94391340e-01f, -3.34294960e-02f, -1.45207629e-01f, 1.64111212e-01f,
  -8.55913386e-02f, 1.09643862e-02f, 3.28458403e-03f, 6.20972998e-02f, -6.17878363e-02f, -5.95869496e-03f, 4.52678185e-03f, -5.85249737e-02f, -2.12175138e-02f, 5.73275015e-02f,
  7.00547770e-02f, -1.84371434e-02f, 1.90517865e-02f, 6.70348331e-02f, -9.78461504e-02f, 5.63910529e-02f, 5.02673499e-02f, -1.14311978e-01f, -2.10954919e-02f, -2.18608696e-02f,
  3.28574441e-02f, -1.23375207e-02f, 5.61538488e-02f, -2.58027744e-02f, 2.02992409e-02f, 1.78421065e-02f, 1.34634405e-01f, 2.75542364e-02f, 3.08130551e-02f, 1.38868198e-01f,
  -4.51785028e-02f, -3.26956749e-01f, 1.92742035e-01f, 2.34063640e-02f, 3.74389701e-02f, 1.07171079e-02f, 1.89910576e-01f, 2.27816291e-02f, 9.65247005e-02f, -4.28287834e-02f,
  -1.39323607e-01f, -8.19553733e-02f, -8.13749582e-02f, 4.59836200e-02f, -1.75791383e-01f, 3.24390344e-02f, -3.08757257e-02f, -4.82907332e-03f, -1.09631717e-01f, 1.21545054e-01f,
  8.42922032e-02f, -3.98158252e-01f, -3.95081043e-01f, -9.67738107e-02f, -1.09741636e-01f, -2.83226013e-01f, -2.33217552e-01f, -1.08848803e-01f, -3.77307326e-01f, -3.62271219e-01f,
  -2.92052805e-01f, -2.83218741e-01f, -2.69904733e-01f, -7.83740431e-02f, -2.47637957e-01f, 9.84434783e-02f, -2.18600094e-01f, 2.58774161e-01f, 1.60597309e-01f, -2.71087348e-01f,
  -1.96547359e-01f, 1.72349915e-01f, -1.22389555e-01f, 1.34125948e-01f, 7.64034614e-02f, -3.31271440e-01f, -2.00449824e-01f, 8.94578733e-03f, 3.32776636e-01f, 1.70002431e-01f,
  1.37764066e-01f, -6.78098807e-03f, 3.88001762e-02f, 1.47683686e-03f, -3.27144772e-01f, -2.36589268e-01f, -4.25392509e-01f, -1.44916788e-01f, -2.88450181e-01f, -5.97755253e-01f,
  -3.85357231e-01f, 2.46689226e-02f, 2.03476638e-01f, -2.95063499e-02f, -2.35985443e-02f, 1.43336684e-01f, 1.10468723e-01f, -5.86734014e-03f, 1.52253043e-02f, -1.98257752e-02f,
  -3.24543826e-02f, 1.00810885e-01f, 4.66621071e-02f, 1.66034326e-02f, 7.16792122e-02f, 6.52157441e-02f, -7.02209622e-02f, 1.66044369e-01f, -4.36303467e-02f, 1.38179004e-01f,
  5.42404409e-03f, -3.62010263e-02f, -1.01863846e-01f, 1.90200299e-01f, 5.80372363e-02f, 1.40020654e-01f, -3.37137282e-02f, 2.19683927e-02f, 6.05179407e-02f, -3.48562241e-01f,
  1.71219241e-02f, -9.78488699e-02f, -1.76822338e-02f, 1.26108378e-01f, 2.49031968e-02f, -1.22143328e-01f, 4.30805273e-02f, -7.54324570e-02f, 2.03117244e-02f, 1.52449142e-02f,
  1.36721358e-01f, 3.84083986e-02f, 5.21086268e-02f, -3.13072987e-02f, -1.36638254e-01f, -6.50437027e-02f, -1.43324837e-01f, -2.12277666e-01f, -3.73042561e-02f, -5.71587458e-02f,
  -7.23945871e-02f, -8.06915015e-02f, -6.87215477e-02f, 4.04553637e-02f, 9.90121067e-02f, -5.87902516e-02f, -4.85854112e-02f, 1.30117923e-01f, 1.08258255e-01f, 4.58548367e-02f,
  -8.75145718e-02f, 2.09465802e-01f, -1.98259607e-01f, 6.96611255e-02f, -1.84547856e-01f, -8.04638490e-02f, -1.14529416e-01f, 5.81534207e-02f, -5.64890467e-02f, -1.16605394e-01f,
  -1.22121044e-01f, -1.18829824e-01f, -1.06932878e-01f, -2.33263336e-02f, 1.08165272e-01f, -8.12561512e-02f, -1.32641494e-01f, -1.20852925e-01f, -5.18218148e-03f, 3.54337916e-02f,
  -6.40826672e-02f, -4.79769334e-02f, -7.34471381e-02f, -1.85453370e-02f, 6.36031702e-02f, -2.37623462e-03f, -2.09949106e-01f, -1.34456322e-01f, -8.20775628e-02f, -2.03863934e-01f,
  -4.58857834e-01f, 2.86614932e-02f, -2.40590900e-01f, -9.31863114e-03f, 3.25913668e-01f, -2.34452374e-02f, -2.07805976e-01f, -4.25034106e-01f, -9.27595124e-02f, -5.75253600e-03f,
  2.56621480e-01f, 1.96904764e-01f, 1.73912793e-01f, 9.76434797e-02f, -1.72063649e-01f, 3.26171927e-02f, 8.94797891e-02f, -1.80032164e-01f, -2.18085378e-01f, -6.81424141e-03f,
  2.94991255e-01f, -2.49986090e-02f, -1.95235088e-01f, 4.03156364e-03f, 2.19112828e-01f, 1.64109960e-01f, 1.45782843e-01f, 1.68658003e-01f, 1.57565206e-01f, 3.75530601e-01f,
  1.73126996e-01f, -1.07159130e-01f, 1.46404952e-01f, 3.09964657e-01f, 1.06499143e-01f, -9.88544673e-02f, -1.70014694e-01f, -1.08167760e-01f, -1.58022970e-01f, -3.66030335e-02f,
  2.59600312e-01f, -1.63762122e-02f, 1.49182044e-02f, 1.53110512e-02f, -2.43406251e-01f, 1.04896678e-02f, -7.45851249e-02f, -2.06215069e-01f, -3.54947120e-01f, -2.54754722e-01f,
  2.32053280e-01f, 1.89017713e-01f, -1.82703450e-01f, -8.71312618e-02f, -2.16358036e-01f, 6.41487539e-02f, -1.10268518e-01f, 1.00106217e-01f, -1.82433426e-01f, -1.03535682e-01f,
  1.34623572e-01f, 1.43109746e-02f, -8.06214884e-02f, 7.90482014e-02f, -2.57984977e-02f, 7.49638081e-02f, 1.33858383e-01f, 8.07095692e-02f, 3.84832472e-02f, -1.08575985e-01f,
  -2.33415682e-02f, 4.44274582e-02f, -7.50106871e-02f, -1.48970872e-01f, 5.54813892e-02f, 3.84656824e-02f, 2.84865610e-02f, 1.95399672e-03f, 1.28694832e-01f, -8.31547901e-02f,
  2.11916659e-02f, -1.22059300e-03f, -3.48231792e-02f, -5.38524576e-02f, 1.37123227e-01f, 8.85786489e-02f, -3.48323062e-02f, 2.44064070e-02f, -1.72445849e-02f, 6.35240600e-02f,
  -1.34307027e-01f, 1.81452870e-01f, 1.76517203e-01f, 1.10877380e-02f, -4.13239188e-03f, 3.02369166e-02f, 1.28639728e-01f, 8.37142169e-02f, -5.13096862e-02f, -1.70292392e-01f,
  -4.59953174e-02f, -1.01032164e-02f, 3.34656201e-02f, 8.53483379e-02f, -2.09942997e-01f, -5.94048016e-02f, 6.83806241e-02f, 1.05665676e-01f, -7.90061504e-02f, 5.12969755e-02f,
  -1.79841280e-01f, -7.13431835e-02f, -7.30125681e-02f, -5.89610599e-02f, 1.17574215e-01f, 9.18173119e-02f, -7.81073719e-02f, 8.87024254e-02f, -1.78599611e-01f, -1.07025020e-01f,
  3.34292352e-01f, -5.91467619e-01f, 4.19547498e-01f, 8.40216875e-02f, -3.88690054e-01f, -3.20026755e-01f, -3.43220830e-01f, -5.86526294e-04f, 4.89546135e-02f, -6.51300773e-02f,
  -1.30019084e-01f, 7.30540752e-02f, 2.98746645e-01f, 2.84232825e-01f, 3.57728034e-01f, -4.05813381e-02f, 1.98730350e-01f, 5.63165963e-01f, 4.72159624e-01f, 1.37213087e-02f,
  -1.40555725e-01f, 9.56479311e-02f, 3.04357380e-01f, 1.57694712e-01f, -1.50601357e-01f, 1.11586340e-01f, 5.12909442e-02f, -2.07140326e-01f, -1.01925224e-01f, 2.05625594e-01f,
  6.42992482e-02f, -1.06663495e-01f, 2.62156010e-01f, -1.65803619e-02f, -1.25883743e-01f, -3.50389257e-02f, -4.99499999e-02f, -6.41265884e-02f, -5.42068630e-02f, -6.92600459e-02f,
  -1.53121054e-01f, -4.01139893e-02f, 1.71404202e-02f, -2.89752912e-02f, -2.20916182e-01f, -2.88214479e-02f, 5.77253252e-02f, 2.10894614e-01f, 2.98882484e-01f, 2.23686509e-02f,
  -1.78899214e-01f, -1.36708394e-01f, -1.38352528e-01f, -1.43396273e-01f, 1.21451467e-01f, 9.11508501e-02f, -1.25757724e-01f, 5.98071441e-02f, 4.09828313e-02f, -1.63467862e-02f,
  5.09262867e-02f, 8.40170681e-02f, 1.88934971e-02f, 2.66219713e-02f, 2.15442721e-02f, 4.97570261e-02f, 7.16810226e-02f, -4.01996672e-02f, 6.41742498e-02f, -7.55529255e-02f,
  1.19749624e-02f, 5.29903658e-02f, -3.06181516e-03f, 2.87070107e-02f, 1.65956467e-01f, 5.52960075e-02f, -3.50792743e-02f, -1.76317070e-03f, 7.66899586e-02f, -1.16155691e-01f,
  3.20251174e-02f, -3.31847966e-02f, -3.55936177e-02f, 4.82600443e-02f, -2.30508950e-02f, 1.00549206e-01f, 2.04667021e-02f, -6.92260414e-02f, -1.00135103e-01f, -5.47863543e-02f,
  -4.16967809e-01f, 1.70620054e-01f, 3.03653449e-01f, 8.67298096e-02f, -9.15043056e-02f, -7.01834029e-03f, 1.45526947e-02f, 4.70386334e-02f, 5.04263863e-03f, 1.39726670e-02f,
  -6.00532219e-02f, 1.19732715e-01f, -8.61027762e-02f, 1.92542914e-02f, -9.44912285e-02f, -1.75261825e-01f, -8.21381882e-02f, 5.03194779e-02f, 2.14634109e-02f, -9.69328508e-02f,
  -6.07649945e-02f, -9.84276161e-02f, -2.37855613e-01f, -1.31373703e-01f, -1.29280493e-01f, -5.43368235e-02f, -7.61166289e-02f, -1.51311234e-01f, -1.48837432e-01f, -1.75669014e-01f,
  -2.87985504e-01f, -2.55600423e-01f, -2.23093644e-01f, 7.67742619e-02f, 1.16333477e-01f, 1.66305646e-01f, 1.84619188e-01f, 3.39441076e-02f, 3.47430706e-02f, 1.12642691e-01f,
  -8.63083676e-02f, -9.54874530e-02f, 5.29665546e-03f, 1.87327117e-02f, 9.88066271e-02f, 1.23140864e-01f, 3.02364737e-01f, 5.58899492e-02f, 1.61035761e-01f, 1.07838966e-01f,
  1.88457742e-01f, 4.41132393e-03f, -1.31714329e-01f, 4.49826121e-02f, 8.11967701e-02f, 5.42518012e-02f, -7.68396333e-02f, -1.33714601e-01f, 4.61695306e-02f, -1.05046453e-02f,
  -3.37102830e-01f, -2.64465660e-01f, 1.86751127e-01f, 1.95537388e-01f, -1.71453521e-01f, 2.76824646e-02f, -1.18147559e-01f, -2.59615898e-01f, -3.10572907e-02f, -2.15803366e-02f,
  7.27429837e-02f, -1.47218451e-01f, 5.54253757e-02f, 2.62552828e-01f, -7.47592971e-02f, -1.08553357e-02f, -3.86876836e-02f, -7.06151426e-02f, -8.17149654e-02f, 9.56032891e-03f,
  2.12095633e-01f, -3.96259367e-01f, -3.59874487e-01f, 7.23481327e-02f, -4.20956463e-02f, -1.55108377e-01f, -7.73563460e-02f, -2.78776065e-02f, -3.22930098e-01f, -4.00939375e-01f,
  -1.42279938e-01f, -2.52051223e-02f, 3.93888764e-02f, 2.26442665e-02f, 1.52438685e-01f, 5.59695298e-03f, 5.54763749e-02f, 1.08108029e-01f, 1.04183532e-01f, 5.89185841e-02f,
  -3.94415110e-03f, -4.61704656e-02f, 3.34545523e-02f, -1.00717753e-01f, 3.13069150e-02f, 1.60744172e-02f, 1.68115832e-02f, 9.97970179e-02f, -3.66634317e-02f, 1.90876033e-02f,
  -5.89653440e-02f, -2.54129283e-02f, -2.10408747e-01f, 5.49369939e-02f, 7.88838342e-02f, 2.97036357e-02f, 1.45141795e-01f, 6.23140372e-02f, -1.55885946e-02f, -2.16856837e-01f,
  -3.37805957e-01f, -1.54325634e-01f, -2.87031475e-02f, 8.12287256e-02f, -1.13748431e-01f, -1.35239646e-01f, -5.22280820e-02f, -1.93069503e-02f, 4.82981876e-02f, -9.83294994e-02f,
  6.55084699e-02f, -4.20520231e-02f, -7.64128938e-02f, 3.74028720e-02f, 9.40585807e-02f, 4.08700444e-02f, -8.01936537e-02f, 1.11195639e-01f, -7.21513554e-02f, -2.93870896e-01f,
  1.38469636e-01f, -5.89080378e-02f, -1.26198173e-01f, -5.11801168e-02f, -2.21893772e-01f, -3.05173956e-02f, -2.60356098e-01f, -6.65226951e-02f, -2.20097378e-01f, -3.28879595e-01f,
  -7.62192130e-01f, 3.16769511e-01f, 1.04429787e-02f, -2.37083271e-01f, 1.62869200e-01f, 2.86351115e-01f, 4.60764170e-01f, 9.56258178e-03f, -3.16897869e-01f, 4.88635637e-02f,
  1.51356399e-01f, -1.37816563e-01f, -2.54160762e-02f, 4.75726761e-02f, 7.96603635e-02f, 2.51538932e-01f, 2.13117495e-01f, -1.33197799e-01f, -1.99766278e-01f, -5.82719669e-02f,
  8.72088969e-02f, -2.44698167e-01f, -3.04643154e-01f, -2.59008467e-01f, -1.08014576e-01f, -3.68198782e-01f, 5.30219786e-02f, -2.82154512e-02f, 1.54876962e-01f, 3.35249268e-02f,
  1.46088123e-01f, 1.22004777e-01f, 1.67439375e-02f, -9.87887457e-02f, -6.99926913e-02f, -3.81320193e-02f, 1.21496629e-03f, 2.32413970e-03f, 3.34008187e-02f, -5.80651276e-02f,
  7.71550345e-04f, 4.64648940e-02f, 7.93223009e-02f, 4.07595970e-02f, 4.12775017e-02f, -2.55108699e-02f, -6.42596558e-03f, 5.53731173e-02f, 8.59359652e-02f, -1.04979891e-02f,
  1.93921924e-01f, 1.36005387e-01f, 2.37869397e-01f, 5.96460998e-02f, 8.76097381e-02f, -3.80454515e-03f, 1.00320950e-01f, -9.12679434e-02f, 2.37458218e-02f, -3.06788206e-01f,
  9.60173756e-02f, -8.49974975e-02f, 1.83004942e-02f, 2.28934572e-03f, -7.05089495e-02f, 2.11345078e-03f, -1.51762133e-02f, -1.41378874e-02f, 1.13237079e-03f, -8.85739829e-03f,
  7.15035722e-02f, 4.59647775e-02f, 1.78375430e-02f, -2.13294756e-03f, -6.13400787e-02f, 2.60965200e-03f, 3.19393165e-02f, -9.57000777e-02f, 6.27889633e-02f, 5.12596481e-02f,
  -5.81396334e-02f, 5.30848056e-02f, 2.58636638e-03f, -7.90805295e-02f, 7.09252656e-02f, 3.50811332e-02f, 1.15681171e-01f, 4.00494710e-02f, -1.84715483e-02f, 1.44639105e-01f,
  -2.74116307e-01f, 3.65790248e-01f, -1.34482652e-01f, -1.25586450e-01f, 9.75157022e-02f, -4.81447577e-02f, 9.35802516e-03f, 5.00683151e-02f, 4.38640602e-02f, -2.18617842e-02f,
  1.51239999e-03f, -1.16527174e-02f, -6.68799412e-03f, -4.08555660e-03f, -1.35397017e-01f, -6.63803592e-02f, -9.78297517e-02f, -1.34791166e-01f, 1.34248108e-01f, -5.40418252e-02f,
  2.85823811e-02f, -1.24969997e-01f, -1.74159899e-01f, -8.28453749e-02f, -3.39430687e-03f, -1.21579520e-01f, -8.78219157e-02f, -9.93753970e-02f, 7.91908875e-02f, -3.14544857e-01f,
  2.24909231e-01f, 5.47537744e-01f, -1.79641977e-01f, 3.01866960e-02f, 2.94710308e-01f, 4.01587747e-02f, 4.61594425e-02f, -2.10095003e-01f, -1.20089732e-01f, 9.71838906e-02f,
  1.48486137e-01f, 1.30811170e-01f, 1.85422301e-02f, -2.89669093e-02f, 1.08165108e-02f, -1.38580306e-02f, -5.68822660e-02f, -4.32701223e-02f, -1.86941862e-01f, -3.05177830e-02f,
  8.80941004e-02f, 1.00067213e-01f, -1.39116138e-01f, -1.11959562e-01f, 1.49895936e-01f, -7.75078535e-02f, 9.70792864e-03f, 1.78272620e-01f, 4.01076935e-02f, 1.44761533e-01f,
  1.33594722e-01f, 1.97641090e-01f, -2.80557752e-01f, 1.38579711e-01f, 1.28957942e-01f, -1.43969029e-01f, -3.42232212e-02f, 6.26022089e-03f, 9.81445089e-02f, -6.48621768e-02f,
  2.07042798e-01f, 1.90467909e-01f, 1.72447279e-01f, -2.37963330e-02f, -3.09567396e-02f, -1.18832037e-01f, -1.20236911e-01f, -5.74735589e-02f, -2.47970790e-01f, -1.73431724e-01f,
  1.69924274e-02f, 1.90023929e-01f, 8.50602686e-02f, -1.58704907e-01f, -1.64737076e-01f, -1.20388614e-02f, 6.00955710e-02f, 1.13833696e-02f, -1.02412604e-01f, 1.33268964e-02f,
  -1.94740236e-01f, 4.05350737e-02f, 7.42271766e-02f, 3.11096776e-02f, 1.24290206e-01f, 8.33211653e-03f, -1.31358178e-02f, 1.27897397e-01f, -9.88934189e-03f, -4.24561538e-02f,
  -7.25237057e-02f, -1.28014967e-01f, -1.08158104e-01f, -3.65617052e-02f, 1.94869116e-02f, 1.71783388e-01f, -8.51353630e-02f, -1.31247640e-01f, -5.82433455e-02f, 3.70026031e-03f,
  9.90646780e-02f, -1.29235655e-01f, -1.07864002e-02f, -5.16759753e-02f, 2.63706893e-02f, -9.33553129e-02f, -5.76078556e-02f, 2.40679830e-02f, 1.23246405e-02f, -4.38822694e-02f,
  -1.77312270e-01f, -6.09783630e-04f, -9.50689465e-02f, 4.34205085e-02f, 1.37948945e-01f, 6.94074482e-02f, -1.24603003e-01f, -7.12596104e-02f, 5.75607307e-02f, -2.03363195e-01f,
  1.75436705e-01f, -5.13610477e-03f, 1.89308703e-01f, -1.59526303e-01f, -8.15219432e-02f, -1.08662739e-01f, -2.83545647e-02f, -2.54773200e-01f, -4.30226885e-02f, 4.74026203e-02f,
  -2.57303044e-02f, -1.01720378e-01f, -2.05080524e-01f, -2.23993137e-01f, -1.09875128e-01f, -1.47753760e-01f, 1.29608914e-01f, -4.50213626e-02f, -1.10281728e-01f, -1.81228727e-01f,
  -6.23220026e-01f, 4.30942476e-02f, -3.68207902e-01f, -4.75919753e-01f, -4.73706037e-01f, -2.26825088e-01f, 1.06567673e-01f, -7.59381503e-02f, -3.73180389e-01f, -1.09529644e-01f,
  6.18049465e-02f, 1.12030514e-01f, 8.69156942e-02f, 1.30460218e-01f, 2.09795207e-01f, -8.33399370e-02f, -3.77336711e-01f, -1.75893143e-01f, -9.62578878e-03f, 1.43111408e-01f,
  -9.46036205e-02f, -1.69339016e-01f, -1.48685768e-01f, -6.10463992e-02f, 1.30624957e-02f, 1.33002982e-01f, -4.65253145e-02f, -8.61163810e-02f, 1.19664781e-01f, -1.39810264e-01f,
  1.92194700e-01f, -2.66277850e-01f, -6.21322915e-02f, -6.70934021e-02f, -9.33434889e-02f, -1.32252276e-01f, 6.38610795e-02f, -1.20156087e-01f, -1.29422233e-01f, -1.18756779e-01f,
  -1.99583203e-01f, -6.21469431e-02f, 4.12800051e-02f, 5.36190793e-02f, -5.10479286e-02f, -7.72484764e-02f, -1.76516846e-01f, 1.05553772e-02f, 7.09462389e-02f, 1.81721017e-01f,
  1.31303966e-01f, -1.25868812e-01f, 5.17423376e-02f, 1.52068257e-01f, 1.86298624e-01f, -1.12018049e-01f, 1.00931428e-01f, 5.37835732e-02f, 1.10052533e-01f, 2.86216978e-02f,
  8.59219804e-02f, 8.01731125e-02f, 1.30294695e-01f, -3.55064665e-04f, 4.39151824e-02f, -4.35702093e-02f, -5.72051927e-02f, -1.33860216e-01f, 1.19674884e-01f, 2.64312774e-02f,
  -3.96105684e-02f, -3.76187265e-02f, -1.56190721e-02f, 2.44725067e-02f, 1.58162743e-01f, -1.23472154e-01f, 2.07970534e-02f, 1.28525928e-01f, 1.08968124e-01f, 1.07173333e-02f,
  -7.46834576e-02f, 2.19295695e-02f, -6.18284754e-02f, 2.48208925e-01f, -2.67837234e-02f, -1.15042202e-01f, -6.94966018e-02f, -6.16102293e-02f, -7.89273977e-02f, -2.58265615e-01f,
  1.69532433e-01f, 5.34282513e-02f, -7.13835955e-02f, 8.42991322e-02f, -1.19371146e-01f, -1.07976250e-01f, 6.67481171e-03f, -3.03496118e-03f, -1.85392737e-01f, 4.13144603e-02f,
  -4.28935401e-02f, 3.58333588e-02f, 9.05399546e-02f, 6.69747517e-02f, -1.35064512e-01f, -7.45355114e-02f, -1.06362909e-01f, -6.70645759e-02f, 1.06929541e-01f, -2.89255660e-02f,
  -4.09944616e-02f, -5.02074212e-02f, 1.37264431e-01f, 2.59846210e-01f, 9.08756405e-02f, 1.78502034e-02f, 1.28261819e-01f, -2.42250357e-02f, 5.39076477e-02f, 2.91782003e-02f,
  -4.97049719e-01f, -2.66097397e-01f, 4.77690578e-01f, -1.27363086e-01f, 3.34948927e-01f, 4.45125818e-01f, 3.81492138e-01f, 1.42767102e-01f, -5.00032492e-02f, -5.29075973e-02f,
  -4.82635871e-02f, -1.07082985e-01f, 5.58045646e-03f, 1.05250217e-02f, -7.25701731e-03f, 1.45460308e-01f, 2.02296898e-01f, 1.49998978e-01f, 3.83325398e-01f, 2.77216405e-01f,
  2.96274982e-02f, 3.04347440e-03f, -1.60631657e-01f, -1.05923451e-01f, -6.53057173e-02f, 6.88092634e-02f, 3.20471302e-02f, -1.02608688e-01f, -6.77271634e-02f, -1.46300703e-01f,
  5.72486401e-01f, -1.57166079e-01f, 1.90652147e-01f, -1.06941611e-01f, -9.07091235e-05f, -1.15785427e-01f, 2.09809437e-01f, -1.19858630e-01f, -1.30819038e-01f, 2.78820191e-02f,
  -7.98298866e-02f, -5.94477765e-02f, 1.69382188e-02f, -2.90671643e-02f, 9.01419222e-02f, -4.90792515e-03f, -2.06577703e-01f, 4.47359830e-02f, -2.75872052e-02f, -2.09476389e-02f,
  -3.87685895e-02f, -1.14680611e-01f, 1.72270268e-01f, 1.99908838e-01f, 2.25795805e-02f, -2.70622736e-03f, -2.47080025e-04f, -5.50053976e-02f, -8.15730616e-02f, 3.84731311e-03f,
  5.76652251e-02f, 1.84290148e-02f, -8.15023407e-02f, 1.04803547e-01f, 4.34487425e-02f, -2.91108387e-03f, 2.61935908e-02f, 6.06786795e-02f, 1.04311429e-01f, -1.05825756e-02f,
  4.48483191e-02f, 8.32791552e-02f, 8.36804062e-02f, 1.40119670e-02f, 6.25185594e-02f, -6.31462485e-02f, 2.70866621e-02f, -5.58155663e-02f, -1.54459029e-01f, -7.04479218e-02f,
  -2.24161744e-02f, -2.60756910e-02f, -1.54749170e-01f, 9.27644596e-02f, 3.64359915e-02f, 9.79983956e-02f, 1.66377109e-02f, 2.94276681e-02f, -4.05798256e-02f, -7.44428188e-02f,
  4.00348544e-01f, -4.81365807e-02f, 4.89859171e-02f, -1.34335726e-01f, -1.13881916e-01f, -1.32046893e-01f, 1.68866031e-02f, -3.09808291e-02f, -4.53719832e-02f, 9.58586633e-02f,
  2.16968525e-02f, -1.09853260e-01f, 1.69314835e-02f, -7.74467215e-02f, 1.23585157e-01f, 3.26124690e-02f, -1.15358800e-01f, 1.09394222e-01f, -2.48099677e-02f, 1.18352935e-01f,
  -2.17531584e-02f, 1.50930792e-01f, 1.92850903e-01f, 2.41622984e-01f, 4.25215848e-02f, 1.58001333e-01f, 1.37258202e-01f, 1.39428779e-01f, 6.36625588e-02f, 1.01572931e-01f,
  -4.56911474e-01f, 1.16743289e-01f, -4.40666109e-01f, -7.33296648e-02f, -1.96078926e-01f, -1.48441479e-01f, -2.85785109e-01f, 1.63008749e-01f, 1.92869812e-01f, 1.15695015e-01f,
  -1.27726108e-01f, -2.61139303e-01f, -2.03380466e-01f, -4.30953130e-02f, -2.43392125e-01f, -1.18082292e-01f, -3.09930384e-01f, -6.68308377e-01f, -7.06087410e-01f, -8.84260461e-02f,
  -1.45061389e-01f, -5.58945298e-01f, -3.43815386e-01f, -1.02313302e-01f, 2.02337384e-01f, -2.35065699e-01f, -5.68977036e-02f, -1.63360223e-01f, -1.00839756e-01f, -6.74797967e-02f,
  -2.52835929e-01f, 6.53740391e-02f, 1.24150753e-01f, 1.26717195e-01f, -5.33867404e-02f, 4.38273028e-02f, 2.28143614e-02f, -2.25800257e-02f, 1.23772606e-01f, 2.75995620e-02f,
  -8.36188495e-02f, 3.48829068e-02f, -1.91101089e-01f, 5.55466302e-03f, 1.87487938e-02f, 5.38756885e-02f, 2.25412518e-01f, -4.50457074e-02f, 1.56891003e-01f, 1.80098310e-01f,
  1.47340074e-01f, -6.32657707e-02f, 4.21624854e-02f, 3.10470551e-01f, 1.15084745e-01f, -7.56094605e-02f, 2.12239310e-01f, 1.81677118e-01f, 1.66349679e-01f, 2.70196587e-01f,
  2.43351348e-02f, -4.41494957e-02f, -1.24052698e-02f, -3.32427360e-02f, 4.87978421e-02f, -2.08380762e-02f, -8.12599733e-02f, 8.41945931e-02f, -1.23839751e-01f, -7.90724084e-02f,
  1.22077689e-01f, -6.21573441e-02f, 1.60058383e-02f, 2.96128839e-02f, 9.95796081e-03f, -1.32986810e-02f, 4.67936248e-02f, -1.28684323e-02f, 9.67716575e-02f, 1.12926103e-01f,
  -9.59693268e-03f, 3.47474180e-02f, -2.49261912e-02f, -1.02480501e-02f, 4.98745264e-03f, 2.97056139e-02f, 1.26500815e-01f, 1.09499477e-01f, -1.39280176e-02f, 5.45862801e-02f,
  -1.40991509e-02f, -2.57254899e-01f, 3.79569381e-02f, 1.06936410e-01f, -6.83911517e-03f, 1.79585218e-01f, 3.06247845e-02f, 5.80636375e-02f, -7.27875307e-02f, 1.37933716e-01f,
  9.16002244e-02f, -5.32421358e-02f, -1.38123497e-01f, 1.24887958e-01f, -2.10757852e-01f, -7.17344731e-02f, 1.81437805e-01f, -1.34450287e-01f, -6.29809648e-02f, 1.96304291e-01f,
  1.46362364e-01f, -4.97159548e-02f, 1.78884026e-02f, 1.63187951e-01f, -4.69562821e-02f, -1.86528385e-01f, -5.96717224e-02f, 3.43294144e-02f, -1.51211724e-01f, 1.31844580e-01f,
  -9.44423527e-02f, -6.28172159e-02f, -4.72465277e-01f, -2.05368653e-01f, -3.42511326e-01f, -7.26439804e-02f, 3.52753438e-02f, 1.31597012e-01f, -1.95606947e-01f, -1.47482827e-01f,
  1.69023150e-03f, 1.32905275e-01f, 7.08592534e-02f, 7.77130127e-02f, 3.80552024e-01f, -1.58193961e-01f, -2.85479009e-01f, -1.06187277e-01f, 2.68880993e-01f, 9.13669094e-02f,
  1.05313092e-01f, -1.51467994e-01f, -9.10592750e-02f, 1.59550104e-02f, -2.14906543e-01f, -1.15947589e-01f, -4.19170648e-01f, -1.95847049e-01f, -3.86026837e-02f, -3.67841691e-01f,
  -1.19967960e-01f, 5.31365257e-03f, 3.31400670e-02f, 8.18498880e-02f, -2.06278205e-01f, 6.57409579e-02f, 2.99297310e-02f, -1.49517193e-01f, -4.96807955e-02f, 1.67626049e-02f,
  -6.38659298e-03f, 9.57212076e-02f, -6.75418526e-02f, 1.67727619e-02f, -1.08740933e-01f, 1.17737398e-01f, -1.09550491e-01f, -9.95801985e-02f, -1.33440673e-01f, -4.05590683e-02f,
  3.30523476e-02f, 5.18697575e-02f, -2.92976648e-02f, 2.45420467e-02f, -1.43006921e-01f, -5.83891645e-02f, -1.57513559e-01f, -1.54745311e-01f, -1.56526789e-01f, -1.28491670e-01f,
  -4.61606570e-02f, -7.55002052e-02f, 3.09220385e-02f, 1.02939969e-02f, 4.84201945e-02f, -3.89220081e-02f, -2.57094540e-02f, -8.41696635e-02f, 9.47023258e-02f, -6.53991289e-03f,
  -5.31023601e-03f, -3.36638168e-02f, -4.41176351e-03f, -5.98209463e-02f, -1.25883758e-01f, 1.19717471e-01f, 1.59444839e-01f, -5.01226820e-03f, 7.04483502e-03f, 3.08881700e-02f,
  1.26888370e-02f, -4.76914644e-02f, -1.11770771e-01f, 9.48969051e-02f, -4.21026954e-03f, -8.58492628e-02f, 4.89026215e-03f, 6.34049028e-02f, 2.57047974e-02f, 8.49535242e-02f,
  -1.11994117e-01f, 1.26770744e-02f, 5.15126400e-02f, 1.80462450e-01f, -8.23082998e-02f, 6.97773248e-02f, -4.44517285e-02f, 4.78392132e-02f, -2.41459049e-02f, -1.67024191e-02f,
  -1.28150955e-01f, -2.91859042e-02f, -7.01907650e-02f, -1.97378476e-03f, 2.72528641e-02f, -8.51677060e-02f, 1.49512693e-01f, 3.94770689e-02f, 1.07591771e-01f, -4.98887412e-02f,
  -1.02428440e-02f, 2.74483889e-01f, 2.07000881e-01f, 1.38979675e-02f, 7.91213755e-03f, 3.06444392e-02f, 6.22987449e-02f, 1.09500149e-02f, 1.50007695e-01f, 1.49275169e-01f,
  2.55344242e-01f, 4.90699738e-01f, 2.35075727e-01f, 1.86048567e-01f, 1.80042952e-01f, 5.66512868e-02f, 5.90230897e-02f, 1.07048705e-01f, -3.26043256e-02f, 1.94573954e-01f,
  2.59409338e-01f, 2.26993412e-01f, 1.38926923e-01f, 1.01435982e-01f, 1.45729750e-01f, 1.70564950e-01f, 1.01467989e-01f, 7.51795098e-02f, -1.22565970e-01f, 4.73982766e-02f,
  1.40519932e-01f, 1.06455579e-01f, 8.58985074e-03f, -8.41728132e-03f, 1.79714918e-01f, -6.74336404e-02f, 6.58718124e-02f, 2.19775945e-01f, 1.66766763e-01f, 4.34353858e-01f,
  2.32254103e-01f, 2.83375263e-01f, -2.49907091e-01f, -2.22813617e-02f, 4.67005037e-02f, -1.41269982e-01f, 9.15541872e-03f, -2.02769004e-02f, -1.45769536e-01f, -5.11986762e-02f,
  2.73241512e-02f, -1.01612657e-02f, 6.11814260e-02f, -2.81777838e-03f, 4.52000946e-02f, 8.12698249e-03f, 5.22395596e-02f, 1.53154239e-01f, 4.57518026e-02f, 7.86255822e-02f,
  1.79926008e-01f, 1.87085882e-01f, 1.93350449e-01f, 1.42086502e-02f, -5.58847003e-02f, 1.00288607e-01f, -8.92783422e-03f, -3.60400192e-02f, 2.76653506e-02f, -4.05638665e-02f,
  -2.27347873e-02f, 7.25258514e-02f, 1.45908579e-01f, -3.58889215e-02f, -4.40425240e-02f, -2.13356569e-01f, 1.67769119e-02f, -6.47723451e-02f, -6.09241426e-02f, 5.13070151e-02f,
  -6.91724615e-03f, 1.18932851e-01f, -6.55441359e-03f, 4.34375554e-02f, -7.01727197e-02f, 1.34293795e-01f, 1.19371243e-01f, 1.17694750e-01f, -1.63231489e-05f, 2.20216736e-02f,
  -5.03071304e-03f, -1.62394773e-02f, -7.49031408e-03f, 1.38906017e-01f, 7.31063932e-02f, 8.99550468e-02f, 1.33711219e-01f, -1.59886181e-02f, -4.03110832e-02f, 5.40503077e-02f,
  -8.39921087e-02f, 1.50717693e-04f, -1.54111851e-02f, 1.14896186e-01f, 1.17664725e-01f, 5.94455153e-02f, 1.75850809e-01f, 3.76620218e-02f, 6.61070421e-02f, 6.45437017e-02f,
  7.14216381e-02f, -1.04133673e-02f, 1.19172120e-02f, -5.84072024e-02f, -1.74368158e-01f, -1.05722696e-01f, 1.45736104e-02f, 2.00620905e-01f, 1.59389243e-01f, -5.60408458e-02f,
  3.67812961e-02f, -3.31854895e-02f, 3.46493535e-02f, -1.16547033e-01f, -2.99709309e-02f, -1.24896124e-01f, -8.74783024e-02f, 1.01238657e-02f, -9.84318480e-02f, -3.33033383e-01f,
  -2.28610262e-01f, -3.36747795e-01f, 5.26278913e-02f, 3.25477600e-01f, 3.79160166e-01f, 1.93741217e-01f, 2.53898025e-01f, 6.89294338e-02f, 1.30033195e-01f, -4.36244160e-02f,
  -2.18076527e-01f, -7.88553208e-02f, -2.98969224e-02f, -7.35096037e-02f, -5.66769987e-02f, 3.29587907e-01f, 3.99770617e-01f, 2.11221799e-01f, 1.73378021e-01f, 1.65495381e-01f,
  1.92067206e-01f, -3.22045982e-02f, -1.67494595e-01f, 3.34299505e-02f, 1.74793512e-01f, 2.29836758e-02f, -1.02368459e-01f, 1.43122086e-02f, -8.38850290e-02f, 1.89763188e-01f,
  -5.10639727e-01f, -2.29031488e-01f, 9.51988623e-02f, -1.53527543e-01f, -1.62050590e-01f, -1.50772944e-01f, -1.17080308e-01f, -1.08832687e-01f, -1.96848795e-01f, -7.56282173e-03f,
  -1.53870821e-01f, -1.94817483e-02f, 5.82941361e-02f, 4.55032848e-02f, 2.58936211e-02f, 1.98645610e-02f, 7.62084648e-02f, -1.74343009e-02f, -1.41863227e-01f, -1.60406843e-01f,
  -5.05206846e-02f, 6.69794828e-02f, -1.43145618e-03f, 7.34764412e-02f, 1.04373679e-01f, -5.06115099e-03f, -8.00912734e-03f, 7.76245520e-02f, -1.04717344e-01f, 4.48013619e-02f,
  1.22441482e-02f, 9.38662607e-03f, 6.61316663e-02f, 3.42619643e-02f, 1.75166540e-02f, 4.23669703e-02f, 4.96615805e-02f, -4.84268367e-02f, 7.82574788e-02f, 7.88511522e-03f,
  -1.06037013e-01f, 9.26613957e-02f, 6.46805018e-02f, -1.14528742e-02f, -5.67938723e-02f, -7.84814358e-02f, 5.63099347e-02f, -4.20616828e-02f, -4.37095463e-02f, 2.49338187e-02f,
  4.07323763e-02f, -4.82495874e-02f, 3.85343730e-02f, 1.04409575e-01f, -3.04753929e-02f, -6.46445826e-02f, 9.46225077e-02f, -3.78230661e-02f, -2.11308971e-02f, -3.13218758e-02f,
  -3.46485108e-01f, -2.20948279e-01f, 5.68878949e-02f, -3.78123000e-02f, -2.80237217e-02f, -3.42775285e-01f, -1.10456116e-01f, -6.71733394e-02f, -1.89691428e-02f, -9.55082104e-02f,
  -2.18816385e-01f, -1.60673842e-01f, -5.77707104e-02f, -8.21002349e-02f, 1.33318394e-01f, 2.80195586e-02f, 2.24355776e-02f, 1.05357483e-01f, -2.44429912e-02f, -3.26455608e-02f,
  7.38134384e-02f, 2.26205572e-01f, 1.35653943e-01f, 1.28565848e-01f, 3.93500701e-02f, 8.00874755e-02f, -2.48950478e-02f, 1.25593036e-01f, 1.12845980e-01f, 1.12646163e-01f,
  -1.66545004e-01f, -5.92038073e-02f, 1.57858673e-02f, -4.42447066e-01f, -3.88142765e-01f, -3.06031913e-01f, 8.40756926e-04f, -3.08589607e-01f, -3.91064882e-01f, -2.86121182e-02f,
  9.99324843e-02f, 4.33094919e-01f, 3.72378320e-01f, 2.05872148e-01f, 4.26072061e-01f, 6.67600706e-02f, -2.10890412e-01f, 2.00924277e-01f, 1.20407060e-01f, -2.95150399e-01f,
  -2.93409884e-01f, -3.21813047e-01f, -1.95053622e-01f, -6.62908927e-02f, -1.37548193e-01f, 7.05076829e-02f, -1.01292819e-01f, -1.80464074e-01f, -2.12941542e-02f, -9.58678797e-02f,
  4.19025928e-01f, -2.66359329e-01f, -3.76823582e-02f, -7.89571330e-02f, 3.04699708e-02f, 1.13139255e-02f, -4.56145778e-02f, -2.57484429e-02f, -1.54981256e-01f, -7.91225955e-03f,
  -2.78068203e-02f, -1.28200680e-01f, 7.17252940e-02f, 4.43213321e-02f, -6.77271336e-02f, 3.63880731e-02f, -1.53437763e-01f, -1.64575905e-01f, -3.34273232e-03f, 3.01892888e-02f,
  6.88006962e-03f, -4.10040841e-02f, 1.95119664e-01f, 3.22448462e-02f, -9.24604982e-02f, 1.89456210e-01f, 3.39027331e-03f, -9.46383923e-02f, -6.10183440e-02f, -2.23340109e-01f,
  -1.34041468e-02f, 5.56871444e-02f, -8.80162120e-02f, 3.74908652e-03f, -1.01022627e-02f, -1.12694077e-01f, 1.33961253e-03f, 6.78999647e-02f, -2.75333393e-02f, 4.84804399e-02f,
  -1.18974090e-01f, -2.66558472e-02f, 2.35509593e-03f, -7.31426626e-02f, -5.49769774e-02f, -5.05935028e-02f, -7.11404858e-03f, -2.59341113e-02f, -9.81984381e-03f, 1.25237433e-02f,
  1.89575332e-03f, -1.81757677e-02f, 2.64352821e-02f, 3.52204554e-02f, -1.29063070e-01f, 1.14509342e-02f, 2.42105052e-01f, 3.98313776e-02f, 3.20092402e-03f, 5.63281439e-02f,
  2.26279452e-01f, -6.64770007e-02f, 2.48404250e-01f, -2.00987738e-02f, -3.00963931e-02f, -1.11358268e-02f, 8.35464448e-02f, -4.66749305e-03f, 1.57729480e-02f, -2.54336149e-02f,
  -6.76112324e-02f, -1.30001307e-01f, 1.40562996e-01f, 1.61130801e-02f, -1.45215735e-01f, -2.19187662e-01f, 6.88597513e-03f, 8.42835531e-02f, -1.07051082e-01f, -3.20467167e-02f,
  -1.15283087e-01f, -1.42037123e-01f, 2.29214698e-01f, 3.13925417e-03f, 2.57664882e-02f, 2.46762827e-01f, 8.83926228e-02f, 3.61154531e-03f, 9.53053534e-02f, -5.23450784e-03f,
  3.04784596e-01f, -9.67983902e-03f, -3.55727822e-01f, -1.83174182e-02f, -3.30998331e-01f, -2.01097980e-01f, -1.67832375e-01f, 2.06895962e-01f, 1.39285326e-01f, -1.86858416e-01f,
  -5.96319139e-02f, 2.19840661e-01f, 2.10972846e-01f, 9.39904600e-02f, 2.75171071e-01f, -2.03454047e-01f, -3.02616984e-01f, -9.24012717e-03f, 1.14169173e-01f, -7.03625083e-02f,
  -9.08212289e-02f, 3.24974842e-02f, 4.68939655e-02f, 5.85122779e-02f, -2.98635513e-01f, -1.34687036e-01f, -2.44429961e-01f, -2.62353331e-01f, -2.94693112e-01f, -5.39199233e-01f,
  -2.49966487e-01f, -2.30748758e-01f, -1.16710536e-01f, 2.45707761e-03f, -7.73813874e-02f, -2.61512026e-02f, -7.93285072e-02f, 1.04816996e-01f, 1.20023482e-01f, 1.57182127e-01f,
  -9.76252928e-03f, 1.08033352e-01f, 1.48077279e-01f, -7.90572092e-02f, -9.46877748e-02f, -8.49784166e-02f, 1.14969630e-02f, -8.60508829e-02f, 5.63478060e-02f, -6.91408366e-02f,
  -9.79018360e-02f, 4.12787534e-02f, -1.14614271e-01f, -6.09059855e-02f, -6.56719133e-02f, -1.14152662e-01f, -2.50400335e-01f, -1.87976986e-01f, -1.82733223e-01f, -2.67904222e-01f,
  5.16960099e-02f, -4.42102030e-02f, -1.49069130e-01f, -1.05569446e-02f, 1.26255646e-01f, 1.45739317e-01f, 1.12512428e-02f, 6.44188970e-02f, 1.46593094e-01f, 1.01411492e-01f,
  9.48941559e-02f, -7.33137429e-02f, 1.03937812e-01f, 7.37398565e-02f, -7.15560988e-02f, 5.25832139e-02f, -2.06886837e-03f, -1.11373745e-01f, -7.41742328e-02f, 8.21531191e-02f,
  5.32018617e-02f, -1.48737608e-02f, -8.62504989e-02f, 4.22739238e-02f, 5.27466182e-03f, -9.37813297e-02f, -5.42357042e-02f, -1.27282077e-02f, 2.36384906e-02f, 3.34622152e-02f,
  1.91024333e-01f, -7.68535882e-02f, -7.66854957e-02f, 8.42521712e-03f, -2.53745858e-02f, -1.72625817e-02f, -5.63715361e-02f, 2.36735508e-01f, 7.81219825e-02f, 7.38715231e-02f,
  -1.86189380e-03f, 1.32314280e-01f, 7.74171948e-02f, -6.96075261e-02f, -3.16386111e-02f, 1.30167988e-04f, 5.92165589e-02f, 1.41388315e-04f, 6.63279891e-02f, 4.94595245e-02f,
  1.01840764e-01f, 1.05872713e-01f, 2.15633288e-01f, 1.41332135e-01f, -5.57446890e-02f, -1.34426514e-02f, -4.81931269e-02f, 1.04921358e-02f, 1.61055580e-01f, 8.22750181e-02f,
  8.42520177e-01f, -4.86885428e-01f, 1.63148358e-01f, 4.29581814e-02f, -1.02084644e-01f, -2.49647461e-02f, -2.15011448e-01f, -3.95193212e-02f, 6.66669905e-02f, -4.09867018e-02f,
  2.35191435e-02f, 2.33409509e-01f, 1.89418301e-01f, 1.93234101e-01f, 1.03267543e-01f, -2.41895765e-01f, -1.18561260e-01f, 1.82785004e-01f, 3.02171558e-01f, -4.43572551e-02f,
  -1.27003968e-01f, -1.22998200e-01f, 6.69686571e-02f, 1.54139497e-03f, -3.35578859e-01f, -3.64429541e-02f, -2.23078877e-01f, -3.19797069e-01f, -2.53496796e-01f, -3.38097662e-01f,
  7.49754012e-02f, 1.74309522e-01f, 3.17041963e-01f, -1.14237261e-03f, 1.01443827e-01f, 1.87873751e-01f, 1.08070523e-01f, -3.71043235e-02f, -2.18210034e-02f, 2.12873574e-02f,
  1.57113094e-02f, 1.35239124e-01f, 6.42344803e-02f, -5.40821552e-02f, -5.52363954e-02f, 1.59069020e-02f, -3.79881524e-02f, -2.95399781e-02f, 2.46741865e-02f, -9.39892679e-02f,
  -1.23977862e-01f, 1.08479541e-02f, 7.18383491e-02f, 1.25911972e-02f, 1.17159113e-01f, 8.12479928e-02f, -5.51270843e-02f, 1.12632379e-01f, 2.92612035e-02f, -3.60541493e-02f,
  -1.16321355e-01f, 5.18076494e-02f, 5.34784757e-02f, -1.23407943e-02f, 8.70505795e-02f, 6.19237758e-02f, 4.27056774e-02f, -5.05470447e-02f, -3.49159464e-02f, -8.69251508e-03f,
  -4.14336435e-02f, 6.64459243e-02f, 2.17741020e-02f, -4.94792759e-02f, 6.41283989e-02f, -6.48451596e-03f, -4.94847298e-02f, 1.34681268e-02f, -1.12120016e-02f, -6.73352927e-03f,
  5.01319468e-02f, 3.65543105e-02f, -6.14150390e-02f, -5.20086475e-02f, -9.00624506e-03f, 7.83401951e-02f, -1.03981912e-01f, -6.32299452e-06f, 7.90463854e-03f, -1.05379887e-01f,
  -1.91353187e-01f, 4.61639225e-01f, 1.76335946e-01f, 9.80790891e-03f, -4.94711325e-02f, -5.69130406e-02f, 1.05737679e-01f, -3.93271521e-02f, -2.10727572e-01f, -1.14125587e-01f,
  -7.87155479e-02f, 4.32306528e-02f, -3.74050140e-02f, 3.94536927e-03f, 1.22825861e-01f, 5.00362180e-02f, -5.64166792e-02f, 8.48369524e-02f, -8.24847966e-02f, -1.12552799e-01f,
  -9.30120572e-02f, 5.47222197e-02f, 2.09125206e-01f, 1.88628107e-01f, 1.29527887e-02f, 1.96841419e-01f, 4.36029211e-02f, 4.06638384e-02f, 5.19112200e-02f, -3.52644324e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 20)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 20;
const float L0_fan_Bp_bar_data[] = {
  4.34418678e-01f, -3.10566097e-01f, 1.86415583e-01f, -5.13665676e-02f, 1.65587097e-01f, 1.55731425e-01f, 1.76643029e-01f, 2.47535050e-01f, -4.35932651e-02f, 1.73291922e-01f,
  1.38759390e-01f, 1.39806524e-01f, -1.67674422e-01f, 2.98982412e-01f, 6.85187504e-02f, 2.06127852e-01f, 9.62737501e-02f, 6.55900016e-02f, 6.23746030e-02f, -5.84447533e-02f
};

// L1_fan_Wp (Shape: 6 x 32)
const int L1_fan_Wp_rows = 6;
const int L1_fan_Wp_cols = 32;
const float L1_fan_Wp_data[] = {
  5.79146780e-02f, 4.57143001e-02f, 8.15086141e-02f, -7.11038411e-02f, 6.09253123e-02f, 7.52731413e-03f, -7.59290457e-02f, -6.50064263e-04f, 3.30713838e-02f, 8.68629888e-02f,
  -2.29384184e-01f, -8.95269141e-02f, 5.66746652e-01f, -1.63962781e-01f, -1.82940587e-01f, 8.84417817e-02f, -2.44092140e-02f, 1.90692991e-01f, 2.83902865e-02f, 1.52491763e-01f,
  -2.06161052e-01f, -1.64754525e-01f, -6.84973598e-02f, 7.06707314e-02f, -1.44389242e-01f, -1.50631279e-01f, 6.93624141e-03f, 9.61074606e-02f, -1.13077395e-01f, -4.05514687e-02f,
  7.71726891e-02f, 3.31903633e-04f, -2.36343537e-02f, -5.48042841e-02f, 2.69605150e-03f, 4.79926318e-02f, 1.23884082e-01f, -1.19263291e-01f, 4.19255197e-02f, 6.69949427e-02f,
  -6.60574660e-02f, 1.54001452e-02f, -1.01084448e-01f, 1.83112209e-03f, 4.45482880e-03f, -1.22454531e-01f, 7.14193732e-02f, 9.61933658e-02f, -4.52937670e-02f, 1.20600268e-01f,
  2.79856116e-01f, -1.23469159e-01f, 5.81759103e-02f, 3.95096689e-01f, 3.40440243e-01f, 2.62788567e-03f, -3.01253170e-01f, 2.60940492e-01f, -3.78437787e-02f, 5.35095111e-02f,
  1.21492520e-01f, -1.98948279e-01f, -1.15744047e-01f, 8.87154974e-03f, -4.34890017e-02f, -6.77572861e-02f, -8.05797130e-02f, 2.10152846e-02f, -3.14636491e-02f, -1.28643781e-01f,
  -7.03577027e-02f, -1.74550965e-01f, 3.29859257e-02f, 7.45351687e-02f, -2.46654108e-01f, -1.91415414e-01f, 4.37297598e-02f, 1.93665579e-01f, -1.01128109e-01f, -1.02056535e-02f,
  -5.52183837e-02f, -3.62464301e-02f, 3.56125087e-01f, -3.71579051e-01f, -2.21215129e-01f, 4.32846248e-01f, 1.74012497e-01f, -5.46394885e-02f, 9.40576568e-02f, 1.89608894e-02f,
  -1.50206551e-01f, 3.17935526e-01f, -3.56133736e-04f, -2.05244824e-01f, -2.39348769e-01f, -1.14734761e-01f, 8.62833932e-02f, -1.47109628e-01f, -3.09974216e-02f, 1.56947941e-01f,
  -1.13594078e-01f, -1.87738776e-01f, -9.61813107e-02f, 2.49084055e-01f, -2.27646858e-01f, -8.40645283e-03f, -1.79370433e-01f, 8.66826400e-02f, 5.79843111e-02f, -2.22393900e-01f,
  3.08067594e-02f, -1.68630734e-01f, 1.30900845e-01f, -1.43768013e-01f, -8.78535882e-02f, -9.37254056e-02f, 1.37064457e-01f, -1.25024736e-01f, 4.36133146e-02f, -3.20992678e-01f,
  1.04556970e-01f, 9.05558746e-03f, -7.58637115e-02f, 1.78880692e-01f, 1.05741307e-01f, -3.41239393e-01f, 3.07035190e-03f, -5.39127477e-02f, 2.96592317e-03f, -8.97444487e-02f,
  -6.84458390e-02f, 4.53629717e-02f, -1.51422009e-01f, -2.62381835e-03f, -4.35916111e-02f, -1.53106138e-01f, 6.90867454e-02f, -8.38791803e-02f, 7.94694424e-02f, 5.20319864e-02f,
  -3.24220466e-03f, -3.61389853e-02f, 1.80481806e-01f, 3.87312502e-01f, 1.71513539e-02f, 1.64423093e-01f, 3.36069793e-01f, -8.10955241e-02f, 6.96461499e-02f, 2.29663104e-01f,
  9.23701972e-02f, 7.36800879e-02f, -1.90833479e-01f, 1.66244268e-01f, 9.62481946e-02f, 1.69240795e-02f, 6.45939186e-02f, -2.71178871e-01f, -2.54577219e-01f, -1.44467428e-01f,
  -3.49881314e-03f, -3.56590711e-02f, -2.03437686e-01f, 8.80949870e-02f, 8.12516138e-02f, 1.45011917e-01f, 2.54064918e-01f, 2.57603914e-01f, -7.22992122e-02f, -8.34593400e-02f,
  -1.57187223e-01f, -3.66796106e-02f, 1.47376508e-01f, -1.28767997e-01f, -1.51969880e-01f, 3.78533751e-02f, 2.79114813e-01f, 4.66701984e-02f, -1.38999969e-01f, -1.00342251e-01f,
  -2.83636808e-01f, -1.16557069e-02f, 2.12737024e-01f, 8.85752961e-03f, -2.25258693e-01f, 3.08177799e-01f, -4.82432768e-02f, 6.91164983e-03f, -6.46432936e-02f, -4.03173327e-01f,
  1.48890153e-01f, -1.57833502e-01f
};

// L1_fan_Wp_bar (Shape: 20 x 32)
const int L1_fan_Wp_bar_rows = 20;
const int L1_fan_Wp_bar_cols = 32;
const float L1_fan_Wp_bar_data[] = {
  3.04789543e-01f, 1.28071651e-01f, -5.72303943e-02f, 5.77969775e-02f, 2.14074880e-01f, 8.91252682e-02f, 1.37423992e-01f, 1.78117603e-01f, -2.95893606e-02f, -1.30140465e-02f,
  -2.98013210e-01f, -1.26266569e-01f, -4.20435131e-01f, 2.12183893e-01f, 1.32576585e-01f, 8.45832750e-02f, 1.17303111e-01f, -2.97603384e-02f, -6.87934235e-02f, -3.29456478e-01f,
  -9.74631235e-02f, 3.57090801e-01f, 1.75970420e-01f, 1.85514703e-01f, 2.20286310e-01f, 1.98569790e-01f, -2.48966627e-02f, 3.04798365e-01f, -3.88224348e-02f, 1.02040529e-01f,
  -2.87663862e-02f, -1.62435427e-01f, 1.30311087e-01f, 1.48649827e-01f, 1.74721777e-01f, -5.77423163e-02f, 1.54495090e-01f, 3.96420732e-02f, 1.29335582e-01f, -4.37478542e-01f,
  1.12035751e-01f, 1.25166968e-01f, -2.27655768e-01f, 2.83976253e-02f, -2.19916448e-01f, 7.75867403e-02f, 3.15375388e-01f, 2.31673077e-01f, 1.01037599e-01f, -1.10938750e-01f,
  4.46424663e-01f, -1.43406719e-01f, 8.01152438e-02f, 4.51246589e-01f, 8.34860057e-02f, 1.88712850e-01f, 1.16727538e-02f, 2.21694589e-01f, -3.30264587e-03f, -1.75136372e-01f,
  3.19742471e-01f, 1.89240426e-01f, 7.58668557e-02f, -3.91071141e-01f, 1.64310530e-01f, 7.20589235e-02f, 3.33033979e-01f, 1.27175182e-01f, 1.94798172e-01f, 1.08239315e-01f,
  -2.32844889e-01f, -3.53171863e-02f, 2.39004847e-02f, 1.24292515e-01f, -2.70833746e-02f, -9.05067623e-02f, 5.18449545e-01f, 1.67187616e-01f, -1.49828240e-01f, 3.11372019e-02f,
  -1.74414650e-01f, 5.63391984e-01f, 1.65442023e-02f, 1.04139067e-01f, 1.65611118e-01f, -8.69301185e-02f, 4.72139567e-03f, -3.65377963e-02f, -1.21445365e-01f, 1.92836344e-01f,
  3.02548796e-01f, -8.10863823e-02f, -1.78906992e-01f, -6.32665306e-02f, 3.70246798e-01f, 3.79583120e-01f, -1.18672445e-01f, 8.77953880e-03f, 5.30423261e-02f, 7.61211440e-02f,
  -1.13659188e-01f, -1.14493817e-01f, 2.73528080e-02f, -7.17095613e-01f, -5.49265556e-02f, -5.34136705e-02f, 7.68396556e-02f, -1.45728874e-04f, -2.32179891e-02f, 7.65822735e-03f,
  2.96676666e-01f, 7.59995207e-02f, 2.14089453e-01f, 9.50280130e-02f, 3.73631537e-01f, -6.28471598e-02f, 3.49407166e-01f, 2.57949531e-01f, -2.18504369e-02f, 3.18613321e-01f,
  -1.26948789e-01f, -1.24134593e-01f, -2.58770417e-02f, -6.30832836e-02f, 2.27147549e-01f, 1.81916207e-01f, -7.48773664e-02f, -2.39310876e-01f, 3.54761511e-01f, 7.25651458e-02f,
  1.43560633e-01f, 3.00401181e-01f, -4.61664982e-03f, 2.06484959e-01f, -3.29939008e-01f, 3.58494103e-01f, 1.51183859e-01f, 1.01253845e-01f, 1.42575741e-01f, 4.39649560e-02f,
  1.86761424e-01f, 2.33645644e-02f, 2.57865518e-01f, -7.72582740e-02f, 6.27217861e-03f, 1.74572945e-01f, 4.20395359e-02f, -3.71020734e-02f, 2.17842713e-01f, -2.67421156e-01f,
  -2.34099284e-01f, 1.80147737e-01f, 3.15897405e-01f, 1.52175054e-01f, 2.39573985e-01f, -4.72103059e-01f, 5.19374490e-01f, 1.50273860e-01f, 2.27686107e-01f, 1.46173192e-02f,
  2.39044771e-01f, 3.44380915e-01f, 2.84556776e-01f, 2.42541462e-01f, 3.19935232e-01f, 1.11088663e-01f, -2.07220614e-01f, -3.46201435e-02f, 3.25485379e-01f, 2.63402253e-01f,
  -2.30084017e-01f, 1.52786076e-01f, 4.60436732e-01f, -2.96913809e-03f, -6.40122220e-02f, -6.69625551e-02f, -2.36571223e-01f, 2.32422918e-01f, -6.40906021e-02f, 1.91754371e-01f,
  1.80153117e-01f, -4.00409937e-01f, -2.01269418e-01f, 3.53711724e-01f, 3.16662085e-03f, 6.17888756e-02f, 2.13282838e-01f, -1.86304927e-01f, -1.07615426e-01f, 3.30131412e-01f,
  2.50836879e-01f, -1.40472755e-01f, 1.82081744e-01f, 2.44263008e-01f, -7.80492201e-02f, 1.68646537e-02f, -2.26958599e-02f, 5.55351488e-02f, -4.98212129e-02f, 8.02237634e-03f,
  1.98381022e-02f, 9.28501487e-02f, 3.08611214e-01f, 2.10628286e-01f, 1.43327683e-01f, -2.40926072e-03f, 2.64564842e-01f, -2.61214316e-01f, -1.28816888e-01f, -6.55364320e-02f,
  -3.64359282e-02f, -4.37168390e-01f, -9.07789543e-02f, -5.06078243e-01f, -2.97172010e-01f, 2.76492596e-01f, 4.07438993e-01f, -1.99764743e-01f, 3.23898792e-01f, -3.06570381e-01f,
  2.22225174e-01f, 1.55724719e-01f, 2.54266262e-01f, -1.53647522e-02f, 9.87033099e-02f, 8.50749239e-02f, 1.30540892e-01f, -3.16904262e-02f, -6.62461892e-02f, 2.67548651e-01f,
  -2.54530162e-01f, 1.01438709e-01f, 3.15479308e-01f, -2.21215993e-01f, 1.47059113e-01f, -1.03428610e-01f, 5.21449029e-01f, -2.17819601e-01f, -1.56638682e-01f, 3.26077998e-01f,
  4.29742008e-01f, 3.33111614e-01f, 1.66013703e-01f, 4.69452471e-01f, -1.91060349e-01f, -2.14368299e-01f, -1.84353083e-01f, 3.41878049e-02f, -4.35890526e-01f, 2.31644794e-01f,
  8.79880786e-02f, -1.23401038e-01f, 6.03767782e-02f, -1.38262630e-01f, 2.14433461e-01f, -7.77031407e-02f, 1.41367957e-01f, 2.02493742e-01f, 7.97200575e-02f, 2.25893527e-01f,
  9.51051414e-02f, 2.69339401e-02f, -1.66446548e-02f, 8.19840208e-02f, 5.79000041e-02f, -1.11639492e-01f, 1.87816754e-01f, -1.97234787e-02f, 2.34621137e-01f, -4.89132591e-02f,
  -4.48639430e-02f, -2.23954722e-01f, 2.11695835e-01f, 8.68072584e-02f, -2.61332184e-01f, 5.37324965e-01f, -9.68535468e-02f, -1.82547137e-01f, -2.05717489e-01f, 8.83228853e-02f,
  3.44543532e-02f, -1.50622100e-01f, 2.51048684e-01f, 1.23977162e-01f, 1.45920645e-02f, 3.68727297e-01f, 5.77226169e-02f, 4.03864443e-01f, 6.28096536e-02f, 7.43710250e-02f,
  1.71723798e-01f, -3.10192653e-03f, 9.36532468e-02f, 2.58334816e-01f, -6.27393275e-02f, -1.97768852e-01f, 1.42058864e-01f, 1.32530048e-01f, 1.04715023e-02f, 1.01179890e-01f,
  4.55281176e-02f, -8.29055011e-02f, -2.76402503e-01f, -3.22851203e-02f, -2.41500750e-01f, 3.75368685e-01f, -2.69578937e-02f, 1.57718688e-01f, -8.21474865e-02f, 9.38645154e-02f,
  -1.84883758e-01f, 4.36677277e-01f, -5.37352636e-02f, 4.75015432e-01f, 2.55903453e-01f, 9.10934135e-02f, 8.42325911e-02f, 2.22839698e-01f, 3.01685125e-01f, 9.45821553e-02f,
  1.62238181e-01f, -9.17627588e-02f, 1.69782847e-01f, -6.20629601e-02f, -1.52834490e-01f, -8.44018683e-02f, -1.37441814e-01f, -1.62120253e-01f, -5.48032559e-02f, -2.34167017e-02f,
  -9.88587588e-02f, 1.43273413e-01f, 3.24197292e-01f, -7.89376050e-02f, -1.09723650e-01f, 4.72715974e-01f, 4.97250333e-02f, 1.02839164e-01f, 3.71178538e-01f, 1.80577278e-01f,
  -1.23421244e-01f, -1.10299690e-02f, -1.87617354e-02f, -1.89066753e-02f, -1.44330412e-01f, 3.00899655e-01f, 9.55315083e-02f, -2.06193283e-01f, 1.09312003e-02f, -2.49999076e-01f,
  5.41728735e-02f, -1.01177625e-01f, 1.90833718e-01f, 3.66713256e-02f, 2.31057107e-01f, 8.71664956e-02f, 7.80798718e-02f, 6.86753616e-02f, 2.44929880e-01f, -5.83908409e-02f,
  3.34036499e-01f, -1.91285595e-01f, -2.05591351e-01f, -8.45865235e-02f, 1.06042534e-01f, -1.88258633e-01f, -8.39121491e-02f, 3.52750361e-01f, 3.90175357e-02f, 9.55462307e-02f,
  1.20126031e-01f, 2.91827247e-02f, -2.07587659e-01f, 1.47694007e-01f, -6.17414489e-02f, 4.05802503e-02f, -2.55205065e-01f, 4.04790938e-01f, 3.55234779e-02f, -8.70142952e-02f,
  -1.31899461e-01f, -8.31236467e-02f, 1.69123664e-01f, -1.74033791e-02f, 6.62728027e-02f, -1.95364401e-01f, 3.73176873e-01f, 2.07672849e-01f, -1.21963739e-01f, 1.21350288e-01f,
  -9.34144557e-02f, -4.42828029e-01f, -1.00210570e-01f, -1.23416588e-01f, -3.20023149e-02f, 1.47087708e-01f, 2.32781142e-01f, -6.39613019e-03f, 3.19255441e-01f, 4.55784559e-01f,
  6.53996691e-02f, 2.28194565e-01f, 3.91504943e-01f, 1.22962959e-01f, 2.61985272e-01f, 6.47133112e-01f, -1.89990140e-02f, 4.29940708e-02f, -4.99086946e-01f, -1.99341532e-02f,
  1.76412895e-01f, 1.31899849e-01f, 2.96181738e-02f, -1.93088785e-01f, -1.40255228e-01f, -3.39222729e-01f, 7.25276768e-02f, 3.45399797e-01f, 3.03311616e-01f, 3.00724730e-02f,
  1.10655703e-01f, 1.61650136e-01f, 2.57141292e-01f, -8.97388682e-02f, 1.27885252e-01f, -2.99820393e-01f, -9.28298533e-02f, -9.72309858e-02f, 3.10386121e-01f, -4.47568834e-01f,
  -1.49686396e-01f, 3.66429567e-01f, 5.64126134e-01f, -5.65165281e-02f, 3.05374205e-01f, 4.62478817e-01f, -3.26438189e-01f, -1.76761746e-01f, 3.76862794e-01f, -6.57717958e-02f,
  -2.34516114e-01f, -9.85719962e-04f, -2.43070289e-01f, 1.66019291e-01f, -3.71202677e-02f, 5.56833223e-02f, 2.07635015e-03f, -2.23125913e-03f, -7.54975528e-03f, -7.84368291e-02f,
  2.07118466e-01f, -1.48581669e-01f, -7.53128007e-02f, -1.42857190e-02f, -1.45669356e-01f, -3.96172881e-01f, 5.57942800e-02f, -1.96515530e-01f, -4.84436378e-02f, -7.48325512e-02f,
  5.11535227e-01f, -2.24665821e-01f, -1.48579806e-01f, 3.24866652e-01f, 5.16912460e-01f, 2.59631693e-01f, 1.45982236e-01f, 1.57974720e-01f, -1.75334841e-01f, -2.87138849e-01f,
  -1.13531917e-01f, 7.82159567e-02f, -3.82834107e-01f, 1.07158042e-01f, -1.77626982e-01f, 5.05601689e-02f, 2.63907220e-02f, 1.00224048e-01f, -7.17865676e-02f, -1.39568672e-01f,
  8.54350924e-02f, -1.24749966e-01f, 1.36273906e-01f, -1.96170673e-01f, 7.46427327e-02f, 2.01428041e-01f, 1.62965313e-01f, -7.47081041e-02f, -2.38542989e-01f, 2.66938984e-01f,
  1.89517841e-01f, -4.60181348e-02f, -4.66943800e-01f, -1.05610363e-01f, 3.48213792e-01f, -2.10509315e-01f, 9.40799043e-02f, -3.46619748e-02f, 2.44694413e-03f, 3.38687479e-01f,
  3.22501838e-01f, -1.45196781e-01f, -3.37616540e-02f, -3.39111805e-01f, -4.20926488e-04f, -3.85786444e-01f, -2.65188068e-01f, 1.02242216e-01f, 3.37990314e-01f, -3.79906222e-02f,
  -1.93265706e-01f, 1.85173869e-01f, 9.54596698e-02f, 1.55477464e-01f, 1.28041118e-01f, -3.97735015e-02f, 6.32617250e-02f, 1.74835280e-01f, -7.75946900e-02f, -5.59859686e-02f,
  -1.28582716e-01f, -1.74614135e-02f, 1.15330547e-01f, 9.80174467e-02f, 1.27074659e-01f, -3.34176183e-01f, 2.02706933e-01f, 9.70655903e-02f, 2.72053182e-01f, -2.40309328e-01f,
  2.71994442e-01f, 5.49300909e-01f, 3.41534466e-01f, 1.17525063e-01f, 1.81072950e-01f, -5.06493151e-01f, 1.48834914e-01f, -1.55800194e-01f, -2.24467590e-01f, 2.90302515e-01f,
  3.84469539e-01f, -2.10463002e-01f, -4.13884640e-01f, 5.91544025e-02f, 3.24547678e-01f, 2.06929460e-01f, 8.15228820e-02f, 3.11324954e-01f, 4.85220760e-01f, 3.67456853e-01f,
  2.44265050e-01f, 8.97241160e-02f, -6.30681589e-02f, -7.36415908e-02f, -8.25029910e-02f, -1.19636416e-01f, -5.76804161e-01f, -5.88614047e-02f, 2.78384537e-01f, -1.39304459e-01f,
  -2.64920980e-01f, 4.99818008e-03f, 1.49804786e-01f, -3.38722527e-01f, 3.32929820e-01f, 5.47306716e-01f, 1.97022006e-01f, 1.02998845e-01f, 2.19341740e-01f, -2.65142117e-02f,
  1.67708799e-01f, -2.79944949e-02f, 9.09802169e-02f, 2.20547587e-01f, -1.22971311e-01f, -3.17310750e-01f, 5.78317009e-02f, 3.07048500e-01f, 4.94624600e-02f, -5.86627200e-02f,
  2.84070462e-01f, 2.32578367e-01f, 3.99838030e-01f, -3.77121866e-02f, -2.40600519e-02f, -5.78159213e-01f, -1.32961199e-01f, 8.58655199e-02f, 9.31667984e-02f, -3.41443956e-01f,
  -9.28427726e-02f, 1.18815646e-01f, 6.74931049e-01f, -2.08596975e-01f, -8.10352713e-02f, 2.13878900e-01f, -1.62274048e-01f, -1.69169053e-01f, 3.58701825e-01f, 6.25639111e-02f,
  -5.75969756e-01f, 2.26053745e-01f, -2.01433733e-01f, 8.84865522e-02f, -3.04394066e-01f, 1.61627293e-01f, 7.06282929e-02f, -2.56070793e-01f, 3.76710892e-01f, 1.49831474e-01f,
  7.91766942e-02f, 3.94276023e-01f, 5.79943776e-01f, 5.12060702e-01f, -4.93432172e-02f, -2.31847882e-01f, 2.23643333e-01f, 4.23446655e-01f, -2.72435546e-01f, 9.27074477e-02f,
  1.40093878e-01f, -4.08133008e-02f, 2.36477241e-01f, -5.92885073e-03f, -2.45451942e-01f, 1.84038728e-01f, 3.37993890e-01f, -1.73817828e-01f, 1.59265667e-01f, 2.92469531e-01f,
  2.56233722e-01f, 3.16824108e-01f, 6.35636076e-02f, 3.66784960e-01f, 3.21137846e-01f, -9.20759290e-02f, 2.09912643e-01f, -3.62907313e-02f, 2.03888774e-01f, -3.96125108e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 20)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 20;
const float L1_fan_Bp_bar_data[] = {
  1.27291247e-01f, 1.80168331e-01f, 8.06321725e-02f, -1.56499222e-01f, 1.97242483e-01f, 1.75470605e-01f, 2.61787802e-01f, 1.43194720e-01f, 1.69324636e-01f, 1.36876449e-01f,
  -5.07046320e-02f, 2.80313939e-01f, -1.12986274e-01f, 1.84023753e-01f, -1.51977599e-01f, 2.96641976e-01f, 4.83391106e-01f, 1.68031633e-01f, 3.04740578e-01f, 1.86284095e-01f
};

// L2_fan_Wp (Shape: 6 x 32)
const int L2_fan_Wp_rows = 6;
const int L2_fan_Wp_cols = 32;
const float L2_fan_Wp_data[] = {
  -2.73970902e-01f, -1.21975049e-01f, -1.08207412e-01f, -2.22510561e-01f, -1.24079660e-01f, 8.11880454e-02f, 9.44143627e-03f, 3.24036330e-01f, -2.05090284e-01f, 4.09896933e-02f,
  1.68864205e-01f, 1.33587494e-01f, -5.97095415e-02f, -3.62294286e-01f, 2.49770388e-01f, -1.37234047e-01f, 1.51726514e-01f, 1.67820603e-01f, 2.72549838e-01f, 6.95461631e-02f,
  1.05006635e-01f, -1.74146831e-01f, -6.84127510e-02f, 3.95671204e-02f, -8.63454938e-02f, -8.95519480e-02f, 1.89612255e-01f, 5.14114872e-02f, -2.25762695e-01f, -1.91487134e-01f,
  1.62511051e-01f, -1.89611360e-01f, -1.31668970e-01f, -2.64343381e-01f, -1.10482983e-01f, 5.42225428e-02f, -5.52578308e-02f, -1.40427843e-01f, -1.85404494e-01f, -1.00041218e-01f,
  6.76709712e-02f, 8.48244783e-03f, 2.42676318e-01f, 9.98433307e-02f, 1.24435589e-01f, 1.56292528e-01f, -2.06684753e-01f, 1.88510492e-01f, -2.57844329e-01f, -5.65438829e-02f,
  -3.22716594e-01f, 2.27361964e-03f, -4.37788405e-02f, 1.96215212e-01f, 3.86620536e-02f, 1.09458730e-01f, 2.08936885e-01f, -4.92551513e-02f, 1.51234448e-01f, 5.49869705e-03f,
  2.00938284e-01f, -1.60742328e-01f, -2.64840424e-01f, 1.07385293e-01f, -7.60431364e-02f, 1.47825152e-01f, -1.31486356e-01f, 4.13732082e-01f, 2.85677850e-01f, 3.63025844e-01f,
  7.15767264e-01f, 4.51874822e-01f, 1.96662694e-01f, 3.01420063e-01f, 2.26277113e-01f, 3.62357795e-01f, 3.24761644e-02f, -2.50555575e-01f, 2.06280828e-01f, -2.30598390e-01f,
  9.70817506e-02f, -7.37042874e-02f, -4.01002839e-02f, -2.29829215e-02f, -7.15212300e-02f, 1.17493398e-01f, 2.16565162e-01f, -7.62318745e-02f, 9.50891897e-02f, -1.69624716e-01f,
  -7.97751620e-02f, -1.59382388e-01f, -1.24111220e-01f, 1.12171285e-01f, -3.61901708e-02f, 5.83829693e-02f, 1.17386378e-01f, 1.01963378e-01f, -2.12481692e-01f, -2.67183959e-01f,
  3.15997869e-01f, 1.95078596e-01f, 1.04051828e-02f, 2.07985826e-02f, -2.23023787e-01f, 3.04167159e-02f, 3.75745967e-02f, -2.73599356e-01f, -4.45240140e-01f, -1.75932035e-01f,
  2.68642753e-01f, -2.01670825e-01f, 3.11205149e-01f, 2.86062092e-01f, 2.04210982e-01f, -6.61133379e-02f, -4.80422415e-02f, 2.56711859e-02f, 2.05383658e-01f, 8.12921748e-02f,
  1.26434833e-01f, -9.32136364e-03f, 1.35346025e-01f, -1.68518946e-01f, -1.55552372e-01f, -1.98958799e-01f, -1.94446743e-01f, -2.33483478e-01f, -3.05049688e-01f, 1.86267272e-01f,
  -7.04115778e-02f, 1.72201043e-03f, 8.01089704e-02f, 1.32176623e-01f, -1.35760866e-02f, 1.68131530e-01f, 3.22021782e-01f, -1.31285012e-01f, 1.83078289e-01f, 6.05188496e-02f,
  -3.58698145e-02f, 2.28373870e-01f, -8.03492367e-02f, -2.22086743e-01f, 8.86350945e-02f, -8.06183070e-02f, -3.00859451e-01f, 4.80784997e-02f, -3.79541934e-01f, 1.49671631e-02f,
  6.03123754e-02f, -5.92500120e-02f, 3.43243182e-02f, -1.28109723e-01f, 3.89427900e-01f, -3.02802473e-01f, -1.39413759e-01f, -2.45336980e-01f, -1.23758100e-01f, 1.20639876e-01f,
  -2.09218144e-01f, -1.45294085e-01f, 1.08210549e-01f, -2.47953817e-01f, -1.27600938e-01f, -1.98531643e-01f, -2.58700758e-01f, -1.22906446e-01f, -1.26466721e-01f, 2.46770889e-03f,
  -1.46227926e-01f, -1.40541747e-01f, -3.78393412e-01f, 1.98130026e-01f, 1.35829896e-01f, 2.08386987e-01f, 2.36712828e-01f, -1.39937606e-02f, 1.37270898e-01f, -1.46312788e-01f,
  3.21952067e-02f, -1.15668774e-01f, 2.86826286e-02f, -1.08590096e-01f, 1.87777504e-01f, -1.37144804e-01f, -7.48913661e-02f, -5.46597317e-02f, 1.81500033e-01f, 6.96409494e-02f,
  -3.81814599e-01f, 2.17849806e-01f
};

// L2_fan_Wp_bar (Shape: 20 x 32)
const int L2_fan_Wp_bar_rows = 20;
const int L2_fan_Wp_bar_cols = 32;
const float L2_fan_Wp_bar_data[] = {
  2.50726879e-01f, 1.79728568e-01f, 3.08543324e-01f, 4.03787673e-01f, 4.19976041e-02f, 4.00179029e-01f, 3.27621430e-01f, 1.23902880e-01f, 1.37319937e-01f, -5.78629494e-01f,
  3.75719033e-02f, 3.06745440e-01f, -1.50533944e-01f, -9.21160951e-02f, 2.46929750e-01f, -1.71934888e-01f, 1.55832767e-01f, 3.78549069e-01f, -2.30388671e-01f, 2.64814734e-01f,
  -1.06968239e-01f, 2.23355204e-01f, 1.91911638e-01f, 3.57588679e-01f, 8.55889693e-02f, 2.00648099e-01f, 5.51190786e-02f, -3.15081507e-01f, -2.52271205e-01f, 1.34024814e-01f,
  -1.80187389e-01f, 1.93964228e-01f, 1.86112836e-01f, 1.53105482e-01f, 2.63216406e-01f, -5.20421624e-01f, -8.37538317e-02f, -3.23644221e-01f, 4.09348369e-01f, -3.39929283e-01f,
  7.22276196e-02f, -2.89113760e-01f, 6.00144640e-02f, -9.92142037e-02f, 8.90021771e-02f, 1.86200574e-01f, 2.23572567e-01f, 3.31068963e-01f, 7.17965374e-03f, 3.81024241e-01f,
  1.37115851e-01f, 2.91946918e-01f, -4.17919867e-02f, 4.75652903e-01f, 8.98790210e-02f, -2.05488615e-02f, 9.42481607e-02f, -2.47747123e-01f, 1.49122164e-01f, -2.98434287e-01f,
  -6.74714983e-01f, 1.40183881e-01f, -3.00967038e-01f, 1.45375013e-01f, 3.22348416e-01f, 3.63071352e-01f, -2.27958709e-01f, 2.33695358e-01f, 8.20211694e-02f, 9.30129662e-02f,
  3.84690642e-01f, -2.39247844e-01f, -5.57377994e-01f, 3.58570851e-02f, -7.16979563e-01f, -3.90414983e-01f, -5.34347534e-01f, -5.69485366e-01f, 1.54113621e-01f, -3.64266723e-01f,
  1.64531842e-01f, 2.70534396e-01f, -2.21864600e-02f, 3.46500933e-01f, 1.27762198e-01f, 1.91752836e-01f, 1.11257181e-01f, -3.00414972e-02f, -2.11825185e-02f, 1.05015062e-01f,
  -5.86332791e-02f, 3.11728805e-01f, 2.09466323e-01f, -8.26451331e-02f, 1.36375144e-01f, 7.06933364e-02f, -2.07363486e-01f, -9.50908512e-02f, 1.69505656e-01f, 1.88255310e-01f,
  -3.57526749e-01f, 1.92190390e-02f, 5.12003660e-01f, 3.43297124e-02f, -9.38619599e-02f, -1.67707875e-02f, 3.04352432e-01f, -5.16043425e-01f, -4.30200011e-01f, -1.49190024e-01f,
  4.69153225e-01f, 2.59978324e-01f, 1.04230102e-02f, 1.45277664e-01f, -1.47261973e-02f, 1.57132611e-01f, 4.31826532e-01f, 3.19059014e-01f, 1.31536528e-01f, -1.87706202e-02f,
  4.39390540e-01f, 8.70637149e-02f, 2.73223132e-01f, 2.03588873e-01f, 1.70795664e-01f, 4.15662900e-02f, -2.98032016e-01f, 3.24359715e-01f, 6.97358400e-02f, 3.38482916e-01f,
  5.29463068e-02f, 1.71175525e-01f, 5.55067003e-01f, 1.41666040e-01f, 8.20735693e-02f, 4.81678605e-01f, 1.35442719e-01f, -4.85349186e-02f, 3.46309692e-01f, 4.90138948e-01f,
  -7.49278143e-02f, 2.04131931e-01f, -2.94785611e-02f, -5.96905760e-02f, -1.56209141e-01f, 6.28214553e-02f, -1.63001075e-01f, 1.24775358e-01f, -7.35958740e-02f, 7.99670219e-02f,
  1.79379314e-01f, 3.94054979e-01f, 3.33782732e-01f, 4.49554831e-01f, 3.36903304e-01f, -8.22423622e-02f, 3.02228928e-02f, 1.72713146e-01f, 5.71844280e-01f, 1.90833107e-01f,
  -2.11522505e-02f, 2.73871750e-01f, 2.78648496e-01f, 6.23986647e-02f, 8.92239064e-02f, 1.07364645e-02f, 2.52780288e-01f, -6.72565922e-02f, -2.96862066e-01f, 2.75845349e-01f,
  -3.47184449e-01f, 1.46604702e-01f, 2.01892450e-01f, -1.93490043e-01f, -9.06142816e-02f, -3.66474599e-01f, 1.60938889e-01f, 1.51204884e-01f, 3.45613182e-01f, -1.72066078e-01f,
  1.18200161e-01f, 3.42638418e-02f, -1.21822812e-01f, 1.06702648e-01f, -1.88648403e-01f, 9.09595713e-02f, -4.01361644e-01f, 1.75822318e-01f, 2.76440054e-01f, 4.48347747e-01f,
  2.30463184e-02f, -7.83175826e-02f, 2.13354096e-01f, 3.81681472e-01f, -7.90337846e-02f, 1.97220519e-01f, 1.04010642e-01f, 2.77973920e-01f, 4.52248901e-01f, -2.71513581e-01f,
  -3.73147547e-01f, -2.31499344e-01f, -4.53200936e-01f, -3.16821009e-01f, -4.27850336e-01f, -5.45354545e-01f, 3.18203241e-01f, -1.98987842e-01f, 3.57064158e-01f, 3.98314834e-01f,
  2.90234804e-01f, 3.19844246e-01f, 2.90288538e-01f, 1.94565624e-01f, -5.27285598e-02f, 4.67197672e-02f, -3.42973396e-02f, 2.54026413e-01f, -8.28708112e-02f, 9.55725461e-02f,
  1.49689853e-01f, -1.92957312e-01f, 1.04975343e-01f, 3.93769369e-02f, -3.46355647e-01f, -1.38801694e-01f, -1.78304359e-01f, -4.18659687e-01f, -3.42398256e-01f, 5.34717031e-02f,
  3.21063489e-01f, 1.43455848e-01f, 8.02584663e-02f, 2.23769732e-02f, 7.30095804e-01f, 2.51233548e-01f, -5.46249282e-03f, -9.32025239e-02f, 1.98049501e-01f, 2.09721610e-01f,
  1.78860351e-02f, 8.52344334e-02f, -1.56062990e-01f, 4.11946714e-01f, 1.72869146e-01f, 1.93534404e-01f, 4.15482759e-01f, 9.14189965e-02f, 3.70486617e-01f, 1.97470799e-01f,
  5.15945971e-01f, -1.54168800e-01f, 3.86957861e-02f, -4.56785977e-01f, -1.21407211e-01f, -1.38539374e-01f, 1.68650951e-02f, 1.30531579e-01f, 3.26426148e-01f, -8.34304616e-02f,
  4.09544408e-01f, 1.05107151e-01f, 2.31708661e-01f, 7.05514252e-01f, 3.42193484e-01f, 6.99360371e-01f, -1.50938153e-01f, -4.84842271e-01f, 4.63207886e-02f, 2.01584652e-01f,
  1.08404718e-01f, 2.73065567e-01f, -3.78849357e-01f, -7.34825656e-02f, -1.09894186e-01f, -4.19261724e-01f, -2.99418848e-02f, -1.03187568e-01f, -1.35711029e-01f, 1.61187857e-01f,
  1.57011017e-01f, 1.93927899e-01f, -2.12382339e-02f, 5.22935912e-02f, 2.96780348e-01f, 2.36035705e-01f, -8.83478224e-02f, 2.32683405e-01f, 1.45200491e-01f, 2.92838693e-01f,
  2.09989354e-01f, 4.33633924e-01f, 2.09169894e-01f, 1.84232339e-01f, -5.28085172e-01f, 1.37958929e-01f, -2.84550309e-01f, 6.85377777e-01f, 1.70380846e-01f, -2.41339356e-02f,
  -1.06159136e-01f, 3.34337592e-01f, -5.02776682e-01f, 8.04503337e-02f, 3.04263890e-01f, -5.44534922e-01f, 2.34164730e-01f, 1.65502459e-01f, -2.90068924e-01f, -5.76969445e-01f,
  -2.22182408e-01f, -1.92350730e-01f, 3.06604564e-01f, -1.26776267e-02f, 3.18731278e-01f, 2.68023014e-01f, 1.43853575e-01f, 2.85030007e-01f, 2.58917481e-01f, -1.83236375e-01f,
  -6.95738271e-02f, -1.13796145e-01f, 3.61821651e-01f, 1.38041914e-01f, 1.88566789e-01f, 2.30767354e-01f, -4.93931025e-01f, 2.56209731e-01f, 2.88121134e-01f, 2.23101541e-01f,
  1.09089211e-01f, -1.45238981e-01f, 5.42030931e-02f, 5.91222167e-01f, -1.17933832e-01f, 2.47987330e-01f, 2.46672764e-01f, -1.54234162e-02f, 2.77806163e-01f, -1.79912940e-01f,
  -1.96642518e-01f, -1.41208380e-01f, -7.37821683e-02f, 6.63280785e-02f, 3.16476017e-01f, -1.29530862e-01f, -2.19506264e-01f, -1.55632883e-01f, 2.78441787e-01f, 7.54343331e-01f,
  -1.15117878e-01f, 2.59288013e-01f, -1.06292740e-01f, -2.98058934e-04f, 9.14113522e-02f, 4.12025541e-01f, 2.30051413e-01f, 1.73167735e-01f, -1.22485086e-01f, 2.47455627e-01f,
  -2.47875199e-01f, 4.58129138e-01f, 1.05392218e-01f, 4.46781397e-01f, -2.48133261e-02f, -1.88666210e-01f, -4.57341284e-01f, 2.26207688e-01f, -2.01054648e-01f, -3.26248378e-01f,
  1.08197235e-01f, 7.04432130e-02f, -1.58252329e-01f, -5.46001911e-01f, -2.57497847e-01f, -1.76749140e-01f, 1.90727547e-01f, 1.27226785e-01f, 2.12513790e-01f, 7.05312267e-02f,
  2.95372844e-01f, 3.34390461e-01f, 4.85036552e-01f, -1.30939946e-01f, 2.45358676e-01f, 3.62609208e-01f, 4.78443831e-01f, -2.21609831e-01f, 2.16760665e-01f, -7.62545094e-02f,
  3.61494757e-02f, -3.34196031e-01f, -8.55577439e-02f, -1.47455797e-01f, -3.51815641e-01f, -6.46407187e-01f, -4.14712220e-01f, -2.26028740e-01f, 5.26046418e-02f, -1.37168854e-01f,
  1.26699865e-01f, 3.03636432e-01f, 2.94513285e-01f, -2.28125751e-01f, 2.70680010e-01f, 2.91068226e-01f, -1.17252834e-01f, 3.81687246e-02f, -1.95124194e-01f, -2.41647035e-01f,
  -8.79677609e-02f, -1.91101320e-02f, -2.40658391e-02f, 6.17436245e-02f, -1.74475878e-01f, 2.67370611e-01f, 8.03282931e-02f, 2.89387167e-01f, 2.41298199e-01f, 4.58092928e-01f,
  2.27740973e-01f, 2.80940175e-01f, 1.13040321e-01f, -2.55371213e-01f, -2.92537481e-01f, -1.81313470e-01f, -2.82818913e-01f, -7.91935846e-02f, -5.85789800e-01f, -3.38368565e-01f,
  1.06395893e-01f, -3.19319777e-02f, 2.81301141e-01f, 2.38189355e-01f, 2.76408195e-01f, 8.95025581e-02f, 1.45053178e-01f, 2.35674810e-02f, -1.38290271e-01f, -2.52336133e-02f,
  -3.38936038e-02f, -1.53068155e-01f, -5.63260242e-02f, -7.17262924e-02f, 3.88143621e-02f, 2.25876257e-01f, -2.46616840e-01f, 3.79981428e-01f, 1.44173980e-01f, 1.56533509e-01f,
  2.46393740e-01f, 4.04497176e-01f, 4.25219029e-01f, 5.51589906e-01f, 7.86323100e-02f, 5.79492271e-01f, -3.57947103e-03f, -7.92251527e-02f, 4.55852151e-01f, 7.11849391e-01f,
  3.53996456e-01f, 3.08270335e-01f, 5.48371254e-03f, 1.17404312e-01f, 1.82668030e-01f, -1.03164226e-01f, 3.58501524e-02f, 2.99915969e-01f, -9.68446359e-02f, 1.42958015e-01f,
  2.24940211e-01f, 2.49247625e-01f, 2.36473724e-01f, 5.14312685e-01f, 2.06041723e-01f, 3.24050360e-03f, -2.76853926e-02f, 2.04099447e-01f, 4.86688495e-01f, 3.12314421e-01f,
  1.03386573e-01f, 2.36426100e-01f, 2.44212598e-01f, -1.91018935e-02f, 2.61709273e-01f, -1.18230462e-01f, -7.97507539e-02f, 3.20141762e-02f, 1.49143100e-01f, -2.42499471e-01f,
  -3.29828449e-02f, 5.86523600e-02f, -2.78482854e-01f, 2.52602875e-01f, 8.02349485e-03f, -1.46052152e-01f, 1.20961167e-01f, 2.58584291e-01f, 2.59792387e-01f, 2.32905000e-01f,
  -3.11109424e-01f, 2.80901015e-01f, 1.55045241e-01f, 5.81205934e-02f, -6.42371550e-02f, -2.82193929e-01f, 2.01670766e-01f, -1.64113015e-01f, -6.11882269e-01f, -5.61909168e-04f,
  -2.03092888e-01f, 3.65715474e-01f, 4.62760031e-02f, 2.23177239e-01f, 1.58533499e-01f, -1.37375534e-01f, 1.88422114e-01f, -4.03492637e-02f, 5.71541965e-01f, 2.40935043e-01f,
  -5.19444942e-01f, -1.23617023e-01f, 4.29497331e-01f, 9.46283117e-02f, -5.36309958e-01f, -1.66640088e-01f, -7.50398859e-02f, 2.59365767e-01f, -2.22105533e-01f, -6.97542503e-02f,
  -3.45203906e-01f, 4.01960969e-01f, 2.42381066e-01f, -1.34477183e-01f, 6.01207875e-02f, 3.67214441e-01f, 9.01043415e-02f, 3.99333447e-01f, 4.55963343e-01f, 1.34559259e-01f,
  2.54740089e-01f, -3.87735665e-01f, 3.52062523e-01f, -5.93148768e-02f, 5.02462208e-01f, 2.93048352e-01f, 8.78241062e-02f, 3.53666425e-01f, 2.72764474e-01f, 1.70310870e-01f,
  8.62040147e-02f, 4.22315262e-02f, -2.21387058e-01f, 4.25441474e-01f, -4.42694575e-01f, -2.91065335e-01f, -4.71700251e-01f, -5.17330766e-01f, 2.82939505e-02f, -3.09525013e-01f,
  -2.75999829e-02f, -9.44552869e-02f, 2.74369679e-02f, 3.40711892e-01f, 4.71194774e-01f, -1.11273237e-01f, -1.17787257e-01f, 8.84791166e-02f, 1.13393717e-01f, 1.65649712e-01f,
  2.54733801e-01f, 1.97865129e-01f, 4.72892463e-01f, 1.32973537e-01f, 1.85452342e-01f, -2.52069294e-01f, 7.02720741e-03f, -7.92382509e-02f, 8.94603282e-02f, 6.58433363e-02f,
  1.08325668e-01f, -3.10631305e-01f, -6.15892053e-01f, -2.64119059e-01f, -6.26168177e-02f, 3.54101717e-01f, -2.28700817e-01f, -3.21129531e-01f, 3.73377688e-02f, 9.26599279e-02f,
  -4.01327640e-01f, 2.75769562e-01f, 3.15077335e-01f, -2.34660767e-02f, 3.41046840e-01f, -4.59078372e-01f, 1.78066999e-01f, 1.88384615e-02f, -6.67686999e-01f, -4.16963518e-01f,
  1.92952603e-02f, -6.13390617e-02f, -1.35356456e-01f, 3.06509167e-01f, 4.39914316e-01f, 2.46317282e-01f, 1.69602945e-01f, -2.23167315e-01f, 4.20555353e-01f, 1.75318271e-01f,
  3.10524716e-03f, 2.62899399e-01f, 8.76922905e-02f, -1.93082973e-01f, -2.29847327e-01f, -5.40603459e-01f, -1.25586987e-01f, -1.50640205e-01f, -5.39833426e-01f, -1.95481684e-02f,
  -1.33308545e-01f, -5.72154760e-01f, 1.86538354e-01f, -2.60272045e-02f, -6.56180978e-01f, -1.53655494e-02f, -2.09191605e-01f, -7.96473846e-02f, 3.79953235e-01f, -1.58192307e-01f,
  -6.81264758e-01f, -3.52290571e-01f, -2.12688625e-01f, 1.62684441e-01f, 5.88333514e-03f, 1.63823873e-01f, 4.49416861e-02f, -2.09693521e-01f, 1.83659375e-01f, -3.86485010e-01f
};

// L2_fan_Bp_bar (Shape: 1 x 20)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 20;
const float L2_fan_Bp_bar_data[] = {
  -1.20551109e-01f, -1.26563162e-01f, 1.34640196e-02f, -4.76669567e-03f, 1.49938136e-01f, 2.76571929e-01f, 6.71738237e-02f, -1.72404170e-01f, 2.21230775e-01f, 1.20119207e-01f,
  1.33301571e-01f, 2.43114755e-01f, 2.43620977e-01f, 1.41356587e-01f, 1.78831249e-01f, 1.97269723e-01f, 6.04160093e-02f, 3.55033576e-01f, 9.77300256e-02f, 3.38903427e-01f
};

// L3_fan_Wp (Shape: 6 x 32)
const int L3_fan_Wp_rows = 6;
const int L3_fan_Wp_cols = 32;
const float L3_fan_Wp_data[] = {
  1.81903213e-01f, -1.55042186e-01f, -2.26363376e-01f, 2.06868619e-01f, 2.27839530e-01f, -2.17401698e-01f, 6.95650056e-02f, -2.33967714e-02f, -1.57588422e-01f, 1.75691452e-02f,
  3.83953929e-01f, 2.27892578e-01f, 4.45659794e-02f, -6.45963550e-02f, -1.88691378e-01f, 4.64957170e-02f, 1.37249142e-01f, -4.78274412e-02f, -2.13311315e-01f, -1.01291105e-01f,
  9.51052010e-02f, 1.41648382e-01f, 4.53001037e-02f, -9.67871770e-03f, -5.42373024e-02f, 4.09336537e-02f, 1.79919645e-01f, -4.85155210e-02f, -2.86775474e-02f, -1.88302875e-01f,
  -3.27270404e-02f, -1.69055089e-01f, -8.83810520e-02f, -5.17912388e-01f, 1.99418351e-01f, 2.21321523e-01f, 5.78504086e-01f, -1.27682358e-01f, 2.10490629e-01f, -3.19712400e-01f,
  3.58652890e-01f, 4.14517134e-01f, 9.84035730e-02f, -3.82649489e-02f, -1.03876732e-01f, -2.40250334e-01f, 7.93916583e-02f, -4.73737568e-02f, 2.30363667e-01f, -2.07154691e-01f,
  2.66009066e-02f, 2.85787266e-02f, -3.60304788e-02f, 2.90309370e-01f, 1.96343467e-01f, 6.49437425e-04f, -1.06542252e-01f, -3.44914421e-02f, 9.06798057e-03f, -1.42863825e-01f,
  -1.28032312e-01f, 1.53022528e-01f, -5.44033907e-02f, -3.76724660e-01f, 1.26611575e-01f, -6.80096895e-02f, -5.01362234e-02f, -6.05543330e-02f, 4.52012010e-03f, -4.15788628e-02f,
  -3.04453433e-01f, 1.23205788e-01f, 3.38615239e-01f, -2.17110097e-01f, 1.71642259e-01f, -2.25267395e-01f, 5.30355833e-02f, -6.12210780e-02f, -1.11634284e-01f, -2.14208722e-01f,
  1.36987120e-01f, -1.29830301e-01f, -1.04674444e-01f, 1.29824623e-01f, 3.74589674e-02f, -9.90164280e-03f, 1.63498789e-01f, -1.29280398e-02f, 1.31696491e-02f, -4.68691401e-02f,
  1.18810326e-01f, 1.06015973e-01f, -6.97982460e-02f, 2.63824742e-02f, -2.29882926e-01f, 2.29248293e-02f, -2.95830071e-01f, -6.09233491e-02f, -1.37157932e-01f, -2.49149084e-01f,
  -1.64620489e-01f, 3.90037060e-01f, -6.72647804e-02f, 8.26639235e-02f, -1.37368932e-01f, -3.54203194e-01f, -3.26512814e-01f, -1.78652495e-01f, -1.93457887e-01f, -7.87413940e-02f,
  1.30868442e-02f, 1.02481499e-01f, 1.14109062e-01f, -1.36029527e-01f, 9.20911729e-02f, -1.06095575e-01f, 2.51302838e-01f, 1.75265059e-01f, 1.57676816e-01f, 1.56519353e-01f,
  -2.94792503e-01f, -1.87405750e-01f, -1.47071660e-01f, -3.13318819e-01f, 2.45116577e-01f, 3.84899564e-02f, -2.70682685e-02f, 9.04511660e-03f, 5.51158451e-02f, 1.97488204e-01f,
  -1.67874377e-02f, -2.51804352e-01f, -1.48330271e-01f, 2.40858644e-01f, 9.42368582e-02f, 2.38111332e-01f, 9.04364809e-02f, -2.00719506e-01f, -1.59584209e-01f, 2.02887617e-02f,
  1.01078816e-01f, -2.77927101e-01f, 3.77776660e-02f, 1.12190917e-01f, 1.47431687e-01f, -2.76858747e-01f, 1.18571445e-01f, -3.78329270e-02f, -3.16111520e-02f, -3.05833714e-03f,
  -1.19743213e-01f, -1.39615119e-01f, 2.67806910e-02f, 1.41469717e-01f, 1.18196152e-01f, 1.69468939e-01f, -4.91454303e-02f, -1.28008634e-01f, -2.98427731e-01f, -5.83066978e-02f,
  6.71098769e-01f, 6.31871104e-01f, 1.96849734e-01f, -2.72515088e-01f, -1.30227625e-01f, 2.82836080e-01f, -1.30066901e-01f, 2.95850903e-01f, -9.93492380e-02f, -7.88118243e-02f,
  -6.13957755e-02f, -4.06818360e-01f, -1.73893452e-01f, 1.35502577e-01f, -1.07195072e-01f, -8.28855857e-02f, 5.62792160e-02f, 9.23631564e-02f, -3.88904922e-02f, -1.02383718e-01f,
  -1.91815063e-01f, 5.18309064e-02f, -1.06141634e-01f, -4.05154340e-02f, -3.15071046e-01f, -8.43808278e-02f, -8.90268665e-03f, 1.39568880e-01f, 7.84257054e-03f, -4.73185591e-02f,
  -1.78925612e-03f, 4.72746581e-01f
};

// L3_fan_Wp_bar (Shape: 20 x 32)
const int L3_fan_Wp_bar_rows = 20;
const int L3_fan_Wp_bar_cols = 32;
const float L3_fan_Wp_bar_data[] = {
  3.80114555e-01f, 2.60116637e-01f, 1.31370246e-01f, -2.78808773e-01f, -3.20277922e-02f, -3.61171454e-01f, 4.82429527e-02f, 6.40222132e-02f, 1.43917307e-01f, 6.01615965e-01f,
  1.59969032e-01f, -2.40798146e-01f, 4.42525186e-02f, 2.22300425e-01f, 3.26300502e-01f, 1.00760221e-01f, -1.32092729e-01f, 4.10745054e-01f, 3.14008623e-01f, 1.36191532e-01f,
  -3.30871403e-01f, -3.21213156e-01f, -3.50548148e-01f, -7.51252249e-02f, 3.14592272e-02f, 2.19729766e-01f, 1.04877867e-01f, 2.91218549e-01f, 6.39919192e-02f, 7.26337582e-02f,
  2.60369498e-02f, 1.07442819e-01f, -1.48095131e-01f, -9.45668593e-02f, -1.18242763e-01f, -1.44389793e-01f, -1.60918072e-01f, -2.23693341e-01f, -1.93809718e-01f, 5.21510839e-01f,
  2.24233925e-01f, -3.20363343e-01f, 8.54856789e-01f, 1.59109741e-01f, 1.77041888e-01f, 1.34694636e-01f, -3.95841748e-01f, 2.88548559e-01f, 5.20200878e-02f, -3.94187957e-01f,
  3.94133627e-02f, 1.11873373e-01f, -1.91062540e-01f, 6.37188032e-02f, 3.76222700e-01f, -4.55326766e-01f, -2.43582919e-01f, 8.21718201e-02f, 3.03656340e-01f, 1.40021160e-01f,
  -8.63327757e-02f, -5.21072268e-01f, -3.70160580e-01f, 2.35139430e-01f, -1.22374445e-01f, 1.68716192e-01f, 9.73743275e-02f, -8.70650932e-02f, -3.40876311e-01f, -2.78596506e-02f,
  -8.79944488e-02f, 6.05360009e-02f, 2.06325248e-01f, 3.07833459e-02f, -1.82327449e-01f, -1.34981051e-01f, -4.20956194e-01f, -7.24435389e-01f, 3.53060067e-01f, -2.12616116e-01f,
  -1.52268156e-01f, 3.93178284e-01f, -1.48772359e-01f, -4.66305286e-01f, 5.37187934e-01f, 3.97021443e-01f, 3.62396836e-01f, 8.24332833e-02f, -3.94860804e-02f, -6.81027211e-03f,
  1.86362967e-01f, -4.22538131e-01f, 4.76034991e-02f, 3.94986361e-01f, 3.81907642e-01f, 1.11877946e-02f, 7.12496877e-01f, 3.33313704e-01f, 3.71247530e-01f, 2.62256682e-01f,
  2.34136358e-01f, 4.22433704e-01f, -6.46945357e-01f, 5.78052759e-01f, 6.95925727e-02f, 6.69230074e-02f, 9.28580165e-02f, -8.59101892e-01f, 3.65917347e-02f, -2.61833668e-01f,
  2.24881917e-01f, -7.27021620e-02f, 4.83459711e-01f, -2.08665177e-01f, -4.86935228e-02f, -1.07117161e-01f, 1.68677121e-01f, -2.97098327e-02f, -3.47419709e-01f, 2.59611547e-01f,
  -2.90979892e-01f, -4.36110109e-01f, 4.45908755e-01f, -2.32493713e-01f, 4.12815750e-01f, 2.62284458e-01f, 1.27997085e-01f, 4.88883406e-01f, -1.95940524e-01f, 4.61273305e-02f,
  8.76626447e-02f, 1.93275779e-01f, 1.11189067e-01f, -1.79357231e-02f, 1.93624958e-01f, -1.27518490e-01f, 1.64601341e-01f, -1.38038188e-01f, -1.76912948e-01f, 4.83080328e-01f,
  9.77585092e-02f, -8.63042846e-02f, 3.16458762e-01f, 1.20154060e-01f, -4.68967676e-01f, 1.51462153e-01f, 3.29927504e-01f, -3.49115580e-01f, 3.91448230e-01f, -7.73572698e-02f,
  -2.13031527e-02f, 8.88683051e-02f, 5.28859973e-01f, 3.33092988e-01f, -3.72104943e-01f, 8.58722404e-02f, -3.05252850e-01f, 9.76995081e-02f, 6.25217855e-02f, 5.22495359e-02f,
  2.75980383e-01f, 3.11539948e-01f, -5.03644953e-03f, 1.11894563e-01f, 2.87447006e-01f, -2.21026629e-01f, -2.73203850e-01f, -1.98390692e-01f, -3.93232964e-02f, 7.64822885e-02f,
  8.18497390e-02f, 2.57252514e-01f, 3.00777525e-01f, 3.56305659e-01f, -1.12771474e-01f, 1.32597208e-01f, 1.59695357e-01f, 2.62351394e-01f, -1.05878882e-01f, -6.94939718e-02f,
  7.51053989e-02f, 4.01311144e-02f, 6.16224945e-01f, -1.92435786e-01f, 3.53244603e-01f, 4.37097102e-02f, -4.50865366e-02f, 2.91167438e-01f, -3.22073966e-01f, -2.31793985e-01f,
  2.85982519e-01f, -1.87404618e-01f, 3.75504568e-02f, 1.16347463e-03f, -3.60716373e-01f, -4.67407703e-01f, -3.35609615e-02f, -5.27726352e-01f, 4.65250105e-01f, -2.26306394e-02f,
  -1.60895124e-01f, -5.08933961e-01f, 1.05310753e-01f, 2.20329389e-01f, -3.42229530e-02f, 7.39311650e-02f, 2.31383607e-01f, 2.27059469e-01f, -1.34560615e-01f, -7.01662078e-02f,
  1.48123041e-01f, 2.19267771e-01f, 2.27518491e-02f, -1.31174609e-01f, 3.94347832e-02f, 4.91770953e-02f, 1.53672650e-01f, 2.45662495e-01f, -1.05185136e-01f, 3.09479952e-01f,
  -3.09782296e-01f, -4.15076673e-01f, -1.05897747e-01f, 9.16482657e-02f, -1.37933016e-01f, 3.68768871e-01f, 1.16010301e-01f, 1.63800895e-01f, -2.33814433e-01f, -1.03107758e-01f,
  5.19812882e-01f, -4.74858850e-01f, 6.38677254e-02f, 5.34525923e-02f, -4.21617121e-01f, 2.35605687e-01f, -1.28113304e-03f, 1.57773048e-02f, 8.56071711e-01f, 2.87661493e-01f,
  -1.77335665e-01f, 2.51197308e-01f, 6.03963971e-01f, 1.73880845e-01f, -1.04760811e-01f, -7.11140260e-02f, -2.62978911e-01f, 1.37004405e-01f, 4.72445011e-01f, 4.28638846e-01f,
  1.11664288e-01f, -6.54186830e-02f, 1.70297980e-01f, 4.39970344e-01f, -3.24234702e-02f, 1.71052694e-01f, -2.57183015e-01f, -9.33601335e-02f, -4.47822027e-02f, 9.63632911e-02f,
  -5.47053695e-01f, 1.10438786e-01f, 2.56595045e-01f, 7.46957138e-02f, -1.10486424e+00f, -2.73100078e-01f, -5.18202901e-01f, 3.84790897e-01f, -1.64228946e-01f, 3.35139543e-01f,
  -9.29033160e-02f, 2.16848865e-01f, -4.17852700e-01f, 1.21460900e-01f, 1.33499727e-01f, 5.84548025e-06f, 1.92643091e-01f, 4.74281281e-01f, 3.96249115e-01f, -1.03866933e-02f,
  3.42911422e-01f, 2.25278184e-01f, -2.75627077e-01f, -2.18597967e-02f, -1.56187981e-01f, 1.21711351e-01f, 6.25901639e-01f, -1.03047363e-01f, -3.07438791e-01f, -2.64669538e-01f,
  -3.92099731e-02f, -1.79666832e-01f, 2.76049793e-01f, 2.29343876e-01f, -3.22976828e-01f, 2.14345425e-01f, 8.92236084e-02f, -1.10188060e-01f, 1.99645117e-01f, 4.24882546e-02f,
  -1.67370856e-01f, -2.23103929e-02f, -5.63296497e-01f, 1.55876547e-01f, 1.96599528e-01f, -3.37989293e-02f, -4.19818699e-01f, 9.37332809e-02f, 3.95627260e-01f, 3.42169821e-01f,
  6.68468297e-01f, 3.38030666e-01f, 1.80896834e-01f, -2.15553895e-01f, 3.24187070e-01f, -1.86773553e-01f, -5.49042318e-03f, -8.49980861e-02f, 9.09451172e-02f, -4.15987104e-01f,
  2.17961162e-01f, -1.06264561e-01f, -4.02008072e-02f, 2.86939919e-01f, 2.26266846e-01f, 1.32177815e-01f, -3.72918658e-02f, 6.32292554e-02f, 4.26902086e-01f, 1.72783852e-01f,
  4.62155074e-01f, 7.59529620e-02f, 6.36752546e-01f, 3.47206861e-01f, 1.23430513e-01f, 2.46397391e-01f, 1.80258736e-01f, -1.95874423e-01f, 1.60974458e-01f, 1.54918551e-01f,
  2.93662965e-01f, -5.44173181e-01f, 1.70128241e-01f, -2.95533299e-01f, 1.92564070e-01f, 2.59926528e-01f, 5.49468517e-01f, 4.73097503e-01f, 2.45069130e-03f, -1.12325571e-01f,
  -1.95458010e-01f, -3.12287509e-01f, 4.17107977e-02f, -9.06385258e-02f, 3.34423147e-02f, 5.19064330e-02f, 4.17903870e-01f, -3.83573711e-01f, 2.85926312e-01f, -1.93945706e-01f,
  2.98862487e-01f, -1.67268310e-02f, -3.04596841e-01f, 6.61852732e-02f, 2.18521833e-01f, 3.51743639e-01f, 9.16126668e-02f, 9.15764347e-02f, -2.37503365e-01f, 2.35001281e-01f,
  3.33203822e-01f, -2.78450906e-01f, 1.90456107e-01f, -4.38741922e-01f, -3.46383482e-01f, -2.61232346e-01f, 4.88514096e-01f, 3.55495751e-01f, 9.65302251e-03f, 4.57292311e-02f,
  -3.36653441e-01f, -3.37559193e-01f, -1.86003372e-01f, -1.68224365e-01f, 4.90471661e-01f, 3.07367444e-01f, 4.04262245e-01f, 4.96589124e-01f, 5.32484770e-01f, 3.08482945e-01f,
  -1.51906803e-01f, -5.94350815e-01f, -6.00501560e-02f, 9.13171470e-01f, -6.31718218e-01f, 1.14750657e-02f, 6.50488539e-03f, -1.88980788e-01f, -5.81788160e-02f, -2.24684060e-01f,
  1.86384410e-01f, 2.37778246e-01f, 2.16983035e-01f, -3.29625309e-01f, -1.84629768e-01f, 4.99682486e-01f, 4.73970383e-01f, 3.64069492e-01f, 1.18587695e-01f, 1.55164868e-01f,
  3.00408155e-01f, 9.99263301e-02f, -6.07880503e-02f, -1.04303777e-01f, 9.57814753e-02f, -2.33412489e-01f, -4.19274569e-01f, 4.25276875e-01f, 7.19587924e-03f, -1.35456830e-01f,
  -9.33332369e-02f, 3.24423052e-02f, -2.00978309e-01f, -1.33701041e-01f, 9.50757623e-01f, -1.78838998e-01f, -2.07459748e-01f, -2.89585948e-01f, 2.45824568e-02f, -3.77762973e-01f,
  8.82053077e-02f, -1.30018130e-01f, -9.84208360e-02f, 3.33185107e-01f, -1.52034670e-01f, -2.06523389e-01f, 4.26194072e-01f, -2.87968963e-01f, 1.26116589e-01f, -3.00803240e-02f,
  1.75104395e-01f, 1.68868199e-01f, 4.93311957e-02f, -1.88713044e-01f, -3.80525857e-01f, 3.44069570e-01f, 1.38978809e-01f, -1.27764598e-01f, 3.17572892e-01f, -2.35495463e-01f,
  -5.96162584e-03f, 6.24547005e-01f, -2.31747869e-02f, 8.66453499e-02f, 5.35898983e-01f, -3.57785851e-01f, -5.10302961e-01f, 3.24046105e-01f, -1.77089006e-01f, 5.58185995e-01f,
  -7.62195885e-01f, -3.02354485e-01f, 9.54168364e-02f, 2.64819432e-03f, -2.68744469e-01f, 9.28210393e-02f, -8.34994391e-03f, -2.44315356e-01f, -8.21895897e-02f, 3.81771237e-01f,
  3.53666171e-02f, 2.75702208e-01f, 2.55564600e-01f, 5.17577976e-02f, 8.35358724e-03f, -6.22571528e-01f, 5.83833605e-02f, 1.01817325e-01f, 3.77913684e-01f, 1.76107198e-01f,
  7.51444474e-02f, 6.79678977e-01f, 5.28813779e-01f, 3.87427807e-02f, -1.27138272e-01f, 3.14757943e-01f, 4.06660363e-02f, 2.24881079e-02f, -1.42785488e-02f, 6.45149127e-02f,
  -7.06701577e-01f, -2.48667017e-01f, -9.58790258e-02f, -2.55441785e-01f, 3.61815602e-01f, 1.24756269e-01f, 3.14167559e-01f, 1.24101840e-01f, 1.81184396e-01f, -1.80957928e-01f,
  5.21211438e-02f, 1.48344442e-01f, -1.20875835e-01f, 3.39479864e-01f, 1.01010405e-01f, 2.15473533e-01f, 6.32156134e-02f, -2.82426208e-01f, 1.46930277e-01f, 3.63408267e-01f,
  4.74923588e-02f, 3.67181331e-01f, -4.67557199e-02f, 7.91218430e-02f, 2.08310947e-01f, 1.09126553e-01f, -1.13547601e-01f, 3.86461198e-01f, -1.68872386e-01f, 4.71034050e-01f,
  2.22400144e-01f, -4.52440381e-01f, -2.66071670e-02f, -3.38008463e-01f, 3.85444015e-01f, 2.18541458e-01f, 4.77833152e-02f, 5.03856838e-01f, 3.79075825e-01f, -1.26466736e-01f,
  2.74251878e-01f, 3.89490753e-01f, -2.25056782e-01f, -1.23393506e-01f, -1.26831427e-01f, 8.32868293e-02f, -3.73684824e-01f, 1.02247626e-01f, 1.84849590e-01f, -1.24727055e-01f,
  4.44239855e-01f, 3.19994360e-01f, -2.96323746e-01f, 1.73763391e-02f, -4.66439039e-01f, -8.10306296e-02f, 1.39515370e-01f, -9.10748914e-03f, 7.44399801e-02f, 4.21801835e-01f,
  4.68648285e-01f, -4.05653208e-01f, 2.70086437e-01f, 1.42906561e-01f, -1.74936906e-01f, 4.82201546e-01f, 1.63372353e-01f, 5.74748851e-02f, 4.47787851e-01f, 1.78534299e-01f,
  -2.66273022e-01f, 1.55012906e-01f, 8.68307129e-02f, 5.30168489e-02f, 2.66702473e-01f, -2.47440815e-01f, 1.59594372e-01f, -2.27448225e-01f, 4.24488895e-02f, 2.47140795e-01f,
  -4.13061725e-03f, -5.00956364e-03f, -6.38357475e-02f, 3.49120080e-01f, 6.97866827e-02f, -2.89050281e-01f, 1.89610109e-01f, -1.24731019e-01f, 1.27428174e-01f, -2.37158939e-01f,
  -1.56076610e-01f, 4.15241271e-01f, -7.88189098e-02f, 7.38585964e-02f, 5.09023666e-02f, 6.06586277e-01f, 3.42514589e-02f, 8.44280347e-02f, 2.23390698e-01f, 7.08868504e-02f,
  1.64745599e-02f, -1.83449388e-02f, 4.42496575e-02f, 3.50246519e-01f, 1.14723884e-01f, 1.78736657e-01f, -3.67741764e-01f, -1.89619780e-01f, -4.28207874e-01f, -4.42371935e-01f,
  -3.46436918e-01f, -7.00944290e-02f, 1.31003886e-01f, -7.48338504e-03f, -2.97641456e-02f, 7.86367059e-02f, 4.08320606e-01f, -3.65540609e-02f, 3.95316660e-01f, -5.26697859e-02f,
  -1.06200635e-01f, 2.10768700e-01f, -1.62768960e-01f, 1.18735798e-01f, -6.90553412e-02f, 6.34635150e-01f, -4.66983050e-01f, -1.71098739e-01f, 5.37949443e-01f, -4.26683664e-01f,
  -1.63179442e-01f, 1.77965745e-01f, 3.84950250e-01f, 1.56730279e-01f, 9.25056636e-02f, -1.01709068e-01f, 2.83683777e-01f, 3.30560863e-01f, 2.63807118e-01f, 7.69150537e-03f,
  -3.68603408e-01f, 1.73215881e-01f, -1.39389530e-01f, -3.28239530e-01f, -1.50755703e-01f, 1.99980050e-01f, 4.63316739e-01f, 3.32494378e-01f, 3.37948263e-01f, 5.81516981e-01f
};

// L3_fan_Bp_bar (Shape: 1 x 20)
const int L3_fan_Bp_bar_rows = 1;
const int L3_fan_Bp_bar_cols = 20;
const float L3_fan_Bp_bar_data[] = {
  -9.13021527e-03f, -7.48498738e-02f, 6.53640479e-02f, 4.88350034e-01f, -1.39675543e-01f, 5.39269000e-02f, -1.88040420e-01f, -1.43741677e-02f, 5.60323372e-02f, -2.08422318e-02f,
  2.18516067e-01f, -6.50627678e-03f, 1.06379151e-01f, 7.45079387e-03f, 2.51311719e-01f, 4.53186691e-01f, 1.87787682e-01f, 1.51024461e-01f, 2.05590218e-01f, 3.68980542e-02f
};

// L4_linear_W (Shape: 12 x 32)
const int L4_linear_W_rows = 12;
const int L4_linear_W_cols = 32;
const float L4_linear_W_data[] = {
  -3.42402495e-02f, -4.18434173e-01f, 1.52043819e-01f, 1.01292558e-01f, -4.30909023e-02f, -2.54276395e-01f, -3.58031429e-02f, 3.76767129e-01f, 2.20174611e-01f, -1.78612337e-01f,
  -1.60347179e-01f, -6.12698570e-02f, 1.97958738e-01f, 1.71508938e-01f, -1.73366621e-01f, -6.31010771e-01f, -2.31167346e-01f, 7.68536180e-02f, 5.12970924e-01f, 1.66475132e-01f,
  -3.68604273e-01f, -5.25798798e-01f, 8.41045082e-02f, -8.24103504e-02f, -7.36662805e-01f, -1.78684443e-01f, -4.38309498e-02f, -2.44779170e-01f, 1.90792754e-01f, -8.85151401e-02f,
  -1.20360879e-02f, 8.13104957e-02f, -4.89160627e-01f, -5.45362197e-02f, -2.73111075e-01f, -2.40572542e-01f, -4.00023498e-02f, 2.08794668e-01f, 3.10575247e-01f, -3.61926436e-01f,
  -5.09687960e-02f, -1.88693274e-02f, 1.16290692e-02f, 5.24094641e-01f, 1.02246128e-01f, -2.88001120e-01f, 2.78311998e-01f, -1.66853681e-01f, 3.82764608e-01f, -2.36134246e-01f,
  2.77259201e-01f, 2.80025363e-01f, 2.91333366e-02f, -1.84446901e-01f, 2.68591847e-02f, 2.46619627e-01f, -6.41648293e-01f, 3.58232796e-01f, -4.21630144e-02f, 4.87264320e-02f,
  -1.52460605e-01f, 2.11454555e-01f, -8.92220181e-04f, 2.64725477e-01f, -1.02175862e-01f, -1.14103414e-01f, 9.33763012e-02f, 5.27454197e-01f, -8.77469480e-02f, -1.83942258e-01f,
  -4.34642255e-01f, 1.58091605e-01f, -5.16893804e-01f, 5.09301841e-01f, 1.23515159e-01f, -3.11344832e-01f, 2.03309283e-01f, -4.35437918e-01f, -4.51606840e-01f, -7.60374917e-03f,
  -3.21573794e-01f, -5.87880015e-01f, -1.84887633e-01f, 3.76949757e-01f, -1.89628810e-01f, -5.91531932e-01f, -2.93141127e-01f, -2.97325104e-01f, -9.69277471e-02f, -5.26903927e-01f,
  -7.29776978e-01f, 1.14931576e-01f, 3.62012029e-01f, 2.38345131e-01f, 3.60926807e-01f, 1.32548169e-03f, -1.13249049e-01f, 1.06948793e-01f, -2.02287268e-02f, 2.64333710e-02f,
  1.93573311e-01f, -3.43570799e-01f, -8.06477293e-02f, 1.37144059e-01f, 5.85546382e-02f, 1.62875280e-01f, 9.10338685e-02f, -1.40169874e-01f, -1.65807009e-01f, 2.84772277e-01f,
  -4.27740626e-02f, -7.05204844e-01f, -1.71358377e-01f, 2.60976166e-01f, 1.13576971e-01f, -4.21312660e-01f, 6.76294463e-03f, 3.79485220e-01f, 9.60292220e-02f, -3.21875513e-01f,
  -2.25854680e-01f, -1.90544590e-01f, -1.76914185e-01f, -3.52914900e-01f, 1.10796511e-01f, 1.74687669e-01f, -2.06708714e-01f, -5.53983808e-01f, -1.24673963e-01f, 2.79686898e-01f,
  -1.23935498e-01f, -1.21499799e-01f, -4.99427825e-01f, 6.40147030e-01f, 4.44480926e-01f, -3.14749032e-01f, 1.53273389e-01f, -4.93706703e-01f, 3.53066862e-01f, 1.32107303e-01f,
  1.37473002e-01f, 9.88491997e-02f, 9.84468758e-02f, 1.63215637e-01f, -2.33339414e-01f, 3.63250053e-03f, -2.97010541e-01f, -2.98068553e-01f, -6.53510019e-02f, -1.23274647e-01f,
  1.46106765e-01f, -4.77513254e-01f, -6.29070699e-02f, 7.97299221e-02f, 2.61856288e-01f, -4.71776694e-01f, 1.71728626e-01f, -2.54751772e-01f, 3.32343489e-01f, 1.90636963e-01f,
  5.77171326e-01f, 3.38868320e-01f, 3.19153041e-01f, -2.15462625e-01f, 1.21642955e-01f, 1.42226204e-01f, -3.98699671e-01f, -1.13207333e-01f, 4.61180843e-02f, -7.66048208e-02f,
  7.16353655e-01f, -4.20294613e-01f, 2.08284020e-01f, -2.13101208e-01f, 8.26934800e-02f, -5.02025075e-02f, 8.69414583e-02f, 9.01973099e-02f, 5.04572727e-02f, 1.75449133e-01f,
  -6.14986718e-01f, -3.19517791e-01f, 2.03065366e-01f, 1.98949024e-01f, 5.51666260e-01f, 2.14374959e-01f, -3.79502773e-01f, -3.00349407e-02f, -1.40686452e-01f, 9.11515057e-02f,
  1.82653144e-02f, -4.49115962e-01f, 3.20301717e-03f, 4.16293651e-01f, 1.52218238e-01f, -2.46176720e-01f, 3.09717655e-01f, -3.19911718e-01f, -2.57101864e-01f, -1.11077182e-01f,
  -1.79305986e-01f, -4.24194902e-01f, -4.85677980e-02f, 5.56188643e-01f, 6.74673617e-02f, 1.54826760e-01f, 1.59747135e-02f, 3.28795969e-01f, -2.13812739e-01f, -1.55697942e-01f,
  -3.21515650e-01f, 2.65118122e-01f, -4.75830525e-01f, -3.29844028e-01f, -7.13842750e-01f, -4.90426570e-02f, 1.82545185e-01f, -5.43252349e-01f, 2.63006061e-01f, 2.88953066e-01f,
  5.50521202e-02f, -8.73372018e-01f, -3.66254687e-01f, 1.95630357e-01f, -3.45168203e-01f, -2.74644315e-01f, 1.65942207e-01f, 2.09054202e-01f, -2.54656672e-01f, -3.45861137e-01f,
  -5.10597154e-02f, -2.44530424e-01f, -2.34239712e-01f, -2.44658709e-01f, 1.53492600e-01f, 2.05986395e-01f, 7.70159513e-02f, -1.25151053e-01f, 2.84346104e-01f, -5.69030158e-02f,
  -3.64608914e-01f, 5.14036641e-02f, -2.80296594e-01f, -6.39115810e-01f, 3.88362139e-01f, 2.74597526e-01f, -4.41415042e-01f, -1.73491687e-01f, 2.48693153e-01f, -2.38407969e-01f,
  2.40236357e-01f, 1.60207525e-02f, -5.01506686e-01f, -2.80805886e-01f, 5.21179996e-02f, 4.17522602e-02f, -5.39659448e-02f, 3.81003141e-01f, -3.32962781e-01f, 1.90076083e-01f,
  -2.60378029e-02f, 9.67709869e-02f, -3.35311890e-02f, 6.86612189e-01f, 2.80206855e-02f, -1.30604133e-01f, -2.68797725e-01f, -3.65865052e-01f, -1.40237376e-01f, -4.41384278e-02f,
  1.51420191e-01f, -6.12555087e-01f, 2.00044185e-01f, 3.79950018e-03f, -1.81453794e-01f, 2.56307989e-01f, 3.22935373e-01f, -2.59173095e-01f, -7.12512612e-01f, -1.74560055e-01f,
  4.13383752e-01f, 6.17998317e-02f, 5.40852129e-01f, 4.00184654e-02f, -6.53145134e-01f, 1.58942237e-01f, -2.64713038e-02f, -3.80288988e-01f, 7.55354986e-02f, -6.69764221e-01f,
  -7.34138116e-03f, 2.55942732e-01f, 1.05592115e-02f, -1.25251397e-01f, 2.91607261e-01f, 1.00011468e-01f, 1.01563640e-01f, 3.96117777e-01f, 5.30113280e-01f, -2.10191071e-01f,
  -5.53329408e-01f, -5.51106393e-01f, -2.37175614e-01f, 3.32965523e-01f, -9.09705460e-02f, -8.81134748e-01f, -1.14249378e-01f, -1.75004438e-01f, 3.58396620e-01f, 3.10233742e-01f,
  2.72376817e-02f, -4.12759781e-01f, -8.40342790e-02f, -4.14901108e-01f, 1.24774344e-01f, 1.32310107e-01f, 3.08708966e-01f, -2.27992535e-01f, -4.01564598e-01f, 2.36916631e-01f,
  1.43895239e-01f, -3.46167028e-01f, -2.12174907e-01f, -5.38282841e-02f, -4.56724495e-01f, -1.30641982e-01f, -7.99696594e-02f, -1.72435477e-01f, -5.10084396e-03f, -3.35982114e-01f,
  -4.86023992e-01f, -2.00451314e-01f, 9.01991129e-02f, -5.14587939e-01f, -6.28340364e-01f, -3.75944108e-01f, 1.94376037e-01f, 3.02774757e-01f, 1.55692711e-01f, 5.98525219e-02f,
  5.88997364e-01f, 2.49148116e-01f, -1.10481985e-01f, 2.73320913e-01f, 2.80360729e-01f, -3.91487330e-01f, -1.19645551e-01f, -8.60302508e-01f, -6.93784833e-01f, -1.18055604e-01f,
  -2.66503483e-01f, -4.21748877e-01f, 1.35407984e-01f, 3.44529450e-01f, 9.13959220e-02f, -4.61110801e-01f, 1.63911238e-01f, 2.74271369e-01f, 4.20660436e-01f, 5.69462359e-01f,
  6.15581751e-01f, 5.36628306e-01f, -5.33627748e-01f, 3.73857558e-01f, -7.22209215e-01f, -4.81371194e-01f, 3.12962651e-01f, 2.27134690e-01f, -3.64818066e-01f, -1.38309047e-01f,
  6.53752685e-02f, -4.57112193e-01f, -3.09903592e-01f, 2.63429761e-01f, -3.76532286e-01f, -2.27875113e-02f, 2.98674136e-01f, 6.57419622e-01f, -4.28242415e-01f, 2.10098982e-01f,
  -1.45385936e-01f, -3.61185402e-01f, -6.29631519e-01f, -2.44860202e-01f
};

// L4_linear_B (Shape: 1 x 12)
const int L4_linear_B_rows = 1;
const int L4_linear_B_cols = 12;
const float L4_linear_B_data[] = {
  3.02136820e-02f, -6.44225907e-03f, -3.69779244e-02f, -1.35877848e-01f, -7.61560202e-02f, 1.35995775e-01f, -8.31380114e-02f, -1.21144123e-01f, -3.23795108e-03f, 2.20956340e-01f,
  7.04674646e-02f, 1.32468224e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 6, 20
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        32, 6, 20
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        32, 6, 20
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L3_fan_Wp_data, L3_fan_Wp_bar_data, L3_fan_Bp_bar_data,
        32, 6, 20
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 4: L4_linear
    linear_forward_pgm(
        buffer1, x_out,
        L4_linear_W_data, L4_linear_B_data,
        32, 12
    );
    }
    