/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 16 (x2)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 16;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    static inline float fan_activation(float x) { return x; }

    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 4 x 120)
const int L0_fan_Wp_rows = 4;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -2.76999503e-01f, -2.33148083e-01f, -2.20836520e-01f, -3.57517377e-02f, 1.00641586e-01f, -2.27645576e-01f, 2.38400791e-02f, -1.34695932e-01f, -2.73533970e-01f, -3.41291018e-02f,
  3.24875504e-01f, -8.49652141e-02f, 8.02536532e-02f, -3.14599946e-02f, 1.30236000e-01f, -1.12946071e-01f, -4.68111001e-02f, -5.50787784e-02f, -1.99621141e-01f, -1.14436984e-01f,
  -8.58328268e-02f, 1.37600675e-01f, 1.84455644e-02f, -9.16206930e-03f, -6.69099092e-02f, -9.86441150e-02f, 2.19048962e-01f, 3.94771770e-02f, 1.17017895e-01f, 6.73241019e-02f,
  4.20033596e-02f, -1.17548980e-01f, -4.18448932e-02f, -1.38854846e-01f, 8.05614749e-04f, 8.16596299e-02f, 7.11542591e-02f, 5.21607772e-02f, 2.89587118e-03f, -5.37372008e-02f,
  5.57132214e-02f, -2.74823848e-02f, -8.57588369e-03f, -1.33563420e-02f, -3.26455534e-02f, 2.55779573e-03f, 1.80699211e-02f, 1.99361537e-02f, -5.99020608e-02f, -4.63721156e-03f,
  -3.62337157e-02f, 1.24183014e-01f, -1.46869505e-02f, 1.08639458e-02f, -2.25426462e-02f, 5.83127094e-03f, 3.96459922e-02f, 4.78191115e-02f, 5.42356186e-02f, -7.69540295e-02f,
  6.68545514e-02f, -5.54326735e-02f, -1.10265128e-02f, 3.83931138e-02f, -5.58493286e-03f, 4.23093885e-02f, -2.69306311e-03f, 6.33603111e-02f, -3.32768224e-02f, 5.55144250e-02f,
  6.41338974e-02f, 3.72886956e-02f, -3.56588722e-03f, -4.25647236e-02f, 1.15003223e-02f, -3.19478810e-02f, 5.17482832e-02f, -5.12496307e-02f, -4.77514900e-02f, 6.71435520e-02f,
  -1.68665051e-02f, -3.36215384e-02f, 4.00213897e-02f, 6.42606542e-02f, 8.90361611e-03f, 8.71812552e-03f, -6.90455688e-03f, -4.54991451e-03f, -5.88871427e-02f, 7.54232779e-02f,
  4.31348644e-02f, -7.79859722e-02f, 9.25815839e-04f, 5.48830740e-02f, 7.20715970e-02f, 1.00356555e-02f, -8.35024565e-02f, -4.40934720e-03f, 5.31548448e-03f, -4.06452734e-03f,
  1.12549178e-02f, 1.76041462e-02f, -3.75505583e-03f, 1.14728538e-02f, 5.40787354e-02f, 1.71078872e-02f, -5.77245979e-03f, 5.67488037e-02f, 6.52870983e-02f, 7.36364573e-02f,
  1.18372723e-01f, -1.08531187e-03f, 2.35681962e-02f, -1.62481107e-02f, 2.99248043e-02f, 8.98299366e-02f, -6.55028373e-02f, -1.02616325e-02f, 3.89204845e-02f, -5.90488128e-03f,
  4.59871553e-02f, 2.20267490e-01f, 7.25257993e-02f, -2.71931499e-01f, -6.60367981e-02f, -3.20382565e-01f, -3.26132685e-01f, -3.46556492e-02f, -2.70809412e-01f, 2.39921436e-02f,
  -9.37679112e-02f, -1.10032372e-01f, 5.74789159e-02f, -2.96933562e-01f, -3.78656209e-01f, -8.11064094e-02f, -2.75453210e-01f, -1.01589136e-01f, 3.30010466e-02f, -3.03910840e-02f,
  -4.53349389e-02f, -1.51324987e-01f, 1.37851415e-02f, 8.79922584e-02f, -5.11996336e-02f, 1.30445808e-01f, 1.55662745e-01f, 8.50206986e-02f, 6.13426641e-02f, -6.49847165e-02f,
  1.32685930e-01f, -8.06033332e-03f, 7.42419288e-02f, 8.57599378e-02f, -8.19218345e-03f, 3.68981846e-02f, 6.29298016e-02f, 1.03957541e-02f, -3.82877104e-02f, -1.70924477e-02f,
  1.75920315e-02f, -4.15801480e-02f, -7.85081238e-02f, -5.88657260e-02f, -5.86683005e-02f, -2.21212767e-03f, -1.33692613e-02f, -3.30424719e-02f, 1.80568397e-02f, -6.63476437e-02f,
  -6.03747405e-02f, 1.90831311e-02f, -1.66260116e-02f, -4.50385734e-02f, 8.56683217e-03f, -8.30767825e-02f, -1.45712523e-02f, 1.43965930e-02f, -3.10934056e-02f, -5.47699034e-02f,
  8.58814362e-03f, 4.26793583e-02f, 2.31680628e-02f, 1.03582339e-02f, -2.08128220e-03f, -3.55667919e-02f, -9.41087492e-03f, 3.90185118e-02f, -1.14697730e-02f, -1.87327620e-02f,
  -3.17015983e-02f, -5.19443341e-02f, 6.08735997e-03f, -4.04276550e-02f, -9.46379546e-03f, -2.59714536e-02f, 4.75987084e-02f, 4.19465415e-02f, -5.53147793e-02f, -4.81097363e-02f,
  -4.85979542e-02f, -2.17407458e-02f, 6.40780292e-03f, 6.05013818e-02f, -6.49567097e-02f, 2.91792583e-02f, -2.60599926e-02f, 2.83585209e-02f, 2.84907222e-02f, 1.24449767e-02f,
  7.95325711e-02f, 1.83498174e-01f, -2.43013836e-02f, -2.04638392e-02f, 7.51559157e-03f, -6.54135048e-02f, 1.27547025e-03f, -4.34104800e-02f, 5.79458475e-02f, 3.19599621e-02f,
  3.90163027e-02f, -1.30826337e-02f, 5.88828735e-02f, -4.93759327e-02f, -2.83521810e-03f, -2.59233522e-03f, 2.40705218e-02f, -1.73453242e-03f, -4.98613343e-02f, 6.45007566e-02f,
  4.71907035e-02f, 1.02490131e-02f, -5.73478779e-03f, 4.51083382e-04f, -4.83856611e-02f, 4.16121222e-02f, -1.38539532e-02f, -3.79464729e-03f, 4.97714579e-02f, -3.33363377e-02f,
  -2.12293398e-02f, 2.03209937e-01f, 1.82581022e-01f, 1.92427516e-01f, -1.16374969e-01f, 2.66536593e-01f, 4.58864927e-01f, -1.18678652e-01f, 5.79932332e-02f, 9.58234146e-02f,
  -9.94443335e-03f, 2.06833005e-01f, 1.47323817e-01f, 2.63398349e-01f, 1.64321899e-01f, 2.92093217e-01f, 1.16342604e-01f, 5.17362878e-02f, -1.02124307e-02f, -2.26889551e-03f,
  -6.30876748e-03f, 3.70664475e-03f, 1.56129166e-01f, -1.50760472e-01f, -4.10137847e-02f, -2.22363442e-01f, -1.87617853e-01f, -1.68111008e-02f, -1.27990767e-01f, -2.79150456e-02f,
  1.30244061e-01f, 4.90531065e-02f, 1.02529421e-01f, 2.04574084e-03f, 3.76354121e-02f, -2.62292046e-02f, -2.06654146e-02f, 5.27754761e-02f, -6.24694973e-02f, -9.07691102e-03f,
  5.74714988e-02f, -3.71089578e-02f, -2.79331040e-02f, 3.40334664e-04f, -2.85524670e-02f, -1.08354595e-02f, -7.49042883e-05f, 3.86492088e-02f, 2.68026236e-02f, 7.04252198e-02f,
  7.64364377e-02f, 3.63757908e-02f, -2.30323896e-02f, 7.48378877e-03f, -5.14671253e-03f, 4.56616096e-02f, 4.46992368e-02f, 2.09952500e-02f, -5.84448092e-02f, -1.10373003e-02f,
  -5.90713136e-03f, -3.15315686e-02f, -1.28488122e-02f, -5.93433790e-02f, 1.96644347e-02f, -4.45466563e-02f, 7.45826140e-02f, -1.91860292e-02f, -2.83529330e-02f, 3.07815429e-02f,
  -7.76027702e-03f, -2.09895596e-02f, -1.24708768e-02f, 3.45796458e-02f, -2.64422633e-02f, -7.29848910e-03f, 9.37238988e-03f, -2.75955256e-02f, 1.84512306e-02f, 1.74573082e-02f,
  3.26428413e-02f, -2.47896519e-02f, 4.13912535e-02f, -5.54921455e-04f, -2.20948700e-02f, -7.47963833e-03f, -1.48742078e-02f, -1.12315891e-02f, -5.30737042e-02f, 2.19505876e-02f,
  6.31024763e-02f, 4.24011573e-02f, -1.64899207e-03f, -2.77720802e-02f, 9.00613703e-03f, -1.71791781e-02f, 4.12822515e-02f, -2.58684531e-02f, -2.81422734e-02f, 2.40040626e-02f,
  -8.48278031e-02f, -5.22813410e-04f, -3.67801711e-02f, -3.36361229e-02f, -5.68547957e-02f, 1.01291817e-02f, 1.87078770e-02f, -7.36552924e-02f, -2.74040289e-02f, 1.30929593e-02f,
  -5.02633229e-02f, -5.89740761e-02f, -2.95401029e-02f, -2.16476414e-02f, -3.48166041e-02f, -2.65265331e-02f, -3.49589586e-02f, -2.74649542e-02f, -1.34620368e-02f, 6.20091222e-02f,
  3.37321311e-02f, -1.03857309e-01f, 2.32858106e-01f, -1.19536214e-01f, 5.42719057e-03f, 9.48413312e-02f, 6.46841973e-02f, -1.81310862e-01f, 7.73971528e-02f, -3.11637700e-01f,
  -1.43047616e-01f, 2.14059338e-01f, 3.54982466e-02f, -2.18765795e-01f, 3.15995008e-01f, 1.61687315e-01f, -1.31773159e-01f, -6.24949597e-02f, 9.39689726e-02f, -1.99517667e-01f,
  5.62158450e-02f, -2.86745161e-01f, 1.52560592e-01f, -2.05583021e-01f, -5.89202642e-02f, 5.42727783e-02f, -1.88195169e-01f, 3.68322507e-02f, -1.47449002e-01f, 6.88825250e-02f,
  1.54037833e-01f, -7.89582506e-02f, 7.40929469e-02f, -7.34087825e-02f, -1.05263673e-01f, 1.35562913e-02f, 1.55291762e-02f, 1.49160326e-01f, 3.90943363e-02f, 3.13457139e-02f,
  8.63008574e-02f, 2.84171999e-02f, -2.46496778e-02f, -1.00805354e-03f, -2.63521094e-02f, 4.78072390e-02f, 5.06169721e-02f, 4.53919806e-02f, 3.39032933e-02f, 9.87225696e-02f,
  4.81588878e-02f, 8.40072781e-02f, 1.90911368e-02f, 1.90903805e-02f, 1.35630950e-01f, 5.46298586e-02f, 1.71081629e-02f, 7.88994357e-02f, 1.16879949e-02f, -2.81568356e-02f,
  1.84300840e-02f, -4.84064296e-02f, 2.92557315e-03f, -2.26709805e-02f, -2.54566371e-02f, -3.57063413e-02f, -7.13110669e-03f, -7.31845498e-02f, 2.86543407e-02f, -7.55149722e-02f,
  -4.77649681e-02f, -1.37452048e-03f, -3.79707888e-02f, -3.83950491e-03f, -3.83500196e-02f, -5.15194200e-02f, 3.14075910e-02f, -5.36000654e-02f, -2.46712882e-02f, -5.02317846e-02f,
  -3.37295346e-02f, -1.37833152e-02f, -4.83330898e-02f, -9.31812637e-03f, -1.45085098e-03f, 1.83805376e-02f, -8.50959308e-03f, -1.56812984e-02f, 1.40761798e-02f, 3.44187543e-02f,
  -3.09220135e-01f, -3.56397361e-01f, 9.06315912e-03f, 4.10219096e-02f, 1.75428111e-02f, 6.02329001e-02f, 6.67419061e-02f, -4.55232784e-02f, -4.03519953e-03f, -4.25205678e-02f,
  -3.18248607e-02f, -9.80325043e-02f, 3.63394655e-02f, 1.23959538e-02f, -4.26843809e-03f, -4.38119372e-04f, -3.64450142e-02f, -3.20775658e-02f, -1.38765480e-02f, -3.08413152e-02f,
  -1.01412438e-01f, -3.46428460e-05f, 7.18613043e-02f, -4.08795141e-02f, -7.63431117e-02f, 2.87237708e-02f, 9.91963595e-03f, 2.17754655e-02f, 1.07138855e-02f, 2.31924411e-02f
};

// L0_fan_Wp_bar (Shape: 8 x 120)
const int L0_fan_Wp_bar_rows = 8;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -3.78755748e-01f, 3.54923695e-01f, 1.78944379e-01f, -1.90158591e-01f, 1.10188015e-01f, 1.04980513e-01f, -1.53891265e-01f, 9.29955542e-02f, -2.25604489e-01f, -3.40387672e-02f,
  -3.39043438e-02f, -8.90810192e-02f, 1.03781030e-01f, -3.92882451e-02f, -4.57628936e-01f, -1.64499670e-01f, -2.81946063e-01f, -1.73700333e-01f, 5.63277006e-02f, 1.37585867e-02f,
  -1.35122493e-01f, -4.28235270e-02f, 1.22535475e-01f, 3.09742630e-01f, 1.15318939e-01f, 6.67925626e-02f, -1.15208961e-01f, 2.45153710e-01f, 3.90352271e-02f, 1.32056773e-01f,
  -1.80670932e-01f, -1.93027988e-01f, 4.92276773e-02f, 4.36386839e-02f, 1.47292893e-02f, -8.37991107e-03f, -3.57263871e-02f, -6.15261719e-02f, 8.72751977e-03f, 1.46205081e-02f,
  3.13321687e-02f, 8.64360556e-02f, -6.23997897e-02f, 5.22876866e-02f, -1.55309197e-02f, 7.97187388e-02f, 6.06043749e-02f, 6.60555959e-02f, 6.43494874e-02f, 4.33506630e-02f,
  1.17333941e-01f, 6.27780259e-02f, -1.04262903e-02f, -5.22551611e-02f, -6.03493303e-04f, -8.88579618e-03f, -2.89960783e-02f, 2.13398729e-02f, 6.70879753e-03f, -4.71516550e-02f,
  6.66347472e-03f, -8.04793537e-02f, 3.36968377e-02f, 2.10847221e-02f, -3.45714092e-02f, 7.45825619e-02f, -1.19994599e-02f, -6.99526370e-02f, -3.50697041e-02f, 4.78427783e-02f,
  -3.06395739e-02f, -1.24666179e-02f, 3.99967916e-02f, -1.01420686e-01f, -6.52408898e-02f, 5.32538407e-02f, -4.67511639e-02f, 6.31770790e-02f, -2.01200545e-02f, 5.88850453e-02f,
  -4.28542309e-03f, -4.07338515e-02f, 3.77357453e-02f, -1.34419808e-02f, -4.85210717e-02f, -4.96677496e-02f, 4.13227864e-02f, 9.72057111e-04f, 1.99742056e-03f, -5.39270230e-02f,
  -1.64276138e-01f, -2.68967181e-01f, -2.35443413e-02f, -2.41048839e-02f, -3.08823474e-02f, -7.35263079e-02f, -1.03716612e-01f, 6.07364289e-02f, -1.72264040e-01f, -1.05083175e-03f,
  -1.14566498e-01f, 2.61220876e-02f, 5.48785226e-03f, -2.54535247e-02f, -4.47198860e-02f, -5.32070436e-02f, -4.12584022e-02f, -8.31012577e-02f, -6.54184818e-03f, 1.02540530e-01f,
  4.63685356e-02f, 2.25919560e-02f, -7.94306770e-02f, 4.59210873e-02f, -1.12992031e-02f, -5.33202291e-02f, -7.68553242e-02f, -1.70376878e-02f, -3.59852836e-02f, -4.74038441e-03f,
  4.88388270e-01f, -5.24081588e-01f, 4.60894197e-01f, 8.01330745e-01f, 2.68297762e-01f, -3.32521439e-01f, 2.81946093e-01f, 5.78681082e-02f, 8.85126665e-02f, -6.44755781e-01f,
  1.15912311e-01f, 3.83970812e-02f, -1.49810210e-01f, 1.58060163e-01f, 5.85856438e-01f, -1.80329278e-01f, 7.77674690e-02f, 5.77962361e-02f, 6.88935071e-03f, 2.35479325e-01f,
  3.65401536e-01f, 1.52892947e-01f, 4.92222607e-01f, -1.36552989e-01f, 3.52008402e-01f, 8.88772160e-02f, 1.06884293e-01f, -7.43161365e-02f, 2.03138422e-02f, -2.94247959e-02f,
  -1.03214905e-01f, 7.08261132e-02f, 1.27171248e-01f, -8.18794519e-02f, -1.09527297e-02f, -5.34358947e-03f, -6.41377643e-02f, 3.40486914e-02f, 6.29926622e-02f, -7.34307468e-02f,
  -7.48977587e-02f, -6.37747049e-02f, -2.09287703e-02f, 1.40181538e-02f, 1.62276626e-02f, 2.03668329e-04f, 2.20341366e-02f, 4.99138907e-02f, 4.72394750e-02f, 6.14099503e-02f,
  2.94515155e-02f, -4.35736701e-02f, 1.07982568e-01f, -8.83965194e-02f, 1.45804703e-01f, 3.32171954e-02f, 5.59411943e-03f, 3.12962197e-02f, -6.28387928e-02f, 2.74405498e-02f,
  -9.91382971e-02f, 3.36443493e-03f, 4.39543203e-02f, 4.10882831e-02f, 8.68875533e-02f, 3.22184600e-02f, -1.05671752e-02f, 1.41420690e-02f, 7.39504234e-04f, 1.50062284e-03f,
  2.36688070e-02f, 7.19945133e-02f, 2.02990733e-02f, 3.26068141e-03f, 1.07959677e-02f, 7.80945923e-03f, 3.38526666e-02f, -3.16454330e-03f, 1.71442777e-02f, 4.11697291e-02f,
  -3.14848311e-02f, 3.59342359e-02f, 3.99362622e-03f, -1.32340873e-02f, -3.60921286e-02f, 4.35686717e-03f, -4.99691330e-02f, -6.57324493e-02f, -4.79032360e-02f, 1.82372294e-02f,
  -2.31952474e-01f, -2.62922704e-01f, -9.08406600e-02f, -1.14390869e-02f, -1.48988992e-01f, -3.74941826e-02f, -3.50682102e-02f, -4.31774929e-02f, -1.19319707e-01f, 2.07964070e-02f,
  -1.78579111e-02f, 8.19901451e-02f, -8.97223651e-02f, 1.95701625e-02f, 6.48507336e-03f, -1.65345073e-02f, 4.43077087e-02f, -1.36265486e-01f, 2.06185021e-02f, 6.77753182e-04f,
  1.75985992e-02f, -1.18736759e-01f, 1.11532565e-04f, -2.04751063e-02f, -2.46829093e-02f, -2.16760375e-02f, -6.13082014e-02f, -4.70691994e-02f, -3.13458666e-02f, -6.14950769e-02f,
  -9.76545334e-01f, -1.15369046e-02f, 3.64067763e-01f, -3.63644719e-01f, -2.31719241e-01f, 4.90024574e-02f, 1.69474408e-01f, -1.62307829e-01f, -2.86331147e-01f, 1.08786285e-01f,
  9.42622498e-02f, -1.66249633e-01f, 3.78645450e-01f, 1.20437555e-01f, 1.24085754e-01f, 3.29760790e-01f, 9.48322713e-02f, 6.41942173e-02f, -6.80135638e-02f, -1.47342131e-01f,
  -3.26064676e-02f, -7.97457341e-03f, 3.50317776e-01f, 1.01603032e-03f, 3.19906540e-04f, -1.74250513e-01f, -5.99600449e-02f, 7.31626451e-02f, 2.60888506e-02f, 4.02444676e-02f,
  -1.85372591e-01f, -1.55347288e-01f, 1.04305800e-02f, 3.66924740e-02f, -4.39156108e-02f, 2.50868686e-02f, -4.20415448e-03f, 3.35885957e-02f, -2.86684278e-02f, -3.23068239e-02f,
  -7.17537403e-02f, -7.07889274e-02f, -1.17936864e-01f, -5.61298802e-03f, -6.10442720e-02f, -7.89143238e-03f, 1.35801025e-02f, 5.54716121e-03f, 3.75321630e-04f, 1.19485319e-01f,
  1.88877687e-01f, -2.88604274e-02f, 3.58459204e-02f, 3.56549956e-02f, 4.99295443e-02f, -4.35594842e-02f, 2.52044816e-02f, 4.84428778e-02f, 1.35323731e-03f, -9.29672271e-02f,
  -2.86655407e-02f, 3.69763412e-02f, 1.13847978e-01f, -1.00361016e-02f, 2.61559896e-03f, 1.01277689e-02f, 2.02022512e-02f, 5.23268916e-02f, -4.54227142e-02f, -5.06675709e-03f,
  -8.85404423e-02f, -2.68555451e-02f, -3.38004008e-02f, 1.84629820e-02f, 1.45795224e-02f, -1.47223799e-02f, 1.73241012e-02f, -3.78124826e-02f, 3.73975039e-02f, 1.84554365e-02f,
  3.72769311e-03f, -4.10104580e-02f, 3.33165303e-02f, 3.98812257e-02f, 1.24507751e-02f, 1.65861635e-03f, -7.07480311e-02f, 2.10683569e-02f, 3.09559964e-02f, 4.20374563e-03f,
  -4.99106884e-01f, -4.43773091e-01f, -1.07745059e-01f, -1.56786233e-01f, -3.73480320e-02f, -5.11295907e-02f, -4.89320606e-02f, -5.38580418e-02f, -1.02288045e-01f, -3.45430933e-02f,
  -1.66685227e-02f, 2.71274932e-02f, -6.39438108e-02f, -3.98296602e-02f, 1.16812158e-02f, -2.08605547e-02f, -1.13677541e-02f, -5.92651591e-02f, -4.16208021e-02f, -5.51544838e-02f,
  -5.91807254e-02f, -3.42437625e-02f, 5.41620813e-02f, -1.67114399e-02f, 7.34162005e-03f, -3.36526670e-02f, -1.61209151e-01f, -4.65887524e-02f, 7.38903601e-03f, 2.71202940e-02f,
  1.24746710e-01f, -3.83627206e-01f, -1.89091936e-01f, 7.16643501e-03f, 1.31552562e-01f, 8.81041735e-02f, -1.29216090e-01f, -1.90378562e-01f, -2.54090637e-01f, -2.69963652e-01f,
  -2.58964509e-01f, 3.32120918e-02f, -3.25636029e-01f, 1.56142861e-01f, 3.60168129e-01f, 1.04556885e-02f, 6.71680048e-02f, 5.35853803e-02f, 2.60008592e-03f, -1.59314126e-01f,
  3.55778784e-02f, 1.27582625e-01f, 1.42353520e-01f, 1.61499962e-01f, 1.31713808e-01f, 5.32151051e-02f, 8.90508667e-02f, 7.90734887e-02f, 9.40499753e-02f, 2.40500718e-01f,
  8.11498314e-02f, -7.01806620e-02f, -2.39422433e-02f, 7.42498413e-02f, -1.45838261e-01f, -8.52087140e-02f, 2.92639602e-02f, 1.70005485e-01f, 7.87987560e-02f, -5.00671342e-02f,
  4.60219793e-02f, 1.08615167e-01f, 7.88250342e-02f, 5.50397485e-02f, 2.85963751e-02f, 1.90844163e-02f, 9.54210199e-03f, -1.58062745e-02f, -4.94549721e-02f, -9.15078819e-03f,
  -1.31078690e-01f, 6.51154071e-02f, -2.91586667e-02f, 4.52320576e-02f, -5.78314774e-02f, -6.52641198e-03f, -1.13284364e-02f, -3.39418948e-02f, -1.14497431e-02f, -2.08924268e-03f,
  9.26463865e-03f, 9.37780738e-02f, -8.10826123e-02f, 1.72508340e-02f, -1.77045781e-02f, 1.07823119e-01f, 6.53575873e-03f, -5.71676940e-02f, -5.16233966e-02f, -3.87476794e-02f,
  -4.64925766e-02f, -3.24886329e-02f, 5.24879340e-03f, 2.33436152e-02f, -1.06663601e-02f, -1.99673958e-02f, 8.94279554e-02f, 9.77661647e-03f, -1.01518951e-01f, -1.97245013e-02f,
  7.66144018e-04f, 7.26562515e-02f, -2.70625260e-02f, -3.81769575e-02f, -1.13530746e-02f, 3.00174206e-03f, 2.19763163e-02f, -5.01126423e-02f, -1.15103312e-02f, -4.89506945e-02f,
  4.57964689e-02f, -3.52011442e-01f, -6.58301339e-02f, 7.82534406e-02f, -1.37066822e-02f, -1.55123807e-02f, 7.73813128e-02f, 3.11661214e-02f, 4.83192243e-02f, -5.15379235e-02f,
  1.26468800e-02f, 5.73787838e-03f, 3.24137323e-02f, 7.17482790e-02f, 4.55686444e-04f, -8.69857073e-02f, -6.36722520e-02f, 2.74777152e-02f, 1.44508118e-02f, 1.01756593e-02f,
  1.76165067e-02f, -4.34231050e-02f, 2.10584197e-02f, -3.40081602e-02f, -1.99435782e-02f, -2.98363883e-02f, 6.67834431e-02f, -3.76843885e-02f, 3.22076753e-02f, 2.10494846e-02f,
  -1.63031459e-01f, 6.46052212e-02f, -3.79447371e-01f, -3.59479040e-01f, -1.97534814e-01f, -7.40964472e-01f, -5.07973075e-01f, -9.81432945e-02f, 2.44393840e-01f, 1.18884325e-01f,
  -4.65318114e-02f, 2.22128317e-01f, 1.53367981e-01f, -1.67899624e-01f, -1.71292529e-01f, 1.45117939e-01f, -5.19803703e-01f, -3.20069760e-01f, 1.54385135e-01f, -3.19408178e-01f,
  -9.95874256e-02f, -2.73917496e-01f, -2.69425452e-01f, -6.60352707e-02f, -4.23621535e-01f, -9.36434865e-02f, -9.77966934e-03f, -1.41437411e-01f, -2.23488182e-01f, 7.90802948e-03f,
  -6.69601560e-02f, 1.55082986e-01f, -1.14491567e-01f, -7.94132426e-02f, -1.76185876e-01f, -1.44890234e-01f, -2.06044972e-01f, 5.75967059e-02f, -2.49673985e-02f, 3.73394564e-02f,
  3.26591246e-02f, 5.63421361e-02f, 2.22048117e-03f, 6.92187473e-02f, -3.75404442e-03f, 2.01033894e-02f, 2.84067150e-02f, -5.35217971e-02f, 3.13646570e-02f, 1.50884110e-02f,
  -7.73138329e-02f, -5.29340580e-02f, -1.99098691e-01f, 4.42260914e-02f, -8.19063410e-02f, -3.47409653e-03f, -6.16187192e-02f, -1.42941400e-02f, -3.82269062e-02f, -9.93396621e-03f,
  5.15783355e-02f, -9.14916322e-02f, 9.12708603e-03f, 2.49658935e-02f, -2.04040972e-03f, 1.36915492e-02f, 2.66303271e-02f, 1.94457900e-02f, 1.16090598e-02f, -3.36498246e-02f,
  1.68344472e-02f, -1.67727377e-02f, -7.31679611e-03f, -9.20004398e-02f, -1.01292543e-02f, 4.28042710e-02f, -2.95800027e-02f, 6.02740385e-02f, -1.11672007e-01f, -1.64553579e-02f,
  8.07289109e-02f, -7.30180144e-02f, 7.50862062e-02f, -5.27606457e-02f, -1.04807336e-02f, 9.03005376e-02f, 3.85140777e-02f, 5.91782033e-02f, 2.85287835e-02f, -9.81526673e-02f,
  -1.31768301e-01f, -2.71348525e-02f, 4.41245250e-02f, 1.12414405e-01f, 5.18935695e-02f, -4.45112474e-02f, -2.24862453e-02f, -5.97223416e-02f, 9.15873889e-03f, -4.08774465e-02f,
  -6.56889603e-02f, -6.70964271e-02f, -8.53980333e-02f, 1.58899166e-02f, -2.99578160e-02f, -3.33289094e-02f, -9.17622969e-02f, -2.41108518e-02f, -1.16754688e-01f, -2.12539863e-02f,
  -4.39916941e-04f, -4.02070507e-02f, 5.69472015e-02f, -6.68471903e-02f, -9.90452897e-03f, -4.43343632e-02f, -7.45361000e-02f, 2.07711719e-02f, -5.41220978e-02f, 1.98744703e-02f,
  4.20701325e-01f, 5.62332213e-01f, 5.47205865e-01f, 4.64005828e-01f, -4.47105855e-01f, -4.33399379e-01f, -1.70994997e-01f, 3.23172882e-02f, 1.31200433e-01f, 1.76522322e-02f,
  -2.02190652e-01f, 5.25935113e-01f, -6.05618283e-02f, 1.73637941e-01f, -1.10616066e-01f, -9.22928005e-03f, 1.77616552e-01f, 2.68379040e-02f, -9.00621787e-02f, 3.59914809e-01f,
  1.45577416e-01f, -1.74277604e-01f, 2.40052223e-01f, -1.79339461e-02f, 2.55372196e-01f, 3.38879049e-01f, 6.32581860e-02f, -3.41455378e-02f, 1.42045543e-01f, -1.66816637e-01f,
  -1.46208197e-01f, 1.39318287e-01f, 1.49682119e-01f, -3.03255990e-02f, 3.43227834e-02f, 6.13181153e-03f, -1.59931183e-02f, -6.44103661e-02f, 2.44543771e-03f, 5.22870496e-02f,
  8.04715529e-02f, -3.08632590e-02f, 6.83076531e-02f, -6.43461943e-02f, -3.82628292e-02f, 2.45744977e-02f, 9.80655029e-02f, 1.04852848e-01f, 7.64083639e-02f, 1.61753774e-01f,
  1.94038436e-01f, 5.90037331e-02f, 8.49735439e-02f, 3.49310264e-02f, 1.11878939e-01f, 6.77393051e-03f, -1.95852481e-02f, 1.19819827e-01f, 4.74756472e-02f, 3.15417126e-02f,
  1.21356752e-02f, -9.37068090e-02f, -4.78005856e-02f, -5.48324287e-02f, 7.10172877e-02f, 3.17583908e-03f, 8.65666494e-02f, -8.19147900e-02f, 5.07502891e-02f, -5.15374281e-02f,
  1.07790502e-02f, -1.95829794e-02f, -1.33094460e-01f, -5.25641814e-02f, 9.49329603e-03f, -1.48594026e-02f, -2.63784118e-02f, -8.95133521e-03f, 9.69741307e-03f, 2.09000036e-02f,
  -8.33269879e-02f, -6.44742278e-03f, 1.58862621e-02f, -7.40567222e-02f, -9.42002311e-02f, -2.97417175e-02f, 5.05822115e-02f, 9.21619833e-02f, -4.28321138e-02f, -3.37529778e-02f,
  7.15025589e-02f, 3.29424471e-01f, 1.07384175e-01f, -7.33491452e-03f, 4.09030244e-02f, -9.03199092e-02f, -4.68645943e-03f, 7.57569894e-02f, 1.46217793e-01f, -7.24799857e-02f,
  1.45278452e-02f, -6.22077957e-02f, -5.72437234e-02f, 4.43264879e-02f, 3.46433185e-02f, 9.39854383e-02f, 2.76470818e-02f, 7.51730520e-03f, 7.96800554e-02f, 1.57426316e-02f,
  5.51166907e-02f, -5.28776348e-02f, 5.21425195e-02f, 1.15933046e-02f, 2.31824331e-02f, -4.79551405e-03f, 6.30085990e-02f, 4.18281704e-02f, -6.26059845e-02f, 1.07561387e-01f,
  3.00414979e-01f, 7.85400495e-02f, -4.98688787e-01f, 4.59050620e-03f, -1.35311663e-01f, 2.13622823e-01f, 4.24447320e-02f, -5.13676330e-02f, -2.88899243e-01f, 3.70012105e-01f,
  2.40282327e-01f, -7.67739564e-02f, -6.12256303e-02f, 6.04214847e-01f, 1.93115681e-01f, 1.11153141e-01f, 5.49757659e-01f, 2.58800805e-01f, -1.77208155e-01f, 7.00853318e-02f,
  3.98617499e-02f, 5.05329907e-01f, 4.96892072e-02f, 1.51050717e-01f, 1.71460003e-01f, -1.42418608e-01f, 2.00985596e-01f, -2.78364092e-01f, 2.81354725e-01f, 1.80341467e-01f,
  7.57123753e-02f, 2.48513129e-02f, -1.02932692e-01f, -1.11554794e-01f, -9.54866968e-03f, 1.49347633e-02f, -3.23222503e-02f, 5.26803099e-02f, -1.52321026e-01f, -6.34560660e-02f,
  -3.31269987e-02f, 9.14797932e-03f, 1.04817180e-02f, -1.21308662e-01f, -6.69937059e-02f, -4.51832786e-02f, -8.41663927e-02f, -7.78967366e-02f, -5.07279485e-02f, 4.43608053e-02f,
  -1.27741620e-01f, 5.60523234e-02f, 3.49344090e-02f, -8.52101017e-03f, -2.12705582e-02f, 6.89929500e-02f, -1.92650724e-02f, -5.27983867e-02f, 1.63297281e-02f, 1.51881948e-02f,
  9.98372957e-02f, -3.19790877e-02f, 8.11755434e-02f, 4.49079350e-02f, 3.63584049e-02f, -4.46429010e-03f, 1.00297481e-01f, 4.04399596e-02f, -3.37257981e-02f, 9.90312025e-02f,
  -5.18708266e-02f, 1.15482034e-02f, 2.82541513e-02f, 7.62295909e-03f, 8.77653062e-02f, 1.00159645e-01f, -3.81005593e-02f, 3.45638581e-02f, -8.30737650e-02f, -3.94046418e-02f,
  5.00081815e-02f, 1.57306399e-02f, -3.24055441e-02f, 3.95878404e-02f, 1.53970206e-02f, -9.46321562e-02f, 1.47677884e-01f, -3.77792977e-02f, -9.93337110e-02f, -9.47049260e-03f,
  5.59296571e-02f, 1.01036482e-01f, -4.67710607e-02f, -6.01679832e-02f, -4.19250056e-02f, 7.38722160e-02f, 1.13346614e-02f, 1.09221116e-02f, 6.66009709e-02f, 6.16918728e-02f,
  6.63063750e-02f, -2.95270421e-02f, 9.44307297e-02f, -1.71910189e-02f, -9.84132811e-02f, 5.48480786e-02f, 9.13450867e-02f, 4.55363933e-03f, 6.01235554e-02f, 1.33676343e-02f,
  4.14924473e-02f, -8.21610242e-02f, 3.75802815e-02f, -4.45140898e-02f, 3.60359326e-02f, -6.21893350e-03f, -7.48308562e-03f, -3.01430058e-02f, 3.89620773e-02f, -2.56014410e-02f,
  1.83035657e-01f, 5.02698660e-01f, 1.42712817e-01f, 2.55536646e-01f, 8.31604078e-02f, 1.51943341e-01f, 1.21187806e-01f, 2.00548351e-01f, 3.10029417e-01f, 2.23243847e-01f,
  -1.25676915e-01f, 4.71794635e-01f, -1.48523137e-01f, 3.45961541e-01f, -3.25682282e-01f, -1.69236153e-01f, 1.06322341e-01f, 1.85372040e-01f, 7.58482665e-02f, 6.13516532e-02f,
  -6.26453906e-02f, -1.71319038e-01f, -1.46304190e-01f, -1.88273683e-01f, 3.40377502e-02f, 1.82540603e-02f, -4.87057120e-01f, -1.71890363e-01f, 2.77185179e-02f, -1.16999701e-01f,
  -4.77522798e-02f, 2.25285273e-02f, -3.37381236e-04f, -3.07479184e-02f, -9.82807577e-02f, 3.47967707e-02f, 1.01420598e-03f, -3.28587256e-02f, -7.18059689e-02f, 8.43254477e-02f,
  5.19918688e-02f, -1.19569920e-01f, 3.29123810e-02f, -2.09027063e-03f, 1.73924804e-01f, 9.45346504e-02f, 6.48985803e-02f, 5.37079796e-02f, 3.41306552e-02f, 3.89178172e-02f,
  5.56256250e-02f, 9.97675881e-02f, 3.31432410e-02f, 7.64020309e-02f, -5.03864326e-02f, 6.75662830e-02f, 4.80262525e-02f, -9.04847905e-02f, 7.68069550e-02f, 8.79106298e-02f,
  -1.48647139e-02f, 7.85007328e-02f, 2.02582367e-02f, 1.15248496e-02f, -7.79377948e-03f, -2.45596170e-02f, -4.09345478e-02f, -2.27411482e-02f, -3.32245207e-03f, 1.34310341e-02f,
  3.67118930e-03f, 3.03073432e-02f, 1.52145866e-02f, -2.50692572e-03f, 2.23054048e-02f, 5.07300384e-02f, 4.67356779e-02f, -1.11419067e-01f, 5.09359017e-02f, -5.00655398e-02f,
  -1.45667251e-02f, -3.82204331e-03f, 3.89791019e-02f, 1.29750604e-02f, -1.32433670e-02f, -1.34784998e-02f, 1.04653835e-02f, 2.66711861e-02f, -5.44689260e-02f, -6.88283667e-02f,
  7.20079914e-02f, -8.86915699e-02f, -6.55346364e-02f, -1.92052573e-02f, -1.18341604e-02f, -7.88002908e-02f, -3.19102854e-02f, 7.22893327e-02f, -4.47029732e-02f, -3.62768024e-02f,
  1.17815463e-02f, 2.51113661e-02f, 8.38696025e-03f, -8.76785163e-03f, -7.48466030e-02f, -1.78921521e-02f, -1.73700359e-02f, -1.30580524e-02f, -5.18390443e-03f, -3.68128009e-02f,
  3.86569672e-03f, 3.10690557e-05f, 6.03660755e-02f, -6.70599043e-02f, 2.91523486e-02f, -1.34529704e-02f, 2.51848735e-02f, 3.23580801e-02f, -4.80563641e-02f, -6.11848757e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 8)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 8;
const float L0_fan_Bp_bar_data[] = {
  3.71415704e-01f, 6.93844795e-01f, 3.50431263e-01f, 7.63159394e-02f, 1.23339690e-01f, 2.94739723e-01f, 3.26850742e-01f, 5.14104962e-01f
};

// L1_fan_Wp (Shape: 4 x 16)
const int L1_fan_Wp_rows = 4;
const int L1_fan_Wp_cols = 16;
const float L1_fan_Wp_data[] = {
  -2.53939301e-01f, -4.11774516e-01f, -2.50212640e-01f, 1.32832170e-01f, -1.22749403e-01f, 5.14966309e-01f, -6.77988410e-01f, -7.22235382e-01f, 8.03173557e-02f, 1.20905153e-01f,
  -5.51938713e-01f, -1.56751201e-01f, -4.66289222e-02f, 2.69501090e-01f, 2.05204591e-01f, 2.44693667e-01f, -2.44533882e-01f, -6.18014392e-03f, 3.06835949e-01f, 2.14353457e-01f,
  -4.14729685e-01f, -5.82097434e-02f, -2.11177304e-01f, 5.18342555e-01f, 1.09197058e-01f, -1.37252033e-01f, -5.57971299e-02f, 2.31831968e-01f, 5.30514419e-01f, -2.86829203e-01f,
  -4.20373142e-01f, 1.55147925e-01f, 2.51615699e-02f, 2.02954769e-01f, -2.64023617e-02f, -3.35389197e-01f, 3.10037851e-01f, -3.97986084e-01f, 4.11976904e-01f, 4.72877592e-01f,
  -4.15407240e-01f, 3.05349212e-02f, 4.03650582e-01f, 2.29668915e-01f, 3.75763923e-01f, -1.38775051e-01f, -2.97637701e-01f, -4.32266563e-01f, -3.66553180e-02f, 3.50415230e-01f,
  -1.36571117e-02f, -7.76809826e-02f, -3.72858107e-01f, -3.91034991e-01f, 7.20412910e-01f, 5.06441116e-01f, -2.60481864e-01f, -3.50682914e-01f, 4.68827128e-01f, -6.91771358e-02f,
  3.11677635e-01f, 3.72576565e-01f, -8.96340311e-02f, -4.04991247e-02f
};

// L1_fan_Wp_bar (Shape: 8 x 16)
const int L1_fan_Wp_bar_rows = 8;
const int L1_fan_Wp_bar_cols = 16;
const float L1_fan_Wp_bar_data[] = {
  3.12136024e-01f, 1.33429408e-01f, 3.12334359e-01f, 3.55205946e-02f, 1.47341847e-01f, 8.89768839e-01f, -6.88505530e-01f, -5.23896992e-01f, 2.51593381e-01f, 4.07930583e-01f,
  -4.09419984e-01f, -4.77256685e-01f, 4.26564157e-01f, 9.76678252e-01f, 2.85518486e-02f, 1.16574410e-02f, 5.38348794e-01f, 5.28199114e-02f, 5.54544151e-01f, -1.21874079e-01f,
  8.18028972e-02f, 6.20633602e-01f, -2.53142476e-01f, 7.27883756e-01f, 1.61706775e-01f, 2.59422511e-01f, 4.08589691e-01f, 2.18147323e-01f, 1.19381821e+00f, -2.50240803e-01f,
  -3.76693189e-01f, -4.58988622e-02f, 1.78977445e-01f, -2.88177431e-02f, -6.70596957e-02f, 3.96129340e-01f, 5.62885776e-02f, -9.99113917e-01f, 4.19258654e-01f, -7.99262404e-01f,
  -3.90237868e-01f, -1.40562266e-01f, 2.38303300e-02f, 3.15896809e-01f, 2.90766031e-01f, 1.64781600e-01f, 1.29205501e+00f, 2.31788069e-01f, -2.75694162e-01f, -1.96518108e-01f,
  3.14720988e-01f, -3.47787589e-02f, -1.45636588e-01f, 2.13319346e-01f, -8.48672688e-02f, 1.15637235e-01f, 3.06845829e-03f, 3.72944295e-01f, -1.25850260e-01f, -1.31159410e-01f,
  -1.21454440e-01f, 3.80776972e-01f, 1.69529632e-01f, 1.06753185e-01f, 4.01972950e-01f, 3.98796439e-01f, 4.79184210e-01f, 5.36232352e-01f, -1.15529668e+00f, -6.00380659e-01f,
  7.37208903e-01f, 3.67230386e-01f, -4.81527328e-01f, 4.41528708e-01f, -6.58796906e-01f, -4.94914114e-01f, -3.03569645e-01f, 6.44981205e-01f, -3.54270190e-01f, 7.63728797e-01f,
  2.52492607e-01f, -4.77472395e-02f, 3.27645577e-02f, 2.54133791e-01f, 3.46778244e-01f, -4.93890226e-01f, -3.42494905e-01f, -3.53490442e-01f, -1.38660297e-01f, 1.35442472e+00f,
  -5.18406808e-01f, 5.15448391e-01f, -2.13240162e-01f, -2.20000725e-02f, -1.04238102e-02f, -2.81491309e-01f, 1.60185724e-01f, 4.94707137e-01f, 6.82252049e-01f, -4.09945518e-01f,
  3.67699005e-02f, 1.31131530e-01f, 2.81877875e-01f, 5.93085349e-01f, 4.09175068e-01f, 9.13338065e-01f, 1.69679642e-01f, 9.64796320e-02f, -4.09094870e-01f, 6.64802492e-01f,
  -3.30080271e-01f, 2.31392652e-01f, 2.29230627e-01f, 2.59391721e-02f, 4.64248151e-01f, 8.17550540e-01f, -3.53266686e-01f, 5.52104861e-02f, 1.96165547e-01f, -4.96856985e-04f,
  7.00652897e-01f, -5.36547542e-01f, 8.27587247e-01f, -2.52551019e-01f, 2.06490070e-01f, 2.51496345e-01f, -9.92951542e-02f, 7.85125554e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 8)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 8;
const float L1_fan_Bp_bar_data[] = {
  2.46534243e-01f, 4.13866848e-01f, 4.54946071e-01f, -2.08096787e-01f, 6.76883280e-01f, 2.12043270e-01f, 3.61241341e-01f, 9.99342129e-02f
};

// L2_linear_W (Shape: 12 x 16)
const int L2_linear_W_rows = 12;
const int L2_linear_W_cols = 16;
const float L2_linear_W_data[] = {
  -4.57887799e-01f, -1.89575985e-01f, 3.24342877e-01f, -6.45644739e-02f, -7.55454957e-01f, -5.94097674e-01f, 3.74322563e-01f, 6.76707625e-01f, -5.71062803e-01f, -4.21015382e-01f,
  8.11596096e-01f, -3.03183407e-01f, -5.33839166e-01f, -4.91949916e-01f, -6.00006402e-01f, 7.33456373e-01f, 4.99127597e-01f, -3.40338707e-01f, -1.35429114e-01f, 5.67531943e-01f,
  4.18827206e-01f, -2.60153472e-01f, -5.78756750e-01f, -4.31484520e-01f, -4.24205273e-01f, -3.74726385e-01f, 1.20467246e+00f, -3.13033648e-02f, -7.34771118e-02f, -4.49681357e-02f,
  -2.09966779e-01f, -4.73838508e-01f, 4.33787078e-01f, 1.03956141e-01f, -1.07929841e-01f, -7.80810595e-01f, 6.69350773e-02f, -1.84981897e-01f, 2.71395892e-01f, -6.61170661e-01f,
  -2.73512363e-01f, -2.68684536e-01f, 2.61866391e-01f, 3.29229869e-02f, -7.97554970e-01f, 1.21301901e+00f, 5.42865098e-02f, -2.96385020e-01f, 5.77890873e-01f, -1.03166208e-01f,
  5.09905636e-01f, 4.79275972e-01f, 3.23148757e-01f, 7.02175856e-01f, -1.75656870e-01f, -4.12909567e-01f, 3.77238542e-01f, 6.94979131e-01f, -5.27477205e-01f, -1.19252883e-01f,
  -6.94186330e-01f, -2.47280806e-01f, -3.18693668e-01f, 7.47843564e-01f, -6.85574591e-01f, 4.84931231e-01f, 7.12793827e-01f, 6.30979091e-02f, -8.10906947e-01f, 8.00018728e-01f,
  4.66743410e-01f, 6.97911918e-01f, -5.30368626e-01f, 6.37758434e-01f, -6.20993912e-01f, -1.79861724e-01f, -3.06833126e-02f, -3.41738105e-01f, 4.94358152e-01f, 7.18226492e-01f,
  4.21917319e-01f, -5.07811420e-02f, 4.90441322e-01f, -1.16113953e-01f, -2.97435701e-01f, 3.12962621e-01f, -8.06357116e-02f, 8.16847980e-01f, -3.00050318e-01f, -5.66274345e-01f,
  3.39836925e-01f, -3.33195001e-01f, 1.47806215e+00f, -1.09275028e-01f, -5.58176696e-01f, 2.44290173e-01f, 4.24015790e-01f, 1.90682914e-02f, 5.48710465e-01f, 1.94912344e-01f,
  -4.29871380e-01f, 2.41646051e-01f, 2.59408742e-01f, -6.59207106e-01f, -1.52992189e-01f, -6.70551062e-02f, -6.89971089e-01f, -4.37557250e-02f, 8.95811319e-01f, 6.62509859e-01f,
  2.88459957e-01f, -2.93661296e-01f, 3.50742400e-01f, -3.67658913e-01f, -7.23158360e-01f, -4.27772671e-01f, -3.45458657e-01f, 1.72235787e-01f, 5.37163556e-01f, 4.31451619e-01f,
  1.08832810e-02f, 1.25921035e+00f, -2.12874532e-01f, 6.19109124e-02f, -5.75136304e-01f, -1.67545095e-01f, -3.84070575e-01f, -2.83852309e-01f, -1.70206930e-02f, -9.25323129e-01f,
  -1.52660191e-01f, -9.39521566e-02f, 2.98227131e-01f, -2.26683080e-01f, 2.00389735e-02f, -1.30887613e-01f, 1.00026488e+00f, -2.30738983e-01f, -1.20083518e-01f, 2.14086935e-01f,
  5.40049635e-02f, 1.62072897e-01f, 5.87275982e-01f, -5.22375345e-01f, -1.17100799e+00f, 5.24682581e-01f, -6.70323312e-01f, 2.86481053e-01f, -6.25313282e-01f, -2.75643468e-01f,
  1.09380257e+00f, 4.73664671e-01f, -6.03994310e-01f, 3.90224844e-01f, -2.20632583e-01f, -5.64688556e-02f, 2.32126210e-02f, 3.27471197e-01f, 8.62416625e-01f, -6.66918993e-01f,
  7.62995426e-03f, 7.88785994e-01f, -4.25144807e-02f, -3.89089823e-01f, 1.33378756e+00f, -6.85305834e-01f, -8.90197456e-01f, -1.23457205e+00f, 8.58562231e-01f, 1.57783795e-02f,
  -2.45070502e-01f, -2.94093221e-01f, -4.73300368e-01f, 2.16726623e-02f, -3.18532586e-01f, -1.98937029e-01f, 2.13031158e-01f, -1.29567608e-01f, -6.62741005e-01f, -1.58678889e-01f,
  2.81519383e-01f, 3.20665985e-01f, -4.69726712e-01f, 2.34573662e-01f, 2.88365424e-01f, -2.00466096e-01f, -4.30959642e-01f, 2.58582830e-01f, 7.06190526e-01f, -6.86692476e-01f,
  6.75140977e-01f, 4.70011413e-01f
};

// L2_linear_B (Shape: 1 x 12)
const int L2_linear_B_rows = 1;
const int L2_linear_B_cols = 12;
const float L2_linear_B_data[] = {
  3.25652212e-01f, -2.84024570e-02f, -1.68344136e-02f, -9.20946896e-02f, 2.50341892e-01f, 1.82638075e-02f, 8.09115842e-02f, -8.82194266e-02f, -2.53999084e-01f, 5.08530200e-01f,
  6.72009706e-01f, -4.50542778e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 4, 8
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        16, 4, 8
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_linear
    linear_forward_pgm(
        buffer1, x_out,
        L2_linear_W_data, L2_linear_B_data,
        16, 12
    );
    }
    