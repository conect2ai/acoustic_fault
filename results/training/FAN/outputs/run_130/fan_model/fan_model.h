/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 64 (x3)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 64;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    return (x > 0.0f) ? x : 0.0f;
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 25 x 120)
const int L0_fan_Wp_rows = 25;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -1.80583090e-01f, 1.58499032e-01f, 2.01432720e-01f, -3.96002568e-02f, -1.66537687e-01f, -1.94570437e-01f, -1.40276879e-01f, 5.92575520e-02f, 1.42510504e-01f, 2.67151669e-02f,
  -1.08447008e-01f, 1.23342246e-01f, 1.46877944e-01f, -4.45074551e-02f, -7.17324018e-02f, 1.10983759e-01f, -2.37892698e-02f, -3.73924710e-02f, 1.08371593e-01f, 3.43155139e-03f,
  1.67608753e-01f, -5.34396917e-02f, 9.52055976e-02f, -8.72252788e-03f, -1.34549722e-01f, 6.84817657e-02f, -1.39100850e-01f, 6.83055595e-02f, -1.60982087e-01f, -1.27380788e-01f,
  -1.18101798e-01f, 3.93545069e-02f, -3.00155533e-03f, 1.19127266e-01f, -9.11951289e-02f, -6.16299026e-02f, -8.59327521e-03f, -4.77442555e-02f, -2.09610537e-02f, 4.48289514e-02f,
  -2.84537785e-02f, 2.70464085e-02f, 1.58931240e-02f, 7.90569037e-02f, 2.27214228e-02f, 3.73664759e-02f, 9.07173008e-03f, 5.58172818e-03f, 4.96210530e-02f, -1.15836561e-02f,
  4.74867932e-02f, 8.95463228e-02f, 7.13482797e-02f, 1.78366341e-02f, 6.80447146e-02f, 2.88004149e-02f, 4.55577150e-02f, 3.66217876e-03f, -3.89478989e-02f, -1.02982987e-02f,
  6.79575233e-03f, 3.98597121e-02f, 2.71200687e-02f, -2.30181497e-02f, 2.70373728e-02f, -8.85654688e-02f, 1.26130478e-02f, -1.51845012e-02f, -1.21953338e-02f, 2.48898920e-02f,
  -8.77573714e-03f, -6.17235526e-02f, -2.48388238e-02f, 4.76488583e-02f, -9.38892271e-03f, -2.60454835e-03f, -3.93238999e-02f, -8.75884220e-02f, -1.93815660e-02f, -1.48166055e-02f,
  2.02509072e-02f, -9.05253366e-03f, -5.25733978e-02f, -6.24892153e-02f, -1.30593218e-02f, 5.40173389e-02f, 2.05604378e-02f, 3.01018991e-02f, -1.89165976e-02f, -3.70836630e-02f,
  -1.72440529e-01f, 8.43274370e-02f, -3.50161679e-02f, -9.75822061e-02f, -3.70966233e-02f, -1.27657512e-02f, 6.51564375e-02f, -8.02389346e-03f, 9.18149352e-02f, 2.92499866e-02f,
  -3.32132843e-03f, -4.54714261e-02f, -4.51888740e-02f, -2.01181322e-02f, -3.66620496e-02f, -1.56644464e-03f, 7.57082831e-03f, -1.22097377e-02f, -5.81315756e-02f, -7.82179385e-02f,
  1.36577757e-02f, -8.65050480e-02f, -4.55059931e-02f, -4.93803360e-02f, -1.97628848e-02f, 3.10729053e-02f, 1.47797866e-02f, 4.05652635e-02f, -8.34069103e-02f, 6.20709211e-02f,
  -4.22990590e-01f, 4.04598027e-01f, 5.68966605e-02f, -1.14145381e-02f, -7.70428479e-02f, -1.76957119e-02f, -1.47775248e-01f, -7.08256429e-03f, -6.35270551e-02f, 2.20550463e-01f,
  -5.38726747e-02f, 1.04921274e-01f, 6.17939644e-02f, -1.31328255e-02f, -2.34713778e-01f, 1.03942424e-01f, -2.65551880e-02f, 6.06810451e-02f, -5.11023887e-02f, -1.28659666e-01f,
  -1.56412899e-01f, -1.41217262e-01f, -1.37140051e-01f, -3.77432667e-02f, -1.20944893e-02f, -1.02881752e-02f, -8.91167950e-03f, -3.18703353e-02f, 1.23487897e-02f, -8.04558694e-02f,
  -8.75799656e-02f, -6.48896992e-02f, -6.58662319e-02f, 8.37366581e-02f, 3.65119688e-02f, -2.90501514e-03f, 7.40445480e-02f, -1.84161495e-02f, -8.49022418e-02f, 4.02974896e-02f,
  6.39634207e-02f, -2.82591637e-02f, -3.40227522e-02f, -1.26942238e-02f, -6.23418111e-03f, 6.60593668e-03f, -9.39614326e-03f, 4.23999280e-02f, 1.57943480e-02f, -5.88656869e-04f,
  5.03408201e-02f, 1.30581826e-01f, 2.99055576e-02f, 1.33215353e-01f, 1.32654076e-02f, -9.76715796e-03f, 3.63174453e-03f, 4.59336825e-02f, 6.14061914e-02f, 2.16440614e-02f,
  -2.38507818e-02f, 6.89367875e-02f, -7.69152958e-03f, 1.38306357e-02f, -2.62444988e-02f, -5.21834306e-02f, 4.65003046e-04f, 1.34099303e-02f, -7.57049248e-02f, 2.24056803e-02f,
  -8.61506071e-03f, -2.43761504e-04f, 1.79810934e-02f, 1.91013869e-02f, -5.38674071e-02f, -6.93829954e-02f, -6.56397388e-05f, -1.83880758e-02f, 4.94864807e-02f, 8.80504400e-02f,
  1.91184711e-02f, -4.96875457e-02f, -2.36214101e-02f, 4.11857925e-02f, 6.32413402e-02f, -2.46158130e-02f, 2.07396355e-02f, 1.74780644e-03f, 8.13460164e-03f, 3.92112546e-02f,
  7.23176897e-02f, 1.54257983e-01f, 1.36444895e-02f, 1.26498798e-03f, 2.05571428e-02f, 6.56127408e-02f, -1.43831493e-02f, -3.99010867e-04f, 2.84815393e-02f, -6.63814023e-02f,
  5.46746664e-02f, 1.31389825e-02f, 9.60565731e-02f, -5.95980026e-02f, 2.57194806e-02f, 8.03813431e-03f, 4.59171608e-02f, -1.19423075e-02f, 1.39010409e-02f, 6.22788928e-02f,
  4.69923504e-02f, 1.83396600e-03f, 1.30856968e-02f, -3.91042382e-02f, 4.28201593e-02f, 7.62759522e-02f, 8.50641169e-03f, -6.72230050e-02f, 3.44209746e-02f, 3.07261422e-02f,
  -1.22071743e-01f, -1.36311576e-01f, 2.04431228e-02f, 6.88829795e-02f, -5.00588715e-02f, 1.56751022e-01f, 3.57189253e-02f, -1.05179541e-01f, 9.26333368e-02f, -1.48781657e-01f,
  -7.43025765e-02f, 6.43269941e-02f, -3.35730501e-02f, 9.15780142e-02f, 3.21822584e-01f, 2.37707227e-01f, 1.15990065e-01f, 6.84976056e-02f, 4.72480953e-02f, -1.58632338e-01f,
  9.70273167e-02f, -3.72376107e-02f, 7.49249607e-02f, -7.18963444e-02f, -1.77872196e-01f, -3.84793095e-02f, -1.42805889e-01f, -2.50520324e-03f, -7.06276000e-02f, 1.85493100e-02f,
  7.47058764e-02f, -9.86743346e-02f, -7.89958388e-02f, -1.05247013e-02f, -2.00167093e-02f, -4.77564186e-02f, -2.74092425e-02f, 2.81302072e-02f, -5.91548672e-03f, -1.19866384e-02f,
  2.36846274e-03f, 1.24045620e-02f, 7.48141408e-02f, -2.12970618e-02f, -2.33602040e-02f, 4.90107425e-02f, 4.90110274e-03f, -2.50498019e-02f, -8.41217767e-03f, 3.53491269e-02f,
  6.14851154e-02f, 6.96469843e-02f, -5.90866851e-03f, 3.10408697e-03f, 2.27770526e-02f, 5.05119152e-02f, 6.36773482e-02f, 5.11594675e-02f, 5.20590357e-02f, 4.09809500e-02f,
  -1.26337782e-02f, -1.20420735e-02f, -1.05320737e-02f, -6.33997768e-02f, -4.40909080e-02f, 6.95319287e-03f, -3.29833552e-02f, -1.05729175e-03f, -1.37520647e-02f, -4.59121205e-02f,
  -1.12052636e-04f, -3.07868086e-02f, -3.40134315e-02f, -3.89307290e-02f, -1.96655542e-02f, -2.28909310e-02f, 1.36166997e-02f, -1.53046139e-02f, 5.95785156e-02f, -4.10962887e-02f,
  -2.37341616e-02f, 3.89402136e-02f, 4.31701355e-02f, -4.49670479e-02f, 3.67622077e-02f, -5.87757789e-02f, -1.17026418e-02f, -4.11603302e-02f, 3.56646255e-03f, 5.96336573e-02f,
  -7.92547837e-02f, -1.69417486e-01f, -7.44923716e-03f, -6.92686881e-04f, 6.75200894e-02f, -3.05967499e-02f, 2.63584778e-02f, 1.06958104e-02f, -4.21608537e-02f, -5.45702726e-02f,
  -7.38578010e-03f, -2.67348979e-02f, 8.98146257e-03f, 5.76255051e-03f, 1.83354244e-02f, -1.45459147e-02f, 2.27278098e-02f, -4.67884839e-02f, -3.17497365e-02f, -3.81257161e-02f,
  -4.43652421e-02f, -5.41330837e-02f, 1.66943427e-02f, -5.16923219e-02f, -3.82102616e-02f, 6.48661554e-02f, -2.59889737e-02f, -6.64452309e-05f, -1.93053391e-02f, 2.66373605e-02f,
  -4.46825847e-03f, -2.66727120e-01f, 2.94802219e-01f, -1.17274582e-01f, -5.10033630e-02f, 1.55439079e-01f, 2.00580135e-02f, -5.24137244e-02f, 8.86747241e-02f, -2.71046937e-01f,
  -1.53292984e-01f, 3.73023897e-02f, 1.76631808e-02f, -1.29933864e-01f, 3.17236423e-01f, 2.42339000e-01f, 1.18117100e-02f, 5.13086375e-03f, 4.34581675e-02f, -5.37292436e-02f,
  8.69343653e-02f, -1.53243706e-01f, 8.10194835e-02f, -7.06552938e-02f, -2.88727079e-02f, 5.24551980e-03f, 3.52783548e-03f, -1.78163908e-02f, -2.13514138e-02f, -3.29294428e-02f,
  -4.48991545e-02f, -1.41835034e-01f, -2.66500767e-02f, -3.39745581e-02f, 4.32572298e-04f, -3.46046761e-02f, 4.84555438e-02f, 9.42797884e-02f, 7.25156292e-02f, 2.30290797e-02f,
  4.66814302e-02f, 1.31918509e-02f, 1.77968759e-02f, 1.93499234e-02f, 1.41355093e-03f, -1.26092080e-02f, 5.00709824e-02f, 1.82254314e-02f, -2.23258063e-02f, 9.50051621e-02f,
  -1.87459197e-02f, 1.88964494e-02f, 4.53603268e-02f, 6.72647208e-02f, 4.11105268e-02f, -6.12495318e-02f, 2.69159377e-02f, 3.55025269e-02f, 5.68639375e-02f, -5.19140624e-03f,
  2.93938760e-02f, 1.05177406e-02f, -2.97069550e-02f, -2.93807387e-02f, 2.55708490e-02f, -7.04536885e-02f, -4.73038247e-03f, 1.92624750e-03f, 8.29333812e-02f, -3.41061205e-02f,
  5.65802865e-02f, -6.67595193e-02f, 1.77090801e-02f, 3.28982882e-02f, 9.03046865e-04f, -5.01979887e-02f, 4.07186598e-02f, 5.95049821e-02f, 4.85726632e-02f, 1.00722998e-01f,
  -1.93513127e-03f, -2.02397183e-02f, -2.08994877e-02f, 7.79962400e-03f, -6.84230998e-02f, 1.60697997e-02f, -1.52556626e-02f, 1.36763398e-02f, 7.88639672e-03f, 5.05511053e-02f,
  -1.32760271e-01f, -1.48406252e-01f, -3.68920974e-02f, -4.26876321e-02f, 3.91766950e-02f, 6.93645701e-02f, 8.71450454e-02f, 6.63719140e-03f, 1.04359584e-02f, 5.80052752e-03f,
  -4.58238646e-02f, -3.78581248e-02f, 1.69464201e-02f, 4.31738682e-02f, 9.10299830e-03f, 6.98949769e-02f, -1.05410554e-02f, 1.35835595e-02f, -1.10711150e-01f, 1.42654907e-02f,
  -1.90572366e-02f, 3.45987752e-02f, 2.26373505e-02f, -6.82824552e-02f, -1.80926286e-02f, -2.05764920e-02f, 3.42265517e-02f, 1.87332015e-02f, 4.00770418e-02f, 3.90974395e-02f,
  -1.29214466e-01f, 1.24081679e-01f, 1.52708218e-01f, -8.44154879e-03f, -5.44276685e-02f, -2.41306633e-01f, -1.80484772e-01f, -4.80364524e-02f, -1.25449836e-01f, 7.06568686e-03f,
  -1.16808325e-01f, 1.31080136e-01f, 1.17193997e-01f, -1.57766655e-01f, -2.20748201e-01f, -3.92415281e-03f, -1.25417218e-01f, -2.25947276e-02f, -4.95078191e-02f, 2.52583902e-02f,
  5.34154754e-03f, -1.48113713e-01f, -6.53373376e-02f, 2.18087737e-03f, -3.86971020e-04f, 1.21107914e-01f, 1.80190608e-01f, 6.89393207e-02f, -5.60918897e-02f, 2.58873776e-02f,
  -1.34756997e-01f, 1.82637349e-02f, -3.14584337e-02f, -6.72352090e-02f, 6.09542727e-02f, 4.23944741e-02f, 4.47498672e-02f, -3.19066085e-02f, 5.95770888e-02f, 7.67911645e-03f,
  4.54671085e-02f, -3.54444161e-02f, -3.86335030e-02f, 1.39738899e-02f, -3.25477421e-02f, 7.93555751e-03f, 3.75449588e-03f, -2.32368186e-02f, 5.33996010e-03f, 2.41029058e-02f,
  5.94688021e-02f, -2.43126694e-02f, 2.72068027e-02f, 2.55209524e-02f, 5.33844940e-02f, 6.41833013e-03f, 3.57633643e-02f, 5.61233945e-02f, -4.05105911e-02f, 1.37615232e-02f,
  -6.16198871e-03f, 6.69130310e-02f, 3.88654023e-02f, -9.72178299e-03f, -1.84052493e-02f, -7.09991604e-02f, 3.68418433e-02f, 1.62819624e-02f, -1.15275793e-02f, 1.05244517e-02f,
  -4.91925366e-02f, 5.47118671e-03f, -5.32486700e-02f, -5.77357709e-02f, 1.89025998e-02f, -2.31522731e-02f, 1.55840404e-02f, 1.46295992e-03f, 3.91209535e-02f, 1.34679703e-02f,
  -3.75400744e-02f, 5.93225211e-02f, 3.05554876e-03f, 4.32100929e-02f, 2.56579593e-02f, 2.91636158e-02f, 4.20545973e-03f, -1.63602550e-02f, -1.98505446e-02f, -1.10164545e-02f,
  1.00848809e-01f, 1.57090724e-01f, -1.19895730e-02f, 3.88680249e-02f, 7.50683695e-02f, 2.11663470e-02f, 6.38816226e-03f, -2.41263416e-02f, 1.33507894e-02f, -3.86626320e-03f,
  9.26066190e-02f, 2.57196911e-02f, -5.33208717e-03f, -3.65817100e-02f, 1.56620406e-02f, -5.76297082e-02f, 8.61981139e-02f, -1.71192903e-02f, 4.74176221e-02f, 2.30462663e-02f,
  8.02479014e-02f, -1.35058230e-02f, 1.43974265e-02f, -2.83682272e-02f, 3.17541622e-02f, 4.49897274e-02f, 5.72670996e-02f, 3.14881206e-02f, 2.86752675e-02f, 2.69063283e-02f,
  2.65636742e-01f, -7.64258578e-02f, 2.89014459e-01f, -7.78444484e-02f, -1.44550055e-02f, 1.23363987e-01f, 7.68277943e-02f, 6.04045251e-03f, 9.80291069e-02f, -1.46648481e-01f,
  -6.39312714e-02f, 1.79742083e-01f, 7.52480924e-02f, -1.91523060e-01f, 1.82538003e-01f, 2.28177514e-02f, -1.06701009e-01f, -6.51882812e-02f, -1.73498057e-02f, -9.32291523e-02f,
  -2.97183823e-02f, -2.74289131e-01f, -4.36225310e-02f, -2.01708406e-01f, -8.94821063e-02f, 2.89460476e-02f, -6.33873641e-02f, -2.95297033e-03f, -2.15678602e-01f, 2.01707371e-02f,
  2.46566646e-02f, 2.52509750e-02f, 5.13109341e-02f, 8.26193914e-02f, 1.06484190e-01f, 5.70164882e-02f, 4.26304862e-02f, 4.02234830e-02f, 3.91170606e-02f, 1.57734174e-02f,
  9.17689502e-02f, 1.06190354e-01f, 1.12808403e-02f, 2.08288915e-02f, -6.25991588e-03f, -2.24176086e-02f, -5.54157123e-02f, -6.09788718e-03f, 8.16119742e-03f, 5.78570552e-03f,
  7.96086937e-02f, -2.45683435e-02f, 4.95624030e-04f, -4.08679433e-02f, -3.02831195e-02f, -2.86620092e-02f, 9.25435126e-03f, 2.30157971e-02f, 3.46800080e-03f, 5.21121034e-03f,
  9.06120986e-03f, 4.65734396e-03f, -2.35044900e-02f, 8.07824824e-03f, 4.06202162e-03f, -1.06727611e-02f, -5.59620149e-02f, -3.02604735e-02f, -4.44977395e-02f, -3.50100435e-02f,
  -2.08036061e-02f, 1.62321737e-03f, -3.98586830e-03f, 3.39901373e-02f, -5.27672358e-02f, 3.75508256e-02f, -2.83356439e-02f, -1.69842560e-02f, 2.75550112e-02f, -5.04611656e-02f,
  -8.14268738e-03f, -2.11571455e-02f, -7.21868947e-02f, -6.99260877e-03f, 3.76737025e-03f, 7.33487457e-02f, -3.07677481e-02f, -1.13738943e-02f, 7.14225508e-03f, 1.95711162e-02f,
  -3.03611159e-02f, -2.06990987e-02f, -2.02543139e-02f, 3.85185331e-02f, 1.42577162e-03f, 5.45069249e-03f, -1.70849338e-02f, -6.29904354e-03f, -3.04943714e-02f, 4.51646410e-02f,
  6.40329570e-02f, -6.44375151e-03f, -5.68529665e-02f, 2.25184094e-02f, 3.31998542e-02f, -1.02353916e-02f, -4.33656536e-02f, 4.78303544e-02f, -2.27221865e-02f, -4.41054665e-02f,
  -4.21018079e-02f, 2.48983167e-02f, -1.19052287e-02f, -3.69961262e-02f, -8.84111226e-02f, -4.36451845e-02f, -2.03042794e-02f, 2.58410559e-03f, -6.81110024e-02f, -2.85874624e-02f,
  -1.16843283e-01f, 3.00275415e-01f, -7.74290860e-02f, 1.77490283e-02f, -2.16505885e-01f, 1.85889211e-02f, 3.01636215e-02f, -6.50379881e-02f, 1.55415386e-01f, 2.44633049e-01f,
  6.54214323e-02f, 9.68199447e-02f, 1.54409602e-01f, 2.08426669e-01f, -2.64034164e-03f, 2.14676574e-01f, 8.93213302e-02f, 5.88034429e-02f, 7.88499117e-02f, -1.16801972e-03f,
  -3.01559828e-03f, 1.09973647e-01f, 5.39299846e-02f, -3.84795889e-02f, -6.32350296e-02f, -1.53271645e-01f, -1.66666940e-01f, -1.11239024e-01f, -4.55295146e-02f, 2.36399006e-02f,
  2.68680193e-02f, 6.55915290e-02f, -4.45907600e-02f, -4.00547273e-02f, -8.79282653e-02f, -1.24811441e-01f, -1.41177028e-01f, 1.40665565e-02f, -5.33694103e-02f, -1.21756215e-02f,
  -6.74376413e-02f, -5.77193908e-02f, -6.79272646e-03f, -2.51391390e-03f, -1.50918413e-03f, -6.74026133e-03f, 5.35951145e-02f, -5.21908738e-02f, 2.03770287e-02f, 7.82067981e-03f,
  2.78791692e-03f, -4.32365984e-02f, -4.29302156e-02f, 5.98849170e-03f, -2.98005007e-02f, -5.01236245e-02f, -4.68058921e-02f, -4.34262166e-03f, 2.69660000e-02f, -4.68799174e-02f,
  -5.12057580e-02f, -2.14649104e-02f, -3.54202208e-03f, 2.06701402e-02f, 5.26791662e-02f, -1.11404108e-02f, 5.15250303e-02f, 6.33909628e-02f, 5.11931181e-02f, 1.39851160e-02f,
  6.21565478e-03f, 5.22850491e-02f, 3.74268764e-03f, 6.60074800e-02f, 3.59682441e-02f, -1.72706731e-02f, 2.17173598e-03f, 2.35281382e-02f, 2.95264367e-02f, -5.64167509e-03f,
  6.66069388e-02f, -3.99067774e-02f, 1.09065194e-02f, -2.61607822e-02f, -1.49452975e-02f, -5.76685704e-02f, 4.54769582e-02f, 6.41158745e-02f, -1.38287200e-02f, -2.46503502e-02f,
  1.02481984e-01f, 5.18644527e-02f, 3.14828493e-02f, 3.99609581e-02f, 1.25588104e-01f, 4.32006679e-02f, -1.11777941e-02f, -2.23271139e-02f, 7.28777498e-02f, 1.84050687e-02f,
  -1.04671612e-01f, -4.37524728e-02f, -8.28167349e-02f, 3.72563563e-02f, -5.82377724e-02f, 4.38569188e-02f, -4.66009825e-02f, 1.11981994e-02f, -7.55309835e-02f, -8.14149715e-03f,
  -5.47775254e-02f, -4.08345796e-02f, -1.46425609e-02f, -3.89631465e-02f, -8.49793404e-02f, -4.18857150e-02f, -8.16508941e-03f, 1.17871771e-02f, 2.69444590e-03f, -4.21372131e-02f,
  -9.12484825e-02f, 1.92606285e-01f, -1.71143651e-01f, -2.13262051e-01f, 1.26141071e-01f, 1.24331051e-02f, -7.91243985e-02f, -4.14453186e-02f, 3.99494842e-02f, -6.43910561e-03f,
  -9.75695476e-02f, 1.02521993e-01f, 1.39407488e-02f, -9.13010836e-02f, -1.44923910e-01f, 1.20632023e-01f, -1.82663128e-01f, -4.97241244e-02f, 5.49917705e-02f, -1.56646132e-01f,
  -6.95384070e-02f, -6.86189458e-02f, -1.22250296e-01f, 1.61278751e-02f, -4.29529026e-02f, -1.94332469e-02f, -2.33397454e-01f, -3.70054245e-02f, -1.61303014e-01f, 1.29174292e-01f,
  8.63300860e-02f, -1.16043828e-01f, -5.35347201e-02f, 1.30844582e-02f, -7.94584304e-02f, -5.92133887e-02f, -4.72778827e-02f, 8.51496216e-03f, -3.45938429e-02f, -1.17914146e-02f,
  -7.84964999e-04f, 1.56547371e-02f, -2.31490061e-02f, 7.33752027e-02f, -8.34427075e-04f, -4.88155074e-02f, 2.24510506e-02f, 1.43338088e-02f, -1.04229022e-02f, 3.34549807e-02f,
  5.06660230e-02f, 3.21874656e-02f, -1.36519313e-01f, -8.38327780e-02f, -8.54846165e-02f, -7.39831030e-02f, 1.67151019e-02f, -2.63884235e-02f, 1.47137614e-02f, -3.74444611e-02f,
  -9.68025997e-03f, -5.41507825e-02f, -5.24095781e-02f, 5.21952957e-02f, -3.99458874e-03f, 5.03531136e-02f, -2.53506517e-03f, 4.82090972e-02f, -2.80646645e-02f, -2.06305571e-02f,
  1.32988719e-02f, -1.39079206e-02f, -8.58200621e-03f, -6.52835220e-02f, -3.39203700e-02f, -4.03352231e-02f, 7.41852727e-03f, -1.36769877e-03f, 9.30295214e-02f, -5.55214249e-02f,
  -5.37405722e-02f, 9.57669038e-03f, 2.42160317e-02f, -3.43215838e-02f, 2.04377603e-02f, -2.71077715e-02f, -5.87321073e-02f, -1.46656167e-02f, -3.86451259e-02f, -7.42010176e-02f,
  -4.05749492e-02f, -3.00907701e-01f, -2.62244437e-02f, 4.09889407e-02f, 6.59089210e-03f, -8.64374265e-03f, 9.44449194e-03f, 3.67610045e-02f, -1.18687056e-01f, 2.87510063e-02f,
  -3.21050622e-02f, 1.02914581e-02f, -2.93625724e-02f, 1.93095934e-02f, 2.88174525e-02f, -3.50753516e-02f, -3.67568135e-02f, -6.82296325e-03f, -1.02808930e-01f, -6.13476038e-02f,
  -4.29568700e-02f, 6.54397309e-02f, -1.05003826e-02f, -3.28509952e-03f, -2.39745788e-02f, -7.57947937e-02f, 3.12079899e-02f, 3.98063995e-02f, -7.75397122e-02f, 1.62675697e-03f,
  -2.08557472e-01f, -1.54566541e-01f, 7.87320063e-02f, -2.64952313e-02f, 9.46159065e-02f, -1.23249292e-01f, -7.85391256e-02f, 1.01514973e-01f, -3.74833420e-02f, -1.33287385e-01f,
  -1.05334058e-01f, -3.20057273e-02f, -1.02174029e-01f, -9.99603271e-02f, -9.86926258e-02f, -8.14997181e-02f, -1.15680575e-01f, -1.39763534e-01f, -1.57559868e-02f, -9.32059214e-02f,
  1.13780893e-01f, -4.86290567e-02f, 1.32795289e-01f, 1.45053551e-01f, 5.57194054e-02f, 1.68945089e-01f, 5.55284787e-04f, 7.34202117e-02f, 8.60951021e-02f, 5.90195432e-02f,
  -7.36336708e-02f, 1.86582934e-02f, 8.04856420e-02f, 5.27712554e-02f, -1.39285838e-02f, -2.09139790e-02f, -2.29625311e-02f, 2.15736143e-02f, 7.60549381e-02f, 1.83318965e-02f,
  -6.50930963e-03f, 5.75265922e-02f, 6.12494126e-02f, -4.84470744e-03f, 7.06492811e-02f, 3.54064479e-02f, 1.52036995e-02f, -3.00187040e-02f, 8.52162912e-02f, 2.40117088e-02f,
  1.31039824e-02f, 1.11574931e-02f, 9.82416049e-03f, -2.49174442e-02f, 7.42842555e-02f, 2.85819266e-02f, 2.46235263e-02f, 2.37566102e-02f, -4.05480973e-02f, -1.71757787e-02f,
  -3.31886075e-02f, 3.67208198e-02f, 1.08923636e-01f, 1.78254601e-02f, 2.98394170e-02f, 6.20235316e-02f, 1.09847384e-02f, 1.26710171e-02f, 6.19357601e-02f, -7.31763095e-02f,
  -1.78138018e-02f, 1.96837280e-02f, -4.74166591e-03f, 3.02268583e-02f, 3.59344035e-02f, 5.48705831e-03f, -1.21601112e-02f, -1.07847843e-02f, 3.58700119e-02f, 5.93394525e-02f,
  -3.22288908e-02f, 2.87837218e-02f, -1.51886640e-03f, 1.06600486e-02f, -2.44960934e-02f, 7.38773867e-02f, 3.31061408e-02f, 2.44041085e-02f, 2.11255159e-02f, 2.45661456e-02f,
  -1.41277060e-01f, -1.76035300e-01f, 5.45721967e-03f, 2.38445960e-02f, -2.66900193e-02f, -2.55604740e-02f, -1.78407766e-02f, 1.89330298e-02f, -5.66628426e-02f, 1.11749209e-02f,
  3.53742316e-02f, 3.00897211e-02f, -3.88468429e-02f, 2.34325808e-02f, -2.48275744e-03f, 1.59875602e-02f, -4.50858735e-02f, -9.01028339e-04f, -9.29094572e-03f, -3.92337590e-02f,
  -5.06721623e-02f, -4.42983471e-02f, 2.21732073e-02f, 6.60034120e-02f, 1.17653143e-02f, 2.86548100e-02f, 2.76469043e-03f, -1.47834315e-03f, -4.24965061e-02f, -2.98449397e-02f,
  -1.29413195e-02f, -2.32136786e-01f, -2.56578743e-01f, 3.10870446e-02f, -6.60172105e-02f, -2.31899068e-01f, -1.88943595e-01f, -4.31221612e-02f, 1.68233309e-02f, 1.47686437e-01f,
  6.10678531e-02f, -6.65648133e-02f, 1.05979070e-01f, -1.03640564e-01f, 9.98652205e-02f, 1.31221384e-01f, -1.15840495e-01f, -8.89208689e-02f, -1.56805634e-01f, -9.98914689e-02f,
  2.08820924e-02f, 5.37233800e-02f, -8.96874592e-02f, -1.06925093e-01f, -1.52099267e-01f, -4.03325222e-02f, 1.89780295e-01f, -1.05824649e-01f, -4.45241518e-02f, -8.08271691e-02f,
  -7.52874017e-02f, 3.45325731e-02f, -8.28535408e-02f, 2.06053965e-02f, -1.55390799e-02f, -4.13675718e-02f, -6.96296524e-03f, -7.46547850e-03f, -1.29797673e-02f, -9.30334479e-02f,
  4.39680666e-02f, 1.21219918e-01f, 3.25774215e-02f, 4.39014845e-02f, -4.39608209e-02f, -3.29215936e-02f, -1.52433692e-02f, -1.39041573e-01f, -2.25201212e-02f, 4.14764807e-02f,
  -6.89987838e-02f, -8.92241597e-02f, 5.25439046e-02f, 6.97017685e-02f, -2.05922127e-02f, -2.12748684e-02f, 2.08347924e-02f, 2.83212569e-02f, -2.63509303e-02f, -2.10624747e-03f,
  2.01222133e-02f, 5.39162606e-02f, 7.03022815e-03f, -6.78992718e-02f, -2.28467900e-02f, -3.92389623e-03f, -2.40294393e-02f, 7.42814168e-02f, -3.73839475e-02f, -8.44087638e-03f,
  2.58450788e-02f, -3.74582224e-02f, 2.58160550e-02f, -6.67548599e-03f, 9.13298503e-03f, -3.27677131e-02f, -2.76631564e-02f, -1.10572819e-02f, -2.76533924e-02f, -4.29888107e-02f,
  9.14106444e-02f, 1.62132476e-02f, 4.57891589e-03f, 3.85760190e-03f, -5.14805727e-02f, -2.96918899e-02f, -3.44909467e-02f, -1.60922222e-02f, 1.09818345e-02f, 3.91852669e-02f,
  -1.48716457e-02f, 1.60767645e-01f, 4.16296013e-02f, -2.16123331e-02f, -6.34365389e-03f, 2.23940574e-02f, 4.11144756e-02f, -7.24923005e-03f, 1.06002511e-02f, 3.60500417e-03f,
  9.92913544e-02f, -1.61091723e-02f, -1.15588950e-02f, -6.57065306e-04f, 2.86047943e-02f, 7.42947534e-02f, -2.93460507e-02f, 8.41426104e-02f, 2.10606772e-02f, -6.39979541e-02f,
  2.49905437e-02f, 3.64816748e-02f, 3.72256935e-02f, 1.03181042e-02f, 6.91875294e-02f, 3.26111866e-03f, -4.65932824e-02f, 1.95090577e-03f, 1.13644833e-02f, 4.44964282e-02f,
  6.86376914e-02f, 3.55313793e-02f, 4.40265760e-02f, -1.34461656e-01f, 3.32963129e-04f, -2.56875396e-01f, -1.88247070e-01f, 9.93020982e-02f, -2.79003512e-02f, -5.54754585e-03f,
  -1.40861854e-01f, 3.69616747e-02f, 2.44137738e-02f, -2.11555004e-01f, -2.99562573e-01f, -1.45978063e-01f, -2.53609270e-01f, -7.91401714e-02f, 6.02900498e-02f, 5.00967279e-02f,
  1.77700203e-02f, -1.11620866e-01f, -1.36744753e-01f, 8.11304748e-02f, 1.24837458e-02f, 1.79227754e-01f, 8.92109349e-02f, 6.67352006e-02f, -4.20605727e-02f, -8.62245113e-02f,
  -1.44345924e-01f, 5.41861542e-02f, 8.77817869e-02f, 6.42287210e-02f, 2.89580459e-03f, 2.47778390e-02f, -2.03879084e-02f, -8.69563073e-02f, -1.00121014e-02f, -1.56816188e-02f,
  5.40829673e-02f, -5.73462294e-03f, 3.37063596e-02f, 2.33239792e-02f, 8.02115072e-03f, -2.10559182e-02f, 3.07039898e-02f, 4.96638101e-03f, -2.22372683e-03f, -7.45442659e-02f,
  -3.99831869e-03f, -1.01115173e-02f, -1.82897430e-02f, -6.24475405e-02f, 2.29147961e-03f, -5.09923324e-02f, 1.13392537e-02f, 4.12505912e-03f, 1.41670322e-02f, -6.00613141e-03f,
  8.17327481e-03f, 3.37421484e-02f, 8.46089050e-03f, -2.72124517e-03f, -4.11357470e-02f, -8.16470683e-02f, 4.23757508e-02f, -2.78057009e-02f, 6.19178973e-02f, -7.69104883e-02f,
  2.01225970e-02f, 2.56334040e-02f, 2.09784377e-02f, 5.84134795e-02f, -7.21975742e-03f, -2.81903911e-02f, -4.92053712e-03f, 8.97952095e-02f, 1.04634315e-02f, -3.50953862e-02f,
  5.04870564e-02f, 1.47134566e-03f, -2.04825774e-02f, 1.80121474e-02f, -7.57568628e-02f, 3.82014886e-02f, 3.77826691e-02f, -6.98636472e-02f, 1.01172119e-01f, 1.35648884e-02f,
  -9.02994443e-03f, 6.77497089e-02f, -5.62760932e-03f, -8.03856850e-02f, -1.53593821e-02f, -1.16404733e-02f, 1.51784932e-02f, 1.43169146e-02f, 2.75813658e-02f, -2.18281560e-02f,
  7.97236431e-03f, 3.09774503e-02f, 1.44938501e-02f, 2.54420023e-02f, -1.81440599e-02f, -1.57439876e-02f, -1.65389497e-02f, -2.12462824e-02f, -1.76726896e-02f, -2.08695568e-02f,
  8.54628161e-03f, -1.49502801e-02f, -2.13451311e-02f, -2.10679485e-03f, 1.38489790e-02f, -1.26564791e-02f, 4.05489355e-02f, 3.73975858e-02f, -9.96700227e-02f, -1.48435896e-02f,
  -8.36155191e-02f, 1.17583498e-01f, 2.68967985e-03f, 1.81556884e-02f, -1.96961358e-01f, -2.72015363e-01f, -2.06774294e-01f, -3.52509059e-02f, -7.73697272e-02f, -5.56440763e-02f,
  -9.77302715e-02f, 4.68893610e-02f, 7.02953637e-02f, -2.88316477e-02f, -1.07526213e-01f, 5.92995062e-02f, -7.89651573e-02f, -7.29457885e-02f, 9.99516100e-02f, -1.34756207e-03f,
  6.58516735e-02f, -6.54722825e-02f, 9.33730081e-02f, -1.67043507e-02f, -8.38372186e-02f, 9.52836871e-02f, 9.39812791e-03f, 1.93868596e-02f, -7.21333474e-02f, -8.36202353e-02f,
  -2.06150692e-02f, 1.06294878e-01f, -2.92682536e-02f, 2.50674952e-02f, -7.29267448e-02f, 3.57222967e-02f, -1.97419040e-02f, -2.55872495e-02f, 4.38573249e-02f, 1.70649346e-02f,
  2.74095102e-03f, 1.25000598e-02f, 1.17391367e-02f, 1.27916923e-02f, 1.46081485e-02f, -3.25662293e-03f, 3.84956375e-02f, 3.05049252e-02f, 5.20515777e-02f, 3.07714362e-02f,
  -4.80794497e-02f, 5.47084697e-02f, -5.90103716e-02f, 6.53284639e-02f, -4.33093980e-02f, -1.66457109e-02f, -4.97729778e-02f, -3.04031782e-02f, -5.17018978e-03f, -4.09824885e-02f,
  -7.87560735e-03f, -8.26076232e-03f, 3.58026056e-03f, -1.04110576e-02f, 2.02406794e-02f, 4.03986834e-02f, -3.58086601e-02f, -3.64424065e-02f, 1.86505709e-02f, 4.22504172e-02f,
  -4.31914255e-02f, 2.09169127e-02f, 2.66882442e-02f, -1.24443443e-02f, -1.37590636e-02f, 6.37439042e-02f, 3.91853554e-03f, 6.19711503e-02f, -6.98894076e-03f, -1.08949520e-01f,
  -1.54659664e-02f, -5.20431772e-02f, 6.37495983e-03f, -5.69395907e-02f, -9.68879461e-02f, 4.68134880e-03f, -1.63085511e-04f, -5.88664040e-03f, 4.81988645e-05f, -1.66876968e-02f,
  -6.83244020e-02f, 2.98724324e-03f, 2.43848725e-03f, -3.58764897e-04f, 1.08624753e-02f, 1.51368824e-03f, 4.86558527e-02f, 1.96808614e-02f, -2.78817229e-02f, 1.62057057e-02f,
  -9.14185215e-03f, -3.34642120e-02f, 2.07740776e-02f, 1.14300447e-02f, -1.27007114e-02f, -9.12773311e-02f, -4.00210060e-02f, -2.13968530e-02f, -7.55549669e-02f, 3.81401107e-02f,
  3.57876793e-02f, -2.76812017e-02f, 1.81022845e-02f, -2.42585018e-02f, -3.22912075e-02f, -6.49563223e-02f, -6.67371079e-02f, -1.11601204e-02f, 3.38801108e-02f, -2.49848831e-02f,
  -3.72585915e-02f, -9.14226770e-02f, 1.28424123e-01f, -5.15092025e-03f, 1.04479790e-01f, 1.69975460e-02f, 8.01535621e-02f, -4.95558679e-02f, 1.45453006e-01f, -1.35547310e-01f,
  -7.19754025e-02f, 1.53054968e-01f, 1.02466969e-02f, -2.08847672e-01f, 6.83220848e-02f, -8.86589065e-02f, -1.96363151e-01f, -1.08785763e-01f, 9.98163670e-02f, -1.90148354e-02f,
  1.08448848e-01f, -1.10254899e-01f, -4.15434577e-02f, -3.19867395e-02f, -5.47305308e-03f, 3.27807553e-02f, -1.45745948e-01f, 1.54235378e-01f, -7.83665776e-02f, 1.68273561e-02f,
  -9.09967124e-02f, 1.43984249e-02f, 7.88044836e-03f, 1.01048360e-02f, -5.58641786e-03f, -2.46117190e-02f, 8.07017311e-02f, 3.44837941e-02f, -2.38733478e-02f, -2.66184248e-02f,
  5.07787578e-02f, 2.06461139e-02f, -1.59025136e-02f, 6.56909272e-02f, 5.94054349e-03f, 8.35443474e-03f, 2.94879284e-02f, -1.34660685e-02f, 2.24174708e-02f, 5.68588711e-02f,
  3.87114398e-02f, 3.36519144e-02f, -4.42720130e-02f, -1.60065014e-02f, -1.63216610e-02f, 5.40484209e-03f, 1.20865041e-02f, 8.21583793e-02f, 4.91386466e-02f, -5.53539814e-03f,
  5.88434897e-02f, 8.18315372e-02f, -5.11678085e-02f, -1.08262822e-01f, -8.27200562e-02f, -6.82283193e-02f, -5.62290475e-02f, -3.64890625e-03f, -5.97060695e-02f, -5.16525917e-02f,
  -7.03275055e-02f, 5.31011894e-02f, 2.93109510e-02f, 3.91563848e-02f, -1.39279775e-02f, -2.33380757e-02f, -4.51142229e-02f, -1.74748264e-02f, -3.50586660e-02f, -1.18201673e-02f,
  2.39289738e-02f, 3.95322926e-02f, -4.40832153e-02f, -3.79667915e-02f, -3.07032280e-02f, 5.58180064e-02f, -1.92184355e-02f, -9.56213684e-04f, -2.65170801e-02f, 1.03001166e-02f,
  -1.39796615e-01f, -5.30247949e-02f, 5.43629564e-02f, 5.68092093e-02f, -4.88299951e-02f, -2.48951688e-02f, 5.27989082e-02f, -1.14209875e-02f, -5.56841958e-03f, -4.43438673e-03f,
  7.14761093e-02f, -3.04562598e-02f, 3.29532400e-02f, -2.08308976e-02f, 7.01777413e-02f, -1.01906462e-02f, -9.90530569e-03f, -2.01287437e-02f, -2.40361392e-02f, -1.54383667e-02f,
  -5.35577349e-02f, -2.84276251e-02f, -2.03544348e-02f, -1.28603373e-02f, -3.08664907e-02f, -7.44072869e-02f, -1.35392207e-03f, 2.26566996e-02f, 8.19586869e-03f, 3.19784097e-02f,
  -1.55207664e-01f, -5.43367118e-02f, 1.33209974e-01f, -8.37387294e-02f, 2.58036405e-01f, -4.97662351e-02f, -5.07070236e-02f, -1.82239544e-02f, -1.73966974e-01f, -1.27905250e-01f,
  2.04822272e-02f, -9.31454077e-02f, -8.42505172e-02f, -4.12734412e-02f, -1.24286845e-01f, -1.89963624e-01f, -1.20018534e-01f, -1.20416440e-01f, 7.82868937e-02f, 4.72273640e-02f,
  -5.70463075e-04f, -4.71787080e-02f, 6.92707598e-02f, 1.22084163e-01f, 1.08334526e-01f, 7.19924495e-02f, -6.66109100e-02f, 1.10347047e-01f, 2.13229991e-02f, 4.09118608e-02f,
  2.65313853e-02f, 1.55153405e-02f, 9.20131505e-02f, -8.42097327e-02f, 2.97717713e-02f, -4.26200069e-02f, -9.62102339e-02f, 6.40573399e-03f, -1.12635065e-02f, 2.85798870e-03f,
  -8.79139528e-02f, -5.52942511e-03f, -3.41697335e-02f, 8.51242244e-03f, -8.01442042e-02f, 9.33657810e-02f, 5.21113165e-02f, 2.58962978e-02f, 6.44599611e-04f, 5.94086573e-02f,
  1.94315612e-02f, 2.73947939e-02f, -6.74775243e-02f, -1.40851125e-01f, -5.15026860e-02f, 7.40813091e-03f, -5.36087668e-03f, 5.54700047e-02f, 6.11942355e-03f, -1.23681789e-02f,
  -8.06392729e-02f, 9.90817510e-03f, 7.11246487e-03f, 6.16635308e-02f, 4.98343706e-02f, 7.83539750e-03f, -2.86409166e-02f, 6.49556965e-02f, 3.79432552e-02f, -9.04958416e-03f,
  -5.47332577e-02f, -2.61161174e-03f, -3.51288542e-02f, -2.25083455e-02f, -4.97184359e-02f, -4.56331149e-02f, -2.41979305e-02f, 1.67064127e-02f, -5.22724539e-02f, 1.39623974e-02f,
  1.81807652e-02f, -2.81979367e-02f, -4.48764767e-03f, 4.47166804e-03f, 3.09708919e-02f, -3.15693878e-02f, 3.23086791e-02f, -2.12000404e-02f, 2.28572283e-02f, 5.12010716e-02f,
  -8.10287148e-02f, -1.65446162e-01f, -3.10949627e-02f, -3.96519639e-02f, 6.81702793e-02f, 1.11896275e-02f, 1.44947646e-02f, -3.71132232e-02f, -1.48718208e-01f, 7.91600905e-03f,
  -5.79277053e-02f, -5.30844741e-02f, -8.82419795e-02f, -8.13683588e-03f, -1.48134129e-02f, -7.71329105e-02f, -1.13504030e-01f, -5.31272925e-02f, -1.52883688e-02f, 3.23081538e-02f,
  8.81590992e-02f, -8.29037353e-02f, -4.05333899e-02f, 1.39024742e-02f, -3.31115089e-02f, -6.57100901e-02f, 4.69221212e-02f, -2.74675060e-02f, 1.85189378e-02f, -4.18295152e-02f,
  3.37965906e-01f, 2.66046524e-01f, 2.79591471e-01f, 2.89410144e-01f, -3.04367244e-02f, 2.53088504e-01f, 2.51291871e-01f, -1.92394834e-02f, 1.69852048e-01f, -1.18850181e-02f,
  -1.04204558e-01f, 2.34977424e-01f, -1.74333706e-01f, 1.40115291e-01f, -5.55473492e-02f, -4.26284224e-02f, 1.51782036e-01f, 9.83234048e-02f, -6.98816776e-02f, 1.23153128e-01f,
  -8.78365338e-03f, -4.87959273e-02f, -3.49773467e-03f, -1.91647202e-01f, 1.46144599e-01f, 7.50595927e-02f, -7.89941102e-02f, -2.64716707e-02f, 3.36689726e-02f, -4.05961089e-03f,
  7.70064220e-02f, -3.40592861e-02f, -1.36951664e-02f, 3.43649015e-02f, -5.11130318e-02f, 3.62417698e-02f, 7.92875588e-02f, -4.99012098e-02f, 2.27302667e-02f, 6.55050739e-04f,
  9.87062883e-03f, -8.07862170e-03f, 4.96643037e-02f, 2.06495682e-03f, 1.96653157e-02f, 5.04336171e-02f, 3.50814238e-02f, 1.14792347e-01f, -7.03379861e-04f, 3.17143351e-02f,
  8.63671824e-02f, 4.19674441e-02f, 2.20598560e-02f, 3.90159450e-02f, 2.29740911e-03f, 1.39335683e-02f, 1.27564669e-01f, 1.26017258e-02f, 8.68701041e-02f, 1.43179782e-02f,
  -8.44150633e-02f, 2.20576972e-02f, -5.04034013e-02f, -3.87733220e-03f, 6.97906641e-03f, -1.11325504e-02f, -1.98366903e-02f, 3.69477295e-03f, 5.47361374e-02f, -8.75816774e-03f,
  3.05701196e-02f, 1.84769202e-02f, 9.63620935e-03f, 3.55461724e-02f, 5.04511688e-03f, -1.98733769e-02f, -1.83435474e-02f, -3.98188867e-02f, 6.26503825e-02f, -2.50402149e-02f,
  -3.54965590e-02f, 2.71714441e-02f, -2.72144191e-02f, -2.03441009e-02f, 1.16170687e-03f, -4.38483730e-02f, -4.21681590e-02f, -1.78063416e-03f, 1.94533495e-03f, -1.85937174e-02f,
  -1.99369732e-02f, 7.87256062e-02f, 4.89191189e-02f, -3.21152732e-02f, -4.45664227e-02f, -1.78454840e-03f, -3.05142459e-02f, 5.39206713e-02f, 1.09821456e-02f, -2.74401736e-02f,
  7.94823542e-02f, 5.44895753e-02f, 5.59692867e-02f, 3.44484858e-02f, -4.23907451e-02f, -5.99337835e-03f, -3.56926695e-02f, -1.47841349e-02f, 2.17961278e-02f, -7.75375143e-02f,
  -8.93295836e-03f, -4.03729007e-02f, 1.66402882e-04f, 1.11242197e-02f, 8.89762957e-03f, 3.38470899e-02f, 6.47646040e-02f, 3.25868167e-02f, -3.34279016e-02f, 9.92411654e-03f,
  7.34435767e-02f, -1.08325481e-01f, -7.50468373e-02f, 1.59869492e-01f, -2.76788753e-02f, -8.19230229e-02f, 4.39729020e-02f, 1.58788219e-01f, -2.44645141e-02f, -9.19075403e-03f,
  1.37552589e-01f, -5.15669882e-02f, -4.58926186e-02f, 1.78186432e-01f, 1.58333465e-01f, 4.35022786e-02f, 1.71749428e-01f, 1.14545189e-01f, 1.97150968e-02f, 9.64738578e-02f,
  1.56694278e-01f, 7.24556595e-02f, 1.04910038e-01f, 1.00719154e-01f, -2.54559182e-02f, -8.58434662e-03f, 2.09198087e-01f, -1.24779485e-01f, 1.05612569e-01f, 4.82896063e-03f,
  3.23939212e-02f, -3.08862962e-02f, 1.38312820e-02f, -1.78094301e-02f, -9.51974280e-03f, -9.81802940e-02f, -4.54591066e-02f, -4.85664196e-02f, 3.81839722e-02f, 2.61579044e-02f,
  -5.80822863e-02f, 3.76578383e-02f, -4.15134467e-02f, 1.57511644e-02f, -8.21917690e-03f, -4.11841134e-03f, 3.34203951e-02f, -1.64276753e-02f, 1.69224013e-02f, 9.76118892e-02f,
  -9.28683951e-03f, -1.26891024e-02f, -1.25782229e-02f, -2.49753427e-02f, 5.32943979e-02f, -1.06166592e-02f, 2.66700853e-02f, 4.04619128e-02f, -4.84833755e-02f, 6.15576142e-03f,
  2.97676437e-02f, -2.25409195e-02f, -1.36746587e-02f, -1.14319399e-02f, -4.43121977e-02f, 4.85060830e-03f, -1.97930168e-02f, 5.85239008e-02f, -6.59849271e-02f, -2.57083196e-02f,
  -1.21066570e-02f, 4.25077509e-03f, 4.63763252e-03f, 3.03103011e-02f, 3.01703792e-02f, -2.72324495e-02f, -3.68006192e-02f, -6.67830184e-03f, 4.32191640e-02f, 6.77321926e-02f,
  -8.47678725e-03f, 2.91843582e-02f, -5.21190045e-03f, -8.57764296e-03f, -5.88306561e-02f, 5.39768636e-02f, 9.98294204e-02f, -8.31776857e-02f, 9.46940295e-03f, 1.57190468e-02f,
  -2.67675426e-02f, 8.83425549e-02f, 3.97258848e-02f, -1.17538404e-02f, -1.26343682e-01f, -5.17528541e-02f, 6.81059733e-02f, -1.96164269e-02f, -1.02627068e-03f, -7.29103163e-02f,
  -1.73721910e-02f, 2.17147823e-02f, -6.49408698e-02f, -2.16912734e-03f, -1.77578852e-02f, 7.63034895e-02f, -4.93708104e-02f, -6.84871376e-02f, 2.94757579e-02f, 5.85263669e-02f,
  -1.10722883e-02f, -1.83325242e-02f, -3.61957997e-02f, -4.55903672e-02f, 3.57101634e-02f, -1.67711359e-02f, -2.50549912e-02f, 2.03431435e-02f, 2.34305989e-02f, -7.35941855e-03f,
  -4.58230495e-01f, -4.68941312e-03f, -1.31811067e-01f, -5.66273071e-02f, -2.26517823e-02f, -2.10096300e-01f, -1.62809148e-01f, -6.95916452e-03f, -1.08738504e-01f, -3.14607844e-02f,
  -4.89833802e-02f, -1.26553267e-01f, -2.46137334e-03f, -9.53048840e-02f, -1.58036649e-02f, 2.53826715e-02f, -8.45155790e-02f, -7.87939355e-02f, -5.36747416e-03f, -2.81314217e-02f,
  -3.37969586e-02f, 1.60606652e-02f, -7.92155694e-03f, 6.80776834e-02f, -1.47678897e-01f, 4.36687358e-02f, 1.30518660e-01f, 1.07059916e-02f, 6.16586246e-02f, -1.84088517e-02f,
  -1.18061760e-02f, -1.99727751e-02f, -8.24558921e-03f, -7.48395249e-02f, -6.65050149e-02f, -6.85347393e-02f, 2.09331196e-02f, 2.16242429e-02f, -5.22031961e-03f, -5.87696489e-03f,
  -1.51371229e-02f, 2.06729528e-02f, -2.02481057e-02f, -2.61119623e-02f, -4.58752103e-02f, -2.55266968e-02f, -9.72951110e-03f, 6.83811354e-03f, -2.90232189e-02f, -3.52680646e-02f,
  -8.19656439e-03f, -1.61735769e-02f, 4.99661174e-03f, 9.19461157e-03f, -1.10594882e-02f, -5.15683629e-02f, -2.14513354e-02f, -9.73005593e-02f, -3.43383402e-02f, 1.41983423e-02f,
  -6.61712289e-02f, -7.16697099e-03f, 2.30168402e-02f, -5.00236154e-02f, 1.41915884e-02f, 5.42546622e-02f, 1.87668018e-02f, 4.81239632e-02f, -3.76629010e-02f, -6.42621005e-03f,
  2.23178952e-03f, -2.06036437e-02f, 1.67396218e-02f, -7.02582020e-03f, -9.95821320e-03f, 1.52832353e-02f, -7.09696067e-03f, -7.66592752e-03f, -2.39808317e-02f, 2.04983205e-02f,
  3.93384025e-02f, -4.81478199e-02f, 3.14034373e-02f, 1.35882478e-02f, 5.93185239e-02f, -3.37902233e-02f, 2.45334469e-02f, 2.43369788e-02f, 7.09212036e-05f, 3.74107249e-02f,
  -5.86171560e-02f, 1.09793156e-01f, 4.59239483e-02f, -4.53578867e-02f, 7.62940049e-02f, -1.97015461e-02f, -7.46636186e-03f, -3.52253988e-02f, 6.07131533e-02f, 2.93531432e-03f,
  -3.13633531e-02f, -1.97306443e-02f, 8.03340077e-02f, -4.27237805e-03f, -1.56698953e-02f, -7.29850819e-03f, 2.83324048e-02f, 4.80318628e-02f, 3.10880207e-02f, 7.32352212e-02f,
  1.89414341e-02f, -2.14027986e-02f, 3.85002755e-02f, -1.60776079e-02f, 3.46960761e-02f, 2.91779581e-02f, 2.73833480e-02f, -2.92625595e-02f, 9.67312902e-02f, 4.83516306e-02f,
  -2.70627797e-01f, -1.52966946e-01f, 5.24813458e-02f, -8.17858502e-02f, 1.91733204e-02f, 1.70062378e-01f, 2.39571139e-01f, -8.08150098e-02f, -2.36611426e-01f, -7.63133392e-02f,
  -1.83379352e-02f, -1.22769199e-01f, -1.22348210e-02f, 2.86810473e-02f, 5.58824725e-02f, -6.14756420e-02f, 6.10499941e-02f, -2.24180962e-03f, -1.18828356e-01f, 1.12008229e-02f,
  -1.22763347e-02f, 3.68362367e-02f, 1.43293098e-01f, -1.58139374e-02f, 8.42955485e-02f, -1.41129062e-01f, 2.56300867e-02f, 1.48329318e-01f, 5.34767918e-02f, -1.27494652e-02f,
  7.23869503e-02f, -1.42102599e-01f, 6.32720962e-02f, -3.32108252e-02f, 1.00384019e-01f, 1.04367100e-01f, 1.41479179e-01f, 4.28312495e-02f, 3.34272645e-02f, -1.35071883e-02f,
  5.42248972e-02f, -2.47218944e-02f, -4.59437557e-02f, -2.23071985e-02f, 2.44834069e-02f, -2.71338318e-02f, 6.99716955e-02f, -6.81138085e-03f, 5.32488152e-02f, -2.69214995e-02f,
  1.29371826e-02f, 6.74080700e-02f, 2.89570671e-02f, 1.59181352e-03f, 3.52197327e-02f, -1.56682935e-02f, 7.04197772e-03f, 3.01864706e-02f, 4.35855277e-02f, 3.33987921e-03f,
  -8.07030201e-02f, 2.15516724e-02f, 4.05787578e-04f, -4.31005806e-02f, -3.78426500e-02f, -5.86620159e-03f, -1.99138597e-02f, -2.16226283e-04f, -6.12570718e-02f, 1.37756448e-02f,
  1.16248615e-02f, 1.25469323e-02f, 5.99769838e-02f, -2.99613196e-02f, -6.26690909e-02f, 1.98972840e-02f, 3.44044231e-02f, -9.49374679e-03f, 2.46364176e-02f, -4.96241078e-02f,
  -1.32615920e-02f, 4.39603664e-02f, -5.90848811e-02f, 2.33596172e-02f, 1.53975328e-02f, -3.76574174e-02f, -9.21657607e-02f, -1.11336075e-01f, 1.84659902e-02f, 2.77044047e-02f,
  1.15541192e-02f, -1.49547532e-01f, -4.61385250e-02f, 6.30559027e-02f, 2.05237940e-02f, 4.78671379e-02f, 4.57221083e-02f, -1.05717760e-02f, -8.77627879e-02f, 1.04930729e-01f,
  -4.24579578e-03f, -1.44592160e-02f, 6.46319315e-02f, 3.84299122e-02f, -2.33584642e-02f, -5.04462570e-02f, -4.59089279e-02f, 9.69409570e-03f, 2.69798711e-02f, 1.26746343e-02f,
  -3.97754349e-02f, -1.33270808e-02f, -4.93048802e-02f, -4.19092216e-02f, 3.03076743e-03f, -1.93779655e-02f, -6.49524555e-02f, -2.13078298e-02f, -2.93056131e-03f, -2.76274327e-02f,
  1.72415018e-01f, 2.33924901e-03f, -1.02944031e-01f, 7.97123536e-02f, -5.36569394e-02f, 2.94934869e-01f, 2.70413101e-01f, -1.93614960e-02f, 1.12622939e-01f, 9.11231115e-02f,
  1.17636546e-01f, -2.03504171e-02f, 9.57025439e-02f, 2.99415559e-01f, 1.23626493e-01f, 1.81642532e-01f, 1.63822815e-01f, 1.66014001e-01f, 2.56365421e-03f, 4.48794328e-02f,
  2.62402501e-02f, 2.21642777e-01f, -5.21664247e-02f, -7.80825540e-02f, -4.31960896e-02f, -1.91936478e-01f, -1.16947219e-01f, -1.42741889e-01f, -6.45225868e-02f, 5.51026464e-02f,
  8.48598778e-02f, 6.53731003e-02f, -1.02456324e-01f, 2.20272541e-02f, 2.72347238e-02f, -7.20182657e-02f, -8.89019016e-03f, 7.20302062e-03f, 3.66394245e-03f, 5.27635738e-02f,
  4.94714603e-02f, -3.36979702e-02f, 4.12569903e-02f, -3.66790853e-02f, 3.55432881e-03f, -4.70611602e-02f, -6.09665476e-02f, -4.79141288e-02f, -3.15826163e-02f, -3.51412855e-02f,
  -4.14566509e-02f, 1.12563828e-02f, 2.65585333e-02f, 3.02441400e-02f, 5.34525933e-03f, 2.47507934e-02f, -2.49415636e-02f, -5.66062294e-02f, -2.47827638e-02f, 2.80003902e-02f,
  6.91633150e-02f, 3.23008075e-02f, 2.07340326e-02f, -7.20508769e-02f, 2.40380783e-02f, -1.97776146e-02f, 6.41943812e-02f, 2.21469719e-02f, -1.14936298e-02f, 3.13106887e-02f,
  4.19883020e-02f, -2.25722343e-02f, 2.58618258e-02f, 2.19008755e-02f, 2.83671021e-02f, -2.57873512e-03f, -4.56977710e-02f, 1.41493266e-03f, -1.27446437e-02f, -1.23880513e-03f,
  3.40559185e-02f, 3.11485231e-02f, -6.11868277e-02f, 3.95395868e-02f, 4.97376882e-02f, -1.41925104e-02f, 7.62926880e-04f, -3.06928176e-02f, -5.18376119e-02f, 6.15975074e-03f,
  1.12924613e-01f, 1.03307568e-01f, -2.87625156e-02f, 5.04324446e-03f, -3.36034945e-03f, -3.99422534e-02f, 7.77403861e-02f, 2.08873525e-02f, -1.22027658e-02f, 1.86750684e-02f,
  -7.76253715e-02f, -8.47410262e-02f, 9.73042846e-03f, -9.97172389e-03f, 7.40131438e-02f, -2.92516928e-02f, 6.21046312e-02f, -6.84561208e-03f, 4.73446958e-02f, -6.30611181e-02f,
  -3.73863503e-02f, 1.76820587e-02f, -9.31983441e-03f, -7.18860105e-02f, -2.00143624e-02f, -2.09625135e-03f, 4.65972982e-02f, 9.20761283e-03f, -3.62573639e-02f, 5.61286397e-02f,
  -3.81126851e-01f, 4.44893874e-02f, 1.27122477e-01f, -1.89634845e-01f, -1.96545526e-01f, -1.46924004e-01f, 6.59404993e-02f, -9.82065797e-02f, -8.98010731e-02f, 8.04591104e-02f,
  -3.99611657e-03f, 8.36320594e-02f, 1.93033963e-01f, 2.56329551e-02f, -4.30007949e-02f, 1.84407920e-01f, -1.37720615e-01f, 1.00243734e-02f, 6.68323115e-02f, -1.14800915e-01f,
  -9.07189548e-02f, -4.55338843e-02f, 1.10022545e-01f, -7.08903894e-02f, -1.53706700e-01f, -1.87199980e-01f, -9.69802886e-02f, 4.02414352e-02f, -1.83681473e-01f, -4.34188209e-02f,
  -1.31906301e-01f, 6.77608326e-03f, 4.62900428e-03f, 3.08702588e-02f, -6.59094080e-02f, 1.66595466e-02f, -5.46616241e-02f, 1.16364621e-01f, 6.44404814e-03f, 1.13130296e-02f,
  -7.67941447e-03f, 3.68816033e-03f, -6.00940324e-02f, 4.05504880e-03f, -1.47798195e-01f, -3.60907763e-02f, 8.75627680e-04f, 2.04351097e-02f, 7.02019185e-02f, 3.25955972e-02f,
  7.72815570e-02f, -5.39950095e-02f, -1.82154607e-02f, -7.02121705e-02f, 2.32432596e-02f, 2.66619842e-04f, 8.65511410e-03f, 8.17626435e-03f, -9.85114276e-02f, -1.10768527e-01f,
  6.75218627e-02f, 1.70649756e-02f, 1.65635291e-02f, 5.92471249e-02f, -8.46094731e-03f, -1.85490176e-02f, -4.49544750e-02f, 4.43838723e-02f, -4.09784168e-02f, -2.52938569e-02f,
  -5.48563823e-02f, -6.60619959e-02f, 1.14458473e-02f, 2.95776501e-02f, -3.02495118e-02f, 1.24965096e-02f, 3.39423902e-02f, -7.55370706e-02f, -5.70813045e-02f, -1.44424997e-02f,
  4.11858596e-02f, -1.54620782e-02f, 2.15960331e-02f, 1.13224359e-02f, 3.47317085e-02f, 4.12902143e-03f, -7.42547773e-03f, 2.35645752e-02f, -8.10441561e-03f, -2.68585850e-02f,
  -2.42892444e-01f, -2.54966468e-01f, 6.14843927e-02f, -2.13713776e-02f, -9.75228325e-02f, -3.53460610e-02f, 3.66310403e-02f, 2.13802867e-02f, -8.76670778e-02f, -1.95857231e-02f,
  -1.85226947e-02f, 8.74220580e-03f, -7.00254962e-02f, -1.42248475e-03f, 8.21467414e-02f, -4.13885228e-02f, -5.83187342e-02f, -8.18248466e-02f, -6.23657182e-02f, -6.54470921e-03f,
  1.58815980e-02f, 7.48083787e-03f, 2.09654458e-02f, 1.88027248e-02f, -5.01741506e-02f, -2.78475396e-02f, -9.61511433e-02f, 2.29026913e-03f, -8.08743834e-02f, 1.71262044e-02f,
  1.45367339e-01f, -4.32286002e-02f, -6.15622699e-02f, 1.23612352e-01f, 1.11558497e-01f, -1.67617872e-01f, -2.93270826e-01f, 1.22592226e-01f, -8.77670497e-02f, -7.03481063e-02f,
  3.12252454e-02f, -1.23653151e-01f, -1.77217156e-01f, -6.92814216e-02f, -6.07480071e-02f, -1.53005570e-01f, -6.69376850e-02f, -3.04427948e-02f, -1.07844487e-01f, 3.55279669e-02f,
  1.25716487e-02f, 4.54117544e-02f, -6.35140017e-02f, 1.15137391e-01f, 5.08709215e-02f, 1.36703774e-01f, 1.19681798e-01f, 2.97722798e-02f, 1.66227996e-01f, 1.30288256e-02f,
  -7.67093450e-02f, -6.31853752e-03f, -5.74203730e-02f, -2.25307085e-02f, -3.13858711e-03f, 4.44505066e-02f, 1.53168375e-02f, -2.77318470e-02f, 2.22953092e-02f, -1.68900397e-02f,
  2.78704558e-02f, -1.18645197e-02f, 4.52172309e-02f, -1.34944366e-02f, 1.52512612e-02f, 1.99315716e-02f, -5.99114336e-02f, -4.20765998e-03f, -4.39214110e-02f, -9.18522254e-02f,
  -5.54907462e-03f, 3.22790518e-02f, 4.45333309e-02f, -2.58140564e-02f, -2.76083853e-02f, -3.31010781e-02f, -5.94354887e-03f, 8.88367742e-03f, 3.85357440e-02f, 5.27504757e-02f,
  8.11851472e-02f, 4.42401581e-02f, 2.23996444e-03f, -3.83582190e-02f, -4.99711037e-02f, -2.48198118e-02f, -5.84910884e-02f, -4.27354649e-02f, -1.71481501e-02f, 3.38708572e-02f,
  3.01427413e-02f, 1.19185457e-02f, -3.63173261e-02f, 5.30128554e-02f, 2.43142545e-02f, -7.10121263e-03f, 3.40170264e-02f, -5.65800304e-03f, -4.40489268e-03f, -1.08493119e-02f,
  -1.04122479e-02f, 5.90618933e-03f, 1.59081742e-02f, -3.86942327e-02f, -3.10159847e-02f, -5.56319766e-03f, 6.09032437e-03f, 2.98876269e-03f, -3.15072350e-02f, 3.21839564e-02f,
  1.25677176e-02f, 1.34462863e-01f, -7.70273879e-02f, 6.45704195e-02f, -3.10997870e-02f, 6.70390250e-03f, -4.00525443e-02f, 3.77764031e-02f, -1.13984505e-02f, 3.13348137e-02f,
  1.72222294e-02f, -8.91382660e-05f, 7.18157664e-02f, 4.91547063e-02f, 6.89443126e-02f, 6.03911839e-02f, 1.52950892e-02f, -2.80998759e-02f, 3.94391827e-02f, 5.10596745e-02f,
  1.56216800e-01f, 9.44877639e-02f, -8.11769292e-02f, -3.16285752e-02f, -2.69538444e-02f, 4.54179458e-02f, 1.74259748e-02f, 4.85718958e-02f, -7.11783487e-03f, -5.85839525e-02f,
  -2.81466603e-01f, 1.85007587e-01f, 2.60880906e-02f, 1.28469601e-01f, -4.35613841e-02f, 9.37216654e-02f, 1.62213206e-01f, 9.99419466e-02f, -4.19199243e-02f, 1.07446983e-01f,
  9.82740745e-02f, -8.37892219e-02f, -2.18112394e-02f, 1.94292203e-01f, -1.92075789e-01f, -1.13288634e-01f, 9.17489603e-02f, 1.21184096e-01f, 7.73042664e-02f, 1.76584825e-01f,
  6.84334943e-03f, 1.77909285e-01f, -3.58497575e-02f, 2.23172218e-01f, 5.00363335e-02f, 5.72695769e-02f, -1.20110258e-01f, 2.67716888e-02f, 1.41123801e-01f, -2.71437205e-02f,
  1.12231802e-02f, 3.11381090e-02f, -9.40233469e-02f, -2.75664944e-02f, -2.40399502e-03f, 3.29308100e-02f, 6.49319440e-02f, -9.84450430e-02f, -9.44273472e-02f, 1.41488444e-02f,
  -4.05147038e-02f, -2.60898676e-02f, 1.48468139e-03f, -6.06779940e-03f, 2.73500942e-02f, -4.35228497e-02f, 2.47978233e-02f, 2.66131908e-02f, -9.88023132e-02f, -7.17651770e-02f,
  8.12854022e-02f, 1.86098311e-02f, -3.43538523e-02f, -6.37644455e-02f, -2.53734551e-02f, 2.55233666e-04f, 4.76778895e-02f, -1.09523222e-01f, 4.45902310e-02f, 3.57903056e-02f,
  -1.60626844e-02f, 2.42848769e-02f, -2.73137297e-02f, -1.57544930e-02f, 7.67437592e-02f, 2.71827728e-02f, 7.37222657e-02f, 1.47430710e-02f, 4.42564413e-02f, -5.75518198e-02f,
  -4.41736132e-02f, -1.70070622e-02f, 2.77369414e-02f, 8.91100336e-03f, 1.05860658e-01f, 2.09536590e-02f, -1.06497519e-01f, 1.98717564e-02f, 7.16896504e-02f, -8.96301866e-03f,
  1.63711384e-01f, 4.25308049e-02f, 4.72612865e-02f, -3.51995453e-02f, -5.04352264e-02f, -5.36058694e-02f, 1.22322161e-02f, -7.64145851e-02f, -3.08153536e-02f, -6.51880130e-02f,
  8.49015862e-02f, 1.04567192e-01f, -8.69900584e-02f, -1.65121239e-02f, -3.43623236e-02f, -6.47488534e-02f, 7.39966007e-03f, -2.23461445e-02f, -2.92585958e-02f, 7.29885027e-02f,
  8.53553712e-02f, -2.98960619e-02f, 2.28054821e-02f, 4.06070128e-02f, 3.31355929e-02f, 7.15506002e-02f, 1.30272862e-02f, 6.35273708e-03f, 2.57846415e-02f, 3.86118852e-02f,
  3.55284065e-02f, -7.10163498e-03f, -1.46198608e-02f, 1.95516217e-02f, -5.60152568e-02f, -9.11074877e-03f, -1.11067323e-02f, -8.53242427e-02f, -5.14754094e-02f, 3.42118144e-02f,
  -2.17895478e-01f, -1.04880996e-01f, -2.20557928e-01f, -1.86088815e-01f, -5.65723740e-02f, 1.06641605e-01f, 9.67799276e-02f, -6.71937093e-02f, -1.02269985e-01f, 1.85801208e-01f,
  7.80479908e-02f, -9.56740528e-02f, 1.56431943e-01f, 1.05572576e-02f, 2.30945516e-02f, 1.23416699e-01f, -5.63567169e-02f, -8.32438841e-02f, -8.17555115e-02f, -1.46811446e-02f,
  -4.91314791e-02f, 8.48340169e-02f, -7.92156234e-02f, 4.96709719e-02f, -9.16697085e-02f, -9.69261527e-02f, 9.53207240e-02f, -6.10329099e-02f, -5.52747492e-03f, 4.02799286e-02f,
  2.40305737e-02f, -4.34857905e-02f, -3.97545435e-02f, 4.31263372e-02f, -6.64862916e-02f, -6.12527831e-03f, 6.55428022e-02f, 2.28739418e-02f, -3.63597344e-03f, 2.88089644e-02f,
  9.73783582e-02f, 1.06499307e-01f, 6.73010200e-02f, 3.89681943e-02f, -7.11711720e-02f, -2.66528148e-02f, 1.53429070e-02f, -6.95213377e-02f, -3.48371565e-02f, 3.29199396e-02f,
  -1.03024915e-01f, -9.25954953e-02f, -8.80782753e-02f, -9.74892918e-03f, -7.07243010e-02f, 1.33837238e-02f, 1.91255994e-02f, -3.44992355e-02f, 4.27950956e-02f, -2.29737833e-02f,
  -3.67271677e-02f, 2.71537490e-02f, 4.05918621e-02f, 3.28058898e-02f, -1.85960308e-02f, -3.49123329e-02f, -2.91521121e-02f, -2.05250215e-02f, -1.45295663e-02f, -4.19797264e-02f,
  -2.65149642e-02f, -3.53810191e-02f, -1.41813690e-02f, -1.31023163e-02f, -2.94142384e-02f, 2.18513627e-02f, 2.74029449e-02f, 1.68399997e-02f, -7.59264529e-02f, -1.21827060e-02f,
  -1.87373534e-02f, -6.92103291e-03f, -3.60712856e-02f, 5.67409024e-03f, -5.52705862e-02f, 6.41638264e-02f, 2.15130635e-02f, -4.05103788e-02f, 5.11888601e-03f, 1.97358504e-02f,
  -3.84082925e-03f, 1.07971668e-01f, 2.04158090e-02f, -4.10081865e-03f, -1.34405699e-02f, 4.29935679e-02f, -3.04576438e-02f, 2.74838135e-02f, -8.08189362e-02f, 3.58527675e-02f,
  2.07819846e-02f, -1.48469582e-02f, 8.09982046e-03f, -2.85965740e-03f, -2.32610647e-02f, 8.99569914e-02f, 6.29037991e-02f, -7.34927831e-03f, 1.30913137e-02f, 7.82484841e-03f,
  3.42929922e-02f, 1.67200193e-02f, -2.19454113e-02f, -7.67300799e-02f, 2.06154250e-02f, -1.41410427e-02f, -4.49867323e-02f, -3.04097477e-02f, 2.75238510e-02f, -3.74660566e-02f,
  3.18742186e-01f, 2.74451464e-01f, 2.45359857e-02f, 1.15735523e-01f, -1.67847760e-02f, 2.19000921e-01f, 8.62464905e-02f, 4.94082756e-02f, 1.89488366e-01f, 9.04690921e-02f,
  -1.15400247e-01f, 1.01308115e-01f, -6.80541098e-02f, 9.09776241e-02f, -1.04054466e-01f, 3.48957852e-02f, 1.40700385e-01f, 5.72272651e-02f, 1.08569898e-01f, 1.28302470e-01f,
  8.22705701e-02f, 3.93780246e-02f, -5.80801181e-02f, -1.20681338e-02f, 2.52060406e-02f, 1.06601574e-01f, -1.94171295e-02f, -7.18236193e-02f, 5.10653071e-02f, -1.02624074e-01f,
  1.37120187e-01f, 7.47803785e-03f, 8.90851319e-02f, 2.04001758e-02f, 4.13333997e-02f, -6.82192370e-02f, -1.15299206e-02f, -6.34733737e-02f, -3.62981185e-02f, 3.62621248e-02f,
  3.37532200e-02f, -4.27240208e-02f, 3.04775871e-02f, 2.21023466e-02f, 7.47623071e-02f, -2.99520511e-02f, 1.75612755e-02f, 2.98231952e-02f, 6.63534030e-02f, -4.55691852e-02f,
  -8.60747397e-02f, 3.56522165e-02f, 3.91153954e-02f, 1.66138094e-02f, -2.22056769e-02f, 6.53170720e-02f, -3.56845860e-03f, -8.54168274e-03f, 1.01006022e-02f, 2.89782528e-02f,
  -3.10559943e-02f, 2.43231002e-02f, 3.67791094e-02f, 4.89262193e-02f, 1.99255459e-02f, -3.65890898e-02f, -1.22380478e-03f, -3.31867114e-02f, 1.94171164e-02f, 2.86290459e-02f,
  4.35266793e-02f, -2.07988676e-02f, -5.12138335e-03f, 2.36630142e-02f, -1.24914497e-02f, 3.40144187e-02f, 5.47185130e-02f, 7.05246627e-02f, -6.67711860e-03f, -8.92933458e-03f,
  -3.20101436e-03f, 2.63725258e-02f, -7.00281933e-02f, -6.17195591e-02f, 1.58939417e-02f, -4.91170911e-04f, 5.15312850e-02f, -4.98366496e-03f, 1.79670975e-02f, 1.06275184e-02f,
  2.24469498e-01f, 2.10689679e-01f, 9.62530077e-02f, 9.26179811e-02f, 2.70473845e-02f, -3.60527495e-03f, 5.67948632e-02f, 2.86611579e-02f, 9.55755562e-02f, 1.10828290e-02f,
  5.60962735e-03f, 2.33538616e-02f, -2.64813062e-02f, 8.76862556e-02f, -6.22146111e-03f, -4.23136307e-03f, 2.00498588e-02f, 6.17317297e-02f, 1.58667623e-03f, 4.17905254e-03f,
  -1.44953802e-02f, -4.05243225e-02f, -3.13430838e-02f, 1.23670110e-02f, 1.13811111e-02f, 7.83114345e-04f, 3.48800197e-02f, 1.15678562e-02f, -6.56004474e-02f, 2.31093843e-03f,
  1.43108010e-01f, 1.46519780e-01f, 1.25827342e-01f, 1.15613669e-01f, 1.93848267e-01f, 9.22864825e-02f, -3.17301936e-02f, 1.61449656e-01f, 9.68646854e-02f, -9.25770849e-02f,
  1.16770578e-04f, -1.12682693e-01f, -2.22958952e-01f, 5.44534475e-02f, -2.10304871e-01f, -1.44774064e-01f, 1.09802008e-01f, 1.20471977e-02f, 8.23805556e-02f, 3.74269523e-02f,
  4.90548313e-02f, 2.86556836e-02f, -6.07843846e-02f, 1.12008438e-01f, 1.68608785e-01f, 1.37368411e-01f, -7.59245679e-02f, 8.65616724e-02f, 1.35840431e-01f, 6.66064546e-02f,
  -4.55025025e-02f, 7.23168924e-02f, 4.03849445e-02f, -9.49813649e-02f, -3.16560306e-02f, 1.34808859e-02f, -9.85142123e-03f, 9.49400105e-03f, 4.72698770e-02f, 6.30443916e-03f,
  -7.10701719e-02f, -3.71799134e-02f, -3.52917463e-02f, 2.76887268e-02f, 3.54780369e-02f, 4.35721166e-02f, 1.36863058e-02f, 1.71131548e-02f, -6.91671099e-04f, 3.96175757e-02f,
  -2.88547780e-02f, -1.20659620e-02f, 5.24110068e-03f, 2.79782861e-02f, 1.92979332e-02f, 4.92549650e-02f, -5.05938642e-02f, 4.17027548e-02f, 5.89569972e-04f, 6.46203905e-02f,
  -6.37521315e-03f, 5.06998450e-02f, -1.26307262e-02f, -1.45783182e-02f, 2.39286013e-02f, 4.69937734e-02f, -2.58222688e-02f, -6.01488091e-02f, 4.97121215e-02f, -1.14300326e-02f,
  7.41840946e-03f, 2.40426213e-02f, 4.84532258e-03f, -4.16346155e-02f, 1.58456974e-02f, -6.09612046e-03f, -4.54338193e-02f, 6.11997508e-02f, 1.23392344e-02f, -1.85415260e-02f,
  -9.25143994e-03f, -6.22598715e-02f, 3.65429781e-02f, 3.22299614e-03f, 4.60637137e-02f, -5.29178828e-02f, 3.10913958e-02f, 2.76326276e-02f, -1.52709074e-02f, -6.52630851e-02f,
  6.69555590e-02f, 3.44009176e-02f, -4.82458174e-02f, -2.60480810e-02f, 1.36460476e-02f, -9.63667873e-03f, 4.34140153e-02f, 8.41029584e-02f, 3.37800458e-02f, -4.30062041e-02f,
  7.27215456e-03f, 2.74542179e-02f, -9.96164326e-03f, 6.48980811e-02f, 4.49891959e-04f, 2.82518612e-03f, -7.04803541e-02f, -5.03586344e-02f, 4.09593200e-03f, 9.44685098e-03f,
  -7.41087273e-02f, -5.02011627e-02f, -7.83365518e-02f, 5.06391525e-02f, -9.30350740e-03f, -3.49653699e-02f, 3.42607386e-02f, 1.29418410e-02f, -3.18737589e-02f, 1.59549899e-02f
};

// L0_fan_Wp_bar (Shape: 14 x 120)
const int L0_fan_Wp_bar_rows = 14;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -5.87840006e-02f, -1.22773722e-01f, 4.38915715e-02f, 2.57031381e-01f, -2.31090616e-02f, -1.80914044e-01f, -2.95298368e-01f, 3.95328328e-02f, -1.55879766e-01f, -1.87841997e-01f,
  8.57197214e-03f, 2.89585963e-02f, -1.20481521e-01f, 1.47199884e-01f, 2.62685746e-01f, -1.09020784e-01f, 8.77031162e-02f, 6.48153201e-03f, 9.88883898e-02f, 9.58554447e-02f,
  1.37874857e-01f, 1.71650738e-01f, 1.59245551e-01f, 1.97592646e-01f, 2.74908380e-03f, 1.67465314e-01f, 2.06709653e-01f, 5.26559679e-03f, 2.09040016e-01f, 7.27170259e-02f,
  -1.47410156e-02f, 1.01966515e-01f, -3.75047848e-02f, 6.46611825e-02f, 3.70730981e-02f, -2.37282421e-02f, 1.10514946e-02f, 2.29638331e-02f, 7.06509426e-02f, 1.92830656e-02f,
  -5.05075091e-03f, 8.15143138e-02f, 1.30058333e-01f, 4.23316434e-02f, -9.77241341e-03f, 1.20552722e-02f, -1.59114283e-02f, -5.21807559e-03f, -1.24723352e-02f, 5.34856766e-02f,
  -6.89625293e-02f, 5.61067797e-02f, -2.62301918e-02f, -3.68457362e-02f, -5.47900498e-02f, -4.38580327e-02f, -7.04930723e-02f, 3.99893941e-03f, 4.74992022e-02f, 1.46457404e-02f,
  6.77329525e-02f, -2.79130824e-02f, -6.97500035e-02f, -7.36734085e-03f, -2.02347599e-02f, -4.10638005e-02f, -1.69215119e-03f, 2.36033071e-02f, 4.99902945e-03f, -4.32889834e-02f,
  3.39206122e-02f, 9.39450711e-02f, -1.33143822e-02f, -2.05018520e-02f, -1.94982365e-02f, 2.59537194e-02f, 2.91401595e-02f, -3.65414284e-03f, -5.33931293e-02f, -1.59826614e-02f,
  -4.58113626e-02f, 2.96117347e-02f, -1.06890231e-01f, -8.92564561e-03f, 4.38835211e-02f, -4.91253398e-02f, 2.77925432e-02f, -5.37041388e-02f, -3.37729566e-02f, 1.26591530e-02f,
  9.17088613e-02f, 1.33882701e-01f, -2.18443424e-02f, 5.19691929e-02f, -9.03182384e-03f, 7.50345960e-02f, -4.03534062e-02f, 1.03307314e-01f, 1.36829736e-02f, -5.65291308e-02f,
  7.62773156e-02f, -7.30320392e-03f, -3.79712437e-03f, 3.59204784e-02f, 7.86893517e-02f, -4.88522984e-02f, 1.82117317e-02f, 5.14223380e-03f, 4.46072221e-03f, 5.14632165e-02f,
  4.69461717e-02f, 1.00409873e-02f, -3.29827913e-03f, -2.35119835e-02f, -1.75602958e-02f, -4.09847759e-02f, 3.39928046e-02f, -3.95532660e-02f, 4.93996218e-02f, -7.52771124e-02f,
  2.44960538e-03f, 8.04237872e-02f, 1.56122684e-01f, 2.19895095e-02f, -1.38766482e-01f, -9.58444849e-02f, 3.40724885e-02f, 8.15072954e-02f, 1.73858732e-01f, 1.34834930e-01f,
  -6.75101578e-02f, 1.95881903e-01f, -6.57058433e-02f, 4.70824130e-02f, -2.25763425e-01f, -1.16609581e-01f, -1.45718649e-01f, 7.67060369e-02f, -6.16662167e-02f, -2.18955595e-02f,
  -1.98078170e-01f, -1.62240639e-01f, -2.44830370e-01f, -9.59002599e-02f, 1.24364840e-02f, 1.50075957e-01f, -9.16240066e-02f, -3.08908187e-02f, 7.45264292e-02f, 4.77271825e-02f,
  3.92228328e-02f, 1.71762392e-01f, 2.92466003e-02f, 5.69130527e-03f, 4.11020070e-02f, 4.11157086e-02f, 3.95746231e-02f, 4.96072657e-02f, 2.49106642e-02f, 1.02929678e-02f,
  6.35642707e-02f, 1.22207811e-03f, 1.29178818e-02f, -2.03764495e-02f, 9.51988623e-02f, 1.32845774e-01f, -1.33623602e-02f, -8.53464473e-03f, 6.35210872e-02f, 3.44229676e-02f,
  -3.80798504e-02f, 3.63627821e-02f, -3.07023767e-02f, 4.53381501e-02f, 2.02873908e-02f, 1.36667058e-01f, 3.95183191e-02f, -8.45785886e-02f, 3.85744609e-02f, 4.30561928e-03f,
  3.48568428e-03f, -8.50292742e-02f, -8.87949839e-02f, 2.24116817e-02f, -2.57755183e-02f, 1.30328983e-01f, 4.21156595e-03f, 3.74736935e-02f, -1.73368901e-02f, -1.27334837e-02f,
  3.08537818e-02f, -9.89935827e-03f, 6.31441027e-02f, -3.70796956e-02f, -5.33831008e-02f, 7.22343773e-02f, -2.09570378e-02f, 7.68812001e-03f, -7.01591596e-02f, -2.09317505e-02f,
  -3.45931686e-02f, 2.12738626e-02f, 2.62221005e-02f, -4.05606218e-02f, 1.48284817e-02f, 1.05825430e-02f, 1.27628148e-02f, 3.05832624e-02f, 1.07729656e-03f, -8.69774818e-02f,
  6.81951642e-02f, 6.61712140e-02f, 6.11101799e-02f, 6.26377314e-02f, -5.70738595e-03f, -2.73703597e-02f, -4.67113703e-02f, 9.63063561e-04f, 1.89030059e-02f, -1.08459428e-01f,
  2.27683149e-02f, 3.48585397e-02f, 3.92884277e-02f, -3.56913917e-02f, -3.56828608e-02f, 2.67337821e-02f, -4.36361693e-02f, 7.87931960e-03f, -1.59563776e-02f, -2.92333383e-02f,
  -7.00445399e-02f, -7.21922563e-03f, 4.08289023e-02f, -4.92423773e-02f, -5.70805818e-02f, 5.54201230e-02f, -1.05223628e-02f, 4.96080108e-02f, -6.40242770e-02f, -4.09597792e-02f,
  -2.78633922e-01f, 2.17557885e-02f, -1.48882121e-01f, -1.77256361e-01f, 1.03458479e-01f, -4.97325063e-02f, -1.01100118e-03f, 4.30259109e-02f, -6.09525666e-02f, 2.19797418e-01f,
  2.97393166e-02f, -5.34352958e-02f, 7.38921314e-02f, -2.61593044e-01f, -4.46684450e-01f, -2.38717392e-01f, -2.14412749e-01f, -1.51074693e-01f, -1.27861738e-01f, 8.86906812e-04f,
  -1.14023387e-01f, -6.64906204e-02f, -2.48883113e-01f, 1.53477088e-01f, -1.48671074e-02f, 6.52792677e-02f, 1.32853031e-01f, 1.87622085e-01f, 1.22338980e-02f, -3.20223086e-02f,
  3.01041082e-02f, 4.92843287e-03f, 2.06905771e-02f, 2.03844835e-03f, 3.76120508e-02f, 4.45658974e-02f, -1.72139276e-02f, 2.07282547e-02f, 1.50786210e-02f, -6.14214800e-02f,
  -2.43646316e-02f, -2.85392366e-02f, -1.00278087e-01f, 9.59665515e-03f, 7.75200054e-02f, -3.45182754e-02f, -1.44981686e-02f, 1.53688407e-02f, -6.46609999e-03f, -5.09626158e-02f,
  -7.85916820e-02f, -1.37827976e-03f, 3.30134742e-02f, -1.19964471e-02f, -7.19958097e-02f, 1.25166413e-03f, -6.55983016e-02f, 7.79381320e-02f, -2.59788875e-02f, -3.96572202e-02f,
  -3.27221677e-02f, 2.65234243e-03f, -2.68255384e-03f, -4.99400198e-02f, 5.40040098e-02f, 3.07413768e-02f, -5.51554486e-02f, 3.47720981e-02f, 1.98759250e-02f, 2.87957154e-02f,
  3.84858623e-02f, -3.11740134e-02f, -1.78827457e-02f, -2.62129214e-03f, -2.21784301e-02f, -4.08314429e-02f, 1.39489956e-02f, -3.38926390e-02f, -5.22207581e-02f, -1.33722927e-02f,
  3.92892025e-02f, -1.68064516e-02f, -1.19356262e-02f, 8.14743619e-03f, 3.26116048e-02f, 6.87405700e-03f, -1.55738392e-03f, 1.13196550e-02f, -2.18957476e-02f, 5.12539521e-02f,
  2.71263644e-02f, 4.13887762e-02f, 9.35879815e-03f, 4.36528213e-02f, -3.29993218e-02f, 1.99675262e-02f, -2.07640994e-02f, 2.30199425e-03f, 4.08068746e-02f, -4.13581692e-02f,
  7.73704648e-02f, 2.20130030e-02f, 6.74122870e-02f, 3.19041833e-02f, -3.75717767e-02f, 1.02172541e-02f, 8.11313614e-02f, 1.08345740e-01f, 4.89282683e-02f, -1.57343037e-02f,
  6.47766441e-02f, 4.56501395e-02f, -2.84607466e-02f, 7.13030901e-03f, -1.46537758e-02f, 5.22144884e-02f, 6.96328655e-02f, 3.12005784e-02f, 2.57855374e-02f, -1.28493027e-03f,
  -3.76785278e-01f, -1.32939070e-01f, -3.86767066e-03f, 2.64881961e-02f, -2.55123712e-02f, 1.54594511e-01f, 2.54717171e-01f, -1.73101649e-01f, -8.21647197e-02f, 8.81718025e-02f,
  7.52515942e-02f, -5.31413853e-02f, -2.04309560e-02f, 1.95048422e-01f, 1.07590541e-01f, 1.34651199e-01f, 1.54775992e-01f, 4.64505330e-02f, -1.27401650e-01f, -1.74561381e-01f,
  -8.00087452e-02f, 6.07912093e-02f, 1.58807755e-01f, -8.21800455e-02f, 1.02665406e-02f, -5.00695556e-02f, 3.00275274e-02f, -6.57054931e-02f, 1.92413583e-01f, 1.35021821e-01f,
  -7.50143826e-02f, -2.33735517e-01f, -4.37951572e-02f, 3.59397493e-02f, -9.37611517e-03f, -3.35140377e-02f, 2.75605582e-02f, 7.64126852e-02f, -5.46783470e-02f, -5.68282567e-02f,
  3.41593996e-02f, -8.04329887e-02f, 7.23204091e-02f, -2.72866237e-05f, -3.85746583e-02f, 3.37647973e-03f, -4.98238020e-02f, 3.35626975e-02f, -4.65503447e-02f, 7.60708237e-03f,
  7.57581275e-03f, -1.82399284e-02f, -9.03847720e-03f, 2.36566123e-02f, -2.19976064e-02f, 3.34495753e-02f, 5.82907423e-02f, 3.09848860e-02f, -8.92177522e-02f, 1.49875544e-02f,
  -9.55603365e-03f, -2.17023212e-02f, 2.52200104e-02f, 3.63737643e-02f, 6.99170772e-03f, -6.64097304e-03f, 1.21833347e-01f, 8.50169268e-03f, 1.78080071e-02f, 3.79108414e-02f,
  -6.49044439e-02f, -5.47646768e-02f, -6.91904426e-02f, -8.89418088e-03f, 4.36152592e-02f, 5.18282764e-02f, -1.00258766e-02f, -8.64023790e-02f, 3.46356854e-02f, -1.17317419e-02f,
  -2.98122093e-02f, -9.95581001e-02f, 3.17950211e-02f, 2.17881706e-02f, -8.60826075e-02f, 4.59887236e-02f, -2.50540357e-02f, -4.36118245e-02f, -2.19059922e-02f, -5.90263400e-04f,
  -1.42471328e-01f, -2.34831557e-01f, 1.58902016e-02f, 3.38786654e-03f, -4.33088839e-02f, 1.68219302e-02f, -4.14518453e-02f, 1.92582421e-02f, -2.05013808e-02f, -7.44192302e-02f,
  3.73995826e-02f, 1.37107996e-02f, -5.58327436e-02f, -8.97465087e-03f, 3.22365351e-02f, 1.50029426e-02f, 7.68593745e-03f, -3.26715945e-03f, 3.59962098e-02f, -5.30400835e-02f,
  4.41368623e-03f, -4.32264917e-02f, -3.31044868e-02f, -2.01201215e-02f, 6.11865595e-02f, 7.19124358e-03f, -9.22661051e-02f, -3.50773986e-03f, -2.33942196e-02f, -1.61877722e-02f,
  2.42788687e-01f, -4.47752237e-01f, 8.70266557e-02f, 1.79671511e-01f, 2.22014487e-01f, -1.12903304e-03f, 2.17084512e-01f, -1.91840515e-01f, -8.78238901e-02f, -3.68405133e-01f,
  4.98634111e-03f, 2.45418902e-02f, -9.51162651e-02f, -6.76457509e-02f, 2.95142651e-01f, -2.03496560e-01f, 3.05151027e-02f, -1.29104322e-02f, -2.44777817e-02f, -1.15330629e-02f,
  5.50490394e-02f, 7.17980042e-02f, 3.77095677e-02f, -1.22640885e-01f, 6.39362410e-02f, 5.94067737e-04f, -9.18072462e-03f, 4.98836301e-02f, -1.97578687e-02f, 1.25449955e-01f,
  6.65724128e-02f, -4.54576053e-02f, 1.23869032e-01f, 5.03573893e-03f, -3.81426476e-02f, 6.39593368e-03f, 4.34894264e-02f, 1.37078851e-01f, 5.72049990e-02f, 2.43661925e-02f,
  8.61670764e-04f, -2.06892355e-03f, -2.93417415e-03f, -9.83368326e-03f, 3.10786217e-02f, -4.78515960e-03f, 3.43835540e-02f, 5.39151113e-03f, -4.47892509e-02f, -8.85869414e-02f,
  -1.95126869e-02f, 1.14039481e-02f, 2.06505228e-02f, -4.59623113e-02f, -1.40474299e-02f, -3.01948725e-03f, -5.06913625e-02f, -3.11278272e-02f, -2.69087934e-04f, -5.51141873e-02f,
  -1.73960812e-02f, -4.94064577e-03f, -4.52001356e-02f, 2.67761666e-02f, 4.83851172e-02f, 1.72300224e-05f, 1.41248398e-04f, 6.93997741e-02f, -1.27053130e-02f, -1.02483830e-03f,
  4.21219915e-02f, -1.23355677e-02f, -4.21051160e-02f, 7.22141117e-02f, 2.19093934e-02f, -5.91302030e-02f, 6.60819858e-02f, -3.19343619e-02f, -5.18630147e-02f, 1.18651409e-02f,
  1.19539956e-02f, 4.00707349e-02f, -3.75664560e-03f, -1.55486697e-02f, 2.69731861e-02f, 3.64430100e-02f, -2.97695361e-02f, 3.84673174e-03f, 1.93080287e-02f, 2.55531985e-02f,
  -1.41168758e-01f, -2.96506941e-01f, 2.59624096e-04f, 5.82027659e-02f, -5.49374446e-02f, -1.08323321e-01f, 1.50702270e-02f, -6.00914136e-02f, 9.71983373e-03f, -1.35992765e-02f,
  -4.02575396e-02f, 4.47778627e-02f, -7.25933686e-02f, 6.66800663e-02f, 7.93293715e-02f, -8.48353058e-02f, 1.54029615e-02f, -1.46638788e-02f, 1.59458653e-03f, -6.13267906e-02f,
  -5.09005319e-03f, -4.28915061e-02f, 7.48437792e-02f, 4.23259065e-02f, -1.18372599e-02f, 4.90365028e-02f, -1.49835376e-02f, -9.93410312e-03f, -9.40462425e-02f, 4.06784564e-02f,
  4.07709777e-01f, -4.18023020e-02f, -2.85260584e-02f, 1.65375233e-01f, 1.16839819e-01f, 1.13218658e-01f, -1.26611181e-02f, 1.44654408e-01f, 3.15454423e-01f, -3.93828526e-02f,
  7.11594671e-02f, 5.49117941e-03f, -1.18454486e-01f, 1.30260691e-01f, 4.33708094e-02f, -1.32458299e-01f, 1.26154214e-01f, 7.36148879e-02f, 1.10956371e-01f, 4.35512401e-02f,
  6.83091283e-02f, 1.29623875e-01f, -1.08637057e-01f, 3.63101140e-02f, 8.53021815e-02f, -5.14751226e-02f, -1.51092216e-01f, -1.48473695e-01f, -3.53831165e-02f, -3.87048386e-02f,
  -9.46898106e-03f, 8.10507089e-02f, -8.46763700e-03f, -5.42397238e-02f, -3.29661742e-02f, 5.04765473e-03f, -3.14037390e-02f, -6.70668436e-03f, 3.40103470e-02f, -1.96950659e-02f,
  1.45517839e-02f, -2.73746196e-02f, -8.13598651e-03f, -7.57635012e-02f, -4.14160499e-03f, 1.34779969e-02f, 5.89761622e-02f, 5.83963320e-02f, 2.21896488e-02f, 4.26998511e-02f,
  8.08627438e-03f, 3.40386257e-02f, 7.74129927e-02f, -6.84194565e-02f, 4.11564251e-03f, 2.07207985e-02f, 3.56166624e-03f, -1.38772324e-01f, -7.73830190e-02f, 8.91309232e-02f,
  -3.81715037e-02f, 1.68958921e-02f, 1.54949240e-02f, 3.09172366e-02f, 1.51962796e-02f, 5.32645220e-03f, 6.91722855e-02f, -2.19874755e-02f, 5.34302555e-03f, 5.14049968e-03f,
  4.94467355e-02f, 5.72277009e-02f, 3.20721380e-02f, 4.39662524e-02f, 5.98250329e-02f, 4.70121875e-02f, -8.43233545e-04f, -5.64029403e-02f, 2.18893569e-02f, 4.67357486e-02f,
  2.16081105e-02f, -1.34472619e-04f, -3.22021842e-02f, -1.55037232e-02f, 4.14461792e-02f, -9.57869459e-04f, 6.15158230e-02f, 4.50424068e-02f, -1.65153779e-02f, -2.89754495e-02f,
  2.13811044e-02f, -5.37109040e-02f, -5.83169691e-04f, 1.00065144e-02f, -7.27708265e-02f, 1.23985291e-01f, 4.95236143e-02f, 2.83552078e-03f, -8.90248735e-03f, 9.86852050e-02f,
  -2.69196779e-02f, -9.63727664e-03f, 3.71227153e-02f, 4.53387201e-03f, -4.25904691e-02f, 3.82423960e-02f, -9.72556248e-02f, -2.19653770e-02f, -1.49596641e-02f, -2.67193257e-03f,
  7.37802535e-02f, -4.79687043e-02f, 2.89489590e-02f, -5.82701247e-03f, 5.40189147e-02f, -1.51369289e-01f, 4.87074219e-02f, -6.79093003e-02f, 1.30126197e-02f, 6.99355081e-03f,
  2.05989480e-02f, 1.17678875e-02f, 2.09861532e-01f, 1.08361103e-01f, 8.97469074e-02f, 1.40692100e-01f, 1.86167091e-01f, 8.68277028e-02f, 1.05666630e-01f, -5.98543100e-02f,
  -6.44411072e-02f, 1.88233070e-02f, -7.23813474e-02f, -1.55844644e-01f, 1.29066467e-01f, 5.76657988e-02f, -3.29036079e-02f, -6.70579216e-03f, 2.71046292e-02f, -8.84212106e-02f,
  -5.36039658e-02f, -1.55127525e-01f, -4.99774814e-02f, -1.34396866e-01f, -1.55807674e-01f, 1.79474484e-02f, -1.20295741e-01f, 5.30426539e-02f, -4.79983427e-02f, 9.39957500e-02f,
  1.02490829e-02f, 6.40751645e-02f, -4.96730208e-02f, 1.25229079e-02f, -1.15698524e-01f, 4.80954014e-02f, -6.16227612e-02f, 1.01048104e-01f, 6.74340278e-02f, -1.06947487e-02f,
  -3.49643454e-02f, -7.83377513e-02f, 3.82142887e-02f, 3.68610136e-02f, 2.89847050e-02f, 3.01916730e-02f, 2.43000966e-02f, -3.02925017e-02f, 8.88832286e-02f, 2.76146848e-02f,
  -3.37933656e-03f, -5.66843301e-02f, -7.16153234e-02f, -1.30447373e-02f, 8.23993422e-03f, 6.24412932e-02f, 1.25588030e-02f, 8.48846585e-02f, -6.56237602e-02f, 7.27606043e-02f,
  1.41572719e-03f, 4.96941321e-02f, 7.75658414e-02f, -7.45828524e-02f, -7.21929893e-02f, -8.01495761e-02f, -6.40143678e-02f, -6.43487461e-03f, 4.79458608e-02f, -1.00097001e-01f,
  -3.23068872e-02f, 8.99534021e-03f, -6.61477149e-02f, -3.47985253e-02f, -8.30680430e-02f, -4.88118874e-03f, -4.57291566e-02f, -2.76401155e-02f, -8.30123648e-02f, -2.83934213e-02f,
  -9.87159368e-03f, 3.88709381e-02f, -1.65793095e-02f, 1.02216052e-02f, 5.14684319e-02f, -1.45705389e-02f, -6.78888857e-02f, -3.13318670e-02f, 4.27648015e-02f, 1.20744472e-02f,
  5.36242463e-02f, 1.31235287e-01f, 2.62686200e-02f, -3.12883928e-02f, -2.64212098e-02f, 1.54119553e-02f, 4.52522263e-02f, -6.58983961e-02f, 1.00216873e-01f, -2.54866830e-03f,
  -3.59957628e-02f, -2.61939839e-02f, 7.18644410e-02f, 4.36851382e-02f, -1.22427819e-02f, -2.27064174e-02f, 2.76656020e-02f, 3.19236778e-02f, -5.41836768e-03f, -7.49651901e-03f,
  -4.89777736e-02f, 2.73444355e-02f, 2.01685354e-04f, -9.86018777e-02f, 3.38395834e-02f, -7.21512437e-02f, -1.24763101e-02f, -4.45780111e-03f, 7.98047036e-02f, 1.78135838e-02f,
  4.10510659e-01f, -2.00767070e-01f, 9.67062637e-02f, 3.36660445e-01f, 2.24322036e-01f, -2.54690759e-02f, 1.88589603e-01f, 1.02736279e-01f, 3.74640226e-01f, -1.02804899e-01f,
  2.30283160e-02f, -7.31224865e-02f, -7.83679932e-02f, 4.39196639e-02f, -2.48018429e-02f, 1.25797815e-03f, 6.67601377e-02f, 2.30810773e-02f, 9.35076103e-02f, 7.18013421e-02f,
  2.06296980e-01f, 5.56753315e-02f, -2.93451957e-02f, -4.57676649e-02f, 4.53029685e-02f, -1.38798868e-03f, -1.50590166e-01f, -1.45554036e-01f, -1.60084978e-01f, -7.15348274e-02f,
  1.97567139e-02f, 1.41338140e-01f, -5.28694727e-02f, -9.12422966e-03f, 3.64698321e-02f, -3.98994014e-02f, -6.33596703e-02f, -1.22945504e-02f, 3.57163809e-02f, 1.06123462e-02f,
  -2.98260469e-02f, 8.60802364e-03f, 7.30064735e-02f, -9.02056973e-03f, 2.67425776e-02f, 4.03036326e-02f, 6.18911684e-02f, 4.25489545e-02f, 5.01540639e-02f, 3.44281606e-02f,
  5.60924634e-02f, -5.07391319e-02f, 1.10352570e-02f, -9.06133279e-02f, -7.79361837e-03f, 3.81986611e-02f, -5.30200750e-02f, -4.21782881e-02f, 1.29869301e-02f, -3.48760113e-02f,
  -5.51649705e-02f, 3.66980359e-02f, -2.51199175e-02f, 3.66335772e-02f, -2.41551921e-02f, 8.50268826e-02f, 4.30203564e-02f, 3.53908390e-02f, 6.55061901e-02f, -2.44980142e-03f,
  7.78285861e-02f, -6.93405122e-02f, 9.96832624e-02f, -5.25500346e-03f, 9.72992182e-03f, 3.93277518e-02f, -6.00588135e-02f, -1.74910445e-02f, 1.72031093e-02f, 3.32908779e-02f,
  9.65996012e-02f, -1.24124652e-02f, -6.13373481e-02f, 6.49818331e-02f, -7.65903620e-03f, -1.55352205e-02f, -4.42973487e-02f, -2.79935431e-02f, 7.35823661e-02f, 8.12020060e-03f,
  -1.85030088e-01f, -2.15170458e-01f, -2.11831089e-02f, -1.54028786e-02f, -7.99472034e-02f, 1.99791472e-02f, 2.45897714e-02f, -3.31139483e-04f, -1.46203518e-01f, 3.77509557e-02f,
  4.78965603e-03f, 5.06370589e-02f, -2.91292765e-03f, -4.73478949e-03f, -9.01340917e-02f, -4.32178788e-02f, 6.31873682e-02f, -6.66114837e-02f, -8.27358291e-03f, -6.13155495e-03f,
  1.64601691e-02f, 1.89271513e-02f, -3.75229632e-04f, -2.68180552e-03f, -1.06087895e-02f, 3.26079971e-05f, 1.34924171e-03f, -1.15975395e-01f, -2.78212465e-02f, -4.72702570e-02f,
  4.11353201e-01f, -2.52592891e-01f, -9.50866640e-02f, -6.79552406e-02f, -9.00112763e-02f, -2.04506367e-01f, -1.35022491e-01f, -2.74436682e-01f, -3.22973495e-03f, -1.96991190e-01f,
  -7.57218972e-02f, 2.31545970e-01f, 1.94167346e-01f, -2.81249493e-01f, 3.18339527e-01f, 1.54179946e-01f, -1.35293141e-01f, -3.59849189e-03f, -1.88151235e-03f, -1.17977612e-01f,
  2.29823347e-02f, -2.94887781e-01f, -1.37339626e-02f, -3.23258907e-01f, -2.00816870e-01f, -1.55382603e-01f, 5.44129722e-02f, -5.15561737e-02f, -2.49564454e-01f, 4.28218804e-02f,
  1.66225750e-02f, 1.86336581e-02f, -9.40776616e-02f, -5.49301170e-02f, -7.26585984e-02f, 4.48055491e-02f, 6.96158549e-03f, 6.73692822e-02f, 3.34126987e-02f, 1.86574124e-02f,
  4.38574366e-02f, 3.67226824e-02f, -1.08570531e-01f, 1.27430093e-02f, -1.99390785e-03f, -4.76884283e-02f, 2.70631723e-02f, 4.24323939e-02f, -5.94799332e-02f, 2.09004469e-02f,
  6.39376715e-02f, 4.18317914e-02f, -2.71079391e-02f, -1.34859998e-02f, 5.00176698e-02f, 9.64427274e-03f, -8.23665317e-03f, 5.72756231e-02f, 1.49138691e-02f, 2.84587475e-03f,
  -1.27231389e-01f, 1.90323759e-02f, 2.38050520e-02f, -4.16201428e-02f, -2.85009742e-02f, 2.19208580e-02f, 3.53598930e-02f, 2.36171409e-02f, 6.21152595e-02f, 3.49225663e-02f,
  3.46096270e-02f, -4.64637578e-03f, -3.39751393e-02f, 2.29815356e-02f, -2.29618885e-02f, 4.31972137e-03f, 1.15252370e-02f, 5.81505825e-04f, 1.79482829e-02f, -2.04220824e-02f,
  5.96939884e-02f, -6.69643981e-03f, -1.56764966e-02f, 1.60444696e-02f, -9.25944839e-03f, 4.18146551e-02f, -1.48957828e-02f, 1.69701800e-02f, -1.46664875e-02f, 1.96718276e-02f,
  -1.06323801e-01f, -1.45478919e-01f, -9.25886333e-02f, -3.38935293e-02f, 6.78230170e-03f, 4.07240726e-02f, -6.96599891e-04f, -3.46616395e-02f, -1.15897590e-02f, -1.90581009e-02f,
  -3.49872001e-02f, 1.32076731e-02f, 5.79185784e-02f, -9.57635883e-03f, 2.56184302e-03f, -6.00625575e-02f, -5.18648513e-03f, -1.41490009e-02f, -1.22752928e-04f, -1.01832496e-02f,
  -1.61417387e-02f, 7.42685273e-02f, 3.28688929e-03f, -2.66161840e-03f, -2.98712961e-02f, 7.52313137e-02f, 8.95352960e-02f, -1.56268720e-02f, 5.15407473e-02f, 4.16668924e-03f,
  2.00698391e-01f, -7.11459816e-02f, -3.39158207e-01f, -1.51301682e-01f, 5.58112450e-02f, 2.29599312e-01f, 8.66697133e-02f, -1.03727564e-01f, -3.01046759e-01f, 2.61914551e-01f,
  1.30548820e-01f, -1.43747687e-01f, -8.81279260e-02f, -1.15673582e-03f, -1.38998002e-01f, -1.76616058e-01f, 1.43659502e-01f, 6.50382116e-02f, -1.32714525e-01f, 1.14531815e-01f,
  -1.11865122e-02f, 2.09898174e-01f, -1.25233710e-01f, 1.07997224e-01f, 9.32028666e-02f, 8.63020588e-03f, 1.81286156e-01f, -7.34722242e-02f, 1.23557135e-01f, 8.90695583e-03f,
  -6.52346155e-03f, -9.63413250e-03f, -7.70470798e-02f, -4.73781601e-02f, 1.30207837e-01f, 1.17424607e-01f, 4.17218804e-02f, 1.82128418e-02f, -1.04053594e-01f, -7.48183280e-02f,
  2.77882069e-02f, -3.26499790e-02f, 2.13000216e-02f, -1.02703944e-02f, -2.24809372e-03f, -6.85527399e-02f, -1.85850468e-02f, 8.89596622e-03f, -3.87413837e-02f, 5.81767131e-03f,
  -4.01577279e-02f, -1.84735644e-03f, 4.73227613e-02f, 2.61180513e-02f, -7.78868422e-02f, 1.54624702e-02f, 3.01130884e-03f, -2.66719759e-02f, 5.97785935e-02f, -3.59178074e-02f,
  9.94723011e-03f, 6.67606015e-03f, 6.62019895e-03f, -1.08692981e-02f, -7.23784696e-03f, -2.17458396e-03f, 2.82925350e-04f, 2.58829370e-02f, -4.22274396e-02f, -2.11184584e-02f,
  4.06720489e-02f, -4.24435101e-02f, 3.79788131e-02f, 7.26349503e-02f, -1.02877878e-02f, 2.26386357e-02f, 1.49303284e-02f, -2.88458075e-03f, -5.11069642e-03f, -4.03257646e-02f,
  -1.28601296e-02f, 3.03912386e-02f, -1.78874526e-02f, 4.10998911e-02f, -1.54666416e-03f, -5.49029559e-02f, 3.73562016e-02f, -3.71524021e-02f, -5.09282723e-02f, -4.83614346e-03f,
  6.38617203e-02f, 4.72867973e-02f, -2.38321107e-02f, -2.63120458e-02f, -3.84783815e-03f, 1.42939389e-01f, -3.99481803e-02f, 3.98346186e-02f, -1.01260673e-02f, 8.25365558e-02f,
  9.86926034e-02f, 3.42749781e-03f, 1.07444912e-01f, -4.62895855e-02f, 1.02700731e-02f, 8.84746090e-02f, -1.34354373e-02f, 1.97611805e-02f, 3.90940299e-03f, 2.31676493e-02f,
  3.37023214e-02f, 7.13157132e-02f, 6.83168247e-02f, -2.02105418e-02f, 8.52966979e-02f, 1.13718122e-01f, 6.79650232e-02f, 5.10975979e-02f, 3.26522291e-02f, -1.07386842e-01f,
  2.05164015e-01f, 1.26775935e-01f, -8.66257120e-03f, -6.67100772e-02f, 2.77866963e-02f, 1.80011421e-01f, 2.22208947e-02f, 5.36217690e-02f, 1.09785320e-02f, 2.96473298e-02f,
  -3.28718238e-02f, 7.05278888e-02f, 3.70091908e-02f, 5.75891323e-02f, 1.43315168e-02f, 1.01332173e-01f, 1.33400112e-01f, 4.86131683e-02f, 1.65548699e-03f, 2.83232424e-02f,
  3.60895507e-02f, 6.97515905e-02f, -3.67684178e-02f, 2.45000869e-02f, 9.52458009e-03f, -5.76367900e-02f, -1.69895500e-01f, -3.04783881e-02f, -6.75028563e-02f, 5.17449640e-02f,
  9.32363514e-03f, 1.12727940e-01f, 8.82758349e-02f, 7.11526945e-02f, 6.94718435e-02f, 2.17780732e-02f, -2.62814090e-02f, 1.17965918e-02f, 1.40551412e-02f, 3.25354896e-02f,
  1.86684188e-02f, -8.63946136e-03f, 5.49659431e-02f, -1.53767420e-02f, 2.69909762e-02f, -1.25316074e-02f, -2.68525425e-02f, -3.88375036e-02f, -2.08123289e-02f, 1.71648804e-02f,
  -2.45186891e-02f, 1.31515618e-02f, -3.77293024e-03f, -1.85139664e-02f, -3.47096883e-02f, -6.39975071e-02f, -2.94419602e-02f, 1.12761175e-02f, -4.70214598e-02f, 5.08065112e-02f,
  7.70085081e-02f, 9.56789777e-03f, 8.52134824e-02f, -8.64742510e-03f, 1.10411271e-02f, 2.12691186e-04f, 1.40684415e-02f, 4.22980785e-02f, 3.06994636e-02f, 8.92793573e-03f,
  -7.01003075e-02f, -8.74143168e-02f, -2.19088439e-02f, -2.05243006e-02f, 1.12149846e-02f, 3.73782311e-03f, 4.84586135e-02f, -5.26943319e-02f, 1.92608722e-02f, -7.02934861e-02f,
  -1.65548585e-02f, 8.35115984e-02f, -1.48740625e-02f, -4.02567349e-02f, -4.53499295e-02f, 9.64265689e-03f, -4.55061495e-02f, -6.17098622e-02f, -1.25234826e-02f, 7.17200041e-02f,
  9.08447206e-02f, 1.25087649e-01f, 3.58749703e-02f, 4.93206494e-02f, 2.63992306e-02f, 2.69262530e-02f, 5.92872053e-02f, 9.07675177e-02f, 7.06931110e-03f, 2.83113290e-02f,
  1.71047561e-02f, 3.65227684e-02f, 6.27545863e-02f, -2.20411327e-02f, -1.50603428e-02f, 4.77488451e-02f, -6.98120743e-02f, -1.10754445e-02f, -1.49789723e-02f, -6.02305755e-02f,
  -5.46908602e-02f, 6.15820289e-02f, 3.55114415e-02f, -1.62594940e-03f, 1.46441888e-02f, -4.77602519e-02f, 1.56137114e-03f, -4.30384129e-02f, -3.93088870e-02f, -1.71749070e-02f,
  7.81968310e-02f, -9.80452597e-02f, -1.84754282e-01f, 1.26900271e-01f, -1.24258676e-03f, -1.66298211e-01f, -2.07685500e-01f, 1.62402585e-01f, -1.52316064e-01f, 2.03615855e-02f,
  2.34449301e-02f, 7.71011338e-02f, -1.66743889e-01f, 1.48841485e-01f, 3.08905780e-01f, -2.17545003e-01f, 2.03492880e-01f, -7.31874444e-03f, -1.46107934e-02f, 1.05607018e-01f,
  1.14481881e-01f, 2.39756033e-01f, 1.03863917e-01f, 1.82076752e-01f, 1.18749984e-01f, 4.13663089e-02f, 2.52804518e-01f, -6.60084784e-02f, 2.51000941e-01f, 7.40205273e-02f,
  2.80987769e-02f, 5.84315583e-02f, -2.71236487e-02f, -6.28587678e-02f, 2.78925300e-02f, 5.40220700e-02f, -8.69185850e-02f, 3.28133143e-02f, 1.48100108e-02f, 7.86438212e-03f,
  -3.73851322e-02f, 5.70510328e-02f, -5.14616584e-03f, 3.17019448e-02f, 6.76070014e-03f, 3.74396145e-02f, 2.19923723e-02f, -5.90757653e-03f, -3.13665569e-02f, -3.51493917e-02f,
  -6.93422258e-02f, -2.52693426e-02f, -1.24975303e-02f, 3.79811451e-02f, -2.49128379e-02f, -3.14711453e-03f, -5.45910224e-02f, 3.35532948e-02f, -3.06388345e-02f, 1.13515183e-02f,
  8.05736780e-02f, -1.66696981e-02f, -3.11204810e-02f, -2.19251327e-02f, 4.50431332e-02f, -9.38419439e-03f, -8.97113699e-04f, 2.95906123e-02f, -1.52897602e-02f, 7.00786561e-02f,
  2.02397294e-02f, -3.89056504e-02f, 2.29727384e-02f, -4.81405258e-02f, 8.64090491e-03f, -1.49351340e-02f, -4.13190089e-02f, 3.54951844e-02f, -2.98852827e-02f, -3.96442562e-02f,
  -1.95580032e-02f, 6.83616847e-02f, -5.17216437e-02f, 3.49473879e-02f, 2.52103060e-02f, 5.36690094e-02f, 2.07317155e-02f, 1.98021661e-02f, -6.41079918e-02f, -5.67731373e-02f,
  4.37395610e-02f, 9.61972177e-02f, 2.04805676e-02f, -1.09160179e-02f, -1.70904212e-02f, -1.54312607e-02f, 2.52522100e-02f, 3.85226272e-02f, 3.36249806e-02f, -8.31975020e-04f,
  5.06182164e-02f, -5.52710295e-02f, 4.51253541e-02f, 7.00607081e-04f, 4.89646606e-02f, 1.71425217e-03f, -5.19372001e-02f, -2.76714861e-02f, 5.35754040e-02f, 8.35888684e-02f,
  -2.02058954e-03f, -1.12804091e-02f, -2.53687929e-02f, -1.18423618e-01f, 4.66921106e-02f, -1.46332653e-02f, 9.97553580e-04f, -1.13761267e-02f, 1.34284683e-02f, 6.06540870e-03f,
  -1.98860615e-01f, 2.71134148e-03f, 3.73439267e-02f, 2.64065921e-01f, -1.34642407e-01f, -2.27954432e-01f, -1.00950383e-01f, 8.23177584e-03f, 3.96423526e-02f, 5.48119955e-02f,
  2.14997325e-02f, -8.71273514e-04f, -2.19819862e-02f, 1.88869148e-01f, 1.68383494e-01f, 8.41701627e-02f, 1.49098203e-01f, 2.67473068e-02f, 1.31811872e-01f, 1.04306616e-01f,
  1.48185998e-01f, 1.48350120e-01f, 2.47070283e-01f, 9.92741957e-02f, 1.60379801e-02f, 1.36669070e-01f, 1.71702340e-01f, 4.06076247e-03f, 1.33558333e-01f, -1.09400023e-02f,
  -4.97564934e-02f, -9.35911294e-03f, -2.90988549e-03f, -2.22261213e-02f, 3.41618657e-02f, -7.04738647e-02f, 4.23486941e-02f, -2.00126972e-02f, 5.07222861e-03f, 4.95691374e-02f,
  -1.07186213e-01f, -8.29979870e-03f, 1.94804743e-03f, 3.89926322e-02f, -1.16408370e-01f, 1.26576032e-02f, -1.96154527e-02f, -3.27049904e-02f, 4.89354916e-02f, -6.39498010e-02f,
  1.18914926e-02f, 2.50311997e-02f, 4.15404364e-02f, 4.44538854e-02f, 2.12852983e-03f, -2.06793249e-02f, 4.57293056e-02f, -4.26724851e-02f, -3.38716805e-02f, 4.12205681e-02f,
  -1.37063265e-01f, 2.63958741e-02f, -6.71100393e-02f, 4.59398963e-02f, -3.53643261e-02f, 3.50460261e-02f, -3.32450494e-02f, -6.19938178e-03f, 6.33906573e-02f, -5.61013469e-04f,
  6.16279207e-02f, 7.21661747e-02f, 9.00966451e-02f, 7.52347615e-03f, -5.71099333e-02f, -2.80481409e-02f, 1.36080701e-02f, 1.53834969e-02f, 4.64799367e-02f, 4.36372571e-02f,
  4.85502928e-02f, -4.37203515e-03f, -2.16875086e-03f, -3.36175621e-03f, -2.65453220e-03f, 1.77921634e-02f, 4.96381000e-02f, 7.42461681e-02f, 8.95898715e-02f, -1.71274040e-02f,
  1.13491558e-01f, 1.86378956e-01f, 3.73126008e-02f, -9.03502256e-02f, -3.68908350e-03f, 9.06238519e-03f, 2.62121428e-02f, -1.76031776e-02f, 4.55792211e-02f, 6.25808761e-02f,
  -3.74575593e-02f, -5.80366980e-03f, -4.97681983e-02f, 1.06936311e-02f, 3.71250324e-03f, -1.41990809e-02f, 3.22158113e-02f, 4.07275371e-02f, 3.28560174e-02f, 2.61541251e-02f,
  1.32802166e-02f, -1.96505096e-02f, 5.00593185e-02f, -6.39060661e-02f, -3.34339626e-02f, 5.76951802e-02f, -3.73880044e-02f, -1.88275110e-02f, -1.41846128e-02f, 3.20251882e-02f,
  4.61310744e-01f, 2.94145644e-01f, 2.78498530e-01f, 3.55826855e-01f, -1.81622520e-01f, -2.33322352e-01f, -8.09517354e-02f, 1.73740834e-02f, 7.98351169e-02f, 8.58116150e-02f,
  -1.93254814e-01f, 4.08753633e-01f, -1.32384390e-01f, 1.90568030e-01f, -8.26338232e-02f, -1.73881084e-01f, 9.63695869e-02f, -1.14432881e-02f, -3.46650300e-03f, 1.95426866e-01f,
  8.18279013e-02f, -1.11903973e-01f, 1.73495993e-01f, -8.38774666e-02f, 1.05292194e-01f, 1.84456676e-01f, 3.12888622e-02f, -1.11038722e-01f, 1.59400120e-01f, -1.30428329e-01f,
  -9.34244227e-03f, 3.06730121e-02f, 1.30469888e-01f, 2.98690870e-02f, 6.52742572e-03f, -5.02305143e-02f, 1.72361378e-02f, -2.01776717e-02f, -5.76984175e-02f, 1.72655366e-03f,
  1.20979741e-01f, 2.87197810e-02f, -5.84202446e-03f, -4.33523841e-02f, 4.25400808e-02f, 8.98256972e-02f, 5.49146011e-02f, 3.70895267e-02f, 8.02166983e-02f, 5.94406724e-02f,
  8.17464218e-02f, 3.45441364e-02f, 7.93637261e-02f, -2.87065487e-02f, 1.15413561e-01f, 3.70345227e-02f, -5.13364039e-02f, 6.05327897e-02f, 5.32712676e-02f, 1.32024348e-01f,
  -8.02715048e-02f, -7.35163093e-02f, -1.34918764e-02f, 5.31705879e-02f, 2.72538401e-02f, 1.31551102e-02f, 1.94409327e-03f, 1.07393274e-02f, -2.84980163e-02f, -8.28156248e-02f,
  6.77444413e-03f, 5.23669608e-02f, -4.23824713e-02f, 2.37120986e-02f, 4.75068949e-02f, 8.31862092e-02f, 6.21178262e-02f, -1.05155267e-01f, 2.60982774e-02f, 1.01130225e-01f,
  -5.78246638e-02f, -8.20948184e-02f, 6.89709708e-02f, 1.58047173e-02f, -7.07013234e-02f, -3.68317775e-02f, -2.57469807e-02f, 5.04097976e-02f, -8.03810060e-02f, 4.34745383e-03f,
  -1.21181175e-01f, 1.55565785e-02f, 3.00322361e-02f, -6.69580176e-02f, -1.93578508e-02f, -5.16973028e-04f, -1.51439691e-02f, 3.81767787e-02f, 2.78160945e-02f, -2.16608737e-02f,
  -1.40621085e-02f, -9.32357088e-02f, 3.41175199e-02f, -7.89836340e-04f, -3.17472965e-02f, 1.57932043e-02f, 1.28451064e-02f, 3.68967541e-02f, 1.04538843e-01f, -8.73429049e-03f,
  2.97321603e-02f, -5.43827675e-02f, 3.73079032e-02f, 4.21562195e-02f, -2.10014582e-02f, 8.25056434e-03f, 2.65258811e-02f, 7.14926571e-02f, -1.09647224e-02f, -1.61723346e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 14)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 14;
const float L0_fan_Bp_bar_data[] = {
  6.95317537e-02f, 7.22669065e-02f, 1.01459570e-01f, 1.25352010e-01f, 3.72923315e-02f, 1.30378231e-01f, 5.04803769e-02f, 1.50102424e-02f, 2.11349294e-01f, 1.52144626e-01f,
  6.38050511e-02f, 1.00925192e-01f, 1.03895470e-01f, 1.57055646e-01f
};

// L1_fan_Wp (Shape: 25 x 64)
const int L1_fan_Wp_rows = 25;
const int L1_fan_Wp_cols = 64;
const float L1_fan_Wp_data[] = {
  -9.14574973e-03f, -5.04898615e-02f, 7.82662183e-02f, 6.64193407e-02f, -3.99746746e-02f, -6.76779123e-03f, -1.87885799e-02f, 1.23756044e-01f, -7.15426132e-02f, -6.18886715e-03f,
  5.30498289e-02f, -6.58858642e-02f, 2.37007458e-02f, -7.58047551e-02f, -7.73139596e-02f, 2.21838430e-02f, -5.11629879e-02f, 3.62141877e-02f, -1.48334265e-01f, 9.32383686e-02f,
  8.12939703e-02f, 3.00418753e-02f, -1.44781977e-01f, -4.99610081e-02f, -6.50470778e-02f, -3.75973806e-02f, -8.56085122e-02f, 3.09214052e-02f, 1.07989153e-02f, -2.43705995e-02f,
  2.08772004e-01f, 2.98238806e-02f, 1.70989875e-02f, -7.80770257e-02f, -9.44256112e-02f, -9.54077300e-03f, -3.41640264e-02f, 4.35621962e-02f, -5.99530637e-02f, 2.37482071e-01f,
  4.02645357e-02f, -2.24993274e-01f, -1.07878312e-01f, 1.02444805e-01f, -1.07547797e-01f, -2.74297758e-03f, -6.31656796e-02f, -1.38544247e-01f, 1.94313869e-01f, 1.27755791e-01f,
  -2.22940207e-01f, 7.71468831e-03f, -1.93277016e-01f, -1.33211225e-01f, -9.28859562e-02f, 1.94538280e-01f, 5.02258763e-02f, 2.38173410e-01f, 5.66033646e-02f, -1.00270197e-01f,
  1.32322133e-01f, -5.97863346e-02f, -7.30013102e-02f, 2.31232032e-01f, 4.76732850e-02f, -1.63540412e-02f, -7.75501654e-02f, 1.10453191e-04f, -3.37808840e-02f, 4.92853075e-02f,
  -9.58994851e-02f, -1.02730349e-01f, -4.61530127e-02f, 1.12464026e-01f, -6.71439022e-02f, 1.15807869e-01f, 8.18221346e-02f, -6.32266924e-02f, 9.87848118e-02f, -5.33517115e-02f,
  5.22930920e-03f, -4.30190377e-03f, 1.14661172e-01f, -2.07051430e-02f, -4.75535467e-02f, 7.34226853e-02f, 9.30547714e-02f, 1.10398948e-01f, 3.54654156e-02f, 4.18447889e-02f,
  1.30070239e-01f, -2.48996913e-02f, -7.94423372e-02f, 4.36863154e-02f, -1.57306090e-01f, -9.50745791e-02f, -1.02208788e-02f, 1.33786276e-01f, 6.32069185e-02f, 7.07432553e-02f,
  -2.95471717e-02f, -6.58124909e-02f, 6.63662031e-02f, -9.35111940e-02f, -1.25765160e-03f, 2.37480313e-01f, 1.20445698e-01f, -1.15577556e-01f, 3.93356606e-02f, 8.00071061e-02f,
  5.33425175e-02f, 3.63667123e-02f, -1.48382232e-01f, -2.06770971e-02f, 1.67389169e-01f, 5.99702112e-02f, 1.81487635e-01f, 7.94895515e-02f, 1.18183962e-03f, -8.23771581e-02f,
  -1.49720162e-01f, -1.33606613e-01f, -2.62757748e-01f, -1.58682019e-02f, -7.50834644e-02f, 7.41851851e-02f, 1.16769433e-01f, -8.28866586e-02f, -4.15192842e-02f, 9.23225060e-02f,
  1.89714581e-02f, 8.18949416e-02f, 8.72853696e-02f, -5.89704253e-02f, -8.61411020e-02f, 6.32211044e-02f, 4.43870686e-02f, -7.89104626e-02f, 8.23831782e-02f, -1.28785530e-02f,
  -8.41886997e-02f, -5.96613390e-03f, -3.43750864e-02f, 1.56579673e-01f, 5.59050627e-02f, -9.93463993e-02f, -4.26433161e-02f, -4.61198986e-02f, 1.12001160e-02f, -9.74295288e-02f,
  -1.17131891e-02f, -9.93069857e-02f, -1.11233637e-01f, 4.23619412e-02f, 6.13871664e-02f, 1.55168369e-01f, 1.17321730e-01f, 8.86556040e-03f, 9.92267430e-02f, 8.74955878e-02f,
  1.56499334e-02f, -1.30569428e-01f, -3.24807912e-02f, -1.41085386e-01f, -8.39074049e-03f, -1.55253168e-02f, -1.14944994e-01f, 9.49442685e-02f, -4.70040292e-02f, -1.58738662e-02f,
  6.65918365e-02f, 1.34359419e-01f, 1.01234086e-01f, -1.11335553e-01f, 4.12337482e-02f, 6.77737370e-02f, 3.85493860e-02f, -9.70385000e-02f, -8.88197646e-02f, -5.87297138e-03f,
  -2.08178997e-01f, 1.18145220e-01f, -9.51814204e-02f, -1.39207110e-01f, 1.39681131e-01f, -2.32030705e-01f, 9.73983780e-02f, 5.12691448e-03f, 1.34289831e-01f, -1.02812305e-01f,
  1.15911126e-01f, -4.77402397e-02f, -4.66023237e-02f, 9.59654599e-02f, 6.45223912e-03f, 1.75029069e-01f, -8.39371085e-02f, 9.22568738e-02f, 2.09316816e-02f, 1.75107066e-02f,
  -1.04127623e-01f, -4.66403849e-02f, 5.63168116e-02f, -1.31937504e-01f, -3.54739204e-02f, 3.37874740e-02f, -1.46932662e-01f, 1.92563254e-02f, -8.79962668e-02f, 6.86207116e-02f,
  -1.19983420e-01f, 7.98241794e-02f, 9.91392583e-02f, 1.99494399e-02f, -8.74544904e-02f, 1.18178464e-02f, 3.61039750e-02f, -2.83030923e-02f, 3.40993307e-03f, 9.69774369e-03f,
  -8.51674601e-02f, 4.49186638e-02f, 7.97294676e-02f, 1.32371083e-01f, -2.86939088e-02f, -1.45989999e-01f, -1.40240537e-02f, 1.75978635e-02f, 5.68500720e-02f, -5.41114323e-02f,
  -1.04180194e-01f, 1.86286688e-01f, 8.32825154e-02f, -1.67494744e-01f, -2.41205499e-01f, 8.85958746e-02f, -2.15576768e-01f, 3.18320543e-02f, -2.20282394e-02f, -8.56564865e-02f,
  2.25085273e-01f, 1.31497771e-01f, -7.96843246e-02f, -6.36210591e-02f, -2.59981126e-01f, -2.00752631e-01f, -1.78649068e-01f, 2.06206173e-01f, 5.00419475e-02f, 1.41508520e-01f,
  -2.94569172e-02f, 1.08821299e-02f, 2.27003753e-01f, 8.45805556e-02f, -3.38026658e-02f, 2.77351201e-01f, 4.87555601e-02f, 8.59623775e-02f, 1.19103035e-02f, -4.30940874e-02f,
  6.61647618e-02f, -4.09563556e-02f, 2.00027004e-02f, -1.25459775e-01f, 5.59516400e-02f, -1.93921462e-01f, 6.29818141e-02f, -1.88578628e-02f, 7.50347460e-03f, -9.51547772e-02f,
  -1.21512637e-01f, 3.69193628e-02f, 4.43386026e-02f, -2.75976881e-02f, 1.94563381e-02f, -8.85155722e-02f, 3.22021246e-02f, -1.02644734e-01f, 2.05542445e-02f, -7.21452162e-02f,
  -3.11279576e-02f, 7.85059854e-02f, 1.70488924e-01f, 3.44885439e-02f, 1.18718535e-01f, 2.86142565e-02f, -4.50063264e-03f, 1.25068650e-01f, 1.03330322e-01f, 1.99837349e-02f,
  -2.04287898e-02f, 7.36855064e-03f, 9.50734764e-02f, 7.78326616e-02f, 4.16436717e-02f, -1.53796434e-01f, -6.36714473e-02f, 7.81797245e-02f, -2.30271630e-02f, -3.69184241e-02f,
  2.08105281e-01f, -9.94167551e-02f, 3.03740706e-02f, 3.83312777e-02f, -9.45656821e-02f, 7.09248590e-04f, -6.64093345e-02f, 1.97015136e-01f, -1.79080963e-02f, 9.01287794e-02f,
  -1.67523891e-01f, -1.60663605e-01f, 7.81433359e-02f, -1.22210503e-01f, -2.47875601e-02f, -4.60379794e-02f, -2.85034981e-02f, -1.45122945e-01f, 1.35863908e-02f, -2.39671804e-02f,
  9.22727734e-02f, 9.58886743e-02f, -3.06549035e-02f, 5.85388429e-02f, 6.55497387e-02f, 1.10484930e-02f, 1.05469607e-01f, -1.33416310e-01f, -1.75830182e-02f, -9.24105793e-02f,
  3.13541964e-02f, -7.97097981e-02f, 6.21585082e-03f, -2.56861411e-02f, -9.11471173e-02f, 5.48141673e-02f, -3.88830751e-02f, 5.28076179e-02f, -7.46650398e-02f, 4.24793959e-02f,
  9.32066422e-03f, -5.90051003e-02f, -1.05935246e-01f, -7.41522312e-02f, -4.35170345e-02f, 9.47176293e-02f, 3.76572870e-02f, 5.07049896e-02f, -3.54114585e-02f, 1.19372800e-01f,
  7.86023661e-02f, 1.94469646e-01f, 4.89426255e-02f, -1.01535171e-01f, -9.59810708e-03f, -1.19912550e-02f, 9.88695994e-02f, -2.73062326e-02f, -1.08006291e-01f, 5.31677976e-02f,
  1.20030819e-02f, -5.80683351e-02f, -2.00453699e-01f, 1.23670690e-01f, -5.64534739e-02f, 2.50400696e-02f, 4.90393452e-02f, -4.85353284e-02f, 1.27980575e-01f, 9.12303180e-02f,
  -1.40651353e-02f, 3.95563543e-02f, -7.38629326e-02f, -1.66880175e-01f, -2.46127710e-01f, 4.80043367e-02f, 1.24111466e-01f, 8.35885759e-03f, -3.06504946e-02f, -4.36902605e-02f,
  1.28827184e-01f, 8.13066512e-02f, 4.48002778e-02f, 1.91508219e-01f, 9.95956454e-03f, -1.28798574e-01f, -1.01361580e-01f, -1.19400769e-01f, -3.60038131e-02f, 2.63481867e-02f,
  7.88469836e-02f, -1.21332102e-01f, -2.00278424e-02f, 1.76628605e-02f, -3.28078959e-03f, 4.63871546e-02f, 4.36186902e-02f, 6.36374429e-02f, 1.15101159e-01f, -1.53716117e-01f,
  -4.50022928e-02f, 6.32241461e-03f, 1.89749017e-01f, 3.11996751e-02f, -7.94842541e-02f, 9.25064906e-02f, 8.29522908e-02f, 7.91263059e-02f, 1.27318546e-01f, 1.18467957e-01f,
  -1.43681809e-01f, -3.97209562e-02f, 5.64210117e-03f, 5.74126514e-03f, 3.00500393e-02f, -1.37627855e-01f, -8.50794662e-04f, 2.61931926e-01f, -4.99682091e-02f, 6.82050809e-02f,
  4.51293923e-02f, 5.73024452e-02f, 2.25859076e-01f, -9.77928117e-02f, 1.28091071e-02f, 1.29006252e-01f, 8.62820446e-02f, -2.22896770e-01f, 4.97232489e-02f, 9.04075876e-02f,
  -1.10203989e-01f, -1.50767088e-01f, -1.87891051e-01f, 1.10298051e-02f, 1.55535266e-01f, 8.43100101e-02f, 9.16870683e-02f, -7.33116120e-02f, 1.70567855e-01f, 4.90873167e-03f,
  -1.10052474e-01f, 9.72188562e-02f, 1.91513635e-02f, -1.72453210e-01f, -1.77043900e-01f, 1.62257195e-01f, -1.16565432e-02f, 5.29445745e-02f, -1.64294280e-02f, -1.64814204e-01f,
  -6.42327368e-02f, -7.62283057e-02f, 3.38672027e-02f, -5.91825135e-02f, -2.58945394e-02f, 7.85660967e-02f, 6.75134500e-03f, 1.35940582e-01f, 2.90108845e-02f, 2.23215427e-02f,
  5.33380685e-03f, 3.58438529e-02f, 1.55078605e-01f, -4.21581343e-02f, 2.14707330e-02f, -4.99004833e-02f, 1.48168311e-01f, -6.29184907e-03f, -6.94872439e-02f, 4.80006449e-02f,
  3.78450891e-03f, 2.18925707e-04f, 4.00143899e-02f, -3.69346403e-02f, -2.54963636e-01f, 5.10401130e-02f, 1.53757259e-01f, -1.21403441e-01f, 1.32518917e-01f, -1.63336426e-01f,
  -5.63626885e-02f, 1.65299013e-01f, -1.03096642e-01f, -8.39188918e-02f, -8.60763490e-02f, 1.16840936e-01f, 1.75024301e-01f, 4.19576764e-02f, -2.95224357e-02f, -2.29502060e-02f,
  1.64425269e-01f, -1.36511937e-01f, 5.24145477e-02f, -9.69553273e-03f, -1.83972090e-01f, -1.14919536e-01f, -1.96425423e-01f, 2.04851129e-03f, 7.35042691e-02f, -1.16860896e-01f,
  -5.39112128e-02f, -2.99308952e-02f, 2.80367136e-01f, -6.77983537e-02f, -3.53830270e-02f, 1.09429918e-01f, 5.57310227e-03f, -9.65389162e-02f, -6.65954351e-02f, 2.38215420e-02f,
  -4.48019281e-02f, -4.54031639e-02f, -1.07465498e-01f, -3.44625078e-02f, 7.45443907e-03f, -4.71087452e-03f, -6.00783974e-02f, -2.91638635e-02f, 8.30101073e-02f, 2.93038711e-02f,
  -9.12969746e-03f, -2.63742059e-02f, -3.01730372e-02f, -7.02564567e-02f, 5.27164377e-02f, 3.00891511e-02f, 3.30862217e-02f, -7.87175819e-02f, -7.53853396e-02f, 5.43187326e-03f,
  -6.93875104e-02f, 4.78144689e-03f, 2.07296181e-02f, 1.11287288e-01f, 3.06984726e-02f, 6.34607226e-02f, 7.45855868e-02f, -1.58973262e-01f, -1.89258248e-01f, -1.83751181e-01f,
  -1.03232026e-01f, 4.48929220e-02f, -4.36794572e-02f, -1.78042650e-01f, -8.20174143e-02f, 2.06730962e-02f, 5.05432561e-02f, 8.87905583e-02f, 2.73144655e-02f, -1.05908647e-01f,
  4.06637155e-02f, 7.03034252e-02f, 1.40213922e-01f, -1.83275454e-02f, -6.48051649e-02f, -1.11578889e-01f, -2.32283801e-01f, 2.07148150e-01f, -4.49638106e-02f, -1.17777035e-01f,
  9.11760777e-02f, 4.10635360e-02f, 1.79235697e-01f, -1.37607634e-01f, 9.09526425e-04f, -1.39121667e-01f, 6.97900057e-02f, 1.88652992e-01f, -1.90537572e-01f, 8.00141320e-02f,
  5.46532404e-03f, 1.50887579e-01f, -2.61507072e-02f, 2.70292222e-01f, 5.43866381e-02f, 2.23801166e-01f, 5.57127595e-02f, 1.15728326e-01f, 5.77452369e-02f, 2.62390524e-02f,
  1.27824126e-02f, 8.68981928e-02f, 5.51464222e-02f, -3.18341814e-02f, 6.18152507e-02f, -1.82937548e-01f, -1.13708386e-02f, -6.88607097e-02f, 2.84490921e-02f, -5.66004775e-02f,
  -1.83866411e-01f, 6.79372251e-02f, 8.74335691e-02f, 5.05194329e-02f, -5.01993112e-02f, -3.97756323e-02f, 1.57357335e-01f, -9.96327475e-02f, 4.90955338e-02f, -6.39790148e-02f,
  -3.65716293e-02f, 6.49311170e-02f, 1.54219136e-01f, 6.88756630e-02f, -3.86285670e-02f, -3.20826098e-02f, -5.04992828e-02f, 1.47726372e-01f, 1.32331684e-01f, -5.61692379e-02f,
  -2.94206990e-03f, 7.82551616e-02f, 5.54641709e-02f, 3.81579483e-03f, -1.21501302e-02f, -1.08121045e-01f, -3.83151360e-02f, 2.76045669e-02f, -1.03732489e-01f, -3.46250571e-02f,
  3.40662198e-04f, -5.01475371e-02f, 2.83935014e-02f, 9.52917263e-02f, 3.86969894e-02f, 4.87067886e-02f, -9.42656472e-02f, 1.61707476e-01f, -4.07918766e-02f, -5.74339107e-02f,
  -2.04521894e-01f, -1.29657574e-02f, 1.10253140e-01f, -8.62514675e-02f, 5.80604794e-03f, 1.45312771e-01f, 1.68144524e-01f, -6.56116530e-02f, -1.03643864e-01f, -1.78459119e-02f,
  -3.83793525e-02f, -7.43096471e-02f, 2.28625406e-02f, -2.67973430e-02f, 4.30707373e-02f, 1.09604280e-02f, -1.22427419e-01f, 1.07910730e-01f, -8.11774656e-02f, 1.89267710e-01f,
  3.02518927e-03f, 4.51388583e-03f, -5.07311895e-02f, 4.34563868e-03f, 1.93813905e-01f, 1.36245131e-01f, 6.41324893e-02f, 8.17588530e-04f, -9.36158597e-02f, -2.32166145e-02f,
  1.00758169e-02f, 1.47215426e-01f, 4.31552343e-02f, 3.74678113e-02f, 3.71855521e-03f, -1.42381638e-01f, -1.74665436e-01f, 1.09643362e-01f, 3.10169477e-02f, -1.64031267e-01f,
  1.78397857e-02f, -2.94071250e-02f, -2.95450725e-02f, -6.85744509e-02f, -2.69779451e-02f, -1.80964649e-01f, -1.14287145e-01f, 3.84612344e-02f, -3.05898562e-02f, 1.11887030e-01f,
  3.40898745e-02f, -1.02634788e-01f, 6.05904050e-02f, 1.89174026e-01f, -1.23417087e-01f, -9.04051140e-02f, -2.90780067e-02f, 6.64079338e-02f, 2.51709446e-02f, 9.61679034e-03f,
  -6.37574047e-02f, -1.43193394e-01f, -8.82342979e-02f, 8.61232802e-02f, 1.94661662e-01f, 1.13407426e-01f, 5.37640322e-03f, 1.85616344e-01f, -3.28268334e-02f, 6.76065460e-02f,
  5.60924299e-02f, -3.53933983e-02f, -3.31432447e-02f, -2.48415262e-01f, -7.08937645e-02f, -1.07999071e-01f, -5.11812754e-02f, 5.97557612e-02f, -1.01832800e-01f, 1.65394992e-02f,
  -4.59335335e-02f, 1.04963437e-01f, 7.60534639e-03f, 1.03245996e-01f, -2.37750579e-02f, -6.77694334e-03f, -4.76848520e-02f, 7.57962763e-02f, 4.45363671e-03f, -1.02095932e-01f,
  -5.95306233e-02f, 1.54534802e-01f, -1.24632463e-01f, 6.61261603e-02f, -6.05042689e-02f, 1.59543365e-01f, -6.53099939e-02f, 1.26456067e-01f, 3.05134133e-02f, -1.05778061e-01f,
  2.34379359e-02f, -1.36189699e-01f, -2.09206104e-01f, -5.60942618e-03f, -9.19590890e-02f, -7.42271915e-02f, -3.23253199e-02f, -7.24263769e-03f, -4.13097553e-02f, 1.11462787e-01f,
  4.25272901e-03f, -1.10404588e-01f, -2.19275360e-03f, 4.51446809e-02f, 1.39462277e-01f, -1.31708607e-01f, -1.55384550e-02f, -3.89235206e-02f, -1.50474727e-01f, 1.14573352e-01f,
  7.40634426e-02f, -6.59286454e-02f, 1.38175666e-01f, 4.43228185e-02f, -2.62151826e-02f, -4.85112369e-02f, 5.75713441e-02f, -5.88666536e-02f, -5.01527488e-02f, 1.81745052e-01f,
  -1.49735123e-01f, 2.25491270e-01f, -2.05129787e-01f, 1.76802471e-01f, -2.23645661e-03f, 1.22209623e-01f, -8.96015242e-02f, 2.03818962e-01f, 3.01087246e-04f, 1.08292021e-01f,
  1.09491490e-01f, 5.58976308e-02f, 1.49218827e-01f, -5.81735708e-02f, -6.64509237e-02f, -1.91734023e-02f, 8.87462124e-02f, -3.33510935e-02f, 1.15660913e-01f, 9.55481902e-02f,
  2.59613898e-03f, -1.46852434e-02f, -2.10771430e-02f, 1.68868169e-01f, 1.29657075e-01f, -9.65047330e-02f, 9.18387845e-02f, 7.86495768e-03f, -6.86427229e-04f, -1.20450407e-01f,
  7.10371137e-02f, -1.18687205e-01f, -1.26074523e-01f, 7.20682666e-02f, 7.07111359e-02f, 1.76531076e-01f, 2.31640249e-01f, -1.55641846e-02f, 1.28740236e-01f, 8.81738067e-02f,
  3.62114497e-02f, -9.54806805e-02f, -1.89524535e-02f, -1.24312364e-01f, -3.82172205e-02f, 1.48493782e-01f, 1.65491626e-02f, -5.34545109e-02f, -1.23560868e-01f, 5.36834039e-02f,
  1.37426266e-02f, 1.39898136e-01f, 1.65570825e-01f, -1.63047314e-01f, -4.02027331e-02f, 7.79950768e-02f, -1.41892554e-02f, -6.40823394e-02f, -5.25305010e-02f, -1.84964407e-02f,
  -1.18126534e-01f, 9.06438455e-02f, -1.42231118e-02f, -1.97712556e-01f, 2.26256803e-01f, -1.47362962e-01f, 1.63442567e-01f, -3.54720023e-03f, -5.15410735e-04f, -9.55742672e-02f,
  8.19613710e-02f, -1.46666899e-01f, -3.63422073e-02f, -8.27410668e-02f, 5.54340258e-02f, 5.51488809e-02f, 3.36487032e-02f, 6.27599880e-02f, -1.40392274e-01f, 1.58691734e-01f,
  1.37320505e-02f, 1.58727333e-01f, 9.23789367e-02f, 2.99049132e-02f, -5.11208316e-03f, -5.57303913e-02f, 9.97140035e-02f, 1.53639600e-01f, 9.29516628e-02f, 3.23150791e-02f,
  -1.49499610e-01f, -1.54320151e-02f, 4.06198092e-02f, 8.63781869e-02f, 3.34163979e-02f, 2.48514153e-02f, -6.41110167e-02f, -4.08251621e-02f, -1.29401028e-01f, 7.32537881e-02f,
  1.01171926e-01f, -1.13840148e-01f, 1.32873863e-01f, -3.83789651e-02f, -8.63448232e-02f, -9.15229097e-02f, 8.43307097e-03f, -1.16581932e-01f, -1.25185609e-01f, -5.44910645e-03f,
  -6.50034919e-02f, 1.49714917e-01f, 5.25024720e-02f, -6.80219680e-02f, 4.52347994e-02f, 1.62485585e-01f, -1.00571007e-01f, -8.73907730e-02f, -1.23843197e-02f, -1.62141956e-02f,
  4.57286574e-02f, 1.06028812e-02f, -6.17249757e-02f, -7.68268704e-02f, -1.33591210e-02f, 4.17382009e-02f, 9.23427045e-02f, 9.61648300e-02f, 9.94191468e-02f, 8.31131041e-02f,
  7.74151906e-02f, 8.69461671e-02f, 5.28051779e-02f, -1.10752814e-01f, -1.94569379e-02f, -1.01954624e-01f, 1.91858128e-01f, 7.86470175e-02f, 4.66133878e-02f, -1.13470852e-03f,
  1.08541802e-01f, -7.56943045e-05f, 1.30789563e-01f, -9.99584701e-03f, 4.54612821e-02f, -6.38686717e-02f, 1.53735951e-01f, 9.72336605e-02f, 1.20649084e-01f, -1.58890456e-01f,
  -1.09662049e-01f, 1.01560645e-01f, 5.30928746e-02f, -3.90929617e-02f, 5.81836961e-02f, 4.29422334e-02f, 1.61524534e-01f, -1.78080171e-01f, -1.06053362e-02f, -1.46243364e-01f,
  -1.36069760e-01f, 1.84779525e-01f, -1.56137198e-01f, 2.07365662e-01f, 3.17298889e-01f, 3.43338884e-02f, 2.83742219e-01f, 8.43231827e-02f, 1.07053198e-01f, 7.94351697e-02f,
  -8.85082036e-02f, 7.03193620e-02f, 4.25129384e-02f, 2.62076110e-01f, 7.64887929e-02f, 2.98992489e-02f, -1.58705935e-01f, -7.97713399e-02f, -9.27857533e-02f, -5.78926541e-02f,
  2.32263923e-01f, -1.38087109e-01f, -1.92438379e-01f, -2.36470774e-01f, -3.54193226e-02f, 3.67624834e-02f, -2.10242823e-01f, 1.06527500e-01f, -8.12066346e-02f, -1.50486290e-01f,
  4.40007150e-02f, 2.72885226e-02f, 2.55390346e-01f, 2.02915296e-01f, 2.49426603e-01f, -3.24141741e-01f, 5.50083928e-02f, -2.85063535e-01f, -1.46559164e-01f, 2.44841337e-01f,
  5.51902056e-02f, -3.82359996e-02f, -4.45196517e-02f, -1.41313598e-01f, 7.65298158e-02f, -3.72869857e-02f, -2.79743299e-02f, -4.32599299e-02f, 3.82660255e-02f, 5.73920980e-02f,
  -4.36984710e-02f, 2.37686578e-02f, 1.30240445e-03f, -5.99784739e-02f, 6.18037730e-02f, 6.30752668e-02f, 3.90869454e-02f, -9.37999785e-02f, 8.50442201e-02f, -4.76329178e-02f,
  -2.06384063e-02f, -1.10179894e-01f, 8.25293139e-02f, -2.96670068e-02f, 2.30051242e-02f, 1.14767976e-01f, 7.04039261e-02f, 2.80546490e-02f, 1.10031165e-01f, -8.54594335e-02f,
  -5.22734858e-02f, 4.19831127e-02f, 1.10510133e-01f, 1.17553689e-01f, -5.17602488e-02f, -5.31341583e-02f, 4.28379998e-02f, 4.42168936e-02f, 1.25513554e-01f, -1.99324206e-01f,
  -7.15827793e-02f, 1.03380702e-01f, 1.52065471e-01f, -1.46148037e-02f, 2.89101392e-01f, -9.39143673e-02f, -2.80290488e-02f, 1.64814189e-01f, -1.99141800e-01f, -3.82503755e-02f,
  -8.14259350e-02f, 2.90496610e-02f, 1.02361478e-01f, 9.01509970e-02f, 6.47022575e-02f, -2.05138519e-01f, 2.24394910e-02f, -1.71753258e-01f, -5.45807518e-02f, -3.08875646e-02f,
  -3.77869904e-02f, -1.89383000e-01f, -6.47871420e-02f, -3.32466960e-01f, -9.63417888e-02f, -5.50483502e-02f, -5.91523834e-02f, 5.86840045e-03f, -8.64954367e-02f, -5.45281954e-02f,
  -2.05856070e-01f, 2.23229334e-01f, -8.01583007e-02f, 1.89849973e-01f, 8.84965062e-04f, 4.72539440e-02f, -7.65270144e-02f, -1.16396081e-02f, 1.27651468e-01f, 9.69892517e-02f,
  4.38410863e-02f, -4.71225567e-02f, -4.69079576e-02f, -3.10017671e-02f, -3.66779082e-02f, 1.44492075e-01f, -2.78275087e-02f, 1.11408466e-02f, -8.21024696e-06f, -1.61842495e-01f,
  -1.12755867e-02f, 1.96098480e-02f, 6.40590442e-03f, -6.15313202e-02f, -4.48139198e-02f, -1.10266529e-01f, -1.23676091e-01f, -1.34309575e-01f, 6.08530864e-02f, -8.49095732e-02f,
  -1.26808926e-01f, -4.51000184e-02f, -9.36698914e-02f, 1.20644800e-01f, 5.17060868e-02f, -8.25160369e-02f, 1.56039029e-01f, 1.23007528e-01f, -1.05805293e-01f, 4.48667184e-02f,
  8.49851072e-02f, 5.84798381e-02f, 2.93134637e-02f, -4.20267954e-02f, -8.43534619e-02f, -1.54543251e-01f, 1.46118309e-02f, 1.18528344e-01f, 1.72286034e-01f, 7.50278588e-03f,
  -4.77580428e-02f, -2.44903732e-02f, -5.43588400e-02f, 2.22991332e-01f, -7.50879645e-02f, -1.79150868e-02f, -5.87819479e-02f, -2.82078415e-01f, 6.52900264e-02f, 6.45994842e-02f,
  -7.72584463e-03f, 3.55887203e-03f, -1.90148316e-02f, 7.02179298e-02f, -1.59618109e-02f, 6.14471966e-03f, 4.68291491e-02f, -3.51914279e-02f, -8.51719975e-02f, -2.97551341e-02f,
  4.45810100e-03f, 4.86948676e-02f, -6.33265600e-02f, 5.62576763e-03f, 1.47710396e-02f, 3.12047042e-02f, -4.28573638e-02f, 2.68940777e-02f, 7.64120296e-02f, 2.11305469e-02f,
  -4.88882922e-02f, 5.38732074e-02f, 1.36440750e-02f, 5.89125231e-02f, 2.56289840e-01f, -1.16962947e-01f, -1.66980609e-01f, 9.28838626e-02f, -7.71202147e-02f, 7.51959383e-02f,
  7.97556564e-02f, -6.44435138e-02f, 4.55572121e-02f, 1.00586489e-01f, 1.11360840e-01f, -7.26616383e-02f, -9.61818025e-02f, -9.69986469e-02f, -3.44529115e-02f, 1.02208573e-02f,
  -3.49881276e-02f, 4.31739446e-03f, -1.14179570e-02f, 1.11288507e-03f, 1.29676580e-01f, 1.40730515e-01f, 1.03880741e-01f, 3.70119838e-03f, -1.05864063e-01f, 7.92110860e-02f,
  1.56536296e-01f, 3.33157144e-02f, -1.86049685e-01f, 2.90671140e-02f, -3.43589261e-02f, -6.63173422e-02f, -8.52337629e-02f, 2.16047242e-01f, 1.39250448e-02f, -1.30925685e-01f,
  -2.12626681e-02f, -1.87360216e-02f, -1.75759699e-02f, -8.79657790e-02f, -7.39651248e-02f, 8.47430527e-02f, -1.12494454e-01f, -9.02101118e-03f, -7.61289522e-02f, 4.64887694e-02f,
  -7.18763024e-02f, 4.01753113e-02f, -4.49289940e-02f, -3.49826105e-02f, -7.21245706e-02f, 9.13533717e-02f, 1.07139856e-01f, -1.09481722e-01f, -1.57141704e-02f, 1.52300671e-02f,
  2.56004203e-02f, 1.78233755e-03f, -7.35364854e-02f, 3.91321145e-02f, -9.84474830e-03f, 9.00387317e-02f, 8.27343836e-02f, -5.33938184e-02f, -9.47324038e-02f, -1.39269933e-01f,
  -1.08002283e-01f, -1.29859829e-02f, -1.12843215e-01f, -1.03134371e-01f, -5.26270866e-02f, -9.68957413e-03f, 3.12855169e-02f, 5.80219887e-02f, -1.89585332e-02f, -1.09863915e-01f,
  9.15847532e-03f, 2.95508164e-03f, 9.07854140e-02f, 2.22502761e-02f, -3.63097005e-02f, -7.10132644e-02f, -1.61584154e-01f, 9.89753678e-02f, 2.59708967e-02f, -4.67361473e-02f,
  5.24812117e-02f, 3.15039940e-02f, 1.74791589e-01f, -1.23128347e-01f, -1.99483223e-02f, 2.66842078e-02f, 7.47065060e-03f, 6.03076629e-02f, -8.87525752e-02f, 5.88208809e-02f,
  -3.81824411e-02f, 1.37032671e-02f, 3.16174179e-02f, 1.98229834e-01f, 9.73142460e-02f, 9.66185646e-04f, -6.39176220e-02f, -1.15891183e-02f, 4.62627411e-02f, -5.09638749e-02f,
  -2.96083596e-02f, -9.45618898e-02f, -1.26375288e-01f, -8.45082197e-03f, -8.30168128e-02f, -1.15309730e-02f, -4.75857928e-02f, -2.42693145e-02f, -8.56962875e-02f, -9.43294028e-04f,
  9.35585275e-02f, 6.07916005e-02f, 3.60311866e-02f, -8.01990926e-02f, 1.05164880e-02f, -9.64543745e-02f, -1.02409653e-01f, -4.53167669e-02f, 6.22780025e-02f, -7.34519362e-02f,
  -8.94730538e-02f, -8.26690271e-02f, 1.11039042e-01f, 1.07625544e-01f, 3.87295224e-02f, 6.18144497e-03f, -8.65810886e-02f, 1.28316313e-01f, 5.03024878e-03f, -1.20155670e-01f,
  8.74908757e-04f, -1.71562508e-01f, -6.14103563e-02f, -5.22804484e-02f, -1.44434601e-01f, 1.20544367e-01f, 5.13530187e-02f, -7.20471004e-03f, -8.83837137e-03f, 1.19928531e-01f,
  -1.12629971e-02f, -3.13150212e-02f, 1.38801098e-01f, 1.09563194e-01f, -1.63490977e-02f, -1.24605991e-01f, 1.89059854e-01f, -2.23360434e-02f, -2.03398168e-01f, 1.79965422e-01f,
  8.08152184e-02f, -3.92957665e-02f, 4.72847410e-02f, -2.25094900e-01f, 6.26893714e-02f, 3.51198204e-02f, -1.42184123e-02f, 1.36627421e-01f, 1.48481771e-01f, -1.27695456e-01f,
  -1.25596691e-02f, 5.83650619e-02f, -2.24094074e-02f, 1.30276028e-02f, -1.34970611e-02f, 2.88733840e-02f, 2.60967463e-02f, -6.99248239e-02f, 3.78107727e-02f, -1.11759827e-01f,
  -1.16574079e-01f, -6.60570115e-02f, -3.26688141e-02f, 9.73694678e-03f, -1.30422220e-01f, -6.16643876e-02f, -4.81391512e-02f, 2.05649696e-02f, -1.73914582e-02f, -9.60965641e-03f,
  1.97588578e-02f, -7.52738640e-02f, -5.60841262e-02f, -4.07627299e-02f, -6.05072081e-03f, 3.18485573e-02f, 2.14524120e-01f, -1.07077271e-01f, -1.28167912e-01f, 9.57212597e-02f,
  -1.06883548e-01f, 1.04908325e-01f, 1.11988090e-01f, -2.17960570e-02f, 3.21367681e-02f, 1.23238809e-01f, 9.68997255e-02f, -5.73336780e-02f, -1.84399867e-03f, -1.44149929e-01f,
  -5.78160994e-02f, 5.28979599e-02f, -9.07609090e-02f, -9.71596017e-02f, 2.38566734e-02f, 4.98510338e-02f, 9.85218734e-02f, 7.90384486e-02f, 4.08056565e-02f, 3.79521884e-02f,
  -8.78929794e-02f, 1.01958409e-01f, 1.11481979e-01f, -3.56455632e-02f, -2.62407213e-01f, -5.60687445e-02f, -5.07591963e-02f, -1.79787800e-01f, -1.09872557e-01f, 1.19853854e-01f,
  1.22078611e-02f, -6.61059320e-02f, -9.30731967e-02f, 2.54767225e-03f, -1.29433513e-01f, -4.15483005e-02f, -2.86947526e-02f, 2.53152344e-02f, -1.32268280e-01f, -8.75104405e-03f,
  -1.12488918e-01f, 5.28887287e-02f, -1.08402252e-01f, 9.56967697e-02f, -9.28573757e-02f, -5.90371117e-02f, -5.09993732e-02f, 9.83541831e-02f, 1.34304538e-01f, 5.68555519e-02f,
  -1.94339976e-02f, 1.76774487e-02f, -9.55007374e-02f, -7.91306142e-03f, -9.27040204e-02f, 1.23339973e-01f, -9.30610951e-03f, 7.60002062e-02f, 2.06286795e-02f, -2.01680169e-01f,
  9.36125368e-02f, -7.41547793e-02f, -2.17597246e-01f, 5.14432937e-02f, -2.06356063e-01f, -7.22358748e-02f, -8.56099725e-02f, -1.44309253e-01f, 1.33267745e-01f, -4.06820551e-02f,
  -1.18004814e-01f, -2.10863069e-01f, -1.55238971e-01f, -8.75433832e-02f, 8.16744417e-02f, 8.34172145e-02f, 9.15400386e-02f, 1.16883881e-01f, -2.25994244e-01f, 1.13738604e-01f,
  1.38691559e-01f, 1.84169471e-01f, 7.80978277e-02f, -4.88935970e-02f, 6.43698126e-02f, -9.42884609e-02f, 5.07481582e-02f, 1.12700440e-01f, -7.25401863e-02f, 1.23312483e-02f,
  -1.30530745e-01f, -1.76157281e-01f, -2.26081058e-01f, 3.05433393e-01f, -2.14742939e-03f, 1.84721738e-01f, 7.50116110e-02f, -2.47659579e-01f, -4.20765802e-02f, 8.67886618e-02f,
  -6.19922727e-02f, 4.25708629e-02f, -4.51319478e-02f, -3.53171267e-02f, -1.85202397e-02f, -7.79047534e-02f, -5.96056096e-02f, -1.15943467e-02f, -1.04425438e-01f, -2.30223835e-02f,
  -3.66087742e-02f, -5.56755923e-02f, 3.99394110e-02f, 9.49765928e-03f, -5.09238392e-02f, -3.53796482e-02f, 5.35583943e-02f, -7.25888014e-02f, -5.81262708e-02f, 6.74115047e-02f,
  1.09304480e-01f, -1.91543847e-02f, 1.55307567e-02f, 2.25425866e-02f, 9.74688157e-02f, 2.46593319e-02f, -1.12829827e-01f, 7.38809481e-02f, -1.73161387e-01f, -1.20992819e-02f,
  1.19872438e-02f, 1.72014330e-02f, 5.86998574e-02f, -4.87208441e-02f, -3.09072956e-02f, -7.41803646e-02f, -4.70502628e-03f, -1.36972263e-01f, 2.31569242e-02f, 1.37028500e-01f,
  1.63099822e-02f, 2.44351663e-02f, -3.63834538e-02f, 3.18613239e-02f, 1.07259594e-01f, 5.16905524e-02f, -7.50439912e-02f, -1.05782643e-01f, 2.15825394e-01f, -3.31138596e-02f,
  1.15719318e-01f, 1.63365304e-01f, -9.27486494e-02f, -5.19590452e-02f, -6.65229708e-02f, -2.16599539e-01f, -1.47169456e-01f, 3.22996303e-02f, -9.47622061e-02f, 1.89550430e-01f,
  1.51473165e-01f, -1.46199748e-01f, 2.24714894e-02f, -9.75491200e-03f, -5.68916164e-02f, 6.83757216e-02f, -5.44305593e-02f, 2.05649575e-03f, -1.05341084e-01f, 1.41062355e-02f,
  -5.67817986e-02f, 1.31776959e-01f, -4.98624751e-03f, -3.86484899e-02f, 1.71115045e-02f, 3.97197455e-02f, 3.40253636e-02f, -5.86236715e-02f, 1.92144047e-03f, 8.82595871e-03f,
  -1.29750609e-01f, -2.18630992e-02f, -3.82714868e-02f, 9.56451967e-02f, 3.21256593e-02f, 9.49268490e-02f, 5.58479987e-02f, -5.63183799e-02f, -2.04969104e-02f, -1.22203760e-01f,
  -1.68367565e-01f, -3.39746173e-03f, -3.97225209e-02f, -3.30358259e-02f, -1.00318804e-01f, -1.35414645e-01f, 1.01225644e-01f, -1.04857907e-01f, -4.49302867e-02f, -9.25108269e-02f,
  -1.49646267e-01f, 1.33292690e-01f, 9.16971937e-02f, -6.25056447e-03f, -5.60019203e-02f, 1.75573364e-01f, -2.08281755e-01f, 6.76029250e-02f, 7.74463415e-02f, 2.75189839e-02f,
  1.64207324e-01f, -1.73895583e-02f, 1.24165900e-01f, -1.78535521e-01f, -4.65556309e-02f, 2.29354091e-02f, -8.01379457e-02f, 6.69039786e-02f, 2.05132682e-02f, 6.25272244e-02f,
  -1.84327900e-01f, 1.46216750e-01f, -1.73034593e-02f, 1.17466912e-01f, 1.58175573e-01f, 1.48199843e-02f, 1.45332972e-02f, -6.02970906e-02f, -4.92570847e-02f, -9.51240435e-02f,
  1.57606360e-02f, -7.38148317e-02f, 3.19113731e-02f, -1.10237651e-01f, 3.79532166e-02f, -3.98842283e-02f, -2.16955356e-02f, 2.75139697e-02f, 1.37891592e-02f, 2.53505912e-03f,
  1.99733581e-02f, -1.49450317e-01f, -2.30485108e-02f, -9.05983597e-02f, 1.23802744e-01f, -1.42681412e-02f, -6.05856907e-03f, -8.27270299e-02f, 3.34121101e-02f, 3.10917571e-02f,
  -2.41076257e-02f, 8.00998434e-02f, -1.47930801e-01f, -9.39267501e-03f, 9.10018757e-02f, 9.09685865e-02f, -1.03662014e-02f, -1.63575843e-01f, 2.26243753e-02f, 1.90579057e-01f,
  4.75145690e-02f, 1.06011748e-01f, 4.77235876e-02f, 8.02738667e-02f, 1.35331258e-01f, -1.03976794e-01f, -5.90197854e-02f, 1.71373352e-01f, 2.92249639e-02f, -2.03067884e-01f,
  1.22376993e-01f, 8.50666910e-02f, -1.32477120e-01f, -1.21892713e-01f, -1.95167437e-01f, -2.45316420e-02f, 1.28451020e-01f, 5.72104156e-02f, 7.72443935e-02f, -1.79784764e-02f,
  1.23653881e-01f, -5.46509512e-02f, -6.87833726e-02f, 4.14566435e-02f, 1.39045253e-01f, -2.28830010e-01f, -2.01597303e-01f, 8.84248614e-02f, 1.03986479e-01f, 3.70222516e-02f
};

// L1_fan_Wp_bar (Shape: 14 x 64)
const int L1_fan_Wp_bar_rows = 14;
const int L1_fan_Wp_bar_cols = 64;
const float L1_fan_Wp_bar_data[] = {
  -1.16492100e-01f, -5.84175959e-02f, -4.73349243e-02f, 7.15640113e-02f, -6.53202981e-02f, -2.52007842e-02f, -6.48503453e-02f, 1.35423526e-01f, 2.18548030e-02f, 1.71060845e-01f,
  2.26566121e-02f, -8.97055306e-03f, -4.01402451e-02f, 1.55228972e-01f, 1.69595316e-01f, 8.23289715e-03f, -1.22742746e-02f, 1.03415556e-01f, 1.11179613e-02f, -1.58749241e-02f,
  -1.31774088e-02f, 1.85241178e-01f, 6.83931708e-02f, 1.28473520e-01f, 1.23453863e-01f, -1.84236228e-01f, -1.46118179e-01f, -1.46565020e-01f, -2.00389072e-01f, -1.14092544e-01f,
  -1.48684904e-01f, -1.08168334e-01f, -1.10164620e-01f, 1.68029629e-02f, 4.12724912e-02f, 1.30477604e-02f, -8.85773301e-02f, -1.98333874e-01f, -3.29928957e-02f, 2.45089497e-04f,
  1.96195334e-01f, -3.62602621e-02f, -2.72797793e-02f, -1.98235884e-02f, -2.22951829e-01f, 1.44631088e-01f, 7.22343177e-02f, -1.70572996e-02f, 5.91980591e-02f, 5.23498245e-02f,
  1.93996266e-01f, -1.89618602e-01f, -1.73989926e-02f, 6.60575032e-02f, 1.15052104e-01f, 2.09928200e-01f, -1.28388181e-01f, 1.51953325e-01f, 5.64807691e-02f, 1.86157733e-01f,
  9.95846391e-02f, 3.53799731e-01f, 4.59682196e-02f, -3.44771572e-04f, 1.34274811e-01f, 1.59696817e-01f, 2.29947772e-02f, 1.32647455e-01f, -9.82125942e-03f, 1.82368681e-01f,
  1.21499427e-01f, 3.61746214e-02f, 4.13949266e-02f, 1.73531566e-02f, 8.14569369e-02f, 1.12788260e-01f, 1.43624216e-01f, 2.39743423e-02f, -1.57603752e-02f, 4.43192124e-02f,
  4.58627380e-02f, 1.27807215e-01f, -4.73762266e-02f, 9.47068855e-02f, 1.20584950e-01f, 9.35156345e-02f, 2.21707858e-02f, 2.09726486e-02f, 1.38008207e-01f, 2.72980947e-02f,
  8.88481885e-02f, -1.03969939e-01f, -8.07894096e-02f, 9.92659256e-02f, 1.35391103e-02f, 6.98003569e-04f, -1.81577392e-02f, -4.63991426e-02f, -1.07633546e-02f, 1.25777766e-01f,
  5.91128580e-02f, 2.73079891e-03f, 2.04444304e-02f, -1.37288431e-02f, -7.59709114e-03f, -3.90084088e-02f, -5.87154999e-02f, 1.66932009e-02f, -1.53745994e-01f, 5.57740852e-02f,
  4.38861139e-02f, -6.11894503e-02f, 1.81036636e-01f, 1.58608973e-01f, -6.23780973e-02f, 9.27403197e-02f, 1.37969092e-01f, -1.07608356e-01f, -1.67112291e-01f, 1.18805870e-01f,
  4.53877971e-02f, 9.99744758e-02f, -1.22185878e-01f, 1.28353402e-01f, 1.39434516e-01f, 6.37783185e-02f, 5.05309924e-02f, 2.89532721e-01f, -3.28553692e-02f, 1.75955668e-02f,
  8.18379819e-02f, 1.64174691e-01f, 1.73941478e-02f, 7.64522925e-02f, -1.78100541e-01f, 3.05530071e-01f, -2.45988127e-02f, 2.42485598e-01f, -2.09720600e-02f, 5.53696640e-02f,
  9.63784754e-02f, 9.71381739e-02f, 2.17251062e-01f, 1.25847369e-01f, 1.05831318e-01f, 1.38792634e-01f, -5.28583415e-02f, 5.70711792e-02f, 5.86848846e-03f, 1.72657624e-01f,
  1.37810275e-01f, 9.05431584e-02f, 2.40857862e-02f, -2.51505792e-01f, -1.45182833e-02f, 3.38955894e-02f, -5.73014328e-03f, -1.80025801e-01f, -5.70080914e-02f, -1.31479844e-01f,
  -1.39992088e-01f, -1.60916790e-01f, 9.51556936e-02f, -1.11838914e-01f, -1.76086798e-01f, -7.54859373e-02f, -1.50578961e-01f, 8.58925134e-02f, 6.06307872e-02f, -3.83030884e-02f,
  1.68114856e-01f, 1.22651808e-01f, -1.31153926e-01f, 2.47143917e-02f, 8.77215639e-02f, 1.92518309e-01f, 3.59038338e-02f, -8.64840522e-02f, 3.92252244e-02f, -7.51787648e-02f,
  1.35061041e-01f, 2.64145404e-01f, 2.50684500e-01f, 1.20351471e-01f, 2.23233849e-02f, 5.23391413e-03f, 9.49184000e-02f, 3.43987465e-01f, 6.24627098e-02f, 3.23046781e-02f,
  -3.23422672e-03f, -2.37725958e-01f, 2.43862420e-01f, 2.12709099e-01f, 7.11212680e-02f, 1.25093520e-01f, 1.57381490e-01f, 7.51586407e-02f, 6.04138710e-02f, -5.61806932e-02f,
  1.53283402e-01f, -1.52995121e-02f, 1.58192553e-02f, 1.98158234e-01f, 1.65837899e-01f, -2.89700888e-02f, -2.82052737e-02f, 6.35769144e-02f, 1.90103933e-01f, 1.67080849e-01f,
  3.98101099e-02f, 7.41900131e-02f, 7.91661963e-02f, 5.47253676e-02f, 2.68183015e-02f, 9.27955210e-02f, 1.80913895e-01f, 2.13330030e-01f, 2.80736834e-01f, -8.60731527e-02f,
  -1.06089942e-01f, 2.75310520e-02f, -1.17626123e-01f, 1.62305608e-01f, 1.21048167e-01f, 6.28003329e-02f, -3.61014344e-02f, 1.13406703e-01f, 5.16002290e-02f, 6.14778176e-02f,
  1.10100865e-01f, -1.67720944e-01f, -1.32823691e-01f, 1.14726827e-01f, -3.88971642e-02f, 1.23711536e-03f, 2.26397276e-01f, -8.40477124e-02f, 5.47128394e-02f, 8.03800523e-02f,
  -5.00747785e-02f, 1.21802598e-01f, -6.96429387e-02f, 2.72946060e-01f, 2.95049727e-01f, 4.59867828e-02f, -2.74586171e-01f, -3.97827253e-02f, 1.22423694e-01f, -6.77710772e-02f,
  -2.99574584e-01f, 5.64842299e-02f, 5.40345758e-02f, -7.98520073e-02f, 1.20420225e-01f, 1.52391523e-01f, 3.20371613e-02f, 1.99365675e-01f, 1.72020122e-01f, 1.05209999e-01f,
  1.53058827e-01f, -4.18640859e-02f, -2.01867167e-02f, -7.96284229e-02f, 6.29807189e-02f, 9.50330868e-02f, 1.60568178e-01f, 6.55402616e-02f, -1.60946709e-03f, 2.80684419e-02f,
  2.37674281e-01f, 9.40015167e-02f, 1.34834066e-01f, -3.60754766e-02f, 1.45248562e-01f, -5.01383804e-02f, -6.90345317e-02f, -3.81379644e-03f, 1.82400450e-01f, 1.41546458e-01f,
  -5.05007058e-03f, 2.08748966e-01f, 8.53479281e-02f, 1.95599183e-01f, 1.50343552e-01f, 1.93444081e-02f, -1.00153394e-01f, 1.86878741e-01f, 1.17315995e-02f, 4.74077463e-03f,
  -2.58746967e-02f, -2.28215739e-01f, 3.94868292e-02f, -1.09965123e-01f, -1.05614454e-01f, -2.66370345e-02f, 1.46461725e-01f, 2.21404463e-01f, 7.10744709e-02f, 1.18821852e-01f,
  1.95322946e-01f, -9.49722230e-02f, 1.69640094e-01f, 1.31589696e-01f, -1.26100659e-01f, -1.57303050e-01f, 4.41523880e-01f, -3.32441926e-02f, -2.07792804e-01f, 3.97977918e-01f,
  -1.26763424e-02f, -1.18463494e-01f, 1.03968091e-01f, -2.20208168e-01f, 2.70555988e-02f, -3.00867725e-02f, 6.24608190e-04f, 2.58560658e-01f, 5.34538150e-01f, 4.77465093e-02f,
  6.32980242e-02f, 5.65638840e-02f, -7.87222683e-02f, 1.48750423e-02f, 4.55023907e-03f, 1.96010739e-01f, 4.33347523e-02f, 1.22433499e-04f, 3.65943350e-02f, 1.03716262e-01f,
  -4.71957065e-02f, 1.22108243e-01f, 1.13123164e-01f, 4.20765206e-02f, 3.31525840e-02f, -1.51587361e-02f, 2.68251542e-03f, 4.83209714e-02f, -1.78239644e-02f, 7.07011223e-02f,
  1.65117253e-02f, 1.63737446e-01f, 4.25123014e-02f, 1.35368422e-01f, 1.43601835e-01f, -3.76891345e-02f, 1.84347451e-01f, -2.58394569e-01f, -1.81307286e-01f, 1.61138579e-01f,
  -1.27487734e-01f, -9.22047794e-02f, 3.09075005e-02f, 6.18687123e-02f, 1.50051057e-01f, 2.33039916e-01f, 4.30442393e-03f, 1.04623344e-02f, 9.62770805e-02f, -2.09641710e-01f,
  -1.27942517e-01f, 1.64435342e-01f, 8.12069625e-02f, -1.20868973e-01f, -3.11549306e-02f, 1.28876284e-01f, 5.38308453e-03f, 1.61704704e-01f, -3.50195915e-02f, -1.39108188e-02f,
  -1.54476792e-01f, 1.63660884e-01f, 5.06061256e-01f, -8.71943608e-02f, -6.15366101e-02f, -6.77142143e-02f, -9.52529982e-02f, -3.38003337e-02f, -1.94829911e-01f, 1.91308498e-01f,
  -1.35645360e-01f, -1.11536779e-01f, -1.49580628e-01f, -2.11372092e-01f, 9.61013436e-02f, -3.82102281e-02f, 1.96312014e-02f, 8.19473490e-02f, 7.05295876e-02f, 1.25111789e-02f,
  6.67570978e-02f, -1.66638233e-02f, 8.35570693e-02f, 1.03917465e-01f, 8.70989263e-02f, 1.27456337e-01f, 1.19216204e-01f, 1.07268080e-01f, 1.42790020e-01f, 1.58747826e-02f,
  6.57104552e-02f, 1.35296658e-01f, 1.68158650e-01f, 4.47440855e-02f, 1.65323354e-02f, 1.66713536e-01f, 1.09954037e-01f, 1.62274569e-01f, 1.52451977e-01f, 5.36923110e-02f,
  -8.96510575e-03f, -7.32789040e-02f, -7.82351941e-02f, 4.56377231e-02f, -1.17586710e-01f, -6.99080378e-02f, -7.84210041e-02f, 1.77376583e-01f, -5.34918234e-02f, 7.08477292e-03f,
  4.75514792e-02f, -7.00339004e-02f, 1.17281497e-01f, 2.77837310e-02f, 5.57948984e-02f, 6.47417679e-02f, 5.81380576e-02f, -1.70167819e-01f, 3.36036086e-03f, 1.06235571e-01f,
  6.58132136e-02f, -8.12460631e-02f, -5.67913689e-02f, 6.16367273e-02f, 2.51964301e-01f, 1.16367295e-01f, 1.12454511e-01f, 1.16526552e-01f, 1.27421170e-01f, 1.16402455e-01f,
  -8.46336931e-02f, 9.74889621e-02f, -7.04302788e-02f, 1.09605743e-02f, -1.77680701e-02f, 2.17691064e-01f, 2.60880768e-01f, 2.85089910e-01f, 1.69401586e-01f, 1.07551418e-01f,
  9.74811539e-02f, 1.07649803e-01f, 1.01273306e-01f, 1.56126380e-01f, 2.08827764e-01f, 6.14122301e-02f, 1.09684363e-01f, -3.19128931e-02f, 1.40877679e-01f, 1.29687607e-01f,
  1.97736919e-01f, -3.89319807e-02f, -1.33926570e-01f, 7.36579522e-02f, 2.40063071e-02f, 1.23495452e-01f, 1.00310050e-01f, 1.11458525e-01f, 1.59710616e-01f, 3.13405432e-02f,
  5.06764948e-02f, -6.65936098e-02f, 3.39233167e-02f, 1.63373128e-01f, 2.91628372e-02f, 1.58795081e-02f, 1.11295804e-01f, -1.05489437e-02f, 1.78357929e-01f, 1.13043813e-02f,
  6.21339045e-02f, 1.64354332e-02f, -1.39448896e-01f, 9.13732722e-02f, 7.01524839e-02f, 1.20494075e-01f, 4.00489196e-02f, 8.88567641e-02f, -1.11525275e-01f, -1.06731229e-01f,
  -1.23078361e-01f, -9.61368997e-03f, 4.48291339e-02f, -2.53038816e-02f, -1.07364319e-01f, -1.53550416e-01f, 6.24417849e-02f, 1.64839312e-01f, -1.23390935e-01f, 2.09067836e-01f,
  -2.30309903e-03f, -1.54210985e-01f, -5.53298034e-02f, 1.55021265e-01f, 2.21396744e-01f, 2.24992961e-01f, 2.04380136e-02f, -1.12791777e-01f, 1.43631294e-01f, -9.67919305e-02f,
  -1.09692328e-01f, 3.75298113e-01f, 7.59330690e-02f, 8.82523283e-02f, 8.77842978e-02f, -4.89779562e-02f, 1.52879775e-01f, 2.91093215e-02f, 2.75508106e-01f, -8.70860368e-02f,
  1.53241307e-01f, -6.99765831e-02f, 1.22185852e-02f, 4.43785861e-02f, 1.61728814e-01f, 1.10550903e-01f, -8.41966346e-02f, -5.21113761e-02f, 9.10457671e-02f, 9.53265727e-02f,
  2.23608583e-01f, 4.60645482e-02f, 1.68530554e-01f, 9.57985781e-03f, 1.05753586e-01f, 7.77920410e-02f, 1.56986535e-01f, 2.11409450e-01f, 1.34517178e-01f, -1.52387768e-01f,
  -1.27506062e-01f, 1.65899500e-01f, -1.30197212e-01f, 6.85799643e-02f, 1.84596136e-01f, 2.15521991e-01f, -1.99319236e-02f, 2.70635277e-01f, 1.95213914e-01f, 9.78842825e-02f,
  2.46477067e-01f, -3.20999026e-01f, -9.44568440e-02f, 1.84020504e-01f, -3.18360217e-02f, -3.00351888e-01f, 2.33882442e-01f, 1.02715157e-01f, -9.87563580e-02f, -2.66778637e-02f,
  -1.54172346e-01f, 1.34414464e-01f, 8.33582059e-02f, 2.66859829e-01f, 3.08149189e-01f, -1.13124147e-01f, -2.32135355e-01f, -6.92580640e-02f, -6.68034237e-03f, -9.79415625e-02f,
  -1.07636951e-01f, -7.67797306e-02f, 8.32085460e-02f, 2.79972404e-02f, -2.93206703e-02f, 1.75781012e-01f, -1.31715685e-02f, -9.96373221e-02f, 9.86726955e-02f, 7.78685734e-02f,
  5.34339175e-02f, 1.17932372e-01f, -2.37439154e-03f, 2.49869168e-01f, 9.45928916e-02f, 1.48285553e-01f, 5.67560904e-02f, 6.71639517e-02f, 1.05308123e-01f, 8.02085474e-02f,
  1.11083731e-01f, 1.03768334e-01f, 2.87133101e-02f, 1.17297247e-01f, 6.14801869e-02f, 6.88344389e-02f, 9.63746458e-02f, 1.39117584e-01f, 9.95422155e-02f, 7.59176016e-02f,
  6.18603118e-02f, -1.51162714e-01f, -2.68427521e-01f, 7.23131225e-02f, 7.61451349e-02f, -1.49728075e-01f, 1.99227884e-01f, -2.38340795e-01f, -7.91558847e-02f, 6.52080053e-04f,
  3.65825742e-02f, -1.10533781e-01f, -1.51226982e-01f, 1.19965307e-01f, 3.35179567e-02f, 1.11700729e-01f, 2.70533878e-02f, -1.65280282e-01f, 1.00935400e-01f, 3.55123630e-04f,
  -2.09891289e-01f, 4.12364267e-02f, -1.34623051e-01f, -8.42074230e-02f, -1.80302020e-02f, 6.11088350e-02f, -8.58065337e-02f, -1.07416131e-01f, 6.02851734e-02f, -1.11242617e-02f,
  3.41638267e-01f, 2.27314517e-01f, 6.83339685e-02f, 2.22306117e-01f, 3.30750406e-01f, 1.97500467e-01f, 2.77419500e-02f, -3.37011204e-03f, -9.92561728e-02f, -7.05210268e-02f,
  1.02952763e-01f, 6.69284314e-02f, 1.36977062e-01f, 1.06745787e-01f, 1.43183293e-02f, 6.35441989e-02f, 6.33075088e-02f, 1.93479091e-01f, 7.97936991e-02f, 5.05058952e-02f,
  1.01494260e-01f, 4.36018631e-02f, 1.14042424e-01f, 2.69284695e-02f, -7.74607807e-02f, 9.13316905e-02f, 3.78754176e-02f, 1.88292280e-01f, -9.04405266e-02f, 1.94957823e-01f,
  1.81929171e-01f, 7.17374310e-02f, -6.82567134e-02f, 6.15007803e-02f, 2.84426529e-02f, -4.52272631e-02f, -1.51210755e-01f, -2.25530975e-02f, 3.90265360e-02f, -7.90990666e-02f,
  2.02692881e-01f, -3.50820273e-02f, -1.44283529e-02f, -4.50434983e-02f, -4.21932116e-02f, -1.29247585e-03f, -2.69559734e-02f, 8.36937577e-02f, -7.05058575e-02f, 1.60991162e-01f,
  4.31919806e-02f, -2.08840773e-01f, -1.09840356e-01f, 8.53033811e-02f, -2.11093694e-01f, 2.70765163e-02f, -1.16125494e-01f, -1.31668970e-01f, 1.93525180e-01f, 1.30779386e-01f,
  -1.88880876e-01f, 4.16715294e-02f, -3.54178213e-02f, -2.19193503e-01f, 4.44266871e-02f, 2.68415332e-01f, 1.02867872e-01f, 3.32224220e-01f, 2.05051690e-01f, 1.28174096e-01f,
  7.76552334e-02f, -7.45199770e-02f, -1.22831710e-01f, 2.91756928e-01f, 9.76648852e-02f, -8.57178271e-02f, 5.76137826e-02f, 3.49694490e-02f, 1.67105466e-01f, 2.58767065e-02f,
  2.41433196e-02f, 1.44227058e-01f, 6.89882636e-02f, 1.88075259e-01f, 1.49088025e-01f, 2.08306223e-01f, 8.53702277e-02f, 2.59044357e-02f, 2.34170958e-01f, 1.41434178e-01f,
  9.52813402e-02f, 5.50053716e-02f, 1.96763009e-01f, 3.76071967e-02f, 7.15097133e-03f, 1.54569104e-01f, 1.37805417e-01f, 1.19903855e-01f, 1.48718297e-01f, 6.37990311e-02f,
  -1.92797750e-01f, 1.40793398e-01f, 2.48093829e-01f, -2.13887990e-01f, 1.04126610e-01f, -1.13880731e-01f, -4.32586623e-03f, 2.23479271e-01f, -2.26303890e-01f, -1.40318334e-01f,
  -1.31402791e-01f, 1.78051040e-01f, 2.76813447e-01f, -2.99630687e-03f, -6.49477094e-02f, -3.55727486e-02f, 2.01474950e-01f, -7.96882287e-02f, 1.19267479e-01f, -1.29944578e-01f,
  -1.35504439e-01f, -1.02140889e-01f, -2.11213306e-01f, 8.43517035e-02f, 7.48470202e-02f, 7.30668530e-02f, 5.71754836e-02f, 1.65190294e-01f, 3.40627879e-01f, 1.56653356e-02f,
  1.17590226e-01f, 1.81267932e-01f, -6.70057908e-02f, -8.20271745e-02f, 7.32760876e-02f, -3.52250300e-02f, 2.38755867e-02f, -1.22306742e-01f, 6.35673702e-02f, 1.67773634e-01f,
  1.12354986e-01f, 3.84729467e-02f, 2.46139392e-02f, -6.44048899e-02f, 1.86034426e-01f, -2.38892928e-01f, 6.72815517e-02f, -2.74764568e-01f, -8.23627971e-03f, -6.77585900e-02f,
  4.10934314e-02f, 7.73493797e-02f, -1.70995563e-01f, -4.52304520e-02f, -3.58818070e-04f, -7.77622536e-02f, 4.00306359e-02f, 1.86044152e-03f, 5.73973954e-02f, -2.90868938e-01f,
  4.93398495e-02f, -5.32579012e-02f, -1.25190854e-01f, 1.08411178e-01f, 1.71585567e-02f, -2.73517817e-02f, 3.03547904e-02f, 2.28240848e-01f, 4.18144325e-03f, 5.56006655e-02f,
  1.34721085e-01f, -2.55025513e-02f, 2.50337780e-01f, 2.10809097e-01f, 1.89390525e-01f, 1.35583915e-02f, -1.39197871e-01f, -2.02842966e-01f, -2.53911987e-02f, 1.90644890e-01f,
  -2.68083841e-01f, -1.43013507e-01f, 6.27728775e-02f, 9.85203832e-02f, -6.09437563e-02f, 3.39855887e-02f, -6.98645189e-02f, -1.45239666e-01f, 1.97171673e-01f, 4.11973037e-02f,
  7.28686377e-02f, -1.23340189e-01f, -3.77422124e-02f, -1.24295810e-02f, 3.77897844e-02f, 1.13055157e-02f, 5.71062684e-01f, -9.68554243e-02f, -9.38043594e-02f, 1.78546295e-01f,
  1.53578818e-01f, 1.01821065e-01f, 1.66004002e-02f, 5.17360978e-02f, 1.20774217e-01f, -3.18576023e-02f, 1.50276482e-01f, -8.34900141e-02f, 9.02479365e-02f, -6.83235228e-02f,
  1.75302446e-01f, -1.00871541e-01f, -9.23703657e-04f, -3.20560895e-02f, 2.56446302e-02f, 1.10380612e-01f, 5.33077829e-02f, 6.81876019e-02f, 1.28307626e-01f, -1.30679861e-01f,
  1.13168120e-01f, 3.59807815e-03f, 1.32636696e-01f, -1.70016527e-01f, 1.23945281e-01f, 6.96584508e-02f, 1.44134061e-02f, 3.63378562e-02f, 3.13192531e-02f, 1.05951183e-01f,
  1.75078899e-01f, 3.79671864e-02f, 4.65452522e-02f, 6.24784045e-02f, 1.32249966e-01f, -8.86036176e-03f, 9.68100652e-02f, 4.12473688e-03f, 6.36781901e-02f, 5.38356565e-02f,
  -1.15186563e-02f, -1.87218860e-01f, -8.13580975e-02f, 1.24090694e-01f, 4.13005538e-02f, -8.76754373e-02f, 2.61709809e-01f, -1.42254189e-01f, -3.59680019e-02f, 1.83033988e-01f,
  -2.64582187e-01f, -2.35102937e-01f, 5.06922901e-02f, 5.46004027e-02f, 7.21637756e-02f, 2.49590978e-01f, 2.08825931e-01f, -2.51078039e-01f, 1.04008995e-01f, -1.21162489e-01f,
  4.37551230e-01f, -5.69241643e-02f, -7.46067986e-02f, -7.05912113e-02f, 6.42626435e-02f, -1.91847265e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 14)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 14;
const float L1_fan_Bp_bar_data[] = {
  8.88468623e-02f, 1.31439209e-01f, 1.51159585e-01f, 9.56450030e-02f, 1.99358791e-01f, 6.48492351e-02f, 1.26503676e-01f, 3.59170064e-02f, 4.06389311e-02f, 1.68351531e-01f,
  1.17477186e-01f, 1.10990562e-01f, 1.16989076e-01f, 8.87324512e-02f
};

// L2_fan_Wp (Shape: 25 x 64)
const int L2_fan_Wp_rows = 25;
const int L2_fan_Wp_cols = 64;
const float L2_fan_Wp_data[] = {
  -2.89715603e-02f, -4.08034474e-02f, -2.79084481e-02f, 7.61239370e-03f, -1.59671336e-01f, 3.41950618e-02f, -9.01011936e-03f, 1.91163402e-02f, -1.00423552e-01f, 5.28913550e-03f,
  -2.80763227e-02f, -6.76468313e-02f, 8.04119781e-02f, 2.09068209e-02f, -1.59209937e-01f, 2.31895857e-02f, -3.03955022e-02f, -9.71976481e-03f, -9.18544680e-02f, -4.86520007e-02f,
  -3.13069522e-02f, -1.14593945e-01f, -9.69008058e-02f, 6.12551346e-03f, -3.94247919e-02f, 8.45099688e-02f, -2.10340749e-02f, -8.09194967e-02f, 1.91258505e-01f, -6.59960210e-02f,
  1.47849927e-03f, 2.55282968e-02f, 3.08557320e-02f, 1.50435448e-01f, -1.00842759e-01f, 9.92452726e-02f, 1.59747139e-01f, -1.00628532e-01f, 1.14992009e-02f, -2.27014706e-01f,
  -1.89198345e-01f, 8.93622562e-02f, -3.24293524e-02f, 7.99782649e-02f, 9.70956981e-02f, -2.91927848e-02f, 1.33026034e-01f, -2.99892649e-02f, 1.43291473e-01f, -5.89513779e-02f,
  1.97751254e-01f, -1.06017500e-01f, -3.33054876e-03f, -2.09878221e-01f, -3.10919639e-02f, -1.41135052e-01f, 6.18567169e-02f, -1.28023311e-01f, -2.07569584e-01f, 7.58757517e-02f,
  1.42482057e-01f, -1.17462210e-01f, 5.86194694e-02f, -6.82931319e-02f, 1.09177314e-01f, 3.79280560e-02f, 3.05905268e-02f, -1.44528486e-02f, 1.00329146e-02f, -8.79423097e-02f,
  -6.06903806e-02f, 7.73020647e-03f, 1.72205511e-02f, -6.90249680e-03f, 4.21232125e-03f, -4.70602252e-02f, -4.44995053e-02f, 3.68836299e-02f, -6.81349114e-02f, 8.90477598e-02f,
  -9.82755329e-03f, 2.99360100e-02f, -3.51510234e-02f, 3.23553905e-02f, 1.56846438e-02f, -1.67176034e-02f, 8.44564289e-02f, 1.81274191e-02f, -7.12342635e-02f, -3.46009769e-02f,
  -4.23839465e-02f, 8.42615366e-02f, -1.58611406e-03f, -4.31127846e-02f, -1.28177647e-02f, -9.63842943e-02f, -3.58754471e-02f, -5.52967265e-02f, -2.04409566e-02f, 1.69160008e-01f,
  -2.56194118e-02f, 8.88281390e-02f, 1.08901225e-01f, -1.33198321e-01f, -3.59816551e-02f, 1.21982612e-01f, -1.68877114e-02f, 1.23183019e-02f, 1.73829406e-01f, -1.86472274e-02f,
  1.32331476e-01f, 2.50634588e-02f, 1.13141336e-01f, 6.89755892e-03f, -8.48378346e-04f, -6.18739352e-02f, 1.96007624e-01f, -8.61716792e-02f, 1.79781541e-01f, -1.23416796e-01f,
  5.33167971e-04f, -1.31960869e-01f, -2.26685598e-01f, 9.34118703e-02f, 1.69324558e-02f, -4.26464602e-02f, 6.33171275e-02f, 7.85559937e-02f, 9.47818011e-02f, 1.39717069e-02f,
  -4.09899279e-02f, 3.02792471e-02f, 6.62664464e-03f, 1.08483871e-02f, 3.11433128e-03f, -1.32643685e-01f, -8.70568305e-02f, -5.71868196e-02f, -1.98845156e-02f, 6.55490607e-02f,
  3.20851174e-03f, -6.10404722e-02f, -6.62669912e-02f, 3.34071927e-02f, 6.06926493e-02f, -7.47841001e-02f, -5.02896942e-02f, -4.85951873e-03f, -8.54486600e-02f, -3.18081304e-02f,
  -1.85785573e-02f, 2.31558084e-02f, 1.13068698e-02f, -1.14593215e-01f, 3.11943982e-02f, 3.29243764e-02f, -1.45854801e-01f, -1.07212506e-01f, -1.29346952e-01f, 6.23297617e-02f,
  4.51534018e-02f, -4.44050431e-02f, -1.87648803e-01f, 1.38423145e-01f, 3.09882760e-02f, -3.05066146e-02f, 8.41305703e-02f, -2.65831649e-01f, 1.73883699e-02f, 1.64212897e-01f,
  -3.94332409e-02f, 4.94410917e-02f, 1.77667618e-01f, -4.04170118e-02f, 1.70255646e-01f, 4.37646694e-02f, 1.12258866e-01f, 8.25928245e-03f, 6.44744411e-02f, -1.36569917e-01f,
  6.86722919e-02f, -1.86280221e-01f, 7.23920837e-02f, -3.95191424e-02f, 1.09031096e-01f, -2.00935155e-01f, -2.45049343e-01f, 4.91809957e-02f, -7.43204579e-02f, -3.41117941e-03f,
  -1.22145131e-01f, 5.60989752e-02f, -1.46269277e-01f, -5.72600886e-02f, -8.35844949e-02f, 2.60275416e-03f, -8.91286805e-02f, 1.51572293e-02f, 4.71624918e-03f, 2.82735974e-02f,
  3.68866213e-02f, -8.51654783e-02f, -3.50187831e-02f, 3.17640789e-02f, 1.13614285e-02f, 5.73430909e-03f, 7.05095679e-02f, -4.13069203e-02f, -7.23174363e-02f, -2.89648976e-02f,
  -2.10914873e-02f, -4.72952761e-02f, -7.47069865e-02f, 1.03839025e-01f, 9.94600076e-03f, 2.84941234e-02f, 1.52687803e-01f, -6.95061162e-02f, 1.38470992e-01f, -1.94022939e-01f,
  -6.10478818e-02f, 1.13780029e-01f, 1.55565459e-02f, 1.93304807e-01f, 9.20257643e-02f, 9.85421315e-02f, 2.76585808e-04f, -1.79300368e-01f, 2.68631447e-02f, -8.30428004e-02f,
  -2.11896673e-01f, 1.09181687e-01f, 3.94275263e-02f, -1.49717346e-01f, -5.26669994e-02f, -2.10782964e-04f, -1.40297607e-01f, 1.16317943e-01f, -6.18825778e-02f, 1.28969746e-02f,
  -9.46427658e-02f, 1.11559346e-01f, -2.88434010e-02f, 6.60558045e-02f, -1.77594975e-01f, 1.13528363e-01f, -4.16318104e-02f, 1.68467894e-01f, 3.22046243e-02f, 1.28806159e-01f,
  2.09305525e-01f, -7.57866539e-03f, 2.15093531e-02f, -1.92714054e-02f, 1.32387102e-01f, 2.19068378e-02f, -2.67418963e-03f, -4.16867323e-02f, -4.42751832e-02f, 2.21615694e-02f,
  -1.10498746e-03f, -1.38988800e-03f, 1.61265805e-02f, -8.32056068e-03f, -3.08798850e-02f, -3.63244601e-02f, -1.46711655e-02f, 1.46011980e-02f, -5.13799489e-02f, 9.19578522e-02f,
  2.83540636e-02f, 7.78567716e-02f, 2.03550197e-02f, -5.01194522e-02f, 4.23992798e-02f, 3.90259698e-02f, 1.94628891e-02f, 1.80542544e-02f, 5.58467470e-02f, -1.06780063e-02f,
  6.29906207e-02f, -1.58065885e-01f, 7.94616565e-02f, -2.16222145e-02f, -1.73344955e-01f, 3.43061723e-02f, -1.08459331e-01f, 1.13567829e-01f, 9.31820308e-04f, -2.32814867e-02f,
  -2.15781480e-02f, -1.39206294e-02f, -1.75739806e-02f, 1.75223406e-02f, -6.86413646e-02f, -1.90868258e-01f, 6.34276345e-02f, -2.24564178e-03f, -1.21740932e-02f, 4.49153818e-02f,
  9.56275612e-02f, 1.64918099e-02f, 1.45209119e-01f, 1.36603177e-01f, 2.88509093e-02f, 1.32130191e-01f, 8.88057500e-02f, -8.45667422e-02f, 1.24000259e-01f, -9.58554912e-04f,
  2.01659471e-01f, 7.15194494e-02f, 9.66138393e-02f, -1.17638379e-01f, 1.30036801e-01f, -9.23930928e-02f, -1.44148588e-01f, 5.01636826e-02f, 1.62674248e-01f, 1.78008810e-01f,
  -8.70396644e-02f, -3.54339220e-02f, 1.74161848e-02f, -4.51221317e-02f, -2.20515002e-02f, -3.62269431e-02f, -2.73354780e-02f, 5.77597916e-02f, -1.46024767e-02f, -1.65635869e-02f,
  -5.07504828e-02f, 5.89708798e-02f, 9.49678570e-02f, -3.46799903e-02f, 9.41638127e-02f, -1.44672439e-01f, 5.17797619e-02f, 4.48930822e-02f, -5.55165187e-02f, -3.86775918e-02f,
  -8.32563713e-02f, 1.13889776e-01f, -3.86697985e-02f, -2.76923180e-03f, 4.04309388e-03f, 6.92573562e-02f, 2.78890450e-02f, -6.50800765e-02f, 1.88862756e-01f, 5.09366393e-03f,
  1.75829947e-01f, 4.17250618e-02f, -1.31323533e-02f, -6.62915129e-03f, 1.84853077e-02f, -1.08434610e-01f, 8.73023048e-02f, -1.24097802e-01f, -1.20660000e-01f, 1.79055512e-01f,
  -4.39578667e-02f, -1.63970172e-01f, -6.60087913e-02f, -3.81134041e-02f, -9.80989560e-02f, -2.67773811e-02f, -1.23040840e-01f, -1.47113856e-02f, 2.17536520e-02f, -3.94035988e-02f,
  5.72154634e-02f, 1.13825366e-01f, -2.20915839e-01f, 1.09208107e-01f, -6.11903034e-02f, -4.65799607e-02f, 1.47831626e-02f, 1.63564205e-01f, 9.95263234e-02f, -1.02021113e-01f,
  1.27528965e-01f, -4.06241082e-02f, -1.94568653e-02f, -1.77853167e-01f, -3.82670276e-02f, -7.13696256e-02f, -5.73440567e-02f, -7.11805047e-03f, -9.88350064e-02f, 8.64958614e-02f,
  -1.97685487e-03f, -7.48240110e-03f, -7.25676790e-02f, 1.73461102e-02f, -4.62450348e-02f, 5.93630113e-02f, 2.31403671e-02f, 1.04758916e-02f, -4.77563217e-02f, -1.04297644e-04f,
  2.22655572e-02f, -2.19501760e-02f, -2.42602290e-03f, -6.65408894e-02f, -1.18555818e-02f, -8.07558373e-02f, -2.00657155e-02f, 5.25164045e-03f, 1.01697752e-02f, -1.37548491e-01f,
  1.52655408e-01f, -1.59455180e-01f, -3.52011360e-02f, -4.27385867e-02f, -1.00149617e-01f, 1.11970775e-01f, -3.11823306e-03f, 1.27561212e-01f, -7.48593509e-02f, -4.59898589e-03f,
  1.26885742e-01f, -1.34220272e-01f, -8.43788832e-02f, -2.65479863e-01f, -4.69633415e-02f, 6.04338571e-02f, 3.87198552e-02f, 1.38228089e-01f, 2.14407034e-02f, 7.52534345e-02f,
  1.12377994e-01f, 1.45429179e-01f, 6.93896189e-02f, 2.82979794e-02f, 2.20562324e-01f, -5.48926406e-02f, 9.66785550e-02f, -4.04068194e-02f, -1.48092804e-03f, 2.32144967e-01f,
  8.68986025e-02f, -1.24179721e-01f, 9.93459858e-03f, 4.22396435e-04f, -9.97722596e-02f, -2.61200964e-02f, -1.80590209e-02f, -4.91952933e-02f, -1.93533897e-02f, -8.80014002e-02f,
  -2.65670381e-02f, -2.55695805e-02f, -5.96752204e-02f, -3.00385766e-02f, -6.15247749e-02f, 4.66749668e-02f, -7.47415945e-02f, -3.80190909e-02f, -8.78843945e-03f, -3.99950333e-02f,
  7.05060661e-02f, 1.51888514e-02f, -7.08689392e-02f, -9.22233090e-02f, -4.88752089e-02f, -1.54953431e-02f, -2.35975087e-02f, -4.45582066e-03f, 9.37230363e-02f, -7.11459965e-02f,
  -4.75922376e-02f, -8.34012628e-02f, -1.44847363e-01f, 5.77756912e-02f, -2.06737649e-02f, -1.07188812e-02f, 1.67936802e-01f, -1.07295904e-02f, 7.97906145e-02f, -7.55365863e-02f,
  -1.52783111e-01f, 1.57259911e-01f, 1.81693323e-02f, -1.87849149e-01f, 1.49840251e-01f, -1.12660088e-01f, -1.35382339e-01f, -1.41228408e-01f, -9.05490145e-02f, -6.19069859e-02f,
  1.06564589e-01f, 8.20862874e-02f, -2.01585423e-02f, 2.46880371e-02f, 1.50896788e-01f, 6.00282215e-02f, 1.16053171e-01f, -5.88034131e-02f, -3.93174849e-02f, 1.62020162e-01f,
  -6.92163184e-02f, -5.01134768e-02f, -6.20728843e-02f, 7.09862486e-02f, -1.48426797e-02f, -9.39022973e-02f, 8.17398876e-02f, -1.80485293e-01f, -2.65052002e-02f, -2.06048116e-01f,
  1.68827787e-01f, -1.57162383e-01f, -1.26144171e-01f, -1.08578809e-01f, -9.39512849e-02f, 4.56579868e-03f, -1.50582954e-01f, 7.83461556e-02f, 7.38204122e-02f, -2.24863477e-02f,
  3.26285623e-02f, 1.00296233e-02f, -4.26029973e-02f, -1.89169624e-03f, 9.83889252e-02f, 3.91095020e-02f, -1.51657328e-01f, 5.94866164e-02f, -7.85714313e-02f, -4.51351330e-02f,
  -4.57222946e-02f, -1.44255370e-01f, -4.93294410e-02f, -7.89208040e-02f, -1.08918063e-01f, -3.20682377e-02f, 2.61696242e-02f, 3.10335454e-04f, 9.62651372e-02f, -2.03781664e-01f,
  3.56261320e-02f, -4.86668088e-02f, -7.60299116e-02f, 3.39533724e-02f, 6.21324368e-02f, 1.93703681e-01f, -8.06145072e-02f, 7.73160905e-03f, 1.74492240e-01f, -2.15044975e-01f,
  2.14236062e-02f, -1.57043025e-01f, -1.39947638e-01f, 3.94247547e-02f, -3.33928466e-02f, 9.36579481e-02f, -3.23959067e-02f, 9.83888283e-02f, 1.27436489e-01f, 6.91676512e-02f,
  4.27963361e-02f, -5.56177460e-04f, 1.22762583e-01f, 8.53296369e-02f, 1.24235027e-01f, -3.04773748e-02f, -2.48326093e-01f, 1.74943715e-01f, -3.01730651e-02f, -1.24020524e-01f,
  -4.58633434e-03f, 1.90857321e-01f, 9.52742919e-02f, -8.68579298e-02f, 2.17014030e-02f, -7.26988241e-02f, 8.01051185e-02f, 2.79884487e-02f, 2.30362564e-02f, 2.02267393e-02f,
  5.12997098e-02f, 6.45578234e-03f, -2.73718853e-02f, -3.76296639e-02f, 6.89261258e-02f, 1.63702928e-02f, 1.84617881e-02f, 2.57546175e-02f, -2.94072907e-02f, 2.97142230e-02f,
  -4.36198637e-02f, 1.17190823e-01f, -1.81578670e-03f, 1.02165928e-02f, 1.05508082e-01f, 3.20488885e-02f, 8.31138492e-02f, -7.22086057e-04f, 1.17700294e-01f, 4.27004546e-02f,
  -7.13371262e-02f, -9.50428396e-02f, -5.53497225e-02f, 1.14876948e-01f, -8.90517607e-02f, 1.15001472e-02f, -6.04554676e-02f, -1.28035232e-01f, -1.64035231e-01f, -7.43374452e-02f,
  4.24925014e-02f, 9.55139622e-02f, -7.21549019e-02f, 1.04633674e-01f, 8.43052566e-02f, -1.09470904e-01f, 5.72608151e-02f, 1.55409187e-01f, 6.54817373e-02f, -1.48953777e-02f,
  1.12973697e-01f, -2.52986774e-02f, 1.43864065e-01f, 4.98261116e-02f, 7.69781545e-02f, -1.24329105e-02f, 8.25237110e-03f, -3.97218950e-02f, 2.28011638e-01f, 9.23713967e-02f,
  9.59608927e-02f, 1.06853351e-01f, -1.13839619e-01f, -7.30759948e-02f, -8.15386549e-02f, 2.95657385e-02f, -6.43668845e-02f, -1.03356339e-01f, 1.32907599e-01f, 2.21498206e-01f,
  1.96278356e-02f, 6.42732084e-02f, 3.46057974e-02f, -6.25920668e-02f, 6.74413294e-02f, 2.77170422e-03f, -8.60055387e-02f, -3.57385129e-02f, 5.60992360e-02f, -6.25167266e-02f,
  9.91247594e-02f, -1.87051538e-02f, -9.11381990e-02f, -3.59779485e-02f, 1.32785663e-01f, 2.78884210e-02f, -2.24948563e-02f, 1.32338051e-02f, -1.05649987e-02f, 4.82337065e-02f,
  1.99717972e-02f, 6.31664321e-02f, 1.38388664e-01f, -2.12079063e-02f, -3.65247019e-02f, 2.02400163e-02f, -9.08967182e-02f, 1.41074568e-01f, -2.36566048e-02f, 1.46924317e-01f,
  1.28912285e-01f, -1.41086921e-01f, -1.57931298e-01f, -1.52831525e-01f, 1.59119233e-01f, -4.09451686e-02f, -2.07278818e-01f, 1.59627557e-01f, -1.65540236e-03f, 2.12860689e-01f,
  1.33619905e-01f, -7.86530152e-02f, 2.28053611e-02f, -1.34233147e-01f, 2.08045468e-02f, 2.45011859e-02f, -7.14611113e-02f, -4.04234901e-02f, -9.04527381e-02f, -6.22477308e-02f,
  -2.55756497e-01f, -2.06570961e-02f, -8.34745988e-02f, 1.18278787e-01f, 1.02755189e-01f, -7.54807144e-02f, -9.34459865e-02f, 2.97759636e-03f, -1.96906067e-02f, -6.85271472e-02f,
  -1.24028943e-01f, -4.64001149e-02f, 1.00231223e-01f, 1.05491333e-01f, -1.93977654e-01f, 7.46445404e-03f, -7.47217163e-02f, 3.92972268e-02f, 9.30588692e-02f, 1.03669241e-01f,
  1.30322035e-02f, 1.07309379e-01f, 7.10709170e-02f, 9.98025984e-02f, 4.56937365e-02f, 1.19656026e-01f, 1.02966458e-01f, -1.80792511e-02f, 9.89566371e-02f, 1.71387438e-02f,
  -2.78187599e-02f, 7.08456561e-02f, 7.44261518e-02f, -2.24374998e-02f, 5.41488677e-02f, 2.26579010e-02f, -2.58827191e-02f, 6.07325546e-02f, -1.02093928e-01f, 7.11087435e-02f,
  3.57666425e-02f, -5.18471338e-02f, 5.90524226e-02f, 5.74606583e-02f, 8.44762549e-02f, -1.06631041e-01f, -1.55001491e-01f, -7.54784867e-02f, 7.65080526e-02f, -2.39765737e-02f,
  1.28645942e-01f, -4.34831642e-02f, -1.05482908e-02f, 4.79735062e-02f, 4.38036881e-02f, -4.53782193e-02f, 1.64039642e-01f, -1.95621736e-02f, -9.06135589e-02f, -3.22324522e-02f,
  -1.31983114e-02f, 1.25155589e-02f, 3.23152989e-02f, -1.36055604e-01f, -5.37752844e-02f, 1.60302430e-01f, -6.40256777e-02f, 2.80344546e-01f, -9.77074429e-02f, 2.01155096e-01f,
  -2.96330154e-02f, 7.10658208e-02f, 5.59981838e-02f, -2.05613337e-02f, 1.24811351e-01f, 3.81305888e-02f, -1.42893746e-01f, -1.83540881e-01f, 1.19364835e-01f, -1.58464815e-02f,
  6.43717125e-02f, -4.67785075e-02f, -8.13607126e-02f, 2.47043669e-02f, -2.94582266e-02f, 7.64461758e-04f, -5.58262281e-02f, -9.61504951e-02f, -2.33292021e-02f, -7.41171464e-02f,
  -7.01423734e-02f, -3.56255472e-02f, -1.30433962e-01f, 3.08001060e-02f, 6.61138743e-02f, -2.86170412e-02f, -7.60463029e-02f, 1.14669785e-01f, -8.49361792e-02f, 1.07539049e-03f,
  5.05800266e-03f, -3.35861556e-02f, 5.42855216e-03f, 2.54076384e-02f, -1.00742988e-01f, 2.67565884e-02f, 3.65056358e-02f, -1.12777911e-01f, -2.57671047e-02f, -9.73771885e-03f,
  7.79972002e-02f, 1.13319546e-01f, -8.53495747e-02f, 8.60950351e-02f, -4.52414826e-02f, 5.38787693e-02f, 9.88569856e-02f, 2.39254516e-02f, -9.76341143e-02f, 5.22665083e-02f,
  -1.30220279e-01f, 6.47372678e-02f, 9.48028862e-02f, -5.67994379e-02f, -2.04554498e-02f, -6.47400618e-02f, 1.18984906e-02f, 2.08397303e-02f, 1.58410534e-01f, -7.41721690e-02f,
  1.60124339e-02f, -2.30946124e-01f, -6.12077443e-03f, -1.46870673e-01f, -3.99614014e-02f, -6.46150932e-02f, -2.01155975e-01f, 2.09074512e-01f, 5.11612631e-02f, -1.27483159e-02f,
  6.92884400e-02f, 7.28525147e-02f, -8.69164914e-02f, -3.73757258e-02f, -1.17498450e-01f, -3.62257939e-04f, 1.32356673e-01f, 3.79866734e-02f, -4.22891825e-02f, 9.35647935e-02f,
  3.48981731e-02f, 9.28094983e-02f, 4.44199629e-02f, 8.19578618e-02f, 9.78303999e-02f, -7.01200590e-02f, 1.24815203e-01f, -1.90651976e-03f, 2.35333312e-02f, -3.13288979e-02f,
  -2.83093238e-03f, 1.93211380e-02f, 6.12772070e-02f, 5.78928180e-02f, 1.12631517e-02f, 5.70714064e-02f, -1.09363971e-02f, 5.62630780e-02f, 3.05564124e-02f, 6.59983531e-02f,
  -1.70858745e-02f, 1.33054435e-01f, 1.34229347e-01f, -1.61144301e-01f, -1.95241734e-01f, -8.28109905e-02f, 1.51085556e-01f, -7.21364766e-02f, 2.29105670e-02f, 7.17313290e-02f,
  1.76441334e-02f, 1.05560698e-01f, 1.14592211e-02f, -3.37966233e-02f, 1.30836248e-01f, -9.96873155e-02f, -2.76510138e-02f, -2.88206786e-02f, -1.50711481e-02f, 1.58731882e-02f,
  1.13625135e-02f, -1.37921959e-01f, -1.84425890e-01f, 1.02453105e-01f, -1.34355417e-02f, 2.71652281e-01f, -1.01441070e-01f, 1.50872469e-01f, -3.77270095e-02f, 8.26832801e-02f,
  1.05248578e-01f, -1.69237658e-01f, -2.23469865e-02f, -3.68699920e-03f, -7.69658312e-02f, -9.12223458e-02f, 1.13678969e-01f, -8.45006183e-02f, -4.23258021e-02f, -6.28896654e-02f,
  -7.30970427e-02f, -7.81798959e-02f, 5.64875314e-03f, -1.49424329e-01f, -8.17082897e-02f, -9.50792730e-02f, -9.42703933e-02f, -9.41730738e-02f, -1.12456203e-01f, -1.42084789e-02f,
  -6.23791665e-02f, -8.65829643e-03f, -6.19045757e-02f, -1.27068087e-01f, -1.06681220e-01f, 1.47143882e-02f, -1.22918896e-01f, 5.13522513e-02f, 2.34813243e-02f, 2.28167586e-02f,
  6.21300749e-02f, -1.90508403e-02f, 3.68292853e-02f, 1.20181753e-03f, -1.13924041e-01f, -3.97019126e-02f, -8.76043439e-02f, 1.79996520e-01f, 1.30459577e-01f, 8.14135745e-02f,
  -1.66097209e-01f, -7.35126734e-02f, -4.63557877e-02f, -5.40777110e-02f, -1.74518079e-02f, -1.35418251e-01f, -2.71475706e-02f, 4.08219360e-03f, -1.09749533e-01f, 4.66237925e-02f,
  9.39162150e-02f, 4.33915779e-02f, 1.03619307e-01f, 5.58490641e-02f, 3.40724811e-02f, 1.32443950e-01f, 1.14888595e-02f, -7.75861889e-02f, -1.66925211e-02f, -2.53900617e-01f,
  1.45886824e-01f, -2.18118969e-02f, 5.61068542e-02f, -1.74940512e-01f, -1.59316659e-01f, 1.82046965e-02f, -1.14659257e-01f, -6.42109215e-02f, 1.47086501e-01f, 7.79363886e-02f,
  1.63998513e-03f, 1.67513657e-02f, -1.20253745e-03f, 1.09870834e-02f, 7.49992430e-02f, 6.50995299e-02f, -9.76650137e-03f, 3.35251018e-02f, 2.09044735e-03f, -3.70667577e-02f,
  1.49042988e-02f, 7.54312202e-02f, 4.90403660e-02f, 2.08031218e-02f, 2.65312921e-02f, -1.35425152e-03f, -1.23187482e-01f, -7.93938700e-04f, 5.38708903e-02f, 2.29415242e-02f,
  4.08315398e-02f, 3.17433365e-02f, 8.28587785e-02f, -5.92530370e-02f, -2.14332864e-02f, -1.61333725e-01f, 9.54604223e-02f, 2.82300683e-03f, -4.51874621e-02f, 3.62018012e-02f,
  -9.11862403e-03f, 4.33265083e-02f, -1.13411859e-01f, -8.26510265e-02f, 5.79159558e-02f, -1.57556742e-01f, -4.41402830e-02f, -6.00412488e-02f, -1.44492626e-01f, -1.63412005e-01f,
  1.01363719e-01f, -6.79241344e-02f, 7.43130371e-02f, -1.20795639e-02f, 8.07053223e-02f, 3.22073363e-02f, 4.13835645e-02f, 1.48292080e-01f, 2.12340499e-03f, 8.61955993e-03f,
  -5.87792993e-02f, -3.64920087e-02f, -9.29102525e-02f, 9.36686322e-02f, 1.74315616e-01f, 7.38357976e-02f, 9.40909460e-02f, -6.08678199e-02f, 1.51951969e-01f, -2.13957444e-01f,
  -2.05999970e-01f, -1.07114553e-01f, 2.09455952e-01f, 1.01623513e-01f, 5.50005361e-02f, 3.47800665e-02f, 9.67042595e-02f, 4.42600586e-02f, -1.06758073e-01f, 1.14908114e-01f,
  9.19208229e-02f, 2.48309802e-02f, -1.54563738e-02f, -1.38448291e-02f, -1.06938228e-01f, -7.54702911e-02f, 2.21843608e-02f, 6.09683283e-02f, -1.09361753e-01f, -9.92641896e-02f,
  -9.95401368e-02f, 1.01638451e-01f, -8.01502019e-02f, 2.82982197e-02f, 5.62894717e-03f, -1.45346165e-01f, -5.48705794e-02f, -1.33623794e-01f, -3.03335134e-02f, 1.55639676e-02f,
  -1.74472958e-03f, -7.74711892e-02f, 1.54164314e-01f, -4.82388884e-02f, 2.54395360e-04f, 4.03362066e-02f, 9.90832746e-02f, 1.68970764e-01f, -3.10670473e-02f, -9.21670720e-02f,
  5.27519956e-02f, -1.23971745e-01f, -9.85406265e-02f, -1.07529208e-01f, -1.24347106e-01f, -4.75474894e-02f, -6.49458244e-02f, 9.86401960e-02f, 2.14324296e-02f, 3.72558646e-02f,
  -5.33359013e-02f, 2.62879916e-02f, -8.31602812e-02f, 5.00222147e-02f, 1.83997631e-01f, -6.34300709e-02f, -7.39294440e-02f, -1.76094815e-01f, -1.24848727e-02f, -2.23467559e-01f,
  4.78731208e-02f, -4.60707322e-02f, 1.23612605e-01f, 1.01912901e-01f, 9.99345444e-03f, 1.97701789e-02f, 1.49616674e-01f, 7.49878734e-02f, 3.24925818e-02f, -3.72820459e-02f,
  2.22697239e-02f, 7.40459189e-02f, 4.42067385e-02f, -1.49678886e-02f, 6.40109852e-02f, -3.12885977e-02f, -1.63445864e-02f, 7.68632516e-02f, 5.31677976e-02f, 3.40463431e-03f,
  1.52474986e-02f, 2.19960045e-02f, -5.69368303e-02f, 4.19119634e-02f, -5.12717851e-03f, -1.20448703e-02f, 7.00560631e-03f, -4.30958346e-02f, -3.01217418e-02f, -9.72442925e-02f,
  -3.00346483e-02f, -1.93128865e-02f, 7.44393021e-02f, -5.45340180e-02f, 9.48313326e-02f, -1.72501504e-02f, -1.66910678e-01f, -6.41260520e-02f, -1.96980044e-01f, 1.21776521e-01f,
  7.48223364e-02f, 2.95152552e-02f, -1.37501448e-01f, 1.25951558e-01f, 5.71701713e-02f, -5.36502805e-04f, 1.17825232e-01f, -1.90721720e-01f, 5.29628769e-02f, 1.61097944e-01f,
  -1.97491776e-02f, 9.64904279e-02f, 9.04744342e-02f, 2.62608379e-02f, 1.20247476e-01f, 3.53108421e-02f, 4.55774665e-02f, -1.44987199e-02f, 1.49077520e-01f, -1.03530705e-01f,
  2.00800762e-01f, -1.11272611e-01f, 3.80140506e-02f, 7.68504664e-02f, 3.13192084e-02f, -6.20686747e-02f, -1.40746340e-01f, 1.82996243e-01f, -3.73960696e-02f, 1.37454823e-01f,
  -2.12764755e-01f, -4.44957288e-03f, 1.62487254e-01f, 6.35224134e-02f, 2.39283703e-02f, -2.60143150e-02f, -1.62023515e-03f, -1.32839745e-02f, -3.34668532e-02f, -8.05292055e-02f,
  5.00410609e-02f, 3.52626741e-02f, 4.13322337e-02f, 5.45883849e-02f, -6.35501370e-03f, 6.76211854e-03f, -6.71897549e-04f, 5.43514863e-02f, 3.67831215e-02f, -6.53769076e-02f,
  1.42022148e-02f, 1.73901906e-03f, 3.38596031e-02f, -3.75413150e-02f, 5.01173511e-02f, 9.80860181e-03f, -3.17593925e-02f, -1.01045378e-01f, 8.06545839e-03f, 9.84327793e-02f,
  -1.58278525e-01f, -4.64718901e-02f, -1.19479582e-01f, -6.13964088e-02f, -1.02280686e-02f, -6.25136197e-02f, -7.13538304e-02f, 1.73846245e-01f, -7.93840513e-02f, 1.34776935e-01f,
  1.58853918e-01f, -9.50817913e-02f, 7.79976025e-02f, 1.45842463e-01f, -2.14932021e-02f, -1.87073797e-02f, 1.26367569e-01f, -6.95978524e-03f, 7.73693398e-02f, 1.26809338e-02f,
  -2.10482464e-03f, -4.50472273e-02f, 3.13657708e-02f, -1.48627385e-01f, 1.14711374e-01f, -3.23950127e-02f, 1.90469012e-01f, -8.22021663e-02f, -1.23528056e-02f, -1.08990192e-01f,
  -1.53647646e-01f, -1.81563981e-02f, -1.29933849e-01f, 1.56332210e-01f, -1.80393651e-01f, 5.75828515e-02f, -1.78965852e-02f, -7.63824061e-02f, 4.21681628e-03f, -4.86141257e-02f,
  -7.65935928e-02f, 3.43802050e-02f, 7.64525309e-03f, 9.56107825e-02f, -1.08122885e-01f, 7.34354882e-03f, 7.56827667e-02f, 3.35831009e-02f, 5.09005114e-02f, 6.82896152e-02f,
  -3.49517353e-02f, -5.36476523e-02f, -8.80810712e-03f, 1.93796344e-02f, -2.64898520e-02f, 1.81667448e-03f, 5.29067330e-02f, -3.17507163e-02f, 4.76548113e-02f, -6.33746758e-02f,
  -1.60168428e-02f, -7.85809234e-02f, 1.29785150e-01f, -1.43066138e-01f, 3.55722643e-02f, 1.21629313e-02f, -4.52097915e-02f, 8.92541483e-02f, 1.35256033e-02f, 1.13292783e-01f,
  1.83443073e-02f, -7.69979209e-02f, 1.06527828e-01f, -1.49905950e-01f, -7.28344768e-02f, -1.15035214e-01f, 1.74367707e-02f, -7.94465616e-02f, 3.68304998e-02f, 1.17368400e-01f,
  -6.43149316e-02f, -2.06855033e-03f, 5.36410771e-02f, 8.26027542e-02f, 3.32752839e-02f, 7.41526634e-02f, 1.23159662e-01f, 1.41417801e-01f, 3.08666956e-02f, 3.01014706e-02f,
  -3.03955059e-02f, 1.58314183e-01f, 6.76277280e-02f, -7.11994991e-02f, 1.86302260e-01f, -8.92220512e-02f, -1.28064319e-01f, 3.51430103e-02f, -1.37405396e-01f, -1.89258665e-01f,
  1.28464922e-02f, -6.37922436e-03f, 1.23072769e-02f, 3.85429128e-04f, -1.15076765e-01f, -5.09645604e-02f, 6.76263720e-02f, -8.84018913e-02f, 1.90253742e-02f, -1.54322252e-01f,
  -4.24941070e-02f, -3.95795405e-02f, 2.60155126e-02f, -7.60385171e-02f, 6.65619820e-02f, -2.12411359e-02f, -6.33255839e-02f, -3.78429554e-02f, -8.83335471e-02f, 1.18542485e-01f,
  -1.42051250e-01f, 1.07537694e-01f, -4.03280444e-02f, -4.45101261e-02f, 5.45704626e-02f, 4.21881722e-03f, -7.44155841e-03f, -6.07768558e-02f, -8.90463963e-02f, 1.07544027e-01f,
  -2.50917468e-02f, 1.95723191e-01f, 1.17005669e-01f, -8.81123096e-02f, -1.10154347e-02f, -9.18311030e-02f, -1.45985216e-01f, -3.17282020e-03f, -1.18681118e-01f, 1.41117960e-01f,
  9.94960144e-02f, -1.66933477e-01f, -2.09400088e-01f, -4.23689224e-02f, -7.76738152e-02f, 5.46633685e-03f, -1.49358600e-01f, -9.21535119e-03f, -1.27331048e-01f, 1.53961048e-01f,
  -1.07473144e-02f, -1.43238157e-01f, -1.60526395e-01f, -9.73042026e-02f, 9.65679586e-02f, -7.18404427e-02f, 1.13332912e-01f, -1.94566920e-02f, 1.85764670e-01f, -5.47672696e-02f,
  -2.09948774e-02f, 6.87314942e-02f, 2.23204419e-01f, 1.21657223e-01f, -1.52066862e-02f, 3.19208950e-02f, -3.40058096e-02f, -8.24217945e-02f, 5.21283373e-02f, 3.14826742e-02f,
  -1.04757017e-02f, -4.02445570e-02f, 1.24110669e-01f, -6.19170815e-02f, -8.20372254e-02f, -4.51089814e-02f, 9.66043212e-04f, -4.82544713e-02f, 3.26003321e-02f, 7.82342860e-04f,
  6.10115305e-02f, -4.30084765e-04f, -1.09146927e-02f, 6.64322078e-02f, -1.65101409e-01f, 1.78879593e-02f, -3.78686376e-02f, 1.80193763e-02f, 5.94417565e-02f, 4.69354764e-02f,
  -1.18195683e-01f, -3.07574924e-02f, -7.43187442e-02f, 1.84001420e-02f, 6.23309538e-02f, 5.47317043e-03f, 3.38628702e-02f, 1.97704379e-02f, 4.99802828e-02f, 8.69112741e-03f,
  -7.04572946e-02f, 4.39474285e-02f, -6.73197955e-02f, 2.47945189e-01f, 1.00164013e-02f, -9.22366455e-02f, -9.07353610e-02f, -9.77128521e-02f, -1.06313825e-01f, 7.77930692e-02f,
  -1.47216424e-01f, -1.40337229e-01f, -8.43427032e-02f, -6.02810120e-04f, -1.55662224e-01f, 5.63494079e-02f, -9.39089209e-02f, -2.61029210e-02f, -1.42075062e-01f, 1.34660199e-01f,
  -7.85286352e-02f, 1.52055308e-01f, 1.23318166e-01f, 1.29312918e-01f, 1.84577301e-01f, 3.65794264e-02f, 5.00873625e-02f, 7.20038339e-02f, 7.03659877e-02f, -4.27108109e-02f,
  2.82959063e-02f, 3.84831168e-02f, -8.95291269e-02f, -1.66575499e-02f, 4.46721818e-03f, -4.82528657e-02f, -1.06352895e-01f, -4.30422500e-02f, -9.10995603e-02f, -6.23112880e-02f,
  -1.07275238e-02f, 4.43429351e-02f, -7.06213340e-02f, -5.62871695e-02f, -1.40974382e-02f, 6.02635741e-03f, -8.36709514e-02f, 1.08230114e-03f, -8.15629289e-02f, -8.74751136e-02f,
  -8.97755399e-02f, -8.36714804e-02f, 7.65046850e-02f, -2.26356974e-03f, 6.19988963e-02f, -2.82705203e-02f, 6.96522966e-02f, -1.43864989e-01f, -3.88628505e-02f, 1.32460192e-01f,
  1.52913243e-01f, 1.72630981e-01f, -1.14913002e-01f, 2.35144198e-02f, 6.33557662e-02f, -1.28502518e-01f, 4.17380854e-02f, -2.16134667e-01f, -1.16862752e-01f, 3.67735215e-02f,
  -7.35210255e-02f, 1.30195588e-01f, 1.52121074e-02f, -3.28000411e-02f, 6.25983551e-02f, -1.52809452e-02f, 7.08710477e-02f, 8.88949260e-02f, 2.03286201e-01f, -1.25190407e-01f,
  2.84257773e-02f, -2.12860942e-01f, 4.63339314e-02f, -7.99011663e-02f, 1.23899437e-01f, -1.01759404e-01f, -1.12655953e-01f, 1.17572717e-01f, 2.05414910e-02f, 7.57153556e-02f,
  -1.07359719e-02f, -5.72111681e-02f, 3.17927040e-02f, -5.24535403e-02f, -4.05132435e-02f, 1.13060549e-02f, -6.20188192e-02f, -1.23630008e-02f, 1.29179480e-02f, 2.29103584e-02f,
  -9.73830074e-02f, -8.81832093e-02f, -6.02710247e-02f, -4.44052704e-02f, -1.98562983e-02f, 8.63766894e-02f, -9.96864289e-02f, 2.86051509e-04f, -1.06743351e-01f, -2.22315397e-02f,
  -2.30602361e-02f, -1.03940442e-01f, 5.36660329e-02f, -5.15212119e-02f, 1.43902795e-02f, 1.80831049e-02f, 6.07758015e-02f, -1.11260362e-01f, 1.03136413e-01f, -5.04868291e-02f,
  -5.54482788e-02f, -3.34774591e-02f, -7.53155798e-02f, 1.07071966e-01f, -2.52692178e-02f, 2.82155816e-02f, -1.46630064e-01f, -1.22362353e-01f, 1.22864656e-01f, -1.30428538e-01f,
  1.15166197e-03f, -2.64727324e-01f, -6.53357431e-02f, 1.00215383e-01f, 1.68392472e-02f, 8.29551369e-02f, 1.29960343e-01f, 1.47554689e-04f, 2.07257032e-01f, 1.42971292e-01f,
  9.96987149e-02f, 1.33322418e-01f, 9.06593129e-02f, -7.92815536e-03f, -1.47287175e-03f, -7.29692057e-02f, 1.12687416e-01f, 6.30771965e-02f, 5.02474122e-02f, -1.01478793e-01f,
  -8.33178237e-02f, 2.88300589e-02f, -9.79272574e-02f, -1.37751758e-01f, 1.39168471e-01f, 2.50210948e-02f, 2.52152551e-02f, 2.92771719e-02f, 2.71489210e-02f, 3.46768014e-02f,
  -8.53281021e-02f, 4.50920761e-02f, -1.98301338e-02f, -4.38886583e-02f, 6.22741543e-02f, 1.82952732e-02f, -8.15485269e-02f, -3.97801846e-02f, -4.09099460e-02f, -8.87561738e-02f,
  -1.61397494e-02f, 4.63294573e-02f, 1.63223618e-03f, 8.12152326e-02f, 3.06539051e-03f, -1.08043021e-02f, -8.75328407e-02f, 2.96729710e-02f, -9.94234830e-02f, -3.99475656e-02f,
  -7.01578408e-02f, 1.29051626e-01f, -1.50986195e-01f, 4.47568782e-02f, 1.62797183e-01f, -4.20867614e-02f, 7.77072757e-02f, -9.37801674e-02f, -1.37986671e-02f, -1.77233685e-02f,
  -7.86431320e-03f, 4.72061709e-02f, 3.71242315e-02f, 4.50327396e-02f, 4.39962745e-02f, 1.13666691e-01f, -9.90741476e-02f, -4.93275980e-03f, -8.44897851e-02f, -1.46870390e-02f,
  1.27525758e-02f, -7.65635446e-02f, -5.30977361e-02f, -1.16060421e-01f, 4.84530292e-02f, -8.50144122e-03f, 2.21120268e-02f, -8.19962099e-02f, -5.72368642e-03f, -1.95091963e-01f,
  1.00698145e-02f, -1.58412158e-01f, -5.43560535e-02f, 8.35175738e-02f, -1.87777981e-01f, 1.59813508e-01f, 1.76436499e-01f, -3.78460810e-02f, 1.80398479e-01f, 1.50476964e-02f
};

// L2_fan_Wp_bar (Shape: 14 x 64)
const int L2_fan_Wp_bar_rows = 14;
const int L2_fan_Wp_bar_cols = 64;
const float L2_fan_Wp_bar_data[] = {
  -3.12704705e-02f, 5.63518554e-02f, 7.37284496e-02f, -6.15069717e-02f, 4.70743589e-02f, 3.11069470e-03f, -1.96159794e-03f, 1.08572058e-01f, -4.20760363e-02f, 2.81763710e-02f,
  1.36881232e-01f, 9.10101980e-02f, 4.17873636e-02f, 5.69951385e-02f, 1.87523752e-01f, -1.55341744e-01f, 8.65047351e-02f, 1.51571184e-01f, -1.72480233e-02f, 8.09150040e-02f,
  1.16942011e-01f, 1.91107571e-01f, 3.02182268e-02f, 1.56280547e-02f, 5.51408567e-02f, 1.04203530e-01f, 3.47007476e-02f, -1.00833215e-02f, 1.38483882e-01f, 8.41340423e-02f,
  1.60121426e-01f, 1.36008775e-02f, 3.72699164e-02f, -9.96154770e-02f, 1.07296512e-01f, -3.81365381e-02f, -2.59858351e-02f, 4.75399829e-02f, -2.66360082e-02f, 3.14802825e-01f,
  1.54027063e-02f, -2.23085985e-01f, -2.20853202e-02f, -8.11681449e-02f, -7.44671300e-02f, -1.07361577e-01f, -2.10659891e-01f, -5.56403175e-02f, -5.10050468e-02f, -4.94099148e-02f,
  -9.98174772e-02f, 2.02751815e-01f, -1.98471844e-01f, 2.67140001e-01f, 8.88790786e-02f, -1.45684272e-01f, 1.25332817e-01f, 2.91487008e-01f, 2.13035077e-01f, -1.25822589e-01f,
  6.91562742e-02f, 1.54322401e-01f, -2.34282032e-01f, -1.95234612e-01f, -1.09500185e-01f, -1.14169344e-01f, -4.46081832e-02f, 1.03076972e-01f, -1.23403139e-01f, 1.30513180e-02f,
  6.93901554e-02f, 3.61586250e-02f, -9.26251039e-02f, -5.74826933e-02f, 2.73924526e-02f, 1.84271317e-02f, 1.05465770e-01f, 8.49161223e-02f, 3.06412615e-02f, -9.09185857e-02f,
  4.87834327e-02f, 1.74487347e-03f, -6.59372658e-02f, -6.20743260e-02f, -6.46616444e-02f, 4.25196663e-02f, -7.57592544e-02f, 9.52174664e-02f, 2.60995924e-01f, -1.03202105e-01f,
  2.62330472e-01f, -3.28002900e-01f, -7.11849257e-02f, 6.11202186e-03f, -9.65577289e-02f, 4.14387167e-01f, 3.17764640e-01f, 1.23784602e-01f, -1.99135557e-01f, -1.21173538e-01f,
  1.59632996e-01f, -1.94904655e-01f, -1.42570898e-01f, -2.47700606e-02f, 6.16683625e-03f, -1.91252351e-01f, -1.31025597e-01f, 1.33492202e-01f, -2.07365364e-01f, 1.11059193e-03f,
  -5.47831245e-02f, 8.33867043e-02f, -4.39458862e-02f, 2.19220281e-01f, 2.47932583e-01f, 2.21644878e-01f, -8.10880363e-02f, 1.67172387e-01f, 4.78115641e-02f, 1.69287637e-01f,
  4.47427362e-01f, 1.86530605e-01f, 3.28116447e-01f, 7.24906325e-02f, 1.18711613e-01f, 3.55276227e-01f, -1.59455270e-01f, -1.98130876e-01f, 1.97593719e-01f, 1.78218260e-01f,
  1.89895064e-01f, 4.09848765e-02f, 1.23807363e-01f, 1.24916993e-01f, -3.64607573e-02f, 2.48205066e-01f, -2.43312865e-02f, 1.85062498e-01f, 8.10528770e-02f, 5.94183505e-02f,
  4.95491922e-02f, 7.37620816e-02f, -1.78574715e-02f, -8.89010169e-03f, 6.62947595e-02f, 3.02716702e-01f, 1.14101157e-01f, 1.35920495e-01f, 3.80163580e-01f, 8.01575407e-02f,
  2.05083847e-01f, -1.43845275e-01f, -3.42446387e-01f, 4.76457179e-02f, -2.45970219e-01f, 2.92111844e-01f, 4.08326238e-01f, -4.88457121e-02f, 4.05554771e-01f, -4.66200233e-01f,
  -4.99801904e-01f, -9.02754515e-02f, 2.65863389e-01f, -8.75401124e-03f, 5.61571494e-02f, 1.67662531e-01f, 8.78409967e-02f, -1.16494773e-02f, -2.02003837e-01f, -2.21092273e-02f,
  1.70501500e-01f, -2.60485690e-02f, 2.21347123e-01f, -1.99909642e-01f, 1.22740746e-01f, 1.00050934e-01f, 1.60526514e-01f, -2.54327983e-01f, 1.80444688e-01f, 2.72103041e-01f,
  1.18075624e-01f, 1.52426943e-01f, 5.33846557e-01f, -3.23533148e-01f, 3.98818478e-02f, 1.94278196e-01f, -9.74093750e-02f, -1.58037409e-01f, 1.10293590e-01f, -2.75873810e-01f,
  5.23837924e-01f, 1.48867607e-01f, -9.03453007e-02f, 2.42532883e-02f, 6.41574860e-02f, 5.12330420e-02f, -7.40957111e-02f, 1.25472963e-01f, 1.67262763e-01f, 1.39629677e-01f,
  1.35259315e-01f, 1.71849608e-01f, -8.97140279e-02f, -4.90880199e-02f, 1.79951519e-01f, 1.60631575e-02f, -2.78277218e-01f, 2.42198370e-02f, -2.05773674e-02f, 8.63878652e-02f,
  1.30923584e-01f, -1.81279227e-01f, 7.90971965e-02f, -3.35049659e-01f, -1.49669096e-01f, 6.75516352e-02f, 2.53333393e-02f, 2.66384035e-01f, -1.82614654e-01f, -1.43612519e-01f,
  2.99533367e-01f, -2.14434087e-01f, 1.75658893e-03f, -7.05430284e-02f, 1.22764828e-02f, 3.85294795e-01f, 9.64016002e-03f, -1.86297130e-02f, 3.32782835e-01f, -2.19860971e-01f,
  6.58106357e-02f, 2.41830572e-02f, -3.58066857e-01f, 1.33609861e-01f, 1.20498188e-01f, 1.03594847e-01f, -2.09343091e-01f, 3.86592858e-02f, -2.93861632e-03f, -1.78422526e-01f,
  3.40927169e-02f, -1.96661174e-01f, 2.63594300e-01f, 2.79015750e-01f, 2.34787181e-01f, 2.66339462e-02f, -4.59142447e-01f, 1.37305871e-01f, 1.27862215e-01f, 3.02175939e-01f,
  6.76554367e-02f, 3.48481536e-01f, 4.89089549e-01f, 5.29099070e-02f, -1.80037752e-01f, -2.98175544e-01f, 5.92383668e-02f, 1.22511707e-01f, 7.53569156e-02f, 7.17137977e-02f,
  9.65497047e-02f, 2.36775428e-02f, 3.06289624e-02f, 1.24362849e-01f, -4.12640125e-02f, 8.11703652e-02f, 9.65254083e-02f, 7.09317029e-02f, -2.12896019e-02f, 1.88818872e-02f,
  -1.82214670e-03f, -6.30075932e-02f, 5.64002916e-02f, 2.17308566e-01f, -3.03364620e-02f, 1.49076477e-01f, 5.71988709e-02f, 4.64257151e-02f, -8.67964700e-02f, 7.01615512e-02f,
  4.11689328e-03f, 2.38806754e-01f, -1.78350195e-01f, 1.03081256e-01f, 2.91845322e-01f, -6.22759908e-02f, 2.50853062e-01f, -3.13655250e-02f, 1.23768933e-01f, -8.14465433e-02f,
  1.34636844e-02f, 5.79150654e-02f, -9.01281461e-02f, 1.50529534e-01f, 1.13783903e-01f, 4.44979340e-01f, -1.20675161e-01f, -2.20218584e-01f, -1.08099796e-01f, -8.39365423e-02f,
  -1.11784615e-01f, -2.09885672e-01f, -3.06707650e-01f, -2.34450936e-01f, -5.00519238e-02f, -1.09116659e-01f, -1.26611507e-02f, 1.80429399e-01f, -9.57279131e-02f, 1.12571493e-01f,
  1.14515707e-01f, -3.63190442e-01f, 1.99876517e-01f, 5.03256500e-01f, 6.54409751e-02f, 1.72752514e-01f, 4.29901809e-01f, 2.33365327e-01f, -9.30923969e-02f, -1.43225521e-01f,
  9.54616293e-02f, 3.37787122e-02f, 9.32947621e-02f, 2.83587519e-02f, -6.98970910e-03f, 8.60620756e-03f, -6.70793355e-02f, 1.32474065e-01f, -1.47902042e-01f, 2.91313808e-02f,
  1.05672181e-01f, 5.79267219e-02f, 4.54224795e-02f, 1.69269919e-01f, -1.05815999e-01f, -2.39221491e-02f, 4.89733107e-02f, 8.88064578e-02f, -7.41418675e-02f, 1.05446681e-01f,
  1.60489887e-01f, -3.50492671e-02f, 1.49060681e-01f, -8.71184245e-02f, 1.50069804e-03f, -1.74975663e-01f, 1.71170652e-01f, -2.32950598e-02f, 7.56453872e-02f, -1.42482638e-01f,
  5.24304528e-03f, -1.57787073e-02f, -2.53864545e-02f, 4.40445840e-02f, -9.03352797e-02f, 7.86843449e-02f, 1.31803483e-01f, -9.46427360e-02f, 3.40646543e-02f, -3.30751419e-01f,
  -1.13337405e-01f, 8.15806985e-02f, 2.43561864e-02f, 2.05104128e-01f, 1.67625338e-01f, -1.15719363e-01f, 3.27591747e-01f, 2.58010447e-01f, 2.23647922e-01f, -7.01935787e-04f,
  3.31276506e-01f, 1.29660979e-01f, 2.47384250e-01f, -1.64435487e-02f, 4.84965801e-01f, -6.95242286e-02f, 2.94436216e-01f, -2.32116714e-01f, 1.82069205e-02f, -2.91773975e-02f,
  -1.19314954e-01f, -4.79799286e-02f, 4.24067080e-02f, -3.11127733e-02f, -1.74896214e-02f, -4.05706391e-02f, 1.42777450e-02f, 5.26338443e-02f, -5.63127808e-02f, 4.40715924e-02f,
  3.41393799e-02f, 7.14730546e-02f, 1.36520579e-01f, 7.01902807e-02f, -3.74170654e-02f, -1.05765788e-02f, 9.01942253e-02f, -8.90505388e-02f, -1.13958783e-01f, 1.35368735e-01f,
  1.56963438e-01f, 5.50363362e-02f, 1.51555613e-01f, -2.19095405e-02f, 8.62260722e-03f, -5.87591641e-02f, 7.28780553e-02f, 1.06430165e-01f, -5.79016991e-02f, 1.74936697e-01f,
  -1.42920166e-01f, -4.37746495e-02f, 1.46280944e-01f, -2.33155355e-01f, -5.45666032e-02f, -1.79727688e-01f, -9.13010985e-02f, 2.07297251e-01f, 2.75018271e-02f, 2.13223457e-01f,
  1.27255514e-01f, -1.23986490e-02f, 1.92151651e-01f, -7.39700673e-03f, -2.36595631e-01f, 2.33548343e-01f, 2.35607866e-02f, 8.94725770e-02f, -1.58869922e-02f, -2.79003214e-02f,
  1.70751035e-01f, -1.47071227e-01f, 1.97910964e-01f, -1.72620147e-01f, 2.10148141e-01f, 1.60213515e-01f, 4.68607724e-01f, -7.77353644e-02f, -1.91227213e-01f, 1.71329498e-01f,
  -2.85592652e-03f, 1.49703875e-01f, -1.32252991e-01f, 4.26270813e-01f, 3.71542692e-01f, 1.38644367e-01f, -9.91954729e-02f, -1.07228488e-01f, -3.48186605e-02f, -1.19143762e-02f,
  -4.80729230e-02f, 7.16170967e-02f, 1.31835639e-02f, 4.95709926e-02f, -1.94555465e-02f, 4.77568433e-02f, -5.12737036e-02f, 7.77976075e-03f, 1.81277424e-01f, 1.95412010e-01f,
  3.27321291e-02f, 1.34451345e-01f, 2.26651534e-01f, 6.15727082e-02f, 8.22498277e-02f, -3.18715572e-02f, 5.45582287e-02f, 7.35795945e-02f, 4.09512036e-02f, 1.81108803e-01f,
  1.33490413e-01f, 1.00495085e-01f, 1.65279701e-01f, -2.28322342e-01f, 3.44247967e-01f, -6.98775724e-02f, -2.81817019e-01f, 1.80221871e-01f, -1.67115226e-01f, 2.21493140e-01f,
  9.00895149e-02f, -1.63264573e-01f, 5.84456604e-03f, 6.81871846e-02f, -6.72894418e-02f, 7.81806782e-02f, 3.44419875e-03f, -1.19293459e-01f, 2.34888107e-01f, -5.84617406e-02f,
  9.98380012e-04f, 1.27090886e-02f, 2.83959024e-02f, -3.03605665e-02f, 6.67854697e-02f, 2.33412325e-01f, 1.98150389e-02f, 2.55857296e-02f, -1.88842006e-02f, 1.79925766e-02f,
  5.09131253e-02f, 3.42458665e-01f, 2.60415703e-01f, 2.49276027e-01f, 1.66500896e-01f, -7.46973157e-02f, 2.20846698e-01f, -1.12964377e-01f, -2.86401570e-01f, 3.20346713e-01f,
  -2.50695199e-01f, -1.54237850e-02f, -1.29311252e-02f, 5.29035032e-02f, 5.26466817e-02f, 1.19928457e-01f, 1.58340842e-01f, 1.23092391e-01f, 2.50920933e-03f, 1.13122441e-01f,
  5.42591289e-02f, 1.87800378e-02f, -4.10072058e-02f, 1.28367752e-01f, 1.30948350e-01f, 1.27669156e-01f, 4.36080657e-02f, 1.18958382e-02f, -1.24520160e-01f, -5.23606827e-03f,
  1.34092599e-01f, -8.30472633e-02f, 1.37289867e-01f, -5.18114306e-04f, 5.59783652e-02f, 1.07547924e-01f, 1.39349982e-01f, -2.41161317e-01f, 1.79211169e-01f, -5.51741384e-03f,
  -8.38991255e-02f, 2.27356553e-01f, 3.05181034e-02f, 9.78859365e-02f, -1.71906352e-01f, -1.81673020e-01f, 1.10140160e-01f, -2.39743114e-01f, 4.10160162e-02f, 2.15269551e-02f,
  -2.41349563e-01f, -1.56270623e-01f, 1.44543216e-01f, -1.87364459e-01f, 1.42373323e-01f, -5.95189147e-02f, -3.06325704e-02f, 1.10883892e-01f, 1.17809214e-02f, 1.81413904e-01f,
  -1.00155540e-01f, 1.07102133e-01f, -4.23226394e-02f, 5.69654368e-02f, -1.49568990e-01f, 4.02671129e-01f, 2.92455971e-01f, 1.25926435e-01f, 3.38890553e-01f, 7.45961517e-02f,
  3.97209406e-01f, -3.18924189e-01f, -1.18362069e-01f, -3.11392173e-02f, 3.77270132e-01f, 3.03407013e-01f, 9.31326002e-02f, 9.51432586e-02f, 1.98244542e-01f, 2.72208434e-02f,
  7.27007538e-02f, 1.01983801e-01f, 2.14452654e-01f, 8.67773294e-02f, 1.05209023e-01f, 2.37844083e-02f, 6.57289028e-02f, -9.85262394e-02f, 2.68898066e-02f, 2.07421780e-01f,
  -1.42926618e-01f, 4.78036478e-02f, -1.24660879e-01f, 2.46630888e-02f, 6.70150146e-02f, 4.86799218e-02f, 1.52237952e-01f, -1.85258374e-01f, 1.47300884e-01f, -1.11213075e-02f,
  9.04918462e-02f, -1.96458876e-01f, -4.63249646e-02f, -3.76391262e-02f, -1.17101237e-01f, 1.28316492e-01f, -6.81076124e-02f, 1.20728314e-01f, -6.24241680e-02f, 1.10596649e-01f,
  1.98133558e-01f, -2.70255446e-01f, -7.71652907e-02f, -2.66227149e-03f, -1.68765306e-01f, 7.98506960e-02f, 8.26903135e-02f, -1.10332891e-01f, 1.07400149e-01f, -4.05003056e-02f,
  -1.12545833e-01f, 1.82189539e-01f, -1.34796873e-01f, -7.99428374e-02f, -3.41560096e-01f, 7.48019591e-02f, 5.31188250e-02f, 2.01270413e-02f, -2.05158275e-02f, 1.24308415e-01f,
  -5.20330034e-02f, 1.64768308e-01f, 8.21197852e-02f, 1.55011415e-01f, 4.14476097e-01f, 5.98719865e-02f, 3.18769403e-02f, -4.67338599e-02f, 4.11785066e-01f, 3.73834193e-01f,
  8.48183706e-02f, 5.58707044e-02f, 1.67757422e-01f, 1.04775708e-02f, 1.18637770e-01f, 4.34866250e-02f, 2.06675887e-01f, -3.73988003e-02f, 1.35083869e-01f, 1.27055302e-01f,
  9.77277160e-02f, 1.79850850e-02f, -1.10952653e-01f, 1.03087008e-01f, -8.67370632e-04f, 2.21915409e-01f, 9.88913327e-02f, 1.06575806e-02f, 8.60846266e-02f, 1.62104368e-01f,
  1.19965725e-01f, -2.03493219e-02f, 1.05198942e-01f, 4.77924794e-02f, 1.66901946e-01f, -2.50132322e-01f, -1.87955331e-02f, 1.46168843e-01f, -4.03665304e-01f, 1.54015154e-01f,
  -2.34437883e-01f, 1.00537926e-01f, 4.30838875e-02f, -1.47254780e-01f, 5.53791970e-02f, -5.15042841e-02f, -2.79348254e-01f, 2.53354162e-01f, 5.17847352e-02f, 8.14193785e-02f,
  3.32518369e-01f, 5.47138974e-02f, 3.70178558e-02f, -1.32511079e-01f, -8.47101659e-02f, 4.71422002e-02f, -1.49577677e-01f, -9.32027549e-02f, -3.02836090e-01f, 3.48115340e-02f,
  -1.77332714e-01f, -7.95551240e-02f, 1.31927103e-01f, 1.18600190e-01f, 1.69814989e-01f, 1.87535584e-01f, -9.85976192e-04f, -4.69485708e-02f, 2.49343365e-01f, 1.25231564e-01f,
  -1.06906652e-01f, 2.37117276e-01f, 1.59099728e-01f, 5.07073462e-01f, -7.19170086e-04f, -2.79117804e-02f, -3.65381800e-02f, 1.22613810e-01f, -4.53279652e-02f, 3.29177566e-02f,
  1.51200574e-02f, 5.40831313e-02f, -6.74626455e-02f, 9.00433585e-02f, 4.80101816e-02f, 4.27456456e-04f, 9.41540077e-02f, 8.16156045e-02f, -1.23230062e-01f, 1.17298476e-01f,
  7.75604472e-02f, -6.85339002e-03f, 2.96750050e-02f, -4.72667553e-02f, 1.24675706e-01f, -9.94118750e-02f, 4.07173969e-02f, 3.51857021e-02f, 6.49821246e-04f, -1.28562301e-01f,
  1.21387534e-01f, -6.97477683e-02f, -1.05464794e-02f, -1.61497861e-01f, -1.41322628e-01f, -5.49400337e-02f, -2.64268629e-02f, 1.38664439e-01f, -1.03985615e-01f, 1.43127948e-01f,
  1.91949099e-01f, -1.06353521e-01f, 1.23577900e-01f, -3.80969256e-01f, -1.38881236e-01f, 2.65264213e-01f, 8.61900449e-02f, 1.94501325e-01f, 1.46694496e-01f, -3.61463986e-02f,
  3.15851331e-01f, 1.68909386e-01f, 2.58038282e-01f, -6.70747012e-02f, 3.44355136e-01f, 3.80171724e-02f, 4.34302747e-01f, 2.73976177e-02f, 1.08787797e-01f, 2.05408350e-01f,
  1.80098146e-01f, -2.36153334e-01f, -7.75777400e-02f, 1.67778924e-01f, 3.37595567e-02f, -2.85646450e-02f, -9.94053558e-02f, -1.50502414e-01f, 1.91910997e-01f, 1.10303812e-01f,
  7.13677853e-02f, 1.03221171e-01f, 7.79586509e-02f, -4.86731902e-02f, 9.07099165e-04f, -1.10252351e-01f, 6.06417172e-02f, 1.91500932e-02f, 6.37116358e-02f, 1.11684829e-01f,
  -8.83856416e-02f, -5.32335602e-02f, 1.12316340e-01f, 1.70827225e-01f, 2.13721663e-01f, 3.06302146e-03f, 7.07243457e-02f, 2.01354384e-01f, -1.56349614e-01f, 1.95952147e-01f,
  1.06473424e-01f, 1.64200276e-01f, 1.57006934e-01f, -8.52726623e-02f, 9.81999096e-03f, 1.62254736e-01f, -3.34648967e-01f, -7.19516724e-02f, -2.30882660e-01f, 1.17581576e-01f,
  2.84028500e-01f, -2.45786861e-01f, -2.14135513e-01f, 3.24197710e-01f, -2.64336765e-01f, 3.29934210e-01f, 3.05531502e-01f, 1.12274900e-01f, 1.92359552e-01f, 1.93597540e-01f,
  -2.69895017e-01f, -9.32137296e-02f, 1.54047742e-01f, -1.71564549e-01f, -6.12166710e-02f, -6.85389936e-02f, 5.89377386e-03f, 1.72891226e-02f, 9.72971320e-02f, -1.63375705e-01f,
  3.41023415e-01f, -4.08001207e-02f, 4.09052104e-01f, -1.68114781e-01f, 2.26278096e-01f, 3.41101661e-02f, -2.11626023e-01f, 3.55324566e-01f, 4.10784371e-02f, 6.43563628e-01f,
  -3.09768438e-01f, 2.02421367e-01f, -1.29094794e-01f, -1.14789985e-01f, -8.05069655e-02f, -3.26553099e-02f, 7.91601837e-03f, -5.33151217e-02f, -5.55655211e-02f, 2.91077103e-02f,
  1.57874972e-02f, 1.18259282e-03f, -8.73702094e-02f, 3.78239043e-02f, 8.67559016e-02f, 6.88284710e-02f, 7.32918531e-02f, 9.11760051e-03f, 4.03678184e-03f, -8.83033276e-02f,
  1.26787927e-02f, -6.02812767e-02f, -7.74195194e-02f, 5.70057072e-02f, 5.67103177e-02f, 5.07793128e-02f, 1.52248621e-01f, -9.48412046e-02f, 1.98207930e-01f, -2.29992807e-01f,
  -7.46588707e-02f, -1.92985125e-02f, -4.45612930e-02f, 2.26781040e-01f, -5.18221930e-02f, 1.49766281e-01f, -7.23468810e-02f, -2.29172766e-01f, 1.62868410e-01f, -2.21044153e-01f,
  -1.90674007e-01f, -1.63983524e-01f, -2.12769266e-02f, -7.81966448e-02f, 5.26730120e-02f, 4.58071977e-02f, -7.03332126e-02f, 1.09305836e-01f, 1.32092893e-01f, 9.77875516e-02f,
  4.66270484e-02f, 1.64089143e-01f, 6.17949739e-02f, 2.05043167e-01f, 1.76336039e-02f, 2.25251272e-01f, -1.27100378e-01f, 4.17478412e-01f, 3.03026617e-01f, 9.21507105e-02f,
  2.80872494e-01f, -3.98589857e-02f, 2.02175248e-02f, -1.20125644e-01f, 8.63175988e-02f, -6.70295209e-02f
};

// L2_fan_Bp_bar (Shape: 1 x 14)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 14;
const float L2_fan_Bp_bar_data[] = {
  1.63074508e-02f, 4.50430848e-02f, 1.23417884e-01f, 6.96262568e-02f, 1.11473672e-01f, 1.06616266e-01f, 7.13603497e-02f, 1.66069549e-02f, 1.29604876e-01f, 1.07818663e-01f,
  1.66894067e-02f, 6.80198967e-02f, 9.54011902e-02f, 4.37767878e-02f
};

// L3_linear_W (Shape: 12 x 64)
const int L3_linear_W_rows = 12;
const int L3_linear_W_cols = 64;
const float L3_linear_W_data[] = {
  1.67743653e-01f, -2.76762307e-01f, 8.50227550e-02f, -1.97137907e-01f, -1.50453389e-01f, -2.41987631e-01f, 2.46546328e-01f, -1.20445520e-01f, 2.47766059e-02f, -2.28663728e-01f,
  2.75297940e-01f, 1.54734943e-02f, 1.57795802e-01f, 1.43279791e-01f, -1.74642559e-02f, 5.45071363e-02f, -1.12577833e-01f, -1.35528773e-01f, -3.16968441e-01f, 9.82927904e-02f,
  -1.43254951e-01f, -1.67961955e-01f, 1.33009031e-01f, 1.86965838e-01f, 5.73315956e-02f, -3.29105705e-01f, 1.66426703e-01f, 3.78197730e-01f, -2.65027761e-01f, 1.15589418e-01f,
  -1.78874791e-01f, 1.40353158e-01f, -2.15862855e-01f, -2.96691805e-01f, -1.16013452e-01f, 6.28123134e-02f, 1.99400917e-01f, -3.03264320e-01f, 2.22873941e-01f, -1.58748955e-01f,
  3.64962757e-01f, -3.02704424e-01f, 2.07186565e-01f, 1.26006097e-01f, -2.04455093e-01f, -1.54701367e-01f, -2.99723327e-01f, -2.67258912e-01f, 2.07250968e-01f, -6.99559301e-02f,
  -2.93060869e-01f, -3.88857126e-01f, 2.91549027e-01f, -6.51876509e-01f, -2.50339627e-01f, 1.25151441e-01f, -1.67876676e-01f, 2.59726048e-01f, 2.29439452e-01f, -3.41642290e-01f,
  3.18785794e-02f, 2.26851821e-01f, 1.63130462e-01f, -2.41388485e-01f, -1.08156830e-01f, -1.23496518e-01f, 1.37725756e-01f, -2.58614182e-01f, 2.06954300e-01f, 1.28523603e-01f,
  -1.14301285e-02f, 3.05448562e-01f, 6.68147430e-02f, -1.49248526e-01f, -2.05949426e-01f, 1.38354808e-01f, 1.52846694e-01f, 2.12214604e-01f, 6.25204444e-02f, 8.24191049e-02f,
  2.36903131e-02f, -1.94320515e-01f, -1.15758111e-03f, 1.45209387e-01f, -3.61117661e-01f, -6.48336262e-02f, -1.85767151e-02f, 2.37923190e-01f, 6.36104960e-03f, 3.98726851e-01f,
  1.85241774e-01f, 2.39737004e-01f, -2.00011581e-01f, 1.05601296e-01f, -2.43382126e-01f, 2.53743827e-01f, -6.66449666e-02f, 3.40033144e-01f, 1.89905480e-01f, -2.92653739e-01f,
  1.83810480e-02f, 3.21319968e-01f, -3.54194969e-01f, -2.43509889e-01f, -1.00461632e-01f, 3.84820223e-01f, 2.12180778e-01f, 1.59429997e-01f, 1.94963306e-01f, -8.16807151e-02f,
  -3.04994911e-01f, 3.46757561e-01f, 2.25879729e-01f, 8.98164958e-02f, -3.44711274e-01f, -3.20935190e-01f, 3.78157288e-01f, 2.98199624e-01f, -1.82285801e-01f, 1.72185585e-01f,
  2.54860252e-01f, -4.56942469e-01f, -3.90434951e-01f, 3.11906375e-02f, -3.44725877e-01f, 2.24170089e-01f, -2.64340669e-01f, -2.65196532e-01f, -1.55355230e-01f, -1.52128309e-01f,
  -2.98961043e-01f, 1.91397175e-01f, -2.50086606e-01f, 2.06757151e-02f, -1.33970693e-01f, -2.70277709e-01f, -1.17439695e-01f, -5.66001981e-03f, -1.29969403e-01f, -9.26596671e-02f,
  -1.03582770e-01f, -2.20831573e-01f, 2.32209768e-02f, 5.70529215e-02f, -4.70003858e-03f, -1.72208890e-01f, -1.25189602e-01f, 9.71378013e-03f, 2.56273389e-01f, -6.42620027e-02f,
  -1.97080076e-01f, -1.21265732e-01f, 1.16421893e-01f, 2.08935395e-01f, 1.20008990e-01f, 9.27699432e-02f, -1.01111688e-01f, 5.22930995e-02f, -7.74506405e-02f, 9.10947993e-02f,
  -1.65708244e-01f, 9.32874754e-02f, 5.87080419e-02f, 9.56692249e-02f, -3.52718532e-01f, 1.98966295e-01f, -3.46199796e-02f, 4.06657696e-01f, -1.84069440e-01f, 5.22643887e-02f,
  -1.51762828e-01f, 1.66524515e-01f, 1.32969111e-01f, -3.93639505e-02f, -2.15268239e-01f, -1.86529845e-01f, 2.04289392e-01f, -4.69300114e-02f, -1.38507903e-01f, 2.46085733e-01f,
  -3.97394001e-01f, -2.33854741e-01f, -3.31317186e-01f, 2.19833985e-01f, 8.65349248e-02f, 2.08737895e-01f, -3.54595423e-01f, -4.89090055e-01f, -3.48843038e-01f, 2.45158732e-01f,
  3.42503965e-01f, 1.00358754e-01f, -8.00771639e-02f, -1.67589590e-01f, -8.11184943e-02f, -6.62055463e-02f, -1.10251851e-01f, 1.52373258e-02f, 1.16355337e-01f, 1.82769507e-01f,
  2.40417883e-01f, 1.23628512e-01f, 3.12956572e-01f, -1.29515186e-01f, -1.37666449e-01f, -2.43611872e-01f, -1.91644192e-01f, -2.94446826e-01f, -7.61463447e-03f, 9.08683687e-02f,
  2.16207225e-02f, -7.16967136e-02f, 9.78660285e-02f, -7.75805935e-02f, -2.68322021e-01f, 1.21589512e-01f, -1.73801750e-01f, 1.79756209e-01f, -4.70042005e-02f, -9.30873156e-02f,
  -2.80322641e-01f, 1.13358185e-01f, 2.77204722e-01f, 3.11670840e-01f, -2.21908987e-02f, 1.27636597e-01f, 6.85742646e-02f, 1.44507840e-01f, -5.62395714e-03f, 1.96160153e-01f,
  -3.57276462e-02f, -3.91118303e-02f, -2.66209450e-02f, -9.00444463e-02f, -3.28061849e-01f, -1.66636631e-01f, 1.82077318e-01f, 3.42010051e-01f, 2.09669873e-01f, -4.97560985e-02f,
  -1.71841085e-01f, -9.92488340e-02f, 1.33801565e-01f, 1.60828188e-01f, -3.30243081e-01f, -4.10739839e-01f, -4.44319457e-01f, -3.92910033e-01f, -4.58042890e-01f, 2.70155996e-01f,
  3.50744545e-01f, 2.26483181e-01f, 6.30193725e-02f, -3.97532225e-01f, -5.71713090e-01f, 2.89144874e-01f, -3.26334089e-01f, 1.29307821e-01f, -9.72638577e-02f, 2.43755192e-01f,
  7.60344788e-02f, 1.66338548e-01f, 9.14712250e-02f, -3.46697330e-01f, -2.13049293e-01f, 1.99485987e-01f, 9.02470201e-02f, 1.49477229e-01f, 5.43812029e-02f, 1.76853016e-01f,
  -2.61626691e-01f, 2.42118716e-01f, 8.78410116e-02f, 1.87239230e-01f, 2.74684906e-01f, 1.69297621e-01f, 1.60133228e-01f, 1.97956681e-01f, -3.84814404e-02f, -1.73293561e-01f,
  9.33714956e-03f, 1.97806597e-01f, -2.22889170e-01f, -3.57024729e-01f, 4.14385706e-01f, 1.68672919e-01f, -7.24953637e-02f, -1.94021106e-01f, 1.04687780e-01f, -7.96830505e-02f,
  1.14946924e-01f, 1.06886722e-01f, 2.32218429e-01f, -3.56252521e-01f, 1.03774652e-01f, -2.88851876e-02f, 1.46418333e-01f, -8.27490538e-02f, 9.82874855e-02f, 3.06160122e-01f,
  9.90949273e-02f, 2.86122411e-01f, 9.42127258e-02f, -1.61615089e-01f, -2.34576985e-01f, -3.84956390e-01f, 4.87925977e-01f, 9.15069729e-02f, -2.12895930e-01f, -4.48079348e-01f,
  1.92622378e-01f, -1.67736605e-01f, -4.63426739e-01f, 3.77059072e-01f, -4.20732275e-02f, 7.10227117e-02f, 2.76043802e-01f, -3.49701464e-01f, 1.44851059e-01f, -3.65012974e-01f,
  6.07926399e-02f, 8.68649259e-02f, -5.20952009e-02f, 5.50775938e-02f, 1.60522729e-01f, 1.67219892e-01f, -2.06760168e-01f, -6.32589012e-02f, -4.31689508e-02f, 5.29498383e-02f,
  2.82648772e-01f, -1.11820392e-01f, 2.45248839e-01f, -6.21994305e-03f, -2.23962203e-01f, -4.53398516e-03f, -1.30086988e-01f, 2.74939299e-01f, 2.67779827e-01f, 3.81403305e-02f,
  -1.44962937e-01f, 2.04787627e-01f, -1.25322938e-02f, -2.21359313e-01f, 2.59674396e-02f, -2.49902129e-01f, 1.98090211e-01f, -3.81810546e-01f, -3.83527219e-01f, -2.64962822e-01f,
  2.21212640e-01f, -3.02453041e-01f, -7.55072832e-02f, -2.81982034e-01f, 2.79809266e-01f, 2.51202166e-01f, 1.39755458e-01f, 5.16366437e-02f, 4.67017829e-01f, 3.76424678e-02f,
  -3.37372899e-01f, -3.32227290e-01f, -1.58810854e-01f, 4.32292521e-02f, -3.19886118e-01f, -2.58280396e-01f, 3.27493161e-01f, -3.63670915e-01f, -1.41862392e-01f, 3.26904446e-01f,
  3.55866373e-01f, -4.67570364e-01f, 5.02712190e-01f, -1.37880266e-01f, 3.84968430e-01f, -2.40758389e-01f, 2.02958226e-01f, -1.45819679e-01f, -4.50496852e-01f, -4.09380555e-01f,
  -2.91404039e-01f, -2.56965786e-01f, 7.60466009e-02f, -2.21524224e-01f, 8.10434222e-02f, 2.14500159e-01f, 3.70104387e-02f, 1.75405025e-01f, 5.43148406e-02f, 1.69023663e-01f,
  1.93350971e-01f, -3.36242825e-01f, -1.00216620e-01f, 5.36902025e-02f, -3.36676210e-01f, 1.83312491e-01f, 6.77967966e-02f, 8.73238891e-02f, -8.21071491e-02f, -1.87093124e-01f,
  -2.74130944e-02f, -1.05501547e-01f, 1.98661327e-01f, 8.63572862e-03f, 1.73456416e-01f, -6.91022575e-02f, -1.77035853e-02f, -1.03426248e-01f, -2.07245752e-01f, 3.49551111e-01f,
  -1.47964433e-01f, -6.23106919e-02f, 6.32930622e-02f, -1.85681507e-01f, 2.10577816e-01f, -7.05287680e-02f, -3.74899767e-02f, 3.89657646e-01f, -2.09778935e-01f, 5.36264926e-02f,
  2.56294101e-01f, 2.49140218e-01f, -3.92298639e-01f, -2.68809974e-01f, 8.52388665e-02f, 1.31303445e-01f, 2.47144356e-01f, -1.72440663e-01f, -9.90128368e-02f, -8.16601589e-02f,
  1.97279274e-01f, 3.38656515e-01f, -1.39502421e-01f, 1.50746927e-01f, -5.58999069e-02f, 2.50082910e-01f, -4.61058646e-01f, 4.81953591e-01f, 2.30688095e-01f, -4.56247747e-01f,
  2.03661069e-01f, -2.46065766e-01f, -3.96076530e-01f, -4.51858401e-01f, -3.14416170e-01f, -1.85817815e-02f, 4.65899240e-03f, -1.39380217e-01f, 6.77239103e-03f, 5.07810935e-02f,
  -1.67381555e-01f, -5.83810136e-02f, -1.29269972e-01f, 6.38406500e-02f, 1.51903378e-02f, 1.07561797e-01f, 5.95149249e-02f, -1.64838061e-01f, 1.14322240e-02f, 1.27262652e-01f,
  1.42115533e-01f, 1.41942367e-01f, 1.63673833e-01f, -1.62257418e-01f, -1.55963495e-01f, -1.19489685e-01f, -4.24793661e-02f, -1.20567560e-01f, -1.98149219e-01f, 2.91233864e-02f,
  -4.07143310e-02f, 1.70538694e-01f, 7.62353688e-02f, -1.40734375e-01f, 3.83453704e-02f, -3.03970613e-02f, 1.78904891e-01f, 6.42525777e-02f, -1.55807137e-01f, -1.88434795e-01f,
  7.21657183e-03f, -2.34755531e-01f, 1.60285562e-01f, 1.85091659e-01f, -2.73134619e-01f, 3.75779308e-02f, -1.31251499e-01f, -3.62271778e-02f, 1.71613783e-01f, 2.76381105e-01f,
  -1.84641957e-01f, -1.71831980e-01f, -2.34275594e-01f, 1.75855711e-01f, 1.48950264e-01f, -1.21854931e-01f, -1.55684669e-02f, 2.02270731e-01f, -2.45792553e-01f, -3.89972925e-01f,
  3.94238740e-01f, -2.22161785e-01f, -6.32334575e-02f, -1.81375682e-01f, -2.00530410e-01f, -3.98880899e-01f, 2.83194482e-01f, 4.68513668e-01f, 3.06325972e-01f, -2.25558802e-01f,
  -3.70391786e-01f, -1.66409537e-01f, 1.93428338e-01f, 1.70573264e-01f, 1.31882578e-01f, -3.37196677e-03f, -1.06351234e-01f, -9.01012197e-02f, -7.55961612e-02f, 3.49193029e-02f,
  1.14748485e-01f, 9.68758389e-02f, -4.83800806e-02f, 2.09510311e-01f, 1.71226606e-01f, 1.16280422e-01f, 2.31444240e-01f, -2.09718212e-01f, -1.45823151e-01f, 2.11037114e-01f,
  6.10148348e-02f, -2.12741017e-01f, 1.34594873e-01f, -7.88100436e-02f, -9.49113593e-02f, -5.90303726e-02f, 5.76833710e-02f, 1.27084002e-01f, -6.55113831e-02f, -2.49576531e-02f,
  2.21884087e-01f, 9.26922932e-02f, 2.89546579e-01f, 1.54244468e-01f, 2.55206555e-01f, -6.08510412e-02f, -1.91685706e-01f, -5.14663719e-02f, 2.73161661e-02f, -1.50211319e-01f,
  -2.25958019e-01f, 1.67149886e-01f, 9.56554785e-02f, 2.52622247e-01f, -3.75407711e-02f, -2.22483084e-01f, 1.14041179e-01f, 1.98201716e-01f, -2.51826435e-01f, 2.14750394e-01f,
  2.34297782e-01f, -1.17258385e-01f, 1.72523007e-01f, 2.93058336e-01f, 3.03434581e-01f, -3.77850413e-01f, 1.16388902e-01f, 3.16217422e-01f, -4.29491788e-01f, 3.67997140e-02f,
  1.86774805e-01f, -2.16646031e-01f, -4.14276034e-01f, -1.67430434e-02f, -2.84105539e-01f, 1.16713881e-01f, -5.85007854e-03f, -2.05453932e-02f, 7.37236291e-02f, 1.24952011e-01f,
  1.81518406e-01f, -1.99873880e-01f, 7.79168010e-02f, -1.19692357e-02f, 1.07119285e-01f, 4.43715975e-02f, 2.64833272e-01f, 6.47482229e-03f, -1.13702528e-01f, -1.19571842e-01f,
  3.28631252e-01f, -1.27620399e-01f, 1.23613797e-01f, -2.34793171e-01f, -2.52135605e-01f, -2.51420826e-01f, 1.03641257e-01f, -9.94353816e-02f, 1.21478230e-01f, -5.67132905e-02f,
  7.45520666e-02f, -2.83085555e-01f, 1.33782223e-01f, 4.00191516e-01f, -2.29896754e-01f, 2.11397931e-01f, -2.54874408e-01f, -1.97857231e-01f, 1.73954561e-01f, -3.39462698e-01f,
  2.38876864e-01f, -1.18120462e-01f, -4.10899639e-01f, 3.14451873e-01f, -2.87977725e-01f, 1.61572054e-01f, -3.11796129e-01f, -1.02548167e-01f, 1.07693300e-01f, 2.28525013e-01f,
  -1.96253777e-01f, 1.82564065e-01f, 2.04761371e-01f, 1.96644053e-01f, -1.90741077e-01f, 2.98743248e-01f, -3.09320122e-01f, -1.88136980e-01f, -3.46845925e-01f, -2.24888489e-01f,
  8.85483027e-02f, -3.35694820e-01f, 1.12164989e-02f, -1.57560363e-01f, -3.62341642e-01f, -1.66853797e-02f, 3.63327652e-01f, -2.38692269e-01f, 4.88349468e-01f, -1.61937729e-01f,
  -2.52779108e-03f, 9.61572230e-02f, 1.63309753e-01f, -1.66982755e-01f, -9.81111452e-02f, 1.31447315e-01f, -8.36618915e-02f, 6.37161434e-02f, -2.96301037e-01f, -3.03683709e-02f,
  -2.38719717e-01f, -2.53531039e-01f, -1.31344080e-01f, 2.51937136e-02f, -2.39458568e-02f, 1.48939118e-01f, 2.80886460e-02f, -9.28299353e-02f, 1.02680646e-01f, -1.70770928e-01f,
  -1.30921617e-01f, 1.58613354e-01f, 2.50166565e-01f, 5.21238372e-02f, -2.08181605e-01f, -2.43513763e-01f, -1.89232916e-01f, -2.16207549e-01f, 2.76162982e-01f, 9.06289369e-02f,
  -1.15107119e-01f, 6.79613464e-03f, 8.73343945e-02f, 1.33614540e-01f, 1.22096784e-01f, -8.00912455e-02f, 1.02502115e-01f, -1.96020529e-01f, 2.17578858e-01f, -1.56428501e-01f,
  1.54899925e-01f, -2.38198593e-01f, 2.78800160e-01f, -2.21249804e-01f, 7.44029880e-04f, -3.46387327e-01f, -3.00760772e-02f, -1.69076219e-01f, 1.80191979e-01f, -3.21997777e-02f,
  -2.50705808e-01f, 1.85530365e-01f, -4.31582719e-01f, 2.70453483e-01f, -5.07411003e-01f, -8.11311603e-03f, 1.80521861e-01f, 1.44823685e-01f, -1.14730202e-01f, -1.53759811e-02f,
  4.27904688e-02f, 2.74321705e-01f, -3.68025094e-01f, 2.87787914e-01f, -1.68752279e-02f, -1.28895506e-01f, -1.69109955e-01f, -7.90803209e-02f, 1.03619754e-01f, -2.06097871e-01f,
  -1.56707186e-02f, 1.33828670e-01f, 1.02099761e-01f, 2.21983977e-02f, 1.10363983e-01f, -1.75489150e-02f, -1.49395108e-01f, -3.92340459e-02f, -1.94967136e-01f, 1.72917560e-01f,
  9.81719941e-02f, 8.46636891e-02f, -1.68002710e-01f, 1.07707553e-01f, 3.11263930e-02f, 1.11148180e-02f, 1.03141457e-01f, 2.63324883e-02f, 1.88929617e-01f, -2.42171049e-01f,
  -2.65484422e-01f, 1.07021242e-01f, 2.57661372e-01f, -3.09829801e-01f, 2.26417720e-01f, -2.22426176e-01f, -1.23303244e-02f, 8.50904733e-02f, -2.80059606e-01f, -1.68945059e-01f,
  -2.06240662e-03f, -2.01686576e-01f, 1.86366662e-01f, 1.52209446e-01f, -1.46765217e-01f, 7.83755183e-02f, -2.97728837e-01f, -1.42384917e-01f, 2.62581725e-02f, -5.38607463e-02f,
  1.52207226e-01f, -1.99069142e-01f, -1.93106726e-01f, -1.27199233e-01f, 3.04284096e-01f, 9.43917632e-02f, -2.97275446e-02f, 4.64209139e-01f, 2.33387336e-01f, -4.49866295e-01f,
  -1.27556294e-01f, -2.72802830e-01f, 3.90632153e-02f, 1.62233934e-01f, -1.84013769e-01f, -3.62804294e-01f, -5.18822730e-01f, 5.66685200e-02f
};

// L3_linear_B (Shape: 1 x 12)
const int L3_linear_B_rows = 1;
const int L3_linear_B_cols = 12;
const float L3_linear_B_data[] = {
  7.55349454e-03f, 1.56195741e-02f, -1.20446213e-01f, -1.35950986e-02f, -4.31970134e-02f, 6.36504367e-02f, 2.68194899e-02f, -1.83902327e-02f, 5.37523476e-04f, 7.46800229e-02f,
  -8.54447391e-03f, 2.21669897e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 25, 14
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        64, 25, 14
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        64, 25, 14
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_linear
    linear_forward_pgm(
        buffer1, x_out,
        L3_linear_W_data, L3_linear_B_data,
        64, 12
    );
    }
    