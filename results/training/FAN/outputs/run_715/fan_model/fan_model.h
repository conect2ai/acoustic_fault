/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 64 (x4)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 64;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    return (x > 0.0f) ? x : 0.0f;
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 19 x 120)
const int L0_fan_Wp_rows = 19;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  8.89743343e-02f, -1.32475123e-01f, -4.12008017e-02f, 2.13970691e-01f, 9.71784368e-02f, -1.46060109e-01f, -1.49728850e-01f, -8.31506625e-02f, 9.60612148e-02f, -5.06800972e-03f,
  -1.95360556e-01f, 5.41847125e-02f, 1.33462399e-02f, -5.27803833e-03f, -3.93779576e-03f, -1.18741184e-01f, 1.03701182e-01f, 2.23016277e-01f, 7.69112036e-02f, 7.85897002e-02f,
  1.21411242e-01f, 2.27048099e-01f, 2.08519295e-01f, 1.61524981e-01f, 1.98733941e-01f, 1.19193949e-01f, -3.14289406e-02f, 3.07060592e-02f, 1.09158389e-01f, 3.19535077e-01f,
  5.73844574e-02f, 1.19254634e-01f, -1.23254536e-02f, 9.60586816e-02f, -6.49696216e-02f, -6.37177750e-02f, -2.62739900e-02f, -1.24030434e-01f, -1.14078604e-01f, 6.03404827e-02f,
  -2.41400283e-02f, 3.24751623e-02f, 2.08763359e-03f, 2.96015851e-03f, 1.86241753e-02f, 1.17402133e-02f, -6.60381690e-02f, -7.79268444e-02f, 6.02232069e-02f, -2.73519512e-02f,
  2.99885795e-02f, 6.05618805e-02f, 5.31921089e-02f, -6.19978905e-02f, -1.12414807e-01f, 1.16400547e-01f, -5.60584664e-02f, 2.08826810e-02f, -5.06507829e-02f, -7.98863545e-02f,
  1.07626520e-01f, -3.30828130e-02f, -1.21259786e-01f, -1.47492632e-01f, -1.20928615e-01f, -1.59042314e-01f, -7.84371644e-02f, -2.89729945e-02f, 2.29085330e-02f, -1.58798665e-01f,
  -7.57971928e-02f, -4.18662876e-02f, 1.07443206e-01f, -1.17031164e-01f, -9.36092138e-02f, -6.08164333e-02f, 9.77263693e-03f, -8.78535658e-02f, -5.87324388e-02f, -9.74063482e-03f,
  -5.32086827e-02f, -5.38888164e-02f, 1.05230259e-02f, -3.50515135e-02f, -9.39461365e-02f, -3.56309153e-02f, 6.93057030e-02f, -3.72020341e-02f, 1.02128880e-02f, -3.83034609e-02f,
  5.69252744e-02f, 5.05905710e-02f, 1.84924025e-02f, 3.56019475e-04f, 6.19154274e-02f, -2.08593924e-02f, 3.00059784e-02f, 8.01175460e-02f, 7.21533969e-02f, 1.25290304e-01f,
  1.18925758e-02f, 2.85627469e-02f, -9.99075267e-03f, -3.13720442e-02f, 1.29206568e-01f, 9.38013196e-02f, -6.62027001e-02f, 7.52918199e-02f, 1.30848646e-01f, 1.22314885e-01f,
  -1.91524271e-02f, 4.04858179e-02f, -4.38722260e-02f, -1.11322604e-01f, -1.86054967e-02f, -7.96296541e-03f, 1.28902541e-02f, 4.83496971e-02f, -1.34382444e-02f, -1.78240597e-01f,
  -1.85725704e-01f, 1.45393118e-01f, -2.04421058e-01f, 1.28670260e-01f, 4.28560600e-02f, -1.21648781e-01f, -2.27381557e-01f, 4.77015600e-02f, 2.78041303e-01f, 7.22872615e-02f,
  1.53399959e-01f, 2.83124864e-01f, 1.27094135e-01f, 7.84314796e-02f, -1.47554889e-01f, -2.12462440e-01f, -1.51356429e-01f, -2.48358607e-01f, -1.78879395e-01f, -1.50689548e-02f,
  2.26309389e-01f, 2.70995535e-02f, -7.95548707e-02f, 7.79004022e-02f, 1.97700605e-01f, 2.95165062e-01f, -6.35650456e-02f, -6.19224422e-02f, 3.20198275e-02f, 2.55053490e-01f,
  -3.29382792e-02f, 8.41787383e-02f, 1.31517231e-01f, 1.49343520e-01f, 7.23601580e-02f, -1.58346985e-02f, -6.00905567e-02f, 6.40447810e-02f, 6.48818612e-02f, 8.94603208e-02f,
  1.17445506e-01f, 4.93495911e-02f, 5.64092882e-02f, 1.70985281e-01f, 3.14800185e-03f, 8.51182118e-02f, 6.05285279e-02f, -1.79528184e-02f, -5.11824675e-02f, -1.13102356e-02f,
  1.93934813e-01f, 1.28187925e-01f, 5.08435853e-02f, 9.60187465e-02f, -5.55894375e-02f, 1.73952635e-02f, 8.19112957e-02f, 7.05575794e-02f, 9.28941369e-02f, 1.33885264e-01f,
  -1.81288511e-01f, -1.35747846e-02f, -4.16807644e-02f, -1.42312378e-01f, -1.32288903e-01f, -1.08483128e-01f, -4.38989513e-03f, -3.20696994e-03f, -4.43347096e-02f, -2.55772006e-02f,
  -3.73475775e-02f, -1.07643768e-01f, -5.83697297e-02f, 3.10650039e-02f, 8.37786496e-02f, 2.56864876e-02f, 3.51293720e-02f, -2.59566382e-02f, 1.35983583e-02f, -3.78869213e-02f,
  -1.35110943e-02f, -1.74508244e-02f, -2.52074227e-02f, -7.38445967e-02f, -3.69131118e-02f, 2.22545117e-02f, 1.15035027e-01f, -1.84970407e-03f, 9.74719971e-03f, 8.94551724e-02f,
  2.02060938e-01f, -3.89722809e-02f, 9.58023667e-02f, 1.30345896e-01f, 1.17049120e-01f, 2.36963909e-02f, 1.06535755e-01f, 8.68465677e-02f, 1.25386596e-01f, 1.15564436e-01f,
  8.57034400e-02f, 9.20392275e-02f, 7.47701479e-03f, 9.25623253e-02f, -3.26658934e-02f, 1.18635580e-01f, 1.20024458e-01f, 8.53530690e-02f, 1.04796834e-01f, 1.64447799e-01f,
  5.99199384e-02f, 4.11690362e-02f, 2.06096899e-02f, 3.59956622e-02f, 8.67607743e-02f, 6.56851009e-02f, 1.96515340e-02f, 5.81968166e-02f, -5.50687173e-03f, -4.86881025e-02f,
  -4.86846045e-02f, 2.15984479e-01f, 5.29941767e-02f, -4.70283777e-02f, 2.53679961e-01f, 4.23471481e-01f, 4.90478247e-01f, 1.92192867e-01f, -3.28359916e-03f, 1.85199857e-01f,
  2.09475458e-01f, -5.43146692e-02f, -8.43982175e-02f, -2.37541017e-03f, 6.09019585e-02f, 3.17815617e-02f, -4.74268943e-02f, -2.00365171e-01f, -1.41992807e-01f, -8.79093260e-02f,
  -1.94775984e-01f, -8.57670978e-02f, -5.80465794e-02f, -7.58271366e-02f, -1.85558870e-01f, -1.15715116e-01f, 7.55506083e-02f, 2.22802050e-02f, -6.86132684e-02f, -3.26575279e-01f,
  4.11793776e-02f, 2.08162442e-01f, 1.22312894e-02f, -4.09264602e-02f, 9.66937393e-02f, -3.16578872e-03f, 2.72497255e-02f, -1.41498970e-03f, 1.05984502e-01f, 5.19543141e-02f,
  -4.42698374e-02f, 1.01738177e-01f, 1.29433990e-01f, 1.07290290e-01f, 5.00797220e-02f, 1.28156081e-01f, 1.41134143e-01f, 3.67426239e-02f, 1.11072592e-01f, 1.07551657e-01f,
  -5.31302355e-02f, 4.92409281e-02f, 2.13507384e-01f, 1.90055445e-01f, 6.92292899e-02f, 9.38512608e-02f, 2.17053667e-01f, 1.19504243e-01f, -1.88697560e-03f, 6.94405213e-02f,
  -2.74649039e-02f, -1.13000600e-02f, 4.20391746e-02f, -2.56717354e-02f, -4.84106913e-02f, 8.28253552e-02f, -1.17081076e-01f, -5.62073812e-02f, -4.69739735e-02f, -2.76520457e-02f,
  2.69172266e-02f, 3.77879143e-02f, 3.26923579e-02f, 6.95328810e-04f, 2.62410883e-02f, 1.42535428e-02f, 5.04215732e-02f, -4.15205136e-02f, -1.44242076e-02f, 6.15829229e-03f,
  3.69511433e-02f, 2.11786833e-02f, 7.04500219e-03f, -8.72731581e-02f, 5.33521436e-02f, -1.12938769e-01f, 4.14429680e-02f, -3.87968048e-02f, -1.58528522e-01f, -1.70003287e-02f,
  -2.54965741e-02f, 6.81621628e-03f, 5.95162697e-02f, 3.56472433e-02f, 2.95022270e-03f, 1.06750444e-01f, 5.21672629e-02f, 1.01568058e-01f, 1.07189216e-01f, 7.21626952e-02f,
  1.12349354e-01f, -8.01280439e-02f, 7.97664747e-02f, 4.18301821e-02f, 9.51221362e-02f, 7.39682838e-02f, -4.19030637e-02f, 5.76002263e-02f, 8.59636515e-02f, -3.01347021e-03f,
  1.39264286e-01f, 1.78873211e-01f, 1.42439693e-01f, 7.84841999e-02f, 1.23342820e-01f, 6.55415729e-02f, 1.10315181e-01f, 8.76050517e-02f, 2.01958820e-01f, 2.03879282e-01f,
  7.23656565e-02f, -9.34152082e-02f, -2.09835082e-01f, 2.12423578e-01f, 5.47038391e-02f, 5.43000288e-02f, 3.49381519e-03f, 9.51936990e-02f, 1.26077101e-01f, 5.57629531e-03f,
  -2.60457993e-01f, -1.59764647e-01f, -1.98609635e-01f, -1.21320866e-01f, -3.50414850e-02f, 1.84024453e-01f, 2.08344564e-01f, -2.15593129e-02f, -2.17260748e-01f, -4.74623702e-02f,
  1.92230597e-01f, 1.18788637e-01f, -3.73687521e-02f, -2.14435067e-02f, 7.86770433e-02f, -2.75260005e-02f, 4.36684862e-02f, 1.29790492e-02f, -6.70770407e-02f, 2.87764490e-01f,
  -1.89644754e-01f, -2.07045227e-01f, -9.87847149e-02f, -1.86210588e-01f, -2.68230200e-01f, 1.31233754e-02f, -1.09777533e-01f, -5.18772490e-02f, -1.35856941e-01f, -1.43543646e-01f,
  -1.76739216e-01f, -1.40949354e-01f, -2.33766675e-01f, -1.10879764e-01f, -1.10348135e-01f, -7.22239465e-02f, 1.09002292e-02f, -5.18762805e-02f, -7.12079555e-02f, -1.81560934e-01f,
  -7.40899220e-02f, -1.31330326e-01f, -2.55060434e-01f, -6.18472658e-02f, -1.90770805e-01f, -1.66104496e-01f, -1.24988943e-01f, -1.98783502e-01f, -1.00403205e-01f, 2.10703332e-02f,
  4.73548360e-02f, -7.62578920e-02f, -5.32534271e-02f, 1.03316970e-01f, 4.54146825e-02f, -6.04289621e-02f, 1.94667317e-02f, 7.30086342e-02f, 3.40192905e-03f, 7.87763819e-02f,
  -2.81507950e-02f, -2.45494489e-02f, -5.34283519e-02f, -6.02030121e-02f, -6.99115098e-02f, 9.80976745e-02f, 1.22822411e-01f, 1.54388025e-02f, -6.47580996e-02f, 7.97681659e-02f,
  8.73553082e-02f, 9.85729098e-02f, 1.04548689e-02f, -1.71856750e-02f, 2.92740371e-02f, -2.81917397e-02f, 8.50769728e-02f, -5.00627495e-02f, 2.36219056e-02f, 9.41692591e-02f,
  8.73792917e-02f, -6.34284616e-02f, 1.41153224e-02f, -1.00514747e-01f, -1.25987828e-01f, -8.10887888e-02f, -6.17027842e-02f, -1.82406783e-01f, -1.95283622e-01f, -1.78674638e-01f,
  -1.81898192e-01f, -2.21907347e-01f, -1.09102137e-01f, -1.15609363e-01f, -5.09672761e-02f, -6.38411194e-02f, 2.71723494e-02f, -7.27171218e-03f, 1.98766566e-03f, -5.86047694e-02f,
  -4.15162044e-03f, -2.19635363e-03f, 6.82718903e-02f, 6.83732033e-02f, -1.00324623e-01f, -5.55141680e-02f, -1.95015743e-02f, -5.17337620e-02f, -2.01612208e-02f, 2.84547620e-02f,
  2.64174312e-01f, -5.56935295e-02f, -1.55068144e-01f, 1.46134228e-01f, -3.05686653e-01f, -4.32005644e-01f, -5.35899997e-01f, -1.05457358e-01f, 1.00331768e-01f, -4.16711196e-02f,
  -4.44250703e-02f, 1.37524262e-01f, 2.44014457e-01f, 1.52011484e-01f, -6.70542270e-02f, -8.05654228e-02f, -1.46918178e-01f, -5.10295518e-02f, -1.40643701e-01f, -2.90949613e-01f,
  -8.12216401e-02f, 1.19174430e-02f, 1.91496126e-02f, 3.96653228e-02f, 7.98490569e-02f, -1.23253971e-01f, -1.94466971e-02f, -2.70209368e-02f, -1.02631681e-01f, 1.05162896e-01f,
  3.11589260e-02f, -1.19956527e-02f, -1.48147091e-01f, 8.61082226e-03f, 6.53020740e-02f, 8.63545537e-02f, -6.19952455e-02f, 4.29580957e-02f, 1.04114655e-02f, -1.98591530e-04f,
  -2.65919603e-02f, 6.23201346e-03f, 1.56998374e-02f, 1.12322800e-01f, 8.55193436e-02f, -1.60329975e-03f, 1.86067715e-01f, 5.71517125e-02f, 1.27476547e-03f, -3.82808261e-02f,
  -1.38036702e-02f, 1.95361022e-02f, 2.91092377e-02f, 1.17640439e-02f, 6.27108514e-02f, -6.37371168e-02f, -3.91702401e-03f, 9.43223685e-02f, -5.18756509e-02f, 1.43444940e-01f,
  1.92610528e-02f, -1.20090423e-02f, 2.20789369e-02f, 1.81862265e-02f, -5.40061016e-03f, 9.15443376e-02f, 9.24662650e-02f, -4.87471856e-02f, -3.34053040e-02f, 3.69549356e-03f,
  5.51569313e-02f, 5.81274042e-03f, 5.03400862e-02f, 9.27808881e-03f, 3.36248800e-02f, 7.85457119e-02f, 4.38407762e-04f, 2.73744054e-02f, 6.17255270e-03f, 6.65448233e-02f,
  2.90565994e-02f, -5.98275438e-02f, -6.18270971e-02f, 5.25268987e-02f, 1.57876555e-02f, 8.53759199e-02f, -6.59696683e-02f, -1.62400473e-02f, 1.23578459e-02f, 2.30165366e-02f,
  -4.64868508e-02f, -1.24248914e-01f, -4.41433489e-02f, -4.09683436e-02f, 2.78668869e-02f, 5.96627370e-02f, -3.43591869e-02f, 1.52031332e-02f, 3.55887115e-02f, -4.81394492e-02f,
  -1.14413261e-01f, -4.21809405e-02f, 8.46977755e-02f, -4.25383747e-02f, -1.24337435e-01f, -1.36119694e-01f, -3.94054614e-02f, -1.18087590e-01f, 1.15210591e-02f, -4.51976480e-03f,
  8.62383321e-02f, -8.52537304e-02f, -1.78310499e-02f, -1.84987992e-01f, -1.32778928e-01f, -1.43642738e-01f, -1.18624732e-01f, -2.19257146e-01f, -1.74218550e-01f, -2.13023186e-01f,
  -1.55013204e-01f, 2.18763843e-01f, 3.90429825e-01f, -1.89313456e-01f, -3.50709930e-02f, -3.03801447e-02f, -4.69455570e-02f, -8.95847157e-02f, -7.79992566e-02f, -6.52046222e-03f,
  1.90229669e-01f, 5.54185768e-04f, 1.11205883e-01f, 2.32381094e-02f, -3.76269817e-02f, -4.08500656e-02f, -1.48484021e-01f, -1.95558909e-02f, -8.72114524e-02f, -9.69816744e-02f,
  -1.84460789e-01f, -7.43515715e-02f, 5.18544316e-02f, 8.90747681e-02f, -1.16229177e-01f, -1.01872727e-01f, 1.93339214e-01f, 1.93692997e-01f, 2.71283478e-01f, -1.95588931e-01f,
  3.27585727e-01f, 1.30950406e-01f, -1.61662862e-01f, -1.08678028e-01f, 1.18911400e-01f, -5.15265949e-02f, -7.28067234e-02f, 4.34630141e-02f, 8.88092723e-03f, -4.88221383e-04f,
  -2.11741515e-02f, -4.01330516e-02f, 3.64864543e-02f, -3.30981277e-02f, 7.04373792e-03f, -7.71036074e-02f, 5.57401031e-02f, 9.00454223e-02f, 8.27987492e-02f, 7.58985728e-02f,
  1.60682611e-02f, 4.91358563e-02f, 1.53176263e-01f, 2.50522308e-02f, 1.31238595e-01f, 5.05675189e-02f, 1.52739376e-01f, 1.97425202e-01f, 2.05303505e-01f, 6.01597689e-02f,
  -2.70135775e-02f, -1.77644417e-01f, -5.11682406e-02f, 1.35682328e-02f, -7.50599131e-02f, -6.78927824e-03f, -7.21299872e-02f, 3.96973453e-02f, -7.65648931e-02f, -3.96136343e-02f,
  4.26477902e-02f, -6.26001656e-02f, -2.99736019e-02f, -1.19094793e-02f, -6.01857044e-02f, 1.48342839e-02f, -8.23749676e-02f, -5.63744195e-02f, 2.18689274e-02f, -4.74682041e-02f,
  -7.04438761e-02f, -5.74798808e-02f, -6.12432733e-02f, -1.33846387e-01f, 9.44042429e-02f, -9.44025815e-03f, -1.21606722e-01f, -7.60835260e-02f, -1.09384492e-01f, 5.29088825e-02f,
  -3.54753472e-02f, 2.21168205e-01f, -1.25666693e-01f, -1.75285973e-02f, -1.53214624e-02f, 6.59591258e-02f, 1.64852589e-02f, 5.82486838e-02f, 7.71336257e-02f, -4.62079793e-02f,
  1.09767519e-01f, -1.09817851e-02f, 3.70692089e-02f, 5.16323484e-02f, -7.53557384e-02f, 2.24764775e-02f, 4.12446447e-02f, -1.12432875e-02f, -1.98569838e-02f, 1.02086319e-02f,
  5.85609823e-02f, -9.43098739e-02f, -5.37717119e-02f, -4.35043424e-02f, -2.28115432e-02f, -1.53869420e-01f, -6.70088381e-02f, 2.58667041e-02f, -1.12766661e-02f, -1.86850950e-01f,
  -1.27118111e-01f, -4.26904112e-01f, -1.22491270e-01f, 1.72107428e-01f, 1.11985341e-01f, -7.63286129e-02f, -3.45712274e-01f, 6.83473349e-02f, 1.58647433e-01f, -2.86453843e-01f,
  -7.25423992e-02f, 3.05765241e-01f, 1.83948696e-01f, 2.33309776e-01f, 9.97141600e-02f, -2.64296591e-01f, -9.58459973e-02f, 1.28657550e-01f, 2.10013390e-01f, 1.85173795e-01f,
  1.11795245e-02f, -9.47272107e-02f, 9.31711681e-03f, 1.34595394e-01f, -1.41441375e-01f, 7.66636506e-02f, -1.73657313e-01f, -8.72107148e-02f, -1.64250746e-01f, -1.33563772e-01f,
  -1.26040608e-01f, -8.61378834e-02f, 8.90958086e-02f, 1.51829168e-01f, 1.95301659e-02f, 1.19406126e-01f, -2.50444934e-02f, 1.39323711e-01f, 9.00086239e-02f, -2.53902823e-02f,
  6.96373880e-02f, 1.13923058e-01f, 3.61326262e-02f, 9.37136188e-02f, 5.24502508e-02f, 4.36722413e-02f, 4.87740338e-02f, -2.62339786e-02f, 1.12144753e-01f, 5.71076199e-02f,
  -2.99810246e-02f, -1.28717393e-01f, -7.53022209e-02f, -1.11819260e-01f, 2.97539569e-02f, 5.92453182e-02f, 2.54493076e-02f, -1.89385079e-02f, 7.13514909e-02f, -1.66622281e-01f,
  -1.29467547e-01f, -9.78926271e-02f, 9.99917462e-02f, -4.91680056e-02f, 4.11487035e-02f, 3.01109273e-02f, 9.77925435e-02f, -6.87521994e-02f, 5.27939536e-02f, -6.40550852e-02f,
  1.10873878e-01f, 5.58849610e-02f, 6.13798723e-02f, 2.59915050e-02f, -3.69581878e-02f, -4.30011377e-02f, -4.01923396e-02f, -7.88700730e-02f, 1.07113756e-01f, 1.26317469e-02f,
  1.28954664e-01f, 6.74797893e-02f, -4.47473601e-02f, 5.66292852e-02f, -2.94449199e-02f, 1.13832071e-01f, -6.50649965e-02f, 5.18202782e-02f, -1.24463309e-02f, -1.79606713e-02f,
  7.47657120e-02f, 1.43435225e-01f, -3.97502221e-02f, -8.43307674e-02f, 3.28900479e-02f, 6.39716908e-02f, -3.28602940e-02f, -3.20523075e-04f, -4.82535735e-02f, -7.63192028e-02f,
  -1.86083373e-02f, 1.64165497e-02f, 6.72999173e-02f, 8.58975947e-03f, 7.50153214e-02f, -6.76662624e-02f, -4.35091145e-02f, 5.42986766e-02f, -5.36748134e-02f, -1.20469607e-01f,
  -1.05828017e-01f, 1.62296686e-02f, 5.17593883e-03f, -7.17698485e-02f, 2.38137674e-02f, 1.13300800e-01f, -1.07797064e-01f, 3.71959545e-02f, 4.83641922e-02f, -2.98538864e-01f,
  -5.68810165e-01f, 2.08175823e-01f, 5.64897880e-02f, -3.33456665e-01f, -2.96671595e-02f, 1.49182603e-01f, 3.00882548e-01f, 1.18816093e-01f, -1.46986857e-01f, 1.07447803e-01f,
  3.00652068e-02f, -1.29580870e-01f, -6.00427985e-02f, 6.72012493e-02f, 3.25729959e-02f, 1.35566697e-01f, 2.24123612e-01f, -6.66472092e-02f, -1.52838200e-01f, -2.42050402e-02f,
  3.93510722e-02f, -9.82190147e-02f, -1.28755584e-01f, -8.91409889e-02f, 3.54308039e-02f, -3.78166027e-02f, 1.39318004e-01f, -3.05935577e-03f, 1.03831194e-01f, 7.07654431e-02f,
  -2.39384726e-01f, -5.78113869e-02f, -7.41196126e-02f, 7.00931624e-02f, 6.85874000e-02f, -7.70196542e-02f, -6.68422058e-02f, -8.63320306e-02f, -2.44539930e-03f, 9.85520855e-02f,
  -4.63117883e-02f, 6.33358508e-02f, 8.96337349e-03f, -4.77755675e-03f, 4.21167538e-03f, -1.66944247e-02f, 1.49362028e-01f, 5.89254759e-02f, 1.38425352e-02f, -1.68459881e-02f,
  7.93410540e-02f, 4.94790152e-02f, 6.04635850e-02f, 1.26472265e-01f, 1.32760825e-03f, -7.98670948e-02f, 1.50041413e-02f, 7.58603960e-02f, 7.78007805e-02f, -4.79473807e-02f,
  -9.60141644e-02f, 5.55796549e-02f, 6.13611117e-02f, -8.54946896e-02f, -9.02568847e-02f, 2.03677826e-02f, 1.25818923e-02f, -7.94931129e-03f, -2.37926710e-02f, -8.43199492e-02f,
  4.42217365e-02f, 1.14167575e-03f, -6.62799273e-03f, -6.43322319e-02f, -5.86285889e-02f, -4.82335873e-02f, 5.82043454e-03f, 9.83043760e-02f, 2.33835112e-02f, 7.18451058e-03f,
  9.47919339e-02f, -7.16331229e-02f, -1.20853767e-01f, 1.03182279e-01f, 2.60998923e-02f, -3.68797109e-02f, -8.18370283e-02f, 1.10802121e-01f, 2.36264858e-02f, -1.99519806e-02f,
  -1.44310161e-01f, 3.09859842e-01f, -1.38061449e-01f, -9.33344755e-03f, -1.76434554e-02f, 2.93066017e-02f, -3.32830437e-02f, 7.37593472e-02f, -1.80315562e-02f, 6.29726499e-02f,
  8.41396600e-02f, -6.74079359e-02f, 9.43482742e-02f, 8.91469792e-02f, -6.04414493e-02f, -2.93617863e-02f, 1.49582133e-01f, -7.49101564e-02f, 1.03567861e-01f, -9.20113996e-02f,
  9.97685120e-02f, -7.65883103e-02f, -3.83818783e-02f, -3.36204004e-03f, -4.13857512e-02f, -1.35257185e-01f, -1.72091853e-02f, -3.41953747e-02f, -8.55405927e-02f, 5.66516519e-02f,
  -4.46745187e-01f, -3.75169277e-01f, -2.92253852e-01f, -1.20812155e-01f, -1.46536040e-03f, -1.41045526e-01f, -2.67498046e-01f, -1.27572283e-01f, 1.51601672e-01f, -1.55363575e-01f,
  -4.38546315e-02f, 1.52090997e-01f, -6.05771542e-02f, 6.82075769e-02f, -1.20076060e-01f, -2.66731739e-01f, -2.97184978e-02f, -4.22034152e-02f, -2.09552139e-01f, 2.00323556e-02f,
  1.20421946e-01f, -4.50058766e-02f, -4.39302437e-02f, -4.00804691e-02f, 2.33723652e-02f, 7.36596584e-02f, -5.76832294e-02f, 4.25742939e-02f, 4.51217517e-02f, 3.01834401e-02f,
  -3.09466690e-01f, -2.79889166e-01f, -1.04338601e-01f, 3.84363979e-02f, 1.21196033e-02f, -6.10374399e-02f, -8.96769315e-02f, -9.44831297e-02f, -5.39201796e-02f, 1.27735659e-02f,
  -3.81505233e-05f, -7.48970732e-02f, -1.51966810e-02f, 8.26108307e-02f, -9.94695351e-02f, -1.04975130e-03f, 4.35131695e-03f, -7.96910524e-02f, -6.54347539e-02f, -6.70083910e-02f,
  6.24546297e-02f, -8.72470662e-02f, -1.51879072e-01f, -8.78449678e-02f, -6.85914680e-02f, 4.27478924e-02f, -1.26271382e-01f, 2.26307735e-02f, -4.36040536e-02f, -7.59257302e-02f,
  4.30643111e-02f, 5.35703637e-03f, 2.76867636e-02f, 3.95528711e-02f, 8.26688036e-02f, 1.03407145e-01f, 5.90801165e-02f, 5.31696789e-02f, 8.62909406e-02f, -3.98173742e-02f,
  -1.12382593e-02f, -2.55905520e-02f, -5.98503351e-02f, -1.23505130e-01f, -2.37203240e-02f, -7.00665545e-03f, 3.25966626e-02f, 8.43887106e-02f, 1.58194184e-01f, 3.52810733e-02f,
  -3.23030762e-02f, -3.25012021e-03f, 1.13273710e-01f, -4.04119827e-02f, 4.54527372e-03f, -1.03883306e-02f, -8.50754231e-03f, 3.48465294e-02f, 4.53524143e-02f, 2.01772302e-02f,
  -1.42195016e-01f, -1.16972804e-01f, -8.03623721e-02f, 1.99523498e-03f, -5.41885123e-02f, -4.85489741e-02f, -1.07193701e-01f, -3.44452099e-03f, -9.88850370e-02f, -5.88039532e-02f,
  -1.14582166e-01f, -1.85593084e-01f, -5.04596084e-02f, -4.81588952e-02f, -4.31707427e-02f, 2.11149082e-02f, 8.73927400e-02f, -9.59406197e-02f, 2.49070488e-02f, -4.56211455e-02f,
  -2.07459852e-02f, -8.28035250e-02f, -1.68886632e-01f, -2.16085017e-01f, -1.82945117e-01f, -1.48688644e-01f, -2.22568899e-01f, -1.45659670e-01f, -2.02871874e-01f, -2.80150563e-01f,
  4.72893089e-01f, -7.87533671e-02f, -1.77217394e-01f, -1.83417753e-03f, 9.69277602e-03f, -9.85472575e-02f, -3.36129963e-02f, 9.62647945e-02f, 1.48503363e-01f, 3.23398933e-02f,
  1.71605758e-02f, 4.69313422e-03f, 2.64899749e-02f, -4.78441156e-02f, -9.42424387e-02f, -1.28761545e-01f, -1.73506528e-01f, -9.71175544e-03f, 3.01357056e-03f, -2.75251968e-03f,
  3.04160528e-02f, 2.00070590e-02f, 1.31161898e-01f, -4.72232662e-02f, 5.88366166e-02f, -1.69793572e-02f, 4.76440527e-02f, 1.57658570e-02f, -6.65806085e-02f, -1.16906159e-01f,
  9.48136374e-02f, -1.16176561e-01f, -1.34190470e-01f, -1.30960152e-01f, -2.21202910e-01f, -2.75160652e-02f, -1.33123890e-01f, -3.51316705e-02f, -9.06406119e-02f, -5.90131693e-02f,
  -1.39224529e-01f, -1.55900538e-01f, -2.20475733e-01f, -1.38555378e-01f, -1.46163076e-01f, -2.25578137e-02f, -1.53676018e-01f, -2.62617078e-02f, -1.21102706e-01f, -8.89296979e-02f,
  -1.58615619e-01f, -1.67105496e-01f, 2.50457856e-03f, 3.28771910e-03f, -1.06416099e-01f, -6.51416853e-02f, -1.68216944e-01f, -8.51765200e-02f, 4.90702502e-02f, 7.17788115e-02f,
  1.27171516e-01f, 1.34777889e-01f, 8.45508743e-03f, 1.66122437e-01f, 3.89932506e-02f, 1.39562920e-01f, 3.50816660e-02f, 8.55450481e-02f, 5.52756637e-02f, 6.23662956e-02f,
  5.17473519e-02f, 1.14144489e-01f, 1.06861442e-01f, 1.39955685e-01f, 5.52392565e-02f, 1.11150980e-01f, 8.93998146e-02f, 2.01929850e-03f, 3.73446085e-02f, 1.66788265e-01f,
  6.91239759e-02f, 1.19857870e-01f, 4.85486388e-02f, -3.61392573e-02f, 3.72551046e-02f, -4.19849381e-02f, 1.10165156e-01f, 5.40829450e-02f, 5.98023683e-02f, 2.05339082e-02f,
  1.37724712e-01f, -3.19514722e-01f, -1.19661018e-01f, -1.05555028e-01f, -1.21819429e-01f, -1.40084058e-01f, -1.61692128e-01f, -3.75944637e-02f, -1.36936337e-01f, -1.23443473e-02f,
  -5.50690405e-02f, -1.03596836e-01f, -5.45964539e-02f, -7.00287968e-02f, -7.40155801e-02f, -3.67839374e-02f, 6.41966471e-03f, -1.00068182e-01f, -2.92359833e-02f, 2.88000926e-02f,
  -4.08702232e-02f, -1.27291875e-02f, -6.21836521e-02f, -4.34609987e-02f, -2.94201095e-02f, 3.09150256e-02f, 2.62963995e-02f, -2.51824353e-02f, -2.86671780e-02f, 1.76643074e-01f,
  -3.91223282e-01f, 1.75883935e-03f, 6.86169639e-02f, -9.92473736e-02f, 5.42726703e-02f, 5.02460189e-02f, -1.31305475e-02f, -1.67092040e-01f, -1.57051925e-02f, 5.04707955e-02f,
  -3.50764133e-02f, 6.23897836e-02f, 1.81410909e-01f, 1.67799011e-01f, 1.65569894e-02f, 2.08480448e-01f, 1.73456058e-01f, 3.26964557e-02f, -1.48969486e-01f, -1.95218474e-01f,
  -9.70671419e-03f, -2.09405705e-01f, -2.76343405e-01f, -9.66814533e-02f, -1.12540545e-02f, -8.50933418e-03f, -2.27456018e-02f, -1.94882117e-02f, -4.44145426e-02f, 1.14868253e-01f,
  7.88807776e-03f, -5.40405810e-02f, 1.26896381e-01f, -2.14491691e-02f, 3.79383862e-02f, -4.59122173e-02f, 4.82055768e-02f, 8.83918032e-02f, 1.07937939e-01f, 2.72131916e-02f,
  -8.87527037e-03f, -4.71305139e-02f, 1.23246394e-01f, 1.22578025e-01f, -6.69031367e-02f, -3.93584557e-02f, -1.40289199e-02f, -3.44026498e-02f, -4.93374607e-03f, -1.43422028e-02f,
  3.12657841e-02f, -3.05535309e-02f, -5.49313091e-02f, -4.93944883e-02f, 1.83072159e-04f, -2.44914256e-02f, -1.13957554e-01f, 8.01809318e-03f, -2.89717019e-02f, -1.68901920e-01f,
  2.57623149e-03f, 5.64918257e-02f, 5.63704409e-02f, 5.67329638e-02f, 1.20800184e-02f, 9.67060179e-02f, 3.70490439e-02f, 2.19083689e-02f, -5.25150029e-03f, -7.19548538e-02f,
  1.50666714e-01f, -1.32968813e-01f, -2.73748003e-02f, 1.28237600e-03f, -4.12903428e-02f, -2.00101249e-02f, 7.18667954e-02f, -1.95284877e-02f, 4.76777889e-02f, -9.67828408e-02f,
  -1.70788225e-02f, 4.49013077e-02f, 6.95765624e-03f, 1.59911334e-03f, 4.37166402e-03f, -1.98072251e-02f, -6.56418176e-03f, -8.82239267e-02f, -1.55242523e-02f, -4.31114202e-03f,
  -1.57438561e-01f, 1.15270250e-01f, -3.73616293e-02f, 2.01976057e-02f, 3.09132617e-02f, 4.60186563e-02f, 2.35647354e-02f, -1.23628579e-01f, 7.94673041e-02f, -8.53505731e-02f,
  -7.18858745e-03f, -5.75116500e-02f, 9.53473449e-02f, 1.96060687e-02f, -7.92163759e-02f, 3.53179611e-02f, 4.27068323e-02f, -1.01329885e-01f, -9.47391763e-02f, -7.85187334e-02f,
  2.99373791e-02f, -1.44757181e-01f, -1.40748605e-01f, 7.63934925e-02f, -4.87789400e-02f, -1.25916749e-01f, -3.87673900e-02f, -8.06308240e-02f, -2.02573407e-02f, -1.20674677e-01f,
  -4.32618409e-01f, -1.30333737e-01f, -3.10075320e-02f, -1.85383379e-01f, 9.79676694e-02f, 1.84410512e-01f, 1.41951799e-01f, 2.11872071e-01f, 1.03676533e-02f, -1.67405128e-01f,
  1.13442615e-01f, 1.72747970e-01f, 1.86671689e-02f, 1.47531535e-02f, 1.92012757e-01f, -4.47250865e-02f, -1.42988145e-01f, 1.36389425e-02f, 2.22204775e-01f, 1.88075379e-01f,
  -6.69957697e-02f, -1.29568517e-01f, -5.59304096e-02f, 1.75086111e-02f, -1.34454638e-01f, 9.54867899e-02f, -1.42667308e-01f, -1.21832035e-01f, 9.27586574e-03f, -4.04775023e-01f,
  -2.56701559e-01f, 6.18214533e-02f, 7.13185444e-02f, -8.28216318e-04f, 3.66664454e-02f, 1.42410696e-02f, -3.38396132e-02f, 5.47860675e-02f, 1.21029153e-01f, 9.43192397e-04f,
  -2.29157582e-02f, 1.07288221e-02f, -2.70702764e-02f, -3.62016186e-02f, 9.79017559e-03f, 8.59096739e-03f, -3.59963402e-02f, -3.20660584e-02f, 2.62836274e-02f, -2.40516476e-02f,
  3.15634832e-02f, 9.62559059e-02f, 1.07862003e-01f, 1.64140508e-01f, 1.50366928e-02f, 5.43466955e-02f, 7.72213340e-02f, -8.81400425e-03f, 1.29925862e-01f, -1.66952729e-01f,
  -4.45660204e-02f, 2.36187261e-02f, 1.82167068e-02f, 1.10419877e-01f, 3.22293602e-02f, 9.76301655e-02f, 2.02605911e-02f, -5.13742566e-02f, 4.24613543e-02f, -8.65406916e-03f,
  6.25563040e-02f, 1.10356715e-02f, 5.22453114e-02f, -2.36902735e-03f, 9.12262127e-02f, 4.89420295e-02f, -3.82919163e-02f, -7.26394802e-02f, -8.64882693e-02f, -1.56739098e-03f,
  -8.51016343e-02f, -7.74913058e-02f, -1.09664639e-02f, 4.71673645e-02f, 3.97465229e-02f, -5.09396419e-02f, -2.82064732e-02f, 3.67403924e-02f, 4.47025485e-02f, -5.39350696e-02f,
  -2.43563093e-02f, 1.17376126e-01f, -1.72191158e-01f, 3.47988456e-02f, 9.53338444e-02f, 7.73793906e-02f, 6.15682788e-02f, 6.66177124e-02f, 3.07850335e-02f, -3.49906809e-03f,
  1.87641546e-01f, 2.97337901e-02f, 5.48660569e-02f, 8.67130682e-02f, 5.14778355e-03f, 4.14305888e-02f, 9.84505638e-02f, -1.66371725e-02f, 5.71283437e-02f, 8.23767260e-02f,
  -3.04122195e-02f, 7.52400383e-02f, -5.18853106e-02f, 4.84064072e-02f, 3.65521759e-02f, 5.67246750e-02f, 2.85054669e-02f, 6.12315461e-02f, 1.26150697e-01f, -5.23002632e-03f,
  -3.17124456e-01f, 1.02625236e-01f, 1.80974558e-01f, 5.58523946e-02f, 5.92652969e-02f, -7.30492771e-02f, -8.83459672e-02f, -1.56393200e-01f, -1.14362985e-01f, -6.02975264e-02f,
  3.72675224e-03f, -1.79182544e-01f, -5.86645268e-02f, 2.44045239e-02f, -8.22409615e-02f, 6.54399768e-02f, 2.91128844e-01f, 4.02486287e-02f, -2.48759404e-01f, -1.20083191e-01f,
  -4.08435315e-02f, -7.63947740e-02f, -1.11487411e-01f, 1.76238026e-02f, -6.24959730e-02f, -9.34957415e-02f, -3.43187759e-03f, 8.50505605e-02f, -4.88665327e-02f, 1.19079113e-01f,
  -7.95055404e-02f, -2.65312456e-02f, 1.36113493e-02f, -1.03372797e-01f, -2.19629686e-02f, 4.90276776e-02f, -2.69278940e-02f, 8.01598653e-02f, 1.22515345e-02f, 5.09660281e-02f,
  2.74675284e-02f, -1.21926114e-01f, 4.14989442e-02f, 4.04770859e-03f, -9.01829675e-02f, -4.27185521e-02f, 1.62365556e-01f, 4.42929752e-02f, -3.81264389e-02f, 8.20445716e-02f,
  9.21969637e-02f, 9.37491506e-02f, 1.23681454e-02f, 6.24746978e-02f, 8.60486645e-03f, 8.61763139e-04f, -7.42572024e-02f, 4.88009490e-03f, 1.05245672e-02f, -5.32414354e-02f,
  7.86867812e-02f, 4.36001047e-02f, 8.70709494e-03f, -2.74875648e-02f, -1.25497967e-01f, 2.29469072e-02f, -3.20881121e-02f, -5.42941056e-02f, -1.63946934e-02f, -2.25283951e-02f,
  9.57979262e-02f, -6.88283294e-02f, 5.29001094e-02f, -5.89305647e-02f, 3.68340388e-02f, 1.99218281e-02f, -5.56412674e-02f, -7.43281841e-02f, 2.98435660e-03f, -3.36071178e-02f,
  -1.44009413e-02f, 1.22378943e-02f, -3.44895013e-02f, 3.69903632e-02f, 1.26557583e-02f, -3.21450233e-02f, 2.94941794e-02f, -1.77149788e-01f, 4.35957307e-04f, -3.19333486e-02f,
  -2.84735799e-01f, 1.67476237e-01f, -6.30232021e-02f, -6.32438809e-02f, 2.33667791e-02f, 1.06374674e-01f, 7.04831034e-02f, 1.14981104e-02f, 3.73646393e-02f, -3.63876373e-02f,
  -6.34562522e-02f, -1.79714186e-03f, -1.70536302e-02f, -5.75402193e-02f, -1.06994785e-01f, -8.52799788e-02f, 6.09523728e-02f, -1.86295975e-02f, -5.71546331e-02f, -4.00907695e-02f,
  1.44090261e-02f, -3.33910100e-02f, -1.33001536e-01f, -3.33906040e-02f, -1.58999395e-02f, -1.59945786e-01f, -1.47361696e-01f, -1.95070907e-01f, -2.01879010e-01f, -3.30490857e-01f,
  6.47133365e-02f, -1.71746239e-01f, -2.14230850e-01f, 2.69395500e-01f, -1.65593717e-02f, 7.39103779e-02f, 9.83613729e-02f, 3.27317081e-02f, 2.83933789e-01f, -1.71339866e-02f,
  -5.92019670e-02f, 1.14896938e-01f, 7.94271007e-02f, 1.92764159e-02f, 4.48368452e-02f, -6.70684455e-03f, 4.15522382e-02f, 4.61755246e-02f, 1.27355307e-01f, 3.75363268e-02f,
  1.05383962e-01f, 1.81199223e-01f, 3.49712297e-02f, 8.92228708e-02f, 5.12275323e-02f, 2.40966752e-01f, -8.42813849e-02f, -1.68364272e-01f, -1.94702223e-01f, -9.05707292e-03f,
  -1.43352315e-01f, -3.44046086e-01f, 1.86453655e-01f, 1.20525099e-01f, 1.08664304e-01f, 6.40928745e-02f, 6.78643212e-02f, 5.21059372e-02f, 2.60820659e-03f, 1.72555521e-02f,
  -3.65842832e-03f, -7.02866316e-02f, 4.68599312e-02f, -4.26623374e-02f, -7.83186182e-02f, 7.78807029e-02f, -2.64930315e-02f, -8.57001171e-02f, 8.27995501e-03f, -3.71095352e-02f,
  1.95224341e-02f, -9.09065604e-02f, -6.69736564e-02f, 7.40656629e-02f, -3.59240472e-02f, 1.88867413e-02f, -8.53245556e-02f, -9.19822156e-02f, -3.38698067e-02f, -1.43493051e-02f,
  6.64137769e-03f, 1.15969576e-01f, -2.86259979e-04f, -1.30746178e-02f, 3.58556584e-02f, 3.27814184e-02f, -8.33873525e-02f, 5.93386367e-02f, -4.20624390e-02f, 2.31731310e-02f,
  -1.11807017e-02f, 3.04566044e-02f, 8.42002407e-03f, 1.86390039e-02f, 1.71327703e-02f, 5.74185289e-02f, 1.99290961e-02f, -7.75666758e-02f, 4.95655462e-02f, 4.08778153e-03f,
  4.73003015e-02f, -1.64746307e-02f, 3.29529122e-02f, -1.23820463e-02f, -3.79295647e-03f, 1.47886658e-02f, 1.27131492e-02f, -3.14890556e-02f, 5.82375079e-02f, -5.74189797e-03f,
  2.96772301e-01f, -3.86120752e-02f, 8.08722302e-02f, 1.72117457e-01f, 3.97034250e-02f, -1.16636688e-02f, 6.56067356e-02f, 9.58313271e-02f, 6.37495592e-02f, 6.86137527e-02f,
  5.83667979e-02f, 9.17124823e-02f, -7.83903897e-02f, 9.60802194e-03f, 1.72928169e-01f, 1.30947918e-01f, 3.51092368e-02f, 1.76697657e-01f, 1.11970576e-02f, 4.37242016e-02f,
  1.10398561e-01f, 2.01232851e-01f, 2.99773157e-01f, 1.98689297e-01f, 1.23219393e-01f, 2.91747421e-01f, 9.93722826e-02f, 1.19877607e-01f, 1.81350753e-01f, 3.85110915e-01f,
  5.80796413e-02f, -5.94065189e-02f, -1.14830427e-01f, -1.71381548e-01f, -3.27487290e-02f, 2.04245262e-02f, -1.45587668e-01f, -1.09981149e-01f, -6.83026239e-02f, -8.86553004e-02f,
  2.47735735e-02f, 7.53092393e-02f, 1.85617544e-02f, -6.07605167e-02f, -3.21759880e-02f, -2.37043634e-01f, -2.26661041e-01f, 6.73242807e-02f, 2.35444549e-02f, 1.95404403e-02f,
  -2.65670903e-02f, 1.03457972e-01f, 1.70551166e-01f, 6.61550462e-02f, 3.89828309e-02f, 1.65542290e-02f, -8.80282223e-02f, 5.65777943e-02f, -3.25926878e-02f, -2.67221093e-01f,
  -5.51398508e-02f, -6.55077025e-02f, -1.88319609e-01f, -3.34717557e-02f, -3.94004304e-03f, -1.10697441e-01f, -4.72124629e-02f, -1.97092090e-02f, -2.93107033e-02f, -1.19003020e-01f,
  -3.95774990e-02f, -8.83975402e-02f, -5.40980622e-02f, -1.01280838e-01f, -8.28070939e-02f, -8.59016329e-02f, -9.90939960e-02f, -1.03411399e-01f, -8.42989609e-02f, -5.49207116e-03f,
  -1.09662600e-01f, 4.84409705e-02f, 7.02963844e-02f, -1.02350973e-01f, -1.20969683e-01f, -9.47023630e-02f, 2.32795663e-02f, -3.73036191e-02f, 2.35891622e-02f, -2.52637845e-02f,
  8.95608403e-03f, -2.44741775e-02f, -6.57269359e-03f, -7.82568008e-02f, 8.34833533e-02f, -1.10260593e-02f, -3.66444103e-02f, -9.75597724e-02f, -4.62862514e-02f, 2.57679969e-02f,
  2.72143167e-02f, -6.20193444e-02f, -7.13450462e-02f, -5.63438535e-02f, -2.63017081e-02f, 3.08548624e-04f, 1.08468505e-02f, 2.17774101e-02f, 1.61324497e-02f, 3.37450616e-02f,
  -2.96116546e-02f, 3.32573354e-02f, 6.67549530e-03f, 3.94417532e-02f, -6.47386163e-02f, -5.38493991e-02f, -4.94099148e-02f, 4.61161416e-03f, 2.87095811e-02f, 5.07479198e-02f,
  2.78367922e-02f, -3.70627083e-02f, -2.11560726e-01f, -1.57796573e-02f, -6.98710680e-02f, -7.00515136e-02f, -1.30522922e-01f, -1.70369178e-01f, -2.75641363e-02f, -4.80047315e-02f,
  -1.17313899e-01f, -4.58656661e-02f, -1.35535095e-02f, -9.41748247e-02f, -3.96129489e-02f, -3.66254412e-02f, -1.61244452e-01f, -7.35905915e-02f, -8.58198851e-02f, 2.93154474e-02f,
  -1.27527401e-01f, 4.82362062e-02f, 8.37133005e-02f, -8.76247063e-02f, -6.63891286e-02f, 2.06083488e-02f, 1.14962749e-01f, 3.24786305e-02f, -4.75608222e-02f, -4.94827852e-02f,
  -3.04194856e-02f, -1.43811166e-01f, -7.22656921e-02f, 1.78346470e-01f, -1.46385059e-01f, -8.39427188e-02f, -2.58568883e-01f, -1.28856122e-01f, 1.02577120e-01f, -2.89051291e-02f,
  4.40215394e-02f, 6.98134974e-02f, 1.17802627e-01f, -2.01271269e-02f, -2.11427867e-01f, -3.46159823e-02f, -2.43130769e-03f, -2.59428285e-02f, -9.23016295e-02f, -1.58527240e-01f,
  1.15914149e-02f, 1.13120824e-02f, -1.69194728e-01f, -7.56724700e-02f, 2.18472898e-01f, 1.15151905e-01f, 9.94484127e-02f, -3.52915900e-04f, 7.47047067e-02f, 3.74469876e-01f,
  2.82689631e-01f, 5.03772497e-02f, 4.21529189e-02f, 3.14537212e-02f, 2.60362271e-02f, 9.95450318e-02f, 9.74219963e-02f, 9.50123277e-03f, -1.11519406e-03f, 1.32963613e-01f,
  3.99028212e-02f, 6.68291524e-02f, 6.31317645e-02f, 1.11465707e-01f, 7.74081275e-02f, 4.02579829e-02f, 8.00684616e-02f, -2.97350716e-02f, 2.70397719e-02f, 1.45333722e-01f,
  1.66380815e-02f, 8.90888944e-02f, -1.40878260e-01f, 6.69859052e-02f, 9.42136720e-03f, 1.38442293e-01f, -1.59350634e-02f, 1.42148659e-02f, -2.35823840e-02f, 1.75525829e-01f,
  -4.43392135e-02f, -1.05836883e-01f, -9.43608116e-03f, -9.09187049e-02f, -4.20477241e-02f, -1.74073540e-02f, -3.26130278e-02f, -8.20559263e-02f, -8.33824500e-02f, -1.08571379e-02f,
  -4.76660170e-02f, 8.14951658e-02f, 4.83898111e-02f, 1.29811922e-02f, -7.51497447e-02f, -4.74838950e-02f, 3.37171517e-02f, -1.06495075e-01f, -6.34642737e-03f, -3.85515881e-03f,
  -7.70199224e-02f, 8.38403706e-04f, 6.00414909e-02f, 8.43712315e-02f, 1.76852681e-02f, -6.28172830e-02f, -1.44115128e-02f, -1.33434698e-01f, -3.20023653e-04f, -1.10954478e-01f,
  1.54436871e-01f, -2.27226019e-02f, 2.77394176e-01f, 7.08692372e-02f, 6.43671453e-02f, 1.19521931e-01f, 1.13099530e-01f, -3.96107644e-05f, 3.81692522e-03f, -1.27660409e-02f,
  8.07527676e-02f, 6.22279793e-02f, 5.66807948e-02f, 8.45458657e-02f, 8.41903239e-02f, 6.17749877e-02f, 3.25459465e-02f, -7.12437108e-02f, 2.18725614e-02f, 5.09009324e-02f,
  2.69527305e-02f, -1.94710505e-03f, -3.46939489e-02f, 9.61226691e-03f, 3.49245220e-02f, -8.69724080e-02f, -3.26131918e-02f, 5.34065627e-02f, -5.57348393e-02f, -6.70810342e-02f,
  -4.72262323e-01f, -3.24916422e-01f, 1.06183209e-01f, -7.96181783e-02f, -4.13797870e-02f, -1.14743501e-01f, -2.87136376e-01f, -1.17680483e-01f, -5.57781495e-02f, -1.43787205e-01f,
  1.26534447e-01f, 3.53613973e-01f, 2.65897483e-01f, 1.72302336e-01f, -9.15662036e-04f, -1.26284808e-01f, -2.31047705e-01f, -1.33082103e-02f, 2.32725307e-01f, 8.81375596e-02f,
  7.10981339e-02f, -1.08371548e-01f, -5.25120646e-02f, 6.88101724e-02f, -1.74467534e-01f, 1.92371294e-01f, -4.45764363e-02f, -1.75380171e-03f, -4.79592420e-02f, -1.86797261e-01f,
  2.25080013e-01f, -2.39933640e-01f, 1.52686700e-01f, -4.40327683e-03f, -9.93849803e-03f, -1.00372776e-01f, -3.90792377e-02f, -6.40997961e-02f, -9.47086364e-02f, -7.23420456e-02f,
  -3.57511491e-02f, -1.71538908e-02f, -8.59820396e-02f, -9.62585956e-02f, -7.43480399e-02f, -1.08466648e-01f, -1.55369148e-01f, -1.34389997e-01f, -7.65774846e-02f, -6.39455542e-02f,
  -3.18875387e-02f, -2.50905715e-02f, -9.80589017e-02f, -5.29682785e-02f, -3.09794247e-02f, -2.72508059e-03f, -8.22335035e-02f, -1.55656084e-01f, 4.82709631e-02f, -2.15843350e-01f,
  -8.75311252e-03f, 1.60557762e-01f, 2.77643763e-02f, 3.77408937e-02f, -1.18728377e-01f, 8.12822059e-02f, 2.44501140e-02f, -5.26112504e-02f, 2.84426510e-02f, 1.44966198e-02f,
  6.38905838e-02f, 3.20691504e-02f, -2.14042142e-02f, -6.64883405e-02f, 1.54237732e-01f, -3.56640033e-02f, -5.06837331e-02f, -4.26157005e-02f, -1.84956882e-02f, -1.28633445e-02f,
  3.34471203e-02f, -7.80586302e-02f, -1.68132503e-02f, 5.50386906e-02f, -6.68092594e-02f, 3.30267921e-02f, 5.39469086e-02f, 3.00572533e-02f, 1.16265967e-01f, -4.38930541e-02f,
  3.85457464e-02f, 1.14066578e-01f, 2.21738350e-02f, -3.10151633e-02f, -7.12056234e-02f, 7.69852996e-02f, 5.07286489e-02f, -7.41154626e-02f, -5.97644672e-02f, -1.34890471e-02f,
  -3.32529098e-02f, 9.54941474e-03f, -6.09328225e-02f, 2.83529442e-02f, -1.27460705e-02f, 9.57403556e-02f, -4.13313769e-02f, 1.46248247e-02f, -7.79892039e-03f, -7.81195387e-02f,
  -1.08202770e-01f, -5.73614947e-02f, -2.14871783e-02f, 1.90422926e-02f, -2.06927247e-02f, 9.06412750e-02f, 5.05239479e-02f, 2.27447003e-02f, 9.62563455e-02f, -1.03192218e-01f,
  -3.32837999e-01f, -1.87208597e-02f, 2.39463761e-01f, -3.97382267e-02f, 6.57653287e-02f, 6.12155013e-02f, -1.34566380e-02f, 1.79783553e-02f, -1.05695702e-01f, 9.22758207e-02f,
  3.57070118e-02f, -9.86104459e-02f, -7.29820356e-02f, 1.20060056e-01f, 5.28003201e-02f, 6.34095892e-02f, 2.88440883e-01f, 1.36254385e-01f, 8.16710442e-02f, 4.40426208e-02f,
  -3.72871272e-02f, -9.33359563e-02f, 6.21839687e-02f, 9.65602770e-02f, -8.26773122e-02f, -1.19333871e-01f, 2.18412168e-02f, -2.34568268e-02f, 1.23934537e-01f, 1.77562699e-01f,
  -5.18243909e-02f, 1.15180776e-01f, 1.27138272e-01f, 7.60362521e-02f, -7.23625533e-03f, -6.58530220e-02f, 1.07064061e-01f, 9.11986381e-02f, 6.33219257e-02f, -2.29191333e-02f,
  9.86874476e-02f, 9.03408006e-02f, 4.74404618e-02f, 1.00036234e-01f, -2.44895741e-02f, 1.18796326e-01f, 1.75354257e-01f, 1.37144253e-01f, 7.84367695e-02f, 1.24141939e-01f,
  1.58812582e-01f, 1.85410812e-01f, 1.73283443e-01f, 1.70208454e-01f, 1.34720594e-01f, 1.03203863e-01f, 9.24010798e-02f, 6.07995950e-02f, 1.69940721e-02f, 3.13315950e-02f,
  3.90377380e-02f, -3.19750719e-02f, -9.85894054e-02f, -7.12480173e-02f, -7.57041872e-02f, -5.25711477e-02f, -1.00964673e-01f, -5.22541516e-02f, -8.63279179e-02f, -2.03650147e-02f,
  -1.22248949e-02f, -9.44156572e-02f, -1.00348564e-02f, -7.61616901e-02f, -4.67318259e-02f, 2.85027139e-02f, -2.95959730e-02f, -1.13032579e-01f, -9.57840607e-02f, -1.36331126e-01f,
  -8.98889750e-02f, -6.59511462e-02f, -4.11018692e-02f, -1.18416302e-01f, 7.26181641e-02f, 2.23295335e-02f, -1.01948291e-01f, -4.25343327e-02f, -1.07570641e-01f, -1.00644305e-01f,
  -1.61570430e-01f, 1.86556563e-01f, 2.60749720e-02f, -7.54535198e-02f, -9.75205854e-04f, -2.09125988e-02f, 7.90432021e-02f, 2.86640525e-02f, 8.44283029e-03f, 3.77358869e-02f,
  -3.29156779e-02f, -2.30735689e-02f, 1.24542877e-01f, 1.62869275e-01f, 1.03090115e-01f, 1.40405312e-01f, 1.62773933e-02f, -5.06178103e-02f, -2.12816410e-02f, 1.64492354e-02f,
  4.01838943e-02f, 8.53993278e-03f, -6.55421317e-02f, -2.85293180e-02f, -3.72503027e-02f, -2.80223750e-02f, -5.71178794e-02f, 9.45062190e-03f, -1.53400924e-03f, -1.72427580e-01f,
  2.73059487e-01f, 1.23941123e-01f, 3.14895138e-02f, 1.32302269e-01f, 1.57600772e-02f, -1.89416572e-01f, -1.52826026e-01f, -8.08427855e-02f, -2.28559989e-02f, 6.54520541e-02f,
  -6.31242543e-02f, -6.48542792e-02f, -1.61666930e-01f, -1.30215704e-01f, -1.28208786e-01f, 7.99525380e-02f, 1.48228988e-01f, -9.99267176e-02f, -3.36326033e-01f, -2.37978041e-01f,
  -8.37940909e-03f, -3.99328768e-02f, 7.30693713e-02f, -5.80158718e-02f, 7.79746324e-02f, -1.17113300e-01f, 7.87976235e-02f, 2.28201106e-01f, 1.58975665e-02f, 3.03666234e-01f,
  6.40956387e-02f, 9.83095840e-02f, -1.23057954e-01f, -2.83506423e-01f, -9.91598070e-02f, -5.76158054e-02f, -1.14545196e-01f, -1.56046540e-01f, -1.67164102e-01f, -1.26148254e-01f,
  -2.10592583e-01f, -9.73155126e-02f, -1.42409950e-01f, -9.32339802e-02f, -2.85094857e-01f, -2.12763891e-01f, -1.89029962e-01f, -2.05652222e-01f, -1.69683874e-01f, -1.73372984e-01f,
  -8.81888643e-02f, -1.26228884e-01f, -1.11000016e-01f, -1.51752412e-01f, -1.89380392e-01f, -2.38730744e-01f, -1.84488371e-01f, -1.69553488e-01f, -2.53935456e-01f, -1.29764318e-01f,
  -1.17618673e-01f, 9.35593620e-02f, 9.28337723e-02f, 1.00123964e-01f, 7.06351325e-02f, 6.24042563e-02f, -4.76574339e-03f, 4.18262091e-03f, 7.75186643e-02f, 3.81640792e-02f,
  -6.31017797e-03f, 6.74913824e-02f, 8.30532014e-02f, -1.21878628e-02f, -5.42704538e-02f, 1.57876432e-01f, 1.05393678e-01f, 1.06116682e-01f, 5.82226776e-02f, 5.42485341e-02f,
  -1.58965476e-02f, 1.35085285e-01f, 1.35281578e-01f, -3.66345011e-02f, 1.10200189e-01f, 7.75427371e-02f, 6.05741441e-02f, -2.14007706e-03f, 5.12892976e-02f, 1.47742435e-01f,
  -4.16250557e-01f, -1.51557699e-01f, -7.83856362e-02f, -1.58902958e-01f, -1.24642543e-01f, -1.12557247e-01f, -5.21311574e-02f, -6.71316013e-02f, -1.57035084e-03f, -2.51571815e-02f,
  -2.54338868e-02f, -1.60400391e-01f, -3.20432335e-02f, -1.66717306e-01f, -1.64930910e-01f, -2.45222941e-01f, -1.63085505e-01f, -9.77386236e-02f, -1.93627462e-01f, -2.47044608e-01f,
  -2.47263700e-01f, -2.58347392e-01f, -1.21691465e-01f, -1.17852628e-01f, -2.00853631e-01f, -2.54508793e-01f, -1.50504008e-01f, -1.50596634e-01f, -2.62441933e-01f, -2.17232659e-01f
};

// L0_fan_Wp_bar (Shape: 26 x 120)
const int L0_fan_Wp_bar_rows = 26;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  6.36375070e-01f, -3.98779362e-01f, -4.22655523e-01f, -6.00409023e-02f, -2.14634985e-01f, -1.94405794e-01f, -3.84653062e-01f, -3.19591761e-02f, -1.03332829e-02f, -3.39686841e-01f,
  -2.88431674e-01f, 2.02011183e-01f, -1.22549281e-01f, -3.51611944e-03f, 1.12649821e-01f, -3.13411355e-01f, -3.85032415e-01f, 1.36377826e-01f, 4.51245874e-01f, 1.60145879e-01f,
  8.00553057e-03f, 6.32766336e-02f, 2.62605667e-01f, 4.59445938e-02f, -2.45451033e-01f, -4.29161415e-02f, -3.90251458e-01f, -1.73375428e-01f, -2.31006235e-01f, -4.47564095e-01f,
  -4.77914631e-01f, -1.71220936e-02f, -4.06647809e-02f, 5.92525117e-02f, -1.44820213e-01f, -1.02132196e-02f, 6.68422505e-03f, 5.24557643e-02f, -1.62640661e-02f, -9.96637437e-03f,
  -4.04456221e-02f, 9.46539491e-02f, 1.98411584e-01f, 1.75967775e-02f, -1.09946053e-03f, -4.55008401e-03f, 7.38359839e-02f, 1.57827333e-01f, 4.05243151e-02f, -7.20264092e-02f,
  -5.63320443e-02f, 9.01124328e-02f, 2.30436623e-02f, -2.92067248e-02f, 4.98557985e-02f, 1.09026387e-01f, -1.25645474e-01f, 1.72384121e-02f, 8.56359489e-03f, -1.42499670e-01f,
  -1.15994297e-01f, -2.34012213e-02f, -3.60103371e-03f, 1.51640743e-01f, 1.25328481e-01f, 3.96402851e-02f, 2.05083657e-02f, -5.01852036e-02f, 3.48255523e-02f, -6.91227894e-03f,
  1.69116370e-02f, 3.87066742e-03f, -1.15633253e-02f, -1.41094118e-01f, -7.12267384e-02f, 1.92886461e-02f, 5.69472462e-02f, -6.38242662e-02f, -1.19989114e-02f, 4.31301855e-02f,
  5.94124570e-02f, 2.82477308e-02f, -4.39092070e-02f, 4.31438908e-02f, -6.78885803e-02f, -1.16464552e-02f, 2.44364478e-02f, -5.04314937e-02f, -1.10779405e-02f, 4.12229858e-02f,
  -4.23134975e-02f, 9.67921540e-02f, -1.16606645e-01f, 3.47425826e-02f, 3.83128673e-02f, -3.37088928e-02f, -2.25807920e-01f, 9.53078121e-02f, 1.38448700e-01f, -9.64243487e-02f,
  5.95531240e-03f, 1.14485390e-01f, -8.00665244e-02f, -9.44841057e-02f, 9.44417343e-02f, 2.39128638e-02f, -7.36780688e-02f, 4.04657982e-02f, 4.76661138e-02f, -1.51011035e-01f,
  -1.16678603e-01f, 5.33821322e-02f, 1.52351305e-01f, -8.51727352e-02f, -4.47709188e-02f, 1.86827496e-01f, -4.63165157e-02f, 6.06654361e-02f, 2.43137315e-01f, 9.39845946e-03f,
  -1.12747572e-01f, -1.99125022e-01f, 1.09153442e-01f, 2.53430694e-01f, 3.20819765e-01f, 1.72805592e-01f, 1.05498612e-01f, 2.64470633e-02f, 1.15655005e-01f, 4.49804962e-02f,
  1.29137471e-01f, 2.77636975e-01f, 2.28423879e-01f, 1.78070202e-01f, 1.25581443e-01f, 8.04597139e-02f, 1.66521803e-01f, 8.71692970e-02f, 5.01544587e-02f, 1.82279661e-01f,
  7.76505917e-02f, -1.87983230e-01f, -3.07942152e-01f, 6.73434325e-03f, 1.34037407e-02f, 1.98157996e-01f, 5.44343926e-02f, -7.21489415e-02f, 3.38411108e-02f, -1.21001359e-02f,
  2.14145198e-01f, -1.12328403e-01f, 1.84170172e-01f, 1.52384890e-02f, -1.41624168e-01f, -1.81766629e-01f, 5.03213294e-02f, 1.80298351e-02f, -5.07038832e-02f, 5.06578349e-02f,
  -4.81920168e-02f, -9.90100950e-02f, -1.22856103e-01f, -1.56922638e-01f, -1.42117366e-01f, -1.82705000e-01f, -2.69897819e-01f, -3.78111601e-02f, 1.02154523e-01f, 2.12874226e-02f,
  -1.02518633e-01f, 2.66975202e-02f, 1.27796575e-01f, 1.38340946e-02f, 6.30424172e-02f, 9.15383026e-02f, 3.08222021e-03f, 2.87699942e-02f, 3.44774760e-02f, -8.78287330e-02f,
  2.80078262e-01f, 9.05246288e-02f, 6.28589764e-02f, 1.02543764e-01f, -1.06743993e-02f, 9.45473239e-02f, -2.63164472e-02f, 2.59805229e-02f, -4.31246916e-03f, -8.21108148e-02f,
  5.41451201e-02f, 1.83378950e-01f, 4.24959175e-02f, 2.52007768e-02f, 3.83286700e-02f, -6.44816980e-02f, 3.96037363e-02f, -5.60900234e-02f, -2.64901742e-02f, -2.89309751e-02f,
  -4.64399457e-02f, -5.59534840e-02f, -9.47428197e-02f, -1.15886308e-01f, -5.09895831e-02f, 4.90836017e-02f, -3.59012447e-02f, -8.07721540e-02f, -1.06214948e-01f, 1.51611085e-03f,
  2.06310973e-01f, 1.56150147e-01f, 1.18468449e-01f, -5.35311736e-03f, -6.28066137e-02f, -5.79395890e-02f, 1.94204926e-01f, 4.31191660e-02f, 8.36882181e-03f, 7.15596676e-02f,
  1.14594884e-02f, -2.72514634e-02f, -7.89648443e-02f, -1.85785964e-01f, -1.99008659e-02f, -1.47862792e-01f, -3.36303860e-02f, 1.13921180e-01f, 3.05901915e-02f, 1.04863949e-01f,
  -1.07158313e-03f, 5.02134860e-02f, 1.40116259e-01f, 2.10056111e-01f, 1.04935743e-01f, 3.22194137e-02f, -6.98568746e-02f, 6.10881262e-02f, -6.65302128e-02f, -5.35904840e-02f,
  1.93429515e-01f, 3.21220964e-01f, -3.13730210e-01f, 2.94222921e-01f, -1.86391547e-01f, -3.59873533e-01f, -4.08956170e-01f, -5.74862622e-02f, 2.60610521e-01f, 1.46698967e-01f,
  3.17383073e-02f, 4.00101859e-03f, -8.50514919e-02f, -1.42410234e-01f, -4.23466623e-01f, -2.63176471e-01f, -3.10017318e-01f, -4.80416566e-01f, -6.56896651e-01f, -3.35980535e-01f,
  -1.38449550e-01f, -1.21659257e-01f, -5.60252033e-02f, -9.37054902e-02f, 2.34809950e-01f, 6.38075024e-02f, 1.82803661e-01f, -1.56528577e-02f, -1.29221991e-01f, 2.50572503e-01f,
  -3.19710195e-01f, -6.94257990e-02f, -1.26412570e-01f, -2.36419216e-02f, 8.77346992e-02f, 1.55652054e-02f, -9.66872051e-02f, 7.16739297e-02f, 6.26731589e-02f, -7.70851970e-02f,
  -9.75901540e-03f, 1.26507636e-02f, 1.18354382e-02f, -3.06394976e-02f, -9.28680897e-02f, -1.20030724e-01f, 6.72159344e-02f, -1.61403984e-01f, -1.20675571e-01f, 3.02469339e-02f,
  9.12082791e-02f, -1.65250480e-01f, -2.02643514e-01f, 9.30888020e-03f, -2.84424759e-02f, -1.48850352e-01f, 8.81683379e-02f, -4.66197170e-02f, 5.28390333e-02f, 3.25598389e-01f,
  4.07730900e-02f, -1.48622375e-02f, 3.72883119e-02f, 1.28288120e-01f, 8.56208503e-02f, 1.11149453e-01f, -6.50908649e-02f, 5.57878092e-02f, -7.89943486e-02f, 6.37203977e-02f,
  6.29459247e-02f, 3.56678758e-03f, 3.51680033e-02f, -5.43150445e-03f, 3.24316956e-02f, -9.04827565e-02f, 1.25883548e-02f, 5.87119870e-02f, 1.49755348e-02f, -3.33698876e-02f,
  7.98257664e-02f, -2.69918013e-02f, 5.38905188e-02f, -2.23950017e-02f, -3.44334543e-02f, 9.53615382e-02f, -1.28046107e-02f, -4.62873839e-02f, 6.46366701e-02f, -4.80967090e-02f,
  3.27306330e-01f, -3.50192875e-01f, 2.50241328e-02f, -3.94975804e-02f, 3.46011855e-02f, 9.88897905e-02f, 1.45708308e-01f, 1.19581632e-01f, 1.68137148e-01f, 4.66261096e-02f,
  3.01861577e-02f, 6.96320161e-02f, 3.33384946e-02f, 4.47419472e-02f, 1.64292697e-02f, -9.37896036e-03f, 1.07771799e-01f, -8.58345404e-02f, -2.78783906e-02f, 1.66659966e-01f,
  1.47891164e-01f, 6.56405240e-02f, 7.13219345e-02f, 1.00634292e-01f, 2.06343587e-02f, -5.09284288e-02f, 1.34759814e-01f, 3.48373912e-02f, -9.19904783e-02f, 3.09918165e-01f,
  2.24786803e-01f, -1.40468895e-01f, -3.62123162e-01f, 1.41990911e-02f, -2.89694071e-01f, -1.12762466e-01f, -1.98725134e-01f, 1.38775939e-02f, 9.53320414e-04f, -2.21666947e-01f,
  -1.31529033e-01f, 6.46085590e-02f, 1.21569201e-01f, -4.96748127e-02f, -2.82291528e-02f, -8.40852782e-02f, -2.40419611e-01f, -1.24473266e-01f, 1.50739066e-02f, -2.23126113e-01f,
  3.40257445e-03f, 5.61678000e-02f, 6.78852573e-02f, -2.86321901e-03f, -3.12083284e-03f, 3.29819471e-02f, -1.34218067e-01f, -1.49359377e-02f, -5.97601086e-02f, -1.57000795e-01f,
  1.90724790e-01f, -1.01878501e-01f, -2.02893168e-01f, -1.05812447e-02f, -4.28490788e-02f, -1.31668989e-02f, -9.28030685e-02f, 2.53442153e-02f, -6.74519911e-02f, -1.11713938e-01f,
  -1.11225415e-02f, -7.21339360e-02f, 1.26637608e-01f, -1.46040702e-02f, 3.90721895e-02f, 8.16199556e-02f, 7.59697184e-02f, -7.44408593e-02f, -1.54802501e-01f, -4.03603651e-02f,
  -4.15974520e-02f, -2.19807878e-01f, -2.81038415e-02f, -3.78530920e-02f, -2.00008042e-02f, 2.84286086e-02f, 3.34394015e-02f, -4.90721799e-02f, -7.56944194e-02f, 1.57429446e-02f,
  -6.53188974e-02f, 5.34510389e-02f, -5.55362627e-02f, -2.29557082e-02f, -2.44549848e-02f, 3.16627994e-02f, -5.36952093e-02f, 9.72767994e-02f, 9.41021889e-02f, 1.30056543e-02f,
  -1.13758780e-01f, -2.56306846e-02f, -1.93305891e-02f, -1.01550885e-01f, 4.37684497e-03f, -8.93847202e-04f, -4.46126284e-03f, 7.47491792e-02f, 2.69698612e-02f, -1.86176505e-02f,
  -6.82695806e-02f, -5.40897287e-02f, -1.38079491e-03f, -1.01086162e-01f, -1.85969099e-01f, 3.92295979e-02f, -8.37248266e-02f, 4.33589518e-03f, 3.80444676e-02f, -1.18808992e-01f,
  3.57027441e-01f, -3.14121395e-01f, 1.45737365e-01f, -5.47671467e-02f, -1.79918241e-02f, -1.89240336e-01f, -4.60641459e-02f, -1.07044943e-01f, 1.72928628e-02f, -8.63186866e-02f,
  -8.12504366e-02f, -4.96247746e-02f, 7.50867799e-02f, 4.28517945e-02f, 1.09955549e-01f, -8.19577426e-02f, 1.16317116e-01f, 1.03343517e-01f, -1.05026476e-01f, 2.45599318e-02f,
  -3.02499570e-02f, 8.01122859e-02f, 3.12853336e-01f, 8.62596780e-02f, 1.28189355e-01f, 1.24278180e-01f, 8.99862275e-02f, 8.29550102e-02f, 1.00621872e-01f, 2.46195942e-01f,
  5.43886542e-01f, -4.12195504e-01f, -2.40687747e-02f, 1.32673219e-01f, -8.30096100e-03f, 1.63719743e-01f, -1.25632450e-01f, 2.35927813e-02f, 8.04759338e-02f, -1.05387315e-01f,
  -5.24576195e-02f, 3.28080356e-01f, 1.89535573e-01f, 1.81353405e-01f, 2.44208321e-01f, -1.71690017e-01f, -2.72910267e-01f, 1.33160457e-01f, 4.85031456e-01f, 1.82013780e-01f,
  -1.33397385e-01f, -1.28932461e-01f, 5.13999909e-02f, -7.41046527e-03f, -3.62675935e-01f, -1.96614768e-03f, -2.80448496e-01f, -1.05179973e-01f, -1.15022294e-01f, -4.17268038e-01f,
  1.29461259e-01f, -1.28632143e-01f, 9.04126987e-02f, -1.62324198e-02f, 3.23613100e-02f, 2.40457263e-02f, 2.40489915e-02f, -1.47547558e-01f, -1.29855918e-02f, -6.39667064e-02f,
  -2.07355227e-02f, -1.72432333e-01f, 1.02328546e-01f, -7.34794140e-02f, -1.52323052e-01f, 6.66278675e-02f, -2.44351953e-01f, -9.03299078e-02f, 1.30589809e-02f, 4.81376089e-02f,
  -1.40707821e-01f, -1.09921671e-01f, 1.16192410e-02f, 2.33872235e-02f, -3.78009677e-02f, 1.00948364e-01f, -1.42638862e-01f, -1.05963826e-01f, 9.00968760e-02f, -1.45319447e-01f,
  -1.44724129e-02f, -3.67505811e-02f, 1.65618751e-02f, -2.24188250e-02f, 1.76462956e-04f, -2.06411257e-02f, -9.15220156e-02f, -4.61596102e-02f, 2.94610597e-02f, -3.44465971e-02f,
  1.62133258e-02f, -8.56696218e-02f, 9.01562572e-02f, 2.64821853e-02f, 4.57750808e-04f, -1.37808725e-01f, 3.79885919e-02f, -1.99870616e-02f, 9.11556557e-03f, 2.56841499e-02f,
  1.23905338e-01f, 4.78222519e-02f, -1.57159753e-02f, 1.61576476e-02f, 2.95276772e-02f, 2.31170803e-02f, 1.53634101e-02f, 3.11046019e-02f, 4.30606157e-02f, 1.47199687e-02f,
  -7.89280459e-02f, 1.32576510e-01f, 8.82768258e-02f, 7.55131543e-02f, -6.33199289e-02f, 8.91654715e-02f, 1.86239891e-02f, -2.16711294e-02f, 1.22432634e-02f, 7.57220713e-03f,
  2.95787528e-02f, 1.16330639e-01f, -6.09819181e-02f, -1.27205281e-02f, -4.26917374e-02f, 5.72375618e-02f, -4.09387872e-02f, 8.88695195e-02f, -5.67594990e-02f, 1.02395685e-02f,
  -1.06083274e-01f, -2.14813892e-02f, 1.82961568e-01f, -6.97031897e-03f, -1.80104487e-02f, 1.79010853e-01f, 4.40631621e-02f, 5.03702424e-02f, 2.31506124e-01f, -2.37991614e-03f,
  3.43547106e-01f, -4.93968651e-02f, 3.60794514e-01f, 4.72766645e-02f, 3.58327985e-01f, 4.25585032e-01f, 4.65848655e-01f, 1.18581332e-01f, 6.56761602e-02f, -4.31158170e-02f,
  -2.37604305e-01f, -3.10957164e-01f, -3.66346985e-01f, -2.79629946e-01f, -1.03684135e-01f, 4.94384393e-02f, 5.60351126e-02f, 1.62484467e-01f, 2.50657797e-01f, 1.29953459e-01f,
  -3.00480425e-02f, 1.64113581e-01f, 7.86896572e-02f, -6.83112890e-02f, -2.63742488e-02f, -1.64595872e-01f, 1.28565371e-01f, 1.84211001e-01f, -8.55322704e-02f, -2.63027400e-01f,
  -2.17223674e-01f, 1.19910583e-01f, -9.79330912e-02f, -6.71974421e-02f, 1.01186946e-01f, -2.04199255e-02f, -2.72787791e-02f, 9.18224305e-02f, -1.41942576e-02f, -1.12895876e-01f,
  2.51192991e-02f, 6.94824010e-02f, 9.13726985e-02f, 1.09188169e-01f, 1.88429847e-01f, 5.06803878e-02f, -6.61795214e-02f, -2.36684326e-02f, -7.07196146e-02f, -4.95889522e-02f,
  -1.27271026e-01f, 1.74171880e-01f, 1.08604636e-02f, -1.18026035e-02f, 3.18687893e-02f, -7.36305639e-02f, 1.25513539e-01f, -2.61184201e-02f, 8.55192840e-02f, -1.95631906e-02f,
  1.27228633e-01f, 5.75169027e-02f, 6.04799837e-02f, 2.01462135e-02f, 2.97483075e-02f, 5.44229895e-02f, 4.24438082e-02f, 1.00028785e-02f, 2.60340478e-02f, 9.30972304e-03f,
  4.57233675e-02f, -6.77589774e-02f, 1.33333297e-03f, 5.12097636e-03f, -1.16312854e-01f, 6.92531466e-02f, -5.11129051e-02f, -1.47430182e-01f, -2.92169470e-02f, -2.99029648e-02f,
  -6.16426989e-02f, 5.52633516e-02f, 7.46625885e-02f, 6.72910316e-03f, -4.65985499e-02f, -8.08761790e-02f, -7.56520331e-02f, -1.25238732e-01f, -2.67825462e-02f, 1.06707411e-02f,
  -5.44375479e-01f, -1.26417786e-01f, -2.10444748e-01f, -6.62471801e-02f, 1.17663763e-01f, -4.34059091e-02f, -1.14212446e-01f, -6.96391910e-02f, 1.93825755e-02f, -7.04112230e-03f,
  1.54901326e-01f, -1.07751610e-02f, -3.46384384e-02f, 7.97346048e-03f, 1.30346045e-01f, 5.45194484e-02f, -4.14804853e-02f, -5.63509855e-03f, -5.73970117e-02f, -2.19451115e-02f,
  2.59829741e-02f, 1.06500432e-01f, 7.48937204e-02f, 2.08589644e-03f, -4.32230271e-02f, 8.67458582e-02f, 9.56459492e-02f, 1.58938408e-01f, 1.72119603e-01f, 1.58215195e-01f,
  -7.79326737e-01f, 1.54532358e-01f, -1.51408628e-01f, -6.01425827e-01f, -2.50813425e-01f, -4.28792275e-02f, 9.47547052e-03f, -3.28441374e-02f, -2.81602085e-01f, -1.79444313e-01f,
  1.11593381e-01f, 4.03600000e-02f, -9.78974327e-02f, 1.17344707e-01f, 4.63154204e-02f, -2.19933048e-01f, -4.14573669e-01f, -2.73503870e-01f, 6.21891767e-02f, 1.98664397e-01f,
  -2.04007998e-02f, -3.10252637e-01f, -3.04759353e-01f, -4.91119027e-02f, -1.09200977e-01f, -8.93052891e-02f, -1.39566824e-01f, -1.97700694e-01f, 1.52689502e-01f, -1.05795726e-01f,
  2.58048832e-01f, -2.25934744e-01f, 2.36885604e-02f, -1.98289063e-02f, -5.48522137e-02f, -4.09079939e-02f, 2.94781686e-03f, -1.16336249e-01f, 6.92895334e-03f, -1.44580767e-01f,
  -1.82734206e-01f, -3.10693663e-02f, -1.22725265e-02f, 7.18067586e-02f, -5.53036667e-03f, -1.14795476e-01f, -1.11861952e-01f, -1.52629986e-01f, 1.02271631e-01f, 1.63696557e-01f,
  9.89633650e-02f, -3.22912522e-02f, 9.24519170e-03f, 4.28364687e-02f, 4.07854468e-02f, -1.51438728e-01f, 1.35383576e-01f, 6.45050257e-02f, 8.64857957e-02f, 4.64182794e-02f,
  9.21678822e-03f, 8.42591748e-02f, -1.65088978e-02f, 1.28966615e-01f, -2.97509618e-02f, -3.25529762e-02f, -2.16037296e-02f, 7.75641799e-02f, 4.67033572e-02f, 1.18635967e-01f,
  -2.60426067e-02f, 9.78339463e-03f, -4.16347273e-02f, -1.05173066e-01f, -5.66777540e-03f, -6.54902309e-02f, -5.94289340e-02f, 1.77512243e-02f, 3.27825621e-02f, -4.14543673e-02f,
  1.69790164e-03f, -5.92637844e-02f, -9.22077671e-02f, 1.23898916e-01f, -2.11564582e-02f, -8.74909014e-02f, -7.48326033e-02f, 1.56357378e-01f, -2.25549117e-02f, -1.37040690e-01f,
  1.08748436e-01f, -1.66963011e-01f, -1.17270149e-01f, 1.06028646e-01f, -9.83460546e-02f, -5.32462075e-02f, -1.82798039e-02f, 7.83963054e-02f, -7.46407136e-02f, 4.02373001e-02f,
  1.45816915e-02f, 2.91194003e-02f, 3.36337974e-03f, 7.96396211e-02f, -8.62736907e-03f, 6.59067035e-02f, -9.07565095e-03f, -1.04710333e-01f, 1.28656983e-01f, 7.71811083e-02f,
  7.84947276e-02f, 8.83859769e-02f, 4.98899482e-02f, 3.46503109e-02f, 1.30592361e-01f, -2.03877483e-02f, 1.86876893e-01f, 1.10667266e-01f, 1.10008202e-01f, 1.79687917e-01f,
  1.72735006e-01f, 6.46111742e-02f, -1.40673399e-01f, 6.13236837e-02f, -1.00048155e-01f, -2.66489476e-01f, -2.73241580e-01f, -1.42033279e-01f, 6.58103004e-02f, -6.71430212e-03f,
  -7.57288411e-02f, 2.63960660e-01f, 4.14892025e-02f, 4.10975628e-02f, -5.94368298e-03f, -9.34871437e-04f, 1.33989319e-01f, 8.28768238e-02f, -9.70249921e-02f, 8.08616877e-02f,
  3.44566345e-01f, 1.17436573e-01f, 8.81444141e-02f, 2.56939977e-03f, 3.88989687e-01f, 2.29903400e-01f, 4.36073169e-02f, 1.20624535e-01f, 1.37947440e-01f, 6.86530709e-01f,
  1.10383451e-01f, -1.47919387e-01f, -4.26409580e-02f, 1.19554907e-01f, 1.51972026e-01f, 4.84491847e-02f, 5.96241578e-02f, 3.42202708e-02f, -1.86312012e-02f, -2.98844203e-02f,
  1.05755396e-01f, 1.37911990e-01f, -4.86107841e-02f, 7.61997029e-02f, -6.92076087e-02f, 1.72897521e-02f, 2.23147236e-02f, -1.60542671e-02f, -2.41271053e-02f, 4.41984609e-02f,
  1.51761239e-02f, -1.21314287e-01f, -2.92266965e-01f, -1.91574812e-01f, -1.73853472e-01f, 1.03833534e-01f, 9.51414835e-03f, -3.90757732e-02f, -1.80293038e-01f, 1.62503552e-02f,
  4.97177541e-02f, 3.83745953e-02f, 1.85846969e-01f, 1.98436715e-02f, 1.01967990e-01f, -2.48934235e-02f, 1.32499002e-02f, 1.36211082e-01f, -1.90775171e-02f, 1.27028376e-01f,
  -1.10518023e-01f, -1.01191467e-02f, -7.46539682e-02f, -1.56556800e-01f, -1.04171254e-01f, 4.28334661e-02f, -3.46886888e-02f, -7.50145167e-02f, -5.45571744e-02f, 7.55612403e-02f,
  -1.16448980e-02f, -5.01465723e-02f, 3.69489342e-02f, -4.20848926e-04f, -8.40329230e-02f, -5.31410053e-02f, 1.00893425e-02f, 1.30262718e-01f, -1.81545652e-02f, -8.02403018e-02f,
  -9.99852642e-02f, -2.66031891e-01f, 1.61292374e-01f, -1.21935236e-03f, 5.74341528e-02f, -6.16472680e-03f, 6.31437972e-02f, 5.23703247e-02f, 9.39022377e-03f, -4.59525101e-02f,
  2.27122549e-02f, -5.01434952e-02f, -8.08260962e-02f, -6.35816306e-02f, 3.44084315e-02f, 5.36056096e-03f, 9.15400013e-02f, -7.40211755e-02f, -7.12570548e-02f, -2.87598036e-02f,
  1.38158782e-03f, -2.01279253e-01f, -2.55170494e-01f, -1.53230876e-01f, -5.43953590e-02f, -5.84315211e-02f, -1.10614695e-01f, -1.58931706e-02f, -8.98851156e-02f, -1.09926209e-01f,
  2.24984005e-01f, -1.39026225e-01f, 3.08153071e-02f, 2.36140583e-02f, 3.46887782e-02f, -9.54628214e-02f, -1.78279728e-01f, -1.62704155e-01f, -9.09845755e-02f, 2.00285986e-02f,
  1.79560468e-01f, 1.66337386e-01f, 1.95470661e-01f, 1.45042196e-01f, 1.47862136e-01f, -1.14382483e-01f, -9.13504735e-02f, -4.83188368e-02f, 1.79327846e-01f, 7.24237189e-02f,
  -1.64427012e-01f, -1.85585007e-01f, -1.09721288e-01f, -2.80999746e-02f, -6.18896671e-02f, -9.61215515e-03f, -1.42176062e-01f, -1.56492159e-01f, -1.27301216e-01f, -1.24795936e-01f,
  2.82355905e-01f, 1.51673555e-01f, 1.65621132e-01f, 4.15600045e-03f, -8.38171467e-02f, -5.13590723e-02f, 5.88523559e-02f, -5.86666130e-02f, -8.77999142e-02f, 1.86087713e-02f,
  -7.06756413e-02f, -8.34312756e-03f, -6.62556812e-02f, -6.93735853e-02f, -9.21668261e-02f, -5.87586053e-02f, -6.33946136e-02f, 1.02836736e-01f, 8.25699233e-03f, -6.56387880e-02f,
  1.61514897e-02f, 2.71533895e-02f, 8.72265473e-02f, -5.27332127e-02f, 8.14735368e-02f, 7.40722120e-02f, -6.24696128e-02f, 7.12099578e-03f, -2.33722571e-02f, 2.09597535e-02f,
  6.96769953e-02f, 6.86847940e-02f, -6.36903867e-02f, 4.67298031e-02f, 2.46794447e-02f, -7.75002465e-02f, 1.14564247e-01f, 1.18747931e-02f, 3.25155593e-02f, -4.77411635e-02f,
  -9.45940688e-02f, 5.98510951e-02f, 5.71621694e-02f, 1.58676831e-03f, -6.52574077e-02f, -5.65504134e-02f, -2.02514231e-02f, -3.28584276e-02f, 5.20845838e-02f, 9.76135023e-03f,
  -9.36031621e-03f, -5.13698049e-02f, -5.18339537e-02f, -1.08695254e-01f, -1.39295340e-01f, 1.25027701e-01f, -7.23050311e-02f, -1.15373857e-01f, -1.53168634e-01f, 5.51362820e-02f,
  -5.18113859e-02f, 3.39751184e-01f, 1.90354273e-01f, 1.39593437e-01f, -3.78389619e-02f, -9.23800841e-02f, 2.60043472e-01f, 6.28254861e-02f, 1.72042113e-03f, 6.45299703e-02f,
  -2.47893645e-03f, 4.86639403e-02f, -7.78698251e-02f, 4.67020012e-02f, -1.04096113e-02f, 2.75546480e-02f, -1.99009292e-02f, 1.25034839e-01f, 1.44536644e-01f, -5.01220077e-02f,
  -1.61965862e-01f, 1.38097657e-02f, 2.03017011e-01f, 6.18058108e-02f, 1.47696093e-01f, 1.58019707e-01f, 2.88177282e-02f, 2.61565428e-02f, 4.40337397e-02f, -1.34361446e-01f,
  -1.93222146e-02f, 8.71031955e-02f, -9.21921805e-03f, 3.27716321e-01f, 2.38085791e-01f, 1.54977143e-01f, 3.19611698e-01f, 1.37981772e-01f, 2.16382161e-01f, 2.35233545e-01f,
  2.02954024e-01f, 2.54019827e-01f, 2.36042976e-01f, 1.12692274e-01f, 1.08959258e-01f, 1.19456500e-01f, 7.73741677e-02f, 3.87379117e-02f, 1.45380214e-01f, 1.98366478e-01f,
  2.88793057e-01f, 1.36968505e-03f, -1.21769153e-01f, 7.56980777e-02f, 1.27095520e-01f, 1.76924318e-01f, 1.36158228e-01f, 4.30315658e-02f, -1.59228835e-02f, 2.57961720e-01f,
  -4.78581160e-01f, -4.08582240e-02f, -8.03278480e-03f, -1.36373471e-02f, -1.25330806e-01f, -1.31041557e-01f, -1.12425545e-02f, -1.94883533e-02f, -1.02005964e-02f, 4.98853810e-02f,
  2.13708710e-02f, -2.67033074e-02f, 7.90059119e-02f, -6.52123392e-02f, -4.81204912e-02f, -1.32483523e-02f, -8.58527049e-02f, 3.87254097e-02f, 9.75700542e-02f, -2.48646680e-02f,
  1.26628757e-01f, 1.77043468e-01f, 4.55669174e-03f, 1.50177643e-01f, 9.15939659e-02f, 6.93805069e-02f, 2.10150145e-02f, 3.27530107e-03f, 7.52586946e-02f, 3.45067643e-02f,
  2.31294915e-01f, 2.15923652e-01f, 1.93627164e-01f, 1.17474675e-01f, 1.54692307e-01f, 6.09381795e-02f, 5.19870743e-02f, 6.39935955e-02f, 5.78200519e-02f, 1.86765548e-02f,
  1.45873919e-01f, 7.36967996e-02f, 6.84668869e-02f, 1.89641863e-01f, 1.40762627e-01f, 1.28287449e-01f, 4.94062230e-02f, 1.28474966e-01f, -1.50315193e-02f, -5.74607365e-02f,
  3.88283432e-02f, -2.81740930e-02f, -7.11130276e-02f, -5.42191369e-03f, 1.79412216e-02f, 1.44850314e-01f, 7.27728605e-02f, 1.59182161e-01f, 9.87855792e-02f, 8.63837898e-02f,
  -2.91182965e-01f, 8.63098055e-02f, 7.03710541e-02f, -4.88967374e-02f, -1.14261188e-01f, -7.43992776e-02f, 8.63161236e-02f, -7.09585249e-02f, -2.02492848e-01f, -8.89598578e-02f,
  -1.06013566e-01f, -1.07379958e-01f, -2.17004064e-02f, 2.80250125e-02f, 9.14810672e-02f, -8.27875584e-02f, 7.27433886e-04f, 1.65902195e-03f, -5.11985505e-03f, -5.56771420e-02f,
  8.88257846e-02f, 1.50567323e-01f, 1.43140433e-02f, 8.40111673e-02f, -7.24440888e-02f, -2.14506332e-02f, -4.48156893e-02f, -1.38277337e-01f, -9.82351452e-02f, 1.46684768e-02f,
  -6.32157445e-01f, -1.61948707e-02f, 2.96023697e-01f, -2.26402879e-01f, 1.04649104e-01f, 5.71478643e-02f, 3.12503159e-01f, -8.30060989e-02f, -1.55038968e-01f, 2.30793759e-01f,
  2.08982229e-01f, -1.59413099e-01f, -8.56892839e-02f, 8.36730003e-02f, 4.64031436e-02f, 2.17717007e-01f, 8.09654146e-02f, -8.54795128e-02f, -2.99093843e-01f, -1.26757830e-01f,
  -2.17590317e-01f, -3.20560306e-01f, -3.01015615e-01f, -6.86985850e-02f, -4.77260165e-02f, -1.34756774e-01f, 5.57511337e-02f, -7.21500963e-02f, 1.73205942e-01f, 6.17745370e-02f,
  1.87520847e-01f, 5.41178286e-02f, -2.11910196e-02f, -3.09702456e-01f, -5.08957282e-02f, -2.20054582e-01f, 8.10297653e-02f, 3.74222919e-02f, -4.13713045e-02f, -2.65422668e-02f,
  -1.34360297e-02f, 1.40416309e-01f, -1.48746222e-01f, -1.21153928e-01f, -1.29750535e-01f, -4.82913963e-02f, -1.14119671e-01f, -6.99368631e-03f, -1.05251200e-01f, -6.23509362e-02f,
  -1.50409192e-01f, -6.94588274e-02f, -7.02422187e-02f, 1.16405562e-02f, -4.53863069e-02f, -1.73391208e-01f, -9.40061659e-02f, -8.20152238e-02f, 1.43446133e-01f, 9.40606743e-03f,
  -3.63835767e-02f, 1.19041704e-01f, 8.72985050e-02f, 9.13420096e-02f, 1.52324382e-02f, 3.72536071e-02f, 8.91213194e-02f, 2.95411255e-02f, 5.81897190e-03f, -3.04595008e-02f,
  1.18122064e-03f, 7.31193200e-02f, -2.91076265e-02f, -1.91464331e-02f, 1.32760778e-01f, 5.79261221e-02f, -5.79538904e-02f, 1.19925477e-02f, 4.16935012e-02f, -1.64605584e-03f,
  -1.16684616e-01f, 2.23042984e-02f, -2.44385451e-02f, -1.18879192e-01f, 4.36095931e-02f, 1.00151286e-01f, -1.40209654e-02f, -1.46462858e-01f, 1.81096233e-02f, 7.97305852e-02f,
  -2.56741345e-01f, 1.91183940e-01f, 1.22165993e-01f, -1.30909637e-01f, 1.26390800e-01f, -3.14217135e-02f, -2.42860969e-02f, 4.88165207e-02f, -5.69440052e-02f, -1.06991664e-01f,
  -1.12759940e-01f, -1.01580983e-02f, -5.75993583e-03f, -1.18821979e-01f, -1.58624664e-01f, -5.17804362e-02f, -2.80686617e-01f, -1.14891894e-01f, -1.25454664e-01f, -2.14134857e-01f,
  -2.74351597e-01f, -4.02274318e-02f, -2.47195527e-01f, -4.86691818e-02f, -1.58101976e-01f, -4.29401137e-02f, 6.82259873e-02f, -1.19676948e-01f, 1.15996048e-01f, -5.36415428e-02f,
  3.73623580e-01f, -4.42195773e-01f, 3.30212973e-02f, 2.41075903e-01f, 1.52731702e-01f, 2.92313099e-01f, -2.77447863e-03f, 2.90189665e-02f, 1.09270677e-01f, -1.51292056e-01f,
  -3.05340469e-01f, -1.97872102e-01f, -1.29356146e-01f, -1.77434385e-01f, -5.76172099e-02f, 5.91247194e-02f, 1.09411426e-01f, 1.27142802e-01f, 2.14189753e-01f, 1.80711597e-01f,
  -1.80109262e-01f, -1.68206990e-02f, 3.85372303e-02f, 4.55094390e-02f, -1.87383190e-01f, -1.04722522e-01f, -1.69848531e-01f, 7.03221336e-02f, -1.36344850e-01f, -2.08983690e-01f,
  -1.46014228e-01f, -1.90892145e-01f, 4.95548584e-02f, -8.76765102e-02f, -7.78375491e-02f, -1.05300151e-01f, -2.85482872e-02f, -7.77638033e-02f, 3.18874754e-02f, 1.21173810e-03f,
  -5.17761186e-02f, -4.81450791e-03f, -8.44611749e-02f, -1.34155214e-01f, 7.27338269e-02f, 3.18499375e-03f, -2.47897636e-02f, -3.73933315e-02f, -4.82961051e-02f, -1.69629887e-01f,
  -1.82628512e-01f, 9.38280374e-02f, 6.31549880e-02f, 1.20076433e-01f, -2.47355346e-02f, -3.02942190e-02f, -1.36265635e-01f, 6.69702142e-02f, 2.97550187e-02f, 9.18379053e-02f,
  4.88820635e-02f, 6.01789430e-02f, -6.38580620e-02f, -1.64952478e-04f, 4.94815707e-02f, 6.28278404e-02f, 1.59582734e-01f, 3.29895057e-02f, -6.90491050e-02f, -8.59084651e-02f,
  -9.41888765e-02f, -1.08800881e-01f, -9.64602232e-02f, 6.94984794e-02f, -1.10562921e-01f, -2.55585127e-02f, -1.41295213e-02f, -1.00931644e-01f, -8.24414659e-03f, -6.86746314e-02f,
  -1.63829207e-01f, -1.24290280e-01f, -1.00904316e-01f, -1.48163661e-01f, -1.50832474e-01f, 6.30815998e-02f, 5.04386202e-02f, -1.21727869e-01f, 3.23373862e-02f, -5.86404428e-02f,
  -3.05770755e-01f, -3.96163128e-02f, 9.43957493e-02f, -1.74454615e-01f, -2.91871168e-02f, -1.10172324e-01f, -8.00734982e-02f, 1.24023454e-02f, 9.83945746e-03f, -1.69025529e-02f,
  -1.03406131e-01f, 6.45757094e-02f, -7.00158253e-02f, -1.81646734e-01f, 2.04517379e-01f, 2.39272360e-02f, -1.08759128e-01f, 4.72950228e-02f, -1.17376961e-01f, -3.01466733e-02f,
  -3.49960686e-03f, 1.77914277e-01f, 1.97737783e-01f, 1.01621889e-01f, 2.43176401e-01f, 2.06603229e-01f, 1.50700837e-01f, 2.01812118e-01f, 1.04970276e-01f, 1.82390064e-01f,
  -6.19295239e-01f, -1.06351994e-01f, -2.34754264e-01f, 2.13336095e-01f, 1.87510282e-01f, 3.23209852e-01f, 1.50566712e-01f, 1.33882299e-01f, 2.27733955e-01f, 4.56218198e-02f,
  -1.01681814e-01f, 1.24974467e-01f, 1.64022177e-01f, 1.54052377e-01f, 9.62477643e-03f, 1.33192822e-01f, 2.49268934e-01f, -8.98469314e-02f, -1.53347831e-02f, 4.71002832e-02f,
  2.10087016e-01f, -3.12957615e-02f, -3.37945879e-01f, 1.07296407e-02f, -2.08732206e-02f, 1.56901866e-01f, 1.15282007e-01f, -4.93589882e-03f, 5.93569092e-02f, 6.09489307e-02f,
  -2.69783050e-01f, -2.00759560e-01f, 1.67730346e-01f, 4.10439307e-03f, -2.27071941e-01f, -5.26713766e-02f, 3.29063013e-02f, -1.45794004e-01f, -2.18739901e-02f, 5.45268133e-02f,
  -8.99134129e-02f, -1.39303371e-01f, 3.38914921e-03f, -6.38825595e-02f, -8.58372375e-02f, -9.38688070e-02f, -1.38323620e-01f, 7.88371637e-03f, 1.35283917e-01f, -2.43513566e-02f,
  1.20790958e-01f, 4.95074950e-02f, 7.48561695e-02f, 1.64729625e-01f, 1.84442461e-01f, -1.56076951e-02f, -7.00007528e-02f, -5.04744984e-03f, -2.04025656e-02f, -1.18697241e-01f,
  3.10622245e-01f, -1.63622275e-02f, -4.33328338e-02f, -1.40565718e-02f, -1.26219122e-02f, -4.45941947e-02f, -1.21004470e-01f, -2.30543893e-02f, 9.35566574e-02f, -5.13529964e-02f,
  -9.03424993e-03f, 8.46001580e-02f, 9.17264745e-02f, 8.53630677e-02f, 5.25041111e-02f, -7.95102865e-03f, -8.40541944e-02f, -9.19053629e-02f, -2.12847605e-01f, -7.09743425e-02f,
  3.63394781e-03f, -9.88937169e-02f, -2.21780866e-01f, -1.00770436e-01f, -3.26278689e-03f, 4.24845964e-02f, -7.91598298e-03f, -4.80682328e-02f, -7.64534846e-02f, 1.60513550e-01f,
  2.16037273e-01f, 1.33709341e-01f, 1.63990799e-02f, -5.30129783e-02f, -1.50223687e-01f, -1.25202671e-01f, 1.35256425e-01f, -2.87219901e-02f, -1.06368333e-01f, 1.15889616e-01f,
  -5.68861328e-02f, -9.41547230e-02f, 5.78291621e-03f, -4.85018119e-02f, -8.78158733e-02f, -9.78462473e-02f, -1.32579058e-01f, -4.66180667e-02f, 1.20796598e-01f, 1.26832128e-02f,
  5.80143817e-02f, 1.93557531e-01f, 8.48903693e-03f, 1.32800713e-01f, 1.43649876e-01f, 8.84683132e-02f, -3.22784930e-02f, -5.48552424e-02f, -1.11900255e-01f, 1.05979711e-01f,
  -2.70584255e-01f, -2.15996414e-01f, -2.69017667e-01f, -9.56517458e-02f, 1.64795116e-01f, 3.51498276e-01f, 1.98142454e-01f, 1.25410601e-01f, 9.89542007e-02f, -2.27879994e-02f,
  1.36570647e-01f, 1.57979995e-01f, -3.39739583e-02f, 1.29163876e-01f, 1.12330228e-01f, 1.32203102e-03f, 4.08609398e-03f, -6.78813532e-02f, 2.70925820e-01f, 2.55243629e-01f,
  1.23666234e-01f, -5.17282970e-02f, 5.05490229e-03f, 5.20634428e-02f, -2.10471213e-01f, 5.79009615e-02f, -1.49042919e-01f, -1.36026099e-01f, -5.83323427e-02f, -2.71762699e-01f,
  -2.90618598e-01f, -2.24412397e-01f, 1.66870058e-01f, 1.45566270e-01f, -5.92016988e-02f, -1.36261120e-01f, -1.04602754e-01f, -3.77693266e-01f, -1.18098229e-01f, -1.46423697e-01f,
  -1.19078383e-01f, -5.78580759e-02f, -1.61561474e-01f, 4.59420606e-02f, 3.10826171e-02f, 1.20830365e-01f, -3.55673092e-03f, -1.78723067e-01f, -8.77697170e-02f, 1.70107052e-01f,
  5.50578125e-02f, -3.21161933e-02f, -1.85884014e-01f, 8.03697035e-02f, -1.67747140e-01f, -1.82199612e-01f, -7.63592944e-02f, -2.19604343e-01f, -1.67234808e-01f, -3.25980753e-01f,
  -5.41114472e-02f, -3.54423262e-02f, 5.02201729e-03f, -1.19905934e-01f, 1.90288369e-02f, 1.17812362e-02f, 7.28309574e-03f, 5.65403365e-02f, -8.63275304e-03f, -5.61214238e-02f,
  1.25746906e-01f, 1.46810144e-01f, 9.02102962e-02f, -1.09906693e-03f, -8.61861706e-02f, -2.53663957e-02f, 8.46309811e-02f, -2.16908101e-02f, 3.21940109e-02f, 8.35664868e-02f,
  -2.95152031e-02f, -8.29610080e-02f, -5.95165938e-02f, 1.11880362e-01f, -3.90751474e-02f, 3.83885577e-02f, -7.75936320e-02f, 4.00025472e-02f, -5.51264361e-02f, 7.39198849e-02f,
  -5.78911416e-02f, -1.98405962e-02f, -9.13020670e-02f, -4.37205583e-02f, -3.98645625e-02f, -3.31768207e-02f, -4.66491245e-02f, -2.61076782e-02f, 1.01642543e-02f, 8.02824423e-02f,
  -1.60042420e-02f, 6.14469051e-02f, -1.13913968e-01f, 8.76442790e-02f, 9.69864130e-02f, 1.64948199e-02f, 1.79911032e-02f, 1.02566458e-01f, 3.38829644e-02f, -3.67716365e-02f,
  -1.27953321e-01f, 1.34499639e-01f, -8.86401981e-02f, -1.57345068e-02f, -1.65067941e-01f, -1.66205704e-01f, -7.13335499e-02f, -7.75697902e-02f, -7.90152401e-02f, -1.56865120e-01f,
  -6.36865377e-01f, 6.39011487e-02f, -2.01810673e-01f, -5.03578782e-01f, -1.70957938e-01f, 1.26445651e-01f, 1.77740470e-01f, 8.16217065e-02f, 1.24953268e-02f, -3.30847427e-02f,
  3.61776575e-02f, -1.65875733e-01f, -2.31483415e-01f, -8.19963440e-02f, -5.45400865e-02f, -1.99517474e-01f, -2.73027152e-01f, -2.56550759e-01f, -1.10906549e-01f, 8.03367123e-02f,
  7.48500153e-02f, -2.84408510e-01f, -3.01811099e-01f, 4.53141108e-02f, -1.66673779e-01f, -8.48719850e-02f, -2.97098666e-01f, -1.10029183e-01f, 9.10436511e-02f, -2.17564538e-01f,
  -1.58342540e-01f, -2.03689970e-02f, 3.44728939e-02f, -1.84217803e-02f, 2.98380833e-02f, 1.90644059e-02f, 3.77688669e-02f, -4.14586700e-02f, 1.87735781e-02f, -2.80205105e-02f,
  -5.65100722e-02f, -4.75569023e-03f, -8.72785449e-02f, 1.80229284e-02f, 6.00667708e-02f, 1.00058965e-01f, 3.30325216e-02f, 2.78068986e-02f, 7.85364360e-02f, 3.25892419e-02f,
  1.19862922e-01f, 3.97489108e-02f, 1.07830361e-01f, 1.99056163e-01f, 1.47493258e-01f, 1.13647409e-01f, 2.23463252e-01f, 1.59419402e-01f, 2.40037248e-01f, 8.17767978e-02f,
  8.39013308e-02f, -1.12086609e-02f, -6.15156665e-02f, -4.69783731e-02f, 1.39913764e-02f, 5.45225479e-02f, -5.72336977e-03f, 3.57625894e-02f, 1.29605547e-01f, -2.72277612e-02f,
  1.45359104e-02f, -8.52195024e-02f, 2.43585054e-02f, -3.38710882e-02f, -1.07706390e-01f, -1.44031886e-02f, 1.09071419e-01f, 1.06796645e-01f, 7.53328949e-02f, -5.51709719e-02f,
  2.80627497e-02f, 4.31880578e-02f, -1.18563235e-01f, 1.44845590e-01f, 1.14922173e-01f, -1.88832358e-02f, 3.65528688e-02f, 9.98506919e-02f, -8.81262422e-02f, 1.97533257e-02f,
  -3.12158406e-01f, 1.36890970e-02f, -8.66248608e-02f, 2.01403163e-02f, -6.09782040e-02f, 9.26485360e-02f, -1.09821834e-01f, -6.98646456e-02f, -4.35218737e-02f, 3.94601487e-02f,
  1.60589084e-01f, -5.23505313e-03f, -7.70569518e-02f, 4.56752777e-02f, 5.69268537e-04f, 8.58737528e-03f, -2.11591590e-02f, -3.01466957e-02f, 7.15332776e-02f, 9.82756540e-02f,
  7.00221807e-02f, 7.90219977e-02f, 3.88602428e-02f, 8.09771642e-02f, 1.37799710e-01f, -1.32226735e-01f, -4.82906811e-02f, 1.98996753e-01f, 3.23627628e-02f, 5.30965365e-02f,
  -1.64328992e-01f, -3.06934327e-01f, -2.88836688e-01f, -2.67207295e-01f, -1.89990655e-01f, 1.35116559e-02f, -3.02880025e-03f, 6.00932501e-02f, 8.70746970e-02f, -9.85496193e-02f,
  -5.71797378e-02f, 8.49512666e-02f, -1.84244961e-02f, 6.84258044e-02f, 1.65669829e-01f, -1.67209834e-01f, -2.14768723e-01f, -7.70149231e-02f, 2.78551579e-01f, 3.16643029e-01f,
  5.91011271e-02f, -4.48653176e-02f, 4.02583443e-02f, 5.20302169e-02f, -2.12764502e-01f, -1.55030131e-01f, -2.61446953e-01f, -1.23184130e-01f, -7.99486116e-02f, -3.85127425e-01f,
  -2.97028244e-01f, 3.96833289e-03f, 4.32544053e-02f, 9.36629549e-02f, -1.25477239e-01f, -2.06376184e-02f, 3.55685838e-02f, -3.46000236e-03f, -3.80837098e-02f, 1.57368146e-02f,
  -9.86508839e-03f, 1.49418771e-01f, -2.65061073e-02f, -2.09139083e-02f, -1.23130888e-01f, -8.04458454e-04f, 9.87207964e-02f, 5.53430319e-02f, 2.57281046e-02f, 8.50687400e-02f,
  -2.48910226e-02f, 5.30558974e-02f, 3.72151807e-02f, 9.93038900e-03f, 6.13439605e-02f, 7.66281039e-02f, -3.87624763e-02f, 7.81181036e-03f, 2.13168208e-02f, -1.89937383e-01f,
  -2.28587240e-02f, -9.89207476e-02f, 4.15468812e-02f, -5.87752908e-02f, 1.95363667e-02f, -1.09126950e-02f, -1.06928244e-01f, 2.25793831e-02f, -7.02941045e-03f, -3.02526858e-02f,
  -7.62589835e-03f, -3.84395197e-02f, 7.56433159e-02f, 4.66704834e-03f, 9.46490467e-02f, 1.23070702e-02f, -3.76428105e-02f, -5.52669019e-02f, 8.69002566e-02f, 5.39399497e-02f,
  -5.55302314e-02f, 2.48712301e-03f, -5.04037179e-02f, 4.47221957e-02f, 6.66144937e-02f, 6.23372346e-02f, 8.07651803e-02f, 1.15458786e-01f, -1.73112806e-02f, 8.30536112e-02f,
  -1.82523072e-01f, -2.47626305e-02f, -1.57662645e-01f, 5.20138778e-02f, -1.28118530e-01f, 6.03696071e-02f, -6.47757202e-02f, 3.37046906e-02f, -1.61690086e-01f, 1.06272511e-01f,
  6.90400526e-02f, 4.51558083e-02f, -1.58111691e-01f, -4.62901071e-02f, -9.74753350e-02f, -9.12341475e-03f, -1.26058728e-01f, -5.33300415e-02f, 3.83163765e-02f, 1.00281626e-01f,
  1.77325644e-02f, 1.68436095e-01f, 7.48722255e-02f, -8.69185254e-02f, -2.40688659e-02f, 8.57982785e-02f, -9.70210731e-02f, -2.89823972e-02f, 5.51212467e-02f, -9.80614573e-02f,
  9.58713703e-03f, -9.53009203e-02f, -3.55576366e-01f, 3.36101860e-01f, -1.50693968e-01f, -1.35771349e-01f, -2.17203107e-02f, 1.51398629e-01f, 1.98747590e-01f, 3.45683433e-02f,
  3.95879103e-03f, 1.51637971e-01f, 1.03198051e-01f, -1.14613570e-01f, -2.15638116e-01f, -1.44613877e-01f, -1.33021489e-01f, -2.96946734e-01f, -1.67946935e-01f, 2.17253402e-01f,
  5.56660034e-02f, 1.08271077e-01f, -7.01721832e-02f, 5.04970476e-02f, 1.76663380e-02f, -2.38945201e-01f, -1.55404657e-01f, -3.46639544e-01f, -4.03039068e-01f, -5.12272477e-01f,
  -4.29945976e-01f, -9.02587473e-02f, 8.59152991e-03f, 4.55309488e-02f, -7.64539167e-02f, 1.36579245e-01f, 9.88507420e-02f, 7.50827119e-02f, 1.50731727e-01f, 8.95890817e-02f,
  8.80703107e-02f, 9.07692909e-02f, 3.45347896e-02f, -4.68111634e-02f, 8.58404022e-03f, 1.26043871e-01f, 1.09858215e-01f, -8.90857652e-02f, 1.01845656e-02f, 5.36688529e-02f,
  8.12067091e-02f, 8.66626129e-02f, -6.51287436e-02f, -3.24562639e-02f, -1.41589984e-01f, -1.68997571e-01f, -7.97640756e-02f, -1.64963797e-01f, -2.08052397e-01f, -1.83830392e-02f,
  -3.54270972e-02f, -6.30349368e-02f, -2.05399096e-03f, 6.42422661e-02f, 1.26901537e-01f, -8.62021372e-03f, -1.23304591e-01f, -1.26480401e-01f, -8.08895528e-02f, -4.96835597e-02f,
  4.06090803e-02f, -3.70340608e-02f, -2.46534366e-02f, 4.26685475e-02f, -2.43206751e-02f, 2.74145361e-02f, -1.05292611e-01f, -2.65056100e-02f, -9.10306163e-03f, -1.52369449e-02f,
  -1.19073868e-01f, -1.10254101e-01f, 5.64641804e-02f, -7.85127953e-02f, -1.10141933e-01f, 2.57806592e-02f, -1.25875756e-01f, 1.20028339e-01f, 1.48820177e-01f, 4.67554815e-02f,
  2.83542216e-01f, -2.17085421e-01f, 6.70334846e-02f, 3.83830145e-02f, -8.09483044e-03f, 1.02974519e-01f, 8.26253742e-03f, 2.60866117e-02f, 1.39476927e-02f, 1.69862971e-01f,
  6.79102493e-04f, -5.63040487e-02f, -4.66594920e-02f, -3.21165808e-02f, 1.49632737e-01f, 9.76401865e-02f, 2.40018144e-02f, -1.80043012e-01f, -6.35715201e-02f, 7.07973093e-02f,
  1.18458524e-01f, 1.57059029e-01f, 2.21719760e-02f, -1.41840622e-01f, -4.97597158e-02f, -1.14547305e-01f, -5.93343750e-02f, -9.75582749e-02f, -1.59503832e-01f, 1.26369298e-01f,
  -2.95060664e-01f, 2.16467809e-02f, -3.12620431e-01f, 1.86237782e-01f, 2.59050548e-01f, -3.66827101e-02f, -1.59747452e-01f, -1.01179987e-01f, 1.82633877e-01f, -5.85591309e-02f,
  -1.25303522e-01f, 8.93808454e-02f, 1.13999009e-01f, -1.50147319e-01f, -1.18458107e-01f, 1.17390536e-01f, 2.43249640e-01f, -5.19240797e-02f, -3.43552530e-01f, -1.33180991e-01f,
  2.39387393e-01f, 2.28680223e-02f, -1.37778521e-01f, -5.89783043e-02f, 1.36304125e-01f, 1.38892755e-01f, 3.05024963e-02f, -5.23501523e-02f, 4.88196611e-02f, 4.90232587e-01f,
  -1.49444923e-01f, -2.27847204e-01f, -1.00688696e-01f, -2.62118410e-02f, 6.54705614e-02f, -1.87147290e-01f, -2.27989748e-01f, -5.00640720e-02f, 3.39200273e-02f, -1.12311915e-01f,
  7.61888772e-02f, -1.16097771e-01f, 1.53876156e-01f, 7.35017210e-02f, -1.50152773e-01f, -8.86013582e-02f, -1.12086855e-01f, -2.44138464e-01f, -2.35405073e-01f, -1.44268975e-01f,
  2.75493711e-01f, 2.09097192e-01f, -6.34421259e-02f, -1.49486363e-01f, -2.06278890e-01f, -5.21451188e-03f, -1.18014902e-01f, -1.40238166e-01f, -3.52991134e-01f, -1.95367172e-01f,
  -2.87243333e-02f, -5.24031147e-02f, -7.38807395e-02f, 4.68553454e-02f, 9.92146432e-02f, 1.37099236e-01f, 1.17569566e-01f, 4.56727818e-02f, 6.24472089e-02f, -9.43054929e-02f,
  1.16948737e-02f, -7.51304850e-02f, -7.46678561e-02f, -5.14225848e-02f, -2.39839759e-02f, -1.13764973e-02f, -3.66111845e-02f, -8.07412714e-02f, -4.49743532e-02f, -1.58227891e-01f,
  1.31620571e-01f, -4.88667525e-02f, -3.57013009e-02f, 5.37511855e-02f, -2.12465283e-02f, -4.95122932e-02f, -2.32687332e-02f, -3.63431014e-02f, 4.44190763e-03f, -2.84494902e-03f,
  -8.93777087e-02f, -3.04030068e-02f, -4.56352159e-02f, 8.69872235e-03f, 8.50102454e-02f, 5.09415790e-02f, -5.98405898e-02f, 1.34456102e-02f, -4.97965477e-02f, 4.99940570e-03f,
  -6.09609783e-02f, -8.45728293e-02f, 8.43887553e-02f, 3.17866802e-02f, 5.10490537e-02f, 1.13934763e-02f, 1.61645651e-01f, 8.89504924e-02f, -9.48110148e-02f, 5.74226379e-02f,
  1.30802736e-01f, -7.94564262e-02f, 6.74342504e-03f, 2.97619272e-02f, -6.84121922e-02f, -3.21255066e-02f, -2.56447420e-02f, -7.63871819e-02f, -1.43931225e-01f, -4.52927724e-02f,
  -4.45279777e-01f, -9.70937759e-02f, -7.22696781e-02f, -2.24010140e-01f, -1.24119811e-01f, -2.31715236e-02f, -2.47054286e-02f, 6.22466616e-02f, 2.25591604e-02f, -8.96094069e-02f,
  3.11128935e-03f, 5.74660860e-02f, -1.38485909e-01f, 3.99003029e-02f, -8.32386762e-02f, -2.25409895e-01f, -2.06050605e-01f, -1.52192920e-01f, 3.39729674e-02f, 2.32116997e-01f,
  -1.91280805e-02f, -2.21930116e-01f, -1.11947730e-01f, -3.28953029e-03f, -1.97038665e-01f, -1.82468727e-01f, -3.29177707e-01f, -1.31278440e-01f, 2.24185269e-02f, -2.65402287e-01f,
  -2.35967770e-01f, 7.79943839e-02f, 1.29657745e-01f, -7.21914985e-04f, -8.82959738e-02f, 2.38175485e-02f, -4.93490770e-02f, -1.56697258e-02f, -9.60735697e-03f, -2.36454774e-02f,
  7.20934793e-02f, 4.85318042e-02f, -4.87888530e-02f, -2.92860195e-02f, -8.80412161e-02f, 7.45162591e-02f, 4.40165475e-02f, 1.23033293e-01f, -4.19920795e-02f, -5.34105161e-03f,
  6.85702171e-03f, 1.77781805e-01f, 2.09587127e-01f, 6.21534102e-02f, 2.30869859e-01f, 1.37024552e-01f, 8.82850662e-02f, 8.39350671e-02f, 1.15487576e-01f, 4.95473482e-03f,
  -1.34521574e-01f, -1.06336936e-01f, 4.99522462e-02f, 1.09908447e-01f, 1.51177291e-02f, 9.09146518e-02f, -2.77376752e-02f, -4.25145812e-02f, -5.65538779e-02f, 9.35075805e-02f,
  7.23588914e-02f, -1.71886921e-01f, -5.57330213e-02f, -6.64757639e-02f, -1.12481736e-01f, 4.85484079e-02f, 2.56840736e-02f, -6.77921847e-02f, -2.19903886e-02f, 1.06992191e-02f,
  7.82769322e-02f, 1.48558453e-01f, -9.44393799e-02f, -7.28251487e-02f, -2.01351121e-02f, -1.21737376e-01f, 1.01204954e-01f, 3.76217254e-02f, -2.67769396e-03f, 4.46469039e-02f,
  -2.82367885e-01f, -1.68918014e-01f, -1.34663835e-01f, 5.89763671e-02f, -1.15550242e-01f, 3.52763012e-02f, -7.85305202e-02f, -7.66571984e-02f, -5.42673841e-02f, 1.70668645e-03f,
  1.61644280e-01f, -1.42321676e-01f, -3.12530063e-02f, -1.41553767e-02f, -7.37608448e-02f, 1.03976719e-01f, 4.63909134e-02f, 4.86927480e-02f, 6.75031915e-02f, 2.82684788e-02f,
  1.97428972e-01f, 5.70664369e-02f, 3.01257558e-02f, 8.17869455e-02f, 1.27799913e-01f, -1.50193855e-01f, -2.35590618e-02f, 1.10723406e-01f, 7.72400126e-02f, -1.07389234e-01f,
  -3.54111373e-01f, -3.26863319e-01f, -3.69116734e-03f, 5.11829853e-02f, 2.19223410e-01f, 9.06897523e-03f, -4.77792561e-01f, -4.58573490e-01f, 1.18345348e-02f, -1.67834356e-01f,
  6.11171164e-02f, 3.58878165e-01f, 3.04376055e-02f, -1.84014738e-02f, -4.24474537e-01f, -4.59103256e-01f, -2.12792028e-02f, -1.61143430e-02f, 6.24893941e-02f, 6.40074909e-02f,
  1.59055233e-01f, 1.06561191e-01f, 3.27207558e-02f, -4.31675948e-02f, 7.23657683e-02f, 1.26901940e-01f, -1.76460706e-02f, 4.82889749e-02f, -3.25394310e-02f, 3.82041894e-02f,
  -6.52845949e-02f, -3.01823407e-01f, 1.70806870e-01f, 1.28380194e-01f, 3.57762463e-02f, -2.62906224e-01f, -1.91003948e-01f, -5.83523065e-02f, 6.66351616e-02f, -5.95677271e-02f,
  1.07430808e-01f, 5.94906472e-02f, 8.16263109e-02f, 1.67305380e-01f, -2.86325980e-02f, -8.51609185e-02f, -3.51403765e-02f, -1.50773704e-01f, -1.31539881e-01f, -8.30004960e-02f,
  2.24592447e-01f, 1.73445761e-01f, -2.56449115e-02f, -1.78167939e-01f, -2.11858183e-01f, 9.72241163e-02f, 1.57898933e-01f, -7.38491863e-02f, -1.67977184e-01f, -3.70665342e-01f,
  1.28735453e-01f, 4.82621975e-02f, 1.01645030e-01f, -1.16042070e-01f, -1.08846952e-03f, -7.90822133e-03f, -4.55679968e-02f, 5.18908873e-02f, 9.03048180e-03f, -5.08977436e-02f,
  4.26444970e-03f, 1.26621500e-01f, 4.60748821e-02f, -5.98102845e-02f, 8.69178101e-02f, -8.40792060e-03f, -3.35730724e-02f, -2.05354422e-01f, -3.10994014e-02f, -1.61483213e-02f,
  -3.12167909e-02f, 1.35569833e-02f, 1.20236985e-01f, -2.59389859e-02f, -1.18171267e-01f, 4.07687016e-02f, 4.90648858e-02f, -3.47808599e-02f, -7.26121217e-02f, 6.35204837e-02f,
  -1.62312947e-02f, 2.67767191e-01f, -1.86958924e-01f, -1.11321911e-01f, -6.15231087e-03f, 2.04862263e-02f, 1.04792595e-01f, 3.74036543e-02f, -1.26725193e-02f, -1.00639299e-01f,
  -7.85556585e-02f, -6.97072670e-02f, -4.24464159e-02f, 6.80168793e-02f, -2.39849966e-02f, -1.90860368e-02f, 3.61002870e-02f, 3.06992903e-02f, -1.41570549e-02f, 1.71005562e-01f,
  -3.86254825e-02f, -1.86868966e-01f, -2.42523387e-01f, -2.35747293e-01f, -1.72714323e-01f, 2.80586584e-03f, -5.30731082e-02f, -1.59586757e-01f, -2.47956410e-01f, -4.36663896e-01f,
  -4.84686345e-01f, -3.77926439e-01f, 8.71520787e-02f, 2.33903974e-01f, 2.79565573e-01f, 2.99143106e-01f, 2.24446952e-01f, 1.86076969e-01f, 3.40187214e-02f, -7.44936988e-03f,
  -3.01054716e-01f, -9.16901827e-02f, -2.51188338e-01f, -1.28596395e-01f, 2.96127843e-03f, 1.63912162e-01f, 3.56195688e-01f, 1.54216411e-02f, 1.02801219e-01f, 1.32927177e-02f,
  5.83420806e-02f, -3.94149944e-02f, -4.04503852e-01f, -1.36460051e-01f, 1.48926064e-01f, 1.10977136e-01f, 1.66686550e-02f, -1.16676837e-03f, -9.65620354e-02f, 1.91159084e-01f,
  -1.40426412e-01f, -1.50395274e-01f, 8.86786282e-02f, -1.91168308e-01f, -4.60072793e-02f, -2.32218623e-01f, 4.22555022e-02f, -1.27352238e-01f, -6.07306734e-02f, 4.28081723e-03f,
  -4.91912141e-02f, -1.32829338e-01f, 5.74109070e-02f, -5.27692884e-02f, -2.11918373e-02f, -1.12527855e-01f, -1.24425083e-01f, -1.04580194e-01f, 9.81973633e-02f, -2.22030026e-03f,
  -6.48961067e-02f, 1.78995971e-02f, 1.35232890e-02f, 1.79420963e-01f, 3.48926112e-02f, -3.30836996e-02f, -1.35060742e-01f, 2.76505202e-02f, -2.80870311e-02f, -8.89215097e-02f,
  6.28915429e-02f, 5.63912094e-02f, 6.34696782e-02f, 8.76438059e-03f, 4.70437342e-03f, 4.22021113e-02f, -4.38483581e-02f, 4.63215113e-02f, 1.11411270e-02f, -7.74421990e-02f,
  4.04114537e-02f, 1.93168446e-02f, 2.99448669e-02f, 5.40409088e-02f, -7.16386316e-03f, 1.72787122e-02f, 1.05103031e-01f, -1.09707221e-01f, -7.70197958e-02f, -2.99618188e-02f,
  -6.89131320e-02f, 1.25763386e-01f, -2.32004505e-02f, 7.03111812e-02f, -1.83373708e-02f, -3.17665301e-02f, 1.53093845e-01f, -1.02603085e-01f, 1.26054659e-02f, -2.55595008e-03f,
  -9.35775116e-02f, 2.30675247e-02f, 1.15421519e-01f, -6.70325607e-02f, -2.71239299e-02f, -9.31553394e-02f, 1.23579735e-02f, 5.73317800e-03f, -1.05326273e-01f, 5.94699383e-02f,
  1.94433909e-02f, -3.83580266e-03f, -1.81967467e-02f, 9.73777100e-02f, 3.02730873e-02f, 5.49441203e-02f, -4.39840071e-02f, 7.39718452e-02f, 7.34892264e-02f, 6.25776500e-02f,
  4.50704359e-02f, 1.74433112e-01f, 9.90931615e-02f, 1.84095353e-01f, 2.17805520e-01f, 1.11615092e-01f, 2.32223608e-02f, 4.80850451e-02f, 2.60877982e-02f, 9.63386893e-02f,
  -1.68513387e-01f, 3.16980749e-01f, 1.33326352e-01f, -1.65253431e-01f, -7.96404481e-02f, -2.52704956e-02f, -1.14226036e-01f, -6.13038801e-02f, -1.67895943e-01f, 1.35742556e-02f,
  9.82160121e-02f, 2.54082769e-01f, 2.34678671e-01f, 1.76579848e-01f, 2.35371158e-01f, -3.17127220e-02f, -2.29159847e-01f, 1.03996933e-01f, 4.01900634e-02f, 4.75539863e-02f,
  -2.33903393e-01f, -2.00002551e-01f, -1.60844207e-01f, -9.03216898e-02f, 1.05270095e-01f, 1.47625729e-01f, -2.51130573e-02f, 2.60937884e-02f, 6.16030619e-02f, 6.48271013e-03f,
  6.99640512e-01f, 1.47898778e-01f, 1.60614565e-01f, 2.23345831e-01f, 6.96214214e-02f, 1.35940030e-01f, 5.02258874e-02f, 5.58601227e-03f, -1.18709961e-02f, -8.52957070e-02f,
  1.33069530e-01f, 3.60671990e-02f, -5.68522140e-03f, -6.75688535e-02f, -1.85406469e-02f, 4.23715413e-02f, -7.52019212e-02f, -2.73010228e-02f, 1.70242250e-01f, 1.72048256e-01f,
  2.78342664e-02f, 3.77385952e-02f, 1.26834258e-01f, 9.76929814e-02f, 9.69229639e-02f, 6.72835559e-02f, 1.56562760e-01f, 1.65566534e-01f, 1.07452050e-01f, 2.63084210e-02f,
  -1.81967318e-01f, 2.23003179e-02f, 6.67842701e-02f, -2.75323894e-02f, -1.20976739e-01f, -5.57700954e-02f, -1.90179832e-02f, -6.04666471e-02f, -1.22635327e-01f, -3.32886763e-02f,
  -2.63191890e-02f, 1.60575695e-02f, -2.84400443e-03f, 5.59519269e-02f, -9.71807390e-02f, -1.07652228e-02f, -3.57216001e-02f, 8.49396884e-02f, -5.06440699e-02f, -8.09878409e-02f,
  1.11922203e-02f, 9.91372243e-02f, -1.01887956e-01f, 1.48743289e-02f, -9.00469571e-02f, -2.43425164e-02f, 2.76054647e-02f, -2.49216184e-02f, -1.08470827e-01f, 1.53588476e-02f,
  2.85490096e-01f, 6.28448054e-02f, 9.74526331e-02f, 8.09845850e-02f, 3.19614485e-02f, 8.26806650e-02f, 1.75271451e-01f, 1.32993132e-01f, 1.59796756e-02f, -2.68754251e-02f,
  1.62019819e-01f, 8.87329653e-02f, 1.77565232e-01f, 1.15827873e-01f, -7.94414058e-02f, 9.10268500e-02f, 1.50412738e-01f, 1.20423898e-01f, 1.11181207e-01f, 1.06490105e-01f,
  1.09495729e-01f, 1.05129145e-01f, 2.63662696e-01f, 1.43474951e-01f, 4.15542312e-02f, 1.75213248e-01f, 1.91431254e-01f, 1.66373998e-01f, 9.88408327e-02f, -1.53847039e-02f,
  -1.73863456e-01f, 2.39590570e-01f, -5.53623140e-02f, -3.63255739e-02f, 2.28665978e-01f, 3.82211030e-01f, 2.78622478e-01f, 2.65340865e-01f, 4.83913869e-02f, -3.99010442e-02f,
  1.37896061e-01f, 1.39475033e-01f, -1.27279580e-01f, -4.59971465e-02f, 3.11628114e-02f, -1.38068870e-01f, -1.14214212e-01f, -1.13247752e-01f, 6.32506832e-02f, 3.11557025e-01f,
  9.91213769e-02f, -3.08594387e-03f, -7.60880560e-02f, 5.07213362e-02f, -2.50180751e-01f, -1.95017710e-01f, -2.16738716e-01f, -7.60567114e-02f, -2.62981802e-02f, -5.05295873e-01f,
  -2.61661351e-01f, 1.74117997e-01f, -9.00551155e-02f, -1.12562411e-01f, -9.89165809e-03f, 1.26536461e-02f, 4.23240103e-02f, -1.70538068e-01f, 8.46845061e-02f, -1.27900332e-01f,
  -1.42085031e-01f, 7.56836310e-02f, -5.70788682e-02f, 5.12527227e-02f, 1.42258376e-01f, 8.87451023e-02f, 3.90562713e-02f, 5.56278192e-02f, -1.76981747e-01f, 6.99883178e-02f,
  6.16193600e-02f, -3.34145650e-02f, 9.39024612e-03f, 2.94220541e-02f, 4.28373739e-02f, -1.07665181e-01f, 1.62306905e-01f, 5.29667921e-02f, 4.16940376e-02f, -2.90897578e-01f,
  1.92827154e-02f, -1.49423433e-02f, -5.26521951e-02f, 1.55191615e-01f, 2.07606219e-02f, -1.01996688e-02f, 1.79807376e-02f, -2.57553291e-02f, -1.77217443e-02f, -1.45658739e-02f,
  5.60179614e-02f, 8.06353390e-02f, 3.41291018e-02f, -9.38457176e-02f, -7.70263001e-02f, 1.12064620e-02f, -6.83384622e-03f, -2.00062292e-03f, -3.78475823e-02f, -5.81549900e-03f,
  -8.68403018e-02f, -1.15543447e-01f, 7.63303488e-02f, -8.03620964e-02f, -6.10557422e-02f, 1.05907209e-02f, -6.31985739e-02f, 1.07999846e-01f, 5.47513664e-02f, 3.76603641e-02f,
  -1.02629170e-01f, -5.14019281e-03f, -2.70041764e-01f, 1.93375662e-01f, 6.63350299e-02f, 7.02284649e-03f, -2.06660246e-03f, 1.00964464e-01f, 4.00448131e-04f, -5.12037380e-03f,
  6.81898445e-02f, 1.91983115e-03f, -1.35122851e-01f, -5.24363331e-02f, -4.64737229e-02f, 2.19687652e-02f, -2.19954364e-02f, -1.60998628e-01f, -1.49439871e-02f, -6.12916574e-02f,
  3.32913920e-02f, -1.08746864e-01f, -1.09088816e-01f, -1.08614095e-01f, -5.00023477e-02f, -9.51158777e-02f, -1.90952733e-01f, -1.81867987e-01f, -1.41073838e-01f, -3.31358492e-01f,
  -3.77930135e-01f, 1.28919929e-01f, 2.23347768e-02f, -1.58322066e-01f, -1.59468487e-01f, -6.17323592e-02f, -1.64003760e-01f, -8.73251855e-02f, -8.17945600e-02f, 1.32625759e-01f,
  1.93310186e-01f, 4.00730073e-01f, 3.10762048e-01f, 2.87470579e-01f, 1.79575145e-01f, -5.79973944e-02f, -2.71785259e-01f, -2.39634886e-02f, 2.02368144e-02f, -2.04488300e-02f,
  3.10948454e-02f, -2.53560275e-01f, -6.80884123e-02f, 1.54974433e-02f, 5.14236912e-02f, 2.70090491e-01f, 6.92478195e-02f, 1.26634926e-01f, 3.12177986e-01f, 1.35833696e-01f,
  4.01750505e-01f, -1.25683531e-01f, -2.89655931e-04f, 4.79331538e-02f, -6.62822649e-02f, -8.58979523e-02f, 1.41056344e-01f, -7.97317848e-02f, -1.34054244e-01f, 1.88062191e-02f,
  7.87022635e-02f, -5.92729189e-02f, -1.05275370e-01f, -3.36120091e-02f, -4.78839166e-02f, -1.57938048e-01f, -3.97395231e-02f, -5.00983410e-02f, 4.07167338e-02f, 8.79528075e-02f,
  -6.50816858e-02f, 3.42580825e-02f, 1.39670327e-01f, 1.48560461e-02f, -4.11983877e-02f, 2.31029838e-02f, 1.46597087e-01f, 1.33142471e-01f, 1.38149723e-01f, 1.81113467e-01f,
  9.41131115e-02f, 7.37927780e-02f, 1.50024906e-01f, 2.41501220e-02f, -5.90026975e-02f, 2.64322245e-03f, 8.44476521e-02f, -1.11796819e-02f, 6.77480595e-03f, -9.95343626e-02f,
  -6.81319227e-03f, 6.87893555e-02f, 3.89045849e-02f, 4.07285988e-02f, 3.02936938e-02f, 6.21073097e-02f, -1.12982482e-01f, 9.08904076e-02f, 6.60746768e-02f, -7.80273648e-03f,
  -9.29106623e-02f, 7.60280341e-02f, -4.83462997e-02f, -6.64677694e-02f, 3.75886844e-03f, 8.14977810e-02f, 4.95292712e-03f, 2.80435458e-02f, 6.96217567e-02f, 1.05220480e-02f,
  1.19349323e-01f, 2.37871017e-02f, 7.07386211e-02f, 1.61386698e-01f, 4.39648554e-02f, 8.02636594e-02f, 1.58923864e-01f, -2.66641402e-03f, -1.60391346e-01f, 1.37430830e-02f,
  1.16698369e-01f, 2.57944665e-03f, -9.39929560e-02f, 3.80271971e-02f, 4.97522168e-02f, 5.07289544e-02f, 1.07095413e-01f, -1.14425290e-02f, 9.71159786e-02f, 9.03872177e-02f,
  -6.68900385e-02f, 1.30624592e-01f, 2.05326572e-01f, 1.64792240e-01f, 3.29143219e-02f, 4.84728254e-02f, 8.29172954e-02f, 6.24179579e-02f, 1.69985965e-01f, -3.31830932e-03f,
  -3.35014135e-01f, -3.33829015e-01f, -8.52396712e-02f, -2.65481383e-01f, -8.19317847e-02f, -7.73718208e-02f, -2.36753851e-01f, -4.55605835e-02f, 3.61783728e-02f, -4.36844260e-01f,
  -1.48177072e-01f, 1.39341772e-01f, -5.48064560e-02f, 1.61406592e-01f, 4.27730121e-02f, -3.19885492e-01f, -2.62184590e-01f, 3.77219431e-02f, 3.50574732e-01f, 1.19544454e-01f,
  5.44603914e-02f, -2.83185840e-02f, 2.31085926e-01f, 2.00915635e-01f, -2.22915262e-01f, 6.16061501e-02f, -9.08333138e-02f, -6.26157746e-02f, 2.53013857e-02f, -3.12790513e-01f,
  -1.18511952e-01f, -1.43861920e-01f, 1.41358957e-01f, 1.33469990e-02f, -7.73778483e-02f, -9.28185182e-04f, -6.16892390e-02f, 7.01988712e-02f, -2.83950549e-02f, 6.62971586e-02f,
  -3.94114889e-02f, 3.45145948e-02f, 9.77171734e-02f, 1.64346918e-02f, -2.47372244e-03f, -9.15964693e-02f, 3.03748203e-03f, 1.17271274e-01f, 1.00122742e-01f, -1.19856454e-01f,
  -7.66454116e-02f, -6.34649917e-02f, 1.07557222e-01f, 1.29553467e-01f, 9.04826894e-02f, 1.36720449e-01f, 6.70861453e-02f, 6.86335266e-02f, 3.88528295e-02f, -2.80232221e-01f,
  -1.67263690e-02f, 4.91301715e-03f, 7.36717954e-02f, 7.00891316e-02f, 9.63114109e-03f, -3.30723226e-02f, -4.28247750e-02f, 2.18858402e-02f, 4.12941873e-02f, -4.93539162e-02f,
  -7.37258941e-02f, -8.43328014e-02f, 4.36627604e-02f, -5.26036061e-02f, -5.84053285e-02f, 5.54833002e-02f, -7.89562613e-02f, -3.63072306e-02f, 3.57376449e-02f, -3.95236574e-02f,
  -7.56594092e-02f, 8.16356167e-02f, -1.05265947e-03f, 1.35313690e-01f, -7.16697648e-02f, 3.02093327e-02f, -3.13615911e-02f, 1.38006443e-02f, -2.20285188e-02f, -2.74538416e-02f,
  -1.56693204e-04f, 7.43026882e-02f, -1.22696251e-01f, 5.40661551e-02f, -7.32314661e-02f, -1.71274934e-02f, -1.26138367e-02f, 9.09860134e-02f, 3.85597115e-04f, -8.88853073e-02f,
  5.67210577e-02f, -1.60431251e-01f, -4.52603027e-02f, 8.46538246e-02f, 7.18351640e-03f, -8.12556688e-03f, -1.39295653e-01f, 1.89218819e-02f, 2.26414539e-02f, -9.79262516e-02f,
  -1.26002148e-01f, -1.53367877e-01f, 3.05533130e-02f, -1.58378631e-02f, 3.25647043e-03f, 1.71922836e-02f, 5.74020967e-02f, -4.33856472e-02f, 4.73745987e-02f, -1.98460117e-01f,
  -1.34146690e-01f, -2.25115135e-01f, -1.41186908e-01f, 3.69733013e-03f, 7.78380483e-02f, 2.82815751e-02f, -3.16370696e-01f, 7.67230764e-02f, 1.43395111e-01f, -2.95023203e-01f,
  -8.14493224e-02f, 2.78023053e-02f, -1.14533417e-01f, -1.05449058e-01f, -9.02403742e-02f, -4.56044942e-01f, -3.20716619e-01f, -1.43528864e-01f, 1.96086273e-01f, -2.65815239e-02f,
  -5.78958821e-03f, 1.29236251e-01f, 9.76347849e-02f, 1.88762262e-01f, -5.04000485e-02f, 1.13625124e-01f, 8.05262011e-03f, -2.12077238e-02f, 5.41427024e-02f, -2.30305701e-01f,
  -1.67306855e-01f, 7.56065920e-02f, 3.23407538e-02f, -9.93625522e-02f, 4.02812958e-02f, -1.98690929e-02f, -2.41348799e-02f, -6.92773089e-02f, 3.90252285e-03f, -3.98677774e-02f,
  -6.19583018e-02f, 2.42959429e-02f, 7.92813525e-02f, 2.41640303e-02f, -4.86459397e-02f, 2.95921564e-02f, -4.32464480e-02f, -5.80729209e-02f, -9.51864850e-03f, -6.84076995e-02f,
  -1.29588142e-01f, -1.67713121e-01f, -1.32064849e-01f, -2.55476627e-02f, -5.06790960e-03f, 1.18326740e-02f, 7.94584081e-02f, 1.25909299e-01f, 2.23729312e-02f, -1.08270191e-01f,
  -1.04481220e-01f, -1.01521261e-01f, 1.04996320e-02f, 1.03385979e-02f, -8.21275786e-02f, -1.45760914e-02f, -6.03679642e-02f, -6.50533438e-02f, 6.60938695e-02f, -4.38720956e-02f,
  -1.15461320e-01f, -5.30367196e-02f, 4.85854037e-03f, -1.52362898e-01f, 2.46264115e-02f, 3.86472791e-02f, -5.79733029e-02f, -1.85133368e-01f, -7.28031322e-02f, -6.96750581e-02f,
  -3.51619311e-02f, 1.34140119e-01f, -1.46089075e-03f, -1.47164520e-02f, -5.58791831e-02f, -5.93856350e-02f, 8.33794698e-02f, 9.70937312e-02f, -2.82006525e-02f, -6.18872307e-02f,
  6.59255907e-02f, 7.28062317e-02f, -7.95387700e-02f, 5.15438691e-02f, 1.66539960e-02f, -4.18402590e-02f, -6.67150021e-02f, 9.65125784e-02f, 7.23201260e-02f, 1.35148644e-01f,
  3.26510780e-02f, -1.58892289e-01f, 2.82417722e-02f, 2.42300052e-02f, -7.03883823e-03f, -4.50240783e-02f, -1.08835839e-01f, 5.69296330e-02f, -1.33720770e-01f, 6.60823360e-02f,
  -9.40790549e-02f, -2.11563334e-01f, -2.17962012e-01f, -1.11336321e-01f, 4.45062369e-02f, -2.64582299e-02f, 2.41729151e-02f, 3.34476568e-02f, -1.85184792e-01f, -3.17446977e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 26)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 26;
const float L0_fan_Bp_bar_data[] = {
  3.66601832e-02f, 1.13577405e-02f, 3.29727679e-01f, 1.12750039e-01f, 1.91327393e-01f, -2.40121484e-02f, 1.36890888e-01f, 1.11010961e-01f, -1.37147933e-01f, 4.66443934e-02f,
  5.98023497e-02f, 8.10686499e-02f, 6.31067380e-02f, 2.15072837e-02f, -3.80321518e-02f, -5.16008697e-02f, 9.50590372e-02f, -2.93393526e-03f, -1.68610051e-01f, 3.45932879e-02f,
  4.73109409e-02f, -5.39156199e-02f, 6.03872500e-02f, -1.66468889e-01f, 1.78017735e-01f, 8.11668336e-02f
};

// L1_fan_Wp (Shape: 19 x 64)
const int L1_fan_Wp_rows = 19;
const int L1_fan_Wp_cols = 64;
const float L1_fan_Wp_data[] = {
  -2.97998078e-03f, 7.08399042e-02f, 3.84877659e-02f, -4.63679247e-02f, 1.16541430e-01f, 1.54586047e-01f, -1.72755301e-01f, 1.62548989e-01f, 6.71564415e-02f, 2.05979077e-03f,
  1.52092263e-01f, 4.31023352e-02f, 1.25237271e-01f, 1.33678168e-01f, 8.42139199e-02f, 1.69169798e-01f, -1.29220784e-01f, -8.27099457e-02f, 2.68457383e-02f, -1.65839046e-02f,
  -1.33315489e-01f, 9.70000103e-02f, -2.79388696e-01f, 1.34957666e-02f, 3.67383063e-02f, 2.29977369e-01f, -3.91098894e-02f, -3.52612920e-02f, -1.21519998e-01f, -7.04632327e-02f,
  9.21407938e-02f, -1.17126621e-01f, 7.36409947e-02f, 6.06396720e-02f, -4.24783342e-02f, 2.08609894e-01f, 1.27440721e-01f, -1.03673190e-01f, 2.77151108e-01f, 1.12708680e-01f,
  -3.07936639e-01f, 5.75436614e-02f, 2.87752897e-01f, 1.86338097e-01f, 2.21059889e-01f, -1.92606494e-01f, 1.94905568e-02f, 5.96862324e-02f, -2.14690939e-01f, 1.71258762e-01f,
  1.34047121e-02f, 2.01125160e-01f, 3.65748890e-02f, 1.50987655e-02f, -8.43582153e-02f, -3.07375968e-01f, 1.45044610e-01f, 3.34656872e-02f, -3.33909765e-02f, -6.46457542e-03f,
  6.13849089e-02f, 9.58061963e-03f, 2.52508014e-01f, -1.22510334e-02f, -1.69709116e-01f, -5.93391359e-02f, 7.07686618e-02f, 1.33304382e-02f, 2.06482515e-01f, 5.97393028e-02f,
  -9.73094180e-02f, 2.37336271e-02f, 9.11434367e-02f, 1.30095020e-01f, -1.92376021e-02f, 4.65240031e-02f, 9.98006687e-02f, -1.91243831e-02f, 1.37666970e-01f, 9.49875489e-02f,
  -6.59657940e-02f, -6.92621758e-03f, 8.75267759e-03f, 3.41109037e-02f, -1.53015822e-01f, 1.16203181e-01f, -1.99673459e-01f, 1.82711855e-02f, 1.93509266e-01f, -2.50448614e-01f,
  1.62919149e-01f, -3.18339914e-02f, -3.35336924e-02f, 1.58372596e-01f, 3.30973268e-02f, -9.81705263e-02f, -2.93354541e-01f, 7.40232691e-02f, -1.83790356e-01f, 3.10304053e-02f,
  1.66301839e-02f, -2.78896540e-02f, -3.58052701e-01f, 6.06455728e-02f, -1.96377382e-01f, -1.09797299e-01f, -1.52492851e-01f, 8.58779550e-02f, 2.39255920e-01f, -6.57791719e-02f,
  9.57427323e-02f, -1.18721306e-01f, 2.81527281e-01f, -2.42986426e-01f, -1.52480572e-01f, 2.28903312e-02f, 3.72342132e-02f, -3.54741886e-02f, -3.51603061e-01f, -2.44428590e-01f,
  4.72957641e-02f, -6.21412732e-02f, -3.13524380e-02f, 2.44826421e-01f, 7.64979646e-02f, 2.03592002e-01f, 1.93828672e-01f, 2.20199432e-02f, -7.73392841e-02f, -7.99784996e-03f,
  -1.07561080e-02f, -4.13570181e-02f, -3.24740298e-02f, 3.27620469e-02f, 4.22897562e-02f, -3.15620610e-03f, 6.53236583e-02f, -3.10902204e-02f, -9.97081995e-02f, 7.97815900e-03f,
  -9.80354324e-02f, -1.64305717e-02f, 2.72386968e-02f, 1.67225264e-02f, 1.23196043e-01f, 7.53206841e-04f, 7.02298433e-02f, 3.73348221e-02f, 1.67605311e-01f, -1.35490268e-01f,
  1.21396519e-01f, 3.03391051e-02f, -2.44290560e-01f, -8.19206536e-02f, -1.33364424e-01f, -1.11621790e-01f, 2.05090139e-02f, -6.55342937e-02f, -8.94574896e-02f, 8.98711681e-02f,
  3.01541775e-01f, -1.44573808e-01f, 7.08555132e-02f, -2.32515976e-01f, 1.06647797e-01f, -8.05936754e-02f, 7.22300708e-02f, -1.56785175e-01f, 5.81551865e-02f, 1.74601600e-01f,
  -6.26137331e-02f, -8.49943832e-02f, -1.65110245e-01f, 2.14776412e-01f, -2.19636753e-01f, -6.43978082e-03f, -2.73894608e-01f, 4.83539626e-02f, -1.17733635e-01f, -1.10955618e-01f,
  -6.87823072e-02f, 1.38085559e-01f, 7.19690323e-02f, 1.29410595e-01f, -1.79097836e-03f, -8.73677991e-03f, -4.84837033e-02f, -2.77638197e-01f, -3.72237921e-01f, -2.75563866e-01f,
  -1.75224096e-01f, -9.98212695e-02f, -6.29964191e-03f, 9.07451659e-02f, -2.67659593e-02f, -1.28793925e-01f, 7.73222148e-02f, 3.77665157e-03f, 7.34209940e-02f, -1.38313890e-01f,
  -1.69773155e-03f, 4.96168574e-03f, -8.55172724e-02f, 5.65071478e-02f, -2.12127287e-02f, 5.42746857e-02f, 3.44013907e-02f, -3.55379432e-02f, 1.74757466e-01f, 9.94082838e-02f,
  -6.25705952e-03f, -8.94122422e-02f, -1.75583631e-01f, -5.74554764e-02f, 1.00016840e-01f, -1.47319064e-02f, 6.04826547e-02f, -1.52752221e-01f, 2.00638756e-01f, 9.82566774e-02f,
  -7.16673434e-02f, 1.08364627e-01f, -1.14193469e-01f, 1.51082575e-01f, -5.12879267e-02f, 6.00652322e-02f, -1.56243155e-02f, -3.57639901e-02f, 1.35611296e-01f, -1.96387386e-03f,
  -2.09257640e-02f, -1.31827146e-01f, 1.07520618e-01f, 2.00417358e-02f, -7.96761885e-02f, -1.84012074e-02f, -1.66612834e-01f, 9.73051861e-02f, -6.06533438e-02f, -5.52160218e-02f,
  8.41464289e-03f, 3.08817588e-02f, -6.27877042e-02f, -2.82012448e-02f, -8.61942302e-03f, -2.16958653e-02f, -4.12169397e-02f, 3.20058204e-02f, -3.89651395e-02f, 1.44302053e-02f,
  6.39107451e-03f, -2.11315498e-01f, -1.39355436e-01f, -1.57162994e-01f, -3.45355049e-02f, -6.17631488e-02f, 3.85920121e-03f, -1.03584051e-01f, -1.92395188e-02f, -6.29419312e-02f,
  5.61674014e-02f, 1.11929759e-01f, -1.36492113e-02f, 8.46450701e-02f, 1.95430424e-02f, 1.04472294e-01f, 2.74498701e-01f, 2.02706605e-02f, -6.37510419e-02f, 2.12720353e-02f,
  8.26286897e-03f, 4.92577292e-02f, -1.21759335e-02f, 2.10661292e-02f, 2.23372335e-04f, -3.78815569e-02f, -1.06438220e-01f, 4.79109474e-02f, -1.38054445e-01f, -1.13498025e-01f,
  5.83894625e-02f, 1.65734276e-01f, -2.30339766e-02f, -1.32729337e-01f, 5.35746664e-02f, -4.75637950e-02f, 2.93400258e-01f, -4.54722643e-02f, -3.95596214e-02f, -8.51494521e-02f,
  -5.04863150e-02f, 1.10519513e-01f, -2.72894800e-02f, -1.46699369e-01f, 2.30219826e-01f, 1.17677972e-01f, -1.35794178e-01f, 4.40370068e-02f, 2.08388478e-01f, -6.01622500e-02f,
  1.82360366e-01f, -1.38834715e-01f, 1.75951734e-01f, -1.64756015e-01f, -1.19837031e-01f, 6.15556389e-02f, 4.92256507e-03f, 1.81819618e-01f, 1.31215766e-01f, 7.20277056e-02f,
  6.07991330e-02f, -3.29195529e-01f, 1.92763463e-01f, -4.86688614e-02f, -6.93672895e-02f, 8.78715329e-03f, 1.90260679e-01f, 1.24990977e-01f, 1.28550991e-01f, 7.14347735e-02f,
  1.63767099e-01f, -3.76850031e-02f, 4.61062342e-02f, -3.39727812e-02f, 2.02276949e-02f, 4.95658442e-03f, 1.45056292e-01f, 8.36085603e-02f, -3.42211574e-02f, 7.19777644e-02f,
  1.02249853e-01f, -6.57636002e-02f, -1.73092994e-03f, -1.20617785e-01f, 6.41222205e-03f, 1.52177110e-01f, 2.73125293e-03f, -1.10300586e-01f, -1.24069594e-01f, -1.47793097e-02f,
  -1.96209848e-01f, -1.39344102e-02f, 3.57850119e-02f, -3.84306796e-02f, 8.85997550e-04f, -9.78858396e-02f, -1.25133947e-01f, -1.36463568e-01f, -2.52545066e-02f, -4.74418327e-02f,
  -3.26750753e-03f, -1.34560401e-02f, 6.07437119e-02f, -6.20449334e-02f, -2.07008328e-02f, 2.09617801e-02f, 2.76162066e-02f, -9.15152133e-02f, -4.02517393e-02f, 1.31170809e-01f,
  -2.10022628e-01f, 1.35383800e-01f, 2.87240565e-01f, 2.18916889e-02f, 2.21462548e-01f, -5.86071834e-02f, 2.48579402e-02f, -1.82642400e-01f, -9.66052637e-02f, -4.19660434e-02f,
  -4.14006822e-02f, -5.37677333e-02f, -1.73346549e-01f, -4.44414979e-03f, -2.09575906e-01f, -1.22961000e-01f, -1.64508119e-01f, -4.31194991e-01f, 6.82386162e-04f, 1.65176228e-01f,
  -2.60674328e-01f, -3.75403315e-02f, 1.29473098e-02f, -2.74100862e-02f, -2.85377819e-02f, -5.61065860e-02f, 3.66826006e-03f, -3.64869973e-03f, -1.43864647e-01f, 5.61258905e-02f,
  -1.11495048e-01f, -2.35170554e-02f, -1.41022608e-01f, -6.01207167e-02f, 5.14331870e-02f, -1.69357702e-01f, 4.58198190e-02f, -1.17678508e-01f, 6.37333915e-02f, -1.90033764e-03f,
  -1.13235310e-01f, 1.46091077e-02f, -1.31937981e-01f, 1.38749540e-01f, -2.02429578e-01f, 7.76502341e-02f, -2.18288094e-01f, -4.15059477e-02f, 4.66799997e-02f, -1.62456766e-01f,
  1.93500789e-04f, -1.59157038e-01f, -8.32531974e-02f, -1.14726119e-01f, -1.28221586e-01f, 8.99882317e-02f, -1.57466140e-02f, 4.34074588e-02f, -5.71605377e-02f, -1.36841953e-01f,
  -2.74365637e-02f, 4.24339511e-02f, -4.30971310e-02f, -8.99608657e-02f, 1.21004656e-01f, -1.22560821e-01f, -1.64304703e-01f, 1.80624604e-01f, -1.76155537e-01f, 1.31696180e-01f,
  -1.07002191e-01f, 1.16672762e-01f, -4.30003740e-02f, -1.26342918e-03f, -1.84486970e-01f, -2.22708821e-01f, 2.67380625e-02f, -1.06215373e-01f, -6.41083866e-02f, 1.20746806e-01f,
  1.30859762e-01f, 1.01997696e-01f, 1.66786373e-01f, -1.93322703e-01f, -1.44203141e-01f, -5.10631427e-02f, -1.71903595e-01f, -7.66174197e-02f, -1.56566337e-01f, -4.82676327e-02f,
  -1.82230063e-02f, -3.23528759e-02f, -8.04239661e-02f, -3.92718948e-02f, -1.49448970e-02f, 1.39772370e-01f, 2.52898395e-01f, 1.81412569e-03f, 5.34409694e-02f, -1.81945026e-01f,
  8.78214464e-02f, -4.51788455e-02f, 4.83965408e-03f, 6.40476197e-02f, -9.99422371e-02f, 1.04976788e-01f, -2.91520469e-02f, -1.93287969e-01f, 1.76825970e-01f, -2.06965357e-02f,
  -7.53825605e-02f, 3.09878409e-01f, 1.33928418e-01f, -2.11390957e-01f, -2.75557674e-02f, -6.55302703e-02f, -8.12439770e-02f, -1.06675439e-02f, -1.88222975e-01f, -6.40156046e-02f,
  -2.02681005e-01f, 5.22454977e-02f, 2.18465596e-01f, -1.02339193e-01f, -8.10948908e-02f, 2.15760365e-01f, -3.32933754e-01f, -5.38241565e-02f, 3.13087583e-01f, 1.06742330e-01f,
  -2.69905150e-01f, -2.31385365e-01f, 3.32729796e-05f, 1.88309297e-01f, 7.35246064e-03f, 1.55319080e-01f, 1.55598432e-01f, -2.62517005e-01f, -1.24465279e-01f, -3.81820560e-01f,
  -1.41930476e-01f, -1.43124729e-01f, 5.57854660e-02f, -1.03732012e-02f, -1.54084777e-02f, -9.79123265e-03f, -1.97937548e-01f, 7.84147829e-02f, -1.98315024e-01f, 9.70640332e-02f,
  -1.24695912e-01f, 1.19130731e-01f, -2.39059180e-02f, 2.95217391e-02f, 8.98065716e-02f, 1.25404652e-02f, -2.01899111e-02f, 1.75611272e-01f, -3.49315703e-02f, 7.65063465e-02f,
  -7.55629316e-02f, 1.70584217e-01f, -2.46726051e-02f, 1.12017170e-01f, 9.40090567e-02f, -2.48638485e-02f, -2.27222636e-01f, 9.58954096e-02f, 6.63230121e-02f, 4.29694727e-02f,
  -4.24192213e-02f, 2.68346164e-02f, -5.91391698e-02f, 1.90648273e-01f, 1.02773290e-02f, -1.28964901e-01f, -1.02574974e-02f, -1.13547139e-01f, -2.11772453e-02f, -2.12688893e-01f,
  1.06999539e-01f, -2.15171009e-01f, 1.04116909e-01f, -1.02228202e-01f, -6.14326410e-02f, -5.64575791e-02f, -1.21487770e-03f, -1.71422958e-01f, 2.41880547e-02f, -2.49104425e-02f,
  2.34359160e-01f, -1.94584817e-01f, -8.22461247e-02f, -2.87392233e-02f, 5.77625036e-02f, 1.67583123e-01f, 2.78437823e-01f, -5.23098893e-02f, 3.79025787e-02f, -1.42534435e-01f,
  2.31218953e-02f, 1.97504222e-01f, -1.10402316e-01f, 2.04098731e-01f, 2.43528426e-01f, 1.83415681e-01f, 5.24120070e-02f, -3.94582003e-01f, 3.13486978e-02f, -3.28731418e-01f,
  -2.82152951e-01f, 1.92471861e-03f, 1.46169811e-01f, -1.39441356e-01f, 1.17742188e-01f, -4.20033671e-02f, -7.99753889e-02f, 1.13346480e-01f, -8.36570840e-03f, 8.68221931e-03f,
  2.38968328e-01f, -1.55725200e-02f, -1.92269608e-01f, -1.00648925e-01f, 2.54823528e-02f, -1.07875578e-02f, -4.34451327e-02f, -9.36487243e-02f, 1.36616873e-03f, -3.17247808e-02f,
  4.30709198e-02f, -5.90922013e-02f, -1.74075663e-02f, 5.79289012e-02f, 4.11912389e-02f, 1.05376229e-01f, -2.99454108e-02f, -7.09781647e-02f, -6.35097176e-02f, -4.05507237e-02f,
  -3.24205607e-02f, 1.29759640e-01f, 2.58893907e-01f, 5.83315380e-02f, -1.45527288e-01f, 5.06634042e-02f, 1.54736266e-01f, 1.36418357e-01f, -7.57700056e-02f, -2.41223965e-02f,
  -7.89093077e-02f, 1.47259951e-01f, 7.66953155e-02f, -9.34760422e-02f, 7.91317225e-02f, -9.95715410e-02f, -3.75658095e-01f, -2.00627729e-01f, -1.24719672e-01f, -1.17577761e-01f,
  -5.58467545e-02f, 1.27301151e-02f, -1.15674771e-01f, -1.89961586e-02f, -1.26430228e-01f, -5.57912402e-02f, -6.72219247e-02f, 8.89578462e-02f, 2.55260110e-01f, 1.78359553e-01f,
  -1.52918354e-01f, 2.27246016e-01f, 8.54911655e-02f, 1.12255737e-01f, 8.92053321e-02f, 1.18681781e-01f, 1.15772791e-01f, 6.59257323e-02f, -1.58043124e-03f, -2.38256633e-01f,
  2.42373850e-02f, -1.00921139e-01f, -3.56702954e-02f, -5.51257171e-02f, -1.47834733e-01f, -1.02629893e-01f, -1.64266139e-01f, 1.48888081e-02f, -1.47734672e-01f, -4.68705706e-02f,
  1.34340301e-01f, 9.88744572e-02f, -1.07765026e-01f, 5.44817969e-02f, -1.13648251e-01f, 4.84335162e-02f, 4.31999154e-02f, -9.78661925e-02f, 4.10781316e-02f, -2.95607764e-02f,
  -2.17032045e-01f, 1.56945348e-01f, 4.83857058e-02f, 1.58034712e-02f, -7.16747418e-02f, 1.83047861e-01f, -2.50555456e-01f, -1.05600394e-01f, -1.28261009e-02f, -4.80862893e-02f,
  5.67999519e-02f, -7.04793492e-03f, 1.95532545e-01f, 8.93728156e-03f, -2.56388709e-02f, 1.09879434e-01f, 6.47897720e-02f, -3.18476111e-02f, 2.73930401e-01f, 7.66179487e-02f,
  -1.83597609e-01f, 5.94122261e-02f, 2.94287354e-01f, 7.29461014e-02f, -4.17253040e-02f, -2.48648494e-01f, 1.18000038e-01f, -1.02917053e-01f, -1.65578887e-01f, -9.08337347e-03f,
  -6.45764768e-02f, 1.39603958e-01f, -4.76833098e-02f, 1.01009853e-01f, 6.67291805e-02f, -3.45783263e-01f, -8.87564346e-02f, -1.17086418e-01f, -1.13911040e-01f, 1.06667936e-01f,
  1.90416798e-01f, 8.55906978e-02f, 9.33906287e-02f, 1.04940064e-01f, -2.54734624e-02f, 3.29206400e-02f, -6.04183674e-02f, 1.43692508e-01f, -9.84667465e-02f, 8.04832876e-02f,
  8.86583142e-03f, -6.43615378e-03f, -1.26221642e-01f, 5.52552007e-02f, -2.35075373e-02f, 1.04711391e-02f, -9.97445062e-02f, 1.74946636e-01f, -3.93551476e-02f, -8.62385184e-02f,
  3.00790314e-02f, 3.89466956e-02f, -1.31468195e-02f, 1.98076176e-03f, 7.06433579e-02f, -1.59058318e-01f, 9.93566737e-02f, 1.58823594e-01f, -2.11938061e-02f, 8.79452154e-02f,
  -1.14827663e-01f, 9.79278237e-02f, 2.14307252e-02f, -3.59574109e-02f, -5.62387407e-02f, -1.00959837e-01f, -2.42598038e-02f, 1.98189512e-01f, 1.10396802e-01f, -5.76199628e-02f,
  5.02564982e-02f, 7.06586018e-02f, -9.97984931e-02f, -3.26303579e-02f, 2.93200970e-01f, 1.08434632e-02f, -1.26829237e-01f, -2.64768392e-01f, -2.99914405e-02f, 9.34626833e-02f,
  -5.81358261e-02f, 3.39123537e-03f, -2.04348210e-02f, -2.83926517e-01f, -1.86236367e-01f, -4.56448682e-02f, -4.72456813e-02f, 6.51522428e-02f, 8.19355845e-02f, 3.60209942e-02f,
  -1.24160470e-02f, 4.88617688e-01f, -1.56715512e-01f, 3.59103642e-02f, 1.61028087e-01f, 1.28173307e-01f, 9.41732526e-02f, 9.53432396e-02f, 6.21202961e-02f, -1.65690094e-01f,
  6.02517277e-03f, 4.04498987e-02f, -2.53462940e-01f, 7.12148324e-02f, 5.86747304e-02f, 8.67582336e-02f, 1.30797073e-01f, 8.13748688e-02f, -1.09203011e-01f, 2.14096848e-02f,
  4.62191505e-03f, -1.58232227e-01f, 1.21114917e-01f, -3.80789004e-02f, 5.01088426e-03f, 7.60670751e-02f, -2.11644061e-02f, -1.42469496e-01f, -9.35579538e-02f, 1.07883893e-01f,
  1.20676984e-03f, 1.57583579e-01f, 3.07800267e-02f, -1.71186507e-01f, -9.69149768e-02f, -1.15537576e-01f, 5.48013709e-02f, -1.39876604e-01f, -3.12150747e-01f, -4.23865356e-02f,
  -1.59162194e-01f, 1.96589753e-01f, 1.43519938e-01f, -2.84642220e-01f, -3.57026607e-02f, 1.14776306e-01f, -1.56565219e-01f, 3.79967429e-02f, 6.56091794e-02f, 1.22049920e-01f,
  -1.35776356e-01f, 1.19596571e-01f, -2.68506128e-02f, -3.44615541e-02f, -7.89422020e-02f, -1.72583967e-01f, 7.63254538e-02f, -4.17612791e-02f, 3.24875414e-02f, -3.19996715e-01f,
  -7.98539594e-02f, -1.15836911e-01f, 5.89013565e-03f, -1.77169114e-01f, -1.11657791e-01f, -5.01342751e-02f, -5.76341376e-02f, -2.12558806e-01f, -1.48874387e-01f, -1.04023606e-01f,
  -5.45663945e-02f, 1.17465965e-01f, -1.49052488e-02f, 1.60807624e-01f, -1.28163034e-02f, 1.09673783e-01f, 5.22497259e-02f, 1.57850742e-01f, 2.18560323e-01f, -1.37758227e-02f,
  1.21579081e-01f, 2.33525485e-02f, 3.08326501e-02f, 9.63224471e-02f, 1.70460075e-01f, -9.91817284e-03f, 1.31556392e-01f, 1.82351574e-01f, 4.70519476e-02f, 9.38339755e-02f,
  -2.69583240e-03f, 1.56915665e-01f, -9.40695107e-02f, 1.04450434e-01f, -7.53130391e-02f, -7.56796896e-02f, -3.63394469e-02f, -1.71779379e-01f, 9.23719779e-02f, -6.53245971e-02f,
  -1.19933985e-01f, 2.17100784e-01f, -1.40570000e-01f, 1.38157904e-01f, 1.50642604e-01f, -1.19096883e-01f, 1.07338473e-01f, -1.14366323e-01f, 1.40382409e-01f, 5.27569912e-02f,
  -3.52659784e-02f, 6.40218034e-02f, -8.73046517e-02f, 2.12605204e-02f, 1.74750909e-01f, 1.61475703e-01f, -1.59850623e-03f, 1.02391541e-01f, 1.74618866e-02f, 2.16630083e-02f,
  6.35269657e-02f, 2.38692433e-01f, -5.05553372e-02f, 1.13221392e-01f, 1.11452170e-01f, 2.19015460e-02f, -7.92853460e-02f, 6.97166706e-03f, -1.16848238e-01f, -2.05368191e-01f,
  1.26921400e-01f, -4.40269001e-02f, -8.70911628e-02f, -1.50680423e-01f, -1.93356141e-01f, -1.74668431e-01f, -5.30949682e-02f, -7.38475248e-02f, -4.00128886e-02f, -3.10310926e-02f,
  -1.34573907e-01f, 4.24709655e-02f, 3.86765227e-02f, 8.93631354e-02f, 3.02709162e-01f, -1.58769358e-02f, 1.69516563e-01f, -1.39489472e-01f, -8.43225643e-02f, 9.14423447e-03f,
  1.68111116e-01f, 7.15696365e-02f, 1.02802388e-01f, -1.95957366e-02f, 7.65802637e-02f, -2.70356208e-01f, -1.66870490e-01f, 1.44664943e-01f, 8.61622170e-02f, 1.84074596e-01f,
  1.22847565e-01f, 2.37298682e-02f, -3.34149227e-02f, -1.87079728e-01f, -2.79888004e-01f, -1.53095111e-01f, 1.87945385e-02f, -1.60587162e-01f, 1.15491385e-02f, 2.42223348e-02f,
  -1.19416803e-01f, -7.18601644e-02f, 1.38010114e-01f, 1.91027094e-02f, 4.96812500e-02f, -1.01562880e-01f, -2.51566209e-02f, 1.16210423e-01f, 1.48564234e-01f, 2.19759136e-01f,
  1.39447287e-01f, -6.68013170e-02f, 2.49493346e-01f, -4.20956276e-02f, -7.17579126e-02f, 8.35616663e-02f, -4.96712178e-02f, -1.90911710e-01f, -2.78074313e-02f, -1.05676524e-01f,
  3.33087072e-02f, -3.65699053e-01f, 2.41016820e-01f, -3.81301999e-01f, -1.36592254e-01f, 3.73463899e-01f, -9.07923207e-02f, 3.82855445e-01f, -1.41824082e-01f, -1.92298919e-01f,
  1.77179407e-02f, -2.73176990e-02f, -1.77507680e-02f, -2.65900102e-02f, -1.81136504e-02f, 6.94891065e-02f, 1.73065335e-01f, 7.50196129e-02f, 9.58551243e-02f, -1.64684113e-02f,
  -2.02480946e-02f, 5.54917082e-02f, 9.19871107e-02f, 1.04644552e-01f, 2.06100106e-01f, -2.83972733e-02f, 3.51581722e-02f, 2.08840162e-01f, -1.04113676e-01f, -6.14649951e-02f,
  -2.54461393e-02f, 2.66800970e-02f, 1.46422505e-01f, 6.21896572e-02f, -5.35502611e-03f, -7.10031092e-02f, -5.97911561e-03f, -2.42572874e-02f, -6.09574169e-02f, 7.12178499e-02f,
  -1.19689442e-01f, 6.69746324e-02f, 9.90321562e-02f, 4.57901657e-02f, 2.16519777e-02f, -1.42529068e-04f, 3.62900682e-02f, -9.12583768e-02f, -1.05849959e-01f, 1.31389007e-01f,
  4.71621007e-02f, -7.13980868e-02f, 7.21118599e-02f, 9.88401771e-02f, -2.80566067e-02f, 1.11918740e-01f, 1.11588694e-01f, -1.83510035e-02f, 1.94919944e-01f, 3.98609117e-02f,
  -2.81642321e-02f, -7.58625641e-02f, -6.07704706e-02f, -1.21561192e-01f, -1.39545456e-01f, 1.26872063e-01f, -6.95743561e-02f, 1.24555297e-01f, -7.56198948e-04f, 1.60828143e-01f,
  -2.28827372e-01f, 1.52798900e-02f, 8.14044569e-03f, -1.41758472e-01f, -2.18996033e-01f, 1.24344580e-01f, -6.58880547e-02f, 2.06408221e-02f, -1.00003086e-01f, 2.17545442e-02f,
  1.94070056e-01f, -2.59020785e-03f, 4.74439561e-02f, -7.72595927e-02f, -1.38880298e-01f, -1.18809640e-01f, 2.94271223e-02f, -8.71211365e-02f, -5.34914583e-02f, 3.99773428e-03f,
  -1.09683335e-01f, -6.57649785e-02f, -3.46693806e-02f, 2.31781136e-03f, -1.94645360e-01f, -1.09159432e-01f, 4.02347893e-02f, -2.13538572e-01f, -1.32262275e-01f, -3.85294378e-01f,
  2.38520149e-02f, -9.85364169e-02f, 1.04612060e-01f, 8.14971402e-02f, 1.01040468e-01f, -8.92751738e-02f, 4.16141339e-02f, -2.79322527e-02f, 1.23862047e-02f, -6.02491014e-02f,
  -1.20033450e-01f, -4.11283560e-02f, -1.66928634e-01f, -1.22531071e-01f, -1.67673603e-01f, 6.50136620e-02f, -2.30491564e-01f, 1.98636591e-01f, 2.15054289e-01f, 1.01554498e-01f,
  9.91487801e-02f, -3.00450623e-02f, 2.04959929e-01f, 6.92670122e-02f, 1.46578550e-02f, -1.07347406e-01f, -7.87767395e-02f, -2.74990331e-02f, 5.97853363e-02f, -2.41183513e-03f,
  -3.97456698e-02f, -2.51085013e-01f, 2.07844272e-01f, 1.18745618e-01f, -2.52538145e-01f, 1.81927621e-01f, -1.18413597e-01f, -1.96800500e-01f, 2.89401375e-02f, 5.66718951e-02f,
  5.85706905e-02f, 5.61049506e-02f, 9.15680826e-02f, 7.24775195e-02f, -5.06871156e-02f, 5.81861474e-03f, -6.45752251e-02f, 2.96559222e-02f, -1.54754752e-02f, 2.36367285e-02f,
  4.54526320e-02f, 7.27157369e-02f, 6.34763092e-02f, 3.79499905e-02f, 1.20499402e-01f, 5.80970906e-02f, -5.70412800e-02f, 1.59690142e-01f, -5.24648353e-02f, -1.54659405e-01f,
  -7.75076598e-02f, 1.75875247e-01f, -5.85747398e-02f, 1.27803937e-01f, -1.42197475e-01f, 5.11054546e-02f, -1.59163550e-02f, -1.67909302e-02f, -4.45605814e-02f, -7.18196630e-02f,
  -4.12848145e-02f, -9.71834082e-03f, 4.89680171e-02f, 2.32373178e-01f, -7.73165096e-03f, 2.86052637e-02f, 3.08925241e-01f, -1.33662328e-01f, -3.67268145e-01f, -6.33842647e-02f,
  3.37683737e-01f, -2.91180015e-01f, -2.23731279e-01f, 1.39371753e-01f, -2.08442509e-01f, -1.14598103e-01f, -4.17636275e-01f, -7.08168969e-02f, -1.24431588e-01f, -2.25932866e-01f,
  -1.91396818e-01f, 3.23736272e-03f, -6.97331354e-02f, -6.66439952e-03f, 7.04558715e-02f, 2.53558189e-01f, -8.48163813e-02f, -1.84268773e-01f, -5.57489283e-02f, -2.45601013e-01f,
  2.48137102e-01f, 1.43726066e-01f, -7.31837004e-02f, 3.54734585e-02f, -2.89609786e-02f, -1.59668744e-01f, 6.15813807e-02f, 4.16486291e-03f, 3.04071791e-02f, -7.02744126e-02f,
  4.09513945e-03f, 1.71914488e-01f, -1.18824407e-01f, -1.47314614e-03f, -4.03286368e-02f, -6.58621341e-02f, 5.07144332e-02f, 7.36995116e-02f, -1.93123100e-03f, 6.98835179e-02f,
  1.16165385e-01f, 8.71672183e-02f, 5.13327532e-02f, 2.43724689e-01f, 1.89457312e-01f, -3.16938400e-01f, -6.54146075e-02f, -3.06087941e-01f, 2.61237025e-01f, -9.77309421e-02f,
  3.86487730e-02f, -4.81151082e-02f, 7.44390264e-02f, -9.16051343e-02f, 7.64256567e-02f, -9.55105722e-02f, -2.17438728e-01f, -2.40502298e-01f, 1.46544904e-01f, -6.88000694e-02f,
  -2.45286822e-01f, -2.84912474e-02f, -1.66212559e-01f, -2.51422524e-02f, -6.71401024e-02f, 3.36882174e-01f, 1.84960529e-01f, -2.66941916e-02f, 3.23874578e-02f, -7.70128658e-03f,
  2.58074552e-01f, -1.64220721e-01f, 1.00633591e-01f, 1.79003939e-01f, 1.09644264e-01f, -5.08615598e-02f, -1.38534093e-02f, -7.41156861e-02f, 2.67530163e-03f, -2.65162677e-01f,
  1.49066851e-03f, 3.26250307e-02f, 8.34842697e-02f, -4.92181629e-02f, -1.29745603e-01f, -2.55005062e-01f
};

// L1_fan_Wp_bar (Shape: 26 x 64)
const int L1_fan_Wp_bar_rows = 26;
const int L1_fan_Wp_bar_cols = 64;
const float L1_fan_Wp_bar_data[] = {
  9.81733575e-02f, -3.62894908e-02f, -1.02461033e-01f, 1.85857818e-01f, 5.45222536e-02f, 3.45143497e-01f, 1.01981059e-01f, 1.44039065e-01f, 1.74394518e-04f, 1.03686221e-01f,
  1.45922616e-01f, -2.41324641e-02f, 2.77525634e-01f, 2.34403193e-01f, 1.30228370e-01f, 6.78854659e-02f, 2.22467944e-01f, -4.43318747e-02f, 8.43500346e-02f, 7.98540041e-02f,
  -2.67155260e-01f, -1.89965010e-01f, -8.68356526e-02f, 1.49938032e-01f, 3.60776961e-01f, 8.98618922e-02f, 2.04267576e-01f, -1.36521012e-01f, -1.68879569e-01f, -2.03421429e-01f,
  -2.09981933e-01f, 1.07051339e-02f, -2.69804209e-01f, 1.16215102e-01f, -2.03296572e-01f, -1.26819149e-01f, 2.02549890e-01f, 1.01350233e-01f, 2.50186682e-01f, -9.26371962e-02f,
  -3.10635149e-01f, -3.41453850e-01f, -1.03792667e-01f, 2.31195077e-01f, -2.76440740e-01f, 2.27823377e-01f, 5.80028296e-02f, -1.98621526e-02f, -4.34568264e-02f, 1.72688048e-02f,
  -6.67458028e-02f, -1.99675277e-01f, -3.81028861e-01f, -3.11377253e-02f, -3.78068030e-01f, -1.56845197e-01f, -1.97188348e-01f, 1.99976504e-01f, -1.46326929e-01f, -7.81286135e-02f,
  1.52648306e-02f, -1.15060620e-01f, 4.13495332e-01f, -5.50383441e-02f, 1.88289508e-01f, 8.74628872e-03f, -2.99085658e-02f, 1.60777062e-01f, 7.55085796e-02f, 4.77212295e-02f,
  -9.14146155e-02f, -3.68704982e-02f, 1.43351257e-01f, -4.97350767e-02f, 2.55566716e-01f, 2.25758135e-01f, 1.08456224e-01f, 1.03795655e-01f, -3.10776494e-02f, 1.36601225e-01f,
  1.78889424e-01f, 9.40429792e-02f, 6.42988272e-03f, 4.50438708e-02f, -2.36681644e-02f, -1.18280001e-01f, -3.04271095e-02f, -1.82904035e-01f, 3.39530106e-03f, 3.81947041e-01f,
  5.89289293e-02f, 5.86649552e-02f, -9.08831879e-02f, -3.09095308e-02f, 1.04234993e-01f, -3.93122993e-02f, 2.53743725e-03f, -1.15481444e-01f, 2.08726572e-03f, 9.54725072e-02f,
  8.43944997e-02f, -6.13860413e-02f, 1.77001923e-01f, -1.23258471e-01f, 6.00062385e-02f, -9.33000222e-02f, 2.63841420e-01f, -2.80483723e-01f, 1.39217854e-01f, 8.19865465e-02f,
  -9.87432213e-05f, -1.13217056e-01f, 4.54568025e-03f, -2.42137089e-01f, -1.30222917e-01f, 2.86551684e-01f, 1.26241267e-01f, 2.33062729e-02f, 2.91494559e-02f, 4.77065034e-02f,
  5.38078249e-02f, 2.34438419e-01f, -5.39277717e-02f, 1.11882582e-01f, 7.87812918e-02f, 5.53350411e-02f, 1.20933510e-01f, 1.70874730e-01f, 3.81811671e-02f, 4.65545356e-02f,
  2.89354231e-02f, 3.67743075e-02f, -1.23384021e-01f, 1.44216865e-01f, 9.17171389e-02f, 7.12853894e-02f, 9.91269425e-02f, 9.37393606e-02f, 1.52575225e-01f, 4.96698990e-02f,
  -6.51952773e-02f, 2.33684368e-02f, -1.20547943e-01f, 2.33528372e-02f, 1.45906314e-01f, -3.95643339e-02f, 1.09431371e-01f, -2.65619922e-02f, 5.34392968e-02f, 1.63411111e-01f,
  -8.40593204e-02f, 5.51710911e-02f, -3.17334741e-01f, 7.60635883e-02f, -2.18676522e-01f, -1.66873291e-01f, 9.03197452e-02f, -1.97120726e-01f, -3.90629359e-02f, -4.19578403e-02f,
  1.75754756e-01f, -1.97983515e-02f, 1.44529670e-01f, 2.07366526e-01f, -4.69294749e-02f, -4.11012955e-02f, 3.12898219e-01f, 3.84990610e-02f, -5.93446335e-03f, 1.69809073e-01f,
  4.58005220e-01f, -8.05182680e-02f, -5.58348484e-02f, 2.84565520e-02f, 4.10816958e-03f, -2.53770929e-02f, -1.77875012e-01f, 1.04828335e-01f, -3.43067646e-02f, 1.20542198e-01f,
  -1.01447403e-01f, 1.68670967e-01f, 9.75736044e-03f, -6.46895841e-02f, -1.76810045e-02f, -1.77818984e-01f, 1.38179645e-01f, -1.52469367e-01f, -1.33482113e-01f, 7.71496370e-02f,
  7.81249776e-02f, -9.97063145e-03f, 9.70217437e-02f, -2.29978096e-02f, 3.94719429e-02f, -6.50318637e-02f, 2.12953731e-01f, 4.63087447e-02f, -5.50611094e-02f, 1.49175569e-01f,
  -1.50675654e-01f, 4.70131449e-03f, -5.57388552e-02f, 1.47951379e-01f, -4.29655463e-02f, 3.13404389e-02f, 5.04386872e-02f, 9.42877233e-02f, -1.25781270e-02f, 1.78161636e-01f,
  -8.60762820e-02f, 9.45613980e-02f, 1.22615322e-01f, 2.83304285e-02f, -6.30952343e-02f, -2.70123899e-01f, -9.92444456e-02f, -9.74066034e-02f, 3.19951884e-02f, 1.36912661e-03f,
  5.36837541e-02f, -6.12070877e-03f, -1.37366755e-02f, -1.97558701e-02f, -6.76870197e-02f, -1.30977884e-01f, -1.19477183e-01f, -5.24513461e-02f, 2.42183004e-02f, 1.07541867e-01f,
  2.95331068e-02f, 4.00547907e-02f, 1.92515388e-01f, 8.01289007e-02f, -1.97384447e-01f, -2.12434217e-01f, 3.30834538e-01f, 6.05063513e-04f, -1.37133226e-01f, 5.50806336e-02f,
  9.47562829e-02f, 1.57975312e-02f, 3.51331711e-01f, 2.79436737e-01f, 3.38833183e-01f, 1.02429405e-01f, 1.91366121e-01f, -5.61030507e-02f, 2.18151331e-01f, 5.74988686e-02f,
  -1.24491341e-01f, -4.54333909e-02f, 3.22529793e-01f, -6.06147712e-03f, -8.55038241e-02f, 1.70937061e-01f, 3.58411251e-03f, -1.71623006e-02f, 2.22290028e-02f, 2.44971439e-02f,
  1.22996435e-01f, -2.01271866e-02f, -1.70022771e-01f, -5.38931880e-03f, -1.52370892e-02f, -1.85585514e-01f, 1.61640495e-01f, 3.77625600e-02f, 9.13589150e-02f, 4.45069596e-02f,
  -1.53743356e-01f, 1.12100735e-01f, 1.95577145e-01f, -7.26875961e-02f, 1.29651085e-01f, -1.26755297e-01f, -3.97368185e-02f, 9.93050039e-02f, -4.79387529e-02f, 8.39812830e-02f,
  -2.56133795e-01f, 3.15045238e-01f, -1.99742422e-01f, -7.87682459e-02f, -1.03303842e-04f, -2.49840692e-01f, 1.80632882e-02f, -1.93938047e-01f, 2.96551660e-02f, 2.38743350e-02f,
  1.35820612e-01f, 1.63639411e-01f, -1.55234620e-01f, -1.16539530e-01f, 3.83968145e-01f, 1.53704211e-01f, -1.70632645e-01f, 1.36388466e-01f, 3.37983221e-01f, 7.34786242e-02f,
  9.76768509e-02f, -1.88193768e-01f, -4.31724079e-02f, 5.79646230e-02f, -3.71235669e-01f, 2.62919515e-01f, -1.35580987e-01f, 3.07565406e-02f, -1.17451034e-01f, 1.61318749e-01f,
  -5.99303208e-02f, -1.60691202e-01f, 4.59434874e-02f, -1.28788188e-01f, -4.48865891e-02f, -8.00941512e-02f, -5.81823476e-02f, -1.65649965e-01f, -5.27995378e-02f, 9.21368077e-02f,
  -2.02224832e-02f, -6.10210188e-02f, 1.27923600e-02f, 6.78691268e-02f, 4.85438481e-02f, -1.55316328e-03f, 1.67754546e-01f, -1.34524241e-01f, 3.79229337e-02f, -2.48241909e-02f,
  3.54440100e-02f, -5.02395034e-02f, 6.11902997e-02f, 2.81295832e-02f, 2.53933799e-02f, 1.50465209e-03f, 2.87514739e-02f, 8.26151967e-02f, -1.24404684e-01f, 7.43415877e-02f,
  9.57024470e-02f, -1.51398182e-01f, -2.14256063e-01f, 2.62010135e-02f, -7.07151592e-02f, -9.78881493e-02f, -2.57813875e-02f, 1.18024416e-01f, -9.24197584e-02f, 7.28502944e-02f,
  -6.69338703e-02f, 3.04707065e-02f, -1.67677730e-01f, -1.34041175e-01f, 6.22667186e-02f, -1.74321979e-01f, 2.66323835e-02f, 1.56660110e-01f, -2.51246504e-02f, 2.22862750e-01f,
  4.11192067e-02f, -1.48868829e-01f, 1.77599415e-01f, -2.79016912e-01f, -4.99536544e-01f, 1.47611588e-01f, 1.38438031e-01f, 7.99648240e-02f, -1.29040033e-01f, -3.15758348e-01f,
  5.14719710e-02f, 3.50941010e-02f, -2.24376749e-02f, -3.98085937e-02f, -1.95670426e-01f, 3.30334574e-01f, -1.85271367e-01f, 3.46071303e-01f, 1.66509762e-01f, 1.27730414e-01f,
  -9.18414518e-02f, 2.38462202e-02f, -3.74647602e-02f, -3.44148241e-02f, -1.97583199e-01f, -2.88360715e-02f, -5.34902960e-02f, 1.33508250e-01f, 5.87994680e-02f, -9.31514874e-02f,
  2.06812322e-02f, -6.60137981e-02f, 3.69645841e-02f, 5.87591343e-02f, 1.03254288e-01f, -3.60472761e-02f, 1.08803362e-01f, 1.73582241e-01f, -1.90872982e-01f, -1.29102036e-01f,
  2.16431934e-02f, 1.39839754e-01f, -1.53438985e-01f, 2.24588484e-01f, 1.66690841e-01f, -1.71897873e-01f, -1.84197128e-01f, 1.08719423e-01f, -2.05400631e-01f, -1.20385319e-01f,
  -7.02319741e-02f, 1.34584606e-01f, -2.69411355e-02f, 9.46548879e-02f, -1.08326845e-01f, 8.59574452e-02f, -3.91018279e-02f, -2.33998820e-01f, 2.07407400e-01f, -2.65509244e-02f,
  -9.71111841e-03f, 9.57812816e-02f, 8.95581692e-02f, 6.38231486e-02f, 1.77590981e-01f, 7.36704050e-03f, -5.42510711e-02f, -1.77642450e-01f, -4.30929899e-01f, 3.45213503e-01f,
  9.64297447e-03f, -1.33944582e-02f, -2.46569104e-02f, -3.14414594e-03f, 1.28733248e-01f, -3.54848728e-02f, -1.35050967e-01f, -2.06102386e-01f, -8.73994008e-02f, 1.90659374e-01f,
  -3.54306474e-02f, -9.70322639e-03f, 3.11643183e-01f, -1.90125667e-02f, -1.23080172e-01f, -4.00921032e-02f, -2.05085769e-01f, -1.58332400e-02f, 5.25767207e-02f, -9.17813089e-03f,
  7.53159523e-02f, 8.27878937e-02f, 2.85387725e-01f, 9.72490162e-02f, -4.45361808e-02f, 1.53409034e-01f, -1.68733373e-02f, 6.29219711e-02f, 1.75553590e-01f, 2.07823798e-01f,
  3.26125734e-02f, 1.36250511e-01f, 1.24374494e-01f, 1.29883945e-01f, 4.71414067e-02f, 3.63549441e-02f, 5.85592724e-02f, 1.22703180e-01f, 1.17094040e-01f, -1.01914331e-02f,
  -1.21729910e-01f, 3.25287953e-02f, 1.24130093e-01f, 3.96221846e-01f, -2.92751715e-02f, 5.06226718e-02f, -6.79120794e-02f, 5.95963188e-02f, 1.29489839e-01f, 7.77721405e-02f,
  5.36159799e-02f, 4.31618690e-02f, 4.46767919e-02f, 3.12302709e-01f, -4.44857590e-02f, -1.60789993e-02f, 6.52751401e-02f, -6.49605552e-03f, -5.71427196e-02f, 1.56454239e-02f,
  1.62301973e-01f, -3.20890099e-01f, 1.10087201e-01f, -7.15227500e-02f, -2.88117696e-02f, 1.93276498e-02f, -1.07124574e-01f, 5.00255190e-02f, -1.36392251e-01f, 1.87638015e-01f,
  7.92347416e-02f, 1.12935513e-01f, 3.00219785e-02f, -2.72071678e-02f, 2.08403483e-01f, 4.23534632e-01f, -1.83305472e-01f, -1.05966181e-01f, 1.38787940e-01f, 1.07460387e-01f,
  1.98932812e-01f, 1.02710038e-01f, 6.90973923e-02f, -4.18421701e-02f, 3.10187321e-02f, 1.07631557e-01f, -8.55474994e-02f, -2.61157393e-01f, 7.55876154e-02f, -2.04594910e-01f,
  -1.40969843e-01f, -1.15319043e-01f, -1.19932823e-01f, -1.03815697e-01f, -7.11346939e-02f, -3.52178328e-02f, -7.18004555e-02f, 4.52311523e-03f, -1.17190935e-01f, -7.68155530e-02f,
  9.76312980e-02f, 8.28628317e-02f, 1.49273202e-01f, -1.86095491e-01f, 1.70294985e-01f, -7.63163343e-02f, -2.29393333e-01f, -2.11155973e-02f, 2.75059581e-01f, 1.02837622e-01f,
  -1.34927481e-01f, 2.17424512e-01f, 2.04143509e-01f, 2.01991796e-01f, 2.18821302e-01f, -6.81563513e-03f, -8.64169672e-02f, -1.97503507e-01f, -2.34876797e-02f, -9.13844407e-02f,
  -1.26697719e-01f, -6.56148344e-02f, -2.24982858e-01f, -5.26071191e-02f, -3.18803042e-01f, -1.09723665e-01f, 6.35712743e-02f, -1.39428288e-01f, -5.79788201e-02f, 1.26963496e-01f,
  3.84969190e-02f, -6.26501488e-03f, 2.69300878e-01f, 2.22921014e-01f, 7.55074844e-02f, -4.93474565e-02f, -1.17417304e-02f, 2.02584192e-01f, -1.29286563e-02f, -7.91460425e-02f,
  3.45631629e-01f, -3.11988834e-02f, 2.14779139e-01f, -1.53422013e-01f, -4.30935435e-02f, -1.32261157e-01f, -5.41744800e-03f, -1.29787341e-01f, 5.10147884e-02f, 3.46773379e-02f,
  3.95099586e-03f, 1.01612220e-02f, -1.22812428e-01f, 7.51895979e-02f, -1.01919679e-04f, -1.00746229e-02f, -4.68652435e-02f, 8.49115551e-02f, -9.60889682e-02f, 1.42163813e-01f,
  9.30969417e-02f, -4.24423590e-02f, -2.61922423e-02f, 5.20938486e-02f, 1.66954309e-01f, 7.27577135e-02f, -8.16154480e-02f, -1.46631926e-01f, -1.04930378e-01f, 1.55698940e-01f,
  7.50215873e-02f, 6.38332292e-02f, 1.24844298e-01f, 3.14975232e-02f, -5.93816750e-02f, -1.32035348e-03f, -5.03028110e-02f, 3.17164361e-02f, -1.68958694e-01f, -2.18298912e-01f,
  1.59054771e-01f, -1.47120476e-01f, 1.43005967e-01f, 1.24262281e-01f, -3.85497779e-01f, 3.65510248e-02f, -3.97854596e-02f, -3.45376313e-01f, 2.16760814e-01f, -1.11363985e-01f,
  -3.14912081e-01f, 2.17908487e-01f, 6.21913597e-02f, 2.68716067e-01f, -1.81133673e-01f, -1.56271309e-02f, 1.01519816e-01f, 7.59181892e-03f, -3.39571685e-01f, -3.27760875e-01f,
  -1.39590994e-01f, -3.88245942e-04f, -8.83240625e-02f, -1.21993264e-02f, 5.97286820e-02f, -2.22419132e-03f, -1.41193882e-01f, 3.41993757e-02f, -3.16755354e-01f, -7.46550709e-02f,
  3.87890562e-02f, -1.07023716e-01f, 6.64858595e-02f, 6.07108772e-02f, 1.18274860e-01f, 1.62985101e-01f, -1.81699879e-02f, 1.09487250e-01f, 1.32923340e-02f, 2.55784933e-02f,
  1.14320613e-01f, 2.08340771e-02f, 2.70884544e-01f, 1.52979702e-01f, 3.43678258e-02f, 2.86403913e-02f, -6.96909055e-02f, 9.35022905e-02f, 1.52676320e-03f, 1.16854109e-01f,
  -7.75592998e-02f, 6.96104467e-02f, -4.88436520e-02f, -3.23332585e-02f, 2.06799537e-01f, 1.02383584e-01f, 1.38146609e-01f, 1.23620689e-01f, 8.50909203e-03f, 1.00856714e-01f,
  1.68922856e-01f, 1.47791967e-01f, 9.21037570e-02f, -1.09722810e-02f, -1.15353785e-01f, -7.20542017e-03f, 1.49559617e-01f, 3.81194800e-02f, -2.58925725e-02f, -1.98438436e-01f,
  -2.01617554e-01f, -1.77778006e-01f, -3.02406549e-02f, 1.14596792e-01f, -1.59041621e-02f, -1.52707189e-01f, 5.34054078e-02f, -3.29363883e-01f, 2.10056022e-01f, 7.35297352e-02f,
  -1.21799774e-01f, 5.93737066e-02f, 2.50580490e-01f, 1.19873613e-01f, -3.42770442e-02f, -7.28969201e-02f, 2.65577257e-01f, 2.47007251e-01f, 6.81503937e-02f, 1.56577796e-01f,
  5.85979335e-02f, -5.69687597e-02f, 1.85030311e-01f, 1.62612081e-01f, -3.45521644e-02f, -1.30596263e-02f, 1.87404118e-02f, 6.03358448e-02f, 1.10951528e-01f, -3.95870768e-02f,
  -9.58564058e-02f, 9.54184607e-02f, -2.83168722e-02f, 2.69263443e-02f, 9.34800133e-02f, -2.96982471e-02f, 5.54568693e-03f, 1.26146838e-01f, -4.85322103e-02f, -2.92728841e-02f,
  1.29828557e-01f, 7.34972581e-02f, 7.76593983e-02f, -1.55342564e-01f, 9.40937996e-02f, 7.06497058e-02f, -3.00563257e-02f, 2.05895126e-01f, 2.11853366e-02f, 1.48880988e-01f,
  -1.47002339e-01f, 1.11499280e-01f, 1.09004490e-01f, -1.18804641e-01f, -1.35622382e-01f, 2.00838852e-03f, -9.62319318e-03f, 4.26636934e-02f, 3.90617698e-02f, 9.82997864e-02f,
  -1.00998536e-01f, 8.89726281e-02f, 3.78702581e-02f, 1.84336156e-01f, 1.01284906e-01f, -4.07415070e-02f, 6.56273291e-02f, -1.15431234e-01f, 6.29065856e-02f, -6.42338861e-03f,
  6.01949841e-02f, 1.72401771e-01f, -5.44000827e-02f, -1.30764857e-01f, 2.57687122e-01f, 3.20777334e-02f, 8.68531168e-02f, 1.90375954e-01f, 2.72374481e-01f, 4.99738241e-03f,
  1.01944849e-01f, 8.51890296e-02f, -5.35934195e-02f, -7.34175509e-03f, 1.59276605e-01f, 7.58204088e-02f, 7.43134841e-02f, 2.16067091e-01f, 6.27029464e-02f, -3.19020338e-02f,
  -8.66237357e-02f, 1.95663273e-01f, 8.00065994e-02f, -6.34183064e-02f, -6.02489635e-02f, -7.75992572e-02f, 1.08350247e-01f, -2.33446378e-02f, -1.13356136e-01f, -4.16181795e-02f,
  8.78402665e-02f, 4.81108800e-02f, 1.27260178e-01f, -7.17529505e-02f, 1.24833889e-01f, 1.45977229e-01f, 3.44264843e-02f, 2.32377928e-02f, 1.31494805e-01f, -6.40600845e-02f,
  -9.99584142e-03f, -2.50972006e-02f, 8.57645869e-02f, 2.96930790e-01f, 2.72969812e-01f, 2.32538238e-01f, -3.72522846e-02f, 4.64670286e-02f, 2.06207186e-01f, 1.03960551e-01f,
  -6.93741664e-02f, 2.86121462e-02f, 1.49940372e-01f, -2.65528727e-02f, 7.22856522e-02f, -5.45578152e-02f, -2.27153257e-01f, -6.37499169e-02f, -2.43766815e-03f, -2.75712729e-01f,
  -2.20871300e-01f, -6.47280440e-02f, 1.85531259e-01f, 6.55703992e-02f, -5.60463406e-02f, 9.02593210e-02f, 1.35751516e-01f, -7.96003938e-02f, 2.95837998e-01f, 2.69484997e-01f,
  3.11581016e-01f, 2.73920149e-01f, 5.41153625e-02f, 1.72343299e-01f, 2.77584165e-01f, 2.38333657e-01f, 2.24007979e-01f, -2.04865813e-01f, 1.08672999e-01f, -4.66124341e-02f,
  -2.53041685e-02f, 1.89511791e-01f, 9.33445916e-02f, 2.91451998e-02f, -8.34479332e-02f, -5.36332615e-02f, 2.57356968e-02f, -7.55174085e-02f, 1.45346165e-01f, -2.01568343e-02f,
  9.08821449e-02f, 1.35548845e-01f, 2.00613798e-03f, 3.86118144e-02f, 5.42001426e-02f, 1.12297438e-01f, -5.78250783e-03f, 9.08759758e-02f, 7.38843856e-03f, 5.28348908e-02f,
  6.11107536e-02f, 1.58548839e-02f, -6.86733350e-02f, -6.22793250e-02f, 2.31276512e-01f, 2.30737161e-02f, -3.84971589e-01f, -2.87594199e-01f, 2.13064700e-01f, 1.49877235e-01f,
  -2.34513301e-02f, -1.72852218e-01f, -1.43117845e-01f, -1.10768385e-01f, 1.90675169e-01f, -6.80780336e-02f, -5.85086681e-02f, -4.64026421e-01f, -4.88284454e-02f, -6.08463325e-02f,
  -8.10337514e-02f, -1.77409500e-01f, 3.05363238e-01f, 1.46274328e-01f, -1.54771417e-01f, 2.20565423e-01f, 3.35640758e-02f, 5.13223037e-02f, -3.43550771e-01f, 1.16862496e-02f,
  -1.10353090e-01f, 1.48994669e-01f, 2.80983627e-01f, -3.31828967e-02f, -5.17964251e-02f, -3.57419848e-02f, 3.37904096e-01f, 1.63328975e-01f, -1.50571421e-01f, -4.07174975e-01f,
  2.02756152e-01f, -1.59367129e-01f, -2.80532748e-01f, -5.02421200e-01f, -3.80800337e-01f, -2.45153129e-01f, -1.19936308e-02f, -3.85145191e-03f, 1.70943975e-01f, -3.29364948e-02f,
  -7.06685409e-02f, 1.48027554e-01f, 7.40252882e-02f, 8.03843513e-02f, 3.87287736e-02f, 1.64630815e-01f, -1.38161853e-01f, 5.22802100e-02f, 1.44862488e-01f, -1.24472693e-01f,
  2.19263192e-02f, 9.83363688e-02f, 6.83979839e-02f, 3.95084843e-02f, 4.07049479e-03f, 1.30088534e-02f, -6.67906478e-02f, 2.91390359e-01f, -3.97851542e-02f, -1.89838946e-01f,
  6.05224967e-02f, -8.53086486e-02f, 2.35456042e-02f, -1.81956410e-01f, -5.08048944e-02f, -3.75380255e-02f, -1.69694334e-01f, 4.16429155e-02f, -5.66189848e-02f, -3.04969922e-02f,
  -1.42072469e-01f, -2.63669610e-01f, 1.34529592e-02f, -2.26315148e-02f, -2.13537484e-01f, -1.11320563e-01f, 3.81146818e-02f, 1.02444008e-01f, -2.42451370e-01f, 2.52302796e-01f,
  1.11068495e-01f, 3.92877460e-02f, -1.27950519e-01f, -5.74202538e-02f, 2.18991071e-01f, 2.32562628e-02f, -9.34851691e-02f, -1.04992718e-01f, 3.32396291e-02f, 4.06899340e-02f,
  -5.81609495e-02f, -6.08307347e-02f, 2.77337655e-02f, -7.93101117e-02f, -4.10591923e-02f, 7.76863098e-02f, 8.44514966e-02f, -7.02732131e-02f, 5.65740243e-02f, 8.89576823e-02f,
  5.22052832e-02f, 7.43317325e-03f, 2.24509444e-02f, 1.22540228e-01f, -5.25506064e-02f, -3.47333252e-02f, 1.76632121e-01f, -1.10578183e-02f, 4.24999325e-03f, 1.57813802e-02f,
  1.12061631e-02f, 1.55328084e-02f, -7.80009180e-02f, -7.00095743e-02f, 1.75119996e-01f, 1.58003479e-01f, 2.05981538e-01f, -4.87969583e-03f, 1.85482845e-01f, 9.59220901e-03f,
  4.11136784e-02f, -1.08091258e-01f, 1.13878161e-01f, 2.38899235e-02f, -3.68521273e-01f, 9.85059887e-02f, -2.57911421e-02f, 3.26802284e-02f, 4.83037606e-02f, -1.64035007e-01f,
  1.27416387e-01f, -1.44281253e-01f, 2.06792906e-01f, 2.86288513e-03f, 1.00742683e-01f, -2.53641456e-02f, 7.25254044e-03f, 1.31361634e-02f, 5.50720215e-01f, 4.88861352e-02f,
  -2.74388050e-03f, 1.24178194e-01f, 2.28221089e-01f, 2.35022187e-01f, -1.97306573e-01f, 4.27124426e-02f, 1.25495344e-01f, -1.58567280e-01f, -3.25361639e-01f, 2.92726070e-01f,
  3.18795964e-02f, 2.20820293e-01f, 6.10645264e-02f, 7.91718215e-02f, 2.68217206e-01f, 9.22666863e-02f, 1.23473397e-02f, -9.99066457e-02f, 1.12795256e-01f, -8.41466337e-02f,
  -1.28480047e-01f, -2.35637665e-01f, 4.52933833e-02f, 5.09734116e-02f, 9.27425921e-02f, -7.64751108e-03f, -2.01257125e-01f, 1.24154978e-01f, -1.35711133e-01f, -2.76176650e-02f,
  4.51657511e-02f, 1.53519008e-02f, -1.30022578e-02f, -3.34951095e-02f, 7.31571838e-02f, 1.40748103e-03f, 1.01436742e-01f, 3.51558649e-03f, 1.00113586e-01f, 3.49683054e-02f,
  1.36573672e-01f, 5.46617433e-02f, -1.42668188e-01f, 1.71240315e-01f, -7.22021312e-02f, -6.91626668e-02f, 7.41489828e-02f, 3.03096384e-01f, 1.02812378e-02f, -1.90783956e-03f,
  -9.06312838e-02f, -1.29443612e-02f, -8.70840177e-02f, 4.33035903e-02f, -8.93017948e-02f, 1.80181414e-01f, -1.00322232e-01f, -9.29853097e-02f, 1.81646109e-01f, -4.50406559e-02f,
  1.87464327e-01f, -9.70325619e-02f, 2.47127235e-01f, -4.39125150e-02f, -3.11655432e-01f, -1.06962889e-01f, 2.42856354e-01f, 5.72569855e-02f, -3.47524345e-01f, 4.27567288e-02f,
  1.34140372e-01f, 1.80707112e-01f, -7.54190758e-02f, 2.09591493e-01f, -8.23984668e-02f, -5.19649051e-02f, 1.91886853e-02f, 8.34147166e-03f, -3.08815897e-01f, -8.85910168e-02f,
  5.35982400e-02f, 2.03148983e-02f, 1.41800389e-01f, 4.54985313e-02f, -4.14201826e-01f, 1.89941830e-03f, 1.06963545e-01f, -2.47989185e-02f, 1.26425609e-01f, 2.39713252e-01f,
  2.46487528e-01f, -1.61034167e-02f, 7.85423592e-02f, -8.61562639e-02f, 1.42726928e-01f, -7.93229416e-02f, -5.67582287e-02f, -4.26645689e-02f, 1.00308582e-01f, 1.02454729e-01f,
  -2.67573372e-02f, -1.27673343e-01f, -6.37526661e-02f, 7.54933879e-02f, -1.09142169e-01f, -1.02667257e-01f, -1.07861631e-01f, -2.20635943e-02f, -8.60856622e-02f, 1.07819311e-01f,
  2.58256812e-02f, -1.43268064e-01f, 3.75426672e-02f, -6.41467720e-02f, -2.23290082e-02f, -1.40819699e-01f, 4.52518426e-02f, 1.86870784e-01f, 1.45731390e-01f, 5.83488531e-02f,
  1.93265766e-01f, 1.21223964e-01f, -1.40213042e-01f, 2.44868621e-01f, -2.82933339e-02f, -6.09726496e-02f, -5.98416366e-02f, -1.22172432e-03f, -2.02080250e-01f, 2.33457372e-01f,
  2.32854262e-01f, 1.86581671e-01f, 4.01032031e-01f, -2.03177452e-01f, -5.84702529e-02f, 3.10989112e-01f, -1.47719711e-01f, 8.28608721e-02f, -1.94707245e-01f, 3.28726098e-02f,
  -3.73856537e-02f, -1.00589551e-01f, -2.06529379e-01f, -8.22717845e-02f, 1.88304279e-02f, -4.54168111e-01f, 3.84568865e-03f, -2.23523285e-02f, -3.60504761e-02f, -4.42401692e-02f,
  1.30788326e-01f, -1.41320094e-01f, -1.62088662e-01f, -5.28035406e-03f, -4.49584797e-02f, -2.78859623e-02f, -4.48668748e-02f, -2.94286180e-02f, 8.64439160e-02f, -1.43122032e-01f,
  1.21840179e-01f, -1.67371687e-02f, 6.21297285e-02f, -5.18844314e-02f, 6.40223473e-02f, 4.27436419e-02f, -1.31089166e-01f, 5.47367595e-02f, 5.50807407e-03f, -7.30417743e-02f,
  -6.10057190e-02f, 1.52025327e-01f, 1.69960424e-01f, -1.44932806e-01f, -8.45909268e-02f, 1.94441423e-01f, -1.87010616e-01f, -6.91814125e-02f, -5.88086993e-02f, 4.68425034e-03f,
  -7.66449794e-02f, -4.86547463e-02f, -9.31486040e-02f, 4.94394004e-02f, -1.85884371e-01f, -4.45978157e-02f, 2.19275862e-01f, -9.95785892e-02f, 5.47376163e-02f, 9.97848958e-02f,
  -1.04810618e-01f, 2.36334100e-01f, -3.41729708e-02f, 1.20144278e-01f, -2.72723854e-01f, -2.76093441e-03f, -3.33976746e-01f, 4.01130468e-01f, -5.24474382e-02f, 1.53611422e-01f,
  -1.41529202e-01f, 1.77054167e-01f, 1.40497550e-01f, -7.40531087e-02f, -1.85033813e-01f, -9.17169526e-02f, -3.66137475e-02f, 1.96579501e-01f, -6.69854954e-02f, -1.44992143e-01f,
  1.71290353e-01f, -1.35406360e-01f, -2.06988961e-01f, -4.02782261e-02f, -2.47252852e-01f, -1.08445361e-02f, 8.74676406e-02f, -5.37461191e-02f, 1.34675816e-01f, 8.44191238e-02f,
  -8.75941664e-02f, -1.74023449e-01f, 3.22270170e-02f, -1.09474398e-01f, 5.91488928e-03f, 1.92767233e-02f, -9.37807783e-02f, 4.31156121e-02f, -3.15945828e-03f, -3.32693756e-03f,
  -2.08373051e-02f, 4.38984819e-02f, 7.72574618e-02f, -2.16238964e-02f, -7.45148659e-02f, 1.87580913e-01f, 8.23239088e-02f, 4.53037024e-02f, 7.14548677e-02f, -4.46896479e-02f,
  2.20447592e-02f, 1.97272487e-02f, -1.26510691e-02f, -2.13037264e-02f, -2.09452823e-01f, 1.61403790e-01f, 8.98287669e-02f, 2.20719233e-01f, 1.00280292e-01f, -7.63637647e-02f,
  -6.11037984e-02f, -3.98774967e-02f, -5.74269751e-03f, -1.40983099e-02f, -1.01111688e-01f, 2.35189646e-01f, -2.35675141e-01f, -6.76985011e-02f, 4.08983324e-03f, 1.25461444e-01f,
  -1.65049851e-01f, -2.08307981e-01f, -4.10268595e-03f, 1.40843645e-01f, 2.71577358e-01f, 1.73479781e-01f, 4.03735608e-01f, 2.81104088e-01f, -6.55421242e-02f, -9.29863453e-02f,
  -2.23958865e-01f, 1.07491583e-01f, 9.26716402e-02f, 7.92615861e-03f, 4.73693460e-01f, -8.73722062e-02f, 1.69568092e-01f, 1.45171300e-01f, -2.61202127e-01f, -1.42329752e-01f,
  1.61646888e-01f, -4.47501764e-02f, -1.89188700e-02f, -1.23465039e-01f, -3.74753065e-02f, 1.19158633e-01f, -8.98726061e-02f, -5.02138361e-02f, -2.19031591e-02f, 1.66395664e-01f,
  2.57270694e-01f, 8.94481614e-02f, 8.86010155e-02f, -1.58454999e-01f, 6.55347407e-02f, 7.59166852e-02f, -2.42905784e-02f, 1.09974176e-01f, -1.15171224e-01f, 1.17394269e-01f,
  -1.94721162e-01f, 4.99665141e-02f, -3.10594682e-02f, -2.37929113e-02f, 1.53424293e-01f, -2.19102919e-01f, 9.60301086e-02f, -2.38968626e-01f, -1.28254015e-02f, -2.03154534e-01f,
  -2.08236072e-02f, 1.43257737e-01f, -3.19015682e-01f, -1.69644415e-01f, -1.18468083e-01f, -2.04809904e-01f, 1.68222655e-02f, 1.43832222e-01f, 6.88941851e-02f, -7.59019181e-02f,
  -2.28686154e-01f, -1.41429916e-01f, 1.03739584e-02f, 2.75593102e-01f, -2.32818484e-01f, -4.39554872e-03f, -4.59669717e-02f, 3.13842952e-01f, 1.53333023e-01f, 2.52088398e-01f,
  -1.01362340e-01f, -8.67062621e-03f, 1.08839378e-01f, -1.87344730e-01f, -2.51409799e-01f, -2.82174885e-01f, -2.32075024e-02f, -5.31557381e-01f, 8.57056007e-02f, -8.77801254e-02f,
  2.17425749e-01f, -8.37084725e-02f, -9.87929106e-02f, -3.96844745e-02f, 1.90119565e-01f, -7.35121071e-02f, 1.21880911e-01f, -9.05722566e-03f, -1.71869248e-01f, -1.29080027e-01f,
  -1.16599396e-01f, 4.18566121e-03f, -4.79340479e-02f, 9.14471783e-03f, 6.66791424e-02f, -2.20348407e-03f, 1.13893710e-02f, -9.82275978e-02f, -1.58379555e-01f, -1.36968613e-01f,
  -8.13804392e-04f, 6.02762029e-02f, 3.11453026e-02f, -8.75764042e-02f, 1.93436276e-02f, -1.37963109e-02f, -8.64551589e-02f, -5.01373857e-02f, 6.13744855e-02f, -6.97363764e-02f,
  1.22379601e-01f, -2.48321652e-01f, -5.29311821e-02f, -3.72419530e-03f, -1.31588385e-01f, 6.21458292e-02f, 1.21844625e-02f, 6.45484775e-02f, 5.45266569e-02f, -4.49486300e-02f,
  2.22213138e-02f, -5.53098228e-03f, 2.16966003e-01f, -1.28192678e-01f, 1.32608190e-01f, 2.06844553e-01f, 2.41712499e-02f, -2.16800719e-02f, 7.47506768e-02f, -1.79152846e-01f,
  7.17093796e-02f, 6.64417958e-03f, -1.20610982e-01f, -1.61266297e-01f, 6.43091947e-02f, 3.70058566e-02f, 1.23165883e-01f, 1.57129437e-01f, 1.38160124e-01f, -1.33281991e-01f,
  1.55446753e-01f, -4.87469099e-02f, -9.25129652e-02f, 5.25426492e-02f, 2.87259549e-01f, 9.28278342e-02f, 1.89529270e-01f, 7.61270076e-02f, 2.66876053e-02f, 8.40383321e-02f,
  4.39864956e-02f, -4.97483872e-02f, 6.79566488e-02f, 1.13046058e-01f, 1.18171632e-01f, 2.47059448e-04f, -4.02827654e-03f, -8.65690261e-02f, 2.51066685e-02f, 1.23574860e-01f,
  1.09102778e-01f, -3.10448799e-02f, -6.76540583e-02f, -4.93542142e-02f, 2.35555351e-01f, 6.05169050e-02f, 7.32129999e-03f, 1.48086041e-01f, -4.00332995e-02f, 2.33913325e-02f,
  1.88182965e-01f, -1.04356604e-02f, -2.48945177e-01f, 1.43374680e-02f, -1.88077182e-01f, -9.31643471e-02f, -6.18254617e-02f, -2.00170904e-01f, -6.40544444e-02f, -2.37457260e-01f,
  3.08518887e-01f, -1.10861391e-01f, 2.02524275e-01f, -1.59773484e-01f, -1.69395451e-02f, -1.45513080e-02f, 3.38514328e-01f, -6.68287277e-02f, 1.60273969e-01f, 8.39281604e-02f,
  1.85239419e-01f, 1.85515612e-01f, -2.08166372e-02f, -6.17678985e-02f, -1.48069235e-02f, -7.93590099e-02f, -2.54720598e-01f, 1.56090364e-01f, 1.38607681e-01f, 3.73937488e-02f,
  -2.54187360e-02f, 2.57649031e-02f, 7.34190717e-02f, 7.46952817e-02f, 1.47880943e-04f, -4.17867184e-01f, 3.25692415e-01f, -1.29909560e-01f, -2.28372842e-01f, -2.66149640e-01f,
  -2.37261906e-01f, -2.41619751e-01f, -5.25456446e-04f, 1.42831832e-01f, -3.83206904e-02f, -1.03724860e-01f, 5.84343709e-02f, -9.94426981e-02f, 5.84152155e-02f, 1.60193861e-01f,
  -6.13006800e-02f, 4.77355830e-02f, -5.59614971e-02f, 1.18462525e-01f, -4.38697077e-02f, -4.02262667e-03f, 3.76473330e-02f, 1.09834120e-01f, 1.88009333e-04f, 5.61888367e-02f,
  1.87763169e-01f, -1.50424764e-01f, 6.64600357e-02f, 5.95636666e-02f, 1.42947063e-01f, 2.46833507e-02f, 1.74851835e-01f, -7.06152469e-02f, 1.34667099e-01f, 3.77764776e-02f,
  4.98478040e-02f, -8.99685174e-02f, -2.17349157e-02f, -8.62538442e-02f, 1.66972071e-01f, 2.01276854e-01f, 1.62918746e-01f, 1.66963607e-01f, -1.75212659e-02f, 3.61140072e-03f,
  -2.22385600e-01f, 6.37108088e-02f, 3.13141614e-01f, -3.05183306e-02f, -1.32199273e-01f, -1.74940333e-01f, 4.45448816e-01f, 6.55442625e-02f, -2.41770789e-01f, -2.15817645e-01f,
  2.97610492e-01f, -6.61251461e-03f, 1.30592853e-01f, 1.16157662e-02f, 2.55149931e-01f, 9.98264644e-03f, 1.60885930e-01f, -5.49731664e-02f, 1.63236231e-01f, 4.15322483e-02f,
  -1.87205955e-01f, -8.76198411e-02f, 1.67876855e-01f, 1.69364318e-01f, 2.00352408e-02f, -1.07357025e-01f, 3.00880987e-02f, 9.22057256e-02f, -1.66094303e-01f, 7.83272535e-02f,
  3.24237317e-01f, -3.35497521e-02f, -6.22994592e-03f, 5.50361313e-02f, -2.18713144e-03f, 3.21609601e-02f, 6.86468706e-02f, 8.34035724e-02f, 4.79564555e-02f, 3.62996869e-02f,
  5.22921532e-02f, 9.65228602e-02f, 5.54395840e-02f, 1.48275778e-01f, 1.39846042e-01f, -7.50248209e-02f, -1.45083070e-01f, -5.44363745e-02f, 3.03931348e-02f, -9.21950489e-02f,
  2.62613565e-01f, 7.69229382e-02f, 2.75579125e-01f, 6.55316859e-02f, -5.06578162e-02f, 5.88267855e-02f, 8.42161104e-02f, 2.61844933e-01f, -3.65682468e-02f, 3.49000022e-02f,
  -7.13111311e-02f, 1.18967623e-01f, 4.54609245e-02f, -1.60977975e-01f, -2.37642035e-01f, -4.08362038e-02f, -1.16554469e-01f, -2.85429001e-01f, -1.51367635e-01f, 1.99959010e-01f,
  2.26678744e-01f, -1.77781790e-01f, -2.06048489e-01f, 1.38356417e-01f, 3.12099576e-01f, -2.06700861e-01f, 2.29641885e-01f, 8.57575312e-02f, 2.85060972e-01f, 1.85554266e-01f,
  4.07793708e-02f, -7.57541433e-02f, 2.25377887e-01f, 1.75849199e-01f, -2.60846894e-02f, -1.30686417e-01f, 2.40457371e-01f, -1.70585632e-01f, 2.26389661e-01f, 1.35899395e-01f,
  -1.94366481e-02f, 2.36952826e-01f, -1.31335380e-02f, -6.58654422e-02f, 1.69587106e-01f, 7.92969540e-02f, 1.18397005e-01f, 2.53841102e-01f, -1.26693435e-02f, -4.08170149e-02f,
  1.16951674e-01f, 2.82226149e-02f, -2.41990034e-02f, 4.71802726e-02f, 2.48430204e-03f, 8.42784904e-03f, -3.85921486e-02f, -7.23303780e-02f, 1.57821164e-01f, -9.49213281e-02f,
  1.60086051e-01f, -8.08869451e-02f, 9.06438008e-02f, 2.08564192e-01f, -2.02282727e-01f, 1.47696316e-01f, -1.17928915e-01f, -1.86324656e-01f, 4.24430296e-02f, -1.92696497e-01f,
  -2.68871754e-01f, -1.05557978e-01f, 2.41121680e-01f, -1.29304022e-01f, 7.66322948e-03f, -1.52844489e-01f, 8.26819167e-02f, 3.99570279e-02f, 1.34477347e-01f, 2.19534244e-03f,
  4.11208481e-01f, 2.89044291e-01f, 1.07041210e-01f, -2.85425961e-01f, 9.43492129e-02f, 4.07979548e-01f, 8.03767964e-02f, 2.39286676e-01f, -2.62205213e-01f, -6.15001358e-02f,
  8.27143639e-02f, 5.68871666e-03f, -1.13003895e-01f, -2.19113212e-02f, 3.62832576e-01f, 1.07263356e-01f, -2.80802697e-02f, -4.66892309e-02f, -3.27102631e-01f, -1.55446529e-01f,
  -1.07747264e-01f, 5.04115745e-02f, -8.46752431e-03f, 1.01133041e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 26)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 26;
const float L1_fan_Bp_bar_data[] = {
  1.38042524e-01f, -1.01496756e-01f, 3.12156752e-02f, 8.06909800e-02f, 5.28278761e-02f, -8.00158754e-02f, 1.84080470e-02f, -1.79550974e-04f, -8.27974733e-03f, 1.78327709e-01f,
  -1.19374886e-01f, -1.57130033e-01f, 1.17292799e-01f, 1.48972273e-01f, 1.60830110e-01f, 2.16463149e-01f, 1.26924157e-01f, 8.29160810e-02f, 1.51403651e-01f, 6.01925515e-02f,
  1.39307573e-01f, -9.47134793e-02f, 5.79038970e-02f, -3.45573165e-02f, -6.62509874e-02f, 3.42608169e-02f
};

// L2_fan_Wp (Shape: 19 x 64)
const int L2_fan_Wp_rows = 19;
const int L2_fan_Wp_cols = 64;
const float L2_fan_Wp_data[] = {
  1.33368760e-01f, -3.60410921e-02f, -1.00458123e-01f, -1.79741949e-01f, -6.84959590e-02f, -1.86270606e-02f, 3.45383845e-02f, 1.55805955e-02f, 2.81983893e-02f, -5.86679764e-02f,
  3.75209808e-01f, 8.14583451e-02f, -7.32169449e-02f, 2.56780684e-02f, 1.01627879e-01f, 3.10109314e-02f, 4.98790927e-02f, -5.91423027e-02f, -1.75798908e-02f, -8.43293518e-02f,
  6.75143078e-02f, -6.26911521e-02f, -8.62886384e-02f, -7.74550661e-02f, -1.20802641e-01f, -8.69108513e-02f, 1.36670366e-01f, 3.57904173e-02f, -2.05774769e-01f, 4.95861545e-02f,
  -1.27867073e-01f, 2.09557131e-01f, -6.76736012e-02f, 7.50501156e-02f, 1.18932188e-01f, 1.81012720e-01f, -3.53745759e-01f, 2.71023184e-01f, -2.51980759e-02f, 7.53852427e-02f,
  -5.51955737e-02f, 1.82222098e-01f, -2.05828592e-01f, -2.72697974e-02f, -9.86073911e-02f, -8.18444788e-02f, -1.71290681e-01f, -1.78322583e-01f, 1.11139208e-01f, 8.19807723e-02f,
  9.32725705e-03f, 2.25345179e-01f, 1.64002925e-01f, -2.21497670e-01f, -7.87044019e-02f, -1.69208441e-02f, 3.41060907e-02f, -1.77089944e-01f, -1.27856418e-01f, 1.62703529e-01f,
  -6.42211661e-02f, 2.25162148e-01f, 1.75290659e-01f, 6.41374066e-02f, -1.07000247e-01f, -3.87659632e-02f, 6.17822353e-03f, -1.27276167e-01f, -1.74577385e-01f, -4.18973044e-02f,
  -9.99333486e-02f, -1.04791097e-01f, 1.28742605e-01f, -1.09217808e-01f, -1.05659328e-01f, -2.02988952e-01f, -9.53842849e-02f, 1.07333742e-01f, 2.37507641e-01f, -1.14053227e-01f,
  -1.87296227e-01f, -1.66315824e-01f, -2.81142563e-01f, 6.76403046e-02f, -5.59423380e-02f, -7.85183012e-02f, -2.63597965e-01f, -5.93538210e-02f, -2.25294396e-01f, 1.18681811e-01f,
  -1.46327049e-01f, -4.84621450e-02f, 3.22232693e-01f, 6.01696558e-02f, 4.24444675e-02f, 5.79704866e-02f, -8.91731605e-02f, 9.45818238e-03f, -9.87522230e-02f, -1.70182198e-01f,
  1.97640583e-01f, -2.55385816e-01f, 9.40017849e-02f, -3.75227109e-02f, -4.75150310e-02f, 9.98768359e-02f, -5.66272959e-02f, 1.09802909e-01f, -2.15261653e-02f, 1.64397284e-01f,
  5.45266867e-02f, 1.83304809e-02f, -4.68262322e-02f, 1.14823813e-02f, 2.84892350e-01f, -2.79631287e-01f, -7.47630149e-02f, -3.25615883e-01f, -1.04495376e-01f, -1.49913996e-01f,
  9.57632437e-03f, -9.48061571e-02f, -1.55685380e-01f, -1.40305430e-01f, -2.43061364e-01f, 2.47670952e-02f, 2.88014561e-01f, -1.48513466e-01f, 1.02058850e-01f, 2.94334963e-02f,
  7.92724639e-02f, -2.50058830e-01f, -2.55397595e-02f, -1.42820910e-01f, -4.32668207e-03f, -5.02369590e-02f, 9.74875316e-02f, -3.07036303e-02f, 3.27021517e-02f, -2.15030345e-03f,
  2.72192121e-01f, 1.01057617e-02f, 4.01236750e-02f, 9.22933146e-02f, -1.01574443e-01f, 1.11915633e-01f, 3.80428657e-02f, 3.14894319e-02f, 1.77436769e-01f, 3.74944322e-02f,
  1.38674259e-01f, 3.44735309e-02f, 2.57298559e-01f, 8.06456357e-02f, 7.12729245e-02f, 2.57658362e-01f, -2.35554576e-01f, -7.55965197e-03f, -1.29643649e-01f, 1.10731006e-01f,
  1.09533191e-01f, 2.23791867e-01f, -5.87161519e-02f, 9.82861370e-02f, -1.64064378e-01f, 3.86051983e-02f, 3.44499163e-02f, -8.19664374e-02f, 1.92383796e-01f, -3.30043808e-02f,
  9.17409658e-02f, 2.87380833e-02f, 2.41804626e-02f, -2.65635848e-01f, -1.13201447e-01f, -5.55639528e-02f, 1.52797282e-01f, -4.84129712e-02f, -1.88904852e-01f, 1.21042676e-01f,
  1.34632915e-01f, -5.85107170e-02f, -7.31074112e-03f, -3.60758579e-03f, 1.07506290e-02f, -1.94374681e-01f, 3.25913638e-01f, 1.44201115e-01f, 7.32362941e-02f, -2.19241247e-01f,
  -3.09986025e-01f, 1.18303910e-01f, -1.71995178e-01f, -2.14700803e-01f, 8.42261687e-02f, -1.90276727e-01f, -1.63427293e-02f, 7.42664039e-02f, -5.45694567e-02f, 3.12861726e-02f,
  3.24328244e-02f, 1.94249507e-02f, 7.55426958e-02f, 1.36947393e-01f, -1.12980030e-01f, 1.78228877e-02f, -3.18403617e-02f, -9.55020413e-02f, -2.79792875e-01f, 1.61663085e-01f,
  -5.56849055e-02f, 1.06051974e-01f, 1.70896396e-01f, -2.18356833e-01f, -2.38494743e-02f, 2.30630971e-02f, -6.89312909e-03f, -6.21372946e-02f, -2.60686912e-02f, 5.00535592e-02f,
  8.45748559e-03f, 2.47469395e-01f, -2.52225604e-02f, -4.63937782e-02f, -1.83699638e-01f, 3.19775566e-02f, 1.43588468e-01f, -1.83077380e-01f, 3.48922580e-01f, -1.30760744e-01f,
  -3.86629999e-02f, 2.44660437e-01f, 1.08875677e-01f, -1.30975559e-01f, 2.76356600e-02f, 1.44320160e-01f, -1.64256439e-01f, 1.17308468e-01f, -5.48654161e-02f, 2.37068951e-01f,
  6.85892552e-02f, 4.65805270e-02f, -6.83286265e-02f, -3.51203293e-01f, 1.23585074e-03f, -1.68823823e-01f, 2.79831626e-02f, 1.34470254e-01f, -2.06014454e-01f, -1.63557548e-02f,
  -4.32171859e-02f, 1.07816719e-01f, -1.42728254e-01f, 3.62602551e-03f, -2.88370661e-02f, 1.68136418e-01f, 6.57369345e-02f, 5.50589301e-02f, -1.65695697e-01f, -4.87357229e-02f,
  2.72677928e-01f, 1.58183843e-01f, -3.57204899e-02f, 1.91402733e-01f, 1.01663329e-01f, -7.99048916e-02f, 2.55555481e-01f, 1.25525609e-01f, 1.77992642e-01f, 9.27643552e-02f,
  1.41201228e-01f, 1.69366021e-02f, 1.17914476e-01f, 9.27863568e-02f, 4.50933874e-02f, -1.70150269e-02f, 1.33280028e-02f, 9.06880386e-03f, -2.98972018e-02f, 2.63530701e-01f,
  8.21054056e-02f, -1.65796906e-01f, 1.66403472e-01f, 1.44612968e-01f, -1.57662213e-01f, -1.43684279e-02f, -9.26691219e-02f, 7.05125257e-02f, -3.00637446e-03f, 1.22119576e-01f,
  3.49932581e-01f, -5.86964600e-02f, -1.08565882e-01f, -6.62740171e-02f, -7.06973746e-02f, -1.05126640e-02f, -2.23001707e-02f, -1.66618243e-01f, 7.93352649e-02f, 1.63658097e-01f,
  3.82285528e-02f, -8.47002491e-03f, -2.00093210e-01f, 9.12526324e-02f, -2.87726205e-02f, 1.77669227e-01f, -1.65329605e-01f, -4.17298563e-02f, 8.20729136e-02f, 1.03305273e-01f,
  1.32200345e-01f, 1.74018428e-01f, -1.41834930e-01f, -1.01144530e-01f, 5.17434962e-02f, 1.46796212e-01f, 1.64592430e-01f, -1.23890661e-01f, -1.35305345e-01f, -3.28337327e-02f,
  -5.00865839e-02f, -2.93821860e-02f, -1.16608307e-01f, -1.49433330e-01f, -1.00591451e-01f, -1.54782996e-01f, 1.63914531e-01f, -1.45030111e-01f, 2.24117953e-02f, -7.97938183e-02f,
  1.03292286e-01f, 2.64416099e-01f, -3.59389894e-02f, -2.48133436e-01f, 3.22192945e-02f, 6.74267858e-02f, -8.05559903e-02f, -1.00998081e-01f, -7.59236738e-02f, -1.51805580e-01f,
  -4.99471165e-02f, 8.17453489e-02f, -2.71753937e-01f, 6.04427606e-02f, -2.59666834e-02f, -1.34565189e-01f, -9.81824845e-02f, -1.51603043e-01f, 5.47018237e-02f, -7.92319030e-02f,
  -2.71701217e-01f, 1.32010393e-02f, 1.22036979e-01f, -1.03576995e-01f, 1.47735193e-01f, 8.98538157e-02f, 8.86384472e-02f, 1.95488036e-02f, -1.30499125e-01f, -1.63436517e-01f,
  1.13216490e-01f, -1.52020141e-01f, 1.48419574e-01f, 9.75860953e-02f, -2.17779428e-02f, -1.97019458e-01f, 1.48784593e-01f, 4.91417088e-02f, 7.75360465e-02f, -2.21126014e-04f,
  4.57392819e-02f, 2.21314833e-01f, 5.25479093e-02f, 2.26116657e-01f, 1.21301271e-01f, -4.50227484e-02f, -6.92612156e-02f, 2.40080163e-01f, -1.98329583e-01f, -1.02372363e-01f,
  2.77702183e-01f, -2.10546255e-01f, -9.51834023e-02f, -1.79872990e-01f, -1.01606473e-02f, 1.18936725e-01f, 8.29122290e-02f, -5.60668670e-02f, -1.51286989e-01f, -3.24031234e-01f,
  7.63434395e-02f, -1.24046132e-01f, -2.68514529e-02f, 1.19168393e-01f, -2.61445910e-01f, -1.51857793e-01f, -5.96156716e-02f, -2.13345304e-01f, -2.14628041e-01f, -4.61767353e-02f,
  -1.70067757e-01f, 2.87768453e-01f, -1.05387092e-01f, -2.44324744e-01f, -2.80246168e-01f, 8.02478716e-02f, -1.73744932e-01f, -2.03990772e-01f, -1.16126329e-01f, 1.34000927e-01f,
  8.93140286e-02f, 1.72639824e-02f, -1.37465864e-01f, -3.56927440e-02f, 9.47303846e-02f, -2.40343064e-02f, -9.91885066e-02f, -7.19707459e-03f, -2.62401074e-01f, -8.89695138e-02f,
  -5.98895364e-03f, -1.79962069e-01f, -3.08065265e-01f, 1.01695716e-01f, 7.00296536e-02f, -9.52823088e-02f, -7.26226903e-03f, 1.79460302e-01f, 2.48909220e-01f, -1.07432306e-01f,
  1.86597824e-01f, 1.54087916e-01f, 3.29136923e-02f, 3.11970524e-02f, -2.48178318e-02f, -1.14751801e-01f, -1.74520373e-01f, 3.56797166e-02f, -8.01376998e-02f, -2.08478302e-01f,
  1.71574488e-01f, 3.75607945e-02f, -1.15122177e-01f, 7.82855526e-02f, 2.47125495e-02f, -1.73119411e-01f, -1.98209688e-01f, 2.24042326e-01f, 2.05431640e-01f, -5.20697013e-02f,
  -8.06614012e-02f, 1.45208374e-01f, 1.59227829e-02f, -3.96041237e-02f, 1.30666956e-01f, 5.06565198e-02f, 5.64763434e-02f, -1.18453547e-01f, -3.10189407e-02f, -8.71623009e-02f,
  1.34688556e-01f, 2.83016950e-01f, 1.35521032e-02f, 6.03604130e-02f, 1.06614269e-01f, -2.33940929e-01f, -5.81622496e-02f, -1.70221463e-01f, -8.77540857e-02f, 2.10551143e-01f,
  1.41714970e-02f, -8.97396803e-02f, -7.99785852e-02f, 4.22279388e-02f, 2.23476037e-01f, 3.96381542e-02f, 8.41795746e-03f, -2.09113196e-01f, 6.38415813e-02f, 2.34788224e-01f,
  1.53056964e-01f, 7.47015402e-02f, -1.31093293e-01f, 8.70652646e-02f, -3.46328557e-01f, -1.62664168e-02f, -6.56509846e-02f, -1.56189829e-01f, -2.00381577e-01f, 3.29781026e-02f,
  -1.85541153e-01f, -8.23554769e-02f, 2.46117905e-01f, 4.58676443e-02f, 2.07447395e-01f, -1.41469061e-01f, -4.88263592e-02f, -1.49960071e-01f, 2.48242393e-02f, 3.06023121e-01f,
  1.55673638e-01f, -1.91099003e-01f, -1.83916450e-01f, -2.06536248e-01f, 5.75124212e-02f, 4.19397838e-02f, -9.31893364e-02f, -5.17643094e-02f, 2.17941478e-02f, 9.79095921e-02f,
  7.03453124e-02f, 1.98408570e-02f, -1.31917313e-01f, 7.05418177e-04f, 9.11278129e-02f, 4.03467007e-02f, 7.54045919e-02f, 2.27635443e-01f, -2.06590220e-01f, 7.70443082e-02f,
  -2.10208133e-01f, 1.18153587e-01f, 1.95078462e-01f, 1.14101343e-01f, -1.29679590e-01f, 1.73884314e-02f, -6.47597527e-03f, -3.23802754e-02f, 1.59096960e-02f, -5.46954945e-02f,
  3.05797718e-03f, 9.36909318e-02f, -1.94849923e-01f, -2.55949609e-02f, -1.80785004e-02f, -6.89568594e-02f, 1.16341583e-01f, -8.99825841e-02f, -3.21838439e-01f, 1.04862250e-01f,
  -4.36062180e-02f, 2.87731022e-01f, -1.68281347e-01f, -5.69775961e-02f, -1.18594110e-01f, -3.38211395e-02f, 8.43847394e-02f, -8.32265392e-02f, -1.87670756e-02f, 1.72226444e-01f,
  -3.14707384e-02f, 2.89253742e-02f, 1.28026694e-01f, 3.10329199e-02f, 1.81428239e-01f, -1.31396949e-01f, -1.12782285e-01f, 7.09384754e-02f, -1.98496953e-01f, -1.69810176e-01f,
  2.78726131e-01f, -4.98526990e-02f, 9.73265339e-03f, 1.15033768e-01f, 8.84644762e-02f, 7.19087496e-02f, 1.67498551e-03f, -4.15328406e-02f, -2.39265680e-01f, -1.89005444e-03f,
  1.17991664e-01f, 1.75984144e-01f, 7.75208846e-02f, 6.83843419e-02f, 2.12452471e-01f, 1.10634696e-02f, 3.06217633e-02f, -7.39335343e-02f, -5.95363155e-02f, 2.39314005e-01f,
  -2.70237148e-01f, 1.66212395e-01f, -1.60314173e-01f, 7.73748755e-02f, -1.12063557e-01f, 4.25889604e-02f, -5.21697626e-02f, 2.66076267e-01f, 9.08986628e-02f, 1.65836096e-01f,
  -1.82369590e-01f, 2.06904039e-01f, 7.99549147e-02f, -4.52109277e-02f, -6.77738935e-02f, 1.26179665e-01f, -2.62244558e-03f, 8.76289085e-02f, 1.30496338e-01f, 8.15091357e-02f,
  -2.45764151e-01f, -6.26010150e-02f, -3.05958688e-01f, 9.87710208e-02f, 8.73629749e-02f, -6.44161105e-02f, 4.96898443e-02f, -2.20879808e-01f, 4.17039096e-02f, 1.05494611e-01f,
  -2.05374300e-01f, -1.20139666e-01f, -2.60874536e-02f, 1.73194304e-01f, -4.70327549e-02f, 2.23800093e-02f, 3.77250612e-02f, 2.62426496e-01f, 2.28661466e-02f, -5.13308495e-02f,
  -2.04543658e-02f, -5.77442581e-03f, -2.89264005e-02f, -1.19419836e-01f, 3.64754610e-02f, -5.80597036e-02f, 8.39392096e-02f, 3.94261209e-03f, -1.73704341e-01f, 9.76137966e-02f,
  -2.64807552e-01f, 1.19196391e-02f, -1.25808254e-01f, -1.90052882e-01f, 9.05588455e-03f, -1.28248498e-01f, -3.08774672e-02f, 8.54864791e-02f, 2.51057416e-01f, 1.69193342e-01f,
  1.77701563e-03f, 2.32844308e-01f, 1.03592789e-02f, 1.82606265e-01f, 2.07789630e-01f, -1.21258730e-02f, 2.34547451e-01f, -1.53688058e-01f, -5.43664917e-02f, 1.36428788e-01f,
  -1.21113518e-02f, -9.33183730e-02f, 2.22917106e-02f, -1.51465058e-01f, 1.06140383e-01f, 1.21562183e-01f, -7.83147961e-02f, -5.81359528e-02f, 8.07923824e-03f, -2.28942800e-02f,
  -1.85242265e-01f, 2.74341226e-01f, 3.74932975e-01f, -1.11357659e-01f, -1.43623576e-01f, -6.72914609e-02f, 4.49083447e-02f, -1.73864707e-01f, 3.59462798e-02f, -1.35183558e-01f,
  1.82076782e-01f, -1.10118344e-01f, 7.70758390e-02f, -1.30251944e-01f, 4.41243023e-01f, -3.93277407e-03f, 3.75186026e-01f, -1.41236469e-01f, 2.36530423e-01f, 3.73855643e-02f,
  2.99474086e-05f, -2.66533673e-01f, 7.05474466e-02f, 2.03170739e-02f, 1.89212471e-01f, 9.45661739e-02f, 1.03710555e-01f, -7.78722391e-02f, 4.67796363e-02f, -1.31387919e-01f,
  -1.38324305e-01f, -1.54147834e-01f, -1.64786845e-01f, 1.19889922e-01f, 1.28616303e-01f, -1.90612599e-01f, 1.12247296e-01f, -5.98798320e-03f, -2.92062491e-01f, -7.84302726e-02f,
  1.43410027e-01f, -1.48706838e-01f, -1.26960546e-01f, -2.71367561e-02f, 8.85804594e-02f, 9.22881812e-02f, -2.82346979e-02f, -1.11536287e-01f, -1.21176876e-01f, 2.21909527e-02f,
  -2.47644722e-01f, 3.56894508e-02f, 5.25653288e-02f, 1.41988304e-02f, -1.72308475e-01f, -1.20116159e-01f, -6.98950142e-02f, -9.76537690e-02f, -7.47699961e-02f, -6.84950054e-02f,
  -3.45686674e-02f, 2.01904014e-01f, 5.99611476e-02f, -1.96895842e-03f, -2.37528518e-01f, 8.84367898e-02f, -1.36706069e-01f, 2.76050949e-03f, -2.55561154e-02f, 1.64461851e-01f,
  1.34232296e-02f, -9.53271464e-02f, -1.51949316e-01f, 1.44546449e-01f, -3.01115355e-03f, 6.13228455e-02f, -1.40067816e-01f, 1.25268891e-01f, -2.23255947e-01f, 1.54886199e-02f,
  -1.19836003e-01f, -2.89534807e-01f, -1.51391611e-01f, -7.63966963e-02f, 2.92460769e-01f, 1.02494948e-01f, 1.11833826e-01f, 1.09322526e-01f, 1.91812038e-01f, -4.50566970e-02f,
  2.36564457e-01f, 1.08232610e-01f, -2.02738151e-01f, 1.30141377e-01f, 5.50027154e-02f, 1.82590261e-01f, -1.05864808e-01f, 3.83832514e-01f, -1.07316986e-01f, -3.26607823e-01f,
  4.59546186e-02f, 2.69212313e-02f, -3.40678930e-01f, -1.31791219e-01f, 3.37115020e-01f, -9.28274542e-02f, -1.94768175e-01f, 8.84135365e-02f, 1.13692209e-01f, 5.91273829e-02f,
  4.28900346e-02f, 2.30290532e-01f, 1.12904526e-01f, 1.37119189e-01f, 8.06092843e-03f, 3.49290073e-02f, 1.33480892e-01f, 3.50910313e-02f, 2.98116714e-01f, -1.72016397e-01f,
  -3.81759256e-02f, 7.46278837e-02f, 1.46526089e-02f, -2.03268752e-01f, -1.14047132e-01f, 2.23900363e-01f, 7.60530159e-02f, -3.26167047e-02f, -2.35106692e-01f, 1.64646551e-01f,
  1.64396167e-01f, 9.27592535e-03f, -2.60635942e-01f, -3.27315442e-02f, 2.48680249e-01f, -1.98109344e-01f, -2.09197178e-01f, -2.46431515e-01f, 1.76030666e-01f, 8.95901248e-02f,
  -9.57984570e-03f, -4.98688556e-02f, 2.71674186e-01f, -1.18248977e-01f, -1.67919956e-02f, -3.07651937e-01f, -1.02464028e-01f, 5.44875339e-02f, 4.49280888e-02f, -1.00222200e-01f,
  -1.39224276e-01f, -3.64128985e-02f, 1.16748720e-01f, -1.10269926e-01f, -1.31190807e-01f, 3.59931141e-02f, -1.40801042e-01f, -1.26525676e-02f, 1.08565632e-02f, 9.29122120e-02f,
  1.26951011e-02f, -1.38396814e-01f, -2.03104224e-02f, -1.36418477e-01f, 1.77290797e-01f, -1.72841176e-01f, -3.22572142e-01f, 3.79767157e-02f, 1.28131704e-02f, 9.58411396e-02f,
  -1.89076632e-01f, 2.28911445e-01f, -5.68925813e-02f, 1.49239063e-01f, -4.04591449e-02f, 1.73768878e-01f, 1.90954264e-02f, -1.04405150e-01f, 1.17149301e-01f, -1.44047618e-01f,
  1.49928272e-01f, -1.20158747e-01f, -1.51583925e-01f, -2.07989573e-01f, -6.73962245e-03f, -6.55056983e-02f, 4.76115011e-03f, -1.17001399e-01f, 1.18026254e-03f, 4.34958898e-02f,
  -2.03586891e-02f, -4.28544432e-02f, -6.10880628e-02f, -1.36832759e-01f, -1.85385291e-02f, 3.69942188e-02f, 1.50550663e-01f, -7.29053915e-02f, 6.40241569e-03f, -1.70294628e-01f,
  -3.38304229e-02f, -5.09542972e-02f, 2.17507817e-02f, 1.16860338e-01f, -1.15211025e-01f, 4.36840998e-03f, -7.60532990e-02f, -3.61638755e-01f, 6.99503273e-02f, -2.41024971e-01f,
  -1.53758883e-01f, 1.46749429e-02f, -1.10726401e-01f, 2.46715248e-02f, -1.68172475e-02f, 2.61137396e-01f, -6.90633664e-03f, 1.90719888e-01f, -3.32591534e-01f, 2.34248601e-02f,
  1.11166380e-01f, 2.21236542e-01f, -9.33601335e-02f, -3.38939130e-01f, -7.30829034e-03f, -1.99649945e-01f, -5.66773973e-02f, -8.38344321e-02f, -1.74253702e-01f, 4.82088625e-02f,
  -2.36017749e-01f, 6.86668158e-02f, -1.29845187e-01f, -4.40530479e-02f, 5.27877919e-02f, 7.56180882e-02f, 5.93858398e-02f, 1.30434498e-01f, 1.63691744e-01f, -6.75295815e-02f,
  1.39575213e-01f, -6.15721606e-02f, 1.21210769e-01f, -4.31591365e-03f, 1.21324472e-01f, -1.46186113e-01f, 2.70469673e-02f, -6.50347546e-02f, 1.43683165e-01f, 2.22061247e-01f,
  1.56338185e-01f, 8.78289714e-02f, 7.93950930e-02f, 7.49219656e-02f, -8.56064912e-03f, 1.82858203e-02f, 3.45644727e-02f, 5.72768673e-02f, 3.03100646e-01f, 2.02604339e-01f,
  -6.94328099e-02f, -9.93370544e-03f, 2.52298027e-01f, -3.38890427e-03f, 6.10609390e-02f, -3.04132491e-01f, 1.57743812e-01f, 1.25136644e-01f, 1.29768252e-01f, -4.80640540e-03f,
  2.23662153e-01f, 3.17915566e-02f, 1.20704532e-01f, -1.97387695e-01f, 1.65361673e-01f, -1.31961390e-01f, 2.46930718e-02f, -7.84376170e-03f, -1.17583394e-01f, -2.11069480e-01f,
  6.11583218e-02f, 6.99155554e-02f, -1.61634371e-01f, -4.93234657e-02f, 3.32436971e-02f, -9.34186131e-02f, -2.31617372e-02f, -1.80614129e-01f, 1.04565518e-02f, -9.07010883e-02f,
  -1.92916691e-01f, 3.49736288e-02f, 1.97104421e-02f, -1.21810779e-01f, 1.10009015e-01f, -2.18659714e-01f, -1.25473842e-01f, 5.87424114e-02f, 8.04698989e-02f, 1.04962826e-01f,
  -1.87348381e-01f, 5.23230284e-02f, 1.36345178e-01f, 8.62618349e-03f, 3.80137227e-02f, 7.15923160e-02f, -7.86233470e-02f, 6.96921116e-03f, -3.68233919e-02f, 1.05546527e-01f,
  1.69378400e-01f, 1.06275767e-01f, -9.20585766e-02f, -2.58976184e-02f, 9.02125016e-02f, -1.74041927e-01f, -1.47392914e-01f, -1.79312006e-01f, 2.07070336e-01f, 4.00201306e-02f,
  1.27275497e-01f, -1.91159919e-02f, -1.14161111e-01f, -6.83552250e-02f, -1.89816564e-01f, -2.34141693e-01f, -1.09385438e-01f, 3.71564962e-02f, -1.19623803e-01f, 2.34516606e-01f,
  2.23348308e-02f, -2.54212290e-01f, -6.63701445e-02f, -9.42638516e-02f, 2.05800459e-02f, -8.29095393e-02f, 2.56798059e-01f, 6.34010509e-03f, 6.44697472e-02f, 1.45164937e-01f,
  -7.84978941e-02f, -1.62821766e-02f, 1.49992555e-01f, 6.44975007e-02f, -7.07727596e-02f, 2.34085977e-01f, -7.98785314e-02f, 1.17092863e-01f, 1.70164511e-01f, 9.72918570e-02f,
  -8.38939399e-02f, -1.91325709e-01f, 2.85249278e-02f, 4.38448079e-02f, -1.97295565e-02f, 1.31183743e-01f, -7.49344900e-02f, -2.18749046e-01f, -1.01410285e-01f, 1.33726865e-01f,
  -1.24997646e-01f, 8.24809223e-02f, -8.84914398e-02f, 2.74607003e-01f, -7.77752250e-02f, 8.16500336e-02f, 6.73758909e-02f, 2.96254549e-03f, -1.33736685e-01f, 2.87521333e-01f,
  -2.66945720e-01f, -1.80725634e-01f, 8.89290646e-02f, -2.97115110e-02f, -8.89712945e-02f, -1.89346403e-01f, 1.24265850e-01f, -7.01643080e-02f, 2.44113002e-02f, -3.40676814e-01f,
  -1.66480258e-01f, -5.64849004e-02f, -3.31155732e-02f, -9.88323614e-02f, 2.26968825e-01f, -1.82480618e-01f, -1.46925762e-01f, 9.87982899e-02f, -1.71720311e-01f, 1.29903629e-01f,
  -1.29223809e-01f, -1.10345393e-01f, 7.93678015e-02f, -1.06244618e-02f, -3.31090204e-02f, -4.13055867e-02f, -3.53877842e-02f, -4.59133573e-02f, -2.94799805e-01f, -2.53521334e-02f,
  7.88054243e-02f, 9.48043466e-02f, 3.21602039e-02f, 8.20197314e-02f, -1.46957919e-01f, 4.29056883e-02f, -1.69465378e-01f, -9.17792320e-02f, -1.41700640e-01f, 1.66746944e-01f,
  -3.23010653e-01f, 2.40258947e-02f, 8.95147249e-02f, -5.43464050e-02f, 2.03131944e-01f, -2.53853232e-01f, 1.39301777e-01f, -2.81838924e-02f, 1.62838902e-02f, -1.21835880e-01f,
  -1.65699482e-01f, -6.64334074e-02f, 3.39232907e-02f, -9.34657604e-02f, -2.63737440e-01f, 1.75395295e-01f, 1.79562911e-01f, -1.31912336e-01f, 1.13760261e-02f, -2.35199392e-01f,
  -1.14278071e-01f, -4.72231098e-02f, -5.66594154e-02f, 1.40015120e-02f, -4.80018929e-03f, 1.48735687e-01f, -9.45495963e-02f, -1.04608729e-01f, 1.31389946e-01f, -3.96111161e-02f,
  -2.43087076e-02f, 2.06853807e-01f, -2.78825104e-01f, 4.88658100e-02f, 6.20138943e-02f, 4.37213182e-02f, 6.17271364e-02f, 2.65449602e-02f, -1.39216989e-01f, 9.94498208e-02f,
  -1.77994683e-01f, -1.07440412e-01f, -9.66323465e-02f, -1.17762141e-01f, 6.71017766e-02f, -6.77926093e-03f, 1.09600417e-01f, -7.45742396e-02f, 6.34036213e-02f, -1.03195205e-01f,
  1.63478702e-01f, 4.53523435e-02f, -6.19531237e-02f, 1.28320709e-01f, -3.59701402e-02f, 7.56237283e-02f, -2.66439557e-01f, 1.09676056e-01f, -1.89984500e-01f, 2.46777356e-01f,
  -5.19189686e-02f, 1.04347788e-01f, 8.78100097e-02f, 1.41394719e-01f, 1.88785583e-01f, -1.27785923e-02f, -4.42792810e-02f, 1.84835956e-01f, 2.42353380e-02f, 1.27807975e-01f,
  -7.39745572e-02f, -1.28195673e-01f, -5.66645376e-02f, -8.78944695e-02f, 6.40952680e-03f, 1.45479485e-01f, -1.97439238e-01f, 6.99936971e-02f, -3.52397449e-02f, 1.85714170e-01f,
  6.07541669e-03f, 2.10252076e-01f, 3.02800924e-01f, 5.09150960e-02f, -1.28029406e-01f, 1.26679704e-01f, 2.72645146e-01f, -1.43310457e-01f, -4.96587381e-02f, -2.34436197e-03f,
  3.10986698e-01f, -7.11786076e-02f, 3.53440046e-01f, -1.64144542e-02f, 1.69411540e-01f, 1.43564120e-01f, 1.93071067e-01f, 1.48862273e-01f, -4.87532541e-02f, 9.79043990e-02f,
  1.08174734e-01f, 1.10122077e-01f, -5.29604368e-02f, 2.03749552e-01f, 2.33219922e-01f, 1.83017105e-01f, -5.74200489e-02f, -2.69616339e-02f, 1.50099337e-01f, 2.48046830e-01f,
  -2.71719158e-01f, 1.33934498e-01f, 2.22078408e-03f, 1.73937947e-01f, 6.47407696e-02f, 1.17674455e-01f, 1.28892824e-01f, 1.34668022e-01f, -2.19310611e-01f, 2.43051216e-01f,
  -3.54971476e-02f, -1.38858423e-01f, -7.04950690e-02f, 8.41814876e-02f, -1.14159778e-01f, -1.76437527e-01f, -1.00999758e-01f, -1.26490921e-01f, -1.08194634e-01f, 9.01393779e-03f,
  -2.64235318e-01f, -2.92500220e-02f, -7.81347528e-02f, 2.94124335e-01f, 1.46118060e-01f, -1.16995782e-01f, -1.50137246e-01f, -1.51277333e-01f, -4.79538105e-02f, -7.55634299e-03f,
  1.02901950e-01f, -8.55518319e-03f, -1.68150838e-03f, 7.83451274e-02f, 1.13080209e-02f, 1.35451764e-01f
};

// L2_fan_Wp_bar (Shape: 26 x 64)
const int L2_fan_Wp_bar_rows = 26;
const int L2_fan_Wp_bar_cols = 64;
const float L2_fan_Wp_bar_data[] = {
  -5.48967540e-01f, -2.56680459e-01f, -2.21546292e-01f, -2.90570319e-01f, 4.29702476e-02f, 2.43600294e-01f, -5.95198154e-01f, 2.54063368e-01f, 1.48801327e-01f, 3.61790657e-01f,
  -1.37427211e-01f, 4.49377567e-01f, -1.49257720e-01f, 2.87678838e-02f, -1.06558494e-01f, -8.72614831e-02f, -2.23748889e-02f, 3.32185365e-02f, 2.04889745e-01f, 2.92976141e-01f,
  3.07791471e-01f, 8.25432912e-02f, 1.40135828e-02f, 2.84026973e-02f, 4.01107103e-01f, -5.69352396e-02f, -5.46367243e-02f, 2.36212701e-01f, -1.25419418e-03f, 3.02661240e-01f,
  -1.66529745e-01f, -3.92997622e-01f, 1.58722565e-01f, -8.53875130e-02f, -3.36180031e-01f, 9.97087434e-02f, 1.51754424e-01f, -2.43332624e-01f, -3.40264142e-01f, -1.15563013e-02f,
  1.00238681e-01f, 1.00312114e-01f, 1.57421708e-01f, -1.84358254e-01f, 8.53444040e-02f, 1.06360808e-01f, 1.08240150e-01f, 1.86800182e-01f, -2.17028022e-01f, 3.02905105e-02f,
  -1.36357337e-01f, -1.61311880e-01f, -9.71077457e-02f, -1.35040835e-01f, -1.49905503e-01f, 1.58657774e-01f, 3.57574850e-01f, -1.27959661e-02f, 1.20851994e-01f, -1.17769770e-01f,
  -1.14970095e-01f, 7.61687681e-02f, -8.49027932e-02f, 2.38413662e-01f, -4.92064804e-02f, -3.06236111e-02f, 7.04741664e-03f, -3.09359003e-03f, -1.21652342e-01f, -7.14617595e-02f,
  1.61889970e-01f, 1.77659392e-02f, -8.44222084e-02f, -3.44588347e-02f, 3.85768041e-02f, -2.16828566e-02f, -3.97942215e-02f, 3.69817168e-02f, 1.31812558e-01f, 1.82910543e-02f,
  -4.56172153e-02f, 3.65144871e-02f, 5.63565781e-03f, -5.60989492e-02f, -5.97826913e-02f, -8.94587021e-03f, -5.65419123e-02f, -1.51572853e-01f, 2.03173105e-02f, -1.97206121e-02f,
  -7.91217610e-02f, -1.11031793e-01f, 1.73901141e-01f, -1.50716022e-01f, 1.03232563e-01f, 1.13369390e-01f, -3.94943357e-02f, -8.18315893e-02f, -1.87785238e-01f, -2.21076459e-01f,
  -1.81131344e-02f, 1.62907969e-02f, -2.67547723e-02f, 2.31418349e-02f, 1.59854859e-01f, 1.39444426e-01f, 1.20734349e-02f, -1.61976069e-02f, 1.52470106e-02f, 3.96496318e-02f,
  1.40592411e-01f, 3.88035141e-02f, -5.75555898e-02f, -3.15409452e-02f, 2.24236384e-01f, 1.06658570e-01f, -7.46824667e-02f, 1.35623977e-01f, -3.81916426e-02f, 1.61139388e-02f,
  8.47909823e-02f, 1.02891110e-01f, 1.12805031e-02f, -2.96466220e-02f, 8.96664560e-02f, 1.59180552e-01f, 1.43019915e-01f, 2.35206280e-02f, -1.77032635e-01f, -2.54099462e-02f,
  -6.44634292e-02f, 3.23655270e-02f, -1.00045808e-01f, 2.74801910e-01f, 1.38548333e-02f, 1.76385462e-01f, 4.63215224e-02f, 1.22759882e-02f, 8.16132128e-03f, 9.77396443e-02f,
  -8.55364054e-02f, 8.85936916e-02f, -1.08805500e-01f, -6.82878867e-02f, -2.47731842e-02f, -7.50374328e-03f, -1.83713764e-01f, 1.14428386e-01f, 3.50777775e-01f, 1.04401680e-02f,
  -1.15817845e-01f, -4.11051419e-03f, 4.49033916e-01f, -5.83080091e-02f, -2.69635856e-01f, 1.33243129e-01f, -7.10262656e-02f, 1.77665412e-01f, -1.03239208e-01f, -4.82504927e-02f,
  1.38293818e-01f, -9.40113589e-02f, 4.21802476e-02f, -2.02137545e-01f, 1.67228043e-01f, -1.24637611e-01f, 2.94605464e-01f, -2.54927110e-02f, -1.00021929e-01f, -3.70630808e-02f,
  1.14082858e-01f, 2.19657049e-02f, -8.62322450e-02f, 2.37694263e-01f, 1.17794104e-01f, 4.19267341e-02f, 2.34280065e-01f, -5.56352036e-03f, -7.29958117e-02f, -4.14666206e-01f,
  2.49814853e-01f, -5.24344221e-02f, 1.65367723e-01f, 1.11008450e-01f, -7.11687207e-02f, -8.18045810e-03f, 1.23400658e-01f, 6.15917258e-02f, -1.19498260e-01f, -1.64903924e-01f,
  -9.48253423e-02f, 1.18610915e-02f, 2.81971693e-01f, 2.87766941e-03f, 1.37761399e-01f, 2.19773248e-01f, 3.16024154e-01f, 1.76637903e-01f, 1.15472876e-01f, 2.12349847e-01f,
  -1.04697039e-02f, 2.60881454e-01f, -1.00575693e-01f, 2.42367998e-01f, 2.82995980e-02f, 2.96818346e-01f, 1.83180287e-01f, 2.47953102e-01f, 1.45418435e-01f, -9.78581682e-02f,
  2.58520246e-01f, 1.21233970e-01f, -1.54045716e-01f, 3.54938447e-01f, 2.19330847e-01f, -6.33935854e-02f, 7.61540532e-02f, 4.71035438e-03f, -1.47072300e-01f, -4.63675857e-02f,
  2.32805312e-01f, -1.27661943e-01f, 5.11573963e-02f, -2.54378557e-01f, 3.33354950e-01f, 1.05307186e-02f, 7.64867663e-02f, -2.26626005e-02f, 3.04320335e-01f, 2.82451957e-02f,
  4.55636531e-01f, 8.64615142e-02f, 1.36934100e-02f, -1.81994021e-01f, 6.03285916e-02f, 5.33624273e-03f, 3.04331154e-01f, 4.45363484e-02f, 3.40026617e-01f, 5.12002073e-02f,
  -1.18714251e-01f, -1.33901358e-01f, 2.61804052e-02f, 1.46444261e-01f, -6.50973246e-02f, 2.69791871e-01f, -3.09998486e-02f, 1.81779519e-01f, 3.86109769e-01f, 5.00177220e-03f,
  2.84829050e-01f, -1.64956659e-01f, 3.05166781e-01f, -9.84407142e-02f, 4.42497768e-02f, 1.44826546e-01f, 1.64545625e-01f, 4.59247455e-02f, 8.04282054e-02f, 1.56468134e-02f,
  -3.90309142e-03f, 3.33109088e-02f, -6.78087026e-02f, 6.21360205e-02f, -9.47834998e-02f, 9.43640620e-02f, 1.01377375e-01f, -9.59148854e-02f, 9.73792933e-03f, 2.00395033e-01f,
  -1.31150901e-01f, 8.12806860e-02f, 3.46973701e-03f, 1.45031080e-01f, 9.41833667e-03f, 1.62676170e-01f, -2.83477098e-01f, -2.99147349e-02f, -1.20876268e-01f, 9.05517489e-02f,
  -2.75875598e-01f, -2.33223945e-01f, -1.74530804e-01f, -1.22235641e-01f, -1.20947763e-01f, 1.11652426e-02f, 1.64512381e-01f, -1.49869904e-01f, -7.43699595e-02f, -8.59242827e-02f,
  -5.90316243e-02f, -1.94236860e-01f, 8.03649500e-02f, -2.64546722e-01f, -6.14973605e-02f, 1.46996990e-01f, 2.30080500e-01f, 3.45069498e-01f, 1.50296345e-01f, -1.16574414e-01f,
  1.52670085e-01f, 2.78555900e-01f, -3.42719741e-02f, 6.30767867e-02f, 2.16918010e-02f, 3.08136502e-03f, 1.46102279e-01f, 1.16478570e-01f, -1.40049964e-01f, 6.20773993e-02f,
  -2.81249374e-01f, 5.81272990e-02f, -1.35778189e-01f, -1.76769391e-01f, -3.34045053e-01f, -1.57263242e-02f, -7.16540292e-02f, 2.37182304e-01f, 1.62665203e-01f, 3.25202316e-01f,
  -1.83259577e-01f, -3.42801869e-01f, -1.98661268e-01f, -1.28132582e-01f, 1.14925895e-02f, 2.79266417e-01f, -1.03223078e-01f, 2.55960021e-02f, -3.82347643e-01f, 9.32146609e-02f,
  -4.14607078e-02f, 2.29187086e-01f, -2.64148831e-01f, -3.66368182e-02f, 3.57958488e-02f, 1.10296689e-01f, 2.94519186e-01f, -1.19037300e-01f, 4.91769910e-02f, -1.08705975e-01f,
  4.45965797e-01f, -1.49852693e-01f, 4.71907258e-02f, -6.92609251e-02f, -5.50242439e-02f, 6.90636982e-04f, -3.69724154e-01f, 8.69425461e-02f, 3.80382866e-01f, -1.90075174e-01f,
  -1.37722671e-01f, -1.70203492e-01f, 3.66270900e-01f, 1.04035838e-02f, -5.20230010e-02f, 1.50530800e-01f, -2.51028061e-01f, 7.27912843e-01f, 1.14031890e-02f, -1.95373725e-02f,
  -3.72204274e-01f, 1.45141050e-01f, -8.31189901e-02f, -1.63730025e-01f, -9.10538509e-02f, -6.19724989e-02f, 1.96737871e-01f, -1.17903121e-01f, 2.11734697e-01f, -6.66737631e-02f,
  2.09219173e-01f, 2.31954996e-02f, 1.01394549e-01f, -2.90879458e-01f, -1.44597545e-01f, 2.21189093e-02f, -7.06167221e-02f, 1.49624154e-01f, 2.48479158e-01f, -1.05555467e-01f,
  5.75873330e-02f, 4.49125916e-02f, 2.99477637e-01f, -2.15420261e-01f, -3.27585429e-01f, -1.32553846e-01f, -1.94325536e-01f, -3.62520635e-01f, -3.45728427e-01f, -2.42970124e-01f,
  -3.90309542e-01f, -8.02747160e-03f, 2.52049752e-02f, 2.14588940e-01f, 2.93674022e-02f, 6.90755621e-02f, -3.09781116e-02f, 4.86728661e-02f, -2.00254187e-01f, 9.75247025e-02f,
  -1.52328044e-01f, -2.55548209e-02f, 4.46327254e-02f, 1.18739493e-01f, 2.86613256e-01f, -2.13751733e-01f, -1.07738517e-01f, 2.54768610e-01f, 6.43971920e-01f, -4.85600270e-02f,
  2.09346980e-01f, 1.83152586e-01f, -1.98377907e-01f, 1.96780134e-02f, -3.28803398e-02f, -2.01130480e-01f, 1.91533864e-01f, 6.58290014e-02f, 3.61632198e-01f, 6.15788043e-01f,
  -1.66166387e-02f, 1.35386204e-02f, -1.25263616e-01f, 4.21368480e-02f, 1.47277415e-01f, 1.09143751e-02f, 3.67746502e-02f, -2.43194610e-01f, -1.70568496e-01f, 1.27381578e-01f,
  -1.33166358e-01f, -2.14998454e-01f, -1.59874618e-01f, -9.90445912e-02f, -1.57377914e-01f, -3.23827624e-01f, 2.25654673e-02f, -1.01586185e-01f, -6.03047200e-02f, 4.54157382e-01f,
  -2.08491072e-01f, -7.29783624e-02f, -1.47301599e-01f, -1.22128902e-02f, -1.30214736e-01f, 1.22248620e-01f, -2.42404953e-01f, -1.84925888e-02f, -2.57956594e-01f, 1.29213065e-01f,
  -4.96690441e-03f, -4.56814356e-02f, -1.28210559e-01f, -1.15018494e-01f, -7.94302225e-02f, -1.63003549e-01f, -7.85579458e-02f, 6.71269791e-03f, -1.66866824e-01f, 5.84179275e-02f,
  -4.74196039e-02f, -2.59003967e-01f, -2.03827638e-02f, -1.19322874e-01f, -2.18453202e-02f, 4.35333923e-02f, -2.27599025e-01f, -3.12710777e-02f, -1.25679940e-01f, -7.16592222e-02f,
  6.74033538e-02f, 1.03446372e-01f, -1.82136491e-01f, 2.13231355e-01f, -9.48932171e-02f, -6.71749935e-02f, 9.97075588e-02f, 8.41407944e-03f, -1.87486216e-01f, -5.63398525e-02f,
  -2.35481523e-02f, 1.31526098e-01f, -1.32915959e-01f, -2.59148497e-02f, 1.89496130e-01f, 3.45516689e-02f, -2.44857781e-02f, 1.02020383e-01f, 1.32679015e-01f, 8.07182789e-02f,
  -4.18954603e-02f, 8.05424526e-02f, 9.31709483e-02f, 1.40906096e-01f, 1.93801060e-01f, -3.26101482e-02f, -7.09203184e-02f, 1.13301925e-01f, 1.09671175e-01f, -7.51129091e-02f,
  -2.52913050e-02f, 6.94421530e-02f, -9.99523029e-02f, -1.05870023e-01f, 4.13535833e-02f, 5.75226136e-02f, -1.02463722e-01f, 6.00846484e-02f, 4.66441624e-02f, -1.67068094e-01f,
  -2.21676528e-02f, -1.10634953e-01f, 2.93920815e-01f, 5.88858910e-02f, 1.14551865e-01f, 1.21529676e-01f, 1.88594878e-01f, 2.26476081e-02f, 1.33936748e-01f, -6.17395528e-02f,
  -4.75518815e-02f, 8.29642639e-02f, -2.93385625e-01f, -3.40507664e-02f, 3.10514241e-01f, 1.26935557e-01f, 1.47352740e-01f, 1.89455718e-01f, 1.20625459e-01f, 5.38123101e-02f,
  -5.10257995e-03f, -1.19220905e-01f, 4.54291552e-02f, -1.97689503e-01f, -4.40079629e-01f, 1.73215475e-02f, -2.35578269e-01f, 3.32390696e-01f, 2.34377831e-01f, -1.75513998e-01f,
  3.15738171e-01f, -2.45387703e-01f, 1.32293656e-01f, 1.20802065e-02f, 2.64192522e-01f, 2.95512564e-02f, -2.28507444e-02f, -3.35930213e-02f, 3.17372829e-02f, 7.61222839e-02f,
  8.98991078e-02f, 2.73566335e-01f, -6.91936240e-02f, 9.68358386e-03f, -2.56350189e-01f, 9.31502730e-02f, 2.77793378e-01f, 2.62475805e-03f, 7.53696188e-02f, 2.94542080e-03f,
  1.95698440e-01f, 1.00226747e-02f, 2.27919847e-01f, 2.62556411e-02f, 3.30376276e-03f, -3.19371611e-01f, -2.75200661e-02f, -2.40847722e-01f, 2.78459758e-01f, -2.17991456e-01f,
  -9.24579520e-03f, 3.67023312e-02f, -1.26783192e-01f, -2.00277176e-02f, 5.75147122e-02f, -2.47302908e-03f, -2.81023562e-01f, 1.21698909e-01f, -6.71916977e-02f, 1.34632990e-01f,
  1.21822603e-01f, 3.87683287e-02f, 3.20365839e-03f, -1.25139847e-01f, 7.57851973e-02f, 1.97606429e-01f, -1.11103594e-01f, 1.31601393e-01f, 6.90452307e-02f, -7.52236880e-03f,
  2.12838594e-02f, -1.67947248e-01f, -1.46969827e-02f, 2.24140778e-01f, 1.64699629e-02f, 1.19668439e-01f, 3.53566170e-01f, -3.06334868e-02f, 4.20768559e-02f, 3.44006494e-02f,
  3.42277348e-01f, -1.99157186e-02f, -7.59120733e-02f, 2.63897866e-01f, -2.67260104e-01f, 3.81387561e-03f, -1.07975438e-01f, 1.58739701e-01f, -9.14787278e-02f, 2.15090156e-01f,
  5.19445501e-02f, -4.60749976e-02f, 6.69317320e-02f, -7.97010139e-02f, 2.54325747e-01f, -1.60021782e-01f, 8.51323605e-02f, 2.75584236e-02f, 1.42880291e-01f, -4.90473881e-02f,
  3.44963744e-02f, -1.37632433e-02f, -8.35179165e-02f, 1.52114287e-01f, -1.78111903e-02f, 6.70643896e-02f, -1.67707577e-01f, -1.78516265e-02f, 3.40999067e-02f, -1.47623867e-02f,
  1.19464219e-01f, 2.95714587e-01f, -3.02081574e-02f, 1.35599390e-01f, 4.21888024e-01f, 7.78181478e-02f, 6.44720942e-02f, -1.73769772e-01f, -8.22322071e-02f, -1.09526716e-01f,
  2.15462953e-01f, 1.04871072e-01f, 1.87612623e-01f, 1.55028969e-01f, 1.43190786e-01f, 1.73553690e-01f, 1.93020880e-01f, 2.25801975e-03f, 3.01473409e-01f, -4.11897823e-02f,
  2.49607503e-01f, 5.73167950e-02f, 1.33221611e-01f, 2.92285770e-01f, 1.67388871e-01f, 6.60163239e-02f, 1.52715445e-01f, -3.16952792e-05f, 1.89414456e-01f, 1.40903175e-01f,
  -1.34427369e-01f, 1.61859736e-01f, 6.76010400e-02f, 3.39486524e-02f, -2.59804815e-01f, 5.90190350e-04f, 5.49257845e-02f, -9.40671042e-02f, -1.47239625e-01f, -1.43691987e-01f,
  3.74176532e-01f, 2.03865871e-01f, 2.88247973e-01f, 8.35805461e-02f, -1.07956408e-02f, -9.10582244e-02f, -4.89803851e-02f, -2.70346791e-01f, 2.28130117e-01f, 5.68505377e-02f,
  -1.05503678e-01f, -1.14442157e-02f, -2.44512126e-01f, -6.08612150e-02f, 7.69172981e-02f, 8.85890275e-02f, -2.51494348e-01f, 8.74629021e-02f, 1.64434779e-02f, 8.13027024e-02f,
  1.34581290e-02f, 2.06619784e-01f, 1.42699227e-01f, -1.04635023e-02f, -5.43113798e-02f, -1.17418505e-01f, 1.69281662e-02f, -4.37768131e-01f, -1.51356116e-01f, -4.15070467e-02f,
  2.55724620e-02f, 2.40972452e-02f, 6.62498781e-03f, 1.34148315e-01f, -3.22961152e-01f, -1.23139746e-01f, -8.07343945e-02f, -1.35320410e-01f, -1.66404486e-01f, 1.01971760e-01f,
  -3.01861674e-01f, 1.46174459e-02f, -3.28219533e-02f, -2.87379045e-02f, 1.06368713e-01f, -3.82089466e-02f, -1.54529929e-01f, 6.23105355e-02f, -7.83812553e-02f, -4.03412580e-01f,
  -1.05712071e-01f, 1.70608267e-01f, 4.38992940e-02f, 1.10728808e-01f, 2.29906887e-01f, -2.26165831e-01f, -1.89991340e-01f, -3.20419557e-02f, 1.86682567e-01f, -3.69717665e-02f,
  2.39635836e-02f, -3.53282318e-02f, 1.23999100e-02f, 3.46462250e-01f, -1.33416608e-01f, -5.57752661e-02f, -3.98614965e-02f, 3.13023143e-02f, 1.18809240e-02f, 1.04105063e-01f,
  1.57069340e-01f, -1.74568176e-01f, -4.04093206e-01f, 6.78103119e-02f, 7.71641284e-02f, 1.70427337e-02f, 1.24760792e-01f, 6.69428036e-02f, -1.14616081e-02f, 1.78671777e-01f,
  2.38298420e-02f, 2.78667659e-01f, -3.08441401e-01f, 1.43604994e-01f, 3.48842354e-03f, -1.65928990e-01f, -3.09602588e-01f, -2.02764571e-03f, 9.62424576e-02f, 1.59206405e-01f,
  -7.38755390e-02f, 1.68340310e-01f, 1.09792538e-02f, 4.19316292e-02f, -1.18168741e-01f, 2.77829934e-02f, -2.50344165e-02f, -1.75271295e-02f, -4.73604836e-02f, 2.28923127e-01f,
  5.94647415e-02f, 8.30003992e-02f, 3.01153548e-02f, 7.89398924e-02f, 2.88086794e-02f, -1.13337122e-01f, 1.11409766e-03f, -8.30652006e-03f, 2.63357852e-02f, -1.00242943e-01f,
  -9.80530828e-02f, 1.00783892e-02f, -9.91920978e-02f, 1.74639553e-01f, 9.09110457e-02f, -6.97343946e-02f, -3.51091512e-02f, -7.33658373e-02f, -3.87383372e-01f, 5.48638701e-02f,
  -6.65113106e-02f, -8.42560381e-02f, -5.54825604e-01f, -5.98774627e-02f, -1.59994245e-01f, -4.84326743e-02f, -2.45962292e-02f, -1.42735496e-01f, 4.52866182e-02f, -1.49295703e-01f,
  -3.73869427e-02f, -8.91359448e-02f, -7.12900236e-02f, -2.67159790e-01f, -8.48468021e-02f, -1.85800314e-01f, 4.46556173e-02f, 3.41797695e-02f, -6.78176060e-02f, 7.86186457e-02f,
  3.98150608e-02f, 8.43241811e-02f, -5.08789085e-02f, 9.88606215e-02f, -9.46304873e-02f, -4.79075387e-02f, 1.31514162e-01f, 1.49651110e-01f, 2.86643714e-01f, -1.27023920e-01f,
  -5.87446801e-02f, 1.42606586e-01f, -1.23062953e-02f, -1.75355256e-01f, -1.77176088e-01f, 1.05578423e-01f, -3.96599948e-01f, 1.04880035e-01f, -9.63110663e-03f, 1.77346781e-04f,
  6.34975135e-02f, 1.74125805e-02f, 7.75208399e-02f, 2.36628100e-01f, -9.32413563e-02f, 1.44965187e-01f, 1.09872013e-01f, -1.25044063e-01f, 2.68035829e-01f, 8.86487309e-03f,
  -8.47514942e-02f, 1.26895502e-01f, 1.23693362e-01f, 1.49800286e-01f, 5.25226863e-03f, -1.54056596e-02f, -6.71017841e-02f, 4.07795727e-01f, 1.73819453e-01f, 7.20317364e-02f,
  2.49777317e-01f, -6.51752949e-02f, -3.02019030e-01f, 2.06930786e-01f, 3.54180038e-01f, 1.74623728e-02f, 6.59906939e-02f, -2.31340587e-01f, -9.03348625e-03f, -1.92409635e-01f,
  -9.34420452e-02f, 1.22680850e-01f, 2.26889238e-01f, -1.78291962e-01f, 9.80082974e-02f, 1.12037873e-03f, 2.27212757e-01f, -1.55247405e-01f, 8.39652717e-02f, -1.88640535e-01f,
  -9.70912501e-02f, 1.13419190e-01f, 3.06714743e-01f, -5.67068756e-02f, 5.70008680e-02f, 1.00801028e-01f, 1.16245747e-01f, -2.41988618e-03f, 7.02598318e-02f, 1.16245903e-01f,
  -1.86215878e-01f, 1.91608265e-01f, -1.34947196e-01f, 1.74151093e-01f, -1.19347908e-01f, 3.75277936e-01f, 1.63563505e-01f, -2.45083824e-01f, 2.47866154e-01f, -4.19855230e-02f,
  -1.09002590e-01f, 3.34078856e-02f, 2.60857880e-01f, -5.21673411e-02f, -1.15785994e-01f, 3.89494121e-01f, -4.17247087e-01f, 1.53827995e-01f, 1.54615566e-01f, 1.34069026e-01f,
  -2.81212032e-01f, -6.77219778e-02f, 2.23933645e-02f, -1.27740756e-01f, -3.08145136e-01f, 5.55792870e-03f, -3.02658707e-01f, 4.76380205e-03f, -1.63568884e-01f, -2.34543800e-01f,
  -9.38057005e-02f, -7.20445141e-02f, -4.32127938e-02f, -7.06362352e-02f, -1.75792053e-01f, -3.65821458e-02f, -3.08375090e-01f, 1.16568573e-01f, 2.23111790e-02f, -5.53554632e-02f,
  3.86776985e-03f, 9.79457498e-02f, -3.01118225e-01f, 5.31176738e-02f, 1.91355526e-01f, 1.06576577e-01f, -1.22883938e-01f, -1.37189806e-01f, -1.27930388e-01f, -1.23092882e-01f,
  -9.87300202e-02f, -1.53897405e-01f, 2.24300146e-01f, -4.78163688e-03f, -9.70015186e-04f, 9.69736800e-02f, 3.25186029e-02f, 3.75072807e-02f, 2.30791926e-01f, 1.82041332e-01f,
  2.33142063e-01f, 1.48504496e-01f, 1.98156565e-01f, 7.57690296e-02f, 6.78157359e-02f, 1.54844001e-01f, 3.40697989e-02f, -1.71502590e-01f, -1.44172281e-01f, 2.40789622e-01f,
  1.85072377e-01f, -5.44934496e-02f, 2.27382421e-01f, 1.74447641e-01f, -2.15716660e-02f, 6.97109476e-02f, 1.78935394e-01f, -8.89159217e-02f, -1.07032590e-01f, -3.71652767e-02f,
  4.11433466e-02f, 9.40997154e-02f, 1.03754774e-01f, 1.16502278e-01f, -5.10020321e-03f, -9.07156020e-02f, 4.07589525e-01f, 3.64878476e-02f, 1.03645474e-01f, 1.28565624e-01f,
  2.21672609e-01f, 2.33145848e-01f, 1.58470154e-01f, 5.36979809e-02f, 1.31452888e-01f, 2.39203990e-01f, 1.17372833e-01f, -1.57184526e-01f, 3.08481399e-02f, -2.37342604e-02f,
  2.94435084e-01f, 1.33278146e-01f, 8.60254541e-02f, -1.79350376e-01f, -2.27488741e-01f, 1.44215718e-01f, 1.44229248e-01f, -1.88828167e-02f, 3.14595282e-01f, -1.62251621e-01f,
  2.55349934e-01f, -7.57348984e-02f, 4.20196503e-01f, -4.31040712e-02f, 1.26797602e-01f, -8.05460811e-02f, 3.15150321e-01f, -1.31602297e-02f, 5.62320054e-01f, 2.02157527e-01f,
  -1.11619914e-02f, 8.09752867e-02f, -7.12936372e-03f, 6.14371412e-02f, 1.63266048e-01f, 8.07904601e-02f, 8.77405554e-02f, 8.18555057e-02f, -1.22209797e-02f, -1.64003357e-01f,
  1.52609810e-01f, -2.18891889e-01f, 9.57438201e-02f, -2.53751308e-01f, 3.22773866e-02f, -7.87933022e-02f, 2.58752257e-01f, -2.30536163e-01f, 2.57519841e-01f, -1.27941653e-01f,
  -1.87406480e-01f, 1.71839878e-01f, 2.94690609e-01f, 9.06481072e-02f, 1.40481696e-01f, 1.33435011e-01f, 1.89175546e-01f, 6.91888109e-02f, 1.24470577e-01f, 3.50096337e-02f,
  7.86733627e-02f, -7.09618479e-02f, 2.33762771e-01f, 7.07451105e-02f, -1.96440201e-02f, -3.53449099e-02f, 1.00004770e-01f, 5.05743995e-02f, 2.36039087e-01f, -3.24443400e-01f,
  -1.83797419e-01f, 1.34832069e-01f, -7.26624727e-02f, -6.63776472e-02f, 1.40858799e-01f, 1.88514575e-01f, 2.82066036e-02f, -2.01521311e-02f, -6.28606752e-02f, 2.23399252e-01f,
  2.72422791e-01f, -1.91322580e-01f, 9.22683403e-02f, -1.47942286e-02f, 2.47132182e-01f, 9.86189619e-02f, 1.98593631e-01f, 1.23420328e-01f, 2.20594734e-01f, -1.96651500e-02f,
  2.74235576e-01f, -1.96915567e-01f, 4.08809364e-01f, 2.17077389e-01f, 1.58362627e-01f, -4.52112675e-01f, 7.49402586e-03f, 1.25674024e-01f, 2.22832426e-01f, 5.72629534e-02f,
  -1.35975987e-01f, 9.13646370e-02f, 2.29858339e-01f, -8.53514895e-02f, 3.99673656e-02f, -1.86779514e-01f, 4.31214124e-02f, -1.15189679e-01f, 1.36188969e-01f, -3.27844471e-01f,
  2.12798014e-01f, -5.43580949e-01f, -8.16252604e-02f, -7.38951284e-03f, -2.11636603e-01f, -1.53310075e-01f, -8.47340524e-02f, 1.75223485e-01f, -1.86622187e-01f, 5.89560978e-02f,
  -2.56379172e-02f, -8.45836550e-02f, 8.26545134e-02f, 3.00278813e-02f, -2.56156772e-01f, 1.92994568e-02f, -2.34401748e-02f, 2.76162833e-01f, -2.24017918e-01f, 1.10110350e-01f,
  2.37431541e-01f, -3.44590726e-03f, -1.48758829e-01f, 1.66610293e-02f, 1.14128716e-01f, 1.56358778e-01f, 1.92586929e-01f, 2.01245755e-01f, -5.87536134e-02f, 6.98603392e-02f,
  -7.01453909e-02f, 1.48270711e-01f, 4.08590615e-01f, -2.27295712e-01f, -2.05987453e-01f, 6.58217594e-02f, -4.77468818e-02f, 2.43600875e-01f, -7.69970566e-02f, -3.92046511e-01f,
  2.23273076e-02f, -4.78928164e-02f, -1.67143196e-01f, 9.04007107e-02f, 9.85882655e-02f, -1.78432867e-01f, -4.31098074e-01f, -1.38825163e-01f, 2.75535315e-01f, -1.67664811e-02f,
  2.19626307e-01f, -1.91228986e-01f, -6.80854497e-03f, -2.35905610e-02f, -1.02263326e-02f, -2.80750394e-02f, -4.13673371e-01f, 1.22808523e-01f, -1.14128426e-01f, 2.17389062e-01f,
  -3.26256901e-01f, 3.11512828e-01f, 1.50763486e-02f, 2.45969713e-01f, 1.33893505e-01f, 1.32151037e-01f, 1.19678684e-01f, -6.35882765e-02f, 3.47972780e-01f, 4.89397831e-02f,
  -2.40646690e-01f, 2.10495204e-01f, 1.41446054e-01f, -5.01747467e-02f, -3.90449837e-02f, 6.79405779e-02f, 5.75555824e-02f, -1.12641260e-01f, 1.27964973e-01f, 1.01897538e-01f,
  2.24694788e-01f, 1.21999808e-01f, -3.25603455e-01f, 2.08490208e-01f, 6.21045893e-03f, -1.93107769e-01f, -4.57522608e-02f, 1.79309547e-01f, 1.17622636e-01f, 9.28727016e-02f,
  1.19763136e-01f, -8.47927257e-02f, 8.89162049e-02f, 1.17855892e-02f, -1.82853609e-01f, -4.02688943e-02f, 3.95621419e-01f, 3.69451284e-01f, 2.21882403e-01f, 7.02842698e-02f,
  2.82462865e-01f, -3.24959129e-01f, 4.70576659e-02f, 2.76846737e-01f, 2.01836720e-01f, 7.86346793e-02f, -1.45294324e-01f, -9.34769288e-02f, -2.08982065e-01f, 1.87828600e-01f,
  7.87128285e-02f, 8.23600739e-02f, 5.29369898e-02f, 4.98400666e-02f, -4.82370183e-02f, 1.73855588e-01f, 2.51841217e-01f, -1.06380686e-01f, 2.78733492e-01f, 4.42545116e-02f,
  -7.09168836e-02f, -1.33654565e-01f, 8.41720253e-02f, 1.94972560e-01f, -2.77176988e-03f, 1.38393074e-01f, 1.04956642e-01f, -1.75608601e-02f, 8.78069177e-02f, 5.38697988e-02f,
  1.35394678e-01f, 6.50844947e-02f, 1.14354759e-01f, -1.44248396e-01f, -3.66837792e-02f, -1.11109443e-01f, 2.85286494e-02f, -5.23785241e-02f, -1.27881184e-01f, 6.02875091e-03f,
  -3.69317383e-02f, 5.74688092e-02f, -1.74535457e-02f, 1.05754495e-01f, -6.94218948e-02f, 1.03831492e-01f, -3.43445651e-02f, 9.31649655e-02f, -1.27636939e-01f, 8.11264217e-02f,
  3.50099131e-02f, -1.19324466e-02f, 5.32222018e-02f, -3.75770144e-02f, 1.93744320e-02f, -5.21814264e-02f, -2.31043752e-02f, -5.23046497e-03f, -8.29511788e-03f, -1.06858619e-01f,
  -2.40369849e-02f, -4.71915156e-02f, 1.74324233e-02f, -8.24833289e-02f, 1.15595594e-01f, 4.96381596e-02f, -1.30224437e-01f, -1.31547349e-02f, 2.88772341e-02f, -7.54749179e-02f,
  -2.84692887e-02f, 7.55877467e-03f, -4.75532413e-02f, 1.49540722e-01f, -6.52058348e-02f, -8.97972360e-02f, -8.42770860e-02f, 2.62749493e-02f, -6.49834350e-02f, -9.82402265e-02f,
  7.09480420e-02f, -8.73359665e-02f, 3.01015377e-01f, -8.41543525e-02f, 8.97055306e-03f, -9.57246721e-02f, 2.07942605e-01f, 2.80841645e-02f, 7.89005030e-03f, -4.42665890e-02f,
  -1.62960440e-01f, -9.61806551e-02f, 3.38536575e-02f, 3.56367640e-02f, 9.56519544e-02f, -4.35060710e-02f, -2.86475420e-02f, 2.77734711e-03f, 1.44442409e-01f, -8.68930817e-02f,
  1.91662490e-01f, 2.23077521e-01f, 9.00431499e-02f, 8.25022608e-02f, -1.47853484e-02f, 7.17031881e-02f, -1.12126075e-01f, 1.48908570e-01f, 2.89203245e-02f, 1.23331681e-01f,
  1.71949938e-01f, -7.57818967e-02f, 1.18685178e-01f, 1.17827855e-01f, 1.20970495e-01f, 5.69490204e-03f, 2.43968993e-01f, 1.05468430e-01f, 7.97571614e-03f, 5.74278459e-02f,
  1.30249206e-02f, -1.99851230e-01f, -4.26718220e-02f, 1.57427892e-01f, -2.48068407e-01f, -1.70734435e-01f, -8.14949721e-02f, 1.29453596e-02f, -2.21753761e-01f, 7.85746351e-02f,
  1.80586591e-01f, -1.22420587e-01f, -1.64706632e-02f, -5.26149897e-03f, 8.34763702e-03f, -1.38891056e-01f, -1.11133121e-01f, -2.33044386e-01f, -9.66834575e-02f, 7.01312423e-02f,
  6.27274998e-03f, 2.95281410e-01f, -8.04675668e-02f, -2.20922858e-01f, -5.66853546e-02f, 6.44887984e-02f, -1.90820575e-01f, -4.67830151e-02f, -7.50479521e-03f, 8.07823166e-02f,
  2.78831154e-01f, 2.53543854e-01f, 7.32406182e-03f, 4.94958684e-02f, -3.17385614e-01f, -9.89362895e-02f, -2.29585230e-01f, -1.18753612e-01f, -1.32355556e-01f, 1.06253907e-01f,
  4.67180684e-02f, 3.50295871e-01f, 2.53693759e-01f, 1.02272883e-01f, -4.97297607e-02f, 8.29869136e-02f, 1.43498644e-01f, 3.84889618e-02f, -2.06454508e-02f, 1.77643940e-01f,
  1.33278826e-02f, 1.42543152e-01f, 1.47350535e-01f, 1.95418105e-01f, 1.00787245e-01f, -2.94808764e-02f, 7.61203393e-02f, 2.57987082e-01f, -1.36611298e-01f, 1.85650557e-01f,
  7.88579062e-02f, -1.01987633e-03f, 1.24307148e-01f, 1.53436244e-01f, -9.79179963e-02f, -5.47436327e-02f, -6.73742890e-02f, 5.43336049e-02f, -2.74137497e-01f, -9.81986225e-02f,
  -7.78161138e-02f, -2.48824209e-01f, 3.21457684e-02f, -6.97842008e-03f, 1.60207897e-01f, -3.18583697e-01f, -9.46041718e-02f, -1.11128032e-01f, 6.83770701e-02f, 1.02950316e-02f,
  -1.41642774e-02f, 9.72364563e-03f, -8.51622894e-02f, 2.99837887e-02f, -5.68438470e-02f, 3.13091546e-01f, -3.96983251e-02f, -1.55868694e-01f, -1.34704530e-01f, 2.70683736e-01f,
  -9.56402197e-02f, -8.02570209e-02f, 1.19527876e-01f, 1.40973642e-01f, 1.47426754e-01f, 1.19992338e-01f, 1.24147095e-01f, 7.72582041e-03f, -1.78898603e-01f, 9.63464677e-02f,
  -1.63692743e-01f, -1.40954569e-01f, -3.95771384e-01f, 1.81194156e-01f, -6.89451322e-02f, 4.01333362e-01f, 3.30184609e-01f, 2.00792760e-01f, 2.17947707e-01f, -5.36366589e-02f,
  3.90089676e-02f, 1.11401521e-01f, -9.04369205e-02f, -1.08635068e-01f, 2.33022377e-01f, -9.25384089e-02f, -2.44568028e-02f, 4.22804244e-02f, -1.77192748e-01f, 5.11324964e-02f,
  -5.31264544e-02f, -8.89615715e-02f, -1.70712888e-01f, 1.73734397e-01f, 1.13577187e-01f, -6.86393231e-02f, 2.17872057e-02f, -3.21397424e-01f, -2.35573798e-01f, 1.93685040e-01f,
  7.39835575e-02f, -2.36275852e-01f, -3.61189783e-01f, 1.78682879e-01f, 4.35244173e-01f, -1.98850721e-01f, 1.60741165e-01f, -3.59731197e-01f, -1.77761972e-01f, 1.49631044e-02f,
  -6.32534996e-02f, -4.05133516e-02f, 1.11095525e-01f, 1.42022017e-02f, -2.80298982e-02f, 1.27396196e-01f, -5.93454838e-02f, -8.28059623e-04f, -1.15880378e-01f, 1.57381564e-01f,
  -2.58371174e-01f, 1.24832809e-01f, 2.89863318e-01f, -1.46456912e-01f, 4.40574735e-01f, 1.48964629e-01f, -1.55321255e-01f, 3.68812233e-02f, 1.81182280e-01f, 2.78378516e-01f,
  -1.05971098e-01f, -7.35426545e-02f, -3.97390453e-03f, -2.16728777e-01f, 2.03666434e-01f, 1.73627868e-01f, -2.23152101e-01f, -1.33202160e-02f, 5.66593595e-02f, -4.69903536e-02f,
  -5.89213893e-02f, 9.33481231e-02f, 2.34232649e-01f, 2.95592565e-02f, 1.20692924e-01f, 9.65818018e-02f, 2.14663520e-01f, 1.00899577e-01f, 1.60847694e-01f, 6.64465874e-02f,
  -1.12110592e-01f, 1.58094112e-02f, 2.37446222e-02f, 1.74299479e-01f, 1.89184532e-01f, -1.29602641e-01f, 1.54570073e-01f, 1.13174513e-01f, 5.62066101e-02f, 6.58119470e-02f,
  1.06168211e-01f, 1.41894370e-01f, -1.91097483e-01f, 2.51231492e-01f, 1.02391452e-01f, 2.08085746e-01f, 1.34350270e-01f, 6.57100305e-02f, -1.35702461e-01f, 1.15477748e-01f,
  -8.25856924e-02f, 1.43438689e-02f, 2.17185289e-01f, 6.40118569e-02f, 2.40089968e-01f, 2.09042281e-01f, 1.11474112e-01f, -2.71074325e-02f, -1.62768140e-01f, 2.87298381e-01f,
  2.08364010e-01f, -1.03341304e-01f, 3.08858193e-02f, -1.13873467e-01f, 1.78960651e-01f, -1.41756743e-01f, 4.73130867e-02f, -8.89153108e-02f, 1.10878929e-01f, 1.09837973e-03f,
  -1.74858034e-01f, -7.08355904e-02f, 2.23445576e-02f, 4.01611775e-01f, -2.33768448e-02f, 3.56940866e-01f, 1.98989492e-02f, 3.80864553e-02f, 6.70109615e-02f, 7.93014690e-02f,
  3.69131774e-01f, -1.05024144e-01f, 2.80185819e-01f, 1.69771630e-02f, 6.72893738e-03f, -2.11574584e-02f, 1.40498161e-01f, 1.16354972e-01f, -1.03101566e-01f, -4.27372009e-02f,
  2.28849128e-01f, 1.86600953e-01f, -3.70984077e-01f, 8.74295905e-02f, 2.22844884e-01f, -2.18826383e-02f, 4.27292436e-02f, 2.13805065e-02f, 2.05961958e-01f, 6.63288534e-02f,
  6.78926185e-02f, -3.64145398e-01f, -9.35585350e-02f, 7.87522420e-02f, 1.23222709e-01f, -1.87110245e-01f, -1.54470310e-01f, -7.53852203e-02f, -3.12193960e-01f, 2.67989445e-03f,
  9.83056948e-02f, -6.39447197e-02f, 9.46246162e-02f, 1.57492414e-01f, -2.06311718e-01f, 1.92679256e-01f, 2.19336867e-01f, 2.68419445e-01f, -1.25585362e-01f, 8.24631155e-02f,
  -3.33302617e-01f, -2.94867069e-01f, -9.11048874e-02f, -3.17135334e-01f, -2.87796855e-01f, 6.81542680e-02f, 1.09406717e-01f, 9.89466012e-02f, 1.39159232e-01f, -7.50743300e-02f,
  -9.53778028e-02f, 1.57433391e-01f, -2.25999147e-01f, -7.58773088e-02f, 2.06578270e-01f, 1.63332433e-01f, -5.31364279e-03f, -6.89983442e-02f, 1.81984767e-01f, 8.25066003e-04f,
  9.09991413e-02f, -2.14918390e-01f, 3.15217227e-02f, -7.82234967e-03f, -7.35294744e-02f, 1.71626538e-01f, 5.67355147e-03f, 1.71227500e-01f, -1.31977364e-01f, 3.24346572e-01f,
  2.27040872e-02f, 1.92885652e-01f, 1.54815027e-02f, 2.07100749e-01f, 2.19561793e-02f, -3.18041183e-02f, 2.55974114e-01f, 2.67154239e-02f, 6.41526654e-02f, 2.98847239e-02f,
  1.02287173e-01f, 1.41371325e-01f, -2.05302060e-01f, -4.32992820e-03f, 2.69483328e-02f, 4.37966406e-01f, 1.83786139e-01f, -1.47893548e-01f, -5.01722395e-02f, -5.27579822e-02f,
  -1.48446962e-01f, -2.24236120e-02f, 4.76281285e-01f, 1.02639668e-01f, -3.88069838e-01f, -2.98286468e-01f, -2.38613859e-01f, -3.40577662e-01f, 9.26395357e-02f, -1.55861303e-01f,
  2.90232543e-02f, -2.67910898e-01f, 3.84331355e-03f, -2.42975041e-01f, 4.20280993e-01f, -9.09638777e-02f, 2.20406085e-01f, -1.76622197e-01f, 4.76344191e-02f, 1.97148710e-01f,
  -9.11147986e-03f, -7.99468905e-02f, -1.50310710e-01f, 1.05205737e-01f, -1.10959113e-01f, 1.81930348e-01f, 1.44367263e-01f, -8.25020820e-02f, 3.17563489e-02f, 2.54356302e-03f,
  2.62195617e-01f, -6.06033728e-02f, -1.14752039e-01f, -5.86480685e-02f, 9.67641547e-02f, -1.21750273e-01f, -1.81380302e-01f, 9.49479789e-02f, -3.74794483e-01f, -7.56503344e-02f,
  -1.60940453e-01f, -6.94285184e-02f, 2.21861258e-01f, -1.55091777e-01f
};

// L2_fan_Bp_bar (Shape: 1 x 26)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 26;
const float L2_fan_Bp_bar_data[] = {
  1.90458387e-01f, -2.09231321e-02f, -1.13127595e-02f, 2.36013532e-01f, 1.10869229e-01f, -1.28731847e-01f, 1.14160441e-01f, -2.46847868e-02f, 6.62664399e-02f, -5.52571975e-02f,
  2.44707838e-02f, 6.49837628e-02f, -1.97465774e-02f, 1.80093199e-02f, -4.31941710e-02f, 1.16125621e-01f, 1.41977087e-01f, 7.32006680e-04f, 1.06215566e-01f, -6.10182621e-02f,
  4.02997732e-02f, 8.97774473e-02f, 9.81453881e-02f, 1.39693141e-01f, 9.23805288e-04f, 1.04674324e-01f
};

// L3_fan_Wp (Shape: 19 x 64)
const int L3_fan_Wp_rows = 19;
const int L3_fan_Wp_cols = 64;
const float L3_fan_Wp_data[] = {
  1.45304650e-01f, 9.79796350e-02f, 2.06338689e-01f, -1.32121965e-01f, -4.84596044e-02f, 1.13907933e-01f, 1.16725251e-01f, 3.64005864e-02f, -9.66144130e-02f, 4.91692089e-02f,
  -5.48932217e-02f, -7.92470276e-02f, 2.01791693e-02f, -1.05049036e-01f, -3.62978503e-02f, -1.76545270e-02f, -5.66401109e-02f, -2.32160017e-02f, 2.77954131e-01f, -1.45619825e-01f,
  -2.14345917e-01f, 3.52472700e-02f, 2.15011492e-01f, -1.20316975e-01f, 5.61825931e-02f, 7.97487497e-02f, 1.44733652e-01f, -3.42242330e-01f, -3.44716996e-01f, 1.55386224e-01f,
  3.70662771e-02f, -2.18754262e-01f, 4.95883413e-02f, 2.03226641e-01f, -1.77446187e-01f, -9.89029855e-02f, -6.27469048e-02f, -7.75821060e-02f, -7.03743752e-03f, 1.07619099e-01f,
  1.82562798e-01f, 9.09036323e-02f, -7.72316381e-02f, 2.31139556e-01f, 1.27931893e-01f, 6.67194510e-03f, 5.89059957e-04f, 1.81692950e-02f, -4.36358601e-02f, 1.81311339e-01f,
  -2.79967953e-02f, -1.43507317e-01f, 3.07307571e-01f, 2.48892773e-02f, 1.26564071e-01f, 2.59770900e-02f, 9.53186899e-02f, 2.18086708e-02f, -1.36923283e-01f, -1.54340819e-01f,
  2.40393475e-01f, 1.52428998e-02f, 9.43747014e-02f, -2.16807455e-01f, 3.77767794e-02f, 4.95967045e-02f, 1.98808685e-01f, 7.16120889e-03f, -7.09398836e-02f, -2.18338042e-01f,
  4.74701487e-02f, -6.56834543e-02f, -2.12241281e-02f, 7.41173252e-02f, 1.11838356e-01f, 5.21596968e-02f, 2.24535633e-02f, -1.36349618e-01f, -1.60175562e-01f, 7.41281584e-02f,
  -1.10493198e-01f, -1.45194218e-01f, -1.11238122e-01f, 5.44500202e-02f, -9.81114134e-02f, 1.48301408e-01f, 1.37694106e-01f, -1.05692446e-01f, -9.83258262e-02f, -7.10239932e-02f,
  9.74162519e-02f, 3.46454531e-01f, 3.16137075e-01f, -8.86356011e-02f, -6.22011423e-02f, -9.15869921e-02f, -1.28043890e-01f, -7.35956654e-02f, 1.65487051e-01f, -4.88229357e-02f,
  -1.48323625e-01f, 6.46546930e-02f, -1.17844693e-01f, -1.04082376e-01f, -6.27328828e-02f, -9.80405584e-02f, 2.17220634e-01f, -1.68955639e-01f, 5.20994551e-02f, -2.10597795e-02f,
  -1.57398671e-01f, 8.18758309e-02f, -6.07235990e-02f, 1.08061638e-02f, 1.38448328e-01f, 1.63440123e-01f, 1.94006443e-01f, -2.02393010e-01f, -1.94438726e-01f, 1.13444500e-01f,
  4.78459559e-02f, -8.01987574e-03f, 1.69074476e-01f, 7.20734298e-02f, -1.34481445e-01f, -1.40829263e-02f, 2.20047385e-01f, -1.12287968e-01f, -1.18303709e-01f, 2.19504803e-01f,
  2.78162241e-01f, -5.79175726e-02f, 1.37195617e-01f, -2.89864819e-02f, 2.77462564e-02f, -4.11969163e-02f, -2.21444704e-02f, -8.05858895e-02f, 5.46383187e-02f, 2.98018218e-04f,
  7.21246898e-02f, 9.35062990e-02f, 1.68059897e-02f, 9.49539840e-02f, 6.14889041e-02f, -1.96245760e-02f, -2.40382999e-02f, 1.87624209e-02f, -1.97766542e-01f, -1.38012215e-01f,
  -1.50036542e-02f, 2.37482205e-01f, -8.94241184e-02f, 6.73636422e-02f, 4.31414358e-02f, 1.71108305e-01f, 2.15922505e-01f, -2.79062390e-01f, -3.09507363e-02f, 1.34140909e-01f,
  1.30506620e-01f, -9.06590298e-02f, 7.77613819e-02f, 8.08659382e-03f, 1.37755588e-01f, 4.01659906e-02f, 2.45417506e-01f, 1.63230032e-01f, -7.85853192e-02f, 1.33514658e-01f,
  2.08802402e-01f, -1.77985251e-01f, -4.58763866e-03f, 2.23236382e-02f, -2.38743499e-01f, 1.89784855e-01f, -8.20351541e-02f, 5.79173788e-02f, -2.18785435e-01f, 5.34652248e-02f,
  -2.09967539e-01f, -1.16759509e-01f, -1.58924118e-01f, 1.69245034e-01f, -3.30307186e-02f, 1.08176819e-05f, 8.86476934e-02f, -5.57751767e-02f, -5.60007542e-02f, 1.15027964e-01f,
  -1.48833394e-02f, -2.17213109e-01f, 6.93593249e-02f, 3.90081294e-02f, 1.02170631e-02f, -2.05718696e-01f, -1.92845419e-01f, -1.79955959e-01f, 1.32195786e-01f, 7.84299001e-02f,
  -7.12817013e-02f, -2.65620261e-01f, 2.28111236e-03f, -1.57209381e-01f, -1.92282200e-01f, -8.63745585e-02f, 9.84897092e-02f, -1.04403913e-01f, -1.35986254e-01f, -1.16556592e-01f,
  1.16332054e-01f, 5.99946734e-03f, 9.62847546e-02f, -1.14905469e-01f, -5.00815697e-02f, -1.18523233e-01f, 8.89858380e-02f, 2.12582182e-02f, -5.87668084e-03f, -2.54330695e-01f,
  -4.65099290e-02f, 7.03189969e-02f, 2.43264675e-01f, 2.45213002e-01f, -1.38197437e-01f, -8.51219594e-02f, 7.53737465e-02f, -4.25339073e-01f, 8.76523256e-02f, 3.36151898e-01f,
  -9.95643437e-02f, 6.92855492e-02f, -2.97172368e-01f, 9.67539400e-02f, -5.92511855e-02f, -2.19713464e-01f, 1.39588024e-02f, -3.20320614e-02f, 9.89174172e-02f, -9.85138416e-02f,
  1.23049811e-01f, -8.96627754e-02f, -1.24338590e-01f, 1.78745776e-01f, -2.23503530e-01f, 1.86409224e-02f, 8.82944651e-03f, 9.14971977e-02f, 8.83339718e-02f, -3.32935601e-02f,
  -2.68598106e-02f, -1.58102065e-01f, 1.81912079e-01f, -3.69235910e-02f, 2.69205477e-02f, 1.26073867e-01f, -1.27397031e-01f, -5.09211533e-02f, 1.90995038e-01f, -1.05703287e-01f,
  3.41745950e-02f, -1.76604927e-01f, 1.76142082e-01f, -3.48886847e-02f, 1.89493541e-02f, -1.61202177e-01f, -2.29952056e-02f, -3.15867253e-02f, -2.61701103e-02f, -8.40352997e-02f,
  -1.15104809e-01f, 5.45903817e-02f, -6.33137450e-02f, 7.99423382e-02f, 1.72827169e-02f, 4.76311408e-02f, -5.64552210e-02f, 8.21174681e-02f, 5.13422340e-02f, 2.37923384e-01f,
  7.30059370e-02f, -9.80101675e-02f, 8.52307007e-02f, 1.11223072e-01f, 6.53701425e-02f, -2.14545012e-01f, 1.50833443e-01f, 1.64978296e-01f, -1.03840359e-01f, -4.30979244e-02f,
  -9.70351696e-02f, -1.25961587e-01f, 1.29994005e-02f, 2.17154756e-01f, 6.87217861e-02f, 9.70262010e-03f, -8.87119472e-02f, 1.68694660e-01f, -8.61249790e-02f, -2.87248552e-01f,
  3.21463406e-01f, -9.32527110e-02f, -5.16204573e-02f, 1.15265474e-01f, -8.11799988e-02f, 1.24923907e-01f, -1.77894369e-01f, 4.75023761e-02f, -2.36223683e-01f, 9.60321873e-02f,
  -8.67286474e-02f, 2.69172668e-01f, 1.68883312e-03f, 1.05367184e-01f, 3.36578041e-02f, 5.58854342e-02f, -3.10089029e-02f, -1.06254104e-03f, -7.89087042e-02f, -7.34954774e-02f,
  -1.87968373e-01f, -8.22110698e-02f, -3.42638907e-03f, -1.18987195e-01f, -2.73422301e-01f, 6.58168867e-02f, 2.59056222e-03f, -1.60330802e-01f, 1.03125781e-01f, -1.77105129e-01f,
  -2.16855988e-01f, -6.36783168e-02f, -2.15108976e-01f, -4.17089015e-02f, 1.25126094e-01f, -4.07272018e-02f, -2.91779358e-02f, -3.79103303e-01f, -2.03986783e-02f, 2.41042778e-01f,
  -3.38257244e-03f, -8.55016708e-02f, -1.80502877e-01f, -7.69306198e-02f, -2.06756160e-01f, -2.39120886e-01f, 2.43834406e-02f, -1.62800550e-01f, -2.22096533e-01f, 2.73350120e-01f,
  3.22685428e-02f, 2.72312105e-01f, -2.75378972e-01f, 1.22365288e-01f, -2.20372543e-01f, -3.42546672e-01f, -9.97603536e-02f, 3.16353291e-01f, 3.78529914e-02f, -2.35460196e-02f,
  -2.90362358e-01f, 1.46105751e-01f, 2.49393340e-02f, -1.64649263e-01f, 1.21147573e-01f, -1.66364059e-01f, -1.35063156e-02f, -1.44106597e-01f, 1.19974628e-01f, -7.77787939e-02f,
  -2.87158024e-02f, 3.88672613e-02f, -1.36378393e-01f, 9.41936523e-02f, 1.98068917e-01f, 2.04298094e-01f, -2.39309013e-01f, 3.17099839e-02f, -1.10232092e-01f, -2.72210762e-02f,
  1.31074145e-01f, 1.16388202e-01f, -1.45230696e-01f, -4.18851385e-03f, -9.18330848e-02f, -8.78990963e-02f, 6.80400757e-04f, 4.98006307e-02f, 4.22464646e-02f, 7.67470971e-02f,
  -1.53271571e-01f, 6.06173910e-02f, -7.31621981e-02f, 4.05591391e-02f, -8.78585652e-02f, -8.44786912e-02f, -5.85535914e-02f, -3.89589183e-02f, -8.55013356e-02f, -1.00011796e-01f,
  -1.20030619e-01f, 7.53155164e-03f, -7.20760226e-02f, 1.73550352e-01f, -6.92125186e-02f, 5.14190756e-02f, 1.34521484e-01f, 4.75399196e-02f, 1.05011083e-01f, -1.57415733e-01f,
  -6.49923757e-02f, 3.51740196e-02f, 1.16321805e-03f, 1.92087248e-01f, -1.61298245e-01f, 2.05584005e-01f, -2.83119470e-01f, 1.79897770e-01f, -6.69950917e-02f, -4.85777594e-02f,
  -1.16913870e-01f, 2.93805033e-01f, -1.81185246e-01f, -5.07172085e-02f, 1.18643135e-01f, 3.05076540e-02f, -1.80424616e-01f, 1.42764291e-02f, -3.05524707e-01f, -1.49928518e-02f,
  2.42657110e-01f, 5.29651120e-02f, 1.26306832e-01f, -1.57741666e-01f, 8.78175199e-02f, 6.45636618e-02f, 5.34884632e-02f, 2.26864338e-01f, 1.82692185e-01f, -1.09733641e-01f,
  9.51808877e-03f, 3.56721431e-02f, -1.25924796e-01f, -4.23290990e-02f, -3.67213190e-02f, -5.02876565e-02f, -1.76981706e-02f, 1.46265225e-02f, 6.76370859e-02f, 1.66211158e-01f,
  -2.33811489e-03f, -1.10819012e-01f, 4.27517630e-02f, -2.22869024e-01f, 5.90788126e-02f, 1.35636598e-01f, 6.14518076e-02f, 1.53014258e-01f, -8.89426656e-03f, 1.65651813e-01f,
  6.20288253e-02f, -9.51404423e-02f, -1.18855368e-02f, -5.66756092e-02f, 9.58228856e-02f, -1.71910487e-02f, -8.39076564e-02f, 4.01166901e-02f, 1.13997974e-01f, -1.87458619e-01f,
  -4.03913334e-02f, -4.60923016e-02f, 2.59628326e-01f, -6.43031718e-03f, -2.03971192e-02f, -1.50990531e-01f, 1.59538195e-01f, -5.09591680e-03f, 1.28139555e-01f, 1.47238404e-01f,
  1.68396264e-01f, -2.29529694e-01f, 4.65387218e-02f, 2.75332689e-01f, 2.35387802e-01f, -2.24565729e-01f, -3.02978933e-01f, -3.95510010e-02f, -8.71618390e-02f, -2.87214518e-02f,
  6.45052865e-02f, -3.25244367e-01f, -1.64095044e-01f, 1.40138045e-01f, -3.98319028e-02f, -2.43476816e-02f, 1.12499729e-01f, -1.85970385e-02f, 1.89170927e-01f, -4.35007140e-02f,
  -7.56724179e-02f, 7.03363493e-02f, -3.62106115e-02f, -1.09714597e-01f, 2.61335094e-02f, -1.77688822e-02f, -4.86822203e-02f, -6.82378337e-02f, 2.07502216e-01f, -9.29858908e-02f,
  3.64191681e-02f, 1.69014871e-01f, 5.50346784e-02f, 8.33450537e-03f, 4.50894513e-05f, 6.30673543e-02f, -4.78555523e-02f, 1.73913330e-01f, 2.31012125e-02f, 1.14191053e-02f,
  2.62859136e-01f, 3.33950557e-02f, -4.86711487e-02f, -1.55133456e-02f, -8.91889166e-03f, 2.58203261e-02f, 7.87777454e-02f, -1.15157411e-01f, 1.25739336e-01f, 1.75034497e-02f,
  -3.46193761e-02f, 1.66870981e-01f, 1.79861784e-01f, -8.83593485e-02f, 2.69039720e-01f, -5.87794706e-02f, -2.27085382e-01f, -5.21499142e-02f, -9.75775942e-02f, -3.56921047e-01f,
  1.69976950e-02f, -6.44264966e-02f, 1.19624570e-01f, 3.56047153e-02f, 3.13021332e-01f, 9.28728655e-02f, 3.10640275e-01f, -1.55720830e-01f, 1.97989717e-01f, -1.65344104e-01f,
  1.35894597e-01f, -1.24813020e-01f, 1.35967851e-01f, 3.77013944e-02f, 1.97067097e-01f, -1.94044739e-01f, -7.46221393e-02f, 4.21068408e-02f, -1.63115915e-02f, 1.06839836e-01f,
  6.86992481e-02f, 2.86394298e-01f, 5.95935136e-02f, 1.88208118e-01f, 4.57216129e-02f, 7.08673596e-02f, 2.00632531e-02f, 1.71565581e-02f, -7.59516954e-02f, -1.41072839e-01f,
  8.42025280e-02f, 1.90199926e-01f, 1.60106774e-02f, -1.66862026e-01f, 8.57625231e-02f, 1.09874256e-01f, 1.11445487e-01f, -1.44180804e-01f, 1.26666099e-01f, 1.17513597e-01f,
  6.26122430e-02f, -2.84542680e-01f, -9.12880991e-03f, 2.22703576e-01f, -1.05204731e-01f, 6.66119158e-03f, 1.70653358e-01f, 2.17570830e-03f, -1.02481499e-01f, -8.15614909e-02f,
  1.73097089e-01f, 1.19202942e-01f, 7.19329789e-02f, -1.49749085e-01f, -2.52615094e-01f, -1.48645505e-01f, 5.18714897e-02f, 8.91301110e-02f, -2.46056095e-01f, 2.75937356e-02f,
  4.02648784e-02f, 2.27006581e-02f, -1.19002014e-01f, 3.05680990e-01f, 1.37562528e-01f, -2.47070551e-01f, 1.63998455e-01f, 9.78568196e-03f, -2.60597169e-01f, -2.70152930e-02f,
  7.14382082e-02f, -5.44706767e-04f, -1.99050128e-01f, 2.36193568e-01f, -2.69322902e-01f, 1.69092253e-01f, 2.51881350e-02f, 7.43722320e-02f, -5.57610989e-02f, 2.59700771e-02f,
  -1.80910572e-01f, -2.36297306e-02f, -2.02593192e-01f, -2.76063513e-02f, -4.40856554e-02f, -1.99394487e-02f, 1.73807051e-02f, 1.96413063e-02f, -5.81602454e-02f, -1.36256665e-01f,
  -3.05521488e-01f, 1.15563348e-02f, 1.13553829e-01f, 2.84552779e-02f, -7.11617526e-03f, -1.31318346e-01f, 9.15491432e-02f, 1.32648990e-01f, -1.00138798e-01f, -9.17024836e-02f,
  2.22754925e-01f, 1.02138907e-01f, 5.39833680e-02f, -8.20602253e-02f, 2.43402004e-01f, -3.77697349e-01f, -2.00372934e-01f, -7.83090219e-02f, 2.52488345e-01f, 1.17445022e-01f,
  5.57339638e-02f, 2.73051977e-01f, 1.35036781e-01f, -1.49876043e-01f, 2.10495908e-02f, 9.96185541e-02f, -3.68404910e-02f, -1.42683446e-01f, -1.13593921e-01f, 9.88176689e-02f,
  1.44487038e-01f, 6.43021148e-03f, -2.28197485e-01f, -1.39848545e-01f, -1.76393181e-01f, -1.44233376e-01f, -2.19459519e-01f, 3.10213953e-01f, 4.16473951e-03f, 2.13211879e-01f,
  -5.93524761e-02f, -7.26794899e-02f, -2.20828682e-01f, -2.33078562e-02f, -2.20821708e-01f, 1.31463349e-01f, -2.63977557e-01f, 7.32328370e-02f, -2.97247291e-01f, 9.57444310e-02f,
  1.42768219e-01f, -1.29449144e-01f, -5.90789355e-02f, -1.72096416e-01f, 2.95678616e-01f, 1.07021064e-01f, 2.82169711e-02f, 1.13783270e-01f, -1.41538709e-01f, -1.33528888e-01f,
  1.52289480e-01f, -3.64471935e-02f, 4.36020717e-02f, -1.30018620e-02f, 6.24571964e-02f, -7.16848746e-02f, 1.92821354e-01f, -5.91936521e-03f, 3.62611338e-02f, 8.97609666e-02f,
  5.23066632e-02f, 1.71604380e-02f, 6.29134253e-02f, 8.07525665e-02f, -1.56068221e-01f, 4.72494923e-02f, -8.56433958e-02f, -6.38464168e-02f, 2.02862203e-01f, 4.41285707e-02f,
  1.37785282e-02f, 1.23045994e-02f, -2.38228515e-01f, 1.27526283e-01f, -5.59077002e-02f, 2.73034245e-01f, -5.51437400e-02f, -1.94228679e-01f, 9.76284966e-02f, 3.79986875e-02f,
  -1.15171131e-02f, 1.61806718e-01f, 1.96943074e-01f, 8.49048048e-02f, 6.92168474e-02f, 8.57578292e-02f, 2.57961839e-01f, 7.89601430e-02f, -1.48674205e-01f, -5.69026843e-02f,
  9.27103311e-02f, -8.63667130e-02f, 4.58557494e-02f, -3.61267254e-02f, -1.75457716e-01f, 2.49228284e-01f, 1.13184161e-01f, 2.54671961e-01f, 1.21206559e-01f, 1.37620732e-01f,
  9.38659161e-03f, 1.35064900e-01f, 4.99690808e-02f, 3.55820172e-02f, 2.84432590e-01f, -2.87861060e-02f, -1.03430331e-01f, -1.96019962e-01f, 1.12163365e-01f, 4.51856218e-02f,
  2.46966496e-01f, 2.11136520e-01f, 1.20872922e-01f, 3.35562900e-02f, -6.06732778e-02f, -9.06130522e-02f, -8.22022930e-02f, 3.59971002e-02f, 1.96377248e-01f, -8.46613422e-02f,
  1.04030885e-01f, 1.32107399e-02f, -1.47975400e-01f, -8.17331001e-02f, 6.27313256e-02f, -1.60573974e-01f, 1.93732858e-01f, -5.92832528e-02f, -1.22016750e-01f, 1.89489245e-01f,
  -1.27549008e-01f, 2.27310862e-02f, -1.23439930e-01f, 9.39954668e-02f, -3.52636054e-02f, -1.92239776e-03f, -1.02979958e-01f, 2.58626342e-01f, -1.53573200e-01f, -1.44892663e-01f,
  1.21839326e-02f, -1.65858775e-01f, -8.95652622e-02f, -4.75447699e-02f, 1.14453398e-01f, 1.27271041e-01f, 4.70112413e-02f, -2.64593512e-02f, -2.88367346e-02f, -1.17650583e-01f,
  1.07541315e-01f, -2.24037051e-01f, 6.91640452e-02f, 1.36048988e-01f, 6.73965439e-02f, -1.06588826e-01f, -2.03862324e-01f, -2.03410666e-02f, -4.70203273e-02f, -2.21362889e-01f,
  1.00096129e-01f, -4.18860018e-02f, 3.65248602e-03f, 2.64539987e-01f, 3.03715430e-02f, -3.66106123e-01f, -1.64332911e-01f, 2.87502562e-03f, 1.09393418e-01f, -3.46725807e-02f,
  2.65130326e-02f, 1.62024319e-01f, -2.68799216e-01f, 1.24219976e-01f, -7.17939287e-02f, -8.87427852e-02f, -5.37373871e-02f, 1.14991667e-03f, 1.10397413e-02f, 1.23609388e-02f,
  6.33848011e-02f, 5.72206490e-02f, 3.30744340e-04f, -2.73197800e-01f, -1.12885073e-01f, -9.75973010e-02f, 2.70261690e-02f, 1.24015436e-01f, -5.81160486e-02f, -6.12880439e-02f,
  -1.61123369e-02f, 5.69271594e-02f, 2.02624142e-01f, 3.34759243e-04f, -1.92493275e-02f, 2.30188519e-01f, 1.84132859e-01f, 2.81452775e-01f, -1.33574577e-02f, 9.31646004e-02f,
  6.56084996e-03f, 2.15978827e-02f, -1.28051355e-01f, -4.77026701e-02f, 2.38432083e-02f, 1.24977268e-01f, -1.42410100e-02f, 2.22449645e-01f, -3.72582898e-02f, 7.70219564e-02f,
  2.89360024e-02f, 8.10134970e-03f, 7.17554763e-02f, 8.39794800e-02f, -6.29967526e-02f, 6.35151044e-02f, -1.34328991e-01f, -1.62938491e-01f, -2.81394362e-01f, -8.96573290e-02f,
  -4.46624577e-01f, 2.32591122e-01f, 3.41482013e-02f, 1.81641113e-02f, 1.14981145e-01f, 1.56123769e-02f, -6.45791069e-02f, 6.22873269e-02f, -3.76380235e-01f, 3.90218338e-03f,
  -6.82890341e-02f, 6.75519034e-02f, 1.10472729e-02f, 1.28534183e-01f, -1.73067510e-01f, 2.40351602e-01f, -1.38282478e-01f, -1.05854616e-01f, -1.15965195e-01f, 5.38330153e-02f,
  -3.83891836e-02f, 1.14878766e-01f, -1.21663049e-01f, 4.75269705e-02f, -2.19236687e-01f, 1.91141531e-01f, 7.71053210e-02f, -1.62155449e-01f, -3.01129501e-02f, 2.75651161e-02f,
  -1.87138021e-01f, -9.89722013e-02f, -3.99079584e-02f, 1.26706854e-01f, -1.95032340e-02f, 7.88136851e-04f, 5.07646315e-02f, -2.37843338e-02f, 2.13171792e-04f, -4.43318114e-02f,
  6.93317354e-02f, 9.66266170e-02f, -1.36641100e-01f, 1.56437624e-02f, -1.06164314e-01f, 6.90333322e-02f, -3.30708325e-02f, 7.78664127e-02f, -2.51321971e-01f, -1.94282811e-02f,
  -1.20242946e-02f, -6.50793314e-02f, -6.60247877e-02f, -1.89361852e-02f, -2.91367713e-02f, 1.22379765e-01f, 1.25118317e-02f, 1.96291342e-01f, -5.87958172e-02f, 1.80409834e-01f,
  1.10505424e-01f, -6.76623061e-02f, 1.42345533e-01f, -1.39235884e-01f, -1.01706155e-01f, 1.04949415e-01f, -4.11149040e-02f, -6.20132871e-03f, -3.39973688e-01f, 1.13048665e-01f,
  -1.03754960e-01f, -1.01430707e-01f, -3.48564424e-02f, 2.75686741e-01f, 9.87001806e-02f, 5.60595579e-02f, -6.73794374e-02f, 1.77301452e-01f, -1.41140252e-01f, 2.47657169e-02f,
  5.43715097e-02f, -1.05370563e-02f, 1.11571491e-01f, -1.40266955e-01f, -4.68720309e-02f, -3.21969628e-01f, -5.42475991e-02f, -1.24208622e-01f, -7.05427155e-02f, 1.45744249e-01f,
  1.23319507e-01f, -4.44502272e-02f, 5.15790060e-02f, 1.02771655e-01f, -1.53554171e-01f, -6.91246763e-02f, 7.04575926e-02f, 1.14410721e-01f, -1.95082314e-02f, -2.10207880e-01f,
  3.76115069e-02f, 2.66080797e-01f, 2.36378133e-01f, 1.52324393e-01f, 7.67719001e-02f, -9.03090686e-02f, 1.18409924e-01f, -7.09433705e-02f, -1.42116398e-01f, 1.49483263e-01f,
  2.03517213e-01f, 2.39942744e-01f, -1.06852457e-01f, -6.41339943e-02f, -1.03242017e-01f, -8.79920423e-02f, 1.41279086e-01f, -2.23159767e-03f, -4.04071249e-02f, -2.18434408e-01f,
  -2.95837559e-02f, -2.25886300e-01f, 1.32782444e-01f, -1.41866162e-01f, 1.33658037e-01f, 1.97081149e-01f, 5.32324128e-02f, -1.17204584e-01f, -1.10920221e-01f, -1.10345230e-01f,
  2.73377627e-01f, -3.37098576e-02f, 3.45989615e-01f, 3.16347256e-02f, 1.82386100e-01f, 2.19210386e-02f, 1.05325542e-01f, -2.06598431e-01f, -3.07150539e-02f, 3.45578417e-02f,
  1.36573926e-01f, -1.29667833e-01f, -1.77831333e-02f, -2.33218744e-01f, -2.32582763e-01f, 1.15926884e-01f, -6.36393279e-02f, 1.60917342e-01f, -2.81500407e-02f, 1.87606171e-01f,
  1.72596663e-01f, 6.64014295e-02f, 3.05166900e-01f, -7.38844946e-02f, -1.32518858e-01f, -1.25225589e-01f, 7.58892819e-02f, -5.30697629e-02f, -8.43036473e-02f, -1.43223986e-01f,
  -6.35157805e-03f, -5.49040064e-02f, 2.13182569e-01f, -1.20743491e-01f, -9.27906707e-02f, -2.24961877e-01f, 1.35530874e-01f, -2.12134793e-01f, -1.72506809e-01f, -1.50623456e-01f,
  2.53711045e-01f, -2.23852396e-01f, 9.38635096e-02f, -5.25833406e-02f, -4.55053486e-02f, 2.32065581e-02f, 7.97667801e-02f, -9.31084342e-03f, -8.30696523e-02f, -8.86240378e-02f,
  -2.68264711e-02f, -2.45425366e-02f, -1.85627490e-01f, -8.37422907e-02f, -2.57272243e-01f, 7.82949850e-03f, -8.67903829e-02f, -2.03788858e-02f, 2.18523636e-01f, 1.20401464e-01f,
  7.50277415e-02f, -1.88588262e-01f, -1.11864299e-01f, 1.93777308e-01f, 1.38340369e-01f, -1.74605802e-01f, -2.93653179e-02f, -1.77090198e-01f, -1.40904337e-01f, -1.71154991e-01f,
  -1.27969265e-01f, 5.78467771e-02f, 1.75833665e-02f, -1.99086536e-02f, 6.11347184e-02f, 4.43397798e-02f, -6.98006302e-02f, -2.18730167e-01f, 1.95919499e-01f, 1.82768777e-02f,
  -2.23084554e-01f, 1.19109102e-01f, -1.55221730e-01f, 1.81690380e-01f, -6.02987967e-02f, 3.04690208e-02f, 8.45306590e-02f, -1.91578910e-01f, 5.57376146e-02f, 1.87286153e-01f,
  -2.79004648e-02f, 2.09387317e-02f, -8.20743814e-02f, 6.43173009e-02f, 1.21813945e-01f, 3.72626558e-02f, -6.08285069e-02f, -3.51806134e-02f, -2.01161783e-02f, -1.73887223e-01f,
  1.47142649e-01f, -1.91586256e-01f, -8.30442235e-02f, 1.39513295e-02f, -1.54700041e-01f, -2.95237154e-01f, -2.71891858e-02f, -1.19687051e-01f, 9.67808962e-02f, -1.55021071e-01f,
  -1.11661926e-01f, 3.30519490e-02f, -1.08214661e-01f, -1.45728558e-01f, -1.54156880e-02f, -4.25753742e-02f, 2.19799280e-02f, 7.64800534e-02f, -2.64475763e-01f, 2.50729118e-02f,
  -1.63545255e-02f, -6.11554570e-02f, 1.64304554e-01f, 7.05321282e-02f, 1.96249798e-01f, 2.62718201e-01f, 2.04985172e-01f, -2.12939814e-01f, 8.81053954e-02f, -2.18775943e-01f,
  -3.40052992e-01f, -6.56386167e-02f, 2.98875403e-02f, -1.32992730e-01f, 9.42318235e-03f, 8.84141624e-02f, -2.31807046e-02f, 9.68637168e-02f, 1.00122243e-01f, -2.81214584e-02f,
  3.58276442e-02f, -4.13279096e-03f, 2.00315207e-01f, 1.34017676e-01f, -1.11910731e-01f, 2.56673574e-01f, -1.73914641e-01f, 2.48790130e-01f, -2.53952034e-02f, -2.19444353e-02f,
  2.68634260e-01f, -7.37526268e-02f, -1.42728746e-01f, 1.71220899e-01f, 1.45052016e-01f, 7.01319203e-02f, 9.73780677e-02f, -3.51008736e-02f, 6.23370633e-02f, -7.84578025e-02f,
  8.31698328e-02f, -1.31315112e-01f, -7.74124190e-02f, -1.10448323e-01f, 1.83370620e-01f, 1.51715335e-03f, -3.50255184e-02f, -8.30481797e-02f, 3.85318220e-01f, -1.99644584e-02f,
  -1.73066482e-01f, 7.63566792e-03f, 8.42640921e-02f, 2.17005797e-02f, 8.92796367e-02f, -1.40250623e-01f, -2.80290488e-02f, 1.27156720e-01f, -3.60019431e-02f, 9.77734476e-02f,
  -4.79287319e-02f, 1.65325105e-01f, -6.05730526e-02f, 1.48998544e-01f, -2.06045419e-01f, 1.44515499e-01f, 3.68498154e-02f, -6.98484406e-02f, -3.02867115e-01f, 2.82805860e-01f,
  -1.57850739e-02f, -1.39704332e-01f, 7.38780666e-03f, 2.14461505e-01f, -1.46094099e-01f, 2.63780188e-02f, 1.70652822e-01f, 7.79632106e-02f, -2.76400685e-01f, 2.31185794e-01f,
  -9.61731374e-02f, -2.59158276e-02f, 5.90698682e-02f, -1.15443729e-01f, -3.37633267e-02f, -1.95286229e-01f, -1.08433135e-01f, -3.72612849e-02f, -1.52216002e-01f, 8.93696323e-02f,
  1.37296602e-01f, 1.11568294e-01f, 9.13665444e-02f, 1.23147100e-01f, 3.69933806e-02f, -8.16238225e-02f, 4.16951030e-02f, 6.19047172e-02f, 2.24224711e-03f, 5.88873168e-03f,
  3.11850687e-03f, -5.34852482e-02f, -6.98566064e-02f, 1.54517546e-01f, 2.35958770e-01f, -1.34751378e-02f
};

// L3_fan_Wp_bar (Shape: 26 x 64)
const int L3_fan_Wp_bar_rows = 26;
const int L3_fan_Wp_bar_cols = 64;
const float L3_fan_Wp_bar_data[] = {
  2.51787186e-01f, 2.59377807e-01f, 1.36789709e-01f, 4.79293056e-02f, 2.81735778e-01f, 4.93897870e-03f, 3.65775168e-01f, 1.63069516e-01f, 3.54648829e-02f, 3.44189525e-01f,
  1.41614780e-01f, 2.09128439e-01f, -1.26331866e-01f, -7.14113121e-05f, 9.37478803e-03f, 3.99043709e-01f, -2.41105445e-02f, -1.52527198e-01f, 6.56165555e-02f, -1.51626393e-01f,
  -8.49561691e-02f, -6.69407099e-02f, -1.96892455e-01f, -4.96765971e-02f, -8.88266414e-02f, 2.41807312e-01f, 3.16702962e-01f, -5.60329974e-01f, -3.15494239e-01f, -2.31298119e-01f,
  2.46430770e-01f, 5.72420880e-02f, 2.22375225e-02f, -1.71982542e-01f, 1.14934765e-01f, -1.08864874e-01f, 3.31838101e-01f, -1.17131323e-01f, -3.13757896e-01f, 1.18235022e-01f,
  -1.48593009e-01f, 1.11017905e-01f, 7.87574500e-02f, 3.14110219e-02f, 4.79238033e-02f, 9.15204957e-02f, 2.16200963e-01f, -2.31511146e-01f, 1.80457965e-01f, 2.63061021e-02f,
  -9.99766588e-02f, 4.80511039e-02f, 9.33132172e-02f, 4.11849655e-02f, 1.37244061e-01f, -2.53740937e-01f, 1.09735295e-01f, 9.83925760e-02f, 1.22080930e-01f, -4.87372018e-02f,
  3.94647032e-01f, -8.11896697e-02f, -1.28498986e-01f, 5.52367866e-02f, -1.59348622e-01f, -1.35124639e-01f, -2.72843331e-01f, -3.63564603e-02f, -4.02915210e-01f, 6.87343404e-02f,
  -2.87289806e-02f, -1.96855545e-01f, 1.65779218e-01f, -1.51998147e-01f, 9.25745144e-02f, -2.59259969e-01f, 1.03925698e-01f, 7.21392930e-02f, -1.82225809e-01f, -1.01075158e-01f,
  -6.43866137e-02f, 1.96751013e-01f, 7.81428739e-02f, -1.50002211e-01f, 4.80401814e-02f, 1.84854921e-02f, 3.10617685e-01f, -1.29233614e-01f, 3.74095678e-01f, -6.33883923e-02f,
  1.64325908e-01f, -2.72064030e-01f, -2.46695057e-01f, 3.17822933e-01f, 5.41283302e-02f, 1.20712142e-03f, 2.33184889e-01f, 4.47447188e-02f, -9.10905190e-03f, -6.76766932e-02f,
  -1.24001019e-01f, -5.04661024e-01f, -3.45080979e-02f, 6.95940629e-02f, 2.82431431e-02f, 2.02363908e-01f, 9.04536322e-02f, 2.19433337e-01f, -1.65067762e-01f, 1.94337964e-01f,
  6.48820177e-02f, -8.98142755e-02f, -2.83162594e-02f, -3.79941240e-02f, 3.08543533e-01f, 1.97288990e-01f, 2.70794928e-01f, 2.68714398e-01f, 2.88911372e-01f, 5.94642870e-02f,
  -1.43219441e-01f, -8.45374390e-02f, 1.06069461e-01f, 9.74689331e-03f, 9.90076661e-02f, -1.50629759e-01f, 1.71961095e-02f, 3.89710516e-01f, 1.07877210e-01f, -1.82138637e-01f,
  8.07954669e-02f, 2.97463313e-02f, 1.66608151e-02f, 8.62340480e-02f, -5.90530001e-02f, -6.70912415e-02f, -6.63171115e-04f, 5.54453246e-02f, 1.80040613e-01f, 5.26055694e-02f,
  3.70927185e-01f, 1.15341000e-01f, 6.34443983e-02f, 4.01816182e-02f, 1.01781301e-02f, 1.77174896e-01f, -1.53388798e-01f, -1.43284306e-01f, -1.63674921e-01f, 9.08515900e-02f,
  1.03673778e-01f, 1.62092865e-01f, 9.76567566e-02f, -1.15549751e-01f, 7.71235973e-02f, 2.98107296e-01f, 3.76566611e-02f, 3.02122056e-01f, -1.08417004e-01f, -9.03781056e-02f,
  -3.47943157e-02f, -1.44998729e-01f, -7.45971501e-02f, -1.22136399e-01f, -2.79690266e-01f, 6.68802485e-02f, 4.54747751e-02f, 2.26217769e-02f, 1.48089930e-01f, 2.50268996e-01f,
  -1.56218652e-02f, 2.60013547e-02f, -1.66291118e-01f, 4.54867259e-02f, -1.00454867e-01f, 1.07486293e-01f, -1.08865146e-02f, 3.14283185e-02f, -1.22749398e-03f, 3.65640149e-02f,
  1.01658441e-01f, 1.71912819e-01f, -1.36630833e-01f, 2.99039297e-02f, -3.90046253e-03f, 1.10634461e-01f, -1.16031095e-01f, -1.35123923e-01f, -4.00839001e-02f, 2.15549573e-01f,
  5.91113092e-03f, 1.05500847e-01f, 1.61708280e-01f, 2.31893420e-01f, 2.25249901e-01f, -2.08691042e-02f, 7.72667974e-02f, 4.14045870e-01f, -1.10533059e-01f, 1.17869355e-01f,
  2.67712057e-01f, 1.74991980e-01f, 2.05091417e-01f, 1.26779571e-01f, 7.98912346e-02f, 1.09251507e-01f, 1.98528484e-01f, -3.54303047e-02f, 1.69008911e-01f, 3.59434038e-01f,
  1.31019205e-01f, 2.41540402e-01f, -2.78918147e-02f, 4.93948236e-02f, 1.86240837e-01f, 2.58549422e-01f, -3.14171463e-01f, -2.13017955e-01f, 5.16322441e-03f, 1.43664002e-01f,
  -1.62247613e-01f, 1.11495867e-01f, -1.28327608e-01f, -5.09578623e-02f, -1.85942098e-01f, 3.47696930e-01f, -4.27006558e-02f, -1.58251867e-01f, -1.63179144e-01f, 2.20287144e-01f,
  -6.16824664e-02f, -5.86415455e-03f, 1.61668465e-01f, 3.11520845e-01f, -2.70709127e-01f, -6.95319995e-02f, -1.70342758e-01f, 5.35031110e-02f, 3.51403467e-02f, 1.54821187e-01f,
  2.69107789e-01f, -1.28959209e-01f, -3.37916724e-02f, -1.05767414e-01f, -1.84495971e-01f, 2.19408154e-01f, 2.94144511e-01f, -3.49177241e-01f, -2.17495542e-02f, 8.51629749e-02f,
  -1.02908075e-01f, -1.55460119e-01f, -1.49735123e-01f, 2.62789845e-01f, 7.40367249e-02f, 1.80412531e-01f, 2.30388895e-01f, -9.38972756e-02f, -3.17443982e-02f, 1.50778338e-01f,
  -8.17647725e-02f, 3.80084157e-01f, 1.32969588e-01f, -9.95823815e-02f, 9.09654051e-02f, 1.10522680e-01f, 1.13497801e-01f, -1.36655733e-01f, 4.26026098e-02f, 2.32270285e-01f,
  3.35452855e-02f, -2.16740802e-01f, 1.36153355e-01f, 4.30826098e-02f, 4.41300049e-02f, -7.04640225e-02f, -5.86505160e-02f, -1.05100013e-01f, 3.40793312e-01f, 2.69142509e-01f,
  1.81140035e-01f, -3.50069813e-02f, -1.45137563e-01f, -1.58673510e-01f, 1.01761423e-01f, 2.09334671e-01f, 7.31043424e-03f, -5.94170205e-02f, 1.99226692e-01f, -1.14744857e-01f,
  1.06152408e-01f, -3.91497433e-01f, 2.20829949e-01f, -1.32662117e-01f, 2.74197519e-01f, -6.63634017e-02f, 1.34874091e-01f, 1.97568581e-01f, -2.87442282e-03f, 9.77956951e-02f,
  -3.44571710e-01f, -5.93010634e-02f, 1.71340212e-01f, -1.72376186e-01f, 9.99091044e-02f, -1.83307827e-01f, 1.87420234e-01f, 2.87337273e-01f, 7.60652646e-02f, 1.16490364e-01f,
  3.08489557e-02f, 5.49752973e-02f, 3.09043974e-02f, -5.21385446e-02f, -1.63201556e-01f, -1.12029968e-03f, 1.79862350e-01f, 2.54042111e-02f, -4.44711335e-02f, 1.29246041e-01f,
  9.89205297e-03f, 1.96315259e-01f, -4.82212305e-02f, -1.01098463e-01f, -1.59069896e-02f, -2.99778372e-01f, 3.26284468e-02f, 4.61452603e-02f, 3.34468409e-02f, -7.24041229e-03f,
  -3.41248102e-02f, 1.29950330e-01f, 5.01699001e-03f, -3.15688670e-01f, -4.76894062e-03f, 2.00095519e-01f, -2.27353275e-01f, -3.09182823e-01f, 2.47211188e-01f, -6.42432570e-02f,
  1.66890055e-01f, -1.48696184e-01f, -2.59189814e-01f, -3.57216209e-01f, -1.72560066e-01f, 3.97493690e-02f, -1.20907743e-02f, -4.72304877e-03f, -7.86682777e-03f, -3.65994334e-01f,
  2.22032383e-01f, -1.85153410e-01f, -2.46042968e-03f, 1.54286057e-01f, -1.10018522e-01f, 4.11228329e-01f, 3.96343134e-03f, 8.21350738e-02f, -1.10256121e-01f, 2.11995557e-01f,
  9.04878005e-02f, -2.52805889e-01f, 5.09171598e-02f, 1.35821611e-01f, -3.89875889e-01f, 1.96365774e-01f, 2.29158744e-01f, -5.35079874e-02f, -2.13729534e-02f, 2.51095295e-01f,
  2.01938108e-01f, -1.25386208e-01f, -9.00028367e-03f, -2.63007104e-01f, -1.04931951e-01f, -1.64849982e-01f, 1.80510849e-01f, 9.42605287e-02f, 2.44136482e-01f, 1.30158812e-01f,
  1.15161955e-01f, -1.80040330e-01f, 2.07568586e-01f, -5.88194802e-02f, 2.35800520e-01f, 2.77082533e-01f, -2.28078086e-02f, 1.82289600e-01f, 1.71092853e-01f, 6.71916679e-02f,
  1.93522945e-01f, 1.95458904e-01f, 9.12041739e-02f, 1.33145541e-01f, -1.13673441e-01f, 1.57806009e-01f, -1.33121222e-01f, -1.95990503e-01f, 4.97020520e-02f, 1.33766159e-01f,
  -1.46973029e-01f, -2.11046576e-01f, 2.32955217e-01f, 1.46957636e-01f, 8.21297243e-02f, -1.71248212e-01f, -2.92917937e-01f, -2.80156255e-01f, -1.37558267e-01f, -2.21101288e-02f,
  1.57603800e-01f, -3.42625648e-01f, -1.28136471e-01f, -4.71916735e-01f, 2.83073634e-01f, 7.88671151e-03f, 2.72340178e-01f, 1.20644040e-01f, 1.76568747e-01f, 1.83449298e-01f,
  1.65614650e-01f, 1.54075056e-01f, -1.38312623e-01f, 7.32380077e-02f, -8.16439688e-02f, -3.31802964e-02f, 1.14107326e-01f, -1.34724006e-01f, -3.73737037e-01f, 1.74226806e-01f,
  3.11089844e-01f, 4.29608263e-02f, 2.06114575e-01f, 1.53674766e-01f, 2.27720007e-01f, -2.92170271e-02f, 3.27141918e-02f, 2.42414586e-02f, 1.88867271e-01f, -2.35068411e-01f,
  1.11426279e-01f, 1.22294575e-02f, 1.78491279e-01f, 1.44577712e-01f, 9.96850431e-02f, -8.03484116e-03f, 1.56922117e-01f, -1.71570212e-01f, -9.97186005e-02f, 2.04702660e-01f,
  -3.11890453e-01f, 1.07546091e-01f, 2.15612039e-01f, -3.00832421e-01f, -1.26987815e-01f, 1.58474609e-01f, 1.03776850e-01f, 8.83762687e-02f, -1.95609257e-01f, 7.23126754e-02f,
  1.11339547e-01f, 2.90351994e-02f, 2.97576100e-01f, -8.43513533e-02f, -1.50965480e-03f, -1.22168036e-02f, 9.04891938e-02f, -1.29917920e-01f, 4.33813870e-01f, -3.75344604e-01f,
  1.56072741e-02f, -4.11987990e-01f, -1.07648864e-01f, -1.85439587e-01f, -3.46767902e-02f, 2.03638464e-01f, 2.40426585e-01f, 1.50682971e-01f, -1.53571233e-01f, 1.11185089e-02f,
  3.05786073e-01f, -3.50195169e-03f, -2.37786956e-02f, 2.75330454e-01f, 3.07889888e-03f, -3.54991108e-01f, -2.13319659e-01f, 1.41489699e-01f, -1.04524568e-02f, 1.23718359e-01f,
  1.69855163e-01f, -2.73807831e-02f, -1.37148559e-01f, 4.10598144e-02f, 1.14606611e-01f, -1.43403307e-01f, 1.87408611e-01f, -9.58622545e-02f, 1.09842792e-01f, -8.88166800e-02f,
  -5.14874458e-02f, 1.23017319e-01f, 1.72410943e-02f, -2.88725495e-01f, -1.42163932e-01f, -1.03261201e-02f, 1.59644619e-01f, 1.68448180e-01f, -6.97871670e-02f, -7.99135342e-02f,
  -3.54944393e-02f, 2.97024697e-01f, -2.29320198e-01f, -3.18001986e-01f, 2.22853180e-02f, -5.07823862e-02f, -2.63195723e-01f, 5.38267940e-02f, 2.19542091e-03f, -1.98287129e-01f,
  -2.10432649e-01f, -3.19102466e-01f, -1.10526726e-01f, -1.01954989e-01f, 1.59515720e-02f, 2.65166104e-01f, -2.43607506e-01f, -1.68487981e-01f, -1.09506488e-01f, -1.63820744e-01f,
  3.66908796e-02f, -3.44071612e-02f, -3.39660227e-01f, -1.56049699e-01f, 3.14752728e-01f, 1.14396952e-01f, 7.04184100e-02f, 7.65972286e-02f, 5.57419658e-03f, 1.68042444e-02f,
  5.04864872e-01f, -9.05904621e-02f, -1.26110196e-01f, -1.38190046e-01f, -8.78642872e-02f, -1.24281198e-01f, 1.75868005e-01f, -1.38338104e-01f, 3.33705842e-01f, 1.59991577e-01f,
  5.93747437e-01f, 5.71343005e-02f, 1.15009718e-01f, -4.36225235e-02f, 2.64776736e-01f, 5.25012314e-01f, 2.21902445e-01f, 8.27159062e-02f, 4.12650593e-02f, 1.04544222e-01f,
  -1.25504315e-01f, 6.27564266e-02f, 5.49175180e-02f, -9.39707011e-02f, 2.13392191e-02f, -8.35771784e-02f, -2.32912824e-01f, 1.67179421e-01f, -4.33968492e-02f, -1.38881877e-02f,
  1.15490690e-01f, 2.90864259e-01f, 1.30438590e-02f, -5.39590828e-02f, 1.31330386e-01f, 2.51372308e-02f, -1.07989825e-01f, -9.88753960e-02f, -9.58285630e-02f, 1.87416956e-01f,
  -7.63230473e-02f, -6.52749324e-03f, -1.39455259e-01f, 8.95388126e-02f, -5.80492765e-02f, 1.13728344e-01f, 1.85359642e-01f, -4.86712128e-01f, 3.24422158e-02f, 1.64942101e-01f,
  2.68214513e-02f, 3.09414685e-01f, -3.05950195e-02f, -5.88971563e-02f, 1.68472193e-02f, -2.26395845e-01f, -5.20526096e-02f, -7.35623091e-02f, -2.28573516e-01f, -1.18612140e-01f,
  1.70412034e-01f, 6.05597198e-02f, -1.12015950e-02f, -5.39570004e-02f, -2.52182335e-01f, -1.57424912e-01f, 7.50820637e-02f, -4.48575675e-01f, -1.66234836e-01f, -3.44135612e-01f,
  -4.69535738e-02f, -1.48677304e-01f, -2.23537415e-01f, -8.11836645e-02f, -7.05285519e-02f, 1.29695892e-01f, -3.88368480e-02f, 1.12488292e-01f, 4.18372527e-02f, 6.72064781e-01f,
  -3.70899051e-01f, 1.24379396e-01f, 5.55566400e-02f, 1.32902980e-01f, -7.78744593e-02f, 4.52968292e-02f, 1.72697827e-01f, 8.90869424e-02f, 1.43105283e-01f, 1.69536695e-02f,
  -2.79804379e-01f, 5.31076640e-02f, 1.57330871e-01f, 1.33011624e-01f, 1.02056675e-01f, 7.69663602e-02f, 2.10720614e-01f, 2.38425300e-01f, -3.57481427e-02f, 2.24341661e-01f,
  2.76579916e-01f, 6.78144023e-02f, 8.88606384e-02f, 1.70278683e-01f, 1.63305625e-01f, 8.03673342e-02f, 6.58574760e-01f, 8.58127102e-02f, 1.09531013e-02f, -5.54330982e-02f,
  1.52331039e-01f, 1.82917640e-01f, -2.59595960e-01f, -1.45127093e-02f, -1.13277018e-01f, 3.76836769e-02f, -4.07951102e-02f, -1.18846759e-01f, 1.64747424e-02f, 9.28190723e-02f,
  -1.02758624e-01f, -4.20463085e-02f, 1.54065967e-01f, 1.48482457e-01f, 5.67314327e-02f, 1.85507923e-01f, -3.51534691e-03f, -2.85264879e-01f, -3.97775834e-03f, -1.53043717e-01f,
  4.04835135e-01f, 4.09046620e-01f, 2.08527878e-01f, 9.17999446e-02f, 1.40894338e-01f, -1.33372389e-03f, 2.73698509e-01f, 5.55067435e-02f, -1.49869025e-02f, 2.05209982e-02f,
  2.25982703e-02f, 1.29200131e-01f, 5.31650446e-02f, -4.32083488e-01f, -4.00828421e-01f, 9.24318731e-02f, 2.00194404e-01f, -7.70763680e-02f, 1.87911928e-01f, -1.38014689e-01f,
  1.62427232e-01f, 2.97119170e-01f, 9.48017612e-02f, 5.96195236e-02f, 2.41245747e-01f, 2.03854144e-01f, 1.91381112e-01f, -7.23142326e-02f, -1.02604767e-02f, -5.07730767e-02f,
  3.51856530e-01f, -1.50497654e-03f, 2.07440570e-01f, 5.49125634e-02f, -1.10799067e-01f, 1.20408379e-01f, 1.21244475e-01f, 1.78433329e-01f, 2.80683279e-01f, 1.45955667e-01f,
  -1.53587908e-01f, -4.59327661e-02f, -7.88805783e-02f, -6.12447876e-03f, 1.17726870e-01f, 1.87338933e-01f, 1.53475210e-01f, 2.89095849e-01f, 1.59969985e-01f, 1.08916268e-01f,
  9.43674296e-02f, 2.26191744e-01f, 2.42980331e-01f, -4.72897179e-02f, -9.83744394e-04f, 1.66713566e-01f, -9.58812982e-02f, 3.65637392e-01f, -2.01011136e-01f, -1.47155479e-01f,
  -2.57967204e-01f, 3.35749894e-01f, -2.79993534e-01f, 2.32712477e-01f, -1.58108100e-01f, -1.82070330e-01f, -1.00901991e-01f, 1.26388028e-01f, 1.65619291e-02f, -1.41646788e-01f,
  -2.80305833e-01f, 2.15741731e-02f, 2.09117323e-01f, 6.63607009e-03f, 1.20719083e-01f, 1.07146919e-01f, -1.38718739e-01f, 1.05867609e-01f, 9.20640230e-01f, 9.08417329e-02f,
  6.94991127e-02f, 2.96209604e-01f, 1.66705102e-01f, -1.91453360e-02f, -2.17145875e-01f, -8.24557617e-02f, -8.63279030e-02f, 2.46275470e-01f, 3.97098660e-01f, 1.53674424e-01f,
  1.89640567e-01f, 1.25451321e-02f, -5.38162305e-04f, -3.90036963e-02f, -1.49171188e-01f, 3.64462107e-01f, -4.91631962e-02f, -9.20249820e-02f, -1.40791640e-01f, -2.22724333e-01f,
  -1.94334257e-02f, 9.18534771e-02f, -2.68146276e-01f, 1.60220295e-01f, 1.25821114e-01f, -1.25911608e-01f, -1.34572282e-01f, -2.96609104e-01f, -4.35386859e-02f, -2.38535047e-01f,
  -1.48218036e-01f, 1.89540461e-01f, -1.65902317e-01f, -2.13016331e-01f, 4.66117971e-02f, -2.64806658e-01f, 1.82308063e-01f, 1.58201382e-01f, -3.52963209e-01f, -2.73651570e-01f,
  4.01791304e-01f, 8.56992379e-02f, -3.63631770e-02f, 1.87434912e-01f, -1.36568844e-01f, -1.20685562e-01f, 4.44924116e-01f, -1.51864976e-01f, 3.30858901e-02f, 4.63862792e-02f,
  1.64542764e-01f, -1.01933945e-02f, 1.14347152e-01f, -1.59729093e-01f, 4.43654895e-01f, -1.01154312e-01f, 5.79760849e-01f, -4.46052616e-03f, 8.86174366e-02f, -5.86526934e-03f,
  3.34359735e-01f, 1.83885977e-01f, -5.88924438e-03f, -6.91331737e-03f, 6.54069856e-02f, -1.43232390e-01f, 5.87982833e-02f, -4.39931266e-03f, 1.04474053e-01f, 1.39298260e-01f,
  3.98694053e-02f, 6.94593191e-02f, 2.74325646e-02f, 2.06588671e-01f, -6.40793815e-02f, -9.59922075e-02f, 2.68476278e-01f, 2.60341614e-01f, 1.78622246e-01f, -4.67909090e-02f,
  2.07038835e-01f, 2.11576611e-01f, 3.30848813e-01f, -2.27928087e-01f, 2.18459949e-01f, 4.47017968e-01f, 6.63736984e-02f, 3.15430701e-01f, -1.17897138e-01f, 3.18595648e-01f,
  -3.32133919e-01f, 1.15843624e-01f, -3.72904330e-03f, -2.82324106e-01f, -3.16850305e-01f, 1.76678270e-01f, -4.83595245e-02f, 2.20935613e-01f, -1.48897946e-01f, -4.62729894e-02f,
  -2.45413452e-01f, 3.21097076e-01f, -1.31642940e-02f, 7.61159137e-02f, -4.34460282e-01f, 1.67966094e-02f, 1.23081831e-02f, 5.16357124e-02f, -1.42071173e-01f, 1.30576998e-01f,
  -1.44537762e-01f, -2.09987357e-01f, 2.60642054e-03f, -2.50100017e-01f, -1.41445950e-01f, -1.71785399e-01f, 3.43627363e-01f, -2.34549031e-01f, -1.43028215e-01f, 3.91823798e-01f,
  -2.98783686e-02f, 7.85695985e-02f, 4.50798012e-02f, 2.56819934e-01f, 6.02223277e-02f, 5.98611653e-01f, -3.90121579e-01f, -1.32450759e-01f, -3.11550088e-02f, 4.12681177e-02f,
  5.26431203e-02f, -1.69489786e-01f, 5.19743897e-02f, -4.05088719e-03f, -7.54320398e-02f, 1.65197551e-02f, -2.01422736e-01f, 9.91688669e-02f, 1.65482908e-01f, 3.34121473e-02f,
  4.46571261e-02f, 6.62407503e-02f, -5.06360307e-02f, 2.08079889e-01f, 1.38510615e-02f, -7.84989521e-02f, 1.74690232e-01f, -1.92135900e-01f, 3.12003344e-01f, 3.02193314e-01f,
  1.82212234e-01f, 1.98512033e-01f, 3.16147774e-01f, 8.67921039e-02f, -7.12134466e-02f, -3.83774154e-02f, 1.43942550e-01f, 3.26755792e-01f, 4.04681228e-02f, 2.29884133e-01f,
  -6.96951663e-03f, 1.11829992e-02f, 1.04930021e-01f, 1.85486853e-01f, -7.23327696e-03f, 1.94206417e-01f, -7.95010924e-02f, 1.87720746e-01f, -7.75816990e-03f, 5.38061202e-01f,
  1.06675893e-01f, -1.00615464e-01f, -3.06867659e-01f, 3.02831769e-01f, -1.09881505e-01f, 1.22576259e-01f, 1.17495753e-01f, 1.85963675e-01f, 9.24565718e-02f, -3.77146080e-02f,
  7.58134276e-02f, -2.00943634e-01f, 3.07636969e-02f, 3.49052846e-01f, 2.02896848e-01f, 1.43409781e-02f, -7.48178130e-03f, 1.52223378e-01f, 1.10697560e-01f, -3.67481023e-01f,
  2.09390208e-01f, 1.19056314e-01f, -6.45803288e-02f, 2.05797795e-02f, 6.42694086e-02f, -1.02671340e-01f, -4.92693763e-03f, 2.71277666e-01f, 1.44981220e-01f, 8.79613161e-02f,
  1.91432059e-01f, 4.95715410e-01f, 2.04338878e-01f, -1.63139552e-01f, 1.18314505e-01f, -1.05727702e-01f, -9.79564637e-02f, 3.64140928e-01f, 2.03166530e-01f, -1.53991550e-01f,
  -2.13728040e-01f, 1.16323173e-01f, 5.01246303e-02f, 1.61579907e-01f, 2.33497858e-01f, 1.28471613e-01f, -1.75750583e-01f, 5.13040423e-01f, -8.37456435e-03f, 8.97280127e-02f,
  -2.65050173e-01f, 9.33790356e-02f, 8.82475972e-02f, 1.49751171e-01f, 4.50354576e-01f, -1.66359022e-01f, 1.65377229e-01f, -8.31662938e-02f, 2.82349046e-02f, 3.52513701e-01f,
  -5.26744761e-02f, -2.23872513e-02f, -5.60499988e-02f, 1.01829723e-01f, -2.30078697e-01f, -5.54069817e-01f, -2.73414731e-01f, 5.66192329e-01f, 5.00634134e-01f, -5.23233294e-01f,
  -4.67830360e-01f, 3.02759677e-01f, -1.17030539e-01f, -3.52923162e-02f, 3.38973075e-01f, 9.43291709e-02f, 3.31288368e-01f, 4.82907981e-01f, 7.72667378e-02f, 1.37182012e-01f,
  -3.91576514e-02f, 1.34813756e-01f, 7.56187066e-02f, 2.18431801e-01f, 1.34875998e-01f, -1.07330970e-01f, 1.54970437e-01f, -1.63864531e-02f, 2.77509898e-01f, -9.36863869e-02f,
  -4.29935229e-04f, 1.39569771e-02f, -3.87046844e-01f, 2.03126952e-01f, -8.43745321e-02f, -1.21861380e-02f, -1.70176089e-01f, 4.53147255e-02f, 1.89152807e-01f, 1.47752896e-01f,
  -2.68123746e-01f, 1.43611223e-01f, 6.56705126e-02f, 2.09339380e-01f, 3.03939879e-01f, -1.96678847e-01f, -2.72010475e-01f, -1.09360315e-01f, -1.36127263e-01f, -8.80199671e-02f,
  1.84847325e-01f, -5.90113476e-02f, -8.53019357e-02f, -1.05399795e-01f, 1.12121310e-02f, -2.76892245e-01f, 7.87734240e-02f, 4.78545837e-02f, -2.20651671e-01f, 2.85623312e-01f,
  -3.17366630e-01f, -3.18466723e-02f, -4.29471582e-02f, -9.37103778e-02f, 2.10964605e-01f, 1.30287319e-01f, -4.49100196e-01f, -1.52049243e-01f, -6.25395179e-02f, -8.04726481e-02f,
  -3.19380790e-01f, -1.94562837e-01f, -1.26602888e-01f, 1.38046637e-01f, 4.92951661e-01f, 1.43684432e-01f, -3.14018011e-01f, -3.48264992e-01f, -3.14264774e-01f, 7.77798668e-02f,
  -4.03228670e-01f, 6.09868914e-02f, 7.48020969e-03f, 1.32031798e-01f, -1.52662322e-01f, 2.25386649e-01f, 1.93438113e-01f, -1.06474012e-01f, -9.23582762e-02f, 7.83509240e-02f,
  -1.53737783e-01f, -7.63722286e-02f, 8.90037566e-02f, 4.11198027e-02f, 6.38383906e-03f, 2.66244948e-01f, 1.66410565e-01f, -3.41573179e-01f, -2.73183078e-01f, 2.01720595e-01f,
  -1.15338131e-03f, 1.17334239e-02f, -3.93938199e-02f, 1.61634505e-01f, 1.53070375e-01f, 3.04530174e-01f, 2.49709580e-02f, -4.75644022e-02f, 2.52394527e-01f, 2.57376879e-01f,
  2.01168671e-01f, 1.64346187e-03f, 2.06194058e-01f, 9.75183994e-02f, 2.64188021e-01f, 9.67942625e-02f, 1.49735406e-01f, 2.22599924e-01f, 1.16662323e-01f, 9.85180587e-02f,
  4.51501571e-02f, -2.21571419e-02f, 9.17344391e-02f, 1.68412507e-01f, -1.75369218e-01f, 1.88828051e-01f, 2.90698320e-01f, -1.30529672e-01f, 2.14149486e-02f, 2.90119965e-02f,
  -6.77717254e-02f, -1.44322336e-01f, -1.36645883e-01f, 5.71068265e-02f, 1.17350951e-01f, -5.30844927e-01f, -2.51927882e-01f, 1.18047316e-02f, 2.27462232e-01f, 2.25606799e-01f,
  -1.20534934e-01f, -1.38650283e-01f, -1.15410358e-01f, -1.11704491e-01f, 1.50202036e-01f, -1.04469182e-02f, -9.57698524e-02f, 1.22059584e-02f, -2.26148352e-01f, -2.97746737e-04f,
  -1.68150276e-01f, -1.37251541e-01f, 1.31803691e-01f, 7.22954944e-02f, 2.19162598e-01f, -1.42502844e-01f, -1.84804271e-03f, 1.29348449e-02f, 2.30665412e-02f, 1.45038649e-01f,
  -6.41236827e-02f, 1.88341439e-01f, 2.32637912e-01f, -2.95433313e-01f, 2.35650301e-01f, 9.54975411e-02f, -2.31431752e-01f, -1.49400219e-01f, 3.33575934e-01f, 2.11877842e-02f,
  -1.63487360e-01f, -1.68639198e-02f, 1.05732523e-01f, 3.81955147e-01f, -1.81674302e-01f, 4.69259024e-02f, 2.58721471e-01f, 2.12961093e-01f, -3.26928407e-01f, 1.51551470e-01f,
  9.17775109e-02f, 2.17321232e-01f, -7.18305483e-02f, -3.39845717e-02f, 1.45487711e-01f, 1.97214171e-01f, 2.22016409e-01f, -4.60811704e-02f, 9.36758146e-03f, 9.56188366e-02f,
  1.76910183e-03f, -2.06860811e-01f, 1.36393964e-01f, -1.22972943e-01f, -1.38224512e-01f, -1.49922147e-01f, -2.18390167e-01f, -8.15486014e-02f, 8.64892676e-02f, -1.64898261e-01f,
  2.85835899e-02f, 2.15242594e-01f, -2.95217395e-01f, 5.56654036e-02f, 1.85873628e-01f, 5.36454767e-02f, 1.45230412e-01f, -1.01172782e-01f, -1.01016294e-02f, -3.07052046e-01f,
  1.63169876e-02f, 2.21379519e-01f, 3.62247415e-02f, 3.76223356e-01f, 4.44057807e-02f, 4.57604885e-01f, 1.10243313e-01f, 4.90073897e-02f, 1.15920790e-01f, -2.89975941e-01f,
  1.32946923e-01f, -2.08538368e-01f, -9.80529469e-03f, -1.66555077e-01f, -1.98660970e-01f, 3.37211579e-01f, 2.14629248e-01f, -1.96020737e-01f, -2.30309013e-02f, 1.43160567e-01f,
  1.30141437e-01f, 1.60556868e-01f, 2.13024154e-01f, 1.11897014e-01f, -1.99827552e-01f, 2.53075987e-01f, -1.34121001e-01f, -3.72185171e-01f, -5.75761497e-02f, -1.01711839e-01f,
  2.73346100e-02f, -2.42698282e-01f, 8.53663534e-02f, -2.39966199e-01f, -3.04129999e-02f, 2.49415990e-02f, 2.82699674e-01f, 3.19450647e-02f, 1.72213957e-01f, 1.92184553e-01f,
  3.05603761e-02f, 1.44776329e-01f, -3.95323820e-02f, 5.02479561e-02f, 4.89403754e-02f, -4.76580024e-01f, 1.16055114e-02f, 4.60312143e-02f, -7.87405670e-02f, -7.23114833e-02f,
  3.06027591e-01f, -1.98851689e-03f, -1.00201480e-02f, -1.17321452e-02f, -2.20107540e-01f, 2.71360457e-01f, 2.46653035e-01f, -1.74450263e-01f, -1.09835483e-01f, -3.09087485e-01f,
  -1.81997970e-01f, -2.06892744e-01f, -3.17649007e-01f, -2.14311168e-01f, -8.99441354e-03f, 6.55041933e-02f, 4.79375795e-02f, 1.50499612e-01f, -9.44134369e-02f, -2.02273577e-02f,
  4.26146626e-01f, 8.55001584e-02f, -2.10509196e-01f, 3.01969260e-01f, -4.43236023e-01f, 1.53642192e-01f, 1.99141148e-02f, 2.69411623e-01f, 2.99205959e-01f, -1.12638213e-01f,
  -3.63422394e-01f, 2.48156041e-01f, 1.23372592e-01f, 4.90592718e-02f, -5.73039874e-02f, -1.37319013e-01f, 2.99174994e-01f, 2.75858164e-01f, -1.03178054e-01f, 1.43742830e-01f,
  -1.30711734e-01f, 1.27153307e-01f, 2.27940366e-01f, 7.93276504e-02f, -7.08844960e-02f, -1.97081700e-01f, 1.10383600e-01f, 1.58859361e-02f, 2.78027952e-01f, 1.35708064e-01f,
  1.16405815e-01f, -4.72931042e-02f, -1.36549070e-01f, 1.49345219e-01f, -1.20425008e-01f, 1.47981212e-01f, 1.21694163e-03f, -1.66021913e-01f, 1.83307558e-01f, -5.57893395e-01f,
  -1.73437566e-01f, -2.64956832e-01f, 1.06528848e-02f, 9.71791800e-04f, 2.66910881e-01f, 1.30967021e-01f, 3.86560827e-01f, -3.68297845e-01f, -1.90845549e-01f, -7.38026649e-02f,
  2.53265291e-01f, -1.82399414e-02f, 2.18432888e-01f, -2.74490535e-01f, 2.13268325e-01f, -4.88271445e-01f, 1.62412986e-01f, -4.00822043e-01f, 8.57370421e-02f, 1.00106113e-01f,
  1.50052048e-02f, 2.09008008e-01f, -5.62693253e-02f, -1.09234288e-01f, -1.05186207e-02f, 8.22035745e-02f, 6.76545575e-02f, 1.16928875e-01f, -1.99914187e-01f, 1.87219549e-02f,
  6.49910942e-02f, 9.77007374e-02f, 1.44334599e-01f, 1.28035158e-01f, -1.05075687e-01f, 1.18526712e-01f, 2.34695971e-01f, 1.44869275e-02f, -1.64429590e-01f, -1.76949874e-01f,
  5.47716081e-01f, 2.56889081e-03f, -1.56093359e-01f, 2.17288986e-01f, 1.08169392e-02f, 8.13771933e-02f, -1.19135082e-01f, 2.88687736e-01f, 1.45143852e-01f, -1.33972359e-03f,
  7.86497593e-02f, 7.94220418e-02f, -7.59478733e-02f, -1.26758158e-01f, -1.34193614e-01f, -8.32241669e-04f, -2.38157380e-02f, 2.12539919e-02f, 1.85288131e-01f, -9.83203277e-02f,
  -1.90844327e-01f, -1.64908051e-01f, -3.63448113e-02f, 2.14785069e-01f, 3.13533217e-01f, -2.94541717e-01f, -3.09053421e-01f, -3.35482955e-01f, 6.57484978e-02f, -3.36706787e-01f,
  -3.22397619e-01f, 8.27474222e-02f, 2.76769042e-01f, -1.03650369e-01f, 2.01298356e-01f, 4.65469778e-01f, 2.48961642e-01f, 3.73146161e-02f, 1.95692644e-01f, 1.56634152e-01f,
  1.63639441e-01f, 8.96212682e-02f, -1.55307651e-01f, 6.92276051e-04f, -2.30515897e-01f, 1.18565693e-01f, 3.05189848e-01f, -4.97997165e-01f, -5.96034765e-01f, -1.91755667e-01f,
  1.10335294e-02f, -2.73414463e-01f, 2.80681342e-01f, -2.85256982e-01f, 2.32917204e-01f, 2.21733768e-02f, -1.72657743e-01f, -7.44341314e-02f, -2.35072188e-02f, -9.30780992e-02f,
  -2.74084687e-01f, -8.45557153e-02f, 2.77197421e-01f, 2.87891388e-01f, -1.28841877e-01f, 1.10156842e-01f, 1.36821717e-01f, 2.81475514e-01f, 3.18420231e-01f, 6.24475852e-02f,
  3.25626671e-01f, 1.02872625e-01f, 2.95746297e-01f, -2.03306973e-02f, 1.89116240e-01f, 2.47744590e-01f, 3.57124507e-02f, 2.38394905e-02f, 1.27884090e-01f, 4.58538055e-01f,
  1.03666775e-01f, 9.29627344e-02f, 6.09180406e-02f, -7.42343590e-02f, 2.99063742e-01f, 1.39193656e-02f, -1.95764124e-01f, 2.14997649e-01f, -2.18754187e-01f, 1.65087938e-01f,
  5.29254712e-02f, 4.80154932e-01f, -7.15395659e-02f, -1.29673034e-01f, -1.54776543e-01f, 4.06669676e-01f, 2.78312624e-01f, -8.49925503e-02f, -7.33245816e-03f, 3.67074817e-01f,
  2.46906150e-02f, 1.58561796e-01f, 3.31511974e-01f, -9.78568420e-02f, 1.83890954e-01f, 2.24018216e-01f, -9.95314792e-02f, -5.48642641e-03f, 1.95942894e-01f, 1.61501825e-01f,
  -6.20122775e-02f, -3.77778500e-01f, 1.26315668e-01f, -7.26726428e-02f, -8.79882276e-02f, 7.78417066e-02f, 2.39983976e-01f, 2.66314484e-02f, -2.41468996e-02f, 2.79519349e-01f,
  -9.32796821e-02f, 1.15082666e-01f, 2.04176724e-01f, 1.13130927e-01f, -3.61727290e-02f, -4.94012870e-02f, 8.52527469e-02f, 4.49651815e-02f, -1.61594614e-01f, 2.28935272e-01f,
  1.92436829e-01f, 3.39664519e-02f, 5.34544978e-03f, -2.27240860e-01f, -1.92354023e-01f, -1.87882319e-01f, -1.50181264e-01f, 2.37040952e-01f, 1.15823872e-01f, -2.44527906e-01f,
  1.62515715e-01f, -1.70840845e-01f, 6.97370842e-02f, -1.37914017e-01f, 2.90357947e-01f, 1.49562150e-01f, -6.93480074e-02f, -2.01266542e-01f, -6.11898527e-02f, 3.45704377e-01f,
  4.72045168e-02f, -2.43322209e-01f, -1.48855254e-01f, 3.28023569e-03f, 4.34607327e-01f, 1.52672514e-01f, 7.00441599e-02f, 7.53314272e-02f, 6.01810850e-02f, -3.35638136e-01f,
  -4.24554832e-02f, 3.28520477e-01f, 5.80016188e-02f, 1.49960618e-03f, 4.34443764e-02f, -2.27433935e-01f, -2.89374441e-01f, -1.51655987e-01f, -1.12054773e-01f, -3.73526394e-01f,
  5.63061237e-02f, 1.03471860e-01f, -3.76152247e-02f, 2.39689261e-01f, -4.20455262e-02f, -7.02048000e-03f, -1.50575995e-01f, 1.99899942e-01f, 1.17527895e-01f, -1.80661350e-01f,
  -1.38513846e-02f, 7.98451379e-02f, 1.99474111e-01f, 2.12688431e-01f, 6.86816201e-02f, 2.17216119e-01f, 2.38070026e-01f, 9.97053683e-02f, 3.97461429e-02f, 6.13935245e-03f,
  -4.62159514e-02f, 3.85390259e-02f, 1.68392211e-01f, -2.01262105e-02f, -7.38334879e-02f, 3.36576700e-01f, 2.87061125e-01f, 1.37684643e-01f, 1.18120154e-02f, 3.75457443e-02f,
  -1.21332191e-01f, 2.34745219e-01f, 3.86778079e-02f, 1.40516445e-01f, 2.99917787e-01f, 2.72389203e-01f, 9.13744867e-02f, 1.62190095e-01f, -1.56408235e-01f, 3.85691375e-02f,
  1.12713769e-01f, 2.51871794e-01f, 5.39833307e-02f, -1.17291570e-01f, 2.55387545e-01f, -3.94637920e-02f, -2.49311894e-01f, 1.12431437e-01f, -1.27421722e-01f, 6.22981414e-02f,
  -1.60244793e-01f, 1.43497199e-01f, 3.00965488e-01f, -1.91141397e-01f, -7.49807656e-02f, -1.40215561e-01f, 1.45381510e-01f, 5.74405789e-02f, -2.41294742e-01f, 8.50690603e-02f,
  8.65076110e-02f, -3.88297349e-01f, 3.30691300e-02f, 1.20888725e-01f, 1.24441564e-01f, 3.45044583e-02f, 5.51857753e-03f, 8.49070847e-02f, -1.08047621e-02f, 3.51662524e-02f,
  2.83640493e-02f, -1.81574691e-02f, 3.25790703e-01f, -1.51894704e-01f, -7.64599517e-02f, 1.04189046e-01f, -1.75789714e-01f, 1.25355512e-01f, -2.48725750e-02f, 1.10847116e-01f,
  1.66615054e-01f, -3.72031987e-01f, 4.08311516e-01f, 1.53264448e-01f, -1.68909475e-01f, -1.80798963e-01f, 4.69854861e-01f, 7.58919716e-02f, 7.56995976e-02f, -1.05753250e-01f,
  -1.77387908e-01f, -1.18217401e-01f, -1.10558987e-01f, -4.91763279e-02f, 4.83375676e-02f, -5.35894334e-02f, -9.49885137e-03f, -1.08460382e-01f, -6.86711967e-02f, 1.11343106e-02f,
  -2.72108018e-01f, 4.72154804e-02f, 1.10938452e-01f, 3.95882577e-02f, 5.57202622e-02f, -2.74735361e-01f, 2.10928008e-01f, -1.32224008e-01f, 1.33899331e-01f, 9.54788253e-02f,
  -3.02803703e-02f, -2.95029432e-01f, 3.19804043e-01f, -1.29065350e-01f, -2.51167834e-01f, -8.27531144e-02f, -7.43873324e-03f, 8.62366408e-02f, 3.28832626e-01f, 4.30062860e-02f,
  -4.87567149e-02f, -3.17347725e-03f, 1.19705230e-01f, 4.15040627e-02f, 1.38005614e-01f, 6.70479685e-02f, 1.72936901e-01f, -2.41249874e-01f, 2.96665072e-01f, 1.29770231e-03f,
  2.28291929e-01f, 3.94237861e-02f, 3.64814222e-01f, -1.17473930e-01f, 6.25814855e-01f, -5.11302426e-02f, 1.32879298e-02f, -1.07698189e-02f, 9.73865949e-03f, 7.47352242e-02f,
  1.39423400e-01f, 8.61680359e-02f, -3.92018408e-02f, 1.11554496e-01f, 8.39303881e-02f, 1.21935457e-02f, -1.98501781e-01f, -8.44602510e-02f, 1.13251619e-01f, 2.67202705e-01f,
  1.17011234e-01f, -1.67211935e-01f, 1.42789736e-01f, 1.89352348e-01f
};

// L3_fan_Bp_bar (Shape: 1 x 26)
const int L3_fan_Bp_bar_rows = 1;
const int L3_fan_Bp_bar_cols = 26;
const float L3_fan_Bp_bar_data[] = {
  7.28212148e-02f, 7.82719031e-02f, 3.43901366e-02f, 1.05400831e-01f, -3.53122950e-02f, 6.00587167e-02f, 1.78225115e-01f, -5.80064394e-02f, -2.38454016e-03f, 6.12200946e-02f,
  8.00220966e-02f, 2.09029447e-02f, 6.29228428e-02f, 1.28662422e-01f, 1.95832834e-01f, 8.96630362e-02f, 6.12666234e-02f, -2.38219742e-02f, -3.75317708e-02f, 8.77895951e-02f,
  1.10591598e-01f, 6.47365898e-02f, 1.03879094e-01f, -4.82967310e-02f, 1.65183470e-01f, 1.50251448e-01f
};

// L4_linear_W (Shape: 12 x 64)
const int L4_linear_W_rows = 12;
const int L4_linear_W_cols = 64;
const float L4_linear_W_data[] = {
  1.83852226e-01f, 1.93544999e-01f, -1.80633500e-01f, -6.81383312e-02f, -1.36955604e-01f, -1.12615205e-01f, -4.83719110e-01f, 8.15910995e-02f, 1.17552720e-01f, -3.46152335e-01f,
  -1.75236776e-01f, -1.42029330e-01f, 4.00264654e-03f, -5.59047051e-02f, 1.81228146e-01f, -1.64374977e-01f, 3.05413246e-01f, -2.92753845e-01f, 5.17334305e-02f, -3.49603623e-01f,
  -2.10408177e-02f, 1.62378568e-02f, -3.81717063e-03f, -2.82509588e-02f, -5.29210977e-02f, -1.56345233e-01f, 6.15247227e-02f, 1.44464672e-01f, 2.42119476e-01f, 2.35290498e-01f,
  -3.18315804e-01f, 1.65058881e-01f, 1.14024609e-01f, 2.18059883e-01f, 1.01388589e-01f, 7.64709618e-03f, 1.85645536e-01f, 1.51769280e-01f, -2.48454362e-01f, 1.02748819e-01f,
  -1.94371000e-01f, -4.74661477e-02f, -8.06622133e-02f, 1.43143803e-01f, 1.88774541e-01f, 3.66773047e-02f, 3.10201161e-02f, -6.43420219e-02f, 1.44190863e-02f, -1.85843837e-02f,
  1.45344153e-01f, -4.27789688e-01f, -1.41940027e-01f, -3.96256834e-01f, 2.88067341e-01f, -7.70159215e-02f, -4.16121155e-01f, -2.70369351e-01f, -4.50118124e-01f, 8.53294507e-02f,
  -3.09846908e-01f, -1.66404620e-02f, 1.41775133e-02f, 1.00464828e-01f, -1.22127764e-01f, 1.44761413e-01f, -2.60560095e-01f, 3.84038575e-02f, 1.99170485e-02f, -1.43118128e-01f,
  -7.64668062e-02f, 5.87374233e-02f, -1.42318502e-01f, 1.04610704e-01f, -1.69015869e-01f, 4.97873016e-02f, 2.24720296e-02f, -1.43733174e-01f, -1.30570069e-01f, -9.26126838e-02f,
  6.47189394e-02f, -3.88370343e-02f, 1.22869685e-01f, 2.03160912e-01f, -1.13350496e-01f, 1.82803497e-01f, -2.00975388e-01f, 2.62750566e-01f, -3.80839467e-01f, -6.21002959e-03f,
  -1.48186952e-01f, 1.87467948e-01f, -8.82412493e-02f, -4.39821750e-01f, -2.93974280e-02f, -2.14399964e-01f, 1.10362500e-01f, -2.34728903e-01f, 3.72695625e-01f, 1.74137831e-01f,
  -9.96654108e-02f, 1.83330536e-01f, -3.10515791e-01f, 1.12689734e-01f, 1.16297975e-01f, -9.13126767e-02f, 1.84954613e-01f, -3.31163943e-01f, -3.17129493e-01f, -2.44252160e-01f,
  1.62126929e-01f, 3.12451012e-02f, 2.39401441e-02f, -5.39233051e-02f, 1.80705816e-01f, -1.07612051e-01f, 8.09387714e-02f, -6.00323379e-01f, -7.18613639e-02f, -1.22600898e-01f,
  -4.56941605e-01f, 1.63533494e-01f, 1.72376722e-01f, -2.50738353e-01f, -2.16055587e-02f, 1.39109761e-01f, -8.92149881e-02f, 9.86959133e-03f, 1.63132861e-01f, 1.79606125e-01f,
  -9.87866446e-02f, -1.40784517e-01f, 6.53476790e-02f, 3.58821861e-02f, -2.22924665e-01f, 8.06289986e-02f, -4.61286567e-02f, -1.74265370e-01f, 7.28020594e-02f, -4.53736559e-02f,
  -4.14256267e-02f, 2.01062173e-01f, -3.83846648e-02f, 1.37563217e-02f, 2.95150299e-02f, -1.37394831e-01f, -4.67014611e-02f, -2.68398494e-01f, -6.74725100e-02f, -2.79095918e-01f,
  -2.63367712e-01f, -2.74230570e-01f, -8.42791870e-02f, 3.01967561e-01f, 1.78770199e-01f, -5.73999994e-03f, 2.30375808e-02f, 8.37458223e-02f, 2.98047215e-01f, 2.31763020e-01f,
  -1.21991597e-01f, -2.74470240e-01f, 3.24265473e-02f, 1.71554178e-01f, -6.78502349e-03f, -1.33948326e-01f, -5.54197729e-01f, 2.31953725e-01f, 1.20105676e-01f, 1.05035089e-01f,
  1.89923510e-01f, -4.90651220e-01f, -1.56185985e-01f, 1.94572419e-01f, -2.03757077e-01f, -2.07912579e-01f, -1.16860330e-01f, 9.34612658e-03f, -4.64448035e-02f, -4.68498260e-01f,
  -8.26352462e-02f, -4.49171886e-02f, -1.63127273e-01f, -3.13142031e-01f, 1.95239812e-01f, -1.07709534e-01f, -4.35115784e-01f, 6.38312027e-02f, 1.67734012e-01f, 1.57740504e-01f,
  -5.13869762e-01f, 1.42915964e-01f, -8.32405165e-02f, 8.28482881e-02f, -2.59295791e-01f, -1.05574755e-02f, -1.95282787e-01f, -1.38340175e-01f, 6.70063682e-03f, 6.21503703e-02f,
  -1.03877380e-01f, -1.06817700e-01f, 1.45057430e-02f, -3.89554650e-02f, -1.34108782e-01f, -1.53665408e-01f, -1.18301213e-01f, 7.02221915e-02f, -1.19158633e-01f, 1.42576337e-01f,
  -5.45240007e-02f, -3.34199846e-01f, 2.11032107e-01f, -2.15530425e-01f, 4.60036751e-03f, -7.72684216e-02f, -1.13983609e-01f, -2.89839774e-01f, -2.53277689e-01f, 9.15726796e-02f,
  1.42262995e-01f, 6.50271252e-02f, -3.86402577e-01f, 2.54137367e-01f, -2.68527955e-01f, -5.50851598e-02f, 4.73468285e-03f, 1.50213325e-02f, -9.36286449e-02f, -3.40201795e-01f,
  -1.60279527e-01f, 9.74309072e-02f, -3.37301791e-01f, -1.79276347e-01f, -1.18387200e-01f, 4.82023284e-02f, 1.05251715e-01f, 9.07243639e-02f, 1.25035122e-01f, 2.50464648e-01f,
  -8.72007489e-01f, -1.53200001e-01f, 3.28308754e-02f, 1.75654963e-01f, -5.71428299e-01f, 4.03438769e-02f, -2.01091245e-01f, -2.19573498e-01f, 1.10580519e-01f, -2.96184897e-01f,
  -4.47666317e-01f, 4.97794338e-02f, -4.27788615e-01f, -2.53904879e-01f, -3.46437573e-01f, 1.18534900e-02f, -2.45275885e-01f, -2.19331056e-01f, 3.42778742e-01f, 1.50162026e-01f,
  3.41578960e-01f, -9.46705043e-02f, 2.30451256e-01f, -1.34699583e-01f, -1.67244107e-01f, -2.00479850e-02f, 5.63631691e-02f, 1.99545875e-01f, 2.45076701e-01f, -1.24899566e-01f,
  -2.93534875e-01f, 2.21503049e-01f, -3.05336297e-01f, 2.60749102e-01f, 2.34044611e-01f, -3.53283202e-03f, 2.66842246e-01f, 7.01547638e-02f, -9.90880728e-02f, -2.29311436e-01f,
  3.17011662e-02f, -3.19481254e-01f, 3.05440992e-01f, -9.04262587e-02f, -5.52252051e-04f, 2.24969268e-01f, 4.10708427e-01f, 1.42978691e-02f, 3.14456448e-02f, 7.94329718e-02f,
  1.67740867e-01f, -9.65086371e-02f, -2.55252153e-01f, 2.63977349e-01f, 5.20279408e-02f, -1.12758674e-01f, -7.07247257e-02f, -2.34244719e-01f, -2.77137876e-01f, 1.29375085e-01f,
  2.28684142e-01f, 1.26102895e-01f, -1.22828986e-02f, -1.38095528e-01f, -7.37275481e-02f, -2.98252255e-01f, 1.38276909e-02f, -4.45718706e-01f, -2.00391859e-01f, 2.23659083e-01f,
  -3.92699301e-01f, -2.54469991e-01f, -2.00736091e-01f, -2.43058391e-02f, 2.23288555e-02f, 1.53922707e-01f, 1.66940913e-01f, -4.00813073e-01f, 2.00112443e-02f, 1.02195024e-01f,
  -6.29482567e-02f, -7.62320310e-02f, -1.46735953e-02f, -9.42479745e-02f, 3.05692218e-02f, 1.31951943e-01f, 1.56111419e-01f, 2.31241718e-01f, 1.29709095e-01f, 2.90931523e-01f,
  7.79597741e-03f, -3.04288268e-01f, -6.92818388e-02f, 4.54139970e-02f, 5.48310690e-02f, 1.54286638e-01f, 4.02521878e-01f, -6.66662753e-02f, -1.31331921e-01f, -2.25912705e-01f,
  1.45804539e-01f, -8.52781981e-02f, 4.46531594e-01f, 6.33713081e-02f, 4.87003952e-01f, 6.01664856e-02f, -4.67059240e-02f, 2.20013276e-01f, 1.25863090e-01f, -1.61277786e-01f,
  -1.95412830e-01f, -1.19601712e-01f, -2.21176505e-01f, -1.81273550e-01f, -1.85537905e-01f, -3.67341004e-02f, 3.33858013e-01f, 6.77031279e-02f, -2.48388544e-01f, -1.87278852e-01f,
  -3.54399830e-02f, -1.42406926e-01f, 6.01420850e-02f, -8.84068161e-02f, 3.17185633e-02f, -2.59092540e-01f, 5.62306568e-02f, -3.88612300e-02f, 8.63808617e-02f, -2.29677692e-01f,
  1.05271406e-01f, 2.74120748e-01f, 9.93462279e-02f, 8.57891738e-02f, 2.35690430e-01f, -2.77315766e-01f, -2.77061909e-01f, -2.08599076e-01f, -3.47590595e-01f, 1.53965905e-01f,
  2.35386416e-01f, -2.31130645e-01f, -2.10758314e-01f, -6.24358840e-02f, -1.58305578e-02f, -1.19269371e-01f, 1.13558352e-01f, 8.69196057e-02f, 2.76277158e-02f, -2.44223386e-01f,
  1.21017788e-02f, 1.92504138e-01f, 1.18160389e-01f, 2.10740685e-01f, 5.65147810e-02f, -2.63396204e-01f, -1.33463725e-01f, -2.93653071e-01f, -1.42627776e-01f, -7.95090869e-02f,
  2.46795833e-01f, -1.22836478e-01f, 8.79042223e-02f, 1.81450918e-01f, 2.08554547e-02f, -2.54568964e-01f, 7.97924865e-03f, 1.25376716e-01f, -8.00717529e-03f, -2.21541673e-01f,
  -1.59874186e-01f, 3.82348031e-01f, -2.89363503e-01f, -1.82300359e-01f, 6.05089515e-02f, -1.39692485e-01f, 4.35747989e-02f, -9.32766497e-02f, -4.06855978e-02f, -1.95685238e-01f,
  -3.72471541e-01f, 1.14279106e-01f, 3.88723165e-02f, -1.37951732e-01f, 4.64860126e-02f, 2.40039855e-01f, 2.14648724e-04f, 7.83937126e-02f, 7.73526803e-02f, -5.56045532e-01f,
  -8.27552378e-02f, -4.33687121e-01f, 4.62411083e-02f, 1.35989040e-01f, -4.45490956e-01f, -8.93590674e-02f, 1.60403728e-01f, -2.01596275e-01f, -1.24274850e-01f, 2.01571971e-01f,
  6.06860220e-02f, -4.20612216e-01f, -1.99277982e-01f, -4.90871131e-01f, 2.16314048e-01f, -3.98016758e-02f, 1.96397036e-01f, -3.69454861e-01f, -7.25171193e-02f, -1.72143318e-02f,
  -5.48700504e-02f, 9.38877165e-02f, 2.02664167e-01f, -2.74998583e-02f, 1.63783744e-01f, -8.14766213e-02f, 1.63842905e-02f, 1.45853713e-01f, 1.68078497e-01f, -1.49918720e-01f,
  1.39785692e-01f, 9.44415629e-02f, -1.23584375e-01f, 9.32235047e-02f, 2.50832755e-02f, 8.60258192e-02f, -1.83234707e-01f, 9.73703340e-03f, -1.35334700e-01f, -1.48694530e-01f,
  1.32275835e-01f, -3.14100869e-02f, -6.55156001e-02f, -1.20604627e-01f, 1.92411855e-01f, -1.26894251e-01f, 1.95670530e-01f, 1.31301463e-01f, -6.01777397e-02f, -2.82628369e-03f,
  -1.46051615e-01f, 1.59616455e-01f, -9.85472128e-02f, 1.78812087e-01f, 1.49346218e-01f, -2.08319545e-01f, 1.08514331e-01f, 5.93316108e-02f, 4.45697755e-02f, -3.63151729e-01f,
  -3.04305870e-02f, 1.30943274e-02f, -8.33501965e-02f, -1.35568663e-01f, -1.58402234e-01f, 1.88478321e-01f, -4.98212948e-02f, -3.86960089e-01f, -1.44030750e-01f, -1.84938997e-01f,
  -2.69419760e-01f, -4.09497261e-01f, 2.31465831e-01f, 8.23408589e-02f, 7.16360658e-02f, 2.33672112e-01f, 1.20825842e-01f, -3.62281859e-01f, -4.27686870e-01f, 1.35894567e-01f,
  4.48781811e-02f, -6.88325390e-02f, 2.32139394e-01f, -6.27879053e-02f, 1.03275105e-01f, 1.17712423e-01f, -1.01491623e-01f, -6.37945309e-02f, 7.93056414e-02f, 4.02500434e-03f,
  3.04823756e-01f, -1.85992122e-01f, 1.89198162e-02f, 5.89537318e-04f, -1.96861669e-01f, 1.23861752e-01f, 1.63206547e-01f, 7.23720565e-02f, 1.75804682e-02f, 2.59226728e-02f,
  -2.63422310e-01f, 4.43752199e-01f, 2.75321335e-01f, 1.60866514e-01f, 3.69645268e-01f, 5.62513061e-03f, 3.59026939e-01f, -2.15321966e-02f, -3.58705670e-02f, -4.88837063e-01f,
  2.51464427e-01f, 4.81890947e-01f, -3.99569184e-01f, -5.95653802e-02f, 3.96174908e-01f, 1.22106291e-01f, -1.80909276e-01f, 9.43096057e-02f, 2.85183489e-01f, 4.22690324e-02f,
  -1.30293652e-01f, -2.25287870e-01f, 9.86724496e-02f, -1.81296945e-01f, -2.42100522e-01f, -1.69305086e-01f, -1.32462531e-01f, -4.05603163e-02f, -3.87291491e-01f, 1.23964533e-01f,
  -3.09630167e-02f, 1.87450558e-01f, -5.67862809e-01f, 4.89395149e-02f, 2.01793268e-01f, -6.12336278e-01f, 3.18113595e-01f, -1.80524036e-01f, -2.50926316e-01f, 3.75521541e-01f,
  9.57924128e-03f, -2.77821779e-01f, 8.27465057e-02f, -2.36816317e-01f, -2.60036916e-01f, -2.55652547e-01f, 1.48203135e-01f, -4.85237390e-02f, -6.64004907e-02f, 1.05341949e-01f,
  1.51118055e-01f, 7.77228996e-02f, -2.42651068e-02f, 1.05004106e-02f, -2.96414167e-01f, -1.37637192e-02f, -8.07808936e-02f, -1.31462827e-01f, 1.96231887e-01f, 2.11899191e-01f,
  4.02798384e-01f, -8.81043300e-02f, -7.96506777e-02f, 1.47166979e-02f, -4.33316864e-02f, 4.23363805e-01f, -7.52924532e-02f, -1.39940649e-01f, 3.45362723e-01f, -2.91565299e-01f,
  3.16727161e-01f, 3.74781519e-01f, 3.18059891e-01f, -3.08650523e-01f, -1.01516224e-01f, -2.79880852e-01f, 2.65290350e-01f, 2.01015830e-01f, 6.16028421e-02f, 3.11683804e-01f,
  4.90121752e-01f, -2.96759784e-01f, -2.57668167e-01f, -2.64994740e-01f, 2.26543263e-01f, 2.25219410e-02f, -2.25934178e-01f, -1.15240462e-01f, 2.17465848e-01f, -4.90421176e-01f,
  2.33673364e-01f, -9.67556834e-02f, -6.00718617e-01f, -1.38450086e-01f, 1.26835257e-01f, -1.87582925e-01f, 2.66128741e-02f, -1.22067399e-01f, -1.12589575e-01f, -2.21293584e-01f,
  -3.22988421e-01f, 1.32736295e-01f, 1.23876378e-01f, -4.89372224e-01f, 1.28899619e-01f, -4.67610471e-02f, -1.04594350e-01f, -4.60416339e-02f, 6.43200278e-02f, -8.65878165e-03f,
  2.28960767e-01f, -1.10094510e-01f, -2.74457961e-01f, -1.59624606e-01f, -1.26002282e-01f, 2.52408057e-01f, -3.01147163e-01f, -2.09306329e-01f, -1.91920519e-01f, -2.07019046e-01f,
  1.30817443e-01f, 2.38392666e-01f, -1.86442956e-01f, -1.97565630e-01f, 1.73405975e-01f, -4.36060838e-02f, 9.35048833e-02f, -1.64326623e-01f, 1.95415720e-01f, -2.55223095e-01f,
  3.13781619e-01f, 1.95801213e-01f, -9.56605300e-02f, 7.52489045e-02f, -1.09494850e-01f, -2.54613608e-01f, -1.92484215e-01f, 1.85904637e-01f, -2.05363542e-01f, 2.58698575e-02f,
  -5.85524775e-02f, -2.01256394e-01f, -3.09536546e-01f, -2.41761029e-01f, -4.20434833e-01f, 1.55864611e-01f, 6.44603092e-03f, 9.05525014e-02f, -1.52923420e-01f, -6.43991470e-01f,
  -3.16713691e-01f, -2.84084827e-01f, -3.58966112e-01f, -2.58640170e-01f, -4.36424851e-01f, -3.10193282e-02f, 2.35204965e-01f, -4.75617021e-01f, -6.68356240e-01f, 2.21872583e-01f,
  2.23754585e-01f, -2.33716592e-01f, -3.28348838e-02f, 1.98928252e-01f, -2.10341036e-01f, -3.89782228e-02f, -3.87975276e-02f, -6.81710094e-02f, -6.31276071e-01f, -2.11515948e-01f,
  1.50351182e-01f, -5.55470526e-01f, -2.54921079e-01f, 3.62235099e-01f, 6.76893666e-02f, 2.34292656e-01f, 1.43277319e-02f, -7.69667476e-02f, 1.27059311e-01f, 2.35147163e-01f,
  -7.63052776e-02f, -2.92505175e-01f, 1.59512803e-01f, 9.87666771e-02f, 1.79627821e-01f, 1.66146234e-01f, 8.62712599e-03f, -2.14151554e-02f, 5.35361841e-02f, -3.73233780e-02f,
  -4.27715220e-02f, 1.81359619e-01f, 2.61265069e-01f, -6.09312207e-02f, -5.16396873e-02f, 2.67278075e-01f, -3.58886719e-01f, 3.56117576e-01f, -1.06930874e-01f, 3.31267804e-01f,
  -1.79309666e-01f, -4.94455621e-02f, 3.87687385e-01f, -2.57720686e-02f, -2.41152737e-02f, -1.02178089e-01f, 3.04357260e-01f, 3.96702796e-01f, -2.41730899e-01f, -1.14709482e-01f,
  2.56270498e-01f, 4.99321707e-02f, -3.79935026e-01f, -5.38477957e-01f, 1.55936345e-01f, 2.39548996e-01f, -3.57310362e-02f, -4.18988734e-01f, -1.35845050e-01f, -1.37177274e-01f,
  -1.59255013e-01f, 2.06913382e-01f, -4.53141540e-01f, 1.86186060e-01f, -3.00922424e-01f, 2.95607626e-01f, -6.29850104e-02f, 2.17217281e-01f, -3.12926829e-01f, -2.24813610e-01f,
  7.14840963e-02f, -1.97132662e-01f, -2.59107888e-01f, -2.15162814e-01f, -1.39987736e-03f, -3.02545816e-01f, -3.42124072e-03f, -1.47600934e-01f
};

// L4_linear_B (Shape: 1 x 12)
const int L4_linear_B_rows = 1;
const int L4_linear_B_cols = 12;
const float L4_linear_B_data[] = {
  -4.50090319e-02f, -1.16178006e-01f, 1.52313128e-01f, 1.25749111e-02f, -6.43550828e-02f, 2.45235339e-02f, 5.13491705e-02f, -8.37828293e-02f, 1.94676425e-02f, -2.01424453e-02f,
  1.05626710e-01f, 1.02617115e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 19, 26
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        64, 19, 26
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        64, 19, 26
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L3_fan_Wp_data, L3_fan_Wp_bar_data, L3_fan_Bp_bar_data,
        64, 19, 26
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 4: L4_linear
    linear_forward_pgm(
        buffer1, x_out,
        L4_linear_W_data, L4_linear_B_data,
        64, 12
    );
    }
    