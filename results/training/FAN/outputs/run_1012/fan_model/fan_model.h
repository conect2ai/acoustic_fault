/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 32 (x1)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 32;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    return (x > 0.0f) ? x : 0.0f;
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 6 x 120)
const int L0_fan_Wp_rows = 6;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -1.23916298e-01f, -2.80695796e-01f, -4.27747846e-01f, -2.58264691e-01f, 1.12376168e-01f, 1.95150912e-01f, 1.74767405e-01f, 1.07613824e-01f, -4.29477096e-02f, -1.95020348e-01f,
  -4.24741954e-02f, 1.34656191e-01f, 4.97565083e-02f, 1.38372660e-01f, 7.50260204e-02f, -2.21249193e-01f, -2.39448205e-01f, -3.52296419e-02f, 4.64569777e-01f, 3.66161048e-01f,
  1.76896244e-01f, 6.47841319e-02f, 1.10972412e-02f, -4.15284522e-02f, -1.98283255e-01f, 3.30147706e-02f, -3.43046308e-01f, -1.24477290e-01f, -1.02682643e-01f, -4.40903932e-01f,
  -3.05233806e-01f, -4.10248905e-01f, 1.88046008e-01f, 5.53687438e-02f, -7.80057311e-02f, -4.60676663e-02f, 1.76033694e-02f, -3.28038842e-03f, 2.19469219e-02f, -1.31848425e-01f,
  -1.13590039e-01f, -4.51915748e-02f, -5.57630546e-02f, -4.32127342e-02f, -4.57236469e-02f, -7.45722279e-02f, -8.76358300e-02f, -1.58739477e-01f, -9.74916220e-02f, -9.10035968e-02f,
  -8.79375711e-02f, -7.66876712e-02f, -2.85261162e-02f, -2.85196844e-02f, -3.43728550e-02f, 4.36600409e-02f, -5.79970554e-02f, -6.99146315e-02f, -9.81111545e-03f, -1.72166765e-01f,
  2.06564173e-01f, -2.54520979e-02f, 3.78582180e-02f, 2.04959996e-02f, 3.25893424e-02f, -2.88165966e-03f, -7.47050121e-02f, 7.97618553e-02f, 1.12104125e-01f, 3.17559913e-02f,
  1.35881454e-02f, -1.44058252e-02f, 5.25365816e-03f, -1.40695926e-02f, -1.51494080e-02f, -1.09366244e-02f, 7.72438943e-02f, -2.08057053e-02f, 1.88874286e-02f, 1.64347012e-02f,
  -6.84167491e-03f, 1.24471355e-02f, 3.36726755e-02f, 1.02254085e-01f, -3.71368369e-03f, -2.84396112e-02f, 2.65276190e-02f, 3.29872780e-02f, 7.18246326e-02f, -5.16066402e-02f,
  2.77440190e-01f, 7.64158294e-02f, -8.61604884e-02f, -2.78108884e-02f, -3.44287716e-02f, -1.56091265e-02f, -7.00705722e-02f, -5.17146327e-02f, -4.75567803e-02f, -3.73985921e-03f,
  3.10656857e-02f, -1.20127946e-02f, -6.88592046e-02f, -1.88622009e-02f, 1.55009776e-01f, 6.80682808e-02f, 2.23692507e-02f, -4.05375063e-02f, -1.67419389e-02f, -1.29011214e-01f,
  9.93694924e-03f, 1.70066476e-01f, 1.97240189e-01f, 1.06001064e-01f, 3.44745480e-02f, 2.04811141e-01f, 1.12293728e-01f, 1.30261615e-01f, 2.25890905e-01f, 2.40190148e-01f,
  -3.94825011e-01f, -2.88846046e-01f, 2.97534913e-01f, -1.00342691e-01f, -1.63609892e-01f, -6.20200410e-02f, -1.55627474e-01f, -3.60935703e-02f, -1.77480038e-02f, 5.84893413e-02f,
  -2.69337624e-01f, 3.06834374e-02f, 2.56529540e-01f, 1.97563648e-01f, 1.05209574e-01f, 3.11478823e-01f, 4.66553479e-01f, 4.52995032e-01f, 2.28164792e-01f, -8.63507614e-02f,
  -6.01594411e-02f, -8.22006389e-02f, 5.03869504e-02f, 7.50195831e-02f, 1.33152783e-01f, 2.20270857e-01f, 9.55495015e-02f, -1.41953945e-01f, -9.26390737e-02f, 2.37329468e-01f,
  1.72167942e-01f, -3.17827135e-01f, 1.08600602e-01f, -6.19856343e-02f, -1.76410321e-02f, -1.08046860e-01f, 3.19415033e-02f, -6.50067776e-02f, -1.39689833e-01f, 3.74023058e-02f,
  -8.91673639e-02f, -6.02157451e-02f, -2.28022803e-02f, -3.90277281e-02f, -6.36697784e-02f, -1.04027778e-01f, -9.91313532e-02f, 3.15031558e-02f, -4.56101894e-02f, -1.54063314e-01f,
  -1.54597417e-01f, -2.21242696e-01f, -1.21678390e-01f, -4.45730649e-02f, -1.62770171e-02f, -2.11218949e-02f, -6.97669983e-02f, -8.36455151e-02f, 3.51669304e-02f, -6.29115030e-02f,
  1.95980415e-01f, 6.69382885e-02f, -1.23443231e-02f, -1.48561243e-02f, -5.05186245e-02f, -1.80702135e-02f, 6.32121116e-02f, 4.19643521e-02f, 1.35046942e-02f, 4.64593992e-02f,
  2.60886494e-02f, 5.50246872e-02f, 4.54359576e-02f, 6.03111051e-02f, 1.20588191e-01f, -1.72144081e-02f, 8.25756714e-02f, 3.69790122e-02f, 4.26772162e-02f, -1.78739596e-02f,
  -2.60902592e-03f, 9.68273506e-02f, -1.63407158e-02f, 1.08766451e-01f, -5.38192019e-02f, 8.02115053e-02f, 2.07312275e-02f, -4.68774475e-02f, -4.65616211e-02f, 6.07762821e-02f,
  -1.00933157e-01f, -3.51980850e-02f, 4.02387343e-02f, 2.19838731e-02f, -3.17591317e-02f, -2.56516319e-03f, -9.55125540e-02f, -4.28385772e-02f, -8.39087218e-02f, -1.02091447e-01f,
  -4.75582294e-02f, 1.83873996e-02f, 6.97301403e-02f, -4.82405461e-02f, -6.61332300e-03f, 4.39138636e-02f, -2.55285911e-02f, 5.85705377e-02f, 8.14621989e-03f, -2.93217245e-02f,
  -4.58891988e-02f, -2.77218949e-02f, 1.02755390e-01f, -2.49855611e-02f, 3.55025493e-02f, 1.02416344e-01f, 1.82748809e-01f, -3.74715589e-02f, 1.27108827e-01f, 1.07696801e-01f,
  3.48861396e-01f, -3.29099834e-01f, -1.28544003e-01f, 1.20276853e-01f, 1.91834167e-01f, 2.01832950e-01f, 3.14638838e-02f, 5.86638637e-02f, 1.17187374e-04f, -1.87220141e-01f,
  -1.42778233e-01f, -2.45101321e-02f, 4.23796214e-02f, 6.04703240e-02f, 2.89886773e-01f, -2.39097327e-02f, 6.03040420e-02f, 2.87288994e-01f, 3.60661596e-01f, 1.30985722e-01f,
  -7.09860995e-02f, -4.79456708e-02f, 8.68730545e-02f, 3.78949605e-02f, -2.36866280e-01f, 3.62490527e-02f, -2.47083589e-01f, -9.94066373e-02f, -1.44717500e-01f, -2.82889962e-01f,
  -3.09163421e-01f, -2.56960660e-01f, 7.14011639e-02f, -1.43367410e-01f, -1.66843936e-01f, -1.35753572e-01f, -9.71120074e-02f, -2.13804170e-01f, -6.17466308e-02f, -1.71934009e-01f,
  -1.63602516e-01f, -1.42010987e-01f, -2.51800343e-02f, -9.35187563e-02f, -1.91995502e-02f, -6.51508123e-02f, -1.26679048e-01f, -1.32930800e-01f, -1.31772041e-01f, -1.52615592e-01f,
  -2.07789391e-01f, -4.42006066e-02f, -9.28982254e-03f, -2.83519719e-02f, -1.09223194e-01f, -9.23596602e-03f, -1.72158957e-01f, -1.91261068e-01f, -1.20097008e-02f, -2.08723187e-01f,
  1.67794693e-02f, 7.18681440e-02f, 1.19822785e-01f, 4.95141558e-02f, 6.95773959e-02f, 1.02765828e-01f, 6.53446093e-02f, 8.28507021e-02f, 1.24804944e-01f, 1.06966324e-01f,
  1.94277033e-01f, 1.24577917e-01f, 9.44380183e-03f, 1.20930448e-01f, -5.25559904e-03f, 1.22675925e-01f, 1.42922193e-01f, 7.83002004e-03f, 1.41708076e-01f, 6.38132393e-02f,
  7.22662210e-02f, 6.01804182e-02f, 9.66815054e-02f, 6.14057928e-02f, 5.38139567e-02f, 1.86419159e-01f, 3.57640274e-02f, 6.23441637e-02f, 4.87686694e-02f, 1.99588761e-02f,
  -2.42788315e-01f, 1.59442931e-01f, -9.73789394e-02f, -1.01230480e-01f, -6.86306059e-02f, -1.52409270e-01f, -6.33047372e-02f, -2.34048113e-01f, -1.20758750e-01f, -9.57515612e-02f,
  -1.09761119e-01f, -6.75015599e-02f, -8.82824436e-02f, -1.49292991e-01f, 3.19742300e-02f, -1.21367343e-01f, -1.13950163e-01f, -9.67896357e-03f, -2.28494424e-02f, -2.29371339e-01f,
  -1.03221662e-01f, 1.37336567e-01f, 1.75114870e-01f, -7.04539269e-02f, -6.04692027e-02f, 7.72392005e-02f, -1.52915437e-02f, -1.06526008e-02f, 1.17643222e-01f, -1.14430182e-01f,
  1.47834376e-01f, -3.87475669e-01f, -6.89627649e-03f, -2.22851843e-01f, -8.93233046e-02f, 5.20895123e-02f, -1.44394368e-01f, 1.53831720e-01f, 3.69630754e-02f, -8.47909003e-02f,
  -1.12156873e-03f, 2.91191816e-01f, 1.99685737e-01f, 2.57496148e-01f, 2.25140423e-01f, -2.79399514e-01f, -3.77993643e-01f, 2.31352583e-01f, 5.10037422e-01f, 1.97412610e-01f,
  -1.24048501e-01f, -1.80522710e-01f, 1.28036872e-01f, 8.11148509e-02f, -2.43924156e-01f, -4.65496304e-03f, -1.10683151e-01f, -3.30584683e-02f, -1.20355994e-01f, -3.50564092e-01f,
  1.58265993e-01f, 2.99747288e-02f, 2.39695147e-01f, 1.27249345e-01f, 1.00726113e-02f, 7.53480792e-02f, 6.28385618e-02f, 9.86328162e-03f, 1.57403778e-02f, -3.23474780e-02f,
  -7.63746584e-03f, 1.35711161e-02f, -1.05147501e-02f, 1.06098346e-01f, 5.40337637e-02f, 4.74144481e-02f, 8.74219090e-02f, 2.03019753e-01f, 1.44764036e-01f, 6.84779212e-02f,
  -7.39428326e-02f, -8.56433138e-02f, 8.36790353e-02f, 1.43572032e-01f, 1.81354940e-01f, 1.11277960e-01f, 2.13260520e-02f, 1.83771461e-01f, 1.67044848e-01f, 2.26106904e-02f,
  2.08409838e-02f, -6.99982047e-02f, -9.50613543e-02f, -1.07330933e-01f, -1.22401081e-01f, -1.36997223e-01f, -8.57984796e-02f, -1.42616063e-01f, -6.85577914e-02f, -1.32143185e-01f,
  2.29699407e-02f, -1.11641593e-01f, -6.27650740e-03f, -1.09340839e-01f, -5.68059050e-02f, -6.19349666e-02f, -8.81892815e-02f, -9.74817351e-02f, -8.74947235e-02f, -1.11161746e-01f,
  -1.35514691e-01f, -3.09695471e-02f, -1.49152368e-01f, -4.51902300e-02f, -1.14160828e-01f, -3.35423425e-02f, -2.06558835e-02f, -1.57232117e-02f, -3.50752696e-02f, -1.06983341e-01f,
  9.69671980e-02f, 3.16246748e-01f, 1.93295795e-02f, 5.91271296e-02f, -1.02363117e-02f, 1.13186121e-01f, 3.28491032e-02f, 3.50080468e-02f, -4.53632213e-02f, 9.64114666e-02f,
  1.21694580e-01f, 1.75239608e-01f, 5.50436042e-02f, 1.16105422e-01f, 7.52616003e-02f, 1.00603916e-01f, -5.68350255e-02f, 1.06285237e-01f, 1.16217598e-01f, 5.29702343e-02f,
  -6.12564236e-02f, -4.25315015e-02f, 5.08017428e-02f, 2.76807789e-02f, 7.63866082e-02f, 1.32593423e-01f, 1.22632407e-01f, 5.15089929e-02f, 2.90501148e-01f, -1.27586380e-01f,
  2.00915962e-01f, -1.40202925e-01f, 1.12232022e-01f, -9.03577432e-02f, 3.02299261e-02f, -1.82731390e-01f, -3.41559827e-01f, -2.90058702e-01f, -8.17878023e-02f, -2.08512291e-01f,
  1.33341387e-01f, 3.34947482e-02f, -8.17006361e-03f, -1.73803091e-01f, -1.58647805e-01f, -3.34930807e-01f, -2.35846549e-01f, -2.31900886e-01f, -2.56213784e-01f, -3.02313864e-01f,
  -2.63113379e-01f, -1.83036149e-01f, -1.70633480e-01f, -2.04084903e-01f, -3.44742596e-01f, -1.51250571e-01f, -8.53735507e-02f, -1.69218317e-01f, -1.51378796e-01f, -3.22143525e-01f,
  -7.75389373e-02f, 1.39325961e-01f, -1.44461855e-01f, 5.57685904e-02f, 1.26994282e-01f, -9.55801904e-02f, -1.22879356e-01f, -1.29555389e-01f, -6.85466826e-02f, -2.29830220e-01f,
  -1.12302729e-03f, -9.38600004e-02f, 1.69874728e-02f, -1.64709792e-01f, -1.34515956e-01f, -1.54335216e-01f, -2.26097390e-01f, -1.69067323e-01f, -1.52931929e-01f, -1.30097240e-01f,
  -1.01482198e-01f, -8.56711492e-02f, -4.93042879e-02f, -1.84089214e-01f, -2.68067956e-01f, -1.38663054e-01f, -2.33661503e-01f, -3.58198494e-01f, -2.54963994e-01f, -4.06219393e-01f,
  -2.97492556e-02f, 1.42600685e-01f, 1.51332304e-01f, 9.16307718e-02f, -3.00933467e-03f, 1.34122342e-01f, 1.64178625e-01f, 1.02638833e-01f, 3.32850851e-02f, 7.00964266e-03f,
  1.40167773e-01f, 1.34270385e-01f, 8.89072642e-02f, 7.14008585e-02f, 3.39740738e-02f, 7.85183460e-02f, 7.29918107e-02f, 3.52734402e-02f, 6.77037835e-02f, 1.54308662e-01f,
  8.19332302e-02f, 9.28792283e-02f, 1.39492705e-01f, 1.31533071e-01f, 1.24132164e-01f, 7.43630007e-02f, 4.45019044e-02f, 1.11565679e-01f, 7.73727447e-02f, 8.20025131e-02f,
  -7.31393099e-02f, 2.29446039e-01f, -1.75063536e-01f, -2.04201266e-01f, -5.19859940e-02f, -1.35793298e-01f, -6.22876212e-02f, -5.42961359e-02f, 5.30262105e-02f, -1.05816104e-01f,
  -5.58966398e-02f, -1.48821250e-01f, -4.49019596e-02f, -8.71315300e-02f, -6.02290668e-02f, -1.02817886e-01f, -1.49058461e-01f, -4.11953405e-02f, -8.98946300e-02f, -2.34698489e-01f,
  -2.29490295e-01f, -2.72113800e-01f, -2.14160413e-01f, -2.44349644e-01f, -2.21000761e-01f, -1.45392030e-01f, -1.67060554e-01f, -2.81411946e-01f, -1.36619776e-01f, -4.66465503e-01f,
  4.42268342e-01f, -3.52638274e-01f, 1.96664229e-01f, 1.25126496e-01f, -3.61472443e-02f, -1.43141940e-01f, -5.18313527e-01f, -4.60722372e-02f, 1.59514770e-01f, -4.70910184e-02f,
  6.54217899e-02f, 2.25763336e-01f, 2.37567604e-01f, 1.93930298e-01f, -4.60795909e-02f, -2.51244158e-01f, -1.96470946e-01f, 1.82958469e-01f, 1.58157751e-01f, -1.99909091e-01f,
  -2.17980877e-01f, 3.93240759e-03f, 1.86703607e-01f, 9.78745595e-02f, 5.10709882e-02f, 1.36184007e-01f, 8.30292031e-02f, 5.73818460e-02f, -1.04647659e-01f, -2.60209411e-01f,
  5.19395098e-02f, -1.00655973e-01f, 6.31995350e-02f, -5.70473522e-02f, 6.16616420e-02f, -2.46580988e-02f, 5.45083918e-02f, 1.35043725e-01f, -2.59272382e-02f, 2.88392194e-02f,
  1.52850021e-02f, -8.24249350e-03f, -5.39332926e-02f, -4.42385152e-02f, -7.83435330e-02f, -4.15044278e-02f, -4.71408851e-02f, -9.63317230e-02f, 7.28030968e-03f, -8.65056273e-03f,
  -2.11067572e-01f, -7.71100596e-02f, -2.85255853e-02f, -4.82491180e-02f, -6.83303326e-02f, 1.41236141e-01f, 3.12023778e-02f, -8.32904577e-02f, 7.88254961e-02f, -5.24023809e-02f,
  -4.18029465e-02f, 1.43969104e-01f, 1.32414654e-01f, 4.37282305e-03f, -1.15830088e-02f, 8.89753848e-02f, 9.91843045e-02f, -4.18636762e-02f, -5.39154699e-03f, 2.01341808e-02f,
  2.90582143e-03f, 1.06154326e-02f, 2.49432791e-02f, 6.79396912e-02f, -5.57785528e-03f, 1.15337148e-01f, 3.37531380e-02f, 4.05251049e-02f, 1.32042006e-01f, 3.29773426e-02f,
  3.57749406e-03f, 1.00323290e-01f, 1.95924386e-01f, -4.13346738e-02f, 9.87858027e-02f, 2.42462680e-02f, 1.39685515e-02f, 8.47137943e-02f, 1.02635734e-01f, 4.28217053e-02f,
  3.05749148e-01f, 1.57489121e-01f, 8.73229951e-02f, 3.44825238e-02f, 7.20525682e-02f, 1.10414982e-01f, 8.40068012e-02f, 2.09439602e-02f, 8.13899860e-02f, -7.81429559e-03f,
  -1.11684181e-04f, 4.94854972e-02f, 9.84913781e-02f, -1.02789916e-01f, -7.46543631e-02f, -7.12967850e-03f, 3.27769294e-02f, 6.39079809e-02f, -2.73050237e-02f, -5.09184338e-02f,
  -2.14683414e-02f, 1.60314643e-03f, 2.47691497e-01f, 3.74564640e-02f, 3.23417373e-02f, 1.40190244e-01f, 1.03647575e-01f, 4.38010730e-02f, 1.35204703e-01f, 1.06963448e-01f
};

// L0_fan_Wp_bar (Shape: 20 x 120)
const int L0_fan_Wp_bar_rows = 20;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  2.88900703e-01f, 4.90810871e-01f, 4.13596891e-02f, 3.41867238e-01f, 5.68127215e-01f, 4.00583267e-01f, 4.19006884e-01f, 1.43510431e-01f, 2.95380473e-01f, 2.87991673e-01f,
  5.49985766e-01f, 4.27254051e-01f, 4.19983774e-01f, 1.34933338e-01f, 8.92947614e-02f, 4.38574292e-02f, -7.84394294e-02f, -2.38764167e-01f, -1.34877801e-01f, 1.94320187e-01f,
  3.29880923e-01f, 2.87595361e-01f, 5.55103421e-02f, -1.04677349e-01f, 1.73014984e-01f, 9.88020673e-02f, 2.89359577e-02f, 1.26718447e-01f, 2.94900984e-01f, -7.99874440e-02f,
  -2.13267997e-01f, 1.84853271e-01f, -2.33759791e-01f, 7.65257627e-02f, -1.72788445e-02f, -2.26449430e-01f, -6.18161634e-02f, -2.25324914e-01f, 8.57408568e-02f, -6.65004477e-02f,
  -3.93084362e-02f, -3.86351608e-02f, 4.92735282e-02f, -5.34994490e-02f, -1.09959342e-01f, -4.19439934e-02f, -2.68851161e-01f, -2.73630142e-01f, -8.14474151e-02f, -5.82339205e-02f,
  1.32073179e-01f, 9.45738703e-02f, -8.55811983e-02f, 2.07363721e-02f, 7.48587251e-02f, -1.26782507e-01f, -6.67603686e-02f, -9.21227112e-02f, -7.27925748e-02f, -2.42643252e-01f,
  -5.05778901e-02f, 2.58708410e-02f, -1.57866143e-02f, -3.47421728e-02f, -2.70636799e-03f, -1.04662158e-01f, -1.89438835e-02f, 1.27229735e-01f, 1.71365030e-02f, -3.45219038e-02f,
  -1.32014170e-01f, -1.72095641e-01f, -3.06175277e-02f, 7.89415762e-02f, 1.31210431e-01f, 7.95858502e-02f, -1.20226093e-01f, -3.11436392e-02f, 3.83488834e-02f, -5.78785390e-02f,
  6.12550639e-02f, -1.15231805e-01f, -3.41231562e-02f, -8.46707150e-02f, -8.85718465e-02f, -9.12170112e-02f, 4.87880642e-03f, 7.66504779e-02f, 1.94619700e-01f, 1.24025933e-01f,
  1.09725200e-01f, 1.35929331e-01f, -2.60978818e-01f, -2.79102892e-01f, -5.95948324e-02f, -8.11743438e-02f, 1.99804977e-01f, -1.31591782e-01f, 4.53586876e-02f, -1.31807730e-01f,
  1.39668565e-02f, -1.91406414e-01f, 2.52592303e-02f, -1.48917750e-01f, -2.29449660e-01f, -1.89024076e-01f, -3.51497941e-02f, -1.12325817e-01f, -1.58107117e-01f, -2.02664167e-01f,
  -4.18448895e-02f, -2.26357162e-01f, -2.19123438e-01f, -1.99453980e-01f, -8.85075405e-02f, 1.30306883e-02f, -2.30795711e-01f, -1.70130774e-01f, -1.79921001e-01f, -2.66163528e-01f,
  -6.00355804e-01f, 3.87393199e-02f, 3.85336459e-01f, 1.19769238e-01f, 6.89916670e-01f, 7.98121989e-01f, 1.01693296e+00f, 4.46309060e-01f, 8.58175941e-03f, 1.69621632e-01f,
  -7.95742348e-02f, -3.84848535e-01f, -4.65320528e-01f, -1.69086084e-01f, -1.34881656e-03f, 4.47313935e-01f, 5.42965412e-01f, 1.84552111e-02f, -8.31697658e-02f, 1.56932279e-01f,
  7.62934759e-02f, -1.19329058e-01f, -6.62335753e-01f, -2.97418356e-01f, -1.91925749e-01f, -1.75677672e-01f, 3.11127342e-02f, 1.37880579e-01f, 3.52289021e-01f, -1.62202299e-01f,
  -2.81182259e-01f, -1.70520887e-01f, 9.82758924e-02f, -2.28830606e-01f, -4.29469720e-02f, -2.41073281e-01f, -8.34788159e-02f, -3.69444489e-01f, -9.68293026e-02f, -1.60665780e-01f,
  -2.54418980e-02f, -1.86084718e-01f, -7.29897618e-02f, -9.74194854e-02f, -8.53712484e-02f, -6.44460917e-02f, -3.31157833e-01f, -2.33060837e-01f, -1.47260621e-01f, -1.93049178e-01f,
  -8.46797302e-02f, 7.03176558e-02f, 1.45420521e-01f, 7.86031112e-02f, -1.52905071e-02f, -6.28144443e-02f, 2.89889635e-04f, -7.10854158e-02f, -8.62690359e-02f, -4.36789781e-01f,
  -1.33711681e-01f, 6.84846565e-02f, 5.10159694e-02f, -9.71484482e-02f, 5.59698530e-02f, 4.66702692e-02f, -1.04110576e-02f, 4.12602313e-02f, 1.91420019e-01f, -1.12842796e-02f,
  1.23343132e-01f, 3.75398062e-02f, -6.97403622e-04f, 1.79032553e-02f, -4.09621149e-02f, 7.73760751e-02f, 1.18377209e-01f, -5.02576865e-03f, 8.39486793e-02f, 5.38916811e-02f,
  2.47292798e-02f, 1.38918325e-01f, -1.27815232e-01f, -6.55517206e-02f, 5.73644452e-02f, 8.22454020e-02f, -5.86907454e-02f, -5.64919487e-02f, -3.65507752e-02f, 9.01544020e-02f,
  -4.08681631e-01f, 3.37341040e-01f, -3.94640826e-02f, -9.98312905e-02f, 7.26746023e-02f, -1.87679604e-02f, 1.97596550e-01f, -2.03873683e-02f, 7.60425581e-03f, 8.99297446e-02f,
  5.57815023e-02f, -1.83626600e-02f, 7.42734522e-02f, 6.30939379e-02f, 2.18038894e-02f, 7.15744449e-03f, 1.94483057e-01f, 1.45148188e-01f, -6.19559027e-02f, -6.62479773e-02f,
  6.84350058e-02f, 1.65413305e-01f, 4.86544333e-02f, 1.12671077e-01f, 8.61756131e-02f, 4.50356491e-02f, -4.15873528e-02f, -1.52754756e-02f, 1.00980669e-01f, 2.63366802e-03f,
  1.00608373e+00f, 3.46373796e-01f, 4.88022447e-01f, 2.85024494e-01f, 2.31697470e-01f, 4.27818090e-01f, 5.08439064e-01f, 3.18378925e-01f, -6.97252750e-02f, 7.55186528e-02f,
  -1.60475239e-01f, -4.61131334e-01f, -5.72919786e-01f, -5.37916362e-01f, -2.58278102e-01f, 6.04567453e-02f, 5.64197004e-02f, 1.46465614e-01f, 1.43875480e-01f, 2.02905610e-01f,
  -1.45448461e-01f, 3.05745214e-01f, 4.96327132e-01f, 2.71619335e-02f, -2.16635123e-01f, -3.50595325e-01f, 3.82428654e-02f, 9.02310237e-02f, -5.34491427e-02f, -1.70918480e-01f,
  -1.43274918e-01f, 4.96004611e-01f, -4.98447180e-01f, -3.92195046e-01f, -1.22299701e-01f, 3.18166129e-02f, 2.78008729e-02f, 1.57858938e-01f, -2.45016348e-02f, 1.04684263e-01f,
  -1.04290359e-01f, -2.64327601e-02f, 7.53608346e-02f, 8.25946182e-02f, 1.64735153e-01f, 1.06184550e-01f, 7.13182390e-02f, 9.63644907e-02f, -1.88660190e-01f, -1.54419646e-01f,
  -2.69363195e-01f, 2.68608183e-01f, 1.51869491e-01f, 1.19396010e-02f, -6.61619604e-02f, -2.66889691e-01f, 2.50511449e-02f, -4.55135852e-02f, -6.14005961e-02f, 9.99982134e-02f,
  -1.00640424e-01f, -9.20974538e-02f, -1.10223040e-01f, 8.37473124e-02f, 5.03195822e-02f, 1.23203605e-01f, 1.11279249e-01f, -1.06730564e-02f, 5.77392727e-02f, 1.29605427e-01f,
  -1.71068867e-04f, 8.69267210e-02f, 2.06804976e-01f, 2.06366882e-01f, -1.57814130e-01f, 8.71648118e-02f, 9.40908939e-02f, 1.30085798e-03f, -5.43719530e-02f, 8.99897069e-02f,
  2.02297136e-01f, 1.67205423e-01f, 1.59775048e-01f, 1.40471667e-01f, 1.29986480e-01f, 1.38957333e-02f, 5.27923107e-02f, -4.87838537e-02f, 2.99120825e-02f, 1.07656233e-01f,
  -5.57376519e-02f, -1.83197305e-01f, -2.02009276e-01f, -1.43191129e-01f, 5.29405437e-02f, 1.71171804e-03f, -2.58575678e-01f, -1.42917842e-01f, -1.30328313e-01f, -5.62274531e-02f,
  -1.39247969e-01f, -3.14349905e-02f, 5.88696217e-03f, 1.04854494e-01f, 2.26706088e-01f, 7.78735951e-02f, -8.91050398e-02f, 6.83722571e-02f, -1.55498713e-01f, -5.22415005e-02f,
  -5.87376766e-02f, 1.19985454e-01f, 2.12789148e-01f, -7.51936659e-02f, -7.10589141e-02f, -8.49990174e-02f, 8.13805833e-02f, -1.30503150e-02f, 8.80399197e-02f, 2.52215862e-01f,
  -1.08078972e-01f, 3.38981867e-01f, 1.66201085e-01f, 4.30871040e-01f, 4.35517430e-01f, 1.50604159e-01f, 2.32649654e-01f, 2.42852643e-02f, 1.81940302e-01f, 2.19847471e-01f,
  1.84492826e-01f, 2.13165164e-01f, 1.87852740e-01f, 2.13314474e-01f, 4.39558662e-02f, 3.95109296e-01f, 4.15637106e-01f, 7.51517043e-02f, 5.24601303e-02f, 2.25755021e-01f,
  2.60899484e-01f, 1.41081676e-01f, -8.34269971e-02f, 1.15628190e-01f, 4.39690948e-01f, 2.29441747e-01f, 1.27857059e-01f, 2.83145398e-01f, 3.24142903e-01f, 8.07729065e-01f,
  5.42849839e-01f, -7.16784643e-03f, -2.19657086e-02f, -1.25419304e-01f, -2.48441007e-02f, -2.69411683e-01f, -5.55064529e-02f, -1.19594984e-01f, -1.26937971e-01f, 1.93496868e-02f,
  -5.61837107e-03f, -3.95351723e-02f, 4.48694602e-02f, -9.05804485e-02f, -1.36829242e-01f, -2.04822659e-01f, -1.74597114e-01f, 7.87702203e-03f, 7.80612305e-02f, 1.62249282e-01f,
  1.79758534e-01f, 1.33370176e-01f, 1.62615716e-01f, -6.99166358e-02f, -1.03207275e-01f, -1.00063927e-01f, -1.49225801e-01f, 4.44646515e-02f, -1.86582610e-01f, -8.57593268e-02f,
  5.07781386e-01f, 1.65354699e-01f, 1.92607909e-01f, 2.86524057e-01f, -5.31936064e-02f, -1.46735340e-01f, 6.87620491e-02f, 7.64709339e-02f, -2.61840355e-02f, -4.19828556e-02f,
  3.77430655e-02f, 1.31282791e-01f, -4.54393812e-02f, 6.25468642e-02f, 7.76948929e-02f, 2.79709935e-01f, 1.86266825e-01f, 2.55144201e-02f, -9.82543677e-02f, 3.77277993e-02f,
  -1.67707149e-02f, 7.34923556e-02f, -2.51880884e-01f, -3.74846719e-02f, -2.50405679e-03f, 9.24920291e-02f, 9.61059406e-02f, -3.42016704e-02f, -4.60979044e-02f, 3.34566049e-02f,
  1.08220473e-01f, -2.82533288e-01f, 3.19268078e-01f, 2.83108383e-01f, -3.42696469e-04f, -2.28327274e-01f, 2.49140725e-01f, -1.33016026e-02f, 9.63883698e-02f, -5.79268076e-02f,
  -5.42354435e-02f, 8.60704761e-03f, -2.36455407e-02f, -1.05069019e-01f, -2.17291594e-01f, -1.34618059e-01f, 1.27296627e-01f, 2.54593343e-01f, 2.24723238e-02f, 1.02418631e-01f,
  -4.44247574e-02f, -2.75327861e-02f, 1.72086969e-01f, 2.34608906e-05f, -8.74997228e-02f, -9.27503034e-02f, -2.25134879e-01f, -1.63152575e-01f, -2.26621166e-01f, -2.75334090e-01f,
  5.64314723e-01f, 8.30195174e-02f, -8.15487564e-01f, 6.18618190e-01f, -1.68305337e-01f, -6.22062624e-01f, -7.38367200e-01f, -3.06434393e-01f, 5.12500525e-01f, 1.50776058e-01f,
  3.77271883e-02f, -2.93030739e-01f, -3.51394743e-01f, -7.48257756e-01f, -1.29457664e+00f, -7.17748940e-01f, -6.00926399e-01f, -1.00088298e+00f, -1.22531807e+00f, -7.56399095e-01f,
  -2.70248950e-01f, -2.48314701e-02f, -4.09992725e-01f, -4.29781795e-01f, 6.14818573e-01f, 1.94040045e-01f, 1.93331942e-01f, 5.73870800e-02f, -4.80265856e-01f, 2.84327239e-01f,
  -6.57106578e-01f, -7.76242688e-02f, -3.36503655e-01f, -1.34257555e-01f, 2.42876664e-01f, 5.27021177e-02f, -3.68312687e-01f, 1.30493000e-01f, 2.83396970e-02f, -8.23482275e-02f,
  -1.11497588e-01f, -1.02116942e-01f, -1.62449002e-01f, -1.16228856e-01f, -1.64656118e-01f, -3.86871308e-01f, -8.54179636e-03f, -5.12274265e-01f, -2.96738654e-01f, -3.56618196e-01f,
  3.12377419e-02f, -3.53440642e-01f, -3.68902445e-01f, -8.23183879e-02f, -3.76772612e-01f, 6.80887774e-02f, -9.94991288e-02f, -3.22065093e-02f, -2.08990827e-01f, 4.28205818e-01f,
  3.03712003e-02f, -6.71126274e-03f, 5.36035821e-02f, -4.29273471e-02f, 1.61954001e-01f, 2.46889532e-01f, 1.32901790e-02f, -1.30855903e-01f, -4.40529659e-02f, -1.37162488e-02f,
  -6.94462731e-02f, 8.82558078e-02f, -1.48045942e-01f, -9.17130336e-02f, -9.91677791e-02f, -4.63419333e-02f, 7.29146451e-02f, -7.05247000e-02f, -1.63866028e-01f, 1.49197638e-01f,
  -1.85142666e-01f, -4.51140385e-03f, 1.26912504e-01f, -1.50210798e-01f, -1.87881693e-01f, -3.41238081e-02f, -1.04193106e-01f, -2.12783948e-01f, 3.63675803e-02f, 6.62856326e-02f,
  4.71999168e-01f, -5.19783020e-01f, 1.42357767e-01f, -4.09882545e-01f, -1.11799672e-01f, 8.76469687e-02f, 1.94433287e-01f, -1.76948612e-03f, 2.40694344e-01f, -3.84541601e-02f,
  -4.40495193e-01f, -3.18268947e-02f, 4.48637865e-02f, 1.35368690e-01f, -3.51152003e-01f, -1.51575014e-01f, 1.18715758e-03f, 1.33781493e-01f, -4.05248493e-01f, 2.08865032e-01f,
  2.03867137e-01f, -1.18337452e-01f, 7.23893344e-02f, 1.64334297e-01f, -1.10045113e-01f, -1.19631484e-01f, -1.09121136e-01f, -1.34858057e-01f, -4.20438617e-01f, 2.98103422e-01f,
  -5.11227369e-01f, -8.49036098e-01f, 7.29917586e-01f, -3.89378190e-01f, 3.71402383e-01f, 5.37900031e-01f, 5.90945601e-01f, 1.36071682e-01f, -3.81573409e-01f, 1.11754686e-01f,
  -3.44049603e-01f, -4.99717414e-01f, -4.60897416e-01f, -2.59109646e-01f, -2.83135474e-01f, 3.38214487e-01f, 3.65266353e-01f, 2.46226311e-01f, 6.14633143e-01f, 3.88962030e-01f,
  -9.20162871e-02f, -2.73863375e-01f, -4.14414257e-01f, -1.59143180e-01f, -1.82441831e-01f, 2.27645990e-02f, -6.79652169e-02f, -2.52716452e-01f, -1.41958818e-01f, -3.63734931e-01f,
  5.46547294e-01f, -4.53410268e-01f, 2.97844529e-01f, -3.88662517e-01f, -7.65462071e-02f, -2.51894742e-01f, 4.75616939e-02f, -1.80548340e-01f, -1.14307605e-01f, 1.46884263e-01f,
  -1.82446048e-01f, -8.74135494e-02f, -3.94759998e-02f, -1.06947329e-02f, -3.48280482e-02f, -3.86066781e-03f, -2.84123689e-01f, -2.52050191e-01f, -2.85218596e-01f, -9.10133049e-02f,
  -2.13044807e-01f, 7.11172894e-02f, 7.31449351e-02f, -1.47010684e-02f, -1.20570496e-01f, 2.39966419e-02f, 8.49432033e-03f, -6.44583851e-02f, 1.40805478e-05f, 3.26898731e-02f,
  5.27202897e-02f, 9.09736007e-02f, -1.13646120e-01f, -2.44949814e-02f, 3.65258083e-02f, 2.12504506e-01f, 7.33040497e-02f, -1.55288391e-02f, -3.31966132e-02f, 2.65975613e-02f,
  -2.71331705e-02f, 1.18782772e-02f, -9.81796011e-02f, 1.61152110e-02f, -1.31687626e-01f, -1.14085935e-01f, 4.40943893e-03f, -1.14678696e-01f, -1.51847795e-01f, -1.21291615e-01f,
  -1.58824340e-01f, -6.45227879e-02f, 2.45652609e-02f, -1.50711641e-01f, -1.07035086e-01f, -5.12151904e-02f, -8.37411657e-02f, -6.49187565e-02f, -4.46467511e-02f, -6.39725849e-02f,
  1.24360569e-01f, -2.03299329e-01f, 1.94124252e-01f, -2.35491544e-01f, -8.55263509e-03f, -1.30473375e-01f, -1.81543142e-01f, -1.39661998e-01f, -6.14647940e-02f, 3.26634683e-02f,
  -1.23267658e-01f, -1.46030888e-01f, -7.49683306e-02f, 1.05425129e-02f, 2.22386941e-01f, 1.16436467e-01f, -2.93484211e-01f, -3.68866548e-02f, -1.40438870e-01f, -2.86726514e-03f,
  -2.80891992e-02f, 2.48050719e-01f, 3.46233934e-01f, 1.63255438e-01f, -2.56876107e-02f, 3.41753662e-01f, 3.13201129e-01f, 2.29875192e-01f, 2.44872928e-01f, 4.33677316e-01f,
  2.24368632e-01f, 5.48862340e-03f, 8.78395021e-01f, -9.70257297e-02f, -3.46557528e-01f, -4.62188005e-01f, -4.84231561e-01f, -4.21644032e-01f, -3.98283750e-01f, -2.03487903e-01f,
  -3.30357760e-01f, -1.77972987e-01f, 5.99201582e-02f, -1.14807747e-02f, 4.10123803e-02f, -5.98326251e-02f, 2.07518667e-01f, 5.28337300e-01f, 2.63297141e-01f, -1.37550667e-01f,
  -2.28699744e-01f, 1.62603050e-01f, 4.38379794e-01f, 2.57814765e-01f, 1.02781266e-01f, -6.55765310e-02f, 2.42546380e-01f, 1.84800074e-01f, -1.00499280e-01f, 3.44049156e-01f,
  7.53934681e-01f, -2.94241440e-02f, -1.24337777e-01f, -1.34184301e-01f, 1.00153729e-01f, -1.27938390e-02f, 1.06296420e-01f, 5.70531525e-02f, -1.85796440e-01f, -1.19085215e-01f,
  -6.06151149e-02f, 3.97109147e-03f, 6.54463395e-02f, -7.87680224e-02f, 3.50398719e-02f, 4.00638767e-02f, 7.30189458e-02f, 7.89718404e-02f, -9.66094285e-02f, 5.34829274e-02f,
  -2.35983819e-01f, -4.77092192e-02f, 8.52507204e-02f, -1.40343279e-01f, -1.50468618e-01f, -4.66124639e-02f, 4.44784164e-02f, -5.69506101e-02f, -1.23499416e-01f, -7.15901479e-02f,
  -9.00335833e-02f, 1.07884154e-01f, 1.30921258e-02f, -8.15117210e-02f, -2.00078025e-01f, -1.92409575e-01f, -1.36837035e-01f, 1.23324082e-03f, -9.56122354e-02f, -1.19807441e-02f,
  -1.43821359e-01f, -1.71446621e-01f, -1.43585987e-02f, -5.81831113e-02f, -4.86875232e-03f, 4.40750755e-02f, -7.26371557e-02f, -5.78542538e-02f, 4.13818173e-02f, -1.02304697e-01f,
  -8.91467407e-02f, -2.37786360e-02f, 1.54142350e-01f, 1.21903904e-02f, -1.60420761e-01f, -3.20952795e-02f, -7.83079490e-03f, 4.02879566e-02f, 1.27397195e-01f, 5.52637540e-02f,
  4.47675474e-02f, 4.72945310e-02f, -1.19749159e-01f, 8.77142027e-02f, 1.32657051e-01f, 2.09621415e-02f, 1.20970562e-01f, 2.79497318e-02f, -2.80895848e-02f, -9.81315002e-02f,
  1.60447806e-02f, 2.13807598e-01f, 1.77035958e-01f, 5.59269637e-02f, 1.14529775e-02f, -1.40157584e-02f, -1.55352667e-01f, -4.67092311e-03f, -1.91336438e-01f, 2.66090203e-02f,
  -5.64602204e-02f, -1.24699883e-01f, -1.05975300e-01f, -8.90575573e-02f, -1.12134919e-01f, -6.14847429e-02f, 1.12055570e-01f, -1.03668161e-02f, 1.10586680e-01f, -2.08427727e-01f,
  -9.03311849e-01f, -8.62268448e-01f, -5.34662724e-01f, -1.36437273e+00f, -6.62046313e-01f, 1.31366774e-01f, -5.00538610e-02f, -1.55743316e-01f, -5.84475517e-01f, -7.51466453e-01f,
  6.59661368e-02f, 4.49723005e-01f, -2.02532783e-01f, 2.61962175e-01f, 4.47435021e-01f, -5.16268134e-01f, -7.51964688e-01f, -9.43469107e-02f, 6.52738512e-01f, 5.28174102e-01f,
  -1.25290111e-01f, -6.24320328e-01f, -3.12146813e-01f, -2.82092392e-01f, -9.72250938e-01f, -3.29491615e-01f, -8.45309138e-01f, -5.27536571e-01f, 7.27131451e-03f, -9.90722060e-01f,
  -5.19680157e-02f, -4.27935570e-01f, 1.84485987e-01f, 8.13638717e-02f, -3.85076314e-01f, 2.20702171e-01f, 1.42818317e-01f, -3.01870972e-01f, 1.71047032e-01f, -1.93262160e-01f,
  -1.76592812e-01f, 1.38690844e-01f, 2.35161670e-02f, -3.67269432e-03f, -3.84672225e-01f, 1.29428804e-01f, -2.67024994e-01f, -1.31873503e-01f, -2.21889522e-02f, 2.07177922e-01f,
  1.03322398e-02f, 6.07516915e-02f, -2.06032749e-02f, 2.22183064e-01f, 4.19224948e-01f, 3.46636981e-01f, 1.36807576e-01f, 3.12868476e-01f, 1.95327148e-01f, -8.09554815e-01f,
  -2.27030441e-01f, -1.99151617e-02f, 1.27087444e-01f, 8.17751735e-02f, 1.48127794e-01f, 1.02059081e-01f, -2.30161427e-03f, -4.83539104e-02f, -1.25314035e-02f, -4.61645536e-02f,
  -6.42148480e-02f, -3.57838981e-02f, 1.08447246e-01f, -8.04546624e-02f, 4.18267474e-02f, -1.04650691e-01f, -2.15399619e-02f, -1.83238938e-01f, -3.44372727e-02f, -5.47368005e-02f,
  1.08629324e-01f, 4.11415845e-02f, -1.32005706e-01f, 1.20752871e-01f, 1.72321931e-01f, -2.37890169e-01f, -4.18507569e-02f, 1.14480637e-01f, -1.99450791e-01f, 4.68190387e-02f,
  -3.27703714e-01f, 4.86047000e-01f, -3.72692406e-01f, 1.02348313e-01f, -7.24233165e-02f, 1.46980599e-01f, -1.59896016e-01f, 2.33663008e-01f, -1.54932618e-01f, -1.24530636e-01f,
  1.54304445e-01f, 5.13048694e-02f, -1.94566399e-01f, -4.06900905e-02f, -1.64073333e-02f, 1.19837150e-01f, -1.22728765e-01f, -1.21950358e-01f, 1.03462830e-01f, -1.61519200e-01f,
  -1.87293783e-01f, 1.54824406e-02f, -3.01699173e-02f, 1.25351071e-01f, 1.37083247e-01f, 4.18625921e-01f, 3.61672901e-02f, 1.74864918e-01f, 4.22843814e-01f, -3.83986264e-01f,
  1.60519981e+00f, 4.78909075e-01f, -2.16955751e-01f, 2.53212929e-01f, -4.46349919e-01f, -1.50845543e-01f, 1.68454334e-01f, 3.14406633e-01f, 2.62269258e-01f, 2.21726120e-01f,
  4.80220048e-03f, 2.43717030e-01f, 3.03448826e-01f, 1.67374879e-01f, 3.86581063e-01f, 1.38616130e-01f, 2.39922069e-02f, 1.35503381e-01f, 8.13506842e-02f, -5.95895313e-02f,
  6.82059582e-03f, 1.28881738e-01f, 1.31364003e-01f, 2.06771150e-01f, -1.78156391e-01f, 4.87291217e-02f, -9.87409875e-02f, -4.72532928e-01f, -2.56851315e-01f, -1.61559537e-01f,
  -5.31471789e-01f, -1.39752239e-01f, 1.32229075e-01f, -8.05465207e-02f, -2.49041080e-01f, 2.71163017e-01f, 1.64720826e-02f, -8.19138885e-02f, -1.04242433e-02f, 2.52035819e-02f,
  -5.01043573e-02f, -8.26805681e-02f, -1.01035088e-01f, -3.21501903e-02f, -1.79770291e-01f, -6.07333295e-02f, -1.08013660e-01f, 9.03167948e-02f, 8.67471099e-03f, -1.90376770e-02f,
  -1.80892840e-01f, -2.15066865e-01f, -2.30710462e-01f, -1.88593529e-02f, -1.25474874e-02f, -7.36240894e-02f, -6.40755296e-02f, -4.69706804e-02f, -1.89699586e-02f, 1.39114127e-01f,
  -5.72862960e-02f, 2.46965587e-01f, -1.38712943e-01f, -5.32037020e-02f, 8.76393542e-02f, -8.72910842e-02f, -4.23413850e-02f, 8.47551078e-02f, 6.69599399e-02f, 8.90083164e-02f,
  1.58060957e-02f, -2.26358294e-01f, -7.97325571e-04f, -2.17357166e-02f, -4.98278439e-02f, -6.18863143e-02f, 2.19544806e-02f, -1.22272722e-01f, -2.92495638e-01f, -1.10050634e-01f,
  -1.28560454e-01f, 4.92262729e-02f, -1.05777927e-01f, -2.02021167e-01f, -2.60863096e-01f, -8.92573521e-02f, -8.92170705e-03f, 1.50085362e-02f, 1.41729966e-01f, 1.57988504e-01f,
  -2.98900679e-02f, -3.04526687e-01f, 2.02659667e-01f, 3.25271904e-01f, -8.38541687e-02f, 2.98959203e-02f, 3.72162950e-03f, -9.38655958e-02f, -2.58987397e-01f, -7.97127113e-02f,
  -1.74703211e-01f, 7.22007677e-02f, -1.05997041e-01f, 2.44471920e-03f, -3.61977443e-02f, -1.46733969e-01f, -5.69801852e-02f, 4.76058051e-02f, -2.38482300e-02f, -1.63717926e-01f,
  5.94854616e-02f, 1.41444415e-01f, 1.06313385e-01f, 1.79840162e-01f, 1.97480291e-01f, 2.58636475e-01f, -7.38575608e-02f, -9.65823047e-03f, 1.18881859e-01f, 2.65260786e-01f,
  -9.73274559e-02f, -9.24267113e-01f, 6.33517727e-02f, 2.96754837e-01f, 1.22151569e-01f, -7.97805861e-02f, -4.33038861e-01f, -1.04789115e-01f, 2.25890592e-01f, -2.48259127e-01f,
  -3.20259899e-01f, 2.64309078e-01f, 2.64505088e-01f, 3.05430204e-01f, 1.43108904e-01f, 1.13484591e-01f, 4.51939762e-01f, 4.80642825e-01f, 4.11850393e-01f, -5.01874872e-02f,
  -7.42799044e-02f, 7.35215284e-03f, -8.81559029e-03f, 1.37160346e-01f, -3.84110570e-01f, 1.59897909e-01f, 7.30941072e-02f, -1.18573897e-01f, -3.31698895e-01f, -3.39448899e-01f,
  -4.58177060e-01f, -2.11168215e-01f, 2.91830599e-01f, 8.02120790e-02f, -8.29571784e-02f, -1.48359284e-01f, 7.86567479e-02f, -5.19005209e-02f, -1.77165121e-01f, 3.57625373e-02f,
  6.98672980e-02f, -1.04903258e-01f, -3.36348824e-02f, -5.72545528e-02f, 3.93767580e-02f, -7.16852397e-02f, 9.51488689e-02f, -2.72469856e-02f, 7.32050613e-02f, -9.12414640e-02f,
  -1.28327170e-02f, 6.78123981e-02f, 1.38792872e-01f, 2.30368018e-01f, 2.68329650e-01f, 3.74786139e-01f, -5.90901040e-02f, 1.45106623e-02f, 2.64096230e-01f, -3.02106002e-03f,
  5.43973260e-02f, -7.83489496e-02f, 1.03916049e-01f, 8.60134810e-02f, 1.56509489e-01f, 1.52426332e-01f, -2.28546113e-02f, 7.19008371e-02f, 3.06376308e-01f, -2.42733713e-02f,
  -6.41281679e-02f, 2.59994745e-01f, 1.50388375e-01f, -9.67374668e-02f, 1.12966813e-01f, -1.39007822e-01f, -1.76162347e-01f, -6.91875890e-02f, 1.33758515e-01f, 3.75912674e-02f,
  8.65706578e-02f, -2.52590105e-02f, -1.06665596e-01f, -1.04057387e-01f, -8.05158913e-02f, 2.00453788e-01f, 9.57759172e-02f, 5.62050156e-02f, -2.37086043e-02f, -2.57287562e-01f,
  -3.49697262e-01f, 6.90667808e-01f, 1.19452765e-02f, -1.03139341e-01f, -9.21972394e-02f, -8.07292461e-02f, 9.83775128e-03f, -1.81286231e-01f, -2.18384415e-01f, 1.49182053e-02f,
  -7.80357197e-02f, -1.35342270e-01f, -1.26797214e-01f, 6.37927093e-03f, 2.14439094e-01f, 5.94753772e-02f, -1.88881066e-02f, -4.07181159e-02f, -5.25686592e-02f, -1.16035648e-01f,
  -1.25569567e-01f, 2.34328806e-01f, 1.54690161e-01f, 1.63720071e-01f, 1.08133920e-01f, 3.57284904e-01f, -9.11131501e-02f, -1.24241471e-01f, 1.13778546e-01f, 1.59075409e-01f,
  -3.93017381e-01f, 8.29914585e-02f, -5.22347689e-01f, -5.68134129e-01f, 1.89670518e-01f, 3.46949250e-01f, 1.95731238e-01f, 1.93502128e-01f, 1.15109757e-01f, -1.05612628e-01f,
  4.77550209e-01f, 3.97723280e-02f, -7.44702458e-01f, -5.73248267e-01f, -5.88055730e-01f, -6.29637539e-01f, -9.22911167e-01f, -7.76837528e-01f, -1.85816899e-01f, 8.13321352e-01f,
  2.74732977e-01f, -1.86578766e-01f, -2.16117337e-01f, -2.43231013e-01f, -1.58313259e-01f, -4.30118710e-01f, -6.30904555e-01f, -4.92589027e-01f, -4.33706015e-01f, -6.47572219e-01f,
  -6.37954772e-01f, -7.88275748e-02f, 2.35173911e-01f, 1.22376740e-01f, 3.38851884e-02f, -5.95101677e-02f, 2.47155011e-01f, -7.09570274e-02f, 2.20362917e-02f, -9.19197723e-02f,
  6.14461079e-02f, 2.10697547e-01f, -7.15844631e-02f, 2.20916700e-02f, 1.40999168e-01f, 5.99782094e-02f, 2.01574951e-01f, -1.41329646e-01f, -2.09572181e-01f, 2.85048962e-01f,
  4.20555115e-01f, -2.03875937e-02f, -6.37144804e-01f, -1.33074805e-01f, -2.09839121e-01f, -4.91890192e-01f, 7.98379332e-02f, 9.39475968e-02f, -4.76743639e-01f, -5.42603552e-01f,
  2.02116638e-01f, 1.71677291e-01f, 2.03290492e-01f, 1.51599705e-01f, 1.18624605e-01f, -5.49918041e-02f, -2.44081452e-01f, -3.31700891e-02f, 1.24014594e-01f, -4.64883558e-02f,
  -5.61157241e-02f, 1.72714405e-02f, -4.19020541e-02f, -2.58081764e-01f, -3.14906865e-01f, -2.22759582e-02f, -1.43697644e-02f, -1.41812220e-01f, -3.06431800e-01f, -2.79021353e-01f,
  -5.88032156e-02f, 7.10098743e-02f, 1.67637274e-01f, -1.00456655e-01f, 9.56494361e-02f, -1.19184010e-01f, 3.08701217e-01f, 5.49416423e-01f, 2.85880178e-01f, 1.19545005e-01f,
  -4.05491680e-01f, -7.90367723e-02f, -4.52486485e-01f, 6.58453256e-02f, -3.73331420e-02f, 6.88870400e-02f, -1.06089048e-01f, 2.79439479e-01f, -7.40305707e-02f, 1.72818094e-01f,
  2.53378183e-01f, -9.64598432e-02f, -1.84914201e-01f, -1.91123914e-02f, 1.90931082e-01f, -2.69862413e-01f, -1.11257054e-01f, -2.33529940e-01f, 1.44067436e-01f, 1.54204950e-01f,
  1.41407460e-01f, -5.02868116e-01f, -7.14161575e-01f, -7.24275529e-01f, -2.83466130e-01f, -6.72962785e-01f, -5.35465419e-01f, -2.42722496e-01f, -6.92524612e-01f, -1.00821400e+00f,
  -1.26938665e+00f, 3.14042121e-01f, 6.51736021e-01f, -2.72883862e-01f, -9.08072740e-02f, -1.97794959e-01f, -2.64124304e-01f, -3.09323430e-01f, -1.56416353e-02f, 7.29551120e-03f,
  -3.04981440e-01f, -4.40127254e-01f, 2.33829543e-01f, 2.77620941e-01f, -5.60508110e-02f, 7.89892316e-01f, 8.98801327e-01f, 3.24312717e-01f, -7.21896946e-01f, -1.15958655e+00f,
  -2.74205029e-01f, -4.48943734e-01f, -5.88937879e-01f, 4.30927686e-02f, 2.99263954e-01f, 7.58220404e-02f, 7.15663552e-01f, 2.23291684e-02f, 2.81451643e-01f, 6.77389741e-01f,
  -3.73635560e-01f, -2.67042428e-01f, -1.77247733e-01f, -4.18473721e-01f, 2.82145143e-02f, -6.92587271e-02f, -2.11115964e-02f, 2.08184406e-01f, 1.05524734e-01f, 1.51194483e-01f,
  -3.86008531e-01f, -1.36864586e-02f, -2.88510591e-01f, -1.65358901e-01f, -4.71351504e-01f, -3.88225943e-01f, 1.54614747e-01f, 4.24350500e-02f, 2.06862211e-01f, -4.06163186e-01f,
  -9.47466269e-02f, -5.44480383e-01f, -3.53589565e-01f, 3.90061587e-02f, 3.87438655e-01f, -2.41241828e-01f, -3.48524936e-02f, -1.98785082e-01f, -7.95023739e-02f, -2.94041008e-01f,
  1.29287928e-01f, 1.12433933e-01f, 2.01429531e-01f, 2.62835622e-01f, -1.16770238e-01f, 6.89483061e-02f, 2.69826919e-01f, -1.06681675e-01f, -5.67130372e-02f, -1.49707004e-01f,
  4.53382507e-02f, -1.61551461e-01f, 2.42718775e-02f, -5.25527745e-02f, 6.09710328e-02f, -3.65188830e-02f, -6.20297566e-02f, 2.03746289e-01f, 1.04065865e-01f, 3.57783437e-02f,
  4.55693305e-02f, -2.30053347e-02f, 2.03080460e-01f, 2.64676549e-02f, 4.40687031e-01f, 2.93635368e-01f, 2.39690579e-02f, -1.31556258e-01f, 6.52390940e-04f, -4.23626751e-02f,
  -4.40056980e-01f, 5.15043616e-01f, -3.00966024e-01f, 2.00615656e-02f, 2.84940191e-02f, 9.51089934e-02f, 3.63004327e-01f, 1.87919825e-01f, 1.12655394e-01f, -4.54181105e-01f,
  -3.19988608e-01f, -1.49107605e-01f, 1.48760632e-01f, 1.43873647e-01f, -5.09513140e-01f, -1.66307285e-01f, -2.94295847e-01f, -1.32540166e-01f, -2.30679259e-01f, -1.18242994e-01f,
  6.03514910e-02f, -7.38027155e-01f, -1.01107526e+00f, -4.25834209e-01f, -3.32804590e-01f, -6.86178565e-01f, -2.73576915e-01f, -5.17236471e-01f, -4.33053702e-01f, -7.67749310e-01f,
  1.42380610e-01f, -2.81559259e-01f, -1.92389935e-01f, 1.74465567e-01f, -3.46437037e-01f, -6.78419113e-01f, -8.49805772e-01f, -5.58687568e-01f, -3.45642149e-01f, -3.46591949e-01f,
  -4.72857714e-01f, -3.46776024e-02f, 2.23988518e-02f, 3.06446224e-01f, 1.00373067e-01f, 2.02184590e-03f, 5.99907875e-01f, 8.25708508e-01f, 4.75257874e-01f, 4.06745672e-01f,
  2.73843229e-01f, 4.25381660e-01f, 6.10124946e-01f, 4.61101472e-01f, 4.70591217e-01f, 2.24104002e-01f, 7.08098188e-02f, 2.10002989e-01f, -7.73892878e-03f, 7.47028947e-01f,
  -1.10824099e-02f, -3.02350909e-01f, -2.06020087e-01f, 1.47596508e-01f, -1.93029363e-03f, 2.05705389e-01f, -1.16268598e-01f, 4.11274344e-01f, -5.97546250e-03f, 6.40285388e-02f,
  -2.93433741e-02f, -4.97856028e-02f, 3.47736664e-02f, 6.99982122e-02f, -1.80219457e-01f, -3.25998068e-01f, 2.20615998e-01f, 2.37539187e-01f, -4.89398576e-02f, -1.20069727e-01f,
  3.61691475e-01f, 9.03307647e-03f, -3.13472629e-01f, -5.04971147e-01f, -3.87515903e-01f, 1.99582785e-01f, -1.99039787e-01f, 2.54547335e-02f, -3.36939603e-01f, 2.24669307e-01f,
  -6.38044551e-02f, -1.43075157e-02f, -1.49167776e-01f, 2.27911025e-02f, 2.71151036e-01f, 5.39223664e-03f, 1.69128686e-01f, 1.18346758e-01f, 3.19064967e-03f, 1.65249601e-01f,
  1.00638252e-02f, 6.36809841e-02f, 1.65184915e-01f, 1.28520029e-02f, -9.80741531e-03f, -1.13764197e-01f, 7.81393796e-02f, 9.90069509e-02f, -1.21725043e-02f, -2.58133978e-01f,
  -1.48199230e-01f, -5.03472844e-03f, 1.74489796e-01f, 3.10278207e-01f, -1.28598064e-01f, 7.16606562e-04f, -7.56935915e-03f, -6.46525323e-02f, 1.27373204e-01f, -5.50760701e-02f,
  -5.15874386e-01f, -3.91096920e-01f, -1.77160725e-01f, 5.49924858e-02f, -1.85150191e-01f, -3.54126655e-02f, -2.54940782e-02f, -1.04056738e-01f, -2.23628446e-01f, 1.21693723e-01f,
  -1.43154755e-01f, 1.21940531e-01f, -3.56973082e-01f, -5.88285774e-02f, -2.15809271e-02f, -4.03121173e-01f, -1.02370344e-01f, -4.50008027e-02f, -9.92075503e-02f, 1.10991813e-01f,
  1.75721541e-01f, -3.86328131e-01f, -2.58330703e-01f, -6.25316858e-01f, -6.07816875e-01f, -2.79515147e-01f, -7.39476606e-02f, -2.55202800e-01f, -8.16260576e-01f, -5.08730769e-01f,
  7.76077032e-01f, 3.27201754e-01f, -5.74225843e-01f, 3.44696462e-01f, -5.87508559e-01f, -8.83274794e-01f, -4.48841751e-01f, -1.64591700e-01f, 8.92280042e-02f, -5.73422350e-02f,
  -9.59518403e-02f, 9.65495929e-02f, 5.11570573e-01f, -2.56649163e-02f, -1.76191963e-02f, -1.12440914e-01f, -2.03260884e-01f, -1.74648985e-01f, -6.52745306e-01f, -7.52226353e-01f,
  -2.67087579e-01f, 1.18783660e-01f, 1.22253142e-01f, -1.64644420e-01f, -1.59286499e-01f, 3.06361113e-02f, -5.13090705e-03f, -3.42342764e-01f, -6.95626557e-01f, -3.88701499e-01f,
  1.84208900e-02f, -6.52313590e-01f, -1.10010758e-01f, -3.09793837e-02f, 2.20200986e-01f, 2.71815330e-01f, 4.95812669e-02f, 5.32268547e-02f, 2.50824273e-01f, 9.45253149e-02f,
  -1.35176867e-01f, -1.11347839e-01f, -6.15825020e-02f, 1.20222718e-02f, -1.34071648e-01f, -1.17421329e-01f, -1.14206858e-01f, -1.91387936e-01f, 1.49978967e-02f, -1.11541510e-01f,
  -2.45076373e-01f, -5.01041591e-01f, 4.73835841e-02f, -1.03028873e-02f, -1.27759144e-01f, -1.98595688e-01f, -2.87286848e-01f, -4.68530446e-01f, -3.36647004e-01f, -9.61634964e-02f,
  -7.40002319e-02f, 2.37592921e-01f, 7.37257674e-02f, 1.85342297e-01f, 3.18163216e-01f, 1.87964216e-01f, 2.42955431e-01f, -4.99623157e-02f, -4.50865738e-02f, 1.41784877e-01f,
  3.13507169e-02f, 4.36365195e-02f, 1.52584668e-02f, 2.00637326e-01f, -6.64467216e-02f, -1.79441005e-01f, 1.15142937e-03f, 1.87471688e-01f, -8.40579867e-02f, 2.17549488e-01f,
  1.70214057e-01f, -2.13867482e-02f, 5.39423563e-02f, -3.91159265e-04f, -1.60235032e-01f, -3.22526619e-02f, 1.10623734e-02f, 2.89459191e-02f, 4.48929891e-02f, -1.77332938e-01f,
  7.89374828e-01f, -3.23016584e-01f, 4.81343269e-01f, -2.98499577e-02f, 3.21885087e-02f, -5.77782020e-02f, 2.06723332e-01f, 1.92316815e-01f, 1.83663666e-01f, 1.03772983e-01f,
  -2.33735383e-01f, -6.03545718e-02f, 6.80484169e-04f, -4.27112021e-02f, -4.82873134e-02f, -8.34905878e-02f, -3.52204069e-02f, -5.83802238e-02f, -4.95684966e-02f, -1.63677186e-02f,
  1.59195941e-02f, 9.51483175e-02f, 5.76920092e-01f, 5.38645029e-01f, 1.03178225e-01f, 1.94942340e-01f, 3.97960663e-01f, 4.54777777e-02f, 1.40132621e-01f, 7.81503677e-01f,
  -6.80085361e-01f, 9.67485458e-02f, -1.03842556e+00f, 4.47823644e-01f, 6.83171690e-01f, -5.14928341e-01f, -8.90904248e-01f, -6.38204515e-01f, 6.27410948e-01f, 3.33003551e-01f,
  6.80228949e-01f, 5.31853437e-01f, 3.10685724e-01f, -1.32007539e-01f, -8.13651919e-01f, -4.06733543e-01f, -2.40997806e-01f, -8.43149900e-01f, -5.99463105e-01f, -9.08157825e-02f,
  6.74608707e-01f, 2.77606487e-01f, -3.55366200e-01f, -2.34134659e-01f, 7.68176854e-01f, 5.26578009e-01f, 2.79266864e-01f, 3.49833786e-01f, -7.09631713e-03f, 4.37959939e-01f,
  -6.66865474e-03f, -2.53597885e-01f, -1.15292393e-01f, 2.19152153e-01f, 3.62362564e-01f, -2.32521653e-01f, -2.71448821e-01f, -1.97344765e-01f, 1.79954935e-02f, -4.92151976e-02f,
  4.89388943e-01f, 1.39119118e-01f, 2.11555913e-01f, 1.40807346e-01f, 2.23922413e-02f, -3.85067701e-01f, -3.93819988e-01f, -8.37318420e-01f, -7.42993593e-01f, -5.22694886e-01f,
  7.15587258e-01f, 2.70817637e-01f, -6.17958188e-01f, -4.52513129e-01f, -5.00124872e-01f, 1.29321709e-01f, -3.71177375e-01f, -1.52624428e-01f, -8.94652247e-01f, -2.93614358e-01f,
  -9.46779773e-02f, -7.73375332e-02f, -4.73882221e-02f, -6.73014894e-02f, 1.48139909e-01f, 8.00487250e-02f, 1.86485007e-01f, 9.49375406e-02f, 4.71584499e-02f, 6.48917444e-03f,
  -7.76357800e-02f, -6.53667152e-02f, -1.17576934e-01f, -3.88764851e-02f, 1.14353292e-01f, -5.92749268e-02f, 4.58511487e-02f, -5.51945716e-02f, -2.01600075e-01f, -3.72642428e-02f,
  -4.05437760e-02f, 4.33690213e-02f, 3.29286575e-01f, -1.18288398e-01f, 1.07031381e-02f, -7.24639967e-02f, 5.97839132e-02f, 1.47052437e-01f, -1.54485196e-01f, 1.09328352e-01f,
  5.82614362e-01f, -2.73682058e-01f, 2.94816822e-01f, -2.18569636e-01f, 9.91543755e-02f, 1.64975330e-01f, 1.88419953e-01f, -1.31941736e-01f, 5.02586253e-02f, -3.26820940e-01f,
  -1.28333867e-01f, -2.81751305e-01f, 6.97351247e-02f, -1.10346727e-01f, -1.02096766e-01f, 1.02546886e-01f, 1.08888708e-01f, -8.11617635e-03f, -7.49751413e-03f, 3.26470345e-01f,
  1.96705714e-01f, -2.13909432e-01f, -2.35054240e-01f, -2.16419056e-01f, 3.63926798e-01f, 1.94848567e-01f, -1.61615759e-02f, 6.38689250e-02f, -5.66081345e-01f, -2.41665125e-01f,
  -1.07610822e+00f, 7.51632214e-01f, 9.74044859e-01f, -7.23722577e-01f, -8.83662030e-02f, 2.40616426e-01f, 4.89572316e-01f, -2.37770215e-01f, -5.92584491e-01f, 1.62677959e-01f,
  5.72562814e-01f, -4.96230721e-02f, 1.45652115e-01f, 1.46812052e-01f, 2.10754141e-01f, 3.05636704e-01f, -4.86965552e-02f, -5.10272756e-02f, -1.40329987e-01f, -3.47374529e-01f,
  -3.76567513e-01f, -3.89869213e-01f, -4.94190931e-01f, -1.92643732e-01f, -6.68048561e-02f, -2.73588955e-01f, 5.54559648e-01f, 2.08426639e-01f, 3.10817033e-01f, -3.22236687e-01f,
  3.96065265e-01f, -6.96974546e-02f, -1.39673486e-01f, -2.87267029e-01f, 2.65422285e-01f, -3.29588652e-01f, -5.47153801e-02f, -5.49257249e-02f, -1.37714297e-01f, -9.15058181e-02f,
  1.99666694e-01f, -5.02161048e-02f, 5.58227971e-02f, 2.61615440e-02f, -1.48833394e-01f, -5.79579845e-02f, -3.99644561e-02f, -8.31399411e-02f, 1.03011623e-01f, 2.97040969e-01f,
  1.11267701e-01f, 1.27334163e-01f, 4.77425218e-01f, 2.63527483e-01f, 1.37154326e-01f, -1.27792493e-01f, 3.57030392e-01f, -1.64853439e-01f, 1.13303192e-01f, -2.08771497e-01f,
  -1.82767525e-01f, 1.33331018e-02f, 9.72640216e-02f, -8.41638446e-02f, 5.55595057e-03f, 3.62733826e-02f, 1.84114501e-02f, 6.42862245e-02f, 6.70764744e-02f, 1.04090497e-02f,
  6.85495883e-02f, 3.59800085e-02f, 1.67185888e-02f, 4.19036765e-03f, -9.97500122e-02f, 7.97004029e-02f, -7.91192241e-03f, -6.21806569e-02f, 1.63715910e-02f, -5.69674671e-02f,
  -1.29051581e-01f, 1.57983489e-02f, -6.53827563e-02f, 1.54975113e-02f, -1.01639189e-01f, -1.43026397e-01f, -1.47553161e-01f, -5.75951813e-03f, -4.85455357e-02f, -1.07133843e-01f,
  1.93898305e-01f, 3.37822884e-01f, -9.80950817e-02f, -1.56621277e-01f, -4.82926555e-02f, 4.46175970e-02f, -7.91250989e-02f, -8.90296474e-02f, 2.31202301e-02f, -1.00655459e-01f,
  1.30235747e-01f, -1.30911440e-01f, 1.45401642e-01f, -1.02576368e-01f, -1.85589880e-01f, -2.41644233e-01f, -1.40639141e-01f, 2.54642889e-02f, 1.22566417e-01f, 2.76929922e-02f,
  -7.71096647e-02f, -2.40536854e-01f, -2.00028881e-01f, -1.58854738e-01f, -1.83171570e-01f, -3.70991528e-01f, 2.19902962e-01f, -1.45730123e-01f, 9.96458307e-02f, -3.24095428e-01f,
  6.14658408e-02f, 4.22663450e-01f, -1.38323426e+00f, -7.48260796e-01f, -9.62208509e-01f, -5.90996802e-01f, 4.23314780e-01f, 4.44541760e-02f, -4.24387157e-01f, 1.50570676e-01f,
  2.45348603e-01f, 1.51146561e-01f, 6.28021210e-02f, 2.69826174e-01f, 8.82238925e-01f, 3.46556455e-01f, -2.70887524e-01f, -2.07367927e-01f, -1.30456641e-01f, 1.58054426e-01f,
  3.05954576e-01f, -3.87394018e-02f, 3.11826896e-02f, -1.14940502e-01f, -5.92577994e-01f, -3.74181300e-01f, -6.76165760e-01f, -5.63705444e-01f, 2.67364644e-02f, -5.47454119e-01f,
  -1.79286301e-01f, -7.66611457e-01f, -1.72910139e-01f, 1.52469188e-01f, -1.18243225e-01f, 9.27225947e-02f, 4.89838272e-02f, -2.54915267e-01f, 3.29667814e-02f, -1.68326512e-01f,
  -3.80902022e-01f, -1.01470470e-01f, -7.58256912e-02f, -1.30394593e-01f, -3.51163745e-01f, -1.41521960e-01f, -7.45736016e-03f, -1.99312940e-01f, 4.43238430e-02f, -7.21851811e-02f,
  2.06919149e-01f, -1.27989724e-01f, -4.18130308e-01f, -1.04300469e-01f, -1.35202900e-01f, -3.19551170e-01f, -3.49306643e-01f, -4.09058809e-01f, -3.84065747e-01f, 5.45352921e-02f,
  1.14910841e-01f, -1.13296382e-01f, 1.23456968e-02f, -4.51087914e-02f, 3.06717634e-01f, -3.43181416e-02f, -7.22821057e-02f, 2.09385782e-01f, -8.91302247e-03f, 1.13012806e-01f,
  -9.81541947e-02f, 8.29931058e-04f, -3.57466154e-02f, 3.75015400e-02f, -1.28417537e-01f, -6.40558451e-02f, 9.46802944e-02f, 2.28191301e-01f, 1.11043140e-01f, 1.80489998e-02f,
  7.22376481e-02f, -2.24096850e-02f, -1.59934521e-01f, 2.54306465e-01f, -1.18500866e-01f, 4.68119867e-02f, -8.49451125e-03f, 1.19773664e-01f, 6.03176951e-02f, -1.12956010e-01f,
  6.71696126e-01f, 3.19316268e-01f, 2.01296419e-01f, 1.38993129e-01f, -1.59388006e-01f, -1.35256901e-01f, 1.86988991e-02f, 1.95437551e-01f, -1.92829236e-01f, -1.57834366e-01f,
  -1.09722748e-01f, -6.33006766e-02f, -1.30572438e-01f, 6.81121573e-02f, 7.75813162e-02f, -8.94988701e-02f, 4.37173545e-01f, -2.14594230e-02f, 5.90100996e-02f, -1.06627673e-01f,
  3.19792241e-01f, 3.44144166e-01f, 3.75010759e-01f, 1.24883823e-01f, 3.06135900e-02f, 6.27249479e-02f, 1.33638620e-01f, 1.89044207e-01f, 3.55817378e-01f, 7.81705141e-01f,
  8.97415400e-01f, -1.15545249e+00f, -3.75849396e-01f, 3.62673283e-01f, 3.09705455e-02f, -3.15887004e-01f, -1.17852020e+00f, -1.94002807e-01f, 2.52505094e-01f, -7.86345184e-01f,
  3.90185751e-02f, 1.07593906e+00f, 6.10280097e-01f, 6.01453543e-01f, 3.48396391e-01f, -1.01676464e+00f, -7.13723540e-01f, 4.65041459e-01f, 8.75036061e-01f, 2.22073153e-01f,
  -1.31957799e-01f, -3.86210047e-02f, 3.81270587e-01f, 1.82245165e-01f, -4.59617734e-01f, 4.47486453e-02f, -8.54825258e-01f, -2.54030645e-01f, -3.79506886e-01f, -6.92743003e-01f,
  6.60998002e-02f, -2.27459162e-01f, 5.80630183e-01f, 4.23389763e-01f, 7.15278238e-02f, -2.19264150e-01f, -7.34488219e-02f, -1.09642357e-01f, -1.40997590e-02f, -2.27766395e-01f,
  1.78911284e-01f, 1.75412491e-01f, 2.66466826e-01f, -9.91264582e-02f, -1.87540978e-01f, -2.13942930e-01f, -1.93737045e-01f, -4.59687077e-02f, -1.51085764e-01f, -1.81204677e-01f,
  -3.96720350e-01f, 1.22601621e-01f, 2.01856986e-01f, -2.48544887e-01f, -7.13731572e-02f, 3.82578969e-01f, -3.98610979e-01f, 7.03416094e-02f, -5.22565804e-02f, -1.07252085e+00f,
  4.12373468e-02f, -3.10823806e-02f, 9.31191817e-02f, -4.01582383e-02f, -1.00459926e-01f, 8.98642167e-02f, -1.29180243e-02f, -7.91041777e-02f, -1.43591901e-02f, -6.22974709e-02f,
  -6.99652731e-02f, 1.14803377e-03f, 6.39368743e-02f, -1.30941495e-01f, 3.06162052e-02f, 3.98020856e-02f, -9.92721766e-02f, -3.74421887e-02f, 1.15908884e-01f, 1.60258394e-02f,
  2.41347298e-01f, 6.63676932e-02f, -3.80370207e-02f, 3.87681909e-02f, 4.22554426e-02f, 1.64144412e-02f, -1.26977274e-02f, 6.95394203e-02f, -3.54116522e-02f, -1.30452588e-01f,
  -1.36125803e-01f, 3.68777931e-01f, -1.16456524e-01f, 1.81324199e-01f, -1.99719116e-01f, 6.80013075e-02f, -2.05623545e-02f, 1.20412908e-01f, -3.68744531e-03f, 1.96975786e-02f,
  -8.18279758e-02f, 2.23753620e-02f, -9.80930999e-02f, -1.11153536e-02f, -4.03550602e-02f, -7.54267052e-02f, -1.18520826e-01f, 2.72701383e-01f, -1.27034888e-01f, -1.09145932e-01f,
  -2.57673740e-01f, -2.70497471e-01f, 1.57788992e-01f, -1.08214624e-01f, 7.24614933e-02f, 2.67754227e-01f, -4.69751269e-01f, -2.02243447e-01f, 6.62977016e-03f, -9.70266700e-01f,
  1.16309536e+00f, 4.01059479e-01f, 3.46956432e-01f, 2.73535937e-01f, 8.42867326e-03f, -7.01178387e-02f, -3.86877805e-02f, 3.30682024e-02f, 4.81496081e-02f, 1.23502344e-01f,
  2.63061643e-01f, 2.87715066e-02f, 5.04104421e-02f, 6.53828457e-02f, 1.38084307e-01f, 1.15238596e-02f, -1.59117565e-01f, 2.25779474e-01f, 2.59405434e-01f, 1.15895435e-01f,
  6.01397967e-03f, 2.55080611e-01f, 3.18559378e-01f, 1.12557575e-01f, 1.04258582e-01f, -8.86652544e-02f, 8.38355795e-02f, 9.16282535e-02f, 6.47679120e-02f, 6.75748140e-02f,
  3.07890981e-01f, 4.08042133e-01f, -3.21175575e-01f, -1.38297692e-01f, 6.60855323e-02f, 1.19590290e-01f, 9.97314006e-02f, -5.80055118e-02f, 5.04023023e-02f, -3.50478627e-02f,
  -5.00648133e-02f, 8.24569836e-02f, 3.54020596e-02f, 2.34357752e-02f, -7.64355343e-03f, -6.14977367e-02f, -4.54610921e-02f, 5.64652793e-02f, 3.29617821e-02f, -9.72269997e-02f,
  -3.73701379e-02f, -2.37286426e-02f, -1.91147067e-02f, -1.28305912e-01f, 1.70461640e-01f, -4.49199259e-04f, -5.76721178e-03f, 7.51532614e-02f, 7.02103693e-03f, 1.50761038e-01f,
  1.74925968e-01f, 3.29377115e-01f, 2.91501582e-01f, 2.11473808e-01f, 3.49659860e-01f, 9.47040468e-02f, -8.09576362e-02f, 5.65488636e-03f, 2.06318691e-01f, 3.39352340e-02f,
  -1.86469704e-01f, 1.03752583e-01f, 1.48489177e-01f, -1.78950056e-01f, -2.14634854e-02f, -3.26127582e-03f, -2.93037202e-02f, -1.84589207e-01f, 1.75694689e-01f, -9.12551433e-02f,
  1.60564020e-01f, -1.27601802e-01f, 5.90386391e-02f, 3.79744172e-02f, 1.79390404e-02f, 5.37033454e-02f, 9.43981633e-02f, 7.30359256e-02f, 2.66548488e-02f, 1.26868691e-02f,
  -6.46874726e-01f, 1.74749881e-01f, 7.94075727e-02f, -1.22275926e-01f, 1.75878219e-02f, 1.05118610e-01f, 1.87571242e-01f, -1.63206626e-02f, -1.77518651e-01f, -9.09115076e-02f,
  -3.31818983e-02f, 9.24550891e-02f, 1.12713091e-01f, 4.16663624e-02f, -1.76478669e-01f, -2.13443145e-01f, 2.57735164e-03f, -1.54368713e-01f, -2.52322610e-02f, -1.41699374e-01f,
  -1.34770259e-01f, -1.52134180e-01f, -2.88812757e-01f, -1.94043159e-01f, -1.02222934e-01f, -1.42144993e-01f, -1.09821901e-01f, -1.13740474e-01f, -9.86902192e-02f, -7.43857995e-02f,
  -1.53194022e+00f, -3.98152799e-04f, 3.78536761e-01f, -8.42833698e-01f, -4.69221145e-01f, -2.69155223e-02f, 1.43679738e-01f, -6.31142706e-02f, -2.18024015e-01f, 3.03343356e-01f,
  3.02577734e-01f, -3.40900898e-01f, -1.29266948e-01f, -1.85089394e-01f, -4.88202035e-01f, 3.24526429e-01f, -7.23558366e-02f, -8.04704189e-01f, -1.03450632e+00f, -7.06418455e-01f,
  -5.81510127e-01f, -9.17327404e-01f, -9.41694260e-01f, -3.64186168e-01f, 3.08769811e-02f, -2.68878281e-01f, 1.99750543e-01f, -3.93730193e-01f, 4.99729514e-02f, -5.43220155e-02f,
  7.37195909e-01f, -4.22376454e-01f, -2.25846007e-01f, -2.76363790e-01f, 1.17064431e-01f, 7.31277987e-02f, -1.05831273e-01f, 8.67890343e-02f, 2.33650953e-02f, 1.36566758e-01f,
  -1.00616924e-01f, -4.06770259e-02f, -1.43594369e-01f, 4.57195044e-02f, -2.44323716e-01f, -1.56850275e-02f, 2.03875557e-01f, -1.84194371e-01f, 6.35903552e-02f, 4.48565394e-01f,
  3.03784549e-01f, 8.12113062e-02f, 1.02365106e-01f, 2.45435894e-01f, 8.20249468e-02f, -2.55450398e-01f, 2.30113432e-01f, 8.19864497e-02f, 1.26106754e-01f, 1.54388174e-01f,
  7.91804045e-02f, 2.24748343e-01f, 5.88727035e-02f, -1.34874895e-01f, -5.19963028e-03f, 1.08744383e-01f, -1.26359724e-02f, 2.73264386e-03f, 2.15677936e-02f, -1.17720120e-01f,
  8.55240375e-02f, 1.58860117e-01f, 2.14613244e-01f, 1.59753151e-02f, 5.26611693e-02f, -8.66391584e-02f, -1.03152469e-01f, 3.66337076e-02f, 1.50936618e-01f, -1.65434614e-01f,
  -6.14143088e-02f, 9.45442170e-02f, -2.26589181e-02f, 1.26594797e-01f, 1.09077059e-01f, -4.94131632e-02f, 4.61895131e-02f, 4.00654860e-02f, -3.85160581e-03f, 2.88358852e-02f,
  -5.33477054e-04f, -3.76212060e-01f, -5.08803204e-02f, -5.34122773e-02f, 1.04046822e-01f, 1.23258658e-01f, 4.91473936e-02f, 3.24815735e-02f, -1.29651293e-01f, 9.86543298e-03f,
  3.46636064e-02f, -2.44493783e-02f, 6.25272617e-02f, 1.48432732e-01f, -9.02003050e-02f, -2.62952168e-02f, 1.43546751e-02f, -1.09402977e-01f, 1.38248980e-01f, 2.54999399e-01f,
  2.11366445e-01f, 4.91913781e-02f, -1.41298771e-01f, 9.06706452e-02f, 2.40998417e-02f, -1.25100181e-01f, 1.14417993e-01f, 9.43632349e-02f, 4.91426066e-02f, 6.13339581e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 20)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 20;
const float L0_fan_Bp_bar_data[] = {
  6.41100526e-01f, 9.65344548e-01f, 9.36982512e-01f, 6.24060512e-01f, 4.67209607e-01f, 1.03422308e+00f, 1.37366235e+00f, 1.73860535e-01f, 8.90886784e-01f, 7.36507654e-01f,
  2.01816291e-01f, 1.03090131e+00f, 6.00803971e-01f, 1.02114773e+00f, 2.60048240e-01f, 1.10389984e+00f, 5.45080185e-01f, 6.30252898e-01f, 7.64478385e-01f, 6.53048694e-01f
};

// L1_linear_W (Shape: 12 x 32)
const int L1_linear_W_rows = 12;
const int L1_linear_W_cols = 32;
const float L1_linear_W_data[] = {
  -3.30044687e-01f, -5.93889475e-01f, 1.57700375e-01f, -6.05722427e-01f, -3.70762274e-02f, -3.95872891e-02f, 1.03821158e+00f, -3.71397696e-02f, 1.18979402e-01f, 3.86265904e-01f,
  -2.31470279e-02f, -8.70815739e-02f, -1.01142657e+00f, -6.02007926e-01f, -2.42729977e-01f, -1.00180101e+00f, 5.31901680e-02f, -8.80118370e-01f, -5.48778176e-01f, 4.76848900e-01f,
  -6.38175607e-01f, 5.99900067e-01f, 6.17909193e-01f, -8.74671996e-01f, 6.61344230e-02f, -5.50893068e-01f, 3.66532095e-02f, -8.72802198e-01f, -2.24240199e-02f, 7.39863217e-01f,
  -6.14483237e-01f, -2.78061092e-01f, -4.27330844e-03f, -1.11072756e-01f, -4.19429392e-02f, -7.45249018e-02f, 1.53129801e-01f, -2.83110350e-01f, 5.15508316e-02f, 2.99730413e-02f,
  9.61895436e-02f, 3.59011322e-01f, 1.87654659e-01f, 4.29312810e-02f, 3.51940006e-01f, 1.08523788e-02f, -1.38851792e-01f, -2.53267139e-01f, -2.73765892e-01f, -8.19830596e-01f,
  -2.31634289e-01f, 9.70237315e-01f, 2.10294217e-01f, 4.04636770e-01f, -1.31316876e+00f, -1.48653245e+00f, -7.40064442e-01f, 6.58565536e-02f, -1.41234112e+00f, -3.13179195e-01f,
  3.96969646e-01f, 1.47680759e+00f, 6.67139232e-01f, -8.80772471e-01f, 2.14647695e-01f, -7.31660277e-02f, 9.28654298e-02f, 1.37107940e-02f, 5.69260120e-02f, -1.38818221e-02f,
  6.29150644e-02f, 3.69291514e-01f, 1.70751542e-01f, 7.16054618e-01f, 3.30973834e-01f, 2.62523055e-01f, -1.13744855e+00f, -5.40460825e-01f, -6.83828712e-01f, -9.11768794e-01f,
  -6.36724412e-01f, -3.70711833e-01f, 4.40042555e-01f, -1.99259520e-01f, -5.66609025e-01f, 5.31542838e-01f, -4.17528093e-01f, 7.63247848e-01f, 5.55718184e-01f, -1.78920522e-01f,
  -7.81936586e-01f, 9.36277136e-02f, -4.64455634e-01f, 1.08758223e+00f, -1.43901929e-01f, -8.03281188e-01f, 4.55318298e-03f, 2.80631602e-01f, -2.76131272e-01f, -8.31134394e-02f,
  -2.32531145e-01f, -3.92368674e-01f, -1.86252356e-01f, -1.38711482e-01f, -1.75498843e-01f, -9.75653436e-03f, 2.16438681e-01f, -7.64317751e-01f, -5.30009985e-01f, 8.22016478e-01f,
  -9.72534359e-01f, -1.08558607e+00f, -5.23586929e-01f, 9.72005576e-02f, -1.49751890e+00f, 5.82466900e-01f, -8.03273559e-01f, -3.71813208e-01f, 2.25117087e-01f, 6.72035754e-01f,
  -5.24322748e-01f, -1.12145364e+00f, -6.14439487e-01f, 6.96095467e-01f, 2.43700907e-01f, -1.18497288e+00f, -3.91350836e-01f, 3.88540626e-01f, 9.82669815e-02f, -6.71251910e-03f,
  -2.22530678e-01f, 1.08473554e-01f, -3.41687948e-01f, -4.81454283e-02f, -7.43213952e-01f, -1.18933455e-03f, -1.39019459e-01f, -6.11386932e-02f, 4.56874333e-02f, 1.46375731e-01f,
  -4.63628829e-01f, -9.92682397e-01f, 1.24775653e-03f, 2.06034735e-01f, 6.26437366e-01f, -9.19184506e-01f, -1.64122999e-01f, -5.01738846e-01f, 3.67872678e-02f, 1.33947700e-01f,
  3.07443049e-02f, 5.61603248e-01f, -1.25449741e+00f, -2.48463731e-02f, 5.33253133e-01f, -4.60657999e-02f, -8.44306767e-01f, -2.51839072e-01f, -4.37801033e-01f, 6.76976562e-01f,
  3.38730633e-01f, 9.88455266e-02f, 2.46421799e-01f, 4.06905979e-01f, 4.89811331e-01f, 4.57299739e-01f, 4.87888664e-01f, -3.14243197e-01f, 9.66919437e-02f, -3.03900719e-01f,
  -1.53274447e-01f, 2.72126257e-01f, 4.66171324e-01f, -3.35813105e-01f, 1.41927525e-01f, -5.81030428e-01f, 4.67115134e-01f, -3.78193170e-01f, -5.70967674e-01f, -7.82992542e-01f,
  5.94161332e-01f, -1.58850059e-01f, -3.39696407e-01f, -7.15168655e-01f, -6.12012267e-01f, 6.46636069e-01f, 5.86675465e-01f, -1.75025594e+00f, 8.01098943e-01f, -9.56615746e-01f,
  -6.76884949e-02f, -2.74585448e-02f, -6.92793012e-01f, 4.28103894e-01f, 3.85534406e-01f, 2.99237341e-01f, 1.32264778e-01f, 2.52886638e-02f, -4.49259907e-01f, 2.03483939e-01f,
  -2.37386376e-01f, -2.48382300e-01f, -2.97098339e-01f, -1.41293645e-01f, -5.41352808e-01f, -1.15284467e+00f, 3.37802470e-01f, -7.06735924e-02f, -8.53969634e-01f, -9.01391625e-01f,
  4.65479910e-01f, -6.52237475e-01f, 5.12991250e-01f, -9.83617961e-01f, -1.26927459e+00f, 2.70199090e-01f, 8.38981867e-01f, -4.38981503e-01f, -1.44657469e+00f, -9.65364158e-01f,
  -6.62679553e-01f, -4.29483324e-01f, 3.81621450e-01f, -6.51976526e-01f, 4.76171747e-02f, -2.71113575e-01f, -1.80474129e-02f, -2.10749432e-01f, -3.31702791e-02f, -6.07374370e-01f,
  -6.35474846e-02f, 1.09354526e-01f, 1.04490794e-01f, -7.58231729e-02f, 8.22924916e-03f, -2.31750999e-02f, 9.26370360e-03f, 6.46472752e-01f, -8.70274127e-01f, 3.97950441e-01f,
  -8.66344988e-01f, 9.06577185e-02f, -7.82865822e-01f, -8.04251790e-01f, -3.40803742e-01f, 2.68310696e-01f, -3.81269604e-01f, 8.12088132e-01f, 1.55702475e-02f, -4.97481257e-01f,
  3.10069799e-01f, 1.89344078e-01f, -6.85889661e-01f, -1.43063867e+00f, -8.54130924e-01f, -5.30270219e-01f, -1.42766088e-01f, 5.85227348e-02f, -1.97821870e-01f, 1.95229277e-01f,
  9.12508667e-02f, 1.61820814e-01f, 2.86276221e-01f, 3.48003775e-01f, 3.47851634e-01f, -1.46883279e-01f, -2.81026989e-01f, 1.87217042e-01f, -4.05556679e-01f, 7.60881424e-01f,
  7.26660132e-01f, -3.99376526e-02f, -4.05018151e-01f, 1.22085655e+00f, 3.12287305e-02f, 6.52306899e-02f, -4.42391485e-01f, 1.24187786e-02f, -3.05322945e-01f, -6.14870369e-01f,
  -6.27700659e-03f, 1.42419264e-01f, -4.85012025e-01f, -1.35011101e+00f, -1.03521252e+00f, -2.48844817e-01f, -4.55512911e-01f, -6.41241789e-01f, 1.78191766e-01f, -1.85878396e-01f,
  -2.16214195e-01f, -6.39642477e-02f, -3.13422173e-01f, -1.46030903e-01f, -7.17606544e-01f, -8.19992125e-01f, -3.43697250e-01f, -5.67175090e-01f, 4.77756560e-01f, -2.45024249e-01f,
  -2.25992575e-01f, -7.94215977e-01f, -5.92606068e-01f, 4.33294713e-01f, 6.55016124e-01f, -7.04349399e-01f, 4.87288833e-01f, -1.19175291e+00f, -1.22389734e+00f, -2.77003556e-01f,
  -2.03805417e-02f, -3.32508683e-01f, 3.11361402e-01f, 8.56173784e-02f, 9.23468769e-01f, -6.82487249e-01f, -1.08038700e+00f, 2.42493287e-01f, 2.18542770e-01f, -8.87139857e-01f,
  -2.95640171e-01f, 8.21027830e-02f, 1.33689910e-01f, 2.39860013e-01f, -4.24357839e-02f, 5.33776805e-02f, 3.58086884e-01f, 7.82626092e-01f, -2.19077244e-01f, 4.14710082e-02f,
  -3.71463090e-01f, 3.22005093e-01f, -3.08043897e-01f, -4.70931739e-01f, -8.81994903e-01f, 1.49453785e-02f, -9.55657184e-01f, 7.69977510e-01f, 2.28532389e-01f, 1.62518024e-01f,
  -7.06774831e-01f, -1.02933264e+00f, -7.53822744e-01f, -6.57969475e-01f, -6.97565824e-02f, 5.02076507e-01f, 1.46380356e-02f, 7.52794266e-01f, 4.37814474e-01f, -8.22278380e-01f,
  -6.62760735e-01f, 1.44313678e-01f, -4.08908948e-02f, -9.56374630e-02f, 9.87782329e-02f, 9.72334445e-02f, -2.55267229e-02f, -3.23406793e-02f, -3.56911302e-01f, -5.59346855e-01f,
  1.16232939e-01f, -1.96203068e-01f, 4.90433007e-01f, -4.38440323e-01f, 3.51171255e-01f, 5.41478515e-01f, 1.02781308e+00f, -3.15320492e-01f, -3.34207594e-01f, -8.28013480e-01f,
  6.81307167e-02f, -3.75209749e-01f, -4.02524561e-01f, -1.00546050e+00f, 1.78958192e-01f, -4.62221533e-01f, -1.08347547e+00f, -7.73597360e-01f, -1.29256952e+00f, 1.09251797e+00f,
  -5.36170483e-01f, -9.58149314e-01f, 5.10857642e-01f, -2.23175421e-01f
};

// L1_linear_B (Shape: 1 x 12)
const int L1_linear_B_rows = 1;
const int L1_linear_B_cols = 12;
const float L1_linear_B_data[] = {
  4.67977852e-01f, -1.98248282e-01f, 1.76241145e-01f, -5.17723799e-01f, -1.47775546e-01f, 2.26693869e-01f, -2.00979099e-01f, -3.18335742e-01f, -4.76082295e-01f, 3.60924631e-01f,
  -5.99344671e-01f, 3.54765095e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 6, 20
    );
    
    // Camada 1: L1_linear
    linear_forward_pgm(
        buffer1, x_out,
        L1_linear_W_data, L1_linear_B_data,
        32, 12
    );
    }
    