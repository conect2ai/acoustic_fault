/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 16 (x1)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 16;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    float x3 = x * x * x;
    return 0.5f * x * (1.0f + tanhf(0.79788456f * (x + 0.044715f * x3)));
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 3 x 120)
const int L0_fan_Wp_rows = 3;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -9.70819890e-02f, 3.22625190e-01f, 2.25925326e-01f, -3.27758253e-01f, -2.05307808e-02f, 4.36153680e-01f, 4.78583753e-01f, -1.42048925e-01f, -4.29346412e-01f, 2.39179462e-01f,
  1.61888748e-01f, -8.26961361e-03f, 2.29295880e-01f, 2.71365792e-01f, 3.50766964e-02f, 2.84160465e-01f, 1.80237621e-01f, 1.06492519e-01f, -1.94508582e-01f, -2.75074933e-02f,
  7.92148784e-02f, 8.45530555e-02f, 3.54382724e-01f, -2.22681105e-01f, 1.78167686e-01f, -8.01585093e-02f, -5.66613674e-02f, 7.09582772e-03f, -4.80724424e-02f, -8.52979627e-03f,
  2.00727940e-01f, -5.89566901e-02f, 1.69701707e-02f, 9.27398447e-03f, 1.07617415e-01f, 7.98130035e-02f, 1.72214350e-03f, -7.02940300e-02f, -3.34669165e-02f, -2.07369905e-02f,
  1.43149905e-02f, -1.14295213e-02f, -1.14247650e-01f, -7.62227923e-02f, -8.52594301e-02f, -9.73627567e-02f, 2.93212850e-02f, 1.15555488e-01f, -1.67071093e-02f, 1.58354133e-01f,
  6.83658198e-02f, 5.28564677e-02f, 9.18683186e-02f, -1.11643575e-01f, -1.38212278e-01f, -4.68188226e-02f, 1.46200806e-01f, -4.91001643e-03f, 2.20838655e-02f, -1.15157992e-01f,
  2.39844732e-02f, 2.35733408e-02f, 4.03943174e-02f, 2.24336702e-03f, 1.05458805e-02f, 6.79057883e-03f, -9.05213282e-02f, 5.62233552e-02f, -1.66063666e-01f, 3.64211202e-02f,
  -1.13753408e-01f, -2.64723953e-02f, 4.38055508e-02f, 8.98330566e-03f, 3.69617827e-02f, -4.88399714e-02f, 1.07464171e-03f, 2.41853222e-02f, -1.58882104e-02f, -1.13898851e-02f,
  1.72180706e-04f, -2.44343560e-02f, 5.48878461e-02f, 5.84559552e-02f, 4.78289463e-02f, -2.81698792e-03f, -1.42626138e-02f, 7.21579120e-02f, 4.05668728e-02f, 1.13425367e-01f,
  3.35979983e-02f, 6.04481436e-02f, 9.93008260e-03f, -1.73454151e-01f, -1.05499022e-01f, -4.07260004e-03f, 3.57019268e-02f, -1.03146182e-02f, -1.04060046e-01f, -5.15890829e-02f,
  -5.17375860e-03f, -2.11528167e-02f, 8.39174818e-03f, 4.15271856e-02f, -6.26751259e-02f, 1.04857154e-01f, 5.05563915e-02f, -8.82736892e-02f, -8.12324211e-02f, -6.16717637e-02f,
  -1.80436801e-02f, -3.11783943e-02f, -1.82310604e-02f, 4.08802321e-03f, 6.22558072e-02f, 8.49057958e-02f, -1.45064026e-01f, -1.44718690e-02f, 3.27639692e-02f, -6.88930135e-03f,
  7.43642926e-01f, 1.61443651e-01f, -9.76515785e-02f, 3.86865169e-01f, 3.23789537e-01f, 1.20643176e-01f, 3.85383755e-01f, 2.53769666e-01f, 1.49670914e-01f, 6.22709915e-02f,
  8.23771656e-02f, 3.15393396e-02f, -2.41979524e-01f, 2.36688815e-02f, 2.14311570e-01f, -3.44720930e-01f, 4.51807857e-01f, 1.22553229e-01f, -1.42619103e-01f, 3.17643583e-01f,
  9.65720713e-02f, 1.54792771e-01f, 6.47153184e-02f, 1.93749100e-03f, 9.78382379e-02f, 4.00322163e-03f, 2.66148478e-01f, -8.05820599e-02f, 4.48065996e-02f, -1.12059832e-01f,
  -4.23699804e-02f, 1.31596908e-01f, -9.30417478e-02f, -1.47264630e-01f, 1.20082125e-01f, -1.73773209e-03f, 2.53939088e-02f, -2.06941575e-01f, -8.46902877e-02f, 2.61982419e-02f,
  2.37927642e-02f, 2.25797147e-02f, -6.54061735e-02f, -1.48208424e-01f, 2.26100944e-02f, -2.76789386e-02f, -1.30124986e-01f, 1.42531879e-02f, -4.54735607e-02f, -3.49574024e-03f,
  5.45135029e-02f, -8.43877718e-02f, -4.50820178e-02f, -3.77102718e-02f, 4.43494599e-03f, -4.29387437e-03f, -1.38757899e-02f, 4.08053510e-02f, 1.04933001e-01f, 1.12393171e-01f,
  -3.92972454e-02f, 2.32657250e-02f, -2.16671210e-02f, -1.37210377e-02f, 4.74729240e-02f, 1.28665697e-02f, -1.80352423e-02f, -9.08505358e-03f, -7.52580017e-02f, 9.97372791e-02f,
  5.38789406e-02f, 9.83349830e-02f, 9.87803005e-03f, 2.28374265e-02f, 4.55310456e-02f, 1.31621212e-01f, -1.87323298e-02f, -6.97458237e-02f, 6.57153577e-02f, -2.88217440e-02f,
  4.41808775e-02f, 5.02802525e-03f, -1.58386249e-02f, -2.21462771e-02f, 3.28245834e-02f, -6.70934543e-02f, -5.11894049e-03f, 5.71246678e-03f, -7.09095970e-02f, -3.51398699e-02f,
  2.29252413e-01f, 4.76299733e-01f, 6.82514459e-02f, 7.98916966e-02f, -1.97827164e-02f, 9.32579301e-03f, 1.03724338e-02f, 2.71076951e-02f, -9.99202877e-02f, 3.05868220e-02f,
  -8.30312446e-02f, -1.77086471e-03f, 9.66877863e-02f, 3.35614569e-02f, -2.23727711e-02f, -3.43235885e-03f, 4.69415076e-02f, -6.48934860e-03f, 2.32826293e-01f, 6.45929947e-03f,
  7.88646862e-02f, 1.11812830e-01f, 2.79686134e-02f, 1.60608545e-01f, 5.59469275e-02f, 1.06482729e-01f, 1.59186721e-01f, -9.35568139e-02f, -8.22407380e-02f, -3.47552598e-02f,
  -4.25407916e-01f, 1.16794752e-02f, 2.08656281e-01f, 1.48485601e-02f, -4.32870060e-01f, -5.43733239e-01f, -2.96503305e-01f, -1.03517458e-01f, -4.45050240e-01f, 4.66813482e-02f,
  9.88330599e-03f, 3.90275449e-01f, -3.81435454e-02f, 2.62451798e-01f, -1.08403154e-01f, -1.38259590e-01f, 3.37609798e-02f, -3.97087028e-03f, -2.02173039e-01f, -8.23552161e-02f,
  -5.35663292e-02f, 9.18426067e-02f, 3.53041857e-01f, -2.46774289e-03f, -1.49512336e-01f, 6.77451268e-02f, 2.62288731e-02f, 7.90093467e-02f, 1.92691907e-01f, 2.82569751e-02f,
  -7.11031482e-02f, 1.44224063e-01f, 6.20633140e-02f, 1.95222422e-02f, 2.27801688e-03f, -1.34946167e-01f, -3.07779945e-03f, 1.01237901e-01f, 5.95652945e-02f, 2.79952381e-02f,
  8.95439312e-02f, 1.69330850e-01f, 2.28967592e-02f, 4.22868319e-02f, -2.48122409e-01f, 7.33222067e-02f, -1.09157361e-01f, -8.10419917e-02f, -3.87064442e-02f, 2.55890749e-02f,
  -6.81046620e-02f, 5.70138097e-02f, -6.12439923e-02f, 3.84523310e-02f, -4.62663174e-02f, -1.56891704e-01f, 2.77795307e-02f, -2.90121697e-02f, 2.58050188e-02f, -7.98307434e-02f,
  5.55445850e-02f, -1.50243834e-01f, -9.58274454e-02f, 1.59541830e-01f, -1.60181406e-03f, -5.69476895e-02f, 3.92196290e-02f, 2.95393132e-02f, -3.24795395e-02f, -3.15039605e-02f,
  -2.49871500e-02f, -1.42772064e-01f, 4.46370654e-02f, -1.14959911e-01f, 5.65743037e-02f, -6.57009259e-02f, 6.08504470e-03f, -5.64258173e-03f, -1.33009791e-01f, -7.09411874e-02f,
  1.22367099e-01f, -1.25895575e-01f, 7.89457560e-02f, -8.89080018e-02f, -8.19505230e-02f, 4.71370667e-02f, 5.35956435e-02f, 2.39384379e-02f, -4.29379428e-03f, -1.52116017e-02f,
  -3.90684545e-01f, -3.95338863e-01f, -4.68485653e-02f, -4.51013744e-02f, 7.11786747e-03f, -4.44995426e-02f, 4.24929857e-02f, -7.60425702e-02f, -8.66562501e-02f, -8.20431337e-02f,
  2.67089773e-02f, -1.48237273e-01f, -1.06923863e-01f, -6.10592701e-02f, 1.45694315e-01f, -5.43338060e-02f, 1.17525704e-01f, -6.33585528e-02f, 9.41296946e-03f, -3.25350091e-02f,
  4.87146042e-02f, -3.37761082e-02f, 3.29415090e-02f, 2.64955945e-02f, 5.87445199e-02f, 8.06462094e-02f, -1.66235324e-02f, 8.57244954e-02f, 2.50591412e-02f, 2.38775685e-02f
};

// L0_fan_Wp_bar (Shape: 10 x 120)
const int L0_fan_Wp_bar_rows = 10;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  1.61864325e-01f, -4.59091872e-01f, -7.02697337e-02f, -9.42564607e-01f, -1.39937177e-01f, -8.34126174e-02f, 1.39627010e-02f, -6.15797579e-01f, -7.28047192e-01f, -5.16651988e-01f,
  -4.60280687e-01f, 1.76803589e-01f, 6.58222437e-01f, -9.46051896e-01f, 1.39836514e+00f, 5.61235666e-01f, -8.27286482e-01f, -4.01497334e-01f, -2.47903660e-01f, -7.69586325e-01f,
  -3.30778472e-02f, -9.72271860e-01f, 2.64498293e-01f, -6.77325904e-01f, -8.31640840e-01f, -6.86161458e-01f, -2.81304661e-02f, -1.36211496e-02f, -6.14232481e-01f, 1.50234252e-01f,
  -2.01921538e-01f, -1.34951070e-01f, -5.00061142e-04f, 1.78095043e-01f, -1.59258917e-01f, 6.80971518e-02f, 1.11772686e-01f, 4.89800453e-01f, 1.54400263e-02f, 7.89565668e-02f,
  8.98571908e-02f, 3.01179290e-01f, -1.42707884e-01f, 1.48403302e-01f, -2.23633885e-01f, -2.78648525e-01f, 3.72682475e-02f, -3.40560079e-01f, -1.87679544e-01f, 1.02703296e-01f,
  2.99665723e-02f, -5.25390469e-02f, -2.77368784e-01f, -1.63130630e-02f, 1.12907607e-02f, -3.18862349e-01f, 2.10934535e-01f, 1.72002435e-01f, -4.08029966e-02f, -9.22303274e-02f,
  -8.73452425e-02f, 1.30484983e-01f, -6.38887566e-03f, -1.58002943e-01f, -1.86369196e-02f, -3.83293301e-01f, -7.83895403e-02f, 8.93425122e-02f, -5.85505962e-02f, -1.38683513e-01f,
  -2.28658602e-01f, -1.72810867e-01f, -6.10703640e-02f, 6.54934673e-03f, -1.08483769e-01f, -5.63725680e-02f, 2.76501983e-01f, 7.75648206e-02f, -2.11088791e-01f, 1.28482119e-04f,
  -2.10248336e-01f, 2.42963601e-02f, 2.69217044e-03f, -6.41852617e-02f, -1.04107790e-01f, 1.70379475e-01f, 5.65766415e-04f, 3.21790166e-02f, -1.39735006e-02f, 2.17786804e-01f,
  -1.88865066e-01f, -2.25896299e-01f, -1.09679885e-01f, -7.76999220e-02f, 2.76910421e-03f, 2.36424338e-02f, 1.84500694e-01f, -3.81949395e-01f, -1.53689519e-01f, -1.38226599e-01f,
  -2.28024572e-01f, 4.51857224e-04f, -6.46190196e-02f, -1.92427605e-01f, 2.57066470e-02f, -1.42803863e-01f, -1.18761890e-01f, 4.66411859e-02f, -1.43438384e-01f, -1.62407696e-01f,
  -6.48127645e-02f, 5.75166605e-02f, 1.63877904e-01f, -4.03224267e-02f, -5.99067323e-02f, 1.53723270e-01f, -1.33183852e-01f, -1.05066374e-02f, 1.40465021e-01f, -2.43442617e-02f,
  3.84108543e-01f, -6.17241383e-01f, -7.18063176e-01f, 6.25485599e-01f, -3.74587357e-01f, 8.96259844e-01f, 1.36933935e+00f, -3.28099579e-01f, 3.12759250e-01f, 3.71707261e-01f,
  4.83578384e-01f, -2.67497934e-02f, 6.57998724e-04f, 1.15972590e+00f, 6.73114181e-01f, 3.85216415e-01f, 8.97564828e-01f, 6.79385304e-01f, -9.13154632e-02f, 3.21076512e-02f,
  2.37182736e-01f, 8.64994287e-01f, -2.35988125e-01f, -4.43585008e-01f, -1.82022557e-01f, -6.07825637e-01f, -3.39358091e-01f, -6.55227959e-01f, 2.42270038e-01f, 9.65064839e-02f,
  4.01501238e-01f, 3.95289995e-02f, -9.46908519e-02f, 1.50698468e-01f, -1.43582135e-01f, -1.73652709e-01f, 1.19193062e-01f, -1.13371186e-01f, 8.96808505e-02f, 8.86356235e-02f,
  1.96259379e-01f, 1.58326868e-02f, 3.63624722e-01f, -1.44681349e-01f, 1.73667148e-01f, -1.54867977e-01f, -1.36913329e-01f, -1.62969530e-01f, -1.03577711e-01f, -2.16072395e-01f,
  -8.46396387e-02f, -1.36907220e-01f, 1.14773167e-02f, -2.49246950e-03f, -2.39509009e-02f, 2.45429687e-02f, -3.49757336e-02f, -1.77993745e-01f, 6.40218854e-02f, 8.45012721e-03f,
  -1.09535433e-01f, 9.77756828e-02f, -7.36280903e-02f, 1.58024773e-01f, -1.97055131e-01f, 1.09247550e-01f, 1.34380773e-01f, -6.12963252e-02f, -7.40214065e-02f, -5.02658561e-02f,
  9.24204364e-02f, -4.80629615e-02f, 1.51039302e-01f, 1.92473885e-02f, 2.12833270e-01f, 5.73526183e-03f, -7.16472268e-02f, 1.55496091e-01f, 7.13760927e-02f, -5.70624918e-02f,
  4.02501896e-02f, 4.75187832e-03f, 7.52868829e-03f, -4.42740805e-02f, 1.69251725e-01f, -3.72690498e-03f, 6.32080734e-02f, -1.47041693e-01f, -1.14538241e-02f, -2.87837572e-02f,
  2.04453394e-02f, -3.92650306e-01f, 1.31407995e-02f, 1.28805891e-01f, -8.02744627e-02f, -1.80957943e-01f, 1.09443508e-01f, -8.67246836e-02f, -1.06408276e-01f, 8.56880322e-02f,
  5.23871854e-02f, 1.28252935e-02f, -9.04035270e-02f, -1.00052981e-02f, -6.84591234e-02f, -7.73109878e-06f, 3.18314642e-01f, 3.57162394e-02f, -8.75796899e-02f, -9.82587114e-02f,
  -1.54737264e-01f, 1.52271241e-01f, 5.21938466e-02f, 9.25789122e-03f, -4.67814244e-02f, -1.18914254e-01f, -1.92661449e-01f, -3.16244364e-02f, 5.92445582e-03f, 5.40694445e-02f,
  -2.11420345e+00f, 5.25581717e-01f, -6.82228744e-01f, -1.08549845e+00f, 5.72534092e-02f, -4.12067443e-01f, -5.99236451e-02f, -6.70484826e-02f, -5.75982511e-01f, 9.30165052e-01f,
  3.06366563e-01f, -9.55126166e-01f, 7.82648385e-01f, -6.23533070e-01f, -1.51213133e+00f, -3.04967523e-01f, -7.22884238e-01f, -3.85360748e-01f, -2.82631129e-01f, -3.36233914e-01f,
  -5.48565388e-01f, -1.19651109e-01f, -9.69343781e-02f, 5.27201831e-01f, -9.55728218e-02f, 1.93691969e-01f, 3.11717778e-01f, 4.23960537e-01f, -6.22373447e-02f, -2.97074407e-01f,
  -3.95569295e-01f, 1.53310344e-01f, 3.41051042e-01f, -8.53906348e-02f, -6.83644488e-02f, 2.11636513e-01f, -1.18884817e-01f, 1.28598763e-02f, -1.55666664e-01f, -3.16535503e-01f,
  -7.32003525e-02f, -1.31917953e-01f, -2.23444000e-01f, -5.54624163e-02f, 9.14678201e-02f, -8.43434632e-02f, -1.42340094e-01f, 1.00785131e-02f, 5.68899736e-02f, -1.46757394e-01f,
  9.51302238e-03f, -4.76893149e-02f, 3.60176945e-03f, -7.02053495e-03f, -2.41161868e-01f, 1.77725742e-03f, -1.23735487e-01f, -1.41640544e-01f, -1.25734106e-01f, -3.18704545e-01f,
  -9.64875147e-02f, 5.80072366e-02f, 4.35501151e-02f, 1.04953811e-01f, -5.19859828e-02f, 2.31088832e-01f, -1.39229476e-01f, -1.59163885e-02f, -2.30201870e-01f, 3.02186906e-02f,
  -1.56166643e-01f, 9.41464212e-03f, -1.01220369e-01f, -1.66660342e-02f, 3.04320687e-03f, 8.51583481e-02f, -9.25304741e-02f, 5.65160252e-03f, -1.13977253e-01f, -8.73473510e-02f,
  5.51607050e-02f, 5.59028350e-02f, 1.08294420e-01f, 1.57997474e-01f, -8.88611674e-02f, -1.14860669e-01f, 1.30961820e-01f, 1.03269428e-01f, 3.36917154e-02f, -1.77819982e-01f,
  -3.76960516e-01f, -2.99033046e-01f, -1.48243236e-03f, 5.93334949e-03f, -1.34386554e-01f, -2.64675301e-02f, -6.48784116e-02f, -2.17338160e-01f, -4.36299071e-02f, 6.28689528e-02f,
  -8.96658003e-02f, 1.92000419e-01f, -1.11083478e-01f, -7.61849657e-02f, -1.62563473e-01f, -3.21838222e-02f, -1.06516913e-01f, -8.19822997e-02f, -5.77650294e-02f, -1.93512347e-02f,
  9.64721069e-02f, 8.50907899e-03f, 4.74924147e-02f, 1.74872831e-01f, 2.04447851e-01f, 1.57351345e-01f, -1.30989000e-01f, 7.37572610e-02f, -6.99192584e-02f, 1.05395988e-01f,
  4.00424063e-01f, -2.15582788e-01f, -1.06193721e+00f, -6.26368344e-01f, 8.28658938e-01f, 9.73171830e-01f, -3.50786746e-01f, 1.41769081e-01f, -7.80067384e-01f, 1.33752361e-01f,
  3.61927241e-01f, -2.88979053e-01f, -6.76347077e-01f, 4.10925835e-01f, -8.58699903e-02f, -7.95354247e-01f, 2.06709713e-01f, 6.30076677e-02f, -2.73594856e-01f, -6.99509978e-02f,
  -1.52113840e-01f, 1.12763369e+00f, -5.09635031e-01f, 6.55136168e-01f, 4.93482471e-01f, -3.44364464e-01f, 6.99855611e-02f, -1.19378448e-01f, 7.06271589e-01f, 4.03362602e-01f,
  -2.18378715e-02f, -1.23106420e-01f, -7.43140802e-02f, -8.85119140e-02f, -1.18351072e-01f, 1.91838503e-01f, -1.08426295e-01f, -1.58963669e-02f, -1.64399892e-01f, -1.92858621e-01f,
  -1.85092241e-02f, 9.67161804e-02f, 1.23969682e-01f, 1.08073674e-01f, 3.14406097e-01f, 1.83647558e-01f, 2.02405564e-02f, 4.15961519e-02f, -7.53270537e-02f, 1.15491942e-01f,
  -1.67999446e-01f, -4.77353390e-03f, -4.83944081e-02f, -1.25136524e-01f, -3.07588726e-01f, -8.75478238e-02f, -1.16317607e-01f, -1.54362068e-01f, 6.86178505e-02f, 3.14539038e-02f,
  2.33355522e-01f, 7.29955956e-02f, 1.05799809e-01f, 1.97663322e-01f, 2.26536449e-02f, 4.83634546e-02f, 3.94328050e-02f, 6.50525689e-02f, -1.48832023e-01f, 7.88605809e-02f,
  -4.06643562e-03f, 2.66497675e-03f, 9.98958871e-02f, 1.04538187e-01f, 1.66758180e-01f, -1.42802104e-01f, 1.25836963e-02f, 4.41357419e-02f, -2.17990801e-02f, -1.66757908e-02f,
  -9.04050097e-02f, -4.56313863e-02f, 2.95881741e-02f, -4.11702208e-02f, 1.67980641e-01f, -7.20762163e-02f, 1.17045537e-01f, 9.86036807e-02f, -1.70649081e-01f, 5.64102735e-03f,
  -8.33603665e-02f, -1.11465216e-01f, -1.30023435e-01f, 2.80028190e-02f, -6.63794652e-02f, 3.59442115e-01f, 9.88872647e-02f, 8.74173418e-02f, -5.64899035e-02f, -2.05568541e-02f,
  1.37123063e-01f, -6.96664676e-02f, 2.00074222e-02f, 7.92225972e-02f, -1.75716460e-01f, 1.19661488e-01f, -7.43812993e-02f, -5.11474460e-02f, -1.77211873e-02f, 1.26084730e-01f,
  2.46596839e-02f, 5.15602082e-02f, -2.10024137e-02f, 1.48240954e-01f, 1.25865743e-01f, 5.60505874e-02f, 1.99858189e-01f, -2.11782992e-01f, 1.60708860e-01f, -6.64474368e-02f,
  5.57532847e-01f, 3.57836097e-01f, 7.93617725e-01f, 8.49858224e-01f, 5.01357280e-02f, -2.13031605e-01f, -7.22986877e-01f, 6.70235634e-01f, 4.74029094e-01f, -6.35800838e-01f,
  -6.30035043e-01f, 7.68390298e-02f, -7.73055434e-01f, 3.99455994e-01f, -2.08585802e-03f, -2.50009090e-01f, 3.97062510e-01f, -6.43430650e-02f, 2.62202263e-01f, 1.05420701e-01f,
  6.03348494e-01f, -6.15810096e-01f, 4.20396686e-01f, 6.80027306e-02f, 3.68051767e-01f, 5.10122180e-01f, -3.52371782e-01f, -2.04317600e-01f, 3.34741354e-01f, -1.64447621e-01f,
  4.51614149e-02f, 2.68479794e-01f, 3.65051091e-01f, 1.95925966e-01f, 1.59767419e-01f, -1.00371167e-01f, 9.72216278e-02f, -3.50359499e-01f, 7.60919005e-02f, 3.47103998e-02f,
  -3.76087010e-01f, 3.10892146e-02f, 2.06303924e-01f, -1.95012446e-02f, 2.84357909e-02f, 3.88763696e-01f, 2.07614496e-01f, 2.61802763e-01f, 1.17742188e-01f, 3.87407355e-02f,
  -1.29202688e-02f, 2.28683636e-01f, 2.22084880e-01f, -1.10653900e-02f, 1.35664105e-01f, 1.79401711e-01f, -1.00911811e-01f, -9.60527435e-02f, 1.04662359e-01f, 2.35208780e-01f,
  1.64187059e-01f, -1.59918129e-01f, -7.09806830e-02f, 5.64321391e-02f, -2.85061061e-01f, -1.24890387e-01f, 3.43175642e-02f, -1.40803248e-01f, -1.34107307e-01f, 2.93696746e-02f,
  -2.80873571e-02f, 2.61263903e-02f, 2.59880759e-02f, 1.29748181e-01f, -3.81340869e-02f, 1.99477505e-02f, 4.13137637e-02f, -3.91580351e-02f, 1.49718404e-01f, 1.73418269e-01f,
  -2.48441234e-01f, -6.03276119e-02f, 1.82530470e-02f, -9.84956920e-02f, -3.12643908e-02f, -1.28891036e-01f, 1.87285006e-01f, 1.80226550e-01f, -3.58698741e-02f, -6.82196021e-02f,
  -6.87461734e-01f, -4.73467797e-01f, 1.04182824e-01f, -3.80680710e-01f, -4.61836196e-02f, -5.53876050e-02f, -4.03400622e-02f, 7.76282400e-02f, -1.66492745e-01f, 1.38083352e-02f,
  -1.02204634e-02f, -1.21113591e-01f, -2.10776031e-01f, 2.81566679e-02f, 1.10148387e-02f, 2.45299358e-02f, -2.51358837e-01f, -2.45087698e-01f, -1.53145730e-01f, 1.70071855e-01f,
  -6.72278106e-02f, -3.24821442e-01f, 1.38584867e-01f, 1.33961633e-01f, -7.15811551e-02f, -1.63870811e-01f, 1.85938954e-01f, 1.29220262e-01f, -1.09214082e-01f, -1.88943669e-02f,
  7.37152934e-01f, 6.06182635e-01f, 2.17147171e-01f, 4.15509999e-01f, -4.27588373e-01f, -5.18514574e-01f, -3.11143070e-01f, -3.13843131e-01f, 2.46010482e-01f, 3.00457567e-01f,
  -7.18657076e-01f, 1.03367531e+00f, -2.12460488e-01f, -3.08356494e-01f, -6.27633989e-01f, -5.46584427e-01f, 2.86102861e-01f, 2.38774151e-01f, -2.57167388e-02f, 6.79161131e-01f,
  1.44902706e-01f, -3.19130093e-01f, -3.99438173e-01f, -7.09011018e-01f, 1.86314672e-01f, 4.05368924e-01f, 4.69065942e-02f, -3.17433208e-01f, 1.42594457e-01f, -4.11484599e-01f,
  -2.61942416e-01f, 3.92477401e-02f, 1.51645914e-01f, -1.24630723e-02f, 5.72088808e-02f, 6.45971596e-02f, 1.68993156e-02f, -3.86826426e-01f, -7.03861192e-02f, 1.57902181e-01f,
  3.51155132e-01f, 6.86511248e-02f, 1.53205380e-01f, -1.47993371e-01f, -2.91095972e-02f, 8.26735273e-02f, 1.04984380e-01f, -4.49591578e-04f, 2.54026167e-02f, 1.87640395e-02f,
  5.07854447e-02f, -1.23335337e-02f, 1.23184502e-01f, 1.73633546e-01f, 7.41838515e-02f, -8.52235779e-02f, 8.72915238e-02f, 9.58627239e-02f, 2.57659256e-01f, 8.44198242e-02f,
  5.46172187e-02f, 1.71357900e-01f, -1.10041745e-01f, -2.03148037e-01f, -2.73009203e-02f, 1.18629619e-01f, 6.66668788e-02f, -1.14696138e-01f, 6.32892456e-03f, -2.97825448e-02f,
  -1.23717695e-01f, -3.02216839e-02f, -1.13711275e-01f, 1.37496948e-01f, 7.13517144e-02f, -3.30959782e-02f, -5.27829304e-02f, -4.21156362e-02f, -7.29967374e-03f, -9.29225013e-02f,
  -1.47678137e-01f, 5.68957701e-02f, -8.10723975e-02f, -1.34827131e-02f, -4.40786541e-01f, -1.83569178e-01f, 6.18897751e-02f, 1.35520101e-01f, -1.01305552e-01f, 1.69605508e-01f,
  9.41993967e-02f, 6.06863678e-01f, 5.25426269e-02f, -1.83801919e-01f, -3.25732119e-02f, 1.89979542e-02f, 6.53178692e-02f, 2.34963313e-01f, 3.60401392e-01f, -7.84157366e-02f,
  2.72346288e-01f, 8.27983022e-02f, 1.64402828e-01f, -2.79540196e-02f, -1.17961027e-01f, 2.47425586e-02f, 2.43818998e-01f, 1.82643041e-01f, 1.83499381e-01f, 4.39658053e-02f,
  1.49226889e-01f, 2.59465843e-01f, 2.48604625e-01f, 1.80818632e-01f, 4.40302305e-02f, 9.90187153e-02f, 2.16836363e-01f, 6.38703350e-03f, 4.39045727e-02f, 2.00683862e-01f,
  7.34492183e-01f, -1.30555308e+00f, 5.23700356e-01f, 6.98670983e-01f, 1.02487290e+00f, 8.85444403e-01f, 9.74765956e-01f, -3.37274782e-02f, -1.14684120e-01f, -9.73878205e-01f,
  -2.81614345e-02f, -3.13480556e-01f, -1.05731852e-01f, -3.95139277e-01f, 9.53084350e-01f, -3.86751533e-01f, 9.83804017e-02f, -2.20360652e-01f, 1.65393442e-01f, -8.41525476e-03f,
  6.37293339e-01f, 1.86144158e-01f, 4.95035768e-01f, -3.75730962e-01f, 4.13941026e-01f, -1.26502723e-01f, -1.80682644e-01f, 3.84083748e-01f, -3.60734493e-01f, 3.08566272e-01f,
  2.27589365e-02f, -3.98267776e-01f, 1.03547471e-02f, -3.93473506e-01f, -5.14121130e-02f, 1.35230988e-01f, 1.78576391e-02f, 2.07512051e-01f, 2.96671957e-01f, 1.05676882e-01f,
  8.65880959e-03f, 1.43507987e-01f, -6.41698614e-02f, 1.47321984e-01f, 7.89798647e-02f, -2.37774365e-02f, 2.87185341e-01f, 3.36142778e-02f, -3.46481800e-02f, 2.49752432e-01f,
  1.35606691e-01f, -8.04865211e-02f, 5.23933321e-02f, -1.78431675e-01f, 7.94019997e-02f, 6.44989759e-02f, 7.17296749e-02f, 7.64456913e-02f, -6.08664043e-02f, -5.89101873e-02f,
  -5.59809152e-03f, -2.48095877e-02f, 4.29804921e-02f, -1.89243153e-01f, 1.05561219e-01f, 2.67853826e-01f, -6.93147583e-03f, 1.06789218e-03f, -3.06565184e-02f, -6.06158748e-02f,
  1.59200996e-01f, 4.58290353e-02f, -9.67715457e-02f, 1.82715043e-01f, -1.62537564e-02f, 1.24848537e-01f, 8.80832076e-02f, -6.81481585e-02f, -2.28561193e-01f, 1.40238523e-01f,
  -7.43399514e-03f, 1.76072091e-01f, -1.40932500e-01f, -2.46158168e-02f, -2.03898177e-01f, -4.95864823e-02f, -3.11928093e-01f, 5.94487749e-02f, 1.68585926e-01f, 1.30689785e-01f,
  -1.04169250e+00f, -1.34284973e+00f, -2.06263199e-01f, -1.11833140e-01f, -2.33573690e-01f, -1.15307651e-01f, 5.46074733e-02f, -4.18666303e-02f, -1.40767023e-01f, 6.80235401e-02f,
  1.01686224e-01f, 7.28583410e-02f, -5.05851209e-02f, -1.66303199e-02f, -1.89495638e-01f, 7.56641403e-02f, 8.42438778e-04f, -3.88455659e-01f, -1.68073118e-01f, -2.02951089e-01f,
  -2.67613083e-01f, 7.62177929e-02f, 1.69473082e-01f, 1.87085629e-01f, -2.29043171e-01f, -6.58605844e-02f, -9.64817703e-02f, -2.24292912e-02f, 8.69695544e-02f, 6.17759861e-02f,
  -9.59656239e-01f, 1.03985608e+00f, 1.07407439e+00f, -2.00207785e-01f, 6.58763349e-01f, 1.84989244e-01f, 2.26644382e-01f, 5.99302590e-01f, 8.32139432e-01f, -4.67552394e-02f,
  -1.72834128e-01f, 4.05413359e-01f, 1.04177736e-01f, 1.06303714e-01f, -6.33797050e-01f, 2.21746750e-02f, -3.47294182e-01f, 4.14065421e-02f, 3.56417030e-01f, 1.28136292e-01f,
  -5.76512404e-02f, -1.85718134e-01f, -2.36324742e-01f, 1.99030757e-01f, -2.86349840e-02f, 1.19959354e-01f, -1.15049922e+00f, 3.33650589e-01f, -4.48338747e-01f, 2.97001719e-01f,
  -1.80401877e-01f, 5.37781119e-01f, -9.25646573e-02f, 2.24926502e-01f, -2.50917077e-01f, -5.52366637e-02f, -9.75090712e-02f, 1.61315218e-01f, 4.19265330e-02f, 5.84222376e-02f,
  -5.02685159e-02f, 1.09266780e-01f, 1.29978061e-01f, 1.92721501e-01f, 2.78665841e-01f, 1.83774605e-01f, 1.22950204e-01f, -1.78232297e-01f, 3.19583565e-01f, 2.77355611e-01f,
  1.77834369e-02f, -2.52478812e-02f, -1.00440778e-01f, -2.02454194e-01f, 4.29515429e-02f, 2.26574153e-01f, 2.50956491e-02f, 7.12619945e-02f, -1.89792225e-03f, 5.56706041e-02f,
  -7.35438466e-02f, 1.02593720e-01f, 5.33449315e-02f, 9.23387483e-02f, 2.18019541e-03f, -1.52277173e-02f, 4.31223176e-02f, -1.17881693e-01f, 5.96761517e-02f, -2.73803890e-01f,
  -1.27299964e-01f, 1.09658986e-01f, 1.93788588e-01f, -1.73477799e-01f, 8.04530829e-02f, 3.91830616e-02f, -1.26832187e-01f, 7.35594407e-02f, -1.58468813e-01f, -2.29139164e-01f,
  1.95927650e-01f, -1.38048828e-01f, 6.13985918e-02f, -1.54486224e-01f, 1.62308309e-02f, 1.44680589e-01f, -9.66185927e-02f, 1.98439062e-02f, -5.74705712e-02f, -1.39693394e-01f,
  -3.51570725e-01f, -7.74236694e-02f, 9.15911421e-02f, 7.62406141e-02f, -7.74005726e-02f, -7.77148232e-02f, 9.65889990e-02f, -9.45353433e-02f, -1.11539558e-01f, 3.82039472e-02f,
  2.45619714e-02f, -6.70227706e-02f, -6.20912388e-02f, -8.14519916e-03f, -7.36493096e-02f, -1.22902691e-01f, -1.36164069e-01f, 3.22783701e-02f, -3.38702738e-01f, -1.03913806e-01f,
  -2.00542122e-01f, 2.61929668e-02f, -1.03583738e-01f, -1.51816398e-01f, -2.97298580e-01f, -2.44234368e-01f, -1.59651190e-01f, 2.47187186e-02f, -8.94536898e-02f, -8.72880220e-02f,
  -1.44718277e+00f, 1.25562799e+00f, -3.64032462e-02f, 2.69424245e-02f, -4.68810230e-01f, 1.62857199e+00f, 7.04496205e-01f, 1.09634683e-01f, 2.64580905e-01f, 6.81482553e-01f,
  -8.28487054e-02f, -2.93999761e-01f, 3.30454230e-01f, 6.78071916e-01f, 4.89796966e-01f, 9.04750407e-01f, 8.27126741e-01f, 3.35038781e-01f, 1.17757954e-01f, -1.64656758e-01f,
  -1.05574347e-01f, 2.73516923e-01f, 1.55315623e-01f, 8.51461813e-02f, -4.06441927e-01f, -4.71053094e-01f, -4.72643137e-01f, -1.46099374e-01f, -8.46499205e-02f, -1.77368894e-02f,
  -3.27821225e-01f, -8.19373190e-01f, -3.67981762e-01f, 1.35424703e-01f, 2.86195539e-02f, -1.42575920e-01f, -1.06986009e-01f, -1.85397863e-01f, -3.93616527e-01f, 1.79802850e-02f,
  5.94243407e-02f, -1.32581398e-01f, 7.65050948e-02f, 9.86550897e-02f, -5.51196840e-03f, 6.74843118e-02f, 8.55683014e-02f, 8.79245996e-02f, 1.18722962e-02f, 1.69437155e-02f,
  5.50345425e-03f, -3.57127525e-02f, 1.90844852e-02f, 1.80423170e-01f, -2.47129127e-02f, 3.77733372e-02f, 1.33980438e-01f, -7.05190822e-02f, 1.90701149e-02f, 1.75338864e-01f,
  4.40973938e-02f, -6.32256791e-02f, 1.75240695e-01f, -8.99822339e-02f, 8.44013169e-02f, -2.15558693e-01f, 2.30922848e-02f, -1.92344919e-01f, -2.47039646e-02f, 8.90702754e-02f,
  7.24295676e-02f, -1.36481181e-01f, -1.22825481e-01f, 5.76132424e-02f, -7.16997981e-02f, -1.26402557e-01f, -1.59324616e-01f, -8.53207037e-02f, 1.18520990e-01f, -1.08599424e-01f,
  -7.53104175e-03f, 1.97649390e-01f, -5.25612421e-02f, -9.28389430e-02f, 1.54221281e-01f, -1.02350317e-01f, 1.27861341e-02f, 1.46830976e-01f, -7.10019991e-02f, 5.40936850e-02f,
  7.42092609e-01f, 3.72423440e-01f, 1.08172037e-02f, -5.49500957e-02f, 9.01991054e-02f, 1.21672139e-01f, 2.26677403e-01f, 4.23156321e-02f, 3.67475659e-01f, -2.12933235e-02f,
  -9.65001360e-02f, -1.20321862e-01f, -5.45699671e-02f, -6.45167157e-02f, 1.20972998e-01f, 2.52447456e-01f, 3.85609106e-03f, 5.68647345e-04f, 2.97479555e-02f, -1.73097298e-01f,
  -2.32322127e-01f, 7.57663175e-02f, -6.29332382e-03f, -2.27664821e-02f, -1.61911041e-01f, -7.57681429e-02f, -1.09945036e-01f, -5.10066897e-02f, -7.07790628e-02f, 1.45386010e-01f,
  -4.84937876e-02f, -2.67574131e-01f, -1.17778376e-01f, -2.01660588e-01f, 1.37222894e-02f, 1.51029835e-03f, -5.59024513e-01f, 2.42805243e-01f, -9.61488068e-01f, -2.14329690e-01f,
  5.28106987e-01f, -4.82670397e-01f, -3.12234648e-02f, 3.94265950e-01f, 7.27719367e-01f, -3.11279386e-01f, 5.49246430e-01f, 2.35226274e-01f, -7.26786768e-03f, 7.03334928e-01f,
  4.38172817e-01f, 7.59536445e-01f, 6.69211030e-01f, 8.01154196e-01f, 2.24433690e-01f, 2.91828156e-01f, 8.87922347e-01f, 2.19583586e-01f, 1.00418103e+00f, 2.54038990e-01f,
  -2.55878210e-01f, -9.17858910e-03f, -2.84213312e-02f, -2.07556084e-01f, 4.37057465e-01f, 7.22514018e-02f, 1.50605232e-01f, -1.04390793e-01f, -1.69835448e-01f, 7.52501981e-03f,
  -3.95258740e-02f, 1.74050078e-01f, 1.07733116e-01f, -1.52110860e-01f, -2.53705144e-01f, -1.55294195e-01f, 2.43793279e-02f, -2.59428650e-01f, -2.21389711e-01f, -1.97384544e-02f,
  -1.62577748e-01f, -2.61895776e-01f, -1.08057544e-01f, -4.98146750e-02f, -1.46897867e-01f, -7.01282695e-02f, -7.91194364e-02f, 6.71871752e-02f, -1.63309440e-01f, 2.67774072e-02f,
  1.87173232e-01f, -4.23750579e-02f, -1.11301236e-01f, -7.57792816e-02f, 8.31758827e-02f, 1.03878699e-01f, -6.77830130e-02f, 9.40958858e-02f, 2.87941638e-02f, 3.61745656e-02f,
  -2.50959788e-02f, 1.26508489e-01f, -1.34361982e-01f, -6.81261998e-03f, 1.93665490e-01f, -3.91585082e-02f, -2.78934222e-02f, -1.17467819e-02f, -2.47842327e-01f, 1.07965849e-01f,
  -3.90284769e-02f, 3.58389467e-02f, 6.02567755e-02f, -7.71605894e-02f, -3.22860003e-01f, 2.68947314e-02f, -9.97188240e-02f, -6.21290505e-02f, 9.36055034e-02f, 7.31016174e-02f,
  1.72678694e-01f, 6.92061782e-01f, -6.54247701e-02f, -2.42063329e-02f, 6.77438155e-02f, -7.07658157e-02f, -9.01992768e-02f, 2.43249044e-01f, 2.27855921e-01f, 1.41821846e-01f,
  3.20538610e-01f, -8.49313587e-02f, -3.94649319e-02f, 1.90148745e-02f, -5.37284603e-03f, 2.39815056e-01f, 3.00090760e-01f, -1.43892109e-01f, 8.63765702e-02f, 4.87167060e-01f,
  -5.10210656e-02f, 1.33335385e-02f, -8.82266536e-02f, -2.17975259e-01f, -1.03590637e-01f, 6.12948760e-02f, -3.30434814e-02f, 9.79150310e-02f, 1.96697831e-01f, -1.38875335e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 10)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 10;
const float L0_fan_Bp_bar_data[] = {
  6.52736187e-01f, 1.07269609e+00f, 1.44422853e+00f, 8.25037181e-01f, 1.40151715e+00f, 1.38436520e+00f, 1.09710336e+00f, 1.06535077e+00f, 1.16365767e+00f, 1.06212378e+00f
};

// L1_linear_W (Shape: 12 x 16)
const int L1_linear_W_rows = 12;
const int L1_linear_W_cols = 16;
const float L1_linear_W_data[] = {
  -1.51291084e+00f, 3.67123783e-01f, 2.91840792e-01f, 2.57462323e-01f, -1.24730229e+00f, 1.24489880e+00f, -1.06522632e+00f, 7.53274620e-01f, 4.66164559e-01f, -1.31655335e+00f,
  -7.54304767e-01f, -1.07705963e+00f, -1.02194679e+00f, -1.28460169e+00f, 6.83823109e-01f, -1.45177901e-01f, -3.98373783e-01f, -8.06225717e-01f, -4.52456959e-02f, 1.29457104e+00f,
  9.86239731e-01f, -1.46979654e+00f, -1.09202549e-01f, 2.44831070e-01f, -1.64575481e+00f, 1.24911821e+00f, -1.54112339e+00f, -3.82858127e-01f, -8.91298771e-01f, -1.03806973e+00f,
  2.33339801e-01f, 3.97651196e-01f, -2.22375527e-01f, 5.56182191e-02f, -9.25499052e-02f, -1.45474041e+00f, 5.93805552e-01f, 1.37953389e+00f, -1.06365490e+00f, 3.50697279e-01f,
  -9.40425813e-01f, 1.06941199e+00f, 3.02760988e-01f, -1.46859133e+00f, 2.37115532e-01f, -1.40173435e+00f, -1.51436770e+00f, 1.88917413e-01f, -5.28369486e-01f, -1.33790576e+00f,
  -3.99788260e-01f, -9.67493653e-01f, -7.37990975e-01f, 1.28452170e+00f, -7.96709120e-01f, -8.62793565e-01f, 9.81811404e-01f, -2.23680973e-01f, -1.12594450e+00f, -6.68900251e-01f,
  -1.34265375e+00f, 8.06513131e-01f, -9.13401604e-01f, -1.49015141e+00f, 1.18946008e-01f, -6.65233493e-01f, 6.94786966e-01f, 1.36006141e+00f, -1.45883751e+00f, 7.56816706e-03f,
  2.67627418e-01f, -1.74011075e+00f, -3.10396373e-01f, -3.49734753e-01f, 4.03175861e-01f, -1.46706581e+00f, -1.05171569e-01f, 7.41356552e-01f, 6.34798288e-01f, 4.95533943e-01f,
  6.73917711e-01f, 2.69989491e-01f, -6.84962392e-01f, 2.40220070e-01f, 1.27146173e+00f, -6.85782194e-01f, -5.67700714e-02f, 2.16030657e-01f, -1.95404291e+00f, -2.05823255e+00f,
  -2.52986133e-01f, 5.44088185e-01f, -8.23170185e-01f, 6.38241053e-01f, 8.27314317e-01f, -6.40929520e-01f, 1.18635230e-01f, -9.39605176e-01f, -7.13874280e-01f, -1.08127379e+00f,
  7.06412733e-01f, -1.38757813e+00f, -1.29532969e+00f, 5.17485559e-01f, -3.71973187e-01f, -6.43449545e-01f, 1.05147982e+00f, -4.10586923e-01f, 8.84069085e-01f, -6.05914788e-03f,
  -1.58250916e+00f, -1.62503839e+00f, -6.56314611e-01f, -6.33144975e-01f, -7.19478369e-01f, -9.90619302e-01f, -5.91396332e-01f, 7.46201873e-02f, 1.11106849e+00f, -9.05878007e-01f,
  -1.69890136e-01f, -1.22684181e+00f, 2.35400125e-01f, 3.46202850e-01f, -8.48036230e-01f, -8.21452916e-01f, -3.54542285e-01f, -7.34553933e-01f, 2.48099640e-01f, 3.50866280e-02f,
  -2.93395281e-01f, -5.88408768e-01f, 3.26747000e-01f, 7.47057736e-01f, -9.77640569e-01f, -1.15995932e+00f, -1.42986810e+00f, -1.01119375e+00f, 7.25618243e-01f, 4.10601735e-01f,
  -9.79901314e-01f, -8.63568664e-01f, -3.80674928e-01f, 1.21529543e+00f, -1.39738902e-01f, 1.07115173e+00f, 5.68931818e-01f, 1.23053098e+00f, -7.64011145e-01f, 7.23082542e-01f,
  8.18433702e-01f, 7.74792880e-02f, -1.68834043e+00f, -7.59491801e-01f, -7.07140863e-01f, -1.08567095e+00f, 1.00100243e+00f, -3.15003306e-01f, -1.10842347e+00f, -5.88057041e-01f,
  6.00008070e-01f, 1.15063584e+00f, 6.23021722e-01f, -8.87961626e-01f, 5.87393820e-01f, -1.24929988e+00f, -1.05639851e+00f, -1.19808292e+00f, 7.09352195e-01f, 7.40545630e-01f,
  -1.28144777e+00f, 2.85646260e-01f, -9.13291514e-01f, -1.44411969e+00f, -8.35321009e-01f, 2.70364076e-01f, 7.07855523e-01f, 4.37531114e-01f, 4.03846502e-01f, -3.60706180e-01f,
  3.89069349e-01f, 1.02295077e+00f, -1.08765388e+00f, -1.51614738e+00f, -8.11011612e-01f, -2.13340804e-01f, 1.03393841e+00f, 1.17372262e+00f, -6.82252407e-01f, 7.69529939e-01f,
  -1.19732916e+00f, -1.43269038e+00f
};

// L1_linear_B (Shape: 1 x 12)
const int L1_linear_B_rows = 1;
const int L1_linear_B_cols = 12;
const float L1_linear_B_data[] = {
  -2.53345549e-01f, -3.30401957e-01f, -9.31361020e-02f, 1.01563461e-01f, 2.96296626e-01f, 3.00992221e-01f, 2.85649389e-01f, -2.63941567e-02f, 9.27389041e-02f, 1.17227659e-01f,
  3.35764289e-01f, -1.53807089e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 3, 10
    );
    
    // Camada 1: L1_linear
    linear_forward_pgm(
        buffer1, x_out,
        L1_linear_W_data, L1_linear_B_data,
        16, 12
    );
    }
    