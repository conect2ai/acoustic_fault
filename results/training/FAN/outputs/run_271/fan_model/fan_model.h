/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 32 (x3)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 32;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    return (x > 0.0f) ? x : 0.0f;
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 9 x 120)
const int L0_fan_Wp_rows = 9;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -3.10918838e-01f, 3.62459868e-01f, -3.54434401e-01f, 2.21867666e-01f, -2.36716092e-01f, -2.58150995e-01f, -1.44097283e-01f, 9.53894779e-02f, 1.96095079e-01f, 1.52560696e-01f,
  1.84864399e-03f, -1.17401011e-01f, 7.87036791e-02f, 1.47534311e-01f, -1.19586080e-01f, 1.01084366e-01f, 1.61467358e-01f, 5.38279489e-02f, 1.61359891e-01f, 5.86129725e-02f,
  1.68072134e-02f, 1.78583279e-01f, -1.45504192e-01f, 5.63877933e-02f, -9.85463932e-02f, -1.02858320e-02f, 3.15804826e-03f, -1.41943559e-01f, -5.57867140e-02f, -1.21528264e-02f,
  1.36208653e-01f, 7.49802366e-02f, -8.94758385e-03f, 3.45304608e-02f, -4.70895544e-02f, -7.28414878e-02f, -1.89119410e-02f, -7.71292374e-02f, -4.66416068e-02f, -4.47796248e-02f,
  2.94679906e-02f, -9.76709947e-02f, 4.14410457e-02f, -3.40520963e-02f, -5.07782288e-02f, -3.78742144e-02f, -8.27584565e-02f, -1.86653435e-02f, -2.05082763e-02f, -7.26149231e-02f,
  -5.04980199e-02f, -3.69556025e-02f, 1.26902582e-02f, -6.06879499e-03f, -4.95699942e-02f, 3.07317544e-02f, 1.48951001e-02f, -6.03949353e-02f, -2.47399919e-02f, 1.59781780e-02f,
  -7.71856122e-03f, -4.56102379e-02f, -5.40279225e-02f, -3.07416189e-02f, -6.95744455e-02f, 4.19087559e-02f, -2.36716564e-03f, -3.65097821e-02f, -1.93379801e-02f, 7.24764988e-02f,
  2.59918906e-03f, 3.12961340e-02f, 5.94139770e-02f, -7.54950382e-03f, 7.22628385e-02f, 1.47865936e-02f, -2.32147407e-02f, -3.67936119e-02f, 9.98373106e-02f, -7.48212337e-02f,
  6.35853410e-02f, 3.82172293e-03f, -5.83050810e-02f, -3.86799197e-03f, 3.28360833e-02f, -6.86899433e-03f, 7.44364932e-02f, 9.63101105e-04f, -3.54891047e-02f, -5.00300191e-02f,
  3.49814832e-01f, 3.47444177e-01f, 1.05070189e-01f, -1.05375545e-02f, 5.30229285e-02f, 2.04347204e-02f, 5.15254885e-02f, -1.17861386e-02f, 1.02443263e-01f, 5.30800782e-03f,
  -1.57688316e-02f, 1.40393488e-02f, -4.96653421e-03f, -1.16174296e-02f, 6.04762323e-02f, 7.64039904e-02f, 1.31361382e-02f, 5.39501309e-02f, 7.69131705e-02f, 3.46376263e-02f,
  1.24386754e-02f, -1.23321554e-02f, -6.78959265e-02f, -2.37787627e-02f, 3.33598442e-02f, -7.87221193e-02f, 1.62943557e-03f, -3.33206654e-02f, -5.11549078e-02f, 1.46117918e-02f,
  -2.62405962e-01f, 2.16098025e-01f, -9.86356661e-02f, 2.30336547e-01f, -1.60746984e-02f, -1.54075562e-03f, -6.07152544e-02f, 2.00774685e-01f, -3.21140476e-02f, 1.26698524e-01f,
  6.71575963e-02f, 1.48584470e-02f, -1.59428827e-02f, 2.08434165e-01f, -7.07522929e-02f, -2.28289887e-02f, 1.53013781e-01f, 5.49959689e-02f, -3.30520011e-02f, 2.30238035e-01f,
  6.11857697e-03f, 2.24568173e-01f, -9.61571261e-02f, 1.06253557e-01f, -1.86056308e-02f, 1.11219957e-02f, 7.01556653e-02f, -2.36902405e-02f, 4.93491478e-02f, -7.23512173e-02f,
  -2.57704221e-02f, 2.59125661e-02f, -9.87556130e-02f, -3.05455606e-02f, -5.32602938e-03f, -4.53047417e-02f, -4.30746935e-02f, -5.39090261e-02f, -2.25498993e-02f, 5.10635264e-02f,
  4.46399720e-03f, 2.33538635e-02f, 1.14565110e-02f, 6.14228146e-03f, 5.93247032e-03f, -6.12912932e-03f, -3.53887654e-03f, -2.08101831e-02f, -2.36608256e-02f, -5.64137325e-02f,
  -4.81571108e-02f, 3.13267447e-02f, 3.86997871e-03f, 3.79107594e-02f, -3.70480791e-02f, 4.50413761e-04f, 1.92922056e-02f, -9.78875384e-02f, 4.74462695e-02f, -2.00870307e-03f,
  -6.64636344e-02f, 7.78024038e-03f, -9.75077786e-03f, 1.70081351e-02f, -2.37468048e-03f, 1.05841532e-02f, 2.63935924e-02f, 5.53240487e-03f, -5.78707196e-02f, 5.78227527e-02f,
  -2.78038420e-02f, 3.96778509e-02f, 3.28574553e-02f, 1.93490461e-02f, 2.84512155e-03f, -8.16136226e-03f, -3.99686992e-02f, 1.91155802e-02f, -1.77133258e-03f, 7.32216686e-02f,
  -3.72994915e-02f, 7.44427380e-04f, 2.38281637e-02f, -4.99474220e-02f, -3.34429853e-02f, -1.74410678e-02f, 3.05834245e-02f, -2.05746610e-02f, 1.56526715e-02f, -5.19285947e-02f,
  1.47095516e-01f, 1.98146284e-01f, -7.85186235e-03f, 3.90494498e-03f, 7.64943892e-04f, 2.17358731e-02f, -4.16931510e-02f, 3.63742709e-02f, -1.72613133e-02f, 3.79094109e-02f,
  2.31666937e-02f, -2.75562843e-03f, -1.43137854e-02f, 1.37777701e-02f, 1.94080770e-02f, 5.51701663e-03f, 1.94488242e-02f, 2.55091637e-02f, 8.86710510e-02f, 5.21581136e-02f,
  1.35728540e-02f, -5.07518947e-02f, -1.11739081e-03f, 2.26626433e-02f, 1.54080475e-02f, -5.03654741e-02f, -2.48988252e-02f, -2.25144695e-03f, -4.61713076e-02f, 1.59690995e-02f,
  1.22437961e-02f, -3.96425165e-02f, -9.82308388e-03f, -1.45428842e-02f, -5.55760823e-02f, -2.54182935e-01f, -4.11124051e-01f, 1.22507446e-01f, -1.82909016e-02f, -1.79569840e-01f,
  -1.20100208e-01f, -1.20077044e-01f, -2.91041166e-01f, -1.08657241e-01f, -2.08370760e-01f, -1.51052669e-01f, -1.12391464e-01f, -8.77873972e-02f, 7.72926286e-02f, 9.23047867e-03f,
  6.88878149e-02f, -3.91630046e-02f, 4.92054075e-02f, 1.23502150e-01f, 3.73491645e-02f, 3.06625754e-01f, 5.77050447e-02f, 1.63730308e-01f, 1.34013370e-01f, -1.99649464e-02f,
  -1.15887336e-02f, 3.91290784e-02f, 2.26570964e-02f, -7.19678104e-02f, -2.19310615e-02f, 3.19163278e-02f, 3.33306454e-02f, -1.00726023e-01f, 5.62615581e-02f, -5.38166352e-02f,
  1.58076882e-02f, -1.02288425e-02f, -8.21611658e-03f, -1.27588660e-02f, -4.13438231e-02f, 5.99980429e-02f, 3.56123014e-03f, 8.14766064e-02f, 5.26972003e-02f, -4.97720204e-02f,
  4.39088233e-02f, 5.46721295e-02f, 3.32838781e-02f, -3.51479836e-02f, 1.07325442e-01f, -4.01004665e-02f, 1.01352865e-02f, 2.31517274e-02f, 8.83807093e-02f, -1.37256524e-02f,
  1.94221474e-02f, -5.21019055e-03f, -6.35926053e-02f, -5.64074283e-03f, -9.92844030e-02f, 1.00418881e-01f, -6.06304146e-02f, 6.52917754e-03f, 9.27750859e-03f, -2.45838426e-02f,
  1.35502452e-02f, 3.88491787e-02f, 1.43830804e-02f, -1.46007845e-02f, 1.62200686e-02f, 6.23242706e-02f, -1.60315502e-02f, 6.41191974e-02f, 1.29906433e-02f, 8.43861550e-02f,
  -3.88526246e-02f, -2.18941811e-02f, -3.34483609e-02f, 2.01153178e-02f, -8.31133276e-02f, -2.30276398e-02f, -4.15425301e-02f, 4.48021330e-02f, 5.91458082e-02f, -2.87847891e-02f,
  -7.50813335e-02f, -1.41932875e-01f, -3.91718261e-02f, -1.08066415e-02f, -2.48398781e-02f, -2.61611436e-02f, -3.92756723e-02f, 7.27275908e-02f, -2.72992291e-02f, 8.83293338e-03f,
  1.62584502e-02f, 3.33706364e-02f, -3.43981944e-02f, 1.80203782e-03f, 4.49747220e-02f, -6.58589229e-02f, -1.20693920e-02f, 1.31970942e-02f, -1.54187044e-04f, 4.66059037e-02f,
  1.20519567e-02f, -3.43228914e-02f, 1.08207921e-02f, 5.57721108e-02f, 4.15822379e-02f, 9.46607848e-04f, 1.38992779e-02f, 2.26654876e-02f, -8.34031962e-03f, -5.55170923e-02f,
  -2.28462204e-01f, 7.44707882e-02f, 7.02335015e-02f, 6.84332475e-02f, -1.20931715e-01f, -1.78940937e-01f, -4.05155830e-02f, 1.92655642e-02f, 1.16848573e-01f, 6.11251667e-02f,
  -3.45061123e-02f, 1.85672715e-01f, 5.89304511e-03f, 6.83801472e-02f, -1.60182580e-01f, 7.42398873e-02f, -6.42030165e-02f, -5.12051694e-02f, 8.71827230e-02f, 3.18247476e-03f,
  -7.16889650e-02f, -9.32064746e-03f, 8.37720484e-02f, -4.89908736e-03f, -5.35051264e-02f, 6.09078854e-02f, 3.63451280e-02f, 2.26540565e-02f, -6.26319423e-02f, -5.81626073e-02f,
  7.76518509e-02f, 8.88316333e-02f, 2.78523080e-02f, 5.17835505e-02f, -1.10267945e-01f, -1.03395119e-01f, -5.89675941e-02f, 1.50719862e-02f, 3.00355069e-02f, -1.41917812e-02f,
  -4.51973714e-02f, 2.92543881e-02f, -7.09653134e-03f, 7.69184679e-02f, -1.50395595e-02f, 2.42572371e-02f, 2.41279881e-02f, 7.33867437e-02f, 5.18938974e-02f, -1.31114144e-02f,
  4.27119061e-02f, -8.19663890e-03f, -6.10474171e-03f, 6.14637844e-02f, 1.33355325e-02f, -3.36844958e-02f, 2.44095246e-03f, -4.33388054e-02f, -4.83867601e-02f, -4.05351035e-02f,
  -4.09391262e-02f, -3.38339922e-03f, 5.00323288e-02f, -3.76240797e-02f, 2.40998380e-02f, -6.73497468e-02f, -1.09823458e-02f, 1.70202386e-02f, 9.16598886e-02f, 3.17179710e-02f,
  -5.88739989e-03f, 2.19159648e-02f, -4.98934649e-02f, -3.30990665e-02f, 1.39554078e-02f, 4.77813520e-02f, -1.95188802e-02f, 4.62292321e-02f, -1.09857013e-02f, -2.08694413e-02f,
  3.25930007e-02f, 3.31364543e-04f, -3.00128032e-02f, 1.90438516e-02f, 4.81747277e-03f, -1.09193576e-02f, -1.64988060e-02f, -1.65081490e-02f, 4.53144237e-02f, 2.23281770e-03f,
  7.92345926e-02f, 7.27715492e-02f, 1.42957726e-02f, -7.91588705e-03f, -1.86656788e-02f, -4.68370207e-02f, -2.10802760e-02f, -4.74143624e-02f, -6.01794161e-02f, 1.45416204e-02f,
  -1.05125718e-01f, -4.15185988e-02f, -4.80057113e-02f, -5.21311723e-02f, -8.35884083e-03f, 1.59622694e-03f, 6.19486347e-02f, -2.43564714e-02f, -3.63516957e-02f, 2.89583635e-02f,
  -2.31856909e-02f, -1.58881713e-02f, 2.17403099e-02f, -7.69839287e-02f, -7.91450441e-02f, 1.87654085e-02f, 1.43322917e-02f, 5.41668423e-02f, -5.53757288e-02f, 4.92439754e-02f,
  -4.92067158e-01f, 1.53839797e-01f, -1.50023669e-01f, 1.09344706e-01f, -1.06151953e-01f, 6.19913675e-02f, -9.69551355e-02f, 1.22811981e-02f, -5.11422008e-02f, 1.10120878e-01f,
  -1.49855494e-01f, -1.00171734e-02f, -1.88616693e-01f, 1.85460642e-01f, -2.30509013e-01f, -5.88897988e-02f, -6.34635240e-02f, 3.22764367e-02f, 2.24886425e-02f, -1.65831763e-02f,
  -1.43205309e-02f, -9.46618337e-03f, -3.30484658e-02f, 6.60161078e-02f, 5.21899387e-02f, -1.38905980e-02f, -5.44998385e-02f, -4.58823629e-02f, 1.23419128e-01f, 2.62144804e-02f,
  -7.38460347e-02f, 9.40628797e-02f, 4.55640592e-02f, -9.17745307e-02f, -1.27128109e-01f, -6.32787272e-02f, -2.14470532e-02f, -1.82327386e-02f, 3.10828853e-02f, -3.96913178e-02f,
  -5.37862144e-02f, 1.78558286e-02f, -1.25346594e-02f, -5.54263629e-02f, 7.39675909e-02f, 1.25332875e-02f, 7.78542534e-02f, 3.91071700e-02f, 3.85881290e-02f, 7.12977648e-02f,
  6.91771060e-02f, 4.59788777e-02f, 1.00458167e-01f, -3.61482315e-02f, 5.79328500e-02f, 3.55448350e-02f, -4.00949493e-02f, 4.83815037e-02f, 2.84260120e-02f, 4.89663444e-02f,
  -1.08253516e-01f, -1.04961237e-02f, -4.41733412e-02f, 6.94366097e-02f, -2.79114433e-02f, -1.90164931e-02f, -8.50915257e-03f, -2.78796516e-02f, 4.08185422e-02f, -2.50654668e-03f,
  -3.53296474e-02f, 4.68216985e-02f, 9.27499402e-03f, -2.22212188e-02f, -1.38082346e-02f, 1.08547695e-02f, -3.33164632e-02f, 2.44744886e-02f, 5.44436872e-02f, 2.73853056e-02f,
  -2.12888612e-04f, -5.03693633e-02f, 2.80192681e-02f, 5.66782095e-02f, -6.15516230e-02f, -5.21879271e-02f, 3.04041114e-02f, 5.33609651e-02f, -4.60690595e-02f, -1.19852014e-02f,
  -1.48380369e-01f, -2.02639788e-01f, -5.08868247e-02f, 3.27419639e-02f, 2.60346639e-03f, 4.04117256e-02f, -6.81620091e-03f, -5.35688084e-03f, -6.29947335e-03f, -2.82526631e-02f,
  -1.50970276e-02f, -1.67352762e-02f, -3.25617045e-02f, 2.72143167e-02f, -4.57326472e-02f, 4.45281044e-02f, -2.75286399e-02f, -2.20672768e-02f, -3.43632549e-02f, 1.81141328e-02f,
  1.29090529e-02f, -7.97714815e-02f, 5.39820231e-02f, -1.53721105e-02f, 4.04005349e-02f, 3.51470616e-03f, 2.83865957e-03f, 2.44714245e-02f, -3.26835923e-02f, -3.80383357e-02f,
  -4.53410089e-01f, -2.00763047e-01f, -4.17129546e-01f, -1.21019110e-01f, -2.69064829e-02f, -9.27546099e-02f, -1.21214405e-01f, -7.75169060e-02f, -2.92890817e-01f, 8.21491256e-02f,
  8.16563368e-02f, -2.45307893e-01f, -4.38364595e-02f, -2.25241296e-03f, -1.41085654e-01f, 3.15850973e-02f, -6.57888874e-02f, -2.13508941e-02f, -4.17477898e-02f, -7.26979747e-02f,
  -5.68760037e-02f, 2.40818560e-01f, -4.06607203e-02f, 2.60626763e-01f, -1.20426439e-01f, -5.00696301e-02f, 1.38092771e-01f, 6.53361529e-02f, 5.30688129e-02f, 5.91628924e-02f,
  -1.10323699e-02f, 3.02664861e-02f, -5.39612286e-02f, -1.16848294e-02f, -6.05023876e-02f, 1.39015773e-02f, -1.71804074e-02f, 2.66481824e-02f, 2.26706900e-02f, -9.70328518e-04f,
  -1.76188909e-02f, 5.02229035e-02f, 2.13482473e-02f, 1.87302344e-02f, 4.87633087e-02f, -5.16378693e-02f, 6.01179749e-02f, -6.90030828e-02f, -2.63935998e-02f, -2.51443628e-02f,
  -7.48620108e-02f, -5.84126590e-03f, -3.50511000e-02f, 7.03359628e-03f, -2.74608079e-02f, 2.78737815e-03f, -1.39333885e-02f, -6.01018630e-02f, -1.73123330e-02f, -6.35480462e-03f,
  5.28782886e-03f, -4.04507443e-02f, 3.06882318e-02f, 1.95853896e-02f, -7.34890404e-04f, 3.40549462e-02f, 4.76085320e-02f, 1.06807940e-01f, -5.26423417e-02f, 5.66657372e-02f,
  1.33572584e-02f, -1.78213548e-02f, 4.52665798e-03f, 2.57109348e-02f, 2.35164780e-02f, 2.66848598e-02f, 1.19054131e-02f, 1.46535505e-02f, -2.91434005e-02f, 2.55600549e-02f,
  1.34376921e-02f, -1.93356480e-02f, 2.13115700e-02f, -4.95533692e-04f, 7.82723203e-02f, -1.81182567e-02f, 2.16400661e-02f, -4.86806780e-02f, -1.84576623e-02f, -4.15978068e-03f,
  -4.74087559e-02f, -8.46139267e-02f, -9.33851209e-03f, 3.45925428e-03f, 4.30553667e-02f, 3.51799950e-02f, 1.11138821e-03f, -2.80895382e-02f, -4.65077646e-02f, -5.65657094e-02f,
  -9.37903672e-03f, 3.92317846e-02f, -8.37309137e-02f, 8.20438266e-02f, -2.02913792e-03f, 2.26999801e-02f, 4.97800037e-02f, 5.40594086e-02f, 1.06825447e-02f, -1.81235448e-02f,
  1.39678456e-03f, 1.42315188e-02f, -4.25579362e-02f, 1.24366442e-02f, 3.30177732e-02f, 5.06802229e-03f, -4.14715111e-02f, -1.21601811e-02f, 2.70913467e-02f, 1.26047796e-02f,
  -6.82218894e-02f, -2.57736802e-01f, -3.62069368e-01f, -2.10859522e-01f, 1.66432664e-01f, 1.83250308e-01f, -5.25384322e-02f, 8.97942111e-03f, -2.08639443e-01f, -2.32498087e-02f,
  7.34835267e-02f, -2.49169052e-01f, -6.43382147e-02f, 4.02854867e-02f, 1.03407383e-01f, -1.29615769e-01f, 1.57668114e-01f, -6.01149127e-02f, -1.42173365e-01f, -4.56901751e-02f,
  -3.69788078e-03f, 1.38818592e-01f, -3.86601537e-02f, 1.05375655e-01f, -1.92710441e-02f, -1.42202735e-01f, 2.31711447e-01f, -9.94045287e-02f, 3.60488258e-02f, 3.46258916e-02f,
  -2.58575305e-02f, -5.09695895e-02f, -2.25783996e-02f, -6.00620620e-02f, 2.36000121e-02f, 7.34260976e-02f, 4.32587378e-02f, -2.12430153e-02f, 2.43612682e-03f, -5.16983233e-02f,
  -6.04991950e-02f, 2.10530702e-02f, -3.46218795e-02f, 4.06750217e-02f, -1.85208619e-02f, -5.73348328e-02f, -3.19140814e-02f, 5.17351460e-03f, -7.56552890e-02f, -1.67192630e-02f,
  -5.24196960e-03f, 9.25847888e-03f, 2.94037387e-02f, 3.77926342e-02f, -9.96859558e-03f, 1.90555323e-02f, -2.09176652e-02f, -4.73391265e-02f, 4.21347423e-03f, -1.41707826e-02f,
  8.93874317e-02f, 3.44667621e-02f, -2.48560607e-02f, -1.61762126e-02f, -3.92633677e-02f, 3.92973889e-03f, 4.18612733e-02f, 7.47988820e-02f, 2.81459484e-02f, -3.51392739e-02f,
  3.67259048e-02f, -7.22023174e-02f, -8.56076367e-03f, 5.90764843e-02f, -3.13561298e-02f, 2.24519968e-02f, -2.56674960e-02f, 2.23191734e-02f, -1.03191175e-02f, 5.08432556e-03f,
  2.48417463e-02f, 3.97754014e-02f, -5.78629822e-02f, 4.38529812e-02f, -5.28285801e-02f, -2.77406741e-02f, 2.40338668e-02f, -5.33836968e-02f, -4.08671089e-02f, 3.72717492e-02f,
  6.99400231e-02f, -1.94259677e-02f, -6.01013526e-02f, -2.13219374e-02f, -5.58057800e-02f, -1.12382881e-02f, -1.49090737e-02f, -2.10322137e-03f, -3.44186500e-02f, 9.51317418e-03f,
  1.86393112e-02f, 4.20690477e-02f, 5.51535562e-02f, -2.74762437e-02f, 1.47113067e-04f, 5.17406203e-02f, 1.58923827e-02f, 4.16849069e-02f, 6.43902197e-02f, -1.83172431e-02f,
  2.47992668e-02f, -5.18627875e-02f, 2.65026651e-02f, 3.07077263e-02f, 7.59908035e-02f, 4.33391035e-02f, 1.57096200e-02f, 3.25547792e-02f, 1.60784218e-02f, 3.32313892e-03f,
  5.69863915e-01f, -9.94410440e-02f, -6.59162924e-02f, 1.61944345e-01f, 7.72737190e-02f, -6.89596906e-02f, 1.03452139e-01f, 1.08780935e-01f, 1.58823058e-01f, -7.76958615e-02f,
  6.58739954e-02f, -4.29218747e-02f, -7.98017532e-02f, 4.67485450e-02f, 3.17816973e-01f, 5.29727479e-03f, 1.20194294e-01f, 5.75812953e-03f, 5.57885170e-02f, 2.86071580e-02f,
  2.05803979e-02f, 3.96536663e-02f, 7.93685764e-02f, 5.71004078e-02f, 5.54431714e-02f, -1.20315209e-01f, 1.48437582e-02f, -2.83237044e-02f, -9.85038932e-03f, 6.92733657e-03f,
  -4.61049154e-02f, -6.12383075e-02f, 3.84753607e-02f, -9.63081196e-02f, -3.89404334e-02f, -7.40975961e-02f, -5.67720458e-02f, 2.70930957e-02f, 6.41560107e-02f, 1.61846219e-05f,
  -4.22699302e-02f, 5.76709211e-03f, -1.40081067e-02f, -9.42499842e-03f, 5.44975474e-02f, -2.58483309e-02f, 3.76594216e-02f, -4.15455475e-02f, -3.27808782e-02f, -2.51064990e-02f,
  -1.74449664e-02f, 4.48967740e-02f, 3.93844210e-02f, -1.33521721e-01f, -2.32168380e-03f, -1.19958511e-02f, -6.35200962e-02f, -6.98276283e-03f, -1.49833225e-02f, -2.15278063e-02f,
  -8.42684731e-02f, 6.80315420e-02f, 3.82338353e-02f, 1.09851062e-02f, 9.02781379e-04f, 2.85408017e-03f, 8.54251757e-02f, -2.54838243e-02f, 3.63882408e-02f, 6.98575191e-03f,
  1.46172550e-02f, 3.13009396e-02f, 5.55283297e-03f, -1.26665346e-02f, 5.50038628e-02f, 3.06503400e-02f, 3.36555988e-02f, -2.02592332e-02f, -1.35242166e-02f, 4.97168191e-02f,
  3.97428572e-02f, 6.00823984e-02f, -6.18350692e-03f, 2.87374551e-03f, 1.15699563e-02f, 5.19497991e-02f, 2.04178859e-02f, 4.37820563e-03f, 3.84562351e-02f, -1.51134224e-03f,
  -8.19976628e-02f, -9.36360359e-02f, -6.57367632e-02f, 3.14996690e-02f, -4.84341457e-02f, -2.68931575e-02f, 7.62428194e-02f, 9.25076369e-04f, -6.22806363e-02f, 4.20655217e-03f,
  -1.02933429e-01f, -1.94238629e-02f, -5.00682481e-02f, -4.50256765e-02f, 1.16935289e-02f, -1.05237355e-02f, 1.49758309e-02f, 3.28911631e-03f, 7.20159849e-03f, 3.84540409e-02f,
  -1.59419291e-02f, -1.73913650e-02f, -1.60203129e-02f, 1.82433836e-02f, 7.33668637e-03f, -2.65310481e-02f, -1.45250931e-02f, -4.18404900e-02f, -2.62452848e-02f, -4.01734598e-02f,
  -1.94892138e-01f, -9.26560070e-03f, 3.32855247e-02f, 4.05841209e-02f, -1.83839932e-01f, 1.62639394e-02f, 2.16893107e-01f, -5.25099263e-02f, 1.08942213e-02f, 7.96431676e-02f,
  -7.08278939e-02f, -3.15006226e-02f, 1.92250475e-01f, -6.16351552e-02f, 2.36614108e-01f, 2.42827579e-01f, -5.27380146e-02f, -3.11501026e-02f, -1.81730334e-02f, -4.60661761e-02f,
  -1.29085155e-02f, -4.30002846e-02f, 1.52925462e-01f, -8.81126896e-02f, -6.29914645e-03f, -7.67089501e-02f, 5.95442727e-02f, 1.61943302e-01f, -1.03310980e-01f, 2.25060340e-02f,
  -1.67907596e-01f, -1.85104802e-01f, -6.37522936e-02f, -1.56325232e-02f, -7.45751783e-02f, 4.31999862e-02f, -5.28764771e-03f, 9.97372419e-02f, 1.12675196e-02f, -1.25171850e-02f,
  3.38936411e-02f, -5.29852360e-02f, -6.72465712e-02f, 3.41676921e-02f, -1.30957924e-04f, -5.65441623e-02f, -8.38457868e-02f, -7.55533250e-03f, -5.21422736e-02f, -3.28208432e-02f,
  -1.32205114e-02f, -8.26860443e-02f, -1.63355283e-02f, -2.53191926e-02f, 3.23580019e-02f, -5.25598750e-02f, -1.77837946e-02f, 2.69860327e-02f, -3.11176330e-02f, -5.33909537e-03f,
  -1.88505594e-02f, 1.32159457e-01f, -6.46014512e-02f, 1.78881772e-02f, -3.66337784e-02f, 5.54439146e-03f, -3.35859805e-02f, -3.30997892e-02f, 5.52499853e-02f, -6.56690598e-02f,
  -7.62106627e-02f, -1.01533905e-02f, -1.85625465e-03f, 1.57552566e-02f, -7.64206350e-02f, 3.28270942e-02f, -7.35189095e-02f, 5.30621856e-02f, 4.95899329e-03f, -2.31415406e-02f,
  1.90879889e-02f, -7.70715298e-03f, 8.81005265e-03f, 4.47879881e-02f, -2.91487388e-02f, 6.53857663e-02f, -3.34295146e-02f, 4.02858518e-02f, 2.30489317e-02f, -1.22428552e-04f,
  5.92275104e-03f, 5.86405843e-02f, -1.01310924e-01f, -1.15529172e-01f, -2.19397731e-02f, -4.38209949e-03f, 3.71831208e-02f, -3.33431736e-02f, 1.03789821e-01f, 3.80639769e-02f,
  -1.35669112e-02f, 4.48635109e-02f, 1.36749190e-03f, -3.73461726e-03f, 9.49065108e-03f, 8.99219234e-03f, 6.52535558e-02f, 7.59829814e-03f, 1.67785976e-02f, -2.27282923e-02f,
  -5.11828251e-03f, 7.35088438e-02f, 4.14367095e-02f, -1.83853377e-02f, 1.98132079e-03f, 3.38780321e-02f, -6.59223367e-03f, 4.12753150e-02f, -4.10294570e-02f, -2.01062858e-02f
};

// L0_fan_Wp_bar (Shape: 14 x 120)
const int L0_fan_Wp_bar_rows = 14;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  1.39287800e-01f, -1.20650224e-01f, 1.61835939e-01f, 2.19400659e-01f, -2.75738770e-03f, -2.10612655e-01f, -1.47660077e-01f, 6.93016425e-02f, 6.75509721e-02f, -9.72384289e-02f,
  8.04705452e-03f, -1.26824707e-01f, -1.09147862e-01f, 1.43999919e-01f, 1.28768101e-01f, -1.45564750e-01f, -2.23886203e-02f, -2.40607113e-02f, 6.80028573e-02f, 1.14049017e-01f,
  1.86509296e-01f, -8.03865120e-03f, 1.07013494e-01f, 1.89257003e-02f, 1.31599978e-01f, 1.59849659e-01f, 1.40717790e-01f, -6.88471552e-03f, 7.32313916e-02f, -4.43121279e-03f,
  -6.17772378e-02f, 8.13798700e-03f, 2.35083085e-02f, -9.88951623e-02f, 5.04300445e-02f, -9.93353426e-02f, -6.41432330e-02f, 9.28574987e-03f, 6.71819746e-02f, 1.51523948e-02f,
  -5.08660898e-02f, -1.98141504e-02f, 2.80890726e-02f, 5.32810353e-02f, -4.06032838e-02f, 3.66165396e-03f, -4.79128398e-03f, 1.63015686e-02f, 3.52310464e-02f, -6.02527969e-02f,
  -5.81546389e-02f, -7.92109892e-02f, 4.07728963e-02f, 4.05460000e-02f, 7.84268230e-02f, 2.85862800e-04f, -1.29333045e-02f, 1.19050052e-02f, 1.71370246e-02f, 2.68864315e-02f,
  1.22729000e-02f, -4.67382818e-02f, 2.00882591e-02f, -2.76866592e-02f, -5.58018126e-02f, -4.10500094e-02f, -3.89623418e-02f, 2.55730357e-02f, 2.77910996e-02f, -8.35399423e-03f,
  1.44929904e-02f, 4.24215421e-02f, -1.22017907e-02f, -7.11053461e-02f, 1.15149766e-02f, -4.97130379e-02f, -1.55530125e-02f, 1.00138962e-01f, -3.54338961e-04f, 5.15525304e-02f,
  -5.75557351e-02f, 2.26109922e-02f, 1.16549553e-02f, 9.27586928e-02f, -4.29959036e-03f, -4.11456190e-02f, -7.92840421e-02f, 1.59712434e-02f, 3.30814384e-02f, 2.88950782e-02f,
  -1.30218297e-01f, 3.44002023e-02f, -1.48820439e-02f, -6.85807616e-02f, -7.20129116e-03f, -2.30692723e-03f, -6.36666715e-02f, 3.57313789e-02f, -4.90040816e-02f, 1.16334893e-02f,
  -7.74898753e-02f, 3.91326509e-02f, 4.41432605e-03f, 4.16006185e-02f, -4.69449461e-02f, 9.01387557e-02f, -1.13372952e-02f, -2.75476538e-02f, -6.88706487e-02f, 4.06356044e-02f,
  3.43092307e-02f, -3.86919416e-02f, -4.55773920e-02f, 8.73493552e-02f, -7.18972925e-03f, 3.21371295e-02f, -1.26790954e-02f, -1.57831572e-02f, -7.36237764e-02f, -2.54722014e-02f,
  7.55102187e-03f, 7.89210573e-02f, -2.46129613e-02f, 3.46417964e-01f, 2.16282047e-02f, -3.01112235e-02f, -4.56832582e-03f, 7.06995651e-02f, -2.40527578e-02f, 4.66015525e-02f,
  1.36043116e-01f, -5.11740742e-04f, 8.26361775e-03f, 2.31683165e-01f, 2.96699375e-01f, 5.06820716e-02f, 2.24306032e-01f, -4.09266204e-02f, 1.23214489e-02f, 7.35741332e-02f,
  1.55893847e-01f, 2.95055419e-01f, 5.64179011e-02f, 1.28185734e-01f, 1.45163625e-01f, 1.34384617e-01f, 2.36918002e-01f, 2.40907390e-02f, 3.06831151e-01f, 9.22447443e-02f,
  1.40994946e-02f, 1.36013450e-02f, 1.36028863e-02f, -8.17657709e-02f, 3.60194109e-02f, 6.22141473e-02f, -4.91536707e-02f, -6.52479753e-02f, 1.73761100e-02f, -1.55763011e-02f,
  2.82607134e-02f, -1.07312743e-02f, 2.43231151e-02f, -1.94068812e-02f, -3.23442109e-02f, 3.12204808e-02f, -2.96566859e-02f, 9.44288075e-03f, -5.66573292e-02f, 4.23251726e-02f,
  -3.88699137e-02f, -1.94984358e-02f, 6.21907525e-02f, -4.59589437e-02f, 1.76009350e-02f, 5.27879074e-02f, -3.78657170e-02f, 2.44557764e-02f, 1.01284869e-01f, 3.39908414e-02f,
  4.29412536e-02f, -7.77827129e-02f, -1.92446995e-03f, 2.03309171e-02f, 5.61355054e-02f, -4.68340181e-02f, -1.46813020e-02f, -5.84524907e-02f, 8.52314476e-03f, 5.20789362e-02f,
  5.52255660e-02f, -1.46480585e-02f, -4.14878735e-03f, -7.93941021e-02f, 2.31476407e-03f, -5.36023751e-02f, -4.99356203e-02f, 2.32066624e-02f, 8.76690913e-03f, 8.13222583e-03f,
  -1.13845337e-03f, 3.26325931e-02f, 3.94908972e-02f, 1.56914610e-02f, 4.76819044e-03f, 2.35391152e-03f, 3.97447757e-02f, 5.62075973e-02f, 1.87347960e-02f, 1.02634495e-02f,
  9.70257148e-02f, 2.64530152e-01f, -2.09471956e-03f, -9.00915265e-02f, -4.64632772e-02f, -2.27452181e-02f, -3.21826898e-03f, 1.29551739e-01f, 1.08592369e-01f, 4.83427010e-02f,
  -3.69780585e-02f, -1.10791638e-01f, -9.19021852e-03f, -2.02793777e-02f, -4.81742956e-02f, 7.89884999e-02f, 2.51321215e-03f, -1.09622627e-02f, 1.40607730e-01f, 2.14460474e-02f,
  8.69607553e-03f, 8.39951169e-03f, -4.45490563e-03f, -8.94427449e-02f, 3.37137878e-02f, 4.39260080e-02f, 5.10891937e-02f, -4.08017039e-02f, 3.33621502e-02f, -2.53793094e-02f,
  -4.73791268e-03f, -3.64010006e-01f, 1.10957593e-01f, 1.16641052e-01f, 1.94838166e-01f, 1.25259191e-01f, 1.32573545e-01f, -8.99773687e-02f, -4.79838671e-03f, -2.75823802e-01f,
  -3.59293073e-02f, -1.61699668e-01f, 4.86335456e-02f, -1.34615615e-01f, 1.11951470e-01f, -3.94147821e-02f, 9.54718981e-03f, -7.26405531e-02f, 7.12258965e-02f, -5.06144278e-02f,
  5.55745587e-02f, -1.02831377e-02f, -9.03096702e-03f, -6.64992854e-02f, 1.00178398e-01f, -7.49177262e-02f, 1.65582579e-02f, 3.07836607e-02f, -1.54137556e-02f, 1.13354838e-02f,
  4.66847196e-02f, -6.43857792e-02f, -3.99229750e-02f, -2.42716596e-02f, -1.62946228e-02f, -4.05781195e-02f, -1.00868732e-01f, -7.88569823e-03f, 8.88732448e-02f, 1.63784996e-02f,
  -1.66552681e-02f, -3.25661749e-02f, -1.32205384e-02f, 7.21267564e-03f, -2.18235911e-03f, 3.54936011e-02f, 3.74895334e-02f, 4.39269692e-02f, -9.01276525e-03f, 4.30811495e-02f,
  9.77316573e-02f, -5.39068170e-02f, 1.02929696e-01f, -1.11843929e-01f, -3.46442647e-02f, 2.22339705e-02f, -4.98463437e-02f, 6.95025101e-02f, -2.39060111e-02f, -8.70551914e-02f,
  -9.10705030e-02f, -7.01905787e-02f, -7.82353710e-03f, 5.40573969e-02f, 1.30696606e-03f, 6.39299154e-02f, -6.26628771e-02f, 1.53861195e-02f, -2.18789652e-02f, 9.22763720e-02f,
  4.99404743e-02f, -1.21501200e-02f, 1.80581603e-02f, 3.45764607e-02f, -1.07741386e-01f, 4.89811823e-02f, -2.56533902e-02f, 2.09270623e-02f, -4.54055443e-02f, -7.15190619e-02f,
  4.91404086e-02f, -1.01316988e-01f, -1.10978552e-03f, 6.87914491e-02f, 6.03591762e-02f, 2.68676854e-03f, 3.41976136e-02f, 7.36112297e-02f, 1.14691239e-02f, 1.00153871e-02f,
  3.68677117e-02f, -1.52089089e-01f, -7.82853588e-02f, 8.72313697e-03f, -6.84151500e-02f, 5.32655455e-02f, -2.55159903e-02f, -4.80560064e-02f, -9.00805816e-02f, 2.13239491e-02f,
  8.57351422e-02f, -8.69715307e-03f, -9.68691409e-02f, 9.42784324e-02f, -4.21791598e-02f, -7.45798834e-03f, -7.31718019e-02f, -7.99593702e-02f, 2.85645854e-03f, -5.72216734e-02f,
  -6.85468167e-02f, 3.16850021e-02f, -1.75216049e-02f, -6.05617091e-02f, -5.67505509e-02f, 1.63575727e-03f, -3.69816087e-02f, -5.43137863e-02f, -4.84183133e-02f, 8.03982187e-03f,
  8.45461860e-02f, -2.93171555e-01f, -3.05113256e-01f, -2.36124694e-01f, -1.30661875e-01f, -2.94096410e-01f, -2.34320670e-01f, -2.09002525e-01f, -1.72137678e-01f, 5.25650568e-02f,
  -7.69985989e-02f, -2.39094645e-02f, 1.15744174e-01f, -9.92340297e-02f, 2.42131297e-02f, 1.03443988e-01f, -2.33241707e-01f, -3.84540968e-02f, -4.91756499e-02f, -2.19928741e-01f,
  5.15612513e-02f, -1.17971353e-01f, 1.10697933e-02f, -4.69139926e-02f, -1.07155405e-01f, -2.93672271e-02f, 3.51909250e-02f, -1.68837562e-01f, -8.86758789e-02f, 5.90746570e-03f,
  3.39514725e-02f, 9.72298086e-02f, -6.05153479e-02f, -5.70548885e-02f, -6.13480136e-02f, -8.11240748e-02f, -2.14325301e-02f, -1.38025377e-02f, 7.40294084e-02f, -4.00022380e-02f,
  5.56858927e-02f, 6.85878173e-02f, -7.21085295e-02f, 5.44501357e-02f, -6.08247519e-03f, -3.16351606e-03f, -4.78905886e-02f, -4.67857532e-02f, -6.50652125e-02f, 1.00198895e-01f,
  8.36630538e-03f, -1.75766554e-02f, -8.15405603e-03f, 8.65937024e-03f, -9.64346305e-02f, -1.90812373e-03f, 7.74604362e-03f, 7.14167804e-02f, 1.87891982e-02f, -3.86423096e-02f,
  -2.69468166e-02f, -7.51118641e-03f, 1.63639360e-03f, -4.12884578e-02f, 3.34144942e-02f, -2.55837268e-03f, -3.15656252e-02f, 6.93350062e-02f, -9.43011567e-02f, 6.43198844e-03f,
  -7.97146633e-02f, 7.63193592e-02f, -5.78975305e-02f, -4.43279892e-02f, -8.57725069e-02f, -1.98077001e-02f, 1.17779270e-01f, -8.44600201e-02f, -2.37321202e-02f, 3.12307104e-02f,
  -9.16576828e-04f, 7.22435042e-02f, 9.58334003e-03f, -8.14647451e-02f, -5.53488098e-02f, -3.85200791e-02f, -8.08296204e-02f, 1.19274572e-01f, 6.47219345e-02f, -4.48103715e-03f,
  -1.36600956e-01f, 1.94692854e-02f, -6.19994216e-02f, -4.99717109e-02f, -5.84641546e-02f, 1.80888940e-02f, 2.17018723e-02f, -2.39129700e-02f, -1.24922752e-01f, -5.75025491e-02f,
  -6.84184656e-02f, -2.62324996e-02f, 4.01941016e-02f, 3.43276933e-02f, -4.51337025e-02f, -7.35426620e-02f, -6.65695369e-02f, 3.26176658e-02f, -9.04110968e-02f, 6.15529791e-02f,
  -2.32014544e-02f, 3.77407148e-02f, 4.72633354e-02f, -5.28042018e-02f, -4.46569640e-04f, -4.07674070e-03f, -1.36145409e-02f, -8.05649608e-02f, -8.78046602e-02f, -6.89174756e-02f,
  -1.65652707e-01f, -9.94625911e-02f, -1.22609764e-01f, 8.86383560e-03f, -1.74989328e-01f, 2.44205266e-01f, 2.23448768e-01f, 1.48953293e-02f, -1.56780049e-01f, 3.28353494e-01f,
  1.99705243e-01f, -1.30339667e-01f, 7.87894428e-02f, 2.89911568e-01f, -5.03686331e-02f, 1.76307738e-01f, 2.08309412e-01f, 2.16313392e-01f, -1.60050839e-01f, 5.25314547e-03f,
  -7.03876615e-02f, 1.64842889e-01f, 7.32705072e-02f, -6.31420240e-02f, 1.26143903e-01f, -1.44168168e-01f, 7.72821233e-02f, -1.36038661e-01f, 1.57385036e-01f, -2.14154497e-02f,
  1.14868760e-01f, -1.60292070e-02f, 1.75074525e-02f, -2.95806415e-02f, 8.19759667e-02f, 1.60126500e-02f, -4.46900241e-02f, 1.40459267e-02f, -3.48641723e-02f, -3.25266123e-02f,
  -1.03153987e-02f, -5.29446676e-02f, 3.12194247e-02f, -6.18940219e-02f, -8.39783251e-02f, -1.22969434e-01f, -5.20883091e-02f, -3.43822315e-02f, -1.57519449e-02f, 2.96330894e-03f,
  1.30503913e-02f, 2.01427806e-02f, 1.76484641e-02f, -6.64609745e-02f, -7.08009824e-02f, -2.27589402e-02f, 1.57496687e-02f, 6.92258850e-02f, 3.43356235e-03f, -9.53690242e-03f,
  2.78904513e-02f, -1.11143272e-02f, 8.09630528e-02f, 3.01134624e-02f, -6.84304684e-02f, 2.23263185e-02f, 6.31854534e-02f, -1.01732478e-01f, -2.75732428e-02f, 3.07721458e-02f,
  1.43052218e-02f, -3.32741439e-02f, -1.60416849e-02f, -8.62875674e-03f, 7.48737380e-02f, 1.15125015e-01f, 5.64166605e-02f, -2.85324641e-02f, -1.01038434e-01f, -2.08925512e-02f,
  1.85554884e-02f, -8.85631330e-03f, 4.30179611e-02f, 5.97023629e-02f, 5.35225049e-02f, -2.06031483e-02f, -5.88937216e-02f, -5.02429754e-02f, -4.35640989e-03f, 4.17276695e-02f,
  2.86197457e-02f, -9.26994607e-02f, 1.55261913e-02f, 1.34255262e-02f, -4.80368324e-02f, 2.35230546e-03f, 1.13157649e-02f, -2.47963984e-02f, 2.01778151e-02f, 2.73500904e-02f,
  8.43067071e-04f, -1.98577419e-02f, 4.13675196e-02f, -3.98822688e-02f, 2.46005766e-02f, 5.84080778e-02f, 8.78331661e-02f, -7.06369281e-02f, -2.27382295e-02f, -5.79933682e-03f,
  -1.04766503e-01f, 3.40232402e-02f, 1.52361894e-03f, 7.44034126e-02f, 2.01739483e-02f, 7.71775767e-02f, -6.71456233e-02f, -3.61036807e-02f, 5.03270514e-02f, -4.10283357e-02f,
  -3.48002791e-01f, 5.96210584e-02f, -4.99321669e-02f, -2.85622030e-01f, 4.10842635e-02f, -2.05705687e-01f, -2.20306531e-01f, -9.86535177e-02f, -1.51996002e-01f, -2.29802489e-01f,
  -1.74901232e-01f, -7.20637094e-04f, 1.05490930e-01f, -2.06540436e-01f, 5.23674935e-02f, 1.41108006e-01f, -2.77495474e-01f, -2.35854939e-01f, 1.52683392e-01f, -1.65429235e-01f,
  -8.10167342e-02f, -1.00938469e-01f, 5.18151373e-02f, 9.57336947e-02f, -1.78445920e-01f, -8.10606033e-02f, -8.20934325e-02f, 1.25246167e-01f, -7.98595026e-02f, 1.20949440e-01f,
  -1.43665269e-01f, -2.39014298e-01f, -7.02920705e-02f, -7.39225671e-02f, -1.45625219e-01f, -2.14564949e-02f, -1.06202140e-01f, 7.74093345e-02f, 2.06429884e-02f, 7.51495594e-03f,
  4.73026447e-02f, 3.65558788e-02f, -2.13198103e-02f, 1.05228843e-02f, 1.22609828e-02f, 1.42680090e-02f, 9.14473012e-02f, -3.72923873e-02f, 2.38788724e-02f, 1.09830491e-01f,
  7.05181286e-02f, 3.38102272e-03f, -1.54559568e-01f, -8.58852118e-02f, 1.55537762e-02f, 2.04295032e-02f, -3.40637937e-02f, 1.39896497e-02f, -1.01459213e-01f, -8.73765200e-02f,
  -2.98271216e-02f, -3.01806666e-02f, 1.09919943e-02f, 2.31976844e-02f, 3.44586447e-02f, -1.28575526e-02f, -3.72057483e-02f, 3.31663862e-02f, -6.72099143e-02f, 5.10158390e-02f,
  1.86737918e-03f, -4.63457406e-02f, -1.38995685e-02f, 1.04327942e-03f, -3.00667565e-02f, -3.84171046e-02f, -6.84944540e-03f, -2.53954083e-02f, -2.19070408e-02f, 7.83716049e-03f,
  -3.22008668e-03f, 4.07730043e-02f, -4.94011566e-02f, 2.28643399e-02f, -5.32465428e-02f, 5.21377064e-02f, 3.83679122e-02f, 5.24996920e-03f, 2.72245724e-02f, -2.08229106e-03f,
  -2.88923442e-01f, -4.48767930e-01f, 1.49128342e-03f, -4.98795174e-02f, 9.86622879e-04f, 2.39129574e-03f, 3.57079618e-02f, 1.53623158e-02f, -7.43644759e-02f, -3.53219807e-02f,
  -1.13116331e-01f, -7.43430629e-02f, -1.48180947e-02f, -1.94949266e-02f, 1.82959083e-02f, -2.97528375e-02f, -2.36296095e-02f, 9.60103585e-04f, -4.95040789e-02f, -2.02981345e-02f,
  -3.68371345e-02f, -9.10897553e-03f, -1.17015718e-02f, 1.52177615e-02f, -4.56927419e-02f, -1.34842753e-01f, -3.58330160e-02f, -1.83075890e-02f, 1.52836898e-02f, -5.69709688e-02f,
  -5.22638904e-03f, -1.64808616e-01f, -1.42925590e-01f, 1.80035472e-01f, 1.13536194e-01f, -5.30321673e-02f, -1.30386919e-01f, 6.05384782e-02f, -5.92649132e-02f, -5.03410771e-02f,
  3.29717733e-02f, -1.09038427e-02f, -1.84803665e-01f, 1.27598187e-02f, 2.18740087e-02f, -1.73941687e-01f, 7.59541020e-02f, 7.37887993e-02f, -1.70811042e-01f, 1.29428376e-02f,
  3.69344875e-02f, 1.54510334e-01f, 1.25738531e-01f, 2.08666712e-01f, 3.47499130e-03f, 3.72324958e-02f, 1.76717937e-01f, -4.35944200e-02f, 2.94224948e-01f, 9.14534703e-02f,
  -1.93730928e-02f, -1.04853906e-01f, 6.04665168e-02f, -3.89104607e-05f, 4.06943597e-02f, 2.55165510e-02f, -7.59546757e-02f, 5.15436530e-02f, -1.17231738e-02f, -5.30559532e-02f,
  -3.81259633e-05f, 5.15757278e-02f, 1.35950401e-01f, 7.17677623e-02f, 1.16148703e-01f, 2.77385884e-03f, -1.15627550e-01f, -4.01099883e-02f, 5.65055907e-02f, -9.20134634e-02f,
  -2.50988994e-02f, -8.68660435e-02f, -8.90304819e-02f, -1.57252215e-02f, -2.23887265e-02f, -2.37274598e-02f, 4.34629321e-02f, 3.45597900e-02f, -2.78734583e-02f, 6.78132102e-02f,
  2.04965062e-02f, 2.06711958e-03f, 1.41608538e-02f, 3.19459960e-02f, 1.23483025e-01f, 4.12981352e-03f, -4.37939465e-02f, -7.79986149e-03f, 4.30468656e-02f, 4.35855351e-02f,
  -2.22058482e-02f, 1.03671782e-01f, 7.50369430e-02f, 3.77433300e-02f, 2.50605792e-02f, -6.47869483e-02f, -7.45113846e-03f, 2.23231129e-02f, -3.85899469e-02f, -4.92138090e-03f,
  -3.52881961e-02f, 9.49892588e-03f, 2.35044155e-02f, -1.14719654e-02f, 1.06741833e-02f, 1.76586602e-02f, 3.95527408e-02f, -2.21856534e-02f, -5.14264144e-02f, 3.24012898e-02f,
  -3.58200818e-02f, 2.68096216e-02f, 6.18497990e-02f, 7.63034075e-03f, -2.31531207e-02f, -3.75995878e-03f, 9.22749415e-02f, -9.09976289e-02f, -4.22611870e-02f, 4.01831865e-02f,
  6.07053079e-02f, 9.83349532e-02f, -7.68291056e-02f, 8.92435014e-02f, -1.41431754e-02f, -2.30263583e-02f, 7.52803236e-02f, 4.86737117e-04f, 3.01515851e-02f, -3.42976265e-02f,
  -5.68090267e-02f, 4.86120731e-02f, 6.65878430e-02f, 1.12944245e-02f, -3.77870873e-02f, 4.58875857e-03f, 5.80059476e-02f, 1.80176925e-02f, 3.69240120e-02f, -7.81496018e-02f,
  2.57289201e-01f, -1.94792956e-01f, -1.43836737e-02f, -4.66746390e-02f, -7.59283155e-02f, -1.55225664e-01f, 1.74034201e-02f, -2.15275452e-01f, -6.62861615e-02f, -1.32014826e-01f,
  -2.97603570e-02f, 1.15503609e-01f, 1.64094016e-01f, -1.89551592e-01f, 3.15501004e-01f, 1.25069872e-01f, -6.09301887e-02f, -3.65811102e-02f, -1.01845324e-01f, -8.24187174e-02f,
  -1.89437214e-02f, -8.43013078e-02f, 8.22393149e-02f, -1.68055952e-01f, -1.34192958e-01f, -3.10226232e-02f, 1.76765427e-01f, 1.14831768e-01f, -1.46519855e-01f, -5.08777332e-03f,
  -4.19653282e-02f, 9.58161801e-03f, -1.21427402e-01f, 5.64921722e-02f, -3.70493159e-02f, 8.73075426e-03f, -3.90744582e-02f, 3.50455903e-02f, 4.83647510e-02f, -2.38316320e-02f,
  3.30416039e-02f, -3.81962322e-02f, -4.02630866e-02f, 1.91286989e-02f, -3.91737036e-02f, -9.04599428e-02f, -2.89224903e-03f, -1.42424116e-02f, -1.49165932e-02f, 6.00675754e-02f,
  1.53227048e-02f, -8.08284134e-02f, -1.54055040e-02f, -4.63895127e-02f, 7.59718716e-02f, -3.82686518e-02f, 5.87687194e-02f, 5.76220267e-02f, -4.78580333e-02f, -5.50289592e-03f,
  -9.81754437e-03f, 2.70164777e-02f, -2.12109778e-02f, 1.08113987e-02f, -1.13429151e-01f, -6.05625063e-02f, -2.13600509e-02f, 4.52785799e-03f, 2.59293821e-02f, 3.20840813e-02f,
  -1.14115402e-02f, 2.95011681e-02f, 3.38611901e-02f, 2.12297328e-02f, -3.61688510e-02f, 7.64208883e-02f, 5.27844578e-02f, -8.35948251e-03f, -3.00275162e-02f, 3.48767973e-02f,
  -1.34807518e-02f, -9.42272693e-02f, -1.52232107e-02f, -3.99578698e-02f, -1.53663270e-02f, 7.07429796e-02f, -2.56971586e-02f, -5.27122174e-04f, -8.69660056e-04f, 3.13875005e-02f,
  2.52744230e-03f, 2.07736511e-02f, -1.13602839e-02f, 8.98900032e-02f, 4.26101759e-02f, -9.78444796e-03f, 3.30916978e-02f, -3.67020331e-02f, -4.29886878e-02f, -4.17241221e-03f,
  -1.57082267e-02f, 8.80080760e-02f, -6.49309671e-03f, -7.39071285e-03f, -5.56692183e-02f, -7.34773371e-03f, 2.63722464e-02f, 3.17740329e-02f, 5.07803932e-02f, -8.26625153e-02f,
  4.62099761e-02f, -3.20048705e-02f, 1.29849240e-01f, -3.98979485e-02f, 4.61897179e-02f, 1.05204307e-01f, -8.36090297e-02f, 2.26710569e-02f, 9.73162875e-02f, -7.82665517e-03f,
  2.13686839e-01f, -6.73273951e-02f, -3.21578830e-01f, -5.99728450e-02f, 4.81369644e-02f, 7.91058317e-03f, 2.75174379e-02f, -5.54348752e-02f, -1.79519877e-01f, 6.21497370e-02f,
  1.06058165e-01f, -4.55743447e-02f, -7.59265944e-02f, 2.34179460e-02f, 1.19490266e-01f, -9.03400481e-02f, 1.35058105e-01f, 3.35477106e-02f, -8.57871249e-02f, 1.34142339e-01f,
  7.61255920e-02f, 1.78699926e-01f, -6.31277487e-02f, 1.76351130e-01f, 7.11692721e-02f, 5.92513792e-02f, 1.84263662e-01f, 1.96214137e-03f, 1.81605354e-01f, 9.86187607e-02f,
  -7.82508310e-03f, -8.17248970e-03f, -2.80660503e-02f, -5.68686016e-02f, 1.12362906e-01f, 1.31864831e-01f, -4.06454802e-02f, 8.32847506e-03f, -3.37912515e-02f, 5.50121665e-02f,
  -1.97925661e-02f, -7.08698854e-02f, -4.16506901e-02f, -4.62393649e-02f, -3.58091965e-02f, 3.29149328e-02f, -4.81212959e-02f, -4.36785296e-02f, -4.16509621e-02f, -2.53499970e-02f,
  -1.55422771e-02f, -1.44276312e-02f, -7.72135705e-02f, -2.42543072e-02f, -3.24765518e-02f, -2.20882054e-02f, 5.88488430e-02f, 2.26251408e-02f, -5.08784577e-02f, 1.95080712e-02f,
  7.32344836e-02f, -2.22335942e-02f, -4.81971763e-02f, -6.25738725e-02f, -1.88761614e-02f, -5.09733222e-02f, -5.22699170e-02f, 5.18802889e-02f, -4.46097441e-02f, 4.12976965e-02f,
  3.03379958e-03f, 4.57730144e-02f, -1.19400062e-02f, 9.83238742e-02f, -1.77342724e-02f, 5.52767664e-02f, 2.42349179e-03f, 6.92614615e-02f, -9.02074575e-03f, -3.21341269e-02f,
  -4.11730818e-02f, 6.20084852e-02f, 5.62064275e-02f, 2.16499548e-02f, 2.06775051e-02f, -2.27134153e-02f, 1.30050990e-03f, -2.12160833e-02f, 3.61499190e-02f, 4.15051393e-02f,
  9.83199626e-02f, 7.15193003e-02f, -5.81909940e-02f, 2.34207157e-02f, 5.44015598e-03f, 7.76279811e-03f, -2.29598749e-02f, -3.80768143e-02f, -2.89922915e-02f, -2.87386663e-02f,
  4.60964739e-02f, 7.61159211e-02f, 3.87527607e-02f, 4.42945398e-02f, 6.01922870e-02f, 2.89682969e-02f, -2.11435836e-03f, 2.45234068e-03f, 7.65094757e-02f, 4.98376824e-02f,
  4.63955523e-03f, 3.76082547e-02f, 6.10582381e-02f, -4.33178470e-02f, 1.36316232e-02f, -3.49288695e-02f, -4.43859994e-02f, 4.46610525e-02f, -2.78162528e-02f, -3.67453434e-02f,
  -3.09600800e-01f, 5.03178053e-02f, -2.22852886e-01f, -2.04895109e-01f, 1.61008000e-01f, 8.11635554e-02f, 1.15849562e-02f, 3.19612399e-02f, -4.63730097e-02f, 2.18060121e-01f,
  1.69865206e-01f, -8.95704105e-02f, 1.15870178e-01f, -9.41733420e-02f, -2.15043336e-01f, -5.20199072e-03f, -1.16382562e-01f, -5.22019640e-02f, -1.03035420e-01f, -3.12836729e-02f,
  -1.11049011e-01f, 1.22003458e-01f, -1.20746993e-01f, 3.71374451e-02f, 1.85340028e-02f, 1.01512028e-02f, 1.71638712e-01f, 1.61035895e-01f, -4.35056537e-02f, -2.93258112e-02f,
  1.14159890e-01f, 7.02374950e-02f, -6.19881041e-02f, 5.28033078e-02f, -4.50903475e-02f, -4.97620180e-02f, 6.37181029e-02f, -9.17488113e-02f, 1.46424593e-02f, 2.49847099e-02f,
  -6.15499057e-02f, -1.38016999e-01f, -2.47687921e-02f, 5.81095815e-02f, -3.63748521e-02f, 1.87616367e-02f, -3.36310081e-02f, -6.65274486e-02f, -1.82539355e-02f, -8.17829520e-02f,
  -2.35656891e-02f, -5.07037155e-02f, 4.69652843e-03f, -2.00218009e-03f, -3.18640918e-02f, -4.27219607e-02f, -5.30312955e-02f, -7.79831689e-03f, -3.41934636e-02f, -3.94391753e-02f,
  2.41803303e-02f, -1.13792429e-02f, 1.55896042e-02f, -2.17120089e-02f, -5.21023646e-02f, 3.18090767e-02f, -5.88207282e-02f, -7.00995997e-02f, 1.64578594e-02f, 2.66092140e-02f,
  3.75438482e-02f, -5.94378151e-02f, 7.82148540e-02f, -4.86574396e-02f, -3.90476957e-02f, -5.99363595e-02f, -6.02967665e-02f, 1.88541114e-02f, -3.54423150e-02f, -5.25901206e-02f,
  2.63317022e-03f, 2.76207700e-02f, 9.08398479e-02f, 8.31354186e-02f, -5.19252308e-02f, 7.02017918e-02f, -3.55218491e-03f, 8.48907083e-02f, 1.97754074e-02f, -5.56194074e-02f,
  6.92115957e-03f, 2.36761477e-02f, -4.07401472e-02f, 3.69506888e-03f, 3.22969593e-02f, 4.82764840e-02f, -7.23949373e-02f, 3.75830345e-02f, 6.46544155e-03f, 7.24500045e-02f,
  1.97799224e-02f, 6.57760212e-03f, 3.81395519e-02f, -1.58491731e-02f, -6.26192242e-02f, 8.50659311e-02f, 1.57571770e-02f, 5.63871078e-02f, 2.21623778e-02f, -1.17303818e-01f,
  1.01570040e-01f, 5.87181635e-02f, -4.72447127e-02f, -5.81346452e-03f, -3.13392915e-02f, -1.74834188e-02f, 5.60434610e-02f, -3.74542363e-02f, 5.52429399e-03f, -1.40850339e-02f,
  -1.15052328e-01f, -6.52147532e-02f, -2.47274816e-01f, -2.59018928e-01f, -1.55221879e-01f, -2.25913271e-01f, -3.16283584e-01f, -6.89963996e-02f, 1.88694429e-03f, -8.99481308e-03f,
  -1.48464650e-01f, -2.16845982e-03f, 1.29251182e-01f, -1.14477806e-01f, 5.22917546e-02f, 2.17150584e-01f, -7.76323155e-02f, -1.22612081e-02f, 7.82912597e-02f, -9.34627205e-02f,
  -4.95305751e-03f, -5.94286947e-03f, 1.16954008e-02f, 9.13554244e-03f, -8.64166468e-02f, -6.18665330e-02f, -8.63324199e-03f, -5.84917180e-02f, -1.49080917e-01f, -9.62204114e-02f,
  -4.02771123e-02f, -1.52190700e-01f, -1.31910905e-01f, -9.35322698e-03f, 4.41117678e-03f, -8.43724534e-02f, -2.97503229e-02f, 4.37323861e-02f, -3.29627544e-02f, -5.03531210e-02f,
  -1.07330509e-01f, 6.10794611e-02f, -2.74423659e-02f, -6.28837245e-03f, -6.02390096e-02f, -2.99059656e-02f, 4.12651338e-02f, -8.16767588e-02f, 5.82975429e-03f, -7.04003572e-02f,
  -3.06774061e-02f, 4.13725078e-02f, 2.04718728e-02f, 7.22722560e-02f, 4.64088768e-02f, -1.44940251e-02f, 6.83700964e-02f, -4.87353615e-02f, -1.10017182e-02f, -7.90690258e-03f,
  3.63981836e-02f, 5.06876670e-02f, -2.95786131e-02f, -1.39284823e-02f, 1.00708799e-02f, 3.70662101e-02f, -4.03363891e-02f, 2.45271828e-02f, 1.74178611e-02f, -1.01283453e-02f,
  -7.30580126e-04f, 2.20290106e-02f, 3.71429659e-02f, -2.82499231e-02f, 2.60402169e-02f, -5.47255352e-02f, 5.66403382e-02f, -1.14180809e-02f, -5.90221994e-02f, 7.06828758e-02f,
  1.04728960e-01f, -8.73847213e-03f, 1.05302274e-01f, -9.83246788e-02f, -5.89538217e-02f, 5.46475127e-02f, 1.03084324e-02f, -1.41040785e-02f, -5.22309616e-02f, -1.64980907e-02f,
  -1.19689330e-01f, -1.13008343e-01f, 6.15888536e-02f, -6.51162565e-02f, 3.51968035e-02f, -6.27945736e-02f, 8.84466618e-03f, -1.89861450e-02f, -1.24307789e-01f, -5.85859567e-02f,
  2.61466820e-02f, 2.24374048e-02f, -8.60883668e-02f, -5.53995408e-02f, 3.67661826e-02f, 8.19843858e-02f, -7.07089156e-02f, -2.18874924e-02f, -4.57009263e-02f, -9.01233479e-02f,
  2.01803781e-02f, -1.24786636e-02f, 3.56170312e-02f, -4.20765243e-02f, 3.62245366e-02f, -6.46068063e-03f, -3.99594605e-02f, -3.04911248e-02f, -4.50141579e-02f, 3.95278782e-02f,
  5.54737709e-02f, -2.06416428e-01f, -1.67030036e-01f, 5.26060313e-02f, 4.26019505e-02f, 2.16696095e-02f, -8.11907724e-02f, -2.66501736e-02f, -2.37698376e-01f, -4.09388542e-02f,
  -1.84717011e-02f, -1.57401636e-01f, -1.43341526e-01f, 6.92426562e-02f, 4.68015671e-03f, -9.74673852e-02f, -1.08632185e-02f, -2.83335764e-02f, -1.59811415e-02f, 5.03054745e-02f,
  -3.52806002e-02f, 1.79739535e-01f, -9.25760046e-02f, 2.90847775e-02f, 5.76362386e-02f, 9.66173634e-02f, 7.96240270e-02f, 3.17409672e-02f, 2.60095224e-02f, 4.29745205e-02f,
  -2.71301232e-02f, -9.57946405e-02f, -4.28240672e-02f, 9.02147889e-02f, -5.80222979e-02f, 1.46265104e-01f, 4.87012304e-02f, 1.03687905e-01f, -8.35639834e-02f, -5.77033013e-02f,
  -1.11514181e-02f, 1.54328858e-02f, -5.46891354e-02f, -8.69447552e-03f, -8.71460736e-02f, 3.73279117e-02f, -8.62001702e-02f, -4.97018173e-02f, -2.72523798e-02f, -7.30410889e-02f,
  -4.76784445e-02f, 4.57606576e-02f, -3.14685293e-02f, 7.96347763e-03f, -5.14104851e-02f, 1.61014721e-02f, 4.95699458e-02f, 3.07381675e-02f, -9.27044898e-02f, 4.01965491e-02f,
  1.18594870e-01f, 8.64340216e-02f, 3.59145775e-02f, 6.08960865e-03f, 3.18788216e-02f, 2.23967489e-02f, -8.15531835e-02f, -2.46656630e-02f, -1.39946323e-02f, -1.37114991e-02f,
  -8.95911362e-03f, 3.66214924e-02f, -8.05491209e-03f, -2.94242948e-02f, 6.97257295e-02f, 6.38387874e-02f, 8.41335673e-03f, 5.53093404e-02f, 5.18840030e-02f, -4.14448865e-02f,
  7.58956373e-02f, -5.24434708e-02f, -7.06619322e-02f, -1.03675500e-02f, -1.26161315e-02f, 5.96007407e-02f, 7.65765905e-02f, 2.69934405e-02f, -2.35411469e-02f, 7.12763332e-03f,
  3.14276963e-02f, -1.60827097e-02f, -3.97620909e-02f, -1.91253275e-02f, -3.36936489e-02f, 6.03787638e-02f, -7.32256547e-02f, -8.84170085e-03f, 6.83360547e-02f, -9.75189582e-02f,
  1.51969522e-01f, 1.35805421e-02f, 4.84265648e-02f, -2.10306793e-02f, -3.40467058e-02f, 5.03126048e-02f, 6.76364601e-02f, -2.92812791e-02f, 9.34778061e-03f, 1.06371857e-01f,
  7.96311423e-02f, -1.83604695e-02f, 1.69908144e-02f, -4.71459376e-03f, 6.70106113e-02f, -1.84634533e-02f, -3.19312280e-03f, -8.95441175e-02f, 8.33783373e-02f, 3.44540030e-02f,
  -2.48710364e-01f, 3.27637070e-04f, 4.06963006e-02f, -2.34006569e-01f, 3.88370734e-03f, -2.29042266e-02f, -9.82370079e-02f, -1.56205511e-02f, -3.41640487e-02f, 1.43325344e-01f,
  1.50785120e-02f, -1.56226335e-03f, 1.12095222e-01f, -1.91605747e-01f, -5.18952310e-01f, -1.32635236e-01f, -4.02421027e-01f, -1.93359300e-01f, -1.32543281e-01f, -1.90530457e-02f,
  -2.25259319e-01f, -1.77103654e-01f, -1.66743696e-01f, 1.40874475e-01f, 1.90574557e-01f, 1.61309302e-01f, 6.86481521e-02f, 2.21511334e-01f, -4.15218249e-02f, -7.69246668e-02f,
  -7.22970292e-02f, 2.52031889e-02f, 8.08970034e-02f, 2.82274056e-02f, 8.74157473e-02f, 7.53775090e-02f, 9.57211759e-03f, -2.83357613e-02f, -5.48572280e-02f, -6.22534715e-02f,
  9.38823745e-02f, 5.68895973e-02f, -5.02999090e-02f, 1.56478933e-03f, 4.47344184e-02f, -5.84618896e-02f, -5.52960858e-02f, -1.66411437e-02f, -3.54008935e-02f, 9.57271457e-03f,
  -1.68284513e-02f, -2.38516927e-02f, -4.65358654e-03f, -1.18650243e-01f, -4.01769802e-02f, -1.10969283e-02f, 6.79977098e-03f, -1.62277669e-02f, -1.80758499e-02f, -8.54325294e-02f,
  9.22862533e-03f, 9.54282433e-02f, -2.72191670e-02f, 6.51924079e-03f, 5.10473251e-02f, 1.18978200e-02f, 2.95820925e-02f, 2.44506225e-02f, 1.10811333e-03f, 5.63674979e-03f,
  -3.82843986e-02f, 3.11092865e-02f, -1.05498927e-02f, 4.59365584e-02f, -6.39310628e-02f, 5.71095832e-02f, -6.58081518e-03f, -3.00904755e-02f, -1.11795753e-01f, -8.18721578e-02f,
  5.50737754e-02f, 2.38951705e-02f, 9.72202179e-05f, -6.94469362e-02f, 2.49971468e-02f, 6.68589547e-02f, 4.78678718e-02f, -1.75611451e-02f, -1.31716793e-02f, 3.60073755e-03f,
  3.20342183e-02f, 5.44752851e-02f, 2.79929359e-02f, -5.12429513e-02f, -2.20641978e-02f, -3.30502801e-02f, -3.55447233e-02f, 8.11980963e-02f, 9.32956114e-03f, 9.19736177e-02f,
  8.59815180e-02f, 3.64174098e-02f, 1.27485329e-02f, 2.03805417e-03f, -6.67013898e-02f, -3.48724201e-02f, 5.75698204e-02f, 2.24199835e-02f, -6.78299442e-02f, -3.62164564e-02f,
  4.89492677e-02f, 5.21927588e-02f, -7.87400752e-02f, 1.83818326e-03f, -4.23059203e-02f, 1.08511060e-01f, -7.72717446e-02f, 6.66915700e-02f, 2.84730680e-02f, 6.27860986e-03f,
  2.79683948e-01f, 2.69976616e-01f, 1.17764644e-01f, 2.92545795e-01f, -2.48788506e-01f, -3.33796829e-01f, -2.44043350e-01f, 4.05847356e-02f, -1.12571545e-01f, -1.08803540e-01f,
  -1.94661804e-02f, 1.22673348e-01f, 3.34429778e-02f, 1.82314768e-01f, -1.53814936e-02f, -6.51527271e-02f, -4.28576171e-02f, -1.58000410e-01f, -3.73405293e-02f, 1.30593792e-01f,
  2.01033279e-01f, 1.43848062e-02f, 2.82804430e-01f, 1.50523961e-01f, 1.13968119e-01f, 1.85393602e-01f, 2.69150048e-01f, -1.84763465e-02f, 1.13268256e-01f, 1.84378203e-03f,
  -2.02389315e-01f, 8.28209892e-02f, 1.38221839e-02f, -1.48443021e-02f, 4.25644368e-02f, -3.16358358e-02f, 3.10890209e-02f, -3.71803045e-02f, -1.11474924e-01f, 4.96475622e-02f,
  2.87343953e-02f, 5.98988347e-02f, -2.38227448e-03f, -2.92903129e-02f, -7.19875395e-02f, 2.37989035e-02f, 1.18710985e-02f, -6.67952141e-03f, -3.52609381e-02f, 9.81096029e-02f,
  -1.64196659e-02f, 5.77689894e-02f, 6.91857636e-02f, 9.56007913e-02f, -1.52791524e-02f, 7.80937029e-03f, 1.33086732e-02f, 1.81675367e-02f, -8.40533450e-02f, 1.26296785e-02f,
  8.89030397e-02f, 2.33616363e-02f, 2.49738712e-02f, 1.70947891e-02f, 4.17444818e-02f, 4.41179164e-02f, 3.63181196e-02f, 3.46887857e-02f, 2.90220324e-02f, 9.25015658e-02f,
  1.79625843e-02f, -3.68332341e-02f, -5.91045283e-02f, 3.51636633e-02f, -2.70423871e-02f, -1.58510394e-02f, 4.93693305e-03f, -2.94515491e-02f, 2.15961952e-02f, -4.23529111e-02f,
  1.59075705e-03f, -3.62308510e-02f, 1.80330295e-02f, 1.27756747e-03f, -6.71528280e-02f, 2.60838903e-02f, 3.73360626e-02f, 6.33869544e-02f, 1.06043871e-02f, 2.58667916e-02f,
  3.16827521e-02f, 2.91280895e-01f, 6.43622279e-02f, 2.70641670e-02f, -2.77526909e-03f, -4.00646143e-02f, -5.77507727e-02f, 2.71117594e-02f, 2.71496624e-02f, -1.93429515e-02f,
  4.25611772e-02f, 4.42852266e-03f, 3.98146138e-02f, 4.22231071e-02f, 5.21738082e-02f, -8.34457949e-03f, 1.09844513e-01f, 8.09969082e-02f, -1.64381396e-02f, 4.24533859e-02f,
  4.23989594e-02f, 1.93446428e-02f, -3.12712789e-02f, -3.59798707e-02f, 6.34525791e-02f, 5.43531515e-02f, -3.39114331e-02f, -3.02409828e-02f, -6.47385418e-03f, 2.16609873e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 14)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 14;
const float L0_fan_Bp_bar_data[] = {
  1.62868090e-02f, 4.95872833e-02f, 9.69464630e-02f, 1.43941324e-02f, -1.47598367e-02f, 2.62882471e-01f, -1.59194600e-02f, 1.16918989e-01f, 1.24881327e-01f, 2.66582578e-01f,
  -1.72857791e-02f, 2.58090831e-02f, 1.14531286e-01f, -3.98051143e-02f
};

// L1_fan_Wp (Shape: 9 x 32)
const int L1_fan_Wp_rows = 9;
const int L1_fan_Wp_cols = 32;
const float L1_fan_Wp_data[] = {
  2.73199499e-01f, 4.35095467e-02f, -6.15528487e-02f, -4.19810414e-02f, -7.42120072e-02f, 8.33251327e-02f, 2.10398324e-02f, -2.22154394e-01f, -9.05015543e-02f, -1.86224401e-01f,
  -9.11650360e-02f, 3.20651799e-01f, -1.33594945e-01f, 2.06888810e-01f, 5.38453199e-02f, 1.80744901e-01f, 1.92340314e-01f, -2.38479629e-01f, 3.00151948e-02f, -8.52688476e-02f,
  1.75505683e-01f, -2.19042942e-01f, 4.37946990e-02f, -2.40036156e-02f, -5.47173545e-02f, -3.39399248e-01f, 1.12296805e-01f, 1.09342493e-01f, 1.69634074e-02f, -7.71359801e-02f,
  1.32640436e-01f, -3.29318017e-01f, -1.14837706e-01f, 6.18560947e-02f, 8.71959850e-02f, -7.13205263e-02f, -9.75130275e-02f, 8.11529309e-02f, 1.97524562e-01f, 3.80394273e-02f,
  -7.98574239e-02f, 2.34565675e-01f, 8.40006322e-02f, -6.90848678e-02f, 2.63289481e-01f, 1.13419548e-01f, 1.61220342e-01f, -1.63448185e-01f, -1.53228536e-01f, 3.35242391e-01f,
  -1.47123650e-01f, 2.12478004e-02f, -5.87383024e-02f, 1.78431615e-01f, 1.00713782e-01f, 3.50357652e-01f, -2.01616734e-01f, -9.95290205e-02f, -2.35893309e-01f, 2.02930108e-01f,
  2.21956968e-01f, -7.57298246e-02f, -1.02131002e-01f, -1.63068950e-01f, 7.18644038e-02f, -3.75222191e-02f, 7.26787094e-03f, -2.62260083e-02f, -1.10214107e-01f, 5.43138497e-02f,
  -1.02028623e-01f, -5.02430927e-03f, 1.27771899e-01f, -1.15769051e-01f, 2.23986760e-01f, 1.47003174e-01f, -3.77517641e-02f, -3.26765627e-02f, -1.39541626e-01f, 4.59557325e-02f,
  2.19190210e-01f, -1.89167321e-01f, -4.81570736e-02f, 2.77741641e-01f, 9.85839143e-02f, 4.93767150e-02f, -1.30986899e-01f, -2.78293818e-01f, 5.14705628e-02f, 1.02465913e-01f,
  2.12831303e-01f, 1.53924972e-02f, -2.70154238e-01f, -3.69536951e-02f, 7.19297305e-02f, 2.45909601e-01f, 5.25495736e-03f, -2.98550010e-01f, -2.27957815e-01f, -1.58318013e-01f,
  -1.59333006e-01f, 3.38559300e-01f, 1.90467834e-01f, 2.11887449e-01f, -9.10422206e-02f, 2.29602680e-02f, -2.54284758e-02f, -3.08939666e-01f, 8.24867636e-02f, -3.91661733e-01f,
  -3.20013538e-02f, 2.42383197e-01f, 1.78660139e-01f, 3.18372667e-01f, -1.46327808e-03f, 3.04476321e-01f, 1.75952226e-01f, 2.01832145e-01f, 1.97031021e-01f, -2.61411425e-02f,
  -9.31425393e-03f, 1.17424019e-01f, 7.59902969e-02f, 3.78739871e-02f, 1.75372362e-01f, 1.39383584e-01f, -3.73973966e-01f, 2.85532326e-01f, 1.58418417e-02f, -1.55185059e-01f,
  2.01946899e-01f, 7.62289464e-02f, -1.33788913e-01f, 2.26908680e-02f, 6.44436618e-03f, 5.76724708e-02f, -5.10690585e-02f, -2.58031487e-01f, -2.57834047e-01f, -7.44467080e-02f,
  7.42939115e-02f, 2.30775923e-02f, -1.97365940e-01f, -1.61767751e-01f, 5.04707806e-02f, 5.47697991e-02f, -2.05439523e-01f, -2.16644496e-01f, 1.46655828e-01f, -5.03855310e-02f,
  8.38988051e-02f, 2.60050654e-01f, -1.66832536e-01f, -1.78626776e-01f, -3.15179527e-02f, 7.85112083e-02f, 8.84312019e-03f, -9.43603069e-02f, 8.30071867e-02f, -2.04063356e-01f,
  -4.50794287e-02f, -2.34874412e-01f, -1.72429696e-01f, -3.16369198e-02f, -2.12738261e-01f, 8.75918195e-02f, -1.51333705e-01f, 3.16336118e-02f, -8.02437142e-02f, 2.00666457e-01f,
  3.67393225e-01f, -8.97642970e-02f, -1.74659282e-01f, 1.71846882e-01f, 2.43080288e-01f, 3.31477016e-01f, 1.81781739e-01f, -1.06991038e-01f, 8.84889737e-02f, 1.15083762e-01f,
  -1.37109578e-01f, -1.59882009e-01f, 2.10493848e-01f, -1.25450090e-01f, 1.71005607e-01f, -8.50940198e-02f, 2.06778586e-01f, -9.48525127e-03f, -9.75909010e-02f, 1.89598173e-01f,
  -1.30372524e-01f, 1.99385226e-01f, -2.54188944e-02f, 6.01805896e-02f, 2.01987643e-02f, 2.30080917e-01f, 1.88463721e-02f, 6.69671893e-02f, -1.82248354e-01f, -5.70021756e-02f,
  2.80653648e-02f, -3.12410533e-01f, 5.89695945e-02f, 2.27122739e-01f, -1.37119573e-02f, -2.00527191e-01f, -2.33234063e-01f, 1.13742307e-01f, 4.70541656e-01f, -7.54793882e-02f,
  5.01300283e-02f, 4.43756692e-02f, 1.31775290e-01f, -4.31786180e-02f, -2.16665462e-01f, -3.49454850e-01f, 2.19739601e-01f, -1.49703652e-01f, 1.97126463e-01f, 9.58309993e-02f,
  -2.91397840e-01f, 2.08352610e-01f, 5.18727526e-02f, 2.04688832e-01f, 9.28455368e-02f, -1.83260515e-01f, 2.19028220e-01f, -2.15660706e-01f, -6.45612851e-02f, 1.52953148e-01f,
  -3.67059670e-02f, -3.87957059e-02f, -1.54126897e-01f, 9.76751465e-03f, 1.42810076e-01f, 1.12578496e-01f, -1.70932814e-01f, 7.34411702e-02f, 2.34477907e-01f, 2.14604512e-01f,
  -3.26278247e-02f, -1.71827644e-01f, 4.50680405e-02f, 5.53959236e-02f, -8.40990469e-02f, 2.03182116e-01f, -3.97819579e-02f, 2.56797671e-01f, 9.91347060e-02f, -1.09944120e-01f,
  -9.40962657e-02f, 1.91965863e-01f, 1.78716406e-01f, 1.04439385e-01f, 3.07268232e-01f, -2.27068141e-01f, 1.33407250e-01f, -1.68884814e-01f, 1.15541600e-01f, -5.26805520e-02f,
  -9.41295996e-02f, 2.68429995e-01f, 2.70926088e-01f, 6.64550811e-02f, 2.82619148e-02f, 2.28397042e-01f, 2.11177528e-01f, -1.28355786e-01f, 1.76323235e-01f, 6.64799288e-02f,
  3.06087304e-02f, -1.87035963e-01f, -2.21031681e-01f, 1.93664789e-01f, -1.46920785e-01f, 2.29902923e-01f, -1.66816965e-01f, 1.19918101e-01f, 1.62238985e-01f, 2.64556110e-01f,
  -1.65628642e-01f, 8.07366222e-02f, 9.19300467e-02f, 1.57190979e-01f, 1.39753044e-01f, -1.75959803e-02f, -1.65881902e-01f, 3.34433138e-01f
};

// L1_fan_Wp_bar (Shape: 14 x 32)
const int L1_fan_Wp_bar_rows = 14;
const int L1_fan_Wp_bar_cols = 32;
const float L1_fan_Wp_bar_data[] = {
  3.41805577e-01f, 3.32149208e-01f, 5.09904251e-02f, 2.16051817e-01f, 2.29205161e-01f, 1.86415147e-02f, 2.62596697e-01f, 2.93117762e-01f, 2.94215292e-01f, 4.44449604e-01f,
  2.89171249e-01f, -1.03580348e-01f, 1.92818224e-01f, 4.57644403e-01f, 3.83532941e-01f, -1.48285806e-01f, -4.34975177e-01f, 1.31506637e-01f, -2.41825998e-01f, 1.50994390e-01f,
  -2.04813302e-01f, 1.99673280e-01f, 4.08307880e-01f, 1.10788696e-01f, -3.20974849e-02f, -1.11093774e-01f, -8.87646154e-02f, 3.41813713e-01f, 3.09746563e-01f, -5.27985208e-02f,
  2.72697508e-01f, 6.94731846e-02f, -9.63405445e-02f, -5.29452302e-02f, 1.36344910e-01f, 1.48659244e-01f, 1.27381742e-01f, 2.25860044e-01f, 1.79524615e-01f, 1.81836002e-02f,
  1.28215685e-01f, -2.72154063e-01f, -3.59344304e-01f, -3.13448370e-01f, -2.59540468e-01f, -3.63950640e-01f, -2.19176933e-01f, 5.29344678e-02f, 3.13602805e-01f, 1.19918764e-01f,
  -3.60055305e-02f, 3.32072787e-02f, 3.66180092e-01f, 2.81723619e-01f, 8.97875503e-02f, 2.57655889e-01f, -1.54239401e-01f, 3.20516765e-01f, 8.55240077e-02f, 8.42448920e-02f,
  8.96108299e-02f, 7.16944709e-02f, -2.63507366e-01f, 1.76266246e-02f, -1.46991876e-03f, 1.24916442e-01f, 3.87537390e-01f, 2.47198224e-01f, 1.20014176e-01f, 1.06215172e-01f,
  4.19133335e-01f, 3.66338581e-01f, 5.01323044e-02f, -3.14768404e-01f, -2.45554611e-01f, 6.23512007e-02f, 2.82770246e-02f, -1.20651007e-01f, -3.76015931e-01f, -2.73972511e-01f,
  -1.15164429e-01f, 3.79352570e-01f, 1.13689221e-01f, -2.44244680e-01f, 2.70550638e-01f, 2.92044461e-01f, -1.52039647e-01f, 6.88910306e-01f, -3.52167785e-02f, 2.45181248e-01f,
  -3.10169935e-01f, -4.18839939e-02f, 3.56812149e-01f, -2.41487041e-01f, -7.85213038e-02f, -1.89734876e-01f, 3.16992998e-01f, 1.22914918e-01f, 2.19656616e-01f, 2.24856958e-01f,
  2.21035525e-01f, -1.74795195e-01f, 1.91012263e-01f, 1.62967518e-01f, 2.43240022e-04f, -9.68327224e-02f, -3.61881964e-02f, 3.37870449e-01f, 1.49630368e-01f, 1.85924470e-01f,
  8.82864743e-02f, 1.50703266e-02f, -1.49132544e-02f, -1.55460238e-01f, -4.13104407e-02f, -1.92854643e-01f, 1.62629828e-01f, -1.65259257e-01f, -1.45982072e-01f, 9.38426554e-02f,
  6.64044470e-02f, -1.35518178e-01f, -8.00051764e-02f, 1.19776316e-01f, -5.28726541e-02f, 8.13866034e-02f, 1.89557061e-01f, -7.38079920e-02f, 3.11712682e-01f, 2.56875157e-01f,
  -9.51204263e-03f, 5.07130086e-01f, 3.98907870e-01f, 3.75764012e-01f, 2.88774312e-01f, 1.64747000e-01f, 4.19030756e-01f, 2.52264529e-01f, 1.50038287e-01f, -1.81664556e-01f,
  -1.23407081e-01f, -3.45602036e-01f, -4.55591977e-01f, -9.93078351e-02f, 5.21377504e-01f, -2.43120696e-02f, 4.42059338e-01f, 5.00774920e-01f, 8.20510909e-02f, -3.64438742e-01f,
  -1.19786277e-01f, -2.79714763e-01f, 3.62960577e-01f, 1.15840189e-01f, 9.07873958e-02f, 8.77188460e-04f, -3.78200486e-02f, 9.34293866e-02f, -2.90942311e-01f, 3.48241389e-01f,
  -3.54259126e-02f, 8.40591416e-02f, 1.94969345e-02f, -6.47794921e-03f, -7.27396980e-02f, 4.44968864e-02f, -1.44161612e-01f, -6.31341636e-02f, 9.40868184e-02f, 6.45133108e-02f,
  1.30689532e-01f, 4.65577766e-02f, 1.74241155e-01f, 9.48755741e-02f, 1.47648275e-01f, 7.65571371e-03f, 2.49678530e-02f, 2.57715564e-02f, -1.09936900e-01f, -2.58600693e-02f,
  -6.54789060e-02f, -3.34851108e-02f, -1.03827126e-01f, -1.49493322e-01f, -2.09970493e-02f, 1.39697701e-01f, -1.16153434e-01f, -1.33255750e-01f, -1.63842708e-01f, 1.56985924e-01f,
  5.95421195e-02f, -1.30030379e-01f, 3.35202545e-01f, 2.27032274e-01f, 7.90583193e-02f, 1.27667487e-01f, 4.42148149e-02f, 1.16359629e-01f, 2.72693068e-01f, 7.41290674e-02f,
  8.98432806e-02f, 1.55963793e-01f, 2.50537366e-01f, -1.16890348e-01f, -1.91113606e-01f, 1.80067301e-01f, 6.70293927e-01f, 4.99763995e-01f, -3.35343510e-01f, -1.32171631e-01f,
  -3.15559357e-01f, 2.64781207e-01f, 2.27352120e-02f, 3.43856812e-01f, 4.91747141e-01f, 4.56909463e-02f, -5.23491949e-03f, -1.33932754e-01f, 3.67384404e-01f, 5.17274380e-01f,
  -2.88718194e-02f, 2.95262754e-01f, 4.56628203e-01f, -4.26402867e-01f, 1.66133773e-02f, 1.47891581e-01f, 1.50200690e-03f, 2.07035244e-01f, 1.03529863e-01f, 2.11844012e-01f,
  3.15538436e-01f, -2.77700685e-02f, 1.56229809e-01f, -2.78142422e-01f, 1.48664564e-01f, 1.74486697e-01f, -3.68098170e-01f, -1.15078408e-02f, -2.79389881e-02f, 4.73927110e-01f,
  3.36285174e-01f, -2.74946857e-02f, 7.50337914e-02f, 1.49821132e-01f, 2.62915492e-01f, -1.24221385e-01f, 2.14561895e-01f, -8.35696757e-02f, 2.63317227e-01f, 1.57687083e-01f,
  1.31672308e-01f, 2.06474751e-01f, 2.62196045e-02f, 2.45099843e-01f, -6.98495656e-02f, -1.84580520e-01f, 4.59217221e-01f, 4.64419246e-01f, 3.00072372e-01f, 2.38011315e-01f,
  3.66078496e-01f, -9.52012613e-02f, -9.59534571e-02f, -1.23148508e-01f, 1.58836246e-01f, -4.96298164e-01f, -8.92365575e-02f, 6.27169847e-01f, 4.17644121e-02f, 3.67334872e-01f,
  7.19271749e-02f, -1.24824449e-01f, -8.04954544e-02f, -5.24545014e-01f, 1.21116668e-01f, -1.38048917e-01f, 1.82326093e-01f, -2.16913059e-01f, -2.88089335e-01f, 1.08575791e-01f,
  2.32171044e-01f, -3.03359151e-01f, 7.43518816e-03f, 2.86262155e-01f, -1.02647007e-01f, 8.96862671e-02f, 3.78008246e-01f, 8.33437953e-04f, -1.42789269e-02f, 1.21918909e-01f,
  -1.48729622e-01f, -6.53628632e-02f, -1.34885386e-01f, 8.12784284e-02f, 2.10784271e-01f, 6.63946569e-02f, 9.47157964e-02f, -1.08507372e-01f, 1.61185250e-01f, 2.95044109e-02f,
  1.13746412e-01f, 5.88536263e-02f, 2.43890490e-02f, -2.15791184e-02f, -4.59232479e-02f, 1.09807879e-01f, -6.96930364e-02f, -2.88566407e-02f, -1.19695552e-01f, 1.73712038e-02f,
  -8.91093984e-02f, 1.79893047e-01f, -1.40996948e-01f, 2.56011523e-02f, 4.11789306e-02f, 1.70130342e-01f, -1.20492376e-01f, -9.67539772e-02f, 6.27962276e-02f, -7.51228929e-02f,
  -2.00021520e-01f, 2.18112990e-02f, 6.74090162e-02f, 4.24109362e-02f, -6.45740703e-02f, 6.20869510e-02f, 1.42398477e-02f, -8.94051138e-03f, -1.54051587e-01f, -1.46148995e-01f,
  -1.07926458e-01f, -1.77921683e-01f, -2.06208751e-02f, -2.19790667e-01f, 9.42908674e-02f, -1.35435173e-02f, -2.16882955e-02f, 7.55084679e-02f, 1.10333480e-01f, -1.03793651e-01f,
  -9.57932621e-02f, 1.17351815e-01f, -5.34180924e-02f, 2.82531708e-01f, -4.61330079e-02f, 2.81141132e-01f, 1.79025114e-01f, 7.56626278e-02f, 2.42403448e-01f, -9.73269492e-02f,
  7.40005970e-02f, -9.56113040e-02f, -1.10156767e-01f, -1.33395866e-01f, 2.45039389e-02f, -4.51793447e-02f, 1.57650962e-01f, -4.08405438e-02f, 4.06026989e-02f, 2.90512834e-02f,
  -5.20639196e-02f, -1.67372778e-01f, 6.61951602e-02f, -4.24171127e-02f, 1.57881603e-02f, 4.69114296e-02f, 1.88832670e-01f, -8.73627365e-02f, -2.06384435e-01f, -1.78010285e-01f,
  9.69825163e-02f, -8.29761699e-02f, -2.05711164e-02f, 1.52496502e-01f, -1.09241575e-01f, 2.06839249e-01f, -1.32331103e-01f, 1.74884833e-02f, -9.50580761e-02f, 9.02060792e-02f,
  1.74031183e-01f, 1.95884928e-01f, 1.39465258e-01f, -9.78389196e-03f, 3.79831716e-02f, -1.70695499e-01f, -2.84081902e-02f, 1.77090749e-01f, -6.20297715e-02f, 6.00966290e-02f,
  1.60303041e-01f, -1.42548934e-01f, -1.00555599e-01f, -8.44895542e-02f, -3.03272810e-03f, -7.08011985e-02f, -1.77247688e-01f, 3.51149612e-03f, 4.68921335e-03f, 1.15779042e-01f,
  3.12529132e-02f, -1.60815179e-01f, -4.26486395e-02f, 3.71097811e-02f, -1.43308565e-01f, -9.25126299e-02f, 8.09163153e-02f, 1.29404590e-01f, -1.53876603e-01f, 1.31583437e-01f,
  -4.72940356e-02f, 4.04509529e-02f, -1.70724779e-01f, 1.35106817e-01f, 3.58675164e-03f, -1.66353658e-01f, 1.49986520e-01f, 1.68863043e-01f, -1.00894878e-02f, -2.98788995e-02f,
  4.42117974e-02f, -9.60162506e-02f, 2.07572691e-02f, -1.22000523e-01f, 9.15876776e-02f, 9.97836590e-02f, 5.67314886e-02f, 1.30287185e-01f, 1.61112361e-02f, -3.40672880e-02f,
  -3.64804044e-02f, -9.52648595e-02f, 1.56994328e-01f, -1.91571284e-02f, 1.40170902e-01f, 1.96041152e-01f, -1.26308307e-01f, 1.72073916e-01f, -4.56795506e-02f, -3.39364968e-02f,
  1.34816155e-01f, 1.58888921e-01f, 2.13076234e-01f, 1.31745279e-01f, 1.11686528e-01f, -4.50222753e-02f, 1.88361660e-01f, 1.80033267e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 14)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 14;
const float L1_fan_Bp_bar_data[] = {
  3.29971045e-01f, 2.82713324e-01f, 3.59558612e-01f, 2.02951282e-01f, 4.50577319e-01f, -1.06924921e-01f, 2.03150034e-01f, 2.62176007e-01f, 3.39363486e-01f, -9.98116881e-02f,
  7.26753026e-02f, 1.90761522e-03f, 6.74923584e-02f, -9.43123475e-02f
};

// L2_fan_Wp (Shape: 9 x 32)
const int L2_fan_Wp_rows = 9;
const int L2_fan_Wp_cols = 32;
const float L2_fan_Wp_data[] = {
  5.55522591e-02f, 4.70151864e-02f, 9.21862721e-02f, 9.85698774e-02f, -1.39999032e-01f, 1.38711900e-01f, 2.07429696e-02f, 1.31235808e-01f, -1.71934173e-01f, -2.56942779e-01f,
  2.35376209e-01f, -6.34663925e-03f, 1.60783842e-01f, -5.40300272e-03f, -2.28355676e-01f, -4.19883400e-01f, 7.56639466e-02f, 2.80116439e-01f, 4.47372437e-01f, 5.05780354e-02f,
  6.08150661e-02f, -6.32037446e-02f, -3.59057426e-01f, 1.71538159e-01f, 3.31237823e-01f, -1.42684922e-01f, -2.13974655e-01f, 2.85511948e-02f, 5.11074737e-02f, 5.49034737e-02f,
  9.59958956e-02f, -9.48805660e-02f, 1.09075449e-01f, 4.22909819e-02f, -1.38974085e-01f, -9.84341353e-02f, 2.56762486e-02f, 7.45320469e-02f, 1.42168090e-01f, 5.15502393e-02f,
  -1.15650885e-01f, 1.62421554e-01f, 1.59723327e-01f, -2.84692883e-01f, -1.58812568e-01f, 1.93940088e-01f, -1.31369382e-01f, -4.36907947e-01f, 6.59653842e-02f, 1.45326415e-02f,
  4.91881259e-02f, -1.86616734e-01f, 3.08592409e-01f, 1.77432165e-01f, -1.95619181e-01f, -9.73480865e-02f, -3.26749720e-02f, -3.18872422e-01f, 8.50402936e-02f, 8.59181359e-02f,
  -1.36011541e-01f, -8.16464201e-02f, -1.33103743e-01f, -4.28394750e-02f, 1.37458682e-01f, -1.17564380e-01f, 5.99770695e-02f, -2.11524457e-01f, -4.20838073e-02f, -1.02042174e-02f,
  -3.33330631e-02f, 9.73972157e-02f, -2.34994978e-01f, -3.96337658e-02f, 2.42934778e-01f, 5.41844405e-02f, 1.73927203e-01f, 7.01977238e-02f, 1.51721865e-01f, -4.15747404e-01f,
  2.44307920e-01f, 3.65152419e-01f, 3.81738126e-01f, -3.89806107e-02f, 1.08011246e-01f, -4.39963639e-02f, -3.12267095e-01f, -1.00493088e-01f, 3.17588262e-02f, -1.46321505e-01f,
  -2.24034190e-01f, -1.15263939e-01f, 1.62344635e-01f, -4.99152206e-02f, -1.53752223e-01f, 2.40815971e-02f, -5.97205572e-02f, -1.53493658e-01f, -1.27801495e-02f, 7.78917298e-02f,
  4.94327061e-02f, 5.26572987e-02f, -2.26925939e-01f, -4.61333655e-02f, 3.79468687e-02f, -7.46953413e-02f, -8.43659267e-02f, -1.07022725e-01f, 3.12692702e-01f, -1.19492203e-01f,
  1.74846098e-01f, 1.40142784e-01f, -1.63330123e-01f, 1.26761803e-02f, -1.74790815e-01f, 9.35292915e-02f, -5.88736497e-02f, -1.90738827e-01f, 2.89893866e-01f, 2.20389720e-02f,
  -3.53044607e-02f, 4.19265389e-01f, -2.45732069e-01f, -3.02221868e-02f, -7.17007816e-02f, -1.23148542e-02f, -6.96859211e-02f, 4.83458349e-03f, -1.14358172e-01f, 1.90326169e-01f,
  4.35962342e-02f, -2.77899783e-02f, 2.42238566e-01f, -8.15572441e-02f, 2.33938664e-01f, 1.62939355e-01f, 1.12976395e-01f, -6.82386458e-02f, 1.73618123e-01f, -4.90358705e-03f,
  2.30835378e-01f, 1.25997022e-01f, -1.10048965e-01f, -5.13583794e-02f, -2.71928370e-01f, 2.06499279e-01f, 1.29560575e-01f, -9.02059898e-02f, -1.51572570e-01f, -2.71218956e-01f,
  3.89838696e-01f, 5.18854260e-02f, -1.76312119e-01f, -2.74897218e-01f, -3.71868014e-01f, 1.47599742e-01f, 1.12589128e-01f, -1.66249290e-01f, -5.00232466e-02f, -1.40934721e-01f,
  -1.91291019e-01f, -1.77174941e-01f, -1.11854017e-01f, -1.23474039e-01f, -1.87818691e-01f, 6.58014715e-02f, -3.95805873e-02f, -1.42492816e-01f, -2.39686612e-02f, -2.30206043e-01f,
  3.79072964e-01f, -1.91140696e-01f, 1.76338404e-02f, -3.61819901e-02f, -2.56929398e-01f, -4.35611457e-01f, -8.86756033e-02f, 3.15986156e-01f, 3.36991757e-01f, -5.56910783e-02f,
  6.61615133e-02f, -6.30801916e-02f, -9.45346802e-02f, -1.68564349e-01f, -1.40865043e-01f, -2.92576887e-02f, -4.39266443e-01f, 1.84250083e-02f, 6.07513450e-02f, 2.50054169e-02f,
  4.92127873e-02f, 1.03768058e-01f, -2.21164990e-02f, -1.34127086e-03f, 3.72996852e-02f, 1.47697970e-01f, -1.78713992e-01f, 1.90819688e-02f, -1.95988685e-01f, -1.69629365e-01f,
  -3.63007598e-02f, 1.47334561e-01f, 2.68530343e-02f, -1.70837231e-02f, 2.77423173e-01f, -3.41229490e-03f, -2.19971940e-01f, 3.20784718e-01f, -4.95075807e-02f, -2.88695365e-01f,
  -4.05901074e-01f, 2.46072099e-01f, 1.40986800e-01f, 8.80025104e-02f, 1.75591871e-01f, -1.42588571e-01f, -4.08996314e-01f, 8.21689144e-02f, 1.07288852e-01f, 3.27047333e-02f,
  -1.13447949e-01f, 1.38275683e-01f, 8.25023800e-02f, 2.94150133e-02f, 8.03852156e-02f, 1.05001494e-01f, 2.08527073e-01f, 7.45774284e-02f, -1.17536210e-01f, 2.28144764e-03f,
  7.12233111e-02f, 1.08091615e-01f, 1.57851115e-01f, 3.48443747e-01f, -3.47227931e-01f, 1.39734790e-01f, -1.83018476e-01f, 2.75143385e-01f, -1.75957114e-01f, 1.69182733e-01f,
  8.14733505e-02f, -1.15635149e-01f, -4.33035880e-01f, 2.72371769e-01f, -1.28452048e-01f, 5.06125875e-02f, -2.17455477e-01f, -1.63358331e-01f, 4.71461974e-02f, 2.94612616e-01f,
  4.02600229e-01f, -1.69484660e-01f, 1.21569626e-01f, 1.12684578e-01f, 5.12349010e-02f, -1.56108394e-01f, 1.99477315e-01f, 1.02855086e-01f, 1.00571565e-01f, 2.12818220e-01f,
  -9.11390781e-03f, -1.57694563e-01f, -1.83068812e-01f, 1.03626929e-01f, 1.87895253e-01f, 3.24076653e-01f, -1.01139188e-01f, -8.00140481e-03f, 1.10344402e-02f, -1.85042366e-01f,
  3.18805903e-01f, 6.10241927e-02f, 2.61606157e-01f, -2.32978404e-01f, -1.20886177e-01f, 7.85431862e-02f, -1.58221394e-01f, 6.13661110e-02f, -1.77515760e-01f, -9.78461467e-03f,
  2.07632869e-01f, 3.79282385e-01f, 1.38513863e-01f, 9.60069299e-02f, 3.61851081e-02f, -1.70223936e-01f, 7.57579952e-02f, -4.82978858e-02f
};

// L2_fan_Wp_bar (Shape: 14 x 32)
const int L2_fan_Wp_bar_rows = 14;
const int L2_fan_Wp_bar_cols = 32;
const float L2_fan_Wp_bar_data[] = {
  -6.46655038e-02f, -9.87009257e-02f, 1.72893852e-01f, -9.35649425e-02f, 4.93848845e-02f, 1.29736930e-01f, 1.25295650e-02f, -2.58925874e-02f, 2.41150036e-01f, -1.23335786e-01f,
  -1.36870116e-01f, 1.36232272e-01f, -3.24772894e-01f, 9.73663256e-02f, -3.23585272e-01f, 3.91414501e-02f, 4.38809693e-02f, -9.50224623e-02f, 1.17260508e-01f, -2.10810006e-01f,
  1.41585708e-01f, 3.28996480e-01f, 5.42278215e-03f, -4.46249172e-02f, 3.02428268e-02f, 5.70508689e-02f, 3.21664661e-01f, 2.60805283e-02f, -1.73313126e-01f, 7.30962157e-02f,
  2.83654425e-02f, 2.35278774e-02f, 3.17317337e-01f, 1.90940559e-01f, 1.45082083e-02f, 2.83872187e-01f, 2.23616883e-01f, 6.94781840e-02f, 5.37573770e-02f, 2.44821668e-01f,
  3.35845262e-01f, 5.52841090e-02f, -2.19926208e-01f, 1.33084685e-01f, -1.23262227e-01f, 2.99509257e-01f, -1.58857495e-01f, 2.95727670e-01f, -2.14114487e-01f, -1.39231989e-02f,
  -7.95376524e-02f, 2.41703585e-01f, 3.01034659e-01f, 9.87522900e-02f, 4.56920981e-01f, -5.42156063e-02f, -5.08348525e-01f, 1.24089770e-01f, 3.72063488e-01f, 1.03193887e-01f,
  -1.18079521e-01f, -2.51976490e-01f, -1.43086523e-01f, -1.84869528e-01f, 3.44650507e-01f, 1.14700899e-01f, 5.75816073e-02f, 4.50260699e-01f, 2.11753771e-01f, 1.42832518e-01f,
  6.22266671e-03f, 3.27999413e-01f, 3.03659618e-01f, 2.22949803e-01f, -2.23390043e-01f, 1.59414679e-01f, -7.74346367e-02f, 2.31491312e-01f, -3.47505435e-02f, 3.50250810e-01f,
  8.26076493e-02f, -3.54917377e-01f, -4.25620407e-01f, 7.44073465e-02f, 2.12238863e-01f, 2.74385750e-01f, 3.03709239e-01f, -1.11857332e-01f, 1.40085459e-01f, 4.19433594e-01f,
  2.09279761e-01f, -1.47146925e-01f, -1.12982862e-01f, -3.01706027e-02f, 7.28989020e-02f, -2.23856166e-01f, 1.51954517e-01f, 3.64060663e-02f, 3.51528525e-01f, 1.46288931e-01f,
  3.67658585e-01f, 2.09315389e-01f, 9.04518273e-03f, 3.52570891e-01f, 2.99411505e-01f, -3.11997026e-01f, 2.49655083e-01f, -2.13443443e-01f, 1.92693397e-01f, 2.05852836e-01f,
  -4.65220362e-01f, -3.08461189e-01f, -1.25959158e-01f, 7.15340823e-02f, 1.09777227e-02f, 5.32334805e-01f, 7.76440442e-01f, 4.43302169e-02f, 3.74166742e-02f, 1.14545703e-01f,
  -3.08779806e-01f, 6.13846965e-02f, -1.80264324e-01f, -5.41549399e-02f, 1.93893075e-01f, -1.33399889e-01f, 7.91376010e-02f, 7.10095614e-02f, 5.38978577e-02f, 2.55296715e-02f,
  8.82181339e-03f, 1.38965040e-01f, 8.18867758e-02f, -3.18107270e-02f, 8.59904885e-02f, 2.31074095e-01f, 5.03590144e-02f, -6.26038760e-02f, 1.85637191e-01f, -1.99177206e-01f,
  -2.58716732e-01f, 1.63268209e-01f, -3.68761450e-01f, -1.93117857e-01f, 2.54061967e-01f, 1.83113202e-01f, 2.11006850e-01f, -1.38095930e-01f, 5.36260188e-01f, 1.93676695e-01f,
  -3.57990205e-01f, -3.82012352e-02f, 1.54887304e-01f, -9.97956321e-02f, 5.72100103e-01f, 5.24959750e-02f, 2.11157024e-01f, 3.13350052e-01f, 1.36429608e-01f, -9.16766152e-02f,
  -7.04112723e-02f, 1.38445929e-01f, 4.59802896e-02f, 9.76288319e-02f, 2.40508914e-01f, -1.78522989e-02f, -1.10613136e-02f, 1.77606210e-01f, -1.26361381e-02f, 3.65604355e-05f,
  2.10499302e-01f, -8.91643018e-03f, 5.47426939e-02f, -2.94201206e-02f, -1.15481496e-01f, -1.59039557e-01f, 9.68218446e-02f, -1.31581038e-01f, 1.41716883e-01f, 4.32090998e-01f,
  3.89959335e-01f, -1.30316451e-01f, -2.01687872e-01f, -4.60150801e-02f, 3.57964367e-01f, 2.99843490e-01f, -1.58330023e-01f, 8.19859877e-02f, 2.60827422e-01f, -1.11052193e-01f,
  -6.50986806e-02f, 9.78793427e-02f, 3.44213158e-01f, 1.74487621e-01f, 2.17934564e-01f, 2.89770544e-01f, 3.70729342e-02f, 3.04350764e-01f, -3.29887196e-02f, 2.17112869e-01f,
  3.96135300e-01f, 1.37149841e-01f, 1.02872625e-01f, -1.31296173e-01f, -4.49046791e-01f, -2.08250377e-02f, -3.12706888e-01f, 1.31159127e-01f, -2.42923141e-01f, -7.67768845e-02f,
  5.94795197e-02f, -2.25391522e-01f, 1.89593539e-01f, 4.26919878e-01f, 2.78875172e-01f, 6.93097487e-02f, -2.41181180e-01f, 6.43091351e-02f, 6.55670285e-01f, 6.17811605e-02f,
  -8.71372297e-02f, -1.35420501e-01f, -2.00954378e-01f, 1.71826288e-01f, -1.97709471e-01f, 2.65136927e-01f, 4.87088524e-02f, -2.28431687e-01f, -5.51157594e-02f, -1.43642444e-02f,
  1.25699088e-01f, 2.32117355e-01f, 5.26107987e-03f, -1.83264554e-01f, -1.71291176e-02f, -8.30230042e-02f, 6.02487087e-01f, 5.38613461e-02f, 6.71495870e-02f, 4.47203480e-02f,
  -2.28015557e-02f, 3.84242564e-01f, 2.34778114e-02f, 5.40997565e-01f, 3.15609097e-01f, -8.84775668e-02f, 5.04770517e-01f, -8.21236521e-02f, 2.31567636e-01f, 3.14742118e-01f,
  -5.25179088e-01f, -1.01116568e-01f, 2.99222499e-01f, 7.69337714e-02f, -4.68187295e-02f, -1.68845020e-02f, -1.35795847e-02f, 7.72282630e-02f, 1.18185222e-01f, 1.18782990e-01f,
  -1.67237625e-01f, -1.79105535e-01f, -1.31263152e-01f, 1.02341153e-01f, -1.76586770e-02f, 4.19666767e-02f, 6.26987740e-02f, 5.36883883e-02f, 3.38740908e-02f, 1.42985359e-01f,
  2.29042452e-02f, 1.20958269e-01f, 1.43913791e-01f, -5.10118641e-02f, 5.71974032e-02f, 7.44861588e-02f, -1.34338260e-01f, 1.45704355e-02f, 2.91671716e-02f, 9.40854400e-02f,
  -7.70582333e-02f, 1.83283519e-02f, 1.20639298e-02f, -1.76919941e-02f, 1.04099261e-02f, 1.42136469e-01f, -4.79813367e-02f, 1.00599021e-01f, -1.13656826e-01f, 1.35790825e-01f,
  1.93195447e-01f, 1.28476366e-01f, 1.04051251e-02f, 1.30032644e-01f, -3.74500491e-02f, 1.29830286e-01f, -9.70628485e-02f, -7.32495338e-02f, -2.47390747e-01f, 1.70947000e-01f,
  1.65599629e-01f, -3.99036884e-01f, 3.67232382e-01f, 2.97800004e-01f, -1.94192827e-01f, 1.10520333e-01f, 1.90920919e-01f, -8.40232968e-02f, -2.32739702e-01f, 4.40473594e-02f,
  6.80958390e-01f, 2.09982432e-02f, 1.34628892e-01f, 2.65782118e-01f, -1.19237266e-01f, -1.85742810e-01f, -2.34739147e-02f, 7.29146898e-02f, -1.56605542e-01f, 1.94636509e-01f,
  1.22867525e-01f, 1.90170482e-01f, -9.60664377e-02f, -1.40150234e-01f, 3.57537977e-02f, 1.04589246e-01f, 2.89144162e-02f, 2.96828840e-02f, -6.36599734e-02f, -1.49683446e-01f,
  -3.71583849e-01f, 2.64154792e-01f, 3.11682045e-01f, -3.91769797e-01f, 2.49784559e-01f, 3.71841997e-01f, 7.85858855e-02f, 1.73042655e-01f, -1.56755179e-01f, 1.94743738e-01f,
  -2.77026504e-01f, 2.62261406e-02f, 8.94150496e-01f, -1.03796542e-01f, -2.84715146e-01f, 2.31575534e-01f, 1.68570712e-01f, -2.08597966e-02f, -1.29930735e-01f, -1.52001709e-01f,
  1.02830663e-01f, 2.04811826e-01f, 1.82446793e-01f, 2.46734042e-02f, 1.52884975e-01f, 2.79681772e-01f, 3.33369553e-01f, 2.53539681e-01f, 2.11562902e-01f, 7.37953186e-02f,
  -1.42792642e-01f, 5.56696802e-02f, 4.60133940e-01f, -3.04049015e-01f, 1.66812971e-01f, 7.47329593e-02f, 8.23480338e-02f, -4.77473974e-01f, 1.91560790e-01f, 4.29266900e-01f,
  7.87086189e-01f, -1.25210598e-01f, -1.60165265e-01f, 1.84502855e-01f, -4.55726236e-02f, 4.34897877e-02f, 7.65392780e-01f, 1.64188072e-01f, -2.07699493e-01f, 7.08044767e-02f,
  2.38688607e-02f, -1.35680005e-01f, -7.65700936e-02f, -2.45257527e-01f, 2.60117382e-01f, -1.59938354e-02f, 2.50520706e-01f, 3.10174137e-01f, 2.61445135e-01f, 1.44251719e-01f,
  2.00923264e-01f, 4.32652347e-02f, 3.35646987e-01f, 2.71432698e-01f, -1.21530369e-01f, 2.31992796e-01f, -3.36970568e-01f, -3.51112068e-01f, 2.08278641e-01f, -1.51428645e-02f,
  1.01310737e-01f, 7.04876259e-02f, 5.93782187e-01f, -2.15237960e-01f, -4.10298854e-01f, 3.29918176e-01f, 7.09688738e-02f, 2.77718864e-02f, 9.24726129e-01f, 3.64339381e-01f,
  6.09297156e-01f, 1.53797165e-01f, -2.15748504e-01f, -2.81689540e-02f, 1.76862068e-02f, 1.69197932e-01f, -3.60684283e-03f, 1.88191757e-01f, 2.93323487e-01f, 2.92287350e-01f,
  2.58627713e-01f, 5.24197444e-02f, 2.54837722e-01f, 1.64860874e-01f, 6.28597941e-03f, -7.14549869e-02f, 1.58918247e-01f, -1.82740241e-01f, 3.34833860e-01f, 1.27699181e-01f,
  -3.16886604e-01f, 1.16536841e-01f, -2.05012992e-01f, 6.85593337e-02f, -1.68773696e-01f, 4.38078940e-01f, 5.77463150e-01f, 4.55210544e-02f, 4.17565167e-01f, 8.54736567e-02f,
  -3.35219353e-01f, 6.96368888e-02f, -1.88236251e-01f, 1.03254519e-01f, 1.68114930e-01f, -1.94741134e-02f, 1.59138277e-01f, -2.44248152e-01f
};

// L2_fan_Bp_bar (Shape: 1 x 14)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 14;
const float L2_fan_Bp_bar_data[] = {
  1.09474346e-01f, 2.22529814e-01f, 3.12219799e-01f, 5.38753346e-02f, 5.53806834e-02f, 9.27104130e-02f, 1.82174832e-01f, 2.03409821e-01f, -1.57473773e-01f, 2.48288319e-01f,
  1.57712162e-01f, 2.18850553e-01f, 1.99426264e-01f, 6.91840425e-02f
};

// L3_linear_W (Shape: 12 x 32)
const int L3_linear_W_rows = 12;
const int L3_linear_W_cols = 32;
const float L3_linear_W_data[] = {
  -3.40694726e-01f, 2.25465253e-01f, -2.87615299e-01f, 2.74787158e-01f, 1.57330662e-01f, 7.77012110e-02f, -1.80180863e-01f, -5.12919068e-01f, 1.90617010e-01f, -7.00798556e-02f,
  -1.96168828e-03f, 4.23170030e-01f, 6.12004958e-02f, 3.15307885e-01f, 5.15753329e-01f, -1.93784878e-01f, -3.07428718e-01f, 1.20911665e-01f, -1.84770972e-01f, -2.55789727e-01f,
  -5.47833264e-01f, 6.02283366e-02f, -2.09428683e-01f, 2.24738076e-01f, -3.75435740e-01f, -2.34009493e-02f, 1.07852273e-01f, 6.57966584e-02f, -3.55739862e-01f, 9.04995680e-01f,
  2.66412109e-01f, -3.20109010e-01f, 3.38831574e-01f, -6.38203770e-02f, 1.51159838e-01f, 2.06081361e-01f, -8.78707506e-03f, 3.90220135e-02f, -2.59111285e-01f, 1.66552737e-01f,
  9.34521377e-04f, 3.77785981e-01f, -4.10930097e-01f, 1.45258814e-01f, 2.00354204e-01f, 1.59065753e-01f, -2.45378986e-01f, -3.94965261e-01f, 4.67947535e-02f, 2.38300174e-01f,
  -3.15862477e-01f, -3.85194242e-01f, 3.98037303e-03f, -4.60377574e-01f, -4.26285088e-01f, 1.46102905e-01f, -5.68684101e-01f, 4.26399469e-01f, -1.70359403e-01f, 2.57533073e-01f,
  4.47571576e-01f, 2.32932746e-01f, 4.18965369e-01f, -1.24810681e-01f, 1.94350425e-02f, -1.33729264e-01f, -1.99204966e-01f, 4.16172184e-02f, -8.82717818e-02f, -3.95919353e-01f,
  1.83899000e-01f, 1.02985896e-01f, -4.41227466e-01f, -5.68094075e-01f, -1.08373739e-01f, -2.33072162e-01f, 3.74642611e-01f, -3.77177566e-01f, 9.83651653e-02f, 2.59174019e-01f,
  2.10875720e-01f, 5.44628911e-02f, -1.01886004e-01f, 3.61484672e-06f, 4.94266629e-01f, -4.57552820e-01f, -3.80968243e-01f, -8.87551680e-02f, 1.69063568e-01f, -2.22374409e-01f,
  1.21622838e-01f, 3.51319700e-01f, 4.37615424e-01f, -2.99328148e-01f, 4.44925249e-01f, -3.19754511e-01f, -4.00254309e-01f, -2.26932943e-01f, -5.34906164e-02f, -5.40785670e-01f,
  -1.55529782e-01f, 2.92754710e-01f, -2.67650813e-01f, 2.15417117e-01f, 1.52302623e-01f, 1.24897093e-01f, 3.26384515e-01f, 3.85154307e-01f, -1.96384296e-01f, -2.90918797e-01f,
  2.07809240e-01f, -1.39432877e-01f, -2.14475825e-01f, -6.41158968e-02f, 2.61509329e-01f, -5.54448843e-01f, -4.01971042e-01f, -2.11771071e-01f, 6.13079548e-01f, 1.19026966e-01f,
  8.95961374e-02f, -3.89326274e-01f, -1.73477858e-01f, -5.96643686e-01f, -2.18493521e-01f, 4.08078909e-01f, 4.24985260e-01f, -4.68334705e-01f, -1.92599013e-01f, 1.76802166e-02f,
  3.58029693e-01f, -1.40062449e-02f, 2.79696643e-01f, 3.24524730e-01f, 7.73282349e-02f, 2.76237518e-01f, 1.88075438e-01f, 2.53922611e-01f, 4.99501407e-01f, 3.91103476e-01f,
  -4.76596564e-01f, -2.12050080e-01f, -4.85808738e-02f, -1.16345368e-01f, 1.60051063e-01f, 9.40861031e-02f, -1.18323117e-02f, 1.75683677e-01f, 2.89688259e-01f, 3.19591671e-01f,
  4.71892983e-01f, 1.73336640e-01f, 2.29351446e-01f, -5.18123619e-02f, -7.38004968e-02f, -4.87166315e-01f, -4.00233686e-01f, 4.63899881e-01f, -2.10822478e-01f, 3.28758776e-01f,
  1.31422505e-01f, 4.80426967e-01f, 4.06592727e-01f, 2.00021580e-01f, -3.77570868e-01f, 3.59086484e-01f, 3.48998874e-01f, -6.25323206e-02f, 1.00087300e-01f, 3.82482857e-01f,
  -1.64038241e-01f, -2.45329402e-02f, 7.88005739e-02f, 6.67822778e-01f, 2.76178300e-01f, -2.68055081e-01f, -5.73702872e-01f, -4.28957731e-01f, -2.94277109e-02f, 1.53146744e-01f,
  -9.96907279e-02f, 3.90118182e-01f, -2.91417599e-01f, -1.65578455e-01f, 3.02330285e-01f, 2.00956061e-01f, 1.37640268e-01f, 1.90024704e-01f, 9.67706591e-02f, 3.18896115e-01f,
  -2.31400743e-01f, 4.26232725e-01f, -3.43441904e-01f, 2.13205591e-01f, -5.78259408e-01f, 8.83656144e-02f, -5.66666909e-02f, -2.29687080e-01f, -3.32321644e-01f, -1.50321245e-01f,
  -4.61957492e-02f, -5.04752576e-01f, -2.56164491e-01f, -1.59176201e-01f, 3.27455550e-01f, -5.31379841e-02f, -1.34401649e-01f, 3.89967710e-01f, 9.39875096e-02f, 7.22727999e-02f,
  1.49683774e-01f, 5.67736566e-01f, 5.57271421e-01f, 1.87854543e-01f, -9.96791348e-02f, 4.06078957e-02f, 2.86045820e-01f, -2.90815651e-01f, -1.22484475e-01f, 2.28656270e-02f,
  2.42351949e-01f, -5.81075609e-01f, -3.27343971e-01f, 3.28063160e-01f, -4.57572639e-01f, 1.46226496e-01f, -2.55531460e-01f, -2.21630768e-03f, 1.10625155e-01f, 3.33678201e-02f,
  2.18599200e-01f, -1.21426672e-01f, 7.54186735e-02f, 1.59601375e-01f, 1.21535704e-01f, 3.44041646e-01f, 5.37091196e-02f, 2.46840566e-02f, 3.81267160e-01f, 1.01617083e-01f,
  -1.19520262e-01f, -1.83917314e-01f, -7.21256882e-02f, -4.67536569e-01f, -5.69280803e-01f, 7.04838216e-01f, 4.10828024e-01f, 4.65302825e-01f, -5.20409048e-01f, 4.98767644e-01f,
  -8.15537721e-02f, -1.51896536e-01f, -1.31816089e-01f, -4.77405787e-02f, -7.35828221e-01f, 3.56061101e-01f, 1.67402178e-01f, -9.98828411e-02f, -4.01567295e-02f, -2.19718590e-02f,
  -3.11297160e-02f, 1.37708694e-01f, 1.77749008e-01f, -2.77012974e-01f, 1.79190084e-01f, -4.55207229e-01f, -4.12279755e-01f, -1.13841280e-01f, 3.17537636e-01f, 2.61704594e-01f,
  7.62034953e-02f, 1.75293088e-01f, -4.42837477e-01f, -2.72941619e-01f, -1.73334807e-01f, 9.04863402e-02f, -2.84990251e-01f, -4.30688590e-01f, -1.82976216e-01f, -5.00676990e-01f,
  -8.71292129e-02f, 3.38789105e-01f, 3.74751538e-02f, 5.81897676e-01f, 9.17609572e-01f, -3.49564761e-01f, -2.85055846e-01f, -1.33435830e-01f, 3.02971244e-01f, 7.75640383e-02f,
  2.35554770e-01f, 5.87835461e-02f, -2.00129915e-02f, 3.21241140e-01f, 1.62212159e-02f, 2.49594256e-01f, 2.22787440e-01f, -1.36007458e-01f, -1.51734084e-01f, -3.58372062e-01f,
  1.91798314e-01f, 1.78316697e-01f, -6.27659187e-02f, 5.00317812e-01f, 4.09248829e-01f, -1.33529484e-01f, -1.82608992e-01f, 3.06914508e-01f, 2.55350709e-01f, 6.49738193e-01f,
  -2.56085455e-01f, 2.91240752e-01f, -3.08911234e-01f, 5.58256924e-01f, -4.93871942e-02f, -2.87830144e-01f, -9.10579711e-02f, -4.89321262e-01f, -8.45439196e-01f, 4.59575415e-01f,
  1.84941083e-01f, 1.68579325e-01f, 2.00679094e-01f, 9.29557160e-02f, -2.42316231e-01f, -2.80957341e-01f, 2.97634018e-04f, 3.24127376e-02f, -3.68700266e-01f, 4.23037618e-01f,
  -2.13774741e-01f, -2.52363026e-01f, -2.96788603e-01f, -2.88319230e-01f, -2.86012858e-01f, -2.29895547e-01f, 2.34640315e-01f, 1.21550560e-01f, 1.38102725e-01f, -3.02565157e-01f,
  2.80463517e-01f, -4.57871318e-01f, 7.68598318e-02f, -5.38161211e-03f, 2.72355210e-02f, -3.80071074e-01f, -1.18277110e-01f, -7.23306313e-02f, -3.56604189e-01f, 2.17658401e-01f,
  8.27912092e-01f, -5.55752397e-01f, 5.11721730e-01f, 1.38117671e-01f, 2.72870600e-01f, -8.09135213e-02f, 2.16274038e-01f, -1.98438302e-01f, 1.81345880e-01f, 1.60625786e-01f,
  3.13306600e-01f, -3.16938490e-01f, 1.43334419e-01f, -3.44884127e-01f, -5.47537625e-01f, -7.67069235e-02f, -3.73689860e-01f, -7.29086921e-02f, 3.59845191e-01f, -1.07670061e-01f,
  3.82309079e-01f, 4.80571300e-01f, 1.84924722e-01f, 1.08826406e-01f, 2.69037306e-01f, -2.33202949e-01f, 7.49746144e-01f, -7.39623964e-01f, -1.15680285e-01f, -2.42013052e-01f,
  1.23269511e-02f, -4.76087302e-01f, 1.71174094e-01f, -1.11089826e-01f
};

// L3_linear_B (Shape: 1 x 12)
const int L3_linear_B_rows = 1;
const int L3_linear_B_cols = 12;
const float L3_linear_B_data[] = {
  8.05786327e-02f, -5.19795390e-03f, -1.44393653e-01f, -7.74043053e-02f, -1.40445247e-01f, 1.98075116e-01f, 1.40326582e-02f, 1.08694367e-01f, 5.80555201e-02f, -6.13943581e-03f,
  -1.77549854e-01f, 6.08206578e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 9, 14
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        32, 9, 14
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        32, 9, 14
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_linear
    linear_forward_pgm(
        buffer1, x_out,
        L3_linear_W_data, L3_linear_B_data,
        32, 12
    );
    }
    