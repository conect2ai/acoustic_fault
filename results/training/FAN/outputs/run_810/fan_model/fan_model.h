/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 16 (x4)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 16;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    float x3 = x * x * x;
    return 0.5f * x * (1.0f + tanhf(0.79788456f * (x + 0.044715f * x3)));
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 4 x 120)
const int L0_fan_Wp_rows = 4;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  6.96717948e-02f, -1.35120511e-01f, -4.72749770e-02f, 1.51324542e-02f, 1.38032839e-01f, -4.57534119e-02f, -1.36388287e-01f, -1.47814080e-01f, -2.98089394e-03f, -1.12075044e-03f,
  1.55569285e-01f, 2.86025614e-01f, 1.36420831e-01f, -1.81526151e-02f, -1.59651145e-01f, -2.24679917e-01f, -2.59681940e-01f, -1.76849350e-01f, -4.37720194e-02f, 1.00692369e-01f,
  4.78472598e-02f, 1.95088908e-02f, -6.95654079e-02f, -1.86575335e-02f, 2.04172786e-02f, 2.63574928e-01f, 1.34558976e-02f, 4.61569577e-02f, 8.27735960e-02f, -1.88810825e-01f,
  1.90873697e-01f, -9.71153006e-02f, 4.25722310e-03f, 1.03552938e-01f, 9.37299132e-02f, -3.38077322e-02f, 3.61902243e-03f, -1.15971878e-01f, -6.65165186e-02f, 2.59534568e-02f,
  1.46757916e-01f, 3.83473337e-02f, 1.18261069e-01f, 3.59343216e-02f, 2.33333167e-02f, -1.28466934e-01f, -4.67659682e-02f, -1.41849041e-01f, -8.97186920e-02f, 1.74315851e-02f,
  -2.68725157e-02f, 4.82286438e-02f, -6.33338764e-02f, -2.35935338e-02f, -1.20903641e-01f, -2.10562740e-02f, -2.51270421e-02f, 2.48135421e-02f, -4.36254516e-02f, -6.77485168e-02f,
  1.26458243e-01f, -1.05624050e-02f, 2.36371923e-02f, 8.47599097e-03f, -3.01783029e-02f, 4.91623953e-02f, -6.03919558e-04f, -1.57820806e-02f, -8.92483257e-03f, 6.07481971e-03f,
  -2.86977738e-03f, -7.43117882e-03f, -2.97555272e-02f, -4.54602316e-02f, 6.93937317e-02f, 8.69696587e-03f, -5.14390171e-02f, 1.40360165e-02f, 5.41097149e-02f, -5.63267507e-02f,
  -1.11390434e-01f, 2.95818521e-04f, 7.40686506e-02f, -4.62119505e-02f, -3.31924632e-02f, -5.19558378e-02f, -2.81154402e-02f, -5.92599297e-03f, -1.68259963e-02f, 3.15535665e-02f,
  2.71722913e-01f, -1.09276595e-02f, -2.24383175e-02f, -5.55814244e-02f, 1.87134352e-02f, 8.24039131e-02f, 7.72535428e-02f, -1.17822802e-02f, 7.52433762e-02f, -8.68867859e-02f,
  2.81916112e-02f, -7.19907954e-02f, 4.37510274e-02f, 1.56169266e-01f, -3.58357728e-02f, 9.55931470e-03f, 2.68559866e-02f, 4.27834801e-02f, 1.21130422e-02f, -8.18833560e-02f,
  -3.95810790e-02f, -5.06076738e-02f, -6.90860599e-02f, -1.48266375e-01f, -2.81317085e-02f, 5.10653947e-03f, 6.00618832e-02f, -2.42034364e-02f, 7.06620589e-02f, 1.12912521e-01f,
  2.16554046e-01f, -1.21936038e-01f, -5.84962130e-01f, 8.86481479e-02f, -3.36345345e-01f, 1.20071121e-01f, 1.00002572e-01f, 2.80929863e-01f, 1.18512928e-01f, -1.80598795e-02f,
  1.64347105e-02f, 3.11671402e-02f, -4.94149402e-02f, 8.73914957e-02f, 2.54345626e-01f, -1.44941226e-01f, -2.87215233e-01f, -1.75763443e-01f, 1.52787000e-01f, 5.42237386e-02f,
  6.21172413e-02f, -2.19904780e-02f, 1.06979450e-02f, 1.24401666e-01f, -1.28049299e-01f, 4.53817248e-01f, -1.78180233e-01f, -1.58435047e-01f, 2.32694484e-02f, -3.38599503e-01f,
  -4.33178097e-02f, -1.78331390e-01f, 3.06647317e-03f, 1.07505955e-01f, -5.28705157e-02f, 6.84490204e-02f, 6.64267838e-02f, -1.37033805e-01f, -1.00200094e-01f, -2.01894026e-02f,
  -9.94761810e-02f, -1.03458799e-02f, -1.10530302e-01f, 3.11140325e-02f, -5.67995422e-02f, 3.51214074e-02f, 1.23209003e-02f, -7.11734295e-02f, -7.43818805e-02f, 4.71373983e-02f,
  -1.56429321e-01f, -1.21228181e-01f, -1.72059521e-01f, 3.86267155e-02f, 1.16645932e-01f, -6.70438930e-02f, 4.94779609e-02f, 3.71771269e-02f, -4.78472747e-03f, 1.33451939e-01f,
  8.92940313e-02f, -1.29524432e-02f, -2.42476305e-03f, -2.88074426e-02f, 8.95400122e-02f, 5.42131178e-02f, -6.24907613e-02f, 8.44072104e-02f, -3.12296115e-02f, 6.99526891e-02f,
  -1.79480333e-02f, -5.40753379e-02f, -3.86414565e-02f, 1.83234531e-02f, 5.18141203e-02f, -4.36575105e-03f, 8.62605066e-06f, 4.88116145e-02f, -2.36751977e-02f, -2.61371932e-03f,
  7.06341714e-02f, -1.34544065e-02f, 5.36551252e-02f, -5.30475378e-02f, -2.23766416e-02f, -6.21586330e-02f, -4.34788987e-02f, 4.44481485e-02f, 3.76236103e-02f, -3.57083790e-02f,
  2.51468390e-01f, -8.45869258e-02f, 1.86585318e-02f, -1.97712909e-02f, -1.21436650e-02f, -2.86947060e-02f, -9.16392282e-02f, 5.46270721e-02f, -1.08661138e-01f, 4.08976898e-02f,
  2.19031610e-02f, 5.10204993e-02f, -1.00044578e-01f, 3.42551172e-02f, 2.74343416e-02f, 7.10642710e-02f, 6.83686286e-02f, -3.65408813e-03f, -4.11638059e-02f, 4.54456575e-04f,
  -3.96803347e-03f, 1.55884579e-01f, 3.79445851e-01f, 1.02549471e-01f, 4.85550314e-02f, 1.47199199e-01f, 1.04163751e-01f, 9.09852013e-02f, 2.43074968e-01f, 4.82645631e-01f,
  -2.27555305e-01f, -1.25903383e-01f, -1.82471760e-02f, -3.68210971e-01f, 1.93105880e-02f, 2.47823019e-02f, -2.36713022e-01f, -9.61775705e-02f, -3.13288718e-02f, -1.50140962e-02f,
  5.27781844e-02f, 7.13908747e-02f, 7.62228742e-02f, 7.57927224e-02f, -1.25187725e-01f, -5.90477958e-02f, -1.27863809e-01f, -2.97102123e-03f, 4.06862004e-03f, 1.30662194e-03f,
  6.94527626e-02f, -1.98057026e-01f, -1.84288770e-01f, -5.65181673e-02f, 4.80138324e-02f, 1.53775856e-01f, -1.27520831e-02f, -7.14325672e-03f, 2.21564531e-01f, 2.24037006e-01f,
  2.96214461e-01f, -9.33212489e-02f, 6.25475794e-02f, -4.58964445e-02f, -3.94077562e-02f, -6.07044473e-02f, -6.20526671e-02f, -2.59726997e-02f, 4.45655324e-02f, 1.33112343e-02f,
  4.97496128e-03f, 9.86937582e-02f, -9.36713740e-02f, 4.15707193e-02f, -7.08204657e-02f, 5.64420223e-02f, -5.86860627e-02f, -1.04778498e-01f, -5.10318018e-02f, 9.73238796e-02f,
  8.80103335e-02f, 7.31773004e-02f, 1.36568798e-02f, -1.96882128e-03f, -8.51530805e-02f, 4.44553047e-03f, 3.46903577e-02f, 1.11532077e-01f, -4.91554141e-02f, 7.32719228e-02f,
  -2.14833356e-02f, 4.82861884e-02f, -1.83416605e-02f, -3.88762094e-02f, 4.35935147e-02f, 7.16049457e-03f, -9.34115238e-03f, 3.30174267e-02f, -1.51468096e-02f, -6.03519529e-02f,
  -2.27825679e-02f, -4.08077203e-02f, 1.08553190e-02f, 5.46570346e-02f, 3.14306319e-02f, -1.75329484e-02f, -8.57903622e-03f, -3.80302295e-02f, 2.63860542e-02f, 2.32342333e-02f,
  8.31768364e-02f, 2.20014751e-02f, -4.11867797e-02f, -5.26283868e-03f, 6.18386129e-03f, 1.05910944e-02f, 3.97536084e-02f, 1.60141699e-02f, 3.05822976e-02f, -6.58215676e-03f,
  -1.80084214e-01f, -8.89519509e-03f, 1.60616472e-01f, -5.97933754e-02f, 8.96052569e-02f, -5.54237515e-03f, 4.20660106e-03f, 2.19377894e-02f, -2.06503971e-03f, 5.69682457e-02f,
  -2.91665699e-02f, 3.28205265e-02f, -2.06434019e-02f, -4.80638146e-02f, 1.44899674e-02f, 2.40065400e-02f, -1.63972117e-02f, 1.17482938e-01f, -3.59059647e-02f, 6.98425397e-02f,
  -8.47352445e-02f, -4.98714559e-02f, 3.16282734e-02f, -2.66707372e-02f, 7.29858726e-02f, -4.20306511e-02f, -4.49912995e-02f, 2.08407771e-02f, -6.43759221e-03f, -1.39599666e-01f,
  3.85086268e-01f, -8.46587569e-02f, -2.06479296e-01f, 4.97394770e-01f, -9.84977372e-03f, -1.02672502e-01f, -2.78475672e-01f, -1.28455266e-01f, 8.34499002e-02f, -1.04445778e-01f,
  4.48517362e-03f, 2.73677021e-01f, -3.47824283e-02f, -2.45918967e-02f, -6.44941442e-03f, -1.95949912e-01f, 1.01297490e-01f, 1.82788998e-01f, 2.04839464e-02f, 1.29741058e-01f,
  9.80662704e-02f, 2.90088296e-01f, 3.10089201e-01f, -1.31956920e-01f, 6.19389080e-02f, -4.14207391e-02f, -2.43532270e-01f, 3.01884264e-01f, -2.12190330e-01f, 6.26966894e-01f,
  1.28346623e-03f, 3.60221672e-03f, -1.79768074e-02f, 8.10872838e-02f, 2.97360811e-02f, -6.80357441e-02f, 9.70600289e-04f, 6.20345473e-02f, -1.63599588e-02f, -2.04686522e-02f,
  7.98652992e-02f, 4.51087244e-02f, 3.42552811e-02f, 2.60709152e-02f, 3.73612121e-02f, 6.57655522e-02f, -2.35937331e-02f, 6.22071326e-02f, 8.52214172e-03f, -4.83522639e-02f,
  8.39215070e-02f, 8.81263465e-02f, -1.10000772e-02f, -6.82972595e-02f, -1.20472446e-01f, 4.90566380e-02f, -6.01605996e-02f, 8.06347057e-02f, -7.82006457e-02f, 1.36908710e-01f,
  4.30988194e-03f, -5.06964177e-02f, -2.74441596e-02f, -1.94168184e-02f, 1.91373657e-02f, -6.96996003e-02f, 4.05989885e-02f, -1.38004543e-02f, 2.50760801e-02f, 1.94437858e-02f,
  -1.79378428e-02f, -7.36377295e-03f, 4.55290516e-04f, 1.32090980e-02f, -2.91301198e-02f, 1.67542715e-02f, -1.10622011e-02f, -1.98831912e-02f, 7.23835966e-03f, 6.15144661e-03f,
  4.93319798e-03f, -3.37639339e-02f, -1.09143360e-02f, 2.51722485e-02f, -3.04079223e-02f, 8.32679402e-03f, 3.57667729e-03f, -5.56970388e-02f, -2.27963906e-02f, 4.35758382e-02f,
  2.33145971e-02f, -5.57868853e-02f, 6.64410517e-02f, -3.10908649e-02f, 3.52102369e-02f, 3.14916577e-03f, 3.00792400e-02f, -4.61671688e-02f, 1.18505126e-02f, 9.11452994e-03f,
  -3.32126617e-02f, -6.79285731e-03f, 4.07462977e-02f, -2.79359892e-02f, -1.16127729e-03f, -4.23587188e-02f, 1.94950700e-02f, 8.29791650e-03f, -5.33173084e-02f, 3.39480937e-02f,
  -4.14233990e-02f, -4.94831540e-02f, -3.17951962e-02f, -8.26276988e-02f, 8.32547173e-02f, 3.07447389e-02f, -1.43003371e-02f, -1.01089757e-02f, -8.11123550e-02f, -1.91435397e-01f
};

// L0_fan_Wp_bar (Shape: 8 x 120)
const int L0_fan_Wp_bar_rows = 8;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  1.34914279e-01f, 8.05151165e-02f, 2.45805755e-02f, 1.33931756e-01f, 1.04602948e-01f, 3.20139304e-02f, -5.55430800e-02f, 1.56126879e-02f, 4.02151272e-02f, 3.89593057e-02f,
  5.15940860e-02f, 2.54320838e-02f, -5.74497357e-02f, -5.75631484e-02f, -1.50334388e-01f, -1.44168120e-02f, 6.45334125e-02f, 2.13117525e-02f, -8.04276019e-03f, -1.59922820e-02f,
  7.16632698e-03f, -3.40616107e-02f, 9.57798958e-03f, 2.95603164e-02f, -5.61863147e-02f, -1.89801201e-01f, -8.89232308e-02f, -7.36543862e-03f, 9.52373222e-02f, 2.56931871e-01f,
  4.59698550e-02f, 3.56100663e-03f, -1.81619853e-01f, -3.87180708e-02f, -9.81255248e-03f, 1.23555928e-01f, 1.10728905e-01f, -2.50684917e-02f, -1.50255814e-01f, -5.79057373e-02f,
  5.95371760e-02f, 5.90479514e-03f, 4.44595814e-02f, 1.49273910e-02f, -1.60838068e-02f, -4.71840762e-02f, 5.16334921e-03f, -5.66590615e-02f, -3.72005887e-02f, 8.62985551e-02f,
  4.61376868e-02f, 4.93421741e-02f, -2.79555395e-02f, -5.27879000e-02f, -1.77497622e-02f, -5.37031218e-02f, -1.20701961e-01f, -9.79940221e-02f, -1.22510493e-02f, 8.01527649e-02f,
  -4.45494168e-02f, -1.02850050e-02f, 6.04844093e-02f, 5.07433228e-02f, -6.42578229e-02f, -2.40324605e-02f, 1.56009579e-02f, -6.95472136e-02f, 1.75095350e-02f, 5.15713803e-02f,
  3.29458527e-02f, 9.66179147e-02f, 2.09408607e-02f, -1.13771662e-01f, -1.96832810e-02f, 7.89486393e-02f, 1.22233070e-02f, 2.78303698e-02f, -5.92900105e-02f, 4.93105501e-02f,
  -7.55886063e-02f, -2.96488218e-02f, 3.28953080e-02f, 2.61316486e-02f, -4.19779904e-02f, 1.00093735e-02f, 6.31724903e-03f, 6.14748038e-02f, 1.51342032e-02f, -2.09409799e-02f,
  -5.78412861e-02f, -1.63965702e-01f, -1.91865787e-02f, -2.98849717e-02f, -1.06573090e-01f, -2.82381126e-03f, 1.38939217e-01f, -1.76686347e-02f, 6.03627004e-02f, -4.68413718e-02f,
  5.25060892e-02f, -6.36279136e-02f, 3.87390740e-02f, 1.11040369e-01f, -3.36399861e-02f, -5.97394370e-02f, -2.85454672e-02f, -4.08841819e-02f, -4.32890952e-02f, 2.42862999e-02f,
  1.21156164e-01f, -4.56050923e-03f, 4.09150720e-02f, 5.30190729e-02f, 7.12810606e-02f, -3.86411212e-02f, -6.62495568e-02f, -9.80587453e-02f, -9.58740339e-02f, -4.24784794e-02f,
  1.21817496e-02f, -1.21336244e-01f, -3.15385312e-01f, 1.42256841e-01f, -9.64946449e-02f, -6.45026863e-02f, -1.74752623e-01f, 8.52267444e-02f, 1.67503893e-01f, -1.87126294e-01f,
  -2.00667024e-01f, -1.11378916e-01f, -2.27732539e-01f, -9.53088477e-02f, -1.61557257e-01f, -1.96019322e-01f, -4.27644365e-02f, -5.51991127e-02f, -1.22729667e-01f, -4.77231927e-02f,
  -2.70657204e-02f, -1.32865063e-03f, -3.45139694e-03f, 3.26184072e-02f, -1.52770132e-01f, -8.20810571e-02f, -1.68953001e-01f, -1.46896899e-01f, -1.24441952e-01f, -1.92580581e-01f,
  -4.52499032e-01f, -3.58974226e-02f, -8.13874379e-02f, -2.90591642e-02f, -1.51187137e-01f, 2.11309101e-02f, -2.91507272e-03f, 6.70068562e-02f, 3.68838641e-03f, -9.28070769e-02f,
  -7.18913972e-02f, 4.79948334e-02f, -2.31095329e-02f, -4.82965522e-02f, -6.64447844e-02f, -1.24036588e-01f, 1.56546265e-01f, 1.33527014e-02f, 3.29774246e-02f, -8.16737209e-03f,
  -1.60063021e-02f, -8.31001997e-02f, -1.09547630e-01f, -3.16204540e-02f, -9.34746023e-03f, -1.09171458e-01f, -4.34742961e-03f, -8.74144584e-02f, -2.16443747e-01f, -7.06080794e-02f,
  -8.83423388e-02f, -6.18289821e-02f, -1.57312639e-02f, 7.60987587e-03f, 3.16546112e-02f, 2.72141360e-02f, -1.03402212e-01f, 2.32959799e-02f, -2.26716828e-02f, -2.98830438e-02f,
  -9.76992026e-03f, 2.21958105e-02f, 5.59472702e-02f, -1.72018260e-02f, -2.63561606e-02f, -4.32620160e-02f, 7.29253069e-02f, -2.93736234e-02f, 1.83875263e-02f, 2.75523365e-02f,
  -4.52119019e-03f, 2.91931611e-02f, 1.78011060e-02f, 6.26781955e-02f, -7.32915178e-02f, 4.37831506e-02f, 9.50856321e-03f, -2.38525178e-02f, 2.95284074e-02f, -8.59422609e-02f,
  1.96017511e-02f, 8.35873932e-02f, -3.38585153e-02f, 1.17549494e-01f, 3.53370495e-02f, 6.33193851e-02f, -2.89552342e-02f, 3.10963728e-02f, -5.90890739e-03f, 3.14009748e-02f,
  -1.10706929e-02f, 5.10606281e-02f, -4.46525216e-02f, -2.70458963e-03f, -5.79559132e-02f, -8.40249956e-02f, 2.18955372e-02f, -2.21755216e-03f, 1.26936436e-01f, 1.32494450e-01f,
  1.08498819e-01f, 1.80829633e-02f, -3.27441096e-02f, 8.27636793e-02f, 7.01494217e-02f, -1.54967525e-03f, -3.69598381e-02f, 3.11121047e-02f, -5.24379425e-02f, 1.77433081e-02f,
  2.38947228e-01f, 1.21326603e-01f, -6.38606846e-02f, -3.31700474e-01f, -3.45875561e-01f, -2.62076437e-01f, -5.36980964e-02f, -2.11467981e-01f, -2.64402986e-01f, -1.39931515e-01f,
  1.53042555e-01f, 3.57556045e-01f, 4.41555321e-01f, 3.78752023e-01f, 3.17786455e-01f, 1.98359303e-02f, -1.57281518e-01f, 2.56884694e-01f, 2.63395607e-01f, -1.28245309e-01f,
  -1.26658350e-01f, -1.49484456e-01f, -6.03097565e-02f, -5.22636101e-02f, -2.55520880e-01f, 1.52238309e-01f, -1.42592132e-01f, -1.40282642e-02f, 1.22134872e-01f, -9.89374071e-02f,
  1.75637409e-01f, -2.85209417e-02f, 2.91985401e-04f, -2.17126142e-02f, 8.54641292e-03f, 2.11891104e-02f, 6.14829473e-02f, 7.80003071e-02f, 3.54035683e-02f, -4.16566990e-02f,
  2.32614055e-02f, -1.23420186e-01f, 1.44212283e-02f, -1.03549913e-01f, 9.97899380e-03f, -3.24017666e-02f, 2.41925325e-02f, 4.53348532e-02f, 1.35452688e-01f, -7.97595084e-03f,
  -5.62641174e-02f, -1.36149272e-01f, 1.57607403e-02f, -2.69714184e-02f, -4.19609733e-02f, 1.02132857e-01f, -5.88118285e-02f, -9.67513025e-02f, 8.11481923e-02f, -8.22790191e-02f,
  -6.15737960e-02f, 4.68908623e-02f, -3.79113341e-03f, -1.51099088e-02f, 3.87182459e-02f, -5.14940650e-04f, -6.64023980e-02f, -1.23189874e-02f, -2.28773174e-03f, 3.94320264e-02f,
  -1.18194632e-02f, 8.37761387e-02f, -5.81465736e-02f, -2.38328595e-02f, -6.09147828e-03f, -4.28978689e-02f, 2.21533086e-02f, 6.61303923e-02f, -1.38739834e-03f, -4.60070334e-02f,
  6.39702007e-02f, -1.69238690e-02f, 2.97291987e-02f, 6.48536459e-02f, -1.16321780e-01f, 4.36335094e-02f, -1.13644227e-02f, -1.92852113e-02f, 2.87836716e-02f, -8.26687515e-02f,
  1.33721337e-01f, 1.58471644e-01f, 4.62997817e-02f, 1.35596916e-01f, -6.46673515e-02f, -1.31879561e-02f, -1.98584907e-02f, -5.83028719e-02f, 4.72081937e-02f, 2.47862935e-02f,
  -9.63544764e-04f, 6.52460083e-02f, 1.04619693e-02f, -3.11879292e-02f, 1.48308175e-02f, -7.75726363e-02f, -2.85548568e-02f, 1.11540869e-01f, -4.21174318e-02f, -1.07847765e-01f,
  -6.77701011e-02f, 5.89476377e-02f, 2.25395396e-01f, 8.44065920e-02f, 2.56862156e-02f, 1.84342578e-01f, 1.19963065e-01f, 2.91087013e-02f, 1.43666238e-01f, 4.56650667e-02f,
  1.95350274e-01f, -6.92502223e-03f, 2.22815469e-01f, 2.33866915e-01f, 9.57557335e-02f, 2.57121831e-01f, 1.85125574e-01f, 5.91460504e-02f, 1.82890275e-03f, 6.61597550e-02f,
  -4.44109403e-02f, -8.90969709e-02f, -1.70988336e-01f, -1.71284080e-01f, 1.17943920e-02f, 1.00286100e-02f, 9.91684198e-02f, -5.94309857e-03f, -7.76206851e-02f, -5.59091270e-02f,
  -1.82512905e-02f, 8.40341747e-02f, 8.50223564e-03f, -9.99723673e-02f, -1.39278218e-01f, -1.28586724e-01f, -8.00076574e-02f, 1.31811380e-01f, -1.01543106e-01f, -1.10826500e-01f,
  -8.85967091e-02f, 3.09255838e-01f, -1.21917352e-01f, -6.84338585e-02f, 1.81536411e-03f, -3.35477889e-02f, -4.82234284e-02f, -1.73216518e-02f, 8.29648450e-02f, 1.25453651e-01f,
  1.67146558e-03f, 5.36190458e-02f, 1.13982283e-01f, 1.10744154e-02f, 6.96978765e-03f, -2.24282295e-02f, -8.47270936e-02f, 9.31328014e-02f, 1.04134344e-02f, 4.04246189e-02f,
  3.14575769e-02f, 1.83572218e-01f, 1.59170300e-01f, 1.47780403e-01f, 1.17248461e-01f, -1.05313629e-01f, -9.06040240e-03f, 8.95306543e-02f, 1.40539616e-01f, -9.23602376e-03f,
  -7.13171214e-02f, 1.01224650e-02f, -9.08007100e-02f, 2.38672812e-02f, 6.54946342e-02f, -1.49740530e-02f, -2.66881362e-02f, -8.24923366e-02f, 2.14953981e-02f, -6.09043799e-02f,
  -3.32938284e-02f, -9.46123004e-02f, 3.88275385e-02f, -5.51079288e-02f, 9.47056897e-03f, 3.02353762e-02f, -1.99782718e-02f, 6.90124184e-02f, -7.25553883e-03f, 9.09200832e-02f,
  3.96676920e-02f, 1.09859994e-02f, 6.68720156e-02f, -7.09089190e-02f, -4.02850695e-02f, 4.73275930e-02f, 4.43023145e-02f, -7.03427866e-02f, -6.58965204e-03f, 1.82023912e-03f,
  -1.50120497e-01f, 1.37345180e-01f, -9.48359594e-02f, -5.25829419e-02f, 4.66819331e-02f, 6.10231713e-04f, -3.44328135e-02f, 1.51712345e-02f, 1.35037184e-01f, 7.00424388e-02f,
  2.90042665e-02f, 6.45123646e-02f, 5.82292043e-02f, -4.04943246e-03f, -6.46546707e-02f, 5.44772390e-03f, -3.03135645e-02f, 4.03728560e-02f, -2.43884092e-03f, -4.51711491e-02f,
  5.56189008e-02f, 9.39827487e-02f, 4.94231237e-03f, -3.63923050e-02f, -1.09192669e-01f, -9.53524187e-02f, -5.32263033e-02f, -3.55156362e-02f, -4.53389473e-02f, -1.75438836e-01f,
  -3.91087294e-01f, 1.27449363e-01f, 6.47113994e-02f, 2.12518424e-01f, 1.15615889e-01f, 2.19182491e-01f, 3.11703444e-01f, 2.88622022e-01f, -1.50611429e-02f, 5.21136150e-02f,
  -1.20006176e-02f, -4.79300506e-02f, 3.01806182e-02f, 3.88714075e-02f, 1.16894528e-01f, 1.22875527e-01f, 1.86368302e-01f, 7.38376752e-02f, -1.20003924e-01f, -1.18864290e-02f,
  1.09216183e-01f, -1.10317096e-01f, -1.21963158e-01f, -9.05540306e-03f, 1.11578047e-01f, -7.90339522e-03f, 5.64768687e-02f, 3.74075472e-02f, -1.26358792e-01f, 1.76285759e-01f,
  -4.52745110e-02f, -1.60338178e-01f, 6.27543330e-02f, -1.32133290e-01f, -9.76729393e-02f, -1.12398125e-01f, 2.89976634e-02f, -1.70576662e-01f, -7.88901150e-02f, -2.11720541e-02f,
  6.56976923e-02f, -1.11403558e-02f, 6.18052557e-02f, 1.08196521e-02f, -1.12657314e-02f, -7.36985169e-03f, -5.08541800e-02f, 8.56116712e-02f, -4.58647758e-02f, -1.11028135e-01f,
  4.60963845e-02f, -1.05295114e-01f, -8.29684287e-02f, 7.56702647e-02f, 5.69836572e-02f, -9.01092738e-02f, 3.61953974e-02f, 3.84446792e-02f, 2.99442597e-02f, -4.16352451e-02f,
  -2.10799160e-03f, -7.15622231e-02f, -1.71641354e-02f, -3.92045677e-02f, 4.03489321e-02f, -1.03047295e-02f, 9.24494267e-02f, -2.64450479e-02f, 2.98772976e-02f, 2.51366813e-02f,
  5.25882915e-02f, 4.18341830e-02f, -1.91999804e-02f, 7.69019872e-02f, 2.00423151e-02f, -5.77587001e-02f, -1.99144660e-03f, 5.91339208e-02f, -6.97399974e-02f, 4.34072427e-02f,
  5.36025763e-02f, -1.30146099e-02f, 3.07215154e-02f, 1.07181914e-01f, -1.92244630e-02f, 1.41037554e-02f, -1.33141503e-01f, -3.46764512e-02f, 2.07971390e-02f, -1.96800232e-02f,
  1.87403902e-01f, -1.05847359e-01f, 9.05441269e-02f, 5.35809435e-02f, 1.25580616e-02f, 5.64877130e-02f, 4.24507372e-02f, -9.50497389e-02f, -4.58078086e-02f, -1.13182627e-02f,
  6.42008409e-02f, 2.77929637e-03f, 6.94073141e-02f, 1.62745721e-03f, 5.63523844e-02f, -8.03887006e-03f, -5.36583886e-02f, 1.01589538e-01f, -1.99333411e-02f, 6.99868128e-02f,
  2.12796964e-02f, -1.05988540e-01f, -1.32476762e-01f, 4.11073975e-02f, 3.64999138e-02f, -3.12778614e-02f, -2.39160899e-02f, 5.13471328e-02f, -4.94988896e-02f, 2.48114727e-02f,
  -7.66388401e-02f, -1.36892155e-01f, -1.15943097e-01f, 8.96085128e-02f, -1.71444893e-01f, 1.74848903e-02f, 5.75955287e-02f, 6.61462247e-02f, -4.61782888e-03f, 1.66139565e-02f,
  1.48027018e-01f, 1.02901064e-01f, 9.57542360e-02f, 1.69628710e-02f, -5.96623793e-02f, -2.96096168e-02f, -1.57665610e-01f, -2.71858498e-02f, 4.77150716e-02f, 1.31194899e-02f,
  7.26779103e-02f, -3.54772434e-02f, -8.37431625e-02f, -1.89723214e-03f, -4.41979356e-02f, -7.90134743e-02f, -2.13700727e-01f, -2.33161300e-01f, -1.05009608e-01f, -3.56756717e-01f,
  4.40353975e-02f, -2.15886552e-02f, 9.98882204e-02f, -2.30957307e-02f, -2.01426707e-02f, 1.24193951e-01f, 7.77092800e-02f, -6.50192471e-03f, 1.57877252e-01f, 7.78337121e-02f,
  -8.18287302e-03f, -3.22686648e-03f, -6.37057275e-02f, 2.41785757e-02f, 1.94382407e-02f, 1.02742977e-01f, -3.64419483e-02f, -5.21966033e-02f, -2.20872387e-02f, 6.72661662e-02f,
  -1.33017916e-02f, -5.42833768e-02f, -8.40669349e-02f, -1.95273962e-02f, -1.57532454e-01f, -1.66493908e-01f, -7.83625096e-02f, 4.89738444e-03f, -1.06976457e-01f, 3.58608700e-02f,
  -2.72130109e-02f, 2.15650927e-02f, 2.37115771e-02f, 5.41716591e-02f, -3.95630114e-02f, -4.36856272e-03f, 4.40325439e-02f, -1.38075251e-04f, 6.46480173e-03f, -3.07086622e-03f,
  1.01610079e-01f, -8.43258481e-03f, -1.72832713e-03f, -1.22072041e-01f, 6.75408542e-02f, -4.39155251e-02f, -1.68465648e-03f, -5.85343502e-02f, -2.56046858e-02f, -3.05914180e-03f,
  6.81931823e-02f, -5.71347699e-02f, -3.29423845e-02f, 8.55949000e-02f, -4.39525507e-02f, -1.08895794e-01f, -6.65876120e-02f, 1.51678830e-01f, 9.63907316e-02f, -3.91325802e-02f,
  1.71299517e-01f, -2.09996030e-01f, 5.00486698e-03f, -4.56235697e-03f, -2.35429741e-02f, 6.78594690e-03f, 2.23231539e-02f, 4.47956584e-02f, 1.79067906e-02f, -1.63106818e-03f,
  1.36231007e-02f, -3.01332735e-02f, 1.23302743e-01f, -9.25352680e-04f, 7.91066438e-02f, -4.64053676e-02f, -5.09151630e-02f, -3.15064974e-02f, -1.33015901e-01f, -1.05496002e-02f,
  1.38212871e-02f, 6.98788390e-02f, -4.41546775e-02f, 2.47827061e-02f, 3.69074941e-02f, -8.58643651e-02f, 6.93620667e-02f, 2.33383626e-02f, -7.88668096e-02f, 1.81693092e-01f,
  5.75876951e-01f, -4.45805550e-01f, 3.20790559e-01f, 2.48611644e-01f, 3.57812405e-01f, 2.97918260e-01f, 1.02699243e-01f, 5.14277332e-02f, 1.01343617e-01f, 1.14152469e-01f,
  4.19833809e-02f, -7.55507946e-02f, -1.12468831e-01f, -1.13997996e-01f, -1.58584863e-01f, -6.91244677e-02f, 1.29819259e-01f, -4.76223305e-02f, 2.87013769e-01f, 3.03340226e-01f,
  3.74157876e-02f, 2.30121799e-02f, -1.14900083e-03f, -1.22943157e-02f, -1.44404024e-01f, 2.26971984e-01f, -4.38914169e-03f, -8.65873173e-02f, 1.33091528e-02f, -3.97520959e-01f,
  -4.24942449e-02f, -2.07037162e-02f, 1.01312093e-01f, 1.07652053e-01f, -4.27696407e-02f, -1.57399792e-02f, 2.80498271e-03f, -2.49280743e-02f, 2.85274684e-02f, -3.50185223e-02f,
  2.51444150e-02f, -5.60942031e-02f, -4.82350141e-02f, 8.90739262e-03f, 7.52014294e-02f, 6.65175095e-02f, -1.05460018e-01f, -1.22708589e-01f, -3.63107361e-02f, 3.39010544e-02f,
  -1.48439407e-01f, 2.62386445e-02f, -2.74553820e-02f, 5.00535220e-02f, -3.70002240e-02f, 4.61628214e-02f, -1.45253912e-01f, -2.46983003e-02f, 6.12084493e-02f, -1.96628168e-01f,
  -7.02869594e-02f, -2.28943173e-02f, 6.40085787e-02f, -6.25528861e-03f, -2.14600861e-02f, -4.56786677e-02f, -6.52096048e-02f, 4.78193862e-04f, 9.07776952e-02f, -9.48000513e-03f,
  4.88433242e-02f, 4.40540314e-02f, 6.00405131e-03f, 9.59622115e-02f, -4.83246222e-02f, 4.14072797e-02f, -1.85797866e-02f, -7.46374428e-02f, 4.39361529e-03f, 1.22328745e-02f,
  8.86965245e-02f, -3.80767323e-02f, -8.26219935e-03f, -4.35831361e-02f, -3.97809297e-02f, -1.85564980e-02f, -2.58415323e-02f, -1.47589659e-02f, 5.61075211e-02f, 8.87295529e-02f,
  -1.12883300e-01f, 3.76639031e-02f, 3.26963142e-02f, -9.95644256e-02f, -5.82508482e-02f, -2.97787562e-02f, 8.71410519e-02f, -6.29096031e-02f, -8.10751766e-02f, -1.00683682e-01f,
  -2.20267549e-02f, 1.84826367e-02f, -5.85376024e-02f, -3.48810256e-02f, 7.33267963e-02f, -3.39440182e-02f, -2.25280728e-02f, 2.79610902e-02f, -6.24820404e-02f, -2.17171703e-02f,
  -2.68484931e-02f, 7.84763098e-02f, 4.06760089e-02f, 9.81545448e-02f, 4.06281278e-02f, 2.05465734e-01f, 5.17672896e-02f, -4.68364060e-02f, 3.41495387e-02f, 5.29802740e-02f,
  5.14695406e-01f, -6.77301168e-01f, 4.17316221e-02f, 5.07989675e-02f, 9.02766287e-02f, 1.98733553e-01f, -2.37308946e-02f, 1.57519039e-02f, 2.40122490e-02f, -6.81878850e-02f,
  -1.74418986e-01f, 4.12130095e-02f, 2.24196687e-02f, -9.01261419e-02f, -1.04598060e-01f, 1.87554874e-03f, -6.35722503e-02f, 1.44521847e-01f, 2.91993737e-01f, 1.81493059e-01f,
  -7.66779110e-03f, -1.87764107e-03f, 1.06907867e-01f, 1.09339565e-01f, -1.70109779e-01f, 1.02314651e-01f, -1.40271872e-01f, -1.32550627e-01f, -1.31334484e-01f, -2.58202314e-01f,
  1.20205723e-01f, -1.99789345e-01f, 1.21519677e-01f, -5.42116389e-02f, -1.55926824e-01f, 5.37186563e-02f, -4.90066186e-02f, -6.86534867e-02f, -3.82384360e-02f, -1.43818319e-01f,
  8.66532028e-02f, 2.29093023e-02f, 3.82805206e-02f, -4.73303348e-03f, -3.27311493e-02f, 4.54304516e-02f, -6.84093460e-02f, -7.48748332e-02f, -5.85011020e-03f, 4.90695890e-03f,
  -4.77338992e-02f, 6.27429865e-04f, -6.58618435e-02f, -2.85739731e-02f, 1.09676257e-01f, 7.51179829e-02f, -2.17400655e-01f, -6.01176033e-03f, -7.66233578e-02f, -1.82244793e-01f,
  5.30684032e-02f, 7.39245936e-02f, 5.53911831e-03f, -3.89501080e-02f, 1.74023490e-02f, 5.83879687e-02f, -2.64637005e-02f, 1.18085742e-02f, -1.07122818e-02f, -1.09776631e-02f,
  -1.29432725e-02f, -1.50176920e-02f, -9.22177546e-03f, -2.32259333e-02f, 2.78280489e-03f, 3.66010889e-03f, 3.07904631e-02f, -4.19185907e-02f, -1.50628863e-02f, 2.72821821e-03f,
  -5.88451438e-02f, 3.99536788e-02f, -1.34407058e-02f, -2.63986066e-02f, 3.41215879e-02f, -3.82106453e-02f, 5.39749004e-02f, 6.36255443e-02f, -2.77821310e-02f, -6.15565199e-03f,
  -7.81722590e-02f, -4.30890918e-02f, -2.58567203e-02f, 9.62439831e-03f, 6.81325123e-02f, -4.87079769e-02f, -1.48869157e-02f, -9.31591727e-03f, 3.02111600e-02f, 3.48666348e-02f,
  7.37988064e-03f, -8.28527752e-03f, -6.53718561e-02f, -2.16415953e-02f, 5.55547625e-02f, 1.37503549e-01f, -9.52454954e-02f, 7.04177991e-02f, -1.95809826e-02f, 1.71722646e-03f,
  -1.42999692e-02f, 8.44829157e-02f, 1.18989021e-01f, 8.65081251e-02f, 7.38928653e-03f, 1.10548586e-01f, -5.50678410e-02f, -2.86428519e-02f, 1.67327449e-01f, 1.61250100e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 8)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 8;
const float L0_fan_Bp_bar_data[] = {
  -2.53839269e-02f, 3.49462599e-01f, 2.96031713e-01f, 2.02479139e-01f, -1.27870515e-01f, 2.70493567e-01f, -6.49897456e-02f, -1.01830862e-01f
};

// L1_fan_Wp (Shape: 4 x 16)
const int L1_fan_Wp_rows = 4;
const int L1_fan_Wp_cols = 16;
const float L1_fan_Wp_data[] = {
  -1.28443241e-01f, -5.86239025e-02f, -9.89766940e-02f, -3.38367283e-01f, 4.37606126e-02f, 1.30898029e-01f, 4.38596725e-01f, 1.25499308e-01f, 2.11890087e-01f, 1.15785338e-01f,
  5.04650950e-01f, -2.14655146e-01f, 2.29753852e-01f, -5.31630553e-02f, -1.26611203e-01f, -1.56333044e-01f, -1.91991195e-01f, -1.07137496e-02f, -2.35582039e-01f, -3.11447769e-01f,
  -4.85725790e-01f, -5.83550215e-01f, -3.42845857e-01f, 3.74386191e-01f, 2.52985388e-01f, -2.96188861e-01f, -3.29268336e-01f, -4.89704944e-02f, 1.68119758e-01f, -3.89301896e-01f,
  -5.45098484e-01f, -5.61293960e-01f, 1.54036969e-01f, -2.32802540e-01f, -1.01429865e-01f, 5.02233803e-01f, 1.66818112e-01f, 5.86506486e-01f, -3.20459813e-01f, -1.90832555e-01f,
  -3.02871376e-01f, -1.46206453e-01f, 5.39308548e-01f, 7.70873111e-03f, 4.58105654e-01f, 1.11329593e-01f, 1.31831780e-01f, 1.87309459e-01f, -2.41806418e-01f, -7.58739561e-02f,
  -1.40433520e-01f, 9.40259844e-02f, 3.20027292e-01f, -1.31631956e-01f, -1.57089740e-01f, -2.30441153e-01f, 8.46527219e-02f, -6.15746826e-02f, -1.15232892e-01f, 3.48790288e-01f,
  -3.14742774e-01f, 2.04082970e-02f, 3.50767940e-01f, 2.79036701e-01f
};

// L1_fan_Wp_bar (Shape: 8 x 16)
const int L1_fan_Wp_bar_rows = 8;
const int L1_fan_Wp_bar_cols = 16;
const float L1_fan_Wp_bar_data[] = {
  4.50833470e-01f, 1.15005657e-01f, 1.06504798e-01f, 6.93274975e-01f, -2.36467868e-01f, 5.62871248e-02f, -1.99787006e-01f, 1.78672239e-01f, 3.60534154e-03f, 5.79210557e-02f,
  2.90438384e-01f, 2.36155018e-01f, 3.94956708e-01f, -3.87116611e-01f, 3.38063061e-01f, 5.14797151e-01f, 1.89055055e-01f, 3.30310285e-01f, 4.91826832e-01f, 4.26545739e-01f,
  -5.77475011e-01f, -5.29642999e-01f, -4.90503013e-01f, 4.92535591e-01f, 4.52649221e-02f, -5.43482542e-01f, -6.72995374e-02f, 1.47999585e-01f, 2.96896696e-01f, -5.15881300e-01f,
  -2.70814866e-01f, -4.98641133e-02f, 2.96647012e-01f, -1.30795494e-01f, 1.11658171e-01f, 7.88154721e-01f, -5.19277677e-02f, 2.54713684e-01f, -3.27029765e-01f, -2.02341363e-01f,
  -2.16142476e-01f, 8.03906322e-01f, -5.04124403e-01f, 1.22955590e-01f, -2.70945728e-01f, 2.49408811e-01f, 5.39277554e-01f, 3.32725883e-01f, -6.60200417e-02f, 4.40870114e-02f,
  3.90043288e-01f, 1.60018280e-01f, 1.53983623e-01f, -1.71439737e-01f, 3.95888612e-02f, 3.44465643e-01f, -6.36432543e-02f, -1.06131576e-01f, 3.80118161e-01f, 2.41270840e-01f,
  -9.99559909e-02f, -2.52521664e-01f, -2.38432921e-02f, -8.26971903e-02f, -7.20369890e-02f, -1.79721892e-01f, 1.22619614e-01f, -6.81221187e-02f, 2.22446546e-01f, 8.78987759e-02f,
  8.85108933e-02f, -8.05480480e-02f, 2.50155866e-01f, -1.65698215e-01f, 1.24985404e-01f, -2.11951703e-01f, 8.61210972e-02f, 7.85687938e-02f, -5.38738742e-02f, -2.26988047e-01f,
  -1.98700070e-01f, -3.45265889e-03f, 2.80474544e-01f, 1.77265406e-01f, -3.00742716e-01f, -1.62251219e-01f, 8.91910270e-02f, 1.62207156e-01f, -2.47055843e-01f, -7.22444728e-02f,
  -1.06319161e-02f, -4.11384962e-02f, 3.81709039e-01f, -9.54371393e-02f, 8.79186541e-02f, 3.10486943e-01f, -2.69973308e-01f, -1.03734285e-01f, -1.26470938e-01f, 1.80341005e-01f,
  -1.88713409e-02f, -1.45358652e-01f, -9.34685841e-02f, 1.10026762e-01f, 1.42728046e-01f, -1.71187133e-01f, -1.57465450e-02f, 4.88409877e-01f, 3.34857643e-01f, -1.39017448e-01f,
  4.21070494e-02f, -5.94538637e-02f, -2.31109764e-02f, 9.06478427e-03f, 1.16515070e-01f, -3.04807853e-02f, -2.19874531e-01f, -1.18358500e-01f, 1.88953523e-02f, -1.15928836e-01f,
  1.16005160e-01f, 8.74279216e-02f, 4.12987798e-01f, -2.10919023e-01f, 8.65375102e-02f, 1.24533489e-01f, 2.61939820e-02f, -1.96371093e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 8)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 8;
const float L1_fan_Bp_bar_data[] = {
  1.10029794e-01f, 3.13343197e-01f, 4.29009646e-01f, 1.70715638e-02f, 8.81435908e-03f, -1.05323792e-01f, 2.09804755e-02f, 1.57625183e-01f
};

// L2_fan_Wp (Shape: 4 x 16)
const int L2_fan_Wp_rows = 4;
const int L2_fan_Wp_cols = 16;
const float L2_fan_Wp_data[] = {
  5.45513965e-02f, 3.65981191e-01f, 4.86222863e-01f, 2.34596595e-01f, -1.64784938e-01f, 8.50952327e-01f, -5.92784226e-01f, -2.15423003e-01f, -3.64646435e-01f, 7.68713415e-01f,
  -2.19331309e-02f, -2.07591385e-01f, -1.54834345e-01f, 6.05967492e-02f, 1.12512140e-02f, -2.20953509e-01f, 4.58859563e-01f, 4.16814595e-01f, 1.30302772e-01f, 4.75313544e-01f,
  1.09324776e-01f, -4.50355522e-02f, -8.60804439e-01f, 2.33276829e-01f, -3.68798018e-01f, -2.84778744e-01f, -2.21656233e-01f, -2.08221540e-01f, 2.68044043e-02f, -5.54067157e-02f,
  -3.24404448e-01f, -1.05880804e-01f, 2.11144432e-01f, 4.25808132e-01f, -5.71791679e-02f, -9.09902379e-02f, 1.07491881e-01f, -2.91166961e-01f, -5.50906658e-01f, 8.71612728e-02f,
  -2.60359831e-02f, -1.63452029e-01f, -3.13924015e-01f, 1.42111495e-01f, 7.94303492e-02f, -2.20998943e-01f, 2.14824528e-01f, 1.56739980e-01f, -3.55355024e-01f, -4.56066519e-01f,
  -3.17259818e-01f, -4.60066766e-01f, -1.23457154e-02f, -2.29142100e-01f, 5.36614001e-01f, 3.39455724e-01f, 3.24362397e-01f, 1.58613831e-01f, -6.83375821e-02f, -4.41739447e-02f,
  2.43522123e-01f, 2.66674370e-01f, -2.44306430e-01f, -7.87506998e-02f
};

// L2_fan_Wp_bar (Shape: 8 x 16)
const int L2_fan_Wp_bar_rows = 8;
const int L2_fan_Wp_bar_cols = 16;
const float L2_fan_Wp_bar_data[] = {
  -2.95486689e-01f, -2.51737922e-01f, 1.42283827e-01f, 3.01412307e-02f, -3.84856343e-01f, 1.59446761e-01f, 4.16260839e-01f, 2.86218911e-01f, 7.89860368e-01f, 3.27223212e-01f,
  8.59856188e-01f, 8.23902562e-02f, -2.92451936e-03f, 2.53899038e-01f, 8.29283595e-02f, -1.81650415e-01f, -1.28876552e-01f, -5.52461818e-02f, -2.33200356e-01f, -1.38376758e-01f,
  -1.50302529e-01f, -1.45969853e-01f, 5.14175817e-02f, 1.49743855e-01f, -8.27261899e-03f, 1.76538467e-01f, -1.37136653e-01f, 6.13055844e-03f, -1.59481671e-02f, -1.98691085e-01f,
  -2.38524646e-01f, 1.62650988e-01f, 1.84025437e-01f, 2.22743019e-01f, 7.43277848e-01f, 4.34223890e-01f, -5.64244211e-01f, -6.90430224e-01f, 6.76232725e-02f, 5.87864876e-01f,
  -1.34351820e-01f, -2.76229382e-01f, 9.05189753e-01f, -2.66690515e-02f, -2.54246267e-03f, 1.03381574e-01f, -1.80787787e-01f, -9.55061913e-02f, -9.12424773e-02f, -7.00127333e-02f,
  2.48153836e-01f, -1.77912131e-01f, -2.63790905e-01f, 5.41747212e-01f, 3.87208730e-01f, 5.74647710e-02f, 2.13090941e-01f, 7.61136949e-01f, 3.56309116e-01f, -7.53909498e-02f,
  -1.57501206e-01f, 2.12705299e-01f, 3.75085734e-02f, 1.20057873e-01f, -1.89700127e-01f, 6.17380291e-02f, -8.50269049e-02f, -1.01652332e-01f, 1.75625935e-01f, 1.83680877e-01f,
  1.87222734e-01f, 1.39638856e-01f, 5.01619056e-02f, -2.06297785e-02f, -2.59571522e-01f, 2.11106002e-01f, 1.28823966e-01f, 8.69436283e-03f, 2.65239477e-01f, 1.33253098e-01f,
  6.65528715e-01f, 6.71742558e-01f, 1.96792305e-01f, 5.50129294e-01f, -4.25115749e-02f, 5.73018074e-01f, -4.17553157e-01f, -4.24656868e-01f, 3.47879946e-01f, 8.71944368e-01f,
  -1.98733315e-01f, 3.99775565e-01f, -2.81604426e-03f, 7.99499750e-02f, -7.75002912e-02f, 1.74524337e-02f, 5.52697659e-01f, 1.23679265e-01f, 4.13417608e-01f, 5.37310302e-01f,
  2.81743586e-01f, -2.31846929e-01f, -5.56827009e-01f, -3.48679692e-01f, -4.36931193e-01f, -3.95472236e-02f, 2.77430475e-01f, 7.97986388e-02f, -1.56922229e-02f, -2.15845540e-01f,
  -3.23887616e-01f, 3.50137174e-01f, 2.18599513e-01f, 3.43797654e-01f, 7.83087611e-01f, 1.85367137e-01f, -6.47997558e-01f, -5.21126747e-01f, 1.76514655e-01f, 3.59666467e-01f,
  -7.16451481e-02f, -2.17133760e-01f, 7.61251390e-01f, 1.77264765e-01f, -2.81245947e-01f, -3.17183584e-01f, -3.45551997e-01f, -6.05931971e-03f
};

// L2_fan_Bp_bar (Shape: 1 x 8)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 8;
const float L2_fan_Bp_bar_data[] = {
  -1.77652370e-02f, 1.35177419e-01f, 4.83311325e-01f, 2.51768649e-01f, 3.12785106e-03f, 4.78525639e-01f, 5.65647244e-01f, 3.21353972e-01f
};

// L3_fan_Wp (Shape: 4 x 16)
const int L3_fan_Wp_rows = 4;
const int L3_fan_Wp_cols = 16;
const float L3_fan_Wp_data[] = {
  2.69595116e-01f, 2.17507035e-01f, -4.39996749e-01f, -4.99416888e-02f, 1.83662787e-01f, -8.40271115e-01f, -6.02380820e-02f, 1.90177560e-02f, 6.67189807e-02f, 4.64968123e-02f,
  8.41662213e-02f, 3.02263260e-01f, 1.52047992e-01f, -2.47493878e-01f, -3.90149742e-01f, 4.12283242e-01f, -2.94106096e-01f, 4.43211459e-02f, -3.89948785e-01f, -1.04667716e-01f,
  -8.06741059e-01f, -7.26089895e-01f, -3.57203424e-01f, 5.17879069e-01f, 4.34839934e-01f, -7.96243846e-02f, 1.99829131e-01f, -2.31719360e-01f, 7.41713867e-02f, -6.01451874e-01f,
  -4.59227979e-01f, -2.73096591e-01f, -1.23328649e-01f, -2.97506273e-01f, 4.48330849e-01f, 2.53476858e-01f, 5.70554852e-01f, 5.58891118e-01f, 2.30619803e-01f, -4.03385937e-01f,
  -2.39173651e-01f, -2.99876153e-01f, 9.47612058e-03f, -2.09784254e-01f, -1.19750880e-01f, 1.47342935e-01f, 3.59038711e-01f, -2.67786860e-01f, -2.49210879e-01f, 2.37901181e-01f,
  -1.08946420e-01f, 5.00232399e-01f, -2.95848608e-01f, -3.10426444e-01f, -3.15344900e-01f, 5.45883179e-02f, -6.23229444e-02f, -2.54533768e-01f, -2.13700727e-01f, 3.22250426e-01f,
  5.55782281e-02f, 1.30594522e-01f, -2.09771469e-01f, -6.43982470e-01f
};

// L3_fan_Wp_bar (Shape: 8 x 16)
const int L3_fan_Wp_bar_rows = 8;
const int L3_fan_Wp_bar_cols = 16;
const float L3_fan_Wp_bar_data[] = {
  -2.54017323e-01f, 1.76532175e-02f, 7.61968940e-02f, -1.62085533e-01f, -2.97280662e-02f, 1.69137985e-01f, 1.37955055e-01f, -2.44765967e-01f, -1.77239969e-01f, -2.40458429e-01f,
  -4.92834061e-01f, 3.06782782e-01f, -1.05762780e-01f, 4.42966372e-01f, 1.00607283e-01f, -5.29137671e-01f, 3.58841777e-01f, -3.99728417e-02f, 3.20229828e-01f, -2.58325487e-01f,
  1.38235688e-01f, 6.19465828e-01f, 5.08901238e-01f, -3.81680191e-01f, -4.98197407e-01f, -3.81071717e-02f, 4.91039813e-01f, -3.57900798e-01f, 7.93410689e-02f, 3.04026365e-01f,
  2.70859927e-01f, 3.99725199e-01f, 6.30178690e-01f, 8.19183648e-01f, 2.64184713e-01f, 5.06713986e-01f, -6.08173549e-01f, 1.68572262e-01f, -1.97901353e-01f, -1.04224898e-01f,
  -3.69490176e-01f, 2.24200394e-02f, 1.16426027e+00f, -3.71331751e-01f, -2.41360262e-01f, -6.87884927e-01f, 5.89589238e-01f, 9.17010128e-01f, -2.11301550e-01f, 1.79017827e-01f,
  3.92442256e-01f, 3.54778111e-01f, -5.30772090e-01f, 2.14154333e-01f, 1.38738966e-02f, 5.46702296e-02f, 1.73984647e-01f, -2.85538053e-03f, -1.26515049e-02f, -3.23643088e-01f,
  1.35266399e-02f, 3.52278501e-01f, -6.43391861e-03f, 2.76552469e-01f, 3.22783083e-01f, -3.83176953e-01f, 2.93076515e-01f, -4.68868688e-02f, 2.65410393e-01f, 5.66231072e-01f,
  3.89529884e-01f, -3.66827697e-02f, -4.53768820e-01f, 6.76494613e-02f, 1.64811447e-01f, -3.88994485e-01f, 1.24858260e-01f, 1.40333712e-01f, 5.79486132e-01f, 3.62723991e-02f,
  6.95616663e-01f, 4.69085515e-01f, 3.40325892e-01f, -4.10402380e-02f, 1.20146859e+00f, 7.66612649e-01f, 4.57669467e-01f, -6.22417212e-01f, -1.40513659e-01f, -2.83403993e-01f,
  5.77238619e-01f, -3.59037071e-02f, -3.23980391e-01f, 5.40308058e-01f, 3.32917064e-01f, 3.27924639e-01f, -3.60406995e-01f, -2.50632614e-01f, -3.07479292e-01f, 2.28431433e-01f,
  3.23081881e-01f, -4.12048936e-01f, -5.87628126e-01f, 4.79101032e-01f, 1.16528523e+00f, -1.43482849e-01f, 6.47750199e-01f, 7.34211326e-01f, -2.20474154e-01f, -4.36818339e-02f,
  -5.61010182e-01f, 4.38659728e-01f, -5.33083081e-01f, 1.67030245e-01f, 5.14523052e-02f, -3.62039767e-02f, 4.83703405e-01f, 3.58676910e-01f, 6.02655187e-02f, -2.55192637e-01f,
  -2.69926757e-01f, -1.36866808e-01f, -6.12933278e-01f, 3.61057729e-01f, 9.86363441e-02f, 1.16946459e+00f, 3.94002736e-01f, -4.96372700e-01f
};

// L3_fan_Bp_bar (Shape: 1 x 8)
const int L3_fan_Bp_bar_rows = 1;
const int L3_fan_Bp_bar_cols = 8;
const float L3_fan_Bp_bar_data[] = {
  2.58961827e-01f, -2.85220984e-02f, 2.88882136e-01f, -4.07782905e-02f, -4.20863032e-02f, 3.93552244e-01f, 1.44176796e-01f, 3.57021660e-01f
};

// L4_linear_W (Shape: 12 x 16)
const int L4_linear_W_rows = 12;
const int L4_linear_W_cols = 16;
const float L4_linear_W_data[] = {
  -1.54891029e-01f, 1.13909757e+00f, 4.96500917e-02f, -3.33532453e-01f, 2.00608168e-02f, -5.05662560e-01f, -8.63391519e-01f, -3.88968643e-03f, -3.01762391e-02f, -1.13608450e-01f,
  7.82095492e-01f, -4.64621663e-01f, -4.22157764e-01f, 5.81747741e-02f, 1.73215315e-01f, -5.71563188e-03f, 2.48385385e-01f, -1.01780784e+00f, -9.37649965e-01f, 6.01752102e-01f,
  4.19047892e-01f, 1.36642075e+00f, -9.14062023e-01f, 1.36581033e-01f, -2.04940826e-01f, -3.22882235e-01f, -1.40286326e-01f, 2.56720066e-01f, -3.71555179e-01f, -9.38403368e-01f,
  6.99932516e-01f, -1.12680510e-01f, 3.67980510e-01f, -2.20459566e-01f, 6.40464187e-01f, 3.15199316e-01f, 3.58136714e-01f, -5.28663993e-02f, 1.06943972e-01f, -5.03093243e-01f,
  -3.66617143e-01f, 1.36491284e-01f, -1.17062330e-01f, 2.51255453e-01f, -1.67565063e-01f, 9.56691086e-01f, -4.77152690e-02f, 1.65750653e-01f, 1.58094615e-01f, 1.14247814e-01f,
  2.68058449e-01f, -1.98869005e-01f, -3.28408629e-01f, -2.65050799e-01f, 5.88222921e-01f, -4.48087044e-02f, -3.82538021e-01f, 7.95358539e-01f, 1.07513286e-01f, -3.07130724e-01f,
  5.38135767e-01f, 8.80770326e-01f, -1.03895962e+00f, -6.85386837e-01f, 5.06832540e-01f, 2.74190366e-01f, 5.76021075e-01f, -2.10256770e-01f, 5.22503480e-02f, -1.11508667e+00f,
  1.22065889e-02f, 2.17659771e-02f, -4.78636026e-02f, 5.14493883e-01f, 6.79136157e-01f, 3.25407028e-01f, 5.44419885e-02f, 1.41510844e-01f, -2.84442455e-01f, -4.63177621e-01f,
  -4.77217436e-01f, 2.91343868e-01f, -5.25554121e-01f, -1.96085885e-01f, 5.26291788e-01f, 1.29106152e+00f, -4.74241316e-01f, -7.27951303e-02f, 1.73822790e-01f, -2.50065804e-01f,
  1.04318321e+00f, -1.56594571e-02f, 8.20033811e-03f, -8.83355439e-01f, 2.14902043e-01f, 7.93797616e-03f, -3.33373487e-01f, -3.33645463e-01f, 9.33426060e-03f, 1.38398468e-01f,
  -4.69176918e-01f, 4.69607441e-03f, 9.42385495e-01f, 4.95766491e-01f, 5.07363141e-01f, -1.91288069e-01f, -6.34619951e-01f, 1.63267523e-01f, -2.71930963e-01f, -6.09821454e-02f,
  -7.06225753e-01f, 1.09705436e+00f, 1.72373712e-01f, -7.37866998e-01f, -1.62785605e-01f, -4.10056412e-01f, 1.09638728e-01f, -5.16090751e-01f, 5.43093443e-01f, 2.16913268e-01f,
  4.56117302e-01f, -3.98312628e-01f, -7.01204062e-01f, -4.45933163e-01f, 2.39575058e-02f, -1.85652658e-01f, 3.17755163e-01f, 7.50365973e-01f, -2.55167961e-01f, -7.32859254e-01f,
  -5.69391251e-01f, -4.27959889e-01f, 2.59468585e-01f, -1.85408797e-02f, 5.24763405e-01f, -3.25410247e-01f, -3.29249837e-02f, -4.05385286e-01f, -1.52881578e-01f, -3.28463227e-01f,
  -8.67080409e-03f, -5.47454417e-01f, 8.46959770e-01f, -1.98083535e-01f, -4.67625946e-01f, -2.70586699e-01f, -8.17810178e-01f, 1.57419264e-01f, -4.03005421e-01f, -6.52422160e-02f,
  3.87797147e-01f, -4.17329013e-01f, 2.45057479e-01f, 3.95072341e-01f, -5.95816970e-01f, -5.95583543e-02f, 8.38506162e-01f, 4.30444479e-01f, -5.39960980e-01f, 5.26304245e-01f,
  4.50810015e-01f, 1.18465269e+00f, 6.60743713e-01f, 5.29110968e-01f, -3.28171551e-02f, 1.07235932e+00f, -8.52988422e-01f, 5.74894130e-01f, -1.91150963e-01f, -3.85652363e-01f,
  1.12831390e+00f, 1.82263926e-01f, -6.51414692e-02f, -4.97781217e-01f, -6.60183370e-01f, -3.53412271e-01f, -8.55400786e-02f, -3.89403015e-01f, 5.76001525e-01f, 2.00152785e-01f,
  4.09083933e-01f, -9.58845377e-01f, -2.76716024e-01f, -5.10487817e-02f, -2.90943414e-01f, -3.49663436e-01f, -7.22803235e-01f, -1.98358625e-01f, -1.60210148e-01f, 6.80016279e-01f,
  6.44477069e-01f, -2.93195873e-01f
};

// L4_linear_B (Shape: 1 x 12)
const int L4_linear_B_rows = 1;
const int L4_linear_B_cols = 12;
const float L4_linear_B_data[] = {
  -2.83750921e-01f, 2.20514104e-01f, 6.80484623e-02f, 2.47273698e-01f, 1.06573194e-01f, 1.36833817e-01f, -2.60675587e-02f, -2.62738019e-01f, -2.25539640e-01f, 7.95070305e-02f,
  6.29276514e-01f, 1.09088555e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 4, 8
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        16, 4, 8
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        16, 4, 8
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L3_fan_Wp_data, L3_fan_Wp_bar_data, L3_fan_Bp_bar_data,
        16, 4, 8
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 4: L4_linear
    linear_forward_pgm(
        buffer1, x_out,
        L4_linear_W_data, L4_linear_B_data,
        16, 12
    );
    }
    