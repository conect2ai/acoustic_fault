/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 64 (x4)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 64;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    return (x > 0.0f) ? x : 0.0f;
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 25 x 120)
const int L0_fan_Wp_rows = 25;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  2.41721377e-01f, -2.38262519e-01f, 1.29569992e-02f, -1.12567708e-01f, 2.07858562e-01f, 3.14679183e-02f, 2.54568662e-02f, 2.18867767e-03f, -9.44217518e-02f, -1.12958521e-01f,
  1.62116840e-01f, -3.66600193e-02f, -2.35071816e-02f, -3.71687748e-02f, -1.37422875e-01f, -2.57513195e-01f, -7.35550821e-02f, -1.71398465e-02f, -1.23079047e-02f, 2.36458369e-02f,
  -2.24791691e-02f, -1.20997131e-02f, -1.59235485e-02f, -1.50990663e-02f, 1.02705196e-01f, 7.99828619e-02f, 2.82118749e-02f, -4.50577736e-02f, 8.17696303e-02f, 1.21127600e-02f,
  1.72086917e-02f, 6.84747025e-02f, 1.16838813e-01f, 5.91495819e-02f, 6.26591370e-02f, 8.51892158e-02f, -2.66155265e-02f, -2.82164067e-02f, 8.64720121e-02f, 5.99125810e-02f,
  -6.52904809e-03f, 1.02609582e-02f, -1.55016538e-02f, 2.76713353e-02f, 4.57741022e-02f, -2.70592961e-02f, 5.50604872e-02f, 6.59293979e-02f, 6.07088208e-02f, 2.98633520e-03f,
  2.77914256e-02f, 2.89900601e-02f, 2.91161761e-02f, -1.01958558e-01f, -9.13615059e-03f, 4.45990153e-02f, 2.09621824e-02f, 6.26139250e-03f, 7.16948463e-03f, 3.35021652e-02f,
  5.71087115e-02f, -2.80266069e-02f, -4.38466296e-02f, 1.20300725e-01f, -5.09988293e-02f, 8.66841078e-02f, 1.79057810e-02f, 6.77838363e-03f, 5.43399006e-02f, 3.61660076e-03f,
  4.45905961e-02f, 7.34642819e-02f, 4.26094905e-02f, 8.96201562e-03f, 3.91391367e-02f, 2.75876597e-02f, 6.78626355e-03f, 2.63312086e-02f, -6.85717026e-03f, 2.92007923e-02f,
  -1.01826787e-01f, 1.89164951e-02f, 6.93753287e-02f, -1.94085436e-03f, -5.92273809e-02f, 4.40869816e-02f, -6.23453446e-02f, 4.60550822e-02f, 6.43501207e-02f, 5.81498891e-02f,
  -2.28878902e-03f, -1.91767395e-01f, -6.82907477e-02f, 3.51045057e-02f, -8.26583803e-03f, 2.28458289e-02f, 1.36720156e-03f, 5.71312085e-02f, -8.75578299e-02f, -5.49634285e-02f,
  1.54743227e-03f, -1.80516019e-02f, -6.17620349e-03f, -5.13569154e-02f, 1.31577887e-02f, -4.91647571e-02f, -1.39926579e-02f, -1.03816152e-01f, -2.97149252e-02f, 1.60578836e-03f,
  -3.31575870e-06f, -4.53789011e-02f, -1.28379008e-02f, -1.64121971e-03f, -6.50897026e-02f, -8.61431286e-03f, -8.65340326e-03f, -7.92749878e-03f, -4.71672267e-02f, -4.10699807e-02f,
  1.24754407e-01f, 1.37557641e-01f, 3.97345036e-01f, 1.48888573e-01f, -9.44797229e-03f, -1.63732886e-01f, 2.03826323e-01f, 1.32691577e-01f, 2.12193862e-01f, -1.34446084e-01f,
  -1.30314067e-01f, 2.14730695e-01f, 1.30644694e-01f, -1.48832753e-01f, -2.81401332e-02f, 1.75578706e-02f, -1.28978446e-01f, -6.72215223e-02f, 1.96389139e-01f, 1.40596703e-01f,
  9.66349095e-02f, -1.99543789e-01f, 4.47497256e-02f, -1.46024480e-01f, -1.16692901e-01f, 4.00550328e-02f, -1.81103930e-01f, 1.81301653e-01f, -2.66832471e-01f, 1.41138146e-02f,
  -7.70068020e-02f, 1.04470320e-01f, -1.02951579e-01f, 2.86251190e-03f, -1.10076025e-01f, -7.93267637e-02f, 4.30056918e-03f, 8.47507119e-02f, -2.72348765e-02f, 7.57601857e-02f,
  1.60175096e-02f, 2.71114730e-03f, 2.37030257e-02f, 3.11510153e-02f, -1.43861352e-02f, -1.35096153e-02f, -8.02571177e-02f, -9.36523303e-02f, 3.16132382e-02f, 2.65260991e-02f,
  7.63079897e-03f, -1.67061463e-02f, 1.83305908e-02f, 4.13717926e-02f, 6.50214702e-02f, -1.06119169e-02f, -5.34683876e-02f, 9.76373162e-03f, 1.16609223e-02f, 6.36068638e-03f,
  -1.98881812e-02f, -1.84110757e-02f, 3.90770659e-02f, 1.46784158e-02f, -5.50302006e-02f, -6.80764439e-03f, -9.88593977e-03f, -6.05792329e-02f, 7.89504498e-02f, -2.12827474e-02f,
  -4.20036241e-02f, -1.17793540e-02f, 1.26632899e-02f, -1.01615954e-02f, 2.02857871e-02f, -3.68551612e-02f, 4.09802645e-02f, -2.24984959e-02f, -5.09117544e-02f, -9.78398174e-02f,
  5.45802824e-02f, -3.25778499e-02f, -2.14875434e-02f, 6.29633712e-03f, 1.30777890e-02f, 5.34673594e-02f, 3.04620131e-03f, 6.71595857e-02f, -3.21728876e-03f, -3.45205851e-02f,
  -9.38994065e-02f, 8.06372836e-02f, -8.96871649e-03f, -5.95227964e-02f, -5.60171604e-02f, -1.30422994e-01f, 5.65530546e-02f, -4.61721234e-02f, 1.15160914e-02f, 2.56257840e-02f,
  -1.01941703e-02f, -8.31118301e-02f, -8.89429264e-03f, -1.83125418e-02f, 2.96817068e-02f, -1.00177014e-02f, -6.88282307e-03f, 3.81594931e-04f, -5.82133187e-03f, -7.65613765e-02f,
  -1.39187768e-01f, -2.65287552e-02f, 1.69010777e-02f, 1.21711493e-02f, -2.74825376e-02f, -5.77035770e-02f, 2.00656578e-02f, 7.81677067e-02f, -1.03043891e-01f, 6.11751340e-03f,
  6.81189522e-02f, 2.34983832e-01f, -1.25414342e-01f, -1.06123641e-01f, 2.07241997e-01f, 5.76634407e-02f, -8.20645913e-02f, 3.67684253e-02f, -1.88655034e-02f, 1.30151793e-01f,
  -5.05145267e-03f, -2.29719561e-02f, -1.86727136e-01f, 3.99211422e-02f, -2.25866199e-01f, -1.78213090e-01f, -3.80593203e-02f, -6.89217374e-02f, -6.85659572e-02f, 1.69521391e-01f,
  -1.48002626e-02f, 2.01835170e-01f, -9.23369080e-02f, 2.12334171e-01f, 1.52834103e-01f, 3.20570059e-02f, 1.07773937e-01f, -3.37743908e-02f, 1.25605360e-01f, -9.14079174e-02f,
  3.44658755e-02f, 1.16270676e-03f, 3.62739787e-02f, 9.21739787e-02f, 9.35152620e-02f, 1.16494998e-01f, 2.08484679e-02f, -3.05097811e-02f, -1.13670323e-02f, 4.99970606e-03f,
  -1.21262176e-02f, 2.18275804e-02f, -4.12945189e-02f, -5.78188598e-02f, 6.77931160e-02f, 2.97598541e-02f, -9.71954763e-02f, 3.78812850e-02f, 7.61084408e-02f, -6.93328753e-02f,
  -9.21331812e-04f, 2.36682463e-02f, 7.66912028e-02f, 3.89301195e-03f, -1.03556670e-01f, -1.22632325e-01f, -4.01527174e-02f, -7.87749067e-02f, -6.00003004e-02f, 1.69811025e-02f,
  -2.91264709e-03f, 8.06771442e-02f, 1.24114109e-02f, 1.26601122e-02f, -2.68916562e-02f, -1.58627573e-02f, 4.51860130e-02f, 5.68983406e-02f, -3.72380950e-02f, 6.56791478e-02f,
  -1.70199629e-02f, 9.77525674e-03f, -2.52830721e-02f, 3.60923894e-02f, 5.20581342e-02f, 3.00068893e-02f, 4.78252582e-02f, -4.07877825e-02f, 2.85655241e-02f, 2.03403248e-03f,
  -4.85911639e-03f, -7.08518773e-02f, -1.31913752e-03f, -1.51785007e-02f, -1.01546859e-02f, -3.27236913e-02f, -6.19429816e-03f, -3.20657380e-02f, 9.71261319e-03f, 1.41398441e-02f,
  1.95039794e-01f, 1.64355218e-01f, 1.31286934e-01f, 8.04043859e-02f, 4.28997912e-03f, -6.63906895e-03f, -2.22104881e-02f, -2.13123225e-02f, -4.86262888e-03f, 5.94289042e-03f,
  2.25771591e-02f, -3.58933099e-02f, -1.36444904e-02f, 7.65353302e-03f, -3.65421735e-03f, 3.72740477e-02f, -6.20524958e-02f, 5.04349135e-02f, 9.35387388e-02f, 8.03922266e-02f,
  5.44014275e-02f, 2.86350935e-03f, 4.05160477e-03f, 5.79744168e-02f, 3.83035839e-02f, -3.00559625e-02f, 3.48698050e-02f, -2.73058824e-02f, 4.20959434e-04f, 2.17372645e-02f,
  -2.28517443e-01f, -1.06489949e-01f, -5.64988367e-02f, -1.78715214e-01f, -1.31786108e-01f, -1.18508473e-01f, -1.26770183e-01f, -6.47940561e-02f, -1.39271751e-01f, 4.53608781e-02f,
  -7.19660223e-02f, 8.00081268e-02f, 2.37326659e-02f, -2.15820074e-01f, -1.89094543e-02f, 8.06669816e-02f, -2.48490572e-01f, -7.05671459e-02f, -3.71501185e-02f, -1.84095025e-01f,
  -7.10128471e-02f, -1.49695516e-01f, 4.14957628e-02f, -1.36001453e-01f, -5.87684475e-02f, -7.81878382e-02f, -3.55858132e-02f, 2.42296942e-02f, -3.51581909e-02f, 2.18078494e-02f,
  -1.09224178e-01f, -1.40383303e-01f, 1.55426133e-02f, 1.18704094e-02f, -6.06868006e-02f, 1.24662025e-02f, 3.20493206e-02f, 3.95593904e-02f, -1.84648745e-02f, -7.35645816e-02f,
  3.15061398e-02f, 2.98294630e-02f, -3.94396484e-02f, 2.14192495e-02f, -6.66098529e-03f, -4.01140749e-02f, -2.23499513e-03f, -4.30502146e-02f, -9.82858166e-02f, 3.38432193e-02f,
  2.26097535e-02f, -7.57800788e-02f, -4.37415577e-02f, -5.87642044e-02f, 2.55300421e-02f, -7.60045722e-02f, -4.45397533e-02f, 7.37867504e-02f, -7.89291039e-02f, -9.16335359e-02f,
  -1.02757171e-01f, 3.04268375e-02f, -1.26543595e-02f, 1.70199536e-02f, 2.26665605e-02f, 9.07373652e-02f, -2.86340620e-02f, 6.17192648e-02f, 4.08896953e-02f, -2.91906577e-02f,
  -3.29198502e-02f, 3.62606384e-02f, -3.34539600e-02f, 7.18276948e-02f, -3.29579227e-03f, 2.26081926e-02f, 3.63650010e-03f, -2.40125544e-02f, 5.00778370e-02f, 3.03685572e-02f,
  2.10203994e-02f, -4.32068743e-02f, 8.68634954e-02f, 5.79965189e-02f, 2.90865656e-02f, -2.84659285e-02f, 1.26488116e-02f, -8.36685672e-03f, -4.50313762e-02f, 7.05376826e-03f,
  -1.62939698e-01f, -1.24962658e-01f, -9.50910673e-02f, -3.27756293e-02f, 4.53574903e-04f, -4.25400212e-02f, 3.03324708e-03f, -5.16108237e-02f, -8.80634636e-02f, -7.80769251e-03f,
  3.92282382e-03f, 2.41771601e-02f, -5.37076406e-02f, 5.24611585e-02f, 1.22045837e-01f, -7.95075390e-03f, -6.92175701e-02f, -1.35973301e-02f, -8.17751139e-02f, -1.88090038e-02f,
  -8.13653469e-02f, 2.69211009e-02f, 2.47538127e-02f, 2.97100712e-02f, -5.61956950e-02f, 1.55924549e-02f, 3.97012345e-02f, 2.13956293e-02f, -3.85715924e-02f, -1.92454760e-03f,
  1.19745523e-01f, -3.83108072e-02f, 3.13866496e-01f, 3.58323269e-02f, 2.04327226e-01f, -7.85630941e-02f, -9.32140723e-02f, 5.88943847e-02f, 9.31495950e-02f, -2.00391650e-01f,
  -1.59867197e-01f, -2.96274386e-02f, -1.04547702e-01f, 1.08584296e-02f, 1.24230258e-01f, 6.32249925e-04f, -4.15892191e-02f, -1.61766425e-01f, 1.67243496e-01f, -1.74220875e-01f,
  6.01749718e-02f, -4.30156700e-02f, 1.36834607e-01f, 6.10498115e-02f, 5.00048809e-02f, 3.42294946e-02f, -1.32200018e-01f, 4.09839042e-02f, -1.43299773e-01f, 8.15865234e-04f,
  -4.75586625e-03f, -6.75177947e-02f, 6.26773909e-02f, 5.58384508e-02f, 4.51844670e-02f, -1.28121134e-02f, -5.86326085e-02f, 5.51981106e-02f, 6.60562664e-02f, 2.00196868e-03f,
  -4.65193987e-02f, 9.04627666e-02f, -1.68399177e-02f, 7.42973536e-02f, -2.51907874e-02f, 1.37244567e-01f, 7.47423992e-02f, 8.88433680e-02f, 1.90483799e-04f, 1.22264281e-01f,
  7.20792860e-02f, 8.61400515e-02f, -2.75286138e-02f, -7.28841722e-02f, 5.85724972e-02f, 8.30195695e-02f, 1.45951752e-02f, -1.10609401e-02f, -8.68258178e-02f, 1.12402834e-01f,
  -6.26138970e-02f, 8.46132543e-03f, -6.52535781e-02f, 4.84655201e-02f, -2.25597359e-02f, 1.66339725e-02f, 1.77808236e-02f, -4.11295407e-02f, 6.07106686e-02f, -7.78274424e-03f,
  -3.66624705e-02f, -5.13528846e-02f, 2.16888674e-02f, -9.31610912e-02f, -4.46574995e-03f, 1.91345420e-02f, -5.15848063e-02f, 1.57815367e-02f, 3.21701430e-02f, 1.73981544e-02f,
  4.79667127e-04f, 2.50975378e-02f, -2.16603950e-02f, -3.43608558e-02f, 2.03194469e-02f, 7.04323351e-02f, 5.04078344e-02f, 9.74524841e-02f, -2.06508581e-02f, 2.58087385e-02f,
  -2.77505249e-01f, -1.91457018e-01f, -1.39657650e-02f, -8.71535204e-03f, -2.23018136e-02f, -1.79804247e-02f, -8.38679522e-02f, -3.48834358e-02f, -6.95614964e-02f, -6.44493150e-03f,
  -7.34605491e-02f, -4.62159701e-02f, -1.04907274e-01f, -2.02064263e-03f, -3.40794884e-02f, 2.46848036e-02f, -9.92168859e-02f, -2.81636249e-02f, -5.95691614e-03f, 2.05468349e-02f,
  -5.26208021e-02f, -5.34312762e-02f, 2.66245976e-02f, -2.69558672e-02f, 1.03779780e-02f, -1.01643473e-01f, -6.76140040e-02f, 1.77459121e-02f, 4.05802876e-02f, 1.48188490e-02f,
  -1.91663325e-01f, -1.56840670e-03f, -6.31169304e-02f, -1.88674077e-01f, 1.19723395e-01f, -1.26365796e-01f, -1.62437081e-01f, 3.52716818e-02f, 3.29645700e-03f, 6.68960363e-02f,
  -1.14335932e-01f, 5.18572479e-02f, -9.07903165e-02f, -1.47631854e-01f, -2.57001311e-01f, -1.37180030e-01f, -1.99103937e-01f, -3.77661102e-02f, -1.02989860e-01f, -3.00898552e-02f,
  -9.20793712e-02f, -7.65772015e-02f, -1.78257912e-01f, -2.74226759e-02f, -5.27847931e-02f, 3.72126028e-02f, -1.20412119e-01f, -6.55789822e-02f, -2.61992663e-02f, -4.89319004e-02f,
  -1.40438855e-01f, 8.27443972e-02f, 1.61246490e-02f, -2.70690285e-02f, -4.08089384e-02f, 9.06289741e-03f, -3.30689289e-02f, 3.26174870e-02f, -2.92973667e-02f, -3.22041959e-02f,
  3.36644873e-02f, 7.29414746e-02f, -6.76077232e-02f, 9.06352475e-02f, 1.61148962e-02f, 6.94675446e-02f, 8.05823654e-02f, 2.58403588e-02f, -2.99804397e-02f, 2.67005712e-02f,
  1.28320809e-02f, 2.10440457e-02f, 4.07855213e-02f, 3.71243581e-02f, 8.01603198e-02f, 7.68992454e-02f, -2.60561761e-02f, 2.92125046e-02f, -5.22202589e-02f, 2.29850505e-02f,
  7.21337497e-02f, 1.28605803e-02f, 7.31695890e-02f, -1.92091484e-02f, 3.43199670e-02f, -7.07510486e-02f, 1.16056181e-01f, 5.18763959e-02f, 4.11019251e-02f, 3.13121416e-02f,
  1.21616246e-02f, -3.77389453e-02f, 3.51866558e-02f, -9.08465881e-04f, 6.26347363e-02f, -7.79076815e-02f, -1.02408335e-01f, 9.33367312e-02f, -1.49020879e-02f, 4.06605527e-02f,
  -1.05125364e-02f, 5.82171790e-02f, -7.31783733e-03f, -3.49693783e-02f, 3.35877039e-03f, 6.11068793e-02f, -8.53978842e-03f, -1.39161739e-02f, -2.81846840e-02f, 4.84374128e-02f,
  -4.25571837e-02f, -1.86167076e-01f, -3.10216229e-02f, -6.72087539e-03f, -9.94984657e-02f, 1.33609409e-02f, -1.93742923e-02f, -4.98443879e-02f, 3.25323306e-02f, 1.28671601e-02f,
  -1.83284152e-02f, -5.20609878e-02f, 1.49813204e-04f, -5.17527387e-02f, 4.65331338e-02f, -3.45131848e-03f, -4.59859259e-02f, -5.01136556e-02f, -6.22983612e-02f, -6.48675188e-02f,
  5.90917394e-02f, -5.22097759e-03f, -5.36091207e-03f, 4.66852114e-02f, 5.38182408e-02f, 3.87635864e-02f, -5.03528230e-02f, -1.99134909e-02f, 9.09479409e-02f, 7.00638592e-02f,
  -3.48128617e-01f, -1.23180347e-02f, 4.86644283e-02f, -2.54520535e-01f, -8.03814903e-02f, 8.56818929e-02f, 3.06881294e-02f, -1.93111584e-01f, -2.20649168e-01f, 9.48610455e-02f,
  4.96449880e-02f, -1.37658671e-01f, 1.93392619e-01f, -1.51858348e-02f, -8.23721290e-02f, 6.50746524e-02f, -1.03935182e-01f, -5.68183847e-02f, 4.60163504e-02f, -1.30500168e-01f,
  -7.90300816e-02f, -1.39708091e-02f, 8.26698542e-02f, 9.00287330e-02f, -4.63493951e-02f, 6.91386778e-03f, -1.15831839e-02f, 1.47665471e-01f, 2.50454303e-02f, 6.14790730e-02f,
  2.07031444e-02f, 7.06409663e-02f, -7.19169527e-02f, 2.07088795e-03f, -4.65859175e-02f, 1.64034907e-02f, 6.19764216e-02f, 1.02873430e-01f, 1.01763206e-02f, 3.73185724e-02f,
  -1.01236645e-02f, 2.54042409e-02f, -6.23820834e-02f, -3.73423100e-02f, -8.43869373e-02f, 7.31816813e-02f, -1.51722841e-02f, 5.45810796e-02f, -1.73128769e-02f, 7.85239507e-03f,
  7.33403638e-02f, -5.24057746e-02f, -1.18331537e-02f, -6.09050989e-02f, -5.83278500e-02f, -3.91509496e-02f, 6.22444190e-02f, 5.72465435e-02f, -3.50342542e-02f, 5.96463773e-03f,
  -5.92698529e-02f, 8.24681856e-03f, 6.05352968e-02f, 3.43138240e-02f, -2.29861457e-02f, 1.58418417e-02f, 4.13605385e-02f, 2.24428643e-02f, -2.72778030e-02f, 2.44853757e-02f,
  1.17272092e-02f, -9.95669980e-03f, -6.39080182e-02f, 3.50405052e-02f, -5.73478686e-03f, -2.50789225e-02f, -2.56621428e-02f, 6.86456710e-02f, -3.43040042e-02f, 2.38372129e-03f,
  -1.26426490e-02f, -3.14358771e-02f, 4.70783636e-02f, -1.25992289e-02f, -6.46995753e-03f, 4.41904403e-02f, 2.35882476e-02f, 2.80162767e-02f, 3.64043340e-02f, 4.00709473e-02f,
  2.69076638e-02f, 1.84574525e-03f, -9.14569758e-03f, -6.84082285e-02f, 6.15482554e-02f, 1.20147187e-02f, 6.97481865e-03f, -9.12801456e-03f, -5.64542376e-02f, 2.80737001e-02f,
  -2.17608288e-02f, -3.30362916e-02f, -5.42626083e-02f, 5.88805489e-02f, 1.94766745e-02f, -2.97352066e-03f, 1.90586038e-02f, -5.18094487e-02f, 1.62365902e-02f, 9.97131574e-04f,
  -3.68507393e-02f, 7.00898990e-02f, -6.23951899e-04f, 5.69704846e-02f, -3.75775360e-02f, 3.15074529e-03f, -7.55737498e-02f, 7.86362216e-02f, 3.40618379e-02f, -5.27519137e-02f,
  6.11956492e-02f, -2.89422929e-01f, 1.64583817e-01f, -1.59910724e-01f, 2.32177228e-01f, 1.25920400e-01f, 1.04310490e-01f, 1.25489766e-02f, 1.07788658e-02f, -8.15675557e-02f,
  -6.56532217e-03f, 5.02378233e-02f, -7.59095773e-02f, -1.33455187e-01f, 6.12079017e-02f, -1.07667871e-01f, -1.44692585e-01f, -1.28714532e-01f, -1.10782906e-01f, -1.28515333e-01f,
  -7.73795992e-02f, -2.13768613e-02f, 5.37951551e-02f, 5.39924800e-02f, 9.75358710e-02f, -2.09270120e-02f, -6.35113241e-03f, 1.01223558e-01f, -9.54501610e-03f, 6.81168362e-02f,
  -3.88509384e-03f, -9.04124901e-02f, 1.43715486e-01f, 1.02287680e-02f, 9.96733606e-02f, 1.03831485e-01f, 5.37047349e-02f, 1.30805090e-01f, 8.77603795e-03f, -6.25351910e-04f,
  2.92701870e-02f, 5.87237719e-03f, 7.05460366e-03f, -4.45675291e-02f, 6.11002855e-02f, 2.02545449e-02f, 7.33351707e-02f, 6.82792887e-02f, 8.31935033e-02f, 5.73302880e-02f,
  7.51791522e-02f, 8.70009661e-02f, 1.63446125e-02f, -2.89929677e-02f, 4.85949330e-02f, 1.04755592e-02f, 3.21006179e-02f, 6.10656291e-02f, 3.51115242e-02f, 3.94430198e-02f,
  3.65137830e-02f, 4.12864760e-02f, -4.78559025e-02f, -5.05326875e-02f, -3.20046060e-02f, -4.21556532e-02f, -5.89532964e-02f, 5.72176613e-02f, -3.91762033e-02f, -6.70557320e-02f,
  -2.74901465e-02f, -5.45432046e-02f, -4.46813647e-03f, 2.02457383e-02f, 1.81410015e-02f, -4.52612527e-02f, 1.05318381e-02f, -7.31908530e-02f, -1.56201376e-02f, -1.98752526e-03f,
  4.70625907e-02f, -1.16529828e-02f, -1.94706041e-02f, 9.40239895e-03f, 3.04893893e-03f, -4.53356542e-02f, 6.15805909e-02f, -1.42798957e-03f, -1.24498457e-02f, -4.10724208e-02f,
  -2.29714066e-01f, -2.03053787e-01f, 5.83131835e-02f, 5.22307344e-02f, -9.82384160e-02f, -4.27585132e-02f, 3.90975922e-02f, -6.26152605e-02f, -3.34721096e-02f, 6.33557066e-02f,
  2.47936416e-02f, -3.44161130e-02f, 9.40982532e-03f, -3.36402133e-02f, -2.93450952e-02f, 4.16867211e-02f, -2.06439923e-02f, -3.49387736e-03f, 1.53474072e-02f, -4.82591502e-02f,
  -6.01118691e-02f, 5.02879843e-02f, 6.85160309e-02f, 4.30761166e-02f, 3.88137475e-02f, 1.14263557e-02f, -3.41789499e-02f, 1.54862478e-02f, 5.84337348e-03f, 8.07482377e-03f,
  -3.31167251e-01f, 1.24390192e-01f, -1.95944488e-01f, -1.51990354e-02f, 4.05358672e-02f, 2.23546162e-01f, 1.10992774e-01f, 4.51788791e-02f, 7.69072818e-03f, 2.42573768e-01f,
  2.47495342e-02f, -7.62352347e-02f, 7.21991286e-02f, 5.52822910e-02f, -4.04919684e-02f, -1.13464764e-03f, 3.19887511e-02f, 5.01462109e-02f, 2.45324615e-02f, 3.61143728e-03f,
  -1.21219628e-01f, 5.92862032e-02f, -1.55519873e-01f, 1.04472578e-01f, -1.57363415e-01f, -1.63450807e-01f, -3.11239716e-02f, -1.85528740e-01f, -5.73862754e-02f, -9.85452831e-02f,
  -8.21406543e-02f, -1.00022638e-02f, -1.38897851e-01f, -7.61826709e-02f, 6.52234852e-02f, 7.57597610e-02f, -1.96410939e-02f, -6.11029789e-02f, -6.33927286e-02f, -5.03081921e-03f,
  -3.14408122e-03f, 9.81706847e-03f, 7.61584863e-02f, 4.11497355e-02f, 6.88969120e-02f, -3.39181460e-02f, -5.40712141e-02f, 4.93172556e-03f, 2.06391141e-02f, 4.99405824e-02f,
  -6.22680523e-02f, 4.24531801e-03f, -7.37728328e-02f, 1.45256659e-02f, -2.66905557e-02f, 5.27307875e-02f, 8.08968842e-02f, -6.51022568e-02f, -3.84058617e-03f, 8.05016533e-02f,
  4.26149033e-02f, 1.19595595e-01f, -6.33084550e-02f, 5.72437011e-02f, -2.43835114e-02f, 2.46937592e-02f, 1.72483213e-02f, -2.85562370e-02f, -9.05042887e-02f, 4.41680066e-02f,
  9.22715943e-03f, -2.35615261e-02f, 1.27989324e-02f, 1.04440384e-01f, -4.50266935e-02f, 6.38695955e-02f, -4.51152921e-02f, -3.02083269e-02f, -1.81054045e-02f, 1.17200743e-02f,
  4.23332527e-02f, 4.58257943e-02f, -4.46537882e-02f, -2.51750536e-02f, 5.61124682e-02f, -1.84527989e-02f, 2.33247504e-02f, -3.07932477e-02f, -6.01461120e-02f, 6.09913329e-03f,
  1.59949988e-01f, 1.60621360e-01f, 6.86486438e-02f, 1.61914937e-02f, 7.84346983e-02f, -1.46184340e-02f, 2.02513416e-03f, 2.28800252e-03f, 1.11864537e-01f, -3.72284465e-02f,
  -1.89197958e-02f, -3.46063301e-02f, 7.40090758e-02f, -1.36244893e-02f, -2.06227265e-02f, -5.32712461e-03f, 6.17756620e-02f, -1.67158747e-03f, 6.47359155e-03f, -3.49455439e-02f,
  2.29614619e-02f, 7.44050816e-02f, 2.64470279e-02f, -7.06554577e-03f, 7.53983632e-02f, -5.66496747e-03f, 3.69290374e-02f, 7.54488036e-02f, 1.02058193e-02f, 6.09580837e-02f,
  3.61469507e-01f, -8.70233029e-02f, -7.74620101e-02f, 1.46909937e-01f, 8.43564644e-02f, -2.28289403e-02f, -1.21399797e-02f, 1.31748602e-01f, 1.16050899e-01f, 2.36226190e-02f,
  5.47498465e-02f, 1.87185612e-02f, -1.16217479e-01f, -5.08159772e-02f, 1.10345051e-01f, -6.82752058e-02f, 1.98917352e-02f, 5.56379072e-02f, 7.96314254e-02f, 9.01398659e-02f,
  1.16019212e-01f, 9.34645981e-02f, -7.61354640e-02f, 8.50834921e-02f, -3.71657498e-02f, 4.74114679e-02f, -5.13549261e-02f, -1.27407506e-01f, -8.41799155e-02f, 6.49936348e-02f,
  -9.15805693e-04f, 4.48508784e-02f, 5.85759468e-02f, 3.58106643e-02f, -1.55535887e-03f, -4.73372079e-02f, -9.62557122e-02f, 1.56614892e-02f, -5.69136720e-03f, -7.79965194e-03f,
  -7.74986595e-02f, 9.81727801e-03f, -1.02482783e-02f, -7.56995380e-02f, -9.47254710e-03f, -8.09694268e-03f, 4.99338694e-02f, -1.78860202e-02f, 2.30087824e-02f, -7.07906438e-03f,
  7.14721810e-03f, -1.31869735e-02f, 1.73534118e-02f, -8.82882252e-02f, -2.39864215e-02f, -8.15714244e-03f, -5.44752628e-02f, -7.31849521e-02f, -8.83686990e-02f, 4.33797650e-02f,
  4.09598723e-02f, 4.28433949e-03f, -8.88407007e-02f, 8.30314457e-02f, 8.08567777e-02f, -1.97244361e-02f, -1.77744590e-02f, -1.67377926e-02f, 7.51974210e-02f, 4.51925807e-02f,
  -8.65052640e-03f, 5.21901660e-02f, 5.26720397e-02f, -3.32874409e-03f, 5.21829277e-02f, 5.38708605e-02f, -1.55254370e-02f, -2.72202287e-02f, 3.02515998e-02f, -1.97151732e-02f,
  -4.13013855e-03f, 2.15447731e-02f, 2.69934181e-02f, -2.33726539e-02f, -5.53569198e-02f, -3.38980407e-02f, -5.65467477e-02f, -1.37949793e-03f, 5.66305593e-02f, 3.10429279e-02f,
  3.19223595e-03f, 1.94518380e-02f, 1.29676005e-02f, -8.69447589e-02f, -1.05149262e-02f, 4.05635722e-02f, 5.80126196e-02f, 7.83931278e-03f, -8.55655819e-02f, 4.89636995e-02f,
  -4.62085307e-02f, -3.62382010e-02f, 3.58282924e-02f, 5.70475496e-02f, 2.90370174e-02f, 1.11473659e-02f, 5.63583486e-02f, 1.72125511e-02f, -2.43828036e-02f, 3.11670499e-03f,
  1.57528166e-02f, -7.55648389e-02f, -2.33376268e-02f, -4.11571376e-02f, -2.73886230e-02f, -9.92104113e-02f, 3.73574905e-02f, -4.93512955e-03f, -3.43393721e-02f, -3.49503793e-02f,
  1.57165248e-02f, 2.76560038e-01f, -3.02744746e-01f, 2.26313040e-01f, -1.51165411e-01f, 3.31903785e-03f, 1.56754777e-02f, 2.80389171e-02f, 2.64283232e-02f, 2.46916488e-01f,
  1.27029657e-01f, 3.78289074e-02f, 4.42072004e-02f, 6.94435984e-02f, -1.18907439e-02f, -5.29639870e-02f, 9.67997164e-02f, 5.74137494e-02f, -9.63701122e-03f, 2.19524838e-02f,
  1.68135595e-02f, 3.60982940e-02f, -1.56985074e-01f, -1.24459162e-01f, -1.02534369e-01f, -2.59360801e-02f, 1.08095333e-01f, -6.39065132e-02f, 1.27932359e-03f, -5.53213656e-02f,
  7.91453123e-02f, 1.18617013e-01f, -5.75953396e-03f, -8.02919827e-03f, 5.21345111e-03f, 5.72830811e-02f, -1.40538784e-02f, -7.45149627e-02f, -5.69863543e-02f, -5.03136143e-02f,
  2.09417548e-02f, 1.50517514e-02f, -1.16126888e-01f, -8.16732496e-02f, 6.82990104e-02f, 3.15557653e-03f, -3.79624777e-03f, 1.72528289e-02f, -1.33824693e-02f, -7.73332790e-02f,
  -3.05019189e-02f, 2.43012365e-02f, 4.90888730e-02f, 7.89009780e-03f, 1.50618181e-02f, 3.83217186e-02f, -2.06669252e-02f, -4.82610315e-02f, 8.26403312e-03f, 4.14134711e-02f,
  -8.53853002e-02f, -2.44901385e-02f, 5.04850149e-02f, -4.13065813e-02f, 6.00763224e-02f, 3.88637395e-03f, 3.05168107e-02f, -2.58965064e-02f, 8.06802362e-02f, -2.26297267e-02f,
  -3.23489308e-02f, 2.18907315e-02f, -1.61084626e-03f, 3.76639105e-02f, 6.31144568e-02f, 1.07449330e-01f, -5.14945090e-02f, 6.16357438e-02f, -6.34887591e-02f, 1.94764957e-02f,
  -5.75555675e-03f, 3.66963111e-02f, -1.17084512e-03f, -4.05587517e-02f, 2.32028938e-03f, -9.83344205e-03f, 8.07664916e-02f, 6.51757699e-03f, 2.88921800e-02f, -4.59800065e-02f,
  3.16886067e-01f, 2.45452091e-01f, -4.36853878e-02f, 3.36141512e-02f, 2.45318227e-02f, 1.47324083e-02f, 2.09616520e-03f, 2.23662294e-02f, 6.04041107e-02f, 3.71337533e-02f,
  3.65439951e-02f, 3.64379399e-02f, 3.81811298e-02f, 3.36784832e-02f, 6.58643916e-02f, 5.66401370e-02f, 5.62723055e-02f, 1.81724168e-02f, 8.16387981e-02f, 3.41505967e-02f,
  9.93656889e-02f, -2.37008091e-02f, -1.99256185e-02f, 2.61607170e-02f, -2.15035696e-02f, 1.46279959e-02f, -2.28242134e-03f, 4.22422774e-02f, 4.21777368e-02f, -1.98671352e-02f,
  2.51838952e-01f, 4.58713882e-02f, 1.18249528e-01f, -5.89723922e-02f, 8.63226205e-02f, 1.29537806e-01f, 2.10668549e-01f, -5.31850606e-02f, 2.83583254e-01f, 3.62480432e-02f,
  -4.81202528e-02f, 6.22384138e-02f, 1.47717386e-01f, -1.70358449e-01f, -1.34810999e-01f, 7.05814585e-02f, 4.10631225e-02f, -7.23423762e-03f, 5.06659448e-02f, 6.65735779e-03f,
  5.45037724e-02f, -2.00614586e-01f, -1.94929987e-01f, -3.17324400e-01f, 3.14135700e-02f, -9.35172066e-02f, -2.28514165e-01f, -3.65930349e-02f, -3.28695893e-01f, -1.76055148e-01f,
  3.41809057e-02f, 3.86022329e-02f, -9.08579770e-03f, -4.06948477e-02f, -9.93382856e-02f, 1.45084113e-02f, -4.06406857e-02f, -6.06242903e-02f, 6.52994737e-02f, -2.58875526e-02f,
  3.01145241e-02f, 5.22276387e-02f, -8.64636451e-02f, -2.09837798e-02f, 2.79585477e-02f, -4.81572710e-02f, -3.72086912e-02f, 7.95899630e-02f, 5.76405972e-02f, 9.53916553e-03f,
  4.07832339e-02f, -1.05853355e-03f, -1.23006947e-04f, -3.64197306e-02f, -1.04184216e-02f, 2.64428407e-02f, -5.71308881e-02f, 3.05458321e-03f, -2.23294534e-02f, -1.47728985e-02f,
  6.10723943e-02f, 5.66307642e-02f, 2.57655196e-02f, 2.19295267e-02f, 2.53564678e-02f, 7.52320001e-03f, -1.61274616e-02f, -2.41662133e-02f, 4.70413789e-02f, 2.39423048e-02f,
  6.99460506e-03f, 6.78295363e-03f, 2.04857346e-02f, 8.31818059e-02f, 6.76655490e-03f, 3.50652710e-02f, -5.29155973e-03f, -1.64488293e-02f, 4.69879769e-02f, -4.73295040e-02f,
  2.47974712e-02f, 1.55883725e-03f, -9.55110490e-02f, -2.55731028e-02f, -1.61299051e-03f, 7.15860054e-02f, 1.06964987e-02f, 7.50368461e-02f, 3.43553652e-03f, -1.06087723e-03f,
  -4.45435457e-02f, -4.29026186e-02f, 1.20791169e-02f, 9.17435661e-02f, 2.89097223e-02f, -7.12237805e-02f, 6.63936138e-03f, 1.21483915e-02f, -5.02254777e-02f, -7.47819319e-02f,
  -2.26103771e-03f, -6.07412383e-02f, 5.24613559e-02f, -2.91187372e-02f, -2.77553648e-02f, -6.69438625e-03f, -1.02521256e-02f, -1.10914320e-01f, -9.12666991e-02f, -2.36570686e-02f,
  -4.97868583e-02f, 1.01123052e-02f, -1.93317868e-02f, -7.09692240e-02f, -4.85336781e-02f, -4.51860093e-02f, 7.10494351e-03f, 4.36358489e-02f, -2.59960126e-02f, -7.46981502e-02f,
  2.86310047e-01f, 8.23255554e-02f, 7.77284428e-02f, -1.23827770e-01f, 1.00730792e-01f, -4.02110070e-02f, -5.90251386e-02f, 9.61868390e-02f, -6.59175292e-02f, -9.23951417e-02f,
  -1.23595633e-01f, -2.83695851e-02f, -6.71133101e-02f, -7.79580697e-02f, -3.13409030e-01f, -1.29974514e-01f, -1.37143835e-01f, -8.98552462e-02f, 3.59787084e-02f, 2.37204824e-02f,
  -5.42766675e-02f, -4.92083207e-02f, -9.92807820e-02f, 9.55497846e-02f, -4.54100594e-02f, 2.59257155e-03f, -1.32431343e-01f, 1.25096411e-01f, -1.34397358e-01f, -5.08151203e-02f,
  8.69680867e-02f, 2.03828037e-01f, 1.36268869e-01f, 6.79610297e-02f, 6.01660386e-02f, 2.23284848e-02f, -3.32504027e-02f, 5.05324490e-02f, 2.78346650e-02f, 3.92369507e-03f,
  1.66462958e-02f, -4.57191989e-02f, 3.31070200e-02f, 1.49986669e-02f, 7.39038810e-02f, 4.16428596e-02f, 2.66287550e-02f, -3.93993482e-02f, -4.93126512e-02f, 1.09704696e-02f,
  -6.02130406e-02f, -1.56913064e-02f, -4.13582064e-02f, -1.29199937e-01f, -6.04143739e-02f, -1.10433642e-02f, -3.61029967e-03f, -1.46094682e-02f, -1.31704509e-02f, -4.31025326e-02f,
  -1.09684505e-02f, 5.14312051e-02f, -2.89865695e-02f, 2.11369786e-02f, -2.71071605e-02f, -9.01436210e-02f, -8.56612399e-02f, -2.57393830e-02f, 2.62658615e-02f, -8.69036186e-03f,
  -6.48598000e-02f, 1.56631917e-02f, -2.93708406e-02f, -8.07307735e-02f, -6.41795024e-02f, 1.10527249e-02f, -3.31663936e-02f, 2.70485971e-02f, -3.56921107e-02f, -8.02823529e-02f,
  8.78884736e-03f, -3.83618772e-02f, -9.38660204e-02f, -2.28650235e-02f, -5.29880263e-02f, 9.71086603e-03f, 1.60551947e-02f, -4.27701697e-03f, -6.45361617e-02f, 1.49853658e-02f,
  1.81112476e-02f, 1.37026757e-01f, 3.19666415e-02f, -6.01238385e-03f, -2.74790600e-02f, 2.83916164e-02f, 8.87399819e-03f, -5.39745577e-02f, 2.90338807e-02f, -2.56915726e-02f,
  -4.14366461e-02f, 8.39389414e-02f, -5.20510972e-02f, -2.62472834e-02f, -1.67404011e-01f, -3.99691910e-02f, 3.70987728e-02f, 2.54125521e-02f, -2.69455463e-02f, -1.26625067e-02f,
  3.40149552e-02f, 1.73177905e-02f, 1.38763422e-02f, 2.16177665e-02f, 2.46577375e-02f, -5.10382056e-02f, 6.77831322e-02f, 3.76296900e-02f, -3.22923921e-02f, -1.74775650e-03f,
  -9.49332863e-02f, 2.82756031e-01f, 7.04145133e-02f, -1.32926255e-02f, -2.36359522e-01f, -3.32309246e-01f, -1.38239950e-01f, -2.51070205e-02f, -2.99053895e-03f, 1.09806061e-01f,
  -4.01960611e-02f, 1.66794181e-01f, 7.86056593e-02f, -1.11089438e-01f, -2.01892570e-01f, -6.68582506e-03f, -7.83783495e-02f, 7.63826212e-03f, -4.60034236e-02f, -1.90800931e-02f,
  4.97110710e-02f, -1.53668061e-01f, 1.10903352e-01f, 1.68612018e-01f, 3.14098559e-02f, 1.17838740e-01f, 6.59041777e-02f, 1.19639710e-01f, 5.70012294e-02f, -2.19323467e-02f,
  -2.36825785e-03f, -2.45035859e-03f, -2.09921189e-02f, 4.69801836e-02f, -7.35403374e-02f, 3.73806246e-02f, 1.07758000e-01f, -2.40081847e-02f, 6.32728636e-02f, -7.03016594e-02f,
  6.80235848e-02f, -9.81126167e-03f, -5.54114319e-02f, 3.76561284e-02f, -2.06602905e-02f, -7.17030125e-05f, -2.17843577e-02f, -3.42923291e-02f, 6.90672249e-02f, -2.97639687e-02f,
  -3.45990509e-02f, -3.51005495e-02f, -8.97789747e-03f, 1.32352607e-02f, -9.38577764e-03f, -9.48865898e-03f, -7.10413931e-03f, -9.47389286e-04f, -8.72309208e-02f, -2.36838125e-02f,
  -2.61116233e-02f, -7.01221963e-03f, 8.65009893e-03f, -2.27374379e-02f, -1.53269051e-02f, -5.98585419e-02f, 2.99183093e-02f, -6.30128607e-02f, 1.14587639e-02f, 4.00856175e-02f,
  -2.63822097e-02f, 1.02704614e-02f, 2.75803003e-02f, -4.09384221e-02f, -4.86123376e-02f, 3.88400257e-02f, -3.10234390e-02f, -7.30584115e-02f, 4.50239554e-02f, -8.45981911e-02f,
  -9.13090073e-03f, 4.16292064e-03f, -1.38312420e-02f, 1.12600927e-03f, 3.71923274e-03f, -1.86989084e-02f, 2.08927356e-02f, 2.38390490e-02f, -2.61214506e-02f, -3.53255719e-02f,
  3.76951694e-02f, 4.97991517e-02f, -4.00587078e-03f, 4.06033956e-02f, 5.70959263e-02f, 8.75223503e-02f, -6.98358119e-02f, 1.66897271e-02f, 1.07491434e-01f, 4.68870960e-02f,
  -2.87638865e-02f, -2.45854091e-02f, -1.39821265e-02f, -6.87258244e-02f, -3.23533304e-02f, -8.81144777e-02f, -8.90017208e-03f, -1.80886779e-02f, -8.70442167e-02f, -3.21114175e-02f,
  -7.66786095e-03f, -1.08351387e-01f, -8.72134045e-03f, -4.18358520e-02f, -6.28165156e-02f, -4.92347628e-02f, 5.15376069e-02f, -3.53720486e-02f, -6.85044080e-02f, -1.67787110e-03f,
  -6.96229637e-02f, 4.30440344e-02f, 9.46062580e-02f, -1.88858509e-02f, -1.44418597e-01f, -2.68613875e-01f, -1.41059279e-01f, -7.21099228e-02f, 7.02160550e-03f, -2.81194993e-03f,
  -1.27641529e-01f, 1.62715003e-01f, 3.30876522e-02f, -1.29334718e-01f, -2.32990265e-01f, -1.38784554e-02f, -2.77321577e-01f, -7.42684677e-02f, 5.03096904e-04f, -1.20123364e-01f,
  -1.05638385e-01f, -1.47113398e-01f, -6.90008029e-02f, -1.18626930e-01f, 7.22138502e-04f, 1.43472031e-01f, -2.41924040e-02f, 9.11301076e-02f, 7.49913510e-04f, 6.02328256e-02f,
  -1.49329351e-02f, 7.81254023e-02f, 6.03647344e-02f, -2.84215547e-02f, 7.07263732e-03f, -7.41424039e-02f, -5.92052490e-02f, -4.13141884e-02f, -2.36201733e-02f, -2.03199196e-03f,
  8.30477923e-02f, -2.25626137e-02f, -8.69897604e-02f, 2.12213453e-02f, 3.98707613e-02f, -5.74310385e-02f, -7.89677948e-02f, 2.04303525e-02f, 6.61256313e-02f, -4.37612878e-03f,
  -2.70248521e-02f, 2.91574523e-02f, -6.29736632e-02f, 5.45619056e-02f, 2.13166624e-02f, -3.80131826e-02f, -2.24791076e-02f, -1.12870239e-01f, 8.72717202e-02f, 5.73562495e-02f,
  2.12756246e-02f, -8.83562192e-02f, 4.20721658e-02f, 3.73819694e-02f, -3.57023329e-02f, 3.00836954e-02f, -3.18732001e-02f, -2.14025080e-02f, 6.02181554e-02f, -4.95803766e-02f,
  -8.51951819e-03f, 4.64448668e-02f, -1.30540524e-02f, 3.90681252e-02f, -3.63777205e-02f, 3.15001532e-02f, 8.47278442e-03f, 7.86815062e-02f, 9.54501331e-03f, 1.05263516e-02f,
  4.71466519e-02f, -7.82519579e-03f, 6.79962263e-02f, 4.37476672e-02f, -5.60054407e-02f, -3.55530269e-02f, 8.13582093e-02f, 3.61004635e-03f, 2.81173680e-02f, -2.48589907e-02f,
  -5.73441237e-02f, -7.59141520e-02f, 3.48863527e-02f, 5.35781011e-02f, 7.18247294e-02f, 4.07581404e-02f, -6.54100850e-02f, 5.35937473e-02f, -3.49225732e-03f, -2.31409129e-02f,
  -3.03790290e-02f, -3.79960798e-02f, 3.53373587e-02f, 6.95449021e-03f, -1.28147993e-02f, 1.45901302e-02f, 4.46309056e-03f, 6.66574463e-02f, -5.22605889e-02f, 2.13863254e-02f,
  1.38037233e-03f, -4.41157147e-02f, -5.49574122e-02f, -7.00325444e-02f, -6.25694841e-02f, 4.28072363e-03f, -4.80087250e-02f, 7.31546804e-02f, 4.74258624e-02f, -1.92165095e-02f,
  -2.79954195e-01f, 2.67785430e-01f, -1.38603365e-02f, 3.44861783e-02f, 5.96934371e-02f, 2.21968051e-02f, 7.35366568e-02f, 1.85714290e-01f, 4.81380895e-02f, 1.94159508e-01f,
  -1.16000306e-02f, 8.38076137e-03f, 1.76758215e-01f, 2.17596695e-01f, -7.90739432e-02f, 1.18662521e-01f, 8.11203718e-02f, 8.08546469e-02f, 5.38304001e-02f, 1.42729372e-01f,
  5.29532731e-02f, 1.62227243e-01f, 6.04929253e-02f, 1.82683319e-01f, 9.27252620e-02f, -1.22886058e-03f, 1.01187475e-01f, -3.53138819e-02f, -2.27218866e-02f, -4.55210432e-02f,
  -5.85650913e-02f, 8.04964155e-02f, 5.26340455e-02f, -1.01777790e-02f, 3.39393951e-02f, 9.45167243e-02f, -7.58826658e-02f, -6.52831420e-02f, -7.74775967e-02f, 4.36066948e-02f,
  -1.30573092e-02f, -4.45663184e-02f, 3.48269381e-02f, -5.54741640e-03f, -1.33541794e-02f, 1.48764271e-02f, -4.90228534e-02f, 1.65780857e-02f, 5.07845543e-02f, -3.52457352e-02f,
  5.78107424e-02f, 4.65449207e-02f, 3.74141000e-02f, -2.40066852e-02f, -9.37030911e-02f, -2.30528768e-02f, 5.42938709e-02f, -1.99491605e-02f, 5.64489737e-02f, 2.76931487e-02f,
  4.74148840e-02f, 5.88526316e-02f, 4.81905453e-02f, -6.85234219e-02f, -1.85217168e-02f, -5.62682301e-02f, -3.74086797e-02f, -2.44681425e-02f, -5.15103638e-02f, -4.98785637e-02f,
  -6.08665720e-02f, -2.18310580e-02f, 4.61208634e-02f, -2.98270509e-02f, 7.63720041e-03f, 4.26660217e-02f, -3.29747051e-02f, -3.15742497e-03f, -1.15469843e-02f, -1.01904884e-01f,
  9.20876674e-03f, 3.88646778e-03f, -2.93485243e-02f, -4.44239564e-02f, 8.70741624e-03f, 2.41037980e-02f, 5.65391891e-02f, -3.09717562e-02f, 1.68450475e-02f, 5.00325933e-02f,
  1.91406950e-01f, 3.10753822e-01f, 9.26140472e-02f, -1.97548904e-02f, -1.49585810e-02f, -3.78970429e-02f, -1.81916934e-02f, 5.49199618e-02f, 2.47016400e-02f, 2.71986127e-02f,
  -3.60615142e-02f, -9.93351117e-02f, 2.33006291e-03f, -5.12587726e-02f, 4.96662930e-02f, 9.94734932e-03f, 5.67651950e-02f, 1.95540651e-03f, 2.96748262e-02f, 2.81730164e-02f,
  4.83956113e-02f, -2.20991895e-02f, -6.61306605e-02f, -4.64927182e-02f, -1.54873105e-02f, -5.66245615e-02f, -7.17001185e-02f, 2.23656818e-02f, -4.27539945e-02f, -5.19633554e-02f,
  1.90014839e-01f, 9.86391678e-03f, 8.66129100e-02f, 1.16123967e-01f, -1.06320474e-02f, 5.03760241e-02f, 7.13207573e-02f, 1.12745114e-01f, 6.10624142e-02f, 2.00273450e-02f,
  -2.73906179e-02f, -1.82377733e-02f, -1.73503876e-01f, 4.34836596e-02f, 7.77437240e-02f, -1.41407803e-01f, 4.88977470e-02f, 4.04451825e-02f, -1.95776066e-03f, 1.27869248e-01f,
  1.50527701e-01f, 1.63148195e-02f, 7.65120685e-02f, -4.36029471e-02f, 8.66773650e-02f, 9.59882513e-02f, 6.21700212e-02f, -7.87586793e-02f, 1.26854688e-01f, -3.71327288e-02f,
  1.27753299e-02f, -4.73721623e-02f, 1.14095360e-02f, -1.11507960e-01f, -4.34607230e-02f, 9.33698937e-02f, -8.32279492e-03f, 3.84879112e-02f, 5.62794171e-02f, -5.90553954e-02f,
  1.30808754e-02f, -7.95479938e-02f, 9.79485922e-03f, -4.88953814e-02f, -3.09143681e-02f, 7.29959970e-03f, 2.86360439e-02f, -5.36445901e-03f, -9.30665992e-04f, -2.94780768e-02f,
  -1.55607713e-02f, 3.28157805e-02f, 7.68202543e-02f, 2.63305251e-02f, 4.93090451e-02f, 6.69147372e-02f, -1.45698832e-02f, 4.89129424e-02f, 2.27857605e-02f, -1.55503245e-03f,
  -4.67527881e-02f, 1.96850374e-02f, -3.78655344e-02f, -1.49034634e-02f, 3.14816386e-02f, 5.83411977e-02f, 1.83729269e-02f, 6.84186891e-02f, 3.81581835e-03f, 1.14611253e-01f,
  -5.50232641e-02f, 7.61086419e-02f, -5.18456288e-02f, 6.07912913e-02f, 7.60574639e-02f, -1.38836969e-02f, 5.49416430e-03f, -7.96836540e-02f, -9.89296846e-03f, 8.25753435e-02f,
  1.78890005e-02f, 2.43440387e-03f, 7.90932328e-02f, 7.63849020e-02f, 4.18700464e-02f, -6.90421462e-02f, 5.46573810e-02f, 1.16147210e-04f, 3.68891284e-02f, -3.19955610e-02f,
  -7.39379004e-02f, 3.91672477e-02f, -2.55489163e-02f, 9.22852661e-03f, 4.45673615e-03f, 2.98491493e-02f, -8.00322145e-02f, 9.21525657e-02f, 1.06060803e-02f, -1.32086861e-03f,
  9.92637724e-02f, 6.59637377e-02f, -3.26507352e-02f, -7.31697120e-03f, 3.31094745e-03f, 2.94246781e-03f, -3.30747589e-02f, -4.32025194e-02f, 1.05713882e-01f, 1.51524472e-03f,
  -3.35772894e-02f, -6.13755248e-02f, 8.36061016e-02f, 1.07924476e-01f, -4.77436483e-02f, -7.18333796e-02f, -8.79772529e-02f, -6.92141149e-03f, -2.51057036e-02f, 5.06971553e-02f,
  -3.20191085e-01f, -4.04735245e-02f, -2.34315228e-02f, -2.91752458e-01f, 2.12053414e-02f, 1.50371149e-01f, 1.54833019e-01f, -9.27673504e-02f, -2.89435126e-02f, 5.66727370e-02f,
  7.23889023e-02f, -1.35226861e-01f, 1.73422784e-01f, -1.50337651e-01f, -7.84950405e-02f, 1.09829962e-01f, -1.02222472e-01f, -1.19298711e-01f, -3.45295382e-04f, 1.88760292e-02f,
  1.02805551e-02f, 5.79112731e-02f, -6.18536808e-02f, 9.67108924e-03f, -3.28184403e-02f, -1.56989977e-01f, -4.46364023e-02f, 7.26750270e-02f, -9.20743346e-02f, -2.83808708e-02f,
  9.86746252e-02f, -6.05523288e-02f, -8.58305767e-03f, -1.44767351e-02f, -3.88787985e-02f, 4.19317074e-02f, -4.89052832e-02f, 3.60698346e-03f, -4.06357273e-02f, 2.50202119e-02f,
  8.07452872e-02f, -3.99192125e-02f, -8.59644264e-02f, -2.19345205e-02f, -7.66553655e-02f, -8.44723061e-02f, -4.85735945e-02f, 2.29027979e-02f, 3.99442427e-02f, 2.20774822e-02f,
  6.09377213e-03f, -1.29112648e-02f, -3.32229584e-02f, -3.85679044e-02f, 1.87888704e-02f, -3.50483395e-02f, 1.78848226e-02f, -1.25633562e-02f, 5.62798753e-02f, -1.47788718e-01f,
  6.70104921e-02f, -5.65416180e-03f, -2.53146235e-02f, -7.09417686e-02f, -2.45621782e-02f, -1.26380855e-02f, -2.18107365e-02f, 7.00707287e-02f, -3.93241495e-02f, 4.57888562e-03f,
  -1.68395545e-02f, 8.57658975e-04f, -4.71231826e-02f, -4.03517410e-02f, 2.91049667e-03f, 4.63324512e-04f, -8.12539011e-02f, -5.80339991e-02f, -6.94353208e-02f, -5.27445860e-02f,
  8.88566971e-02f, 1.54334903e-02f, -4.69835242e-03f, 1.70397088e-02f, 5.28898127e-02f, 1.53406672e-02f, -6.79163784e-02f, -1.35130547e-02f, 5.44661246e-02f, 6.39060810e-02f,
  -3.00296582e-03f, 8.53874069e-03f, 8.97569805e-02f, 8.43216479e-02f, 6.94064274e-02f, -3.21116038e-02f, -7.44594727e-03f, -9.12765134e-03f, 2.02681124e-02f, -3.66315222e-03f,
  -3.93568054e-02f, -4.70531583e-02f, 4.89319861e-02f, -4.92902026e-02f, 1.25560053e-02f, -2.46028397e-02f, -5.41426102e-03f, -1.19509678e-02f, -6.60205334e-02f, 6.29510432e-02f,
  3.65111083e-02f, -7.00810030e-02f, 1.03289969e-02f, -6.56364188e-02f, -7.62507468e-02f, -9.44076572e-03f, -1.24944672e-02f, -3.52926925e-02f, 2.51986831e-02f, 1.10017341e-02f,
  4.26432073e-01f, -1.51084706e-01f, -8.17526951e-02f, 9.08872299e-03f, -2.05099639e-02f, -1.47677734e-01f, 7.62752593e-02f, -1.53652832e-01f, -1.11494422e-01f, -2.15443045e-01f,
  -7.58339046e-03f, 8.95298645e-03f, -2.35284045e-02f, 3.84639390e-02f, 2.27420077e-01f, -1.22619448e-02f, 1.16583884e-01f, -9.48965363e-03f, 9.33040399e-03f, 6.09837938e-03f,
  8.73439610e-02f, -4.64602225e-02f, 7.39609823e-02f, -3.79246511e-02f, 4.83991504e-02f, -8.05163756e-02f, 5.48863672e-02f, -5.66228516e-02f, -5.55601083e-02f, 1.77515186e-02f,
  3.57653163e-02f, 5.43806553e-02f, 4.10789512e-02f, -8.12127739e-02f, 6.58362657e-02f, 6.28194585e-02f, -3.07503268e-02f, 2.31006276e-02f, 1.41797960e-02f, 6.94139078e-02f,
  3.30241174e-02f, 6.86832052e-03f, -7.35847503e-02f, 7.47907907e-02f, 2.30425689e-02f, -3.04097626e-02f, -2.98679341e-02f, 1.70311164e-02f, -5.35487495e-02f, -1.01668529e-01f,
  -6.22999528e-03f, -6.02370128e-02f, 9.90671758e-03f, -6.56488910e-02f, -1.94121283e-02f, 5.03123067e-02f, 5.42369336e-02f, 4.74084876e-02f, 3.63964997e-02f, -9.28137153e-02f,
  4.27328423e-02f, -1.70268249e-04f, -1.36721050e-02f, -2.75079124e-02f, -6.59667030e-02f, 3.73390317e-02f, -6.96629360e-02f, 2.96500791e-02f, -4.94950600e-02f, -5.69987521e-02f,
  4.54352330e-03f, 4.26385812e-02f, -9.90384445e-03f, -1.53055564e-02f, -7.07879709e-03f, 1.77049562e-02f, -4.80523100e-03f, 5.55260852e-03f, -2.02485546e-02f, 5.03986143e-02f,
  -3.99574637e-02f, 9.64521256e-04f, -4.09817696e-02f, 5.37308306e-02f, 4.07585800e-02f, 1.75886210e-02f, 4.20322828e-03f, -7.61258528e-02f, -9.01921093e-03f, 8.66774023e-02f,
  -1.09395690e-01f, -6.92942217e-02f, -7.95336440e-02f, 3.68862562e-02f, 4.86802757e-02f, -2.40378138e-02f, 1.67059377e-02f, 1.56852528e-02f, 3.50577012e-03f, -3.13422382e-02f,
  2.65112743e-02f, 9.36262216e-03f, -4.29620855e-02f, 5.95719665e-02f, -5.43148071e-02f, -8.85270014e-02f, 3.47588025e-02f, -1.26229487e-02f, -6.44514635e-02f, -3.19422707e-02f,
  -6.20075129e-03f, -2.40260828e-02f, 8.61748457e-02f, 4.50229682e-02f, -2.66415942e-02f, -4.98713702e-02f, 3.55481692e-02f, 2.07141880e-02f, 1.57216936e-02f, -6.54276460e-02f,
  2.89584428e-01f, -1.21143289e-01f, -1.44598559e-01f, 1.30964637e-01f, 6.61705360e-02f, -1.30490243e-01f, -1.19910263e-01f, 7.53075704e-02f, 1.20941456e-02f, 2.40738802e-02f,
  6.35178201e-03f, -1.62715241e-02f, -1.77718624e-01f, 3.12236231e-02f, 1.16988331e-01f, -1.37005314e-01f, 6.92950189e-02f, -7.70285353e-02f, -1.22829765e-01f, 1.63620502e-01f,
  -2.12451965e-02f, 1.26654774e-01f, 5.77972364e-03f, 1.57571733e-01f, 7.31583312e-02f, 2.28842627e-03f, 2.10557535e-01f, -5.87220564e-02f, 1.51953340e-01f, -3.59724574e-02f,
  1.26867548e-01f, 2.77581271e-02f, -1.52830807e-02f, -2.49980800e-02f, 7.30970874e-03f, 6.48046806e-02f, -8.32285881e-02f, -1.18962020e-01f, -5.78846484e-02f, -6.99577183e-02f,
  -4.93244492e-02f, 1.03904225e-03f, 6.19094670e-02f, -4.32620663e-03f, -2.08836831e-02f, -9.36488807e-02f, -4.04842459e-02f, -4.57386574e-04f, 1.93386376e-02f, -3.68093699e-02f,
  -8.72209519e-02f, -3.14390324e-02f, -1.48549443e-02f, 9.86007974e-03f, 2.17790506e-03f, -2.17937119e-02f, 3.69895287e-02f, -7.34055191e-02f, -7.18890950e-02f, -3.35963303e-03f,
  -8.17492604e-02f, -2.24032309e-02f, -2.39949618e-02f, 9.02201384e-02f, 6.51139475e-04f, 9.92018580e-02f, 4.00734246e-02f, -1.01011312e-02f, 7.53421262e-02f, 6.53253868e-02f,
  6.58149794e-02f, 7.51909986e-02f, -9.65006575e-02f, -8.93819183e-02f, 4.31378670e-02f, -1.59045048e-02f, -8.55866168e-03f, -3.38925421e-02f, 8.74871947e-03f, 1.09464163e-02f,
  -1.58803184e-02f, -8.94328021e-03f, -2.82969512e-02f, -3.78400385e-02f, -1.53935850e-02f, -1.69284213e-02f, 3.96315008e-02f, -3.26540396e-02f, -2.72990335e-02f, -5.89257181e-02f,
  5.93224838e-02f, 1.00309432e-01f, 1.22704695e-03f, -4.06757556e-02f, -3.51863876e-02f, -4.24154028e-02f, -3.23946029e-02f, 1.51720019e-02f, 1.46895600e-02f, 1.89575292e-02f,
  -2.94043571e-02f, 4.45413813e-02f, -4.75043012e-03f, -9.20989364e-03f, 4.14083786e-02f, -4.80597168e-02f, 1.02703996e-01f, 8.64126347e-03f, -4.69767526e-02f, 9.88646224e-03f,
  9.17130057e-03f, 9.11070853e-02f, 7.06540346e-02f, 8.21847171e-02f, -5.30297123e-02f, 5.36497347e-02f, -5.32187289e-03f, -6.51147636e-03f, -3.37979235e-02f, 1.96849257e-02f,
  1.55668601e-01f, -1.44481078e-01f, -1.34690166e-01f, -7.11115003e-02f, 1.54284343e-01f, 8.82916451e-02f, -9.36190858e-02f, -1.08922804e-02f, -1.47635490e-01f, 6.30841181e-02f,
  2.25344211e-01f, -1.79561377e-01f, 7.54034296e-02f, 5.65455332e-02f, -8.08008984e-02f, -7.40617588e-02f, -3.43747474e-02f, -3.58438045e-02f, -1.19836144e-01f, -1.51193161e-02f,
  3.63953337e-02f, 1.95981249e-01f, -1.22961245e-01f, 3.94785106e-02f, 1.59685984e-01f, 4.18244340e-02f, 1.58721864e-01f, 5.36829419e-02f, -4.27414253e-02f, 2.33666855e-03f,
  -1.03112787e-03f, -9.62692276e-02f, -3.37901153e-02f, -7.93251395e-02f, 4.72555496e-02f, 2.26161666e-02f, 3.95313697e-03f, 3.59969214e-02f, -3.51029448e-02f, 1.51440213e-02f,
  7.29161203e-02f, -5.96012585e-02f, -3.17846201e-02f, -2.65899058e-02f, -7.12281838e-02f, -2.92124916e-02f, -5.96226789e-02f, 1.72201842e-02f, -7.81603381e-02f, -1.79991722e-02f,
  -3.81260775e-02f, 5.66151105e-02f, 3.61798890e-02f, -1.49149159e-02f, -8.44252780e-02f, -2.82356665e-02f, -6.63185641e-02f, 1.51798682e-04f, 9.01270285e-02f, -6.09019436e-02f,
  6.39076978e-02f, 6.66836426e-02f, 5.50905652e-02f, -1.80648640e-02f, -1.17206253e-01f, 2.05894094e-02f, -1.46388458e-02f, 1.01116173e-01f, -2.73866579e-03f, -4.20322530e-02f,
  1.43088223e-02f, -6.43412694e-02f, 1.97950136e-02f, 5.37742674e-02f, -6.36868253e-02f, -3.35229486e-02f, 1.45321060e-03f, 4.70140390e-02f, -3.42109874e-02f, -3.67023721e-02f,
  4.05794941e-03f, 5.37665635e-02f, -7.21240267e-02f, 4.29201201e-02f, 4.63340543e-02f, 6.89382432e-03f, -2.85025146e-02f, -1.56423487e-02f, 1.51330046e-02f, 5.40703870e-02f,
  1.47693623e-02f, -1.06860034e-01f, -1.18092462e-01f, -1.14637099e-01f, -1.13576800e-01f, -6.99269548e-02f, -1.02751911e-01f, 8.19804892e-02f, 1.78476737e-03f, -7.60976374e-02f,
  -1.64931659e-02f, 5.78086153e-02f, 5.05749919e-02f, 9.34781879e-02f, 1.39404219e-02f, -1.70039982e-02f, -1.64277088e-02f, -1.46433776e-02f, 7.71698877e-02f, -4.04145084e-02f,
  5.67736626e-02f, 2.89186630e-02f, -2.23506019e-02f, -3.44900563e-02f, 6.45660162e-02f, -1.88765097e-02f, 1.00136865e-02f, -1.67967640e-02f, 5.11670932e-02f, -6.17853217e-02f,
  -1.44316569e-01f, 8.54875222e-02f, -1.95019051e-01f, 1.19567728e-02f, -2.02335209e-01f, -1.15207084e-01f, -1.08762473e-01f, 9.35748667e-02f, 1.45589530e-01f, 3.22944313e-01f,
  1.64430171e-01f, 1.73462834e-02f, -7.48934736e-03f, 1.61956131e-01f, -2.91685343e-01f, 7.84843042e-02f, 1.56011898e-02f, 7.93513935e-03f, -6.35976270e-02f, -4.75528277e-02f,
  -1.47696421e-01f, 8.34556967e-02f, -1.69084951e-01f, -3.16343904e-02f, -1.80945724e-01f, -4.43997085e-02f, 1.22963395e-02f, -1.47736669e-01f, -1.65244061e-02f, 2.48876736e-02f,
  5.19025624e-02f, 8.03460479e-02f, 2.75922325e-02f, -1.17058028e-02f, -2.54593361e-02f, -1.22816585e-01f, -2.54384205e-02f, -1.93935297e-02f, -4.58458029e-02f, 1.45069975e-02f,
  -3.25151421e-02f, -6.02042582e-03f, -1.17569575e-02f, 4.26422209e-02f, -2.64505967e-02f, 3.11271334e-03f, 1.29064657e-02f, -2.60746423e-02f, -6.42962381e-02f, -3.01867016e-02f,
  5.67248538e-02f, -7.50637501e-02f, -9.40229893e-02f, 4.81603332e-02f, -8.44642743e-02f, 7.01648146e-02f, 5.68870194e-02f, -3.19641382e-02f, 8.39766189e-02f, 1.29942307e-02f,
  7.09448680e-02f, -8.15742835e-02f, -3.94894220e-02f, 6.05438612e-02f, -4.32232022e-02f, 4.84367944e-02f, 2.32477803e-02f, -1.60553493e-02f, 3.43607068e-02f, -3.77696604e-02f,
  -4.84517552e-02f, 6.53325906e-03f, 2.05510519e-02f, -8.55369680e-03f, 7.94398114e-02f, 7.40480572e-02f, -7.11547062e-02f, -8.30281060e-03f, 3.67683731e-02f, 7.12516233e-02f,
  4.64588292e-02f, -3.55485044e-02f, 9.98416692e-02f, 7.57351378e-03f, 5.15041091e-02f, -1.21769898e-01f, 4.35004868e-02f, 5.01346849e-02f, -1.09512359e-02f, -5.97398877e-02f,
  7.15889856e-02f, 2.26881117e-01f, 1.57443006e-02f, 4.31417394e-03f, -2.15630792e-02f, -3.64277698e-02f, -3.02781984e-02f, -2.73523983e-02f, -1.59869045e-02f, 2.40761172e-02f,
  3.02045681e-02f, 2.78076138e-02f, -5.75955547e-02f, -7.52303004e-02f, -1.76742300e-02f, 1.10798940e-01f, -7.58363679e-03f, 1.04668429e-02f, 1.39099741e-02f, 5.90465404e-03f,
  -6.46338090e-02f, 1.01073883e-01f, 1.48250489e-04f, -4.83071171e-02f, 6.63769022e-02f, 5.01220077e-02f, 1.63369961e-02f, 3.72404680e-02f, -1.06844552e-01f, 4.28574011e-02f,
  1.65433064e-01f, 1.89742446e-02f, -1.15958139e-01f, 1.54267564e-01f, 1.85829103e-01f, -1.38195092e-02f, -2.46041611e-01f, 1.72709182e-01f, -5.02403937e-02f, -1.01402387e-01f,
  1.05335139e-01f, -1.27652258e-01f, -2.42638052e-01f, -3.24745104e-02f, -1.24074318e-01f, -1.89681679e-01f, 4.19880040e-02f, -8.18584189e-02f, 2.89224312e-02f, 1.20945878e-01f,
  8.28724429e-02f, 2.18423232e-01f, 3.50544825e-02f, 2.75773108e-01f, 1.49937734e-01f, 8.32217187e-02f, 2.41655111e-01f, 4.25562151e-02f, 1.36540800e-01f, -6.18528016e-02f,
  -6.13124818e-02f, 7.62153883e-04f, -8.95469487e-02f, 1.07624652e-02f, 1.16518907e-01f, 2.91630924e-02f, -6.04419596e-02f, -4.56371754e-02f, -4.47849371e-02f, -3.94288674e-02f,
  -2.41351593e-02f, 2.00273823e-02f, 6.44572303e-02f, -5.40292403e-03f, -3.97661030e-02f, -7.61541054e-02f, 3.15046720e-02f, -3.06315888e-02f, 1.96687002e-02f, 1.81694925e-02f,
  -5.41227125e-02f, -3.33464169e-03f, -5.94697781e-02f, 1.00098085e-02f, 1.02097146e-01f, -4.03790362e-02f, -1.08897291e-01f, -3.02955564e-02f, 4.75984663e-02f, -1.38989286e-02f,
  4.88144420e-02f, -2.68715508e-02f, 7.04651475e-02f, -2.79894006e-02f, 8.00452381e-02f, 8.48642066e-02f, -6.40360042e-02f, 5.24530150e-02f, -4.85939309e-02f, 7.51183331e-02f,
  1.02526106e-01f, 1.39078368e-02f, 3.23447119e-03f, 1.38083985e-02f, -7.50797987e-03f, 6.49630849e-04f, 3.04149576e-02f, 3.19922231e-02f, 3.13073769e-02f, -3.32660112e-03f,
  -4.64482941e-02f, -1.51010249e-02f, 3.66735943e-02f, 1.02358731e-02f, -3.60953212e-02f, 1.29039520e-02f, 9.03726965e-02f, 9.55860037e-03f, 2.92207059e-02f, 3.54724675e-02f,
  1.51215196e-01f, 1.84119612e-01f, 2.16132626e-02f, 3.71738449e-02f, -7.36029968e-02f, 9.80316661e-03f, 9.68475360e-03f, 4.49925587e-02f, -4.09703776e-02f, 6.43013716e-02f,
  8.87387171e-02f, -6.43850267e-02f, 1.35308519e-01f, 4.05271202e-02f, -8.22903663e-02f, 3.22650969e-02f, -4.07545688e-03f, 5.30174328e-03f, 5.32748103e-02f, -1.95493083e-02f,
  2.34197043e-02f, -1.20517407e-02f, 5.24767907e-03f, 8.60299394e-02f, -5.28795365e-03f, 3.34350788e-03f, -4.82025882e-03f, 5.42751662e-02f, 6.63781017e-02f, -4.96658236e-02f,
  -3.56405973e-01f, 1.47161325e-02f, -2.74377838e-02f, -1.56366065e-01f, -1.18762694e-01f, 5.21885268e-02f, 1.24609873e-01f, -1.76693067e-01f, -4.01465371e-02f, -5.73527850e-02f,
  -7.67721096e-04f, 5.07225282e-02f, 1.12477399e-01f, -3.51054454e-03f, 1.52026951e-01f, 9.11165923e-02f, -2.09832918e-02f, 6.56351298e-02f, -6.62253127e-02f, -1.52180642e-01f,
  1.70236658e-02f, -3.83129939e-02f, 8.18264857e-02f, -9.12309960e-02f, -2.05152586e-01f, -2.16669142e-01f, -8.02622512e-02f, -2.60350481e-02f, -9.88966748e-02f, -3.00020389e-02f,
  -1.30650610e-01f, -2.06405729e-01f, 5.28727584e-02f, -4.98566851e-02f, -4.37767357e-02f, -6.54539140e-03f, -6.70832023e-02f, 1.17406845e-01f, 6.09282106e-02f, -6.55606166e-02f,
  3.90998535e-02f, 2.27341577e-02f, 5.57817705e-02f, 9.08737257e-02f, -6.50409833e-02f, -2.20678132e-02f, 5.19842803e-02f, -2.23004948e-02f, 3.57844457e-02f, 4.06803116e-02f,
  6.41149729e-02f, 5.03429882e-02f, -4.54226695e-02f, -1.39070314e-03f, 7.77709065e-03f, 3.03631127e-02f, -2.68192813e-02f, -5.48144020e-02f, -5.20531759e-02f, -4.37238347e-03f,
  4.78692427e-02f, 4.34370637e-02f, 6.49253130e-02f, 8.20311904e-02f, 8.26210529e-02f, -1.30772255e-02f, 2.44829264e-02f, 7.08216354e-02f, 1.08271716e-02f, -1.21816304e-02f,
  3.40204723e-02f, -3.09653785e-02f, -6.01125024e-02f, 5.67502044e-02f, -1.55205578e-02f, -5.55985495e-02f, 2.50040721e-02f, -6.83425739e-02f, 3.01125203e-03f, -2.00254805e-02f,
  4.69920076e-02f, -3.34310271e-02f, -1.79445371e-02f, -1.56540144e-02f, -3.35178822e-02f, 4.23177183e-02f, 4.05482650e-02f, -5.17005250e-02f, -3.50385010e-02f, 5.01110256e-02f,
  -3.74004170e-02f, -1.71438619e-01f, 5.14811501e-02f, -3.33463252e-02f, 4.32363078e-02f, 5.92127722e-03f, -1.84247866e-02f, 1.76582895e-02f, -2.50864998e-02f, -4.05117981e-02f,
  -7.49238282e-02f, -2.95009855e-02f, 4.85879369e-02f, 1.46508552e-02f, -4.02757861e-02f, -3.41341794e-02f, -4.27068025e-02f, -9.22496393e-02f, -5.64178303e-02f, -7.18789250e-02f,
  2.64611915e-02f, -6.25038054e-03f, 1.02094486e-01f, -8.65829363e-02f, -2.98825819e-02f, -1.45202074e-02f, -8.29451308e-02f, 6.69755563e-02f, 9.17082280e-03f, 3.71959582e-02f,
  1.21252745e-01f, -8.93371627e-02f, 1.51148498e-01f, 2.58406430e-01f, 1.86914788e-03f, -1.94115862e-01f, -8.01398158e-02f, -2.12626420e-02f, 4.16801311e-03f, -1.81305036e-01f,
  5.52302673e-02f, 1.96264148e-01f, -3.56424749e-02f, 1.28672883e-01f, 1.98370174e-01f, -5.26887551e-02f, 3.21503505e-02f, -8.97406191e-02f, 8.52902606e-02f, -2.14856602e-02f,
  6.70077950e-02f, 9.61291343e-02f, 1.73007637e-01f, 1.33727327e-01f, 5.82746379e-02f, 1.67986333e-01f, 1.52077153e-01f, 1.19601235e-01f, 1.06603466e-01f, 9.05144587e-02f,
  -4.95911799e-02f, 5.77015802e-02f, -9.89110209e-03f, 1.77341998e-02f, -8.05338174e-02f, -5.23152761e-02f, 2.17931569e-02f, 1.37077451e-01f, 9.35973302e-02f, -4.36194129e-02f,
  -2.03177184e-02f, 6.67696213e-03f, -9.25246850e-02f, 3.88965383e-02f, -2.75098495e-02f, 9.90992486e-02f, 4.65572216e-02f, 2.72998791e-02f, 4.97915111e-02f, -6.44828752e-02f,
  -9.26428735e-02f, 1.20876078e-02f, -1.00138791e-01f, 4.84669171e-02f, 9.76594910e-03f, -1.88982226e-02f, -2.12080835e-04f, 1.74780786e-02f, -7.79464543e-02f, -1.96135845e-02f,
  -2.30122004e-02f, 4.81573008e-02f, 2.20934618e-02f, -2.78708506e-02f, 7.90471025e-03f, -3.38531397e-02f, 1.90907996e-02f, 5.33928722e-02f, -4.59345803e-03f, -3.00321896e-02f,
  -5.36532402e-02f, 2.05635410e-02f, 3.10824439e-02f, -1.45404087e-02f, 2.60104593e-02f, -4.61183712e-02f, -2.80044861e-02f, -7.53216222e-02f, -8.03434253e-02f, 1.09760631e-02f,
  2.83176508e-02f, 4.14577611e-02f, -1.20183593e-02f, -4.92585115e-02f, 1.12809405e-01f, 4.08793539e-02f, -1.29787317e-02f, -7.41100833e-02f, 3.14944834e-02f, -7.10135251e-02f,
  -1.37559518e-01f, 7.45031908e-02f, 5.59369009e-03f, 4.46889214e-02f, -7.39273662e-03f, -8.39970708e-02f, 3.98017131e-02f, 1.41460923e-02f, 2.18013804e-02f, 1.09474091e-02f,
  -9.43274982e-03f, -2.36039236e-02f, 3.83003205e-02f, 2.88539547e-02f, 8.27920884e-02f, -3.40413526e-02f, -5.56711890e-02f, -4.66923974e-03f, 6.08597137e-02f, 4.25113394e-04f,
  -1.17422584e-02f, 7.05339387e-03f, 8.98906961e-03f, 2.79094838e-02f, 6.50426513e-03f, 4.14656363e-02f, -4.83019948e-02f, -2.63388138e-02f, 2.35952083e-02f, 2.90160645e-02f
};

// L0_fan_Wp_bar (Shape: 14 x 120)
const int L0_fan_Wp_bar_rows = 14;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -7.90961832e-02f, -6.80626333e-02f, -2.04392403e-01f, -1.35100350e-01f, -5.17064184e-02f, -2.19942778e-01f, -3.49260747e-01f, -8.92954320e-02f, -5.64145893e-02f, -4.55330722e-02f,
  -7.95547664e-02f, -1.22091779e-02f, 8.23720247e-02f, -1.24074742e-01f, 6.72612935e-02f, 1.32651374e-01f, -2.21957475e-01f, -1.55841455e-01f, 8.59019607e-02f, -7.29757324e-02f,
  -1.18660806e-02f, -4.30265777e-02f, -9.95412692e-02f, -1.13096582e-02f, -9.96184051e-02f, 1.76729504e-02f, -2.25735120e-02f, -8.38243142e-02f, -6.42002150e-02f, -8.11798126e-02f,
  9.10978019e-03f, -7.85190314e-02f, 2.58934610e-02f, 3.48199718e-02f, -3.46238427e-02f, -1.09363727e-01f, -1.42492563e-01f, 4.10854556e-02f, 6.31556585e-02f, -1.00756558e-02f,
  -7.58266225e-02f, 7.70476386e-02f, -1.54724875e-02f, 5.49487434e-02f, -4.70719784e-02f, -5.26292995e-02f, 3.02305678e-03f, -1.92116760e-02f, 3.81556638e-02f, 3.44618317e-03f,
  -2.16649491e-02f, 3.76610197e-02f, -7.68242925e-02f, 9.17554572e-02f, -5.53709269e-02f, -6.71440884e-02f, -9.07291248e-02f, 3.82524692e-02f, -3.17618363e-02f, 9.14252456e-03f,
  -9.78491921e-03f, 4.82793860e-02f, -5.55359311e-02f, 7.07081892e-03f, 2.33569611e-02f, 2.11450458e-02f, -1.96787268e-02f, 1.85881127e-02f, -9.42356512e-03f, 5.18630899e-04f,
  2.39634444e-03f, -3.10843773e-02f, -4.65822319e-04f, -1.01641580e-01f, -2.90930048e-02f, 5.20105623e-02f, 1.20021313e-01f, -7.90912062e-02f, 1.62436198e-02f, -3.93092558e-02f,
  4.01176699e-02f, 3.00071370e-02f, -4.57083695e-02f, 1.99761372e-02f, -4.05617207e-02f, -7.76043674e-03f, -3.53755690e-02f, 2.89207119e-02f, -3.08636669e-02f, 3.43416147e-02f,
  -9.78438854e-02f, -8.92166048e-02f, -3.01896762e-02f, -8.72843564e-02f, -6.11487357e-03f, -1.02165103e-01f, 2.49641165e-02f, 5.03643267e-02f, -4.13383842e-02f, -2.19373591e-02f,
  -7.48054013e-02f, 4.04672474e-02f, 2.86822170e-02f, 1.59326177e-02f, -9.00194701e-03f, -1.04652673e-01f, -3.99282090e-02f, -3.63008678e-02f, 2.57555507e-02f, -1.19471122e-02f,
  -3.79270464e-02f, 1.09738365e-01f, 2.69270204e-02f, -3.31059173e-02f, 3.01853511e-02f, -2.06261780e-02f, -2.06239335e-02f, -8.65022838e-02f, -6.59039095e-02f, -1.61534585e-02f,
  -1.32506397e-02f, 1.04593873e-01f, -8.07716548e-02f, -2.86066920e-01f, 5.62439449e-02f, -6.34378642e-02f, -3.06374822e-02f, 4.38303500e-02f, -1.56033725e-01f, 2.62482762e-01f,
  5.65642715e-02f, 1.17252514e-01f, 1.77570488e-02f, -2.70951629e-01f, -3.70690584e-01f, -2.52838671e-01f, -1.68376431e-01f, 2.06936747e-02f, -8.88506770e-02f, 2.90059522e-02f,
  -1.31916672e-01f, -1.52473584e-01f, -1.48080558e-01f, 3.59788239e-02f, 9.42252874e-02f, 2.47169808e-01f, 2.23589778e-01f, 5.85979521e-02f, 1.36474967e-01f, -2.75826100e-02f,
  -1.91791207e-02f, -3.15628760e-02f, -2.44430285e-02f, -6.94629252e-02f, 5.50639071e-02f, 5.66980913e-02f, 6.17089607e-02f, 6.37868047e-03f, 4.19041887e-03f, -4.81913127e-02f,
  2.00481173e-02f, 4.25702706e-02f, -3.22934147e-03f, 2.33452693e-02f, 4.67478018e-03f, 4.02927138e-02f, -4.60616946e-02f, 1.42148966e-02f, 9.59111564e-03f, -6.60088956e-02f,
  -7.69098401e-02f, 8.80341139e-03f, -2.83460151e-02f, 1.56599190e-02f, 2.53676297e-03f, 1.82601195e-02f, 2.57924777e-02f, 3.16637978e-02f, 7.53834397e-02f, -6.90296292e-02f,
  4.51095700e-02f, 9.03003439e-02f, -8.19504932e-02f, 2.21136454e-02f, 2.58673299e-02f, -1.75784286e-02f, -3.86464735e-03f, -3.26090157e-02f, -7.08671054e-03f, -4.68940325e-02f,
  1.65253934e-02f, 3.00843880e-04f, -5.71495444e-02f, 7.99201280e-02f, 1.49704767e-02f, 4.02995013e-02f, 7.66625851e-02f, -4.70379554e-02f, -3.44257504e-02f, -4.74674423e-04f,
  5.43254912e-02f, -5.47505170e-02f, 1.53966723e-02f, 5.32646962e-02f, 1.59778912e-02f, -1.08814560e-01f, 2.97744777e-02f, -3.08456589e-02f, 3.92853841e-02f, 5.86052462e-02f,
  3.11718713e-02f, 8.26647952e-02f, 5.16974889e-02f, 1.36222020e-02f, 4.00426388e-02f, 6.50804490e-02f, -6.84929937e-02f, -6.21768795e-02f, -2.78091766e-02f, 2.29166318e-02f,
  9.39226821e-02f, 7.93502107e-02f, 6.13934807e-02f, 4.84274924e-02f, -4.05005626e-02f, 1.02220420e-02f, 5.47576277e-03f, -1.33985293e-03f, -4.21985053e-02f, 5.09708263e-02f,
  1.05679817e-01f, -7.29773100e-03f, -1.53114405e-02f, 4.53881035e-03f, 1.24650083e-01f, 1.56093240e-01f, 3.87581773e-02f, 4.66270465e-03f, -2.59525254e-02f, 1.65097226e-05f,
  7.52321631e-02f, 1.07166260e-01f, -5.59096560e-02f, 7.50726163e-02f, 3.12374462e-03f, 6.28760457e-02f, -5.71843237e-02f, 1.34678343e-02f, 1.97225749e-01f, 5.46427891e-02f,
  -1.24654025e-01f, 2.24471152e-01f, 1.11939795e-02f, -4.60388325e-02f, -5.18986844e-02f, 2.91209575e-02f, 1.22897893e-01f, 2.21953660e-01f, 1.19875357e-01f, -1.39416188e-01f,
  -1.05250895e-01f, -5.88646866e-02f, -2.18243614e-01f, -1.77495167e-01f, -1.07920803e-01f, -6.36108369e-02f, -1.76149279e-01f, -1.82928648e-02f, -6.28805393e-03f, 4.69694398e-02f,
  6.27559498e-02f, 3.11033186e-02f, -7.16459900e-02f, 3.46455239e-02f, -6.64507449e-02f, 4.18324722e-03f, 5.27317747e-02f, 7.49958679e-02f, -2.07531583e-02f, 1.20709859e-01f,
  -3.07173897e-02f, 1.97657514e-02f, 1.62714437e-01f, -6.69975355e-02f, -8.63636509e-02f, 2.09799074e-02f, -4.55939770e-03f, -4.93045431e-03f, 4.16859910e-02f, -6.33725598e-02f,
  -7.50736892e-02f, -6.71338737e-02f, -6.52634725e-02f, -2.63318215e-02f, -6.65601864e-02f, 6.26607090e-02f, 1.61713898e-01f, 4.41542156e-02f, 6.55031390e-03f, 1.19252622e-01f,
  1.82871465e-02f, 9.65573266e-02f, -4.96790148e-02f, -1.22222364e-01f, -5.07642701e-02f, -1.46316569e-02f, -4.82495651e-02f, 7.95029178e-02f, 4.77681942e-02f, -4.09569852e-02f,
  4.98013105e-04f, -6.35828227e-02f, -4.97994162e-02f, -6.11858536e-03f, 4.14059162e-02f, -2.73893140e-02f, -1.52308904e-02f, 3.43140699e-02f, 2.12948881e-02f, 4.46401211e-03f,
  2.15354245e-02f, 1.57425215e-03f, 4.44624946e-02f, -4.12734374e-02f, 1.07194871e-01f, -8.46999437e-02f, -2.00509839e-02f, -8.54265168e-02f, -6.02141768e-02f, -8.88635144e-02f,
  1.68767706e-01f, 2.17775881e-01f, -2.26018559e-02f, 2.02944595e-02f, -4.11406048e-02f, -2.17429437e-02f, 9.15132537e-02f, 1.09583713e-01f, 1.51269332e-01f, -3.46654165e-03f,
  4.79361117e-02f, -4.57107235e-04f, 1.23147853e-02f, -1.68165732e-02f, 4.82504033e-02f, 3.59296352e-02f, 5.39917033e-04f, -1.16363943e-01f, -1.92953292e-02f, -1.18605919e-01f,
  -1.44870535e-01f, 1.14930354e-01f, 2.89214011e-02f, -1.54093970e-02f, -8.52903724e-03f, 3.55604701e-02f, 1.08494528e-01f, 3.69822532e-02f, -6.24607131e-02f, 1.70425847e-02f,
  -8.56270492e-02f, -4.71633151e-02f, -1.62192971e-01f, -1.55111626e-01f, -1.14972398e-01f, -1.63573638e-01f, -1.85455739e-01f, -1.14515178e-01f, 3.84862646e-02f, 2.65423562e-02f,
  -1.62689105e-01f, 5.94512820e-02f, 1.34958386e-01f, 2.55442481e-03f, 7.30434805e-02f, 7.42884204e-02f, -1.13408513e-01f, 2.45850347e-02f, -4.24586125e-02f, -1.78018689e-01f,
  -2.74552461e-02f, -1.44551128e-01f, 9.35472101e-02f, -1.67963021e-02f, -1.64296985e-01f, -1.15725622e-02f, 1.01907320e-01f, -1.75117642e-01f, -5.09563349e-02f, -5.18636219e-02f,
  -1.76510699e-02f, -3.61818112e-02f, -5.31200357e-02f, 5.91452383e-02f, -4.12759744e-02f, 3.44330003e-03f, -1.21092215e-01f, -9.18181799e-03f, -3.55142727e-02f, 9.88085419e-02f,
  6.08319640e-02f, -1.91077646e-02f, 7.33878687e-02f, 7.42163435e-02f, 1.43726552e-02f, 6.78890990e-03f, 4.60745841e-02f, -1.92430709e-02f, -5.41040003e-02f, -4.80385832e-02f,
  -4.83317003e-02f, -7.48447776e-02f, -4.39049006e-02f, 9.28275436e-02f, 3.01189777e-02f, -2.10547727e-02f, 1.01082161e-01f, 4.78455462e-02f, -6.52720630e-02f, -7.13544115e-02f,
  -7.46357953e-03f, -2.29049232e-02f, -4.01818566e-02f, -1.01628378e-02f, -4.13678624e-02f, 7.82219991e-02f, 2.96571432e-03f, 6.78183138e-02f, -7.34525248e-02f, 8.44662488e-02f,
  1.54629886e-01f, -1.78074557e-02f, 8.53037462e-02f, -3.66248819e-03f, 6.78311149e-03f, -6.28334582e-02f, 7.41825700e-02f, 4.90713157e-02f, 1.03258207e-01f, 5.60976863e-02f,
  1.81200299e-02f, 2.30969060e-02f, 6.78960085e-02f, 5.69580821e-03f, -4.50375415e-02f, -2.88808066e-02f, 6.80993274e-02f, 3.00210458e-03f, 3.24737541e-02f, -1.06224291e-01f,
  -6.37253225e-02f, -1.10263586e-01f, -4.96752448e-02f, -5.91140129e-02f, -6.51133480e-03f, -2.46397313e-02f, 3.87577154e-02f, -3.04787997e-02f, -1.57209020e-02f, -9.43776518e-02f,
  -9.31348354e-02f, 4.20095399e-02f, 2.76811030e-02f, -4.75536734e-02f, 2.08048616e-02f, -5.67843243e-02f, -4.94080782e-03f, 4.71510775e-02f, -1.30642876e-01f, -5.25732525e-02f,
  5.38193546e-02f, -8.18616077e-02f, 1.14806302e-01f, 1.51684899e-02f, -6.12013862e-02f, -7.67281651e-02f, -6.93010613e-02f, -1.25967674e-02f, -5.03851771e-02f, -4.06506658e-02f,
  2.64330149e-01f, 2.58222759e-01f, 2.00233161e-01f, 2.17751592e-01f, -1.13174699e-01f, -1.81897417e-01f, -1.71901613e-01f, 4.76081520e-02f, -1.24300405e-01f, -1.44316517e-02f,
  1.52858431e-02f, 2.02138096e-01f, 1.01643959e-02f, 6.37804866e-02f, -6.84265122e-02f, -1.14048369e-01f, 8.20841566e-02f, -5.06766178e-02f, -1.05736226e-01f, 1.35808975e-01f,
  9.19976830e-02f, -6.43714294e-02f, 2.36121774e-01f, 4.82728630e-02f, 3.88657041e-02f, 2.33443782e-01f, 1.84974119e-01f, 9.90515724e-02f, 2.21795037e-01f, -1.06379621e-01f,
  -8.39449018e-02f, 2.54514627e-03f, 4.97976393e-02f, 3.32605503e-02f, -2.18709055e-02f, 1.30779417e-02f, 3.92607599e-02f, -7.31364861e-02f, -4.34409119e-02f, -1.09981941e-02f,
  -1.73335988e-02f, 5.64834196e-03f, -1.09055951e-01f, 7.47302920e-02f, -7.20196813e-02f, 2.87495144e-02f, 4.70380560e-02f, 5.06353215e-04f, -3.72721478e-02f, 1.14278309e-01f,
  8.50856379e-02f, -3.77412699e-02f, 4.11616685e-03f, 8.82698596e-02f, 9.62510407e-02f, 3.61638479e-02f, -2.28800066e-02f, 5.52546084e-02f, 8.34718570e-02f, -1.13790343e-02f,
  2.86392495e-02f, -4.31674458e-02f, -2.67593991e-02f, -7.99284130e-02f, 3.70621160e-02f, -5.61171845e-02f, -4.92598973e-02f, -3.19068208e-02f, -4.25660126e-02f, -3.38121550e-03f,
  -8.37944169e-03f, 5.97294457e-02f, -1.44885629e-01f, 2.56406255e-02f, 2.34146956e-02f, -5.00139184e-02f, 4.67504002e-03f, -5.92326522e-02f, 6.22207597e-02f, 3.77386436e-02f,
  -7.94630498e-02f, -1.27616245e-02f, -2.67505459e-02f, -3.88947912e-02f, 2.34419312e-02f, 4.27008495e-02f, -3.33879292e-02f, 5.14983609e-02f, 1.75399669e-02f, -7.36151114e-02f,
  -9.95335542e-03f, 1.66220605e-01f, 2.22514924e-02f, -1.60586033e-02f, 3.93782891e-02f, -3.49944830e-02f, -8.58841613e-02f, 6.17820509e-02f, 2.99293529e-02f, -4.95802835e-02f,
  5.57629988e-02f, 3.43660563e-02f, 2.39769593e-02f, -4.23398577e-02f, 1.10352658e-01f, 3.27583067e-02f, -2.48827110e-03f, 7.73756206e-02f, 9.30719972e-02f, 1.34920552e-02f,
  6.32406548e-02f, -2.36153752e-02f, 2.42253039e-02f, -4.21155728e-02f, 2.12797839e-02f, 2.49687824e-02f, 4.30004448e-02f, 9.91711020e-02f, -1.39611755e-02f, -3.79457399e-02f,
  -8.81840140e-02f, 4.65269340e-03f, -1.34653270e-01f, -1.70753598e-01f, -1.29530355e-01f, -1.86753765e-01f, -1.03555553e-01f, -5.00016585e-02f, -4.61672358e-02f, -8.18522424e-02f,
  -1.14695288e-01f, 1.08586244e-01f, 1.18586794e-01f, -1.37543440e-01f, 1.07644610e-01f, 1.57688558e-01f, -1.22926503e-01f, -5.59630282e-02f, 4.46790904e-02f, -1.21564321e-01f,
  3.71450260e-02f, -1.52519211e-01f, 2.86310818e-03f, -2.00749617e-02f, -1.06378376e-01f, -4.54273298e-02f, 7.99982250e-02f, 9.42331553e-03f, -5.89883551e-02f, -3.42806205e-02f,
  -1.38309449e-01f, -1.72951519e-01f, -1.65114939e-01f, -1.29526993e-02f, -1.04517341e-01f, 8.01249593e-03f, -7.55703673e-02f, -2.46464438e-03f, -7.18624517e-02f, -2.40809731e-02f,
  -6.87426254e-02f, -8.83257091e-02f, -5.36530241e-02f, -6.70152009e-02f, -6.41092360e-02f, -1.07367309e-02f, 2.34814398e-02f, 1.17873354e-02f, -9.03301314e-03f, 1.66036412e-02f,
  -4.14245762e-02f, 2.61390507e-02f, -1.04370661e-01f, -1.30718844e-02f, -1.35839786e-02f, -5.55745251e-02f, 2.52979621e-02f, 1.00753255e-01f, -5.93803823e-02f, -2.87544373e-02f,
  -2.53398195e-02f, -1.14265129e-01f, -5.28392680e-02f, -4.02200259e-02f, -9.09809992e-02f, -1.08454302e-01f, -1.55932844e-01f, 2.74140062e-03f, 1.95982829e-02f, -3.32207009e-02f,
  -3.29969004e-02f, -3.29401391e-03f, 8.69811885e-03f, 4.08003740e-02f, 1.62476283e-02f, 4.18959856e-02f, -4.99797016e-02f, -1.04449660e-01f, -5.58118410e-02f, 1.38955623e-01f,
  -9.38361511e-02f, -5.43362182e-03f, -5.13652675e-02f, -4.69874442e-02f, -2.92147547e-02f, 9.39554349e-02f, -6.09455407e-02f, -4.67772670e-02f, -9.27357841e-03f, -9.24560707e-04f,
  -1.78101078e-01f, -2.01583147e-01f, -6.60356060e-02f, -9.63567644e-02f, -1.02826841e-02f, 1.28805637e-01f, 1.80870220e-02f, 4.80065607e-02f, -7.03550056e-02f, -4.72532026e-02f,
  5.73369339e-02f, 3.54567878e-02f, 4.38187458e-02f, -3.32690962e-02f, 3.44003998e-02f, 6.19695932e-02f, 1.10304430e-01f, 1.42205462e-01f, -5.80082461e-02f, -9.22531337e-02f,
  -6.54346272e-02f, -1.13648642e-02f, 5.97654246e-02f, -4.84478697e-02f, 1.05896518e-01f, -8.44758470e-03f, -1.55508919e-02f, -2.62839496e-02f, 2.97537297e-02f, 2.88533363e-02f,
  1.39427453e-01f, -3.24995257e-02f, -1.47780105e-01f, -1.18153594e-01f, -1.48824751e-01f, -2.64234364e-01f, -2.80811638e-01f, -1.64073318e-01f, 5.99209741e-02f, 2.72978749e-03f,
  2.01056432e-02f, -5.07996194e-02f, 7.18214437e-02f, -2.23449886e-01f, 9.82961580e-02f, 2.44035468e-01f, -2.68547505e-01f, -1.36842787e-01f, -1.15191527e-02f, -2.58948877e-02f,
  1.76012404e-02f, -9.50162858e-03f, -1.05987571e-01f, -4.47872393e-02f, -1.57893851e-01f, 8.89415145e-02f, 6.12017550e-02f, -1.16730608e-01f, -1.41356990e-01f, -4.37234491e-02f,
  1.87522434e-02f, 5.37621081e-02f, -7.82034248e-02f, 8.43187198e-02f, 2.22853757e-02f, -5.54820411e-02f, -1.18993476e-01f, 8.71336758e-02f, 1.85481422e-02f, 4.57026996e-02f,
  -1.27461348e-02f, 8.18098933e-02f, 7.08723888e-02f, -1.82696115e-02f, -2.17485465e-02f, 1.74192209e-02f, 8.83266702e-02f, -6.09184913e-02f, 1.68413632e-02f, -3.77216004e-02f,
  -2.69585801e-03f, -5.80339022e-02f, -1.17722332e-01f, -2.33680680e-02f, -5.36501035e-02f, 4.28523235e-02f, -2.12133974e-02f, 4.31326441e-02f, -1.30215855e-02f, -5.16226888e-02f,
  3.85384411e-02f, 8.03696439e-02f, -4.43692617e-02f, -1.99960135e-02f, -3.51863764e-02f, -4.19970453e-02f, 2.07992829e-02f, 6.71243519e-02f, -5.50097898e-02f, 2.40280032e-02f,
  3.76527570e-02f, -9.20265075e-03f, 1.55499568e-02f, -1.08543234e-02f, 6.64218375e-03f, 4.13740948e-02f, -7.73098832e-03f, 5.07823527e-02f, -1.48954198e-01f, -1.57914739e-02f,
  7.06500262e-02f, 4.09536064e-02f, 6.21006545e-03f, 1.25585152e-02f, -6.12728558e-02f, 3.00407540e-02f, -2.37441920e-02f, -5.11311777e-02f, 5.36013134e-02f, 2.80245524e-02f,
  -1.07904650e-01f, 1.68594569e-02f, 8.17219689e-02f, -4.00501713e-02f, -5.47209242e-03f, -7.21477941e-02f, -3.22905779e-02f, 1.30463019e-02f, -4.55480330e-02f, -6.06753752e-02f,
  -4.38599549e-02f, 2.41616182e-02f, -6.09665662e-02f, 6.82643428e-02f, -3.23481448e-02f, -1.41056538e-01f, 3.36246602e-02f, 3.94758247e-02f, -3.86939161e-02f, 9.43115726e-02f,
  -3.45736393e-03f, 2.85892859e-02f, 1.22423366e-01f, -3.68749201e-02f, 8.70800838e-02f, 2.61303503e-02f, -2.48100460e-02f, -2.48986967e-02f, 9.60611831e-03f, -8.39473084e-02f,
  1.65851310e-01f, 3.07256669e-01f, 2.56215423e-01f, 1.39312401e-01f, -1.73930943e-01f, -3.99239630e-01f, -2.65215665e-01f, -2.14856993e-02f, -4.32578139e-02f, -9.19890404e-03f,
  -1.01411767e-01f, 3.11425865e-01f, -3.45404074e-02f, 1.61894083e-01f, -2.55220950e-01f, -8.96009952e-02f, -1.39003813e-01f, 1.32046655e-01f, 1.08401887e-02f, 5.42849360e-04f,
  1.50128985e-02f, -1.61800519e-01f, -3.69262812e-03f, -3.33276428e-02f, 8.14938173e-02f, 2.55216718e-01f, -3.81060317e-02f, -5.31532839e-02f, 1.00822479e-01f, -2.66363118e-02f,
  -4.38998155e-02f, -1.77539531e-02f, 7.94277564e-02f, 2.42684130e-02f, -4.01897244e-02f, 5.06709795e-03f, -4.27008197e-02f, 4.07459709e-04f, -4.52807471e-02f, -6.61787391e-02f,
  -1.53422030e-02f, -1.00066364e-01f, -1.65822497e-03f, 5.24097793e-02f, -4.62008119e-02f, 7.89076760e-02f, -5.34260049e-02f, 8.61126706e-02f, 1.33329958e-01f, 1.08511768e-01f,
  1.24953620e-01f, 8.90886337e-02f, 9.00286250e-03f, 1.56746930e-04f, -2.73593049e-02f, 7.44168907e-02f, -6.19558431e-02f, 6.45790547e-02f, 7.11729005e-02f, -5.43809980e-02f,
  -1.07584549e-02f, 1.78455412e-02f, -1.65408745e-03f, 5.14556505e-02f, 4.91171479e-02f, -1.68770049e-02f, 6.22234941e-02f, -1.15308631e-02f, -7.26478696e-02f, -1.04847863e-01f,
  1.60715543e-02f, 7.96173606e-03f, 2.90737469e-02f, 6.13910798e-03f, 1.43658342e-02f, -7.19095871e-04f, -3.77573958e-03f, 4.16133367e-03f, -1.15138412e-01f, -6.45639747e-02f,
  -4.25583422e-02f, -3.19583714e-02f, 5.72925918e-02f, -3.43536399e-02f, -3.89287993e-02f, 1.75457209e-01f, -2.66241785e-02f, 6.97252378e-02f, 3.77151966e-02f, 2.21481025e-02f,
  -9.08254310e-02f, 3.48720956e-03f, -5.21542281e-02f, -1.02440655e-01f, -6.00330345e-02f, -4.94328067e-02f, 9.68897901e-03f, -5.84789738e-02f, -5.59482761e-02f, -3.15192491e-02f,
  -7.13945134e-03f, -7.59022832e-02f, 2.46121846e-02f, -3.22663225e-02f, -1.48722343e-02f, -3.43331285e-02f, 2.71435101e-02f, -4.07363847e-02f, -5.74553646e-02f, 4.26404700e-02f,
  6.20569773e-02f, 1.21340342e-02f, -4.73186001e-02f, 1.94434375e-02f, -5.89936599e-02f, -1.04157038e-01f, 1.99826760e-03f, 9.48680472e-03f, -1.01788817e-02f, 4.83895913e-02f,
  2.10972637e-01f, -1.27916681e-02f, 2.85721701e-02f, -3.15648108e-03f, 1.30954146e-01f, -2.43873857e-02f, -1.81222800e-02f, -3.44212949e-02f, 1.08968958e-01f, -3.55241746e-02f,
  -4.99607623e-02f, 1.09417150e-02f, -1.19992211e-01f, -4.65317592e-02f, -2.96637505e-01f, -1.52257010e-01f, -1.30067557e-01f, 9.28986967e-02f, 7.80882537e-02f, 1.49954902e-02f,
  -2.84351520e-02f, -1.17300965e-01f, -5.38045354e-02f, 1.10877715e-01f, 2.30171829e-01f, 3.46596614e-02f, -9.05659199e-02f, -5.40142618e-02f, 7.02811182e-02f, -1.21947937e-01f,
  3.90330963e-02f, -3.66493613e-02f, 4.28613424e-02f, -9.69248116e-02f, -5.54485731e-02f, 7.91215617e-03f, -8.91312025e-03f, -3.13287675e-02f, 1.46745052e-02f, 8.04674253e-02f,
  -6.74561560e-02f, 2.18260959e-02f, 6.44409508e-02f, 7.15313405e-02f, -4.77684401e-02f, 8.18931237e-02f, 1.41766429e-01f, 9.77229774e-02f, -2.30407491e-02f, 1.33224651e-02f,
  1.06956817e-01f, -1.42922895e-02f, -3.32260318e-03f, 7.25794360e-02f, -2.94014495e-02f, -4.62960154e-02f, 1.65337160e-01f, 5.96574843e-02f, 5.64790666e-02f, 5.33541739e-02f,
  5.98641708e-02f, 3.64720635e-02f, 5.73883802e-02f, -3.03368196e-02f, 5.13244569e-02f, 9.76814404e-02f, 3.69578227e-02f, 5.65396138e-02f, 2.66049467e-02f, -7.40441829e-02f,
  2.76676361e-02f, -3.11723258e-02f, 3.57290506e-02f, 7.91834667e-02f, -5.69808744e-02f, 7.16456771e-02f, -6.54675737e-02f, -1.83173567e-02f, -8.94831400e-03f, 1.07014596e-01f,
  1.16392419e-01f, -2.91595012e-02f, -5.16143665e-02f, -4.02577072e-02f, -1.19897090e-01f, 3.28472964e-02f, -2.85092834e-03f, -5.04491404e-02f, -8.88780504e-03f, 8.22633207e-02f,
  -2.24400714e-01f, -2.11457700e-01f, -5.65952770e-02f, 4.75835353e-02f, 5.18857688e-02f, -4.82948981e-02f, 6.89266324e-02f, 2.56413501e-02f, -3.54037322e-02f, 5.62155768e-02f,
  2.07719356e-02f, -4.11711261e-02f, 1.98445693e-02f, -5.16202413e-02f, -1.45566696e-02f, -2.04184577e-02f, -1.09382935e-01f, -4.47099991e-02f, -6.39983043e-02f, 9.78451222e-03f,
  1.68317687e-02f, -9.01327468e-03f, 6.70982525e-03f, -5.23244180e-02f, 9.24041271e-02f, 1.40063958e-02f, -3.39300446e-02f, 4.41963831e-03f, -2.28088517e-02f, -7.96434134e-02f,
  1.31512195e-01f, 3.43407653e-02f, -1.62216634e-01f, 1.81186050e-01f, -5.31440862e-02f, -3.68060768e-02f, -9.87625197e-02f, 8.47441778e-02f, -1.53314114e-01f, 1.62930727e-01f,
  1.26942769e-01f, 5.39833866e-02f, -4.30070125e-02f, 3.65474820e-01f, 2.10509822e-01f, 3.34213348e-03f, 2.32937619e-01f, 1.44618109e-01f, -5.99225424e-02f, 1.03163838e-01f,
  2.30824966e-02f, 2.40601569e-01f, 9.03950557e-02f, 8.23705792e-02f, 6.25798553e-02f, -6.62585273e-02f, 1.31832033e-01f, -1.03552341e-01f, 2.24914834e-01f, 1.61980465e-01f,
  9.81529802e-02f, -5.02155311e-02f, -1.67185199e-02f, -2.33752914e-02f, -6.52557164e-02f, -7.29128793e-02f, -1.24218510e-02f, -6.24677986e-02f, -8.39069858e-02f, -5.15668504e-02f,
  4.58077202e-03f, 5.89656867e-02f, 9.14108157e-02f, -4.88718636e-02f, 6.06479086e-02f, -4.12453040e-02f, -3.09826229e-02f, -3.31643224e-03f, -4.40318249e-02f, -8.09968486e-02f,
  -1.43401921e-01f, -6.83066025e-02f, 3.04800487e-04f, -6.33642077e-02f, 3.49591263e-02f, 1.00505687e-01f, -9.23235416e-02f, 3.70084774e-04f, 2.27154829e-02f, 2.16056146e-02f,
  -4.37330687e-03f, -1.70282405e-02f, -3.38239372e-02f, 4.22715768e-02f, -1.19125478e-01f, 1.84279270e-02f, 3.00110374e-02f, -9.17097628e-02f, -8.29223320e-02f, -8.28459039e-02f,
  1.25145065e-02f, 3.06588989e-02f, 7.96963423e-02f, -3.73481475e-02f, -4.37284783e-02f, 6.60443865e-03f, -6.20626360e-02f, 8.67474973e-02f, -2.59894822e-02f, -6.47761449e-02f,
  3.70024629e-02f, 4.25825901e-02f, 6.61507100e-02f, -4.40208688e-02f, -2.95597110e-02f, 1.96381882e-02f, 1.41888440e-01f, 3.76203321e-02f, -1.58931613e-02f, 1.48885222e-02f,
  3.05273719e-02f, -4.87527577e-03f, -1.53843407e-02f, -1.73538364e-02f, 3.52196284e-02f, 6.38155341e-02f, 1.14104867e-01f, -2.41850503e-02f, 6.75073192e-02f, 2.65029725e-02f,
  2.91163325e-02f, -6.45995885e-02f, 5.45022152e-02f, 3.82766798e-02f, -6.42035678e-02f, 4.80914153e-02f, 9.92881209e-02f, -7.64702167e-03f, 9.38493013e-03f, -4.88623008e-02f,
  -2.32103523e-02f, -9.38148797e-02f, -4.86098900e-02f, -1.10807113e-01f, 1.62592828e-02f, -3.26324180e-02f, -9.24185887e-02f, -6.55153319e-02f, 4.61456291e-02f, -7.86998570e-02f,
  2.80790925e-01f, 1.98445141e-01f, 3.82721536e-02f, 1.09704912e-01f, -1.31933853e-01f, -3.43336258e-03f, -1.19488336e-01f, -4.17418592e-02f, 2.62699068e-01f, 7.44283125e-02f,
  -1.83654681e-01f, 3.11963230e-01f, 1.05802782e-01f, -1.25420347e-01f, 1.33241177e-01f, 9.56946984e-02f, 8.46921504e-02f, 4.20664400e-02f, 4.04766686e-02f, 1.13051571e-01f,
  1.87137201e-02f, -9.36091989e-02f, -1.38543695e-01f, -1.33502811e-01f, -1.30412564e-01f, -1.79730535e-01f, -2.15113953e-01f, -8.92425254e-02f, -1.74372181e-01f, -9.86093208e-02f,
  -3.59563641e-02f, 8.42583999e-02f, 7.88684841e-03f, 8.20714328e-03f, -7.72958156e-03f, 4.41449583e-02f, 4.24398892e-02f, -2.91109961e-02f, -5.96909747e-02f, -5.11442311e-03f,
  1.41063288e-01f, -5.21215610e-03f, -6.98293792e-03f, 5.41421846e-02f, -2.10018996e-02f, 3.61035299e-03f, 5.38718998e-02f, -1.94739923e-02f, 2.25478243e-02f, 2.00536381e-02f,
  1.84867252e-02f, -2.66659521e-02f, -6.59795702e-02f, -4.88787033e-02f, 9.65364724e-02f, -3.14133130e-02f, -2.92904656e-02f, 1.41614033e-02f, -4.61534038e-02f, -1.17199402e-03f,
  6.74043819e-02f, 1.81645062e-02f, -5.15867881e-02f, -2.28759851e-02f, -1.92652866e-02f, -6.52478561e-02f, 8.45568553e-02f, -1.87430636e-03f, 7.96721689e-03f, -8.63917544e-02f,
  -2.96005718e-02f, -5.57669103e-02f, -7.17296526e-02f, 8.38002563e-02f, 8.45838040e-02f, -8.55995342e-02f, 3.75261977e-02f, -4.01407480e-02f, 9.67096388e-02f, 1.79490708e-02f,
  2.00584363e-02f, 7.44247762e-03f, 7.11530633e-03f, -3.77784818e-02f, -6.91207126e-02f, 6.57728240e-02f, -3.27013992e-02f, -7.09429197e-03f, -2.32210215e-02f, -2.11642636e-03f,
  4.03858311e-02f, 1.68125689e-01f, 1.09966323e-02f, -3.12282350e-02f, 8.74666497e-02f, -5.33832349e-02f, 4.99682641e-03f, 5.52628189e-02f, 2.34901961e-02f, -1.54824380e-03f,
  -4.93178479e-02f, 6.80551305e-03f, 1.22395992e-01f, 1.44096930e-02f, 2.90898383e-02f, -8.66989866e-02f, -6.94396868e-02f, 4.16550823e-02f, -2.53904983e-02f, 1.00698970e-01f,
  -2.58262735e-02f, 9.43856314e-02f, 4.01285142e-02f, -6.64895475e-02f, 6.82703033e-03f, -7.56278485e-02f, -1.22034829e-02f, -3.22323963e-02f, 7.34494179e-02f, 9.48151872e-02f,
  1.45678565e-01f, -2.19649106e-01f, -1.82117745e-01f, 1.09165981e-01f, 9.83803198e-02f, 1.39321014e-01f, -9.66807380e-02f, 5.83866276e-02f, -8.02870020e-02f, -6.52480423e-02f,
  1.19713070e-02f, -1.26912415e-01f, -2.31413916e-01f, 5.60496934e-02f, -5.35207940e-03f, -2.06353649e-01f, 7.53144920e-02f, 4.56377454e-02f, -7.40765501e-03f, -1.11664414e-01f,
  1.33545890e-01f, 1.84675500e-01f, -1.78365931e-02f, 1.03127398e-01f, 1.36204576e-02f, 1.48278385e-01f, 9.48282555e-02f, 1.56857446e-02f, 2.29534999e-01f, -3.28619704e-02f,
  8.86214375e-02f, -1.86748430e-02f, -4.58000042e-02f, 3.43792401e-02f, 4.74036066e-03f, -2.18117144e-03f, -3.95618975e-02f, -2.82736793e-02f, 7.78306276e-02f, -8.72441679e-02f,
  3.68790980e-03f, 4.65836041e-02f, -7.04441741e-02f, 1.03235781e-01f, 1.96544118e-02f, -1.20819025e-02f, -1.23424530e-01f, -4.93948609e-02f, -7.27545470e-02f, 5.57310668e-05f,
  -1.41662076e-01f, -6.85161799e-02f, -7.95318261e-02f, -1.41649703e-02f, -1.16968323e-02f, -1.87320132e-02f, 8.75601545e-02f, 2.94478517e-02f, -9.08637866e-02f, 6.57969341e-02f,
  4.35701534e-02f, -4.93444838e-02f, 6.67227581e-02f, 1.55754304e-02f, -4.22437899e-02f, -4.50324640e-02f, 6.75336421e-02f, 1.58622116e-03f, -7.60264620e-02f, -7.53661618e-02f,
  2.43089371e-03f, -2.83886176e-02f, -8.49139988e-02f, 5.77837117e-02f, -1.06587512e-02f, 5.89715242e-02f, 4.06645946e-02f, -5.38285710e-02f, -8.62725265e-03f, -2.38818694e-02f,
  4.09135446e-02f, -4.29609194e-02f, -5.72335944e-02f, 5.69566898e-02f, -5.15693091e-02f, -1.09199304e-02f, 8.39389116e-02f, -1.06784534e-02f, -4.35670279e-02f, 7.23335221e-02f,
  -2.26221676e-03f, -8.01050290e-02f, -7.08184391e-02f, 1.19374827e-01f, -4.62343208e-02f, 6.59836158e-02f, -6.32865727e-03f, 9.30748433e-02f, -4.22220752e-02f, 7.53234178e-02f,
  4.35097441e-02f, -7.21923858e-02f, 7.28029162e-02f, -3.68734337e-02f, 6.87290728e-02f, 4.92321290e-02f, -6.87771812e-02f, -4.71917726e-03f, -1.34013027e-01f, -2.96505485e-02f,
  4.74358574e-02f, -7.55184069e-02f, -6.76640570e-02f, 8.43409076e-03f, 4.47986536e-02f, -1.58030652e-02f, -4.41167131e-02f, 6.86355978e-02f, -7.84914792e-02f, -3.54503989e-02f,
  -4.94617790e-01f, 1.77306667e-01f, -1.54635936e-01f, -1.61087051e-01f, 5.00148907e-02f, -1.29160717e-01f, -1.13777518e-01f, -1.81475014e-03f, -1.58138335e-01f, 1.42558441e-01f,
  1.27967238e-01f, -1.97252244e-01f, 1.17948443e-01f, -1.13478422e-01f, -3.28172117e-01f, -4.45248149e-02f, -1.50433496e-01f, -7.36815557e-02f, -4.02594693e-02f, 8.94340724e-02f,
  3.06834783e-02f, 8.49134400e-02f, -6.41249493e-02f, 3.25648755e-01f, 5.98104438e-03f, -8.21864582e-04f, -1.14198411e-02f, 1.28250867e-01f, -7.15063885e-02f, -1.24700002e-01f,
  -9.77733880e-02f, 1.10196650e-01f, 1.77016389e-02f, 1.20423706e-02f, -1.19067959e-01f, 4.53868369e-03f, -6.58996478e-02f, -2.57473048e-02f, -7.72607848e-02f, -4.80904542e-02f,
  -3.47289369e-02f, 7.75726810e-02f, -7.37944394e-02f, -4.85587977e-02f, 7.13687539e-02f, -5.50950095e-02f, 1.27093121e-01f, -1.91679306e-03f, 8.48815739e-02f, -4.20816131e-02f,
  2.04042848e-02f, 5.03429212e-03f, 4.28411737e-02f, -9.56724659e-02f, 2.31414400e-02f, 8.48124772e-02f, 4.49301302e-03f, -3.82168368e-02f, -4.21493948e-02f, -1.09518558e-01f,
  2.61847451e-02f, 5.56314029e-02f, -5.75364232e-02f, 4.49059643e-02f, 1.95765588e-02f, 1.29285395e-01f, -3.75940613e-02f, -3.94934751e-02f, 4.15809080e-02f, -2.18297523e-02f,
  -9.08401161e-02f, 3.80624905e-02f, -3.93794328e-02f, -1.12660741e-03f, -3.72167714e-02f, -1.87123977e-02f, 5.01357950e-02f, -9.81757697e-03f, 1.41549846e-02f, -1.08176039e-03f,
  -1.23618077e-02f, 7.34172901e-03f, 1.32277654e-02f, -3.44181154e-03f, -2.51533482e-02f, 5.09087294e-02f, -2.95974426e-02f, 1.55033255e-02f, -2.66615096e-02f, -1.12366252e-01f,
  -2.97824852e-02f, -3.18796821e-02f, -3.42473537e-02f, 6.90514967e-02f, -2.31410027e-03f, -8.84100199e-02f, -1.16398325e-02f, 3.30376346e-03f, -5.54255955e-02f, -1.04141787e-01f,
  4.41391543e-02f, 7.40693090e-03f, 6.38897195e-02f, 5.20334952e-02f, 1.81571562e-02f, -7.95193240e-02f, -3.70583832e-02f, -5.32958135e-02f, -7.79166371e-02f, 2.18225922e-02f,
  -3.00325342e-02f, 2.62626782e-02f, 2.62417626e-02f, 7.30500324e-03f, -7.28549510e-02f, -9.49659795e-02f, -1.21339865e-01f, -5.31754792e-02f, 2.48423368e-02f, 1.64191071e-02f,
  -1.08016528e-01f, -5.14317639e-02f, -1.22505315e-01f, 1.35607898e-01f, -1.60666481e-01f, -1.23224311e-01f, -4.96706702e-02f, -2.91172173e-02f, -9.91744101e-02f, 7.88323581e-02f,
  2.47524157e-02f, 1.06187716e-01f, 1.22783834e-03f, 3.19092602e-01f, 5.83293103e-02f, 1.27425134e-01f, 1.94356173e-01f, 1.51497871e-01f, 2.84043197e-02f, 6.33719042e-02f,
  8.83893147e-02f, 2.72566319e-01f, 2.41046593e-01f, 1.52721629e-01f, 1.50465831e-01f, -6.72530085e-02f, 2.18100280e-01f, -6.15603440e-02f, 1.71543986e-01f, 1.09010704e-01f,
  -1.23085946e-01f, -1.30848140e-02f, -4.33612242e-02f, -3.34529318e-02f, -1.20615747e-04f, 1.60806871e-03f, 2.58640926e-02f, 1.72093417e-02f, -7.39890710e-02f, 1.60528987e-03f,
  -9.67842713e-02f, -6.60170913e-02f, 1.74399484e-02f, 1.13718053e-02f, -9.65914801e-02f, -8.37261528e-02f, 5.12738526e-03f, -1.38867674e-02f, -9.56771374e-02f, -3.03945802e-02f,
  -1.15223318e-01f, 3.94840539e-03f, -3.39689180e-02f, 9.02486518e-02f, 6.76036254e-02f, -5.38858697e-02f, 7.15337768e-02f, -6.46973178e-02f, -3.16212364e-02f, -7.16193859e-03f,
  -2.41039484e-03f, 7.52009973e-02f, -9.36537758e-02f, 3.34709696e-02f, -5.14773317e-02f, 7.63986483e-02f, -1.55465901e-02f, -3.26563306e-02f, 1.30694672e-01f, 7.37316087e-02f,
  -9.82327014e-02f, 4.10850979e-02f, -8.76286346e-03f, -6.25936463e-02f, -3.71626839e-02f, -4.92351651e-02f, 2.40602531e-02f, 6.70431107e-02f, -9.50932950e-02f, 1.21891825e-02f,
  7.10784048e-02f, -1.28798354e-02f, 4.53707613e-02f, 6.04729056e-02f, -9.41407979e-02f, 7.91328326e-02f, 1.28152675e-03f, 9.50424969e-02f, -4.28600833e-02f, 5.11829145e-02f,
  -1.82776541e-01f, -1.53912734e-02f, 7.86785269e-04f, -3.82060483e-02f, -8.67670178e-02f, -3.53805758e-02f, 9.20295343e-02f, 1.40428152e-02f, 6.74653947e-02f, -5.47920540e-02f,
  2.17656940e-02f, -9.80734476e-04f, -7.06734359e-02f, 2.80646756e-02f, 3.58131877e-03f, 4.21383791e-02f, -2.20307317e-02f, 1.01228645e-02f, 9.62277874e-02f, -2.15008184e-02f,
  -1.34646539e-02f, 3.36481333e-02f, 7.75326565e-02f, -3.93374525e-02f, 8.88716653e-02f, 6.56758696e-02f, -3.61802010e-03f, -2.40237433e-02f, 4.58770804e-02f, 4.31755185e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 14)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 14;
const float L0_fan_Bp_bar_data[] = {
  -3.08665093e-02f, 4.01580147e-02f, 1.60383999e-01f, -8.05865526e-02f, 7.28873909e-02f, 8.17438215e-02f, -3.19925584e-02f, 7.49458969e-02f, 5.76072149e-02f, 9.15396586e-02f,
  2.22443715e-01f, -5.26694171e-02f, 2.26898164e-01f, 1.34751648e-01f
};

// L1_fan_Wp (Shape: 25 x 64)
const int L1_fan_Wp_rows = 25;
const int L1_fan_Wp_cols = 64;
const float L1_fan_Wp_data[] = {
  9.25435647e-02f, -8.64483267e-02f, 1.77196771e-01f, 1.46387145e-02f, 1.34859057e-02f, 6.04809560e-02f, -1.09428018e-01f, -1.09934196e-01f, 6.88151419e-02f, 1.37027696e-01f,
  -1.14844091e-01f, 7.21909478e-02f, -4.96442467e-02f, 5.94874751e-03f, -1.63250700e-01f, -8.31817910e-02f, -5.41567393e-02f, 6.35605752e-02f, 1.97359119e-02f, 8.82901326e-02f,
  -1.09609969e-01f, -1.67349309e-01f, 8.50055292e-02f, 1.06564283e-01f, 7.57850036e-02f, -1.37455419e-01f, -4.89548668e-02f, 1.75862581e-01f, 1.12653673e-01f, -6.24435488e-03f,
  8.86028111e-02f, 2.33951956e-02f, -1.77347913e-01f, 7.65354708e-02f, -1.06344834e-01f, 8.10693204e-02f, -5.38324006e-02f, -7.93268010e-02f, 1.92737147e-01f, 1.83447674e-01f,
  9.82041061e-02f, 4.84070480e-02f, -1.33522376e-01f, -2.52653062e-01f, 1.82513837e-02f, -1.55826822e-01f, 2.04159409e-01f, -5.28481342e-02f, 2.05671713e-02f, -1.45753115e-01f,
  9.36003104e-02f, 5.23465276e-02f, 1.90353006e-01f, 5.04088663e-02f, -9.26638767e-02f, -5.03325909e-02f, 1.30869731e-01f, 2.37373665e-01f, 2.03133091e-01f, 3.47783007e-02f,
  1.93689037e-02f, -3.96369621e-02f, 2.03260913e-01f, 1.15148630e-02f, -1.39696389e-01f, -2.12066799e-01f, -1.66295350e-01f, 1.63406804e-01f, -2.27589756e-01f, 1.37014493e-01f,
  -1.58176020e-01f, 4.60795313e-02f, -2.82867309e-02f, 7.61095760e-03f, 1.26100883e-01f, 1.05949920e-02f, -6.98504522e-02f, -3.71328592e-02f, 1.09702893e-01f, -1.57224223e-01f,
  1.37607351e-01f, 1.82014003e-01f, -6.20024279e-02f, 7.07908645e-02f, 4.12560105e-02f, 5.55469934e-03f, -1.03402928e-01f, -7.32786134e-02f, 1.49088167e-02f, 1.68100283e-01f,
  -4.03332144e-01f, 5.22903912e-02f, 6.32533291e-03f, -7.85205215e-02f, -1.87929608e-02f, 1.85178444e-01f, 8.53601396e-02f, 1.13657646e-01f, -1.76631391e-01f, 9.00077522e-02f,
  -5.01335524e-02f, -2.86665440e-01f, -1.46097288e-01f, -1.90226495e-01f, -1.28782988e-01f, 8.30452368e-02f, 1.61410775e-02f, 2.88580321e-02f, 4.10772525e-02f, 3.23640347e-01f,
  1.66704699e-01f, 7.12558851e-02f, 4.54210378e-02f, -1.29473835e-01f, -2.24707648e-01f, 1.77162036e-01f, -1.40160486e-01f, -1.02266744e-01f, -4.34877872e-02f, -1.42353848e-02f,
  -8.55594948e-02f, -3.03828388e-01f, -6.34225830e-02f, 1.52509972e-01f, -8.18011910e-02f, 2.27327228e-01f, -3.10036354e-03f, 5.88433929e-02f, -2.38791686e-02f, 1.25285760e-01f,
  -3.28952037e-02f, -1.17842332e-01f, -5.71971722e-02f, -5.46913184e-02f, 1.54086441e-01f, -5.51804714e-02f, -5.75446337e-02f, 1.33713856e-01f, -1.15428604e-01f, 9.88037959e-02f,
  9.24072713e-02f, -4.52178381e-02f, 1.70081016e-02f, -1.26484931e-01f, 3.34965810e-02f, -6.27444461e-02f, -4.36671562e-02f, -2.21914914e-03f, -8.67106020e-02f, -2.32953522e-02f,
  -1.39900520e-01f, 4.05476317e-02f, -1.48623995e-02f, -2.20924079e-01f, 4.12410982e-02f, 1.64959297e-01f, -8.11987370e-02f, -1.16783217e-01f, 4.31529991e-02f, 4.20725308e-02f,
  -3.11954528e-01f, 1.18478067e-01f, -7.65941739e-02f, 2.06495196e-01f, -1.62507966e-01f, -1.56630073e-02f, 1.55477062e-01f, -1.03016861e-01f, 2.91861892e-01f, -6.15565963e-02f,
  -5.62640950e-02f, -1.57658279e-01f, 1.32332072e-01f, -6.08477816e-02f, 1.94528043e-01f, 1.20527118e-01f, 6.85729086e-03f, -8.43526125e-02f, 1.33310020e-01f, -6.80330321e-02f,
  8.02073404e-02f, -1.14335772e-02f, 1.75355136e-01f, 1.35829687e-01f, 1.47658035e-01f, -5.21502942e-02f, -1.00508720e-01f, 1.36456087e-01f, 7.61050060e-02f, -1.57314494e-01f,
  9.26508382e-02f, 1.31575242e-01f, 1.35598660e-01f, -1.09870307e-01f, 2.27778368e-02f, -9.22644064e-02f, -2.48927642e-02f, -9.79669169e-02f, -7.50815570e-02f, 8.59813839e-02f,
  -3.74387130e-02f, -1.09646939e-01f, -1.14094280e-01f, 1.38832241e-01f, -5.09615839e-02f, -3.28472890e-02f, -1.15201131e-01f, 5.64351603e-02f, -1.59511305e-02f, -2.56672222e-02f,
  -2.83148922e-02f, 6.79728016e-02f, -2.74866819e-02f, -9.10414681e-02f, -6.62669465e-02f, -5.05742766e-02f, 1.91505387e-01f, 6.39731511e-02f, -3.49025577e-01f, 2.74853349e-01f,
  6.79824799e-02f, -2.82229036e-01f, 1.90421522e-01f, 3.03885639e-01f, 2.28510518e-02f, 1.72098249e-01f, -1.47745281e-01f, 1.93396017e-01f, -1.69706032e-01f, -2.05013007e-02f,
  9.27413329e-02f, -1.14705712e-01f, 1.08208038e-01f, -1.41186222e-01f, 1.57835767e-01f, -1.65670440e-01f, 7.23272339e-02f, 3.22038949e-01f, 1.40099660e-01f, 3.08821678e-01f,
  5.09861186e-02f, -1.55649140e-01f, 9.22391191e-02f, 4.89192940e-02f, -3.47954929e-02f, -7.21844472e-03f, -1.89296812e-01f, 1.06941044e-01f, 4.89906110e-02f, -3.90551575e-02f,
  1.93943605e-02f, 7.99808651e-02f, -2.95397639e-01f, -3.65719432e-03f, 2.01029822e-01f, -6.72151819e-02f, 8.80024061e-02f, -1.06978185e-01f, 2.53101252e-03f, 1.31018832e-01f,
  -2.76233908e-02f, -1.16647214e-01f, 1.17964365e-01f, -5.96412271e-02f, -7.70443082e-02f, -7.27442950e-02f, -5.13640270e-02f, -1.79233328e-01f, 6.60915375e-02f, -6.89466223e-02f,
  1.17899321e-01f, -1.35596976e-01f, 4.71784957e-02f, 2.27893591e-02f, -1.02690712e-01f, -1.29692420e-01f, 7.59479553e-02f, -7.68867210e-02f, -5.22691049e-02f, -1.54244192e-02f,
  -1.23196699e-01f, 1.37351425e-02f, -8.23057592e-02f, 1.42471775e-01f, -1.46597117e-01f, 2.11113706e-01f, -8.93336684e-02f, -1.67408258e-01f, -1.47717655e-01f, -2.17837002e-02f,
  1.36154532e-01f, 9.72535312e-02f, 2.11878717e-02f, -1.15426861e-01f, -6.44820407e-02f, -1.80956274e-01f, 1.35798410e-01f, 8.07217360e-02f, -1.20558515e-01f, 2.73806080e-02f,
  1.36683643e-01f, 5.34445383e-02f, 6.79696649e-02f, 1.95245855e-02f, 6.02006912e-02f, 6.18100986e-02f, -9.67212394e-02f, -1.36103585e-01f, -1.47363544e-01f, -1.71372101e-01f,
  1.24547891e-01f, -1.71222135e-01f, -1.33838251e-01f, -9.46175978e-02f, -4.02828632e-03f, 1.73256546e-01f, -1.10980652e-01f, 1.80921614e-01f, -2.18770746e-02f, 2.01331452e-01f,
  -2.82003116e-02f, -1.46706477e-01f, -5.87563217e-02f, -1.13819733e-01f, 1.47966295e-01f, 6.88589290e-02f, 1.18591832e-02f, -2.31781602e-01f, -1.78799435e-01f, 8.33963677e-02f,
  1.55070955e-02f, -5.57018220e-02f, -1.34405270e-01f, 5.68579324e-02f, -1.50796205e-01f, -6.25835359e-02f, 9.35394913e-02f, -1.41569167e-01f, -1.08353682e-02f, -4.19447795e-02f,
  -1.10182250e-02f, -1.66607156e-01f, -2.37152323e-01f, -1.04303434e-01f, -7.74559528e-02f, 2.45473571e-02f, -2.45151535e-01f, 7.23832771e-02f, -7.49349594e-02f, -1.19380109e-01f,
  -6.22168332e-02f, 1.07679047e-01f, -6.98025674e-02f, -6.01640008e-02f, -1.38267517e-01f, 2.06229687e-01f, -5.03969155e-02f, -3.39028090e-01f, 6.26858696e-02f, -1.53499618e-01f,
  1.97033957e-02f, -1.02509953e-01f, 5.42291207e-03f, 7.32690766e-02f, 4.67639081e-02f, 9.06501785e-02f, 2.93108486e-02f, -8.99799615e-02f, 1.78402767e-01f, 1.55107990e-01f,
  1.12726361e-01f, -2.80702531e-01f, 4.55675200e-02f, 4.80049327e-02f, 8.36912394e-02f, 1.61272317e-01f, 2.01510891e-01f, -5.71680218e-02f, -1.45730153e-01f, 2.94674635e-01f,
  -8.26357529e-02f, 1.72848165e-01f, -3.00531179e-01f, 2.19517440e-01f, 8.66174698e-02f, -4.93176877e-02f, -9.91357490e-02f, 3.46676409e-02f, 7.62480944e-02f, 1.11274943e-01f,
  9.67518799e-03f, 1.49740919e-01f, 1.19254567e-01f, -5.18657155e-02f, 6.62684366e-02f, 1.88412499e-02f, 1.19619310e-01f, 6.39548583e-04f, 3.50629650e-02f, -3.40861939e-02f,
  -1.37909418e-02f, 6.48037530e-03f, 8.57747495e-02f, 1.80464089e-02f, 6.89618662e-02f, 1.24800310e-01f, 4.34963815e-02f, 1.61315262e-01f, 1.18742034e-01f, -4.43760632e-03f,
  -5.97744137e-02f, 1.06701553e-01f, -2.15575516e-01f, 3.94290388e-02f, -6.68732375e-02f, -2.62172490e-01f, -1.12924939e-02f, -2.54122689e-02f, 2.39868984e-01f, -1.15059964e-01f,
  1.56541705e-01f, -9.67612211e-03f, -1.67685181e-01f, 2.59620082e-02f, -1.87569447e-02f, 1.39732942e-01f, -1.56497523e-01f, 8.96527320e-02f, 7.14203268e-02f, 1.63353249e-01f,
  -1.44095063e-01f, 1.16386734e-01f, -1.19523913e-01f, 1.04350187e-01f, -7.84460008e-02f, 1.20495237e-01f, 2.48023439e-02f, -2.22806394e-01f, 1.54097244e-01f, -2.89793760e-01f,
  5.15132248e-02f, -9.11592990e-02f, 1.71977520e-01f, 1.37513399e-01f, 1.24084897e-01f, 1.36405498e-01f, -3.76707688e-02f, -1.22127920e-01f, 6.78152964e-02f, -1.43492162e-01f,
  -9.23862979e-02f, -4.50623175e-03f, 1.24537878e-01f, 1.05852671e-01f, -3.79944667e-02f, -1.62265282e-02f, 3.63022313e-02f, 3.77108827e-02f, 1.12181686e-01f, -8.37441683e-02f,
  7.56851360e-02f, -9.21625569e-02f, -6.15561530e-02f, -1.22734673e-01f, 5.22491448e-02f, -6.39801994e-02f, 1.15348138e-02f, -1.49074674e-03f, -7.77827278e-02f, 5.10981940e-02f,
  -5.76264486e-02f, -7.50335827e-02f, -1.46440223e-01f, 2.09945664e-01f, -7.29001760e-02f, -1.65351629e-01f, 5.61069660e-02f, 4.60234694e-02f, -1.49697676e-01f, 1.87143534e-02f,
  2.15666771e-01f, -2.62494355e-01f, 1.00821733e-01f, -2.06731603e-01f, 1.20463878e-01f, -1.97475441e-02f, -3.06100231e-02f, -6.06956612e-03f, -2.97660440e-01f, 6.37426972e-02f,
  -1.30598828e-01f, 2.50119358e-01f, 1.28528610e-01f, 1.43950686e-01f, -2.24103570e-01f, -1.75014049e-01f, -5.29510574e-03f, 1.13104038e-01f, -8.55666474e-02f, -1.26678318e-01f,
  -3.41737159e-02f, -7.48335272e-02f, -1.14921026e-01f, 5.65179661e-02f, -1.90148149e-02f, -4.85875234e-02f, 2.54021510e-02f, -3.54939513e-02f, -1.02150984e-01f, 5.92147419e-03f,
  -1.59135327e-01f, 5.50171919e-02f, -6.64298534e-02f, -6.81062415e-02f, 6.73537329e-02f, 1.52535081e-01f, -3.73277999e-02f, 1.90361068e-01f, -9.48470458e-03f, -2.50979271e-02f,
  4.17326242e-02f, 5.41937463e-02f, -9.04207975e-02f, -2.95571657e-03f, -2.83787353e-03f, 1.82912365e-01f, 2.68572807e-01f, -5.51614445e-03f, 2.08618566e-02f, 5.43022640e-02f,
  6.47253990e-02f, -4.80863899e-02f, -2.05738079e-02f, -2.93761343e-02f, 2.92151626e-02f, 8.22194070e-02f, -1.36074141e-01f, -1.05056472e-01f, 2.70727766e-03f, -3.09018672e-01f,
  9.06167179e-02f, -3.31731252e-02f, -1.74157217e-01f, 1.80444077e-01f, 1.58097029e-01f, 1.24323905e-01f, -8.20799917e-02f, -2.24736184e-02f, 7.96832889e-02f, -2.30424657e-01f,
  -2.28424564e-01f, -1.80925071e-01f, 4.61633812e-04f, -1.38197467e-01f, 1.67077214e-01f, 1.01113394e-01f, -1.58741176e-02f, -1.33700639e-01f, -7.29613304e-02f, -1.65262759e-01f,
  2.55559385e-01f, 5.53403236e-02f, -2.13759512e-01f, -3.46187592e-01f, -3.81793119e-02f, -8.23905393e-02f, -2.47709662e-01f, 9.02527273e-02f, -2.73226887e-01f, -3.12342793e-01f,
  -9.28223580e-02f, -4.58884910e-02f, -1.63410716e-02f, 8.18734765e-02f, -2.15750054e-01f, -1.42343147e-02f, 7.23876478e-03f, -1.34161189e-01f, -1.15480185e-01f, -1.14174470e-01f,
  1.27457559e-01f, 1.61525526e-03f, 6.47299215e-02f, -2.32992098e-01f, -5.09318225e-02f, 1.15733352e-02f, 3.14408843e-03f, -1.77364677e-01f, -1.01630718e-01f, 9.06457845e-03f,
  -2.46244948e-02f, -1.65030584e-01f, -1.28669232e-01f, -1.79543480e-01f, -1.09054431e-01f, -7.50744045e-02f, 2.09998358e-02f, -5.02690934e-02f, -2.73061514e-01f, -2.19940990e-01f,
  -1.44731179e-01f, -2.03280244e-02f, -1.17653258e-01f, -1.27134487e-01f, 6.10195994e-02f, 1.01926148e-01f, -1.52411804e-01f, 7.44248703e-02f, -1.30760118e-01f, 3.19284690e-03f,
  -2.13623047e-02f, -4.94419225e-02f, -1.16310529e-01f, -1.39074862e-01f, 6.72590360e-02f, -4.78006527e-02f, -9.39647481e-02f, -9.91052538e-02f, -6.46440834e-02f, 8.58065262e-02f,
  2.09812298e-01f, -7.95840174e-02f, 7.39132911e-02f, 9.59022120e-02f, 5.48113883e-02f, 1.56259969e-01f, 2.99507212e-02f, -1.71007857e-01f, -1.85715958e-01f, 1.15601860e-01f,
  1.28421471e-01f, 1.49535984e-01f, 1.59094349e-01f, 1.06941745e-01f, -6.26545846e-02f, 1.80442080e-01f, 1.02138370e-01f, 1.19763024e-01f, -2.37708807e-01f, 2.28104874e-01f,
  7.83870928e-03f, -3.13891843e-02f, 1.28473386e-01f, 1.02632694e-01f, 1.99488960e-02f, 2.76160818e-02f, -4.22274210e-02f, 1.34206899e-02f, -6.83449134e-02f, -4.13303412e-02f,
  1.66863203e-02f, -8.55156183e-02f, -2.29671020e-02f, -1.16745541e-02f, 7.24813864e-02f, 1.06640860e-01f, 1.22386925e-01f, -6.26922697e-02f, 2.42984649e-02f, -1.42907137e-02f,
  -8.44000652e-02f, 2.53368169e-01f, -1.60231590e-01f, 1.22429781e-01f, -4.53695953e-02f, -3.84205654e-02f, -1.09802991e-01f, 1.85689807e-01f, -1.21014446e-01f, -1.02303594e-01f,
  -9.67031792e-02f, -5.44501916e-02f, -2.59540230e-02f, 8.97299731e-04f, -4.82395589e-02f, 1.53301150e-01f, -1.34648114e-01f, -4.94852383e-03f, -4.35033888e-02f, -2.32444748e-01f,
  1.32684056e-02f, 6.07047789e-02f, 1.03429882e-02f, -1.07774608e-01f, 9.79274139e-02f, 5.24407700e-02f, 2.60867588e-02f, 1.32826477e-01f, 6.35790452e-02f, -9.77984220e-02f,
  -3.66425607e-03f, 1.11910902e-01f, -9.23727378e-02f, -2.29410768e-01f, 7.63972476e-02f, -3.96669209e-02f, -6.47213161e-02f, -9.46663767e-02f, -1.59965888e-01f, 1.81145862e-01f,
  3.42538357e-02f, 2.51665711e-01f, -7.13757327e-05f, 1.97529599e-01f, -1.21533684e-02f, 9.59594622e-02f, -8.74288231e-02f, -1.03705145e-01f, 1.29318208e-01f, 2.10570432e-02f,
  4.47938256e-02f, 2.35524662e-02f, -2.32016653e-01f, 6.32672086e-02f, -3.70918997e-02f, -1.42260507e-01f, 2.60344110e-02f, 9.57415439e-03f, -5.29736504e-02f, -1.40818566e-01f,
  -9.76734832e-02f, 1.85852759e-02f, 2.64930334e-02f, -2.95422617e-02f, 2.92682722e-02f, -6.61161169e-02f, -2.00515270e-01f, -1.69220522e-01f, -6.06857613e-03f, -2.35311598e-01f,
  3.36436719e-01f, -1.21199988e-01f, -2.00756848e-01f, -2.24809006e-01f, -2.02999711e-01f, -7.57949799e-02f, -2.43554533e-01f, -1.11251205e-01f, -2.60946490e-02f, 5.45284934e-02f,
  8.25269371e-02f, -3.73283625e-02f, 5.84525941e-03f, -1.57204419e-02f, 2.99203664e-01f, -1.06121274e-02f, -1.63108289e-01f, 2.83589959e-02f, -3.85453887e-02f, -1.66530773e-01f,
  8.46356805e-03f, -1.68133363e-01f, -1.39679134e-01f, 1.04221396e-01f, -2.37674061e-02f, -2.22388640e-01f, 1.03102610e-01f, 1.39598712e-01f, 2.42918387e-01f, -1.47430431e-02f,
  1.26103133e-01f, 1.59112483e-01f, -3.28159362e-01f, -5.46366647e-02f, 1.18048564e-01f, -6.88667744e-02f, -1.91478163e-01f, -6.45431504e-02f, -1.13200985e-01f, -2.65455991e-02f,
  -9.41453204e-02f, 1.02115283e-02f, -1.11515652e-02f, -5.74625805e-02f, -6.01773337e-02f, -3.68911438e-02f, 9.71953794e-02f, 9.95258316e-02f, -4.34008837e-02f, 9.82038081e-02f,
  -1.89143226e-01f, -1.01938639e-02f, -3.98681797e-02f, -2.05255672e-02f, 6.78684190e-02f, -8.81097093e-02f, -2.35880036e-02f, 3.05743404e-02f, -5.43803498e-02f, -5.30927405e-02f,
  9.78399515e-02f, -2.09039245e-02f, 5.56679256e-02f, -5.14659360e-02f, 3.76656721e-03f, 6.21164124e-03f, 3.03692825e-04f, 4.36908789e-02f, 2.23652162e-02f, 1.17475800e-01f,
  7.84301385e-02f, 7.25975409e-02f, -1.35772213e-01f, -5.01300171e-02f, 1.54521763e-01f, 5.74571593e-03f, 5.23370653e-02f, 1.16854385e-01f, -7.01896772e-02f, -7.18925074e-02f,
  1.14462100e-01f, 1.19628035e-01f, -1.41156495e-01f, -2.32525527e-01f, -9.06578091e-04f, -1.11148618e-01f, 1.25193134e-01f, -1.37856558e-01f, 1.57751307e-01f, 6.79844171e-02f,
  4.54256237e-02f, 1.56830952e-01f, -2.29828268e-01f, 2.17778459e-01f, 2.27782298e-02f, -7.13814422e-02f, -3.29474360e-02f, -1.33982658e-01f, -2.34406777e-02f, -2.18210459e-01f,
  1.13894239e-01f, 2.50842236e-02f, -8.09098780e-02f, 6.30443841e-02f, 6.93070218e-02f, 6.44931346e-02f, 3.56128365e-02f, -6.98868511e-03f, 6.93223402e-02f, -1.03407249e-01f,
  -1.97797399e-02f, -1.00764118e-01f, -1.29639834e-01f, 6.83897883e-02f, -1.09323837e-01f, -5.30852526e-02f, 1.97935589e-02f, -1.34512082e-01f, 6.30665272e-02f, -8.12275708e-02f,
  -1.57428056e-01f, -4.29621525e-02f, -4.27147076e-02f, -1.48708194e-01f, 9.92401838e-02f, -1.59272589e-02f, 6.88755289e-02f, -1.95573568e-01f, -6.07022569e-02f, -9.02466103e-02f,
  1.64439052e-01f, -2.20153816e-02f, 1.75108150e-01f, 1.50841400e-01f, -3.66727659e-03f, 2.21257564e-02f, -8.67626220e-02f, -1.47436634e-01f, -1.41496724e-02f, -8.41996539e-03f,
  1.35868609e-01f, 2.13738829e-01f, 2.75881542e-03f, 1.02797136e-01f, 7.30386823e-02f, -5.30877076e-02f, -2.55021304e-01f, -2.84364343e-01f, 1.53062105e-01f, -1.91477776e-01f,
  2.46629462e-01f, 4.70444001e-02f, 1.83196515e-02f, -1.49712488e-01f, -2.96963546e-02f, 2.42755264e-01f, -1.05284080e-01f, 1.20830029e-01f, -1.04590598e-02f, 1.97262675e-01f,
  1.29738431e-02f, -7.44163767e-02f, -7.02150241e-02f, -2.51211733e-01f, 2.34351724e-01f, 1.05171993e-01f, -3.65504064e-02f, 1.46574765e-01f, 1.43543556e-01f, 1.26521170e-01f,
  -4.66199815e-02f, -3.72207202e-02f, 1.34647980e-01f, 1.36526003e-01f, -2.15365477e-02f, 1.66838560e-02f, 4.70745526e-02f, -6.52718544e-02f, 1.70462191e-01f, 3.27207297e-02f,
  1.11207291e-01f, 1.35139093e-01f, 5.98376151e-03f, 2.39996575e-02f, -1.75010376e-02f, -7.41939247e-02f, 1.61884144e-01f, 1.71968237e-01f, -1.06965140e-01f, 4.09528315e-02f,
  4.44865189e-02f, -1.36192322e-01f, 1.03486784e-01f, -4.51544598e-02f, -2.57801265e-01f, 7.71081224e-02f, -2.11083114e-01f, -1.56154469e-01f, -1.44472614e-01f, 7.86463246e-02f,
  2.38250718e-01f, -4.52411138e-02f, 1.44478336e-01f, -2.06369549e-01f, -2.19060153e-01f, -2.26393089e-01f, 1.60994977e-02f, 1.10053636e-01f, -6.15688600e-02f, 1.26974732e-01f,
  -9.44495276e-02f, -1.59074605e-01f, 4.62734699e-02f, -1.30508035e-01f, 4.20653336e-02f, 7.18921050e-02f, -4.46129926e-02f, -2.77515143e-01f, 1.24046750e-01f, 1.15572765e-01f,
  8.57817531e-02f, -5.68463234e-03f, 9.32077095e-02f, -1.47968784e-01f, 1.52417114e-02f, 2.91200250e-01f, 2.17584893e-01f, 1.88503399e-01f, -1.83281824e-01f, 1.67958632e-01f,
  -2.07736646e-03f, 1.19941078e-01f, 1.36116177e-01f, -4.41796146e-02f, -8.61242935e-02f, -1.11553125e-01f, 2.64789835e-02f, 2.99094059e-03f, -1.38919810e-02f, 3.19630168e-02f,
  -9.78593379e-02f, 1.25726387e-01f, -1.24462947e-01f, 1.10771872e-01f, -4.10374859e-03f, -1.95119940e-02f, -1.03300415e-01f, -1.63914096e-02f, 7.88054429e-03f, 4.61761244e-02f,
  -3.03800427e-03f, -1.41449586e-01f, -7.86133334e-02f, 1.57321279e-03f, -2.55976175e-03f, 6.05344586e-02f, 8.70686695e-02f, -6.61643669e-02f, 6.41515777e-02f, 4.99341786e-02f,
  -2.94153541e-02f, 2.60760993e-01f, -4.38775644e-02f, 4.73286957e-02f, -1.57128289e-01f, -1.02086693e-01f, -1.27303481e-01f, -1.18779160e-01f, 3.26026678e-02f, 9.37935114e-02f,
  1.62620489e-02f, -1.15813017e-01f, 1.78168848e-01f, -7.31496587e-02f, -2.37009808e-01f, 3.13556264e-03f, 1.10530823e-01f, -2.09197067e-02f, 1.85566902e-01f, -8.32275003e-02f,
  3.66193242e-02f, -6.44413680e-02f, -6.76311329e-02f, 1.17823012e-01f, -7.73445666e-02f, 2.23398656e-01f, 1.29714727e-01f, -4.84314561e-02f, -1.65136158e-01f, 1.33425500e-02f,
  -1.71915561e-01f, -1.61549821e-01f, 1.17246471e-01f, 1.24799617e-01f, -1.28349364e-02f, -1.02115758e-02f, 7.25597739e-02f, -8.79840255e-02f, 5.25173880e-02f, 1.12573706e-01f,
  -4.86331284e-02f, 1.31616086e-01f, -7.83034042e-02f, -3.14945169e-02f, -5.58004268e-02f, 2.22984612e-01f, -1.04744487e-01f, 1.32879183e-01f, 1.05730467e-01f, 8.94944817e-02f,
  4.85857315e-02f, -1.21682016e-02f, -1.00787491e-01f, 1.80947557e-01f, 3.95322777e-02f, -5.80564253e-02f, 6.61295727e-02f, 1.34215549e-01f, 2.01581046e-01f, 3.29572447e-02f,
  2.02730358e-01f, -1.60497591e-01f, 1.10626750e-01f, 1.02037556e-01f, -7.89616928e-02f, 1.38796810e-02f, 1.73701674e-01f, -1.86327115e-01f, -6.10890016e-02f, 1.32785253e-02f,
  1.78271845e-01f, 2.09316477e-01f, 4.89963479e-02f, 1.27304897e-01f, -1.78967133e-01f, -4.25689556e-02f, 1.22483611e-01f, -2.97827162e-02f, -1.43517300e-01f, -1.09067842e-01f,
  -1.62870243e-01f, -1.19601235e-01f, 1.61257908e-02f, 1.60738841e-01f, -3.88919003e-03f, 4.08326872e-02f, -2.52097622e-02f, 5.05451672e-02f, -1.72478497e-01f, 3.87600884e-02f,
  -2.02465877e-01f, -9.84737501e-02f, 5.36043048e-02f, -1.39997095e-01f, -1.79227382e-01f, -1.09866753e-01f, 6.56151101e-02f, -1.75991625e-01f, 1.36525303e-01f, 1.00922644e-01f,
  -3.81947719e-02f, 4.13640179e-02f, 1.56346530e-01f, 1.37814030e-01f, -5.31388000e-02f, 1.88641320e-03f, -6.15715161e-02f, 8.97540748e-02f, -2.75083724e-02f, -1.48386031e-01f,
  9.09679979e-02f, 7.98960552e-02f, 2.03193113e-01f, -1.05318435e-01f, -6.27596453e-02f, -1.06809191e-01f, 7.33096013e-03f, 1.16839491e-01f, 7.81694576e-02f, -4.56184410e-02f,
  -6.98994994e-02f, 9.61085707e-02f, 3.45673040e-02f, -3.80274169e-02f, 2.19498426e-01f, -1.41869739e-01f, 3.53356265e-02f, -2.40138993e-02f, -1.71865642e-01f, -1.16092846e-01f,
  1.15485363e-01f, -2.29151726e-01f, 4.84177209e-02f, -1.17010668e-01f, 7.78792948e-02f, 1.12257324e-01f, -2.49352753e-02f, 1.34722665e-02f, -1.39585003e-01f, 8.23325738e-02f,
  -1.29904494e-01f, 2.11319074e-01f, -6.41502393e-03f, 8.33450258e-02f, -1.02636077e-01f, -1.89837843e-01f, -1.32980213e-01f, 1.35690510e-01f, -1.76538482e-01f, -1.57796130e-01f,
  1.32189140e-01f, -1.54444396e-01f, 1.80042401e-01f, -1.58094808e-01f, -1.64783433e-01f, 2.00763032e-01f, 1.86661854e-01f, 1.30046317e-02f, 2.40144700e-01f, 1.86366197e-02f,
  -2.11761907e-01f, -1.07859999e-01f, -2.44309790e-02f, 1.07286878e-01f, 1.26323393e-02f, 1.04024433e-01f, 3.30330655e-02f, -4.55841571e-02f, 6.69034943e-03f, -2.27859081e-03f,
  1.39908254e-01f, 7.39192814e-02f, 1.01215765e-01f, -1.45238876e-01f, 7.21838921e-02f, 4.62935604e-02f, 1.72824059e-02f, -3.02597787e-02f, -1.13115050e-01f, -1.28267288e-01f,
  -3.11846603e-02f, -3.74243930e-02f, 4.32575867e-02f, -5.60372658e-02f, -5.53429238e-02f, 7.65598863e-02f, -2.77329423e-03f, -6.83302507e-02f, 9.58777741e-02f, -8.99646804e-02f,
  -1.21971138e-01f, 1.60399228e-01f, -1.22707121e-01f, -6.63412213e-02f, 7.67210200e-02f, -2.31358960e-01f, -1.27416290e-03f, -1.97604358e-01f, 9.24746841e-02f, 1.16816880e-02f,
  -7.27138519e-02f, 5.60863353e-02f, -2.04400420e-02f, 1.33040193e-02f, -1.74918324e-01f, 1.88104674e-01f, 7.13436212e-03f, -1.51346922e-01f, -1.84600949e-01f, -1.59012035e-01f,
  5.06404638e-02f, 1.83234692e-01f, 7.45391175e-02f, -2.15998128e-01f, -9.17513520e-02f, 5.77344820e-02f, -6.91146925e-02f, 1.87445253e-01f, 3.36482674e-02f, -4.76816632e-02f,
  -6.45561442e-02f, 1.58754904e-02f, 1.31550478e-02f, 9.24599543e-02f, -1.13021448e-01f, 2.04100907e-01f, -8.23989138e-03f, -5.07928133e-02f, 7.31391553e-03f, -1.57511383e-01f,
  1.25594765e-01f, -6.39350787e-02f, -4.54845950e-02f, -5.19246943e-02f, 7.93021545e-02f, -5.78792579e-02f, -5.77866845e-02f, 4.30125464e-03f, 2.84197740e-02f, -6.55465014e-03f,
  1.16274185e-01f, -7.04331547e-02f, 9.21065435e-02f, -9.10754502e-02f, -4.12933752e-02f, -5.55037037e-02f, -1.60787683e-02f, -1.89191289e-02f, -1.35370120e-01f, -4.00822721e-02f,
  -1.49971262e-01f, -1.67419821e-01f, -1.14892974e-01f, -1.58486560e-01f, 1.31202102e-01f, 7.15082660e-02f, -3.42731401e-02f, 5.44269383e-02f, 3.06283683e-02f, -1.06565021e-01f,
  -9.65072662e-02f, -1.58582255e-01f, -1.54201999e-01f, -1.59719840e-01f, -1.05878793e-01f, -9.22487304e-02f, -7.80671183e-03f, -1.62744612e-01f, 1.36643618e-01f, 1.03794873e-01f,
  -7.10421205e-02f, -8.77641216e-02f, -1.05912119e-01f, -2.19476685e-01f, 1.63543403e-01f, 1.68905128e-02f, 1.22727983e-01f, -1.45316422e-01f, -2.81535904e-03f, 2.34353080e-01f,
  -2.30477482e-01f, 1.11968040e-01f, 1.11051805e-01f, -1.11744016e-01f, -2.08386779e-01f, 6.49955645e-02f, -8.90487805e-02f, 3.48289758e-02f, -6.04221746e-02f, 2.19432861e-01f,
  1.21026568e-01f, 8.20918977e-02f, 9.23117101e-02f, -1.09336786e-01f, 2.28601806e-02f, -8.63453597e-02f, 1.05671007e-02f, -1.44477084e-01f, -1.14980139e-01f, -1.77146737e-02f,
  -9.61993933e-02f, 5.92777878e-02f, -8.59132558e-02f, 5.16434945e-02f, 8.80762786e-02f, -2.68596187e-02f, -2.71701645e-02f, -1.95727516e-02f, -9.42511037e-02f, -1.21278176e-02f,
  -1.03519909e-01f, -1.63610131e-01f, -2.29743272e-02f, -1.37268543e-01f, -9.61330608e-02f, -7.35980123e-02f, -1.10812292e-01f, -4.15008478e-02f, 5.49346581e-02f, 1.52608871e-01f,
  6.00148365e-02f, 2.52963215e-01f, 1.14845648e-01f, 1.14993127e-02f, -1.13961309e-01f, -1.69524893e-01f, -2.43970707e-01f, -9.49250683e-02f, -2.49218158e-02f, 1.32978395e-01f,
  5.34675419e-02f, -1.48556054e-01f, 2.06407726e-01f, -1.87264368e-01f, -1.78182080e-01f, -8.68453085e-02f, 4.44710478e-02f, -8.05765670e-03f, 1.72422558e-01f, 1.13544106e-01f,
  2.77020514e-01f, 2.92886607e-03f, -1.02951564e-01f, 1.67289808e-01f, -2.42157876e-01f, -3.62899504e-03f, -1.20966882e-02f, -1.40890568e-01f, -9.26847085e-02f, -6.52717473e-03f,
  -2.54472673e-01f, 1.66346803e-02f, 2.15765834e-01f, 1.66062847e-01f, 8.15156847e-02f, 5.39166965e-02f, -5.91648817e-02f, -1.40231669e-01f, 1.37334928e-01f, -1.18474714e-01f,
  -7.14247674e-03f, -3.22734639e-02f, -4.83623333e-02f, -4.22651656e-02f, -3.95069219e-04f, 1.81993216e-01f, -2.02459446e-03f, 1.33325964e-01f, -1.28260493e-01f, 6.14512386e-03f,
  -1.22990683e-01f, 9.39913839e-03f, 7.14446828e-02f, 8.07462111e-02f, 3.28484997e-02f, 7.52550587e-02f, 3.00717559e-02f, -8.29395279e-02f, 3.57814208e-02f, -2.97791120e-02f,
  2.74544135e-02f, 1.17304422e-01f, 1.36119559e-01f, -1.63421094e-01f, -3.69344391e-02f, -1.70604195e-02f, -6.55772090e-02f, 9.07677412e-02f, -3.62982713e-02f, 8.81799534e-02f,
  -2.07712203e-01f, 1.87960371e-01f, 1.20674722e-01f, 1.15929581e-01f, 1.46294400e-01f, 2.21452732e-02f, 4.12618294e-02f, -7.85063058e-02f, -1.02383800e-01f, 2.17184484e-01f,
  6.22975864e-02f, 1.66725740e-01f, -2.94699147e-02f, 3.78735587e-02f, 1.93365708e-01f, 1.26534343e-01f, 4.88556586e-02f, 4.13014367e-02f, 1.31758666e-02f, 5.61493933e-02f,
  1.58580318e-01f, 1.55781493e-01f, -1.39173701e-01f, -6.42246976e-02f, 1.23432800e-02f, -1.37287527e-01f, 4.45771888e-02f, -7.26225674e-02f, 4.06254455e-02f, 6.16888665e-02f,
  6.95245489e-02f, -1.04786061e-01f, -1.36708200e-01f, -9.44854245e-02f, -3.39651182e-02f, 2.42146440e-02f, 3.64495092e-03f, 7.59128481e-03f, -2.98853144e-02f, 1.78225413e-01f,
  -1.43538877e-01f, 1.07929841e-01f, 1.03836790e-01f, 5.06574400e-02f, -1.14509039e-01f, 9.97917950e-02f, 4.42073010e-02f, 8.91731903e-02f, 1.13803566e-01f, -2.73858737e-02f,
  9.81169567e-02f, -8.69941935e-02f, 7.20673651e-02f, -1.82448849e-01f, -4.47165370e-02f, 1.51667893e-01f, -1.01290151e-01f, -3.99212120e-03f, -3.67240794e-02f, 4.68383729e-02f,
  -5.52094132e-02f, 1.39475405e-01f, -4.39929776e-02f, 1.01850919e-01f, -1.29095949e-02f, -6.92753047e-02f, 1.28170803e-01f, 3.03628445e-02f, 2.16682822e-01f, -1.17938980e-01f,
  9.70703661e-02f, -1.54105365e-01f, 2.89666820e-02f, -8.00002664e-02f, 1.96562335e-01f, -1.62973218e-02f, 1.78007467e-03f, -1.11516468e-01f, 1.89633861e-01f, -3.04563455e-02f,
  2.92092282e-02f, 3.89456153e-02f, -9.91875604e-02f, 1.98064700e-01f, 2.21144289e-01f, 5.06956019e-02f, -1.16865098e-01f, 9.75342691e-02f, -1.09631289e-02f, -3.73292863e-02f,
  6.33031800e-02f, -4.19458114e-02f, -1.13956295e-01f, 7.31781051e-02f, -4.84456383e-02f, 1.06254155e-02f, -1.38515476e-02f, -1.75316140e-01f, 1.71666127e-02f, 5.63772842e-02f,
  -9.85359102e-02f, 9.22879949e-02f, 5.70784174e-02f, -3.36544961e-02f, 9.24848020e-02f, 7.92727321e-02f, 2.84314225e-03f, 1.01738915e-01f, 5.20134205e-03f, -9.31069851e-02f,
  8.07132125e-02f, -4.54329737e-02f, -1.09687343e-01f, 7.22853094e-02f, -1.53067157e-01f, -5.98521382e-02f, -1.83337241e-01f, -1.67646095e-01f, 2.73686737e-01f, 2.38460749e-01f,
  1.09306641e-01f, -1.62853748e-01f, 2.15855483e-02f, -3.60579193e-02f, -3.13533038e-01f, 1.45234570e-01f, -7.20063299e-02f, 3.30534518e-01f, -8.77131056e-03f, 2.42442161e-01f,
  2.68954098e-01f, 2.54411131e-01f, 1.84197053e-01f, 1.05541475e-01f, -1.99011445e-01f, -1.37606099e-01f, 8.22583288e-02f, -1.43971965e-01f, 1.74530476e-01f, 2.50240657e-02f,
  -8.85524005e-02f, -3.34560499e-02f, 4.46837805e-02f, 1.19870067e-01f, 1.58125177e-01f, -7.40389228e-02f, 2.38828957e-01f, 9.98046100e-02f, 5.23223206e-02f, 3.37608397e-01f,
  6.24188744e-02f, -9.21204686e-02f, 1.10404871e-01f, -1.66860864e-01f, 2.36190617e-01f, -7.40326419e-02f, 9.01554129e-04f, 4.23926376e-02f, 8.21474865e-02f, 1.28226489e-01f,
  -5.08951163e-03f, -4.02336791e-02f, -1.29775614e-01f, -3.44580635e-02f, -4.47326154e-03f, 7.48761222e-02f, -5.08735180e-02f, 6.01801574e-02f, -4.42520157e-02f, 7.76036978e-02f,
  1.47521511e-01f, -6.29617199e-02f, 6.97688982e-02f, -3.21993465e-03f, -1.05564229e-01f, 5.11481613e-02f, 2.49881912e-02f, -1.64110679e-02f, 1.49003386e-01f, 6.64133728e-02f,
  1.36998162e-01f, -1.19604073e-01f, 1.05285108e-01f, 5.36887757e-02f, 1.26293629e-01f, 7.81084374e-02f, 1.17677182e-01f, 2.58275960e-02f, 4.46919017e-02f, -7.45396987e-02f,
  7.51487969e-04f, -1.49688616e-01f, -4.18192632e-02f, -4.63047205e-03f, -7.26535395e-02f, -5.90397455e-02f, 3.15401368e-02f, -3.96698219e-04f, 2.25303397e-01f, -1.11655131e-01f,
  3.82712297e-02f, -1.69497579e-01f, -1.32077947e-01f, 2.54497640e-02f, -2.41941214e-02f, -2.21021026e-02f, -8.39232504e-02f, 7.38158869e-03f, 1.00411333e-01f, 2.63370667e-02f,
  -1.66456074e-01f, 8.09389725e-02f, -9.64500681e-02f, -2.36077413e-01f, 8.16293880e-02f, -6.87221158e-03f, -1.45809337e-01f, 2.59346850e-02f, 1.80430666e-01f, -2.71426979e-02f
};

// L1_fan_Wp_bar (Shape: 14 x 64)
const int L1_fan_Wp_bar_rows = 14;
const int L1_fan_Wp_bar_cols = 64;
const float L1_fan_Wp_bar_data[] = {
  1.36387751e-01f, -8.43476504e-03f, -4.31806929e-02f, 1.32207468e-01f, -2.56540300e-03f, 1.29344985e-01f, -2.69362424e-03f, 1.18267931e-01f, 1.48947522e-01f, 1.12954319e-01f,
  1.15436032e-01f, -5.44239506e-02f, 1.00855045e-01f, -6.51222542e-02f, 2.13722624e-02f, 2.20770150e-01f, 9.52258855e-02f, -5.14809191e-02f, 2.30288729e-01f, 2.16853693e-01f,
  -3.00700236e-02f, 2.13314831e-01f, 2.40397558e-01f, 1.51472941e-01f, 1.21397033e-01f, 6.56743869e-02f, 1.00045867e-01f, -2.56337710e-02f, -9.69481021e-02f, 1.66310012e-01f,
  1.77989945e-01f, -4.26069014e-02f, 1.63395643e-01f, -7.48530822e-03f, 7.66018480e-02f, -1.04059808e-01f, 1.18506148e-01f, 1.72452509e-01f, 1.69303104e-01f, 2.08235942e-02f,
  -1.44692250e-02f, -4.19833995e-02f, -2.11015537e-01f, -4.97425608e-02f, -1.22014567e-01f, 3.19091119e-02f, 7.57171866e-03f, 4.04297970e-02f, -6.78975284e-02f, 1.47021618e-02f,
  -7.69361779e-02f, 2.54293740e-01f, 1.88532248e-01f, -5.25792129e-02f, 1.48127079e-01f, -6.26868308e-02f, 9.01011303e-02f, 2.26498783e-01f, 1.82162389e-01f, -1.45533994e-01f,
  1.76798016e-01f, -7.87336901e-02f, 3.78793478e-02f, -4.38433960e-02f, -1.63214598e-02f, 4.29547168e-02f, -3.24629433e-02f, 1.16871387e-01f, 5.81347719e-02f, 1.48330256e-02f,
  -9.06510800e-02f, 5.29619306e-02f, 1.54819772e-01f, 1.45903096e-01f, 9.96845216e-02f, 9.24165100e-02f, 1.55317292e-01f, 1.64359123e-01f, -1.34452945e-02f, 1.53565615e-01f,
  1.55384466e-03f, 2.10986808e-02f, 1.08859397e-01f, 7.05868825e-02f, 1.04193084e-01f, 5.99109121e-02f, 1.13944352e-01f, 1.60640195e-01f, 2.27444381e-01f, 2.14838013e-02f,
  1.34534970e-01f, -2.34170258e-02f, 1.11392103e-01f, 1.86859980e-01f, 1.35763839e-01f, -1.72409758e-01f, 1.74695507e-01f, -1.92940012e-01f, 4.64549288e-02f, -8.86592418e-02f,
  1.12823509e-01f, 1.37488246e-01f, 1.81749418e-01f, 1.51875615e-01f, -1.60584465e-01f, -1.18009113e-02f, -1.13997057e-01f, -3.18053029e-02f, -1.78231835e-01f, -2.46720925e-01f,
  3.85625921e-02f, -1.76403195e-01f, 3.76739055e-02f, 9.33453366e-02f, 1.05170950e-01f, 2.09430322e-01f, 2.78011650e-01f, -5.87081015e-02f, 7.01687038e-02f, 2.12724417e-01f,
  4.75972798e-03f, 2.12431297e-01f, 4.76733819e-02f, -2.97258515e-02f, 2.62509793e-01f, -1.76299304e-01f, 1.96470723e-01f, -1.34391204e-01f, -2.20160037e-02f, 1.85262784e-01f,
  -1.97269972e-02f, 1.58876136e-01f, 2.13231772e-01f, 5.22054844e-02f, -3.72926742e-02f, 1.99620202e-01f, 1.34371258e-02f, 6.98641175e-03f, 1.80668142e-02f, -6.84294254e-02f,
  1.99844852e-01f, 6.59940466e-02f, 8.13588649e-02f, -7.18790293e-02f, 5.82370423e-02f, -7.58100376e-02f, 2.51385182e-01f, 1.54734656e-01f, 1.02613140e-02f, 1.98394224e-01f,
  -1.58699919e-02f, 9.45387632e-02f, -1.09593291e-02f, 9.08795372e-02f, 1.89120501e-01f, 2.47761831e-02f, -3.21817622e-02f, 9.43263173e-02f, -6.65726215e-02f, -1.94160655e-01f,
  -1.47150636e-01f, -1.56258821e-01f, -9.51370411e-03f, -1.93078630e-02f, -2.98287310e-02f, -3.69222909e-02f, 9.04296935e-02f, 1.30207732e-01f, -5.85918203e-02f, -1.61564406e-02f,
  -2.06034288e-01f, 1.90045357e-01f, 1.13014042e-01f, 6.53816536e-02f, -7.69907087e-02f, -6.54967055e-02f, -1.55455828e-01f, -1.14523713e-02f, 1.77101586e-02f, 2.26267129e-01f,
  2.30115131e-01f, -2.01833975e-02f, 3.56608480e-01f, 1.12008438e-01f, 1.14994101e-01f, 2.50120372e-01f, 1.95263550e-01f, -1.09816380e-02f, 2.63527155e-01f, -1.20559372e-01f,
  -6.41856939e-02f, 3.74710299e-02f, -4.77538742e-02f, 1.81132033e-02f, -3.17880139e-02f, 4.07106988e-02f, 1.01938598e-01f, -8.13307299e-04f, 9.03008804e-02f, 1.57261789e-02f,
  1.41625069e-02f, 3.94046605e-02f, 5.15359230e-02f, 7.05987960e-02f, -1.16641894e-01f, 1.69082552e-01f, 1.36167958e-01f, 7.02302158e-02f, 3.57903615e-02f, 1.32833317e-01f,
  4.33001705e-02f, -6.47436008e-02f, 9.69181433e-02f, -6.16567358e-02f, -6.27709106e-02f, -1.38155863e-01f, -3.45082395e-02f, -1.25828028e-01f, -1.04601629e-01f, -3.00221980e-01f,
  1.75687566e-01f, 1.02447435e-01f, -3.08894198e-02f, 2.19547316e-01f, -9.42001268e-02f, 7.39289075e-02f, -2.41744012e-01f, -1.26173899e-01f, 1.95287038e-02f, -1.79626852e-01f,
  -7.03357756e-02f, -8.75165835e-02f, -8.69353414e-02f, -1.33925676e-01f, 6.45215288e-02f, -1.19028814e-01f, -3.76427732e-02f, -1.34142384e-01f, -8.49919766e-02f, -2.10465625e-01f,
  2.60799229e-01f, 2.86849197e-02f, 1.31298065e-01f, -1.03088349e-01f, -1.73455983e-01f, 1.63045317e-01f, -9.66748446e-02f, 1.43510431e-01f, -1.45162016e-01f, -1.76784340e-02f,
  -6.80838823e-02f, -7.50536248e-02f, -6.66707754e-02f, -9.53990072e-02f, 6.27397969e-02f, 2.23596781e-01f, -3.74459587e-02f, 5.99865541e-02f, 1.59614012e-01f, -1.20099492e-01f,
  4.82147299e-02f, 1.17276214e-01f, 2.28620917e-01f, -1.00533413e-02f, 9.97575838e-03f, 2.70783484e-01f, 1.75999612e-01f, 1.42296061e-01f, 1.46771431e-01f, 2.38305181e-01f,
  -3.80658619e-02f, 1.00815400e-01f, 8.67999196e-02f, 1.41976625e-01f, 2.03340203e-01f, 1.22136787e-01f, 9.31485593e-02f, -6.49786070e-02f, -6.18149191e-02f, 7.97045417e-03f,
  6.78013414e-02f, -6.72604591e-02f, 2.18306839e-01f, 1.75391600e-01f, -8.55834037e-02f, -1.27867296e-01f, 7.48808309e-03f, 2.11500302e-01f, -2.93523312e-01f, 3.15619120e-03f,
  -1.37080833e-01f, 2.42704794e-01f, 2.72641554e-02f, -4.02256846e-02f, 1.10318422e-01f, 1.39776394e-01f, 2.54592180e-01f, -1.00180641e-01f, -4.56222426e-03f, -1.12432517e-01f,
  -1.03101507e-01f, -1.01350240e-01f, 2.40837023e-01f, -6.56444207e-02f, 5.87619133e-02f, -6.03449754e-02f, 2.73152143e-01f, 2.53606215e-02f, 6.93470240e-02f, 2.58409202e-01f,
  1.38744205e-01f, 8.32479373e-02f, 2.39662334e-01f, 2.63777167e-01f, -1.03129029e-01f, -3.38567595e-04f, 1.08059600e-01f, -1.63233683e-01f, 2.17078075e-01f, 2.23006830e-01f,
  -3.40071432e-02f, -7.72821158e-02f, 1.34921730e-01f, 1.47674933e-01f, -8.17415193e-02f, 7.34952539e-02f, 7.91127160e-02f, 9.75464657e-02f, 2.24604338e-01f, 1.53264463e-01f,
  5.80915436e-02f, 2.18156815e-01f, -6.72746599e-02f, 1.89944029e-01f, -3.37827541e-02f, 1.30407214e-01f, 1.10675015e-01f, 6.57209754e-02f, 3.97039428e-02f, 6.52623102e-02f,
  6.16045147e-02f, 1.14429615e-01f, 3.16008329e-02f, 2.04801470e-01f, 1.90853223e-01f, 1.47643656e-01f, -7.77204707e-02f, 2.26023525e-01f, 2.26205006e-01f, 7.39295185e-02f,
  1.32135794e-01f, 3.17676328e-02f, -4.30084728e-02f, 4.81240004e-02f, -2.25066438e-01f, -1.48279175e-01f, -1.78294301e-01f, 2.31055066e-01f, 1.96194481e-02f, -8.04166961e-03f,
  -1.12991594e-01f, 2.88809687e-02f, 4.35135663e-02f, -2.20386505e-01f, -3.20141949e-02f, 1.73933968e-01f, -1.91998072e-02f, 1.21763162e-01f, -9.74570289e-02f, -1.89340502e-01f,
  -3.90561484e-02f, 1.91338032e-01f, -1.21087477e-01f, -3.46647779e-04f, -1.35332551e-02f, -1.30063528e-02f, -6.20616414e-02f, -1.06875889e-01f, 1.40122518e-01f, -3.70512754e-02f,
  -1.83615223e-01f, 2.32133269e-02f, 3.77596229e-01f, -8.80349725e-02f, -1.07708558e-01f, 1.09196343e-01f, 8.97989273e-02f, -6.90302402e-02f, 1.01365782e-01f, 1.13158785e-01f,
  2.14879960e-01f, -4.83187288e-02f, -1.60070683e-03f, 2.08353892e-01f, 4.60659303e-02f, -8.18074122e-02f, 1.09954000e-01f, 1.86106458e-01f, -3.28112347e-03f, 9.70304664e-03f,
  -1.25135884e-01f, -6.54046237e-03f, 1.83775201e-01f, 7.28672817e-02f, 7.31721148e-02f, 6.51401526e-04f, -8.27469379e-02f, 6.98646680e-02f, -1.97563633e-01f, -2.89294958e-01f,
  7.23611787e-02f, -6.64790496e-02f, -4.20846306e-02f, -2.42021829e-01f, -2.11079672e-01f, -1.34046495e-01f, -3.12914580e-01f, 2.32034922e-01f, 5.26307374e-02f, 3.50652903e-01f,
  1.35033419e-02f, -1.34007290e-01f, -5.78248091e-02f, -4.28698137e-02f, 1.88004345e-01f, -8.43651369e-02f, -4.93445955e-02f, -1.99429449e-02f, -9.99680161e-02f, -2.26966769e-01f,
  6.06406592e-02f, -1.09644495e-02f, -7.92403817e-02f, 6.13663308e-02f, 1.79392770e-01f, -2.10488603e-01f, 2.42552981e-01f, 6.11384884e-02f, 2.32698530e-01f, 6.46803081e-02f,
  2.12815613e-01f, -6.91288635e-02f, -3.52305561e-01f, 1.00439012e-01f, 2.49561757e-01f, -7.69235715e-02f, -2.23977432e-01f, 9.26566496e-02f, 1.87570184e-01f, 8.76971632e-02f,
  1.77017316e-01f, 2.66200192e-02f, 7.37898052e-02f, 1.54813454e-01f, 1.92241997e-01f, -1.42785953e-02f, 1.74445838e-01f, 2.96718478e-02f, 3.54890376e-02f, 1.73481017e-01f,
  -2.66290009e-02f, 9.51849669e-02f, 1.91941082e-01f, 4.16329801e-02f, 9.74493753e-03f, 6.31127432e-02f, 2.57628970e-02f, -4.93204333e-02f, 5.51237166e-02f, -5.83433397e-02f,
  3.70238535e-02f, 1.42659813e-01f, 1.65349931e-01f, -1.34645000e-01f, -5.16097546e-02f, -1.36868313e-01f, 2.27718115e-01f, -3.83504294e-02f, -5.87163344e-02f, 2.54231095e-01f,
  -5.23745455e-02f, 1.80449054e-01f, -2.82272875e-01f, -9.26674753e-02f, -1.53634831e-01f, -1.07209310e-01f, -3.15545802e-03f, -1.42163262e-01f, 1.90491363e-01f, -4.60428335e-02f,
  2.24587485e-01f, -2.64270812e-01f, -3.36268276e-01f, -3.14454213e-02f, 1.82838649e-01f, -1.70368746e-01f, 9.22164917e-02f, -5.32354414e-02f, 4.21341183e-03f, -2.10846160e-02f,
  2.02976428e-02f, 1.60747528e-01f, -1.53580397e-01f, 2.64981687e-01f, -1.02924006e-02f, -9.48340595e-02f, -3.95030901e-02f, 1.56944975e-01f, -1.41635686e-01f, 2.88610645e-02f,
  1.30505919e-01f, 2.12952837e-01f, 2.86764298e-02f, 8.83288011e-02f, -1.52598107e-02f, 8.94230790e-03f, 1.52485415e-01f, -6.01268001e-02f, 1.97544366e-01f, 9.04141217e-02f,
  1.52094392e-02f, 5.75711615e-02f, 6.17035804e-03f, 1.77985176e-01f, 1.68048963e-01f, -3.69710252e-02f, 5.20457588e-02f, -1.14228353e-01f, -2.19980404e-02f, -3.75328735e-02f,
  -1.52715936e-01f, 3.14567424e-02f, 1.47588417e-01f, -1.12968966e-01f, -7.18884096e-02f, -6.80618212e-02f, 3.57209109e-02f, 1.05015009e-04f, -2.89753582e-02f, -3.21588427e-01f,
  3.54829013e-01f, 1.26328841e-01f, 7.71636963e-02f, 2.25723773e-01f, 2.98105896e-01f, -2.39450470e-01f, -5.50217591e-02f, -1.31052703e-01f, -4.14693765e-02f, -1.48458764e-01f,
  -6.45360351e-02f, 1.44253567e-01f, -2.33183838e-02f, -2.07191944e-01f, 2.86850661e-01f, 8.67723152e-02f, -1.49567232e-01f, 1.68321520e-01f, -2.19466180e-01f, -9.20487344e-02f,
  1.38203189e-01f, -3.87335829e-02f, 8.99526104e-02f, -7.09370598e-02f, -4.36717309e-02f, -1.91980321e-02f, -6.73748255e-02f, 2.50849038e-01f, 5.77887483e-02f, -6.53164228e-03f,
  -1.08820550e-01f, -4.49437164e-02f, 7.53498524e-02f, -2.35380307e-01f, -9.16436464e-02f, 1.04167581e-01f, 2.92263683e-02f, 8.49245936e-02f, -4.91859354e-02f, -5.38487546e-02f,
  2.02705085e-01f, 1.31566569e-01f, 8.21798760e-03f, 3.45654367e-03f, 1.42541919e-02f, 4.22190614e-02f, 7.60925412e-02f, -4.33621928e-02f, 2.08507836e-01f, 1.10550918e-01f,
  -7.66665339e-02f, 4.73553054e-02f, 1.61036298e-01f, 1.31394658e-02f, 1.80429772e-01f, 1.30856419e-02f, -2.76541188e-02f, 4.69972789e-02f, 1.76120117e-01f, -7.48727564e-03f,
  1.73308164e-01f, -7.43070021e-02f, 1.19224176e-01f, -2.09209085e-01f, 3.51883993e-02f, 7.70900324e-02f, 7.91868716e-02f, 1.42356567e-02f, 3.17113474e-03f, -6.69512600e-02f,
  9.73488092e-02f, -1.68669522e-01f, 2.22912207e-01f, 2.29185537e-01f, 1.37841240e-01f, 1.45715445e-01f, -1.67053923e-01f, -1.95717722e-01f, -6.14872389e-02f, -1.04365207e-01f,
  -7.16299471e-03f, -1.73374757e-01f, -3.11805066e-02f, -1.67802677e-01f, -3.91153879e-02f, -1.55889895e-02f, 9.75808725e-02f, -1.16119221e-01f, 8.08872730e-02f, 1.94459915e-01f,
  1.73915610e-01f, 1.14981666e-01f, 2.04962313e-01f, 1.34349659e-01f, 2.20021605e-01f, -7.69471228e-02f, 2.37907231e-01f, -1.17964623e-02f, -4.74812053e-02f, -1.26007900e-01f,
  4.18511080e-03f, 6.35457039e-02f, -4.01010588e-02f, 1.46044627e-01f, 1.55764699e-01f, 1.00464961e-02f, 3.86831909e-02f, 8.87364671e-02f, 2.05328450e-01f, 7.34742284e-02f,
  -4.37510862e-05f, 4.44261916e-02f, -1.79640464e-02f, 1.77681193e-01f, 2.27395222e-01f, 1.79619923e-01f, 1.06757082e-01f, 9.07012355e-03f, 1.20445572e-01f, -4.72171307e-02f,
  1.95558086e-01f, -1.07137524e-01f, 2.29558110e-01f, -4.15336601e-02f, 5.47381714e-02f, 2.73513980e-02f, 6.60487637e-02f, -1.45492658e-01f, 5.92871988e-03f, -6.42992258e-02f,
  1.98083043e-01f, 2.35050172e-01f, 1.53049594e-03f, -3.85619514e-02f, -1.58750176e-01f, -1.28565654e-01f, -1.60688590e-02f, 1.86233614e-02f, 1.07355721e-01f, 1.56433359e-01f,
  8.91852975e-02f, -2.05113724e-01f, 2.36785039e-01f, -1.00663088e-01f, -1.94479272e-01f, -8.13398063e-02f, -1.05467826e-01f, 2.71897744e-02f, 1.74086392e-01f, -1.13879561e-01f,
  1.91144068e-02f, 1.80863664e-01f, 3.13353501e-02f, -1.82406474e-02f, -5.58572970e-02f, 1.39332443e-01f, -1.09322734e-01f, -3.82812917e-02f, 1.35361165e-01f, -1.47560120e-01f,
  -4.79206145e-02f, 2.50670332e-02f, 2.82274187e-01f, -9.57899839e-02f, -1.18200965e-01f, -8.44426155e-02f, -5.55083267e-02f, 1.07737251e-01f, -2.76999585e-02f, 1.68536574e-01f,
  -2.49543097e-02f, 4.70501408e-02f, 6.92687556e-02f, -5.73205389e-02f, 1.08436555e-01f, 1.93600774e-01f, -1.37543514e-01f, 5.88030443e-02f, 2.26121601e-02f, 1.68549389e-01f,
  1.76343992e-01f, 1.68094993e-01f, 4.31658141e-02f, 5.87972887e-02f, 1.06197700e-01f, 1.62419844e-02f, -8.60975757e-02f, -9.81001779e-02f, 1.35485634e-01f, -5.93028031e-02f,
  -2.29018390e-01f, 2.65207142e-01f, -7.20127393e-03f, -2.85120070e-01f, 3.62816639e-02f, 7.66846910e-02f, 2.67203301e-02f, 3.02665740e-01f, 3.28469500e-02f, 1.25172108e-01f,
  -4.55848984e-02f, -1.57258511e-01f, -2.22211331e-01f, -2.56868631e-01f, -4.64034565e-02f, -5.13789840e-02f, -1.10960649e-02f, -1.59616545e-01f, 2.08163306e-01f, 2.67870337e-01f,
  2.34490171e-01f, 1.97675273e-01f, -1.71702027e-01f, -2.72429109e-01f, 7.16330856e-02f, 1.41962901e-01f, 5.00369072e-02f, -1.05321303e-01f, -1.13474682e-01f, -2.24026181e-02f,
  -8.91036633e-03f, -2.80440092e-01f, 3.16441581e-02f, 1.04064867e-01f, -1.52307963e-02f, 1.68263271e-01f, 1.03811603e-02f, -9.40362066e-02f, -1.25981513e-02f, 4.38173302e-03f,
  7.57729635e-02f, 6.23961464e-02f, -6.63178638e-02f, 5.66523857e-02f, 2.51769930e-01f, 1.33194998e-01f, 7.93435648e-02f, 4.22081128e-02f, 1.02173045e-01f, -6.83948994e-02f,
  9.75552648e-02f, 1.09874465e-01f, 2.77791500e-01f, 2.39708915e-01f, 2.66446918e-01f, 1.68587297e-01f, 7.08724037e-02f, -1.81779228e-02f, 8.00367519e-02f, 3.24703038e-01f,
  -6.57315403e-02f, -6.16220981e-02f, 7.90806040e-02f, -2.82643110e-01f, -1.57963336e-01f, 2.27822334e-01f, -4.48644124e-02f, -2.29413882e-01f, -3.99964750e-02f, -5.65914027e-02f,
  -3.21785323e-02f, 3.74780566e-01f, -9.73083526e-02f, 3.29299480e-01f, -9.63893980e-02f, -2.05769554e-01f, -3.05011719e-01f, -3.30261528e-01f, 2.77228266e-01f, 3.66085954e-02f,
  9.98318791e-02f, -2.36211255e-01f, -6.88506216e-02f, -1.03104979e-01f, 1.79679111e-01f, 4.30043377e-02f, 2.85258275e-02f, -1.17610246e-01f, -1.16563588e-01f, -7.31550455e-02f,
  3.05114359e-01f, -1.39953971e-01f, -3.31745371e-02f, -1.47494197e-01f, -4.05267254e-02f, -2.75241971e-01f, -1.60536215e-01f, 1.48442268e-01f, 2.09354654e-01f, 2.84294009e-01f,
  -1.38143068e-02f, 1.78232864e-01f, -7.84656778e-02f, 1.02856450e-01f, 1.64903283e-01f, -8.20079371e-02f, 1.83008283e-01f, 1.52259246e-01f, 1.17386386e-01f, 2.41646711e-02f,
  -4.75585125e-02f, 8.87436196e-02f, 7.45238364e-02f, 2.34200448e-01f, 8.27525482e-02f, -3.66820791e-03f, 8.51798058e-02f, 2.90836170e-02f, -2.07679719e-03f, 1.39086187e-01f,
  -1.22523375e-01f, -7.56794214e-03f, 1.82157636e-01f, -6.30953684e-02f, -1.06662111e-02f, -7.02468678e-02f, -7.63084367e-03f, -1.04482822e-01f, 6.00418374e-02f, -2.47965723e-01f,
  2.33082041e-01f, -4.66201752e-02f, 1.78621970e-02f, 2.35416785e-01f, -1.58768073e-02f, 5.28753214e-02f, -1.60543397e-01f, -1.10813538e-02f, -4.02453393e-02f, -3.37301418e-02f,
  6.73601702e-02f, 4.92870919e-02f, -5.04818857e-02f, -5.62289469e-02f, 1.04057051e-01f, -5.05232401e-02f, -2.53976107e-01f, -1.75300568e-01f, 2.14105193e-02f, -2.05337137e-01f,
  1.57325298e-01f, 1.06506959e-01f, 2.59131968e-01f, -1.83174059e-01f, 1.01889148e-01f, 2.31021762e-01f, -2.53869593e-01f, 2.81511426e-01f, 2.33019188e-01f, 5.08180968e-02f,
  -1.03419065e-01f, 4.88600321e-02f, 7.61626586e-02f, -2.38403529e-01f, -8.55423324e-03f, 1.86314628e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 14)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 14;
const float L1_fan_Bp_bar_data[] = {
  6.46051019e-02f, 1.21814087e-01f, 3.93156521e-02f, 1.17962301e-01f, 9.60170776e-02f, 1.08558513e-01f, -5.21339364e-02f, 2.15672433e-01f, -5.13752066e-02f, 7.97407180e-02f,
  1.83852911e-01f, -5.10100350e-02f, 1.83293112e-02f, 3.14671472e-02f
};

// L2_fan_Wp (Shape: 25 x 64)
const int L2_fan_Wp_rows = 25;
const int L2_fan_Wp_cols = 64;
const float L2_fan_Wp_data[] = {
  2.22149349e-04f, -3.63221727e-02f, -3.68123986e-02f, -4.98952828e-02f, -1.82551518e-01f, 1.39879018e-01f, 1.62888020e-02f, 3.37277427e-02f, -9.56999287e-02f, 2.69276910e-02f,
  -7.52071217e-02f, -1.63686886e-01f, -1.80792063e-01f, -2.79213954e-02f, 1.42661795e-01f, -1.05771072e-01f, -4.99322787e-02f, 6.19152337e-02f, 1.63431820e-02f, -1.65169279e-03f,
  7.94417486e-02f, -1.45537436e-01f, -8.07242170e-02f, -1.73919573e-01f, 1.00589804e-01f, -6.92035854e-02f, -1.40609518e-01f, -1.54995862e-02f, -1.07585855e-01f, 1.35491461e-01f,
  1.33639857e-01f, 7.68706277e-02f, 2.57582515e-01f, -5.51720932e-02f, 2.80965120e-01f, -4.98610828e-03f, 3.53680179e-02f, -1.51092663e-01f, -7.17462674e-02f, 6.50153235e-02f,
  -1.60469443e-01f, -9.49268192e-02f, 1.58403218e-02f, 2.07336366e-01f, 1.00443400e-01f, 7.55837038e-02f, -4.54316265e-04f, -1.80031493e-01f, -4.68175821e-02f, -1.13950424e-01f,
  6.25132248e-02f, 4.32760734e-03f, 5.89620993e-02f, 8.57272148e-02f, -1.03799380e-01f, -2.06016958e-01f, -2.89738663e-02f, -3.79638262e-02f, 2.00421706e-01f, 1.96896091e-01f,
  3.67145687e-02f, -2.93833017e-01f, -9.61210430e-02f, 7.69677311e-02f, 5.71712442e-02f, 1.12628475e-01f, 8.07926878e-02f, 7.52325803e-02f, 1.55118451e-01f, 1.40169049e-02f,
  5.81541955e-02f, 5.42470925e-02f, 3.20183896e-02f, -1.16390727e-01f, 8.09074119e-02f, -9.29630250e-02f, 1.27904862e-01f, 1.10119008e-01f, -1.10401012e-01f, 1.94343179e-02f,
  -1.14893295e-01f, -5.94419762e-02f, 1.40862063e-01f, 7.48809278e-02f, -1.30851671e-01f, -2.04461515e-02f, 2.13653401e-01f, -7.91588426e-02f, -1.38744146e-01f, -1.97584078e-01f,
  -3.13430101e-01f, -5.43192513e-02f, -7.50113502e-02f, -1.30272627e-01f, -1.57564953e-01f, 6.67168051e-02f, -4.30861488e-02f, 3.31895128e-02f, -2.90788263e-01f, -8.26200247e-02f,
  -8.64732638e-02f, 3.37289413e-03f, -7.60206729e-02f, -1.38292089e-01f, -2.48029009e-02f, 1.43855616e-01f, 5.45579866e-02f, -1.82964578e-02f, -9.46764648e-02f, 5.52416258e-02f,
  -7.76973739e-02f, -1.82255562e-02f, 6.25571907e-02f, 1.50596976e-01f, 4.19480428e-02f, 6.56450838e-02f, 9.98560265e-02f, -7.82223139e-03f, -1.21805156e-02f, -4.15325873e-02f,
  1.15558747e-02f, -1.49041533e-01f, 4.19877991e-02f, -1.37967579e-02f, 1.65981084e-01f, -1.35835826e-01f, -1.58128589e-01f, -1.44931898e-01f, -8.91942382e-02f, -3.98310646e-03f,
  8.28127190e-02f, -5.81615791e-02f, 1.96120348e-02f, 1.08771306e-02f, -6.36118054e-02f, 9.12948772e-02f, -5.21890968e-02f, 3.98265459e-02f, -4.60676476e-02f, 3.69750671e-02f,
  5.33528253e-03f, 9.77210552e-02f, -3.01874131e-01f, -8.20094049e-02f, 8.85239393e-02f, -9.10716429e-02f, 4.27401625e-02f, -3.28350207e-03f, 1.79454058e-01f, 3.63829248e-02f,
  -1.02713041e-01f, 5.45949191e-02f, 3.08208168e-02f, 6.39104396e-02f, -1.97642535e-01f, 1.88737974e-01f, 5.73303141e-02f, 1.05971813e-01f, 9.59913358e-02f, 2.61200778e-02f,
  -1.77867070e-01f, -3.46993990e-02f, 1.03711799e-01f, 6.05703741e-02f, 1.32934943e-01f, -6.68204725e-02f, -1.32698253e-01f, 1.30451277e-01f, 1.12969331e-01f, 7.27123842e-02f,
  -4.02783975e-02f, 1.23645840e-02f, -7.43348598e-02f, -2.78522708e-02f, 6.08087741e-02f, 9.01620835e-02f, 5.61974831e-02f, -2.06885636e-02f, -1.85826540e-01f, -5.35082929e-02f,
  -8.46124738e-02f, -1.02780379e-01f, 3.70395668e-02f, -1.74149826e-01f, 2.12916300e-01f, 1.08571343e-01f, -1.97954312e-01f, -1.33791551e-01f, 3.29188891e-02f, 1.07575320e-01f,
  1.06690124e-01f, 1.55197069e-01f, -8.45499486e-02f, 8.40036497e-02f, 5.96923642e-02f, -1.13116413e-01f, -5.93900010e-02f, -1.65822372e-01f, -1.76984683e-01f, -1.70615554e-01f,
  5.27183898e-02f, 1.42886266e-02f, -1.08861253e-01f, 3.64461169e-02f, 8.33358616e-02f, -5.99102341e-02f, -1.18967131e-01f, -8.15561786e-02f, 6.54265285e-02f, -8.02465603e-02f,
  -1.84740409e-01f, 6.59446940e-02f, 3.35226357e-02f, -3.86726670e-02f, -7.32276514e-02f, 1.15139247e-03f, 1.34036809e-01f, 6.29799068e-02f, 2.62353778e-01f, -8.30655321e-02f,
  2.80928403e-01f, 1.20235331e-01f, 1.03843525e-01f, 7.17910975e-02f, 1.72058135e-01f, -2.26189077e-01f, 4.82429601e-02f, 2.20428571e-01f, -1.76032752e-01f, -5.14059663e-02f,
  -2.43766561e-01f, -2.29671970e-01f, -2.20219955e-01f, -1.96039051e-01f, -5.50603457e-02f, -6.68461770e-02f, -2.47312874e-01f, -2.17181638e-01f, 5.88436015e-02f, -2.17567056e-01f,
  -2.78256148e-01f, -7.05589280e-02f, 1.07823266e-02f, -1.34109706e-01f, -4.84130234e-02f, -2.44611502e-01f, -2.16193438e-01f, 1.60609111e-01f, -1.55706435e-01f, 2.08872817e-02f,
  -9.39476714e-02f, 1.01132467e-01f, -4.97550406e-02f, 2.03538597e-01f, -3.64478528e-02f, -1.25439748e-01f, -1.96836472e-01f, 3.50815477e-03f, -4.58633155e-02f, -2.35568676e-02f,
  -1.76219836e-01f, -5.92236407e-02f, 1.43453563e-02f, -5.89455143e-02f, -5.07412925e-02f, -1.42319454e-02f, 1.17580369e-02f, 4.61655818e-02f, -1.64434776e-01f, -3.42573263e-02f,
  -3.95739488e-02f, -1.00945048e-01f, -3.27492878e-02f, 3.20315063e-02f, 9.97574702e-02f, 1.01585828e-01f, -3.97318788e-02f, -5.85295893e-02f, 1.77007429e-02f, -6.93903193e-02f,
  2.81857941e-02f, 3.25928070e-02f, -2.81930178e-01f, 1.85652390e-01f, -1.17170677e-01f, 1.45567968e-01f, 5.06994724e-02f, -2.63424255e-02f, -9.42527652e-02f, -2.72785217e-01f,
  9.26559269e-02f, -2.21129749e-02f, 1.06587417e-01f, 1.26805782e-01f, 2.04323903e-01f, -3.34957950e-02f, 9.69142914e-02f, 2.31661778e-02f, 8.81192908e-02f, 6.88255131e-02f,
  -7.89023116e-02f, 1.88952222e-01f, -2.53992844e-02f, -5.40352538e-02f, 1.58419892e-01f, 4.01123948e-02f, 3.77644077e-02f, 7.93111101e-02f, 3.32475640e-02f, 3.78767177e-02f,
  1.66934535e-01f, 5.71183376e-02f, 7.07105622e-02f, 1.84436403e-02f, -1.39929056e-01f, 7.00753778e-02f, -1.26037106e-01f, -2.10546121e-01f, -1.87059596e-01f, 1.48542508e-01f,
  6.07160144e-02f, -3.85905057e-03f, -1.18051566e-01f, -1.14154778e-01f, -8.50643665e-02f, 7.01074582e-03f, 9.98387933e-02f, 3.28235254e-02f, -8.50206092e-02f, 2.55257729e-02f,
  7.09853172e-02f, -1.12256326e-01f, -1.44485265e-01f, -1.17738023e-02f, -1.76224053e-01f, 1.10532001e-01f, -9.02352259e-02f, -4.99469079e-02f, 5.08969873e-02f, 3.69677432e-02f,
  -9.13207070e-04f, -8.03302452e-02f, -7.31617510e-02f, 4.78106812e-02f, 6.32514246e-03f, 1.79616511e-01f, -2.52265155e-01f, 2.92420805e-01f, 8.15905407e-02f, 7.41272420e-03f,
  8.83280635e-02f, 1.84682310e-01f, -9.78932902e-02f, -2.35308394e-01f, 1.22681828e-02f, -6.55974373e-02f, 2.52883285e-01f, 4.33113202e-02f, -6.96787015e-02f, -2.76416470e-03f,
  -1.05784275e-01f, -1.54740602e-01f, -1.53477743e-01f, -1.51550487e-01f, -1.11247301e-01f, -1.38913065e-01f, 2.20680237e-01f, 8.92934576e-02f, 2.64165938e-01f, -1.79546922e-01f,
  7.93737993e-02f, 4.47686948e-02f, 1.15359716e-01f, -1.27535939e-01f, 1.61188796e-01f, 5.16288020e-02f, 1.93179920e-02f, 3.78901362e-02f, -9.61398780e-02f, 1.37464136e-01f,
  -8.49414542e-02f, 1.11917548e-01f, -8.47021192e-02f, -1.05346084e-01f, -2.76194066e-01f, -3.16488696e-03f, -1.42243849e-02f, 8.18864405e-02f, -5.30753434e-02f, 1.97150074e-02f,
  4.05896306e-02f, -7.00391829e-02f, -2.62777191e-02f, 2.36462889e-04f, 1.19343661e-01f, 7.23277628e-02f, -4.89282096e-03f, 7.43506700e-02f, 1.41869307e-01f, -6.30432963e-02f,
  -5.57714812e-02f, -1.02513440e-01f, 8.93788338e-02f, 1.22847408e-01f, 2.41316427e-02f, 3.18172425e-02f, -6.39681220e-02f, 4.81645809e-04f, 3.14916372e-02f, -1.01343475e-01f,
  1.34784564e-01f, 9.64932516e-03f, 7.82986060e-02f, -3.88272144e-02f, 1.25827283e-01f, -2.31372193e-01f, 1.04819730e-01f, 1.09362863e-01f, 2.07925355e-03f, -5.99617064e-02f,
  -1.60767123e-01f, 1.76598534e-01f, 3.13623756e-01f, -5.15301898e-02f, 2.59210169e-01f, 1.23048648e-01f, 1.03054252e-02f, 2.28415895e-02f, 2.38380879e-01f, 2.99269319e-01f,
  -6.27004281e-02f, 1.31637398e-02f, -1.77659571e-01f, 4.99171428e-02f, -1.74937665e-01f, -3.07713635e-02f, -9.43116844e-02f, 1.84927925e-01f, 1.15938663e-01f, 1.75144672e-02f,
  -9.88888815e-02f, 2.01014653e-01f, 7.58142546e-02f, -1.29570693e-01f, 1.18429050e-01f, -2.04353780e-01f, -2.36163452e-01f, 1.93778023e-01f, 1.11438833e-01f, 5.97913342e-04f,
  -4.09377227e-03f, 1.10532455e-01f, 2.24750508e-02f, -4.87062484e-02f, -1.27448395e-01f, -7.87639096e-02f, -2.02457774e-02f, -7.64907077e-02f, 1.50337666e-01f, -8.26690197e-02f,
  -1.87836085e-02f, -1.59481689e-02f, -7.19883367e-02f, 4.32462320e-02f, -7.12600052e-02f, -1.20790198e-01f, -4.81469557e-02f, 1.07905753e-01f, -1.56510666e-01f, 7.01857656e-02f,
  8.78092200e-02f, -7.78433383e-02f, 1.16150513e-01f, -1.64875478e-01f, -2.20135465e-01f, -1.50288001e-01f, -2.63952762e-01f, 6.86477795e-02f, -7.14978725e-02f, 1.93974540e-01f,
  1.92764506e-01f, 1.58148974e-01f, -2.69342568e-02f, 2.66352165e-02f, 2.92080730e-01f, -1.67895406e-01f, -5.46727218e-02f, 9.05815661e-02f, -3.33147645e-01f, 1.26854062e-01f,
  3.01216125e-01f, 2.73041070e-01f, -2.51977816e-02f, -2.18125626e-01f, -1.70236319e-01f, -2.60560513e-01f, 9.04423594e-02f, 1.01053245e-01f, 1.17443301e-01f, 6.16995096e-02f,
  2.55454838e-01f, -1.06544821e-02f, -7.20030889e-02f, -3.24285030e-02f, 1.94575578e-01f, -2.01309413e-01f, 9.58442166e-02f, 1.61408752e-01f, -1.16691403e-01f, -1.06452353e-01f,
  -1.07543357e-01f, 4.69590500e-02f, 3.23932469e-02f, -1.29570544e-03f, 8.91636312e-02f, -1.55530334e-01f, -1.80503484e-02f, 7.75178475e-03f, -5.28379902e-03f, -1.09708704e-01f,
  8.40729848e-02f, -2.08668206e-02f, -7.25004449e-02f, -3.07902731e-02f, 2.88397595e-02f, 3.38782072e-02f, -1.87009186e-01f, -1.05405124e-02f, 1.74754709e-02f, -6.96026301e-03f,
  1.21295929e-01f, 1.02876052e-01f, -1.32565111e-01f, -1.33153424e-01f, 6.35704175e-02f, -6.00519963e-02f, -7.43426010e-02f, 1.82472929e-01f, -2.68163949e-01f, 2.05064952e-01f,
  1.03861131e-01f, 5.92068583e-03f, -1.14131227e-01f, 1.70958728e-01f, -2.56308615e-01f, -2.43683621e-01f, -1.98111355e-01f, -1.23351656e-01f, 9.13497061e-02f, -1.56504288e-02f,
  -1.25480846e-01f, -1.62557304e-01f, -1.71528965e-01f, 7.04354867e-02f, 4.07108441e-02f, -2.54672289e-01f, -2.32891575e-01f, -1.60658926e-01f, 4.69379984e-02f, -3.11633144e-02f,
  3.33146602e-01f, -1.04471169e-01f, 7.95981362e-02f, -2.21051872e-02f, 1.63105056e-01f, -2.50984609e-01f, 1.02416016e-01f, -1.07059687e-01f, 7.79714063e-02f, -6.33276999e-02f,
  -4.05768752e-02f, -5.97391538e-02f, -6.05501048e-02f, -9.64750499e-02f, 1.55074611e-01f, -6.08876087e-02f, 1.21735400e-02f, -5.74958734e-02f, -2.76272986e-02f, -4.66746576e-02f,
  6.38020039e-02f, -5.39360158e-02f, 2.93221120e-02f, -6.23350628e-02f, -5.01152314e-02f, -4.79610972e-02f, -8.52961466e-02f, -8.20986461e-03f, 1.34714812e-01f, 4.42963988e-02f,
  1.25053033e-01f, 7.88695365e-02f, -1.20219208e-01f, -5.87375984e-02f, 1.14790266e-02f, -2.41037868e-02f, -1.41817600e-01f, 1.49785265e-01f, 7.10545257e-02f, 2.62466576e-02f,
  -9.83164981e-02f, -8.60060602e-02f, -2.27516200e-02f, -9.78958234e-02f, 5.68514578e-02f, -1.62232175e-01f, -1.16572857e-01f, 6.31931573e-02f, 1.34482831e-01f, 1.17669098e-01f,
  -3.50256450e-02f, -2.86544729e-02f, 1.99768804e-02f, 1.67853832e-02f, -1.23676188e-01f, 3.96669917e-02f, -1.23085238e-01f, 1.16708435e-01f, 2.09957808e-01f, -1.40373513e-01f,
  7.22179040e-02f, -1.47375837e-01f, 1.24110535e-01f, -1.25618771e-01f, 4.55426192e-03f, 7.85666630e-02f, -6.94769323e-02f, 9.57112908e-02f, 2.84330621e-02f, -1.01411521e-01f,
  -5.39158583e-02f, -1.68463662e-02f, -5.21369465e-02f, -1.38866439e-01f, 1.93341747e-01f, -7.99436122e-02f, 1.19980112e-01f, -8.25026184e-02f, -2.71925256e-02f, 7.99775347e-02f,
  1.32603481e-01f, -8.73428595e-04f, -5.82642928e-02f, 1.27394106e-02f, -9.47802216e-02f, -5.31040411e-03f, -1.39873266e-01f, -5.81068434e-02f, -1.04687244e-01f, 3.03183291e-02f,
  -1.00465715e-01f, -4.21738029e-02f, 2.33626179e-02f, 8.55739787e-02f, -1.02130055e-01f, 8.14866126e-02f, 1.05039597e-01f, -1.20989889e-01f, 9.74310637e-02f, -9.17871520e-02f,
  -2.12851882e-01f, -1.32718742e-01f, -9.90763400e-03f, 8.51106793e-02f, 4.11827229e-02f, -3.79221141e-02f, -8.81054103e-02f, -6.25908375e-03f, -1.22837098e-02f, 2.00723365e-01f,
  -6.59682080e-02f, 5.06966226e-02f, 1.32561907e-01f, -1.93464890e-01f, 6.67557716e-02f, -1.15772262e-02f, 4.07664292e-02f, 3.34470393e-03f, -4.16022427e-02f, 7.13062733e-02f,
  -2.95467883e-01f, -1.69871196e-01f, 8.16279836e-03f, -1.10442795e-01f, -2.78678805e-01f, -1.92072749e-01f, -8.43473375e-02f, -1.90750342e-02f, -5.45797497e-02f, -4.19870093e-02f,
  9.94932875e-02f, 4.62070592e-02f, 9.25487131e-02f, -2.19165117e-01f, -5.05286604e-02f, -1.20777987e-01f, 7.86456242e-02f, -2.35488668e-01f, -1.94432229e-01f, 2.12110564e-01f,
  -1.88908234e-01f, 9.62479264e-02f, -4.28638346e-02f, -6.04428835e-02f, -6.43113554e-02f, -5.72566539e-02f, -7.83995837e-02f, 4.37529311e-02f, 5.17764911e-02f, -2.34895214e-01f,
  6.76943883e-02f, 5.89522049e-02f, 1.29115313e-01f, -8.35131854e-02f, 7.61528760e-02f, 2.83157686e-03f, -2.17494182e-02f, -3.19561176e-02f, 9.90282744e-02f, -1.52528018e-01f,
  1.69622619e-02f, 8.10081884e-02f, -4.11304310e-02f, -1.11546010e-01f, -2.04634354e-01f, 4.20929752e-02f, 1.61686108e-01f, 5.54235689e-02f, -5.80147132e-02f, -5.81692113e-03f,
  -7.67469332e-02f, -4.15101610e-02f, 1.21812038e-01f, -4.13989425e-02f, -1.65917471e-01f, -1.44326359e-01f, -1.22650512e-01f, -8.34721550e-02f, -2.80211568e-01f, 4.97652702e-02f,
  -2.49057487e-01f, -3.20211351e-02f, 1.23661071e-01f, -1.25726745e-01f, 7.16567561e-02f, 2.11648688e-01f, -1.17798865e-01f, -1.33312449e-01f, -1.29385144e-01f, 1.14521071e-01f,
  6.58956766e-02f, -5.40004671e-02f, 7.02153370e-02f, -4.04432714e-02f, 1.34265065e-01f, 7.29969442e-02f, -6.37876987e-02f, -1.49247693e-02f, -1.15782812e-01f, 1.61220253e-01f,
  -2.13979796e-01f, -1.03661515e-01f, 5.75854862e-03f, -4.05741110e-02f, 1.05622457e-02f, -7.69713055e-03f, -8.43095183e-02f, -1.80330113e-01f, -1.30700786e-02f, 1.35863528e-01f,
  -2.57281400e-02f, -7.63657270e-03f, -8.21408406e-02f, -4.96568307e-02f, -1.37131989e-01f, -2.12713163e-02f, 5.19253239e-02f, -6.47365153e-02f, -7.31088743e-02f, -7.69877583e-02f,
  -5.73149184e-03f, 3.27607826e-03f, -1.42265648e-01f, 6.23511747e-02f, 1.39496550e-01f, -2.53976509e-02f, 7.81914368e-02f, -5.52147254e-02f, -9.45261493e-02f, -1.22897662e-01f,
  1.53686684e-02f, -3.94513905e-02f, 6.65505081e-02f, -7.96208382e-02f, -7.42393509e-02f, -1.47493601e-01f, -2.39528447e-01f, 1.75061002e-01f, 5.36570102e-02f, 9.31089297e-02f,
  1.68650210e-01f, 8.23901501e-04f, 1.09574974e-01f, -1.66516751e-02f, 1.15470305e-01f, -2.74902135e-02f, -1.96488455e-01f, 1.38311774e-01f, -1.99295640e-01f, -1.93270236e-01f,
  5.78121990e-02f, 2.66160846e-01f, 5.87534867e-02f, -2.01447561e-01f, -1.75990060e-01f, -9.28928703e-02f, -4.86264564e-02f, 4.51405011e-02f, -7.64594078e-02f, 3.85167897e-02f,
  1.19631246e-01f, -9.76796821e-02f, 3.35123204e-02f, -2.37342268e-01f, 2.18219012e-01f, -6.26473278e-02f, 1.08206317e-01f, 1.21537812e-01f, 1.26218209e-02f, 1.95201449e-02f,
  -9.75070894e-03f, 1.61040366e-01f, 2.53239311e-02f, -1.17465124e-01f, -1.92785133e-02f, -6.60155015e-03f, 2.12744009e-02f, 1.81360915e-01f, 1.85949206e-01f, 1.08371399e-01f,
  -1.25092000e-01f, 1.11163631e-01f, -1.29795671e-01f, 2.12064832e-02f, -2.03145921e-01f, -1.00900248e-01f, -1.01639880e-02f, 1.00111395e-01f, -2.34321877e-03f, -5.02133816e-02f,
  1.40593171e-01f, 6.84749987e-03f, 2.25397989e-01f, 7.87083358e-02f, 5.67452796e-02f, -2.33292002e-02f, -1.07269129e-02f, -5.07539138e-02f, 1.42331928e-01f, 1.04427472e-01f,
  -1.39222490e-02f, 1.67400926e-01f, 2.13877857e-01f, -6.23784736e-02f, 8.93708691e-02f, 1.55321196e-01f, 2.53079295e-01f, 1.72837660e-01f, 1.23477571e-01f, -2.68322807e-02f,
  8.45548585e-02f, 2.71741956e-01f, 2.11868539e-01f, -1.45314500e-01f, 9.49244425e-02f, 1.14837438e-01f, 1.37659639e-01f, -3.19527984e-02f, -4.79807332e-02f, -2.75255479e-02f,
  3.51215601e-02f, -9.28341076e-02f, -1.67007402e-01f, -1.64010718e-01f, -4.38810699e-02f, 1.44956976e-01f, 3.91657986e-02f, -1.40871897e-01f, 1.76652238e-01f, 1.68338358e-01f,
  1.79129124e-01f, 1.75303176e-01f, -7.68145174e-02f, -1.37586832e-01f, 1.69181660e-01f, 1.45550936e-01f, -7.15318099e-02f, -3.13178971e-02f, -1.87336355e-01f, 3.75026725e-02f,
  -5.59363365e-02f, -5.53949736e-02f, -1.63387164e-01f, -1.38850644e-01f, -9.66425240e-03f, 4.31629382e-02f, -2.72664186e-02f, -1.58404201e-01f, -8.76678620e-03f, -2.10548155e-02f,
  -1.92038771e-02f, -1.48443773e-01f, 9.55351964e-02f, -8.87354091e-02f, -1.10560213e-03f, -1.25868767e-01f, -1.28713340e-01f, -8.74991715e-02f, 7.88339414e-03f, -1.52285993e-01f,
  -6.17467649e-02f, -2.17484012e-01f, -7.48558640e-02f, -1.82671040e-01f, -2.31858224e-01f, 1.80103332e-01f, 9.11675990e-02f, -3.13089974e-02f, 2.13005021e-01f, 7.73342773e-02f,
  1.56342000e-01f, -6.96572065e-02f, -1.26326337e-01f, 1.00330688e-01f, 3.65092047e-02f, -4.82453071e-02f, -1.49788707e-01f, 2.09929757e-02f, 1.30191073e-01f, 2.89938688e-01f,
  1.21766187e-01f, 9.14137289e-02f, -1.04686946e-01f, -8.80731791e-02f, -1.44655541e-01f, -9.54162180e-02f, 8.43916759e-02f, -2.74894685e-02f, 6.58821911e-02f, 8.75204802e-02f,
  -1.27044111e-01f, -6.30698353e-02f, -9.59338844e-02f, -1.61447585e-01f, 1.56991735e-01f, 1.03535205e-01f, -9.12222937e-02f, -2.09442437e-01f, -9.93849486e-02f, -2.16462910e-02f,
  -1.89775541e-01f, 5.37252007e-03f, -2.09917903e-01f, -1.85539216e-01f, -6.98825270e-02f, -1.11689560e-01f, -1.61425665e-01f, -5.68022840e-02f, 2.45475955e-02f, -7.78465122e-02f,
  -7.36196414e-02f, -1.66139454e-01f, -6.03469387e-02f, 4.55464609e-02f, 7.61043951e-02f, -7.17751384e-02f, 7.00580403e-02f, -1.34683669e-01f, -1.00485452e-01f, -1.65938288e-01f,
  -2.07260475e-01f, -1.26035854e-01f, -2.00376078e-01f, 5.31349219e-02f, -3.57978456e-02f, 1.97802618e-01f, -1.92511216e-01f, 2.18755499e-01f, 1.55775234e-01f, -1.46511242e-01f,
  1.64855141e-02f, -1.65594578e-01f, -2.62622181e-02f, -3.39933783e-01f, 8.73570815e-02f, -2.19102010e-01f, 7.20933229e-02f, -1.24233356e-02f, 1.69515610e-01f, -1.96233436e-01f,
  -7.82874599e-02f, 6.54676929e-02f, -2.11394444e-01f, -1.02426864e-01f, 5.12772053e-03f, -4.44327891e-02f, 4.35333252e-02f, 1.42819330e-01f, 6.96188733e-02f, -1.83021337e-01f,
  5.36168751e-04f, 1.02656305e-01f, -1.01303048e-01f, -1.73580155e-01f, -7.09750503e-03f, -1.21963523e-01f, 1.40723333e-01f, -8.13058764e-02f, -4.52302657e-02f, 9.24967006e-02f,
  -1.16098650e-01f, -2.40453929e-01f, -1.68462664e-01f, 5.61275296e-02f, -1.08305454e-01f, -3.13889310e-02f, -1.95467025e-01f, -9.04609188e-02f, -4.20429669e-02f, 1.00019522e-01f,
  7.66330808e-02f, 3.19020972e-02f, -8.14306899e-04f, 9.96650010e-02f, -1.07386215e-02f, 1.05808124e-01f, -1.77655384e-01f, -7.33485222e-02f, 1.26286186e-02f, 1.32754490e-01f,
  -1.51020721e-01f, 8.24714527e-02f, 5.12840934e-02f, 3.14430185e-02f, 7.36567378e-02f, -9.39971358e-02f, 6.89997822e-02f, -1.58536449e-01f, 1.70975253e-02f, -2.50758469e-01f,
  7.61462227e-02f, 4.33856584e-02f, -6.01462610e-02f, 2.86200106e-01f, -2.07975768e-02f, -9.08868294e-03f, 2.28808612e-01f, -3.03085465e-02f, 5.80755621e-03f, 7.09798634e-02f,
  6.45587966e-02f, -2.19329983e-01f, -9.40103158e-02f, 1.68319847e-02f, -7.99768716e-02f, -1.93948969e-02f, 4.41832915e-02f, 2.56817807e-02f, 6.09376132e-02f, 3.30289640e-02f,
  -1.35069713e-01f, -8.07642788e-02f, -1.86173946e-01f, -3.44311586e-03f, -1.17812246e-01f, -1.34871557e-01f, 8.89926329e-02f, -1.35530308e-01f, -5.36860935e-02f, -1.01016067e-01f,
  -5.86246289e-02f, -1.35973081e-01f, 2.05054119e-01f, 1.39216617e-01f, -1.77885428e-01f, -1.45714685e-01f, -5.57482913e-02f, -1.44399822e-01f, 5.99617697e-02f, 6.89726919e-02f,
  -6.32621944e-02f, 3.22597325e-02f, 1.06993757e-01f, 8.72025713e-02f, 2.18912780e-01f, 1.20996669e-01f, -1.15860492e-01f, 1.06302142e-01f, 1.69997305e-01f, 7.09262043e-02f,
  -5.98120354e-02f, -4.10467237e-02f, 1.49064824e-01f, -5.81600741e-02f, -3.44836749e-02f, 3.43113728e-02f, 9.27793160e-02f, 1.22795902e-01f, 1.11642450e-01f, 1.63417891e-01f,
  7.59524927e-02f, 1.13446787e-01f, 1.95312649e-02f, 3.44442502e-02f, -2.27925062e-01f, 9.06145424e-02f, -2.13844150e-01f, -1.73363253e-01f, -8.34039599e-02f, -1.61908329e-01f,
  -9.05741081e-02f, 1.07976966e-01f, -1.44438162e-01f, -1.07915841e-01f, 1.99484497e-01f, 1.32977083e-01f, 1.84279010e-01f, -2.96288952e-02f, 3.10015291e-01f, 2.40684643e-01f,
  9.43405852e-02f, 1.28933877e-01f, 1.32492989e-01f, 1.92867126e-02f, 4.39929627e-02f, 1.83014050e-01f, 1.66444957e-01f, 8.42102543e-02f, -1.59596339e-01f, -4.66512702e-02f,
  -1.66595519e-01f, 7.29614347e-02f, 1.61150768e-01f, -9.16378275e-02f, 5.79202808e-02f, 2.42649093e-01f, 2.86846399e-01f, -5.41841947e-02f, 5.71508855e-02f, -6.06119521e-02f,
  -4.46689576e-02f, 3.28010976e-01f, -1.77357476e-02f, -1.71125174e-01f, 9.28671584e-02f, -9.22664478e-02f, 2.16574389e-02f, 9.65625718e-02f, -2.86624022e-02f, 5.90810366e-02f,
  1.33855790e-01f, 4.54883873e-02f, 8.38403478e-02f, 1.10378727e-01f, 5.16557656e-02f, -2.43432429e-02f, 1.33121327e-01f, -1.12431072e-01f, 4.79089208e-02f, 9.11220089e-02f,
  -1.25887573e-01f, -8.72060005e-03f, 8.14552456e-02f, -1.16441779e-01f, 5.48166484e-02f, 1.04068927e-02f, -7.45068416e-02f, 1.61639810e-01f, 6.95068836e-02f, 8.04686695e-02f,
  1.38687789e-01f, -1.45535693e-01f, -3.20432074e-02f, -1.33545667e-01f, -1.54102936e-01f, -1.17822498e-01f, 6.67116139e-03f, -1.70802504e-01f, -1.39835820e-01f, 2.61383764e-02f,
  1.62708238e-01f, -1.50420457e-01f, 1.96908742e-01f, 1.09982826e-01f, -2.89510518e-01f, 8.45754445e-02f, 1.47216395e-01f, 2.02626556e-01f, 1.19794048e-01f, 2.42814980e-02f,
  6.38508722e-02f, 9.89916027e-02f, -1.64984852e-01f, -2.42152773e-02f, -4.11340035e-02f, 7.89418742e-02f, 1.01819135e-01f, 1.33442774e-01f, 2.87484992e-02f, -1.75676099e-03f,
  9.04306993e-02f, -2.41726730e-02f, 2.06272176e-04f, 5.59488721e-02f, -1.54377341e-01f, 2.20962241e-01f, -2.13337034e-01f, 2.99745370e-02f, -8.06739628e-02f, 4.54063751e-02f,
  1.05045646e-01f, -6.64078668e-02f, 1.38710335e-01f, 6.85401727e-03f, -1.19882599e-01f, 1.00009412e-01f, 1.36916086e-01f, 1.33830592e-01f, 4.60965447e-02f, -2.24941187e-02f,
  2.33273685e-01f, 4.85601015e-02f, 1.98054612e-02f, -1.18136220e-01f, -2.58909501e-02f, -5.21874661e-03f, -1.44371867e-01f, 1.56645760e-01f, -2.59862430e-02f, -1.13679014e-01f,
  -1.54621359e-02f, -4.09294292e-02f, -1.14045449e-01f, -1.44385204e-01f, -1.11224569e-01f, 1.74241457e-02f, 9.08866618e-03f, 5.83383143e-02f, -8.16505700e-02f, -4.58602048e-02f,
  -1.94119528e-01f, -2.13137940e-01f, -2.21664742e-01f, 1.77923679e-01f, 3.06832850e-01f, 5.70617504e-02f, 1.82068199e-01f, 1.80907875e-01f, 8.00318792e-02f, 4.35075387e-02f,
  1.61864027e-01f, 1.62647739e-01f, 4.39503826e-02f, 1.00118071e-01f, 3.89569774e-02f, -1.40810013e-02f, 3.33604142e-02f, 1.15661435e-01f, 9.71033797e-02f, 1.10259809e-01f,
  4.99623194e-02f, 8.48117471e-02f, -1.71471640e-01f, 1.29097849e-01f, 2.17336893e-01f, -3.13916653e-02f, -3.84307164e-03f, -2.03498840e-01f, -1.47767544e-01f, 2.08136141e-01f,
  -7.08024949e-02f, -8.52164328e-02f, -1.06717668e-01f, 8.52371529e-02f, 1.95855498e-02f, 4.85640466e-02f, 7.37647573e-03f, -3.70452832e-03f, -1.85878620e-01f, 3.66400667e-02f,
  -1.44947097e-01f, -1.81029439e-02f, -8.74375403e-02f, 2.44082902e-02f, -1.03871278e-01f, -9.12014842e-02f, 1.39545500e-02f, -1.69131011e-01f, 3.12395357e-02f, 8.06880146e-02f,
  1.49838194e-01f, 1.07360728e-01f, -1.00456774e-01f, -2.98612043e-02f, 9.14732888e-02f, -7.97470883e-02f, 8.87837932e-02f, 1.82088107e-01f, 4.88695987e-02f, 3.04600328e-01f,
  2.00224966e-01f, -2.50213891e-02f, 7.17923939e-02f, -3.89533006e-02f, 3.21479529e-01f, 6.10990040e-02f, 1.98434502e-01f, -1.36033565e-01f, -1.85314178e-01f, 1.31174892e-01f,
  1.35206997e-01f, -2.51078159e-01f, -1.17211968e-01f, 1.83598921e-01f, -1.08249579e-02f, 1.34227678e-01f, 1.11311868e-01f, 9.58637148e-02f, 1.57024413e-02f, -2.03235015e-01f,
  -1.41492620e-01f, -2.15030447e-01f, -1.57240346e-01f, -6.66575506e-02f, 8.03825706e-02f, -2.07435191e-01f, 2.31797621e-02f, -1.00310473e-02f, -1.90465171e-02f, -2.54156049e-02f,
  -4.25269306e-02f, -2.49117073e-02f, 6.42370433e-02f, 7.97633752e-02f, 8.63077492e-02f, 4.68409015e-03f, -3.02210171e-02f, 2.92328969e-02f, 7.99943358e-02f, 8.02980457e-03f,
  -1.32254899e-01f, 6.10274961e-03f, 2.79632434e-02f, -6.66031474e-03f, 1.12419680e-01f, 8.84957537e-02f, 3.73390839e-02f, -3.72691639e-02f, -1.00501858e-01f, 6.19772635e-02f,
  -3.80041264e-02f, 1.28269583e-01f, 5.03163636e-02f, 7.75210559e-02f, 7.71785304e-02f, 8.14258978e-02f, 9.50974375e-02f, 1.23775773e-01f, 2.11383356e-03f, -5.80618083e-02f,
  -6.59133345e-02f, -1.02976866e-01f, -1.74369469e-01f, -4.67207795e-03f, -4.83681373e-02f, 6.15077838e-02f, -1.05928257e-01f, 2.85841018e-01f, -8.76185894e-02f, 1.53166920e-01f,
  2.07898498e-01f, -1.19807618e-02f, -2.39547834e-01f, 5.11360504e-02f, -4.16775607e-02f, -1.46314576e-01f, -3.54735889e-02f, 7.13570118e-02f, -5.59710041e-02f, -1.12040997e-01f,
  -7.27041960e-02f, 3.77515480e-02f, 8.59564245e-02f, -2.00060569e-02f, -5.59399500e-02f, 4.29797582e-02f, -7.03159198e-02f, -6.13341220e-02f, -1.64294918e-03f, -5.30081429e-02f,
  5.35729863e-02f, 2.09994409e-02f, -2.96231406e-03f, 6.45374954e-02f, -8.35786760e-02f, 1.56295061e-01f, 2.57307917e-01f, -1.51998043e-01f, 1.38162121e-01f, -5.77191897e-02f,
  -5.50041310e-02f, -7.36941397e-02f, -1.37182087e-01f, -5.39446715e-03f, -1.13972239e-01f, 1.31009266e-01f, 7.39408098e-03f, -2.06082668e-02f, -9.89062935e-02f, -1.65084377e-01f,
  -1.83228180e-01f, -7.70390555e-02f, -1.99376613e-01f, 1.47425607e-01f, 2.15579011e-02f, 1.25655010e-01f, 5.64789549e-02f, 4.05903533e-02f, 5.23397624e-02f, -7.77023286e-02f,
  -2.48232321e-03f, 1.58140391e-01f, 1.08898744e-01f, -6.72167987e-02f, 9.67541113e-02f, 2.58954495e-01f, 5.52955233e-02f, 6.91143870e-02f, 2.73701817e-01f, 8.86229053e-03f,
  -1.84833735e-01f, 1.01936907e-01f, 2.07503080e-01f, 1.45140275e-01f, 2.67834276e-01f, -8.57312679e-02f, -1.27819926e-01f, 1.84833393e-01f, -4.82116714e-02f, -2.32669964e-01f,
  1.60417631e-02f, -1.34257032e-02f, -8.22373778e-02f, -6.19013533e-02f, 4.24988531e-02f, 1.79508403e-01f, 1.85028985e-01f, 2.64799707e-02f, -1.66148424e-01f, -1.44222483e-01f,
  -3.56463832e-03f, 5.36183119e-02f, 9.88536328e-02f, 4.67957370e-03f, 2.34987810e-01f, 2.91092694e-02f, -1.41475692e-01f, 1.09454632e-01f, -2.00949177e-01f, -7.91427121e-03f,
  1.63661033e-01f, 4.96014170e-02f, 1.69700205e-01f, 6.58954233e-02f, 1.15455568e-01f, -7.06769712e-03f, -6.29596114e-02f, -1.16621278e-01f, -3.91342901e-02f, 7.65483379e-02f,
  1.56394184e-01f, 9.70035568e-02f, -1.16954215e-01f, -9.14257616e-02f, 2.42870357e-02f, 2.49927323e-02f, -2.45069638e-02f, -7.65253371e-03f, -1.82045233e-02f, -4.85677011e-02f,
  -1.48940846e-01f, -4.83873561e-02f, -3.76862176e-02f, -1.26306802e-01f, 8.70043039e-02f, -2.64925491e-02f, -2.45916154e-02f, -4.66278605e-02f, 1.04351938e-01f, -1.87278688e-01f,
  1.24004245e-01f, 2.38132868e-02f, -1.47107571e-01f, 1.06079571e-01f, 9.26940441e-02f, 4.98238131e-02f, -1.01831090e-02f, 1.13098048e-01f, -2.73974240e-01f, -2.27623098e-02f,
  7.42564071e-03f, 5.87584265e-02f, -2.01819390e-01f, -2.07014401e-02f, 2.21718219e-03f, -9.76469964e-02f, -1.02499135e-01f, 1.04395926e-01f, -7.55974427e-02f, -6.59066215e-02f,
  -5.43033704e-02f, 1.66052654e-02f, -5.97312748e-02f, -5.79924211e-02f, 1.48978531e-01f, 4.11211401e-02f, -1.79468557e-01f, 2.01017559e-01f, -2.55624264e-01f, 1.09078273e-01f,
  -9.60085988e-02f, 1.19444989e-02f, 4.89738910e-03f, 6.25666231e-02f, 1.50607536e-02f, -2.04734489e-01f, 3.65458243e-02f, -8.60709324e-02f, 6.98870793e-02f, -1.03871621e-01f,
  1.01701505e-01f, -1.31006837e-01f, -6.94831833e-02f, -1.12197977e-02f, 1.16440594e-01f, 9.25675035e-02f, 3.17187188e-03f, -2.69313529e-02f, 8.32839534e-02f, -1.61768515e-02f,
  5.58800586e-02f, 6.51632026e-02f, 2.45846016e-03f, 5.53683639e-02f, -1.00794032e-01f, 1.16233379e-01f, 1.19891152e-01f, -5.68313040e-02f, 5.19740433e-02f, 1.65307194e-01f,
  6.08989522e-02f, -8.46344009e-02f, 9.10271928e-02f, -1.41594233e-02f, 1.47766843e-01f, 4.71109562e-02f, 8.69912282e-02f, -3.76701429e-02f, 1.75258666e-02f, 2.43699905e-02f,
  -3.78520377e-02f, 2.25849241e-01f, -3.24276954e-01f, -4.54744436e-02f, -1.60898179e-01f, 1.37511507e-01f, 3.42380852e-02f, -7.42197707e-02f, -3.18763554e-01f, -1.32245094e-01f,
  8.22976679e-02f, 5.29752672e-03f, -6.35638684e-02f, -8.04506689e-02f, -2.86407351e-01f, 4.79953773e-02f, -9.09327641e-02f, -1.69749692e-01f, -8.65806490e-02f, -5.62793948e-02f,
  -1.23490840e-01f, 2.31957510e-01f, -1.63959146e-01f, 1.71228275e-02f, -6.80728033e-02f, 2.19895761e-03f, 3.23784836e-02f, 2.73171008e-01f, 9.20840204e-02f, 1.90428570e-02f
};

// L2_fan_Wp_bar (Shape: 14 x 64)
const int L2_fan_Wp_bar_rows = 14;
const int L2_fan_Wp_bar_cols = 64;
const float L2_fan_Wp_bar_data[] = {
  1.20591283e-01f, -1.99595839e-02f, 3.69512886e-02f, 1.46891043e-01f, 1.29045263e-01f, -7.02120438e-02f, 1.47598892e-01f, 2.09048286e-01f, -5.40608242e-02f, -3.20672467e-02f,
  2.81699263e-02f, -3.15369740e-02f, 2.18417204e-04f, 7.42669776e-02f, -5.89750111e-02f, 2.15710327e-01f, 1.10039651e-01f, 1.00392416e-01f, 1.92659035e-01f, -1.63923968e-02f,
  -5.85713610e-02f, 1.53663546e-01f, 2.21552595e-01f, 1.96713001e-01f, 2.00488076e-01f, 3.05515766e-01f, 1.96345728e-02f, 2.82013059e-01f, 2.24780831e-02f, -7.44489431e-02f,
  -4.95415553e-02f, 4.81651500e-02f, -3.87929291e-01f, -2.35040590e-01f, -3.99713516e-02f, 1.01327419e-01f, 1.25826746e-01f, -8.81268010e-02f, -1.68047130e-01f, 1.04281925e-01f,
  -5.16294986e-02f, -1.24331243e-01f, -7.52311274e-02f, -3.13874543e-01f, -1.46948054e-01f, -1.56482652e-01f, 5.77797890e-02f, 2.22645700e-01f, 3.65386516e-01f, 3.18959542e-02f,
  6.01917021e-02f, 1.41511723e-01f, 1.80203035e-01f, -7.28808567e-02f, 3.22617948e-01f, 1.23155385e-01f, 3.20612520e-01f, 2.09229663e-01f, -8.66289735e-02f, 7.27198496e-02f,
  5.67730926e-02f, 3.14594597e-01f, 2.09273070e-01f, -5.18515632e-02f, 1.16525553e-01f, 1.25755772e-01f, 5.48816361e-02f, 1.16455920e-01f, 1.37268603e-01f, -9.90450606e-02f,
  -6.11930192e-02f, 9.26106051e-02f, 3.27678353e-01f, 8.33263341e-03f, 3.32816914e-02f, 2.05732003e-01f, 5.63883921e-03f, 8.62529352e-02f, -9.48377550e-02f, 1.56469300e-01f,
  8.71666893e-02f, 5.79143241e-02f, 1.69250086e-01f, 1.29647762e-01f, 2.19427019e-01f, 7.28260819e-03f, -4.00027595e-02f, 2.99336553e-01f, 2.05567360e-01f, 1.45768866e-01f,
  1.84723258e-01f, -9.17612668e-03f, 2.66525149e-02f, 2.41614152e-02f, -4.27291207e-02f, -6.03492297e-02f, -2.74082750e-01f, 3.10100377e-01f, -2.18080118e-01f, 1.64705247e-01f,
  -1.88431680e-01f, -1.40080657e-02f, -2.75830954e-01f, 1.52744606e-01f, 2.10619345e-02f, -1.01971008e-01f, -2.10031793e-01f, -1.44145504e-01f, -4.86067832e-02f, -1.51209116e-01f,
  -1.06586985e-01f, 2.34207496e-01f, -1.97407499e-01f, 2.58962899e-01f, 8.65279734e-02f, -5.79555072e-02f, -1.00215770e-01f, 1.11600973e-01f, -5.97620271e-02f, 3.43985558e-02f,
  1.34260833e-01f, 1.15060776e-01f, -1.49367854e-01f, 2.79418938e-02f, 1.69533268e-02f, 3.83334875e-01f, 2.88870543e-01f, -1.87217118e-03f, 1.08275995e-01f, -6.42302930e-02f,
  1.38365030e-01f, 7.46087879e-02f, 6.55225618e-03f, -1.93102658e-02f, 1.89493771e-03f, 1.88841030e-01f, 1.74164742e-01f, -1.03447484e-02f, 9.77132469e-02f, 9.00776684e-02f,
  -1.42303616e-01f, 3.92380171e-02f, -1.27196044e-01f, 1.16565615e-01f, 5.75469546e-02f, 1.94289744e-01f, 1.25308201e-01f, 6.15413971e-02f, 1.48727849e-01f, 1.58360481e-01f,
  -1.05815351e-01f, 6.52137101e-02f, -2.77719647e-02f, 2.49218017e-01f, -3.16437811e-01f, 1.48001283e-01f, -2.50065085e-02f, -9.91213918e-02f, 1.78240582e-01f, -1.80568799e-01f,
  -2.57952243e-01f, -9.51910317e-02f, 1.79021686e-01f, -1.44292368e-02f, 7.71713257e-02f, 8.02515224e-02f, 1.31124809e-01f, 2.00299650e-01f, 1.82338059e-01f, -8.83416533e-02f,
  -2.39355981e-01f, 4.58746180e-02f, 1.89864039e-01f, 4.32766043e-02f, 1.85070112e-01f, 2.36884460e-01f, 3.78735997e-02f, -1.03103794e-01f, -1.34726897e-01f, 4.43456657e-02f,
  2.87713334e-02f, 9.65863913e-02f, 1.28895432e-01f, -9.46060643e-02f, 2.87234187e-01f, 1.50141478e-01f, 2.63557620e-02f, 2.64791995e-01f, 3.33817750e-02f, -9.65346918e-02f,
  8.57730769e-03f, 2.03597888e-01f, 2.54993528e-01f, 2.81928238e-02f, 4.30206545e-02f, 1.23109356e-01f, 1.26210988e-01f, 1.66746005e-01f, 1.09814964e-01f, 2.17456043e-01f,
  1.77079082e-01f, 2.00523570e-01f, 7.37756491e-02f, 1.19828498e-02f, 6.53446317e-02f, 6.01846874e-02f, -2.46241853e-01f, 3.57883960e-01f, -1.02258455e-02f, 7.45187402e-02f,
  1.21688701e-01f, 2.67159671e-01f, 2.13096663e-01f, 2.81482011e-01f, 2.19355315e-01f, 1.95555642e-01f, 1.37046322e-01f, -7.19528412e-03f, -8.49312544e-03f, 8.92144293e-02f,
  -2.07041979e-01f, 5.83616085e-02f, 7.68093914e-02f, 2.89824486e-01f, -6.96554258e-02f, 9.13848802e-02f, 1.07843757e-01f, 2.85756111e-01f, 2.81388164e-01f, -2.88237989e-01f,
  -1.85260355e-01f, 2.21483767e-01f, -7.29381144e-02f, -1.96596414e-01f, 3.23071867e-01f, 7.31881857e-02f, 1.46196680e-02f, -1.34488449e-01f, 1.24209020e-02f, 1.48600906e-01f,
  -1.10552413e-02f, -1.82338774e-01f, 7.29957744e-02f, -5.63774817e-02f, 3.00693274e-01f, 1.98700324e-01f, 2.14764312e-01f, 3.54630202e-02f, 2.83312380e-01f, 1.24308623e-01f,
  -1.77376680e-02f, 6.47091419e-02f, -1.48896603e-02f, 1.23785913e-01f, 3.71893913e-01f, 1.52589008e-01f, 2.04321772e-01f, 5.72164319e-02f, 7.44993240e-02f, -1.01746619e-02f,
  2.21296549e-01f, 4.07103226e-02f, 2.48200297e-02f, 1.57702893e-01f, 1.80570796e-01f, 1.16240196e-01f, 2.13182703e-01f, 7.73075372e-02f, 1.51342735e-01f, 2.87403958e-03f,
  2.81890342e-03f, -2.74978746e-02f, 1.20817363e-01f, 1.20775498e-01f, 2.05790773e-02f, 6.01487905e-02f, 1.10869981e-01f, 1.75960977e-02f, 1.53021991e-01f, 2.53108978e-01f,
  1.22694224e-01f, 1.19864084e-01f, 3.49007607e-01f, 4.81233224e-02f, 3.54211867e-01f, 5.84673211e-02f, 1.09530166e-01f, 6.69559464e-02f, -2.54451454e-01f, 8.22155997e-02f,
  -1.74295798e-01f, 2.01092094e-01f, -3.00816894e-01f, 4.24760841e-02f, -4.08872962e-02f, 1.56874761e-01f, 8.21429491e-02f, 6.58132434e-02f, -3.12986404e-01f, -2.27997616e-01f,
  1.07072726e-01f, 3.87861803e-02f, -1.04402199e-01f, 2.85946429e-01f, -1.35232642e-01f, 1.58246204e-01f, 1.18080676e-01f, -8.29438213e-03f, -2.25214675e-01f, 1.25749186e-01f,
  1.98275015e-01f, 2.06319302e-01f, -2.44523678e-02f, 1.32168502e-01f, 2.34545730e-02f, -2.45183948e-02f, 1.42582685e-01f, 2.66173720e-01f, 1.53080076e-01f, -1.69586185e-02f,
  1.42492754e-02f, -4.39248495e-02f, -3.65678850e-03f, 1.16443492e-01f, 1.92536429e-01f, 1.99499547e-01f, 2.59644181e-01f, -6.44268841e-02f, 1.53206855e-01f, 1.26619814e-02f,
  8.80050957e-02f, -4.47388226e-03f, 1.64827973e-01f, 1.68559745e-01f, -3.26086432e-02f, 1.23383977e-01f, 1.50232419e-01f, 9.56307426e-02f, 2.20316470e-01f, -4.36403230e-02f,
  3.16015482e-02f, 1.72290638e-01f, 2.50858236e-02f, 1.69410408e-01f, 5.75243346e-02f, 2.20682710e-01f, -2.57171243e-01f, -1.40629178e-02f, -1.64479092e-01f, -1.80564865e-01f,
  -1.05451867e-01f, -2.42290720e-01f, -6.68642223e-02f, 1.87965631e-01f, -6.14977777e-02f, 1.47868060e-02f, 2.41538301e-01f, 3.12076360e-01f, 3.24759066e-01f, 1.53957129e-01f,
  1.44933462e-01f, 2.05125809e-01f, 8.18898082e-02f, 9.73585099e-02f, 3.29791516e-01f, 1.69328645e-01f, 5.03427628e-03f, 2.40119815e-01f, 2.05847830e-01f, 2.05639705e-01f,
  -1.77806932e-02f, -1.24414200e-02f, -5.98357841e-02f, 2.83030599e-01f, 3.07051726e-02f, -1.01436399e-01f, 6.62915185e-02f, 9.13458690e-02f, 1.57107979e-01f, 1.98802091e-02f,
  1.13843247e-01f, -1.71032637e-01f, 1.11654066e-01f, 3.24994028e-01f, 1.37143388e-01f, 1.16826378e-01f, 8.04843083e-02f, 1.75871432e-01f, -1.55638801e-02f, 2.74798930e-01f,
  9.89282951e-02f, 6.19198047e-02f, 7.90386647e-02f, 1.16053633e-01f, 4.39024903e-02f, -4.95649837e-02f, -9.59261656e-02f, 8.06424618e-02f, -2.17672423e-01f, 1.81774661e-01f,
  -1.01746423e-02f, 3.00678052e-02f, 9.11792070e-02f, 1.20755620e-01f, 7.80988559e-02f, 2.66594380e-01f, 1.97732747e-01f, 9.32372063e-02f, 1.26042888e-01f, 3.60038988e-02f,
  -2.09646404e-01f, 1.92071617e-01f, -2.11118445e-01f, -1.05537593e-01f, 2.31629372e-01f, 1.22374557e-01f, 1.06256548e-02f, 2.78475881e-01f, 8.17522481e-02f, 9.07524154e-02f,
  2.32034937e-01f, -7.64544401e-03f, -7.83953071e-02f, 2.08950922e-01f, 1.56091914e-01f, -9.91956666e-02f, 2.05202341e-01f, -2.72088889e-02f, 1.55664589e-02f, -1.29537329e-01f,
  4.08911034e-02f, 1.68979451e-01f, 9.22374055e-02f, -2.48923041e-02f, -8.77671018e-02f, -4.95294146e-02f, -2.75600236e-02f, 1.97477359e-02f, 5.13359234e-02f, -2.10306302e-01f,
  4.22190249e-01f, 1.62351057e-01f, 2.15455577e-01f, 8.76223892e-02f, -9.15769115e-02f, 3.36485319e-02f, 3.62860233e-01f, 3.39091234e-02f, 2.31976524e-01f, 1.80668518e-01f,
  2.62573391e-01f, 2.87034482e-01f, 1.68646008e-01f, 2.57491410e-01f, 2.08329763e-02f, 7.59771690e-02f, 2.73963779e-01f, 2.78720319e-01f, -7.14465557e-03f, 2.05597267e-01f,
  4.66884151e-02f, -4.75682970e-03f, -9.21198353e-02f, 5.05279675e-02f, 1.87165990e-01f, 1.02163434e-01f, 4.92180474e-02f, 1.30571365e-01f, 2.97403514e-01f, 4.78015058e-02f,
  1.28312796e-01f, 2.60131329e-01f, 1.63395688e-01f, -1.23841852e-01f, 5.38635291e-02f, -3.09118539e-01f, -2.87243515e-01f, 3.00448034e-02f, -3.93833853e-02f, 5.75289987e-02f,
  2.88714170e-01f, 3.83374423e-01f, 1.75662920e-01f, 2.18305667e-03f, -1.84475511e-01f, -4.96759340e-02f, 1.40355807e-02f, 2.61388183e-01f, -3.62299830e-02f, -7.13814422e-02f,
  2.51096278e-01f, 3.00679207e-01f, 2.24265367e-01f, -1.00824848e-01f, -2.85900414e-01f, -1.85570240e-01f, -3.28906238e-01f, 1.43052891e-01f, 4.14090864e-02f, 7.28778243e-02f,
  -2.03192513e-02f, 2.90788978e-01f, -1.63467824e-02f, 1.37647197e-01f, 1.59430936e-01f, 1.99881196e-01f, 2.52496213e-01f, 1.49334997e-01f, 1.40203105e-03f, -4.33562696e-02f,
  2.42060155e-01f, 2.22715616e-01f, 1.17374107e-01f, 1.85879096e-02f, 2.24670038e-01f, -1.01054192e-01f, -6.61269110e-03f, 7.06001297e-02f, 1.09741330e-01f, 1.15992874e-01f,
  1.31828770e-01f, -7.98432678e-02f, 3.38837840e-02f, 6.98091788e-03f, 1.15918063e-01f, 1.54095024e-01f, 9.77534503e-02f, 1.52883470e-01f, 1.36495590e-01f, 1.77382082e-01f,
  5.50186336e-02f, 3.73481847e-02f, -1.88242674e-01f, -6.22394821e-03f, 1.19931959e-01f, 1.11858010e-01f, 1.54739007e-01f, 1.86363921e-01f, -2.79682130e-01f, 1.01877950e-01f,
  -9.77389887e-03f, -2.00523466e-01f, -2.42316365e-01f, 2.24593580e-01f, -2.66219199e-01f, -3.44042271e-01f, -3.30970585e-01f, -1.11278668e-02f, 1.12219036e-01f, -1.46490186e-01f,
  -8.26122016e-02f, -1.23635761e-01f, -2.55324394e-01f, -6.25579134e-02f, 2.32295860e-02f, -2.56736130e-01f, -3.96546632e-01f, -2.16282949e-01f, 2.73251623e-01f, 1.58255085e-01f,
  3.74596685e-01f, -6.87456354e-02f, 2.71753669e-01f, 1.95118636e-01f, 2.89127618e-01f, -2.19339758e-01f, 2.27197900e-01f, 2.80972958e-01f, 1.40437767e-01f, 7.69134238e-02f,
  7.61341527e-02f, 2.70352721e-01f, 1.49650559e-01f, -5.02779754e-03f, 2.07935855e-01f, -1.09700307e-01f, 1.61723077e-01f, -4.84864600e-02f, 2.30137348e-01f, 1.33055067e-02f,
  2.15841174e-01f, -7.43866861e-02f, 1.11732647e-01f, 2.75234710e-02f, 2.05731243e-02f, 1.58719774e-02f, 2.36700580e-01f, 7.72941634e-02f, 1.98584750e-01f, 7.82026574e-02f,
  -1.63745123e-03f, 1.41792685e-01f, 2.03782097e-01f, 1.56221047e-01f, 1.32082954e-01f, 1.08287316e-02f, 2.13982031e-01f, 1.31506488e-01f, 1.26015112e-01f, 3.67932245e-02f,
  -9.53219738e-03f, 3.95159200e-02f, -7.74653777e-02f, 1.06574148e-01f, -1.06028117e-01f, -1.59703836e-01f, -1.09027013e-01f, -1.58574805e-01f, -1.70075253e-01f, 2.04375237e-01f,
  -2.32782811e-01f, -1.04539514e-01f, 4.16615512e-03f, 1.83542505e-01f, 2.42634624e-01f, 1.23876423e-01f, 2.26052895e-01f, 2.40280077e-01f, -7.41867647e-02f, -4.75136116e-02f,
  -1.11391405e-02f, -1.26705179e-02f, 1.10558189e-01f, 2.47804657e-01f, -2.66867671e-02f, 1.80684984e-01f, 6.62576109e-02f, 1.95321590e-01f, -1.72210321e-01f, 2.07386315e-01f,
  2.32778981e-01f, 1.42429426e-01f, 1.78093374e-01f, 2.09668159e-01f, 4.62640375e-02f, 1.51071340e-01f, 2.48424843e-01f, 1.50188357e-01f, 2.28728771e-01f, 2.28508428e-01f,
  1.86611488e-01f, 2.59202629e-01f, 4.23503295e-02f, 1.01049086e-02f, 1.36532977e-01f, 9.00679678e-02f, -1.04193695e-01f, 1.86929613e-01f, 3.23902249e-01f, 7.03358874e-02f,
  7.83508345e-02f, 9.80012640e-02f, -5.67581877e-02f, 5.87836653e-02f, -1.26882970e-01f, 1.69450387e-01f, 1.48283571e-01f, 1.47469804e-01f, 2.05807596e-01f, 2.12450892e-01f,
  -1.00448579e-01f, 1.76171839e-01f, 2.65039444e-01f, 1.83128759e-01f, 1.22834668e-01f, -1.50672466e-01f, -4.65857424e-02f, -1.68806955e-01f, -1.55572712e-01f, 1.14956878e-01f,
  -2.49187216e-01f, 2.51139998e-01f, 1.24033704e-01f, -8.14455673e-02f, 6.04020655e-02f, 2.21326143e-01f, 6.09275512e-03f, -5.43320663e-02f, -1.24431454e-01f, 3.04057419e-01f,
  -4.11327660e-01f, 7.37297395e-03f, 3.16708326e-01f, 2.68530011e-01f, -2.85680085e-01f, -2.98469365e-01f, -3.04210603e-01f, -1.31941363e-01f, -8.21618065e-02f, -6.03307411e-02f,
  2.78382659e-01f, 2.30019331e-01f, 3.12831372e-01f, -8.15750882e-02f, 8.50932375e-02f, 5.37558608e-02f, 1.67673886e-01f, -3.00901476e-02f, -6.06026091e-02f, 1.98538661e-01f,
  7.57723767e-03f, -1.57793108e-02f, 7.62370229e-02f, -9.17023718e-02f, -2.00732216e-01f, -2.32051447e-01f, -6.97826669e-02f, 5.70510775e-02f, -1.94373980e-01f, -7.22823143e-02f,
  5.15125468e-02f, 1.01864740e-01f, -2.67693847e-01f, -1.11200176e-02f, -6.55543711e-03f, 5.68715343e-03f, -3.48043367e-02f, 6.31322488e-02f, 1.38965219e-01f, 3.17120254e-02f,
  -7.49680251e-02f, -2.21736897e-02f, -1.70286298e-02f, -1.62338600e-01f, -2.98242271e-02f, -1.01049893e-01f, -7.77155459e-02f, -8.67424011e-02f, 9.24044624e-02f, 1.27889551e-02f,
  -1.72675565e-01f, 2.19137505e-01f, -1.04982994e-01f, 1.18516646e-01f, 2.96397239e-01f, 9.86248162e-03f, -1.09726608e-01f, -5.38683057e-01f, 3.49749804e-01f, -2.27897018e-01f,
  1.48843348e-01f, 1.70678925e-02f, -8.47382173e-02f, 1.00099873e-02f, 1.20820157e-01f, -4.56725173e-02f, -6.25967011e-02f, 1.19107611e-01f, 3.08879968e-02f, -5.15311882e-02f,
  3.26137036e-01f, 2.98543219e-02f, 2.96518803e-01f, -2.04076320e-01f, 1.89825237e-01f, 1.90543503e-01f, 3.12735200e-01f, -1.12698199e-02f, 1.98366284e-01f, -4.22047786e-02f,
  1.74712285e-01f, -1.14833608e-01f, 1.80356130e-01f, 3.65316808e-01f, -8.62955600e-02f, -9.46010500e-02f, -3.02482516e-01f, 1.96777970e-01f, -1.29749523e-02f, 1.74347714e-01f,
  1.11805433e-02f, 2.54954070e-01f, 1.52861908e-01f, 9.13281813e-02f, 8.07840005e-02f, 1.19486801e-01f, 3.82732935e-02f, 8.37764665e-02f, 3.30785304e-01f, 1.67844743e-01f,
  3.26445460e-01f, 1.44919589e-01f, 1.46550953e-01f, 1.84107129e-03f, 1.02966025e-01f, 9.39829499e-02f, 2.31559440e-01f, 7.61804134e-02f, 2.11832672e-01f, 2.09594235e-01f,
  1.24612533e-01f, 3.05608492e-02f, 1.24610469e-01f, 1.15938513e-02f, -3.49905878e-01f, -2.27551207e-01f, -2.50033289e-01f, -3.54158193e-01f, -3.08757931e-01f, 1.03814498e-01f,
  1.17476016e-01f, 2.35129863e-01f, -3.16118658e-01f, -2.95155942e-01f, -9.07812454e-03f, 1.56935364e-01f, 1.07065246e-01f, 1.96775898e-01f, -5.59931807e-02f, 2.24009663e-01f,
  6.25900254e-02f, 1.36929423e-01f, 8.83549526e-02f, 2.18134690e-02f, 3.86151709e-02f, 1.37829438e-01f, -2.00529516e-01f, 2.58582324e-01f, 2.06711709e-01f, 3.94823551e-01f,
  1.53238205e-02f, 1.78988650e-01f, 1.32182449e-01f, 1.29225686e-01f, -1.56872757e-02f, 2.20505744e-01f, 1.84491783e-01f, 1.93132117e-01f, 2.71179676e-01f, -1.95268825e-01f,
  -1.49310395e-01f, 2.00956568e-01f, 1.34076038e-02f, -8.26133266e-02f, -1.46618456e-01f, 1.72658890e-01f, 1.98197499e-01f, 2.33621791e-01f, -1.91322520e-01f, 8.22643340e-02f,
  1.31029412e-01f, 4.61853683e-01f, 2.33688056e-02f, 5.65877020e-01f, 1.26479968e-01f, -2.25579932e-01f, -2.80724615e-01f, -2.26780921e-01f, 2.04021096e-01f, -1.01725973e-01f,
  3.62095572e-02f, -4.87970002e-03f, 5.29621094e-02f, 2.10586369e-01f, -4.01931673e-01f, 4.50599372e-01f, 2.77039319e-01f, 2.02262759e-01f, 1.20650709e+00f, 4.64840293e-01f,
  7.62803853e-01f, 4.09939915e-01f, 9.19532835e-01f, -4.73612368e-01f, -1.83049813e-01f, 1.97992101e-01f, 1.76959231e-01f, 3.88807833e-01f, -5.70915714e-02f, 1.85890585e-01f,
  -2.79178005e-02f, 5.26610196e-01f, 1.71900928e-01f, -5.26492655e-01f, -6.52267158e-01f, -4.31996942e-01f, 2.69001573e-01f, 2.56112874e-01f, -5.00115305e-02f, 1.87396899e-01f,
  3.74398939e-02f, -2.65783608e-01f, -6.63619518e-01f, -3.93102914e-01f, -6.26952767e-01f, 2.67562598e-01f, 9.55315828e-02f, -2.46109106e-02f, 2.17107430e-01f, 1.65188700e-01f,
  -3.40836555e-01f, -5.65241039e-01f, -2.16334879e-01f, 3.34897578e-01f, 2.74785280e-01f, 8.21106881e-02f
};

// L2_fan_Bp_bar (Shape: 1 x 14)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 14;
const float L2_fan_Bp_bar_data[] = {
  2.05654666e-01f, 5.77145703e-02f, 1.13683730e-01f, 2.40237802e-01f, 7.59360418e-02f, 1.28715590e-01f, -5.51212952e-02f, 5.44943996e-02f, 7.87954330e-02f, 1.40845239e-01f,
  2.57743031e-01f, -6.62677512e-02f, 7.09256306e-02f, 6.17343336e-02f
};

// L3_fan_Wp (Shape: 25 x 64)
const int L3_fan_Wp_rows = 25;
const int L3_fan_Wp_cols = 64;
const float L3_fan_Wp_data[] = {
  -8.70488398e-03f, 1.86342020e-02f, 9.00913477e-02f, -4.31401879e-02f, -2.50453483e-02f, -9.31468830e-02f, -1.38821006e-01f, 3.26992534e-02f, -1.37309749e-02f, -2.52908655e-02f,
  -1.23691678e-01f, 5.95450997e-02f, 2.68832762e-02f, 4.38350774e-02f, -9.29488763e-02f, -2.64959279e-02f, 1.51060387e-01f, 8.68992209e-02f, 1.73174605e-01f, 1.28523502e-02f,
  -8.22558403e-02f, 1.38342872e-01f, -1.05413273e-01f, 1.47354215e-01f, 1.19650349e-01f, -9.97542813e-02f, 7.67571181e-02f, -4.96818572e-02f, -2.98938621e-02f, -2.12152317e-01f,
  -1.46840662e-01f, 1.36549607e-01f, -1.27384722e-01f, -1.86309405e-02f, 5.47225885e-02f, -2.32212082e-01f, -1.52126476e-01f, -1.63395852e-01f, 2.14813083e-01f, 6.65205941e-02f,
  -2.32462317e-01f, 2.30602399e-02f, 2.26296470e-01f, 1.16081879e-01f, -3.23694269e-03f, -6.35138154e-02f, 1.22468166e-01f, -6.01135716e-02f, -1.10183232e-01f, 2.59075034e-03f,
  1.90985668e-02f, 1.25642717e-01f, -4.47646640e-02f, -7.57721663e-02f, 9.46045816e-02f, 2.64986102e-02f, 5.82183078e-02f, 8.86795670e-02f, -1.05182737e-01f, 1.27177685e-01f,
  -1.53651342e-01f, -1.44573212e-01f, 4.92028892e-02f, 1.37742445e-01f, -1.01607718e-01f, 7.05982894e-02f, 7.89125338e-02f, 6.44497871e-02f, 6.70859069e-02f, 4.20580572e-03f,
  1.45457700e-01f, -1.43840566e-01f, 1.96761429e-01f, 1.14499241e-01f, 5.05537987e-02f, 1.60877928e-01f, -1.22376531e-01f, -1.85987446e-02f, 1.23963878e-01f, 4.29681316e-02f,
  6.76155686e-02f, -1.04270540e-01f, -1.53429180e-01f, -1.83175206e-01f, 6.54606568e-03f, 4.27697934e-02f, 1.07278138e-01f, -5.35266250e-02f, 8.25912729e-02f, -9.89466459e-02f,
  1.65371537e-01f, 3.98396794e-03f, -1.69384569e-01f, -1.35540843e-01f, -3.12728435e-02f, 4.30734418e-02f, 6.14208728e-02f, -1.71949491e-02f, 1.52043656e-01f, -9.74187180e-02f,
  4.94621694e-02f, -6.89755678e-02f, -2.09967002e-01f, -3.01775318e-02f, 9.55666304e-02f, -1.03952013e-01f, 2.61326693e-02f, 1.91892106e-02f, 1.61241487e-01f, -4.13085595e-02f,
  -1.09952986e-01f, -2.96610385e-01f, 5.59369586e-02f, 1.46292955e-01f, -1.27090707e-01f, -2.32651196e-02f, 9.99697670e-02f, -2.36153714e-02f, -6.75202832e-02f, 9.42238048e-02f,
  -1.31771147e-01f, 6.24534711e-02f, -1.86226279e-01f, 6.56846687e-02f, -1.17180860e-02f, 1.45897403e-01f, 1.73480421e-01f, 6.70474246e-02f, 7.98988044e-02f, 4.64857891e-02f,
  -7.54619837e-02f, -2.19544977e-01f, 1.45153806e-01f, 1.09586842e-01f, -1.93230603e-02f, -7.07513513e-03f, -2.25325271e-01f, 4.32217158e-02f, -8.80429894e-03f, -5.13367541e-02f,
  1.58238634e-02f, 7.59629011e-02f, 3.79654230e-03f, 2.21454613e-02f, 5.47002442e-02f, -1.05106689e-01f, 2.82003254e-01f, -2.82429121e-02f, -8.33755508e-02f, 5.67102097e-02f,
  1.09420568e-01f, -5.47314025e-02f, -2.46630497e-02f, -1.94701105e-01f, 2.10583135e-01f, 5.38903661e-03f, -4.66930717e-02f, -1.14086665e-01f, -1.88858047e-01f, -3.82998176e-02f,
  3.01400959e-01f, -6.74684122e-02f, 1.91412300e-01f, -8.56929179e-03f, -1.89446996e-03f, -3.51238586e-02f, -4.81680818e-02f, 1.22370563e-01f, -8.48041922e-02f, -1.19961254e-01f,
  5.61785810e-02f, 1.52380735e-01f, 1.31203383e-02f, -1.80664465e-01f, 2.79532783e-02f, -9.44034010e-02f, -2.30298396e-02f, -7.46590793e-02f, -1.17765516e-01f, -1.07911423e-01f,
  -2.50007153e-01f, 3.57890688e-02f, -1.48307830e-01f, 1.57833546e-01f, 2.04891264e-02f, 9.66493711e-02f, 8.72680023e-02f, 7.72761106e-02f, -4.69465703e-02f, -2.00593799e-01f,
  1.16480999e-01f, -3.23183648e-02f, 6.66465610e-02f, 5.31332009e-02f, 4.80422601e-02f, -5.89704961e-02f, -1.14970401e-01f, -6.31736219e-02f, -7.77839646e-02f, 8.97605494e-02f,
  -3.73645239e-02f, -5.43937683e-02f, 1.85207203e-01f, -1.47108138e-01f, -1.41157418e-01f, 1.16505161e-01f, 1.07994743e-01f, -1.55600496e-02f, 2.05904022e-01f, 1.01719297e-01f,
  9.41796750e-02f, 1.45498902e-01f, -8.96253902e-03f, -1.06030345e-01f, -1.10419624e-01f, -5.44053689e-02f, 3.67387719e-02f, 1.15442656e-01f, -1.82293892e-01f, 5.89814261e-02f,
  2.42371172e-01f, -6.20869212e-02f, -1.24777503e-01f, -2.46012405e-01f, 7.30058104e-02f, 1.72273889e-02f, -7.56027624e-02f, -1.65069357e-01f, -6.60921037e-02f, 2.13811368e-01f,
  2.38578901e-01f, 4.57744896e-02f, -1.64376333e-01f, 2.59725213e-01f, -1.04770176e-01f, -1.58727884e-01f, -1.53950870e-01f, -8.51042047e-02f, 2.77582128e-02f, 2.29459435e-01f,
  1.93454802e-01f, 1.36788547e-01f, 3.47861461e-02f, 1.57643892e-02f, -1.43713459e-01f, 6.72804415e-02f, -6.21482218e-03f, -1.94913507e-01f, 1.27154533e-02f, 2.34053843e-02f,
  -7.24345595e-02f, 6.36957809e-02f, 1.58229530e-01f, 7.81587809e-02f, -9.38842148e-02f, 3.35065313e-02f, -2.58931853e-02f, 1.16688944e-01f, -6.80129007e-02f, -2.94006243e-02f,
  -2.44492479e-02f, -1.50936335e-01f, -3.92923318e-02f, -2.98294537e-02f, -7.24219382e-02f, -4.11664322e-02f, 1.43490851e-01f, 4.16873582e-03f, -4.48078476e-02f, -1.17452748e-01f,
  4.63955961e-02f, 4.96950746e-02f, -7.76154622e-02f, 1.59364477e-01f, 8.76276419e-02f, 2.01435477e-01f, -4.05443981e-02f, -9.08095688e-02f, -7.67815951e-03f, 4.58384976e-02f,
  5.81911393e-02f, 1.83063000e-01f, 1.42649427e-01f, -4.94777262e-02f, -3.29828002e-02f, 1.20947473e-02f, 3.37388702e-02f, -1.88968554e-01f, 2.48225018e-01f, 1.29006654e-02f,
  1.59300044e-01f, 1.70415789e-01f, -1.54373541e-01f, 2.60026872e-01f, 4.65761609e-02f, 2.14607362e-02f, -2.04674482e-01f, 1.82854280e-01f, -5.37532605e-02f, -1.62338495e-01f,
  -6.79600239e-02f, 2.17123181e-02f, 9.39534605e-02f, 1.46420106e-01f, 1.65672779e-01f, -1.93290785e-01f, -2.07875837e-02f, -7.00138137e-02f, -1.67696789e-01f, 7.71429315e-02f,
  -8.34292993e-02f, -8.45950395e-02f, 9.07564536e-02f, 7.48023763e-02f, 8.90273694e-03f, -1.25367448e-01f, 7.29127899e-02f, -1.76715646e-02f, -5.06557859e-02f, -4.23685536e-02f,
  4.13992703e-02f, -8.38404372e-02f, 6.97350129e-02f, 2.09971238e-03f, -7.08446130e-02f, -8.87882635e-02f, -2.57066078e-02f, -8.19846615e-02f, -1.00434475e-01f, -1.16059884e-01f,
  1.49392873e-01f, -1.78620547e-01f, 9.42007378e-02f, -1.91279396e-01f, 2.17052530e-02f, -6.05200827e-02f, -6.43389486e-03f, 5.55110313e-02f, 3.97825427e-03f, 3.47869694e-02f,
  -2.35620588e-02f, -2.93474700e-02f, -6.60037994e-02f, 4.71066050e-02f, -9.14218649e-02f, 3.01386863e-01f, -1.10335402e-01f, -7.60798976e-02f, 4.75447439e-02f, -1.20451458e-01f,
  9.02184546e-02f, -2.42214173e-01f, 3.64134982e-02f, -6.10004440e-02f, -1.15552612e-01f, -5.51943965e-02f, -4.32310067e-02f, 1.59391671e-01f, 1.69377089e-01f, 1.43567130e-01f,
  2.68642772e-02f, 2.11492002e-01f, -5.35699129e-02f, -1.49297044e-01f, -1.09966703e-01f, 1.47683159e-01f, -2.47424617e-02f, 2.54926771e-01f, -3.13547347e-03f, 7.20696226e-02f,
  7.63308927e-02f, -1.38109818e-01f, -3.34545039e-03f, 4.39983904e-02f, -9.36675742e-02f, -6.23888895e-03f, -1.19627289e-01f, -2.16396549e-03f, 1.50246918e-01f, -1.48224145e-01f,
  -2.52769943e-02f, 1.56417057e-01f, -2.31008798e-01f, -6.25183154e-03f, -4.96699288e-03f, -1.74980938e-01f, -4.59770598e-02f, -3.21480259e-02f, 1.02071643e-01f, 4.29873578e-02f,
  4.73384410e-02f, -1.30077079e-01f, -3.94766293e-02f, -4.25080629e-03f, -6.37422428e-02f, -3.23488005e-02f, -5.02814017e-02f, -2.85482444e-02f, -4.91067069e-03f, 6.13707975e-02f,
  -1.56320389e-02f, 9.29334760e-02f, -1.22808971e-01f, 3.32156479e-01f, 4.72523235e-02f, -6.76426105e-03f, -3.99548467e-03f, -1.29761234e-01f, -9.96136814e-02f, 6.15002103e-02f,
  -1.87505335e-01f, 3.35536292e-03f, -7.86134005e-02f, -5.56902364e-02f, -4.77562333e-03f, -2.10360393e-01f, 1.91009179e-01f, 7.01214895e-02f, -1.61104411e-01f, 3.39716494e-01f,
  -2.88831666e-02f, 1.43966585e-01f, 1.09805837e-01f, -5.78495599e-02f, -2.21625701e-01f, 1.78582370e-01f, -2.81478107e-01f, -7.99538344e-02f, 1.43155335e-02f, 1.63145870e-01f,
  2.69327819e-01f, 2.32539371e-01f, -6.86906220e-04f, 8.76925886e-03f, 2.71737948e-02f, 1.47978082e-01f, 1.25343025e-01f, 5.72139882e-02f, -9.25171822e-02f, 8.73587579e-02f,
  1.74633022e-02f, 4.83400784e-02f, -1.72337294e-01f, -6.62826821e-02f, 1.85764521e-01f, -1.67058542e-01f, -8.29435512e-02f, 1.39168827e-02f, 1.78353801e-01f, 5.59282340e-02f,
  6.11491427e-02f, -6.15074523e-02f, 6.56735152e-02f, -3.05756181e-02f, 7.55557790e-02f, 7.98860639e-02f, 1.70338660e-01f, 1.51146725e-01f, 1.03175282e-01f, -4.01084274e-02f,
  1.11034319e-01f, 2.85951700e-02f, 4.70433012e-02f, -9.95329693e-02f, 2.48789325e-01f, 2.39070147e-01f, 1.72519624e-01f, -3.66124772e-02f, 1.07436888e-01f, 4.67924476e-02f,
  -5.72575331e-02f, -2.58971192e-02f, 8.00467432e-02f, 2.16768950e-01f, 1.72908112e-01f, -2.55036801e-01f, 5.76401595e-04f, -1.30063206e-01f, -4.31423672e-02f, -2.00295880e-01f,
  1.75623983e-01f, 5.03251776e-02f, 1.95009992e-01f, 1.16488613e-01f, -4.14762124e-02f, 6.22904748e-02f, 1.58796892e-01f, 1.53981850e-01f, -1.76663503e-01f, 1.82615891e-01f,
  -6.93439394e-02f, -2.02147111e-01f, -7.57680237e-02f, -7.00493157e-02f, 2.27237985e-01f, -5.45219183e-02f, 3.62255648e-02f, -2.68585905e-02f, -1.44900428e-02f, -5.87651618e-02f,
  -3.88184600e-02f, 7.61002749e-02f, 5.40373959e-02f, -9.30507779e-02f, 4.30043600e-02f, 2.91372593e-02f, -1.54961990e-02f, -1.30747914e-01f, 1.64235353e-01f, -1.28864646e-01f,
  6.41691359e-03f, -2.55803317e-02f, -4.30666059e-02f, -3.13468426e-02f, -1.51780322e-02f, 1.49727032e-01f, -8.45082328e-02f, -7.52219409e-02f, -9.57424846e-03f, -5.74143119e-02f,
  4.95632971e-03f, 1.82753224e-02f, -1.55096510e-02f, -1.42206371e-01f, 1.95935503e-01f, -1.06796697e-01f, 8.16749781e-02f, -2.40869541e-02f, 5.25341965e-02f, 1.19429521e-01f,
  9.16716158e-02f, -1.72870725e-01f, 2.07831562e-02f, 1.54153064e-01f, -1.30420163e-01f, 1.46440104e-01f, -1.29912630e-01f, 1.77169472e-01f, 4.32981588e-02f, -1.36912942e-01f,
  1.27908438e-01f, -1.12983614e-01f, 7.77385533e-02f, -9.99196321e-02f, 1.92603413e-02f, 1.24838561e-01f, 6.25413135e-02f, 4.59393971e-02f, -5.91132306e-02f, 1.84825346e-01f,
  1.95584446e-01f, 1.99174061e-02f, -6.85449764e-02f, 1.64965436e-01f, 3.58236507e-02f, -1.89721242e-01f, -9.56757888e-02f, -4.05806862e-02f, 8.63675103e-02f, -2.06013963e-01f,
  1.33526623e-01f, -1.17679268e-01f, -1.32222138e-02f, -1.27888456e-01f, -2.50347137e-01f, 1.05527997e-01f, -1.14909694e-01f, -1.10734940e-01f, 7.27563053e-02f, -5.46636917e-02f,
  1.02018379e-01f, -1.34460241e-01f, -5.70006762e-03f, 1.15796402e-01f, -8.41712207e-02f, 1.80217735e-02f, -1.09441234e-02f, -9.89363194e-02f, -9.34278816e-02f, -9.72888321e-02f,
  -7.65858442e-02f, 3.43034901e-02f, 1.20454878e-01f, 4.62223813e-02f, 9.13354158e-02f, -5.93087822e-02f, 7.86167383e-02f, 9.51981265e-03f, 1.86323360e-01f, 6.49028495e-02f,
  4.44084965e-02f, -5.18702082e-02f, 1.43574417e-01f, -1.88817725e-01f, 1.01486303e-01f, -1.12334028e-01f, 9.49080363e-02f, 9.32819694e-02f, -5.06306402e-02f, -9.05135497e-02f,
  2.80439034e-02f, 1.74925521e-01f, -6.87800944e-02f, 1.44668203e-02f, -8.72409344e-02f, 6.11942112e-02f, -1.94776338e-02f, -8.68734554e-04f, 1.02941737e-01f, -1.21567622e-01f,
  -6.17280379e-02f, -1.91222847e-01f, -2.08563969e-01f, 2.58383416e-02f, 3.11847627e-01f, -7.08300546e-02f, -6.33744672e-02f, -3.56534235e-02f, 1.73753604e-01f, -1.36842625e-02f,
  -2.15471625e-01f, 1.71477079e-01f, 7.70363137e-02f, 2.39840612e-01f, -8.85785371e-02f, -7.44486004e-02f, -3.72542068e-02f, -9.06150490e-02f, 1.28791109e-02f, 2.58585811e-01f,
  -1.09744996e-01f, 1.16842702e-01f, 1.80462405e-01f, 1.49297103e-01f, -1.39373215e-02f, -4.39402793e-04f, -1.06335491e-01f, 1.16484687e-02f, -1.36569619e-01f, 1.46709934e-01f,
  -2.51188222e-02f, -1.03611678e-01f, 4.58048470e-02f, 2.27098018e-02f, 1.04195669e-01f, 5.57875540e-03f, -5.66548444e-02f, 1.24676742e-01f, 1.30891904e-01f, -2.58121453e-02f,
  2.95770057e-02f, 7.05428421e-02f, 7.39560872e-02f, 2.09526971e-01f, 4.90080332e-03f, -1.20209038e-01f, -3.78570072e-02f, 9.16611310e-03f, 5.37369922e-02f, -5.78996204e-02f,
  7.27979019e-02f, 4.53902222e-02f, -1.67611673e-01f, -1.25656044e-02f, 1.30507782e-01f, -1.63242877e-01f, 1.22987628e-02f, 2.44359434e-01f, -3.35574113e-02f, 4.42887023e-02f,
  -6.75623789e-02f, 2.33715504e-01f, -2.53470182e-01f, -6.77235872e-02f, -1.35075301e-01f, -1.25556499e-01f, 1.08185969e-01f, -8.31388682e-02f, -4.72142026e-02f, -3.70199867e-02f,
  7.68979266e-02f, -2.08189324e-01f, 1.38197780e-01f, 1.30303904e-01f, 1.09389469e-01f, 6.40095845e-02f, -1.65260613e-01f, -7.67479688e-02f, -7.13226721e-02f, 1.34461641e-01f,
  2.83015668e-02f, 2.76409425e-02f, 1.76993430e-01f, 5.21348268e-02f, 1.19673714e-01f, 1.02128029e-01f, -2.85153557e-02f, -5.09045422e-02f, -1.52625963e-01f, 1.14803798e-01f,
  -1.93807587e-01f, 1.60903409e-01f, 1.10005401e-01f, 1.82185844e-01f, -5.28607629e-02f, 2.90119704e-02f, -8.95679370e-02f, 9.70513821e-02f, -7.65919387e-02f, 6.69621229e-02f,
  1.44871697e-02f, 1.07702903e-01f, 1.26596749e-01f, 4.02567796e-02f, 1.93827376e-02f, -9.52223595e-03f, 1.25560939e-01f, 1.58896700e-01f, 3.75890099e-02f, -1.69530753e-02f,
  1.77136436e-01f, 5.35473563e-02f, 8.60922188e-02f, -4.96143587e-02f, -1.15354188e-01f, 2.33067423e-02f, 1.39636606e-01f, 1.19443992e-02f, -1.00819422e-02f, 1.38578013e-01f,
  1.88543528e-01f, -1.89958841e-01f, -3.34935300e-02f, -9.35631692e-02f, -1.78420007e-01f, 9.24435724e-03f, 1.37391090e-01f, -1.47172838e-01f, 2.21259743e-01f, 1.89463675e-01f,
  1.80896856e-02f, 6.96285516e-02f, 1.44874319e-01f, 5.08440845e-02f, -1.57557517e-01f, 1.43164530e-01f, -6.98634759e-02f, -7.49196783e-02f, 9.99486148e-02f, 5.05295880e-02f,
  4.42894436e-02f, -2.45762736e-01f, 1.83412403e-01f, 6.71567470e-02f, -3.66793014e-02f, -1.48161963e-01f, 2.23938171e-02f, -6.05955236e-02f, -7.89790973e-03f, -1.97539330e-02f,
  5.19754440e-02f, 1.50229171e-01f, -1.89913541e-01f, -3.55211981e-02f, 1.52017340e-01f, 5.56100607e-02f, 1.40724946e-02f, -5.44332229e-02f, -1.96475275e-02f, 5.55429533e-02f,
  1.59800008e-01f, -1.07355811e-01f, 8.81782621e-02f, 1.46356642e-01f, 8.89169052e-02f, 2.50612736e-01f, -5.26771098e-02f, 1.06088780e-01f, 4.53362726e-02f, 4.46363958e-03f,
  2.14137994e-02f, 1.90323874e-01f, -4.65971380e-02f, -9.44520999e-03f, 6.86887428e-02f, 9.98010114e-02f, 1.46064043e-01f, 9.99601260e-02f, -3.03002018e-02f, 6.16361499e-02f,
  -4.54600938e-02f, 9.38594565e-02f, -5.07228374e-02f, -8.02509487e-02f, 1.40143670e-02f, 5.19424006e-02f, 1.51712805e-01f, -1.21849358e-01f, 8.29987824e-02f, -2.73550272e-01f,
  7.80483633e-02f, 1.29781708e-01f, 6.44921660e-02f, 1.32032871e-01f, -1.21676944e-01f, 6.32776394e-02f, 1.26040936e-01f, -6.13557175e-02f, -1.71274498e-01f, 3.84654775e-02f,
  -7.05840290e-02f, -1.75844669e-01f, -2.07989126e-01f, -9.66120139e-02f, 7.90621117e-02f, 1.71199977e-01f, -6.23040134e-04f, 2.76635010e-02f, -2.52780579e-02f, 1.39505535e-01f,
  -5.12138382e-02f, -1.62213277e-02f, 5.49480170e-02f, 5.80047220e-02f, 7.58915693e-02f, 4.30957004e-02f, -8.39754567e-03f, -9.65404883e-02f, 2.29896560e-01f, -1.07769161e-01f,
  -6.07779622e-02f, -9.36537310e-02f, -1.05410099e-01f, -1.76544815e-01f, -1.09183058e-01f, -5.15795313e-04f, -5.32231666e-02f, -1.09829968e-02f, -7.83276632e-02f, -8.57852325e-02f,
  -8.64577591e-02f, 5.49159348e-02f, 2.08406243e-02f, -1.39463898e-02f, 5.21212071e-02f, -1.58521757e-01f, -3.15919667e-02f, 8.46227482e-02f, -1.47917613e-01f, 4.71126065e-02f,
  3.73703539e-02f, 7.01230690e-02f, -1.45880550e-01f, -6.57220259e-02f, -1.46315880e-02f, -5.20744435e-02f, -5.72075807e-02f, -2.30313703e-01f, -4.12166901e-02f, -1.21404920e-02f,
  5.78629039e-03f, -1.40409559e-01f, 5.06888777e-02f, -1.07041851e-01f, -2.46392965e-01f, 1.06202252e-01f, 1.08775616e-01f, 4.29656617e-02f, 9.40001383e-03f, -1.77674249e-01f,
  -2.33455509e-01f, -1.37770742e-01f, -2.05962792e-01f, -8.79528001e-02f, 1.04128025e-01f, 1.61878631e-01f, 5.32424115e-02f, 5.48317432e-02f, -2.20038928e-02f, -3.48986648e-02f,
  -8.20237994e-02f, 8.34238678e-02f, 5.95934205e-02f, 2.32102409e-01f, -1.24180615e-01f, 4.00528982e-02f, 2.32044458e-01f, 7.02817962e-02f, -7.59265497e-02f, -2.18593150e-01f,
  -2.06345487e-02f, 9.09962729e-02f, -4.38690893e-02f, -1.36587635e-01f, -4.51399293e-03f, 1.22252271e-01f, -1.63626131e-02f, 7.40754455e-02f, -2.27175951e-02f, -1.12106048e-01f,
  5.32364026e-02f, 6.06066212e-02f, -1.24632038e-01f, 7.20273256e-02f, -7.09375143e-02f, 6.51960671e-02f, -1.55623630e-01f, -6.23842552e-02f, 8.54879916e-02f, 2.04185601e-02f,
  -1.95166290e-01f, 4.24566716e-02f, -9.97524858e-02f, 3.63322459e-02f, 2.74201129e-02f, 3.43772434e-02f, -5.04195038e-03f, 7.16006458e-02f, -1.29022911e-01f, 4.03573439e-02f,
  6.86136857e-02f, -5.53736426e-02f, -2.00790405e-01f, 7.09431693e-02f, 1.68246068e-02f, -9.33807343e-02f, 1.00109085e-01f, -8.34872946e-03f, -7.99699798e-02f, -9.99854431e-02f,
  -1.66132540e-01f, -4.21370752e-02f, 8.92785657e-03f, -1.46886542e-01f, 4.49022688e-02f, -1.11112475e-01f, -2.18893662e-01f, -1.27323896e-01f, 1.46089807e-01f, 1.86621070e-01f,
  -6.91383481e-02f, 1.69930249e-01f, 1.66459262e-01f, 1.81124628e-01f, -1.05154976e-01f, 2.43748110e-02f, 1.01282358e-01f, 2.39112854e-01f, -1.08430915e-01f, 7.91692808e-02f,
  5.75781278e-02f, 5.32648824e-02f, 1.29632473e-01f, -5.87054230e-02f, 4.07816134e-02f, 2.74991877e-02f, -1.33261815e-01f, -1.97297603e-01f, -8.83485079e-02f, 1.47714168e-01f,
  -6.41267970e-02f, -7.65860379e-02f, 5.27376272e-02f, -3.05974409e-02f, -6.97178841e-02f, 9.35915038e-02f, -3.71928923e-02f, -1.59478486e-01f, 6.91892132e-02f, -7.85897002e-02f,
  -1.14909604e-01f, -4.53794710e-02f, 9.54566523e-02f, 1.57414451e-01f, 5.49401455e-02f, -5.23626991e-02f, 1.19189084e-01f, -8.41611065e-04f, 5.71137033e-02f, -1.46324113e-01f,
  -5.90599291e-02f, -5.08033298e-02f, -1.52219776e-02f, -3.12846452e-02f, 9.92404073e-02f, -8.69906470e-02f, -5.19634411e-02f, 4.80014645e-02f, -4.99531673e-03f, -9.94967222e-02f,
  -5.61140291e-02f, 1.59495324e-01f, -4.96428572e-02f, -2.03958943e-01f, 2.36061327e-02f, 6.17808104e-02f, -5.78084849e-02f, -7.74653032e-02f, 1.81075945e-01f, 1.03468589e-01f,
  2.22900026e-02f, -4.21131887e-02f, 1.35214955e-01f, 9.63817313e-02f, 2.26941742e-02f, 6.44032881e-02f, 4.47614677e-02f, -1.79840773e-01f, -4.56228405e-02f, 1.96604386e-01f,
  -1.81421399e-01f, 7.97793195e-02f, -8.51821676e-02f, -3.82239968e-02f, 1.52994469e-01f, -1.58934519e-02f, 7.20502660e-02f, 1.83878064e-01f, -2.22061962e-01f, 1.02456860e-01f,
  -1.54239804e-01f, 4.84822914e-02f, 1.06612772e-01f, 8.35156590e-02f, 4.95588779e-02f, 5.73157240e-03f, -4.71723266e-02f, 4.77445722e-02f, 9.12348405e-02f, 5.22765033e-02f,
  -3.15525234e-02f, 9.17884409e-02f, -3.65050393e-03f, 2.42005773e-02f, 3.95043381e-02f, 8.69826078e-02f, -5.43723628e-02f, -6.81752041e-02f, -1.66918159e-01f, 1.71448261e-01f,
  -2.04188228e-01f, -1.58973426e-01f, 5.78859746e-02f, -8.15962777e-02f, -2.13915646e-01f, -6.76521473e-03f, 1.63802236e-01f, -3.98032106e-02f, -1.03350781e-01f, -2.36778662e-01f,
  1.44292727e-01f, 1.07966490e-01f, -1.62938640e-01f, 1.08337075e-01f, -4.60371189e-03f, 1.29897624e-01f, -4.25017588e-02f, 1.22561112e-01f, -3.14769219e-03f, 2.37543564e-02f,
  6.85072541e-02f, -2.86196806e-02f, -1.42969772e-01f, -1.37200132e-01f, 1.40435711e-01f, -1.16925150e-01f, 8.38624761e-02f, 1.26978979e-01f, 1.14309229e-01f, -2.28842616e-01f,
  -2.62154937e-01f, -8.73064548e-02f, 7.23921061e-02f, -2.54425526e-01f, 9.26167741e-02f, 2.03860570e-02f, 1.58351138e-01f, -3.22894715e-02f, -1.91843882e-02f, 1.16514340e-01f,
  -5.27844653e-02f, -1.26121476e-01f, 1.28063306e-01f, 1.81691125e-01f, -9.56752598e-02f, -1.33155063e-01f, -3.19084898e-02f, -6.89040944e-02f, -8.13015029e-02f, 1.02456370e-02f,
  -5.90348504e-02f, -1.28201693e-01f, 6.49362803e-02f, 7.77269229e-02f, -6.18930645e-02f, -2.32882068e-01f, 1.62123591e-01f, -6.23030402e-02f, -1.04854219e-01f, -1.37521431e-01f,
  -9.72409025e-02f, -1.00317739e-01f, 9.98812467e-02f, -1.66275203e-01f, 2.72234920e-02f, -1.21899173e-01f, -1.19009800e-01f, 2.49703601e-01f, 1.46191299e-01f, 3.04319896e-02f,
  1.52966142e-01f, -2.94630863e-02f, -3.67153101e-02f, 2.32183367e-01f, -1.97377682e-01f, 2.40851771e-02f, -9.08547118e-02f, 1.28236547e-01f, -1.69956252e-01f, 1.61457956e-01f,
  1.26021639e-01f, -2.29646176e-01f, 1.56353526e-02f, -1.25361569e-02f, -1.92343637e-01f, 2.27485105e-01f, 2.27514505e-01f, 1.08107969e-01f, 4.81435210e-02f, 1.02104977e-01f,
  -1.04273684e-01f, -6.07441179e-02f, 6.50858507e-02f, 4.89247739e-02f, 4.43350188e-02f, 1.51198268e-01f, 4.93965819e-02f, -8.59449655e-02f, -1.88013781e-02f, -1.56614501e-02f,
  6.98434636e-02f, -3.06408666e-02f, 7.45642260e-02f, 1.33436680e-01f, -5.37612140e-02f, 3.20759043e-02f, -2.26752505e-01f, -1.47199854e-01f, 6.80091605e-02f, 1.03670493e-01f,
  -1.25998436e-02f, 4.86039035e-02f, 5.18298447e-02f, -7.19685927e-02f, 4.28181216e-02f, -1.27618745e-01f, -1.28594458e-01f, -2.34714262e-02f, -9.07085240e-02f, 2.84889042e-02f,
  2.14778110e-02f, -1.58005196e-03f, 3.32161337e-02f, -9.80297327e-02f, -6.08453006e-02f, -9.60012451e-02f, 1.24926858e-01f, -6.94570541e-02f, -1.46019040e-02f, 5.94578609e-02f,
  1.34007568e-02f, 7.17076808e-02f, -6.90339804e-02f, 3.86422649e-02f, 1.09201968e-01f, -1.23782054e-01f, -1.01953819e-01f, 2.92818725e-01f, -2.53453285e-01f, -9.98215377e-02f,
  1.38376430e-01f, -1.22502476e-01f, -1.43369243e-01f, 6.77120779e-03f, -1.09846324e-01f, -1.99947476e-01f, -8.19255412e-03f, -9.07461047e-02f, -3.73098403e-02f, -2.15819292e-02f,
  2.51322389e-01f, 1.71442732e-01f, -4.93914373e-02f, 2.70745177e-02f, -1.46817058e-01f, 2.42027231e-02f, -1.50273055e-01f, 2.07234491e-02f, 5.03941029e-02f, 3.68993171e-02f,
  1.14552833e-01f, 7.58436173e-02f, 1.12977121e-02f, 6.67288974e-02f, 6.03407286e-02f, 5.75967953e-02f, 1.68380693e-01f, -8.55340809e-02f, 4.68775444e-02f, 8.71506706e-02f,
  -8.99916217e-02f, -1.67365730e-01f, -1.26609564e-01f, 9.94258970e-02f, -1.49497047e-01f, 1.76251382e-01f, 6.96134567e-02f, 1.08099766e-01f, -2.79337354e-02f, -1.39949247e-01f,
  1.36262169e-02f, -4.02840897e-02f, -1.08365752e-01f, 1.81011066e-01f, -1.24292590e-01f, 5.90282232e-02f, -2.30857842e-02f, 1.09871410e-01f, 3.92145440e-02f, -7.96620846e-02f,
  -3.22117694e-02f, 4.48936410e-02f, -2.59731263e-02f, -1.77806258e-01f, -1.66612659e-02f, -6.88565001e-02f, 3.37985903e-02f, 6.67631775e-02f, -6.28874451e-02f, -1.05737917e-01f,
  2.18641516e-02f, 4.27014343e-02f, -7.75641277e-02f, 1.21732265e-01f, -1.60153523e-01f, 9.92832482e-02f, 1.75026760e-01f, 2.11249769e-01f, 2.21880674e-01f, -8.67422521e-02f,
  -1.76104337e-01f, -1.77236259e-01f, -8.02312121e-02f, -1.74242780e-01f, 1.53344855e-01f, -8.27632844e-02f, 1.31905258e-01f, 7.72515982e-02f, 9.83492285e-02f, 2.36102015e-01f,
  1.06369011e-01f, 3.98682579e-02f, -1.02916919e-02f, 8.02268535e-02f, 4.06867154e-02f, -1.50506005e-01f, 5.44252694e-02f, -1.08315669e-01f, 1.45863056e-01f, 5.04665673e-02f,
  -1.36367530e-01f, 1.51455283e-01f, 7.92214796e-02f, 5.49283251e-02f, -1.12777561e-01f, 5.48174679e-02f, 3.52227278e-02f, 4.66500260e-02f, 8.10817927e-02f, -4.96044680e-02f,
  -5.85342897e-03f, 6.85365200e-02f, -3.48814242e-02f, -3.19889076e-02f, -9.72526427e-03f, 6.25759065e-02f, 1.66411921e-02f, -1.31904721e-01f, -1.66231394e-02f, 1.07787371e-01f,
  -1.70101508e-01f, -8.03757533e-02f, -1.67441547e-01f, 6.85445890e-02f, 7.65409172e-02f, -4.25269641e-02f, 1.13934390e-01f, -9.56658795e-02f, -8.67549479e-02f, -1.93579067e-02f,
  2.14824416e-02f, 1.53089181e-01f, 5.94766364e-02f, 1.46901608e-01f, -1.78730246e-02f, 1.02582380e-01f, -1.30544171e-01f, -5.86868338e-02f, -6.81927875e-02f, 8.13452248e-03f,
  -1.38868615e-01f, 2.65477329e-01f, 7.05226436e-02f, -1.81831732e-01f, -1.43349871e-01f, 1.86121240e-02f, -8.48597139e-02f, -4.86073643e-02f, 2.60840118e-01f, 2.16296799e-02f,
  -1.51046842e-01f, 2.05735415e-01f, -6.11086152e-02f, 1.03067830e-02f, 2.59225015e-02f, 2.54311487e-02f, 1.00316525e-01f, -1.27439469e-01f, -4.57296856e-02f, 1.20802768e-01f,
  -1.41241193e-01f, 8.28624517e-02f, -2.55178139e-02f, 1.03278518e-01f, 2.75453366e-02f, -6.52381405e-02f, -1.08710371e-01f, 1.00579657e-01f, -2.48970449e-01f, -6.90594912e-02f,
  8.12322125e-02f, -9.04201716e-02f, 1.09155864e-01f, 4.14775982e-02f, -3.03202737e-02f, 1.32871032e-01f, 1.43605918e-01f, -1.10426195e-01f, 7.13426024e-02f, -3.10363080e-02f,
  -1.05633155e-01f, -1.07495664e-02f, -3.58429402e-02f, 2.44473945e-02f, -2.56951433e-03f, 6.17533997e-02f, -9.08848271e-02f, 4.87185679e-02f, 8.61703530e-02f, -1.26478123e-03f,
  -2.31474708e-03f, -1.65540189e-01f, -7.55743459e-02f, 1.07791141e-01f, -1.61037400e-01f, 5.84319085e-02f, 8.78308043e-02f, 1.63122769e-02f, 3.18114720e-02f, -1.24122582e-01f,
  2.79911399e-01f, -1.95129532e-02f, 6.14032820e-02f, -1.12882569e-01f, -2.54735470e-01f, 1.21358015e-01f, 7.49139041e-02f, -1.70387045e-01f, 1.78898975e-01f, -2.02039301e-01f,
  7.43943325e-04f, 1.74363777e-02f, -1.02039590e-01f, 2.62065269e-02f, -1.45539716e-01f, 6.23512939e-02f, -3.10717002e-02f, 1.71413645e-01f, 1.63143307e-01f, -2.19171256e-01f,
  1.20754041e-01f, -2.07134590e-01f, -9.33426172e-02f, 7.44588226e-02f, -5.46482876e-02f, 1.13336027e-01f, -4.71115932e-02f, -9.40859467e-02f, 1.16339460e-01f, 6.42903969e-02f,
  9.19986293e-02f, -1.44125782e-02f, -1.24443762e-01f, 9.77193415e-02f, -1.28203183e-01f, -2.03644395e-01f, 1.89526901e-01f, -6.97122365e-02f, 5.40185086e-02f, 6.63087964e-02f,
  1.21559784e-01f, -1.00535385e-01f, -5.60215935e-02f, -3.61907482e-02f, -3.61237340e-02f, -2.30453927e-02f, -1.66462675e-01f, 1.41094357e-01f, 6.44467175e-02f, -5.49327582e-02f,
  -1.03900217e-01f, -9.29746926e-02f, -2.12691613e-02f, -1.31496601e-02f, 2.25995630e-02f, 9.18652043e-02f, 1.37599468e-01f, 5.26976511e-02f, -1.99007213e-01f, -5.18374443e-02f,
  -5.76572828e-02f, 1.30391017e-01f, -1.93223134e-01f, -7.82128423e-02f, 1.37155280e-01f, -4.51440662e-02f, 1.06227338e-01f, -1.16856560e-01f, -7.63595030e-02f, -2.29747951e-01f,
  1.23432636e-01f, 1.48442894e-01f, 1.31458163e-01f, 1.75900385e-01f, 5.06583191e-02f, -2.76278909e-02f, -1.73596531e-01f, 1.90702733e-02f, -2.11857438e-01f, 1.57168716e-01f,
  -1.52930558e-01f, -1.65894315e-01f, -3.80901769e-02f, 1.27606660e-01f, 1.64789200e-01f, -1.63580865e-01f, 6.20608255e-02f, 9.19109024e-03f, 3.70062366e-02f, -1.42361373e-01f,
  -4.92009856e-02f, -3.28362957e-02f, -6.22648634e-02f, -1.06688007e-03f, 4.74190526e-02f, -7.35855550e-02f, 1.23418435e-01f, -8.44262317e-02f, 2.31128201e-01f, -1.55412197e-01f,
  -4.49308790e-02f, -3.59749198e-02f, 1.94014702e-02f, -3.37292030e-02f, 5.48047386e-02f, -1.24587558e-01f, 1.23488091e-01f, -5.03137261e-02f, 1.12934455e-01f, 1.77484634e-03f,
  1.28431350e-01f, -1.25104979e-01f, -7.17840269e-02f, 3.03017963e-02f, 8.03892761e-02f, -5.57828359e-02f, -3.57290991e-02f, 1.10381946e-03f, -3.79386991e-02f, -2.72473425e-01f,
  -6.83988184e-02f, -1.19354270e-01f, 1.95052236e-01f, -9.55876634e-02f, 4.21107151e-02f, -6.17897287e-02f, 1.19426228e-01f, 9.92028490e-02f, -5.42939715e-02f, 1.90777570e-01f,
  2.22129896e-02f, 9.45546031e-02f, -1.14838462e-02f, 2.82894582e-01f, 2.23388970e-01f, -1.76428154e-01f, -7.78783485e-02f, 6.35321252e-04f, -1.56838149e-01f, 1.87656488e-02f,
  1.49288684e-01f, 7.14081377e-02f, 2.07793146e-01f, -4.87959832e-02f, 1.69304490e-01f, 8.32249746e-02f, -4.18371670e-02f, 7.07128122e-02f, -1.81656912e-01f, 3.99159417e-02f,
  -1.50532663e-01f, 3.33444029e-02f, -1.15234427e-01f, -1.03322260e-01f, 2.39423867e-02f, 1.20359264e-01f, 6.27372414e-02f, 8.57620984e-02f, 2.39656121e-02f, 1.42524406e-01f,
  -2.05799695e-02f, 9.44511779e-03f, -1.51455492e-01f, -1.34053174e-02f, 1.20325424e-01f, -4.33993787e-02f, -1.11807637e-01f, -1.01586789e-01f, 2.39660069e-02f, -1.53570622e-01f,
  1.42780811e-01f, -3.14513259e-02f, -2.67632958e-02f, -1.68219686e-01f, -1.70544580e-01f, -3.86598334e-02f, 2.94199865e-02f, -1.16947070e-01f, 1.29210964e-01f, -1.84091516e-02f,
  1.21420883e-02f, -2.12195367e-02f, -1.16889663e-01f, -1.30861700e-01f, 6.11104183e-02f, 1.13073640e-01f, -4.23053652e-02f, -8.21825489e-02f, 1.01765506e-02f, -1.14123382e-01f,
  -6.97924569e-02f, -9.05665904e-02f, -2.60091443e-02f, -2.23515555e-02f, -2.09445640e-01f, -1.98457693e-03f, 2.65780557e-02f, 2.40803093e-01f, 2.62328684e-01f, 7.68911466e-02f,
  -6.07787296e-02f, 1.51528362e-02f, -9.43347886e-02f, -3.03619704e-03f, -1.51050985e-01f, 1.15309581e-01f, 1.73106149e-01f, -8.59414339e-02f, 1.08135708e-01f, -6.12756163e-02f,
  9.80102420e-02f, -1.03211500e-01f, -1.13418326e-01f, -5.61759770e-02f, -6.23244457e-02f, -1.90790609e-01f, 1.32796332e-01f, -2.03115374e-01f, -3.55120264e-02f, 1.61804724e-02f,
  -1.70132115e-01f, 2.27921292e-01f, 8.07266459e-02f, 6.44396767e-02f, -5.72439358e-02f, -5.09825498e-02f, -7.44374469e-02f, 1.65405706e-01f, 1.02458753e-01f, 5.95487356e-02f
};

// L3_fan_Wp_bar (Shape: 14 x 64)
const int L3_fan_Wp_bar_rows = 14;
const int L3_fan_Wp_bar_cols = 64;
const float L3_fan_Wp_bar_data[] = {
  3.81914079e-02f, 6.58057779e-02f, 3.11085656e-02f, 2.52334595e-01f, 1.65994376e-01f, -3.18140611e-02f, -6.77621886e-02f, -1.63283723e-03f, -4.92332764e-02f, 1.09528959e-01f,
  1.54477209e-01f, 5.65505549e-02f, 2.19416410e-01f, -6.48903698e-02f, -2.10899562e-02f, 9.99337509e-02f, 3.21430564e-01f, 4.77868110e-01f, 2.95769572e-01f, -4.67542149e-02f,
  -1.63060367e-01f, -2.05042469e-03f, -1.31204739e-01f, 2.64853269e-01f, -8.93121660e-02f, -1.95657179e-01f, 3.44755858e-01f, 9.48492158e-03f, -2.20184311e-01f, -9.62165669e-02f,
  3.26387346e-01f, -4.84353125e-01f, -1.39966801e-01f, 4.44122255e-01f, 2.29572251e-01f, 2.14129373e-01f, -9.11201015e-02f, 2.30723709e-01f, -2.20573232e-01f, -7.28971437e-02f,
  -1.88055962e-01f, -9.42490622e-02f, -9.55734868e-03f, -3.85610878e-01f, -6.71903044e-02f, 8.27206969e-02f, 8.34809840e-02f, -9.87835601e-02f, -1.32678151e-01f, -2.47808650e-01f,
  2.10345775e-01f, 9.67207029e-02f, -5.42574935e-02f, 2.38937899e-01f, -1.09866178e-02f, -2.67790884e-01f, 1.13814265e-01f, -1.91692516e-01f, 3.92375648e-01f, -1.01254664e-01f,
  3.81381094e-01f, 1.76269948e-01f, 1.53862953e-01f, 1.26398563e-01f, 2.81577855e-02f, 1.15096673e-01f, -3.44061777e-02f, -2.97990948e-01f, 2.06990153e-01f, -1.21902928e-01f,
  1.14668749e-01f, 7.70950243e-02f, -1.17024787e-01f, 8.05847719e-02f, 3.02429020e-01f, -2.35390365e-01f, 1.32548269e-02f, 1.22743107e-01f, 1.82755545e-01f, -2.06010804e-01f,
  1.07907377e-01f, -2.88958877e-01f, 1.60976071e-02f, 1.38329104e-01f, 1.98746786e-01f, 2.80206688e-02f, 1.52270660e-01f, -2.34816983e-01f, -1.96503326e-02f, 2.56920397e-01f,
  2.40832400e-02f, 8.68408084e-02f, -2.34530851e-01f, 8.87747183e-02f, 4.14965339e-02f, -3.95537876e-02f, 3.90933663e-01f, -6.75855577e-02f, 9.26351100e-02f, -1.94688231e-01f,
  -2.80533344e-01f, 4.53306407e-01f, 3.24760228e-01f, -1.39116049e-01f, 6.28139898e-02f, -1.45318300e-01f, 2.40750834e-01f, -2.75022924e-01f, 8.56101699e-03f, -2.22137019e-01f,
  1.78478390e-01f, 3.36039364e-01f, -1.88486010e-01f, -3.80437523e-01f, -2.42570248e-02f, -2.69757956e-02f, 2.91926712e-01f, 3.47044617e-01f, -2.03779399e-01f, 3.05439502e-01f,
  3.06828856e-01f, 3.64940614e-01f, -5.70169371e-03f, 2.21112236e-01f, 2.98653185e-01f, 3.13826442e-01f, 2.28833109e-01f, -1.35440552e+00f, 2.79351175e-01f, -1.04177937e-01f,
  -2.27721427e-02f, -2.57401258e-01f, 3.17388624e-01f, 1.07210852e-01f, 4.90908884e-02f, -1.44726530e-01f, 8.40356201e-03f, 6.65656105e-02f, -2.76577562e-01f, 2.65431762e-01f,
  1.05774343e-01f, 3.42161842e-02f, -9.19377208e-02f, 2.32254431e-01f, -3.53333801e-01f, -1.14540890e-01f, 3.59381400e-02f, -2.28760079e-01f, -2.58282214e-01f, 2.88503677e-01f,
  1.24873109e-01f, 2.53151268e-01f, 8.31955597e-02f, -3.09108913e-01f, 3.70500833e-01f, -2.27042809e-01f, -2.73660630e-01f, 1.27090827e-01f, -1.86591640e-01f, 3.29109877e-01f,
  1.82119966e-01f, -2.32544184e-01f, 1.20121688e-01f, 1.31463677e-01f, 2.24552795e-01f, -3.66023719e-01f, -2.09177122e-01f, -2.94969738e-01f, -2.48747647e-01f, -1.60175085e-01f,
  -5.07296016e-03f, 1.53524667e-01f, 2.39994004e-01f, -5.35134450e-02f, -5.79996174e-03f, -3.06094587e-01f, -1.46047488e-01f, -2.35514909e-01f, -9.94671881e-02f, 8.99340883e-02f,
  -4.23902348e-02f, 2.87423860e-02f, 1.15677848e-01f, 4.10653323e-01f, 8.30211118e-03f, 1.84600249e-01f, 1.94637254e-01f, 3.23820114e-01f, 1.68096170e-01f, -2.53699690e-01f,
  3.47811043e-01f, -5.35349995e-02f, 1.62512124e-01f, 2.02914983e-01f, 2.73708403e-01f, -2.25183070e-01f, -2.34273389e-01f, -2.98191994e-01f, 2.81724393e-01f, -6.33685216e-02f,
  -3.47807556e-02f, 1.85865983e-01f, 9.15917903e-02f, -2.37421006e-01f, -9.94028449e-02f, 1.42326325e-01f, 7.13721991e-01f, 5.07839620e-02f, 4.93647873e-01f, -3.69544536e-01f,
  -1.96083859e-01f, -4.06990826e-01f, 3.93511951e-01f, 4.62533146e-01f, 1.97249562e-01f, 5.88561073e-02f, -5.09659648e-02f, 9.54700112e-01f, -4.32539105e-01f, 2.09951904e-02f,
  -2.33005062e-02f, 1.05085365e-01f, -2.24516064e-01f, 3.71277869e-01f, 3.54338527e-01f, -4.01853710e-01f, -2.37142622e-01f, -2.92849451e-01f, -6.16844416e-01f, 1.99435860e-01f,
  6.77649260e-01f, 1.12484820e-01f, 3.54049027e-01f, 4.07535344e-01f, -4.16471437e-02f, -1.56755224e-01f, -3.86374086e-01f, 7.59347796e-01f, 1.75403759e-01f, 4.62119520e-01f,
  2.29218945e-01f, -9.29274485e-02f, -2.47580260e-02f, -3.76404732e-01f, 2.71764975e-02f, 2.24205717e-01f, -3.18840563e-01f, -2.79942602e-02f, 1.48995489e-01f, 1.85479909e-01f,
  -1.31804124e-01f, -7.10203126e-02f, 1.18906125e-01f, 2.56381661e-01f, 2.21271720e-02f, -2.43086651e-01f, 2.13995740e-01f, 1.99632809e-01f, 1.71005964e-01f, 9.14805532e-02f,
  1.54096186e-01f, -1.14903286e-01f, 1.01922601e-01f, -2.52318472e-01f, -3.03418003e-02f, 2.02859059e-01f, 2.22357027e-02f, 7.67613053e-02f, 6.98830783e-02f, 1.14491463e-01f,
  7.84721076e-02f, 1.76958829e-01f, 9.26630273e-02f, 6.47273436e-02f, -4.55308557e-02f, -2.25444674e-01f, -6.74350783e-02f, -4.00125124e-02f, -1.24092169e-01f, 2.13480607e-01f,
  1.16713598e-01f, -3.57264616e-02f, 3.32292676e-01f, -1.06105179e-01f, -4.41906720e-01f, 2.27845505e-01f, 2.33268663e-01f, 2.65204698e-01f, 3.08716297e-01f, -1.21457661e-02f,
  7.66191930e-02f, 3.49763408e-02f, -1.27414376e-01f, 1.94256648e-01f, 7.68376663e-02f, -1.14955634e-01f, -7.90775940e-02f, 1.40550911e-01f, 2.87712187e-01f, -1.27546668e-01f,
  1.76978469e-01f, 2.91517936e-02f, -1.55102611e-01f, -2.01509878e-01f, -3.65838468e-01f, -3.41006607e-01f, 1.32675499e-01f, -1.08065650e-01f, -5.97238354e-03f, 1.24069676e-01f,
  -1.83135718e-02f, 7.67621025e-02f, 1.66204780e-01f, -2.53450368e-02f, 2.47832566e-01f, 7.02572009e-03f, 1.00154825e-01f, 1.63484201e-01f, 2.26190999e-01f, -6.73713923e-01f,
  -1.08985230e-01f, 2.48267241e-02f, -8.88014585e-02f, -8.42185784e-03f, 1.25919923e-01f, -8.03525895e-02f, -1.38524279e-01f, 3.12806875e-01f, 6.61271363e-02f, 2.71560121e-02f,
  1.66275263e-01f, -1.51487403e-02f, 1.71011150e-01f, 1.66391000e-01f, -3.25602978e-01f, -7.29739368e-02f, 1.73604731e-02f, 1.57833248e-01f, 9.78820473e-02f, 1.37904868e-01f,
  1.28243104e-01f, -3.40381525e-02f, -5.84279932e-02f, -7.13268444e-02f, 9.76986215e-02f, -1.65007740e-01f, -2.74006397e-01f, 3.11164528e-01f, 1.62277102e-01f, -1.40620127e-01f,
  3.59877884e-01f, -3.68778735e-01f, -2.81549752e-01f, 2.42149964e-01f, -2.84360886e-01f, -1.08076923e-01f, -3.17506850e-01f, -4.88890707e-02f, 3.54711503e-01f, -6.97468221e-02f,
  -1.27825081e-01f, -9.83821452e-02f, 7.38151046e-03f, 1.31265838e-02f, -3.44451427e-01f, 2.53313214e-01f, 3.17672014e-01f, 3.76808584e-01f, -1.54539138e-01f, 1.80864722e-01f,
  4.05267328e-01f, 3.18057865e-01f, 3.35446179e-01f, 4.41572487e-01f, 3.74721348e-01f, 9.65983700e-03f, 4.03979093e-01f, 5.33092581e-02f, 2.66752511e-01f, 1.65130466e-01f,
  -5.31294718e-02f, 3.54190543e-03f, -2.46047601e-01f, 1.28934336e+00f, 1.02940023e-01f, 2.17971593e-01f, 2.54829019e-01f, 8.43111426e-02f, 2.32869431e-01f, 2.93382227e-01f,
  3.17146489e-03f, 2.66195089e-01f, 3.37131560e-01f, 1.84536934e-01f, 9.28032584e-03f, 2.99552500e-01f, 9.39582065e-02f, 2.59562284e-01f, 1.69022903e-01f, -3.91149610e-01f,
  1.81957185e-01f, 1.31355628e-01f, -7.21746832e-02f, 8.42537805e-02f, -1.63564369e-01f, 2.37367719e-01f, 3.59099656e-01f, 5.60163297e-02f, 1.10756435e-01f, 3.23805958e-02f,
  1.58671305e-01f, -2.74568528e-01f, 3.65541637e-01f, -3.35889637e-01f, -2.63394922e-01f, -1.23469926e-01f, -2.08401084e-01f, -2.22721800e-01f, 1.07155330e-01f, 1.32498369e-01f,
  6.41702265e-02f, -1.79739684e-01f, -4.18133028e-02f, 7.01960847e-02f, -2.91684955e-01f, -1.53892800e-01f, -4.64102417e-01f, -1.69208515e-02f, -4.04649638e-02f, -7.13074505e-02f,
  2.84323990e-01f, -3.25123459e-01f, 3.78798574e-01f, 3.84399652e-01f, -7.58582577e-02f, 1.63528711e-01f, -3.19785401e-02f, 3.88719477e-02f, 1.26300529e-01f, -9.78270024e-02f,
  -1.26777560e-01f, 3.27818543e-01f, 2.81113945e-02f, 8.14147145e-02f, 2.87310183e-01f, -3.07632476e-01f, 1.18756361e-01f, -4.96651083e-01f, -3.89465913e-02f, 1.75149769e-01f,
  5.71663231e-02f, -6.62743002e-02f, 2.61224687e-01f, 2.66748369e-01f, 2.21396998e-01f, 1.79541800e-02f, 7.61173368e-02f, 5.16926385e-02f, -3.04233395e-02f, 5.46738133e-02f,
  3.05403918e-02f, 2.30524078e-01f, 3.19559984e-02f, -4.41745967e-01f, 1.18780047e-01f, -3.52548361e-02f, 3.05401415e-01f, 2.24085767e-02f, 5.80080822e-02f, 2.07535610e-01f,
  1.40075997e-01f, 2.12574124e-01f, 5.33489585e-02f, 1.12220258e-01f, -1.64743781e-01f, -3.56118493e-02f, 1.73684046e-01f, -4.01809603e-01f, -3.23113143e-01f, 1.55033886e-01f,
  2.34683260e-01f, -3.86596233e-01f, -6.74319193e-02f, -2.67455548e-01f, -3.29861730e-01f, 7.56872371e-02f, 4.36983019e-01f, 6.60495162e-02f, -4.32691760e-02f, 5.57604246e-02f,
  -1.14416428e-01f, 7.41916895e-02f, -7.22172335e-02f, -7.42272288e-02f, 1.45389572e-01f, 2.07142860e-01f, -6.79169316e-03f, 3.88525486e-01f, -3.88572551e-03f, 3.79387259e-01f,
  -1.06809512e-02f, 2.26996481e-01f, 3.24990094e-01f, 3.15580547e-01f, 3.07722986e-01f, 4.76696104e-01f, -2.03333348e-01f, 2.08510995e-01f, 4.82788906e-02f, -4.18248028e-01f,
  1.47164971e-01f, 1.35334706e+00f, -1.51490420e-01f, 1.49171457e-01f, 8.38834867e-02f, -6.14552721e-02f, 1.29201680e-01f, 6.52720630e-02f, 4.11658315e-03f, 3.09885647e-02f,
  3.36721838e-02f, 2.73047537e-02f, -7.61746988e-02f, 2.11573735e-01f, 1.69336826e-01f, 7.54446685e-02f, -2.74850190e-01f, -5.70459105e-02f, -2.41840497e-01f, -2.86702245e-01f,
  2.00245023e-01f, 2.36247465e-01f, -8.12070444e-02f, 6.64653704e-02f, 2.27349937e-01f, 1.43982232e-01f, 1.17257990e-01f, -2.08816350e-01f, 2.11400002e-01f, 2.48937365e-02f,
  -2.78396428e-01f, -2.52035260e-01f, 3.68778706e-02f, 3.56597424e-01f, -1.13922089e-01f, -7.90665895e-02f, -1.05184793e-01f, -3.58291090e-01f, 5.45736440e-02f, -2.42533848e-01f,
  -1.43933654e-01f, -1.09147809e-01f, -2.20654935e-01f, -1.39706478e-01f, 2.77147174e-01f, 2.57893741e-01f, 2.33678192e-01f, -3.41594875e-01f, -6.70539215e-02f, -9.84140635e-02f,
  -1.49004295e-01f, -1.82099238e-01f, 2.31586173e-01f, 1.62898570e-01f, 1.12907127e-01f, 7.52072558e-02f, 3.37167412e-01f, 3.34003121e-01f, 1.39813527e-01f, 2.05125317e-01f,
  1.27022237e-01f, 2.29309976e-01f, -7.41204768e-02f, -4.27042276e-01f, 4.02974069e-01f, 6.15923524e-01f, -2.69100279e-01f, 3.35799873e-01f, 3.58075470e-01f, 5.03186285e-02f,
  -5.15050022e-03f, -1.13023899e-01f, 1.49041027e-01f, 1.31644113e-02f, 2.61726260e-01f, 1.98447570e-01f, -4.90329713e-01f, 3.65007937e-01f, -1.87080771e-01f, -1.37174353e-01f,
  -3.33159864e-01f, 2.89377183e-01f, -6.86136484e-01f, -1.94278792e-01f, -1.88860387e-01f, -2.23309711e-01f, -3.62638682e-01f, 5.95618963e-01f, 3.93091798e-01f, 7.87244290e-02f,
  9.89986137e-02f, -8.21305960e-02f, 1.27477378e-01f, -3.08281869e-01f, 4.33544405e-02f, 2.25471556e-01f, 1.48377135e-01f, 5.40318787e-01f, -5.07975101e-01f, 4.76770774e-02f,
  -2.49683559e-02f, -1.87256083e-01f, 5.61230898e-01f, -6.87735140e-01f, -4.55732495e-01f, -1.17827654e-01f, 1.11296168e-02f, -4.59842123e-02f, -6.97241351e-02f, 7.01593816e-01f,
  1.82483122e-01f, 1.32956980e-02f, -3.42921883e-01f, -2.69039899e-01f, 1.70208365e-01f, 2.68380433e-01f, 2.29285106e-01f, 1.55335078e-02f, 3.06769282e-01f, -7.23616257e-02f,
  2.94912368e-01f, 1.88785419e-01f, -4.04495895e-01f, -3.27178091e-02f, 3.06243777e-01f, 3.66914123e-01f, -3.57876062e-01f, 6.61072314e-01f, 1.59204915e-01f, 1.62897691e-01f,
  -2.46126309e-01f, 4.47746851e-02f, 1.98576733e-01f, 1.67674825e-01f, 3.97781059e-02f, 2.32094139e-01f, -9.82039645e-02f, -1.12700975e-02f, 1.00495733e-01f, 2.26892501e-01f,
  2.49214873e-01f, 1.42224133e-01f, -1.82563543e-01f, -3.77395712e-02f, -2.01362938e-01f, 4.16785963e-02f, -2.26381138e-01f, 1.55560315e-01f, 1.20588645e-01f, 4.21711653e-01f,
  -2.97608882e-01f, -7.36684501e-02f, 2.36245826e-01f, -3.33744474e-02f, 1.96739480e-01f, -2.50069618e-01f, 1.28369272e-01f, -1.81366295e-01f, 3.23308080e-01f, -2.39875749e-01f,
  2.77078867e-01f, -4.99246359e-01f, -1.83976009e-01f, 3.36034894e-01f, 5.07574417e-02f, -8.68105367e-02f, 2.72897393e-01f, 4.22735326e-02f, -5.16330183e-01f, 1.41162053e-01f,
  -2.20810637e-01f, -4.39116508e-02f, -1.50833309e-01f, 5.38358167e-02f, -7.11939484e-03f, -3.50333542e-01f, 1.49132282e-01f, -1.17984049e-01f, 2.18603700e-01f, -1.33078755e-03f,
  2.35892802e-01f, 2.50607163e-01f, -1.40617892e-01f, 1.29155934e-01f, 2.58585423e-01f, -1.75815210e-01f, -5.08305989e-02f, -2.03254707e-02f, 4.05207366e-01f, 1.34381384e-01f,
  1.84955567e-01f, -3.16375911e-01f, -3.78873758e-03f, 8.07930455e-02f, 3.39035876e-02f, -1.78585306e-01f, -7.29087815e-02f, 2.52401173e-01f, 1.17764592e-01f, 7.27718174e-02f,
  1.18347622e-01f, -1.13910332e-01f, 1.90130383e-01f, 1.01115234e-01f, -1.05763130e-01f, 1.52310610e-01f, -7.42270648e-02f, -3.42568830e-02f, 2.22507700e-01f, -1.64333079e-02f,
  1.72990769e-01f, 1.76174372e-01f, -1.20193055e-02f, 2.47786686e-01f, 1.22630231e-01f, 4.36547138e-02f, 7.21509382e-02f, 1.53846711e-01f, 1.15116231e-01f, -5.97872548e-02f,
  -1.54920757e-01f, 1.58823393e-02f, -6.28417432e-02f, -1.74179047e-01f, -5.07400744e-02f, 3.81351885e-04f, -2.04947323e-01f, -1.88849717e-01f, -9.55606475e-02f, 1.59355536e-01f,
  -1.60283387e-01f, 1.16459928e-01f, 3.55761983e-02f, 2.44280286e-02f, -2.80388951e-01f, 1.77493647e-01f, -7.20664635e-02f, -1.25355840e-01f, -1.29474208e-01f, -1.21035916e-03f,
  3.53414744e-01f, 8.45856816e-02f, 1.06983542e-01f, 3.09361279e-01f, 1.44690741e-02f, 2.28787169e-01f, 1.42553926e-01f, 1.56596243e-01f, 2.84099668e-01f, 1.33582801e-02f,
  -5.64876758e-03f, 2.24555120e-01f, -2.14932814e-01f, 9.33432654e-02f, 1.59805074e-01f, -1.52616426e-01f, -6.59016473e-03f, 1.85459948e+00f, 3.16403836e-01f, -5.39079159e-02f,
  7.95078091e-03f, 3.16754580e-02f, 2.65730143e-01f, 2.06825703e-01f, 1.28428340e-01f, -6.76245764e-02f, 2.18078241e-01f, 2.33682379e-01f, 1.99227959e-01f, 1.37536630e-01f,
  2.05677509e-01f, -4.75982903e-03f, 4.11500305e-01f, -3.83102261e-02f, 2.99518287e-01f, 3.60680252e-01f, -5.86097538e-02f, 3.55177037e-02f, -9.78846103e-02f, 2.90611148e-01f,
  9.23576280e-02f, 1.69198066e-01f, -5.63298315e-02f, 2.60235220e-01f, 3.22551250e-01f, -2.62309343e-01f, -6.33778125e-02f, -6.51195422e-02f, -1.75225288e-01f, -4.35032248e-01f,
  2.57997900e-01f, 1.67791322e-01f, 1.79831952e-01f, 5.03726721e-01f, -3.08897495e-02f, 3.40275675e-01f, -5.16985916e-02f, -2.42369459e-03f, -1.86075538e-01f, -9.78195295e-02f,
  -2.71894366e-01f, -3.44079852e-01f, 9.64081511e-02f, 1.65570516e-03f, 2.45895237e-01f, -1.76959932e-01f, 2.33882368e-01f, -1.95602834e-01f, 5.53245135e-02f, 1.25000507e-01f,
  -1.16980989e-02f, 2.99787790e-01f, -1.32301569e-01f, -9.36430842e-02f, -8.84383265e-03f, 3.73215497e-01f, 7.83437863e-02f, 4.71643731e-03f, 3.47817808e-01f, 1.43550232e-01f,
  2.24056855e-01f, -4.43500519e-01f, 1.34854570e-01f, 2.25524366e-01f, 2.17922807e-01f, 9.31045711e-02f, -3.33038886e-04f, 5.96754486e-03f, 1.66007549e-01f, 6.28499612e-02f,
  -1.01181203e-02f, 2.92185575e-01f, -7.97311291e-02f, 2.57892042e-01f, 3.77706103e-02f, -7.91750699e-02f, 2.19221905e-01f, 4.95471917e-02f, -5.70721254e-02f, -9.05089546e-03f,
  1.59470141e-02f, -3.30098361e-01f, -3.11245531e-01f, 3.25581729e-01f, 6.79743942e-04f, 2.36528814e-01f, -8.32519084e-02f, 5.68886250e-02f, 2.44570524e-01f, -2.46563688e-01f,
  -1.72379985e-01f, 2.49794543e-01f, 1.86072201e-01f, 1.64134596e-02f, -2.90660504e-02f, 6.49978267e-03f, 7.82910511e-02f, 2.52767168e-02f, 3.76886755e-01f, -1.04621157e-01f,
  -2.19509512e-01f, -2.53283143e-01f, 2.50141025e-02f, -2.58986354e-01f, 7.78018963e-03f, 3.06174189e-01f, 2.59465009e-01f, 7.01317340e-02f, -1.95828333e-01f, -3.25590879e-01f,
  -3.46224271e-02f, -1.96905449e-01f, 2.10469678e-01f, -1.37289405e-01f, 1.15813956e-01f, -2.11714301e-02f, 1.22045830e-01f, 9.04094800e-03f, -8.58158022e-02f, 7.51599371e-02f,
  4.02873486e-01f, 4.72942479e-02f, 1.41393170e-01f, 6.83719397e-01f, 3.01613897e-01f, -7.49084771e-01f
};

// L3_fan_Bp_bar (Shape: 1 x 14)
const int L3_fan_Bp_bar_rows = 1;
const int L3_fan_Bp_bar_cols = 14;
const float L3_fan_Bp_bar_data[] = {
  2.36748457e-01f, 1.79038331e-01f, 1.68537945e-02f, 1.21021047e-01f, -3.34209716e-03f, -2.70854738e-02f, 3.90562564e-02f, 7.63181672e-02f, 7.51101300e-02f, 1.43018141e-01f,
  1.28365755e-01f, -4.03852714e-03f, 1.79314896e-01f, 2.49241695e-01f
};

// L4_linear_W (Shape: 12 x 64)
const int L4_linear_W_rows = 12;
const int L4_linear_W_cols = 64;
const float L4_linear_W_data[] = {
  -6.33853525e-02f, 1.20042451e-01f, 1.08721577e-01f, 6.58651963e-02f, -2.24178314e-01f, -1.47463575e-01f, -8.69408250e-02f, -5.66379242e-02f, -1.90714791e-01f, 9.51787308e-02f,
  -2.93019358e-02f, -1.85283631e-01f, 1.14474498e-01f, -1.15603328e-01f, -1.71778351e-01f, -9.16023087e-03f, 1.37715787e-01f, 6.90789819e-02f, 1.90861356e-02f, -2.87680570e-02f,
  9.55106616e-02f, 1.89338818e-01f, -2.85031408e-01f, -7.68571347e-02f, -2.35373806e-02f, 1.65852100e-01f, -9.29914489e-02f, -2.79104114e-01f, -1.53171465e-01f, -8.04883763e-02f,
  -4.41712029e-02f, 2.38700718e-01f, -2.15881795e-01f, 1.14551745e-01f, 1.24891557e-01f, 2.49713156e-02f, -1.87830597e-01f, -1.34163439e-01f, 7.68705755e-02f, -1.61066130e-01f,
  1.97473586e-01f, 1.73049688e-01f, 3.85300905e-01f, 8.46552327e-02f, 1.37721866e-01f, 9.63213667e-02f, 2.84787595e-01f, -4.23441194e-02f, 1.81668848e-01f, 1.12503938e-01f,
  -4.04519677e-01f, -1.54166847e-01f, 3.98450084e-02f, -5.26424587e-01f, -2.20072523e-01f, 3.67088020e-02f, -3.94199908e-01f, 1.30030617e-01f, 1.62617415e-01f, -4.22789194e-02f,
  -1.67516664e-01f, 2.44775310e-01f, -4.50465411e-01f, -3.73946369e-01f, -5.56261167e-02f, -1.12127699e-01f, -2.26161823e-01f, -8.04854408e-02f, 5.23407012e-02f, 2.02035278e-01f,
  8.98953825e-02f, 2.14685693e-01f, 1.19143844e-01f, -4.86197211e-02f, -1.59939602e-01f, -4.46007540e-03f, -1.09829947e-01f, -1.27244264e-01f, -1.18158601e-01f, 2.42380112e-01f,
  1.99701563e-01f, -2.66392305e-02f, 6.90048411e-02f, 1.32333115e-01f, 4.01719809e-02f, -2.06992716e-01f, 2.01241508e-01f, 1.76892370e-01f, -1.80365536e-02f, 2.59052664e-01f,
  -2.32679933e-01f, -2.39139676e-01f, 2.00312600e-01f, -1.98942140e-01f, -5.75193726e-02f, 1.70155287e-01f, 2.22948298e-01f, -8.85040462e-02f, 1.97094992e-01f, 1.71967030e-01f,
  -2.07170010e-01f, 1.18842788e-01f, 1.87983513e-01f, -1.00861609e-01f, 1.91322103e-01f, -2.52561301e-01f, -1.70690596e-01f, 2.16347486e-01f, -1.16033562e-01f, -7.94261992e-02f,
  -3.05240452e-01f, -1.16722547e-01f, -1.43805042e-01f, -3.60561728e-01f, 1.91135168e-01f, -2.80434757e-01f, -4.69902873e-01f, -1.10921097e+00f, -1.83234915e-01f, 2.85939932e-01f,
  -5.80795929e-02f, 1.01812437e-01f, -9.20506939e-02f, -5.88812411e-01f, -4.88420810e-05f, 1.51623487e-01f, -2.07630441e-01f, -3.38128090e-01f, 1.12512000e-01f, 1.31933883e-01f,
  1.05349772e-01f, -2.11635008e-01f, 2.15120930e-02f, 1.68468729e-01f, -2.65114486e-01f, -1.15628175e-01f, 1.50886729e-01f, -8.33778270e-03f, -9.63771790e-02f, 2.63204705e-02f,
  -2.40523160e-01f, -1.52627632e-01f, 1.70213208e-01f, 9.91890579e-02f, -1.01970322e-01f, -6.73272833e-02f, -1.75136421e-02f, 3.77083309e-02f, -2.07634553e-01f, 1.05028488e-01f,
  1.21596605e-01f, 1.44618392e-01f, 3.07480022e-02f, -1.13921598e-01f, -2.42573380e-01f, -5.37356883e-02f, -1.27426591e-02f, 2.69537866e-01f, 3.62301141e-01f, 1.27422869e-01f,
  7.06300437e-02f, 2.50990856e-02f, 1.97590381e-01f, -2.32702911e-01f, 2.91853249e-01f, 7.70714954e-02f, -1.90319389e-01f, -1.49396330e-01f, 8.06312338e-02f, -1.53983638e-01f,
  3.35848659e-01f, 3.42678308e-01f, 2.69718301e-02f, 2.41441742e-01f, -2.71447212e-01f, 1.43554524e-01f, 1.66055471e-01f, -1.44483581e-01f, -2.16315761e-01f, 9.36297551e-02f,
  -5.46154678e-01f, 6.67004406e-01f, -2.91350186e-01f, -6.65502250e-02f, 2.29316160e-01f, 3.63991976e-01f, -4.61518526e-01f, -1.80631787e-01f, -2.28733897e-01f, 1.01817392e-01f,
  1.86051622e-01f, -6.73252702e-01f, 1.31389111e-01f, -3.41044962e-02f, 9.01908353e-02f, -3.24598879e-01f, -2.36347347e-01f, -2.69314855e-01f, -2.57735610e-01f, -2.81500220e-01f,
  -1.62888125e-01f, -1.52294621e-01f, -2.75818527e-01f, -2.63330191e-01f, -1.43545866e-01f, -3.63763832e-02f, 2.22216487e-01f, 1.95911527e-01f, -1.46337658e-01f, -1.57299384e-01f,
  -2.12455913e-01f, 9.35845450e-02f, -7.43691400e-02f, 9.42183584e-02f, 1.60510466e-01f, 1.77970156e-01f, -2.34544445e-02f, 1.43815696e-01f, 3.01719993e-01f, -1.74698513e-02f,
  -1.86601236e-01f, 6.68816939e-02f, -9.52175483e-02f, 2.45442763e-02f, -2.22088024e-01f, -5.91099337e-02f, -2.52044261e-01f, 1.60152748e-01f, -2.03484222e-01f, -3.61666620e-01f,
  2.00762257e-01f, 1.80193886e-01f, -1.40326142e-01f, -2.49535277e-01f, -7.63324797e-02f, -6.41234219e-03f, 1.10125177e-01f, -1.73364282e-01f, 3.02789688e-01f, -8.94968063e-02f,
  1.30325884e-01f, 3.78630646e-02f, -3.19090076e-02f, -2.94385910e-01f, 1.35575056e-01f, -1.46607530e+00f, 2.34701738e-01f, -1.87521473e-01f, -7.22056031e-01f, -5.05505979e-01f,
  1.32199660e-01f, 2.91876733e-01f, 7.79172555e-02f, -3.95469725e-01f, -6.53712511e-01f, 2.12172568e-01f, -1.12999111e-01f, 5.73028512e-02f, 1.87360831e-02f, -1.26614898e-01f,
  -2.05355465e-01f, 6.50056303e-02f, 1.78153634e-01f, 2.49767303e-01f, -2.20351636e-01f, 2.62117893e-01f, -2.63025850e-01f, 2.33993471e-01f, 9.71902385e-02f, 8.89779478e-02f,
  -1.26035035e-01f, 1.28071904e-01f, -5.47290519e-02f, -2.55366368e-03f, -3.95598151e-02f, -1.72957525e-01f, 8.05186704e-02f, -7.81282559e-02f, 1.28735662e-01f, 7.06684636e-03f,
  6.76454380e-02f, 1.86727643e-01f, 2.40446761e-01f, 2.63556182e-01f, -9.98258889e-02f, -1.03373313e-02f, 3.15070987e-01f, -2.80846417e-01f, -2.65644550e-01f, 1.02549486e-01f,
  -1.46600250e-02f, 2.17277166e-02f, -1.40531706e-02f, 7.85780773e-02f, 1.08967572e-01f, 3.13353479e-01f, 2.02297941e-01f, 7.72008896e-02f, -1.93622634e-01f, -1.76431596e-01f,
  1.92326233e-01f, 4.53412011e-02f, 6.70357719e-02f, -3.74111496e-02f, 2.61905432e-01f, -3.52555104e-02f, -2.32600823e-01f, -1.43124565e-01f, 2.21783668e-01f, -1.73425817e+00f,
  -1.03691481e-01f, -8.63312855e-02f, 1.93903178e-01f, 3.17027271e-02f, 1.03633091e-01f, 1.96521059e-02f, -2.61980981e-01f, -5.83535433e-02f, -8.76091942e-02f, 1.22736238e-01f,
  1.02292828e-01f, -3.29585262e-02f, 1.22510724e-01f, 1.97381660e-01f, 2.06622094e-01f, -7.19911978e-02f, 2.58932076e-02f, 2.05173507e-01f, -1.64200932e-01f, 1.64589472e-02f,
  1.43071204e-01f, -9.20454934e-02f, -2.30317876e-01f, 1.87754273e-01f, -2.82806009e-01f, 2.45292261e-02f, -2.09310681e-01f, -1.93558130e-02f, -1.23350926e-01f, -1.03967495e-01f,
  -1.58409163e-01f, 9.20664519e-02f, 1.72814772e-01f, 9.16108340e-02f, -7.34573156e-02f, 1.53772131e-01f, -2.39526570e-01f, 2.88580567e-01f, 1.71260536e-01f, 6.93483204e-02f,
  -2.33324051e-01f, 1.85022756e-01f, 9.64444429e-02f, -2.24132225e-01f, 9.75559801e-02f, 1.29593804e-01f, -2.65895426e-01f, 1.22668758e-01f, 2.60190576e-01f, 1.58535317e-01f,
  -1.26343489e-01f, 2.58274913e-01f, -1.88233957e-01f, -1.51494130e-01f, 2.38216385e-01f, -1.25835061e-01f, 6.79079071e-02f, 1.09950677e-01f, 1.07882813e-01f, 3.91263008e-01f,
  7.39481524e-02f, 2.89702863e-01f, -1.02918614e-02f, -1.22123098e+00f, 7.43284822e-02f, 1.14033692e-01f, -3.78285170e-01f, -4.42460217e-02f, 1.26520991e-01f, -7.05961406e-01f,
  9.98226106e-02f, -1.84431851e-01f, -9.05685872e-02f, -1.91088304e-01f, 5.65925948e-02f, -4.04118095e-03f, 1.07412800e-01f, 4.60506342e-02f, 8.70755911e-02f, -6.01609945e-02f,
  -3.00369300e-02f, -2.45043159e-01f, 2.01920480e-01f, 1.19777791e-01f, 1.40663326e-01f, -8.55023861e-02f, -1.32874800e-02f, 2.06257164e-01f, -1.74499501e-03f, 2.72607595e-01f,
  1.72300413e-01f, 2.08860204e-01f, 1.75298359e-02f, -5.51341847e-02f, 1.86942622e-01f, 1.78674132e-01f, -7.23253340e-02f, -9.67262592e-03f, 5.44829369e-02f, 3.35212722e-02f,
  2.22438395e-01f, 1.25557333e-01f, 1.75913870e-01f, 2.29813516e-01f, -1.65031046e-01f, 3.13910902e-01f, 6.63143918e-02f, -4.81938273e-02f, -3.83912772e-01f, -1.23569116e-01f,
  2.60168552e-01f, 1.23751029e-01f, -1.44469187e-01f, -2.48449653e-01f, -7.71021917e-02f, -2.75694132e-01f, -1.17765382e-01f, -8.79234672e-02f, -3.61230135e-01f, 2.14297473e-01f,
  2.66628176e-01f, 2.54092425e-01f, -2.91775763e-01f, -1.80991143e-01f, 2.33205423e-01f, -8.34607631e-02f, -3.67343575e-02f, -1.72111571e+00f, -3.25010382e-02f, -3.63138676e-01f,
  2.51740456e-01f, -2.01611698e-01f, -8.60904977e-02f, -8.74687672e-01f, 2.14271173e-01f, 2.02360675e-01f, 2.68217295e-01f, -1.04899667e-01f, 4.45197988e-03f, -4.53778543e-02f,
  -1.00143768e-01f, 1.50957614e-01f, -1.99542001e-01f, 1.42379552e-01f, 1.38486281e-01f, -6.33151829e-02f, -1.83063716e-01f, -1.37724638e-01f, -5.22844456e-02f, 5.57199866e-02f,
  -1.09701939e-02f, -1.09842464e-01f, 8.07335079e-02f, 4.93512303e-02f, -5.94227314e-02f, 8.78931955e-02f, 1.27853081e-01f, -2.09883720e-01f, -2.09034234e-01f, 3.30290198e-02f,
  -2.35333964e-01f, -1.91393167e-01f, -2.07103819e-01f, -1.19168848e-01f, 1.77086502e-01f, -1.35491103e-01f, -4.14622165e-02f, -1.99611738e-01f, 4.44085561e-02f, -2.10173398e-01f,
  -2.25263551e-01f, -1.30006224e-01f, 2.11015970e-01f, -1.83407478e-02f, -2.02573627e-01f, -1.74585506e-01f, -1.98987126e-01f, -2.24104807e-01f, -6.65521100e-02f, 1.31874055e-01f,
  1.94638222e-01f, -2.69139316e-02f, -2.39141099e-02f, -1.01047859e-01f, -2.11582720e-01f, -1.57561600e-02f, 1.55931249e-01f, 2.28795096e-01f, -2.87654221e-01f, 3.37190777e-01f,
  -3.72814029e-01f, 2.33393610e-01f, -2.03016683e-01f, 1.65877398e-02f, -5.91531694e-01f, -2.89111972e-01f, -3.99666950e-02f, 2.15853944e-01f, -4.52299625e-01f, -1.74708590e-01f,
  -8.69737491e-02f, 2.14191407e-01f, 5.23060597e-02f, -2.51522094e-01f, -7.81884864e-02f, -2.00460821e-01f, -1.40353590e-01f, 1.70788430e-02f, -1.72455624e-01f, -8.26483071e-02f,
  -1.60114408e-01f, -1.41746819e-01f, 1.60412699e-01f, 5.10677211e-02f, -5.98742329e-02f, 2.78986637e-02f, 8.90852809e-02f, -3.37674707e-01f, 7.08760619e-02f, 1.13260023e-01f,
  2.06950486e-01f, -2.33373996e-02f, 2.33717456e-01f, -2.99506605e-01f, -7.02569634e-02f, 6.59534186e-02f, 2.47033425e-02f, -1.52097985e-01f, -2.30491072e-01f, -2.06806287e-01f,
  2.65222371e-01f, 1.68352515e-01f, 3.20837229e-01f, 1.58206075e-01f, 2.06279188e-01f, 2.48977393e-01f, 2.41423801e-01f, -2.33034939e-01f, -9.19365361e-02f, 2.26274997e-01f,
  -2.54209250e-01f, 1.39170557e-01f, 7.16478843e-03f, -2.34200612e-01f, 6.72467425e-02f, 2.93013658e-02f, 2.32042208e-01f, 3.76124159e-02f, -6.39794096e-02f, 2.61123329e-01f,
  -1.23162061e-01f, 9.29993913e-02f, 2.62101233e-01f, 1.21444412e-01f, -4.63860482e-01f, 5.33041656e-01f, 2.68059254e-01f, 7.81109259e-02f, -2.89515823e-01f, -5.11056781e-01f,
  -3.30932647e-01f, -9.06404197e-01f, -3.36917132e-01f, -4.68734512e-03f, 1.58768892e-01f, 8.62036720e-02f, -2.17874318e-01f, -9.40641388e-02f, -1.43674642e-01f, 2.19650149e-01f,
  2.14398623e-01f, -2.31552243e-01f, 8.86402652e-02f, -1.65122151e-01f, 2.17590213e-01f, 1.61776580e-02f, 2.47614712e-01f, -6.31204024e-02f, 1.68484747e-01f, 5.06742299e-02f,
  5.08192740e-02f, -1.41590774e-01f, 1.77998886e-01f, 3.69445197e-02f, 1.10175043e-01f, -3.13757844e-02f, -1.55463442e-01f, -2.20847547e-01f, 2.71129429e-01f, -1.42030701e-01f,
  -1.24051929e-01f, 2.35674709e-01f, 2.25370422e-01f, 6.64649382e-02f, 1.06717080e-01f, 1.06206164e-01f, -1.98108017e-01f, -2.12702796e-01f, 2.91887552e-01f, -1.75235882e-01f,
  3.21906656e-01f, 2.34752655e-01f, 3.26777756e-01f, 1.63743541e-01f, -3.33062381e-01f, -1.27165988e-01f, 2.23089635e-01f, -3.14366937e-01f, 3.83585244e-02f, -1.61815822e-01f,
  2.36098573e-01f, 2.39004046e-01f, 2.38783687e-01f, -3.38755548e-02f, 2.93873459e-01f, 1.45477459e-01f, -4.92096394e-02f, 1.88037872e-01f, 3.26640420e-02f, 3.71143341e-01f,
  1.85914904e-01f, -4.45419997e-01f, -7.17431232e-02f, 2.16532946e-01f, 1.06326334e-01f, -8.69310915e-01f, -5.12596250e-01f, -6.85262457e-02f, -3.02820895e-02f, -6.88737258e-02f,
  2.96384841e-02f, 1.26745582e-01f, 7.43683279e-02f, 1.91199571e-01f, 9.91967693e-02f, 1.25281736e-01f, 4.12952043e-02f, 8.87043849e-02f, 1.00349963e-01f, -1.83654219e-01f,
  2.41761222e-01f, -8.23227987e-02f, 1.86418667e-01f, -1.81414664e-01f, -1.26300797e-01f, -4.20943648e-02f, -1.66887879e-01f, -8.04822072e-02f, 9.36956182e-02f, 6.80731013e-02f,
  -1.71942607e-01f, 2.82114372e-02f, 1.06382102e-01f, -2.82482445e-01f, -6.07681237e-02f, 1.92944869e-01f, -3.31429958e-01f, 4.80632000e-02f, 3.44339646e-02f, -7.99358040e-02f,
  -1.31671861e-01f, -2.15313897e-01f, -4.24988009e-02f, -1.24115080e-01f, -2.42261842e-01f, 1.53106317e-01f, -2.75183450e-02f, 1.60319090e-01f, -7.98761547e-02f, 1.51534602e-01f,
  -1.72170579e-01f, 2.14213863e-01f, -1.16534881e-01f, -8.71734247e-02f, -3.32534701e-01f, -1.80492193e-01f, 1.17830165e-01f, 2.68858612e-01f, -2.41832405e-01f, -3.63948345e-01f,
  7.76648000e-02f, -5.61653614e-01f, -1.95834130e-01f, -4.64620173e-01f, -2.57653534e-01f, 4.05592248e-02f, 8.40640068e-02f, -2.26491913e-01f, 1.04108199e-01f, 1.31551862e-01f,
  4.09486204e-01f, -1.56307191e-01f, -2.26104096e-01f, 4.14224193e-02f, -4.73787449e-02f, -1.66576095e-02f, 3.11006159e-02f, -4.32826541e-02f, 1.43348008e-01f, 1.16431423e-01f,
  1.26578942e-01f, 2.50935912e-01f, 1.01533063e-01f, 6.16940707e-02f, 2.54838049e-01f, 1.29795894e-01f, 1.58807993e-01f, 3.26325782e-02f, 9.71469134e-02f, -2.55507350e-01f,
  -1.31981626e-01f, -1.59940839e-01f, -1.63106620e-01f, 8.36769715e-02f, -7.43969604e-02f, -5.95940389e-02f, -1.46827683e-01f, -3.23887207e-02f, 7.89577141e-03f, -2.76095420e-01f,
  -8.14239755e-02f, 2.50732780e-01f, -3.31186414e-01f, 3.48343775e-02f, -8.27755779e-02f, -2.09457874e-01f, 1.54042616e-01f, 1.12788185e-01f, -2.52039075e-01f, -1.65012572e-02f,
  -1.71628166e-02f, -1.24146417e-02f, 1.04262486e-01f, -1.98651731e-01f, -1.27220973e-01f, 1.65139154e-01f, -1.27056926e-01f, 1.23609612e-02f, 4.70722131e-02f, -2.59054434e-02f,
  -3.56850326e-01f, 2.03048453e-01f, -1.46092281e-01f, 3.71533930e-01f, 2.76669025e-01f, -1.97409660e-01f, 2.32861966e-01f, -8.98900509e-01f, 1.84637904e-01f, -2.83037484e-01f,
  -3.38748038e-01f, -8.18382800e-01f, -5.52871898e-02f, -1.58697084e-01f, -9.42688286e-02f, -3.70305002e-01f, 2.17879474e-01f, 2.81851232e-01f
};

// L4_linear_B (Shape: 1 x 12)
const int L4_linear_B_rows = 1;
const int L4_linear_B_cols = 12;
const float L4_linear_B_data[] = {
  2.08361167e-02f, 7.22443238e-02f, -1.97624974e-02f, 1.47844851e-01f, -1.20286494e-01f, -9.99155790e-02f, -1.13951437e-01f, 8.39676410e-02f, 1.06733657e-01f, 7.20309317e-02f,
  -1.15826495e-01f, -6.19311519e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 25, 14
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        64, 25, 14
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        64, 25, 14
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L3_fan_Wp_data, L3_fan_Wp_bar_data, L3_fan_Bp_bar_data,
        64, 25, 14
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 4: L4_linear
    linear_forward_pgm(
        buffer1, x_out,
        L4_linear_W_data, L4_linear_B_data,
        64, 12
    );
    }
    