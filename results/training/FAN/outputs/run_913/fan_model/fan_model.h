/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 128 (x1)
    * Saída: 12
    * Buffer Máx: 128
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 128;
    const int FAN_MAX_BUFFER_SIZE = 128;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    return (x > 0.0f) ? x : 0.0f;
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 12 x 120)
const int L0_fan_Wp_rows = 12;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -4.94767316e-02f, -3.21192920e-01f, -2.81531569e-02f, 7.91442394e-03f, -1.08072720e-01f, -1.89965721e-02f, 4.48720828e-02f, 4.80761565e-02f, 3.20599154e-02f, 2.14060023e-02f,
  -2.29918420e-01f, 5.67872487e-02f, 4.32867445e-02f, 1.54513597e-01f, 1.92061767e-01f, 1.58541605e-01f, 2.49131739e-01f, 2.47883022e-01f, 3.03457201e-01f, 1.41437024e-01f,
  6.48916140e-02f, 2.43660156e-02f, 9.64371301e-03f, 2.17801351e-02f, -1.72909591e-02f, 2.19679475e-02f, -6.48441538e-02f, -9.64574888e-02f, -6.07421622e-02f, 2.69835033e-02f,
  1.94004655e-03f, -2.87471563e-01f, 1.74894378e-01f, 4.61914130e-02f, -1.10500880e-01f, 1.56513415e-02f, -5.19686565e-02f, -9.35659036e-02f, -4.50743682e-04f, 1.23557206e-02f,
  -3.00324261e-02f, -6.81715608e-02f, 3.35293077e-02f, 2.12859060e-03f, -7.72645697e-04f, 3.43915559e-02f, 1.43009061e-02f, 4.47691754e-02f, 4.93364334e-02f, -5.36420420e-02f,
  -2.98694298e-02f, -1.17844611e-01f, 2.85257529e-02f, -5.58568239e-02f, -3.84473871e-03f, 1.43376039e-02f, -3.54251303e-02f, -1.10665150e-01f, -1.50802517e-02f, 2.13511474e-03f,
  4.80320230e-02f, 4.03558426e-02f, 1.13394822e-03f, -1.03109285e-01f, -3.97136761e-03f, 2.32492364e-03f, -2.14676131e-02f, 3.92529853e-02f, 7.82765746e-02f, -3.19565982e-02f,
  6.32445421e-03f, -3.08183604e-03f, -1.32179363e-02f, -6.69660338e-04f, 1.85781103e-02f, -9.70793888e-02f, -4.77583185e-02f, 1.16054360e-02f, -4.39441055e-02f, -1.06656067e-02f,
  -4.26530242e-02f, 6.21901415e-02f, -1.26739487e-01f, -1.48999868e-02f, -6.70963619e-03f, -2.72255279e-02f, 7.31413737e-02f, -6.73793331e-02f, -4.94997716e-03f, 1.93416141e-02f,
  3.66748869e-02f, 2.96328235e-02f, 5.61042242e-02f, 1.45194441e-01f, 4.65662666e-02f, 1.60653833e-02f, -7.22890049e-02f, -4.20965068e-03f, -7.41827115e-02f, -1.25676440e-02f,
  -3.72456275e-02f, 5.06057590e-02f, -3.21409106e-02f, -6.16515093e-02f, 5.95241189e-02f, 1.12660555e-03f, 6.83186948e-02f, -7.74929719e-03f, 1.07291833e-01f, -9.24603343e-02f,
  -4.84129647e-03f, 1.68610707e-01f, 1.68320820e-01f, 1.51239768e-01f, 5.81768304e-02f, 2.00082392e-01f, 4.26526405e-02f, 1.40347451e-01f, 1.71796456e-01f, 1.99403584e-01f,
  2.63734162e-01f, -1.79261416e-02f, -1.78380400e-01f, -9.24142748e-02f, -2.52617210e-01f, -1.36386260e-01f, -1.16005391e-01f, 4.89321016e-02f, 9.35779512e-02f, -1.36929099e-02f,
  -1.37468800e-01f, 4.54341695e-02f, 8.76170695e-02f, 8.17008689e-02f, 1.45049840e-01f, 3.60421836e-02f, 6.80803088e-03f, 1.92645684e-01f, 1.48962647e-01f, 7.09122717e-02f,
  -8.59176666e-02f, 6.84387013e-02f, 8.92571658e-02f, 1.98079888e-02f, -3.35320309e-02f, -1.33202393e-02f, -1.58752829e-01f, -1.52452618e-01f, -1.37120694e-01f, -9.49205309e-02f,
  -2.29982495e-01f, -1.14874193e-03f, 4.52784598e-02f, -6.05606250e-02f, -1.63035080e-01f, 6.33722171e-02f, -6.27794713e-02f, 6.37657270e-02f, -5.36375716e-02f, 5.94753325e-02f,
  -7.00210929e-02f, -4.98235151e-02f, 7.66801760e-02f, -4.33924869e-02f, 4.28782292e-02f, 8.18482786e-02f, 4.76799682e-02f, 1.37578592e-01f, 1.18870951e-01f, -9.75251943e-02f,
  -1.04729705e-01f, -2.47388557e-01f, -2.97838151e-02f, -4.18545268e-02f, -1.26118213e-02f, 6.91061281e-03f, -6.62987903e-02f, -6.23875409e-02f, 3.18537652e-02f, -7.98574686e-02f,
  2.41308883e-02f, -9.33069438e-02f, 2.28768354e-03f, 8.79938155e-02f, 5.70007376e-02f, 3.65895815e-02f, 2.13787779e-02f, -1.13382816e-01f, 5.80316111e-02f, -6.07223026e-02f,
  7.00505748e-02f, -5.83137013e-02f, -3.39056216e-02f, 3.54698673e-03f, -4.59149852e-02f, 2.25769747e-02f, -3.36985365e-02f, -8.72683898e-03f, -1.49442665e-02f, 6.67363871e-03f,
  1.11490741e-01f, 3.60529795e-02f, -6.29510507e-02f, -5.23399375e-03f, 1.51964147e-02f, 4.28815745e-03f, 2.72427835e-02f, 4.09046141e-03f, -1.31175928e-02f, -6.56898618e-02f,
  -4.64574359e-02f, -4.53336760e-02f, 3.52896079e-02f, 7.44785517e-02f, -2.09346190e-02f, 4.28734533e-02f, -4.22803871e-02f, -4.59078401e-02f, -3.24561596e-02f, -5.79994768e-02f,
  -3.30223776e-02f, 1.20126799e-01f, -6.35874346e-02f, -1.85078830e-02f, -1.49525646e-02f, 7.17731938e-02f, -1.07055884e-02f, 4.71265912e-02f, 5.89346588e-02f, -8.12817290e-02f,
  -2.44128183e-02f, -3.51116136e-02f, -1.38941864e-02f, -3.59809883e-02f, -8.35887715e-03f, -1.09101878e-02f, -8.60891193e-02f, -6.11033998e-02f, 1.21873163e-01f, 7.91091099e-02f,
  -1.55704468e-01f, -1.59461349e-02f, 8.44395440e-03f, -3.31743136e-02f, -3.86882573e-02f, 1.11223765e-01f, 1.49729222e-01f, 1.92786619e-01f, 4.10163812e-02f, 1.01770135e-02f,
  -1.02647498e-01f, 2.24920772e-02f, -5.24380468e-02f, 2.26800311e-02f, 1.18139789e-01f, 1.72143131e-01f, 6.84366822e-02f, 1.15551226e-01f, 6.73930049e-02f, 6.57676086e-02f,
  -1.76239125e-02f, -2.05908585e-02f, -1.41385987e-01f, -5.92218339e-02f, -7.66448304e-02f, 6.26874063e-03f, -5.89561537e-02f, -1.14164956e-01f, 2.86784233e-03f, -2.11841047e-01f,
  -5.30391000e-02f, -2.59807169e-01f, 3.12457345e-02f, -1.00073256e-01f, -3.30632925e-02f, 1.50872897e-02f, -3.66150308e-03f, -3.36934365e-02f, -9.84992087e-02f, 1.13370279e-02f,
  -2.86539141e-02f, -7.41535798e-02f, 3.05887870e-02f, -8.60171765e-02f, -1.12161068e-02f, 8.53460375e-03f, 9.86093730e-02f, -6.50417283e-02f, 2.82133222e-02f, 4.48565297e-02f,
  2.12856685e-03f, -1.39885291e-01f, 9.21428669e-03f, 1.19674668e-01f, -3.84565257e-02f, 4.92190681e-02f, 1.91357397e-02f, -7.96169639e-02f, 2.72450857e-02f, 2.02065092e-02f,
  6.31093085e-02f, -6.74765036e-02f, -1.68130696e-02f, -3.72378044e-02f, 1.17403874e-02f, 2.91144922e-02f, 2.57370491e-02f, 4.19061221e-02f, -4.37246636e-03f, 7.01212510e-02f,
  5.20870835e-02f, -7.26827756e-02f, -5.65561391e-02f, -4.03543760e-04f, -2.42563710e-03f, 1.75165776e-02f, -7.07440153e-02f, -2.75995620e-02f, -6.06462965e-03f, -1.90807898e-02f,
  -6.84980750e-02f, 4.37745079e-02f, 3.17133055e-03f, 2.97685321e-02f, -2.08342504e-02f, 1.44163482e-02f, 6.29511923e-02f, 2.10835412e-02f, 2.09299587e-02f, 4.71992791e-02f,
  2.09143862e-01f, 1.06860436e-01f, -1.20906448e-02f, -3.74187939e-02f, -8.94669164e-03f, 3.82668264e-02f, -3.45264785e-02f, 2.25909930e-02f, -1.21700531e-03f, 7.55094066e-02f,
  4.01225761e-02f, -3.55161689e-02f, 3.58439945e-02f, 1.01047054e-01f, 7.65391206e-03f, 4.60167136e-03f, 8.54025558e-02f, -9.30886343e-03f, -5.61272763e-02f, -3.46581601e-02f,
  5.18208444e-02f, 2.13020757e-01f, 2.77594864e-01f, 2.00604379e-01f, 6.95098713e-02f, 1.78091317e-01f, 1.91171825e-01f, 1.68742076e-01f, 2.49056473e-01f, 2.25898415e-01f,
  2.21246213e-01f, -2.51554288e-02f, 1.15527079e-01f, 6.02526478e-02f, 1.40356869e-01f, 1.42651230e-01f, 2.42136791e-01f, 4.41644751e-02f, 3.19916606e-02f, -1.97698902e-02f,
  -9.55261886e-02f, -1.56596005e-01f, 2.99369451e-02f, -6.22471571e-02f, 2.55277306e-02f, 8.56014341e-02f, 2.38032073e-01f, 1.92698419e-01f, 1.12661317e-01f, 1.42234564e-01f,
  3.42643745e-02f, 1.59000501e-01f, 1.40576273e-01f, 1.16280906e-01f, 3.37875113e-02f, -3.71884108e-02f, 3.13462354e-02f, 5.74993454e-02f, 1.84604228e-02f, 5.18533587e-03f,
  -1.01587949e-02f, -1.13070548e-01f, -2.47292481e-02f, -8.37056935e-02f, -8.42024833e-02f, 1.13591492e-01f, -4.14291508e-02f, 3.75910811e-02f, 1.55509524e-02f, 5.81443571e-02f,
  7.87781784e-04f, 4.55731861e-02f, 5.95760942e-02f, -7.39788935e-02f, 1.58999786e-02f, 8.48484933e-02f, -3.65960598e-02f, 6.18758760e-02f, -5.27044460e-02f, -3.60534005e-02f,
  -1.06570534e-01f, 1.08606920e-01f, 1.34221405e-01f, -1.82879679e-02f, -6.33096322e-02f, -1.72564760e-02f, 3.66854519e-02f, -3.23477909e-02f, -4.50597405e-02f, 1.47773931e-02f,
  9.39320773e-02f, 4.64437390e-03f, -1.31497076e-02f, 2.32597440e-02f, -2.71286741e-02f, -9.63175017e-03f, -2.84031294e-02f, 4.94041927e-02f, -5.52019700e-02f, 6.75821751e-02f,
  -7.25670531e-02f, -1.97686837e-03f, -3.78675908e-02f, 5.48270009e-02f, -3.35305440e-03f, -4.41903062e-02f, 2.94227749e-02f, 1.15694096e-02f, 4.81651574e-02f, -1.71500782e-03f,
  -1.43996626e-02f, 1.29045993e-02f, 2.55696084e-02f, 3.62470932e-02f, -7.90088028e-02f, 9.29005630e-03f, -4.21227105e-02f, -1.17065780e-01f, 3.73362787e-02f, -4.60347086e-02f,
  -5.70133254e-02f, 2.32580351e-03f, 7.55227208e-02f, 2.63782181e-02f, 7.32733533e-02f, -5.65530322e-02f, -1.82360560e-02f, -7.49958027e-03f, 6.80778595e-03f, -1.03407307e-02f,
  2.43716892e-02f, 4.75223511e-02f, -2.73365080e-02f, 3.70543599e-02f, -2.35742275e-02f, 4.64653708e-02f, 7.28865564e-02f, 1.15807377e-01f, 2.20386474e-03f, -6.89820945e-02f,
  1.62410233e-02f, 1.42032653e-01f, 1.40358642e-01f, 1.20476417e-01f, -8.45383760e-03f, 4.24654856e-02f, 8.16273838e-02f, 6.09730370e-02f, 1.41571447e-01f, 1.84365854e-01f,
  -7.42039979e-02f, 1.36458576e-01f, 8.77933726e-02f, 1.81345150e-01f, 1.24416471e-01f, -6.90838173e-02f, -1.62507832e-01f, -4.23955508e-02f, 1.95342079e-02f, 9.02561620e-02f,
  -1.14069864e-01f, -1.77245095e-01f, -7.03673437e-02f, -2.15063944e-01f, -1.39073253e-01f, 1.04429424e-01f, 1.62724823e-01f, -1.42328486e-01f, -2.84763157e-01f, -7.12415874e-02f,
  5.93962334e-02f, 8.97768959e-02f, -9.62875038e-02f, 1.41141966e-01f, 3.49391401e-01f, 1.39022857e-01f, 1.34359241e-01f, 2.03930706e-01f, 8.27024430e-02f, 3.22013527e-01f,
  -3.84929217e-02f, 9.19343606e-02f, -1.73611403e-01f, 3.04764509e-02f, 3.72329168e-02f, -6.62003532e-02f, -6.00069650e-02f, 2.43160315e-02f, 8.94622970e-03f, 5.46504296e-02f,
  1.46591514e-01f, -1.41153885e-02f, 1.21496338e-02f, -1.70262356e-03f, 5.92713319e-02f, -3.51472311e-02f, 2.00528949e-02f, 4.32566516e-02f, -1.08447753e-01f, 4.42480296e-02f,
  9.10208449e-02f, 3.92595641e-02f, -1.39818013e-01f, -1.06546208e-01f, -9.18861851e-02f, -9.50692296e-02f, 5.72271943e-02f, 2.56067440e-02f, -1.72970369e-01f, 1.18516147e-01f,
  5.55290319e-02f, 9.82501358e-03f, 2.48946995e-02f, 4.72156405e-02f, 5.94377238e-03f, 1.53188901e-02f, -1.14602968e-04f, 3.34179867e-03f, 6.38840580e-03f, 3.96643467e-02f,
  1.89486761e-02f, -4.81207706e-02f, -1.83497462e-02f, 2.34758258e-02f, 2.81988084e-02f, 4.48404923e-02f, 4.71631624e-02f, -5.86491711e-02f, 3.18807438e-02f, 2.78001800e-02f,
  6.49074791e-03f, -1.02859236e-01f, 2.17153840e-02f, -4.74494807e-02f, 3.20434384e-02f, 5.36227785e-02f, -3.70748714e-02f, 2.75594741e-02f, -3.32781710e-02f, 6.24781400e-02f,
  -1.41994774e-01f, -2.50922471e-01f, 1.09076314e-01f, -8.44147354e-02f, 6.30425438e-02f, -1.67198926e-02f, 3.81627604e-02f, 4.50693704e-02f, 3.02123791e-03f, 2.18516658e-03f,
  -8.34069178e-02f, -7.48110935e-02f, 5.71391433e-02f, 5.87710626e-02f, -7.71596357e-02f, -4.62690890e-02f, 5.36671355e-02f, 2.07943209e-02f, -8.29133671e-03f, 5.55322431e-02f,
  5.39771058e-02f, -2.60155611e-02f, -1.45431712e-01f, -1.17166296e-01f, -8.84813163e-03f, -1.96285829e-01f, -5.99952787e-02f, -9.16565806e-02f, -2.48422757e-01f, 5.79005405e-02f,
  -3.24025214e-01f, -3.92937899e-01f, -1.40025124e-01f, -3.42590772e-02f, 9.61056873e-02f, 3.36733051e-02f, -4.78755645e-02f, -1.48924133e-02f, 1.24365948e-01f, -1.49391014e-02f,
  3.58939804e-02f, 1.29240394e-01f, 1.32804960e-01f, 1.22682691e-01f, 7.35779628e-02f, -3.22331302e-02f, -4.68872599e-02f, -5.64883761e-02f, 2.09871769e-01f, 1.48763090e-01f,
  8.14738050e-02f, -1.21438459e-01f, -1.98963031e-01f, 5.04386518e-03f, -8.36527497e-02f, 2.24452019e-02f, -1.04795367e-01f, -6.15214854e-02f, -1.28613114e-01f, -1.41586244e-01f,
  1.81594074e-01f, -2.64850318e-01f, 1.96290106e-01f, -3.94296162e-02f, -1.26931608e-01f, 5.97654916e-02f, -4.45227660e-02f, -1.11474330e-02f, -5.64895105e-03f, -4.01984751e-02f,
  7.67579302e-03f, 6.74149245e-02f, 1.32880891e-02f, -3.91234867e-02f, 1.85329448e-02f, 7.44403899e-02f, -6.66885376e-02f, -4.10034135e-02f, -7.08025768e-02f, 6.31976873e-03f,
  -4.08358872e-02f, -8.36956501e-02f, -6.62185177e-02f, -8.31480175e-02f, 1.14492578e-02f, 5.28151989e-02f, -1.32531404e-01f, -8.95522237e-02f, -1.41934633e-01f, -1.52232721e-01f,
  4.89324965e-02f, -5.24179451e-02f, 5.81146665e-02f, 3.90732177e-02f, 1.16798060e-03f, -2.37202737e-02f, 3.33976671e-02f, 1.44658536e-02f, 1.37559203e-02f, -6.11026175e-02f,
  7.85215423e-02f, 5.45679145e-02f, 5.83111262e-03f, -5.70805334e-02f, -2.68933829e-03f, 3.24064121e-02f, 4.00549965e-03f, 4.49788943e-02f, -7.36347288e-02f, 2.13778652e-02f,
  4.49250676e-02f, -1.48259923e-02f, 1.80780198e-02f, -6.98666573e-02f, 3.97689408e-03f, -6.12919703e-02f, 8.28980953e-02f, -1.60522684e-02f, 1.82459783e-02f, -1.87266394e-02f,
  7.92403985e-03f, -7.67634064e-02f, 6.84851408e-02f, 6.13912195e-02f, -2.43127793e-02f, 2.46471819e-02f, -3.64177302e-02f, -4.70476598e-02f, -4.38960567e-02f, 7.74725452e-02f,
  5.99835850e-02f, -3.91299389e-02f, -3.43693681e-02f, 4.21779841e-05f, 1.27036095e-01f, 4.56476472e-02f, -5.57284290e-03f, 4.34480831e-02f, 8.71443078e-02f, 5.79080731e-02f,
  6.65442422e-02f, -3.93484123e-02f, 1.20514408e-01f, 1.07186720e-01f, 4.40635607e-02f, 1.22563191e-01f, 1.07562810e-01f, 9.01290774e-02f, -2.63724010e-02f, -4.25033048e-02f,
  2.53236115e-01f, 7.08443820e-02f, 2.60436505e-01f, -6.93575069e-02f, -8.62150919e-03f, -3.52819711e-02f, 5.04626930e-02f, -8.29320848e-02f, -6.34241626e-02f, 1.13743305e-01f,
  -1.19391285e-01f, -1.87983155e-01f, -7.02311238e-03f, -1.25749186e-01f, -3.41001078e-02f, 1.14656821e-01f, 1.40630957e-02f, 2.41009071e-02f, -2.72727497e-02f, 3.44641879e-02f,
  -8.93957242e-02f, -1.15206830e-01f, 8.92233402e-02f, -1.04849778e-01f, -5.72273768e-02f, -4.66680992e-03f, 1.04023755e-01f, -4.54644952e-03f, 8.26434568e-02f, 7.74638727e-02f,
  2.89258987e-01f, 9.55287218e-02f, -7.74651617e-02f, -1.94166288e-01f, 4.86838222e-02f, -2.52494477e-02f, 8.09689611e-02f, -5.13148308e-02f, -6.14540055e-02f, 4.34802137e-02f,
  -9.82580483e-02f, -6.56516775e-02f, -3.14596854e-02f, -2.22837534e-02f, 3.69060561e-02f, 1.08406134e-01f, 4.08491865e-02f, 1.14330150e-01f, 9.08412486e-02f, 6.95316792e-02f,
  -1.57118842e-01f, 1.85298249e-02f, 9.37030390e-02f, 1.21388324e-01f, 4.72115651e-02f, -4.28734720e-02f, 8.45553949e-02f, 1.22330941e-01f, 1.65491343e-01f, 1.51844352e-01f,
  5.71461320e-02f, -2.88636405e-02f, 2.52056867e-02f, -2.48170961e-02f, -3.76079828e-02f, 3.08931377e-02f, -1.40309390e-02f, 2.12562587e-02f, -5.24050966e-02f, 5.19410484e-02f,
  -1.34366145e-02f, 8.05147588e-02f, 3.51143368e-02f, 2.34211292e-02f, -6.28599226e-02f, 3.87061015e-02f, -2.70722788e-02f, -5.89747801e-02f, 3.02635296e-03f, 1.08529879e-02f,
  7.01297149e-02f, 7.20848655e-03f, -2.28792150e-03f, 5.45818591e-03f, -5.26804067e-02f, 1.08270496e-02f, 4.39414233e-02f, 6.66855946e-02f, 5.25066257e-03f, 6.30392954e-02f,
  8.74703601e-02f, -7.29755238e-02f, 9.69395489e-02f, 1.90198123e-02f, 4.16970216e-02f, 5.21557741e-02f, -5.84600642e-02f, 6.85817841e-03f, 5.41149871e-04f, -3.00519783e-02f,
  1.10070975e-02f, 3.09927855e-02f, -5.23713194e-02f, -6.64443970e-02f, 4.94294055e-02f, -5.80109209e-02f, -6.78324401e-02f, -3.98881957e-02f, -3.30257453e-02f, 2.41113584e-02f,
  3.96808721e-02f, 5.99790104e-02f, 8.12508836e-02f, 6.84117572e-03f, 2.31356174e-02f, 3.01603861e-02f, 8.05096254e-02f, 2.68004499e-02f, 9.10463557e-02f, 1.86761305e-01f,
  4.64662433e-01f, 1.33178607e-01f, 1.76429987e-01f, -1.76371038e-02f, -2.79009715e-02f, 1.44298106e-01f, 1.56347170e-01f, 1.30045772e-01f, -6.44119922e-03f, -7.56058246e-02f,
  -2.08671436e-01f, -9.36604068e-02f, -1.32440440e-02f, 3.29033285e-02f, 1.64747685e-01f, 9.38493162e-02f, 1.10853992e-01f, 8.47082809e-02f, 1.95768282e-01f, -3.84238847e-02f,
  -3.34519260e-02f, 6.11370057e-02f, 9.76089761e-02f, 5.77581227e-02f, -1.39926538e-01f, 1.05317887e-02f, -8.90303403e-03f, -1.08585116e-02f, -2.96833627e-02f, -6.72312751e-02f,
  -6.08614124e-02f, 1.28148839e-01f, -2.06852388e-02f, -1.64411087e-02f, -6.94980621e-02f, -3.46278958e-02f, 9.24526528e-03f, 4.39696340e-03f, 1.80636765e-03f, -6.67541176e-02f,
  -7.97692761e-02f, -1.11349858e-01f, -4.19376791e-02f, -6.68207407e-02f, 6.46141768e-02f, -3.76214460e-02f, -7.96067938e-02f, 1.03701510e-01f, -3.89602780e-02f, 1.91338025e-02f,
  -2.13243425e-01f, -8.99470877e-03f, 3.54917161e-02f, 3.45991850e-02f, -2.94017605e-02f, -1.21645899e-02f, 5.93219809e-02f, 8.77620950e-02f, 1.98398188e-01f, 1.46175906e-01f,
  1.73114892e-02f, 4.11244743e-02f, 1.01643177e-02f, -1.44929411e-02f, 6.93033338e-02f, -3.97025943e-02f, 1.24810531e-03f, -4.76826802e-02f, -1.25534860e-02f, 2.25104950e-02f,
  -2.08046045e-02f, 4.18252870e-02f, -4.64942157e-02f, -4.55236947e-03f, -1.56446416e-02f, 2.54055653e-02f, 8.43882486e-02f, -1.74202956e-02f, 1.20691005e-02f, 4.65145223e-02f,
  1.23125617e-03f, -4.15662341e-02f, -3.80754587e-04f, -4.14193757e-02f, 3.05387042e-02f, 8.51150006e-02f, -4.03807964e-03f, -3.95815484e-02f, -1.23222377e-02f, 5.67831434e-02f,
  -1.42244071e-01f, 7.31130987e-02f, 3.58844437e-02f, -5.54593727e-02f, -7.07516586e-03f, -5.19675948e-02f, 3.43550108e-02f, 9.51391086e-03f, -1.92736778e-02f, 5.40014766e-02f,
  -1.38991168e-02f, 1.05859168e-01f, -1.93825234e-02f, -6.42287284e-02f, 6.48458898e-02f, -1.09203476e-02f, -2.17399392e-02f, 8.83272216e-02f, -2.58611832e-02f, -3.58754559e-03f,
  6.68254197e-02f, 1.63555503e-01f, 2.32239634e-01f, 4.09165286e-02f, 5.01926765e-02f, 1.51977718e-01f, 1.21315368e-01f, 1.44257143e-01f, 2.67062396e-01f, 2.96289384e-01f,
  -4.26096618e-01f, -3.76258008e-02f, 9.27915946e-02f, -2.57210463e-01f, 2.63658054e-02f, 2.02740565e-01f, 7.19499290e-02f, 5.25659993e-02f, -2.21483916e-01f, -8.76347125e-02f,
  5.85305169e-02f, -3.63013446e-02f, 3.56300399e-02f, 1.24812268e-01f, 6.84548691e-02f, 8.91761184e-02f, 4.83099334e-02f, 1.43941686e-01f, 4.32928540e-02f, -1.63489636e-02f,
  -5.01383189e-03f, -4.22444893e-04f, -3.22276950e-02f, -8.22627693e-02f, 2.60912627e-02f, -3.97097878e-02f, 7.87410885e-02f, 7.24237338e-02f, 4.00142632e-02f, -7.11722076e-02f,
  5.36968298e-02f, -9.15627740e-03f, 4.80607674e-02f, 5.52134216e-03f, 9.86714363e-02f, -1.24053918e-01f, -8.61969143e-02f, 1.92081295e-02f, -2.17944980e-02f, -1.78651102e-02f,
  8.27149451e-02f, 3.92894931e-02f, 8.23386828e-04f, 4.21855511e-04f, -6.38177171e-02f, -7.24313408e-02f, 2.88732089e-02f, 4.24754024e-02f, -3.02531067e-02f, 3.60535942e-02f,
  6.17705174e-02f, -1.93230752e-02f, 1.06463768e-01f, 1.12834156e-01f, 2.97304876e-02f, 8.42504725e-02f, -9.04980488e-03f, 6.65645897e-02f, 7.28447437e-02f, -1.09286442e-01f,
  -4.67887037e-02f, 5.45542724e-02f, -2.10186113e-02f, -3.90787981e-02f, 4.08620499e-02f, -5.09595498e-03f, -4.63208109e-02f, 6.90074489e-02f, -3.80232707e-02f, -2.76545379e-02f,
  -1.56333297e-02f, 9.13204346e-03f, 4.27794419e-02f, -2.51887105e-02f, 6.26909453e-03f, 8.83541480e-02f, 1.72075722e-02f, -3.06605902e-02f, 8.93361345e-02f, -1.03070132e-01f,
  -7.55449757e-02f, 3.44810374e-02f, 3.31199244e-02f, 6.70515224e-02f, 4.11207825e-02f, -4.41336595e-02f, 4.50271182e-02f, 4.06513251e-02f, -7.47898147e-02f, 1.73820108e-02f,
  -2.16517776e-01f, 2.07578272e-01f, -5.85524105e-02f, 2.27644318e-03f, 5.11849448e-02f, -4.62283902e-02f, -1.26874642e-02f, -7.38406405e-02f, 3.64610343e-03f, -8.18341076e-02f,
  7.38530932e-03f, -2.59709433e-02f, 5.13858758e-02f, -6.46175398e-03f, -8.90701413e-02f, -6.45109545e-03f, 9.05640237e-03f, 4.80623581e-02f, 1.02333479e-01f, 2.26334226e-03f,
  -1.08438730e-01f, -4.49066889e-03f, -1.28546000e-01f, -3.07980105e-02f, 1.09687783e-02f, -2.59289462e-02f, 6.79803714e-02f, -2.15134993e-02f, 9.06586647e-03f, -2.19192639e-01f,
  -4.96528774e-01f, 2.41946518e-01f, 3.03565204e-01f, -1.99437335e-01f, 1.02681153e-01f, 1.55122697e-01f, 4.66599852e-01f, 6.45881221e-02f, -1.12366974e-01f, 2.99940072e-02f,
  -7.90250003e-02f, -3.02780777e-01f, -4.14258353e-02f, -4.96149100e-02f, 9.03979093e-02f, 4.02709574e-01f, 2.51769871e-01f, 1.35197952e-01f, -4.26786244e-02f, -1.97990015e-02f,
  4.24031578e-02f, 2.20789537e-02f, -1.22592740e-01f, -4.63830903e-02f, -8.27049762e-02f, -1.20488867e-01f, 5.61506897e-02f, -1.45049365e-02f, 5.84455170e-02f, -2.34478693e-02f,
  -7.20712589e-04f, -1.57361165e-01f, 2.52192542e-02f, -1.84253231e-01f, -8.35614055e-02f, -5.14675006e-02f, -1.17905904e-02f, 2.92876810e-02f, -2.61670304e-03f, 3.14338431e-02f,
  -1.48095071e-01f, -8.91593620e-02f, 1.23126050e-02f, -6.48788363e-02f, 4.15731445e-02f, -7.59018213e-03f, 5.37147596e-02f, -2.75424384e-02f, 2.43516341e-02f, 3.40216458e-02f,
  1.40493298e-02f, 8.24009478e-02f, 1.03531554e-01f, 1.92317307e-01f, 5.24125919e-02f, 1.86095499e-02f, 1.10115096e-01f, -3.33479457e-02f, -2.12775432e-02f, 8.42802692e-03f,
  -2.60826442e-02f, 7.66430721e-02f, 3.52954343e-02f, -1.38157113e-02f, -4.65888977e-02f, 6.90221861e-02f, 1.99144185e-02f, 5.02972305e-02f, -3.39222737e-02f, 2.65248232e-02f,
  -1.15637863e-02f, -9.60753392e-03f, 2.28335839e-02f, -2.22403966e-02f, -5.66200279e-02f, 1.01760298e-01f, 1.32896460e-03f, 8.68769735e-02f, 2.62465235e-02f, -2.91102901e-02f,
  -6.79595619e-02f, -4.07218486e-02f, -2.64134053e-02f, -1.19841322e-02f, 5.17331213e-02f, -1.95912886e-02f, -4.51433100e-02f, -8.92112032e-03f, -5.87693900e-02f, 9.36986320e-03f,
  -1.17471993e-01f, -4.19507436e-02f, -3.08726802e-02f, -1.23882554e-02f, 3.77865210e-02f, -5.80059439e-02f, -4.64750528e-02f, -6.19138405e-02f, -1.11235708e-01f, -1.17139807e-02f,
  -2.31712926e-02f, 8.86130426e-03f, -2.69011769e-04f, 5.93221374e-02f, 1.75829399e-02f, 2.69870572e-02f, 3.44264358e-02f, -5.32436073e-02f, 1.57021470e-02f, -2.03567799e-02f,
  1.24956533e-01f, 8.34149867e-02f, 1.56852920e-02f, 2.00008005e-02f, -4.22461592e-02f, -1.06938787e-01f, 7.89136738e-02f, 8.07226822e-02f, 5.04148863e-02f, 1.56358510e-01f,
  3.77352417e-01f, 1.76368728e-01f, 1.22478999e-01f, 1.65504798e-01f, -3.92355099e-02f, -4.31554466e-02f, 2.00460851e-02f, 4.99201939e-02f, 8.36685300e-03f, 6.79655522e-02f,
  -8.25271681e-02f, -1.23341963e-01f, 5.63401356e-02f, 1.03567366e-03f, 2.75695007e-02f, 2.06881568e-01f, 2.71863848e-01f, 2.59475917e-01f, 4.70790528e-02f, 8.81638452e-02f,
  7.74952620e-02f, 7.87725523e-02f, 1.48116127e-01f, 1.59131691e-01f, 4.32218499e-02f, 1.35528976e-02f, -2.78042018e-04f, 1.59222052e-01f, 1.22336345e-02f, 2.38773257e-01f,
  -3.86990644e-02f, 1.36691451e-01f, -1.97445787e-02f, -6.68684319e-02f, -9.16475430e-02f, 2.63521019e-02f, 6.76483214e-02f, 9.29114874e-03f, -5.88712990e-02f, -5.81945432e-03f,
  -5.71539253e-02f, -8.39518607e-02f, 4.26698290e-02f, -7.89432749e-02f, -3.63716111e-03f, 8.76527466e-03f, 1.19106509e-02f, 9.07262564e-02f, 6.07034042e-02f, 4.87294868e-02f,
  -9.66704357e-03f, 5.71736358e-02f, 8.12197700e-02f, -1.08082466e-01f, -8.65656957e-02f, -1.14491973e-04f, -1.29980668e-01f, 4.39716270e-03f, -2.30129864e-02f, -2.95618493e-02f,
  5.84361516e-03f, 7.89074413e-03f, 1.97329447e-02f, -5.26956320e-02f, 1.77545915e-03f, -1.15596406e-01f, 9.35114995e-02f, -5.46220094e-02f, -1.99300563e-03f, -7.93470442e-03f,
  4.99587413e-03f, 4.69156094e-02f, 2.55010892e-02f, 2.87153125e-02f, 1.25484783e-02f, -1.18555147e-02f, 6.11915439e-02f, -6.31721392e-02f, 8.82751681e-03f, 2.05247756e-02f,
  -5.91304675e-02f, -2.05368325e-02f, -4.89706397e-02f, -8.91400948e-02f, -1.38447881e-02f, -2.13273130e-02f, 1.31951936e-03f, -5.02303839e-02f, 4.08419222e-02f, -1.14821922e-02f,
  -8.91365707e-02f, -8.45194682e-02f, 4.56336588e-02f, 8.61786008e-02f, 6.93303868e-02f, -3.28529924e-02f, -7.82791972e-02f, -4.45951819e-02f, -3.25236879e-02f, 3.00991833e-02f,
  -6.02248907e-02f, -3.52918692e-02f, 3.17617804e-02f, -8.99312720e-02f, 5.19213825e-02f, -4.71759625e-02f, -6.66406937e-03f, 3.56109217e-02f, -7.85941482e-02f, -8.23282972e-02f,
  -9.73380357e-02f, 4.69357986e-03f, 1.08908135e-02f, -4.23892867e-04f, -3.85102555e-02f, 6.74927607e-02f, -7.02323020e-02f, -6.66908920e-02f, -1.02120407e-01f, 2.64222827e-02f,
  -2.96101004e-01f, -2.38341719e-01f, -1.88819781e-01f, 7.74545148e-02f, 3.41777146e-01f, 1.20728098e-01f, 5.03008626e-02f, -1.07575007e-01f, 6.55307546e-02f, -9.34222862e-02f,
  1.88162193e-01f, 1.06859416e-01f, 1.18367754e-01f, 6.24619313e-02f, -2.02020019e-01f, -2.03510731e-01f, -1.69319794e-01f, -1.16554752e-01f, 7.19870767e-03f, 1.65239677e-01f,
  1.39323309e-01f, -5.15140109e-02f, -1.87045783e-01f, -8.42466280e-02f, -5.38319275e-02f, 5.59686050e-02f, -1.76709607e-01f, -3.59738953e-02f, 2.26389505e-02f, -2.98144482e-02f,
  1.52517762e-02f, -1.27475157e-01f, 4.65501621e-02f, 4.05189879e-02f, 9.61378589e-03f, -8.89092013e-02f, -3.61978374e-02f, -1.48194313e-01f, -1.98036921e-03f, -1.02704942e-01f,
  2.02862173e-02f, -1.52025279e-02f, 5.69738150e-02f, 3.42747420e-02f, -4.93358858e-02f, -9.44454819e-02f, -1.43317610e-01f, -1.56462848e-01f, -1.45307064e-01f, 4.64333035e-02f,
  1.95375726e-01f, 2.01845080e-01f, 1.21778846e-02f, -1.74533762e-02f, -1.02811895e-01f, 6.83048815e-02f, -7.05173910e-02f, -1.39697641e-02f, -1.67676389e-01f, -2.39206612e-01f,
  -3.20303515e-02f, -6.81006908e-02f, -4.42347780e-04f, -5.23185879e-02f, -4.32276577e-02f, 4.91801053e-02f, 2.96868347e-02f, 2.29630265e-02f, -2.85544395e-02f, -3.94180901e-02f,
  1.87195055e-02f, 2.58631390e-02f, 5.33905886e-02f, -8.73531476e-02f, 6.39087474e-03f, 1.60347647e-03f, 1.18787587e-02f, -3.39905359e-02f, -4.53479122e-03f, -4.06090915e-02f,
  5.18474914e-02f, -2.14417446e-02f, -1.98129751e-02f, -3.05848829e-02f, -2.97771227e-02f, -6.50038570e-02f, -3.40815410e-02f, -1.61940716e-02f, -9.37568098e-02f, 3.22033241e-02f,
  -1.29342705e-01f, 4.35456820e-02f, 5.37628122e-02f, -8.83116126e-02f, 9.53983888e-02f, -7.82950968e-02f, 6.86179399e-02f, 4.58178706e-02f, 3.51565555e-02f, -1.03872502e-02f,
  7.91294500e-02f, -6.78755268e-02f, -1.23042781e-02f, -8.37248936e-02f, 8.10201168e-02f, 3.73637229e-02f, 4.51438315e-02f, 2.45641600e-02f, 8.15045536e-02f, -8.02185480e-03f,
  3.25306468e-02f, 3.48340422e-02f, -3.03379670e-02f, 4.80706878e-02f, 9.06532332e-02f, 1.31926179e-01f, 3.43142897e-02f, -1.36050126e-02f, -2.40687300e-02f, -2.18754157e-01f
};

// L0_fan_Wp_bar (Shape: 104 x 120)
const int L0_fan_Wp_bar_rows = 104;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  1.43249795e-01f, 7.07060397e-02f, -1.83687918e-02f, -4.80223782e-02f, 2.31186152e-02f, -5.39669469e-02f, 9.25316885e-02f, -1.96946915e-02f, 1.18021511e-01f, 5.79644777e-02f,
  -1.59910508e-02f, 2.90569700e-02f, 9.16466489e-02f, 6.46661967e-02f, 5.93079813e-03f, 3.54502872e-02f, 2.74242088e-03f, -2.28400659e-02f, -2.23020948e-02f, -1.18530229e-01f,
  -8.36545303e-02f, -7.93534964e-02f, -6.48114979e-02f, -6.38933405e-02f, -4.25902978e-02f, 2.77569108e-02f, -5.30731864e-02f, -1.10016212e-01f, -6.25795871e-03f, -4.87998165e-02f,
  -1.74286172e-01f, -3.18754278e-02f, 2.04015374e-02f, 4.60426137e-02f, 3.56845893e-02f, 2.21073255e-02f, 5.75382970e-02f, 3.14370133e-02f, 2.72722379e-03f, 8.44210833e-02f,
  -1.16535783e-01f, -9.48323533e-02f, 6.59656152e-02f, 2.82203611e-02f, -6.81852410e-03f, 3.16282362e-02f, 2.23399550e-02f, -4.17061001e-02f, 2.95653641e-02f, -1.01760142e-01f,
  -7.08280457e-03f, -7.49611706e-02f, 2.33367924e-02f, 6.90591186e-02f, -7.36402394e-03f, 5.74608482e-02f, -1.06097870e-02f, -2.71229688e-02f, 4.82501946e-02f, 5.94300665e-02f,
  1.30658895e-01f, -6.64862394e-02f, -1.13779120e-01f, -3.14286016e-02f, -5.12412675e-02f, -8.33897591e-02f, -3.13321166e-02f, 3.21041830e-02f, 4.83182110e-02f, -3.24464440e-02f,
  -5.47463335e-02f, -2.93669011e-02f, 7.45148063e-02f, 1.99752003e-02f, -7.73427635e-02f, -8.54089111e-02f, 8.06258023e-02f, 8.53614211e-02f, -5.16676903e-02f, 8.48301128e-02f,
  -1.37822134e-02f, 3.20891924e-02f, 6.83745518e-02f, -1.64244287e-02f, 2.49677729e-02f, 5.07302992e-02f, 1.51663199e-02f, -4.45156312e-03f, 7.77480453e-02f, -1.32302046e-02f,
  7.18024671e-02f, 7.86167011e-02f, 7.74318948e-02f, -9.11847781e-03f, -4.00967337e-02f, -7.18557984e-02f, 6.26059398e-02f, -9.06379744e-02f, -5.67459092e-02f, -6.76721185e-02f,
  -1.05755113e-01f, -7.74481744e-02f, -7.25600347e-02f, -5.56359217e-02f, 3.44961882e-02f, 1.90165956e-02f, 1.04493946e-01f, 2.55255308e-03f, -6.03904342e-03f, -4.98305112e-02f,
  8.95263478e-02f, 3.02187745e-02f, 9.42417160e-02f, -3.11698131e-02f, -7.63121322e-02f, 5.33277094e-02f, 4.07391302e-02f, 5.86798340e-02f, -3.87739241e-02f, 6.81645051e-02f,
  1.01832405e-01f, 2.50314083e-02f, -2.09782913e-01f, -5.37366122e-02f, -2.96897497e-02f, 3.49832214e-02f, -1.17613107e-01f, -1.11029163e-01f, 3.73622514e-02f, 3.89294922e-02f,
  1.03172615e-01f, -1.20852664e-02f, 1.59536451e-02f, 1.48750143e-02f, -1.78973109e-01f, -1.45736590e-01f, -5.71906269e-02f, -1.32278562e-01f, -1.08549498e-01f, 1.06573634e-01f,
  7.34947324e-02f, 5.76043278e-02f, 2.82741175e-03f, -6.11949377e-02f, 7.39911944e-02f, 1.90243553e-02f, 3.22911958e-03f, 9.99319702e-02f, 1.38085753e-01f, 1.44410834e-01f,
  3.85001511e-03f, -7.88595602e-02f, -4.74825390e-02f, 8.22043270e-02f, 6.82968274e-02f, 5.96487662e-03f, -3.83700170e-02f, -3.07396129e-02f, 1.34738283e-02f, -1.00014679e-01f,
  4.25361060e-02f, -4.93119135e-02f, -8.54266137e-02f, 6.09031282e-02f, 1.63835958e-02f, 2.17763223e-02f, -3.23091559e-02f, -1.08701907e-01f, -1.41465008e-01f, 7.69883487e-03f,
  6.82515651e-02f, 1.08195409e-01f, -1.27603412e-01f, -3.00216693e-02f, -1.41485542e-01f, 1.95614602e-02f, -9.33599845e-02f, 2.91984826e-02f, -1.56980619e-01f, -2.75503397e-02f,
  7.75372759e-02f, 3.01731303e-02f, -9.58291907e-03f, -3.61926705e-02f, 5.21820858e-02f, 5.64505272e-02f, -3.59024331e-02f, 3.08656152e-02f, -2.68117506e-02f, -7.73944110e-02f,
  -3.45597789e-02f, -1.19770051e-03f, -4.74632531e-02f, 4.17337492e-02f, 3.87697692e-05f, -4.63507436e-02f, 1.00305855e-01f, -1.15351242e-04f, 3.59296910e-02f, 2.57204119e-02f,
  -7.02328533e-02f, 4.00238410e-02f, -8.33610147e-02f, -4.20840941e-02f, -6.72719032e-02f, -1.85388420e-02f, 5.02590381e-04f, 8.95665437e-02f, 1.21296132e-02f, -4.24516723e-02f,
  -1.70640387e-02f, -9.24310759e-02f, -1.32175395e-02f, -6.08020183e-03f, 1.36127183e-02f, 6.60588369e-02f, 7.47123808e-02f, -4.58404608e-03f, -5.23253456e-02f, 5.93417995e-02f,
  3.15549187e-02f, -5.72055541e-02f, -6.43202811e-02f, 2.46621389e-02f, 3.83102745e-02f, -9.64911133e-02f, 3.78923342e-02f, 2.33391169e-02f, -1.29753023e-01f, -1.23471906e-02f,
  6.28628805e-02f, -2.24382654e-02f, -8.37781355e-02f, -6.09094761e-02f, 3.79323065e-02f, 2.28191353e-02f, -7.92750269e-02f, 1.28672328e-02f, -6.26333132e-02f, -8.27939436e-03f,
  2.03960627e-01f, 1.25006258e-01f, 1.68435842e-01f, -7.43188486e-02f, 1.80319138e-02f, 8.35258737e-02f, 2.05257788e-01f, 1.05005652e-01f, 5.34806438e-02f, 2.18505431e-02f,
  1.25613630e-01f, 1.61495637e-02f, -8.55284631e-02f, 2.08485723e-02f, 2.25230530e-02f, -4.74495254e-02f, -2.73529980e-02f, -7.84675851e-02f, 5.38277179e-02f, 4.65311892e-02f,
  -5.26475348e-02f, 1.83462054e-02f, -1.97753161e-02f, 1.49492025e-02f, -4.46491167e-02f, -1.27493829e-01f, 1.03662990e-01f, 2.55552828e-02f, 1.11399554e-02f, -2.02445984e-02f,
  -3.56143937e-02f, 2.37391472e-01f, -1.11787237e-01f, -4.13105227e-02f, 3.91606726e-02f, 6.87690079e-02f, -2.22235471e-02f, -4.52233776e-02f, -9.06490088e-02f, -5.88645637e-02f,
  -7.55224517e-03f, -5.50911799e-02f, -4.57301065e-02f, 5.12253605e-02f, -1.42512787e-02f, 5.31869270e-02f, -4.71645072e-02f, 2.51455279e-03f, 9.12140589e-03f, 9.16492790e-02f,
  4.59039062e-02f, 8.55193064e-02f, 1.31557837e-01f, 9.64495167e-02f, 4.82842475e-02f, -1.41866608e-02f, 6.26671389e-02f, 4.45303395e-02f, 1.93767995e-02f, 5.75637296e-02f,
  -6.10214211e-02f, 6.84407577e-02f, 1.33698126e-02f, 2.92121731e-02f, -1.58169866e-03f, -5.47272619e-03f, 7.74706015e-04f, 6.54178038e-02f, -6.28398210e-02f, -4.89533581e-02f,
  1.89760962e-04f, -4.26788218e-02f, -5.69309369e-02f, 2.18894053e-03f, -8.21137577e-02f, -3.62818018e-02f, 2.70008408e-02f, -1.79491155e-02f, 2.86727306e-02f, 1.24644674e-02f,
  1.36937182e-02f, 1.87045578e-02f, -3.36335972e-03f, -9.31974947e-02f, 5.87835535e-02f, -2.81557534e-02f, -8.41266140e-02f, 1.58268586e-02f, -4.79160734e-02f, 5.10929450e-02f,
  -1.54896572e-01f, 7.09295273e-02f, -9.40679610e-02f, 9.77033749e-03f, -1.01787075e-02f, -9.32590365e-02f, 3.69254388e-02f, 2.75809150e-02f, -2.44838744e-02f, 2.15024240e-02f,
  -2.80205831e-02f, 4.45482060e-02f, 4.48332131e-02f, 1.02975247e-02f, -3.85346375e-02f, -6.37996122e-02f, -1.75521057e-02f, 2.47639045e-02f, -2.92724520e-02f, -9.55693200e-02f,
  1.77446508e-03f, 4.37437184e-02f, -1.98954623e-02f, -4.65025101e-03f, -5.46318516e-02f, -4.37155925e-02f, -6.77331164e-02f, -1.21796608e-01f, -5.78140728e-02f, -5.16834334e-02f,
  -2.95827866e-01f, 1.67701207e-02f, -7.97746703e-02f, -1.84744149e-01f, -1.25518665e-01f, 4.67979116e-03f, 2.34586805e-01f, 2.93048304e-02f, -1.41769260e-01f, 9.34620425e-02f,
  -5.03586419e-03f, -1.31939307e-01f, -1.05706900e-01f, -2.13984568e-02f, 1.93826705e-02f, 1.38123423e-01f, 5.92745356e-02f, 3.13391425e-02f, -4.14456502e-02f, 3.34073231e-02f,
  3.25239114e-02f, -4.75677252e-02f, -1.74602866e-01f, -1.08645208e-01f, -1.59774616e-01f, -6.46373555e-02f, -1.22732900e-01f, -8.43250453e-02f, 2.18670499e-02f, -1.06414616e-01f,
  5.93196154e-02f, -8.28036889e-02f, -8.33660131e-04f, 1.61719080e-02f, -1.15973361e-01f, 7.10255206e-02f, 2.72067469e-02f, -1.46153763e-01f, -6.18378446e-02f, 2.64282767e-02f,
  -3.97082195e-02f, 2.92358771e-02f, -7.59375989e-02f, 1.46078654e-02f, 4.83023487e-02f, 6.29158923e-03f, 1.75931200e-03f, -5.72443306e-02f, 2.24703290e-02f, 5.44539653e-03f,
  -3.21232527e-02f, 6.42504469e-02f, -7.60122016e-02f, -2.23064236e-03f, -8.66428092e-02f, -6.43664971e-02f, 3.16830724e-02f, -5.82003072e-02f, -6.12532441e-03f, 7.64077976e-02f,
  1.00318514e-01f, 9.58373100e-02f, -6.32670671e-02f, -1.30214645e-02f, 6.34125322e-02f, 2.98089813e-03f, -9.38945934e-02f, 4.45446335e-02f, -4.08621505e-02f, -3.14559750e-02f,
  6.20804690e-02f, 3.74117342e-04f, 6.03198893e-02f, -1.17339775e-01f, 2.39514168e-02f, -1.50058046e-02f, 5.00572324e-02f, 3.37728932e-02f, 1.29369684e-02f, 6.76293150e-02f,
  2.55255979e-02f, -6.25314843e-03f, -3.49144749e-02f, -4.82351221e-02f, 8.44121203e-02f, 1.22107752e-02f, -5.78230284e-02f, -4.44027372e-02f, -6.89842328e-02f, -1.72544215e-02f,
  -9.52360593e-03f, 3.43679152e-02f, -5.31043969e-02f, 2.80461404e-02f, 5.26675140e-04f, -8.65627155e-02f, -7.82890096e-02f, 3.80176120e-02f, 7.60256359e-03f, -4.60352302e-02f,
  7.49733150e-02f, -6.85739741e-02f, -3.06510516e-02f, 5.08383326e-02f, -6.14284128e-02f, -6.56742323e-03f, 3.90334800e-02f, -2.61543822e-02f, 8.81690085e-02f, 2.10230108e-02f,
  -1.54459709e-02f, -1.67141855e-02f, 2.83712000e-02f, 5.32777384e-02f, 8.54491070e-02f, 6.71063662e-02f, 1.07481539e-01f, -3.04617323e-02f, -9.76799987e-03f, 1.70494154e-01f,
  6.65143505e-02f, 2.96457913e-02f, 1.00741029e-01f, -1.06624171e-01f, -3.89381684e-02f, 9.07157511e-02f, -3.45659219e-02f, 3.90211903e-02f, 6.91289380e-02f, -4.45951261e-02f,
  -1.07413277e-01f, 3.81223075e-02f, -7.04753250e-02f, -9.24867392e-03f, 6.90108212e-03f, -4.36454313e-03f, -7.03403552e-04f, 7.16730654e-02f, 4.91639823e-02f, 3.16610374e-02f,
  -7.43046552e-02f, -7.52632320e-02f, 6.94398284e-02f, -2.44209636e-02f, -4.54981774e-02f, -8.20994303e-02f, -4.86028604e-02f, 3.41820791e-02f, 4.36450094e-02f, 5.25252707e-02f,
  3.04549700e-03f, 5.09002730e-02f, -2.66209021e-02f, -8.23783726e-02f, -2.37890184e-02f, 5.48349656e-02f, -8.16886351e-02f, -3.15785222e-02f, -6.76420256e-02f, -3.14414054e-02f,
  -9.68029723e-02f, 5.13082556e-02f, 1.26221199e-02f, -5.51293120e-02f, -3.90707515e-02f, 9.78512689e-03f, 1.08564543e-02f, -5.24262823e-02f, 7.48357177e-02f, -9.97897387e-02f,
  3.36939394e-02f, -8.77360161e-03f, -7.07842186e-02f, 5.61734699e-02f, 3.28163356e-02f, 2.38656206e-03f, -9.99269262e-02f, -2.24017873e-02f, 4.07795198e-02f, -1.15202880e-02f,
  -4.39482182e-03f, -3.67815346e-02f, 4.21502925e-02f, 2.53443252e-02f, -6.74874187e-02f, 6.61323890e-02f, 1.15070917e-01f, -8.35125446e-02f, -2.45605651e-02f, 4.12223004e-02f,
  -1.34105692e-02f, -4.54241782e-03f, 4.09268886e-02f, -6.64056540e-02f, -8.69646519e-02f, 3.67816538e-02f, 7.26345256e-02f, -3.89639959e-02f, 5.53089641e-02f, -4.08563390e-02f,
  -8.49828124e-02f, -8.83734375e-02f, -7.80066922e-02f, 3.81651940e-03f, -5.46079464e-02f, -5.49597777e-02f, 6.35140985e-02f, -3.55754346e-02f, -1.32708810e-02f, -9.38055143e-02f,
  4.31514904e-02f, -8.58753696e-02f, 5.84055372e-02f, -6.80722371e-02f, 5.09433076e-02f, -9.25125629e-02f, 2.69135218e-02f, -3.16230245e-02f, -6.49026260e-02f, 7.26222023e-02f,
  -5.63183893e-03f, 3.76804508e-02f, -4.35458869e-02f, -9.57183465e-02f, 6.35769442e-02f, 8.70496184e-02f, 8.60271901e-02f, 4.46029380e-02f, 6.42313063e-02f, 1.06850434e-02f,
  7.98054039e-03f, 6.54970035e-02f, 7.17415363e-02f, 8.48475937e-03f, -8.50944221e-02f, -6.25891760e-02f, 7.12140501e-02f, 8.91986415e-02f, 6.86293021e-02f, -3.93260382e-02f,
  2.08887875e-01f, 1.45745009e-01f, 1.07068263e-01f, -2.58795973e-02f, 1.84892192e-02f, 3.99629632e-03f, 1.12647131e-01f, 4.71283272e-02f, 3.09289731e-02f, -4.33967216e-03f,
  -9.78718419e-03f, -1.67250587e-03f, -9.18317661e-02f, -7.45158270e-02f, 3.06554213e-02f, 7.03016594e-02f, 1.12179182e-02f, 6.63468093e-02f, 4.23153862e-02f, 3.30074057e-02f,
  -5.75289838e-02f, -3.09357159e-02f, 1.51343063e-01f, 8.65540504e-02f, -1.19297616e-01f, -2.93438919e-02f, -1.99897885e-02f, 6.64471909e-02f, -4.51293141e-02f, -2.79268753e-02f,
  -3.22738066e-02f, 1.66355222e-01f, -6.05119467e-02f, 6.36424795e-02f, 4.56420183e-02f, 6.89804703e-02f, -5.55619001e-02f, -1.87174173e-03f, -3.09595577e-02f, -6.98576123e-02f,
  -4.80823182e-02f, -9.37929302e-02f, 3.18466127e-02f, -1.87880024e-02f, 2.02906914e-02f, 5.96003607e-02f, 5.19328304e-02f, 9.17581245e-02f, 3.28439497e-03f, -5.35853431e-02f,
  -2.23066378e-02f, -5.69980219e-02f, 5.91968037e-02f, 2.94130687e-02f, -7.26160482e-02f, -8.38219970e-02f, -5.45158759e-02f, 3.70947868e-02f, 6.11446388e-02f, 6.16471618e-02f,
  -4.94075976e-02f, -1.28697800e-02f, 1.09797530e-02f, -3.84767242e-02f, 6.23414777e-02f, -5.48332334e-02f, -1.01064794e-01f, 5.71410656e-02f, 7.70042762e-02f, 9.02449861e-02f,
  6.36613071e-02f, 5.69988713e-02f, 8.32780823e-02f, 1.00404359e-01f, -9.47373882e-02f, -4.65865694e-02f, -2.39224974e-02f, -7.80398259e-03f, -5.31118363e-02f, -7.44493380e-02f,
  1.37043390e-02f, 4.24049273e-02f, 4.86246683e-02f, 8.86253491e-02f, 5.46903675e-03f, 5.96126951e-02f, 3.28899175e-02f, 6.78843558e-02f, 6.28547072e-02f, 1.11256815e-01f,
  -1.26405761e-01f, 7.19161406e-02f, -8.21905434e-02f, -7.82695040e-03f, 5.02515212e-03f, 4.74916864e-03f, 6.10064156e-02f, 6.86264485e-02f, 3.43524404e-02f, 7.25548565e-02f,
  -8.29759315e-02f, -3.05432780e-03f, 7.38476142e-02f, -6.56116381e-02f, -2.60247029e-02f, -7.35560730e-02f, 5.12549803e-02f, 6.55405596e-03f, -9.46108997e-02f, -7.03098923e-02f,
  3.16714570e-02f, 7.50227571e-02f, -7.75090158e-02f, 2.38895658e-02f, -1.14413969e-01f, -1.65062603e-02f, 2.64449771e-02f, 4.36863005e-02f, -9.36161876e-02f, 3.38683426e-02f,
  3.17837000e-01f, -5.81365786e-02f, -4.77415413e-01f, 1.02744348e-01f, -1.59508422e-01f, -2.24232852e-01f, -3.46799716e-02f, 5.79230078e-02f, 3.42418440e-02f, 7.36949891e-02f,
  -1.20973527e-01f, -4.99085709e-03f, -7.36085027e-02f, -2.86985300e-02f, -9.14086625e-02f, -1.74111083e-01f, -1.21091031e-01f, -6.57294318e-02f, -1.50849223e-01f, 4.67077345e-02f,
  2.19892245e-02f, 4.94133681e-02f, 7.43516982e-02f, 1.02481291e-01f, -5.30754626e-02f, -1.16114177e-01f, -7.87049308e-02f, -1.02601022e-01f, -6.40429705e-02f, -2.01659203e-01f,
  -3.87459189e-01f, -1.27378002e-01f, -5.48826903e-02f, 7.57989585e-02f, -1.10001080e-01f, -3.88276540e-02f, 1.89645551e-02f, -1.85835268e-02f, -2.03416105e-02f, -3.56160998e-02f,
  -9.75626346e-04f, -4.06768844e-02f, -2.04852466e-02f, 5.16687892e-03f, -6.16019033e-02f, -3.65825072e-02f, 5.79409860e-02f, -5.44412062e-02f, -1.27643928e-01f, -7.72083998e-02f,
  -2.95473803e-02f, 5.08100213e-03f, -8.27664975e-03f, -3.58665474e-02f, -8.49501342e-02f, 1.29820053e-02f, -5.65792695e-02f, -1.58488154e-01f, -9.16852057e-02f, 2.58913357e-02f,
  8.11592117e-03f, -8.71414915e-02f, -3.02992500e-02f, 6.83020726e-02f, 8.73684138e-02f, -7.43834535e-03f, -9.72517021e-03f, -5.15289372e-03f, 3.09644863e-02f, -3.23884673e-02f,
  5.37300594e-02f, 3.34220827e-02f, 6.30602762e-02f, 3.76241617e-02f, -3.65639701e-02f, -3.64059545e-02f, -2.67093889e-02f, 9.01882052e-02f, 2.52740122e-02f, 1.92471072e-02f,
  -4.27913070e-02f, -8.03933218e-02f, 5.79823256e-02f, -5.09405322e-02f, -2.08623079e-03f, 2.00132821e-02f, 2.34291283e-03f, 2.69833277e-03f, 2.59051961e-03f, -7.64461905e-02f,
  2.25553200e-01f, -9.11164135e-02f, 6.06071390e-02f, 1.07041873e-01f, -3.23491320e-02f, 5.99791557e-02f, -2.38958863e-03f, 7.53256902e-02f, 2.32621785e-02f, 4.50032093e-02f,
  -9.77655202e-02f, 1.23386104e-02f, 1.93982460e-02f, 4.51664580e-03f, 2.16424819e-02f, 4.16956805e-02f, 1.05881065e-01f, 4.78364863e-02f, -4.14740248e-03f, 3.44810747e-02f,
  3.12638916e-02f, 9.27717164e-02f, 1.91550404e-01f, -1.52553795e-02f, -6.88042790e-02f, 7.24947974e-02f, -7.80824423e-02f, -1.58528127e-02f, -3.73330712e-02f, 3.08087051e-01f,
  -2.58824136e-02f, 5.77067323e-02f, -4.87810560e-02f, 1.12125920e-02f, 3.62153612e-02f, 1.80803072e-02f, -6.96419626e-02f, -1.79551281e-02f, -6.27378002e-02f, -1.25049744e-02f,
  -3.10213189e-03f, 8.85978490e-02f, 4.86622900e-02f, -6.80082366e-02f, -4.28661928e-02f, -7.83357711e-04f, 4.20137495e-02f, 7.30314180e-02f, 3.88707668e-02f, -8.50767791e-02f,
  5.47285983e-03f, -6.24895953e-02f, 2.63556489e-03f, 3.66960727e-02f, -1.62948593e-02f, -2.05542035e-02f, 8.26757103e-02f, 8.14718846e-03f, -7.75195882e-02f, -3.34151722e-02f,
  1.43393382e-01f, -1.47527769e-01f, 2.71918885e-02f, 3.86027084e-03f, 5.16195633e-02f, -5.57127707e-02f, -4.69594188e-02f, 4.59148213e-02f, -8.80956352e-02f, -6.72247484e-02f,
  2.96378322e-02f, 5.58016188e-02f, -1.93954632e-02f, -2.66615003e-02f, -7.46064354e-03f, -1.40535738e-02f, 3.26107182e-02f, -9.54199061e-02f, 5.37887141e-02f, 6.00723922e-02f,
  -1.11945681e-02f, -1.27161504e-03f, -1.10155910e-01f, -1.61153730e-02f, -1.03355654e-01f, -4.64295857e-02f, 6.41879961e-02f, -3.94950360e-02f, 2.22104006e-02f, -3.52062359e-02f,
  3.33229415e-02f, 6.94441423e-02f, -9.16654170e-02f, -5.99605292e-02f, 1.61039010e-02f, 2.20554471e-02f, -4.09770049e-02f, 3.45974751e-02f, 1.68991834e-02f, -4.33124304e-02f,
  5.40279001e-02f, 6.92497566e-02f, 7.08681270e-02f, -2.74588987e-02f, -8.02452564e-02f, -5.88768721e-02f, 3.44559699e-02f, 3.82506736e-02f, 7.26755261e-02f, -1.16265109e-02f,
  5.61696887e-02f, 1.02868015e-02f, -4.57844995e-02f, -4.02492424e-03f, -5.49660847e-02f, -5.82570098e-02f, -3.51913944e-02f, -2.32974347e-03f, 1.09939640e-02f, -1.56394194e-03f,
  1.99356362e-01f, 6.13930728e-03f, -3.93207148e-02f, -7.43182153e-02f, 2.69510737e-03f, -4.83413041e-02f, 9.66395289e-02f, -3.67711671e-02f, 1.57143306e-02f, 1.49324592e-02f,
  -1.03731222e-01f, 5.26429750e-02f, 7.00664194e-03f, -1.51219312e-02f, -5.58747202e-02f, 4.92499955e-02f, 5.15323393e-02f, 3.09071988e-02f, 4.81934547e-02f, -2.03676298e-02f,
  -7.41832256e-02f, -7.43519096e-03f, -1.34181802e-03f, -4.45733555e-02f, 3.19709964e-02f, 1.05591998e-01f, 1.21484168e-01f, -2.36123428e-02f, -2.22680159e-02f, 1.03733480e-01f,
  8.69188309e-02f, 2.25257829e-01f, 2.73703821e-02f, 1.15770668e-01f, 1.05054840e-01f, 7.11515546e-02f, 1.61135480e-01f, 1.62832439e-01f, 1.28554419e-01f, 9.44385827e-02f,
  1.22844718e-01f, 5.60115017e-02f, 9.94847044e-02f, 1.10948049e-01f, 1.56291068e-01f, 7.20432699e-02f, 1.16171047e-01f, 1.00921607e-02f, 5.62988147e-02f, -4.87678498e-02f,
  -2.82506868e-02f, -3.12326681e-02f, -5.37373945e-02f, 4.86012362e-02f, 9.66908932e-02f, 3.31130736e-02f, 6.66611129e-03f, 8.96304101e-02f, -3.21502015e-02f, -4.26034518e-02f,
  -8.98763835e-02f, 1.41847879e-01f, -1.24566860e-01f, -8.43853429e-02f, -5.74083216e-02f, 3.77029106e-02f, 7.08256289e-02f, 1.09730950e-02f, 8.38904604e-02f, 5.82611896e-02f,
  -3.81329320e-02f, -3.91680971e-02f, -8.10841992e-02f, -2.81718653e-03f, -8.98599401e-02f, 5.82463443e-02f, 5.03999852e-02f, 9.06611681e-02f, 1.19312279e-01f, 4.04128432e-02f,
  -5.08477315e-02f, 6.78604320e-02f, -3.26773003e-02f, 8.51340294e-02f, -2.47106850e-02f, -6.75155036e-03f, 3.07443179e-02f, 6.48057982e-02f, -9.53039899e-03f, 8.96004587e-02f,
  3.49753127e-02f, -5.65108396e-02f, -2.26507410e-02f, -1.12652695e-02f, 1.21234190e-02f, 5.07068783e-02f, 1.18350526e-02f, -3.19276452e-02f, 6.58052415e-02f, -2.34126467e-02f,
  -5.55745699e-02f, 4.17324761e-03f, 5.94066344e-02f, 2.99564772e-03f, -3.53264660e-02f, -4.94491942e-02f, -6.73096254e-02f, 7.51174539e-02f, -2.01740041e-02f, 2.83330567e-02f,
  3.23453313e-03f, -4.21717651e-02f, -5.38808331e-02f, -1.28121786e-02f, -5.02842106e-02f, 3.88734750e-02f, -4.44575064e-02f, 8.25669393e-02f, 5.46522848e-02f, -4.04207930e-02f,
  -7.77709112e-02f, -5.65835759e-02f, -6.77724034e-02f, -5.74766956e-02f, -6.59431964e-02f, 3.57140638e-02f, -1.98962744e-02f, -9.68261957e-02f, 8.03630054e-03f, -6.96376264e-02f,
  -4.34192037e-03f, -4.60377745e-02f, 7.77552277e-02f, 6.31179735e-02f, -1.03283545e-03f, 4.08296622e-02f, 7.09942915e-03f, -7.10693523e-02f, -5.41073680e-02f, -6.72698393e-02f,
  2.12324560e-02f, 6.41233176e-02f, -6.17745966e-02f, -8.56114626e-02f, 7.20559955e-02f, -8.01013261e-02f, 3.52022015e-02f, -1.33083418e-01f, -1.83261689e-02f, -6.59190565e-02f,
  2.52492458e-01f, 1.20997116e-01f, 3.25349979e-02f, 1.47028510e-02f, 2.89808698e-02f, -1.23529099e-01f, -6.89102262e-02f, -3.61384787e-02f, -1.12108715e-01f, 2.09525712e-02f,
  2.45778239e-03f, -8.63559395e-02f, 5.09078912e-02f, 2.72576977e-02f, -7.52036721e-02f, -5.80569357e-02f, 1.83555931e-02f, 4.30547260e-02f, -2.05181409e-02f, 3.57389264e-02f,
  1.75191043e-03f, 1.24998078e-01f, 9.58661214e-02f, 6.62385821e-02f, 1.12975165e-01f, -2.76834201e-02f, 1.07382782e-01f, 8.88190195e-02f, 5.54978326e-02f, 1.58494145e-01f,
  7.08599761e-03f, 1.94206778e-02f, -1.92910563e-02f, -4.89163958e-02f, 9.75737534e-03f, 2.10787468e-02f, -8.12371075e-02f, -4.59936401e-03f, 4.31912504e-02f, -7.55064040e-02f,
  -7.15209246e-02f, 3.43657993e-02f, -8.78636613e-02f, -8.37290585e-02f, 3.72694694e-02f, -5.19707352e-02f, -5.25613874e-02f, -5.31741604e-02f, -6.09447584e-02f, 7.00305253e-02f,
  -6.20021224e-02f, -2.99536623e-02f, 4.10213098e-02f, -1.07122578e-01f, -3.70977214e-03f, 2.89384574e-02f, 3.90374251e-02f, 1.41845364e-02f, -8.29360783e-02f, -4.42227088e-02f,
  6.78628907e-02f, -2.96190903e-02f, -8.39832202e-02f, -2.09700852e-03f, -1.03714596e-02f, 2.32630521e-02f, 5.16570359e-03f, 1.56221529e-02f, 8.87185428e-03f, -7.34840631e-02f,
  -9.50062349e-02f, 3.36897112e-02f, -4.95326519e-02f, -8.13047141e-02f, -9.77397040e-02f, 8.10090974e-02f, 9.99006703e-02f, -3.43596786e-02f, -8.53722841e-02f, 4.07683775e-02f,
  2.50618812e-02f, -5.69187179e-02f, 7.92510882e-02f, 6.40870556e-02f, 1.21576348e-04f, -6.67819008e-02f, 8.82503092e-02f, -3.05500384e-02f, 7.85871595e-02f, 2.35396940e-02f,
  -4.16566469e-02f, -1.96807623e-01f, -1.40175922e-03f, 5.91501929e-02f, 6.46716803e-02f, -9.56469476e-02f, -8.68749171e-02f, -2.37606317e-02f, -1.38650397e-02f, 5.78362681e-02f,
  -2.85861101e-02f, -1.20146945e-02f, -1.99078117e-02f, -1.23921335e-02f, -3.82116586e-02f, -1.24156233e-02f, 8.09028596e-02f, -5.67836277e-02f, -4.86050844e-02f, 3.83399390e-02f,
  2.64433790e-02f, -1.00717135e-01f, -5.53134903e-02f, -9.18766558e-02f, 4.96734269e-02f, -1.08165547e-01f, -6.58794865e-02f, -6.53449893e-02f, -3.87736559e-02f, 3.78057659e-02f,
  8.66000578e-02f, -1.57762423e-01f, 6.41951188e-02f, 5.03588915e-02f, 3.44091468e-02f, 1.12013988e-01f, -6.64030388e-02f, -4.24892977e-02f, 1.66717581e-02f, -5.65851666e-02f,
  -2.14066729e-02f, 1.45180337e-02f, -3.98307964e-02f, 2.24330425e-02f, 7.18331560e-02f, -7.83374254e-03f, 1.11736536e-01f, 1.32060796e-01f, 5.46107069e-02f, 8.30689166e-03f,
  -1.50329312e-02f, -5.86761795e-02f, 1.15856498e-01f, 5.10334298e-02f, -4.69516739e-02f, 2.47733034e-02f, -4.20756750e-02f, -4.44762670e-02f, -9.12845358e-02f, -6.35514557e-02f,
  -1.31299183e-01f, 3.93076017e-02f, 1.12862676e-01f, -7.68681467e-02f, -5.06074317e-02f, -4.12671939e-02f, -6.08858243e-02f, 1.24298194e-02f, -9.25144553e-02f, -6.29905798e-03f,
  -7.04622120e-02f, -1.03189819e-01f, -1.68529395e-02f, -4.89824228e-02f, -3.55173722e-02f, 1.36209615e-02f, -1.71543881e-02f, -2.19399892e-02f, 8.59439820e-02f, -2.75870748e-02f,
  -5.32488748e-02f, -4.43024524e-02f, 6.46714941e-02f, 7.90689960e-02f, -6.70964345e-02f, 3.43131237e-02f, -1.55954668e-02f, -9.90831032e-02f, 4.48913164e-02f, -2.25379467e-02f,
  -5.56062944e-02f, -2.57959105e-02f, -2.05796156e-02f, -2.39752717e-02f, -5.69467992e-02f, 5.88987954e-03f, 7.30380639e-02f, 1.32409288e-02f, -6.55065179e-02f, -6.25682846e-02f,
  -3.01678088e-02f, -1.09487055e-02f, 2.33216453e-02f, -6.81470409e-02f, -3.67976353e-02f, -1.37256598e-02f, 2.55606137e-02f, -1.03345163e-01f, 5.55930054e-03f, 5.74696437e-02f,
  6.10382780e-02f, 3.55584063e-02f, 5.87174371e-02f, 3.43843885e-02f, 1.18777379e-02f, 8.53776485e-02f, 8.44585001e-02f, -7.87480474e-02f, -2.23653223e-02f, 5.79988472e-02f,
  -1.40429750e-01f, 9.07857493e-02f, -2.22712196e-02f, 3.49317193e-02f, -6.52882457e-02f, 1.96126867e-02f, 2.88883671e-02f, -1.16408886e-02f, -3.55552137e-02f, -5.06273843e-02f,
  -4.65238141e-03f, 7.49116614e-02f, 5.43789603e-02f, 4.79167998e-02f, -4.43314165e-02f, -6.37776330e-02f, -2.56820414e-02f, 8.12203363e-02f, -2.02305596e-02f, -3.14247385e-02f,
  2.30315384e-02f, 1.38153300e-01f, 9.45327207e-02f, -3.01864929e-02f, 8.57846141e-02f, 1.86148286e-01f, -2.36145202e-02f, 7.05690160e-02f, 8.09804797e-02f, 9.69431326e-02f,
  2.27790728e-01f, 8.21194202e-02f, -2.51117408e-01f, 5.72296046e-02f, -1.19654931e-01f, -2.25044653e-01f, -2.74332643e-01f, -6.47715256e-02f, 1.05561137e-01f, 1.53108137e-02f,
  -3.51071768e-02f, 6.89289197e-02f, 8.95556808e-03f, -1.63194150e-01f, -2.36916736e-01f, -9.08422619e-02f, -2.19723076e-01f, -2.84562409e-01f, -2.81867474e-01f, -2.76350766e-01f,
  -1.29319206e-01f, 3.42122801e-02f, 1.69205235e-03f, -1.26894549e-01f, 1.07935697e-01f, 3.05872504e-03f, 1.66635588e-02f, -8.11700802e-03f, -1.90220326e-01f, -5.88543117e-02f,
  1.79053396e-02f, -4.07648273e-02f, -3.91483642e-02f, 2.87518762e-02f, 6.10075817e-02f, 1.04028508e-02f, -8.27684775e-02f, 7.52190202e-02f, 1.19527273e-01f, -3.98369990e-02f,
  -2.92789508e-02f, -1.09456303e-02f, 3.70318033e-02f, -2.78453231e-02f, 1.99709795e-02f, 2.48966366e-02f, 8.42105970e-03f, 1.53782777e-02f, 1.13356058e-02f, 4.25332747e-02f,
  3.76827009e-02f, -7.59199560e-02f, 4.49748933e-02f, 1.55355083e-02f, -4.96695377e-02f, -1.59778986e-02f, -5.79254590e-02f, 9.11893025e-02f, -7.12429807e-02f, 1.65423974e-01f,
  3.27167809e-02f, 1.19123489e-01f, 1.22765712e-02f, -4.53606434e-02f, 2.07889285e-02f, -6.54927315e-03f, 9.04200971e-02f, 5.71397282e-02f, -6.02146760e-02f, -2.39367466e-02f,
  -6.15478493e-03f, 3.69141512e-02f, 1.29563804e-03f, -1.90342255e-02f, -9.20466240e-03f, 5.02600148e-02f, -3.96501943e-02f, 5.61740622e-02f, -3.17098573e-02f, 1.14651240e-01f,
  -5.85486144e-02f, 3.71650010e-02f, 1.03724226e-01f, 3.77640091e-02f, -5.36873154e-02f, -4.08242308e-02f, -5.29360995e-02f, -1.08078711e-01f, 2.15354487e-02f, 5.17245345e-02f,
  1.80965066e-01f, -1.46942943e-01f, 7.10151270e-02f, 3.16500023e-04f, 7.83552695e-03f, 1.28807202e-01f, 8.95136967e-03f, -2.22708117e-02f, -1.22598177e-02f, 5.66404723e-02f,
  -5.92757715e-03f, -1.98420770e-02f, 2.22427845e-02f, 2.13679858e-02f, -5.74845523e-02f, 2.81911623e-02f, -5.20590460e-03f, -2.82587633e-02f, -3.19198444e-02f, 2.87074521e-02f,
  2.10021902e-02f, 6.62270561e-02f, 8.00716802e-02f, 1.15968384e-01f, 1.05877849e-03f, -7.76804537e-02f, -4.51343209e-02f, -7.75947096e-03f, 1.84350759e-02f, 1.60591900e-01f,
  -5.24998605e-02f, -1.93298787e-01f, -2.74760038e-01f, -1.18178435e-01f, 3.55331190e-02f, 8.66024047e-02f, 1.18712403e-01f, 9.18119028e-02f, -4.24713716e-02f, -1.57557845e-01f,
  -9.96450111e-02f, -1.74332745e-02f, -1.00548312e-01f, -2.30970383e-02f, 9.91189107e-02f, -8.20324644e-02f, -1.77064732e-01f, -1.11013502e-01f, 1.34612113e-01f, 2.30603501e-01f,
  1.31558061e-01f, -5.97343333e-02f, -4.82168805e-04f, 5.56851067e-02f, -8.68123472e-02f, -1.22871108e-01f, -8.22616965e-02f, -6.52274862e-02f, -1.05551705e-01f, -2.15044215e-01f,
  -1.43921420e-01f, -8.75928253e-02f, 1.10385716e-01f, 4.39655632e-02f, -1.45023093e-01f, -1.60333444e-03f, -1.16534550e-02f, -1.23991728e-01f, -3.79759707e-02f, -1.06996402e-01f,
  -2.15820521e-02f, 7.08921999e-02f, 3.06067709e-02f, 3.29547450e-02f, 1.05769157e-01f, 7.79939368e-02f, -7.17438832e-02f, -8.70416537e-02f, -4.03125584e-03f, -3.42768095e-02f,
  -5.05131844e-04f, -2.73681395e-02f, -5.39728403e-02f, 7.22941235e-02f, -1.87355827e-03f, -1.07298806e-01f, 3.11026722e-02f, 1.00582726e-01f, 5.93132451e-02f, -5.65532874e-03f,
  1.85047816e-02f, -4.51659225e-02f, 3.49664204e-02f, -5.98098198e-03f, 7.63712451e-02f, -1.03839852e-01f, -2.40203440e-02f, 6.23667724e-02f, 2.17256434e-02f, 4.81687337e-02f,
  -9.38244443e-03f, -3.32872458e-02f, 2.59261187e-02f, -1.72201153e-02f, -3.89000252e-02f, -8.63966495e-02f, -5.72092272e-02f, -2.51129847e-02f, 5.78018464e-02f, -6.10690899e-02f,
  3.93094160e-02f, 4.90650646e-02f, -1.63765568e-02f, 5.80628067e-02f, 4.69842590e-02f, 1.89285353e-02f, 2.68056933e-02f, 9.23558399e-02f, 2.25284155e-02f, 7.69090001e-03f,
  -5.46705686e-02f, 7.94827379e-03f, -4.99977060e-02f, 2.33111903e-02f, 2.56672502e-03f, 2.21352112e-02f, -6.70214519e-02f, 4.85588573e-02f, -7.56745934e-02f, 4.16142046e-02f,
  2.98238844e-02f, 5.26657440e-02f, 4.65146974e-02f, -3.62413675e-02f, 2.76986882e-02f, -2.79521067e-02f, -4.03718501e-02f, -7.39657283e-02f, -2.47590188e-02f, 3.06504425e-02f,
  -4.78543788e-02f, 2.69219512e-03f, -4.70052063e-02f, -2.50313133e-02f, -5.40423170e-02f, 6.92768442e-03f, -4.41609602e-03f, 1.32158967e-02f, -1.87855698e-02f, 2.54857335e-02f,
  -1.46599039e-01f, 2.58026328e-02f, -4.86391829e-03f, -1.91354483e-01f, 2.53454521e-02f, 1.23072565e-02f, 9.51554254e-02f, -3.53721646e-03f, -7.82716870e-02f, -4.63412702e-02f,
  6.86045662e-02f, 8.83611105e-03f, 6.46020249e-02f, -8.35581869e-02f, 8.76338333e-02f, 1.64166000e-02f, 1.02811851e-01f, -8.89811143e-02f, 1.26853185e-02f, -2.02460997e-02f,
  -7.49314502e-02f, -1.15169324e-01f, -8.99610370e-02f, 1.67933386e-02f, -1.43975824e-01f, -9.17289034e-02f, -3.30495872e-02f, 3.14489682e-03f, -3.29255164e-02f, -1.05155975e-01f,
  1.46774039e-01f, -1.68076456e-01f, 1.92615334e-02f, -3.98518033e-02f, 1.93589069e-02f, -2.67387237e-02f, -5.24782948e-02f, -6.76662400e-02f, 4.46974207e-03f, -2.07943413e-02f,
  -1.05967492e-01f, 5.59366792e-02f, -1.23001352e-01f, 7.10038021e-02f, -7.91674480e-02f, -2.28780843e-02f, -7.45100807e-03f, -9.74080637e-02f, 1.32973194e-02f, -2.55311094e-02f,
  4.08411585e-02f, -5.59138320e-02f, -5.57393581e-03f, 7.41843786e-03f, 2.79134605e-02f, -5.22524156e-02f, 4.79337089e-02f, -3.36671658e-02f, -1.62316412e-02f, 5.78368492e-02f,
  9.09484550e-02f, -8.85416120e-02f, -4.74289395e-02f, -6.30559400e-02f, 6.02322817e-02f, 6.55619442e-05f, -2.81153992e-02f, 1.14246970e-02f, -2.16462556e-02f, 4.76091132e-02f,
  -9.63776372e-03f, -6.41281679e-02f, -3.93802896e-02f, 7.08257481e-02f, 6.35740384e-02f, -1.04944028e-01f, -5.84120937e-02f, -8.63270182e-03f, 4.77966927e-02f, 1.22280968e-02f,
  -9.49797481e-02f, 5.60013391e-02f, 2.79403701e-02f, 1.68552361e-02f, -4.62122411e-02f, -3.97842266e-02f, 2.59856023e-02f, -6.45619258e-02f, -9.35889184e-02f, -7.12407529e-02f,
  3.02531645e-02f, -1.28435374e-06f, 1.13948330e-01f, 1.32038631e-02f, -5.98047711e-02f, 4.09407206e-02f, -4.54750881e-02f, -6.00540973e-02f, -9.06292722e-02f, -2.05422603e-02f,
  -5.94135113e-02f, 4.49085496e-02f, 6.24735700e-03f, 6.62767375e-03f, 7.99662620e-03f, -2.35837270e-02f, 3.72870564e-02f, 4.53556292e-02f, 4.09753360e-02f, -5.78328781e-02f,
  -3.45617570e-02f, 2.28286199e-02f, 1.70973822e-01f, 1.51877016e-01f, 1.06168569e-04f, 1.00305967e-01f, 1.48676485e-01f, 4.63169888e-02f, 1.32489339e-01f, 1.50916800e-01f,
  -1.04203910e-01f, 8.76413733e-02f, -1.62922293e-02f, -1.52852714e-01f, -3.10597047e-02f, 5.51502258e-02f, 1.76870361e-01f, -2.46541146e-02f, -8.21683481e-02f, 1.33967504e-01f,
  -3.03700361e-02f, -7.27052316e-02f, -1.63999274e-01f, -1.14933982e-01f, -5.67942150e-02f, 7.46871307e-02f, 4.35569510e-02f, -1.27005503e-01f, -9.34242085e-02f, -1.86486654e-02f,
  -2.00166143e-02f, -1.45379841e-01f, -8.11772943e-02f, -1.07695706e-01f, 2.91207936e-02f, -1.29208878e-01f, 8.54024142e-02f, 4.04105857e-02f, 7.80179054e-02f, 9.83966142e-03f,
  -1.17913005e-03f, -4.98983897e-02f, 4.97952327e-02f, -5.23427427e-02f, -8.14184919e-02f, -4.73534316e-02f, -3.54910418e-02f, -8.86960402e-02f, 3.67287695e-02f, 4.46770452e-02f,
  -8.34203213e-02f, 3.70081887e-02f, -7.20004663e-02f, -1.10103868e-01f, -8.02083220e-03f, -5.31812534e-02f, 2.01671827e-03f, -3.12558897e-02f, 3.60151939e-02f, -8.32365546e-03f,
  -2.63538714e-02f, -2.72687580e-02f, -3.96723188e-02f, -2.13000514e-02f, -8.83299857e-03f, -1.04316734e-01f, 1.58124547e-02f, -3.63658145e-02f, 4.50021625e-02f, 9.65902116e-03f,
  1.13765001e-01f, 3.18528973e-02f, -2.45816801e-02f, 3.15135578e-03f, 2.66456492e-02f, 4.04504351e-02f, -1.73702464e-02f, -7.15980828e-02f, -3.33401188e-02f, -4.80517372e-02f,
  -5.19538447e-02f, 9.83280968e-03f, 2.05558762e-02f, 4.61703315e-02f, -4.36546933e-03f, 1.42264804e-02f, -1.87273324e-02f, 2.31635030e-02f, -3.64469104e-02f, -6.99245408e-02f,
  8.46616253e-02f, -5.05960882e-02f, 1.28713660e-02f, -1.50604546e-03f, 7.76553527e-02f, 4.57733683e-02f, -4.43301722e-02f, -1.41140800e-02f, -1.11275040e-01f, -8.51709619e-02f,
  9.82825384e-02f, -8.04118589e-02f, -6.11589141e-02f, -8.02095234e-02f, 2.55572423e-03f, 3.29015218e-02f, 6.07462227e-02f, -7.31090605e-02f, -1.15464322e-01f, 4.08014357e-02f,
  -9.60658491e-03f, -6.49572462e-02f, -5.96771128e-02f, 3.11959386e-02f, 1.93220396e-02f, 1.04023200e-02f, 1.35379225e-01f, -6.83246776e-02f, 2.63028573e-02f, 5.73276393e-02f,
  3.49246971e-02f, 1.32654205e-01f, 1.12348184e-01f, 1.41125873e-01f, 1.04659989e-01f, 5.27679995e-02f, 3.52117680e-02f, -7.61086270e-02f, 3.73730510e-02f, 1.09716631e-01f,
  -2.47909769e-01f, -6.15157783e-02f, 1.30078122e-01f, -5.51487319e-02f, 8.45659524e-02f, 7.37285167e-02f, 1.05669744e-01f, 2.90439744e-02f, -4.60718339e-03f, 5.35075180e-03f,
  7.46176839e-02f, -1.40690077e-02f, -1.18786544e-01f, -1.21992275e-01f, -5.49267717e-02f, 3.87837775e-02f, -3.64556499e-02f, -5.25205210e-02f, -6.70106411e-02f, 2.25178432e-02f,
  -1.31106809e-01f, -1.31733000e-01f, -2.13064760e-01f, -2.30578929e-02f, -4.97257113e-02f, -1.68101326e-01f, 2.64418386e-02f, 2.78989170e-02f, 6.55798838e-02f, -1.05720021e-01f,
  -5.64772300e-02f, -1.84508581e-02f, 6.21703342e-02f, -9.70290378e-02f, -5.84558211e-02f, -6.78134561e-02f, -3.40366252e-02f, 1.68243200e-02f, -2.14280784e-02f, -4.29049432e-02f,
  -7.28745759e-02f, 2.81988382e-02f, 5.83897484e-03f, 2.01771781e-02f, -1.02691762e-01f, 6.88537806e-02f, -7.16063753e-02f, -2.56851129e-02f, -3.97216156e-02f, -5.98967038e-02f,
  -5.25632724e-02f, -2.23102956e-03f, 5.75869251e-03f, -8.14278126e-02f, 1.97375584e-02f, -8.43749493e-02f, -7.31468052e-02f, -6.58169165e-02f, -5.31658754e-02f, -2.33144257e-02f,
  -1.47569715e-03f, -3.35349981e-03f, 8.16407651e-02f, -3.35630886e-02f, -3.63847939e-03f, 2.37459447e-02f, 4.92648073e-02f, -1.93021074e-02f, -5.59669174e-02f, 4.29638028e-02f,
  -2.35274676e-02f, -5.69842197e-02f, 9.66610666e-03f, -6.49991781e-02f, -1.66677609e-02f, -7.18268156e-02f, 2.00759098e-02f, -3.60343866e-02f, 1.41604524e-02f, -3.45919281e-02f,
  -1.09978512e-01f, 1.73425209e-02f, -3.70606557e-02f, 4.11803499e-02f, 6.64526224e-02f, -1.10326735e-02f, 8.64778534e-02f, -1.55882379e-02f, 2.41826139e-02f, 1.94908939e-02f,
  -1.39550164e-01f, 1.14396021e-01f, -4.84493859e-02f, -1.24772759e-02f, -3.20705846e-02f, -5.41790910e-02f, 5.10841459e-02f, 1.58628169e-02f, -3.59703153e-02f, -7.23898411e-03f,
  5.28638624e-02f, -1.06254771e-01f, -9.90714803e-02f, -3.29679921e-02f, -2.00879984e-02f, -4.87587638e-02f, -5.13626859e-02f, 1.97849534e-02f, 4.73241434e-02f, 5.33457585e-02f,
  -2.80849487e-02f, -1.06988840e-01f, -5.17281964e-02f, -1.06792353e-01f, -7.77467117e-02f, -1.05787396e-01f, -1.49337247e-01f, 1.31494422e-02f, -1.40038192e-01f, -1.62945166e-01f,
  1.01875260e-01f, -8.10076743e-02f, -4.23812494e-02f, 9.22928751e-02f, 1.07313618e-01f, -1.35216042e-01f, -9.66948792e-02f, -1.44306183e-01f, -1.36918379e-02f, 8.89543965e-02f,
  2.13991806e-01f, 6.29188120e-03f, 9.28549170e-02f, -7.91917322e-04f, -1.76398963e-01f, -1.45422220e-01f, -1.49390548e-01f, -3.74646746e-02f, -1.77052826e-01f, -1.27280384e-01f,
  4.60188799e-02f, 6.36237413e-02f, 1.79373529e-02f, -4.90778647e-02f, 1.12000875e-01f, 1.34413749e-01f, -4.90540043e-02f, 4.09239978e-02f, 7.72077218e-02f, 1.56588390e-01f,
  1.08860806e-01f, 1.08534679e-01f, -1.25158414e-01f, 1.16302725e-03f, 1.39335513e-01f, -8.16841424e-02f, 1.48269059e-02f, 3.74169610e-02f, 4.37221639e-02f, -8.84498134e-02f,
  6.25519827e-02f, -4.88591753e-02f, 4.66840006e-02f, 1.05997473e-02f, -3.64786088e-02f, -1.46404831e-02f, -3.31537053e-02f, -1.13154471e-01f, -9.53950807e-02f, -4.39131036e-02f,
  4.11514612e-03f, 1.46305501e-01f, -4.13282439e-02f, -7.90911168e-02f, 2.44285358e-04f, 1.38064504e-01f, -4.75106155e-03f, -9.85819288e-03f, -1.70137566e-02f, 6.87086731e-02f,
  -3.26352119e-02f, 7.16232806e-02f, 7.21055828e-03f, -5.27720377e-02f, -8.22691470e-02f, 3.64540182e-02f, 7.13427141e-02f, -4.04021330e-02f, -1.58006046e-02f, 3.42667624e-02f,
  -3.56741622e-02f, -1.04842521e-02f, -4.20862921e-02f, 2.44262232e-03f, -6.02965765e-02f, -5.87781817e-02f, -4.06063907e-02f, -1.78810020e-04f, -3.38022001e-02f, -3.02645154e-02f,
  -6.44334704e-02f, -2.78869793e-02f, 1.19620204e-01f, -7.92526901e-02f, 2.23855264e-02f, -5.05929925e-02f, 1.07066415e-01f, 4.39184979e-02f, 8.90802220e-02f, 8.60902295e-03f,
  8.30586348e-03f, -1.09040782e-01f, -5.19665927e-02f, -1.01554170e-01f, 1.31494358e-01f, -4.49181050e-02f, 2.16723178e-02f, 6.79020807e-02f, 7.98609406e-02f, -7.36130551e-02f,
  5.76501489e-02f, 3.88024151e-02f, 3.50710675e-02f, -2.19057547e-03f, -4.29189838e-02f, -1.10251196e-01f, -7.48921782e-02f, 1.09736826e-02f, 7.31288362e-03f, -8.42409208e-02f,
  -5.58430962e-02f, -2.69086640e-02f, -2.91456766e-02f, -6.99566454e-02f, 2.63797864e-02f, 4.32119053e-03f, -5.43964244e-02f, -2.44213212e-02f, -1.35100380e-01f, -2.01574638e-01f,
  -2.25181296e-01f, 8.79488140e-02f, 2.51764562e-02f, -5.47268502e-02f, -1.04583353e-01f, 6.16921335e-02f, -7.06434548e-02f, -1.21149667e-01f, -1.94660313e-02f, 5.75760612e-03f,
  1.88253559e-02f, -6.52745292e-02f, 5.41918874e-02f, -1.54435709e-02f, 2.00556125e-02f, -6.84833899e-02f, -6.89651584e-03f, -2.08494300e-03f, 8.76044855e-02f, 5.96631207e-02f,
  8.51363167e-02f, -2.28462112e-03f, 1.75971445e-02f, 5.40268095e-03f, 5.15278317e-02f, -3.24675106e-02f, -6.18397221e-02f, 3.97145972e-02f, -4.31088433e-02f, -3.01643033e-02f,
  3.36477160e-01f, 1.85054950e-02f, -6.21831045e-02f, 1.07003301e-02f, -2.52307430e-02f, -9.22019011e-04f, 7.03179538e-02f, 3.93759906e-02f, -1.22967241e-02f, -3.53274145e-03f,
  -2.29613706e-02f, -4.77740206e-02f, 1.79175530e-02f, 1.40002286e-02f, -7.20872581e-02f, 3.22503112e-02f, -1.12220533e-01f, 3.49494745e-03f, 5.58417588e-02f, 5.38408756e-02f,
  -4.26464863e-02f, -9.69060659e-02f, 7.58402422e-02f, -7.24019036e-02f, -5.56437038e-02f, -2.62314659e-02f, 1.33248270e-01f, -7.56122097e-02f, 8.44102725e-02f, 8.83126482e-02f,
  1.77573711e-02f, -5.56189986e-03f, -1.90652895e-03f, -1.02937808e-02f, 3.47988717e-02f, -5.12370281e-02f, -4.30003479e-02f, -8.74498580e-03f, -6.80034840e-03f, 6.35831198e-03f,
  3.35173885e-04f, 7.28375167e-02f, 7.93454498e-02f, -8.32585339e-03f, 7.49980360e-02f, -5.70477284e-02f, 4.68919165e-02f, 9.23651680e-02f, 2.06189303e-04f, 1.54661238e-02f,
  -1.94983874e-02f, -3.87926660e-02f, 3.06121781e-02f, -1.53935356e-02f, 4.61116284e-02f, -4.03318889e-02f, 1.31763956e-02f, 3.15268598e-02f, -7.59173632e-02f, 4.47860695e-02f,
  2.31765687e-01f, -1.14321008e-01f, 6.58045560e-02f, -2.44483799e-02f, 5.96043328e-03f, -1.54980877e-02f, 4.95012738e-02f, -9.24915969e-02f, -3.93160731e-02f, 6.61795884e-02f,
  7.56561980e-02f, 4.33904156e-02f, 8.13238844e-02f, -8.03728700e-02f, -8.91692284e-03f, -3.30549739e-02f, -5.34175150e-02f, 2.31906325e-02f, 5.56356050e-02f, 8.68665650e-02f,
  -2.05832683e-02f, 4.81455550e-02f, 9.73419920e-02f, 8.72571692e-02f, -4.51256596e-02f, -3.28470878e-02f, 1.40098244e-01f, 3.19130048e-02f, 1.33198546e-02f, -6.16868166e-03f,
  1.18534051e-01f, 6.87195957e-02f, -9.50435251e-02f, 4.20469306e-02f, 2.19749231e-02f, -3.69392801e-03f, -9.64264274e-02f, -9.99127254e-02f, -7.68725248e-03f, 1.92248859e-02f,
  -9.29968283e-02f, 6.27365783e-02f, 2.79602665e-03f, -4.19337861e-03f, 7.99628813e-03f, -4.95279692e-02f, 3.91286351e-02f, 2.86191162e-02f, 8.15099403e-02f, -6.40455559e-02f,
  -4.59143035e-02f, 6.10867776e-02f, -4.47384641e-02f, 1.12083688e-01f, -3.84262912e-02f, -3.36227193e-02f, 2.78723333e-03f, -3.25798839e-02f, 2.01869179e-02f, 9.90214795e-02f,
  -2.29891781e-02f, 8.01339447e-02f, -1.24509158e-02f, 7.02979490e-02f, 1.15983663e-02f, 7.13429675e-02f, 7.42350668e-02f, 2.26231175e-03f, -2.05563400e-02f, -8.96361936e-03f,
  -5.18771969e-02f, -7.65440017e-02f, 7.36073554e-02f, 3.56495455e-02f, 1.96103211e-02f, -3.31043266e-02f, 4.31014784e-02f, -1.61156955e-03f, 4.19615731e-02f, -6.46349639e-02f,
  -2.11863685e-02f, -5.83034568e-02f, -2.23933011e-02f, -1.04179852e-01f, 4.49390113e-02f, -5.76985516e-02f, -2.06140671e-02f, 7.08250999e-02f, -1.08392939e-01f, 8.99531841e-02f,
  6.42622728e-03f, 4.62626554e-02f, -8.17499608e-02f, -7.70659681e-05f, 4.41553295e-02f, 1.47899054e-02f, 4.63652536e-02f, 5.42630628e-02f, 7.92091265e-02f, 4.19684835e-02f,
  -2.79210620e-02f, 3.50767979e-03f, -4.81910352e-03f, -6.06904440e-02f, 8.23401213e-02f, 9.02552828e-02f, -1.11138355e-03f, -7.50771677e-03f, -5.70388399e-02f, 4.49622422e-02f,
  -4.17931180e-04f, 5.09949811e-02f, 5.30587584e-02f, -3.84005010e-02f, -8.71785544e-03f, 7.25871995e-02f, -3.74658220e-02f, -5.20236194e-02f, -1.09380931e-02f, 6.87989071e-02f,
  6.23860918e-02f, -1.00091107e-01f, 2.87982896e-02f, 1.99531112e-02f, -4.04865062e-03f, -7.77031258e-02f, -9.98598114e-02f, 4.66010012e-02f, 3.35974470e-02f, -1.75564811e-02f,
  3.97583731e-02f, -4.24669832e-02f, 4.57082577e-02f, -3.09658032e-02f, -1.47270588e-02f, -5.18746264e-02f, 7.67178601e-03f, 6.96552098e-02f, -7.18693659e-02f, 8.68584439e-02f,
  -8.22959691e-02f, -9.22408849e-02f, -1.02691427e-01f, -4.13011834e-02f, 5.36238477e-02f, -1.03809342e-01f, 3.70339118e-02f, 1.74411037e-03f, -1.08587578e-01f, -9.46087539e-02f,
  -8.75468180e-02f, 1.72190778e-02f, -1.91959627e-02f, -1.02358334e-01f, -1.40985265e-01f, -9.50058252e-02f, -5.46931997e-02f, -4.09721285e-02f, 1.89823704e-03f, -1.62239390e-04f,
  -6.51762709e-02f, -8.51299316e-02f, -6.81672618e-02f, 6.36478513e-02f, -1.77033637e-02f, 4.67179604e-02f, 1.79590136e-02f, -1.23503385e-02f, -4.81503643e-02f, 9.19821039e-02f,
  8.54768828e-02f, 7.44889081e-02f, 1.33011743e-01f, -5.47982231e-02f, -8.65719765e-02f, -1.00097945e-03f, 7.15654045e-02f, 6.02514632e-02f, 4.46649343e-02f, 1.51936356e-02f,
  -7.06383437e-02f, -9.23287943e-02f, -4.68792543e-02f, 1.02019593e-01f, -3.41736712e-02f, -9.11683738e-02f, 4.87275608e-02f, -2.04492901e-02f, -1.01019047e-01f, -5.79036586e-02f,
  -5.73648289e-02f, -2.52548065e-02f, 3.36186960e-02f, 1.94463190e-02f, -8.70691016e-02f, -1.75484847e-02f, 6.62320713e-03f, -4.61794771e-02f, 9.16461051e-02f, 6.54508695e-02f,
  -6.68061525e-02f, -9.41670239e-02f, 1.82917435e-02f, -3.10537387e-02f, -8.25090334e-03f, -8.46230388e-02f, -1.98995303e-02f, -1.71863474e-02f, -6.02093227e-02f, -7.51548186e-02f,
  -6.16663843e-02f, 4.73630242e-02f, -1.94898769e-02f, 3.92209589e-02f, 1.54766617e-02f, -3.67749967e-02f, 4.88268299e-04f, 6.75758049e-02f, 5.21311015e-02f, 3.00717913e-02f,
  6.84611797e-02f, 3.77469063e-02f, 5.06094955e-02f, 3.46780941e-02f, 5.04274562e-04f, 1.98938251e-02f, 1.18451575e-02f, -6.28421977e-02f, 7.79250488e-02f, -2.45401077e-02f,
  -5.56996427e-02f, -1.59681216e-02f, 4.92344685e-02f, 2.31420733e-02f, -5.59188537e-02f, 7.13507831e-02f, -1.00997444e-02f, 7.80001730e-02f, 3.42287123e-02f, 1.75964125e-02f,
  1.63602980e-03f, 1.04839750e-01f, -1.04383714e-01f, -6.97478354e-02f, -6.67539835e-02f, -1.27150100e-02f, 3.11515480e-02f, 1.01073727e-01f, -7.27637410e-02f, 5.40113589e-03f,
  -3.39362361e-02f, -5.41814510e-03f, -3.79475467e-02f, 2.25897208e-02f, -5.30297272e-02f, -2.26310212e-02f, 1.04839206e-01f, -6.72235787e-02f, -3.47083472e-02f, 2.97349691e-02f,
  -2.64329556e-02f, 7.61791840e-02f, -4.30891290e-02f, 2.32874844e-02f, 4.54042945e-03f, -1.19052351e-01f, 6.23406209e-02f, 1.55548789e-02f, 3.41120698e-02f, 2.40903664e-02f,
  -9.53697637e-02f, -1.25061814e-02f, 4.65937816e-02f, 1.54582635e-01f, 8.61736834e-02f, 1.51720168e-02f, 1.30793065e-01f, 7.62989670e-02f, -1.61788389e-02f, 4.00904082e-02f,
  3.83805856e-02f, 6.26702532e-02f, -1.86269879e-02f, 3.34043130e-02f, -1.34211769e-02f, -2.11935323e-02f, 4.16516177e-02f, 4.18442264e-02f, 8.72736350e-02f, 4.84647006e-02f,
  1.29211336e-01f, -3.07344981e-02f, 4.95347492e-02f, 3.32481302e-02f, -3.78880799e-02f, -4.67298143e-02f, -5.33297518e-03f, 6.14947379e-02f, 5.11695072e-02f, -3.86375785e-02f,
  -4.74629588e-02f, 9.65769682e-03f, -8.96624173e-04f, 1.56368874e-02f, 2.00242829e-02f, 2.22712643e-02f, -2.61185281e-02f, -7.67756104e-02f, -9.19775590e-02f, -7.24062547e-02f,
  -5.09781428e-02f, 4.10883129e-02f, -5.97402342e-02f, 1.34836463e-03f, 8.92327726e-03f, 6.26383945e-02f, -5.31426258e-02f, -8.13280717e-02f, -8.31679851e-02f, 2.49963868e-02f,
  -8.36638808e-02f, 1.44721847e-02f, 8.48034397e-02f, -9.61059332e-02f, -6.21639891e-03f, 1.17717246e-02f, 3.91727649e-02f, 5.90490038e-03f, -1.03308186e-01f, -2.92813219e-02f,
  -9.06636640e-02f, 3.09098568e-02f, 1.06080491e-02f, -2.74178153e-03f, -6.65413290e-02f, -8.55632797e-02f, -2.49890368e-02f, -7.42597878e-02f, -6.70651868e-02f, 5.88370487e-02f,
  -8.92234072e-02f, 5.05592898e-02f, 3.07104569e-02f, 6.13520853e-02f, 2.32754778e-02f, -2.53476147e-02f, -8.74345079e-02f, 2.11534338e-04f, -8.74264687e-02f, -7.56765082e-02f,
  -1.50034428e-02f, 1.40573056e-02f, 1.01747196e-02f, -8.25081095e-02f, -6.57330006e-02f, -9.96355638e-02f, -2.16648523e-02f, 6.40949309e-02f, -2.73655299e-02f, 1.57037638e-02f,
  -1.25338938e-02f, -1.05682798e-01f, 7.41543472e-02f, 2.95931213e-02f, 7.45093822e-02f, -6.34853691e-02f, 4.52257283e-02f, 1.52471848e-02f, 4.55073901e-02f, -8.42003711e-03f,
  -1.17624342e-03f, 3.55845839e-02f, -2.99547594e-02f, -4.15057279e-02f, 5.46769388e-02f, -6.61649033e-02f, 2.57793684e-02f, 5.27203418e-02f, -1.06025608e-02f, -7.08200410e-02f,
  -9.23536494e-02f, 9.58382487e-02f, 3.37911472e-02f, 7.74770007e-02f, -4.64103147e-02f, -1.37753479e-04f, 3.89386006e-02f, -5.72433285e-02f, -4.98172231e-02f, 3.50345224e-02f,
  -6.21658191e-03f, -1.78302556e-01f, -1.74200356e-01f, -1.97382197e-01f, -1.37419149e-01f, 3.39602530e-02f, -7.08383918e-02f, -6.62178695e-02f, -1.39198020e-01f, -1.81228787e-01f,
  -4.13621627e-02f, 1.29072174e-01f, 5.13540506e-02f, 8.53543282e-02f, 1.20312899e-01f, -6.30640462e-02f, -2.07429811e-01f, 2.44741403e-02f, 7.05733374e-02f, -1.33486586e-02f,
  1.59352589e-02f, 5.45668532e-04f, -4.13205437e-02f, -1.00728817e-01f, -6.51982874e-02f, 6.69689151e-04f, -1.05116822e-01f, -1.20447159e-01f, -5.20836636e-02f, -1.82970077e-01f,
  -1.02523774e-01f, 5.65880015e-02f, -1.74998567e-02f, 1.39214575e-01f, -9.71542075e-02f, 1.03638671e-01f, 3.17153893e-02f, -2.00469419e-02f, 6.73277676e-02f, -9.74932685e-02f,
  6.45974502e-02f, 1.13365732e-01f, -3.88341919e-02f, 8.81666541e-02f, -1.28439153e-02f, 4.78395112e-02f, -2.43937224e-02f, 6.78702965e-02f, -5.11772633e-02f, 5.58429323e-02f,
  -9.03543923e-03f, 1.04696050e-01f, 8.67774412e-02f, -2.91973259e-02f, 5.01497164e-02f, 8.03307667e-02f, 1.86208878e-02f, -3.57541479e-02f, 7.88660124e-02f, 4.43394557e-02f,
  -5.16519509e-02f, -8.82512480e-02f, 6.58286810e-02f, 7.86391944e-02f, -7.17202201e-02f, -4.02484797e-02f, 2.55565885e-02f, 6.30553439e-02f, -6.80571562e-03f, 2.65365373e-02f,
  -2.90582562e-03f, 1.36945641e-03f, 3.32988091e-02f, 1.65065154e-02f, -4.55007292e-02f, 5.57688400e-02f, 2.87602823e-02f, -2.30056886e-02f, 3.25809307e-02f, 1.34914164e-02f,
  4.28981632e-02f, -1.22908661e-02f, -3.34294476e-02f, -7.96473101e-02f, -3.19507048e-02f, 2.61509195e-02f, -1.13886781e-02f, -2.87623424e-02f, -3.50590795e-02f, -3.66192274e-02f,
  -1.16888694e-01f, 1.96187869e-01f, 2.89646219e-02f, 4.52733189e-02f, 3.64786237e-02f, -2.59277727e-02f, 5.03411591e-02f, -1.82004962e-02f, 4.89713103e-02f, 5.75492457e-02f,
  -2.98620909e-02f, -5.33288829e-02f, -9.08349380e-02f, -5.06504579e-03f, 9.85478424e-03f, 2.21460462e-02f, -1.57968700e-02f, -5.87689085e-03f, 2.84199845e-02f, -8.69782045e-02f,
  -1.02610148e-01f, 3.13043408e-02f, 2.41955929e-02f, 2.87553277e-02f, -1.15479976e-02f, 1.41547889e-01f, 4.49598283e-02f, 6.90350682e-02f, 4.62025730e-03f, -1.25205889e-01f,
  -2.03369930e-01f, 1.74652666e-01f, 1.08472139e-01f, -7.69039840e-02f, -1.02043070e-01f, -1.07309058e-01f, -9.57141742e-02f, 1.15819164e-02f, -7.29872733e-02f, 8.04065987e-02f,
  -2.23627561e-04f, -1.01137169e-01f, -1.48719912e-02f, -3.41203511e-02f, -1.79945529e-02f, 6.21336065e-02f, -1.80625059e-02f, -4.99279238e-02f, -2.84289330e-01f, -1.80669650e-01f,
  -9.07106698e-02f, -1.39933914e-01f, -1.37190118e-01f, -1.00149557e-01f, -1.89588091e-03f, 8.15927237e-02f, 1.49909750e-01f, 3.26991305e-02f, -5.17205372e-02f, 1.35537043e-01f,
  2.40484536e-01f, -5.81318066e-02f, -1.22728050e-01f, -4.42641042e-02f, 6.60475120e-02f, 5.92203587e-02f, 5.38830273e-02f, -5.39272092e-03f, -9.21310186e-02f, -1.36822369e-02f,
  -9.73930061e-02f, 5.63535281e-02f, -1.91041268e-02f, 5.01418225e-02f, -9.03103035e-03f, -7.21064061e-02f, -1.27846515e-02f, -1.10785544e-01f, 2.14848816e-02f, 1.62596209e-03f,
  1.03620566e-01f, -5.24160787e-02f, -3.23772058e-02f, 4.31925394e-02f, 7.09567964e-02f, 1.10145230e-02f, -1.21393865e-02f, -3.32715921e-02f, -8.01400170e-02f, 1.01615004e-02f,
  -7.28993639e-02f, -8.33866559e-03f, 5.34101874e-02f, 6.39374554e-03f, -5.92931546e-02f, 7.20788166e-02f, -4.70165536e-02f, -3.76554020e-02f, 1.67421252e-02f, -3.40910703e-02f,
  -3.58854444e-03f, -3.60566229e-02f, 8.30615088e-02f, -3.16509418e-02f, 5.60235269e-02f, 5.47934957e-02f, -3.63988057e-02f, -1.99305788e-02f, 6.88780248e-02f, -5.28513752e-02f,
  -8.37091431e-02f, -2.41935421e-02f, -1.25817442e-02f, 1.12936758e-02f, 6.07330725e-02f, -5.96906878e-02f, 1.11196190e-02f, -9.08326134e-02f, 3.38209160e-02f, -5.16909622e-02f,
  6.21159226e-02f, -1.49417490e-01f, 1.20110780e-01f, 4.82018031e-02f, -2.38220207e-02f, 4.78928611e-02f, 1.34181261e-01f, 7.55238906e-02f, 3.59531045e-02f, 4.45641950e-02f,
  -2.54783668e-02f, -6.52049929e-02f, 3.03943641e-03f, 5.89112658e-03f, -4.53911312e-02f, -5.78292534e-02f, -5.71783222e-02f, 4.16210443e-02f, -1.01328557e-02f, 8.65579247e-02f,
  -2.84268558e-02f, 3.75081487e-02f, 3.86971161e-02f, 4.94923517e-02f, -5.31059839e-02f, -7.59530813e-02f, 1.07371531e-01f, -2.44829748e-02f, -4.86838408e-02f, 7.61300847e-02f,
  -4.57531016e-04f, -2.41943467e-02f, 1.46764204e-01f, 6.08675815e-02f, 3.06754857e-02f, -1.07586890e-01f, -2.13304028e-01f, -8.53816643e-02f, -7.51091540e-02f, -1.17881186e-01f,
  -4.68184650e-02f, -7.92087466e-02f, 4.75301109e-02f, -6.34286329e-02f, -4.74551097e-02f, -4.78327945e-02f, 1.69660486e-02f, 1.57218650e-02f, 7.65961111e-02f, -1.76591426e-01f,
  -1.37366414e-01f, 1.56838819e-02f, 1.42677307e-01f, -3.07195876e-02f, -4.16470170e-02f, -1.64856911e-02f, 1.39986739e-01f, 1.29009977e-01f, 1.51408715e-02f, -1.11291371e-01f,
  -6.86495006e-02f, 2.21459046e-02f, -2.07638228e-03f, 3.90278921e-02f, 8.00031647e-02f, 4.28400151e-02f, -1.94154996e-02f, 1.10813208e-01f, -8.66634026e-02f, -7.36492500e-02f,
  6.05964549e-02f, -8.45058635e-02f, 9.52855777e-03f, -4.24586758e-02f, -9.74707305e-02f, -1.20657058e-02f, -6.73131226e-03f, 1.10447913e-01f, 5.74308708e-02f, -1.09268129e-01f,
  -1.18727468e-01f, -6.79001734e-02f, -4.35047373e-02f, 3.94666791e-02f, 5.79584911e-02f, -5.85344657e-02f, 3.59152816e-02f, -1.03534617e-01f, -2.77358871e-02f, -1.17385678e-01f,
  -1.02122843e-01f, 3.59125026e-02f, -6.80013746e-02f, 1.61487609e-03f, 4.97441478e-02f, 6.86334521e-02f, 1.35993669e-02f, 2.78702993e-02f, 5.42991087e-02f, -1.47684095e-02f,
  -7.41660297e-02f, 1.19268475e-02f, 7.05090526e-04f, -2.89681554e-02f, 6.42018905e-03f, 2.47666910e-02f, -1.63838789e-02f, -2.41825264e-02f, 1.47201391e-02f, -5.25309145e-02f,
  -3.56772095e-02f, 4.73280922e-02f, 7.78041929e-02f, 2.35338677e-02f, 2.52856221e-02f, -1.54830217e-02f, -2.66207606e-02f, 4.78555113e-02f, -3.39646600e-02f, -1.03859715e-01f,
  -6.19023442e-02f, 1.74677521e-01f, -1.49781525e-01f, -8.55911523e-02f, 4.18824852e-02f, -9.50820837e-03f, -5.82645871e-02f, -3.53804976e-02f, 1.62233342e-03f, -1.01038150e-01f,
  -5.06580807e-02f, -4.32690680e-02f, 5.69871031e-02f, -1.52926603e-02f, -9.58388112e-03f, -9.90401357e-02f, -8.70362297e-02f, -8.29395503e-02f, -2.94717848e-02f, 6.16399087e-02f,
  -6.58475608e-02f, -6.51583821e-02f, 5.88628929e-03f, -8.27993229e-02f, -3.15058641e-02f, 8.76233540e-03f, -6.29205033e-02f, 1.95918139e-02f, -9.67319682e-03f, -1.26945525e-02f,
  -3.14349234e-01f, 1.11379951e-01f, -2.82422779e-03f, -1.70385420e-01f, 5.36185205e-02f, 3.89146693e-02f, 2.38024071e-02f, -1.30789220e-01f, 2.57678758e-02f, 6.93861842e-02f,
  3.13539468e-02f, -3.80655304e-02f, -3.06180529e-02f, -5.24908453e-02f, 5.72576448e-02f, 8.05666372e-02f, 8.13182965e-02f, -3.70733789e-03f, 2.75323559e-02f, -4.83244210e-02f,
  4.39434908e-02f, 1.23072509e-03f, -8.96979421e-02f, -7.35211372e-02f, 1.11678019e-01f, -3.61298211e-02f, 1.12861507e-02f, 2.24724691e-02f, 1.84048861e-01f, 1.76646672e-02f,
  7.98800141e-02f, -2.52412230e-01f, -7.59980679e-02f, 8.60896930e-02f, -9.58456018e-04f, -9.09573361e-02f, -2.49186493e-02f, -1.29162222e-01f, -9.24641714e-02f, -6.96155354e-02f,
  4.45347950e-02f, 2.10671239e-02f, -7.85198510e-02f, -1.74197778e-02f, -4.14563753e-02f, -8.97502229e-02f, -9.03973356e-02f, -1.68285027e-01f, -1.65094547e-02f, 3.69285196e-02f,
  1.14769295e-01f, -3.40000950e-02f, -5.36150038e-02f, -8.63574222e-02f, -6.72945231e-02f, 2.87918793e-03f, -6.30632639e-02f, -2.94338539e-02f, -4.65642512e-02f, -5.70275076e-02f,
  3.62773165e-02f, 7.88497105e-02f, -2.40373909e-02f, -1.43951103e-02f, 2.75726262e-02f, 1.08305423e-03f, 2.38718223e-02f, 9.17399898e-02f, -6.05343319e-02f, 6.56468514e-03f,
  -8.02149400e-02f, 8.38712454e-02f, -8.77171904e-02f, -6.65275007e-02f, -5.86363375e-02f, -6.43861219e-02f, -4.40709479e-02f, -2.58547366e-02f, 8.26040283e-02f, -9.53054242e-03f,
  -7.18541518e-02f, 2.21228246e-02f, 1.84853617e-02f, -6.18104376e-02f, 1.10795997e-01f, 5.04610650e-02f, -1.42360490e-03f, -6.53958693e-03f, -1.47373565e-02f, -4.90925759e-02f,
  -6.56074360e-02f, -4.93756868e-02f, -7.41234049e-02f, -1.76541612e-03f, 3.00315376e-02f, 2.75073182e-02f, 3.39108519e-02f, -6.93847910e-02f, -1.89577155e-02f, -1.07933860e-02f,
  -1.96250938e-02f, 2.55314913e-02f, -5.75125925e-02f, 4.34392393e-02f, -5.08032851e-02f, -5.71333207e-02f, -4.01699953e-02f, -4.87447493e-02f, -4.76006120e-02f, 4.51162364e-03f,
  8.96362439e-02f, -5.90662435e-02f, -4.51795384e-02f, 3.62185799e-02f, -2.34973300e-02f, 3.82851586e-02f, 1.65408440e-02f, 2.38429084e-02f, -3.25841308e-02f, -1.00050874e-01f,
  -2.34249979e-01f, 1.16916806e-01f, 4.56360057e-02f, -1.31239012e-01f, -6.15260331e-03f, -4.61372919e-02f, -5.31153800e-03f, -9.81026888e-02f, -2.92732865e-02f, -3.66562828e-02f,
  9.63261351e-02f, 9.78642851e-02f, 1.39484823e-01f, 9.22329351e-02f, -8.71099439e-03f, -1.65138301e-02f, -1.37407094e-01f, 3.39083519e-04f, 1.17028140e-01f, 6.89701438e-02f,
  -4.48448360e-02f, -4.24777828e-02f, -7.49300718e-02f, 2.14826036e-02f, -7.33239427e-02f, 5.08041605e-02f, -7.66004547e-02f, -6.36298656e-02f, -7.44492114e-02f, 6.43149540e-02f,
  4.11197931e-01f, -1.91570520e-01f, 4.78093773e-02f, -3.69618312e-02f, -4.03989032e-02f, -8.70469660e-02f, 1.37313884e-02f, -1.38926268e-01f, 2.82390304e-02f, 5.76353185e-02f,
  -6.19401857e-02f, -5.61832190e-02f, 4.94454540e-02f, -4.25293185e-02f, 1.76484492e-02f, 4.99891788e-02f, -9.92526412e-02f, -3.14594321e-02f, -5.80215156e-02f, 8.24309513e-03f,
  -7.85402358e-02f, -3.39030125e-03f, -2.30036192e-02f, -2.43544746e-02f, -6.98842183e-02f, -5.32383099e-02f, -7.27038309e-02f, -3.14132944e-02f, -1.40194502e-02f, 2.22321078e-02f,
  2.62256153e-02f, -6.87428415e-02f, 3.94813046e-02f, 5.38013503e-02f, 8.96963924e-02f, -2.25776024e-02f, 1.57336630e-02f, 8.97096097e-02f, 2.30345093e-02f, 5.89900203e-02f,
  -5.31017892e-02f, -4.84454483e-02f, 6.55548945e-02f, -5.56301363e-02f, 6.01322018e-02f, 1.41995698e-02f, 1.68566778e-02f, 9.77734700e-02f, -1.41503690e-02f, -4.91601676e-02f,
  1.43942656e-02f, 2.99446359e-02f, 3.64007466e-02f, -2.16239095e-02f, -8.37129951e-02f, -5.06074354e-02f, -2.63012573e-02f, -3.61552685e-02f, -8.45742226e-02f, -2.92848106e-02f,
  3.56505394e-01f, -9.60062966e-02f, 1.14279613e-01f, -5.97939417e-02f, -3.37283835e-02f, -1.05202109e-01f, -6.81761876e-02f, -4.67895344e-03f, -3.98652554e-02f, 4.03506532e-02f,
  -9.06939618e-03f, -6.84093237e-02f, 2.94978283e-02f, 1.34976283e-02f, 3.18862535e-02f, -4.97895628e-02f, -4.01574448e-02f, 3.97238089e-03f, -6.24012724e-02f, 2.86458377e-02f,
  3.69556434e-02f, 5.79016702e-03f, 1.53020099e-01f, -2.50794124e-02f, -1.02398500e-01f, 9.04983804e-02f, 7.54553676e-02f, 9.42495614e-02f, 5.32159209e-02f, 1.77259803e-01f,
  2.59924591e-01f, 1.68761492e-01f, 1.30757492e-03f, 3.80905829e-02f, -1.21209122e-01f, -6.16953336e-02f, -7.86824971e-02f, 4.01587263e-02f, 1.08437203e-01f, 5.45687489e-02f,
  1.60505436e-02f, -1.57374889e-02f, -7.32377172e-02f, 4.00578678e-02f, -8.85184333e-02f, 6.18587295e-03f, -1.03687122e-01f, 4.69551720e-02f, -1.13607571e-01f, -1.39009327e-01f,
  -1.22635655e-01f, -5.07054515e-02f, 1.86227504e-02f, -8.20252374e-02f, 3.30282301e-02f, 3.33124138e-02f, -4.77628373e-02f, 6.47597834e-02f, 7.56280273e-02f, 1.10596322e-01f,
  -2.38792561e-02f, 1.91710144e-01f, -4.01503742e-02f, 6.47446141e-02f, -1.01088174e-01f, -1.76918283e-02f, 2.55371872e-02f, -1.54120028e-02f, -5.01441546e-02f, -7.24085942e-02f,
  7.07624257e-02f, 1.81994475e-02f, 7.35146925e-03f, -9.20337141e-02f, -2.02767588e-02f, -7.26987198e-02f, 1.52889611e-02f, -6.80085793e-02f, 1.11033088e-02f, -2.80097164e-02f,
  -8.92121196e-02f, 7.58254826e-02f, -2.95265466e-02f, -3.59553890e-03f, -9.38407108e-02f, 4.25721370e-02f, -7.62278140e-02f, 6.49354979e-02f, 6.73279837e-02f, 6.68133646e-02f,
  -5.10598952e-03f, -1.03255391e-01f, -1.13891624e-01f, 9.60154168e-04f, -1.98948365e-02f, -9.59904641e-02f, -5.80904298e-02f, -6.00922182e-02f, -1.13116898e-01f, -4.69942614e-02f,
  -5.11823669e-02f, -9.39205587e-02f, -8.81704018e-02f, 2.67464202e-02f, 1.64203253e-02f, -7.95821380e-03f, 2.37549748e-02f, -1.86301097e-02f, -7.73476288e-02f, -1.06994517e-01f,
  1.24169178e-02f, -7.19874054e-02f, -7.19450638e-02f, -6.60321712e-02f, 1.86540559e-02f, -7.84960017e-02f, -7.93922916e-02f, -2.13970654e-02f, -5.55609576e-02f, -2.03501273e-04f,
  4.62721325e-02f, 1.25324249e-03f, 2.36580987e-02f, 9.02232453e-02f, 1.02634290e-02f, -5.73972315e-02f, 4.11898084e-03f, -8.13260600e-02f, 1.83921829e-02f, 8.21465030e-02f,
  -1.77595709e-02f, 2.41585709e-02f, 5.17653078e-02f, -6.24431372e-02f, -4.47903983e-02f, -1.08936720e-01f, 5.01443222e-02f, -5.50142266e-02f, -6.91966414e-02f, -4.77131493e-02f,
  2.67168414e-02f, -5.50978519e-02f, 1.05860243e-02f, -5.24170138e-02f, -4.02094738e-04f, -3.88473533e-02f, 1.63243897e-02f, 3.18986289e-02f, -7.70089626e-02f, 4.61709909e-02f,
  -8.23672190e-02f, 2.46789530e-02f, 4.03787792e-02f, 7.66816735e-02f, -1.46880373e-01f, -1.01410367e-01f, -1.84955582e-01f, -1.43839940e-01f, -1.82469282e-02f, 3.23050618e-02f,
  -1.28287539e-01f, 6.36405423e-02f, 1.08706476e-02f, 1.33247338e-02f, -7.74238184e-02f, 3.42391543e-02f, 4.84908111e-02f, 7.65499175e-02f, -3.03673074e-02f, -1.35961130e-01f,
  -1.46725148e-01f, -5.78573532e-02f, 1.39748119e-02f, -5.76758534e-02f, -9.18620825e-02f, 1.57485006e-03f, 1.38129577e-01f, -5.12911044e-02f, -3.96686159e-02f, 2.25726180e-02f,
  8.39808360e-02f, -5.50124375e-03f, -6.65032258e-03f, 4.39759605e-02f, -2.05579996e-02f, -1.46732600e-02f, -3.39880772e-02f, 5.88022266e-03f, 1.78042296e-02f, 3.20483297e-02f,
  -4.44026403e-02f, 2.28335615e-03f, -3.52647826e-02f, 6.57988759e-03f, -5.66271832e-03f, -8.07101429e-02f, -3.20455171e-02f, 5.34282960e-02f, 3.87122259e-02f, -3.80958281e-02f,
  -1.01505190e-01f, -6.70623705e-02f, 4.36998811e-03f, 3.72207463e-02f, 6.12098351e-02f, -7.38131180e-02f, 4.70110700e-02f, -1.28004299e-02f, -4.78668846e-02f, -9.24002528e-02f,
  -5.86452149e-02f, 4.80265357e-02f, -1.08051999e-02f, -8.78556147e-02f, -2.91567203e-02f, 2.37975530e-02f, -6.16850778e-02f, 7.82386363e-02f, -1.70845464e-02f, -1.59114711e-02f,
  2.31227297e-02f, 6.46983683e-02f, 7.51022398e-02f, 8.83140638e-02f, -3.06569431e-02f, 3.75965796e-02f, 3.29732373e-02f, 1.64193138e-02f, 7.77140260e-02f, 6.61568269e-02f,
  2.32202448e-02f, 6.30431622e-02f, 8.93608332e-02f, -8.87506530e-02f, -6.22054972e-02f, 4.02575918e-02f, -6.62861094e-02f, 2.37515196e-02f, -7.72873908e-02f, -1.63774695e-02f,
  6.45391643e-03f, 3.02432152e-03f, 6.07701391e-02f, -3.70150106e-03f, -7.16045126e-02f, -5.88317169e-03f, -1.73669141e-02f, 1.10993832e-01f, -2.09193639e-02f, -1.04673915e-01f,
  -1.03737459e-01f, -8.18694755e-02f, -3.85747701e-02f, -6.88663274e-02f, 4.08459604e-02f, 5.08088581e-02f, -3.99905331e-02f, 7.93024749e-02f, 5.91670424e-02f, -2.63614971e-02f,
  4.18498833e-03f, -1.35952145e-01f, -1.11754894e-01f, -3.19845490e-02f, 2.07778979e-02f, -7.61064095e-03f, -5.79122938e-02f, -9.67947766e-02f, 2.34863795e-02f, -7.29276985e-02f,
  2.25532562e-01f, 7.27692321e-02f, -1.95994973e-01f, 9.56312940e-02f, -8.50363541e-03f, -9.26171429e-03f, 2.14890260e-02f, 6.11946993e-02f, 1.63177983e-03f, -6.36620745e-02f,
  -7.50300437e-02f, -1.07473016e-01f, -1.26219625e-02f, -1.98138136e-04f, 2.56486833e-02f, -5.18735349e-02f, -8.54407102e-02f, -1.30936161e-01f, -1.57274604e-01f, 8.09549761e-04f,
  -7.50513822e-02f, 3.45255211e-02f, -4.95618992e-02f, 2.25000307e-02f, 1.61042083e-02f, -7.58744702e-02f, -8.63089859e-02f, -5.37782386e-02f, -8.66245031e-02f, 1.30764423e-02f,
  -1.64458573e-01f, -1.29402159e-02f, -6.19077310e-02f, 9.15038213e-02f, 2.59666890e-02f, 1.04798628e-02f, -4.50378321e-02f, -4.04282175e-02f, -5.52956983e-02f, -6.52978756e-03f,
  -9.65268612e-02f, -6.55745789e-02f, -4.99915108e-02f, -6.20353334e-02f, -7.33041465e-02f, -1.19886724e-02f, -6.88028708e-03f, -6.95565715e-02f, -2.85298042e-02f, -3.86513174e-02f,
  -7.12000579e-02f, -5.71110062e-02f, 2.93062720e-02f, 9.30256695e-02f, -1.01847120e-01f, -6.02586456e-02f, -2.96479166e-02f, -1.17172308e-01f, 4.17215526e-02f, -5.61067350e-02f,
  4.43396494e-02f, -2.69096624e-02f, 2.39958279e-02f, 2.99739931e-02f, 8.84716809e-02f, -1.53293759e-02f, -6.84576035e-02f, 4.67704684e-02f, -6.00310043e-02f, 7.17407241e-02f,
  7.30399042e-02f, -5.16303368e-02f, -8.55355635e-02f, 2.29190197e-02f, 6.67485893e-02f, -1.90359149e-02f, -4.26196009e-02f, 3.99300270e-02f, -4.19473695e-03f, 8.37077678e-04f,
  -4.30790260e-02f, -2.85594288e-04f, 5.78287430e-02f, -2.72616930e-03f, -4.94526513e-02f, -3.33685651e-02f, -4.61070240e-02f, -3.41354199e-02f, -3.46583650e-02f, 2.62732105e-03f,
  1.37536019e-01f, 1.82119664e-02f, 9.95655283e-02f, -1.59483254e-02f, 7.27173919e-03f, -4.46439497e-02f, 6.06817529e-02f, 1.99812744e-02f, -7.59984627e-02f, -7.35395476e-02f,
  -9.54085067e-02f, -4.65803295e-02f, -4.79167663e-02f, -5.12243472e-02f, 7.92532042e-03f, -8.76337588e-02f, 1.30642787e-01f, 9.05466825e-02f, 8.32068175e-02f, -3.16598527e-02f,
  1.44068882e-01f, 6.88130315e-03f, 1.45234913e-01f, -2.35788729e-02f, -5.08562811e-02f, -4.76840371e-03f, -4.43740860e-02f, -2.28013564e-02f, -8.28421395e-03f, 2.12173074e-01f,
  6.60251528e-02f, -7.73239583e-02f, -3.29261385e-02f, 2.61922888e-02f, 1.30077407e-01f, -4.57910821e-02f, -1.14395857e-01f, 1.05358409e-02f, 1.32142124e-03f, 7.23004118e-02f,
  5.67955151e-02f, 1.21285804e-01f, 1.09116949e-01f, 1.50408866e-02f, -6.21160604e-02f, 5.61893769e-02f, -5.76427020e-03f, -6.83443621e-02f, -5.72119504e-02f, 7.10093677e-02f,
  2.78432225e-03f, 1.70123912e-02f, 3.45910043e-02f, 5.08495755e-02f, 8.38690251e-02f, 6.63729683e-02f, 9.43207741e-02f, -3.80259156e-02f, 9.39689651e-02f, 6.15078472e-02f,
  1.68432333e-02f, 1.54297212e-02f, 2.14738287e-02f, 1.04044072e-01f, -5.14118262e-02f, 5.85166141e-02f, -2.45629530e-02f, 1.53357387e-02f, 4.31668088e-02f, 3.04643549e-02f,
  1.39340740e-02f, 2.25958806e-02f, -4.79013547e-02f, -3.09696943e-02f, 6.30837828e-02f, 7.98884481e-02f, -7.08744973e-02f, -1.25092536e-01f, 3.56242582e-02f, -1.02442272e-01f,
  -2.01417375e-02f, 9.26237032e-02f, -7.78621584e-02f, -1.00014701e-01f, -1.16879359e-01f, 8.41128454e-02f, -1.03809573e-01f, -3.18084955e-02f, -9.87511501e-02f, 2.20404062e-02f,
  6.74390644e-02f, 6.52730688e-02f, 1.79675054e-02f, 9.25935581e-02f, 8.24284926e-02f, -2.38474980e-02f, 5.37682176e-02f, 8.17311108e-02f, 5.23191411e-03f, 7.45132146e-03f,
  -4.75684926e-02f, 1.26244128e-02f, -4.00749929e-02f, -4.76308949e-02f, 9.98408124e-02f, 1.89816300e-02f, 1.17054366e-01f, 4.30126600e-02f, 8.38585496e-02f, 9.40331370e-02f,
  2.19242666e-02f, -3.24881747e-02f, -4.79015034e-05f, 2.02738475e-02f, -5.52335866e-02f, 5.06810360e-02f, 9.60312784e-02f, 4.78184782e-02f, 9.14990995e-03f, -3.39748226e-02f,
  1.11764550e-01f, -3.27172386e-03f, 3.50485407e-02f, 2.41082236e-02f, 5.33581339e-02f, -7.39272162e-02f, -6.09130459e-03f, -3.54125798e-02f, 1.59011055e-02f, -9.65387821e-02f,
  9.72367898e-02f, -4.06456515e-02f, 5.73336147e-02f, 2.61404645e-02f, -1.91303492e-02f, 1.02307580e-01f, 4.61874455e-02f, -7.41587132e-02f, -1.38723757e-02f, 3.01207788e-02f,
  -4.94586751e-02f, -7.33174337e-03f, 7.56608769e-02f, -1.32277953e-02f, 4.78809439e-02f, 3.43344249e-02f, -2.23809611e-02f, -4.40450609e-02f, -6.76515549e-02f, 4.14491706e-02f,
  3.22089165e-01f, -1.54549971e-01f, 1.06256939e-01f, 4.10423940e-03f, -4.54167537e-02f, 9.32851713e-03f, 1.03403963e-02f, -4.92027253e-02f, 1.21452563e-01f, -8.41725096e-02f,
  -1.60961658e-01f, 3.84271741e-02f, 7.86056221e-02f, 8.10668990e-03f, -1.29567496e-02f, 6.77119568e-02f, -1.70584973e-02f, 1.79221585e-01f, 2.12786481e-01f, 1.04268640e-01f,
  -1.18116170e-01f, 7.87875205e-02f, 1.68660864e-01f, 7.29920790e-02f, -1.15297101e-02f, -6.88494593e-02f, -5.16296960e-02f, -4.23165485e-02f, -2.01222729e-02f, 6.93979263e-02f,
  -4.49530445e-02f, -8.26383301e-04f, 1.08423948e-01f, 5.64018078e-02f, -8.49958435e-02f, -4.41456139e-02f, 8.00526738e-02f, -7.90523831e-03f, -8.61639306e-02f, 4.03780155e-02f,
  -7.66356215e-02f, 9.48071852e-03f, 2.27740575e-02f, -8.19916576e-02f, -5.71837183e-03f, -7.54641183e-03f, -4.32834774e-02f, 4.77192700e-02f, 9.94306151e-03f, -8.13505650e-02f,
  -1.63383335e-01f, 3.49285603e-02f, -2.69033480e-02f, -2.59224493e-02f, -2.78965067e-02f, 3.91415134e-02f, -1.11579679e-01f, -7.61325136e-02f, -9.56050772e-03f, 9.36844274e-02f,
  3.25487070e-02f, 3.37694958e-02f, -2.65137237e-02f, 8.41547847e-02f, 6.63409233e-02f, 1.14558935e-02f, -5.23912944e-02f, 3.77668887e-02f, 6.41845316e-02f, 8.57389439e-03f,
  -2.49336846e-03f, -4.69719209e-02f, 8.36358070e-02f, 2.68659694e-03f, -2.81731971e-02f, 6.40372410e-02f, -4.10623439e-02f, 4.35922779e-02f, 4.17738371e-02f, 4.65498343e-02f,
  -6.30365685e-02f, -4.67198566e-02f, 1.98635310e-02f, -7.14352950e-02f, -5.17622940e-02f, -3.31649780e-02f, -5.32893650e-02f, -5.26908264e-02f, 2.66599618e-02f, 9.28930007e-03f,
  -3.54839899e-02f, -3.39179151e-02f, 1.62529703e-02f, -5.48258126e-02f, 3.98255624e-02f, 3.56952101e-02f, -2.35614087e-02f, -2.94781495e-02f, 8.03805888e-03f, 7.52332062e-03f,
  -8.28947648e-02f, 5.50561547e-02f, -4.75255251e-02f, -1.21439323e-02f, 3.45222540e-02f, -1.55248530e-02f, -6.73310161e-02f, 1.92198921e-02f, 2.10540108e-02f, -1.03441484e-01f,
  -5.00146300e-02f, 9.64122415e-02f, 1.27093375e-01f, 7.17465803e-02f, 5.92154600e-02f, 1.37691110e-01f, 7.08504319e-02f, 3.93125862e-02f, 1.24621853e-01f, 2.21044570e-02f,
  -3.11646670e-01f, 7.25128725e-02f, -1.41613726e-02f, -1.28846645e-01f, -9.88704935e-02f, -2.25698669e-02f, 7.88917542e-02f, -3.88749912e-02f, -1.19923279e-01f, 1.08013973e-01f,
  -6.10672496e-02f, -2.64053307e-02f, -3.47364438e-03f, -1.26664624e-01f, -2.50341874e-02f, 1.02803841e-01f, 7.83957541e-02f, -1.83374390e-01f, -1.45251587e-01f, -1.56403601e-01f,
  -1.44114122e-01f, -1.54053852e-01f, -1.60017058e-01f, -1.71262309e-01f, -7.55066648e-02f, -4.66339290e-02f, -7.06164613e-02f, 1.71050336e-02f, 3.48521955e-02f, 1.85721163e-02f,
  1.21093810e-01f, -1.38040155e-01f, -1.62912626e-02f, -3.30017284e-02f, 5.70686981e-02f, -5.41164838e-02f, -2.97353175e-02f, -6.74661845e-02f, 3.50101641e-03f, -1.33197084e-02f,
  -1.19442150e-01f, -6.52060956e-02f, 1.63226910e-02f, 1.69302691e-02f, -2.45617088e-02f, -1.11292131e-01f, 4.45969105e-02f, -4.20679785e-02f, 2.10413039e-02f, 8.07409063e-02f,
  6.08508512e-02f, -7.30006248e-02f, 7.06797764e-02f, -4.62144054e-02f, -7.29183480e-02f, -2.16174201e-04f, 6.74208924e-02f, -1.37768146e-02f, 7.52967894e-02f, 7.95853660e-02f,
  -6.41853958e-02f, 1.14020715e-02f, -6.72701523e-02f, 5.59860431e-02f, 2.93950159e-02f, -4.75018695e-02f, 3.24305706e-03f, 4.18040492e-02f, 4.32039984e-03f, -2.76129320e-02f,
  6.76204339e-02f, 1.19877093e-01f, 4.35179956e-02f, 1.00716008e-02f, -4.56767855e-03f, -7.32957721e-02f, 6.01615496e-02f, -5.37091456e-02f, 1.01236582e-01f, -1.19345756e-02f,
  -8.97574499e-02f, -6.79823160e-02f, 1.62146869e-04f, -3.92201245e-02f, -5.56328595e-02f, 1.14064692e-02f, 5.71764857e-02f, 5.82458265e-02f, 5.50746880e-02f, -4.80968319e-03f,
  1.21852279e-01f, -1.27173096e-01f, 4.21563275e-02f, -9.50277373e-02f, 5.87298572e-02f, 7.76964873e-02f, -4.83205356e-02f, -8.26693103e-02f, -8.24934095e-02f, -3.06100994e-02f,
  1.72439609e-02f, 5.50013296e-02f, 7.38596842e-02f, 1.38400886e-02f, -5.08060418e-02f, 6.79520592e-02f, -1.96224656e-02f, 7.12672025e-02f, 1.15845706e-02f, 2.83666723e-03f,
  9.80859324e-02f, -1.54775269e-02f, -6.42726570e-02f, 1.01532228e-01f, 7.75830969e-02f, 1.26268882e-02f, 1.19433016e-01f, 9.14040655e-02f, 1.02425128e-01f, 1.16446398e-01f,
  -1.13711976e-01f, -6.39586747e-02f, -1.10515267e-01f, 4.60111797e-02f, -9.37016010e-02f, -1.36406243e-01f, 1.06975464e-02f, 5.35799712e-02f, 5.27952574e-02f, -4.36435752e-02f,
  5.30351810e-02f, 9.67288837e-02f, 8.88836235e-02f, 6.78619891e-02f, 2.19306406e-02f, 6.97134435e-02f, -8.16678256e-02f, -1.10356726e-01f, -5.82857281e-02f, -2.14301907e-02f,
  -4.00172062e-02f, -2.30471827e-02f, 1.13559440e-02f, -9.69870854e-03f, 8.97257030e-02f, 8.39139521e-02f, 5.15855514e-02f, -2.71478314e-02f, -8.59237313e-02f, -1.83004346e-02f,
  -1.19214058e-01f, -4.47788602e-03f, 3.17588560e-02f, -8.29978846e-03f, 1.82100162e-02f, 1.79297961e-02f, 2.68339273e-02f, 1.08529697e-03f, -4.65005636e-02f, 1.22926950e-01f,
  5.60668893e-02f, 5.93678504e-02f, -7.43903741e-02f, 3.55733279e-03f, 1.06593985e-02f, 6.67985827e-02f, 1.21516228e-01f, 5.60609140e-02f, -4.60409746e-02f, -5.49459755e-02f,
  1.04189195e-01f, -7.76929855e-02f, -6.45170286e-02f, 4.85442318e-02f, -7.46158436e-02f, 4.87722158e-02f, -2.10130569e-02f, -2.97138859e-02f, 3.43540572e-02f, 3.37741338e-02f,
  -6.84795231e-02f, -5.57517372e-02f, -6.49761632e-02f, 3.23434286e-02f, -2.75923330e-02f, 7.66390637e-02f, -3.18834409e-02f, 4.39327620e-02f, -1.10279880e-01f, 3.64885032e-02f,
  2.44526770e-02f, -2.68195160e-02f, -1.12522155e-01f, 6.86026588e-02f, 6.78524002e-03f, 4.38266620e-02f, -6.71177078e-03f, -6.61659986e-02f, -2.43607592e-02f, 4.30327132e-02f,
  9.33174882e-03f, -1.45740183e-02f, 1.06632702e-01f, -3.15644667e-02f, -1.05388567e-01f, -7.57081807e-02f, -7.35256746e-02f, -5.42571594e-04f, -3.42472158e-02f, 8.60436037e-02f,
  1.63809195e-01f, -1.05588324e-01f, 4.15322557e-02f, -3.88761088e-02f, -1.07033856e-01f, 3.88672836e-02f, -1.13738598e-02f, 2.49329396e-03f, -3.82072292e-02f, 3.77953500e-02f,
  5.57406507e-02f, 2.98559549e-03f, 4.36800867e-02f, 8.53994687e-04f, 8.12909752e-02f, 7.57364230e-03f, 4.77120690e-02f, 1.20978674e-03f, -5.99457026e-02f, 7.35002607e-02f,
  1.51118100e-01f, -2.11149696e-02f, 9.12500173e-02f, -2.47719046e-02f, -6.39058277e-02f, -4.85682450e-02f, -2.57217488e-03f, 3.45396325e-02f, -2.61362791e-02f, 1.84068322e-01f,
  7.76377544e-02f, 8.28493088e-02f, 6.74781278e-02f, -3.39773968e-02f, 4.08025645e-02f, -1.74596488e-01f, -3.06825757e-01f, -2.78480411e-01f, -1.18644871e-02f, 1.34423021e-02f,
  -2.72279046e-02f, 1.18723646e-01f, -2.58922037e-02f, -5.85216247e-02f, -6.67280033e-02f, -1.04179800e-01f, 2.05451846e-02f, 1.41685288e-02f, -3.28543223e-02f, 5.70377195e-03f,
  8.62757638e-02f, 6.63249418e-02f, 6.87961951e-02f, 1.84616800e-02f, 1.17552385e-01f, 1.42974436e-01f, 1.85847357e-02f, 6.89850599e-02f, 1.35543004e-01f, 1.83884576e-01f,
  8.16821530e-02f, 7.19205365e-02f, -8.12432393e-02f, 3.57842818e-02f, -1.80918965e-02f, 3.69355455e-02f, 2.81607937e-02f, -5.34309857e-02f, -1.65574427e-03f, -2.63155960e-02f,
  -2.10017897e-02f, 9.46856439e-02f, 8.77684802e-02f, -2.70145647e-02f, -1.00944214e-01f, -8.22216123e-02f, -6.64557666e-02f, -5.44006564e-02f, -1.11399315e-01f, 4.90513965e-02f,
  7.68111870e-02f, 6.36734590e-02f, 6.21383153e-02f, -1.04444191e-01f, -1.05945177e-01f, 8.28216150e-02f, 5.16929962e-02f, 2.19819434e-02f, 4.49485034e-02f, -4.15402986e-02f,
  1.11983702e-01f, -2.36521270e-02f, 2.60889269e-02f, 4.36193384e-02f, -3.09647676e-02f, 6.10108636e-02f, 9.80292410e-02f, 2.22610533e-02f, -6.66839331e-02f, 2.50490997e-02f,
  -5.88533692e-02f, -3.79683226e-02f, -2.08692718e-02f, 8.84156078e-02f, 1.03144139e-01f, 5.97122684e-02f, 5.57607561e-02f, -8.01500026e-03f, 7.08820075e-02f, 6.34977520e-02f,
  -6.86462447e-02f, 3.41526195e-02f, -1.46748694e-02f, -7.24421218e-02f, 9.20306146e-02f, 7.23971874e-02f, 4.41067033e-02f, -5.32499962e-02f, -5.58749251e-02f, 4.01673466e-02f,
  -1.47982940e-01f, -7.59335831e-02f, 3.24298330e-02f, -6.73079714e-02f, 1.11115677e-02f, -1.60102230e-02f, 9.95172262e-02f, -6.11159168e-02f, -2.56810542e-02f, -2.86724567e-02f,
  -1.23242587e-02f, -8.15313309e-02f, -6.19167946e-02f, 2.16632169e-02f, -8.28150213e-02f, -6.03270605e-02f, 1.84178464e-02f, -7.75895789e-02f, 2.02906244e-02f, -9.28209722e-02f,
  -9.73068848e-02f, -1.42198578e-01f, -1.27732232e-01f, -7.68260434e-02f, -5.43177612e-02f, -6.84284270e-02f, -5.56341447e-02f, 2.62781400e-02f, -1.53235793e-01f, -7.72532672e-02f,
  -1.11876279e-02f, 2.28784546e-01f, 2.65446603e-01f, -1.17078818e-01f, 3.52492370e-02f, 9.90020111e-02f, 2.24047989e-01f, -3.45871039e-02f, -1.85162574e-01f, 5.62416390e-02f,
  1.29158854e-01f, -1.71213984e-01f, -1.61533594e-01f, -1.35323197e-01f, 5.80238774e-02f, -7.72916526e-02f, -3.09494361e-02f, -7.29858279e-02f, 4.05121967e-02f, 3.55447121e-02f,
  -1.37582775e-02f, 5.54424524e-03f, 1.03573702e-01f, -8.40459540e-02f, -1.10209204e-01f, -1.05832867e-01f, -1.42158149e-02f, 3.94522324e-02f, 8.44072327e-02f, -1.60791073e-02f,
  -2.78546680e-02f, 1.94319382e-01f, -4.17389125e-02f, -4.61508557e-02f, 5.82172275e-02f, 1.74644135e-03f, 4.80659269e-02f, -2.58619115e-02f, 5.71804978e-02f, 1.77011043e-02f,
  1.05879329e-01f, 4.33744565e-02f, 1.55378282e-02f, -6.28472045e-02f, 3.06639709e-02f, -9.21529904e-02f, 1.01854522e-02f, -1.93763506e-02f, -4.62477515e-03f, 2.88609583e-02f,
  -2.01613847e-02f, 9.89123434e-02f, 4.25583795e-02f, 6.09709844e-02f, -4.73962575e-02f, 6.27994984e-02f, 6.89354688e-02f, -2.76098698e-02f, 1.38784852e-02f, -1.71248585e-01f,
  2.70733070e-02f, -8.07961151e-02f, 6.34478219e-03f, 5.37052602e-02f, -2.99617629e-02f, 4.20429707e-02f, -4.49908674e-02f, 2.53396146e-02f, 3.57923545e-02f, 4.98082340e-02f,
  4.08520997e-02f, 8.05796683e-02f, 5.57238562e-03f, -1.49880126e-02f, 2.40412541e-02f, 8.60463455e-02f, 3.08066029e-02f, 4.85326443e-03f, 9.32707787e-02f, -4.67370450e-03f,
  2.68873060e-04f, 3.44519317e-02f, -3.38800089e-03f, -4.34587449e-02f, 6.33656159e-02f, -2.79470049e-02f, 3.93213294e-02f, -5.08847460e-02f, 2.81072571e-03f, -3.35065536e-02f,
  -1.50322959e-01f, 2.44910449e-01f, -1.66941106e-01f, -1.04822077e-01f, -3.13773490e-02f, 3.57189253e-02f, -7.70448372e-02f, -1.97573956e-02f, -4.45637899e-03f, -2.86546778e-02f,
  5.64062111e-02f, -5.68211488e-02f, 9.97811854e-02f, 8.00228911e-04f, 5.08228093e-02f, 7.88409729e-04f, 6.72088563e-02f, -3.02083939e-02f, -8.82345363e-02f, -3.13596916e-04f,
  3.35485525e-02f, 2.71829907e-02f, -1.07599333e-01f, 9.34292004e-03f, 9.58506297e-03f, -1.49876192e-01f, -1.02595530e-01f, -8.69667605e-02f, -7.36612966e-03f, -1.50926113e-01f,
  -3.33635211e-02f, -1.11325853e-01f, -1.23871006e-01f, -1.08377501e-01f, -1.08254611e-01f, -1.04180187e-01f, -1.94692269e-01f, -5.27261533e-02f, -5.78504093e-02f, -8.45712721e-02f,
  -6.77539855e-02f, -3.91467512e-02f, -6.63297856e-03f, -1.76512189e-02f, -1.03975728e-01f, -2.58931238e-02f, -1.65925577e-01f, -2.05389693e-01f, -1.83054060e-01f, -1.71289444e-01f,
  -2.64220238e-02f, -1.75970532e-02f, -9.13469344e-02f, -1.32336318e-01f, 4.38604355e-02f, 6.69464096e-02f, -8.34146813e-02f, -4.77182977e-02f, -7.97345340e-02f, 6.68590516e-02f,
  2.20436409e-01f, 5.62891457e-03f, -6.29890263e-02f, 2.84408070e-02f, -5.81767634e-02f, 4.57889438e-02f, -9.45802964e-03f, 2.32509822e-02f, -6.58871084e-02f, -1.72055289e-02f,
  3.01946662e-02f, -3.75840925e-02f, -3.63225024e-03f, -1.16833383e-02f, -3.78723629e-02f, -9.77992266e-02f, -6.70259492e-03f, -6.73638955e-02f, -4.75639179e-02f, -1.13737337e-01f,
  1.09955831e-03f, -1.57943159e-01f, -1.86292343e-02f, 2.07467414e-02f, -2.33267341e-02f, -3.29938270e-02f, 7.53581300e-02f, -1.67135410e-02f, 3.56651433e-02f, 1.18381277e-01f,
  -4.19126526e-02f, 7.22741485e-02f, 5.88519387e-02f, -4.80861291e-02f, -2.51540192e-03f, 5.50888181e-02f, -3.39497104e-02f, -3.74509133e-02f, -4.35429215e-02f, 4.05255146e-02f,
  9.01074633e-02f, -8.52172300e-02f, 9.60406363e-02f, -3.38350087e-02f, -4.67651449e-02f, 5.54646961e-02f, -7.02507943e-02f, 2.57450920e-02f, -5.98324789e-03f, -6.38052151e-02f,
  -2.16582641e-02f, 1.50093390e-02f, -3.76226567e-02f, 7.13879019e-02f, -9.34084412e-03f, -4.17581126e-02f, -7.66109824e-02f, 4.76237386e-03f, 8.77051726e-02f, -8.63445476e-02f,
  2.62657642e-01f, -1.51698980e-02f, -7.17914756e-03f, 2.50719022e-02f, -7.03648627e-02f, -5.04093356e-02f, 4.64846529e-02f, 2.52632219e-02f, -5.43591045e-02f, -4.58271019e-02f,
  1.04030939e-02f, -5.05949110e-02f, 5.91297932e-02f, -6.11575646e-03f, -8.40645283e-02f, 6.88487962e-02f, -1.10510722e-01f, 3.21596526e-02f, -7.29414076e-02f, -3.02033089e-02f,
  -1.47557333e-01f, 5.17816842e-02f, 1.13068111e-01f, 4.82697878e-03f, 1.94525737e-02f, 1.01725370e-01f, 9.06144828e-02f, 9.94184464e-02f, -3.65714617e-02f, -1.31606255e-02f,
  -1.11256436e-01f, 1.94646865e-01f, 2.24436611e-01f, 8.97949859e-02f, 8.34285691e-02f, 1.22025140e-01f, 2.58052349e-01f, 1.18120737e-01f, 4.45068516e-02f, 2.53078844e-02f,
  9.28415507e-02f, -9.68246460e-02f, -1.49935827e-01f, -1.06845059e-01f, -7.62020648e-02f, 1.65615857e-01f, 1.22305870e-01f, -7.80867413e-02f, -1.96697321e-02f, -6.79001212e-02f,
  -9.49923173e-02f, -8.44591111e-02f, -1.19740061e-01f, -8.18744376e-02f, 8.75351485e-03f, -9.65206847e-02f, -1.59435514e-02f, 1.64256189e-02f, 6.50881156e-02f, -1.15713067e-01f,
  -1.60943106e-01f, 6.32260507e-03f, -1.36811078e-01f, -5.54718263e-02f, -1.93730947e-02f, -1.84616614e-02f, -5.34610003e-02f, 3.83132063e-02f, -1.40168052e-02f, -6.34400025e-02f,
  7.38250315e-02f, 7.27877673e-03f, -3.20294835e-02f, 1.87565032e-02f, -8.37962329e-02f, -4.24938202e-02f, 6.53590774e-03f, -8.26375410e-02f, -1.07992537e-01f, -7.61005878e-02f,
  -5.40873148e-02f, 7.67121017e-02f, 5.04790731e-02f, -4.04714942e-02f, -2.84065325e-02f, -1.08072340e-01f, 3.25164422e-02f, -7.30103552e-02f, -6.55419901e-02f, -1.77001864e-01f,
  -3.98764238e-02f, 1.46272620e-02f, -2.17843466e-02f, -6.26203567e-02f, 4.26999666e-02f, -1.48250004e-02f, -5.18029276e-03f, -7.29162470e-02f, 9.48833972e-02f, 3.07609588e-02f,
  4.01421972e-02f, -4.60356884e-02f, -8.82703215e-02f, 1.84201598e-02f, -3.76350135e-02f, 9.26510468e-02f, 2.07563490e-02f, 4.31638770e-02f, 4.80374768e-02f, -6.73432872e-02f,
  1.36771910e-02f, 1.18980845e-02f, -4.20662574e-02f, -8.26394558e-02f, 2.58291326e-03f, -5.71969971e-02f, 2.18226463e-02f, 3.31353433e-02f, -8.57853144e-02f, 3.23510729e-02f,
  -7.90429935e-02f, 1.11357890e-01f, -1.28781378e-01f, 7.69881718e-03f, 7.99990967e-02f, 5.16992249e-03f, 8.62298459e-02f, -1.96771100e-02f, 6.84132501e-02f, -8.36475939e-02f,
  2.02389546e-02f, -2.57386155e-02f, -2.91546099e-02f, -8.55035782e-02f, -5.12487814e-02f, -2.44783349e-02f, 8.93503800e-02f, 6.76566176e-03f, 6.02717586e-02f, 2.14931043e-03f,
  -6.16154931e-02f, -4.79044802e-02f, -1.21130729e-02f, 6.64613098e-02f, -6.71818480e-02f, 1.71742141e-02f, -4.04621363e-02f, 4.12858501e-02f, -9.33256149e-02f, -7.61368871e-02f,
  2.00438350e-01f, -1.04096763e-01f, -3.51582229e-01f, 2.11008545e-02f, -1.23159781e-01f, -2.10308209e-01f, -6.99334815e-02f, 8.36085528e-02f, -9.73828789e-03f, -1.38993561e-01f,
  -5.26433922e-02f, -5.20668831e-03f, 4.63406462e-03f, -1.00749783e-01f, -9.31428298e-02f, -2.03983888e-01f, -2.54574209e-01f, -1.02361232e-01f, -8.88332799e-02f, 6.25403374e-02f,
  -4.47658869e-03f, -2.21745926e-03f, -1.40595427e-02f, 5.47503047e-02f, -1.14263766e-01f, -5.15666008e-02f, -2.46216834e-01f, -1.94299757e-01f, -1.64704844e-01f, -2.68109143e-01f,
  -2.68316388e-01f, 3.47431824e-02f, 5.67122139e-02f, 3.80286872e-02f, -3.60257924e-02f, -4.79822345e-02f, -4.84335534e-02f, -6.95446804e-02f, 3.75794955e-02f, -9.46294665e-02f,
  4.10618680e-03f, -5.74891567e-02f, 9.95718874e-03f, -4.27030250e-02f, -1.36134382e-02f, 6.94614574e-02f, -2.18319683e-03f, 1.11600645e-02f, 1.44694075e-02f, 2.39340067e-02f,
  -1.52246258e-03f, 6.18893933e-03f, 6.45404682e-03f, 4.72166896e-04f, 1.02786925e-02f, -8.90450105e-02f, -2.94916499e-02f, 5.21967858e-02f, -3.91712189e-02f, -1.18813783e-01f,
  -6.75239880e-03f, 4.35109772e-02f, -4.55769822e-02f, -4.44195680e-02f, 6.48381189e-02f, 2.50703916e-02f, 5.21725118e-02f, 3.93809266e-02f, -1.73474327e-02f, 6.37151115e-03f,
  -8.04525688e-02f, 3.87501507e-03f, -9.02481144e-04f, 5.17957322e-02f, -2.77034640e-02f, -6.81234896e-02f, -3.54907336e-03f, 1.43354386e-02f, 6.67970255e-02f, -3.00470218e-02f,
  -3.65737192e-02f, 6.03275336e-02f, -6.24417514e-02f, 2.52054911e-02f, -3.64881083e-02f, -1.02700554e-01f, 3.63786519e-02f, 2.57945023e-02f, -8.64322204e-03f, 3.50075103e-02f,
  3.24985497e-02f, -6.72833994e-02f, 2.86083436e-04f, 9.49995890e-02f, -6.40208572e-02f, 3.21109742e-02f, 4.70177364e-03f, 1.68733280e-02f, 6.55342489e-02f, -6.06593490e-02f,
  -1.97186992e-02f, 5.09090275e-02f, -1.11097194e-01f, -2.52320133e-02f, -1.87618081e-02f, 3.40863056e-02f, 2.50710137e-02f, -6.01628842e-03f, -4.14471775e-02f, -5.23058958e-02f,
  1.43212834e-02f, -3.67329642e-02f, 3.48876193e-02f, 6.68954328e-02f, 3.62161808e-02f, 5.28678149e-02f, -8.30956027e-02f, 5.35993278e-02f, -9.47923288e-02f, 1.31964171e-02f,
  -6.91137314e-02f, -4.71803360e-02f, -8.59734491e-02f, 9.55154374e-02f, -1.21298973e-02f, -1.73096582e-01f, -4.38696183e-02f, -1.50269866e-01f, -1.60715617e-02f, -7.44677186e-02f,
  -7.65859559e-02f, 3.72525789e-02f, -1.05606832e-01f, -1.07229128e-01f, -1.39561445e-01f, -6.11193106e-02f, -1.37863442e-01f, -9.89000797e-02f, -3.21012847e-02f, -1.22229666e-01f,
  -5.07681519e-02f, 4.08448167e-02f, 6.11548051e-02f, 2.70619579e-02f, 9.49064363e-03f, -2.42845118e-02f, 3.79041731e-02f, 2.61580143e-02f, -1.02585822e-01f, -1.34725913e-01f,
  -1.71145946e-01f, -4.89830114e-02f, 1.58269573e-02f, -4.77049761e-02f, -6.50244672e-03f, 3.51707228e-02f, -6.66461810e-02f, -7.19641745e-02f, 9.11472589e-02f, 1.30193634e-02f,
  3.42997313e-02f, -2.06472408e-02f, -5.70690148e-02f, -2.74712574e-02f, 4.05076146e-02f, -7.51013011e-02f, 7.82731995e-02f, -7.99846090e-03f, -4.44397982e-03f, 2.90944520e-02f,
  2.08176579e-02f, -4.52085398e-02f, -8.99640843e-02f, 8.63480289e-03f, -3.28909978e-02f, -2.30514091e-02f, 2.63114255e-02f, -7.83461332e-02f, -1.32536411e-01f, -9.80220884e-02f,
  8.07228759e-02f, 1.73558351e-02f, 1.10105602e-02f, 1.48408953e-02f, 2.26005055e-02f, 4.44220100e-03f, -6.37749061e-02f, -7.78637826e-02f, 4.72143590e-02f, -5.38137518e-02f,
  -8.98537710e-02f, -6.45293966e-02f, -6.61076233e-02f, -5.17340042e-02f, -5.23986518e-02f, -2.69237161e-02f, -3.22441459e-02f, -1.21876383e-02f, -3.98176461e-02f, 2.95104291e-02f,
  -5.26000513e-03f, 1.25894668e-02f, -1.33316070e-02f, 8.78679082e-02f, 3.75576094e-02f, 2.08091941e-02f, 6.73643053e-02f, 6.94942549e-02f, -3.91377881e-02f, 6.17378131e-02f,
  3.12624350e-02f, 9.31578409e-03f, -1.23861857e-01f, 5.07704876e-02f, 6.34175772e-03f, 8.02293718e-02f, -5.14958464e-02f, -7.85217807e-02f, 6.22013658e-02f, -4.62870710e-02f,
  3.45448367e-02f, -5.79155460e-02f, 3.06424834e-02f, 2.14028470e-02f, -7.59180188e-02f, 5.52859604e-02f, 5.51061258e-02f, 5.18737920e-02f, -7.07838610e-02f, 4.38762130e-03f,
  -4.48407270e-02f, -7.43675083e-02f, -3.74157242e-02f, -9.80592892e-02f, -1.05050001e-02f, -9.48832855e-02f, 2.28501745e-02f, -9.98365954e-02f, -1.53342709e-01f, -1.41509185e-02f,
  -4.76249129e-01f, 8.76486152e-02f, 1.87611207e-02f, -1.02668986e-01f, -5.85082881e-02f, 1.20382234e-01f, 1.02560073e-01f, -7.65580032e-03f, 1.07188951e-02f, -8.80193489e-04f,
  -2.99410224e-02f, -1.00437000e-01f, 5.72408475e-02f, 7.40280971e-02f, 6.12929650e-02f, 2.18186617e-01f, 9.19951797e-02f, -1.46461148e-02f, -2.28510835e-04f, -6.96441457e-02f,
  6.59882370e-03f, -1.77200481e-01f, -2.84509361e-01f, -1.35740668e-01f, 8.03970620e-02f, 4.31318171e-02f, -1.11189112e-02f, -7.47496635e-02f, 1.40979826e-01f, 8.82024914e-02f,
  3.08563430e-02f, -2.31072903e-01f, -7.13542998e-02f, -1.37445956e-01f, -2.81884223e-02f, -2.27085557e-02f, 3.77560854e-02f, -7.57209782e-04f, -2.77097709e-02f, 6.35374486e-02f,
  1.03229247e-02f, -1.06637396e-01f, -4.66328599e-02f, 6.27276450e-02f, 1.23789639e-03f, -3.52790840e-02f, -2.68148389e-02f, -9.97114107e-02f, -8.26192647e-03f, -8.14674273e-02f,
  -3.18791643e-02f, 1.38357366e-02f, -6.58502579e-02f, 6.67986199e-02f, 2.26971768e-02f, -3.20488214e-02f, -7.47671351e-02f, -3.52636613e-02f, -3.14769447e-02f, -1.49724260e-01f,
  6.00197129e-02f, -4.36622128e-02f, -3.13495994e-02f, -3.68344150e-02f, -4.36764397e-02f, 6.03407957e-02f, 7.43621960e-02f, 4.64836620e-02f, -1.67407021e-02f, -4.31024805e-02f,
  8.77530314e-03f, 2.83535905e-02f, -4.39159796e-02f, 1.81579422e-02f, -1.70226805e-02f, -3.02170850e-02f, 5.85657768e-02f, -3.38880196e-02f, -4.67134863e-02f, -5.62124886e-02f,
  -5.95487282e-02f, 8.58803689e-02f, -8.94705206e-02f, 7.39856511e-02f, -6.59605265e-02f, 6.48427084e-02f, -6.89736009e-02f, 5.07506691e-02f, -1.16615463e-02f, -3.48808318e-02f,
  7.19152838e-02f, -3.39493863e-02f, -7.59765366e-03f, -8.13026205e-02f, -4.44116928e-02f, 2.03323327e-02f, 5.48513373e-03f, -6.68779388e-02f, 5.33944890e-02f, 1.90869346e-03f,
  -6.83602989e-02f, -3.93774658e-02f, -5.29292300e-02f, -4.58188616e-02f, -6.74732379e-04f, 2.34858021e-02f, -3.30165960e-02f, -1.65794902e-02f, 3.18409875e-02f, 2.07968224e-02f,
  1.16296411e-02f, -1.06395774e-01f, -9.94643494e-02f, -2.57052705e-02f, 2.96194162e-02f, 2.32437793e-02f, 5.59331067e-02f, -1.47366908e-03f, -6.49831519e-02f, -9.49819162e-02f,
  -2.88384501e-02f, -7.83979893e-02f, -1.72907382e-01f, -1.15137778e-01f, -8.33318830e-02f, -4.91482019e-02f, -8.38722959e-02f, -1.21070474e-01f, 5.94984181e-03f, -5.82916513e-02f,
  7.71294385e-02f, 9.48295221e-02f, 3.50488611e-02f, -1.23744262e-02f, 2.88550612e-02f, -8.60146061e-02f, -1.64849073e-01f, -9.85160563e-03f, 3.56000736e-02f, -1.42963920e-02f,
  3.88574861e-02f, 9.97084901e-02f, 1.16898790e-02f, -4.01221998e-02f, 2.78665740e-02f, 6.76390827e-02f, -7.47598186e-02f, 5.89858778e-02f, -9.66226831e-02f, -5.65894395e-02f,
  8.82049799e-02f, -7.23564178e-02f, 8.05538446e-02f, 9.12404805e-02f, 3.03244591e-02f, -1.70891657e-02f, 7.83707947e-02f, 7.57101402e-02f, 5.24880663e-02f, -4.76511233e-02f,
  -7.97778517e-02f, -5.23737185e-02f, 6.81670383e-02f, 9.13401097e-02f, -5.47046326e-02f, -3.65440361e-02f, -7.56958276e-02f, 5.94912022e-02f, -5.57728112e-04f, -2.19231918e-02f,
  8.07982869e-03f, 2.17704903e-02f, -3.50377988e-03f, -4.15615924e-02f, -6.44240435e-03f, -3.14925760e-02f, 4.42634784e-02f, 6.31362796e-02f, -8.19617696e-03f, -1.80144645e-02f,
  -8.81658196e-02f, -3.90866511e-02f, 2.91071506e-03f, 8.16359520e-02f, -5.32727800e-02f, 4.18591220e-03f, 5.14931679e-02f, -7.26922303e-02f, 1.06905419e-02f, 7.57113546e-02f,
  6.18131906e-02f, -2.68810969e-02f, -7.15407729e-02f, -3.22532404e-04f, 7.36336224e-04f, 6.24244884e-02f, 5.17099947e-02f, 2.07637660e-02f, -4.72942889e-02f, -8.21238309e-02f,
  4.59086783e-02f, -5.39866835e-02f, -2.38624588e-02f, -2.32660603e-02f, 8.87673795e-02f, 3.28694545e-02f, 2.53743865e-03f, 2.28590500e-02f, -7.39615411e-02f, -5.96311539e-02f,
  1.89139292e-01f, -1.13977946e-01f, 2.43666898e-02f, 3.11586596e-02f, -1.10849380e-01f, 2.74372865e-02f, 9.73904058e-02f, 6.79511800e-02f, 8.06103945e-02f, -5.37985191e-02f,
  -2.94317696e-02f, 5.72358407e-02f, -2.87186652e-02f, 5.92247993e-02f, -1.78393116e-03f, -6.62682811e-03f, 4.83961590e-02f, 4.54345681e-02f, -6.99704885e-02f, -4.03450914e-02f,
  2.25295909e-02f, -3.08004189e-02f, 7.16865584e-02f, -6.55111894e-02f, 1.59261860e-02f, -6.02487959e-02f, 9.42979846e-03f, 7.55114574e-03f, 6.25077561e-02f, -1.72076877e-02f,
  3.60575095e-02f, -5.70294112e-02f, 7.17069805e-02f, -2.24922388e-03f, 9.36344825e-03f, -1.90894961e-01f, -2.12180510e-01f, -1.43521100e-01f, -2.49130577e-02f, -3.31325531e-02f,
  3.20843384e-02f, 4.53791767e-03f, 7.87128061e-02f, -9.40524340e-02f, -1.05108768e-01f, -8.56925100e-02f, -9.47807133e-02f, -1.50883213e-01f, -1.92862049e-01f, -1.68753028e-01f,
  9.49653052e-03f, -3.34026814e-02f, 4.13451530e-02f, 3.76878195e-02f, -1.30354539e-02f, 9.68639404e-02f, -5.40765701e-03f, 5.86978644e-02f, -6.38059080e-02f, 1.54711872e-01f,
  -3.10585368e-03f, -3.84573750e-02f, -3.42878923e-02f, 5.87475263e-02f, 5.34677468e-02f, -1.39005920e-02f, -5.49270250e-02f, 4.91545163e-02f, -5.73108811e-03f, 6.65586889e-02f,
  8.24557766e-02f, 2.52519976e-02f, 6.99798912e-02f, -7.32727498e-02f, 2.61539314e-02f, -1.60403717e-02f, -7.84630552e-02f, -9.01428834e-02f, -4.41576727e-02f, -8.90571252e-02f,
  -1.49985841e-02f, 2.67652851e-02f, -7.12383986e-02f, -1.18898034e-01f, -4.51131426e-02f, 1.14092985e-02f, -3.54377963e-02f, 3.84736992e-02f, -1.50299883e-02f, -7.91361332e-02f,
  -2.85638701e-02f, 5.93441129e-02f, -2.39195279e-03f, 3.61920856e-02f, -8.18002131e-03f, -1.27324229e-02f, 4.68518399e-03f, -6.17053034e-03f, -5.99012012e-03f, -4.00641821e-02f,
  -4.63813096e-02f, -7.49850944e-02f, -8.11622888e-02f, -4.97360304e-02f, -9.70656611e-03f, 5.25746793e-02f, -5.44817597e-02f, -9.48143005e-02f, -4.55596596e-02f, 5.64116165e-02f,
  -5.08763827e-02f, -1.25749328e-03f, -1.14462459e-02f, 3.71637195e-02f, 3.69046032e-02f, -1.00221159e-02f, 7.36083463e-02f, -3.33661437e-02f, 9.06330720e-02f, 7.06839934e-02f,
  1.22856349e-01f, 3.49817015e-02f, 6.92682341e-02f, -1.15075074e-01f, 1.14400163e-01f, -4.92960699e-02f, -3.32234055e-02f, -8.64228979e-02f, 1.05906911e-01f, -4.41082641e-02f,
  -7.82823116e-02f, -2.31566038e-02f, -5.86909279e-02f, -2.39569508e-02f, -3.03702410e-02f, -5.21622673e-02f, 2.68924255e-02f, -4.50977422e-02f, 3.11207660e-02f, -2.21003927e-02f,
  -7.95685351e-02f, -3.76946926e-02f, 4.91289087e-02f, -3.42475213e-02f, -6.94718435e-02f, -4.14249673e-03f, 6.13077655e-02f, -7.80081972e-02f, -8.96195322e-02f, -6.55786470e-02f,
  -1.12280846e-02f, -3.14864255e-02f, 1.61008388e-01f, 4.49948311e-02f, -1.08529627e-01f, -1.50642857e-01f, -2.51279026e-01f, -7.62112066e-02f, 2.20820084e-02f, -6.10726466e-03f,
  -3.05510145e-02f, -1.55430034e-01f, -4.83450517e-02f, 2.29031537e-02f, -9.68366340e-02f, -5.24215214e-02f, 7.22394660e-02f, 9.88030136e-02f, 1.60316862e-02f, -1.16946198e-01f,
  -2.65866052e-02f, -8.08008313e-02f, -6.08516894e-02f, 2.49627675e-03f, -4.49001156e-02f, -9.51741412e-02f, -2.78283432e-02f, -3.89302485e-02f, 4.61401865e-02f, -3.77782397e-02f,
  6.44022971e-03f, -4.22444567e-02f, -7.37723149e-03f, -5.74545562e-02f, 5.03146462e-03f, 1.74035095e-02f, -1.33524761e-01f, 3.05528603e-02f, -6.03918023e-02f, -3.07193585e-03f,
  -3.58916959e-03f, -3.62274908e-02f, 2.23222727e-04f, 2.22914424e-02f, 2.33713351e-02f, 5.40202148e-02f, -2.73741968e-03f, 1.43802404e-01f, -5.34305684e-02f, 5.94381765e-02f,
  2.49176454e-02f, -3.16125005e-02f, -3.05451956e-02f, 2.54530869e-02f, 5.35249664e-03f, 3.51415463e-02f, -9.86489840e-03f, 1.51189417e-02f, -2.99273729e-02f, -1.46681353e-01f,
  7.27221817e-02f, -5.85103668e-02f, 5.04490435e-02f, 5.04536070e-02f, -4.54906262e-02f, -4.73220535e-02f, 8.04170519e-02f, -3.56450700e-03f, -4.37384099e-02f, 3.97342443e-02f,
  -3.06847785e-02f, 3.61539945e-02f, -3.71787399e-02f, 6.78007230e-02f, -3.40577774e-02f, 8.70650262e-02f, 3.35978568e-02f, -5.40538318e-02f, 5.11874538e-03f, 4.68573682e-02f,
  -3.69477109e-03f, 2.13879924e-02f, 2.63290592e-02f, -3.24386880e-02f, 4.60540429e-02f, -4.02712962e-03f, -6.87903985e-02f, -4.26175185e-02f, -6.54894263e-02f, 3.60278450e-02f,
  -2.98158545e-02f, 7.62564018e-02f, -1.33540913e-01f, -7.53632262e-02f, -4.14438061e-02f, -6.18455512e-03f, -2.92824842e-02f, 8.78156796e-02f, 3.91288474e-02f, 1.01308525e-02f,
  -7.12658018e-02f, 1.18763205e-02f, -1.18524760e-01f, -9.12397206e-02f, 2.77963914e-02f, -1.01283394e-01f, -5.45552187e-02f, -3.16948793e-03f, -3.17477360e-02f, -1.00594603e-01f,
  -8.97666588e-02f, -1.50310159e-01f, -2.49189049e-01f, -9.32103768e-02f, -1.37844503e-01f, -1.45449951e-01f, -1.41650468e-01f, -1.47846237e-01f, -8.79771262e-02f, -2.04816803e-01f,
  -6.86988160e-02f, 7.82255977e-02f, -7.83366989e-03f, 4.75243479e-02f, 7.88461342e-02f, 1.21863782e-01f, 3.96349691e-02f, 2.25031555e-01f, 2.22521648e-01f, 1.18815847e-01f,
  1.55184180e-01f, 9.37151238e-02f, 9.97188836e-02f, 2.07452625e-01f, 1.95026577e-01f, 1.96242243e-01f, 1.17170356e-01f, -4.34231609e-02f, 9.64264348e-02f, 6.16116636e-02f,
  8.33083168e-02f, 4.28926535e-02f, -3.47971469e-02f, -1.14108492e-02f, 1.06086940e-01f, 7.33086094e-02f, 9.57300439e-02f, -7.66355470e-02f, -2.38954369e-02f, 2.27112323e-02f,
  -1.42850876e-01f, -1.50433138e-01f, 8.66139382e-02f, 7.13187978e-02f, 7.44035142e-03f, -6.89270869e-02f, -1.01153463e-01f, -2.58279275e-02f, 6.86117075e-03f, 6.62236894e-03f,
  -1.30313225e-02f, -5.59721887e-03f, -5.82234822e-02f, 2.41818335e-02f, 1.27032595e-02f, -3.96862701e-02f, -1.37326252e-02f, 3.89201343e-02f, 1.26553565e-01f, -1.01414118e-02f,
  1.24656156e-01f, -4.29531299e-02f, -1.05907559e-01f, 1.40141509e-02f, 9.79645327e-02f, 5.79701364e-02f, -3.68733779e-02f, 2.95585822e-02f, 6.84626624e-02f, 7.58387556e-04f,
  1.29280761e-02f, -3.78395990e-02f, 5.49996197e-02f, 8.97701681e-02f, 7.90989995e-02f, 2.09661826e-04f, 3.81107181e-02f, -5.09229600e-02f, -7.90947024e-03f, -7.14945123e-02f,
  -3.22600529e-02f, 3.25174071e-02f, -4.01940271e-02f, 1.31699974e-02f, 3.58903259e-02f, -1.07047454e-01f, 3.95061038e-02f, 8.57446156e-03f, 4.20255214e-02f, 2.34385533e-03f,
  4.87862788e-02f, -2.11982373e-02f, -5.51294051e-02f, -1.57385487e-02f, 1.36243012e-02f, -1.52829550e-02f, 5.38491607e-02f, 4.40084487e-02f, -1.05464041e-01f, 1.19090108e-02f,
  1.47037674e-02f, -3.92312147e-02f, 7.17081279e-02f, 8.74952995e-04f, -5.47573604e-02f, -2.04270128e-02f, 1.12023778e-01f, -2.42576711e-02f, -5.26112244e-02f, -7.02548865e-03f,
  -2.69871987e-02f, 2.50372500e-03f, -4.79612723e-02f, -5.06706424e-02f, -1.14348985e-01f, -6.64741769e-02f, 7.62450099e-02f, 2.62841880e-02f, 1.91696621e-02f, 5.81059903e-02f,
  -4.50647582e-04f, -7.72145540e-02f, -1.00986592e-01f, 1.00873791e-01f, -2.78768037e-02f, -3.05512045e-02f, -9.07027796e-02f, -6.67907670e-02f, 9.27623641e-03f, -2.57446542e-02f,
  1.99411921e-02f, -1.56995565e-01f, 1.03305541e-01f, 1.34341344e-02f, -1.40909821e-01f, -1.54608205e-01f, -2.67232567e-01f, -1.79321930e-01f, -1.37469247e-01f, -1.85292989e-01f,
  -1.31195728e-02f, 6.14343137e-02f, 5.16562238e-02f, 1.30365610e-01f, 6.26420826e-02f, -1.74036399e-02f, 3.09906900e-02f, 2.40306288e-01f, 1.05635114e-01f, -1.81576367e-02f,
  -7.66969994e-02f, 2.18778010e-02f, 1.33026719e-01f, 7.06341937e-02f, -1.76527157e-01f, 6.21950347e-03f, 5.57355024e-03f, -8.82827193e-02f, -3.42794359e-02f, -1.52526796e-01f,
  6.52889460e-02f, 1.13269482e-02f, 8.15306827e-02f, 2.57558506e-02f, 1.17671765e-01f, -2.46363576e-03f, -2.37552077e-02f, 4.51839156e-02f, -1.02488138e-02f, -9.84453186e-02f,
  8.87490511e-02f, 6.84337616e-02f, 6.54246658e-02f, -3.81323555e-03f, -6.90120980e-02f, 6.71534911e-02f, 1.46524962e-02f, 6.72067180e-02f, 2.13913862e-02f, -8.40327218e-02f,
  8.14944785e-03f, -1.31022438e-01f, 8.79264921e-02f, -2.75050104e-02f, 1.03448480e-01f, 1.01910174e-01f, 2.52724830e-02f, -7.11799040e-02f, 8.68034288e-02f, -1.52357846e-01f,
  2.43899245e-02f, 7.94671923e-02f, 5.38831577e-02f, -5.06045446e-02f, -3.06163933e-02f, -2.86296513e-02f, 5.79886995e-02f, -6.68159276e-02f, 3.40013504e-02f, -1.52485014e-03f,
  -2.34643146e-02f, -5.97999804e-02f, 4.35687415e-02f, 5.34588657e-02f, 8.76792446e-02f, 1.06490357e-03f, -8.78782757e-03f, -1.78447217e-02f, 5.95228672e-02f, 4.88078594e-02f,
  4.43745218e-02f, -4.49583754e-02f, -6.76175877e-02f, -1.65166054e-02f, -8.44567716e-02f, -3.34622413e-02f, 1.06254313e-02f, 3.15292366e-02f, 5.38986921e-02f, -8.36523622e-02f,
  7.51002580e-02f, 1.84529513e-01f, -7.28094056e-02f, 1.40202474e-02f, -6.59633279e-02f, -1.17204199e-02f, -3.41405049e-02f, 4.71671857e-02f, -8.08599032e-03f, -9.57380235e-02f,
  4.00585048e-02f, 6.75420389e-02f, -6.61346465e-02f, -6.26588017e-02f, 9.29331705e-02f, 6.07064227e-03f, -7.52848312e-02f, -2.90707238e-02f, -4.18655947e-02f, -3.87272090e-02f,
  -5.02491593e-02f, 2.14427356e-02f, 9.40312520e-02f, 7.85674974e-02f, 1.02301757e-03f, 3.28232571e-02f, -3.34417447e-02f, 4.85471338e-02f, 1.13406852e-01f, -2.59076655e-02f,
  -6.82337731e-02f, -1.83397561e-01f, 7.34604746e-02f, -5.47971874e-02f, -1.27179235e-01f, -8.95821154e-02f, -1.53036773e-01f, -1.28848165e-01f, -5.78410290e-02f, -1.41207695e-01f,
  -1.09787822e-01f, -1.03894524e-01f, 4.11549546e-02f, 8.80610347e-02f, -4.52366332e-03f, 2.78808945e-03f, 5.50326817e-02f, 1.58892050e-01f, 1.45353451e-01f, -3.61502394e-02f,
  -7.09262937e-02f, -1.19856605e-02f, 4.43712696e-02f, 1.15790561e-01f, -3.94421257e-02f, -6.52915090e-02f, 8.84821638e-02f, 6.51123598e-02f, -4.42313179e-02f, -1.36522725e-02f,
  1.93692334e-02f, -1.36711866e-01f, 8.79721791e-02f, -7.39259124e-02f, 9.85197797e-02f, -2.57201567e-02f, -4.94020134e-02f, -2.84485891e-02f, -3.90962362e-02f, -5.30617461e-02f,
  6.95130453e-02f, -1.01450011e-01f, 4.87866811e-02f, -2.36755535e-02f, -4.34069932e-02f, -5.41437380e-02f, -3.53018800e-03f, 9.64709092e-03f, 1.09294169e-01f, -9.57169905e-02f,
  -1.63161308e-02f, -1.19401060e-01f, -2.26919856e-02f, 9.86026824e-02f, -4.27663773e-02f, -1.70966070e-02f, -4.86421473e-02f, 3.52015309e-02f, 5.29644527e-02f, -9.13693458e-02f,
  -6.09234758e-02f, 2.11177114e-02f, -5.37674241e-02f, -4.33641858e-03f, 5.50919063e-02f, -4.18825746e-02f, 9.23596881e-03f, 5.62708862e-02f, -2.99258195e-02f, -1.07627846e-02f,
  3.96478921e-02f, -4.24196720e-02f, -3.74888591e-02f, 8.69213045e-03f, 2.45868717e-03f, 6.79174438e-02f, 4.37353067e-02f, 1.90630872e-02f, -7.17655346e-02f, 7.49705657e-02f,
  7.51109496e-02f, -2.89410762e-02f, 4.24234691e-04f, -5.46313711e-02f, 9.70446225e-03f, -2.09707599e-02f, -7.08520133e-03f, 1.60756968e-02f, 1.59977637e-02f, 2.12491658e-02f,
  -4.62519974e-02f, 1.32722288e-01f, -9.20503289e-02f, -4.95362887e-03f, -5.81348129e-02f, -1.06137451e-02f, 3.58436406e-02f, 3.77251557e-03f, 9.14369226e-02f, -3.00019179e-02f,
  -8.72458145e-02f, -3.27709131e-02f, -4.85132039e-02f, -5.29356450e-02f, -3.66259180e-03f, -9.81628522e-02f, -7.11791143e-02f, 1.77157428e-02f, -3.99904922e-02f, -3.22943088e-03f,
  -2.97156107e-02f, -1.30865052e-01f, 1.27108032e-02f, -9.26578790e-02f, -8.81993398e-02f, 7.78089762e-02f, 7.74964243e-02f, -6.80006668e-02f, 5.22784591e-02f, 1.77134890e-02f,
  1.47243425e-01f, -3.11264008e-01f, 1.70830876e-01f, 1.78132460e-01f, 6.57446384e-02f, 2.06481889e-01f, 8.55487734e-02f, 1.29057184e-01f, 9.78662521e-02f, 4.38375026e-02f,
  -1.50593951e-01f, 2.21403055e-02f, -1.05400741e-01f, -1.40388692e-02f, -9.72216576e-02f, 6.33242726e-02f, 5.53830042e-02f, 1.36047617e-01f, 2.05400094e-01f, 5.73754795e-02f,
  -1.02569133e-01f, -3.38565335e-02f, -1.70264151e-02f, 5.52318171e-02f, -1.13075040e-01f, 7.72308633e-02f, -9.64697674e-02f, -8.98101628e-02f, -5.44547997e-02f, -1.34620564e-02f,
  -3.64637002e-02f, -7.35597536e-02f, 1.52350157e-01f, -3.43783125e-02f, -1.14982016e-01f, 1.63951553e-02f, 5.96696176e-02f, -5.35604283e-02f, -7.09438743e-03f, -3.55881453e-02f,
  -3.19209769e-02f, -9.50899795e-02f, -6.11962490e-02f, -1.10689595e-01f, 3.59616056e-02f, -3.87753695e-02f, -1.02261931e-01f, 2.28522858e-03f, -1.04324274e-01f, -3.70668992e-03f,
  -1.50929213e-01f, -6.19070269e-02f, 1.78821627e-02f, 2.60195509e-02f, -9.76710320e-02f, 9.54755023e-02f, -1.27210021e-01f, -9.27680880e-02f, -1.65451989e-02f, -6.87083900e-02f,
  2.38799434e-02f, 4.45319004e-02f, -1.21067138e-02f, 1.07413968e-02f, 8.22762623e-02f, 7.65328556e-02f, -2.72840355e-02f, -3.64919305e-02f, -1.35914078e-02f, -6.02596067e-02f,
  8.79621506e-02f, 9.84991789e-02f, 8.82110298e-02f, 6.96327537e-02f, 3.39134820e-02f, 4.08502333e-02f, 4.37390395e-02f, -7.29313865e-02f, 2.47069150e-02f, 8.59874208e-03f,
  -5.04726134e-02f, -7.08284741e-03f, -1.92696396e-02f, 7.43613299e-03f, 1.62623040e-02f, 6.69230334e-03f, -3.86946090e-02f, -8.99276286e-02f, -2.19032932e-02f, -7.71004558e-02f,
  -1.58200227e-02f, 9.15405992e-03f, 1.28416032e-01f, 1.69960398e-03f, 8.14092532e-03f, -1.03564821e-01f, -3.44330491e-03f, -3.32446061e-02f, -6.46292344e-02f, -3.20529193e-02f,
  -5.00155985e-02f, -5.21656051e-02f, -7.30275288e-02f, 5.85907623e-02f, 1.18491173e-01f, 1.31035790e-01f, -4.77933465e-03f, -1.44786378e-02f, -6.98676631e-02f, 2.59297271e-03f,
  -5.26169874e-02f, 1.73343986e-01f, 2.40896583e-01f, 1.52109995e-01f, 1.46138985e-02f, 1.68657869e-01f, 2.39056535e-02f, 1.57657981e-01f, 9.53660905e-02f, 1.72923639e-01f,
  1.87184170e-01f, -1.56228870e-01f, -2.85090029e-01f, 8.53581354e-02f, -7.61959851e-02f, -3.97012234e-02f, -7.28704855e-02f, 1.27145508e-02f, -1.91656332e-02f, -5.99055327e-02f,
  8.86108633e-03f, -1.26018682e-02f, 3.78099717e-02f, 1.88475866e-02f, 1.47704482e-02f, -1.59203157e-01f, -6.84720576e-02f, -1.14181653e-01f, 1.01940013e-01f, 5.50421923e-02f,
  3.23724151e-02f, 5.80584854e-02f, 6.84913918e-02f, -5.43267131e-02f, 1.74469538e-02f, -8.13787505e-02f, -1.22694999e-01f, 2.00357549e-02f, -1.07251704e-01f, -1.92111731e-01f,
  -1.06768571e-01f, 6.86996616e-03f, 7.66717046e-02f, 6.69437349e-02f, -1.32825956e-01f, 8.62954408e-02f, -1.03265680e-02f, -8.34034011e-02f, 7.34804124e-02f, 2.06481162e-02f,
  -3.32348198e-02f, 3.23635116e-02f, 3.54634635e-02f, 4.25829254e-02f, 4.59702965e-03f, 2.81889960e-02f, -1.58349853e-02f, -5.24164028e-02f, 3.48994769e-02f, -7.44685829e-02f,
  -1.00302979e-01f, 4.20435406e-02f, -7.87540302e-02f, -2.34535504e-02f, 3.20146270e-02f, -8.81632343e-02f, -5.49726859e-02f, -1.48381889e-02f, -4.70589846e-02f, -4.29614633e-02f,
  -1.91417970e-02f, 1.09022213e-02f, -5.35666123e-02f, -1.66846942e-02f, 5.04248030e-03f, 6.40600314e-03f, 4.89562787e-02f, 9.50616449e-02f, 8.45175683e-02f, -1.19832838e-02f,
  -6.43682629e-02f, 4.03058901e-03f, 3.96562256e-02f, 3.83809172e-02f, -4.69062738e-02f, 3.52725983e-02f, 4.65555340e-02f, -6.01987429e-02f, 3.75618897e-02f, 3.06826923e-03f,
  -3.64489332e-02f, -2.75660455e-02f, -6.65929839e-02f, -5.72109446e-02f, -1.83075070e-02f, -8.68843310e-03f, -4.04193290e-02f, 1.51743488e-02f, 9.74410474e-02f, -3.83224078e-02f,
  1.73286676e-01f, -5.20031713e-02f, -6.94768652e-02f, 9.29265618e-02f, -3.06635611e-02f, -1.67368315e-02f, 3.17718685e-02f, 4.89740632e-02f, -5.22195920e-03f, 7.48980641e-02f,
  -3.96016948e-02f, 1.13389306e-01f, -1.47464974e-02f, -3.75191011e-02f, -3.45419087e-02f, -5.77091575e-02f, 7.32752085e-02f, -8.99292007e-02f, -1.65928472e-02f, -6.29585981e-03f,
  -2.69884914e-02f, 1.22766197e-01f, 1.79446027e-01f, -2.01263186e-03f, -1.35923661e-02f, 3.20110247e-02f, -5.46634905e-02f, -2.65518539e-02f, 1.15676679e-01f, 8.18977579e-02f,
  1.94253493e-02f, -8.67018476e-02f, 8.78383517e-02f, 4.16403897e-02f, -4.51246575e-02f, 1.23015270e-01f, 8.43454003e-02f, -4.32189181e-02f, 9.62123424e-02f, -7.98260644e-02f,
  3.77252772e-02f, -1.45323304e-02f, -1.20707698e-01f, 9.81383119e-03f, -1.08509377e-01f, -1.24805914e-02f, -1.27937726e-03f, 5.19701019e-02f, 9.73408371e-02f, 3.39008942e-02f,
  1.46489441e-02f, 3.27003784e-02f, -2.25652736e-02f, -6.92500547e-02f, 7.42298812e-02f, 6.58354759e-02f, -5.41498587e-02f, 2.59285271e-02f, 3.61513384e-02f, 3.92632820e-02f,
  -3.45379859e-02f, -5.72008006e-02f, 2.58832593e-02f, -4.93564084e-02f, -5.46370074e-03f, 6.71494380e-02f, -8.80849883e-02f, 8.85236934e-02f, -5.87886162e-02f, -1.68811213e-02f,
  -1.79260299e-02f, 7.75714219e-02f, 9.02409405e-02f, 5.73878139e-02f, 8.04291889e-02f, 4.66590654e-03f, 5.52945398e-02f, -6.09258749e-02f, -2.64017526e-02f, 3.60773467e-02f,
  -3.70642208e-02f, 4.67462018e-02f, 4.78388779e-02f, -1.97525881e-02f, 5.08235255e-03f, -5.61850481e-02f, 2.23255046e-02f, 1.53725129e-02f, -7.70942029e-03f, -3.31419595e-02f,
  5.38964011e-02f, -3.54487523e-02f, -8.98896977e-02f, -6.16631098e-02f, 5.05932979e-02f, 8.69445596e-03f, -6.71427697e-03f, -1.13490047e-02f, 5.89384092e-03f, -5.71145155e-02f,
  3.26330289e-02f, 3.32034566e-02f, -4.32307310e-02f, 7.14851096e-02f, 4.19411808e-02f, 8.16658139e-02f, -4.45775203e-02f, 5.31668253e-02f, 7.41335843e-03f, 7.12243691e-02f,
  7.05605075e-02f, -2.37589050e-02f, -8.27160254e-02f, -6.73405034e-03f, -3.08135040e-02f, -8.19140077e-02f, -6.42424673e-02f, -5.91658875e-02f, 3.72540653e-02f, -6.93923011e-02f,
  -1.03189677e-01f, 7.94363767e-02f, -1.06151573e-01f, -5.95325381e-02f, 5.23696728e-02f, 3.88030186e-02f, -5.90483360e-02f, 1.82525325e-03f, 6.30284473e-02f, 3.55807878e-02f,
  8.24695677e-02f, 3.48966494e-02f, -1.51997935e-02f, 9.58208144e-02f, 1.98078416e-02f, -8.54152907e-03f, 5.58554865e-02f, -6.02074899e-02f, 7.05437362e-02f, -2.79143024e-02f,
  5.80094568e-02f, 1.15546174e-01f, 9.15948004e-02f, -7.71987136e-04f, 3.01690330e-03f, 7.55790472e-02f, 8.42964649e-03f, -5.81170321e-02f, 5.90186715e-02f, -3.56631130e-02f,
  1.18467454e-02f, -5.53430878e-02f, 7.09788948e-02f, 2.59938668e-02f, 1.52316615e-01f, 3.04986387e-02f, -4.89157401e-02f, -1.76111292e-02f, 8.40578601e-02f, 8.45578164e-02f,
  9.54139754e-02f, 1.25000477e-01f, -1.70169899e-03f, 1.79157499e-02f, 4.46432978e-02f, 4.68057021e-02f, -1.68071175e-03f, -6.31113350e-03f, -1.84596013e-02f, -2.52839178e-02f,
  1.08381160e-01f, 5.11813629e-03f, 3.47730480e-02f, -5.28607219e-02f, 8.70353356e-02f, 8.11947212e-02f, -2.60992994e-04f, 2.04176884e-02f, 5.67459241e-02f, 6.57658428e-02f,
  -2.65671387e-02f, 3.87623869e-02f, -3.70866247e-02f, 5.02072163e-02f, 1.17016574e-02f, -3.78015712e-02f, 3.71226892e-02f, -4.80339602e-02f, -7.49920681e-02f, -7.23818317e-02f,
  9.89695787e-02f, 4.13837209e-02f, 9.71182063e-02f, 5.01668490e-02f, -2.90125026e-03f, 2.43077949e-02f, 4.09608185e-02f, -8.87136813e-03f, -9.07508507e-02f, 6.95850551e-02f,
  -2.80453097e-02f, 6.63835853e-02f, 6.13504462e-03f, 6.73988974e-03f, -1.99742746e-02f, -2.89984513e-02f, 9.78241581e-03f, 2.04330962e-02f, -1.03590213e-01f, -7.54535794e-02f,
  7.40048215e-02f, 9.74794570e-03f, -1.95933990e-02f, 7.92148933e-02f, 5.77667914e-02f, 7.96521902e-02f, 8.08797106e-02f, 3.17293331e-02f, 9.86342952e-02f, 4.84309793e-02f,
  -1.80532429e-02f, 4.77710320e-03f, -2.00107545e-02f, -5.63682728e-02f, -1.77238490e-02f, -1.64706018e-02f, -5.21718897e-02f, -4.25369926e-02f, 4.08761529e-03f, 1.00411788e-01f,
  1.58061218e-02f, 4.86877598e-02f, 4.51091640e-02f, 5.70912175e-02f, -2.16972940e-02f, 1.26701137e-02f, -6.34362176e-02f, -4.07095328e-02f, 4.04205807e-02f, -5.38218208e-02f,
  9.06984657e-02f, 1.91131886e-02f, -7.02608228e-02f, -5.42781614e-02f, -4.21547741e-02f, 7.58374035e-02f, 7.89920539e-02f, -5.74984066e-02f, 2.09235959e-02f, 4.10037041e-02f,
  6.23486377e-03f, 3.60108502e-02f, -4.07982878e-02f, -2.84566656e-02f, 7.33200163e-02f, -4.12061401e-02f, -3.28733884e-02f, 6.48017749e-02f, -7.36913234e-02f, -4.06274125e-02f,
  -3.05172876e-02f, 2.75205579e-02f, 8.37240070e-02f, -3.40968594e-02f, 9.82920267e-03f, -3.93296704e-02f, 4.21256125e-02f, -5.77991381e-02f, -5.68535626e-02f, -4.13086899e-02f,
  1.35833234e-01f, 6.97721681e-03f, 8.04960057e-02f, 1.20895356e-01f, 4.49219979e-02f, 9.02231485e-02f, 2.52665225e-02f, -1.20064691e-02f, 7.05652386e-02f, 6.81807995e-02f,
  2.13443749e-02f, 1.58025324e-01f, 2.90571358e-02f, 1.34774130e-02f, 1.21623039e-01f, -8.46099108e-02f, -5.28904684e-02f, -1.91145241e-02f, 1.62647124e-02f, 9.57454965e-02f,
  9.21639204e-02f, -7.73133710e-02f, 2.17681937e-03f, -1.02689201e-02f, 7.93915391e-02f, 4.74828966e-02f, 6.30490333e-02f, 6.74119294e-02f, 4.73445393e-02f, -6.69793636e-02f,
  3.47141027e-02f, -7.70009682e-03f, 8.80973116e-02f, -2.71478910e-02f, 7.81428367e-02f, 8.65710974e-02f, -4.34035212e-02f, -2.98414491e-02f, 7.89512768e-02f, -4.48598266e-02f,
  -1.66756492e-02f, -1.13272946e-02f, 8.01287144e-02f, -6.86293747e-03f, -9.54927579e-02f, -2.38476600e-03f, -8.10799599e-02f, 5.24426550e-02f, 5.80647253e-02f, 4.26678509e-02f,
  -4.17201407e-02f, 1.74066424e-02f, -3.06032747e-02f, -7.71894678e-02f, -4.46862876e-02f, 8.08568895e-02f, -3.07600237e-02f, 3.66514884e-02f, -7.92032015e-03f, 5.48521392e-02f,
  8.87227952e-02f, 7.29949847e-02f, -3.79623212e-02f, 8.89210030e-02f, 4.26412560e-02f, 2.64387317e-02f, -5.50184492e-03f, -1.51025420e-02f, -1.32385613e-02f, -3.18606496e-02f,
  -6.05402142e-02f, 1.01572812e-01f, 8.60080421e-02f, 2.65086964e-02f, -1.50706302e-02f, -7.29794148e-03f, -3.11273728e-02f, -1.58046037e-02f, -5.44729978e-02f, -6.24563284e-02f,
  -7.80107034e-03f, -6.57694042e-02f, 4.77994084e-02f, -4.25586700e-02f, 9.62749049e-02f, 9.77275744e-02f, -4.06008624e-02f, -3.97647433e-02f, -9.24280286e-03f, -4.44716066e-02f,
  -7.83206969e-02f, 5.89850731e-02f, 2.25671083e-02f, 4.96717282e-02f, 6.30165190e-02f, 6.49411045e-03f, 9.85717848e-02f, 4.67841551e-02f, -2.77714971e-02f, 6.29088050e-03f,
  2.80015822e-02f, -4.95641120e-02f, -1.74348950e-02f, 8.05278216e-03f, 4.89016473e-02f, 7.32268319e-02f, -7.60486070e-03f, -1.55996056e-02f, 1.84959807e-02f, 4.83393781e-02f,
  -7.17632622e-02f, -3.65282819e-02f, -2.05954481e-02f, 6.28389791e-02f, -7.98098221e-02f, 3.26665938e-02f, 4.97951396e-02f, -3.93897556e-02f, 6.41888827e-02f, 3.11137140e-02f,
  -1.00287087e-01f, -2.04668477e-01f, -9.58833937e-03f, -1.43177688e-01f, -6.73798099e-02f, -7.53250495e-02f, -1.03765003e-01f, -1.56433973e-02f, -3.82216088e-02f, -1.78624779e-01f,
  -1.40515387e-01f, 5.37287183e-02f, -2.84558814e-02f, 5.29390238e-02f, 1.25762910e-01f, 6.17898488e-03f, -4.81713414e-02f, 2.70262603e-02f, 1.94674581e-01f, 6.26569847e-03f,
  -1.48865022e-02f, 2.43107118e-02f, 1.07209302e-01f, 9.71512571e-02f, -7.33761787e-02f, -5.44224717e-02f, -3.80183384e-02f, -3.82982939e-03f, 8.97150021e-03f, -1.26767620e-01f,
  -8.97275582e-02f, -8.86183083e-02f, -2.22923495e-02f, 5.40978797e-02f, 4.20335419e-02f, -2.74091568e-02f, 3.90363811e-03f, 7.06733298e-03f, -6.69613406e-02f, -3.67988013e-02f,
  2.04436146e-02f, -1.47776799e-02f, 4.07346088e-05f, -7.46812019e-03f, -6.49549961e-02f, 6.39130920e-02f, -2.20901966e-02f, -4.18494195e-02f, 2.15893742e-02f, -5.02463654e-02f,
  -3.73580121e-02f, -7.19452351e-02f, 7.00343326e-02f, -2.68364400e-02f, 3.50100026e-02f, -1.60835609e-02f, -8.51588771e-02f, -9.29463431e-02f, 8.44786614e-02f, -8.39168802e-02f,
  6.48710702e-04f, 4.90972847e-02f, -1.11327395e-02f, 2.75986139e-02f, -4.54461202e-03f, -5.06574400e-02f, 5.78077585e-02f, -3.73863168e-02f, 5.31966500e-02f, -6.45114481e-02f,
  -2.20221863e-03f, 7.24381534e-03f, -4.03089672e-02f, 2.86885481e-02f, 3.50773558e-02f, -7.77403712e-02f, 8.21408704e-02f, -3.18228379e-02f, 5.65977767e-02f, 4.49548997e-02f,
  -6.30634576e-02f, 2.33744849e-02f, 5.08395135e-02f, 4.58759144e-02f, 1.34182209e-02f, -5.04674914e-04f, -2.34308168e-02f, -4.37774882e-02f, 5.79155199e-02f, -3.20699476e-02f,
  -9.93513316e-02f, 1.91177219e-01f, -2.00629327e-02f, -5.30612879e-02f, -6.14086054e-02f, -2.35394128e-02f, -5.85937910e-02f, 3.87794077e-02f, -2.34106537e-02f, 3.50156650e-02f,
  -2.53428128e-02f, -1.24049209e-01f, -8.00569132e-02f, 5.07504120e-02f, -4.36034575e-02f, -4.35185852e-03f, -7.52639845e-02f, 6.31046444e-02f, 7.37223327e-02f, 3.27737331e-02f,
  -1.09371971e-02f, 1.72435623e-02f, -4.40860428e-02f, 1.75925810e-02f, -2.02447120e-02f, -5.57737425e-02f, -6.59962595e-02f, -1.17537216e-03f, 8.11222047e-02f, -7.38691241e-02f,
  -2.59770900e-01f, -3.10557961e-01f, 1.58351868e-01f, -1.31903768e-01f, -1.43621013e-01f, -2.08849877e-01f, -3.04835618e-01f, -6.23689890e-02f, -8.17256644e-02f, -1.91626638e-01f,
  -1.84394240e-01f, 2.61033904e-02f, 6.08687364e-02f, 1.05109081e-01f, 6.06159493e-03f, -1.01438269e-01f, -6.93413615e-02f, 2.15563342e-01f, 8.57665986e-02f, 7.04729259e-02f,
  -7.98956007e-02f, 2.41119564e-02f, 1.50694713e-01f, 1.31661519e-01f, -8.33743066e-02f, 9.33687091e-02f, 1.12476222e-01f, -5.65015012e-03f, -1.33604273e-01f, -1.14153817e-01f,
  -2.25859523e-01f, -7.50147998e-02f, 9.01594311e-02f, -2.20048167e-02f, -4.95906584e-02f, -5.61652482e-02f, -5.05939871e-02f, 1.33808004e-02f, -4.00529727e-02f, -1.02218613e-01f,
  -1.73194557e-02f, -1.82077587e-02f, -5.50206378e-02f, 5.13198078e-02f, 3.99652347e-02f, -7.72119462e-02f, 3.95018049e-02f, 7.91480541e-02f, 1.39986888e-01f, -5.05184233e-02f,
  -1.23867780e-01f, -2.42425688e-02f, -5.40618598e-02f, 9.62761045e-02f, -3.85926664e-02f, -1.59351099e-02f, -2.79077538e-03f, -2.47346200e-02f, 1.11336671e-01f, -2.61678733e-03f,
  7.62789547e-02f, 3.79460976e-02f, -3.07009015e-02f, 3.84345204e-02f, -9.22574997e-02f, 4.63271961e-02f, -1.49637954e-02f, -8.34780633e-02f, -9.38555319e-03f, 1.30302776e-02f,
  7.83275291e-02f, -6.90245852e-02f, 5.80746010e-02f, -2.25476758e-03f, 3.61456536e-02f, -7.76655450e-02f, 6.25558570e-02f, -6.47906773e-03f, -5.07234894e-02f, 3.53352018e-02f,
  -5.60916997e-02f, 3.99334691e-02f, 8.10751468e-02f, 4.72064465e-02f, 5.54568768e-02f, -1.81317460e-02f, -7.90626258e-02f, -5.55404946e-02f, 2.85643581e-02f, 1.91570669e-02f,
  2.55432865e-03f, 2.41021991e-01f, -1.69947654e-01f, -5.98758049e-02f, -2.58417260e-02f, 9.10988823e-02f, -7.27735460e-02f, 4.62670363e-02f, -1.59446280e-02f, -8.05350766e-03f,
  -3.89483981e-02f, -8.54495987e-02f, -6.86729699e-02f, -4.30005193e-02f, 8.82862788e-03f, -4.20202389e-02f, -6.18814677e-02f, 7.65649229e-03f, -3.31647508e-02f, -1.05262391e-01f,
  -8.83427337e-02f, -5.87844998e-02f, -2.00884357e-01f, -3.27951759e-02f, -6.95494041e-02f, -7.50732794e-02f, -9.37994495e-02f, -1.17046367e-02f, -3.76921594e-02f, -2.48706728e-01f,
  1.62524566e-01f, -4.42004204e-02f, 8.22847039e-02f, 5.57223409e-02f, 1.30297646e-01f, 1.60875037e-01f, 1.73977911e-01f, -1.93159480e-03f, -1.22933919e-02f, -3.77453938e-02f,
  6.22343607e-02f, -5.49236871e-02f, -1.47655159e-01f, -1.42224789e-01f, 1.54447164e-02f, 2.84095295e-02f, 5.79369068e-02f, -9.45765525e-02f, -7.91744813e-02f, -3.38638425e-02f,
  -8.72547999e-02f, 4.82183583e-02f, -7.96476901e-02f, -1.09553128e-01f, -9.98297483e-02f, -3.21828090e-02f, -1.50573871e-03f, -8.83749593e-03f, 4.39916141e-02f, -4.41189781e-02f,
  -1.36741340e-01f, -6.98127085e-03f, 6.24597222e-02f, -1.49733290e-01f, -4.70165238e-02f, 6.82277232e-02f, 5.71115129e-02f, 4.81609926e-02f, 6.94243237e-02f, 6.31638095e-02f,
  -7.94196222e-03f, -4.34958450e-02f, -3.85190197e-03f, -1.29624968e-02f, -1.18795515e-03f, 2.19287127e-02f, 6.99679181e-02f, -6.09870180e-02f, 1.49461338e-02f, -3.59042063e-02f,
  2.55038943e-02f, 9.25944373e-02f, 1.88372612e-01f, 1.96266975e-02f, -9.37848643e-04f, 8.08531940e-02f, 4.16738652e-02f, -4.45693210e-02f, 5.15765101e-02f, 3.50523293e-02f,
  -9.58750695e-02f, 6.40062392e-02f, -1.84281655e-02f, -5.75141050e-02f, 3.84378210e-02f, -5.16263880e-02f, -5.14939278e-02f, 2.53931452e-02f, 5.07430770e-02f, 6.93842322e-02f,
  -4.45130691e-02f, 1.30792521e-02f, 2.01468598e-02f, -1.29473871e-02f, -1.66437700e-02f, 5.48574105e-02f, 1.06881566e-01f, 5.06512038e-02f, 1.76627212e-03f, -6.49047941e-02f,
  1.45141110e-02f, 2.18059253e-02f, 6.37441641e-03f, -6.06828481e-02f, 1.16996141e-02f, 8.85267928e-02f, 6.28429502e-02f, 3.53556126e-02f, 7.51040205e-02f, 1.17014367e-02f,
  -1.52970761e-01f, 9.04497281e-02f, 2.26849411e-03f, -7.80417919e-02f, -8.17627162e-02f, 2.29611006e-02f, -1.17211759e-01f, -2.45839972e-02f, -6.83316737e-02f, -6.34936392e-02f,
  -4.24550362e-02f, -2.49998812e-02f, 2.13793814e-02f, -6.76836818e-02f, 8.15635994e-02f, -1.78869870e-02f, 4.65572029e-02f, -5.68262972e-02f, -1.03776999e-01f, -7.25113377e-02f,
  -2.39447448e-02f, 1.26279682e-01f, 1.18407182e-01f, 2.56818458e-02f, -4.98994738e-02f, 1.30849034e-01f, -6.74828812e-02f, 7.76618794e-02f, 1.04122380e-04f, -2.38756053e-02f,
  3.74616235e-02f, -1.66395813e-01f, 1.14314910e-02f, 4.13048528e-02f, 1.15729503e-01f, 1.47347137e-01f, 4.39548343e-02f, 4.32834662e-02f, 7.75031447e-02f, 2.13490753e-03f,
  -8.67961794e-02f, -6.85066730e-02f, -1.51717141e-01f, -1.25746623e-01f, -3.03557906e-02f, 1.20449968e-01f, 9.23938826e-02f, 8.48530158e-02f, 1.08017020e-01f, 5.87986968e-02f,
  -6.39908463e-02f, -4.14215587e-02f, -6.46062568e-02f, 4.51384895e-02f, 5.02966307e-02f, 2.37162989e-02f, -6.18235134e-02f, 1.29466588e-02f, -6.45345747e-02f, -8.95478502e-02f,
  8.19181055e-02f, -1.15817234e-01f, -7.65785128e-02f, -1.12847775e-01f, -2.39135753e-02f, -2.55361665e-02f, 5.34230098e-03f, -8.34475905e-02f, -1.36564717e-01f, -5.12880413e-03f,
  -1.10777263e-02f, -1.06023759e-01f, -3.52337398e-02f, -7.70774037e-02f, -3.21457442e-03f, 7.79606327e-02f, 1.94810750e-03f, 1.24973096e-02f, -9.48304087e-02f, -5.49488440e-02f,
  -7.56375939e-02f, 5.66195510e-02f, 4.05127974e-03f, 3.11364662e-02f, -1.37001038e-01f, 3.15656476e-02f, 4.31341827e-02f, 2.53889281e-02f, 1.50399990e-02f, 9.17183161e-02f,
  9.29273590e-02f, -8.04452077e-02f, 5.80703989e-02f, -3.41774896e-02f, 4.96937148e-02f, -5.05872071e-02f, 4.58991304e-02f, -3.15015540e-02f, 2.10023392e-02f, -4.50869016e-02f,
  -6.11461625e-02f, 5.29771410e-02f, 1.13952439e-02f, 5.02428263e-02f, -8.59472826e-02f, 3.19938809e-02f, -1.24183495e-03f, -5.59839085e-02f, -7.26340637e-02f, -3.62876318e-02f,
  -6.78905323e-02f, -3.89738902e-02f, 7.32917935e-02f, 5.24227768e-02f, -1.72980949e-02f, -3.45585719e-02f, 9.64380428e-02f, 5.45200482e-02f, 5.11148386e-02f, -1.16756083e-02f,
  1.12606086e-01f, -9.61187705e-02f, 5.37373833e-02f, -7.36738965e-02f, 5.75534627e-02f, 3.77578884e-02f, -4.44049239e-02f, 3.65820266e-02f, -9.01426449e-02f, 3.65492068e-02f,
  -3.80136818e-02f, -3.85750756e-02f, 1.11247776e-02f, -6.30188137e-02f, 1.23390235e-01f, 2.10826844e-02f, 5.34784757e-02f, -1.05884736e-02f, -2.16217376e-02f, 5.97480126e-02f,
  5.33543341e-02f, 5.91708869e-02f, 1.08010985e-01f, 7.94453919e-02f, 4.96746898e-02f, 3.67465764e-02f, 1.51102319e-01f, 1.54311553e-01f, 5.26142903e-02f, 1.76056713e-01f,
  -5.44437915e-02f, -7.50883520e-02f, 8.16599205e-02f, 5.55505566e-02f, 9.80205555e-03f, -1.16520464e-01f, -3.64007391e-02f, -6.54574707e-02f, 4.73733433e-02f, 5.04919104e-02f,
  3.63841057e-02f, 1.95585024e-02f, 8.13704133e-02f, -4.37401868e-02f, -8.98339301e-02f, -4.71336618e-02f, 9.94839445e-02f, 1.41298994e-01f, 5.02551980e-02f, -8.90868902e-02f,
  -2.61450205e-02f, 8.14289376e-02f, -1.64853204e-02f, 7.88369477e-02f, 1.18628599e-01f, -1.71224717e-02f, 8.01732391e-02f, 9.87933055e-02f, -5.13387769e-02f, 8.78913999e-02f,
  -6.04514182e-02f, 3.73253711e-02f, -9.66206267e-02f, 1.64229050e-02f, -2.29517091e-02f, 4.34848741e-02f, -6.06518164e-02f, -3.59083526e-02f, 6.13954626e-02f, 7.37381428e-02f,
  -2.23859847e-02f, 4.54888530e-02f, 8.27279501e-03f, -8.58010352e-02f, -9.41626262e-03f, -3.28634530e-02f, -7.27125630e-02f, 1.64759438e-03f, 7.64423003e-03f, 5.09246551e-02f,
  3.44374292e-02f, -7.18586240e-03f, -7.10580796e-02f, 4.66817692e-02f, -6.70634732e-02f, -5.31549640e-02f, 2.84079481e-02f, -8.46066251e-02f, -1.18188679e-01f, -3.92336026e-03f,
  9.27149728e-02f, -2.41910703e-02f, 3.79150696e-02f, 3.29452269e-02f, 7.56077759e-04f, 2.35316418e-02f, 5.66718541e-02f, 3.69130261e-02f, 5.09758107e-02f, -3.00872121e-02f,
  -4.04592864e-02f, 5.09833246e-02f, -6.86055496e-02f, 2.12675091e-02f, 1.04402103e-01f, 4.76418473e-02f, -6.76737800e-02f, 7.05596209e-02f, -3.43902595e-02f, 5.48817106e-02f,
  4.31332141e-02f, -7.59322941e-02f, -4.54236977e-02f, 3.48544866e-02f, -3.08120288e-02f, 1.56908780e-02f, -6.65303692e-02f, 5.83166890e-02f, 6.96077291e-03f, 3.50095518e-02f,
  -3.68239358e-02f, -7.88831338e-02f, -9.71895605e-02f, -2.67446619e-02f, 6.15843907e-02f, -4.70164086e-04f, 3.62235680e-02f, -4.39669192e-02f, 8.72150436e-03f, -7.61090443e-02f,
  -7.93557707e-03f, -1.62125994e-02f, -6.62268251e-02f, -9.80689526e-02f, -6.98402971e-02f, -1.08602189e-01f, 3.30686122e-02f, 1.78545173e-02f, -1.25019578e-02f, 2.29483228e-02f,
  2.62798145e-02f, -8.51523280e-02f, -7.98006505e-02f, -1.33922070e-01f, -1.17785798e-03f, 4.14843298e-03f, -1.27752826e-01f, -1.12185664e-01f, -1.66056260e-01f, -3.10382154e-02f,
  1.22762263e-01f, 3.33268754e-02f, -8.16646684e-03f, 7.48999640e-02f, 6.86933026e-02f, 3.98770757e-02f, 8.97851661e-02f, 6.88414127e-02f, -6.35283440e-02f, -2.35781651e-02f,
  -6.87495023e-02f, -1.13884769e-01f, -7.09123090e-02f, -1.23595998e-01f, -7.04039708e-02f, -1.01461016e-01f, -2.62864530e-02f, -1.71187744e-02f, 3.61753278e-03f, 7.52720609e-02f,
  9.05412883e-02f, -1.71541497e-02f, 1.65149029e-02f, 3.68671827e-02f, 9.50803012e-02f, 1.82697326e-02f, -3.47692296e-02f, -5.65156229e-02f, -6.25512302e-02f, 6.85068220e-02f,
  5.56276459e-03f, -9.94075239e-02f, -5.12916408e-02f, 3.31307724e-02f, -1.99573766e-02f, -3.76568027e-02f, -1.68798380e-02f, -3.16419341e-02f, -4.77449149e-02f, -3.89288005e-04f,
  -5.19587174e-02f, 2.32651690e-03f, -5.14623150e-02f, -9.24860537e-02f, 7.24849105e-02f, -3.31717953e-02f, 1.59882940e-03f, 2.69275736e-02f, -1.23181287e-02f, -6.59539029e-02f,
  1.25428168e-02f, 2.32996885e-02f, 5.84547929e-02f, -2.61388961e-02f, 3.33218044e-03f, 7.68202096e-02f, -9.23853517e-02f, -3.75736170e-02f, -9.75312665e-03f, 6.72196448e-02f,
  -2.44865306e-02f, 3.76207591e-03f, 6.86964467e-02f, -2.29413733e-02f, -8.82572960e-03f, 4.91496641e-03f, -2.07091365e-02f, 5.60324057e-04f, 1.33992899e-02f, -9.14207697e-02f,
  8.49331170e-02f, 8.50567296e-02f, 7.79722771e-03f, 1.01951566e-02f, 4.46669534e-02f, 2.77920645e-02f, -6.62457794e-02f, -5.01363017e-02f, 6.39366172e-03f, -4.63137776e-02f,
  -3.83513868e-02f, 4.55724187e-02f, 7.91606754e-02f, -8.58486667e-02f, -4.80445623e-02f, 3.68511267e-02f, -5.86528927e-02f, -1.69214420e-02f, -7.34492764e-02f, 7.04755215e-03f,
  -5.62320417e-03f, -2.76469951e-03f, -4.60353978e-02f, 2.25013010e-02f, 1.13031920e-02f, -6.54829964e-02f, -1.90583691e-02f, 5.68043105e-02f, -2.90784910e-02f, -9.60099860e-04f,
  -9.50973034e-02f, 3.12214717e-02f, 2.32796930e-03f, -4.39013876e-02f, -3.30680655e-03f, 1.27332862e-02f, 8.36037695e-02f, 3.42087937e-03f, -4.49056737e-02f, -7.42085278e-02f,
  -7.94510916e-02f, 1.23409532e-01f, 6.83363825e-02f, -8.02094340e-02f, -6.73594326e-02f, 8.04620683e-02f, -1.39680309e-02f, 8.53985921e-02f, -6.95940256e-02f, 9.93483812e-02f,
  2.05219135e-01f, 5.08883037e-02f, 8.25325102e-02f, 1.79889500e-01f, 2.42721334e-01f, 1.35119736e-01f, 1.84362069e-01f, 4.68686223e-02f, 8.37071761e-02f, 9.87943187e-02f,
  2.13500068e-01f, 7.55292550e-02f, 1.49065837e-01f, 1.11043379e-01f, 3.27927619e-02f, -3.50319743e-02f, -1.18941158e-01f, 3.18779610e-02f, 2.68874578e-02f, 1.01824753e-01f,
  1.21910237e-02f, 3.98108549e-03f, 1.03516839e-01f, 4.86980267e-02f, 5.94159365e-02f, -5.99599369e-02f, 9.22610611e-02f, 8.83751437e-02f, 2.43060067e-02f, 3.07982136e-02f,
  1.31639421e-01f, 8.30897987e-02f, -1.23618908e-01f, 6.85013384e-02f, -1.03197724e-03f, 1.53876084e-03f, -7.41994977e-02f, -1.24431573e-01f, 4.22779359e-02f, -1.42738149e-01f,
  1.00541137e-01f, -7.44526312e-02f, -2.87543312e-02f, -1.08904906e-01f, -2.07939156e-04f, -9.59922448e-02f, -8.91492069e-02f, -1.29025146e-01f, -7.44653046e-02f, 4.84239720e-02f,
  -5.27064875e-02f, 9.15519148e-02f, 9.15289670e-02f, -1.31596982e-01f, -1.92661677e-02f, 4.67592552e-02f, 3.01025854e-03f, -8.58526453e-02f, 7.57534709e-03f, -8.29872936e-02f,
  3.80783752e-02f, 6.65900707e-02f, 2.97992080e-02f, -9.57008265e-03f, 8.97240341e-02f, -1.03444293e-01f, -6.32500350e-02f, 3.30811031e-02f, -7.00384453e-02f, -3.96337034e-03f,
  2.47582924e-02f, 5.39903603e-02f, -2.53531206e-02f, -5.67158982e-02f, -1.04526598e-02f, -3.14601548e-02f, 5.27996421e-02f, 4.28372249e-02f, 7.42181912e-02f, -3.88253070e-02f,
  7.80006796e-02f, 2.40416471e-02f, 1.61216892e-02f, -9.94882137e-02f, -5.67067303e-02f, -7.31458664e-02f, -7.76498169e-02f, 4.78609726e-02f, 3.77968289e-02f, -3.20334695e-02f,
  1.39393499e-02f, 1.42836064e-01f, -4.58664671e-02f, -4.97893356e-02f, 9.35503002e-03f, 4.76064198e-02f, -5.95087046e-03f, -9.26083326e-02f, -5.26905693e-02f, -5.48683032e-02f,
  9.03470367e-02f, 3.20345946e-02f, 9.16837379e-02f, -1.14782833e-01f, 4.19026315e-02f, -1.12777632e-02f, 1.17703958e-03f, -9.89606827e-02f, -3.75063494e-02f, -8.53540096e-03f,
  -1.21176206e-01f, -2.71900911e-02f, 2.79117115e-02f, -1.35654360e-02f, -5.33978119e-02f, -5.02158292e-02f, 1.38117466e-02f, -2.90030185e-02f, -3.74455936e-02f, -1.54720619e-01f,
  -6.91126753e-03f, 4.75434922e-02f, 4.19169068e-02f, -2.49141250e-02f, 3.40850540e-02f, 3.73872742e-02f, -3.97782512e-02f, -6.83793575e-02f, -2.31199656e-02f, 1.42487707e-02f,
  5.92430308e-02f, -3.38265859e-02f, -3.82687598e-02f, -4.98730019e-02f, -8.79857969e-03f, -9.99922752e-02f, -9.12380219e-02f, 3.57651082e-03f, -8.71201009e-02f, -3.92093183e-03f,
  -3.79029196e-04f, -7.30339810e-02f, 2.97744293e-02f, 3.05436421e-02f, 1.35432661e-01f, -8.71007219e-02f, 3.77760679e-02f, 5.46118850e-03f, 8.49678833e-03f, -6.50984189e-03f,
  -6.12623408e-04f, 7.29024634e-02f, -2.22877357e-02f, -7.95347467e-02f, 1.44433044e-02f, 9.39976126e-02f, 7.06952810e-02f, 7.05345050e-02f, 1.01738848e-01f, 7.85885230e-02f,
  3.37913595e-02f, 2.65529472e-02f, 5.53659871e-02f, 1.19992837e-01f, -2.09612492e-02f, -4.04070318e-02f, 5.84666543e-02f, -1.44595141e-02f, 6.37064576e-02f, 1.01621144e-01f,
  8.01368654e-02f, -8.79060626e-02f, -3.05967275e-02f, -8.67053866e-03f, -8.11604857e-02f, 5.51017327e-03f, -3.49770337e-02f, -1.53479530e-02f, 3.64398472e-02f, 4.81342524e-02f,
  -1.17491290e-01f, 6.26591742e-02f, -5.17298579e-02f, 1.50540862e-02f, 2.68113650e-02f, 2.07086559e-03f, -7.61285126e-02f, -3.48392837e-02f, 6.53000772e-02f, 8.44191313e-02f,
  1.19608250e-02f, 3.42066847e-02f, 5.98183796e-02f, -2.47862600e-02f, 5.49494401e-02f, -3.12747620e-02f, -3.77846695e-02f, 8.71475339e-02f, 1.99010745e-02f, -2.66419235e-03f,
  -7.09159598e-02f, -3.95470932e-02f, 4.38458082e-04f, -4.32368442e-02f, 8.52749795e-02f, 1.90954302e-02f, -5.46994694e-02f, -5.40607460e-02f, -6.31793290e-02f, 6.40711561e-03f,
  1.54070809e-01f, -9.71518233e-02f, 8.82214010e-02f, 7.29143247e-02f, -3.61157246e-02f, 1.15190797e-01f, 3.68198031e-03f, -5.77962957e-02f, 7.86734894e-02f, -5.57975769e-02f,
  -2.02607363e-02f, 6.04597814e-02f, 1.08403780e-01f, 5.51722683e-02f, -4.78651077e-02f, 8.34884401e-03f, 7.97933191e-02f, -8.61985385e-02f, 7.29262596e-03f, -2.82735433e-02f,
  4.78560366e-02f, -3.31551805e-02f, -4.84167933e-02f, 7.81997219e-02f, 1.18945045e-02f, -1.24640666e-01f, -2.14416813e-02f, 9.54086334e-02f, 3.72055694e-02f, -5.76954149e-02f,
  -1.99451581e-01f, 4.20225523e-02f, 1.18185900e-01f, 8.12482834e-03f, -3.91558819e-02f, -1.13182493e-01f, -6.96657822e-02f, -1.00198276e-01f, -1.98686812e-02f, -8.11950564e-02f,
  -5.33022918e-03f, -1.80619191e-02f, -2.05279924e-02f, -3.00791394e-02f, -1.03816554e-01f, 7.70802051e-02f, 6.47221729e-02f, -6.30117133e-02f, -1.85994998e-01f, -1.22530699e-01f,
  -1.11861147e-01f, -1.03715420e-01f, -2.00520620e-01f, -2.10000910e-02f, 8.23994540e-03f, -3.89310122e-02f, 7.47820288e-02f, 3.11823636e-02f, -4.58930209e-02f, -1.77679341e-02f,
  2.91210543e-02f, 4.18523327e-02f, -1.21187530e-01f, 7.90248276e-04f, 2.17666011e-02f, 2.70615867e-03f, -5.40838242e-02f, 1.21481702e-01f, -6.24356940e-02f, -5.87230623e-02f,
  4.03195284e-02f, 2.48131827e-02f, -2.99751777e-02f, 5.52576929e-02f, 2.79502869e-02f, -3.50671299e-02f, -1.30029814e-02f, 8.46698321e-03f, -5.70855401e-02f, 7.68978298e-02f,
  2.44547762e-02f, 2.37268247e-02f, -1.12675903e-02f, 9.81297195e-02f, 2.90183518e-02f, -1.61850266e-02f, -4.40658368e-02f, 5.90367094e-02f, 3.72820273e-02f, 4.31364328e-02f,
  -1.26866363e-02f, 1.33181000e-02f, 6.86469302e-02f, -4.63668033e-02f, -8.23535547e-02f, -2.28620432e-02f, 9.35569555e-02f, -2.70698201e-02f, -1.04487784e-01f, -1.76599249e-03f,
  6.58142045e-02f, 6.74016327e-02f, 5.07237799e-02f, 4.05696817e-02f, -5.00873402e-02f, -3.22776958e-02f, -5.40096313e-02f, 3.97425666e-02f, -2.24637706e-02f, -6.67010099e-02f,
  1.39586872e-03f, 4.65997420e-02f, 8.53965506e-02f, 4.42366190e-02f, 8.91067609e-02f, 3.93617600e-02f, -1.10609263e-01f, -2.51412131e-02f, -9.33081731e-02f, 4.25220542e-02f,
  -1.01378106e-01f, -3.99279781e-02f, 4.61719446e-02f, 6.55514142e-03f, 5.90563193e-02f, -9.62514430e-03f, 9.22238007e-02f, -5.24868518e-02f, 3.88375893e-02f, 2.90327761e-02f,
  1.39023401e-02f, 1.42974714e-02f, 1.39082978e-02f, 4.06272523e-02f, -1.61655352e-01f, -1.48145447e-03f, -2.03602929e-02f, -1.18813477e-02f, 5.81506714e-02f, -2.42416542e-02f,
  -1.42011754e-02f, -7.80114532e-02f, -1.46619096e-01f, 4.01312597e-02f, 9.24063995e-02f, 6.29559346e-03f, -7.81353861e-02f, 8.26536119e-03f, 2.09111404e-02f, 2.17863433e-02f,
  -1.04221955e-01f, -2.88856681e-02f, -1.86475348e-02f, -9.21647772e-02f, -4.87956591e-03f, -1.97195802e-02f, 3.22351493e-02f, -5.94621710e-02f, -7.22720567e-03f, -9.17557627e-02f,
  -6.76910803e-02f, -1.37072176e-01f, -3.47099081e-02f, 4.59408015e-03f, 8.97281542e-02f, 1.09321550e-01f, 2.65994519e-02f, 1.73985828e-02f, -2.75840610e-02f, -8.62328559e-02f,
  -8.52743462e-02f, -1.04958653e-01f, 6.32605553e-02f, 2.41111703e-02f, 2.98462696e-02f, 8.36964790e-03f, -7.14223832e-02f, -2.31240764e-02f, -9.22671240e-03f, 1.65440608e-02f,
  -2.95868814e-02f, -1.18628271e-01f, 7.66898245e-02f, 4.69377898e-02f, 5.20466529e-02f, 2.86295004e-02f, 8.99570808e-03f, -9.02944952e-02f, 1.57863069e-02f, 5.92596829e-02f,
  -5.97683887e-04f, -9.54321474e-02f, -8.83533433e-02f, -4.45618033e-02f, 1.06187873e-02f, -7.69108310e-02f, 6.73877373e-02f, 6.84565753e-02f, 1.96303446e-02f, 1.37645286e-02f,
  1.96766481e-03f, 5.58379572e-04f, -9.32726637e-02f, 7.55435750e-02f, 6.95660338e-02f, -6.43831044e-02f, 2.95816753e-02f, -9.89303887e-02f, -4.64934781e-02f, -2.90528201e-02f,
  1.66378985e-03f, 7.84289371e-03f, 4.93809730e-02f, 2.95978505e-02f, -7.01462254e-02f, -6.66126087e-02f, 5.02916090e-02f, 1.75078530e-02f, 4.01707292e-02f, -4.89320382e-02f,
  -8.64375904e-02f, 9.46101844e-02f, -6.75877854e-02f, 2.15394497e-02f, -8.76570567e-02f, 2.55210251e-02f, 7.42240474e-02f, 6.28185570e-02f, 5.46583608e-02f, 5.34814075e-02f,
  -3.00090052e-02f, 3.41112949e-02f, 1.42445683e-03f, 3.78298648e-02f, -2.99485959e-02f, -2.33180299e-02f, 5.49103366e-03f, -2.67114043e-02f, 5.37310913e-02f, -9.67899337e-02f,
  -1.12121269e-01f, 1.49625063e-01f, -1.06951691e-01f, -1.12082018e-02f, -4.26204316e-02f, 1.42538194e-02f, -2.84595368e-03f, -6.61239251e-02f, -7.62814358e-02f, 2.18117554e-02f,
  -6.65453523e-02f, 3.86706628e-02f, 2.05928199e-02f, 7.55337477e-02f, -1.17030423e-02f, -2.43037310e-03f, 8.85109454e-02f, -9.07471702e-02f, 1.72188114e-02f, -3.29623409e-02f,
  8.47328976e-02f, -3.18820891e-03f, -9.23506320e-02f, -3.98513256e-03f, -3.13686356e-02f, -1.51984002e-02f, 6.47892943e-03f, -4.18618545e-02f, -5.02567776e-02f, -1.24083795e-01f,
  -2.54081059e-02f, 1.20325955e-02f, 1.47186756e-01f, -8.54706764e-02f, -1.40225857e-01f, -4.33497466e-02f, 2.68655177e-02f, 7.79845100e-03f, -1.01455972e-01f, -5.52010275e-02f,
  -6.07873686e-02f, -1.06765538e-01f, -9.22926366e-02f, -1.74459796e-02f, 1.14453040e-01f, 1.29655421e-01f, 2.25196257e-02f, 2.01350190e-02f, 1.08996682e-01f, 4.77119163e-02f,
  6.52037412e-02f, 6.56961650e-02f, -7.87030347e-03f, 7.31343329e-02f, -3.91072519e-02f, 5.03048785e-02f, -6.47075549e-02f, -5.90196326e-02f, 8.31601471e-02f, 1.51144818e-03f,
  -4.13699336e-02f, 6.02589883e-02f, -5.85651807e-02f, -1.23965010e-01f, -9.09049585e-02f, 7.42247701e-03f, 5.52559234e-02f, -6.41161352e-02f, -4.50591790e-03f, 9.24039409e-02f,
  5.97092463e-03f, 1.71627495e-02f, -8.69600251e-02f, 4.97546531e-02f, -1.02877066e-01f, 4.08771522e-02f, 3.87812518e-02f, 1.25093162e-01f, 1.08032644e-01f, 8.04679766e-02f,
  6.51881918e-02f, -2.01740842e-02f, -4.19201702e-02f, 2.23144051e-02f, 1.34966709e-02f, -8.37414488e-02f, -2.24754568e-02f, -8.83999187e-03f, 2.28239130e-02f, 2.88621858e-02f,
  -1.55346217e-02f, 6.05766848e-02f, 8.49312469e-02f, -6.02613166e-02f, -5.95663581e-03f, 9.76981223e-03f, -4.04671170e-02f, 5.32264225e-02f, -2.25725807e-02f, -1.78864393e-02f,
  3.21139917e-02f, -3.82149369e-02f, 2.65980791e-03f, -8.47138688e-02f, -1.12064974e-02f, -7.48652369e-02f, 1.14366733e-01f, -6.66040555e-02f, 8.30596983e-02f, -2.94199232e-02f,
  -2.64239572e-02f, -3.74201336e-03f, -6.96733370e-02f, -4.87084314e-03f, 8.87817070e-02f, -9.63596441e-03f, 2.16824003e-02f, 8.54762420e-02f, -8.33465010e-02f, -3.06870565e-02f,
  -1.50050968e-01f, -1.11220971e-01f, -6.17631823e-02f, 5.66392280e-02f, -1.04569353e-03f, -1.39664561e-02f, -4.58412915e-02f, 7.86836073e-02f, -9.15008336e-02f, -7.19250292e-02f,
  -1.17954751e-02f, 2.83110607e-02f, -8.77775401e-02f, 2.04625260e-02f, -5.64794429e-02f, -9.16567892e-02f, -2.43897531e-02f, -6.62858337e-02f, 4.03585024e-02f, -1.55508937e-02f,
  -5.31632267e-02f, -7.15507939e-02f, -1.05309770e-01f, -3.40080932e-02f, -1.25562668e-01f, -1.15428932e-01f, -8.33133012e-02f, 1.11194197e-02f, -3.45204324e-02f, -1.00621611e-01f,
  -1.14355341e-01f, 1.98591799e-01f, 2.02763081e-02f, -2.73602866e-02f, 7.45376013e-03f, 1.03791177e-01f, 1.66601941e-01f, 3.48642394e-02f, 3.91949005e-02f, 7.43561089e-02f,
  -9.96921025e-03f, 2.90749744e-02f, -1.18798902e-02f, -8.77736062e-02f, 2.23854557e-02f, -2.86486521e-02f, -1.97173636e-02f, -2.79411282e-02f, -1.22449383e-01f, -3.29525617e-04f,
  7.48631731e-02f, -1.11774530e-03f, -1.37855515e-01f, 1.56372711e-02f, 5.19758016e-02f, 2.83519290e-02f, 2.07223520e-02f, 7.41260275e-02f, -5.02033010e-02f, 1.21085018e-01f,
  -4.51987050e-02f, 1.40311820e-02f, -6.07450381e-02f, -1.11796930e-01f, 4.00605910e-02f, -3.19460072e-02f, -7.34715760e-02f, -2.53550913e-02f, -7.10976124e-02f, -6.54861107e-02f,
  -3.20753120e-02f, -2.14621313e-02f, -3.34504507e-02f, -5.81072196e-02f, 2.54251584e-02f, -7.46435076e-02f, -5.50876334e-02f, -9.36621204e-02f, -1.07228145e-01f, -4.14987206e-02f,
  4.25200462e-02f, 6.74315318e-02f, -6.74344301e-02f, 2.95223519e-02f, 3.35988775e-02f, -5.45984767e-02f, 1.86296366e-02f, 4.83959652e-02f, -2.29330268e-03f, -4.93100919e-02f,
  -2.42665932e-02f, -5.22302426e-02f, -2.92222505e-03f, -5.27902059e-02f, 7.96080157e-02f, 3.33310254e-02f, -7.31391907e-02f, -4.27829251e-02f, -5.46761118e-02f, 3.23718786e-02f,
  7.14003891e-02f, -6.71499595e-02f, 5.26379533e-02f, 6.02431893e-02f, -3.74808395e-03f, -7.11893588e-02f, -5.75939193e-02f, -7.44580403e-02f, -5.97361885e-02f, -4.13794741e-02f,
  5.91264404e-02f, -5.00745662e-02f, 2.35580541e-02f, 5.77452332e-02f, -3.09523288e-02f, -5.69687933e-02f, -1.03304133e-01f, -7.73958713e-02f, 3.93054560e-02f, 7.07092136e-02f,
  -4.68323529e-02f, -3.29323113e-02f, -4.01749387e-02f, 2.11380664e-02f, -2.37095766e-02f, -7.18156397e-02f, 1.06716976e-02f, 3.61846238e-02f, -6.02228679e-02f, 4.42333221e-02f,
  -1.69287827e-02f, 6.27965108e-02f, 7.06820637e-02f, -9.68261436e-02f, -7.78260678e-02f, -7.57602453e-02f, 2.78258547e-02f, -5.60384244e-02f, 9.45163984e-03f, -9.27118808e-02f,
  -6.05602600e-02f, -9.05984864e-02f, 4.24729520e-03f, -4.69674822e-03f, -5.49577847e-02f, -5.99487387e-02f, 8.06897059e-02f, 1.18316896e-02f, 3.68003175e-02f, -2.47718766e-02f,
  -3.64151411e-02f, 1.46861866e-01f, 9.97767523e-02f, -1.30131543e-01f, 9.64365527e-02f, 1.30091056e-01f, 2.75786638e-01f, 3.87421362e-02f, -7.84237608e-02f, -2.85922107e-03f,
  1.23396434e-01f, -1.25603765e-01f, -1.31136864e-01f, -9.50925872e-02f, 8.22715834e-02f, 3.45172249e-02f, -8.47532153e-02f, -1.84385963e-02f, 3.42805423e-02f, -2.38454808e-02f,
  1.01478677e-02f, 4.83647548e-02f, -1.19300872e-01f, 9.92019288e-03f, -1.62048593e-01f, -1.38969809e-01f, -9.48899332e-03f, 7.00481907e-02f, 1.69487018e-03f, -1.79271802e-01f,
  -2.50190999e-02f, 8.93829167e-02f, -8.19736347e-02f, -1.55247608e-02f, 1.01218365e-01f, -1.12269908e-01f, -3.96909900e-02f, -9.58576053e-02f, -7.27924407e-02f, 1.59721859e-02f,
  5.63143492e-02f, 7.80142546e-02f, 7.47036114e-02f, 2.61209644e-02f, 9.15851537e-03f, 7.72475377e-02f, 3.48319151e-02f, -6.27819821e-02f, -2.17529829e-03f, 5.44684976e-02f,
  -2.90304553e-02f, 2.96247099e-02f, 1.19151570e-01f, 1.04044653e-01f, 3.77316885e-02f, 6.18217550e-02f, 6.89855516e-02f, 2.80519500e-02f, 2.78343093e-02f, -3.82529944e-02f,
  -2.83154822e-03f, 2.04724241e-02f, 8.34092274e-02f, -3.19272454e-04f, -7.23430589e-02f, -5.22968061e-02f, -2.20382717e-02f, 2.40995530e-02f, -3.78140341e-03f, -4.63655479e-02f,
  -1.51203088e-02f, 3.11377887e-02f, 2.11562440e-02f, -3.87130640e-02f, -8.21738169e-02f, -5.24485596e-02f, 2.71514300e-02f, 6.35281801e-02f, -4.80902754e-02f, 7.45852292e-02f,
  -1.29399942e-02f, 4.74354178e-02f, -2.83983983e-02f, 5.80823608e-02f, 5.79406731e-02f, -7.24064484e-02f, -6.78569600e-02f, -3.66264507e-02f, 2.82648634e-02f, -6.06040284e-02f,
  -2.00921029e-01f, 2.44677082e-01f, -3.98330539e-02f, -5.49744181e-02f, 8.76108557e-03f, 4.84692119e-03f, 4.49451096e-02f, 1.95545647e-02f, 3.29520591e-02f, 5.06192967e-02f,
  3.37303453e-03f, -2.90699769e-02f, 3.74357365e-02f, 2.67402641e-02f, -1.90596711e-02f, -2.38123462e-02f, -1.66649595e-02f, -9.16896015e-02f, -4.26423885e-02f, 1.26510551e-02f,
  5.91887794e-02f, -1.78530402e-02f, -7.93291703e-02f, -8.86128023e-02f, 6.61152042e-03f, -1.76909417e-01f, -9.43036526e-02f, 2.02141814e-02f, -4.72853482e-02f, -7.29718804e-02f,
  -1.08703924e-02f, 4.56029586e-02f, -5.55523597e-02f, 8.50267261e-02f, 3.10244597e-02f, -7.46916384e-02f, -1.42019391e-02f, -5.77265956e-02f, 3.53988968e-02f, -7.01410919e-02f,
  -3.78616080e-02f, -6.27377778e-02f, 4.66987817e-03f, 2.84248441e-02f, 7.53856599e-02f, 2.90670954e-02f, 5.00318892e-02f, 8.66578594e-02f, 2.60445792e-02f, -5.01611717e-02f,
  4.72775027e-02f, 9.52661261e-02f, 8.01207647e-02f, -3.43405642e-02f, -5.04169147e-05f, -2.97982004e-02f, 1.50412181e-02f, 4.54469062e-02f, 1.77449286e-02f, 5.69366887e-02f,
  6.85946643e-02f, -5.36434241e-02f, -6.83625340e-02f, -3.51988748e-02f, -3.28343362e-03f, -1.21199237e-02f, 7.63963833e-02f, 9.12201777e-02f, -7.89834633e-02f, -3.22878337e-03f,
  -1.36571545e-02f, 3.65537740e-02f, -1.47358337e-02f, -4.75876592e-02f, 9.80617478e-02f, -4.81954589e-02f, 6.17807098e-02f, -1.36965513e-02f, -8.16717669e-02f, 3.93720604e-02f,
  6.59313351e-02f, 4.68875654e-02f, 9.01454315e-03f, 6.33668005e-02f, -2.29838211e-02f, 3.59561704e-02f, 5.51774614e-02f, -2.59590223e-02f, 1.97897777e-02f, -6.12939429e-03f,
  -7.16786459e-02f, -6.44562766e-02f, 8.69804248e-02f, 2.63825408e-03f, -1.01211511e-01f, 1.32141532e-02f, -1.26758097e-02f, -1.96159687e-02f, 4.90879565e-02f, 4.55957055e-02f,
  -3.56421955e-02f, 2.51393653e-02f, -7.87844732e-02f, -3.72752808e-02f, -4.50054966e-02f, 6.34794415e-04f, -7.12175444e-02f, -7.92394280e-02f, 3.82664911e-02f, 5.99075817e-02f,
  6.29567653e-02f, -3.72074470e-02f, 6.40871301e-02f, 7.82815516e-02f, -5.64822834e-03f, 2.65117344e-02f, -5.80297261e-02f, -7.54878521e-02f, -7.13682547e-02f, -5.57476394e-02f,
  -3.96030210e-02f, -5.50338626e-02f, 9.15299281e-02f, 3.66811343e-02f, -2.74321865e-02f, 6.85847700e-02f, 7.21483529e-02f, 6.34967312e-02f, 4.57419194e-02f, -9.89040919e-03f,
  -6.62275702e-02f, 8.61447677e-02f, 1.04537167e-01f, -4.03829031e-02f, 3.54149304e-02f, 6.35071993e-02f, 4.21416275e-02f, 8.33088011e-02f, -3.47742923e-02f, -1.71342567e-02f,
  -9.36747640e-02f, 1.59904528e-02f, 5.01918718e-02f, 1.26810782e-02f, -3.45721096e-02f, -4.67179529e-02f, -1.09650427e-02f, -6.79069385e-02f, 4.56755273e-02f, -4.05393951e-02f,
  -3.93001229e-01f, -2.63179168e-02f, -1.73519716e-01f, 1.65070713e-01f, 2.27571011e-01f, 2.38061458e-01f, 2.43780717e-01f, 1.20096818e-01f, 8.65888223e-02f, 1.00718737e-01f,
  7.98889473e-02f, 1.87105522e-01f, 8.94430131e-02f, 2.00909808e-01f, 1.48508742e-01f, 1.71016544e-01f, 2.28095666e-01f, 2.41115503e-02f, -6.33942187e-02f, 1.20814718e-01f,
  1.91591024e-01f, 1.22588150e-01f, -4.48265783e-02f, -2.19518561e-02f, 7.86966085e-02f, 2.18112916e-01f, 9.89488605e-03f, 2.97616720e-02f, 1.45428538e-01f, 1.97490856e-01f,
  -2.29147762e-01f, -1.70522794e-01f, 6.60694689e-02f, -5.09379059e-02f, -5.75023368e-02f, -7.90150985e-02f, -2.66106185e-02f, -1.87978640e-01f, -9.40282047e-02f, 6.19538268e-03f,
  -7.78438672e-02f, -1.27915218e-01f, 1.06534526e-01f, -7.32642263e-02f, -4.48779352e-02f, 1.13132922e-02f, -1.20369181e-01f, -5.04092388e-02f, 2.17777415e-04f, -3.86242755e-02f,
  1.32819101e-01f, -9.14467499e-02f, -1.01954073e-01f, 5.67141622e-02f, 5.20565137e-02f, -6.43088743e-02f, -9.91288349e-02f, -4.29645963e-02f, -1.47079825e-01f, -8.14179257e-02f,
  6.70675859e-02f, 4.96408604e-02f, -1.95978396e-02f, 6.75043538e-02f, -4.07541208e-02f, -2.77468152e-02f, -3.47166732e-02f, 1.10524759e-01f, -9.19345953e-03f, 1.60330832e-02f,
  -6.38160780e-02f, -3.03739272e-02f, 7.06192553e-02f, -6.44043162e-02f, 9.01145190e-02f, 4.90979664e-02f, 3.46795991e-02f, -1.75711624e-02f, -8.51771161e-02f, 9.41343792e-03f,
  -7.63919670e-03f, 4.59916443e-02f, -5.77422678e-02f, -5.20382598e-02f, 5.30705042e-02f, -8.14914182e-02f, -4.11630943e-02f, -8.36748332e-02f, 5.82840219e-02f, -5.09149283e-02f,
  1.84847787e-01f, -8.25809464e-02f, 8.04328322e-02f, 4.70831990e-02f, 1.13229761e-02f, -3.21300067e-02f, -7.05269352e-03f, -6.27141148e-02f, 1.73401069e-02f, 4.91945855e-02f,
  4.13771048e-02f, -8.59513283e-02f, -7.21207680e-03f, -2.13398449e-02f, -4.43664715e-02f, 2.28135362e-02f, -7.28345215e-02f, 6.62635416e-02f, -6.98814122e-03f, 1.56049235e-02f,
  4.46289256e-02f, 4.71566543e-02f, -3.38749327e-02f, -3.48114818e-02f, 3.76286432e-02f, 5.30044660e-02f, -2.10321452e-02f, 7.74165541e-02f, -3.66109633e-03f, 6.42804056e-02f,
  1.23876885e-01f, 6.46132752e-02f, 3.25047784e-02f, 1.31346583e-01f, 3.82595100e-02f, -8.64031762e-02f, -1.03775784e-01f, -4.69381921e-02f, -5.09625636e-02f, 4.62484024e-02f,
  6.97667769e-04f, -3.71607542e-02f, 3.61908576e-03f, -4.03245799e-02f, -1.62961200e-01f, -1.74238253e-02f, 4.43467684e-03f, -1.31528586e-01f, -2.23177243e-02f, -1.62663192e-01f,
  3.95940691e-02f, 4.51968350e-02f, -6.34029806e-02f, -3.89448479e-02f, 1.02278948e-01f, -2.31890455e-02f, 7.69526232e-03f, 6.07270376e-05f, -5.44087728e-03f, 9.51556787e-02f,
  -1.13546224e-02f, 1.52063191e-01f, -6.34809360e-02f, 3.12428660e-04f, 6.74427748e-02f, -8.57715830e-02f, 5.14450222e-02f, -5.95389726e-03f, 3.62352952e-02f, -9.13829717e-04f,
  -1.26512470e-02f, -2.58556549e-02f, 1.88818295e-02f, 3.79284695e-02f, -3.25908847e-02f, -4.86236736e-02f, 5.70806442e-04f, -1.15785688e-01f, -5.55673987e-02f, 3.97567935e-02f,
  -1.94048882e-02f, 6.29736632e-02f, -5.77892885e-02f, 2.50422414e-02f, 3.65187488e-02f, -8.44595581e-02f, 1.01623096e-01f, 6.60311058e-02f, 2.69925836e-02f, 1.20833144e-02f,
  6.97254688e-02f, -4.07092683e-02f, 9.15852562e-02f, -5.41369133e-02f, -1.35019971e-02f, 5.78517560e-03f, -9.70255677e-03f, 4.88070250e-02f, 3.66406925e-02f, 1.06738014e-02f,
  -8.80537108e-02f, -1.31216822e-02f, -3.56273055e-02f, 2.50087772e-02f, 8.95654410e-02f, -2.47923005e-02f, 7.02052265e-02f, 6.42523021e-02f, 6.22705482e-02f, 3.58268432e-02f,
  1.06601389e-02f, 1.90292709e-02f, -3.18047265e-03f, -5.43413348e-02f, 5.80369402e-03f, -1.15460185e-02f, -3.24389408e-03f, 7.11731017e-02f, 8.34906623e-02f, 6.94668218e-02f,
  9.61932242e-02f, 2.52907909e-02f, 4.63304967e-02f, 4.14247625e-02f, -2.33719479e-02f, 3.73707041e-02f, -1.28450459e-02f, -4.16634083e-02f, -3.61506129e-03f, 6.75536320e-02f,
  -8.41633976e-02f, 1.85021348e-02f, 9.32356790e-02f, -9.95477885e-02f, -3.78365652e-03f, 4.43045720e-02f, -2.28239484e-02f, -4.90295254e-02f, -3.71159650e-02f, 7.20266774e-02f,
  -8.80364627e-02f, -1.10279704e-02f, -1.39199957e-01f, -5.54943532e-02f, 2.02077236e-02f, 4.27964590e-02f, -8.85461122e-02f, 4.83850054e-02f, 3.06964293e-02f, 1.75943002e-02f,
  1.66993052e-01f, 1.46074519e-01f, 1.84255004e-01f, 1.40948012e-01f, 8.04372728e-02f, 2.12184355e-01f, 1.53164744e-01f, 6.43302202e-02f, -5.36825061e-02f, 1.39806913e-02f,
  -1.79634586e-01f, -5.27465083e-02f, -1.06772624e-01f, -1.53125087e-02f, 5.67080714e-02f, 6.96014315e-02f, -6.88145449e-03f, 9.25768018e-02f, 2.29894295e-02f, 2.77058198e-03f,
  -7.65780509e-02f, 4.21696119e-02f, 7.85200074e-02f, 4.74887043e-02f, 5.98451346e-02f, -3.50931548e-02f, 2.66084503e-02f, 1.46629393e-01f, 9.31216702e-02f, 5.90186715e-02f,
  -6.42677471e-02f, 6.69036806e-02f, -1.29741013e-01f, -7.26042241e-02f, 4.65336285e-04f, -4.42372076e-02f, -8.31796788e-03f, -7.93176368e-02f, 2.18066247e-03f, 5.09267151e-02f,
  5.89309353e-03f, 4.93558832e-02f, 2.97308564e-02f, 3.14764939e-02f, 9.68872234e-02f, -5.44318855e-02f, -4.93023992e-02f, -1.92781184e-02f, -6.57586455e-02f, -8.62802789e-02f,
  -1.43778563e-01f, 7.20645627e-03f, 1.15149744e-01f, -3.72513048e-02f, -2.87637971e-02f, 1.81858465e-02f, 3.30030657e-02f, 1.10329188e-01f, 7.76776969e-02f, 2.57685483e-02f,
  -1.05910257e-01f, -1.20835949e-03f, -1.38934040e-02f, 4.23609454e-04f, 1.14237051e-02f, 1.28428796e-02f, 7.57789239e-02f, 3.96162942e-02f, -7.49295438e-03f, -8.02579429e-03f,
  7.87180513e-02f, -2.22491678e-02f, 4.99712117e-02f, -4.99349982e-02f, -2.04463210e-02f, 2.92750392e-02f, 7.73575976e-02f, 9.00091790e-03f, 3.25702801e-02f, -3.53120528e-02f,
  -3.57302018e-02f, 1.36523219e-02f, -1.32033753e-03f, -3.84898707e-02f, 4.65062857e-02f, -5.13664186e-02f, 5.99039271e-02f, -9.89775732e-02f, -1.11583562e-03f, -5.25959097e-02f,
  -1.39806911e-01f, -1.11892864e-01f, -4.66354145e-03f, -2.22261306e-02f, 1.57119241e-02f, 2.21677143e-02f, -6.42862990e-02f, -5.25583839e-03f, -7.48309717e-02f, 1.07672788e-01f,
  4.92139719e-03f, -8.08504373e-02f, -4.03655954e-02f, 3.67639214e-02f, -1.40911946e-02f, -2.86148861e-02f, -2.00082958e-02f, 7.84972906e-02f, 4.50133421e-02f, -2.60281954e-02f,
  2.23384295e-02f, 7.80692250e-02f, -4.13862115e-04f, -2.72344667e-02f, 1.95927005e-02f, 2.07108725e-02f, -5.57134999e-03f, 8.09575394e-02f, -2.49672793e-02f, 2.52896380e-02f,
  3.22497077e-02f, -1.15643263e-01f, 1.49906039e-01f, -1.68491170e-01f, -1.29089639e-01f, -9.18132141e-02f, -8.48759264e-02f, -1.40148580e-01f, -8.91312584e-02f, -5.29019684e-02f,
  -9.22890007e-02f, -6.79019243e-02f, 5.99487044e-04f, -1.61700021e-03f, -5.00168353e-02f, 2.94405827e-03f, -8.65279138e-03f, 8.88449848e-02f, 4.67504002e-02f, 2.77241822e-02f,
  -5.04735522e-02f, -5.05794622e-02f, 4.01229486e-02f, -3.16764526e-02f, -1.63496751e-02f, -3.02185910e-03f, 4.42512743e-02f, -1.05230294e-01f, -4.56313975e-02f, -3.82394604e-02f,
  6.90919459e-02f, -2.54867156e-03f, -1.19494861e-02f, -2.05455832e-02f, 1.42682006e-03f, 6.39428496e-02f, 7.89829716e-02f, -6.48867413e-02f, -2.61723101e-02f, -4.50020842e-03f,
  -3.09282187e-02f, -5.16377278e-02f, -3.16719040e-02f, -7.49921426e-02f, 4.58143502e-02f, 3.14053111e-02f, -1.09922200e-01f, -7.77020678e-03f, 3.65514867e-02f, -8.89176652e-02f,
  -2.02407241e-02f, 1.37148732e-02f, 2.49822922e-02f, -1.70990247e-02f, -3.81884314e-02f, 1.53957114e-01f, -2.88737733e-02f, 6.55576736e-02f, 4.52993102e-02f, -1.63796563e-02f,
  -6.94375187e-02f, -8.12832639e-02f, 4.48948033e-02f, 3.84139903e-02f, -1.04225412e-01f, -2.31138896e-02f, -1.17204003e-02f, -9.54124853e-02f, 2.27557383e-02f, -8.95414725e-02f,
  -6.99185133e-02f, 9.02445987e-02f, -1.28704505e-02f, -8.80253762e-02f, -5.18047735e-02f, 8.07036180e-04f, -6.80946335e-02f, -1.23753687e-02f, 6.27568215e-02f, -3.94500121e-02f,
  5.82485609e-02f, 1.96810160e-02f, -1.82683952e-02f, -3.71370651e-03f, 6.53730193e-03f, -4.95316163e-02f, -5.75390980e-02f, 4.07018326e-02f, 8.64147395e-02f, 8.55875760e-03f,
  -6.58261925e-02f, 1.67866722e-01f, -4.28210525e-03f, 3.82094644e-02f, 5.44449836e-02f, -7.27013312e-03f, 2.02831049e-02f, -6.19447306e-02f, 7.82989487e-02f, 4.22124863e-02f,
  5.84093444e-02f, 8.26822966e-02f, -5.08738868e-02f, 1.40687460e-02f, 8.90468955e-02f, -2.40735766e-02f, 9.69517324e-03f, 9.95554924e-02f, 8.05466175e-02f, -3.81545015e-02f,
  -1.49705961e-01f, 2.31958590e-02f, 6.36742041e-02f, -6.07013851e-02f, -9.25476700e-02f, 1.41215861e-01f, 7.80921876e-02f, -5.95107004e-02f, 7.75691122e-02f, -7.43138865e-02f,
  -1.19355001e-01f, -9.10252109e-02f, 1.07727401e-01f, -1.32461876e-01f, -9.18240249e-02f, -1.16915576e-01f, -5.24865687e-02f, -1.61650240e-01f, -5.24603985e-02f, -9.30333957e-02f,
  -1.61061939e-02f, -4.65386733e-02f, 4.37574051e-02f, -9.07597020e-02f, 5.52067682e-02f, -1.03213660e-01f, -1.96831860e-03f, -9.01192203e-02f, -8.29744432e-03f, -1.23258643e-01f,
  -1.23999782e-01f, -1.86365321e-01f, -9.86842737e-02f, -1.04743987e-01f, 6.60701282e-03f, 4.42947038e-02f, -9.24118049e-03f, -5.33180051e-02f, 3.17681879e-02f, -3.57135199e-02f,
  -2.05786563e-02f, 1.46021977e-01f, -3.18810972e-03f, -2.43643615e-02f, -8.12487677e-02f, 5.64692169e-02f, -5.82721010e-02f, -4.02848125e-02f, 5.72016416e-03f, -3.65611166e-02f,
  -1.22159999e-02f, -4.03428962e-03f, 8.60460699e-02f, -3.53810121e-03f, 3.21716107e-02f, 4.22439463e-02f, -1.49493916e-02f, -5.90668395e-02f, 1.64700262e-02f, 6.69989884e-02f,
  8.70195329e-02f, 6.15512468e-02f, 1.15206458e-01f, 6.89010620e-02f, 2.17845701e-02f, 2.93751247e-02f, 7.79167637e-02f, -8.00367910e-03f, 1.79924387e-02f, -1.25523239e-01f,
  -7.78530985e-02f, -3.15562449e-02f, 4.34078239e-02f, -6.03868626e-02f, 4.65996079e-02f, 1.67005192e-02f, -2.64441464e-02f, -6.49267286e-02f, -5.35744242e-02f, 1.01842908e-02f,
  1.70567632e-02f, 1.15742020e-01f, -9.55296680e-02f, -6.85139224e-02f, 3.85372080e-02f, 3.52365971e-02f, -5.35746440e-02f, -7.55674168e-02f, 4.40253094e-02f, 7.74962008e-02f,
  -5.00255227e-02f, 4.23286390e-03f, 2.08071992e-02f, -1.44370003e-02f, 9.61833820e-02f, 8.81554037e-02f, 4.31910483e-03f, 7.99090713e-02f, -1.25643965e-02f, 5.05749062e-02f,
  -1.81053102e-01f, 1.57815561e-01f, -4.18795459e-02f, 3.23566757e-02f, -7.41955861e-02f, 5.82959615e-02f, 7.49970926e-03f, 8.53515863e-02f, 2.58885343e-02f, 2.40630824e-02f,
  2.42087953e-02f, -4.88547273e-02f, -2.83162924e-03f, 8.98897368e-03f, -7.86837935e-02f, 5.08497097e-02f, -5.30794263e-02f, 6.72528371e-02f, 1.01304501e-01f, -3.84714380e-02f,
  3.71068679e-02f, 4.12893891e-02f, -6.35056272e-02f, -1.09099951e-02f, 1.13143772e-01f, -5.83173707e-03f, -8.02744329e-02f, 2.67607588e-02f, -2.10292172e-02f, -1.49181798e-01f,
  1.94395289e-01f, 1.78222403e-01f, -1.42154070e-02f, 3.93579304e-02f, 1.78910904e-02f, 4.38341759e-02f, 1.99610386e-02f, 9.94915515e-02f, 1.27831772e-01f, 1.11151516e-01f,
  -1.06983177e-01f, -1.60406664e-01f, -1.66794786e-03f, -3.33300047e-02f, 2.92722844e-02f, 2.32744683e-02f, -2.96669547e-02f, 6.09376729e-02f, -1.27978057e-01f, -1.02804311e-01f,
  9.91792604e-02f, 7.78214447e-03f, 1.45662293e-01f, -5.23560084e-02f, 9.10289213e-02f, -4.74428087e-02f, -3.90040129e-02f, -5.84639795e-02f, -5.37862591e-02f, 3.23586427e-02f,
  -1.15330748e-01f, -1.29978973e-02f, -7.80112520e-02f, -1.09979078e-01f, -1.24962972e-02f, -4.63816747e-02f, -2.92898454e-02f, -2.15878915e-02f, -1.21879302e-01f, 7.61164799e-02f,
  -8.22669417e-02f, -8.04809183e-02f, -1.31868482e-01f, 1.18653560e-02f, -5.80796935e-02f, 1.94255859e-02f, -5.41461557e-02f, -4.80655283e-02f, -5.03227152e-02f, 1.94977727e-02f,
  -8.38786662e-02f, 7.47676380e-03f, -1.10246748e-01f, -8.44145492e-02f, -1.35564595e-01f, -1.36133321e-02f, -4.86432714e-03f, -9.48512480e-02f, -3.16190124e-02f, 1.07605137e-01f,
  -9.59697887e-02f, 3.22523266e-02f, 7.74282292e-02f, 1.60584040e-02f, 6.40548021e-02f, 3.05484384e-02f, -9.77402851e-02f, 4.88785468e-02f, -2.03598235e-02f, 7.51447082e-02f,
  -9.43242535e-02f, -3.45973335e-02f, -7.78548047e-02f, 2.69372459e-03f, -6.80317357e-02f, 4.92863730e-02f, 5.02055921e-02f, 4.51148115e-02f, -6.44926354e-02f, 9.07498971e-02f,
  -7.06505915e-03f, -5.92219532e-02f, -4.83587794e-02f, -9.92613584e-02f, -6.15287162e-02f, 4.74058352e-02f, 3.09965070e-02f, -2.65445374e-02f, 4.36250158e-02f, 1.46416053e-02f,
  7.81105384e-02f, -1.20002687e-01f, 1.57297272e-02f, -4.03788649e-02f, -2.72931214e-02f, -1.10532261e-01f, -1.01801462e-01f, -4.93116938e-02f, 2.23833062e-02f, 8.10062215e-02f,
  -5.35082594e-02f, -8.73789191e-02f, -6.67915940e-02f, -8.63494724e-02f, -2.23141676e-03f, -8.32733810e-02f, 4.31583785e-02f, 6.06130697e-02f, -8.00514668e-02f, -1.26635367e-02f,
  1.04330353e-01f, 1.13400519e-01f, 3.04430369e-02f, 9.01491120e-02f, 7.71135464e-02f, 3.92836742e-02f, -6.54957518e-02f, 9.15394574e-02f, -2.27908734e-02f, 2.30203390e-01f,
  2.75458306e-01f, 1.07962728e-01f, -7.84315914e-03f, 6.78819492e-02f, -9.18567479e-02f, -5.39622009e-02f, -1.30937576e-01f, -1.10615948e-02f, 2.34247670e-02f, -2.00719349e-02f,
  -4.68489304e-02f, -6.10239618e-03f, 1.97235271e-02f, 1.03092112e-01f, 6.15004227e-02f, -4.11398225e-02f, 5.80844060e-02f, 3.94688062e-02f, 1.26095533e-01f, 1.18553892e-01f,
  -4.68436182e-02f, 6.27275333e-02f, 1.99731916e-01f, -2.43241508e-02f, -3.64578664e-02f, 3.27978134e-02f, 1.04824416e-01f, 2.66732778e-02f, 3.74779887e-02f, 3.73335592e-02f,
  -1.08859073e-02f, 1.16369739e-01f, -2.31660549e-02f, -1.69928931e-02f, 6.79135248e-02f, 3.62960324e-02f, 1.11812735e-02f, 7.26796910e-02f, -6.61250204e-02f, -2.95022572e-03f,
  3.52124833e-02f, 1.82511676e-02f, 6.48898212e-03f, 9.26392227e-02f, 4.25167941e-02f, -8.53875950e-02f, 5.40730916e-02f, -1.60484202e-02f, -7.31330365e-02f, -2.26435252e-02f,
  -1.98607258e-02f, -7.06378445e-02f, -1.10311046e-01f, -6.28482923e-02f, 7.99030885e-02f, -6.27218783e-02f, -5.45201860e-02f, 4.77370657e-02f, -7.58516863e-02f, 6.10491894e-02f,
  -2.49071009e-02f, -1.71855949e-02f, -6.59219697e-02f, 9.02715325e-02f, -1.74721777e-02f, 4.99585047e-02f, -5.24479821e-02f, 6.77168816e-02f, 7.48677850e-02f, 8.80691409e-02f,
  4.66414541e-02f, 1.31726656e-02f, 7.67539963e-02f, -1.53971110e-02f, -4.67407592e-02f, 1.08560510e-02f, -5.50684109e-02f, -8.30102060e-03f, -9.07152332e-03f, 2.15528272e-02f,
  6.26854300e-02f, -6.79607242e-02f, -3.13709863e-02f, 2.92664976e-03f, 7.86416754e-02f, 1.56727415e-02f, 7.12131038e-02f, 2.24853847e-02f, 9.31748077e-02f, -7.48726055e-02f,
  4.56328318e-02f, -8.45445991e-02f, -2.20409576e-02f, -4.27177288e-02f, -8.59317854e-02f, 5.12368381e-02f, -8.60066637e-02f, -4.62089740e-02f, 5.28884456e-02f, -2.65534334e-02f,
  1.95973981e-02f, 7.75016099e-02f, -3.53651829e-02f, -4.87210415e-03f, -6.76259249e-02f, -3.65635306e-02f, 3.70858028e-03f, 4.03612293e-02f, 4.88992073e-02f, 6.68510869e-02f,
  -4.19950746e-02f, -4.07380760e-02f, -1.10970698e-01f, -7.47779664e-03f, -1.05611525e-01f, -1.11860111e-02f, -8.84334091e-03f, 1.29045509e-02f, -4.10717167e-02f, 1.06669776e-02f,
  -1.40909672e-01f, -1.22586735e-01f, 1.07287085e-02f, -4.50916477e-02f, 1.78047344e-01f, 7.87543952e-02f, 1.65533453e-01f, 8.41979757e-02f, 1.00972513e-02f, -9.91892368e-02f,
  -7.80375302e-03f, -6.93395883e-02f, 8.50568525e-03f, -1.90153420e-02f, 3.17379497e-02f, 7.23084137e-02f, -5.16661257e-02f, -5.94697706e-03f, 7.84468800e-02f, 7.83498771e-03f,
  -6.10718178e-03f, -1.29188038e-02f, -1.83053259e-02f, 7.60015622e-02f, -8.94374177e-02f, -1.02270795e-02f, -6.69069588e-02f, 2.55690143e-02f, 4.67602462e-02f, -6.24543913e-02f,
  -1.95744917e-01f, 2.09501833e-02f, 7.48882592e-02f, -4.57035750e-02f, -6.92782598e-03f, 3.78862768e-02f, -6.33107051e-02f, -6.89960830e-03f, 2.63604093e-02f, -6.49901479e-02f,
  -5.78114502e-02f, -8.55850428e-02f, -5.09689748e-02f, -4.09351513e-02f, -2.65135914e-02f, 5.78107350e-02f, -7.28729591e-02f, -5.15350774e-02f, -1.86140761e-02f, -8.08810964e-02f,
  7.95935318e-02f, 4.38137539e-02f, 2.64442936e-02f, -8.95940810e-02f, -1.09922357e-01f, 8.09729192e-03f, -9.17284265e-02f, -2.58504022e-02f, 4.54333685e-02f, -5.57159781e-02f,
  -4.20264015e-03f, -5.46733756e-03f, -7.37316087e-02f, -1.00663915e-01f, 4.89943065e-02f, -6.28966466e-02f, -8.23863819e-02f, -3.77255753e-02f, 7.18297949e-03f, 7.65340328e-02f,
  1.79769658e-02f, -1.25133004e-02f, -5.38634323e-02f, 5.28548099e-02f, -7.31585696e-02f, 8.95142928e-02f, 1.15154497e-02f, 7.46424869e-02f, 8.45659003e-02f, 7.66982436e-02f,
  -8.15059543e-02f, 7.80285615e-03f, -7.49174505e-02f, 2.35034041e-02f, 5.38570397e-02f, 4.99343686e-02f, -1.66229382e-02f, -3.01588587e-02f, 4.59124446e-02f, -2.37515792e-02f,
  -5.74561991e-02f, 3.16828936e-02f, -1.05333716e-01f, -1.14251561e-01f, -9.66525376e-02f, -3.60515900e-02f, -2.23697163e-02f, 3.66327949e-02f, -1.02481820e-01f, -6.87295124e-02f,
  -2.91077122e-02f, -1.82277709e-02f, -8.37806389e-02f, -5.02666049e-02f, 5.14369719e-02f, -5.09653166e-02f, 5.06216381e-03f, 1.20272189e-02f, 5.85716888e-02f, 1.08766183e-02f,
  -7.56897181e-02f, 7.65847564e-02f, -3.12547870e-02f, -5.18249720e-02f, 6.36293218e-02f, -9.94541943e-02f, 1.11769848e-02f, 4.03023474e-02f, 2.88287774e-02f, 1.45521360e-02f,
  -1.37550458e-01f, 1.50242940e-01f, 1.28677174e-01f, -1.27885461e-01f, 2.94360938e-03f, 1.01976525e-02f, 1.35976717e-01f, -4.27912809e-02f, -2.90376060e-02f, 1.09477989e-01f,
  4.63036597e-02f, -4.01963741e-02f, -2.98708701e-03f, -4.96590286e-02f, -1.13419361e-01f, 1.53939947e-01f, 1.12990946e-01f, -5.50436489e-02f, -1.52132422e-01f, -1.54165654e-02f,
  -1.29535705e-01f, -1.21739402e-01f, -3.99479531e-02f, -2.28066202e-02f, 2.85027977e-02f, -8.94074887e-02f, -2.82899737e-02f, -7.00782165e-02f, -3.07509191e-02f, 1.05293944e-01f,
  1.63831949e-01f, 1.16308346e-01f, -1.03058249e-01f, -6.96541592e-02f, -6.52783066e-02f, 2.03756541e-02f, 4.14000936e-02f, 2.17793300e-03f, -7.50857219e-02f, -5.06162532e-02f,
  -3.54961716e-02f, -9.98748541e-02f, -7.65909925e-02f, -5.19057587e-02f, -3.43058854e-02f, -8.19512382e-02f, 5.28709367e-02f, -2.65785176e-02f, 6.29012063e-02f, 3.24180648e-02f,
  -2.09170170e-02f, 9.60182957e-03f, 2.67744740e-03f, 7.10288286e-02f, 8.19832534e-02f, -3.23330350e-02f, 6.50361404e-02f, 3.94391082e-02f, -3.43975052e-02f, 1.03888072e-01f,
  5.02908640e-02f, 3.48121226e-02f, -8.41168314e-03f, 6.32124627e-03f, -4.55393046e-02f, -6.18735626e-02f, 6.32313043e-02f, -4.17838655e-02f, -2.70414585e-03f, -1.78164449e-02f,
  -8.24871212e-02f, 9.07617286e-02f, -3.66755985e-02f, 3.05041112e-02f, -5.21160588e-02f, 4.00719605e-02f, 7.52861574e-02f, 7.30148926e-02f, -3.41333374e-02f, -6.49773004e-03f,
  4.51063886e-02f, -5.19996211e-02f, 7.91845024e-02f, -4.05761003e-02f, 1.14714555e-01f, -6.67816103e-02f, -2.14108992e-02f, -6.49822205e-02f, 7.09805340e-02f, -7.05622286e-02f,
  -2.08349943e-01f, 9.45054833e-03f, -7.47759417e-02f, -1.08240426e-01f, -6.51702881e-02f, -6.32690936e-02f, 3.68683622e-03f, 1.46478647e-02f, 8.70701447e-02f, 7.63168857e-02f,
  9.19438750e-02f, 1.12910205e-02f, -1.83152705e-02f, -5.71623668e-02f, -1.52407229e-01f, -2.96165980e-02f, -2.50553116e-02f, -1.26928151e-01f, 4.46688458e-02f, -3.52494493e-02f,
  3.91488895e-02f, 5.33235120e-03f, -1.06068589e-01f, -1.00110590e-01f, -6.28102645e-02f, 8.63032416e-03f, -1.07618108e-01f, -1.08814031e-01f, -6.39856234e-02f, -7.39922822e-02f,
  -1.87507063e-01f, -1.11942008e-01f, -8.44184458e-02f, -2.23881543e-01f, -1.55457363e-01f, 5.99130206e-02f, 1.41804973e-02f, -7.39636943e-02f, -1.33646384e-01f, -1.45401880e-01f,
  -3.58856916e-02f, -1.17389880e-01f, -3.94400246e-02f, 4.19400707e-02f, -7.86567330e-02f, 3.74342129e-02f, -9.79827270e-02f, -1.30521432e-01f, -5.63287847e-02f, -1.15483172e-01f,
  -1.31829321e-01f, -2.70674646e-01f, -2.17871711e-01f, -1.51511177e-01f, -1.84521466e-01f, -9.34825689e-02f, -2.06352338e-01f, -1.82142958e-01f, -5.90941943e-02f, -1.50047451e-01f,
  -7.53988475e-02f, -2.19862759e-02f, 5.92225790e-02f, -3.96065749e-02f, -9.63669792e-02f, 3.96567509e-02f, -3.40952352e-02f, -1.34774242e-02f, 1.60976145e-02f, -7.46035576e-02f,
  -3.99892032e-02f, 2.09592227e-02f, -6.00053743e-02f, -7.68538117e-02f, -6.62542507e-02f, 8.05989504e-02f, 1.98572967e-03f, 1.52588859e-02f, -5.46991676e-02f, 8.06373283e-02f,
  -1.25206560e-02f, 1.91484336e-02f, 5.85856289e-02f, -1.49833895e-02f, -2.08230074e-02f, -1.32215244e-03f, 4.39233705e-02f, 2.99540185e-03f, 7.53472224e-02f, -6.70260713e-02f,
  2.95471270e-02f, 5.78600578e-02f, -5.55395633e-02f, 1.10512394e-02f, 4.96825762e-02f, 7.14821368e-02f, -7.48119801e-02f, -8.03396925e-02f, 7.82909710e-03f, -1.05400011e-02f,
  3.64316255e-02f, -2.66422331e-02f, -1.09304488e-02f, -6.39043190e-03f, 1.65736191e-02f, 2.52912100e-02f, -3.44560966e-02f, -6.29590005e-02f, 1.47972265e-02f, 1.75461061e-02f,
  4.62376773e-02f, -7.99948722e-02f, -2.85338182e-02f, 1.15870414e-02f, 7.18611479e-02f, 1.82527006e-02f, 8.86358172e-02f, 5.96323982e-02f, -3.60870287e-02f, 5.60055338e-02f,
  -2.05186680e-01f, 2.08530843e-01f, 3.19437347e-02f, 7.94295669e-02f, 7.05103949e-02f, 4.98169065e-02f, 3.18649635e-02f, -3.99994589e-02f, -5.15193269e-02f, 3.41937020e-02f,
  -3.91674712e-02f, 1.58861466e-02f, -7.06529766e-02f, -5.27235866e-02f, -1.91839486e-02f, 4.64247987e-02f, 1.07809333e-02f, 8.78072251e-03f, -7.97734689e-03f, 4.92278114e-02f,
  -9.56589077e-03f, -7.18117803e-02f, -9.35904682e-02f, 1.82789266e-02f, 4.96471673e-02f, -1.39690470e-02f, -2.56468058e-02f, -1.47832911e-02f, 1.20222168e-02f, -1.97839603e-01f,
  1.45731494e-02f, -2.44854406e-01f, -2.38080442e-01f, -9.01611224e-02f, -4.27524596e-02f, -1.20334521e-01f, -1.90947752e-03f, 8.46661031e-02f, -3.27328630e-02f, -5.13630286e-02f,
  -1.24482512e-01f, 4.21318784e-02f, 3.88009101e-02f, -2.54976451e-02f, -1.10194325e-01f, -1.56569615e-01f, -2.24230871e-01f, -8.22326839e-02f, 9.33919847e-02f, 7.55473748e-02f,
  -8.47406164e-02f, 4.30469476e-02f, 3.83576341e-02f, 2.71501876e-02f, -1.08038522e-02f, -8.12701210e-02f, -1.29766285e-01f, -5.54031022e-02f, -1.24916583e-01f, -8.90252888e-02f,
  -9.85755771e-02f, 6.04050513e-03f, -4.29538637e-02f, 7.65338391e-02f, -5.17524965e-02f, 8.33570398e-03f, -5.00337481e-02f, -2.68983226e-02f, 4.39911559e-02f, -4.63057980e-02f,
  -2.90919933e-02f, 5.98729998e-02f, 2.74489224e-02f, 1.23457238e-02f, -3.76698151e-02f, 5.05906940e-02f, -2.84277964e-02f, -9.35485438e-02f, -3.27183679e-02f, -1.46422973e-02f,
  -9.56334025e-02f, 3.67122293e-02f, -4.16402519e-02f, 6.68259477e-03f, -4.18286324e-02f, 2.95015574e-02f, -1.30229723e-02f, 2.82150097e-02f, 5.46388626e-02f, -9.28216055e-02f,
  -9.56540257e-02f, 3.36832292e-02f, 2.80269254e-02f, -4.34937626e-02f, -1.86373852e-02f, 6.34886697e-02f, -8.87298957e-02f, 4.37575690e-02f, -2.70817187e-02f, -1.14189275e-02f,
  -4.28059883e-02f, 1.19539853e-02f, -5.82508855e-02f, 1.79381110e-03f, -7.11153969e-02f, 3.72841246e-02f, 1.26757333e-02f, -2.22184509e-02f, -3.87224704e-02f, -2.45538931e-02f,
  -1.65594497e-03f, 3.01527837e-03f, -6.94691688e-02f, 1.58893913e-02f, -5.91468252e-02f, -3.13767269e-02f, -2.73653516e-03f, 5.80119193e-02f, 4.55224849e-02f, -2.55276635e-02f,
  1.16618641e-01f, -7.71562904e-02f, -2.95686666e-02f, -4.50782431e-03f, -3.00011281e-02f, -7.23794475e-02f, 1.01847192e-02f, -3.02737206e-02f, -4.37932126e-02f, 6.36607111e-02f,
  2.31489558e-02f, -1.72524266e-02f, 1.86808500e-02f, 3.01713459e-02f, 7.82194510e-02f, 1.00834630e-02f, 4.10049371e-02f, -3.32570784e-02f, 6.71346560e-02f, -1.09687187e-02f,
  -3.21576633e-02f, 3.75084393e-02f, -4.99115214e-02f, 3.15607563e-02f, 9.87147763e-02f, 4.40179482e-02f, 3.67779955e-02f, 2.97122356e-02f, -4.33970578e-02f, -8.89458209e-02f,
  2.37748727e-01f, -1.75226718e-01f, -3.62400822e-02f, -8.44823718e-02f, -1.30090013e-01f, -1.69214875e-01f, -2.00087652e-01f, 4.15975936e-02f, 1.36794802e-02f, -9.13503245e-02f,
  9.63965952e-02f, 1.80524021e-01f, 2.78573900e-01f, 1.45838186e-01f, 2.08478987e-01f, -1.38491960e-02f, -3.88591806e-03f, 1.68175399e-01f, 1.48332641e-01f, -1.01820484e-01f,
  -1.58100218e-01f, -9.48901102e-02f, 7.14806989e-02f, 5.96597306e-02f, -7.61868879e-02f, 5.72928153e-02f, -3.30970138e-02f, -7.08278120e-02f, -1.99152250e-02f, -8.98211896e-02f,
  -2.83768978e-02f, 5.81972487e-02f, 1.19699188e-01f, 1.10149451e-01f, 2.89876293e-03f, -5.59472814e-02f, 6.44841939e-02f, -5.54879084e-02f, -8.76593515e-02f, 5.93481399e-03f,
  -7.76753128e-02f, 2.46000160e-02f, -8.70154053e-03f, -6.48690239e-02f, -7.86291808e-02f, -7.63928294e-02f, 4.85542417e-02f, 1.10595129e-01f, 8.92450940e-03f, 1.29752618e-03f,
  6.79586828e-03f, -1.12845279e-01f, -2.66034398e-02f, 3.15561146e-02f, 8.19408447e-02f, 1.53219476e-01f, -3.00453305e-02f, -3.14251445e-02f, 8.15951154e-02f, -9.85051841e-02f,
  -9.51467827e-03f, 3.33667099e-02f, 6.51673526e-02f, -3.21328975e-02f, 4.13079560e-02f, -3.90670672e-02f, 9.77920368e-04f, -4.97387983e-02f, 3.16644907e-02f, 2.81174667e-02f,
  -2.17670146e-02f, 6.29766956e-02f, 2.71358341e-02f, -7.90134631e-03f, -2.81330142e-02f, -2.74982899e-02f, -1.22528244e-02f, 3.58805060e-02f, 1.38539337e-02f, 1.16807427e-02f,
  1.14739435e-02f, -1.37425994e-03f, 4.87435497e-02f, -8.01381934e-03f, -3.77835035e-02f, -1.11537229e-04f, -6.41756207e-02f, -4.86159734e-02f, 5.19378483e-02f, -7.71783743e-05f,
  -7.18525127e-02f, 1.67982280e-01f, -1.08073680e-02f, 7.61007667e-02f, -2.36085244e-02f, -6.95611015e-02f, -1.10631119e-02f, -5.46417385e-03f, -7.86127150e-03f, -1.94067676e-02f,
  -9.32468325e-02f, 9.66043994e-02f, 5.44605069e-02f, -3.71024683e-02f, -1.97735224e-02f, -3.22565815e-04f, 1.02783330e-02f, -2.09979583e-02f, 8.51721317e-02f, -8.57118964e-02f,
  -9.08654034e-02f, 2.25614645e-02f, 8.22604448e-02f, 6.62038848e-02f, -7.17079192e-02f, 7.79819340e-02f, 9.95809585e-03f, 4.68089357e-02f, 7.19163567e-02f, -1.84102148e-01f,
  -7.86417257e-03f, -2.11742446e-02f, -6.90928921e-02f, 6.53900253e-03f, -1.01793870e-01f, -7.34076500e-02f, 3.03955935e-02f, -6.75607147e-03f, -3.48505080e-02f, -4.76366840e-02f,
  1.58859305e-02f, 1.15761280e-01f, -1.54882111e-02f, 6.69701071e-03f, -4.04860899e-02f, 5.03451712e-02f, -2.09803078e-02f, 9.25645605e-02f, 7.54726827e-02f, 1.84940696e-02f,
  5.86228184e-02f, -1.09462388e-01f, -4.95649464e-02f, 5.62895350e-02f, -7.30537772e-02f, 3.52902822e-02f, 3.38149890e-02f, -4.05179486e-02f, 6.08568154e-02f, -9.22887176e-02f,
  -5.59496731e-02f, -2.05310639e-02f, 4.88619953e-02f, -8.77781247e-04f, -9.09062400e-02f, 3.28578576e-02f, 3.72911803e-02f, -8.83881971e-02f, 6.50024414e-02f, 5.28078564e-02f,
  2.26685423e-02f, -1.04978746e-02f, -2.65113059e-02f, 5.28038815e-02f, -8.42166170e-02f, -8.59829634e-02f, 6.88436702e-02f, 2.93457359e-02f, 4.58988808e-02f, -6.81303740e-02f,
  -6.99027032e-02f, -1.03396036e-01f, 1.13238739e-02f, -2.86644995e-02f, -6.97754547e-02f, 5.68940267e-02f, 3.29215676e-02f, -6.67210445e-02f, 1.22860400e-03f, -3.47043052e-02f,
  -2.42958497e-03f, -7.58115724e-02f, -1.89802255e-02f, 6.86359629e-02f, 3.54679674e-02f, -4.74075526e-02f, 1.34621728e-02f, -4.43352684e-02f, 2.92169936e-02f, 3.83078568e-02f,
  -1.50613720e-02f, 4.41740081e-02f, -7.99143538e-02f, 7.63644874e-02f, -1.92173403e-02f, 4.62242775e-02f, 7.30801225e-02f, -7.65563920e-02f, -6.21882938e-02f, 5.63801862e-02f,
  -2.28678454e-02f, -8.17784145e-02f, -6.06398620e-02f, -6.35333508e-02f, 6.23373613e-02f, 8.72342139e-02f, 2.66632475e-02f, -5.32445638e-03f, -6.85197953e-03f, 3.81157026e-02f,
  -3.36925238e-02f, 8.87029395e-02f, -7.01134130e-02f, -5.73141426e-02f, -9.28116590e-02f, 7.80372089e-03f, -5.68511188e-02f, 5.18035553e-02f, 9.08488855e-02f, -6.97142482e-02f,
  5.77036999e-02f, -3.76394391e-02f, -2.61004306e-02f, 8.56805127e-03f, -5.41255139e-02f, 4.49275970e-03f, -8.31434652e-02f, 8.20641667e-02f, 7.10337088e-02f, 5.56760430e-02f,
  -5.68940006e-02f, -1.08828573e-02f, -5.42444848e-02f, 1.36262812e-02f, 8.33480135e-02f, -5.94416000e-02f, 6.54481947e-02f, -2.56321486e-02f, 3.88700627e-02f, -5.61103411e-03f,
  3.02824616e-01f, -6.10506944e-02f, 4.39939164e-02f, -1.47163868e-02f, -9.18278471e-02f, -4.79695275e-02f, -1.53579846e-01f, -1.23697920e-02f, 1.12845995e-01f, -3.54502983e-02f,
  -1.29578292e-01f, 2.55225692e-02f, 1.42307319e-02f, 5.60197309e-02f, 1.06981717e-01f, 1.34546692e-02f, -2.50048935e-02f, 1.12459794e-01f, 1.87010899e-01f, 2.11811103e-02f,
  -1.38131215e-03f, 5.59707470e-02f, -4.56526224e-03f, 1.09484635e-01f, 1.35550760e-02f, 8.31708685e-02f, -9.33240503e-02f, 4.04965170e-02f, -4.27205442e-03f, 8.64455923e-02f,
  -3.03035155e-02f, -1.46528464e-02f, 5.81066310e-02f, -3.06216944e-02f, -1.33556172e-01f, 7.72570670e-02f, 6.42427877e-02f, 7.93410912e-02f, -1.04876056e-01f, 4.37591709e-02f,
  -9.46450308e-02f, 4.74275351e-02f, -4.11638692e-02f, -2.22531967e-02f, 4.05046158e-02f, -7.51668885e-02f, -5.74202016e-02f, -3.37919816e-02f, -5.85574051e-03f, -6.42876402e-02f,
  -2.90788673e-02f, -4.22347337e-02f, 4.20722216e-02f, -5.16952761e-02f, -7.65597671e-02f, 9.76194516e-02f, -1.07964970e-01f, 8.30274075e-02f, 6.40204623e-02f, 1.21696383e-01f,
  -3.13319750e-02f, -4.44876365e-02f, 3.31451148e-02f, 1.92098040e-02f, -5.06884083e-02f, 2.23358423e-02f, 5.47089614e-03f, -6.06304593e-02f, -1.03089213e-02f, -1.73400529e-02f,
  -6.36110380e-02f, -7.23720854e-03f, -1.17465956e-02f, -7.88714853e-04f, 6.85070753e-02f, 3.07961572e-02f, -2.67808251e-02f, -8.47043246e-02f, 5.66376522e-02f, -7.94977620e-02f,
  -4.10847180e-02f, 7.22350180e-02f, 4.03441750e-02f, 1.93764083e-02f, -2.22740509e-03f, 5.41499332e-02f, 1.54282106e-02f, 7.67114060e-03f, -4.11423817e-02f, 4.37590070e-02f,
  -3.43589708e-02f, 4.13290374e-02f, 5.52495830e-02f, 9.10153091e-02f, -6.46068454e-02f, -3.23972814e-02f, -7.53041655e-02f, -5.96126681e-03f, 2.45685857e-02f, -1.19549828e-02f,
  -8.79047439e-02f, 5.67418896e-02f, -2.45899279e-02f, -5.53668253e-02f, -3.21550593e-02f, 5.40496558e-02f, 2.04289444e-02f, -3.65951434e-02f, 3.99114266e-02f, -2.46595661e-03f,
  -8.73638839e-02f, 2.42535733e-02f, 9.32066888e-02f, 3.59367840e-02f, 8.05536658e-02f, 8.66067708e-02f, -1.03733070e-01f, 3.96478623e-02f, 7.05670118e-02f, 6.13176748e-02f,
  1.59645408e-01f, 6.25901446e-02f, -1.04383096e-01f, 8.74822289e-02f, -1.00960821e-01f, -7.89628625e-02f, -3.10395975e-02f, 1.18180709e-02f, 8.94241706e-02f, 5.03597707e-02f,
  4.15040702e-02f, -7.30070425e-03f, 3.55762653e-02f, -1.03327580e-01f, -1.76897459e-02f, -3.20360139e-02f, -6.93399906e-02f, -8.81640241e-02f, 9.37399827e-03f, 6.41046464e-02f,
  5.95117994e-02f, 4.81807664e-02f, -6.04498684e-02f, -6.44830465e-02f, 2.06397213e-02f, -1.39006257e-01f, 1.27656208e-02f, -7.30807111e-02f, -7.07879812e-02f, 5.01791723e-02f,
  -7.23084062e-02f, 3.18359621e-02f, -3.88005190e-02f, -1.65279619e-02f, -9.39672161e-03f, -2.48271357e-02f, 3.27252224e-02f, 8.50360990e-02f, -8.86930060e-03f, -2.68228594e-02f,
  6.20753095e-02f, 3.59603390e-02f, 7.22098202e-02f, -4.19879407e-02f, 1.80640146e-02f, 6.05934337e-02f, 7.14397337e-03f, 1.12141840e-01f, 4.44183722e-02f, 2.54453681e-02f,
  9.70394642e-04f, -5.78226559e-02f, 6.01194166e-02f, 2.43926886e-02f, -1.39537011e-03f, -1.22520380e-01f, -3.89766991e-02f, -2.09445562e-02f, -6.61728159e-02f, 1.29798084e-01f,
  -7.02338666e-02f, 1.03756611e-04f, -1.95953827e-02f, 8.27189349e-03f, 2.26608533e-02f, -5.70748635e-02f, 2.67200992e-02f, -1.00528203e-01f, -3.01984567e-02f, -4.49549854e-02f,
  4.31194678e-02f, 3.50662991e-02f, 9.72781423e-03f, -3.54562551e-02f, -3.98103260e-02f, 3.76319885e-02f, -1.42073659e-02f, -2.13424861e-02f, -6.27156794e-02f, 7.92181399e-03f,
  6.35856837e-02f, 2.32934207e-02f, 5.09843305e-02f, -7.71241486e-02f, 8.24355241e-03f, 2.23249197e-02f, -2.96198595e-02f, 3.86326909e-02f, -7.96414167e-02f, 1.21007999e-02f,
  2.32091751e-02f, -3.73490117e-02f, 4.34207805e-02f, 1.09547526e-01f, -7.60924667e-02f, 6.57595992e-02f, -3.31872851e-02f, 1.08479848e-02f, 6.64803907e-02f, 2.35889964e-02f,
  -4.91988584e-02f, 5.85223623e-02f, 2.08222605e-02f, -3.22269672e-03f, 4.42255056e-03f, 8.32675677e-03f, 6.49945214e-02f, 5.82875945e-02f, -1.45592587e-02f, 1.24091715e-01f,
  4.79347035e-02f, 4.69761379e-02f, -7.85162821e-02f, -1.28832413e-02f, 6.40706122e-02f, 2.54707094e-02f, -1.76983532e-02f, -6.00285530e-02f, -1.20997332e-01f, 3.19023095e-02f,
  -1.02066360e-01f, -1.80031016e-01f, -1.63064599e-01f, -1.38753474e-01f, -6.03169911e-02f, 1.56044379e-01f, 6.05370142e-02f, 3.95400450e-03f, -6.34397194e-02f, -1.44751102e-01f,
  -7.97702596e-02f, -3.40803489e-02f, -5.12519702e-02f, -3.64026576e-02f, 4.40234952e-02f, -1.50090367e-01f, -1.43642455e-01f, -8.63317773e-02f, 6.88555539e-02f, 1.94162473e-01f,
  2.35182252e-02f, 2.00592373e-02f, -6.54920861e-02f, -6.11534342e-02f, -1.43878788e-01f, -1.21676795e-01f, -1.72451973e-01f, -8.62702876e-02f, -9.61958021e-02f, -1.35979369e-01f,
  -1.06257826e-01f, 6.69132695e-02f, 7.94322267e-02f, 7.58056864e-02f, 7.80056976e-03f, -6.90281317e-02f, -6.43158555e-02f, -4.41832356e-02f, -6.17050240e-03f, -3.41474228e-02f,
  -9.71310735e-02f, 1.00441746e-01f, -8.53517130e-02f, 5.22724688e-02f, 8.74033198e-02f, 2.55025309e-02f, -5.91689609e-02f, -1.28042344e-02f, -1.46287726e-02f, 1.15423694e-01f,
  -7.11465348e-03f, 9.02764797e-02f, 4.41184491e-02f, 7.55836964e-02f, 8.43258128e-02f, -2.32190378e-02f, 8.52053165e-02f, 6.51592985e-02f, 3.34667340e-02f, 3.84060554e-02f,
  1.87527966e-02f, -4.84963879e-02f, 6.77409992e-02f, -3.37722264e-02f, -1.40097365e-02f, -5.01330569e-02f, -3.94601338e-02f, 3.64135876e-02f, -3.67120020e-02f, -7.75519982e-02f,
  -5.72103914e-03f, 1.24836639e-02f, -3.53200547e-02f, -9.97010618e-02f, 3.90184671e-02f, 5.14006354e-02f, -4.17525880e-03f, -2.98549887e-02f, -5.34443855e-02f, -3.15241894e-04f,
  7.12150931e-02f, 1.18154800e-03f, 1.44643197e-02f, 1.46985520e-02f, 3.04959714e-02f, 5.08590825e-02f, -6.94459751e-02f, -9.80548188e-03f, -4.35088947e-02f, 6.91669583e-02f,
  -7.44094700e-02f, 1.40084893e-01f, 8.81807506e-03f, 2.69351318e-03f, -1.12161092e-01f, 5.28461710e-02f, -5.71561567e-02f, -8.16144943e-02f, -2.50318758e-02f, 9.38269272e-02f,
  1.07432351e-01f, 7.24831074e-02f, -7.59575237e-03f, -1.78357884e-02f, 3.60664688e-02f, 5.18655106e-02f, -9.55271646e-02f, -1.95402149e-02f, 1.04097806e-01f, 6.12680390e-02f,
  8.27163644e-03f, 4.52928543e-02f, -7.18595088e-02f, -2.51850765e-02f, 4.85886121e-03f, 7.32538551e-02f, 3.87330004e-03f, -8.87605827e-03f, 9.79272127e-02f, -1.63459554e-02f,
  1.46633297e-01f, 3.11314967e-02f, 1.00285202e-01f, 5.54414652e-02f, 1.06363587e-01f, 1.33429915e-01f, 1.65318772e-02f, 7.51360226e-03f, 6.52335435e-02f, 1.07892072e-02f,
  1.07605867e-01f, 1.32110402e-01f, 7.41255283e-02f, 1.21365130e-01f, -6.62931765e-04f, -1.68222953e-02f, -7.65483305e-02f, 8.77916217e-02f, 9.99506414e-02f, -5.78527488e-02f,
  6.58925325e-02f, -5.82788400e-02f, -5.76848313e-02f, -2.92366333e-02f, -4.09089848e-02f, -5.26345428e-03f, 4.59056832e-02f, 8.54873564e-03f, -3.63980159e-02f, -9.40083861e-02f,
  7.99981430e-02f, 1.24383941e-01f, -3.63176875e-03f, 2.62066685e-02f, -5.02942167e-02f, -8.10523927e-02f, 1.47685502e-02f, 1.09841581e-02f, -1.33327069e-02f, 1.41371938e-03f,
  3.32644172e-02f, -1.00286476e-01f, 1.41143687e-02f, -1.20324560e-01f, -1.00800700e-01f, 1.72856674e-02f, 2.29720008e-02f, -1.20995427e-02f, -3.20737101e-02f, 6.81838840e-02f,
  9.54976305e-03f, -3.19878981e-02f, 5.52240666e-03f, -3.42879929e-02f, -6.23885505e-02f, 1.87452789e-02f, -1.75286066e-02f, 7.68621936e-02f, -6.56715333e-02f, -1.12795971e-01f,
  3.09296474e-02f, 1.04708008e-01f, 1.02715172e-01f, -3.85325626e-02f, 7.63524994e-02f, -6.99491054e-02f, -9.40675009e-03f, -4.66715135e-02f, -4.18797210e-02f, -8.47171545e-02f,
  1.26693740e-01f, -1.74886156e-02f, 1.06078293e-02f, 3.68307754e-02f, 7.91781023e-02f, 7.74951577e-02f, 7.43336901e-02f, -1.01233914e-03f, -1.24205258e-02f, 9.50423628e-03f,
  -1.34495357e-02f, -9.10315779e-04f, -6.50405511e-02f, 7.64177069e-02f, -4.67122272e-02f, 7.19861612e-02f, 3.13364938e-02f, 4.20897640e-02f, -2.24200282e-02f, -4.52218689e-02f,
  3.21108382e-04f, 1.10784443e-02f, 5.80063425e-02f, 3.79348844e-02f, 6.99999090e-03f, -8.05282444e-02f, -5.55105656e-02f, -1.00110725e-01f, -7.45639876e-02f, 5.16092964e-02f,
  1.43243466e-02f, 3.93372811e-02f, 1.49875507e-02f, -4.97671403e-02f, -2.26888694e-02f, -9.47103426e-02f, -4.09664288e-02f, -9.36104283e-02f, 5.94029203e-02f, -3.40070650e-02f,
  -2.08203476e-02f, 3.95512655e-02f, 8.23200867e-02f, 1.45286834e-02f, 1.78425610e-02f, 5.42122908e-02f, 6.86699618e-03f, -1.69589408e-02f, 2.89462879e-03f, -1.73229389e-02f,
  -4.96443436e-02f, 3.17830443e-02f, -6.51723221e-02f, 1.03493541e-01f, 4.98735011e-02f, -7.74084255e-02f, -2.13723540e-01f, -1.42463848e-01f, -2.37122830e-02f, 5.88893630e-02f,
  3.16565298e-02f, 4.96246517e-02f, -1.38982916e-02f, 3.73514183e-03f, -1.41417384e-01f, 2.79284902e-02f, 9.80614647e-02f, 1.71991289e-02f, 2.94447243e-02f, 6.87568309e-03f,
  7.96462968e-02f, 1.24004357e-01f, 8.06300193e-02f, 5.18983714e-02f, 9.31462348e-02f, 1.28816381e-01f, 7.36327469e-02f, 4.86859679e-02f, 1.11991018e-01f, 9.85612646e-02f,
  6.92685917e-02f, -1.87459543e-01f, -4.31218706e-02f, 1.16942868e-01f, 6.39765263e-02f, 1.82302315e-02f, -4.47755828e-02f, -7.61710703e-02f, -1.07193783e-01f, -2.35816911e-02f,
  -1.53823551e-02f, 7.91200399e-02f, 5.06052077e-02f, 1.53894350e-02f, 6.11745864e-02f, 4.17562984e-02f, 6.34426624e-02f, -4.62253168e-02f, -6.47135526e-02f, -1.05780773e-02f,
  1.02405131e-01f, 1.10858195e-02f, -3.69206779e-02f, -8.83622691e-02f, -1.50917564e-02f, -4.15384658e-02f, -1.32666096e-01f, -1.31703675e-01f, -8.88677165e-02f, 2.87450235e-02f,
  7.24330172e-02f, -2.58491910e-03f, 5.90587407e-02f, 5.50316013e-02f, 6.96446672e-02f, 4.66176122e-02f, -4.21261378e-02f, -5.98514229e-02f, -5.60371689e-02f, 4.89392653e-02f,
  -6.79967031e-02f, 5.90096451e-02f, -5.40199038e-03f, -4.88447249e-02f, 7.27455169e-02f, 4.72371727e-02f, -6.86914176e-02f, -5.72238863e-02f, 1.96536146e-02f, 2.14985870e-02f,
  4.13239487e-02f, -8.99131447e-02f, 5.68995290e-02f, 4.07627299e-02f, 6.59869378e-03f, -4.95706499e-02f, -3.04739885e-02f, -7.85689428e-02f, 2.70567127e-02f, -3.56550254e-02f,
  -1.62887946e-02f, -2.84664072e-02f, 3.70044075e-03f, -8.58896375e-02f, -7.27957785e-02f, 5.06529324e-02f, -3.73826809e-02f, -1.01356484e-01f, 1.50519805e-02f, 2.12094703e-04f,
  -6.33745417e-02f, -9.10946801e-02f, -5.07130548e-02f, -3.77905034e-02f, -8.09300318e-02f, 6.10716157e-02f, -3.60882953e-02f, -2.40665209e-02f, -1.07055232e-01f, -8.18491578e-02f,
  7.52288625e-02f, -5.55329733e-02f, 1.38863288e-02f, -4.66285422e-02f, -6.75772056e-02f, -6.99705258e-02f, -4.05063108e-02f, -8.41355994e-02f, -1.72013207e-03f, -7.22190291e-02f,
  -7.09787533e-02f, 1.97963089e-01f, 4.54429090e-02f, 7.50345290e-02f, 1.07830942e-01f, 2.56570607e-01f, 3.09204102e-01f, 1.17730752e-01f, -2.76608579e-02f, 8.42060000e-02f,
  1.01224713e-01f, -3.98144573e-02f, -2.05146838e-02f, 2.00852305e-02f, -1.90617777e-02f, 7.59998634e-02f, 7.17159063e-02f, -3.58667597e-02f, -6.91202953e-02f, 1.94535106e-02f,
  1.10090591e-01f, -4.60361280e-02f, -1.09791338e-01f, -4.93175676e-03f, 7.10902885e-02f, -4.30203788e-02f, -2.88864393e-02f, 5.34867030e-03f, -5.64195774e-02f, -9.64629278e-02f,
  -2.64799565e-01f, 2.55301148e-02f, -9.02115107e-02f, -4.65610810e-02f, -1.12099778e-02f, -8.41641799e-03f, 1.64455269e-03f, -6.24344908e-02f, -6.67833239e-02f, 4.60820645e-02f,
  -2.06754580e-02f, -3.96907441e-02f, 5.85802533e-02f, -3.28598055e-03f, 6.86102584e-02f, -8.38368684e-02f, -1.31259069e-01f, -1.47672817e-01f, -1.31443560e-01f, -1.28578901e-01f,
  1.98719595e-02f, -1.62230730e-02f, 3.98896635e-02f, -5.27498918e-03f, 1.32592730e-02f, -1.35194138e-01f, 4.03061919e-02f, -2.96281744e-02f, 3.48827429e-02f, -1.17956489e-01f,
  1.51800392e-02f, -1.93526894e-02f, -2.30259867e-03f, -2.50171144e-02f, 5.28604388e-02f, 3.62487473e-02f, 1.59398075e-02f, -6.28511142e-03f, -5.25686331e-03f, -4.99893799e-02f,
  2.59559210e-02f, -2.30285153e-02f, 3.35326307e-02f, 1.15000233e-02f, -1.40952691e-02f, 7.66617134e-02f, 8.37434530e-02f, -3.58511470e-02f, -8.00802857e-02f, -1.34128351e-02f,
  3.87585796e-02f, -3.52346897e-02f, -5.00767380e-02f, 4.55835648e-02f, -2.99497768e-02f, 3.79027240e-02f, -3.44311446e-02f, 1.97210312e-02f, -5.41011877e-02f, 6.65546358e-02f,
  -7.66729638e-02f, 1.13688082e-01f, -1.66023865e-01f, 9.86926630e-03f, -4.80736140e-03f, -8.70639011e-02f, 6.90561533e-02f, 2.63772882e-03f, 2.19078101e-02f, -1.02025392e-02f,
  -2.77116466e-02f, -2.82534659e-02f, 6.33111522e-02f, -1.28483921e-02f, -6.45872578e-02f, 2.58805566e-02f, 1.41284578e-02f, -1.68241560e-03f, 2.88017578e-02f, -1.65172690e-03f,
  -7.27054998e-02f, -9.58548188e-02f, 1.37869418e-02f, -7.48445168e-02f, -8.20617303e-02f, -2.54395027e-02f, -4.60367091e-02f, -3.68275456e-02f, -5.77274598e-02f, -3.66498828e-02f,
  -1.27844021e-01f, -4.26368341e-02f, 8.55141580e-02f, 6.67093620e-02f, -4.61001731e-02f, -2.13127121e-01f, -2.31823429e-01f, -3.85675468e-02f, 1.52242975e-02f, -8.35222453e-02f,
  -2.73757111e-02f, 5.86160757e-02f, 4.95571792e-02f, 5.42114973e-02f, -1.26908392e-01f, -8.39969441e-02f, -2.78234798e-02f, -7.65846297e-03f, 5.06983884e-02f, -9.38417912e-02f,
  8.90020579e-02f, 2.28320062e-02f, 8.66254941e-02f, 1.41076565e-01f, 1.46612704e-01f, 9.85837206e-02f, 1.06379269e-02f, -4.28887055e-04f, -5.71791455e-02f, 1.44579425e-01f,
  2.20384300e-02f, -1.14180014e-01f, 1.08073382e-02f, 8.71879607e-02f, -2.15745550e-02f, -5.84964268e-02f, 1.17782140e-02f, 4.40073907e-02f, -8.97251740e-02f, -8.86093304e-02f,
  -1.82192102e-02f, -5.16588762e-02f, -2.87067681e-03f, 6.77993298e-02f, -2.72560623e-02f, 1.20892078e-02f, -6.71617389e-02f, -3.20444629e-02f, 4.03515995e-03f, 2.74389256e-02f,
  -4.72522862e-02f, -2.98442841e-02f, 5.48820104e-03f, 2.88300705e-03f, 1.56080844e-02f, 8.37393850e-02f, -7.38505796e-02f, -2.59047970e-02f, -1.00112505e-01f, -6.28110468e-02f,
  3.99566106e-02f, -3.06329094e-02f, -8.44828635e-02f, -6.52661994e-02f, 1.00262119e-02f, 5.64388596e-02f, -3.56249101e-02f, -4.59911600e-02f, 2.92876903e-02f, 3.84069569e-02f,
  4.42176238e-02f, 5.94563447e-02f, 4.18911465e-02f, 3.20617333e-02f, -7.29397312e-02f, -2.18957495e-02f, -1.90217774e-02f, 4.66023386e-02f, -7.75566921e-02f, 1.25254458e-02f,
  2.70578824e-02f, 8.36130604e-03f, -3.42580979e-03f, -4.37031128e-03f, 4.35789153e-02f, 2.92149205e-02f, -2.16227788e-02f, 2.79395208e-02f, 6.73470795e-02f, 2.11459808e-02f,
  1.05720442e-02f, -1.24812074e-01f, -5.30583449e-02f, -4.03147899e-02f, 5.62470444e-02f, 7.55417068e-03f, -4.98592062e-03f, 5.04726246e-02f, 5.39311394e-02f, -2.49151327e-02f,
  -9.48026851e-02f, -3.30060981e-02f, 2.76918113e-02f, -8.56951028e-02f, 1.76353846e-02f, -9.95276496e-02f, -4.15788926e-02f, -6.65094405e-02f, -5.20815291e-02f, 3.92316803e-02f,
  2.17129327e-02f, -1.56245038e-01f, -1.09733351e-01f, -6.99633881e-02f, -3.71278934e-02f, -1.47208333e-01f, -5.24297729e-02f, -6.28861859e-02f, -1.45965382e-01f, -1.32625118e-01f,
  2.71608204e-01f, -1.20280594e-01f, -3.41553688e-01f, 5.22777550e-02f, -2.21855670e-01f, -1.39271438e-01f, -3.10132265e-01f, -8.15044641e-02f, -4.67538573e-02f, -1.65174440e-01f,
  -9.89182387e-03f, 1.14855759e-01f, -7.77068883e-02f, -4.55892682e-02f, -5.62335290e-02f, -2.41427049e-01f, -2.68225729e-01f, -1.39070973e-01f, -2.82215886e-02f, 4.62469819e-04f,
  -1.44234570e-02f, 6.81759492e-02f, 1.18953578e-01f, 7.27646649e-02f, 1.75081082e-02f, 5.57353906e-02f, -7.14869276e-02f, -7.43307322e-02f, -1.37807697e-01f, -2.12600186e-01f,
  -2.35813797e-01f, -4.50107604e-02f, 6.48822263e-02f, 9.25967656e-03f, -7.88350701e-02f, 3.93491760e-02f, -9.58163943e-03f, -9.82248783e-03f, -2.18667015e-02f, -9.07784104e-02f,
  4.63069119e-02f, -2.93775517e-02f, -6.80886358e-02f, -4.32970002e-02f, -4.61139902e-02f, -9.05391797e-02f, 7.65315536e-03f, -4.55980040e-02f, 6.21103942e-02f, -2.76718233e-02f,
  -3.68815404e-03f, -1.12627730e-01f, -2.17705052e-02f, -4.94852997e-02f, -4.10147347e-02f, 7.49834925e-02f, -2.85819899e-02f, -9.90394726e-02f, -1.13843769e-01f, -7.73125514e-02f,
  1.63437687e-02f, 3.01928949e-02f, 1.40610791e-04f, 2.80317459e-02f, -4.97708470e-02f, -4.31293389e-04f, -6.37317523e-02f, 7.14653824e-03f, 4.45979089e-02f, -5.17214797e-02f,
  3.68776992e-02f, 4.35128547e-02f, -1.19458186e-04f, 6.01754375e-02f, -2.39499426e-03f, -4.54317667e-02f, -3.91615462e-03f, 3.44052203e-02f, 3.51376906e-02f, -3.93675305e-02f,
  1.17039692e-03f, -7.19150305e-02f, -2.75386876e-04f, 6.13099523e-02f, -5.14679477e-02f, -4.96558584e-02f, 8.68080780e-02f, -5.34853227e-02f, 6.97729588e-02f, -9.97163542e-03f,
  1.56384826e-01f, 3.40854451e-02f, -7.48864785e-02f, 7.95506537e-02f, -1.13515640e-02f, -2.45562345e-02f, -6.16147108e-02f, -1.43310437e-02f, 3.57837044e-02f, -1.80021022e-02f,
  -5.80358058e-02f, -1.88177247e-02f, 2.46169022e-03f, -8.06586072e-03f, 5.00679761e-02f, 2.75042560e-02f, -5.81202731e-02f, -5.61147323e-03f, -3.32697853e-02f, -6.76570972e-03f,
  -4.44286615e-02f, -5.00299633e-02f, 2.78314650e-02f, 7.47239962e-02f, 1.58080142e-02f, 3.94203328e-02f, -5.80269508e-02f, 1.31564857e-02f, 6.27116561e-02f, 1.39936060e-01f,
  2.26164851e-02f, 1.16357848e-01f, -2.20651820e-01f, 1.21850945e-01f, -9.13534909e-02f, -1.55739680e-01f, -4.83513214e-02f, 5.09812571e-02f, 1.35038719e-01f, 1.17024563e-01f,
  -6.94133490e-02f, 8.82304534e-02f, -4.62141410e-02f, -4.17542038e-03f, 1.22255888e-02f, -1.99796837e-02f, -5.18350396e-03f, -1.46725085e-02f, -9.87537131e-02f, -4.90685878e-03f,
  -7.52608627e-02f, 6.06448203e-02f, 9.74972025e-02f, -5.15524969e-02f, 8.04740414e-02f, -3.83874774e-02f, -1.10989548e-01f, -6.06738515e-02f, -1.53436065e-01f, -8.34776536e-02f,
  -2.17289016e-01f, -9.61121097e-02f, -4.97197434e-02f, 8.48666430e-02f, -8.37555826e-02f, 2.61312947e-02f, -8.04235712e-02f, -8.01596716e-02f, -8.23325589e-02f, -6.23622686e-02f,
  1.35969836e-02f, -3.84713220e-03f, 3.49423215e-02f, -8.03388208e-02f, -2.14444511e-02f, -7.84035176e-02f, 2.92087737e-02f, -8.13965201e-02f, -1.13191746e-01f, -1.06267639e-01f,
  -1.17106568e-02f, -1.32540882e-01f, -1.44532308e-01f, 3.04310396e-02f, -1.20538481e-01f, -3.01655326e-02f, -5.48550375e-02f, -6.56509474e-02f, -1.21645508e-02f, 5.39485477e-02f,
  1.77495237e-02f, -6.29068986e-02f, -8.43282491e-02f, 2.80158501e-02f, -3.83815914e-02f, 6.30295323e-03f, -2.29393244e-02f, 5.99668324e-02f, -6.65297080e-03f, -2.27276236e-02f,
  -2.89468728e-02f, -2.96393838e-02f, -4.54662070e-02f, 9.41934586e-02f, -5.48643470e-02f, 8.70664790e-03f, 5.01315705e-02f, -4.14022617e-02f, 6.55939579e-02f, 4.69618738e-02f,
  -6.97200745e-02f, -9.34468433e-02f, 6.50848970e-02f, 7.16846585e-02f, 1.76713970e-02f, 3.73410597e-03f, -1.60839297e-02f, 7.24282414e-02f, 4.42739464e-02f, -7.97878020e-03f,
  9.73987132e-02f, -1.31063908e-01f, -4.92789373e-02f, 6.81524053e-02f, -7.84175098e-02f, -7.36496644e-04f, -6.24599718e-02f, -5.14167398e-02f, -9.32915881e-02f, 3.19154300e-02f,
  -2.72469744e-02f, 4.51131053e-02f, 4.27936669e-03f, -6.43167198e-02f, -1.15348501e-02f, -1.75091494e-02f, 3.25804949e-02f, 2.71647349e-02f, 4.13395315e-02f, 3.07518188e-02f,
  1.30109519e-01f, 4.80119810e-02f, 7.55047053e-02f, 3.15602012e-02f, 3.17110568e-02f, 4.69192192e-02f, -5.66693069e-03f, -2.52550635e-02f, -6.83072023e-03f, 9.73015800e-02f,
  8.10122304e-03f, -1.08765751e-01f, 5.98005578e-02f, -9.43760723e-02f, -7.63148367e-02f, -5.52345142e-02f, -9.01139006e-02f, -1.71564072e-01f, -1.28145590e-01f, -1.74084436e-02f,
  -3.11605986e-02f, 1.01249427e-01f, -6.51459349e-03f, 3.45264152e-02f, -1.38878241e-01f, -1.37414247e-01f, -4.34975997e-02f, -9.34402645e-02f, -2.79935282e-02f, 7.62631046e-03f,
  -7.71735655e-03f, 7.00909197e-02f, 4.44343463e-02f, 7.55282417e-02f, 3.24232355e-02f, 8.01587105e-03f, -7.08236024e-02f, 2.43344065e-02f, -2.99140532e-02f, 2.41449326e-02f,
  1.62499905e-01f, 5.72558399e-03f, 4.75792587e-02f, -2.40335129e-02f, 9.08397883e-02f, -6.13270029e-02f, -8.16005319e-02f, 2.05975324e-02f, 4.51178439e-02f, 9.45729092e-02f,
  3.01845595e-02f, 7.21596926e-02f, 9.93692204e-02f, 6.05426282e-02f, -7.81183690e-02f, -6.92902580e-02f, -2.54112333e-02f, 3.96298766e-02f, -8.69828835e-02f, -1.12962551e-01f,
  4.42155590e-03f, -3.14142406e-02f, 4.17947248e-02f, -8.59653801e-02f, 3.26970965e-02f, 7.94370994e-02f, -3.95277143e-02f, 9.02288482e-02f, -1.30811362e-02f, 5.99803515e-02f,
  -4.50671604e-03f, -8.57718363e-02f, 3.51815461e-03f, 5.78341596e-02f, 3.19257043e-02f, 3.11585087e-02f, -1.45092849e-02f, -4.20909841e-03f, 5.65280877e-02f, 6.52123168e-02f,
  3.97501662e-02f, -7.08392784e-02f, -5.47478534e-03f, -3.85597646e-02f, 8.64843056e-02f, 1.29353376e-02f, -7.88409635e-02f, 8.02988708e-02f, 1.65126305e-02f, 3.44513394e-02f,
  6.77471608e-02f, -5.73771633e-02f, -4.67882268e-02f, -2.73538176e-02f, 2.31298171e-02f, -2.78545860e-02f, 2.35783448e-03f, -7.96114579e-02f, 4.20310162e-02f, -8.53840858e-02f,
  2.18333885e-01f, -3.57439704e-02f, -5.63078411e-02f, -5.27302511e-02f, -9.06016678e-02f, 4.19896143e-03f, 1.18824765e-01f, -3.77138071e-02f, 7.25194961e-02f, 1.82777294e-03f,
  6.41106442e-02f, 6.77823946e-02f, 5.75591289e-02f, -7.69842358e-04f, 4.15874161e-02f, -1.69765241e-02f, 1.61995254e-02f, 4.89648879e-02f, -9.07746237e-03f, 2.13393737e-02f,
  4.46196720e-02f, -4.21362184e-02f, 2.07212530e-02f, -5.15325144e-02f, -4.20181230e-02f, 1.58123001e-02f, 7.49088749e-02f, -4.99399714e-02f, 7.12891668e-02f, -7.27456510e-02f,
  4.07275520e-02f, 7.98919871e-02f, -6.88062757e-02f, 9.63039845e-02f, -7.78059512e-02f, -9.98570174e-02f, -1.12632073e-01f, -6.40327632e-02f, -3.47791128e-02f, -1.23984634e-03f,
  -3.94299207e-03f, 5.16705364e-02f, 5.23382872e-02f, -8.21403321e-03f, 1.08361252e-01f, 5.95548749e-02f, -4.45060991e-02f, 1.18868008e-01f, 3.44879888e-02f, -2.79893111e-02f,
  9.99461394e-03f, 9.69904810e-02f, -3.31042521e-03f, -4.80065942e-02f, 2.43355297e-02f, 6.13066740e-02f, -2.20410749e-02f, -1.57341566e-02f, 1.08055718e-01f, 4.75575514e-02f,
  -9.08660293e-02f, -5.30274026e-02f, -6.20035864e-02f, -8.05222243e-03f, 3.89014855e-02f, -3.74279618e-02f, -2.03536320e-02f, 9.17644650e-02f, -4.81714495e-02f, 1.08004091e-02f,
  9.43361893e-02f, 6.64571375e-02f, 1.27102537e-02f, 3.73170860e-02f, -4.42093564e-03f, -1.29560558e-02f, 8.19845498e-02f, 2.72117984e-02f, 5.91153279e-03f, 7.62819648e-02f,
  -5.67261577e-02f, 5.76624759e-02f, -2.37256493e-02f, -2.39687115e-02f, 3.18431738e-03f, 7.15723112e-02f, -3.16682942e-02f, -2.44990773e-02f, -7.26438612e-02f, -7.80997351e-02f,
  9.07991379e-02f, 8.68806541e-02f, 2.38038022e-02f, 3.58643234e-02f, -5.58857545e-02f, -4.96156961e-02f, 6.20826706e-02f, -6.05209544e-02f, -7.89704695e-02f, 6.95533007e-02f,
  -6.82458058e-02f, -1.45470649e-02f, 6.51009083e-02f, 5.15416153e-02f, -1.95758007e-02f, 1.34083023e-02f, 2.47595496e-02f, -9.14495587e-02f, -7.87109807e-02f, 1.51001215e-02f,
  -3.10551822e-02f, 1.15990071e-02f, -2.46183928e-02f, -1.51232844e-02f, -6.08340576e-02f, 7.66331479e-02f, 5.22567667e-02f, -2.63205171e-02f, 3.61500271e-02f, 6.12130910e-02f,
  4.78137098e-02f, 1.30066797e-01f, 1.05563559e-01f, -4.27978970e-02f, -2.61219554e-02f, 6.78932518e-02f, -2.27275975e-02f, 5.48048131e-02f, -5.69013208e-02f, 8.27122778e-02f,
  -1.02339173e-02f, -4.20964770e-02f, 9.42597836e-02f, 5.79034872e-02f, -3.64140682e-02f, 2.42967363e-02f, 5.02404757e-02f, -2.63152942e-02f, 6.56083152e-02f, 2.07334198e-02f,
  -1.72542036e-02f, 4.45771664e-02f, 4.46812920e-02f, -1.59090664e-02f, -2.75876410e-02f, 8.02715421e-02f, 9.12386551e-03f, 1.60811022e-02f, 2.42448617e-02f, -1.19168505e-01f,
  -7.88277164e-02f, -1.58948153e-01f, -1.28642991e-01f, -9.24059749e-02f, -1.18545480e-01f, -1.68301418e-01f, -1.12472080e-01f, -1.34853870e-01f, -1.35403007e-01f, -6.13562427e-02f,
  3.31854187e-02f, -4.89541702e-02f, -4.97158095e-02f, 1.65876709e-02f, -3.90058793e-02f, -1.28475890e-01f, -1.85155720e-01f, -8.79439712e-02f, -7.77809024e-02f, -1.46661773e-01f,
  -1.07367583e-01f, -1.98137358e-01f, -1.94512770e-01f, -1.28368855e-01f, -1.40705407e-01f, -1.22843599e-02f, -1.68013066e-01f, -9.83992442e-02f, -1.09700844e-01f, -8.48190784e-02f,
  -1.97236445e-02f, -1.10372547e-02f, -1.23941712e-02f, -4.76447456e-02f, -7.69554973e-02f, 8.72813389e-02f, -5.71059771e-02f, 1.03068063e-02f, 5.59726320e-02f, -1.04359770e-02f,
  4.46442813e-02f, -5.62714785e-02f, -5.95486872e-02f, -6.04782812e-02f, 5.49468026e-02f, -1.07853543e-02f, 1.75064057e-02f, -6.26053847e-03f, -3.70870307e-02f, 5.31999916e-02f,
  5.06374091e-02f, 8.22962727e-03f, -4.95386124e-02f, 4.55815047e-02f, 4.71882224e-02f, -1.28096882e-02f, -3.90947498e-02f, -3.51390652e-02f, 6.39088154e-02f, 3.10650095e-03f,
  -8.42681304e-02f, 3.08928024e-02f, 6.49314821e-02f, 5.99968545e-02f, 7.97916278e-02f, -7.23980591e-02f, 4.08230610e-02f, 2.47640442e-02f, -4.80757467e-02f, -7.08464012e-02f,
  7.88155049e-02f, -5.16822636e-02f, -4.40882891e-02f, 1.04164623e-01f, -6.34082705e-02f, -2.41564196e-02f, 3.79062966e-02f, -6.43227920e-02f, 2.52914950e-02f, -3.35784443e-03f,
  3.87474485e-02f, -5.94178736e-02f, 5.41145392e-02f, 2.36044805e-02f, -6.89095259e-02f, -8.89203697e-02f, -3.75207476e-02f, 4.17927988e-02f, -2.93968320e-02f, 7.94326290e-02f,
  6.03250004e-02f, 2.62739751e-02f, 6.99523464e-02f, 5.96781038e-02f, -7.55321383e-02f, -7.57206231e-02f, -3.63825113e-02f, -2.37537269e-02f, -1.93511583e-02f, 2.07052734e-02f,
  8.10716450e-02f, 3.47288251e-02f, -1.64879840e-02f, -2.20276397e-02f, -8.92898589e-02f, -4.04429212e-02f, -6.89038709e-02f, -1.47055322e-02f, 7.91772604e-02f, -9.85863507e-02f,
  -2.10681334e-02f, -6.10562749e-02f, 9.00643468e-02f, 1.73402093e-02f, 1.33150024e-03f, 7.98790306e-02f, 2.83782464e-02f, 1.66034251e-02f, 1.38873637e-01f, 6.69474602e-02f,
  -1.58453733e-01f, 1.67018160e-01f, -3.04281861e-02f, -6.67264545e-03f, -1.11553748e-03f, 8.53177160e-02f, 1.43319309e-01f, -6.01097979e-02f, 2.14950591e-02f, -2.83604041e-02f,
  -2.85419263e-03f, -1.20324917e-01f, -7.39394575e-02f, -1.09317295e-01f, -7.62820467e-02f, 9.46557671e-02f, 2.82027703e-02f, -1.21893373e-03f, -9.76593345e-02f, -6.66725263e-02f,
  -6.63939118e-02f, -8.01234394e-02f, -1.03286408e-01f, -5.22284731e-02f, -5.35700433e-02f, -1.39243513e-01f, 6.93845302e-02f, 2.59710825e-04f, 9.79095995e-02f, -4.74920608e-02f,
  3.64711173e-02f, -5.99755757e-02f, -4.59019542e-02f, -7.00722039e-02f, 6.04553940e-03f, -3.35580260e-02f, 1.29923830e-03f, -4.80666757e-02f, 5.71365617e-02f, 7.41354823e-02f,
  2.64670420e-02f, -4.27504592e-02f, 4.24391218e-02f, 6.07737452e-02f, -4.32754634e-03f, 7.34446421e-02f, 5.99042512e-02f, -8.65708962e-02f, 4.30898070e-02f, 1.28596172e-01f,
  4.75888886e-02f, -1.15193343e-02f, -6.52646720e-02f, 5.71355782e-02f, 6.67564645e-02f, -8.85366201e-02f, -5.83652593e-02f, -6.84721246e-02f, -8.95388797e-02f, 5.56281023e-02f,
  -3.42254490e-02f, 5.55993915e-02f, -5.52867865e-03f, 3.77304107e-02f, -7.78272469e-03f, 1.09631186e-02f, 7.60006160e-02f, 2.15610042e-02f, 1.15689978e-01f, -5.33094555e-02f,
  7.19806179e-02f, -1.17778266e-02f, -6.88553452e-02f, 7.73419663e-02f, 6.41011000e-02f, -8.25625286e-02f, -5.60234077e-02f, -1.52391875e-02f, 1.66351870e-02f, 2.59658918e-02f,
  -6.61596656e-02f, 3.40425503e-03f, 3.46454121e-02f, -5.14502749e-02f, 1.19886389e-02f, 7.17051700e-02f, 7.77025595e-02f, 9.35985595e-02f, 5.84104955e-02f, -7.29477638e-03f,
  4.01069038e-02f, 3.40873897e-02f, -1.79790403e-03f, 6.58216327e-02f, -9.68770534e-02f, 2.43359036e-03f, 7.97793418e-02f, -4.70339358e-02f, 2.64462009e-02f, 9.72337052e-02f,
  4.72658686e-02f, 1.58901550e-02f, 9.35482904e-02f, -1.54955629e-02f, -1.03004538e-02f, 6.23800717e-02f, 1.15019746e-01f, 2.71447301e-02f, 9.40488279e-02f, 1.06106870e-01f,
  3.88515703e-02f, 6.10757843e-02f, 2.47960910e-02f, 2.95034181e-02f, 4.34497520e-02f, -1.13472506e-01f, -1.53122824e-02f, 5.99680506e-02f, -2.97363885e-02f, 5.23370467e-02f,
  -6.68702349e-02f, 8.64403695e-02f, -3.73720601e-02f, 5.20820543e-02f, -9.52311605e-02f, -9.84044373e-03f, -7.16634467e-02f, -3.79462279e-02f, 3.64480317e-02f, 7.41738304e-02f,
  -1.56971253e-02f, -8.87050629e-02f, 1.86825544e-02f, -1.32196039e-01f, -2.53594778e-02f, -5.36220819e-02f, -1.17339134e-01f, -1.61194161e-01f, -8.85912627e-02f, -1.89108521e-01f,
  -1.25117879e-02f, -2.24814918e-02f, -8.13392475e-02f, 4.43049707e-02f, 2.02651992e-02f, 1.36148602e-01f, 8.77681747e-02f, -6.94059394e-03f, -8.62294883e-02f, -4.39327955e-02f,
  2.32512251e-01f, -6.77541420e-02f, 7.93210883e-03f, -8.82390440e-02f, 3.13259684e-03f, -2.67413929e-02f, 4.13455367e-02f, 5.82699701e-02f, -8.41136202e-02f, 4.79910895e-02f,
  -3.22539583e-02f, -8.16113874e-02f, -9.09534842e-02f, -6.33865520e-02f, -5.55369109e-02f, 3.95236164e-02f, 2.45932816e-03f, -1.06775261e-01f, -7.55245611e-03f, -5.99806709e-03f,
  -1.41163066e-01f, -2.89008543e-02f, 1.17161199e-02f, -6.33886084e-02f, -1.10466443e-01f, -1.19362354e-01f, -2.51176003e-02f, 7.33566210e-02f, -4.53242287e-02f, 1.69268265e-01f,
  7.40994141e-02f, -2.03284882e-02f, -9.38886926e-02f, -7.66790565e-03f, -4.61199656e-02f, -3.07204351e-02f, -3.24955881e-02f, 6.75143907e-03f, 2.19880417e-02f, 3.09188832e-02f,
  -7.62321800e-02f, -2.32975138e-03f, 5.40258251e-02f, 6.31543025e-02f, 4.51556332e-02f, -1.04286280e-02f, 2.36239936e-02f, 8.60953629e-02f, -7.61308670e-02f, -9.19264462e-03f,
  -1.16685210e-02f, -2.31318772e-02f, 7.33925998e-02f, 3.23937535e-02f, 5.10662794e-02f, 1.02104144e-02f, 4.62047271e-02f, -2.31190864e-02f, 6.39801323e-02f, 1.54066947e-04f,
  2.30657175e-01f, -1.17034055e-01f, 3.35307047e-02f, -3.81873660e-02f, -1.71862319e-02f, -6.07887767e-02f, 2.15219576e-02f, -3.00603248e-02f, 1.51788453e-02f, -5.31773418e-02f,
  1.02547798e-02f, -1.57565903e-02f, 6.35134205e-02f, -6.76793978e-02f, 4.88440618e-02f, -1.00373328e-01f, -9.20750499e-02f, -6.68933466e-02f, -3.51320989e-02f, -4.88330387e-02f,
  3.23008969e-02f, -1.05727583e-01f, -6.49687052e-02f, 1.09858528e-01f, 5.13777658e-02f, 1.48974545e-03f, 1.25457659e-01f, 1.35643318e-01f, 2.57920288e-02f, 1.41866907e-01f,
  -2.22894683e-01f, 7.85262883e-02f, -7.03351647e-02f, -2.00168207e-01f, -1.55922433e-03f, -2.53112726e-02f, 7.43302284e-03f, 3.49777676e-02f, 8.08446109e-02f, -6.70247003e-02f,
  3.43069471e-02f, -7.62057230e-02f, -1.38517737e-01f, 2.01643128e-02f, -5.33123352e-02f, 7.55151361e-02f, 5.29320948e-02f, -3.27194221e-02f, -1.35193273e-01f, -8.06166381e-02f,
  -1.51413128e-01f, -6.39201254e-02f, -8.65567699e-02f, -6.99168891e-02f, -4.19098623e-02f, -1.13774620e-01f, -5.96957728e-02f, -7.30748326e-02f, 3.56469452e-02f, -4.13787290e-02f,
  -4.31347005e-02f, 2.12344024e-02f, -5.73321395e-02f, -6.71838224e-02f, -9.79701290e-04f, 5.76991551e-02f, -3.94777171e-02f, 2.68344302e-04f, -6.54490516e-02f, -5.63004687e-02f,
  -9.25429836e-02f, -4.33245711e-02f, -1.22686654e-01f, 3.11350310e-03f, -2.40925793e-02f, -7.69115835e-02f, 8.38312581e-02f, -7.85016343e-02f, -5.64448424e-02f, -2.54103262e-02f,
  -7.91302994e-02f, -1.57803655e-01f, -5.78077324e-02f, 1.79642271e-02f, 7.77462358e-03f, -2.38849632e-02f, 7.84411803e-02f, -5.11324443e-02f, 8.63653794e-02f, 8.93900320e-02f,
  -2.68244520e-02f, -4.42271940e-02f, 1.87796401e-03f, -1.33895883e-02f, -6.29987791e-02f, 7.96919689e-02f, -1.07094962e-02f, 6.40169755e-02f, -4.92560342e-02f, 3.21464911e-02f,
  7.84921348e-02f, -5.13475835e-02f, 6.97533414e-02f, 1.12065580e-02f, -1.09547442e-02f, -9.06605050e-02f, -4.21338342e-02f, 1.07938610e-01f, 8.27279091e-02f, 9.38832760e-02f,
  1.53703634e-02f, 6.78210706e-02f, -8.34182203e-02f, 6.99884370e-02f, -6.34791330e-02f, -1.39763085e-02f, 9.08963606e-02f, -7.93935135e-02f, -1.77628156e-02f, -6.19588308e-02f,
  -8.12922716e-02f, -3.82430330e-02f, -8.53042901e-02f, -1.68176480e-02f, -6.38007224e-02f, -2.17753984e-02f, -2.27894858e-02f, -4.28822227e-02f, -7.38147588e-04f, -3.73652391e-02f,
  1.78207811e-02f, -1.03374626e-02f, 5.30920632e-04f, -8.72352347e-02f, -1.10421941e-01f, -8.23360980e-02f, -8.54697526e-02f, -4.91770804e-02f, -8.15456733e-02f, -7.44066387e-02f,
  1.12383284e-04f, -1.45462409e-01f, -1.64362445e-01f, 3.47200148e-02f, -4.70673703e-02f, -4.19200659e-02f, -1.15822740e-01f, 2.83096395e-02f, -1.29801696e-02f, 3.66544421e-03f,
  6.60379697e-03f, 1.48873135e-01f, -1.31051332e-01f, 3.17862444e-02f, 5.46391457e-02f, -1.16212308e-01f, -7.60931820e-02f, 2.65015196e-02f, 1.28249684e-02f, 7.34573090e-03f,
  -8.16683192e-03f, -4.07543555e-02f, -2.23606564e-02f, -1.92572117e-01f, -1.91998869e-01f, 6.24786876e-02f, -1.05079100e-01f, -1.04248464e-01f, -2.23473608e-01f, -8.49796012e-02f,
  -1.23339653e-01f, -1.10316657e-01f, -9.20491144e-02f, 1.70816276e-02f, -3.15289125e-02f, -6.99971020e-02f, 9.19573978e-02f, -8.79139155e-02f, 1.56038022e-02f, 6.16036430e-02f,
  -1.28828451e-01f, -7.76351942e-03f, -1.32237405e-01f, -2.36483905e-02f, -2.94398014e-02f, 4.96476814e-02f, -4.70253304e-02f, -1.86858885e-02f, -5.01239933e-02f, -7.22782165e-02f,
  -7.75016993e-02f, 1.33596687e-02f, -5.44147268e-02f, 3.53986048e-03f, -1.25768986e-02f, 2.68276501e-03f, 2.09736358e-02f, -1.06444083e-01f, -8.23297873e-02f, -2.83203106e-02f,
  -5.24728652e-03f, 4.49231416e-02f, -4.54370454e-02f, 4.46576066e-02f, -2.36518700e-02f, -2.41054147e-02f, -2.47521102e-02f, -5.97595237e-02f, -2.86895186e-02f, 1.42006293e-01f,
  6.98135644e-02f, 6.44594878e-02f, 8.90575796e-02f, 5.49256802e-02f, -2.89087873e-02f, -5.77779673e-02f, 1.84656195e-02f, -7.45996013e-02f, -4.37380858e-02f, 4.03078720e-02f,
  8.12924728e-02f, 4.74815583e-03f, 8.91530216e-02f, -4.18719873e-02f, -3.76111493e-02f, -4.92223091e-02f, 4.80945259e-02f, -4.07858454e-02f, -1.96138080e-02f, -4.54021916e-02f,
  3.01290490e-02f, -1.20533034e-02f, -5.84159568e-02f, -9.06658471e-02f, 6.89028054e-02f, 4.80138548e-02f, 1.06538245e-02f, -2.63501648e-02f, -6.61407709e-02f, -1.35431979e-02f,
  1.78375877e-02f, -1.71518207e-01f, 4.88436073e-02f, -9.50474367e-02f, 7.02440739e-02f, 8.15381878e-04f, 8.18270519e-02f, -5.37818633e-02f, 5.34894615e-02f, -5.73273897e-02f,
  1.67359412e-02f, -1.93442814e-02f, 6.14545010e-02f, -1.14389090e-02f, -3.06296051e-02f, 3.19710746e-02f, 2.10872456e-03f, -9.96026695e-02f, -2.38812603e-02f, 3.81042957e-02f,
  1.15999445e-01f, -6.01084791e-02f, -4.96544130e-02f, 3.58782224e-02f, 1.39835235e-02f, -3.49259079e-02f, -6.63226098e-02f, 6.69507077e-03f, -3.56975123e-02f, 5.38499095e-02f,
  2.98947036e-01f, -1.32707596e-01f, 1.39723634e-02f, 4.52178717e-02f, 7.01521263e-02f, 3.71509492e-02f, -1.31572798e-01f, -5.80950230e-02f, 1.06924340e-01f, 3.24911363e-02f,
  -2.37735398e-02f, 1.04759932e-01f, 8.49618241e-02f, 9.67817232e-02f, 7.60662183e-02f, -1.24591038e-01f, 3.04790656e-03f, 1.77936777e-02f, 1.31941110e-01f, 4.10883389e-02f,
  1.59578249e-02f, -6.40505403e-02f, 6.76973984e-02f, -2.79776156e-02f, -1.24123156e-01f, 7.32865110e-02f, -5.95337003e-02f, -1.57545805e-01f, -1.30806535e-01f, -7.37170130e-02f,
  -1.17788263e-01f, -8.73417631e-02f, 1.19225778e-01f, -1.75134446e-02f, -1.75025929e-02f, -2.67647561e-02f, -1.63418595e-02f, -7.35587552e-02f, -8.00874531e-02f, -1.36386856e-01f,
  -2.48850081e-02f, -1.12879379e-02f, -4.47556376e-02f, -1.03186220e-01f, -6.17367728e-03f, 5.41131720e-02f, 1.67225488e-02f, 7.78273493e-02f, 7.81577006e-02f, -3.25403623e-02f,
  -1.35590926e-01f, 2.84802411e-02f, -6.86967820e-02f, 4.60432172e-02f, -2.78889369e-02f, 6.67370558e-02f, -9.00147781e-02f, -2.90086539e-03f, -1.72895603e-02f, -7.09189847e-02f,
  4.13560644e-02f, 3.81391831e-02f, 9.70678553e-02f, -8.25233161e-02f, 6.84517920e-02f, -1.24535430e-02f, -3.80310863e-02f, -8.66789296e-02f, 4.31623906e-02f, 9.19779912e-02f,
  -1.20579386e-02f, -3.58748995e-03f, -6.34337813e-02f, 5.84750883e-02f, -6.95222393e-02f, 3.97574641e-02f, 1.36943243e-03f, -2.47755391e-03f, 5.95078021e-02f, 2.40960419e-02f,
  8.10062066e-02f, -8.00068378e-02f, -9.55288336e-02f, -1.80888250e-02f, 2.21094210e-02f, -3.21079567e-02f, -2.30214950e-02f, 8.28567743e-02f, -1.44873075e-02f, 4.92007807e-02f,
  5.04728742e-02f, 1.24300085e-01f, 1.29173128e-02f, 4.41728942e-02f, -2.60467436e-02f, -6.22020923e-02f, 1.43503873e-02f, 3.49611975e-02f, -2.17071828e-02f, -3.83861698e-02f,
  3.72724910e-03f, -2.35692449e-02f, -1.94936525e-02f, 3.14176679e-02f, 2.52127536e-02f, -3.07390727e-02f, -5.83261810e-02f, 6.74450025e-02f, 8.11774433e-02f, -2.84632444e-02f,
  -2.31527761e-02f, 2.90351752e-02f, 9.24296454e-02f, 1.05330989e-01f, 5.70118167e-02f, 1.70064509e-01f, 6.95766285e-02f, -3.41144912e-02f, 8.13974366e-02f, -8.70653614e-03f,
  1.40200838e-01f, 8.45766366e-02f, 1.16832361e-01f, 1.08005822e-01f, -9.25800204e-02f, -4.66862284e-02f, -3.02134566e-02f, -4.20421548e-02f, 6.46527708e-02f, 8.53057951e-02f,
  -2.53507663e-02f, -2.44476851e-02f, 1.68320835e-02f, 8.28945860e-02f, -2.12204624e-02f, 5.73280640e-02f, 9.55476612e-03f, 8.83323774e-02f, 3.28055620e-02f, -1.39396377e-02f,
  -7.56582990e-02f, 8.02546069e-02f, 1.10499524e-01f, 3.19818743e-02f, 8.39737952e-02f, -7.39220679e-02f, -9.12919939e-02f, -3.03574391e-02f, 8.00098553e-02f, 8.11806545e-02f,
  1.24074034e-01f, 8.36104304e-02f, -4.30405363e-02f, 6.95946664e-02f, -3.31451446e-02f, 6.22197874e-02f, -3.08934436e-03f, 4.81096050e-03f, -7.39419484e-04f, -2.72469372e-02f,
  -5.80566712e-02f, -3.66164581e-03f, -5.60140312e-02f, -5.27500287e-02f, -9.71596316e-02f, -2.42182165e-02f, -4.53337125e-05f, -1.02761080e-02f, 3.17217186e-02f, 9.71966535e-02f,
  -2.08853744e-02f, -4.62658517e-02f, -7.37765208e-02f, -6.63725138e-02f, -6.68817163e-02f, 5.00622056e-02f, 6.48338720e-02f, -6.80337772e-02f, -1.80489291e-02f, 6.02197833e-02f,
  -1.94646642e-02f, -3.74283828e-03f, 2.47504972e-02f, 6.57164156e-02f, 2.98247281e-02f, -6.95911050e-02f, 6.11503124e-02f, -9.75459516e-02f, -5.97810410e-02f, -4.13030460e-02f,
  -2.99743353e-03f, 6.31206110e-03f, -2.04932317e-02f, 8.99366289e-03f, 4.64765541e-02f, -3.80377658e-02f, 2.70050038e-02f, -1.63675728e-03f, 5.17457491e-03f, -3.20441350e-02f,
  3.78364585e-02f, 2.38772593e-02f, -2.24113110e-02f, 6.22080974e-02f, -6.13924675e-02f, -1.14709428e-02f, -7.41188154e-02f, -9.73110944e-02f, -8.34215432e-02f, 7.43793324e-02f,
  -1.29651040e-01f, 9.65226218e-02f, 1.34045444e-02f, -3.54012363e-02f, 3.92732061e-02f, 7.97577873e-02f, -1.43190823e-03f, -4.67941770e-03f, -2.47438140e-02f, 7.55426735e-02f,
  -3.46538089e-02f, 1.07696727e-01f, -8.85902196e-02f, 4.89597321e-02f, -1.97150353e-02f, 1.52059225e-02f, 3.01071303e-03f, -2.43991870e-03f, 3.88979865e-03f, -5.51332645e-02f,
  -3.06702852e-02f, 2.81764120e-02f, 4.72912788e-02f, -1.00787245e-01f, -1.97960641e-02f, 8.96173809e-03f, -7.46804103e-02f, -3.02611422e-02f, -6.29726574e-02f, -1.06763216e-02f,
  -1.58640966e-02f, -1.47444233e-01f, -1.39915776e-02f, 4.95905429e-02f, 1.01749964e-01f, -9.28063691e-02f, -9.32815224e-02f, 1.45176668e-02f, -5.31097874e-02f, 6.20566048e-02f,
  3.55380177e-02f, 9.44728181e-02f, 1.57183811e-01f, 1.53075699e-02f, 5.87000176e-02f, 6.18605539e-02f, 2.52040327e-02f, 1.43395588e-01f, 1.23889945e-01f, 6.77566007e-02f,
  -2.51167547e-02f, 3.73579785e-02f, 4.44844104e-02f, -6.57728016e-02f, -6.96541518e-02f, -1.73018519e-02f, 3.95066142e-02f, 5.48007376e-02f, -3.82115226e-03f, 4.17984016e-02f,
  1.48922997e-02f, -1.22294210e-01f, 1.45215631e-01f, 1.71599407e-02f, -3.02622914e-02f, 7.79669657e-02f, 3.94222662e-02f, 5.11868782e-02f, -7.02507272e-02f, 3.06608938e-02f,
  4.46605645e-02f, 4.78784442e-02f, -4.27973010e-02f, -9.46067497e-02f, -9.89343524e-02f, -2.48155519e-02f, -5.36559336e-02f, -1.68367140e-02f, -7.75683150e-02f, 4.52119224e-02f,
  -2.59620622e-02f, -3.27747390e-02f, 2.17510201e-02f, 2.42005661e-02f, -4.22935225e-02f, 1.44802421e-01f, 7.24367499e-02f, 4.99883965e-02f, 9.80633777e-04f, 2.77536195e-02f,
  5.95286377e-02f, -3.87985930e-02f, 9.24243182e-02f, 7.17965364e-02f, 2.12161075e-02f, 2.38176808e-02f, 6.12014607e-02f, 8.06215778e-02f, 4.66812029e-02f, 5.07101826e-02f,
  -9.52110812e-03f, -2.05183141e-02f, -7.72082210e-02f, -2.31128242e-02f, 1.24652386e-01f, 5.75435162e-02f, 7.92439580e-02f, 4.08258475e-02f, -2.13814210e-02f, 8.26001167e-02f,
  8.76649246e-02f, -3.59001048e-02f, 4.36399989e-02f, -5.10898903e-02f, -7.74760172e-02f, 3.40020424e-03f, 7.21905082e-02f, 1.01730332e-01f, -5.03246784e-02f, -7.00729638e-02f,
  -9.96526629e-02f, 1.17543012e-01f, -3.62494588e-02f, -1.38943624e-02f, -5.26980460e-02f, 6.38741925e-02f, 4.97510843e-02f, -7.59000555e-02f, -7.71026872e-03f, 3.13811116e-02f,
  -8.17725435e-03f, 1.62719190e-02f, 3.85473371e-02f, -7.73583204e-02f, -7.39778057e-02f, -1.77439619e-02f, 7.10444227e-02f, -4.17684093e-02f, -8.34947377e-02f, -8.94837528e-02f,
  7.18126372e-02f, 4.37111035e-02f, 4.51271348e-02f, 5.28541617e-02f, -7.75766838e-03f, 1.60293892e-01f, -3.99090461e-02f, 8.84191841e-02f, -7.17796246e-03f, -5.08049801e-02f,
  -9.94307697e-02f, 5.61700650e-02f, -1.00926518e-01f, 1.13524519e-01f, 5.45262322e-02f, -3.07944324e-02f, 5.66351134e-03f, 6.85372651e-02f, 5.23524694e-02f, 7.63030499e-02f,
  1.68071035e-02f, -3.74130644e-02f, -1.37346638e-02f, 4.32663634e-02f, -4.26004529e-02f, 1.01767495e-01f, 6.17736466e-02f, -2.60207914e-02f, -6.50160462e-02f, 9.58136097e-02f,
  8.45247805e-02f, 7.48889893e-02f, -3.53150330e-02f, 1.14374362e-01f, 9.58887190e-02f, 5.31573594e-02f, 9.49281901e-02f, -1.58289459e-03f, 1.05769888e-01f, 2.05204055e-01f,
  -7.43431449e-02f, -8.95235315e-02f, -7.80697614e-02f, -3.77652869e-02f, -3.07880417e-02f, 1.65442880e-02f, -6.77127615e-02f, 1.02780256e-02f, -8.77530500e-02f, -2.93593053e-02f,
  -3.14754136e-02f, -1.79103855e-02f, 7.07353279e-02f, 7.83677101e-02f, 3.08733974e-02f, -2.45083403e-02f, 5.80384908e-03f, -3.11624408e-02f, -1.14183903e-01f, -5.92124313e-02f,
  1.21833868e-01f, 3.11136693e-02f, -4.03254218e-02f, 6.27438771e-03f, -1.59451086e-02f, -1.28543288e-01f, -4.93134707e-02f, -7.83395693e-02f, -1.30196333e-01f, -2.37085745e-02f,
  -6.59089610e-02f, 2.09342670e-02f, -7.62440488e-02f, 8.53943527e-02f, -4.55556102e-02f, 3.94805856e-02f, 1.06876828e-01f, -4.80107069e-02f, 9.05528739e-02f, 6.64407164e-02f,
  -1.91754177e-02f, -4.41048443e-02f, -7.15091825e-02f, -8.70682485e-03f, -3.12028024e-02f, -2.92120990e-03f, -6.37229113e-03f, 5.06389476e-02f, -2.20635179e-02f, 2.26042401e-02f,
  -2.30537970e-02f, 3.41265723e-02f, -7.17368629e-03f, 5.07934839e-02f, -2.95123868e-02f, 5.60465492e-02f, -3.66826579e-02f, 1.04941567e-02f, -6.62429407e-02f, -5.28661860e-03f,
  -1.54573202e-01f, -2.57512361e-01f, -2.27591787e-02f, -2.80364361e-02f, -7.25753531e-02f, -7.41301030e-02f, 1.75670795e-02f, 2.53335238e-02f, 5.93345836e-02f, 3.82971577e-02f,
  -1.10362424e-02f, -4.67668623e-02f, -3.66385877e-02f, -9.28943455e-02f, -1.31658306e-02f, 1.48181375e-02f, -5.43297604e-02f, 1.40490429e-03f, -4.98689013e-03f, 3.64107974e-02f,
  -4.61009629e-02f, -6.57096207e-02f, -1.30015969e-01f, -3.84898968e-02f, 3.89651139e-03f, -4.49195392e-02f, -7.59175271e-02f, -1.22100860e-01f, -1.58492297e-01f, -1.09639585e-01f,
  2.70629138e-01f, 3.28238383e-02f, 2.32902631e-01f, 1.31977722e-01f, 1.37546986e-01f, 2.77299970e-01f, 1.96148187e-01f, 1.42113507e-01f, 5.72451502e-02f, 1.09061636e-01f,
  2.35948749e-02f, -2.67275367e-02f, -9.49582830e-02f, -1.15718342e-01f, -4.16132882e-02f, 1.36051420e-02f, -3.13824415e-02f, 8.00895467e-02f, 5.46889454e-02f, 9.77722928e-02f,
  -1.34475127e-01f, -2.06212923e-02f, 1.25392616e-01f, -9.13610216e-03f, 6.43671956e-04f, -1.54503688e-01f, -4.78340313e-02f, 1.57596618e-02f, 8.62059519e-02f, -1.28119558e-01f,
  8.37238133e-02f, 2.34328076e-01f, -9.45399106e-02f, -1.12933151e-01f, 1.79909747e-02f, -6.46388158e-02f, 5.04622385e-02f, -6.57069311e-02f, 4.43388615e-03f, 4.28499933e-03f,
  -6.71302304e-02f, -1.08435996e-01f, -5.41236773e-02f, 2.44654492e-02f, 1.18449368e-01f, 6.02759011e-02f, 2.28338074e-02f, -6.12673722e-02f, -7.39030242e-02f, 7.17711635e-03f,
  -1.21547058e-01f, 4.73991632e-02f, 1.11175954e-01f, 6.04457706e-02f, 2.03290805e-02f, -1.03300765e-01f, 1.27920419e-01f, 5.36656156e-02f, -2.89750304e-02f, -9.61658135e-02f,
  3.05093341e-02f, 1.10552704e-03f, 3.16221491e-02f, 1.96109712e-02f, 1.75651480e-02f, 3.64616439e-02f, -3.87858809e-03f, 7.33901933e-02f, 6.63371012e-03f, 9.38049797e-03f,
  -2.96325795e-02f, -1.19414562e-02f, 9.14765820e-02f, 3.35812382e-02f, -8.84792116e-03f, 7.94743821e-02f, -6.88074678e-02f, -8.53165705e-03f, 7.52950646e-03f, 7.32425973e-02f,
  8.62576738e-02f, 9.33540240e-03f, 6.89527467e-02f, 1.71742197e-02f, -3.85336243e-02f, -4.73380834e-03f, 2.87386067e-02f, -6.77923113e-03f, 2.75457874e-02f, 2.88014896e-02f,
  -1.41226247e-01f, 8.59780461e-02f, -1.39525086e-01f, -1.01081349e-01f, 8.61412212e-02f, -9.40696746e-02f, 2.11532786e-02f, -7.08587766e-02f, -6.80684596e-02f, 4.12536711e-02f,
  5.34873605e-02f, 1.57765895e-02f, 7.32826218e-02f, -3.71425524e-02f, 1.00529298e-01f, 8.14876258e-02f, -9.89885852e-02f, 3.44170183e-02f, -5.37958294e-02f, -7.74837807e-02f,
  -5.93999252e-02f, 1.56308096e-02f, 9.54991952e-02f, -4.54598814e-02f, -6.36381507e-02f, 4.20259535e-02f, -4.94109876e-02f, 3.03660985e-04f, 2.16349382e-02f, -5.06321788e-02f,
  6.53560087e-02f, -9.06378478e-02f, -2.92553335e-01f, -1.38359487e-01f, -4.02603745e-02f, -3.69893759e-02f, 3.46666425e-02f, 3.30246389e-02f, -3.49626392e-02f, 3.05704456e-02f,
  -6.62088171e-02f, -8.11626837e-02f, -1.30178869e-01f, -1.25274524e-01f, 4.42650057e-02f, -4.20596153e-02f, -4.43214625e-02f, -1.71488225e-01f, -1.46271035e-01f, 1.03356630e-01f,
  5.39310090e-02f, -8.12406167e-02f, 3.40953842e-02f, -5.51763624e-02f, -9.70876142e-02f, -8.71775523e-02f, -8.66062492e-02f, -1.09019496e-01f, 1.07912626e-02f, -2.00998172e-01f,
  -1.22557655e-01f, 1.82334799e-02f, 1.31095340e-03f, 2.80813109e-02f, 3.01107746e-02f, -2.19808016e-02f, -4.32388410e-02f, -5.78458514e-03f, -9.93997306e-02f, -5.71393743e-02f,
  -1.42854769e-02f, 9.42365918e-03f, -5.21075614e-02f, -5.16920574e-02f, 3.76081429e-02f, 6.95121437e-02f, 1.23798205e-02f, -5.16715422e-02f, 3.13409828e-02f, -2.66730394e-02f,
  5.27881123e-02f, -7.98658207e-02f, -1.11667506e-01f, 5.21182977e-02f, -5.13418950e-02f, -2.67798658e-02f, -8.09889957e-02f, -9.84448045e-02f, -8.30377787e-02f, -2.01000422e-02f,
  -4.04956527e-02f, -5.48124239e-02f, 3.10305078e-02f, 7.23516271e-02f, 6.64043278e-02f, -5.77371381e-02f, 4.90786098e-02f, -4.49506827e-02f, 4.02428620e-02f, -3.39735746e-02f,
  2.39408780e-02f, 7.24256784e-03f, 6.35785386e-02f, -1.85818542e-02f, -5.50070591e-02f, 7.55534098e-02f, 6.78909943e-02f, -2.40673441e-02f, 6.90311491e-02f, -5.10532819e-02f,
  -9.12474170e-02f, -2.00350452e-02f, -2.52167368e-03f, 4.39708121e-03f, -8.83198678e-02f, -6.58117682e-02f, 3.94901410e-02f, 9.82170105e-02f, 3.12904492e-02f, 1.87874734e-02f,
  3.37461643e-02f, -4.53170091e-02f, -9.11942497e-02f, -6.52903840e-02f, -2.97825467e-02f, -6.93112658e-03f, -4.27797157e-03f, -5.75014064e-03f, -1.08198531e-01f, 7.23955482e-02f,
  -3.67047638e-02f, 2.29776446e-02f, -6.52574673e-02f, 3.56388576e-02f, 8.62785429e-02f, -3.84923033e-02f, 4.57627028e-02f, -7.34437853e-02f, -8.14683884e-02f, 9.67801884e-02f,
  -3.70474644e-02f, -6.44856170e-02f, 7.45450258e-02f, 5.44725358e-02f, 2.34149452e-02f, -4.24975380e-02f, -1.43331671e-02f, 4.68904451e-02f, 3.24777998e-02f, 9.00952071e-02f,
  4.37592953e-01f, 1.08373165e-01f, 1.00792266e-01f, 1.34210035e-01f, -1.43869326e-01f, -2.58887887e-01f, -1.87693834e-01f, -1.40458882e-01f, -2.14887783e-02f, -4.18370552e-02f,
  7.53263608e-02f, -6.50080964e-02f, -6.89791664e-02f, 1.11033566e-01f, 1.38224483e-01f, -4.13135486e-03f, 8.71293247e-02f, 1.71867162e-01f, 1.75611347e-01f, 1.45851359e-01f,
  8.28624889e-02f, 1.62239373e-01f, 1.86873689e-01f, 5.86969666e-02f, 1.49656117e-01f, 2.26926561e-02f, -4.48236950e-02f, 8.37876871e-02f, 1.10745244e-01f, 2.40701407e-01f,
  2.88526416e-01f, 1.93582669e-01f, -7.64274001e-02f, 2.75235903e-02f, 1.69856567e-02f, 7.05605522e-02f, -5.69504052e-02f, -3.42558175e-02f, -9.81825516e-02f, -1.05953831e-02f,
  1.96106192e-02f, -3.56030799e-02f, 7.47006759e-03f, -1.68614723e-02f, 2.89713889e-02f, -1.49652120e-02f, 1.21674361e-02f, 1.21630363e-01f, 4.53497395e-02f, 2.42512356e-02f,
  -2.69757933e-03f, 4.94171120e-02f, -2.35192175e-03f, -1.54679850e-01f, -6.61513880e-02f, -7.58745195e-03f, -1.03609711e-01f, 5.20862676e-02f, -2.70057786e-02f, 9.96210873e-02f,
  -2.47409176e-02f, 8.72856826e-02f, -7.94436559e-02f, -6.38175756e-02f, 1.02798983e-01f, -7.40147233e-02f, -3.33404690e-02f, -6.53963163e-02f, -6.81631034e-03f, 2.18413398e-02f,
  -5.58123440e-02f, -2.98967841e-03f, -5.74460300e-03f, 4.56121229e-02f, 1.75124072e-02f, 3.01230978e-02f, 4.37653363e-02f, 3.54645960e-03f, -6.16284572e-02f, -6.52884245e-02f,
  7.23951012e-02f, 3.35401595e-02f, 1.07691018e-02f, 7.09161237e-02f, 8.96387920e-03f, -5.53245135e-02f, -6.88241562e-03f, -2.11984497e-02f, 4.71389629e-02f, 6.44548759e-02f,
  -1.09244317e-01f, -2.62677878e-01f, 2.73733437e-02f, 6.26166537e-02f, 2.65437178e-02f, 5.09071536e-02f, 8.26405585e-02f, 9.09296498e-02f, -2.53256578e-02f, 1.46480706e-02f,
  7.26440474e-02f, -1.17970817e-02f, 2.23489907e-02f, 3.00949588e-02f, 4.54459824e-02f, 5.00660809e-03f, 5.78001700e-02f, -8.79433565e-03f, -3.28596309e-02f, -5.13496138e-02f,
  -1.04547732e-01f, -1.39688909e-01f, -1.12864785e-01f, -2.09918484e-01f, -1.15197569e-01f, -1.76150218e-01f, -1.41485035e-01f, -3.58347618e-03f, -2.02013239e-01f, -2.65038144e-02f,
  7.03036785e-02f, -1.96934432e-01f, 1.11418776e-01f, 3.18591744e-02f, 1.78375497e-01f, 1.14899538e-01f, 1.55930653e-01f, 7.81434327e-02f, -4.56823111e-02f, -9.31177661e-02f,
  -1.24122212e-02f, -1.66827574e-01f, -1.67261943e-01f, -1.33568391e-01f, -5.57332970e-02f, -7.18094688e-03f, 7.17034042e-02f, -3.71998399e-02f, 5.32456934e-02f, 7.00920671e-02f,
  5.29280156e-02f, -8.26305151e-02f, 2.65556537e-02f, -8.50553289e-02f, -7.53301308e-02f, -9.24552754e-02f, -3.02466471e-02f, 3.65231596e-02f, 2.74204109e-02f, -1.28129199e-01f,
  -2.59737242e-02f, -2.42007095e-02f, 1.21509142e-01f, -1.27466992e-01f, -3.18166497e-03f, 2.31191842e-03f, 5.86042777e-02f, -6.35268390e-02f, -6.35201558e-02f, 4.68291529e-02f,
  2.52901912e-02f, -5.35103045e-02f, 3.10099013e-02f, 3.10998484e-02f, -4.27218527e-02f, 7.51631185e-02f, -9.19467807e-02f, -5.66555224e-02f, -1.17774539e-01f, -6.26726076e-02f,
  3.02777868e-02f, -3.27860601e-02f, 4.91835847e-02f, -1.26696052e-02f, 5.68827987e-02f, -5.44041805e-02f, -1.11750653e-02f, -4.46950272e-02f, 7.01907426e-02f, -9.55819990e-03f,
  4.93551120e-02f, 4.09309156e-02f, -4.79606986e-02f, -1.93519667e-02f, -5.64913452e-03f, 7.73988590e-02f, -7.80022964e-02f, 7.02382922e-02f, -2.89873388e-02f, 4.98930253e-02f,
  1.09084276e-02f, 4.25147079e-02f, -5.28986007e-02f, -3.29189375e-02f, -6.57804087e-02f, -2.57051978e-02f, 3.63236479e-02f, 8.46235082e-04f, -2.11823359e-02f, 3.57508063e-02f,
  -8.32610019e-03f, 7.17931837e-02f, -5.50184175e-02f, -6.49721175e-02f, -3.65167223e-02f, -5.35179675e-02f, -3.88782434e-02f, 6.11093789e-02f, -4.85149808e-02f, -4.58805868e-03f,
  -4.74249385e-02f, 6.04437180e-02f, -7.80104920e-02f, -9.81782302e-02f, 2.76160464e-02f, -1.79234650e-02f, 4.17544171e-02f, 7.42079243e-02f, -8.48177671e-02f, -6.57049716e-02f,
  -1.64059028e-02f, -5.46103008e-02f, 1.73051916e-02f, 2.08095349e-02f, 8.78865197e-02f, 7.65620619e-02f, 5.59708923e-02f, -6.10454055e-03f, -5.12260199e-02f, -5.15344134e-03f,
  -2.95892474e-04f, 8.73271078e-02f, -3.27821076e-02f, 6.09120391e-02f, -6.35092333e-02f, 4.74939728e-03f, 3.75022441e-02f, 1.13857113e-01f, 8.44577849e-02f, -3.33107524e-02f,
  -1.49038509e-01f, 2.12824233e-02f, -4.51398641e-02f, -1.85871944e-01f, -1.07617401e-01f, 6.53023943e-02f, 9.79015976e-02f, 2.97464188e-02f, -2.29537450e-02f, 2.55559701e-02f,
  -6.74945116e-02f, -7.81426579e-02f, -9.00059044e-02f, 3.97522114e-02f, 2.38324590e-02f, 3.82985771e-02f, -1.03512488e-01f, -8.68043974e-02f, -6.95596486e-02f, -5.14114834e-02f,
  -1.89705621e-02f, -9.01549533e-02f, -9.37623382e-02f, -1.24401040e-01f, -9.38995257e-02f, -7.70342862e-03f, -1.08753413e-01f, -1.50642440e-01f, 1.40093779e-02f, -1.25730515e-01f,
  -1.41728837e-02f, -2.01182459e-02f, 4.71759625e-02f, 4.63775881e-02f, 4.70534712e-02f, 3.30074131e-02f, -4.04987892e-04f, 5.57575782e-04f, -6.49094880e-02f, -7.05254450e-03f,
  -8.12752396e-02f, -3.06828022e-02f, -2.08425950e-02f, -5.05631790e-02f, -4.79898266e-02f, -3.42146195e-02f, -7.90583119e-02f, -7.69672589e-03f, -9.13116187e-02f, -6.58253580e-02f,
  2.93079726e-02f, 4.56517152e-02f, -1.26992792e-01f, -2.08274485e-03f, -3.94465700e-02f, -2.26812214e-02f, -3.75714265e-02f, -1.05974320e-02f, 4.96888123e-02f, -1.64026141e-01f,
  9.12953243e-02f, -1.66292060e-02f, 1.49921756e-02f, 3.72748673e-02f, -7.61537999e-02f, -2.33582389e-02f, -8.66119936e-02f, 1.72042549e-02f, -4.34029698e-02f, -4.75646742e-02f,
  -3.74386571e-02f, 2.08412623e-03f, 3.00750472e-02f, 4.44408506e-03f, 2.82082502e-02f, -3.34052294e-02f, 3.34362760e-02f, 3.74075659e-02f, -1.87061541e-02f, 7.06313550e-02f,
  4.89450954e-02f, -2.62984708e-02f, -8.32666233e-02f, -6.14763275e-02f, 1.01526119e-01f, -6.71315044e-02f, -2.28064954e-02f, 4.52681035e-02f, 9.15215909e-02f, 2.85355542e-02f,
  -1.66043341e-01f, 1.97143704e-01f, -1.10681608e-01f, -4.25577648e-02f, -7.59385228e-02f, 2.89474241e-02f, -1.90240201e-02f, 3.90951894e-02f, -5.01339510e-02f, -6.17018454e-02f,
  -5.61575927e-02f, -1.09982744e-01f, -1.06591053e-01f, 2.62373071e-02f, 5.19229248e-02f, 4.75898087e-02f, -1.03341706e-01f, -5.59028126e-02f, 7.50789344e-02f, -6.84293732e-03f,
  2.66414210e-02f, -2.38913912e-02f, -1.18681751e-01f, -4.47247922e-02f, -1.19472012e-01f, -1.47446975e-01f, -1.07580587e-01f, -8.15991834e-02f, 4.83281575e-02f, -1.46417126e-01f,
  7.20324963e-02f, -5.47666661e-02f, -7.66545534e-02f, -4.86311689e-02f, -4.04068083e-02f, -1.73289813e-02f, -6.04871623e-02f, 2.28471179e-02f, -6.84491321e-02f, -1.69413760e-02f,
  -1.15112826e-01f, 9.32009332e-03f, 1.70686506e-02f, 2.29275040e-02f, 7.53922015e-02f, -6.78601488e-02f, 8.62610564e-02f, 1.25003412e-01f, 9.50433463e-02f, -5.72395325e-02f,
  -7.40138888e-02f, -7.85532519e-02f, -2.27883533e-02f, -1.47283114e-02f, -1.32072523e-01f, 5.91595247e-02f, 2.04108972e-02f, -9.78459418e-03f, 4.00811508e-02f, -1.89507063e-02f,
  -5.87835275e-02f, 2.68574040e-02f, -3.32271284e-03f, 2.49058902e-02f, -3.30369361e-02f, -8.36496726e-02f, 3.01881097e-02f, 4.11641458e-03f, -5.71802445e-02f, -1.07197538e-01f,
  8.26312676e-02f, -6.02672733e-02f, 3.12690288e-02f, 3.08469944e-02f, -9.08011347e-02f, -3.09880581e-02f, 3.03391162e-02f, 1.80414729e-02f, 3.62435058e-02f, -4.66845147e-02f,
  3.51327211e-02f, 7.77817890e-02f, -6.73191622e-02f, -2.14328971e-02f, -5.27261198e-02f, 1.08597979e-01f, -2.88121235e-02f, 5.13279019e-03f, -2.74452996e-02f, -1.19459014e-02f,
  6.21435642e-02f, 4.09707837e-02f, 1.91646218e-02f, 7.43088871e-02f, 4.30288613e-02f, 3.46374922e-02f, 2.48560980e-02f, -4.82947828e-04f, 6.87590837e-02f, -5.55918925e-02f,
  -6.08558170e-02f, -4.40992229e-03f, -4.89346264e-03f, 8.93809795e-02f, -9.07172486e-02f, 1.92099605e-02f, 1.50103783e-02f, 8.45651794e-03f, -6.37642071e-02f, -1.15945041e-02f,
  5.79854064e-02f, 2.38630368e-04f, 4.59440351e-02f, 2.33853869e-02f, -2.66361460e-02f, -3.43312360e-02f, -5.13723865e-02f, 1.00689679e-02f, -5.67606315e-02f, 2.53149010e-02f,
  5.95945977e-02f, 8.27991664e-02f, -6.14215359e-02f, 1.72652826e-02f, -4.75350022e-02f, -2.64781900e-02f, -6.06070422e-02f, 3.72264571e-02f, -4.76464815e-02f, -6.29289523e-02f,
  -8.66495445e-02f, 4.79281694e-02f, 8.37224051e-02f, 3.41710672e-02f, 1.09312870e-01f, 4.40989733e-02f, 6.93640783e-02f, 3.13792862e-02f, 4.84455116e-02f, -3.31425071e-02f,
  1.07556116e-03f, 1.03245445e-01f, 4.20698337e-02f, 8.56102183e-02f, -3.23733315e-02f, 9.41180512e-02f, 3.57922316e-02f, -6.54811263e-02f, 9.89648551e-02f, -1.31023144e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 104)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 104;
const float L0_fan_Bp_bar_data[] = {
  1.15362369e-01f, 3.01910695e-02f, 7.71928057e-02f, 3.95602249e-02f, -2.68169818e-03f, 1.18021920e-01f, 2.07603291e-01f, 1.55844569e-01f, 1.41021371e-01f, 1.33513942e-01f,
  1.81876630e-01f, 2.71421820e-01f, 2.85846903e-03f, 8.29742551e-02f, 1.43816859e-01f, 1.24155775e-01f, 2.00718522e-01f, -2.21896116e-02f, -9.20271594e-03f, 1.15290210e-01f,
  9.74838436e-03f, -2.01828890e-02f, 2.01939732e-01f, 6.45110235e-02f, 1.63152292e-01f, 1.43183559e-01f, 9.02762115e-02f, 7.57562146e-02f, 1.58710927e-01f, -3.11071929e-02f,
  1.61716163e-01f, 2.08230644e-01f, 6.43302724e-02f, 1.00298911e-01f, 2.19476297e-01f, 1.82761118e-01f, 2.22004846e-01f, 1.01725459e-01f, 5.20899817e-02f, 2.17606440e-01f,
  5.50205335e-02f, 4.56284806e-02f, 8.79401267e-02f, 4.04434949e-02f, 1.93769112e-01f, 7.74539858e-02f, 1.33695692e-01f, 6.83382228e-02f, -2.92454381e-02f, 2.84586977e-02f,
  -7.00532272e-02f, 1.03322335e-01f, 1.34980515e-01f, 1.52106598e-01f, 1.78822502e-01f, 9.92719363e-03f, -1.85868051e-02f, 1.07585497e-01f, 8.02272484e-02f, 5.84460273e-02f,
  1.44684687e-01f, 9.25594196e-02f, 5.91305420e-02f, 1.85550764e-01f, -3.52689414e-04f, 1.17450384e-02f, 1.34253621e-01f, 1.03517570e-01f, 1.26382783e-01f, 1.99162036e-01f,
  1.53583840e-01f, 4.93033156e-02f, 1.12887889e-01f, 1.80513486e-01f, 1.00874260e-01f, -1.78784237e-03f, 1.89233467e-01f, -2.84240954e-02f, 1.95496663e-01f, 1.33251816e-01f,
  -6.24706363e-03f, -4.30726521e-02f, 5.49274236e-02f, 9.70202759e-02f, 1.35464787e-01f, 1.57248273e-01f, 5.83076142e-02f, 6.72435164e-02f, 9.25257578e-02f, 7.08551193e-03f,
  1.31714955e-01f, 6.94322959e-02f, 1.15175046e-01f, 7.47555941e-02f, 2.22471863e-01f, -7.24493153e-03f, 1.04538538e-01f, 5.41624017e-02f, 1.00637123e-01f, 1.49716893e-02f,
  1.46805823e-01f, 6.94717243e-02f, -2.71426328e-02f, 4.31724899e-02f
};

// L1_linear_W (Shape: 12 x 128)
const int L1_linear_W_rows = 12;
const int L1_linear_W_cols = 128;
const float L1_linear_W_data[] = {
  -1.10879876e-01f, -9.72475111e-02f, -1.71338245e-01f, -2.18930721e-01f, -1.33016825e-01f, -3.68529081e-01f, -3.16206932e-01f, -2.81008750e-01f, -8.96907449e-02f, -3.97166669e-01f,
  -2.89077789e-01f, -2.56794930e-01f, -1.48485303e-01f, 2.39486173e-01f, -7.98252821e-02f, -1.40117079e-01f, -2.75710076e-01f, 1.88410938e-01f, -2.17314377e-01f, -2.65231401e-01f,
  9.99749731e-03f, -1.32072210e-01f, -1.08991079e-01f, 2.19281435e-01f, -8.64740685e-02f, 1.02274172e-01f, -8.30348358e-02f, 2.27742493e-02f, -1.51450252e-02f, -4.69151847e-02f,
  2.84968674e-01f, -1.15993969e-01f, 2.23509688e-02f, 1.79856736e-02f, -1.39463946e-01f, 5.99292442e-02f, 5.49744904e-01f, -2.12016225e-01f, -1.96573660e-01f, 5.29490933e-02f,
  -4.49374728e-02f, -8.43246002e-03f, 3.67626920e-02f, 9.27825924e-04f, -5.20332307e-02f, 2.34297961e-01f, -3.79764736e-01f, -8.64981264e-02f, -1.75827861e-01f, -4.79426384e-02f,
  -1.98772594e-01f, -1.03587031e-01f, -2.11982504e-02f, -9.05836374e-03f, -7.08611012e-02f, -2.03412160e-01f, 1.07969142e-01f, -1.25749797e-01f, -1.80668831e-01f, 1.13368586e-01f,
  -2.17493907e-01f, 5.55239201e-01f, 2.40987077e-01f, -1.87687084e-01f, 2.18184307e-01f, -7.41726011e-02f, 5.64978421e-02f, -2.45771501e-02f, 9.05533228e-03f, -4.07462381e-03f,
  -6.73705861e-02f, 2.84067035e-01f, -5.00014424e-02f, -3.59641872e-02f, 7.60506019e-02f, 1.61727726e-01f, 2.80558258e-01f, -4.98188473e-02f, -5.43936379e-02f, -1.02527976e-01f,
  3.38240489e-02f, -1.47547796e-01f, 1.73470825e-02f, -2.06150576e-01f, -1.20506752e-02f, 2.66806912e-02f, -1.62493140e-01f, 2.78854761e-02f, -3.77149833e-03f, 2.64474060e-02f,
  -1.49009913e-01f, -1.09967656e-01f, -5.97373359e-02f, -5.00863194e-02f, -1.07934564e-01f, -5.21935299e-02f, 1.40264630e-01f, -2.55898416e-01f, 1.91996887e-01f, 4.30964112e-01f,
  -1.15383230e-02f, -2.38162652e-02f, -1.41522467e-01f, 9.73529741e-02f, 4.53848392e-01f, -3.56699303e-02f, -7.30608702e-02f, -4.05903487e-03f, 1.57138631e-02f, 4.74893212e-01f,
  1.34803355e-01f, 1.06326938e-01f, -3.32468711e-02f, 1.76039547e-01f, -1.18060820e-01f, -8.77789184e-02f, 5.28708100e-02f, -1.44828474e-02f, 7.19602825e-03f, -3.56953070e-02f,
  -9.90138277e-02f, 1.57167558e-02f, 4.53858357e-03f, 3.57966334e-01f, -9.92578939e-02f, 7.86014721e-02f, 1.74474820e-01f, -9.69969630e-02f, -4.55758423e-02f, -2.77469724e-01f,
  6.56164512e-02f, 1.52283520e-01f, -3.88926595e-01f, 1.34587765e-01f, 1.17698170e-01f, 7.20566139e-02f, -6.71757609e-02f, -8.85587484e-02f, -1.25496055e-03f, 6.83255419e-02f,
  2.73821235e-01f, 2.71948427e-01f, 2.90901601e-01f, 5.60637331e-03f, -4.58557963e-01f, 2.30462909e-01f, 7.85925426e-03f, 3.93344462e-01f, -8.40611234e-02f, -4.79676723e-01f,
  -4.39567529e-02f, 9.06154066e-02f, 1.54593766e-01f, -1.95962682e-01f, 8.72959420e-02f, -1.08122513e-01f, 2.36652400e-02f, 3.40850651e-02f, 2.59075850e-01f, -3.11133470e-02f,
  1.63331762e-01f, -1.86572373e-01f, 1.63370535e-01f, 1.54687092e-01f, -4.39187363e-02f, -9.87050822e-04f, -2.71682262e-01f, -2.56796181e-01f, 3.52510922e-02f, -2.19996378e-01f,
  -8.77343640e-02f, -1.26879096e-01f, 2.17357893e-02f, 3.12997341e-01f, -1.28731951e-01f, -4.30945307e-02f, -2.78748810e-01f, -4.25513908e-02f, 1.09443076e-01f, 4.18402478e-02f,
  7.94072300e-02f, 4.27554771e-02f, 2.67507881e-01f, -1.08977854e-01f, -1.21214055e-01f, -1.55749723e-01f, -1.48557216e-01f, 1.87637687e-01f, -1.53381631e-01f, 3.18226367e-01f,
  -4.99208532e-02f, -2.46771842e-01f, 5.51200844e-02f, 6.96694553e-02f, -2.46790096e-01f, 2.40596667e-01f, 3.30848396e-01f, 4.21340577e-02f, 2.81111211e-01f, 2.67830223e-01f,
  -1.04883477e-01f, 5.56644872e-02f, 2.09434122e-01f, 8.19892436e-02f, -1.15461297e-01f, 1.10835955e-01f, -1.72160029e-01f, -4.67255712e-02f, -1.51177764e-01f, 3.85894209e-01f,
  -1.84978083e-01f, -1.21996291e-01f, -4.99225557e-02f, -1.13688461e-01f, -6.12420812e-02f, -1.58852428e-01f, -1.38936013e-01f, 1.21483050e-01f, -9.08623487e-02f, -1.02058254e-01f,
  2.10431963e-01f, 1.37204453e-01f, -1.42742321e-01f, 2.40593720e-02f, -1.17042229e-01f, -1.83083296e-01f, 2.85845578e-01f, 1.22967280e-01f, 5.72057903e-01f, 9.77282003e-02f,
  2.32940301e-01f, -5.54522388e-02f, 3.79743986e-02f, 3.22295159e-01f, -1.08461514e-01f, 5.09783812e-02f, -1.86943859e-01f, 3.31383646e-01f, 3.62589844e-02f, 3.31657454e-02f,
  2.62830500e-02f, 3.45766306e-01f, -3.28862935e-01f, -1.67754740e-01f, -1.82681322e-01f, -2.29193106e-01f, 4.77347821e-01f, 1.42040879e-01f, 1.90290391e-01f, -1.13673434e-01f,
  1.71154156e-01f, 3.60193439e-02f, 6.55563176e-02f, -1.49483070e-01f, -5.06393425e-02f, 1.59655735e-01f, 2.79399395e-01f, 1.31242812e-01f, 2.59297937e-01f, 9.39420834e-02f,
  3.34350079e-01f, 2.27630660e-01f, 1.24918208e-01f, 3.09079111e-01f, 3.09954640e-02f, 2.16292053e-01f, 3.12808394e-01f, 1.64804101e-01f, 4.97671999e-02f, 2.26820320e-01f,
  -1.75750464e-01f, -1.08737417e-01f, -1.09565519e-02f, -5.57559542e-02f, -1.85565665e-01f, -1.72220036e-01f, 2.95623988e-01f, -9.37749669e-02f, 3.26849855e-02f, -2.02083066e-01f,
  -7.14797378e-02f, -2.15362027e-01f, -2.10026335e-02f, -8.04614052e-02f, 3.04915346e-02f, -7.00961659e-03f, -2.02045679e-01f, -4.78793308e-03f, -1.81289673e-01f, -6.12182729e-02f,
  1.20776221e-01f, -2.95782894e-01f, -1.59896061e-01f, -1.00515164e-01f, -1.67729586e-01f, -3.94799300e-02f, -5.29065132e-02f, -6.03648610e-02f, -2.97401156e-02f, 1.60530224e-01f,
  -1.06705800e-01f, 3.91403027e-02f, -1.37403160e-01f, 4.05184984e-01f, 6.02762960e-02f, -1.54639602e-01f, -1.66811571e-01f, 2.37112164e-01f, -8.99174064e-02f, -1.17515540e-02f,
  5.43983914e-02f, -2.05906674e-01f, 6.95656836e-02f, 1.80263408e-02f, 9.37502012e-02f, -1.72546625e-01f, -6.42058626e-02f, -1.75398856e-01f, 1.64166927e-01f, -6.93422109e-02f,
  7.68939704e-02f, 2.48336010e-02f, 3.46454442e-01f, -7.55867884e-02f, 5.13110220e-01f, 4.71840292e-01f, -1.36898100e-01f, -1.37218148e-01f, 1.21528164e-01f, -5.27513437e-02f,
  5.82396910e-02f, 3.38978320e-01f, 7.59676039e-01f, -8.52261931e-02f, -1.44535735e-01f, 1.06978893e-01f, -1.37894928e-01f, -1.42252058e-01f, -5.77430183e-04f, -3.92210521e-02f,
  1.99579194e-01f, 1.20260350e-01f, -2.20639616e-01f, 2.48942059e-02f, 4.71422542e-03f, -2.12415263e-01f, -1.58270285e-01f, -1.80297434e-01f, 1.87634751e-01f, 9.79382321e-02f,
  -2.01671526e-01f, 1.70201417e-02f, 8.39516670e-02f, -1.29043072e-01f, -8.73663947e-02f, -1.61742061e-01f, 2.80458987e-01f, 7.28133991e-02f, 8.33772123e-02f, -9.44311023e-02f,
  6.24007592e-03f, -1.17619693e-01f, 8.37306678e-02f, -2.03697756e-01f, 2.11180031e-01f, 5.31969257e-02f, -8.35899264e-02f, 8.43151733e-02f, 1.14067569e-01f, -2.66864002e-01f,
  -9.26768929e-02f, -9.57981348e-02f, -1.38215311e-02f, -1.46848038e-01f, 9.69039053e-02f, 3.46209407e-02f, 1.62047192e-01f, -2.24832788e-01f, -1.98950350e-01f, -1.98407724e-01f,
  -5.78735694e-02f, -4.69833650e-02f, 3.41182621e-03f, 1.04297876e-01f, -4.80147004e-02f, 4.07968834e-02f, 8.22504908e-02f, -8.27044472e-02f, -2.36839559e-02f, 1.88539308e-02f,
  -1.43309131e-01f, -9.54750031e-02f, 2.64485609e-02f, 5.43908104e-02f, -1.45532116e-01f, -2.84006540e-02f, -1.58544585e-01f, -9.11313221e-02f, 3.26880850e-02f, -1.89621478e-01f,
  -1.30426690e-01f, 2.00632751e-01f, -1.92202497e-02f, -1.55479565e-01f, 3.92065942e-01f, 4.70390707e-01f, -2.15591326e-01f, 2.01281801e-01f, 1.85247269e-02f, 2.18938533e-02f,
  3.23993526e-03f, 4.79026347e-01f, 6.01986311e-02f, -5.10281790e-03f, -3.34302545e-01f, -1.05353273e-01f, -8.30093250e-02f, -1.72116116e-01f, 7.76189044e-02f, -3.31183285e-01f,
  1.30647987e-01f, 1.72678873e-01f, 2.85544306e-01f, 3.66989434e-01f, -2.45321646e-01f, -3.18153314e-02f, -1.35852471e-01f, 9.28345323e-02f, -7.88984299e-02f, 4.27867286e-02f,
  1.43225312e-01f, -1.36004895e-01f, 3.28313321e-01f, -1.75476372e-01f, -1.51333824e-01f, 7.02613639e-03f, -8.42866078e-02f, -3.38048860e-02f, -1.37351319e-01f, 3.31368685e-01f,
  -1.30003363e-01f, -1.34598494e-01f, 1.89541489e-01f, -9.21461508e-02f, 2.06447318e-01f, -1.31274268e-01f, -1.51148178e-02f, 3.87396425e-01f, -1.21291220e-01f, -1.68241277e-01f,
  1.14441685e-01f, -1.07186981e-01f, -1.74157217e-01f, 1.93521809e-02f, -3.58403437e-02f, -3.01734567e-01f, -1.11762546e-02f, -1.44133687e-01f, -3.47908065e-02f, 1.18473984e-01f,
  -2.90616695e-02f, 1.47508442e-01f, 1.03274316e-01f, -1.06266826e-01f, -8.71922821e-02f, -1.96130440e-01f, -9.58097726e-02f, 1.68705449e-01f, 2.71715730e-01f, 1.94907486e-01f,
  -1.27515802e-02f, 3.00361931e-01f, -1.14800833e-01f, -9.21176895e-02f, -1.99185133e-01f, -1.25495732e-01f, 5.24741225e-02f, 2.30370626e-01f, -1.14336766e-01f, -8.81190896e-02f,
  1.52212918e-01f, 3.59287351e-01f, 5.66850185e-01f, -1.85570344e-01f, -7.12524503e-02f, 5.59095405e-02f, -3.63919623e-02f, -1.31298959e-01f, 2.45541617e-01f, -9.94025823e-03f,
  -1.09355532e-01f, 4.47940715e-02f, -2.33341575e-01f, -3.74948531e-01f, -1.70256302e-01f, -2.01167151e-01f, -1.27368912e-01f, 1.16603903e-01f, 2.33741105e-01f, -1.60113141e-01f,
  3.49397868e-01f, 7.05144480e-02f, -6.19683750e-02f, 4.19807211e-02f, 4.02624309e-02f, -5.52320108e-02f, -1.58342391e-01f, 1.54924825e-01f, -1.04948632e-01f, 9.38616693e-02f,
  4.67345417e-01f, -2.72618048e-02f, -4.35069889e-01f, 5.30618019e-02f, -1.06668867e-01f, -3.98898244e-01f, 1.92629665e-01f, -1.56396657e-01f, 2.22187508e-02f, -4.13829565e-01f,
  1.26015797e-01f, -5.19489348e-02f, -3.98137458e-02f, -1.77497119e-02f, -1.88478053e-01f, -1.72246605e-01f, -2.97326267e-01f, -2.70292938e-01f, 3.73108953e-01f, -8.80914181e-03f,
  9.33540091e-02f, -1.19099610e-01f, -1.52212918e-01f, -3.40246260e-01f, -4.72026259e-01f, -4.20730375e-02f, -2.11169738e-02f, -1.59005690e-02f, 7.61153772e-02f, -2.20742777e-01f,
  -4.66361828e-02f, -9.09822658e-02f, -1.75615683e-01f, -1.30206225e-02f, 1.06220476e-01f, -9.77892950e-02f, -1.50607094e-01f, 5.21429002e-01f, -3.27169597e-01f, -2.10866645e-01f,
  -1.29734855e-02f, 1.67420030e-01f, 2.69826084e-01f, -2.19917037e-02f, 4.83940132e-02f, -8.72401372e-02f, -7.42074698e-02f, -2.70426005e-01f, 3.65005493e-01f, 2.08729863e-01f,
  -6.46085516e-02f, -1.43999770e-01f, 1.63831830e-01f, 2.59354591e-01f, 1.51888898e-03f, 1.43382745e-02f, -3.48286494e-03f, 2.17157349e-01f, 1.46316797e-01f, 7.75137469e-02f,
  -1.75990701e-01f, 3.46643478e-01f, 1.27968401e-01f, 5.36537245e-02f, 2.03027382e-01f, 8.14025328e-02f, -3.26558538e-02f, 3.00113618e-01f, 2.61025846e-01f, 1.67176947e-01f,
  -3.34572941e-02f, 4.94509414e-02f, -3.53781842e-02f, -1.59989998e-01f, 7.01372847e-02f, 1.27883643e-01f, 2.80058011e-02f, -1.89785823e-01f, 6.15114793e-02f, -4.68461551e-02f,
  -2.42752265e-02f, 6.86428323e-03f, -6.97979107e-02f, -1.91606611e-01f, 2.12300465e-01f, 3.65156323e-01f, 5.40498132e-03f, -1.26421139e-01f, 1.03388995e-01f, -1.57847196e-01f,
  -9.20082927e-02f, -8.77825916e-02f, 2.00158745e-01f, 1.28452435e-01f, -3.29520926e-02f, 2.18319222e-01f, 8.49462748e-02f, -1.32591441e-01f, -2.24096417e-01f, 1.20909914e-01f,
  1.70302674e-01f, -3.20275724e-02f, -5.77584207e-02f, -6.53950348e-02f, 6.59226403e-02f, 4.92249578e-02f, -2.81617671e-01f, -5.44872880e-02f, -6.78782687e-02f, -7.15613365e-02f,
  1.05172649e-01f, 1.26102678e-02f, 2.76315771e-02f, 9.82354507e-02f, -8.74290839e-02f, 1.48512155e-01f, 9.87151712e-02f, 3.06468666e-01f, 2.24800318e-01f, 3.30291271e-01f,
  -2.01887086e-01f, -1.45721436e-01f, -4.20882292e-02f, -7.12099969e-02f, -1.20345205e-01f, -2.31501292e-02f, -2.65615791e-01f, -1.36845529e-01f, 5.18362736e-03f, -1.53758824e-01f,
  4.02503073e-01f, 9.54760909e-02f, 1.83389664e-01f, 2.23205194e-01f, 4.08381343e-01f, 2.04649583e-01f, 9.87247080e-02f, 1.61638290e-01f, -1.61133423e-01f, 2.73114592e-01f,
  1.20427690e-01f, 1.40325844e-01f, 2.49735191e-02f, 2.01692522e-01f, 4.23886597e-01f, 8.64200071e-02f, -1.98954307e-02f, -1.79033548e-01f, -4.06323038e-02f, 1.52315646e-01f,
  -4.82824773e-01f, -1.16893210e-01f, -6.81202635e-02f, -3.00827175e-01f, 2.57969260e-01f, 9.44783315e-02f, 5.05975299e-02f, 1.47809640e-01f, 4.09859270e-02f, 9.42188054e-02f,
  7.19854414e-01f, 8.79316032e-02f, 1.63951591e-01f, 9.37043279e-02f, -5.99855743e-02f, 4.74249244e-01f, -3.05756051e-02f, 5.63593209e-02f, 2.27236673e-01f, -2.26158321e-01f,
  -1.57409340e-01f, -1.35072768e-01f, -3.20261195e-02f, 1.36515066e-01f, 6.07145689e-02f, -3.22119594e-01f, 3.84236723e-02f, -8.00815523e-02f, 8.21697060e-03f, 7.78091373e-03f,
  9.30382907e-02f, -3.07254586e-02f, 4.93445098e-01f, 1.41935855e-01f, -3.75577509e-02f, 7.89544135e-02f, 2.98275292e-01f, -2.57624775e-01f, -2.17475340e-01f, 3.88674960e-02f,
  -3.13295983e-02f, 2.38875285e-01f, 1.19697630e-01f, -2.05687284e-01f, 5.07118627e-02f, -5.25142290e-02f, -1.83828697e-01f, 7.43783861e-02f, -2.40293324e-01f, -1.53678298e-01f,
  -8.54925364e-02f, 2.30527833e-01f, -2.47057974e-02f, 1.67703666e-02f, 3.63538973e-02f, -1.98149666e-01f, -2.59207457e-01f, 3.52403484e-02f, 7.39431009e-02f, -1.01727448e-01f,
  5.45585528e-02f, 6.49399683e-02f, 1.06632300e-01f, -8.69692713e-02f, 2.74475627e-02f, -1.69839725e-01f, -6.10804036e-02f, -1.61621287e-01f, -5.07506691e-02f, 2.09986135e-01f,
  2.61345766e-02f, -9.66260210e-02f, -3.09409499e-01f, -3.34569454e-01f, 4.24087316e-01f, 7.62727261e-02f, 4.25638892e-02f, -9.22765210e-02f, -1.62201583e-01f, -7.48250186e-02f,
  -2.63073683e-01f, -4.99995574e-02f, -1.30886789e-02f, 1.78232044e-01f, -1.67001277e-01f, -9.66668203e-02f, 1.97656974e-02f, 1.21837586e-01f, -1.39771953e-01f, 2.87447274e-01f,
  4.55648899e-01f, -4.27819677e-02f, -1.06303990e-02f, -2.68928371e-02f, 9.35193747e-02f, 1.92044839e-01f, 4.53913063e-02f, 2.97569692e-01f, 1.76610798e-02f, -4.38995175e-02f,
  -1.69403374e-01f, -8.19640011e-02f, -1.17895558e-01f, 2.99813032e-01f, -1.45340770e-01f, -9.50504169e-02f, -8.87518376e-02f, -4.89511825e-02f, 2.38142669e-01f, 3.67444456e-02f,
  -8.79109353e-02f, 4.87115644e-02f, -1.29824534e-01f, -6.37315884e-02f, 1.69574052e-01f, 2.20105872e-01f, 1.34408072e-01f, 2.30752587e-01f, -4.08369303e-01f, -3.26271623e-01f,
  -1.76198825e-01f, 3.38938624e-01f, -2.62930214e-01f, 1.44973651e-01f, 3.81999135e-01f, -4.11743790e-01f, 3.24907482e-01f, 2.50678658e-01f, -1.72499746e-01f, -2.56002694e-02f,
  4.54695076e-01f, -7.30938494e-01f, -1.45865753e-01f, -1.35206208e-01f, 6.43339977e-02f, -2.59077661e-02f, 1.04553416e-01f, 1.57812521e-01f, -1.77995145e-01f, -1.57564536e-01f,
  9.51923579e-02f, 3.36264253e-01f, -1.44792963e-02f, -2.45389819e-01f, -1.44795954e-01f, -7.30735660e-02f, -9.35842246e-02f, -2.18239397e-01f, -8.49526450e-02f, -3.07880025e-02f,
  1.82941824e-01f, 2.45445166e-02f, -8.23018253e-02f, -1.40091375e-01f, 7.26909712e-02f, -7.79874921e-02f, -1.86351418e-01f, -1.18460283e-01f, 2.00233206e-01f, 5.40596023e-02f,
  -1.53132081e-01f, -1.42649308e-01f, 1.17094129e-01f, -1.56115711e-01f, -8.57720524e-02f, 1.98435903e-01f, -3.06251831e-02f, -1.88563034e-01f, -2.90840924e-01f, -1.91559449e-01f,
  -2.34829500e-01f, -1.91750810e-01f, -5.32704964e-02f, -2.36400604e-01f, 1.46849036e-01f, -9.03052986e-02f, -3.87458652e-02f, -1.81688257e-02f, -1.00947559e-01f, -9.48656276e-02f,
  1.56709366e-02f, -1.02222502e-01f, 3.68076633e-03f, -3.81616130e-02f, -1.17133185e-01f, -1.30595431e-01f, -1.66035011e-01f, 1.26268521e-01f, -5.65086231e-02f, -1.89259365e-01f,
  8.02243501e-02f, 1.65130571e-02f, 4.45688050e-03f, 3.59303713e-01f, -1.18748143e-01f, -1.85442135e-01f, 1.09488063e-01f, -4.14291859e-01f, 1.28239552e-02f, 1.75790757e-01f,
  -1.37453461e-02f, -1.18845895e-01f, 1.24427579e-01f, 3.50973576e-01f, -1.59565270e-01f, 1.86608344e-01f, -1.64956659e-01f, -1.52453631e-01f, 4.24987674e-02f, -5.46933003e-02f,
  2.68053889e-01f, 1.44060925e-01f, -3.58765386e-02f, -1.11002035e-01f, -5.62600326e-03f, -2.22576946e-01f, 3.46731916e-02f, -2.13496685e-01f, -7.66188726e-02f, -4.68342900e-02f,
  6.09572791e-02f, -1.63551912e-01f, -1.37555853e-01f, -2.79947817e-02f, -2.31278539e-02f, -1.58735849e-02f, -1.00734532e-01f, 2.42210060e-01f, -1.41943097e-01f, 1.43999174e-01f,
  -4.33924682e-02f, -1.85800884e-02f, 7.70438731e-01f, -1.78612620e-01f, -2.08018109e-01f, -9.99569297e-02f, 3.00100297e-02f, -1.12805463e-01f, 1.16912901e-01f, 9.65385586e-02f,
  -3.06829125e-01f, 2.81995256e-02f, -2.18346745e-01f, 2.78810747e-02f, -1.29857197e-01f, -3.26961964e-01f, -1.97175872e-02f, -4.98656183e-02f, 1.02870703e-01f, 7.44869858e-02f,
  1.57516688e-01f, 5.83083853e-02f, 2.47538894e-01f, 9.53675061e-02f, -4.03301746e-01f, -1.99138299e-01f, 2.74811089e-01f, 4.55864310e-01f, 1.93545341e-01f, 2.82836676e-01f,
  -1.77905709e-02f, -7.84614906e-02f, -1.49483413e-01f, -4.26992290e-02f, -5.85146956e-02f, -1.77318811e-01f, -1.24512449e-01f, 1.87142696e-02f, 1.34858474e-01f, -1.40009606e-02f,
  -3.49545255e-02f, -1.82028651e-01f, -7.12955184e-03f, -3.21840681e-02f, -1.40255287e-01f, 2.74673607e-02f, -5.57264835e-02f, 1.04275115e-01f, 2.07663663e-02f, -7.96340182e-02f,
  7.54628927e-02f, -8.23951960e-02f, 4.82061915e-02f, -1.29629418e-01f, 2.32418910e-01f, 6.54477067e-03f, -1.39887780e-01f, -1.34011120e-01f, -1.19872466e-01f, -5.67058437e-02f,
  -2.20874593e-01f, -4.92928848e-02f, 8.45435113e-02f, -4.45972718e-02f, -2.54726876e-02f, -1.46243051e-01f, 2.26017550e-01f, -9.51234326e-02f, -1.16731331e-01f, 3.04949105e-01f,
  -5.60429655e-02f, -1.29094839e-01f, -1.33134857e-01f, 3.58297139e-01f, -5.28903194e-02f, -6.62309527e-02f, -3.16180959e-02f, -3.26549858e-02f, -4.09210697e-02f, 1.60847325e-02f,
  -3.83550003e-02f, -4.83722538e-02f, -5.57563975e-02f, -1.22115955e-01f, -5.98538369e-02f, 1.55803502e-01f, -6.02229722e-02f, -1.23087794e-01f, -4.76514921e-02f, -8.88574421e-02f,
  3.01742069e-02f, 7.25548565e-02f, 2.08908230e-01f, -5.11126034e-02f, -3.34114693e-02f, 7.50809014e-01f, -6.12885095e-02f, 3.14035453e-02f, -1.62053272e-01f, -1.39378265e-01f,
  6.09369166e-02f, -1.95726052e-01f, 1.45679504e-01f, 5.04305623e-02f, -1.45618275e-01f, -1.25300884e-01f, -4.62755896e-02f, 3.11459112e-03f, -9.71941128e-02f, -7.11730048e-02f,
  -1.30138725e-01f, -5.31962439e-02f, 7.48029426e-02f, 4.05485868e-01f, 1.15680993e-01f, -1.44010872e-01f, 8.94806832e-02f, -1.06962346e-01f, 6.91867247e-02f, -1.44625098e-01f,
  7.13728741e-02f, -1.06737733e-01f, -7.08389431e-02f, 3.84411588e-02f, -5.63525409e-02f, -1.31730005e-01f, -2.17795838e-02f, 4.08418477e-01f, -2.14954436e-01f, -4.78124693e-02f,
  -3.07757944e-01f, -1.39156640e-01f, -6.19560704e-02f, -2.88342163e-02f, -1.45262748e-01f, 1.19990148e-01f, -1.41438186e-01f, -3.62975240e-01f, 1.74127981e-01f, 2.00559840e-01f,
  -5.27642556e-02f, -3.45100135e-01f, 1.53653726e-01f, 1.22359939e-01f, 1.31773740e-01f, 1.06026337e-01f, 4.71547335e-01f, -6.49162605e-02f, 3.45846862e-01f, 5.37356913e-01f,
  -6.23208173e-02f, 1.52989820e-01f, 2.98404366e-01f, 4.33797866e-01f, -1.52508274e-01f, 3.95323694e-01f, 1.67608306e-01f, 7.01239258e-02f, -1.50258495e-02f, 2.47893836e-02f,
  -6.66265413e-02f, -2.60699932e-02f, 2.16582209e-01f, 2.09256746e-02f, -4.75570234e-03f, 4.87146294e-03f, -1.73669815e-01f, -3.85393575e-02f, 3.06055605e-01f, -1.17505550e-01f,
  3.38185392e-02f, 9.29130688e-02f, 5.99359088e-02f, -4.05995026e-02f, -1.33846134e-01f, -9.72439125e-02f, -4.65449877e-02f, -1.04807489e-01f, 1.39742717e-01f, -1.18551634e-01f,
  -1.94725677e-01f, -9.19964015e-02f, -6.16455562e-02f, -7.42623508e-02f, -9.20641497e-02f, -1.43989190e-01f, 4.68110964e-02f, 1.90304667e-02f, 3.81158888e-01f, -4.93235737e-02f,
  -1.95734039e-01f, -1.60048142e-01f, -3.64294462e-02f, -1.20759979e-01f, 1.30736813e-01f, -1.77650437e-01f, -5.31597808e-02f, -1.15680650e-01f, -2.12328300e-01f, -1.38199195e-01f,
  -1.61157086e-01f, -2.74620682e-01f, 2.79679466e-02f, 2.44881795e-03f, 6.98783636e-01f, 3.36776711e-02f, 1.62992552e-01f, 3.85019183e-02f, -2.31398325e-02f, -2.12170929e-03f,
  -1.47041067e-01f, 3.17632228e-01f, 4.41575259e-01f, -1.07341908e-01f, 1.84982434e-01f, -8.76079351e-02f, -9.47265998e-02f, -9.23653245e-02f, -8.45332518e-02f, 2.98759770e-02f,
  -7.23832473e-02f, -6.30850419e-02f, -2.42814943e-02f, 3.34161445e-02f, -6.57328665e-02f, 2.62703270e-01f, 1.39297634e-01f, -1.91042587e-01f, 2.30774984e-01f, -1.09032929e-01f,
  1.91508576e-01f, -7.04394132e-02f, -4.77397218e-02f, -1.13009801e-03f, -2.52060175e-01f, -6.54445365e-02f, 1.93173990e-01f, -1.10994451e-01f, 7.78156295e-02f, -3.42438482e-02f,
  2.74067447e-02f, -3.22241411e-02f, -6.12621233e-02f, -2.51917362e-01f, -1.57664672e-01f, -6.25617504e-02f, -1.34570599e-01f, -1.43258661e-01f, -7.67764673e-02f, 3.75828668e-02f,
  -1.24593213e-01f, -6.00867197e-02f, 2.00683534e-01f, -4.46728282e-02f, 7.04023689e-02f, -7.19308332e-02f, 2.71193713e-01f, -7.23522753e-02f, -1.28871024e-01f, 3.42126906e-01f,
  -1.08324736e-01f, 8.59774798e-02f, -1.27721906e-01f, 1.05916604e-01f, -2.91170925e-01f, 9.92764011e-02f, -2.09161699e-01f, 2.25216255e-01f, 9.99653488e-02f, -4.40659598e-02f,
  8.56347457e-02f, -1.50646761e-01f, 2.13905841e-01f, 2.77435720e-01f, -3.10049444e-01f, -3.74202847e-01f, -2.94689506e-01f, -2.62759745e-01f, 4.14585620e-01f, -1.32520571e-01f,
  -2.63039231e-01f, -5.57471037e-01f, -7.45117664e-02f, -4.56693828e-01f, 1.00435115e-01f, 4.34382975e-01f, -1.60328671e-01f, 3.80254984e-01f, -2.03657717e-01f, -1.52730346e-01f,
  -9.67939794e-02f, -9.76681486e-02f, -3.60302515e-02f, 1.86104253e-02f, -2.40368456e-01f, 2.49581680e-01f, -1.58717752e-01f, 1.01173915e-01f, -9.13350731e-02f, -1.66831631e-02f,
  -1.79869652e-01f, -1.23347573e-01f, 5.21622479e-01f, 6.37183860e-02f, 1.14518791e-01f, -4.43530828e-02f, 1.12414718e-01f, -3.14763673e-02f, 8.39027837e-02f, -1.03007369e-01f,
  1.95308864e-01f, 2.46139895e-03f, 8.73202085e-02f, 6.25898922e-03f, -8.13331082e-02f, 3.13688546e-01f, -1.23432837e-01f, -1.58450603e-01f, -1.72608979e-02f, 5.08174360e-01f,
  -9.74643417e-03f, -3.11841443e-03f, -1.60311744e-01f, -3.89883518e-02f, 1.30406469e-01f, -1.85525090e-01f, 1.77588016e-01f, 2.75833726e-01f, 3.79245877e-02f, -9.31711048e-02f,
  -1.41436875e-01f, -7.21637309e-02f, -1.05863892e-01f, -9.64245349e-02f, -4.66933772e-02f, 1.85723647e-01f, 9.68504474e-02f, -1.40277624e-01f, -2.37515584e-01f, 5.92218898e-03f,
  -7.43333846e-02f, 2.14842230e-01f, 9.79808941e-02f, 1.95019811e-01f, 2.92288288e-02f, -1.02394454e-01f, -1.23194598e-01f, -9.39810500e-02f, 1.16094938e-02f, -1.53473675e-01f,
  7.68347308e-02f, 5.11041842e-02f, 1.77489251e-01f, -1.65989771e-01f, 1.42663193e-03f, -4.34295163e-02f, -8.27942267e-02f, 7.29991198e-02f, -1.10201403e-01f, -2.97314040e-02f,
  -2.15066120e-01f, -1.28257662e-01f, -1.11380473e-01f, -7.59832561e-02f, -1.93778169e-03f, 3.47793996e-02f, 1.44872377e-02f, 4.16598486e-04f, 3.85249704e-01f, -1.78498849e-01f,
  2.46767327e-01f, -1.90663582e-03f, -8.31075162e-02f, 1.60415694e-01f, 9.86641198e-02f, -8.03605542e-02f, -7.47441426e-02f, 3.60817648e-02f, -2.02548578e-01f, 1.35698050e-01f,
  -5.79493716e-02f, 6.33605197e-02f, 2.04375505e-01f, 1.65510222e-01f, -1.68347433e-01f, -1.26254737e-01f, 3.74235839e-01f, -6.20294660e-02f, -7.22099245e-02f, -3.80188972e-02f,
  8.90541971e-02f, 1.01426944e-01f, -1.44547418e-01f, 1.83616430e-01f, -3.60310674e-02f, -8.68026167e-02f, -2.44414695e-02f, 1.67485118e-01f, 7.48087913e-02f, -8.17175768e-03f,
  -1.28421783e-01f, 1.66527987e-01f, 2.85931438e-01f, -1.89003691e-01f, 4.04341370e-01f, -6.06680810e-02f, -3.38684618e-01f, 2.71424294e-01f, 3.27235490e-01f, 8.28710478e-03f,
  1.39210045e-01f, 3.41571301e-01f, -3.29988480e-01f, -9.74999741e-04f, -6.34582043e-02f, -1.20649926e-01f, -5.01157865e-02f, 2.21142888e-01f, 7.83857554e-02f, -1.99471563e-01f,
  -2.05075935e-01f, 2.18951434e-01f, -1.25467911e-01f, -4.97937799e-02f, -1.73031062e-01f, 5.88558801e-02f, 1.80917345e-02f, 3.42822701e-01f, 8.26873630e-02f, -9.33589414e-02f,
  -5.71195744e-02f, 3.85782212e-01f, -6.45285323e-02f, 1.27239637e-02f, -3.02284695e-02f, -1.07869491e-01f, 3.19135368e-01f, -1.49886206e-01f, 1.59974962e-01f, 7.04696536e-01f,
  -1.43106058e-01f, 2.36019231e-02f, -1.52901351e-01f, 4.06399406e-02f, -1.11322455e-01f, 3.67901772e-01f, 9.61675718e-02f, -1.73104882e-01f, -8.08189809e-02f, 3.72470438e-01f,
  -8.16889182e-02f, -2.43816882e-01f, -1.95175841e-01f, 2.73974508e-01f, 2.21387163e-01f, -4.51532975e-02f, -2.18559757e-01f, -1.81790859e-01f, 1.45162180e-01f, 8.45746994e-02f,
  9.94614791e-03f, -2.64366642e-02f, -1.34656310e-01f, -3.37548703e-02f, -1.03465848e-01f, -1.94134321e-02f, -6.29273131e-02f, -2.34455138e-01f, 1.18521221e-01f, -9.27273110e-02f,
  -1.16125450e-01f, -1.36956826e-01f, -2.77467519e-02f, -7.89084956e-02f, -9.76080075e-02f, -5.67010716e-02f, 2.76098028e-02f, -1.17934234e-02f, -1.17568094e-02f, 7.08424598e-02f,
  -6.64848089e-02f, -1.53745905e-01f, 7.29911327e-02f, -1.86227202e-01f, -1.85024217e-02f, -7.97013789e-02f, -8.76142457e-02f, -7.64796045e-03f, -1.06720358e-01f, -1.86954755e-02f,
  -5.70628643e-02f, 1.00262510e-02f, -1.64524585e-01f, -2.16037005e-01f, -1.12207204e-01f, 5.33562005e-02f, -2.53112353e-02f, -6.56906515e-02f, 7.83509482e-03f, -8.63075927e-02f,
  -4.63428386e-02f, 2.58651376e-01f, -8.05684328e-02f, 1.64608777e-01f, -1.66391802e-03f, 3.51792186e-01f, -3.29288989e-02f, -1.66446581e-01f, -1.53830826e-01f, -1.05391964e-01f,
  1.40347714e-02f, -1.62678391e-01f, -1.38554618e-01f, -3.65011171e-02f, -1.36974737e-01f, -5.18462583e-02f, -1.04756214e-01f, -4.39942628e-02f, 1.48224027e-03f, 5.90322092e-02f,
  1.22252092e-01f, 9.65784639e-02f, 2.30821490e-01f, -2.47306377e-01f, 1.28978238e-01f, -1.26077961e-02f, 3.32932174e-02f, 7.05043152e-02f, 1.18333258e-01f, 5.54357581e-02f,
  -5.01604974e-01f, -3.13835144e-01f, -7.51310140e-02f, 1.40043542e-01f, 8.34802017e-02f, -3.57382625e-01f, 1.78224966e-01f, 2.57912040e-01f, 1.94861352e-01f, 2.66517073e-01f,
  1.48250237e-01f, 1.60489492e-02f, 1.14398086e-02f, -1.39444038e-01f, 4.46087211e-01f, -4.79700193e-02f, -4.46149334e-03f, 2.94666469e-01f, -2.08333597e-01f, -1.15580074e-01f,
  2.09495172e-01f, 6.97502345e-02f, -4.63403463e-02f, -8.18592682e-02f, -6.75763264e-02f, -1.45935312e-01f, -3.43906656e-02f, 7.01501966e-02f, 1.33791655e-01f, 1.37213501e-03f,
  -8.65125582e-02f, -1.33216962e-01f, 6.44856840e-02f, -1.09350525e-01f, -9.39964950e-02f, 9.85293835e-02f, -1.14090264e-01f, -1.11026866e-02f, 1.29405811e-01f, -1.73834264e-01f,
  1.36991516e-02f, -5.52392080e-02f, -2.23466098e-01f, -9.22771171e-03f, -1.19043022e-01f, -9.37444121e-02f, 6.34814918e-01f, -1.25421554e-01f, 3.86145204e-01f, -8.82042721e-02f,
  -1.29096620e-02f, -2.05448121e-01f, -2.23116558e-02f, -2.39088647e-02f, -7.34169185e-02f, -2.22363651e-01f, -1.34703116e-02f, -7.83641040e-02f, -2.42796838e-01f, -4.96734343e-02f,
  6.59963861e-02f, 4.67642583e-02f, -3.26632783e-02f, -1.38491020e-01f, -1.72707915e-01f, 2.97805011e-01f, -1.26573160e-01f, -5.33124879e-02f, -7.30748987e-03f, 3.30231845e-01f,
  1.10138999e-02f, -1.02416255e-01f, -7.51575008e-02f, 1.63569171e-02f, 1.61532804e-01f, 5.09258151e-01f, -3.96045558e-02f, -2.55869567e-01f, 7.74025619e-02f, 2.70738512e-01f,
  -2.36327783e-03f, 6.56672567e-02f, 4.21034805e-02f, 3.40777129e-04f, 8.94993991e-02f, 2.32354060e-01f, -1.36247739e-01f, -7.05740601e-02f, -1.59281418e-01f, -8.15869048e-02f,
  -2.72649974e-01f, -3.31066847e-02f, 3.08697056e-02f, 7.65758529e-02f, -2.24742636e-01f, 3.86252522e-01f, -2.76677698e-01f, -2.02293202e-01f, -1.13007836e-01f, -7.91790932e-02f,
  -1.12888673e-02f, -1.69985667e-01f, 8.26414004e-02f, -7.72876143e-02f, -8.93834233e-02f, 2.10185051e-02f, -1.55367687e-01f, 5.18042333e-02f, -1.54503211e-01f, -1.31362051e-01f,
  5.49650669e-01f, -1.61194373e-02f, -6.64149821e-02f, 5.20411655e-02f, -8.43185093e-03f, -3.19218338e-02f
};

// L1_linear_B (Shape: 1 x 12)
const int L1_linear_B_rows = 1;
const int L1_linear_B_cols = 12;
const float L1_linear_B_data[] = {
  -1.73967436e-01f, -6.69231415e-02f, 1.03425607e-03f, 3.87281068e-02f, 1.10579915e-02f, -6.06547482e-02f, -1.67132337e-02f, -3.31049971e-02f, 6.91142166e-04f, -4.97384928e-03f,
  -3.88457812e-02f, -5.77337714e-03f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 12, 104
    );
    
    // Camada 1: L1_linear
    linear_forward_pgm(
        buffer1, x_out,
        L1_linear_W_data, L1_linear_B_data,
        128, 12
    );
    }
    