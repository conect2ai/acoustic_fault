/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 16 (x2)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 16;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    static inline float fan_activation(float x) { return x; }

    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 1 x 120)
const int L0_fan_Wp_rows = 1;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -6.84726119e-01f, 1.02755643e-01f, 3.32122296e-01f, -2.54025400e-01f, 1.01729102e-01f, 1.45367300e-02f, 1.71900436e-01f, -1.08966686e-01f, -1.37330487e-01f, 7.26189762e-02f,
  -1.92822725e-01f, 1.56860836e-02f, 7.86953866e-02f, 3.19017209e-02f, -3.05826720e-02f, 3.94007295e-01f, 3.41031790e-01f, 1.17561877e-01f, 4.97660413e-02f, -2.16930702e-01f,
  -4.23726290e-02f, -1.72719374e-01f, -2.83028662e-01f, -2.13074729e-01f, 7.99963996e-02f, 5.97205833e-02f, 2.57874906e-01f, -3.21080163e-02f, 3.01727466e-02f, 2.68268675e-01f,
  2.09197402e-01f, -8.85908529e-02f, 2.75699887e-02f, -1.09297507e-01f, 1.02517903e-01f, 3.45610306e-02f, 3.73847336e-02f, 2.19305456e-02f, -5.77786788e-02f, -2.51521617e-02f,
  4.02104147e-02f, -6.30498305e-02f, 7.01624751e-02f, 1.91718154e-02f, -1.71363056e-02f, -6.58540651e-02f, -3.53106409e-02f, -7.61817470e-02f, 1.32073660e-03f, 5.91576099e-02f,
  -5.72367944e-03f, -9.11128968e-02f, -9.44987033e-03f, -4.90586385e-02f, 8.43174234e-02f, -5.71734132e-03f, -1.08658500e-01f, -8.29005316e-02f, -1.56476930e-01f, -7.37342238e-02f,
  6.73958007e-03f, 7.30200112e-02f, -1.14559010e-02f, -5.57774566e-02f, 2.74944045e-02f, -2.02942509e-02f, 2.81227678e-02f, -1.38935940e-02f, -5.57318330e-02f, -5.25114499e-02f,
  -2.56000329e-02f, 1.79482307e-02f, -4.01770435e-02f, -2.27513295e-02f, -6.01798892e-02f, -6.90301228e-03f, -3.04907095e-02f, -5.19597717e-03f, -1.10601991e-01f, -6.54445216e-02f,
  -9.33121070e-02f, 3.03966124e-02f, -7.17843976e-03f, -2.42227949e-02f, -3.35767008e-02f, 1.67736113e-02f, 5.60530499e-02f, -5.77203184e-02f, -8.34759884e-03f, -1.13329031e-01f,
  6.07477874e-03f, -2.89855432e-02f, 1.42454073e-01f, 1.83344260e-02f, 1.06222004e-01f, -3.96509804e-02f, -5.07265851e-02f, -2.23213825e-02f, 5.03422767e-02f, -1.80425532e-02f,
  1.63680315e-02f, -7.75642600e-03f, 1.07727693e-02f, -5.41710220e-02f, -5.48727699e-02f, -1.28652200e-01f, -6.46659955e-02f, 1.00170977e-01f, 4.52538813e-03f, -4.55219448e-02f,
  -8.91012400e-02f, -7.17747360e-02f, 1.23412855e-01f, 3.20078433e-02f, 5.05849868e-02f, 1.51422024e-01f, 1.38387725e-01f, 8.19167718e-02f, 1.15752462e-02f, 6.06762767e-02f
};

// L0_fan_Wp_bar (Shape: 14 x 120)
const int L0_fan_Wp_bar_rows = 14;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  4.77256954e-01f, 6.14537537e-01f, 6.68718576e-01f, 3.63110274e-01f, 3.28412920e-01f, 3.80295604e-01f, 6.97087467e-01f, 4.37846869e-01f, -1.51539728e-01f, 1.98709473e-01f,
  1.89956978e-01f, -2.85900801e-01f, -6.87493533e-02f, -1.03124045e-02f, 3.40422511e-01f, 3.44654769e-01f, 1.97337911e-01f, 4.40508351e-02f, 1.62139218e-02f, 9.28605273e-02f,
  2.51044054e-02f, 2.36369088e-01f, 2.76208937e-01f, 1.24037139e-01f, 4.41461653e-02f, -1.25372007e-01f, 3.84772032e-01f, 4.21433955e-01f, 3.14498484e-01f, -3.16827111e-02f,
  4.20333259e-02f, 5.43377459e-01f, -4.53063667e-01f, -2.21326321e-01f, 5.42452224e-02f, -1.06813768e-02f, -1.55879203e-02f, -2.87760689e-04f, 6.85453042e-03f, 2.14550667e-03f,
  1.39188757e-02f, -2.74251737e-02f, 1.98826849e-01f, -1.78744793e-02f, 2.40222156e-01f, -1.15818679e-01f, -1.28445640e-01f, 2.52602220e-01f, 1.79041401e-01f, 6.12970628e-02f,
  -1.47706613e-01f, 1.46527871e-01f, 2.96516001e-01f, 7.72550032e-02f, 2.33977959e-01f, -8.96366388e-02f, 1.81294441e-01f, -3.67243327e-02f, 9.75567102e-02f, -1.23145491e-01f,
  5.91467991e-02f, 4.17128485e-03f, 1.43958516e-02f, -6.50222227e-02f, 7.01527745e-02f, -4.62607630e-02f, 5.57551645e-02f, 9.05572996e-02f, 1.49848580e-01f, 7.79978335e-02f,
  -1.07326536e-02f, -2.54675448e-02f, 6.07259460e-02f, -6.40118160e-05f, -1.83839396e-01f, 2.01102749e-01f, 1.91355124e-02f, 7.87727833e-02f, 1.70891732e-02f, -1.16025303e-02f,
  1.09974489e-01f, 8.55259970e-02f, 1.12356640e-01f, 1.54423267e-01f, 1.31681347e-02f, 1.71839502e-02f, 1.83986023e-01f, 2.48701237e-02f, 5.11201881e-02f, 3.10229901e-02f,
  -1.34820551e-01f, 3.39403480e-01f, -3.14689964e-01f, -1.24928333e-01f, 1.80906713e-01f, -1.76409289e-01f, -1.91261135e-02f, -1.02535129e-01f, -8.71002823e-02f, -1.03146754e-01f,
  3.65162715e-02f, -3.28483842e-02f, 1.37288496e-01f, 2.35781595e-02f, -1.46420926e-01f, -1.44247904e-01f, -2.93780863e-01f, -1.43543810e-01f, -5.51595632e-03f, -3.54348198e-02f,
  -5.56545295e-02f, -2.61242241e-01f, -2.53704458e-01f, -2.56851405e-01f, -5.08396626e-02f, -3.20205808e-01f, -1.62912965e-01f, -2.70059824e-01f, -1.11543633e-01f, -3.69428307e-01f,
  3.98728400e-01f, 8.49709380e-03f, -1.18565753e-01f, 4.18567896e-01f, 9.07394588e-02f, -5.33608556e-01f, -9.70667303e-01f, -4.54936773e-01f, 1.19993187e-01f, -1.79422811e-01f,
  -1.57338768e-01f, 2.20734417e-01f, 1.76587269e-01f, 1.03489878e-02f, -6.77975893e-01f, -5.52501380e-01f, -2.15760037e-01f, -1.38734564e-01f, -2.82995313e-01f, -3.38267356e-01f,
  9.75080803e-02f, 8.45790356e-02f, -3.80889624e-02f, -4.64436039e-02f, 5.61952829e-01f, 2.93539673e-01f, 1.02565072e-01f, 3.10073286e-01f, 1.99488550e-01f, 8.44471157e-01f,
  4.85612392e-01f, 2.77377784e-01f, -2.89564729e-01f, 2.51871377e-01f, 2.03033388e-01f, 2.93197408e-02f, -2.37378720e-02f, 2.20860496e-01f, -5.36872894e-02f, -1.48839474e-01f,
  2.69279242e-01f, 3.24537337e-01f, 2.19543621e-01f, 1.04548328e-01f, -1.72463730e-01f, -2.39474103e-01f, -6.07745210e-03f, 2.53949668e-02f, -1.01383500e-01f, 2.89234221e-02f,
  2.73294568e-01f, 1.64738730e-01f, -2.26242259e-01f, -3.16480279e-01f, -7.06771240e-02f, 1.89247191e-01f, -1.44098336e-02f, 2.56280720e-01f, -1.95344254e-01f, 2.45726153e-01f,
  -1.13708891e-01f, 9.46197808e-02f, 4.90361266e-02f, -1.34772882e-01f, -8.56178924e-02f, 1.20042386e-02f, -2.48138122e-02f, -6.56309873e-02f, 6.85869902e-03f, -7.78654218e-02f,
  -2.01822352e-02f, -4.88935113e-02f, -1.02573678e-01f, -3.47975194e-02f, 1.16536856e-01f, -1.81106087e-02f, 1.23621523e-02f, -9.98717323e-02f, -6.68361261e-02f, 1.11886844e-01f,
  5.83478063e-02f, -5.48559334e-03f, 4.70449105e-02f, -6.37550950e-02f, 1.96245492e-01f, 7.04255179e-02f, 1.65827021e-01f, 9.28824320e-02f, 3.22542414e-02f, 7.70658106e-02f,
  -1.60343885e-01f, -5.11687577e-01f, 4.34617512e-02f, -1.23229787e-01f, 5.39335096e-03f, 5.00478595e-02f, 1.45379975e-01f, -7.43445242e-03f, 2.58890122e-01f, -1.18003868e-01f,
  -6.88752308e-02f, -1.21478952e-01f, -1.01633845e-02f, -1.29870817e-01f, -1.09108701e-01f, 1.09230071e-01f, -8.00392702e-02f, -2.11101230e-02f, -2.11379871e-01f, 3.92452888e-02f,
  -1.25152707e-01f, -4.19140786e-01f, -4.29198563e-01f, -3.89907956e-01f, 3.96018513e-02f, -3.20841402e-01f, -2.26091072e-01f, 7.93783441e-02f, -3.99577528e-01f, -6.39689028e-01f,
  -3.98779571e-01f, -7.29224607e-02f, 2.15992093e-01f, -1.90861955e-01f, 2.59677976e-01f, -6.65066242e-02f, -6.02166712e-01f, -9.80765447e-02f, 2.10660830e-01f, 8.55877399e-02f,
  2.09799230e-01f, 6.52522743e-02f, -1.87706232e-01f, -3.97592962e-01f, -5.73538363e-01f, -5.14492869e-01f, -5.13964593e-01f, -5.28732002e-01f, -4.04807299e-01f, -1.43858388e-01f,
  -7.27986842e-02f, -2.16929868e-01f, -2.83423930e-01f, -1.28917828e-01f, -1.68988064e-01f, -3.45891297e-01f, -1.80499017e-01f, -2.72894740e-01f, -2.69149154e-01f, -4.02650118e-01f,
  -1.98594853e-01f, -1.13236316e-01f, 2.22188324e-01f, 2.23982230e-01f, 1.53041139e-01f, 6.72382712e-02f, -5.34147434e-02f, 1.27146095e-01f, 6.37599081e-02f, 6.77260160e-02f,
  1.03563733e-01f, 1.46703333e-01f, -8.19775164e-02f, 1.50578439e-01f, -7.06961751e-02f, -7.96924718e-03f, 1.85365483e-01f, -2.57492866e-02f, -3.71990167e-02f, 3.25602144e-01f,
  -6.32535517e-02f, -1.24558531e-01f, -5.34107149e-01f, -3.44195925e-02f, 6.50859922e-02f, -1.67901069e-01f, 3.98281366e-02f, -3.07525724e-01f, -4.02472258e-01f, -6.06868923e-01f,
  7.79463351e-02f, 3.07153642e-01f, 3.20483893e-01f, 9.78685766e-02f, -4.18230407e-02f, -2.33133137e-02f, -2.21306920e-01f, -1.52187183e-01f, -2.32821070e-02f, -2.97538247e-02f,
  -9.83775966e-03f, 1.65702298e-01f, 1.18157886e-01f, -2.98901320e-01f, -1.32511199e-01f, 6.37324015e-03f, -9.45202634e-02f, -1.98340476e-01f, -2.92193383e-01f, -6.87024295e-02f,
  -2.98387229e-01f, -1.33496031e-01f, -5.86298015e-03f, -1.40117735e-01f, 6.22284934e-02f, 6.87873960e-02f, 1.19745225e-01f, -1.80662021e-01f, -3.01275980e-02f, -6.70677191e-03f,
  -5.24716079e-01f, 5.44644967e-02f, -7.13442862e-02f, -2.85827685e-02f, 2.73797344e-02f, 1.63426474e-01f, -9.75421816e-03f, 3.73928063e-02f, 7.86522999e-02f, 1.33025842e-02f,
  6.34113327e-02f, -1.15026034e-01f, -4.00569141e-02f, -4.01887111e-02f, 1.23335302e-01f, -1.35939300e-01f, -2.60504037e-02f, -3.06747645e-01f, -1.78941578e-01f, 2.03378573e-01f,
  2.07441449e-02f, -5.99088073e-01f, -7.47200131e-01f, -3.86506081e-01f, -5.11695087e-01f, -6.94180071e-01f, -5.26852608e-01f, -4.34192240e-01f, -5.72120786e-01f, -1.00246930e+00f,
  -4.32579845e-01f, -6.40039563e-01f, 3.83055866e-01f, -1.71422526e-01f, -4.01851863e-01f, -5.06129086e-01f, -6.53221667e-01f, -8.60660709e-03f, -1.12188853e-01f, -2.27269351e-01f,
  -3.30109745e-01f, 2.14752369e-02f, 1.94025889e-01f, 3.35621059e-01f, 3.72007847e-01f, 2.32168570e-01f, 3.86926621e-01f, 7.17185915e-01f, 3.89434934e-01f, -1.94232184e-02f,
  -6.26490042e-02f, 9.94663537e-02f, 3.91598135e-01f, 4.20735389e-01f, 5.39816394e-02f, -2.89770551e-02f, 2.60610849e-01f, -1.88549962e-02f, -7.44525641e-02f, 2.93857425e-01f,
  1.92619227e-02f, -1.72443166e-01f, 1.77806482e-01f, -1.30230814e-01f, -2.47556227e-03f, -9.60662439e-02f, -5.57011105e-02f, 3.10576826e-01f, 3.21964659e-02f, 1.15178913e-01f,
  -1.12973578e-01f, -2.18982138e-02f, -4.12118323e-02f, 5.58620170e-02f, -7.75081366e-02f, 2.81961579e-02f, 2.43884116e-01f, 5.50376952e-01f, 1.79517344e-01f, -4.01548706e-02f,
  -1.00676410e-01f, -2.12295175e-01f, -1.48338541e-01f, -1.26951173e-01f, 1.27599612e-01f, 9.59963053e-02f, -9.90780070e-02f, 3.64295579e-02f, 6.04466908e-02f, 4.96853841e-03f,
  1.91599816e-01f, 2.99778245e-02f, 2.48856805e-02f, -2.84760743e-02f, 1.48762062e-01f, -5.41863777e-02f, 2.56551176e-01f, -6.54173940e-02f, 1.07543543e-02f, 9.34787318e-02f,
  2.07341522e-01f, -8.19923878e-02f, 1.80848941e-01f, 3.29034030e-02f, 2.40662411e-01f, -1.40792727e-01f, 3.26958485e-02f, 1.63793892e-01f, 3.36272687e-01f, 7.48089701e-02f,
  -7.71672204e-02f, 8.19378197e-02f, -2.72890627e-02f, 1.66968539e-01f, 2.84479130e-02f, 7.89545551e-02f, -8.57706442e-02f, -2.20986336e-01f, -5.27422614e-02f, -6.33263811e-02f,
  -4.37992543e-01f, 5.53463735e-02f, -6.76029222e-03f, 2.01565921e-01f, -1.38228074e-01f, 2.00107470e-01f, -2.79330611e-02f, -5.28672040e-02f, -2.57959038e-01f, -8.16169456e-02f,
  -2.68100798e-01f, 2.49368930e-03f, -7.48853832e-02f, 6.85469657e-02f, -3.73178534e-02f, -1.52597010e-01f, -5.42790405e-02f, -1.02111734e-01f, -1.34969121e-02f, -1.93136603e-01f,
  -3.37841734e-02f, -1.94371492e-01f, -4.52443331e-01f, -3.42935085e-01f, -1.08009532e-01f, -2.73391485e-01f, -1.52100995e-01f, -2.76310056e-01f, -3.15596640e-01f, -5.56872547e-01f,
  -5.56631804e-01f, 1.52087271e-01f, 2.04868689e-01f, 2.24565677e-02f, -2.45300040e-01f, -1.52497455e-01f, -1.48664877e-01f, -1.35431573e-01f, 1.34272734e-02f, 1.19942702e-01f,
  3.16184223e-01f, 5.56013942e-01f, 3.86949837e-01f, 3.69892240e-01f, 1.58325821e-01f, 2.89987843e-03f, -8.28712359e-02f, 1.16581216e-01f, 1.19425595e-01f, 6.42951485e-03f,
  1.26169115e-01f, -1.00507408e-01f, -8.02040100e-02f, 8.63537192e-02f, 1.98432297e-01f, 2.78507710e-01f, 3.88967022e-02f, 1.47555731e-02f, 2.43980065e-01f, 3.07622075e-01f,
  1.16810858e+00f, -2.37249751e-02f, 2.37608552e-01f, 1.67704478e-01f, -4.84665632e-02f, 3.84791233e-02f, 1.46767601e-01f, 1.52180661e-02f, -1.35325298e-01f, 3.74846049e-02f,
  4.02877964e-02f, -5.18571772e-02f, -1.11463837e-01f, -1.13901831e-01f, -2.19095677e-01f, -2.02998938e-03f, -1.82918102e-01f, -1.42369065e-02f, 1.15213782e-01f, 2.51315802e-01f,
  1.43850580e-01f, 1.56383723e-01f, 1.12744257e-01f, 2.87497062e-02f, -1.11829951e-01f, 1.34318888e-01f, 5.06322384e-02f, -2.81551629e-02f, -6.33933246e-02f, 9.63135250e-03f,
  1.74839929e-01f, 1.58302456e-01f, -1.89271662e-02f, -1.63246140e-01f, -1.31681919e-01f, -6.48102388e-02f, -1.16857015e-01f, -9.28614587e-02f, -1.63193375e-01f, -2.06917629e-01f,
  -1.40896186e-01f, 7.84515217e-02f, 1.13475677e-02f, -1.45319849e-01f, 1.37164682e-01f, 1.05301835e-01f, 1.13151610e-01f, 1.19795248e-01f, -4.79004644e-02f, -2.75049042e-02f,
  -1.76302850e-01f, 2.82146819e-02f, -4.10116576e-02f, -7.82115534e-02f, 5.58616482e-02f, 1.44803062e-01f, 4.88094911e-02f, 9.93450209e-02f, 5.69806285e-02f, 7.50224292e-02f,
  6.06746137e-01f, -8.36541429e-02f, 2.11071089e-01f, 1.03592053e-01f, -6.53204396e-02f, -9.52141359e-02f, 1.77341118e-01f, -4.08357047e-02f, 5.51843010e-02f, 1.22879215e-01f,
  8.49741548e-02f, 3.79750691e-02f, -8.86028856e-02f, -1.96852125e-02f, -2.39012450e-01f, -9.66229886e-02f, 1.05497338e-01f, 3.89211103e-02f, 1.33239865e-01f, 1.85150817e-01f,
  1.03059150e-02f, -1.21941734e-02f, 2.65423506e-01f, -2.97867116e-02f, -1.02873497e-01f, 8.08457434e-02f, 1.17206611e-01f, 2.01054644e-02f, 1.07227750e-02f, -1.05075471e-01f,
  9.49904382e-01f, -6.71347439e-01f, -7.68807828e-01f, 6.14475422e-02f, -1.99534863e-01f, -2.08371729e-01f, -4.79405165e-01f, 2.86529865e-02f, 6.32700920e-02f, -5.19054115e-01f,
  1.55248076e-01f, 5.99762917e-01f, 2.68448234e-01f, 4.59403813e-01f, 4.81585532e-01f, -7.04925537e-01f, -5.73731244e-01f, 2.07386091e-01f, 6.28521562e-01f, 3.59944940e-01f,
  1.10993594e-01f, -9.79565457e-03f, 4.70111132e-01f, 1.97267666e-01f, -4.07065958e-01f, 1.68129504e-01f, -6.36923909e-01f, -2.31623545e-01f, -1.33227140e-01f, -6.98283434e-01f,
  -2.40455166e-01f, -2.12095737e-01f, 2.96639234e-01f, 1.54642731e-01f, -2.80354798e-01f, 2.02232957e-01f, 9.80787128e-02f, -1.25711486e-01f, -1.63580757e-02f, -4.59686220e-02f,
  3.45201008e-02f, -2.85849697e-03f, 8.10345188e-02f, 1.18380062e-01f, -9.48417634e-02f, 5.91509864e-02f, -5.36946841e-02f, 1.44366220e-01f, 4.43062074e-02f, -2.14921683e-01f,
  -2.10609794e-01f, 7.60813057e-03f, -1.89922214e-01f, -5.77124767e-02f, 7.65619650e-02f, 1.31980941e-01f, -1.87277436e-01f, 1.19422033e-01f, 5.75457104e-02f, -5.02371848e-01f,
  -5.87006100e-02f, 5.51467296e-03f, -3.53281200e-02f, 4.89770584e-02f, 3.82284038e-02f, -2.96247359e-02f, -5.00590242e-02f, -2.35471446e-02f, 4.28432040e-02f, -8.54211394e-03f,
  -5.14823683e-02f, -1.81932617e-02f, 2.13669837e-02f, -1.20921277e-01f, -8.69661346e-02f, -6.82775304e-02f, 4.32047382e-04f, -6.15314655e-02f, 1.06981575e-01f, 1.17483675e-01f,
  8.81764591e-02f, -2.32009087e-02f, -9.34504792e-02f, 1.20637015e-01f, 8.28951877e-03f, 9.09020007e-03f, 1.03335902e-01f, 3.73260006e-02f, 5.83666153e-02f, -7.16264471e-02f,
  -8.63265246e-02f, 2.00296849e-01f, -6.26997948e-02f, 1.46384522e-01f, -7.74014965e-02f, 5.39533049e-02f, -1.49941936e-01f, 1.30218878e-01f, 5.45154139e-02f, -1.60639286e-02f,
  3.71960737e-02f, 1.02277726e-01f, -1.64495796e-01f, -4.65200730e-02f, 5.29553788e-03f, -5.79347573e-02f, -1.07872896e-02f, 1.18425610e-02f, 1.05221264e-01f, -1.14711262e-01f,
  -1.47752672e-01f, -9.24566984e-02f, 3.52889001e-02f, 3.29976752e-02f, 8.02353304e-03f, 1.38591215e-01f, -2.55573243e-01f, -1.75066695e-01f, 1.63438618e-01f, -4.77154046e-01f,
  2.32052818e-01f, -6.84811771e-01f, 3.95763725e-01f, 2.85472512e-01f, 4.13982481e-01f, 4.93959159e-01f, 3.82593900e-01f, 2.37974271e-01f, 2.80187100e-01f, 4.15863730e-02f,
  -3.61700267e-01f, -1.54676780e-01f, -9.40299854e-02f, -2.06094235e-01f, -7.13533089e-02f, 2.86446929e-01f, 3.28682393e-01f, 3.56887996e-01f, 5.48027694e-01f, 2.96462148e-01f,
  1.33148739e-02f, 8.33451282e-03f, 1.66428745e-01f, -5.13990549e-03f, -1.02728128e-01f, 1.19358875e-01f, 1.13787003e-01f, -6.29797280e-02f, -1.38732210e-01f, -4.22508605e-02f,
  1.24218971e-01f, -5.38544714e-01f, 2.80705661e-01f, -1.86809391e-01f, -1.31879106e-01f, -7.50516355e-02f, 3.23016569e-02f, -2.74064448e-02f, 1.00418869e-02f, 2.33232714e-02f,
  -9.10364166e-02f, -1.59611925e-02f, -1.90763965e-01f, -1.31225601e-01f, 4.71368171e-02f, -7.04734121e-03f, -2.34598622e-01f, -8.42171833e-02f, -3.12791280e-02f, -2.40125924e-01f,
  -3.50442916e-01f, -6.25081211e-02f, 8.59989077e-02f, -5.41343689e-02f, -1.12396047e-01f, 2.47795749e-02f, -2.34417617e-01f, -2.33783811e-01f, -9.39098224e-02f, -5.81407771e-02f,
  1.08814396e-01f, 1.08689874e-01f, -1.47759005e-01f, 3.95427831e-02f, 1.89146977e-02f, 1.24285616e-01f, 2.85733581e-01f, 1.48404524e-01f, 1.46870300e-01f, 4.23325263e-02f,
  7.95873478e-02f, 7.51162693e-02f, 1.25759291e-02f, 2.19297446e-02f, -2.43525535e-01f, 2.31079590e-02f, 3.44188847e-02f, -1.16894521e-01f, -1.31272331e-01f, -1.25350088e-01f,
  -1.29530728e-01f, 1.81241482e-01f, 9.66503769e-02f, -1.12688884e-01f, -2.60025144e-01f, -3.75987664e-02f, 8.96109715e-02f, -9.17086601e-02f, 1.47473201e-01f, 1.95621043e-01f,
  8.55141208e-02f, -2.02968121e-01f, 1.91585228e-01f, -1.24250399e-02f, 6.93102330e-02f, -1.30150378e-01f, -4.49451059e-02f, -4.72783670e-02f, -4.55385819e-02f, 1.08534604e-01f,
  3.52102183e-02f, -3.62021625e-02f, -2.24856257e-01f, -7.33307824e-02f, 2.00988933e-01f, -3.56405647e-03f, -1.45394146e-01f, 7.62170702e-02f, 1.01967610e-01f, -7.11825490e-02f,
  -5.21832705e-02f, 3.24207127e-01f, 4.70027268e-01f, 3.29042494e-01f, 7.76946247e-02f, 3.25397044e-01f, 2.82262146e-01f, 2.63306618e-01f, 2.90969014e-01f, 3.92138004e-01f,
  -6.59965813e-01f, 2.35592231e-01f, 3.05709153e-01f, -8.46862614e-01f, 5.46557792e-02f, 5.90819836e-01f, 6.69857740e-01f, 1.68819889e-01f, -4.48316067e-01f, 8.61276239e-02f,
  1.02289245e-01f, -4.71407354e-01f, -3.40590745e-01f, -4.92069274e-02f, 4.40951228e-01f, 3.22245896e-01f, -1.25426203e-01f, -1.04775563e-01f, 1.84318185e-01f, 3.86797428e-01f,
  8.04077685e-02f, -2.85892725e-01f, -2.46788010e-01f, -2.34901592e-01f, -4.28588033e-01f, -5.44667423e-01f, -2.82085299e-01f, -1.05248382e-02f, 4.13426727e-01f, -4.30788994e-01f,
  3.76511633e-01f, -7.46040046e-02f, 2.79299654e-02f, -1.74789712e-01f, 5.80524430e-02f, -7.10928887e-02f, -3.66817974e-02f, -2.88381457e-01f, -3.29771265e-02f, -8.23437721e-02f,
  -2.62514174e-01f, 9.17184353e-02f, -1.42340049e-01f, 3.88773973e-03f, -1.18615024e-01f, -1.42321857e-02f, -3.20798121e-02f, -1.20586352e-02f, -3.80102396e-02f, 3.01256806e-01f,
  1.72661886e-01f, 2.68530846e-01f, 5.04822023e-02f, 2.79441386e-01f, 2.39419580e-01f, 1.93513557e-02f, 3.29156131e-01f, 7.72749260e-02f, 2.65588731e-01f, -2.28928268e-01f,
  -1.16431993e-03f, -6.35478646e-02f, 6.88817725e-02f, -5.08805737e-02f, 7.10144220e-03f, 2.62093246e-02f, -9.07585770e-02f, 9.68196839e-02f, 1.04672603e-01f, -8.66276249e-02f,
  1.17613608e-02f, 9.96464640e-02f, -4.69786674e-02f, -1.18861251e-01f, -1.06228925e-02f, -8.45752843e-03f, 1.19111165e-01f, 1.35578141e-02f, 4.70830649e-02f, -1.05751254e-01f,
  2.84154173e-02f, 1.68517277e-01f, -1.48321703e-01f, 1.19820787e-02f, 2.02544168e-01f, -5.37195019e-02f, 8.84169415e-02f, 1.89440042e-01f, -3.15020271e-02f, 5.78987086e-03f,
  -4.29118782e-01f, 3.84113252e-01f, -4.14991945e-01f, -1.67267304e-02f, -1.35662541e-01f, -8.31436738e-02f, -1.80684343e-01f, 6.70715347e-02f, -1.29120439e-01f, 5.74601479e-02f,
  1.32844329e-01f, -5.82380109e-02f, -1.29428029e-01f, 5.50228767e-02f, 1.84248050e-03f, 7.91081134e-03f, 5.42695820e-03f, -6.82857409e-02f, 7.28126392e-02f, -1.66181445e-01f,
  3.78484279e-02f, 1.11811794e-02f, -1.66611299e-01f, -1.90377355e-01f, -6.27312064e-02f, -2.01239973e-01f, -5.10074049e-02f, 5.21253534e-02f, 1.16016254e-01f, -3.10985029e-01f,
  -2.30826527e-01f, 6.18222475e-01f, -6.73139691e-01f, -6.19925916e-01f, -1.07081676e+00f, -1.03954339e+00f, -4.81616288e-01f, -4.19616401e-01f, -2.72914320e-01f, -4.99225184e-02f,
  6.31120801e-02f, 3.57521564e-01f, 5.24819672e-01f, -6.23278739e-03f, -3.02495450e-01f, -5.57074904e-01f, -7.06249893e-01f, -6.89799607e-01f, -8.20513844e-01f, -8.10784280e-01f,
  -3.61011565e-01f, -2.58121520e-01f, -2.88045466e-01f, -2.15027004e-01f, -1.02812827e-01f, -8.38441029e-03f, -1.54487446e-01f, -3.72542113e-01f, -2.62852490e-01f, -3.66736174e-01f,
  2.56088972e-01f, -7.14805603e-01f, -4.53220695e-01f, 6.33099824e-02f, -8.49888623e-02f, -4.51394171e-02f, -1.42520800e-01f, -3.38972181e-01f, 5.22027761e-02f, -9.06409100e-02f,
  -4.17866647e-01f, -2.31431872e-01f, -1.54564843e-01f, -2.62511522e-01f, -4.31175888e-01f, -3.99013072e-01f, -4.06557649e-01f, -4.67751563e-01f, -1.95849195e-01f, -4.54858281e-02f,
  -2.36948594e-01f, -4.25706029e-01f, -7.48228878e-02f, 2.66115684e-02f, -6.02856129e-02f, -1.80066422e-01f, 1.40582845e-01f, -1.33185014e-01f, -1.26591623e-01f, 6.47565961e-01f,
  1.32321683e-03f, 1.05857998e-01f, 3.68442833e-02f, 1.18050613e-01f, 1.53682441e-01f, 1.16651371e-01f, 1.96191877e-01f, 5.34183085e-02f, -1.51059628e-02f, 3.22456986e-01f,
  1.90525904e-01f, 1.56108797e-01f, 6.83873817e-02f, 2.20268875e-01f, -2.48533990e-02f, -1.39725462e-01f, -8.60249922e-02f, 1.51148662e-01f, -1.55880243e-01f, -5.00494428e-02f,
  -6.51075691e-03f, -1.73299491e-01f, -3.76719423e-02f, 1.24765277e-01f, -3.02507073e-01f, -1.66738704e-01f, 4.90038879e-02f, 1.36138320e-01f, 1.29267396e-02f, -3.41983825e-01f,
  1.08390784e+00f, -4.13383096e-01f, 1.71968654e-01f, 6.32370189e-02f, -1.28490537e-01f, -3.87226231e-02f, 2.60158211e-01f, 3.32533419e-02f, -4.10309695e-02f, 1.50757954e-01f,
  -1.75431505e-01f, 2.22001031e-01f, 3.26440483e-02f, 7.40123764e-02f, -2.32886210e-01f, -1.96043342e-01f, 1.34048671e-01f, -4.28114623e-01f, -1.24276444e-01f, 1.47352621e-01f,
  5.62349856e-02f, -5.27735576e-02f, 4.21138346e-01f, 5.40628254e-01f, 6.13664091e-02f, -5.83507642e-02f, 3.34711492e-01f, 1.54641315e-01f, 1.09463364e-01f, 8.93640697e-01f,
  -2.79798120e-01f, -8.65718164e-03f, 9.02481854e-01f, -4.47306149e-02f, -1.60309941e-01f, -1.47432357e-01f, -3.54524642e-01f, 7.50905871e-02f, -1.80337876e-01f, -1.18984349e-01f,
  -2.65381664e-01f, -3.12393576e-01f, -6.44655107e-03f, -1.42360792e-01f, 1.50882080e-01f, 1.59682199e-01f, 4.27192181e-01f, 4.74223435e-01f, 8.28079134e-02f, -4.64925021e-01f,
  -5.03203213e-01f, 5.61469682e-02f, 4.00307268e-01f, 1.82014152e-01f, -1.55262068e-01f, -2.53066063e-01f, 3.91721696e-01f, 1.29112929e-01f, -1.18869394e-01f, -6.92422548e-03f,
  -1.17165364e-01f, 2.51418263e-01f, 1.85942128e-01f, -1.01787910e-01f, 2.09308863e-01f, -1.41865417e-01f, -2.07110032e-01f, 4.06192541e-01f, -9.65650678e-02f, 6.26304895e-02f,
  -8.11930597e-02f, 5.11111468e-02f, -1.75082073e-01f, -9.48275328e-02f, -1.65479511e-01f, -1.93596601e-01f, 1.46811575e-01f, 2.48395026e-01f, 1.24279082e-01f, -1.72944069e-01f,
  -4.86765265e-01f, -4.56104219e-01f, 1.13815121e-01f, 1.65245727e-01f, 3.05587292e-01f, 2.18867928e-01f, -9.77422968e-02f, 2.36454915e-04f, 3.18400174e-01f, -2.92293608e-01f,
  -2.66816653e-02f, 4.37869914e-02f, 1.64385378e-01f, 7.25699514e-02f, -1.04478613e-01f, -3.48179340e-02f, 1.30097330e-01f, -1.72890410e-01f, -8.79846066e-02f, 9.62687004e-03f,
  -2.40012724e-02f, -9.03835073e-02f, 4.37072441e-02f, 4.98892069e-02f, -5.16119711e-02f, 1.51752383e-01f, -8.64419118e-02f, -7.46977562e-03f, 1.86506838e-01f, 1.16432101e-01f,
  -2.78677065e-02f, 2.18933988e-02f, 6.67686909e-02f, -6.51259646e-02f, 3.24001759e-02f, 3.23591352e-01f, -5.58883734e-02f, 3.63436826e-02f, 9.07477140e-02f, -9.05379951e-02f,
  -4.14019257e-01f, 5.25780857e-01f, -1.98524073e-01f, -2.73042675e-02f, -1.59306675e-01f, 2.35823635e-03f, 2.31064171e-01f, 3.69219594e-02f, -5.45565300e-02f, -1.21043943e-01f,
  -2.94514280e-02f, 4.61025238e-02f, 5.18402718e-02f, -1.35315526e-02f, -2.12661549e-01f, -7.63315335e-02f, -1.88448444e-01f, -3.13380092e-01f, -8.54563639e-02f, -9.86584648e-02f,
  -6.77248985e-02f, -3.47956747e-01f, -7.13721991e-01f, -2.62052983e-01f, -3.88874978e-01f, -2.94052422e-01f, -3.06801707e-01f, -5.31789362e-01f, -3.74912947e-01f, -8.62192571e-01f,
  -1.06836700e+00f, 4.34215188e-01f, -8.25668037e-01f, -1.43050686e-01f, 3.27065259e-01f, -1.43276863e-02f, 1.30973175e-01f, 2.76299585e-02f, 9.59997922e-02f, 2.19067320e-01f,
  7.33566061e-02f, 1.42372310e-01f, 1.58480749e-01f, 2.09082246e-01f, 1.61791727e-01f, 4.48649913e-01f, 4.38384652e-01f, -3.34222913e-01f, -5.33711314e-01f, 1.32131875e-02f,
  6.48904622e-01f, -3.35128829e-02f, -6.56032503e-01f, -1.79262131e-01f, 1.17126055e-01f, 3.60911936e-02f, 1.11609558e-03f, -4.08378690e-02f, 2.67968506e-01f, 3.56057614e-01f,
  -6.88454449e-01f, -5.62065303e-01f, 8.12273696e-02f, 5.45528606e-02f, -2.72982061e-01f, -3.11063826e-01f, -4.52518016e-02f, -1.89852402e-01f, -8.50777049e-03f, -1.30633175e-01f,
  3.11037265e-02f, -1.54213116e-01f, 3.16684544e-02f, -9.44859460e-02f, -2.66238987e-01f, -3.14339131e-01f, -2.45351329e-01f, -3.63091379e-01f, -4.50065881e-01f, -4.56971377e-01f,
  5.53384602e-01f, 2.52058655e-02f, -4.82713789e-01f, -1.47833422e-01f, -9.33688432e-02f, -1.73875809e-01f, -3.02497506e-01f, -4.04789269e-01f, -5.55795014e-01f, -3.13010365e-01f,
  -3.57065611e-02f, -6.87897205e-02f, 1.19934313e-01f, 1.36107326e-01f, 1.08658642e-01f, 7.08810985e-02f, 2.30441332e-01f, 8.38015899e-02f, -5.52009307e-02f, -5.85507378e-02f,
  7.90588111e-02f, -1.84867740e-01f, -1.60800755e-01f, -6.14486774e-03f, -7.54406303e-02f, 1.95459239e-02f, -1.02441140e-01f, 2.76779588e-02f, 4.16242965e-02f, -8.29111040e-03f,
  -7.45930197e-03f, -1.13770723e-01f, -5.46742342e-02f, 7.65924752e-02f, 7.28027150e-02f, 5.16753756e-02f, -1.02729192e-02f, -6.80053383e-02f, -1.64311841e-01f, -1.36074588e-01f,
  6.78643361e-02f, 6.98270798e-02f, 2.08456628e-02f, 1.44338205e-01f, -6.04177825e-02f, -1.03381881e-02f, 2.43668452e-01f, 1.04392938e-01f, 1.74418259e-02f, -2.88517356e-01f,
  -2.50278443e-01f, -2.56051928e-01f, -3.86278257e-02f, 3.49952839e-02f, -1.97565868e-01f, -1.14630491e-01f, 4.00465637e-01f, 6.96373954e-02f, 2.26810083e-01f, -1.29345834e-01f,
  1.67976603e-01f, 1.12685494e-01f, -7.99054205e-02f, -2.48248521e-02f, -4.08284105e-02f, 2.70547550e-02f, -1.21569872e-01f, -6.16788082e-02f, -2.12889835e-01f, -4.30503301e-02f,
  6.50762737e-01f, 2.85306334e-01f, 2.95605302e-01f, 5.60378850e-01f, 2.62300462e-01f, -1.28428146e-01f, -3.26914340e-01f, -2.38518149e-01f, 3.25865559e-02f, 1.82001173e-01f,
  1.62960827e-01f, 2.91806549e-01f, 1.65483713e-01f, 2.70618498e-01f, 8.67264643e-02f, 2.40639430e-02f, 2.85300672e-01f, 2.64157861e-01f, 1.53568238e-01f, 2.77719378e-01f,
  4.39132869e-01f, 1.74211368e-01f, 1.44284770e-01f, 1.02913029e-01f, 2.41578788e-01f, 2.22840205e-01f, -1.13014147e-01f, 1.52139917e-01f, 1.95934281e-01f, 5.85003853e-01f,
  3.72349948e-01f, 8.74655545e-02f, -1.06691249e-01f, -4.01625857e-02f, 4.54996079e-02f, -8.08791295e-02f, -9.18013826e-02f, -6.43205196e-02f, -6.32316768e-02f, -3.34486589e-02f,
  -6.10476127e-03f, 3.89820011e-03f, -2.25214884e-02f, -7.99380541e-02f, -6.00652434e-02f, -2.08088487e-01f, -9.09138378e-03f, 3.27973217e-02f, -2.63699275e-02f, 8.11115354e-02f,
  4.65554774e-01f, 1.95882365e-01f, -3.34352195e-01f, -2.49422088e-01f, 1.21212397e-02f, 2.60548294e-03f, -2.39060253e-01f, 1.93563476e-02f, -2.13296637e-01f, 1.28669113e-01f,
  3.24417800e-02f, 1.61912441e-01f, 1.26568317e-01f, 1.96594179e-01f, 1.33417338e-01f, -1.33181950e-02f, -4.15994115e-02f, -8.46186653e-02f, 1.09650105e-01f, 7.32142702e-02f,
  -1.33659756e-02f, 3.82811539e-02f, -4.25146334e-02f, 1.56848788e-01f, 1.48965701e-01f, -2.83359224e-03f, 1.91205107e-02f, 6.65175244e-02f, -6.61868323e-03f, -1.52465105e-01f,
  9.25413072e-02f, -5.68747856e-02f, -2.79729124e-02f, -5.35026677e-02f, -7.51928613e-02f, 1.06014803e-01f, 1.31412774e-01f, -9.06519443e-02f, 1.29268672e-02f, 8.00261572e-02f,
  -6.33563459e-01f, -1.35019898e-01f, 2.50651121e-01f, -1.54706895e-01f, -9.72636566e-02f, -1.58354670e-01f, 2.45270699e-01f, 1.62742008e-02f, -3.18434252e-03f, -4.13984247e-03f,
  -7.85279423e-02f, 6.71027675e-02f, -1.66195095e-01f, -8.81594792e-02f, -1.31037682e-01f, -1.10014901e-01f, -1.79896802e-02f, 7.54364952e-03f, -1.36671603e-01f, 1.05406575e-01f,
  6.02165284e-03f, -2.67387837e-01f, -3.80272418e-01f, -2.16118515e-01f, -8.97336900e-02f, -2.50814795e-01f, -3.51927549e-01f, -3.20712864e-01f, -5.22122860e-01f, -3.89154881e-01f,
  1.14991987e+00f, -4.48327094e-01f, 4.03436422e-01f, 2.42620185e-01f, -8.98876786e-02f, 7.99739659e-02f, -2.62474149e-01f, -1.51123628e-01f, 5.93167879e-02f, 1.90574434e-02f,
  -2.57072449e-02f, 1.50562406e-01f, 1.86669588e-01f, 1.37319684e-01f, 1.20167427e-01f, -2.05616891e-01f, -8.53071362e-02f, 3.43935579e-01f, 4.14775193e-01f, 7.58628324e-02f,
  -2.46512786e-01f, -7.33252689e-02f, 1.53818533e-01f, -1.74063945e-03f, -2.93113649e-01f, 2.32746713e-02f, -1.09193236e-01f, -1.54637724e-01f, -9.28273574e-02f, -3.15847754e-01f,
  1.03968583e-01f, 2.34433830e-01f, 1.75736070e-01f, -5.05564101e-02f, 8.60816166e-02f, -7.33098667e-03f, 1.65463060e-01f, -1.24019742e-01f, -1.52085200e-01f, -2.58899301e-01f,
  3.06751616e-02f, 4.98404540e-02f, 4.98850606e-02f, 1.12340497e-02f, -4.30548340e-02f, 5.02731651e-02f, -6.52983114e-02f, 5.55469766e-02f, 6.00930629e-03f, -5.51732630e-02f,
  -1.99544445e-01f, 1.95955127e-01f, 1.39828861e-01f, -1.68552250e-02f, 1.60367072e-01f, 1.29163802e-01f, 4.55811359e-02f, 1.12137109e-01f, 1.54239595e-01f, 5.06021865e-02f,
  -1.73928037e-01f, 4.62956131e-02f, 2.85495937e-01f, 4.02232111e-02f, 1.28530932e-03f, 8.90469104e-02f, -1.71161238e-02f, -6.96873069e-02f, 5.94297610e-02f, 6.17116168e-02f,
  -1.30338132e-01f, 1.67834312e-01f, 1.57308415e-01f, 3.26145180e-02f, 8.56425390e-02f, 6.91271713e-03f, -4.96888570e-02f, 1.87506285e-02f, -2.53902506e-02f, -1.82190403e-01f,
  7.04230368e-02f, 1.47811184e-02f, 3.68659869e-02f, -2.80430708e-02f, -5.93146263e-03f, 1.24123201e-01f, 1.36893749e-01f, -2.69780103e-02f, -1.18188746e-02f, -2.17870682e-01f,
  -3.25419068e-01f, 4.67309624e-01f, -7.70674348e-02f, -1.25648379e-01f, 1.67421214e-02f, -9.23999548e-02f, 2.03240275e-01f, -5.86838834e-02f, -2.36399934e-01f, -1.13959387e-01f,
  -1.04729742e-01f, 3.68645303e-02f, -2.69228350e-02f, 4.31424640e-02f, -1.58044118e-02f, 1.54969752e-01f, 6.82545006e-02f, 3.54476981e-02f, -7.63345361e-02f, -2.01621830e-01f,
  -2.63323814e-01f, 1.03829622e-01f, 1.33310273e-01f, 8.10649917e-02f, 1.81886762e-01f, 2.06632406e-01f, 1.10704385e-01f, 3.23552601e-02f, 3.04032415e-01f, -4.12251167e-02f,
  9.50781822e-01f, 2.95189261e-01f, 7.74926767e-02f, 2.32085753e-02f, -7.43670821e-01f, -4.27075118e-01f, -5.19942790e-02f, 9.34754834e-02f, 3.48599739e-02f, 6.06008470e-02f,
  -4.14675623e-01f, -4.87744272e-01f, -2.80824810e-01f, -1.78941205e-01f, 1.93617061e-01f, 2.62582242e-01f, 1.69829935e-01f, 3.87053490e-01f, 2.17189610e-01f, -6.74861595e-02f,
  9.85504477e-04f, 2.51703382e-01f, 3.25354099e-01f, 2.17829213e-01f, 1.70078829e-01f, -2.44692296e-01f, -7.80617297e-02f, -2.89613098e-01f, -1.55586213e-01f, 3.76587957e-01f,
  1.69608220e-01f, 2.17128620e-01f, -3.29431623e-01f, -9.26970392e-02f, -1.54146865e-01f, 3.56563777e-01f, 1.57573551e-01f, -1.69245489e-02f, -1.62426472e-01f, 6.40517026e-02f,
  -2.79230118e-01f, -1.41928762e-01f, -8.77163932e-02f, -5.75109646e-02f, -3.98245119e-02f, 7.71492645e-02f, 9.93254781e-02f, 3.61743867e-01f, 2.25534618e-01f, 6.42024279e-02f,
  -3.71651389e-02f, -1.91414088e-01f, -1.97945386e-01f, -2.88547933e-01f, 2.57084928e-02f, -3.31624657e-01f, -1.54163450e-01f, -2.87172459e-02f, -1.89855099e-01f, 3.70503455e-01f,
  -6.04919381e-02f, -4.33159946e-03f, -5.54771647e-02f, 7.57511705e-02f, 2.91907676e-02f, -6.10178560e-02f, -1.08233579e-02f, -1.21183038e-01f, -1.52167110e-02f, 9.82289538e-02f,
  8.40741396e-03f, 7.33734891e-02f, -1.04512833e-01f, 8.20298959e-03f, -8.60114098e-02f, 2.34657107e-03f, 1.07979253e-01f, 1.36908926e-02f, -2.13926196e-01f, -8.73682648e-03f,
  -6.46904856e-02f, -1.30689770e-01f, 8.07779375e-03f, 1.27107039e-01f, 3.79690453e-02f, 2.44587734e-02f, 8.25490132e-02f, -1.09527409e-01f, 5.53280637e-02f, -4.93862480e-02f,
  1.27069741e-01f, -6.88843966e-01f, 1.99225470e-01f, 2.22731099e-01f, 6.03405572e-02f, -1.25509733e-02f, -1.23134024e-01f, -1.62106544e-01f, -1.26415521e-01f, 7.90265799e-02f,
  -5.55766821e-02f, -3.61329876e-02f, -8.70417953e-02f, 1.10206373e-01f, 5.78966038e-03f, -3.52774896e-02f, 8.86592045e-02f, 1.00543857e-01f, -6.58022091e-02f, -6.16574176e-02f,
  8.79790261e-02f, 6.50500208e-02f, -1.82491424e-03f, -8.57249275e-02f, -1.73279330e-01f, -3.15290987e-01f, -2.62881089e-02f, 7.98479319e-02f, -1.09278962e-01f, 3.76904517e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 14)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 14;
const float L0_fan_Bp_bar_data[] = {
  6.21743143e-01f, 1.42779067e-01f, -1.33953601e-01f, 6.56319261e-01f, -1.24895051e-01f, 2.21790120e-01f, 7.63928592e-01f, 3.17211330e-01f, 1.43799818e+00f, 8.96687627e-01f,
  6.85286820e-01f, 4.38411057e-01f, 3.30888182e-01f, 7.04922795e-01f
};

// L1_fan_Wp (Shape: 1 x 16)
const int L1_fan_Wp_rows = 1;
const int L1_fan_Wp_cols = 16;
const float L1_fan_Wp_data[] = {
  -1.79840311e-01f, 1.00270674e-01f, 1.47863284e-01f, 7.12017193e-02f, 1.59206733e-01f, 2.64502704e-01f, -1.11570448e-01f, -6.87740862e-01f, -2.27755994e-01f, 6.23282909e-01f,
  -5.98327117e-03f, -5.79993308e-01f, 4.36899304e-01f, -1.71448693e-01f, -3.24006587e-01f, -3.83385509e-01f
};

// L1_fan_Wp_bar (Shape: 14 x 16)
const int L1_fan_Wp_bar_rows = 14;
const int L1_fan_Wp_bar_cols = 16;
const float L1_fan_Wp_bar_data[] = {
  4.85011250e-01f, 3.26951504e-01f, 3.30094337e-01f, -5.47951102e-01f, 3.77339303e-01f, 1.63651288e-01f, -1.39664501e-01f, -8.09871018e-01f, -4.38758761e-01f, 1.33317721e+00f,
  2.97357827e-01f, 8.00230265e-01f, 6.87844932e-01f, -2.05581486e-01f, -7.23935366e-02f, -3.40930194e-01f, -4.02440578e-02f, 1.46324664e-01f, -6.94081306e-01f, -7.45007098e-01f,
  -1.33791327e-01f, -3.63598883e-01f, 2.12065384e-01f, 1.40045667e+00f, -6.85328916e-02f, 8.05355966e-01f, 9.18268323e-01f, -7.72491634e-01f, 5.27630925e-01f, -5.29178903e-02f,
  -2.59684939e-02f, 5.43093026e-01f, 1.55797258e-01f, -4.95769829e-02f, 2.38566712e-01f, -5.16504824e-01f, -2.95263797e-01f, -2.95128971e-01f, -2.76824862e-01f, 8.90689075e-01f,
  6.02708578e-01f, -8.83508980e-01f, 4.67995286e-01f, -1.28929866e-02f, 7.41440177e-01f, 5.43562889e-01f, 4.46918517e-01f, -5.78223526e-01f, 5.11435032e-01f, 1.00557879e-01f,
  6.54141903e-01f, -4.32191730e-01f, -4.62687433e-01f, 7.18839943e-01f, -4.61556613e-01f, -6.38180852e-01f, 4.43171650e-01f, 4.69160289e-01f, -6.09396398e-01f, 1.00373399e+00f,
  -1.04489779e+00f, 2.31405184e-01f, 5.18831134e-01f, 9.88095760e-01f, 5.48423171e-01f, -1.42758694e-02f, 9.61127058e-02f, -1.25831679e-01f, 2.01809984e-02f, 7.68886507e-01f,
  1.44785136e-01f, -1.19624525e-01f, 2.30431795e-01f, -7.76346743e-01f, 3.65578443e-01f, 7.33925641e-01f, -7.15858340e-01f, -6.72316790e-01f, 1.08517725e-02f, 1.02852786e+00f,
  -2.93067455e-01f, 1.43403065e+00f, -3.39559227e-01f, 6.14027157e-02f, -2.40747422e-01f, 6.90077722e-01f, 2.92608924e-02f, -1.05865192e+00f, 8.74128789e-02f, 6.12034738e-01f,
  5.62559485e-01f, 7.41434276e-01f, 7.20547378e-01f, 3.23791772e-01f, -5.26622891e-01f, 7.45022655e-01f, 1.59025773e-01f, 5.25749661e-02f, -1.92963153e-01f, 9.17776585e-01f,
  4.10391033e-01f, 9.60373223e-01f, 1.06172666e-01f, 1.23958445e+00f, -4.40644741e-01f, -3.47396463e-01f, 5.66416562e-01f, 5.69669008e-01f, -3.41509402e-01f, 2.84479052e-01f,
  3.91023815e-01f, -8.68376374e-01f, 6.86190426e-01f, -8.46588090e-02f, -4.22635138e-01f, -1.01971388e+00f, -2.88418889e-01f, -4.53921348e-01f, -5.03578782e-01f, -3.36045057e-01f,
  8.57614338e-01f, -6.23963356e-01f, 4.93050128e-01f, 1.07673824e-01f, 1.78538989e-02f, -4.67754267e-02f, -8.80801082e-02f, 5.48722029e-01f, 1.48057163e-01f, -2.20639221e-02f,
  3.39604974e-01f, 8.65199983e-01f, 7.36029893e-02f, -2.08999470e-01f, 2.15982899e-01f, -9.74195421e-01f, 2.88870871e-01f, -9.51678336e-01f, 2.89889097e-01f, 6.97885081e-02f,
  7.11352468e-01f, 4.75118339e-01f, -5.18493176e-01f, -2.03344420e-01f, 8.24847519e-01f, -7.92469382e-01f, 1.07950889e-01f, 6.71304584e-01f, 3.48626047e-01f, 5.06498814e-01f,
  -6.55267656e-01f, -4.02942419e-01f, 2.60724932e-01f, 8.57509077e-01f, 5.08906357e-02f, 6.88355327e-01f, 2.75714368e-01f, 3.65082830e-01f, -3.67783010e-01f, 7.80268788e-01f,
  7.25797117e-01f, -1.19043458e+00f, 6.68082893e-01f, -7.48252034e-01f, 6.96240664e-01f, -4.41842750e-02f, -2.97521174e-01f, -9.51738954e-02f, -2.79087216e-01f, 6.93476558e-01f,
  1.25330865e-01f, 4.94108588e-01f, 9.17639315e-01f, -3.65033209e-01f, -6.01509392e-01f, -2.59649336e-01f, 2.85336703e-01f, -1.96991414e-01f, -3.37356210e-01f, 9.16272938e-01f,
  6.35086775e-01f, 4.10255939e-01f, 2.55178154e-01f, 5.26071310e-01f, -1.45278782e-01f, 2.22628146e-01f, 1.14666045e-01f, -3.37079883e-01f, 6.03220224e-01f, 5.51519394e-01f,
  4.45900768e-01f, -3.67996216e-01f, 6.23299539e-01f, -1.07068934e-01f, -6.66253626e-01f, 5.15138924e-01f, 5.58622479e-01f, -8.39468017e-02f, 1.60445958e-01f, -1.24627912e+00f,
  -6.44112825e-01f, -3.61160606e-01f, 7.19101608e-01f, -2.54830450e-01f, -2.00064182e-02f, -1.38345766e+00f, -3.27689916e-01f, -3.11132491e-01f, 1.73830241e-02f, -1.22050166e+00f,
  6.34947360e-01f, -3.61088961e-01f, -2.18423069e-01f, -3.32595974e-01f, -3.26965928e-01f, 1.07071579e+00f, -3.85416806e-01f, -4.00005609e-01f, 2.96017706e-01f, -3.72092307e-01f,
  3.87741834e-01f, 8.43770146e-01f, 2.19071090e-01f, 1.04202449e+00f
};

// L1_fan_Bp_bar (Shape: 1 x 14)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 14;
const float L1_fan_Bp_bar_data[] = {
  8.84658933e-01f, 3.61588635e-02f, 8.69549692e-01f, 2.21311495e-01f, 3.05096716e-01f, 1.10783197e-01f, 2.68254787e-01f, 1.11336911e+00f, 7.98956454e-01f, 5.65498114e-01f,
  9.04751539e-01f, 1.45587653e-01f, 1.20879292e+00f, 5.41770399e-01f
};

// L2_linear_W (Shape: 12 x 16)
const int L2_linear_W_rows = 12;
const int L2_linear_W_cols = 16;
const float L2_linear_W_data[] = {
  8.39021087e-01f, 4.83253449e-01f, -2.37992570e-01f, 4.83762860e-01f, -5.61018348e-01f, -5.30510247e-01f, 3.64449210e-02f, -1.20813644e+00f, 6.15137339e-01f, -1.02001405e+00f,
  -1.01699269e+00f, 5.25427843e-03f, 2.72424608e-01f, 2.73425996e-01f, -1.49962679e-02f, 3.14689696e-01f, -1.17217565e+00f, 5.43897986e-01f, -9.84877408e-01f, 5.33580184e-01f,
  6.23739123e-01f, 4.06474710e-01f, -2.16027588e-01f, -9.40254807e-01f, 4.99267787e-01f, -1.14679977e-01f, -5.45997322e-01f, -1.05656838e+00f, -1.00604630e+00f, 1.83185190e-01f,
  -2.99833775e-01f, 4.13017273e-01f, -3.07339042e-01f, 6.68651938e-01f, 1.12269260e-01f, -5.88091314e-01f, -1.07370794e-01f, -1.60095170e-01f, 8.54105949e-01f, -1.61869541e-01f,
  7.99281001e-01f, -5.81734836e-01f, -6.51093960e-01f, 2.02043220e-01f, 1.15463324e-01f, -3.13662477e-02f, -1.52648938e+00f, -9.93136883e-01f, -6.61862850e-01f, 7.15158358e-02f,
  6.66344941e-01f, 2.35102832e-01f, -1.24180305e+00f, -2.96263695e-01f, -8.30204129e-01f, 8.20188969e-02f, -4.96637076e-01f, -2.38542959e-01f, -9.12961662e-01f, 2.68645614e-01f,
  3.96963805e-01f, 1.22927368e-01f, -6.54372573e-02f, -1.10559738e+00f, 1.12924600e+00f, 3.81763250e-01f, 4.26788256e-02f, -5.33626854e-01f, -2.05984250e-01f, -2.24927682e-02f,
  3.73413920e-01f, -2.93719947e-01f, 2.35600799e-01f, -5.31858385e-01f, 3.61968786e-01f, 1.21062272e-03f, 7.08371922e-02f, -2.08452884e-02f, 8.53866458e-01f, -1.08100617e+00f,
  8.94779265e-01f, -1.40522707e+00f, -5.19985080e-01f, 3.11473489e-01f, 3.24193209e-01f, -7.75831819e-01f, 2.71259516e-01f, -7.33520627e-01f, -6.85149133e-01f, 5.01532555e-01f,
  2.13079497e-01f, -8.72341692e-02f, 3.75397831e-01f, -2.77044803e-01f, 1.21277936e-01f, 5.44180930e-01f, -2.21646190e-01f, 3.03392738e-01f, -7.83723474e-01f, 3.32296222e-01f,
  -9.42918122e-01f, 4.51514781e-01f, 7.32945561e-01f, 1.41464755e-01f, -5.53221583e-01f, -8.05257618e-01f, -9.96860042e-02f, 2.84717172e-01f, -1.07936049e+00f, 6.63844496e-02f,
  -4.32678282e-01f, 3.33112419e-01f, -7.18020201e-01f, 1.22476649e+00f, 2.90701121e-01f, -7.48661101e-01f, -8.91904905e-03f, -5.17524540e-01f, 1.25902519e-01f, 5.48464239e-01f,
  -1.29751217e+00f, -3.58359873e-01f, 7.58373499e-01f, -3.72546427e-02f, 1.36244521e-01f, 2.99866926e-02f, -9.52093840e-01f, -2.05988213e-01f, -1.83012873e-01f, -4.18999076e-01f,
  -2.10132271e-01f, -8.98719013e-01f, 3.05896670e-01f, 6.05695069e-01f, 3.43483955e-01f, -6.68197423e-02f, -1.06041300e+00f, 1.36469638e+00f, -9.06913728e-02f, 2.58989900e-01f,
  -4.19681281e-01f, -5.45243144e-01f, -6.76710844e-01f, -8.65391970e-01f, -2.15725735e-01f, -9.66522992e-01f, -4.63504702e-01f, -3.98868769e-01f, -5.90575933e-01f, -5.06640255e-01f,
  -1.10156822e+00f, 1.50174320e-01f, 4.35302168e-01f, -5.84212065e-01f, 5.11215925e-01f, 4.12479967e-01f, -7.72421062e-01f, 5.88483155e-01f, -3.89719605e-01f, -1.12293668e-01f,
  4.61852103e-01f, -1.06044732e-01f, 1.74009934e-01f, 6.33190036e-01f, -6.44612312e-02f, -7.85211921e-01f, -7.53699243e-02f, 1.15209424e+00f, -1.41839191e-01f, 3.61221284e-01f,
  -1.84148744e-01f, -1.34228516e+00f, -1.01736045e+00f, -7.65376210e-01f, 2.68268347e-01f, -1.35582793e+00f, 2.67319560e-01f, 4.09809738e-01f, 6.57678306e-01f, -6.54866040e-01f,
  -3.45738381e-01f, 6.12308860e-01f, -4.39480454e-01f, -1.11578441e+00f, -5.78959167e-01f, -8.74611020e-01f, -1.72671854e-01f, 2.17770100e-01f, 7.08764255e-01f, -7.21198022e-01f,
  -6.35876656e-01f, 3.49099457e-01f
};

// L2_linear_B (Shape: 1 x 12)
const int L2_linear_B_rows = 1;
const int L2_linear_B_cols = 12;
const float L2_linear_B_data[] = {
  -6.19330108e-01f, -2.73388684e-01f, 3.70454192e-01f, -3.45103741e-01f, -5.53131066e-02f, 4.53850210e-01f, -4.46476489e-02f, -9.11920518e-02f, 8.74374136e-02f, 1.32460490e-01f,
  -4.41956609e-01f, -9.93792899e-03f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 1, 14
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        16, 1, 14
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_linear
    linear_forward_pgm(
        buffer1, x_out,
        L2_linear_W_data, L2_linear_B_data,
        16, 12
    );
    }
    