/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 16 (x1)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 16;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    static inline float fan_activation(float x) { return x; }

    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 3 x 120)
const int L0_fan_Wp_rows = 3;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  7.08126664e-01f, -1.34593010e-01f, -2.39152536e-01f, 2.69190967e-01f, 3.15896899e-01f, 5.48647821e-01f, 4.09970462e-01f, -8.10970441e-02f, 2.46344600e-02f, 9.65052024e-02f,
  1.65317580e-01f, -1.60587907e-01f, -2.79725511e-02f, 1.51193634e-01f, 3.60887408e-01f, -3.97085845e-02f, 7.55352899e-02f, 9.08637568e-02f, 6.72563259e-03f, -1.68042090e-02f,
  9.63535383e-02f, 1.14722490e-01f, -3.03454474e-02f, -4.09804173e-02f, 2.19970509e-01f, -1.99910954e-01f, -4.93811890e-02f, -1.34914055e-01f, -3.58334742e-02f, 1.18597798e-01f,
  5.21350801e-02f, 3.37953344e-02f, -1.06850132e-01f, 1.47146471e-02f, 6.45319000e-02f, 3.26078236e-02f, -2.07409803e-02f, 1.77088436e-02f, 4.81788889e-02f, 9.36044231e-02f,
  -6.87524304e-03f, -9.31980833e-03f, -5.95859718e-03f, -3.36674564e-02f, 1.92108735e-01f, -3.99234034e-02f, -2.46627014e-02f, 2.25999448e-02f, -2.04574928e-01f, 1.17621832e-01f,
  -6.55985624e-02f, 2.15711705e-02f, -2.45325193e-02f, -6.68984726e-02f, -8.40519071e-02f, -2.51809638e-02f, -8.39869753e-02f, 8.32698420e-02f, 5.38277961e-02f, -4.67787236e-02f,
  4.39396277e-02f, 1.14448555e-02f, 3.79834883e-02f, -4.69615757e-02f, 8.03945288e-02f, -6.67063221e-02f, 6.54946864e-02f, 5.99103123e-02f, 2.69642975e-02f, 3.84723954e-02f,
  -6.45267144e-02f, 1.14261374e-01f, -2.55311672e-02f, 1.50309026e-01f, 5.85092194e-02f, -2.57983804e-02f, 7.71614686e-02f, -1.07579008e-01f, -9.16960277e-03f, 7.77256042e-02f,
  7.93916173e-03f, 2.09788606e-02f, -1.09225392e-01f, -2.73093972e-02f, 5.82403131e-02f, 1.10489167e-01f, -1.51386604e-01f, -1.05052069e-01f, -5.27217463e-02f, 6.60730675e-02f,
  -1.81243509e-01f, -2.54403085e-01f, -5.73629960e-02f, 6.66597113e-03f, -4.12080772e-02f, 5.44781052e-02f, 3.72836255e-02f, 3.99304368e-02f, 2.08764728e-02f, 6.73709586e-02f,
  6.90099690e-03f, 5.66741377e-02f, -5.00400178e-02f, 1.92597359e-01f, -4.10921797e-02f, -1.87309291e-02f, -8.68862793e-02f, 4.66352925e-02f, 1.13725260e-01f, -8.34133327e-02f,
  -1.25846602e-02f, 5.23994528e-02f, -3.97522673e-02f, 9.35062468e-02f, 1.65962294e-01f, 3.78310084e-02f, 1.96388178e-03f, -5.48069738e-02f, -2.28763092e-03f, 1.40309436e-02f,
  -5.35265088e-01f, 7.35331234e-03f, -4.56601411e-01f, -4.90688533e-01f, 3.48313868e-01f, 2.56204605e-01f, -3.11013371e-01f, 1.07954130e-01f, -6.23549163e-01f, 1.63749412e-01f,
  2.24191979e-01f, -1.74729750e-01f, -2.16896925e-02f, 7.36161098e-02f, -1.10537820e-01f, 1.25037670e-01f, -1.86536163e-01f, -5.06843477e-02f, -5.42813130e-02f, -2.49591962e-01f,
  -1.32556558e-01f, 3.87579888e-01f, -4.60194014e-02f, 3.26427042e-01f, -1.42432138e-01f, -2.19521403e-01f, -8.08653086e-02f, 7.57821500e-02f, 2.26395383e-01f, 2.37831518e-01f,
  3.17451566e-01f, -2.67403270e-03f, -9.80234146e-02f, -7.31642619e-02f, -1.19652659e-01f, 1.19858459e-02f, 2.42279693e-02f, 6.93445876e-02f, -4.88119759e-02f, 4.15158756e-02f,
  -2.23365426e-02f, 8.00530910e-02f, 2.27281321e-02f, -7.09874555e-02f, -4.78392914e-02f, -8.30113590e-02f, -8.12975615e-02f, -1.16587998e-02f, 1.04183398e-01f, -5.83842164e-03f,
  6.91296009e-04f, -1.91603694e-03f, -2.00026944e-01f, -1.55549303e-01f, -1.62354276e-01f, -6.42718971e-02f, 6.67416304e-03f, -1.58191230e-02f, 1.90396085e-02f, -2.61283498e-02f,
  2.03553382e-02f, -8.93550739e-03f, 1.84402689e-02f, 2.59004254e-02f, 2.97685303e-02f, 1.27488002e-01f, -6.42149970e-02f, 1.83676228e-01f, -2.36554444e-01f, 4.22231928e-02f,
  4.22506332e-02f, 5.55111915e-02f, 7.04760775e-02f, -2.58683246e-02f, -9.93981771e-03f, -8.71740505e-02f, 1.00214303e-01f, 3.81177329e-02f, -7.77194723e-02f, -2.07759757e-02f,
  1.68247610e-01f, 1.65734068e-03f, 9.07213390e-02f, 9.42649618e-02f, 1.24491930e-01f, -7.14452192e-02f, -6.96705505e-02f, 1.20567650e-01f, 4.76374887e-02f, -4.84895483e-02f,
  -5.06431125e-02f, -1.79531753e-01f, -3.99762467e-02f, 2.08424404e-03f, 2.65614800e-02f, 5.95175885e-02f, 6.63689449e-02f, -3.56258592e-03f, -2.78809480e-02f, -1.54948179e-02f,
  -7.62416497e-02f, -1.38465866e-01f, -4.00619954e-02f, 1.76993608e-02f, -3.73088829e-02f, 4.84072454e-02f, 5.98906130e-02f, -2.03028712e-02f, -1.34750217e-01f, 8.13981071e-02f,
  8.00458714e-02f, 5.35556749e-02f, -5.80190308e-02f, 9.67057124e-02f, 2.24461462e-02f, -4.76755761e-03f, -4.67370450e-02f, 1.27582382e-02f, 2.44468600e-02f, -8.09439793e-02f,
  -6.18562847e-02f, -4.97245669e-01f, -5.22865713e-01f, -5.91959119e-01f, 4.28085417e-01f, -3.95204946e-02f, -6.90755308e-01f, 1.28454790e-01f, -2.28629574e-01f, -1.98131204e-01f,
  -2.17314988e-01f, 8.40359479e-02f, -2.45639071e-01f, -3.44641715e-01f, -8.86129960e-02f, -3.87428612e-01f, -2.80224442e-01f, -2.00055659e-01f, -1.02445088e-01f, 1.27952278e-01f,
  -3.17115150e-02f, -1.31745502e-01f, -3.00993681e-01f, 2.41076097e-01f, -1.76330701e-01f, 7.04862997e-02f, 1.11445166e-01f, 3.83082628e-02f, 1.67367324e-01f, -1.06408469e-01f,
  -1.65877983e-01f, -1.21172644e-01f, -2.10984834e-02f, 1.48557136e-02f, -3.92259471e-02f, -2.22385868e-01f, 1.03309127e-02f, 7.12888613e-02f, -3.14009860e-02f, -1.37499487e-02f,
  -1.86851900e-02f, -4.35601845e-02f, 2.59046927e-02f, -1.50104181e-03f, 5.93592972e-02f, 1.41672969e-01f, 9.35190395e-02f, -9.31230634e-02f, 2.59634610e-02f, -1.25579864e-01f,
  -2.74278689e-02f, 4.40483727e-02f, -8.68534371e-02f, 1.80358870e-03f, 1.19663104e-01f, -9.05703977e-02f, -1.16956688e-01f, 2.22620189e-01f, -3.56873125e-02f, 2.69589182e-02f,
  1.36197954e-02f, -7.63207078e-02f, 3.19633670e-02f, -5.22852642e-03f, 9.05642733e-02f, -4.90041859e-02f, -3.65441963e-02f, 1.46742985e-01f, -1.98135693e-02f, -2.52266265e-02f,
  2.25336291e-02f, 1.42658973e-04f, -1.88542884e-02f, -1.17430232e-01f, 6.18223287e-02f, -4.65675555e-02f, -1.29470425e-02f, -4.08898108e-03f, 3.47747467e-02f, 4.88036722e-02f,
  -3.32625397e-02f, -1.83476675e-02f, 6.44725114e-02f, -8.27439968e-03f, -1.45185366e-01f, 1.56666785e-01f, -1.08102910e-01f, -8.69975705e-03f, -3.56433839e-02f, 9.39103812e-02f,
  -6.64670467e-02f, -1.57151356e-01f, 1.01241199e-02f, 1.73754208e-02f, -3.07088215e-02f, 2.59615064e-01f, -6.74711317e-02f, 1.22096814e-01f, 1.75414488e-01f, -4.82531264e-02f,
  8.08097348e-02f, 2.18217741e-04f, -3.72500271e-02f, 3.49305011e-02f, -2.75668241e-02f, -2.40588840e-02f, -6.91367835e-02f, 1.77775025e-01f, -1.22227259e-01f, 1.11210950e-01f,
  5.58428839e-02f, 1.17189445e-01f, -3.95390838e-02f, 6.98932782e-02f, -6.19232766e-02f, 3.20353694e-02f, 1.86501428e-01f, 7.34337345e-02f, 1.27928415e-02f, -1.16428383e-01f
};

// L0_fan_Wp_bar (Shape: 10 x 120)
const int L0_fan_Wp_bar_rows = 10;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  7.84236193e-01f, -5.32132089e-01f, 7.40150690e-01f, 1.02294952e-01f, 9.44636762e-01f, 5.33237159e-01f, 7.04657733e-01f, 1.95080861e-01f, 5.97563922e-01f, -9.70773816e-01f,
  -2.71634847e-01f, -3.92766982e-01f, 3.65393430e-01f, -6.28209591e-01f, 4.76577669e-01f, 2.23331869e-01f, -2.53573954e-01f, -5.26410222e-01f, 3.30340743e-01f, 1.43467531e-01f,
  2.52177536e-01f, -5.17385185e-01f, 1.85420856e-01f, -4.95236188e-01f, 2.99221992e-01f, -1.93390906e-01f, -6.37123406e-01f, 2.66064107e-01f, -1.06773067e+00f, 5.36288805e-02f,
  2.38439324e-03f, 4.60472330e-02f, 3.22422236e-01f, -2.03355238e-01f, 1.02737166e-01f, 2.20589384e-01f, -2.06113234e-01f, 1.90172702e-01f, 3.12593400e-01f, -1.93747003e-02f,
  -5.41400462e-02f, 5.05372509e-02f, -3.48454118e-01f, -1.71516568e-03f, 1.97294295e-01f, -2.01156214e-02f, 1.68502182e-01f, 2.77404308e-01f, 4.44626287e-02f, 1.45333081e-01f,
  4.21790451e-01f, 1.96062073e-01f, 3.25154692e-01f, -3.56618434e-01f, 1.65892422e-01f, 1.07951388e-01f, -2.56232033e-03f, 1.94716662e-01f, -1.40568525e-01f, -4.26266752e-02f,
  -1.21864676e-01f, 1.57625094e-01f, 6.52784631e-02f, -3.86700407e-02f, -1.49454838e-02f, -1.53660420e-02f, -1.74603835e-01f, -1.94171503e-01f, -2.03701273e-01f, -4.97366488e-02f,
  -8.73378962e-02f, 7.19958497e-03f, 1.20499752e-01f, -5.31511568e-02f, -5.11342064e-02f, -4.12304811e-02f, 2.78443675e-02f, -2.71576494e-01f, 3.40160429e-02f, 7.33382404e-02f,
  -4.50331718e-02f, -5.37699685e-02f, 7.92593360e-02f, 3.15882340e-02f, -1.15114398e-01f, 1.66191772e-01f, -1.98852092e-01f, 2.92306930e-01f, 6.79155812e-02f, -1.60409048e-01f,
  -9.25310493e-01f, -1.46562278e+00f, -1.35452285e-01f, -1.48897856e-01f, -4.56372559e-01f, -2.09876988e-02f, 5.23674600e-02f, -4.61187474e-02f, -3.07819754e-01f, 5.51554095e-03f,
  -8.42032433e-02f, -1.82475999e-01f, -4.30216193e-02f, -5.28307706e-02f, -2.01461688e-01f, 4.69821505e-02f, -1.78705871e-01f, -3.39060247e-01f, -1.83933973e-01f, -1.27619818e-01f,
  -1.53268188e-01f, -1.47136703e-01f, -1.35614872e-01f, 3.40196453e-02f, -2.72743762e-01f, -1.39106661e-01f, -6.53074756e-02f, -1.50807172e-01f, -1.42627865e-01f, 3.59583758e-02f,
  8.92752558e-02f, 1.11728728e-01f, -9.87820983e-01f, -6.21144474e-01f, 1.38299842e-03f, 1.21812713e+00f, 8.78217101e-01f, 1.82970747e-01f, -2.08332986e-01f, 1.16500676e+00f,
  6.48556411e-01f, -4.55970496e-01f, 6.88800812e-01f, 4.67139602e-01f, -6.35220170e-01f, 6.68627262e-01f, 5.44620633e-01f, 3.28440666e-01f, -3.16808373e-01f, 2.82121122e-01f,
  -3.59928936e-01f, 7.64455914e-01f, -6.94874763e-01f, 3.65977645e-01f, 2.38810241e-01f, -6.49556458e-01f, 3.83549556e-02f, -3.12354177e-01f, -1.49756059e-01f, -1.01596080e-01f,
  3.90572697e-02f, -8.91903341e-02f, -6.28009662e-02f, -5.97045980e-02f, 2.32805368e-02f, 1.86082676e-01f, 4.10099141e-02f, -7.48220682e-02f, -3.69817555e-01f, -3.90231162e-02f,
  1.31239057e-01f, -1.60699159e-01f, -8.25552121e-02f, -1.51523903e-01f, 9.20690522e-02f, -2.60234177e-01f, -2.33953044e-01f, -5.51132038e-02f, -1.26171276e-01f, 2.59628203e-02f,
  -1.85156256e-01f, -8.52454454e-02f, 1.47786401e-02f, -8.08241218e-02f, -1.77642405e-01f, 8.96411203e-03f, 1.41317770e-01f, -8.04727301e-02f, 1.41985193e-01f, -4.64671701e-02f,
  1.28540292e-01f, 2.23311022e-01f, 3.21724623e-01f, 9.22524109e-02f, -1.15769081e-01f, -2.55091749e-02f, 1.59281924e-01f, -9.11948159e-02f, -1.51461571e-01f, 1.93779707e-01f,
  -1.27120912e-01f, -1.36760324e-01f, 9.48293805e-02f, 1.42764643e-01f, 6.85619637e-02f, -8.00536722e-02f, 5.53325824e-02f, 4.31222096e-02f, -4.53549288e-02f, -1.67650819e-01f,
  -8.09302628e-02f, 4.57719974e-02f, 1.69968814e-01f, 1.76448058e-02f, 2.66122650e-02f, -7.89029822e-02f, 2.20381767e-01f, -6.02326132e-02f, -3.71429287e-02f, -1.88668780e-02f,
  5.43099921e-03f, 2.69509137e-01f, 1.02046333e-01f, -8.87967199e-02f, -1.67278722e-01f, 1.86820492e-01f, 4.26920652e-02f, 3.28464136e-02f, 5.07415123e-02f, 1.29633009e-01f,
  1.70075506e-01f, 2.53058933e-02f, 1.97628513e-01f, -1.12881914e-01f, -1.58427611e-01f, 4.61594701e-01f, 2.06623241e-01f, -1.26964271e-01f, 4.68754508e-02f, -1.72697306e-01f,
  -4.05298499e-03f, 2.16776654e-01f, -1.55905429e-02f, -3.05419583e-02f, 1.35831326e-01f, 8.75994414e-02f, -3.74497660e-02f, -1.84485808e-01f, -7.06811845e-02f, -3.07654925e-02f,
  -6.18973434e-01f, 1.30344212e+00f, 7.24643946e-01f, -2.10813031e-01f, 4.24336568e-02f, 8.55068743e-01f, 5.51627427e-02f, 5.50058842e-01f, 1.02449393e+00f, 1.70424774e-01f,
  -4.99651998e-01f, 4.02794838e-01f, -4.72830003e-03f, -2.55384922e-01f, 3.10976803e-01f, 3.27522427e-01f, -6.04732670e-02f, 5.41923270e-02f, 6.27734125e-01f, -9.90643054e-02f,
  1.22666568e-01f, -5.62119961e-01f, -4.19928372e-01f, -6.66732490e-02f, -3.09800923e-01f, 1.35138601e-01f, -8.56004298e-01f, 2.03917414e-01f, -7.34463111e-02f, 2.61536747e-01f,
  -4.86014150e-02f, -2.06381101e-02f, -3.42001706e-01f, 1.01748228e-01f, -1.60778072e-02f, 6.40337765e-02f, 6.69011986e-03f, 4.66121994e-02f, 7.92569946e-03f, 1.75447091e-01f,
  -1.25915200e-01f, 1.88464317e-02f, 5.67879379e-02f, -4.16837446e-02f, 1.16608992e-01f, 7.40947574e-02f, 2.62823496e-02f, -2.27886319e-01f, 7.86487609e-02f, 5.78106456e-02f,
  -8.79903436e-02f, 1.42349645e-01f, -1.13143444e-01f, 5.00806347e-02f, -5.17117791e-02f, 1.16247766e-01f, 1.62834480e-01f, -1.70705877e-02f, -4.36681174e-02f, 3.66140366e-01f,
  1.16730265e-01f, 1.42106399e-01f, -1.19911969e-01f, -1.51736066e-01f, 2.08856240e-02f, -1.01165764e-01f, -1.02395229e-01f, -1.24476902e-01f, -9.49527137e-03f, -2.08233163e-01f,
  -1.15992993e-01f, -6.80426657e-02f, -3.44868720e-04f, 6.19888417e-02f, -6.61933944e-02f, -1.35142490e-01f, -6.49067685e-02f, -3.78348939e-02f, 9.10015926e-02f, -1.00282177e-01f,
  9.31700245e-02f, 5.09581789e-02f, -9.49537084e-02f, -9.40142572e-02f, -1.12521583e-02f, 1.63538188e-01f, -6.33650273e-02f, -2.94497572e-02f, -7.12149590e-02f, -1.21401660e-01f,
  3.89455587e-01f, 6.70817256e-01f, -2.92257536e-02f, -6.23004250e-02f, -1.05052125e-02f, 7.31897401e-03f, 2.02159390e-01f, 6.87076449e-02f, 3.70639026e-01f, 1.14842601e-01f,
  1.27395764e-01f, -1.26578674e-01f, -5.91527037e-02f, -6.75774589e-02f, 2.08407771e-02f, 1.87289879e-01f, 9.94320773e-03f, 7.42705017e-02f, -7.90677145e-02f, -3.88526395e-02f,
  -3.36021155e-01f, 1.07208528e-01f, -5.75133823e-02f, -1.42380521e-01f, -1.17616579e-01f, -2.62531012e-01f, 5.66719733e-02f, 8.52915421e-02f, -1.71902329e-01f, 2.06656437e-02f,
  -8.24915826e-01f, -5.17131388e-01f, 9.94802862e-02f, -1.80526718e-01f, -8.09707344e-01f, -6.56646565e-02f, 1.02246475e+00f, -8.08475792e-01f, -5.48744440e-01f, 4.08625126e-01f,
  -2.11738907e-02f, 2.16559574e-01f, 1.00965285e+00f, -2.33598009e-01f, 7.00468719e-01f, 7.27525532e-01f, -5.91444923e-03f, 4.21366543e-01f, -3.41592699e-01f, -5.44745028e-01f,
  -3.84844333e-01f, -6.37139440e-01f, 4.30417866e-01f, -9.41051245e-01f, -6.56141639e-01f, -4.65347558e-01f, 1.11094967e-01f, 2.81360388e-01f, -4.03967679e-01f, 6.48455918e-02f,
  -6.73444331e-01f, -5.72674632e-01f, 1.83263216e-02f, 1.12030223e-01f, -2.65647531e-01f, 1.34449184e-01f, 2.84389168e-01f, 4.32695121e-01f, 1.46419212e-01f, -7.32421950e-02f,
  1.58429623e-01f, -2.60511786e-01f, -3.04081500e-01f, 7.55883902e-02f, -2.05135673e-01f, -2.50485927e-01f, -1.27887592e-01f, -1.73929363e-01f, -1.83585420e-01f, -4.05657887e-02f,
  -8.56316835e-02f, -1.16010286e-01f, -1.64830238e-01f, -3.52493627e-03f, 2.79117506e-02f, -2.48949125e-01f, 1.15000360e-01f, 2.50287682e-01f, -1.65078506e-01f, -2.04227760e-01f,
  4.19774465e-02f, 7.63365030e-02f, 1.52760848e-01f, -1.73468769e-01f, -1.57493073e-02f, -1.64880425e-01f, -6.52376786e-02f, 9.78845581e-02f, -4.11741026e-02f, -7.75326937e-02f,
  -2.05326259e-01f, -7.24694459e-03f, -1.52929649e-01f, 2.86137071e-02f, -5.16539775e-02f, 4.96768579e-02f, 2.05171913e-01f, -1.64147824e-01f, -1.28703967e-01f, -2.35051475e-02f,
  -4.47956435e-02f, -4.21309806e-02f, -3.02481204e-02f, 1.57696798e-01f, -5.09209223e-02f, 6.38237223e-02f, -2.72750705e-01f, -8.93833041e-02f, 8.24173912e-02f, 2.63186753e-01f,
  -5.62574387e-01f, -3.83952618e-01f, 1.05024036e-02f, -1.21849135e-01f, 1.21031590e-01f, -1.08105578e-01f, -1.27045286e-03f, -2.50021279e-01f, -9.50489119e-02f, 3.06256227e-02f,
  3.12696472e-02f, 6.65222155e-03f, -1.04562037e-01f, -3.23018208e-02f, 6.26232624e-02f, -1.35101005e-01f, 1.05531991e-01f, 6.56238720e-02f, -1.06896482e-01f, -1.52355835e-01f,
  3.81396785e-02f, 2.35155210e-01f, 1.02780856e-01f, -2.55668283e-01f, 5.80434203e-02f, 1.69802845e-01f, -2.18242496e-01f, 1.07303396e-01f, 4.08768281e-02f, -4.05696556e-02f,
  4.45152581e-01f, 8.09794366e-01f, 2.49169424e-01f, -7.82037497e-01f, -3.15111011e-01f, -5.41086376e-01f, -6.49466693e-01f, -1.26415193e-01f, -6.31656945e-01f, 4.83539641e-01f,
  -5.33603191e-01f, 6.62837207e-01f, -1.38070524e-01f, -8.22681606e-01f, -1.36609137e+00f, -9.47238564e-01f, -7.13405073e-01f, -2.10815564e-01f, -3.12278390e-01f, -1.21164300e-01f,
  -4.40689117e-01f, -1.33454096e+00f, -5.02253115e-01f, -1.50609955e-01f, 5.21322846e-01f, 7.33828664e-01f, -7.21012652e-02f, 3.37882549e-01f, 4.98648286e-01f, -1.90923497e-01f,
  -5.81924543e-02f, 3.71066369e-02f, 2.82264411e-01f, 1.89301930e-02f, 2.24265433e-03f, 3.75834644e-01f, 2.95530468e-01f, -1.37997329e-01f, 9.00434796e-03f, 4.89303619e-02f,
  2.25085571e-01f, -4.95755225e-02f, -3.43573838e-01f, -5.83867803e-02f, 2.63724834e-01f, 1.51508242e-01f, -4.08928804e-02f, 3.78751218e-01f, 1.42868068e-02f, 1.88619688e-01f,
  -2.55569816e-03f, 3.01134288e-01f, 1.13949962e-01f, 5.02875894e-02f, -1.94438398e-01f, -8.68922248e-02f, 8.44193399e-02f, 2.06365630e-01f, 1.45546630e-01f, -1.95452143e-02f,
  1.76848128e-01f, 3.76427807e-02f, -1.90711468e-01f, 2.05436617e-01f, -1.20701879e-01f, -1.30801439e-01f, -1.30022302e-01f, 3.84542197e-02f, 7.92276412e-02f, 3.05187479e-02f,
  -1.25928432e-01f, -1.09784879e-01f, -1.27411321e-01f, 4.60894667e-02f, 2.75187343e-02f, 8.91277567e-02f, 8.37775096e-02f, -1.65638644e-02f, -1.65720910e-01f, -1.53107345e-01f,
  5.54488190e-02f, -1.68149456e-01f, -1.16944171e-01f, 2.38281146e-01f, -2.73170173e-01f, -1.07114516e-01f, 2.14548454e-01f, 1.89936727e-01f, 5.95226884e-02f, 4.60764281e-02f,
  -8.10413212e-02f, -1.20524414e-01f, -1.35619536e-01f, -1.30630046e-01f, 9.01584774e-02f, 9.54186264e-03f, -1.70214042e-01f, -5.83416745e-02f, -7.22594038e-02f, -1.78636536e-01f,
  1.43345684e-01f, -7.78853670e-02f, 1.65302902e-01f, 1.13360249e-01f, -2.92658240e-01f, -2.73091733e-01f, -5.80199175e-02f, 5.78876063e-02f, 5.31655625e-02f, -1.47796515e-03f,
  2.80861944e-01f, -9.87244770e-02f, -1.00127216e-02f, -3.01665008e-01f, -7.79293478e-02f, 1.60292953e-01f, 2.22446084e-01f, 7.64142126e-02f, -1.32335186e-01f, -2.81543508e-02f,
  3.81745845e-01f, -3.42932045e-01f, -5.95039845e-01f, -7.65940487e-01f, -6.45909369e-01f, 2.54320749e-03f, -5.27903557e-01f, -5.66463888e-01f, -4.21075374e-01f, -4.07679319e-01f,
  -7.22496629e-01f, 3.80996943e-01f, 4.14361089e-01f, -8.38792026e-01f, 9.36602056e-01f, 6.39715791e-01f, -2.25003228e-01f, -1.40570745e-01f, -1.67622328e-01f, -2.69254237e-01f,
  -6.67543262e-02f, -3.33030462e-01f, 8.37430134e-02f, -1.97326943e-01f, -6.24075890e-01f, -2.70443022e-01f, 7.42233843e-02f, -6.82755351e-01f, -8.97132933e-01f, -3.26520294e-01f,
  -1.14976838e-01f, -1.31237477e-01f, -6.63906038e-02f, 1.11951061e-01f, -9.19753313e-02f, 5.09687215e-02f, -3.15737426e-01f, 2.05532297e-01f, -5.00486121e-02f, -5.36742508e-02f,
  4.22338158e-01f, 3.50579232e-01f, -1.84121966e-01f, 7.26387203e-02f, -2.17203364e-01f, 2.23570433e-03f, 5.65203615e-02f, -1.97073340e-01f, 9.20626298e-02f, 1.82476625e-01f,
  5.65822311e-02f, -1.03873618e-01f, -4.55722302e-01f, -5.16749732e-02f, -2.04054475e-01f, -3.23672682e-01f, 3.66762042e-01f, -1.12620398e-01f, -1.09115697e-01f, 1.44332781e-01f,
  6.87399879e-02f, -1.24204466e-02f, -4.33699600e-02f, -2.06318468e-01f, -3.46125588e-02f, -2.21348837e-01f, -2.16546565e-01f, -9.46725979e-02f, -1.32730380e-01f, 1.65850073e-02f,
  -1.91342056e-01f, -1.93829581e-01f, 1.24241717e-01f, 1.52684331e-01f, 5.71945012e-02f, 1.50790736e-01f, 1.05245419e-01f, 5.48962913e-02f, -1.56484187e-01f, -7.52343833e-02f,
  -5.76084778e-02f, 1.09578878e-01f, -5.28114988e-03f, -1.84411854e-01f, -2.70138174e-01f, 1.88909769e-01f, 6.22051284e-02f, 2.20655464e-03f, -1.94495231e-01f, -2.58233659e-02f,
  -4.17488813e-02f, 2.11374044e-01f, -1.30502790e-01f, -4.87674214e-02f, -4.66898680e-02f, 1.70445934e-01f, -1.08168289e-01f, 2.35538241e-02f, -1.06654562e-01f, 1.61275212e-02f,
  3.20544653e-02f, 1.35851249e-01f, -1.69180650e-02f, -4.14477050e-01f, 4.32487950e-02f, 2.27012970e-02f, 1.19531132e-01f, 3.32559556e-01f, 3.89891975e-02f, 3.63238214e-04f,
  2.44957600e-02f, 1.13798663e-01f, 2.99499899e-01f, 8.23177323e-02f, -7.77894929e-02f, 5.29001318e-02f, 3.15705866e-01f, 1.77060310e-02f, 2.56227523e-01f, -1.97073072e-01f,
  -1.50364125e+00f, 1.99063167e-01f, -1.24153817e+00f, -8.19153249e-01f, -4.63023447e-02f, -8.92741442e-01f, -4.77805585e-01f, -1.20922097e-03f, -3.80353965e-02f, 7.16690898e-01f,
  2.71438748e-01f, -5.49596846e-01f, 8.57714951e-01f, -6.46467924e-01f, -1.06344986e+00f, 1.88559264e-01f, -1.09634662e+00f, -4.51223075e-01f, 1.21777482e-01f, -5.07487237e-01f,
  -4.39392000e-01f, 8.16474035e-02f, -3.30233812e-01f, 7.41277695e-01f, -7.68333077e-01f, 1.26003221e-01f, 5.55031776e-01f, 6.08810484e-01f, -5.39885998e-01f, 6.25812933e-02f,
  -6.71384037e-01f, 1.24819092e-01f, -9.09975544e-02f, -1.62533104e-01f, -2.69660413e-01f, 1.27372637e-01f, -1.23554841e-01f, 3.05212718e-02f, 8.13752562e-02f, -2.11461335e-02f,
  -8.41678828e-02f, 1.16787143e-01f, -1.91813156e-01f, 3.51499736e-01f, 8.70707631e-02f, -1.22564938e-02f, -6.97775334e-02f, -3.16972136e-01f, 5.94108142e-02f, -2.23386213e-01f,
  -2.26093307e-01f, -1.17263377e-01f, -2.35689849e-01f, 1.28278181e-01f, -3.04959327e-01f, -2.17045154e-02f, -1.06585093e-01f, -7.91394338e-02f, -3.77828062e-01f, -6.12785891e-02f,
  -6.57562539e-02f, 2.02310812e-02f, -8.95857885e-02f, -2.70544104e-02f, -8.79828259e-02f, 1.24957696e-01f, 8.97358172e-03f, 2.06860110e-01f, -3.57645154e-02f, 7.27012604e-02f,
  -1.66540340e-01f, 2.20724363e-02f, 1.47640422e-01f, -9.90584642e-02f, -9.90483090e-02f, -1.82095580e-02f, -8.33194554e-02f, 4.30651568e-02f, -1.33285999e-01f, -1.48941234e-01f,
  2.83274055e-02f, -1.17213726e-01f, 2.51947939e-01f, -4.39288281e-02f, -1.40777066e-01f, 1.34248644e-01f, 5.31415343e-02f, -6.12899214e-02f, -6.92896545e-02f, -1.37845263e-01f,
  -6.87101543e-01f, -7.05108941e-02f, -1.04044033e-02f, 1.82282310e-02f, -1.07987314e-01f, -7.29772449e-02f, -1.22919664e-01f, -9.09274668e-02f, -1.31095096e-01f, 3.15417796e-02f,
  1.32471576e-01f, 8.09937567e-02f, -2.77769357e-01f, 6.91740448e-03f, -3.97778302e-02f, -6.85916319e-02f, 2.83393054e-03f, 2.85459403e-03f, -1.54667452e-01f, 5.31468056e-02f,
  1.68962777e-02f, 7.88185969e-02f, -8.36821198e-02f, -5.47989197e-02f, -5.46096601e-02f, -1.64875779e-02f, -1.23996846e-01f, 2.04889461e-01f, -1.41392127e-01f, 1.54013075e-02f,
  2.68227249e-01f, -1.46553010e-01f, -4.53452796e-01f, 2.60509938e-01f, -1.75940115e-02f, -2.38331571e-01f, -4.42195058e-01f, 4.54460591e-01f, -6.69883430e-01f, 1.37951538e-01f,
  7.62723327e-01f, -4.23576266e-01f, 1.54519141e-01f, 9.66323316e-01f, 5.86702108e-01f, -9.19137523e-02f, 9.82948720e-01f, 2.63125241e-01f, -6.41203150e-02f, 4.60176677e-01f,
  5.40240467e-01f, 1.21498156e+00f, 7.03286231e-01f, 9.68760610e-01f, 6.07727945e-01f, 2.74362952e-01f, 8.49309146e-01f, -6.49661850e-03f, 9.68741179e-01f, 2.07571089e-01f,
  -1.99080929e-01f, 4.20661829e-02f, 4.72268090e-02f, -3.78610522e-01f, 2.92097926e-01f, 1.44301459e-01f, -6.14902973e-02f, -6.64536208e-02f, -2.71889329e-01f, 5.71190030e-04f,
  -2.99997479e-01f, 5.23350351e-02f, 3.80728021e-02f, -8.68017748e-02f, -4.58173081e-02f, -9.11516324e-02f, -2.58782525e-02f, -4.09100503e-02f, -2.27243766e-01f, -8.10558721e-03f,
  -2.44230524e-01f, -3.24554034e-02f, -1.20366216e-01f, 1.00686863e-01f, -9.03899781e-03f, -2.69121617e-01f, -2.27809921e-01f, 7.33916536e-02f, -1.56837344e-01f, 2.19624966e-01f,
  2.88438112e-01f, -8.73469785e-02f, -8.19273964e-02f, -1.69468373e-01f, 5.39801717e-02f, -4.66368794e-02f, -5.89227527e-02f, 1.11723229e-01f, 7.55058974e-03f, 6.96028396e-02f,
  6.97054490e-02f, 2.16692239e-02f, 3.38228606e-02f, -1.33717760e-01f, -6.40221220e-03f, -1.73623040e-01f, -8.89639631e-02f, 1.25701785e-01f, -5.97941980e-04f, 2.93454845e-02f,
  4.13893759e-02f, -8.45893770e-02f, 1.56389959e-02f, 5.78302816e-02f, -2.03837752e-01f, 8.16806182e-02f, 1.31290287e-01f, -7.99247026e-02f, -1.43917561e-01f, 7.93887749e-02f,
  1.85214549e-01f, 5.75807571e-01f, -5.18439189e-02f, -2.93378890e-01f, -1.02012753e-02f, 1.03255443e-01f, 1.91789190e-03f, 1.66647062e-02f, 8.45778883e-02f, 8.32246393e-02f,
  3.61592591e-01f, -4.02236283e-02f, -1.34826764e-01f, 3.31520401e-02f, 3.16374153e-02f, 2.64464110e-01f, 9.44889858e-02f, -4.59346995e-02f, 2.27952033e-01f, 4.18001771e-01f,
  1.10902369e-01f, -2.18686927e-02f, 1.02580644e-01f, -2.13780195e-01f, -6.21288419e-02f, 1.04920089e-01f, 4.28753383e-02f, -2.76595503e-02f, 2.27711484e-01f, -1.00274486e-02f,
  -2.10290289e+00f, -1.71097845e-01f, 6.67329788e-01f, -1.10507262e+00f, 1.45590901e-01f, 9.27355111e-01f, 7.90197589e-03f, -9.13909599e-02f, -8.15334797e-01f, -3.06787729e-01f,
  -7.81234428e-02f, -4.55021977e-01f, 1.76200226e-01f, 1.96713790e-01f, 7.15085208e-01f, 2.16792554e-01f, -2.81519257e-03f, -2.31163323e-01f, -3.85851376e-02f, -3.49823117e-01f,
  -2.68922329e-01f, -7.83282891e-02f, 5.59513628e-01f, 2.44044393e-01f, 6.19812943e-02f, -2.16102093e-01f, 9.29191709e-02f, 3.30563903e-01f, 2.73020983e-01f, 2.96367437e-01f,
  -2.18437836e-01f, -6.82391405e-01f, -2.91948449e-02f, 2.39931896e-01f, 8.87715146e-02f, -6.96664527e-02f, 1.91899180e-01f, 2.43136182e-01f, -6.42241240e-02f, 6.56111725e-03f,
  -1.40581429e-01f, 8.25066939e-02f, -1.76867768e-01f, 7.77845308e-02f, -1.78544953e-01f, -2.38996241e-02f, 2.13781476e-01f, 3.47516797e-02f, 7.11873099e-02f, 1.72845989e-01f,
  6.84127510e-02f, 1.20291427e-01f, 3.75472978e-02f, 3.55512579e-03f, 6.34118840e-02f, -8.27220902e-02f, 1.07912265e-01f, 6.58185035e-02f, 1.86357517e-02f, -1.23646393e-01f,
  1.36539951e-01f, 8.40123519e-02f, -4.13904749e-02f, 1.34893246e-02f, -6.54584691e-02f, 3.47119235e-02f, 4.27406617e-02f, 3.19985859e-02f, -5.78258783e-02f, -3.41454940e-03f,
  -2.02645108e-01f, -1.89493477e-01f, -2.63224472e-03f, -8.39978456e-02f, -1.46773577e-01f, -1.67730659e-01f, 1.04898758e-01f, -9.42631364e-02f, -1.20820276e-01f, 2.76168324e-02f,
  -1.24984995e-01f, 6.34734929e-02f, -1.90490335e-01f, 7.57825673e-02f, 1.53249670e-02f, -5.19221947e-02f, -8.97775069e-02f, 5.50446147e-03f, -7.85451755e-03f, 1.68295264e-01f,
  -6.60665691e-01f, -7.28651941e-01f, -2.01193348e-01f, -3.85841690e-02f, -4.69969250e-02f, 1.28855482e-01f, -1.04604326e-01f, -5.10223396e-02f, -8.46722629e-03f, -1.38771042e-01f,
  6.46674111e-02f, -5.58182187e-02f, -1.88662345e-03f, -3.67003828e-02f, 9.05578956e-02f, 2.10561808e-02f, -2.04836547e-01f, -2.04577982e-01f, -1.57256573e-01f, 6.23698384e-02f,
  -3.80470455e-02f, -2.28274718e-01f, 9.29874480e-02f, -6.37780353e-02f, -1.11567171e-03f, -9.75151584e-02f, -1.67443290e-01f, 1.03955030e-01f, -1.93107105e-03f, 1.14801034e-01f,
  1.09102443e-01f, -1.48792338e+00f, -7.75438011e-01f, 7.51948077e-03f, 9.98695374e-01f, 7.30847418e-01f, 4.42609042e-01f, -1.83765188e-01f, -5.29900610e-01f, -4.60197330e-01f,
  -4.39825319e-02f, -5.45743942e-01f, -9.11495090e-01f, -3.42035800e-01f, 5.88150859e-01f, -8.42499256e-01f, 2.53832936e-01f, -3.93126719e-02f, -5.05401969e-01f, 8.37914199e-02f,
  1.28168166e-01f, 2.77026981e-01f, -2.98570931e-01f, 2.53576040e-01f, 1.67635277e-01f, 3.21478158e-01f, 8.24266553e-01f, 2.10628986e-01f, 5.09505689e-01f, 2.84916967e-01f,
  -8.85391422e-03f, -4.04042184e-01f, -1.00653566e-01f, -2.15862185e-01f, 3.52163315e-01f, 4.18878376e-01f, 5.41025698e-01f, 1.79039538e-01f, 1.52942598e-01f, -1.47835180e-01f,
  -3.45435925e-02f, 1.94005728e-01f, 2.67248740e-03f, -1.96702965e-03f, -4.98182625e-02f, -4.32702675e-02f, -5.90815954e-02f, -2.86518246e-01f, -8.84519815e-02f, -2.93499142e-01f,
  -3.09472829e-01f, -2.37987250e-01f, -1.87315848e-02f, -1.85360759e-02f, -2.60711219e-02f, -9.28194076e-02f, 1.36007369e-01f, 1.09218352e-01f, -6.47837222e-02f, 3.03261012e-01f,
  9.13180709e-02f, 5.96962944e-02f, -1.48258626e-01f, -2.99203783e-01f, -8.07277411e-02f, 1.36336029e-01f, -5.94272986e-02f, -3.09807062e-02f, -7.85038099e-02f, 2.95259282e-02f,
  2.46420160e-01f, -5.33979051e-02f, 2.48608198e-02f, 6.35763481e-02f, -1.53511148e-02f, 5.89660602e-03f, 1.74995214e-01f, 1.85153887e-01f, 1.96834281e-01f, -1.96259469e-01f,
  -2.59437952e-02f, 1.28094226e-01f, 8.33238214e-02f, 1.66756645e-01f, -1.64102033e-01f, -1.05796762e-01f, -3.24498340e-02f, -1.24836713e-01f, -2.41001192e-02f, 1.39580080e-02f,
  -1.51725665e-01f, -1.60685927e-01f, -2.25884750e-01f, -4.23001498e-02f, -1.32234827e-01f, 9.63774100e-02f, -2.96701014e-01f, -1.31534010e-01f, 1.36314198e-01f, 7.59819224e-02f,
  4.83999610e-01f, 2.48491406e-01f, 2.25242436e-01f, 4.98867780e-03f, 1.17999479e-01f, 6.10382296e-02f, 1.56820118e-01f, 2.77747065e-01f, 2.31698439e-01f, 1.22777030e-01f,
  1.14207670e-01f, 3.64759594e-01f, 4.70126607e-02f, 9.24520642e-02f, 2.23057866e-02f, 3.10567528e-01f, 2.46121928e-01f, -5.22961356e-02f, 1.34902331e-03f, -7.99668655e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 10)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 10;
const float L0_fan_Bp_bar_data[] = {
  1.33370018e+00f, 1.39058971e+00f, 8.33037078e-01f, 6.05170608e-01f, 1.30453932e+00f, 2.59396791e-01f, 1.09575224e+00f, 9.08594489e-01f, 8.58005285e-01f, 1.39630079e+00f
};

// L1_linear_W (Shape: 12 x 16)
const int L1_linear_W_rows = 12;
const int L1_linear_W_cols = 16;
const float L1_linear_W_data[] = {
  5.76834261e-01f, -6.03205204e-01f, -1.42199492e+00f, -5.78392327e-01f, 6.03617251e-01f, -4.53304708e-01f, -1.55681825e+00f, 8.17713797e-01f, -8.59932005e-01f, 1.05326867e+00f,
  -1.39056373e+00f, -6.12120092e-01f, 1.77873090e-01f, 3.29333404e-03f, 3.20399314e-01f, -1.77061093e+00f, -1.02477205e+00f, 8.72894466e-01f, 3.46526682e-01f, 1.72762871e+00f,
  1.43155003e+00f, -1.08805764e+00f, -9.78649199e-01f, 1.01883614e+00f, -2.72797137e-01f, -1.07289493e+00f, -9.47047845e-02f, 2.82364581e-02f, -1.57498515e+00f, 4.48779970e-01f,
  -6.56829596e-01f, 6.24947958e-02f, 4.61228155e-02f, 4.24922407e-01f, 2.33097419e-01f, 1.20960867e+00f, 9.47734952e-01f, 3.98025930e-01f, -1.33491516e+00f, -1.62727106e+00f,
  -1.18439639e+00f, -4.25838917e-01f, -1.34678340e+00f, -3.14550430e-01f, -9.51008677e-01f, 3.23016375e-01f, 4.06736553e-01f, 1.27649486e+00f, -7.96666384e-01f, -1.03380370e+00f,
  1.31011516e-01f, -4.48615462e-01f, 3.75593007e-01f, 9.31640923e-01f, -4.00784224e-01f, -8.58775750e-02f, -2.88104713e-01f, -7.18329430e-01f, 1.45471618e-01f, -9.71202135e-01f,
  1.41847205e+00f, -1.29771197e+00f, -2.02359766e-01f, -2.04663682e+00f, 6.43251479e-01f, -4.57923919e-01f, 1.25774097e+00f, -1.48361397e+00f, 1.38142002e+00f, 4.73212510e-01f,
  2.60090888e-01f, -4.59605962e-01f, 3.47730428e-01f, -4.17616725e-01f, -9.64555964e-02f, 3.01885515e-01f, -2.26543412e-01f, -3.08315977e-02f, 1.51374936e+00f, -1.21282327e+00f,
  1.12128139e+00f, 7.97773525e-02f, -2.74521410e-01f, 1.09202750e-01f, -1.61020660e+00f, -9.79537904e-01f, -6.20255351e-01f, 4.05340791e-01f, 1.49799287e+00f, 3.32233876e-01f,
  -1.33865798e+00f, 6.38486207e-01f, -1.05841768e+00f, -9.61844206e-01f, -1.30317700e+00f, -3.40361893e-01f, -3.41941833e-01f, -9.12706435e-01f, 8.03981364e-01f, 1.36958301e+00f,
  -1.12273037e+00f, -9.60859776e-01f, 1.45463657e+00f, -7.28043735e-01f, -5.68915486e-01f, -1.44117630e+00f, -1.19527638e+00f, -6.65061414e-01f, -3.15791488e-01f, -7.00477540e-01f,
  -1.63145971e+00f, 4.15743679e-01f, -1.77631259e-01f, 4.44627255e-02f, -7.05053508e-01f, 3.07518572e-01f, -2.15389207e-01f, 6.87958062e-01f, -2.03463212e-01f, -1.54725945e+00f,
  -1.77669786e-02f, 6.91548944e-01f, -4.11122888e-01f, 9.33883369e-01f, 6.65390909e-01f, -5.93149960e-01f, -1.04785609e+00f, -1.02699518e+00f, -5.14101803e-01f, 3.32722813e-02f,
  2.73803383e-01f, -1.32950938e+00f, -1.16292429e+00f, -8.89524966e-02f, -6.10257924e-01f, -1.23912847e+00f, -2.80424178e-01f, -6.32878900e-01f, -2.50375122e-01f, -2.51466811e-01f,
  -3.63917470e-01f, 1.35127127e+00f, -9.45051789e-01f, -5.87153077e-01f, -1.86651945e-04f, 6.00337625e-01f, -5.68939328e-01f, 1.17659710e-01f, -4.95560497e-01f, -2.39726171e-01f,
  4.91382837e-01f, -1.24313259e+00f, -1.35525680e+00f, 1.29263556e+00f, -8.96609247e-01f, 3.11725765e-01f, -1.22768438e+00f, -6.03970110e-01f, 2.65361637e-01f, 4.35912162e-01f,
  4.73876417e-01f, 6.51948452e-01f, -8.83333206e-01f, -6.22654855e-01f, 4.58621532e-01f, 7.19229400e-01f, -9.34988856e-01f, 4.06803131e-01f, -1.08762872e+00f, -9.11349058e-01f,
  5.74198008e-01f, -1.05000067e+00f, 2.23837957e-01f, -4.63327020e-01f, -2.87426740e-01f, 7.93861151e-01f, 5.44996202e-01f, -4.81004119e-01f, 8.22999358e-01f, -7.05939829e-01f,
  -9.26603675e-01f, 1.95656508e-01f, 1.00263231e-01f, -7.26051390e-01f, 2.03875721e-01f, -6.96028054e-01f, 1.42698205e+00f, -1.21065462e+00f, -1.41538179e+00f, -1.09817886e+00f,
  -1.16469479e+00f, -1.00103080e+00f
};

// L1_linear_B (Shape: 1 x 12)
const int L1_linear_B_rows = 1;
const int L1_linear_B_cols = 12;
const float L1_linear_B_data[] = {
  -1.08104676e-01f, -2.54036605e-01f, -9.41421539e-02f, -3.19879860e-01f, -1.89883217e-01f, 4.00488406e-01f, 7.35265732e-01f, -7.57208586e-01f, 2.23809004e-01f, -4.11371946e-01f,
  -3.54876965e-01f, 2.15915725e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 3, 10
    );
    
    // Camada 1: L1_linear
    linear_forward_pgm(
        buffer1, x_out,
        L1_linear_W_data, L1_linear_B_data,
        16, 12
    );
    }
    