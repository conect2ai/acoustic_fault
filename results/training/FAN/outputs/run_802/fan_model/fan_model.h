/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 16 (x3)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 16;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    return (x > 0.0f) ? x : 0.0f;
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 6 x 120)
const int L0_fan_Wp_rows = 6;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  2.09543183e-01f, -5.74431181e-01f, -1.82421565e-01f, -2.10106403e-01f, -8.16564560e-02f, 2.13035181e-01f, -3.74688447e-01f, 1.84835140e-02f, 1.65577129e-01f, -2.24452555e-01f,
  -9.15970281e-02f, 2.89596766e-01f, 1.49278551e-01f, 2.19475359e-01f, -1.56949665e-02f, -1.72604531e-01f, -3.77376914e-01f, -5.60119376e-02f, 3.95025343e-01f, 1.13735862e-01f,
  -5.79616763e-02f, -1.78887486e-01f, -4.60772291e-02f, 6.72242865e-02f, -3.71678293e-01f, 4.61434692e-01f, -1.05724551e-01f, -1.13520131e-01f, 1.66923389e-01f, -6.86131537e-01f,
  1.73480436e-02f, -2.00204104e-01f, 1.43140718e-01f, 4.99679558e-02f, -4.77595143e-02f, 5.08982874e-02f, 7.94465095e-02f, -9.33891088e-02f, 6.87382966e-02f, -1.30762840e-02f,
  2.88910628e-03f, 9.66260303e-03f, -4.47333567e-02f, 3.58361332e-03f, -1.21327370e-01f, -5.11332713e-02f, -7.89059401e-02f, -8.60978216e-02f, -4.97373082e-02f, -3.65910605e-02f,
  -1.09786451e-01f, -7.72553533e-02f, -1.16906993e-01f, 8.95316005e-02f, -1.10949855e-02f, 6.08193018e-02f, -8.60521123e-02f, 1.72306783e-02f, -3.54699255e-03f, -7.82287493e-03f,
  4.59484793e-02f, 3.10442671e-02f, 3.32279783e-03f, -2.83785979e-03f, 1.23105971e-02f, 5.58739156e-03f, -1.80790592e-02f, -4.26882319e-03f, -1.82940811e-02f, 7.22158141e-03f,
  8.78417492e-03f, -3.64205390e-02f, -7.13088783e-03f, -2.27125045e-02f, 3.49313356e-02f, -2.65935343e-02f, -1.66543238e-02f, 7.44353514e-04f, 3.75003405e-02f, 1.46552818e-02f,
  1.33601138e-02f, -3.63800384e-04f, -2.93190889e-02f, -4.61705551e-02f, -1.99237484e-02f, 2.27978397e-02f, -1.57616455e-02f, -1.57456510e-02f, 2.29561739e-02f, 3.72833759e-02f,
  8.82140025e-02f, 8.44731256e-02f, -2.86584366e-02f, -3.20870318e-02f, 2.53286920e-02f, -1.82439573e-03f, -6.55131042e-02f, 4.07243520e-02f, -5.39256521e-02f, -1.64868291e-02f,
  -6.40614331e-02f, 4.07560728e-02f, -2.63809562e-02f, 3.50644328e-02f, 4.35704216e-02f, 6.38099387e-02f, -3.65822464e-02f, 2.45672073e-02f, 2.87081432e-02f, -9.76259541e-03f,
  -2.88234297e-02f, 1.38478383e-01f, 1.84061944e-01f, 4.93686981e-02f, 4.30760868e-02f, 1.05209611e-01f, 5.21755815e-02f, 8.31756666e-02f, 1.14117838e-01f, 1.88651741e-01f,
  1.85553908e-01f, -9.39920172e-02f, -1.35145977e-01f, -3.81197548e-04f, -2.43401945e-01f, -1.29514948e-01f, -2.59404480e-01f, 8.99659023e-02f, 1.21231504e-01f, -1.96750432e-01f,
  -9.94109139e-02f, -1.12997545e-02f, -8.54270607e-02f, -6.00285046e-02f, 6.39263075e-03f, -1.33157507e-01f, -1.25772819e-01f, -1.46450065e-02f, -3.19067501e-02f, 5.38403029e-03f,
  -1.44584505e-02f, -9.58149955e-02f, 2.04768643e-01f, 1.33635297e-01f, -1.08220503e-01f, -1.90219000e-01f, -1.35355949e-01f, -1.20676858e-02f, 4.25458513e-02f, -2.85205361e-03f,
  -1.31427854e-01f, -2.94962861e-02f, -2.59141298e-03f, 1.20631099e-01f, -3.96980047e-02f, 1.30341500e-01f, -4.81655188e-02f, -8.98171216e-03f, -2.92447656e-02f, 8.88544414e-03f,
  8.92667286e-03f, 1.27121225e-01f, 1.86540093e-02f, 4.91603054e-02f, -3.78306508e-02f, -1.16542522e-02f, 9.88265052e-02f, 8.59481171e-02f, 9.52719059e-03f, -1.97442006e-02f,
  3.36867617e-03f, 9.99661349e-03f, -8.57642666e-02f, 3.25425901e-02f, -3.02790273e-02f, -1.35733053e-01f, 1.20703643e-02f, 3.18757482e-02f, 2.23024492e-03f, 1.62605420e-02f,
  3.47438306e-02f, -1.22177163e-02f, -6.67236149e-02f, 5.03669307e-02f, 7.61206374e-02f, 8.43542255e-03f, 8.94178227e-02f, 3.98266874e-02f, -2.00605784e-02f, -1.69628896e-02f,
  3.55638154e-02f, -4.18037288e-02f, 5.66675216e-02f, -3.08166025e-03f, -6.78133368e-02f, 1.84764955e-02f, 1.37414141e-02f, 5.74708059e-02f, 2.45921947e-02f, 7.01040849e-02f,
  1.94616988e-02f, 8.10601041e-02f, -8.73895362e-03f, 1.18101798e-01f, -8.82301554e-02f, 3.55889127e-02f, -5.71728460e-02f, -5.84653243e-02f, -9.97727737e-02f, -5.13390750e-02f,
  1.44826910e-02f, -5.09253889e-02f, 1.43216476e-02f, 1.97950937e-02f, -1.21231852e-02f, 8.87255743e-02f, -5.70514202e-02f, 1.76337250e-02f, 3.76705304e-02f, 2.89450190e-03f,
  -2.76045762e-02f, -1.47639366e-03f, -5.60428686e-02f, 1.56033942e-02f, -8.48137513e-02f, 1.97965801e-02f, 1.06685841e-02f, -8.41486380e-02f, 2.90588066e-02f, -7.68282730e-03f,
  3.81821729e-02f, -6.37886450e-02f, -1.47202030e-01f, 4.91861999e-03f, -2.55686548e-02f, -1.10462978e-01f, -1.04497865e-01f, -6.68046027e-02f, -1.15454637e-01f, -1.41415685e-01f,
  1.50238359e-02f, -1.48584932e-01f, -4.17698383e-01f, 3.70393425e-01f, 3.02759588e-01f, -1.01911746e-01f, -2.93463051e-01f, -1.63191199e-01f, 1.35275528e-01f, 6.28152862e-02f,
  -1.23055121e-02f, 1.76644772e-01f, -2.01658815e-01f, -3.55649404e-02f, -3.04211229e-01f, 3.05200033e-02f, 1.59180835e-01f, -1.60115540e-01f, -1.90356404e-01f, -1.28095029e-02f,
  3.15121979e-01f, 1.79837823e-01f, 2.47417707e-02f, -1.43830553e-01f, 3.17839801e-01f, 1.62535936e-01f, -5.75219244e-02f, 1.72939032e-01f, 4.50940989e-02f, 4.55881029e-01f,
  -1.80427015e-01f, -1.65350869e-01f, 4.39909250e-02f, 1.46768183e-01f, -3.25714797e-02f, -6.58191592e-02f, 1.32684223e-02f, -9.69147757e-02f, 3.73152085e-02f, 1.65335229e-03f,
  1.18781090e-01f, -3.50677036e-02f, 6.91690519e-02f, 4.21494544e-02f, -3.03834584e-02f, 1.53511791e-02f, -1.18970342e-01f, -9.20529366e-02f, -1.03066951e-01f, -1.00190744e-01f,
  1.84547976e-01f, 1.11482978e-01f, -9.48457718e-02f, -1.14579469e-01f, -1.58995494e-01f, 3.96222547e-02f, -8.78290161e-02f, 5.92113435e-02f, -1.65355057e-01f, 7.53179714e-02f,
  -1.34352632e-02f, -2.80109830e-02f, -6.28148392e-03f, -3.58856544e-02f, 2.24858709e-02f, 5.58359325e-02f, -6.35923166e-03f, -2.32996361e-04f, -5.46704829e-02f, 6.72353655e-02f,
  2.11315136e-02f, -3.53519730e-02f, -9.10039898e-03f, -6.20020367e-02f, 7.29499236e-02f, -2.25007478e-02f, 7.52236182e-03f, -5.04674949e-02f, 2.33574640e-02f, 5.70524205e-03f,
  4.67552745e-04f, 1.94207323e-03f, 5.68080507e-02f, -6.44567311e-02f, 2.98439860e-02f, -6.09704070e-02f, 2.70570070e-02f, 1.06146913e-02f, -5.47269508e-02f, 1.08104788e-01f,
  6.90695718e-02f, -1.47769555e-01f, 9.01710391e-02f, -1.27291158e-01f, 3.22275199e-02f, -2.24491991e-02f, 1.48098441e-02f, 3.62009043e-03f, 2.83677671e-02f, -7.25630969e-02f,
  -3.54693346e-02f, -6.75799474e-02f, -1.11443855e-01f, -1.42894695e-02f, 1.74444057e-02f, 6.03897981e-02f, 7.02975020e-02f, 9.29517113e-03f, 3.32954600e-02f, 2.36911662e-02f,
  -9.40326136e-03f, 3.84830795e-02f, 8.40235949e-02f, -7.35543494e-04f, 1.05090670e-01f, 1.13289639e-01f, 2.70444388e-03f, 6.46969453e-02f, -2.41360907e-02f, 5.85179850e-02f,
  2.83522010e-01f, -2.05142289e-01f, 3.68707955e-01f, 9.52912420e-02f, 8.38923976e-02f, -2.09932059e-01f, 1.90425128e-01f, 6.89162463e-02f, -2.18676239e-01f, 6.04956709e-02f,
  -6.41845539e-02f, -1.42187983e-01f, -3.96339968e-02f, -1.22853473e-01f, 2.27345929e-01f, 2.86420304e-02f, 3.35115224e-01f, 2.74555624e-01f, 2.03502700e-01f, 6.52750134e-02f,
  -1.23194769e-01f, 1.52354062e-01f, 1.26709044e-01f, 6.26424104e-02f, 2.59540565e-02f, -1.12929367e-01f, 5.05660400e-02f, -2.42665899e-03f, -2.04112470e-01f, 3.38469148e-01f,
  8.89945403e-02f, 1.10680997e-01f, 1.92506425e-02f, -5.24882302e-02f, 2.42493320e-02f, -2.97281705e-02f, 5.36374226e-02f, 1.07917801e-01f, -6.33441061e-02f, 1.50793390e-02f,
  -4.98672435e-03f, -8.36230814e-02f, 5.14478572e-02f, -1.45770563e-02f, 8.75191540e-02f, 7.88261816e-02f, -5.84632829e-02f, 1.21486776e-01f, 2.09308136e-02f, 7.06901820e-03f,
  -1.14772022e-01f, 5.61346672e-03f, 8.40282440e-02f, -6.79084510e-02f, 1.06244199e-02f, 3.55399400e-02f, -4.15557139e-02f, 1.23734109e-01f, 1.01947859e-02f, -1.31547246e-02f,
  -6.75018039e-03f, 5.75173693e-03f, -3.32220159e-02f, 2.06604395e-02f, -3.19912061e-02f, -2.14353744e-02f, 1.56207969e-02f, -2.74027493e-02f, -9.98267345e-03f, 1.60544626e-02f,
  1.11585658e-03f, 1.36434492e-02f, 1.90374032e-02f, 9.38889384e-03f, 1.67453885e-02f, -6.40396960e-03f, 1.49735194e-02f, 8.29659286e-04f, -1.89182255e-02f, -1.82613768e-02f,
  9.49122477e-04f, 8.24529305e-03f, -1.08576510e-02f, 1.08747641e-02f, 2.60488354e-02f, 3.89414728e-02f, 1.45795895e-02f, 3.59682320e-03f, -5.95815629e-02f, 7.14810342e-02f,
  -2.14407116e-01f, 5.86951114e-02f, -1.41883059e-03f, 1.13919154e-02f, -4.34313193e-02f, -8.06727111e-02f, -1.95161793e-02f, -4.90736589e-02f, -1.33094070e-02f, -2.55245753e-02f,
  2.88202334e-02f, 5.73413400e-03f, -5.08753117e-03f, -1.96056068e-02f, -9.74892732e-03f, -4.71036471e-02f, -8.59276205e-02f, -9.67665401e-04f, -2.00176034e-02f, 4.48910929e-02f,
  -2.90926900e-02f, -4.07884866e-02f, -8.38811547e-02f, -7.57971033e-02f, -4.18314412e-02f, 2.82803047e-02f, -3.25548910e-02f, -7.31246918e-02f, -1.08707491e-02f, -2.30161905e-01f,
  4.48747128e-01f, -1.72134891e-01f, -1.27481878e-01f, 1.13216460e-01f, -5.29905915e-01f, -2.81120360e-01f, -6.29164457e-01f, -7.59750009e-02f, 1.37042552e-01f, -1.59066841e-01f,
  -5.06639630e-02f, 2.92919070e-01f, 2.23255947e-01f, 2.45398000e-01f, 7.37822279e-02f, -2.17871621e-01f, -2.33235106e-01f, 1.69246122e-01f, 1.45288065e-01f, 6.15929626e-02f,
  -1.75303351e-02f, -7.74296820e-02f, 2.32828036e-01f, 4.40392457e-02f, -4.61401492e-02f, 1.62649766e-01f, -1.88652486e-01f, -6.20223880e-02f, 1.17003061e-01f, 1.67725250e-01f,
  2.27970690e-01f, 2.62784772e-02f, -1.45973014e-02f, 1.99130382e-02f, -2.23189797e-02f, 8.06422830e-02f, 2.78048161e-02f, 4.53431159e-02f, 9.42527037e-03f, -3.80857140e-02f,
  -2.23491658e-02f, 2.27359608e-02f, -6.70034513e-02f, 1.73886437e-02f, -1.24599494e-01f, 6.59486502e-02f, -6.62183836e-02f, 1.06799372e-01f, 1.27208009e-02f, 3.85472924e-02f,
  2.20488869e-02f, 7.93229416e-03f, -2.13974655e-01f, -1.20676965e-01f, 3.90276639e-03f, 3.31472984e-04f, -9.55204889e-02f, 1.28240496e-01f, -4.23287489e-02f, 2.36801520e-01f,
  -5.81410481e-03f, 1.48205869e-02f, -1.68620385e-02f, 2.14025229e-02f, -4.25981358e-02f, -4.23742319e-03f, 6.98331604e-03f, -1.82140414e-02f, -2.49388125e-02f, 5.13513461e-02f,
  1.09987184e-02f, 9.26640909e-03f, -5.84974624e-02f, 1.10198706e-02f, 6.97573870e-02f, -8.29023495e-02f, -2.35559493e-02f, 1.48943411e-02f, 2.95514939e-03f, -7.35645462e-03f,
  6.61786124e-02f, -5.84104806e-02f, -3.74152977e-03f, -6.46884218e-02f, 4.91540171e-02f, -8.99968296e-03f, -1.11316536e-02f, 4.17824648e-03f, -2.03657383e-03f, 8.64230841e-02f,
  8.81040748e-03f, -1.95820723e-02f, 1.59287572e-01f, 3.12180053e-02f, -3.09903454e-02f, 4.80710436e-03f, 5.32835610e-02f, 9.79761127e-03f, -2.63975002e-02f, -2.80347615e-02f,
  -4.85740341e-02f, 4.06231880e-02f, -2.83075515e-02f, 8.64187479e-02f, 1.85275581e-02f, -4.37635705e-02f, 3.59699083e-03f, -4.48632501e-02f, -1.71284489e-02f, 3.28300446e-02f,
  -4.39929254e-02f, -2.00202428e-02f, 2.92678736e-02f, 7.11397966e-04f, -9.80046671e-03f, 3.61264348e-02f, -3.55494507e-02f, 5.50262146e-02f, -1.21955059e-01f, -7.76993260e-02f,
  -3.22023064e-01f, 4.18464020e-02f, 3.66280317e-01f, -5.63472398e-02f, 7.38820806e-02f, 3.69433202e-02f, -7.09202588e-02f, -7.73203447e-02f, -2.18546893e-02f, 2.35113055e-02f,
  5.49490564e-02f, -8.72280970e-02f, -1.21521465e-01f, -6.44373894e-02f, -1.15777649e-01f, 5.00518680e-02f, 6.98228627e-02f, 7.89091289e-02f, 5.77674210e-02f, 3.52238789e-02f,
  1.57151259e-02f, -3.86241078e-02f, -1.61591187e-01f, -1.20197974e-01f, 1.17336482e-01f, 8.49418938e-02f, 9.78574902e-02f, 5.91486432e-02f, 1.14142537e-01f, 2.05069304e-01f,
  8.49223882e-02f, -3.77900004e-02f, 7.74595439e-02f, 1.21473065e-02f, 7.55015910e-02f, 1.38187315e-02f, 6.21302165e-02f, 3.68874706e-02f, 4.89619561e-02f, 1.36078214e-02f,
  7.91033432e-02f, 3.07815392e-02f, -8.47183913e-02f, 2.48408653e-02f, -7.98482671e-02f, -9.28972065e-02f, -4.79814261e-02f, -9.58367903e-03f, -4.29272838e-03f, 7.06751719e-02f,
  3.12426668e-02f, 9.95896831e-02f, 8.88113209e-05f, 3.62857878e-02f, 1.08756954e-02f, -2.76743993e-02f, 7.79249379e-03f, 3.54417786e-02f, 4.04708274e-02f, 8.55580717e-02f,
  2.02013683e-02f, 1.15493117e-02f, 2.39021797e-02f, -6.84716739e-03f, -1.78628806e-02f, -8.96029058e-04f, -5.43934628e-02f, 2.04317886e-02f, -3.92202362e-02f, -6.92023337e-02f,
  -1.56988688e-02f, -6.93059107e-03f, -1.86093170e-02f, -1.59167834e-02f, 1.11400582e-01f, -7.89888110e-03f, 3.76834236e-02f, -4.14179601e-02f, -3.79613526e-02f, 5.00932150e-02f,
  -7.55524933e-02f, -5.74268885e-02f, 3.31912525e-02f, -1.72501802e-02f, -7.36514106e-02f, 1.04262106e-01f, 2.85489373e-02f, 2.53582746e-03f, -5.19693233e-02f, 1.61876809e-02f,
  -1.48419023e-01f, 6.44911602e-02f, 9.20196176e-02f, 1.67172663e-02f, -9.56611615e-03f, 3.74845266e-02f, -2.84424610e-02f, 4.89480607e-02f, -2.26150863e-02f, 1.78592699e-03f,
  -1.47886313e-02f, 5.50334379e-02f, -1.93342250e-02f, 5.79461008e-02f, 9.32833087e-03f, 1.34533383e-02f, 1.31079070e-02f, 2.93818917e-02f, -4.30372283e-02f, -1.61436088e-02f,
  -4.98090461e-02f, 3.40924449e-02f, -8.57938007e-02f, -2.14764737e-02f, -7.40456954e-02f, 4.18848619e-02f, -8.13385025e-02f, 8.53182748e-03f, -8.26077163e-02f, -1.37964532e-01f
};

// L0_fan_Wp_bar (Shape: 4 x 120)
const int L0_fan_Wp_bar_rows = 4;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -8.89515132e-02f, 3.59500609e-02f, -2.98053510e-02f, -1.81285530e-01f, 2.61390908e-03f, -1.84222776e-02f, 3.78683135e-02f, -6.82509914e-02f, -7.07251951e-02f, 1.42413154e-01f,
  -3.22146602e-02f, 6.07126765e-02f, 7.96375349e-02f, -4.88013364e-02f, 5.09465560e-02f, 1.50096668e-02f, 8.44291598e-02f, -1.02062494e-01f, -5.98301105e-02f, -8.10626298e-02f,
  -8.83057714e-02f, -1.23397611e-01f, -4.13318947e-02f, -1.01770297e-01f, -5.00117429e-02f, -7.22787455e-02f, 5.06618200e-03f, -7.20393881e-02f, -3.97657380e-02f, -1.01942066e-02f,
  -4.28359024e-02f, -6.23152852e-02f, 2.66180616e-02f, 1.24514833e-01f, 9.60633755e-02f, 1.48482755e-01f, 1.79128237e-02f, 6.76652789e-02f, 1.56549454e-01f, 1.49822310e-02f,
  3.88039113e-03f, 3.59650068e-02f, -6.27066940e-02f, 5.82301803e-02f, 3.44756432e-02f, 7.83964023e-02f, -9.49760247e-03f, -2.44196653e-02f, -7.41728619e-02f, 8.69425088e-02f,
  5.40877543e-02f, -6.88893124e-02f, -1.97901167e-02f, -2.42241216e-03f, -7.14823953e-04f, 3.94716337e-02f, 8.35987553e-02f, 1.17333019e-02f, -8.64238385e-03f, -5.67465415e-03f,
  1.27189904e-01f, 1.03124544e-01f, -1.04211934e-01f, 2.32688673e-02f, -1.12535253e-01f, -1.98293533e-02f, 5.11472300e-03f, -1.46367224e-02f, -2.89441906e-02f, -6.17843717e-02f,
  3.36713940e-02f, 7.83496946e-02f, -8.45322981e-02f, -4.51221541e-02f, 8.80717039e-02f, 3.74028422e-02f, -9.22414940e-04f, 4.22586985e-02f, 2.42259521e-02f, 4.68835048e-02f,
  2.94419546e-02f, -1.02444373e-01f, -2.27024574e-02f, -6.61787167e-02f, -5.43829165e-02f, 4.13933955e-02f, 1.10485166e-01f, 5.92597015e-02f, 3.13657112e-02f, -1.31141255e-02f,
  -7.87641332e-02f, 1.35960430e-01f, -3.04190461e-02f, -1.34690478e-01f, -6.88456520e-02f, 1.15982350e-02f, -4.59418520e-02f, 1.31994570e-02f, 1.60039514e-02f, -2.07536239e-02f,
  -3.28064710e-02f, 4.13374836e-03f, 5.19110681e-03f, 6.27089590e-02f, 1.62116122e-02f, 1.05537763e-02f, 8.49481747e-02f, -1.09196268e-01f, 3.56113240e-02f, 5.77152520e-02f,
  9.12793204e-02f, -8.56026262e-03f, -1.59055054e-01f, -6.43991604e-02f, -1.91920400e-02f, -1.72068868e-02f, -1.13448583e-01f, 1.91474184e-02f, 5.94001263e-02f, 1.16630860e-01f,
  -4.27588731e-01f, -1.76423013e-01f, -3.67862023e-02f, -2.19668925e-01f, -4.78953049e-02f, 1.29268214e-01f, -1.43361762e-01f, 1.66151881e-01f, 5.89263812e-02f, -1.79279715e-01f,
  4.67775986e-02f, -2.51252372e-02f, -7.97167867e-02f, 2.69038454e-02f, -2.00557455e-01f, -1.42479584e-01f, -2.97184914e-01f, -1.59827083e-01f, 4.19147760e-02f, 1.79459378e-01f,
  -5.78707643e-02f, -3.01930904e-01f, -3.01067889e-01f, 1.39988884e-01f, -5.02249897e-02f, -1.81277528e-01f, -1.25657097e-01f, -2.37647951e-01f, 1.93725862e-02f, -4.44596648e-01f,
  -6.20657913e-02f, 1.43100321e-01f, 9.44575965e-02f, -6.95656762e-02f, -6.22851774e-02f, 1.76596008e-02f, 3.54334675e-02f, -5.89961670e-02f, -1.52967162e-02f, 3.36299948e-02f,
  -1.44798011e-02f, 1.15935452e-01f, -6.67711124e-02f, -2.68662069e-02f, -1.01839611e-02f, 6.97381422e-02f, 7.10577667e-02f, 1.56605393e-02f, 4.35795309e-03f, 1.30443767e-01f,
  -2.17583105e-02f, -5.75833432e-02f, -1.52192950e-01f, 1.49840087e-01f, 5.95132075e-02f, 1.20528257e-02f, 5.31272702e-02f, 4.97037023e-02f, 3.17500904e-02f, -2.06585974e-01f,
  -3.65623683e-02f, 4.90694307e-03f, 1.27921402e-02f, -2.92331111e-02f, -3.82799730e-02f, 2.76954621e-02f, -4.29578163e-02f, -1.61364991e-02f, -6.10099845e-02f, -6.21787226e-03f,
  5.15675619e-02f, 4.00991850e-02f, 2.46305801e-02f, -4.84284461e-02f, 5.12360111e-02f, -2.74810586e-02f, -5.19930646e-02f, -5.77692538e-02f, 2.59874202e-02f, -8.00024346e-02f,
  -1.72912399e-03f, -1.98469311e-02f, -2.07651500e-02f, 4.92353775e-02f, 2.51664482e-02f, 2.03692131e-02f, -1.30510200e-02f, 9.45057049e-02f, 7.02809468e-02f, 6.45366609e-02f,
  -2.87232399e-01f, 6.78826496e-02f, -8.74605179e-02f, -1.55391814e-02f, 1.42050087e-02f, -3.78679037e-02f, -2.71042455e-02f, 9.74715687e-03f, 4.54394333e-02f, -4.69076894e-02f,
  5.96996732e-02f, -7.03034401e-02f, -1.29181296e-02f, 4.66220342e-02f, -3.05720866e-02f, 2.23058672e-03f, -1.58840716e-01f, -1.16606340e-01f, -2.76987087e-02f, 1.16772249e-01f,
  -4.55405600e-02f, -1.48795664e-01f, -2.69606948e-01f, -1.78790689e-01f, -6.59925342e-02f, -1.16661698e-01f, -1.17927842e-01f, -1.94973703e-02f, -1.30408064e-01f, -3.77174109e-01f,
  -6.61628127e-01f, -3.13614041e-01f, 1.47255436e-01f, -5.04246294e-01f, 1.73387095e-01f, 1.96695805e-01f, 3.56012791e-01f, 7.79003873e-02f, -1.32721141e-01f, -8.02635774e-02f,
  -1.00962788e-01f, -1.02027088e-01f, -1.00386351e-01f, -5.69788180e-02f, -7.74376048e-03f, 8.97833928e-02f, 2.68563896e-01f, -4.77093160e-02f, 2.85428502e-02f, 7.03858957e-02f,
  3.99606042e-02f, -2.66305119e-01f, -3.68269235e-01f, -1.97277918e-01f, -7.99686536e-02f, 1.88574329e-01f, 3.00579727e-01f, 2.10005813e-03f, 1.63404018e-01f, 6.73580393e-02f,
  1.87444896e-01f, -9.67060477e-02f, 3.62901366e-04f, -8.37485567e-02f, -6.75369240e-03f, 2.48212051e-02f, -3.61524411e-02f, -3.67129371e-02f, -3.60878929e-02f, -1.03388295e-01f,
  -6.71520457e-02f, -6.25797808e-02f, -1.51546121e-01f, -1.51851987e-02f, -1.18190758e-01f, -3.89624126e-02f, 1.06689846e-02f, -6.83155730e-02f, 6.47089928e-02f, 8.44110623e-02f,
  6.46002889e-02f, 9.97971371e-03f, 4.84834090e-02f, 6.84726834e-02f, -1.73627865e-02f, -6.78141862e-02f, -4.88545746e-02f, 7.11318329e-02f, 5.78499697e-02f, 1.38009056e-01f,
  2.89019048e-02f, -1.07621230e-01f, 8.44421312e-02f, -1.78333409e-02f, 3.09627373e-02f, 4.36046422e-02f, 1.67994760e-02f, 1.31207192e-02f, 1.32654952e-02f, 6.83367858e-03f,
  5.54378740e-02f, -1.36963837e-02f, -3.28501537e-02f, -3.44782434e-02f, 1.14064002e-02f, -5.08387536e-02f, -6.48835078e-02f, 5.91430739e-02f, 3.58785689e-02f, -6.38359115e-02f,
  3.30867991e-02f, 8.60065520e-02f, -6.37223348e-02f, -4.57064100e-02f, 7.48716518e-02f, -3.11775431e-02f, -6.83589606e-03f, -5.02860136e-02f, -7.75205391e-03f, -2.73600183e-02f,
  2.62704380e-02f, -7.56194144e-02f, 1.89079493e-02f, 5.38168922e-02f, -1.07438741e-02f, 2.34562568e-02f, -8.22546240e-03f, -1.28736673e-03f, -7.86560178e-02f, 1.26746884e-02f,
  -1.17351627e-02f, 1.03726964e-02f, -7.29274303e-02f, 8.61959457e-02f, -2.32932046e-02f, 2.35725641e-02f, -5.02924174e-02f, -4.90711592e-02f, 1.25016481e-01f, -9.25925467e-03f,
  -5.52687012e-02f, 1.06793426e-01f, 8.54031444e-02f, 9.65884924e-02f, -1.39026949e-02f, 1.81098253e-01f, 7.88988024e-02f, 5.55471443e-02f, 2.54593417e-02f, 1.15267910e-01f,
  3.27922553e-01f, -1.67798206e-01f, -1.62621006e-01f, 2.69033670e-01f, 1.03049159e-01f, 1.33843556e-01f, 6.11111596e-02f, 1.47639111e-01f, 1.63776666e-01f, -7.13056475e-02f,
  1.87533990e-01f, 1.67219654e-01f, 3.39965336e-02f, 1.13438658e-01f, 9.57694203e-02f, -2.21851826e-01f, -3.53739709e-01f, -4.34627049e-02f, 1.40320614e-01f, 1.96825057e-01f,
  1.10615797e-01f, 6.42521679e-02f, 3.02113462e-02f, 6.03862181e-02f, -7.85136148e-02f, 1.28307536e-01f, -2.53102154e-01f, -2.10153073e-01f, -1.10912070e-01f, -3.63209516e-01f,
  -5.12278751e-02f, 7.87722096e-02f, 5.39404824e-02f, 9.75414664e-02f, -3.62729803e-02f, 2.22111866e-02f, 1.40404478e-02f, -2.93905921e-02f, 2.46164156e-03f, -3.05730458e-02f,
  -3.59120965e-02f, 2.04561055e-02f, 3.12739275e-02f, 7.98060093e-03f, 2.30508614e-02f, 1.18488483e-02f, -6.90784305e-02f, -4.03223000e-02f, 3.24522592e-02f, 8.47257376e-02f,
  -6.76068440e-02f, 2.01761462e-02f, 1.09043539e-01f, 7.48385489e-02f, 3.62859890e-02f, 5.68527877e-02f, 1.49493676e-03f, -7.11267395e-03f, -6.01903871e-02f, -6.04382977e-02f,
  -1.31835910e-02f, -1.01114353e-02f, -1.57991797e-02f, 1.43065359e-02f, -2.89404020e-02f, 5.23372600e-03f, -8.60103816e-02f, -3.74871306e-02f, 3.46038416e-02f, -7.47208744e-02f,
  -3.43381055e-02f, 4.97924685e-02f, -4.40758653e-02f, -5.24484850e-02f, -2.79963985e-02f, 2.08411068e-02f, -5.14484681e-02f, 2.03531627e-02f, 2.70561315e-02f, -1.49848498e-03f,
  5.39131742e-03f, -3.45799364e-02f, -1.54712107e-02f, 3.39291664e-03f, -8.16412345e-02f, -3.18170059e-03f, 1.04545899e-01f, 4.23684791e-02f, 1.73215866e-02f, 1.76828040e-03f,
  -3.77208255e-02f, 6.35016710e-02f, 3.84381488e-02f, 7.76142478e-02f, -5.74200712e-02f, -4.91436273e-02f, -3.22873183e-02f, -2.79204436e-02f, 2.40258183e-02f, 9.41216499e-02f,
  1.50916994e-01f, 5.53875342e-02f, -5.35548925e-02f, -9.32954103e-02f, 6.43078312e-02f, 7.66518638e-02f, -1.02202348e-01f, 5.59043065e-02f, 4.87995893e-02f, -4.07646857e-02f,
  -2.02711765e-02f, 6.47875294e-02f, 6.45916387e-02f, -3.34366933e-02f, -9.98756196e-03f, 1.03907287e-01f, 1.59438010e-02f, 1.89242419e-02f, 6.99172691e-02f, -9.60957259e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 4)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 4;
const float L0_fan_Bp_bar_data[] = {
  -6.48470223e-02f, -4.82642859e-01f, 2.61407286e-01f, 2.95663208e-01f
};

// L1_fan_Wp (Shape: 6 x 16)
const int L1_fan_Wp_rows = 6;
const int L1_fan_Wp_cols = 16;
const float L1_fan_Wp_data[] = {
  7.77112022e-02f, -3.18853483e-02f, 5.58902800e-01f, -3.60846519e-01f, 2.96179235e-01f, -1.40471421e-02f, 5.74108601e-01f, -5.20383120e-02f, -4.84899342e-01f, -4.91857678e-01f,
  2.60342211e-01f, -3.28417420e-01f, -6.98450282e-02f, 4.32549536e-01f, -1.68030292e-01f, 3.16419721e-01f, 5.00608861e-01f, 1.83744624e-01f, -6.39898479e-02f, 1.12990387e-01f,
  4.30424154e-01f, -2.92702466e-01f, -2.08259866e-01f, 7.97726750e-01f, 2.28338242e-01f, 1.67067274e-01f, 7.57555962e-01f, 1.57948639e-02f, -4.03585657e-02f, 4.35698628e-01f,
  -5.19968748e-01f, -1.46640122e-01f, -1.69767946e-01f, 3.07623923e-01f, -1.04514107e-01f, 8.42351392e-02f, -3.70751530e-01f, 3.40210766e-01f, -2.70832062e-01f, -8.81896690e-02f,
  4.77686003e-02f, 6.63878202e-01f, -2.13801682e-01f, 5.91281503e-02f, 2.40500718e-01f, -2.96309888e-01f, 2.23611314e-02f, -5.06462693e-01f, 1.07409179e-01f, -9.50520411e-02f,
  -2.70449102e-01f, 3.15184891e-01f, 2.73078531e-01f, -4.41758595e-02f, 3.14589441e-02f, -2.25664124e-01f, 7.62882292e-01f, -4.50788766e-01f, 4.08486947e-02f, -1.60866812e-01f,
  4.96053174e-02f, -5.73474705e-01f, 3.09207618e-01f, -2.84624726e-01f, 4.84200001e-01f, -1.60088718e-01f, -8.10734257e-02f, 5.47361821e-02f, 2.47318327e-01f, 4.50275898e-01f,
  2.60191798e-01f, -4.38553393e-01f, 1.12631232e-01f, -4.86033320e-01f, -5.44320762e-01f, 9.68010724e-02f, 2.86814779e-01f, 7.02570260e-01f, 4.30762053e-01f, 2.50345878e-02f,
  1.22797556e-01f, -1.88856497e-01f, -9.42465737e-02f, 1.96152493e-01f, 5.91441281e-02f, 7.65301064e-02f, 2.33279064e-01f, 1.53755531e-01f, 2.21718699e-01f, 2.83889845e-03f,
  -3.72758746e-01f, 1.06091991e-01f, -9.91651788e-02f, -2.33888090e-01f, 1.99230224e-01f, -4.68301214e-02f
};

// L1_fan_Wp_bar (Shape: 4 x 16)
const int L1_fan_Wp_bar_rows = 4;
const int L1_fan_Wp_bar_cols = 16;
const float L1_fan_Wp_bar_data[] = {
  -5.48465848e-01f, 6.18499182e-02f, -8.54784623e-02f, 1.32034048e-02f, -3.98121737e-02f, 2.74635702e-01f, -7.32766464e-02f, -8.40553343e-02f, -1.17293127e-01f, 2.44912699e-01f,
  4.45173025e-01f, 1.19170606e-01f, -1.99008197e-01f, 6.01486683e-01f, 1.21326283e-01f, 2.25878298e-01f, -6.50246501e-01f, 2.22934902e-01f, 5.45949340e-01f, 1.93337247e-01f,
  -1.05932243e-01f, 5.46565711e-01f, -1.27795815e-01f, -4.80263323e-01f, -7.74353921e-01f, 4.98440385e-01f, -6.70903444e-01f, 1.36429429e-01f, -2.39019245e-01f, -5.62148355e-02f,
  4.94213283e-01f, -1.57590151e-01f, 5.01412079e-02f, -1.36874676e-01f, -1.30044688e-02f, 6.09298289e-01f, -1.92861900e-01f, 1.92438930e-01f, -2.55323112e-01f, -2.90474623e-01f,
  7.78335452e-01f, -6.21446855e-02f, -3.59064013e-01f, 3.28711241e-01f, -2.62242734e-01f, -3.37806851e-01f, 4.41823274e-01f, -6.48669973e-02f, 8.66130650e-01f, 3.58132213e-01f,
  1.60979509e-01f, -2.04707488e-01f, 3.41545075e-01f, 2.58775622e-01f, 4.81462359e-01f, -9.57227945e-02f, -3.16159219e-01f, -3.70592356e-01f, -7.80849084e-02f, 4.00155157e-01f,
  1.26573145e-01f, 3.31848502e-01f, 7.56443441e-01f, -5.06499231e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 4)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 4;
const float L1_fan_Bp_bar_data[] = {
  4.00357962e-01f, 2.06304029e-01f, -2.10704446e-01f, 6.60888664e-03f
};

// L2_fan_Wp (Shape: 6 x 16)
const int L2_fan_Wp_rows = 6;
const int L2_fan_Wp_cols = 16;
const float L2_fan_Wp_data[] = {
  -8.34256351e-01f, 1.93376355e-02f, -7.38789558e-01f, -2.28475139e-01f, -6.20509148e-01f, 2.23170556e-02f, -1.66966140e-01f, -6.12173557e-01f, -4.66356099e-01f, 4.99756724e-01f,
  7.84593880e-01f, -2.84208596e-01f, 1.02547474e-01f, 5.27208783e-02f, 9.86682028e-02f, 2.25173533e-02f, 4.79782313e-01f, -4.33542728e-01f, 5.20095080e-02f, 1.14111304e-01f,
  -6.87111974e-01f, -3.06154430e-01f, 1.45927638e-01f, 9.37467366e-02f, 3.37226093e-01f, -5.36341965e-01f, -1.50609016e-01f, -3.24261099e-01f, 9.19340551e-02f, -2.98109762e-02f,
  -6.74157143e-01f, 6.27024651e-01f, -1.53075412e-01f, 3.20086151e-01f, -5.06547987e-01f, -1.06571294e-01f, -9.37018752e-01f, 6.49993196e-02f, 6.32923424e-01f, 2.24219143e-01f,
  -6.64527357e-01f, -7.98226774e-01f, -3.61109018e-01f, -1.59680009e-01f, 2.13690877e-01f, 3.08745801e-02f, -7.38477647e-01f, -3.52402896e-01f, -2.34637499e-01f, -5.85854948e-01f,
  -3.39204520e-01f, 1.94197744e-01f, 2.85677072e-02f, -9.01942626e-02f, -5.90939462e-01f, 1.58622503e-01f, 8.61499786e-01f, -1.68542061e-02f, 2.86909461e-01f, 8.07303190e-02f,
  -2.19845235e-01f, 5.02338648e-01f, -7.31840953e-02f, -7.17860043e-01f, 2.24975973e-01f, 1.97742824e-02f, 1.45338662e-02f, -3.72253567e-01f, -4.27838236e-01f, -8.26551616e-02f,
  3.08801919e-01f, 8.61631453e-01f, -2.92900980e-01f, -8.73984396e-02f, -3.27263144e-03f, -7.51994923e-02f, 4.51592393e-02f, -7.20212579e-01f, -1.62345126e-01f, 2.78993070e-01f,
  3.04602355e-01f, 3.46385747e-01f, -2.47292429e-01f, 3.69774163e-01f, 5.48148334e-01f, 1.85867682e-01f, 2.15779664e-03f, -3.45765874e-02f, 3.12991798e-01f, -2.41277337e-01f,
  -3.89727920e-01f, 7.05821589e-02f, 1.71578571e-01f, 6.46521211e-01f, -7.08763301e-02f, -7.17869759e-01f
};

// L2_fan_Wp_bar (Shape: 4 x 16)
const int L2_fan_Wp_bar_rows = 4;
const int L2_fan_Wp_bar_cols = 16;
const float L2_fan_Wp_bar_data[] = {
  1.78507701e-01f, 6.80382550e-02f, -3.49089503e-02f, -2.60509759e-01f, 1.96116254e-01f, -1.66207731e-01f, 1.29016966e-01f, 2.66155452e-02f, 1.97347239e-01f, -2.96370499e-03f,
  -8.62399116e-02f, -3.15220952e-02f, 8.15911070e-02f, -2.20462725e-01f, -5.27559556e-02f, -2.05976859e-01f, 2.85370082e-01f, -3.42479050e-01f, 6.45815879e-02f, 2.29682565e-01f,
  3.38402629e-01f, 1.69885591e-01f, -1.74721032e-01f, -7.08444655e-01f, 5.75623035e-01f, -2.68490553e-01f, 2.66752452e-01f, 2.46129707e-01f, 1.33113181e-02f, 1.15118313e+00f,
  3.26117158e-01f, 3.63155901e-01f, 3.88491601e-01f, 5.95854580e-01f, -4.68411259e-02f, 2.73617476e-01f, 6.36526167e-01f, 3.01922977e-01f, -1.54181734e-01f, 4.80003148e-01f,
  3.50981861e-01f, -6.89021409e-01f, -1.05298030e+00f, -5.79076588e-01f, 8.78162265e-01f, 3.79401863e-01f, -3.91250312e-01f, -5.06424248e-01f, 3.20249870e-02f, 1.84300333e-01f,
  3.76302809e-01f, 2.95154631e-01f, 4.31798875e-01f, 8.28487799e-02f, 9.17401910e-01f, 2.41983920e-01f, -2.66957760e-01f, -5.37138343e-01f, 2.95725256e-01f, -2.90237814e-01f,
  -2.96567529e-01f, -1.08264133e-01f, -5.83449781e-01f, 6.94959879e-01f
};

// L2_fan_Bp_bar (Shape: 1 x 4)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 4;
const float L2_fan_Bp_bar_data[] = {
  -4.11900841e-02f, 2.21741289e-01f, 5.62717855e-01f, 4.67501730e-01f
};

// L3_linear_W (Shape: 12 x 16)
const int L3_linear_W_rows = 12;
const int L3_linear_W_cols = 16;
const float L3_linear_W_data[] = {
  -5.57373106e-01f, 1.02389835e-01f, -2.32846826e-01f, -6.68410882e-02f, 2.37091139e-01f, 4.65519398e-01f, 9.68458176e-01f, 6.39406741e-01f, 1.00468934e+00f, -1.18469238e+00f,
  9.19844568e-01f, -7.87258327e-01f, -2.10458353e-01f, -4.25805330e-01f, 6.45940959e-01f, -4.53379512e-01f, 2.74490535e-01f, 3.39829475e-01f, 7.99658775e-01f, -4.09652263e-01f,
  3.07373494e-01f, 3.44844252e-01f, -5.38847446e-01f, -7.30277181e-01f, 8.71887743e-01f, -6.52175009e-01f, -2.39660606e-01f, 1.02748036e+00f, -5.92933260e-02f, -5.22947729e-01f,
  7.02899873e-01f, 2.79695094e-01f, -1.24604058e+00f, -1.55216809e-02f, 2.00190842e-01f, 2.19992563e-01f, 4.86759424e-01f, 7.42005825e-01f, -1.16161093e-01f, 6.25869572e-01f,
  -9.51039255e-01f, -6.19629443e-01f, 4.18743342e-01f, 7.23990500e-01f, 1.19023830e-01f, -1.42233327e-01f, 1.78417370e-01f, 7.42363989e-01f, 6.03121102e-01f, -5.12151003e-01f,
  2.46844441e-01f, -7.90586919e-02f, 1.86678633e-01f, -1.64105967e-01f, -8.06927502e-01f, 5.78362167e-01f, 8.75797093e-01f, 1.05257010e+00f, 3.68451059e-01f, -8.17992926e-01f,
  1.91526234e-01f, 2.88065165e-01f, 9.20194685e-02f, 4.24094677e-01f, 5.61433375e-01f, -3.64529341e-01f, -9.33665335e-01f, -1.41913855e+00f, -2.91443225e-02f, -8.76611888e-01f,
  7.82589734e-01f, 2.69730568e-01f, 1.07293856e+00f, -3.29236746e-01f, 6.95842624e-01f, -5.60307980e-01f, -7.99710378e-02f, -3.03939432e-01f, -7.37047672e-01f, 5.68640411e-01f,
  8.49788427e-01f, 8.71665001e-01f, 7.05988288e-01f, -7.60753870e-01f, 6.97713554e-01f, 8.83453429e-01f, -7.82575682e-02f, -5.75366855e-01f, -3.63235652e-01f, -3.86860043e-01f,
  6.84055507e-01f, -4.43256855e-01f, 8.03249404e-02f, -6.15633667e-01f, -8.20416033e-01f, 8.29521656e-01f, -8.19956183e-01f, -1.13308258e-01f, 9.15666938e-01f, 7.23489583e-01f,
  3.72197092e-01f, -1.14711094e+00f, -1.74451768e-01f, 3.24592263e-01f, -3.74501973e-01f, 5.60397446e-01f, -3.34175110e-01f, 4.05746639e-01f, -2.21030321e-02f, -5.18788695e-01f,
  1.07358992e+00f, -3.47492605e-01f, 1.84002817e-01f, -6.07582211e-01f, -5.32316625e-01f, -1.05537372e-02f, -8.30207646e-01f, -4.15774912e-01f, 8.12618136e-01f, -5.42630196e-01f,
  3.60609978e-01f, 9.27586198e-01f, 1.92782268e-01f, 8.66699100e-01f, 4.45167795e-02f, 7.80673981e-01f, -3.04924637e-01f, -4.10978854e-01f, 7.31806457e-01f, 5.26262701e-01f,
  -7.80898690e-01f, 9.00889754e-01f, -3.91841650e-01f, 6.93855226e-01f, 1.05969915e-02f, -2.95935780e-01f, -3.57352793e-01f, -4.09552306e-01f, -9.21299100e-01f, 2.59894937e-01f,
  2.26933390e-01f, 6.86942518e-01f, -8.69607031e-01f, -4.10380781e-01f, -6.50991499e-01f, 2.70751845e-02f, -1.24273002e+00f, 9.59614158e-01f, 7.69009233e-01f, 1.49637848e-01f,
  -9.45451438e-01f, -8.87601197e-01f, -5.96473098e-01f, 1.58863440e-01f, -6.47449732e-01f, 8.23001266e-01f, -2.07895562e-01f, -9.37808305e-02f, 4.78700072e-01f, -6.26768351e-01f,
  1.96305007e-01f, -3.72241884e-01f, 3.98547769e-01f, -8.38706136e-01f, 4.36167330e-01f, 5.09502329e-02f, 7.94391453e-01f, 6.75632894e-01f, -9.44494426e-01f, -1.41713023e-01f,
  -8.69085848e-01f, -9.65648770e-01f, 2.26914614e-01f, 4.62510496e-01f, -5.23193181e-01f, 1.90117359e-01f, 5.37401140e-02f, 1.51565909e-01f, 2.02644974e-01f, -2.41870414e-02f,
  -9.74063814e-01f, -7.35358119e-01f, -5.75837553e-01f, -3.41851972e-02f, -8.75292420e-01f, 7.25623369e-01f, 1.38621196e-01f, -1.37065817e-02f, 2.00788766e-01f, 5.20368040e-01f,
  5.22929549e-01f, -2.27213591e-01f
};

// L3_linear_B (Shape: 1 x 12)
const int L3_linear_B_rows = 1;
const int L3_linear_B_cols = 12;
const float L3_linear_B_data[] = {
  3.81183922e-02f, 3.32489498e-02f, -2.51249284e-01f, 2.01673403e-01f, 4.06638354e-01f, 1.99031726e-01f, -3.85636479e-01f, -6.83052614e-02f, 2.03368068e-01f, 4.98190880e-01f,
  -1.16393082e-02f, -3.41024786e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 6, 4
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        16, 6, 4
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        16, 6, 4
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_linear
    linear_forward_pgm(
        buffer1, x_out,
        L3_linear_W_data, L3_linear_B_data,
        16, 12
    );
    }
    