/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 32 (x2)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 32;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    float x3 = x * x * x;
    return 0.5f * x * (1.0f + tanhf(0.79788456f * (x + 0.044715f * x3)));
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 6 x 120)
const int L0_fan_Wp_rows = 6;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  1.66890815e-01f, -3.28369945e-01f, 1.05420560e-01f, 1.54278651e-01f, 1.99274495e-01f, -1.20620325e-01f, 7.54508302e-02f, -4.83603328e-02f, -9.97850597e-02f, -1.78244859e-01f,
  -7.50118867e-03f, 2.79329903e-02f, 7.79438778e-05f, 1.15495604e-02f, 1.95875037e-02f, -1.84198573e-01f, -1.38997915e-03f, -8.80303010e-02f, 9.76901278e-02f, -1.66231543e-02f,
  1.65660784e-01f, -3.76724452e-02f, 2.04100072e-01f, -4.53173779e-02f, 1.84714556e-01f, 1.02269724e-01f, 1.44418404e-01f, 6.36349618e-02f, 8.92824903e-02f, 7.69036114e-02f,
  4.77845818e-02f, -3.79895307e-02f, 1.86638143e-02f, -4.91682850e-02f, 1.03927022e-02f, 1.75967943e-02f, -2.85179145e-03f, 8.40062797e-02f, -3.76720750e-03f, 9.10766944e-02f,
  -1.83025226e-02f, 7.13278055e-02f, -4.85196300e-02f, -4.51037399e-02f, -1.91344377e-02f, 4.39264737e-02f, 4.69757579e-02f, 2.59500463e-02f, 2.84952894e-02f, 1.59377843e-01f,
  3.76934931e-03f, 8.56669173e-02f, 1.23779373e-02f, 7.71526098e-02f, 1.15438096e-01f, -1.10769644e-02f, 3.88229042e-02f, 6.10530525e-02f, 7.32995942e-02f, 9.89658162e-02f,
  -4.77780402e-02f, -9.55385938e-02f, 6.85188845e-02f, 4.71927598e-02f, 1.20615186e-02f, 6.71948120e-02f, -5.56642599e-02f, 7.20810741e-02f, -2.39379816e-02f, -4.47127633e-02f,
  -1.54989976e-02f, -1.08932227e-01f, -2.81228833e-02f, 2.43308209e-02f, 8.41492265e-02f, -4.07779850e-02f, -1.66105423e-02f, 1.41468689e-01f, 7.36640170e-02f, -3.22335213e-02f,
  -2.00062301e-02f, -5.10413200e-02f, -1.13834783e-01f, 1.91788286e-01f, -4.23294008e-02f, -8.94941539e-02f, -3.86487544e-02f, 1.11477561e-01f, 3.17100771e-02f, 7.84029663e-02f,
  -1.46993756e-01f, -1.37210816e-01f, -2.62451842e-02f, 3.80923040e-02f, -1.97698966e-01f, -3.62762921e-02f, -3.65867955e-03f, -6.05169050e-02f, -9.39909592e-02f, -1.37544172e-02f,
  2.73478478e-02f, -1.31177446e-02f, -1.79541635e-03f, 3.09141967e-02f, -3.23298238e-02f, -1.04278341e-01f, 3.44866738e-02f, -1.47072852e-01f, -1.53745711e-02f, -1.14352159e-01f,
  -4.97435976e-05f, -4.33458388e-02f, 1.19344957e-01f, 7.70797655e-02f, 1.71276852e-02f, 9.25109982e-02f, -1.44016836e-02f, -4.59846742e-02f, 1.58048123e-01f, -2.12613749e-03f,
  2.46575937e-01f, -4.49613445e-02f, -2.53078602e-02f, 7.61868879e-02f, -1.22898586e-01f, 2.53834009e-01f, 4.23898697e-01f, -2.07689688e-01f, 2.47823581e-01f, 4.99663688e-02f,
  4.18231525e-02f, 5.89146093e-02f, 1.73216060e-01f, -2.17794795e-02f, 1.00243069e-01f, 1.96174011e-01f, 4.87823449e-02f, 7.05194995e-02f, 2.36956961e-03f, -1.46373063e-01f,
  8.43968149e-03f, -2.94804592e-02f, -7.16714859e-02f, -1.23794630e-01f, 7.11167976e-02f, -9.61851925e-02f, -1.61833569e-01f, -4.59066965e-02f, -2.05154255e-01f, 5.75426370e-02f,
  -2.91416850e-02f, -1.22248558e-02f, -1.79580245e-02f, -5.65237254e-02f, -5.76787777e-02f, 3.99702936e-02f, -2.67119817e-02f, 6.05949536e-02f, -1.84903312e-02f, 3.39263827e-02f,
  1.08769000e-01f, -7.39529505e-02f, -4.31975760e-02f, 7.72479251e-02f, 1.26126662e-01f, -1.70444660e-02f, 4.94136894e-03f, -1.98478289e-02f, -3.63318995e-02f, 1.19775437e-01f,
  8.77610445e-02f, -4.18722592e-02f, 6.86549395e-02f, 1.30221862e-02f, 1.11013204e-01f, 8.15978497e-02f, 2.43792869e-02f, 6.05062507e-02f, -9.15398374e-02f, 6.67626709e-02f,
  6.96106106e-02f, -6.15388341e-02f, -1.80183630e-02f, -5.53344823e-02f, 9.87677090e-03f, -4.53279316e-02f, -5.10376133e-02f, -5.84502891e-02f, 1.19960979e-02f, -2.63490696e-02f,
  -9.26940665e-02f, -8.40070918e-02f, -2.75795311e-02f, 4.82902788e-02f, -3.02808499e-03f, -9.10788402e-02f, 2.64254678e-02f, 2.20402926e-02f, 1.02777630e-01f, -2.72624046e-02f,
  -8.98246840e-02f, 3.36905755e-02f, 6.51597902e-02f, 3.61318476e-02f, -1.05129206e-03f, 3.90352271e-02f, -1.05036264e-02f, 1.44716233e-01f, 7.08918944e-02f, 2.18329672e-02f,
  -1.21424139e-01f, -1.94446653e-01f, 7.15360641e-02f, -9.43718106e-02f, -8.36876929e-02f, -1.00240465e-02f, 4.68480997e-02f, 2.08983105e-02f, -8.27724040e-02f, 6.75454736e-02f,
  -5.36654936e-03f, -5.36037870e-02f, -5.81405945e-02f, 5.23600839e-02f, 2.53021885e-02f, 3.65253761e-02f, 2.08008140e-02f, -8.10546353e-02f, -1.19542442e-01f, -1.42591730e-01f,
  -4.87272814e-02f, -3.13615846e-03f, 2.85004056e-03f, 5.59721701e-02f, 1.06120303e-01f, 4.41465825e-02f, -2.68655755e-02f, 6.35128692e-02f, 2.26582028e-02f, -2.79634837e-02f,
  4.87645090e-01f, -1.51431695e-01f, 4.11705934e-02f, 1.10316962e-01f, 2.92680055e-01f, 2.54891545e-01f, 1.78478882e-01f, 9.37935337e-02f, 1.26177788e-01f, -1.37006119e-01f,
  6.75626025e-02f, 1.96407229e-01f, -1.94852039e-01f, 4.08576801e-02f, 2.14606985e-01f, -1.60245195e-01f, 7.86335319e-02f, 1.28265589e-01f, 3.59098762e-02f, -5.65860793e-02f,
  1.65619478e-01f, 7.68590271e-02f, -5.07141054e-02f, -1.39303301e-02f, 9.23923403e-02f, 2.86618690e-03f, -1.61138266e-01f, 3.08817215e-02f, 4.90765311e-02f, 1.34492025e-01f,
  -7.62100890e-02f, -1.50263384e-01f, -5.19669168e-02f, -1.30486816e-01f, -1.65657803e-01f, -7.94128403e-02f, -8.48315582e-02f, -2.86929458e-02f, -3.97542343e-02f, 3.51256458e-03f,
  7.19595328e-02f, 5.75798452e-02f, -3.58564407e-02f, 1.02341101e-01f, 1.95705980e-01f, 1.70178950e-01f, -3.33179496e-02f, 3.43010463e-02f, -2.68581696e-02f, 1.29635811e-01f,
  -5.11947796e-02f, -2.51637772e-04f, 1.08278088e-01f, -5.79236262e-02f, -3.19553423e-03f, 7.76747689e-02f, -5.47923967e-02f, 1.81240086e-02f, 5.46331592e-02f, 7.83082247e-02f,
  7.77257457e-02f, -2.28157081e-02f, -1.17971944e-02f, -1.18773489e-03f, -2.36893035e-02f, -1.56598687e-02f, 2.74678273e-03f, -9.79830623e-02f, -1.86694767e-02f, -1.34992111e-03f,
  -1.67637672e-02f, 5.20447120e-02f, -2.86934692e-02f, 1.19856246e-01f, 7.74554387e-02f, 8.44952837e-02f, 6.19141348e-02f, -8.15912033e-04f, -9.31059271e-02f, 6.12481162e-02f,
  1.58570670e-02f, -3.27542387e-02f, 5.12713101e-03f, -6.86601847e-02f, -3.84970419e-02f, 1.24316879e-01f, -9.74482000e-02f, 4.98210825e-02f, -3.94133143e-02f, -3.14479228e-03f,
  -1.70290530e-01f, -3.58939886e-01f, -1.38604984e-01f, -4.99861576e-02f, -1.25283524e-01f, -6.10313416e-02f, -5.63618168e-02f, 3.81740518e-02f, 9.48514324e-03f, 1.61330998e-02f,
  6.77878316e-03f, -1.04984706e-02f, -1.06055863e-01f, -1.38682416e-02f, 5.38359843e-02f, -7.04599097e-02f, -6.22740388e-02f, -2.39707679e-02f, 1.44643346e-02f, -5.84944375e-02f,
  -2.77194586e-02f, -7.44837802e-03f, 1.52728766e-01f, 6.49632066e-02f, 8.16153735e-03f, -1.66722149e-01f, -7.70339696e-03f, 9.86498594e-02f, 2.39956025e-02f, -2.81751938e-02f,
  1.22065648e-01f, 1.27190068e-01f, -1.87116623e-01f, -1.51636183e-01f, 8.95070508e-02f, 2.51254112e-01f, -3.15800831e-02f, 9.38462676e-04f, 3.19247805e-02f, 1.67889640e-01f,
  -7.24195763e-02f, 4.46058102e-02f, -4.39569168e-02f, -1.53383076e-01f, -2.69241571e-01f, -1.74100101e-01f, -1.16320983e-01f, -2.87583135e-02f, -1.43208146e-01f, -4.90423702e-02f,
  -1.84673056e-01f, -1.88049003e-01f, -2.75528193e-01f, -4.33006138e-02f, 1.31685138e-02f, -5.02457023e-02f, -1.50200874e-01f, -1.40547976e-01f, 8.77284631e-02f, 4.72284593e-02f,
  9.14632753e-02f, -9.76070315e-02f, -9.15467665e-02f, -2.31178235e-02f, 2.53807497e-03f, 2.60718055e-02f, -9.53577086e-03f, -1.49646223e-01f, -1.53172035e-02f, -5.24021648e-02f,
  -6.02875613e-02f, 2.32846905e-02f, -6.29355609e-02f, -1.71616450e-01f, 1.19171068e-01f, -6.42202049e-02f, 5.68874627e-02f, 3.41046080e-02f, 4.82823327e-02f, 4.21623401e-02f,
  -3.71012874e-02f, 3.42661627e-02f, -3.35811935e-02f, -1.85632408e-02f, -3.49138752e-02f, 4.93144356e-02f, 2.47643050e-02f, 1.18729807e-02f, 2.35628076e-02f, 7.22624138e-02f,
  -1.25435546e-01f, -3.35287601e-02f, -2.39666589e-02f, -1.31842131e-02f, -6.16117986e-03f, 3.13232449e-04f, 1.72863360e-02f, 8.48288909e-02f, 1.25009522e-01f, 5.60022444e-02f,
  1.45000219e-01f, 1.25472337e-01f, 3.23728174e-02f, 1.90462656e-02f, -3.88676636e-02f, 1.28267547e-02f, -6.76502064e-02f, -8.71326867e-03f, 3.09856292e-02f, 6.35052565e-04f,
  -4.84310202e-02f, 2.93210130e-02f, 1.18337097e-02f, 2.23758519e-02f, -1.31775066e-01f, -4.71372530e-02f, -9.78850648e-02f, -6.04946055e-02f, -1.04100533e-01f, -5.63988201e-02f,
  2.76682496e-01f, -4.30792483e-04f, 1.91573277e-02f, 1.07150942e-01f, 5.75538017e-02f, -6.43644482e-02f, -9.80225131e-02f, 7.82829002e-02f, -1.12399561e-02f, -9.58535001e-02f,
  -1.06337309e-01f, 1.52604073e-01f, 1.09221563e-01f, -4.88934712e-03f, -3.96599509e-02f, 8.43050629e-02f, 6.03645900e-03f, 2.10247803e-02f, 6.21034652e-02f, 7.13041797e-02f,
  -2.61118021e-02f, 4.51351143e-02f, -6.04115874e-02f, -4.60792109e-02f, 2.99816448e-02f, 1.22246314e-02f, 2.54473034e-02f, -4.74359542e-02f, -7.13370666e-02f, -3.47277671e-02f,
  6.39692619e-02f, -3.68917376e-01f, 3.52662027e-01f, 4.19909395e-02f, 1.14415325e-02f, 6.18436038e-02f, 3.17136608e-02f, 2.15295181e-02f, 1.13172472e-01f, -2.67230600e-01f,
  3.52598205e-02f, -1.67868972e-01f, -1.05605097e-02f, -1.37677535e-01f, 2.88284928e-01f, 8.59505460e-02f, -4.62313667e-02f, -9.39246938e-02f, 1.18950911e-01f, -1.27166063e-01f,
  1.68941155e-01f, -2.45881051e-01f, 1.91976771e-01f, -3.39521503e-04f, 4.62314226e-02f, 2.10773304e-01f, 5.38816079e-02f, 7.49065876e-02f, -1.09056965e-01f, 3.58938985e-02f,
  -1.88227087e-01f, -2.25819927e-02f, 6.59219362e-03f, 4.40907218e-02f, 2.37743855e-02f, 5.28711602e-02f, -6.34983135e-03f, -4.93143126e-03f, 1.17164284e-01f, -3.91101465e-02f,
  -7.86254108e-02f, 1.76484231e-04f, -4.35578674e-02f, -2.59100236e-02f, 4.17792350e-02f, 2.91989371e-02f, 2.08378844e-02f, 3.03862058e-02f, -1.33102834e-01f, -4.55130227e-02f,
  1.07599655e-02f, 7.15822428e-02f, 8.35242867e-02f, -3.30832526e-02f, 6.31663576e-02f, 2.67977435e-02f, 2.77183335e-02f, 6.02847226e-02f, -9.71471146e-03f, 1.83267761e-02f,
  6.43749908e-02f, 2.65668835e-02f, -7.01540262e-02f, -6.19410202e-02f, -4.51203845e-02f, -3.03050037e-03f, -1.01120092e-01f, -7.07472563e-02f, 2.29317639e-02f, -2.89636943e-02f,
  6.79919645e-02f, -1.72442365e-02f, 5.24383448e-02f, 2.06657667e-02f, -1.28943473e-01f, 1.92266405e-02f, 3.01934406e-02f, -3.10588628e-02f, 1.21058002e-01f, 1.81462672e-02f,
  5.56079997e-03f, -5.72662950e-02f, 1.28261722e-03f, -7.10856467e-02f, -2.19673011e-02f, 7.55738467e-02f, -1.15499042e-01f, 1.37220295e-02f, -3.49137485e-02f, -6.11759685e-02f,
  -3.32947522e-01f, -2.21068591e-01f, -2.69696787e-02f, -1.18930303e-01f, -6.91105425e-03f, 6.86283857e-02f, 1.16383517e-02f, 7.16441795e-02f, -8.99433717e-02f, -9.92771536e-02f,
  -2.11356264e-02f, -4.70674187e-02f, 4.78586555e-02f, 1.15924189e-02f, -1.00783464e-02f, -6.88982010e-02f, 2.07087770e-02f, -6.92603290e-02f, 2.33660191e-02f, -7.10358620e-02f,
  -1.04347385e-01f, 2.32692040e-03f, 7.75550827e-02f, 3.51174548e-02f, 2.06382461e-02f, 2.75802761e-02f, -7.61072934e-02f, 2.32962929e-02f, 1.94136205e-03f, -5.21642491e-02f,
  -6.12955272e-01f, -1.44140214e-01f, -1.13388501e-01f, -2.84983784e-01f, -6.22773394e-02f, 5.22379056e-02f, -1.14075281e-01f, -7.48424679e-02f, -1.66677490e-01f, 1.15541495e-01f,
  -9.49174911e-03f, -2.11715311e-01f, 1.62226498e-01f, 7.59646948e-03f, -2.38101646e-01f, 2.52776206e-01f, -1.50747761e-01f, -9.59955230e-02f, 2.97231954e-02f, -2.65266150e-01f,
  1.03118345e-02f, 1.23302914e-01f, -4.82536480e-02f, 9.96043384e-02f, -1.64419770e-01f, -8.95493776e-02f, 1.95077136e-02f, 1.41577050e-01f, -9.46830735e-02f, 3.99491228e-02f,
  -7.46021792e-02f, -8.27984288e-02f, 4.06515673e-02f, 6.68181852e-02f, -3.66434008e-02f, 7.42693320e-02f, -4.75113094e-02f, 1.04195282e-01f, 1.25992849e-01f, 9.24273580e-03f,
  6.59358278e-02f, -3.71046588e-02f, 2.26085111e-02f, 1.15969099e-01f, 3.22397463e-02f, 8.59283432e-02f, 4.84610870e-02f, -7.94594362e-02f, -2.38575023e-02f, 2.26891786e-02f,
  2.07637474e-02f, 1.29667036e-02f, 6.57011420e-02f, 2.89746914e-02f, 3.47272009e-02f, 5.27682342e-02f, -3.51745822e-02f, 2.53694616e-02f, 7.00247288e-03f, -1.30331004e-02f,
  8.19116011e-02f, -4.82482426e-02f, 3.39504331e-02f, 2.89763119e-02f, 7.56254711e-04f, -3.59032266e-02f, 1.45735200e-02f, -3.09245493e-02f, -3.87637429e-02f, -8.59772563e-02f,
  -7.71228969e-02f, -9.24726576e-02f, -6.54414222e-02f, -2.56884247e-02f, 2.71765087e-02f, -5.64136095e-02f, 3.39685418e-02f, 1.60925370e-03f, -9.36550796e-02f, -7.26797385e-04f,
  -5.18210344e-02f, -2.48481743e-02f, -2.25283224e-02f, -1.08392052e-02f, 6.96589006e-04f, 5.40432669e-02f, 4.57747430e-02f, 1.04522154e-01f, -3.29789743e-02f, 4.62958999e-02f,
  -1.28786504e-01f, -1.95782408e-01f, 6.83772890e-03f, -5.41880541e-02f, 2.13359464e-02f, 1.38021186e-01f, 2.49089152e-02f, -5.17789684e-02f, 8.23391527e-02f, 4.27884310e-02f,
  1.00844651e-01f, -5.72418980e-02f, -3.87361310e-02f, 4.31574788e-03f, -6.66043237e-02f, -4.67087887e-02f, -4.89778519e-02f, -6.31017238e-02f, -4.42837812e-02f, -5.03383242e-02f,
  -2.04307884e-02f, -1.35331536e-02f, 6.69487417e-02f, -3.32364365e-02f, 1.77303632e-03f, -4.05415408e-02f, -7.94101357e-02f, 3.53903472e-02f, 9.52774510e-02f, -5.98374009e-03f
};

// L0_fan_Wp_bar (Shape: 20 x 120)
const int L0_fan_Wp_bar_rows = 20;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  1.66274205e-01f, 4.34454262e-01f, 4.02183324e-01f, 3.78140748e-01f, -2.27141917e-01f, -5.52830338e-01f, -3.15294296e-01f, 1.59670264e-01f, -5.04540093e-02f, 1.29155414e-02f,
  -9.61549059e-02f, 2.86428332e-01f, -7.04727098e-02f, 3.69815677e-02f, -1.87864944e-01f, -2.71272629e-01f, 1.28621861e-01f, -5.31495064e-02f, -1.36057809e-01f, 3.09352398e-01f,
  1.48005679e-01f, -7.00809360e-02f, 3.87799233e-01f, 6.03225417e-02f, 1.21341556e-01f, 2.30483934e-01f, 2.07249328e-01f, -7.32874079e-03f, 3.43350112e-01f, -8.08980018e-02f,
  -1.87621012e-01f, 1.04023449e-01f, 1.93306178e-01f, -3.31987217e-02f, 3.83484289e-02f, -1.91607177e-02f, 5.65289333e-02f, -1.28378123e-01f, 4.01352718e-02f, -1.40550593e-02f,
  1.03211962e-01f, -1.84485745e-02f, 4.41732556e-02f, -4.74303998e-02f, -1.33210635e-02f, 1.48555636e-01f, -4.99993470e-03f, 5.11497408e-02f, 5.33604138e-02f, 1.90488771e-01f,
  6.08412139e-02f, 5.67139499e-02f, -7.74677321e-02f, 1.82613596e-01f, 1.41850188e-01f, -6.63399324e-02f, -1.39840916e-02f, 1.94532245e-01f, 5.03210872e-02f, 1.15945116e-01f,
  8.56522396e-02f, -1.02036610e-01f, -6.76233619e-02f, -2.84670331e-02f, -5.83574213e-02f, -2.53292583e-02f, -7.48873428e-02f, 9.24019814e-02f, -5.99247627e-02f, -4.09380719e-02f,
  -5.08822724e-02f, 1.12431221e-01f, -2.14369550e-01f, -4.33687456e-02f, -5.24464063e-02f, 2.61568706e-02f, -7.58318901e-02f, -5.05600646e-02f, 1.69147938e-01f, 1.12099275e-01f,
  -7.92617127e-02f, -1.43277779e-01f, -1.07462034e-01f, -1.16611399e-01f, -2.21336171e-01f, 1.70634426e-02f, 1.40003890e-01f, -1.45344005e-03f, -3.51405218e-02f, 2.25915443e-02f,
  -3.04727741e-02f, 1.94862396e-01f, 3.31036039e-02f, -8.22834224e-02f, -2.48180684e-02f, -1.30816502e-02f, 1.55917099e-02f, 5.34754433e-02f, 6.41856045e-02f, -1.06041491e-01f,
  1.29220471e-01f, -5.71780577e-02f, -2.97882222e-02f, -9.53111053e-02f, 2.36014426e-02f, -1.59429554e-02f, -2.70320177e-02f, 3.94107588e-02f, 1.66809097e-01f, 1.31842747e-01f,
  8.94168466e-02f, -1.17033057e-01f, -3.27830873e-02f, -5.05790347e-03f, 2.93555185e-02f, -2.47340999e-03f, -3.56747173e-02f, 1.51860192e-01f, 2.39761453e-02f, -8.05587620e-02f,
  6.37421906e-01f, -1.95813507e-01f, -1.01491049e-01f, 3.04877162e-01f, 1.98953047e-01f, -9.04686972e-02f, -1.76911969e-02f, 2.62642443e-01f, 1.04943469e-01f, -1.23889051e-01f,
  2.91065246e-01f, -1.86054394e-01f, 4.46790038e-03f, 3.97285342e-01f, 3.62570673e-01f, -9.74195078e-02f, 3.43902946e-01f, -1.04083018e-02f, 6.96057826e-02f, 2.78894126e-01f,
  3.91067773e-01f, 5.14134526e-01f, 1.17724866e-01f, 1.24261655e-01f, 2.18117505e-01f, -5.28147072e-02f, 7.90107101e-02f, -8.82271379e-02f, 2.10432634e-02f, -1.93281844e-02f,
  -6.69163913e-02f, 1.22254826e-01f, 2.81660128e-02f, -8.34662467e-02f, 9.05500501e-02f, -3.34150083e-02f, -2.30210900e-01f, -1.89193189e-02f, -1.65436566e-02f, 2.89885309e-02f,
  -4.52846959e-02f, 6.73061982e-02f, 4.75748219e-02f, 2.38596294e-02f, 1.35574192e-01f, -1.32125877e-02f, -3.44345644e-02f, -7.88513124e-02f, -1.60533041e-01f, 1.06515877e-01f,
  -1.05453935e-02f, -4.78343554e-02f, 1.04479894e-01f, -8.23371857e-02f, 7.76523054e-02f, 3.76997031e-02f, -1.33560762e-01f, -1.05418809e-01f, -3.29584740e-02f, 1.23557402e-02f,
  1.02870047e-01f, -9.67026036e-03f, 6.40393943e-02f, 4.72063087e-02f, 9.43669379e-02f, -3.24380398e-02f, 4.24363725e-02f, -7.09841028e-02f, -8.93750489e-02f, -8.59874301e-03f,
  1.09103452e-02f, -2.85291541e-02f, 2.24789847e-02f, -6.93556741e-02f, 1.60819903e-01f, -2.30456982e-02f, 6.83347955e-02f, 8.60866858e-04f, -3.95352393e-02f, 1.11544998e-02f,
  -1.18014805e-01f, 1.92814600e-02f, 6.57802157e-04f, -4.69020568e-02f, 3.55132520e-02f, 4.60844003e-02f, 7.43759125e-02f, 1.36312068e-01f, -6.96108267e-02f, 6.71283379e-02f,
  3.15738805e-02f, 4.67867441e-02f, -1.00236341e-01f, -1.30561098e-01f, -1.60035610e-01f, 1.77668393e-01f, 1.93759445e-02f, 1.08164452e-01f, -4.98810709e-02f, 1.95289716e-01f,
  1.33933380e-01f, -1.10748433e-01f, -1.07129477e-02f, 2.42468491e-02f, -6.54099807e-02f, 6.33501634e-02f, -1.41109720e-01f, -1.66689232e-01f, -1.74546856e-02f, 1.21491058e-02f,
  6.52424023e-02f, -6.13195300e-02f, 4.21077013e-02f, 5.26574627e-02f, -3.55043449e-02f, -3.48676853e-02f, 1.10127255e-02f, -5.38098477e-02f, 2.80139074e-02f, -1.08382791e-01f,
  -2.13177115e-01f, -1.02561444e-01f, 2.48321369e-01f, -4.76737231e-01f, 1.38700977e-01f, 2.50271797e-01f, 7.52644092e-02f, -2.33873129e-01f, -4.71392125e-01f, -4.18494433e-01f,
  -6.62794784e-02f, 3.40016303e-03f, 2.77509719e-01f, -2.57212967e-01f, 4.95101243e-01f, 9.88787487e-02f, -2.70196289e-01f, -1.67896926e-01f, -1.40803427e-01f, -1.28609866e-01f,
  -2.07470432e-01f, -3.34348977e-01f, 3.15309525e-01f, -1.00410908e-01f, -3.19294110e-02f, -1.04357921e-01f, 9.03700218e-02f, 2.79023796e-01f, -2.50315040e-01f, 1.12167522e-01f,
  4.68715206e-02f, -2.47490704e-01f, 1.00525722e-01f, -6.64246306e-02f, 3.75816561e-02f, 7.34026283e-02f, 1.53738976e-01f, 2.60390580e-01f, -1.05448678e-01f, -6.23594485e-02f,
  2.28839908e-02f, -1.53471261e-01f, -1.73217461e-01f, 4.33626398e-02f, -1.78248510e-01f, -1.72735229e-01f, 2.03538220e-02f, 6.57776967e-02f, -3.71304713e-02f, 3.56696500e-03f,
  9.19407904e-02f, 3.32173109e-02f, -1.27448261e-01f, -1.26842499e-01f, 6.97696283e-02f, -1.41806766e-01f, 4.86826040e-02f, 2.34384075e-01f, -1.40612617e-01f, -1.50812909e-01f,
  1.47364393e-03f, 1.58083383e-02f, 4.11039405e-02f, -6.43426254e-02f, -2.29395851e-02f, -2.18330715e-02f, 7.22907577e-03f, 1.24274135e-01f, 8.35467875e-02f, -5.40611381e-03f,
  -1.19084977e-01f, -1.49194887e-02f, -5.30248508e-02f, 1.53921293e-02f, -2.58675013e-02f, -2.33396832e-02f, 1.27932265e-01f, -7.46459290e-02f, -4.24961932e-02f, 7.64738321e-02f,
  -2.77877152e-02f, -4.52515222e-02f, 1.80396682e-03f, -3.72476391e-02f, 9.86886211e-03f, 4.72006798e-02f, -1.29231364e-01f, -1.18279316e-01f, 6.78055063e-02f, 3.25718671e-02f,
  5.36771677e-02f, -1.68253407e-01f, 1.39823016e-02f, -1.17803924e-01f, 1.72914669e-01f, -9.96686704e-03f, 3.31052914e-02f, -1.05909839e-01f, -8.40499178e-02f, -4.06932682e-02f,
  -1.02718525e-01f, 2.91906353e-02f, -9.59488153e-02f, 6.46340335e-03f, -4.41536233e-02f, 8.84421729e-03f, -4.29971591e-02f, 5.60609810e-02f, 6.94008172e-02f, 7.83823580e-02f,
  -5.19543290e-02f, -8.16550106e-03f, -7.76798204e-02f, -1.36558473e-01f, -1.41356304e-01f, -7.55297989e-02f, 6.71875626e-02f, -6.84739873e-02f, -3.86035368e-02f, -9.74653382e-03f,
  -6.54518381e-02f, 1.34530917e-01f, -3.05740088e-01f, -1.45477504e-01f, 1.02886438e-01f, -3.85647833e-01f, -3.19334455e-02f, 1.50110126e-01f, -2.63733923e-01f, 2.89798945e-01f,
  1.83111921e-01f, -1.71576232e-01f, 3.46569389e-01f, -9.72664654e-02f, -5.51563442e-01f, -5.17248623e-02f, -3.47814471e-01f, -1.26201302e-01f, 1.43816266e-02f, 2.14992538e-01f,
  -4.92863245e-02f, 2.39165857e-01f, -8.15867931e-02f, 3.50665003e-01f, 1.13243893e-01f, 6.26296103e-02f, 3.18054855e-01f, 4.64034021e-01f, 1.66897650e-03f, 2.88275145e-02f,
  -4.70900908e-02f, 1.09562375e-01f, -3.14107575e-02f, -2.99573299e-02f, -1.11825161e-01f, 1.22769019e-02f, 4.28167768e-02f, -6.17046542e-02f, -1.74604747e-02f, 2.40184017e-03f,
  1.07889891e-01f, -1.11684380e-02f, 1.12699224e-02f, 5.96152432e-02f, 5.94824506e-03f, -2.77472343e-02f, -4.62525487e-02f, -1.99881122e-01f, -8.69652629e-03f, 2.97366604e-02f,
  -3.74139287e-02f, -1.29934072e-01f, -5.31648099e-02f, -6.65409043e-02f, -9.41283128e-04f, 8.21411237e-03f, -1.48488685e-01f, 2.69237570e-02f, -8.61975923e-03f, -1.22412033e-01f,
  7.99520612e-02f, -4.57868986e-02f, 9.78197381e-02f, 4.14205454e-02f, -4.08208347e-04f, 9.93761420e-02f, -5.39256334e-02f, -4.72007059e-02f, -6.84575140e-02f, 5.98544851e-02f,
  -9.21613872e-02f, -8.54687542e-02f, 4.26842868e-02f, 7.88284000e-03f, -3.49362940e-02f, -4.96318340e-02f, -3.05253472e-02f, 1.03763573e-01f, -9.07411054e-02f, -1.77632928e-01f,
  3.22717503e-02f, 2.29573101e-02f, -1.44357756e-01f, 2.39936151e-02f, -1.28202602e-01f, 1.45221293e-01f, 1.69011071e-01f, -1.73199754e-02f, 1.00216828e-01f, 1.51576459e-01f,
  5.23398332e-02f, 1.97074525e-02f, -6.56638071e-02f, -4.88022529e-02f, -7.18514696e-02f, -3.17802466e-02f, -1.05185002e-01f, -7.86358770e-03f, 7.98540283e-03f, -7.72224786e-03f,
  1.91104889e-01f, -5.87681718e-02f, 4.48849192e-03f, -4.69773822e-02f, -8.01688582e-02f, -2.70801838e-02f, 1.52314857e-01f, -4.52148616e-02f, -1.10833779e-01f, -9.08308327e-02f,
  1.27499714e-01f, 5.47496639e-02f, -1.89483956e-01f, 3.24741215e-03f, 5.81352636e-02f, -3.02560702e-02f, -6.49071336e-02f, 5.19421510e-03f, 4.70000245e-02f, -6.03388771e-02f,
  4.72311169e-01f, -8.10995698e-02f, -1.92032725e-01f, -1.20302461e-01f, -1.30893543e-01f, -2.66618997e-01f, -1.54730588e-01f, -2.75211006e-01f, -1.58257961e-01f, -3.04818362e-01f,
  -1.40215578e-02f, -1.48064774e-02f, 2.25287542e-01f, 1.55199487e-02f, 2.87301779e-01f, 2.72460222e-01f, -5.17458003e-03f, -8.72488096e-02f, 2.25544393e-01f, -3.63685973e-02f,
  1.69183016e-01f, 3.16079259e-02f, 1.21388689e-01f, 8.47436488e-03f, 9.31302905e-02f, 7.14016613e-03f, 1.19670063e-01f, 5.45648262e-02f, -1.73330322e-01f, -6.10637031e-02f,
  1.63902804e-01f, 1.59081131e-01f, 3.27476151e-02f, 2.30258815e-02f, 9.03084725e-02f, 7.03805313e-02f, 4.48898636e-02f, -9.81074385e-03f, 7.82558024e-02f, 6.97791055e-02f,
  5.81582561e-02f, 9.53577831e-02f, -2.05503523e-01f, -1.46510825e-02f, 2.39136443e-02f, -3.89783569e-02f, 4.00276780e-02f, 1.13974977e-02f, -1.02046922e-01f, 1.75120115e-01f,
  -4.57574315e-02f, 1.12266541e-01f, -4.38792743e-02f, -2.56881136e-02f, -8.90937969e-02f, -4.24363166e-02f, -1.32154813e-02f, 1.93733070e-02f, -8.58741067e-03f, 9.13489833e-02f,
  -5.92889600e-02f, 1.28076464e-01f, 5.42273521e-02f, 4.90929782e-02f, 3.11576407e-02f, -4.21095490e-02f, -5.90196177e-02f, -8.76174942e-02f, -1.40469964e-03f, 8.99768323e-02f,
  1.69681311e-02f, -9.76214185e-02f, 7.54074901e-02f, 1.07118329e-02f, 9.54720825e-02f, 1.75000094e-02f, 7.69748688e-02f, 2.38242671e-02f, -1.00104148e-02f, -5.07706143e-02f,
  3.17488261e-03f, 2.95608435e-02f, -1.15941763e-01f, 3.55030708e-02f, 9.35219973e-02f, -9.74524990e-02f, 9.19383112e-03f, -2.36942694e-02f, 4.52800281e-02f, 9.34480876e-02f,
  9.17952657e-02f, 4.22568917e-02f, -4.06244285e-02f, -8.69315937e-02f, 2.65068188e-02f, 9.96689647e-02f, 2.48817336e-02f, -1.73495442e-01f, 1.53677445e-03f, 4.09015194e-02f,
  -8.51039682e-03f, -2.54938323e-02f, -4.01592776e-02f, -8.16399008e-02f, -5.69132417e-02f, -2.28522733e-01f, -3.36064189e-03f, -5.18627651e-02f, -9.00460631e-02f, -2.50667222e-02f,
  -7.02929050e-02f, -7.52972963e-04f, 1.46756209e-02f, -3.60697210e-02f, -1.27901614e-01f, 4.91473339e-02f, -3.89098865e-03f, -3.49851213e-02f, 3.88669781e-02f, -2.10549701e-02f,
  -6.50675893e-01f, -2.78569525e-03f, -3.14864755e-01f, 3.14244539e-01f, 4.67642024e-02f, 1.89666465e-01f, 2.12730825e-01f, 7.36580342e-02f, -2.80676961e-01f, 2.75174081e-01f,
  4.58795816e-01f, -2.00315714e-01f, -3.09349652e-02f, 6.61342859e-01f, 1.47232279e-01f, 1.96561620e-01f, 4.32391167e-01f, 3.96997988e-01f, -1.36426553e-01f, -3.45170610e-02f,
  -7.19560636e-03f, 4.43564028e-01f, 2.25447237e-01f, 8.31287727e-02f, 1.74438775e-01f, -2.59635359e-01f, 1.98826060e-01f, -1.26121625e-01f, 4.17165518e-01f, 2.06417844e-01f,
  -1.46694094e-01f, -1.82179332e-01f, -4.06129360e-02f, -1.83128446e-01f, -8.27767327e-02f, -7.27370158e-02f, -3.55668645e-03f, -9.68874022e-02f, -5.54670803e-02f, 4.91145961e-02f,
  -9.82265547e-02f, -6.54692426e-02f, 1.29578978e-01f, -5.26004247e-02f, -3.27583775e-02f, -6.00267947e-02f, -3.43332911e-04f, 1.26809433e-01f, 1.59303360e-02f, 8.75975862e-02f,
  -3.59823033e-02f, 8.79800692e-02f, 1.06497392e-01f, 1.34707302e-01f, -1.05984425e-02f, 1.55604869e-01f, 4.84661870e-02f, -4.26020809e-02f, 5.76170944e-02f, 7.46828178e-03f,
  -2.38906946e-02f, -4.42253947e-02f, -4.26876843e-02f, -3.04280017e-02f, -4.28686403e-02f, 2.45756339e-02f, 1.24454230e-01f, 4.11315747e-02f, -6.43704906e-02f, 2.89323125e-02f,
  -5.91847599e-02f, -4.92575858e-03f, -5.12518808e-02f, -1.32033393e-01f, 8.24870244e-02f, -2.34105755e-02f, -1.08144410e-01f, 9.75222141e-02f, 2.59157028e-02f, 7.44743645e-02f,
  -5.85962683e-02f, -1.13177858e-01f, 2.36143987e-03f, 7.08130747e-03f, 7.87272602e-02f, -1.40683008e-02f, -2.77894735e-02f, -5.76074161e-02f, -1.30146891e-01f, -8.04164633e-03f,
  -5.87315895e-02f, -2.18845934e-01f, 8.49780962e-02f, -1.23708863e-02f, -2.67521907e-02f, 6.23978898e-02f, -3.93189192e-02f, -2.57192980e-02f, 1.16469217e-02f, -4.92435396e-02f,
  -6.42670169e-02f, 6.67686686e-02f, -6.92159459e-02f, -5.44892699e-02f, 3.46279703e-02f, 2.67447662e-02f, -2.67805364e-02f, -9.21160877e-02f, 8.80119875e-02f, 6.50290102e-02f,
  -1.56471897e-02f, 2.03197282e-02f, -4.55119908e-02f, -7.20118778e-03f, 1.42348692e-01f, 8.71439129e-02f, 1.92772988e-02f, -2.36073416e-02f, 1.38186842e-01f, 3.50303650e-02f,
  -1.94148943e-01f, 1.94817007e-01f, 4.67423759e-02f, -3.07285339e-01f, -2.81553436e-02f, -3.19181770e-01f, -3.27056348e-01f, 1.49233952e-01f, 1.18381336e-01f, 2.86181420e-01f,
  1.34456651e-02f, 3.05795759e-01f, 1.05493158e-01f, -2.75028378e-01f, -6.23222113e-01f, -9.54450145e-02f, -5.06081581e-01f, -1.82769358e-01f, -1.65341809e-01f, -2.75614619e-01f,
  -3.66354376e-01f, -3.44946146e-01f, -2.77159035e-01f, -1.46565717e-02f, -2.63918340e-01f, 1.25650600e-01f, -1.75749063e-01f, -5.97629547e-02f, -1.17902979e-01f, -1.40681611e-02f,
  -6.22876361e-02f, 2.91256577e-01f, 2.16340289e-01f, 1.39035910e-01f, -5.49006686e-02f, -6.26997836e-03f, -1.24871105e-01f, 3.22601981e-02f, 5.15992008e-02f, 2.52391677e-02f,
  6.02546781e-02f, 3.00575085e-02f, 6.14832006e-02f, 1.87434871e-02f, 8.83850828e-02f, 1.27011985e-01f, 6.04754277e-02f, 2.46637166e-02f, 1.57720774e-01f, -1.53105548e-02f,
  3.47744375e-02f, 1.30925953e-01f, -6.38927668e-02f, 9.23792366e-04f, -4.27459665e-02f, 8.35721120e-02f, -3.24172489e-02f, -1.33403921e-02f, -5.11837117e-02f, -1.12895612e-02f,
  -9.33558196e-02f, -7.18158484e-02f, -6.44146279e-02f, -1.35078346e-02f, 3.22849452e-02f, -2.91078701e-03f, -2.83101089e-02f, 1.25554755e-01f, 2.93638166e-02f, -2.87369415e-02f,
  -1.86333507e-02f, 1.80357531e-01f, 7.79871643e-02f, -5.16677499e-02f, -1.07932717e-01f, 4.39467654e-02f, -9.90360081e-02f, 1.15508690e-01f, -2.03261465e-01f, 7.14542419e-02f,
  3.43978740e-02f, -6.34768754e-02f, 2.41155885e-02f, -1.21064171e-01f, -1.40517622e-01f, 4.07826640e-02f, 1.82172898e-02f, -3.89133468e-02f, -2.56336052e-02f, -1.89495146e-01f,
  -9.33088660e-02f, 5.87076955e-02f, 1.23132922e-01f, 1.42624244e-01f, 2.31330823e-02f, -9.64626819e-02f, -9.83371735e-02f, -1.21992957e-02f, -1.68953575e-02f, -4.48307544e-02f,
  -1.30419970e-01f, 8.07308033e-02f, -1.43574044e-01f, 6.50605112e-02f, 2.99902633e-03f, 1.94488931e-02f, -3.08064017e-02f, 6.48716241e-02f, 2.13751774e-02f, 7.83598348e-02f,
  9.21117067e-02f, 8.24771672e-02f, -4.32847664e-02f, -5.36455028e-02f, 1.08832738e-03f, 1.32812858e-02f, 3.27252448e-02f, 1.40378281e-01f, -6.50264770e-02f, 1.53243374e-02f,
  -5.97282708e-01f, -5.89271903e-01f, 1.91328987e-01f, 7.22720921e-02f, -6.96479902e-02f, -1.21787630e-01f, -5.80158010e-02f, -1.30295187e-01f, -2.64025003e-01f, -3.79024237e-01f,
  -6.73844442e-02f, -1.01103470e-01f, -2.53571093e-01f, -1.36097237e-01f, 3.05710673e-01f, -2.30736479e-01f, 9.25876722e-02f, 3.24046463e-02f, 2.36564606e-01f, 8.25300515e-02f,
  3.21762621e-01f, 1.76612213e-01f, 3.91714126e-01f, 3.74977648e-01f, 1.21685132e-01f, 3.70393783e-01f, 3.29976290e-01f, 3.79508883e-01f, 4.52245474e-01f, 1.39904261e-01f,
  -1.62334025e-01f, -1.07399337e-01f, -5.53641506e-02f, -4.37186882e-02f, 7.08429515e-02f, 4.02310892e-04f, 9.02636275e-02f, 1.25590131e-01f, 4.41211425e-02f, 5.59657998e-02f,
  -1.21150613e-01f, 8.47301856e-02f, 5.76267876e-02f, 1.57145277e-01f, 1.13679748e-02f, -2.18063109e-02f, 3.54848206e-02f, -7.14056715e-02f, 1.57892350e-02f, 3.21258567e-02f,
  -3.96747589e-02f, -1.17740311e-01f, -7.75037184e-02f, 1.71480961e-02f, 1.43895939e-01f, -8.48521199e-03f, 8.63257051e-03f, 5.67240641e-02f, -5.33566475e-02f, 9.28305238e-02f,
  -3.56831178e-02f, 8.90197977e-02f, -1.23358287e-01f, -7.63324574e-02f, -1.45461578e-02f, -1.19385952e-02f, 4.47567971e-03f, 1.07346311e-01f, 7.41585195e-02f, -4.85386141e-02f,
  -6.40571564e-02f, 2.43805740e-02f, -5.81186488e-02f, -1.24331646e-01f, -2.87979487e-02f, -1.65033266e-01f, 1.00214854e-01f, 9.30110589e-02f, 4.53513861e-02f, 1.17339073e-02f,
  -1.15020908e-01f, -2.23283339e-02f, 6.22030534e-03f, 3.58475149e-02f, -1.01430573e-01f, 1.27984568e-01f, -5.40057682e-02f, -5.63900061e-02f, -7.25060850e-02f, 9.50810313e-02f,
  -2.53142953e-01f, -3.14349458e-02f, -9.04297456e-03f, -7.89740123e-03f, -1.15017761e-02f, 2.51064752e-03f, 9.22288187e-03f, -2.72825193e-02f, -2.72261593e-02f, -6.37652576e-02f,
  7.04496801e-02f, 1.53210431e-01f, -6.62155896e-02f, 1.31844044e-01f, 2.07924813e-01f, -9.89797711e-02f, 1.82305705e-02f, 5.58737926e-02f, 4.98139895e-02f, 1.23802237e-01f,
  -6.85486868e-02f, -6.38377890e-02f, 9.41408724e-02f, 1.24511361e-01f, -6.53750915e-03f, 8.98265317e-02f, -6.80549443e-02f, -4.72466927e-03f, 9.39407572e-02f, 6.06157482e-02f,
  2.33172894e-01f, -2.75217950e-01f, -2.16697246e-01f, -4.28990126e-02f, -3.36350985e-02f, -9.62817669e-02f, -7.92965963e-02f, -1.08542144e-01f, 1.92067489e-01f, -2.69420743e-01f,
  -1.17546208e-01f, 4.09010164e-02f, -2.44295467e-02f, -2.45213002e-01f, 2.97839403e-01f, 1.47931024e-01f, -2.20218748e-02f, -1.22377329e-01f, 1.23456798e-01f, -7.29168206e-02f,
  1.63778499e-01f, -2.16978058e-01f, -2.14151219e-01f, -3.49408567e-01f, -4.02459323e-01f, -3.00537348e-01f, -2.27342650e-01f, -1.86905473e-01f, -2.32963622e-01f, -7.02483729e-02f,
  -6.01484515e-02f, 8.52679908e-02f, -6.13338798e-02f, 1.06254101e-01f, -8.50403681e-02f, -5.96205965e-02f, -1.38566881e-01f, -1.18050449e-01f, 8.66795629e-02f, 1.06775582e-01f,
  6.16416009e-03f, 1.69231147e-01f, -1.23707466e-01f, -4.27499041e-02f, 6.94916099e-02f, 1.09494850e-02f, 3.35167386e-02f, -2.10895129e-02f, 6.43209964e-02f, -1.11812480e-01f,
  7.32059926e-02f, 8.22801962e-02f, 1.05189867e-01f, -1.34624168e-02f, -7.10251555e-02f, 1.51697630e-02f, -2.13184133e-02f, -1.76637441e-01f, 3.62992547e-02f, 1.20596379e-01f,
  2.45850086e-02f, 1.16689883e-01f, -1.09331936e-01f, -3.47474925e-02f, -1.59994811e-02f, 2.88894429e-04f, 8.22978839e-02f, -1.04833253e-01f, 4.08488605e-03f, -5.50245792e-02f,
  9.08999816e-02f, -1.22652508e-01f, 3.02745253e-02f, 1.36040285e-01f, 1.53595060e-02f, 7.49602988e-02f, 1.33007262e-02f, 1.44096604e-03f, 2.98016965e-02f, 7.90490885e-05f,
  3.58320214e-02f, 1.58968810e-02f, -1.15975603e-01f, -5.54383220e-03f, -4.90210652e-02f, 8.83519202e-02f, -3.13381255e-02f, -1.83635559e-02f, -1.12657368e-01f, 1.42876050e-02f,
  1.02754720e-02f, -1.09142615e-02f, -4.69453931e-02f, 7.77276291e-04f, -4.24841642e-02f, -2.59082243e-02f, -8.67777839e-02f, -9.01986659e-02f, 4.69291881e-02f, 1.39316276e-01f,
  -2.96650007e-02f, -9.87869408e-03f, 1.43885970e-01f, -6.72429800e-02f, -2.38575712e-02f, -1.32512644e-01f, 5.14220148e-02f, 5.67722544e-02f, 1.32998377e-01f, -1.27996057e-01f,
  2.23457608e-02f, 7.41510689e-02f, 1.84425294e-01f, 6.66215420e-02f, -8.12897533e-02f, 5.84780686e-02f, 1.37549033e-02f, 4.13477719e-02f, 1.83730759e-02f, 2.81188041e-02f,
  2.03129336e-01f, 2.79160142e-01f, 1.10528819e-01f, -2.78713912e-01f, -9.29668844e-02f, 1.74625710e-01f, -1.57487974e-01f, 6.60905540e-02f, -1.22102834e-01f, 3.68650407e-01f,
  -1.00089125e-01f, 2.18610123e-01f, -1.25513628e-01f, -1.06963038e-01f, -4.43145126e-01f, -3.73318881e-01f, 2.60934290e-02f, 1.39220551e-01f, -1.83488086e-01f, 2.35682800e-01f,
  -1.89473301e-01f, -2.74803132e-01f, -2.18673468e-01f, -7.51220062e-02f, 1.90731078e-01f, 1.45675331e-01f, 5.22521660e-02f, -8.83480161e-02f, 1.78428560e-01f, -2.35786632e-01f,
  9.55337659e-02f, -9.48694497e-02f, 4.36866768e-02f, 2.92237215e-02f, 2.65317783e-03f, 8.73018056e-02f, 1.51662737e-01f, -1.74142390e-01f, -1.85477123e-01f, -5.89816198e-02f,
  1.46437034e-01f, -9.15200189e-02f, -4.65011708e-02f, -1.58775970e-01f, -1.72882620e-02f, 5.01603819e-02f, 3.19067426e-02f, 7.75130093e-02f, -2.23611724e-02f, 4.00411859e-02f,
  2.05888171e-02f, -5.97575493e-03f, 6.39678687e-02f, -8.59110802e-02f, -1.02981195e-01f, 1.47994384e-02f, 5.64484671e-02f, 8.54384340e-03f, 1.45931974e-01f, -2.11427018e-01f,
  -1.02275625e-01f, 7.98928589e-02f, 1.89990383e-02f, 1.63732678e-01f, -5.18755317e-02f, 7.72780329e-02f, 7.31142610e-02f, -3.97711433e-03f, -2.74511287e-03f, 3.97180282e-02f,
  6.51172549e-02f, 1.44604538e-02f, -8.70875046e-02f, 4.33500558e-02f, 7.02747256e-02f, 9.50868651e-02f, -2.04744823e-02f, -3.00034671e-03f, -1.31829630e-03f, 1.57597095e-01f,
  -2.42070798e-02f, 6.39268905e-02f, -1.27553582e-01f, 9.36285034e-02f, -5.51995859e-02f, -2.42730096e-01f, 6.50207000e-03f, -3.15092690e-02f, 1.03607520e-01f, 3.83887105e-02f,
  4.29045446e-02f, 5.11050373e-02f, 8.36433750e-03f, -6.60724267e-02f, 3.99917029e-02f, 1.13006771e-01f, 2.56899726e-02f, 2.93468591e-02f, -1.83324292e-02f, 2.71469075e-02f,
  1.79798514e-01f, 1.22333243e-02f, 1.99925691e-01f, -4.71960055e-03f, -5.65240346e-02f, 9.97342020e-02f, 3.46134081e-02f, 2.99022421e-02f, -1.01323925e-01f, 2.28549186e-02f,
  1.05161764e-01f, 3.77333052e-02f, -1.18168339e-01f, -1.00660495e-01f, -3.75797856e-03f, 4.93399762e-02f, 3.72987427e-02f, 6.88648745e-02f, -5.78370914e-02f, -5.41263707e-02f,
  -4.00189012e-02f, -5.11337161e-01f, -5.54036319e-01f, -1.38413310e-01f, 4.82373446e-01f, 5.02064526e-01f, -1.23638228e-01f, 8.93187672e-02f, -3.72578472e-01f, 2.14697961e-02f,
  7.30524883e-02f, -2.63151377e-01f, -3.95193160e-01f, 2.65357215e-02f, 2.90619098e-02f, -3.78265053e-01f, 1.86372876e-01f, 3.00989859e-02f, -2.31588244e-01f, 1.53837316e-02f,
  7.43690431e-02f, 4.51311320e-01f, -2.48746693e-01f, 2.52913386e-01f, 1.90044001e-01f, 3.20984907e-02f, 2.87768126e-01f, -5.51914424e-02f, 3.44698936e-01f, 9.99758244e-02f,
  5.58999777e-02f, -1.82767212e-01f, -9.59505141e-02f, -5.25549948e-02f, 7.84256533e-02f, 1.66191310e-01f, 7.13691711e-02f, 5.21574169e-02f, 1.99389700e-02f, -4.07857597e-02f,
  5.00218086e-02f, 8.17888528e-02f, 3.16115916e-02f, 6.33404478e-02f, 1.21088035e-01f, 2.89841238e-02f, -7.59284347e-02f, -1.22911163e-01f, -1.42936662e-01f, -1.02081098e-01f,
  -1.59035310e-01f, 5.89100551e-03f, 2.42627990e-02f, 5.75139700e-03f, 1.30217720e-03f, -4.03744206e-02f, -6.00679126e-03f, 4.92358133e-02f, 3.02641001e-02f, 1.38759032e-01f,
  1.29037723e-01f, 1.96050350e-02f, -2.47191973e-02f, -9.72307622e-02f, -4.67149653e-02f, -2.08447445e-02f, -1.17014855e-01f, -8.05247948e-02f, -1.75634012e-01f, -3.52557306e-03f,
  -2.19235811e-02f, -6.24817796e-02f, -1.20366640e-01f, 1.49747804e-01f, 1.79057762e-01f, -4.16374393e-02f, 2.67782696e-02f, 5.12283519e-02f, 7.11933477e-03f, 6.28448557e-03f,
  -8.46246183e-02f, 1.03919573e-01f, 8.11603889e-02f, -2.86743278e-03f, -8.83549452e-02f, 5.82940802e-02f, 1.57284796e-01f, 5.94436266e-02f, 1.76037829e-02f, 8.16094279e-02f,
  7.80901089e-02f, 1.06223829e-01f, -7.27564692e-02f, -3.18906866e-02f, -9.92703587e-02f, 9.71867293e-02f, -1.29690439e-01f, -3.73765198e-03f, 6.18884042e-02f, 3.80442366e-02f,
  2.57074535e-01f, -2.28700601e-02f, 9.28332880e-02f, -2.16723289e-02f, 3.22307535e-02f, 4.83518057e-02f, 8.75620022e-02f, 4.96493727e-02f, 9.93442535e-02f, 6.72550276e-02f,
  1.27072111e-01f, 1.07004344e-01f, 3.58869396e-02f, 1.34293035e-01f, 9.84021202e-02f, 4.65705432e-02f, 7.72149488e-02f, 9.45654046e-03f, 2.12268531e-02f, -3.20383124e-02f,
  -7.33989701e-02f, -4.99155149e-02f, -1.43044949e-01f, -1.81693390e-01f, -9.12933201e-02f, -4.71040010e-01f, -4.56904888e-01f, -1.30576745e-01f, 1.03947602e-01f, -4.50806133e-02f,
  -1.45325854e-01f, 1.67149112e-01f, 1.90162927e-01f, -3.68386686e-01f, 2.19348013e-01f, 1.94485828e-01f, -4.67498124e-01f, -1.64575607e-01f, 2.00619012e-01f, -3.34318787e-01f,
  -4.91663441e-02f, -3.94075125e-01f, -1.66470468e-01f, -1.20829917e-01f, -2.75964618e-01f, 3.61920558e-02f, 2.92490005e-01f, 1.57026493e-03f, -2.43724182e-01f, 4.46546264e-02f,
  -1.33864403e-01f, -1.63774893e-01f, -1.55156091e-01f, -4.94066216e-02f, -1.09125771e-01f, -1.34920046e-01f, 1.18162227e-03f, 4.00819303e-03f, -3.86460274e-02f, -1.31648391e-01f,
  6.39922023e-02f, 8.04889109e-03f, -1.26442119e-01f, 1.55982703e-01f, -1.16160706e-01f, -4.01149765e-02f, 2.28175707e-03f, -4.54260036e-02f, -1.10798374e-01f, 1.44359186e-01f,
  -2.79359277e-02f, -3.85482199e-02f, -5.14081679e-02f, 3.74237262e-02f, 1.23817354e-01f, -6.24881387e-02f, -1.49521986e-02f, 1.19749539e-01f, -6.17319122e-02f, -1.44698052e-02f,
  -5.33921979e-02f, 7.91049078e-02f, 1.89310592e-02f, 1.47227412e-02f, -1.39344662e-01f, -2.20747013e-02f, -6.13464080e-02f, 2.01018676e-02f, 4.82977293e-02f, 1.34770256e-02f,
  -4.19829264e-02f, -1.69951133e-02f, -4.47543189e-02f, -1.52860165e-01f, -1.19243702e-02f, 6.74806861e-03f, -4.64386903e-02f, -4.20180000e-02f, 4.11353074e-02f, 8.26950371e-02f,
  -1.15836114e-02f, -6.22564256e-02f, 1.27485432e-02f, 6.18567802e-02f, -3.17549966e-02f, 2.94528026e-02f, 4.23198938e-03f, -3.40543874e-02f, -1.74553972e-02f, 3.37563939e-02f,
  1.92681551e-02f, -9.07135978e-02f, -5.12420014e-02f, -1.10130250e-01f, 1.95434187e-02f, 2.62452364e-02f, 1.10883573e-02f, 6.26510195e-03f, -1.53085217e-01f, -1.24776147e-01f,
  2.54628211e-02f, 2.25250479e-02f, -1.23331295e-02f, 3.55573371e-02f, 1.22035958e-01f, 2.17308314e-03f, -8.84195119e-02f, 9.54119638e-02f, -1.06460534e-01f, 5.55349365e-02f,
  -2.35556699e-02f, -6.84999377e-02f, 2.03810148e-02f, -2.09843852e-02f, 1.36214674e-01f, 2.09203269e-02f, 3.01014557e-02f, 7.53401443e-02f, -1.32968100e-02f, -3.87949198e-02f,
  -3.40834260e-01f, 6.06702745e-01f, 3.65230411e-01f, -2.25157261e-01f, 1.90573409e-01f, -4.33953032e-02f, -2.55056173e-01f, 2.30462343e-01f, 8.53057802e-02f, -1.43012106e-01f,
  -1.97970062e-01f, 3.14504325e-01f, -4.16029841e-02f, -4.68188860e-02f, -4.11192536e-01f, -1.99000597e-01f, -1.92848876e-01f, -7.61012957e-02f, 1.11814514e-01f, 4.42184806e-02f,
  -3.19291428e-02f, -1.28730267e-01f, 1.09803947e-02f, 2.15303436e-01f, 1.28872246e-01f, 7.46724904e-02f, -3.82763922e-01f, 7.14460462e-02f, 4.26441543e-02f, 1.50531054e-01f,
  -2.03078225e-01f, -2.01606110e-01f, 4.70271222e-02f, 6.27786592e-02f, -7.22291321e-02f, 7.64141371e-03f, -1.40434787e-01f, 2.20634807e-02f, -1.24396598e-02f, 4.76671085e-02f,
  5.15553094e-02f, 7.42828175e-02f, 6.02895021e-02f, -2.86437646e-02f, 1.30291998e-01f, 1.30634353e-01f, 2.34060302e-01f, 9.57572013e-02f, 2.05063596e-01f, 1.34200707e-01f,
  9.38462093e-02f, 1.08636662e-01f, 1.09389117e-02f, 2.47904863e-02f, 6.53674006e-02f, 1.72961354e-02f, 4.38109189e-02f, 1.12981768e-02f, 4.95741814e-02f, 7.37457424e-02f,
  -1.84088424e-02f, 2.47579068e-03f, -8.65201354e-02f, 2.62887981e-02f, 4.34212685e-02f, 7.94814974e-02f, 3.58522832e-02f, -7.31612369e-02f, 1.84289552e-02f, -7.12725669e-02f,
  -2.39266660e-02f, 1.13394164e-01f, -6.08734339e-02f, -1.21261023e-01f, -7.24524260e-02f, -1.25128236e-02f, 8.10731947e-02f, -2.76954006e-03f, -5.81951765e-03f, 1.97649412e-02f,
  -3.83637100e-02f, 2.70298924e-02f, 1.98892429e-02f, 1.85968839e-02f, 3.25924903e-03f, -7.78671578e-02f, -4.87072133e-02f, 1.76986217e-01f, -5.22282813e-03f, -6.17171042e-02f,
  -4.72201973e-01f, -4.52734202e-01f, -1.43099874e-01f, 1.09027009e-04f, 1.64881058e-03f, -5.01701236e-02f, -2.55788807e-02f, 3.82202379e-02f, -2.97915619e-02f, 4.26552780e-02f,
  9.40205529e-03f, -5.46495430e-02f, 3.33167315e-02f, -8.79929289e-02f, -8.24850984e-03f, -1.24522634e-01f, -1.91394284e-01f, -9.05981362e-02f, -1.92900106e-01f, -2.17240732e-02f,
  -4.44566645e-02f, -4.58251089e-02f, -2.38518398e-02f, 1.35438830e-01f, -9.07780379e-02f, -1.51151931e-02f, -4.29475829e-02f, -2.37025693e-02f, -1.08540364e-01f, -3.20933461e-02f,
  -9.26935524e-02f, -3.18559229e-01f, 5.08337021e-01f, -2.56521940e-01f, 2.82837480e-01f, 3.93222034e-01f, 2.37170875e-01f, 1.64575934e-01f, -1.25354871e-01f, -2.87679166e-01f,
  -6.38685971e-02f, -2.01271355e-01f, 2.40869015e-01f, -1.81001186e-01f, 4.45809036e-01f, 1.10176057e-01f, -6.62126765e-02f, -1.82454944e-01f, -8.50577652e-02f, -1.50500283e-01f,
  -7.29340315e-02f, -1.06238499e-01f, 2.99024671e-01f, -1.53726697e-01f, -7.84180015e-02f, -6.81747422e-02f, -1.59388632e-01f, 1.91150174e-01f, -1.49777666e-01f, 6.55375868e-02f,
  3.83640230e-02f, -1.54411212e-01f, -2.05246568e-01f, -1.41217755e-02f, -3.51902172e-02f, -8.02834779e-02f, -1.07454946e-02f, 3.94992679e-02f, -4.44293991e-02f, -2.56513599e-02f,
  -2.81954706e-02f, 4.63151187e-02f, -8.73081312e-02f, 6.05141334e-02f, -1.96145363e-02f, 7.11845160e-02f, 1.11562744e-01f, 3.92236449e-02f, 1.34764627e-01f, 1.60541683e-01f,
  1.72347501e-01f, -5.80841862e-02f, 2.07728567e-03f, -1.46495491e-01f, 8.59367177e-02f, 1.05961114e-02f, -3.87701094e-02f, 2.18513440e-02f, 6.76496997e-02f, -6.29532635e-02f,
  -1.10000581e-03f, -5.79680502e-02f, 7.12457076e-02f, -1.81169938e-02f, 2.70905793e-02f, 8.71469751e-02f, -1.49874836e-01f, 9.25303716e-03f, -4.69429493e-02f, 1.12053700e-01f,
  9.19834003e-02f, -1.06966952e-02f, -3.91107760e-02f, 9.13256928e-02f, -6.20131269e-02f, -1.73064992e-01f, -1.26991391e-01f, -1.00312136e-01f, -1.83602776e-02f, 4.62076515e-02f,
  8.34796801e-02f, 5.72461784e-02f, 6.44600689e-02f, -2.42509209e-02f, -7.16009513e-02f, -2.50921659e-02f, -1.43424839e-01f, 1.28759712e-01f, 5.24253771e-02f, 6.94283098e-02f,
  -3.36267978e-01f, -4.03891474e-01f, -1.67257339e-01f, -1.27951518e-01f, -2.50949800e-01f, -1.30517825e-01f, -1.14972435e-01f, -1.20435499e-01f, -1.67656112e-02f, -1.02403209e-01f,
  2.40895227e-02f, 6.45591272e-03f, 1.59217231e-02f, -1.03487261e-01f, -2.90201511e-02f, 1.54952288e-01f, -6.05445728e-02f, -1.28809080e-01f, -1.05765894e-01f, -3.64045575e-02f,
  -9.66341887e-03f, -7.07461610e-02f, 8.60951021e-02f, -8.47069621e-02f, -1.08371764e-01f, 4.10815813e-02f, -7.14291111e-02f, 9.22731087e-02f, -1.71751417e-02f, -1.16177075e-01f,
  -1.81705933e-02f, -2.43183628e-01f, -1.03158340e-01f, 6.57494925e-03f, -3.30448508e-01f, -5.85937127e-02f, 2.63743490e-01f, -3.52824360e-01f, -1.12678269e-02f, 1.93155184e-02f,
  1.17104411e-01f, 1.48773700e-01f, 3.58006537e-01f, 9.57294106e-02f, 4.08001602e-01f, 3.38416189e-01f, 1.83954030e-01f, 2.43365914e-01f, -1.44518033e-01f, -1.51951984e-01f,
  -1.20683715e-01f, -1.62479520e-01f, 1.35862544e-01f, -4.36547875e-01f, -2.93787032e-01f, -3.92842412e-01f, 3.85645311e-03f, -1.55336231e-01f, -1.07672900e-01f, 4.76769805e-02f,
  -4.69533131e-02f, -1.70981616e-01f, -6.52941167e-02f, 4.86181118e-03f, -1.39962032e-01f, 8.35734084e-02f, 1.02137968e-01f, 4.34453711e-02f, -7.34610185e-02f, -7.46417642e-02f,
  4.18972522e-02f, -8.06163475e-02f, -1.41590536e-01f, -2.91498732e-02f, -3.16505209e-02f, -1.35421157e-01f, -8.23939443e-02f, -6.32337341e-03f, -8.84037241e-02f, 3.86356227e-02f,
  2.77084997e-03f, -1.08434886e-01f, -1.71308964e-02f, 3.01073343e-02f, -4.78838906e-02f, -5.75199630e-03f, -3.04794102e-03f, -6.21447079e-02f, -9.56454948e-02f, -1.13287471e-01f,
  2.48784497e-02f, 8.53926223e-03f, -9.74742547e-02f, -7.62364268e-03f, -1.43066823e-01f, -4.04094309e-02f, 8.13121721e-02f, 6.81919903e-02f, 5.28056845e-02f, -4.19782959e-02f,
  -1.12842120e-01f, 5.94966039e-02f, 6.00178279e-02f, 2.25018151e-02f, 3.23305838e-03f, 1.04266822e-01f, 9.84663963e-02f, -3.05660367e-02f, 7.45737255e-02f, 1.64908580e-02f,
  3.42548825e-02f, 4.11638692e-02f, -5.75538911e-02f, 1.35476187e-01f, 9.17415842e-02f, 5.49888192e-03f, -5.02691381e-02f, -3.28978593e-03f, -8.54184013e-03f, 3.61497067e-02f,
  3.54035497e-02f, -2.10171044e-01f, -6.24530874e-02f, 5.58661669e-02f, 1.25011846e-01f, -4.59319316e-02f, 3.83165199e-03f, -1.47053272e-01f, -1.62975341e-01f, -8.53616223e-02f,
  -5.02386466e-02f, 1.83023270e-02f, -1.08828463e-01f, -2.19634045e-02f, 5.51840514e-02f, -1.22805603e-01f, 1.03638932e-01f, 2.51388866e-02f, -1.08486954e-02f, -2.64308229e-03f,
  4.08118479e-02f, -2.32194811e-02f, -2.85845120e-02f, -1.36207417e-01f, 7.46361725e-03f, 1.69109166e-01f, -7.56712034e-02f, -5.14406711e-02f, -1.98190007e-02f, 1.68007128e-02f,
  2.28675172e-01f, 1.46815166e-01f, 2.93942034e-01f, 5.99641740e-01f, 1.63873971e-01f, 5.22596277e-02f, 2.97860742e-01f, 3.28084886e-01f, 6.18007600e-01f, -1.14311472e-01f,
  1.88231468e-02f, -5.81580848e-02f, 4.20144536e-02f, -2.27922332e-02f, 1.30320817e-01f, 1.27282828e-01f, 4.10905838e-01f, 4.47301567e-02f, 3.56053144e-01f, 1.22525267e-01f,
  4.07869995e-01f, 1.21792845e-01f, -2.27140542e-02f, -2.13343382e-01f, -2.54052430e-02f, 6.35814592e-02f, -1.87342733e-01f, -3.95747498e-02f, -2.46575817e-01f, -7.67767504e-02f,
  3.37273628e-02f, 2.38071471e-01f, -1.37914732e-01f, -6.88896254e-02f, 1.44359440e-01f, -6.93705082e-02f, -1.29337192e-01f, -8.31390917e-02f, 1.78391803e-02f, 5.23313545e-02f,
  1.59282144e-02f, -1.46081590e-03f, 5.46062738e-02f, -4.24449630e-02f, 2.53306963e-02f, 1.99794173e-02f, 1.98248532e-02f, -6.30324930e-02f, 2.70238934e-06f, -4.78121154e-02f,
  -4.55855839e-02f, 9.93952602e-02f, 6.79859892e-02f, 8.78845528e-02f, -2.27436088e-02f, 1.39856130e-01f, -4.52776812e-02f, 3.43942717e-02f, -3.03994324e-02f, 1.30185366e-01f,
  6.56426745e-03f, 6.07686676e-02f, -5.84112853e-02f, -9.38529447e-02f, -5.65577671e-02f, -5.00234365e-02f, -4.62603346e-02f, -9.00897458e-02f, -1.72022283e-02f, 8.48487485e-03f,
  6.78949133e-02f, 4.85674068e-02f, 8.55565257e-03f, 1.33817112e-02f, 1.41679078e-01f, -5.02413213e-02f, -5.03477491e-02f, 1.10898450e-01f, 1.76259309e-01f, -7.40050822e-02f,
  5.38468994e-02f, -5.26837111e-02f, -5.88237904e-02f, -5.45334890e-02f, -4.55167554e-02f, 1.69138387e-02f, 3.05345040e-02f, -2.13133544e-02f, -1.28373941e-02f, 9.06711742e-02f,
  1.98317990e-01f, 4.02876973e-01f, 2.88166981e-02f, -5.98688163e-02f, 1.78676508e-02f, -8.80511925e-02f, -1.52259162e-02f, -3.49800326e-02f, 1.82663247e-01f, 8.21066797e-02f,
  1.00469261e-01f, -1.56840850e-02f, 4.53634635e-02f, -9.32001844e-02f, 5.77455312e-02f, -9.57654268e-02f, 6.67851120e-02f, 2.26931758e-02f, 1.54119089e-01f, -2.45340876e-02f,
  -1.47875220e-01f, 7.18219727e-02f, 1.01437412e-01f, 8.11908096e-02f, -2.38580606e-03f, 3.66877019e-02f, -3.91588174e-02f, -1.48698026e-02f, 3.87593210e-02f, 1.19519807e-01f,
  3.69020283e-01f, 4.44763117e-02f, 3.87695342e-01f, 1.10592991e-01f, -2.02216953e-01f, 1.30078793e-01f, 3.10056239e-01f, -3.69601727e-01f, 1.31812885e-01f, -1.89294934e-01f,
  -1.92238614e-01f, 5.51807463e-01f, 1.00660250e-01f, 2.60717552e-02f, 1.76330641e-01f, 1.40518948e-01f, 3.34038623e-02f, 2.84538805e-01f, -1.69040412e-01f, -1.17493637e-01f,
  -1.68932945e-01f, -3.31518352e-01f, -1.53818019e-02f, -3.88509423e-01f, 8.67767707e-02f, 3.67785655e-02f, -2.41720393e-01f, 5.30201495e-02f, 1.04262177e-02f, 3.72877009e-02f,
  -1.28776189e-02f, -1.80338666e-01f, -5.79432992e-04f, 1.04162559e-01f, -2.01039240e-02f, 1.12664267e-01f, 6.16339184e-02f, 1.87317535e-01f, 5.42571656e-02f, 4.59053963e-02f,
  1.43056348e-01f, 1.92547217e-02f, 7.70658180e-02f, 2.05247793e-02f, -6.04169481e-02f, 9.90089178e-02f, -5.28039262e-02f, -9.82575491e-02f, 5.44999242e-02f, 8.53621811e-02f,
  1.94066182e-01f, 7.64362440e-02f, 7.42962062e-02f, 1.09335929e-01f, 1.24554098e-01f, -5.54169044e-02f, 6.38341680e-02f, 1.63313314e-01f, 2.80408678e-03f, 2.10201442e-02f,
  -1.07002661e-01f, 3.17396522e-02f, 1.41934250e-02f, -1.42416671e-01f, 1.05687641e-02f, -8.37489516e-02f, 6.37325197e-02f, -1.38375610e-01f, 7.57411197e-02f, -1.37865208e-02f,
  -7.47766718e-02f, 7.30681932e-03f, -1.45206004e-01f, 1.61101948e-02f, -4.63033952e-02f, -1.13555238e-01f, 1.57669172e-01f, 6.89978972e-02f, -4.31348663e-03f, 2.99229883e-02f,
  1.40789682e-02f, 6.30024215e-03f, -3.29212248e-02f, 8.29458535e-02f, 1.16562903e-01f, 5.30052334e-02f, -1.13858648e-01f, 1.89799517e-01f, -1.17262088e-01f, 7.45218396e-02f,
  4.63172495e-02f, -4.17453237e-02f, 4.39262055e-02f, 5.46488492e-03f, -1.35221304e-02f, -1.08831741e-01f, -1.34760328e-02f, 1.08906955e-01f, 8.98032859e-02f, -4.22411971e-02f,
  -2.99197081e-02f, 5.66911325e-02f, 3.22421752e-02f, 1.18801985e-02f, -6.14992250e-03f, 3.12821604e-02f, 3.21824923e-02f, -1.14069633e-01f, -8.65787491e-02f, -4.43451144e-02f,
  1.05314225e-01f, 4.52764258e-02f, 1.29819334e-01f, 5.51543497e-02f, 9.01452601e-02f, 1.16984002e-01f, 4.53438796e-02f, 3.11950818e-02f, -5.03601916e-02f, 6.42429013e-03f,
  -9.20487463e-01f, 2.75091559e-01f, -6.41240478e-02f, -1.31366923e-01f, -3.61259103e-01f, 1.27143160e-01f, 7.19305649e-02f, -6.51003495e-02f, -9.04481262e-02f, 3.01454812e-01f,
  -6.65129796e-02f, -1.67838514e-01f, 3.64225864e-01f, 1.50402188e-01f, -1.37962326e-01f, 2.91979730e-01f, -1.09641619e-01f, 7.17864186e-02f, -4.03065123e-02f, -9.80240479e-02f,
  6.18515499e-02f, -9.51890722e-02f, 6.05044812e-02f, 1.13601321e-02f, -3.06636363e-01f, -1.28079146e-01f, -1.48915172e-01f, 1.48507832e-02f, -1.78353623e-01f, -1.39589667e-01f,
  -4.10773426e-01f, -3.55204463e-01f, -2.42596135e-01f, -1.28342807e-01f, -2.53044903e-01f, -9.65089500e-02f, -6.56745881e-02f, -7.05782771e-02f, -1.36397183e-01f, 4.60607111e-02f,
  3.22371908e-02f, 1.55160129e-02f, -1.25018898e-02f, 3.74360569e-02f, -5.85056394e-02f, -1.91265922e-02f, -5.44500612e-02f, -8.95583630e-02f, -2.60672383e-02f, 4.56721932e-02f,
  1.34433741e-02f, -3.36079150e-02f, -1.23616926e-01f, 5.79308383e-02f, -1.65715188e-01f, -7.41621777e-02f, 2.93923989e-02f, -2.69905012e-03f, -1.97898261e-02f, -1.72465041e-01f,
  -1.67175904e-02f, 7.25459903e-02f, 7.89271593e-02f, 2.92133335e-02f, 3.11814807e-02f, 4.09447122e-03f, 6.29834384e-02f, -6.27718214e-03f, 1.72718130e-02f, 6.28167316e-02f,
  -9.30416510e-02f, -1.26338705e-01f, -1.60081312e-01f, 3.41316275e-02f, 4.82505076e-02f, 8.59143808e-02f, 1.50940176e-02f, -6.96974173e-02f, 5.60114011e-02f, -7.78360143e-02f,
  -2.38529984e-02f, -1.09106861e-01f, 6.65482506e-02f, 1.32470056e-01f, -1.06600136e-01f, -2.84729097e-02f, -7.82522634e-02f, 9.97890308e-02f, -4.08484340e-02f, -1.08764499e-01f,
  -5.36775053e-01f, -4.43418741e-01f, -6.69486150e-02f, -1.85751915e-01f, -1.39148533e-01f, -5.96966483e-02f, -3.04319616e-02f, -6.80761412e-02f, -1.41616225e-01f, -1.07612852e-02f,
  -6.32489324e-02f, 5.06513342e-02f, -1.98318079e-01f, 9.23789591e-02f, 1.01797894e-01f, 1.03087522e-01f, 2.76706126e-02f, -2.64190864e-02f, -1.40416145e-01f, -4.75261211e-02f,
  4.85289544e-02f, -9.47336573e-03f, 1.45331085e-01f, 6.24443367e-02f, -7.03639388e-02f, 1.88253243e-02f, -1.03545718e-01f, 2.81068198e-02f, -1.50266081e-01f, 8.38823766e-02f,
  5.10706604e-01f, 1.18152149e-01f, 1.81773961e-01f, 4.43504542e-01f, 3.10335010e-01f, 1.11846693e-01f, -2.98043829e-03f, 2.37934038e-01f, 4.09130275e-01f, -2.12516308e-01f,
  -1.63398653e-01f, -7.48297125e-02f, -1.84569880e-01f, 1.19815715e-01f, -3.45280349e-01f, -1.30794078e-01f, -3.59415216e-03f, -1.49774358e-01f, 2.56194383e-01f, 1.46300346e-01f,
  3.00810784e-01f, -1.82971850e-01f, 1.02530979e-01f, -1.55760916e-02f, 2.22808272e-01f, 2.17952803e-01f, -3.77609760e-01f, -8.27836245e-02f, -1.57518223e-01f, -1.77859440e-01f,
  1.00939579e-01f, 1.88944370e-01f, 2.06778362e-01f, -1.40862446e-03f, 1.22294009e-01f, 1.98018085e-02f, -2.70883623e-03f, -1.72957301e-01f, -1.42184068e-02f, -4.59954776e-02f,
  -3.32801715e-02f, -5.37530938e-03f, -1.85229480e-02f, 2.33200714e-02f, 9.15904641e-02f, 6.78497106e-02f, 3.02435547e-01f, 2.48089492e-01f, 4.07739021e-02f, 7.59646520e-02f,
  1.48307189e-01f, 1.03973381e-01f, 6.72335699e-02f, -1.32512897e-01f, -5.64024337e-02f, -2.49849316e-02f, 2.57749984e-04f, -3.28809805e-02f, -1.46372458e-02f, 1.30532563e-01f,
  -7.19551891e-02f, -1.27701582e-02f, -8.39556158e-02f, 3.59303132e-02f, -8.51970166e-02f, 2.30801757e-02f, -5.45408837e-02f, 5.92369167e-03f, 2.44612638e-02f, 2.09453923e-04f,
  6.05613701e-02f, 2.32745102e-03f, 1.12734027e-01f, 1.34503260e-01f, -3.04934382e-02f, 1.38872340e-01f, -1.44686475e-01f, -1.37701124e-01f, 9.00877193e-02f, -2.13395134e-02f,
  -9.46041569e-02f, -1.53424889e-01f, 6.06747940e-02f, -6.52778428e-03f, -4.72834073e-02f, -1.21531568e-01f, 1.16202585e-01f, -5.90396859e-03f, 2.11496279e-01f, -1.26463220e-01f,
  -3.48087966e-01f, -5.31835496e-01f, -4.13284525e-02f, 2.94113010e-02f, -1.07823677e-01f, 6.36319146e-02f, 2.44977102e-02f, 1.85434893e-02f, -1.70351624e-01f, -8.82823318e-02f,
  1.28085576e-02f, 2.18517259e-02f, -1.95310041e-01f, 2.72752587e-02f, -4.64745164e-02f, -5.34934290e-02f, -3.77367064e-02f, -7.44532198e-02f, -7.72730559e-02f, -7.64160082e-02f,
  -1.04621135e-01f, -5.40790334e-02f, 8.74078497e-02f, 5.48419729e-02f, 3.22471522e-02f, -6.32777214e-02f, -1.43393446e-02f, -3.83179337e-02f, -2.05251947e-01f, -9.59950686e-03f,
  -7.04667807e-01f, 4.83228326e-01f, 1.85571626e-01f, -4.84127104e-02f, 3.32986772e-01f, 5.98822832e-01f, 2.22679511e-01f, 3.96147192e-01f, 5.16069233e-01f, 1.19857088e-01f,
  -2.30924226e-02f, -6.53970689e-02f, -2.93936003e-02f, -5.25572971e-02f, 2.42541614e-03f, 2.18113288e-01f, 3.07842612e-01f, 5.87092042e-02f, 3.78450841e-01f, -6.30839393e-02f,
  1.07112117e-01f, 5.84347099e-02f, -4.14558090e-02f, 5.62849119e-02f, -1.09728694e-01f, -1.22214779e-01f, -3.24855834e-01f, 4.41954558e-04f, -4.80656810e-02f, 1.76073804e-01f,
  -1.76110826e-02f, -5.82529046e-02f, -1.30699024e-01f, 4.94362190e-02f, -9.74858180e-02f, 6.67526647e-02f, -7.08621070e-02f, -1.15500651e-01f, 6.76761419e-02f, 3.37935798e-02f,
  -1.07646495e-01f, 1.03305664e-03f, 1.78856868e-02f, -7.46349171e-02f, 2.29192063e-01f, 8.67987052e-02f, 1.11365676e-01f, 1.02394506e-01f, 6.71242550e-02f, 1.68521181e-02f,
  2.16812715e-02f, 5.68453707e-02f, -4.86141853e-02f, 1.70961469e-01f, 7.02080205e-02f, 5.00509553e-02f, 2.04608645e-02f, -5.16188405e-02f, 8.67216066e-02f, 2.23764524e-01f,
  1.16979606e-01f, 6.51417077e-02f, 1.32725760e-01f, 5.68946898e-02f, -1.71741284e-02f, -5.61794974e-02f, 1.39351059e-02f, -1.93895027e-01f, -7.71160200e-02f, -1.03909396e-01f,
  1.47946337e-02f, -4.92737889e-02f, 7.39192683e-03f, 3.11597390e-03f, 1.34670317e-01f, -2.24888325e-04f, 1.23428842e-02f, 4.39798497e-02f, -3.62695977e-02f, 3.31510119e-02f,
  7.73784518e-02f, -2.14077942e-02f, -5.85387796e-02f, 4.61983681e-03f, 9.37536210e-02f, -2.60000583e-02f, 2.90704146e-02f, 1.57352298e-01f, -1.56821478e-02f, -4.90020029e-02f,
  2.63469070e-01f, 2.79893190e-01f, -2.18759608e-02f, -4.36884314e-02f, 7.62757333e-03f, 6.49077147e-02f, -2.01971978e-02f, 2.09170859e-02f, 2.02275947e-01f, 1.21868275e-01f,
  -6.72581345e-02f, -6.08356707e-02f, -3.36782783e-02f, -5.35608977e-02f, 1.83204655e-02f, 1.39943495e-01f, -1.25592396e-01f, -4.12664600e-02f, -2.00550053e-02f, 1.63348932e-02f,
  -1.87259689e-01f, 1.52703775e-02f, 5.19154258e-02f, -3.22167855e-03f, -6.19953871e-02f, -3.95752378e-02f, 1.06386086e-02f, 5.63005619e-02f, 3.18034329e-02f, 1.03206806e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 20)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 20;
const float L0_fan_Bp_bar_data[] = {
  1.22649036e-01f, 3.52780759e-01f, 3.26892704e-01f, 2.80892164e-01f, 1.77218646e-01f, 5.53534590e-02f, 4.16398525e-01f, 4.71851766e-01f, 2.40148693e-01f, 4.22752351e-01f,
  3.23736310e-01f, 6.14836104e-02f, 3.65500778e-01f, 3.35187763e-01f, 4.21871454e-01f, 2.85451025e-01f, 5.71447313e-01f, 3.49676639e-01f, 3.96375746e-01f, 4.55409527e-01f
};

// L1_fan_Wp (Shape: 6 x 32)
const int L1_fan_Wp_rows = 6;
const int L1_fan_Wp_cols = 32;
const float L1_fan_Wp_data[] = {
  -1.06343944e-02f, 2.63879616e-02f, -4.35380749e-02f, 2.08427832e-01f, -7.19431490e-02f, -4.58815172e-02f, -4.27694678e-01f, -7.99273774e-02f, -3.08842093e-01f, 2.71615207e-01f,
  -4.30719405e-01f, 1.74464986e-01f, -3.23393941e-01f, 4.40594694e-03f, -1.19697690e-01f, 3.56407046e-01f, 2.53233407e-02f, 3.91065598e-01f, -1.01436228e-01f, -3.10271025e-01f,
  -2.91046146e-02f, 2.69739646e-02f, 3.55094741e-03f, 8.73652287e-03f, -1.87272727e-01f, -2.11109295e-01f, -2.22452395e-02f, 1.19046219e-01f, -1.67074710e-01f, 2.03425795e-01f,
  -1.92370355e-01f, 1.77828670e-01f, 1.95428193e-01f, -2.95715313e-02f, 1.05017416e-01f, -8.59832242e-02f, -1.30300894e-01f, -1.36985499e-02f, 1.96772665e-02f, -2.01776892e-01f,
  -2.21675038e-01f, -1.16586655e-01f, 6.26145527e-02f, 3.61234963e-01f, -2.65121102e-01f, -1.73519954e-01f, 2.27378249e-01f, 1.76181212e-01f, 6.57043457e-02f, -6.35713488e-02f,
  2.27396920e-01f, 1.22814216e-02f, 1.02801602e-02f, -4.62660640e-02f, 5.58867902e-02f, 2.48887315e-01f, 2.18650818e-01f, -4.67846878e-02f, -2.90388674e-01f, -2.32900217e-01f,
  -2.35054120e-01f, 2.79702321e-02f, -2.97771692e-01f, 5.73999844e-02f, -3.83339152e-02f, 1.30379781e-01f, -5.38156778e-02f, -3.98295745e-02f, 2.64556035e-02f, -5.95855266e-02f,
  1.53224885e-01f, 2.98220720e-02f, 1.30853698e-01f, -2.10038573e-02f, 3.93250547e-02f, -6.57319129e-02f, -8.30440130e-03f, -1.34642050e-01f, -1.61119521e-01f, 8.94872099e-02f,
  -2.01425571e-02f, -1.09929562e-01f, 2.19714060e-01f, -2.21119553e-01f, 4.87538129e-02f, -1.64216056e-01f, -2.39641443e-01f, 2.35424310e-01f, 1.83484986e-01f, -2.04248518e-01f,
  6.25991495e-03f, -1.13393396e-01f, 1.84572302e-02f, 7.91299865e-02f, 7.73748532e-02f, -9.97944474e-02f, 3.01668979e-02f, -1.05436370e-01f, 5.50402291e-02f, -1.37875453e-01f,
  -2.17361689e-01f, -1.78657584e-02f, 1.08292483e-01f, 2.06592813e-01f, -2.16944113e-01f, -3.67053688e-01f, 1.98498651e-01f, 6.01155572e-02f, 1.77211668e-02f, 8.75051990e-02f,
  1.74337313e-01f, -1.55598164e-01f, 2.07630247e-01f, -2.45869353e-01f, -1.07182361e-01f, 2.08109111e-01f, 8.51287767e-02f, -2.15548888e-01f, -2.09510863e-01f, 1.08053349e-01f,
  -1.46386564e-01f, 4.15292114e-01f, -4.84716669e-02f, -5.51922508e-02f, -6.91037029e-02f, 1.83764338e-01f, -9.76997241e-03f, 3.12893540e-02f, 1.12466380e-01f, -3.18106636e-02f,
  -2.53569596e-02f, -2.45996136e-02f, -1.87997133e-01f, -2.19533682e-01f, -1.56611636e-01f, 2.43442282e-02f, -2.71560818e-01f, -1.32829830e-01f, -1.67047799e-01f, 3.70429277e-01f,
  -2.44845916e-03f, 9.99706015e-02f, -4.97582601e-03f, 2.40894288e-01f, 1.29491240e-01f, 2.44667575e-01f, -5.49107976e-02f, -7.03153685e-02f, -3.81999940e-01f, 1.07856773e-01f,
  -1.80711135e-01f, -1.13546021e-01f, 2.04435661e-01f, 1.68838218e-01f, -3.03187460e-01f, 1.89313609e-02f, -3.34954798e-01f, 2.78728187e-01f, 7.66811967e-02f, -7.69385695e-02f,
  -1.18771590e-01f, -1.82122469e-01f, -5.58422394e-02f, 7.65555650e-02f, -1.21759698e-02f, 6.10109456e-02f, -1.76462069e-01f, 8.79566297e-02f, -2.43447617e-01f, 5.85844517e-02f,
  5.91950156e-02f, -1.12683281e-01f, 5.04874960e-02f, 1.90597922e-01f, -1.24148220e-01f, -2.44538844e-01f, 2.47698605e-01f, 2.48754725e-01f, -2.04329953e-01f, 5.21664880e-02f,
  1.90778881e-01f, -1.78323135e-01f, -2.38910466e-02f, 1.80740476e-01f, -3.05287242e-01f, 2.29994312e-01f, 3.24647129e-01f, 1.64318383e-01f, 1.74255580e-01f, -3.38803343e-02f,
  -2.27013364e-01f, 4.36270423e-02f
};

// L1_fan_Wp_bar (Shape: 20 x 32)
const int L1_fan_Wp_bar_rows = 20;
const int L1_fan_Wp_bar_cols = 32;
const float L1_fan_Wp_bar_data[] = {
  1.51083142e-01f, 4.09850806e-01f, 1.11285552e-01f, 4.98235583e-01f, 5.36296606e-01f, 3.77461791e-01f, 2.02421546e-01f, 5.45387268e-02f, 4.77066547e-01f, 5.64512968e-01f,
  1.51732907e-01f, -3.56893212e-01f, -2.13783473e-01f, -8.42213854e-02f, 2.14065164e-01f, -8.38379562e-02f, -7.82870799e-02f, -7.15923160e-02f, -9.69713777e-02f, 2.87702590e-01f,
  1.61300987e-01f, 5.39698899e-01f, 5.36185384e-01f, -5.12562394e-01f, 7.74985626e-02f, 2.69409716e-01f, 2.96260029e-01f, -1.00785762e-01f, 5.90524614e-01f, -4.49988335e-01f,
  4.98180091e-01f, 1.55427873e-01f, -1.68451220e-01f, 2.10601434e-01f, 3.27580512e-01f, 2.36822382e-01f, 1.48939446e-01f, -7.29370713e-02f, -4.44159865e-01f, 2.44996086e-01f,
  -3.83629262e-01f, -1.39766335e-01f, -1.42849550e-01f, 2.12194070e-01f, -2.16715127e-01f, -3.18134874e-01f, -2.27317765e-01f, 8.94105956e-02f, 5.39378002e-02f, 3.47046018e-01f,
  4.38094527e-01f, -1.81423619e-01f, 3.39867473e-01f, -1.73167348e-01f, -4.03993338e-01f, 3.73076349e-01f, -2.29869455e-01f, -1.16599075e-01f, 1.57131881e-01f, 5.33433735e-01f,
  1.52912989e-01f, 7.87035763e-01f, -3.01879644e-01f, 4.93752986e-01f, 3.76222789e-01f, 2.44329080e-01f, 3.47108901e-01f, 3.81573662e-02f, 2.03980073e-01f, 1.72394559e-01f,
  1.90004542e-01f, -3.04941177e-01f, -1.30342707e-01f, 7.91297853e-02f, 1.80750236e-01f, 4.33606327e-01f, 1.23477578e-01f, -3.98486704e-01f, 4.92731452e-01f, 1.51461244e-01f,
  -9.16388556e-02f, -2.93015569e-01f, 4.54496711e-01f, 4.07540441e-01f, 1.65104911e-01f, 3.60779881e-01f, 4.05425459e-01f, 5.34330606e-01f, 3.73194724e-01f, 3.08982790e-01f,
  -4.51447695e-01f, -5.12644529e-01f, -8.48798379e-02f, 6.35804161e-02f, 1.12881571e-01f, 1.61901757e-01f, -3.37922387e-02f, 2.04271898e-01f, 3.28881204e-01f, 2.11670652e-01f,
  2.00187504e-01f, 1.69883192e-01f, -1.99272111e-01f, 3.04327369e-01f, -2.62331545e-01f, -3.47720116e-01f, 4.33650762e-02f, 1.95735663e-01f, -2.13614017e-01f, -4.25714254e-01f,
  5.21862447e-01f, -2.36661490e-02f, 1.62796333e-01f, 7.59639740e-02f, 1.76665440e-01f, 1.84625596e-01f, 8.50726888e-02f, -1.27775386e-01f, -2.87774920e-01f, 2.45763466e-01f,
  -3.27495039e-02f, 2.81606197e-01f, 3.05200040e-01f, 1.22696750e-01f, 2.83952743e-01f, 6.26847446e-01f, -4.38425779e-01f, 3.63734812e-01f, -2.65199579e-02f, 2.04916507e-01f,
  2.25503564e-01f, 5.58791518e-01f, 4.93908711e-02f, 3.69506389e-01f, -5.08809626e-01f, 1.88204184e-01f, 3.07598174e-01f, 5.19314170e-01f, -2.39049971e-01f, -4.08084065e-01f,
  -3.56369764e-01f, 4.47657317e-01f, -9.45259854e-02f, -9.44892913e-02f, 2.66352236e-01f, 1.97873697e-01f, -2.30913907e-01f, -4.32012439e-01f, 4.31336820e-01f, -1.69682831e-01f,
  2.42364243e-01f, 3.58408242e-01f, -4.77795184e-01f, 1.04493894e-01f, 4.46828485e-01f, 3.45958322e-01f, 1.80436015e-01f, 3.82655188e-02f, 6.01711385e-02f, 5.03892064e-01f,
  1.35789260e-01f, 1.50712892e-01f, -1.14216752e-01f, 2.26835370e-01f, -1.45250540e-02f, -7.61684775e-02f, 1.00316651e-01f, -1.71966240e-01f, 5.27451515e-01f, 2.82935768e-01f,
  -3.17034982e-02f, -4.76744384e-01f, 5.34136713e-01f, 6.46824896e-01f, -2.27941543e-01f, 1.98561981e-01f, 1.42610401e-01f, 3.27817738e-01f, 3.12584102e-01f, -3.96567196e-01f,
  3.83823104e-02f, -7.06821308e-02f, -9.52444673e-02f, 2.33706251e-01f, 5.94933093e-01f, -8.06094408e-02f, -2.25877941e-01f, -6.23445660e-02f, 1.76119246e-02f, -1.57014921e-01f,
  7.88254499e-01f, 6.94206730e-02f, 3.87639739e-02f, 1.88348204e-01f, -5.81074767e-02f, 5.17741637e-03f, -2.90591381e-02f, 2.75617212e-01f, 3.32125053e-02f, -3.47167253e-01f,
  -1.43802851e-01f, 1.72032610e-01f, 2.86015987e-01f, 4.24809545e-01f, -4.02968079e-01f, -2.02460960e-01f, 3.72547328e-01f, 5.64654432e-02f, 3.62661660e-01f, 5.04432082e-01f,
  -5.68076484e-02f, 5.93996704e-01f, 1.92079112e-01f, 2.75395304e-01f, 6.97013438e-01f, 2.30598614e-01f, -9.78109092e-02f, 2.04418570e-01f, 3.29829037e-01f, -3.47990483e-01f,
  1.03172824e-01f, 8.12514573e-02f, -3.71621013e-01f, -1.16776605e-03f, 2.31254965e-01f, 4.08420205e-01f, 3.05868715e-01f, 3.66833121e-01f, -1.53400470e-02f, 2.48461619e-01f,
  -3.04699212e-01f, 3.67044508e-01f, 3.42203408e-01f, 3.18988919e-01f, -2.73013294e-01f, -1.72642753e-01f, -1.32390529e-01f, 2.64158756e-01f, 3.46053332e-01f, 1.91634640e-01f,
  3.48745912e-01f, 2.04830199e-01f, -1.10158429e-01f, -5.51364005e-01f, -1.45775005e-01f, 2.30667010e-01f, -8.91036540e-02f, -3.93062711e-01f, 3.15154910e-01f, 2.82053590e-01f,
  -8.62404853e-02f, 9.45721865e-02f, 2.78567612e-01f, -7.54152611e-02f, 4.17504430e-01f, 4.35311258e-01f, -4.76520602e-03f, -2.98615634e-01f, -1.66898325e-01f, -5.76609075e-02f,
  -2.82386336e-02f, 1.12976991e-01f, 6.03357971e-01f, 8.31543934e-03f, 3.92815590e-01f, -4.58375722e-01f, 7.66716778e-01f, -3.78646433e-01f, 4.74539727e-01f, 2.20261529e-01f,
  1.84934353e-03f, -1.59322634e-01f, 5.41518964e-02f, -6.27125949e-02f, -9.05028731e-02f, 4.28755552e-01f, 4.74269480e-01f, -4.66718942e-01f, 2.30103031e-01f, 4.00130868e-01f,
  -7.89396558e-03f, 3.92328650e-01f, 3.99145156e-01f, 3.01941067e-01f, 2.27108493e-01f, -3.94411057e-01f, 3.77288163e-01f, -4.74389911e-01f, 2.20123082e-02f, 2.20727608e-01f,
  3.72264683e-01f, 2.43944824e-01f, 3.85270834e-01f, 1.42104059e-01f, -1.52892545e-02f, 3.81695777e-01f, 1.21944390e-01f, -1.40973806e-01f, 1.44179001e-01f, -9.80003774e-02f,
  2.72253305e-01f, -1.48682445e-01f, -1.09230459e-01f, -4.64529216e-01f, -7.82453790e-02f, -4.67726588e-01f, -2.05174126e-02f, -1.25218192e-02f, 2.28638127e-01f, 1.74391747e-01f,
  -3.82112324e-01f, -3.34308118e-01f, 2.08567232e-02f, 3.25324327e-01f, 2.66717017e-01f, 4.78388786e-01f, 5.72278976e-01f, 1.68337435e-01f, 4.57029134e-01f, 4.84035879e-01f,
  3.68291765e-01f, 2.57367998e-01f, -1.66969709e-02f, 1.42219201e-01f, -4.23978716e-02f, 1.43865934e-02f, -2.44319275e-01f, -2.61064947e-01f, -2.25286901e-01f, 2.93216016e-02f,
  -2.59174973e-01f, 4.75503147e-01f, -3.16836119e-01f, -2.18954477e-02f, 1.38770819e-01f, 3.73636752e-01f, -3.27450544e-01f, 5.40036857e-01f, 3.46510798e-01f, 5.55374205e-01f,
  -2.07333162e-01f, -9.68744755e-02f, 4.55272049e-01f, -2.18904279e-02f, 4.77023154e-01f, 1.64149940e-01f, -8.76651853e-02f, -4.67814058e-01f, -3.13975543e-01f, 3.50955337e-01f,
  1.37668634e-02f, 2.98873276e-01f, 5.13392612e-02f, -2.48741478e-01f, 5.38895875e-02f, -1.68452729e-02f, -2.20285486e-02f, -3.40348005e-01f, 3.25464725e-01f, -1.26596943e-01f,
  -1.55378357e-01f, -4.81278211e-01f, 3.32688272e-01f, 4.12072651e-02f, 4.94268477e-01f, 2.44832888e-01f, -2.93857664e-01f, -1.41406298e-01f, 2.73438841e-01f, 3.47812563e-01f,
  -1.49432570e-01f, 5.23322821e-01f, 1.95257261e-01f, -1.11842155e-02f, 1.16175435e-01f, -1.37211442e-01f, 1.26043782e-01f, 2.02059537e-01f, -2.40356371e-01f, 4.67201442e-01f,
  -4.84646410e-01f, 2.40543321e-01f, 5.74134707e-01f, 1.77137002e-01f, 2.22678632e-01f, 1.59005448e-01f, 2.64935017e-01f, 2.88765460e-01f, 2.53777921e-01f, 2.43407026e-01f,
  2.35256776e-01f, 2.76396155e-01f, 1.92085952e-01f, -9.11382437e-02f, 2.85487652e-01f, -1.89005196e-01f, -2.68046986e-02f, -1.48511857e-01f, 4.89745528e-01f, -1.23397075e-01f,
  7.34399185e-02f, -5.33959866e-01f, 4.23151255e-01f, 1.01266049e-01f, 1.97628409e-01f, -2.20035508e-01f, -2.49805868e-01f, 3.12411964e-01f, 3.14500749e-01f, 4.16668653e-01f,
  -5.34938164e-02f, 9.19448733e-02f, 4.33807641e-01f, 4.63398099e-02f, 2.14813054e-01f, 3.63336891e-01f, 2.00179502e-01f, 2.42162287e-01f, 9.75876972e-02f, 1.04290225e-01f,
  -1.45886719e-01f, 1.43496886e-01f, -7.76715800e-02f, 2.71906376e-01f, -4.56897393e-02f, -3.09018463e-01f, 2.58063942e-01f, 3.72645169e-01f, -2.35119402e-01f, -2.06230238e-01f,
  6.74478173e-01f, -4.98880804e-01f, 1.99567720e-01f, 6.09875321e-01f, -1.54405430e-01f, 5.34818172e-01f, -1.01217508e-01f, -1.27586603e-01f, 1.26023358e-02f, -4.26273942e-02f,
  5.93820997e-02f, 3.42221707e-01f, 3.70282710e-01f, -5.23599863e-01f, 2.87465155e-01f, 4.14506197e-01f, -4.41424131e-01f, 1.23593494e-01f, 8.73686522e-02f, 2.16279060e-01f,
  7.39408433e-02f, 1.39631107e-01f, 2.13259116e-01f, 2.73955166e-01f, 4.63755950e-02f, 3.64813089e-01f, -2.99389772e-02f, -1.53504089e-01f, 2.67608911e-01f, 1.70538705e-02f,
  -2.94470668e-01f, 4.06383350e-02f, 3.04003209e-01f, -2.80987144e-01f, -2.55117435e-02f, -6.67312384e-01f, -2.75715403e-02f, 2.68275261e-01f, 2.94119805e-01f, -2.55183876e-01f,
  -1.94973856e-01f, -2.75056928e-01f, -8.58999323e-03f, 4.26637441e-01f, 1.38278976e-02f, 3.49220544e-01f, 1.73818246e-01f, 1.34770453e-01f, 3.12563986e-01f, 4.76755798e-01f,
  1.95322722e-01f, -6.78788424e-02f, 5.11507206e-02f, 7.31118768e-02f, 1.11054078e-01f, 2.17060849e-01f, -3.80027384e-01f, -3.12788010e-01f, -3.64717871e-01f, 4.53351080e-01f,
  -4.35776591e-01f, 8.35327581e-02f, 1.90888286e-01f, 4.23352450e-01f, -3.19085211e-01f, 2.16053292e-01f, 2.49417230e-01f, 4.69831705e-01f, -3.00256797e-04f, 2.05467433e-01f,
  1.66429728e-01f, 1.38744503e-01f, 6.49061203e-01f, 5.01882195e-01f, -6.00064337e-01f, -9.93230641e-02f, 4.38619077e-01f, 5.47968931e-02f, -2.09985688e-01f, 8.78455639e-02f,
  -4.13231373e-01f, -6.78135827e-02f, -1.03263110e-01f, 1.47315070e-01f, 1.87561914e-01f, 1.32440850e-01f, -1.71753559e-02f, -1.24297373e-01f, -1.99964233e-02f, 1.78528056e-01f,
  -2.01490656e-01f, -5.15407026e-01f, 2.69617826e-01f, 3.56910080e-01f, -1.72333375e-01f, -2.23317713e-01f, 2.20720726e-03f, -2.87404973e-02f, 3.12509596e-01f, 2.52500828e-02f,
  3.65121216e-01f, -4.81640697e-02f, 1.82111114e-01f, -7.65265077e-02f, -3.98149669e-01f, 9.23906937e-02f, 3.33052695e-01f, 3.69439095e-01f, 1.30989209e-01f, 2.42264122e-01f,
  1.56088501e-01f, 5.21889269e-01f, 4.50797349e-01f, 2.80785918e-01f, 3.48084539e-01f, 3.06330547e-02f, 2.75876701e-01f, 2.54140019e-01f, 1.60034075e-01f, 3.86864096e-02f,
  -4.40136939e-01f, 2.50332132e-02f, -5.33731937e-01f, 1.36622548e-01f, -6.28698230e-01f, 1.47091389e-01f, 5.60602009e-01f, 2.65172869e-01f, 1.36728305e-02f, 8.15390050e-01f,
  -5.53883426e-02f, 2.94010937e-01f, 4.43652868e-01f, -1.63148865e-01f, -2.69342661e-01f, 3.75344217e-01f, -1.40753999e-01f, -6.90416992e-02f, 4.48502675e-02f, -2.39445463e-01f,
  4.22024503e-02f, 4.91649896e-01f, -5.85779548e-02f, 3.79987687e-01f, -1.18975572e-01f, 3.62533480e-01f, 2.19235197e-02f, 1.03085682e-01f, -2.26365160e-02f, 4.01995033e-02f,
  -1.20623298e-01f, 1.07546516e-01f, 1.61923811e-01f, -4.61717471e-02f, 1.71497464e-01f, 9.46176331e-03f, 4.08675939e-01f, -2.30783075e-01f, 1.62437975e-01f, 4.53188509e-01f,
  6.33972406e-01f, -1.79837376e-01f, 4.32021081e-01f, 4.05404061e-01f, 5.27363755e-02f, 4.62660134e-01f, 2.92887539e-01f, -3.11912984e-01f, 3.95548582e-01f, 2.53342390e-01f,
  1.58516802e-02f, 4.87089872e-01f, 2.71931946e-01f, -1.59259930e-01f, -1.43854646e-02f, -1.18868232e-01f, -1.21965945e-01f, -6.92724138e-02f, 2.80726105e-01f, 2.25471213e-01f,
  5.18030226e-01f, 5.55506274e-02f, 4.08274829e-01f, 8.51959269e-03f, -3.78392860e-02f, -2.01656923e-01f, -4.39528257e-01f, -2.01112941e-01f, -3.23894173e-01f, 3.91957194e-01f,
  4.03961509e-01f, -5.29188216e-01f, 5.29532246e-02f, 4.43875462e-01f, -2.44899869e-01f, -2.34614294e-02f, 6.15972340e-01f, 2.00083852e-01f, -1.07771374e-01f, 5.60516238e-01f,
  -2.08597735e-01f, 2.18490399e-02f, 5.36882401e-01f, -8.65581408e-02f, -1.00577980e-01f, 1.92018569e-01f, 4.63235795e-01f, 6.31937146e-01f, 9.76759419e-02f, 3.30622733e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 20)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 20;
const float L1_fan_Bp_bar_data[] = {
  3.77945423e-01f, 2.54917771e-01f, 1.89596504e-01f, 2.63015717e-01f, 3.27669948e-01f, 1.14568315e-01f, 8.14015493e-02f, 1.51120454e-01f, 1.74013928e-01f, 2.46486053e-01f,
  2.23554581e-01f, 1.79639697e-01f, 2.11640686e-01f, 1.48892710e-02f, 1.84030578e-01f, 1.92277521e-01f, 2.07434997e-01f, 4.00320351e-01f, 9.60481465e-02f, 3.15567374e-01f
};

// L2_linear_W (Shape: 12 x 32)
const int L2_linear_W_rows = 12;
const int L2_linear_W_cols = 32;
const float L2_linear_W_data[] = {
  -3.31023425e-01f, 2.63445586e-01f, 1.50534719e-01f, 1.64000452e-01f, -2.17137292e-01f, -2.64647454e-01f, 7.30898008e-02f, -2.78222293e-01f, -9.86396596e-02f, 6.86887428e-02f,
  2.80602485e-01f, 2.39156306e-01f, -6.97393417e-01f, 4.99271154e-01f, -8.44291389e-01f, 2.70873636e-01f, -5.96992485e-02f, -6.71629429e-01f, 2.92775571e-01f, -1.72688529e-01f,
  -2.39346832e-01f, -1.74018770e-01f, 2.40611345e-01f, 1.39634997e-01f, -6.80455685e-01f, 4.88621533e-01f, -3.86963874e-01f, 2.87589163e-01f, 2.72115409e-01f, 2.15456739e-01f,
  -3.84025961e-01f, 3.28342319e-02f, -2.03660056e-01f, 1.93249255e-01f, 9.69392341e-03f, -4.74583767e-02f, 2.14691341e-01f, 8.46603215e-02f, 4.27643836e-01f, -1.57059267e-01f,
  -4.41776067e-02f, -2.45240241e-01f, 2.13167369e-01f, 3.03357363e-01f, 2.00520635e-01f, -2.59870231e-01f, -2.28565395e-01f, -3.28299701e-01f, 6.44078970e-01f, 3.67440790e-01f,
  4.75900918e-02f, 6.99564219e-01f, -7.92083442e-01f, -5.74603438e-01f, 2.01839823e-02f, -3.35359305e-01f, -3.54354173e-01f, 4.83962856e-02f, -4.81089234e-01f, 4.38548714e-01f,
  -6.10083520e-01f, 2.33097643e-01f, 1.68839946e-01f, -8.06685865e-01f, 7.31050000e-02f, -1.05364874e-01f, -1.08356411e-02f, 6.44411296e-02f, 8.71375501e-02f, 1.03764676e-01f,
  -3.61557692e-01f, -3.63949649e-02f, -1.71936646e-01f, -3.74821633e-01f, -4.76800144e-01f, 3.20605598e-02f, 4.30112690e-01f, -3.93262923e-01f, -5.69007732e-02f, -4.11074609e-01f,
  -2.96397179e-01f, 7.27365550e-05f, 4.65599954e-01f, -7.46737242e-01f, 3.59518468e-01f, -4.65834886e-01f, 3.85407716e-01f, 1.67080998e-01f, -5.36872923e-01f, 8.53149667e-02f,
  -4.10939276e-01f, 2.14705113e-02f, -4.25014496e-01f, -7.35997915e-01f, 3.44054580e-01f, -4.74849552e-01f, -4.61482070e-02f, -1.29676253e-01f, -2.08623156e-01f, 7.45933428e-02f,
  -3.12143415e-01f, -2.83393741e-01f, 3.35820079e-01f, 2.61177868e-01f, 5.45310199e-01f, -2.69244909e-01f, 1.48898910e-03f, -3.14469896e-02f, -9.73957598e-01f, 2.25967050e-01f,
  9.10466313e-02f, 7.77848735e-02f, -7.35834777e-01f, 2.38762021e-01f, -4.64117467e-01f, 2.78114676e-02f, -1.53121471e-01f, -6.86609507e-01f, 5.35110235e-01f, -4.11154598e-01f,
  6.35722354e-02f, -4.34928805e-01f, -2.15484023e-01f, -5.32236636e-01f, 1.29851952e-01f, 4.61181909e-01f, -6.64453030e-01f, 4.12658930e-01f, 2.29959294e-01f, 1.02979481e-01f,
  3.45771341e-03f, -2.05776125e-01f, -1.25752509e-01f, 4.69241261e-01f, -2.21380576e-01f, 5.98997414e-01f, -6.14959300e-02f, 5.15478492e-01f, 3.80602270e-01f, -2.07715899e-01f,
  -8.93880054e-02f, -1.48641482e-01f, 3.78643125e-01f, 1.20322481e-01f, -5.43902099e-01f, -3.06519181e-01f, 1.39907494e-01f, 2.40807161e-01f, -8.40175033e-01f, 1.22075640e-01f,
  2.02834666e-01f, 3.05275023e-01f, 1.45879909e-01f, 3.85141283e-01f, 3.55223089e-01f, -5.73819041e-01f, 2.41807953e-01f, -3.37194920e-01f, -1.38191674e-02f, 1.09109707e-01f,
  4.27821577e-01f, -2.48014763e-01f, 8.70610178e-02f, 1.89147383e-01f, -2.23591197e-02f, 1.33408949e-01f, 3.89517963e-01f, -3.90696198e-01f, -8.97131786e-02f, -1.40853032e-01f,
  -6.19585156e-01f, 3.67306828e-01f, 2.20383763e-01f, 5.51022410e-01f, -7.47535765e-01f, 2.60624319e-01f, 4.77210224e-01f, -4.21556145e-01f, -6.77650571e-01f, 6.93932697e-02f,
  -4.86661106e-01f, 5.42434454e-01f, -7.74869323e-01f, -2.90992349e-01f, 1.66169643e-01f, -3.84187669e-01f, 4.25016910e-01f, -3.07699561e-01f, -4.08786312e-02f, 1.30368531e-01f,
  -5.20081699e-01f, 4.69049513e-02f, -6.53731450e-02f, -1.44185916e-01f, 5.11115193e-02f, 3.79739217e-02f, -3.23399566e-02f, 5.09181842e-02f, -4.79352683e-01f, 2.71252021e-02f,
  -3.52414399e-02f, 4.75615442e-01f, 6.88196942e-02f, -1.95893750e-01f, 3.20563227e-01f, -5.31134367e-01f, -4.24216598e-01f, -6.01497531e-01f, 1.74573228e-01f, 3.55300099e-01f,
  -7.35250056e-01f, 2.08348379e-01f, 4.86050278e-01f, 2.99907863e-01f, -2.77307719e-01f, 3.49282265e-01f, 1.81933358e-01f, -6.78919613e-01f, 3.65272492e-01f, -5.44573784e-01f,
  2.04790026e-01f, -5.75050235e-01f, -6.31601289e-02f, -9.43048775e-01f, -6.96637901e-03f, -2.04600349e-01f, -3.43089312e-01f, -3.50882381e-01f, -2.31602550e-01f, -1.98571533e-01f,
  -3.87667329e-03f, 2.80546844e-01f, 3.25044215e-01f, 7.28669688e-02f, -2.75864393e-01f, 3.84782329e-02f, -7.10159957e-01f, 3.71704608e-01f, 3.99972916e-01f, 1.92643270e-01f,
  2.31006518e-01f, -4.45788763e-02f, 2.05972999e-01f, -7.11779475e-01f, 2.08103791e-01f, -3.44050407e-01f, -3.87329936e-01f, -2.31218800e-01f, 2.56767601e-01f, 1.91883221e-02f,
  -2.29582459e-01f, 2.55371749e-01f, 1.56239539e-01f, -4.23160166e-01f, 2.28808299e-01f, -1.29882067e-01f, 1.60803095e-01f, -1.99957103e-01f, -1.62415043e-01f, 9.42679048e-02f,
  4.66430411e-02f, -3.48954946e-02f, -2.93913603e-01f, -2.65226811e-01f, -2.79657990e-01f, 2.38491505e-01f, 2.42451265e-01f, 2.49931440e-01f, -5.62524557e-01f, -3.34665149e-01f,
  -2.05908760e-01f, -3.16528261e-01f, -5.70960999e-01f, 2.02967778e-01f, -4.74694550e-01f, -5.32945096e-01f, 4.09813553e-01f, -1.12166449e-01f, -3.01621944e-01f, 5.69700122e-01f,
  -3.60976517e-01f, -2.51436591e-01f, -1.73422053e-01f, 2.39080489e-01f, -3.63654792e-01f, 5.51553428e-01f, 1.68938518e-01f, -1.79935787e-02f, -2.23202005e-01f, 1.40803248e-01f,
  -4.51516034e-03f, -1.31244332e-01f, -1.39446154e-01f, 1.00629978e-01f, -1.54796332e-01f, -3.73139560e-01f, 4.24730591e-02f, 5.88867906e-03f, -4.81137872e-01f, 3.97072583e-01f,
  3.40758979e-01f, -5.61736643e-01f, -1.88162863e-01f, 3.49504471e-01f, -1.83419645e-01f, -5.84577262e-01f, 2.56782949e-01f, -2.41719908e-03f, 4.05844629e-01f, 1.04795806e-01f,
  -5.55196583e-01f, -8.88527274e-01f, 3.81149024e-01f, 5.97135425e-01f, 2.10521474e-01f, -6.42564714e-01f, -5.19061014e-02f, -7.14885652e-01f, 3.38391364e-01f, -4.09402937e-01f,
  8.02431479e-02f, 1.98958382e-01f, 1.93952501e-01f, -1.07346289e-01f, 3.05078804e-01f, -3.45727019e-02f, 1.73476666e-01f, 4.41015661e-01f, -2.07301497e-01f, -4.09088343e-01f,
  3.73078845e-02f, -4.28849250e-01f, 4.37308013e-01f, -5.50670803e-01f, 5.20199358e-01f, -4.53147322e-01f, -3.90219420e-01f, -6.54537320e-01f, 5.19848645e-01f, -3.34145695e-01f,
  -3.52668881e-01f, -3.20779979e-01f, 3.36633593e-01f, -4.02623296e-01f, -3.32410693e-01f, -5.06648779e-01f, -2.17716426e-01f, 4.46513861e-01f, -7.51820982e-01f, 2.36789808e-01f,
  -6.31715894e-01f, 2.96828687e-01f, -1.35983780e-01f, -4.56807911e-02f, 1.14516228e-01f, -1.13623641e-01f, 9.71323773e-02f, -2.58959860e-01f, -4.08765674e-01f, -3.32190722e-01f,
  3.45818281e-01f, -4.21361536e-01f, -9.97267663e-02f, -3.13217491e-01f, 4.51134264e-01f, -4.51875716e-01f, 1.12168811e-01f, -4.70112413e-01f, -5.81431031e-01f, 5.23397923e-01f,
  -4.97448802e-01f, 2.85865337e-01f, -2.54527867e-01f, 3.39103192e-01f, -6.82186067e-01f, -2.05099106e-01f, 1.35267645e-01f, -3.68376523e-01f, -3.30530345e-01f, -5.51274955e-01f,
  -2.68724933e-02f, 1.30737107e-02f, -7.02970207e-01f, 5.26742816e-01f
};

// L2_linear_B (Shape: 1 x 12)
const int L2_linear_B_rows = 1;
const int L2_linear_B_cols = 12;
const float L2_linear_B_data[] = {
  9.00039449e-03f, 1.75373629e-01f, 3.40897287e-03f, 4.83311452e-02f, -1.73944056e-01f, 8.99257734e-02f, -9.89626795e-02f, -1.36935830e-01f, 3.41763673e-03f, 5.10014296e-02f,
  -1.00466140e-01f, 7.60215372e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 6, 20
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        32, 6, 20
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_linear
    linear_forward_pgm(
        buffer1, x_out,
        L2_linear_W_data, L2_linear_B_data,
        32, 12
    );
    }
    