/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 64 (x3)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 64;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    return (x > 0.0f) ? x : 0.0f;
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 19 x 120)
const int L0_fan_Wp_rows = 19;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -3.20762187e-01f, 1.85300916e-01f, -1.50401384e-01f, -8.60248730e-02f, -1.39092043e-01f, 2.85760239e-02f, 5.41642979e-02f, 1.04716614e-01f, -7.05702230e-02f, 1.80170223e-01f,
  9.16971937e-02f, -1.16844187e-02f, 1.95925295e-01f, 1.04336455e-01f, -2.22271517e-01f, 7.16934428e-02f, -4.34765872e-03f, 7.23376423e-02f, -8.96955505e-02f, 7.06712604e-02f,
  -7.37887174e-02f, 1.62040383e-01f, 2.08522789e-02f, 7.17628933e-03f, -1.40857371e-02f, -2.49215793e-02f, -9.03761610e-02f, -1.41885746e-02f, -1.66829471e-02f, -1.47561748e-02f,
  -7.90482461e-02f, -2.09562909e-02f, -8.27066824e-02f, 6.89622685e-02f, -1.00521162e-01f, -2.47243419e-02f, -3.69851701e-02f, -2.56585125e-02f, -6.47537634e-02f, -5.75248487e-02f,
  -4.48421808e-03f, 5.56206256e-02f, 5.04801832e-02f, -5.60884736e-02f, 3.69720533e-03f, 8.58503859e-03f, 4.51794416e-02f, 7.63010839e-03f, 7.36164153e-02f, 8.81232619e-02f,
  3.91466953e-02f, 1.92651264e-02f, 8.84192064e-03f, 3.11488956e-02f, -4.67826389e-02f, 9.21094269e-02f, 1.53651582e-02f, 1.88605618e-02f, 4.92553413e-02f, 1.64194200e-02f,
  -3.35190520e-02f, -5.21599874e-02f, 4.91217244e-04f, -5.07213213e-02f, -4.11413647e-02f, 5.87823219e-04f, -8.32452672e-04f, -2.79202964e-03f, 1.89277865e-02f, 2.88721989e-03f,
  6.19970821e-03f, 6.59263805e-02f, 1.01100504e-01f, 2.01960914e-02f, -9.35758650e-03f, -2.02941466e-02f, 1.01901777e-02f, 2.98709180e-02f, -3.78678404e-02f, -5.66910580e-02f,
  2.45467667e-02f, 5.44977700e-03f, 5.08287847e-02f, -4.32482809e-02f, 3.03650331e-02f, 1.74614023e-02f, -4.27117571e-03f, 6.31537214e-02f, -5.42605529e-03f, -6.59743622e-02f,
  1.01391487e-01f, 4.94654253e-02f, 7.87146613e-02f, 1.03692159e-01f, 9.29956585e-02f, 1.79261528e-02f, -4.19630297e-02f, -5.40231504e-02f, 4.23662784e-03f, 1.78506989e-02f,
  2.54853367e-04f, 6.46624118e-02f, 8.06053460e-04f, 2.69292165e-02f, -5.76070957e-02f, 7.48831406e-02f, 1.61591489e-02f, -2.02447688e-03f, 2.14035306e-02f, -6.12350143e-02f,
  -3.85534726e-02f, 1.52868498e-02f, 8.42372421e-03f, 3.57273337e-03f, 1.11237308e-02f, -5.50426543e-02f, -7.35986903e-02f, 1.99455656e-02f, -1.35603240e-02f, -3.56141999e-02f,
  3.25574540e-02f, 5.66499121e-02f, 6.90008178e-02f, 1.11065246e-01f, -1.56669249e-03f, 2.46154070e-01f, 3.28625560e-01f, -4.73089376e-03f, 3.66367176e-02f, 6.60959706e-02f,
  2.07039714e-01f, 3.78443822e-02f, 7.83218145e-02f, 2.20326245e-01f, 2.02994362e-01f, -7.44497497e-03f, 3.01027864e-01f, 1.75273284e-01f, -7.75227249e-02f, -5.84993251e-02f,
  -3.91251668e-02f, 1.84120938e-01f, 1.22071095e-01f, -1.43986538e-01f, 1.34702146e-01f, -1.47195622e-01f, -2.18221813e-01f, -1.38454780e-01f, -1.81061460e-03f, 8.05107057e-02f,
  2.02260613e-01f, -4.97765839e-02f, 7.05222189e-02f, 4.51023690e-02f, 2.55187545e-02f, 2.13564970e-02f, -2.09705774e-02f, 6.72265589e-02f, 3.48656811e-02f, -4.28046361e-02f,
  -1.63737703e-02f, -3.90645638e-02f, 8.07632431e-02f, 3.68862636e-02f, -7.61453733e-02f, 8.79245065e-03f, -2.26799138e-02f, 2.89939493e-02f, -1.24985614e-04f, 4.48782817e-02f,
  -1.13052817e-03f, 3.40140201e-02f, -4.34716940e-02f, 5.27105406e-02f, -2.95143984e-02f, 5.84658869e-02f, 8.38412810e-03f, 5.94236106e-02f, -6.47697002e-02f, 1.70589201e-02f,
  -2.95098014e-02f, -6.90630153e-02f, -3.73956561e-02f, 2.33000033e-02f, 2.37415452e-03f, -5.95089793e-03f, 6.81458553e-03f, 5.97670637e-02f, -4.82999869e-02f, 5.50920237e-03f,
  -5.79052158e-02f, 2.99294144e-02f, -5.39398193e-02f, -6.21813629e-03f, -3.28860469e-02f, -7.54787326e-02f, 5.22551360e-03f, -4.07512113e-02f, -3.42832357e-02f, 3.05118300e-02f,
  4.39069346e-02f, -6.76540956e-02f, -1.88781526e-02f, -5.98000502e-03f, 1.21141700e-02f, 4.07876410e-02f, -4.53252904e-02f, -1.04238009e-02f, -8.90092626e-02f, 1.80375129e-02f,
  3.24506983e-02f, -1.72769636e-01f, -3.98101434e-02f, 1.78746413e-02f, -1.53438579e-02f, -4.21978813e-03f, 6.11891970e-02f, -5.16284211e-03f, -5.73284850e-02f, -2.52345204e-02f,
  -5.30375801e-02f, 6.71618804e-02f, -4.96444218e-02f, -2.97390334e-02f, 5.46270311e-02f, -5.27902804e-02f, -4.28575054e-02f, -1.22312289e-02f, -5.70556745e-02f, -2.03099679e-02f,
  -5.02166785e-02f, -1.08941227e-01f, 3.58142145e-02f, 2.93380432e-02f, -3.03553417e-03f, -4.51084450e-02f, -1.93528719e-02f, -1.42907109e-02f, 1.14148641e-02f, 2.86306199e-02f,
  3.29980761e-01f, -3.71629409e-02f, 1.63915619e-01f, 2.07751483e-01f, 2.91585606e-02f, 4.34794575e-02f, 1.58463866e-01f, -2.88548470e-02f, -1.27708346e-01f, -1.96044058e-01f,
  6.42025396e-02f, 4.93996292e-02f, -4.86987717e-02f, 5.60456179e-02f, 1.64099559e-01f, -1.35057703e-01f, -1.51724520e-03f, 6.32118657e-02f, -3.66820619e-02f, 1.17917903e-01f,
  8.00910115e-04f, 5.05648814e-02f, 2.12332025e-01f, -5.96577227e-02f, 1.87211595e-02f, 2.81405766e-02f, -7.57067353e-02f, 5.46933264e-02f, -5.14093228e-03f, 4.36666645e-02f,
  -3.83558758e-02f, 4.15295400e-02f, -3.41679230e-02f, -6.01650290e-02f, 1.48832146e-02f, 6.43003955e-02f, 3.36361048e-03f, 2.01344136e-02f, 5.96890673e-02f, 6.50777593e-02f,
  -2.00046506e-03f, -6.65353704e-03f, 3.67282480e-02f, 7.83682708e-03f, -4.04774733e-02f, -6.69175619e-03f, 5.82716390e-02f, 4.46856022e-02f, 4.00677137e-02f, 1.28167108e-01f,
  6.55327365e-03f, -2.57540382e-02f, -1.82571691e-02f, -6.48502540e-03f, 1.47803808e-02f, -1.81528535e-02f, -4.26071659e-02f, 3.48320976e-02f, -5.37997782e-02f, -3.98892313e-02f,
  4.07308452e-02f, -8.81851315e-02f, -4.81798202e-02f, 1.00561548e-02f, -6.47678450e-02f, 8.16873834e-03f, -1.54017089e-02f, -2.06408706e-02f, -1.97696146e-02f, -5.64825796e-02f,
  4.94729131e-02f, 4.79926169e-02f, -3.70915234e-02f, 3.77669511e-03f, 4.38283645e-02f, 3.69876623e-02f, 7.19974861e-02f, 6.37792051e-02f, 2.65899654e-02f, 7.94652253e-02f,
  -7.12754130e-02f, 6.95647113e-03f, 2.22965013e-02f, -8.78344942e-03f, -5.65433390e-02f, 4.00729589e-02f, -5.78835085e-02f, 3.27266864e-02f, -3.26205790e-02f, -3.10009457e-02f,
  -1.76033109e-01f, -1.13766722e-01f, 5.22746444e-02f, 4.98456806e-02f, -3.28214131e-02f, -3.66955101e-02f, -7.27596357e-02f, 2.12771427e-02f, -5.68664148e-02f, -6.12612395e-03f,
  -1.35719655e-02f, 7.74137154e-02f, -5.11781685e-02f, 2.75822356e-02f, 4.33194600e-02f, 3.24273366e-03f, 1.26363812e-02f, 2.62997841e-04f, -3.95042710e-02f, 4.68577892e-02f,
  6.58332109e-02f, 7.58651495e-02f, 6.56819670e-03f, -3.10842041e-02f, -2.63430625e-02f, 1.50571214e-02f, -8.37339982e-02f, -4.16808315e-02f, -5.62354252e-02f, -2.41129827e-02f,
  -4.20803130e-02f, 1.40011027e-01f, 1.07549183e-01f, 1.66988876e-02f, 6.61078840e-02f, 1.52136952e-01f, 1.98154733e-01f, 3.68720144e-02f, -3.32144678e-01f, 7.84322321e-02f,
  8.62639993e-02f, 2.95093618e-02f, -1.26623008e-02f, 1.65481046e-01f, -3.05495430e-02f, -1.50582850e-01f, 4.59874906e-02f, 4.60581072e-02f, -3.26637477e-02f, 2.05668788e-02f,
  -4.74046990e-02f, -1.55086890e-02f, 6.91398084e-02f, 4.09995951e-02f, 1.62561759e-01f, -6.49956167e-02f, 7.73638440e-03f, 6.70396835e-02f, 1.60619408e-01f, 6.66907281e-02f,
  3.72906551e-02f, -5.84349111e-02f, 1.61198191e-02f, -1.30936369e-01f, -3.21717449e-02f, 8.34846273e-02f, 9.19710323e-02f, -6.59366921e-02f, 3.96503182e-03f, -2.37366408e-02f,
  1.35372132e-02f, -5.34611754e-02f, -5.04275896e-02f, -9.44912881e-02f, -8.32770020e-03f, -3.48928049e-02f, 1.01383310e-02f, -2.47507114e-02f, 3.14235315e-02f, 5.96190058e-02f,
  4.68356971e-04f, 8.71346369e-02f, 4.28298302e-02f, 2.18871124e-02f, -4.04112972e-02f, 9.22050327e-03f, -3.98561694e-02f, 5.74402418e-03f, 1.52501436e-02f, -1.10857435e-01f,
  -5.67348339e-02f, -2.24802569e-02f, 1.10875778e-02f, 2.55485848e-02f, 2.71785026e-03f, 9.48326886e-02f, 3.37685794e-02f, 2.03930726e-03f, -1.61823742e-02f, 2.53317915e-02f,
  -3.19658592e-02f, 5.08245751e-02f, 6.72136713e-03f, 2.13504378e-02f, 6.30213469e-02f, -4.92611900e-03f, 1.47835212e-02f, 8.52991864e-02f, -3.80721390e-02f, 3.55079807e-02f,
  2.13844366e-02f, -1.68314576e-02f, 3.37800458e-02f, -4.56668902e-03f, 6.20836727e-02f, -4.91351224e-02f, -3.10258735e-02f, 5.79170417e-03f, 3.44587229e-02f, 4.43742014e-02f,
  8.97581205e-02f, -3.87239680e-02f, -3.13509293e-02f, -2.04977579e-03f, -2.35763304e-02f, -3.01636104e-03f, -4.54687402e-02f, -5.23732451e-04f, -5.73469512e-02f, 3.86087336e-02f,
  5.27255312e-02f, -5.63481003e-02f, 6.30390048e-02f, 4.26736102e-02f, -4.49342765e-02f, -5.40347816e-03f, 9.91000701e-03f, -1.03925550e-02f, 3.28357145e-02f, -4.98316437e-02f,
  -3.20137627e-02f, -4.26116809e-02f, -1.13704824e-03f, 1.06118098e-02f, 6.56422302e-02f, 5.30057354e-03f, 7.64354365e-03f, -1.20405585e-01f, 3.83477099e-02f, -5.36241382e-02f,
  -1.35607585e-01f, 1.57023206e-01f, -2.35117197e-01f, -3.28433812e-02f, 5.23472019e-02f, -4.26103771e-02f, -1.66473061e-01f, 2.84363870e-02f, -1.26357600e-01f, 3.80740277e-02f,
  1.02740690e-01f, -2.01398760e-01f, -1.37243923e-02f, 2.74418779e-02f, -1.85627297e-01f, -1.97613284e-01f, -1.11828730e-01f, -5.99315464e-02f, -8.65894631e-02f, 6.55102916e-03f,
  -5.08717857e-02f, -1.02018965e-02f, -1.63408414e-01f, 6.91431090e-02f, -5.10639250e-02f, 3.33222300e-02f, -6.79230492e-04f, -5.11860885e-02f, 1.12644017e-01f, 1.94968153e-02f,
  3.69127654e-02f, 4.27030176e-02f, -5.97346909e-02f, 1.27593498e-03f, 6.28960282e-02f, -2.27582175e-03f, -6.66748360e-02f, -1.04752019e-01f, -6.45629093e-02f, -1.88699737e-02f,
  -6.43605143e-02f, 8.96545313e-03f, -6.35219440e-02f, -2.69609485e-02f, 6.12730831e-02f, -1.91628356e-02f, -2.72924732e-02f, -3.47024910e-02f, -2.32649371e-02f, -1.56950187e-02f,
  -4.28963564e-02f, 3.27618532e-02f, 1.22779179e-02f, -1.26154618e-02f, -1.15132444e-02f, 2.93641910e-02f, -1.16612077e-01f, -2.22521331e-02f, 5.02881855e-02f, -2.92420462e-02f,
  -6.12866767e-02f, -1.01722829e-01f, -4.85500321e-02f, 1.16582245e-01f, -4.67275642e-02f, 3.24471928e-02f, 9.20780189e-03f, 7.59141818e-02f, -4.28542262e-03f, 6.74685612e-02f,
  2.57890020e-02f, 1.29417712e-02f, 3.31791863e-02f, 1.41211618e-02f, 3.25821824e-02f, -3.53575796e-02f, -3.09926830e-02f, 7.56452531e-02f, -6.64233416e-02f, 2.38529450e-04f,
  -6.39864206e-02f, 1.47408526e-02f, 2.15544347e-02f, -5.69913164e-02f, -2.98224222e-02f, -1.77318454e-02f, 3.44995745e-02f, 6.01730421e-02f, -1.15314024e-02f, -3.71415243e-02f,
  2.43088156e-01f, 1.33167475e-01f, -1.43503668e-02f, 1.41280398e-01f, 6.57934844e-02f, 2.78736139e-03f, -3.44499424e-02f, 9.30750668e-02f, 5.50690889e-02f, -3.96041479e-03f,
  3.94282825e-02f, 7.01281708e-03f, 8.01649839e-02f, -8.57887268e-02f, -8.21283273e-03f, 3.62937041e-02f, -1.14866369e-03f, 4.93677296e-02f, 9.75999888e-03f, 6.88840747e-02f,
  1.80375762e-02f, 4.95538674e-03f, -2.42739785e-02f, -3.53820585e-02f, 4.36456278e-02f, -3.34327854e-02f, -3.09583098e-02f, -1.01148941e-01f, -3.77971046e-02f, 4.10269126e-02f,
  -1.16157606e-01f, 3.07256460e-01f, 2.52908409e-01f, 8.54650810e-02f, -1.52175367e-01f, -2.01409802e-01f, -1.86244562e-01f, 1.48314416e-01f, 9.07332450e-02f, 6.31318241e-02f,
  -1.12313293e-01f, 2.09589601e-01f, -5.66807687e-02f, -2.04814710e-02f, -1.37154222e-01f, 2.14973073e-02f, 3.67148244e-03f, -5.47082983e-02f, 7.18107373e-02f, 4.08261828e-02f,
  6.98318705e-02f, -6.88843131e-02f, -7.94132520e-03f, 1.11682005e-01f, -3.48397568e-02f, 1.33954272e-01f, -1.11091837e-01f, 1.38212545e-02f, -5.76261617e-02f, 1.97967724e-03f,
  -1.94781199e-01f, 8.13415796e-02f, -5.97141683e-02f, 4.09617610e-02f, 4.75208304e-04f, -2.99829654e-02f, 2.76815109e-02f, -6.76026717e-02f, 1.42209372e-02f, -8.08384735e-03f,
  1.99866332e-02f, 8.23152363e-02f, 6.69331774e-02f, 6.47155242e-03f, 1.19527578e-01f, 5.15547357e-02f, 4.58939113e-02f, -1.69240683e-02f, 7.71799907e-02f, -5.61316349e-02f,
  -3.21573839e-02f, -3.52955237e-02f, 5.27728721e-02f, 1.44020943e-02f, -1.00385339e-03f, -4.25426438e-02f, -6.55574957e-03f, -3.50745544e-02f, 3.10264807e-02f, -1.12131285e-02f,
  6.11678921e-02f, -1.38496899e-03f, 2.57599745e-02f, 1.92563012e-02f, 3.44049074e-02f, -4.09366265e-02f, 7.82081950e-03f, -8.09704512e-02f, -3.94996302e-03f, -3.61945271e-03f,
  -5.59574701e-02f, -5.84949367e-02f, 4.27319668e-02f, 3.65398899e-02f, -5.01752272e-02f, 1.50466114e-02f, -1.83124449e-02f, -4.35857996e-02f, 6.03394099e-02f, -7.78350681e-02f,
  4.15404066e-02f, -2.52136849e-02f, 7.00198188e-02f, -7.40249231e-02f, 8.51627905e-03f, -4.34140787e-02f, 5.17568402e-02f, 1.04979165e-02f, 3.19116749e-02f, -7.82646984e-02f,
  -8.36845115e-02f, 2.41882373e-02f, -1.90522093e-02f, -2.61415611e-03f, -4.03025560e-02f, -3.01601700e-02f, 8.41714814e-02f, -5.74763604e-02f, 7.92953011e-04f, 2.32504755e-02f,
  -3.28287706e-02f, -4.39671353e-02f, -3.53596397e-02f, 6.59196731e-03f, -3.03003099e-02f, -4.80199084e-02f, -2.49727387e-02f, 5.67666069e-02f, -1.04195006e-01f, 6.73878938e-02f,
  6.84931129e-02f, 9.98738781e-03f, 1.52430916e-02f, 1.73904393e-02f, -1.24807013e-02f, -3.63202393e-02f, 1.73830464e-02f, 1.66977067e-02f, -5.38994633e-02f, 1.74976159e-02f,
  -2.36064747e-01f, -1.47762805e-01f, -2.50944346e-01f, -2.39246503e-01f, 1.67663753e-01f, 2.08828360e-01f, 2.34521702e-02f, -1.74029991e-02f, -2.80359596e-01f, 7.01388270e-02f,
  8.06217268e-02f, -1.53937608e-01f, -3.82320285e-02f, 4.43388894e-03f, -2.88860649e-01f, -1.93073943e-01f, 7.05415010e-02f, 7.26675708e-03f, -4.12096418e-02f, -6.46518990e-02f,
  -1.33496508e-01f, 2.25141063e-01f, -9.67002213e-02f, 1.90241426e-01f, 1.18593447e-01f, -7.90850520e-02f, 5.32763414e-02f, -1.39274765e-02f, 2.09410369e-01f, 9.56623554e-02f,
  -5.99001609e-02f, -8.77239257e-02f, -9.55778465e-04f, -1.01999246e-01f, -2.37686075e-02f, 9.28033143e-02f, 3.06231230e-02f, 5.19589260e-02f, -4.42918204e-02f, 1.99184772e-02f,
  -4.15048264e-02f, -9.75641480e-04f, 2.65435185e-02f, -1.92310475e-02f, -8.22230056e-03f, -2.75730416e-02f, 3.68446000e-02f, 7.58417472e-02f, -5.11959642e-02f, 1.25243934e-03f,
  -1.08498022e-01f, 2.24699732e-02f, 6.99523091e-03f, -2.43667476e-02f, -3.07022836e-02f, 2.93171629e-02f, 3.86973172e-02f, 1.01692807e-02f, 5.11612631e-02f, 1.75068453e-02f,
  1.30643267e-02f, 3.49065550e-02f, 3.32844742e-02f, 5.34560159e-03f, 2.75456402e-02f, 6.71003088e-02f, 1.79246161e-02f, 5.15120700e-02f, -8.84971675e-03f, 1.67742278e-02f,
  -5.90974130e-02f, -2.62865424e-03f, -7.99389835e-03f, -4.64152656e-02f, 6.66958019e-02f, 3.58938426e-02f, -1.84275731e-02f, 1.16016353e-02f, 1.14751020e-02f, 7.16383755e-02f,
  -5.96358550e-05f, -6.10194765e-02f, 5.89357689e-02f, 1.70655753e-02f, -3.54601406e-02f, -3.64779048e-02f, 1.68410540e-02f, -6.53710514e-02f, -3.43690813e-02f, 1.51591748e-02f,
  -1.89795403e-03f, -1.34046692e-02f, -3.93749028e-02f, -6.56619966e-02f, 7.91958161e-03f, 1.85770057e-02f, -1.25186533e-01f, 3.80833410e-02f, -5.29216528e-02f, -1.16648553e-02f,
  -1.57323014e-03f, 6.99579045e-02f, -5.29862707e-03f, 2.34165434e-02f, -4.33466733e-02f, -1.91300195e-02f, -3.48130018e-02f, -2.84544844e-03f, 6.27004281e-02f, 3.81770693e-02f,
  4.49297503e-02f, -1.89438313e-02f, 2.52046380e-02f, 6.13173246e-02f, 6.89280406e-02f, 3.38339917e-02f, 2.99172848e-02f, -4.25079577e-02f, 1.68842934e-02f, -2.30400451e-02f,
  2.57805645e-01f, -1.69748396e-01f, -1.28986225e-01f, 9.75073874e-02f, -3.31506543e-02f, 1.69007242e-01f, -3.90454638e-03f, 3.96744870e-02f, 1.49761215e-01f, -2.34533772e-02f,
  -1.60458479e-02f, -6.54864907e-02f, -1.95412003e-02f, -5.74170984e-02f, 1.48461506e-01f, 2.19612811e-02f, 2.18106046e-01f, -1.06275538e-02f, -1.22234644e-02f, 5.55820726e-02f,
  -3.32416967e-02f, 8.33152458e-02f, -1.21083602e-01f, 4.48664576e-02f, -1.16414659e-01f, -1.05409391e-01f, -1.77707821e-01f, -2.13169858e-01f, -6.55412599e-02f, -7.48624206e-02f,
  9.43980925e-03f, -3.32938619e-02f, -1.28432393e-01f, 6.07652031e-02f, 4.25096899e-02f, -3.33274603e-02f, -9.79882777e-02f, -1.58419922e-01f, -3.81519049e-02f, 6.95313290e-02f,
  -3.34542319e-02f, 1.17629394e-01f, -8.08730442e-03f, 6.27495907e-03f, 7.46491328e-02f, -4.74857055e-02f, 8.49534816e-04f, -2.18007118e-02f, 7.38205807e-03f, 1.05433345e-01f,
  7.84031115e-03f, 3.36414017e-02f, 4.27846052e-02f, -2.39368342e-02f, -5.22233685e-03f, 2.44760290e-02f, -4.13751835e-03f, -1.01833865e-01f, 9.02722403e-02f, 4.49777469e-02f,
  -6.19219849e-03f, -6.38453066e-02f, -8.08275715e-02f, -1.05726868e-01f, -2.15450078e-02f, -4.46373643e-03f, -6.07437901e-02f, 7.52040185e-03f, 7.88044408e-02f, 1.40915718e-03f,
  3.42903361e-02f, -6.09640665e-02f, -2.32957359e-02f, -4.39175852e-02f, -5.29288761e-02f, 7.22303018e-02f, 6.47309120e-04f, 1.19878808e-02f, -5.68029359e-02f, -9.29895416e-02f,
  1.24301398e-02f, 3.72036025e-02f, -4.41108923e-03f, -9.55160260e-02f, 4.82673682e-02f, -5.34813441e-02f, 1.01308869e-02f, -1.14848010e-01f, 3.36022563e-02f, 5.40237390e-02f,
  2.62686741e-02f, 1.26664713e-01f, 2.60710362e-02f, -8.65349621e-02f, -7.82996416e-02f, 7.11983666e-02f, 3.83609161e-02f, 6.19735941e-02f, 1.92696434e-02f, 9.26572531e-02f,
  5.28450795e-02f, -1.01620607e-01f, 2.53780764e-02f, 1.79784689e-02f, -9.36640725e-02f, -5.27877398e-02f, -8.62777978e-03f, 7.68480962e-03f, -6.16446808e-02f, -2.62108631e-02f,
  9.67657473e-03f, 2.60428637e-02f, 1.96648818e-02f, 7.57517070e-02f, 6.47778139e-02f, -2.74886768e-02f, -1.65482070e-02f, 9.00771543e-02f, 1.41336499e-02f, -8.57843959e-04f,
  -6.40298948e-02f, 9.47947726e-02f, -1.03140749e-01f, -1.03679700e-02f, 1.58562109e-01f, 6.99405298e-02f, 1.06709011e-01f, 1.05693310e-01f, 3.00968766e-01f, 1.19802192e-01f,
  2.48802826e-01f, -2.32002977e-02f, 8.25734884e-02f, 2.64205653e-02f, -1.55794129e-01f, 2.56171124e-03f, 1.95783470e-02f, -8.83367136e-02f, -5.35153598e-03f, -1.39694363e-01f,
  -9.25781876e-02f, 1.06596984e-02f, -2.51464307e-01f, -6.03163093e-02f, -2.70446353e-02f, -8.96272957e-02f, -1.88420877e-01f, -2.35874560e-02f, -1.33687332e-01f, 4.74682748e-02f,
  -6.61578253e-02f, 1.99798252e-02f, 2.15396751e-02f, 4.64989841e-02f, 1.62179545e-02f, -5.44323549e-02f, -1.51859820e-01f, -7.71334544e-02f, 3.15989107e-02f, 8.19185972e-02f,
  -1.51956715e-02f, 1.64044239e-02f, 4.08151895e-02f, -1.68162230e-02f, 5.54238148e-02f, -1.08555399e-01f, -3.92875262e-02f, 2.17103548e-02f, -4.65315431e-02f, -9.57951546e-02f,
  -9.04604122e-02f, -4.93393876e-02f, -1.97597146e-02f, 5.76165505e-03f, 2.21215859e-02f, 4.71799895e-02f, -9.05638188e-02f, -1.33613169e-01f, 1.11237757e-01f, 4.09536958e-02f,
  8.75493977e-03f, 3.99283171e-02f, -4.01064530e-02f, 1.64929628e-02f, -3.78618063e-03f, 3.24819125e-02f, 3.50017063e-02f, -1.45626245e-02f, -2.63807792e-02f, -8.86076391e-02f,
  1.14655551e-02f, 3.60501558e-02f, 8.10817555e-02f, -1.99923720e-02f, 5.88235818e-02f, 6.63564280e-02f, 7.59192333e-02f, 3.85918021e-02f, 2.12194882e-02f, -5.50456829e-02f,
  7.84236193e-02f, 2.68529747e-02f, -8.91864114e-03f, 4.78799008e-02f, 1.62680112e-02f, -1.81820206e-02f, -3.95584013e-03f, 7.52217099e-02f, -3.49363796e-02f, 1.43153463e-02f,
  2.42882892e-02f, 1.04176506e-01f, 5.41685671e-02f, 5.34029566e-02f, -8.24845582e-02f, -4.87563759e-02f, 5.24706580e-02f, 5.81724979e-02f, -3.64255235e-02f, 5.50374016e-02f,
  -8.03525001e-02f, -3.65054864e-03f, -2.86989622e-02f, -5.93911372e-02f, -6.13303781e-02f, 3.30621488e-02f, -5.23822308e-02f, -3.34840342e-02f, -5.04388921e-02f, -4.94889505e-02f,
  -9.04843584e-02f, 1.94298173e-03f, -3.69436629e-02f, -2.89710388e-02f, 2.42650881e-03f, 2.03057509e-02f, -6.20200858e-03f, -6.22841269e-02f, -6.34030476e-02f, 3.27194929e-02f,
  1.09347239e-01f, -2.49035120e-01f, 2.11373046e-01f, 1.89871863e-01f, 1.67289019e-01f, -4.55508828e-02f, 1.02266751e-01f, -2.69380808e-02f, -1.42130211e-01f, -2.29736850e-01f,
  -9.64216888e-02f, 2.72016898e-02f, -9.62923616e-02f, -1.03632085e-01f, 1.26551300e-01f, -2.25667268e-01f, 2.03719940e-02f, -3.56351212e-02f, -1.31203374e-03f, 7.10664913e-02f,
  9.55874473e-02f, -9.55368876e-02f, 1.39833719e-01f, 9.03598592e-03f, 1.83613569e-01f, 8.59614238e-02f, 5.83031178e-02f, 1.31862134e-01f, 1.30788788e-01f, 1.47081167e-02f,
  -1.48628121e-02f, -4.00400395e-03f, -6.32309988e-02f, -2.15789489e-02f, -2.77788322e-02f, -4.94981296e-02f, -6.54330775e-02f, -3.61965187e-02f, 6.99611977e-02f, -3.20830271e-02f,
  -3.58541273e-02f, 5.10174036e-02f, 4.43284735e-02f, 1.16409790e-02f, -7.29392841e-02f, 6.86489865e-02f, 3.09790280e-02f, 9.33727920e-02f, 2.97888573e-02f, 3.71449403e-02f,
  -3.36285532e-02f, -2.46934108e-02f, 1.09324329e-01f, 4.52265926e-02f, 5.45506831e-03f, 7.85244033e-02f, 3.35138999e-02f, 5.13240062e-02f, 3.96328196e-02f, -4.09043022e-03f,
  -1.15888894e-01f, 5.55976806e-03f, -5.14881164e-02f, -1.12634348e-02f, -1.79790221e-02f, 2.46472489e-02f, 2.41824016e-02f, 2.94778477e-02f, -3.63403955e-03f, -3.03178355e-02f,
  3.43709774e-02f, 1.29246600e-02f, 2.42569372e-02f, 2.16108039e-02f, 4.68572089e-03f, -5.63751496e-02f, 9.54625756e-03f, 2.43003126e-02f, 5.46781197e-02f, -5.90574406e-02f,
  2.55773608e-02f, -4.46306355e-02f, -5.11841625e-02f, -2.39147153e-03f, -4.61712480e-02f, 5.42763956e-02f, 2.78445124e-03f, -8.78591929e-03f, -7.69660948e-03f, 6.10187389e-02f,
  -2.01528475e-01f, -1.46182284e-01f, 4.85775769e-02f, 3.17068072e-03f, -3.99956517e-02f, -2.36129593e-02f, 2.58089863e-02f, -1.65078342e-02f, -5.48805296e-02f, -6.51736557e-02f,
  -5.51218586e-03f, 4.82740328e-02f, 6.17074082e-03f, -1.74474288e-02f, 4.77564856e-02f, -7.50550255e-02f, 3.72850671e-02f, -8.17549974e-02f, -5.73927574e-02f, -4.04609926e-02f,
  -4.96344268e-02f, 4.82648425e-02f, 6.82844147e-02f, 9.15691182e-02f, 5.66443354e-02f, 3.09421662e-02f, -3.73069718e-02f, 9.85861849e-03f, 7.15542361e-02f, 8.26733559e-02f,
  -3.68179977e-01f, -1.22607194e-01f, -2.37846430e-02f, -1.54355764e-01f, 3.11733931e-02f, -2.87821470e-03f, -1.05708957e-01f, -1.47797152e-01f, -7.97388628e-02f, 3.14944461e-02f,
  -5.08115850e-02f, -8.93150494e-02f, 1.15000211e-01f, -5.85114844e-02f, -1.32222280e-01f, 6.89653382e-02f, -1.26570418e-01f, -6.23801798e-02f, -1.24455178e-02f, -1.75751701e-01f,
  -8.91073421e-02f, -1.47945881e-02f, -6.50544986e-02f, 1.06008120e-01f, 2.84384135e-02f, -4.88879904e-02f, -2.39435397e-02f, 4.67608171e-03f, -4.93115224e-02f, -1.09794848e-02f,
  -1.27328280e-02f, 4.51274328e-02f, -6.44595362e-04f, 9.43112187e-03f, -6.96475431e-02f, -4.07933220e-02f, -6.27557784e-02f, 5.12518585e-02f, -6.29946776e-03f, 2.17788983e-02f,
  6.86873123e-02f, 3.92496120e-03f, -4.37527485e-02f, 9.17479694e-02f, 3.36599648e-02f, 7.31642544e-02f, 4.36247066e-02f, 5.79507649e-02f, -4.74403389e-02f, 2.08053477e-02f,
  5.12901209e-02f, -9.05532623e-04f, 4.71070334e-02f, 6.22644909e-02f, -4.12877724e-02f, 9.28657409e-03f, 4.87599373e-02f, 1.24349840e-01f, 6.14976734e-02f, 4.31874115e-03f,
  6.47118986e-02f, -5.03504016e-02f, 7.84586594e-02f, -5.38527481e-02f, -8.09854418e-02f, 1.57130379e-02f, -1.85911860e-02f, -2.92491238e-03f, 1.31394733e-02f, -6.42673112e-03f,
  -6.30733743e-02f, -2.81846914e-02f, -7.65081868e-03f, 4.76968698e-02f, 4.44951318e-02f, 5.37734665e-03f, 1.36434752e-02f, 1.48272077e-02f, -5.18323220e-02f, -8.81532729e-02f,
  -8.40486959e-03f, 2.20215879e-02f, -1.65992156e-02f, -1.03650419e-02f, -6.24765232e-02f, 5.39722256e-02f, 3.67871597e-02f, 7.23082796e-02f, -5.04702814e-02f, -2.39049946e-03f,
  -1.83984071e-01f, -8.80831629e-02f, 4.60046250e-03f, -6.81916426e-04f, -1.67504922e-02f, 1.04833543e-01f, -3.95996198e-02f, 6.12195581e-02f, -3.17700207e-02f, 1.39698191e-02f,
  -2.34339270e-03f, -4.48036864e-02f, -8.80943704e-03f, -6.25089705e-02f, 7.35219643e-02f, 9.22847074e-04f, -7.08281174e-02f, 1.10224588e-02f, 3.12059536e-03f, -6.12969790e-03f,
  1.83752030e-02f, 1.08633712e-02f, 4.74285409e-02f, -5.15886657e-02f, 1.74876899e-02f, -1.14734434e-02f, -5.38660064e-02f, -2.65422296e-02f, 1.33183622e-03f, -4.03595418e-02f,
  -2.42520109e-01f, 2.22346038e-02f, -2.37112060e-01f, 1.89901024e-01f, -8.98990929e-02f, -4.54101861e-02f, -1.13533735e-01f, 1.55661672e-01f, -7.64473677e-02f, 1.47483796e-01f,
  8.47854689e-02f, -1.08650647e-01f, -9.76815000e-02f, 2.68742919e-01f, 1.33245111e-01f, 1.56871989e-01f, 2.51837224e-01f, 5.07481173e-02f, 4.04732302e-02f, -1.98404230e-02f,
  1.36418134e-01f, 2.24980518e-01f, 1.68885380e-01f, 2.40366697e-01f, 1.57586019e-02f, 2.61513479e-02f, 2.42449895e-01f, -9.24065933e-02f, 2.53958732e-01f, 9.36086699e-02f,
  -4.31777537e-02f, 3.83302593e-03f, -8.88890326e-02f, -6.41532764e-02f, -1.23720281e-01f, -1.32940456e-01f, -7.18084574e-02f, -1.06796520e-02f, -3.38227907e-03f, -1.86810624e-02f,
  -6.72517866e-02f, 4.30822782e-02f, 7.63534084e-02f, -1.74496938e-02f, 9.81225166e-03f, -2.17114612e-02f, 4.33596000e-02f, -2.30667442e-02f, -1.81776632e-04f, 2.38543074e-03f,
  -2.45335698e-03f, -1.23654166e-02f, -4.27573994e-02f, -1.52295707e-02f, 1.71349607e-02f, 2.71262247e-02f, 2.08435766e-03f, -4.90787774e-02f, -5.94114810e-02f, 4.75851865e-03f,
  -4.35477383e-02f, -5.34088947e-02f, 2.49292161e-02f, 6.14184793e-03f, -4.22944054e-02f, -7.86511227e-03f, 6.21726140e-02f, 3.31375375e-03f, -1.60493664e-02f, -5.18026156e-03f,
  9.37939137e-02f, -3.70526984e-02f, -6.13199966e-03f, -1.76923051e-02f, -9.88270529e-03f, -5.04261032e-02f, -5.72388619e-02f, 8.88191238e-02f, 9.44009982e-03f, 3.46769765e-02f,
  4.34850715e-03f, -1.44665428e-02f, 3.71457599e-02f, -1.66781545e-02f, 1.24616288e-02f, -5.59217557e-02f, 8.57366323e-02f, -4.12161984e-02f, -5.77239366e-03f, -7.21638137e-03f,
  1.51674777e-01f, 2.18238756e-01f, 1.33438706e-02f, 1.82447806e-02f, 7.87494108e-02f, -1.52972527e-02f, 2.01595984e-02f, 6.09184876e-02f, 4.55802195e-02f, 1.41513022e-02f,
  -5.81573918e-02f, -2.06591748e-03f, -4.55117710e-02f, 3.08567891e-03f, -2.55085551e-03f, 5.47489859e-02f, 3.55594344e-02f, 2.75373906e-02f, 4.55682501e-02f, 3.91281135e-02f,
  2.58241855e-02f, 2.22468935e-02f, -4.74325940e-03f, 1.29025360e-03f, 9.21278670e-02f, -2.83522047e-02f, -5.06897904e-02f, -3.76591347e-02f, 3.97373810e-02f, 5.80687560e-02f,
  4.29108560e-01f, -2.97114775e-02f, 1.50529608e-01f, 1.98203415e-01f, 4.99809114e-03f, -3.34380083e-02f, 1.83787998e-02f, -1.08976379e-01f, 1.01767197e-01f, -1.23819903e-01f,
  -2.80222259e-02f, 2.93129295e-01f, -6.77558854e-02f, 3.59102488e-02f, 1.38912201e-01f, -1.62116110e-01f, 1.10770412e-01f, -1.15955132e-03f, -5.68922684e-02f, -6.01655319e-02f,
  8.43514875e-02f, -1.49160802e-01f, -3.03767212e-02f, -2.19470128e-01f, 6.71382770e-02f, 2.00707726e-02f, -1.40480831e-01f, -6.44738227e-02f, 1.27009638e-02f, 4.26076725e-02f,
  4.23088670e-02f, -7.91342556e-02f, 3.68998647e-02f, 1.57710947e-02f, -7.64669329e-02f, -6.29100725e-02f, -2.07754374e-02f, -2.57500131e-02f, 8.79890751e-03f, -2.15325691e-02f,
  8.58068541e-02f, 6.75398633e-02f, -2.06740052e-02f, 2.32695770e-02f, 1.08663440e-01f, -3.41318808e-02f, 5.57002276e-02f, 8.52393433e-02f, -3.75836343e-02f, 3.73199247e-02f,
  5.77031597e-02f, 3.92379723e-02f, -1.47827426e-02f, -4.65629585e-02f, 2.55233534e-02f, 3.93020175e-02f, 6.93843588e-02f, 2.47227922e-02f, -2.88156718e-02f, 4.56083305e-02f,
  4.52616112e-03f, -6.12520278e-02f, -1.58243102e-03f, -1.60814933e-02f, -5.25300996e-03f, -1.16905989e-02f, 3.62998364e-03f, 3.29277553e-02f, -5.92180481e-03f, 9.98548865e-02f,
  2.04533543e-02f, -1.17641585e-02f, 5.19108884e-02f, -1.50877312e-02f, 3.63602536e-03f, -1.25520518e-02f, -1.98849812e-02f, 9.64969862e-03f, 5.60140908e-02f, 6.16168557e-03f,
  -3.44459154e-02f, -1.06670912e-02f, -4.25294116e-02f, -2.90971734e-02f, -1.22694913e-02f, -1.94669012e-02f, -5.14801927e-02f, 7.85054937e-02f, -6.87839612e-02f, -9.49863624e-03f,
  -3.43063138e-02f, -7.94830024e-02f, -3.36230733e-02f, -1.53273419e-02f, -8.04075412e-03f, 4.16241167e-03f, 5.36887832e-02f, 5.06089292e-02f, -4.47122790e-02f, -2.04273667e-02f,
  -2.69806739e-02f, 5.29811829e-02f, 3.15246619e-02f, 2.57840510e-02f, -4.96961316e-03f, -1.10063832e-02f, -2.45860089e-02f, -1.14322139e-03f, 5.85479811e-02f, -5.11943810e-02f,
  2.47613825e-02f, -7.44063873e-03f, -9.19142505e-04f, -4.95049059e-02f, 6.83344677e-02f, -1.20330062e-02f, -1.81288440e-02f, 1.01690842e-02f, 4.69935499e-02f, -3.38697918e-02f,
  -3.31154376e-01f, 4.54063565e-02f, -1.34640247e-01f, -4.44219746e-02f, -1.28765509e-01f, -1.26175135e-01f, -1.13354377e-01f, -9.91903841e-02f, -1.28980935e-01f, 7.00156391e-02f,
  -8.59439000e-02f, 1.03885762e-01f, 1.43333554e-01f, -8.14087130e-03f, -1.05539158e-01f, 1.56936809e-01f, -8.08736607e-02f, 4.96475510e-02f, -3.07826679e-02f, -1.52796190e-02f,
  -3.59259993e-02f, -1.04127573e-02f, 7.72792771e-02f, 1.33211762e-01f, -4.73618619e-02f, -8.81086290e-02f, 7.64353722e-02f, -4.08350211e-03f, 2.61817016e-02f, -8.89781713e-02f,
  -3.11332773e-02f, 6.58928528e-02f, -2.87203491e-02f, -1.26268826e-02f, -9.87754613e-02f, -6.68872520e-02f, 2.15204749e-02f, -3.71717103e-02f, 5.92423528e-02f, 2.24514194e-02f,
  -6.02803566e-02f, -4.25612517e-02f, 4.57773060e-02f, 4.63599376e-02f, -5.44870533e-02f, -6.52158782e-02f, 2.40078811e-02f, -1.06277667e-01f, 1.87147632e-02f, 1.41116437e-02f,
  -1.00754604e-01f, -1.74103007e-02f, 6.42973371e-03f, -1.22411046e-02f, 1.60343889e-02f, -2.67934916e-03f, 5.07915020e-02f, -1.30380746e-02f, -1.14058979e-01f, -1.26701258e-02f,
  -6.00989982e-02f, 4.44821492e-02f, -3.41193229e-02f, -1.98499057e-02f, 2.21776459e-02f, -5.41411079e-02f, -2.44822324e-04f, 6.32719547e-02f, -3.29205878e-02f, 6.82914630e-02f,
  -1.44753866e-02f, 3.58814164e-03f, -1.98824075e-03f, -4.81306724e-02f, -4.03965898e-02f, -3.99784297e-02f, 3.94753702e-02f, -5.24725504e-02f, -2.74211913e-02f, -6.93596452e-02f,
  1.62538420e-02f, -5.00207022e-02f, 8.17270018e-03f, -2.82064173e-03f, 1.37474248e-02f, 1.96339805e-02f, 3.95649038e-02f, 2.98340898e-03f, 5.40229827e-02f, -4.58827727e-02f,
  8.92943218e-02f, 3.70771475e-02f, 7.68459290e-02f, -2.90486608e-02f, 3.56719829e-02f, -1.38942087e-02f, -4.24270928e-02f, -5.61745465e-02f, -3.58175226e-02f, -4.37791608e-02f,
  3.09350025e-02f, 3.99275497e-02f, -4.97034229e-02f, -3.89469676e-02f, 1.85513776e-02f, 4.75262292e-02f, 2.64473800e-02f, -3.08043547e-02f, 1.45453969e-02f, -1.62907653e-02f,
  8.38228166e-02f, 4.02515531e-02f, 2.02989765e-02f, -2.64626928e-02f, 2.07920987e-02f, -2.64762379e-02f, -8.25056359e-02f, 7.40234609e-05f, -2.37882677e-02f, 1.70893979e-03f,
  2.94163339e-02f, 1.00262009e-01f, -1.70799971e-01f, -7.43603110e-02f, 1.41964387e-03f, 1.09338034e-02f, -5.02270758e-02f, -3.81223112e-02f, -1.18075781e-01f, 1.38092294e-01f,
  1.14582308e-01f, 1.55081689e-01f, 4.07595634e-02f, -1.12341512e-02f, -1.72172606e-01f, 3.24210972e-02f, -6.85223639e-02f, 1.03843026e-02f, 2.07404345e-02f, 1.14246674e-01f,
  -4.22929637e-02f, 5.15540391e-02f, -1.07803464e-01f, 2.94733420e-02f, -2.02031303e-02f, 1.02213016e-02f, 6.23289794e-02f, -6.18420802e-02f, -2.43998915e-02f, -8.16968158e-02f,
  -2.49041356e-02f, -7.92637989e-02f, 3.49107645e-02f, -3.52903195e-02f, 4.54081269e-03f, 1.01514250e-01f, 4.77046892e-02f, -9.98513773e-02f, -1.73625350e-01f, 2.05762424e-02f,
  4.75673378e-02f, 1.26721039e-02f, -5.08445129e-02f, -5.71395904e-02f, -1.28701270e-01f, -9.78689492e-02f, -8.51628631e-02f, -3.08026820e-02f, -5.99413924e-02f, 8.42691436e-02f,
  -2.54943352e-02f, -1.14430033e-01f, -9.23310146e-02f, 5.72937988e-02f, -1.28916234e-01f, -7.78007060e-02f, 5.97368665e-02f, 2.30986401e-02f, -6.30313605e-02f, -7.11771473e-02f,
  -4.63652046e-04f, -8.48456100e-02f, 6.42591342e-02f, -8.93442184e-02f, 5.81643879e-02f, 2.47280374e-02f, -3.01210638e-02f, -4.75900732e-02f, -3.81591655e-02f, 2.04452761e-02f,
  -3.34447362e-02f, 7.28791431e-02f, -2.49367207e-02f, 4.91894893e-02f, 9.13816988e-02f, 7.47775435e-02f, 1.39666656e-02f, 3.86101268e-02f, -4.70419861e-02f, -4.82268333e-02f,
  -7.03206062e-02f, 6.00267462e-02f, 4.32496443e-02f, -6.32563792e-03f, -1.05144337e-01f, 3.89471613e-02f, -1.78571027e-02f, -8.08966253e-03f, -8.87791887e-02f, 4.84412275e-02f,
  5.24222963e-02f, 2.58233905e-01f, 1.94334779e-02f, -4.82210554e-02f, -6.29957840e-02f, 1.55483494e-02f, -1.19788945e-01f, 4.53593954e-03f, 6.82870671e-03f, -2.38158051e-02f,
  3.82069498e-02f, -2.87765078e-02f, 5.57218380e-02f, -3.32249515e-02f, -1.88696459e-02f, 9.55813378e-03f, -3.17332149e-02f, 3.38545218e-02f, -8.01386833e-02f, 2.12855190e-02f,
  1.19420551e-02f, 8.20550621e-02f, -7.85278752e-02f, 2.16731499e-03f, 1.08773569e-02f, -5.11896797e-02f, -9.06926487e-03f, 2.34934017e-02f, -5.13709374e-02f, -2.15865243e-02f,
  3.98132093e-02f, -2.21207514e-01f, -3.94672062e-03f, -3.05977076e-01f, -8.26371014e-02f, -3.60166132e-01f, -2.79263228e-01f, -7.49307349e-02f, -1.72193348e-01f, -1.27683550e-01f,
  -3.86540480e-02f, 2.94652488e-02f, 1.78416315e-02f, -3.37601632e-01f, 5.81803098e-02f, -6.76303208e-02f, -4.08689111e-01f, -1.88112408e-01f, -4.22627851e-02f, -1.33648932e-01f,
  -8.02342966e-02f, -6.31074458e-02f, -4.26060241e-03f, -9.29687545e-02f, -1.06598318e-01f, 3.62331010e-02f, 7.80940875e-02f, 1.70872569e-01f, -7.95244426e-02f, 5.27926385e-02f,
  -9.33328271e-02f, -6.48112446e-02f, 3.99863459e-02f, 1.00042470e-01f, -6.71973825e-02f, -2.69282795e-02f, 6.05380870e-02f, 1.21848762e-01f, 8.33768919e-02f, -2.64032315e-02f,
  -5.45313880e-02f, 5.51319495e-02f, -5.61007252e-03f, 7.84831569e-02f, 1.36710471e-02f, -1.06393201e-02f, -4.75163125e-02f, -6.59008324e-02f, -7.79464748e-03f, -4.73574270e-03f,
  -1.24669872e-01f, 3.98725532e-02f, -5.16912304e-02f, -5.31400815e-02f, 2.74658110e-02f, -5.31602316e-02f, -5.00419997e-02f, 5.08507201e-03f, -7.96998143e-02f, -9.10724164e-04f,
  1.54740701e-03f, 2.63507534e-02f, -5.27943298e-03f, -9.07496177e-03f, -8.30713883e-02f, 2.68160682e-02f, -2.34711356e-03f, 2.88857594e-02f, -9.69213713e-03f, 1.53279938e-02f,
  -7.16296732e-02f, 7.65364664e-03f, -1.02422899e-02f, 1.61918011e-02f, -4.11157422e-02f, -1.09655082e-01f, 7.07420558e-02f, 9.78739839e-03f, -8.15526396e-02f, -6.89071417e-02f,
  -9.89197660e-03f, -7.27723166e-02f, 9.38613638e-02f, 7.25926366e-03f, -2.49402970e-02f, -1.71217173e-02f, -1.55957909e-02f, -8.57490115e-03f, -3.83717939e-02f, -1.78603083e-02f,
  -1.98279992e-01f, -1.48872182e-01f, -8.97091348e-03f, -2.14798171e-02f, 2.87518743e-03f, 1.73962526e-02f, -2.61134785e-02f, 2.34401179e-03f, -1.52683556e-02f, 5.25086336e-02f,
  -1.60671994e-02f, 3.11147403e-02f, 4.60033044e-02f, 1.69945434e-02f, -4.71705794e-02f, -1.08944125e-01f, -2.52306964e-02f, 1.84085090e-02f, -1.01607405e-01f, 4.15134057e-02f,
  2.07599141e-02f, -2.65351459e-02f, 4.84251464e-03f, -9.53320116e-02f, -3.89722176e-02f, -4.05393057e-02f, -1.14441782e-01f, -7.35752955e-02f, 1.00515187e-01f, -3.28829549e-02f,
  3.16394746e-01f, -2.36367181e-01f, 2.33295023e-01f, 6.96807057e-02f, 1.25118867e-01f, 4.69541270e-03f, 8.66713449e-02f, 1.85825139e-01f, 5.48489429e-02f, -1.09494597e-01f,
  1.19017303e-01f, 2.21436955e-02f, -6.28371239e-02f, -1.73955653e-02f, 1.02835275e-01f, -1.36031151e-01f, 9.05200839e-03f, 4.74569798e-02f, -4.80563194e-03f, 1.40612513e-01f,
  7.48495236e-02f, 4.24262322e-02f, 7.31674070e-03f, 1.03590839e-01f, 1.49859831e-01f, 3.79706062e-02f, -8.30106735e-02f, 1.19486973e-01f, -1.69943757e-02f, 2.14610379e-02f,
  7.97511823e-03f, 7.77417496e-02f, 1.29933983e-01f, 1.33312538e-01f, 2.43820157e-02f, 9.76209491e-02f, 8.21053796e-03f, -5.72150759e-02f, 5.30567877e-02f, 6.80444166e-02f,
  -2.22937893e-02f, 4.79665324e-02f, 9.16810632e-02f, -5.31070419e-02f, 9.08499584e-02f, 4.23359536e-02f, -1.51449936e-02f, -2.40777130e-03f, -4.56791893e-02f, 4.45273407e-02f,
  -5.35687525e-03f, 1.60705242e-02f, 5.28872982e-02f, -1.33831307e-01f, 1.87738203e-02f, -5.94828930e-03f, -1.06599294e-01f, 4.36944030e-02f, -9.56386402e-02f, 1.35519495e-02f,
  -1.69971809e-02f, 4.40968797e-02f, 2.60867365e-02f, 3.97884585e-02f, 3.39949392e-02f, -6.58585504e-02f, 5.15619591e-02f, -1.98772829e-02f, 3.01835556e-02f, -3.13547300e-03f,
  4.24219780e-02f, -3.72987352e-02f, -8.59997347e-02f, 6.57159463e-02f, -3.43980975e-02f, -8.28406364e-02f, 4.66183163e-02f, 3.43106426e-02f, 7.53344148e-02f, -1.66503582e-02f,
  -6.59954846e-02f, 2.01892434e-03f, 1.48422429e-02f, -9.64071378e-02f, 2.36036479e-02f, 2.02413388e-02f, 2.34794114e-02f, -1.57919002e-03f, 2.79003642e-02f, -6.92918152e-02f,
  -1.41057387e-01f, -1.26216233e-01f, 7.32837059e-03f, 8.38714689e-02f, -1.94701981e-02f, -2.39689229e-03f, 4.48999964e-02f, 1.69056095e-02f, 1.93593483e-02f, 4.38402593e-02f,
  6.93084747e-02f, -5.84679693e-02f, -2.19854768e-02f, 4.05078232e-02f, 1.16598466e-02f, 3.86687331e-02f, -7.81723559e-02f, -4.10155905e-03f, 4.32433225e-02f, 2.50056125e-02f,
  -9.87551548e-03f, -3.55786495e-02f, 7.96705708e-02f, -4.52841073e-02f, -3.73248197e-02f, -3.37423868e-02f, 4.16758284e-02f, -2.27237437e-02f, -1.08334318e-01f, -5.25812320e-02f,
  -3.43846262e-01f, 1.56575784e-01f, 2.39686176e-01f, -4.03093547e-03f, -1.65760592e-01f, -1.13865390e-01f, 8.06610510e-02f, -4.92150448e-02f, -2.67324686e-01f, 1.60465032e-01f,
  2.03115121e-01f, 6.41368777e-02f, 6.47408962e-02f, 8.51657428e-03f, -1.66438460e-01f, 6.45412654e-02f, -1.52328774e-01f, 1.12945385e-01f, -5.38863018e-02f, 3.20710316e-02f,
  -1.19854510e-01f, -1.92658037e-01f, 1.97750762e-01f, 3.04015540e-02f, 2.97585744e-02f, 8.13539922e-02f, 5.47515303e-02f, 2.64908940e-01f, 1.76110163e-01f, 1.40075564e-01f,
  5.36119305e-02f, -1.80487446e-02f, -3.35747451e-02f, 5.73568419e-02f, 4.35907841e-02f, 3.07366215e-02f, 9.60969627e-02f, -3.52416597e-02f, 3.09464000e-02f, -5.52831963e-02f,
  6.98904619e-02f, 3.33391801e-02f, -1.62917580e-02f, -6.70821965e-03f, -6.64263442e-02f, 9.39690508e-03f, -5.09403162e-02f, 2.49162447e-02f, 7.21544772e-02f, 9.26988795e-02f,
  6.82724863e-02f, -2.83576502e-03f, -1.17495824e-02f, -9.02454660e-04f, 8.94633457e-02f, -7.47622773e-02f, -7.90200010e-02f, 4.14006524e-02f, -2.69386079e-02f, -3.17374952e-02f,
  3.91553231e-02f, -1.96051020e-02f, -7.16130883e-02f, 4.89428379e-02f, -7.99261779e-02f, -2.38178261e-02f, -6.90846443e-02f, 5.58663420e-02f, -2.98506077e-02f, 2.39694975e-02f,
  1.75089985e-02f, 1.67391577e-03f, -3.95893045e-02f, -1.10910989e-01f, 4.05960381e-02f, 6.91746967e-03f, 2.42030229e-02f, 1.03007257e-01f, -3.77075523e-02f, -1.56362522e-02f,
  1.38182724e-02f, 5.50799593e-02f, 7.89755285e-02f, 5.45425452e-02f, -1.35550144e-04f, -8.14225376e-02f, 4.64975312e-02f, 2.21111309e-02f, 8.64172801e-02f, 6.31359667e-02f,
  7.45816305e-02f, 6.80444017e-02f, 8.22338567e-04f, -4.10374366e-02f, 3.57979611e-02f, 2.06764266e-02f, -4.63870540e-02f, 3.33590657e-02f, -2.58417688e-02f, -9.22797471e-02f,
  -7.63741359e-02f, -6.58509042e-03f, 7.87614286e-03f, 2.55834088e-02f, 1.03734117e-02f, -7.61117116e-02f, 4.17770036e-02f, -7.27831870e-02f, -1.16564222e-01f, 2.07806118e-02f,
  -4.43221852e-02f, -8.83998200e-02f, 1.70052685e-02f, -3.46752442e-02f, -6.90259635e-02f, 1.17098086e-01f, -6.86102360e-02f, 6.46952027e-03f, 2.84582060e-02f, 8.58883113e-02f,
  1.07325934e-01f, -7.09657732e-04f, 5.67756072e-02f, -1.23502530e-01f, 1.57288119e-01f, 9.38160047e-02f, 4.71746642e-03f, 5.28965592e-02f, 2.70148784e-01f, -2.28238583e-01f,
  -1.52865648e-02f, -5.84177785e-02f, -9.85775515e-03f, -2.11671516e-01f, -9.61833820e-02f, 1.45554036e-01f, -1.42759725e-01f, -1.44374505e-01f, 1.98216617e-01f, -1.75399244e-01f,
  7.27734864e-02f, -2.65721560e-01f, -1.24575704e-01f, -2.01106118e-03f, -3.90522815e-02f, 4.19586040e-02f, -3.21919173e-01f, 2.97925547e-02f, -3.01227480e-01f, -1.08808447e-02f,
  4.97785844e-02f, 3.15724104e-03f, -9.61770210e-03f, 2.65364978e-03f, -1.71371680e-02f, -1.09704891e-02f, -9.96388942e-02f, -1.36651685e-02f, 6.35305718e-02f, 2.76756543e-03f,
  3.31101492e-02f, -2.98537407e-02f, -2.75030881e-02f, -1.15049556e-02f, 1.47358403e-01f, -1.38758086e-02f, 1.08035794e-02f, 1.30232377e-02f, 7.98834767e-03f, 1.39209569e-01f,
  5.85415028e-02f, 2.86404025e-02f, 1.47464396e-02f, -1.16421066e-01f, -8.44441056e-02f, 4.84250207e-03f, 3.30030881e-02f, -4.34854254e-02f, -5.67065086e-03f, 3.97801623e-02f,
  -2.07966212e-02f, 9.24589261e-02f, -1.64294261e-02f, 4.30404171e-02f, -3.08572613e-02f, 7.72475381e-04f, 2.61916816e-02f, -3.93875018e-02f, -1.38221430e-02f, -8.19225144e-03f,
  2.54613943e-02f, 3.56253562e-03f, -2.35644635e-02f, 1.09492704e-01f, 1.01887202e-02f, 6.71363575e-03f, -3.53488363e-02f, -1.49516165e-02f, 2.24052519e-02f, 5.25805876e-02f,
  -1.52793219e-02f, 1.30842747e-02f, 5.26761860e-02f, -4.06359136e-02f, 1.90003291e-02f, 3.23181748e-02f, -2.07616147e-02f, 4.33888659e-02f, -1.25257939e-03f, -3.11674904e-02f,
  1.21384347e-02f, -3.31954621e-02f, -4.93767299e-03f, 3.07879113e-02f, 3.84695120e-02f, -2.86290958e-03f, 7.60151166e-03f, -2.66235340e-02f, -3.23724821e-02f, -5.47774658e-02f,
  -9.62330699e-02f, -3.62769552e-02f, -4.86563798e-03f, -1.29547026e-02f, -3.58924381e-02f, 5.54724364e-03f, -5.69665711e-03f, 2.73020528e-02f, -6.79429919e-02f, -7.38675967e-02f,
  -5.65056643e-03f, -4.28429134e-02f, -1.70197040e-02f, -4.68302220e-02f, -7.29246996e-03f, 2.92711575e-02f, -5.11512198e-02f, 7.59062544e-02f, 2.19091978e-02f, -3.47157829e-02f
};

// L0_fan_Wp_bar (Shape: 26 x 120)
const int L0_fan_Wp_bar_rows = 26;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  8.88222158e-02f, 3.39735478e-01f, 1.60386845e-01f, 1.96593419e-01f, -2.33924091e-01f, -3.07638645e-01f, -1.26870736e-01f, 8.53564441e-02f, 6.46268055e-02f, 5.59305698e-02f,
  -8.86455625e-02f, 2.77422518e-01f, -5.97673729e-02f, 8.75173882e-02f, -2.50050187e-01f, -2.14925230e-01f, 1.23802135e-02f, 6.54738694e-02f, -2.12952271e-02f, 1.11778282e-01f,
  -8.48672390e-02f, -3.64099853e-02f, -1.48554109e-02f, -5.81026226e-02f, 1.30393714e-01f, 1.85977489e-01f, -4.21281867e-02f, -7.96027258e-02f, 1.26572952e-01f, -7.44773671e-02f,
  -1.26781940e-01f, 1.72025189e-01f, 1.00468449e-01f, 1.71770118e-02f, -3.12468540e-02f, -5.96726052e-02f, -1.36820935e-02f, -3.16252485e-02f, 9.10277595e-04f, -4.54542898e-02f,
  -4.38732840e-02f, -3.91092561e-02f, 4.17340137e-02f, -6.58635870e-02f, -3.13107343e-03f, 6.89707026e-02f, -4.93297540e-02f, 4.86529022e-02f, 8.92622843e-02f, 5.16840741e-02f,
  9.74466279e-02f, 5.66568337e-02f, 7.66514540e-02f, 9.86063927e-02f, 1.10667832e-02f, 5.66915981e-02f, -2.74576619e-02f, 3.19664204e-03f, 3.76484878e-02f, 3.95333804e-02f,
  -5.19228540e-03f, 1.74045737e-03f, -2.82352734e-02f, 4.60808612e-02f, -5.50293177e-02f, -4.82912511e-02f, -1.22271525e-02f, -6.68829447e-03f, 3.64905149e-02f, -6.70112222e-02f,
  -8.27473551e-02f, 9.53406692e-02f, -1.33879215e-01f, -1.19065319e-03f, -1.00432403e-01f, 5.09556867e-02f, -2.69265473e-02f, -5.61698265e-02f, 4.29587299e-03f, -3.75837758e-02f,
  -1.32042710e-02f, -9.88445729e-02f, 4.20940667e-02f, -8.10487848e-03f, -3.57174389e-02f, 4.48612384e-02f, 9.41455215e-02f, 1.74557546e-03f, -5.69587983e-02f, 5.03757894e-02f,
  -5.57852909e-02f, 7.62956813e-02f, 6.55269548e-02f, 4.85617518e-02f, -4.75822901e-03f, -4.35843915e-02f, -4.12562601e-02f, -1.37986233e-02f, -2.39850152e-02f, -1.85774325e-03f,
  8.39827284e-02f, -7.81349391e-02f, -6.30047619e-02f, 1.84462313e-02f, 6.94513740e-03f, -3.09506934e-02f, -3.51449139e-02f, -1.08757116e-01f, -1.87907889e-02f, 1.48136569e-02f,
  1.56904832e-02f, -8.43718648e-02f, -3.87383439e-02f, -4.03982066e-02f, -2.32675113e-02f, 2.64276955e-02f, 8.20253715e-02f, 1.80266816e-02f, 6.33710437e-03f, 1.97237656e-02f,
  1.62732899e-01f, 2.10941538e-01f, 2.33285591e-01f, 1.91839397e-01f, -2.43247598e-01f, -1.21886067e-01f, -8.27439874e-02f, -2.88948137e-02f, 1.56411886e-01f, 1.06958270e-01f,
  -2.51366317e-01f, 2.65888453e-01f, -1.48645744e-01f, 4.30981852e-02f, -8.60181302e-02f, -1.74841344e-01f, 8.72964561e-02f, 5.79613773e-03f, -3.91016565e-02f, 1.86756685e-01f,
  -8.09567515e-03f, -2.02722982e-01f, -6.01773560e-02f, -1.10603616e-01f, 1.88213021e-01f, 1.89014927e-01f, -9.07023400e-02f, -1.38787642e-01f, 1.97780639e-01f, -7.77417645e-02f,
  1.96713731e-02f, 1.05707683e-01f, 1.15230285e-01f, 1.13958225e-01f, -4.08603698e-02f, 8.03067833e-02f, 3.97709981e-02f, -4.24974114e-02f, -3.02105080e-02f, 7.09516406e-02f,
  6.14823662e-02f, -3.37178372e-02f, 3.81347165e-02f, -7.19238743e-02f, 5.42742945e-02f, 3.97518165e-02f, 5.78446165e-02f, 8.76421481e-02f, 4.65176329e-02f, 7.19688237e-02f,
  6.10679612e-02f, 1.29738316e-01f, 3.41450050e-02f, 3.70933823e-02f, 2.82031856e-02f, 1.03153057e-01f, 3.31056528e-02f, 1.00782305e-01f, -9.35239159e-03f, 6.40126690e-02f,
  3.91414538e-02f, -1.16667524e-01f, -2.31745820e-02f, -6.86460733e-02f, 5.65024763e-02f, -6.74279109e-02f, -1.09727234e-02f, 1.55917304e-02f, 1.05919778e-01f, -8.20639133e-02f,
  -7.67289847e-02f, 5.90481460e-02f, -9.42114666e-02f, -3.62471938e-02f, 1.79374069e-02f, 1.05421126e-01f, -2.25234348e-02f, -1.12200327e-01f, -2.72528664e-03f, 9.01518539e-02f,
  3.26521359e-02f, -6.60413876e-02f, 4.50119190e-02f, 2.22541648e-03f, -6.25663772e-02f, 2.45688576e-02f, 2.60512941e-02f, 6.48911819e-02f, 5.01438975e-03f, 7.83175603e-02f,
  3.08826100e-02f, 1.20881908e-01f, -3.54102638e-04f, -2.53947526e-02f, 8.67675021e-02f, -6.18285127e-02f, -8.62676799e-02f, 9.91300046e-02f, 1.44476183e-02f, -3.33387963e-02f,
  3.46698128e-02f, 1.11697875e-02f, 9.46639776e-02f, -4.51412946e-02f, 2.29571853e-02f, 6.12656996e-02f, -3.77253480e-02f, 3.17925736e-02f, 4.74133790e-02f, -1.52392257e-02f,
  2.92767696e-02f, -3.52535509e-02f, 1.53023358e-02f, 4.77050170e-02f, 2.12118048e-02f, -8.47878214e-03f, -1.16192941e-02f, 1.24765441e-01f, 1.27096195e-02f, -6.71147136e-03f,
  -9.24332142e-02f, -3.60397846e-02f, 3.02933846e-02f, -2.42681801e-01f, 3.57682519e-02f, -1.85261369e-01f, -3.19663525e-01f, 3.13636474e-02f, -1.10479090e-02f, 1.36404097e-01f,
  -1.80304363e-01f, 7.47790858e-02f, 5.06167151e-02f, -3.06501299e-01f, -3.92395079e-01f, -1.39858738e-01f, -3.48777741e-01f, -1.90804601e-01f, -8.08133483e-02f, -1.15133099e-01f,
  -6.76428303e-02f, -2.22411692e-01f, -2.67158806e-01f, 5.61649259e-03f, -2.22783387e-02f, 1.04786970e-01f, 1.24151580e-01f, 6.62529236e-03f, -9.00563225e-02f, 9.44772270e-03f,
  -4.82714735e-02f, 1.81223508e-02f, 3.63512523e-02f, 4.33254987e-02f, -4.77657951e-02f, 9.43393931e-02f, 3.56146283e-02f, -1.05012365e-01f, -4.48215678e-02f, 4.49406579e-02f,
  9.99476835e-02f, 1.82356220e-02f, 3.72586452e-04f, 3.12829390e-02f, 6.23075105e-02f, -5.69480658e-02f, 6.52449802e-02f, 3.03053819e-02f, -9.68971290e-03f, -1.27743222e-02f,
  -1.96593478e-02f, 6.05793484e-02f, 3.55240405e-02f, 2.91614570e-02f, -6.90218853e-03f, -4.91350284e-03f, -3.01535800e-02f, 6.84937686e-02f, -1.51067608e-04f, 4.42277902e-04f,
  2.12830696e-02f, 1.04506530e-01f, 2.88239438e-02f, 1.60059799e-02f, -5.59497662e-02f, 4.28263322e-02f, -5.42313121e-02f, -4.03619464e-03f, -2.68313792e-02f, -1.78366918e-02f,
  2.66833231e-02f, -2.52629239e-02f, -1.00160353e-02f, -1.34232398e-02f, -1.06579646e-01f, -7.36465156e-02f, 3.52423489e-02f, -3.56868543e-02f, -6.36982173e-02f, -6.07734313e-03f,
  4.70380904e-03f, -1.28369285e-02f, 1.63761321e-02f, -2.24244408e-02f, -2.73661986e-02f, -7.29015172e-02f, 9.04166475e-02f, -3.99748087e-02f, -2.26666667e-02f, -3.85724865e-02f,
  -7.94228464e-02f, 1.18584421e-06f, 1.02937187e-03f, 5.01759760e-02f, -1.39698535e-02f, -2.85816006e-03f, -2.39860062e-02f, -6.18671812e-02f, -4.73289937e-03f, -4.89337966e-02f,
  1.15812026e-01f, -1.33601865e-02f, 1.29435835e-02f, 2.92987283e-02f, 2.38019079e-02f, 1.70833953e-02f, 4.05523414e-03f, 9.97793898e-02f, -2.42086384e-03f, 7.43007511e-02f,
  4.16363589e-02f, 3.33130658e-02f, -4.33954932e-02f, 6.02022447e-02f, 8.88459459e-02f, 1.06247529e-01f, 3.60093564e-02f, -7.14686587e-02f, -4.64609563e-02f, 4.19030227e-02f,
  -1.67890459e-01f, 3.67013842e-01f, 1.44600660e-01f, 1.09251596e-01f, 5.46984561e-02f, 1.30287275e-01f, 1.79257333e-01f, -5.76220751e-02f, 1.96785629e-01f, 1.43994674e-01f,
  -1.42881319e-01f, 1.84647396e-01f, -9.16686058e-02f, 5.65651879e-02f, -1.31723985e-01f, 1.00831069e-01f, 6.58282861e-02f, 1.79872110e-01f, 9.04109851e-02f, -1.17409945e-01f,
  -7.08796456e-02f, 8.03365838e-03f, -1.68321699e-01f, -1.12376466e-01f, 2.59607993e-02f, -3.07015423e-02f, -8.13800618e-02f, -3.64235975e-02f, 7.52183795e-02f, 1.01021089e-01f,
  -3.22614126e-02f, -2.51330752e-02f, -6.87435735e-03f, 4.18111756e-02f, -6.37911260e-02f, 4.44931425e-02f, -3.29155177e-02f, 7.55988732e-02f, -6.07607216e-02f, 1.15661830e-01f,
  3.08512580e-02f, -3.43252867e-02f, 4.66129035e-02f, 7.81278983e-02f, -2.81243585e-02f, 1.02587938e-02f, 2.12645438e-02f, 7.24158287e-02f, 3.06251775e-02f, 2.37778388e-02f,
  -8.05986300e-02f, -7.08667859e-02f, 8.34593456e-03f, 3.88648584e-02f, -8.28787312e-02f, 7.47707710e-02f, 5.61020523e-03f, 5.43733500e-02f, -7.77640846e-03f, 6.55839816e-02f,
  6.90527111e-02f, -6.24760538e-02f, 7.85362273e-02f, -7.45692775e-02f, -9.19535477e-03f, -3.07181925e-02f, 2.97516529e-02f, -2.59371661e-02f, -2.14754622e-02f, -4.07402888e-02f,
  5.81446588e-02f, -8.91761482e-03f, -8.09284020e-03f, 9.20848921e-02f, -5.47014251e-02f, -3.53278518e-02f, -1.33520896e-02f, -1.47440014e-02f, 6.91809654e-02f, -6.89975396e-02f,
  -8.90820399e-02f, 5.83815277e-02f, 5.31192496e-02f, 6.22858033e-02f, -4.34018113e-02f, -2.76044067e-02f, -1.11394480e-01f, -3.23221162e-02f, 1.31547693e-02f, 7.82270450e-03f,
  1.86109319e-01f, 1.16236329e-01f, 6.50153905e-02f, 1.13139208e-02f, -6.25021309e-02f, 1.11013912e-01f, 1.79648791e-02f, 2.63448823e-02f, 1.32742614e-01f, 1.24684384e-03f,
  -3.42518240e-02f, 8.12606588e-02f, 1.79843735e-02f, -5.80495931e-02f, 7.72110671e-02f, 1.39956251e-01f, 2.23985668e-02f, 7.38612637e-02f, -1.24414675e-02f, -3.82609218e-02f,
  4.82582897e-02f, -5.64341284e-02f, -3.15061882e-02f, -3.88161652e-02f, -6.99408585e-03f, 5.77337295e-03f, 7.07429051e-02f, 2.69615576e-02f, -9.76209063e-03f, 4.09828126e-02f,
  -7.41657391e-02f, -2.93765455e-01f, -2.99944967e-01f, -1.31460235e-01f, 1.38813183e-01f, -9.59370360e-02f, -1.87345967e-01f, -1.55116484e-01f, -1.85776591e-01f, 1.78599104e-01f,
  -7.67005840e-03f, -4.89133522e-02f, -5.64494468e-02f, -2.58017391e-01f, -2.63351560e-01f, -8.96231756e-02f, -2.25807369e-01f, -1.66555405e-01f, -7.63534307e-02f, -1.16227597e-01f,
  -4.53237221e-02f, -2.05256537e-01f, -2.19408289e-01f, 2.44781878e-02f, -9.94294137e-02f, 6.94062486e-02f, 2.68006831e-01f, 1.03121042e-01f, -4.65049371e-02f, -6.84679747e-02f,
  -1.11743240e-02f, -2.43856180e-02f, -1.26638025e-01f, -8.55256170e-02f, 4.95724045e-02f, 3.72046046e-02f, 9.51846391e-02f, 1.28387371e-02f, 9.47794542e-02f, -8.79611745e-02f,
  9.33749601e-02f, -4.97380532e-02f, -9.42429453e-02f, 1.75792109e-02f, -2.47909296e-02f, -1.42138340e-02f, -6.77862093e-02f, 7.84028620e-02f, -2.40238793e-02f, -4.46020253e-02f,
  -1.24068782e-01f, -9.21083428e-03f, -3.50780576e-03f, 8.59951973e-03f, 3.17244902e-02f, -3.58552113e-02f, 3.91588621e-02f, -2.00369544e-02f, 3.43887173e-02f, 2.36127246e-03f,
  4.95656505e-02f, 2.70243995e-02f, -7.96763599e-02f, -6.17550053e-02f, -9.79287177e-03f, -3.27367224e-02f, -5.37488386e-02f, 4.18848805e-02f, 1.76232420e-02f, 5.53568155e-02f,
  4.71803434e-02f, 2.43350584e-02f, -2.98049543e-02f, 3.79340835e-02f, -8.91134143e-03f, -1.93094667e-02f, -7.65176350e-03f, 1.08244540e-02f, 6.02696091e-02f, -6.15340285e-02f,
  1.28107974e-02f, -3.79323065e-02f, -1.25768274e-01f, 5.47917672e-02f, -8.61536935e-02f, 1.78287625e-02f, 7.43412897e-02f, -1.01923734e-01f, 6.67735413e-02f, 5.44780791e-02f,
  -6.46347553e-02f, 1.75428852e-01f, -5.24329767e-02f, -5.21532409e-02f, -4.73843375e-03f, -1.10206157e-02f, -6.89601665e-03f, -9.37340036e-02f, 6.99652210e-02f, 2.45561302e-02f,
  9.73033234e-02f, 9.66382213e-03f, 1.51634663e-01f, -4.77172509e-02f, 6.56589195e-02f, 3.94384637e-02f, 4.74059023e-02f, 6.26416951e-02f, 2.73586195e-02f, 9.40912217e-02f,
  9.01574045e-02f, 5.80658913e-02f, -1.42278699e-02f, -6.57050535e-02f, -3.13802920e-02f, 4.69880644e-03f, -4.93576471e-03f, 1.01928048e-01f, -1.54723432e-02f, -3.91906090e-02f,
  3.03118408e-01f, -1.63143188e-01f, -7.57639855e-02f, 2.86471009e-01f, 2.98801303e-01f, 1.28212469e-02f, 9.87681299e-02f, 2.63182878e-01f, 3.23924333e-01f, -2.86524724e-02f,
  2.09804308e-02f, -2.48074263e-01f, -2.48626024e-01f, 1.40823424e-01f, 9.82046425e-02f, -2.20549643e-01f, 1.96352229e-01f, 5.27542904e-02f, 1.96295470e-01f, 1.24877430e-01f,
  2.02250063e-01f, 2.80764401e-01f, -5.63652664e-02f, 9.88342836e-02f, 2.44249329e-01f, 1.04490928e-01f, 1.23433005e-02f, -1.15418427e-01f, 4.59002033e-02f, -1.68260392e-02f,
  7.31847733e-02f, 8.53904486e-02f, -1.20235300e-02f, -4.68686409e-02f, -2.64515188e-02f, -1.00025218e-02f, -3.66303697e-02f, -1.18938923e-01f, 1.03415616e-01f, -7.65314624e-02f,
  -1.52355745e-01f, 3.02428342e-02f, 6.29576817e-02f, -5.81729366e-03f, -5.52514195e-02f, 4.97823432e-02f, 5.37319742e-02f, 1.45354152e-01f, -4.62530889e-02f, 2.77165342e-02f,
  1.05593964e-01f, -8.76511708e-02f, 1.02126017e-01f, 1.04709357e-01f, -2.21856986e-03f, 1.27975225e-01f, -7.98532218e-02f, -4.59947735e-02f, -3.50331105e-02f, 6.97342008e-02f,
  1.25051243e-02f, -1.00802314e-02f, -2.89569125e-02f, 2.19674222e-02f, 8.14751983e-02f, 1.30654693e-01f, 3.41624729e-02f, -4.96845730e-02f, -4.68805507e-02f, 2.65107173e-02f,
  3.62990759e-02f, 1.19066127e-01f, 9.86585915e-02f, 3.82404104e-02f, 8.36461857e-02f, 7.85048008e-02f, -9.75541174e-02f, -7.25419596e-02f, 8.31461027e-02f, -7.64285401e-02f,
  5.82396872e-02f, -7.58824497e-02f, -9.66492202e-03f, -3.45234014e-02f, 5.37912510e-02f, 1.32855028e-02f, 7.82111136e-04f, 8.32340121e-02f, 2.22243741e-02f, -7.09458441e-02f,
  7.82014579e-02f, -1.10923707e-01f, -6.36616498e-02f, -5.38711287e-02f, -7.21037462e-02f, -5.44598326e-02f, -4.38303985e-02f, 3.30185965e-02f, 7.69672915e-02f, 3.89895067e-02f,
  -2.00019348e-02f, 6.15363970e-05f, -5.49546964e-02f, -9.45722405e-03f, -3.83747891e-02f, 6.96050376e-02f, -9.96414423e-02f, 7.74290264e-02f, -4.06586863e-02f, -6.34701401e-02f,
  -3.41705345e-02f, 1.19787604e-02f, -2.33029714e-04f, 1.30416276e-02f, -4.86530550e-03f, -3.37036587e-02f, 4.80140373e-02f, 2.01969724e-02f, -5.31959087e-02f, -7.89823197e-03f,
  3.02801907e-01f, -3.42811078e-01f, -1.78701237e-01f, 1.24082737e-01f, 2.95141667e-01f, 1.00189932e-01f, 8.02057832e-02f, 1.26984239e-01f, 5.27482629e-02f, -1.79610327e-01f,
  4.07701954e-02f, -1.92420408e-01f, -3.16031098e-01f, -4.90445532e-02f, 7.55267665e-02f, -2.67772079e-01f, 1.02429062e-01f, -1.89205240e-02f, -6.10477813e-02f, -3.11620124e-02f,
  1.83490306e-01f, 1.86566591e-01f, -1.13355324e-01f, 1.80926293e-01f, 6.83834031e-02f, 1.40716329e-01f, 1.66582823e-01f, -7.23654702e-02f, 2.05980211e-01f, 9.89243090e-02f,
  7.35879838e-02f, -7.61705786e-02f, 4.79113013e-02f, -2.08973978e-02f, 2.99816560e-02f, 6.89675659e-02f, 8.46393779e-03f, -4.57941666e-02f, 8.25965181e-02f, -9.78433937e-02f,
  6.06174022e-03f, 8.39678422e-02f, 7.17856809e-02f, 5.03158756e-02f, 6.07977994e-02f, 1.61478333e-02f, -3.53536643e-02f, -2.68265046e-02f, 3.06819961e-03f, -9.98480320e-02f,
  -1.23765975e-01f, 7.21483305e-03f, -2.06982177e-02f, -1.00889683e-01f, -6.57199994e-02f, -9.18906834e-03f, 7.35341311e-02f, -9.14365649e-02f, -5.50049171e-02f, 4.25955169e-02f,
  -1.80685241e-02f, 4.26149294e-02f, -4.02780250e-02f, 3.80820222e-02f, -4.51310389e-02f, -3.33223492e-02f, -4.93539795e-02f, -2.47453004e-02f, -2.28567515e-03f, -1.87892243e-02f,
  -6.10298850e-02f, -8.08748603e-02f, -2.78165825e-02f, -5.27850091e-02f, 1.45841325e-02f, 3.80689986e-02f, 8.86353999e-02f, 1.56862307e-02f, -1.02828750e-02f, -2.76929867e-02f,
  1.39787924e-02f, 5.91959544e-02f, 1.28578153e-02f, 1.08896121e-01f, -1.72480941e-02f, -2.93001756e-02f, 7.12035298e-02f, -3.41884121e-02f, 7.70956501e-02f, 4.10860740e-02f,
  -3.70561704e-02f, -2.80374885e-01f, -3.40463892e-02f, 7.28400275e-02f, -1.64531931e-01f, -5.86626194e-02f, -6.46866411e-02f, -1.10069569e-02f, -1.37658268e-01f, -8.38096216e-02f,
  7.09972978e-02f, 1.74789615e-02f, -5.03918603e-02f, 1.45298848e-02f, 6.90426975e-02f, -1.86424095e-05f, -4.29141745e-02f, -6.12633824e-02f, 2.67395135e-02f, -5.57502359e-02f,
  5.29906899e-02f, -1.19658830e-02f, -9.27114952e-03f, 8.35506525e-03f, 3.56847025e-03f, -3.25123556e-02f, 3.40576507e-02f, -1.05220815e-02f, -9.48104635e-02f, -2.07587099e-03f,
  2.08951861e-01f, 1.14809744e-01f, -6.01221211e-02f, 1.53841749e-01f, -1.70831144e-01f, -1.56528875e-01f, -1.80478826e-01f, 9.90289077e-02f, -3.41547169e-02f, 3.27405520e-02f,
  6.97453767e-02f, 7.65364617e-02f, 7.58772269e-02f, 1.12533450e-01f, 7.56449699e-02f, -1.01963028e-01f, 1.11978143e-01f, 3.07571683e-02f, -5.53475367e-03f, 2.06884295e-01f,
  6.70745969e-02f, 1.01511162e-02f, 1.59568131e-01f, 7.17980117e-02f, 1.45145491e-01f, 1.24141388e-01f, 1.92167431e-01f, -3.16915736e-02f, 6.98028654e-02f, -6.99214712e-02f,
  -2.27190088e-03f, -1.99956913e-02f, -6.26763254e-02f, 1.06141549e-02f, 3.47948670e-02f, 7.78415874e-02f, 5.02255522e-02f, -9.77558717e-02f, -4.66089621e-02f, 2.80554164e-02f,
  -4.78507914e-02f, -1.22244097e-02f, -7.11885691e-02f, 3.74685100e-04f, -7.79161528e-02f, 4.12602797e-02f, 3.08265593e-02f, 7.19576403e-02f, -2.09863000e-02f, 3.62819876e-03f,
  -9.73705854e-03f, 7.43760169e-03f, 9.52982623e-03f, -1.06471144e-02f, 6.84027746e-02f, 3.20587829e-02f, -1.71915963e-02f, -6.13440536e-02f, -2.60016024e-02f, 9.74847376e-02f,
  9.72493216e-02f, 3.37189138e-02f, 1.56232202e-02f, -6.52342513e-02f, -7.49618420e-03f, -2.05241498e-02f, -1.85776558e-02f, -8.98604766e-02f, 1.17542475e-01f, 1.43116051e-02f,
  -1.19490482e-01f, 1.48072420e-02f, 2.31536496e-02f, -7.64286285e-03f, 1.62028745e-02f, 1.54261421e-02f, -1.14854850e-01f, -7.46882111e-02f, 4.10536192e-02f, -3.30365188e-02f,
  -1.20285274e-02f, 2.46584378e-02f, 1.60665959e-02f, 2.34431252e-02f, -2.91334204e-02f, 8.63420963e-02f, 4.76492830e-02f, 6.88715205e-02f, -1.03485147e-02f, 1.70144979e-02f,
  1.52415028e-02f, 2.06471041e-01f, -9.33686551e-03f, -4.71456274e-02f, -6.05349727e-02f, 6.98318630e-02f, 3.71535346e-02f, 2.18973923e-02f, 4.27757539e-02f, 2.40715221e-03f,
  1.77615695e-02f, 1.13165975e-02f, -2.71573514e-02f, -3.15123424e-02f, -1.48463985e-02f, 9.77160260e-02f, 6.48728162e-02f, 6.39972389e-02f, 4.69948947e-02f, 1.96191221e-01f,
  4.52284142e-02f, -9.36911777e-02f, 1.21914037e-01f, -1.17900066e-01f, 5.19010760e-02f, 2.03628484e-02f, 4.88169007e-02f, 4.73673679e-02f, -3.62152718e-02f, 3.89382169e-02f,
  2.39128411e-01f, 7.94224367e-02f, -2.68806487e-01f, -7.18019456e-02f, 1.68741196e-01f, 2.68879235e-01f, 9.86164734e-02f, 5.63802198e-02f, -7.16767907e-02f, 9.35982540e-02f,
  1.06827438e-01f, 5.71704023e-02f, -1.41302198e-01f, 2.48279765e-01f, 1.97657421e-01f, -5.48160337e-02f, 2.53689617e-01f, 8.43848437e-02f, -1.10946357e-01f, 1.78943217e-01f,
  -4.92473729e-02f, 2.83264041e-01f, -1.92202896e-01f, 3.68869528e-02f, 1.13982029e-01f, -2.23550841e-01f, -9.60052162e-02f, -5.83743304e-02f, 3.12483460e-02f, 9.96109322e-02f,
  1.42011512e-02f, 3.91045585e-03f, -7.46247843e-02f, -3.72298062e-02f, 1.02423839e-02f, -1.89280026e-02f, 6.42634323e-03f, -8.98882151e-02f, -1.04286887e-01f, -4.85844351e-02f,
  3.54233533e-02f, 9.20222476e-02f, 8.79023150e-02f, 3.15919556e-02f, 1.02896273e-01f, -6.24823896e-03f, -1.05737120e-01f, -6.65034205e-02f, -8.18423256e-02f, 5.96679337e-02f,
  -5.68315089e-02f, 3.30178589e-02f, 2.11071633e-02f, -4.58545871e-02f, -1.61906838e-01f, 2.72403168e-03f, 2.61344481e-02f, -5.64192049e-03f, 8.08553696e-02f, 9.05287862e-02f,
  1.56379953e-01f, 7.10324720e-02f, 8.88505131e-02f, -2.60015167e-02f, 1.08443778e-02f, -1.07703097e-01f, 4.33348771e-03f, -4.72448170e-02f, -5.35968803e-02f, 1.59993786e-02f,
  1.77747384e-02f, -3.02353930e-02f, -4.66913320e-02f, 9.23242345e-02f, 7.28085041e-02f, 1.88776627e-02f, 4.05582301e-02f, 3.45201902e-02f, 2.44778208e-02f, -6.20345362e-02f,
  -1.99794210e-02f, 2.21039522e-02f, 1.26305467e-03f, -1.20867833e-01f, -6.16279058e-02f, 2.52759438e-02f, 4.43046130e-02f, 1.91933047e-02f, -1.90896783e-02f, -3.58910076e-02f,
  8.42168108e-02f, 1.28355354e-01f, -4.32233810e-02f, 1.07153140e-01f, 9.00069345e-03f, 9.11512673e-02f, 1.49695883e-02f, 1.02394029e-01f, -1.15788030e-02f, 6.59557581e-02f,
  9.19608995e-02f, -9.39386338e-02f, 7.24486336e-02f, 3.77286822e-02f, 4.23840992e-02f, 4.02153246e-02f, 3.42602059e-02f, -5.24476431e-02f, 5.11286370e-02f, 1.18746348e-02f,
  2.70287301e-02f, 7.75662735e-02f, -3.27148773e-02f, 5.74842701e-03f, 7.97336400e-02f, -2.79645287e-02f, -3.77131552e-02f, 1.90567356e-02f, 2.75823288e-03f, -9.82026681e-02f,
  6.14428483e-02f, -8.04219395e-02f, -2.29060739e-01f, -1.95900828e-01f, -7.29833469e-02f, -2.60405153e-01f, -3.14870268e-01f, -1.01691589e-01f, -1.73458252e-02f, -2.76601743e-02f,
  -3.78008746e-02f, 5.20772785e-02f, 6.27602190e-02f, -2.68611491e-01f, -1.71542883e-01f, 7.43889809e-02f, -3.27316940e-01f, -1.50050506e-01f, 1.15446270e-01f, -5.64285964e-02f,
  -1.36432704e-02f, -5.09665795e-02f, -2.33661577e-01f, 6.34768754e-02f, -1.91054806e-01f, 3.19701321e-02f, 2.23947212e-01f, 4.70801517e-02f, -1.01789735e-01f, 3.18153389e-02f,
  -5.53985201e-02f, 5.25506563e-04f, -3.88389896e-03f, 6.21248968e-02f, -3.44680510e-02f, -2.66560595e-02f, -7.24936053e-02f, 7.93707650e-03f, -3.12413555e-02f, -5.46602383e-02f,
  4.00395133e-02f, 1.04140200e-01f, -1.48632156e-03f, 1.22313388e-01f, -4.90118749e-02f, -1.40924631e-02f, -3.75128910e-02f, -1.23969503e-01f, -9.22958627e-02f, 5.43667888e-03f,
  -7.54566491e-02f, -1.25027135e-01f, -9.86013338e-02f, 2.96679437e-02f, -7.66973826e-04f, -7.81279728e-02f, -1.11860871e-01f, -6.09300323e-02f, -3.71159576e-02f, -5.55886477e-02f,
  5.77117801e-02f, 6.36429116e-02f, -7.50026181e-02f, 3.55305299e-02f, 4.27248925e-02f, -1.10267298e-02f, -7.16236681e-02f, 4.10998054e-02f, -1.58356056e-02f, -4.01783399e-02f,
  -1.44868717e-02f, 2.18676999e-02f, 1.81023870e-02f, -6.44837618e-02f, -1.92023031e-02f, 7.56755620e-02f, -5.29978145e-03f, 2.27897502e-02f, -2.33535040e-02f, -1.16042439e-02f,
  1.06491167e-02f, 8.02232698e-03f, -6.05877116e-02f, -1.60800864e-03f, -6.44988716e-02f, 7.44065084e-03f, 1.20933130e-02f, -3.37579735e-02f, -2.12003458e-02f, 2.42692158e-02f,
  -5.74181043e-02f, 8.08105394e-02f, -4.88336086e-02f, 8.04055482e-02f, 1.61794946e-02f, -1.36972917e-02f, -4.01746221e-02f, -1.34224230e-02f, -5.47958128e-02f, 4.89358902e-02f,
  -2.39661410e-02f, 5.48926070e-02f, -7.97916353e-02f, -7.61501342e-02f, -8.93537886e-03f, -1.57189503e-01f, 5.12489267e-02f, 1.73698515e-02f, -3.55467713e-03f, -7.50928596e-02f,
  9.28183049e-02f, 3.89687307e-02f, 2.72519868e-02f, -4.38854983e-03f, -3.00275255e-02f, -2.53030518e-03f, 6.55926473e-04f, 2.80994028e-02f, 5.29381782e-02f, -2.57106554e-02f,
  1.25337109e-01f, 3.35383087e-01f, 2.82600284e-01f, 2.56515354e-01f, -6.66198283e-02f, -2.95345724e-01f, -2.57193506e-01f, 1.42743856e-01f, 6.37754658e-03f, 9.71160755e-02f,
  -4.73239683e-02f, 2.58908868e-01f, -1.03450030e-01f, 9.46061835e-02f, -3.03556353e-01f, -1.75685823e-01f, -2.37304922e-02f, 1.62582789e-02f, -6.25187010e-02f, 1.03227898e-01f,
  3.92583013e-02f, -9.84505489e-02f, 2.60475930e-03f, 8.43015090e-02f, 1.67267367e-01f, 2.65787393e-01f, -2.06154343e-02f, -3.02396994e-02f, 2.42500305e-01f, -1.27326354e-01f,
  -7.49521749e-03f, 3.20886122e-03f, 1.36108816e-01f, 2.51855440e-02f, 6.81837788e-03f, -3.67064178e-02f, 3.07715423e-02f, -9.88690555e-02f, -6.44224957e-02f, 3.46603018e-04f,
  -1.63271837e-02f, 7.16682477e-03f, 5.36885150e-02f, 1.63324308e-02f, 4.26897183e-02f, 2.65245233e-02f, 7.85605758e-02f, 1.17645375e-02f, 4.47896160e-02f, 3.22271325e-02f,
  1.13831729e-01f, 1.33854538e-01f, 3.92307229e-02f, -7.64070218e-03f, 2.52620131e-03f, -3.34526189e-02f, 5.80481105e-02f, 7.05178231e-02f, 4.52918150e-02f, 3.83854024e-02f,
  -3.18775885e-02f, -2.89992522e-03f, -6.84053451e-02f, -1.82770323e-02f, 3.86155881e-02f, 9.74120980e-04f, -5.86422309e-02f, -8.18176642e-02f, 5.14357875e-04f, -8.84054080e-02f,
  3.49908322e-02f, 1.88072608e-03f, -5.48405163e-02f, -3.92083339e-02f, 5.61712757e-02f, 2.38675009e-02f, -7.19185770e-02f, 8.04073066e-02f, 1.16638541e-01f, 5.09083495e-02f,
  -3.49652171e-02f, -4.16449793e-02f, -4.29017954e-02f, 6.63302690e-02f, -9.91251394e-02f, 1.63978599e-02f, 7.41406064e-03f, 9.41086411e-02f, 9.32984054e-03f, -6.25616238e-02f,
  2.60213297e-02f, 1.86783105e-01f, 7.49227926e-02f, -7.81442150e-02f, -5.87988086e-02f, -4.76006744e-03f, -2.10307892e-02f, 9.86691043e-02f, 4.32224944e-02f, -5.28267995e-02f,
  -1.84067823e-02f, 4.55664061e-02f, -3.97703098e-03f, -1.10292308e-01f, -4.20210324e-02f, -4.62842546e-02f, 5.19188046e-02f, 6.77219704e-02f, 1.09523334e-01f, 3.52418050e-02f,
  8.52262005e-02f, -1.88431405e-02f, -6.22875169e-02f, -4.40072566e-02f, -9.98230651e-03f, 3.14121433e-02f, -6.81480914e-02f, 1.09124020e-01f, 3.58425342e-02f, 3.91847044e-02f,
  2.57063331e-03f, 9.07129347e-02f, 7.78057650e-02f, 1.80421457e-01f, 8.30429718e-02f, 1.67078614e-01f, 2.15386897e-01f, 1.06863625e-01f, 3.47942740e-01f, 6.16680132e-03f,
  -1.56054974e-01f, -1.83098957e-01f, -3.49671692e-02f, 6.42237663e-02f, -9.28410217e-02f, 1.27736911e-01f, 3.00419778e-02f, 6.11610115e-02f, 2.01512486e-01f, -2.69146767e-02f,
  2.50806194e-02f, -8.32092464e-02f, -1.54912286e-02f, -1.43548027e-01f, -4.01359200e-02f, 1.90620329e-02f, -8.17044750e-02f, 5.10220118e-02f, -7.04995021e-02f, 2.83528902e-02f,
  7.98517764e-02f, 1.77520975e-01f, -4.82159257e-02f, -5.00573926e-02f, -1.20705172e-01f, -9.15897712e-02f, -1.03034277e-03f, -3.43837924e-02f, 4.49023992e-02f, 7.10416809e-02f,
  4.00733165e-02f, -1.23150893e-01f, 8.35266709e-03f, -1.31302729e-01f, 1.03661448e-01f, -4.06710394e-02f, 6.94339275e-02f, 5.24529144e-02f, -5.95477782e-02f, 3.39139067e-02f,
  -7.07130581e-02f, 3.56905311e-02f, 1.64198160e-01f, 6.80866316e-02f, 3.95418294e-02f, 1.48873866e-01f, 1.32487090e-02f, -9.01102051e-02f, -9.36268046e-02f, -9.21453070e-03f,
  -6.41411766e-02f, 4.10034619e-02f, -1.27187446e-01f, -4.60861027e-02f, -7.29705915e-02f, -2.13923547e-02f, -4.57734242e-02f, -2.62943618e-02f, 7.99337924e-02f, -4.52000685e-02f,
  4.57762964e-02f, 3.06982105e-03f, 5.91107719e-02f, -2.14274367e-03f, 1.55873343e-01f, -5.87914586e-02f, 4.01333719e-02f, -4.39404920e-02f, 9.14901122e-02f, -1.01571187e-01f,
  -2.76029091e-02f, -4.57601584e-02f, -1.94049429e-03f, 1.41071556e-02f, -6.60712868e-02f, 3.08878571e-02f, 2.41579898e-02f, -6.04388751e-02f, 4.77502719e-02f, -5.79677485e-02f,
  6.01137951e-02f, 8.91675577e-02f, 2.54347045e-02f, -1.56894326e-02f, 7.91673549e-03f, -1.72698155e-01f, -1.19111799e-01f, -1.47270057e-02f, -1.40758101e-02f, -7.15773851e-02f,
  5.77904321e-02f, 2.08717827e-02f, -2.21814821e-03f, -3.53529043e-02f, 1.44357430e-02f, -2.87286844e-02f, 5.30086749e-04f, 5.34453467e-02f, 7.38266408e-02f, -8.38565081e-02f,
  -1.61554158e-01f, 5.24479635e-02f, -4.84736040e-02f, 1.02089338e-01f, 4.37717466e-03f, -6.16480224e-02f, -3.35707441e-02f, 3.83348316e-02f, -7.51141012e-02f, 4.82102856e-02f,
  -2.59953737e-01f, 2.28617162e-01f, 1.37382559e-02f, 1.28761649e-01f, 1.48189723e-01f, -3.42241675e-01f, 1.47915492e-02f, 1.75370146e-02f, 7.15897456e-02f, 1.84476525e-01f,
  1.75439164e-01f, 4.14570533e-02f, 8.08268115e-02f, -2.74182986e-02f, -2.76324570e-01f, -9.96584147e-02f, -2.08127663e-01f, -7.33677968e-02f, -9.37460456e-03f, 4.06237766e-02f,
  -5.87205105e-02f, 2.10679382e-01f, -8.56827721e-02f, 1.49435565e-01f, -1.10702701e-02f, 1.24778055e-01f, 7.77666420e-02f, 1.40263170e-01f, -7.57575780e-02f, 8.29813182e-02f,
  -1.46111414e-01f, 1.99832737e-01f, 6.04716614e-02f, -1.31287694e-01f, -1.33186966e-01f, -1.43339306e-01f, -4.63550016e-02f, 1.72336884e-02f, 3.99821512e-02f, 1.77718699e-02f,
  -3.24348845e-02f, 4.70996983e-02f, -1.34915691e-02f, 1.58650547e-01f, -1.83416270e-02f, 7.92844743e-02f, -5.51924966e-02f, -5.80910817e-02f, -7.71883875e-02f, -1.15391120e-01f,
  -2.40363106e-02f, 1.02540469e-02f, -8.68499130e-02f, -1.69201553e-01f, -3.21222208e-02f, 4.67041321e-02f, 1.03587834e-02f, -2.71100122e-02f, -1.15499750e-01f, -9.94877517e-02f,
  -6.00097422e-03f, -4.75318581e-02f, 1.52113941e-02f, -1.91244185e-02f, 7.37413615e-02f, -4.22588475e-02f, 9.45871100e-02f, -1.93126611e-02f, 9.21148732e-02f, -2.94213695e-03f,
  3.07765473e-02f, -3.49236699e-03f, 1.22021928e-01f, 2.87408335e-03f, -2.25437507e-02f, 2.43674088e-02f, -2.33058054e-02f, 5.72741143e-02f, -3.64211984e-02f, 7.34644830e-02f,
  8.29709992e-02f, 4.95569296e-02f, -2.76519768e-02f, -8.66190791e-02f, 8.88990983e-02f, 3.87388021e-02f, -6.48370609e-02f, -1.14742741e-01f, -4.26118784e-02f, 2.31886399e-03f,
  -5.67227863e-02f, 8.49229991e-02f, -1.52053935e-02f, -8.22386742e-02f, 5.29414881e-03f, -3.29884849e-02f, -1.87711863e-04f, -1.16646245e-01f, 1.70770362e-02f, -8.59151706e-02f,
  1.97591484e-02f, -9.41627696e-02f, -1.53533474e-01f, -6.64094687e-02f, 1.13987755e-02f, -6.01957180e-02f, 5.94095029e-02f, 5.38918562e-02f, 7.73514295e-03f, -4.47867028e-02f,
  1.34565751e-03f, 6.56437874e-02f, -7.12076388e-03f, -1.43959252e-02f, -7.92884231e-02f, -6.24285527e-02f, 5.30012622e-02f, 1.69469882e-02f, -6.80281073e-02f, -3.12057491e-02f,
  -6.26496375e-01f, 2.00565919e-01f, 2.48581022e-01f, -2.62793720e-01f, -8.54612235e-03f, 1.84132412e-01f, -1.29970850e-03f, 9.48650762e-02f, 5.12742586e-02f, 1.13887750e-01f,
  1.03499100e-01f, -3.46607268e-02f, 1.65719017e-01f, 1.40794784e-01f, -1.55353144e-01f, -2.64755753e-03f, 7.77226388e-02f, -1.45660127e-02f, 3.79752889e-02f, -4.41653430e-02f,
  -1.46312043e-01f, -3.29749025e-02f, 5.00625148e-02f, 1.52383462e-01f, 2.53955983e-02f, -2.98305620e-02f, -1.30308211e-01f, 6.04906864e-02f, -8.18645582e-02f, 1.81699675e-02f,
  -4.33664650e-01f, -1.69539869e-01f, 1.66100804e-02f, 5.10639548e-02f, -2.23029573e-02f, 3.14668473e-03f, -8.57522562e-02f, -8.46498013e-02f, -1.71921905e-02f, 7.24162683e-02f,
  -1.86137203e-02f, 8.99305195e-02f, 1.22236945e-02f, 6.90773427e-02f, 8.24757386e-03f, 1.71549839e-03f, 1.79213961e-03f, 6.99683055e-02f, 5.19376509e-02f, 5.77459373e-02f,
  1.31960556e-01f, 7.39274174e-02f, -3.95362936e-02f, -5.97384870e-02f, 9.51524172e-03f, 6.41750917e-02f, 6.61052018e-02f, -9.22938213e-02f, 4.71931808e-02f, 4.57652062e-02f,
  -9.63271633e-02f, 4.95308079e-03f, -3.13851275e-02f, -2.77188569e-02f, -3.48484330e-02f, 4.24550584e-04f, -1.74844486e-03f, -7.01269656e-02f, -2.26699542e-02f, -3.50561067e-02f,
  -5.81680275e-02f, -1.19938880e-01f, -1.02284938e-01f, -9.47997048e-02f, 4.26376723e-02f, -4.54820767e-02f, -5.83311766e-02f, 4.24266122e-02f, 1.27115533e-01f, 3.74817513e-02f,
  -2.88623758e-02f, -6.47009909e-02f, -7.02249631e-02f, -7.89786410e-03f, 2.04762109e-02f, -6.11763038e-02f, 1.82342883e-02f, -3.51575315e-02f, -8.87858495e-02f, -1.23060815e-01f,
  -2.90872693e-01f, -3.47488523e-01f, -9.51949731e-02f, -2.24829465e-02f, -9.86506464e-04f, -8.65007266e-02f, -6.59364602e-03f, 3.21353003e-02f, -4.44867648e-02f, -2.44301260e-02f,
  3.15270759e-02f, -3.72687131e-02f, -1.15872994e-02f, 4.42383997e-02f, 3.95783372e-02f, -1.52563965e-02f, -1.09174296e-01f, -2.50986870e-02f, -6.75345510e-02f, 9.98973921e-02f,
  -2.84509752e-02f, -4.88328971e-02f, -7.49308169e-02f, 4.76915427e-02f, -3.50017361e-02f, -1.01705551e-01f, -1.06744066e-01f, 1.77535359e-02f, -1.04455985e-01f, -2.71485224e-02f,
  8.93621147e-02f, 1.28309906e-01f, 1.35557786e-01f, 2.02572733e-01f, 2.21580163e-01f, 3.36444043e-02f, -2.69211195e-02f, 1.04642399e-01f, 3.34944397e-01f, -1.87770844e-01f,
  -2.43090708e-02f, -1.95107218e-02f, -4.63859513e-02f, 5.09916209e-02f, -3.74827921e-01f, -8.25488865e-02f, -1.49248056e-02f, 9.12855193e-02f, 1.27037615e-01f, 1.42295837e-01f,
  7.51548260e-02f, -6.49297144e-03f, -1.32560104e-01f, 7.17962384e-02f, 1.30501598e-01f, 3.47205624e-02f, -2.75197357e-01f, 1.60003814e-03f, -1.68733880e-01f, -4.92901765e-02f,
  -9.19914469e-02f, 6.64108396e-02f, -1.74405351e-01f, -2.49990094e-02f, 1.71790272e-02f, 7.35165775e-02f, -1.07764669e-01f, -7.57092191e-03f, -2.09167171e-02f, -4.52408828e-02f,
  -1.32011930e-02f, 3.36302095e-03f, 6.22469969e-02f, 4.03727368e-02f, 8.37982222e-02f, -6.13342924e-03f, 1.37289912e-01f, 5.66938818e-02f, 6.74488023e-02f, 1.27802581e-01f,
  1.13921724e-01f, -7.83940181e-02f, -3.77106369e-02f, -7.21139461e-02f, -4.16770466e-02f, 1.07538588e-02f, 1.22533869e-02f, -1.75351687e-02f, -2.19921879e-02f, 3.50071341e-02f,
  3.26734409e-02f, 4.41303141e-02f, 1.60591071e-03f, 1.06297806e-02f, -2.08075438e-02f, -5.16093429e-03f, -8.22645500e-02f, 1.45848505e-02f, 3.65543622e-03f, -5.19932359e-02f,
  2.80543976e-02f, 7.80986948e-03f, 1.51356384e-01f, 5.20064048e-02f, 6.88833185e-03f, 1.05481725e-02f, -5.70507757e-02f, -4.51201834e-02f, -1.06473081e-01f, 1.03568099e-01f,
  2.77963746e-02f, -3.97381708e-02f, 8.29319805e-02f, -3.80211696e-02f, -3.31066363e-02f, 8.91221594e-03f, 2.52718609e-02f, 3.21030058e-02f, 6.85874894e-02f, -2.66079768e-03f,
  -1.99644849e-01f, -5.36148176e-02f, -1.84603989e-01f, -1.07341774e-01f, -8.45251009e-02f, 5.14592640e-02f, -2.21453253e-02f, -1.76232273e-03f, -1.44446790e-01f, 6.03929237e-02f,
  -2.83414256e-02f, -3.41184512e-02f, -7.46185184e-02f, 2.48059481e-02f, -7.95590580e-02f, -1.15089677e-01f, -9.41236690e-02f, -3.33305113e-02f, -1.57306895e-01f, 4.44894210e-02f,
  -3.55291329e-02f, -3.85688096e-02f, -6.08941689e-02f, -9.31358486e-02f, -6.43143579e-02f, -8.49949196e-02f, 3.55660147e-03f, -1.89346122e-03f, -1.93470400e-02f, -6.49599135e-02f,
  -4.08799313e-02f, 2.37969235e-02f, -1.57191977e-01f, -1.59542471e-01f, -2.00263914e-02f, 2.15876281e-01f, 4.41822000e-02f, 8.25431757e-03f, -1.97963759e-01f, 3.31101954e-01f,
  1.45752534e-01f, -1.03749432e-01f, -8.41709450e-02f, 4.09126021e-02f, -4.05331343e-01f, -2.20657423e-01f, 9.85167548e-02f, 1.54343247e-01f, -1.51357338e-01f, 1.96263954e-01f,
  -7.88433403e-02f, 1.19918883e-01f, -1.17434368e-01f, 1.77815899e-01f, 1.44001007e-01f, 2.22040731e-02f, 1.18914716e-01f, -2.61627999e-03f, 1.66948959e-01f, -9.66409408e-03f,
  1.58519879e-01f, -6.30903393e-02f, 6.02075718e-02f, 1.18884090e-02f, 9.29810852e-02f, 2.05004245e-01f, 1.43506438e-01f, -6.06185384e-02f, -1.01110056e-01f, -4.66963165e-02f,
  9.30700377e-02f, -2.42980905e-02f, -1.01115834e-02f, -1.49443001e-01f, -2.87827831e-02f, 1.81597238e-03f, 5.11311144e-02f, -1.72863882e-02f, -1.96443945e-02f, 2.23234552e-03f,
  3.72720174e-02f, -1.05467420e-02f, 4.37165983e-02f, -2.07672194e-02f, -1.01771995e-01f, 1.35359401e-02f, 2.52258163e-02f, -2.17247903e-02f, 1.46901039e-02f, -7.64659420e-02f,
  -3.01794838e-02f, 8.45645070e-02f, 6.10571951e-02f, 1.05231935e-02f, -1.22283213e-01f, 4.60249074e-02f, 7.39433989e-02f, 7.12066740e-02f, -1.10115789e-01f, 5.69325350e-02f,
  9.73263476e-03f, -1.13970347e-01f, -9.30265291e-04f, 1.04663141e-01f, -6.79765865e-02f, 3.15565318e-02f, -5.13327792e-02f, -6.54767826e-02f, -2.70553064e-02f, -1.17017575e-01f,
  1.13173112e-01f, 1.36601971e-03f, 2.23067254e-02f, 3.78903821e-02f, 6.24293350e-02f, -6.04452267e-02f, 1.00025974e-01f, -1.80603079e-02f, -6.02811668e-03f, -3.70867662e-02f,
  8.23975820e-03f, -1.03218602e-02f, -1.52457282e-02f, -7.99057558e-02f, -2.67443936e-02f, 1.24477021e-01f, 6.00722134e-02f, -4.46693897e-02f, 1.34030432e-02f, 3.88575718e-02f,
  1.93638429e-02f, 3.40888067e-03f, 1.35443002e-01f, -1.51350470e-02f, -1.05173152e-03f, 3.69810089e-02f, 1.21013433e-01f, 4.17539179e-02f, -3.78693826e-02f, 3.25210690e-02f,
  4.21938002e-02f, 4.56645563e-02f, -1.12550771e-02f, -5.08010499e-02f, 1.30428877e-02f, 9.62272212e-02f, -2.45364979e-02f, 7.71085843e-02f, -5.74742593e-02f, -1.08960219e-01f,
  -2.06698999e-02f, -2.58887380e-01f, 2.08622038e-01f, -2.29957342e-01f, 1.79772034e-01f, 7.09844828e-02f, 1.58882380e-01f, -1.52772367e-01f, -2.30881304e-01f, -3.04382592e-01f,
  -3.36942710e-02f, 4.46919836e-02f, 1.53604940e-01f, -1.98723957e-01f, 4.48161483e-01f, 1.40031755e-01f, -1.76618040e-01f, -1.08879775e-01f, -5.07539464e-03f, -1.73308223e-01f,
  2.56305281e-02f, -2.58459002e-01f, 8.40829909e-02f, -2.01664165e-01f, -5.35988957e-02f, -2.04187214e-01f, -8.83428156e-02f, 1.75269306e-01f, -1.88123912e-01f, 1.85099721e-01f,
  -5.59293218e-02f, -1.02474011e-01f, -1.43795595e-01f, -2.60818247e-02f, 4.18636687e-02f, -1.67995542e-02f, 2.76348460e-02f, 1.45000264e-01f, 3.28987949e-02f, -1.75131380e-03f,
  1.51937921e-02f, 6.71124309e-02f, -1.58257291e-01f, 8.38063955e-02f, -1.48401409e-01f, -5.29247522e-02f, 5.20397387e-02f, -1.83466624e-03f, -9.11024511e-02f, 8.85293335e-02f,
  5.98548204e-02f, 3.84540558e-02f, -1.80241037e-02f, -7.01710507e-02f, 6.87562227e-02f, 4.24031466e-02f, -2.21612435e-02f, 1.46145716e-01f, 4.61418442e-02f, -9.33103263e-02f,
  -2.46722568e-02f, -3.76659259e-02f, 4.17564847e-02f, -8.68730843e-02f, 4.65939380e-03f, -4.50938679e-02f, -1.75209418e-02f, 1.20153073e-02f, 5.37449270e-02f, -1.68042276e-02f,
  -3.18255387e-02f, -1.74791571e-02f, -3.38839069e-02f, -7.83546790e-02f, -1.47865352e-03f, -5.88019490e-02f, 9.61841829e-03f, -4.80906591e-02f, 1.21934514e-03f, -3.94857191e-02f,
  3.27637084e-02f, 8.53148550e-02f, -4.55273734e-03f, -4.20893915e-03f, -1.77106950e-02f, 7.57064819e-02f, -8.34452957e-02f, 5.32708764e-02f, 4.60390337e-02f, 1.24016739e-01f,
  -2.26796210e-01f, -3.04611653e-01f, -1.04914524e-01f, -6.32632449e-02f, -1.35161102e-01f, -4.99434629e-03f, -4.29030545e-02f, -6.25339821e-02f, 2.67975256e-02f, -7.37718642e-02f,
  8.88066087e-03f, -6.90696239e-02f, -4.75856336e-03f, -1.07933760e-01f, 2.05635745e-02f, -1.51813347e-02f, -4.56246315e-03f, -8.73754844e-02f, -1.48908878e-02f, -2.16122717e-02f,
  -2.68154182e-02f, -6.18078038e-02f, 6.57606199e-02f, -9.16100964e-02f, -1.32500619e-01f, -1.05645200e-02f, -5.52323237e-02f, -5.32241655e-04f, -2.46720351e-02f, 1.21344198e-02f,
  1.97169557e-01f, -1.36923678e-02f, -7.08537623e-02f, 2.69434154e-02f, -9.56897587e-02f, -6.25052825e-02f, -2.34816357e-01f, -1.45395417e-02f, -5.24268746e-02f, -4.56322394e-02f,
  1.03435583e-01f, 1.72224324e-02f, -1.35631591e-01f, 2.24210873e-01f, 2.55144566e-01f, 1.28019480e-02f, 2.04300106e-01f, -8.53117090e-03f, -1.99352298e-02f, 1.28452063e-01f,
  2.15255067e-01f, 2.59357154e-01f, 2.58689225e-02f, 2.04758331e-01f, 8.37043077e-02f, 5.10833487e-02f, 1.70871969e-02f, -6.23433664e-02f, 1.27617821e-01f, 1.01678818e-01f,
  -1.20355867e-01f, -4.32914756e-02f, 7.54167233e-03f, -4.59320471e-02f, 1.01202037e-02f, -8.62532035e-02f, -1.45245001e-01f, 1.17157046e-02f, 1.34434849e-02f, -3.43282335e-02f,
  -2.15843581e-02f, -3.04982485e-03f, -9.81166121e-03f, -1.71105098e-02f, -4.14495617e-02f, 1.62219275e-02f, 2.40417384e-02f, -5.40463403e-02f, -1.11725189e-01f, -1.70042161e-02f,
  4.35078368e-02f, 1.44381747e-02f, 6.29647300e-02f, -1.09587461e-01f, 1.10334016e-01f, -2.57550436e-03f, -2.38644574e-02f, -5.81888948e-04f, 4.40926887e-02f, 5.60583174e-02f,
  -5.21322619e-03f, -3.91593091e-02f, -9.43567697e-03f, -3.60922292e-02f, 8.41900893e-03f, -1.79564878e-02f, 5.24507370e-03f, 5.24196029e-02f, -9.49315652e-02f, 2.78691500e-02f,
  5.39615490e-02f, 3.19658183e-02f, -6.48006350e-02f, -4.07965817e-02f, 1.00663729e-01f, -6.53197691e-02f, 1.00521203e-02f, -1.39521379e-02f, -4.30097431e-02f, -3.80807766e-03f,
  -3.94449085e-02f, 4.98883687e-02f, 2.14231890e-02f, -3.24424356e-02f, 5.65293133e-02f, -4.67884727e-02f, 7.35227093e-02f, -1.04931705e-02f, -7.10028559e-02f, -6.09832108e-02f,
  1.21256009e-01f, 2.11358279e-01f, -5.61616831e-02f, 7.18400702e-02f, 3.46824015e-03f, 7.61422217e-02f, 7.83141777e-02f, 4.74853814e-02f, 3.11979186e-02f, 3.47494781e-02f,
  6.03901893e-02f, 5.06137721e-02f, 7.26777017e-02f, -1.49994774e-03f, 8.30926839e-03f, -1.13991210e-02f, 3.64646390e-02f, -4.74597327e-02f, 1.17332950e-01f, 8.31412524e-02f,
  6.18364215e-02f, -5.66677004e-02f, 6.16586134e-02f, -1.17683485e-02f, -2.55866966e-04f, -1.74414348e-02f, -2.13743579e-02f, -4.98636030e-02f, 1.56679861e-02f, -5.74761443e-02f,
  -2.75695086e-01f, 2.63528436e-01f, -3.01447492e-02f, 1.47952467e-01f, 4.43904512e-02f, 7.49556497e-02f, 2.07284093e-01f, 1.61652461e-01f, 2.91261315e-01f, 5.21451384e-02f,
  -7.32903481e-02f, 1.51015833e-01f, 7.70124272e-02f, 5.48226535e-02f, -1.76815446e-02f, 1.04456186e-01f, 1.31785184e-01f, 1.40690491e-01f, 1.51428953e-01f, 3.26156691e-02f,
  1.24784447e-01f, 8.67564827e-02f, -2.01465622e-01f, 2.20227782e-02f, -1.14420943e-01f, -2.61671934e-02f, -2.59127915e-01f, 8.65031108e-02f, -9.79931504e-02f, -2.33751349e-02f,
  -1.72235623e-01f, 1.31087661e-01f, -3.92757952e-02f, -1.68234054e-02f, 6.46090731e-02f, -9.82837155e-02f, 1.01189613e-01f, 1.17602367e-02f, 8.76983181e-02f, -1.89160444e-02f,
  -2.50959173e-02f, -6.10611141e-02f, -2.06300393e-02f, 3.96325551e-02f, -1.76668167e-02f, -1.41762078e-01f, -3.35823148e-02f, -5.15720658e-02f, -4.47619967e-02f, -1.22762300e-01f,
  -1.52106419e-01f, 4.12330292e-02f, -8.71204436e-02f, -4.18866761e-02f, -7.97314495e-02f, 5.65737188e-02f, 7.70708621e-02f, 3.63172591e-02f, 3.49202529e-02f, 7.00889900e-02f,
  -1.46012660e-02f, 1.51714757e-01f, -3.20500582e-02f, -2.06249673e-02f, -3.11716106e-02f, 2.15446353e-02f, -2.20412705e-02f, -2.61552557e-02f, 1.95212048e-02f, -1.42804310e-02f,
  -1.13313429e-01f, -5.80445044e-02f, -3.12318243e-02f, 3.64720589e-03f, 8.89268145e-02f, 2.51249094e-02f, 4.78728190e-02f, 1.80254541e-02f, -3.16187479e-02f, -1.49155065e-01f,
  1.43469840e-01f, 1.84949711e-02f, -7.85118714e-02f, -1.39591666e-02f, 1.41528090e-02f, -1.85016301e-02f, -1.29408650e-02f, 3.27935293e-02f, 1.37121882e-02f, -1.00369312e-01f,
  1.29439607e-01f, 3.37472260e-01f, -6.49014339e-02f, 5.53066246e-02f, -1.58303592e-03f, 4.59206440e-02f, 1.01619504e-01f, 4.07532556e-03f, 1.37088120e-01f, 2.30077468e-02f,
  -1.87440813e-02f, 4.79613096e-02f, 1.80207826e-02f, -5.03495662e-03f, 9.97657329e-02f, 2.74726213e-03f, 5.89336008e-02f, -6.32246071e-03f, 1.00344487e-01f, 9.14421119e-03f,
  -3.59302945e-02f, 9.28367600e-02f, 2.76831351e-02f, -1.27818808e-01f, 7.80794653e-04f, -3.90027504e-04f, 8.43891352e-02f, -7.87847769e-03f, -2.00765319e-02f, -1.53568890e-02f,
  -2.32648551e-01f, 2.07350492e-01f, 1.83639929e-01f, -2.72726119e-01f, 2.69953877e-01f, 2.54784763e-01f, -1.44012943e-01f, 2.48912990e-01f, -2.90741436e-02f, -4.65621334e-03f,
  -1.24660425e-01f, -5.92430346e-02f, -6.44245148e-02f, -2.53420293e-01f, -2.28796750e-01f, -1.85675845e-01f, -1.15941003e-01f, -4.36272398e-02f, 8.68153498e-02f, -6.26077801e-02f,
  -1.83662660e-02f, -1.80632502e-01f, 1.90048724e-01f, 1.80988729e-01f, 1.91185266e-01f, 1.78712994e-01f, -2.00018942e-01f, 1.52257100e-01f, 2.33141128e-02f, 3.29888053e-02f,
  -2.36542597e-02f, -2.05963850e-01f, 8.41912031e-02f, -5.84461028e-04f, 1.10372335e-01f, 8.42229277e-02f, 4.41890210e-03f, 3.53485756e-02f, -1.04030855e-01f, -2.18478702e-02f,
  6.60523549e-02f, 4.91795614e-02f, -7.13081658e-02f, 4.99176886e-03f, 3.65107469e-02f, 4.08103317e-02f, 6.27039447e-02f, 1.06481068e-01f, 1.25417644e-02f, 1.12308756e-01f,
  5.80283254e-02f, 4.27958965e-02f, -2.50553098e-02f, 1.34945596e-02f, 1.35398254e-01f, -1.77737214e-02f, 1.66130476e-02f, 2.58968137e-02f, -3.99669446e-02f, -2.62508206e-02f,
  4.37497757e-02f, -2.50048935e-02f, -1.14168925e-02f, -7.43008703e-02f, -3.53478156e-02f, 9.15820827e-04f, -3.84509042e-02f, -7.68339261e-02f, -1.93680041e-02f, 1.29327700e-01f,
  2.27431883e-03f, -1.54204620e-03f, 1.75396036e-02f, 5.78660965e-02f, 2.04106537e-03f, -4.99604642e-02f, 7.68333301e-02f, -6.07915893e-02f, 6.86627161e-03f, 1.06493095e-02f,
  -4.69121262e-02f, -1.98025517e-02f, -7.79367099e-03f, -3.81094799e-03f, -6.37104884e-02f, 3.14865783e-02f, 3.83452177e-02f, 1.09366156e-01f, 3.93758789e-02f, -5.67300543e-02f,
  -2.47889459e-02f, -2.72199482e-01f, 2.78803539e-02f, 9.31799263e-02f, -6.17017522e-02f, -3.42424363e-02f, 1.99169870e-02f, -1.40147796e-02f, -2.78875791e-03f, -4.25281032e-04f,
  1.68598928e-02f, -2.20128130e-02f, -3.80471088e-02f, -1.91581305e-02f, -4.25479822e-02f, 3.75618739e-03f, -9.01687741e-02f, -6.62725940e-02f, -1.01946682e-01f, 6.05844744e-02f,
  -3.67607065e-02f, 7.79060200e-02f, -3.62911751e-03f, 4.81255166e-02f, 6.60557002e-02f, -4.16169167e-02f, -2.31818687e-02f, 8.61664563e-02f, 5.20096645e-02f, -4.27777767e-02f,
  -3.16388458e-01f, -2.35889763e-01f, -3.33618999e-01f, 1.29009753e-01f, -1.05643257e-01f, 5.27263768e-02f, 1.60824582e-01f, -1.30840108e-01f, 1.95201263e-02f, 9.61927474e-02f,
  2.05516681e-01f, -4.39557098e-02f, 2.88057290e-02f, 3.56407017e-01f, 1.74306352e-02f, 1.82191044e-01f, 2.63471723e-01f, 1.44878700e-01f, -4.60865647e-02f, -2.03425616e-01f,
  5.21428809e-02f, 2.34699830e-01f, 1.19803742e-01f, 1.39071029e-02f, 4.88161258e-02f, -1.79055795e-01f, 1.08929724e-01f, -1.94099739e-01f, 2.61479050e-01f, 9.29721296e-02f,
  -1.52394623e-01f, -3.09320897e-01f, -6.11528568e-02f, -4.98827882e-02f, -5.00539839e-02f, -5.49095161e-02f, 1.81844309e-02f, -8.26395601e-02f, -1.36916304e-03f, -2.75471639e-02f,
  -1.05297036e-01f, -8.78508464e-02f, -7.15446239e-03f, 7.40966424e-02f, -8.64220038e-03f, -1.16911352e-01f, -1.25518963e-02f, 7.40164220e-02f, -3.72046232e-02f, -4.11975384e-02f,
  -6.98124245e-02f, -9.57942754e-02f, 3.87683101e-02f, 5.75967766e-02f, -1.03377607e-02f, -3.54833938e-02f, 1.56083051e-02f, -8.71952176e-02f, -7.35224485e-02f, 1.52063817e-02f,
  -1.36127006e-02f, -3.50008868e-02f, -1.27438188e-01f, 5.91248944e-02f, -3.78391519e-02f, 9.42169130e-02f, 1.61980204e-02f, 5.17472327e-02f, 1.68854534e-03f, -1.34830056e-02f,
  -2.40549771e-03f, -7.17322826e-02f, 5.25546707e-02f, 6.46111229e-03f, 4.92768995e-02f, 6.35788590e-02f, -5.70653453e-02f, 8.57917778e-03f, 7.05881789e-03f, 7.38114640e-02f,
  -1.19392686e-02f, -7.12984055e-02f, 5.83314709e-02f, 5.48700318e-02f, -9.08491164e-02f, 5.97218573e-02f, 1.89099424e-02f, 1.36585627e-02f, 8.10778886e-02f, 1.81197431e-02f,
  -3.35283309e-01f, -3.17041516e-01f, -3.88584621e-02f, 6.04124591e-02f, 1.11682909e-02f, -2.15343107e-02f, 3.27056870e-02f, -8.00851062e-02f, -1.04118191e-01f, -6.12009615e-02f,
  -1.62460357e-02f, 5.83852306e-02f, -5.52872270e-02f, 7.78870238e-03f, -1.84958316e-02f, -2.54553184e-02f, 1.70926657e-02f, -1.37654003e-02f, 5.87753132e-02f, -4.20112599e-04f,
  -5.50563149e-02f, -4.74739112e-02f, -2.12690467e-03f, -9.00795218e-03f, 9.51788574e-02f, 1.12115247e-02f, -1.27227336e-01f, 3.25972140e-02f, 3.63774225e-02f, -4.57179286e-02f,
  -3.26254815e-01f, 2.16502666e-01f, -6.93241954e-02f, -3.35904956e-01f, 2.37663522e-01f, 3.40779200e-02f, -2.71511883e-01f, 2.23483503e-01f, -1.87807344e-02f, -2.50579476e-01f,
  -1.93478912e-01f, -1.87335670e-01f, 4.62281443e-02f, -1.98721379e-01f, 4.25824374e-02f, 1.25819102e-01f, -1.57920316e-01f, -2.75106609e-01f, 2.57574499e-01f, -4.75079939e-02f,
  -1.97633710e-02f, -4.33545373e-02f, -3.48685533e-02f, 1.46644071e-01f, -1.25983730e-01f, 2.09673606e-02f, -1.78245291e-01f, 1.50052324e-01f, -1.51747108e-01f, 3.42221707e-02f,
  -4.56087738e-02f, -2.42405280e-01f, -4.02847230e-02f, -7.68256411e-02f, -9.96512771e-02f, -1.77585650e-02f, -1.26592666e-01f, -3.67958881e-02f, -3.73767875e-02f, 2.18629520e-02f,
  -3.83544452e-02f, 2.52427650e-03f, -1.05439278e-03f, 6.26787394e-02f, 5.65120392e-03f, -3.35461795e-02f, 7.83223435e-02f, 4.36425544e-02f, 3.26576382e-02f, 3.85879651e-02f,
  5.40093705e-02f, 4.98994999e-03f, -6.97316453e-02f, -1.33706734e-01f, -2.07166709e-02f, -7.25497864e-03f, -4.09787111e-02f, -1.04008727e-01f, -4.92952280e-02f, -2.60387138e-02f,
  -4.02620025e-02f, -1.11670852e-01f, -6.28658086e-02f, 1.53746977e-02f, 6.10338114e-02f, -4.00154339e-03f, 8.78963992e-02f, -2.21001878e-02f, 4.59985510e-02f, -8.95269290e-02f,
  -1.13098465e-01f, -9.07633081e-02f, -9.96323377e-02f, -1.34504154e-01f, 2.66179331e-02f, -7.38579705e-02f, 2.32550269e-03f, 5.76701313e-02f, 8.62476081e-02f, 3.92450299e-03f,
  -4.66121547e-02f, -6.71230163e-03f, -1.49364555e-02f, 6.77401945e-02f, -3.77143957e-02f, 1.12278335e-01f, -8.27490464e-02f, 3.24105807e-02f, -6.39955848e-02f, 6.04135655e-02f,
  5.23159243e-02f, -2.51573890e-01f, 3.45086902e-02f, 7.97897112e-03f, -5.25004603e-02f, -1.07012913e-02f, 8.97660200e-03f, 1.03235476e-01f, -7.14508295e-02f, -2.66308524e-02f,
  -4.65106741e-02f, -5.69242798e-02f, -2.67852582e-02f, 1.01602197e-01f, 2.15400811e-02f, 5.80786876e-02f, -1.14642806e-01f, -6.08695634e-02f, -5.86484633e-02f, 3.14039476e-02f,
  -4.57498841e-02f, -1.24597708e-02f, 2.18941160e-02f, -3.91833819e-02f, -4.03989628e-02f, -1.44822016e-01f, -3.29578929e-02f, 5.66608571e-02f, 5.25306202e-02f, 1.67913828e-02f,
  7.83376768e-02f, -9.20896083e-02f, -8.74147043e-02f, 1.55620694e-01f, -1.70959532e-02f, -2.03573957e-01f, -3.02479744e-01f, 1.98643953e-02f, -1.15036786e-01f, -6.61992505e-02f,
  3.78086455e-02f, 3.41933966e-02f, -2.18774125e-01f, 5.71704023e-02f, 2.44348153e-01f, -2.27526888e-01f, 1.47519261e-01f, 1.00180469e-01f, -3.54162790e-02f, 2.50870846e-02f,
  5.60626276e-02f, 2.38512173e-01f, 1.56538054e-01f, 2.70583004e-01f, 7.36667812e-02f, 6.28807545e-02f, 3.11987072e-01f, 3.98729276e-03f, 2.97463626e-01f, 2.19687283e-01f,
  -6.40027523e-02f, -6.42662868e-02f, -6.91023767e-02f, -6.67117238e-02f, 8.33853707e-02f, 3.81774120e-02f, -5.19460738e-02f, 9.84579772e-02f, -4.31550145e-02f, 6.55776635e-02f,
  -4.27655093e-02f, 6.56248108e-02f, 6.04513064e-02f, 5.32711409e-02f, 6.79510310e-02f, 2.13842653e-02f, -3.50002721e-02f, -7.47220591e-02f, -2.87230499e-02f, 2.10253932e-02f,
  -1.32384136e-01f, -4.49270383e-02f, -4.01520208e-02f, -3.24153192e-02f, -8.44890624e-02f, 1.67212896e-02f, -7.22048208e-02f, 5.22941090e-02f, 1.31193409e-02f, -3.89718413e-02f,
  9.82991327e-03f, 9.12529454e-02f, -8.97451788e-02f, -4.55263518e-02f, -2.92364806e-02f, 6.61652186e-04f, 2.69146264e-02f, -5.52074946e-02f, 4.08085585e-02f, -9.71682649e-03f,
  -4.99327481e-03f, 6.11593351e-02f, 7.92983174e-03f, 4.28463072e-02f, 3.62792462e-02f, -8.35739449e-03f, 8.13380405e-02f, -2.33074874e-02f, -1.09705226e-02f, -9.56477225e-02f,
  2.43924465e-02f, 4.01191339e-02f, -7.19576478e-02f, -5.65799959e-02f, 2.57494524e-02f, 4.97827902e-02f, 8.79090428e-02f, -7.47300237e-02f, -4.82319072e-02f, 7.23632798e-02f,
  4.85496521e-02f, 1.66793287e-01f, 1.42120784e-02f, 1.34014226e-02f, -8.41717795e-03f, 9.35900509e-02f, -9.25628096e-03f, 6.66030496e-02f, 7.37202168e-02f, 2.66903024e-02f,
  2.42513437e-02f, -4.65724431e-02f, 3.06632649e-02f, 1.21925985e-02f, 1.04818575e-01f, -6.36822954e-02f, 1.52854854e-03f, 1.20960936e-01f, 9.71049909e-03f, 6.75725043e-02f,
  -9.90332011e-03f, -2.21463200e-02f, -3.12306304e-02f, -1.20134152e-01f, -1.99961904e-02f, -6.05969392e-02f, -1.16320979e-02f, 7.68967122e-02f, 5.89761622e-02f, 8.63170344e-03f,
  -4.52157944e-01f, -2.83635054e-02f, 1.42468482e-01f, -3.32231969e-01f, -2.29315594e-01f, 1.78531423e-01f, 1.63541779e-01f, -1.02399334e-01f, 3.65181938e-02f, -2.53730007e-02f,
  -9.11462158e-02f, -4.58935015e-02f, 2.26751521e-01f, -4.98549901e-02f, 3.01335365e-01f, 3.28453124e-01f, 3.08438875e-02f, 7.12134093e-02f, 5.63013665e-02f, -1.96159899e-01f,
  -1.03642322e-01f, -2.04315737e-01f, 1.65807948e-01f, -1.86095759e-01f, -3.09376627e-01f, -2.12620616e-01f, -1.57375351e-01f, -4.27473038e-02f, -2.93964714e-01f, -8.75172541e-02f,
  -3.06174874e-01f, -1.65246144e-01f, -1.67289436e-01f, 6.83352258e-03f, -6.78009316e-02f, 1.03734225e-01f, 7.08935410e-02f, -1.16490051e-02f, -5.90334274e-02f, -2.18366198e-02f,
  -3.50256227e-02f, -5.70496134e-02f, -1.05540492e-01f, 3.03543992e-02f, -2.98526417e-02f, -1.07549064e-01f, -7.37600923e-02f, -2.73564309e-02f, 1.07846991e-03f, 8.49010050e-02f,
  1.51748061e-01f, -3.21536027e-02f, -6.16656281e-02f, 5.21775372e-02f, 3.02488022e-02f, -6.87566400e-02f, 9.69085991e-02f, 2.43708417e-02f, -4.32474576e-02f, -8.13980773e-02f,
  7.83369988e-02f, 8.74282718e-02f, 3.70895714e-02f, -3.96817503e-03f, -1.73467733e-02f, -1.18632026e-01f, 1.24376351e-02f, 9.15998034e-03f, -1.84867382e-02f, 2.46491656e-02f,
  -6.42077774e-02f, 2.84139849e-02f, -4.22177985e-02f, 8.86961743e-02f, -3.84270437e-02f, 3.43051739e-02f, 3.64087299e-02f, -6.89915717e-02f, 9.37406253e-03f, -4.63213213e-03f,
  -5.95459575e-03f, 1.09047936e-02f, 8.87050331e-02f, -3.38918045e-02f, 6.39474858e-03f, 4.77564074e-02f, -4.23277989e-02f, -3.47707905e-02f, -1.19137885e-02f, -8.82969517e-03f,
  -1.76666006e-01f, -1.81000113e-01f, -1.07107058e-01f, -3.16999182e-02f, 3.69255841e-02f, -3.89348529e-02f, -1.16545418e-02f, -4.45067026e-02f, -7.90624470e-02f, 1.98772568e-02f,
  -9.88387764e-02f, 3.68312895e-02f, 5.56760887e-03f, -5.39129451e-02f, 1.23565316e-01f, 5.77731244e-02f, -6.01050220e-02f, 5.19786142e-02f, -8.64462629e-02f, -3.24992798e-02f,
  -6.10954016e-02f, 1.78524591e-02f, 9.63626504e-02f, -7.79277608e-02f, -3.67118567e-02f, -6.55736923e-02f, -4.48844396e-02f, 5.94490170e-02f, -6.55950531e-02f, 8.29703510e-02f,
  1.02080666e-01f, -4.21544835e-02f, -2.71668047e-01f, -1.36320844e-01f, 4.83007841e-02f, 8.50865692e-02f, -7.53660798e-02f, 7.59639731e-03f, -1.06388636e-01f, 1.98565111e-01f,
  1.49861366e-01f, 4.98408861e-02f, -4.02566424e-04f, 5.66349141e-02f, -1.39274932e-02f, 3.63089815e-02f, 1.15955949e-01f, 8.34928676e-02f, -6.89252466e-03f, 2.86547188e-02f,
  6.84335902e-02f, 1.81035280e-01f, -8.37761834e-02f, 5.13276234e-02f, 1.54475197e-01f, 4.19882685e-02f, 1.42552912e-01f, 5.18164150e-02f, 1.71817154e-01f, 5.09950472e-03f,
  7.75193945e-02f, -2.06000246e-02f, -1.10043623e-01f, 1.62052028e-02f, -9.98750478e-02f, -5.50473146e-02f, 8.40736330e-02f, -3.14906985e-02f, -2.35551726e-02f, 9.01697055e-02f,
  4.02449109e-02f, -5.81922494e-02f, -7.69931152e-02f, 6.97687715e-02f, -2.15665214e-02f, 2.89198040e-04f, -1.02257825e-01f, 6.36474118e-02f, 4.42364737e-02f, -9.03182700e-02f,
  -1.19537092e-03f, 5.77150360e-02f, 1.42815754e-01f, -1.21305287e-01f, -1.19145796e-01f, 8.68060738e-02f, 3.90963815e-02f, 7.26886094e-02f, 5.51998243e-02f, -9.76907983e-02f,
  1.40950069e-01f, 7.02677369e-02f, 7.18153790e-02f, -5.09550385e-02f, -5.83802387e-02f, -5.30356951e-02f, 2.25454383e-02f, 3.51003441e-03f, -5.80886453e-02f, 5.87256439e-02f,
  -2.15993989e-02f, -9.36728120e-02f, 3.92975546e-02f, 1.13494717e-01f, 5.71639463e-03f, 1.15955606e-01f, 5.08719049e-02f, 4.35456634e-02f, 7.91071355e-03f, 7.06622005e-02f,
  4.95696552e-02f, 3.46415192e-02f, -2.53479667e-02f, 1.29620835e-01f, 4.46366519e-02f, -1.94941815e-02f, 2.02807374e-02f, 1.13014728e-01f, -7.79331028e-02f, -3.83824520e-02f,
  1.20151371e-01f, 7.85806328e-02f, -3.19530033e-02f, -7.56143257e-02f, -1.17219478e-01f, -4.89117652e-02f, -3.21191028e-02f, -6.36307672e-02f, 3.58516909e-02f, -8.70563090e-02f,
  -1.95046570e-02f, 2.07474027e-02f, 1.07712798e-01f, -1.00503548e-03f, 1.54733490e-02f, 3.60519364e-02f, 1.64959822e-02f, 3.73495854e-02f, 7.40390792e-02f, 8.33701435e-03f,
  3.24658900e-02f, -8.97707697e-03f, 5.39044850e-04f, -1.32553905e-01f, -4.71712053e-02f, 3.42204608e-02f, 7.92475492e-02f, -4.55715694e-02f, 7.84883872e-02f, 4.40489687e-02f,
  5.16721904e-02f, 1.36625081e-01f, -2.41281912e-02f, 1.18831277e-01f, 1.12367623e-01f, -5.08767739e-02f, -1.23452462e-01f, 2.30124876e-01f, -1.68088868e-01f, -2.89851092e-02f,
  8.50955993e-02f, -3.13572548e-02f, -6.70557767e-02f, -3.04151233e-02f, -1.01002768e-01f, -1.26988351e-01f, 1.56578436e-01f, -1.77891497e-02f, -4.34893854e-02f, 1.29592225e-01f,
  1.98730212e-02f, 1.35049641e-01f, -3.56065817e-02f, 2.72549242e-01f, -5.33858826e-03f, 2.25868464e-01f, 2.83861399e-01f, 5.03881574e-02f, 3.17330599e-01f, 5.07081579e-03f,
  -6.14315011e-02f, 8.22648183e-02f, 4.25595827e-02f, -9.92540717e-02f, 1.57256961e-01f, -3.87717709e-02f, -4.56181802e-02f, 5.81740178e-02f, 2.47514732e-02f, -6.54431209e-02f,
  9.41542834e-02f, 7.36027136e-02f, -2.37999093e-02f, -6.34400994e-02f, 5.40947653e-02f, -6.19208217e-02f, -8.71448517e-02f, -4.70713861e-02f, -1.22214958e-01f, -3.90894450e-02f,
  -2.17265077e-02f, -2.48541255e-02f, -3.92900333e-02f, 1.16753258e-01f, 1.17726989e-01f, -4.52834032e-02f, 6.31257892e-02f, -3.88533510e-02f, 7.47592002e-02f, 8.63786321e-03f,
  1.01496913e-01f, -4.06114645e-02f, 3.37689742e-02f, -1.17209302e-02f, -2.52134483e-02f, -2.44428925e-02f, -6.40502349e-02f, 5.64729534e-02f, -5.63570112e-02f, -2.64538247e-02f,
  -1.27868010e-02f, 4.68111560e-02f, -9.87319928e-03f, -2.30197478e-02f, 5.11999354e-02f, -5.00032865e-02f, -7.75996549e-03f, -3.22539508e-02f, -9.52700619e-03f, 5.80728659e-03f,
  -3.50838564e-02f, 1.03182584e-01f, 6.70108246e-03f, -5.02539463e-02f, -2.71673966e-02f, 1.54799223e-03f, -1.10650212e-02f, -7.14841783e-02f, -3.26839946e-02f, -5.06584980e-02f,
  3.34002264e-02f, 2.03668028e-01f, -9.59107950e-02f, -2.29865089e-02f, 3.26214395e-02f, 8.19236338e-02f, -9.86972824e-02f, 1.72854029e-02f, 4.45530284e-03f, -9.07251686e-02f,
  6.30677193e-02f, 4.38458137e-02f, -6.12129383e-02f, -7.29256868e-03f, 2.11964156e-02f, 7.90162757e-02f, 3.29398923e-02f, -1.71717014e-02f, -2.36669779e-02f, 1.00085966e-01f,
  1.57223329e-01f, 2.31813658e-02f, -2.06470164e-03f, 4.70866449e-02f, 2.60374956e-02f, 2.18647402e-02f, 9.34654176e-02f, 5.23170792e-02f, 5.98833151e-02f, 2.74071433e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 26)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 26;
const float L0_fan_Bp_bar_data[] = {
  8.50882828e-02f, 1.28305271e-01f, 1.47830680e-01f, 2.08660007e-01f, 2.04271853e-01f, 6.35038093e-02f, 1.30554795e-01f, 1.50799915e-01f, 7.85819292e-02f, 7.16724172e-02f,
  1.02627188e-01f, 2.07443302e-03f, 3.70009653e-02f, 1.80338129e-01f, 1.62863627e-01f, 1.74984127e-01f, 2.45566159e-01f, 1.02931395e-01f, 5.09475358e-02f, 3.18731517e-01f,
  1.14961430e-01f, 1.56190678e-01f, 9.22956020e-02f, 3.54335129e-01f, 6.65064603e-02f, 2.25477532e-01f
};

// L1_fan_Wp (Shape: 19 x 64)
const int L1_fan_Wp_rows = 19;
const int L1_fan_Wp_cols = 64;
const float L1_fan_Wp_data[] = {
  -1.59601327e-02f, -1.42744064e-01f, 1.58261627e-01f, -1.48510784e-01f, 6.51357248e-02f, 1.50950626e-01f, 9.55783948e-03f, -9.77464691e-02f, -1.10786989e-01f, -2.55421754e-02f,
  1.05709054e-01f, -1.59821901e-02f, 4.50476073e-02f, -5.20432442e-02f, -3.34796472e-03f, -1.41138092e-01f, 3.77375670e-02f, -1.17669143e-02f, 1.28595188e-01f, 2.33063281e-01f,
  -1.57601401e-01f, -1.00548722e-01f, -1.45473599e-01f, 2.73457527e-01f, 5.07640652e-02f, 3.43298912e-02f, 1.98178411e-01f, 2.61808604e-01f, -1.81761116e-01f, -1.26050994e-01f,
  1.47909492e-01f, -2.61233784e-02f, 2.15634733e-01f, 2.44949684e-01f, -2.01191440e-01f, -1.46653101e-01f, -7.80224651e-02f, -2.44864151e-01f, -9.31437686e-02f, -7.85185546e-02f,
  1.59975380e-01f, 2.23586753e-01f, 1.12075530e-01f, -6.64666444e-02f, -2.11021945e-01f, 1.57965794e-01f, 2.35991672e-01f, 3.41265321e-01f, -1.97489336e-01f, 1.10482618e-01f,
  5.04874475e-02f, -5.82598075e-02f, -7.33898133e-02f, 1.58050224e-01f, -3.14815968e-01f, -3.81712355e-02f, 2.49259382e-01f, -2.90529013e-01f, 1.63720250e-02f, -9.18141194e-03f,
  -6.97207376e-02f, -1.14967525e-02f, 2.11659893e-01f, -7.88482875e-02f, -2.33459636e-03f, 2.39417106e-02f, -4.52263281e-03f, 1.08178854e-01f, 4.59985398e-02f, 6.21398576e-02f,
  -7.90607631e-02f, 2.05635503e-02f, 1.06450737e-01f, 1.30094618e-01f, 5.28533645e-02f, -7.16616958e-03f, -1.20719656e-01f, -5.29868379e-02f, 4.63410839e-02f, 1.57054830e-02f,
  6.62822574e-02f, 3.60699110e-02f, -3.96198705e-02f, -1.80108085e-01f, -2.77705848e-01f, -1.13411009e-01f, -1.19972512e-01f, 6.28720596e-02f, 2.64208674e-01f, 3.95457670e-02f,
  -1.70077324e-01f, -1.05350721e-03f, 1.74404204e-01f, 1.09878294e-01f, -1.31766602e-01f, 7.47714657e-03f, 1.42085804e-02f, -4.25639842e-03f, 5.69160245e-02f, 1.22081585e-01f,
  -4.14115749e-02f, 8.62940401e-02f, 7.26120472e-02f, 2.20078304e-01f, 3.04506332e-01f, -7.79410899e-02f, 1.45654127e-01f, -9.46244150e-02f, -1.39100462e-01f, -7.60867447e-02f,
  -2.20387653e-01f, 1.34167716e-01f, 2.98403412e-01f, -1.33510858e-01f, -2.74954122e-02f, -8.69840663e-03f, 5.88940158e-02f, -2.38131911e-01f, 1.58614099e-01f, -4.81975041e-02f,
  4.91626598e-02f, 2.17052475e-01f, -2.86938488e-01f, 2.80866295e-01f, 1.53266460e-01f, -9.22222435e-02f, -2.33181387e-01f, 8.46379623e-02f, -1.72102693e-02f, -1.90467626e-01f,
  -1.09452838e-02f, -2.29268745e-01f, -4.04896475e-02f, -7.27551356e-02f, -1.09346263e-01f, -6.74648071e-03f, -1.36747912e-01f, -1.45349771e-01f, -9.68472473e-03f, -1.50672838e-01f,
  5.27850799e-02f, 5.19346334e-02f, 4.78500687e-02f, -1.79087818e-01f, -6.10618740e-02f, 4.08822112e-02f, -8.75880718e-02f, -1.78261712e-01f, 1.26961201e-01f, 2.19491437e-01f,
  -7.23144505e-03f, -6.91104233e-02f, -2.10625213e-02f, -2.43488356e-01f, 3.82165648e-02f, -2.90056355e-02f, -4.67535545e-04f, -1.98864877e-01f, 1.53662771e-01f, 2.20439419e-01f,
  -3.18668075e-02f, 2.74041798e-02f, 9.48399398e-03f, 1.54518306e-01f, -1.63830027e-01f, -1.63620666e-01f, 2.53566634e-02f, -2.22619578e-01f, -5.12046628e-02f, -1.99120000e-01f,
  -1.42879799e-01f, 1.45847589e-01f, 1.66851118e-01f, 1.69969380e-01f, 8.08454528e-02f, 1.27214849e-01f, -5.66141214e-03f, 1.13710864e-02f, -8.45269207e-03f, -1.74286202e-01f,
  -3.46092391e-04f, -2.19210580e-01f, 2.51614213e-01f, 2.10293978e-01f, -9.69815329e-02f, -3.03244531e-01f, 1.63852662e-01f, -9.56723001e-03f, 2.15836450e-01f, 3.30443271e-02f,
  3.78361866e-02f, 1.06797203e-01f, -1.29418541e-02f, 1.99464604e-01f, 5.53716235e-02f, 3.26433867e-01f, -9.78529900e-02f, 1.38372853e-01f, -9.67285931e-02f, 5.52577116e-02f,
  1.58514544e-01f, 1.07531659e-01f, -3.70489359e-02f, 5.07776067e-02f, -6.80792332e-02f, 6.88337609e-02f, -1.66707300e-02f, 2.67415851e-01f, -6.06782222e-03f, -2.39731316e-02f,
  -8.13282058e-02f, -2.96293758e-03f, 4.81473878e-02f, -1.15573466e-01f, -5.45524321e-02f, -6.97375834e-02f, 6.59335256e-02f, 2.42620692e-01f, -6.55572042e-02f, -2.83101350e-02f,
  8.35124925e-02f, 1.20154329e-01f, -1.67101756e-01f, -2.07405448e-01f, 8.88191443e-03f, -2.07689226e-01f, -1.62783220e-01f, 1.70837373e-01f, -6.19590767e-02f, 2.03194737e-01f,
  3.66059691e-02f, 8.05449784e-02f, 1.09272063e-01f, -2.18973383e-01f, 1.19787477e-01f, 2.17670128e-01f, 2.00361460e-01f, -8.48969668e-02f, -2.02053800e-01f, -1.69096798e-01f,
  4.62659784e-02f, -5.21455484e-04f, 2.70900160e-01f, 2.24768102e-01f, 2.33458698e-01f, 2.73198903e-01f, -2.36689057e-02f, -2.03434229e-01f, -6.84134737e-02f, 2.39212617e-01f,
  8.03620741e-02f, 1.73764527e-01f, -8.92217681e-02f, -2.47480065e-01f, -1.09164007e-01f, -3.12397350e-02f, 8.64806175e-02f, -2.33296137e-02f, 6.53080270e-02f, -2.57782817e-01f,
  -1.75194982e-02f, -3.51250991e-02f, -9.41547155e-02f, 6.70337453e-02f, -1.61553189e-01f, -7.20302984e-02f, -6.35109395e-02f, -1.94330692e-01f, 3.89386453e-02f, 7.82261714e-02f,
  -3.72520573e-02f, -4.41912487e-02f, -1.12463934e-02f, 1.22696377e-01f, -9.07184184e-02f, -5.28517589e-02f, -2.99570076e-02f, -1.87379364e-02f, 9.79273021e-02f, 7.55438255e-03f,
  -1.24196626e-01f, 1.96515486e-01f, 2.27686558e-02f, -2.60101765e-01f, 2.07898114e-02f, 3.00130658e-02f, 2.98120141e-01f, 3.35199237e-02f, 5.46279028e-02f, 1.22473657e-01f,
  -8.39768946e-02f, -2.19111830e-01f, -7.48148263e-02f, -1.07163891e-01f, -1.13074921e-01f, -4.26575262e-03f, 6.86419457e-02f, 8.78443271e-02f, 1.45867631e-01f, -1.25893876e-01f,
  -4.55991812e-02f, 3.82244308e-03f, 1.11916341e-01f, 1.52069256e-01f, 1.07470021e-01f, -7.48482719e-02f, -2.46028349e-01f, -6.75825626e-02f, -2.06781939e-01f, 1.72836944e-01f,
  -7.91275799e-02f, 2.50832617e-01f, -1.64989308e-01f, 3.84518839e-02f, 2.60636181e-01f, 6.20387867e-02f, 2.13784710e-01f, 1.15714274e-01f, 2.09716484e-01f, -1.21969748e-02f,
  3.06786373e-02f, 1.38047978e-01f, 1.18311994e-01f, 6.09014556e-02f, 2.07701959e-02f, 3.92027292e-03f, 6.54959977e-02f, -7.15030730e-02f, -7.97775947e-03f, -1.09792747e-01f,
  -4.47734185e-02f, 5.33803105e-02f, -6.15256168e-02f, 1.28797982e-02f, 2.74049147e-04f, 1.87476575e-01f, 4.56826901e-03f, -3.20994556e-02f, -9.88932177e-02f, -1.54524997e-01f,
  -1.10290991e-02f, 1.77854791e-01f, -2.02449933e-02f, 3.80077772e-02f, -8.06796998e-02f, 4.71956059e-02f, 1.26198560e-01f, -1.12040989e-01f, 1.44028857e-01f, -3.10990978e-02f,
  -1.96996495e-01f, 2.45157138e-01f, -2.12784022e-01f, -5.04485108e-02f, -1.11226134e-01f, 9.70565900e-02f, -2.63124317e-01f, 5.40321097e-02f, 7.92063922e-02f, 5.05579188e-02f,
  9.63090658e-02f, 2.32957881e-02f, -1.56200528e-01f, 9.17057544e-02f, 4.47706953e-02f, 2.43802723e-02f, 6.13243645e-03f, -1.38568297e-01f, 1.86423033e-01f, -1.10818304e-01f,
  -2.72620976e-01f, 1.94512587e-02f, 1.62297934e-01f, -9.97101236e-03f, 9.52121392e-02f, 8.36997554e-02f, 7.63767362e-02f, 1.65643990e-01f, -1.01061620e-01f, 1.76849905e-02f,
  5.98772503e-02f, -1.75944850e-01f, -9.59443823e-02f, 5.37290424e-02f, 8.20060149e-02f, 3.34055722e-02f, -2.64360067e-02f, -9.33239311e-02f, -1.53585318e-02f, -1.23662956e-01f,
  -1.21423379e-01f, -7.47020915e-02f, -1.06614903e-02f, -1.51325345e-01f, 3.44999507e-02f, -2.29782790e-01f, 8.39771107e-02f, 1.11092530e-01f, -2.04495993e-03f, 2.92195212e-02f,
  -6.49193525e-02f, -1.62794087e-02f, -1.20189928e-01f, -1.35567933e-01f, -1.33581469e-02f, 9.21095833e-02f, 3.95475328e-02f, -2.39987951e-02f, 3.48479599e-02f, -2.05203533e-01f,
  -2.14168519e-01f, -2.47265637e-01f, 4.16582190e-02f, -5.51858060e-02f, -7.94961601e-02f, 2.89443284e-01f, -1.37021378e-01f, -6.47651032e-02f, 1.23137280e-01f, 1.14421353e-01f,
  1.24235637e-01f, -1.77782238e-01f, 1.08850606e-01f, 6.75955862e-02f, -1.37476012e-01f, -2.17748150e-01f, -3.35184261e-02f, -5.43941520e-02f, 1.79782793e-01f, 9.56554897e-03f,
  -1.15757078e-01f, -2.01980993e-01f, 2.29137748e-01f, -1.08232230e-01f, -9.67794191e-03f, -2.08488375e-01f, -1.29740417e-01f, -1.46104813e-01f, 1.46686092e-01f, 5.17109893e-02f,
  -1.99331772e-02f, -2.19901130e-01f, 8.40805992e-02f, -4.58736494e-02f, 2.30533302e-01f, 4.73025218e-02f, -5.68646528e-02f, 5.22608422e-02f, 4.27486934e-03f, 1.66194871e-01f,
  7.65405893e-02f, -7.26811439e-02f, 1.09135553e-01f, -7.33064190e-02f, 2.55909190e-02f, -1.84640996e-02f, -2.46999916e-02f, 5.89365438e-02f, -9.44236964e-02f, -2.02179304e-04f,
  1.93591062e-02f, -2.78169066e-02f, -3.93786468e-02f, 6.70147836e-02f, 1.41626239e-01f, 1.11495279e-01f, 1.07951075e-01f, -1.45595193e-01f, 4.93457466e-02f, 6.03466146e-02f,
  4.51610722e-02f, -2.42026269e-01f, 2.20059618e-01f, -3.49411517e-01f, -5.15755676e-02f, -1.04496464e-01f, 3.88870612e-02f, -1.62710294e-01f, -2.80314654e-01f, 2.81833559e-01f,
  5.44643924e-02f, 5.53570129e-03f, 6.76318770e-03f, -1.39317727e-02f, -2.91107092e-02f, 2.92276829e-01f, 2.48713687e-01f, 1.49589404e-01f, -1.13772742e-01f, 1.36786491e-01f,
  -9.69100818e-02f, -1.82113960e-01f, -2.09394976e-01f, 1.66694671e-01f, -2.54281107e-02f, -7.52893835e-02f, 5.22126332e-02f, 7.35384971e-02f, -7.59593472e-02f, 9.55630466e-02f,
  1.83551192e-01f, -1.75170064e-01f, 1.68387249e-01f, 1.28403697e-02f, 1.47081748e-01f, 1.86896417e-02f, -2.82078922e-01f, 1.03066945e-02f, 4.23459299e-02f, 1.74322173e-01f,
  -1.06760286e-01f, -1.29096895e-01f, -1.78310368e-02f, -1.91746324e-01f, -9.06716064e-02f, -5.54443263e-02f, 1.09897181e-01f, 4.66773212e-02f, -3.14973085e-03f, -7.94385895e-02f,
  2.30121426e-02f, -6.66732118e-02f, 1.18597686e-01f, 1.32330537e-01f, 7.92809799e-02f, -1.17003769e-01f, -3.66566665e-02f, -1.91428408e-01f, -1.51104555e-01f, 9.22021419e-02f,
  1.45973966e-01f, 8.64591300e-02f, -1.96005762e-01f, -1.45612940e-01f, -1.65037569e-02f, 3.21246296e-01f, -1.73470989e-01f, 2.92749703e-01f, 1.29709542e-01f, -5.97062558e-02f,
  -2.55263299e-01f, 3.77614386e-02f, 1.39141589e-01f, -1.54297709e-01f, 1.24279842e-01f, 1.18084148e-01f, -3.91108803e-02f, -1.13029934e-01f, -1.38498386e-02f, -1.75927758e-01f,
  -1.93806916e-01f, -2.31950089e-01f, 1.06926300e-01f, -2.87568681e-02f, 1.48681641e-01f, 2.87242960e-02f, 1.25661209e-01f, 1.50845656e-02f, 2.01397702e-01f, 5.75515218e-02f,
  -1.61324009e-01f, -1.32257551e-01f, -5.95071688e-02f, 3.04026678e-02f, -2.79338539e-01f, 1.42830372e-01f, -1.95826590e-01f, 8.56449455e-02f, -1.30010545e-01f, -1.73842356e-01f,
  1.55447796e-01f, -2.42093410e-02f, 1.62920520e-01f, -1.50278941e-01f, 1.88089520e-01f, 1.22753955e-01f, 3.91322933e-02f, 4.56674173e-02f, 7.91487545e-02f, -8.69060382e-02f,
  -1.47113809e-02f, -9.82419476e-02f, -7.99416825e-02f, 1.11116432e-01f, -7.65348673e-02f, 1.00431256e-01f, -9.44185331e-02f, -7.43976608e-02f, -5.56002930e-03f, 3.88988592e-02f,
  4.01551537e-02f, 8.91976804e-02f, 7.65663162e-02f, -2.34928876e-02f, 1.08173594e-01f, 7.18125179e-02f, -2.18945488e-01f, 5.30927889e-02f, 1.14757404e-01f, 2.16543451e-01f,
  2.68697649e-01f, 1.92724943e-01f, -2.15162456e-01f, 7.45748505e-02f, 1.28669381e-01f, 3.61240916e-02f, -2.00251251e-01f, -3.44440453e-02f, 1.29345894e-01f, 3.23188305e-02f,
  9.80863497e-02f, -5.60541451e-02f, 1.02879755e-01f, 1.05306938e-01f, 1.74982354e-01f, 1.91218644e-01f, 1.53068066e-01f, 8.43938515e-02f, 3.57762687e-02f, -2.16393486e-01f,
  -6.19815364e-02f, 8.87899920e-02f, -1.38005599e-01f, -6.47488162e-02f, 1.65387720e-01f, -2.17042677e-02f, 1.28303155e-01f, 7.95423016e-02f, 1.33124322e-01f, 1.02079570e-01f,
  -3.38818617e-02f, -1.96820989e-01f, -1.26057416e-01f, 1.72930300e-01f, -2.50955403e-01f, 1.33002341e-01f, -2.37229541e-01f, -3.37653756e-01f, -2.01650951e-02f, 6.04150780e-02f,
  -1.11640051e-01f, 5.30481972e-02f, -1.52169183e-01f, -4.43425924e-02f, -1.38630524e-01f, -1.35658979e-01f, 1.70733575e-02f, -1.46328136e-01f, 5.96306920e-02f, 7.18821436e-02f,
  -1.43503800e-01f, 1.01254977e-01f, -1.85388818e-01f, 6.71517327e-02f, -3.99633273e-02f, -4.53307852e-02f, 2.79685073e-02f, 6.92800358e-02f, 1.14522614e-01f, 1.90870702e-01f,
  -1.11407302e-01f, -1.35908097e-01f, -1.22643332e-03f, 1.46373957e-01f, 4.19952534e-03f, 2.78943479e-01f, -2.16111481e-01f, 1.77913994e-01f, -1.55876204e-03f, 2.06716686e-01f,
  -2.02799737e-01f, -6.12244457e-02f, -3.15414779e-02f, 7.09807426e-02f, 2.20776930e-01f, 9.64630395e-02f, 1.97214961e-01f, 1.48841590e-01f, 2.05145985e-01f, 1.28681913e-01f,
  1.57365575e-01f, -9.54667181e-02f, 1.87038705e-02f, -5.53122498e-02f, -1.88289925e-01f, -1.33617297e-01f, -1.74512848e-01f, -9.97475460e-02f, 1.81279108e-01f, -1.30437259e-02f,
  1.76634982e-01f, 2.00166125e-02f, 2.51281947e-01f, 4.50522564e-02f, -1.22870483e-01f, -1.70282021e-01f, -1.79231968e-02f, 1.57689318e-01f, -1.95385844e-01f, -7.18587637e-02f,
  -1.31668285e-01f, -2.93922335e-01f, -3.87015380e-02f, -1.97992120e-02f, -1.76615536e-01f, -1.56752914e-01f, -5.72833493e-02f, -2.04166044e-02f, -2.92132162e-02f, 8.46374780e-02f,
  8.25325400e-03f, 2.50243004e-02f, -9.96627063e-02f, 4.41473536e-02f, -4.77053821e-02f, -1.01373516e-01f, 1.11643083e-01f, -1.24546982e-01f, -1.04055787e-02f, -3.32954139e-01f,
  -1.47435397e-01f, 8.56798664e-02f, -6.80380389e-02f, 1.51376009e-01f, -1.42639652e-01f, -3.16461250e-02f, 5.88887744e-02f, 2.06760302e-01f, -1.44741565e-01f, 3.10097579e-02f,
  8.54346436e-03f, 1.01199917e-01f, -3.04387003e-01f, 7.58671016e-03f, 2.41218328e-01f, -1.18442565e-01f, 6.16032742e-02f, 1.58798009e-01f, -5.57756983e-02f, -1.46842524e-01f,
  -5.19970581e-02f, -2.01965235e-02f, -1.40172318e-01f, -2.22904786e-01f, 7.61070997e-02f, 1.19316436e-01f, 2.00949743e-01f, 1.40457988e-01f, -2.02473089e-01f, 4.94644158e-02f,
  7.05562904e-02f, 1.45697832e-01f, -7.03828931e-02f, -1.00795865e-01f, -6.63285926e-02f, 1.00871250e-01f, -1.25559464e-01f, 1.56398669e-01f, -2.36123040e-01f, 6.41318113e-02f,
  -1.07363880e-01f, -1.83511853e-01f, 2.95747280e-01f, 8.34383816e-02f, -5.39927483e-02f, -1.28542492e-02f, 7.20415190e-02f, -1.50061637e-01f, 1.79426908e-01f, 4.28736396e-02f,
  -1.23878404e-01f, -1.05520725e-01f, -4.95612845e-02f, 2.38506690e-01f, 4.03579697e-02f, -9.89046767e-02f, -5.89934886e-02f, -2.25757658e-02f, -1.18019626e-01f, 3.35482694e-02f,
  -4.02224883e-02f, -8.14610124e-02f, -3.21641602e-02f, -1.07798398e-01f, 4.83933687e-02f, 3.40133649e-03f, -1.04429260e-01f, -1.86107099e-01f, -1.06837682e-01f, -1.06274605e-01f,
  -6.44848943e-02f, 6.96141412e-03f, 2.43222520e-01f, -2.43101552e-01f, 6.07158896e-03f, -4.93383631e-02f, 1.19025081e-01f, -8.17758590e-02f, 8.95273238e-02f, -1.51986122e-01f,
  2.08225604e-02f, -3.09239794e-02f, 1.15356773e-01f, -1.21600693e-03f, -5.81635647e-02f, 2.39203140e-01f, 4.19809073e-02f, 5.18121803e-03f, 1.18688077e-01f, -4.99127135e-02f,
  -1.14624701e-01f, 4.15991917e-02f, -1.42718166e-01f, 1.22954652e-01f, -1.68618262e-01f, 6.77980185e-02f, 1.16890697e-02f, 2.74864472e-02f, 1.46333743e-02f, 5.42722493e-02f,
  1.03604734e-01f, -3.23133409e-01f, 7.50395507e-02f, 1.49081692e-01f, 1.41280785e-01f, 2.19242111e-01f, -2.89488256e-01f, 3.32726419e-01f, 4.10519652e-02f, 1.05863415e-01f,
  -8.40842575e-02f, -3.53833884e-02f, 8.50468874e-02f, 2.50884771e-01f, 1.07091382e-01f, 1.92620024e-01f, 1.53704509e-01f, 2.04764977e-02f, 1.68570563e-01f, -4.64522503e-02f,
  8.73747319e-02f, 1.19739922e-03f, 6.99283108e-02f, 2.45676115e-01f, -7.22885951e-02f, -3.92915979e-02f, -2.68417574e-03f, -4.06353399e-02f, 6.84289485e-02f, -2.11796854e-02f,
  1.21105708e-01f, 1.54999375e-01f, 1.98147640e-01f, 4.64392789e-02f, -1.62565619e-01f, -1.89717725e-01f, 6.07978553e-03f, -1.04927078e-01f, -6.94936365e-02f, 1.92923069e-01f,
  6.05958477e-02f, 1.67082831e-01f, -1.43994451e-01f, 5.71369417e-02f, 5.19363396e-02f, 4.27203020e-03f, -1.38056472e-01f, 1.34065941e-01f, 4.19973135e-02f, 1.55179977e-01f,
  1.68829903e-01f, 1.64968356e-01f, -1.08339697e-01f, 8.60298574e-02f, -7.11538345e-02f, -4.49388437e-02f, 8.10908601e-02f, -1.31732002e-01f, -1.04304150e-01f, 1.29258279e-02f,
  -7.72387162e-02f, 1.99439272e-01f, 5.32531813e-02f, 8.27998072e-02f, 3.18687946e-01f, 1.22245699e-01f, -1.27825037e-01f, -2.60450214e-01f, 2.19386414e-01f, 2.20536385e-02f,
  -7.52105638e-02f, 4.73641194e-02f, -3.60372066e-01f, -1.08660005e-01f, -2.21676067e-01f, -1.18851110e-01f, -7.25387111e-02f, -1.21308342e-01f, 7.31829330e-02f, 1.08650662e-01f,
  -5.90072758e-02f, -1.61000028e-01f, 2.51646191e-02f, 5.19662425e-02f, -1.17984846e-01f, -6.87744617e-02f, -9.68204753e-04f, -2.24484205e-01f, -5.27061969e-02f, 1.06725283e-01f,
  8.15946758e-02f, 1.10253140e-01f, -8.82468894e-02f, 1.11446239e-01f, 3.62987295e-02f, -7.51445368e-02f, 9.10817087e-02f, 2.64540792e-01f, 1.94129139e-01f, 1.38666168e-01f,
  -5.46781905e-02f, 1.98337719e-01f, -1.50435448e-01f, -1.66233480e-01f, 8.73595774e-02f, -2.20617801e-01f, 8.51073489e-02f, 5.11818007e-02f, -1.04355505e-02f, 4.60317582e-02f,
  7.46177062e-02f, 7.39600137e-02f, 1.01605050e-01f, -2.72055924e-01f, 1.98653549e-01f, -3.56212910e-03f, 6.03197701e-03f, 2.46039312e-02f, -1.66982301e-02f, -1.24666803e-01f,
  7.96202868e-02f, 9.12482962e-02f, 9.11888555e-02f, -2.39818648e-01f, 2.38138884e-01f, -1.43303365e-01f, -7.03032985e-02f, -3.71394753e-02f, -1.57507360e-01f, 7.77324662e-02f,
  3.27199176e-02f, 1.19361309e-02f, -1.74694255e-01f, -3.20401676e-02f, 7.07466453e-02f, -2.89098918e-01f, 1.23086654e-01f, -8.69311839e-02f, 6.72636032e-02f, 2.44565755e-01f,
  8.99032503e-02f, -1.62951320e-01f, 1.16355702e-01f, 3.44474874e-02f, 2.88300235e-02f, -9.64188576e-02f, 3.06726620e-02f, -1.45219266e-01f, -7.47619048e-02f, 1.20331652e-01f,
  -1.29531464e-02f, 4.32458557e-02f, 7.95514807e-02f, 4.66021970e-02f, -3.95614393e-02f, -2.28349164e-01f, -4.98566516e-02f, 1.64541006e-01f, -3.73216309e-02f, 1.31945729e-01f,
  -8.93359631e-02f, -1.40864298e-01f, -5.35896011e-02f, 9.24929529e-02f, 7.65840709e-02f, 4.12355214e-02f, 1.05828650e-01f, 2.39447996e-01f, -2.36046270e-01f, -1.58419833e-01f,
  3.76553535e-02f, -1.18132234e-01f, 9.12626758e-02f, 2.02952430e-01f, -1.53024986e-01f, -1.20314069e-01f, 6.08696751e-02f, -1.39749125e-01f, 1.68917656e-01f, 2.17672944e-01f,
  1.70742258e-01f, 7.28002340e-02f, 1.31934032e-01f, -7.91414604e-02f, -2.78888047e-01f, 1.48780197e-01f, 1.33490726e-01f, 9.47409719e-02f, 3.10445786e-01f, -6.89052716e-02f,
  2.21991912e-01f, -5.75417615e-02f, -4.87419926e-02f, -3.85561353e-03f, -3.15393448e-01f, -2.71588732e-02f, 2.21953169e-01f, -2.46699423e-01f, -1.96054161e-01f, -1.60364702e-01f,
  7.00089633e-02f, -9.79056656e-02f, 5.92054278e-02f, 1.73523799e-01f, 1.35147840e-01f, -4.88895923e-02f, -8.40563327e-02f, -8.85420740e-02f, 4.80663963e-02f, -4.90101688e-02f,
  -7.56194293e-02f, 1.28596604e-01f, 8.97600409e-03f, 7.83051550e-02f, -9.51801091e-02f, -4.60697338e-02f, 8.21275190e-02f, 1.55910060e-01f, 1.17183059e-01f, 8.39545503e-02f,
  2.94298548e-02f, 1.27054438e-01f, 1.68539524e-01f, 5.33470325e-02f, -2.12970197e-01f, -1.41364604e-01f, 4.50602323e-02f, -2.44551972e-02f, 8.30104575e-02f, 1.16660766e-01f,
  -8.75405371e-02f, -1.44192174e-01f, 1.22081980e-01f, 2.54797786e-01f, 8.57633771e-04f, -2.07085297e-01f, 2.39292264e-01f, -2.99001019e-02f, 2.21012264e-01f, -8.67197961e-02f,
  9.44162160e-02f, -4.88377437e-02f, 9.64671075e-02f, -1.32092267e-01f, 1.93959609e-01f, -7.67017826e-02f, 3.06140065e-01f, -1.68730646e-01f, -1.43678710e-01f, -7.06718564e-02f,
  -2.64784068e-01f, 1.37071982e-01f, 7.59997219e-02f, -1.32975057e-01f, 1.09828196e-01f, -7.06702378e-03f, -1.50283232e-01f, -3.90828289e-02f, 3.25601727e-01f, -1.31155774e-01f,
  -1.33408055e-01f, 8.69756415e-02f, 5.59074692e-02f, 2.64547288e-01f, 8.32277834e-02f, 2.19189644e-01f, -8.66744593e-02f, 1.04909800e-01f, 7.08632125e-03f, -2.97447070e-02f,
  6.12802356e-02f, -1.31198794e-01f, -1.74685046e-02f, -6.25145882e-02f, -9.36203003e-02f, 1.52001768e-01f, 1.76103532e-01f, -5.70080504e-02f, 5.83041981e-02f, 8.16880018e-02f,
  -1.45421878e-01f, -4.23741527e-02f, -7.08231926e-02f, -8.68071616e-02f, -7.10214898e-02f, -5.39513715e-02f, 1.61633104e-01f, 6.54073134e-02f, -1.54227227e-01f, -2.64743924e-01f,
  2.39561312e-02f, -6.42287657e-02f, -7.26599246e-02f, 8.22120234e-02f, -3.22407186e-02f, 6.82071317e-03f, 3.89329866e-02f, 1.22580275e-01f, -1.59393251e-01f, -2.45688155e-01f,
  1.30299926e-01f, 7.16283917e-02f, 7.51080811e-02f, -2.58924991e-01f, 1.11538924e-01f, 8.69937912e-02f, -7.36145675e-02f, -1.31862620e-02f, 6.86546341e-02f, 3.05123627e-02f,
  2.56837279e-01f, -2.35930949e-01f, -8.86727031e-03f, -1.15128383e-01f, 1.58934519e-02f, 1.07423633e-01f, -1.18485183e-01f, -1.96071956e-02f, 5.91305085e-03f, 1.58664405e-01f,
  -3.18690501e-02f, 8.75817016e-02f, 2.41284937e-01f, -2.18408033e-01f, -4.05458361e-02f, 7.48983622e-02f, 6.23143613e-02f, 2.15430319e-01f, -2.41836667e-01f, 1.02589324e-01f,
  4.08252515e-02f, -1.67346984e-01f, 8.56783837e-02f, -3.73675674e-02f, -5.81820942e-02f, -1.45676851e-01f, 1.89581439e-02f, 1.55621758e-02f, -8.25002044e-03f, -1.52039334e-01f,
  -1.53465927e-01f, 5.80580942e-02f, 3.88795286e-02f, 5.03238887e-02f, 7.56101310e-02f, -2.30090898e-02f, -3.10007669e-02f, -2.11396113e-01f, -1.58678621e-01f, -4.87597920e-02f,
  -4.67244573e-02f, -1.19437069e-01f, -7.44688064e-02f, 5.36115654e-03f, -1.63030654e-01f, -7.59473816e-02f, -1.17974192e-01f, -4.81551066e-02f, 3.09137851e-01f, 1.87025368e-01f,
  -1.07302792e-01f, -2.48077959e-01f, 1.57526694e-02f, 9.94382426e-02f, -1.45847738e-01f, 2.80312747e-02f, -2.44672194e-01f, 5.65293729e-02f, -3.69426310e-01f, 2.08860144e-01f,
  -2.97209263e-01f, -3.21869776e-02f, -1.79671124e-01f, 6.88157603e-02f, -5.73152676e-02f, 2.64555246e-01f, 9.42832902e-02f, 1.69917010e-02f, 2.62698263e-01f, 1.46538001e-02f,
  -3.14034790e-01f, 1.05709426e-01f, -3.55853051e-01f, -1.56333849e-01f, 2.01026276e-01f, -1.04903132e-01f, -8.96898210e-02f, 1.48403615e-01f, 2.38573421e-02f, -2.78558657e-02f,
  -1.49008170e-01f, 4.22921367e-02f, 1.19062565e-01f, -2.19021976e-01f, -4.33666594e-02f, -2.27439795e-02f
};

// L1_fan_Wp_bar (Shape: 26 x 64)
const int L1_fan_Wp_bar_rows = 26;
const int L1_fan_Wp_bar_cols = 64;
const float L1_fan_Wp_bar_data[] = {
  1.98421180e-01f, 2.11586177e-01f, 2.30757490e-01f, 1.51528165e-01f, 1.33732125e-01f, 1.19380012e-01f, 1.00324281e-01f, 8.02819207e-02f, -1.72242634e-02f, 1.58247665e-01f,
  1.63644746e-01f, 9.28633064e-02f, 8.49579927e-03f, -2.84230877e-02f, 6.07671104e-02f, -7.19419867e-02f, 8.75437036e-02f, 2.35558838e-01f, 2.48775899e-01f, 1.97227433e-01f,
  1.35023203e-02f, -2.57648915e-01f, -2.15452649e-02f, -3.26985233e-02f, 2.20758781e-01f, -1.96520820e-01f, -2.33391747e-02f, 1.81391224e-01f, -2.20109478e-01f, 3.01565882e-02f,
  1.54069439e-01f, 2.24200189e-02f, 2.13114515e-01f, -3.63936350e-02f, -1.93036944e-01f, -1.68162331e-01f, 8.46040994e-02f, 3.48691829e-02f, 2.16286823e-01f, 1.80850804e-01f,
  2.08693758e-01f, 2.72439659e-01f, 1.00286841e-01f, 7.24510923e-02f, -2.07040414e-01f, 2.96419393e-02f, 5.23860343e-02f, 1.14665732e-01f, 1.97248191e-01f, 9.69121680e-02f,
  1.99600860e-01f, 2.36683533e-01f, 1.29661992e-01f, 9.33904871e-02f, -9.54808593e-02f, -9.84084532e-02f, 3.21170628e-01f, 1.54465094e-01f, 3.59293334e-02f, 2.28534862e-01f,
  -8.11062977e-02f, 1.79837286e-01f, 2.52436940e-02f, -1.05683759e-01f, 2.11093366e-01f, 1.59741879e-01f, 1.73590094e-01f, 4.40864302e-02f, 1.96620524e-02f, 1.85888395e-01f,
  2.56482780e-01f, 9.50805098e-02f, -5.77609660e-03f, 4.26521897e-02f, -8.36056620e-02f, 1.70143500e-01f, 2.17673898e-01f, 1.95389599e-01f, -1.72050204e-02f, -1.02007743e-02f,
  5.02030104e-02f, 1.50659040e-01f, -3.35906409e-02f, 3.48107591e-02f, 9.10945144e-03f, -2.36141339e-01f, -1.42666131e-01f, -1.15824319e-01f, 2.22774938e-01f, -3.67630005e-01f,
  -2.79240357e-03f, -1.67976871e-01f, -8.55235979e-02f, 2.62727052e-01f, 9.40878876e-04f, -1.15416288e-01f, 1.61117941e-01f, -2.26274580e-01f, -6.55612629e-03f, -2.55403817e-01f,
  -1.96108390e-02f, 1.04431249e-01f, -9.66037884e-02f, -2.22683903e-02f, 5.03980853e-02f, 7.57429078e-02f, -1.91493541e-01f, 2.18419675e-02f, -1.47200078e-01f, -1.01138487e-01f,
  -3.19585688e-02f, 7.21424669e-02f, 7.32501149e-02f, 1.14154510e-01f, 6.63991552e-04f, 4.12516356e-01f, 1.32142633e-01f, -1.85256913e-01f, 2.56793529e-01f, 2.71697761e-03f,
  1.26506284e-01f, 2.95310289e-01f, -8.73760656e-02f, 4.42442328e-01f, -3.95947248e-02f, 3.83297443e-01f, -1.49034902e-01f, -1.63795978e-01f, 1.78022280e-01f, 5.95682934e-02f,
  1.94976509e-01f, -1.13093436e-01f, 1.52614966e-01f, 9.96359438e-02f, 2.97126949e-01f, 4.23153266e-02f, 2.37953454e-01f, 2.71574467e-01f, 1.83576554e-01f, 2.53985465e-01f,
  2.43664846e-01f, 4.65940535e-02f, 2.00877950e-01f, -1.60872594e-01f, 2.25652643e-02f, 8.49026442e-02f, 2.76670069e-01f, 2.14796066e-01f, 1.40479906e-02f, 3.49819399e-02f,
  1.48541749e-01f, -6.66064918e-02f, 1.53605849e-03f, -2.25177050e-01f, -1.53433278e-01f, 1.18824594e-01f, -3.20065141e-01f, 1.12177633e-01f, -1.87412992e-01f, -2.21798047e-02f,
  1.30171970e-01f, 2.00057566e-01f, 2.39847630e-01f, -1.29805684e-01f, 1.21468298e-01f, -8.43054652e-02f, 1.68659374e-01f, 2.76210219e-01f, 3.15903723e-01f, 3.46470147e-01f,
  1.76831067e-01f, -3.29544060e-02f, -1.54881448e-01f, 7.11025670e-02f, 1.35821626e-01f, 2.42509559e-01f, -1.03374375e-02f, -1.96270607e-02f, -4.34075715e-03f, 3.30325335e-01f,
  -8.15846026e-02f, 6.33924305e-02f, 2.94698864e-01f, 2.42413506e-02f, -6.49717078e-02f, 2.02790555e-02f, 2.19112728e-02f, 2.08073884e-01f, -7.27790669e-02f, 1.62715882e-01f,
  2.18022093e-01f, -1.19900309e-01f, 6.05908483e-02f, -2.01630630e-02f, 9.79186296e-02f, -5.92960529e-02f, 6.14650436e-02f, 2.21354797e-01f, 8.45948681e-02f, -3.71944159e-02f,
  1.91401213e-01f, 5.84702082e-02f, 2.64252514e-01f, 1.07000552e-01f, 1.49828658e-01f, 1.46471202e-01f, 4.51104790e-02f, -2.16230825e-01f, -3.04379570e-03f, 8.29079226e-02f,
  -1.18803401e-02f, -9.95149091e-02f, -1.94872729e-02f, 1.75541714e-01f, -1.04199223e-01f, 5.69554456e-02f, -2.88926899e-01f, -5.00826947e-02f, 3.40308875e-01f, 2.32864067e-01f,
  -1.42774358e-01f, -7.65013620e-02f, -1.51639476e-01f, 9.11280885e-02f, -1.71400830e-01f, 1.55558102e-02f, -1.92621216e-01f, 9.78901610e-02f, -1.86341271e-01f, -5.25873415e-02f,
  -3.33310008e-01f, -1.36000276e-01f, 1.50015399e-01f, -4.14458998e-02f, 2.56532282e-01f, 2.58189887e-01f, 3.30620140e-01f, 8.34896639e-02f, 3.45576823e-01f, 1.50651738e-01f,
  -1.95077643e-01f, 1.89632893e-01f, -1.58240274e-01f, -1.17255650e-01f, 3.03400513e-02f, 9.34950337e-02f, 6.20431313e-03f, 1.76171482e-01f, 1.87238932e-01f, 3.84578370e-02f,
  1.84807748e-01f, 8.36796314e-02f, 7.60603622e-02f, 3.27080227e-02f, 2.67325163e-01f, 1.04793876e-01f, 2.00648978e-02f, -2.22344440e-03f, 3.61836678e-03f, 6.68450594e-02f,
  -1.85690135e-01f, -1.74455717e-01f, 1.85461506e-01f, 2.20025271e-01f, 6.10387139e-02f, 6.19031936e-02f, 1.13303967e-01f, 4.70629297e-02f, 7.63383508e-02f, 1.21287696e-01f,
  2.45639160e-02f, 1.44447103e-01f, 6.12544529e-02f, -1.06896043e-01f, 7.00257272e-02f, 6.90739527e-02f, 1.22309782e-01f, 1.28174886e-01f, 1.24264471e-01f, -1.52833164e-01f,
  -2.03352407e-01f, -4.60839644e-02f, -6.09547943e-02f, -1.41068622e-01f, 1.29497692e-01f, 1.30899087e-01f, -2.13001147e-01f, 1.43049955e-01f, 4.30682041e-02f, -8.27746391e-02f,
  2.76513368e-01f, -4.18363698e-02f, 1.57318130e-01f, -6.42929226e-02f, -1.08569011e-01f, -1.49714395e-01f, -1.22536153e-01f, -4.43344302e-02f, 4.77047591e-03f, -2.40668893e-01f,
  -1.72435433e-01f, -3.90240625e-02f, -9.79126990e-02f, -1.71350524e-01f, -1.29602209e-01f, -1.97554484e-01f, 2.73006107e-03f, 3.82465199e-02f, -2.30328411e-01f, -1.58404768e-01f,
  3.20622146e-01f, -2.72200942e-01f, 7.54704606e-03f, -1.50123835e-01f, 4.05523703e-02f, 1.37420952e-01f, 3.70487161e-02f, 2.79738396e-01f, -1.16735891e-01f, -8.21139291e-02f,
  2.40763247e-01f, 1.21582069e-01f, 1.70440271e-01f, 1.30454078e-01f, 2.04513222e-01f, 2.13977352e-01f, -5.48171960e-02f, 1.82375148e-01f, -2.80798711e-02f, 7.99559206e-02f,
  1.07789554e-01f, -3.28462236e-02f, 2.11899489e-01f, 1.31117642e-01f, 1.14505529e-01f, 7.66517743e-02f, 9.02670261e-04f, 1.33801252e-01f, 1.66365981e-01f, -8.93274322e-02f,
  -2.15688556e-01f, 1.75176710e-01f, 1.15473881e-01f, 2.39862159e-01f, 2.09876522e-01f, 9.00761411e-02f, 6.72093630e-02f, -7.05753593e-03f, 1.54595464e-01f, -1.81005403e-01f,
  1.98151886e-01f, 4.88367211e-03f, -6.63319454e-02f, 1.46227861e-02f, -2.46360928e-01f, 1.60407335e-01f, -1.39981553e-01f, -1.80500194e-01f, 1.77371934e-01f, 2.17739433e-01f,
  5.65907620e-02f, 1.32614495e-02f, 8.89420584e-02f, 3.41335565e-01f, 2.74372876e-01f, 2.35967264e-01f, 3.12753797e-01f, 1.15455836e-01f, 2.32569247e-01f, -1.00064337e-01f,
  9.86000448e-02f, -9.38443244e-02f, 1.58014223e-01f, 5.24689928e-02f, -2.00732276e-01f, 2.78010666e-01f, 1.34237245e-01f, 2.99294382e-01f, 1.42443134e-02f, 1.02836810e-01f,
  1.81380197e-01f, -2.75939107e-01f, 2.20220000e-01f, 3.29266071e-01f, 1.18690416e-01f, 1.33574635e-01f, 8.43826607e-02f, 2.03348532e-01f, 2.18732119e-01f, 2.37896815e-01f,
  1.85620151e-02f, 4.13399152e-02f, 4.18102369e-02f, 2.44034119e-02f, 2.27723554e-01f, 1.25175640e-01f, 2.27400243e-01f, 1.61426425e-01f, 2.50514597e-01f, 3.06475967e-01f,
  2.43649259e-02f, -5.15969656e-02f, 1.36241496e-01f, -2.49414191e-01f, 2.16376767e-01f, 1.85901195e-01f, -1.14223182e-01f, -3.32166791e-01f, -5.97561486e-02f, -3.42192531e-01f,
  9.42169502e-02f, -5.99928983e-02f, 1.86400160e-01f, -1.50385410e-01f, -2.46719122e-01f, 3.42253625e-01f, -2.31757179e-01f, -1.81263760e-01f, -1.23281799e-01f, 2.68953621e-01f,
  -2.43032947e-01f, 1.82814300e-01f, 2.98818182e-02f, 1.61816195e-01f, -1.07515387e-01f, -5.27032912e-02f, -2.01407790e-01f, 1.78419739e-01f, 3.25058490e-01f, -3.58144492e-02f,
  -1.52816266e-01f, -9.95209143e-02f, 9.32809860e-02f, 2.33225048e-01f, 6.31362852e-03f, 1.37593925e-01f, 2.20353514e-01f, -9.10539329e-02f, 2.44256258e-01f, 7.36582950e-02f,
  4.63550352e-02f, 1.69772431e-01f, -1.29440110e-02f, 6.88144863e-02f, 9.67063457e-02f, 1.97891727e-01f, -1.50443465e-01f, 8.49200785e-02f, 1.79507926e-01f, 2.67314434e-01f,
  -7.09658628e-03f, 2.48520687e-01f, -3.62908393e-02f, 1.82646573e-01f, 2.19413325e-01f, 2.05751762e-01f, 1.98442847e-01f, 7.51114264e-03f, 1.20869286e-01f, 8.04481283e-02f,
  2.28306539e-02f, 1.88404158e-01f, 1.80439100e-01f, 2.65768677e-01f, 1.14660159e-01f, 9.81817991e-02f, 1.11538783e-01f, -1.83189869e-01f, 3.02069962e-01f, 2.63997138e-01f,
  2.45717585e-01f, -2.63126880e-01f, -1.68357790e-01f, 2.05123380e-01f, 7.38816634e-02f, -1.75827131e-01f, 2.42130399e-01f, -5.81366941e-02f, -2.45916069e-01f, 2.06007063e-01f,
  -1.29969507e-01f, -4.48764600e-02f, 2.84272283e-02f, 1.91331223e-01f, -5.04544191e-03f, 4.32011448e-02f, 1.06691919e-01f, 5.22474460e-02f, 2.60410924e-02f, -2.98685692e-02f,
  1.94954008e-01f, 5.36991991e-02f, 1.98002785e-01f, -2.44060624e-02f, -5.74115850e-03f, -7.47784674e-02f, 5.36030829e-02f, -1.01621058e-02f, -1.23988554e-01f, 3.72522660e-02f,
  4.25060429e-02f, 1.35677800e-01f, 3.67771119e-01f, 1.77386984e-01f, -1.80582091e-01f, 1.66477323e-01f, 2.32840955e-01f, -2.01068390e-02f, 3.09759140e-01f, 2.03069150e-01f,
  7.32420012e-02f, 1.39033258e-01f, 1.46213949e-01f, 1.52230129e-01f, 1.71633005e-01f, 2.40881085e-01f, 2.13146523e-01f, 2.63963133e-01f, 1.07802175e-01f, 2.93501802e-02f,
  7.55600482e-02f, 1.29785284e-01f, 7.02623948e-02f, 1.20418712e-01f, 1.04168460e-01f, -1.53878676e-02f, 1.43843487e-01f, 9.78332385e-02f, 1.91161036e-01f, 7.18960911e-02f,
  5.83157688e-02f, -1.95607141e-01f, 8.50439295e-02f, -7.06275459e-03f, -1.25260264e-01f, -1.98370561e-01f, 1.29970223e-01f, -3.85129839e-01f, 2.09187254e-01f, -3.59772146e-02f,
  -8.11791420e-03f, -3.18677217e-01f, -1.84932128e-01f, 2.10337803e-01f, -2.64253646e-01f, -1.92051511e-02f, -1.95596591e-01f, 1.95096239e-01f, -3.38518143e-01f, 2.01587886e-01f,
  1.68436572e-01f, 1.37483433e-01f, -2.41002679e-01f, 4.57812697e-02f, -1.80438548e-01f, 2.41037980e-01f, 1.35038555e-01f, 2.63459414e-01f, 1.24750294e-01f, -1.60346795e-02f,
  1.02108337e-01f, 1.28009409e-01f, -1.47130698e-01f, -2.13142186e-02f, 2.38606811e-01f, -1.18017860e-01f, -9.83642712e-02f, 2.53667086e-01f, 2.67536998e-01f, 6.15486167e-02f,
  -1.77964613e-01f, 1.66381523e-01f, 4.04337645e-02f, 1.79307461e-01f, -7.04275519e-02f, 3.77621129e-02f, 6.86362982e-02f, 3.39699924e-01f, 8.48883204e-03f, 3.11054200e-01f,
  1.76558986e-01f, -5.86179942e-02f, 1.41496032e-01f, 1.73413366e-01f, 1.25898942e-01f, 1.75293341e-01f, 1.62713557e-01f, 2.53228992e-01f, 7.66485333e-02f, 2.41742775e-01f,
  1.22527063e-01f, 1.76655710e-01f, 8.74608383e-02f, -1.33569608e-03f, 2.57077277e-01f, -1.69486981e-02f, 3.03386152e-01f, 1.57347202e-01f, 1.66202620e-01f, -2.63661891e-01f,
  7.73999915e-02f, -2.19732881e-01f, 3.23692523e-02f, -1.17217496e-01f, 2.19448537e-01f, -8.69468320e-03f, -3.53721857e-01f, 1.76526070e-01f, -4.75322269e-02f, -1.28200993e-01f,
  -1.67017013e-01f, -1.76951326e-02f, 3.28666233e-02f, 1.35179743e-01f, 8.49350616e-02f, 3.14808279e-01f, 4.02814299e-02f, 2.94660032e-01f, -2.38503620e-01f, -1.93882570e-01f,
  -1.32590592e-01f, 8.21061246e-03f, -3.49750593e-02f, -1.53195813e-01f, 2.15777278e-01f, 7.34407008e-02f, -9.90424454e-02f, 2.69259781e-01f, 5.17732948e-02f, 2.07537487e-01f,
  1.31980732e-01f, -2.12739199e-01f, 4.11440283e-02f, 1.53402224e-01f, -1.07084185e-01f, -1.03562973e-01f, -2.47558966e-01f, 2.60689527e-01f, -3.72640975e-02f, -8.34066346e-02f,
  1.04401417e-01f, -1.91129386e-01f, 8.77564624e-02f, -3.43977800e-03f, -6.18908927e-03f, 3.58258118e-03f, -3.73117104e-02f, -9.24536362e-02f, 2.79649012e-02f, 2.01332569e-02f,
  1.35762200e-01f, -6.45306781e-02f, 1.87441483e-01f, 1.84272841e-01f, -5.76092675e-02f, 1.35450706e-01f, -5.83999939e-02f, 5.27049713e-02f, -1.94751285e-02f, 8.29506740e-02f,
  -2.10569426e-02f, 1.10449739e-01f, 2.79044151e-01f, 3.92413914e-01f, -2.63772458e-01f, 4.14176971e-01f, 3.04902140e-02f, -1.12753198e-01f, -1.01373203e-01f, -1.88081130e-01f,
  6.65025339e-02f, -4.36584800e-02f, -1.73701406e-01f, 2.12206617e-01f, 5.61254062e-02f, 1.61969200e-01f, -1.65144410e-02f, -2.79306740e-01f, -2.32282937e-01f, -2.00397000e-01f,
  2.00748533e-01f, 1.48385791e-02f, 1.57040030e-01f, 9.14872587e-02f, 3.02822798e-01f, 1.50096476e-01f, 2.97551513e-01f, 1.98488329e-02f, 1.99969672e-02f, -2.45922193e-01f,
  -1.38840616e-01f, -2.34734938e-01f, -2.51320273e-01f, 1.52399689e-01f, -1.39491335e-01f, 1.64402008e-01f, -3.62830725e-03f, -5.82709163e-02f, 2.72693075e-02f, -1.23026595e-01f,
  2.88250089e-01f, -3.24174881e-01f, 2.06947058e-01f, 3.07627022e-01f, -1.65534858e-02f, 3.26156825e-01f, 1.86518490e-01f, 2.23345503e-01f, 6.07205927e-02f, 1.16354525e-02f,
  1.58082649e-01f, 2.20780477e-01f, 1.24537498e-01f, 1.75048187e-01f, -6.36048466e-02f, 4.33000922e-02f, -1.01345085e-01f, -2.03027297e-02f, 2.28663664e-02f, 1.79109126e-01f,
  1.46163180e-01f, 3.30598839e-02f, 1.52077422e-01f, 1.62179828e-01f, -1.54029906e-01f, -2.44215429e-01f, 1.60343245e-01f, 1.98426068e-01f, 2.45305136e-01f, 3.55259299e-01f,
  -1.28038958e-01f, 2.08718270e-01f, 5.28827868e-02f, 2.21694201e-01f, -3.97024043e-02f, -4.06088531e-01f, 2.09729031e-01f, 1.14594288e-02f, 1.70581967e-01f, 9.26402137e-02f,
  3.40098798e-01f, 2.94552706e-02f, 2.28129461e-01f, 2.44249284e-01f, 8.57670531e-02f, 1.41161785e-01f, 6.83339546e-03f, -3.14109661e-02f, -2.58312654e-02f, 6.81622699e-03f,
  -2.21977070e-01f, 5.14487997e-02f, 2.18487144e-01f, 1.55554831e-01f, 3.60989243e-01f, 3.93871933e-01f, 2.11330876e-01f, 2.54954785e-01f, -1.81403011e-01f, 1.21181039e-02f,
  -8.53433385e-02f, 4.30513650e-01f, -1.06521703e-01f, 3.27981859e-01f, -7.64450878e-02f, -2.16676772e-01f, -6.38924092e-02f, 5.63273281e-02f, -3.26161087e-01f, 5.65855466e-02f,
  -2.69918777e-02f, 9.10914391e-02f, 1.84119627e-01f, -1.34988695e-01f, 2.20071569e-01f, -2.83593163e-02f, 6.98517039e-02f, -1.21069208e-01f, -4.44981977e-02f, -1.82571206e-02f,
  -2.71940362e-02f, 4.67822030e-02f, 5.21394536e-02f, -7.79845789e-02f, -4.22434285e-02f, -4.44580093e-02f, 1.21601513e-02f, 2.56549954e-01f, 6.68632537e-02f, -1.26250342e-01f,
  -2.14377767e-03f, -7.03993514e-02f, 2.47884318e-01f, 1.54709205e-01f, -3.16162288e-01f, 2.55580604e-01f, -2.47669429e-01f, 2.60412097e-01f, 1.07983075e-01f, -3.96550536e-01f,
  3.59387636e-01f, -4.31560725e-02f, 1.77503958e-01f, -2.55123079e-01f, 2.89309204e-01f, -8.36475715e-02f, 8.57815370e-02f, -1.16618961e-01f, -1.95947825e-04f, -1.57875847e-02f,
  -1.15490727e-01f, -1.53834879e-01f, -1.95509866e-01f, -2.23438516e-01f, -1.13271877e-01f, -2.21753716e-02f, -8.23837593e-02f, 1.09058674e-02f, 3.94995421e-01f, 4.15754020e-01f,
  2.03101113e-01f, -7.24418275e-03f, -8.14550593e-02f, -7.07928091e-02f, 1.18959695e-01f, -2.60381657e-03f, 3.56401920e-01f, 1.62265897e-02f, -2.99024731e-01f, 1.82002351e-01f,
  -1.57954097e-01f, -1.31702214e-01f, 1.99518546e-01f, 5.00811264e-02f, 9.53760296e-02f, 6.13887310e-02f, 3.74469198e-02f, -6.80695325e-02f, 1.37505099e-01f, 7.92632401e-02f,
  2.48477817e-01f, 3.01540047e-01f, 9.38839512e-04f, 8.31180513e-02f, 1.88545026e-02f, 2.21752778e-01f, -1.87170319e-02f, 1.33598402e-01f, 1.70337483e-01f, 2.32955053e-01f,
  2.76549071e-01f, 1.20918714e-01f, -8.79361108e-02f, -2.10081920e-01f, 1.37100741e-01f, 6.21996038e-02f, 5.39599173e-02f, 2.09614620e-01f, -2.81726364e-02f, 8.34995806e-02f,
  -7.03244656e-02f, 2.57265538e-01f, -6.08708970e-02f, -4.25862782e-02f, 4.72850986e-02f, 1.37279510e-01f, 1.21388935e-01f, -2.33551607e-01f, 1.86616585e-01f, -3.90429236e-02f,
  8.95405561e-02f, 4.82741408e-02f, 3.53970110e-01f, 1.75672233e-01f, 2.16823906e-01f, -2.48077795e-01f, -1.09318018e-01f, 7.39332587e-02f, 2.09069699e-02f, 3.04811418e-01f,
  4.11990361e-04f, 2.29673795e-02f, -1.12632982e-01f, 7.05744922e-02f, 6.51164874e-02f, 2.58717537e-01f, 2.08726570e-01f, -1.07744507e-01f, -1.10063896e-01f, 2.76654810e-01f,
  -6.71336278e-02f, 2.97141641e-01f, 5.52501418e-02f, 1.17429413e-01f, 2.19940349e-01f, -6.06487654e-02f, -5.32898828e-02f, 2.40321264e-01f, 2.28477567e-01f, 1.72701582e-01f,
  1.87378392e-01f, 8.10151771e-02f, 1.23736553e-01f, 9.01031420e-02f, 6.81818798e-02f, -7.46479584e-03f, 1.95198674e-02f, 1.16975710e-01f, 1.01077512e-01f, 1.18739195e-01f,
  -7.24930596e-03f, 7.03841597e-02f, -3.50907482e-02f, 1.26670092e-01f, 1.10065252e-01f, -2.08371669e-01f, 1.46462142e-01f, -8.58886242e-02f, -1.09969966e-01f, -2.19449013e-01f,
  -1.09646931e-01f, -2.75062412e-01f, 2.68235892e-01f, 2.41506264e-01f, -2.10362859e-02f, -5.88190816e-02f, -7.79202506e-02f, -1.92704555e-02f, -4.55975495e-02f, -1.31164923e-01f,
  -2.80078173e-01f, 1.69257656e-01f, -3.33297133e-01f, 1.56782746e-01f, -9.34686363e-02f, 1.58462916e-02f, -2.47345790e-01f, 7.14636371e-02f, -1.70627773e-01f, 2.88514405e-01f,
  2.43570790e-01f, -1.59717247e-01f, 1.50794059e-01f, -1.46040976e-01f, -1.82244018e-01f, 2.96972454e-01f, -5.32269701e-02f, 5.69287837e-02f, 2.98252374e-01f, 2.54257582e-02f,
  -1.64763451e-01f, 1.43981904e-01f, 2.50549167e-01f, 6.49217144e-02f, 5.60118468e-04f, 1.15562908e-01f, -1.32875532e-01f, -1.07649742e-02f, -1.23822518e-01f, -5.56319095e-02f,
  -6.05871901e-02f, 6.37309402e-02f, 1.27636313e-01f, 1.52595043e-01f, -6.22900873e-02f, 1.48732260e-01f, 8.79374743e-02f, 2.38055035e-01f, 6.76522329e-02f, -5.85355051e-02f,
  3.05677820e-02f, 1.96835920e-01f, 2.10887536e-01f, 1.17197849e-01f, 1.08293287e-01f, 1.09231338e-01f, -6.30233511e-02f, -2.28321590e-02f, -5.25104627e-02f, -2.83358186e-01f,
  2.05717549e-01f, 8.10110494e-02f, -1.44450486e-01f, -4.15485770e-01f, -3.73065062e-02f, -2.16492087e-01f, -1.56487823e-01f, -1.77390635e-01f, 9.34235156e-02f, 2.43399978e-01f,
  9.17122662e-02f, -1.94300205e-01f, 7.84830227e-02f, -2.04333186e-01f, 9.73554514e-03f, -1.03560304e-02f, 3.39940526e-02f, 1.23556875e-01f, -2.83042997e-01f, -1.52489915e-01f,
  4.56901342e-02f, -2.07028557e-02f, 7.72966295e-02f, 1.89336747e-01f, 2.81623185e-01f, 6.51089521e-03f, -2.08405122e-01f, -6.34267032e-02f, -1.91029966e-01f, -2.16322150e-02f,
  -1.62285373e-01f, 2.03801006e-01f, 1.00421356e-02f, -1.86297093e-02f, 4.02762234e-01f, -4.89561036e-02f, -1.70399904e-01f, 1.14584230e-01f, 7.75643960e-02f, 2.79967666e-01f,
  6.07286729e-02f, 3.03573370e-01f, 1.80606022e-02f, 1.38048101e-02f, 6.73395246e-02f, -5.64163178e-02f, 1.34533569e-01f, 1.65467620e-01f, 6.08122461e-02f, 3.20275314e-02f,
  8.62767622e-02f, 1.50712699e-01f, -2.79706120e-02f, 2.82582670e-01f, 1.34946287e-01f, 5.03824130e-02f, 6.28511906e-02f, 9.61425751e-02f, 4.94855419e-02f, -9.26414430e-02f,
  -1.76524911e-02f, 1.91912744e-02f, 1.73919842e-01f, 1.73812002e-01f, -2.13216513e-01f, 4.13138941e-02f, -9.21216160e-02f, 2.94925362e-01f, -4.89854328e-02f, 2.52793878e-01f,
  2.87083164e-02f, 2.59305805e-01f, -2.11997777e-01f, 8.94669909e-03f, -1.38974130e-01f, -3.10081780e-01f, -1.12191796e-01f, 1.18937902e-01f, 5.07321283e-02f, 2.51283217e-02f,
  -1.49316728e-01f, 2.35250533e-01f, -1.76473111e-01f, -9.82958749e-02f, 1.93004563e-01f, 9.75525454e-02f, 3.53974819e-01f, 1.89936459e-01f, 6.44315854e-02f, -5.50641790e-02f,
  1.72678411e-01f, 3.11824709e-01f, -2.59349030e-02f, 3.58540602e-02f, 2.43756399e-01f, -3.50589603e-02f, 2.46808693e-01f, 9.87403328e-04f, 5.79580255e-02f, 5.61971851e-02f,
  7.62638524e-02f, 2.87836939e-01f, -1.56753764e-01f, 3.91851246e-01f, -1.92198660e-02f, -1.90870121e-01f, 5.91990314e-02f, 2.02112049e-01f, 3.17752026e-02f, 9.56318825e-02f,
  5.98214269e-02f, -5.94456866e-02f, 9.53990072e-02f, -6.83124140e-02f, 1.31080532e-02f, -9.42504033e-03f, 1.56591833e-01f, -4.71010879e-02f, 1.60412356e-01f, -1.98848233e-01f,
  9.94905010e-02f, 2.55340785e-01f, 4.71219644e-02f, 2.75586933e-01f, 1.47542149e-01f, 1.45714417e-01f, -2.31258664e-02f, -1.19592085e-01f, -8.55876952e-02f, 9.37344506e-02f,
  1.80933669e-01f, -1.22809969e-02f, -1.05673939e-01f, -3.25329192e-02f, -1.92090929e-01f, -2.73866653e-01f, 1.86546162e-01f, 3.79161462e-02f, -2.28488967e-02f, 9.11674052e-02f,
  -4.08923952e-03f, -1.82197727e-02f, 3.86162810e-02f, 5.78693897e-02f, 1.58506557e-01f, -8.16252902e-02f, 5.49383312e-02f, 7.80007318e-02f, 6.83338493e-02f, -2.52258554e-02f,
  1.98356926e-01f, -2.87709802e-01f, -5.38583321e-04f, 1.77593231e-01f, -1.58847362e-01f, -9.39208046e-02f, 2.83686012e-01f, -1.72322899e-01f, 1.34708062e-01f, -1.39481407e-02f,
  -2.17489049e-01f, -1.83447897e-01f, 3.60709965e-01f, -2.76370738e-02f, -2.39248946e-02f, -8.28295387e-03f, 1.43166762e-02f, -1.28761858e-01f, 5.88435531e-02f, 5.74106388e-02f,
  6.10453188e-02f, 2.11732015e-01f, 1.22699283e-01f, 2.50152983e-02f, 7.15556443e-02f, 8.81970953e-03f, 1.84858561e-01f, 5.45375831e-02f, 3.12647969e-02f, 4.58074287e-02f,
  2.15997156e-02f, -4.32236912e-03f, 2.40747556e-02f, -1.47879675e-01f, -3.17427553e-02f, 1.44712240e-01f, 3.59348133e-02f, 1.91082448e-01f, -9.26467031e-03f, 7.00408891e-02f,
  -1.31335437e-01f, 3.41519527e-02f, -1.37625232e-01f, 2.20603585e-01f, 1.10225501e-02f, -5.31590125e-03f, 1.97308809e-01f, -1.67317048e-01f, -1.27717182e-01f, -2.04998970e-01f,
  9.71251205e-02f, -1.87095344e-01f, -8.25930312e-02f, 1.54044434e-01f, 9.68495831e-02f, 7.30049834e-02f, 5.63792847e-02f, 3.54161672e-02f, 2.62943655e-01f, 1.94904897e-02f,
  4.13618475e-01f, 2.59916425e-01f, 7.05344826e-02f, 1.32688075e-01f, -2.13483945e-01f, 3.36359479e-02f, -2.70195276e-01f, 2.49310836e-01f, -5.35839759e-02f, -8.63766000e-02f,
  3.09477866e-01f, 9.10298992e-03f, 2.32807159e-01f, 2.67622434e-02f, 2.65127122e-01f, -2.25707218e-01f, -1.09133892e-01f, 6.42769635e-02f, 1.74653739e-01f, 8.90214294e-02f,
  -9.72173437e-02f, 1.98671356e-01f, 1.26104847e-01f, -1.35776863e-01f, -9.06159133e-02f, 1.92634359e-01f, 3.57645042e-02f, -4.07484397e-02f, 3.60287651e-02f, -9.67025235e-02f,
  2.09090635e-01f, 1.19806744e-01f, 1.30899593e-01f, 2.50742137e-01f, 2.07585737e-01f, 1.68182671e-01f, 1.11647695e-01f, 7.72277787e-02f, 3.61756235e-02f, 1.31878585e-01f,
  7.04385042e-02f, -1.03989564e-01f, 5.59419729e-02f, 1.53077468e-01f, 2.56215453e-01f, 1.31928787e-01f, -7.15399608e-02f, -1.03651792e-01f, 1.41106784e-01f, 3.28593105e-01f,
  1.00403100e-01f, 1.41472235e-01f, -1.26683727e-01f, -1.03076687e-03f, -1.41310468e-01f, 5.83051033e-02f, 2.20075488e-01f, -2.25733235e-01f, 1.92608818e-01f, 1.79627821e-01f,
  -4.09566201e-02f, -1.80624112e-01f, 1.48194730e-01f, -2.74907500e-01f, 2.40378201e-01f, 3.93156111e-02f, 3.36596996e-01f, 1.99358195e-01f, 3.26014906e-01f, 1.19895056e-01f,
  -5.23626097e-02f, 7.66279399e-02f, 3.52568775e-02f, 2.55196691e-01f, 1.71882674e-01f, 6.65227696e-02f, 1.47299424e-01f, 9.30540189e-02f, -4.62410226e-02f, 1.91198915e-01f,
  -1.94014963e-02f, 4.45895642e-02f, -1.23981223e-03f, 2.96606384e-02f, 2.85428345e-01f, 1.07489869e-01f, 1.95503503e-01f, -1.15308547e-02f, 2.84670413e-01f, 1.73821181e-01f,
  1.77372500e-01f, 6.65608197e-02f, 9.27787945e-02f, 5.67683205e-02f, 5.97335063e-02f, 1.57678157e-01f, 1.13132499e-01f, 9.48393866e-02f, 1.30319044e-01f, 1.53320909e-01f,
  2.15219334e-01f, 9.24977940e-03f, 6.31594136e-02f, 1.80535257e-01f, 7.98709749e-04f, 2.29134306e-01f, 1.23862833e-01f, -2.21609417e-02f, 1.70456037e-01f, -4.58289571e-02f,
  -1.05285160e-02f, -3.28794308e-02f, -3.70182772e-03f, 1.85917258e-01f, -2.39681840e-01f, 3.61279458e-01f, -4.29574773e-03f, -1.14747129e-01f, 2.20868781e-01f, -6.66397363e-02f,
  1.46288589e-01f, -1.15806036e-01f, -1.16443142e-01f, -7.27251545e-02f, -3.66989598e-02f, -4.03766260e-02f, -4.80282046e-02f, -1.64741904e-01f, -2.48451024e-01f, -2.03644499e-01f,
  3.13408375e-02f, -1.23656221e-01f, 3.04715097e-01f, 2.51868635e-01f, 3.95365119e-01f, 3.23741399e-02f, 2.42384151e-01f, -1.39527500e-01f, -5.93573973e-02f, -3.62443738e-02f,
  -2.54683830e-02f, -6.70538321e-02f, -2.69915998e-01f, 1.41712859e-01f, 3.12577456e-01f, -1.19978627e-02f, -8.02303776e-02f, 1.32506728e-01f, 2.63048351e-01f, -4.24706452e-02f,
  3.58634502e-01f, 1.56303838e-01f, 1.45421416e-01f, 2.73437947e-01f, -5.61014824e-02f, -3.35747711e-02f, 2.07803026e-01f, 3.93634103e-02f, 1.63991034e-01f, 1.57533318e-01f,
  1.96206775e-02f, 1.80203974e-01f, 5.34282662e-02f, 1.61479026e-01f, 8.49210769e-02f, 1.92876458e-01f, 8.67250934e-02f, 1.69492200e-01f, 2.15424538e-01f, -8.82203951e-02f,
  2.68047035e-04f, 1.08651131e-01f, 1.35095537e-01f, 3.15429270e-01f, -2.33293138e-02f, -3.60835224e-01f, -3.99323031e-02f, 1.91212669e-02f, 2.34189302e-01f, -1.12729847e-01f,
  -1.16410926e-01f, 3.89304981e-02f, -2.69240946e-01f, 9.75431353e-02f, 4.17489827e-01f, -4.02663559e-01f, 1.91480875e-01f, 1.59989655e-01f, 1.75190549e-02f, -3.09508890e-01f,
  1.24132194e-01f, -2.74928752e-02f, 5.40097896e-03f, -1.01458110e-01f, -1.15950637e-01f, 1.70673609e-01f, -9.01802033e-02f, 2.65353825e-02f, -2.28257865e-01f, 1.01737760e-01f,
  -2.70991530e-02f, 1.93007976e-01f, -4.45706882e-02f, 2.70182073e-01f, 3.11428398e-01f, 3.85103434e-01f, -9.98257026e-02f, 9.86402333e-02f, -4.36986424e-02f, 2.41105780e-01f,
  3.43275368e-01f, -8.38052928e-02f, 2.22911075e-01f, 3.00900728e-01f, -3.81581150e-02f, 3.42807263e-01f, 5.67651168e-02f, 3.42548490e-02f, 1.90894574e-01f, 1.02774678e-02f,
  1.02572881e-01f, -4.95613851e-02f, 2.29260847e-01f, 1.12930506e-01f, 7.87762403e-02f, -7.14656487e-02f, -1.47596106e-01f, 1.38643637e-01f, -4.55275476e-02f, 3.82704660e-02f,
  2.42212966e-01f, 1.70546129e-01f, 2.65436947e-01f, -2.21759886e-01f, 7.34810606e-02f, -3.77903469e-02f, -8.33626539e-02f, 1.88338850e-02f, -5.32255061e-02f, 1.87570881e-02f,
  -7.59946406e-02f, 1.08452849e-02f, 8.80368948e-02f, -4.13589835e-01f, 3.59453406e-04f, 4.66071367e-02f, -2.02303365e-01f, -2.02060744e-01f, -4.00836654e-02f, -3.23148370e-02f,
  2.11335912e-01f, 4.85988557e-02f, -4.99154218e-02f, -1.83654934e-01f, -1.54318258e-01f, -3.21516916e-02f, -1.84972119e-02f, -6.60989201e-03f, 1.19325325e-01f, -1.78012736e-02f,
  2.08510086e-01f, 4.60633226e-02f, -2.08223373e-01f, 2.55796701e-01f, 1.07409194e-01f, 2.85140812e-01f, -1.01691291e-01f, -1.64141469e-02f, 1.20878361e-01f, -1.61262602e-01f,
  -4.50754203e-02f, -1.91173449e-01f, 2.30688363e-01f, 3.19571704e-01f, 1.80007994e-01f, -3.05881917e-01f, -2.89008677e-01f, 2.09654674e-01f, 3.79172891e-01f, 2.65881985e-01f,
  -2.82756835e-02f, 1.82533056e-01f, -2.24410314e-02f, -1.87734198e-02f, 2.18595579e-01f, 1.27290204e-01f, 1.39131635e-01f, 1.80217132e-01f, 1.88046396e-01f, 1.96807712e-01f,
  6.65033460e-02f, 1.61981747e-01f, 1.38480231e-01f, 6.09273836e-03f, 6.40778318e-02f, 9.30766314e-02f, 2.70805433e-02f, 4.43322659e-02f, 9.93779227e-02f, 2.43223220e-01f,
  2.36297287e-02f, 2.67174333e-01f, 3.39828938e-01f, -1.21709593e-01f, 2.22214505e-01f, -1.41730502e-01f, -2.60120328e-03f, -8.78418535e-02f, 1.34806484e-01f, -2.00109053e-02f,
  -3.48354667e-01f, 6.52630329e-02f, 4.14422929e-01f, -3.24886292e-01f, 2.12729335e-01f, 1.20669998e-01f, -3.94184172e-01f, -2.23767638e-01f, 1.91706121e-01f, -2.83951879e-01f,
  8.15900043e-02f, 6.91047087e-02f, -3.67089242e-01f, 2.92383581e-01f, -3.70957047e-01f, -2.16369089e-02f, -2.64476299e-01f, 1.71890393e-01f, 1.16349153e-01f, -9.20166373e-02f,
  -1.04527781e-02f, 1.99811131e-01f, -5.74220046e-02f, 1.92557573e-01f, -7.60468841e-02f, 2.21660942e-01f, -3.03096920e-01f, 1.27374768e-01f, 3.77191454e-01f, -2.51565129e-01f,
  1.69017941e-01f, -1.44439012e-01f, -2.75283717e-02f, 3.46216202e-01f, 1.66360736e-01f, 4.70005684e-02f, 1.85501456e-01f, 2.68189222e-01f, 9.02804136e-02f, 2.49598585e-02f,
  2.43796557e-01f, 1.72781393e-01f, 1.47988096e-01f, 6.44400939e-02f, -7.99723621e-03f, 1.38891682e-01f, 8.03483054e-02f, 8.14853013e-02f, 2.30713487e-01f, 6.86823875e-02f,
  1.05645411e-01f, -1.04876749e-01f, 1.74886793e-01f, 1.61493182e-01f, -8.36366490e-02f, 1.06067434e-01f, 4.46309149e-02f, -2.06604049e-01f, -7.68673271e-02f, 6.76940456e-02f,
  3.42806190e-01f, -3.35708439e-01f, -5.07470779e-02f, -1.05257921e-01f, 3.26955244e-02f, -9.35247913e-03f, 2.12420106e-01f, -1.95468932e-01f, 2.01193884e-01f, -7.11927284e-03f,
  -9.06803906e-02f, -1.45900920e-01f, 2.62360990e-01f, -1.13102637e-01f, 2.73118109e-01f, 3.22033167e-01f, 3.86644192e-02f, 3.00197929e-01f, -4.96730134e-02f, -4.10577767e-02f,
  -4.05751139e-01f, 1.44973934e-01f, -1.20115526e-01f, 8.76732022e-02f, 1.64162517e-01f, 1.42451242e-01f, 2.57774115e-01f, 2.09952846e-01f, 4.77421097e-02f, -3.62439640e-02f,
  -1.89532161e-01f, 1.89851999e-01f, 3.69686991e-01f, 1.14567570e-01f, -1.68551967e-01f, 1.66501820e-01f, 2.00871572e-01f, 1.85873285e-01f, 6.04078919e-02f, 1.40732257e-02f,
  1.08787432e-01f, -5.89481369e-02f, 1.01272032e-01f, 8.22041184e-02f, 2.72437632e-01f, 9.48960334e-02f, 2.11868182e-01f, 1.34892359e-01f, 1.30157799e-01f, 5.82744293e-02f,
  1.77223254e-02f, 4.14242186e-02f, 1.66181281e-01f, 1.35730868e-02f, 5.68192527e-02f, -1.19850434e-01f, 1.15203939e-01f, 1.07873917e-01f, 1.06819943e-01f, 6.06939904e-02f,
  -1.46636084e-01f, 1.51839018e-01f, 1.18618859e-02f, 3.48482057e-02f, 1.51620775e-01f, -1.09527097e-03f, 5.54316714e-02f, 1.95694149e-01f, -4.10038233e-02f, -3.95032823e-01f,
  -3.48030962e-02f, 1.57718256e-01f, -2.27315083e-01f, 1.71166316e-01f, -1.94651321e-01f, 8.67619514e-02f, -1.99402556e-01f, -4.02697176e-03f, 1.71369746e-01f, 1.50858134e-01f,
  1.62866473e-01f, 2.16619313e-01f, -6.00562897e-03f, 1.65280476e-01f, -3.55263539e-02f, 2.09911197e-01f, 2.78283447e-01f, 4.81645018e-02f, 2.47537971e-01f, 1.68692529e-01f,
  2.24755049e-01f, -1.35514989e-01f, 2.62468606e-01f, 7.52512664e-02f, -1.95274889e-01f, 1.44113928e-01f, 2.44522661e-01f, -6.00867830e-02f, -1.28292069e-01f, -6.24145791e-02f,
  3.34925912e-02f, -1.46903917e-01f, 1.42373219e-02f, 2.60748118e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 26)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 26;
const float L1_fan_Bp_bar_data[] = {
  1.09578602e-01f, 1.12576066e-02f, 2.23593906e-01f, 1.97082326e-01f, 1.57608300e-01f, -1.56749990e-02f, 1.12482153e-01f, 1.93538457e-01f, 1.39844537e-01f, 2.30016038e-01f,
  1.15347758e-01f, 9.71424654e-02f, 1.07535928e-01f, 1.97649091e-01f, 2.01855510e-01f, 2.64591455e-01f, 1.86754614e-01f, 3.87067087e-02f, 1.48128867e-01f, 8.65262523e-02f,
  -7.43112119e-04f, 7.67235681e-02f, 7.40154982e-02f, 1.77952662e-01f, -3.14874835e-02f, 3.66687262e-03f
};

// L2_fan_Wp (Shape: 19 x 64)
const int L2_fan_Wp_rows = 19;
const int L2_fan_Wp_cols = 64;
const float L2_fan_Wp_data[] = {
  -6.62772357e-02f, 1.16096856e-02f, 1.42909870e-01f, 2.35273205e-02f, -1.17096819e-01f, -8.80165584e-03f, -5.84821776e-02f, -8.17063171e-03f, 1.21493176e-01f, 2.29016230e-01f,
  -3.72335166e-02f, 1.90508422e-02f, 5.96500002e-02f, -5.87545894e-02f, 7.62159303e-02f, 9.63585228e-02f, 2.95003410e-02f, 3.57239954e-02f, -3.58461663e-02f, -7.33802933e-03f,
  -1.16079792e-01f, -2.36778364e-01f, -2.62343455e-02f, -1.00329317e-01f, -1.24472111e-01f, -6.97364584e-02f, -3.85541990e-02f, -1.18358277e-01f, -8.20256472e-02f, -3.92494276e-02f,
  4.05392190e-03f, -9.79394093e-02f, 2.36543983e-01f, -2.22753182e-01f, -8.72936994e-02f, -2.15733256e-02f, -1.05623655e-01f, 1.57519221e-01f, 1.02723397e-01f, -2.47730948e-02f,
  8.89591575e-02f, -7.95584619e-02f, 4.44343276e-02f, -7.98688084e-02f, -8.98727328e-02f, 2.68076919e-02f, 3.19274813e-02f, 2.20377855e-02f, -3.86155136e-02f, 1.78578589e-03f,
  2.29257315e-01f, -1.03396783e-02f, 1.67761520e-01f, 1.19442321e-01f, 8.39218125e-02f, -1.73475727e-01f, -2.03377068e-01f, -1.55696318e-01f, -1.52064890e-01f, 9.13525149e-02f,
  -8.96378383e-02f, 2.41563350e-01f, -1.26712453e-02f, -2.21685283e-02f, 9.64060575e-02f, 6.99262917e-02f, -1.26351044e-01f, 6.88987300e-02f, 6.45881444e-02f, 1.60647959e-01f,
  5.34636043e-02f, 5.50971404e-02f, -5.58795109e-02f, 1.15428701e-01f, -2.74909995e-02f, -9.21349786e-03f, 1.17652468e-01f, 1.36675173e-02f, -3.95448506e-02f, -8.06201845e-02f,
  -1.27595346e-02f, 6.94119111e-02f, -8.59354734e-02f, 2.02331677e-01f, 1.17380783e-01f, -1.73149377e-01f, -1.37092462e-02f, -9.42527652e-02f, -1.39260933e-01f, -1.75684199e-01f,
  1.67303801e-01f, -5.51626645e-02f, 1.35358134e-02f, 1.40510544e-01f, -7.19553530e-02f, -2.81957183e-02f, -6.42029792e-02f, -1.61677584e-01f, 2.13648394e-01f, 1.00516520e-01f,
  1.69407338e-01f, -1.96877077e-01f, 1.01460077e-01f, -8.17525089e-02f, 9.60389748e-02f, -1.14151360e-02f, 3.01662654e-01f, -1.63967252e-01f, -4.66727801e-02f, -6.88826516e-02f,
  -1.50342062e-01f, 6.36036843e-02f, -1.36590347e-01f, 5.61501943e-02f, 6.67192712e-02f, 1.05956055e-01f, -7.89146721e-02f, -8.70406777e-02f, 8.69699717e-02f, -9.62563828e-02f,
  -1.04353838e-01f, -1.39232092e-02f, 8.23677424e-03f, 1.27446026e-01f, -2.47723553e-02f, 8.11410993e-02f, 9.55324844e-02f, 6.49815500e-02f, 2.36564912e-02f, -3.12756263e-02f,
  3.09728906e-02f, 1.81003753e-02f, 1.04351854e-03f, -3.58621106e-02f, 1.37423947e-01f, -3.01219244e-02f, 4.74344231e-02f, -6.79257363e-02f, -2.35317685e-02f, -9.44133550e-02f,
  -7.93659166e-02f, -1.30185872e-01f, -7.07465708e-02f, 1.15528785e-01f, 6.25056699e-02f, 2.01890096e-02f, 8.76953602e-02f, -2.39661289e-03f, 8.27201009e-02f, -2.00475529e-01f,
  -1.43183395e-01f, -1.64881378e-01f, 6.74660057e-02f, -1.89670235e-01f, 2.75067747e-01f, -1.86473325e-01f, -7.02903718e-02f, 1.13403432e-01f, 1.11674834e-02f, 5.96674159e-03f,
  1.46502644e-01f, -1.05922699e-01f, 1.30704209e-01f, -4.07835282e-02f, 1.13278896e-01f, 2.01773606e-02f, 1.84794888e-01f, 2.88360920e-02f, 3.61655988e-02f, -9.35871303e-02f,
  -2.01637447e-01f, -4.09667306e-02f, -1.23797998e-01f, -6.79423362e-02f, 8.22019279e-02f, 9.17110741e-02f, -2.28786796e-01f, 1.62257180e-02f, -2.83993836e-02f, 6.02212362e-03f,
  7.04377666e-02f, -1.39822051e-01f, 5.88793941e-02f, -4.10452634e-02f, -3.12589183e-02f, 4.39044945e-02f, -2.55386710e-01f, -6.18995316e-02f, 4.96701486e-02f, 4.53545377e-02f,
  5.02401553e-02f, -1.20668327e-02f, -1.27006054e-01f, -1.06200680e-01f, 4.73490767e-02f, 3.06700543e-03f, -6.12097047e-02f, -2.07749624e-02f, 1.15110278e-02f, -7.01945135e-03f,
  6.26893155e-03f, -2.39242725e-02f, -8.19734931e-02f, -7.12722074e-03f, 4.21729833e-02f, -6.88274354e-02f, -3.41587849e-02f, 1.68149635e-01f, -2.08809297e-03f, -1.02098417e-02f,
  4.71953154e-02f, 2.38804013e-01f, -1.70870438e-01f, 1.21974938e-01f, -1.75703079e-01f, 1.69959858e-01f, -1.95709206e-02f, -1.59019642e-02f, 5.21571450e-02f, 1.72633260e-01f,
  -1.11552984e-01f, -1.03548095e-01f, 2.16173679e-01f, -1.15845345e-01f, 3.53731699e-02f, -9.53493342e-02f, -4.20414507e-02f, -1.09205447e-01f, 6.55685365e-02f, 2.80472457e-01f,
  -7.09002912e-02f, -1.11430243e-01f, 1.27196029e-01f, -5.32231992e-03f, -2.76252300e-01f, -7.35705867e-02f, -1.20667685e-02f, -5.88044466e-04f, 4.35890742e-02f, -1.21387303e-01f,
  -1.54566728e-02f, -2.25140706e-01f, -1.50513381e-01f, 3.46840136e-02f, 6.55755028e-02f, -2.10628211e-02f, 7.51046762e-02f, -1.46900713e-01f, -1.70563340e-01f, 2.74776798e-02f,
  -1.80879477e-04f, -4.82030809e-02f, 4.61368635e-03f, 7.50667229e-02f, -4.14197929e-02f, 8.50873068e-03f, 1.20608024e-02f, -8.06938186e-02f, 8.38941801e-03f, 2.45629828e-02f,
  -6.69233575e-02f, -5.08347563e-02f, -5.69568537e-02f, -2.88561825e-02f, 6.13273904e-02f, 3.22519466e-02f, 2.28462950e-03f, -2.86194589e-02f, 9.87077318e-03f, -4.59408294e-03f,
  -1.37196228e-01f, 6.43281862e-02f, 7.13969395e-02f, 8.77474248e-03f, -7.48457573e-03f, 4.29425836e-02f, -2.43811086e-01f, 1.04882196e-01f, -7.09813014e-02f, 2.42855132e-01f,
  -8.49485397e-02f, 1.85523689e-01f, 3.63272913e-02f, 8.67837742e-02f, -5.91145456e-02f, -1.51807770e-01f, 1.23191454e-01f, 3.04421373e-02f, -1.04096778e-01f, 1.49227843e-01f,
  9.37360227e-02f, 1.59133688e-01f, -1.30895004e-01f, -2.22775087e-01f, -8.54838192e-02f, -2.00119801e-02f, -1.62051320e-01f, -1.84152663e-01f, 1.54074505e-01f, 6.26392290e-02f,
  1.19296566e-01f, -5.95462546e-02f, -1.07088700e-01f, 1.47883147e-02f, 8.38609710e-02f, -1.77999541e-01f, 3.32189612e-02f, -2.14237452e-01f, -8.41452628e-02f, 1.29627004e-01f,
  -1.63860798e-01f, 6.41897991e-02f, 4.84166332e-02f, -7.17546493e-02f, 1.76466152e-01f, 3.95452827e-02f, 1.54972263e-03f, 2.52148300e-01f, 1.22594468e-01f, -5.44167235e-02f,
  2.28587389e-02f, -9.58789364e-02f, 8.45000893e-02f, -4.23172582e-03f, -1.32606193e-01f, 3.53160091e-02f, 8.85392576e-02f, -8.05005729e-02f, 1.53371692e-01f, 1.24391556e-01f,
  1.41896233e-01f, -6.83066547e-02f, -2.23157592e-02f, -5.37666772e-03f, -7.76218250e-02f, -2.36201892e-03f, 2.34173443e-02f, 1.90945137e-02f, 1.45661965e-01f, -6.23523593e-02f,
  -1.67231217e-01f, 7.45979548e-02f, -1.39728695e-01f, -1.72824666e-01f, -8.88517722e-02f, 3.52958702e-02f, -4.58108820e-02f, 1.09655365e-01f, -1.30618557e-01f, -2.39560395e-01f,
  -2.41279900e-02f, -1.29182607e-01f, 6.39237091e-02f, 3.69053744e-02f, -5.13429195e-02f, -6.95684692e-03f, 3.89215648e-02f, 3.57877612e-02f, -6.94710761e-02f, -1.47810876e-01f,
  -5.09186275e-02f, 7.17159510e-02f, 2.16354772e-01f, -1.61833495e-01f, 1.46730110e-01f, 1.33828312e-01f, 8.57642069e-02f, 3.80893908e-02f, -1.27557069e-01f, -4.84847017e-02f,
  3.04881066e-01f, -5.33456542e-02f, 1.32076263e-01f, 6.76233396e-02f, -1.71660408e-01f, -4.26250286e-02f, -8.27498436e-02f, -3.78868682e-03f, 3.20062041e-02f, -1.57651573e-01f,
  9.79758203e-02f, 1.13855556e-01f, -5.21530397e-02f, -1.40905485e-01f, 8.20523947e-02f, 1.45356148e-01f, 1.02357594e-02f, -4.88412976e-02f, -1.23824909e-01f, -8.60133693e-02f,
  8.24647248e-02f, 1.11910507e-01f, -7.54529685e-02f, 4.07356359e-02f, 1.45787045e-01f, 4.89985757e-02f, -2.00394467e-02f, -1.42999485e-01f, 5.15066348e-02f, 5.22287637e-02f,
  1.47380695e-01f, -6.84204772e-02f, -7.46973231e-02f, -3.55898403e-02f, -1.85147077e-02f, 6.88050017e-02f, -1.53467162e-02f, -1.59689143e-01f, 1.13251925e-01f, -7.18012173e-03f,
  1.63687900e-01f, -1.68736398e-01f, -8.62915367e-02f, -1.41174775e-02f, -8.80355313e-02f, 8.05006027e-02f, -6.89409301e-02f, -1.12101234e-01f, 7.00458959e-02f, -2.09396109e-02f,
  -2.35806294e-02f, -3.43277231e-02f, -9.20396820e-02f, -9.89216417e-02f, -3.82939875e-02f, -8.72816518e-02f, -3.06134939e-01f, 1.50728151e-01f, 1.68225721e-01f, -1.40394375e-01f,
  1.61084011e-01f, 2.39813998e-02f, -5.54123335e-02f, -8.06528628e-02f, -5.72671182e-02f, -7.08896816e-02f, 1.86213449e-01f, -4.15783226e-02f, -2.54734755e-02f, -1.16728032e-02f,
  1.73663661e-01f, -1.18827946e-01f, -1.52100742e-01f, 5.87307177e-02f, 6.85392469e-02f, 3.13120186e-02f, 8.87450576e-02f, 5.88084757e-02f, -6.00544289e-02f, 1.36881143e-01f,
  1.52270839e-01f, 1.90896187e-02f, -4.21641357e-02f, 9.75584835e-02f, 1.19970687e-01f, 2.09588379e-01f, -9.03550088e-02f, 1.94704488e-01f, 2.08774954e-01f, 1.41726120e-03f,
  -4.36442532e-02f, 2.48426069e-02f, 6.52405173e-02f, 4.57645720e-03f, -8.24058428e-02f, 1.26289114e-01f, 7.61302412e-02f, -7.40774022e-03f, 5.24487942e-02f, -1.60938362e-03f,
  -1.60941347e-01f, -1.13077641e-01f, -1.19269909e-02f, -7.14035705e-02f, 1.09754920e-01f, -1.13615148e-01f, -1.54629439e-01f, -2.62154609e-01f, 1.30903587e-01f, 7.62573108e-02f,
  -6.75273985e-02f, -3.58108878e-02f, -1.79959759e-01f, 1.35185458e-02f, 3.93124036e-02f, -4.40246761e-02f, -4.50125560e-02f, 6.07480742e-02f, 9.99935642e-02f, 9.25298855e-02f,
  2.16122791e-01f, -2.56792605e-01f, 1.27895266e-01f, 1.33096976e-02f, 1.21385768e-01f, 6.83263317e-02f, 3.29010077e-02f, -7.81037584e-02f, -4.33871709e-02f, 1.64099578e-02f,
  1.58957243e-01f, 3.66287902e-02f, -1.50860334e-02f, -5.43893017e-02f, -1.93592265e-01f, -2.78453156e-02f, 3.69198695e-02f, 1.69847216e-02f, 1.11711010e-01f, 9.65065882e-02f,
  3.78774032e-02f, -2.17244729e-01f, 1.12861849e-01f, 5.56977727e-02f, -2.31933445e-02f, -1.07743151e-01f, 1.18382215e-01f, 4.09845449e-02f, 5.76503240e-02f, 7.77739957e-02f,
  1.03361629e-01f, 1.28122300e-01f, -4.71066386e-02f, 1.00483303e-03f, -5.20320944e-02f, -1.74482055e-02f, 1.58056036e-01f, -1.14939846e-01f, -8.80906284e-02f, -3.51422429e-02f,
  -1.54530015e-02f, -2.60336041e-01f, -4.51632552e-02f, -1.40151620e-01f, 1.96870297e-01f, -1.33247912e-01f, 1.07633948e-01f, 2.82267164e-02f, 1.07133918e-01f, -1.19962074e-01f,
  9.18427366e-04f, 2.69090496e-02f, -4.35563624e-02f, -1.24077968e-01f, 1.47437170e-01f, -2.27506459e-02f, -2.11404532e-01f, 2.18349025e-01f, 7.75848925e-02f, -1.58587441e-01f,
  -1.07763857e-02f, -5.54042049e-02f, 9.41206664e-02f, -1.44468278e-01f, 2.68997878e-01f, -1.32598698e-01f, -5.20248525e-03f, 1.14211217e-01f, -1.48568958e-01f, 1.84934124e-01f,
  -1.54013500e-01f, 8.93471166e-02f, 1.90630391e-01f, -1.11198379e-02f, 8.50670114e-02f, 1.06152281e-01f, -2.09037870e-01f, -1.06319170e-02f, -7.40829334e-02f, 8.96731243e-02f,
  1.15465164e-01f, -2.62632146e-02f, -9.99892503e-03f, 1.08274832e-01f, -1.04281172e-01f, -1.54898942e-01f, -5.35692312e-02f, -1.95033215e-02f, -8.65880027e-02f, 1.03641160e-01f,
  1.13427266e-01f, -2.08459981e-03f, -2.98396079e-03f, 1.14200406e-01f, 5.09605259e-02f, 1.26777038e-01f, 1.16000315e-02f, 4.04357389e-02f, 1.31009489e-01f, -1.26060367e-01f,
  -1.48392111e-01f, -8.40746462e-02f, 1.45463124e-01f, -1.78949252e-01f, 7.30035976e-02f, -6.85960129e-02f, 9.60060284e-02f, 1.74097538e-01f, 1.40265852e-01f, -2.22871438e-01f,
  1.92433253e-01f, 3.82902175e-02f, 9.57101285e-02f, -8.03176463e-02f, -1.51684448e-01f, -1.89576745e-01f, -1.18037641e-01f, -2.36416049e-02f, -7.47385994e-02f, -2.57291384e-02f,
  -2.90931333e-02f, -1.79905996e-01f, -1.55150697e-01f, 9.88589898e-02f, -1.27831355e-01f, -6.27235249e-02f, -1.13310702e-01f, 6.91381022e-02f, -2.08097279e-01f, 1.35769129e-01f,
  8.68334994e-02f, 8.98036510e-02f, 7.70774037e-02f, -1.60014808e-01f, -7.61741772e-02f, -4.50164974e-02f, -7.04925284e-02f, -2.57425364e-02f, 1.98043570e-01f, 4.21544202e-02f,
  -1.79952249e-01f, 7.19151422e-02f, 1.09546028e-01f, -1.27665654e-01f, -6.38510212e-02f, 1.46501814e-03f, 1.84367478e-01f, 6.32945001e-02f, 9.04570073e-02f, -1.13673888e-01f,
  5.05379848e-02f, 8.43575522e-02f, 1.11974357e-03f, -1.56683743e-01f, -8.40607099e-03f, -8.76238123e-02f, -1.22549213e-01f, 7.80608729e-02f, 8.68160129e-02f, -5.64670451e-02f,
  9.68249701e-03f, -2.19259877e-03f, -1.93575956e-02f, -1.76753536e-01f, 1.97466742e-02f, 4.13329825e-02f, -8.23867321e-02f, 2.49098968e-02f, -3.57434079e-02f, 2.28377089e-01f,
  1.99319109e-01f, -1.02062106e-01f, -1.29979283e-01f, 3.95286940e-02f, -1.10283099e-01f, -4.30376306e-02f, 2.31929123e-01f, -1.84668954e-02f, 1.70874279e-02f, 5.77353984e-02f,
  -1.44404382e-01f, 1.95097119e-01f, -3.41011696e-02f, -1.25989169e-02f, 1.96624011e-01f, -4.22330350e-02f, -8.70968625e-02f, 4.60694581e-02f, 8.61882418e-02f, 1.22749589e-01f,
  6.32555932e-02f, -2.46649119e-03f, -1.70450538e-01f, 4.63145562e-02f, 1.74092315e-02f, -1.42321795e-01f, -3.30529921e-02f, 1.75135233e-03f, -1.06667452e-01f, 1.43106394e-02f,
  -1.99556485e-01f, 3.72431390e-02f, 3.00834142e-02f, -1.16146937e-01f, 1.50711760e-01f, -1.94637090e-01f, 1.33437499e-01f, 1.92921627e-02f, -1.33719727e-01f, 8.65667835e-02f,
  4.52798456e-02f, 7.03452975e-02f, 9.20692384e-02f, 1.14301719e-01f, 1.32084712e-01f, 1.67811230e-01f, -1.83886781e-01f, 2.56548915e-02f, 1.06875286e-01f, 1.05238013e-01f,
  -5.25444523e-02f, -1.18453860e-01f, 3.86098213e-02f, -1.18348084e-01f, 4.99986149e-02f, -9.52052251e-02f, -3.90716866e-02f, 1.51746184e-01f, -1.39577761e-01f, -3.38157676e-02f,
  -8.67136493e-02f, -1.69061899e-01f, 3.54719944e-02f, -2.04717815e-01f, 1.77604675e-01f, 8.32132399e-02f, 2.81157102e-02f, -3.82270701e-02f, 1.21226832e-01f, 2.64628697e-02f,
  -1.11240903e-02f, 1.98085122e-02f, 2.80948393e-02f, 1.59802865e-02f, 6.40965533e-03f, -3.08051296e-02f, -3.12257502e-02f, 2.06118852e-01f, -2.21320048e-01f, 2.26677507e-01f,
  1.07118115e-01f, -2.76017576e-01f, -1.85818136e-01f, 8.06874484e-02f, -1.46094069e-01f, -5.97627200e-02f, 2.35538229e-01f, -3.36089991e-02f, -7.24710971e-02f, 1.34368181e-01f,
  3.60688455e-02f, 7.97135979e-02f, 2.16889396e-01f, -8.04177821e-02f, -5.58990017e-02f, 8.52143466e-02f, -1.55690804e-01f, -6.57043010e-02f, 7.60739343e-03f, 2.34364495e-01f,
  1.13998972e-01f, -5.03997244e-02f, 1.95583761e-01f, -2.97845826e-02f, 3.67963538e-02f, -1.19897567e-01f, -7.30811991e-03f, -1.63161620e-01f, -2.53891721e-02f, 1.27440661e-01f,
  1.21361976e-02f, -1.23734191e-01f, 6.29867315e-02f, 5.45055158e-02f, 1.38460277e-02f, -2.78153382e-02f, 8.62304270e-02f, 1.84086934e-01f, 6.05352819e-02f, 3.15902419e-02f,
  -2.22438145e-02f, -3.85227352e-02f, -1.45426840e-01f, -7.60280415e-02f, -1.03014052e-01f, -5.52463531e-02f, 9.67351720e-02f, -1.15477145e-01f, 1.24892391e-01f, 1.00650132e-01f,
  -1.97961882e-01f, -2.68517006e-02f, -1.29478484e-01f, -1.19116604e-01f, -5.37132956e-02f, -3.13366167e-02f, -8.20935518e-02f, -1.34301633e-01f, 3.62758897e-02f, 1.03898853e-01f,
  -1.48644999e-01f, -2.89482623e-01f, -1.21223770e-01f, -1.22246481e-01f, -1.46159410e-01f, 2.14546949e-01f, -7.76926652e-02f, 2.94087138e-02f, 1.10789821e-01f, 1.98215589e-01f,
  -2.05568254e-01f, 2.67443247e-02f, 7.39975423e-02f, -7.66780674e-02f, 6.23703599e-02f, -1.36560529e-01f, -1.80628803e-02f, -1.53008282e-01f, -4.91246060e-02f, -4.46540564e-02f,
  1.41855076e-01f, 1.36925176e-01f, 2.91574243e-02f, -2.40873754e-01f, -1.31999612e-01f, -2.54498003e-03f, 3.09655815e-02f, -6.99823871e-02f, 1.83073878e-01f, -1.27216592e-01f,
  -2.77304165e-02f, 3.91700603e-02f, -1.56968627e-02f, -1.10869557e-01f, 3.12157976e-03f, 1.19292010e-02f, 6.07559979e-02f, -3.24232094e-02f, 7.74633586e-02f, 1.59801226e-02f,
  -1.12949759e-01f, -3.69299315e-02f, 8.88866186e-03f, -8.98199528e-02f, 3.76416259e-02f, -1.37026042e-01f, 1.22862555e-01f, 4.91369404e-02f, 1.30317569e-01f, -6.36202395e-02f,
  -1.50846139e-01f, 2.41464153e-02f, -2.25960210e-01f, -1.00813106e-01f, -6.90563619e-02f, 5.29177114e-03f, 2.04623602e-02f, -7.78353438e-02f, -1.15233280e-01f, 1.72587633e-01f,
  6.70038676e-03f, -1.02667816e-01f, 3.50511633e-02f, -1.38205066e-01f, -6.37670755e-02f, 6.10073358e-02f, 7.81455338e-02f, -2.15075105e-01f, -7.29398429e-02f, 2.37405837e-01f,
  7.78665468e-02f, -2.79249400e-02f, -1.99128184e-02f, 8.87577832e-02f, -2.60078728e-01f, -9.94736888e-03f, 1.42692268e-01f, -2.88664196e-02f, 1.44064635e-01f, -2.67006166e-04f,
  1.97874457e-01f, -2.19754800e-01f, -6.27432689e-02f, -1.23839483e-01f, 2.18371183e-01f, -1.42376661e-01f, -1.81407370e-02f, -1.40068576e-01f, -4.34238091e-02f, 9.68558714e-03f,
  -6.54428154e-02f, -1.35867804e-01f, -2.88380776e-02f, 2.07591459e-01f, -1.85971707e-01f, -1.53176785e-02f, -4.26827148e-02f, -1.34852067e-01f, 7.48036504e-02f, 5.74672595e-02f,
  5.67338541e-02f, 8.92218724e-02f, -8.41145590e-02f, -1.08651444e-01f, -1.14846185e-01f, -6.12829737e-02f, 8.92753527e-03f, -7.01754633e-03f, 2.26727184e-02f, 8.47312361e-02f,
  -1.23729587e-01f, 1.21731520e-01f, -4.25663851e-02f, 5.74112907e-02f, -8.25191513e-02f, 2.13125661e-01f, 1.16017267e-01f, -2.76462249e-02f, -3.40218395e-02f, 2.71170706e-01f,
  -1.73148334e-01f, -7.57880434e-02f, -8.14744458e-02f, 2.04994366e-01f, 1.93193018e-01f, 8.38625655e-02f, 6.62623122e-02f, -4.24806699e-02f, 3.36959735e-02f, 1.33483991e-01f,
  2.47331187e-01f, 1.93401650e-02f, 9.16278083e-03f, -1.56053677e-01f, 2.21079830e-02f, -4.80385125e-02f, 1.25609651e-01f, -2.58693919e-02f, 5.18929139e-02f, 1.29000500e-01f,
  -4.64322567e-02f, -1.09413788e-01f, -8.30755979e-02f, -9.99378860e-02f, 1.42043307e-02f, 7.36623108e-02f, -1.57443687e-01f, 1.33172199e-01f, -8.48292038e-02f, -9.85082537e-02f,
  -6.66563138e-02f, 1.22672040e-02f, 2.13709787e-01f, 7.40692988e-02f, -1.54532164e-01f, 1.54643819e-01f, -5.36025269e-03f, 1.03239611e-01f, 8.35951567e-02f, 1.86141878e-01f,
  -6.94076195e-02f, -2.06308113e-03f, -6.58248737e-02f, 8.31816252e-03f, -1.23572432e-01f, -9.18872207e-02f, -3.29509489e-02f, -2.88333241e-02f, -2.34375838e-02f, 1.96246564e-01f,
  2.63111778e-02f, 2.98044719e-02f, 1.03060812e-01f, 3.43290195e-02f, -1.77316830e-01f, 8.55629593e-02f, 8.40297490e-02f, -1.25526115e-01f, -2.47040056e-02f, -2.62232661e-01f,
  -6.63528126e-03f, 1.06527381e-01f, -6.14200160e-02f, 4.73447889e-02f, 6.21272251e-02f, -1.15707763e-01f, 7.02068284e-02f, 8.87430459e-03f, -1.22661404e-01f, -1.72484517e-01f,
  3.17291282e-02f, 1.19390018e-01f, 7.31807277e-02f, 4.67295237e-02f, -2.49850988e-01f, -1.60854533e-01f, 2.41856761e-02f, 1.76267475e-01f, -1.17681503e-01f, 6.78286254e-02f,
  5.64986467e-02f, 3.97826806e-02f, -2.39254743e-01f, 1.77592803e-02f, 1.66724607e-01f, 1.05233029e-01f, 1.39562756e-01f, -2.98700519e-02f, 1.86043456e-01f, 6.67137280e-02f,
  -3.35835177e-03f, 7.81608969e-02f, 1.49131194e-01f, 1.41854525e-01f, -9.63331163e-02f, -7.83677772e-02f, -1.27722602e-02f, -1.72642440e-01f, 7.29592470e-03f, -9.14432555e-02f,
  -4.49605845e-02f, -7.04065710e-02f, -1.07293069e-01f, 3.37515362e-02f, 1.03839980e-02f, 1.20573744e-01f, 4.10383604e-02f, -3.82541004e-03f, 2.27570515e-02f, 4.60953377e-02f,
  -2.00698208e-02f, -6.83399290e-03f, 1.14936747e-01f, -1.80270791e-01f, -1.20580398e-01f, 9.38885137e-02f, 1.30647346e-01f, -3.63220423e-02f, -5.91315366e-02f, 5.21155261e-02f,
  2.75827050e-02f, -1.59408644e-01f, -1.49513558e-01f, 1.34597585e-01f, 1.35755152e-01f, 1.14503503e-01f, -3.15248258e-02f, -2.84127802e-01f, -6.74592108e-02f, 7.66679719e-02f,
  2.00464845e-01f, -1.60936698e-01f, -7.84683693e-03f, 1.22329049e-01f, -1.48433462e-01f, 1.97750136e-01f, 8.24048147e-02f, 1.08339414e-01f, 1.55422688e-01f, -9.30638462e-02f,
  -5.23665734e-02f, -8.67704526e-02f, 1.10080214e-02f, -1.65300474e-01f, -9.04378891e-02f, -7.59245604e-02f, -2.56063640e-01f, -1.99615136e-02f, -3.07788476e-02f, -9.76468325e-02f,
  1.20528467e-01f, -5.94172888e-02f, -9.38441157e-02f, 1.15106724e-01f, 2.68226434e-02f, -9.58671272e-02f, -4.47829328e-02f, -2.29762435e-01f, -4.43535671e-03f, 1.14649855e-01f,
  1.48740783e-01f, 3.93346883e-03f, -1.91550449e-01f, -1.34464388e-03f, 6.15150742e-02f, 1.15904016e-02f, 1.41950414e-01f, 2.28830472e-01f, 3.69812101e-02f, -1.35699660e-01f,
  -2.39923783e-02f, -2.29631215e-02f, -4.03468609e-02f, 3.04089114e-02f, 1.45617992e-01f, 7.76972026e-02f, -1.96958050e-01f, -8.86251852e-02f, -2.62529459e-02f, -1.63354948e-01f,
  7.76368901e-02f, 1.40157267e-01f, 3.52436514e-03f, -8.67005624e-03f, -1.09875083e-01f, 7.66714364e-02f, -7.29007870e-02f, -1.89573228e-01f, -1.16331242e-02f, 1.92933634e-01f,
  8.29374865e-02f, -1.53598756e-01f, 8.70084688e-02f, 1.77754447e-01f, -2.25471891e-02f, 8.65881070e-02f, -4.22224589e-02f, 1.91208377e-01f, 8.85080248e-02f, -1.73581466e-02f,
  4.85473536e-02f, 1.00038528e-01f, -1.78091682e-03f, -3.14783789e-02f, 6.66889697e-02f, -1.28257230e-01f, -5.82876727e-02f, -1.33763790e-01f, 1.44104525e-01f, 2.20336288e-01f,
  8.36460069e-02f, 1.03829451e-01f, 9.09920782e-03f, 8.77602398e-03f, 1.47348978e-02f, -7.94379413e-02f, 1.59104303e-01f, -1.48513079e-01f, -2.09426999e-01f, 6.00640923e-02f,
  -1.35818094e-01f, 3.60576175e-02f, 1.77633747e-01f, 2.15074599e-01f, 1.39156789e-01f, 3.87044027e-02f, 5.49671240e-02f, -2.29774594e-01f, 2.10911613e-02f, -1.12854734e-01f,
  -2.33754233e-01f, 1.03035003e-01f, 2.53630131e-02f, 1.00743324e-01f, 9.49731916e-02f, -2.97399471e-04f, -4.74817306e-02f, -1.70060694e-01f, -2.05795560e-02f, -2.51994133e-02f,
  -9.29124132e-02f, -1.23092741e-01f, -1.73625588e-01f, -8.64327848e-02f, 8.91728979e-03f, -9.20853689e-02f, -9.71940756e-02f, -1.26955524e-01f, 1.18538395e-01f, -2.00464763e-02f,
  -9.43436399e-02f, -4.09811027e-02f, 6.84339404e-02f, 5.80292195e-02f, 6.85231984e-02f, -2.34894887e-01f, -1.96820982e-02f, 2.07411602e-01f, -3.08620743e-02f, -1.13282397e-01f,
  -1.11938700e-01f, 2.72802144e-01f, -7.27853775e-02f, -3.02788317e-02f, 2.27501512e-01f, 1.26941465e-02f, 2.40791738e-02f, -1.26484841e-01f, -2.91819945e-02f, 3.87227163e-02f,
  -2.29348592e-03f, -2.02762663e-01f, 6.64928481e-02f, -1.45382926e-01f, 5.40460832e-03f, -1.35826126e-01f, 1.68411583e-01f, 1.95639551e-01f, 6.26600608e-02f, -4.50823866e-02f,
  -1.23603411e-01f, 1.51681870e-01f, 2.55707383e-01f, -6.84572831e-02f, 1.94006898e-02f, -9.12884027e-02f, 2.11995710e-02f, -2.09681299e-02f, -3.11297122e-02f, -4.54115495e-02f,
  -1.03694238e-01f, -9.94855911e-02f, -6.64201677e-02f, -2.81473905e-01f, -2.07771897e-01f, 1.30810708e-01f
};

// L2_fan_Wp_bar (Shape: 26 x 64)
const int L2_fan_Wp_bar_rows = 26;
const int L2_fan_Wp_bar_cols = 64;
const float L2_fan_Wp_bar_data[] = {
  -9.74372029e-02f, -8.50980505e-02f, 9.33495015e-02f, 5.30982250e-03f, -8.10661986e-02f, 5.33155575e-02f, -2.41499156e-01f, 3.03702950e-01f, 4.70336020e-01f, 3.87164578e-02f,
  -2.03983292e-01f, 1.12108022e-01f, -1.21319331e-01f, -4.99727465e-02f, -1.90117419e-01f, 3.65115553e-02f, 2.50102356e-02f, -4.84539181e-01f, 4.54286598e-02f, -1.33469462e-01f,
  5.01710594e-01f, 5.29609323e-01f, -1.88646287e-01f, 1.74652338e-01f, -2.99893349e-01f, 2.08494857e-01f, 1.15409587e-02f, -4.88926880e-02f, 2.20439285e-01f, -1.94209412e-01f,
  -3.97929810e-02f, 1.87446743e-01f, -2.30180293e-01f, -2.69457817e-01f, -2.15297803e-01f, 1.56279221e-01f, 2.67221630e-01f, -2.96663910e-01f, -1.12852223e-01f, 1.72344312e-01f,
  -6.05447516e-02f, -3.33009332e-01f, -1.81825131e-01f, 1.33848041e-01f, -1.51189506e-01f, 8.12481940e-02f, -1.71306357e-01f, -5.31271219e-01f, -4.45646644e-01f, 2.27029845e-01f,
  1.08354378e+00f, -5.00989109e-02f, -3.92291605e-01f, 3.51114064e-01f, 1.34736031e-01f, 1.41179681e-01f, 2.88779795e-01f, 1.39147624e-01f, -1.12115249e-01f, 3.55843008e-01f,
  6.07101142e-01f, -1.68405026e-02f, 3.48519683e-01f, 2.56616101e-02f, -9.59067196e-02f, -2.39761829e-01f, 1.42373621e-01f, 2.28818014e-01f, -2.44801752e-02f, 1.43041700e-01f,
  9.78154242e-02f, 2.38129467e-01f, 9.60926935e-02f, 4.76561636e-02f, -5.76498210e-02f, 3.79958563e-02f, 7.79365748e-03f, 2.51018796e-02f, 1.75849289e-01f, 2.42892072e-01f,
  7.95103163e-02f, -1.65661816e-02f, -1.59827862e-02f, 3.85775149e-01f, -3.00810605e-01f, 1.77601874e-01f, -2.05725744e-01f, 1.47093803e-01f, -3.03168803e-01f, -1.02987692e-01f,
  -2.66439915e-01f, 3.77247751e-01f, -2.34702379e-01f, -2.53594279e-01f, 3.70517761e-01f, -1.64008841e-01f, -2.25221124e-02f, -1.41514940e-02f, 3.85297626e-01f, 4.78256866e-02f,
  -7.83012807e-02f, 8.06507394e-02f, 9.22692195e-02f, -9.31130573e-02f, 1.57697544e-01f, 2.65322030e-01f, -1.93754211e-01f, -5.10999188e-02f, -1.96989477e-01f, -2.16043711e-01f,
  6.45828322e-02f, -1.41975775e-01f, 6.41928380e-03f, 2.23619547e-02f, 1.61767527e-01f, 1.93804465e-02f, -3.02392412e-02f, -1.87999889e-01f, 1.32870674e-02f, 1.95819549e-02f,
  -7.98756108e-02f, 3.51529807e-01f, 1.59719381e-02f, 3.61247897e-01f, 2.50715464e-01f, 4.02973682e-01f, 1.13393717e-01f, 1.72733769e-01f, -3.58990133e-02f, 1.32891789e-01f,
  -6.40667081e-02f, 2.65461624e-01f, 1.20630004e-02f, 3.08152050e-01f, -4.06767614e-03f, 4.47793230e-02f, 6.44012317e-02f, 3.23939323e-01f, 1.03344776e-01f, 2.19171301e-01f,
  -9.61860344e-02f, -1.07630089e-01f, -2.31692061e-01f, -6.37875050e-02f, -3.72965038e-02f, -2.17006311e-01f, 1.91622287e-01f, 1.26850128e-01f, 7.65837282e-02f, 7.22215697e-02f,
  -2.75327832e-01f, 2.35394463e-01f, 4.43249121e-02f, -1.07389191e-04f, 3.90091985e-01f, 3.18072587e-02f, -4.24181558e-02f, -3.69174689e-01f, 8.37458074e-02f, 3.19625348e-01f,
  -1.40334114e-01f, -1.03986591e-01f, 2.54517227e-01f, 4.97925701e-03f, -7.73937106e-02f, 3.21276151e-02f, 1.14089563e-01f, 2.57285327e-01f, 6.71424791e-02f, 8.85039270e-02f,
  2.11242121e-02f, 1.31936982e-01f, -7.34041408e-02f, -1.30727574e-01f, 1.72476292e-01f, -7.12854490e-02f, -2.22543236e-02f, -2.15418428e-01f, -2.59281307e-01f, -1.16921753e-01f,
  -9.20869485e-02f, 7.55595276e-04f, -7.22508505e-02f, 2.92398110e-02f, 1.63304955e-01f, 2.90635061e-02f, -1.79254353e-01f, 2.97797322e-01f, 4.34918970e-01f, 2.99753487e-01f,
  1.06121957e-01f, 6.28103763e-02f, -3.63592841e-02f, 2.31271788e-01f, 9.94663090e-02f, 6.95564132e-03f, 6.68879598e-02f, 2.63512973e-02f, 1.77171975e-01f, 1.54045984e-01f,
  1.32835239e-01f, -1.12221008e-02f, 8.42405260e-02f, 6.39978349e-02f, 2.34199673e-01f, -1.54035851e-01f, 1.34222001e-01f, 5.68164699e-02f, 1.58094257e-01f, 1.32103726e-01f,
  7.01147392e-02f, -2.69355088e-01f, 1.45787165e-01f, -3.20627213e-01f, 1.08367637e-01f, -2.64760852e-01f, 8.98418427e-02f, -1.38405070e-01f, 4.64022964e-01f, -3.08000714e-01f,
  7.56701156e-02f, 1.10114008e-01f, -3.10872376e-01f, 2.81093121e-01f, 3.52125168e-01f, -2.89597631e-01f, -1.85552686e-01f, 1.16720833e-01f, 2.14195430e-01f, -2.21636832e-01f,
  3.10692698e-01f, 4.20524657e-01f, 3.07404906e-01f, -1.19856633e-01f, 2.23342419e-01f, -9.77224410e-02f, 3.24164420e-01f, 7.42270723e-02f, 2.16766879e-01f, 4.06739086e-01f,
  -3.97207707e-01f, 2.61407554e-01f, 4.19339091e-01f, 1.91607162e-01f, 2.20892653e-01f, 3.12733978e-01f, 4.36074845e-02f, -7.83311296e-03f, 2.26411790e-01f, -9.87133458e-02f,
  -1.85107365e-01f, 2.44469166e-01f, -1.82254612e-02f, 5.92916086e-02f, 1.34190574e-01f, -6.26356676e-02f, 1.82870880e-01f, 4.87393700e-02f, -1.43616736e-01f, 1.06313974e-01f,
  1.62707970e-01f, 1.23049408e-01f, -6.79181814e-02f, 1.02561305e-03f, 1.82346836e-01f, -2.45149806e-02f, -2.23139133e-02f, 4.13178764e-02f, 1.02297440e-01f, 7.70939067e-02f,
  8.39068592e-02f, 7.92742595e-02f, 4.99264672e-02f, 5.48805557e-02f, 7.93757439e-02f, 2.94037759e-01f, 2.51569208e-02f, -4.15938705e-01f, 2.11660832e-01f, 5.38315140e-02f,
  -2.18492985e-01f, -2.80137897e-01f, 9.97652486e-02f, -5.90567142e-02f, 4.74714711e-02f, 2.85997421e-01f, 6.05757684e-02f, -3.41190174e-02f, 3.16275917e-02f, -1.10021159e-01f,
  2.38821581e-01f, 1.36304900e-01f, 1.96415782e-01f, -2.40639582e-01f, 3.55771095e-01f, 2.77321815e-01f, 1.45112082e-01f, -1.61101520e-01f, -1.56887829e-01f, 2.37109140e-01f,
  -1.83776051e-01f, -1.29867435e-01f, 7.68435448e-02f, 1.30773410e-01f, -1.86602145e-01f, 3.81912291e-01f, 5.69378912e-01f, 2.53756106e-01f, -2.97509022e-02f, -1.31606922e-01f,
  2.08223358e-01f, -7.78917968e-02f, 2.09953308e-01f, 3.32273811e-01f, -1.90345913e-01f, 3.42209667e-01f, 1.13374643e-01f, 3.42831641e-01f, 3.98681283e-01f, 4.44757566e-02f,
  -2.27478445e-02f, 8.59508440e-02f, -7.92504475e-03f, 1.93671379e-02f, 7.46140033e-02f, 1.54223949e-01f, -4.07873094e-02f, 5.52894324e-02f, 1.69004634e-01f, 1.48921564e-01f,
  7.01279491e-02f, 1.08468048e-01f, 6.33229539e-02f, -5.45218512e-02f, -1.51373953e-01f, 1.13782696e-01f, -4.68681119e-02f, -1.53102010e-01f, 1.52821690e-01f, -1.02771312e-01f,
  1.60193592e-01f, -2.63392687e-01f, 7.63042844e-05f, -7.28265718e-02f, 7.94256926e-02f, -5.14112674e-02f, 4.15932208e-01f, -3.13810050e-01f, 2.12790087e-01f, 6.45762682e-02f,
  -1.14103183e-01f, 3.45855087e-01f, 1.65079981e-01f, -1.80418596e-01f, 1.87576219e-01f, 1.51582107e-01f, 8.81917179e-02f, -2.16935530e-01f, 3.62880439e-01f, 4.43649560e-01f,
  1.58746943e-01f, -2.59396762e-01f, -2.73846924e-01f, 4.91714813e-02f, 1.19613990e-01f, -9.56422165e-02f, 2.20347434e-01f, 1.50705859e-01f, -2.81135827e-01f, 2.20263943e-01f,
  3.34207803e-01f, 9.42277387e-02f, 1.04878843e-01f, 1.00602265e-02f, 1.62804965e-02f, -4.31790315e-02f, 3.81346047e-01f, 1.17662579e-01f, -2.96218842e-01f, 3.11970145e-01f,
  2.07301676e-01f, 9.20005068e-02f, 3.66065830e-01f, 2.72644699e-01f, 2.22879034e-02f, -1.85883746e-01f, -1.60494015e-01f, 3.58438313e-01f, 2.10693598e-01f, 1.72453582e-01f,
  -1.42752498e-01f, -7.50181526e-02f, 1.74235910e-01f, -5.99611402e-02f, -2.57431895e-01f, 6.72793165e-02f, -1.05449110e-01f, 1.43757835e-01f, -5.93825020e-02f, 2.63517916e-01f,
  3.79058063e-01f, -2.24403039e-01f, 1.38062954e-01f, 1.05201192e-01f, -2.60601878e-01f, 1.94382039e-03f, 5.09007014e-02f, 3.97350729e-01f, 1.89367235e-01f, -9.29358043e-03f,
  -5.40081225e-02f, 3.56427670e-01f, -1.77441269e-01f, -1.68786392e-01f, 3.00747305e-02f, -3.40651602e-01f, -2.34670550e-01f, 3.14018458e-01f, 1.09422907e-01f, -8.56109262e-02f,
  -2.09571838e-01f, 1.39639914e-01f, 1.43932194e-01f, -1.26109466e-01f, -1.75738465e-02f, 1.46617323e-01f, -2.47870058e-01f, 2.50225693e-01f, -6.16328493e-02f, 1.25410259e-01f,
  7.83955008e-02f, -9.81749669e-02f, 1.52758345e-01f, -8.63015726e-02f, -1.07480228e-01f, -1.21174216e-01f, 7.96865523e-02f, -2.26189375e-01f, -1.38802022e-01f, 1.41195461e-01f,
  1.69721916e-01f, 1.15029715e-01f, 2.20686391e-01f, 1.52453825e-01f, 2.68874109e-01f, 3.09885710e-01f, 2.90510595e-01f, 2.33063325e-01f, 7.70420805e-02f, 5.55442236e-02f,
  -6.02887459e-02f, -1.14968121e-01f, 2.51977313e-02f, -1.18973833e-02f, -2.47061159e-02f, -4.47801724e-02f, -8.29378143e-02f, 1.70229837e-01f, 1.09444693e-01f, 1.58222377e-01f,
  3.51873711e-02f, 3.47775407e-02f, 7.20857233e-02f, 4.51929271e-02f, -9.23696682e-02f, -1.59189254e-02f, 1.13146104e-01f, 1.72815666e-01f, 2.18494281e-01f, -1.35263488e-01f,
  -6.44139722e-02f, -1.06078021e-01f, 6.26214817e-02f, -3.26916337e-01f, 1.46197319e-01f, -7.38040656e-02f, 2.36841992e-01f, 5.97277395e-02f, -1.20738089e-01f, 2.79456705e-01f,
  -5.98480664e-02f, -2.64000565e-01f, 1.56624392e-01f, 8.28326270e-02f, 3.94785814e-02f, 4.00574133e-02f, 2.99402505e-01f, 1.05967447e-01f, 1.79779276e-01f, 5.93200065e-02f,
  -2.54789352e-01f, 1.61615908e-01f, -1.10047311e-01f, -8.30376446e-02f, 1.32493943e-01f, -9.58955958e-02f, -3.96695435e-02f, 2.38515258e-01f, -3.01892579e-01f, 2.28485644e-01f,
  -2.84362887e-03f, 1.62376225e-01f, 1.84902132e-01f, -6.83160424e-02f, 1.38250038e-01f, 8.91707763e-02f, 2.60016695e-02f, 1.29901260e-01f, 9.64577049e-02f, 2.94519914e-03f,
  1.61129907e-01f, 2.53027707e-01f, -1.10916033e-01f, 8.35466087e-02f, 6.62556067e-02f, 1.29224822e-01f, 1.17629115e-02f, 1.11513942e-01f, 1.41490147e-01f, 3.62118706e-02f,
  -9.38545316e-02f, -4.02704254e-02f, -6.97892532e-02f, -1.61046907e-01f, 1.07834235e-01f, 1.82702556e-01f, -4.91187125e-02f, -3.81831191e-02f, -1.93547886e-02f, -1.68651063e-02f,
  -3.26837339e-02f, -3.07705522e-01f, 2.34134216e-02f, 1.19879305e-01f, -2.29084352e-03f, 1.04990929e-01f, 2.95995146e-01f, 3.82079452e-01f, 1.64197028e-01f, -4.61987108e-02f,
  3.70303765e-02f, 1.14076436e-01f, -2.27250248e-01f, 5.40189892e-02f, -1.32877991e-01f, 3.52806300e-01f, -1.46613955e-01f, 2.53583699e-01f, -1.56263858e-01f, -2.00036705e-01f,
  3.86603326e-02f, -1.47500716e-03f, 1.48427203e-01f, -6.24094270e-02f, 4.01675284e-01f, 1.44071490e-01f, 1.59190536e-01f, 2.94553757e-01f, 1.44891545e-01f, 8.99923146e-02f,
  3.01810443e-01f, 6.07030280e-03f, -2.10644558e-01f, 2.77858751e-04f, -1.48859113e-01f, -8.36542528e-03f, 3.82138416e-02f, 2.43707582e-01f, 3.27555716e-01f, 7.71795958e-02f,
  1.49826318e-01f, -2.01094806e-01f, 8.06460902e-02f, 3.76786813e-02f, -4.71064635e-02f, 4.46009822e-02f, -1.44934794e-02f, 2.60513753e-01f, -3.94657969e-01f, -4.65377420e-02f,
  1.44152805e-01f, 2.41996169e-01f, -1.90661862e-01f, -3.86803821e-02f, -1.29448295e-01f, 3.10921390e-02f, 5.16916215e-02f, 2.26870224e-01f, 1.80768967e-01f, 1.61594063e-01f,
  7.79471174e-02f, -1.71460867e-01f, -1.76197320e-01f, -5.70495240e-02f, 1.11016445e-01f, -1.22861281e-01f, 3.57756823e-01f, -4.84333970e-02f, 2.62161493e-01f, 1.52886927e-01f,
  1.64434090e-01f, 1.63723484e-01f, -2.73944020e-01f, 2.24948764e-01f, 1.24674529e-01f, 1.61882028e-01f, -2.83859402e-01f, 1.08670138e-01f, -2.19278842e-01f, 1.48450017e-01f,
  -2.07266122e-01f, 2.61987060e-01f, 2.85238713e-01f, -1.78514570e-01f, -1.24120481e-01f, -1.26814887e-01f, 5.90176973e-03f, 7.65985176e-02f, 4.31366593e-01f, 2.24804729e-01f,
  1.34619996e-01f, 2.63302565e-01f, -1.04602769e-01f, -1.45791724e-01f, 3.99760604e-01f, 1.93752006e-01f, -3.29131126e-01f, 2.31236354e-01f, -1.35017842e-01f, 3.44347835e-01f,
  2.22300962e-01f, 4.48787451e-01f, -1.48583174e-01f, 1.80515274e-01f, 3.77527803e-01f, 1.29334712e-02f, 1.05273128e-01f, -1.83793128e-01f, -3.58118229e-02f, 6.44780621e-02f,
  1.38009399e-01f, -4.40127887e-02f, -8.85047242e-02f, -8.79003853e-02f, -3.04168705e-02f, 7.49233291e-02f, 1.16409607e-01f, -5.79014681e-02f, -1.42436147e-01f, -1.30169302e-01f,
  1.39400929e-01f, -7.37300068e-02f, 1.17841274e-01f, 1.45401374e-01f, -4.72994484e-02f, 3.12434211e-02f, 2.81713065e-02f, -1.23229824e-01f, 1.03860274e-01f, -3.60410482e-01f,
  1.71868771e-01f, -4.27912436e-02f, 1.09716341e-01f, 2.48627678e-01f, 2.85316288e-01f, 1.80582494e-01f, 2.16754586e-01f, -2.04689294e-01f, 2.78082103e-01f, 5.39888479e-02f,
  -1.98331222e-01f, 4.98846099e-02f, -9.55316946e-02f, 2.70848781e-01f, -1.93086267e-01f, 2.42339760e-01f, 9.95516703e-02f, -2.80183852e-01f, -2.04855092e-02f, 5.36184236e-02f,
  5.93933724e-02f, -2.20302999e-01f, 3.98080498e-01f, 1.81402177e-01f, 1.88135847e-01f, 3.24894965e-01f, 2.03157630e-04f, 1.72554284e-01f, 1.52618140e-01f, 5.13737388e-02f,
  -2.89284855e-01f, 5.07407300e-02f, -2.34102413e-01f, 2.54910499e-01f, -2.65230834e-01f, 3.03060949e-01f, 2.90147275e-01f, 2.30361283e-01f, 2.98870295e-01f, -1.08794384e-01f,
  1.91772811e-03f, -5.65530956e-02f, 1.14151455e-01f, -5.03575094e-02f, 1.74168006e-01f, -1.74960378e-03f, 8.16801861e-02f, 1.30154282e-01f, -3.34686823e-02f, -2.01621100e-01f,
  5.77272624e-02f, 1.24416314e-01f, 3.30934376e-02f, -8.18715245e-02f, -7.65006319e-02f, -1.14137642e-01f, 1.02726161e-01f, -1.50441214e-01f, 8.47713149e-04f, 2.39802152e-01f,
  3.37078512e-01f, 2.64367461e-02f, 1.48040593e-01f, -4.43280414e-02f, -2.93068498e-01f, 2.55123526e-01f, 1.60487264e-01f, -3.22970040e-02f, 2.33527243e-01f, 7.51489103e-02f,
  2.54402999e-02f, 1.91604733e-01f, -3.42723191e-01f, -1.76349610e-01f, 8.24048445e-02f, -2.50401378e-01f, -4.87371534e-02f, 3.96321528e-02f, 1.09129652e-01f, -2.21556500e-01f,
  -3.61496359e-01f, 4.06090170e-01f, -1.27833942e-02f, -8.57584551e-02f, -4.74812128e-02f, 2.75742352e-01f, -4.06895667e-01f, 2.60538697e-01f, 1.58497900e-01f, 1.67118341e-01f,
  1.61125451e-01f, 1.23382166e-01f, 1.51703745e-01f, -2.69901492e-02f, 1.29542083e-01f, -1.69758350e-01f, 2.72815943e-01f, -6.58931360e-02f, -1.69025674e-01f, -1.13649555e-01f,
  3.17216098e-01f, 1.30391389e-01f, 8.99317339e-02f, -6.57385066e-02f, 1.00316741e-01f, 3.80100220e-01f, 1.22113876e-01f, 4.10967916e-01f, -1.20566420e-01f, -5.86298481e-02f,
  1.36846274e-01f, 3.43359560e-01f, -7.20003471e-02f, 1.87970504e-01f, 6.24873862e-02f, 1.63925096e-01f, 1.74983479e-02f, 1.95226252e-01f, -1.73744842e-01f, 1.30601153e-01f,
  -8.49201605e-02f, 7.98901692e-02f, -3.85327786e-02f, 5.47446236e-02f, 2.32334584e-01f, -1.51406959e-01f, 2.81281471e-01f, -8.76453295e-02f, -2.10363403e-01f, 5.24157524e-01f,
  -2.63141990e-01f, 8.32032114e-02f, 2.20423415e-01f, 2.57155150e-01f, 7.83929080e-02f, 1.62758544e-01f, -3.33965182e-01f, -3.50021869e-01f, 7.33768791e-02f, 1.65400639e-01f,
  -3.91249448e-01f, 1.75781742e-01f, -2.09904119e-01f, -1.08400725e-01f, -3.91510367e-01f, 1.55737281e-01f, -1.61407012e-02f, 3.50175947e-02f, -6.66515231e-02f, 3.83005887e-01f,
  3.01440656e-01f, 1.86511740e-01f, 3.41700256e-01f, 1.69786274e-01f, 2.88385093e-01f, -1.23968683e-01f, 1.88183129e-01f, -3.25270116e-01f, -4.47162062e-01f, -3.85631695e-02f,
  9.97021347e-02f, 4.14805979e-01f, 5.50278425e-02f, 1.87878937e-01f, -1.44195810e-01f, -2.36203205e-02f, 1.69819936e-01f, -3.94494049e-02f, 6.21905565e-01f, -6.40169531e-02f,
  -3.81121896e-02f, 1.00001894e-01f, -2.10855782e-01f, 8.68727416e-02f, 1.95162877e-01f, 4.47217226e-01f, 1.36235729e-01f, 3.96068156e-01f, 1.26655221e-01f, -6.33712783e-02f,
  1.10951945e-01f, 2.39137754e-01f, -2.50263568e-02f, 1.82291389e-01f, 5.06233983e-02f, 1.23771399e-01f, -8.98658037e-02f, 9.92040336e-02f, -8.24037194e-02f, 1.45386010e-01f,
  4.13129598e-01f, 5.81972778e-01f, 7.20513910e-02f, 2.15617921e-02f, -3.97167474e-01f, 2.86436170e-01f, -1.27119929e-01f, -7.63796419e-02f, 2.44274676e-01f, -1.06686369e-01f,
  -2.84041911e-01f, -4.11564469e-01f, 2.78827280e-01f, 6.80629984e-02f, -1.45248577e-01f, 6.62840083e-02f, 4.55260217e-01f, -1.68788359e-02f, 1.01228356e-01f, 6.75470161e-04f,
  2.10429922e-01f, 1.92149609e-01f, 2.33083129e-01f, 9.95416269e-02f, 3.80555242e-01f, -1.30016536e-01f, 4.72167097e-02f, -5.36772162e-02f, 4.26196046e-02f, 1.03929862e-01f,
  5.72228990e-02f, -3.80694389e-01f, -5.40357351e-01f, 2.13184148e-01f, -3.52101400e-02f, 6.59362450e-02f, 1.65439710e-01f, 1.13318242e-01f, -2.17340931e-01f, 3.39464545e-02f,
  -6.23810962e-02f, 2.91612372e-02f, 4.51077163e-01f, 1.39209777e-01f, 1.56113997e-01f, 7.00218454e-02f, 1.60297915e-01f, 2.58182108e-01f, -1.62407771e-01f, -1.96657896e-01f,
  1.70372531e-01f, 1.59726694e-01f, 3.37170400e-02f, 1.13645434e-01f, 1.15270026e-01f, 2.16365486e-01f, 7.11735711e-02f, 1.50667638e-01f, -3.68670560e-02f, 5.48466109e-02f,
  -2.32506935e-02f, 6.99796081e-02f, -1.01173937e-01f, -1.19054709e-02f, -4.24041040e-03f, -2.42183894e-01f, 1.65334687e-01f, -1.92024499e-01f, 3.00178528e-01f, 2.27129776e-02f,
  2.90129513e-01f, -1.41990095e-01f, -5.37353642e-02f, 1.13368064e-01f, 1.65571108e-01f, -1.24628879e-01f, -2.68535912e-01f, 7.70600513e-02f, -1.55456454e-01f, 8.17318335e-02f,
  -2.49444153e-02f, 1.08527802e-01f, 1.03014605e-02f, 3.86710279e-03f, -8.10526907e-02f, 5.57279820e-03f, -1.10608883e-01f, 1.31470710e-01f, -2.16448799e-01f, 2.15056360e-01f,
  2.05400288e-01f, 1.41018823e-01f, 1.62253127e-01f, 8.99798498e-02f, 1.73347801e-01f, 1.94385767e-01f, -2.18654066e-01f, 1.11302054e-02f, 1.77437082e-01f, 1.21954963e-01f,
  2.61154562e-01f, -4.94254790e-02f, -4.99546565e-02f, -6.85589537e-02f, 2.51873553e-01f, -9.35171843e-02f, -7.45850503e-02f, 5.27235083e-02f, -6.59837425e-02f, 2.18643248e-02f,
  -5.50068691e-02f, 1.07718796e-01f, 1.11847207e-01f, 3.14737022e-01f, 1.41894966e-01f, 1.73024282e-01f, 2.40201175e-01f, 9.54252109e-02f, 1.32360414e-01f, 3.07399690e-01f,
  6.12013489e-02f, 2.58062799e-02f, 2.13746846e-01f, 1.41581252e-01f, 1.66360140e-01f, 9.60408077e-02f, 1.71430290e-01f, 1.67548195e-01f, 1.40920281e-01f, 3.95655334e-02f,
  -3.61810327e-01f, 5.90815768e-02f, 1.55696258e-01f, -1.59434497e-01f, 2.21977845e-01f, -4.76873778e-02f, 4.15303588e-01f, -1.51819512e-01f, -3.04168612e-01f, -3.78785521e-01f,
  -4.29334715e-02f, -2.24122569e-01f, 2.23501250e-01f, 2.72306595e-02f, -4.72067483e-02f, -7.61299208e-02f, -1.91425011e-02f, 9.84019786e-02f, 5.03462479e-02f, 2.06308782e-01f,
  2.21323803e-01f, 2.34016150e-01f, 4.19227123e-01f, -2.05141813e-01f, 3.64140123e-01f, 3.16762745e-01f, 2.85201311e-01f, 3.16598296e-01f, -1.32087529e-01f, -2.75391489e-01f,
  -5.17129526e-03f, 4.31004949e-02f, 2.32507557e-01f, 3.01674098e-01f, -2.38611966e-01f, 5.90711311e-02f, -1.25394747e-01f, -1.56562328e-01f, 5.27587533e-02f, 1.90739840e-01f,
  3.47789317e-01f, 1.85564145e-01f, 5.91121726e-02f, 1.14354692e-01f, -2.82142758e-02f, -8.75736102e-02f, 6.08946234e-02f, 1.72128901e-02f, 1.45492226e-01f, 8.45658481e-02f,
  1.24050982e-01f, -4.83949715e-03f, -1.78895846e-01f, -1.16667084e-01f, -1.88494427e-03f, -8.75387043e-02f, -2.35996265e-02f, 4.43934239e-02f, 2.13910967e-01f, 2.27675885e-01f,
  2.11259738e-01f, 1.72831163e-01f, -3.35657522e-02f, 2.22696364e-01f, -9.20187458e-02f, -3.18454504e-01f, 2.17050076e-01f, -9.87545401e-02f, 1.36083901e-01f, -1.62855983e-01f,
  6.58567250e-02f, 1.17808364e-01f, 2.60431208e-02f, 2.20231012e-01f, -4.92110907e-04f, -3.46494645e-01f, 1.75487012e-01f, 2.53604800e-01f, 2.42873326e-01f, -1.77627429e-01f,
  -6.01782799e-02f, 1.89739496e-01f, 1.83042094e-01f, -1.36814773e-01f, 6.08520806e-02f, 2.48202652e-01f, -2.50857443e-01f, 1.71895444e-01f, 4.14320938e-02f, 1.06781296e-01f,
  1.49353564e-01f, 1.65366843e-01f, 2.49877989e-01f, 1.33568943e-01f, -2.71969020e-01f, 1.38064563e-01f, 6.90881237e-02f, -3.60920280e-01f, 1.09837241e-01f, -9.22607630e-02f,
  -2.90898904e-02f, 9.74086151e-02f, 3.18632321e-03f, -7.53316209e-02f, -1.70312271e-01f, 1.57829180e-01f, -1.55451745e-02f, 1.22956000e-01f, 1.97265148e-02f, -2.26769030e-01f,
  -9.03145745e-02f, 1.21411450e-01f, 7.51396418e-02f, -2.57705320e-02f, 9.53433663e-03f, -1.22298680e-01f, -1.69978663e-01f, -1.41361386e-01f, 3.63510996e-02f, -2.08231449e-01f,
  4.35978435e-02f, 7.65092298e-02f, 1.62854329e-01f, 7.71531686e-02f, 1.43828169e-01f, 8.99947062e-03f, -6.20229021e-02f, -6.08264320e-02f, -1.84152558e-01f, -1.05135329e-01f,
  1.53329939e-01f, 3.20876479e-01f, 1.09051988e-01f, -7.47891814e-02f, -1.84810162e-02f, 1.70714125e-01f, 5.66911399e-02f, 2.28919342e-01f, 1.86229691e-01f, -2.61930496e-01f,
  8.92495587e-02f, 3.92150164e-01f, 2.49285907e-01f, 5.01509756e-02f, -2.05871627e-01f, -1.97020054e-01f, -8.04333910e-02f, -2.28462070e-01f, 1.63042039e-01f, 7.10115358e-02f,
  1.16760254e-01f, 2.88828850e-01f, -2.09619123e-02f, 1.97537720e-01f, -1.76883151e-03f, 2.47228906e-01f, 2.57208407e-01f, 8.19834843e-02f, -4.71132964e-01f, 2.36639142e-01f,
  -6.19897023e-02f, -3.39930803e-01f, -3.91024239e-02f, 2.43692011e-01f, 1.89595133e-01f, 1.12869501e-01f, 1.20174624e-01f, -1.37886107e-01f, -2.20544592e-01f, 7.47032538e-02f,
  9.00944099e-02f, 2.09019989e-01f, 1.75354049e-01f, 1.12467825e-01f, 4.10304926e-02f, -2.15009496e-01f, 3.33215706e-02f, 9.39165726e-02f, 2.19986200e-01f, -6.59928992e-02f,
  1.00134514e-01f, 1.97906703e-01f, 2.65823066e-01f, 3.95464301e-02f, 2.43364289e-01f, 1.93712506e-02f, 6.93806782e-02f, -1.29308403e-01f, 6.83914497e-02f, -1.95463188e-02f,
  6.69361651e-03f, -4.55193341e-01f, 3.31162959e-01f, -1.12386212e-01f, 3.17668378e-01f, -2.74973989e-01f, 2.70901918e-01f, -2.08073631e-02f, 9.72113088e-02f, -3.76404673e-01f,
  2.32989863e-01f, -1.12048365e-01f, -3.36930096e-01f, 2.83868581e-01f, 2.53825307e-01f, -6.42534718e-02f, -3.79092067e-01f, 2.14091297e-02f, 9.65318382e-02f, -1.59680650e-01f,
  -8.76614675e-02f, 7.41788000e-02f, -2.77266428e-02f, 1.56200439e-01f, 1.46771401e-01f, 1.08770251e-01f, 2.76326060e-01f, 3.96523833e-01f, 1.43426374e-01f, 2.34957084e-01f,
  2.34659538e-02f, 1.05043836e-01f, -1.79058433e-01f, 5.48647158e-02f, 1.38064146e-01f, 2.76731193e-01f, 1.25166297e-01f, 1.54342562e-01f, 1.91164315e-01f, -2.72793882e-02f,
  1.00217126e-01f, -1.90194800e-01f, -1.12279214e-01f, -4.26396914e-02f, 1.11664943e-01f, -2.44738813e-02f, 1.01301193e-01f, 8.42312723e-02f, -1.80788077e-02f, -2.01198980e-01f,
  6.84111565e-02f, 8.00063089e-02f, -9.84130874e-02f, 2.18607143e-01f, 7.76165128e-02f, 9.73520651e-02f, 2.14992061e-01f, 1.14554428e-01f, 9.75270793e-02f, 9.53733772e-02f,
  1.94972083e-01f, -5.89231551e-02f, 4.38681915e-02f, 1.75925463e-01f, 1.11120082e-01f, 6.75881654e-02f, -1.81428492e-01f, -2.17642874e-01f, 2.44450510e-01f, 1.34054080e-01f,
  -1.95863381e-01f, -3.09382677e-01f, -3.00632596e-01f, 8.43644962e-02f, -5.80359586e-02f, -1.39714956e-01f, 1.28526300e-01f, -2.53090281e-02f, 1.61609307e-01f, -1.76667452e-01f,
  -3.13895553e-01f, 6.94201216e-02f, 1.90867022e-01f, -1.39372600e-02f, 9.20444578e-02f, 1.47856832e-01f, -7.30827004e-02f, 2.48753875e-01f, 1.42889405e-02f, 7.31829405e-02f,
  9.88735706e-02f, 7.10344091e-02f, 6.13462478e-02f, -2.92729028e-02f, 3.94016951e-02f, 2.27697745e-01f, 3.61257732e-01f, 5.77382930e-03f, 2.91727811e-01f, 4.72831607e-01f,
  1.00380808e-01f, -1.86679572e-01f, -2.97874331e-01f, 8.01700260e-03f, 1.71196863e-01f, 3.04042399e-01f, -3.02278280e-01f, 2.33915508e-01f, -5.52241430e-02f, -1.77953139e-01f,
  2.89070308e-02f, 1.27126470e-01f, 3.91087122e-02f, -2.01465026e-01f, 1.18025534e-01f, -6.73069358e-02f, -1.33836572e-03f, 8.40612650e-02f, 2.33201876e-01f, -5.42592965e-02f,
  6.19291924e-02f, 6.44141212e-02f, 1.93921581e-01f, -2.82234013e-01f, -9.85375866e-02f, 4.52028289e-02f, -1.49747143e-02f, -9.85125378e-02f, -4.63998094e-02f, -6.27516676e-03f,
  -8.30646157e-02f, 1.32875487e-01f, 4.53878902e-02f, -1.53671801e-01f, 2.79512793e-01f, -1.54720910e-03f, 9.78898555e-02f, -1.50103211e-01f, -3.39491591e-02f, -1.57372087e-01f,
  -2.11093083e-01f, 2.05054626e-01f, -1.12689426e-02f, -4.44468185e-02f, 8.89215320e-02f, -4.78073955e-01f, -4.67050821e-01f, 4.53815669e-01f, 1.22872189e-01f, 3.46978493e-02f,
  -1.72920600e-01f, 1.22049034e-01f, -4.22797292e-01f, 3.18257064e-01f, 1.25199929e-01f, 3.18844393e-02f, 3.28795105e-01f, -7.29228631e-02f, 1.48395956e-01f, 1.22194327e-01f,
  -7.64683560e-02f, -2.45333955e-01f, 2.65809685e-01f, -1.10421054e-01f, 1.06288426e-01f, -3.81116793e-02f, 2.00098574e-01f, -7.93411061e-02f, 1.13608740e-01f, 7.38728270e-02f,
  2.42995948e-01f, 4.52027731e-02f, 1.65610060e-01f, 4.29210365e-01f, 4.87255827e-02f, 9.03944150e-02f, 6.93343282e-02f, 2.80766226e-02f, -6.14733063e-02f, 1.57227188e-01f,
  9.55033824e-02f, 1.33885210e-02f, -9.55797210e-02f, 1.38563365e-01f, -2.37575676e-02f, 1.09346256e-01f, -6.84282184e-03f, 1.67902768e-01f, -3.78472283e-02f, 1.85348690e-01f,
  1.44009009e-01f, -3.86596732e-02f, 2.17295304e-01f, 6.00190051e-02f, -1.66232646e-01f, 4.12682295e-02f, -4.49283049e-02f, 5.89335635e-02f, 2.14903936e-01f, -2.43971586e-01f,
  -6.59665987e-02f, 2.93967962e-01f, -1.43589079e-01f, -1.11980736e-01f, 8.53164569e-02f, 6.25529283e-05f, -1.31797001e-01f, 1.27893528e-02f, 1.50909767e-01f, -2.06779674e-01f,
  -1.69519305e-01f, 3.19024682e-01f, -5.91421537e-02f, -1.20532624e-01f, 1.69676095e-02f, 2.88252294e-01f, -4.21844721e-01f, 2.69954860e-01f, 7.03220069e-02f, 1.43820137e-01f,
  1.46104500e-01f, 6.59275576e-02f, 2.38415882e-01f, -1.38908997e-01f, -3.66329938e-01f, -8.79255757e-02f, 3.06476623e-01f, -1.37683585e-01f, 3.17891747e-01f, -2.18721479e-01f,
  -2.58181244e-01f, 1.60980165e-01f, 3.10520887e-01f, -6.95977658e-02f, 1.76810026e-01f, -5.12829237e-02f, -8.76245201e-02f, 2.47210488e-01f, -4.73092757e-02f, -1.24887019e-01f,
  -6.04102388e-02f, -1.03445895e-01f, -2.80125234e-02f, 5.83817400e-02f, 9.28937867e-02f, 7.79578984e-02f, -2.98087560e-02f, 4.82656546e-02f, 9.64423940e-02f, 1.15042321e-01f,
  1.35713201e-02f, 1.27072424e-01f, -2.16275513e-01f, 9.88271907e-02f, -3.79124582e-01f, -4.76348810e-02f, 1.02149211e-01f, 1.54548883e-01f, 4.54438835e-01f, 9.16819423e-02f,
  -3.14398140e-01f, 2.10155562e-01f, -1.33021325e-01f, -1.90915823e-01f, -1.64533466e-01f, 1.00012101e-01f, 3.13616365e-01f, 2.90870219e-01f, 2.53658712e-01f, 3.76492888e-01f,
  -2.74806410e-01f, -1.42517105e-01f, 7.93897584e-02f, 6.42536059e-02f, 5.49154133e-02f, 8.39762837e-02f, 1.62617266e-01f, 1.23903222e-01f, 1.13932729e-01f, 2.64355987e-01f,
  -1.31718680e-01f, 2.51223380e-03f, -1.38703346e-01f, -1.08167574e-01f, -1.42887205e-01f, -2.79918909e-01f, 1.95416629e-01f, 2.60134339e-02f, -1.00111105e-01f, 2.79609561e-01f,
  -2.85792857e-01f, -7.76157454e-02f, 2.78218538e-01f, -3.06237955e-02f, 5.35213351e-02f, 3.27559948e-01f, 1.40522256e-01f, 1.41705386e-02f, 4.69761878e-01f, -2.30058074e-01f,
  7.75554255e-02f, -1.04648876e-03f, -4.88050506e-02f, -3.37315768e-01f, 2.63102800e-02f, -2.78938599e-02f, -2.21614633e-03f, 1.19609319e-01f, 1.47274762e-01f, 8.38505477e-02f,
  -1.13694005e-01f, -1.29624218e-01f, 4.02216846e-03f, -2.96515282e-02f, -8.41495246e-02f, 2.38407448e-01f, 2.03108743e-01f, 2.22468793e-01f, -6.46089390e-02f, 1.93192303e-01f,
  -1.45621717e-01f, 2.23561600e-01f, -2.76372194e-01f, -2.85269260e-01f, 4.90063652e-02f, 2.89928168e-01f, 1.39130130e-02f, -2.68586874e-01f, -4.35821235e-01f, 3.45335752e-01f,
  7.12227225e-02f, 5.42793423e-03f, 3.88080716e-01f, -3.96057934e-01f, 2.70026140e-02f, 2.93837249e-01f, 2.17401370e-01f, 2.19608873e-01f, 1.51358217e-01f, -2.05713183e-01f,
  2.43630648e-01f, -1.54713662e-02f, 1.44659013e-01f, 6.38776645e-02f, -1.22313621e-02f, 1.18479475e-01f, -1.45234257e-01f, 1.82989493e-01f, -1.40145600e-01f, 4.37913928e-03f,
  3.08652192e-01f, 1.97559416e-01f, 2.87045926e-01f, 2.73995310e-01f, -2.22400203e-03f, -1.60744205e-01f, 1.80811629e-01f, 3.95365851e-03f, -9.49460641e-02f, 3.77678335e-01f,
  2.75188118e-01f, 2.79325753e-01f, -2.43276432e-01f, 3.03182304e-01f, 3.79811265e-02f, 1.80271998e-01f, -8.55237469e-02f, -1.35295209e-03f, 1.69464082e-01f, 1.94215730e-01f,
  -7.89181367e-02f, -2.04369798e-03f, 1.90818861e-01f, 1.31883651e-01f, -5.71380556e-03f, 1.76868647e-01f, 1.04056217e-01f, -2.73600919e-03f, -9.30238068e-02f, 3.49221736e-01f,
  1.08843289e-01f, 6.73587841e-04f, -2.21569791e-01f, 1.04142740e-01f, 3.83330713e-04f, 1.04570456e-01f, -5.20793535e-02f, -1.95406470e-02f, -4.42964919e-02f, 3.82430911e-01f,
  -3.57620358e-01f, -7.99602047e-02f, -2.72247285e-01f, 2.94505149e-01f, -1.24955714e-01f, -1.35081053e-01f, 3.40276092e-01f, -1.52528241e-01f, -1.62722215e-01f, -1.32425223e-03f,
  -3.18960965e-01f, 2.09462866e-01f, 3.69932383e-01f, -4.12970752e-01f, 5.04853539e-02f, 1.68960273e-01f, 2.66708821e-01f, 1.41034365e-01f, 4.06266719e-01f, -6.83579296e-02f,
  -1.08428627e-01f, 2.51840353e-01f, -2.08261371e-01f, -7.69031048e-02f, 6.31443411e-02f, 4.27641012e-02f, 1.02721415e-01f, 2.17394441e-01f, -1.37142196e-01f, 4.42314088e-01f,
  -4.60475124e-02f, 2.15767890e-01f, -1.72356829e-01f, 3.10758024e-01f, 3.50979686e-01f, 3.24689239e-01f, 2.01122072e-02f, 1.09016344e-01f, -3.17737609e-02f, -3.24424833e-01f,
  -4.59730215e-02f, -1.11179031e-01f, 5.65439127e-02f, 1.34992301e-01f, 1.26069799e-01f, 1.50772417e-02f, -6.56019896e-02f, 1.52297378e-01f, 7.08285719e-02f, 6.54245317e-02f,
  -6.00512549e-02f, 9.23786536e-02f, -1.59798563e-02f, -2.36908495e-02f, -1.98486242e-02f, -2.12839525e-02f, -1.78829968e-01f, 8.52201954e-02f, 8.16944335e-03f, 2.49989435e-01f,
  3.60391326e-02f, 2.83705264e-01f, -2.08643302e-01f, 1.50502175e-01f, -6.21132669e-04f, -5.06269485e-02f, -1.97477415e-01f, 3.44280332e-01f, 9.63388160e-02f, 9.42987110e-03f,
  2.97960907e-01f, -4.56125401e-02f, -7.30926245e-02f, 1.69738069e-01f, 2.74082214e-01f, -1.89634413e-01f, -4.19257209e-03f, 3.21641192e-02f, -6.26153406e-03f, -4.34407257e-02f,
  2.01153353e-01f, 7.43526965e-02f, -2.79594421e-01f, 2.48054355e-01f, -2.86759079e-01f, -1.87583268e-01f, -4.07415144e-02f, -1.86895832e-01f, 2.51771957e-01f, 1.31694168e-01f,
  1.24281317e-01f, 2.60696858e-02f, -1.01515956e-01f, -1.99572861e-01f, 3.54473233e-01f, -5.32642789e-02f, 7.56577328e-02f, 8.14874098e-02f, -4.35421690e-02f, 1.94227517e-01f,
  3.00401032e-01f, -1.17704920e-01f, -2.03852076e-02f, 2.09390551e-01f
};

// L2_fan_Bp_bar (Shape: 1 x 26)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 26;
const float L2_fan_Bp_bar_data[] = {
  -8.00917670e-02f, 1.79650724e-01f, 4.18486036e-02f, 1.58424065e-01f, -1.93984583e-02f, 1.39707118e-01f, 3.79333436e-03f, 1.25239924e-01f, 1.15460284e-01f, -2.70787738e-02f,
  1.34881288e-01f, -3.59499082e-02f, 2.36385182e-01f, -6.78064302e-02f, 1.38789296e-01f, 2.11072356e-01f, 4.02777828e-02f, 1.67294011e-01f, 7.99587891e-02f, 2.12781262e-02f,
  -1.83820017e-02f, 2.00236201e-01f, 1.19095430e-01f, -1.13894697e-02f, 1.64576352e-01f, -2.05719788e-02f
};

// L3_linear_W (Shape: 12 x 64)
const int L3_linear_W_rows = 12;
const int L3_linear_W_cols = 64;
const float L3_linear_W_data[] = {
  -5.35187833e-02f, -1.51759083e-03f, 8.46396238e-02f, 2.05220401e-01f, 2.42962107e-01f, 1.75208688e-01f, 1.05021611e-01f, 6.39570653e-02f, -1.43150166e-01f, -1.37812439e-02f,
  1.57937810e-01f, -1.00465044e-01f, -1.99867543e-02f, 2.25099102e-01f, -7.22033754e-02f, 8.86793435e-02f, -1.35497674e-01f, -9.48432274e-03f, -1.48539454e-01f, 1.01311691e-01f,
  1.11385070e-01f, -2.84436028e-02f, -8.94949660e-02f, 1.51490867e-01f, 1.64908990e-01f, -2.04838142e-01f, 1.83794439e-01f, 2.24340141e-01f, -1.91466764e-01f, 5.25477529e-02f,
  -1.78921610e-01f, -2.39761993e-01f, -9.83801037e-02f, 2.49960169e-01f, -3.38927507e-01f, -8.52694437e-02f, -8.68438110e-02f, 2.39863638e-02f, 2.57517278e-01f, 3.20406914e-01f,
  -1.81535274e-01f, 4.60609794e-03f, 1.21062323e-01f, -1.73123274e-02f, -1.97070427e-02f, -8.64820182e-02f, -3.41183543e-01f, -7.21420228e-01f, -1.21361852e-01f, 5.33808358e-02f,
  -2.43312553e-01f, -2.57599741e-01f, -2.67689377e-01f, 3.87909706e-03f, -2.68199164e-02f, -3.99879664e-02f, -2.80816674e-01f, 2.70815998e-01f, -5.54944694e-01f, -2.07789272e-01f,
  -4.61166084e-01f, 2.63938844e-01f, 2.89368987e-01f, -1.60347983e-01f, 1.39604107e-01f, 2.09647804e-01f, -5.18041067e-02f, 1.47180095e-01f, 1.02546237e-01f, -1.33975474e-02f,
  -1.10185184e-02f, 6.19845688e-02f, -1.44960195e-01f, 1.55902192e-01f, 2.16318339e-01f, 6.34954274e-02f, -5.12946770e-02f, -1.00336403e-01f, 8.44940171e-02f, 9.67021063e-02f,
  -3.61699052e-02f, 9.17822719e-02f, -1.20710470e-01f, -3.68188531e-03f, -3.13477546e-01f, -1.77942872e-01f, 9.84782130e-02f, 1.60749711e-03f, -7.11094737e-02f, -9.40431841e-03f,
  1.23019256e-01f, -1.22016624e-01f, -1.81893427e-02f, -1.18542816e-02f, -2.59934932e-01f, -5.83853200e-02f, 2.38671556e-01f, 2.57540405e-01f, 2.50922948e-01f, -1.94259256e-01f,
  1.51140183e-01f, -3.62120718e-02f, -9.60410416e-01f, 2.36064553e-01f, 9.08848364e-03f, -4.34360772e-01f, -1.95310831e-01f, -4.20694947e-01f, 1.03120260e-01f, -8.89235958e-02f,
  -3.95826325e-02f, -1.62603304e-01f, -2.34566137e-01f, 1.25852004e-01f, 8.58733207e-02f, 1.20828070e-01f, -2.92918943e-02f, -4.37794775e-02f, 2.41493747e-01f, 1.88420743e-01f,
  -2.85686761e-01f, -7.61926770e-02f, -4.84733358e-02f, 2.42487624e-01f, -1.31107852e-01f, 2.09135607e-01f, -9.43015441e-02f, 2.75133759e-01f, -9.45826396e-02f, -2.62883246e-01f,
  -4.70712148e-02f, 1.40219107e-01f, 4.61995602e-02f, 3.56616378e-02f, 8.54563341e-02f, 1.62754104e-01f, 1.72594309e-01f, -2.22324848e-01f, -1.35311529e-01f, -1.20711818e-01f,
  5.25522120e-02f, 5.19626625e-02f, 1.58836141e-01f, -1.67170987e-01f, -5.11971815e-03f, 5.66519350e-02f, 1.89254686e-01f, -2.33491451e-01f, 6.78490847e-02f, 1.52314827e-01f,
  -4.71370555e-02f, 3.02500159e-01f, 2.30342150e-01f, 2.74495613e-02f, -2.65534930e-02f, -5.34515604e-02f, 1.80815428e-01f, -2.72064626e-01f, 3.02332669e-01f, 1.44984663e-01f,
  1.85100734e-01f, -3.74780089e-01f, 5.31772003e-02f, -2.24675328e-01f, 8.59619454e-02f, -1.40672579e-01f, -5.18928349e-01f, -2.61948586e-01f, -2.74957389e-01f, -4.00968045e-01f,
  -3.63074362e-01f, -4.63920176e-01f, 2.36541823e-01f, -4.15826738e-01f, 1.18515372e-01f, 3.62062901e-01f, 1.91688687e-01f, 2.05788016e-01f, 2.11189061e-01f, -8.19529831e-01f,
  1.55232921e-01f, -1.59096137e-01f, -5.05510792e-02f, 4.84281927e-02f, -1.06355488e-01f, -7.10545061e-03f, 1.04596660e-01f, 1.76932797e-01f, -5.51348686e-01f, -1.44592989e-02f,
  -5.87509610e-02f, -2.20633045e-01f, 1.19036987e-01f, -1.84990063e-01f, 8.58558714e-02f, -1.97407305e-01f, -9.90018696e-02f, -8.90633911e-02f, -4.43511829e-02f, 8.95406678e-02f,
  1.13087565e-01f, 1.06354319e-02f, -2.42565572e-01f, -1.38995767e-01f, 7.67296925e-02f, -1.28726676e-01f, 2.22099237e-02f, -8.84028897e-02f, 8.40965882e-02f, 8.98127779e-02f,
  1.66928828e-01f, 2.01749146e-01f, 7.81321749e-02f, 3.39201808e-01f, -1.18341662e-01f, 1.28364444e-01f, -1.77324072e-01f, -2.28281379e-01f, -3.65488797e-01f, 1.40231242e-02f,
  -1.71841048e-02f, -1.05718095e-02f, -1.61922649e-01f, -1.18552476e-01f, 7.22301602e-02f, 9.10078641e-03f, -1.94014981e-01f, 1.91378564e-01f, -1.51020274e-01f, 1.92039995e-03f,
  8.91325474e-01f, 7.68545419e-02f, -2.64674962e-01f, 1.49792865e-01f, 2.19152212e-01f, 2.03294799e-01f, -4.17691439e-01f, 4.05010097e-02f, -2.77377367e-01f, -1.78887010e-01f,
  -3.51532161e-01f, -4.07764614e-01f, -3.16417545e-01f, -4.47835386e-01f, -2.35626161e-01f, -6.11670494e-01f, -6.97617009e-02f, -2.74311781e-01f, -2.79621840e-01f, -3.80816907e-02f,
  -7.90623575e-02f, -3.87628824e-01f, 9.32219252e-02f, 2.03587487e-02f, -9.63748544e-02f, 2.29487866e-01f, -1.16312485e-02f, 1.77368184e-03f, 9.12692696e-02f, -1.74687743e-01f,
  -3.26362662e-02f, 2.00060830e-01f, 1.71685711e-01f, -1.34164393e-01f, -1.60010383e-01f, 1.32775277e-01f, 8.88238847e-02f, 1.59790918e-01f, 1.14992552e-01f, -2.57336795e-01f,
  2.52482921e-01f, 4.63358313e-02f, -1.40353754e-01f, -7.04810722e-03f, -1.45525232e-01f, 2.84081638e-01f, 1.14249587e-01f, 7.51962140e-02f, 1.27215460e-01f, -2.02619344e-01f,
  -2.77667075e-01f, -9.33573768e-02f, 2.48182654e-01f, 1.18032269e-01f, -2.28064269e-01f, 1.98086381e-01f, 7.69085214e-02f, -8.74659270e-02f, -9.53184515e-02f, 7.07187578e-02f,
  1.84255943e-01f, -2.28457838e-01f, -2.84524113e-01f, -8.43067616e-02f, 1.39353275e-01f, -2.90628076e-01f, 1.28731262e-02f, 2.47817457e-01f, 8.09155330e-02f, 1.71607152e-01f,
  -5.21784067e-01f, 1.58699900e-01f, -9.61889327e-02f, 6.88376650e-02f, 6.15783893e-02f, -4.47751492e-01f, -3.34206402e-01f, -2.31647477e-01f, 1.85937062e-01f, -9.89164561e-02f,
  -1.96018696e-01f, -2.84866780e-01f, 2.33867496e-01f, 2.31065616e-01f, -2.95112252e-01f, -2.61456043e-01f, -1.50505543e-01f, -3.38220857e-02f, 8.72097015e-02f, -3.77064854e-01f,
  -7.72290453e-02f, 6.53987676e-02f, -6.21519871e-02f, 1.21166959e-01f, 1.24297053e-01f, 1.69459015e-01f, 6.34995773e-02f, 1.94221903e-02f, 1.29801273e-01f, 2.01489497e-02f,
  -1.79062918e-01f, -1.50323451e-01f, 1.44950166e-01f, 1.21013805e-01f, 2.46462777e-01f, 1.85135722e-01f, 1.09711580e-01f, -9.55486819e-02f, -3.86437625e-02f, 1.33131772e-01f,
  2.12086156e-01f, 2.33293071e-01f, -9.09442604e-02f, -1.65809408e-01f, 5.31679168e-02f, 3.07652771e-01f, 1.33299842e-01f, -4.18140441e-02f, 1.86034665e-01f, 1.38541222e-01f,
  -1.97404921e-01f, 1.40142918e-01f, 1.79003671e-01f, 1.28572315e-01f, 1.44820452e-01f, 1.67297825e-01f, -1.79545060e-01f, -4.57265638e-02f, -8.83979201e-01f, 1.07181557e-02f,
  1.88742593e-01f, 1.60797268e-01f, 1.12892650e-01f, 1.97216257e-01f, 6.64389729e-02f, 8.69234800e-02f, -3.06933194e-01f, -6.99037910e-01f, -2.87329316e-01f, 9.63001028e-02f,
  -8.88976008e-02f, 2.50348985e-01f, -4.39577848e-02f, 1.64108261e-01f, 1.02390729e-01f, -2.03161120e-01f, -1.75333589e-01f, -3.32480036e-02f, 1.09513476e-01f, 6.88213781e-02f,
  -5.37542641e-01f, -2.15173557e-01f, -3.66408110e-01f, -2.65296072e-01f, 1.06920868e-01f, -2.11257190e-01f, 1.87260240e-01f, 1.32236570e-01f, -2.52739284e-02f, -1.48986867e-02f,
  -1.38405219e-01f, -1.57991901e-01f, 1.90302864e-01f, -1.94724739e-01f, 1.78479433e-01f, 4.64120582e-02f, -1.46475166e-01f, 9.84868314e-03f, -2.18256384e-01f, -1.36254370e-01f,
  1.23993337e-01f, 8.18894058e-02f, 2.00798526e-01f, 1.85941473e-01f, -2.36554936e-01f, -1.21510878e-01f, -5.09404652e-02f, -2.71623194e-01f, 2.44391054e-01f, 2.98087239e-01f,
  1.78520486e-01f, 1.93238840e-01f, 2.08624646e-01f, -7.39139915e-02f, -3.78226221e-01f, 1.90665394e-01f, 3.19616973e-01f, -2.63626009e-01f, -3.62232588e-02f, -1.70362279e-01f,
  2.59137809e-01f, 3.00898731e-01f, -2.70967744e-02f, -2.90282845e-01f, -3.28596205e-01f, 1.17893726e-01f, -3.34644943e-01f, -9.43949148e-02f, -2.82285690e-01f, 1.66522451e-02f,
  -9.99996141e-02f, -3.31460774e-01f, -1.66101396e-01f, 2.31869832e-01f, 1.06073961e-01f, -5.99211931e-01f, 1.61943555e-01f, 1.45365968e-01f, 3.25340480e-02f, -2.28066698e-01f,
  2.81579703e-01f, 1.97650194e-01f, 3.17509025e-01f, 2.46605322e-01f, -1.95620060e-01f, -4.83412594e-01f, -4.89479393e-01f, -2.35982120e-01f, -1.42752072e-02f, 1.02512382e-01f,
  7.46297687e-02f, 1.77048817e-01f, -7.09986240e-02f, 1.14888638e-01f, 7.58735016e-02f, -5.29333437e-03f, 1.10901207e-01f, 8.66077468e-02f, -1.17977269e-01f, 5.34713455e-03f,
  -8.57077315e-02f, -1.24659739e-01f, -1.03213705e-01f, 1.07786223e-01f, -5.27745783e-02f, 1.21343449e-01f, -1.62309811e-01f, -1.25247613e-01f, 2.28239626e-01f, 1.23138577e-01f,
  1.52727559e-01f, -1.66560024e-01f, -1.99442744e-01f, -1.66355565e-01f, 1.57945693e-01f, -3.06786090e-01f, -2.02931076e-01f, 1.18212685e-01f, -1.51106030e-01f, 2.77746558e-01f,
  -1.40549973e-01f, 1.00191012e-01f, -7.84196109e-02f, -1.40180916e-01f, 1.28894791e-01f, 4.02946845e-02f, 4.54922318e-01f, 8.06011185e-02f, 1.53799400e-01f, -9.63011384e-02f,
  -1.36613250e-01f, 3.12337223e-02f, -3.11656594e-01f, 1.09202735e-01f, -1.60273105e-01f, -2.25753933e-01f, -1.03454962e-01f, -3.12192857e-01f, 2.15995938e-01f, 3.98898721e-01f,
  -3.48898679e-01f, -1.30872339e-01f, -3.79646987e-01f, -2.63272464e-01f, -2.53824681e-01f, -1.72434658e-01f, -3.51675987e-01f, 3.98462899e-02f, 2.49092147e-01f, -1.23817801e-01f,
  2.26350069e-01f, 9.97493938e-02f, -2.05772355e-01f, 6.46891668e-02f, -1.01625934e-01f, -2.35829338e-01f, 1.45958569e-02f, 6.37910888e-02f, -1.80257320e-01f, 1.06232546e-01f,
  6.88491762e-02f, -1.84450209e-01f, -6.18165843e-02f, 2.09484901e-02f, 2.78639104e-02f, 4.12127115e-02f, -1.48794279e-01f, -5.75331002e-02f, -1.83988661e-01f, 3.86267900e-02f,
  -2.35575765e-01f, -1.43348157e-01f, -2.35681087e-01f, -1.51375175e-01f, -8.45476761e-02f, 2.53736436e-01f, -1.53106585e-01f, 1.94813475e-01f, -1.11010656e-01f, -2.43446544e-01f,
  1.78762972e-01f, 5.86254299e-02f, 2.53173649e-01f, -1.13411792e-01f, -1.93080842e-01f, 2.99467631e-02f, 9.90795158e-03f, 2.21035868e-01f, 1.08788460e-02f, -2.30815895e-02f,
  8.01544607e-01f, 3.14507820e-02f, 2.65470982e-01f, -2.98636675e-01f, -2.04072576e-02f, 9.46728513e-02f, 7.12600201e-02f, 8.34038556e-02f, 1.68855965e-01f, 2.59951688e-04f,
  1.62319779e-01f, 1.25131443e-01f, 5.91859780e-02f, -3.78844202e-01f, 5.36827445e-02f, -3.03440720e-01f, -3.62534255e-01f, -7.79955015e-02f, 6.90405890e-02f, -2.69337207e-01f,
  1.82915434e-01f, -1.54273346e-01f, -2.40793929e-01f, -3.06662053e-01f, -2.84191132e-01f, 7.67340213e-02f, 1.33712232e-01f, 1.15861848e-01f, 2.47961190e-02f, -8.59199688e-02f,
  2.27354467e-01f, -1.55379981e-01f, 1.99770331e-01f, -2.09883362e-01f, -2.53719121e-01f, 9.80423838e-02f, -1.83852986e-01f, -1.13991879e-01f, 1.67536438e-01f, 1.07821815e-01f,
  -2.60130130e-02f, 8.13631266e-02f, -3.21272984e-02f, 7.20366091e-03f, 2.24158779e-01f, 3.86593826e-02f, -8.76340345e-02f, -1.72280908e-01f, -1.00539252e-01f, -4.28636558e-02f,
  2.12254122e-01f, -2.57755890e-02f, 6.54924437e-02f, 1.28647700e-01f, 7.74863660e-02f, -3.60743582e-01f, 3.84009361e-01f, -1.17766991e-01f, -3.62897366e-01f, -1.94776863e-01f,
  2.94297338e-01f, -4.55770083e-02f, 2.12212041e-01f, 2.03398123e-01f, -1.06123161e+00f, -1.87344730e-01f, -2.20346183e-01f, 1.12066656e-01f, -3.30033809e-01f, -2.08857223e-01f,
  -2.47791991e-01f, -3.81985456e-01f, 2.93307364e-01f, 2.23266020e-01f, 2.11116418e-01f, -2.44206771e-01f, 1.19464621e-01f, 2.25201547e-01f, -6.65561035e-02f, 2.76749521e-01f,
  -7.64292181e-02f, 1.69571843e-02f, 1.62313789e-01f, -8.18235502e-02f, -5.22070110e-01f, -1.74737602e-01f, -1.64986789e-01f, -2.49636710e-01f, 1.25900611e-01f, -2.08441153e-01f,
  9.34959725e-02f, -3.51804644e-02f, -4.65107486e-02f, 1.26152225e-02f, -1.11479953e-01f, -1.39965057e-01f, -4.86510098e-02f, 3.16072209e-03f, 2.22178832e-01f, -1.47757292e-01f,
  2.07563024e-02f, 1.52059257e-01f, 2.43619960e-02f, -6.54203072e-02f, -9.11689401e-02f, 2.12811981e-03f, 7.01186210e-02f, 8.01934488e-03f, -2.32048139e-01f, -2.69440800e-01f,
  1.89288005e-01f, -9.62573588e-02f, -1.99587956e-01f, -7.84422904e-02f, -1.75345272e-01f, -2.47680619e-01f, -1.30889565e-01f, -1.24681793e-01f, -2.59255558e-01f, 6.01020046e-02f,
  1.82490557e-01f, -9.92158875e-02f, -2.21837580e-01f, 5.47918119e-02f, -2.10868359e-01f, -1.70754194e-01f, 2.02662721e-01f, -5.10300696e-02f, -5.98166943e-01f, -2.64138952e-02f,
  -3.45897377e-01f, -2.53347874e-01f, 4.39640172e-02f, -2.18441859e-01f, -1.61563933e-01f, 2.19139978e-01f, -5.19605130e-02f, 4.15684313e-01f, 4.61355783e-02f, -3.34954381e-01f,
  -4.20021564e-01f, -1.74955472e-01f, 2.43193105e-01f, -4.90456462e-01f, 1.08374655e-01f, 1.59794465e-01f, 3.37420627e-02f, 1.07557610e-01f, -2.46168539e-01f, 1.56780824e-01f,
  7.07552508e-02f, 2.00341150e-01f, 9.78235379e-02f, 4.01626453e-02f, 4.93461303e-02f, 4.77547944e-02f, -3.58223133e-02f, -1.96670830e-01f, -1.19983062e-01f, -5.15010506e-02f,
  1.47428587e-01f, -4.51716222e-03f, 8.69807824e-02f, 1.26836926e-01f, -2.03619562e-02f, -1.90145839e-02f, -2.45365903e-01f, -1.62651502e-02f, -1.26577809e-01f, 1.59695894e-01f,
  -1.92431323e-02f, 6.99436292e-02f, 1.06045187e-01f, -2.24894017e-01f, -4.81811166e-02f, 3.62076521e-01f, 1.91469688e-03f, -1.01941288e-01f, -2.10468680e-01f, 1.79183543e-01f,
  -2.28374258e-01f, 1.35330139e-02f, -1.38738617e-01f, 1.95173815e-01f, -1.44211361e-02f, -7.77602792e-02f, -1.09091513e-01f, 1.11410178e-01f, 2.19504256e-02f, 1.96360037e-01f,
  1.81644723e-01f, 1.11155599e-01f, -9.33660090e-01f, -3.03933918e-01f, -2.65418082e-01f, 2.06366897e-01f, 5.11375666e-02f, 2.17736855e-01f, -9.17221010e-02f, 5.63482530e-02f,
  1.90439969e-01f, -1.85711548e-01f, 2.66513854e-01f, 1.20864347e-01f, -4.49489504e-01f, -5.49115479e-01f, -5.63480258e-02f, -1.49623245e-01f, 2.35909566e-01f, 3.20871115e-01f,
  1.12727404e-01f, -3.62687886e-01f, 1.96128525e-02f, -2.90574700e-01f, -3.08228165e-01f, 4.66873460e-02f, -3.48887175e-01f, -2.26333812e-01f
};

// L3_linear_B (Shape: 1 x 12)
const int L3_linear_B_rows = 1;
const int L3_linear_B_cols = 12;
const float L3_linear_B_data[] = {
  -7.58229643e-02f, -2.37308871e-02f, 6.99459808e-03f, -1.20487317e-01f, -1.19180745e-02f, -4.28792797e-02f, -4.97168787e-02f, 5.35857715e-02f, -4.30671647e-02f, 4.69930954e-02f,
  -9.46994871e-02f, 6.11873083e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 19, 26
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        64, 19, 26
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        64, 19, 26
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_linear
    linear_forward_pgm(
        buffer1, x_out,
        L3_linear_W_data, L3_linear_B_data,
        64, 12
    );
    }
    