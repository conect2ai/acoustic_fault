/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 16 (x1)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 16;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    float x3 = x * x * x;
    return 0.5f * x * (1.0f + tanhf(0.79788456f * (x + 0.044715f * x3)));
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 6 x 120)
const int L0_fan_Wp_rows = 6;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -4.31322128e-01f, -3.05840522e-01f, 1.48713261e-01f, -1.30228013e-01f, -1.62658185e-01f, -1.25345349e-01f, -1.86054111e-01f, -2.63315976e-01f, -1.17988825e-01f, -2.06228778e-01f,
  1.06621444e-01f, 4.29843247e-01f, 4.74447727e-01f, 4.27471995e-01f, 2.33170763e-01f, -8.00518692e-02f, 4.34362665e-02f, 2.28644550e-01f, 2.10032776e-01f, -7.85921961e-02f,
  4.50722277e-02f, -2.47589558e-01f, 7.17239454e-03f, 1.18713990e-01f, -2.67087251e-01f, 7.91185275e-02f, -3.45263854e-02f, -2.10354984e-01f, 1.50001004e-01f, -1.26448363e-01f,
  1.63870767e-01f, -3.94380689e-01f, 1.96619421e-01f, 8.51319730e-02f, -8.88703540e-02f, 4.00900319e-02f, 3.55385430e-02f, -4.38011624e-02f, 5.02299331e-02f, -3.54801826e-02f,
  5.85224740e-02f, 4.38275300e-02f, 2.59670359e-03f, 1.00327052e-01f, -1.54453203e-01f, 6.32705018e-02f, -3.15465927e-02f, 1.04988649e-01f, 1.56340271e-01f, 2.33937614e-03f,
  1.49778083e-01f, -1.15922876e-01f, -8.43299031e-02f, -5.62327355e-02f, 9.10095051e-02f, 1.67022526e-01f, -6.13023266e-02f, -2.26491746e-02f, 8.97711441e-02f, -2.47766778e-01f,
  2.33933311e-02f, -9.32764560e-02f, -7.02772513e-02f, 5.37096187e-02f, 2.66139139e-03f, 7.67081827e-02f, -4.86414060e-02f, 2.75236983e-02f, 2.37008464e-02f, -7.64918774e-02f,
  8.62087607e-02f, 5.16294912e-02f, 6.15318306e-02f, -2.63283849e-02f, 1.15950957e-01f, -6.57917261e-02f, 5.09704798e-02f, -5.45743331e-02f, 1.31073013e-01f, -4.32872139e-02f,
  -6.25189068e-03f, 7.06133852e-03f, -6.66155368e-02f, 9.43811703e-03f, -1.50459055e-02f, 7.20122904e-02f, -9.39637329e-03f, 1.37916161e-03f, 6.95439661e-03f, -7.45313838e-02f,
  5.02254963e-02f, 3.45544934e-01f, -6.25865683e-02f, -1.99523401e-02f, -6.61473721e-02f, -2.73786299e-02f, 3.89111228e-02f, -4.48188558e-02f, -5.30726574e-02f, 2.93139126e-02f,
  -1.01468027e-01f, 9.02101249e-02f, 3.20051871e-02f, -3.55495177e-02f, 1.71359088e-02f, -2.45020967e-02f, 2.08196919e-02f, 8.43720883e-02f, 8.00090563e-03f, -1.36077091e-01f,
  -6.77237213e-02f, 1.52780432e-02f, 1.59941837e-01f, 9.62332040e-02f, -8.01750049e-02f, 1.93547066e-02f, -2.92549245e-02f, -2.79911738e-02f, 4.49821241e-02f, 3.66775244e-02f,
  6.41490698e-01f, -2.08160691e-02f, -3.61129254e-01f, 5.64179897e-01f, -5.25023863e-02f, -2.80350596e-01f, -6.12462878e-01f, -1.25389844e-01f, 2.16418117e-01f, 2.21622363e-02f,
  1.65538535e-01f, 3.65895748e-01f, 1.73366383e-01f, 8.10976177e-02f, 3.05602513e-02f, -4.10473287e-01f, -3.23829025e-01f, 2.74627525e-02f, -6.95013031e-02f, -1.23640895e-01f,
  -1.13462485e-01f, 5.43878190e-02f, 3.28592777e-01f, 8.38361122e-03f, 7.48721808e-02f, 3.90341207e-02f, -1.16253145e-01f, 1.37008965e-01f, -1.88398972e-01f, 6.86873049e-02f,
  4.15760651e-02f, 1.56714097e-01f, -1.26203120e-01f, 1.60310477e-01f, 1.18057720e-01f, 1.69242714e-02f, -8.33054036e-02f, 1.55405551e-02f, -1.52810372e-03f, -1.16217501e-01f,
  7.97951221e-03f, 1.10263661e-01f, 9.05360095e-03f, -3.97923216e-02f, -3.38723399e-02f, -2.62935087e-02f, 1.23023642e-02f, -3.24443132e-02f, -1.44683301e-01f, -5.02478667e-02f,
  8.03685375e-03f, 6.61555454e-02f, 1.71104111e-02f, -1.63914964e-01f, -8.11060611e-03f, 4.22983579e-02f, 1.63498707e-02f, 6.63486421e-02f, -4.18740250e-02f, 1.01974308e-01f,
  3.32401581e-02f, 1.58503614e-02f, 5.89894541e-02f, 3.74468789e-02f, 3.85351814e-02f, -4.41928580e-02f, -6.89801574e-02f, -1.92124192e-02f, -6.28964454e-02f, 1.72207858e-02f,
  6.30806899e-03f, -4.14919332e-02f, -5.65923713e-02f, 4.55295295e-02f, -2.51209140e-02f, 7.55834300e-03f, -1.81538444e-02f, -1.26074208e-02f, -2.57833805e-02f, 1.51341790e-02f,
  5.63613512e-02f, -7.10492581e-02f, 5.71551286e-02f, -3.94450165e-02f, -2.63353046e-02f, 2.46813931e-02f, 4.00415808e-02f, -2.09861621e-02f, -2.57816762e-02f, 2.48489119e-02f,
  -3.83650623e-02f, -2.15215087e-02f, 5.45799322e-02f, -3.15171145e-02f, 1.82357412e-02f, 7.36735091e-02f, 4.52150293e-02f, -3.20909225e-04f, 3.45422290e-02f, -5.02840243e-02f,
  1.01701133e-01f, -2.40050219e-02f, -4.37271968e-03f, -5.50409080e-03f, -5.02102263e-02f, -5.49424952e-03f, 3.21281627e-02f, 8.48881081e-02f, -2.79781539e-02f, 1.53615102e-02f,
  2.77341567e-02f, -7.67048821e-02f, -9.74172726e-02f, 3.17562148e-02f, 6.55900165e-02f, 2.10426748e-03f, -1.66911811e-01f, 3.73010524e-02f, -7.13829137e-03f, -2.00679481e-01f,
  5.31121671e-01f, -5.59743941e-01f, 1.53632566e-01f, -1.21850900e-01f, 2.08716199e-01f, 1.37432382e-01f, -8.92434269e-02f, -2.13398367e-01f, -1.41319647e-01f, -2.71913171e-01f,
  4.83848974e-02f, 2.07903117e-01f, 8.99003148e-02f, 3.32259163e-02f, 9.11179110e-02f, -2.63293296e-01f, -3.84996325e-01f, 1.53407782e-01f, 4.22767460e-01f, 3.39166135e-01f,
  -1.14082173e-01f, -2.41963696e-02f, 3.74318697e-02f, 1.76274756e-04f, -2.04875916e-01f, 1.38211444e-01f, -2.96374083e-01f, -1.38585836e-01f, -4.04317267e-02f, -5.05481780e-01f,
  2.61694908e-01f, -1.44019574e-01f, 2.23841116e-01f, 3.68596725e-02f, 1.20984405e-01f, -1.35931084e-02f, 1.49538785e-01f, -1.03759840e-01f, 2.46122014e-02f, -1.15989417e-01f,
  4.26975414e-02f, 3.04500237e-02f, 6.01803325e-03f, -4.28670943e-02f, -5.55036180e-02f, -1.11638658e-01f, -1.50921449e-01f, -5.98276034e-02f, -6.58539161e-02f, 1.56847630e-02f,
  -2.56732274e-02f, 4.41323072e-02f, 1.34598672e-01f, 1.47927012e-02f, -6.84585273e-02f, 1.22512013e-01f, -8.54513235e-03f, -7.57684093e-03f, 1.12075411e-01f, -1.39767557e-01f,
  -2.08544806e-02f, 7.84562379e-02f, 2.19724886e-03f, -1.86731145e-02f, -4.00486812e-02f, -3.97299454e-02f, 5.84742520e-03f, 1.52373035e-02f, 2.41642836e-02f, -5.11314645e-02f,
  -2.07092073e-02f, -4.39059585e-02f, 1.25553273e-03f, -1.88623257e-02f, 2.23705806e-02f, -2.28729099e-02f, -1.35909636e-02f, -3.70808169e-02f, 8.87984261e-02f, -1.68300763e-01f,
  4.04610857e-02f, 1.36486441e-01f, -1.07909217e-02f, -5.57632521e-02f, -1.03139609e-01f, -7.78958350e-02f, -2.77944282e-02f, -4.98307012e-02f, -1.10720722e-02f, 8.51519033e-03f,
  6.50926679e-03f, 2.78369337e-01f, -4.25074846e-02f, 4.74318080e-02f, 4.95696254e-02f, -5.08673340e-02f, 4.09196224e-03f, 7.00725392e-02f, 8.33195169e-03f, -4.15227748e-03f,
  2.98033655e-03f, 5.99477291e-02f, -6.05948269e-02f, -1.85631663e-02f, 1.56380624e-01f, 5.21426611e-02f, -6.71642646e-02f, 8.62149075e-02f, 1.33567369e-02f, -7.40571395e-02f,
  -1.47624001e-01f, 1.44907068e-02f, 2.07588837e-01f, 1.00699022e-01f, 6.91222250e-02f, 1.89395159e-01f, 4.27701417e-03f, 6.92247003e-02f, 1.77488402e-01f, -3.83058600e-02f,
  1.81014270e-01f, -1.04836494e-01f, 2.27671862e-01f, 2.00306267e-01f, -1.26088485e-01f, -2.39748538e-01f, -3.31689179e-01f, -1.28527239e-01f, 1.14270404e-01f, 2.48736113e-01f,
  -1.59578651e-01f, -1.57153040e-01f, -1.43074498e-01f, -1.75813854e-01f, -3.51120353e-01f, 1.57858342e-01f, 1.65478185e-01f, 6.82001188e-02f, -1.40295938e-01f, -1.00170083e-01f,
  -1.14166610e-01f, 1.20008275e-01f, 9.82679799e-02f, -3.68003361e-02f, 2.80628324e-01f, 7.52486580e-04f, 1.21413626e-01f, 4.96353135e-02f, -2.01576844e-01f, 5.75115979e-01f,
  3.83563221e-01f, 1.28925487e-01f, -1.69409052e-01f, -9.89531651e-02f, 2.46777646e-02f, 3.72178890e-02f, 3.29994746e-02f, 1.03699885e-01f, -3.40233259e-02f, 1.82778403e-01f,
  2.57652998e-02f, 9.73071828e-02f, -1.13305934e-01f, 8.16490799e-02f, 1.33929729e-01f, 6.99146241e-02f, 4.84627374e-02f, -1.90724563e-02f, -4.18453244e-03f, 8.75256956e-02f,
  -8.53396580e-03f, -5.37525974e-02f, -8.58446807e-02f, -2.56095052e-01f, -3.14199030e-01f, -1.83840215e-01f, -8.66731480e-02f, 3.71581875e-04f, -1.89026028e-01f, 2.56306052e-01f,
  -1.21474832e-01f, 3.38750072e-02f, 4.28132480e-03f, -2.83359252e-02f, -3.89592052e-02f, 4.16177697e-03f, 4.98717651e-02f, 4.69869226e-02f, -2.52934117e-02f, 8.49794894e-02f,
  -2.01552790e-02f, 4.15797904e-02f, -4.68010781e-03f, 2.43945047e-02f, 7.90098384e-02f, -1.29567208e-02f, -1.17806932e-02f, 1.40320286e-02f, -4.49870750e-02f, 6.45265589e-03f,
  -9.25251022e-02f, 2.84337308e-02f, 9.12824497e-02f, -2.86921412e-02f, -9.18809101e-02f, -6.94001615e-02f, 1.47171142e-02f, -6.40637875e-02f, 3.41294371e-02f, -5.10756392e-03f,
  2.68674530e-02f, -4.40233171e-01f, 2.09377423e-01f, -5.66359200e-02f, 1.02527797e-01f, 2.96699768e-03f, -4.57901834e-03f, -1.47997690e-02f, 5.57956845e-02f, -2.01292038e-02f,
  -8.61317366e-02f, 1.97384469e-02f, 4.20434289e-02f, -1.20253321e-02f, 5.20093739e-02f, -5.88795841e-02f, 4.71752696e-03f, 2.74422746e-02f, -2.94519570e-02f, 9.12632272e-02f,
  2.65229121e-03f, 5.47294095e-02f, 1.87240511e-01f, 5.68743646e-02f, -1.07436538e-01f, -3.51630710e-02f, 1.42580226e-01f, 1.04704849e-01f, -1.62940234e-01f, 2.52232581e-01f,
  8.49734247e-01f, -1.74963430e-01f, -5.93342006e-01f, 3.89289796e-01f, -1.06936157e-01f, -3.45678851e-02f, 1.46801472e-01f, 9.78147611e-02f, 5.07563613e-02f, -5.56955673e-02f,
  -2.44022220e-01f, -1.12838857e-01f, -2.35067740e-01f, -1.68837070e-01f, 2.45535392e-02f, -2.31289446e-01f, -2.80463547e-01f, -6.86516538e-02f, 1.54541597e-01f, 3.40340257e-01f,
  1.72079965e-01f, 4.03915197e-01f, 4.04163301e-01f, 8.70893896e-02f, -7.13275969e-02f, -5.37621155e-02f, -1.82948142e-01f, -1.34203564e-02f, -2.43193135e-01f, -3.95997226e-01f,
  -2.27883011e-01f, -1.09675653e-01f, -9.69335660e-02f, -5.20720445e-02f, -1.69926539e-01f, -2.86552254e-02f, -1.74721237e-02f, -6.20877445e-02f, -2.08588261e-02f, -2.35730093e-02f,
  -1.86233252e-01f, -5.35402745e-02f, -5.57137914e-02f, -4.15254943e-02f, 9.79199260e-02f, -1.59673076e-02f, 5.84709905e-02f, -4.79810424e-02f, -7.66762272e-02f, -2.38998115e-01f,
  -1.95110410e-01f, -1.94173902e-02f, -8.32104087e-02f, -1.17166072e-01f, -1.60276353e-01f, -1.46645918e-01f, -4.49400209e-02f, -1.00462385e-01f, -2.08322018e-01f, 8.63649398e-02f,
  1.07262291e-01f, -2.92680971e-02f, -1.16803404e-02f, 6.30789027e-02f, 1.08146660e-01f, -1.29409675e-02f, 2.96608470e-02f, 6.75275177e-02f, 8.36822540e-02f, 8.94823372e-02f,
  3.56144607e-02f, 3.79167660e-03f, 2.35262103e-02f, 7.34673068e-02f, -1.58358030e-02f, 2.77288835e-02f, 5.25719710e-02f, 8.35296884e-02f, -8.24471116e-02f, 7.53866434e-02f,
  1.04883462e-02f, 6.06588973e-03f, -2.19057649e-02f, 3.16249602e-03f, -1.10465428e-02f, 2.75589116e-02f, 5.48669994e-02f, 1.34900548e-02f, 9.67814922e-02f, 5.94384149e-02f,
  1.37655661e-01f, -1.60472035e-01f, -1.31285459e-01f, -1.02942757e-01f, -8.32346007e-02f, -1.18340127e-01f, -1.63643956e-01f, -1.73053816e-01f, -1.92915618e-01f, -9.84920561e-02f,
  -1.22235790e-01f, -4.12484333e-02f, -7.79297575e-02f, -7.85733163e-02f, 3.77173200e-02f, -8.62835646e-02f, -1.47977099e-02f, -1.08213469e-01f, -1.54556975e-01f, -5.34224398e-02f,
  -3.06663923e-02f, -7.27700070e-02f, 4.43318971e-02f, -1.56937122e-01f, -5.14572300e-02f, 1.32101951e-02f, -1.21989936e-01f, -9.73383859e-02f, -5.08959778e-02f, 2.43459299e-01f,
  1.49046794e-01f, -5.68344235e-01f, -2.39322424e-01f, -1.25873029e-01f, -2.55972385e-01f, -2.22825289e-01f, -5.91466308e-01f, 1.63494330e-02f, 2.30789751e-01f, -1.35343239e-01f,
  -1.94974951e-02f, 1.01130180e-01f, 1.76341519e-01f, 5.95196262e-02f, 4.11891304e-02f, -2.66778678e-01f, -1.25547990e-01f, 3.88627015e-02f, -3.55633497e-02f, -2.31928810e-01f,
  -1.72844231e-01f, -1.28207326e-01f, 2.49308079e-01f, 1.00068517e-01f, -2.58142173e-01f, 1.04200117e-01f, 3.04997638e-02f, 7.67375976e-02f, 8.99824686e-03f, -4.49640840e-01f,
  -4.22119558e-01f, -7.76918754e-02f, 1.51890768e-02f, 1.00244500e-01f, -3.87411863e-02f, 1.53385043e-01f, 5.14811426e-02f, 1.03212304e-01f, 6.10899553e-02f, 8.90945867e-02f,
  5.61594963e-02f, 9.22766998e-02f, 2.49566212e-02f, -3.53804603e-02f, -1.19908325e-01f, -2.00645365e-02f, 7.13298693e-02f, 1.34923612e-03f, 1.42089455e-04f, -1.26668707e-01f,
  -1.51814222e-01f, -3.94836143e-02f, -1.28459677e-01f, 6.83691651e-02f, 7.63903335e-02f, 5.72989322e-02f, -1.20707877e-01f, 7.29184300e-02f, 1.24594383e-01f, 5.74222766e-02f,
  -2.57436782e-02f, 4.09827046e-02f, -5.14445230e-02f, -4.98390049e-02f, -5.60759148e-03f, 3.69068049e-02f, -5.85782975e-02f, -1.00569688e-02f, -5.50293624e-02f, 4.56920899e-02f,
  -4.11434136e-02f, -6.63296431e-02f, 9.28720739e-03f, -4.24889894e-03f, -2.69704182e-02f, -2.60489807e-02f, -7.74309412e-02f, -4.34488095e-02f, 2.56893737e-03f, -5.83302323e-03f,
  1.20039023e-02f, -1.76154803e-02f, 3.45211439e-02f, -3.72845307e-02f, -6.69292659e-02f, -8.67332444e-02f, 2.49607544e-02f, 5.64698912e-02f, 1.11708149e-01f, 1.29651561e-01f,
  2.61124671e-01f, 1.28324583e-01f, -1.08731620e-01f, 1.03362184e-02f, -4.29413887e-03f, 2.72291042e-02f, -6.86254129e-02f, 4.59678210e-02f, -3.77253331e-02f, -8.34082961e-02f,
  6.08011931e-02f, 3.23359645e-03f, -3.36457603e-02f, 8.23313519e-02f, 1.29653728e-02f, 8.41660798e-02f, 1.02869133e-02f, -7.67030418e-02f, 4.70192693e-02f, -1.31408535e-02f,
  3.19597349e-02f, 3.94105986e-02f, 5.53611070e-02f, -3.84613685e-02f, -1.34053798e-02f, -9.38343722e-03f, -3.84678356e-02f, -4.76355478e-03f, 4.50338610e-02f, -3.85638289e-02f
};

// L0_fan_Wp_bar (Shape: 4 x 120)
const int L0_fan_Wp_bar_rows = 4;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -8.25829029e-01f, -2.50846654e-01f, -1.85987666e-01f, 4.22838807e-01f, -2.35965014e-01f, -1.09939528e+00f, -1.47166979e+00f, -8.51413667e-01f, 1.22110642e-01f, -5.29694378e-01f,
  -4.84206110e-01f, 2.77724415e-01f, 1.79850280e-01f, -2.95041874e-02f, -3.83428335e-01f, -1.53171122e-01f, 6.34134114e-01f, 5.45041203e-01f, -2.31142238e-01f, -4.75631803e-01f,
  4.88964260e-01f, 3.32665622e-01f, 1.47019967e-01f, 1.29059330e-01f, 7.81410694e-01f, 4.01143104e-01f, 2.09502935e-01f, 3.07970256e-01f, -1.53490663e-01f, 1.51565063e+00f,
  -4.35676575e-01f, -4.79368925e-01f, -1.08022720e-01f, 3.63947041e-02f, 2.31360972e-01f, 1.00253060e-01f, -1.51671201e-01f, 3.27615619e-01f, -7.70000890e-02f, 1.42066032e-01f,
  1.67554244e-01f, -4.04162668e-02f, 1.97862804e-01f, 1.60361845e-02f, -4.46437091e-01f, -4.06878233e-01f, 2.39412531e-01f, -6.11922331e-02f, 1.49325401e-01f, -3.97141874e-01f,
  6.08392715e-01f, 1.48655858e-03f, -4.44138676e-01f, -2.11627498e-01f, -3.11338544e-01f, 3.49202484e-01f, -4.71446842e-01f, 1.08437054e-01f, -4.78015006e-01f, 3.94490391e-01f,
  6.41639754e-02f, -2.44743023e-02f, -1.09173238e-01f, -9.76445079e-02f, -9.94358584e-02f, -7.10976645e-02f, 1.74636051e-01f, -8.49861652e-02f, -7.19046593e-03f, -1.65740654e-01f,
  4.23069112e-02f, -5.06259911e-02f, 1.73704922e-01f, -2.26592958e-01f, 1.30030066e-01f, 3.91685702e-02f, 6.62996843e-02f, -8.07857513e-02f, -5.03030941e-02f, -3.52712162e-02f,
  3.16873044e-02f, 3.68542634e-02f, 1.07566051e-01f, 1.33780971e-01f, 1.44229885e-02f, 2.58527279e-01f, 4.60529000e-01f, -6.95050135e-02f, -1.60959288e-02f, -1.61067098e-02f,
  6.09915480e-02f, 1.06605113e-01f, -1.05947167e-01f, -1.31088011e-02f, 1.52572274e-01f, -3.76904337e-03f, 1.48252085e-01f, 1.10518485e-01f, -5.87143525e-02f, -3.31087150e-02f,
  -2.33688653e-01f, -1.36848465e-01f, 5.80805317e-02f, -1.74226686e-01f, -2.85943210e-01f, -1.29445165e-01f, -1.95704207e-01f, -5.54898232e-02f, -1.35464236e-01f, 6.50017709e-02f,
  1.19329222e-01f, -6.77485943e-01f, -1.20439315e+00f, -5.75528979e-01f, -2.50072896e-01f, -6.28683269e-01f, -5.34393787e-01f, -5.46060562e-01f, -1.07068336e+00f, -1.24491215e+00f,
  -2.15310431e+00f, -6.07477605e-01f, -4.17017490e-01f, -5.26823342e-01f, 2.26501554e-01f, 4.14387077e-01f, 2.05401182e-01f, 6.01998031e-01f, -7.95184299e-02f, -6.34705722e-01f,
  1.85482427e-01f, -1.86524689e-01f, -9.86501932e-01f, -5.39855480e-01f, -8.04985762e-01f, -1.05686629e+00f, -1.17615795e+00f, -1.02940130e+00f, 3.34555894e-01f, 1.37650776e+00f,
  4.61916506e-01f, -6.58377528e-01f, -4.79816824e-01f, 1.64826885e-01f, 2.53913254e-01f, -3.09607923e-01f, -5.76712012e-01f, -4.63176757e-01f, -1.39079422e-01f, -1.03591716e+00f,
  -5.33167362e-01f, 6.40403509e-01f, 1.38078406e-01f, -1.45047441e-01f, -8.88564065e-02f, -1.17780797e-01f, 8.27857181e-02f, -2.13283226e-01f, -2.52050199e-02f, -2.49233529e-01f,
  -7.54347071e-02f, 5.63346922e-01f, 4.61920165e-02f, 8.75581973e-05f, -1.16917849e-01f, -1.16164144e-02f, 4.17251885e-03f, 6.47794828e-02f, -2.99609363e-01f, 5.29746532e-01f,
  1.54698685e-01f, -7.27619976e-02f, -3.76348466e-01f, 4.72545385e-01f, 4.08167571e-01f, -3.61400783e-01f, 4.57973152e-01f, 6.32710338e-01f, -6.02937341e-02f, -7.28153586e-01f,
  1.93504259e-01f, -6.25346750e-02f, 1.00567207e-01f, 1.02113131e-02f, -1.21223100e-01f, -4.52184267e-02f, -7.50947222e-02f, -9.46239308e-02f, 1.31071955e-01f, -2.44760558e-01f,
  1.85683280e-01f, 6.98136464e-02f, 6.25515729e-02f, -1.43479317e-01f, 8.61142427e-02f, -4.42096293e-02f, 3.01749147e-02f, -9.42767486e-02f, -1.22180760e-01f, -5.72727434e-02f,
  -6.99568540e-02f, 2.88484514e-01f, -7.09124207e-02f, 2.17191637e-01f, -1.17923029e-01f, -2.39638090e-01f, 1.26853973e-01f, 2.32470259e-01f, 8.25637281e-02f, -1.49091750e-01f,
  -4.87189054e-01f, -1.67970493e-01f, -6.41972125e-01f, 4.26088087e-02f, -3.03063333e-01f, -9.07524228e-02f, -8.09463933e-02f, -1.38180047e-01f, -2.32048258e-01f, -5.99232242e-02f,
  3.63712281e-01f, -1.32485732e-01f, -3.98194790e-01f, -5.86618530e-03f, -1.11214720e-01f, 1.54750556e-01f, -1.64547160e-01f, -3.43280494e-01f, 2.02569187e-01f, 4.28265780e-01f,
  -1.94449052e-02f, -2.43114933e-01f, -8.54438245e-01f, -3.82223725e-01f, 2.72733252e-02f, -3.78553450e-01f, -4.17986959e-01f, 1.41792223e-01f, -9.93587017e-01f, -1.04715705e+00f,
  1.76999763e-01f, 6.03835762e-01f, 1.32211280e+00f, -8.26406002e-01f, -5.14902949e-01f, -5.05323261e-02f, 4.41660225e-01f, 1.14065744e-01f, -7.21336722e-01f, 7.77487680e-02f,
  4.74755839e-03f, -9.16342556e-01f, -3.78442734e-01f, -2.16285825e-01f, 2.21090987e-01f, 3.41964453e-01f, 3.00183147e-01f, 3.54644537e-01f, -2.33905435e-01f, -5.09278715e-01f,
  -9.11168694e-01f, -2.82005668e-01f, 3.22729915e-01f, 2.44997501e-01f, -5.52541390e-02f, -6.22040451e-01f, 6.31262004e-01f, 1.33305043e-01f, 6.07749343e-01f, -1.52598359e-02f,
  5.92691541e-01f, 8.06628942e-01f, -3.54643792e-01f, -4.77709264e-01f, 2.54420072e-01f, -1.18634626e-02f, 1.33344322e-01f, 1.72025204e-01f, -8.47697109e-02f, 2.75900792e-02f,
  -1.80452675e-01f, 3.69814709e-02f, -1.42660499e-01f, -3.09187442e-01f, -1.19874656e-01f, -1.02021813e-01f, 2.38099113e-01f, 4.59103793e-01f, 1.58016339e-01f, 1.49697304e-01f,
  -6.94925308e-01f, -1.90623239e-01f, 2.14289948e-01f, -4.42080423e-02f, 2.01778054e-01f, -2.65503317e-01f, 3.19469392e-01f, 2.68448710e-01f, 7.14882076e-01f, 1.70208439e-01f,
  -2.30811350e-02f, 1.25994459e-01f, 8.98729935e-02f, 8.60842094e-02f, -3.52594405e-02f, -3.89085896e-02f, -5.38281091e-02f, -1.99664757e-01f, -1.91758946e-01f, 4.12095822e-02f,
  3.38360332e-02f, 1.55997360e-02f, -1.54252844e-02f, 9.79211703e-02f, -1.58484593e-01f, 1.76359475e-01f, -1.12292357e-01f, 1.03727557e-01f, -5.68504706e-02f, 6.15915209e-02f,
  -1.06483981e-01f, 1.33190140e-01f, -9.89987254e-02f, 5.12533039e-02f, -3.69149931e-02f, 2.25585222e-01f, -3.81658487e-02f, -4.14720997e-02f, -1.15839913e-01f, 3.27478312e-02f,
  -6.69532239e-01f, 1.82788670e-01f, 1.29604200e-02f, 6.34961873e-02f, 1.17668115e-01f, 2.44409759e-02f, -2.86038797e-02f, -6.08068099e-03f, 1.47844076e-01f, -1.45949461e-02f,
  1.63633823e-01f, -2.64332555e-02f, 2.14662120e-01f, 1.98831365e-01f, -4.97894853e-01f, -6.38715252e-02f, -1.46590739e-01f, -2.97159314e-01f, -1.90046057e-01f, -9.89769846e-02f,
  3.06194928e-02f, -3.51754248e-01f, -8.44117105e-01f, -2.19654754e-01f, -3.28196108e-01f, -4.88485873e-01f, -1.65756851e-01f, -4.77138668e-01f, -3.53256583e-01f, -6.14799678e-01f,
  -4.11399454e-01f, 1.07162499e+00f, -8.08169007e-01f, 7.82106370e-02f, -5.52260458e-01f, -7.39182234e-01f, 1.26074076e-01f, -6.04274392e-01f, -4.71021116e-01f, 5.16675293e-01f,
  9.03688908e-01f, 3.96277547e-01f, 5.81483603e-01f, -2.87439793e-01f, -1.18433714e+00f, -7.39456415e-01f, -1.08012044e+00f, -1.24325526e+00f, -1.29932249e+00f, -4.62307215e-01f,
  1.66152284e-01f, 3.64434533e-02f, -4.10373598e-01f, -5.39374113e-01f, 2.31221333e-01f, 1.69272974e-01f, 1.87874049e-01f, -1.22191899e-01f, -1.01225160e-01f, 2.24200636e-01f,
  3.86979997e-01f, 2.96823271e-02f, -3.02635819e-01f, -3.29024702e-01f, 5.41896760e-01f, -3.96369368e-01f, 1.91011261e-02f, -2.42852084e-02f, 2.99361557e-01f, -1.72927678e-01f,
  2.04971880e-01f, 2.42315270e-02f, -4.62076426e-01f, -2.58122385e-01f, -4.30450320e-01f, -4.88468945e-01f, -2.22471431e-01f, -6.60283625e-01f, -2.41653606e-01f, 3.02141756e-01f,
  4.68178242e-01f, -2.50138491e-01f, -3.23801450e-02f, 1.20047219e-01f, -1.35146812e-01f, -2.25751057e-01f, 4.90418114e-02f, -5.55645823e-01f, -4.67903823e-01f, 3.09792459e-01f,
  7.34604076e-02f, 1.20364890e-01f, -1.63788605e-03f, -2.31054295e-02f, 9.36337456e-04f, 1.72059566e-01f, 5.11232354e-02f, 1.81444854e-01f, -1.82986721e-01f, 2.34963879e-01f,
  8.26181564e-03f, 3.83809349e-03f, -9.33058932e-02f, 1.56163186e-01f, 3.14265303e-02f, -4.67516575e-03f, 8.09432492e-02f, 1.08673982e-01f, -1.65545922e-02f, -1.59939423e-01f,
  -6.73114089e-03f, -7.12767541e-02f, 1.10641733e-01f, 6.02056868e-02f, -3.69086295e-01f, -1.23980522e-01f, -1.34166852e-01f, 1.84465244e-01f, 2.91315205e-02f, -1.90996021e-01f,
  8.86918008e-01f, -3.46238196e-01f, 2.38195792e-01f, -3.88806723e-02f, -7.10301027e-02f, 1.00889817e-01f, 2.98130929e-01f, -1.37031212e-01f, 1.70207873e-01f, 2.32162267e-01f,
  -1.74165741e-01f, 1.85047537e-01f, 2.09961817e-01f, 1.90698773e-01f, -3.93568158e-01f, 6.25977740e-02f, 3.11872307e-02f, 8.37914497e-02f, -3.76097918e-01f, 6.84710220e-02f,
  -1.44039482e-01f, -2.55834490e-01f, -6.55656829e-02f, 2.13247329e-01f, 6.35998622e-02f, -1.46991566e-01f, 2.48213038e-01f, 1.69556424e-01f, -2.38244265e-01f, 6.79637074e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 4)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 4;
const float L0_fan_Bp_bar_data[] = {
  8.91237378e-01f, -4.71457034e-01f, 1.09656155e+00f, 1.90341794e+00f
};

// L1_linear_W (Shape: 12 x 16)
const int L1_linear_W_rows = 12;
const int L1_linear_W_cols = 16;
const float L1_linear_W_data[] = {
  -1.45976633e-01f, -1.08262211e-01f, -3.24886769e-01f, -4.81717974e-01f, -2.52941642e-02f, -8.41599584e-01f, -2.82193482e-01f, 1.07696509e+00f, 9.38335001e-01f, -8.90777230e-01f,
  1.29158247e+00f, -2.50256687e-01f, -4.13843304e-01f, 9.71202075e-01f, -1.41121697e+00f, -2.72497296e-01f, -2.67732799e-01f, -5.70447184e-03f, -7.33543932e-01f, 7.55498707e-01f,
  6.84747636e-01f, -1.05192327e+00f, 1.42184627e+00f, 2.25697994e+00f, 9.48399484e-01f, -2.18272376e+00f, 9.62541044e-01f, 6.32829266e-03f, -1.29447794e+00f, -8.63817096e-01f,
  -1.29281795e+00f, 9.04695466e-02f, -3.46119523e-01f, 1.33287221e-01f, 5.03546357e-01f, 1.09067112e-01f, 3.82730901e-01f, 2.24827975e-01f, 1.27993739e+00f, 6.00512743e-01f,
  7.14267969e-01f, -1.06949076e-01f, -7.70103574e-01f, 1.69577944e+00f, 7.14928865e-01f, -3.82666945e-01f, 2.99487263e-01f, -1.57147110e+00f, 5.54087162e-01f, -1.61085451e+00f,
  5.29305004e-02f, -9.96224701e-01f, -1.35327613e+00f, 9.93803918e-01f, 6.73594177e-01f, -2.06628275e+00f, -4.20906544e-01f, -1.22193420e+00f, -1.58478987e+00f, 2.59281415e-02f,
  -9.14508820e-01f, 6.41540110e-01f, 7.38019049e-01f, -1.85727865e-01f, -6.50967360e-01f, 8.06859970e-01f, -4.09351021e-01f, 1.08363472e-01f, -5.03533520e-02f, 5.08716479e-02f,
  -4.99665439e-01f, 8.34228575e-01f, -7.60706127e-01f, 1.41079783e+00f, -1.52153707e+00f, 8.23669910e-01f, -6.11992404e-02f, 1.99310690e-01f, -3.34597714e-02f, 3.47823799e-01f,
  8.35052192e-01f, 1.35336328e+00f, 1.53947687e+00f, -2.28658915e-01f, -7.24454999e-01f, 6.18835151e-01f, -7.03451693e-01f, 7.09585428e-01f, -5.34491301e-01f, 3.60624284e-01f,
  1.35581541e+00f, 8.38970065e-01f, -4.81690764e-01f, -8.19777608e-01f, -1.83456886e+00f, 7.47568130e-01f, 1.30761236e-01f, -3.41801047e-01f, -8.10968697e-01f, -1.69253421e+00f,
  3.22336495e-01f, 2.32983813e-01f, -9.39993501e-01f, 1.05998468e+00f, -7.93582559e-01f, 1.82608855e+00f, 2.01896206e-01f, -3.95188481e-01f, 2.61914015e-01f, -1.35479772e+00f,
  1.05687129e+00f, -2.30184174e+00f, 1.43822297e-01f, -9.57180560e-02f, -1.46844697e+00f, 9.67314765e-02f, 4.55955155e-02f, -1.11275530e+00f, -1.39365613e-01f, -2.21601105e+00f,
  -5.61397314e-01f, -1.07727802e+00f, -1.35774934e+00f, -3.38137358e-01f, 9.66869295e-01f, -1.49074480e-01f, -1.61904895e+00f, -6.45902514e-01f, 1.08884346e+00f, 7.00742126e-01f,
  -7.47768402e-01f, 1.28419220e+00f, 3.64120126e-01f, 1.06624603e+00f, -1.38714588e+00f, -2.42265010e+00f, 1.19832981e+00f, 1.17753947e+00f, 1.33150017e+00f, -9.48115528e-01f,
  -7.30268657e-01f, -4.11658525e-01f, -7.17356324e-01f, -2.04639506e+00f, 2.44549498e-01f, -1.27479398e+00f, 5.80547512e-01f, -8.56984437e-01f, 1.32449076e-01f, 3.13030154e-01f,
  -6.89144552e-01f, 1.45832419e+00f, -5.99048972e-01f, 1.60659325e+00f, -6.33064687e-01f, -1.05446386e+00f, 1.05104709e+00f, -1.17405641e+00f, -1.42886233e+00f, 2.88315922e-01f,
  -7.16239393e-01f, -6.63905501e-01f, -1.42205030e-01f, 2.07601264e-01f, -2.19239101e-01f, 1.18319213e+00f, 1.06378663e+00f, -1.92631567e+00f, 5.97909987e-01f, 8.77851665e-01f,
  -1.40299404e+00f, -1.07686627e+00f, -8.47960472e-01f, -8.42337251e-01f, -8.57086360e-01f, 1.04124177e+00f, -1.01720059e+00f, 4.87456888e-01f, 6.88658178e-01f, 9.74863589e-01f,
  2.94613600e-01f, -5.48187196e-01f, -7.14730799e-01f, -1.78988591e-01f, -6.76888168e-01f, -1.50962579e+00f, 1.31597385e-01f, -8.36515844e-01f, -1.81635451e+00f, -5.39574027e-01f,
  1.59679198e+00f, -6.23196602e-01f
};

// L1_linear_B (Shape: 1 x 12)
const int L1_linear_B_rows = 1;
const int L1_linear_B_cols = 12;
const float L1_linear_B_data[] = {
  -1.96971565e-01f, 2.07523608e+00f, -5.21716237e-01f, -1.04676926e+00f, -5.28523684e-01f, -1.18179910e-01f, 1.43362703e-02f, 6.24134123e-01f, 3.71825099e-01f, -8.26578975e-01f,
  -1.05037761e+00f, -2.33405232e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 6, 4
    );
    
    // Camada 1: L1_linear
    linear_forward_pgm(
        buffer1, x_out,
        L1_linear_W_data, L1_linear_B_data,
        16, 12
    );
    }
    