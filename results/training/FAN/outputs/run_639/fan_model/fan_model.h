/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 32 (x2)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 32;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    float x3 = x * x * x;
    return 0.5f * x * (1.0f + tanhf(0.79788456f * (x + 0.044715f * x3)));
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 6 x 120)
const int L0_fan_Wp_rows = 6;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  1.49682179e-01f, -1.54704496e-01f, -2.56646365e-01f, 4.82024513e-02f, -7.60265952e-03f, -2.43049697e-03f, 4.25421372e-02f, 1.28336191e-01f, 1.81570932e-01f, -2.41351873e-02f,
  -7.32504129e-02f, 2.51362175e-02f, 4.00368534e-02f, -6.09060563e-02f, 3.35054770e-02f, -1.48585156e-01f, -2.08956480e-01f, -2.22445071e-01f, -4.50890139e-02f, 6.56692162e-02f,
  1.76234767e-01f, 7.15720579e-02f, 4.17719670e-02f, -7.06863403e-02f, -2.33384278e-02f, -5.15373424e-02f, -1.40730083e-01f, -8.45431983e-02f, -1.31178886e-01f, -1.24520794e-01f,
  -1.58033997e-01f, -3.87082808e-02f, -8.64223987e-02f, -1.06380843e-01f, -2.63515443e-01f, -1.63334087e-01f, -1.12361126e-01f, -1.62026778e-01f, -1.58484787e-01f, -1.78093091e-01f,
  -1.98096931e-01f, -8.10755268e-02f, -1.67946368e-01f, -9.99981984e-02f, -1.18001789e-01f, -8.28262419e-02f, -8.04819390e-02f, -1.77070752e-01f, -2.42174044e-01f, -1.80847228e-01f,
  -1.09605789e-01f, -1.84045821e-01f, -2.44095087e-01f, -2.86821097e-01f, -2.07658216e-01f, -2.66524166e-01f, -2.92239398e-01f, -1.54633224e-01f, -2.05981955e-01f, -5.86995967e-02f,
  -1.02747150e-01f, -9.91112888e-02f, -4.00736220e-02f, 6.83067515e-02f, 5.79231083e-02f, 2.15589665e-02f, 1.00048274e-01f, 3.83050740e-02f, 6.28706142e-02f, 6.32099658e-02f,
  6.88811913e-02f, 9.18638781e-02f, 1.33562386e-01f, 1.37049258e-01f, 1.15458488e-01f, 6.40725121e-02f, 1.99268058e-01f, 1.20138623e-01f, 7.63601735e-02f, 1.59290209e-01f,
  3.49305309e-02f, 8.28982070e-02f, 1.26574457e-01f, 1.30819857e-01f, 2.70946398e-02f, -4.80689108e-02f, 8.21491331e-02f, 3.85534111e-03f, 7.48228729e-02f, 9.46599767e-02f,
  2.11248294e-01f, -1.63890317e-01f, 1.86230112e-02f, 9.29934997e-03f, -8.76106322e-02f, -2.68281857e-03f, -5.16320057e-02f, -3.44604701e-02f, -1.17320888e-01f, -1.03814586e-03f,
  -9.15175676e-02f, -8.02470297e-02f, -2.46007331e-02f, -8.19669068e-02f, -4.13325205e-02f, -2.82314476e-02f, -1.03575446e-01f, -4.53576110e-02f, -1.97551325e-02f, -8.34011734e-02f,
  -1.92098543e-01f, 2.22478844e-02f, -9.36863869e-02f, -6.22936822e-02f, -9.10681039e-02f, -4.76550423e-02f, -1.37788966e-01f, -1.26864657e-01f, -1.20601878e-01f, -3.55039798e-02f,
  6.71238720e-01f, -2.10702643e-01f, 4.13189888e-01f, 4.95796055e-02f, -1.56767398e-01f, 8.24846178e-02f, -9.96276736e-02f, 3.20406184e-02f, -1.79050751e-02f, -2.70374287e-02f,
  -1.42196357e-01f, -2.06844255e-01f, -2.56902799e-02f, -1.38924077e-01f, -5.01495562e-02f, -8.94928798e-02f, -8.89081135e-03f, 1.46131262e-01f, 2.78062612e-01f, -7.80071393e-02f,
  -2.62667060e-01f, -2.39747018e-02f, 1.33963645e-01f, 3.48251243e-03f, -2.13060245e-01f, -2.91668475e-02f, -5.21479361e-02f, 8.55964702e-03f, -2.02646911e-01f, -1.06804483e-01f,
  2.63082325e-01f, 2.71704227e-01f, -2.71538831e-02f, -4.34775427e-02f, 6.77260682e-02f, 1.23848490e-01f, 2.16284767e-02f, 6.59178123e-02f, 2.97073629e-02f, 3.98318134e-02f,
  9.21758935e-02f, -1.88544877e-02f, 2.05330248e-03f, -4.78794053e-02f, 2.82925740e-02f, -1.95725858e-02f, -2.73566023e-02f, 5.00822440e-02f, -1.29948864e-02f, 1.60099510e-02f,
  -1.47280797e-01f, 1.73622184e-02f, 1.04551673e-01f, 7.20689492e-03f, -2.60450318e-03f, -3.68537940e-02f, 3.57088260e-02f, 6.61825463e-02f, 1.69579506e-01f, -3.28235589e-02f,
  -6.62422404e-02f, 3.22380848e-02f, 3.98055539e-02f, 2.34730933e-02f, -1.03836767e-02f, 3.13415155e-02f, 2.36991160e-02f, 1.79528329e-03f, -2.11282354e-02f, 6.10122047e-02f,
  -1.99358109e-02f, 9.90616605e-02f, -1.74783543e-02f, 1.43356144e-01f, -6.14268631e-02f, 7.86443502e-02f, 8.11744407e-02f, -5.03077507e-02f, 5.35284840e-02f, 8.35101381e-02f,
  4.74322401e-02f, 1.00347862e-01f, 2.15457156e-02f, 4.20342237e-02f, 1.65953021e-02f, 1.38154045e-01f, 1.08283997e-01f, -3.25614624e-02f, 6.61519766e-02f, 4.13542520e-03f,
  -3.00509989e-01f, 6.84333071e-02f, 6.68708608e-02f, 7.26924092e-02f, 4.93950956e-02f, -6.66902140e-02f, -4.14876826e-02f, 6.98302984e-02f, 3.63243297e-02f, 1.08446389e-01f,
  6.89039975e-02f, 7.56784752e-02f, -1.82152689e-02f, -4.35069054e-02f, -8.53298698e-03f, 6.61572069e-02f, -1.69160157e-01f, 5.30474894e-02f, -4.42029424e-02f, -7.24324360e-02f,
  -1.74170792e-01f, 5.68893831e-03f, 8.43595713e-02f, 1.90318301e-02f, 2.50048991e-02f, 4.97554475e-03f, 1.96194462e-02f, -2.79024225e-02f, 3.14548947e-02f, -2.55382787e-02f,
  -9.48015451e-02f, -4.25687194e-01f, -3.23520482e-01f, 4.70003411e-02f, -1.46553814e-01f, -2.49686301e-01f, -3.05587739e-01f, -5.06548174e-02f, 1.75039098e-01f, 6.53503044e-03f,
  2.06087306e-02f, 1.36969298e-01f, 6.94129467e-02f, 4.72857878e-02f, -1.02026351e-01f, -2.13227749e-01f, -2.09139064e-01f, -3.00351344e-02f, 1.84653793e-02f, 8.25945511e-02f,
  1.21314593e-01f, 2.07016692e-02f, 1.52924895e-01f, 7.28482679e-02f, 5.75844664e-03f, 1.40721798e-01f, 5.61425788e-03f, -3.66009772e-02f, 3.43766138e-02f, -2.54300404e-02f,
  -2.13058621e-01f, -1.35256171e-01f, -2.32771635e-02f, 2.24180371e-02f, -3.69175561e-02f, 3.28587703e-02f, -2.00668685e-02f, 4.07675616e-02f, -3.67046781e-02f, -8.03938415e-03f,
  1.01420982e-02f, 6.67043179e-02f, -8.03588033e-02f, 4.43488881e-02f, 2.75148731e-02f, -1.07338214e-02f, 5.60751334e-02f, 6.37119487e-02f, -3.07606701e-02f, -5.67520112e-02f,
  -4.67770137e-02f, -7.70959854e-02f, -1.69079408e-01f, -7.90549368e-02f, -3.42304483e-02f, -6.17332160e-02f, -3.70155759e-02f, -3.31720710e-02f, -8.38212892e-02f, -1.41776070e-01f,
  2.81834472e-02f, 9.61642340e-02f, 1.47422299e-01f, 1.26071528e-01f, 1.85897619e-01f, 1.28596365e-01f, 1.34458929e-01f, 1.48569793e-01f, 9.91536826e-02f, 1.16348401e-01f,
  1.78368077e-01f, 7.53489435e-02f, 1.04105517e-01f, -4.28052270e-04f, 2.27629319e-01f, 7.65408427e-02f, 4.27153707e-02f, 1.61956102e-01f, 1.54713035e-01f, 1.51264504e-01f,
  1.59163862e-01f, 2.95114126e-02f, 8.33744258e-02f, 9.60501358e-02f, 1.53884143e-01f, 1.23750232e-01f, 8.12527463e-02f, 2.35289589e-01f, 1.70207888e-01f, 1.43884495e-01f,
  -5.38388304e-02f, -1.19313575e-01f, -1.10556267e-01f, -6.92939833e-02f, -1.11753441e-01f, -5.15696406e-02f, -1.30468056e-01f, -2.42323875e-02f, -3.22666747e-04f, -1.49567232e-01f,
  -7.72452205e-02f, -1.12557150e-01f, -1.14340223e-01f, -2.04835720e-02f, 1.49318306e-02f, 3.16471793e-02f, -1.37436204e-03f, -7.01312497e-02f, -1.22479349e-01f, -3.87118645e-02f,
  -1.09632269e-01f, -8.59732628e-02f, -7.10587353e-02f, -1.63901895e-01f, -1.54743358e-01f, -9.80620980e-02f, -8.61186385e-02f, -1.28841341e-01f, -1.56471193e-01f, -1.45110384e-01f,
  1.40470102e-01f, 9.35296901e-03f, 9.12385806e-02f, 1.60547327e-02f, 5.11299819e-03f, -2.44129032e-01f, -2.66991973e-01f, -3.61401439e-02f, 1.24487942e-02f, 3.76433767e-02f,
  7.63143823e-02f, -2.64404584e-02f, -8.09107423e-02f, -9.25218761e-02f, -1.62242249e-01f, -1.00118533e-01f, -1.32655203e-01f, -6.51191995e-02f, -9.97956097e-02f, 2.54884679e-02f,
  1.48519659e-02f, 9.38745737e-02f, 2.04644993e-01f, 1.22014821e-01f, 8.62696692e-02f, -2.49831397e-02f, 1.84458807e-01f, 2.29387149e-01f, 2.29515254e-01f, 1.64680302e-01f,
  -1.50944041e-02f, 1.93262860e-01f, -9.57408473e-02f, 5.64411581e-02f, 8.00884664e-02f, -7.31268302e-02f, -7.72012100e-02f, 9.50375423e-02f, 1.66474783e-03f, -6.26613945e-02f,
  6.17380291e-02f, 2.77210623e-02f, -4.18980094e-03f, 4.88590747e-02f, -1.71951149e-02f, 2.95038372e-02f, 7.74529576e-02f, 6.63068444e-02f, 7.13617355e-03f, 1.17718605e-02f,
  -2.23179236e-02f, 7.68880546e-02f, -4.33468036e-02f, 2.13213246e-02f, 3.42615851e-04f, -8.04383531e-02f, -4.20818590e-02f, 1.69220418e-02f, -7.49988779e-02f, -1.41047770e-02f,
  7.79412389e-02f, 2.10681945e-01f, 1.79573417e-01f, 1.46148324e-01f, 1.10656708e-01f, 3.12941596e-02f, 1.64195925e-01f, 1.47714764e-01f, 1.55510008e-01f, 1.46050632e-01f,
  9.25614759e-02f, 7.93021843e-02f, 1.05969422e-01f, 1.16218746e-01f, 1.18575394e-01f, 1.40157387e-01f, 6.76750541e-02f, 1.49187163e-01f, 1.91176489e-01f, 1.23323396e-01f,
  1.03220649e-01f, 1.84607625e-01f, 8.35102797e-02f, 1.27669379e-01f, 1.37456536e-01f, 1.90003797e-01f, 7.45249987e-02f, 2.02148557e-01f, 7.51805976e-02f, 1.40389159e-01f,
  -1.43256515e-01f, -1.29295692e-01f, -2.24042624e-01f, -1.10729352e-01f, -4.30800393e-02f, -1.01205735e-02f, -5.22014722e-02f, -6.70293868e-02f, -1.01463392e-01f, -9.50352773e-02f,
  -8.00762698e-03f, -9.85046253e-02f, -2.77571809e-02f, -3.89278941e-02f, -1.67377472e-01f, -1.45854414e-01f, -8.48392695e-02f, -1.23446524e-01f, -5.71353137e-02f, 2.80330740e-02f,
  -1.04281612e-01f, -1.11909837e-01f, -1.08276188e-01f, -1.31288216e-01f, -1.30210862e-01f, -1.24134637e-01f, -4.45616506e-02f, -1.17652982e-01f, -2.51760811e-01f, -2.64023781e-01f,
  -2.14674383e-01f, 1.82101801e-01f, 3.70112956e-01f, -1.97583959e-01f, -6.81711584e-02f, 1.63329393e-02f, 1.18938677e-01f, 6.29890338e-02f, -1.14094459e-01f, 2.54754890e-02f,
  -1.41576603e-01f, -1.75920621e-01f, 1.00482507e-02f, 8.95533189e-02f, 1.66931212e-01f, 1.06974103e-01f, 2.51592577e-01f, 1.48431718e-01f, 5.19982278e-02f, 4.12202850e-02f,
  -1.34280110e-02f, -1.02647439e-01f, 2.03816709e-03f, 2.52712145e-02f, 4.38545346e-02f, -3.96357849e-02f, 1.21938750e-01f, 7.64123946e-02f, 4.68070805e-02f, 2.61600822e-01f,
  4.40616868e-02f, 8.30319002e-02f, 7.31953606e-02f, 1.47340149e-01f, 1.72423497e-01f, 1.28927723e-01f, 7.08577856e-02f, 7.83396810e-02f, 1.40006155e-01f, 9.94744450e-02f,
  1.57108366e-01f, 9.23884064e-02f, 7.03890249e-02f, 5.08097857e-02f, 1.46549404e-01f, 6.63826391e-02f, 2.11450353e-01f, 1.95146769e-01f, 8.16633925e-02f, 1.23493165e-01f,
  1.45135060e-01f, 9.71381664e-02f, 1.74996853e-01f, 8.61902311e-02f, 1.71815500e-01f, 1.42316014e-01f, 1.31669655e-01f, 1.22853309e-01f, 7.14361221e-02f, 5.41628562e-02f,
  -1.07836835e-01f, -1.43267035e-01f, -5.20495176e-02f, -1.84433624e-01f, -9.53451917e-02f, -1.60129875e-01f, -1.41039401e-01f, -1.20139569e-01f, -8.11879560e-02f, -1.62270159e-01f,
  -7.65646249e-02f, -1.32262692e-01f, -1.13512151e-01f, -2.30165944e-01f, -1.93921804e-01f, -1.87145069e-01f, -1.51767373e-01f, -1.56904474e-01f, -1.56663820e-01f, -1.38652205e-01f,
  -1.58050209e-01f, -1.03931218e-01f, -1.98634595e-01f, -1.11446455e-01f, -8.80268067e-02f, -1.74862638e-01f, -1.84782952e-01f, -1.11719541e-01f, -2.14756548e-01f, -1.17125094e-01f,
  -3.20343643e-01f, 1.75174564e-01f, 1.28160184e-02f, 1.60808668e-01f, 2.56646425e-02f, 1.58469155e-01f, 1.11587606e-01f, 8.85835141e-02f, 4.06022705e-02f, 1.00584731e-01f,
  3.74154821e-02f, 3.51072885e-02f, 9.18879882e-02f, 2.26177678e-01f, 1.12517022e-01f, 3.55828926e-02f, -1.63823795e-02f, 5.52815720e-02f, 1.64799467e-01f, 6.43913150e-02f,
  3.16133052e-02f, 1.16462577e-02f, -1.03475906e-01f, 1.02838196e-01f, -2.26060254e-03f, 5.27722714e-03f, 8.75375140e-03f, 2.60212831e-02f, 7.38067552e-02f, -1.37150651e-02f,
  1.60597593e-01f, 3.10428649e-01f, 3.10600519e-01f, 7.95117840e-02f, -8.78736451e-02f, -1.52771413e-01f, -6.86972588e-02f, -3.14088096e-03f, -1.35369794e-02f, 3.22556752e-03f,
  4.24021371e-02f, -8.73876885e-02f, -5.66161126e-02f, 3.14202183e-03f, 2.56518945e-02f, -3.11470218e-03f, 4.02850360e-02f, 4.00219187e-02f, -1.35766461e-01f, -2.31086984e-01f,
  -1.59916267e-01f, -6.56579211e-02f, 9.80194211e-02f, 5.14474623e-02f, 3.45438235e-02f, -1.79476395e-01f, 7.86165670e-02f, 9.68075693e-02f, 4.30203602e-02f, 2.75061280e-01f,
  1.40831947e-01f, 3.41689914e-01f, -1.67120829e-01f, 2.64155995e-02f, 6.58922642e-02f, 3.89305279e-02f, 1.23700220e-03f, 5.98208122e-02f, 5.22109531e-02f, 2.18132976e-02f,
  6.01294404e-03f, -2.94815819e-03f, 9.08033457e-03f, 5.73215820e-02f, 7.85571635e-02f, 3.38082686e-02f, 6.82594627e-02f, 1.53478757e-01f, 8.32213610e-02f, 1.17241874e-01f,
  -5.06612584e-02f, 1.62665099e-01f, 1.79314971e-01f, 9.39944014e-02f, 1.21264704e-01f, 4.98311333e-02f, 1.19573832e-01f, 6.52401373e-02f, 8.65935981e-02f, 4.65624556e-02f,
  -1.02499098e-01f, -1.15485683e-01f, -1.31674148e-02f, 6.73955232e-02f, -9.60447490e-02f, -1.76579896e-02f, -5.75408638e-02f, -8.19072798e-02f, -6.63508773e-02f, -9.62281153e-02f,
  -2.19688453e-02f, -8.33683368e-03f, -2.18001734e-02f, 3.13997790e-02f, -9.23408046e-02f, 2.90136598e-02f, -7.77368918e-02f, -1.85196772e-02f, -6.35525957e-02f, -5.71126826e-02f,
  -4.38513421e-02f, -6.45163283e-02f, -2.60691810e-02f, -2.20845845e-02f, 7.83738419e-02f, -2.63155885e-02f, -3.24945338e-02f, -7.10929278e-04f, -5.06186374e-02f, -1.82440151e-02f,
  1.44862365e-02f, -2.90023033e-02f, -1.18246511e-01f, -3.52959037e-02f, -8.69870856e-02f, -5.09927161e-02f, -4.85061156e-03f, -5.08613698e-02f, -1.55027176e-03f, -7.69338459e-02f,
  3.75061631e-02f, 4.98194881e-02f, 4.05850224e-02f, -4.98561263e-02f, -9.97290611e-02f, -5.66346385e-02f, 3.59538309e-02f, -4.06204537e-02f, -7.49632269e-02f, 4.20159921e-02f,
  -9.91398003e-03f, -1.17713697e-01f, -1.62403822e-01f, -1.07577555e-01f, -2.36963015e-02f, -1.01013020e-01f, -7.64210448e-02f, -1.24509715e-01f, -6.33808970e-02f, -1.68244705e-01f
};

// L0_fan_Wp_bar (Shape: 20 x 120)
const int L0_fan_Wp_bar_rows = 20;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  5.71485639e-01f, 2.58140892e-01f, 2.85351545e-01f, 1.17689699e-01f, -4.98760194e-01f, -5.12594402e-01f, -4.07713950e-01f, -1.69154674e-01f, 2.69725211e-02f, 1.44210190e-01f,
  -3.05152625e-01f, -3.51902515e-01f, 7.94132520e-03f, -1.22626849e-01f, -1.66563362e-01f, 2.88562715e-01f, 3.30643117e-01f, 1.15045875e-01f, -5.37833631e-01f, -6.22766435e-01f,
  -4.31757182e-01f, -9.30183455e-02f, 9.78446305e-02f, 6.54690713e-02f, 1.96540341e-01f, -2.13620812e-01f, 3.12581420e-01f, 1.71344787e-01f, 7.79700875e-02f, 5.63961744e-01f,
  3.86280030e-01f, 2.98104137e-01f, -4.31554377e-01f, -2.75056303e-01f, -1.82496920e-01f, 1.48079649e-01f, 9.41320439e-04f, 2.84016162e-01f, -7.49477297e-02f, 1.29697874e-01f,
  -2.87799001e-01f, 1.08738262e-02f, -1.42659560e-01f, -1.13754250e-01f, -7.23734647e-02f, -1.09583922e-01f, 1.63212389e-01f, 3.15080851e-01f, 3.51416349e-01f, 2.14618444e-01f,
  -3.31646562e-01f, -1.68652624e-01f, 1.19069710e-01f, -2.58066766e-02f, 1.45501986e-01f, -1.04457535e-01f, -4.25105803e-02f, 2.30025742e-02f, 2.72821505e-02f, 3.93110365e-01f,
  -1.16269141e-02f, 3.33652310e-02f, -5.53379543e-02f, 1.22422740e-01f, -2.48716418e-02f, -1.65349934e-02f, 8.64090845e-02f, -8.79807621e-02f, -6.99966028e-02f, -3.43057066e-02f,
  9.27878823e-03f, 1.34016322e-02f, 4.83399704e-02f, 1.64201558e-01f, 3.56184365e-03f, -4.35855910e-02f, -1.71282172e-01f, -3.54049131e-02f, 1.92664310e-01f, 1.22209810e-01f,
  -1.00059137e-01f, -1.84262469e-02f, -4.13750811e-03f, 3.92632596e-02f, 6.73742369e-02f, 2.14589871e-02f, -1.13610597e-02f, -4.24541384e-02f, 1.34130269e-01f, 1.59776174e-02f,
  -3.21433455e-01f, -2.65622795e-01f, 1.20438136e-01f, -1.01607889e-01f, -9.47662815e-02f, 4.54315394e-02f, 6.17397949e-02f, -9.51647162e-02f, 8.27254578e-02f, 3.23040634e-02f,
  -1.15069084e-01f, 1.09583065e-01f, 1.07715808e-01f, 6.72458187e-02f, -2.41274163e-01f, -3.95330675e-02f, -1.75185606e-01f, -3.07105988e-01f, -8.80850926e-02f, -1.09852783e-01f,
  -5.55681214e-02f, -3.73090982e-01f, -1.57863200e-01f, 4.97409068e-02f, 2.63353102e-02f, -3.75446200e-01f, -1.15638919e-01f, -2.89713532e-01f, -2.22652212e-01f, -4.55251038e-02f,
  9.28476632e-01f, -3.43053304e-02f, -9.17894661e-01f, 2.04544008e-01f, -3.58020067e-01f, -2.38627985e-01f, -4.06830043e-01f, -2.36267447e-02f, 3.09283376e-01f, -3.38921696e-01f,
  -1.37966797e-01f, 3.96881849e-01f, -1.21132977e-01f, -1.25322849e-01f, -1.62165582e-01f, -5.71177125e-01f, -5.28972983e-01f, -3.45835924e-01f, -2.90906131e-01f, -4.89667766e-02f,
  2.81316191e-01f, 4.28744614e-01f, 3.17158043e-01f, 5.38780615e-02f, -2.22178861e-01f, -5.80951478e-03f, -6.17180645e-01f, -2.65574127e-01f, -4.28354800e-01f, -4.04301643e-01f,
  -6.57242596e-01f, -2.70790994e-01f, -2.62909085e-01f, 1.80790007e-01f, -3.02144349e-01f, 4.91162464e-02f, -9.74615067e-02f, -1.35052711e-01f, 1.26214281e-01f, -6.58800453e-02f,
  -5.83997965e-02f, -4.66147140e-02f, -2.83216387e-02f, -3.92122529e-02f, -1.88407347e-01f, -7.82934055e-02f, 7.45432675e-02f, -2.16615602e-01f, -2.00005829e-01f, -2.08115637e-01f,
  2.05640271e-01f, -1.01709310e-02f, -1.48463339e-01f, -1.30145207e-01f, -2.56654352e-01f, -4.41648737e-02f, -2.97414094e-01f, -3.71137768e-01f, -4.61206526e-01f, 4.15382273e-02f,
  3.76084968e-02f, -2.70562395e-02f, -1.65495008e-01f, 1.27093136e-01f, 2.11924568e-01f, -6.51313588e-02f, -5.25316708e-02f, 6.07900657e-02f, -6.55133976e-03f, 1.13094887e-02f,
  6.55217394e-02f, -5.47837354e-02f, 2.51291948e-03f, 1.69413596e-01f, -1.32696360e-01f, 1.08420867e-02f, 9.48849097e-02f, 5.35781980e-02f, 1.91981462e-03f, 5.19854389e-02f,
  5.73377833e-02f, -1.50611037e-02f, 1.71219278e-02f, 1.17817044e-01f, 7.18795601e-03f, -5.22176586e-02f, -3.22498754e-02f, -6.00299705e-03f, 6.99807331e-02f, 6.22179396e-02f,
  4.65162456e-01f, -2.12423354e-01f, 7.61351548e-03f, -1.11692928e-01f, -1.25379309e-01f, -2.59595066e-02f, 3.96836586e-02f, 1.69198848e-02f, 5.00933453e-02f, 7.54542351e-02f,
  -2.03000322e-01f, -5.55651216e-03f, -5.46438247e-02f, -1.16534583e-01f, -1.13701448e-01f, -1.07255261e-02f, 1.34402409e-01f, 7.28295594e-02f, 9.40036401e-02f, -6.94762077e-03f,
  4.22093235e-02f, 1.04162157e-01f, 3.18684131e-01f, 1.56296387e-01f, 1.03823453e-01f, 1.08277440e-01f, -7.99042359e-02f, -2.37669155e-01f, 3.95989157e-02f, 3.01980764e-01f,
  4.84109730e-01f, 9.42492262e-02f, 1.32157773e-01f, 1.55625895e-01f, -1.15938872e-01f, -1.03130646e-01f, -4.74200808e-02f, 2.03951821e-01f, 1.84737980e-01f, 1.03337131e-01f,
  -1.16539542e-02f, 2.44453207e-01f, 2.74454564e-01f, 2.61969119e-01f, 3.04778963e-01f, 1.11029096e-01f, 2.65761167e-01f, 3.19890201e-01f, 2.01196581e-01f, 1.98201910e-01f,
  2.39495412e-01f, 1.71218053e-01f, 1.02160998e-01f, 2.50986487e-01f, 1.61180228e-01f, 2.25146294e-01f, 1.01299725e-01f, 6.89455494e-02f, 1.41657472e-01f, 3.33949924e-01f,
  3.30913477e-02f, 8.56308490e-02f, 6.33669421e-02f, -4.11260091e-02f, -1.31055459e-01f, -1.42722890e-01f, -7.48013631e-02f, -1.23327583e-01f, -5.50470650e-02f, -7.13089854e-02f,
  -1.40690401e-01f, -3.20595466e-02f, -1.29966766e-01f, -1.11041948e-01f, -1.15485579e-01f, -1.00726016e-01f, 9.23997462e-02f, 1.41682476e-01f, -5.47648873e-03f, 2.37108488e-02f,
  -3.15310224e-03f, -5.40391058e-02f, -1.86259478e-01f, -7.45841414e-02f, 1.53074369e-01f, 6.21453375e-02f, -7.74229616e-02f, -3.24784964e-02f, -1.49173504e-02f, 3.18092294e-02f,
  1.20448932e-01f, 1.72420926e-02f, 4.60132100e-02f, 1.64181769e-01f, 1.75866365e-01f, 2.23897323e-02f, 4.15461399e-02f, 5.65288253e-02f, 1.45800412e-01f, -5.28274626e-02f,
  5.36278486e-02f, 5.05503863e-02f, 1.15170985e-01f, 8.61451775e-02f, 6.17554970e-02f, 4.32148622e-03f, -8.52427259e-02f, 9.17623378e-03f, 9.03214701e-03f, -3.45164575e-02f,
  -9.59708467e-02f, 2.91943382e-02f, -9.98748243e-02f, -2.19883602e-02f, 6.12772219e-02f, 6.74894592e-03f, 2.06358079e-02f, -6.65219054e-02f, -2.75683943e-02f, 7.23900506e-03f,
  -3.24300736e-01f, -1.97236896e-01f, 2.27490976e-01f, -6.34692311e-02f, -4.81442288e-02f, -1.32087067e-01f, 4.09214199e-02f, -1.50737718e-01f, -1.67361155e-01f, -5.58700822e-02f,
  -1.03523113e-01f, -5.39649054e-02f, -2.77017113e-02f, -1.21085336e-02f, -1.03100508e-01f, -4.68811542e-02f, -7.43093193e-02f, 2.44267657e-02f, -1.34029925e-01f, -8.42289999e-02f,
  -1.17812321e-01f, -2.17606023e-01f, -1.92706361e-01f, -1.01688229e-01f, -6.00661188e-02f, -5.33692837e-02f, -1.03261895e-01f, -1.43344089e-01f, -1.56859919e-01f, -1.01728871e-01f,
  6.61486745e-01f, 4.56695616e-01f, 2.78813273e-01f, 2.38736197e-01f, 4.16402519e-01f, 2.95754641e-01f, 4.36680138e-01f, 1.58802524e-01f, -3.05294618e-02f, 3.26518297e-01f,
  3.60034823e-01f, 1.57159761e-01f, 1.67155289e-03f, -8.16382095e-02f, -4.94247079e-02f, 9.19885337e-02f, -4.47135605e-02f, 9.09826811e-03f, 6.88852742e-02f, 1.44833058e-01f,
  2.83768862e-01f, 2.69478440e-01f, 2.29646459e-01f, 5.06818406e-02f, 1.79135829e-01f, 1.46167308e-01f, 2.40353584e-01f, 4.64879870e-01f, 4.42884088e-01f, -2.67984793e-02f,
  -6.65707812e-02f, 4.98721272e-01f, -3.01904023e-01f, -4.86210734e-03f, -1.37377298e-02f, -1.73156500e-01f, -7.76512250e-02f, -7.93029964e-02f, 5.57482541e-02f, -6.82300031e-02f,
  -3.05900220e-02f, -1.32543352e-02f, 7.40845650e-02f, -4.80526686e-02f, -2.17462797e-02f, -7.88380578e-02f, -1.31948352e-01f, -1.60941809e-01f, -1.51774496e-01f, -1.45959714e-02f,
  6.47373870e-02f, 2.99979776e-01f, 2.27792993e-01f, -2.30315793e-02f, -3.62689719e-02f, 1.10784926e-01f, 1.22287720e-01f, 1.68595929e-02f, -4.76351306e-02f, -1.14277698e-01f,
  -1.80024266e-01f, 1.82060957e-01f, 2.34547198e-01f, -3.74322794e-02f, 3.25704366e-02f, -4.01406847e-02f, -9.03079938e-03f, 9.30202752e-02f, 1.08022138e-01f, 7.05278143e-02f,
  -7.33904466e-02f, -2.25784108e-02f, -7.66968876e-02f, -3.57432961e-02f, -6.37956113e-02f, 7.23620206e-02f, -4.34836969e-02f, -4.16203626e-02f, 5.51017933e-02f, 9.34499782e-03f,
  3.09156757e-02f, -6.59867302e-02f, 1.81999821e-02f, -1.00658797e-02f, -2.93835122e-02f, -3.47372238e-03f, -3.35815586e-02f, 5.46798483e-02f, -5.99439768e-03f, 4.17399108e-02f,
  -2.68146604e-01f, 1.69501737e-01f, -2.44755417e-01f, -6.11732975e-02f, 8.32839757e-02f, 1.34176789e-02f, 5.98425679e-02f, -2.61422042e-02f, -1.70572717e-02f, -1.93977192e-01f,
  -4.85101864e-02f, -1.11538939e-01f, -2.78657898e-02f, -2.37656087e-01f, -1.58115178e-01f, -1.66750491e-01f, -6.55755326e-02f, -8.23729783e-02f, -1.95190907e-01f, -1.94821045e-01f,
  -1.91234678e-01f, -6.70296401e-02f, -6.22542575e-02f, -2.60051489e-01f, -7.81942755e-02f, -1.42035916e-01f, -1.52491376e-01f, -1.24882780e-01f, -1.24018148e-01f, -1.67861521e-01f,
  1.51742607e-01f, -7.45577589e-02f, 2.92771459e-01f, 3.16509962e-01f, -3.84321138e-02f, -4.20943171e-01f, -8.09366167e-01f, -4.95395631e-01f, 1.52242497e-01f, 6.34880140e-02f,
  3.15993279e-02f, 9.19375271e-02f, 1.34769052e-01f, -8.10501948e-02f, -2.54662961e-01f, -1.76057070e-01f, 1.69890568e-01f, 4.06851061e-02f, -1.37071997e-01f, -3.22392225e-01f,
  3.77324633e-02f, 1.49146602e-01f, 1.37476832e-01f, -3.67278606e-02f, 2.93585151e-01f, 1.43506944e-01f, 3.25518608e-01f, 2.66885757e-01f, 8.01460817e-02f, 5.86498439e-01f,
  5.36746562e-01f, 1.26490891e-01f, -1.76631108e-01f, 1.04518039e-02f, 2.92427659e-01f, -6.16672635e-02f, 4.37643565e-02f, 1.76444307e-01f, 7.26250336e-02f, -6.16610274e-02f,
  1.66186303e-01f, 1.06486887e-01f, -1.06500899e-02f, 3.13112885e-02f, -5.73032610e-02f, -1.18570300e-02f, -4.91395332e-02f, -3.88787724e-02f, -4.22580680e-03f, 4.66864817e-02f,
  -5.39523587e-02f, -9.90911275e-02f, -1.52105197e-01f, -2.45679036e-01f, -5.90374693e-02f, -4.93332893e-02f, -4.90699820e-02f, 8.86782184e-02f, -3.69524695e-02f, 6.85424451e-03f,
  -1.51908427e-01f, 9.39556956e-02f, 1.13716058e-01f, 3.01810484e-02f, -1.28969967e-01f, 8.66919905e-02f, 1.23558454e-01f, -1.39260814e-02f, -1.06952731e-02f, 2.41119582e-02f,
  3.00118327e-02f, 5.00530079e-02f, 1.12273678e-01f, 6.68493509e-02f, 4.46329974e-02f, 1.02706455e-01f, 1.75075665e-01f, 2.51420662e-02f, -8.20663199e-02f, 2.17174366e-02f,
  -2.35240888e-02f, 6.46239594e-02f, 2.19792232e-01f, 1.45927984e-02f, -5.25940172e-02f, 7.48961940e-02f, 1.01070754e-01f, -6.38055131e-02f, -5.17699011e-02f, 1.41192749e-01f,
  1.43537978e-02f, -3.84414405e-01f, 6.52793795e-02f, -6.50202408e-02f, 2.25860253e-01f, 6.74295425e-02f, 6.43609837e-02f, 4.00879001e-03f, 1.26468927e-01f, -7.54855126e-02f,
  -3.82610522e-02f, -3.49264778e-02f, 7.08058327e-02f, -6.23245947e-02f, -1.77364364e-01f, 4.27154452e-03f, -1.51949627e-02f, 2.17998549e-02f, -4.47679162e-02f, 1.25792578e-01f,
  -5.49239404e-02f, -4.81880993e-01f, -4.79099661e-01f, -2.36337736e-01f, 2.65301559e-02f, -2.28746116e-01f, -1.89893812e-01f, -1.25038818e-01f, -1.84404701e-01f, -4.41159904e-01f,
  7.19036579e-01f, -1.52439341e-01f, 5.26994348e-01f, 3.23228925e-01f, 2.95151472e-01f, 3.87434632e-01f, 3.46282095e-01f, 1.91612810e-01f, 5.56629971e-02f, -4.95328270e-02f,
  -2.32475191e-01f, -1.91359103e-01f, -2.26782084e-01f, -2.56716877e-01f, -4.60881591e-02f, 2.30885476e-01f, 2.36083940e-01f, 2.35583678e-01f, 3.39081109e-01f, 2.31892884e-01f,
  -4.51330058e-02f, 5.60075603e-02f, 8.90329182e-02f, -4.51630307e-03f, -7.75154531e-02f, -1.61579534e-01f, -3.30245718e-02f, -4.60811965e-02f, -1.56555325e-01f, -8.03406462e-02f,
  -2.88529277e-01f, 1.14442468e-01f, -1.04554206e-01f, -3.09002101e-01f, -1.89383715e-01f, -6.76976889e-02f, 8.49599764e-02f, -4.23106644e-03f, -1.70276046e-01f, -7.57122561e-02f,
  -1.97955698e-01f, -3.80148664e-02f, 3.09845377e-02f, -8.59244764e-02f, -7.82246981e-03f, -9.34681073e-02f, -6.94240928e-02f, 3.82022373e-02f, 9.33119468e-03f, -1.22809902e-01f,
  -1.10677205e-01f, 1.52754843e-01f, 1.06989563e-01f, 6.41248971e-02f, 1.03398420e-01f, 4.92552295e-03f, 3.81577853e-03f, 7.06611872e-02f, 1.15294427e-01f, 2.11201221e-01f,
  5.46126179e-02f, 3.42225969e-01f, 1.15733325e-01f, 3.07462458e-02f, -5.24008181e-03f, 1.62294134e-02f, 1.24540590e-01f, 4.46475260e-02f, 1.49616063e-01f, 9.56509039e-02f,
  4.18029428e-02f, 8.49258825e-02f, 7.69950971e-02f, 1.98286071e-01f, 1.43679291e-01f, 1.89381376e-01f, 8.81598145e-02f, -9.02131870e-02f, -1.10207409e-01f, -1.66183457e-01f,
  1.57219723e-01f, 1.49000153e-01f, 7.64329955e-02f, 7.64730051e-02f, 2.72353087e-02f, 1.57968879e-01f, 1.44492716e-01f, 2.27150451e-02f, 1.29281759e-01f, 1.44535258e-01f,
  -6.65006816e-01f, -1.26078919e-01f, -2.65110824e-02f, 5.79114333e-02f, 2.30404828e-02f, -1.08836383e-01f, 8.72766972e-02f, -4.40940373e-02f, -2.34457016e-01f, -9.67160389e-02f,
  -1.06846299e-02f, 8.37706495e-03f, 1.78590957e-02f, 5.55980466e-02f, 5.02678752e-02f, -2.25097053e-02f, -8.27271193e-02f, 5.13482802e-02f, -7.63391554e-02f, -2.95566469e-02f,
  -1.48892039e-02f, 1.72606021e-01f, 1.26766846e-01f, 2.10583076e-01f, 4.17164266e-02f, 2.25804490e-03f, 5.22666909e-02f, 6.89321477e-03f, 2.05727860e-01f, 1.18988089e-01f,
  -6.87048256e-01f, 5.55649638e-01f, -6.08904241e-03f, -2.63255656e-01f, 1.05180815e-01f, 4.69082482e-02f, 4.64484274e-01f, 1.28580272e-01f, -2.32636575e-02f, 3.74480456e-01f,
  6.29217699e-02f, -1.48942083e-01f, 4.90645878e-02f, 5.04608229e-02f, 3.27627803e-03f, 4.02346045e-01f, 3.84054095e-01f, -2.29959905e-01f, -5.32255411e-01f, -2.73023725e-01f,
  8.91513005e-02f, -3.77862036e-01f, -5.11046410e-01f, -2.12518170e-01f, 1.57101333e-01f, -3.84140052e-02f, 2.43981108e-01f, -6.49970025e-02f, 1.88028544e-01f, 3.41556460e-01f,
  -1.51107058e-01f, -3.20401877e-01f, -1.01249613e-01f, -1.69955671e-01f, -2.15605157e-03f, -1.48579568e-01f, 7.71799833e-02f, -1.70796871e-01f, -1.18870795e-01f, 1.45461308e-02f,
  -1.00929193e-01f, -7.21078590e-02f, -1.80691600e-01f, -1.31244615e-01f, -2.51662225e-01f, -1.27454549e-01f, -2.81528413e-01f, -2.83789635e-01f, -1.67280808e-01f, -2.34363511e-01f,
  2.62344539e-01f, -1.41778782e-01f, -1.53483346e-01f, 5.89116588e-02f, 2.69718990e-02f, -6.85690343e-02f, -3.91462110e-02f, -2.23231584e-01f, -2.00897023e-01f, -1.11036874e-01f,
  -6.00002706e-02f, -7.25662783e-02f, 6.53692037e-02f, 4.50138152e-02f, -6.92290440e-02f, -8.19005147e-02f, -3.14356834e-02f, 4.63319533e-02f, -4.11161818e-02f, -4.07874100e-02f,
  -1.33934513e-01f, -1.01467952e-01f, 7.52515742e-04f, -8.09392259e-02f, -2.37793662e-03f, -6.69369847e-02f, 1.65849283e-01f, 1.21464945e-01f, 5.66743687e-02f, 9.47117656e-02f,
  -8.18872228e-02f, 9.67590436e-02f, -3.84211983e-03f, 2.81105954e-02f, 1.73682988e-01f, 1.21068321e-01f, 9.76800248e-02f, 1.09200485e-01f, 1.07157744e-01f, 1.14136888e-02f,
  -2.32655123e-01f, 1.24084897e-01f, -5.24120964e-02f, 6.19957298e-02f, 9.61280018e-02f, 7.89447036e-03f, 1.22018017e-01f, 1.18369550e-01f, 8.03476721e-02f, -1.79490194e-01f,
  -1.07928142e-01f, 2.38033868e-02f, 1.24021545e-02f, -2.27472745e-02f, -2.54870683e-01f, 7.01226667e-02f, 1.27542898e-01f, -7.41255954e-02f, 4.91311140e-02f, -6.85175583e-02f,
  3.16150814e-01f, 5.04595004e-02f, -5.45915961e-02f, 1.84318870e-01f, 7.96143860e-02f, 8.18476304e-02f, -2.86209881e-02f, -9.00701880e-02f, -5.48889749e-02f, 2.03599989e-01f,
  5.05653799e-01f, 7.06068575e-02f, 2.00218305e-01f, 2.98054516e-02f, 1.19647384e-01f, 2.78595507e-01f, 4.50167835e-01f, 2.99037725e-01f, 2.35980861e-02f, 5.08227050e-02f,
  -4.19065028e-01f, -6.96300864e-01f, -4.46333617e-01f, -3.62275153e-01f, -1.64828986e-01f, 2.26511255e-01f, 2.95638025e-01f, 4.27388847e-02f, -3.13358419e-02f, 1.26268208e-01f,
  -1.06424682e-01f, 2.75830388e-01f, 2.65396863e-01f, 1.37349516e-01f, 7.89471269e-02f, -1.29444480e-01f, 2.28865355e-01f, 6.88422844e-02f, -3.10387909e-02f, -5.93958503e-05f,
  -3.77167910e-01f, 5.17285801e-02f, -6.42339438e-02f, -1.53347418e-01f, -2.75083750e-01f, -1.46487057e-01f, -1.34271860e-01f, -1.35290831e-01f, -5.56556918e-02f, 2.30746940e-02f,
  -2.25303933e-01f, -1.42116889e-01f, -3.61812204e-01f, -6.35281019e-03f, 3.30831297e-02f, 5.49621619e-02f, 8.15325677e-02f, 4.47768047e-02f, -1.36615306e-01f, -1.89560100e-01f,
  -3.32175612e-01f, -9.99963060e-02f, 2.21050940e-02f, 9.79496315e-02f, -1.00740142e-01f, -2.94573754e-01f, 5.19496650e-02f, 2.22595949e-02f, -1.70420692e-03f, 2.54114449e-01f,
  -7.15573803e-02f, -7.44231343e-02f, 5.39573282e-02f, 7.25837052e-02f, 9.57319736e-02f, 4.77869296e-03f, -7.66129941e-02f, 6.65622298e-03f, 7.57636577e-02f, 2.25953549e-01f,
  -6.08063005e-02f, -1.35955215e-01f, -1.21212311e-01f, -4.44924366e-03f, -9.71167311e-02f, -1.29181281e-01f, 9.07782763e-02f, 2.21486036e-02f, 1.56906098e-02f, 7.12975040e-02f,
  -2.94396672e-02f, 1.31969795e-01f, 2.89683379e-02f, 2.26379763e-02f, -3.30358520e-02f, -4.36009876e-02f, -6.79544434e-02f, -1.39974996e-01f, -6.06862828e-02f, -2.79022544e-03f,
  1.42330050e-01f, -4.19653118e-01f, -4.87741120e-02f, -3.83098125e-02f, -7.46321008e-02f, -1.14733689e-01f, -2.68809974e-01f, -3.62768248e-02f, -4.97256182e-02f, -5.96629046e-02f,
  -1.11553401e-01f, -1.38069540e-01f, -1.80893332e-01f, -2.60919761e-02f, 1.77207291e-01f, 1.41670257e-02f, -9.05280933e-02f, 6.04988299e-02f, -3.42170969e-02f, -2.19320515e-04f,
  1.85217056e-02f, 3.36567700e-01f, 2.66934693e-01f, 1.20771654e-01f, -1.80997357e-01f, -3.18681151e-02f, 7.27885962e-02f, 6.59188032e-02f, 5.10450006e-02f, 4.85493988e-01f,
  -1.78705037e-01f, 2.44680613e-01f, -2.35504001e-01f, 3.08855295e-01f, 1.61059201e-01f, -2.31435344e-01f, -2.64232069e-01f, -3.12618762e-01f, 1.84544683e-01f, 7.39373043e-02f,
  6.29250929e-02f, 1.41622722e-01f, 2.33284891e-01f, 4.15027253e-02f, -1.89785793e-01f, 2.38968693e-02f, 1.82188541e-01f, -9.36607569e-02f, -4.21720773e-01f, -1.60684854e-01f,
  2.91808307e-01f, 8.53326544e-03f, -2.32486486e-01f, -5.61301038e-02f, 2.47610196e-01f, 1.08066745e-01f, -2.56046988e-02f, 1.07295275e-01f, 1.72224760e-01f, 5.13062298e-01f,
  2.74578124e-01f, -1.12584561e-01f, -3.78802478e-01f, -3.51468809e-02f, -1.04032688e-01f, -2.92220801e-01f, -1.46376729e-01f, -1.19844481e-01f, -1.07471555e-01f, -1.31318286e-01f,
  1.03558384e-01f, 1.11679384e-03f, 9.60130841e-02f, -3.13159227e-02f, -9.07795802e-02f, -3.83810788e-01f, -1.59351736e-01f, -2.51271576e-01f, -2.60679930e-01f, -2.71844506e-01f,
  3.51845562e-01f, 2.31851816e-01f, -1.49893209e-01f, -3.21467191e-01f, -2.93674320e-01f, -7.37143308e-02f, -3.23915511e-01f, -2.15922251e-01f, -4.36344832e-01f, -5.42754792e-02f,
  -3.21900547e-02f, -1.02444338e-02f, 8.08558837e-02f, 1.42144263e-01f, -2.96881646e-02f, -1.30605949e-02f, 1.31460577e-01f, -9.56411585e-02f, 3.83073241e-02f, -3.54923345e-02f,
  -6.27018213e-02f, -2.20895723e-01f, -1.04896940e-01f, -1.69866949e-01f, 1.02561004e-01f, -6.71396777e-02f, -1.23686805e-01f, -7.69359618e-02f, 1.35700060e-02f, -7.22946972e-03f,
  2.11151615e-01f, -7.27260634e-02f, 1.03658764e-02f, -1.71595752e-01f, -9.91336033e-02f, 8.17876589e-03f, 7.45408162e-02f, -1.27177939e-01f, 3.15859951e-02f, 2.60659400e-02f,
  -1.44804820e-01f, -2.65786469e-01f, 4.82690521e-02f, 5.12629747e-02f, 9.09196883e-02f, -8.90107527e-02f, 8.61973390e-02f, 2.82402579e-02f, 6.23206533e-02f, -2.41925120e-01f,
  -1.91995978e-01f, -1.76973030e-01f, 2.91031040e-02f, 7.84137696e-02f, -1.43773347e-01f, -7.79415816e-02f, -2.36048419e-02f, -1.19964890e-01f, -6.12497255e-02f, -1.92929432e-01f,
  -5.84439300e-02f, -8.21024403e-02f, -3.34510170e-02f, -2.40709960e-01f, -6.75730547e-03f, -7.93734416e-02f, -1.99092939e-01f, -2.12953433e-01f, -2.37042189e-01f, -2.75246143e-01f,
  6.91636875e-02f, 9.85103920e-02f, -1.88310578e-01f, 2.70920366e-01f, 1.91096485e-01f, -3.48217010e-01f, -4.60928112e-01f, -2.49186039e-01f, 2.93443650e-01f, 1.97445318e-01f,
  3.10553133e-01f, -3.40361483e-02f, -8.08385387e-02f, -3.90017629e-01f, -8.15700948e-01f, -4.62025344e-01f, -3.30105513e-01f, -6.43071115e-01f, -7.92668641e-01f, -3.54834586e-01f,
  -7.47755617e-02f, 1.90329400e-03f, -1.54067278e-01f, -6.84979409e-02f, 5.75760365e-01f, 1.85535640e-01f, 3.21824759e-01f, 2.88395971e-01f, 4.61535938e-02f, 4.18839484e-01f,
  1.35561913e-01f, 5.33491820e-02f, -6.11334443e-02f, -5.01798131e-02f, 2.53109843e-01f, -1.09667182e-01f, -1.99941963e-01f, -9.02506560e-02f, 4.20600548e-02f, -5.91629595e-02f,
  6.61153272e-02f, 2.65105488e-03f, -1.32476106e-01f, -6.76341206e-02f, 5.92414439e-02f, -1.32593706e-01f, -1.93033427e-01f, -2.64699757e-01f, -1.56648934e-01f, 1.19785197e-01f,
  -7.78671280e-02f, -4.94360998e-02f, 8.56976733e-02f, -7.75369108e-02f, -2.23900422e-01f, -3.87577191e-02f, 8.85117278e-02f, 1.24224909e-01f, -1.42326102e-01f, 3.09846193e-01f,
  1.35781527e-01f, -6.39615655e-02f, 1.03927655e-02f, 8.37650821e-02f, 9.14398804e-02f, -6.08175695e-02f, 9.27645899e-03f, 2.23146509e-02f, -4.19580787e-02f, -1.12124592e-01f,
  -9.25386101e-02f, -8.23036358e-02f, 4.85355705e-02f, 2.95920148e-02f, 5.73287904e-02f, -6.05427697e-02f, 1.99577823e-01f, 6.28397092e-02f, 7.50500709e-04f, 1.62813649e-01f,
  -6.35713711e-02f, 8.84470418e-02f, 8.77421647e-02f, 2.99565736e-02f, 1.12626396e-01f, 1.10123036e-02f, 5.58544286e-02f, 1.27852038e-01f, -1.27540469e-01f, 7.63061717e-02f,
  2.33209297e-01f, -2.99697667e-01f, 2.69604594e-01f, -9.25684050e-02f, 2.76487656e-02f, -2.75867525e-02f, 2.52813756e-01f, 1.23114353e-02f, 2.45356038e-01f, 8.09444934e-02f,
  -1.08209789e-01f, 3.50610428e-02f, -2.96153761e-02f, 4.90605272e-02f, -1.11321755e-01f, 5.35992496e-02f, -2.87711740e-01f, -3.05973794e-02f, -1.99479192e-01f, 2.35987619e-01f,
  1.21817971e-03f, -1.07491508e-01f, -1.98503211e-01f, 5.78896180e-02f, -6.82120845e-02f, -3.21084373e-02f, 6.24106340e-02f, 2.13141620e-01f, -1.13595620e-01f, 1.76204890e-01f,
  -5.63195884e-01f, 4.11257111e-02f, 1.22078262e-01f, -4.64209437e-01f, -7.72370920e-02f, 2.49179304e-01f, 2.87998140e-01f, 4.62220237e-02f, -2.99181730e-01f, 6.50043339e-02f,
  2.16910932e-02f, -2.89949387e-01f, -3.21755141e-01f, -2.98760265e-01f, -1.75843015e-01f, 2.60247127e-03f, -2.70461917e-01f, -3.19357902e-01f, -2.73732513e-01f, 2.32523866e-02f,
  -1.46782756e-01f, -4.69206333e-01f, -3.84221911e-01f, -4.01238024e-01f, -2.57698923e-01f, -5.16080439e-01f, -3.10235500e-01f, -2.55538136e-01f, 4.51430008e-02f, -2.52889663e-01f,
  1.65586770e-01f, 2.55899191e-01f, -1.07018031e-01f, -9.90252048e-02f, -2.45923400e-02f, -2.29861587e-03f, 5.59676997e-02f, -1.25346318e-01f, -6.16738833e-02f, 1.24682495e-02f,
  -2.06395201e-02f, -3.38763632e-02f, -1.40176728e-01f, -3.18578444e-02f, -6.97840154e-02f, 8.93592611e-02f, 2.43694082e-01f, 1.52594388e-01f, 1.43597394e-01f, 2.26055413e-01f,
  2.37498760e-01f, 2.67501831e-01f, 2.65594393e-01f, 2.54030347e-01f, 3.11664701e-01f, 4.06119749e-02f, 3.19562018e-01f, 2.74345845e-01f, 1.83808237e-01f, -3.03784423e-02f,
  1.03813214e-02f, -7.60401562e-02f, 5.12256883e-02f, -1.53720016e-02f, 3.95990573e-02f, 1.27293259e-01f, -1.51341464e-02f, -1.48939371e-01f, -3.60099114e-02f, -4.58257087e-02f,
  7.17411190e-02f, 1.02707259e-01f, 9.12541971e-02f, -1.68963939e-01f, -3.20871137e-02f, 3.56136300e-02f, -2.15825476e-02f, 1.48957958e-02f, 6.45745993e-02f, 3.81198116e-02f,
  5.50028346e-02f, 3.40871476e-02f, -1.04878023e-01f, 7.88190365e-02f, 2.74289668e-01f, 7.73900300e-02f, 1.58712536e-01f, -1.36206485e-02f, 5.40692098e-02f, 8.52181017e-02f,
  -3.08068335e-01f, 1.87772080e-01f, -2.37937644e-01f, -5.37216105e-02f, -2.35122703e-02f, 7.13967159e-02f, 4.92053591e-02f, 5.02272844e-02f, 1.50062339e-02f, 7.20540881e-02f,
  1.46347508e-01f, -8.21923539e-02f, -6.46526292e-02f, -4.52983454e-02f, -1.25164658e-01f, 7.34091103e-02f, 1.56319439e-01f, -7.01189339e-02f, 8.67949724e-02f, 1.07871793e-01f,
  2.34649889e-02f, 6.67786300e-02f, -1.92852378e-01f, 4.82205003e-02f, 6.12359494e-02f, -5.79392053e-02f, 8.59485008e-04f, -9.80040245e-03f, 9.57002805e-04f, -2.81102717e-01f,
  -1.12065780e+00f, -1.15744740e-01f, 1.88877508e-01f, -5.21021426e-01f, 1.11442283e-02f, 1.14830054e-01f, 4.58662927e-01f, -5.38466349e-02f, -3.56972575e-01f, 6.04715869e-02f,
  5.27430996e-02f, -1.07925683e-01f, 2.48591416e-02f, 1.44562259e-01f, 7.96331242e-02f, 5.18614948e-01f, 3.94501537e-01f, 9.65741500e-02f, 1.21364862e-01f, 3.08329239e-02f,
  1.29413858e-01f, -2.04265371e-01f, -4.18200076e-01f, -1.76533163e-01f, -1.10874936e-01f, 7.46011660e-02f, 1.32780850e-01f, -5.77659346e-03f, 1.36322826e-01f, 1.13777280e-01f,
  5.67898631e-01f, -4.75167245e-01f, -1.93542782e-02f, -1.90404862e-01f, -1.13708794e-01f, -2.83044726e-01f, -7.84023777e-02f, -1.75678059e-01f, -2.18788713e-01f, 2.95085087e-02f,
  -1.35683298e-01f, -2.95155942e-02f, -4.90243211e-02f, -6.91989530e-03f, -9.01655033e-02f, -1.56028092e-01f, -1.18898086e-01f, -3.91367301e-02f, 8.17441270e-02f, 5.76844178e-02f,
  2.35704575e-02f, -7.71988630e-02f, 1.44571885e-01f, 1.45053193e-01f, 6.92995340e-02f, 6.39304742e-02f, 1.84888840e-02f, -2.02619150e-01f, -2.48621348e-02f, -1.65086970e-01f,
  1.05500378e-01f, 1.55949548e-01f, 2.99607832e-02f, -6.47892477e-03f, 1.16171122e-01f, 1.98472857e-01f, 7.32947811e-02f, 9.41129178e-02f, 5.86620905e-02f, 2.35099271e-02f,
  -3.68545242e-02f, 7.82969967e-02f, 1.62074968e-01f, -1.28625492e-02f, -4.31260765e-02f, 6.37504179e-03f, 4.43079285e-02f, -7.44762504e-03f, -6.81537241e-02f, -1.01946563e-01f,
  -2.48836782e-02f, 2.10283771e-02f, -1.34947971e-01f, 5.54373413e-02f, -7.22758770e-02f, -1.79833278e-01f, -1.21696778e-02f, -5.03185727e-02f, -4.99083288e-02f, 3.25513855e-02f,
  3.84786129e-01f, 9.49230120e-02f, 1.59862071e-01f, 8.24347585e-02f, -6.19166903e-02f, -2.09525883e-01f, -8.73160511e-02f, -5.05723804e-02f, -1.61666721e-02f, 1.72010198e-01f,
  -3.95714119e-03f, -4.33195941e-02f, 3.79759297e-02f, -2.37834593e-03f, -1.74140837e-02f, -2.51903310e-02f, -3.72439474e-02f, -4.30811346e-02f, 6.03732057e-02f, 3.99087593e-02f,
  -6.52060211e-02f, 5.11663705e-02f, 1.22026332e-01f, 2.49290615e-01f, 1.21640846e-01f, 1.72409058e-01f, 1.05928130e-01f, 1.51943237e-01f, 1.45601794e-01f, 1.86411381e-01f,
  -4.42970619e-02f, 4.03363049e-01f, -8.89337599e-01f, 1.55088808e-02f, -4.76181120e-01f, -2.82258958e-01f, 6.60347715e-02f, 4.55871463e-01f, 2.85977066e-01f, 6.51103333e-02f,
  -3.88658680e-02f, -1.99172184e-01f, -2.39923596e-01f, -1.71588078e-01f, -7.60172606e-02f, -9.58355740e-02f, -2.38943785e-01f, -5.61625361e-01f, -5.74416697e-01f, -1.25462234e-01f,
  -9.86514613e-02f, -3.25871646e-01f, -2.55464852e-01f, -9.37946960e-02f, -5.05756065e-02f, -3.51288825e-01f, -4.82503623e-01f, -5.32946765e-01f, -4.05780017e-01f, -5.81656992e-01f,
  -8.32626462e-01f, -1.66466862e-01f, -1.06710941e-01f, -1.86977815e-02f, -2.04690427e-01f, 1.40523210e-01f, 7.63391256e-02f, -4.71076183e-02f, 1.06683865e-01f, 3.62229086e-02f,
  -1.97585016e-01f, 1.11904703e-01f, -2.08840638e-01f, -1.38485476e-01f, -1.81932166e-01f, -1.66755825e-01f, -4.22850102e-02f, -1.18945919e-01f, -6.02877699e-03f, 1.87868416e-01f,
  2.41059102e-02f, -1.88358784e-01f, -1.10797487e-01f, 1.31025583e-01f, 1.12177968e-01f, -8.69137198e-02f, -1.33964112e-02f, -1.79631170e-02f, -6.08946234e-02f, 9.20410305e-02f,
  2.12989122e-01f, 7.60232881e-02f, -3.57151181e-02f, 1.24911219e-01f, 7.81457499e-02f, -4.65727486e-02f, -5.80572849e-03f, 3.28672789e-02f, 2.76119933e-02f, 1.88236590e-02f,
  2.13292185e-02f, -3.05313058e-02f, -3.11602186e-02f, -7.12425495e-03f, -2.26652473e-01f, -2.32741218e-02f, -5.06252311e-02f, -2.45503266e-03f, -4.28413078e-02f, -1.09722078e-01f,
  -8.06116909e-02f, -9.55085754e-02f, -3.83393876e-02f, -9.61823165e-02f, -7.10253194e-02f, -1.24538749e-01f, -1.46429818e-02f, 6.59535080e-02f, -9.65834875e-03f, 1.09835654e-01f,
  8.28052498e-03f, -2.54731864e-01f, 9.84348729e-02f, 2.13164300e-01f, 1.01845935e-01f, 3.71715762e-02f, -8.77918974e-02f, 1.79989561e-02f, -2.13538781e-02f, -1.07693218e-01f,
  -1.94340110e-01f, 6.36121840e-04f, -2.26183273e-02f, 9.54302028e-02f, -1.64738014e-01f, -3.26045565e-02f, 4.22636531e-02f, -4.73580472e-02f, 1.05187036e-01f, 3.33081335e-01f,
  2.65923291e-01f, 6.31563738e-02f, 1.09106638e-01f, 3.55577618e-02f, 9.35264602e-02f, -5.41843753e-03f, -3.33979763e-02f, 2.72231326e-02f, 4.37147282e-02f, 3.99864346e-01f,
  -7.81305075e-01f, -5.92228591e-01f, -3.89111694e-03f, 5.06966263e-02f, 6.67892694e-02f, -8.87566060e-02f, -3.12761009e-01f, -2.68025726e-01f, -7.09011406e-02f, -3.73460174e-01f,
  -4.02283967e-01f, 2.68075392e-02f, 1.31070152e-01f, 1.70186430e-01f, 1.18988447e-01f, -2.35999878e-02f, 3.93671453e-01f, 4.98195738e-01f, 1.68858990e-01f, -1.34859934e-01f,
  1.43261164e-01f, 1.80481195e-01f, 1.80060506e-01f, 1.75484851e-01f, 6.88227937e-02f, 2.32044995e-01f, 2.59129703e-01f, 6.82426393e-02f, 8.21031444e-03f, 1.91965997e-01f,
  -5.61210334e-01f, -5.23308039e-01f, 3.04200143e-01f, 3.81326713e-02f, 3.81472446e-02f, -3.71039718e-01f, -1.65436327e-01f, -2.63274094e-04f, -7.97520578e-02f, -1.09815327e-02f,
  1.26691625e-01f, -2.70628452e-01f, 1.19927377e-01f, 5.07053174e-02f, 4.83843982e-02f, -7.75868073e-02f, 3.03603619e-01f, 2.96563804e-01f, 5.39971516e-02f, -1.98700055e-01f,
  2.75095612e-01f, -8.16063881e-02f, -2.44985417e-01f, 6.13981672e-02f, -9.84507874e-02f, 2.97945023e-01f, -5.03703281e-02f, -2.13997945e-01f, -2.59773493e-01f, -3.96274060e-01f,
  -3.54723297e-02f, 3.86728011e-02f, -1.55401796e-01f, -8.40911642e-02f, 5.69254309e-02f, 2.71079894e-02f, 1.71275705e-01f, 7.01007098e-02f, 1.42395005e-01f, -1.32189959e-01f,
  1.38156205e-01f, -7.51074106e-02f, 6.87462538e-02f, -1.06602073e-01f, 5.48980497e-02f, -3.19245411e-03f, -9.18490887e-02f, 1.01269439e-01f, 1.38568461e-01f, -1.99242728e-03f,
  2.08302401e-02f, 9.45387632e-02f, 1.03560157e-01f, 2.66306192e-01f, -4.96002957e-02f, 7.93170407e-02f, -8.06450099e-02f, -2.25334749e-01f, 1.03987239e-01f, -1.90377399e-01f,
  -1.57130659e-01f, 4.40042794e-01f, -4.17318106e-01f, -8.99542030e-03f, -1.18980985e-02f, 2.99018826e-02f, -8.21752921e-02f, -6.87486157e-02f, -1.00508906e-01f, -1.19448498e-01f,
  -2.46195629e-01f, -1.05235398e-01f, -1.99052822e-02f, 1.84451491e-01f, -9.31115225e-02f, -8.52826685e-02f, -6.59608468e-02f, -1.07556470e-02f, -1.74629670e-02f, -9.35787037e-02f,
  1.36719421e-01f, -1.46032959e-01f, -3.59336317e-01f, -2.66321987e-01f, -1.14570335e-01f, -1.45593479e-01f, -1.80158213e-01f, -2.43806705e-01f, -2.78498530e-01f, -6.44090533e-01f,
  -7.52985597e-01f, -4.85482723e-01f, -3.02689224e-01f, -6.95768654e-01f, -7.16711760e-01f, -4.63033140e-01f, -4.42489833e-01f, -2.84090012e-01f, -3.83901715e-01f, -5.04406214e-01f,
  -1.13332845e-01f, 2.97887534e-01f, 1.00911684e-01f, 1.66890413e-01f, 9.97558683e-02f, -5.49322248e-01f, -6.76516533e-01f, -6.53335452e-02f, 3.02582473e-01f, 1.58967257e-01f,
  -1.73151478e-01f, -1.45361781e-01f, -8.79601836e-02f, 2.95354594e-02f, -7.78198466e-02f, 1.30712643e-01f, -1.80244789e-01f, -2.19601020e-01f, -5.88714741e-02f, -4.47278500e-01f,
  4.48403955e-01f, -2.70189911e-01f, 2.99866181e-02f, -3.35236751e-02f, 3.46410610e-02f, -9.89491940e-02f, -3.03031262e-02f, -3.05117127e-02f, -6.56357547e-03f, -1.00206040e-01f,
  -1.81454867e-01f, -5.99476509e-02f, 5.11647984e-02f, 1.51955783e-01f, -1.37146730e-02f, 1.04215339e-01f, -4.75770272e-02f, -7.44796693e-02f, -4.37870771e-02f, -1.37073055e-01f,
  -7.22990260e-02f, -1.23291492e-01f, -4.51707887e-03f, 1.54362589e-01f, 5.93478568e-02f, 6.17201161e-03f, 2.02151135e-01f, 1.39289826e-01f, 7.25207925e-02f, -5.76706417e-03f,
  1.43624201e-01f, -2.13177153e-03f, -4.52255532e-02f, 5.63228913e-02f, 1.19305111e-01f, -5.04116900e-02f, -3.18286754e-02f, 8.58942792e-02f, 1.46352593e-02f, 2.85611693e-02f,
  -8.36241990e-02f, -7.48067275e-02f, -8.45510140e-03f, -1.97052024e-02f, -7.28218406e-02f, -2.71146130e-02f, 1.58202257e-02f, 6.24719001e-02f, -4.03551720e-02f, -1.32676288e-01f,
  -1.34687617e-01f, 2.02335119e-02f, -2.87168697e-02f, 2.60171741e-01f, -6.22617491e-02f, -7.19075203e-02f, -5.36362566e-02f, 7.26739392e-02f, 1.20843332e-02f, -2.19505623e-01f,
  3.97022665e-01f, -2.45532915e-01f, -1.58323616e-01f, 4.87468913e-02f, -7.79365823e-02f, -3.35701779e-02f, -6.76117390e-02f, -1.91134065e-02f, -6.42726719e-02f, 1.07409442e-02f,
  -6.63920194e-02f, 6.29288256e-02f, 8.34304094e-03f, 5.00625521e-02f, -2.17123050e-02f, -4.92586717e-02f, -5.07591888e-02f, -4.85123582e-02f, -5.16048148e-02f, -3.66960955e-03f,
  -2.11320877e-01f, -1.35584161e-01f, 1.94444969e-01f, 1.13577135e-01f, 1.72348190e-02f, 1.63400158e-01f, 2.03343332e-01f, 8.84082094e-02f, 1.51100829e-01f, 1.61847416e-02f,
  3.04137588e-01f, -1.95864849e-02f, 4.80679095e-01f, 3.95452678e-01f, 1.23613738e-01f, 2.78215259e-02f, -7.10723847e-02f, 1.73098505e-01f, 2.69403160e-01f, 1.07049502e-01f,
  -6.65420517e-02f, 8.22845027e-02f, -1.13845933e-02f, 1.54871330e-01f, 1.38461292e-01f, 1.68866530e-01f, 3.12096655e-01f, 3.59263837e-01f, 3.01294357e-01f, 2.19798446e-01f,
  2.81767435e-02f, 8.41557831e-02f, 1.06224515e-01f, 7.30990469e-02f, 6.95160776e-02f, 1.65495694e-01f, 1.08814865e-01f, 2.57423893e-02f, -1.20560993e-02f, 3.58761221e-01f,
  4.14398044e-01f, -4.85914946e-02f, 2.93404788e-01f, -3.02727558e-02f, -8.15118551e-02f, 1.47641703e-01f, 8.68835449e-02f, 2.08286475e-02f, -9.99369249e-02f, 1.71072215e-01f,
  -2.01808773e-02f, -4.68218178e-02f, -1.86387494e-01f, -1.77435815e-01f, -5.32456599e-02f, -5.03102727e-02f, -1.26745522e-01f, 1.52371764e-01f, -6.60983287e-03f, 9.98374149e-02f,
  -1.52303696e-01f, 5.35765365e-02f, -5.20366617e-03f, -8.54198858e-02f, -9.32190046e-02f, -4.71097156e-02f, -6.27101436e-02f, 3.34719196e-02f, 6.78377002e-02f, 8.30522403e-02f,
  1.27340555e-01f, 1.03772376e-02f, 8.22555497e-02f, 4.40589264e-02f, -9.80730355e-02f, -5.83428182e-02f, -5.82431667e-02f, 3.46221775e-02f, 1.19064860e-02f, -1.21319987e-01f,
  -1.67727500e-01f, 2.28321493e-01f, 2.60775220e-02f, 1.02988146e-01f, 2.02730462e-01f, 1.79879498e-02f, 7.90741388e-03f, 6.88821869e-03f, -9.57965702e-02f, -2.35538512e-01f,
  -8.23982581e-02f, -4.14542295e-02f, -3.02697495e-02f, -1.28100559e-01f, -3.43329459e-02f, 1.21470183e-01f, 1.32580251e-01f, -4.77737114e-02f, -1.05941199e-01f, -1.08362541e-01f,
  2.45120198e-01f, -4.18447517e-02f, 6.79086447e-02f, -3.66241448e-02f, -1.83382642e-03f, -6.69193268e-02f, 5.84302582e-02f, -1.62058435e-02f, 2.17143223e-02f, 1.84336618e-01f,
  1.24511756e-02f, -1.90450565e-03f, -3.06748778e-01f, -5.64509518e-02f, -8.46517012e-02f, 8.79662558e-02f, -6.06729686e-02f, 4.85158302e-02f, 1.01722404e-01f, 9.17680636e-02f,
  5.61551414e-02f, 2.18611404e-01f, 3.02354008e-01f, 1.56839907e-01f, 1.26816975e-02f, 3.80255654e-02f, -2.74199639e-02f, 9.71051399e-03f, 8.10028706e-03f, -8.98062065e-03f,
  -1.82445034e-01f, 1.44715756e-01f, 3.77072692e-01f, -3.37759376e-01f, 1.83969781e-01f, 6.93483502e-02f, -2.06791148e-01f, -1.83595493e-01f, -1.44470736e-01f, -5.34732454e-02f,
  2.91398823e-01f, -2.84655001e-02f, -1.54859260e-01f, -1.65317968e-01f, -4.01766121e-01f, -3.23125303e-01f, -2.83095539e-01f, -2.69776344e-01f, -4.79244590e-02f, 1.65768802e-01f,
  1.03335176e-02f, -9.47697088e-02f, -1.16618477e-01f, -1.04994133e-01f, -6.49128482e-02f, -1.91142291e-01f, -1.49788463e-03f, 1.45989642e-01f, 6.74867481e-02f, -2.75727302e-01f,
  2.07179695e-01f, 1.70677766e-01f, 8.84281993e-02f, 3.72120179e-02f, 1.18888244e-01f, -1.59794495e-01f, -1.51950151e-01f, 2.74395924e-02f, -5.80262244e-02f, 8.67959261e-02f,
  1.25097975e-01f, 2.37081796e-01f, 1.69580519e-01f, 1.68934353e-02f, -1.63277805e-01f, -2.43300553e-02f, -5.61887734e-02f, 5.33210933e-02f, -7.62511268e-02f, 1.52262464e-01f,
  -7.82225877e-02f, 1.96387604e-01f, 1.77269518e-01f, -2.22621903e-01f, -1.95343807e-01f, -1.13398805e-01f, 8.33214670e-02f, -1.09032337e-02f, -1.87419746e-02f, -4.43526298e-01f,
  -1.55418128e-01f, 6.86904043e-02f, 1.42711222e-01f, 5.10664172e-02f, -2.64348656e-01f, 5.63135184e-02f, -8.30596089e-02f, -1.37134269e-01f, -2.61777714e-02f, -9.00684446e-02f,
  7.12675750e-02f, 1.15288705e-01f, -4.10548337e-02f, -1.54625978e-02f, -2.00025558e-01f, -7.27610439e-02f, -9.78062451e-02f, -1.29468635e-01f, -5.75809479e-02f, -1.99109390e-02f,
  4.63397242e-02f, 1.55109465e-01f, 1.01593524e-01f, 2.40269909e-03f, -3.29154246e-02f, -1.91385627e-01f, 3.96767110e-02f, 1.30347282e-01f, -2.90248431e-02f, -1.50353938e-01f,
  -2.19874382e-01f, 1.80889666e-01f, -3.19447249e-01f, -1.36562064e-01f, -1.18939176e-01f, -9.56976265e-02f, -1.78369626e-01f, 9.96773317e-02f, 1.32195801e-01f, -1.07966341e-01f,
  1.16686262e-01f, 1.77036732e-01f, -3.51925865e-02f, 1.74984664e-01f, -5.24245501e-02f, -1.61816888e-02f, -3.63848925e-01f, 5.03763482e-02f, -1.87214129e-02f, 2.48732453e-04f,
  -2.34195799e-01f, -4.25446838e-01f, -2.71733493e-01f, -3.57983619e-01f, -3.51288229e-01f, -3.83589417e-01f, -4.50137556e-01f, -1.45211846e-01f, -2.85988271e-01f, -8.44131708e-01f,
  9.49926198e-01f, -6.67719483e-01f, -1.61906444e-02f, 9.98129230e-03f, -2.48502359e-01f, -1.32645890e-01f, -4.43416268e-01f, 1.84296798e-02f, 1.32693186e-01f, -3.56190801e-01f,
  -1.43234894e-01f, 3.01523983e-01f, 3.50148886e-01f, 3.48125428e-01f, 4.16809797e-01f, -4.25715208e-01f, -1.81687206e-01f, 4.88539249e-01f, 5.55615723e-01f, 2.01934800e-01f,
  -2.67912835e-01f, -9.42367762e-02f, 3.43139261e-01f, 2.25184992e-01f, -4.46265876e-01f, 1.89621802e-02f, -3.56445134e-01f, -1.51405931e-01f, -2.51642317e-01f, -3.45308363e-01f,
  -1.48302779e-01f, -3.97982225e-02f, 1.22371852e-01f, -5.30232377e-02f, -2.71436900e-01f, -1.33050336e-02f, -1.30912647e-01f, -9.46101397e-02f, -4.76542860e-02f, -1.34141982e-01f,
  -1.32000133e-01f, -6.71192408e-02f, 1.87593233e-02f, -3.35790962e-02f, -2.20202610e-01f, 1.84272770e-02f, -4.67224531e-02f, 2.05360934e-01f, 2.26094469e-01f, -1.60929307e-01f,
  -2.73923039e-01f, -1.40623152e-01f, -1.56596042e-02f, -8.44779983e-02f, 2.22380817e-01f, 2.26646572e-01f, -1.19219847e-01f, 9.17178839e-02f, 1.54291913e-01f, -3.08103889e-01f,
  -2.99221408e-02f, 1.25084836e-02f, 1.56382788e-02f, -4.68222015e-02f, 4.12635617e-02f, -4.73497584e-02f, 2.63263788e-02f, -6.35835677e-02f, 1.23732932e-01f, -1.06984429e-01f,
  -2.72579473e-02f, 3.23969834e-02f, 6.04376495e-02f, -1.93701953e-01f, 2.03593131e-02f, -2.11716183e-02f, -5.24393795e-03f, -8.11143219e-02f, -1.04320524e-02f, 4.57216240e-02f,
  7.37979785e-02f, 5.69852963e-02f, 8.37469846e-03f, 3.64295929e-03f, -1.31434696e-02f, 5.08448780e-02f, 7.62470812e-02f, 8.84522572e-02f, -7.29725836e-03f, 2.52708327e-04f,
  -2.75792152e-01f, 2.89835095e-01f, -2.67757159e-02f, 1.49756998e-01f, -6.92848638e-02f, -7.70526528e-02f, -3.62964459e-02f, 2.02755425e-02f, -3.61076258e-02f, -9.63000804e-02f,
  1.23438733e-02f, 1.23080522e-01f, -1.02009766e-01f, -9.93401781e-02f, 9.44767892e-03f, 5.87330200e-03f, -1.02267325e-01f, 5.73081821e-02f, 2.54223924e-02f, -6.45142421e-02f,
  -3.01708747e-02f, 1.06449900e-02f, 1.55658945e-01f, 6.85087219e-02f, 2.12907586e-02f, 1.82704896e-01f, -3.79884802e-02f, -3.16617675e-02f, 1.78127110e-01f, -3.35515827e-01f,
  -5.91137230e-01f, 3.93951833e-01f, 2.47831464e-01f, -6.13499105e-01f, 2.67538130e-01f, 3.34624290e-01f, 2.90717989e-01f, 1.55324906e-01f, -1.67512372e-01f, -2.43861997e-03f,
  1.20672859e-01f, -2.08906725e-01f, -1.48740202e-01f, -1.08277194e-01f, 7.00332671e-02f, 1.00379236e-01f, -2.19149739e-01f, -1.78391770e-01f, 1.17905224e-02f, 3.35197508e-01f,
  -3.09276469e-02f, -2.74904668e-01f, -1.83162928e-01f, -2.96514556e-02f, -1.52281016e-01f, -3.52454692e-01f, -4.81931046e-02f, -5.29220328e-02f, 1.31304592e-01f, -5.11747897e-01f,
  -3.35583985e-01f, 1.51201859e-01f, -8.79440084e-02f, -2.33901918e-01f, 1.39648477e-02f, -5.36296815e-02f, 5.49876830e-03f, -1.08826213e-01f, 1.30868584e-01f, -8.93008932e-02f,
  -1.67767093e-01f, 1.16552323e-01f, -7.11166337e-02f, -8.78200233e-02f, -2.98123769e-02f, 3.74923088e-02f, -1.82613745e-01f, -1.17173992e-01f, -1.71770632e-01f, 2.59650797e-01f,
  -8.79694074e-02f, 8.08492154e-02f, -7.15675279e-02f, 3.61947924e-01f, 4.83356863e-02f, -1.42010748e-01f, 2.52749007e-02f, 2.12395173e-02f, 1.23952799e-01f, -4.96717602e-01f,
  -5.19157089e-02f, 8.67686495e-02f, -1.04709975e-02f, -2.04420965e-02f, 1.25825778e-02f, -3.95074859e-02f, -3.26769873e-02f, -2.95382086e-02f, 1.00826368e-01f, -1.74021140e-01f,
  1.96590014e-02f, 1.27153412e-01f, -1.23546403e-02f, 2.21001700e-01f, 1.89325819e-03f, -3.30438539e-02f, -6.74624695e-03f, -4.93907370e-02f, 1.85409024e-01f, 5.42397909e-02f,
  -8.41702595e-02f, 1.04493937e-02f, 9.30671766e-03f, -1.73216492e-01f, 1.02905974e-01f, -7.86805823e-02f, 7.56378844e-02f, 1.21366642e-01f, -7.67751262e-02f, 1.75395384e-01f,
  -5.76412201e-01f, 2.01253325e-01f, -3.43894869e-01f, -7.52583817e-02f, -2.23631293e-01f, -1.36366546e-01f, 3.09749926e-03f, 8.92964005e-03f, 1.71054721e-01f, -9.70493630e-02f,
  7.58767575e-02f, 1.34219259e-01f, -2.65368640e-01f, -9.83393937e-03f, -6.87045678e-02f, -1.66696146e-01f, -1.74223855e-01f, -7.37126023e-02f, 8.79940465e-02f, -1.75090626e-01f,
  -3.26156944e-01f, -6.59579337e-02f, -5.05909503e-01f, -1.04241125e-01f, -7.93228578e-03f, -2.72846907e-01f, -3.49513948e-01f, -1.46806195e-01f, -1.19704016e-01f, -6.30917370e-01f,
  4.58390385e-01f, 7.15791285e-01f, -5.73194921e-02f, 4.09254245e-02f, 1.59502313e-01f, -8.47396702e-02f, 2.35055402e-01f, 2.77543701e-02f, -1.15105808e-01f, 1.76355466e-01f,
  9.56040248e-02f, -9.43652242e-02f, -1.24099096e-02f, -9.07387678e-03f, -4.06408980e-02f, 1.82726219e-01f, 1.72546357e-01f, -3.85832693e-03f, -2.59947240e-01f, -9.38761234e-02f,
  4.75870185e-02f, 1.36134312e-01f, -1.04365647e-02f, 2.22311076e-02f, 2.55357891e-01f, 1.75820533e-02f, 1.57166764e-01f, 1.24808766e-01f, 2.20369294e-01f, 4.58807528e-01f,
  -4.92320210e-02f, 3.98633212e-01f, -3.94792467e-01f, 8.91731009e-02f, 1.24365054e-01f, -2.22532135e-02f, -1.48948565e-01f, -4.60077710e-02f, -1.20891050e-01f, -2.57574141e-01f,
  2.50396729e-01f, 2.90364157e-02f, 3.55402045e-02f, -5.68939447e-02f, -3.90304364e-02f, -1.10385939e-01f, -2.43700407e-02f, 1.02121517e-01f, -8.08688030e-02f, -1.64638776e-02f,
  1.27347067e-01f, 1.03412628e-01f, -8.85578394e-02f, -2.09621340e-01f, -1.76198885e-01f, -2.10603073e-01f, -3.64760756e-02f, -1.39558971e-01f, -3.31238359e-01f, -1.78966299e-01f,
  -3.52489799e-01f, -2.51166616e-02f, -1.75919514e-02f, -1.27868071e-01f, -3.54172811e-02f, -1.37118503e-01f, -5.74498922e-02f, 3.42214783e-03f, -1.30401745e-01f, -6.47394657e-02f,
  -6.99895471e-02f, -1.93394065e-01f, -5.35079986e-02f, -1.91846013e-01f, -1.63133070e-01f, 1.18290789e-01f, 3.11686774e-03f, 1.25583401e-03f, -1.44308984e-01f, -4.89725061e-02f,
  -1.17277284e-03f, 7.75715485e-02f, 5.31488024e-02f, 4.46067564e-02f, 4.19854820e-02f, -7.47649074e-02f, -1.00711517e-01f, -3.86598483e-02f, -1.23231262e-02f, 6.19013682e-02f,
  -2.92530004e-02f, -4.37936217e-01f, -9.63002741e-02f, 2.87165910e-01f, 2.90065408e-01f, 1.89607546e-01f, 1.51474580e-01f, 1.65281782e-03f, 1.83124453e-01f, -7.94260576e-02f,
  1.24419287e-01f, 1.19857781e-01f, 1.60338074e-01f, -8.51688460e-02f, -1.06473014e-01f, -6.34190664e-02f, 2.15100035e-01f, 1.51269659e-01f, 1.72180757e-01f, 9.92210284e-02f,
  1.72177434e-01f, -1.89604342e-01f, -1.92962050e-01f, -1.56120688e-01f, -2.10863352e-01f, -2.69687980e-01f, -1.93454236e-01f, -9.10825357e-02f, -3.11890036e-01f, -3.13742548e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 20)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 20;
const float L0_fan_Bp_bar_data[] = {
  5.95260203e-01f, 5.08129895e-01f, 2.49366015e-01f, 4.23449665e-01f, 4.75381285e-01f, 4.55664575e-01f, 6.03819847e-01f, 7.64832556e-01f, 1.74486324e-01f, 5.11963904e-01f,
  1.29737556e-01f, 5.25799930e-01f, 5.56202948e-01f, 6.85543060e-01f, 5.45129955e-01f, -3.45163196e-02f, 3.49044502e-01f, 6.27281606e-01f, 4.56014633e-01f, 4.56782371e-01f
};

// L1_fan_Wp (Shape: 6 x 32)
const int L1_fan_Wp_rows = 6;
const int L1_fan_Wp_cols = 32;
const float L1_fan_Wp_data[] = {
  3.52811739e-02f, -2.77172308e-02f, -1.38552804e-02f, 5.87244052e-03f, -6.10543462e-03f, -3.33433263e-02f, 5.51682524e-02f, -1.25331759e-01f, 9.59487706e-02f, 6.33936375e-02f,
  8.30292255e-02f, 4.98683974e-02f, -3.40247124e-01f, 3.13744992e-02f, -3.12832482e-02f, 2.59925693e-01f, -3.34363580e-01f, 1.51331965e-02f, 5.45336567e-02f, -4.96366732e-02f,
  -6.36361912e-02f, 9.14799571e-02f, 2.11355686e-02f, -2.00985223e-01f, 9.07048583e-02f, 1.81435823e-01f, -2.39041783e-02f, -2.76259214e-01f, 1.46723270e-01f, -5.47952235e-01f,
  3.29014301e-01f, 8.47320631e-02f, 3.63248363e-02f, 3.64043489e-02f, 2.05928896e-04f, -1.02294438e-01f, -5.53466752e-02f, 8.61017499e-03f, -1.73843741e-01f, -1.49767503e-01f,
  1.16153277e-01f, 4.44803853e-03f, 1.23698734e-01f, -1.41929975e-02f, 2.86354750e-01f, -1.03358693e-01f, 4.26515043e-02f, -1.46826744e-01f, 2.03236803e-01f, -1.29128650e-01f,
  4.01189476e-01f, 1.79749086e-01f, -1.23900712e-01f, 1.75067320e-01f, 3.51100266e-02f, 1.66174322e-01f, -7.74819106e-02f, 3.48722994e-01f, -2.37299800e-01f, -1.10552721e-01f,
  2.52433777e-01f, -2.88417339e-01f, -3.98474932e-03f, 1.85998961e-01f, 2.25208048e-02f, -3.01127993e-02f, 1.21092191e-02f, 2.29287818e-02f, -7.76378885e-02f, -3.72743681e-02f,
  -1.26249075e-01f, -2.17496604e-02f, -3.81622389e-02f, -1.61844085e-03f, -3.34884636e-02f, 9.70867914e-05f, -4.56877649e-02f, -3.88897806e-01f, -1.24898963e-01f, -1.77909378e-02f,
  -2.77462035e-01f, -6.89301491e-02f, 5.67414403e-01f, 4.19722378e-01f, -1.28247187e-01f, 3.65762669e-03f, -6.20023534e-02f, 5.14007568e-01f, 1.06099725e-01f, -5.00751585e-02f,
  2.65141185e-02f, -1.83574244e-01f, 1.43441546e-04f, -3.56899202e-01f, 2.11634308e-01f, 1.17282413e-01f, 5.15803844e-02f, -9.17386487e-02f, -9.16696638e-02f, 8.66511911e-02f,
  6.47950470e-02f, -2.89041121e-02f, -7.29608089e-02f, 1.03197716e-01f, -1.60009379e-03f, -2.51787831e-03f, -1.94645133e-02f, 6.47454560e-02f, 1.81990743e-01f, 1.89625233e-01f,
  7.54107982e-02f, -2.07527354e-01f, 3.30931157e-01f, 3.96853834e-02f, -2.27356955e-01f, -2.14868233e-01f, -6.85623288e-03f, -1.27491817e-01f, -1.62597999e-01f, -6.52129948e-02f,
  -1.75740749e-01f, -3.73190083e-02f, -1.17681079e-01f, 1.99442133e-01f, -8.05831477e-02f, 4.86191034e-01f, -2.63122499e-01f, 1.77843377e-01f, 5.48915379e-02f, 7.93818384e-03f,
  -4.14172411e-02f, 1.07352853e-01f, -8.64383057e-02f, -6.29105046e-02f, -4.50949781e-02f, 7.29834288e-02f, 2.06702277e-01f, -3.76700461e-02f, -1.09332830e-01f, -1.73569053e-01f,
  -5.66177130e-01f, 1.99180543e-01f, 2.22525313e-01f, -1.53075131e-02f, 5.87337799e-02f, -3.37033898e-01f, -3.50188255e-01f, -1.09805778e-01f, -1.95331022e-01f, -1.20052263e-01f,
  -3.85618955e-02f, -2.65695959e-01f, 1.61649004e-01f, 2.25519478e-01f, 1.94407508e-01f, -3.81510295e-02f, 5.04404306e-02f, 3.34775567e-01f, 1.01958260e-01f, -1.19906053e-01f,
  3.92132662e-02f, 7.67417578e-03f, 3.15965042e-02f, 2.62587108e-02f, -2.98873764e-02f, -9.20677558e-02f, 5.98767623e-02f, 1.29493862e-01f, -3.12099047e-02f, -7.13588670e-02f,
  -9.00116265e-02f, 5.84686510e-02f, 3.62109452e-01f, -1.91306826e-02f, 4.71212044e-02f, -4.44500685e-01f, 2.55989283e-01f, 3.02040040e-01f, 7.13584796e-02f, 2.56720364e-01f,
  2.27929771e-01f, 2.12175265e-01f, -3.37688416e-01f, 7.08674639e-02f, -5.26761152e-02f, 2.68414468e-01f, -5.53797930e-02f, 2.44341582e-01f, 1.30350307e-01f, -1.18218325e-01f,
  2.07873881e-01f, 7.21438453e-02f
};

// L1_fan_Wp_bar (Shape: 20 x 32)
const int L1_fan_Wp_bar_rows = 20;
const int L1_fan_Wp_bar_cols = 32;
const float L1_fan_Wp_bar_data[] = {
  2.58850865e-02f, 7.97665268e-02f, 2.09941477e-01f, 1.12657279e-01f, 2.71382183e-01f, -6.76461533e-02f, 4.11165655e-01f, 7.00909048e-02f, 1.20036729e-01f, -1.72863696e-02f,
  -3.67735177e-01f, -3.93498123e-01f, -9.36585903e-01f, 5.80824554e-01f, 8.80114958e-02f, 2.19210871e-02f, -4.18828160e-01f, 1.50801301e-01f, -4.22130466e-01f, 5.25886297e-01f,
  -1.53377196e-02f, -8.35540146e-02f, -2.54083076e-03f, -2.19947174e-01f, 2.48473540e-01f, -1.73596069e-01f, 1.99855283e-01f, 1.30690649e-01f, -8.14015567e-02f, 6.61942422e-01f,
  4.84403037e-02f, -2.24258155e-01f, 5.06830812e-01f, 3.54588151e-01f, 1.16323061e-01f, 2.79083431e-01f, 4.35449421e-01f, 1.99092060e-01f, -5.76392887e-03f, 3.73772204e-01f,
  -2.70338565e-01f, 1.24385215e-05f, 3.31185502e-03f, -3.12750340e-01f, -5.28688490e-01f, 2.08620280e-01f, 1.61250740e-01f, -4.44272071e-01f, -2.38744300e-02f, -1.41328782e-01f,
  -3.86443622e-02f, 6.83968961e-01f, -3.54864597e-01f, -1.34635642e-01f, -2.00319231e-01f, 1.91127852e-01f, 7.44204074e-02f, 7.65038192e-01f, 6.76117361e-01f, 9.40694287e-02f,
  3.66973765e-02f, 7.90189683e-01f, 7.06957802e-02f, -3.47346246e-01f, 3.27863246e-01f, 2.82613337e-01f, 7.69472122e-02f, 1.30170673e-01f, 1.88959241e-01f, 1.44582585e-01f,
  1.16949238e-01f, 3.49923410e-02f, -3.14393193e-01f, -2.35908970e-01f, 7.29324445e-02f, -2.32795924e-01f, 1.78560968e-02f, -6.51921093e-01f, -2.83215255e-01f, 1.74442623e-02f,
  -3.76986355e-01f, 3.24255913e-01f, 9.91980076e-01f, 7.58534372e-01f, -1.52613878e-01f, 8.73876065e-02f, 2.47050434e-01f, 6.09997392e-01f, 6.09923825e-02f, 2.05400303e-01f,
  6.08930707e-01f, -2.02337712e-01f, 3.83233905e-01f, -3.58156264e-01f, 8.90535057e-01f, 4.23278548e-02f, 2.08485171e-01f, -1.57453865e-02f, 1.45418495e-01f, 2.26851001e-01f,
  2.57567704e-01f, -2.62886900e-02f, -2.50412405e-01f, -5.03820777e-02f, 1.21687628e-01f, 1.28589213e-01f, 2.64036328e-01f, 1.10182025e-01f, 5.29669583e-01f, -2.67196506e-01f,
  -6.17636554e-02f, -8.91038962e-03f, 3.11722696e-01f, -5.01538767e-03f, 5.49820721e-01f, -8.09320360e-02f, 2.26341337e-01f, 1.45128176e-01f, 4.60346282e-01f, -3.37260552e-02f,
  6.69084340e-02f, 9.45394218e-01f, -7.39586502e-02f, -3.08589280e-01f, 3.60745907e-01f, -5.14336117e-03f, 5.23005009e-01f, 3.55982371e-02f, -1.09575808e-01f, 2.56833524e-01f,
  1.57598019e-01f, -8.54265690e-03f, 2.22082555e-01f, 1.32832766e-01f, 2.52834171e-01f, -1.38863400e-01f, 2.07169086e-01f, -1.19108327e-01f, -3.69378090e-01f, 4.42776270e-02f,
  6.54264569e-01f, 2.70238012e-01f, -2.28415519e-01f, 2.43066162e-01f, 4.22293574e-01f, -1.94852516e-01f, -7.28033632e-02f, 1.26103953e-01f, 4.75744694e-01f, 6.19185448e-01f,
  3.44727129e-01f, -3.19164127e-01f, 3.57914954e-01f, -1.00908965e-01f, -2.60785490e-01f, 1.68994918e-01f, 1.23838291e-01f, -6.75793231e-01f, 5.32090478e-02f, 2.05022976e-01f,
  7.41336197e-02f, 3.19651306e-01f, 2.28394851e-01f, 8.44664499e-02f, 2.51365721e-01f, 2.80151814e-01f, 2.59901792e-01f, -3.99912953e-01f, 2.67295748e-01f, -1.75150648e-01f,
  -4.10615444e-01f, -2.12852389e-01f, -3.20509613e-01f, 3.47655773e-01f, 1.51027441e-01f, -3.76620442e-02f, 4.58704680e-01f, -5.28784633e-01f, 4.08424586e-01f, -4.23754603e-01f,
  5.93691766e-01f, 6.16284668e-01f, 3.68484229e-01f, 5.96833110e-01f, 3.53084117e-01f, -2.10313410e-01f, 6.66705728e-01f, -3.29279095e-01f, 2.07959744e-03f, -3.28066677e-01f,
  -2.99385637e-01f, 5.07871173e-02f, 1.05145663e-01f, 2.86725819e-01f, 6.77124485e-02f, 2.24092647e-01f, 2.57659137e-01f, 1.52988553e-01f, -2.28422254e-01f, 3.72693479e-01f,
  8.41713250e-02f, 1.38949186e-01f, 1.22090213e-01f, 1.99272692e-01f, 8.28373015e-01f, -5.43476865e-02f, 1.09639220e-01f, 5.30779123e-01f, 4.91595805e-01f, 1.42363623e-01f,
  -5.23642242e-01f, -3.82285863e-01f, -1.86006010e-01f, 3.35090429e-01f, 2.53165722e-01f, -4.18167263e-01f, -1.22217171e-01f, -1.92728370e-01f, -8.51903632e-02f, -1.32409304e-01f,
  2.92503685e-01f, 4.33299184e-01f, -1.45708025e-01f, 6.38069808e-01f, 3.24040204e-01f, -4.61607298e-04f, 3.00935864e-01f, 1.25356570e-01f, 2.51103640e-01f, 2.69784182e-01f,
  1.33894682e-01f, -2.18313605e-01f, -2.38706902e-01f, -1.98224694e-01f, 8.19658712e-02f, -3.05348307e-01f, -1.99758410e-01f, -1.50338644e-02f, 3.73882391e-02f, 4.97682393e-01f,
  -5.77209711e-01f, 1.93004772e-01f, 8.90760064e-01f, 3.67833465e-01f, 3.01697195e-01f, -2.02750657e-02f, -2.36217439e-01f, 7.12119043e-01f, 8.48973691e-02f, 1.97924659e-01f,
  1.68225229e-01f, 3.74469049e-02f, -6.32027388e-02f, -5.85942030e-01f, 6.54651821e-02f, -2.07456827e-01f, 1.57364205e-01f, 2.28447273e-01f, -8.67040306e-02f, 1.47388786e-01f,
  2.33860299e-01f, 2.82629323e-03f, -1.58155367e-01f, 4.40157086e-01f, -2.20914125e-01f, -3.51483189e-02f, -1.68135017e-01f, -2.11408939e-02f, -4.10214663e-01f, 9.34973806e-02f,
  4.82865237e-02f, 4.61713493e-01f, -6.28039777e-01f, 6.34235501e-01f, -3.06675225e-01f, 1.38366699e-01f, -4.08039361e-01f, -5.14594913e-01f, 6.31886303e-01f, -2.92792588e-01f,
  -5.10743521e-02f, -6.41404152e-01f, 4.82240692e-02f, -1.83406368e-01f, 5.75394392e-01f, 5.31550467e-01f, 6.46251619e-01f, 3.24204832e-01f, 5.53423874e-02f, 1.71022974e-02f,
  8.87226239e-02f, 3.96422595e-02f, 1.31531015e-01f, -1.07991360e-01f, -1.24186993e-01f, 1.84308827e-01f, -1.31987244e-01f, 1.86169669e-01f, 2.98767596e-01f, 1.54867932e-01f,
  6.46792471e-01f, -6.40331209e-01f, -5.65461442e-03f, 1.54593801e-02f, 5.37881255e-02f, 1.11087352e-01f, 5.62034309e-01f, 5.46345115e-01f, -4.16130833e-02f, 5.93436658e-02f,
  3.23407799e-01f, 6.33350253e-01f, 3.97946015e-02f, -2.97911674e-01f, -2.13441640e-01f, -2.69274056e-01f, 4.86809194e-01f, -3.70077521e-01f, 5.98751545e-01f, 4.92033988e-01f,
  2.61956364e-01f, 2.41421521e-01f, 1.01586342e-01f, 2.76471704e-01f, 3.25852364e-01f, 7.06888363e-02f, 1.65181115e-01f, 1.65775016e-01f, -4.80811559e-02f, 6.08358756e-02f,
  -2.66667426e-01f, 3.46148908e-02f, 8.09841990e-01f, -2.25175675e-02f, -2.52416372e-01f, 7.76482150e-02f, 6.39944434e-01f, 1.91883281e-01f, -2.20093489e-01f, 9.40520406e-01f,
  9.89398882e-02f, 5.63147902e-01f, -3.86406183e-01f, -3.31127346e-01f, 2.21761301e-01f, -2.72096872e-01f, -8.05827603e-02f, 2.19130721e-02f, 1.64464921e-01f, -3.57316643e-01f,
  -1.87194973e-01f, 4.65282977e-01f, 1.47378251e-01f, 3.97610992e-01f, 1.08698428e-01f, -6.21560328e-02f, 1.42103598e-01f, 3.54686737e-01f, -5.69376200e-02f, -7.95497447e-02f,
  1.91064522e-01f, 2.38952115e-01f, -3.26563179e-01f, -4.61863615e-02f, -4.02179092e-01f, 5.50173283e-01f, -1.32474288e-01f, -1.83016118e-02f, 3.31300616e-01f, -3.11345190e-01f,
  -8.34625065e-01f, -8.99140358e-01f, 4.03316528e-01f, 3.43607485e-01f, 1.26184449e-01f, -4.36193913e-01f, -1.58211887e-01f, 6.48028612e-01f, 4.28254575e-01f, 2.30544265e-02f,
  4.73456621e-01f, 6.57609642e-01f, 3.26572247e-02f, -8.45922381e-02f, 8.62728655e-02f, 1.71684161e-01f, 4.16117311e-01f, 1.20404392e-01f, -7.46952295e-02f, 2.28992105e-01f,
  1.18353613e-01f, 1.41856730e-01f, -2.58179218e-01f, -2.06453830e-01f, -2.82334268e-01f, -8.85649621e-02f, 2.39572614e-01f, 3.72690052e-01f, 4.84229177e-01f, -4.99494448e-02f,
  -2.96969235e-01f, 4.48395431e-01f, 4.55384254e-01f, 4.14485425e-01f, 2.00399220e-01f, -2.20922247e-01f, -3.57715756e-01f, 5.32594979e-01f, 3.51877660e-01f, 2.36178227e-02f,
  -7.60138035e-02f, 1.21707253e-01f, -7.23106980e-01f, 3.94570142e-01f, -5.15176535e-01f, 2.63890028e-01f, 2.32206032e-01f, -4.56948094e-02f, 5.97484596e-02f, -6.29087016e-02f,
  4.73679006e-02f, 4.55802120e-02f, -1.68698132e-01f, -8.37287009e-02f, -3.46408457e-01f, 2.09794760e-01f, -1.06428349e-02f, 1.64249673e-01f, 2.09375739e-01f, 8.85691196e-02f,
  5.02599418e-01f, 3.26688737e-01f, 6.69002116e-01f, 1.99912339e-02f, 3.97147499e-02f, -2.64346153e-01f, 6.11210525e-01f, 4.47217464e-01f, 6.79730177e-02f, 9.83280316e-02f,
  -8.50812018e-01f, 2.92432517e-01f, -9.22047675e-01f, -1.55884221e-01f, 3.64537120e-01f, 1.09807134e-01f, -1.65431947e-02f, 5.62474072e-01f, 3.92255001e-02f, -2.24375483e-02f,
  -4.39428017e-02f, 9.87220854e-02f, 1.29173785e-01f, -2.60535963e-02f, 5.99364191e-02f, 4.29792553e-02f, 2.92781025e-01f, 3.34298681e-03f, 1.12129770e-01f, 1.76458061e-01f,
  3.80119234e-01f, 1.11610204e-01f, 4.38735127e-01f, -1.20094150e-01f, -1.40493184e-01f, 4.38576750e-02f, -2.99149752e-01f, -3.20825279e-01f, -5.91927432e-02f, -5.01619458e-01f,
  4.11785185e-01f, -8.99813138e-03f, 2.79150605e-01f, 4.44745749e-01f, 1.88252777e-01f, 2.95495719e-01f, 3.01970571e-01f, 8.99812698e-01f, 3.90056610e-01f, -7.00263008e-02f,
  9.43463892e-02f, 1.73819914e-01f, 1.80837721e-01f, -2.04592571e-02f, 1.74773067e-01f, 3.32719535e-01f, 7.22389519e-02f, -3.99208069e-01f, 2.03888804e-01f, -1.40787169e-01f,
  -7.57842616e-04f, -6.12598248e-02f, -4.77517247e-01f, 6.71545267e-02f, -2.63774216e-01f, 2.15681002e-01f, 2.59883106e-01f, -4.03066799e-02f, -9.87943411e-02f, 4.00483422e-02f,
  2.86302477e-01f, 5.33598006e-01f, 2.99383759e-01f, -7.38564804e-02f, 2.02780440e-01f, 7.35075772e-01f, 6.19455338e-01f, 1.89049259e-01f, 1.76975176e-01f, 8.46003890e-02f,
  -1.63748443e-01f, -3.07377368e-01f, 2.60634750e-01f, 2.32898235e-01f, 4.85677838e-01f, 3.52374583e-01f, 1.97119176e-01f, 2.42159307e-01f, 3.15599769e-01f, 4.37301844e-01f,
  -3.24843705e-01f, -2.32985139e-01f, -3.40673804e-01f, 6.33889735e-02f, 6.65292442e-01f, 5.44460297e-01f, 1.93974644e-01f, 3.97018880e-01f, -1.94080189e-01f, 2.11034819e-01f,
  1.09462686e-01f, 7.16169834e-01f, -2.65477955e-01f, -1.77844584e-01f, -2.55796492e-01f, -7.05700293e-02f, 1.35487229e-01f, -7.45875716e-01f, 1.43793464e-01f, -2.56564677e-01f,
  -7.19009519e-01f, 3.06739062e-01f, -3.72861177e-01f, 2.88810074e-01f, 1.78423047e-01f, 6.50734529e-02f, 3.24177414e-01f, 1.44540295e-01f, 2.33935937e-01f, 3.80692631e-01f,
  1.74566358e-01f, 8.11729059e-02f, 2.19697773e-01f, 4.46310341e-02f, 3.10261897e-03f, 9.49527472e-02f, 6.43749237e-01f, 4.04424161e-01f, 3.24332982e-01f, 1.84052088e-03f,
  7.27122843e-01f, -1.03596903e-01f, 2.76567042e-01f, -8.08944181e-02f, 6.87008917e-01f, 3.86935025e-01f, -3.76769572e-01f, 1.25505522e-01f, 2.60031283e-01f, 4.40864950e-01f,
  -4.04767126e-01f, 2.05518663e-01f, -1.80165946e-01f, -1.95733547e-01f, -4.63660181e-01f, 3.83628279e-01f, 6.91216439e-02f, 3.48377615e-01f, 3.47283453e-01f, 3.42318773e-01f,
  1.45022601e-01f, 3.76508325e-01f, 1.94592446e-01f, -6.17040038e-01f, 4.07834381e-01f, -1.23512872e-01f, -2.30144203e-01f, -3.60029861e-02f, -7.83609003e-02f, 6.79619491e-01f,
  2.10445467e-03f, 1.24970518e-01f, 1.16399676e-02f, -4.14737791e-01f, 4.09937412e-01f, 1.72499076e-01f, -6.91017881e-02f, 2.06943870e-01f, 2.95576155e-01f, -5.40749907e-01f,
  7.99953282e-01f, 5.63245595e-01f, -3.51138003e-02f, -1.36940777e-01f, 8.22883248e-02f, 4.59108427e-02f, 3.82175118e-01f, -6.56384528e-02f, -1.33746907e-01f, 9.57792103e-02f,
  -4.97416668e-02f, 2.06364393e-01f, 2.25723982e-02f, 2.44369388e-01f, 3.26790094e-01f, -3.84726703e-01f, 1.69803016e-02f, -8.04591924e-02f, -2.37059578e-01f, -7.55859762e-02f,
  -4.10335392e-01f, 7.97714531e-01f, -2.72194445e-02f, 4.56596404e-01f, -7.24268928e-02f, 1.46234557e-01f, -1.09839819e-01f, -1.62687525e-01f, 2.89773881e-01f, 6.13973558e-01f,
  6.32266164e-01f, -4.25447941e-01f, 4.89438653e-01f, -2.51958430e-01f, -7.63792992e-02f, -1.87386334e-01f, 5.30618012e-01f, -2.36783162e-01f, 4.37083602e-01f, 5.81858642e-02f
};

// L1_fan_Bp_bar (Shape: 1 x 20)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 20;
const float L1_fan_Bp_bar_data[] = {
  2.15835020e-01f, 3.73209864e-01f, 1.33341476e-01f, 3.86873484e-02f, 2.59012938e-01f, 2.94924229e-01f, 3.15953076e-01f, 2.01815605e-01f, 7.02530816e-02f, 1.92807898e-01f,
  6.94937631e-02f, 1.70960739e-01f, 2.84469038e-01f, 1.04337454e-01f, -9.53042582e-02f, 3.59827012e-01f, 4.10683930e-01f, 4.42691386e-01f, 5.10242522e-01f, 2.67411739e-01f
};

// L2_linear_W (Shape: 12 x 32)
const int L2_linear_W_rows = 12;
const int L2_linear_W_cols = 32;
const float L2_linear_W_data[] = {
  -4.43803109e-02f, -4.47459258e-02f, -2.16233149e-01f, -4.93610233e-01f, -5.02960861e-01f, -9.74866375e-02f, 8.38909745e-01f, -2.12802038e-01f, 1.13635115e-01f, -2.44234741e-01f,
  -4.19181377e-01f, 5.59577756e-02f, 4.17390555e-01f, 1.81107298e-01f, -2.25386739e-01f, -2.76501805e-01f, -1.54117085e-02f, -3.77042294e-02f, -5.60609639e-01f, -4.59967971e-01f,
  -1.68988276e-02f, -7.46331692e-01f, -1.87357441e-01f, 3.77862722e-01f, -7.88208783e-01f, -7.65502453e-02f, 2.78949410e-01f, 2.96404392e-01f, -7.36599803e-01f, -6.44167185e-01f,
  2.66058534e-01f, 2.76494294e-01f, -3.71603251e-01f, -5.90769768e-01f, -3.06718554e-02f, -1.13094397e-01f, -2.99911052e-01f, 3.70205909e-01f, -8.49499583e-01f, -6.51566982e-01f,
  -7.52602339e-01f, 5.17877281e-01f, -1.70018017e-01f, -9.97835919e-02f, 2.31625438e-01f, 1.65366322e-01f, -5.39541721e-01f, -9.63404894e-01f, -5.27752876e-01f, 9.04102549e-02f,
  1.06018819e-01f, -2.10528880e-01f, 3.05476397e-01f, -4.89488244e-01f, -7.79838741e-01f, 2.35616356e-01f, 2.39883497e-01f, 8.47034380e-02f, 3.12633842e-01f, -1.54951336e-02f,
  4.11764890e-01f, -7.60743022e-02f, -6.17699549e-02f, -1.37706855e-02f, -4.18425798e-01f, 1.47270095e-02f, -8.66895393e-02f, -4.90983367e-01f, 1.70118943e-01f, -3.86482447e-01f,
  2.64289349e-01f, 6.53428435e-02f, -5.91081202e-01f, 6.08791232e-01f, 4.31487948e-01f, 2.02605590e-01f, -4.04146552e-01f, 5.26292205e-01f, -3.17691445e-01f, 4.44403112e-01f,
  -2.00167745e-01f, -9.02244151e-01f, -1.58556439e-02f, -5.77213645e-01f, -5.47577381e-01f, -2.43578494e-01f, -5.36527216e-01f, 4.67664033e-01f, -2.54306614e-01f, -9.17279944e-02f,
  2.78227448e-01f, 2.51384288e-01f, -5.22311866e-01f, 7.24413171e-02f, 3.12664092e-01f, -6.64037228e-01f, -3.32265764e-01f, -6.16975367e-01f, -8.69531333e-01f, -5.43459058e-01f,
  -3.84177327e-01f, 1.17291182e-01f, 3.99007291e-01f, 1.59297869e-01f, 7.98594505e-02f, 5.82334220e-01f, 4.47311252e-01f, 2.85531640e-01f, -4.62776154e-01f, -3.91548455e-01f,
  5.23859203e-01f, 2.39228591e-01f, -1.32461846e-01f, 1.02492191e-01f, -8.53045940e-01f, 3.36120784e-01f, 1.49384346e-02f, 4.63495463e-01f, -6.10830963e-01f, -3.42580706e-01f,
  -5.29728413e-01f, -6.89205527e-01f, 1.11413347e-02f, -2.39347517e-01f, -4.09031004e-01f, -9.25716221e-01f, 2.45776936e-01f, 1.23474330e-01f, 1.81105837e-01f, -3.37193459e-02f,
  2.66236097e-01f, -6.46767691e-02f, 1.01261079e-01f, -3.24745297e-01f, 1.22734793e-01f, 7.94534504e-01f, 6.69378817e-01f, -8.37855995e-01f, 6.59746289e-01f, -2.94561237e-01f,
  -2.35516697e-01f, -6.24492109e-01f, -9.92333144e-02f, 2.70473838e-01f, 3.19150895e-01f, 2.83869952e-01f, 1.73842058e-01f, -2.04971939e-01f, -4.06990610e-02f, -2.60269772e-02f,
  5.24354339e-01f, 4.55194153e-02f, -1.30334184e-01f, -9.44244087e-01f, -1.30520329e-01f, 2.01869488e-01f, -3.95072073e-01f, -3.14442515e-02f, 9.47927088e-02f, -2.07651053e-02f,
  9.28097546e-01f, 5.61268210e-01f, 5.25975764e-01f, 7.60433435e-01f, 5.10416627e-01f, 6.98531151e-01f, -1.71989933e-01f, -4.10657346e-01f, -1.28751963e-01f, -5.90986133e-01f,
  4.04102206e-01f, 5.03994264e-02f, 6.52525946e-02f, -1.88552260e-01f, -4.71735597e-01f, -4.97184813e-01f, 2.43059143e-01f, 1.15059160e-01f, -3.45927268e-01f, -9.80516523e-02f,
  -5.52151263e-01f, -7.53942311e-01f, 7.69836903e-02f, -3.87088925e-01f, 2.27220565e-01f, -3.03571939e-01f, -3.73043537e-01f, -3.69328447e-02f, 5.40522337e-01f, 1.94058597e-01f,
  5.06710112e-01f, 2.96247900e-01f, 3.01687680e-02f, -2.08480015e-01f, -1.70911878e-01f, -1.06616467e-01f, -1.19214080e-01f, -3.49807627e-02f, -3.27400774e-01f, 5.49745619e-01f,
  -1.80293739e-01f, 9.88983065e-02f, -6.72131851e-02f, -2.47326508e-01f, -4.11962569e-01f, -4.81957287e-01f, -5.86473107e-01f, -6.37411103e-02f, 3.25796418e-02f, -6.23433650e-01f,
  2.85032690e-01f, -8.37632298e-01f, -4.66465443e-01f, 4.07961756e-01f, 4.66157526e-01f, -4.11111742e-01f, -4.16025631e-02f, 3.22993845e-01f, 1.69669479e-01f, -1.02425694e+00f,
  3.46870363e-01f, 2.69611448e-01f, -6.10030949e-01f, -9.40499306e-01f, -3.72279704e-01f, -3.99978995e-01f, -3.76938373e-01f, -1.65655464e-01f, -7.81151578e-02f, -2.94174105e-01f,
  6.75788820e-01f, 3.85295361e-01f, 6.27373040e-01f, 1.91564932e-01f, -2.20508605e-01f, -1.84308842e-01f, -3.41692194e-02f, -2.85081685e-01f, 8.73763338e-02f, 3.60310912e-01f,
  -2.91659981e-01f, -1.55934960e-01f, -2.62703449e-01f, 6.29938364e-01f, -2.22457394e-01f, 1.59439519e-01f, -6.32441342e-01f, -5.21182477e-01f, 2.13380799e-01f, 2.34212935e-01f,
  -2.46907491e-02f, -1.91562235e-01f, -6.25186682e-01f, 2.56080359e-01f, -1.48384601e-01f, -5.92112780e-01f, -2.06240952e-01f, 5.72830141e-01f, 3.69831622e-01f, 4.02299136e-01f,
  3.79133224e-01f, -1.76341817e-01f, -5.67755640e-01f, -2.65899569e-01f, 5.12148499e-01f, 3.45305562e-01f, -4.57524568e-01f, 7.68245637e-01f, 3.76480252e-01f, 5.65042973e-01f,
  4.00031507e-01f, -6.67358220e-01f, -6.04722500e-01f, -8.82085681e-01f, -4.62746263e-01f, 1.84725717e-01f, 2.13990867e-01f, -5.08530885e-02f, 3.68956923e-01f, -5.37503302e-01f,
  2.84833401e-01f, -3.67160827e-01f, -3.15511882e-01f, -4.30922098e-02f, 2.84448683e-01f, -2.57797062e-01f, -6.62381172e-01f, -9.02519763e-01f, 5.55535220e-02f, 4.02977914e-02f,
  2.06010014e-01f, -2.31725559e-01f, 1.95593208e-01f, -7.30730295e-01f, -4.43116724e-01f, 9.31105670e-03f, -5.40332258e-01f, 6.16847634e-01f, -2.52444357e-01f, 4.41279113e-01f,
  -5.22527874e-01f, -6.15451336e-01f, -9.89605367e-01f, -1.89891551e-02f, 2.10157767e-01f, 3.75950485e-01f, 8.71386752e-02f, -3.24540943e-01f, -6.49000585e-01f, -3.81887823e-01f,
  1.75024807e-01f, 5.33015490e-01f, -1.47816777e-01f, 3.32056224e-01f, -4.36861843e-01f, -2.30022684e-01f, -8.05058181e-01f, 3.41930181e-01f, -4.35784608e-01f, 1.53271556e-01f,
  1.83887571e-01f, 1.79068670e-01f, -3.31305265e-01f, -1.33400872e-01f, 2.96060026e-01f, 1.56067774e-01f, -4.97803867e-01f, -9.30961967e-02f, 2.15315878e-01f, -5.54592669e-01f,
  -1.01995386e-01f, -4.79188591e-01f, -3.18177491e-01f, 3.89434189e-01f, 4.21497881e-01f, -3.74453634e-01f, -7.90146112e-01f, 7.39377320e-01f, -3.87709230e-01f, 3.95957679e-01f,
  -7.65603542e-01f, -1.89051136e-01f, -5.15733004e-01f, -1.97900116e-01f, -1.27247483e-01f, -2.57892251e-01f, -7.98222482e-01f, 3.04136097e-01f, 5.40212765e-02f, -5.00620961e-01f,
  -3.97478908e-01f, -4.85889554e-01f, 1.75139233e-01f, 2.08059832e-01f, -1.22899465e-01f, 2.57503986e-01f, -1.21302664e-01f, 1.45113930e-01f, 6.98017955e-01f, -1.34899646e-01f,
  5.03973901e-01f, -5.87748587e-01f, -3.73331398e-01f, -3.08446795e-01f, -4.20692205e-01f, -7.59002864e-01f, 3.75038654e-01f, 2.32199207e-01f, -1.02757864e-01f, -5.12139976e-01f,
  3.79684001e-01f, -2.48100922e-01f, 6.60945415e-01f, 5.68046153e-01f, 1.57831013e-01f, -3.03389877e-01f, -5.01243293e-01f, 1.30575299e-01f, -4.78611231e-01f, -7.27517247e-01f,
  1.85065851e-01f, -4.80050802e-01f, -7.21242607e-01f, 1.87815338e-01f
};

// L2_linear_B (Shape: 1 x 12)
const int L2_linear_B_rows = 1;
const int L2_linear_B_cols = 12;
const float L2_linear_B_data[] = {
  -4.24286038e-01f, 2.52764642e-01f, 1.56035155e-01f, -1.77239567e-01f, -1.86272025e-01f, 2.50885010e-01f, -2.65489578e-01f, -2.31921762e-01f, -2.84671653e-02f, 1.65398613e-01f,
  -1.23418339e-01f, -5.95651977e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 6, 20
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        32, 6, 20
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_linear
    linear_forward_pgm(
        buffer1, x_out,
        L2_linear_W_data, L2_linear_B_data,
        32, 12
    );
    }
    