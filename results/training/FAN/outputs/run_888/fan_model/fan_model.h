/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 64 (x3)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 64;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    float x3 = x * x * x;
    return 0.5f * x * (1.0f + tanhf(0.79788456f * (x + 0.044715f * x3)));
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 6 x 120)
const int L0_fan_Wp_rows = 6;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  1.37422502e-01f, 1.71986878e-01f, 6.85353652e-02f, 1.26150087e-01f, -4.52389382e-02f, -2.24766582e-01f, -1.23147763e-01f, -1.64535284e-01f, -1.04400488e-02f, -5.83829125e-03f,
  -6.73103780e-02f, -8.21476430e-02f, -9.84547734e-02f, -6.58852160e-02f, -7.92851895e-02f, 1.05973475e-01f, 1.39870778e-01f, -3.92586477e-02f, -1.60938904e-01f, -1.11570768e-01f,
  -1.32128865e-01f, 1.30003714e-03f, 4.94136699e-02f, 5.33776693e-02f, 1.12500288e-01f, -1.04435913e-01f, 1.12356298e-01f, 6.83209673e-02f, 6.77747205e-02f, 2.88140684e-01f,
  9.97502953e-02f, 1.18662186e-01f, -1.47973970e-01f, 5.56110293e-02f, -1.16330069e-02f, 8.15598071e-02f, -1.81459263e-02f, -8.17541312e-03f, 4.09980826e-02f, 1.50847975e-02f,
  -4.03812453e-02f, -3.30962315e-02f, -2.63853911e-02f, -5.19716553e-02f, 3.08518223e-02f, -8.00534338e-02f, 8.43530372e-02f, 1.00253701e-01f, 6.22727126e-02f, 1.24378474e-02f,
  -2.68712640e-02f, 9.41536203e-02f, 6.53655007e-02f, 4.53684032e-02f, -1.21947033e-02f, 5.92278056e-02f, 6.98194355e-02f, 6.54065236e-02f, 2.14395113e-02f, 2.07497641e-01f,
  5.30183651e-02f, 8.91871899e-02f, 1.59576833e-02f, 2.22617649e-02f, -2.48395093e-02f, 4.73759472e-02f, 4.02699932e-02f, -5.61713018e-02f, 4.04334031e-02f, -2.01303940e-02f,
  2.62533557e-02f, -3.30789685e-02f, 3.45612131e-02f, 3.61102596e-02f, -1.86310168e-02f, 7.70450532e-02f, -8.08181241e-02f, -4.07778732e-02f, 2.12090705e-02f, 2.40512677e-02f,
  -1.93875527e-03f, 6.10377155e-02f, -1.53838785e-03f, -1.47115877e-02f, 5.46055622e-02f, 6.23823749e-03f, 5.97428754e-02f, -3.15687135e-02f, 8.36365595e-02f, -4.45449026e-03f,
  -1.24957047e-01f, -1.75163984e-01f, -6.45870268e-02f, -8.71645734e-02f, -3.13374661e-02f, -2.09952369e-02f, -9.22383368e-02f, 5.44117615e-02f, 7.00977049e-04f, -1.18405253e-01f,
  -1.06018648e-01f, -8.53701904e-02f, -9.63940695e-02f, 4.07645106e-02f, -9.02944654e-02f, -5.47406040e-02f, -5.71613610e-02f, -4.38113622e-02f, -8.09772313e-03f, -1.38643933e-02f,
  -1.30627686e-02f, -7.04766065e-02f, -6.07799273e-03f, -7.81026930e-02f, -4.06966433e-02f, -4.62067723e-02f, -6.67245984e-02f, -1.02605969e-01f, -7.62943178e-03f, -8.32003355e-02f,
  -3.67605329e-01f, 1.74045578e-01f, 1.00667968e-01f, -2.60585010e-01f, 2.18645543e-01f, 3.05296987e-01f, 5.24919927e-01f, 8.51070583e-02f, -1.10462442e-01f, 4.45381366e-02f,
  2.95597017e-02f, -1.49387956e-01f, -9.62724835e-02f, -1.73217013e-01f, 8.73691514e-02f, 1.87697843e-01f, 1.03271030e-01f, -1.46890163e-01f, 5.58810867e-03f, 1.20736517e-01f,
  -1.22704562e-02f, 2.21449379e-02f, -1.97103038e-01f, -1.03014410e-01f, -5.98671287e-02f, -6.10452853e-02f, 7.39056841e-02f, -3.34680788e-02f, 1.86771285e-02f, -1.34217739e-01f,
  -1.70458257e-01f, -1.15536982e-02f, 3.51916514e-02f, -6.97940886e-02f, -3.16398852e-02f, -9.56229419e-02f, 4.64925393e-02f, -5.28895222e-02f, 2.44987495e-02f, -5.23573123e-02f,
  9.67127178e-03f, 4.17660270e-03f, -6.00860491e-02f, -5.61972372e-02f, 8.46894644e-03f, 8.94182641e-03f, 2.25691274e-02f, -1.52788877e-01f, -2.43405886e-02f, 1.16656329e-02f,
  1.62527841e-02f, 8.55130032e-02f, 3.96243818e-02f, 8.37130472e-02f, 2.06914302e-02f, -8.27332139e-02f, 7.35688722e-03f, -1.18140146e-01f, -2.73093116e-02f, -9.65810269e-02f,
  2.51117926e-02f, -3.61073278e-02f, 3.76752727e-02f, -3.79314311e-02f, 1.64473876e-02f, 1.39993383e-02f, -1.99441817e-02f, -5.61537407e-03f, -4.79308479e-02f, -3.12080458e-02f,
  -2.18541007e-02f, -2.68516615e-02f, -1.95329767e-02f, -4.61788438e-02f, -1.01211462e-02f, -7.03518465e-03f, 2.37285309e-02f, 3.02737998e-03f, 7.38008469e-02f, -1.48170125e-02f,
  -7.18177110e-02f, 6.75742626e-02f, -2.48261597e-02f, -3.55042219e-02f, 2.27540173e-03f, -1.72946937e-02f, -4.86771241e-02f, 1.45827495e-02f, 1.27827246e-02f, -7.07441866e-02f,
  -9.40908119e-02f, 1.06605254e-01f, -9.77966711e-02f, 6.19371645e-02f, 1.86232161e-02f, -1.90007165e-02f, -6.58010393e-02f, 5.12976497e-02f, -1.78455152e-02f, -4.90446463e-02f,
  -3.85511853e-02f, -5.78788891e-02f, -2.88031027e-02f, -3.13141644e-02f, -9.63260606e-02f, 9.47868743e-04f, -1.73366535e-02f, 9.19698551e-02f, 2.08447780e-02f, 5.54679483e-02f,
  6.38555661e-02f, 1.12510994e-01f, 1.20081678e-01f, 1.25955313e-01f, -5.65589927e-02f, 9.45071131e-02f, 1.29580557e-01f, -2.78497059e-02f, 1.62672848e-01f, 1.79136232e-01f,
  3.18580091e-01f, -1.88147232e-01f, 1.41948527e-02f, 3.26902084e-02f, -1.07570753e-01f, -1.99501379e-03f, -1.26900733e-01f, -2.17066146e-02f, 4.03960571e-02f, -1.59051239e-01f,
  -4.99503501e-02f, 1.29826963e-01f, 1.96735218e-01f, 1.92162469e-01f, 8.23522508e-02f, -3.99557725e-02f, -1.75822541e-01f, 2.33681142e-01f, 2.61566550e-01f, 1.68102533e-01f,
  -4.37901840e-02f, 1.95765439e-02f, 1.64824083e-01f, 1.11051001e-01f, -5.46398386e-02f, 7.31402338e-02f, -1.11370437e-01f, -1.40371546e-02f, -1.07509747e-01f, -1.57796860e-01f,
  8.73362198e-02f, -1.03992127e-01f, 6.34707436e-02f, -3.79962102e-02f, -4.03457619e-02f, 8.84727240e-02f, 7.46311694e-02f, 3.53202075e-02f, -2.73939501e-02f, 1.34558016e-02f,
  -3.82797793e-02f, 7.93419108e-02f, 2.20674276e-02f, 1.79880168e-02f, 3.49144302e-02f, 1.92887406e-03f, -9.82329547e-02f, 7.79073760e-02f, 8.16638768e-02f, -3.22978720e-02f,
  -1.83184352e-02f, -1.18762001e-01f, 3.26679684e-02f, -4.32361737e-02f, -1.09062284e-01f, 5.03634587e-02f, -1.26770005e-01f, -1.27102304e-02f, 6.34590164e-02f, -1.33935763e-02f,
  4.05769050e-02f, 7.48340935e-02f, 2.00438332e-02f, -3.32707949e-02f, 1.18052587e-02f, 2.23716851e-02f, -4.31716889e-02f, -5.91846369e-02f, -3.43601666e-02f, 1.63039174e-02f,
  -2.73229531e-03f, -4.50565591e-02f, 4.06262912e-02f, -5.32275205e-03f, -1.86672341e-02f, -2.83362139e-02f, 2.99458951e-02f, -4.16587926e-02f, -4.49132957e-02f, -3.24326195e-02f,
  1.35434670e-02f, -1.68241132e-02f, -5.58026582e-02f, 2.47787479e-02f, -2.72602476e-02f, -1.79331861e-02f, 3.75577509e-02f, -1.30045358e-02f, 8.85787234e-02f, -4.70842533e-02f,
  7.88524523e-02f, -7.70779029e-02f, -2.30896398e-02f, 1.57680910e-03f, -2.90040076e-02f, -5.36452420e-02f, -7.10018948e-02f, 1.71317011e-02f, -2.73078755e-02f, -1.73814613e-02f,
  5.61324544e-02f, 5.62454462e-02f, -7.75967613e-02f, 2.62050778e-02f, -4.12512124e-02f, -3.46867507e-03f, -7.69327655e-02f, 4.58498262e-02f, 1.92114490e-03f, -3.40446904e-02f,
  2.76865456e-02f, 7.23142549e-02f, 3.32249179e-02f, 4.47832793e-03f, -1.09111287e-01f, -3.04682236e-02f, -1.71486028e-02f, 3.11919469e-02f, 8.10445249e-02f, 6.22081272e-02f,
  -3.48591894e-01f, -1.83998823e-01f, 5.21857738e-02f, -2.59366989e-01f, -1.19844079e-01f, -9.71315429e-02f, -1.96417421e-01f, -1.09494992e-01f, -7.09482729e-02f, -1.32112885e-02f,
  1.60326168e-01f, 1.73395559e-01f, 1.30064055e-01f, 1.79383889e-01f, 2.44775973e-02f, -1.53048918e-01f, -1.77939534e-01f, -1.60098933e-02f, -2.17663106e-02f, -1.56274587e-01f,
  -6.75422400e-02f, -7.62808695e-02f, -1.57989487e-01f, -8.52188021e-02f, -1.64821267e-01f, 3.61524038e-02f, 7.04938769e-02f, -1.13000786e-02f, 4.61163670e-02f, -1.45705611e-01f,
  1.64935321e-01f, -2.05962971e-01f, 1.15457065e-01f, 5.32889813e-02f, 3.73422690e-02f, -2.92000826e-02f, -9.91588552e-03f, -4.46090996e-02f, 2.71396022e-02f, -3.49571519e-02f,
  3.91539112e-02f, -6.16760412e-03f, 1.04543418e-02f, 9.18704830e-03f, -1.15336679e-01f, -6.90233260e-02f, -4.66636494e-02f, 8.90141726e-02f, 5.96984364e-02f, 1.62597448e-02f,
  -7.40128942e-03f, -1.28630385e-01f, -7.62450621e-02f, -7.78877083e-03f, 7.10732937e-02f, 6.50297850e-03f, -4.96473238e-02f, -3.56496610e-02f, 1.05572224e-01f, -1.67723686e-01f,
  -6.30744174e-02f, -1.38781918e-02f, 1.11548239e-02f, -1.38174966e-02f, 1.72008816e-02f, 4.71666269e-02f, -2.79707126e-02f, -4.24237847e-02f, 4.98466529e-02f, -4.15402502e-02f,
  9.38705578e-02f, -2.30842531e-02f, 8.16188566e-03f, -1.68755054e-02f, 1.51256304e-02f, -6.05279692e-02f, 1.61545649e-02f, -9.78687257e-02f, 1.84133779e-02f, -3.17824557e-02f,
  2.18501873e-02f, 6.35487074e-03f, -2.65259035e-02f, 7.71425664e-03f, 9.23913345e-02f, -3.06732999e-03f, 8.31795856e-02f, -3.88945118e-02f, 3.12735848e-02f, -7.25432485e-02f,
  4.97914776e-02f, 1.77761450e-01f, 5.69503047e-02f, -5.13496250e-02f, -4.82512452e-02f, 8.40549022e-02f, 2.88014673e-02f, -1.72722433e-02f, 7.08003789e-02f, -2.15143040e-02f,
  1.61703844e-02f, 1.46151120e-02f, 4.13604528e-02f, 5.69494776e-02f, -5.43135740e-02f, -3.02810967e-02f, 7.11334050e-02f, -1.36675015e-02f, 1.79945827e-02f, -8.40361416e-02f,
  -1.11909457e-01f, -8.55649188e-02f, -2.84785330e-02f, 3.19780149e-02f, -3.04082725e-02f, 9.83997993e-03f, -1.04996115e-02f, -4.08039875e-02f, -2.74557415e-02f, -3.31370570e-02f,
  -3.35198313e-01f, -4.57314998e-02f, -4.04616222e-02f, -8.59181955e-02f, 1.48301318e-01f, 6.37111813e-03f, -2.62676150e-01f, -3.01099084e-02f, -7.42294872e-03f, -3.84696238e-02f,
  1.42503351e-01f, 1.91191569e-01f, 2.26026282e-01f, 1.68643281e-01f, 6.68802485e-02f, -2.39475429e-01f, -1.81422591e-01f, -9.87769812e-02f, 4.76485491e-02f, 9.03493538e-02f,
  3.62107381e-02f, -1.54881114e-02f, 4.95188385e-02f, 8.99145380e-03f, -3.49108409e-03f, 1.31936714e-01f, 5.16878888e-02f, 8.83290246e-02f, 1.10877141e-01f, -1.77208990e-01f,
  6.74448088e-02f, -1.12641595e-01f, -7.99692236e-03f, 5.52276857e-02f, 9.61520001e-02f, -6.02167211e-02f, -9.27594677e-02f, -2.42904108e-02f, -3.44588608e-02f, 2.34948881e-02f,
  4.89426591e-03f, -9.87551641e-03f, 1.08217318e-02f, 1.24594616e-02f, -7.32181370e-02f, -2.38571558e-02f, 4.11435775e-02f, -1.16932943e-01f, 9.50555969e-03f, 1.13929249e-02f,
  9.69522893e-02f, 3.20969075e-02f, 2.55383365e-02f, 2.62802988e-02f, 3.88972983e-02f, -3.13726328e-02f, 1.28217548e-01f, 1.28726169e-01f, 5.96762039e-02f, -5.34987561e-02f,
  3.57889943e-02f, 2.49146987e-02f, 1.22544970e-02f, -4.60089967e-02f, -1.91797446e-02f, -1.62436981e-02f, -1.09998863e-02f, 7.76701197e-02f, -1.10347308e-02f, 5.25807440e-02f,
  8.54024887e-02f, 4.43501770e-03f, 1.29411547e-02f, -1.63674615e-02f, 1.55095309e-02f, -1.85387977e-03f, -6.89367903e-03f, -1.64251942e-02f, 3.94714512e-02f, 4.61208746e-02f,
  -1.35973142e-02f, -6.28223643e-02f, 8.17825925e-03f, -1.00630075e-02f, -5.23720384e-02f, 6.43693805e-02f, -7.09487051e-02f, 1.11867107e-01f, 9.08373818e-02f, -4.11844440e-02f,
  1.22343943e-01f, 6.28766194e-02f, -1.15905449e-01f, -3.07644904e-02f, 1.67114940e-02f, 5.64472526e-02f, -4.34803516e-02f, 1.84498876e-02f, -3.58607806e-03f, -1.32964980e-02f,
  6.36948422e-02f, -1.36729982e-02f, 2.61054430e-02f, -1.29644852e-03f, 1.53510766e-02f, 2.79635172e-02f, -4.58981795e-03f, -1.56331584e-02f, -4.53129336e-02f, -1.52755817e-02f,
  7.17596486e-02f, -5.18148728e-02f, -6.03670813e-02f, 1.18182097e-02f, -2.23367121e-02f, -3.45451348e-02f, 3.72960698e-03f, -3.57077830e-02f, -4.36593816e-02f, -8.23960826e-02f,
  -7.83041120e-02f, -4.92127314e-02f, 1.95756659e-01f, -1.74039364e-01f, -7.06314072e-02f, 1.76076755e-01f, 3.02067906e-01f, 1.06059521e-01f, -1.94257796e-01f, -6.01627938e-02f,
  -7.06617460e-02f, -1.69661447e-01f, -1.00785017e-01f, -2.79279333e-02f, 1.18771046e-01f, 1.85832724e-01f, 6.42879726e-03f, 1.35247603e-01f, 1.62079602e-01f, 1.11224003e-01f,
  -2.33501568e-02f, 1.32472217e-02f, -1.69693772e-02f, 2.60488372e-02f, -4.23761494e-02f, -8.14336762e-02f, 7.38547370e-02f, -2.96480414e-02f, 7.79433250e-02f, 9.60173309e-02f,
  6.00439981e-02f, 2.32985001e-02f, -7.51500279e-02f, -2.75774095e-02f, 4.03218484e-03f, 3.46227773e-02f, 7.12927571e-03f, -1.67302862e-02f, -1.18520169e-04f, -6.74081221e-02f,
  -3.63568515e-02f, -7.65561536e-02f, 2.58271154e-02f, 3.20316554e-04f, 1.14180669e-02f, -9.41001996e-03f, -5.51906899e-02f, -2.49916762e-02f, 1.95677727e-02f, 2.00814847e-02f,
  -3.03604826e-02f, 2.60914303e-02f, -1.58306379e-02f, 1.38334865e-02f, 1.79552529e-02f, 1.40174786e-02f, -2.08273828e-02f, 7.13652670e-02f, 6.63808659e-02f, 8.79667997e-02f,
  7.92516954e-03f, 7.64441304e-03f, 7.78155997e-02f, -4.90298048e-02f, 2.67352629e-02f, -5.69664501e-02f, -1.22532770e-02f, 2.92531098e-03f, 4.35062796e-02f, 4.81233560e-02f,
  -5.80867752e-02f, -1.27031738e-02f, 4.19759899e-02f, -7.36806542e-02f, -2.74867732e-02f, 2.25905888e-02f, 5.97739499e-03f, -3.76910493e-02f, -6.25216514e-02f, -8.69584531e-02f,
  2.26220507e-02f, -6.97848853e-03f, 2.63605472e-02f, -6.10387651e-03f, 2.93179322e-02f, 8.39826092e-03f, 2.56334934e-02f, -4.21516486e-02f, 7.19823763e-02f, 2.89600063e-02f,
  -1.17374212e-01f, -6.78879097e-02f, -1.60465913e-03f, 2.00776197e-02f, 1.97085608e-02f, -4.03258167e-02f, -2.93175895e-02f, -1.01972274e-01f, -2.58921441e-02f, 9.29555576e-03f,
  3.95804122e-02f, 1.32348947e-02f, -3.84861082e-02f, -1.86172361e-03f, 8.80223513e-02f, 5.16854301e-02f, 1.81011017e-02f, -5.16854115e-02f, -3.34000960e-02f, -3.77267860e-02f,
  -1.19564839e-01f, 2.75490396e-02f, 2.69677117e-03f, -2.42678374e-02f, 8.63941386e-02f, 1.11746611e-02f, 1.56654239e-01f, 6.43493086e-02f, 1.40393749e-01f, 9.07012969e-02f
};

// L0_fan_Wp_bar (Shape: 52 x 120)
const int L0_fan_Wp_bar_rows = 52;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  1.39274344e-01f, 1.31798953e-01f, 1.37466609e-01f, 5.00724837e-02f, -7.20771961e-03f, 4.88602817e-02f, -6.76816329e-03f, 1.05654210e-01f, -6.20280690e-02f, -1.13549344e-02f,
  -9.03888885e-03f, -1.23082846e-01f, 1.36352703e-02f, 3.83334234e-03f, 7.71024004e-02f, 2.36367695e-02f, 9.57115218e-02f, 7.72772282e-02f, 6.04016408e-02f, -9.01281238e-02f,
  -6.81769941e-03f, 7.56070092e-02f, 1.05635010e-01f, -3.41357589e-02f, 2.65835486e-02f, -5.69766685e-02f, 2.00887490e-02f, 1.39180999e-02f, -5.04270419e-02f, 6.88146427e-02f,
  4.91136722e-02f, 1.36733949e-01f, -3.46499868e-02f, -1.33448958e-01f, 3.06252781e-02f, -7.75439143e-02f, -7.62696043e-02f, 2.69703008e-02f, -1.98457185e-02f, 3.68184708e-02f,
  3.93727561e-03f, 6.37619644e-02f, 1.99949509e-03f, 3.98676144e-03f, 1.56541895e-02f, -2.70113666e-02f, 4.70206067e-02f, 1.10540465e-01f, 4.87123467e-02f, 1.47376861e-02f,
  5.48716597e-02f, -6.61519319e-02f, 1.13849625e-01f, -7.36990049e-02f, 5.93952797e-02f, -3.50015238e-02f, -3.35457958e-02f, 3.24916355e-02f, -4.83521558e-02f, 7.96730593e-02f,
  2.65284181e-02f, -4.71953526e-02f, -6.29873015e-03f, -7.16218874e-02f, 8.22445527e-02f, -2.19639521e-02f, 8.77146125e-02f, 2.17313189e-02f, 4.16298804e-04f, 5.79958446e-02f,
  -6.24555536e-02f, 5.57496883e-02f, -4.37352099e-02f, 4.19696011e-02f, -1.02507761e-02f, 5.29012568e-02f, 7.41228387e-02f, -5.95318899e-02f, -1.47150774e-02f, 9.25516561e-02f,
  -4.84625697e-02f, -6.60221651e-02f, 7.59577900e-02f, 1.91851296e-02f, -5.21691442e-02f, 3.49995121e-02f, -3.78002673e-02f, 1.08766900e-02f, -5.72870448e-02f, 3.33217420e-02f,
  -1.27077192e-01f, 7.63026625e-02f, 3.43489870e-02f, 5.15732504e-02f, -2.26066355e-02f, 5.27537800e-02f, -8.75914991e-02f, -7.16143399e-02f, -5.78963384e-02f, -5.29234968e-02f,
  8.52896124e-02f, 6.85683638e-02f, 6.69804662e-02f, 7.04376698e-02f, -6.84035867e-02f, -8.34087208e-02f, 2.31749583e-02f, -1.48270419e-02f, 5.11053279e-02f, 1.51450315e-03f,
  -1.13227457e-01f, -2.87903547e-02f, -2.40248851e-02f, -6.40903115e-02f, 3.92906927e-02f, -3.99874561e-02f, -6.02966845e-02f, 1.86678302e-02f, -6.74713627e-02f, -8.25738627e-03f,
  -3.72866064e-01f, -2.70061847e-02f, -2.25787625e-01f, -1.83536068e-01f, -1.01989761e-01f, 2.10008770e-02f, 6.38490394e-02f, 7.99951032e-02f, 3.84189263e-02f, -1.07566848e-01f,
  9.84167382e-02f, 2.07195189e-02f, -1.14660025e-01f, -8.30309391e-02f, -5.53551763e-02f, -7.77009875e-02f, -2.34826595e-01f, -1.80837512e-01f, -2.96790116e-02f, 1.01425564e-02f,
  6.21985644e-02f, -1.82337165e-01f, -1.29319429e-01f, 4.68695387e-02f, -2.08952068e-03f, -2.25859545e-02f, -1.48855701e-01f, 1.77785233e-02f, 4.25422937e-02f, -1.61824793e-01f,
  4.55605350e-02f, -1.06371850e-01f, 1.90847311e-02f, 7.26138577e-02f, -4.30962443e-02f, -7.31253177e-02f, -3.92459966e-02f, 1.46338427e-02f, 2.56211273e-02f, -5.77195175e-02f,
  -1.37244031e-01f, -8.41530412e-02f, -7.20094740e-02f, 7.10310563e-02f, -1.21163391e-02f, -4.80819773e-03f, -2.79365610e-02f, -4.05501276e-02f, -6.15587831e-02f, 6.40314966e-02f,
  -2.72747129e-02f, -8.06923956e-02f, 2.23692860e-02f, 1.44155174e-01f, 9.80098452e-03f, -3.40901613e-02f, 6.55468181e-02f, 1.61613151e-01f, 8.03671107e-02f, 6.71954965e-03f,
  -4.16818075e-02f, 8.52278471e-02f, 2.64948942e-02f, -6.68398142e-02f, -7.79045895e-02f, 6.83065653e-02f, -2.11786870e-02f, -4.85657230e-02f, 3.08849979e-02f, -2.47827675e-02f,
  -8.92572105e-02f, -2.13064756e-02f, 5.49635217e-02f, -5.61906374e-04f, -1.72773954e-02f, -5.13249896e-02f, -9.29328501e-02f, 4.19411995e-02f, 3.57515030e-02f, -4.36909646e-02f,
  -1.17587461e-03f, 1.05700999e-01f, -3.57896276e-02f, 6.73211738e-02f, 7.32405782e-02f, 2.61342544e-02f, -3.94797288e-02f, -1.35420524e-02f, 2.36035902e-02f, -1.42145231e-01f,
  -9.03392807e-02f, 3.40711027e-02f, -1.45483045e-02f, -7.14712869e-03f, -5.37895933e-02f, 2.61820350e-02f, -7.42792562e-02f, -1.53246531e-02f, -9.76653993e-02f, -8.23518913e-03f,
  8.11309516e-02f, 1.21746566e-02f, 2.83748424e-03f, 8.15884024e-02f, -5.31636253e-02f, 6.64421245e-02f, 1.24531914e-03f, -1.14568107e-01f, 4.47540097e-02f, 1.09313808e-01f,
  4.62591983e-02f, -3.53480242e-02f, -2.14530192e-02f, 3.04596648e-02f, 2.20844056e-02f, -2.52328580e-03f, 1.10876814e-01f, 1.12089187e-01f, -5.90774231e-02f, 3.10267806e-02f,
  -1.80847287e-01f, -1.56991512e-01f, 9.81623158e-02f, 1.40667990e-01f, 1.69674784e-01f, 1.97821021e-01f, 1.49535507e-01f, 8.52800161e-02f, 1.34839714e-01f, 1.18665602e-02f,
  -1.14557981e-01f, -1.01604164e-01f, -9.17876288e-02f, 8.11316073e-02f, 5.71477078e-02f, 1.40097305e-01f, 1.09411091e-01f, -4.05436270e-02f, 1.05600417e-01f, 4.35622521e-02f,
  1.03657976e-01f, -1.06532358e-01f, -8.14174414e-02f, -5.86625896e-02f, 3.35795991e-02f, 4.02486771e-02f, 6.06757067e-02f, 4.76895384e-02f, 7.29197927e-04f, -3.24645005e-02f,
  -1.35169014e-01f, -9.26135480e-02f, 5.85748032e-02f, 4.46215272e-02f, -1.66977998e-02f, -1.29425243e-01f, -5.50005473e-02f, -1.28832325e-01f, -3.59108485e-02f, -2.62631513e-02f,
  -6.59344643e-02f, 3.25194374e-02f, -3.73268053e-02f, -4.54582646e-03f, -7.34753460e-02f, -7.09407851e-02f, -5.46891503e-02f, 4.09409925e-02f, 3.42078917e-02f, -7.95289576e-02f,
  -3.64589319e-02f, -2.87917443e-03f, -7.45768473e-02f, -5.09859622e-02f, 3.59764695e-02f, -1.04659209e-02f, -4.25720550e-02f, -7.79933035e-02f, 2.59445067e-02f, 1.62682831e-02f,
  6.17710873e-02f, -1.20578827e-02f, -3.96443382e-02f, -4.56001572e-02f, 5.01970984e-02f, -4.24752448e-04f, -2.83796787e-02f, -4.77023162e-02f, -1.45698478e-02f, -3.12522426e-02f,
  4.61493507e-02f, 5.65845184e-02f, -7.14005530e-02f, 8.74495972e-03f, -4.74643335e-02f, -5.32572791e-02f, 2.52657235e-02f, 3.98468114e-02f, -7.58379772e-02f, 3.17556523e-02f,
  1.00556314e-01f, 7.32679963e-02f, -2.20961049e-02f, 1.51336007e-02f, -4.70623188e-02f, 3.46936472e-02f, 2.00625956e-02f, -6.72832429e-02f, 1.68835111e-02f, -4.08431627e-02f,
  4.46460992e-02f, 4.86492179e-02f, 6.82483334e-03f, -6.88547641e-03f, -7.07962550e-03f, -2.37267446e-02f, 7.74576440e-02f, 1.55762061e-02f, 9.92580205e-02f, -5.04544824e-02f,
  -2.97472794e-02f, 1.26082562e-02f, -5.10018729e-02f, 8.95935968e-02f, -5.56060523e-02f, 3.93484123e-02f, 5.47503084e-02f, -3.73116024e-02f, -2.85382438e-02f, -1.13475956e-02f,
  -1.97710879e-02f, 3.26140448e-02f, 1.43447090e-02f, 1.23137787e-01f, 5.41785732e-02f, 4.61350195e-02f, 4.69451584e-02f, 1.07531302e-01f, -4.14166674e-02f, 3.12410686e-02f,
  -1.61846220e-01f, -2.84488760e-02f, 7.26517662e-02f, 1.40522942e-01f, 1.57024965e-01f, -6.24829996e-03f, 2.55495356e-03f, 5.58864810e-02f, 1.14123359e-01f, -6.52614385e-02f,
  3.22230570e-02f, -2.11547967e-02f, 9.27603468e-02f, -7.26296455e-02f, -5.02181379e-03f, -1.73642877e-02f, 5.37410080e-02f, 3.18153389e-02f, 1.15051553e-01f, 9.20870677e-02f,
  -5.35742342e-02f, 5.52412309e-03f, 2.13478804e-02f, 6.60269558e-02f, 8.92195031e-02f, 1.00663126e-01f, 1.32166287e-02f, -5.37959300e-02f, -5.38533628e-02f, 7.12673217e-02f,
  3.02643119e-03f, -2.34757606e-02f, -3.33783887e-02f, 8.67747366e-02f, 2.11139694e-02f, 4.84777354e-02f, -5.29467091e-02f, 3.10532432e-02f, -8.24082363e-03f, -2.03396119e-02f,
  -5.74103333e-02f, -1.10261038e-01f, -5.72676212e-02f, -1.22287618e-02f, -9.45305377e-02f, -8.66273697e-03f, -1.12825848e-01f, -8.94524977e-02f, 3.33280340e-02f, -8.02948028e-02f,
  6.08827472e-02f, -3.29503603e-02f, -5.98991588e-02f, -4.43346724e-02f, -2.30778046e-02f, -2.16015894e-02f, -3.69057544e-02f, 4.75004688e-02f, -7.88322743e-03f, -1.31392607e-03f,
  -9.60560236e-03f, 3.45836533e-03f, 7.75955766e-02f, -2.85442360e-02f, 1.81143694e-02f, -5.39229028e-02f, -2.29265988e-02f, 6.36418685e-02f, -3.74818146e-02f, -6.87137097e-02f,
  5.06576262e-02f, 8.32190290e-02f, -8.13523382e-02f, 6.43901825e-02f, -3.50996703e-02f, 6.39167428e-02f, -5.89546822e-02f, 5.77731691e-02f, -2.02150531e-02f, -3.63708958e-02f,
  -5.57896122e-02f, 6.24506585e-02f, 9.68197547e-03f, -2.14098915e-02f, 6.82185516e-02f, 4.95603420e-02f, -1.58756059e-02f, 2.43902337e-02f, -9.99757722e-02f, -7.32112862e-03f,
  -1.16389757e-02f, 2.06174385e-02f, 9.17860866e-02f, -5.54990806e-02f, 7.59220719e-02f, -2.71878857e-02f, 5.84057160e-03f, -4.85406257e-02f, 7.00335130e-02f, 3.77107598e-02f,
  8.80102720e-03f, -1.09799979e-02f, 5.83135895e-02f, 2.30223481e-02f, -5.51227555e-02f, -1.06849030e-01f, 4.91018258e-02f, 5.98660251e-03f, 4.14188877e-02f, 1.41621102e-02f,
  -6.90228641e-02f, 1.77243201e-03f, -2.38123760e-02f, -3.92473908e-03f, -2.31587887e-02f, 2.50648316e-02f, 7.69535899e-02f, 5.05452491e-02f, -9.17880156e-04f, -6.94333538e-02f,
  3.17674965e-01f, 2.09265292e-01f, 9.59260538e-02f, 4.87041362e-02f, 8.19041505e-02f, 2.11451232e-01f, 2.80506909e-01f, 2.01722637e-01f, 3.05443536e-03f, 6.37698323e-02f,
  2.26741880e-01f, 1.39930815e-01f, -3.04531548e-02f, 4.36642542e-02f, 4.77058850e-02f, -4.27234769e-02f, -1.62574545e-01f, -1.04443729e-01f, -7.46748000e-02f, 3.06441244e-02f,
  1.75787248e-02f, -3.88201349e-03f, 2.77658924e-02f, -9.05854627e-02f, -1.79591402e-01f, -8.27715844e-02f, -1.57836266e-02f, 8.81750658e-02f, -8.23819116e-02f, -2.39637643e-01f,
  -1.01851314e-01f, 2.44779035e-01f, -1.16636917e-01f, -3.11728977e-02f, -8.45913067e-02f, -3.17357332e-02f, 2.34194305e-02f, -1.12713099e-01f, -2.56328620e-02f, -2.30627134e-03f,
  -4.23442386e-02f, -2.35062744e-02f, 1.22496067e-02f, -2.96373088e-02f, -4.03662911e-03f, 5.58118382e-03f, -3.51091451e-03f, 5.58839329e-02f, -3.08353752e-02f, 2.36647967e-02f,
  1.31329047e-02f, 1.50956035e-01f, 1.41703248e-01f, 5.81185855e-02f, 7.78260380e-02f, 5.24941273e-03f, 4.17721421e-02f, -1.09258778e-01f, 2.29156278e-02f, -1.37563378e-01f,
  8.93136039e-02f, 9.37178656e-02f, 7.86053240e-02f, 3.22372392e-02f, -9.24986005e-02f, 4.08428684e-02f, -1.03895627e-01f, -4.26723249e-02f, 1.75214540e-02f, 5.49639203e-02f,
  8.32724422e-02f, 4.43563648e-02f, 5.01643941e-02f, -2.43231785e-02f, 1.86346062e-02f, -8.73968005e-03f, 8.68539885e-02f, -1.91824380e-02f, 6.42098188e-02f, -3.16121578e-02f,
  -1.68749280e-02f, 2.43200958e-02f, 7.72308111e-02f, 4.76225615e-02f, 4.75324392e-02f, 6.70409948e-02f, 3.94617394e-02f, 3.76867726e-02f, 1.30587682e-01f, 7.01138228e-02f,
  -1.36160672e-01f, 2.42137134e-01f, -9.35763940e-02f, -6.67650327e-02f, -8.69572088e-02f, -5.17308228e-02f, 4.54196520e-02f, -9.14604813e-02f, 3.65994722e-02f, -8.67073983e-02f,
  7.98532516e-02f, -6.26017824e-02f, 1.01314075e-01f, -3.14973947e-03f, -6.97767362e-02f, 5.16080260e-02f, -5.39148226e-03f, -1.81748800e-03f, 3.53450663e-02f, 3.97609314e-03f,
  -8.50823373e-02f, 4.60911766e-02f, -3.42831649e-02f, -3.40501964e-02f, 1.64713226e-02f, 5.97000532e-02f, 4.37962301e-02f, -2.35418007e-02f, 2.96411160e-02f, -1.01830639e-01f,
  1.51037484e-01f, -1.15395084e-01f, -1.67413816e-01f, 4.29572091e-02f, -8.40142444e-02f, -6.66121840e-02f, 2.67736688e-02f, 9.88352820e-02f, 1.26864284e-01f, 2.50161421e-02f,
  9.16876048e-02f, 7.29855075e-02f, 9.06259790e-02f, 5.05095907e-02f, -6.87405169e-02f, -2.25414820e-02f, -1.94624767e-01f, -6.70738285e-03f, 3.83454449e-02f, 1.03697814e-01f,
  1.49929468e-02f, 8.56878757e-02f, -8.23454000e-03f, 1.41004156e-02f, -7.18484223e-02f, -7.11536109e-02f, -5.68189546e-02f, -5.58074750e-02f, -9.99749899e-02f, -4.93586510e-02f,
  -1.17685907e-01f, -3.12582217e-02f, 9.89902616e-02f, 7.06443861e-02f, 8.87518376e-02f, 4.74911593e-02f, -6.52235895e-02f, -6.91815093e-02f, 2.77260151e-02f, 6.75200149e-02f,
  1.06329294e-02f, 4.14143736e-03f, -6.77891122e-03f, 7.21587911e-02f, -5.61005883e-02f, 1.04828380e-01f, 3.99037451e-02f, -4.92116623e-02f, -5.04321493e-02f, 5.00484146e-02f,
  5.63567579e-02f, 8.71269219e-03f, -8.80441144e-02f, -3.92187722e-02f, 1.38302492e-02f, 7.92965740e-02f, 2.63842847e-02f, 8.02934170e-03f, -1.05185054e-01f, 6.55027032e-02f,
  -7.32799619e-02f, -7.18259588e-02f, -8.22232664e-02f, 7.46272132e-02f, 1.32728191e-02f, -6.63207546e-02f, 4.97046374e-02f, -7.89286122e-02f, 8.40321463e-03f, 4.55209389e-02f,
  -6.23621792e-02f, -8.13481808e-02f, 7.34274536e-02f, -6.46185875e-02f, -8.21148753e-02f, -1.13103792e-01f, -1.13260247e-01f, -1.28572196e-01f, 5.09309303e-03f, -1.22092320e-02f,
  4.46976572e-02f, -3.16250585e-02f, 4.56101000e-02f, 2.42501795e-02f, -1.01137646e-01f, -1.76724866e-02f, 4.54496741e-02f, 8.03512931e-02f, -3.21070254e-02f, 2.38669962e-02f,
  6.95793554e-02f, 5.25136404e-02f, 1.67415962e-02f, 1.43760126e-02f, -2.75644194e-02f, -3.04814056e-02f, -5.01935072e-02f, -7.01779872e-02f, 4.61289622e-02f, 9.78529453e-02f,
  -4.69803810e-02f, -5.46404682e-02f, 4.53708433e-02f, -3.58504266e-03f, -4.90510697e-03f, 2.93878093e-02f, 7.60229630e-03f, -2.49219071e-02f, -7.08720163e-02f, 4.34862114e-02f,
  -5.62722348e-02f, -5.01403101e-02f, 8.31670687e-02f, 6.10654093e-02f, -5.66884242e-02f, -7.18691796e-02f, -4.45838273e-02f, -6.63702935e-02f, -9.42857713e-02f, -5.60361855e-02f,
  -6.45112395e-02f, 5.77458329e-02f, -1.23633958e-01f, 1.86927877e-02f, -7.88109675e-02f, 6.01421334e-02f, -9.49061811e-02f, -2.75743157e-02f, -2.15781014e-02f, -2.53177490e-02f,
  1.10586639e-02f, -8.46290961e-03f, 5.96651435e-02f, -1.16203956e-01f, -1.42040953e-01f, -7.04049617e-02f, -1.96398720e-01f, -1.58634350e-01f, -1.35569632e-01f, 5.78915924e-02f,
  1.21607706e-02f, 5.08478209e-02f, -6.17167763e-02f, -9.39285755e-03f, 5.49179651e-02f, 9.13240667e-03f, 1.21058188e-02f, 1.98764782e-02f, -1.25697732e-01f, -1.25455871e-01f,
  -1.09838948e-01f, 7.58434907e-02f, -6.80930689e-02f, 9.50317755e-02f, -9.85729392e-04f, 6.59239367e-02f, 5.67744039e-02f, 1.02970600e-01f, -2.41321884e-02f, -3.99183147e-02f,
  -2.57401243e-02f, 3.02385874e-02f, 5.46403900e-02f, -3.90755422e-02f, 6.16209097e-02f, 9.58715305e-02f, 3.78100686e-02f, 7.07427487e-02f, 1.89507958e-02f, 3.74852531e-02f,
  7.60902166e-02f, 6.62098080e-02f, -5.47593608e-02f, -5.16729578e-02f, -5.99127151e-02f, 6.86492305e-04f, 5.89893125e-02f, 4.96895462e-02f, 8.24211314e-02f, 1.41244337e-01f,
  4.83566411e-02f, -1.29036941e-02f, -5.42875612e-03f, -4.44823839e-02f, -4.64690551e-02f, 8.83513615e-02f, -5.22702150e-02f, -8.71073753e-02f, -1.42543828e-02f, 3.58050466e-02f,
  1.21391654e-01f, 1.06783155e-02f, -6.32971078e-02f, 5.58759421e-02f, -5.20554557e-02f, 6.67383522e-02f, -6.65306002e-02f, -2.64547300e-02f, -9.20150727e-02f, 2.77143307e-02f,
  -3.92324626e-02f, -8.51725042e-02f, 1.48326466e-02f, 1.26245506e-02f, 4.91212793e-02f, -6.48292750e-02f, 1.31114235e-03f, -8.89400914e-02f, 1.22584905e-02f, 3.17183658e-02f,
  9.81232151e-02f, -1.47585869e-01f, 3.61613999e-03f, -5.47012538e-02f, 2.47619506e-02f, 2.36627255e-02f, 4.67448831e-02f, -7.89299309e-02f, -6.35513067e-02f, -1.70071563e-03f,
  1.89732239e-02f, 6.09448850e-02f, 5.99420890e-02f, -8.37541011e-04f, 5.18006161e-02f, 6.00414686e-02f, 8.82001519e-02f, -8.50502178e-02f, 5.58218285e-02f, -2.78605912e-02f,
  -1.28166238e-02f, 5.33043854e-02f, -4.04529199e-02f, -5.92214577e-02f, 7.26385042e-02f, -9.04948786e-02f, -1.00805447e-01f, 8.99344757e-02f, -7.47196525e-02f, 9.67035592e-02f,
  -1.44567072e-01f, -1.37872063e-02f, -1.07379384e-01f, -5.40933423e-02f, -6.57131746e-02f, 2.53033433e-02f, 1.01887740e-01f, 1.03206616e-02f, -1.20120965e-01f, 9.63778794e-02f,
  2.68236678e-02f, -6.82083368e-02f, 1.54799577e-02f, -8.95554274e-02f, -2.97977347e-02f, 9.26957056e-02f, -3.31410877e-02f, -5.55483475e-02f, -4.70216945e-02f, 1.06332362e-01f,
  -2.62947995e-02f, 2.87639210e-03f, -1.20136961e-01f, -1.20416388e-01f, 2.22166553e-02f, 5.33859432e-02f, -4.11205329e-02f, -1.17557034e-01f, 4.49747108e-02f, -3.15144956e-02f,
  1.95977390e-01f, -2.46241003e-01f, -6.13588244e-02f, -3.48313078e-02f, -2.19498537e-02f, 5.88251203e-02f, 7.19938278e-02f, -6.55580312e-02f, -2.45779138e-02f, 5.85851036e-02f,
  -4.56000939e-02f, 3.49311046e-02f, -6.80997446e-02f, 7.88996220e-02f, 1.98432375e-02f, -1.96919590e-02f, -9.62168425e-02f, 4.37186249e-02f, 2.50549731e-03f, 3.53314877e-02f,
  -1.67629067e-02f, -7.63675570e-02f, -7.77846128e-02f, 3.29010598e-02f, -5.54672182e-02f, 2.39184462e-02f, 4.80798036e-02f, -1.09287500e-01f, -4.55533005e-02f, 1.32564440e-01f,
  7.13192448e-02f, -1.21499887e-02f, -1.05824105e-01f, 5.97607829e-02f, 1.78448670e-02f, -2.49480736e-02f, -3.94261666e-02f, 1.01308860e-01f, 7.91985169e-02f, 1.04629099e-01f,
  6.01385273e-02f, 5.19626327e-02f, -3.00984476e-02f, 1.36894926e-01f, -1.63061116e-02f, 7.44886417e-03f, -4.21726182e-02f, 5.94399236e-02f, 1.27646269e-03f, 5.59877492e-02f,
  -8.56335387e-02f, -5.22889160e-02f, 6.11736178e-02f, 7.28849694e-02f, -1.76490936e-02f, -1.15055181e-01f, -1.17101357e-03f, -5.24484320e-03f, -1.00601397e-01f, -5.40640131e-02f,
  2.24529624e-01f, -2.41453752e-01f, 1.20492086e-01f, 2.75657345e-02f, -7.15316385e-02f, -1.02505378e-01f, -1.10381119e-01f, -4.66538891e-02f, -2.43001580e-02f, 8.40224549e-02f,
  -7.80902943e-03f, 1.42516308e-02f, 7.70891309e-02f, -2.49174666e-02f, 7.95677751e-02f, -1.84816064e-03f, 6.71030432e-02f, -7.80443400e-02f, -2.78864126e-03f, -5.48820347e-02f,
  8.47813040e-02f, 1.44682556e-01f, 1.10022470e-01f, 1.13869004e-01f, -4.67337891e-02f, 7.47278854e-02f, 5.66441230e-02f, 9.28937122e-02f, 2.46477686e-02f, 2.55432069e-01f,
  -3.58313769e-01f, 4.69382256e-02f, 3.49501483e-02f, -9.26532596e-02f, 1.12922117e-01f, 1.47091795e-03f, 1.16362125e-01f, -4.93955053e-02f, -1.21912487e-01f, -5.13113700e-02f,
  -9.02931690e-02f, 2.11755950e-02f, 5.03813252e-02f, 1.73393078e-02f, 7.88465738e-02f, 1.34253561e-01f, 1.51289210e-01f, 5.90269044e-02f, -2.01302573e-01f, -2.74716597e-02f,
  9.50098634e-02f, -7.95440674e-02f, -9.41688642e-02f, -1.21408716e-01f, 1.03259735e-01f, -2.03393749e-03f, 3.33564915e-02f, 2.54492611e-02f, 1.68018118e-02f, 2.44621664e-01f,
  -2.28611249e-02f, -1.11315213e-01f, -5.18212691e-02f, 8.81866515e-02f, 7.40141496e-02f, -1.11286692e-01f, -2.59873681e-02f, -1.00350745e-01f, -1.02914646e-01f, -7.16453493e-02f,
  7.01760724e-02f, -6.65081292e-02f, 9.89253968e-02f, 9.34947729e-02f, -7.09231049e-02f, -9.16783437e-02f, 2.95804907e-02f, -1.38940010e-03f, -8.22011009e-03f, -1.08229667e-01f,
  1.47089198e-01f, -3.08930054e-02f, -1.69789866e-01f, -5.30370846e-02f, -7.53252283e-02f, -1.14236325e-01f, -1.33199960e-01f, -1.23523071e-01f, -1.70099020e-01f, -2.82812566e-02f,
  -3.37056592e-02f, 1.10702150e-01f, 1.14345416e-01f, 6.71761557e-02f, 1.49669899e-02f, -5.93940057e-02f, 1.04127854e-01f, -1.65406696e-03f, 6.38813525e-02f, -5.74994273e-02f,
  7.23210210e-03f, -9.97281671e-02f, -3.59101705e-02f, -6.39715642e-02f, -3.84499803e-02f, -3.28609683e-02f, -4.83326241e-02f, -2.50833202e-02f, -9.36829951e-03f, -9.55422595e-02f,
  2.41833851e-02f, 2.64507513e-02f, 1.28284041e-02f, -6.30836887e-03f, 6.24703430e-02f, 5.06704301e-02f, 5.82739199e-03f, 2.08238401e-02f, 6.85399324e-02f, -4.92640883e-02f,
  -1.39316469e-01f, 7.22109824e-02f, 5.66921383e-02f, -3.17540839e-02f, -6.83466047e-02f, 6.82888627e-02f, 3.26136388e-02f, -1.44307725e-02f, 1.58104450e-02f, -9.69860479e-02f,
  -9.03460756e-03f, -7.15223029e-02f, 1.49015104e-02f, -4.57453951e-02f, -4.57366668e-02f, -9.02131721e-02f, 5.22673950e-02f, -1.60471555e-02f, 3.68561246e-03f, -8.08452889e-02f,
  -3.28086428e-02f, -1.27961993e-01f, -2.04752892e-01f, -2.18374822e-02f, -6.38081580e-02f, -5.42063527e-02f, -5.92648461e-02f, -2.75962204e-02f, -7.65584037e-02f, -9.34758931e-02f,
  2.29784295e-01f, 6.34150952e-02f, 4.69861403e-02f, 6.57820031e-02f, 4.78660921e-04f, 3.96372676e-02f, -4.97353934e-02f, -7.81787857e-02f, -9.85453948e-02f, 7.80782923e-02f,
  1.42053455e-01f, -6.52156100e-02f, -4.84435335e-02f, -2.44543757e-02f, 4.68244068e-02f, -5.63305765e-02f, 7.76145468e-03f, -6.76310286e-02f, -1.30290538e-02f, -2.38746908e-02f,
  4.45044637e-02f, 1.27926022e-01f, 1.08621292e-01f, -1.29164811e-02f, 2.34779231e-02f, 6.96557835e-02f, 6.76870346e-02f, 2.09914036e-02f, 1.00843765e-01f, 9.72073674e-02f,
  1.30194528e-02f, 1.69015765e-01f, -1.52148008e-01f, 2.10231524e-02f, 9.01250169e-02f, 5.78451939e-02f, 1.09146729e-01f, -1.96076427e-02f, 4.61294129e-02f, -1.88746322e-02f,
  -5.73037416e-02f, 1.10638209e-01f, 5.81953898e-02f, 4.87583503e-02f, -6.13132268e-02f, 1.87269729e-02f, 7.08768815e-02f, -2.98092775e-02f, 5.93975699e-03f, 8.16485360e-02f,
  1.64530985e-02f, -3.33878677e-03f, -2.46191341e-02f, -7.71133155e-02f, -3.04104388e-02f, -7.65255764e-02f, -6.19640425e-02f, -5.02061881e-02f, 3.65212262e-02f, 8.51989836e-02f,
  -6.05560280e-03f, 7.18406886e-02f, 9.86554697e-02f, 2.91520283e-02f, -2.81589329e-02f, -6.99036345e-02f, -5.85890561e-02f, -4.47405279e-02f, -4.03904952e-02f, 6.12498596e-02f,
  -2.34735347e-02f, 3.30944061e-02f, 3.65874991e-02f, -5.95807098e-02f, 5.18650301e-02f, 2.79795285e-02f, 4.42377329e-02f, 3.04249097e-02f, -7.63378739e-02f, 1.63420383e-02f,
  -1.06902712e-03f, 8.55229050e-03f, 7.62875229e-02f, 5.22891991e-02f, 5.88031188e-02f, -6.21112846e-02f, 1.42770912e-02f, -8.28872900e-03f, 7.09490338e-03f, 1.30394191e-01f,
  4.99047935e-02f, -9.87280533e-02f, -6.03984743e-02f, -7.35933781e-02f, 2.31902185e-03f, 6.43850341e-02f, -5.10568470e-02f, 5.71719855e-02f, -2.06781439e-02f, -1.54815177e-02f,
  5.89626096e-03f, -6.62093535e-02f, -8.65518954e-03f, -4.90619754e-03f, -7.55501762e-02f, 1.54878758e-02f, -7.76417553e-02f, 2.59124637e-02f, -1.06243566e-01f, 3.74389328e-02f,
  -1.06251664e-01f, -7.36079067e-02f, -9.79900733e-02f, -1.62267536e-01f, -2.75032409e-02f, -9.80134457e-02f, -6.33695573e-02f, -8.69346112e-02f, 9.77352448e-03f, -3.28684412e-03f,
  -3.65836352e-01f, 8.10539424e-02f, 1.83460675e-02f, -1.61200181e-01f, 9.76387858e-02f, 7.97956064e-02f, 1.19929641e-01f, 3.76517884e-02f, -1.25997171e-01f, 1.00010253e-01f,
  -2.23065428e-02f, 5.92932366e-02f, -2.52276547e-02f, 2.94261929e-02f, -1.76459402e-02f, 1.70116410e-01f, 6.54799864e-02f, -1.06392093e-01f, -1.04893848e-01f, 3.38647254e-02f,
  4.42415364e-02f, -8.27599242e-02f, -1.07230663e-01f, -3.06574479e-02f, 2.60351002e-02f, 6.46121129e-02f, -3.98831032e-02f, -5.43306023e-02f, 1.72617566e-02f, 1.98861912e-01f,
  -9.86997485e-02f, -7.73919225e-02f, 8.46937001e-02f, 1.14679486e-02f, -2.69769114e-02f, -4.92400341e-02f, 4.41167131e-02f, -5.95510714e-02f, 1.71776023e-02f, -1.62624791e-02f,
  -5.25529198e-02f, -3.08763701e-02f, 8.13903436e-02f, 7.58238584e-02f, -5.56806028e-02f, -5.49250543e-02f, -1.11293182e-01f, 2.82577928e-02f, 3.61469984e-02f, -1.00722825e-02f,
  9.24373195e-02f, 6.95440592e-03f, -3.90936956e-02f, -5.18772146e-03f, 5.42376973e-02f, -3.71153913e-02f, -1.22372746e-01f, -7.68027678e-02f, -6.41723052e-02f, -1.66114241e-01f,
  4.01955955e-02f, -5.18199652e-02f, -5.36498018e-02f, -1.21131398e-01f, -5.32670990e-02f, 5.41181862e-02f, -7.11610764e-02f, 9.05407816e-02f, 7.05863461e-02f, 1.65492352e-02f,
  5.23385480e-02f, 1.88586917e-02f, -4.18428555e-02f, -4.80705202e-02f, -1.07170828e-02f, 7.58550316e-02f, 4.95268367e-02f, 2.05768947e-03f, -6.44741207e-02f, -1.36006940e-02f,
  -3.31100784e-02f, -3.59257683e-03f, 1.15286428e-02f, 3.63219120e-02f, -4.63120677e-02f, 7.99553171e-02f, 1.80735043e-03f, 4.34929021e-02f, -1.05765939e-01f, -3.46587691e-03f,
  -2.11717606e-01f, -4.35874537e-02f, -6.92548007e-02f, -4.36230376e-02f, -4.46631163e-02f, -7.79964179e-02f, 3.21850181e-02f, -2.65923347e-02f, 1.10347616e-02f, 3.07451375e-02f,
  6.09503575e-02f, -1.25921711e-01f, 3.41577753e-02f, -1.78721696e-02f, 1.81408133e-02f, -7.35526830e-02f, -4.56314674e-03f, -3.24931405e-02f, -6.14539944e-02f, -6.27307594e-02f,
  8.79518539e-02f, -1.42375499e-01f, -9.12979767e-02f, -1.05042510e-01f, -8.73989016e-02f, -1.39775455e-01f, -3.43849324e-03f, -5.92500418e-02f, -7.01672286e-02f, -2.12438390e-01f,
  -2.12101310e-01f, -3.81964445e-01f, -2.68637240e-02f, -9.84012708e-02f, -9.25178379e-02f, 3.77146974e-02f, -3.30679685e-01f, -2.49339379e-02f, -1.00913219e-01f, -2.71196365e-01f,
  -1.73894912e-01f, 1.50384322e-01f, 7.33596161e-02f, 1.21486582e-01f, -1.30508235e-02f, -1.74016118e-01f, -1.57552108e-01f, 2.07171425e-01f, 2.80206919e-01f, 5.12436293e-02f,
  -1.62849091e-02f, 5.22170998e-02f, 1.60995036e-01f, 6.47594081e-03f, -1.71749607e-01f, -6.62917271e-02f, -1.50334612e-02f, -3.30207907e-02f, 2.53899191e-02f, -8.55388194e-02f,
  -1.39891341e-01f, -8.46839026e-02f, 1.48450896e-01f, 4.15593125e-02f, -4.79009710e-02f, -5.75083569e-02f, -3.55119072e-02f, -1.65333580e-02f, 7.20126703e-02f, -3.60058285e-02f,
  2.76382864e-02f, 1.92605425e-02f, -9.60800331e-03f, 6.77985419e-03f, -3.60462368e-02f, 1.10404277e-02f, -7.36214500e-03f, 1.02922730e-01f, 6.66326284e-02f, -1.26821324e-01f,
  3.22817117e-02f, -3.44968662e-02f, -5.86164966e-02f, 2.81373654e-02f, 7.42317215e-02f, 4.85261641e-02f, -1.86345645e-03f, 1.02601051e-02f, -8.19779038e-02f, -2.55223870e-01f,
  -5.25444448e-02f, 4.44558486e-02f, 6.72747120e-02f, -1.47177977e-02f, 5.18455952e-02f, -2.55164299e-02f, -1.58054512e-02f, -3.30747962e-02f, 8.13647434e-02f, -6.47859694e-03f,
  3.77005786e-02f, -1.92806907e-02f, 4.45956811e-02f, -1.11154079e-01f, 3.88266779e-02f, 7.97124282e-02f, -5.16112335e-03f, -7.15555921e-02f, -2.77833100e-02f, 6.67972118e-02f,
  2.92363502e-02f, 2.72565149e-02f, 5.21659330e-02f, 5.82881570e-02f, -3.20241489e-02f, -6.04550354e-02f, 5.09678870e-02f, 2.22538691e-02f, -3.64523940e-02f, 8.27513114e-02f,
  -1.76672727e-01f, 2.72140712e-01f, -2.29800016e-01f, -7.59574622e-02f, -6.17215112e-02f, -1.96418632e-02f, -9.49771926e-02f, 4.59021553e-02f, 7.47597814e-02f, -6.92667738e-02f,
  -2.57442370e-02f, -4.29747254e-02f, -1.44806383e-02f, -2.99396347e-02f, 8.31467807e-02f, -6.19249269e-02f, -8.77625570e-02f, 3.13151851e-02f, 1.21726252e-01f, 3.80388573e-02f,
  -5.82826138e-02f, -3.76921855e-02f, -7.94527978e-02f, -9.03219581e-02f, -5.23225516e-02f, 1.66634773e-03f, 4.02528644e-02f, -1.25023201e-01f, 2.10714689e-03f, -2.88520634e-01f,
  -1.04432650e-01f, 1.21712781e-01f, 1.44565463e-01f, -1.96701825e-01f, 3.85690853e-02f, 1.39304906e-01f, 1.43478274e-01f, 4.49413694e-02f, -2.97620054e-02f, 6.83310404e-02f,
  1.98736954e-02f, -1.44329786e-01f, 1.97036657e-02f, 2.35400554e-02f, -2.49548927e-02f, 1.29384667e-01f, -2.39393525e-02f, 1.22042431e-04f, -1.34625182e-01f, -2.79320274e-02f,
  -6.49976283e-02f, -9.81043503e-02f, -5.23757823e-02f, -9.13577378e-02f, 3.94634111e-03f, -8.23217556e-02f, 8.41111019e-02f, 5.67613840e-02f, 4.25129384e-02f, -8.44925568e-02f,
  4.09499742e-02f, 1.24983832e-01f, -7.20135495e-02f, -9.98943001e-02f, 6.24826476e-02f, 5.76284863e-02f, 4.49265800e-02f, 1.53847914e-02f, -7.12347254e-02f, 8.46324116e-02f,
  5.20594083e-02f, -6.09382913e-02f, -5.81179000e-02f, 7.00063957e-03f, -1.88327208e-02f, 7.59404227e-02f, -3.61587666e-02f, -5.21355532e-02f, -2.38326099e-02f, 7.28928447e-02f,
  -2.20906679e-02f, -4.36701365e-02f, 4.49034758e-02f, 1.43004833e-02f, 8.51801038e-02f, -1.31998613e-01f, 6.96722344e-02f, -1.05419137e-01f, 7.18913972e-02f, -2.38239467e-02f,
  -8.85898843e-02f, -4.66656797e-02f, 3.13960500e-02f, -8.18087533e-02f, 1.22217471e-02f, 3.56449075e-02f, 1.59223042e-02f, -6.18585087e-02f, 6.06895946e-02f, 9.28093269e-02f,
  6.01765551e-02f, 7.83280879e-02f, 1.24918841e-01f, 7.45094642e-02f, 5.45192370e-03f, -6.48470595e-02f, 6.94042742e-02f, -4.70732972e-02f, -5.70794642e-02f, 4.88658659e-02f,
  1.68326602e-03f, 2.56920382e-02f, 5.68007410e-04f, -2.16664840e-02f, -8.02437887e-02f, -4.44446085e-03f, 4.90172915e-02f, 1.44785305e-03f, 7.98364729e-02f, 7.87872300e-02f,
  5.27015515e-02f, 4.46893238e-02f, -5.08023389e-02f, -5.25020435e-02f, 1.28385806e-02f, -4.24406007e-02f, -1.58704557e-02f, -6.48449957e-02f, -6.47061616e-02f, 9.88511890e-02f,
  7.89585412e-02f, -6.34353012e-02f, -8.51048273e-04f, 5.28900698e-02f, 7.34336227e-02f, -2.90591847e-02f, -2.67289504e-02f, -6.75627589e-03f, -4.65115607e-02f, -2.93849991e-03f,
  5.12599684e-02f, -6.32016584e-02f, -9.57455114e-02f, -1.91237796e-02f, -7.12591633e-02f, 5.24431169e-02f, -4.94291596e-02f, 8.13514516e-02f, 6.27686828e-02f, 8.23520962e-03f,
  -2.02015862e-01f, -4.46898937e-02f, 2.44740453e-02f, -8.73256922e-02f, -1.23819947e-01f, -2.19387189e-02f, 1.44442301e-02f, -1.38226114e-02f, -1.04402274e-01f, 5.83618097e-02f,
  -1.24632746e-01f, -1.77791063e-02f, 7.38692004e-03f, -5.64263649e-02f, -1.03300259e-01f, 4.79493402e-02f, 1.10549748e-01f, -2.01300066e-02f, 1.06763147e-01f, 1.07091025e-01f,
  7.75264874e-02f, 3.20925238e-03f, -3.51327062e-02f, 4.41058865e-03f, 1.52566675e-02f, -2.57127844e-02f, 6.58939555e-02f, -5.45618348e-02f, 4.81420010e-03f, 2.53699943e-02f,
  1.99578524e-01f, 3.07455361e-02f, 1.10832043e-01f, -4.92877439e-02f, -6.06089048e-02f, 1.27556063e-02f, 3.74141410e-02f, -4.86706896e-03f, -2.20521856e-02f, -1.38801346e-02f,
  3.92113961e-02f, 1.58215873e-02f, 6.25631735e-02f, -8.26513469e-02f, -5.80450147e-02f, -6.95500299e-02f, 2.60911137e-02f, -6.56539202e-02f, 8.80269036e-02f, -1.64995603e-02f,
  -7.03201666e-02f, 5.31996484e-04f, -1.78409386e-02f, -4.86554280e-02f, -2.73250509e-02f, 4.93902229e-02f, -4.50561987e-03f, -3.37012187e-02f, 2.15226263e-02f, 6.83417171e-02f,
  8.87881368e-02f, 1.03686444e-01f, -3.01159173e-02f, -2.60332152e-02f, -1.10347858e-02f, -3.19116339e-02f, -2.41765156e-02f, 8.31096992e-03f, -3.42400484e-02f, 6.44773524e-03f,
  -5.31521328e-02f, 6.19557835e-02f, -5.62506840e-02f, -2.46147066e-02f, 5.67700416e-02f, -1.11088725e-02f, 4.82989615e-03f, 3.35941687e-02f, -8.48331079e-02f, 1.86093058e-02f,
  -1.16829230e-02f, -3.06041203e-02f, 1.30790155e-02f, 3.57726291e-02f, -6.80892766e-02f, -8.62034038e-02f, 6.35344908e-02f, -5.17355017e-02f, -2.44689789e-02f, -7.93890432e-02f,
  2.02886030e-01f, -1.33427933e-01f, 1.26907066e-01f, 7.98834562e-02f, 1.29843084e-02f, 7.52076954e-02f, -9.82295722e-03f, 2.28848066e-02f, 3.77998650e-02f, 4.88763349e-03f,
  7.63041601e-02f, 4.23314758e-02f, 8.39869608e-04f, 1.23749729e-02f, 1.96347740e-02f, 4.66834009e-02f, 3.91257443e-02f, 2.41794381e-02f, -1.65109318e-02f, -2.59000380e-02f,
  -5.90060540e-02f, 2.31804587e-02f, -4.91523035e-02f, 6.96943104e-02f, 1.08217269e-01f, -4.72638234e-02f, 6.07704557e-02f, 1.02437049e-01f, 9.69012305e-02f, 7.81275257e-02f,
  -3.77991208e-04f, -7.00487755e-03f, -1.45845160e-01f, 9.20249242e-03f, 1.10979892e-01f, 9.27445963e-02f, -3.91294062e-03f, 2.99062440e-03f, 1.06078506e-01f, -3.33070122e-02f,
  3.44216824e-02f, -5.08498624e-02f, -1.17448658e-01f, -9.20334905e-02f, -2.04644307e-01f, -7.58192390e-02f, -1.48535296e-01f, -2.07815170e-01f, -6.44034073e-02f, -4.68386747e-02f,
  1.05594411e-01f, -3.17075774e-02f, -9.90135446e-02f, 6.19717687e-02f, 1.54515103e-01f, 5.99190965e-03f, 4.12179157e-02f, 1.58012927e-01f, 1.98414817e-01f, 1.40611023e-01f,
  1.01263762e-01f, 5.89043088e-02f, 2.61429492e-02f, -4.08879891e-02f, 3.75609323e-02f, 5.19126989e-02f, 1.52242705e-02f, -9.07986835e-02f, -9.80667118e-03f, 6.46075653e-03f,
  3.03759649e-02f, 3.51425298e-02f, -1.10632583e-01f, -3.84210348e-02f, -1.23096369e-01f, -1.14753745e-01f, -7.02702999e-02f, -1.32500574e-01f, 1.38383210e-02f, 3.19224000e-02f,
  -4.52708974e-02f, 2.72534955e-02f, 2.30347272e-02f, -4.77867723e-02f, -8.51885006e-02f, 7.65141994e-02f, 1.13454252e-01f, 5.32174632e-02f, 1.05108380e-01f, 1.28903732e-01f,
  -5.61046489e-02f, 1.47987186e-04f, 2.90240031e-02f, 7.31289983e-02f, 2.17208322e-02f, 5.56061454e-02f, -8.56085047e-02f, -8.72871950e-02f, -4.36853357e-02f, -3.65234464e-02f,
  -4.32808138e-02f, 7.66061470e-02f, -4.09004949e-02f, -2.02269219e-02f, -2.10428126e-02f, 5.76503985e-02f, -9.95741338e-02f, -5.56695959e-05f, -3.34058776e-02f, -6.57530949e-02f,
  -5.05614243e-02f, -3.55217257e-03f, 4.42847051e-02f, 3.09134442e-02f, -7.73447603e-02f, 3.18952426e-02f, 5.41644059e-02f, -1.01021277e-02f, -1.74941383e-02f, 5.98679408e-02f,
  3.38728167e-02f, -1.20826513e-01f, -4.38050739e-02f, -7.01806024e-02f, 7.43141919e-02f, -1.14001418e-02f, -1.83892436e-02f, -1.14144757e-01f, -1.04398936e-01f, -5.93866669e-02f,
  6.37262347e-05f, -2.00184137e-02f, -4.95188832e-02f, 3.51902358e-02f, -1.00298196e-01f, 2.48562023e-02f, -1.52124651e-03f, -1.11402296e-01f, -8.35056230e-02f, -9.27452650e-03f,
  -8.16827044e-02f, 2.47169994e-02f, -1.06384447e-02f, -9.74397212e-02f, -7.01039881e-02f, -9.97055918e-02f, -2.62545701e-02f, -2.30238307e-02f, 1.80264469e-02f, 2.92544514e-02f,
  -5.27674034e-02f, -8.01596940e-02f, -9.06309783e-02f, 1.62270978e-01f, 2.92209294e-02f, 1.33280858e-01f, 1.47876635e-01f, 4.98416945e-02f, 6.75378591e-02f, 1.44649208e-01f,
  -1.07305916e-02f, 1.70885861e-01f, 1.31471589e-01f, 3.60859893e-02f, 7.07295015e-02f, 3.96353789e-02f, 1.39134064e-01f, 3.77601050e-02f, 1.19346030e-01f, 7.82865211e-02f,
  1.35546505e-01f, 1.03452712e-01f, -2.89759468e-02f, 1.95345096e-02f, 8.82038772e-02f, 5.19318320e-02f, 1.16358116e-01f, 9.08957496e-02f, -3.91246714e-02f, 6.87480643e-02f,
  3.27264965e-02f, 2.89646816e-02f, -5.73439002e-02f, 5.70544116e-02f, 4.31992076e-02f, -1.43016651e-01f, -5.00252917e-02f, -8.67479071e-02f, 1.46913202e-02f, -1.14294909e-01f,
  -7.47884717e-03f, -4.71283607e-02f, 1.03956319e-01f, 3.77870202e-02f, 2.33349353e-02f, -1.50809251e-02f, 2.83413157e-02f, -8.01048130e-02f, 4.68960218e-02f, 5.99235855e-02f,
  -3.38470563e-02f, -1.16724588e-01f, -1.14160515e-01f, 5.85478134e-02f, 7.22883120e-02f, 8.10514465e-02f, -8.47084746e-02f, -5.35000525e-02f, -8.00897405e-02f, -9.68743674e-03f,
  -1.61586609e-02f, -1.38783818e-02f, 3.70073915e-02f, -1.02122119e-02f, 5.16814645e-03f, 6.11112714e-02f, 7.34330490e-02f, 4.79208156e-02f, 8.29213113e-02f, 1.78468209e-02f,
  4.97533120e-02f, 7.36852409e-03f, 9.30130407e-02f, -1.42381238e-02f, -3.23811895e-03f, 1.38512421e-02f, -3.96175049e-02f, -6.34817481e-02f, -8.59282017e-02f, -5.74727319e-02f,
  -3.84761542e-02f, 5.06220050e-02f, -3.38822529e-02f, -5.66776581e-02f, -5.40404283e-02f, 5.18930331e-02f, -3.13486764e-03f, -7.31713995e-02f, 6.50289059e-02f, -8.76684040e-02f,
  -1.35943934e-01f, -6.83690235e-02f, -6.10919595e-02f, -1.84932239e-02f, -9.27877724e-02f, -1.09778173e-01f, 5.77300154e-02f, 4.87594120e-02f, 2.25283811e-03f, -2.20124703e-02f,
  -5.12979925e-02f, -7.76349427e-03f, 6.54628947e-02f, 3.60188223e-02f, 5.86597137e-02f, 4.60321084e-03f, -7.02503920e-02f, 3.40753868e-02f, -6.66223317e-02f, -1.02691136e-01f,
  -3.51839215e-02f, -8.91398937e-02f, -5.46067096e-02f, 3.75859300e-03f, -3.76645774e-02f, 1.07739773e-02f, -7.18868896e-02f, -9.73792374e-02f, -1.51385054e-01f, -7.61922542e-03f,
  -2.59758178e-02f, 1.92618519e-02f, 6.22543553e-03f, 3.16508003e-02f, -8.72644261e-02f, 4.77622822e-03f, 2.82488558e-02f, -6.00424930e-02f, -6.26462698e-02f, 5.32944240e-02f,
  -7.99859166e-02f, 5.19511662e-02f, -5.46716824e-02f, -4.51578479e-03f, -2.82048844e-02f, 1.04361558e-02f, -2.17630081e-02f, -8.78304616e-02f, 1.56258978e-02f, 2.38917042e-02f,
  -1.40844693e-03f, -6.42730370e-02f, -9.43445265e-02f, -8.35039541e-02f, -8.15930441e-02f, -4.79371324e-02f, 6.90265000e-02f, 3.32741737e-02f, 4.01070081e-02f, 4.99511436e-02f,
  -7.06137791e-02f, -4.87897458e-04f, 5.56672066e-02f, 2.07184654e-04f, 5.41276187e-02f, -6.20278269e-02f, -3.25554162e-02f, -2.70473864e-02f, 7.33826607e-02f, 5.37445992e-02f,
  -8.67918208e-02f, -3.20139192e-02f, 5.35311140e-02f, 8.96694511e-02f, 9.12152231e-02f, -6.36558011e-02f, 9.54911038e-02f, 9.03431401e-02f, 4.23753373e-02f, 9.18114092e-03f,
  -7.72254020e-02f, -4.38548578e-03f, 8.37932825e-02f, 1.18040435e-01f, -4.17520367e-02f, -1.97660308e-02f, 7.20025674e-02f, 4.35512438e-02f, -5.70369922e-02f, 7.77097568e-02f,
  -2.80102063e-02f, 8.19666386e-02f, -4.05500121e-02f, -5.57294860e-02f, -8.70063528e-02f, -5.53475320e-02f, -5.61607592e-02f, 2.22194921e-02f, 2.61890534e-02f, 6.49537444e-02f,
  8.29098001e-02f, 2.94281673e-02f, 2.14031227e-02f, -8.11127424e-02f, -2.19135378e-02f, 2.45812465e-03f, -2.47847401e-02f, 1.37325423e-02f, 6.64336309e-02f, -5.17748967e-02f,
  5.50746582e-02f, 4.44503203e-02f, -4.45432588e-02f, 5.67748328e-04f, -1.79872173e-03f, 6.68854713e-02f, -2.43084226e-03f, -3.84096950e-02f, 4.98969629e-02f, -1.07273273e-01f,
  4.51241285e-02f, 1.07824549e-01f, 2.66167913e-02f, 5.21436594e-02f, 5.43788001e-02f, 5.74103184e-02f, -8.40768740e-02f, 4.60056216e-02f, -1.64847951e-02f, 8.95924214e-03f,
  2.83540059e-02f, 1.62405148e-02f, -3.10060568e-02f, -7.86167849e-03f, 2.94703096e-02f, 3.72100100e-02f, -4.32078354e-02f, -5.53498976e-02f, -5.60660884e-02f, 4.96241413e-02f,
  2.62241829e-02f, -6.56009465e-02f, -8.67717341e-02f, 7.04835877e-02f, -6.97853118e-02f, 3.34503204e-02f, 7.19813183e-02f, 5.22281900e-02f, -7.79352039e-02f, 6.06383011e-02f,
  9.31503624e-02f, 9.57193077e-02f, 4.13464941e-02f, 7.64006972e-02f, -1.06334135e-01f, -1.11635342e-01f, -7.19446540e-02f, -3.55915204e-02f, 3.53051946e-02f, 4.84998897e-02f,
  5.89775927e-02f, 1.04787774e-01f, 3.32313925e-02f, 2.12568268e-02f, -5.12873568e-03f, -1.00920714e-01f, -7.48137534e-02f, -7.99783319e-02f, -1.22659765e-01f, -3.11452895e-02f,
  5.28179817e-02f, -5.35749905e-02f, 4.57771719e-02f, -5.51980212e-02f, 9.62109417e-02f, 5.48762642e-03f, -1.94763839e-02f, 5.72693981e-02f, 3.30614857e-02f, 5.31890467e-02f,
  -2.20297948e-02f, 4.34112884e-02f, 4.11827788e-02f, 4.06929664e-03f, -1.32517675e-02f, -7.55084157e-02f, -7.88823813e-02f, -1.04747685e-02f, -6.13640137e-02f, 7.95299187e-02f,
  2.52610277e-02f, 6.36046752e-02f, 3.90367359e-02f, -9.30048078e-02f, -1.01440884e-02f, 5.93601763e-02f, 3.57987136e-02f, -8.57207850e-02f, -3.67106055e-03f, 4.41756137e-02f,
  -7.30565935e-02f, -7.85397962e-02f, 2.39063017e-02f, 4.73548658e-02f, -1.13106616e-01f, 4.66715582e-02f, 5.46406396e-02f, -3.37114744e-02f, -7.49928504e-02f, 7.65554681e-02f,
  -1.12198025e-01f, -3.39449309e-02f, -9.69736874e-02f, -7.73294494e-02f, 2.36170087e-03f, 2.39592213e-02f, 4.51849122e-03f, -3.80339175e-02f, -3.39596309e-02f, -3.71699259e-02f,
  2.82068476e-02f, -2.28074789e-02f, -7.02641755e-02f, 3.35980877e-02f, -8.05143192e-02f, -1.79890394e-02f, 5.31174913e-02f, -7.78108314e-02f, 1.25121381e-02f, 6.45944923e-02f,
  -6.26512542e-02f, -9.07281339e-02f, -6.78680316e-02f, -7.15779439e-02f, 6.89315870e-02f, 1.45651866e-02f, -1.00317225e-02f, 4.90542762e-02f, 6.62874281e-02f, 1.48556922e-02f,
  1.01056688e-01f, -1.35162044e-02f, 9.14232358e-02f, -5.55343814e-02f, 1.07422225e-01f, -2.97614299e-02f, -2.95262551e-03f, 9.55188647e-02f, -3.46432142e-02f, -3.33237904e-03f,
  -8.19960609e-02f, -1.39095793e-02f, 5.93099520e-02f, 2.35861763e-02f, -6.47562742e-02f, 7.22032189e-02f, -3.70464250e-02f, -1.11372955e-03f, 8.40859488e-02f, 5.88920712e-02f,
  -2.65674144e-02f, -4.28344402e-03f, -4.69903052e-02f, -2.08810549e-02f, 3.69565003e-02f, -2.86315046e-02f, -1.53647838e-02f, 9.82199516e-03f, -4.34670188e-02f, -3.20749655e-02f,
  3.70596796e-01f, -6.43727109e-02f, 1.69228062e-01f, 2.13803932e-01f, 9.74606946e-02f, 1.39902413e-01f, 2.59857923e-02f, 8.19835514e-02f, -3.68345492e-02f, 3.31365201e-03f,
  -2.67006718e-02f, 3.92840467e-02f, 1.41727448e-01f, -2.59825587e-02f, -5.87686570e-03f, 4.37629633e-02f, 5.91287091e-02f, 1.33877560e-01f, 1.27669930e-01f, -1.08496724e-02f,
  -1.08473547e-01f, -1.16025463e-01f, -8.80306959e-02f, -3.79991904e-02f, -2.00637326e-01f, 7.46506602e-02f, -9.68153030e-02f, -2.55501829e-02f, -7.91940838e-02f, -1.72949120e-01f,
  5.17189950e-02f, 5.02164736e-02f, 1.18715279e-01f, -1.97508335e-02f, -1.35608353e-02f, 6.58915192e-02f, -2.71144006e-02f, -8.78377557e-02f, 2.49383021e-02f, -4.24781144e-02f,
  -3.63589749e-02f, -8.37634504e-02f, -3.12469248e-02f, -6.82529062e-02f, 4.29476984e-02f, 5.07014282e-02f, -4.72135395e-02f, 5.86204566e-02f, 2.27538124e-02f, 8.04561377e-03f,
  -1.34621263e-02f, 8.86481926e-02f, 1.23578317e-01f, 9.30557996e-02f, 1.50727361e-01f, 1.65771261e-01f, 2.24850234e-02f, 6.67466596e-02f, 2.90639251e-02f, -1.03298330e-03f,
  -4.11755666e-02f, -6.92578964e-03f, 1.72572844e-02f, -1.97932683e-02f, 6.51137605e-02f, -2.56627947e-02f, 3.40566039e-02f, -4.89759520e-02f, 7.61972554e-03f, -8.83768220e-03f,
  4.08918224e-02f, 7.24108145e-02f, 9.91920102e-03f, 3.25574949e-02f, -2.68352276e-04f, 5.52880904e-03f, -3.55278216e-02f, -8.73240307e-02f, -2.68056951e-02f, 7.74807036e-02f,
  7.03710644e-03f, 1.42164677e-02f, -2.06546243e-02f, -8.70522410e-02f, -9.08826105e-03f, -1.21925548e-02f, 1.91568173e-02f, 4.04617116e-02f, -6.73767850e-02f, 3.69744785e-02f,
  -8.41237232e-02f, 2.59636402e-01f, 7.32600167e-02f, -9.75272804e-02f, -9.37378109e-02f, -4.05810960e-03f, -2.30643563e-02f, -7.32981041e-02f, -1.16496161e-01f, 2.87238602e-02f,
  -8.15599784e-02f, -7.74471834e-02f, -6.79815710e-02f, 2.64004301e-02f, 5.46570495e-02f, 4.66877557e-02f, -1.06879428e-01f, 4.77119274e-02f, -8.17510858e-02f, -5.87599166e-02f,
  -1.12412542e-01f, 1.30912498e-01f, 4.91578318e-02f, 1.35603786e-01f, 6.12407401e-02f, 1.38459444e-01f, -1.53118316e-02f, 5.99032454e-02f, 1.67916983e-01f, 1.96187058e-03f,
  -1.17191784e-01f, 7.86809698e-02f, -1.47722214e-02f, 1.30335942e-01f, 4.27500382e-02f, 9.11815539e-02f, 5.10631464e-02f, 1.19592071e-01f, 8.81208628e-02f, 6.27990738e-02f,
  -7.93989152e-02f, 5.60736880e-02f, 6.72831237e-02f, -4.96784970e-02f, 1.11781366e-01f, 1.61379784e-01f, 2.31698573e-01f, 5.41813858e-02f, 2.73065865e-02f, 3.72331925e-02f,
  1.02606528e-01f, 2.29823459e-02f, -3.97246405e-02f, -7.74818733e-02f, 1.25161661e-02f, 3.08414437e-02f, -1.57189183e-02f, -6.23848103e-03f, 5.32852188e-02f, 7.97566846e-02f,
  -1.43491700e-01f, -3.43651958e-02f, 8.29250142e-02f, -1.02676384e-01f, -6.89794049e-02f, -8.87675136e-02f, -1.10919595e-01f, -1.00719243e-01f, 3.46379168e-02f, -2.72800643e-02f,
  -1.09770847e-02f, -2.31067277e-02f, 5.74752279e-02f, 5.40191047e-02f, 1.08517855e-02f, -4.75947410e-02f, -1.03111431e-01f, 2.93389824e-03f, 1.19104095e-01f, -5.30644972e-03f,
  4.81932908e-02f, -1.32642193e-02f, -7.81544223e-02f, 1.18090473e-01f, -9.05740075e-03f, 1.02048047e-01f, -5.09501584e-02f, 8.82161185e-02f, 3.23613931e-04f, -6.52224664e-03f,
  -8.99975467e-03f, -1.31079536e-02f, 8.18953365e-02f, 1.04807355e-01f, -6.98449314e-02f, -4.51635476e-03f, 9.35288444e-02f, -5.20675778e-02f, 6.55607730e-02f, 4.67519425e-02f,
  -4.88019474e-02f, -1.55447917e-02f, 9.20356140e-02f, 9.22785029e-02f, 8.75110775e-02f, 9.80526209e-02f, -3.25002111e-02f, -8.51897430e-03f, -7.24573433e-02f, 1.15325013e-02f,
  -2.64834636e-03f, 2.12855283e-02f, -1.10552900e-01f, -3.12603191e-02f, -2.42365059e-02f, 2.01477408e-02f, 3.48382071e-02f, -8.83753523e-02f, -2.88886111e-02f, 9.02132411e-03f,
  -6.10941090e-02f, -3.82872261e-02f, -6.74500316e-02f, 1.08070508e-01f, 7.38954470e-02f, -1.84988137e-04f, 6.27043517e-03f, 3.65208834e-02f, -6.41615465e-02f, 9.97171104e-02f,
  -8.33429247e-02f, 3.89429554e-02f, -7.27960542e-02f, 2.74733081e-02f, -5.00536747e-02f, 2.52844840e-02f, -9.06872526e-02f, -1.01231951e-02f, 1.17703229e-01f, 7.79569447e-02f,
  -3.64610367e-02f, 4.09386083e-02f, -9.32586193e-03f, 8.18241462e-02f, 8.01240187e-03f, 2.75249630e-02f, -9.22033563e-02f, 3.44285816e-02f, -1.02199867e-01f, 2.75498927e-02f,
  -1.30059227e-01f, 6.55880272e-02f, 7.00433403e-02f, -1.08944744e-01f, 6.05048388e-02f, -2.96727046e-02f, 4.11177501e-02f, -1.06149912e-01f, -1.27363294e-01f, 2.72404421e-02f,
  -6.06675260e-02f, 4.39219326e-02f, -5.88967390e-02f, 4.55868877e-02f, -7.88431987e-02f, -7.90862180e-03f, 4.57115248e-02f, -2.43048873e-02f, -4.83743586e-02f, 8.80430639e-02f,
  6.19395915e-03f, -7.80902291e-03f, -3.27976607e-02f, -4.57183011e-02f, 5.01651354e-02f, 6.18232787e-02f, -2.06209440e-02f, 5.74535280e-02f, -3.42494920e-02f, 7.23267049e-02f,
  1.23457618e-01f, -2.69038770e-02f, 1.15532000e-02f, 7.40362005e-03f, -6.19180314e-02f, -1.24241030e-02f, -1.83870774e-02f, -8.39367732e-02f, -3.81954797e-02f, 4.51097153e-02f,
  -5.91275133e-02f, -6.72894670e-03f, 6.99463040e-02f, -7.54906163e-02f, -6.53040409e-02f, 6.06265403e-02f, -4.26470786e-02f, -6.59524724e-02f, 5.37870172e-03f, 7.41116777e-02f,
  8.86036083e-02f, 5.43854535e-02f, -1.34663852e-02f, 1.00197336e-02f, 6.86544366e-03f, -6.34039789e-02f, 6.51703924e-02f, 1.89074166e-02f, 5.08141369e-02f, 9.88114774e-02f,
  -7.53697902e-02f, 3.47907953e-02f, 3.25860339e-03f, 4.20198664e-02f, -3.45104001e-02f, 1.51909459e-02f, -6.30677938e-02f, 4.66511734e-02f, 5.58153652e-02f, 1.90138873e-02f,
  -8.47575255e-03f, 2.49289237e-02f, 2.10357457e-02f, 4.15566526e-02f, 3.75813916e-02f, 5.53807989e-02f, 4.85809445e-02f, -5.73732257e-02f, 6.66147098e-02f, -1.60790663e-02f,
  6.47850186e-02f, -5.19834831e-02f, -6.51558414e-02f, 4.53953296e-02f, 5.16314246e-02f, -9.69004817e-03f, -1.06580801e-01f, 2.27019209e-02f, -4.24986742e-02f, 3.30808684e-02f,
  6.35214746e-02f, -1.54690117e-01f, -7.20058158e-02f, 4.87856045e-02f, -7.74843097e-02f, 1.35976244e-02f, 1.57233067e-02f, 7.12497346e-03f, 9.30920020e-02f, 9.58139226e-02f,
  1.61986761e-02f, 7.20580518e-02f, -6.79821372e-02f, 8.89466405e-02f, 8.58349074e-03f, -6.37954399e-02f, -8.41018464e-03f, 5.28316386e-02f, -2.48119049e-02f, 1.11153886e-01f,
  6.57564774e-02f, 9.15790647e-02f, 6.54441863e-02f, 6.06909618e-02f, 9.83465184e-03f, -2.46664844e-02f, -3.42483781e-02f, 6.08968921e-02f, 2.40420029e-02f, 5.25166541e-02f,
  -1.43790934e-02f, 8.41686353e-02f, -3.07998806e-02f, 1.09281130e-01f, 6.79275393e-02f, -6.75977841e-02f, 1.62811335e-02f, -4.80994396e-02f, 1.23304255e-01f, 4.34858203e-02f,
  -3.29991765e-02f, 9.03872475e-02f, 1.17259651e-01f, 1.69299301e-02f, 9.24669877e-02f, 1.28464296e-01f, 1.11641027e-01f, 3.94607894e-03f, 4.16611694e-02f, 8.81241262e-02f,
  1.39610484e-01f, 2.58735102e-02f, -1.00382291e-01f, 9.56597179e-03f, 8.55368599e-02f, -1.31555162e-02f, -2.79411324e-03f, 5.21758534e-02f, 3.45719382e-02f, 1.90385446e-01f,
  8.95786285e-03f, -6.78011999e-02f, -9.36842524e-03f, 3.96261439e-02f, -8.70698467e-02f, -2.21898016e-02f, 4.73431200e-02f, -1.11217432e-01f, -2.45833769e-02f, -7.79590160e-02f,
  9.57255252e-03f, -6.45401925e-02f, -1.13644181e-02f, -5.51419817e-02f, -2.58444585e-02f, 3.58883813e-02f, -1.07813954e-01f, -4.49699461e-02f, -2.91852709e-02f, -8.98149908e-02f,
  -1.65206864e-02f, -3.89683098e-02f, 2.34012641e-02f, -9.26355273e-02f, -9.65595767e-02f, -1.42340214e-04f, -9.95048881e-02f, 1.25189992e-02f, -2.75935847e-02f, -5.82975661e-03f,
  -2.06483863e-02f, 7.11664781e-02f, -7.33731389e-02f, -5.47335111e-02f, 9.88597348e-02f, -4.22922932e-02f, 3.85118760e-02f, 6.61760047e-02f, -8.38384777e-03f, -2.13501807e-02f,
  -1.12908650e-02f, 4.31700088e-02f, 6.14782125e-02f, -6.30072355e-02f, -2.45049801e-02f, -1.20948041e-02f, -4.23715338e-02f, 1.83905195e-02f, -2.56384835e-02f, 3.19510810e-02f,
  3.18148397e-02f, -2.94377524e-02f, -9.87076312e-02f, 8.70080069e-02f, -2.38907598e-02f, -1.86874960e-02f, -7.88832232e-02f, 2.00196467e-02f, -4.88166325e-02f, -4.44980012e-03f,
  -1.27332538e-01f, -1.80567518e-01f, 7.26936907e-02f, 1.09224498e-01f, -8.15692768e-02f, -6.36682734e-02f, 4.37363833e-02f, -1.05034493e-01f, -1.68759900e-03f, -1.72721446e-02f,
  4.44155280e-03f, 6.01083376e-02f, 2.95474306e-02f, -1.19283751e-01f, 6.48481175e-02f, -2.62938756e-02f, -2.93924101e-02f, 4.94749099e-02f, -2.89707594e-02f, -1.64239872e-02f,
  -1.88311283e-02f, -1.09105669e-01f, 1.59421097e-02f, -5.96189685e-02f, -7.93197751e-02f, -8.50220770e-02f, 2.19056872e-03f, -1.35890424e-01f, -7.70072453e-03f, -1.22703373e-01f,
  2.67936468e-01f, -1.31572895e-02f, -4.37699407e-01f, 4.67340322e-03f, -1.56932980e-01f, -1.75011426e-01f, -5.28489426e-02f, 4.38417420e-02f, 1.90140605e-02f, -4.98543642e-02f,
  -5.46484590e-02f, 5.95667660e-02f, 1.03839181e-01f, 7.17693195e-02f, -3.05125732e-02f, -1.80223972e-01f, -1.67963743e-01f, -1.45473048e-01f, -2.63552759e-02f, -4.53168526e-02f,
  -3.66268679e-02f, 4.00077831e-03f, 2.30651777e-02f, 8.28331411e-02f, -1.88533500e-01f, -9.07685012e-02f, -2.86609322e-01f, -1.17711700e-01f, -7.01804385e-02f, -2.07270533e-01f,
  -3.61464083e-01f, 9.89457369e-02f, -1.16781676e-02f, 5.51802032e-02f, -1.21636584e-01f, -2.46499721e-02f, 2.65630838e-02f, -8.38099122e-02f, -1.00109857e-02f, -4.41998541e-02f,
  7.49509037e-02f, 1.11145832e-01f, 1.24859121e-02f, 3.74011770e-02f, -2.33195238e-02f, 3.33411153e-03f, -3.74996336e-03f, 4.43304665e-02f, -1.37103826e-01f, -1.38695342e-02f,
  3.76703702e-02f, -4.36777771e-02f, -5.05144745e-02f, -8.34300518e-02f, -8.26904178e-02f, 4.67793308e-02f, -9.42071080e-02f, -1.45748809e-01f, -7.18742162e-02f, 6.40058592e-02f,
  -1.81107223e-02f, -6.05264790e-02f, -1.17190136e-02f, -9.38682165e-03f, 9.20956135e-02f, 3.28980312e-02f, 2.16842704e-02f, 5.40117286e-02f, -1.48274219e-02f, 3.78791839e-02f,
  1.17085157e-02f, -1.65380854e-02f, 5.16110249e-02f, 4.30435017e-02f, 3.15124094e-02f, -3.97318341e-02f, 2.13582236e-02f, 3.28140110e-02f, 5.46569265e-02f, 8.66392851e-02f,
  -6.87834844e-02f, 1.79737061e-03f, 1.54301235e-02f, -6.15486354e-02f, -9.28644463e-02f, 7.07840640e-03f, 1.93910189e-02f, -2.69008838e-02f, 1.63115114e-02f, -8.67725760e-02f,
  1.37557283e-01f, -2.85453559e-03f, 5.27915694e-02f, 1.51184380e-01f, -6.88959472e-03f, 1.27020329e-02f, 3.03916857e-02f, 1.37973595e-02f, 1.56321079e-02f, 2.18378976e-02f,
  -2.62003075e-02f, -4.18539792e-02f, -4.29931171e-02f, 7.86845339e-04f, -3.05918120e-02f, -4.65554595e-02f, 7.08442181e-02f, 1.65434740e-02f, -8.01088139e-02f, -1.24761082e-01f,
  -6.58261217e-03f, 1.57292992e-01f, 2.27426931e-01f, 1.18595362e-01f, 4.00036834e-02f, 8.23591948e-02f, 3.66452150e-02f, 4.84569110e-02f, 1.28009111e-01f, -1.14411032e-02f,
  7.41486810e-03f, -1.63087633e-03f, -2.66084403e-01f, 4.45422065e-03f, -8.64537135e-02f, -8.65540504e-02f, -1.19819395e-01f, -2.04902645e-02f, -3.21441479e-02f, -1.66322738e-01f,
  -7.58049730e-03f, 8.49707723e-02f, -5.01094125e-02f, 4.70144004e-02f, -9.75514799e-02f, -4.79506068e-02f, -1.47071809e-01f, -1.23306774e-01f, -1.21763840e-01f, -8.96922424e-02f,
  -6.78612590e-02f, -4.54111435e-02f, -5.19301509e-03f, 1.09727345e-02f, -1.29912123e-01f, 9.86175984e-03f, -1.66564301e-01f, -1.77740715e-02f, -8.38170275e-02f, -1.76501825e-01f,
  -5.00372760e-02f, -6.80293068e-02f, -1.24149419e-01f, -1.05174549e-01f, -2.73474306e-03f, 5.05513437e-02f, -1.10057972e-01f, 5.77288046e-02f, 4.23050625e-03f, -9.15660784e-02f,
  -4.38773707e-02f, 6.94142431e-02f, -6.22873530e-02f, -2.80263256e-02f, 4.86177951e-02f, -1.06324628e-01f, 3.26151811e-02f, -1.94119457e-02f, -8.50817487e-02f, 3.89161296e-02f,
  -9.00873765e-02f, -1.14626870e-01f, -6.69258386e-02f, 6.64209295e-03f, -5.00766980e-03f, 5.84669597e-03f, -5.61846746e-03f, -7.12779388e-02f, -7.45004267e-02f, -7.37174675e-02f,
  3.55344713e-02f, 2.83351243e-02f, -1.46785006e-02f, 7.87210241e-02f, -9.35921445e-03f, 3.30235772e-02f, 2.21024118e-02f, 9.28319320e-02f, -3.59409787e-02f, -7.76775703e-02f,
  -2.43042991e-03f, -6.38950616e-02f, -6.74420521e-02f, -4.01799046e-02f, -7.75568634e-02f, 2.65469160e-02f, 5.78989042e-03f, 7.31857046e-02f, 6.12206906e-02f, -5.51171675e-02f,
  8.11233893e-02f, 9.78880972e-02f, -3.25627364e-02f, 9.33198407e-02f, 9.72624496e-03f, 9.48180631e-03f, 1.04638701e-02f, 6.48151040e-02f, 9.41614956e-02f, 6.39341548e-02f,
  1.32988304e-01f, -1.08778775e-01f, -1.36762992e-01f, 1.85223259e-02f, -5.48728509e-04f, -1.20518431e-01f, -4.72317785e-02f, 5.16556017e-02f, 2.40835901e-02f, -7.38760456e-02f,
  1.11683659e-01f, 4.41696569e-02f, -2.15945747e-02f, -7.34248906e-02f, -5.70798330e-02f, 6.90533370e-02f, -7.60243610e-02f, -9.72902868e-03f, -2.32374836e-02f, -9.04828031e-03f,
  6.38426468e-02f, 2.62156352e-02f, 5.71209230e-02f, 6.97240531e-02f, 4.39652279e-02f, -2.82347351e-02f, -5.47133759e-02f, 7.28899539e-02f, 8.73826444e-02f, 5.70280962e-02f,
  -6.62539080e-02f, -1.74103417e-02f, 1.71893358e-01f, -1.60021260e-01f, 9.92018171e-03f, 1.17851168e-01f, 1.20660745e-01f, -3.96164134e-02f, -5.60325012e-03f, -3.30031253e-02f,
  1.08143277e-01f, -1.13936521e-01f, -6.82412088e-02f, -3.24460790e-02f, 3.51031194e-03f, -3.24040800e-02f, -5.84581420e-02f, -1.06287383e-01f, -8.68658796e-02f, -6.57578185e-02f,
  -6.16344027e-02f, -3.25865634e-02f, -5.70467301e-02f, 3.96466739e-02f, -7.01357052e-02f, -1.33443430e-01f, 6.17355779e-02f, -5.07167494e-03f, -7.55291134e-02f, -1.00294314e-01f,
  -2.07795966e-02f, 8.81641638e-03f, 3.62254120e-02f, 4.59090658e-02f, -1.45523436e-02f, 5.29385637e-03f, -4.03043255e-02f, -1.32289075e-03f, 6.05043061e-02f, -8.28973576e-03f,
  4.34534959e-02f, 4.38493490e-02f, -3.45109254e-02f, -3.05590928e-02f, 2.36133728e-02f, -4.13084142e-02f, 1.16829923e-03f, -1.79686937e-02f, 3.37817669e-02f, -3.08165886e-02f,
  3.82300727e-02f, 3.00056557e-03f, 3.87179432e-03f, -1.28093734e-02f, -3.59101072e-02f, 1.56596620e-02f, -6.06165193e-02f, -9.51915011e-02f, 1.86401997e-02f, -1.28402084e-01f,
  -6.53747097e-02f, 2.20403858e-02f, 4.65064086e-02f, -5.15423790e-02f, -1.25962701e-02f, 3.71966064e-02f, 1.78387593e-02f, 8.30547363e-02f, 4.04158458e-02f, -4.58101965e-02f,
  -6.15157932e-03f, -7.24230409e-02f, -1.64670181e-02f, -3.81124988e-02f, 6.12593107e-02f, -4.07527015e-03f, -8.49527717e-02f, -4.50047664e-02f, -8.46049711e-02f, -3.11603565e-02f,
  -1.40868369e-02f, 5.13456948e-02f, 6.55966299e-03f, -2.50058249e-02f, -1.79894920e-02f, 4.93189469e-02f, -5.59256412e-02f, -1.41657786e-02f, 3.41936611e-02f, -5.99089786e-02f,
  -1.57684639e-01f, 1.35801628e-01f, 3.99107896e-02f, -1.07148230e-01f, 1.37495669e-02f, 2.28631706e-03f, -1.13430545e-02f, -1.02369534e-02f, -5.25578707e-02f, 1.22958124e-02f,
  5.36392368e-02f, 1.03187542e-02f, -9.00798589e-02f, 2.80217025e-02f, -1.40784150e-02f, -1.36412103e-02f, -2.70667002e-02f, -1.15527682e-01f, -7.34447241e-02f, -2.23477650e-02f,
  7.25511182e-03f, -4.42982651e-02f, -8.84748548e-02f, -5.87936975e-02f, 5.89781860e-03f, -5.65418229e-02f, -8.25601667e-02f, -1.34260014e-01f, -4.20822352e-02f, -2.20277712e-01f,
  -8.66711959e-02f, 1.22389402e-02f, -2.22915169e-02f, -5.28960600e-02f, 2.48647053e-02f, 1.43317981e-02f, -2.65199561e-02f, -5.25274836e-02f, -1.48215964e-02f, 4.43684533e-02f,
  -8.57315585e-03f, -3.86722647e-02f, 7.19196051e-02f, -7.73852095e-02f, 4.87535670e-02f, 2.67053023e-03f, -1.25686452e-01f, -2.62167323e-02f, -5.07282279e-03f, 9.16820690e-02f,
  -7.50702173e-02f, -8.41847286e-02f, -1.29903127e-02f, -1.64051596e-02f, -7.90219940e-03f, 8.34350958e-02f, -2.37109326e-02f, 4.74151075e-02f, 5.10418303e-02f, -6.57805949e-02f,
  -8.05567726e-02f, 3.42097059e-02f, 2.71808431e-02f, -8.33844990e-02f, 6.47092015e-02f, -7.59355426e-02f, 1.01164378e-01f, 6.04173243e-02f, 1.49769122e-02f, 6.24302886e-02f,
  -2.72680391e-02f, 6.95140287e-02f, -1.85217727e-02f, -4.05053375e-03f, 3.81840346e-03f, 8.48533288e-02f, 1.00653924e-01f, -2.32675932e-02f, 5.36705218e-02f, -2.25575138e-02f,
  9.34759341e-03f, -6.05549924e-02f, 9.54156816e-02f, 5.32872491e-02f, 9.48374718e-02f, 6.04946129e-02f, 1.14365064e-01f, 5.34724481e-02f, 2.29714103e-02f, 2.73618586e-02f,
  7.92480037e-02f, 1.27864525e-01f, -1.82560281e-04f, 5.09960111e-03f, 9.02668163e-02f, 2.84832828e-02f, 9.77745429e-02f, -5.67047186e-02f, -3.07007581e-02f, 9.65277106e-03f,
  5.31202443e-02f, -6.01253938e-03f, -3.58992815e-02f, -4.45225602e-03f, 6.61277696e-02f, 3.91607173e-02f, -1.81385465e-02f, 7.44255856e-02f, -7.12901652e-02f, -2.78570894e-02f,
  -3.90449464e-02f, 5.17044626e-02f, -6.06897026e-02f, -2.00297143e-02f, -5.80224209e-02f, -1.37846097e-02f, 2.41147093e-02f, -7.34222308e-02f, -8.32715631e-02f, -6.11476451e-02f,
  8.34981650e-02f, -1.32324234e-01f, 4.36181352e-02f, -3.70632522e-02f, 6.50812685e-02f, 6.24789782e-02f, 4.60624285e-02f, 4.18597087e-03f, -6.03227690e-02f, 1.00199290e-01f,
  8.51967111e-02f, 8.04333016e-02f, -8.90633613e-02f, 9.02171806e-02f, 3.85280252e-02f, 7.82277808e-02f, 4.25306521e-02f, 8.03045854e-02f, 7.90091306e-02f, 8.83774683e-02f,
  5.44913337e-02f, 6.07999526e-02f, 6.01338334e-02f, -1.27258832e-02f, 3.05776764e-02f, -9.63744149e-02f, 7.69139230e-02f, -3.24211605e-02f, -2.70747822e-02f, -2.45617162e-02f,
  -6.15983456e-02f, 2.82552876e-02f, -8.92329123e-03f, -9.32542328e-03f, -2.45893672e-02f, 3.75261828e-02f, 1.89489238e-02f, -8.97180066e-02f, -2.19908748e-02f, 1.65996794e-02f,
  1.45098433e-01f, 4.09178771e-02f, -6.27964437e-02f, -7.90449008e-02f, -1.42715886e-01f, -5.55234849e-02f, -7.63668865e-02f, -1.16424248e-01f, -1.28821224e-01f, 2.01733746e-02f,
  -8.61226842e-02f, -1.10574961e-01f, -1.36379629e-01f, -1.16264246e-01f, -6.14021628e-05f, -3.03548053e-02f, -8.82656872e-02f, 3.84937748e-02f, 9.61568207e-03f, -1.12243590e-03f,
  -2.89125983e-02f, 1.50599098e-02f, -3.26380804e-02f, -1.53396120e-02f, 3.56113724e-02f, 4.06586640e-02f, -3.77075188e-02f, -3.28876749e-02f, -5.81911318e-02f, 2.80721206e-02f,
  7.50766397e-02f, 1.05387852e-01f, 1.32358400e-02f, 3.44515294e-02f, 7.33581111e-02f, -2.90599279e-02f, 3.37609323e-03f, -2.88410801e-02f, -5.30044585e-02f, -2.63518021e-02f,
  -4.06501144e-02f, -4.86819120e-03f, -1.04781277e-01f, 1.67245616e-03f, 6.68282202e-03f, 2.75542052e-03f, 7.13636950e-02f, -1.69786289e-02f, 3.54380570e-02f, -1.16315059e-01f,
  3.36645022e-02f, 3.27603258e-02f, 4.76709679e-02f, 5.79652861e-02f, 3.74050811e-02f, 9.08246788e-04f, -7.10839182e-02f, 9.01835784e-02f, 2.07073521e-02f, 2.41203215e-02f,
  -1.90274566e-02f, 3.38859260e-02f, -2.96419468e-02f, -1.20765597e-01f, 4.81578261e-02f, -3.92766595e-02f, -7.56758898e-02f, -1.16542205e-01f, -1.09266408e-01f, 6.23548403e-03f,
  -7.26901218e-02f, 5.18531874e-02f, -6.69273501e-03f, 1.23670027e-02f, -4.37999330e-02f, -1.15087032e-01f, -8.86198506e-02f, -5.42893745e-02f, -6.98729232e-02f, -1.12492694e-02f,
  -1.30221486e-01f, 2.36089863e-02f, 3.80304381e-02f, 1.11127486e-02f, 6.75869361e-02f, -2.28904597e-02f, 7.77227357e-02f, -7.14309663e-02f, 1.09592244e-01f, 6.28987979e-03f,
  3.83261777e-02f, -2.51055732e-02f, 3.86961997e-02f, -6.55769780e-02f, 4.83448356e-02f, -8.38854164e-02f, -2.60956236e-03f, 2.76751220e-02f, -2.33348738e-02f, -7.39999712e-02f,
  1.72650069e-02f, -7.39164725e-02f, -6.21064939e-02f, -1.33088175e-02f, -6.30446747e-02f, -1.20941803e-01f, -9.94916707e-02f, -1.39183681e-02f, -1.76962972e-01f, -8.61647278e-02f,
  4.73210961e-02f, -1.03960544e-01f, 9.65096951e-02f, 9.85225663e-02f, -7.94370659e-03f, -1.05968349e-01f, -1.50016353e-01f, -4.30150889e-03f, -2.14358289e-02f, -4.90020448e-03f,
  9.28752944e-02f, 1.16755530e-01f, 1.02038912e-01f, 5.56230173e-02f, -3.25400457e-02f, -1.12887137e-02f, 7.75787756e-02f, 1.59701899e-01f, 7.88510684e-03f, -2.32871901e-03f,
  -7.37026557e-02f, 8.04365706e-03f, 1.07293189e-01f, 5.73025979e-02f, 3.62261161e-02f, -4.48890403e-02f, -1.97963659e-02f, 7.94518963e-02f, 1.99803449e-02f, -3.45066339e-02f,
  9.07795224e-03f, 1.51123004e-02f, 1.26683652e-01f, 5.07176574e-03f, 7.76704550e-02f, -5.03480621e-02f, -3.22072878e-02f, -4.51936871e-02f, -4.98963371e-02f, -4.93297093e-02f,
  5.25412988e-03f, 9.40466225e-02f, 6.69737011e-02f, -3.75877693e-02f, -5.31629547e-02f, -6.08469620e-02f, 9.04011354e-03f, 4.24666256e-02f, 6.10613450e-02f, 2.46147923e-02f,
  -1.28347706e-02f, 4.76047173e-02f, 5.63524403e-02f, -9.08684283e-02f, -1.81637183e-02f, 7.76787028e-02f, 4.47820090e-02f, 3.25739048e-02f, 4.98294905e-02f, 4.56948318e-02f,
  -8.15399885e-02f, 4.36891653e-02f, -6.66625574e-02f, 8.55244696e-03f, 4.82127443e-03f, -3.91205959e-02f, -5.49472570e-02f, 6.58753980e-03f, -4.43090387e-02f, -1.02327034e-01f,
  -6.12599626e-02f, -5.02383374e-02f, 5.13936542e-02f, -6.66190237e-02f, 2.49166023e-02f, 1.86809618e-02f, -2.29946803e-02f, -5.08263595e-02f, 8.29231292e-02f, 4.54451218e-02f,
  -3.92064489e-02f, 6.24782778e-03f, -3.47355008e-02f, 4.14106958e-02f, -1.25921238e-02f, 4.10102345e-02f, 8.52364823e-02f, -6.64482638e-02f, 8.22316855e-03f, 1.84819810e-02f,
  -1.19052336e-01f, 9.52499956e-02f, 1.11196764e-01f, 1.30029052e-01f, 9.27986130e-02f, 5.18811904e-02f, 2.94545591e-02f, 1.37339979e-02f, -5.14868572e-02f, 7.59577658e-03f,
  6.48822710e-02f, 5.58772348e-02f, -2.97850780e-02f, 5.49093559e-02f, -1.46700302e-02f, 7.12602064e-02f, 1.21126235e-01f, 3.88248228e-02f, 9.75379050e-02f, 6.85144663e-02f,
  -5.83181828e-02f, -7.40497410e-02f, 2.53145886e-03f, 5.10386005e-02f, 4.67782356e-02f, 6.88069016e-02f, -8.90809074e-02f, 1.49903502e-02f, -2.78989356e-02f, 1.13184704e-02f,
  3.46125364e-01f, -5.91918491e-02f, -1.56132206e-01f, -1.95359886e-02f, -1.52931407e-01f, -1.14872843e-01f, -1.40654802e-01f, -1.48214206e-01f, -7.19483644e-02f, -9.70376581e-02f,
  -1.03939570e-01f, -4.15760232e-03f, 1.24386223e-02f, -4.72861268e-02f, 1.29752636e-01f, -1.51097983e-01f, -9.52880010e-02f, 8.28984007e-02f, 1.54214442e-01f, -1.35518983e-01f,
  -3.41893472e-02f, 6.26338720e-02f, 1.46926418e-01f, 4.41016257e-02f, -1.38336226e-01f, -1.08732052e-01f, -2.91447919e-02f, -1.29147470e-01f, -5.49350260e-03f, -1.15962446e-01f,
  -7.84854665e-02f, 5.26099652e-03f, 5.10460995e-02f, 6.76736534e-02f, 3.49786729e-02f, 9.65698659e-02f, -2.51460001e-02f, 7.90273175e-02f, -2.78619491e-02f, -6.42964840e-02f,
  -1.02003608e-02f, 7.78927132e-02f, 1.28375888e-02f, -4.91996743e-02f, -4.90664169e-02f, 4.87762801e-02f, 4.10220884e-02f, 1.30696790e-02f, 1.24543816e-01f, -3.08678783e-02f,
  -1.13989048e-01f, -1.81790181e-02f, -3.40719562e-05f, -2.10884667e-04f, 7.00433478e-02f, 9.22955722e-02f, -8.76736045e-02f, -8.53753835e-02f, 1.10061675e-01f, -5.68238795e-02f,
  -2.93817408e-02f, 1.87454931e-03f, -5.87911494e-02f, 2.82271318e-02f, -5.76476268e-02f, -3.75228301e-02f, -2.87884343e-02f, 5.15853614e-02f, 1.53397573e-02f, -1.27067594e-02f,
  4.09477502e-02f, 1.36696491e-02f, -9.24148336e-02f, -9.35340021e-03f, -7.32115209e-02f, 5.01629934e-02f, -2.78558917e-02f, 6.34767264e-02f, -5.39121181e-02f, 7.38941655e-02f,
  8.04170296e-02f, 1.18304184e-02f, -8.59934539e-02f, -2.69131400e-02f, 7.09594637e-02f, -1.10767186e-02f, -5.65900579e-02f, 5.59463575e-02f, -2.63623297e-02f, 5.73181175e-02f,
  -2.83425115e-02f, 1.77467749e-01f, -4.70632836e-02f, 3.69522050e-02f, 8.40883628e-02f, -5.24235666e-02f, -1.06494687e-01f, -5.47510479e-03f, -1.41044101e-02f, -8.27050488e-03f,
  -5.32938465e-02f, -7.02425232e-03f, 4.60782088e-02f, 2.50893980e-02f, 7.54968077e-02f, 7.63120055e-02f, 2.93105431e-02f, 5.31924069e-02f, -3.60767841e-02f, 6.83596730e-03f,
  -8.96490440e-02f, 1.12215653e-01f, 1.26673460e-01f, 3.64807732e-02f, 6.39160210e-03f, 1.21071108e-01f, 2.05247551e-02f, 4.84955907e-02f, 9.59765241e-02f, -6.31402805e-02f,
  -1.14955463e-01f, -1.00877583e-01f, -6.05361685e-02f, 3.21383262e-03f, 2.38654297e-02f, 7.51866028e-02f, -1.29095316e-01f, 7.28780925e-02f, 3.79869342e-02f, -6.53515756e-02f,
  -6.36372864e-02f, 9.41575542e-02f, 4.36684489e-02f, 3.64287794e-02f, -3.96852717e-02f, -7.09564018e-04f, 1.29773403e-02f, -3.49808149e-02f, 2.38530580e-02f, -4.27419506e-02f,
  -6.35406226e-02f, -2.62358095e-02f, 1.10734999e-02f, -6.38445914e-02f, -2.34073736e-02f, -2.90523227e-02f, -7.98384920e-02f, 4.17852029e-02f, 5.41337766e-02f, 4.80462419e-04f,
  -7.35841468e-02f, 9.78078321e-02f, 1.76584627e-03f, -5.83794788e-02f, -5.31773865e-02f, -7.11310953e-02f, -5.97481467e-02f, 2.99707036e-02f, -9.09111649e-02f, 2.59285830e-02f,
  2.19038744e-02f, 4.26931232e-02f, -4.17738408e-02f, -1.98745560e-02f, 1.57343242e-02f, -3.90086733e-02f, 1.07753679e-01f, 1.03875808e-01f, -1.67327169e-02f, 7.03844726e-02f,
  8.93975496e-02f, -2.86062900e-02f, -6.01519458e-03f, -6.38658628e-02f, -3.73392855e-03f, 1.12855799e-01f, -6.96002468e-02f, 5.49889840e-02f, 7.74097443e-02f, -5.80671318e-02f,
  5.99319004e-02f, -5.02475649e-02f, -1.59502458e-02f, 1.98809560e-02f, 1.30669866e-02f, -2.80303657e-02f, 3.93576175e-02f, -8.98052901e-02f, 8.71980190e-02f, -5.09686992e-02f,
  -4.72590812e-02f, 2.94904057e-02f, 1.98256299e-02f, 3.53961848e-02f, -4.10457700e-02f, -5.54312058e-02f, -4.08088006e-02f, 5.13795391e-02f, 3.31019089e-02f, 6.33916259e-02f,
  -6.51739091e-02f, -9.02908039e-04f, 8.00609123e-04f, -1.03103686e-02f, -4.88347784e-02f, -1.99569203e-02f, -7.48719648e-02f, 5.60193732e-02f, -1.44062862e-02f, 3.62075008e-02f,
  -5.24256080e-02f, 1.26621395e-01f, 7.58132562e-02f, 3.52190770e-02f, 6.77434579e-02f, 9.11472552e-03f, -3.57468450e-03f, -1.18039735e-02f, -8.20384324e-02f, 7.00516701e-02f,
  7.19862431e-02f, 5.89991771e-02f, -1.47729402e-03f, 1.64544433e-02f, 8.49305615e-02f, -7.54479766e-02f, 8.55387449e-02f, -5.25383428e-02f, -5.94770275e-02f, -6.81959838e-02f,
  -5.31743020e-02f, -7.49152303e-02f, 1.55000202e-02f, -1.42497597e-02f, 7.57267550e-02f, 4.03901860e-02f, -6.68573827e-02f, 5.35991089e-03f, -3.87089653e-03f, 7.07485480e-03f,
  -2.53170222e-01f, -8.76458958e-02f, -3.63400988e-02f, 2.02804767e-02f, 1.47296831e-01f, 1.39642596e-01f, 1.60161912e-01f, 1.00102045e-01f, 1.39862791e-01f, 1.01946309e-01f,
  -6.21164478e-02f, 1.54016577e-02f, -5.64233065e-02f, 6.48488924e-02f, 9.83875543e-02f, 1.41427234e-01f, 5.61361909e-02f, 5.98018095e-02f, 1.29610881e-01f, -2.81583215e-03f,
  1.53469769e-02f, 6.23471178e-02f, -1.70490414e-01f, -1.10389302e-02f, 1.08752318e-01f, 8.42882469e-02f, 4.31910083e-02f, -5.80487177e-02f, -5.54618761e-02f, 7.97283202e-02f,
  1.48827061e-02f, -1.89393952e-01f, 5.89490980e-02f, -1.83001452e-03f, -8.91313329e-02f, -8.88172165e-02f, 2.68632779e-03f, -1.52068451e-01f, -1.04707099e-01f, -5.59883863e-02f,
  -2.38095280e-02f, -9.77960676e-02f, 3.97957340e-02f, -9.44751594e-03f, -8.67520422e-02f, 4.28321660e-02f, -4.76474948e-02f, -5.23989797e-02f, -1.21483356e-01f, -1.42894387e-01f,
  -1.03932612e-01f, -1.22758247e-01f, -7.74432346e-02f, -2.17537135e-02f, 3.30911465e-02f, -4.73363772e-02f, -1.25147521e-01f, -1.27429470e-01f, -2.71711145e-02f, -3.38674337e-02f,
  -3.77166457e-02f, 2.31529735e-02f, 4.67204079e-02f, 7.28151873e-02f, 1.25798687e-01f, 4.29801010e-02f, 5.99509962e-02f, -3.60717513e-02f, -3.23238187e-02f, -5.60235567e-02f,
  8.20214078e-02f, -5.31638563e-02f, -1.46943554e-02f, -3.21451016e-02f, 4.83601913e-02f, -6.54264614e-02f, 9.28629413e-02f, 9.06062275e-02f, 6.14284277e-02f, 2.59163994e-02f,
  -2.83382926e-03f, 9.96420383e-02f, -8.40263292e-02f, 8.87480006e-02f, -2.12989617e-02f, -1.95563138e-02f, 7.77515694e-02f, 7.78825358e-02f, 4.26035300e-02f, -3.06752510e-02f,
  1.27103522e-01f, -9.64587703e-02f, -9.21882875e-03f, -7.41272792e-02f, 4.92480770e-02f, -1.19108986e-02f, -3.48153859e-02f, 9.32036061e-03f, -5.33191822e-02f, -7.10215420e-02f,
  -4.45172330e-03f, -6.86814338e-02f, 1.14955138e-02f, -5.06284535e-02f, 4.59251925e-02f, 6.38286322e-02f, -5.40044382e-02f, 6.37427196e-02f, 5.98520711e-02f, -2.00127512e-02f,
  1.15436725e-02f, 1.23223446e-01f, 1.26793414e-01f, 4.77002449e-02f, -3.66113745e-02f, 1.53271213e-01f, -6.09186711e-03f, -4.68519796e-03f, 3.22716497e-02f, 9.67455655e-02f,
  4.55882810e-02f, 3.22951414e-02f, -1.75920159e-01f, -1.12438880e-01f, -7.18353316e-02f, 3.27416025e-02f, 3.67856361e-02f, 4.05839738e-03f, 1.03470413e-02f, 8.28411132e-02f,
  -1.04179271e-02f, 1.44512221e-01f, 4.47574519e-02f, 6.84103370e-02f, 2.43497919e-02f, -8.89764801e-02f, -1.30434096e-01f, 2.46958621e-03f, 8.54311138e-03f, 1.02243368e-02f,
  -6.38178661e-02f, -5.33438195e-03f, -6.71664327e-02f, 7.01929033e-02f, -4.04434316e-02f, 3.37492526e-02f, 8.15521460e-03f, -1.16943948e-01f, -1.01351731e-01f, -8.12107176e-02f,
  5.60444407e-02f, -1.60107717e-01f, 2.09941305e-02f, -1.35603147e-02f, -4.15487997e-02f, 7.15925843e-02f, 1.17863370e-02f, 2.11820081e-02f, 7.69191161e-02f, -3.07026412e-02f,
  6.04683533e-03f, -1.50681557e-02f, -7.62245283e-02f, -1.86107922e-02f, 6.74224123e-02f, -5.84677719e-02f, 4.16813828e-02f, -5.23067079e-02f, -5.14417887e-02f, -3.68323214e-02f,
  -7.89518431e-02f, -1.04639731e-01f, -2.28927415e-02f, -5.51459044e-02f, 5.45661822e-02f, -1.58489291e-02f, -8.34631100e-02f, -4.97682057e-02f, 5.42551987e-02f, -3.78391035e-02f,
  7.22504556e-02f, -4.95558456e-02f, 4.84008938e-02f, 2.38880962e-02f, 1.40748337e-01f, 3.94520648e-02f, -1.15185156e-02f, 9.14244130e-02f, 8.40191245e-02f, 9.27629769e-02f,
  -9.76368561e-02f, 5.28597794e-02f, -9.22829881e-02f, -1.05049077e-03f, -8.18790570e-02f, -1.25206029e-02f, -6.39297292e-02f, -6.39100596e-02f, -3.54449973e-02f, 5.26171215e-02f,
  -7.30155259e-02f, -8.32398087e-02f, -6.27948344e-02f, -1.19535938e-01f, -5.08537143e-02f, -4.08820696e-02f, 3.28694023e-02f, -4.23355848e-02f, -1.01717561e-01f, 6.78334432e-03f,
  1.17179133e-01f, -5.40646762e-02f, 2.75439247e-02f, 3.83988656e-02f, -9.02775526e-02f, -6.87305778e-02f, 6.51182234e-02f, 7.91504085e-02f, -4.45027053e-02f, 7.27225021e-02f,
  -1.01859018e-01f, 9.38424170e-02f, 1.00785926e-01f, -9.24404711e-02f, 4.72431220e-02f, -2.13806937e-03f, 9.53246951e-02f, 4.45573926e-02f, 4.45991792e-02f, 4.38680686e-03f,
  -6.15667701e-02f, 6.99468851e-02f, 1.30517676e-01f, 3.54886800e-02f, 5.75162545e-02f, 1.41029805e-01f, 7.93762133e-02f, -2.70267706e-02f, 1.25068584e-02f, 9.88007933e-02f,
  -2.06614845e-02f, 2.11703435e-01f, -3.14422995e-02f, -8.51975307e-02f, 9.63339359e-02f, 4.43061069e-03f, 1.63908526e-01f, -4.08962145e-02f, 4.65883221e-03f, 7.00156093e-02f,
  3.46760042e-02f, -1.43994883e-01f, -3.32333930e-02f, -4.70729591e-03f, -8.18801299e-02f, 3.72875370e-02f, -2.51744706e-02f, -7.61667043e-02f, -1.68546721e-01f, -7.93926269e-02f,
  1.12645617e-02f, -6.49870336e-02f, -1.47980377e-01f, -7.29275197e-02f, -7.51130730e-02f, -5.58640622e-02f, 4.46503684e-02f, 2.07346044e-02f, -4.32889499e-02f, -1.20915184e-02f,
  9.02729556e-02f, -1.77818630e-02f, -1.08437240e-01f, 5.74639207e-03f, 3.06378454e-02f, 4.68678996e-02f, 4.13460517e-03f, 1.03180967e-01f, 1.91206802e-02f, 7.65147656e-02f,
  5.36011830e-02f, 8.55010897e-02f, -3.88253033e-02f, -2.82047782e-02f, -4.54257652e-02f, 1.04323681e-02f, -2.19459962e-02f, 6.36844486e-02f, -1.23521639e-02f, 7.57928416e-02f,
  1.73448697e-02f, -5.49506508e-02f, 8.79983529e-02f, -1.79682598e-02f, -3.49642783e-02f, -1.03502534e-01f, 4.87794243e-02f, -7.19572976e-02f, 5.81603646e-02f, -9.46201012e-02f,
  8.21564421e-02f, -4.03017625e-02f, 3.54858227e-02f, -3.41912434e-02f, -7.13508725e-02f, -7.40156174e-02f, 3.99022624e-02f, 4.64362167e-02f, -9.47593972e-02f, 3.99598852e-02f,
  5.61924726e-02f, 6.40612245e-02f, -1.21659813e-02f, 5.07744886e-02f, 1.56937186e-02f, 8.75718221e-02f, 8.06168914e-02f, -2.51695551e-02f, -4.95290905e-02f, 7.45983422e-02f,
  3.16051729e-02f, -2.68493816e-02f, -2.85197422e-02f, 2.84436010e-02f, -1.44946147e-02f, 4.97618429e-02f, 1.40640307e-02f, -5.45447357e-02f, 6.89608753e-02f, 2.42052767e-02f,
  -1.55126572e-01f, 8.44351575e-03f, -6.91840500e-02f, -9.71334428e-03f, -3.05492897e-02f, -4.32193875e-02f, 6.37070835e-02f, 1.15202762e-01f, 5.39502017e-02f, -5.90554774e-02f,
  7.79007748e-02f, 2.04690639e-02f, 5.20705208e-02f, 3.41496542e-02f, -4.71751392e-02f, 3.89663577e-02f, -3.19446549e-02f, 6.27349839e-02f, 3.93538922e-02f, -5.03189340e-02f,
  -6.12673610e-02f, -9.62655768e-02f, -7.95123167e-03f, -4.63483147e-02f, -7.85581470e-02f, -1.21776341e-02f, -9.38857794e-02f, -1.27906203e-02f, -1.10285446e-01f, 3.46566439e-02f,
  -3.18237618e-02f, 1.92245796e-01f, 1.63065847e-02f, 1.03487577e-02f, -1.20699452e-02f, 4.30454537e-02f, 1.42934114e-01f, 8.26773979e-03f, -6.02601208e-02f, -2.53453534e-02f,
  -7.23001733e-03f, -3.27131082e-03f, -5.48763536e-02f, -3.02896388e-02f, 6.01488203e-02f, 3.02394852e-02f, 1.59035623e-01f, 1.45948231e-02f, 4.32159305e-02f, 7.24514052e-02f,
  5.85346147e-02f, 4.29510027e-02f, 1.08048417e-01f, 1.11497805e-01f, 2.86595020e-02f, -4.52299565e-02f, 4.91527170e-02f, 1.45889208e-01f, 9.52040683e-03f, 1.32159367e-01f,
  -5.69369970e-03f, 1.62308395e-01f, -5.07145785e-02f, -5.99076152e-02f, 5.74306287e-02f, -3.34459841e-02f, -7.98260346e-02f, -3.82168554e-02f, -7.26922899e-02f, 2.07586568e-02f,
  -7.55183175e-02f, -3.59821087e-03f, -3.59419882e-02f, 2.65750429e-03f, 1.95940994e-02f, -1.65840071e-02f, 6.71934485e-02f, -3.84668447e-02f, 2.62941830e-02f, -2.88479775e-02f,
  2.32107453e-02f, 5.38825355e-02f, 9.39244106e-02f, 2.72590518e-02f, -6.79743811e-02f, 4.80959564e-02f, -7.40634874e-02f, -8.16903114e-02f, -1.56704430e-02f, -5.99386357e-02f,
  -8.99941847e-02f, 8.46767519e-03f, -8.59415159e-02f, 8.55183080e-02f, 6.21317849e-02f, 5.74398115e-02f, -6.92816302e-02f, -1.01575576e-01f, -8.82686228e-02f, -4.50301468e-02f,
  -2.81807454e-03f, -4.24170569e-02f, 5.92118800e-02f, -1.18138129e-02f, -3.82306650e-02f, -1.63063742e-02f, 5.72729222e-02f, 3.72445374e-03f, -2.44750665e-03f, 1.15476809e-01f,
  1.35466605e-02f, 9.27757565e-03f, -7.75242075e-02f, -7.21868724e-02f, 2.84463968e-02f, 4.40460630e-02f, 1.64796468e-02f, -1.92284714e-02f, -6.72614500e-02f, 3.19536366e-02f,
  3.76665816e-02f, 1.06948189e-01f, 2.89317891e-02f, 9.16433111e-02f, -5.43191768e-02f, 7.07424954e-02f, -5.87444045e-02f, 5.15014492e-02f, 2.85825711e-02f, -6.51956126e-02f,
  1.85623206e-02f, -5.08110933e-02f, 6.09608665e-02f, -1.54351126e-02f, -7.63169723e-04f, 7.46459933e-04f, 3.97571549e-02f, 5.82511090e-02f, -4.53268103e-02f, 7.29945675e-02f,
  -1.54116116e-02f, 5.12388833e-02f, -1.53847346e-02f, 5.90898544e-02f, -4.23614569e-02f, -1.10482775e-01f, -6.03077449e-02f, -5.15132919e-02f, 3.61015797e-02f, -9.82691869e-02f,
  -4.76094335e-02f, -5.19819707e-02f, -5.82950637e-02f, -1.46534026e-01f, 4.67225257e-03f, 6.69793319e-03f, -7.28531107e-02f, 1.62889883e-02f, -1.04916342e-01f, -1.00586526e-01f,
  6.97362721e-02f, 1.97770558e-02f, 7.33696222e-02f, 1.17450215e-01f, 7.24633411e-02f, 1.52619202e-02f, -1.18267991e-01f, -4.57106605e-02f, 1.17870765e-02f, 1.24867819e-01f,
  8.75356272e-02f, -1.05136201e-01f, -5.07390015e-02f, 4.76252362e-02f, -5.80863375e-03f, -3.38787064e-02f, -7.16240332e-02f, -9.97933522e-02f, 4.44846787e-02f, -6.80389330e-02f,
  8.21827799e-02f, -4.85925153e-02f, -2.59928424e-02f, -7.79952928e-02f, -5.39531596e-02f, -1.94888152e-02f, 5.76160364e-02f, -6.20611049e-02f, 4.07227799e-02f, 3.17583978e-02f,
  -2.79350374e-02f, 7.82821998e-02f, 1.24351541e-02f, -4.85480502e-02f, -8.86423439e-02f, -5.22429496e-02f, 5.77369519e-02f, 3.97128835e-02f, -6.51664659e-02f, 5.16936816e-02f,
  -6.81487611e-03f, -7.21643940e-02f, -9.08515882e-04f, 9.02328044e-02f, 6.01916201e-03f, -3.37477438e-02f, 5.30941226e-02f, 4.80640531e-02f, -6.18354119e-02f, -5.69901094e-02f,
  -3.75301279e-02f, -4.65571694e-02f, -6.44279569e-02f, 8.79177172e-03f, -1.46451755e-03f, 4.05548401e-02f, -3.38254571e-02f, 9.48038325e-02f, -2.66478863e-03f, -1.31732980e-02f,
  -1.08154289e-01f, -3.97852585e-02f, -8.31576362e-02f, 4.35955152e-02f, 2.94046439e-02f, -4.19128919e-03f, 4.64276858e-02f, 8.12841430e-02f, -1.22631080e-02f, -7.09837228e-02f,
  -9.44802761e-02f, -7.03681931e-02f, -1.12872660e-01f, 6.54197782e-02f, -7.77327418e-02f, -1.83496494e-02f, 7.22722709e-02f, -8.74212682e-02f, -5.59247658e-02f, -1.04549624e-01f,
  -2.24014129e-02f, 4.75822799e-02f, 5.24665788e-02f, 6.72615841e-02f, 3.91947217e-02f, 3.45136523e-02f, -1.23588657e-02f, 2.71915291e-02f, 1.30278431e-02f, 8.89879316e-02f,
  -6.97166706e-03f, 6.84193000e-02f, -9.73925814e-02f, -1.80091802e-03f, -5.96422292e-02f, -6.80348873e-02f, -1.25875622e-02f, -4.86375242e-02f, -9.47524607e-02f, -3.01220883e-02f,
  -3.80894653e-02f, 5.83535954e-02f, 4.48130779e-02f, -5.75226173e-03f, 9.38910246e-02f, 5.58100380e-02f, 1.00448713e-01f, -9.13050994e-02f, 6.83015138e-02f, -2.04869565e-02f,
  1.77931655e-02f, -5.67437038e-02f, 1.47464052e-01f, 6.76672235e-02f, 6.35090470e-02f, 3.32246982e-02f, 1.26469642e-01f, 4.17143479e-02f, 1.65066496e-02f, 4.09849286e-02f,
  -3.37746404e-02f, 9.69359465e-03f, -9.37979743e-02f, -7.45000690e-02f, 5.28768823e-03f, 7.80533701e-02f, 1.11242877e-02f, -2.18772050e-02f, 7.16337049e-03f, -8.06791410e-02f,
  -7.09992573e-02f, 7.97312558e-02f, -1.32194450e-02f, 3.45661887e-03f, 5.06606922e-02f, 1.04557443e-02f, -6.00119904e-02f, 1.07524052e-01f, -8.74591991e-03f, -9.14598107e-02f,
  -5.35890423e-02f, 9.22358688e-03f, -6.89659864e-02f, -9.15118456e-02f, 1.04536638e-01f, 1.79428719e-02f, -2.13533230e-02f, 8.07761922e-02f, 3.08011249e-02f, -1.60938762e-02f,
  1.52922627e-02f, 6.82471171e-02f, -6.47879243e-02f, -3.82250287e-02f, -9.79139656e-03f, 1.07357249e-01f, 1.05164781e-01f, 5.38403122e-03f, 3.38831469e-02f, 6.70192763e-02f,
  -6.34411024e-03f, 1.03415668e-01f, -2.21832283e-02f, 1.89251155e-02f, 5.49996048e-02f, -3.33860852e-02f, 5.24736531e-02f, -3.97283062e-02f, 1.28666013e-01f, -8.99727270e-02f,
  1.45891020e-02f, -4.99486923e-02f, -5.62007912e-03f, -7.29787424e-02f, 7.88157340e-03f, -7.90701881e-02f, -2.47544851e-02f, 3.14315967e-02f, 2.19057314e-02f, 2.00014170e-02f,
  4.65120189e-02f, 1.20324092e-02f, 1.81967411e-02f, -5.07884771e-02f, -5.77343553e-02f, -2.46836767e-02f, 7.67102465e-02f, 1.12566249e-02f, -4.80537564e-02f, -6.40668646e-02f,
  -1.01591239e-03f, -4.15064171e-02f, -5.17183803e-02f, 3.49025019e-02f, 1.61573999e-02f, 5.83917946e-02f, 8.35282728e-02f, -7.13682026e-02f, -6.68014735e-02f, 1.43808974e-02f,
  2.67107226e-03f, 1.50113329e-01f, -7.16162100e-02f, 4.26371135e-02f, 8.53054821e-02f, 4.36029509e-02f, -6.18964955e-02f, 6.18565232e-02f, -1.25991637e-02f, -7.64849782e-02f,
  8.70377272e-02f, -4.46666293e-02f, -5.64639755e-02f, -4.62235622e-02f, 7.81553239e-02f, -5.07671162e-02f, 1.88399237e-02f, 4.57002968e-02f, -3.82930525e-02f, 6.15876913e-02f,
  -8.80725458e-02f, -2.66013090e-02f, 7.29721412e-02f, -6.23460449e-02f, 6.09604083e-02f, -9.05311033e-02f, 1.40191242e-02f, 1.71390343e-02f, 1.00625113e-01f, 2.87326332e-03f,
  -2.46976539e-01f, -3.23501751e-02f, -1.00318156e-01f, 2.20892113e-02f, 5.27736731e-02f, -4.20008376e-02f, -1.64926082e-01f, -1.32595614e-01f, 7.33693019e-02f, 8.90573487e-03f,
  4.15949263e-02f, 1.36816829e-01f, 1.96434781e-02f, -1.15242958e-01f, -1.33504674e-01f, -7.37331435e-02f, -1.29599702e-02f, -1.41491294e-01f, -5.00768237e-03f, -6.01791441e-02f,
  7.25298375e-02f, 3.44473906e-02f, -7.97899291e-02f, -6.82282075e-02f, 2.72834604e-03f, 4.80687246e-02f, -3.65230143e-02f, 9.06837285e-02f, 1.69230830e-02f, 9.18794945e-02f,
  2.68021878e-02f, -6.80625886e-02f, 5.55535369e-02f, -1.78895108e-02f, 5.38579822e-02f, 2.58014966e-02f, 2.74765454e-02f, 7.23222364e-03f, -4.25042808e-02f, -6.30492996e-03f,
  5.72106894e-03f, 8.82732570e-02f, 1.62590183e-02f, -2.16857065e-02f, -8.60104784e-02f, -1.18718572e-01f, -8.44235569e-02f, -1.64989769e-01f, -1.14147611e-01f, 5.53605668e-02f,
  1.24407716e-01f, 1.29752889e-01f, 1.12380302e-02f, -2.69927327e-02f, -8.63407105e-02f, -6.53662626e-03f, 1.37766795e-02f, -1.24067955e-01f, -1.73041880e-01f, -1.76493362e-01f,
  1.02744788e-01f, 6.79765493e-02f, -1.57223623e-02f, -2.49418709e-02f, 1.53933400e-02f, 2.41666418e-02f, 1.93402935e-02f, -6.16616150e-03f, 1.70362052e-02f, -9.85581130e-02f,
  -7.18159974e-02f, -1.56111382e-02f, 7.34548569e-02f, 1.04097193e-02f, 4.86260746e-03f, -9.01930034e-02f, 3.51073742e-02f, 4.79778791e-05f, -4.95303748e-03f, -6.70643151e-02f,
  3.39758620e-02f, 7.54556432e-02f, -3.98863293e-02f, -2.11044513e-02f, -2.64465436e-02f, -7.42459819e-02f, 5.98137304e-02f, -6.52701780e-02f, 1.29375700e-02f, -1.47886602e-02f,
  -8.78745243e-02f, -6.64559612e-03f, -6.22751825e-02f, -1.18575031e-02f, -4.87081893e-02f, -2.43982188e-02f, 6.42613098e-02f, -1.35904402e-02f, 6.70253336e-02f, -8.00001621e-02f,
  7.26759841e-04f, -7.50939921e-02f, -8.69650319e-02f, 4.84591536e-02f, 9.00971983e-03f, 9.57817305e-03f, -9.73259509e-02f, 1.75335426e-02f, 3.35050598e-02f, -6.75180275e-03f,
  -1.24690570e-01f, -8.46990570e-02f, -1.19017720e-01f, -6.93824440e-02f, 4.10095230e-02f, -7.44422078e-02f, -2.10943609e-01f, -1.00237846e-01f, -2.30958611e-01f, -3.28259706e-01f,
  3.32898468e-01f, -4.66452241e-02f, -7.55349025e-02f, 5.87375695e-03f, -3.17792967e-02f, 6.02774285e-02f, -1.75772831e-02f, -5.80834560e-02f, 2.01870855e-02f, 5.15807867e-02f,
  2.70586088e-02f, 4.49413359e-02f, 5.12496335e-03f, -3.40953586e-03f, 1.07614316e-01f, 1.59399975e-02f, -9.10639539e-02f, 8.37199539e-02f, -3.96751128e-02f, -8.90485570e-02f,
  -7.48772221e-03f, -6.45891801e-02f, 2.55298289e-03f, 1.76516976e-02f, -4.52059396e-02f, -6.19582236e-02f, -3.57692167e-02f, 4.66060303e-02f, -4.87328507e-03f, -7.17895702e-02f,
  -1.19687721e-01f, 1.10418029e-01f, 2.80455165e-02f, 7.17346892e-02f, 4.29853471e-03f, 3.79555523e-02f, 2.91361865e-02f, -4.67115454e-02f, -8.24954826e-03f, 7.27324039e-02f,
  4.72462811e-02f, -3.56420949e-02f, -7.47873336e-02f, 3.81028280e-02f, 2.02887896e-02f, -1.88607536e-02f, 2.41329540e-02f, -4.79341932e-02f, -8.33655894e-02f, -6.76513687e-02f,
  3.93064581e-02f, 7.37488866e-02f, 1.03001341e-01f, -6.09521233e-02f, -5.87369490e-04f, 4.32829820e-02f, -6.40380085e-02f, -5.42292483e-02f, -1.55876428e-02f, -5.53192049e-02f,
  -5.05992174e-02f, 3.77298519e-02f, 1.93077922e-02f, -1.68886445e-02f, 3.14043425e-02f, -4.33622226e-02f, 6.04741462e-02f, 9.75013059e-03f, 4.43985015e-02f, -1.11487769e-02f,
  9.05651320e-03f, 1.21230306e-02f, 7.02061132e-02f, 9.63445827e-02f, 2.35142675e-03f, 2.18998920e-03f, -2.05601882e-02f, -8.44126940e-02f, 1.53382970e-02f, 4.47564721e-02f,
  -6.68826606e-03f, 5.57966456e-02f, -1.59860682e-02f, 1.17110359e-02f, -4.13691066e-02f, -6.84155822e-02f, -7.01697990e-02f, -5.42468913e-02f, -2.17231438e-02f, -1.17445514e-02f,
  1.36195943e-02f, 1.74833462e-02f, 3.46904583e-02f, 2.71390453e-02f, -7.32374266e-02f, 6.10742681e-02f, 1.15397125e-01f, 2.54455470e-02f, -7.05187321e-02f, -5.05842716e-02f,
  6.02135099e-02f, 1.41540393e-02f, 6.74356446e-02f, -1.18940435e-01f, 5.07616475e-02f, -3.43601294e-02f, 7.12149218e-02f, 7.95191675e-02f, 1.34370802e-02f, -2.97806431e-02f,
  -4.07481939e-02f, 1.64638646e-02f, 1.39033809e-01f, 8.41147602e-02f, 6.38950244e-02f, 4.96212579e-02f, -4.01879027e-02f, 1.45561071e-02f, 9.12979022e-02f, 5.14356345e-02f,
  -1.63502805e-02f, 1.49723694e-01f, 1.09483071e-01f, -4.20320965e-02f, 1.58766016e-01f, 1.05686851e-01f, 1.49619937e-01f, -6.42407164e-02f, -5.47144488e-02f, 1.52455270e-01f,
  2.35565647e-01f, -6.92670643e-02f, 1.97464433e-02f, -1.42677337e-01f, -8.15172344e-02f, -6.96790516e-02f, -7.28986040e-02f, -2.29941204e-01f, -1.66475609e-01f, -1.21108681e-01f,
  5.59949018e-02f, -6.30172268e-02f, -9.57228616e-02f, -1.63877726e-01f, -3.14309113e-02f, -7.04104605e-04f, -3.38677019e-02f, 8.99671093e-02f, 8.59229937e-02f, 2.81083137e-02f,
  8.89351442e-02f, 2.18927994e-01f, -8.56529176e-02f, -1.48939192e-02f, 8.04267973e-02f, -1.21287018e-01f, 5.38628548e-03f, 4.38455269e-02f, 4.04638350e-02f, 3.20203751e-02f,
  6.03245422e-02f, 1.05891429e-01f, 6.23779669e-02f, 4.25653607e-02f, -1.02123484e-01f, -3.71380225e-02f, -1.28831431e-01f, -1.26343846e-01f, -8.80987421e-02f, -8.77616480e-02f,
  -2.13799477e-02f, 8.38835239e-02f, 9.52500403e-02f, -1.41461760e-01f, -1.03051133e-01f, -1.07002333e-01f, 1.25285015e-01f, -3.24590802e-02f, -7.58459494e-02f, 1.32500045e-02f,
  -3.40002254e-02f, 4.85132039e-02f, 9.61797312e-02f, 2.90240310e-02f, 6.57194927e-02f, 6.19246289e-02f, -2.59441510e-02f, 1.60906638e-03f, -1.03194326e-01f, -3.72968465e-02f,
  -1.79284271e-02f, -4.95434627e-02f, -7.24264607e-02f, 6.17722385e-02f, -9.19841379e-02f, 5.08219637e-02f, 1.00435689e-03f, -3.98679040e-02f, 3.03333867e-02f, 3.40940058e-02f,
  1.15043176e-02f, -5.39514385e-02f, 6.09809086e-02f, -8.93258080e-02f, 4.36825715e-02f, -5.40875942e-02f, 1.57766556e-03f, 3.57474410e-03f, 5.62096797e-02f, 9.61948261e-02f,
  -9.92542803e-02f, 5.78687154e-02f, -5.29312454e-02f, 6.86373189e-03f, 1.30595550e-01f, -2.43849326e-02f, 4.24376763e-02f, 1.01240790e-02f, 1.05472557e-01f, -1.78331707e-03f,
  -8.62850901e-03f, 2.23052520e-02f, 7.90223628e-02f, -4.62600924e-02f, -4.37638201e-02f, -1.32165074e-01f, -5.14305085e-02f, -1.52511552e-01f, -1.40528172e-01f, 7.02076871e-03f,
  -3.62790637e-02f, -1.76416412e-01f, -1.88852876e-01f, -1.43394858e-01f, -1.02313854e-01f, -7.93402568e-02f, -1.17931813e-01f, -4.08906341e-02f, -1.53436020e-01f, -2.52128959e-01f,
  -4.51181941e-02f, 9.08446871e-03f, -2.72566779e-03f, 1.02122100e-02f, -2.75465697e-02f, -9.72408131e-02f, -1.07237972e-01f, 7.55723417e-02f, 3.61060202e-02f, 7.09204450e-02f,
  -1.36677800e-02f, -6.94002286e-02f, -6.34234548e-02f, -4.05332930e-02f, -7.51724541e-02f, 7.26015568e-02f, 3.18431966e-02f, -1.06542490e-01f, -1.55011481e-02f, -2.85831969e-02f,
  7.34399706e-02f, 6.82271048e-02f, -5.39627522e-02f, 7.02842027e-02f, 1.23982899e-01f, 7.69430920e-02f, 2.18788944e-02f, 5.90017848e-02f, 2.92880256e-02f, 9.46986899e-02f,
  -6.34699166e-02f, -6.20230939e-03f, -2.54104217e-03f, -2.77211685e-02f, -1.09390467e-02f, -1.27990358e-02f, -5.53199798e-02f, -2.47320551e-02f, -4.25129682e-02f, -5.86311370e-02f,
  -8.13453719e-02f, 6.31059259e-02f, -4.05873731e-02f, -3.28109153e-02f, -1.95162110e-02f, -1.32720382e-03f, 5.03468476e-02f, -1.10144708e-02f, 5.09485565e-02f, 3.34683969e-03f,
  -6.65660426e-02f, 4.46194038e-02f, 5.94562069e-02f, 4.85953800e-02f, -1.35144340e-02f, -2.88776793e-02f, -9.15109217e-02f, -2.70395596e-02f, 3.19319568e-03f, 1.02037452e-01f,
  8.06670189e-02f, -9.11111906e-02f, 4.34797741e-02f, 2.87964400e-02f, -6.36443421e-02f, -2.45288983e-02f, 3.69094275e-02f, 3.33036073e-02f, 4.72269394e-02f, -4.42982353e-02f,
  4.50917482e-02f, -5.78058027e-02f, 4.99231070e-02f, -1.91245712e-02f, 5.31333312e-02f, -8.10059905e-02f, 2.38761231e-02f, -6.49228841e-02f, -7.14243129e-02f, 1.35720894e-02f,
  -2.25083958e-02f, -1.83013193e-02f, -2.20437683e-02f, -4.55274852e-03f, 4.24164124e-02f, 8.98206681e-02f, 8.17975868e-03f, -1.47755919e-02f, -3.64639610e-02f, 1.11210737e-02f,
  -2.04362571e-02f, 8.73375777e-03f, 8.17603022e-02f, -2.23281328e-02f, -7.64033273e-02f, -5.86479567e-02f, 4.98417541e-02f, -1.99078675e-02f, -9.22558177e-03f, -7.93173164e-03f,
  -9.85439941e-02f, -9.64618549e-02f, -8.65429565e-02f, 2.03641430e-02f, 8.58591497e-02f, -3.44635434e-02f, 9.50658917e-02f, -7.18807802e-02f, -4.50957119e-02f, 8.17018934e-03f,
  -2.05314588e-02f, 6.75162002e-02f, -3.07326764e-03f, -3.42014432e-02f, 3.13851982e-02f, -2.37448607e-02f, -1.10450834e-02f, 1.39499707e-02f, 6.80715442e-02f, 1.09930910e-01f,
  -2.63352811e-01f, 5.77281695e-03f, 1.23185785e-02f, -1.77589878e-02f, 3.03598568e-02f, 3.80280092e-02f, 3.30854498e-04f, 7.95416012e-02f, -1.17290497e-01f, 1.06608327e-02f,
  -2.40217000e-02f, -1.00387491e-01f, 2.09465530e-02f, -7.20066577e-02f, 7.24617988e-02f, 5.74983582e-02f, 1.14909662e-02f, -1.33353785e-01f, -8.19302201e-02f, 1.30302589e-02f,
  -1.09829821e-01f, -1.44877419e-01f, -1.66147590e-01f, -1.59995392e-01f, -9.11346823e-02f, -1.24257967e-01f, -1.47413071e-02f, 4.08227146e-02f, 1.00682370e-01f, -3.97697501e-02f,
  9.70146805e-02f, 1.00087903e-01f, 2.64292918e-02f, -7.64004439e-02f, 2.48515345e-02f, -1.97286811e-02f, 1.59153342e-02f, 5.64901643e-02f, -2.07980163e-02f, -6.16807565e-02f,
  -1.75535902e-02f, -6.83101825e-03f, -5.90396747e-02f, -5.33894226e-02f, 5.69012687e-02f, 7.66154379e-02f, 8.45726579e-02f, 1.79720353e-02f, -2.20858995e-02f, 9.51264501e-02f,
  8.62659737e-02f, 1.21469684e-02f, 7.57061690e-02f, 2.61055715e-02f, 6.77832514e-02f, -4.90867570e-02f, 1.31799713e-01f, -3.01138405e-02f, 8.51345286e-02f, 1.80266965e-02f,
  2.48125345e-02f, -8.95650685e-02f, -1.77930798e-02f, -3.16011235e-02f, 6.30010292e-03f, -6.70694932e-02f, -1.44868363e-02f, 2.85442695e-02f, -9.05442692e-04f, -1.03394873e-01f,
  3.22870538e-03f, 1.53874455e-03f, -5.68081290e-02f, -6.54167309e-02f, -1.20705888e-02f, -4.22448106e-02f, 1.17135486e-02f, 2.29379591e-02f, 7.96980262e-02f, 2.63395961e-02f,
  3.14329229e-02f, -3.72556634e-02f, -7.83405825e-02f, 5.02565950e-02f, 2.61443071e-02f, 6.97399955e-03f, 5.64797670e-02f, 8.51753876e-02f, -2.88894791e-02f, 3.69547009e-02f,
  8.63923784e-03f, 1.10391438e-01f, -1.11498706e-01f, -4.34554182e-02f, 4.70919237e-02f, -1.17963355e-03f, 3.37219685e-02f, 6.59149315e-04f, 7.80197009e-02f, -7.23893121e-02f,
  4.55846190e-02f, -1.17284879e-02f, 1.90017037e-02f, 2.23650374e-02f, -5.44490479e-02f, -3.87617685e-02f, 6.01853095e-02f, -7.30287209e-02f, 1.33598685e-01f, 2.10383441e-02f,
  1.09418407e-01f, 2.73324158e-02f, 2.38218065e-02f, -5.79449348e-03f, 1.23900373e-03f, 1.91752892e-02f, -1.22284153e-02f, -6.56476170e-02f, 9.81598124e-02f, -7.84014389e-02f,
  3.05079035e-02f, -8.86704773e-02f, -2.68379062e-01f, 1.02624744e-01f, 5.29383011e-02f, -1.40515462e-01f, -8.47610682e-02f, -1.56192531e-04f, 1.52782217e-01f, -8.57206732e-02f,
  -8.05719644e-02f, 1.39897689e-02f, -7.20716687e-03f, -7.29438961e-02f, -4.76494571e-03f, -2.22945631e-01f, -1.25745848e-01f, -8.83628204e-02f, 1.26604829e-02f, -3.64292264e-02f,
  4.44283197e-03f, -7.42795542e-02f, -6.65560067e-02f, 8.76822695e-02f, -1.56431515e-02f, 6.09008176e-03f, -1.26569793e-01f, -4.59921779e-03f, -7.02297017e-02f, -6.17429540e-02f,
  -2.09014520e-01f, 1.28683701e-01f, -9.25472379e-02f, 6.30327687e-02f, 4.97904010e-02f, -2.01494191e-02f, 7.07566515e-02f, 8.89036655e-02f, 8.46357942e-02f, 3.77857834e-02f,
  -3.44452597e-02f, 1.03830919e-01f, -2.24760166e-04f, 6.61761984e-02f, 5.29465713e-02f, -2.68677864e-02f, 5.48190847e-02f, -5.85374944e-02f, 2.08332855e-02f, 7.34462067e-02f,
  -9.27494690e-02f, 9.59300250e-03f, 7.01440424e-02f, -8.27736929e-02f, 1.15200086e-02f, -2.26861890e-02f, 3.24936613e-04f, -1.48459645e-02f, 8.61313045e-02f, 1.05337985e-01f,
  -7.15794861e-02f, 3.99833545e-02f, 6.69226199e-02f, 1.27522582e-02f, -2.58031506e-02f, -2.71205436e-02f, -5.12366695e-03f, -1.21245266e-05f, -1.19841332e-02f, 8.95651728e-02f,
  5.68822846e-02f, -3.82812787e-03f, -1.12142949e-03f, -6.27399608e-02f, 3.12959291e-02f, 7.23157525e-02f, -1.67654194e-02f, -1.05167560e-01f, 5.81547320e-02f, -1.38117000e-02f,
  2.69256029e-02f, 3.11571565e-02f, -2.20496976e-03f, 1.63208991e-02f, -9.52939466e-02f, -1.63805000e-02f, 2.79758051e-02f, 3.69493589e-02f, -1.28357271e-02f, 7.12084994e-02f,
  -2.14746352e-02f, -1.34557992e-01f, 2.46853549e-02f, 1.01128720e-01f, -6.00151680e-02f, 7.71503076e-02f, -2.41196412e-03f, -1.13710007e-02f, 5.82776330e-02f, -3.83006185e-02f,
  1.25290737e-01f, -4.50067483e-02f, -2.15646680e-02f, 6.15796559e-02f, -4.33342382e-02f, -4.25561927e-02f, -9.17932298e-03f, -3.24340863e-03f, 3.56644057e-02f, -2.16992591e-02f,
  -4.92938906e-02f, -5.35701551e-02f, -5.03678620e-03f, 4.49771695e-02f, -2.77900770e-02f, 1.25845959e-02f, -4.12254129e-03f, 4.87429500e-02f, -2.78159548e-02f, 6.30408078e-02f,
  1.13394130e-02f, 5.32484055e-02f, 7.64192492e-02f, 1.60087734e-01f, 1.40157238e-01f, 1.60100222e-01f, 1.75922021e-01f, 1.30827144e-01f, 1.46973729e-01f, 1.69252291e-01f,
  7.65659586e-02f, 2.01329753e-01f, 2.24505007e-01f, 2.18182251e-01f, 1.50100365e-01f, 1.82792008e-01f, 9.45442021e-02f, 6.23819865e-02f, -2.80387774e-02f, 1.55979291e-01f,
  1.73233733e-01f, 6.18472323e-02f, 1.38718467e-02f, 1.35777980e-01f, 1.53363511e-01f, 9.30732265e-02f, 8.70459527e-02f, 1.10117562e-01f, 8.11633989e-02f, 1.30107552e-01f,
  1.13837803e-02f, 2.39916798e-02f, 7.47529604e-03f, -3.40092033e-02f, -4.26812097e-02f, -1.61399879e-02f, 3.52172963e-02f, -3.40998136e-02f, -8.48089233e-02f, -8.01656917e-02f,
  -1.30023314e-02f, -2.23431960e-02f, -6.70367153e-05f, -3.85213345e-02f, -6.09445386e-03f, -1.03570014e-01f, 1.79554559e-02f, 3.80657762e-02f, -3.87288444e-02f, -8.17536041e-02f,
  1.43980280e-01f, 4.90498450e-03f, -4.70057800e-02f, -1.16862513e-01f, 6.42411411e-02f, 3.40408050e-02f, -2.41285972e-02f, -1.02591000e-01f, 3.27454656e-02f, 4.28941362e-02f,
  2.37205196e-02f, 3.15004736e-02f, -3.39913502e-04f, 1.11941621e-03f, 3.11051309e-02f, 3.98930646e-02f, -8.65199119e-02f, 6.46718293e-02f, 4.29720022e-02f, -1.15130777e-02f,
  -6.73064515e-02f, -6.97835162e-02f, 4.78358343e-02f, -4.05961182e-03f, -2.01897766e-03f, -6.58022538e-02f, -2.67186798e-02f, 6.44974783e-02f, 1.02921845e-02f, -8.40558782e-02f,
  -6.43100217e-02f, -2.12368984e-02f, -7.31028840e-02f, -2.48441901e-02f, 4.01577689e-02f, -2.82174395e-03f, 6.96221665e-02f, -1.47993919e-02f, 6.18353747e-02f, -3.87987047e-02f,
  2.50939070e-03f, 4.13221382e-02f, 5.41110560e-02f, 9.44319069e-02f, 4.74726781e-02f, -7.90224448e-02f, 2.39120107e-02f, -2.12820340e-02f, -2.52579469e-02f, 3.23826708e-02f,
  4.04233932e-02f, 5.46814911e-02f, 4.07719538e-02f, 3.02406610e-03f, -1.06319763e-01f, -2.09564138e-02f, 7.73715377e-02f, -1.98548362e-02f, -4.34973836e-02f, -4.46901284e-02f,
  1.10412557e-02f, -6.56075478e-02f, -1.54731259e-01f, -7.59809464e-02f, 5.00603393e-02f, -7.23929144e-03f, -1.52799845e-01f, -8.25253129e-02f, -2.07594712e-03f, -1.11348860e-01f,
  1.85356647e-01f, -1.01584420e-02f, -4.47989479e-02f, 1.30157009e-01f, 3.93221676e-02f, -1.69971377e-01f, -2.79352903e-01f, -1.98044658e-01f, -6.07738867e-02f, -8.23749825e-02f,
  -2.53848322e-02f, 4.35071066e-02f, -1.87628139e-02f, -1.30207121e-01f, -2.49210194e-01f, -2.33647540e-01f, -1.73007712e-01f, -3.28416633e-03f, -1.36140436e-01f, -1.96527597e-02f,
  -7.71567449e-02f, 9.98938456e-02f, 1.74181219e-02f, -3.31525155e-03f, 7.99119473e-02f, 8.78201649e-02f, 9.19288471e-02f, 9.39367190e-02f, -6.41936883e-02f, 9.72888321e-02f,
  -1.58329923e-02f, 1.05986901e-01f, -6.06654771e-02f, 1.18356869e-01f, 2.50917207e-03f, -2.15166789e-02f, -8.45267400e-02f, 1.06266774e-02f, 2.20159441e-02f, -3.02591641e-02f,
  5.19672483e-02f, 5.75068966e-02f, 1.02624305e-01f, 5.05452938e-02f, 1.58706140e-02f, 2.91538760e-02f, -1.09336600e-01f, -8.96496475e-02f, -1.35023490e-01f, -1.08317517e-01f,
  7.69669516e-03f, -5.17207989e-03f, -7.61924013e-02f, -9.00462195e-02f, -9.49349254e-02f, -7.40007535e-02f, 2.45995298e-02f, -7.98265785e-02f, -6.20362200e-02f, 7.97541663e-02f,
  -1.17044702e-01f, -9.69561283e-03f, 3.19178849e-02f, -4.32243571e-02f, -4.83451597e-02f, -4.21992391e-02f, 1.23492687e-03f, 2.28346381e-02f, -5.91374189e-02f, 4.99592647e-02f,
  -7.30140582e-02f, 2.74016112e-02f, -9.20052116e-04f, -6.26432002e-02f, 3.33188847e-02f, 8.01644400e-02f, -2.26527061e-02f, 5.14796041e-02f, 1.88396834e-02f, -6.66794479e-02f,
  -4.31137979e-02f, -1.60645768e-02f, 3.97679172e-02f, -2.64307410e-02f, -3.12060360e-02f, -6.38353005e-02f, 2.67025828e-02f, -8.05170238e-02f, -4.46034297e-02f, -7.92060494e-02f,
  9.00631920e-02f, -8.92468616e-02f, 5.85104488e-02f, 2.68449951e-02f, 2.49204971e-02f, -8.99690613e-02f, 6.30353242e-02f, -1.41408527e-02f, 2.62721106e-02f, 3.19358483e-02f,
  8.57956558e-02f, -4.36786152e-02f, 4.70002927e-02f, -6.37726486e-02f, -7.16593191e-02f, 1.12434011e-02f, -2.50192755e-03f, 3.79451439e-02f, -7.96460658e-02f, 5.95971532e-02f,
  -8.61751512e-02f, -8.88643190e-02f, 1.58060472e-02f, -1.32747442e-01f, 5.07451184e-02f, 1.55029977e-02f, -1.14925772e-01f, -2.68799975e-03f, -3.48752253e-02f, -1.87432155e-01f,
  3.10330898e-01f, 4.09058601e-01f, 2.45026108e-02f, 5.34597635e-02f, 9.74347349e-03f, 2.59956787e-03f, 2.12017685e-01f, 5.20425551e-02f, -9.71044004e-02f, 1.30404294e-01f,
  4.51553948e-02f, -1.14894979e-01f, -7.25647137e-02f, -8.06696042e-02f, 1.05114125e-01f, 7.81512931e-02f, 7.96653107e-02f, -9.11197513e-02f, -7.68240914e-02f, 6.69771656e-02f,
  -3.01062316e-02f, 1.54467434e-01f, 1.15805604e-01f, 8.07989836e-02f, 1.56872869e-02f, -2.01256294e-02f, 8.45144391e-02f, 1.35792390e-01f, 7.96979889e-02f, 5.12607656e-02f,
  -8.17056596e-02f, 1.81452036e-01f, -8.86460617e-02f, -1.30210314e-02f, 3.52613851e-02f, 2.09723730e-02f, -5.07654957e-02f, -1.45951668e-02f, -2.40811948e-02f, 4.76222336e-02f,
  1.13048129e-01f, -2.93527022e-02f, -6.87924633e-03f, -2.64453776e-02f, 1.06335238e-01f, -4.42366116e-02f, -1.05659021e-02f, 9.89625975e-02f, -5.76573331e-03f, -5.40003367e-02f,
  2.49622040e-03f, 9.65641998e-03f, 1.07568793e-01f, -1.47472946e-02f, -6.59290403e-02f, -5.68312332e-02f, -1.36496527e-02f, 8.02698433e-02f, 1.98489036e-02f, -4.34771646e-03f,
  -1.41485989e-01f, -4.41274419e-02f, -8.18737000e-02f, 3.84653211e-02f, 7.33425142e-03f, -4.98953909e-02f, -8.87535587e-02f, 3.30642760e-02f, -5.42836599e-02f, 9.61568132e-02f,
  -7.32494593e-02f, -8.08282793e-02f, -5.73012196e-02f, -7.31504187e-02f, -1.03575759e-01f, -2.44797133e-02f, -1.75896790e-02f, -2.38340832e-02f, -1.21533014e-02f, -2.95865629e-02f,
  1.03195685e-04f, -2.70104576e-02f, 5.89032769e-02f, -2.47061439e-02f, 8.03651847e-03f, -9.86409783e-02f, 1.81502309e-02f, 2.01140232e-02f, -9.88372415e-03f, -6.16813265e-02f,
  -1.44965336e-01f, -1.58686489e-01f, -1.55571431e-01f, -1.11594684e-02f, 5.32384496e-03f, -1.12131752e-01f, -5.04040718e-02f, -8.56214240e-02f, -1.79173704e-02f, -1.83528755e-03f,
  1.42732054e-01f, 3.86332572e-02f, 2.77584903e-02f, 1.64518952e-02f, -7.99287930e-02f, 8.67363438e-03f, 6.72489926e-02f, -6.52100295e-02f, -2.20072083e-03f, -1.49088819e-02f,
  5.55089936e-02f, -3.61555740e-02f, 3.51430220e-03f, -2.81498395e-03f, -7.37177655e-02f, -1.94883466e-01f, 2.66418867e-02f, -5.67075834e-02f, 2.73870141e-03f, -1.05847590e-01f,
  -8.18240196e-02f, -1.24472752e-01f, -3.31574827e-01f, -1.17271192e-01f, 2.38707121e-02f, -4.73568067e-02f, 4.47279029e-02f, 1.99391723e-01f, 1.46985903e-01f, -4.87634055e-02f,
  3.24819819e-03f, -1.08853810e-01f, -1.14996694e-01f, -1.32790163e-01f, -1.31046861e-01f, -2.31064573e-01f, -2.46607527e-01f, -2.91351378e-01f, -1.72733560e-01f, 7.58689046e-02f,
  6.68781251e-02f, -8.80203098e-02f, -1.75977394e-01f, -4.06656601e-02f, 4.66039814e-02f, -3.94309834e-02f, -1.02993295e-01f, -1.79649517e-01f, -6.27060831e-02f, -2.04720274e-01f,
  -2.55385995e-01f, 7.14339018e-02f, 4.01966684e-02f, -5.54825030e-02f, -2.48823836e-02f, 5.86315580e-02f, -5.39054796e-02f, -4.91668582e-02f, 6.04055673e-02f, 7.29669817e-03f,
  -1.14234045e-01f, 6.15464803e-03f, 1.40216853e-03f, -6.47897832e-03f, 3.54790725e-02f, 6.86834827e-02f, -5.14228232e-02f, -3.22400779e-03f, -3.11743235e-03f, 3.67704742e-02f,
  -7.11289886e-03f, 1.20651722e-02f, -1.20686390e-01f, -2.67827176e-02f, -5.07259145e-02f, -1.28989235e-01f, 4.02536169e-02f, 9.56619978e-02f, 4.02640365e-02f, 1.19575873e-01f,
  5.65118855e-03f, 1.56386029e-02f, -2.18072888e-02f, -1.66065749e-02f, 2.73298826e-02f, 4.90504364e-03f, 5.29121049e-02f, -3.85387577e-02f, 3.94538082e-02f, 2.23593563e-02f,
  2.60952078e-02f, -2.16521546e-02f, -2.58762259e-02f, -2.20156610e-02f, -3.15543003e-02f, -1.33546898e-02f, 9.70245972e-02f, -8.14444572e-03f, -1.05264165e-01f, -1.23643717e-02f,
  1.46950446e-02f, -2.02934444e-02f, -6.70132041e-02f, 4.93215770e-02f, 3.01701054e-02f, -6.62273541e-02f, 2.60345191e-02f, 6.58093542e-02f, 8.01061690e-02f, -3.42975743e-02f,
  -1.40286729e-01f, -3.03440019e-02f, -3.35519426e-02f, -4.24115732e-02f, -9.69732255e-02f, -6.54449388e-02f, -9.15654469e-03f, 5.78286387e-02f, 8.41125101e-03f, -3.97275612e-02f,
  -2.79152319e-02f, -1.19896546e-01f, -1.84784178e-02f, 7.93205108e-03f, 3.58143300e-02f, -1.13577768e-01f, 1.44847846e-02f, -1.28764823e-01f, -9.58266854e-03f, 1.22749366e-01f,
  -1.08882569e-01f, -1.06410161e-01f, -9.99034867e-02f, 3.58533263e-02f, 5.74777573e-02f, -5.48666604e-02f, -8.68062153e-02f, 1.66407730e-02f, -1.79845858e-02f, 3.69091704e-02f,
  -6.64717406e-02f, -5.96408918e-02f, -2.22481638e-02f, -1.35093838e-01f, 2.30708742e-03f, -3.67059000e-02f, 1.39816955e-01f, -7.03896061e-02f, -5.52121475e-02f, -5.15104793e-02f,
  -3.62386703e-02f, -1.16474263e-01f, -8.22351724e-02f, -6.18232302e-02f, 9.11069438e-02f, 6.53352365e-02f, 8.91745314e-02f, 7.55866244e-02f, -5.33948541e-02f, -8.12478215e-02f,
  -8.32141656e-03f, -1.13397233e-01f, -1.54913738e-01f, -1.09775074e-01f, -1.23330159e-03f, 3.18716764e-02f, -1.16082514e-02f, -1.56556536e-02f, 7.06928074e-02f, -8.46789777e-02f,
  8.50572586e-02f, -6.65424205e-03f, 9.26509798e-02f, -2.27073412e-02f, -9.78668220e-03f, -5.44438176e-02f, 1.33520141e-02f, 1.42426295e-02f, -8.27953741e-02f, 2.64862422e-02f,
  6.21357560e-02f, 6.97987005e-02f, -8.02938119e-02f, -7.96346180e-03f, -6.04489520e-02f, 7.80607611e-02f, 6.96497932e-02f, -3.77462134e-02f, -5.91694377e-02f, 9.79796275e-02f,
  1.12166673e-01f, -3.35904770e-02f, -3.50789130e-02f, -6.43233433e-02f, -6.41170666e-02f, 1.11805219e-02f, 4.38926592e-02f, 3.06827091e-02f, -6.33697659e-02f, -9.04647727e-03f,
  1.41428197e-02f, 8.56103972e-02f, 3.10883950e-02f, -5.43134734e-02f, -7.57733434e-02f, 3.81748527e-02f, 9.04013216e-02f, -2.83527765e-02f, -4.87571470e-02f, -6.42853081e-02f,
  8.42006430e-02f, 9.47011709e-02f, 3.95258237e-03f, 5.02341948e-02f, -8.39538798e-02f, 2.94990335e-02f, -7.04599544e-03f, 1.19430302e-02f, 2.12288834e-02f, -7.37536252e-02f,
  -3.48103344e-02f, -8.60699266e-02f, -8.21995139e-02f, -3.72881554e-02f, -6.88727722e-02f, -8.56815949e-02f, -4.39369641e-02f, 1.80527493e-02f, 5.92053421e-02f, -1.41993482e-02f,
  -1.40610233e-01f, 9.90979895e-02f, 4.13152501e-02f, -3.33651081e-02f, -1.54640265e-02f, -6.30657002e-02f, -1.81901944e-03f, -6.31076768e-02f, 5.50395809e-02f, 9.52933729e-02f,
  1.89186111e-02f, 4.14861590e-02f, 7.13058487e-02f, 5.47683239e-02f, 4.22763731e-03f, 9.29694772e-02f, 3.80462036e-02f, -3.10385246e-02f, 2.12773066e-02f, 3.22520956e-02f,
  9.14412923e-03f, -5.68896011e-02f, -4.90293503e-02f, 2.85177603e-02f, -1.51086543e-02f, -6.43430129e-02f, 1.39319468e-02f, -2.49873642e-02f, 1.06887557e-01f, -4.55244556e-02f,
  -1.19796935e-02f, -7.72546604e-02f, -8.80553573e-02f, 4.11649421e-02f, 5.89257628e-02f, 4.26195301e-02f, -7.66430348e-02f, -5.48648350e-02f, 3.46232615e-02f, 1.03546437e-02f,
  1.01158388e-01f, 1.81225128e-02f, 1.10318385e-01f, -3.92986946e-02f, -3.42793129e-02f, -1.28183281e-03f, 2.03391854e-02f, 7.30629787e-02f, 8.70201215e-02f, 2.49574147e-02f,
  -2.93400604e-02f, 1.40412617e-02f, -4.87908581e-03f, 1.00049712e-01f, 5.99229075e-02f, 9.36489031e-02f, -5.93327917e-02f, -1.55323241e-02f, -5.33011854e-02f, -4.32621501e-02f,
  7.81321973e-02f, -3.44792232e-02f, -8.04986134e-02f, 5.24305925e-03f, 1.98906828e-02f, -3.35782804e-02f, -9.09602344e-02f, 4.13218141e-02f, -3.62602919e-02f, -1.93299185e-02f,
  9.49158818e-02f, 3.08146025e-03f, 7.47698620e-02f, -6.25781566e-02f, 8.17127973e-02f, -4.14955765e-02f, 3.32049839e-02f, -6.88283443e-02f, 3.79313044e-02f, -3.15678231e-02f,
  6.68781027e-02f, 6.18889183e-02f, -2.62109004e-02f, 7.54724862e-03f, 4.29633856e-02f, 2.33676229e-02f, -4.75667156e-02f, -1.83050465e-02f, 4.44788262e-02f, -9.53552574e-02f,
  6.37382120e-02f, 7.68323382e-03f, -6.10691831e-02f, -6.28189519e-02f, 6.11204207e-02f, 5.12575991e-02f, -3.91628668e-02f, 5.00496700e-02f, 4.36108606e-03f, 4.08980548e-02f,
  1.52824549e-02f, 1.04060331e-02f, 4.14377339e-02f, 3.49258780e-02f, 8.97312164e-02f, -7.10313246e-02f, -8.11305270e-03f, 7.07250834e-02f, 8.35305825e-02f, -7.06615299e-02f,
  -3.48127857e-02f, 2.04765033e-02f, 1.91175602e-02f, 2.01080963e-02f, -4.86599654e-02f, 2.12854650e-02f, -8.53727758e-02f, -7.70491734e-03f, 1.84630547e-02f, 1.02745006e-02f,
  -4.30445373e-02f, -8.45979974e-02f, 3.97032909e-02f, 3.14115249e-02f, -5.91589175e-02f, 7.16457069e-02f, 2.51776073e-02f, 5.59792966e-02f, -5.15901968e-02f, -2.37550912e-03f,
  -1.60298478e-02f, -9.34111997e-02f, 7.51772299e-02f, 6.41422048e-02f, -7.95531198e-02f, 7.27685466e-02f, 3.78143415e-03f, 5.03000580e-02f, -7.15184584e-02f, -6.15223907e-02f,
  -2.67179534e-02f, 8.68621748e-03f, -2.68223900e-02f, -1.49112893e-02f, 7.47822076e-02f, -5.32985777e-02f, -5.74662462e-02f, -3.40803005e-02f, -1.35965064e-01f, -1.32827044e-01f,
  -1.30989939e-01f, -6.68411925e-02f, 1.56515554e-01f, -1.62306860e-01f, -9.62658301e-02f, -4.54090722e-03f, -1.47656454e-02f, -8.21416383e-04f, -1.01764895e-01f, -3.82065810e-02f,
  -1.00943454e-01f, 1.79129764e-02f, -4.58830632e-02f, 3.63589339e-02f, 1.05745398e-01f, 9.81093291e-03f, 1.84017364e-02f, 2.64715198e-02f, 4.17899452e-02f, 8.08811001e-03f,
  -2.12510712e-02f, 8.51882342e-03f, -8.98893178e-02f, -2.26570461e-02f, -5.03595918e-02f, 9.19472128e-02f, 2.44062077e-02f, -1.99954472e-02f, -7.29735568e-02f, -1.05424151e-01f,
  1.42909482e-01f, -4.76067923e-02f, 9.17975754e-02f, -8.95853266e-02f, 4.54058051e-02f, -1.17328716e-02f, 2.59662839e-03f, -8.10497925e-02f, -9.37149078e-02f, -1.20205572e-02f,
  -8.16644728e-02f, -6.01162538e-02f, -4.98856157e-02f, -7.03238174e-02f, 5.07295728e-02f, -3.60452831e-02f, 5.51412292e-02f, -3.16497125e-02f, -7.58142322e-02f, -2.33048461e-02f,
  -3.05122556e-03f, 4.34704646e-02f, 1.40024070e-03f, -7.43287280e-02f, -6.02507815e-02f, 2.14147121e-02f, 6.43000081e-02f, -1.03366459e-02f, -1.14861079e-01f, -1.81081370e-02f,
  -5.77699207e-02f, -3.11024878e-02f, 9.19572636e-02f, -6.65221587e-02f, -7.74787515e-02f, 3.01308520e-02f, 1.54364295e-02f, 2.96956673e-02f, -4.66600154e-03f, 6.39803056e-03f,
  -8.82413462e-02f, 3.62154422e-03f, 1.75580923e-02f, -4.81330194e-02f, 2.54862532e-02f, 3.88581716e-02f, -1.24089587e-02f, -8.66884068e-02f, 9.98522416e-02f, -3.87389921e-02f,
  -2.24471372e-03f, 4.99302745e-02f, 7.36366436e-02f, 3.55494395e-02f, -2.14389954e-02f, 6.25526235e-02f, 6.36657104e-02f, 2.07313094e-02f, 2.84200907e-02f, -7.04524666e-02f,
  2.09637582e-01f, 2.55039195e-03f, 5.63878417e-02f, 2.07444094e-02f, -3.60152945e-02f, 1.25939539e-02f, 8.41261446e-02f, 2.81867702e-02f, -8.97160992e-02f, 8.75855014e-02f,
  4.00916766e-03f, -6.09014481e-02f, -5.21611702e-03f, 8.74772817e-02f, 7.96661675e-02f, 1.94805730e-02f, -9.34447721e-02f, 5.42067736e-02f, -5.88639043e-02f, -5.24050519e-02f,
  -9.56661180e-02f, -3.61836366e-02f, 1.21287346e-01f, -8.50409083e-03f, -2.94165104e-03f, -1.24566825e-02f, 8.57191756e-02f, 5.61934635e-02f, -1.88424010e-02f, 1.59311250e-01f,
  -1.66096404e-01f, 1.03421323e-01f, 3.97061743e-02f, 3.22903804e-02f, 3.80231962e-02f, -7.87328258e-02f, -8.80905613e-02f, -1.33360298e-02f, -7.58091286e-02f, 3.77378762e-02f,
  2.78341062e-02f, 6.93115592e-02f, 6.75579021e-03f, -8.85817111e-02f, -7.71770328e-02f, -8.39988049e-03f, 4.15787511e-02f, -1.31438002e-02f, -3.45047899e-02f, -9.44820493e-02f,
  1.17149167e-02f, 6.55272454e-02f, -5.72961383e-02f, -1.03547759e-02f, 8.59023258e-02f, -2.13933401e-02f, -7.62480590e-03f, -2.09094174e-02f, 9.87005979e-02f, 1.06071591e-01f,
  2.84805545e-03f, -5.48003614e-02f, 8.01957101e-02f, -5.23863696e-02f, 3.54566015e-02f, 5.38045242e-02f, -6.58700913e-02f, -3.58417518e-02f, 1.63444784e-02f, 6.42144531e-02f,
  1.13466837e-01f, 7.69920424e-02f, 4.50613089e-02f, -7.05327019e-02f, -2.49030627e-02f, 3.89484502e-02f, -4.59135287e-02f, -7.82198831e-02f, -6.89621419e-02f, 4.91532497e-02f,
  1.02519989e-02f, 4.39384840e-02f, 4.80510518e-02f, 2.81934086e-02f, 1.84871051e-02f, 6.17674142e-02f, 2.00866628e-02f, 1.31826921e-04f, -5.54648563e-02f, 2.20745569e-03f,
  -5.18996790e-02f, 8.22994933e-02f, -2.25599622e-03f, 2.06501093e-02f, -7.21974149e-02f, 6.34250641e-02f, -2.85598710e-02f, -7.98818171e-02f, 5.95464520e-02f, -9.19141918e-02f,
  -8.18202365e-03f, 6.58907518e-02f, 6.82582706e-02f, -6.61237538e-02f, 2.61245910e-02f, -3.67463790e-02f, -8.99757072e-03f, -1.08451342e-04f, 7.48355463e-02f, 2.35072169e-02f,
  7.70633072e-02f, -6.29753917e-02f, 6.35578185e-02f, -4.41308208e-02f, -4.84139957e-02f, -8.44615977e-03f, -6.69324696e-02f, -4.77501191e-02f, 4.91800606e-02f, -2.95503289e-02f,
  7.68712461e-02f, -1.06971487e-01f, 6.99301735e-02f, 8.00398439e-02f, 2.16564219e-02f, 6.83928654e-03f, -4.31742780e-02f, 5.16864508e-02f, -1.34337228e-02f, 9.38939303e-02f,
  8.48538578e-02f, 6.25488088e-02f, 3.81880701e-02f, 2.82471590e-02f, -5.27865142e-02f, 1.86857041e-02f, 4.79011163e-02f, -2.93102916e-02f, 2.80305073e-02f, 5.03664613e-02f,
  8.68726969e-02f, 2.18147691e-02f, 5.95128015e-02f, -5.98159470e-02f, -1.10712331e-02f, -8.57301280e-02f, -8.63356814e-02f, 9.28777605e-02f, -9.78626311e-02f, -5.03088236e-02f,
  1.12067804e-01f, 1.05524614e-01f, 3.32640968e-02f, -1.86693184e-02f, -7.93884788e-03f, -7.87015110e-02f, 5.21187559e-02f, -2.97665410e-03f, 6.04903139e-02f, -2.17095576e-02f,
  -7.02624097e-02f, -2.51869354e-02f, 4.51082326e-02f, -8.39016028e-03f, 1.05516657e-01f, 5.28348908e-02f, 1.31950742e-02f, 7.66184032e-02f, -4.07436453e-02f, -1.22742178e-02f,
  3.77608500e-02f, 4.98776033e-04f, 3.84095088e-02f, -1.59969786e-03f, 2.65034772e-02f, 2.14136466e-02f, 2.09398866e-02f, -3.59919220e-02f, -3.58403027e-02f, 7.48706013e-02f,
  1.33787930e-01f, -5.80463232e-03f, -5.39586693e-03f, -9.80564281e-02f, -1.03453305e-02f, 9.18286070e-02f, -2.46464014e-02f, 5.77431219e-03f, -4.75065112e-02f, 5.14294319e-02f,
  -1.00143954e-01f, 6.07255772e-02f, -8.02675411e-02f, -1.84408780e-02f, -5.74165732e-02f, -4.43353243e-02f, 1.04338653e-01f, 1.39864594e-01f, 7.76416808e-02f, 5.68993427e-02f,
  -7.36913756e-02f, -9.95301828e-02f, 7.42922500e-02f, -5.95679283e-02f, 4.26176861e-02f, 6.89078644e-02f, 1.67582706e-02f, 6.36034831e-02f, -4.35738191e-02f, 1.09361231e-01f,
  -5.90947084e-02f, 3.93835753e-02f, 9.32175480e-03f, 1.28073222e-03f, 3.26408595e-02f, -7.12127388e-02f, -6.55105412e-02f, 3.76209174e-03f, 6.24101013e-02f, 7.84725025e-02f,
  -3.92608531e-03f, 4.14010957e-02f, -3.06405723e-02f, -5.25232926e-02f, 3.20357345e-02f, -5.44205047e-02f, -8.37119520e-02f, 3.76813598e-02f, 1.01873703e-01f, -7.17573538e-02f,
  -5.72276749e-02f, 1.37249315e-02f, -7.67778903e-02f, 9.75808427e-02f, 1.98794883e-02f, 4.43010405e-02f, -5.76486103e-02f, -7.57410331e-03f, -6.49422407e-04f, -3.38196233e-02f,
  -1.55668231e-02f, 4.52729315e-02f, 3.61060165e-02f, 1.00459576e-01f, 5.20763583e-02f, -5.30415289e-02f, 5.12542129e-02f, -6.65415078e-02f, 5.10110855e-02f, 4.17356752e-02f,
  3.04133631e-02f, 3.26889604e-02f, 5.93834817e-02f, 1.06310146e-02f, -3.52396555e-02f, -7.94303939e-02f, -7.03874603e-02f, -5.04367948e-02f, 8.40230212e-02f, -1.97394714e-02f,
  -2.03079022e-02f, -7.14506134e-02f, -5.80911301e-02f, 2.46203213e-04f, -5.49638271e-02f, 4.56567295e-02f, -2.61047743e-02f, -4.87050600e-02f, -6.11707829e-02f, -4.92433310e-02f,
  1.42181501e-01f, 8.96078255e-03f, -3.37887444e-02f, 9.32193771e-02f, 6.75527602e-02f, 9.07318592e-02f, 2.34694611e-02f, -1.18205491e-02f, 2.62197964e-02f, 5.10958023e-03f,
  -3.59470882e-02f, -1.58088118e-01f, -8.03409591e-02f, -1.00490600e-01f, -8.31483584e-03f, 2.24336199e-02f, 1.11698046e-01f, 6.33849278e-02f, -7.08668530e-02f, -4.58367914e-02f,
  -3.28382291e-02f, -3.87570262e-02f, 3.27594765e-02f, 6.42283410e-02f, -4.43735532e-02f, -6.21722639e-02f, 3.81441973e-02f, -3.58267762e-02f, -6.45189881e-02f, -6.09562686e-03f,
  -1.78907424e-01f, -1.44618765e-01f, -4.77104727e-03f, -4.16079089e-02f, -2.86756214e-02f, -4.00951542e-02f, 5.33857569e-02f, 9.06103384e-03f, -2.42167152e-03f, -4.31659333e-02f,
  -9.50382799e-02f, -6.21972308e-02f, -5.15597574e-02f, 5.78768291e-02f, -2.48362832e-02f, 1.03141228e-02f, -3.00788321e-02f, -8.10493007e-02f, 4.25881557e-02f, 2.51164287e-02f,
  6.23135976e-02f, -7.78687671e-02f, -1.40354261e-02f, -1.45770293e-02f, 5.08900918e-03f, 6.96312031e-03f, 6.56292811e-02f, 4.96638343e-02f, -2.46475730e-02f, 5.54457828e-02f,
  -3.13656591e-02f, 4.56524938e-02f, 3.95849859e-03f, 4.91089672e-02f, 2.33240537e-02f, -6.99992105e-02f, 7.58563727e-03f, 6.49063066e-02f, -2.20802948e-02f, 1.07817635e-01f,
  9.79073048e-02f, -3.86774652e-02f, 9.47929695e-02f, 1.05189927e-01f, 1.98053811e-02f, -3.08811944e-02f, -3.44612971e-02f, -1.42185725e-02f, -8.60963315e-02f, 9.57747474e-02f,
  5.65363988e-02f, 6.72447309e-02f, -4.67867479e-02f, 4.49902490e-02f, 2.54639424e-02f, 1.04585476e-02f, -3.73993367e-02f, -5.77148311e-02f, -4.97239679e-02f, 6.07426055e-02f,
  -7.92027488e-02f, -9.64754447e-02f, 4.15458605e-02f, -5.09223081e-02f, 4.64925840e-02f, -4.21830500e-03f, -5.82280904e-02f, -5.72144277e-02f, -3.90701033e-02f, -4.63479478e-03f,
  7.37958448e-03f, 4.98647988e-02f, -7.25665018e-02f, 8.96996409e-02f, -4.00347486e-02f, 5.33946157e-02f, 1.13190472e-01f, 9.44813490e-02f, -7.56873041e-02f, -5.27432561e-02f,
  2.74807005e-03f, 3.31403576e-02f, 1.23669207e-01f, 1.13715574e-01f, -2.08876859e-02f, 6.22842088e-02f, 3.19368206e-02f, 3.70194539e-02f, -4.07181345e-02f, 9.65031311e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 52)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 52;
const float L0_fan_Bp_bar_data[] = {
  -1.71996094e-02f, 2.09135368e-01f, -4.47508655e-02f, -2.36252919e-02f, 2.84898311e-01f, 1.10734794e-02f, 7.76922107e-02f, 1.33659691e-01f, 8.28368366e-02f, 1.21955313e-01f,
  1.51416868e-01f, 2.65252769e-01f, 2.48038575e-01f, 5.88975959e-02f, 1.62067801e-01f, 5.01408987e-02f, 3.03856116e-02f, 3.78500484e-02f, 2.61273742e-01f, 9.39387828e-02f,
  -1.61346812e-02f, -1.94472354e-02f, 1.85532257e-01f, 5.33018634e-02f, 2.43142154e-02f, -2.73178779e-02f, 1.19243033e-01f, -4.90604527e-02f, 7.34555200e-02f, 4.09565344e-02f,
  1.04460388e-01f, 1.98326260e-01f, 3.90527397e-02f, 1.46255612e-01f, -6.08086362e-02f, -5.40680476e-02f, 1.45580292e-01f, 1.93756863e-01f, 1.36861831e-01f, 9.71134081e-02f,
  1.43101245e-01f, 1.30024150e-01f, 6.57042488e-02f, 1.13774195e-01f, 1.76908910e-01f, 2.73085266e-01f, 1.98554453e-02f, -2.72984449e-02f, 1.01036549e-01f, -1.11977151e-02f,
  7.32875317e-02f, 9.13215578e-02f
};

// L1_fan_Wp (Shape: 6 x 64)
const int L1_fan_Wp_rows = 6;
const int L1_fan_Wp_cols = 64;
const float L1_fan_Wp_data[] = {
  -2.36304738e-02f, 1.48152068e-01f, -4.95807007e-02f, -1.35130435e-01f, 1.92189753e-01f, 1.90725029e-01f, -1.01153970e-01f, 2.36368686e-01f, 1.62947014e-01f, 1.61328048e-01f,
  -2.02312842e-01f, 9.39012319e-02f, -6.42780289e-02f, -4.75281626e-02f, 7.60803670e-02f, 1.43603478e-02f, 8.18394944e-02f, -5.21552935e-02f, 3.20678093e-02f, -4.20769490e-02f,
  -9.18627679e-02f, 5.82506284e-02f, 7.84187540e-02f, -3.35919261e-02f, 1.42127976e-01f, 5.60718849e-02f, -2.11045191e-01f, -3.16222683e-02f, 1.40657440e-01f, 4.05735932e-02f,
  2.22683713e-01f, 3.15030962e-02f, 2.36329697e-02f, -6.32573590e-02f, -3.50466464e-03f, -3.63843143e-03f, 1.20487295e-01f, 2.42760237e-02f, 4.69369777e-02f, 2.64647864e-02f,
  2.15530589e-01f, -4.65495326e-02f, -5.91217019e-02f, 4.72372510e-02f, -8.92684609e-02f, -1.04473233e-02f, -7.02245831e-02f, 9.09611732e-02f, -1.01146124e-01f, 1.48401707e-01f,
  -9.30657517e-03f, -3.10775619e-02f, 1.31912664e-01f, -8.04592222e-02f, -8.75502154e-02f, -1.13816254e-01f, 8.72638151e-02f, -1.23427130e-01f, 1.19297288e-01f, -1.38843313e-01f,
  4.88078035e-02f, 4.40522991e-02f, 1.14479281e-01f, 8.63732547e-02f, -1.10383354e-01f, -1.35340974e-01f, -3.03705782e-02f, -1.23103477e-01f, -4.54816557e-02f, -5.66434190e-02f,
  -2.15788316e-02f, 3.99875998e-01f, -1.57135576e-01f, -1.77987128e-01f, -2.26825714e-01f, 1.45690426e-01f, 3.20692137e-02f, 1.21269420e-01f, 6.08236529e-02f, -1.43114105e-01f,
  -2.38211583e-02f, -1.92731366e-01f, -9.58469510e-02f, 2.66435921e-01f, 1.17455870e-01f, -4.06103283e-02f, 6.07463270e-02f, -2.56052047e-01f, 5.12355678e-02f, 1.20486155e-01f,
  -5.96959256e-02f, -1.12685993e-01f, 4.52971905e-02f, -9.95174348e-02f, -3.24964970e-02f, 9.23334504e-04f, 1.05832092e-01f, 2.71661486e-02f, -1.67565525e-01f, -1.44261613e-01f,
  -4.40762490e-02f, 7.11157098e-02f, 3.86735722e-02f, -1.85583174e-01f, -6.26697242e-02f, -4.08926047e-02f, 7.80192539e-02f, 6.13478832e-02f, 7.83172846e-02f, 9.93413152e-04f,
  -1.70145999e-03f, 3.57911317e-03f, -1.27260223e-01f, 2.36709677e-02f, 5.46926223e-02f, -5.94230592e-02f, 1.66222021e-01f, -7.61626009e-03f, -1.98561668e-01f, -1.14010692e-01f,
  2.67284483e-01f, -1.07986808e-01f, 1.93917409e-01f, -5.14979996e-02f, 5.49488813e-02f, 1.10969245e-01f, 1.61923379e-01f, -4.22759131e-02f, -6.25975132e-02f, 4.23153527e-02f,
  -1.65993959e-01f, -2.34630927e-02f, -1.59245133e-02f, 2.56737135e-02f, -1.28316209e-01f, 8.71764719e-02f, -1.90552607e-01f, 1.48958666e-02f, 2.05393940e-01f, -8.64810310e-03f,
  -4.87318784e-02f, 1.71289280e-01f, 2.37427354e-02f, -9.05416533e-02f, 4.28340286e-02f, -3.74833383e-02f, 1.22645266e-01f, 1.27064079e-01f, -1.47222579e-01f, -1.15036473e-01f,
  -8.90359208e-02f, 1.42626524e-01f, -1.76494941e-02f, -6.68274015e-02f, 1.59926996e-01f, 5.59170470e-02f, 3.93198468e-02f, -3.74657474e-02f, 1.03698447e-01f, -1.14198551e-02f,
  -7.01299682e-02f, -1.62868544e-01f, -1.54862359e-01f, -8.73549506e-02f, 7.18670040e-02f, -4.91526444e-03f, 6.66811466e-02f, -7.75239915e-02f, -1.27740413e-01f, -2.74096150e-02f,
  -7.70491883e-02f, -7.52698407e-02f, 1.02525033e-01f, 3.38774398e-02f, 2.11996399e-02f, 6.40852302e-02f, -6.79891789e-03f, -2.68038604e-02f, -5.34620546e-02f, 9.88185331e-02f,
  1.82597354e-01f, 5.48447743e-02f, 4.83880900e-02f, -6.11085556e-02f, -7.97241926e-02f, 1.18380941e-01f, 7.95506835e-02f, -1.11548848e-01f, -1.05131142e-01f, -5.67753799e-02f,
  4.37736101e-02f, -1.26398876e-01f, 6.18108958e-02f, -1.58385649e-01f, 7.01953396e-02f, -2.27188114e-02f, -1.57934390e-02f, -1.34479985e-01f, 3.67640644e-01f, 6.93609342e-02f,
  -2.58436650e-01f, -1.47502840e-01f, -2.28595197e-01f, -2.49927744e-01f, 1.62196726e-01f, -2.53991604e-01f, -8.81714970e-02f, -2.23607346e-02f, 6.39884770e-02f, -5.75098768e-02f,
  1.12942934e-01f, -1.40611604e-01f, 7.55400509e-02f, 1.18236639e-01f, -1.17135368e-01f, -9.78567377e-02f, -7.31696188e-02f, -7.42141753e-02f, -5.45596108e-02f, 8.41092542e-02f,
  3.80312949e-02f, 3.32558155e-02f, -8.42548013e-02f, 9.16910321e-02f, -1.15966268e-01f, -1.01041429e-01f, 3.42014022e-02f, -5.56320474e-02f, 7.92313740e-02f, -6.85302690e-02f,
  -6.04878403e-02f, 4.72670831e-02f, 1.63299099e-01f, 7.85627440e-02f, -2.17383906e-01f, -9.48057696e-02f, 1.00764729e-01f, -3.33884702e-04f, -1.46585763e-01f, 5.53208776e-02f,
  6.05216473e-02f, 1.27818450e-01f, 1.74695641e-01f, -2.24638227e-02f, 7.19719678e-02f, -6.50252914e-03f, 1.24130873e-02f, 1.87268317e-01f, 1.97194323e-01f, -1.09513372e-01f,
  -5.01748770e-02f, -9.03275758e-02f, -1.94884315e-02f, -5.92970885e-02f, 4.03311215e-02f, 7.63059855e-02f, 1.15535200e-01f, -1.43060610e-01f, 6.75012125e-03f, -4.80837524e-02f,
  1.38258576e-01f, 4.58017290e-02f, 2.72049308e-01f, 7.23925680e-02f, -3.26884687e-01f, -1.82480380e-01f, -9.99093428e-02f, 1.92251839e-02f, 5.97205497e-02f, 3.15359309e-02f,
  5.94150566e-04f, -4.77947704e-02f, 1.57624066e-01f, -6.34534135e-02f, -6.32147044e-02f, -5.97784966e-02f, 4.24374677e-02f, 5.59435748e-02f, 1.43809482e-01f, -1.06011644e-01f,
  3.45648490e-02f, 1.16197459e-01f, -1.71375591e-02f, -2.51094718e-02f, -1.95879135e-02f, 1.51161641e-01f, -1.42594144e-01f, 9.04952958e-02f, -2.71708071e-02f, -1.04705985e-04f,
  -4.99278195e-02f, -3.75775783e-03f, 7.42557943e-02f, -1.66244563e-02f, 9.24806967e-02f, -7.09631713e-03f, 3.80138680e-02f, -7.19067678e-02f, 1.72483996e-02f, -9.58898738e-02f,
  2.00420827e-01f, -1.37534831e-02f, -1.40914619e-01f, 8.55281204e-02f, 1.70473918e-01f, -4.98344712e-02f, 2.26057470e-01f, 6.34629801e-02f, 6.81626946e-02f, -1.06033392e-01f,
  9.75179076e-02f, 1.46196082e-01f, 9.12140608e-02f, 9.50801894e-02f, 1.00420658e-02f, -1.17331073e-01f, -9.54071358e-02f, 1.15887351e-01f, 8.03886354e-03f, -1.11171030e-01f,
  1.77504703e-01f, 3.58757824e-02f, -2.90479865e-02f, -9.83250290e-02f, -8.54042545e-02f, -4.64450903e-02f, -2.26345509e-01f, 3.96566778e-01f, -8.30993205e-02f, 2.26260535e-02f,
  -1.07598849e-01f, 1.13391034e-01f, -6.51224628e-02f, 9.28387195e-02f, 2.05857337e-01f, 1.21145956e-01f, -1.66664273e-01f, -1.68528751e-01f, 2.04162169e-02f, 1.92071393e-01f,
  1.91752300e-01f, -1.52494356e-01f, 2.34670937e-01f, -1.47964031e-01f, 1.07177451e-01f, 1.28776804e-01f, 2.40190290e-02f, -2.79502384e-02f, 5.61155416e-02f, -7.01129287e-02f,
  1.12005994e-01f, 1.57470614e-01f, 8.59143399e-03f, -6.83642626e-02f, -2.19427437e-01f, 3.23156863e-02f, -4.59928857e-03f, 1.25945717e-01f, 4.07470800e-02f, -1.62450358e-01f,
  -1.70577869e-01f, -1.10957965e-01f, 2.31953174e-01f, 8.47690701e-02f, 7.61471614e-02f, 2.67874589e-03f, 6.81498973e-03f, 1.08646207e-01f, 3.78529429e-02f, 8.88849201e-04f,
  -1.32040493e-02f, 1.15284652e-01f, 1.20888583e-01f, -2.02222332e-01f, -1.54327512e-01f, -2.39436597e-01f, -1.03404075e-02f, 1.20713450e-02f, 2.24289335e-02f, 9.36105440e-04f,
  1.53287098e-01f, 7.33686313e-02f, -4.84789303e-03f, 1.59419924e-01f
};

// L1_fan_Wp_bar (Shape: 52 x 64)
const int L1_fan_Wp_bar_rows = 52;
const int L1_fan_Wp_bar_cols = 64;
const float L1_fan_Wp_bar_data[] = {
  2.13563830e-01f, 1.12899370e-01f, 9.97119024e-02f, 1.27246499e-01f, 5.89351580e-02f, 1.74927175e-01f, -1.12415120e-01f, 1.59868091e-01f, -2.09602445e-01f, 2.27978289e-01f,
  3.66644740e-01f, -8.82505551e-02f, -6.80829510e-02f, 3.08278739e-01f, -3.76851261e-02f, 4.03317586e-02f, 2.57529378e-01f, 2.90797725e-02f, 5.90370186e-02f, -1.51847214e-01f,
  2.53405064e-01f, -4.55860831e-02f, 2.27043420e-01f, 3.69023293e-01f, 1.25590518e-01f, -1.65572062e-01f, 9.07589272e-02f, 1.61993310e-01f, 1.16002761e-01f, 7.89358765e-02f,
  1.25824109e-01f, -3.89569178e-02f, 1.23189308e-01f, -3.04678548e-03f, -6.50900602e-02f, -5.93973808e-02f, 2.19141141e-01f, -3.26463655e-02f, 2.66350240e-01f, -6.14903169e-03f,
  -1.40773088e-01f, 1.62457645e-01f, 3.91062498e-02f, -5.86722791e-02f, 1.41494330e-02f, 1.00424789e-01f, 6.20036677e-04f, 1.39612585e-01f, 3.41071069e-01f, -3.03910300e-02f,
  2.93015093e-01f, -7.99033195e-02f, 2.27015719e-01f, 7.67667070e-02f, 9.78978947e-02f, -1.17603661e-02f, -7.42042363e-02f, 1.48510411e-01f, 3.47807594e-02f, 1.42649621e-01f,
  -1.29866973e-01f, 4.56771217e-02f, -5.46980910e-02f, -1.32887214e-01f, 9.29054990e-02f, 1.16114140e-01f, 7.95370713e-02f, 3.76233086e-02f, 5.85218742e-02f, 1.45448416e-01f,
  7.55965710e-02f, 2.21231505e-01f, -1.83129638e-01f, 7.80889243e-02f, 2.43348647e-02f, 1.42055228e-01f, 2.01103482e-02f, 2.02155299e-02f, -5.14885373e-02f, 7.64508173e-02f,
  7.52435699e-02f, -9.02743265e-02f, -6.84117377e-02f, -4.76290062e-02f, 7.56544694e-02f, -2.28681061e-02f, 1.99467629e-01f, 8.38968307e-02f, 1.49149269e-01f, -7.45297819e-02f,
  -6.60704158e-04f, 1.17834911e-01f, -2.07890552e-02f, -3.77005972e-02f, 9.10665318e-02f, -8.98327231e-02f, -9.70683545e-02f, -2.65082140e-02f, 2.40849946e-02f, -7.65564591e-02f,
  1.84785888e-01f, -1.03889972e-01f, 4.72162291e-02f, -7.59952515e-03f, -1.05295695e-01f, 1.30762234e-01f, -5.46744280e-02f, -5.01826182e-02f, 1.54031172e-01f, 5.37846312e-02f,
  -8.06916207e-02f, 2.84405332e-02f, -6.19210042e-02f, -8.86771083e-02f, 8.16620514e-03f, -6.27408475e-02f, 1.58794090e-01f, -1.07787328e-03f, -4.93148491e-02f, -6.84466735e-02f,
  -3.97940949e-02f, 1.35387152e-01f, 1.04345985e-01f, 8.67265835e-03f, -3.02634966e-02f, -4.78074774e-02f, -7.45338202e-03f, 5.17807193e-02f, 1.22061096e-01f, 2.21361652e-01f,
  3.70128006e-02f, 1.92032441e-01f, 1.21112704e-01f, 1.77121222e-01f, -2.76084006e-01f, 2.91218996e-01f, 1.54361010e-01f, 1.14661865e-01f, -2.29833394e-01f, 5.04890317e-03f,
  -1.17727265e-01f, 1.69933230e-01f, 1.08920142e-01f, 8.34086761e-02f, 2.44455487e-01f, 3.40619534e-02f, -7.34621286e-02f, 1.51189655e-01f, 5.10887057e-02f, 3.15576270e-02f,
  -4.53298882e-04f, -2.29708161e-02f, -1.07365921e-01f, -5.56903705e-02f, 3.26819383e-02f, 5.97056560e-03f, 3.88646163e-02f, 5.52534172e-03f, 2.16646105e-01f, -1.05294771e-02f,
  -2.75314674e-02f, 6.57561049e-02f, 2.68781513e-01f, 1.88301638e-01f, -6.46265596e-02f, -9.24450830e-02f, -8.38447362e-02f, -4.18207645e-02f, 1.45369917e-01f, -3.77420597e-02f,
  2.21434012e-01f, 2.18182698e-01f, -1.11248404e-01f, 2.15443633e-02f, 1.53475180e-01f, 2.71621998e-03f, 1.40614873e-02f, 1.26518413e-01f, -7.01059178e-02f, 2.29011513e-02f,
  -4.70168181e-02f, 1.95993453e-01f, 5.82308732e-02f, -1.60062790e-01f, 2.04339381e-02f, 1.30267352e-01f, -1.41356867e-02f, -6.55951276e-02f, -6.58636242e-02f, -1.25869825e-01f,
  -1.12720430e-01f, 1.89398497e-01f, 9.42269787e-02f, 3.70445885e-02f, 1.59887865e-01f, 1.25088736e-01f, 6.60780966e-02f, -5.84064387e-02f, 9.36459284e-03f, -1.42273933e-01f,
  -1.68901771e-01f, -3.26769724e-02f, 2.54801303e-01f, -1.42332420e-01f, -1.48945436e-01f, 3.37016508e-02f, -1.14282385e-01f, -6.06589802e-02f, -9.22749788e-02f, -1.17410600e-01f,
  7.18669966e-02f, -5.27292863e-02f, -4.47008163e-02f, -4.07363027e-02f, -8.50876942e-02f, 9.45844948e-02f, 6.76431283e-02f, -8.92416462e-02f, 2.21607342e-01f, -8.42833519e-02f,
  -9.02275667e-02f, 1.25576362e-01f, 2.34555230e-02f, 3.53905857e-02f, 8.50672871e-02f, -6.97743222e-02f, -1.06941819e-01f, -6.92122569e-03f, 1.36254594e-01f, 1.10821970e-01f,
  -2.39913519e-02f, -1.13894239e-01f, -1.46069884e-01f, -8.50399435e-02f, -5.40191606e-02f, -1.19529597e-01f, 6.34624511e-02f, -1.34028599e-01f, 7.94871897e-02f, -1.23143926e-01f,
  8.10053051e-02f, -1.51296109e-01f, -2.49470584e-04f, -3.59046012e-02f, 1.20255664e-01f, 8.80263224e-02f, 4.84767295e-02f, 8.32139477e-02f, -8.71093199e-02f, 2.64029186e-02f,
  -1.06850207e-01f, 5.10959560e-03f, -9.92822810e-04f, 1.19011857e-01f, -1.01911753e-01f, -2.75887325e-02f, -4.95724119e-02f, 1.85827702e-01f, -4.22298536e-02f, -5.41486405e-02f,
  6.52709324e-03f, 1.06867328e-01f, -2.11653680e-01f, 8.86791050e-02f, 6.03199936e-02f, 1.04595199e-01f, -2.61646626e-03f, -4.11414355e-03f, -3.27201188e-02f, 1.28444731e-01f,
  -6.54611737e-04f, 1.17108330e-01f, 1.30946347e-02f, 3.22553404e-02f, 9.66654643e-02f, -8.22611153e-02f, -7.48605579e-02f, -4.11340371e-02f, 2.35950816e-02f, 5.66676259e-03f,
  -1.26074702e-01f, 3.59554356e-03f, -1.02622034e-02f, 9.59027410e-02f, -9.58422273e-02f, -2.17269212e-02f, 6.47142231e-02f, 9.92699564e-02f, -8.80913436e-02f, -3.75738330e-02f,
  1.52499542e-01f, 5.34478426e-02f, -3.82326879e-02f, -1.65905282e-02f, -4.62891087e-02f, -7.86114018e-03f, -4.47316915e-02f, 4.01262045e-02f, 1.25613615e-01f, 3.23785059e-02f,
  2.74883211e-03f, -5.20979874e-02f, 5.13288677e-02f, -7.71811903e-02f, -9.73938257e-02f, 7.36103952e-02f, -1.23262726e-01f, -9.24247727e-02f, -1.13002896e-01f, 3.84962000e-02f,
  1.13760628e-01f, 5.00754975e-02f, -1.16949439e-01f, 1.57823816e-01f, 9.43302885e-02f, -9.35663134e-02f, -7.86315203e-02f, -2.72361934e-03f, 1.04485460e-01f, -6.41680062e-02f,
  2.58832555e-02f, 1.45349979e-01f, 1.19964547e-01f, -4.83611524e-02f, 6.69280738e-02f, 1.88586488e-01f, -1.68745115e-01f, 3.31807166e-01f, -4.32885215e-02f, 6.08192459e-02f,
  9.20299366e-02f, 1.00620322e-01f, -1.32523552e-01f, 1.95817649e-01f, 9.66762658e-03f, -1.47320136e-01f, -3.35231237e-02f, 8.05438161e-02f, 1.65360361e-01f, 1.80552140e-01f,
  -2.20456962e-02f, 1.09270170e-01f, -9.12958570e-03f, 4.63501103e-02f, 1.97746232e-01f, 8.16136003e-02f, 1.63327120e-02f, -4.81246710e-02f, -2.80955452e-02f, 1.37727084e-02f,
  2.88505219e-02f, 1.80700850e-02f, -5.19578606e-02f, -1.01366349e-01f, -7.92569146e-02f, 1.20860443e-01f, 2.09339947e-01f, -4.34332602e-02f, 7.87790492e-02f, -1.23264678e-01f,
  -1.12437569e-01f, 6.93875924e-02f, 7.31399432e-02f, 1.62655696e-01f, 1.31889850e-01f, -1.03290215e-01f, 1.24708958e-01f, -9.64250192e-02f, 3.25954556e-02f, -1.50474101e-01f,
  1.75780088e-01f, -8.81103501e-02f, 3.90884019e-02f, -7.97227547e-02f, 8.12286288e-02f, -1.49474755e-01f, 9.53899994e-02f, 3.51321220e-01f, 5.19955158e-02f, -1.84544511e-02f,
  1.52517110e-01f, -5.61243221e-02f, -1.05672270e-01f, 3.64586264e-02f, 1.52478278e-01f, 1.36088639e-01f, 7.59416074e-02f, 5.64465933e-02f, 1.19892284e-01f, 8.51683095e-02f,
  -1.61019862e-01f, 3.70498635e-02f, 2.20521376e-01f, 9.01153982e-02f, 8.10827985e-02f, -1.67066321e-01f, 2.76589650e-04f, -8.17725528e-03f, 1.11902572e-01f, -1.17537953e-01f,
  1.63541824e-01f, 4.79669794e-02f, -3.39097679e-02f, -8.94933492e-02f, -1.24986887e-01f, 6.10410981e-03f, -1.15199804e-01f, 1.91481024e-01f, 4.32390869e-02f, -4.73950431e-02f,
  -6.52976558e-02f, 3.68001945e-02f, 6.76804483e-02f, -9.80841592e-02f, 2.43886143e-01f, 1.23814210e-01f, -1.51926547e-01f, -1.06596813e-01f, 1.86220288e-01f, -2.97080837e-02f,
  7.88108911e-03f, 2.11268812e-02f, -2.58797314e-02f, 1.40593439e-01f, 1.96981162e-01f, -9.18291584e-02f, -1.76306851e-02f, 9.89649892e-02f, -1.25839800e-01f, -2.04376616e-02f,
  -5.74677326e-02f, 6.55529350e-02f, -6.24618940e-02f, 9.30726752e-02f, -2.50792410e-02f, -1.18430115e-01f, -4.55198251e-02f, 4.33647260e-02f, 1.38532475e-01f, 1.20689325e-01f,
  -1.86335277e-02f, -3.64291854e-02f, 8.54638368e-02f, -1.00356512e-01f, 1.93225946e-02f, -1.42360270e-01f, 6.64713532e-02f, -1.05588548e-02f, 1.63758278e-01f, 3.63385342e-02f,
  8.53325799e-02f, 1.24209955e-01f, -7.40380064e-02f, -1.30587947e-02f, -1.33406714e-01f, 1.62660107e-01f, 9.95711684e-02f, 8.97011161e-02f, -1.00133456e-01f, -1.94329470e-02f,
  -6.91085756e-02f, -9.79086310e-02f, 2.40448549e-01f, 1.21421590e-01f, 1.36998564e-01f, -2.20205542e-02f, -1.03171468e-02f, -7.29993880e-02f, 2.50696748e-01f, -1.48841843e-01f,
  1.06321283e-01f, 1.10024272e-03f, -9.15211961e-02f, -1.14809595e-01f, -1.14571191e-01f, 1.25803828e-01f, 1.03967398e-01f, -6.57221973e-02f, 2.74418712e-01f, 1.37455806e-01f,
  -8.64404961e-02f, 1.24596886e-01f, 1.00704372e-01f, -5.75936921e-02f, 1.43470690e-01f, 9.81847197e-02f, 1.27240065e-02f, -5.08208498e-02f, -2.31514983e-02f, 3.19075994e-02f,
  1.93781421e-01f, 1.38869956e-01f, 6.42300397e-02f, -8.44630823e-02f, 6.35452867e-02f, -9.69808400e-02f, 6.41229898e-02f, 1.26674861e-01f, 2.31550168e-02f, -9.23679397e-02f,
  1.47259340e-01f, -3.77183147e-02f, 1.85483351e-01f, -1.06274448e-01f, -1.48970053e-01f, -1.32795170e-01f, -6.11679554e-02f, 4.59695943e-02f, 8.31105933e-02f, 2.25007087e-02f,
  -8.02549068e-03f, -6.46003615e-03f, 2.94975843e-02f, 1.57648757e-01f, -1.20122330e-02f, 1.30180880e-01f, 9.79280472e-02f, 1.16343781e-01f, -1.07088231e-01f, -2.51311988e-01f,
  3.40832978e-01f, 2.71338373e-01f, 1.02719076e-01f, -2.49622583e-01f, 2.00341307e-02f, -8.49958360e-02f, 7.30291158e-02f, -1.80400796e-02f, 2.71665126e-01f, 3.92594896e-02f,
  1.78790614e-02f, -2.42684126e-01f, -1.81423306e-01f, -5.88173904e-02f, -2.13755853e-02f, 2.49146938e-01f, -1.86660498e-01f, -2.17533588e-01f, -1.00088648e-01f, 6.78468645e-02f,
  -9.69493985e-02f, -4.92208861e-02f, 2.68094033e-01f, -4.70289104e-02f, -1.64626151e-01f, 1.00052416e-01f, 2.68201917e-01f, 1.45790145e-01f, -8.70901495e-02f, -3.56452689e-02f,
  3.77513422e-03f, 6.34738728e-02f, 3.14695656e-01f, 5.68701923e-02f, 1.21029131e-02f, 9.67210606e-02f, -7.40753412e-02f, -1.37113228e-01f, 6.32140264e-02f, 1.20494016e-01f,
  -1.08670652e-01f, 2.12802663e-01f, -7.13334382e-02f, -3.24711427e-02f, -1.76857579e-02f, 5.15596149e-03f, 3.42788808e-02f, 1.28681228e-01f, 2.28590276e-02f, 9.51712281e-02f,
  1.25445696e-02f, -3.29491943e-02f, -8.65385011e-02f, -1.74148396e-01f, -3.89282145e-02f, -1.45024180e-01f, 1.34578764e-01f, 2.35379934e-02f, 1.20796068e-02f, -2.95369029e-02f,
  8.62145498e-02f, 1.33911997e-01f, -1.90462559e-01f, 2.26486638e-01f, -1.06176458e-01f, -3.49485800e-02f, -4.62585548e-03f, 4.42839079e-02f, 2.48959893e-03f, 5.10969125e-02f,
  -6.45602569e-02f, -3.34682986e-02f, 1.83800325e-01f, -2.34092157e-02f, -6.08323654e-03f, 3.07029840e-02f, -1.21241063e-01f, -4.32351753e-02f, -4.56940643e-02f, -1.39146313e-01f,
  1.18676238e-01f, 6.44606305e-03f, 5.07128648e-02f, -4.32795117e-04f, 1.19398825e-01f, -1.31924674e-01f, -1.07313938e-01f, 2.28686221e-02f, 8.12127814e-02f, 4.60545532e-02f,
  -2.81785820e-02f, 7.98048899e-02f, -3.57205570e-02f, 9.56198424e-02f, 1.01683803e-01f, -1.22465894e-01f, -1.29626974e-01f, -1.06420815e-01f, -1.01066791e-01f, 1.21438555e-01f,
  1.42738506e-01f, 1.11599885e-01f, 1.13130547e-01f, 1.06626093e-01f, -6.82945922e-02f, -5.93650527e-03f, 1.33660182e-01f, 5.32937013e-02f, 1.00817144e-01f, 8.13887492e-02f,
  5.97227039e-03f, 2.34569386e-02f, 2.13967770e-01f, 8.42858255e-02f, 1.52070075e-01f, -8.44128709e-03f, 6.16076551e-02f, -7.44320313e-03f, 5.30208647e-03f, -7.86484778e-02f,
  2.10948482e-01f, -6.52561570e-03f, 1.84057295e-01f, 9.99796987e-02f, 1.02035455e-01f, 2.01027483e-01f, 4.17770594e-02f, 9.30068269e-02f, -1.45878196e-01f, -1.79331228e-01f,
  -7.52514005e-02f, -1.50350094e-01f, -1.01605155e-01f, 1.42676726e-01f, -1.01749394e-02f, -6.92666546e-02f, 2.07794875e-01f, 1.33808032e-01f, 1.00746676e-01f, 6.03396669e-02f,
  -7.93607533e-02f, 2.45019719e-01f, 9.72909480e-02f, -2.95946509e-01f, -2.14374494e-02f, -6.49276823e-02f, 1.19832918e-01f, 5.64441681e-02f, -7.88467675e-02f, 2.34213024e-02f,
  -9.24799964e-03f, 6.78556506e-03f, -4.63090651e-02f, 1.83125719e-01f, 2.42170095e-01f, 4.64024842e-02f, -5.03651313e-02f, -1.07201636e-01f, 1.58982590e-01f, 4.46967557e-02f,
  -6.81028515e-03f, -1.30267099e-01f, -2.71466803e-02f, 1.33541510e-01f, 4.46841456e-02f, 1.40294001e-01f, -1.21131048e-01f, -1.11911602e-01f, 1.33753940e-01f, 1.19064234e-01f,
  2.57880360e-01f, 9.24224630e-02f, -1.09296199e-02f, 1.96637735e-01f, 3.20108086e-01f, 1.95338532e-01f, 2.69467235e-01f, 3.47245872e-01f, 2.77735875e-03f, 1.68984011e-02f,
  -1.33324564e-01f, -5.70079312e-02f, -3.88631709e-02f, 9.30627808e-02f, 1.50970936e-01f, 1.85209334e-01f, 6.40921369e-02f, 1.45617232e-01f, 6.11163341e-02f, 9.46566835e-02f,
  -1.05387950e-02f, -1.40854582e-01f, 4.24615443e-02f, -3.10389362e-02f, -2.30981678e-01f, 1.09869450e-01f, 1.19557464e-03f, -9.37614441e-02f, 1.59085821e-02f, 4.03078385e-02f,
  -7.63908029e-03f, -7.98370466e-02f, -7.93195590e-02f, -6.97198212e-02f, 3.38799506e-02f, 2.16801465e-02f, 2.03935891e-01f, 1.63919017e-01f, -4.99946773e-02f, 1.06636725e-01f,
  -1.22285567e-01f, 5.59411906e-02f, -6.43881261e-02f, -1.32943932e-02f, 2.19537854e-01f, 2.27401197e-01f, -5.74388616e-02f, 8.19187164e-02f, 7.61584193e-02f, -1.67169981e-02f,
  -1.09636173e-01f, 3.47503200e-02f, 2.08778530e-02f, -5.57849891e-02f, 1.95423856e-01f, 4.39645797e-02f, 9.37225521e-02f, -3.20264921e-02f, -8.58274326e-02f, 2.48697512e-02f,
  -1.13814019e-01f, 1.27581000e-01f, 5.24778143e-02f, 5.05618826e-02f, -8.68894085e-02f, 1.27330720e-01f, -9.29431915e-02f, 1.18587874e-01f, 2.11264908e-01f, -2.95223705e-02f,
  1.31945178e-01f, -6.72722012e-02f, 8.20747912e-02f, -3.55055369e-02f, 7.53768068e-03f, -1.58298593e-02f, 1.56632349e-01f, 1.34483367e-01f, 5.27109392e-02f, -3.27531323e-02f,
  1.06544532e-01f, 1.23930708e-01f, 1.41619204e-03f, 3.29620726e-02f, -8.21363926e-02f, 2.20360339e-01f, -1.92198921e-02f, -4.98128496e-02f, -1.67845145e-01f, 8.09467584e-02f,
  1.74004316e-01f, -7.94717968e-02f, 1.46594271e-01f, 8.22974145e-02f, 2.97112763e-01f, 3.97032090e-02f, -1.17426038e-01f, -8.26707855e-02f, 1.15880407e-01f, 1.43061578e-01f,
  1.33758998e-02f, 8.07370245e-02f, 1.33311525e-01f, -1.24376550e-01f, -3.33746411e-02f, 1.36966869e-01f, 3.60177495e-02f, -4.65478338e-02f, 9.93840620e-02f, -2.13805889e-03f,
  -3.84236984e-02f, -1.13416046e-01f, -8.17394927e-02f, -9.87278745e-02f, 7.50282183e-02f, -1.39600728e-02f, 4.36248295e-02f, -1.48245558e-01f, -2.65200268e-02f, -1.04229413e-01f,
  -8.80912319e-02f, -5.06478995e-02f, 1.30108118e-01f, 1.11825794e-01f, -4.58163433e-02f, 4.80874144e-02f, -5.42852506e-02f, -1.56770758e-02f, 2.42687881e-01f, -9.68865007e-02f,
  5.11068590e-02f, -2.41933502e-02f, 5.28733023e-02f, -3.96408923e-02f, 1.93483561e-01f, 1.41569702e-02f, 3.04289889e-02f, 1.94939505e-02f, -8.55377987e-02f, 3.81932519e-02f,
  7.66186416e-02f, 7.09781200e-02f, 1.69367790e-01f, 1.59683868e-01f, 1.85319990e-01f, 8.31043255e-03f, -1.11444652e-01f, -5.03245108e-02f, -5.52438162e-02f, -3.79495993e-02f,
  -9.11929011e-02f, 2.37673268e-01f, 2.25446880e-01f, 3.27606648e-02f, 6.70029148e-02f, 9.11776051e-02f, -6.78229779e-02f, 8.31332654e-02f, 8.28712061e-02f, -4.41855714e-02f,
  1.39916241e-01f, -1.59097582e-01f, -5.04487976e-02f, 9.88533348e-02f, 1.16413184e-01f, 2.31414512e-01f, -7.44245276e-02f, 8.42371657e-02f, -3.87784764e-02f, -8.75074565e-02f,
  -5.60615212e-02f, -1.08654484e-01f, 1.61189675e-01f, 8.22478235e-02f, 4.65621836e-02f, -1.01345509e-01f, 1.09229833e-01f, 1.80925474e-01f, 1.33785725e-01f, 1.09563969e-01f,
  2.08889693e-02f, -2.64651608e-02f, 3.30689326e-02f, 9.11704171e-03f, -1.16790542e-02f, 6.12121215e-03f, -1.28176495e-01f, -1.04514495e-01f, -2.26031002e-02f, 8.88953209e-02f,
  2.49446958e-01f, -1.36336163e-01f, 1.54121488e-01f, -7.29489774e-02f, 4.11188714e-02f, 4.20708507e-02f, 6.34976029e-02f, 1.28502667e-01f, -1.81026489e-01f, 2.30023369e-01f,
  8.46219063e-02f, -7.34438375e-02f, 9.21153724e-02f, -8.71014968e-02f, -3.48947197e-02f, 1.95765123e-02f, 2.75393762e-02f, 3.40364724e-02f, 1.32020563e-01f, -7.47764111e-02f,
  2.26785075e-02f, 8.15350488e-02f, 5.29371500e-02f, 1.46198571e-01f, -7.12725744e-02f, -1.47682428e-02f, -1.75939247e-01f, 3.15078720e-02f, -4.89943253e-04f, -1.26656011e-01f,
  -6.70439452e-02f, -4.15855087e-02f, 1.84477448e-01f, -2.14433409e-02f, -9.52895284e-02f, 7.28745535e-02f, -1.76608581e-02f, -4.71544899e-02f, -3.22735794e-02f, 9.15831421e-03f,
  7.51307905e-02f, -8.88124853e-02f, 4.87262197e-02f, 9.32916254e-02f, 1.25207631e-02f, -8.04136097e-02f, 5.24180271e-02f, -6.39062896e-02f, -5.66689484e-02f, 4.22801152e-02f,
  -7.80765787e-02f, -8.67430307e-03f, -1.82762351e-02f, 1.01704393e-02f, -1.05363697e-01f, 1.16266571e-02f, -9.13864449e-02f, -9.27969143e-02f, 1.32355827e-03f, -3.24275829e-02f,
  7.25373486e-03f, 1.15805306e-01f, -1.26565903e-01f, 3.83088030e-02f, -1.04866512e-01f, 4.49783169e-02f, 9.00306851e-02f, -3.43583599e-02f, 8.62771198e-02f, 4.26894017e-02f,
  5.12086190e-02f, 4.35095429e-02f, 2.03165829e-01f, -6.77540675e-02f, 9.97509137e-02f, -2.15503145e-02f, -5.72874360e-02f, -8.74564871e-02f, -3.44543085e-02f, -3.07140611e-02f,
  8.57387856e-02f, -6.53412985e-03f, -8.97867791e-03f, -5.08987643e-02f, 3.45327519e-02f, 1.41177222e-01f, 1.35797799e-01f, -1.69533819e-01f, -5.52644841e-02f, 5.82442842e-02f,
  -7.79210180e-02f, -1.21040888e-01f, 1.11470491e-01f, 7.59175569e-02f, -2.80312970e-02f, -8.96444917e-02f, 1.57509685e-01f, -4.63109687e-02f, -4.92900982e-02f, -1.35962769e-01f,
  8.42321590e-02f, 9.74348262e-02f, -1.00610301e-01f, -7.58372471e-02f, -2.07449985e-03f, -8.84472430e-02f, 7.40076676e-02f, 7.52550811e-02f, 1.10964745e-01f, -4.67086211e-03f,
  6.36919141e-02f, -1.99129507e-02f, 1.00957543e-01f, -4.20631059e-02f, -9.77774858e-02f, 4.66940850e-02f, 6.18576817e-02f, -6.86707124e-02f, -5.06188311e-02f, 3.94032616e-03f,
  -9.06132385e-02f, -1.22578353e-01f, 1.61205195e-02f, -6.14668690e-02f, 2.75859199e-02f, 2.45950483e-02f, -1.23355061e-01f, -1.06253684e-01f, -1.09564446e-01f, 8.38222504e-02f,
  1.18673615e-01f, -6.37160614e-02f, -1.40031114e-01f, -3.14572416e-02f, 1.18270107e-01f, 2.69565601e-02f, -3.12794410e-02f, -9.62309763e-02f, -7.30377110e-03f, -4.32107933e-02f,
  9.12969336e-02f, -7.56601244e-02f, -2.03174795e-03f, -2.92629823e-02f, 6.10695630e-02f, 1.81885958e-01f, -7.35858455e-02f, 9.64222923e-02f, -3.10541652e-02f, -5.15322387e-02f,
  8.85404367e-03f, -8.09280127e-02f, 1.55725047e-01f, 1.81655288e-02f, -1.16419476e-02f, -1.24662921e-01f, -9.56116244e-02f, -6.59313723e-02f, 5.04537486e-03f, -1.16448283e-01f,
  8.03133324e-02f, -1.31014073e-02f, 3.41745932e-03f, 9.11320224e-02f, -9.27556828e-02f, -6.49445504e-02f, -1.41072303e-01f, 1.07059062e-01f, -1.11250959e-01f, -9.20209382e-03f,
  -1.13032512e-01f, -1.12551279e-01f, -4.35406454e-02f, -7.58111998e-02f, 7.11359233e-02f, 1.23466313e-01f, -1.32053614e-01f, -9.20404941e-02f, 4.85292748e-02f, 1.33505151e-01f,
  8.47044215e-02f, -6.97935894e-02f, 1.38518130e-02f, -8.37046504e-02f, 1.64112702e-01f, 1.06209509e-01f, -4.63245884e-02f, 3.19145806e-02f, 1.12772426e-02f, 1.19248860e-01f,
  2.79461648e-02f, -2.18122303e-02f, -6.02969080e-02f, 9.45685282e-02f, -1.47227302e-01f, -7.34895244e-02f, 7.52348155e-02f, 6.03203587e-02f, 5.34836762e-03f, 1.29170179e-01f,
  1.83303114e-02f, 2.88562812e-02f, -1.19073778e-01f, -8.01620781e-02f, 5.64648621e-02f, -5.49557619e-02f, -6.95237592e-02f, 2.22596098e-02f, -8.20719525e-02f, 1.92015488e-02f,
  8.66191536e-02f, 1.41932145e-01f, 4.68227081e-03f, 4.54341620e-02f, -5.59490360e-02f, -8.58759582e-02f, -7.74369016e-02f, 5.44129685e-02f, 1.40005693e-01f, 9.71705765e-02f,
  -1.22267075e-01f, 1.96286052e-01f, 6.64899573e-02f, 8.77090618e-02f, -1.36186823e-01f, 9.59343016e-02f, 2.10540090e-02f, 1.18767910e-01f, 3.38742539e-04f, 7.31062144e-02f,
  9.99109261e-03f, -5.72461896e-02f, -6.65536076e-02f, 1.42280713e-01f, -4.65008467e-02f, 2.52762232e-02f, -1.07895091e-01f, -8.27074945e-02f, -1.25689909e-01f, 1.75953377e-02f,
  1.31018698e-01f, -8.80739540e-02f, 3.64867374e-02f, -9.10395756e-02f, -1.13940232e-01f, -6.94940388e-02f, -6.63021803e-02f, -4.62890090e-03f, -1.12974033e-01f, -3.54065262e-02f,
  6.23161979e-02f, 1.08126424e-01f, -5.64822406e-02f, 9.78628453e-03f, -9.13883373e-03f, -6.05025403e-02f, -6.28315359e-02f, 4.47179116e-02f, 4.14431933e-03f, -5.52172922e-02f,
  -5.35675324e-02f, -1.41202807e-01f, 9.68909543e-03f, -1.29598841e-01f, 2.12303847e-02f, -1.22745866e-02f, -2.47214604e-02f, -9.32174772e-02f, 2.03985602e-01f, -8.99721980e-02f,
  9.75004509e-02f, -1.30622521e-01f, 6.55593276e-02f, -8.07391331e-02f, -2.52729822e-02f, 1.20353691e-01f, -3.51762995e-02f, -1.81795470e-03f, 9.89108756e-02f, 6.16672784e-02f,
  1.90341268e-02f, -6.21297210e-02f, -3.32205221e-02f, 1.45818815e-01f, -4.13827635e-02f, 4.69515547e-02f, 2.75839549e-02f, 9.09036845e-02f, -5.45621440e-02f, 3.57861109e-02f,
  2.07068399e-02f, -1.29969027e-02f, -1.23428904e-01f, -1.20147541e-01f, 7.70385638e-02f, -6.47297576e-02f, -1.64445024e-02f, 1.74597166e-02f, 5.13790734e-02f, 6.81383759e-02f,
  -1.24373518e-01f, -7.82029182e-02f, 1.21151462e-01f, -9.62771177e-02f, -9.90347639e-02f, 5.51684350e-02f, -1.38827711e-01f, 5.15374579e-02f, 3.24764252e-02f, 7.65673593e-02f,
  -6.25841469e-02f, 1.18776008e-01f, -8.84937644e-02f, -3.10633704e-02f, -1.38868000e-02f, -4.68232110e-02f, 1.13735370e-01f, -8.89093354e-02f, -1.09730475e-01f, 5.94443493e-02f,
  -8.94841403e-02f, -1.12999223e-01f, -8.89767557e-02f, 1.03214383e-01f, -2.97465138e-02f, -2.63139736e-02f, 2.41392851e-02f, 2.24767998e-02f, -3.62599120e-02f, -4.20354605e-02f,
  -8.78530741e-02f, 2.29865890e-02f, -1.03064822e-02f, -1.20014541e-01f, 8.22359845e-02f, 2.97510810e-03f, 1.06758751e-01f, 6.00460209e-02f, 1.61276273e-02f, 2.50435084e-01f,
  1.67293623e-01f, 2.20477119e-01f, -3.00559681e-02f, -3.42922322e-02f, 5.51732741e-02f, 1.09311700e-01f, 2.30615422e-01f, -2.08620653e-01f, -1.14062227e-01f, 1.62758559e-01f,
  -4.56238501e-02f, -1.08127184e-01f, -5.95338941e-02f, 1.50400877e-01f, 2.20175579e-01f, 2.22022653e-01f, -1.14967778e-01f, -6.64277747e-02f, -1.48576021e-01f, -1.65552348e-01f,
  -6.79983422e-02f, -2.43705343e-02f, 1.36585981e-01f, 1.15136549e-01f, -6.07932769e-02f, 1.31226525e-01f, -8.51314068e-02f, -8.19552392e-02f, -1.24878408e-02f, 3.91013846e-02f,
  2.43930042e-01f, 1.71664834e-01f, -7.62195066e-02f, 1.14690676e-01f, 1.17592134e-01f, -1.46711007e-01f, -1.84258506e-01f, 8.48223493e-02f, 1.38885528e-01f, 4.46095541e-02f,
  8.13950822e-02f, 3.04065831e-02f, -6.12098873e-02f, -1.37284458e-01f, 1.54286146e-01f, 7.23619759e-02f, -5.21783903e-02f, 1.49613932e-01f, 1.02151565e-01f, 1.71667486e-01f,
  6.36724308e-02f, 9.17611457e-03f, -9.10992324e-02f, 2.80046284e-01f, 5.44890389e-02f, -9.21015814e-02f, -6.52908310e-02f, 8.84245038e-02f, -9.25652310e-02f, 7.71896914e-02f,
  3.99128757e-02f, 1.67921275e-01f, 1.69117033e-01f, 1.56615913e-01f, 4.23541963e-02f, -8.03603008e-02f, -3.37010995e-02f, -3.27582657e-02f, -1.17557146e-01f, -1.74528494e-01f,
  1.74450636e-01f, -1.01279272e-02f, -6.23897538e-02f, 1.27998237e-02f, 3.48524898e-02f, 3.08508184e-02f, -6.40815496e-02f, -1.47099188e-03f, 6.30088001e-02f, 1.27349004e-01f,
  -1.73205789e-02f, 1.35695592e-01f, -1.38968490e-02f, -1.18401237e-01f, 7.35136345e-02f, 6.31357655e-02f, 2.40882382e-01f, 8.87458399e-02f, 4.95108776e-02f, -6.57156557e-02f,
  -3.73937860e-02f, -1.30413920e-01f, 1.38411418e-01f, -2.86563765e-02f, 1.40139490e-01f, 8.20809528e-02f, -1.01995490e-01f, -1.06347045e-02f, 1.32413611e-01f, -1.48333207e-01f,
  -1.47328436e-01f, -1.14725837e-02f, -1.07442521e-01f, 1.05481826e-01f, -1.06418043e-01f, -6.83800578e-02f, -7.84897134e-02f, 3.83073045e-03f, 6.90004751e-02f, 1.98986866e-02f,
  1.06120594e-01f, 1.24310739e-01f, -7.17221349e-02f, 1.82734400e-01f, -6.65420368e-02f, 1.65793329e-01f, 1.32920042e-01f, 1.15158990e-01f, -8.93041939e-02f, 5.74363805e-02f,
  -8.87971073e-02f, 5.38144633e-02f, 8.26373324e-03f, 9.99050960e-02f, 2.05110788e-01f, 2.76458740e-01f, 2.23972768e-01f, 8.19623396e-02f, 2.85972685e-01f, 2.27943704e-01f,
  -1.20734476e-01f, 2.53411680e-01f, 2.07138747e-01f, -9.68741104e-02f, -2.58177906e-01f, 2.63868511e-01f, 4.23810408e-02f, 8.32745582e-02f, -8.29855204e-02f, -1.06741622e-01f,
  1.99662089e-01f, -1.10539526e-01f, -1.11886980e-02f, 1.58011094e-01f, -1.44074306e-01f, 5.55912666e-02f, -1.19550899e-01f, -7.32231289e-02f, 1.99976087e-01f, -7.18765631e-02f,
  -2.55244356e-02f, 5.16091436e-02f, -3.38858292e-02f, -5.89792803e-02f, 1.72043398e-01f, -4.87530092e-03f, 1.04179420e-01f, -1.92558363e-01f, 2.19276905e-01f, 1.63623989e-01f,
  -7.95802027e-02f, -1.43702075e-01f, -7.79146925e-02f, -1.84582010e-01f, -1.89267434e-02f, -8.12741518e-02f, 1.32685870e-01f, 1.28997996e-01f, -3.00473440e-02f, 1.38806984e-01f,
  -4.42253463e-02f, -5.62743992e-02f, -5.25740033e-04f, 8.85413587e-02f, -9.14493427e-02f, -4.37461250e-02f, 7.63462856e-02f, -8.32639933e-02f, -5.05972933e-03f, -8.29115137e-02f,
  1.07203424e-01f, -6.04389645e-02f, 1.18692458e-01f, -1.56002939e-01f, 1.76959947e-01f, -1.40381634e-01f, 1.85546856e-02f, 3.70238237e-02f, -7.06719756e-02f, -7.31884688e-02f,
  -1.01747893e-01f, 1.29831180e-01f, -2.84083933e-02f, 5.86357825e-02f, -5.24649732e-02f, 1.12574592e-01f, 4.38871235e-02f, 9.39562991e-02f, 1.10209383e-01f, -7.52219856e-02f,
  1.11688346e-01f, 1.18039474e-01f, -5.86182289e-02f, -8.18046406e-02f, 9.84664857e-02f, -4.61656600e-02f, 6.76229224e-02f, 6.02309965e-02f, 1.12764142e-01f, -1.27653684e-02f,
  -1.13454811e-01f, -1.53831169e-01f, -3.59184705e-02f, -1.03914842e-01f, 1.01138644e-01f, 7.04916418e-02f, 8.23344067e-02f, -4.56400067e-02f, 7.99348056e-02f, -3.46004926e-02f,
  -5.31264432e-02f, 2.32104138e-02f, -9.30409208e-02f, -4.16880064e-02f, -7.95765966e-02f, -5.15583083e-02f, -3.14007588e-02f, 4.83157076e-02f, 7.88487345e-02f, -6.40451908e-02f,
  -8.58998820e-02f, 3.29695293e-03f, -1.14234582e-01f, -7.19102249e-02f, -5.94581813e-02f, 5.60241006e-02f, 1.00018032e-01f, -6.68096840e-02f, -2.54062265e-02f, 1.67390108e-02f,
  -5.68113141e-02f, 6.69653341e-02f, -4.54312488e-02f, -8.13735127e-02f, -3.09775956e-02f, -9.11731943e-02f, -3.45815495e-02f, -1.28406473e-02f, -8.98935869e-02f, 9.21487287e-02f,
  5.28624654e-02f, 1.01180851e-01f, -1.26430511e-01f, -9.89420861e-02f, 6.89380541e-02f, -9.72332619e-03f, 1.21394128e-01f, -9.13683996e-02f, -1.09904455e-02f, -6.94473013e-02f,
  -7.72988573e-02f, 1.02423243e-02f, 1.12400614e-01f, 1.25854269e-01f, -2.97440384e-02f, -1.15171991e-01f, -3.43134701e-02f, -7.81759545e-02f, 1.22100621e-01f, -4.29983065e-02f,
  -1.13881588e-01f, -1.16520179e-02f, 4.18100171e-02f, 4.13910374e-02f, -9.42644849e-02f, -5.38856164e-02f, -1.22838526e-03f, -5.27184866e-02f, -4.77775633e-02f, -6.51121838e-03f,
  -1.44987870e-02f, 4.23492678e-02f, -1.58219486e-02f, -9.71325189e-02f, -5.78306541e-02f, 1.23200081e-01f, -1.18514687e-01f, -3.17933299e-02f, 9.93826799e-03f, -9.55148786e-02f,
  1.21745810e-01f, 3.66045795e-02f, 1.62847694e-02f, 5.13285622e-02f, 1.72120817e-02f, 8.63568857e-02f, 3.81762860e-03f, -4.56381068e-02f, 4.03319821e-02f, 5.83753102e-02f,
  1.01962738e-01f, -7.09211081e-02f, -3.25701572e-02f, -1.18298270e-01f, 5.97841628e-02f, -2.68971790e-02f, 4.98972088e-02f, -1.00490920e-01f, 1.15083894e-02f, -9.30964872e-02f,
  -8.40119347e-02f, 2.00674660e-03f, -9.79534686e-02f, 6.02021907e-03f, 2.10162047e-02f, -1.07346699e-01f, -2.00405139e-02f, 3.79910208e-02f, 9.00827944e-02f, 1.41468540e-01f,
  1.11942194e-01f, -3.31568196e-02f, -9.05895606e-02f, -3.40119600e-02f, 2.82049514e-02f, 1.04074977e-01f, -2.15838309e-02f, 7.46791884e-02f, 3.95074673e-02f, -1.22036591e-01f,
  8.78181979e-02f, 5.06378226e-02f, -4.20223288e-02f, 1.21062860e-01f, -2.10411847e-02f, 9.46615189e-02f, 3.19489054e-02f, -8.30588415e-02f, -3.53066325e-02f, -8.93505216e-02f,
  4.68281796e-03f, 2.86303628e-02f, 1.63138248e-02f, 2.82744355e-02f, -4.82702442e-03f, 6.82708696e-02f, -2.25067046e-02f, -5.28655574e-02f, 6.68814331e-02f, 2.69470345e-02f,
  2.80120149e-02f, 5.90068772e-02f, -8.27240944e-02f, -1.17292687e-01f, -9.72523838e-02f, 1.08421728e-01f, 1.21278837e-01f, -1.13286218e-02f, 4.50349003e-02f, -3.39291207e-02f,
  9.99066606e-02f, -1.12527953e-02f, -1.21682964e-01f, -3.10748741e-02f, 1.02603130e-01f, 2.32385509e-02f, 8.12152624e-02f, 1.10210530e-01f, -9.28585976e-02f, 3.41923982e-02f,
  -3.21891941e-02f, -8.83798227e-02f, -4.39866856e-02f, -1.03475884e-01f, -1.05555288e-01f, -5.64373583e-02f, 1.31693557e-01f, -3.64420302e-02f, -1.14706010e-01f, 6.32629320e-02f,
  1.71475962e-01f, 1.26574785e-01f, 9.68113095e-02f, -1.15533536e-02f, 3.27379405e-02f, 1.01407714e-01f, -9.80924740e-02f, 2.75752664e-01f, -2.44867995e-01f, -7.21732900e-02f,
  -1.87156871e-01f, 1.63402185e-01f, 4.50202748e-02f, 4.53108735e-02f, 2.02462271e-01f, 4.26125266e-02f, -8.70620236e-02f, -1.26984358e-01f, -1.18450575e-01f, 8.17831606e-02f,
  1.51189461e-01f, -1.87352955e-01f, 3.00407052e-01f, -4.46592942e-02f, 5.47361076e-02f, 1.62400082e-01f, 5.13278097e-02f, 1.11807823e-01f, -8.21083970e-03f, -6.12500347e-02f,
  1.52671933e-01f, 1.74543962e-01f, 6.80580214e-02f, 3.89644578e-02f, 1.12877779e-01f, -1.08717844e-01f, 8.81626159e-02f, 1.88906081e-02f, 2.60620099e-02f, -8.39306116e-02f,
  1.01467796e-01f, 5.04832007e-02f, 2.25243568e-01f, -6.02296442e-02f, 6.38084635e-02f, 1.02612421e-01f, -1.19147412e-01f, -6.05425164e-02f, -4.61562946e-02f, -1.29373008e-02f,
  1.46672115e-01f, -8.77005421e-03f, 1.73614472e-01f, 8.22612047e-02f, 1.20747231e-01f, -1.59532994e-01f, -1.03456095e-01f, 2.56548496e-03f, 1.11920111e-01f, -6.90618157e-02f,
  -3.58358584e-02f, -4.45861109e-02f, -8.44272301e-02f, 1.21523272e-02f, -2.50552166e-02f, 7.93714449e-02f, -2.22341791e-02f, 1.56027824e-01f, 4.65154648e-02f, -4.92060557e-02f,
  1.42633691e-01f, 5.80472639e-03f, -3.80520895e-02f, -1.37709364e-01f, -7.62538165e-02f, -7.39889815e-02f, -3.19903642e-02f, -9.63382050e-02f, 5.76650463e-02f, -1.11502759e-01f,
  5.60318567e-02f, -1.17547587e-02f, -2.79732551e-02f, 8.23416039e-02f, -6.78243414e-02f, -5.93183301e-02f, -1.22769505e-01f, -1.02077454e-01f, 1.34677067e-01f, -2.24800333e-02f,
  1.36353537e-01f, -1.04266316e-01f, -5.45121916e-02f, 2.03543785e-03f, 3.07923164e-02f, 5.25106266e-02f, -1.26101566e-03f, -1.15908124e-01f, -4.21003290e-02f, -3.32488902e-02f,
  3.06981761e-04f, 5.04294373e-02f, -8.80675986e-02f, -5.46522625e-02f, 5.27142659e-02f, 8.56374502e-02f, 1.69263352e-02f, 5.91446422e-02f, 5.98259680e-02f, 1.46841139e-01f,
  8.69852863e-03f, 9.60976332e-02f, -1.02546066e-01f, -2.85341628e-02f, 2.89767087e-02f, 5.02219759e-02f, -1.20546579e-01f, 4.63329628e-02f, 1.33662507e-01f, -8.59108642e-02f,
  1.70974925e-01f, -6.70847893e-02f, 5.28377965e-02f, -1.04123741e-01f, 1.28488680e-02f, -9.36736241e-02f, 7.90623277e-02f, 1.12402283e-01f, -8.00304115e-02f, -6.97127879e-02f,
  6.97263852e-02f, -8.65377411e-02f, -5.95371835e-02f, -5.26849926e-02f, 5.02908453e-02f, 3.96446250e-02f, 1.53555383e-03f, 7.02684298e-02f, -3.60227935e-02f, 6.39066324e-02f,
  8.38429853e-02f, -7.27529675e-02f, -9.00822412e-03f, -6.38488531e-02f, 5.81826083e-02f, -3.40721719e-02f, -1.16986170e-01f, -1.14671379e-01f, -1.46837860e-01f, 2.94798817e-02f,
  9.69222784e-02f, 1.38003808e-02f, -8.40732828e-02f, -1.32870600e-01f, -9.89440382e-02f, 1.84827428e-02f, -6.53922334e-02f, 2.92489994e-02f, 3.70914936e-02f, -6.02167100e-03f,
  -4.36974019e-02f, -7.61611899e-03f, 1.78050101e-01f, 9.34651792e-02f, -9.96216089e-02f, 3.31417687e-04f, 3.47156338e-02f, 8.70194584e-02f, -7.11533204e-02f, 8.97367820e-02f,
  -1.47771258e-02f, -1.52307004e-02f, -7.64924809e-02f, -9.20278728e-02f, 6.78031072e-02f, -9.03463811e-02f, 4.51875851e-02f, -5.25101498e-02f, -3.33930105e-02f, 4.62596342e-02f,
  7.91732222e-02f, 1.63278461e-01f, 1.19182818e-01f, -5.17960563e-02f, 3.52073759e-02f, 1.57288179e-01f, -1.99014880e-02f, -1.01075331e-02f, -6.88301399e-02f, -7.91256200e-04f,
  3.19848992e-02f, -8.45149383e-02f, 5.35378531e-02f, -8.76883566e-02f, 7.22970366e-02f, 1.94697827e-02f, 5.32042868e-02f, 8.88025910e-02f, 1.30556256e-01f, -1.66731745e-01f,
  7.17065856e-02f, 5.89995198e-02f, 4.12465669e-02f, 6.91483021e-02f, -1.06290124e-01f, 9.03914943e-02f, 1.01759538e-01f, -9.80412681e-03f, -2.71287076e-02f, 2.62592100e-02f,
  1.33419901e-01f, -1.68925636e-02f, -7.05636963e-02f, 1.61915214e-03f, 1.21534141e-02f, 1.06141008e-01f, -7.87967518e-02f, -9.57797244e-02f, 1.45969927e-01f, -1.48952473e-02f,
  3.28784809e-02f, -1.01715140e-01f, 6.41492754e-02f, -6.48389608e-02f, -9.31417868e-02f, -2.42693955e-03f, -9.26001519e-02f, -1.17927659e-02f, 1.00611873e-01f, -4.90653105e-02f,
  8.39758962e-02f, -4.70533594e-03f, -1.32195838e-02f, -8.40446651e-02f, -1.21652730e-01f, -6.36043102e-02f, 1.09500803e-01f, 3.03827543e-02f, -6.80871680e-02f, -5.77348620e-02f,
  -3.50700989e-02f, 8.57238322e-02f, -2.08002776e-02f, 1.07500106e-01f, -1.87505428e-02f, 2.23548785e-02f, 1.73352465e-01f, 1.36628002e-01f, 1.05230428e-01f, 7.24587590e-02f,
  -1.40829384e-01f, -3.41897421e-02f, -4.32436056e-02f, 1.25317052e-01f, -9.21635330e-02f, -1.19355887e-01f, 1.54841051e-01f, -4.31953371e-02f, 2.09634587e-01f, 1.88109159e-01f,
  2.03342840e-01f, 8.26369449e-02f, 2.90965796e-01f, -2.96401009e-02f, -6.26963452e-02f, -3.32959108e-02f, -2.51498781e-02f, -7.53887668e-02f, -7.38092661e-02f, -1.17700487e-01f,
  7.57768750e-02f, -2.24599685e-03f, -1.44082397e-01f, -4.73101847e-02f, -9.78132784e-02f, 9.90597648e-04f, 1.72718838e-01f, 1.23400435e-01f, 6.39589429e-02f, 1.91870287e-01f,
  8.76583159e-03f, 1.23912588e-01f, 1.03299066e-01f, 4.54838462e-02f, -1.12070749e-02f, -4.99894768e-02f, -3.62076871e-02f, 5.21352179e-02f, -5.86332269e-02f, -2.82052322e-03f,
  -1.75118133e-01f, -8.47192705e-02f, 1.03542325e-03f, -5.41697964e-02f, -1.00884564e-01f, 1.57701746e-01f, -3.98754254e-02f, 5.56655042e-02f, -7.82990158e-02f, 6.14250377e-02f,
  7.86729977e-02f, 1.64156824e-01f, -9.58096310e-02f, 8.11491311e-02f, 1.64462984e-01f, -4.41083610e-02f, 1.51218489e-01f, -6.71666786e-02f, 4.43765447e-02f, 9.11089256e-02f,
  4.60472889e-02f, 2.06592634e-01f, 1.42957538e-01f, -1.12533227e-01f, 1.49575531e-01f, 1.02877237e-01f, 1.48567408e-01f, 1.09442294e-01f, -5.10771945e-03f, 4.81634215e-02f,
  -7.74458721e-02f, -7.84388483e-02f, 3.19019109e-02f, -6.82456493e-02f, 6.02720194e-02f, -4.03679311e-02f, 1.41765863e-01f, 1.38402030e-01f, 4.41903956e-02f, -1.33132726e-01f,
  -5.50395884e-02f, 1.22951530e-01f, -6.80486485e-02f, 1.21240869e-01f, 6.13940507e-03f, -3.62617448e-02f, -3.12677845e-02f, -1.27642944e-01f, -2.93729473e-02f, -7.51205683e-02f,
  6.55733198e-02f, 3.97840068e-02f, 1.55144604e-02f, 5.32803684e-02f, 2.16418989e-02f, -5.03725596e-02f, 6.35145456e-02f, -4.40507643e-02f, 7.50445649e-02f, -1.05925970e-01f,
  1.68745201e-02f, 1.28347754e-01f, 1.22010894e-01f, 5.19790351e-02f, 8.84594843e-02f, -6.14579162e-03f, 9.05834511e-02f, -8.69335234e-02f, 8.86131823e-02f, -9.87152532e-02f,
  6.69076294e-02f, -1.50506441e-02f, 3.33136097e-02f, 9.41874236e-02f, 6.21728599e-03f, 3.68472338e-02f, 3.92732136e-02f, 1.33949015e-02f, -2.99565657e-03f, -6.32900596e-02f,
  1.11272760e-01f, 6.84632361e-02f, 8.08790848e-02f, 2.77853701e-02f, 1.28014296e-01f, 5.20457104e-02f, -1.42590767e-02f, -2.65697949e-02f, 1.13720715e-01f, -2.50665247e-02f,
  -2.07500570e-02f, 1.11226968e-01f, 9.58067551e-02f, 3.33837345e-02f, 1.47021994e-01f, -4.42904346e-02f, 1.55000702e-01f, 1.42549381e-01f, -5.79813458e-02f, 1.54391482e-01f,
  1.44255042e-04f, -3.43885794e-02f, -1.34485200e-01f, 8.75959918e-02f, 1.79963052e-01f, -1.67832702e-01f, -1.15525447e-01f, 2.12364361e-01f, -9.10888389e-02f, 9.61127132e-02f,
  8.36370811e-02f, 1.34090543e-01f, 1.25487328e-01f, -1.78850964e-01f, 5.28721232e-03f, 1.23759225e-01f, 1.57376543e-01f, 1.54071763e-01f, 4.02302342e-03f, -2.52766125e-02f,
  2.40434811e-01f, 2.66218111e-02f, 9.67450663e-02f, -8.32025260e-02f, -4.88539636e-02f, -1.19639941e-01f, 9.95256826e-02f, -5.03528267e-02f, 1.65944900e-02f, -6.37570024e-02f,
  1.97774932e-01f, 1.10082045e-01f, 1.62874609e-01f, -1.96513776e-02f, -1.41965628e-01f, 8.01722854e-02f, 7.01371133e-02f, -1.31353751e-01f, 4.58996557e-03f, 3.77211832e-02f,
  -7.79328793e-02f, 3.08278967e-02f, 3.06476086e-01f, 1.13910407e-01f, 2.38760933e-01f, 1.17299713e-01f, 7.84462243e-02f, -6.12455886e-03f, -1.30377069e-01f, 2.01366499e-01f,
  -1.86754778e-01f, 2.86911160e-01f, 1.22323930e-01f, -7.40802512e-02f, -8.34284425e-02f, 1.24809723e-02f, -5.36642224e-02f, 2.67670280e-03f, 1.28783375e-01f, 1.77947372e-01f,
  1.33380383e-01f, 6.86923191e-02f, 1.93040833e-01f, 1.16905876e-01f, 1.03136361e-01f, -2.20945209e-01f, -4.74820063e-02f, 4.51261103e-02f, 3.00048068e-02f, -2.07127571e-01f,
  1.02085054e-01f, -8.86831731e-02f, -1.27356648e-01f, 2.69162618e-02f, 2.70058841e-01f, 1.06994987e-01f, 1.99199259e-01f, -2.83687655e-02f, -1.59925103e-01f, -1.52601693e-02f,
  -2.54701316e-01f, -1.94613323e-01f, 5.72087765e-02f, -1.96652368e-01f, 1.49751469e-01f, 1.16468616e-01f, -2.72890143e-02f, 1.32685170e-01f, 1.91256911e-01f, 4.12481204e-02f,
  -4.15368006e-02f, -6.10171631e-02f, 2.76087642e-01f, 2.36687735e-01f, -6.64311275e-02f, 1.01119615e-01f, 1.88222136e-02f, 1.35952070e-01f, 3.79042774e-02f, 4.05734032e-02f,
  -1.99523538e-01f, 1.20276891e-01f, 3.56169976e-02f, 1.37527242e-01f, -1.30242705e-01f, -5.37177213e-02f, 7.25673586e-02f, 1.24242648e-01f, 1.06018811e-01f, -9.50234085e-02f,
  7.83994272e-02f, 8.35962519e-02f, 2.22777531e-01f, 1.69925496e-01f, 2.71795362e-01f, 1.14857554e-01f, -1.95337534e-01f, 4.33143340e-02f, -1.50720194e-01f, 8.82894993e-02f,
  1.17562175e-01f, 1.91681404e-02f, 1.19749255e-01f, 3.28965604e-01f, 8.48394483e-02f, 9.07820091e-03f, 5.88139258e-02f, 2.42058679e-01f, -3.92025977e-01f, -1.74291179e-01f,
  3.77964228e-01f, 2.11657047e-01f, 2.17124879e-01f, -7.28140399e-02f, -1.01768441e-01f, 2.02954292e-01f, -6.61573708e-02f, 8.06899443e-02f, 1.60379007e-01f, 5.50781488e-02f,
  3.43239307e-02f, 1.33022070e-01f, -1.25608668e-01f, -1.00436389e-01f, -1.06548101e-01f, 1.70691133e-01f, -1.05291404e-01f, 6.21092618e-02f, -1.99758238e-03f, 2.25058615e-01f,
  9.69573669e-03f, -4.54241745e-02f, 8.12391490e-02f, 1.17646717e-01f, 5.37115755e-03f, 1.67573854e-01f, 2.91488707e-01f, 1.21916458e-02f, 6.16705716e-02f, 5.19063883e-02f,
  -8.85766447e-02f, -1.20625436e-01f, 1.26369357e-01f, 3.93159054e-02f, 1.22075826e-01f, 1.23659730e-01f, -1.69157714e-01f, -9.40681547e-02f, 1.64418876e-01f, -1.41935572e-01f,
  -9.93543416e-02f, 1.41367644e-01f, -1.32375628e-01f, 5.18682674e-02f, -1.11625075e-01f, 1.27070755e-01f, 2.18832970e-01f, -5.32294288e-02f, -7.41050690e-02f, 1.36741295e-01f,
  -9.28925499e-02f, 4.01631594e-02f, 8.34235474e-02f, -1.53665856e-01f, 8.03062245e-02f, -1.30710214e-01f, 2.15030033e-02f, 1.29317701e-01f, 1.38913974e-01f, 1.10298306e-01f,
  1.30376518e-01f, -2.82642618e-02f, -1.10356718e-01f, -7.59184733e-02f, 1.52778685e-01f, -1.52918041e-01f, -1.36060953e-01f, -2.05955788e-01f, -1.38619587e-01f, -5.10455146e-02f,
  4.84565049e-02f, 9.37522426e-02f, -5.46105057e-02f, 1.87002897e-01f, 1.54208452e-01f, 3.90270352e-02f, -1.33585319e-01f, 1.22910149e-01f, -8.97328407e-02f, -9.01394486e-02f,
  7.16763213e-02f, 2.47145742e-02f, -2.11216062e-02f, 1.57080200e-02f, 9.07247886e-03f, 7.57556707e-02f, -8.31920356e-02f, -3.45957018e-02f, -6.79208711e-02f, 8.03638622e-02f,
  1.35305077e-01f, 1.27459317e-02f, 2.08771620e-02f, 1.45571545e-01f, -2.41431058e-03f, -1.53110679e-02f, 6.83500618e-02f, 5.89186735e-02f, -6.04721308e-02f, 2.44470090e-02f,
  1.65690724e-02f, -1.17857873e-01f, -7.44611248e-02f, -6.71975985e-02f, 4.53013740e-02f, 3.49671990e-02f, 8.42411593e-02f, 1.66773349e-02f, -1.53900117e-01f, 1.75687268e-01f,
  8.47492293e-02f, 1.95296153e-01f, -9.93747339e-02f, 2.70194918e-01f, -1.38781190e-01f, 1.32794440e-01f, 3.22020017e-02f, -1.94653962e-02f, -4.38852943e-02f, 5.18533923e-02f,
  4.02536802e-02f, 1.49279907e-01f, -5.19368388e-02f, 2.58532329e-03f, -4.83964942e-02f, 1.48548454e-01f, -7.98652172e-02f, -7.51261413e-02f, 6.03683218e-02f, 6.51933402e-02f,
  -6.51867613e-02f, -3.52100446e-03f, 3.44323516e-02f, -3.80629003e-02f, 2.10742190e-01f, 1.37482792e-01f, -1.64344952e-01f, 5.02596349e-02f, 7.24982917e-02f, -4.96277735e-02f,
  1.61659181e-01f, -1.97116733e-02f, 6.68633580e-02f, 5.32569997e-02f, -8.91527534e-02f, -5.62507659e-02f, 5.72182499e-02f, 2.02571630e-01f, -9.30681899e-02f, 3.15089412e-02f,
  1.05148174e-01f, 1.88179955e-01f, 6.76994175e-02f, 6.97449269e-03f, -1.28417816e-02f, -1.32531628e-01f, -1.16367400e-01f, -1.17939547e-01f, 4.68774624e-02f, 4.89816889e-02f,
  -4.87199463e-02f, 4.79338467e-02f, 1.36259943e-01f, -7.55209401e-02f, 1.04164660e-01f, 9.01940688e-02f, -5.64233512e-02f, -3.93818952e-02f, 1.60602704e-01f, -1.34627923e-01f,
  1.32977843e-01f, -8.35945383e-02f, -2.91268080e-02f, -5.96087389e-02f, 1.57143235e-01f, 2.28878185e-02f, -7.38679543e-02f, -1.50169715e-01f, 8.63547437e-03f, 4.02907096e-02f,
  -6.97121471e-02f, 1.30587250e-01f, 2.34301742e-02f, -1.30847208e-02f, 6.56838641e-02f, 1.10061042e-01f, -2.41846293e-02f, -5.96405864e-02f, 1.17580555e-01f, 1.58798754e-01f,
  1.15810037e-01f, 1.86465010e-01f, -2.06271797e-01f, -9.44510773e-02f, 9.56474692e-02f, 1.53866708e-01f, 1.76693663e-01f, 1.18585251e-01f, -5.88641986e-02f, -8.03835914e-02f,
  3.10553133e-01f, -1.62136585e-01f, -3.98068391e-02f, 1.02228798e-01f, -2.43582409e-02f, 1.51606113e-01f, 1.20985895e-01f, -1.00023650e-01f, 1.97761372e-01f, -8.55470598e-02f,
  -3.15423161e-02f, -1.25468954e-01f, -4.22064662e-02f, -1.59906093e-02f, 8.92123356e-02f, -1.93746872e-02f, -8.77589509e-02f, -4.68709655e-02f, 4.58241776e-02f, 2.83885617e-02f,
  1.99276194e-01f, -1.00917906e-01f, 1.75676942e-01f, -3.76050221e-03f, -2.21143328e-02f, -9.80717223e-03f, -1.97545186e-01f, -1.03986241e-01f, 1.32074073e-01f, 1.24314547e-01f,
  2.62141414e-02f, 1.27091467e-01f, 7.31839240e-02f, 6.42865747e-02f, 1.98050052e-01f, 4.90847416e-02f, 1.17145672e-01f, -1.08339451e-01f, -3.28758731e-02f, -5.91209978e-02f,
  1.34119153e-01f, 2.57625524e-02f, -1.41082751e-02f, -1.03412315e-01f, -3.02274935e-02f, -1.03525773e-01f, -1.05802059e-01f, 1.17009886e-01f, 1.23561136e-01f, -5.62346354e-02f,
  1.16170803e-02f, 6.43624663e-02f, 1.37380183e-01f, -2.11169571e-02f, 1.45036176e-01f, 2.79027551e-01f, -2.09905148e-01f, -1.74945295e-01f, -1.03789143e-01f, 4.85657416e-02f,
  1.19211242e-01f, 9.55998972e-02f, 1.01664156e-01f, 6.25490770e-02f, 2.26704970e-01f, -6.36824295e-02f, 8.30895677e-02f, -1.99190993e-02f, 1.38356034e-02f, 7.73637220e-02f,
  3.52869183e-02f, -1.83315724e-01f, 1.71864048e-01f, 3.74297276e-02f, 9.41457879e-03f, -1.13034308e-01f, -6.92273676e-02f, -7.97820687e-02f, 1.07650273e-01f, 5.46507910e-02f,
  1.19373903e-01f, 9.09489170e-02f, -1.61957573e-02f, 8.15115497e-02f, 1.63681582e-01f, 9.87025797e-02f, -4.24669310e-03f, -3.94594185e-02f, 7.09228218e-02f, 9.92475972e-02f,
  -5.55190668e-02f, -8.94957557e-02f, 2.41083819e-02f, 1.43386826e-01f, -1.54918816e-03f, 1.40835708e-02f, 9.27575212e-03f, 8.04188251e-02f, 2.70618975e-01f, 4.19661179e-02f,
  7.29623437e-02f, -9.72412899e-02f, -8.65106378e-03f, 9.33090672e-02f, 1.74518496e-01f, 1.38592839e-01f, -1.72912218e-02f, 5.85441701e-02f, -1.67854372e-02f, -5.84437065e-02f,
  -1.79485083e-02f, 1.64774790e-01f, 8.93254429e-02f, 2.31058151e-01f, 1.94965407e-01f, 1.84053421e-01f, 1.80532169e-02f, 6.90036919e-03f, -1.55983165e-01f, -9.79339853e-02f,
  1.56528622e-01f, 2.39644483e-01f, 1.16365410e-01f, -3.48399975e-03f, -1.10973924e-01f, 6.89159632e-02f, -4.86502536e-02f, 2.46427003e-02f, -4.96107042e-02f, 9.51512605e-02f,
  -3.20782550e-02f, -1.96570441e-01f, -2.78925300e-02f, 1.06042020e-01f, -1.60390409e-05f, 3.24615210e-01f, 5.28304018e-02f, -2.60766726e-02f, -8.71379301e-02f, 3.08650378e-02f,
  9.05239396e-03f, -9.86736715e-02f, 2.02801704e-01f, -7.06463158e-02f, -4.58267555e-02f, 1.19557180e-01f, -7.37433434e-02f, 8.11159983e-02f, 9.53907967e-02f, -6.70036897e-02f,
  7.60731474e-02f, 1.39216229e-01f, 1.83458701e-01f, 1.13136865e-01f, -4.07303162e-02f, -1.91459358e-02f, -8.59441608e-02f, 3.81211601e-02f, 1.14585310e-01f, -6.62962571e-02f,
  6.23119511e-02f, 3.81524153e-02f, -2.63010804e-02f, -3.51841785e-02f, 2.65630870e-03f, 1.34621948e-01f, 1.20639607e-01f, -4.50141616e-02f, -1.56577468e-01f, 1.00254370e-02f,
  -1.45102307e-01f, 5.74840158e-02f, -1.00513041e-01f, 8.06988180e-02f, -7.34901279e-02f, -1.10665582e-01f, 8.77316743e-02f, -1.23826325e-01f, -1.06373103e-02f, -8.77285451e-02f,
  -9.61012915e-02f, -3.91496485e-03f, 6.25256449e-02f, -5.53484522e-02f, 1.16241146e-02f, -8.01848806e-03f, -8.34055766e-02f, -3.30922231e-02f, -6.58760518e-02f, -4.59095202e-02f,
  -4.85716015e-02f, -5.00490777e-02f, -4.73503247e-02f, -4.83954363e-02f, 1.13918416e-01f, 5.96432313e-02f, 5.97397704e-03f, 1.10129938e-02f, 4.47884528e-03f, -1.10214747e-01f,
  -9.91629511e-02f, 1.01725213e-01f, 1.16626918e-01f, -4.30895714e-03f, 8.06405321e-02f, 1.92502588e-02f, 2.38564257e-02f, -1.18898518e-01f, -1.00678727e-01f, 7.17681870e-02f,
  -3.94474752e-02f, -5.23386113e-02f, -8.03396404e-02f, -9.63110030e-02f, 9.26326811e-02f, 4.79307473e-02f, 7.92996492e-03f, 7.80870616e-02f, -8.94237608e-02f, 9.37359557e-02f,
  -3.40469554e-02f, -4.38784100e-02f, 6.09627105e-02f, -5.55117428e-02f, -1.93686336e-02f, -6.22411780e-02f, 5.53846173e-02f, 1.26559794e-01f, 4.11488116e-02f, 7.11622387e-02f,
  -1.46444971e-02f, -1.50147080e-02f, 3.88804637e-02f, -7.88951740e-02f, 7.83053339e-02f, 1.17184401e-01f, 1.05982281e-01f, -3.81686464e-02f, -3.48855630e-02f, -1.63249224e-02f,
  9.21186581e-02f, 2.29473293e-01f, 1.49356291e-01f, 7.44020268e-02f, 9.88097265e-02f, 2.10271224e-01f, -6.52026013e-02f, -1.39203697e-01f, -1.35420248e-01f, 1.12784160e-02f,
  2.22863108e-01f, -2.08287165e-01f, -1.14091046e-01f, 1.64329201e-01f, -1.01706311e-01f, 1.25537798e-01f, 1.14701949e-01f, -4.67613488e-02f, 1.03790797e-01f, -1.37993976e-01f,
  -6.92472830e-02f, -1.81222975e-03f, -2.48695705e-02f, 2.72094786e-01f, -9.13880244e-02f, -8.36201608e-02f, 3.41136269e-02f, -6.24742135e-02f, 9.91553888e-02f, 8.85209218e-02f,
  -9.29162651e-02f, -4.73023430e-02f, -1.06865630e-01f, -1.41339570e-01f, -5.70775419e-02f, 9.63615626e-02f, -1.22804288e-02f, 9.14065987e-02f, 9.57146436e-02f, 2.58564744e-02f,
  1.50035530e-01f, -8.33616778e-02f, -7.08951056e-02f, -1.20035447e-01f, -6.52608871e-02f, -1.62996985e-02f, -9.78734270e-02f, -9.38911662e-02f, 2.12666601e-01f, -5.80356009e-02f,
  9.81012955e-02f, -6.09257445e-02f, -8.93037170e-02f, 8.73642974e-03f, -8.00956562e-02f, 2.11389944e-01f, 1.12611810e-02f, 1.53500676e-01f, 8.54650810e-02f, -2.29071360e-02f,
  -1.16507011e-02f, -1.04629867e-01f, -9.53079686e-02f, 6.84909662e-03f, 9.69503075e-02f, 7.62518845e-04f, 1.35212883e-01f, 9.00059342e-02f, 1.22863941e-01f, 2.14398474e-01f,
  1.87944785e-01f, -3.43707263e-01f, 1.17242649e-01f, 2.53170151e-02f, 3.31460014e-02f, -6.17156960e-02f, 1.15855642e-01f, -5.49679659e-02f, 8.56226031e-03f, -2.03075707e-02f,
  -2.26798177e-01f, -7.52713308e-02f, -9.57289934e-02f, -1.92865208e-01f, 1.60432458e-01f, 1.03498168e-01f, 1.83488593e-01f, 6.61823079e-02f, -5.90724871e-02f, 1.07056670e-01f,
  -5.11656106e-02f, 1.19643182e-01f, -3.77866551e-02f, 1.43063515e-01f, -1.11391217e-01f, 1.72882736e-01f, -5.92016354e-02f, 1.07004553e-01f, -1.11489743e-01f, -6.25712201e-02f,
  6.61798865e-02f, -1.25646321e-02f, 1.15428925e-01f, 1.05174169e-01f, 6.18915670e-02f, 9.91423875e-02f, -4.88806702e-02f, 6.16791956e-02f, -8.12763572e-02f, 7.02676028e-02f,
  2.41319463e-02f, -1.54966459e-01f, 8.50166231e-02f, 6.90501928e-02f, 1.98762026e-02f, 1.39147699e-01f, -4.31758836e-02f, 1.12997048e-01f, 1.57679006e-01f, 1.21764205e-01f,
  -1.69098526e-02f, 4.99129668e-03f, 2.40066014e-02f, 1.12668157e-01f, -9.86980572e-02f, -4.30846699e-02f, 1.59095585e-01f, 2.41370071e-02f, -7.34525025e-02f, -9.88845434e-03f,
  3.90701555e-02f, -4.00227048e-02f, 4.48233746e-02f, 6.03867583e-02f, -8.78446922e-02f, -1.15784377e-01f, 5.19608930e-02f, -6.99594393e-02f, -1.49904713e-01f, -2.26580966e-02f,
  2.33890060e-02f, 6.42769411e-02f, -8.73063356e-02f, 3.93810160e-02f, 7.43518397e-02f, -1.23552620e-01f, -1.64803267e-02f, -6.55565038e-02f, -2.46357452e-03f, -5.85375726e-02f,
  2.61716973e-02f, -1.11944340e-01f, 2.19969470e-02f, 4.58749160e-02f, 4.38824892e-02f, 7.73243755e-02f, 5.91722950e-02f, -3.67378481e-02f, 1.11682393e-01f, 8.46408028e-03f,
  1.00652337e-01f, 4.00936529e-02f, -2.15591267e-02f, -1.02809153e-01f, -1.08659178e-01f, 5.55246547e-02f, -7.58209750e-02f, 5.93723655e-02f, 5.59026711e-02f, -1.20333537e-01f,
  -7.78639391e-02f, -3.12956376e-03f, -6.19610250e-02f, 2.98443083e-02f, -1.57015696e-02f, 9.55856070e-02f, -7.96342716e-02f, 1.05364919e-01f, 1.02081195e-01f, -6.24565408e-02f,
  -6.77206889e-02f, 9.52845812e-03f, -1.33017540e-01f, -9.69914794e-02f, -2.95795277e-02f, -6.70556575e-02f, 4.22978140e-02f, 6.53030304e-03f, -1.22636035e-01f, 1.10087506e-01f,
  3.82068194e-02f, 4.10095975e-02f, 8.51763040e-02f, -1.22502577e-02f, 1.91532895e-01f, 5.94101436e-02f, 4.22932617e-02f, -4.72035743e-02f, -1.04475929e-03f, 1.80160142e-02f,
  1.38292402e-01f, -1.82282984e-01f, -1.90354615e-01f, 1.15817517e-01f, 8.32117572e-02f, -1.57490361e-03f, 1.14280805e-01f, 3.56534496e-02f, 1.29063219e-01f, -1.27313942e-01f,
  -5.03934920e-02f, 7.61094317e-02f, -8.14568549e-02f, 1.37767047e-01f, -1.19582601e-02f, -3.54940593e-02f, -8.20647702e-02f, 6.59223972e-03f, -3.69229987e-02f, -6.83774427e-02f,
  4.05660495e-02f, 1.60490479e-02f, 2.18184933e-01f, 8.19870681e-02f, -1.41386762e-01f, -6.39388487e-02f, 4.07358743e-02f, -8.04759935e-02f, 5.71710132e-02f, -5.66613525e-02f,
  -3.90476845e-02f, 1.23170361e-01f, 1.20407663e-01f, -1.16279729e-01f, -8.36182013e-03f, 9.13458318e-02f, -1.25209652e-02f, -4.47796285e-02f, 6.53997436e-02f, 2.02731099e-02f,
  3.37535702e-02f, 1.22610994e-01f, -1.24344520e-01f, 6.08324185e-02f, 1.33342082e-02f, 1.03105064e-02f, 6.33560494e-02f, -2.29433831e-02f, -1.33384047e-02f, -8.03937390e-02f,
  8.72509554e-03f, -8.24895129e-02f, -3.43214124e-02f, 1.04385033e-01f, -1.55002257e-04f, 1.61185384e-01f, 4.66310186e-03f, -1.12386897e-01f, 1.16156423e-02f, -6.71622623e-03f,
  -8.40104967e-02f, 8.70832428e-02f, 1.85037069e-02f, 3.76481563e-02f, 7.21359402e-02f, 9.51743592e-03f, 1.01321869e-01f, -6.43671975e-02f, 6.86834827e-02f, -8.72728154e-02f,
  -8.67546722e-02f, 9.13859438e-03f, 1.25302225e-01f, -6.72896877e-02f, 1.25941820e-02f, 9.76114869e-02f, -4.57733609e-02f, 5.63317575e-02f, -1.04581982e-01f, 3.21071334e-02f,
  9.08235162e-02f, -1.24432042e-01f, 9.32540819e-02f, 3.27151529e-02f, 4.67298664e-02f, -4.10016552e-02f, -7.98669085e-02f, -6.08938076e-02f, -8.98707882e-02f, 5.79365902e-02f,
  2.02313550e-02f, -8.86074603e-02f, -5.99964559e-02f, -9.64467004e-02f, 1.76313855e-02f, -6.45350814e-02f, -1.25280112e-01f, 1.19898900e-01f, -1.25301136e-02f, -7.58600980e-02f,
  -8.55083168e-02f, -1.90037563e-02f, 1.07023098e-01f, -1.50779029e-02f, 7.28427768e-02f, 3.63449864e-02f, -6.28148988e-02f, -1.29707679e-01f, -6.74217716e-02f, -7.94953899e-04f,
  -1.39897531e-02f, 3.19225378e-02f, 4.21600323e-03f, -3.37425731e-02f, -2.70617623e-02f, -1.38383545e-03f, -4.63192202e-02f, 7.84215257e-02f, 7.12518767e-02f, 3.04386839e-02f,
  1.55134993e-02f, -3.75621803e-02f, 3.22399646e-01f, 5.54966331e-02f, 1.82961613e-01f, 2.33814389e-01f, 1.73991635e-01f, -5.63956797e-02f, -5.24067134e-02f, -2.90259391e-01f,
  -3.07216167e-01f, -7.78160840e-02f, 1.60146207e-01f, 2.41385009e-02f, 1.05132371e-01f, -3.75164449e-02f, 4.20158133e-02f, -1.07631773e-01f, 1.03807211e-01f, 9.48471650e-02f,
  2.32555047e-01f, 1.31469995e-01f, 1.76776201e-01f, -2.01404676e-01f, 1.03876002e-01f, -2.47368179e-02f, 1.35882512e-01f, 2.09763601e-01f, -9.15919393e-02f, 1.45862758e-01f,
  1.04506329e-01f, 2.27177680e-01f, 3.05209327e-02f, 1.51114702e-01f, 1.80469647e-01f, 1.94524671e-03f, 2.17816103e-02f, 8.07766686e-04f, 3.72953489e-02f, -7.16782957e-02f,
  -7.52919465e-02f, -2.66612833e-03f, 2.09155291e-01f, 1.68424398e-01f, -5.50168902e-02f, 1.18846737e-01f, 3.43771242e-02f, -1.25314832e-01f, 1.11019000e-01f, 1.50822058e-01f,
  3.56150139e-03f, 4.21766602e-02f, -1.00758143e-01f, -1.12491362e-01f, 2.56379306e-01f, 1.85472712e-01f, 2.48866290e-01f, -4.43097688e-02f, -2.15303106e-03f, -8.79418775e-02f,
  3.99655588e-02f, 2.02791411e-02f, -3.19946371e-02f, 1.66907474e-01f, 6.19780868e-02f, 3.16347107e-02f, 1.69027716e-01f, 1.67972788e-01f, 1.76127419e-01f, 1.57491043e-01f,
  1.24361321e-01f, 4.54813428e-02f, -1.39892802e-01f, 7.87534416e-02f, 1.14680611e-01f, -1.33189008e-01f, -5.35057038e-02f, -2.48687137e-02f, -8.28501210e-02f, 1.40762985e-01f,
  -7.77321756e-02f, 3.15349572e-03f, -5.27549870e-02f, 1.37347549e-01f, 2.02284753e-01f, -1.95228010e-02f, 1.45049483e-01f, 6.90879300e-02f, 1.55956551e-01f, 1.77869603e-01f,
  1.81218937e-01f, -5.52681759e-02f, 6.58054426e-02f, 1.03016175e-01f, -2.28595138e-02f, 1.02723882e-01f, 1.07838273e-01f, 1.02630571e-01f, 5.76808176e-04f, 1.04860701e-01f,
  -9.20829922e-02f, 2.87211891e-02f, 1.06022365e-01f, 7.24321529e-02f, -3.12409140e-02f, -1.36869192e-01f, 8.49792287e-02f, -7.53134936e-02f, 1.30726248e-01f, -3.50154354e-03f,
  -1.21363893e-01f, -8.25855061e-02f, 5.10138758e-02f, 1.70785300e-02f, 9.89298970e-02f, -6.52783439e-02f, 5.27494960e-02f, -5.24182245e-02f, -2.94345506e-02f, -7.34211653e-02f,
  -3.15872096e-02f, 2.23346855e-02f, 3.22014950e-02f, -9.16138515e-02f, 5.50370850e-02f, 1.21713929e-01f, 1.33460239e-01f, -2.02752240e-02f, 2.20461309e-01f, 2.45614305e-01f,
  1.14792161e-01f, 1.48092866e-01f, -2.41824500e-02f, 1.85859278e-01f, -1.58256054e-01f, -2.81993710e-02f, 8.05813894e-02f, 1.90187737e-01f, 1.45417005e-01f, -1.23152457e-01f,
  -1.52636871e-01f, 2.46839315e-01f, -4.41159755e-02f, -9.43183899e-02f, 9.93170664e-02f, 8.96891672e-03f, 6.53991178e-02f, 8.94217845e-03f, -1.45888090e-01f, -1.21425651e-01f,
  -6.89931363e-02f, -6.08268008e-02f, 1.13738663e-01f, 1.21487685e-01f, -5.43566607e-02f, -1.17462976e-02f, 9.62523073e-02f, 8.63716379e-02f, -1.16818368e-01f, -6.06621169e-02f,
  1.06043778e-01f, -9.68645662e-02f, 2.87979543e-01f, 3.01328093e-01f, -8.94482136e-02f, 1.74849138e-01f, -4.32704352e-02f, -6.05805516e-02f, -1.55822223e-03f, -1.13935150e-01f,
  5.18009402e-02f, 2.26746649e-01f, 5.29657193e-02f, -1.09148972e-01f, 5.00027500e-02f, -5.32654114e-02f, 2.31619459e-02f, -7.56536275e-02f, -5.42529710e-02f, 5.39917536e-02f,
  -2.25679576e-02f, 2.11710691e-01f, -9.09882337e-02f, 9.65172872e-02f, -9.07497332e-02f, 2.14592651e-01f, -9.64898989e-02f, 4.21171710e-02f, 4.41187993e-02f, 5.73897548e-02f,
  -7.36713549e-03f, -9.95265618e-02f, 1.47858813e-01f, 1.42546315e-02f, 1.52485341e-01f, 1.85147062e-01f, 1.07885472e-01f, 1.94042251e-02f, -7.47767165e-02f, -4.42245230e-02f,
  -6.35950118e-02f, 2.82235499e-02f, 2.31540099e-01f, -1.81364506e-01f, -1.38938457e-01f, 2.10460857e-01f, -3.82830575e-02f, 1.17491409e-02f, 1.09049551e-01f, -4.42042053e-02f,
  6.23094328e-02f, -2.38322373e-02f, -9.44881216e-02f, -7.58210779e-04f, 6.34262189e-02f, -8.54184777e-02f, -8.31817985e-02f, -2.20902693e-02f, 1.40934959e-01f, -8.26621875e-02f,
  7.05315247e-02f, 5.72782457e-02f, -8.34467262e-02f, 3.16351354e-02f, 1.03936300e-01f, -9.01101828e-02f, 7.89308026e-02f, 3.81085114e-03f, -4.13114354e-02f, 7.07925782e-02f,
  1.88523799e-01f, 9.79690701e-02f, 2.39335019e-02f, -1.11188911e-01f, 8.40802789e-02f, -9.92433801e-02f, -1.03106136e-02f, -6.02840409e-02f, -3.88295352e-02f, 2.30116323e-02f,
  1.72588617e-01f, -7.69572631e-02f, 2.35908460e-02f, 7.69414976e-02f, 1.30688429e-01f, 4.41410989e-02f, -6.46513775e-02f, -7.69771310e-03f, 8.99543911e-02f, 2.44200692e-01f,
  -7.35712722e-02f, 1.52156353e-01f, -1.00181580e-01f, 1.19049780e-01f, -4.37894054e-02f, 7.03814104e-02f, -2.24825442e-02f, 1.38809131e-02f, -4.76402454e-02f, 1.25653356e-01f,
  1.36749938e-01f, -2.00181324e-02f, -1.39511243e-01f, 9.30025950e-02f, -1.73821393e-03f, -1.81350904e-03f, -1.10890307e-01f, -1.68624297e-02f, -6.36811182e-02f, 5.82687184e-02f,
  1.11371122e-01f, 5.64543791e-02f, 3.62747535e-02f, 1.34966094e-02f, -1.09497219e-01f, -2.49507427e-02f, 2.48451173e-01f, -2.14358807e-01f, 1.63732126e-01f, 2.34586373e-01f,
  7.43161961e-02f, 7.71469017e-03f, -1.31243631e-01f, 1.59102142e-01f, -1.05646932e-02f, -1.43975988e-01f, 1.79950461e-01f, 1.66114882e-01f, 3.74251492e-02f, 1.15291595e-01f,
  1.12581693e-01f, -4.50683050e-02f, -9.39321667e-02f, -1.46644965e-01f, -2.73298789e-02f, 5.10668159e-02f, 1.75351948e-01f, 1.00601137e-01f, 1.73084989e-01f, -5.21342549e-03f,
  -5.06616570e-02f, -9.60183293e-02f, 1.15911357e-01f, -6.65947050e-02f, 1.31669268e-01f, -1.02515787e-01f, -1.13919556e-01f, 2.34382730e-02f, 8.41403604e-02f, -7.96378702e-02f,
  1.45225018e-01f, 6.02397062e-02f, -5.38655147e-02f, -1.26335397e-03f, -1.03276446e-01f, 9.97118354e-02f, -7.37797171e-02f, -8.17318112e-02f, -1.32750478e-02f, 1.19048476e-01f,
  2.91834604e-02f, 8.04762095e-02f, 8.68680477e-02f, -3.72677781e-02f, -5.33809289e-02f, -2.25985572e-02f, -1.00631088e-01f, -9.72987488e-02f, 4.34322841e-03f, 1.47562698e-01f,
  -1.11531705e-01f, -1.12610012e-02f, 4.84039597e-02f, 2.85269525e-02f, -6.44130260e-02f, 1.08281098e-01f, -1.16491104e-02f, -5.57607785e-02f, -8.64586830e-02f, -1.04738951e-01f,
  -5.86438850e-02f, -8.83103013e-02f, 7.11173192e-02f, -7.79903159e-02f, -5.86360060e-02f, -6.96674660e-02f, -1.04264691e-02f, 1.10486552e-01f, -9.74666253e-02f, 7.05544725e-02f,
  5.83910793e-02f, 8.17807913e-02f, 5.39076924e-02f, 1.00334086e-01f, 6.86197206e-02f, 6.98300228e-02f, -1.05735712e-01f, -1.03765987e-01f, 2.51781307e-02f, -6.52321428e-02f,
  1.40724182e-01f, 1.16866156e-01f, -1.59353241e-02f, -8.15017149e-02f, 2.90854424e-02f, -1.25446856e-01f, 1.02427118e-01f, 4.65511717e-02f, 1.21739514e-01f, 2.95762159e-02f,
  6.83076726e-03f, -1.36173248e-01f, 1.69029124e-02f, 1.39832050e-01f, 1.07334793e-01f, -4.21345942e-02f, -2.76786042e-03f, -4.55826446e-02f, 9.00487006e-02f, 2.40811724e-02f,
  5.71837537e-02f, 5.20866066e-02f, 3.29614989e-02f, 7.10824952e-02f, 1.00875695e-04f, 7.37218037e-02f, 1.28297016e-01f, 8.54437649e-02f, 3.26783061e-02f, 1.17545910e-01f,
  -2.59614866e-02f, -1.81528032e-01f, 1.75769240e-01f, -2.11023819e-03f, 1.07699921e-02f, -7.87090734e-02f, 7.89478347e-02f, 6.06517680e-02f, -6.25703409e-02f, 3.02884076e-03f,
  8.50977600e-02f, -9.05497298e-02f, -1.65287983e-02f, 4.96884510e-02f, -8.95878822e-02f, 4.00929190e-02f, -6.64584264e-02f, 1.58049420e-01f, 2.22540852e-02f, -7.02189058e-02f,
  -6.98527023e-02f, -5.81739135e-02f, 1.17570072e-01f, 5.02854586e-02f, 9.82839167e-02f, 4.52749878e-02f, -1.29599214e-01f, 4.99818213e-02f, 7.62307793e-02f, 1.52046010e-01f,
  -3.37537155e-02f, -1.14246793e-01f, -1.42887533e-02f, -8.46707150e-02f, 1.11960791e-01f, -1.19163997e-01f, -1.07277617e-01f, -6.15347922e-02f, -1.22192100e-01f, 5.77984974e-02f,
  1.00180751e-03f, -6.96207210e-02f, -1.16089091e-01f, -8.66839886e-02f, -8.80216360e-02f, 2.96858381e-02f, -1.14929773e-01f, 8.01535696e-02f, -7.77588114e-02f, -7.73402080e-02f,
  -1.07548416e-01f, -1.05774432e-01f, -7.72369280e-02f, 9.01070610e-02f, -8.77525806e-02f, -1.11679733e-01f, 4.11457792e-02f, 1.22337818e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 52)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 52;
const float L1_fan_Bp_bar_data[] = {
  2.32584164e-01f, 6.30010664e-02f, 2.34894544e-01f, 7.16644004e-02f, 7.86483884e-02f, 1.74533784e-01f, 1.42692298e-01f, 5.07072322e-02f, 1.07345738e-01f, 1.55164778e-01f,
  2.78811693e-01f, 1.49064153e-01f, 5.21704135e-03f, 2.16338769e-01f, -4.56001470e-03f, 2.29303725e-02f, 3.38622602e-03f, -3.44234891e-02f, -1.03428639e-01f, 2.12894738e-01f,
  5.25522325e-03f, 3.14107060e-01f, -1.09433725e-01f, 1.80796240e-04f, 1.55812964e-01f, -6.61778450e-02f, -3.02204043e-02f, 5.56345657e-03f, -4.65080068e-02f, 1.98354617e-01f,
  1.19617045e-01f, 1.08615821e-02f, 2.19133779e-01f, 1.58141866e-01f, -3.65279578e-02f, -8.66714958e-03f, 7.89957717e-02f, 1.72972828e-01f, 6.25341833e-02f, 3.19899246e-02f,
  1.33254200e-01f, 6.96119815e-02f, 7.73604540e-03f, 1.49051920e-01f, -8.45280737e-02f, 1.41966850e-01f, 8.58220831e-02f, 2.79209316e-01f, -4.73745875e-02f, 1.62379563e-01f,
  -1.25721753e-01f, 9.28408802e-02f
};

// L2_fan_Wp (Shape: 6 x 64)
const int L2_fan_Wp_rows = 6;
const int L2_fan_Wp_cols = 64;
const float L2_fan_Wp_data[] = {
  -1.76652804e-01f, -9.06354114e-02f, -1.13436915e-01f, 8.73189941e-02f, -1.96068138e-01f, 1.25646636e-01f, 1.42470047e-01f, 2.05489639e-02f, -1.14544764e-01f, 2.49408334e-01f,
  1.29269734e-01f, -2.00442895e-01f, -1.04787208e-01f, -1.20960519e-01f, -5.01813367e-02f, 8.11422467e-02f, -1.06791437e-01f, -5.50234057e-02f, 1.29771739e-01f, 3.64672812e-03f,
  2.28796795e-01f, -2.01325119e-02f, 1.31013125e-01f, -1.06447823e-02f, 1.10070020e-01f, -1.82784215e-01f, 1.36741221e-01f, 7.17395321e-02f, 1.28751114e-01f, -9.51137543e-02f,
  -8.43736231e-02f, -7.04304874e-02f, -3.63920107e-02f, -6.53765025e-03f, 1.87637620e-02f, 2.75620185e-02f, 9.00174379e-02f, -8.90678838e-02f, 1.26023486e-01f, -1.39825242e-02f,
  -1.15815766e-01f, -1.36892751e-01f, -1.18644968e-01f, -1.76790521e-01f, 3.74511063e-01f, -1.34470195e-01f, -4.02004633e-04f, -3.86109799e-02f, 2.02164665e-01f, 6.71873987e-02f,
  -1.19429037e-01f, 8.64506885e-02f, 7.62759969e-02f, -1.81259900e-01f, 8.49565640e-02f, 1.61505081e-02f, 9.04025212e-02f, 4.40433808e-02f, -5.68872914e-02f, 5.27196229e-02f,
  1.11685194e-01f, -1.17245875e-01f, -8.21670964e-02f, 3.90352495e-02f, 2.94651892e-02f, 1.65085584e-01f, 5.51352985e-02f, 1.42273560e-01f, -1.25459135e-02f, 1.45330235e-01f,
  -1.69364482e-01f, -2.00634807e-01f, -4.20209719e-03f, 1.99777514e-01f, 2.04199269e-01f, 5.54705523e-02f, -6.14669062e-02f, -5.66659421e-02f, 9.83333122e-03f, -1.02911822e-01f,
  9.27946046e-02f, -1.11580648e-01f, 9.17031709e-03f, 5.50658219e-02f, -5.20570651e-02f, -1.87471822e-01f, -3.12248319e-02f, 1.88353822e-01f, -1.09472640e-01f, -1.30221128e-01f,
  -1.57802887e-02f, 4.26905975e-02f, 2.14679781e-02f, 6.72187954e-02f, -1.68409664e-02f, -1.82513595e-01f, -1.32080585e-01f, -1.22561529e-01f, -4.98484932e-02f, 4.03811969e-02f,
  9.25272629e-02f, -7.50318402e-03f, 7.07940906e-02f, -6.24400601e-02f, 4.53983173e-02f, 3.15370820e-02f, 1.37817726e-01f, -9.28594917e-02f, 1.72048006e-02f, -6.53325915e-02f,
  -1.25529811e-01f, 1.68429524e-01f, -1.09748274e-01f, -1.18032046e-01f, -2.55889166e-02f, -9.43469629e-02f, -6.21705577e-02f, 1.45994529e-01f, 2.09668130e-02f, -4.59109768e-02f,
  4.18422185e-03f, 2.79560328e-01f, -5.92409000e-02f, -1.83685794e-01f, -3.88928242e-02f, 1.80972636e-01f, 4.35533142e-03f, 1.06351256e-01f, -1.15653299e-01f, -1.56125993e-01f,
  -6.95045292e-02f, -7.29882941e-02f, -5.76306740e-03f, 7.25378990e-02f, -8.22271034e-02f, -3.01006204e-03f, 1.11483365e-01f, -2.38484144e-01f, -1.25498563e-01f, 1.53406993e-01f,
  -1.05284266e-02f, -1.78231999e-01f, 1.73197657e-01f, 1.56008631e-01f, 4.27871980e-02f, 1.11084074e-01f, -1.19340219e-01f, -1.12497732e-02f, -3.50817591e-02f, 2.11728532e-02f,
  1.53246999e-01f, -1.81184694e-01f, -8.55795369e-02f, 1.44400701e-01f, 1.12529164e-02f, -1.12196334e-01f, -7.49280751e-02f, 8.69346634e-02f, -4.14989255e-02f, 3.01657170e-01f,
  1.44371256e-01f, -7.29316473e-02f, -7.70514132e-03f, 8.05715844e-03f, 8.85737091e-02f, -1.50732860e-01f, 8.83782357e-02f, 4.28424180e-02f, 5.50195761e-02f, -1.33784756e-01f,
  1.31478822e-02f, 2.26588943e-03f, -6.99383691e-02f, 1.12854734e-01f, 2.69943476e-02f, 3.33571173e-02f, -1.38054445e-01f, -1.53584018e-01f, 1.50754809e-01f, 1.24042429e-01f,
  5.92537634e-02f, -8.30210373e-02f, -7.64662772e-02f, 5.93151562e-05f, 1.09981313e-01f, -8.84988010e-02f, -5.44990189e-02f, 1.60807401e-01f, 1.68062359e-01f, -1.53825119e-01f,
  1.87110435e-02f, 8.81326273e-02f, -1.22703211e-02f, 3.11381608e-01f, 1.12803526e-01f, -1.42530829e-01f, -2.94852611e-02f, -7.90439397e-02f, 2.17597365e-01f, 2.29138181e-01f,
  -1.27883181e-01f, 9.60008353e-02f, -1.59781262e-01f, 2.34207854e-01f, -3.49114835e-01f, -1.73171461e-02f, -5.26155010e-02f, -2.99296621e-02f, 2.84099318e-02f, 2.43305229e-02f,
  -2.13132724e-02f, -6.49459735e-02f, -1.75591454e-01f, 1.81372240e-01f, 9.03467759e-02f, 6.42446103e-03f, 1.21056244e-01f, -4.90446426e-02f, 1.35885656e-01f, -5.62270023e-02f,
  -1.44378945e-01f, 1.07551195e-01f, 6.95923120e-02f, -7.88189769e-02f, 1.30091041e-01f, 1.06790699e-01f, 8.46045762e-02f, 2.45705061e-02f, 5.77692762e-02f, -1.79701410e-02f,
  -2.21634433e-02f, 5.79428934e-02f, -9.27359164e-02f, -1.37926396e-02f, 1.01026259e-01f, -2.38107309e-01f, 5.09352162e-02f, 9.39114764e-02f, 1.57258268e-02f, 1.19722538e-01f,
  -3.72353755e-02f, 7.38443360e-02f, -6.59852475e-02f, -1.70536544e-02f, -2.12879509e-01f, 8.87509137e-02f, -5.75596727e-02f, 6.68667331e-02f, -4.05747853e-02f, 2.38074273e-01f,
  1.92188378e-02f, 1.07708829e-03f, -8.61747861e-02f, -5.88590465e-02f, -1.56181557e-02f, -4.64717904e-03f, -5.24524786e-02f, 1.85282841e-01f, -2.70713028e-02f, -1.63097322e-01f,
  -1.91187188e-01f, -5.90676293e-02f, -3.13001499e-02f, 1.47921562e-01f, 5.01881866e-03f, 1.21717580e-01f, 2.06897557e-01f, 1.83796212e-01f, 7.10257664e-02f, 8.26468468e-02f,
  5.16800117e-03f, -2.98601668e-02f, -1.33086741e-01f, 1.38094246e-01f, -1.61416203e-01f, -1.12211026e-01f, -3.29555750e-01f, 1.24860026e-01f, 1.28241837e-01f, -1.31147295e-01f,
  1.17986100e-02f, -2.93184370e-02f, 9.27060023e-02f, 1.13008060e-01f, -1.28449816e-02f, 4.58134860e-02f, 1.00303456e-01f, -1.16720125e-01f, 5.15828542e-02f, -3.01804510e-03f,
  -1.23537362e-01f, 2.78924406e-03f, -1.19256116e-02f, 9.61966291e-02f, 8.03887937e-03f, -3.95748392e-02f, -1.39297873e-01f, 2.21412316e-01f, 7.48939291e-02f, -4.57915813e-02f,
  -8.63626227e-02f, -2.11274907e-01f, -2.11840093e-01f, 7.47547969e-02f, 1.58269964e-02f, 1.51717633e-01f, -1.18796803e-01f, 7.90826231e-02f, -3.82097885e-02f, -1.35737583e-01f,
  -1.14224896e-01f, 2.89236242e-03f, 1.21932356e-02f, 1.61608145e-01f, -1.54452063e-02f, -1.39459357e-01f, -1.14931554e-01f, -1.26873195e-01f, -5.47779724e-02f, -1.58672303e-01f,
  -9.59785581e-02f, -2.03601450e-01f, -1.52961075e-01f, -1.33602008e-01f, 3.13315615e-02f, 1.14790983e-01f, 5.78761734e-02f, 1.66453794e-02f, 1.24683365e-01f, -3.52782577e-01f,
  -2.58066267e-01f, 1.42689839e-01f, -5.69394417e-03f, -8.25264081e-02f, 1.70238733e-01f, 6.64251223e-02f, 1.35152504e-01f, 1.22707985e-01f, -6.66821189e-03f, -9.05038193e-02f,
  4.23872918e-02f, -8.40426423e-03f, -4.82393615e-02f, -1.28116369e-01f, -1.13599852e-01f, 1.50119096e-01f, -1.14163443e-01f, 3.59232202e-02f, 9.34173092e-02f, -5.08337468e-02f,
  5.70045263e-02f, 1.53265834e-01f, 1.12976559e-01f, 1.42307803e-01f, -7.57715032e-02f, 7.63925165e-02f, 5.30746281e-02f, -3.47471945e-02f, -3.62618528e-02f, 5.74297085e-02f,
  3.13837789e-02f, -2.07567438e-01f, -9.08256248e-02f, 4.52262126e-02f, 3.67946960e-02f, 2.89406776e-01f, -5.17892763e-02f, 1.15665212e-01f, -1.10306889e-01f, -1.42220438e-01f,
  2.65542921e-02f, 1.00771554e-01f, 1.04474043e-02f, -3.80810462e-02f, -1.14323340e-01f, -1.33364469e-01f, -1.20085645e-02f, -2.36651391e-01f, -3.02803121e-03f, 2.54430830e-01f,
  4.96410169e-02f, 7.22126216e-02f, -3.03091127e-02f, -2.06340849e-02f
};

// L2_fan_Wp_bar (Shape: 52 x 64)
const int L2_fan_Wp_bar_rows = 52;
const int L2_fan_Wp_bar_cols = 64;
const float L2_fan_Wp_bar_data[] = {
  -1.13061450e-01f, 1.54032677e-01f, -8.98517370e-02f, 1.17402472e-01f, 2.91282311e-02f, -8.36049467e-02f, -1.32442508e-02f, 5.83641455e-02f, -1.53055966e-01f, -2.43240912e-02f,
  7.93371946e-02f, -1.03148380e-02f, -1.04845002e-01f, -3.43992785e-02f, 2.18404725e-01f, -1.44344911e-01f, -1.74570996e-02f, -9.66985524e-02f, 1.33169005e-02f, -4.93235514e-02f,
  6.34503737e-02f, 7.54940882e-02f, 3.46985430e-01f, -1.56171583e-02f, 7.25332499e-02f, 8.99972320e-02f, 1.00797214e-01f, 1.38454318e-01f, 6.42551482e-03f, 7.52328187e-02f,
  4.65989225e-02f, 1.07548423e-02f, 8.04251879e-02f, 2.32213974e-01f, 8.59398246e-02f, -7.72475153e-02f, 1.18268088e-01f, 1.20586671e-01f, -3.12362071e-02f, 4.82830405e-02f,
  -7.31604546e-02f, -4.26005274e-02f, 6.99882284e-02f, 1.06672356e-02f, 9.05591473e-02f, 2.04072744e-02f, 1.44333899e-01f, -2.11882796e-02f, -1.70972776e-02f, 7.18036890e-02f,
  -1.65784825e-02f, 7.01359436e-02f, -6.27211034e-02f, 9.73666087e-02f, 2.12608464e-02f, 1.48294523e-01f, 4.14453559e-02f, 2.71728396e-01f, -1.95331246e-01f, 1.39384136e-01f,
  -7.78653473e-02f, -3.13022546e-02f, 8.69336650e-02f, -4.86026816e-02f, 1.07799038e-01f, -4.46986826e-03f, -2.60174498e-02f, -7.98687637e-02f, 1.68757662e-01f, 2.79325750e-02f,
  1.18720077e-01f, -8.00991207e-02f, -1.10932492e-01f, -1.03092499e-01f, -3.28995623e-02f, 3.18339467e-02f, -7.62536749e-02f, 8.90637860e-02f, 1.93606485e-02f, -9.59229469e-02f,
  -3.52493972e-02f, -1.12050951e-01f, -7.71662593e-02f, -3.98333631e-02f, -4.36853245e-02f, 1.24973252e-01f, -1.06837124e-01f, 8.19368362e-02f, 9.06903818e-02f, 4.57483754e-02f,
  3.80045781e-03f, -4.28109840e-02f, 7.26617202e-02f, 1.17763385e-01f, 7.27095455e-02f, -8.61161351e-02f, 1.47909392e-02f, 1.85216025e-01f, -6.48699477e-02f, -1.18865617e-01f,
  1.05799839e-01f, -5.00000343e-02f, 6.87995255e-02f, -1.08550213e-01f, -1.02093443e-01f, 1.42756686e-01f, -6.21457510e-02f, 7.06258714e-02f, 5.21743409e-02f, 1.94775835e-02f,
  -5.68509214e-02f, 7.27495924e-02f, 1.04904249e-01f, -2.98135746e-02f, -1.92501638e-02f, -8.21233690e-02f, 7.17776269e-02f, -8.04020688e-02f, -7.31800795e-02f, 1.52651677e-02f,
  -7.37061352e-02f, 9.13277566e-02f, -7.64687955e-02f, -8.62815157e-02f, -1.14352599e-01f, -1.26663923e-01f, -3.25772092e-02f, 3.20264660e-02f, 4.80729863e-02f, -9.67742428e-02f,
  9.10360143e-02f, -7.80070648e-02f, -5.53456396e-02f, 1.10091120e-01f, -1.51522353e-01f, 2.31337305e-02f, 2.13437736e-01f, -5.32272086e-02f, 1.19647495e-01f, 1.01304621e-01f,
  1.31662458e-01f, -5.69453351e-02f, -2.53104903e-02f, 6.30026311e-02f, 4.19464894e-03f, 2.01067209e-01f, 6.35826737e-02f, -1.25992462e-01f, -2.37676445e-02f, 1.77411467e-01f,
  1.44486815e-01f, -7.33921528e-02f, -2.64391545e-02f, 3.98053527e-02f, -8.22276175e-02f, -3.38871107e-02f, -6.95064813e-02f, 9.51930359e-02f, -1.11519881e-01f, 6.83750510e-02f,
  1.59378603e-01f, -1.34275645e-01f, -1.54729588e-02f, 9.02777538e-02f, 8.90897885e-02f, 1.07429795e-01f, 9.17179603e-03f, -4.20182608e-02f, 9.63929594e-02f, -7.10787550e-02f,
  -7.44333640e-02f, 1.79437920e-01f, 1.41672000e-01f, 1.94296002e-01f, 1.48877889e-01f, -7.51895607e-02f, -2.10294537e-02f, 1.68461293e-01f, 9.46246982e-02f, -3.19019519e-02f,
  9.71252620e-02f, 3.45492177e-02f, -7.69106820e-02f, -7.19308911e-04f, 3.54930311e-02f, -1.58244874e-02f, 1.05789527e-01f, 3.82094346e-02f, 1.81418836e-01f, -9.47544128e-02f,
  -8.21468011e-02f, -7.84261823e-02f, -5.27047971e-03f, 1.23946100e-01f, 1.07677914e-01f, 7.60826468e-02f, 7.13158697e-02f, 5.50429896e-02f, 1.26872644e-01f, -1.46336243e-01f,
  3.48136318e-03f, -6.82954714e-02f, 7.06127658e-02f, 2.16180876e-01f, 2.46355698e-01f, -4.14353348e-02f, 1.57590970e-01f, 7.46323764e-02f, -5.08259721e-02f, 2.13687927e-01f,
  -9.94949639e-02f, -3.28540541e-02f, 1.04008149e-02f, 1.74139112e-01f, 1.56195179e-01f, 1.60112400e-02f, 1.26582548e-01f, 3.02831829e-02f, 1.49647929e-02f, 2.38068532e-02f,
  -9.72496197e-02f, 5.94060719e-02f, -4.81405854e-02f, 1.64478675e-01f, 4.87948768e-02f, 6.96538761e-02f, 1.23953529e-01f, -3.89621034e-02f, -3.28395776e-02f, -2.88365427e-02f,
  1.98456328e-02f, 3.62341963e-02f, -6.49198741e-02f, -9.82544720e-02f, 3.58598195e-02f, 7.92623088e-02f, -6.61652163e-02f, -1.58243552e-02f, 3.52075100e-02f, 2.95728166e-02f,
  1.45724624e-01f, 7.71724805e-02f, -1.12368144e-01f, -1.37915090e-01f, 8.22300091e-02f, -7.13987127e-02f, -2.54447535e-02f, -8.27092156e-02f, -7.07341284e-02f, -1.85449254e-02f,
  1.37394324e-01f, 8.26332793e-02f, -2.90411767e-02f, -1.40753374e-01f, 5.57603054e-02f, -9.67089087e-03f, -1.16535733e-02f, -1.54388294e-01f, 3.80012020e-02f, -1.15269825e-01f,
  -2.22307350e-02f, 8.27246308e-02f, -8.41771662e-02f, -8.49505663e-02f, -2.39923391e-02f, 3.61611173e-02f, -1.15221890e-03f, -1.57499328e-01f, 1.17579803e-01f, -1.17724657e-01f,
  -5.14716245e-02f, 5.40483333e-02f, -1.22471884e-01f, -9.86581296e-02f, -2.28700787e-02f, -8.11940134e-02f, -5.46791814e-02f, 1.66321136e-02f, 1.39207110e-01f, 3.10252840e-03f,
  7.31319413e-02f, -1.15115875e-02f, 1.03455082e-01f, 4.78903353e-02f, -1.17942162e-01f, 1.42269388e-01f, 9.31108743e-02f, 7.63171688e-02f, 5.07850982e-02f, -3.96467596e-02f,
  1.09115623e-01f, -6.66889176e-02f, 1.93085652e-02f, -6.04337826e-03f, 6.56154752e-02f, -1.10270921e-02f, -8.09403285e-02f, 1.70835763e-01f, 4.61699703e-04f, 3.58084310e-03f,
  6.07281551e-02f, 7.04631060e-02f, -8.24884847e-02f, 1.29343882e-01f, -6.46295100e-02f, -8.88049006e-02f, 1.51713789e-01f, 8.11736658e-02f, 2.05734894e-01f, 5.73934838e-02f,
  -4.82020853e-03f, -1.63695961e-01f, -7.32520304e-04f, 3.65141523e-03f, -2.59590195e-03f, 1.32765934e-01f, 2.64374409e-02f, 1.28924638e-01f, 2.70241108e-02f, -1.29114568e-01f,
  1.23464920e-01f, -2.46417344e-01f, -1.09931715e-02f, 3.11504543e-01f, 1.11019731e-01f, 1.98041439e-01f, -6.10057861e-02f, -4.99374807e-01f, -8.71287882e-02f, -7.70637989e-02f,
  -1.38050020e-01f, -4.45812672e-01f, 1.42674699e-01f, -9.75515619e-02f, 5.31324372e-02f, 3.21316011e-02f, -3.72476578e-02f, -1.17144279e-01f, 2.35002443e-01f, -8.00752826e-03f,
  4.88764316e-01f, -1.65187091e-01f, -4.68574911e-02f, 1.57880962e-01f, -3.92957032e-02f, 2.39945337e-01f, 4.12031710e-02f, 1.36816397e-01f, -2.96227308e-03f, -1.15716308e-01f,
  -7.52301514e-02f, 9.95807350e-02f, 2.12324373e-02f, -1.97169602e-01f, 2.18022894e-02f, 3.38946097e-03f, 8.94779339e-02f, -3.05512160e-01f, -1.59973308e-01f, 7.76992962e-02f,
  4.15087957e-03f, -2.95875855e-02f, -1.14051826e-01f, 1.83054432e-01f, 3.66893828e-01f, 2.47951537e-01f, 2.04797789e-01f, 1.06775820e-01f, -8.75692666e-02f, -1.81651235e-01f,
  3.08872104e-01f, -6.15114793e-02f, 3.33064675e-01f, 1.49707213e-01f, -6.16821647e-02f, 1.08794242e-01f, 1.10304423e-01f, -9.49743092e-02f, -1.42181024e-01f, 2.36280352e-01f,
  1.12401284e-01f, 4.27919254e-02f, 1.02416649e-01f, 1.40592486e-01f, 1.69934586e-01f, 1.45462334e-01f, 1.42281726e-01f, -3.56641710e-02f, 9.40682366e-02f, 1.92290992e-01f,
  8.17155689e-02f, -9.85938385e-02f, -1.18211277e-01f, -1.24565929e-01f, -1.85699075e-01f, -1.31276041e-01f, -1.54338554e-01f, 3.80493551e-02f, 1.57011166e-01f, -6.92651048e-02f,
  5.21442741e-02f, 3.07028871e-02f, 2.44554162e-01f, -8.53373110e-03f, 1.12846673e-01f, -9.90907922e-02f, -7.78559074e-02f, 8.67582411e-02f, 1.05860613e-01f, -9.32501107e-02f,
  4.45922539e-02f, 1.12830028e-01f, 1.00269653e-01f, 6.42367899e-02f, -1.12862766e-01f, 2.34379768e-01f, 2.75526885e-02f, 2.61284232e-01f, 9.38698053e-02f, 6.11163210e-03f,
  -3.42943333e-02f, -1.76456869e-01f, 9.84831993e-03f, 2.74853967e-02f, -5.51058501e-02f, -6.48376569e-02f, -8.26696232e-02f, -1.76460862e-01f, 1.74628556e-01f, 4.14279968e-01f,
  7.06136227e-02f, -4.42556441e-02f, -1.48704559e-01f, -9.02053341e-02f, 3.26480642e-02f, -7.83458129e-02f, 7.92497303e-03f, -1.25823468e-01f, -4.03355956e-02f, -1.40226901e-01f,
  6.50782958e-02f, 4.92515564e-02f, -1.30077153e-01f, 2.72648722e-01f, 8.65692347e-02f, -1.17192619e-01f, -1.10357031e-02f, 1.02743143e-02f, 3.62383313e-02f, -1.79436635e-02f,
  -4.62587923e-02f, -3.93514987e-03f, -2.74162088e-02f, -4.07405682e-02f, -3.44599411e-02f, -6.90779015e-02f, -3.61891054e-02f, 6.00476228e-02f, -1.08807072e-01f, 6.51164055e-02f,
  6.36406392e-02f, -8.32432043e-03f, 9.41212103e-02f, -3.57249491e-02f, 9.53294113e-02f, -5.19156121e-02f, 1.20158512e-02f, 5.44690676e-02f, 1.77844465e-01f, -1.11880980e-01f,
  8.05607960e-02f, 6.03397638e-02f, -1.01697184e-01f, -3.95015068e-02f, 1.25500197e-02f, -2.76322104e-02f, 8.43589380e-02f, -3.88413221e-02f, 1.08039096e-01f, 6.49435818e-02f,
  -1.34155467e-01f, 7.69686550e-02f, 1.00131109e-01f, -1.05525993e-01f, -1.04235020e-02f, 2.81066578e-02f, 1.14965551e-01f, -6.29146323e-02f, 1.02520801e-01f, -1.15105271e-01f,
  -1.20526828e-01f, -3.64033356e-02f, 6.21533208e-03f, 7.97179863e-02f, 1.08594753e-01f, -1.21982642e-01f, 1.97582450e-02f, -7.17149973e-02f, 1.17958393e-02f, -1.26371697e-01f,
  8.36184174e-02f, -1.42954579e-02f, -7.73150995e-02f, 3.53165120e-02f, -5.36524355e-02f, -6.65155500e-02f, 6.74904808e-02f, -6.79437220e-02f, 6.34143651e-02f, 3.62036936e-02f,
  -6.88035712e-02f, 4.95425016e-02f, 7.72909001e-02f, -9.08771083e-02f, 1.55079380e-01f, 1.36755303e-01f, 1.00302048e-01f, -3.51949967e-02f, -4.79773507e-02f, 1.36161312e-01f,
  6.04747683e-02f, -4.42622937e-02f, -1.16377547e-01f, -3.39783654e-02f, -1.12097496e-02f, 1.13323487e-01f, 2.41110548e-01f, -6.17506541e-02f, -9.61187929e-02f, 9.70487073e-02f,
  1.53482407e-01f, 2.05639571e-01f, 1.10879354e-01f, -2.86936965e-02f, -1.01933353e-01f, 8.74478817e-02f, -5.94872534e-02f, 1.59229890e-01f, -9.73787680e-02f, 2.21063779e-03f,
  6.82730526e-02f, 4.22150716e-02f, -7.67206475e-02f, -1.00822240e-01f, -4.78501990e-02f, 1.16207264e-01f, -6.44825920e-02f, 1.91061608e-02f, -5.03291041e-02f, -3.01837157e-02f,
  -3.02109141e-02f, 3.02184988e-02f, 1.54266963e-02f, -2.79966574e-02f, -1.00728065e-01f, 8.32816288e-02f, -8.94865543e-02f, 1.48596570e-01f, 5.97007163e-02f, 8.03575739e-02f,
  -8.45229998e-02f, 3.73610705e-02f, 1.29712403e-01f, -9.60150210e-04f, -4.29677442e-02f, -8.53460878e-02f, -1.99098475e-02f, 1.32155672e-01f, -1.37520313e-01f, 2.22459938e-02f,
  -1.26240447e-01f, 1.05250113e-01f, -8.65012594e-03f, 1.81643829e-01f, 3.73759754e-02f, 5.90776391e-02f, 4.01140638e-02f, 2.07434401e-01f, 1.59063995e-01f, -4.44422895e-03f,
  5.18144388e-03f, -6.60592541e-02f, 1.64107338e-01f, 9.72205848e-02f, -3.50900344e-03f, -1.20549075e-01f, 4.75247800e-02f, 1.59180388e-01f, 2.89035635e-03f, 1.34514317e-01f,
  1.78401068e-01f, -1.44439146e-01f, -1.17013259e-02f, 1.26660272e-01f, -1.01157658e-01f, 1.83395579e-01f, -2.58397050e-02f, -6.39383048e-02f, 8.64627883e-02f, 7.45959729e-02f,
  9.90258381e-02f, 1.00325242e-01f, 1.28820658e-01f, -1.20369561e-01f, -5.14090918e-02f, 8.36864188e-02f, -3.10004335e-02f, -9.14647803e-02f, 8.88621733e-02f, 2.27977157e-01f,
  1.00188687e-01f, -3.35587114e-02f, -7.63470307e-02f, 2.49134943e-01f, -2.14274600e-02f, -9.46567655e-02f, 7.39408582e-02f, -7.72370994e-02f, 8.45701769e-02f, -4.59830016e-02f,
  -8.94838665e-03f, -1.01239555e-01f, 2.57192608e-02f, 4.89254333e-02f, 1.47348046e-01f, 1.89714685e-01f, 6.33155182e-02f, -4.69851792e-02f, -1.26193404e-01f, -9.78069678e-02f,
  -8.94785766e-03f, -3.92409936e-02f, 5.52863181e-02f, 1.30219221e-01f, -5.69374785e-02f, 6.35085702e-02f, -6.75417185e-02f, 1.27218775e-02f, 9.04713795e-02f, 6.03818335e-02f,
  7.57892877e-02f, 1.68145850e-01f, 1.35625914e-01f, 7.41053820e-02f, 3.28282304e-02f, -8.97245482e-02f, 2.02703401e-02f, 6.12161234e-02f, -9.63329896e-02f, 4.43834402e-02f,
  -1.02576412e-01f, -1.27376795e-01f, -1.06528297e-01f, -7.09183812e-02f, 1.96895450e-01f, -8.19485635e-02f, -1.60775222e-02f, -9.79166627e-02f, 1.73023015e-01f, -1.20221868e-01f,
  -4.13438864e-02f, -6.38860315e-02f, 4.05081548e-02f, 2.01282427e-01f, 3.86821814e-02f, 8.73560011e-02f, -3.22249904e-02f, 5.29041626e-02f, 2.66474672e-02f, 5.69002528e-04f,
  7.07769906e-03f, -2.77542993e-02f, 1.10826463e-01f, 1.68452516e-01f, 2.53898595e-02f, 5.42667843e-02f, 1.20150298e-01f, -9.96340960e-02f, 1.45409137e-01f, 4.30919901e-02f,
  -5.01912870e-02f, -9.27188769e-02f, -9.38514248e-03f, -4.60361801e-02f, -1.11235641e-02f, -2.43976582e-02f, 8.12575445e-02f, -8.28231573e-02f, -9.84988138e-02f, 1.04232825e-01f,
  1.11313894e-01f, -1.09241523e-01f, -9.80354548e-02f, -9.14374739e-02f, 7.14110723e-03f, 1.63147047e-01f, 8.37728083e-02f, 2.03267395e-01f, -6.12609833e-02f, -1.49727002e-01f,
  -4.14708070e-02f, -6.41975850e-02f, 1.24133900e-01f, 1.36562109e-01f, 9.67665389e-02f, 1.39553040e-01f, -2.42983475e-02f, -5.91358803e-02f, 3.65861990e-02f, 6.30519614e-02f,
  6.60823584e-02f, 1.79021791e-01f, 1.54817849e-01f, -1.93864644e-01f, -2.25250259e-01f, 9.79366079e-02f, 4.04250398e-02f, 1.27847731e-01f, 2.48878747e-01f, -9.25220922e-02f,
  1.75738677e-01f, 1.65297553e-01f, -5.56811467e-02f, 9.79588106e-02f, -2.42945794e-02f, 1.61335349e-01f, 1.19139440e-01f, -3.52090634e-02f, 5.87788671e-02f, 2.15898857e-01f,
  3.35465334e-02f, -1.14730410e-01f, 1.21040590e-01f, 1.23393990e-01f, -9.04241651e-02f, 1.87097475e-01f, 1.34020194e-01f, 2.23293483e-01f, 8.70870054e-02f, -2.42493339e-02f,
  -4.18889783e-02f, -5.83643280e-02f, -8.71829167e-02f, -3.40552954e-03f, -5.51899150e-02f, -1.50471423e-02f, -1.19576808e-02f, 4.61188145e-02f, 1.46140963e-01f, 2.78969884e-01f,
  8.30440596e-02f, -5.15723489e-02f, 5.98924654e-03f, -4.64603305e-02f, 1.38034210e-01f, -1.16525322e-01f, 1.14309959e-01f, -1.53584406e-01f, -1.15061484e-01f, 1.38653461e-02f,
  -3.25805396e-02f, -8.46789777e-02f, -7.20931068e-02f, 3.15445423e-01f, 7.65658766e-02f, -4.49631400e-02f, 7.45037198e-02f, 1.17944619e-02f, 1.23057470e-01f, 2.34670728e-01f,
  -1.42295016e-02f, 1.56197116e-01f, -1.50288530e-02f, -6.15992397e-02f, 4.27048765e-02f, 1.18841507e-01f, -1.55127436e-01f, -9.54585001e-02f, 8.79181996e-02f, 2.48816848e-01f,
  -7.79835358e-02f, 7.42077380e-02f, 2.06641287e-01f, 8.14480484e-02f, -1.38805285e-02f, -7.59785473e-02f, -7.96070695e-02f, 9.81691331e-02f, -1.02874704e-01f, -1.06186569e-01f,
  -5.12615070e-02f, 1.16328672e-01f, 1.36082238e-02f, -6.74311146e-02f, 5.81369996e-02f, 6.48288876e-02f, -4.63748910e-03f, -5.20528890e-02f, -5.35625666e-02f, -6.95813224e-02f,
  -1.39395613e-02f, 1.88700587e-03f, 5.55622727e-02f, -1.07341036e-02f, 1.72409713e-01f, 2.23437086e-01f, 6.79162219e-02f, -8.39386322e-03f, -5.69169186e-02f, -7.01420056e-03f,
  -1.69730056e-02f, -9.62475836e-02f, -1.23597734e-01f, -7.73070902e-02f, 9.18139890e-03f, -2.94525214e-02f, -4.86983582e-02f, -7.07397088e-02f, 4.19324748e-02f, 1.69038598e-03f,
  -1.68312475e-01f, -9.41200256e-02f, 9.59277451e-02f, 4.55176644e-02f, -1.27211856e-02f, 1.68656871e-01f, -1.42180715e-02f, 5.21087684e-02f, -5.51769100e-02f, 1.44186199e-01f,
  5.57774268e-02f, 2.23898292e-02f, 7.28705674e-02f, 1.78195894e-01f, 1.59307003e-01f, -1.31354304e-02f, 1.56641845e-02f, 1.40924022e-01f, 1.70730576e-01f, -5.76678850e-02f,
  -7.68175796e-02f, -1.25022888e-01f, -1.10999294e-01f, 2.00528502e-01f, -3.38566527e-02f, 1.46720111e-01f, 1.50571272e-01f, -7.05814511e-02f, -3.50754224e-02f, -1.06916139e-02f,
  6.42964020e-02f, 6.29138276e-02f, 4.78611997e-04f, -1.06700681e-01f, -1.05963580e-01f, -7.33057782e-03f, -5.04298657e-02f, 1.25650823e-01f, 4.62158248e-02f, -8.20604041e-02f,
  -1.08830273e-01f, 6.50684312e-02f, 6.64837286e-02f, -1.25115231e-01f, -8.74575451e-02f, 1.60138667e-01f, -2.83034313e-02f, -6.10922687e-02f, -5.31471409e-02f, 1.86258465e-01f,
  9.06665903e-03f, 6.17111772e-02f, -1.20378084e-01f, 1.22925021e-01f, 1.03717476e-01f, -1.09287472e-02f, 2.52981391e-02f, 7.18894228e-02f, -1.75573394e-01f, 3.06987464e-02f,
  -5.97888753e-02f, -1.98041118e-04f, 6.42366931e-02f, 5.60955442e-02f, 1.15605295e-01f, -5.74491657e-02f, -6.55265972e-02f, 3.42833921e-02f, -7.33323246e-02f, 6.57483861e-02f,
  5.57354242e-02f, 1.40534723e-02f, 7.10807694e-03f, -7.92291164e-02f, 6.28336892e-02f, -7.28833079e-02f, 1.26787638e-02f, 1.77059427e-01f, 5.98647669e-02f, -7.39591718e-02f,
  -8.10248554e-02f, 7.10614771e-02f, 1.94727376e-01f, 1.61098301e-01f, 1.90782428e-01f, -2.49697734e-03f, -1.56049758e-01f, 1.24236695e-01f, 3.33006829e-01f, 7.15334564e-02f,
  1.61803007e-01f, 5.04028462e-02f, 9.75139812e-02f, 1.40338182e-01f, 1.24696299e-01f, 1.46422252e-01f, 9.80499685e-02f, 7.46927783e-02f, 9.92311686e-02f, -3.91593352e-02f,
  1.74891889e-01f, 1.93415247e-02f, 3.37270647e-02f, -4.90355752e-02f, -9.39068273e-02f, 1.10868700e-01f, -1.07384227e-01f, -8.59989822e-02f, -1.66133285e-01f, 5.01526482e-02f,
  8.11216757e-02f, 5.48764355e-02f, -2.95662731e-02f, 1.42217189e-01f, 4.11702506e-03f, -9.72525403e-02f, -2.79732533e-02f, -9.44214314e-02f, -9.16796774e-02f, 9.09024924e-02f,
  1.49755450e-02f, 2.11248919e-01f, -2.11686045e-01f, 6.01497814e-02f, 2.59100229e-01f, 1.18157193e-01f, -1.59482472e-02f, 9.54370871e-02f, 5.61852008e-02f, -1.16665803e-01f,
  -3.88125814e-02f, -1.31260917e-01f, -1.37479743e-02f, -8.27491432e-02f, -6.73700273e-02f, 1.44997150e-01f, -7.30569661e-02f, 5.66494986e-02f, -6.61123544e-02f, 6.65948261e-03f,
  -2.07560956e-01f, -8.35177600e-02f, 2.02657655e-02f, -3.21608186e-02f, -1.19316898e-01f, -1.23438887e-01f, 4.26888354e-02f, -7.68361464e-02f, -1.28151655e-01f, -8.37138593e-02f,
  -7.56756514e-02f, 1.47408515e-01f, 1.29710957e-01f, 9.50953066e-02f, 2.11172953e-01f, -2.03672834e-02f, 1.61587670e-01f, -1.14250816e-01f, -2.42578406e-02f, 2.66914546e-01f,
  1.78367004e-01f, 4.19473127e-02f, 1.12813659e-01f, 1.51950315e-01f, 1.35705292e-01f, 1.34649634e-01f, -2.29426362e-02f, -1.15668684e-01f, -6.03897646e-02f, -4.23853062e-02f,
  -4.64679599e-02f, -3.21064852e-02f, -1.62591338e-01f, -1.11071534e-01f, -1.66602731e-02f, -9.88179911e-03f, -1.12358399e-01f, 2.67409980e-01f, -1.21029496e-01f, 5.02975211e-02f,
  -6.29720837e-02f, 5.51224202e-02f, 7.53320679e-02f, -3.61731090e-03f, 7.25234277e-04f, 2.37695217e-01f, -8.51088837e-02f, 2.18530878e-01f, -9.85089764e-02f, 2.59960201e-02f,
  1.10113271e-01f, 3.40830907e-02f, -1.00146644e-02f, 5.16982749e-02f, -3.54372077e-02f, 3.41327153e-02f, -7.23108500e-02f, 1.00078546e-01f, -1.05933025e-01f, -1.20589184e-02f,
  -6.31548688e-02f, 2.81163365e-01f, 4.55294773e-02f, 8.31321534e-03f, -1.16360709e-01f, -1.97914783e-02f, -4.78270985e-02f, 2.43398566e-02f, 1.09785661e-01f, 3.24928463e-02f,
  -3.12949456e-02f, -7.99202099e-02f, 1.11924276e-01f, -2.75155101e-02f, -1.98553968e-02f, -1.86239198e-01f, 9.90108550e-02f, 8.67556185e-02f, -5.61610609e-02f, -9.88833159e-02f,
  1.12151518e-01f, -4.29313257e-02f, 1.89433962e-01f, -5.78541867e-02f, 1.14954636e-01f, -7.24594109e-04f, 7.29790889e-03f, 7.32046887e-02f, -4.68201824e-02f, 1.76208422e-01f,
  1.01111099e-01f, 1.25452891e-01f, 6.98834434e-02f, 1.01320460e-01f, -9.80546698e-02f, -6.26295581e-02f, 1.75841711e-02f, 5.04061356e-02f, -5.29057421e-02f, 8.30285624e-03f,
  -1.07018970e-01f, 4.94770380e-03f, -1.19622625e-01f, 9.53829568e-03f, 9.64481905e-02f, -9.57498476e-02f, -8.57574586e-03f, 1.64459329e-02f, 1.76050626e-02f, -7.71262450e-03f,
  9.10321921e-02f, -1.08184755e-01f, -1.11389361e-01f, -1.37059823e-01f, 1.70010537e-01f, -9.50504094e-02f, 4.66798842e-02f, 1.30070344e-01f, -1.01539254e-01f, 9.92584676e-02f,
  -1.59396492e-02f, 5.62036112e-02f, -1.34705797e-01f, -3.43180448e-02f, -5.53291366e-02f, 7.16377189e-03f, 1.13795467e-01f, -4.92712557e-02f, -1.51061993e-02f, -6.40278384e-02f,
  2.04147622e-02f, -8.31736550e-02f, 1.49624720e-01f, 1.30737573e-01f, 1.28392160e-01f, 5.02786376e-02f, 1.46996230e-01f, -1.68513924e-01f, -1.53035484e-02f, 1.27236813e-01f,
  1.43380016e-01f, 1.16241783e-01f, 5.87004870e-02f, -5.86331673e-02f, -2.11425684e-02f, 2.48062581e-01f, 3.00108157e-02f, -9.97957885e-02f, -4.07322533e-02f, 1.43963486e-01f,
  -5.63041754e-02f, -5.33845089e-02f, -4.30504158e-02f, 1.96950763e-01f, -6.44171983e-02f, -4.15252633e-02f, 2.70712078e-02f, 7.94996321e-02f, -3.68634611e-02f, 2.58976758e-01f,
  -6.20548390e-02f, -5.24555854e-02f, -3.85632515e-02f, 6.26594722e-02f, -4.83508371e-02f, 3.43727022e-02f, 4.62954352e-03f, -3.12554613e-02f, -8.03075433e-02f, -1.67558447e-01f,
  9.37761590e-02f, 1.47564977e-01f, 5.23608886e-02f, 9.51889604e-02f, -9.71757397e-02f, -1.24296196e-01f, -6.32242952e-03f, -1.12378635e-01f, 6.70102686e-02f, -8.20906460e-02f,
  -2.67040841e-02f, 7.56324828e-02f, -6.97643682e-02f, -1.25670537e-01f, -1.27724081e-01f, 9.88175906e-03f, 2.96565257e-02f, 1.12803631e-01f, 1.37440503e-01f, 1.31849200e-01f,
  2.21948717e-02f, 3.80564816e-02f, 1.24190688e-01f, 8.94099772e-02f, 1.53772473e-01f, -4.24080938e-02f, -1.43250655e-02f, 1.95783272e-04f, -2.42848307e-01f, -1.58256978e-01f,
  4.67714034e-02f, -2.19889015e-01f, 6.57102615e-02f, 1.27113774e-01f, 5.08963346e-01f, 5.31773716e-02f, 7.05435872e-02f, 2.35263333e-01f, -6.25866465e-03f, 2.28084981e-01f,
  -1.13435544e-01f, -6.73483834e-02f, -1.18419804e-01f, -1.76506247e-02f, 3.06236476e-01f, -1.55716851e-01f, -1.20854869e-01f, 2.95463264e-01f, -1.46744084e-02f, -4.68431935e-02f,
  -1.49354696e-01f, 1.61627308e-02f, -1.46065041e-01f, 2.86020547e-01f, 2.46892765e-01f, -2.13708684e-01f, 9.45858210e-02f, -2.33486425e-02f, -4.42958660e-02f, -7.09644929e-02f,
  4.22838703e-02f, -4.89940494e-02f, -1.46715920e-02f, -1.13258632e-02f, 2.96522994e-02f, 4.45077956e-01f, -1.53394733e-02f, 1.39676303e-01f, 4.33462858e-02f, -9.17707384e-02f,
  -2.15924699e-02f, 1.13282196e-01f, 4.10890765e-02f, -8.88312757e-02f, 2.50694931e-01f, -2.74329130e-02f, -1.58435792e-01f, -1.74455002e-01f, 7.20663890e-02f, 5.02422564e-02f,
  1.18941128e-01f, 2.38727227e-01f, 2.99408555e-01f, 5.43374419e-02f, 3.77532723e-03f, -7.73401707e-02f, 3.71960923e-02f, 1.13323946e-02f, 8.86287019e-02f, -4.03610095e-02f,
  -4.73192595e-02f, 1.45553470e-01f, 7.55431317e-03f, 1.31557077e-01f, 1.00217080e-02f, -8.23042467e-02f, 7.31547847e-02f, 1.96977288e-01f, 1.16695128e-01f, 1.97775692e-01f,
  2.24700406e-01f, -9.97391641e-02f, -7.58499652e-02f, 7.90011957e-02f, 9.03871506e-02f, -1.26807848e-02f, -7.34607056e-02f, 5.64949624e-02f, 1.52363241e-01f, 1.39109015e-01f,
  9.81969014e-02f, 4.96096462e-02f, 1.14328571e-01f, -1.14812054e-01f, -2.85740420e-02f, -3.30046304e-02f, -9.30771604e-02f, 1.11486576e-01f, -1.07341453e-01f, 4.38833944e-02f,
  -1.99866071e-02f, -7.13105053e-02f, -2.20636167e-02f, 1.81910053e-01f, 1.55301228e-01f, 7.20177172e-03f, -8.96042958e-02f, -2.96374075e-02f, -5.13410103e-03f, 1.05085947e-01f,
  -1.22758307e-01f, -6.01955131e-02f, 9.18328390e-02f, -6.40719384e-02f, 1.61171556e-01f, 9.47600752e-02f, 2.84443684e-02f, -5.41131347e-02f, 3.93158421e-02f, -1.49879679e-01f,
  8.66296981e-03f, -1.67085025e-02f, -7.49445930e-02f, 4.58371267e-02f, 9.45582986e-02f, -6.56204224e-02f, 1.34774297e-01f, 9.74806249e-02f, -2.78825928e-02f, -1.05364479e-01f,
  2.90584215e-03f, -4.13730219e-02f, -8.87194648e-02f, 2.50772405e-02f, -9.03595015e-02f, -1.15467094e-01f, -4.45949696e-02f, -3.09816021e-02f, 1.84055120e-01f, -1.49205670e-01f,
  4.46552448e-02f, -6.25295639e-02f, 2.57334888e-01f, 1.63080320e-01f, -7.83559978e-02f, 1.36042029e-01f, -1.00822464e-01f, 1.23948932e-01f, 1.22485518e-01f, 1.09114937e-01f,
  5.18068410e-02f, 1.26973689e-01f, -5.60393333e-02f, -5.29367849e-02f, -2.56895572e-02f, 8.43756571e-02f, 2.73493957e-02f, 1.25655860e-01f, -6.78889081e-02f, 5.53622143e-03f,
  2.47907247e-02f, -3.91252944e-03f, 8.63667279e-02f, -8.09824020e-02f, -1.75949838e-02f, 8.30335692e-02f, -9.51488391e-02f, 3.02453283e-02f, 1.02469496e-01f, 1.28079563e-01f,
  -5.89241320e-03f, -3.22993845e-02f, 6.08644150e-02f, 2.45987520e-01f, 1.54999867e-01f, 1.59131065e-02f, -8.65874067e-02f, -4.72109346e-03f, 1.04378507e-01f, 5.16271591e-02f,
  7.11747855e-02f, 8.07359740e-02f, 5.10657020e-02f, -7.50081837e-02f, 9.04114321e-02f, -6.61827698e-02f, -6.05251640e-02f, -2.50448603e-02f, 3.28051373e-02f, -5.68732657e-02f,
  9.06232744e-02f, -6.78179562e-02f, -1.09122977e-01f, -1.57175153e-01f, 1.89224005e-01f, 1.79057911e-01f, 1.52610153e-01f, 1.78902611e-01f, 1.21062219e-01f, 8.07947591e-02f,
  1.48368672e-01f, 3.61593328e-02f, -3.11056338e-02f, 3.75027061e-02f, 1.67342782e-01f, -1.30542949e-01f, -3.11826710e-02f, 7.08765164e-02f, 8.36864561e-02f, -1.12669691e-01f,
  -4.02128120e-04f, -1.16686232e-01f, 7.57427290e-02f, 4.00399938e-02f, 1.19147398e-01f, -1.27056867e-01f, -1.29689202e-01f, 1.73549309e-01f, 3.81289534e-02f, 7.20219016e-02f,
  -8.39267746e-02f, 7.27783656e-03f, -8.76701698e-02f, -8.54307637e-02f, 1.42185781e-02f, -1.17672242e-01f, -2.77233068e-02f, 6.53935373e-02f, 4.00455445e-02f, -5.05609810e-02f,
  -7.62568042e-02f, 9.98640582e-02f, -4.50146645e-02f, 3.27964057e-03f, 5.64226694e-03f, 1.10227287e-01f, 9.90284905e-02f, -1.26653433e-01f, 2.36981232e-02f, -4.92785461e-02f,
  -9.80583057e-02f, -5.59245199e-02f, 1.52750522e-01f, -1.54454755e-02f, 1.01035079e-02f, 2.50814259e-02f, 9.72436219e-02f, 1.89685538e-01f, -5.42516187e-02f, 1.78534955e-01f,
  7.94192590e-03f, -2.61570364e-02f, -1.74272545e-02f, -7.71518350e-02f, -1.55950829e-01f, 1.34220392e-01f, -1.10900998e-01f, -3.53915803e-02f, 7.99790993e-02f, 1.80394530e-01f,
  -5.69830090e-02f, -8.34347904e-02f, 1.56839311e-01f, 1.59645483e-01f, 1.41087398e-02f, 7.65381753e-02f, -1.63357370e-02f, -1.22603193e-01f, -7.66975209e-02f, 6.95036352e-02f,
  7.15646073e-02f, 5.17697036e-02f, 1.81275368e-01f, -1.02718897e-01f, 3.34290750e-02f, 1.56305447e-01f, 4.61408831e-02f, -1.15196548e-01f, -1.04938531e-02f, -4.36505489e-03f,
  6.87097013e-02f, -1.05426461e-01f, -8.61505121e-02f, -1.13164961e-01f, -8.90656859e-02f, 1.02775618e-02f, -9.88029018e-02f, -7.34123290e-02f, -3.43280807e-02f, 1.51675090e-01f,
  -8.92505497e-02f, 1.40608847e-01f, 2.72766482e-02f, -1.28322229e-01f, -9.83546302e-02f, 7.43356720e-02f, -2.61757784e-02f, -2.60362141e-02f, -1.05745487e-01f, -1.07225254e-01f,
  7.35921115e-02f, -4.12285374e-03f, -1.32303774e-01f, 1.10441692e-01f, -4.88552544e-03f, -9.57144946e-02f, -8.73919204e-02f, -5.22029772e-02f, -1.22899301e-01f, 9.60209593e-02f,
  4.53978330e-02f, -1.34780630e-01f, -6.76197633e-02f, -1.03843525e-01f, -1.53055685e-02f, 4.19343784e-02f, 2.55772807e-02f, 1.31651923e-01f, 3.62374932e-02f, 7.67676309e-02f,
  -1.11597016e-01f, 4.26678620e-02f, -3.65252569e-02f, 1.46913484e-01f, 1.21349037e-01f, 7.63465390e-02f, 5.47762178e-02f, 1.27449678e-02f, -1.38938911e-02f, -1.26697347e-01f,
  -1.87291294e-01f, 5.34069315e-02f, 6.44902885e-02f, 3.61633375e-02f, -7.53616542e-02f, -5.59410788e-02f, -1.12151630e-01f, -1.17203057e-01f, 6.24374114e-02f, -1.49158835e-01f,
  -3.54998037e-02f, 3.16907428e-02f, -7.91895017e-02f, 3.31153497e-02f, 1.09834924e-01f, 9.06446278e-02f, -5.19130640e-02f, 2.34837346e-02f, 6.35577664e-02f, -1.05751239e-01f,
  -9.63566005e-02f, -8.75548124e-02f, -5.68051301e-02f, -6.52013272e-02f, 1.20194545e-02f, -9.98470411e-02f, 1.69689599e-02f, 1.10376626e-01f, 8.83557722e-02f, 7.68621489e-02f,
  -9.91524756e-02f, 3.37541383e-03f, -3.30602936e-02f, 1.97236717e-01f, -2.20729914e-02f, 7.46633112e-02f, -1.03897609e-01f, 6.56986162e-02f, 1.90474018e-02f, -2.70483512e-02f,
  -4.31494080e-02f, 7.93434680e-02f, 5.19177727e-02f, 6.06000163e-02f, -5.83358705e-02f, 2.00891748e-01f, 9.15486589e-02f, -1.11409207e-03f, -1.09921746e-01f, 4.75298762e-02f,
  1.10235661e-01f, -1.11486129e-01f, -1.26369998e-01f, -4.40385602e-02f, -6.45699427e-02f, 6.24721237e-02f, 2.26650029e-01f, 1.65843487e-01f, 3.17928851e-01f, 2.20759753e-02f,
  2.70211309e-01f, 1.94222525e-01f, 1.86658442e-01f, -2.26580918e-01f, 6.89053163e-02f, 8.05595610e-03f, -2.15562984e-01f, 8.16933513e-02f, -9.82945636e-02f, -1.36939466e-01f,
  -1.33308368e-02f, 6.93083853e-02f, 3.95709276e-02f, 1.23056076e-01f, 1.89729244e-01f, -1.59891888e-01f, 1.72821224e-01f, 1.09971315e-01f, -1.66549772e-01f, -3.55911739e-02f,
  3.48518342e-02f, 1.40797526e-01f, -3.56781925e-03f, 3.72941531e-02f, 1.20053023e-01f, 1.47359386e-01f, -1.43054381e-01f, -3.04324478e-02f, -2.28871964e-02f, 3.13190728e-01f,
  -4.97783944e-02f, -3.08315590e-04f, 1.19084917e-01f, -1.06398933e-01f, -1.29686251e-01f, -1.54372975e-01f, 4.41314057e-02f, 3.51563916e-02f, -1.43605813e-01f, -1.68895513e-01f,
  -5.56364097e-03f, 1.42355219e-01f, -5.06724864e-02f, -1.99679341e-02f, -2.13672090e-02f, -8.61527920e-02f, 7.49812052e-02f, 1.20850094e-01f, -2.46415008e-03f, -4.19158628e-03f,
  5.52151389e-02f, 1.01613678e-01f, 4.54684813e-03f, 1.21871926e-01f, 4.19439115e-02f, 1.69164151e-01f, -1.11828938e-01f, 3.21116596e-02f, -3.84122133e-02f, 1.21106595e-01f,
  2.64237020e-02f, -3.97446826e-02f, -5.22939824e-02f, 8.84269699e-02f, 1.30528770e-02f, 2.12165564e-01f, 4.40580063e-02f, -5.92500381e-02f, -6.24745078e-02f, -1.92097247e-01f,
  1.03322892e-02f, -3.49676944e-02f, 2.74713665e-01f, 3.30920331e-02f, 9.56004560e-02f, -2.75493097e-02f, -8.55194703e-02f, 4.77320105e-02f, 1.36262178e-01f, 1.30581483e-01f,
  1.96602747e-01f, 4.20237780e-02f, 8.05667713e-02f, 1.87773984e-02f, 1.85440898e-01f, -3.40615027e-02f, 1.35350570e-01f, -1.31345913e-02f, 4.81065176e-02f, -7.90225640e-02f,
  -8.73703808e-02f, -2.68690325e-02f, -1.73042655e-01f, -3.24275135e-03f, 1.96581576e-02f, 8.47656876e-02f, -3.00203878e-02f, 1.24877430e-01f, -1.79122947e-02f, -1.00989915e-01f,
  1.15369307e-02f, 2.72272564e-02f, 1.07337989e-01f, -9.81649011e-02f, -3.42015438e-02f, 3.82996388e-02f, -1.38053834e-01f, 8.73738751e-02f, 1.91824958e-01f, 7.60094300e-02f,
  1.70695171e-01f, -1.16961710e-01f, 2.59597003e-02f, -1.37920395e-01f, 1.96555555e-02f, 4.81354408e-02f, -1.10092506e-01f, -1.91753432e-02f, 1.15581080e-01f, -7.79070854e-02f,
  9.53394696e-02f, 9.07160342e-02f, 1.18675277e-01f, -7.74744712e-03f, 2.99294479e-02f, 1.17224209e-01f, 1.46075189e-01f, 3.52815054e-02f, -8.74104276e-02f, 2.16977239e-01f,
  3.29844020e-02f, -1.02676809e-01f, -1.59856141e-01f, 1.59174502e-01f, 1.97413310e-01f, -9.22460034e-02f, -4.57957014e-02f, -9.06965733e-02f, 1.73142359e-01f, -8.03976581e-02f,
  3.28209437e-02f, -6.94295764e-02f, 1.65148071e-04f, 1.87767625e-01f, -8.45114961e-02f, -6.57094782e-03f, 2.80599058e-01f, 2.44385943e-01f, 4.80156690e-02f, -1.20404758e-01f,
  1.46427020e-01f, 1.04864292e-01f, 1.59447249e-02f, -2.42327675e-02f, -1.26324836e-02f, 1.21161811e-01f, -2.49539898e-03f, -1.22200856e-02f, 8.99723247e-02f, 1.03761889e-01f,
  -3.45960422e-03f, 3.02092642e-01f, 1.92305464e-02f, 5.69931418e-03f, 9.51946601e-02f, 2.08458174e-02f, 8.10438842e-02f, 7.79656321e-03f, 1.04043841e-01f, -4.07630056e-02f,
  -5.61281480e-03f, 2.02182129e-01f, 2.71139294e-02f, 2.09683970e-01f, -1.41006500e-01f, -2.51914375e-03f, -5.76917380e-02f, 7.15401918e-02f, -9.47986618e-02f, 4.98424917e-02f,
  -2.61988211e-02f, 3.63056213e-01f, -4.46059108e-02f, -8.35119486e-02f, -6.45540208e-02f, 1.35638312e-01f, 3.58349294e-03f, -8.45808387e-02f, -1.55907050e-01f, -1.85650170e-01f,
  8.69869068e-02f, 1.53518870e-01f, 2.56294254e-02f, 8.72334093e-02f, -1.77501515e-01f, -7.87618160e-02f, 2.12424025e-02f, -7.68878460e-02f, 2.61046384e-02f, -2.35141188e-01f,
  6.12271763e-03f, -1.32907599e-01f, 1.11406997e-01f, -3.21286395e-02f, 1.39797643e-01f, -5.96441627e-02f, 1.12145180e-02f, -8.72089118e-02f, 2.28272811e-01f, -1.22406632e-01f,
  3.03270221e-01f, -2.15292182e-02f, 1.12757767e-02f, 5.25582721e-03f, -7.44482577e-02f, 1.38490777e-02f, -9.97916982e-02f, -1.48644969e-01f, 5.76049760e-02f, 1.01193875e-01f,
  3.91765572e-02f, -1.49599001e-01f, 3.03025916e-02f, -5.27010188e-02f, -1.26555145e-01f, 5.32457680e-02f, -6.18750677e-02f, -2.68847365e-02f, -7.99080431e-02f, -1.12594299e-01f,
  -1.02731019e-01f, 5.02837934e-02f, 2.73303956e-01f, 1.35045618e-01f, 2.22182274e-01f, 6.59321845e-02f, -1.54925406e-01f, -2.86113918e-02f, -5.59195764e-02f, 2.17645969e-02f,
  1.92190334e-01f, 9.94426757e-03f, -2.05772948e-02f, 1.13960113e-02f, -7.70567134e-02f, 7.57489875e-02f, 6.38398603e-02f, 1.04828887e-01f, 2.00259775e-01f, -1.80638712e-02f,
  -6.84700459e-02f, -1.07777007e-01f, -9.14198384e-02f, -2.27299541e-01f, 1.12672590e-01f, -7.94654638e-02f, 1.41083390e-01f, 8.08707476e-02f, -2.15814412e-01f, -1.27637729e-01f,
  9.44134500e-03f, -8.39964002e-02f, 4.70914412e-03f, -2.40758717e-01f, 9.52631012e-02f, -1.20462030e-01f, -1.36866108e-01f, 1.79865479e-01f, -7.47002065e-02f, -2.10873038e-01f,
  1.23899572e-01f, 1.64541423e-01f, 2.33305097e-01f, -1.58566937e-01f, 1.44893095e-01f, 1.32251695e-01f, 1.95389856e-02f, 1.09806396e-01f, -1.35001019e-01f, 6.94686547e-02f,
  1.08737834e-01f, -2.28713360e-02f, 1.97625365e-02f, 7.41808712e-02f, 6.43828809e-02f, -2.41058037e-01f, -8.27677771e-02f, -9.91559848e-02f, 1.10049903e-01f, -1.11576490e-01f,
  -1.27290159e-01f, -3.38273346e-02f, 7.66051337e-02f, -8.86094347e-02f, 3.20522115e-02f, 7.03531206e-02f, 2.19585419e-01f, 1.88130260e-01f, 1.86709583e-01f, 1.87469691e-01f,
  -1.50719121e-01f, -5.94668463e-02f, 1.90277696e-01f, -5.72058074e-02f, 9.85346735e-02f, 1.30094007e-01f, -1.14882916e-01f, -8.18972290e-02f, 2.63411610e-04f, 6.98421225e-02f,
  4.72464599e-03f, 1.75282121e-01f, 5.54879457e-02f, 1.46614641e-01f, -2.63510253e-02f, -4.80238050e-02f, 1.34270906e-01f, -4.11420055e-02f, 4.49881554e-02f, -1.46228354e-02f,
  5.52323498e-02f, 1.45451441e-01f, -9.02727991e-02f, -3.58826295e-02f, -2.59623043e-02f, 1.10574245e-01f, 1.26020044e-01f, 1.15027100e-01f, 3.65325451e-01f, 1.54026821e-01f,
  -1.27036199e-01f, 1.51261047e-01f, -1.08508132e-01f, -1.82689875e-02f, -1.65403947e-01f, 4.26791497e-02f, -6.62694033e-03f, -7.89861679e-02f, 4.58425432e-02f, -3.40811573e-02f,
  7.18112662e-02f, 1.75728410e-01f, 4.93569560e-02f, -6.12562746e-02f, -7.81730562e-02f, -5.49667440e-02f, -6.03782237e-02f, 3.40381749e-02f, -3.50555517e-02f, -4.37014028e-02f,
  6.08727150e-03f, 6.49597272e-02f, 6.36712685e-02f, 3.92606966e-02f, -1.24836475e-01f, -7.05078393e-02f, 7.05706626e-02f, 1.67885020e-01f, 9.52346176e-02f, 1.97570488e-01f,
  1.81850772e-02f, 1.23851048e-02f, -9.88160968e-02f, 1.62564144e-01f, 1.33910954e-01f, -8.54731053e-02f, 4.19680215e-02f, -3.70924994e-02f, 1.42725846e-02f, 1.25780299e-01f,
  2.11975779e-02f, -3.33066545e-02f, 3.13398317e-02f, 1.86853074e-02f, 1.30894601e-01f, -9.42367762e-02f, 1.42185435e-01f, 2.98178084e-02f, 4.70053442e-02f, -4.33465689e-02f,
  1.64131269e-01f, 3.59790511e-02f, 9.87381712e-02f, 1.69663489e-01f, 2.85793215e-01f, 7.48841539e-02f, -2.64611319e-02f, -1.31152794e-01f, -2.72430688e-01f, -1.04569688e-01f,
  -6.93854913e-02f, -1.91323206e-01f, -1.97274804e-01f, 1.28365103e-02f, 2.02739358e-01f, -1.54341653e-01f, 1.24753885e-01f, -7.73707405e-02f, -1.80279613e-02f, 3.71596888e-02f,
  2.79723287e-01f, -1.70345396e-01f, 5.90418950e-02f, 2.00271145e-01f, -2.77527317e-04f, -2.02156156e-02f, -1.56949043e-01f, -1.11839995e-02f, 8.84534717e-02f, 9.26608294e-02f,
  3.48278061e-02f, -8.20249841e-02f, -1.39851540e-01f, -2.65857379e-04f, -1.31935060e-01f, 1.46375606e-02f, 2.24091262e-02f, -3.68629955e-02f, 4.83060293e-02f, 3.64360325e-02f,
  -8.74820501e-02f, 1.29754171e-01f, 1.26209050e-01f, -2.60486864e-02f, 1.12368232e-02f, 3.03639650e-01f, -4.13542241e-02f, 1.02908127e-01f, -1.97475806e-01f, -1.65030971e-01f,
  1.73933730e-01f, -1.26694828e-01f, 4.38344255e-02f, 1.66504204e-01f, 8.34576879e-03f, 4.44827750e-02f, -9.95427743e-02f, 2.43885443e-01f, 1.48659751e-01f, 7.57599398e-02f,
  -1.35281339e-01f, 8.29738230e-02f, 5.69708943e-02f, 1.61104411e-01f, 2.57090688e-01f, 2.82361567e-01f, 4.88586463e-02f, 1.72449321e-01f, 1.69122085e-01f, 1.41123578e-01f,
  2.78941870e-01f, 2.05338389e-01f, -9.40150693e-02f, 6.56840205e-02f, 9.22422018e-03f, 1.24001309e-01f, -7.19217584e-02f, 1.02126047e-01f, 3.82043160e-02f, -2.58940943e-02f,
  6.30073100e-02f, 2.34196052e-01f, -1.98624656e-02f, -9.03047994e-02f, -1.56779051e-01f, 8.21337923e-02f, 1.37880415e-01f, 8.43119919e-02f, 1.94363207e-01f, -4.27123643e-02f,
  1.29233509e-01f, -8.71778056e-02f, -1.26865253e-01f, -2.30364013e-03f, -1.86582655e-02f, -1.41887322e-01f, -1.13123111e-01f, 3.50373447e-01f, -3.57693732e-02f, -1.23683833e-01f,
  8.14562589e-02f, 3.69173363e-02f, 6.49544895e-02f, -1.08515650e-01f, -8.62554833e-02f, 7.32618347e-02f, 4.08291221e-02f, -3.39891948e-02f, -1.20146632e-01f, -8.62096250e-02f,
  -5.51896505e-02f, -5.17319292e-02f, 2.35917047e-01f, 1.48770392e-01f, -1.13951132e-01f, 1.05065465e-01f, 9.32018533e-02f, -1.20176040e-01f, 9.09895897e-02f, 1.42126188e-01f,
  6.73526898e-02f, 1.76004201e-01f, -3.46351825e-02f, 1.55976610e-02f, 1.85120534e-02f, 8.46055076e-02f, -1.39353260e-01f, -1.10898234e-01f, 3.61942463e-02f, 1.08401418e-01f,
  -2.36243475e-02f, 5.36837392e-02f, -2.38834657e-02f, 1.70777366e-01f, -6.56276494e-02f, 1.46445274e-01f, 1.08976722e-01f, 2.73148566e-02f, -2.27400232e-02f, -4.25909236e-02f,
  8.31995532e-02f, -8.76079276e-02f, 1.44267917e-01f, -8.24139118e-02f, -7.53818154e-02f, 1.35997355e-01f, 3.14319367e-03f, -1.20829746e-01f, -1.53081164e-01f, 1.86711531e-02f,
  5.23329414e-02f, -1.25544488e-01f, 3.85069288e-02f, -6.22779354e-02f, -3.54144499e-02f, -7.75016233e-05f, -1.17650382e-01f, -4.52564191e-03f, 8.30035135e-02f, 9.84783992e-02f,
  1.29622400e-01f, 1.80101767e-01f, 9.08743776e-03f, 1.04051106e-01f, 1.02225937e-01f, 9.40392241e-02f, 1.11884065e-01f, -9.65428725e-02f, 9.96612608e-02f, -8.95885602e-02f,
  5.37758544e-02f, -2.56890751e-04f, 1.72382653e-01f, -1.35959694e-02f, 2.02141125e-02f, -1.96517278e-02f, 1.95204571e-01f, -1.55926670e-03f, -6.65424541e-02f, -1.02390148e-01f,
  -2.99087036e-02f, -1.10296324e-01f, -4.32374291e-02f, 1.48412436e-02f, 3.32892276e-02f, 1.47456869e-01f, 3.49253677e-02f, 1.12127839e-02f, 6.60647824e-03f, -7.62128904e-02f,
  6.81241183e-03f, -7.00968951e-02f, 1.87542185e-01f, -2.14134380e-02f, -1.02606472e-02f, 1.56937838e-01f, 1.73550874e-01f, 1.44025581e-02f, 9.30373222e-02f, -7.33550079e-03f,
  -7.79401436e-02f, 7.76350796e-02f, 1.47953004e-01f, 1.48343919e-02f, -3.07094380e-02f, 2.50159036e-02f, -6.41220659e-02f, 1.02161422e-01f, 4.24488634e-03f, -9.86017520e-04f,
  5.12870550e-02f, 3.84287126e-02f, -1.28580630e-01f, -1.62609275e-02f, -1.99640784e-02f, 5.73468171e-02f, 2.08143797e-02f, -8.96548405e-02f, 1.01787694e-01f, -2.61608623e-02f,
  -5.55070005e-02f, 7.91513696e-02f, 2.02940740e-02f, -8.52708742e-02f, 2.14196760e-02f, -1.26732796e-01f, 9.05655995e-02f, 2.67001856e-02f, 2.97753457e-02f, -2.76592970e-02f,
  8.90227705e-02f, 3.32224891e-02f, -5.10393865e-02f, 2.40565315e-01f, -8.60695913e-02f, 7.77474716e-02f, -1.40761882e-01f, 9.04418454e-02f, -9.12247151e-02f, 1.39127076e-01f,
  2.96146683e-02f, -4.72500250e-02f, 8.38396978e-03f, 3.07693076e-03f, 1.01465181e-01f, 2.28837952e-01f, 3.22550014e-02f, -1.16153896e-01f, -8.07568580e-02f, 1.82406455e-01f,
  1.74173847e-01f, 4.16570865e-02f, -7.86459520e-02f, 9.38161537e-02f, -5.11696823e-02f, 9.94503349e-02f, 7.08285943e-02f, 9.46795270e-02f, 3.21020111e-02f, -2.48302862e-01f,
  9.44493786e-02f, -1.25352547e-01f, -9.68060419e-02f, 4.41282839e-02f, -1.63112208e-02f, -3.32884640e-02f, 7.54353702e-02f, -1.15782261e-01f, -3.15225087e-02f, -9.23325270e-02f,
  1.66262299e-01f, -3.77520993e-02f, 1.25304267e-01f, 5.52030802e-02f, -6.01931363e-02f, 4.82186228e-02f, 1.90291137e-01f, -7.61283562e-02f, 8.14203918e-02f, -5.58939856e-03f,
  -2.52707861e-03f, 3.38458084e-02f, -3.31525616e-02f, 6.04505325e-03f, -8.43296479e-03f, 1.78027272e-01f, -1.05633534e-01f, 1.62931129e-01f, -7.65396506e-02f, 8.89188051e-02f,
  4.71460856e-02f, 2.94293836e-03f, 1.14427641e-01f, -7.70921335e-02f, 4.22973484e-02f, 1.01652719e-01f, -1.12257199e-03f, -9.44881439e-02f, -3.77422944e-02f, -1.57010704e-01f,
  -6.31681383e-02f, 1.75194249e-01f, -2.03532390e-02f, 7.61007443e-02f, -1.03008226e-01f, -9.48069245e-02f, 3.11335195e-02f, -3.02350931e-02f, -7.56432638e-02f, -1.69898067e-02f,
  -9.03700069e-02f, -1.25507921e-01f, -8.85790884e-02f, 1.87794089e-01f, 5.24970852e-02f, 1.94451734e-01f, -3.44390459e-02f, -8.79822895e-02f, 4.91117015e-02f, 7.75712505e-02f,
  2.82112211e-01f, 2.95286119e-01f, 2.55725652e-01f, 1.71797946e-01f, -2.41843574e-02f, 1.40731975e-01f, -1.22324582e-02f, -4.45015728e-04f, -2.90536731e-02f, 2.52559602e-01f,
  1.99459061e-01f, -3.41138244e-02f, -2.47562781e-01f, 1.04944013e-01f, -1.36135310e-01f, -6.49065375e-02f, -1.36790022e-01f, -4.02783714e-02f, -1.34604022e-01f, -2.49931470e-01f,
  -1.51672900e-01f, 1.14515454e-01f, 3.64993393e-01f, 3.93808298e-02f, 1.94835261e-01f, -1.09575875e-01f, 1.72905147e-01f, 1.42704964e-01f, -3.32470890e-03f, -1.36876494e-01f,
  -7.74804782e-03f, 2.86817215e-02f, 2.30148807e-01f, 5.98615967e-02f, -1.18712053e-01f, 8.92932992e-03f, -6.62120506e-02f, -4.70898673e-02f, 1.44303173e-01f, -8.56756344e-02f,
  7.51386862e-04f, 1.72618955e-01f, 7.52614588e-02f, -7.48130605e-02f, 4.19419974e-01f, -1.08729072e-01f, 1.59489676e-01f, -1.97644100e-01f, 2.14101270e-01f, 2.45856673e-01f,
  -2.65411079e-01f, -2.49049384e-02f, -2.93022208e-02f, -6.95139319e-02f, 3.04331798e-02f, 1.19722895e-01f, -1.06242694e-01f, 3.13717663e-01f, 7.16848895e-02f, 1.50171906e-01f,
  -6.58821687e-02f, -2.48607725e-01f, -4.32847850e-02f, -5.41134253e-02f, 1.39835238e-01f, 1.15346521e-01f, 9.34792757e-02f, -7.76060745e-02f, -8.57283548e-02f, 9.93331969e-02f,
  4.70875436e-03f, -1.25600159e-01f, 1.47513017e-01f, -3.94602828e-02f, -4.98196892e-02f, -1.12317363e-02f, 7.96208438e-03f, 9.44877416e-02f, 7.81190246e-02f, 1.43159941e-01f,
  2.36976724e-02f, 1.08563162e-01f, 1.91421360e-02f, -1.24373576e-02f, 1.19639486e-02f, -6.00451464e-03f, 7.65377507e-02f, 5.09673245e-02f, 1.38687119e-01f, 7.77738541e-02f,
  8.69354680e-02f, -1.05669215e-01f, -6.50700033e-02f, -9.11417454e-02f, -5.93089499e-02f, -7.15595111e-02f, -4.28285971e-02f, 7.68955126e-02f, -1.00416780e-01f, 4.75240387e-02f,
  -7.72943571e-02f, -1.05992056e-01f, 6.00984693e-02f, 8.14400148e-03f, -9.18472633e-02f, -1.03768468e-01f, 1.31129369e-01f, 1.47184148e-01f, 1.10527366e-01f, -1.98249608e-01f,
  -8.45237449e-02f, 4.91176266e-03f, 2.19548587e-02f, 1.32991374e-01f, 3.99397649e-02f, 2.70731673e-02f, 3.09292250e-03f, -3.44609357e-02f, -7.62711186e-03f, -8.87923166e-02f,
  -4.06926312e-03f, -8.97732526e-02f, 1.23260818e-01f, 4.15215082e-02f, 8.03827792e-02f, -6.28143176e-02f, -9.44679901e-02f, 4.66113202e-02f, -8.65711123e-02f, 4.04240517e-03f,
  8.66548195e-02f, 1.24881994e-02f, 5.05963191e-02f, 1.93565490e-03f, -8.23926851e-02f, 4.87946011e-02f, -4.99766842e-02f, 6.65363669e-02f, 7.30049610e-02f, 5.24722785e-02f,
  -7.60795027e-02f, -1.08318292e-01f, 1.01994313e-01f, -5.42371310e-02f, 8.45013484e-02f, -9.88564938e-02f, 1.05015613e-01f, 1.94556266e-01f, 3.08114905e-02f, -6.39217570e-02f,
  2.34822016e-02f, -2.31891368e-02f, -3.04798055e-02f, -9.98106301e-02f, -8.73345137e-02f, -5.81947751e-02f, -8.14327598e-02f, 1.11222796e-01f, -7.08447993e-02f, -2.84436159e-03f,
  2.85141878e-02f, 2.24552974e-02f, -9.71714184e-02f, -6.63536694e-03f, 9.87977535e-02f, 2.49929339e-01f, -7.32376873e-02f, -7.54445568e-02f, 4.59479168e-02f, 8.13726932e-02f,
  1.07376138e-02f, 1.35839447e-01f, -1.03872307e-01f, 4.62841382e-03f, 1.16709702e-01f, 1.68667197e-01f, -1.29177645e-01f, 5.49749881e-02f, -5.74681088e-02f, 9.01935156e-03f,
  -1.42745450e-02f, 1.16177209e-01f, 1.14994571e-01f, 9.96246785e-02f, -6.85886666e-02f, 1.85029432e-01f, 1.55761272e-01f, -4.93686758e-02f, -7.21944794e-02f, 1.34425372e-01f,
  -5.17750047e-02f, -8.04619715e-02f, -5.89757673e-02f, -1.25435069e-01f, 1.81202486e-01f, 6.02823682e-02f, 3.26300338e-02f, 6.61678240e-02f, 1.06208466e-01f, -1.73087671e-01f,
  5.29239699e-02f, 1.92466360e-02f, 7.98157975e-02f, -2.76812196e-01f, 1.63935289e-01f, 1.33716658e-01f, 7.40215704e-02f, 2.18084138e-02f, 8.40913281e-02f, -1.71349257e-01f,
  1.84745163e-01f, -1.07027374e-01f, 2.66341090e-01f, 6.83597103e-02f, -1.22061791e-02f, 3.37670967e-02f, 1.46272629e-01f, 1.98007628e-01f, -5.46614118e-02f, 1.10469088e-01f,
  -6.29411116e-02f, -4.69976738e-02f, 1.68555416e-02f, -8.58711004e-02f, -5.54693379e-02f, -1.46980388e-02f, -1.14519596e-01f, 6.98096603e-02f, 7.93425813e-02f, -1.60345703e-01f,
  -3.24581861e-02f, 8.96900147e-02f, 1.57271698e-01f, 1.20800778e-01f, -1.15055472e-01f, 1.74986169e-01f, 2.56133556e-01f, 2.29904912e-02f, -1.30433947e-01f, -2.93113873e-03f,
  2.25891337e-01f, 7.93657675e-02f, 2.08231732e-01f, 6.48304150e-02f, 2.45664969e-01f, 1.24568284e-01f, -4.45837528e-02f, -5.67029826e-02f, -8.75460207e-02f, -1.32651776e-01f,
  -1.19185247e-01f, 6.16577901e-02f, -5.69946505e-02f, -1.75601076e-02f, 1.16939686e-01f, 7.60388076e-02f, 7.45604336e-02f, 6.26024883e-03f, 1.85891077e-01f, 1.70631185e-01f,
  1.61313459e-01f, 1.94738984e-01f, -1.60014942e-01f, -5.06207757e-02f, -6.82803541e-02f, -9.77326557e-02f, 3.16605256e-05f, 9.04974267e-02f, 1.36881337e-01f, -3.45801972e-02f,
  -4.46756333e-02f, 1.59928113e-01f, -1.02713563e-01f, 8.16690996e-02f, 7.05491975e-02f, -1.15533983e-02f, -1.78420976e-01f, 3.27515565e-02f, 5.53302765e-02f, 4.64392789e-02f,
  -1.10847712e-01f, -9.02954768e-03f, -3.40125449e-02f, -1.12435929e-01f, -1.03389390e-01f, -4.90632243e-02f, -6.37907758e-02f, 9.30503383e-02f, 1.70470655e-01f, -9.76344645e-02f,
  3.50863002e-02f, -8.32140446e-02f, 2.41109841e-02f, -1.42617479e-01f, -1.41955353e-02f, -1.25932500e-01f, 1.33515447e-01f, 1.82085738e-01f, 3.87590453e-02f, 1.95376817e-02f,
  1.35568324e-02f, -1.16725259e-01f, -2.91632898e-02f, 1.24834277e-01f, 7.07975551e-02f, -5.87722380e-03f, 5.49465269e-02f, -9.43863764e-02f, 1.25602648e-01f, 1.61855400e-01f,
  6.21003509e-02f, -1.25086337e-01f, -9.36039537e-02f, -1.20991059e-02f, 2.28429735e-01f, 1.98503807e-01f, 1.00803740e-01f, -1.05805509e-01f, -6.05411194e-02f, -3.29168998e-02f,
  -1.12233959e-01f, -7.35374689e-02f, 2.31001899e-02f, 1.40612125e-01f, 1.50647918e-02f, 1.89113304e-01f, 7.64717162e-02f, 7.91522041e-02f, 2.83325855e-02f, -1.25326902e-01f,
  -1.89318314e-01f, -2.54735965e-02f, -4.49540950e-02f, -1.25023037e-01f, 2.83064753e-01f, -8.90889317e-02f, 8.91938806e-02f, 8.75354260e-02f, 1.16254374e-01f, 1.13948628e-01f,
  6.65548444e-02f, 5.32518663e-02f, 2.40026966e-01f, -4.19179238e-02f, 3.60361896e-02f, 4.35255393e-02f, 7.30899274e-02f, 4.25494201e-02f, -6.72962703e-03f, -7.22488835e-02f,
  1.09442495e-01f, 1.59946471e-01f, 2.53942590e-02f, 8.61685127e-02f, 1.11774035e-01f, -1.09321006e-01f, 1.17061064e-01f, -8.93660858e-02f, 2.86275931e-02f, 1.21385321e-01f,
  7.41177350e-02f, -1.82105586e-01f, 2.95408685e-02f, -7.69895837e-02f, 1.43210068e-01f, 2.46457115e-01f, 1.59633890e-01f, -9.36373472e-02f, 1.13477886e-01f, -6.63376451e-02f,
  6.02473132e-03f, -6.86489642e-02f, -4.25722264e-02f, -1.74370095e-01f, -2.19769292e-02f, -4.26011207e-03f, -2.72179563e-02f, -2.86898054e-02f, -1.36174560e-02f, 1.69207871e-01f,
  4.28315531e-03f, 1.10713661e-01f, -2.32919771e-02f, -5.23440428e-02f, -8.76740515e-02f, -6.62374720e-02f, 5.68645783e-02f, -3.85923386e-02f, 1.18325211e-01f, 5.92251793e-02f,
  1.21772345e-02f, -7.52607957e-02f, -5.93465902e-02f, 7.76485428e-02f, 7.36767948e-02f, 1.45628259e-01f, 3.81290391e-02f, -4.75713275e-02f, -6.77787736e-02f, 9.24958587e-02f,
  8.78006406e-03f, -1.94829758e-02f, -5.22493292e-03f, 9.67462361e-02f, 1.04876980e-01f, 1.25637725e-02f, -8.88033360e-02f, -3.66237806e-03f, -7.66805420e-03f, 7.51224384e-02f,
  -1.13529516e-02f, 7.56882802e-02f, -1.15017302e-01f, -6.86579645e-02f, 1.07414097e-01f, -1.04517907e-01f, -5.79176471e-02f, -9.38376486e-02f, 5.53364493e-03f, -6.20253161e-02f,
  6.39356077e-02f, -5.50110489e-02f, 3.16618569e-02f, -6.26034336e-03f, -9.95102301e-02f, -1.07683297e-02f, -6.97012916e-02f, 1.15322478e-01f, -7.75118172e-02f, -1.10218525e-01f,
  1.11293420e-01f, -8.16281512e-02f, -5.68654388e-02f, -9.35504586e-02f, -5.97618595e-02f, -8.68176692e-04f, -2.50816010e-02f, 9.23696682e-02f, -1.18933946e-01f, -6.33218959e-02f,
  -1.00421034e-01f, -3.23969424e-02f, -1.04070678e-01f, 2.52280850e-02f, 8.37893263e-02f, 1.13253281e-01f, -7.02837482e-02f, -7.40150437e-02f, -1.02974042e-01f, 9.19313580e-02f,
  -1.02633022e-01f, 7.09865391e-02f, 2.10321620e-02f, -2.55936702e-05f, -6.81864768e-02f, 1.50634367e-02f, -8.13229755e-02f, -1.34083465e-01f, -1.05672861e-02f, -8.14360008e-02f,
  -7.67776147e-02f, -1.10294707e-01f, 1.71791852e-01f, -1.19666770e-01f, 1.04043499e-01f, 1.84779130e-02f, 1.64030984e-01f, -6.61252951e-03f, 9.02579129e-02f, 8.04528594e-02f,
  8.11276808e-02f, -8.09413940e-02f, 2.06485279e-02f, -5.21692224e-02f, -1.22947082e-01f, -9.43347812e-02f, 4.64545451e-02f, -1.11251771e-01f, 5.93132041e-02f, 1.90612972e-01f,
  6.24710321e-02f, 1.85162231e-01f, 8.23507980e-02f, -5.74918054e-02f, -6.46811649e-02f, 8.16996694e-02f, 8.67311656e-02f, -1.18728518e-01f, 1.05685674e-01f, -1.04059810e-02f,
  -6.68132007e-02f, 6.56159371e-02f, 1.05642959e-01f, 1.60568487e-02f, -4.00781892e-02f, -7.37151429e-02f, -6.22667223e-02f, 7.19935354e-03f, -7.47740492e-02f, 1.14654928e-01f,
  5.59185147e-02f, -9.11637768e-02f, 5.29424250e-02f, -6.86279610e-02f, -1.20692544e-01f, 2.37510838e-02f, -7.61936605e-02f, -2.77811587e-02f, -4.20917086e-02f, 6.22069202e-02f,
  -1.01063021e-01f, 1.23405419e-01f, -1.28343672e-01f, -8.68751481e-02f, -4.84483540e-02f, 5.03503717e-02f, -1.16218232e-01f, -1.10899523e-01f, -7.30805919e-02f, 9.83264446e-02f,
  -7.94590637e-02f, -4.87203449e-02f, -3.92770730e-02f, 4.09983248e-02f, -6.46812320e-02f, -9.31091979e-03f, 4.74790856e-02f, 1.41197005e-02f, -6.29906654e-02f, 9.35496166e-02f,
  9.18205157e-02f, -6.39659688e-02f, -6.79134578e-02f, 1.08818211e-01f, -6.49807081e-02f, 5.77499683e-04f, -1.08772591e-02f, -5.11785410e-02f, 6.37244433e-02f, 1.03447214e-01f,
  1.14276186e-01f, 1.26847863e-01f, -2.88822986e-02f, -5.44142872e-02f, 4.19352278e-02f, 2.85900123e-02f, 3.64149325e-02f, -5.75770950e-03f, 5.98972775e-02f, -2.67844088e-02f,
  -6.93156049e-02f, -2.61181425e-02f, -1.02317661e-01f, 8.39191768e-03f, 7.58879408e-02f, 6.77980855e-02f, 6.87469915e-02f, 9.09670535e-03f, -2.37453124e-03f, -6.75880089e-02f,
  1.18126133e-02f, -6.03490323e-02f, -8.49495158e-02f, -6.97296932e-02f, -1.09608069e-01f, 5.97195886e-02f, 9.09760594e-02f, -1.10087492e-01f, 5.57871945e-02f, 4.47070934e-02f,
  -1.01995014e-01f, -4.91021611e-02f, -1.08931646e-01f, 1.11256398e-01f, 8.85885805e-02f, 1.14026211e-01f, 2.87884027e-01f, 8.70671421e-02f, 6.50715008e-02f, 2.08217651e-01f,
  6.04661219e-02f, 1.73784673e-01f, -7.76868612e-02f, -1.97336689e-01f, -1.58766776e-01f, 2.58759230e-01f, 2.56806821e-01f, -1.22598514e-01f, 1.95002094e-01f, -2.53124442e-02f,
  -6.08222671e-02f, 1.69365361e-01f, -1.83261171e-01f, 8.51802155e-02f, -4.85331714e-02f, -5.04959859e-02f, -9.39248353e-02f, -1.42237976e-01f, 2.33523101e-01f, 5.67278266e-02f,
  5.32519482e-02f, -6.35859072e-02f, -6.32186681e-02f, 1.50874346e-01f, -8.18486661e-02f, -3.18426942e-03f, 3.84973339e-03f, 3.67635079e-02f, -9.00178850e-02f, -1.57208622e-01f,
  -2.17942726e-02f, 3.29717360e-02f, 1.15886919e-01f, 8.79612267e-02f, -1.18507177e-01f, -1.17420107e-01f, 1.67237241e-02f, 2.28219122e-01f, -8.68314058e-02f, 1.05253281e-03f,
  1.19961128e-01f, -1.54385567e-01f, -5.33182621e-02f, 8.34572092e-02f, -3.87736224e-02f, -3.66975777e-02f, 6.38902932e-03f, 3.15844156e-02f, 1.18959313e-02f, 2.14956135e-01f,
  -7.48532116e-02f, 9.58831459e-02f, -8.26831833e-02f, 8.26832503e-02f, 1.83357909e-01f, -4.22738418e-02f, 6.21339586e-03f, -3.31156701e-02f, -4.25782874e-02f, 1.92419626e-02f,
  2.10885480e-01f, 1.06062606e-01f, 1.19955488e-01f, -1.52909636e-01f, 8.95372778e-03f, -3.56963743e-03f, 2.26850491e-02f, -8.80183056e-02f, -6.84464350e-02f, 3.16710249e-02f,
  1.22142732e-01f, -1.77689403e-01f, 1.18872173e-01f, 1.14104711e-01f, 7.23499209e-02f, -2.46445965e-02f, -8.61507505e-02f, 1.55861840e-01f, -3.29836905e-02f, -1.75526440e-02f,
  -2.53048819e-02f, 1.15735352e-01f, 3.04886580e-01f, -2.62129935e-03f, 1.41863614e-01f, -1.22997768e-01f, -7.23260045e-02f, 2.13849917e-02f, -1.24589860e-01f, -2.67820787e-02f,
  -1.50467366e-01f, 7.08570704e-02f, -2.97801252e-02f, 9.21143293e-02f, 1.02186553e-01f, 6.31802306e-02f, -3.88560742e-02f, -1.00753881e-01f, 9.10741612e-02f, 3.48575674e-02f,
  2.64416039e-02f, 2.97634117e-02f, -2.84390803e-02f, 2.01859474e-02f, 1.25755116e-01f, -1.00988321e-01f, 6.02511317e-02f, -6.71198666e-02f, 6.81001395e-02f, 1.74235731e-01f,
  -1.57537013e-01f, -7.76891485e-02f, 6.32319450e-02f, 3.16566080e-02f, -7.58809000e-02f, -1.70663923e-01f, 3.19637321e-02f, 1.85546622e-01f, 9.72936600e-02f, -9.67510343e-02f,
  2.87429001e-02f, -1.85738385e-01f, -2.25309301e-02f, -8.53976905e-02f, 9.03170407e-02f, 6.55421466e-02f, 1.44803077e-01f, -1.98050216e-02f, 1.73529878e-01f, 2.67891679e-02f,
  1.75711989e-01f, 1.95791498e-01f, -3.71145345e-02f, -2.45561451e-01f, -1.34997010e-01f, 2.54072011e-01f, -1.68250620e-01f, 2.72613131e-02f, 2.69806176e-01f, -1.34512261e-01f,
  1.62293270e-01f, -6.14855252e-02f, 2.01595753e-01f, 2.85274714e-01f, 3.54016125e-02f, 1.16787171e-02f, -8.70931074e-02f, 2.25909486e-01f, 1.48543000e-01f, 1.73367709e-02f,
  7.98824616e-03f, -5.70060238e-02f, 1.52488708e-01f, -1.31086975e-01f, -7.46626966e-03f, -5.82847046e-03f, -1.26935750e-01f, 3.69174629e-01f, 6.40906692e-02f, -2.45441310e-02f,
  1.93997622e-01f, 9.94932279e-02f, -8.39629173e-02f, 6.80699721e-02f, -1.24094523e-01f, 3.06388736e-02f, -6.32157102e-02f, -7.62382597e-02f, 3.58783081e-02f, 2.59645730e-01f,
  8.97690132e-02f, 5.45892231e-02f, -1.08972862e-01f, 8.02236274e-02f, -1.01445772e-01f, -9.26845074e-02f, -1.22505352e-01f, -5.12912683e-03f, 8.29590112e-02f, 1.53116569e-01f,
  -9.53605771e-02f, 5.56042865e-02f, 5.76165393e-02f, 1.26326337e-01f, -8.12237710e-02f, 1.69945005e-02f, -1.50912656e-02f, 2.84378938e-02f, 1.08556800e-01f, -6.56678400e-04f,
  -6.83693066e-02f, -1.31256161e-02f, -6.19738437e-02f, 8.87510404e-02f, 3.39829288e-02f, 1.18449263e-01f, 1.09170809e-01f, -1.86981633e-01f, -4.09170538e-02f, 4.85702045e-02f,
  1.82309315e-01f, 1.18179163e-02f, 4.81683351e-02f, 1.24558690e-03f, -1.06121937e-03f, 1.88358754e-01f, 9.01234150e-02f, -3.23999993e-04f, 1.09351560e-01f, 1.29722923e-01f,
  3.42967957e-02f, -6.99847490e-02f, -2.67717857e-02f, 1.05780818e-01f, -5.47723360e-02f, -3.74980946e-03f, -1.08292863e-01f, 1.70126893e-02f, -6.75942078e-02f, -2.25029550e-02f,
  -7.27944970e-02f, 7.75619224e-02f, 3.13836411e-02f, -7.48519376e-02f, 3.41497958e-02f, -2.15354394e-02f, -1.36527508e-01f, -4.07205820e-02f, -1.33354142e-01f, -1.01520857e-02f,
  -3.97353806e-02f, -5.54269850e-02f, -1.32552654e-01f, 2.19075084e-01f, -1.53951854e-01f, 1.10906467e-01f, -1.21032204e-02f, -1.63358673e-02f, 1.41390026e-01f, 9.88082960e-03f,
  -8.61859843e-02f, 5.81138348e-03f, -1.09716013e-01f, 3.70951407e-02f, 2.52820440e-02f, -1.54757500e-01f, 1.66355267e-01f, 1.33050203e-01f, 1.38214044e-02f, 1.13747522e-01f,
  3.01578324e-02f, -4.47929017e-02f, -2.71689501e-02f, -8.88483003e-02f, 1.09279558e-01f, -1.15233399e-01f, -1.14445478e-01f, 2.48304754e-02f, -6.73093572e-02f, 5.60686812e-02f,
  1.37088120e-01f, 5.35209291e-02f, -9.07364413e-02f, -4.02212851e-02f, -3.92750613e-02f, 5.57038970e-02f, -4.71985042e-02f, -1.07780192e-02f, 6.89477101e-02f, 9.80686955e-03f,
  -6.61796927e-02f, 1.20771423e-01f, -2.66502127e-02f, 2.27037407e-02f, -1.10855371e-01f, 1.02962486e-01f, -1.01153024e-01f, -4.27031629e-02f, -4.81350347e-02f, 3.37153077e-02f,
  -8.37479681e-02f, 8.40834975e-02f, -2.07099970e-02f, 1.85987428e-02f, 1.84787083e-02f, 7.22117797e-02f, -7.27127269e-02f, 1.10686079e-01f, 1.03249326e-01f, 4.27856222e-02f,
  -1.13106214e-01f, 5.23651615e-02f, 7.85554871e-02f, -8.77368748e-02f, -7.12380782e-02f, -1.25581408e-02f, 8.91386643e-02f, 9.21141952e-02f, 5.85428663e-02f, 1.01225987e-01f,
  5.78060700e-03f, -1.51706557e-03f, 3.85949835e-02f, -6.39082789e-02f, -6.31217137e-02f, 8.45481604e-02f, -1.14743702e-01f, 9.24317613e-02f, -1.57454138e-04f, -7.96815678e-02f,
  -1.01208098e-01f, -9.33532715e-02f, -3.69067900e-02f, 7.83718377e-02f, 7.98249394e-02f, 1.06904916e-02f, -7.61616454e-02f, 1.11128487e-01f, -3.79127217e-03f, 4.87983190e-02f,
  -2.60874089e-02f, -8.81558359e-02f, 5.93538024e-02f, -5.86202070e-02f, 2.15626843e-02f, -1.55804725e-02f, 5.73497154e-02f, 1.80530444e-01f, 2.76846826e-01f, 6.18265793e-02f,
  -5.12759574e-02f, 3.61279026e-02f, -2.41725259e-02f, 1.41847700e-01f, -1.02252930e-01f, 8.54552314e-02f, -1.52971104e-01f, 5.73844239e-02f, -9.99551192e-02f, 1.25822946e-01f,
  7.23024383e-02f, 1.76430210e-01f, -3.13200727e-02f, -1.11507140e-01f, -1.11138992e-01f, 1.16140343e-01f, 1.25533370e-02f, 7.42919892e-02f, -9.43082327e-04f, 1.14196688e-01f,
  -2.48536728e-02f, -9.16474015e-02f, 7.04574808e-02f, 1.33386612e-01f, 8.00055712e-02f, 9.41660702e-02f, 1.58151146e-02f, 9.15190652e-02f, -1.80425774e-02f, 1.17943287e-01f,
  -3.88272144e-02f, 3.29101160e-02f, -4.99745645e-02f, -7.22372681e-02f, 8.95441398e-02f, 9.91846994e-02f, -5.72086498e-03f, -2.64647715e-02f, 1.61128893e-01f, 7.04018250e-02f,
  8.75289068e-02f, 6.39208183e-02f, -7.18717128e-02f, -1.15448922e-01f, 8.73918831e-02f, 2.09227800e-02f, 2.33775172e-02f, 5.73713481e-02f, -1.21867992e-01f, -1.22372709e-01f,
  9.04827565e-02f, -4.90060747e-02f, 3.64325941e-02f, 2.89163133e-03f, 1.53939664e-01f, -3.94342914e-02f, -9.61042643e-02f, 9.62155089e-02f, 2.25170888e-02f, -3.64416353e-02f,
  1.21024959e-01f, -2.78593670e-03f, -3.25625278e-02f, -6.20715544e-02f, -4.09339815e-02f, 9.53635573e-02f, 1.91485137e-02f, 8.59029144e-02f, 9.23130214e-02f, -1.10317573e-01f,
  -1.82628840e-01f, 5.61305098e-02f, -4.69018668e-02f, 1.28819689e-01f, -1.28959849e-01f, 1.64056793e-01f, -6.14537261e-02f, 8.37956369e-02f, -1.16766408e-01f, 2.54660305e-02f,
  -5.89649342e-02f, 1.55522719e-01f, 7.91977495e-02f, -9.24149156e-02f, 5.22389896e-02f, 3.60047445e-02f, -5.82424551e-02f, -6.54237196e-02f, -2.91694291e-02f, -8.66618231e-02f,
  6.20077550e-02f, 1.33909732e-01f, -1.30670488e-01f, 1.25621200e-01f, 8.57593026e-04f, 7.90019184e-02f, 6.60427427e-03f, -1.51606202e-02f, 2.60321163e-02f, 9.60682034e-02f,
  -3.46100740e-02f, 1.35596335e-01f, -4.17038128e-02f, 1.33594379e-01f, 7.37265646e-02f, 1.20052144e-01f, -1.11153454e-01f, 3.40723014e-03f, 3.34655121e-02f, 1.45333067e-01f,
  1.49502233e-01f, 8.54281709e-02f, -8.91956091e-02f, -1.32122070e-01f, 2.86545992e-01f, 1.41305000e-01f, 1.02840260e-01f, 2.91943192e-01f, 1.82556450e-01f, 1.12781890e-01f,
  -1.80362344e-01f, -2.34015733e-01f, -1.31971538e-01f, 2.63315052e-01f, 2.66314328e-01f, -2.55692869e-01f, -1.75229475e-01f, -1.51819987e-02f, -7.41207525e-02f, 1.50444046e-01f,
  -1.21905878e-02f, -1.63126186e-01f, -1.10828742e-01f, -1.89847603e-01f, -8.45975950e-02f, -7.04263011e-03f, 3.49894613e-01f, -3.66691425e-02f, -1.27814054e-01f, -1.00520439e-01f,
  -3.57609950e-02f, 3.73655022e-03f, 3.08401752e-02f, -9.36468467e-02f, -9.73685607e-02f, 1.77720621e-01f, 1.89895809e-01f, 8.07308108e-02f, 6.12004027e-02f, -4.97787558e-02f,
  1.28153386e-02f, -1.37537956e-01f, 8.82029757e-02f, -9.24625769e-02f, 1.41433418e-01f, 9.47240666e-02f, 6.02041818e-02f, 1.24044798e-01f, 2.95392573e-01f, -7.97972828e-02f,
  1.56900454e-02f, 7.88763165e-02f, -6.00889064e-02f, -3.91994836e-03f, -1.02852814e-01f, -4.06190977e-02f, 1.19604692e-01f, 1.64563075e-01f, 1.51059004e-02f, -8.72768536e-02f,
  -1.05219945e-01f, 1.28091261e-01f, 7.84109831e-02f, 6.90532029e-02f, 1.59809411e-01f, -9.84061435e-02f, -9.64096859e-02f, -7.03503042e-02f
};

// L2_fan_Bp_bar (Shape: 1 x 52)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 52;
const float L2_fan_Bp_bar_data[] = {
  1.34981619e-02f, 1.74121469e-01f, -2.05064211e-02f, 6.57737628e-02f, 8.56815651e-02f, 1.67568743e-01f, 8.38952437e-02f, 9.97045636e-03f, -1.82615817e-02f, 2.29592416e-02f,
  8.53582770e-02f, 2.76689790e-02f, 2.23020747e-01f, 1.94415420e-01f, 1.03796706e-01f, -8.94259959e-02f, -1.55512905e-02f, 7.84936398e-02f, -2.26819925e-02f, -2.86091566e-02f,
  -4.87217605e-02f, 6.83029741e-02f, 4.63587269e-02f, -8.78242403e-03f, 1.87054887e-01f, -1.04150318e-01f, -2.04530079e-02f, 2.15402301e-02f, 1.69878621e-02f, 6.44650236e-02f,
  1.69509590e-01f, 2.57138401e-01f, 3.03442944e-02f, 9.03661847e-02f, 1.41677290e-01f, 2.81870902e-01f, -7.58199999e-03f, 8.68862960e-03f, 1.43756285e-01f, 7.23365024e-02f,
  -4.80165519e-02f, -4.96274605e-02f, -4.48907167e-02f, -2.65849661e-02f, 1.29891381e-01f, 1.28983617e-01f, 1.21508710e-01f, 1.05520278e-01f, -3.48993763e-02f, 4.37752083e-02f,
  1.28544167e-01f, 2.70729274e-01f
};

// L3_linear_W (Shape: 12 x 64)
const int L3_linear_W_rows = 12;
const int L3_linear_W_cols = 64;
const float L3_linear_W_data[] = {
  -2.49710709e-01f, -3.80085647e-01f, -2.24546149e-01f, -2.25585654e-01f, -3.81855488e-01f, -1.60524815e-01f, -1.67365298e-01f, 2.32170984e-01f, -2.82681257e-01f, 8.26036781e-02f,
  3.44881207e-01f, -2.24065945e-01f, -3.97216417e-02f, 6.31348267e-02f, 3.44376534e-01f, -1.69993728e-01f, 1.79418191e-01f, 3.26448947e-01f, -7.02107474e-02f, 4.53177989e-02f,
  1.92148343e-01f, 2.90742256e-02f, -1.47583634e-01f, 2.88523763e-01f, -5.99573404e-02f, -2.33951852e-01f, 1.18037224e-01f, 1.08371049e-01f, 1.77171916e-01f, 1.73950538e-01f,
  3.35312068e-01f, -5.88270910e-02f, 2.50100285e-01f, 8.86478461e-03f, -9.58530903e-02f, 5.73746860e-02f, -3.08416784e-01f, -1.16263106e-01f, -2.25237846e-01f, 3.41235995e-01f,
  3.53682786e-01f, -3.55038606e-02f, -1.47406310e-01f, -3.21691483e-01f, -9.25272331e-02f, -1.35936067e-01f, 9.93506089e-02f, -2.96433270e-01f, -7.59581923e-02f, 9.42865014e-02f,
  1.01421826e-01f, -1.27104566e-01f, 2.11495638e-01f, 6.28582463e-02f, 6.97124377e-02f, -2.95308102e-02f, -2.27724463e-01f, -6.22020774e-02f, -1.64054945e-01f, 1.22605562e-02f,
  -1.14985947e-02f, -2.16570534e-02f, 8.26752335e-02f, -2.71063834e-01f, -4.44395207e-02f, -1.69532433e-01f, -2.68320553e-03f, 3.26700769e-02f, -2.66410738e-01f, -1.10237569e-01f,
  2.74184555e-01f, 1.45601286e-02f, 8.75838697e-02f, -9.07786638e-02f, 1.91367958e-02f, 1.77975390e-02f, 1.77347541e-01f, -4.87377234e-02f, -2.26293713e-01f, -1.49315298e-01f,
  -6.26895577e-02f, 4.54655170e-01f, 3.23616624e-01f, 1.45016029e-01f, 2.03374714e-01f, -5.82661107e-02f, 9.07081440e-02f, 3.81678231e-02f, -1.47746310e-01f, -1.76584478e-02f,
  1.21288382e-01f, 4.34214324e-01f, 1.58027604e-01f, 4.14558873e-03f, -3.57433170e-01f, -2.02325255e-01f, -2.37524524e-01f, -4.35802042e-02f, -5.94456457e-02f, 1.34863937e-02f,
  4.86342609e-02f, 2.49344960e-01f, 7.88171515e-02f, 1.80813983e-01f, 2.99885899e-01f, -2.63701230e-01f, 3.27252209e-01f, -3.45583498e-01f, -2.23343372e-01f, -1.86455891e-01f,
  1.65893450e-01f, -4.55060482e-01f, -7.13078156e-02f, -8.03043228e-03f, 1.79325849e-01f, -3.33209991e-01f, 3.18727642e-01f, -1.54287800e-01f, 1.73609108e-01f, 3.08953077e-02f,
  -2.49898717e-01f, -2.59566039e-01f, 2.69045591e-01f, 1.56112224e-01f, -2.30962541e-02f, -2.32400522e-01f, -2.76188433e-01f, -2.60436356e-01f, 3.37846160e-01f, 3.62372249e-01f,
  2.89169818e-01f, -5.56200333e-02f, -2.26830170e-01f, 6.74606204e-01f, -2.53879011e-01f, 1.38886616e-01f, -1.89973950e-01f, -5.04421115e-01f, -4.32214975e-01f, -1.19770117e-01f,
  -4.17633802e-01f, 1.47228286e-01f, -1.68305933e-01f, -8.36212412e-02f, 8.18770975e-02f, 6.88902676e-01f, 9.95376930e-02f, 1.19601570e-01f, 1.51680231e-01f, -2.37868920e-01f,
  -1.09675467e-01f, -1.56590685e-01f, -1.40962929e-01f, 7.26610571e-02f, -3.24067823e-03f, -1.08089894e-01f, 1.39624551e-01f, -7.56461993e-02f, -1.17285661e-01f, -1.34783283e-01f,
  -5.78822196e-02f, 2.35340983e-01f, -8.42501819e-02f, -4.13373001e-02f, 3.29001158e-01f, 2.08727434e-01f, -3.12703103e-01f, -5.95536493e-02f, 1.72701329e-01f, 1.90251380e-01f,
  3.28719020e-01f, -1.18887484e-01f, -1.29275590e-01f, 1.65065825e-01f, -1.32981673e-01f, -4.01120305e-01f, -2.41037980e-02f, -8.64497647e-02f, 3.40520233e-01f, 1.77922189e-01f,
  -2.23616973e-01f, -1.08802384e-02f, -9.24194530e-02f, 2.78743007e-03f, 2.03196198e-01f, -1.76459089e-01f, -1.29922718e-01f, 2.40646768e-02f, -5.75183816e-02f, 6.51967153e-02f,
  3.65944467e-02f, 7.26070479e-02f, -1.61613047e-01f, 7.18731210e-02f, 5.23632802e-02f, -9.81329009e-02f, 1.54073611e-01f, 2.33768433e-01f, -2.90279478e-01f, -4.88026254e-02f,
  3.65351498e-01f, -2.99340785e-01f, 1.72295958e-01f, 1.89529866e-01f, 1.05404183e-02f, -8.61404240e-02f, 1.30361304e-01f, 3.06479394e-01f, -1.67144611e-01f, -3.44558686e-01f,
  -3.39184642e-01f, -9.13852602e-02f, -1.14924628e-02f, 1.72067389e-01f, -9.40237120e-02f, 1.08555928e-01f, 6.14217622e-03f, 3.01257763e-02f, 3.29268396e-01f, 1.24653727e-01f,
  5.23035461e-03f, 2.78759688e-01f, 3.65560949e-01f, 3.03797781e-01f, 1.44143581e-01f, -1.34544566e-01f, 1.95130885e-01f, 4.76356782e-03f, -2.85442621e-01f, 1.89097106e-01f,
  -2.29244649e-01f, -1.40687183e-01f, -3.72706831e-01f, 1.47943944e-01f, -2.98667580e-01f, 1.81239083e-01f, 6.85687587e-02f, 2.80740801e-02f, -2.01762855e-01f, -2.57384092e-01f,
  2.09105849e-01f, -1.93588123e-01f, -3.37916836e-02f, 5.85938245e-02f, 1.58723276e-02f, 6.36138618e-02f, -5.01061305e-02f, 1.07889861e-01f, -1.74726080e-03f, 1.55912980e-01f,
  -1.85434252e-01f, 2.41487488e-01f, -6.83301538e-02f, 1.95764989e-01f, 6.87840814e-03f, -1.08290225e-01f, 1.03412993e-01f, -2.23070547e-01f, -2.84890175e-01f, -2.97076374e-01f,
  2.47552358e-02f, 7.30088353e-03f, -1.98164620e-02f, -2.69175053e-01f, 5.16743004e-01f, -2.07760766e-01f, -3.37888837e-01f, 4.15491104e-01f, -1.60173774e-01f, -1.79325998e-01f,
  1.98036328e-01f, 4.18326557e-02f, 1.39935806e-01f, 7.37055615e-02f, -2.79217482e-01f, -6.58842772e-02f, -1.36749163e-01f, -1.45805389e-01f, -6.91033080e-02f, 6.06412403e-02f,
  -1.48817778e-01f, -5.02186753e-02f, -6.79604337e-02f, -1.53428063e-01f, -9.76474285e-02f, 8.37459862e-02f, 4.27937210e-01f, -5.48900478e-02f, 1.42945528e-01f, -2.07642049e-01f,
  -1.73334107e-01f, -1.65833190e-01f, -1.06743157e-01f, -1.01021737e-01f, 5.13339601e-02f, 1.86843097e-01f, 2.09860727e-01f, 1.41798854e-01f, -4.21076357e-01f, -2.51495063e-01f,
  1.24996506e-01f, -1.49207383e-01f, -2.01159298e-01f, 3.01578254e-01f, 1.70593560e-01f, 2.13706084e-02f, 7.64836818e-02f, 3.54100406e-01f, -2.05808207e-02f, 1.65428594e-02f,
  -5.75052798e-02f, 2.36557499e-02f, 2.14354500e-01f, -1.91230420e-02f, -1.20015413e-01f, -4.40439954e-02f, 1.64546855e-02f, 1.47358745e-01f, 2.37138510e-01f, 2.66461611e-01f,
  1.85360417e-01f, 8.49218965e-02f, -4.56550568e-02f, 3.03182930e-01f, -3.01778674e-01f, 1.90417096e-01f, 9.55372080e-02f, -1.93385873e-02f, 2.01382905e-01f, 6.44641370e-02f,
  -3.79030675e-01f, 4.22985137e-01f, 2.69297451e-01f, -7.95719996e-02f, 6.63595274e-02f, 1.81679919e-01f, -1.01951279e-01f, 1.35666221e-01f, 3.39169800e-01f, 5.37514053e-02f,
  -1.36972498e-02f, 8.89454931e-02f, -3.72519530e-02f, 2.56855875e-01f, -1.06699973e-01f, -1.52979791e-01f, -1.89784288e-01f, -1.86398327e-01f, -1.66955471e-01f, 8.11570734e-02f,
  4.11282070e-02f, 1.12497225e-01f, -2.63498783e-01f, -1.39067292e-01f, 2.08278209e-01f, -2.94050444e-02f, 8.29384997e-02f, -6.23599142e-02f, 7.80639201e-02f, 2.58214325e-01f,
  -1.11862555e-01f, -2.51121819e-01f, 1.09572828e-01f, -1.37458118e-02f, 9.86498296e-02f, -1.11431621e-01f, 5.58670238e-02f, 2.64891118e-01f, -4.29460704e-02f, 7.86050037e-03f,
  -2.57692814e-01f, 3.34069394e-02f, 3.50922316e-01f, 3.44340317e-02f, 2.46964544e-01f, 2.60285661e-02f, -8.42530802e-02f, 1.73104003e-01f, 7.36758783e-02f, -1.33229986e-01f,
  -5.65252453e-02f, -2.69764870e-01f, 1.04440032e-02f, 3.61374289e-01f, 2.46581241e-01f, -4.22394238e-02f, -6.00961708e-02f, 9.64455307e-02f, 2.75769919e-01f, -3.15450490e-01f,
  3.61213028e-01f, 4.25126880e-01f, -5.60453475e-01f, 2.33187228e-01f, 4.20562178e-02f, -3.83602381e-01f, 9.56395790e-02f, 5.01888245e-02f, -1.66115433e-01f, -2.75892735e-01f,
  -3.42156515e-02f, -1.44829214e-01f, -7.11861923e-02f, -1.28661348e-02f, -2.20022008e-01f, -6.58744797e-02f, 2.14815438e-01f, -3.47342283e-01f, -2.47434452e-02f, -7.81001598e-02f,
  -3.67401391e-01f, -2.87501931e-01f, 4.79450934e-02f, -2.27898076e-01f, -5.94677031e-01f, -2.79195637e-01f, -1.60391778e-01f, 2.81128019e-01f, -1.49447367e-01f, 1.95637062e-01f,
  5.23244850e-02f, -2.96777189e-01f, 2.03593448e-01f, -1.36295101e-02f, -1.90364406e-01f, -1.61617115e-01f, 2.81208664e-01f, 2.30574876e-01f, -6.23838268e-02f, 2.18192130e-01f,
  1.82914943e-01f, 6.58314586e-01f, -8.90631825e-02f, -7.21198991e-02f, -2.32404396e-02f, -7.04851672e-02f, -2.68976808e-01f, -1.07137859e-01f, -1.02923863e-01f, -2.98706517e-02f,
  3.62954915e-01f, 2.71346927e-01f, -2.83179879e-01f, -1.37025893e-01f, -1.06918439e-01f, -1.80843845e-01f, 2.24697012e-02f, 4.68344629e-01f, -1.20117188e-01f, -2.75083989e-01f,
  -3.01976413e-01f, -2.10820744e-03f, 3.35329883e-02f, -3.16391230e-01f, -1.28703313e-02f, 2.01901004e-01f, -8.56522545e-02f, 1.54042080e-01f, 2.28134990e-01f, -1.78166017e-01f,
  -5.64416386e-02f, -8.90265852e-02f, -1.77657068e-01f, -1.67500004e-01f, 1.07358560e-01f, -4.80227709e-01f, -3.38684350e-01f, -9.90631878e-02f, 6.65426031e-02f, 2.78217375e-01f,
  -1.43939540e-01f, -2.33593553e-01f, 3.24921846e-01f, 1.04455724e-01f, -1.45432716e-02f, 4.20846492e-01f, -8.95707309e-02f, 2.97379512e-02f, -1.06213607e-01f, 1.02512740e-01f,
  -2.51581781e-02f, 1.57004297e-01f, -1.55483991e-01f, 1.63096055e-01f, -2.72091180e-01f, 1.47401914e-01f, 4.66313541e-01f, -8.43263790e-02f, -3.88234220e-02f, 1.77065447e-01f,
  1.73867971e-01f, 8.34768862e-02f, -8.51237029e-02f, 2.59193242e-01f, 9.19325054e-02f, -9.06262398e-02f, -1.73375562e-01f, 3.26310068e-01f, -3.70800078e-01f, -1.34310588e-01f,
  -2.32276186e-01f, 7.94748142e-02f, -2.28495616e-02f, 1.25835761e-01f, 1.92803785e-01f, -8.96886289e-02f, 1.85477450e-01f, 3.03849597e-02f, -3.30620352e-03f, 3.96941230e-02f,
  -4.02120352e-02f, -2.44615033e-01f, 1.65554553e-01f, 3.24593335e-01f, 3.20931673e-01f, -4.39223647e-03f, 3.16985846e-01f, 5.21906793e-01f, -1.68275476e-01f, 6.91419914e-02f,
  -7.95303434e-02f, 2.05045417e-01f, -5.25227040e-02f, 5.69047518e-02f, 2.18489885e-01f, 2.21727237e-01f, -2.24109977e-01f, -1.04922570e-01f, -2.09288999e-01f, -5.39918363e-01f,
  -1.10174119e-01f, 1.96636803e-02f, 2.63737857e-01f, 3.27951491e-01f, 2.84834743e-01f, 1.72997899e-02f, 3.60163480e-01f, 2.68290281e-01f, -3.74307334e-02f, 2.49094088e-02f,
  -5.92918284e-02f, -1.52536988e-01f, -5.22964239e-01f, 1.11983009e-01f, 4.00517927e-03f, 1.74044564e-01f, -4.39796485e-02f, 1.01180404e-01f, 1.48921952e-01f, -4.99784686e-02f,
  3.53318937e-02f, -1.76582992e-01f, -3.55820894e-01f, -1.42147884e-01f, 2.82986145e-02f, 5.14194489e-01f, 1.26993850e-01f, 4.54986580e-02f, -1.72493428e-01f, 8.60651582e-02f,
  1.29335215e-02f, 1.58245713e-01f, -2.97009438e-01f, -1.14977516e-01f, 1.13163702e-01f, 8.52146670e-02f, 1.29091665e-01f, -3.94462384e-02f, -1.02544568e-01f, -2.64670849e-01f,
  5.51232100e-01f, -5.05835637e-02f, -6.97086528e-02f, -3.35589647e-02f, -2.37798616e-02f, -2.20917299e-01f, 3.24540704e-01f, 8.42594504e-02f, 3.75755876e-01f, 2.71980077e-01f,
  2.31420562e-01f, -8.66654068e-02f, 7.21112713e-02f, 1.64498966e-02f, -1.44121587e-01f, -4.18897837e-01f, -4.60980572e-02f, -6.19431853e-01f, 6.59181550e-02f, -2.93582398e-02f,
  8.79365504e-02f, -4.27334309e-02f, 2.49108687e-01f, 2.33727321e-01f, -2.31028020e-01f, -1.14755012e-01f, -1.59826651e-01f, -1.30939230e-01f, -1.52143970e-01f, -3.69657457e-01f,
  -1.16062440e-01f, -2.14472786e-01f, -3.19684178e-01f, -1.19762113e-02f, 2.17456259e-02f, -2.62882799e-01f, 3.43223631e-01f, -2.24722251e-01f, -9.92358848e-02f, -1.53340891e-01f,
  -3.72553170e-02f, 1.69233322e-01f, -2.86320299e-01f, -7.54126236e-02f, 1.36366904e-01f, 2.68380165e-01f, 3.42269868e-01f, 3.16915423e-01f, -3.02310735e-02f, -2.00200036e-01f,
  -4.53498513e-02f, 1.73473597e-01f, -1.28408978e-02f, 1.01624001e-02f, -3.47714312e-02f, 2.11864874e-01f, 6.62294542e-03f, 1.40402272e-01f, -2.14473516e-01f, 9.44876112e-03f,
  -2.13913415e-02f, -3.68121080e-02f, 4.17026073e-01f, 1.69714332e-01f, -3.82543355e-01f, -2.64327109e-01f, -9.41531509e-02f, -1.25260353e-01f, 7.43142590e-02f, 4.35514539e-01f,
  -1.84848383e-01f, -1.51152790e-01f, -6.34564683e-02f, 1.07237399e-01f, 9.18660611e-02f, -2.29542866e-01f, -4.80738491e-01f, -1.35721326e-01f, 3.60457033e-01f, 3.91438484e-01f,
  -6.70251027e-02f, 4.89619642e-01f, -1.77258879e-01f, 7.30949268e-02f, 6.23360500e-02f, 1.15778796e-01f, 9.02213752e-02f, -4.76785958e-01f, 3.59137893e-01f, -4.78729904e-02f,
  2.46006139e-02f, 8.01248327e-02f, -1.27405375e-01f, 4.44496006e-01f, 2.98765637e-02f, 1.23362780e-01f, 2.96693653e-01f, -1.08933397e-01f, -1.07094675e-01f, 2.60166287e-01f,
  7.19394535e-02f, -9.34020057e-02f, -1.27346337e-01f, -1.49303362e-01f, 2.63447702e-01f, -7.48941675e-02f, 3.80494833e-01f, -8.99368599e-02f, -3.86058748e-01f, -3.19941938e-01f,
  -1.64003059e-01f, -2.01402660e-02f, 3.12755965e-02f, 3.31559367e-02f, 7.98497051e-02f, 3.24471556e-02f, 3.29157382e-01f, -1.94186524e-01f, -4.76904102e-02f, -5.93704060e-02f,
  -3.57455999e-01f, 6.49262145e-02f, 1.00593112e-01f, -5.76675907e-02f, 4.52827364e-02f, 5.88027351e-02f, -2.93792248e-01f, 1.01454239e-02f, 2.21867025e-01f, 3.22218031e-01f,
  -6.20069541e-03f, 5.68258241e-02f, 1.48940325e-01f, -3.76609445e-01f, -3.09656501e-01f, 2.85676003e-01f, -1.74876943e-01f, -3.56270485e-02f, -7.42967650e-02f, -2.39029735e-01f,
  4.10321712e-01f, -3.79854292e-02f, -2.92869836e-01f, -2.11080723e-02f, 3.35083634e-01f, -3.24762732e-01f, 7.01011866e-02f, 1.47983864e-01f, 7.02611264e-03f, 1.62341893e-01f,
  4.47263420e-02f, -3.43199521e-01f, -3.05930935e-02f, -1.00729227e-01f, -1.63266510e-01f, 2.03358829e-01f, -8.18525404e-02f, -2.94145476e-02f, -1.92503452e-01f, -1.25856595e-02f,
  3.24270666e-01f, -1.38424933e-01f, -1.04743481e-01f, -1.58384219e-01f, -1.41456142e-01f, 1.66794494e-01f, 3.33182816e-03f, 8.03755447e-02f, -1.65090024e-01f, -2.11981684e-01f,
  -8.26415345e-02f, 2.44733691e-01f, 1.92746058e-01f, -1.21063486e-01f, -2.40304545e-01f, 1.16583750e-01f, -4.41468149e-01f, 3.40725332e-01f, 2.03364387e-01f, -6.62773475e-02f,
  -7.43952841e-02f, 5.17827988e-01f, 8.07589218e-02f, -1.74105346e-01f, 2.10625485e-01f, -1.81716859e-01f, 3.09572928e-02f, 1.07409075e-01f, -3.15338448e-02f, 1.90369263e-02f,
  4.26408947e-02f, 3.64388138e-01f, -1.40751556e-01f, 3.14716669e-03f, 3.42376046e-02f, -4.64560511e-03f, -1.16281405e-01f, -7.22580031e-02f
};

// L3_linear_B (Shape: 1 x 12)
const int L3_linear_B_rows = 1;
const int L3_linear_B_cols = 12;
const float L3_linear_B_data[] = {
  -3.07724416e-01f, -1.71377838e-01f, 1.17391698e-01f, -4.40583304e-02f, -1.04988255e-01f, 7.52821341e-02f, 2.55853474e-01f, -1.82834730e-01f, -1.16815520e-02f, 7.72897750e-02f,
  1.27039447e-01f, -7.92668760e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 6, 52
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        64, 6, 52
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        64, 6, 52
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_linear
    linear_forward_pgm(
        buffer1, x_out,
        L3_linear_W_data, L3_linear_B_data,
        64, 12
    );
    }
    