/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 128 (x1)
    * Saída: 12
    * Buffer Máx: 128
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 128;
    const int FAN_MAX_BUFFER_SIZE = 128;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    return (x > 0.0f) ? x : 0.0f;
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 25 x 120)
const int L0_fan_Wp_rows = 25;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  1.57344006e-02f, -1.15498975e-01f, -4.65033622e-03f, -2.30518386e-01f, -8.41544792e-02f, 5.72461970e-02f, -1.14492685e-01f, -7.97977950e-03f, -6.37079254e-02f, 6.65770918e-02f,
  1.70319453e-01f, 2.44557574e-01f, 1.82158738e-01f, 1.09214656e-01f, 3.81191522e-02f, -2.42128655e-01f, -3.80630434e-01f, -7.53644630e-02f, -3.81155871e-02f, -5.09586819e-02f,
  -1.67898983e-01f, -2.32843071e-01f, -1.22836456e-01f, -1.07220635e-01f, -1.79222763e-01f, -4.73864414e-02f, -1.63033620e-01f, -1.37007713e-01f, -4.60565127e-02f, -1.62671551e-01f,
  2.77616411e-01f, 1.47893593e-01f, 3.56541984e-02f, -1.36100268e-02f, -1.31732762e-01f, -9.16401297e-02f, 3.38241234e-02f, -5.16934805e-02f, -5.36414981e-03f, -8.50383863e-02f,
  2.28016526e-02f, 1.33034242e-02f, -5.70240384e-03f, -2.43744515e-02f, -1.51994005e-01f, -6.69259951e-02f, -1.99902654e-01f, -1.35291755e-01f, -1.32466078e-01f, 6.38114065e-02f,
  2.33177356e-02f, -3.52336885e-03f, -1.04827352e-01f, -1.52821630e-01f, 5.35824010e-03f, -1.40747603e-03f, -2.22217012e-02f, 2.92786434e-02f, -1.18314065e-01f, -1.84222102e-01f,
  -4.28658463e-02f, 1.84053108e-02f, 5.84948547e-02f, 1.17017142e-02f, 2.35599279e-02f, 4.63134684e-02f, 1.67677109e-03f, 2.13955785e-03f, -3.18003143e-03f, -5.58468848e-02f,
  -3.58046331e-02f, -3.75547595e-02f, -4.29972354e-03f, -5.79071343e-02f, -4.85973954e-02f, 7.85921589e-02f, 3.85724986e-03f, 2.37352792e-02f, -2.14495864e-02f, 1.28651857e-01f,
  1.56580601e-02f, 1.03818260e-01f, 6.31929040e-02f, 9.61639509e-02f, 4.46075425e-02f, -4.41634767e-02f, 3.02836895e-02f, 1.46548823e-02f, 6.09577857e-02f, 9.19657201e-02f,
  2.06148904e-02f, -1.29151419e-02f, 2.69710310e-02f, 3.86677012e-02f, 1.57499220e-02f, -8.23369697e-02f, 4.28297222e-02f, 9.10437852e-03f, 4.40659299e-02f, -3.08660232e-02f,
  -7.76900561e-04f, -3.57956067e-03f, -8.68743807e-02f, -2.27040071e-02f, 1.49703063e-02f, -5.53847216e-02f, -1.55704588e-01f, -9.51011926e-02f, 3.36991325e-02f, -1.82201229e-02f,
  -1.03194132e-01f, -4.11651097e-02f, 3.14127505e-02f, -2.82803997e-02f, -3.25920768e-02f, 1.61007866e-02f, 2.89373323e-02f, -1.01078749e-01f, -1.96564496e-02f, -1.39448315e-01f,
  1.98260844e-01f, 2.65129596e-01f, 2.64843941e-01f, 1.55601427e-01f, 5.79556003e-02f, 6.40309379e-02f, 1.46185085e-01f, -1.15884217e-02f, -3.73344682e-02f, 8.06569234e-02f,
  -1.07086711e-02f, -1.87744886e-01f, -9.93928015e-02f, -1.40777826e-01f, -6.10465072e-02f, 1.58818692e-01f, 8.27298239e-02f, 3.25195976e-02f, 5.36101405e-03f, 3.02825030e-02f,
  -8.39760061e-03f, 7.43152127e-02f, 3.72283086e-02f, 4.99236025e-02f, 1.80133864e-01f, 6.18222915e-02f, 1.14328973e-02f, 5.17770350e-02f, 1.16101116e-01f, 2.78670847e-01f,
  2.74059087e-01f, 1.75965697e-01f, -1.21737365e-02f, -9.44288354e-03f, -4.75072935e-02f, 7.64864385e-02f, 5.78535162e-02f, 7.50430375e-02f, 3.65900919e-02f, 8.45972300e-02f,
  7.68606067e-02f, 9.01887417e-02f, 1.06127061e-01f, 5.23185804e-02f, 3.81455524e-03f, 1.29124537e-01f, 1.08902186e-01f, 1.11267626e-01f, 2.77618766e-02f, 1.23994745e-01f,
  -8.86316225e-03f, 2.99884267e-02f, 1.05591916e-01f, 6.77518025e-02f, 1.20319948e-01f, 1.42105609e-01f, 1.10572040e-01f, 9.73959863e-02f, 2.39496958e-02f, 1.98393211e-01f,
  -2.96194255e-02f, -6.92226142e-02f, -6.98430017e-02f, -5.98668791e-02f, 1.04989922e-02f, -9.47680473e-02f, -1.04727998e-01f, -1.79610793e-02f, -8.38173255e-02f, 4.35103616e-03f,
  -7.24278316e-02f, -7.86781684e-02f, -1.42777129e-03f, -4.80678678e-02f, -3.63508277e-02f, -3.55024412e-02f, -2.25438941e-02f, 4.66593634e-03f, -5.20541482e-02f, -9.78674889e-02f,
  -6.45764694e-02f, -3.67849767e-02f, 7.40346760e-02f, -1.49392998e-02f, 3.17858392e-03f, -6.09210320e-02f, -6.45150244e-02f, 1.31116705e-02f, -4.06189263e-02f, 3.20168361e-02f,
  3.17910723e-02f, -2.09413126e-01f, 1.51583329e-01f, 7.06420392e-02f, 5.84493689e-02f, 7.81125054e-02f, 3.33583578e-02f, 7.01758787e-02f, 9.58699360e-02f, 1.42513156e-01f,
  -5.38573898e-02f, -2.69338135e-02f, 9.75930095e-02f, -3.50350067e-02f, 8.25393125e-02f, -2.39446610e-02f, 9.49362814e-02f, 1.44311339e-01f, 7.88868517e-02f, 3.73171531e-02f,
  8.84478614e-02f, 7.64570162e-02f, 1.93892479e-01f, 4.16665934e-02f, 1.29496142e-01f, 1.16294995e-01f, 3.67299877e-02f, 1.25084251e-01f, 5.62350787e-02f, 2.12350979e-01f,
  -2.06580590e-02f, -2.71019757e-01f, -3.43000352e-01f, -2.88615674e-01f, -2.27690846e-01f, -1.95011958e-01f, -1.47826925e-01f, -4.75566536e-02f, -1.51933923e-01f, -3.06576967e-01f,
  -1.60013080e-01f, -9.95035470e-02f, -6.43624812e-02f, -1.53934106e-01f, -2.34007929e-02f, -2.63935089e-01f, -2.28955939e-01f, -1.04517274e-01f, -9.29758847e-02f, -9.69380513e-02f,
  -7.99649805e-02f, -4.17751186e-02f, -4.81210127e-02f, -6.45060390e-02f, -1.03054672e-01f, -2.08570793e-01f, -2.70569295e-01f, -1.82489291e-01f, -7.80481771e-02f, -3.01313847e-01f,
  -3.78134519e-01f, -1.81718141e-01f, 7.28615299e-02f, 9.50947031e-02f, -5.86498827e-02f, -1.17186323e-01f, -8.08034837e-02f, -4.13389271e-03f, -9.75915696e-03f, -1.71911910e-01f,
  -1.22575201e-01f, 3.08473706e-02f, -1.46390885e-01f, -1.12602459e-02f, -3.25501747e-02f, -5.93031794e-02f, -4.95077483e-02f, -9.46111083e-02f, -2.28339806e-03f, -1.70159027e-01f,
  -1.37155503e-01f, -1.22415811e-01f, -5.75291514e-02f, -1.39070153e-01f, -7.60956760e-03f, -1.09164305e-02f, -7.82481432e-02f, -1.23454288e-01f, -1.27112806e-01f, -8.65018517e-02f,
  -5.52353375e-02f, 1.15264207e-01f, 1.03330724e-01f, 1.58754006e-01f, 1.47451743e-01f, 8.22004750e-02f, 6.60729483e-02f, 1.64559066e-01f, 1.65250212e-01f, 1.25238448e-01f,
  1.07130334e-01f, 1.58815324e-01f, 8.85312036e-02f, 1.52486056e-01f, 9.32358876e-02f, 1.40118852e-01f, 1.38259470e-01f, 1.33290961e-01f, 4.60940264e-02f, 8.42566937e-02f,
  1.23192199e-01f, 2.03449503e-01f, 1.51103392e-01f, 1.72436163e-01f, 1.14620842e-01f, 9.97734666e-02f, 1.68817684e-01f, 1.67118028e-01f, 3.94595638e-02f, 1.50189698e-01f,
  -2.29007304e-01f, 1.51932329e-01f, -1.28363162e-01f, -7.10435286e-02f, -6.96115345e-02f, -2.37055495e-02f, -3.79418880e-02f, -1.46651883e-02f, 3.37244868e-02f, -1.40060350e-01f,
  -1.06003240e-01f, 1.08799599e-02f, -5.97645678e-02f, -1.52574494e-01f, -1.16366744e-01f, -6.99824318e-02f, -7.70459771e-02f, -9.29818004e-02f, -3.04216594e-02f, -1.55458391e-01f,
  -6.45176098e-02f, -2.64168251e-02f, -2.82661486e-02f, -9.76975262e-02f, -1.47922084e-01f, -4.80119139e-02f, -6.98374733e-02f, 7.02314265e-03f, -6.59828633e-02f, -1.82979062e-01f,
  -2.59537041e-01f, -2.20198348e-01f, -2.89824933e-01f, -8.00172538e-02f, 2.28316650e-01f, 2.09280744e-01f, 3.07065994e-01f, 2.24871799e-01f, 5.29507324e-02f, -1.44323900e-01f,
  -8.38780180e-02f, -2.88244151e-02f, 1.96074508e-02f, 1.45375535e-01f, 1.60754740e-01f, 7.88109154e-02f, -3.12873982e-02f, 7.68955201e-02f, 1.51315078e-01f, 2.39155352e-01f,
  2.43974194e-01f, 1.99378226e-02f, -4.72932011e-02f, 1.31996185e-01f, 2.91402098e-02f, 1.77717973e-02f, -1.06638074e-01f, -7.32273906e-02f, -1.87251661e-02f, -1.13468409e-01f,
  -3.18499744e-01f, -1.10616215e-01f, 1.53913528e-01f, 1.73983321e-01f, -9.07505080e-02f, 5.32747665e-03f, 8.38310495e-02f, 1.40456660e-02f, -3.92113999e-02f, 4.38282825e-02f,
  1.55162970e-02f, 8.15365836e-03f, 1.07926227e-01f, 5.05655482e-02f, 5.52708097e-02f, 3.44297774e-02f, -4.92974604e-03f, 4.76462170e-02f, -1.22459084e-02f, -5.26352786e-02f,
  9.97066274e-02f, 1.12091422e-01f, 3.95687595e-02f, 1.10800743e-01f, 1.41881946e-02f, 1.29769206e-01f, 3.26736383e-02f, -2.53406595e-02f, 9.70969151e-04f, 1.85021348e-02f,
  1.38198718e-01f, -4.36755791e-02f, -4.37673405e-02f, -4.51779850e-02f, -1.67394169e-02f, -3.72040682e-02f, -1.05064556e-01f, -7.47734904e-02f, -6.30735010e-02f, -3.53477113e-02f,
  -1.00713380e-01f, -2.20714044e-02f, -9.18995067e-02f, -4.57549654e-02f, -9.72332507e-02f, -3.79464068e-02f, -9.31070000e-02f, -8.72700512e-02f, -2.56510843e-02f, -7.10888132e-02f,
  -1.19462721e-01f, -3.78250293e-02f, -1.38975441e-01f, -1.54272718e-02f, -5.63114998e-04f, -7.44003952e-02f, -6.06763028e-02f, -3.85251753e-02f, -5.25392555e-02f, -3.96068655e-02f,
  -2.68537730e-01f, 1.61781430e-01f, -6.54089749e-02f, 3.65701318e-02f, 5.74203357e-02f, 7.72042200e-02f, -5.26617989e-02f, -3.27396616e-02f, -1.48015385e-02f, 5.47753945e-02f,
  2.16322392e-02f, 7.77831301e-02f, -3.92090492e-02f, 9.60102230e-02f, 4.96626385e-02f, 6.39981031e-02f, 2.56613959e-02f, -3.41431648e-02f, 5.92890717e-02f, -3.63521837e-02f,
  -2.83883046e-03f, 7.43899941e-02f, -1.50590790e-02f, 3.51099670e-02f, 6.95915986e-03f, 5.65481372e-02f, -5.00366464e-02f, 7.82655999e-02f, 1.78386681e-02f, 3.34055610e-02f,
  -4.47942922e-03f, 9.45671275e-02f, -1.12427503e-01f, -2.33064964e-02f, 9.95403505e-04f, 3.89772579e-02f, 2.40887366e-02f, -7.69147500e-02f, -4.73577157e-02f, 4.95349541e-02f,
  2.04414591e-01f, 1.59724638e-01f, -6.69498667e-02f, 1.98657741e-03f, -1.23466924e-01f, -1.67647451e-01f, -1.90936744e-01f, -7.88890943e-02f, 3.53321293e-03f, 8.05759802e-02f,
  -2.41204370e-02f, -8.41587260e-02f, -9.68169272e-02f, -5.95528819e-02f, 7.00884173e-03f, 4.86013517e-02f, 4.57805349e-03f, -4.62567247e-02f, 1.09530605e-01f, -7.06786439e-02f,
  1.77610442e-01f, 9.92885977e-02f, 5.47028147e-02f, 1.04926433e-02f, 9.95968357e-02f, 6.17273413e-02f, 1.91073909e-01f, 1.89370345e-02f, 9.42894369e-02f, 1.40921101e-01f,
  1.40248209e-01f, 1.48186088e-01f, 1.56775042e-01f, 1.75614819e-01f, 1.58937648e-02f, 1.09382235e-01f, 4.27915007e-02f, -3.61530855e-02f, 1.34455860e-01f, 9.31888893e-02f,
  1.76725388e-01f, 2.01209664e-01f, 1.06982961e-01f, 1.04147634e-02f, 1.22915275e-01f, 2.50918865e-02f, 1.65631324e-01f, 7.48989508e-02f, 1.00709610e-02f, 1.26442537e-01f,
  -1.43405264e-02f, -1.85777396e-01f, -1.11684255e-01f, -1.43150464e-01f, -1.33408904e-01f, -7.90608227e-02f, -1.62942186e-01f, -1.57498777e-01f, -1.02658592e-01f, -1.11531392e-01f,
  -4.69250716e-02f, -6.10305332e-02f, -7.65712187e-02f, -1.42110541e-01f, -6.48929775e-02f, -1.16672419e-01f, -1.14179872e-01f, -2.07492635e-01f, -2.76183188e-01f, -8.54243785e-02f,
  -1.52500436e-01f, -1.72058091e-01f, -1.79530323e-01f, -1.05200157e-01f, -1.93038821e-01f, -1.43976584e-01f, -8.75114202e-02f, -1.88832983e-01f, -2.26434261e-01f, -1.39775991e-01f,
  5.18774837e-02f, 7.01491088e-02f, 1.97127044e-01f, 1.02854043e-01f, 2.95445360e-02f, 6.39933795e-02f, 1.67686149e-01f, 1.17507003e-01f, 1.49238497e-01f, 1.10324696e-01f,
  1.16409287e-01f, 3.32022682e-02f, 6.22627661e-02f, 5.54836728e-02f, 1.45141706e-01f, 8.77957568e-02f, 1.06668353e-01f, 7.41056353e-02f, 1.25022069e-01f, 6.20332845e-02f,
  1.78690106e-02f, 8.76661763e-02f, 2.42091734e-02f, 9.94910747e-02f, 4.30326164e-02f, 1.00459948e-01f, 1.16886094e-03f, 9.24500525e-02f, 1.36798283e-03f, 1.02002598e-01f,
  3.85233313e-01f, 2.91273147e-01f, -2.23047182e-01f, 9.62931141e-02f, -1.51712522e-01f, -1.62300915e-01f, -1.05827115e-02f, -5.20027354e-02f, -9.04909743e-04f, 4.02572043e-02f,
  3.66422459e-02f, -7.75649175e-02f, 1.10725090e-02f, 5.63479103e-02f, 1.94541272e-02f, -5.72721139e-02f, -9.57687199e-02f, 5.32825328e-02f, -2.75264569e-02f, 9.09167752e-02f,
  1.40736522e-02f, 1.30000025e-01f, 2.55601376e-01f, 1.50654718e-01f, -5.08544259e-02f, -1.42110974e-01f, -1.13661759e-01f, -4.88050170e-02f, -2.68186023e-03f, -1.25449434e-01f,
  -2.65346199e-01f, 1.55199796e-01f, 1.73737444e-02f, 3.72016542e-02f, 6.19161688e-02f, 1.76337048e-01f, -6.51771203e-03f, -3.18344049e-02f, 1.46739215e-01f, 4.63619977e-02f,
  7.74906529e-03f, -1.09669995e-02f, -5.30930869e-02f, 5.49997669e-03f, 3.60701159e-02f, 6.89386278e-02f, 1.69047080e-02f, -1.62054636e-02f, 8.12814459e-02f, -1.31216804e-02f,
  5.42037822e-02f, 7.19154775e-02f, 5.14585152e-03f, 4.82545383e-02f, -4.07101260e-03f, 5.96978404e-02f, -7.97349960e-02f, 8.08793399e-03f, -7.76769407e-03f, -2.67449189e-02f,
  -6.10282924e-03f, -3.41755822e-02f, -5.04559800e-02f, -6.82396954e-03f, 3.89839709e-02f, 1.07807629e-02f, -7.08672777e-02f, 8.61715898e-03f, 5.47520816e-02f, -7.22697228e-02f,
  1.53746353e-02f, -3.55623476e-02f, -8.39462802e-02f, -5.26091531e-02f, -4.10638265e-02f, -5.83907552e-02f, -7.31929317e-02f, 8.99387896e-02f, -7.09438920e-02f, 2.18593255e-02f,
  -3.19803134e-02f, -1.38410721e-02f, 2.02408549e-03f, 1.90875642e-02f, 9.63175320e-04f, 4.68968228e-02f, 1.85087379e-02f, -1.75985601e-02f, -2.04456039e-03f, 1.68969221e-02f,
  -1.18050784e-01f, 1.00083709e-01f, 4.44891080e-02f, 1.17007472e-01f, -3.85864675e-02f, 2.28039045e-02f, 8.13316256e-02f, 8.32712352e-02f, 2.17930339e-02f, 4.36757356e-02f,
  1.00496612e-01f, -2.80381572e-02f, -2.34933174e-03f, 4.68780249e-02f, 1.93998571e-02f, 3.88902128e-02f, 8.37898180e-02f, 3.86629403e-02f, -1.35856122e-02f, -1.38527500e-02f,
  1.32369790e-02f, -6.17275834e-02f, -2.87456028e-02f, 2.04281174e-02f, -5.80533221e-03f, 2.12774593e-02f, -8.35757479e-02f, 3.05429772e-02f, -1.25244875e-02f, 9.90296826e-02f,
  1.71681732e-01f, 5.11440635e-01f, 2.08617881e-01f, 2.85358340e-01f, 2.60908127e-01f, 2.54152387e-01f, 2.76386887e-01f, -1.49922725e-03f, 1.81546256e-01f, 2.19266221e-01f,
  6.26604632e-02f, -5.37433885e-02f, -1.41030133e-01f, -4.47385758e-02f, -1.44197658e-01f, 2.36440092e-01f, 1.44811749e-01f, 1.66359823e-02f, -1.60133779e-01f, 6.44402653e-02f,
  2.64291942e-01f, 2.68804640e-01f, 8.62798691e-02f, 1.38812125e-01f, 2.50335753e-01f, 2.87014153e-02f, 2.18947664e-01f, 1.25894234e-01f, 2.10402265e-01f, 1.39321268e-01f,
  -1.47760823e-01f, -2.43959520e-02f, 1.69736426e-02f, 1.90040722e-01f, 1.80783704e-01f, 1.43756434e-01f, 2.18149096e-01f, 1.00533560e-01f, 1.65420085e-01f, 2.07001373e-01f,
  9.08320770e-02f, 9.28208083e-02f, 5.27531616e-02f, 1.08142182e-01f, 1.48702487e-01f, 1.01263791e-01f, 1.26156434e-01f, -3.96975279e-02f, 2.42394302e-02f, 7.57253468e-02f,
  1.60103127e-01f, 2.38839984e-01f, 2.00742975e-01f, 3.41713540e-02f, -2.29708273e-02f, 1.05091266e-01f, 1.20617047e-01f, -1.09073566e-02f, 5.24847247e-02f, 9.71077457e-02f,
  3.63291092e-02f, -2.53656432e-02f, -1.69079885e-01f, -1.12238824e-01f, -1.32067248e-01f, -1.96844503e-01f, -1.07768312e-01f, -1.75576642e-01f, -1.14932761e-01f, -1.45555243e-01f,
  -1.88684568e-01f, -1.52657762e-01f, -1.55707404e-01f, -1.54488161e-01f, -1.46482244e-01f, -9.09533873e-02f, -3.99254113e-02f, -8.14995840e-02f, -1.21016383e-01f, -2.21026108e-01f,
  -1.49059415e-01f, -1.79296345e-01f, -9.28238928e-02f, -1.76810905e-01f, -2.25568265e-01f, -1.64767653e-01f, -8.16866532e-02f, -1.52677029e-01f, -4.24728729e-02f, -8.30407813e-02f,
  1.41447961e-01f, -3.99262272e-02f, 5.51778711e-02f, -1.20187532e-02f, 1.35878175e-01f, 4.76632603e-02f, 1.90246597e-01f, 1.11836985e-01f, 1.63288072e-01f, 8.21683407e-02f,
  1.00759350e-01f, 1.40885219e-01f, 1.34207889e-01f, 9.63412300e-02f, 2.84932293e-02f, 1.04813941e-01f, 1.46147132e-01f, 1.10103965e-01f, 1.04188472e-02f, 1.65611729e-01f,
  1.35482088e-01f, 1.96302131e-01f, 1.56384528e-01f, 1.32491037e-01f, 1.33753762e-01f, 8.35903212e-02f, 1.72655851e-01f, 4.92323600e-02f, 4.50975336e-02f, 2.77149349e-01f,
  4.15350080e-01f, 8.24285373e-02f, -9.21060890e-02f, 9.05167237e-02f, -1.98821992e-01f, -1.84006020e-01f, -7.04299733e-02f, 1.22611849e-02f, 3.03697400e-02f, 1.32235825e-01f,
  -1.88934922e-01f, -6.69164732e-02f, -5.67661598e-02f, -4.37983777e-03f, 5.03700264e-02f, 1.07934654e-01f, -1.47237740e-02f, 1.63647339e-01f, 8.94746408e-02f, 4.50119115e-02f,
  1.16024099e-01f, 8.35633203e-02f, 6.51944652e-02f, 1.88364148e-01f, 2.41698414e-01f, 9.10144076e-02f, 8.66419524e-02f, 2.23942604e-02f, 7.23288730e-02f, 3.64388287e-01f,
  2.32469887e-01f, 2.08322182e-02f, -2.15324573e-02f, 7.08729550e-02f, -5.57223000e-02f, 3.77071053e-02f, 1.52789459e-01f, 4.11498547e-02f, 6.58310056e-02f, 1.28974602e-01f,
  3.05000246e-02f, 2.01655868e-02f, 1.44643309e-02f, 3.07298303e-02f, -2.78604124e-02f, 9.44567472e-02f, 9.93378740e-03f, 9.04644206e-02f, -3.23945545e-02f, 2.60842126e-02f,
  -9.64994282e-02f, 7.80224428e-02f, 1.02456503e-01f, 4.66482826e-02f, 7.13942796e-02f, 5.60848266e-02f, 1.19220525e-01f, 1.43890396e-01f, 1.40296698e-01f, 2.01878354e-01f,
  2.35969834e-02f, 1.67884380e-02f, -1.06963374e-01f, -5.39184250e-02f, -2.06975825e-03f, 1.47029255e-02f, -8.56457092e-03f, -7.68532231e-02f, 4.00048159e-02f, 4.78694364e-02f,
  -5.61901145e-02f, -7.85198063e-03f, -5.30813113e-02f, -2.15795655e-02f, -2.12082565e-02f, -9.62090343e-02f, -1.73130315e-02f, 4.33818763e-03f, -1.49480224e-01f, -3.46588492e-02f,
  -1.89928319e-02f, -5.34881540e-02f, -1.20740622e-01f, 1.42488545e-02f, -1.30887508e-01f, -8.15697685e-02f, 9.97755863e-03f, -1.11786366e-01f, -1.26403183e-01f, -3.62642258e-02f,
  1.49015501e-01f, -2.49236166e-01f, 1.91897854e-01f, 1.01553142e-01f, 5.32645360e-02f, 6.14810660e-02f, -5.72960600e-02f, -4.27019857e-02f, -1.24936625e-02f, -9.56907962e-03f,
  -8.26921463e-02f, 3.26479152e-02f, 2.45142318e-02f, 8.36010799e-02f, 2.93648001e-02f, 1.09294066e-02f, -3.40705886e-02f, 1.90459881e-02f, 3.67531255e-02f, -3.99876013e-02f,
  -7.01738670e-02f, 1.72126532e-01f, 1.39683917e-01f, 1.04140341e-01f, 6.91522434e-02f, 1.45250157e-01f, 1.20255098e-01f, 2.02347487e-01f, 9.97270197e-02f, 2.71957725e-01f,
  -4.55621272e-01f, 2.68551782e-02f, -2.83400983e-01f, -8.87081493e-03f, -3.38291451e-02f, -1.13685638e-01f, -7.37485364e-02f, 8.29281062e-02f, 1.77956540e-02f, 3.63893285e-02f,
  9.65006500e-02f, 1.30983129e-01f, 9.99842063e-02f, 2.34294683e-02f, -6.98910728e-02f, -1.34396225e-01f, -2.91850060e-01f, -3.62347990e-01f, -1.53495952e-01f, 2.60117347e-03f,
  1.64805222e-02f, -1.35636896e-01f, -2.91631728e-01f, -1.79379299e-01f, 3.35920490e-02f, -8.22557416e-03f, -1.68086991e-01f, -2.09144354e-01f, -6.01057261e-02f, -9.27985460e-03f,
  -5.03528863e-02f, -7.79212415e-02f, -1.63464695e-01f, -1.36650398e-01f, -1.04757845e-01f, -1.12915806e-01f, -2.08804195e-04f, -4.50871252e-02f, 9.38477460e-03f, 3.12186312e-02f,
  -8.52635950e-02f, -3.27654853e-02f, -1.00616522e-01f, 2.37182621e-02f, -1.16270080e-01f, -1.14693634e-01f, -6.40575215e-02f, -1.47213312e-02f, -2.29797792e-02f, 3.39873619e-02f,
  -9.56957266e-02f, -1.14950985e-01f, -9.57324505e-02f, 3.89145575e-02f, 2.68191863e-02f, -1.70598641e-01f, -9.72551852e-02f, -3.18542235e-02f, -1.42199010e-01f, -1.55359030e-01f,
  6.08449839e-02f, 2.05666218e-02f, -3.09732016e-02f, 5.57240844e-02f, -1.12416456e-02f, -3.45686898e-02f, 3.17058899e-02f, 1.73672158e-02f, -7.46726245e-02f, -3.27122919e-02f,
  -8.76326021e-03f, -6.40578270e-02f, -7.08530396e-02f, 5.12689054e-02f, 2.23214310e-02f, -4.00609896e-02f, -1.62629467e-02f, -1.64221190e-02f, -1.13117687e-01f, -4.86966185e-02f,
  -3.87335084e-02f, 4.65613529e-02f, -6.91281185e-02f, 5.84531501e-02f, 4.74759303e-02f, -9.13665220e-02f, -1.51813820e-01f, -1.91909149e-02f, -1.28134325e-01f, -1.44792750e-01f,
  7.40810633e-02f, -2.86930293e-01f, -5.20434231e-02f, -2.24434920e-02f, 4.68162820e-02f, 4.35428619e-02f, -7.62111321e-02f, 1.25008831e-02f, -3.10552195e-02f, 1.59487538e-02f,
  -1.21226452e-01f, 1.50984069e-02f, -8.82324651e-02f, -7.20551163e-02f, -7.04281777e-02f, -1.57189779e-02f, 4.20085853e-03f, -9.16650891e-02f, -2.45718602e-02f, -6.56814203e-02f,
  2.38300748e-02f, -3.61477137e-02f, -1.88561082e-01f, -9.40685347e-02f, 6.30004406e-02f, -1.56830013e-01f, -7.75493458e-02f, 2.63126288e-02f, -6.34255856e-02f, -1.64134651e-01f,
  3.13003808e-01f, -2.09099635e-01f, -1.54108375e-01f, 1.88360456e-02f, -1.42957464e-01f, -1.77796632e-01f, -1.65414065e-01f, -9.16594490e-02f, 3.23134325e-02f, -5.41014001e-02f,
  2.90133711e-02f, 1.64173394e-01f, 1.05009288e-01f, 1.90603696e-02f, -1.41422704e-01f, -2.81995624e-01f, -2.01735288e-01f, -5.16224727e-02f, -7.38394931e-02f, -2.40907148e-02f,
  6.14291765e-02f, 1.53537512e-01f, 2.14309946e-01f, 1.87215328e-01f, 1.22350752e-01f, 1.01381287e-01f, -9.38771479e-03f, -1.66930836e-02f, -2.83500273e-02f, 1.09708533e-01f,
  -2.18188256e-01f, 1.27651662e-01f, -3.84687074e-02f, -2.79908199e-02f, -8.68216455e-02f, -1.26536600e-02f, -1.29226327e-01f, -4.78667812e-03f, -5.57150133e-02f, -3.72849405e-02f,
  -1.02277465e-01f, -2.17257384e-02f, -1.40040675e-02f, -9.76175591e-02f, -1.24216214e-01f, -8.45004097e-02f, -7.28126764e-02f, -7.73566589e-03f, -8.42420235e-02f, -8.84905681e-02f,
  -4.40381281e-02f, -1.62652552e-01f, -1.67081773e-01f, -2.21307874e-01f, -2.71839239e-02f, -7.88698718e-02f, -1.10690415e-01f, -3.02738156e-02f, -9.15218517e-02f, 2.52018068e-02f,
  -1.20355725e-01f, 3.38000096e-02f, 1.65747255e-01f, 1.20355010e-01f, 6.05880506e-02f, 4.78067212e-02f, 5.38704582e-02f, 1.27233610e-01f, 1.01992920e-01f, 7.07158148e-02f,
  4.63227406e-02f, -6.15361985e-03f, 3.76161300e-02f, 1.28004730e-01f, 1.80049360e-01f, 9.60507467e-02f, 8.48258808e-02f, 7.21057057e-02f, 1.50333121e-01f, 2.10484266e-01f,
  1.03103749e-01f, 9.17090923e-02f, 3.36262621e-02f, 7.48122111e-02f, 1.77894071e-01f, 9.61848572e-02f, 6.97466880e-02f, 7.58481175e-02f, 2.35117171e-02f, 9.06241089e-02f,
  -3.34612317e-02f, -1.62221670e-01f, -2.45630946e-02f, -7.15246722e-02f, -3.11906654e-02f, 4.36562188e-02f, -1.14145145e-01f, -1.62561424e-03f, 5.20594195e-02f, -8.99751037e-02f,
  -4.69804183e-02f, 1.48893865e-02f, -3.89136225e-02f, -6.55111857e-03f, -1.08384266e-01f, -3.74293029e-02f, -9.24796462e-02f, -1.00321375e-01f, -8.49069506e-02f, -3.29926126e-02f,
  -6.47275448e-02f, -1.57369763e-01f, -9.51288640e-02f, -1.83360890e-01f, -5.41223586e-02f, -7.64329135e-02f, -1.22309834e-01f, -4.49417010e-02f, -2.32541427e-01f, -2.46505171e-01f,
  3.12513500e-01f, 9.05765668e-02f, 9.34739113e-02f, -7.77381212e-02f, -1.28349200e-01f, -6.81477785e-02f, -2.37896703e-02f, 3.30287963e-02f, -4.98990994e-03f, 3.17418799e-02f,
  -1.10545523e-01f, -2.03372873e-02f, -1.30364761e-01f, -5.11977486e-02f, 4.94635701e-02f, -1.39881659e-03f, -8.21383521e-02f, -1.22640617e-01f, -8.75163376e-02f, -1.40654907e-01f,
  -1.97332919e-01f, -2.01030865e-01f, -1.78024694e-01f, -1.66560397e-01f, -1.44334674e-01f, -1.88487768e-01f, -1.30997047e-01f, -6.85430095e-02f, -1.17369615e-01f, -8.49163234e-02f,
  6.75014332e-02f, 9.62528810e-02f, -1.28427640e-01f, -8.34791884e-02f, -7.54350498e-02f, -5.62219769e-02f, -6.73420057e-02f, -7.44871970e-04f, -3.95345408e-03f, -4.70453650e-02f,
  -4.17476259e-02f, -1.59846693e-01f, -8.69867131e-02f, -1.62236065e-01f, 1.41076790e-02f, -4.22460996e-02f, -6.89167157e-02f, 3.76599133e-02f, 2.31310204e-02f, 3.10592484e-02f,
  -1.59598663e-01f, 5.84081421e-03f, -1.42898904e-02f, 4.91774902e-02f, -1.48961265e-02f, -1.68305516e-01f, -8.53240490e-03f, -8.95560309e-02f, 5.08687794e-02f, 1.07116789e-01f,
  1.37976199e-01f, 1.62895277e-01f, 1.52058050e-01f, 3.79899554e-02f, 8.90566409e-02f, 1.74112979e-03f, 4.80388775e-02f, 4.74180579e-02f, 1.03289045e-01f, 6.76242933e-02f,
  9.47335660e-02f, 1.35594964e-01f, 6.19030334e-02f, 1.36983991e-01f, 9.49804485e-02f, 1.27622023e-01f, 6.34267107e-02f, 8.37820396e-02f, 1.10312320e-01f, 3.19760330e-02f,
  4.81434874e-02f, 4.93308045e-02f, -4.48821262e-02f, 4.65435162e-02f, 8.91179070e-02f, 1.29914850e-01f, 1.90294430e-01f, 5.53146526e-02f, 7.36538619e-02f, 6.54733181e-02f,
  -2.42037073e-01f, -1.20628014e-01f, -9.76682678e-02f, -1.28020987e-01f, -1.99526064e-02f, -1.42434895e-01f, -1.47607386e-01f, -2.70548500e-02f, -4.70978282e-02f, -5.18695172e-03f,
  -1.16506085e-01f, -1.84026156e-02f, -1.68643832e-01f, -8.13484639e-02f, -8.19701329e-02f, -9.91297811e-02f, -1.69328421e-01f, -7.38972127e-02f, -9.56965759e-02f, -1.11764088e-01f,
  -5.57018444e-02f, -6.52396679e-02f, 2.77139172e-02f, -9.85394642e-02f, -7.42815807e-02f, 5.08854585e-03f, -1.31531730e-01f, -1.28172711e-01f, -6.16301857e-02f, 1.22734196e-02f,
  2.52312399e-03f, -1.35610625e-01f, -1.81562647e-01f, 4.75359261e-02f, 1.59699246e-01f, 2.89486527e-01f, 2.79056787e-01f, 2.54260391e-01f, 8.50399882e-02f, 8.86540487e-02f,
  8.87205228e-02f, 8.56723934e-02f, 1.51546612e-01f, 1.74847260e-01f, 2.17288420e-01f, 6.49448782e-02f, 3.07785124e-02f, 1.13508560e-01f, 3.00164819e-01f, 2.26602569e-01f,
  2.32456028e-01f, 9.67122018e-02f, -3.04819327e-02f, 1.36662677e-01f, -9.52905044e-02f, 4.94951196e-02f, -7.80555978e-02f, 9.75705776e-03f, 6.77809725e-03f, -1.31088540e-01f,
  -2.15448946e-01f, -1.29694581e-01f, 1.53364196e-01f, -1.75606627e-02f, -1.73565760e-01f, 4.62759957e-02f, 5.52204764e-03f, -5.19016907e-02f, -7.12754345e-03f, 2.33836453e-02f,
  -1.28428563e-01f, -5.06423824e-02f, 2.52793580e-02f, -4.52653430e-02f, 7.84387533e-03f, -7.28515908e-02f, -1.02270655e-01f, -4.86277118e-02f, 2.20036451e-02f, -1.03698587e-02f,
  -9.46977809e-02f, -7.00201094e-02f, -6.36728555e-02f, 8.64228979e-02f, 3.11532952e-02f, 6.84513450e-02f, -5.18969819e-02f, -7.89443776e-02f, -7.50265792e-02f, -4.28642184e-02f,
  -2.62159575e-03f, -1.37854675e-02f, 1.46706495e-02f, -3.48244198e-02f, 2.68653650e-02f, 1.25599075e-02f, -3.96475159e-02f, 2.55456269e-02f, -1.86220277e-02f, -1.93483476e-02f,
  -3.18906344e-02f, -3.30834426e-02f, 3.63225266e-02f, -5.28115854e-02f, -4.88326140e-02f, -3.93710323e-02f, 3.84899266e-02f, -3.59816328e-02f, -3.83639075e-02f, 2.68201008e-02f,
  -9.75332335e-02f, -1.08583772e-03f, -2.33309288e-02f, 4.96206945e-03f, -4.06248234e-02f, -3.50688137e-02f, -4.18774448e-02f, -2.59355530e-02f, 6.28813878e-02f, -1.06531695e-01f,
  1.86573297e-01f, 5.19660860e-02f, -9.76709463e-03f, 5.67070246e-02f, -1.96567327e-02f, -1.85428578e-02f, 7.72691332e-03f, -1.12818040e-01f, 1.72176939e-02f, -2.36875489e-02f,
  2.58918125e-02f, 2.12175976e-02f, -1.92299187e-02f, -5.06748967e-02f, 6.40622154e-02f, 3.71951386e-02f, 2.99766269e-02f, 6.23594671e-02f, 7.36709312e-02f, -9.67739597e-02f,
  4.90990616e-02f, 1.30259126e-01f, 2.51563281e-01f, 1.07545651e-01f, 1.04028292e-01f, 2.01669767e-01f, 1.61007613e-01f, 1.65461436e-01f, 1.36723876e-01f, 1.12438984e-01f,
  -2.24739574e-02f, 2.74977446e-01f, 1.52469173e-01f, 7.84008801e-02f, -2.28455868e-02f, 7.85549432e-02f, 1.56483859e-01f, 1.50427386e-01f, -2.44944580e-02f, -5.85439466e-02f,
  -2.30706155e-01f, -3.47781539e-01f, -1.79706246e-01f, -2.13932455e-01f, -1.44108746e-03f, 2.28255138e-01f, 2.23414734e-01f, 4.34002466e-02f, -1.69706523e-01f, -3.19141954e-01f,
  -2.39600703e-01f, -5.72297573e-02f, -8.71835947e-02f, -6.41412800e-03f, -4.06357795e-02f, -1.68551311e-01f, -7.61157786e-03f, -2.15966087e-02f, -4.28491533e-02f, -1.47650521e-02f,
  -2.68648922e-01f, 5.11824600e-02f, -2.18161270e-01f, -2.62466997e-01f, -2.03618214e-01f, -7.52881318e-02f, -9.84450951e-02f, -1.48692951e-01f, -9.48872119e-02f, -5.96511811e-02f,
  -1.74225152e-01f, -1.57347545e-01f, -1.50128379e-01f, -1.07222110e-01f, -6.40057623e-02f, -1.01902910e-01f, -1.11655176e-01f, -9.27125961e-02f, -1.33800268e-01f, -5.39493561e-02f,
  -1.42287344e-01f, -1.12435237e-01f, -1.03887372e-01f, 4.61037457e-02f, -7.57211074e-02f, -1.65362865e-01f, -1.00186512e-01f, -1.81561917e-01f, 2.38069929e-02f, -8.31177309e-02f,
  -3.28763239e-02f, 7.65659139e-02f, 1.31296486e-01f, 1.45179987e-01f, 1.47296309e-01f, 1.57518461e-01f, 1.57357737e-01f, 7.46941045e-02f, 8.10343251e-02f, 8.26141015e-02f,
  9.32733864e-02f, 1.42269090e-01f, 1.34180591e-01f, 1.48118332e-01f, 6.85570613e-02f, 1.53133750e-01f, 9.02834460e-02f, 1.43273845e-01f, 8.12396929e-02f, 1.29134655e-01f,
  1.17633663e-01f, 1.34581059e-01f, 7.48709291e-02f, 1.23388901e-01f, 1.04734041e-01f, 9.65083912e-02f, 8.43641087e-02f, 4.34548743e-02f, 1.71857588e-02f, 1.16298243e-01f,
  -1.01821303e-01f, -1.57797158e-01f, -1.32627070e-01f, -2.01984912e-01f, -3.93106863e-02f, -1.63814813e-01f, -2.47077376e-01f, -1.37505680e-01f, -1.67324200e-01f, -1.40959501e-01f,
  -1.29254729e-01f, -1.88392445e-01f, -1.12983204e-01f, -1.04887627e-01f, -9.39816311e-02f, -1.00139953e-01f, -1.03729360e-01f, -8.16817284e-02f, -9.11385566e-02f, -7.06661493e-02f,
  -7.53452927e-02f, -3.07050627e-02f, -1.71021476e-01f, -4.42930013e-02f, -1.11075722e-01f, -1.66398019e-01f, -1.96620330e-01f, -1.65793419e-01f, -1.08860612e-01f, 3.06051616e-02f,
  -2.96274096e-01f, -1.32305846e-01f, 5.69691546e-02f, 1.25883603e-02f, 1.42385229e-01f, 9.40463841e-02f, -3.05432286e-02f, -6.98037893e-02f, 3.79149690e-02f, -3.22310366e-02f,
  3.91193070e-02f, 1.77004859e-01f, 1.44583762e-01f, 8.81715193e-02f, -1.09121569e-01f, -7.16967583e-02f, 1.01419263e-01f, 1.49328709e-01f, 6.96371943e-02f, 1.63527980e-01f,
  2.46825889e-01f, 1.49049446e-01f, 7.15640048e-03f, 8.60172659e-02f, 5.26490621e-02f, 1.41820922e-01f, 1.27510792e-02f, 1.26352414e-01f, -4.40636054e-02f, -3.00602848e-03f,
  1.60697460e-01f, -1.95314467e-01f, 1.47090092e-01f, 8.55924860e-02f, 1.33301333e-01f, 4.56045987e-03f, -2.03372762e-02f, -1.06726903e-02f, 1.01650879e-01f, 3.49001610e-03f,
  6.56149387e-02f, 2.94677503e-02f, 3.01318653e-02f, 3.70680057e-02f, 8.54648575e-02f, 9.43815783e-02f, -3.30570824e-02f, -6.24388270e-02f, -3.09393741e-02f, -5.63644804e-02f,
  1.08298354e-01f, 1.81941435e-01f, 1.88816264e-01f, 1.45459145e-01f, 3.41320857e-02f, 7.85174742e-02f, 7.36575425e-02f, 7.13526038e-03f, -7.09936172e-02f, -4.00645435e-02f,
  -4.72681690e-03f, 5.57349576e-03f, -8.62167999e-02f, -8.33853036e-02f, -6.07210584e-02f, -7.73919653e-03f, -9.07883421e-02f, 2.40453999e-04f, -8.06853771e-02f, 5.48069924e-02f,
  -1.37609720e-01f, -3.63716781e-02f, -1.39081329e-01f, -1.03318334e-01f, -4.08955812e-02f, -7.96201453e-02f, 1.18592577e-02f, -4.65750620e-02f, -1.55544430e-01f, -1.57875821e-01f,
  -7.35027716e-02f, -9.48208049e-02f, 3.06517687e-02f, -1.12963580e-02f, -1.31060287e-01f, -1.37828112e-01f, -1.10781625e-01f, -1.27221942e-01f, -1.60802640e-02f, -4.33746129e-02f,
  2.81533837e-01f, 5.53184515e-03f, 5.26321642e-02f, 1.11245319e-01f, 9.67024118e-02f, 5.97339943e-02f, 3.18502635e-02f, 2.34508868e-02f, -6.51575252e-03f, 1.15222238e-01f,
  8.10998082e-02f, 9.96608380e-03f, 4.04990017e-02f, 1.57689199e-01f, 1.67021185e-01f, 9.07069594e-02f, 1.08951725e-01f, 1.64812163e-01f, 1.33730963e-01f, 8.65538120e-02f,
  2.31680229e-01f, 1.00421436e-01f, 1.50446340e-01f, 1.06366329e-01f, 3.95279117e-02f, 1.06364787e-01f, 2.37429664e-01f, 2.37776041e-01f, 1.53065369e-01f, 2.32643604e-01f,
  -3.57576370e-01f, -8.83420855e-02f, -3.15859288e-01f, -3.04196328e-01f, -1.77415282e-01f, -7.43374452e-02f, -6.73858598e-02f, -4.76636887e-02f, -1.75045952e-01f, -2.69479193e-02f,
  1.19221725e-01f, 5.60428575e-02f, -1.28257740e-02f, 2.70406827e-02f, -2.95414962e-03f, -2.81667173e-01f, -2.47503757e-01f, -2.02581301e-01f, -1.91268414e-01f, -9.11317840e-02f,
  -2.08910089e-03f, -1.97169721e-01f, -1.47102088e-01f, -2.30308890e-01f, -9.34119895e-02f, -1.15446106e-01f, -1.36079818e-01f, -1.77166000e-01f, -1.65482536e-02f, -1.47816256e-01f,
  -8.99809301e-02f, -1.24881025e-02f, -1.51089057e-01f, -1.66007906e-01f, -1.56566590e-01f, -1.02093019e-01f, -1.12190932e-01f, -2.04777986e-01f, -1.06683955e-01f, -6.50572181e-02f,
  -4.11701910e-02f, -1.21526085e-01f, -1.14427850e-01f, -5.12852333e-02f, -5.08064106e-02f, -1.06101386e-01f, -2.10451424e-01f, -2.01914474e-01f, -1.59378186e-01f, -2.91489009e-02f,
  -4.34997790e-02f, -1.74740672e-01f, -2.25287482e-01f, -9.74595472e-02f, -1.49842694e-01f, -2.34651878e-01f, -5.94608597e-02f, -1.63870007e-01f, -7.99019635e-02f, -2.45192841e-01f,
  7.45742023e-02f, 7.85682648e-02f, 1.11715838e-01f, 1.09929837e-01f, 1.39166877e-01f, 1.67947814e-01f, 1.89578667e-01f, 9.66295898e-02f, 5.66514954e-02f, 2.26643514e-02f,
  4.64870520e-02f, 1.52348708e-02f, 1.05827413e-01f, 1.06145442e-01f, 8.03883299e-02f, 7.22821727e-02f, 5.11124693e-02f, 3.56673002e-02f, 6.94187805e-02f, 1.67936623e-01f,
  9.35563445e-02f, 9.43213031e-02f, 8.07749629e-02f, 1.70920551e-01f, 1.62340775e-01f, 2.83715148e-02f, 1.00397140e-01f, 4.66193780e-02f, 8.22020695e-02f, 1.40472986e-02f,
  -1.51265085e-01f, -3.76234539e-02f, -1.76395893e-01f, -1.34082243e-01f, -1.26235381e-01f, -1.40644580e-01f, -4.45499793e-02f, -9.46756452e-02f, -1.38143733e-01f, -1.39873937e-01f,
  -6.33363649e-02f, -9.53259319e-02f, -1.01422384e-01f, -9.74373296e-02f, -7.04609007e-02f, -7.89835677e-02f, -1.00548320e-01f, -1.15032502e-01f, -1.31871194e-01f, -9.93971303e-02f,
  -2.11464375e-01f, -1.41877621e-01f, -1.04720891e-01f, -1.66434735e-01f, -1.00877948e-01f, -2.16575071e-01f, -1.76419660e-01f, -1.03212923e-01f, -2.68516064e-01f, -1.30920202e-01f,
  2.47185349e-01f, 7.27658421e-02f, 1.36285931e-01f, 1.03976190e-01f, -1.62042230e-01f, -2.76477814e-01f, -2.26366103e-01f, -1.61561042e-01f, -1.24269329e-01f, 4.70839674e-03f,
  -8.66044685e-02f, -9.52620357e-02f, -5.39565384e-02f, -1.51754141e-01f, -5.82587868e-02f, -2.88252300e-03f, -9.74120572e-02f, 1.00063615e-01f, -4.41059321e-02f, -3.65551934e-02f,
  -1.11495942e-01f, 1.17159612e-01f, 1.68438926e-01f, 4.50922661e-02f, 1.46135271e-01f, 1.91498902e-02f, 1.50707066e-01f, 1.84526537e-02f, -6.07691593e-02f, 1.41177565e-01f,
  3.47900271e-01f, 8.80623534e-02f, 1.90041566e-04f, 1.68231539e-02f, -2.20039506e-02f, -4.65998752e-03f, -2.09999830e-02f, 3.24882716e-02f, -2.66359765e-02f, 8.29694867e-02f,
  -2.13106163e-02f, 4.10098657e-02f, 5.14157377e-02f, 1.19424008e-01f, 8.53684917e-02f, -4.45241965e-02f, 4.98150848e-02f, 1.17804997e-01f, -1.38578517e-03f, -7.62646720e-02f,
  -1.10685460e-01f, 5.98575827e-03f, -1.64937805e-02f, -1.29964901e-03f, -9.00599509e-02f, -6.30934238e-02f, 8.62178728e-02f, 5.37959486e-02f, 1.18945015e-03f, 1.26262531e-01f,
  6.71851635e-02f, 3.45430188e-02f, -5.24186976e-02f, 6.68279007e-02f, 2.20876504e-02f, -1.19454050e-02f, 1.60529148e-02f, 5.05579775e-03f, -1.34749627e-02f, 6.49086535e-02f,
  -2.62648147e-02f, -2.75127981e-02f, -6.15269244e-02f, 8.08716193e-02f, -3.74713019e-02f, 7.23691061e-02f, -4.41141762e-02f, -2.68628839e-02f, -1.48734059e-02f, -4.64753434e-03f,
  -7.04759508e-02f, -2.09962726e-02f, 2.34862138e-02f, 4.31216359e-02f, -5.21685220e-02f, 3.36749665e-02f, 1.08714057e-02f, -8.33807588e-02f, 4.70112450e-02f, -4.70596105e-02f,
  5.87786846e-02f, -3.32751751e-01f, 2.77953204e-02f, 3.17898095e-02f, -1.84297394e-02f, -3.03630140e-02f, -5.00188023e-02f, 6.87319934e-02f, -8.36911947e-02f, 3.18786241e-02f,
  -2.15340536e-02f, 8.36474635e-03f, -8.92747119e-02f, -5.99321872e-02f, -2.26230901e-02f, 5.51288873e-02f, -1.45901129e-01f, 2.32260656e-02f, -1.10028856e-01f, -6.76141530e-02f,
  -1.73412915e-03f, 2.66179685e-02f, -6.85292706e-02f, -6.62295371e-02f, -4.00483608e-02f, -1.04721107e-01f, -3.14074792e-02f, 5.35685867e-02f, -4.42433096e-02f, 1.01753332e-01f,
  -3.69330565e-03f, 1.12323068e-01f, 2.00903118e-01f, -1.84314042e-01f, 1.29615247e-01f, 3.69957298e-01f, 4.01632100e-01f, 1.71319380e-01f, -1.09229632e-01f, -1.94288213e-02f,
  -9.42616388e-02f, -3.09956402e-01f, -1.45217806e-01f, -1.76339690e-02f, 1.64600879e-01f, 2.14805067e-01f, 2.12371036e-01f, 1.38597295e-01f, 8.36346373e-02f, 1.12674542e-01f,
  2.38722260e-03f, -6.76438212e-02f, -1.52478248e-01f, -1.56730920e-01f, -2.19291344e-01f, -2.44767040e-01f, -1.20357156e-01f, -3.51026207e-02f, -2.49873810e-02f, -1.25014052e-01f,
  -1.82589516e-01f, 2.72397194e-02f, 6.99709207e-02f, -1.28646910e-01f, -4.56946157e-02f, -1.25914544e-01f, -3.49652730e-02f, -1.16372935e-01f, -1.56360157e-02f, -2.62189414e-02f,
  -1.32665366e-01f, -6.90216944e-02f, -5.09922802e-02f, -3.70882526e-02f, -8.87646154e-02f, -3.38400975e-02f, -1.46861672e-01f, -1.07167974e-01f, -8.06460250e-03f, -3.11996061e-02f,
  -1.13441139e-01f, -6.57405630e-02f, 2.39880178e-02f, -9.97622148e-04f, 3.91980298e-02f, -1.15305595e-01f, -1.73540488e-02f, 2.21903436e-02f, -4.81427908e-02f, -7.52601922e-02f,
  -4.71729524e-02f, -2.18420811e-02f, 2.90114619e-02f, -2.03500055e-02f, 4.25075479e-02f, 1.89245008e-02f, 4.35949564e-02f, 1.46560639e-01f, -1.58433728e-02f, 1.80960204e-02f,
  -4.56488412e-03f, 7.40165785e-02f, 2.85121296e-02f, 8.62579048e-02f, 1.35134114e-02f, 7.00898543e-02f, 7.01945722e-02f, 1.24454029e-01f, 6.96932375e-02f, 7.23765045e-02f,
  3.27176489e-02f, 4.02746759e-02f, -1.06426533e-02f, 4.27330815e-04f, 1.19900823e-01f, -8.54364131e-03f, 5.89056648e-02f, -2.31074891e-03f, -4.26669493e-02f, 9.39608663e-02f,
  -2.64739543e-01f, 2.40820661e-01f, -7.37250298e-02f, -4.89275940e-02f, -7.38971829e-02f, -5.96483648e-02f, -9.52154323e-02f, 1.09020220e-02f, -1.12774871e-01f, -6.35668412e-02f,
  4.77861762e-02f, -4.00285833e-02f, -5.14561534e-02f, -1.02546543e-01f, 1.24099068e-02f, 1.62708387e-02f, 1.76947471e-02f, -1.05090834e-01f, -1.01650450e-02f, -1.08255461e-01f,
  5.80335818e-02f, 1.18599877e-01f, -1.73904113e-02f, -1.65097304e-02f, -4.21906635e-02f, 9.75136608e-02f, 7.30264187e-02f, -6.18245527e-02f, 7.47472346e-02f, 1.43438965e-01f,
  -1.52005687e-01f, 2.74000317e-01f, 2.07813948e-01f, -8.90032873e-02f, -1.56447336e-01f, -1.15938783e-01f, 1.29310876e-01f, 1.49390977e-02f, -1.38411699e-02f, 1.26999259e-01f,
  -5.77570386e-02f, -1.60734832e-01f, -1.39163241e-01f, -1.64796726e-03f, -4.18965938e-03f, 8.74980986e-02f, 1.61079578e-02f, -1.05231903e-01f, -2.15858534e-01f, -1.18059739e-01f,
  -1.73790604e-01f, 6.64539561e-02f, 7.48891905e-02f, 7.88712054e-02f, 1.20717786e-01f, -6.18014708e-02f, 1.62315771e-01f, 5.81102222e-02f, 1.50015473e-01f, 9.53008011e-02f,
  -6.46215677e-02f, 9.13532898e-02f, -1.42489731e-01f, -6.56058714e-02f, -6.94405229e-04f, 7.96078965e-02f, -3.95704620e-02f, 7.98863173e-02f, -6.39193803e-02f, 5.06332284e-03f,
  -6.87381476e-02f, -4.75121401e-02f, 1.77850295e-02f, 8.92144293e-02f, -4.69513983e-02f, -8.82366952e-03f, 1.11265808e-01f, 4.79058065e-02f, 8.19455236e-02f, 8.28877389e-02f,
  -4.95509915e-02f, -1.25458136e-01f, -4.89401817e-02f, 3.55980955e-02f, 1.29111469e-01f, -2.94825695e-02f, 1.04653373e-01f, 3.70975286e-02f, 2.27053091e-02f, 3.44749354e-02f,
  8.82614218e-03f, -2.40069106e-02f, 4.73207571e-02f, 5.45245409e-03f, -2.44146343e-02f, 1.20263491e-02f, 1.60226151e-02f, 3.48206819e-03f, -3.54503430e-02f, 4.99117039e-02f,
  4.83806543e-02f, -4.68099751e-02f, 3.51831019e-02f, -3.90163548e-02f, -2.52003921e-03f, 5.66469692e-02f, -2.02106405e-03f, 1.00138001e-02f, 2.18710080e-02f, 3.71966138e-02f,
  -8.60832408e-02f, 2.03496334e-03f, -1.98905077e-02f, -1.75685193e-02f, 2.13880092e-02f, 2.46949941e-02f, 2.00224407e-02f, -5.08364215e-02f, 9.20638666e-02f, -6.03526682e-02f,
  -1.97548307e-02f, 8.90692975e-03f, -1.80846080e-01f, -1.20207788e-02f, 2.54088342e-02f, 5.47577515e-02f, -1.07565649e-01f, 1.61696170e-02f, 6.42000884e-03f, -1.70404054e-02f,
  -4.51188497e-02f, 1.10062212e-03f, -3.21809240e-02f, -2.78094951e-02f, -8.80687758e-02f, -3.27632483e-03f, 1.68923065e-02f, -9.46724489e-02f, -1.14741297e-02f, -4.47364599e-02f,
  -6.22616112e-02f, -1.22053750e-01f, -2.71158934e-01f, -1.54496744e-01f, -1.56135038e-02f, -1.91754654e-01f, -1.13919780e-01f, -2.86701042e-02f, -1.91317156e-01f, -6.88674599e-02f,
  -4.26997840e-01f, -4.75610465e-01f, 1.98839515e-01f, -2.55907923e-01f, 2.13163152e-01f, 2.60586500e-01f, 1.99741811e-01f, -6.37331605e-02f, -1.34186417e-01f, -9.05836150e-02f,
  -8.67839064e-03f, -8.62693712e-02f, -4.09845151e-02f, 4.22256105e-02f, 4.42179069e-02f, -5.59543781e-02f, 5.59463948e-02f, 3.28580961e-02f, 2.85992473e-01f, 2.50734121e-01f,
  -7.46050552e-02f, -1.68447137e-01f, -1.77829951e-01f, 2.79706363e-02f, -2.38354634e-02f, -4.53893887e-03f, -5.98151572e-02f, -4.44089388e-03f, 3.02373637e-02f, -7.55162090e-02f,
  1.38511941e-01f, -8.83829445e-02f, 5.73093556e-02f, -4.19847667e-02f, 6.88764006e-02f, -6.67486489e-02f, 2.74167163e-03f, -7.45515227e-02f, 2.79596895e-02f, 2.53790431e-02f,
  5.27055655e-03f, 1.75426025e-02f, 3.87883037e-02f, -5.65098822e-02f, 6.37689903e-02f, -1.71467997e-02f, -1.56902429e-02f, -3.38334292e-02f, 7.61300605e-03f, 6.98192269e-02f,
  1.45725803e-02f, 7.77252614e-02f, 1.06537655e-01f, 1.12252973e-01f, 5.16109988e-02f, 5.77127822e-02f, -9.42582730e-03f, 2.82911025e-02f, 1.36633992e-01f, -8.78007039e-02f,
  -5.75611256e-02f, -7.82017559e-02f, 1.63127556e-02f, -1.07119806e-01f, -9.58256945e-02f, -4.06796299e-02f, -7.40964711e-02f, -9.59211662e-02f, -4.14656810e-02f, -1.24072671e-01f,
  -1.40651420e-01f, -3.72398756e-02f, -7.54539818e-02f, -1.57044843e-01f, -3.43987383e-02f, -3.30835991e-02f, -1.21739872e-01f, -7.93444961e-02f, -1.06644351e-02f, 7.86298048e-03f,
  -9.96496603e-02f, -4.58390303e-02f, -1.25032306e-01f, -6.04561083e-02f, -2.62255315e-02f, -7.58722275e-02f, -4.73343953e-02f, -1.32767498e-01f, -1.93195138e-02f, -9.55660716e-02f,
  -5.98843768e-02f, 2.77623892e-01f, -2.60925619e-03f, -1.59644131e-02f, 3.04939877e-02f, 3.01020965e-02f, -7.00465068e-02f, 7.69354403e-02f, -1.79915410e-02f, 1.13923820e-02f,
  6.44540265e-02f, -3.57091706e-03f, -5.93250571e-03f, 1.30139450e-02f, 1.24548711e-01f, 8.45028013e-02f, -1.07710063e-01f, -3.39780748e-02f, 5.60958348e-02f, 3.31733041e-02f,
  -5.01081347e-02f, 4.71287332e-02f, 1.32395625e-01f, 8.90131146e-02f, 1.00781761e-01f, 1.62253290e-01f, 8.54008868e-02f, 7.38137513e-02f, 1.77624412e-02f, -1.98404968e-01f,
  -2.07105592e-01f, -4.39048707e-01f, -3.82702470e-01f, 1.44708063e-02f, 4.61662412e-02f, -9.48042497e-02f, -4.25639115e-02f, 7.55838156e-02f, 1.05705701e-01f, -1.75673723e-01f,
  2.78900769e-02f, 6.04043491e-02f, 9.11066402e-03f, 1.93459034e-01f, 1.31748661e-01f, -2.31324151e-01f, -6.78684041e-02f, -1.09856226e-01f, 1.10381424e-01f, 8.74316040e-03f,
  2.13545151e-02f, -1.97418723e-02f, -7.64630958e-02f, 4.78262566e-02f, -2.44303662e-02f, 7.77668180e-03f, -2.07968205e-01f, -1.51646063e-01f, -2.01066330e-01f, -3.45674902e-01f,
  -2.88652152e-01f, -9.26312804e-02f, 1.44160658e-01f, 1.54404983e-01f, 3.59900743e-02f, 8.82114992e-02f, 2.28578206e-02f, 7.63804987e-02f, 3.38823758e-02f, -1.08407596e-02f,
  7.59132728e-02f, 7.26368651e-02f, 8.73882696e-02f, 1.43590286e-01f, 1.05082020e-01f, 5.82646579e-02f, 4.40755412e-02f, 2.11158674e-02f, -5.88149391e-03f, 7.42873549e-02f,
  3.62017937e-02f, -6.94345459e-02f, -1.11729570e-01f, 6.63864240e-02f, 3.31973955e-02f, 2.38245670e-02f, 1.10429479e-02f, -6.08352013e-02f, -6.30939379e-02f, -1.55394807e-01f,
  -9.44328830e-02f, -9.41657647e-02f, -9.24570337e-02f, -8.09490308e-02f, -7.36380816e-02f, -2.05938313e-02f, -7.79490694e-02f, -5.77526651e-02f, -7.14492425e-02f, -8.79455879e-02f,
  -4.99751642e-02f, -2.13904604e-02f, -3.20804641e-02f, 1.42473178e-02f, -3.85664627e-02f, -7.69166127e-02f, -7.47871473e-02f, -6.30299933e-03f, -6.91784173e-02f, 3.67702059e-02f,
  -1.02033779e-01f, -5.50542250e-02f, -3.83342616e-02f, 7.68682882e-02f, -2.91255694e-02f, -3.72779891e-02f, -1.33138672e-02f, 3.79785560e-02f, 7.06188455e-02f, -4.56774607e-02f,
  1.06774606e-01f, 2.04627007e-01f, 1.67086899e-01f, 1.99082479e-01f, 1.23031013e-01f, 2.81175673e-02f, 3.06552183e-02f, 1.35337174e-01f, 1.17027298e-01f, 9.03226063e-02f,
  8.25582147e-02f, 8.20237994e-02f, 6.59586713e-02f, 5.03431000e-02f, 7.81077296e-02f, 3.68283242e-02f, 1.99242339e-01f, 9.03424919e-02f, 1.30823568e-01f, 3.07656024e-02f,
  1.07672680e-02f, 1.63582098e-02f, -4.67285700e-03f, 1.37030482e-01f, 3.51059474e-02f, 1.39563903e-01f, 4.34816070e-02f, 5.07418849e-02f, 1.95418790e-01f, -6.20208979e-02f,
  1.31708458e-01f, 1.81522980e-01f, 1.84819847e-01f, 2.63355166e-01f, 2.45044529e-01f, 2.06465781e-01f, 1.05138823e-01f, 1.71024069e-01f, 1.58861637e-01f, 2.50184655e-01f,
  5.20244762e-02f, -9.94746834e-02f, -2.62350086e-02f, 2.07205117e-02f, -1.53686449e-01f, 2.15313479e-01f, 1.10288888e-01f, -1.45192146e-02f, 1.61254313e-02f, 1.53719276e-01f,
  1.86744168e-01f, 6.49973154e-02f, 6.87668025e-02f, 4.76102643e-02f, 2.37953529e-01f, 1.48070380e-01f, 1.86887696e-01f, 2.36530393e-01f, 1.63536310e-01f, 2.63429254e-01f,
  1.02090664e-01f, 1.81555763e-01f, 2.34585255e-02f, 6.87377006e-02f, 7.46313781e-02f, 5.66289537e-02f, 2.61589102e-02f, 3.67597155e-02f, -2.89200228e-02f, 1.08425081e-01f,
  1.29800960e-01f, 1.52009698e-02f, 1.14357345e-01f, 3.48873101e-02f, 1.16792396e-01f, 1.09094188e-01f, -9.20764171e-03f, 3.11202239e-02f, 9.15856473e-03f, 3.65418270e-02f,
  6.48893192e-02f, 7.80921802e-02f, 1.39117733e-01f, 6.96064532e-02f, 6.14204742e-02f, -2.75825914e-02f, 1.52400494e-01f, 3.06365266e-02f, 1.03241898e-01f, 1.92316636e-01f,
  1.62996594e-02f, -1.21650197e-01f, -8.80437046e-02f, -1.24643773e-01f, 2.11963672e-02f, -4.03081551e-02f, -6.57219766e-03f, -6.87036663e-02f, -4.52282950e-02f, -5.09946011e-02f,
  -6.90013766e-02f, -6.34145588e-02f, -7.94777498e-02f, -8.94848630e-02f, -2.99750753e-02f, -4.26447354e-02f, -7.32726306e-02f, -8.41706321e-02f, -5.32613136e-02f, -8.40251073e-02f,
  -3.17549147e-02f, -2.99159680e-02f, -1.03934422e-01f, -5.74054420e-02f, -7.99064618e-03f, -1.07492268e-01f, -1.34394124e-01f, -1.77923530e-01f, -1.00389279e-01f, 1.30034910e-04f,
  -3.28026079e-02f, -1.25825882e-01f, 1.26346201e-01f, 8.35546553e-02f, 6.61742985e-02f, 1.33623853e-01f, 1.81281388e-01f, 7.56167695e-02f, 8.30850378e-02f, 3.81886475e-02f,
  1.17544226e-01f, 1.87996272e-02f, 6.83282837e-02f, 9.33871865e-02f, -3.17241065e-02f, 8.17442685e-02f, 1.36642680e-01f, 1.58871263e-01f, 6.01619333e-02f, 9.22751334e-03f,
  9.74411890e-02f, 2.85707936e-02f, 6.01243190e-02f, 1.29432097e-01f, 1.31159481e-02f, -3.17857554e-03f, 1.07689358e-01f, 4.66681086e-02f, 1.10986874e-01f, 1.54567927e-01f,
  6.73844591e-02f, -3.36903721e-01f, -1.33374065e-01f, -6.90893910e-04f, 2.05563325e-02f, 1.47375222e-02f, -1.58752903e-01f, -4.41096500e-02f, 1.04871295e-01f, -2.12455094e-01f,
  -6.47223741e-02f, 1.80194512e-01f, 1.55698046e-01f, 1.30650893e-01f, 7.58078918e-02f, -1.97837591e-01f, -1.44735679e-01f, 2.85818651e-02f, 3.24238211e-01f, 1.82589933e-01f,
  1.75943151e-01f, 6.11901470e-02f, -2.33200546e-02f, -2.96560805e-02f, -1.69166476e-01f, 4.62534502e-02f, -2.67756969e-01f, -2.14565232e-01f, -8.65733996e-02f, -1.55329302e-01f,
  3.20738070e-02f, -2.40958929e-01f, 6.19022399e-02f, -3.93024869e-02f, -6.09329082e-02f, 6.00453978e-03f, -3.95683013e-02f, -9.16014761e-02f, -1.04380421e-01f, -6.81205615e-02f,
  -1.16279408e-01f, -9.09778252e-02f, -5.75914122e-02f, -1.82733964e-03f, -1.24507219e-01f, -1.01536542e-01f, -1.66259155e-01f, -7.71121457e-02f, -1.81348082e-02f, -2.70236414e-02f,
  -6.58638328e-02f, -6.53561205e-02f, 1.20774340e-02f, -4.93990742e-02f, -7.52849430e-02f, 1.94612779e-02f, -1.14000864e-01f, -6.03265762e-02f, -7.19820261e-02f, -1.64446056e-01f,
  6.96749538e-02f, -3.18286158e-02f, 1.95880942e-02f, 3.70206945e-02f, -2.42429283e-02f, -3.31941471e-02f, -2.37007495e-02f, 5.92083037e-02f, 3.38297263e-02f, 3.64888012e-02f,
  4.21336619e-03f, 6.63695931e-02f, 8.95066410e-02f, -5.80108687e-02f, 1.24834791e-01f, -7.86947180e-03f, 8.19223523e-02f, -8.34246799e-02f, 4.86843549e-02f, 3.16772424e-02f,
  7.86698163e-02f, 2.38559861e-02f, 5.17292619e-02f, 1.96176860e-02f, -7.07756635e-03f, 6.29588589e-02f, -1.59597006e-02f, -1.06870290e-02f, -5.41277602e-03f, 2.11672559e-02f,
  1.07441992e-01f, 9.03090537e-02f, -7.34631196e-02f, 1.80460364e-02f, -6.78736493e-02f, -5.41442260e-02f, -4.20812406e-02f, -7.54554495e-02f, -9.83970612e-02f, -7.61475507e-03f,
  -4.59413454e-02f, -2.66688038e-02f, -9.33512151e-02f, -4.58253138e-02f, 1.00367613e-01f, -2.99371034e-02f, -1.25707552e-01f, 3.85347567e-02f, 1.39171188e-03f, -1.06241316e-01f,
  -9.35865939e-02f, 3.12251151e-02f, 7.78024346e-02f, 8.23264942e-02f, 3.12564836e-04f, 1.26098394e-01f, -6.48944676e-02f, 5.33023924e-02f, 5.92111796e-02f, 4.84605916e-02f,
  9.29601863e-02f, 2.70504933e-02f, 7.72907361e-02f, 1.95788573e-02f, -2.73671728e-02f, -1.78785389e-03f, 5.48788942e-02f, -1.15143523e-01f, -3.67787257e-02f, 1.37773722e-01f,
  1.43758491e-01f, 8.42998847e-02f, -3.18208430e-03f, 1.12126514e-01f, 8.93050283e-02f, 8.83155391e-02f, 9.87028554e-02f, -2.10162420e-02f, 6.27695695e-02f, 2.32167970e-02f,
  -3.73792090e-02f, -3.44249560e-03f, 5.37856147e-02f, -8.69431198e-02f, 8.24232772e-03f, 1.84273738e-02f, -7.91016519e-02f, -5.44819273e-02f, 1.14500657e-01f, 5.80039695e-02f,
  3.52467269e-01f, -6.84116706e-02f, 2.05057755e-01f, 9.56996530e-02f, 1.09213882e-03f, 7.16833174e-02f, 1.61852628e-01f, 5.12504764e-02f, 2.43737325e-02f, 1.22834235e-01f,
  1.11151800e-01f, 3.93215157e-02f, 8.88931155e-02f, 5.75265214e-02f, 8.22532997e-02f, 4.84915031e-03f, -8.61579273e-03f, -1.36843305e-02f, 1.03174448e-01f, 5.67272566e-02f,
  8.66508577e-03f, 8.79802257e-02f, 7.56017491e-03f, -2.79523097e-02f, -4.44336645e-02f, 1.14605457e-01f, 1.81616191e-02f, 1.89507846e-02f, 8.84255618e-02f, 1.21076740e-01f,
  1.41999096e-01f, -1.82839409e-02f, -4.93062995e-02f, -6.93277940e-02f, -4.16569337e-02f, -3.42407599e-02f, -7.90355727e-02f, -7.97519088e-02f, -6.99009523e-02f, -3.42160240e-02f,
  -3.27341110e-02f, -3.11299716e-03f, 1.60200391e-02f, -1.04632199e-01f, -5.20346733e-03f, -7.87322968e-02f, -6.05012942e-03f, 7.94200525e-02f, 4.64321077e-02f, -7.09476741e-03f,
  1.18589932e-02f, -5.71821583e-03f, 4.83873673e-02f, -2.46808603e-02f, -3.78067680e-02f, -2.62601133e-02f, -4.33935374e-02f, -7.79760182e-02f, -3.08416579e-02f, -6.65368587e-02f,
  1.88346595e-01f, 4.36476544e-02f, 2.73493975e-01f, 1.03173479e-01f, 8.36207196e-02f, 1.42583787e-01f, 1.12303071e-01f, 1.78735316e-01f, 7.09610358e-02f, 9.27022547e-02f,
  -2.78194882e-02f, 5.90939820e-02f, 1.17700592e-01f, 4.27637175e-02f, 9.54088196e-02f, 9.15845856e-02f, 1.26806855e-01f, 9.34414268e-02f, 1.59212407e-02f, 8.24840218e-02f,
  1.54130131e-01f, 6.37281537e-02f, 2.07198411e-01f, 1.54117569e-01f, 8.23436156e-02f, 1.03894100e-01f, 1.66795224e-01f, 5.99507838e-02f, 6.40072078e-02f, 2.55333513e-01f,
  1.59337521e-01f, 2.73939669e-01f, 2.67210275e-01f, 1.23766549e-01f, 1.07170418e-01f, -2.50982139e-02f, 8.29162970e-02f, -9.36406758e-03f, -7.34293759e-02f, 9.33299661e-02f,
  -1.05459668e-01f, -2.53949970e-01f, -1.28127337e-01f, -1.04095876e-01f, -1.33224472e-01f, 1.32155851e-01f, 1.55502647e-01f, 1.14305191e-01f, -4.52482179e-02f, 6.96005225e-02f,
  -5.29076904e-03f, 1.05586886e-01f, 3.94088663e-02f, 8.74053035e-03f, 1.73428088e-01f, 3.64041030e-02f, 2.07631737e-01f, 2.69251585e-01f, 1.41119152e-01f, 2.69680768e-01f,
  1.80399269e-01f, 6.49525076e-02f, -7.41408616e-02f, 5.50033785e-02f, 1.11172885e-01f, 3.38882133e-02f, 1.91904858e-01f, 9.15772766e-02f, 2.91547608e-02f, 1.36314303e-01f,
  1.06854327e-02f, 1.54002234e-01f, 9.42498967e-02f, 1.05741881e-01f, 6.82329237e-02f, 3.15336064e-02f, 1.27157882e-01f, 4.25339080e-02f, -7.88685400e-03f, 1.03019401e-01f,
  1.00737736e-01f, 2.15330407e-01f, 1.01147145e-01f, 2.54732668e-02f, 1.41200900e-01f, 9.38704908e-02f, 1.68585971e-01f, 6.27258569e-02f, 3.37920971e-02f, 1.96725085e-01f,
  2.72223875e-02f, 4.12641689e-02f, -1.19915046e-02f, 3.01322360e-02f, -1.07156672e-01f, 3.78117785e-02f, -2.90656723e-02f, 1.78137571e-02f, 6.04062863e-02f, 6.65365160e-02f,
  5.24507910e-02f, -6.73127323e-02f, -6.35890663e-02f, -1.84995010e-02f, 5.29172495e-02f, 3.73291895e-02f, 7.84170581e-04f, -3.54553834e-02f, -8.88976529e-02f, 3.29192318e-02f,
  -6.88308552e-02f, -8.91733542e-03f, -2.58781295e-02f, 1.46020595e-02f, -3.26703973e-02f, 9.45201982e-03f, 1.28629152e-02f, 4.69108461e-04f, 2.86344327e-02f, 7.64640570e-02f,
  6.86055198e-02f, -1.66255593e-01f, 1.02231830e-01f, -5.64804301e-03f, 8.86349753e-02f, -2.98293978e-02f, -1.92274954e-02f, 8.78898725e-02f, -2.37169843e-02f, 2.55147666e-02f,
  1.06920868e-01f, -3.46281677e-02f, 5.08280024e-02f, 3.00791441e-03f, 1.48473373e-02f, 1.57959871e-02f, -6.13765344e-02f, -1.95965171e-02f, 7.98498467e-03f, 1.21142663e-01f,
  5.68185486e-02f, 1.53814420e-01f, 1.87258020e-01f, 1.09104656e-01f, 1.40462732e-02f, -7.75993988e-03f, 1.44450188e-01f, 1.60341829e-01f, 1.19756132e-01f, 1.25837967e-01f,
  -1.59229368e-01f, -1.87993258e-01f, -2.25035161e-01f, -6.97849225e-03f, -1.64539456e-01f, -1.21180624e-01f, -1.68302178e-01f, -2.32918020e-02f, -5.65127395e-02f, -1.55696422e-01f,
  -2.00417697e-01f, -1.51781887e-01f, -1.25897542e-01f, 1.71657559e-02f, -1.06765971e-01f, -7.58436322e-02f, -2.91646980e-02f, 4.28709239e-02f, 6.49759471e-02f, -5.22123948e-02f,
  -2.50614751e-02f, 8.67296103e-03f, -2.05695978e-03f, 1.12222210e-02f, -2.03556139e-02f, 2.75589321e-02f, -2.14071974e-01f, -8.18734691e-02f, -1.08059488e-01f, 6.47599474e-02f,
  -1.85976580e-01f, -1.70396164e-01f, 8.58251285e-03f, -6.93771914e-02f, -7.19342083e-02f, -3.44595946e-02f, -3.67654413e-02f, -1.78675190e-01f, -8.50894973e-02f, -1.78806726e-02f,
  -5.53867854e-02f, -1.33886680e-01f, -1.31248191e-01f, -4.85976525e-02f, -1.69446483e-01f, -7.41263703e-02f, 3.16540077e-02f, 1.59924813e-02f, -9.99335796e-02f, -5.46600893e-02f,
  9.24449996e-04f, -1.16018109e-01f, -1.62529305e-01f, -1.33846149e-01f, -8.87162387e-02f, -5.22054806e-02f, -1.44423127e-01f, -2.22618163e-01f, -7.50795379e-02f, -5.38650714e-02f,
  -1.87647734e-02f, -2.24679150e-02f, -3.86713520e-02f, 8.28841925e-02f, 6.01148158e-02f, 6.00612983e-02f, 2.99852677e-02f, 1.07341982e-01f, 6.38732389e-02f, 2.35608928e-02f,
  7.92079866e-02f, -5.65464981e-02f, 1.51486114e-01f, 1.59380093e-01f, 1.41957402e-01f, 9.29406434e-02f, 1.76267624e-01f, 1.31244630e-01f, 1.38986006e-01f, 8.13214481e-02f,
  5.37260100e-02f, 4.34999913e-02f, 1.12501949e-01f, 8.88764635e-02f, 8.31766278e-02f, 7.80026093e-02f, 3.19694988e-02f, 1.19617335e-01f, 1.76507374e-03f, 5.59440162e-03f,
  -1.60533991e-02f, -9.31100920e-02f, -1.09520070e-01f, 1.20256431e-02f, -3.82453646e-03f, -4.30146158e-02f, -6.99383765e-02f, -5.07184006e-02f, -2.05019247e-02f, -2.51456201e-02f,
  -2.93761189e-03f, -1.26855671e-02f, -3.06013389e-03f, 2.06624456e-02f, -1.29373267e-01f, 6.24676701e-03f, -9.78040248e-02f, -1.09068520e-01f, -1.28594294e-01f, -7.81542733e-02f,
  -8.25450867e-02f, 2.18231305e-02f, -6.15517087e-02f, -1.42592430e-01f, -1.84955791e-01f, -1.29914349e-02f, -1.39396831e-01f, -1.74241364e-01f, -1.59917548e-01f, -3.97852063e-02f
};

// L0_fan_Wp_bar (Shape: 78 x 120)
const int L0_fan_Wp_bar_rows = 78;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  2.30108589e-01f, -7.08129443e-03f, -7.10343719e-02f, 2.41397232e-01f, 2.30433568e-01f, 1.45352900e-01f, 2.22384259e-01f, 4.75555435e-02f, -2.11301856e-02f, 5.21557964e-02f,
  2.59918243e-01f, 1.60647795e-01f, 9.99821573e-02f, -8.12067557e-03f, 2.56213732e-02f, -6.95194975e-02f, -2.46574301e-02f, -1.22317821e-01f, 1.16595089e-01f, 1.58051521e-01f,
  2.36420691e-01f, 1.05263069e-01f, -1.05044730e-01f, 3.58281918e-02f, 1.69536546e-01f, 1.03199221e-01f, -2.72227991e-02f, 1.22287609e-01f, 1.64415628e-01f, 5.07171303e-02f,
  -1.06038630e-01f, 1.05255343e-01f, 1.03296384e-01f, 5.46066053e-02f, 6.30160347e-02f, -6.95222840e-02f, -4.45666388e-02f, -8.84826854e-02f, -1.94339287e-02f, -1.95100337e-01f,
  2.63382643e-02f, -9.39766541e-02f, 4.20150943e-02f, -3.10843512e-02f, -6.91712126e-02f, 6.02273550e-03f, -7.88656995e-03f, -1.75385639e-01f, -1.15944326e-01f, -5.61246974e-03f,
  9.49260443e-02f, 2.15897918e-01f, 4.98254448e-02f, -3.10401265e-02f, 1.08673610e-01f, 1.56301901e-01f, -8.65558013e-02f, 9.23126042e-02f, 2.23986302e-02f, -1.60722524e-01f,
  3.14209282e-01f, 2.85431325e-01f, 3.17645997e-01f, 1.40919372e-01f, -4.00712993e-03f, -3.29651646e-02f, 3.81452218e-02f, 4.65799905e-02f, 2.15512827e-01f, 6.01457059e-03f,
  -5.69223380e-03f, 6.80504367e-03f, -3.10601406e-02f, 1.29379183e-01f, 2.03186035e-01f, 2.46083617e-01f, 1.32512689e-01f, 7.47451186e-02f, 8.52137804e-02f, -3.86961326e-02f,
  7.34974295e-02f, -7.63180852e-02f, 5.71147688e-02f, -1.62185758e-01f, 9.21632648e-02f, 2.27631733e-01f, 2.42513672e-01f, 2.13452578e-01f, 1.63121521e-01f, 2.75330096e-01f,
  -1.63311616e-01f, 2.42841542e-01f, -9.60424729e-03f, -6.70364052e-02f, 1.07164390e-01f, 3.05190217e-02f, 2.65824255e-02f, -1.67211071e-01f, -1.80124536e-01f, -2.08212838e-01f,
  -7.22056776e-02f, -1.32718727e-01f, 7.11920718e-03f, 1.19627928e-02f, 1.31948721e-02f, 1.92378499e-02f, -4.70742546e-02f, -1.45763263e-01f, -2.31026243e-02f, -5.26806265e-02f,
  -4.00677361e-02f, 3.69564071e-02f, 3.46038640e-02f, -3.24909575e-02f, 6.06798232e-02f, 8.99742693e-02f, -5.03750443e-02f, 5.64300641e-02f, -4.22261953e-02f, -1.77298978e-01f,
  -5.75127184e-01f, 6.89518303e-02f, 3.59748006e-01f, -3.83149594e-01f, -8.51021633e-02f, -4.35661301e-02f, -1.39527157e-01f, -3.61755729e-01f, -2.26051137e-01f, 1.63876727e-01f,
  1.07219040e-01f, -3.54613125e-01f, 8.00418085e-04f, -2.47849926e-01f, -2.08727196e-01f, 1.26314878e-01f, 1.93540618e-01f, -1.87904626e-01f, -5.84863424e-01f, -5.82892716e-01f,
  -4.80788738e-01f, -4.93452013e-01f, -4.62441921e-01f, -1.01136543e-01f, -1.01853117e-01f, -1.87962607e-01f, 1.32818580e-01f, 3.16316411e-02f, 1.25199467e-01f, 3.29694711e-02f,
  1.75380930e-01f, 1.35764912e-01f, -1.33725271e-01f, -1.36380121e-01f, 3.55987027e-02f, 2.86984444e-02f, -4.72674333e-02f, -1.33643329e-01f, -1.04797566e-02f, 1.09651461e-01f,
  5.92966452e-02f, -1.34429395e-01f, 6.12685829e-02f, -5.13237491e-02f, -8.42286497e-02f, -1.87473353e-02f, 1.82689950e-02f, 2.85067912e-02f, 5.15679158e-02f, 1.26503751e-01f,
  1.92568079e-01f, 2.74592005e-02f, 1.77152127e-01f, 1.82611108e-01f, 1.67310968e-01f, -2.03837417e-02f, 1.28620371e-01f, 5.16487472e-02f, 1.19086221e-01f, -1.21852852e-01f,
  -1.03816614e-01f, 7.83469900e-02f, 4.85182032e-02f, -1.31560445e-01f, 5.35082184e-02f, 9.52985287e-02f, -1.14153586e-01f, 1.99811552e-02f, -8.23607668e-02f, -8.65369216e-02f,
  4.03364785e-02f, 4.99719828e-02f, -1.00367246e-02f, 1.95563156e-02f, 8.14313516e-02f, 7.56145967e-03f, 3.30580771e-02f, -3.43634970e-02f, 1.96574345e-01f, 1.21848173e-01f,
  4.49308939e-02f, 5.14700934e-02f, 3.56192961e-02f, -5.70050478e-02f, 8.21436122e-02f, 3.38543691e-02f, 1.40949875e-01f, 5.41422069e-02f, 7.27870017e-02f, 1.83384359e-01f,
  -4.39011544e-01f, 2.50954419e-01f, -8.62495080e-02f, 4.48755585e-02f, 3.58446613e-02f, 7.39342347e-02f, -1.81476884e-02f, -7.11593181e-02f, 8.14446248e-03f, -4.25303867e-03f,
  9.44918990e-02f, -7.00650737e-02f, -6.45007007e-04f, 3.19853649e-02f, -7.14476928e-02f, 4.12071124e-02f, -3.18912463e-03f, -1.19082686e-02f, 2.20558628e-01f, 1.03189573e-01f,
  1.35528386e-01f, 1.09327309e-01f, -1.27011493e-01f, 4.76956777e-02f, 3.61942723e-02f, -6.90057576e-02f, -3.96034718e-02f, 1.95690840e-02f, 1.09333038e-01f, -1.96536377e-01f,
  -5.74197471e-01f, 2.02737868e-01f, 4.09276605e-01f, -4.63253200e-01f, 2.25810677e-01f, 5.36055386e-01f, 8.30008209e-01f, 1.89365998e-01f, -2.19680145e-01f, 1.41964957e-01f,
  -3.03361621e-02f, -4.30339545e-01f, -2.80888110e-01f, -6.11532368e-02f, 2.40777895e-01f, 5.75799763e-01f, 4.36009884e-01f, 1.07754216e-01f, -9.77092758e-02f, -1.17416577e-02f,
  4.50633373e-03f, -1.97167784e-01f, -3.74634296e-01f, -2.15712324e-01f, -2.17054456e-01f, -1.59510151e-01f, -1.47300623e-02f, -6.49607852e-02f, 3.06332737e-01f, 4.29091742e-03f,
  -3.09059471e-01f, -2.77795702e-01f, 1.36589333e-01f, -3.76139671e-01f, -1.23210810e-01f, -1.62341133e-01f, 4.85831052e-02f, -6.94647431e-02f, 2.48326156e-02f, 1.85516044e-01f,
  -7.90726766e-02f, 2.30844915e-02f, -7.07180500e-02f, 1.92421619e-02f, -1.41649519e-03f, -8.59842449e-02f, -7.24169835e-02f, 1.24676339e-02f, -1.30657122e-01f, 1.80095136e-02f,
  1.33227482e-01f, 1.22697307e-02f, -2.71615442e-02f, 6.80564567e-02f, 2.60214675e-02f, -2.58234739e-01f, -6.35600463e-02f, -8.40912014e-02f, 8.15084875e-02f, -2.07645580e-01f,
  -2.80563831e-02f, 1.16873436e-01f, 1.43827155e-01f, -3.04126982e-02f, 4.27562892e-02f, 5.87347113e-02f, -5.04557192e-02f, 4.37842868e-02f, 8.86309221e-02f, 5.87437190e-02f,
  3.36195715e-02f, -1.78611875e-02f, -6.32251352e-02f, -7.47942179e-02f, -8.51348042e-02f, 5.05009480e-02f, 1.70381889e-01f, 3.17051783e-02f, -1.44427801e-02f, 3.05154286e-02f,
  -1.29630044e-01f, 6.83040917e-02f, -3.09831966e-02f, 9.23086628e-02f, 1.66268975e-01f, 7.30722919e-02f, -1.22033298e-01f, 3.10815237e-02f, -4.73625883e-02f, 1.18797757e-02f,
  -4.87807900e-01f, 2.65109330e-01f, -1.43923119e-01f, -1.30670086e-01f, -1.47149995e-01f, -8.09499100e-02f, -1.88316897e-01f, -7.02224001e-02f, -8.80566146e-03f, -8.88522863e-02f,
  1.51564240e-01f, -7.04194829e-02f, -2.56600827e-01f, 2.51837909e-01f, 1.48110520e-02f, 6.16555735e-02f, 1.93990413e-02f, -2.78366711e-02f, 6.85923733e-03f, -1.66674897e-01f,
  1.34758666e-01f, 1.64564345e-02f, -1.67366594e-01f, 2.60437578e-02f, -1.38788044e-01f, -3.39903653e-01f, -9.22338013e-03f, -1.28008306e-01f, 7.03795701e-02f, -5.43239377e-02f,
  -3.13597292e-01f, -6.10587358e-01f, -1.59189433e-01f, -5.19154012e-01f, -3.50465894e-01f, -1.15302153e-01f, -5.66355169e-01f, -1.83557555e-01f, -1.99151367e-01f, -5.51280260e-01f,
  -2.65034765e-01f, 3.45185190e-01f, 1.42936856e-01f, 1.78110898e-01f, 2.19519868e-01f, -5.32332361e-01f, -3.19179833e-01f, 1.53601691e-01f, 6.53733373e-01f, -5.77216074e-02f,
  -3.14721197e-01f, -2.57623374e-01f, 2.16674209e-01f, -5.47642857e-02f, -6.98922455e-01f, -1.67664945e-01f, -4.47031558e-01f, -2.63829410e-01f, -1.50066674e-01f, -7.00885057e-01f,
  -3.88674080e-01f, -2.45528370e-02f, 2.82337368e-01f, 3.07352036e-01f, -2.19068274e-01f, 1.51073337e-01f, -4.88793701e-02f, 1.33741885e-01f, 1.28542155e-01f, -1.08616889e-01f,
  -2.47265808e-02f, 1.50750995e-01f, 4.46256734e-02f, 4.60939780e-02f, -2.19261035e-01f, 5.07864207e-02f, -4.92952727e-02f, 1.50712401e-01f, -5.15573435e-02f, -2.26599798e-01f,
  -4.01506543e-01f, -1.99470788e-01f, 4.54347804e-02f, 1.15900785e-01f, 6.13759123e-02f, 3.17298710e-01f, -1.67123228e-01f, 1.16803579e-01f, 2.22256556e-01f, -6.24408364e-01f,
  -5.60906716e-02f, -2.97155324e-02f, -1.61662512e-02f, -4.11994755e-03f, 8.90602544e-02f, 3.39167804e-04f, -6.82782829e-02f, -9.89466012e-02f, 1.05278403e-01f, -4.48742658e-02f,
  -7.99440518e-02f, -3.20243761e-02f, 9.00294259e-02f, -6.50808821e-03f, -1.10716797e-01f, -1.09759487e-01f, -3.80020477e-02f, -1.05288036e-01f, -7.86856189e-03f, -1.41444393e-02f,
  7.71208033e-02f, 2.62521673e-03f, 2.38715522e-02f, 1.13919750e-01f, 3.61771621e-02f, -2.28706654e-02f, -2.74764039e-02f, 6.40996695e-02f, -9.65956524e-02f, 1.12374052e-02f,
  -2.22480372e-01f, 4.19159293e-01f, -2.55629152e-01f, 1.25947952e-01f, -1.25883028e-01f, 2.89157555e-02f, 2.63528414e-02f, 1.50198996e-01f, 9.16076172e-03f, -1.02254242e-01f,
  3.14926058e-02f, -1.04861483e-01f, -2.59509206e-01f, -6.62948936e-02f, 1.75668690e-02f, 2.93532461e-02f, -2.45481730e-01f, -9.81645882e-02f, 5.17468974e-02f, -2.05101654e-01f,
  -3.12133878e-01f, -3.68758254e-02f, -1.63631123e-02f, -1.63417637e-01f, -1.09306604e-01f, 1.68261901e-01f, -1.83973640e-01f, -2.20977038e-01f, 1.68257922e-01f, -6.35794520e-01f,
  4.96157974e-01f, 2.42637731e-02f, 1.37490302e-01f, 4.04372513e-01f, -1.24605112e-01f, -2.94048756e-01f, -3.63550574e-01f, -2.26546869e-01f, 1.13496542e-01f, 1.65644243e-01f,
  5.84774651e-02f, 2.53810644e-01f, 2.84953237e-01f, 2.35610664e-01f, 2.50374258e-01f, -1.95753518e-02f, 1.53639212e-01f, 3.02110165e-01f, 1.95467860e-01f, 1.32966042e-01f,
  9.73876864e-02f, 1.01586312e-01f, 5.17634079e-02f, 1.59554988e-01f, 2.33347818e-01f, 2.42641225e-01f, -8.00422505e-02f, 1.81143403e-01f, 1.75943021e-02f, 5.57882726e-01f,
  2.64901847e-01f, -1.67268608e-02f, -1.69046536e-01f, -2.69873720e-02f, 1.16142154e-01f, 1.01686396e-01f, -1.55855030e-01f, -2.16459811e-01f, -7.40850791e-02f, -4.34914604e-02f,
  -3.66339348e-02f, -4.85869963e-03f, -3.89858484e-02f, -3.42962928e-02f, -3.23214501e-01f, -2.76803136e-01f, -1.03356443e-01f, -2.47378717e-03f, -5.30883716e-03f, 8.86319391e-03f,
  2.01352015e-01f, -2.16684900e-02f, -1.77553803e-01f, -3.33506912e-01f, -1.89072061e-02f, 2.44483858e-01f, -1.64302468e-01f, 5.04057929e-02f, -3.09301227e-01f, 1.21397577e-01f,
  -8.08418617e-02f, -4.37848493e-02f, -7.42585957e-02f, -1.04568250e-01f, -1.29311197e-02f, -8.50502402e-02f, 1.39983624e-01f, 3.44975442e-02f, -1.76849842e-01f, -2.02032030e-01f,
  1.18180364e-01f, 5.34052476e-02f, -1.12428181e-01f, -2.66657937e-02f, 5.86142484e-03f, -1.80644304e-01f, 8.74198508e-03f, 1.47911891e-01f, -9.46688429e-02f, -1.34005055e-01f,
  1.04034469e-01f, 7.86713958e-02f, -7.10121468e-02f, 8.35617483e-02f, 1.25390843e-01f, 3.30849104e-02f, -5.53321540e-02f, -9.74120647e-02f, -7.30912015e-02f, -1.20884202e-01f,
  -3.22841614e-01f, -2.68991917e-01f, 7.46703371e-02f, 6.97482526e-02f, 4.91772825e-03f, 1.15500623e-02f, 1.65356666e-01f, 1.17276669e-01f, 9.66948047e-02f, 1.63289279e-01f,
  -1.47778705e-01f, 1.99186713e-01f, -1.65291056e-01f, -3.73712853e-02f, -2.10335866e-01f, -2.47837007e-01f, 1.65998694e-02f, 7.65875429e-02f, -2.40881518e-01f, -1.26805529e-02f,
  -1.11794375e-01f, -3.04690421e-01f, -1.63750693e-01f, -1.87724173e-01f, -2.75131911e-01f, -1.57161772e-01f, -2.48447850e-01f, -3.39889914e-01f, -5.27863979e-01f, -3.57930154e-01f,
  3.63569677e-01f, 4.45113182e-01f, -1.56831905e-01f, 2.18470395e-01f, -1.38256580e-01f, -1.15500212e-01f, -1.36800230e-01f, -8.25853646e-03f, 1.46200657e-01f, 1.58973351e-01f,
  2.06867769e-01f, 1.25549063e-01f, 1.75798923e-01f, -4.81949304e-04f, -4.14855778e-02f, -1.92587554e-01f, -1.51142359e-01f, -2.13146165e-01f, -1.75044894e-01f, -1.14427283e-01f,
  -1.40318573e-01f, -1.90460216e-02f, -3.17677744e-02f, 3.33488770e-02f, 1.23712473e-01f, -6.84655170e-05f, -4.13463414e-02f, -4.39706855e-02f, -2.53799856e-01f, 5.45356795e-03f,
  -1.39268547e-01f, -1.67289704e-01f, -6.63803816e-02f, 1.41096741e-01f, 1.62851185e-01f, 2.54126281e-01f, 1.19916983e-01f, 2.45372415e-01f, 1.97930634e-01f, 7.25515932e-02f,
  -3.16043161e-02f, 5.82513399e-02f, 2.72059627e-02f, -3.43669280e-02f, 4.92917709e-02f, 1.17676340e-01f, 1.41871676e-01f, 1.00972407e-01f, 2.86820009e-02f, 1.01576604e-01f,
  1.12537362e-01f, 3.33004096e-03f, -2.15865634e-02f, -1.16310887e-01f, -1.72430471e-01f, 1.25125684e-02f, 1.18136294e-01f, -2.55897222e-03f, -5.37865981e-02f, 1.20164384e-03f,
  8.57866555e-02f, 2.32572392e-01f, -1.01825327e-01f, -1.11106448e-01f, -9.46646854e-02f, 1.19123412e-02f, -8.19960833e-02f, -9.33839753e-02f, -3.00711244e-02f, 6.81759045e-02f,
  1.22749815e-02f, -1.16110809e-01f, -3.37100413e-04f, 7.83689786e-03f, 6.52143881e-02f, 7.80544952e-02f, -9.31230187e-02f, 9.20728967e-02f, -4.39402275e-02f, -7.50840083e-02f,
  -2.23448440e-01f, -1.68018397e-02f, 7.31547102e-02f, -3.70967598e-03f, 3.46995406e-02f, 3.53557281e-02f, 3.05595007e-02f, 1.42931147e-02f, 4.14958894e-02f, 2.72512119e-02f,
  1.38708144e-01f, -5.05527854e-01f, -1.95152238e-02f, 4.79788613e-03f, 2.45854203e-02f, 2.00363427e-01f, -1.60468340e-01f, -7.77025372e-02f, -4.51989695e-02f, -3.04483194e-02f,
  -1.70610063e-02f, 9.95233431e-02f, 9.69753265e-02f, -9.26992204e-03f, 2.57877130e-02f, -4.72083427e-02f, 8.46439898e-02f, 5.95750920e-02f, -1.31643377e-03f, 1.53805032e-01f,
  2.29698569e-01f, 1.19594805e-01f, -4.55921888e-03f, 6.55136928e-02f, -3.64012457e-02f, -1.00721069e-01f, -4.17416133e-02f, -2.08235048e-02f, -5.99085465e-02f, 2.06675828e-01f,
  -7.15260804e-02f, 1.21916853e-01f, 4.38771605e-01f, 1.84503626e-02f, -3.45738053e-01f, -4.28384095e-01f, -5.20501137e-01f, -1.02181427e-01f, -1.64547805e-02f, -1.04343288e-01f,
  -4.33270305e-01f, -3.00284833e-01f, 3.16645950e-02f, -5.16985916e-02f, -2.21391823e-02f, 7.50957206e-02f, 2.83533901e-01f, 3.17042649e-01f, -1.34390548e-01f, -4.00454611e-01f,
  -2.77010143e-01f, -9.55953822e-02f, 2.18618855e-01f, 2.84111351e-01f, 4.04272318e-01f, 1.02809519e-01f, 3.63583058e-01f, 1.08036928e-01f, 6.46812618e-02f, 6.01988196e-01f,
  2.36733645e-01f, 2.71124661e-01f, -8.68530944e-02f, -1.08937286e-01f, -6.00553602e-02f, 1.34850994e-01f, -1.93991270e-02f, 3.79555285e-01f, -8.34518671e-02f, 2.31293023e-01f,
  -1.41235262e-01f, -6.37270138e-02f, -1.11711048e-01f, -1.38250813e-02f, -2.96850979e-01f, -1.38937369e-01f, 1.61028802e-01f, 2.69531339e-01f, 1.70628935e-01f, -1.10798694e-01f,
  -3.59950155e-01f, -3.56991976e-01f, -1.39480874e-01f, -7.34605780e-03f, 1.59575015e-01f, -5.57119697e-02f, 1.85561955e-01f, 1.97679967e-01f, 1.83865726e-01f, 4.39542711e-01f,
  2.41461396e-03f, 2.53967773e-02f, 1.94215983e-01f, 1.54606611e-01f, -1.53133452e-01f, -8.52441415e-03f, 2.74718041e-03f, 3.75842601e-02f, 1.88731146e-03f, -1.11224994e-01f,
  9.84451617e-04f, -1.21410295e-01f, 4.08302546e-02f, 1.20987371e-03f, -3.60471383e-02f, 1.08596087e-01f, 5.94798755e-03f, 1.37453377e-01f, 3.27450894e-02f, -3.20935212e-02f,
  -9.73597541e-02f, 8.43267813e-02f, 2.05873251e-01f, 1.72989592e-01f, -1.87133569e-02f, 6.03681132e-02f, -2.77933683e-02f, 4.14673090e-02f, 5.61992489e-02f, -6.26158714e-03f,
  -1.90448061e-01f, -2.62744457e-01f, -5.53536043e-02f, 1.78511620e-01f, -3.20651270e-02f, 7.60096014e-02f, 7.79837668e-02f, -6.31261691e-02f, -1.53977036e-01f, -1.80933982e-01f,
  -2.05387205e-01f, -2.26014033e-01f, -4.99994904e-02f, 7.44026825e-02f, -2.00669572e-01f, -1.84790671e-01f, -1.87761232e-01f, -2.10592255e-01f, -2.95296669e-01f, -2.07726389e-01f,
  -1.67782515e-01f, -4.86617267e-01f, -5.95588446e-01f, -1.94492847e-01f, -2.48293668e-01f, -4.64420855e-01f, -8.39960426e-02f, -3.16938050e-02f, -4.04077709e-01f, -3.90486330e-01f,
  -4.92016040e-02f, -6.33862689e-02f, -6.93947852e-01f, 1.48137257e-01f, 1.13138750e-01f, -2.69349903e-01f, -4.96862322e-01f, -2.48958111e-01f, 2.33391285e-01f, 5.71341589e-02f,
  2.03998715e-01f, 3.63141239e-01f, -9.29935426e-02f, -3.35521311e-01f, -4.96657848e-01f, -3.78116041e-01f, -5.21131456e-01f, -5.36118627e-01f, -2.42135167e-01f, 3.30383867e-01f,
  3.40377003e-01f, 1.62928194e-01f, 4.85436916e-02f, -7.75491968e-02f, 4.13464129e-01f, 2.10034445e-01f, -1.11709379e-01f, 3.16490084e-02f, -6.81780502e-02f, -1.12997353e-01f,
  -7.80932307e-02f, -2.49289125e-01f, -4.03232761e-02f, 1.22875609e-01f, -2.50670681e-04f, -4.58306186e-02f, 9.86630917e-02f, -1.52580932e-01f, 4.58240770e-02f, 1.23280540e-01f,
  2.11077660e-01f, 1.29204929e-01f, 2.15262949e-01f, 1.95816875e-01f, 2.59615391e-01f, -7.64848664e-02f, -1.37947664e-01f, -3.97826731e-01f, -3.80837590e-01f, -9.15077925e-02f,
  2.63420522e-01f, -1.17774330e-01f, -4.57579911e-01f, -2.81592369e-01f, -3.27381909e-01f, -8.15128461e-02f, -4.61350828e-02f, -9.96511579e-02f, -5.79300165e-01f, -1.67912599e-02f,
  -3.77320275e-02f, -2.87022777e-02f, 8.95034522e-03f, 4.89422120e-02f, 2.07458660e-01f, 7.72435069e-02f, 6.09106272e-02f, 8.19302350e-02f, 1.17901288e-01f, -1.51477188e-01f,
  -5.08436561e-02f, -2.91285049e-02f, -7.76233058e-03f, -3.58893611e-02f, 1.26238912e-01f, -6.81558549e-02f, -9.27163661e-02f, -1.39455825e-01f, -1.16882913e-01f, -2.57862899e-02f,
  -3.96274738e-02f, 1.47495195e-02f, 3.25252533e-01f, 7.77147040e-02f, -5.10542206e-02f, -2.94375509e-01f, 1.36500001e-01f, 7.76941776e-02f, -2.02199128e-02f, 1.24279588e-01f,
  4.37878340e-01f, -1.11002177e-01f, 1.70080401e-02f, -1.34626552e-01f, 1.97084169e-04f, 9.90536883e-02f, 2.15503007e-01f, -1.42793745e-01f, -4.35316097e-03f, 9.02469456e-02f,
  3.14633641e-03f, -6.23442419e-02f, 2.07663327e-01f, 6.41683862e-02f, 8.71224701e-02f, 4.86007594e-02f, -1.26931608e-01f, -2.00388685e-01f, -1.92772269e-01f, 2.77771324e-01f,
  -1.19233737e-02f, -1.15022436e-01f, -2.56269991e-01f, -3.50692660e-01f, 6.62028864e-02f, -6.77301437e-02f, -5.06738685e-02f, 4.55548726e-02f, -5.10385454e-01f, -2.13588737e-02f,
  -1.34971380e-01f, 3.59094143e-01f, -3.73391807e-01f, 3.18076342e-01f, -5.12530375e-03f, -7.54731521e-02f, 4.62571234e-01f, 3.69168401e-01f, 2.94390321e-01f, 1.36001661e-01f,
  -3.96994770e-01f, -5.10284364e-01f, -3.88365656e-01f, -4.46342051e-01f, -1.99813426e-01f, 3.30266625e-01f, 4.01204407e-01f, -4.55408305e-01f, -4.53276038e-01f, 6.35647848e-02f,
  2.67006218e-01f, 4.07096982e-01f, 1.24450512e-01f, 7.12963939e-02f, 4.07724410e-01f, 5.20724989e-02f, 1.17586076e-01f, 1.14755429e-01f, -1.58878103e-01f, 6.29419461e-02f,
  -4.09180939e-01f, -1.49115205e-01f, -1.28439680e-01f, -1.68668926e-01f, -1.44745186e-01f, 1.30907595e-01f, -1.42941193e-03f, -4.07966562e-02f, -1.74230799e-01f, 6.30544722e-02f,
  -2.01881230e-01f, -1.35178894e-01f, -3.60274225e-01f, -1.21737190e-01f, -6.23463728e-02f, -1.59196198e-01f, 1.73594765e-02f, -1.04409806e-01f, -1.80128098e-01f, -2.03279674e-01f,
  -1.19379073e-01f, -3.84280711e-01f, -4.82562482e-01f, -2.59503517e-02f, -2.74395257e-01f, -5.20608068e-01f, -6.20313361e-02f, -3.51661325e-01f, -3.36575717e-01f, 3.64304900e-01f,
  1.31665513e-01f, -5.22623137e-02f, -3.87793407e-02f, 1.06429473e-01f, 1.35633484e-01f, 9.55657009e-03f, 5.36045320e-02f, -1.47919450e-02f, 7.28731090e-03f, 8.25942904e-02f,
  -7.09803402e-02f, -1.12745531e-01f, -3.69943194e-02f, 2.23969948e-03f, -7.22593218e-02f, -1.63171627e-02f, -6.28420617e-03f, 1.13737628e-01f, -4.12816182e-02f, 5.56675531e-03f,
  -7.07696751e-02f, -7.42218271e-02f, -5.98565675e-03f, -5.50583331e-03f, -6.40357733e-02f, -1.14658304e-01f, 7.31161982e-02f, -8.19371492e-02f, 3.02582197e-02f, 1.36924624e-01f,
  3.63810033e-01f, -2.43238688e-01f, 7.56880194e-02f, 1.29674450e-01f, 1.66617017e-02f, -1.85670465e-01f, -6.41364884e-03f, -6.46237507e-02f, -1.69514850e-01f, -5.33802658e-02f,
  -1.31668538e-01f, -1.31950408e-01f, -1.39183074e-01f, 6.38763085e-02f, -1.12536319e-01f, -4.81319316e-02f, 8.01913887e-02f, -2.98617203e-02f, 4.94625941e-02f, 9.55226570e-02f,
  2.65363902e-01f, 2.36408398e-01f, 1.36905119e-01f, 1.84590280e-01f, 1.00940377e-01f, -2.15937309e-02f, 1.34690076e-01f, 1.66725382e-01f, -1.19024470e-01f, 7.38559127e-01f,
  1.09150000e-02f, -4.36128899e-02f, -5.41360974e-01f, -2.25322857e-01f, -4.47407931e-01f, -2.81167418e-01f, -6.56340793e-02f, 2.08300874e-01f, 1.86837614e-01f, -4.62979227e-02f,
  -1.71069548e-01f, -1.73849940e-01f, -2.83592671e-01f, -1.44693613e-01f, -4.11259905e-02f, -1.61366433e-01f, -2.29743212e-01f, -3.35166305e-01f, -3.84138048e-01f, -1.39160320e-01f,
  -1.77727863e-01f, -2.81527787e-01f, -1.94292873e-01f, -1.74922779e-01f, -2.90124297e-01f, -2.11162180e-01f, -1.66566238e-01f, -3.53582412e-01f, -2.76269525e-01f, -3.58894825e-01f,
  -3.41213733e-01f, 1.87391061e-02f, -1.37100071e-01f, -2.32647970e-01f, -1.96852624e-01f, 7.51563832e-02f, -2.49936637e-02f, 1.42283412e-02f, 8.28140303e-02f, 5.44014014e-02f,
  -2.95467377e-01f, 4.05932367e-02f, 1.19229155e-02f, -2.86854118e-01f, -2.43963361e-01f, -4.77241762e-02f, -7.91109055e-02f, -1.34250820e-01f, 8.53635743e-03f, 1.56943426e-01f,
  -1.02278240e-01f, -2.69553125e-01f, -2.93479830e-01f, 1.33351669e-01f, 2.15221494e-01f, -1.46102861e-01f, -1.98040977e-01f, 2.40410548e-02f, 1.13249406e-01f, -1.12705879e-01f,
  5.46698049e-02f, -2.22038031e-02f, 3.62411141e-02f, 1.07782386e-01f, 8.71901512e-02f, 1.01476036e-01f, -3.11541129e-02f, -7.04453140e-02f, 1.16900474e-01f, 3.24328095e-02f,
  1.43670529e-01f, -3.03415582e-03f, 2.65595112e-02f, 9.28833261e-02f, -1.06042795e-01f, -1.57939225e-01f, 2.76774876e-02f, 1.25699237e-01f, -6.32054135e-02f, -2.13275105e-02f,
  -1.77123338e-01f, -2.22801760e-01f, -1.85417145e-01f, -5.93907088e-02f, -1.57270834e-01f, 2.64162086e-02f, 9.75020751e-02f, -8.46329890e-03f, -2.24431455e-02f, -3.24097089e-02f,
  2.02811621e-02f, 1.29071862e-01f, 9.05255263e-04f, -1.40425161e-01f, -3.22765554e-03f, 5.97361177e-02f, 3.77703197e-02f, 1.53879404e-01f, -2.45067626e-02f, -1.05603583e-01f,
  -1.12115227e-01f, -5.58151901e-02f, -1.34235919e-01f, -1.10346258e-01f, -5.62416203e-02f, 9.88963172e-02f, -5.18213538e-03f, -3.16758901e-01f, 2.06287601e-03f, -3.80382203e-02f,
  2.69206092e-02f, 1.22596867e-01f, -1.03494143e-02f, -6.67124614e-02f, 3.84523980e-02f, -8.43414068e-02f, -2.71427542e-01f, -4.90895435e-02f, 1.22021725e-02f, 1.46274239e-01f,
  5.90700805e-01f, 5.74391186e-01f, -1.43703729e-01f, -8.95601232e-03f, 1.04225941e-01f, -1.26401648e-01f, 1.40702084e-01f, 1.27501473e-01f, 6.93928599e-02f, 1.66008607e-01f,
  5.77156954e-02f, -7.76358843e-02f, 6.42526373e-02f, -1.92621142e-01f, -1.45443231e-01f, -2.14026608e-02f, -2.13770103e-02f, -2.79159278e-01f, -4.21757191e-01f, -2.72644818e-01f,
  -5.66794649e-02f, 2.63189197e-01f, 2.58590996e-01f, 1.52332457e-02f, 1.94638804e-01f, -1.31304085e-01f, 1.67385250e-01f, 2.04419285e-01f, 1.02517694e-01f, -2.86604147e-02f,
  -2.71007210e-01f, 4.55571502e-01f, -5.82417905e-01f, -8.40471834e-02f, -3.20696011e-02f, -1.08243652e-01f, -6.76969737e-02f, -2.45237760e-02f, 3.93219516e-02f, 1.64826494e-02f,
  2.06373669e-02f, -1.27845198e-01f, 7.76269883e-02f, -3.37734707e-02f, 1.16275497e-01f, -2.34025009e-02f, 8.38619769e-02f, -1.48034829e-03f, -8.84550437e-02f, 3.95066850e-02f,
  -5.14423102e-02f, 1.13621935e-01f, 1.50320038e-01f, -2.12268345e-02f, 6.43967604e-03f, -1.14502572e-01f, 8.68883282e-02f, -8.93576443e-02f, -5.80125339e-02f, 1.12905167e-01f,
  -2.64866441e-01f, 2.29033688e-03f, 2.66632065e-02f, -3.82403284e-02f, -9.38049406e-02f, -1.49412706e-01f, 1.70268580e-01f, 7.53547847e-02f, -2.48889867e-02f, 9.79949385e-02f,
  3.02532446e-02f, -9.95097160e-02f, -1.41894266e-01f, 1.04452804e-01f, -3.64129408e-03f, -9.16122226e-04f, -9.50479656e-02f, 5.97987920e-02f, 1.39253721e-01f, -5.21481521e-02f,
  4.19330923e-03f, -2.33480297e-02f, 1.09136395e-01f, -3.15229339e-03f, 3.05759478e-02f, -1.81697205e-01f, -1.10919923e-01f, 1.13021070e-02f, 6.04428016e-02f, 4.82996888e-02f,
  -1.92169860e-01f, -3.49093735e-01f, -4.00954306e-01f, -1.37686029e-01f, 6.43177778e-02f, 1.75988078e-02f, -1.74309790e-01f, -3.00272536e-02f, 1.13737836e-01f, 1.11752003e-01f,
  1.22337438e-01f, -1.04394294e-01f, 5.63860834e-02f, -4.04759310e-02f, -1.67410612e-01f, -1.86545644e-02f, 1.03520215e-01f, -7.14822039e-02f, -6.52877167e-02f, 5.07893637e-02f,
  2.38930229e-02f, -8.85816514e-02f, -1.20104700e-01f, -9.14101377e-02f, -2.78694648e-02f, -1.39445990e-01f, 3.94337587e-02f, -1.56875312e-01f, -2.09667400e-01f, 4.49654162e-02f,
  -5.82123399e-01f, -7.91704834e-01f, -1.71295553e-02f, -6.58366263e-01f, -3.17243934e-01f, -2.02043250e-01f, -4.64463264e-01f, -9.43992585e-02f, -2.11909920e-01f, -7.27644622e-01f,
  -2.54114985e-01f, 1.07938439e-01f, -2.74391193e-02f, 2.58495986e-01f, 1.56179085e-01f, -6.85705066e-01f, -3.74723107e-01f, 2.44681165e-01f, 6.68172538e-01f, 2.18044013e-01f,
  -9.38196629e-02f, -3.55111770e-02f, 2.59407014e-01f, 8.83634537e-02f, -5.81128538e-01f, -7.07509695e-03f, -2.08072647e-01f, -2.20708579e-01f, -2.89181650e-01f, -7.49620616e-01f,
  -3.40161204e-01f, -2.02015564e-01f, 4.70122099e-01f, 2.25486591e-01f, -1.36631742e-01f, 9.97722819e-02f, 1.33700800e-04f, 1.99235603e-01f, 6.73252121e-02f, -1.16617285e-01f,
  1.53978532e-02f, 8.33848678e-03f, 4.17891964e-02f, 1.42335286e-02f, -7.01214373e-02f, -4.38843155e-03f, 1.37890697e-01f, 2.67418593e-01f, 2.52793469e-02f, -1.27772227e-01f,
  -2.16540217e-01f, -1.23664007e-01f, -2.05157456e-04f, 1.14798680e-01f, 5.10314032e-02f, 1.91378906e-01f, 9.08210427e-02f, 1.73218578e-01f, 2.30735868e-01f, -6.99158967e-01f,
  -1.02407314e-01f, -3.62775214e-02f, -1.04675454e-03f, 1.57037407e-01f, 7.99017027e-02f, 5.96644357e-03f, -1.63796952e-03f, -3.05552017e-02f, 1.36365101e-01f, -4.25024964e-02f,
  -6.64641708e-02f, -1.09697603e-01f, 1.83292627e-02f, -1.96753964e-01f, 1.99295562e-02f, -2.87176855e-02f, -1.26580685e-01f, -5.10935932e-02f, -8.03643931e-03f, -2.76087113e-02f,
  1.11559480e-01f, 2.57123411e-02f, 4.75491695e-02f, 1.75423231e-02f, -5.89641407e-02f, 6.48513213e-02f, 3.77830751e-02f, 7.14907125e-02f, 4.57850583e-02f, -5.93904108e-02f,
  -1.36233881e-01f, 5.32872558e-01f, -5.36564112e-01f, 1.06936291e-01f, -7.98737481e-02f, 5.48306145e-02f, -1.53235584e-01f, 1.32566676e-01f, -3.84963751e-02f, -8.49964172e-02f,
  3.08652148e-02f, -1.68522313e-01f, -1.47087932e-01f, 5.49606793e-02f, 4.45018671e-02f, 1.04241408e-02f, -1.71914443e-01f, -1.51844740e-01f, 1.02439396e-01f, -9.46137607e-02f,
  -2.48014435e-01f, -1.15216099e-01f, -2.17602149e-01f, -1.43089309e-01f, -1.66177347e-01f, 5.75463362e-02f, -7.64304623e-02f, -5.35745509e-02f, -6.28974214e-02f, -5.76883256e-01f,
  -3.68500888e-01f, 1.83921099e-01f, -4.07701820e-01f, -1.27893388e-01f, 1.26531543e-02f, -6.06364235e-02f, -9.27481242e-03f, -7.46909827e-02f, 6.22359216e-02f, 8.82317349e-02f,
  3.28560872e-03f, 4.90311533e-02f, -1.39185525e-02f, 1.01379156e-01f, 1.60790551e-02f, 3.38584214e-01f, 3.46515238e-01f, 5.86304553e-02f, -1.57669947e-01f, 1.66460261e-01f,
  2.95047462e-01f, -2.32228599e-02f, -2.02691033e-01f, 1.27065077e-01f, 3.29630315e-01f, -3.63767752e-03f, -1.01065643e-01f, 1.05958112e-01f, 1.80459082e-01f, 5.14488637e-01f,
  -9.47543308e-02f, -6.13502078e-02f, -1.04924649e-01f, 7.49792382e-02f, 7.72070419e-03f, 1.72372982e-01f, 2.50137657e-01f, -3.68348346e-03f, 2.66082138e-01f, 1.59093156e-01f,
  4.05264385e-02f, 7.41226524e-02f, 1.47560433e-01f, 6.75418824e-02f, 8.05175528e-02f, -1.99044123e-02f, -7.64929550e-03f, 4.78885546e-02f, -2.23361552e-01f, -2.00027321e-02f,
  4.40843701e-01f, -5.58928214e-02f, -3.95229012e-01f, -1.60611510e-01f, -4.33867611e-02f, -2.73440868e-01f, -2.45588526e-01f, -2.70546861e-02f, -4.37281400e-01f, 9.50362682e-02f,
  -1.33684557e-03f, -1.00583001e-03f, 9.65858921e-02f, -8.91483203e-02f, 9.82470661e-02f, 7.65003189e-02f, -6.43701584e-04f, 1.38416663e-01f, 1.81137044e-02f, -5.36191743e-03f,
  -4.14254563e-03f, -5.60112633e-02f, -8.69176071e-03f, -6.79390207e-02f, 1.98275968e-02f, -1.09695621e-01f, 6.87860399e-02f, -8.75932351e-02f, -1.25562251e-01f, 5.86059950e-02f,
  -4.77977656e-02f, -7.44803101e-02f, -8.48861709e-02f, 1.61197647e-01f, -3.82806733e-02f, -1.01295181e-01f, 1.10908523e-01f, 1.36692330e-01f, -1.37841459e-02f, 2.72171441e-02f,
  -3.64161223e-01f, -3.73513222e-01f, 5.72257899e-02f, -1.88552476e-02f, 7.52190277e-02f, -1.04956657e-01f, -6.44827709e-02f, -2.81736925e-02f, -3.62390876e-02f, -7.62488171e-02f,
  -1.64090663e-01f, -7.01091532e-03f, -3.26058157e-02f, 1.36302441e-01f, -2.59534759e-03f, -1.46534830e-01f, 1.42467603e-01f, -5.05265081e-04f, -3.35280932e-02f, 6.21170131e-03f,
  -1.21559374e-01f, -3.16812962e-01f, -3.95021141e-01f, -1.60465673e-01f, -5.72022088e-02f, -3.54952246e-01f, -3.30957949e-01f, -2.03923702e-01f, -5.46104014e-01f, -3.61674011e-01f,
  -6.63143933e-01f, 1.65056333e-01f, 5.25582373e-01f, -2.41710290e-01f, 3.54228541e-02f, -4.25394699e-02f, -3.43958259e-01f, -3.77786517e-01f, -2.01447561e-01f, 1.55001357e-01f,
  1.37100503e-01f, 4.99303751e-02f, 7.55168125e-02f, 5.74027263e-02f, -1.61218241e-01f, 1.92477450e-01f, 4.19873953e-01f, 1.38160989e-01f, -2.65556276e-01f, -3.21233273e-01f,
  9.39248689e-03f, -1.28471658e-01f, -2.69778997e-01f, -7.90794715e-02f, 1.83519214e-01f, 1.01595201e-01f, 2.48632535e-01f, 5.42656556e-02f, 1.96572080e-01f, 6.19757533e-01f,
  5.78651130e-02f, -2.53824264e-01f, -1.40005365e-01f, -9.11856722e-03f, 2.27974668e-01f, -5.21920063e-02f, -1.00599557e-01f, 1.74552754e-01f, 1.26198381e-01f, 1.07013471e-01f,
  1.29976988e-01f, 1.27847388e-01f, 6.52269460e-03f, 3.38171981e-03f, -2.49260977e-01f, -2.88128883e-01f, -1.72527254e-01f, -1.48874760e-01f, -6.27242774e-02f, 2.67752465e-02f,
  3.27850401e-01f, 3.91177945e-02f, -1.78783923e-01f, -1.14042841e-01f, -1.10353760e-01f, -3.28238010e-02f, -1.78487152e-01f, -5.73174022e-02f, -2.29227141e-01f, -1.24884933e-01f,
  5.26560135e-02f, 1.07820973e-01f, -1.93999335e-02f, 8.17324966e-02f, 8.80535785e-03f, 6.86207265e-02f, 2.63007551e-01f, -2.40717246e-03f, 9.02085379e-02f, -7.76470006e-02f,
  5.99129759e-02f, -9.91909858e-03f, 6.06819205e-02f, -3.28121334e-02f, 3.27609479e-02f, -6.88982802e-03f, -1.93423294e-02f, -1.00021191e-01f, 1.02614373e-01f, 2.64987932e-03f,
  3.09282355e-03f, -1.13985185e-02f, 1.62440434e-01f, -1.05537608e-01f, 1.63963109e-01f, 5.58025576e-02f, 7.25213364e-02f, -1.82393938e-01f, -1.24264486e-01f, -5.32343164e-02f,
  -3.71978998e-01f, 2.56353140e-01f, -1.10762060e-01f, -1.26902685e-01f, 1.03966184e-01f, 5.36786020e-02f, 9.12692472e-02f, 2.44632605e-02f, -1.21666014e-01f, -1.43106431e-01f,
  -1.22814596e-01f, -4.76180427e-02f, 8.68560374e-02f, 4.85933200e-02f, -1.44311205e-01f, -1.79503039e-01f, -3.18617411e-02f, -1.37515306e-01f, 8.71660071e-04f, 3.07970941e-02f,
  1.56252623e-01f, -4.21188205e-01f, -4.32832628e-01f, -2.67864794e-01f, -1.68147668e-01f, -4.08435285e-01f, -2.71672726e-01f, -2.10015863e-01f, -3.53849053e-01f, -4.79666293e-01f,
  6.02860987e-01f, 2.11377934e-01f, 3.13868463e-01f, 4.26471494e-02f, -6.59963191e-01f, -6.43355012e-01f, -5.78597724e-01f, -1.02942564e-01f, -7.79806357e-03f, -2.48893611e-02f,
  -3.52521598e-01f, -8.40380341e-02f, 2.76935905e-01f, 1.54714957e-01f, 2.53606439e-01f, 2.65806466e-01f, 2.75924504e-01f, 1.97874084e-01f, -6.56113550e-02f, -5.36879003e-01f,
  -2.51481503e-01f, -1.50495360e-03f, 2.72860080e-01f, 2.58567054e-02f, -6.29462674e-02f, 5.07470109e-02f, 1.55771032e-01f, -2.96847560e-02f, -5.68296313e-02f, 3.14688981e-01f,
  7.84420297e-02f, 4.15076725e-02f, -1.39445499e-01f, 3.70035768e-02f, -8.84407107e-03f, 2.14343622e-01f, -1.55278873e-02f, 1.27377277e-02f, -3.13647874e-02f, -4.30299342e-02f,
  -1.88397262e-02f, -1.26618460e-01f, -9.48040113e-02f, -1.50869846e-01f, -1.92884609e-01f, -1.52929410e-01f, 1.28465474e-01f, 2.59929001e-01f, 1.54120669e-01f, -1.18048541e-01f,
  -2.27786660e-01f, -4.19969559e-01f, -1.38403878e-01f, -9.83818173e-02f, 4.63103279e-02f, -4.53762040e-02f, -2.32370660e-01f, -8.77551660e-02f, -2.34464258e-02f, 5.33999503e-02f,
  -2.95326859e-01f, 3.40350792e-02f, -2.58769915e-02f, -1.20985009e-01f, -2.32958049e-02f, -1.15191884e-01f, -9.28308144e-02f, -1.54620931e-01f, -1.14599921e-01f, -1.14116460e-01f,
  -9.69914198e-02f, -1.52980164e-01f, -7.37098083e-02f, 9.74675789e-02f, 8.12042579e-02f, -1.34407520e-01f, -1.56047031e-01f, 1.99742708e-02f, -1.14647157e-01f, 6.74561337e-02f,
  -5.83670251e-02f, -1.27578467e-01f, 7.35856444e-02f, 1.00738946e-02f, 5.64128673e-03f, 2.33100746e-02f, -5.44734225e-02f, -1.31738484e-01f, -3.32738720e-02f, -1.16968468e-01f,
  3.17099750e-01f, -1.65000975e-01f, 1.40690371e-01f, 1.51443183e-01f, -2.59304922e-02f, -3.67002524e-02f, 4.28872406e-02f, -8.66175890e-02f, -8.27737451e-02f, -9.78065431e-02f,
  -8.21556821e-02f, -3.79289612e-02f, 1.45592883e-01f, 1.16101846e-01f, -2.65416980e-01f, -2.16294482e-01f, -1.10300884e-01f, -4.71599661e-02f, -1.36001602e-01f, -1.09206829e-02f,
  2.12272964e-02f, -1.44064724e-01f, 5.35732135e-02f, 1.62407234e-01f, 4.80753519e-02f, 2.19651237e-02f, 3.52955796e-03f, -1.29731357e-01f, -1.26585931e-01f, -5.59093915e-02f,
  -1.22487746e-01f, 2.88704246e-01f, -1.84919566e-01f, 1.36212289e-01f, 2.35765129e-01f, 1.01053230e-01f, 2.78351635e-01f, 2.18346283e-01f, 2.11556271e-01f, 2.35867754e-01f,
  3.33688200e-01f, 3.26907963e-01f, 4.24068779e-01f, 2.64777899e-01f, 2.17115447e-01f, 8.80132020e-02f, 1.64137572e-01f, -9.84352753e-02f, -5.36292642e-02f, 1.61438167e-01f,
  3.56930614e-01f, 1.04896568e-01f, -1.12931453e-01f, 8.17204714e-02f, 2.11861238e-01f, 3.40779990e-01f, 2.30758801e-01f, 1.90983444e-01f, 1.24828130e-01f, 1.24181524e-01f,
  -1.55498818e-01f, -1.12694517e-01f, -5.00939861e-02f, 6.06847228e-03f, -1.42334267e-01f, -5.21029010e-02f, -1.09406710e-01f, -5.53442352e-02f, -3.84122692e-02f, -4.71755639e-02f,
  -9.16254967e-02f, -8.20332542e-02f, -6.61255121e-02f, 8.93948041e-03f, -1.47951365e-01f, -2.13442817e-01f, -1.65547535e-01f, 1.29806638e-01f, 1.26779214e-01f, 5.11572696e-03f,
  2.54660193e-02f, -8.09188858e-02f, -3.49607058e-02f, -1.96269210e-02f, 4.77311537e-02f, -1.06955236e-02f, -9.83503759e-02f, -3.80186141e-02f, -1.12875827e-01f, 8.94072428e-02f,
  -6.15688078e-02f, -1.06931642e-01f, -6.90614283e-02f, 4.71760109e-02f, -5.20267375e-02f, -7.90994056e-03f, -6.25612661e-02f, -3.31983715e-02f, -2.66438015e-02f, -4.52872328e-02f,
  6.83829561e-02f, 1.24775499e-01f, -1.62595809e-02f, 3.35061587e-02f, -9.30310860e-02f, -1.82175580e-02f, -1.31007537e-01f, -8.80818740e-02f, -2.51415461e-01f, -5.04607446e-02f,
  -8.31548944e-02f, -1.47227431e-02f, -1.06977552e-01f, -8.72543305e-02f, 1.32516706e-02f, -6.06034324e-02f, -1.07988633e-01f, 1.14894873e-02f, -1.01298675e-01f, -7.74836494e-03f,
  3.93077582e-01f, -1.50828540e-01f, 1.24789789e-01f, 5.95716164e-02f, -1.07677385e-01f, -1.99237853e-01f, -7.04434440e-02f, -1.50108129e-01f, -1.03590146e-01f, -6.08605146e-02f,
  -5.57243004e-02f, -1.33686185e-01f, -1.50905311e-01f, -4.69073802e-02f, -1.26381844e-01f, -6.28229901e-02f, -8.16082805e-02f, 1.93193123e-01f, 1.05816148e-01f, -9.77881029e-02f,
  3.44023444e-02f, 9.24379975e-02f, 5.82063943e-02f, 1.04490124e-01f, 6.31776154e-02f, 9.11646411e-02f, 5.04852869e-02f, -3.04834731e-02f, 6.36653677e-02f, 1.63138002e-01f,
  -6.84583843e-01f, -1.25025183e-01f, -1.82028309e-01f, -1.68068886e-01f, -2.03521118e-01f, -2.73915231e-01f, -3.45468372e-01f, -1.15831062e-01f, 5.03831916e-02f, 6.97391555e-02f,
  -8.73920172e-02f, -6.96064010e-02f, -9.30855237e-03f, -1.32815763e-01f, -2.46826470e-01f, -1.56663582e-01f, -2.50086755e-01f, -4.48032647e-01f, -3.31596643e-01f, -2.57915884e-01f,
  -1.79905176e-01f, -3.12007397e-01f, -2.10991070e-01f, -1.02017792e-02f, 1.58659443e-01f, -5.72139546e-02f, 7.37897074e-03f, -1.25658691e-01f, -3.12641412e-01f, -2.10301325e-01f,
  2.77410150e-01f, -2.42194980e-01f, -2.89255064e-02f, -1.19050935e-01f, 1.33659318e-01f, -3.15816291e-02f, -8.92453045e-02f, 2.65225545e-02f, 1.81079633e-03f, 3.40022077e-03f,
  6.21180423e-02f, 6.44602627e-02f, -9.43758059e-03f, 1.14474669e-01f, -1.17577438e-03f, -5.25267515e-03f, 1.09633029e-01f, -5.86978830e-02f, 3.79001051e-02f, 2.31272757e-01f,
  8.64957199e-02f, -1.69729814e-01f, 6.52231500e-02f, 1.52528614e-01f, 5.51559590e-02f, -2.19220802e-01f, 7.56474361e-02f, 4.76484410e-02f, 6.48746965e-03f, 3.09110787e-02f,
  1.06981188e-01f, 1.59550130e-01f, 9.26976576e-02f, 8.77267197e-02f, 9.96428207e-02f, -6.43745214e-02f, -4.03262908e-04f, 8.90919715e-02f, -1.19248576e-01f, 1.09266944e-01f,
  9.36502665e-02f, -2.97271404e-02f, 1.38269337e-02f, -1.28072277e-01f, -9.43111852e-02f, -1.04928762e-01f, -6.67435676e-02f, 5.48218489e-02f, 1.58394556e-02f, 1.32862516e-02f,
  -1.29936486e-02f, 1.23695180e-01f, 1.50249740e-02f, -3.23675498e-02f, -6.00922517e-02f, 1.12761185e-02f, -1.40867680e-01f, -1.90507527e-02f, 3.69354412e-02f, -1.23129927e-01f,
  2.67587364e-01f, -4.41133380e-01f, -8.34745690e-02f, 7.23245973e-03f, -6.78824112e-02f, 1.57809347e-01f, -3.67528759e-02f, 4.80065821e-03f, -7.84727260e-02f, 1.22743216e-03f,
  1.13531183e-02f, 1.60119534e-02f, 9.24386829e-02f, 2.11501986e-01f, -4.01109606e-02f, 3.06059830e-02f, -1.33297537e-02f, -7.32746422e-02f, 7.20764622e-02f, 3.26660365e-01f,
  1.99396595e-01f, -1.35925040e-01f, 5.69433458e-02f, 1.32042661e-01f, 6.85089454e-02f, -1.81398571e-01f, 8.63761455e-02f, 1.17674254e-01f, -1.76523641e-01f, 1.04457043e-01f,
  4.97160286e-01f, -1.02259845e-01f, 2.00711004e-02f, 1.15038395e-01f, -1.31281778e-01f, -2.65909344e-01f, -3.42374325e-01f, -1.39530540e-01f, 4.03940715e-02f, 9.78485718e-02f,
  1.96900051e-02f, 1.43037066e-01f, 1.34456560e-01f, 1.98708385e-01f, 2.04211354e-01f, -9.84268822e-03f, 2.61895601e-02f, 2.79662162e-01f, 3.04597527e-01f, 1.64949119e-01f,
  1.08538590e-01f, 2.05762982e-01f, 3.39914203e-01f, 2.71618545e-01f, 2.13950187e-01f, 1.13608547e-01f, 8.94736350e-02f, 7.29930848e-02f, 5.26617505e-02f, 2.43059307e-01f,
  -5.63651547e-02f, -2.37557944e-02f, 8.36262032e-02f, 1.15656100e-01f, -5.51215522e-02f, -3.43950279e-02f, 4.21306193e-02f, 7.23699555e-02f, 1.02213390e-01f, 6.61900192e-02f,
  -7.15913922e-02f, -3.71361598e-02f, -3.37052867e-02f, 2.75248382e-02f, -1.53936539e-03f, 5.13293669e-02f, -1.74423843e-03f, 1.82067364e-01f, 1.38568506e-01f, -5.68456054e-02f,
  7.88342953e-02f, -1.59030154e-01f, -1.04994610e-01f, -1.14738025e-01f, 7.95849506e-03f, -4.84699756e-02f, -1.55135468e-01f, 3.12620103e-02f, -1.09140202e-01f, 1.00191556e-01f,
  1.01551697e-01f, -1.15172835e-02f, 2.15728030e-01f, 2.57099032e-01f, 3.35896611e-01f, 1.71407759e-01f, 8.92890170e-02f, 9.00721103e-02f, 1.37881458e-01f, 2.80619822e-02f,
  -2.84808762e-02f, 7.79095441e-02f, -6.47277161e-02f, -5.32020740e-02f, 1.26322076e-01f, -5.64854313e-03f, -2.91857839e-01f, -2.11152270e-01f, 5.88426776e-02f, 1.49214966e-02f,
  1.19612813e-02f, -1.08309567e-01f, 6.34788945e-02f, 1.07675353e-02f, -4.88812812e-02f, -1.38150826e-02f, 1.11785959e-02f, -4.41153459e-02f, -5.36696427e-02f, 3.17494906e-02f,
  -3.63063037e-01f, 1.39939645e-02f, 1.22114547e-01f, -5.75341024e-02f, -1.16397571e-02f, 1.66263338e-02f, 3.70763578e-02f, -2.00116355e-02f, -1.08903445e-01f, -4.34528068e-02f,
  -1.13835879e-01f, 3.49288844e-02f, -4.75095548e-02f, 6.14827983e-02f, 3.60429361e-02f, -1.41877100e-01f, 5.56474254e-02f, -9.14486218e-03f, -4.21394072e-02f, -1.54459387e-01f,
  -1.47773042e-01f, -2.71208167e-01f, -2.12121040e-01f, -1.87981978e-01f, -4.01518755e-02f, -9.15471911e-02f, -7.66208023e-02f, -7.65766874e-02f, -1.51938125e-01f, -8.17326009e-02f,
  -6.18424714e-01f, -3.60437363e-01f, 2.94863433e-01f, 2.35659070e-02f, 2.45197579e-01f, 7.45800976e-03f, -8.97191539e-02f, -1.32313490e-01f, -1.85728252e-01f, -4.09112163e-02f,
  -1.90193355e-01f, 6.33196682e-02f, 1.00790374e-02f, 4.36342321e-02f, -1.46958143e-01f, 1.36399448e-01f, 9.68006700e-02f, 1.77846640e-01f, 3.58675756e-02f, 3.15277651e-02f,
  -3.83962207e-02f, -7.56684616e-02f, -1.21512167e-01f, -1.02557447e-02f, 8.82350132e-02f, 1.65414050e-01f, 1.80276826e-01f, 8.29382390e-02f, 7.39089772e-02f, 2.41265029e-01f,
  4.04878974e-01f, -2.99021751e-01f, 6.94121867e-02f, -1.84888765e-01f, 9.86698419e-02f, -6.20885454e-02f, -7.31888935e-02f, -8.24573077e-03f, -1.58678710e-01f, -6.20338023e-02f,
  -7.84017518e-03f, -1.25002980e-01f, -4.29915115e-02f, -1.26160398e-01f, -1.30471170e-01f, -8.99493396e-02f, -1.06032208e-01f, -1.45868734e-01f, -4.70756814e-02f, -1.07820801e-01f,
  -9.86780524e-02f, -8.19269419e-02f, 8.14518109e-02f, -6.89930767e-02f, -1.37226582e-01f, 1.38465865e-02f, 3.90600488e-02f, -3.51805543e-03f, -7.20861629e-02f, -7.26588741e-02f,
  2.13620365e-02f, 1.05956458e-01f, 9.36306342e-02f, 1.94872841e-02f, 3.63112614e-02f, 8.45811889e-02f, 1.62146419e-01f, 7.29746819e-02f, 1.08882755e-01f, 1.44594148e-01f,
  1.23776548e-01f, 5.86087629e-02f, -8.10017958e-02f, -9.84385163e-02f, 7.49194473e-02f, 7.85218775e-02f, 1.57315880e-01f, 3.93917896e-02f, 1.75499499e-01f, 1.85845513e-03f,
  5.05534299e-02f, 4.15459163e-02f, 8.68464038e-02f, -2.00960524e-02f, 2.65310854e-02f, -1.30312843e-02f, 5.34234792e-02f, 1.84878148e-02f, 4.39317264e-02f, 5.57872206e-02f,
  1.07662648e-01f, -2.16895923e-01f, 1.95024520e-01f, 1.25072584e-01f, 3.77492867e-02f, -6.95183724e-02f, 1.59735993e-01f, -2.09463947e-02f, 1.60048172e-01f, 9.87104923e-02f,
  3.51339169e-02f, 3.64972726e-02f, 3.93426642e-02f, 6.75192252e-02f, 5.56354821e-02f, 5.64148426e-02f, -5.26307113e-02f, 2.92495750e-02f, 5.11361333e-03f, 5.84148914e-02f,
  3.05838021e-03f, -4.00176011e-02f, 2.05994889e-01f, 1.91496029e-01f, 5.84338084e-02f, 1.95920154e-01f, 2.52386957e-01f, 1.85731992e-01f, 2.00126380e-01f, -4.94693220e-03f,
  -4.47861940e-01f, -3.05995010e-02f, 9.01956037e-02f, -3.12722892e-01f, -1.90047786e-01f, 1.46636799e-01f, 4.22917128e-01f, 1.59356713e-01f, 8.75175074e-02f, 4.21552479e-01f,
  2.64625088e-03f, -4.50383902e-01f, -2.07500935e-01f, -2.90728211e-01f, -1.49431601e-01f, 4.61151510e-01f, 3.25153142e-01f, -2.03556091e-01f, -4.01029080e-01f, -1.81713343e-01f,
  -1.50700822e-01f, -1.93917811e-01f, -3.67943972e-01f, -2.95359462e-01f, -9.17699262e-02f, -2.41572857e-01f, 4.88723256e-02f, -1.47473305e-01f, -9.46586728e-02f, 8.41286182e-02f,
  4.24957901e-01f, -4.47673023e-01f, 7.27179833e-03f, -2.76470006e-01f, -6.56176805e-02f, 8.55565369e-02f, 1.72306687e-01f, 7.28344894e-04f, -1.56174272e-01f, 2.46731386e-01f,
  -2.09071308e-01f, -9.60683227e-02f, -1.83667406e-01f, -7.45643899e-02f, -6.66792095e-02f, 1.14150584e-01f, -1.73036039e-01f, -2.51107991e-01f, -1.25599951e-01f, 2.75344756e-02f,
  -2.11749107e-01f, -1.06155574e-01f, -1.83053706e-02f, -7.94338714e-03f, -1.87799424e-01f, -1.23478174e-01f, -8.85578170e-02f, -2.58134872e-01f, -1.85292006e-01f, 2.62020290e-01f,
  2.20063373e-01f, 1.38918623e-01f, -5.00792451e-02f, 3.98284122e-02f, 2.21421551e-02f, -1.77007988e-02f, -9.20486301e-02f, -7.74652660e-02f, 8.35415944e-02f, 8.73730853e-02f,
  -5.89665771e-02f, 8.59167948e-02f, -3.18741463e-02f, 7.11170658e-02f, 3.35397869e-02f, 1.01911938e-02f, 8.84552151e-02f, 4.29551154e-02f, 5.05404770e-02f, -3.12027466e-02f,
  -1.09209590e-01f, 6.82422146e-02f, -1.18117712e-01f, 3.48128676e-02f, 6.25180304e-02f, 6.43711910e-03f, 1.11856639e-01f, -7.76154771e-02f, -1.32329717e-01f, -4.95279059e-02f,
  1.13079183e-01f, -3.41976643e-01f, 3.03682506e-01f, -2.21083850e-01f, 2.85055116e-03f, -1.28648737e-02f, 5.24517894e-02f, 1.05018727e-01f, -3.03252377e-02f, 9.77003798e-02f,
  -1.74508810e-01f, 2.34338306e-02f, -2.02465296e-01f, 3.89593914e-02f, -2.02134177e-02f, 8.42336938e-02f, 1.33252859e-01f, -1.00536019e-01f, -7.81701058e-02f, 5.37287816e-02f,
  1.51441827e-01f, 7.24179596e-02f, 1.80617824e-01f, 2.16676846e-01f, -6.83407784e-02f, 5.20110242e-02f, 1.61303744e-01f, 1.50834963e-01f, 3.49344201e-02f, 5.02276957e-01f,
  4.75922048e-01f, -1.23284243e-01f, 9.81048197e-02f, 4.33573537e-02f, -2.39074141e-01f, -8.83386955e-02f, -1.96930960e-01f, 2.32117977e-02f, 5.68760224e-02f, 2.90388651e-02f,
  2.27462835e-04f, 1.28096938e-01f, 1.35608897e-01f, 5.15993312e-02f, 1.87178150e-01f, 9.76341590e-02f, 5.27425967e-02f, 2.91092843e-01f, 2.92091966e-01f, 8.35584775e-02f,
  3.21534425e-02f, 3.98597419e-02f, 2.83463627e-01f, 1.38274446e-01f, 1.22632511e-01f, 1.69804245e-01f, 4.08053286e-02f, 1.79897882e-02f, 2.37029698e-03f, 1.99768886e-01f,
  -5.72479181e-02f, 2.45469749e-01f, -6.19996488e-02f, 1.26698175e-02f, -1.74142107e-01f, 2.65980009e-02f, 9.66926888e-02f, -2.01220158e-02f, -1.00723848e-01f, 6.85256422e-02f,
  -1.08070955e-01f, 2.02622768e-02f, -9.82577205e-02f, -8.14257115e-02f, 5.19807115e-02f, -6.13497682e-02f, 4.85961959e-02f, 9.07580256e-02f, -2.22797859e-02f, -5.86006790e-02f,
  -1.54872118e-02f, -2.40614489e-02f, 1.64066404e-02f, 3.73961627e-02f, 2.80839540e-02f, -9.75131691e-02f, -4.20982465e-02f, 1.37290254e-01f, -1.24532469e-02f, 2.38592759e-01f,
  -4.97178845e-02f, -3.68438810e-02f, 5.84304631e-02f, 2.74038203e-02f, 8.42715353e-02f, 9.22257230e-02f, 1.05453059e-01f, 1.71121377e-02f, 1.07193425e-01f, 1.14623360e-01f,
  1.74746588e-01f, 2.44916946e-01f, 1.76710039e-02f, 1.80638343e-01f, 1.59093410e-01f, 5.97017109e-02f, -2.94112191e-02f, 6.41956851e-02f, 3.02894749e-02f, 6.82750642e-02f,
  -4.94392414e-04f, -2.27990914e-02f, 1.53389936e-02f, 2.83382218e-02f, 1.52106494e-01f, 1.37333736e-01f, 1.33144706e-01f, 2.01495234e-02f, 7.86276832e-02f, 2.37370413e-02f,
  -2.72310555e-01f, -5.49763665e-02f, 1.74398005e-01f, 4.94559892e-02f, -4.29525115e-02f, -9.59205255e-03f, -9.25063938e-02f, -1.03762299e-01f, -2.28563711e-01f, -5.33989593e-02f,
  1.12881642e-02f, -1.37632452e-02f, -1.19014695e-01f, -4.14229557e-02f, 9.92252678e-02f, 9.27624777e-02f, -9.50432499e-04f, -1.57655161e-02f, -2.90963091e-02f, -1.35668948e-01f,
  -8.67920518e-02f, 6.44156411e-02f, -3.32817510e-02f, 2.30559129e-02f, -7.63450339e-02f, -1.20631449e-01f, -3.69827561e-02f, -9.33819562e-02f, -7.70393983e-02f, 3.60209006e-03f,
  5.98272622e-01f, -2.08768636e-01f, 1.28093541e-01f, 1.09926425e-01f, -4.66497928e-01f, -6.21598065e-01f, -6.15280747e-01f, -3.29868257e-01f, -1.16537236e-01f, -8.56444836e-02f,
  -1.74728073e-02f, 8.41007531e-02f, -1.14622660e-01f, 3.08265584e-03f, 9.38114151e-02f, -6.24344721e-02f, 1.60734937e-01f, 4.19839501e-01f, 3.27393442e-01f, 6.78659081e-02f,
  1.46372437e-01f, 2.49607474e-01f, 5.31528354e-01f, 1.69292659e-01f, 1.27156705e-01f, 7.29416087e-02f, 7.72923008e-02f, 2.40319371e-01f, 4.10162956e-02f, 4.03247327e-01f,
  4.10864621e-01f, -1.73475984e-02f, -2.38758013e-01f, 2.19726101e-01f, 1.79079682e-01f, 1.69355258e-01f, 8.16727579e-02f, 1.15362190e-01f, 3.35167721e-02f, 7.97983706e-02f,
  4.55783084e-02f, 1.62788667e-02f, -3.63816358e-02f, 4.66647819e-02f, -2.14407314e-02f, -1.81485340e-01f, -4.39261906e-02f, 1.24895044e-01f, 8.44019651e-02f, 8.07758495e-02f,
  5.14202900e-02f, -2.70881411e-02f, -2.74331897e-01f, -2.39969000e-01f, -2.36030862e-01f, 4.39502373e-02f, -1.07153147e-01f, 1.12430369e-02f, -9.89964232e-02f, 1.21732622e-01f,
  -1.20882824e-01f, 1.42518520e-01f, -4.68080230e-02f, 4.69393767e-02f, 1.21677041e-01f, -6.86657801e-03f, 1.71836540e-02f, 2.44523510e-02f, 6.00733161e-02f, -2.11091200e-03f,
  1.32088587e-02f, 9.58961248e-02f, 7.34795108e-02f, 3.89645919e-02f, -1.60261113e-02f, 9.01340246e-02f, 1.28802776e-01f, 1.03829674e-01f, 3.61199640e-02f, 6.13343120e-02f,
  9.46953520e-02f, -8.10713600e-03f, 3.20442431e-02f, 3.56462561e-02f, 1.04847096e-01f, 9.22144800e-02f, 9.62545723e-02f, 8.27751756e-02f, 4.49247882e-02f, 3.02585997e-02f,
  -3.12450469e-01f, -1.63012132e-01f, 7.79233277e-02f, 5.27184270e-02f, -9.83703360e-02f, -8.54865313e-02f, 1.02955818e-01f, 1.12334587e-01f, 6.73564374e-02f, -3.01066227e-02f,
  -1.34693846e-01f, 1.27296848e-02f, -1.32359624e-01f, -1.36130340e-02f, 1.62268713e-01f, -1.17784165e-01f, 1.10121705e-01f, 6.72114938e-02f, -6.49392232e-02f, 6.64651692e-02f,
  -1.18090950e-01f, -2.77470887e-01f, -3.02986860e-01f, -3.05076241e-01f, -1.45478830e-01f, -1.76130295e-01f, -2.55632699e-01f, -1.89159647e-01f, -2.98083484e-01f, -4.20702159e-01f,
  -4.70793992e-02f, 3.70230198e-01f, -2.03149602e-01f, -1.97414905e-01f, -3.14071387e-01f, -2.63784170e-01f, 7.56217316e-02f, -3.25780921e-03f, -2.12623999e-01f, 1.65732101e-01f,
  1.79622889e-01f, -2.19123259e-01f, -2.14136839e-02f, 9.04999115e-03f, 1.82259366e-01f, 3.84784073e-01f, 2.67724544e-01f, -9.72436666e-02f, -4.57294226e-01f, -3.85557383e-01f,
  -1.09632164e-01f, -1.17283680e-01f, -2.31642291e-01f, -3.44408005e-02f, -2.08933771e-01f, -2.22553775e-01f, -5.91360927e-02f, -1.69555321e-01f, -4.89690006e-02f, -1.90577433e-02f,
  -2.58824140e-01f, -1.35570571e-01f, -1.53528780e-01f, -5.10668494e-02f, -9.18278936e-03f, -6.31791949e-02f, 3.63226421e-02f, -6.04129620e-02f, 1.91884451e-02f, -1.25502134e-02f,
  -6.86428472e-02f, -3.60460095e-02f, -9.39983726e-02f, -1.57130077e-01f, -2.63876408e-01f, -1.70100436e-01f, -1.78076588e-02f, 3.05308346e-02f, 2.45733671e-02f, 1.02236696e-01f,
  2.36101195e-01f, 4.82655428e-02f, -1.34079248e-01f, 2.32213493e-02f, 3.57468165e-02f, -1.17367253e-01f, -8.60142708e-02f, -1.87847808e-01f, 9.22783986e-02f, -2.57978775e-02f,
  7.38517419e-02f, 8.97855163e-02f, -1.03493185e-05f, -2.02418510e-02f, 1.59116253e-01f, 1.11462913e-01f, 7.62481168e-02f, 2.23541185e-02f, 1.41844958e-01f, 8.77439324e-03f,
  -8.41633230e-02f, 1.54675841e-01f, -6.99179843e-02f, 2.35359520e-02f, 1.06656127e-01f, 8.22286308e-02f, 1.64526999e-01f, 5.49518131e-02f, 2.27104072e-02f, 6.73880652e-02f,
  -6.62246672e-03f, 8.66804644e-02f, 7.11338297e-02f, -8.00300110e-03f, 8.04790482e-02f, -1.91376954e-02f, 3.40854973e-02f, 1.36315942e-01f, -9.76868048e-02f, 1.35761932e-01f,
  -2.96412081e-01f, 2.50346959e-01f, 2.55756564e-02f, -1.55284517e-02f, -1.11610629e-01f, -3.12714726e-02f, -2.62983087e-02f, 1.49826229e-01f, -9.61402655e-02f, -8.59675929e-02f,
  -1.66591052e-02f, 2.23133136e-02f, 1.32021368e-01f, -1.61585864e-02f, -8.19576606e-02f, -2.29008682e-02f, 1.34839907e-01f, 4.53753509e-02f, 3.44539322e-02f, 9.25055742e-02f,
  3.65597010e-01f, 1.56469256e-01f, 2.07518086e-01f, 3.87104899e-02f, 1.11042753e-01f, 6.27216771e-02f, 9.72207859e-02f, 3.94665785e-02f, 1.64936677e-01f, 3.04903239e-01f,
  3.47042121e-02f, 5.18905163e-01f, 1.41178474e-01f, -8.09521973e-02f, 9.96804833e-02f, 2.20176920e-01f, 3.44852298e-01f, 3.13282907e-01f, 6.71356395e-02f, 3.18915009e-01f,
  2.78154433e-01f, -3.70187968e-01f, -3.74373406e-01f, -4.79018897e-01f, -4.76428419e-01f, 5.14869131e-02f, -2.48191297e-01f, -6.05232596e-01f, -7.37616479e-01f, -4.21166331e-01f,
  -2.73617238e-01f, -1.60236746e-01f, -2.95093209e-01f, -3.20319802e-01f, 2.14818373e-01f, -1.44836277e-01f, 3.15718204e-01f, 1.29255839e-02f, -7.92786852e-02f, -2.61207819e-01f,
  -2.75956541e-01f, 5.57716906e-01f, -1.38478190e-01f, 2.04202794e-02f, 1.94681183e-01f, -1.65142938e-01f, 4.22655754e-02f, 8.03196505e-02f, -1.17367536e-01f, -8.56255367e-03f,
  -1.25623360e-01f, -6.00110255e-02f, -9.80550330e-03f, -9.30498913e-02f, -4.20134291e-02f, -1.37592196e-01f, -1.15251854e-01f, -3.10688347e-01f, -2.30941832e-01f, 6.83198124e-02f,
  -2.62202501e-01f, 1.29413947e-01f, 2.91718133e-02f, 1.43078178e-01f, -1.56415366e-02f, -2.14186653e-01f, 3.11711878e-01f, -4.18585762e-02f, 2.48225871e-03f, 1.28126487e-01f,
  2.82092672e-02f, -4.38130274e-02f, -3.01790237e-02f, 7.29956552e-02f, 1.36710569e-01f, 7.16513321e-02f, 1.78804323e-02f, -1.34236421e-02f, 7.74809998e-03f, -5.52564152e-02f,
  1.31412461e-01f, 3.90623556e-03f, 1.33803666e-01f, 8.93908590e-02f, -1.80536747e-01f, 1.83259305e-02f, 3.37747857e-02f, 9.67452675e-02f, -1.53789073e-02f, 1.46058127e-02f,
  -6.72016758e-03f, -4.55245972e-02f, -1.24262542e-01f, -1.11475922e-02f, 8.76125880e-03f, -6.79538585e-03f, 2.60457620e-02f, 1.82877723e-02f, 1.11977816e-01f, 6.86905384e-02f,
  1.29634393e-02f, 1.17989831e-01f, 3.47011983e-02f, -7.32075274e-02f, 1.21146128e-01f, -1.01545407e-03f, 1.90439954e-01f, -6.01504333e-02f, 1.35466933e-01f, 8.06661174e-02f,
  -2.42484640e-02f, -9.10080671e-02f, 1.02635629e-01f, -9.89257023e-02f, -5.56550361e-02f, -1.13672212e-01f, -1.59793407e-01f, -1.61790147e-01f, -8.15845132e-02f, 1.39334038e-01f,
  -3.81019115e-02f, -7.48958031e-04f, -2.96618015e-01f, -1.47910520e-01f, 7.69283175e-02f, -1.93824112e-01f, -1.69801921e-01f, -1.54793695e-01f, -1.61122307e-01f, -4.08875048e-02f,
  5.11769056e-01f, -3.80189568e-01f, -3.82733792e-01f, 2.82711834e-01f, -2.86825269e-01f, -4.07325238e-01f, -5.56662738e-01f, -3.89008485e-02f, 1.76623285e-01f, -4.03570235e-01f,
  -3.97434950e-01f, -1.63544849e-01f, 3.99137735e-02f, -1.91033721e-01f, -1.91272497e-01f, -4.35525537e-01f, -2.52843350e-01f, -1.54272556e-01f, -3.00967872e-01f, -6.12701118e-01f,
  -3.96488070e-01f, -6.47149533e-02f, -5.71728265e-03f, -8.69863480e-02f, 8.74102190e-02f, -2.27661729e-02f, 5.25407903e-02f, -1.15616791e-01f, -3.01365227e-01f, -1.20913580e-01f,
  -2.00283498e-01f, 3.61148566e-02f, 5.78294620e-02f, -1.85800884e-02f, -1.43656870e-02f, -1.03987679e-02f, -8.40939358e-02f, 7.20025674e-02f, -4.94350456e-02f, 2.69888658e-02f,
  -1.89322308e-01f, -2.05915958e-01f, 1.05699815e-01f, -7.15447590e-02f, -5.76595366e-02f, -1.07228599e-01f, -1.39082223e-01f, -1.15277693e-01f, -2.72530895e-02f, -2.53146350e-01f,
  -3.96826625e-01f, -6.33989871e-02f, 1.05356537e-01f, -1.14988707e-01f, -7.71526620e-02f, 2.83616893e-02f, -1.11726858e-01f, 4.28116769e-02f, 4.26601693e-02f, 2.10056752e-01f,
  4.29659076e-02f, 9.10921842e-02f, -5.48209809e-02f, 5.04314676e-02f, 6.40021861e-02f, 1.50073096e-01f, 1.91546828e-01f, 6.00151420e-02f, -6.53436258e-02f, 6.13686536e-03f,
  -2.37641130e-02f, -5.66347204e-02f, 5.67335151e-02f, -1.56324394e-02f, 1.45039195e-02f, -1.03066377e-02f, 4.11064774e-02f, -3.99108529e-02f, 1.04334161e-01f, 9.69714969e-02f,
  -1.07407728e-02f, 4.37675603e-02f, 1.03962027e-01f, 2.96373032e-02f, -1.85146987e-01f, 1.01814799e-01f, -1.14258938e-01f, -1.04763836e-01f, 7.18041062e-02f, -1.42170459e-01f,
  4.24086809e-01f, -8.74216668e-03f, 1.61963999e-01f, 3.69162448e-02f, 1.17100127e-01f, -7.63659775e-02f, -3.59726779e-04f, 1.60559136e-02f, 1.15453310e-01f, -4.16359454e-02f,
  -1.74841046e-01f, -1.43344905e-02f, 1.05562195e-01f, -6.19392358e-02f, -1.11410454e-01f, -1.22141883e-01f, -2.24168688e-01f, 4.46926616e-02f, -9.01536271e-02f, -2.09988415e-01f,
  -6.52886555e-02f, 9.20435861e-02f, 2.87055880e-01f, 1.50073886e-01f, 1.62394106e-01f, 1.98331192e-01f, 1.19972546e-02f, 7.05718547e-02f, 2.48047307e-01f, 1.68789938e-01f,
  4.91522163e-01f, 3.87866825e-01f, -2.40775235e-02f, 2.25156158e-01f, 9.39821750e-02f, 1.94088250e-01f, 2.31488615e-01f, 2.99427152e-01f, 2.18482688e-01f, 2.44970530e-01f,
  2.22612202e-01f, 2.89743841e-01f, 2.15876833e-01f, 1.48019418e-01f, 1.96398601e-01f, 1.39587149e-01f, 1.12356402e-01f, 3.34708765e-02f, 5.55947311e-02f, 1.76460251e-01f,
  2.22113907e-01f, 1.38419509e-01f, 9.53635573e-02f, 1.89411908e-01f, 3.65248658e-02f, 4.01674807e-02f, 1.05620861e-01f, 4.96613309e-02f, 1.17290698e-01f, -2.81040575e-02f,
  -2.41364926e-01f, 1.56199694e-01f, -1.75701976e-01f, -3.31594027e-03f, -6.29576296e-02f, -7.60597438e-02f, 1.08590953e-01f, -1.55898362e-01f, 8.75445977e-02f, -1.72193516e-02f,
  -1.21110091e-02f, -1.05722338e-01f, 1.17091455e-01f, 2.46358719e-02f, -1.09115832e-01f, -1.49265587e-01f, -5.42717651e-02f, -7.04213902e-02f, -1.15559243e-01f, -7.30977654e-02f,
  8.13434497e-02f, -7.30471238e-02f, -2.22421028e-02f, 5.48456237e-02f, 5.97490966e-02f, -1.47848859e-01f, -7.99725577e-02f, -1.21065453e-01f, 1.10843927e-02f, 6.66971728e-02f,
  1.98125407e-01f, 9.12993494e-03f, -5.44959158e-02f, 2.25202572e-02f, 2.34652936e-01f, -3.17538977e-02f, -1.18779801e-02f, 2.97732987e-02f, -4.29994278e-02f, 3.18942443e-02f,
  4.06163558e-03f, -1.17789082e-01f, 1.09661312e-03f, -1.00160073e-02f, -4.42675222e-03f, 5.18947951e-02f, -7.17031807e-02f, -8.55453536e-02f, -7.58442953e-02f, 1.08923271e-01f,
  1.57084491e-03f, -1.74684346e-01f, -9.50246304e-03f, 3.79774794e-02f, -1.45615533e-01f, 4.23811004e-02f, 3.96957919e-02f, 2.38276012e-02f, 6.46812320e-02f, 1.64964005e-01f,
  -3.01602762e-02f, 1.04186423e-01f, -7.37611055e-02f, -1.27959803e-01f, -7.94092789e-02f, -7.78623819e-02f, 1.06756322e-01f, -5.56113869e-02f, 3.95553149e-02f, 7.17488676e-02f,
  -7.77340401e-03f, 2.77863145e-02f, 1.01470754e-01f, -1.02802306e-01f, -1.53889284e-01f, -1.20047800e-01f, -4.06279005e-02f, -1.60487711e-01f, -1.40386850e-01f, -1.70534492e-01f,
  -9.38782468e-02f, -2.09723949e-01f, -1.72497064e-01f, -1.72459692e-01f, -1.50689602e-01f, -2.15470772e-02f, -1.64342910e-01f, -4.53874506e-02f, -1.72244772e-01f, -2.50801630e-02f,
  -6.26472950e-01f, 4.41748276e-02f, 2.54971385e-01f, -2.42012724e-01f, 2.83989720e-02f, 2.78894871e-01f, 4.11283404e-01f, 1.38327897e-01f, -1.43221945e-01f, 6.38517668e-04f,
  -1.60959408e-01f, -3.20086300e-01f, -2.99444795e-01f, -1.36373669e-01f, 1.10404484e-01f, 2.68514842e-01f, 4.08389956e-01f, 2.08673343e-01f, 4.20910865e-02f, 3.81931178e-02f,
  -2.44826358e-02f, -1.45583734e-01f, -2.25414097e-01f, 9.32707042e-02f, -9.66868401e-02f, -8.95551220e-02f, -5.84387453e-03f, -7.46424571e-02f, 2.85518259e-01f, -1.07964464e-02f,
  -3.93978864e-01f, -2.55075693e-01f, 7.05080703e-02f, -2.75499433e-01f, -2.14115098e-01f, -3.48800756e-02f, -2.94102672e-02f, -1.96903303e-01f, -3.06484345e-02f, 2.29074638e-02f,
  -2.63955861e-01f, -6.92203045e-02f, -2.81066388e-01f, -6.78024217e-02f, -1.39447466e-01f, -3.23927812e-02f, 2.10213568e-02f, -1.08465692e-02f, 8.33019707e-03f, -5.40528744e-02f,
  9.34462473e-02f, -6.26114905e-02f, -5.86200207e-02f, 2.04323024e-01f, 7.78723881e-02f, 2.41898419e-03f, 2.03845860e-03f, -7.84241632e-02f, 3.27663906e-02f, -1.67550355e-01f,
  -4.91823927e-02f, -6.47078604e-02f, 1.03233801e-02f, -1.42005803e-02f, -8.41188952e-02f, 3.13053578e-02f, -2.21225549e-03f, -4.92785498e-02f, -9.41569135e-02f, -1.95872456e-01f,
  3.25017571e-02f, -5.04083298e-02f, -7.03604072e-02f, -2.10368372e-02f, -4.76860180e-02f, -1.38277002e-02f, 3.16113643e-02f, -7.29473755e-02f, 1.86738223e-02f, 1.41892694e-02f,
  -2.40629595e-02f, 2.21867431e-02f, -8.31886828e-02f, 1.93784363e-03f, 1.80510417e-01f, 8.78829788e-03f, -2.00263541e-02f, -5.30122332e-02f, -1.32896230e-01f, 6.27189353e-02f,
  -4.27295417e-01f, 2.40814388e-01f, -1.95806906e-01f, 4.73437011e-02f, -7.44533986e-02f, -5.13367727e-03f, -4.84275855e-02f, -4.26414758e-02f, -2.81642028e-03f, -1.31650642e-01f,
  -4.33312617e-02f, -2.77710594e-02f, -9.59169939e-02f, 9.53041688e-02f, 1.23546422e-02f, -2.22600289e-02f, 2.48531206e-03f, -9.21684727e-02f, 1.02045937e-02f, 1.83223430e-02f,
  8.17612633e-02f, 9.35912579e-02f, -1.63100481e-01f, 1.76284683e-03f, 3.81776355e-02f, -7.33934715e-02f, -1.87453687e-01f, -1.17695391e-01f, 4.51935083e-02f, -2.78892182e-02f,
  5.94735622e-01f, -4.14686173e-01f, -5.13717890e-01f, -1.19104668e-01f, -1.59593716e-01f, 1.56610832e-02f, -1.52536288e-01f, 3.29651721e-02f, 1.29153416e-01f, -2.00585574e-01f,
  -1.68371394e-01f, 1.14677083e-02f, -6.01748154e-02f, -1.86563551e-01f, -6.93900064e-02f, -3.90173376e-01f, -3.66268933e-01f, -5.55095673e-02f, 1.85688585e-01f, 1.95901319e-01f,
  -8.91485736e-02f, -3.21646482e-02f, 5.67439524e-03f, -5.39579391e-02f, -2.20749348e-01f, -3.80258970e-02f, -3.98180008e-01f, -2.31366202e-01f, -3.60891342e-01f, -3.60480905e-01f,
  -3.15641046e-01f, 9.57816988e-02f, 1.76864401e-01f, 1.19869309e-02f, -1.76990405e-01f, 1.30992651e-01f, -7.99844787e-03f, 1.44444061e-02f, 1.17396712e-01f, -1.02307200e-01f,
  1.75112544e-03f, 2.85665691e-02f, -5.64425662e-02f, -6.90262020e-02f, -2.75662839e-02f, 4.99854796e-02f, 8.24853554e-02f, 1.69418395e-01f, -8.39369595e-02f, -1.69116423e-01f,
  -8.66381750e-02f, 2.45502517e-02f, 1.96430668e-01f, 2.34068915e-01f, 1.96774974e-01f, 1.92165926e-01f, -1.01369925e-01f, 1.01228096e-01f, 5.32208718e-02f, 1.50404632e-01f,
  -1.16107859e-01f, -1.38110919e-02f, 6.24980517e-02f, 1.24706447e-01f, 2.64534384e-01f, 1.50053471e-01f, 1.09906018e-01f, 7.42274746e-02f, 8.01538154e-02f, 8.97834301e-02f,
  -3.04029249e-02f, 7.43499920e-02f, 4.51765470e-02f, -1.27143441e-02f, -1.59658775e-01f, -9.15881619e-02f, 5.46352528e-02f, 1.33834248e-02f, -4.12937067e-02f, -4.92500253e-02f,
  4.78207618e-02f, -6.54900074e-02f, -1.39537081e-01f, -1.61759287e-01f, -1.45989105e-01f, -3.06660589e-02f, -5.51006086e-02f, -1.14528351e-02f, -7.18929023e-02f, -3.29780318e-02f,
  -2.37324432e-01f, 2.00393006e-01f, 1.56659223e-02f, 1.03721753e-01f, -2.34060045e-02f, -8.32122266e-02f, -9.01196301e-02f, -2.87283659e-02f, -1.00885108e-01f, 8.71810392e-02f,
  -7.32500330e-02f, -5.12009161e-03f, -1.46108419e-01f, 5.27338982e-02f, 1.99406654e-01f, 1.19531728e-01f, 1.27960935e-01f, 1.44588307e-01f, -9.14482847e-02f, -1.82448566e-01f,
  -1.58503652e-01f, 2.60581106e-01f, 2.46911630e-01f, 1.26264855e-01f, 1.76248252e-01f, 2.32439801e-01f, 1.61228720e-02f, 1.50542855e-01f, 1.07887127e-01f, 2.64218420e-01f,
  3.20036411e-01f, -5.10578752e-01f, 2.45810688e-01f, 1.45219535e-01f, -3.13083921e-03f, 1.73967436e-01f, -4.30529080e-02f, 4.41564247e-02f, 1.21178562e-02f, -4.74767610e-02f,
  -3.08625251e-01f, -2.59255111e-01f, -1.81404307e-01f, -8.31707343e-02f, 1.05466865e-01f, 1.07842699e-01f, 2.88317144e-01f, 3.58935356e-01f, 3.26200783e-01f, -4.26489115e-02f,
  -2.40341872e-02f, 6.09777570e-02f, 8.68546739e-02f, 3.07325944e-02f, 6.01086114e-03f, 2.79909074e-02f, -1.37394601e-02f, -3.42707802e-03f, 1.16526438e-02f, 8.40338320e-02f,
  -1.91693380e-01f, -1.08623073e-01f, -1.14908732e-01f, -1.84756339e-01f, -1.30964532e-01f, -6.94781356e-03f, 7.49456361e-02f, 1.25793461e-02f, -9.41812769e-02f, 1.51008321e-02f,
  -8.52628350e-02f, -8.89520645e-02f, -8.61329287e-02f, 4.13034000e-02f, -2.98629533e-02f, -7.21793855e-03f, -1.21587953e-02f, 5.67390658e-02f, -3.32353674e-02f, -9.58944932e-02f,
  -5.49405478e-02f, 6.13060817e-02f, 1.15901761e-01f, 6.36382326e-02f, -6.33120313e-02f, -3.48714441e-02f, -2.85741743e-02f, -2.66440623e-02f, -2.66676992e-02f, -7.06617162e-02f,
  -1.04250669e-01f, 3.11150681e-02f, 5.70025817e-02f, 8.87918025e-02f, 8.45095217e-02f, 1.40617952e-01f, 1.61888391e-01f, 5.41156866e-02f, 1.73586920e-01f, 2.67710295e-02f,
  1.53370246e-01f, -1.80214667e-03f, -1.18450271e-02f, 5.13536595e-02f, 2.88881292e-03f, 2.11755745e-03f, 4.21004482e-02f, -1.10277772e-01f, 1.48435431e-02f, -2.11819578e-02f,
  3.06010968e-03f, 1.29176304e-01f, -5.24789505e-02f, 1.31154796e-02f, -1.89651977e-02f, 5.82531579e-02f, 9.49976146e-02f, -5.84737137e-02f, -9.59789306e-02f, 5.45995049e-02f,
  -6.10882193e-02f, -1.90612048e-01f, 7.97593296e-02f, -3.21701393e-02f, -2.49453001e-02f, -2.53110230e-02f, -6.15342408e-02f, -5.78886941e-02f, 6.73515946e-02f, 1.27071559e-01f,
  -2.27057617e-02f, -6.14746101e-02f, 6.22418113e-02f, 9.02442187e-02f, 1.27910331e-01f, 7.07141450e-03f, -1.87169045e-01f, 4.22533266e-02f, -3.53977643e-02f, -2.85509392e-03f,
  2.17783060e-02f, 1.17906705e-01f, 8.91596973e-02f, -9.73909907e-03f, -3.06501891e-02f, 7.92017058e-02f, 1.16353564e-01f, 2.12398320e-02f, 1.10516831e-01f, 1.08988129e-01f,
  -2.27361783e-01f, 8.29108208e-02f, 9.82883037e-04f, 1.47572175e-01f, 2.72772700e-01f, 1.43525377e-01f, 2.63104230e-01f, 2.02348843e-01f, 1.32317513e-01f, 8.31025615e-02f,
  1.58285484e-01f, 1.50157601e-01f, 1.83359802e-01f, 1.64404050e-01f, 2.02968687e-01f, 2.59246260e-01f, 2.70365506e-01f, 1.26379490e-01f, -9.61442478e-03f, 1.07806876e-01f,
  1.94415495e-01f, 5.00142388e-02f, -1.48246959e-01f, 4.43213433e-03f, 7.91205838e-02f, 2.00307965e-01f, 1.05349727e-01f, 2.67493296e-02f, 7.38209113e-02f, 9.35457572e-02f,
  -5.04334318e-03f, 6.45699585e-03f, 6.36814311e-02f, -9.39312801e-02f, -1.70326442e-01f, -2.20063075e-01f, 3.44898477e-02f, -8.09986815e-02f, -1.71952292e-01f, -1.22862637e-01f,
  -1.12819055e-03f, -1.39312968e-01f, 2.54874583e-02f, -1.38935596e-01f, -1.31888434e-01f, -1.23733893e-01f, 1.22286156e-02f, 1.55134097e-01f, 6.27903491e-02f, 7.00968951e-02f,
  6.74023256e-02f, 5.61253801e-02f, 1.17529728e-01f, 9.79176536e-02f, 1.00642510e-01f, -4.00907360e-02f, -1.54303415e-02f, 3.83328162e-02f, 2.13603675e-02f, 3.82597791e-03f,
  1.59781769e-01f, 1.37802720e-01f, 8.89518633e-02f, 1.30991593e-01f, 9.76439938e-02f, -1.89538337e-02f, 1.08956071e-02f, 5.13355061e-02f, 1.26957148e-01f, 6.66260570e-02f,
  -4.07308787e-02f, 2.23147824e-01f, 1.54861644e-01f, 8.94614160e-02f, 7.95244873e-02f, -3.79884019e-02f, 5.84526137e-02f, 8.31519589e-02f, -5.84137440e-02f, 9.79393348e-02f,
  4.72423732e-02f, -7.01164901e-02f, -2.75686324e-01f, -6.85202628e-02f, -7.47764111e-02f, 7.01878825e-03f, 4.06663120e-02f, 1.82153247e-02f, -1.60588682e-01f, -1.01472139e-01f,
  1.37777179e-01f, 1.37156084e-01f, 1.22852363e-01f, 1.06535904e-01f, 4.05380689e-03f, -2.35950172e-01f, 1.29927859e-01f, -7.54304081e-02f, -1.51297972e-01f, 4.07600738e-02f,
  1.72465108e-02f, -7.76824355e-02f, -4.94537801e-02f, -3.10670417e-02f, -2.37894095e-02f, -9.59553644e-02f, 1.55964484e-02f, 1.48281395e-01f, 1.11361511e-01f, -5.89274094e-02f,
  2.05777939e-02f, 1.70307811e-02f, 2.58460883e-02f, 5.09776324e-02f, 1.07550636e-01f, 7.81301558e-02f, -1.24346606e-01f, 3.25320143e-05f, -1.37341812e-01f, -7.70192370e-02f,
  -9.64860246e-02f, -5.40225863e-01f, 1.17569216e-01f, -4.66528609e-02f, 1.34343877e-01f, 1.65787891e-01f, 2.02206448e-01f, 8.69523138e-02f, -1.34920686e-01f, -1.09032080e-01f,
  -3.76561195e-01f, -2.30139837e-01f, -3.00623059e-01f, -1.90290511e-01f, -1.58689603e-01f, 2.71320622e-02f, 1.46793023e-01f, 1.00092135e-01f, 1.99944094e-01f, 1.78316444e-01f,
  1.22352667e-01f, 1.44980922e-01f, 4.20381948e-02f, -3.68581302e-02f, -2.02670306e-01f, -9.04765949e-02f, -1.09409511e-01f, -5.19000292e-02f, -2.60313243e-01f, -2.56599903e-01f,
  2.56174691e-02f, -4.03404742e-01f, 6.64114207e-02f, -2.38605693e-01f, -5.15589528e-02f, -1.79627374e-01f, 2.34666876e-02f, -2.41026878e-02f, -8.85850415e-02f, 1.06197141e-01f,
  -3.41043994e-02f, -9.78243425e-02f, -3.22832633e-03f, -9.78968590e-02f, 1.34141847e-01f, 6.44346559e-03f, -1.26223043e-01f, -1.56701878e-01f, -8.59456509e-02f, -1.34585783e-01f,
  -1.42374948e-01f, -1.11573383e-01f, 5.66102155e-02f, -5.42312977e-04f, -4.59060520e-02f, -2.61389986e-02f, -3.17526832e-02f, -1.82002410e-01f, -9.64717101e-03f, -8.12184885e-02f,
  3.10719371e-01f, 6.67933524e-02f, -2.14808419e-01f, -1.23225532e-01f, -2.14532409e-02f, 8.52799974e-03f, 1.34030446e-01f, -8.05821791e-02f, -1.64702043e-01f, -3.04151159e-02f,
  -2.19469983e-02f, -1.88188061e-01f, -8.48975182e-02f, 1.13086894e-01f, -1.67593628e-01f, -2.36997202e-01f, -1.36983261e-01f, -1.62424862e-01f, -1.87660441e-01f, -1.31664708e-01f,
  -8.05797353e-02f, -9.34259035e-03f, 1.07395067e-03f, -6.69636130e-02f, -1.59353778e-01f, -8.47998559e-02f, -8.04283842e-02f, -3.49107524e-03f, 7.37147406e-02f, -9.03332829e-02f,
  -9.10408124e-02f, -2.66027272e-01f, -6.07128032e-02f, -1.65699661e-01f, -6.69811890e-02f, -1.03563294e-01f, -2.08325043e-01f, -6.97520599e-02f, 7.98436552e-02f, 7.78115839e-02f,
  -1.37263432e-01f, 5.49636595e-02f, -8.98850486e-02f, -1.25420354e-02f, 2.71830410e-01f, 7.79379085e-02f, -9.20375884e-02f, 3.35328989e-02f, 6.71698079e-02f, 7.80786062e-03f,
  2.38320045e-02f, 2.18643308e-01f, 2.50651866e-01f, 1.31827042e-01f, 1.37817636e-01f, 1.91710889e-01f, 2.72867411e-01f, 1.18291728e-01f, 3.10678542e-01f, 4.42905903e-01f,
  -1.77565977e-01f, 4.35311258e-01f, 3.91232967e-01f, -1.23862572e-01f, 3.70547771e-01f, 3.92269939e-01f, 4.52276856e-01f, 2.56460965e-01f, -9.77827534e-02f, 3.02601725e-01f,
  5.06401002e-01f, -1.81480721e-01f, -6.78007826e-02f, -3.77683222e-01f, -4.62956101e-01f, -1.05108999e-01f, -3.20759594e-01f, -4.58520681e-01f, -4.07020420e-01f, -2.30847269e-01f,
  -2.52371162e-01f, -2.45010868e-01f, -3.88510287e-01f, -2.52901703e-01f, -1.20998316e-01f, -3.94052327e-01f, 2.47619241e-01f, 6.34945631e-02f, 1.03096794e-02f, -4.97260004e-01f,
  2.17012018e-02f, 4.69067484e-01f, -1.40847176e-01f, -8.23505297e-02f, 8.60912278e-02f, -1.49474040e-01f, -1.04944094e-03f, 1.16760060e-01f, 1.30385116e-01f, -1.33432552e-01f,
  1.08410008e-01f, 2.21482664e-02f, 8.52531940e-02f, 8.85450020e-02f, 6.29314408e-02f, 6.14004992e-02f, 2.32798919e-01f, -1.00525536e-01f, -4.55796048e-02f, 2.07073927e-01f,
  -8.98002759e-02f, 2.46590808e-01f, 3.63975704e-01f, 1.38202488e-01f, -1.82637349e-01f, -1.70657814e-01f, 1.04519226e-01f, 6.35152962e-03f, -1.58958638e-03f, -3.12275052e-01f,
  5.74835064e-03f, -1.86065268e-02f, -2.27261782e-02f, 2.64051985e-02f, -1.95034802e-01f, 1.45242652e-02f, -5.49289286e-02f, -2.51604859e-02f, -8.22612494e-02f, -6.42862245e-02f,
  1.05005518e-01f, 7.04048201e-02f, 5.22540286e-02f, 1.19133025e-01f, -2.13594273e-01f, 1.86037034e-01f, -1.22707682e-02f, 5.39450124e-02f, 8.43617395e-02f, -6.56309128e-02f,
  -5.98554611e-02f, 1.77020859e-02f, 7.84632415e-02f, -1.35466650e-01f, 3.00557353e-02f, -9.14965123e-02f, -9.40620825e-02f, -3.59784327e-02f, 6.34027719e-02f, 2.38592222e-01f,
  -3.23464423e-01f, 1.71697646e-01f, -2.11107597e-01f, -1.55942574e-01f, 8.51496086e-02f, 6.48424625e-02f, 1.17765427e-01f, 5.26075251e-02f, 1.29225552e-01f, -1.06304832e-01f,
  1.91525787e-01f, 3.59158777e-02f, 1.07285202e-01f, 1.82263199e-02f, -1.28974989e-01f, 3.88856493e-02f, 9.11068637e-03f, 5.21770120e-02f, -1.67467996e-01f, 1.72036052e-01f,
  -7.17271864e-02f, -3.05392355e-01f, -2.37900943e-01f, -1.37035206e-01f, -2.50156432e-01f, -3.53349119e-01f, -3.05979609e-01f, -2.18693838e-01f, -3.68129820e-01f, -4.72652048e-01f,
  -1.86322480e-02f, -3.59148473e-01f, 1.78613245e-01f, -7.32563511e-02f, -1.28484786e-01f, -4.73983623e-02f, -3.21532875e-01f, -1.96296215e-01f, -2.02436626e-01f, -1.50074556e-01f,
  1.98266748e-02f, 2.92446464e-01f, 3.73186439e-01f, 1.93457752e-01f, 1.54568672e-01f, -1.33475065e-01f, -9.25712287e-02f, 3.36513132e-01f, 3.31687093e-01f, -8.67352784e-02f,
  -2.50988156e-01f, -1.19548000e-01f, -1.32790431e-01f, -5.62099144e-02f, -2.05875143e-01f, 1.16521902e-01f, -1.20864704e-01f, -2.86627173e-01f, -2.18475118e-01f, -1.76067725e-01f,
  4.20998663e-01f, -1.62277073e-01f, 8.88194963e-02f, -1.42221406e-01f, -1.14387393e-01f, -4.16185148e-03f, 8.35336838e-03f, -1.02001205e-01f, -2.16374155e-02f, -4.71378118e-02f,
  3.43954237e-03f, -5.51648773e-02f, -2.32035387e-02f, 2.20648330e-02f, -6.54791370e-02f, 1.00212414e-02f, -7.44348541e-02f, -1.71106353e-01f, -7.03893825e-02f, -1.25778029e-02f,
  -3.99387516e-02f, -1.45222200e-02f, 3.22305560e-02f, 8.07927735e-03f, -7.38231614e-02f, 9.82391164e-02f, -5.87398633e-02f, 2.85462663e-02f, -6.07105494e-02f, -2.11834013e-01f,
  7.07970634e-02f, 8.80864486e-02f, -4.93970476e-02f, -2.52637211e-02f, 2.13754158e-02f, 2.70933807e-02f, 6.27307668e-02f, 1.45625584e-02f, -1.31683666e-02f, -1.06114363e-02f,
  7.41713075e-03f, 1.20733157e-02f, -9.73385349e-02f, -7.34069124e-02f, -8.19447786e-02f, 5.02797356e-03f, 1.35059869e-02f, 1.73569692e-03f, -1.07061028e-01f, -1.17253087e-01f,
  -1.01641612e-03f, -9.57636535e-02f, -1.12921232e-02f, -2.65770163e-02f, -2.81379689e-02f, 2.28960346e-02f, 1.48002841e-02f, 3.73570770e-02f, 9.58238617e-02f, -1.33924112e-01f,
  2.50688374e-01f, 9.30088609e-02f, 7.97307193e-02f, 1.65676270e-02f, -4.78366315e-02f, -1.37681261e-01f, 2.09292881e-02f, -8.12471136e-02f, -1.00137971e-01f, 8.39048007e-05f,
  -1.45567015e-01f, 5.85230999e-02f, 4.32927310e-02f, -3.07414643e-02f, 6.48882985e-02f, -2.95398869e-02f, -1.38620198e-01f, 2.92727887e-03f, -1.64436683e-01f, -7.74660334e-02f,
  -1.86846301e-01f, 4.74277623e-02f, 2.74201959e-01f, 1.29095152e-01f, 4.69384491e-02f, 2.99581259e-01f, 1.86193153e-01f, -3.91131677e-02f, 2.27720603e-01f, 1.17874615e-01f,
  1.33150190e-01f, 4.39955950e-01f, 1.86848834e-01f, -8.16952959e-02f, 3.97079229e-01f, 2.65869021e-01f, 3.07085454e-01f, -2.08891377e-01f, -3.00190330e-01f, 1.52296707e-01f,
  2.85864711e-01f, -6.93932548e-02f, -3.02316278e-01f, -2.76907474e-01f, -1.51522547e-01f, -2.81298533e-02f, -1.90080360e-01f, -2.59639591e-01f, -1.58826038e-01f, 2.50481218e-01f,
  1.74544342e-02f, -5.33115603e-02f, -1.09885760e-01f, -1.96314111e-01f, 7.58826137e-02f, -1.50441602e-01f, -4.40007895e-02f, 3.24136138e-01f, 3.49173307e-01f, 1.00587450e-01f,
  1.83651373e-01f, 2.98161566e-01f, -4.67086971e-01f, -7.41216354e-04f, 2.51761019e-01f, -2.31559142e-01f, -9.53995362e-02f, -6.27563968e-02f, 9.14959833e-02f, -1.85232714e-01f,
  2.48300672e-01f, 2.35110968e-01f, 1.06367096e-01f, -1.06724743e-02f, 1.34365156e-01f, -5.43860532e-02f, 1.64002227e-03f, -1.29500717e-01f, -2.19065890e-01f, 1.97090954e-01f,
  1.23670943e-01f, 3.91269624e-01f, 2.28691995e-01f, -1.47394165e-01f, -1.10522315e-01f, -1.37183413e-01f, 6.81030974e-02f, 1.13441691e-01f, -1.29475623e-01f, -7.60815218e-02f,
  -1.65298894e-01f, 1.30292431e-01f, 1.87982082e-01f, 7.35355366e-04f, -1.13420002e-01f, -4.27193642e-02f, -5.37712723e-02f, 8.27773362e-02f, 8.04965273e-02f, 6.70049638e-02f,
  -1.08465225e-01f, -7.94801041e-02f, 3.48703616e-04f, -1.36545748e-01f, -2.02899277e-01f, 5.27355410e-02f, 3.10918652e-02f, -1.00957118e-01f, -2.48042587e-02f, 2.34819576e-02f,
  -1.11896815e-02f, 4.05444242e-02f, -4.46791127e-02f, -1.00426674e-01f, -1.07121587e-01f, -1.06553935e-01f, -2.23362699e-01f, -9.80370641e-02f, -1.02501519e-01f, -3.77444737e-02f,
  -2.98572242e-01f, -5.50354794e-02f, -1.68566674e-01f, -9.15543810e-02f, 1.32738769e-01f, 1.36575717e-02f, -1.08334877e-01f, -1.06657185e-01f, 1.52101025e-01f, -2.14440644e-01f,
  6.30868971e-02f, -6.21815212e-02f, -5.83996065e-02f, -1.19985200e-01f, -1.53450947e-02f, 2.91267317e-02f, 1.75895784e-02f, -7.96431005e-02f, -3.83870825e-02f, 1.63906470e-01f,
  -1.23392589e-01f, -1.89353824e-01f, -3.00973952e-01f, -3.10841024e-01f, -3.17110837e-01f, -5.77196062e-01f, -2.51555979e-01f, -1.13491483e-01f, -1.63331062e-01f, -3.35246354e-01f,
  -6.85759187e-01f, 8.68971646e-02f, -3.35747689e-01f, -4.84259039e-01f, 5.74791320e-02f, 2.03256279e-01f, 3.61027420e-01f, 6.04567975e-02f, -2.24407941e-01f, 3.96360569e-02f,
  2.59270091e-02f, 8.11534934e-03f, 3.98941785e-02f, 1.60125002e-01f, 1.65074021e-01f, 2.06964523e-01f, 2.07147211e-01f, -3.65361534e-02f, 5.49473055e-02f, 3.33151698e-01f,
  3.59477431e-01f, -2.55487502e-01f, -3.96730006e-01f, -5.75681701e-02f, 4.99862880e-02f, 9.50899869e-02f, -9.26728994e-02f, -2.16008630e-02f, 2.22138390e-01f, 3.37271422e-01f,
  7.08347857e-02f, -2.19293624e-01f, 7.69842565e-02f, 1.23380963e-02f, -8.89119506e-02f, -1.31880492e-01f, -5.76797538e-02f, -3.38548332e-01f, -8.98508448e-03f, -2.73458928e-01f,
  -1.15767280e-02f, -9.36959535e-02f, 1.03239261e-01f, 1.75174668e-01f, -1.46083355e-01f, 3.72640863e-02f, -1.31072909e-01f, -1.72481537e-01f, -3.44790697e-01f, -2.77732103e-03f,
  5.18847466e-01f, 1.99599247e-02f, -2.69748718e-01f, 1.35371700e-01f, -7.36208037e-02f, -5.93601801e-02f, -6.03013970e-02f, 4.94468249e-02f, -3.05126846e-01f, -2.07127303e-01f,
  -4.81591187e-02f, 1.76906902e-02f, -2.73368359e-02f, 7.69579634e-02f, 1.35007247e-01f, 3.48286219e-02f, 1.97086763e-02f, 1.89753175e-01f, 2.88225291e-03f, -3.91281396e-02f,
  -2.63479501e-02f, 1.51363732e-02f, -4.89421829e-04f, 2.34045237e-02f, 3.26740108e-02f, -8.59662443e-02f, 1.93597928e-01f, -6.37633204e-02f, 4.82123308e-02f, -1.66791722e-01f,
  -4.86347312e-03f, 1.20838126e-02f, -1.20282881e-01f, 2.23011494e-01f, 8.06242302e-02f, 4.53533009e-02f, 1.75480712e-02f, 1.22100199e-02f, 1.61652025e-02f, -2.09124014e-02f,
  -3.04881245e-01f, -1.83150202e-01f, -1.05908290e-02f, -1.48166299e-01f, -1.64654240e-01f, 1.27528803e-02f, -1.17440060e-01f, -1.75223053e-02f, -7.96709582e-03f, -7.23125339e-02f,
  4.56279851e-02f, -1.03700981e-01f, -1.66283861e-01f, 1.48810223e-01f, -4.06252891e-02f, -5.56743145e-02f, 5.57913110e-02f, 8.87431577e-02f, 8.94080102e-02f, 1.32917747e-01f,
  3.06719579e-02f, 1.85659733e-02f, -1.48860604e-01f, 1.69601932e-01f, 7.79675990e-02f, -4.20656428e-02f, 6.48025796e-02f, 1.02447636e-01f, -1.96151391e-01f, -1.83560088e-01f,
  5.07175028e-01f, 2.63467580e-01f, -3.76228690e-02f, 3.03389519e-01f, 1.02471747e-01f, 1.83975086e-01f, 3.66666675e-01f, 3.66744369e-01f, 2.69221365e-01f, 2.49615192e-01f,
  -2.81171761e-02f, -1.02899075e-01f, -1.30788490e-01f, -1.41770706e-01f, -8.77744984e-04f, 1.43030286e-01f, 1.11454740e-01f, -6.65115565e-02f, -1.66607857e-01f, -9.55445990e-02f,
  -2.79680006e-02f, 2.23968491e-01f, 1.31741628e-01f, -6.53925464e-02f, -5.27731739e-02f, -4.75171320e-02f, -1.44675942e-02f, -2.80841552e-02f, -2.00461432e-01f, -1.47750825e-01f,
  -4.27854657e-01f, -1.22578442e-01f, -1.88143671e-01f, -2.81129070e-02f, -3.20136435e-02f, 8.20039660e-02f, 4.51479256e-02f, -3.00093200e-02f, 1.32615045e-01f, 1.08260691e-01f,
  -5.53317331e-02f, 2.68716160e-02f, -6.60533411e-03f, -7.00042173e-02f, 1.03432000e-01f, 4.49444354e-02f, -6.10746183e-02f, 4.67209145e-02f, -8.54562670e-02f, -1.37146488e-01f,
  -4.69667539e-02f, 1.08921584e-02f, 4.62338924e-02f, -3.88726592e-02f, -9.51536447e-02f, -1.07526347e-01f, -8.86210650e-02f, -8.90791193e-02f, -7.66470060e-02f, 8.77871290e-02f,
  -2.10698023e-01f, 8.79900753e-02f, -2.19378658e-02f, -9.58630536e-03f, 7.51846191e-03f, -4.05844003e-02f, -4.45285402e-02f, 6.46933839e-02f, 2.16087401e-02f, 3.14684287e-02f,
  -3.31425965e-02f, -4.39476967e-02f, -1.10050410e-01f, 3.40875126e-02f, -5.78086637e-02f, -3.00110644e-03f, -5.77879585e-02f, -9.30213630e-02f, -1.39054269e-01f, -9.13939700e-02f,
  -6.85787275e-02f, 5.95095120e-02f, -1.15358941e-02f, -3.71428840e-02f, -7.46014044e-02f, -2.52281800e-02f, -6.66565523e-02f, -1.18504509e-01f, 2.06088740e-02f, 1.67970911e-01f,
  -2.89478600e-02f, -3.36759120e-01f, -1.49211198e-01f, -1.38098553e-01f, 3.74653600e-02f, 2.44948249e-02f, -1.77137047e-01f, -7.26254061e-02f, 2.13227049e-02f, 5.60865784e-03f,
  -5.80562949e-02f, -3.47307487e-03f, 3.90715897e-02f, -5.84827065e-02f, 8.66077989e-02f, -7.12164417e-02f, -2.80058850e-02f, -6.45424128e-02f, -7.11217895e-02f, 4.13408056e-02f,
  -1.79009754e-02f, 1.49957612e-01f, 1.40675411e-01f, 1.30827248e-01f, 4.30932678e-02f, -4.34622318e-02f, -3.29522081e-02f, 7.32623637e-02f, -5.18993922e-02f, 3.35061550e-01f,
  -4.19460386e-01f, 7.56167024e-02f, -3.24884146e-01f, -3.31781715e-01f, -1.77876756e-01f, 1.08539231e-01f, 1.72410622e-01f, 1.55619964e-01f, 2.02243906e-02f, -2.49167681e-02f,
  -1.05450772e-01f, -3.16021234e-01f, -2.93389112e-01f, -1.72121957e-01f, -2.41943628e-01f, -6.77421615e-02f, -3.02595317e-01f, -3.71570736e-01f, -2.49469951e-01f, 8.53000581e-02f,
  2.96996292e-02f, -3.06463718e-01f, -2.54246533e-01f, -2.04610363e-01f, -2.10048765e-01f, -3.35993916e-01f, -3.75747055e-01f, -3.13901871e-01f, -1.39171883e-01f, -2.57448018e-01f,
  -3.56701255e-01f, -1.33356348e-01f, 5.16204722e-02f, 2.79171951e-02f, 2.37284042e-02f, 1.95315272e-01f, -2.13544797e-02f, 4.80053611e-02f, 1.37445599e-01f, 1.84064955e-01f,
  -9.33874995e-02f, 7.29202032e-02f, -4.27096598e-02f, -1.47367418e-02f, -2.44757421e-02f, 1.13767348e-01f, 8.25600326e-02f, 7.72345588e-02f, 5.83819263e-02f, 2.89288640e-01f,
  2.57073730e-01f, 2.47376002e-02f, 1.00444285e-02f, 1.67193323e-01f, 2.57130444e-01f, -1.10059723e-01f, 8.31348971e-02f, 1.13479272e-01f, 6.01459928e-02f, 6.24314174e-02f,
  1.04625396e-01f, -8.34508892e-03f, 1.21426716e-01f, -6.14167228e-02f, 3.79076488e-02f, 3.86866275e-03f, -5.08702137e-02f, -2.13173497e-03f, -7.33011588e-02f, 6.88477978e-02f,
  8.58386233e-02f, 1.14486143e-01f, 5.17713279e-02f, -5.83812930e-02f, -8.59059691e-02f, -8.48137215e-02f, -5.83000705e-02f, 6.89949095e-02f, 7.27667138e-02f, -2.70900745e-02f,
  -5.49025349e-02f, 6.17642179e-02f, -1.00863993e-01f, 4.58965227e-02f, 1.37119159e-01f, 1.07522801e-01f, 8.08788522e-04f, 3.11174281e-02f, -3.18765920e-03f, 9.39055812e-03f,
  -2.20463827e-01f, -9.63350311e-02f, -1.48256600e-01f, 1.00563830e-02f, -8.16460326e-02f, 2.33489260e-01f, -9.84314978e-02f, 1.41471326e-01f, 7.06218183e-02f, 1.35345131e-01f,
  5.88856861e-02f, 4.58367728e-03f, -1.23017557e-01f, 1.81782506e-02f, -7.12979361e-02f, -2.27070693e-02f, 1.63074657e-01f, -1.68239444e-01f, 1.16078071e-01f, 1.67459011e-01f,
  2.21646339e-01f, 1.50548145e-01f, -2.66513042e-02f, 4.02660854e-02f, 1.47299379e-01f, -1.23853825e-01f, -1.09321289e-01f, 1.15283892e-01f, -9.88725722e-02f, 6.73322054e-03f,
  3.15313011e-01f, 3.50109577e-01f, 3.74222040e-01f, 1.27814546e-01f, 2.36521643e-02f, -3.58571291e-01f, -4.18571621e-01f, -2.07771912e-01f, -4.11756486e-02f, 1.24669574e-01f,
  4.90302965e-02f, -1.41174406e-01f, 4.61761020e-02f, -1.96537778e-01f, -2.74577916e-01f, -6.27625883e-02f, 1.31045908e-01f, -1.00993127e-01f, -5.01021862e-01f, -5.35013080e-01f,
  -1.44761607e-01f, 3.41156833e-02f, -1.34245560e-01f, -1.02018036e-01f, 3.27340215e-01f, -4.98288535e-02f, 1.97529718e-01f, 1.66184038e-01f, 7.26097971e-02f, 3.98244739e-01f,
  3.79716873e-01f, 3.01592559e-01f, -3.95979047e-01f, -1.66184325e-02f, 2.40245149e-01f, 1.52144758e-02f, 3.04899141e-02f, 2.34675601e-01f, 4.12949696e-02f, 1.90742522e-01f,
  1.66453287e-01f, 1.20843910e-01f, 6.90831393e-02f, 7.32274577e-02f, 4.17458154e-02f, -1.36068324e-02f, 7.63956308e-02f, -9.94939357e-02f, 2.65045911e-02f, 1.20032847e-01f,
  -4.03130706e-03f, 8.84964839e-02f, 1.15742229e-01f, -2.21186548e-01f, -1.40854465e-02f, -1.28197614e-02f, -3.60395536e-02f, -1.38137303e-02f, -2.17552602e-01f, 1.59985229e-01f,
  -1.41823575e-01f, 6.49196208e-02f, 1.01505280e-01f, 6.86198771e-02f, 9.55646858e-03f, 1.31091714e-01f, 1.41745314e-01f, 1.15391333e-03f, 4.67788661e-03f, 5.93226179e-02f,
  4.18609940e-02f, 2.17478164e-02f, 2.67089885e-02f, 1.48675293e-01f, 1.28327712e-01f, 1.24194153e-01f, 1.21941172e-01f, -1.30488118e-02f, 1.86723247e-01f, -5.08625573e-03f,
  1.46442698e-02f, 1.50767550e-01f, 2.08774939e-01f, -1.28164873e-01f, 6.30791411e-02f, 2.71850321e-02f, 6.84015676e-02f, -3.25433016e-02f, 1.27488881e-01f, 1.62460148e-01f,
  -2.17149422e-01f, -4.68479216e-01f, 1.33353561e-01f, -6.10796809e-02f, 4.29128855e-02f, -5.22303209e-02f, 1.37547702e-01f, -5.49492650e-02f, 1.66679680e-01f, -4.29430865e-02f,
  -1.37449250e-01f, -2.86294799e-03f, 1.18849486e-01f, -9.26128551e-02f, -1.76980600e-01f, -9.36620310e-03f, -4.18568887e-02f, 1.53150212e-03f, -1.60740227e-01f, 2.08396971e-01f,
  -5.77147491e-02f, -4.04376894e-01f, -2.45270103e-01f, -2.24247411e-01f, -1.05385534e-01f, -2.69667655e-01f, -1.38151363e-01f, -3.28935713e-01f, -3.61256480e-01f, -3.54834229e-01f,
  -4.72090155e-01f, -8.40435624e-01f, 7.71565974e-01f, 2.52604157e-01f, 3.57991010e-01f, -3.56889486e-01f, -7.09174573e-01f, -5.21237612e-01f, -3.35455015e-02f, -1.37154251e-01f,
  -1.17311165e-01f, -1.22679463e-02f, 5.49446978e-02f, -5.92864603e-02f, -2.27336124e-01f, 6.23671524e-02f, 3.31122965e-01f, 5.15857100e-01f, 4.31283385e-01f, -9.35295969e-02f,
  -1.64571822e-01f, 1.93758264e-01f, 3.53038162e-01f, 6.02437295e-02f, -6.50819838e-02f, 1.43687113e-03f, 2.61166364e-01f, 1.75704479e-01f, -1.14458479e-01f, 1.78919196e-01f,
  2.02961653e-01f, -4.47088271e-01f, 2.93971092e-01f, 4.55620736e-02f, 1.94142163e-01f, -1.67199031e-01f, -1.26854718e-01f, 1.42550245e-01f, -3.75384558e-03f, -1.11269735e-01f,
  1.96633160e-01f, -1.24256581e-01f, -1.14351800e-02f, -9.50836316e-02f, -1.39158905e-01f, -1.94199875e-01f, 9.70226824e-02f, 9.54788849e-02f, -1.12180924e-02f, -1.44354001e-01f,
  -1.03109643e-01f, 1.29970580e-01f, 1.97640970e-01f, -2.19323575e-01f, -3.31643313e-01f, 1.04728296e-01f, -1.77211881e-01f, -1.98049560e-01f, -1.51788875e-01f, -2.02607423e-01f,
  -4.65762168e-02f, 1.43305600e-01f, 7.51011670e-02f, -4.12304141e-02f, -1.32426679e-01f, -3.70093845e-02f, -6.49523512e-02f, -4.19271812e-02f, 1.28988683e-01f, 7.46021420e-02f,
  -8.75946656e-02f, 9.95277092e-02f, 1.58358634e-01f, -3.50858681e-02f, -4.28783633e-02f, -5.73159643e-02f, 5.15215509e-02f, 1.69490173e-03f, 1.76348716e-01f, 2.30327286e-02f,
  1.57905281e-01f, -3.66380205e-03f, 1.45014465e-01f, -1.48048952e-01f, -1.54816985e-01f, 3.64946686e-02f, 5.71975810e-03f, -6.88382834e-02f, -4.72011380e-02f, -1.06914982e-01f,
  -8.55890065e-02f, 2.97109365e-01f, 7.63759091e-02f, -3.67426984e-02f, -2.22525410e-02f, -3.71306241e-02f, 2.52168104e-02f, 8.18891600e-02f, -1.60725527e-02f, -1.35702968e-01f,
  -1.44164190e-01f, -2.37964183e-01f, -5.67175448e-02f, 3.89111266e-02f, 1.35441320e-02f, 8.05907100e-02f, 1.19714282e-01f, 2.28486881e-01f, 1.35284379e-01f, 2.22831331e-02f,
  4.07661535e-02f, 1.38412103e-01f, 5.95526546e-02f, -8.02227259e-02f, -2.00085893e-01f, -9.28495750e-02f, -6.94191381e-02f, -2.16922220e-02f, 1.29241180e-02f, -3.27138662e-01f,
  -3.27325821e-01f, 4.13622372e-02f, 3.18187803e-01f, -1.15478240e-01f, -2.18243465e-01f, -4.46910977e-01f, -5.31592727e-01f, -5.56779146e-01f, -4.32831407e-01f, -5.24459071e-02f,
  2.77069330e-01f, 3.94238532e-01f, 2.45807901e-01f, 5.61730824e-02f, -9.78390649e-02f, -2.53866524e-01f, -1.62986532e-01f, -1.13730766e-01f, -4.02800620e-01f, -5.40499330e-01f,
  -3.15059900e-01f, -3.55731785e-01f, -2.02065617e-01f, -3.36509436e-01f, -4.09991704e-02f, 1.09956913e-01f, 1.94552898e-01f, -5.96193001e-02f, 9.08525661e-02f, 1.20314464e-01f,
  2.50566483e-01f, 1.56247895e-02f, -1.63505554e-01f, -1.22948721e-01f, -4.87834625e-02f, 4.13681455e-02f, 5.61387241e-02f, -8.39392468e-03f, -8.14267807e-03f, -9.74798501e-02f,
  -1.96575578e-02f, -3.72554432e-03f, 1.12092998e-02f, -2.70008333e-02f, -2.84605175e-01f, -1.13716230e-01f, -2.09649026e-01f, -1.71765551e-01f, -1.12955809e-01f, -1.79563258e-02f,
  6.60078153e-02f, 7.93167204e-02f, 1.43956900e-01f, -7.70787150e-02f, -1.26950126e-02f, 6.52476475e-02f, 9.19597223e-02f, -4.67706956e-02f, 5.55717126e-02f, 1.15975372e-01f,
  -2.23123759e-01f, -2.19164327e-01f, -1.41159207e-01f, -9.13910102e-03f, -1.88271224e-01f, -1.57288998e-01f, -1.23501591e-01f, -4.11371402e-02f, -1.56335935e-01f, -9.59925726e-02f,
  6.21623918e-03f, 1.44531965e-01f, -1.18768007e-01f, -1.44061759e-01f, -7.88263753e-02f, -9.19015482e-02f, -1.73309296e-01f, -1.86263934e-01f, -5.41722141e-02f, -8.00655857e-02f,
  -3.48560587e-02f, -1.52268723e-01f, -1.36130443e-02f, -6.26229569e-02f, -1.22742184e-01f, -1.13715060e-01f, 3.15727107e-02f, 6.54896349e-02f, -9.28964689e-02f, -7.64464587e-02f,
  2.29134396e-01f, 2.09569231e-01f, 2.57799570e-02f, -1.64023861e-01f, 5.59583977e-02f, 1.69447333e-01f, 2.19060153e-01f, 1.04527906e-01f, 2.38501187e-02f, 1.65466610e-02f,
  3.62828188e-02f, 8.29699785e-02f, -6.17051050e-02f, -8.97689024e-05f, -1.08777344e-01f, 2.62946468e-02f, -6.67577311e-02f, -5.80674484e-02f, -4.35719118e-02f, -9.51946601e-02f,
  -7.45404586e-02f, -1.55331925e-01f, 8.73634368e-02f, 9.83766466e-02f, -2.90822256e-02f, 1.03457265e-01f, 1.10010013e-01f, -1.10037299e-02f, 1.01291731e-01f, -8.23655501e-02f,
  2.66980588e-01f, -6.13948226e-01f, -8.29893649e-01f, 6.13859892e-01f, 3.65090042e-01f, -2.47063488e-01f, -6.29472792e-01f, -1.10941261e-01f, 3.93609285e-01f, -7.23888651e-02f,
  2.00974464e-01f, 7.37203717e-01f, 3.57131541e-01f, 1.46361709e-01f, -1.52822450e-01f, -3.01843107e-01f, -6.93488196e-02f, -2.04754069e-01f, 3.51699516e-02f, 2.09795773e-01f,
  3.95008385e-01f, 3.27414691e-01f, 6.60280064e-02f, 4.60062437e-02f, 6.96646124e-02f, 3.21118623e-01f, -2.24865705e-01f, 7.25730881e-02f, -3.40052873e-01f, -2.78221965e-02f,
  -3.36151570e-01f, -5.99560916e-01f, -6.18180968e-02f, 4.71455723e-01f, 1.13986097e-01f, -2.30207086e-01f, -2.79120326e-01f, -4.23428625e-01f, -1.87549405e-02f, -4.24250245e-01f,
  3.63989621e-01f, -1.88661497e-02f, 2.56308645e-01f, -3.63258868e-02f, -1.52632147e-01f, -2.73334175e-01f, -2.98511326e-01f, -4.70728427e-01f, -2.97023773e-01f, -4.46919382e-01f,
  2.39522561e-01f, 1.60695627e-01f, -3.92696232e-01f, -3.41444194e-01f, -5.09125412e-01f, 4.42044772e-02f, -4.74466085e-01f, -3.52005064e-01f, -4.55926359e-01f, -5.63629627e-01f,
  5.85112087e-02f, 9.29539278e-02f, 8.63891840e-02f, -2.15047628e-01f, 1.55754223e-01f, -1.97342690e-02f, -3.21259797e-02f, -7.71086663e-02f, 2.63818465e-02f, -6.50617257e-02f,
  3.29146981e-02f, 1.76558066e-02f, -9.44204777e-02f, -1.28859818e-01f, 1.68842480e-01f, 6.08845390e-02f, 8.51770956e-03f, -3.87455299e-02f, 6.41074181e-02f, 8.53978246e-02f,
  3.85289416e-02f, 4.51720841e-02f, 7.23551437e-02f, -9.58093849e-04f, -1.57749861e-01f, 5.52284531e-02f, 1.14377320e-01f, 1.76692139e-02f, 2.05210268e-01f, -6.42224774e-02f,
  3.77389014e-01f, -2.45879143e-02f, -2.52990484e-01f, -6.46865070e-02f, -3.51214223e-02f, -2.91612074e-02f, 1.12927668e-02f, -1.64206997e-01f, -1.37016829e-02f, -1.39905483e-01f,
  -2.07245082e-01f, -5.68924285e-02f, -1.16785258e-01f, -1.34701198e-02f, -7.23633170e-03f, 1.21362042e-02f, 1.31320372e-01f, 5.72811961e-02f, 2.97967512e-02f, -1.52997330e-01f,
  1.05502456e-01f, -1.58186704e-02f, 1.59248322e-01f, -1.61771312e-01f, -6.77437112e-02f, 3.49103421e-01f, -2.46774673e-01f, -3.05073619e-01f, -2.48959869e-01f, -1.97111696e-01f,
  -8.55319560e-01f, 2.88062215e-01f, 2.80525953e-01f, -5.46539485e-01f, -1.77118972e-01f, 2.41151631e-01f, 5.36562443e-01f, -1.88896395e-02f, -3.37490231e-01f, 1.23427093e-01f,
  2.69241989e-01f, -6.14912249e-02f, -5.34810014e-02f, 9.20275450e-02f, 2.08197162e-01f, 3.70412529e-01f, 8.63232613e-02f, -6.00274540e-02f, -3.25347558e-02f, 8.86258110e-02f,
  1.16413698e-01f, -1.80148751e-01f, -3.01902890e-01f, -1.03092961e-01f, -1.56437278e-01f, -1.20697655e-01f, 1.05165549e-01f, -5.85000664e-02f, 3.14891249e-01f, 7.97575116e-02f,
  5.28410375e-01f, -8.58944282e-02f, -8.58858451e-02f, -1.32730365e-01f, -1.51445251e-02f, -1.62966654e-01f, -2.59428304e-02f, -1.70430288e-01f, -1.52443424e-01f, -7.08799735e-02f,
  -6.11680225e-02f, -1.06709518e-01f, 1.19456295e-02f, -3.63402963e-02f, -1.38211861e-01f, -2.40150448e-02f, -1.03003770e-01f, 6.75291494e-02f, 1.74956918e-01f, 2.12343991e-01f,
  2.76976060e-02f, 6.47744536e-02f, 1.23761043e-01f, 6.98893815e-02f, 5.24782129e-02f, -4.81150746e-02f, 1.69838518e-01f, -8.92995372e-02f, 3.76319440e-05f, -5.55121526e-02f,
  -1.12147279e-01f, 5.40066091e-03f, -2.66221706e-02f, -2.58406661e-02f, -3.75662260e-02f, -9.38554555e-02f, -5.47497571e-02f, 5.50583266e-02f, -3.06354370e-02f, -1.73747968e-02f,
  -4.53860275e-02f, 9.62639749e-02f, 7.63779655e-02f, 1.86850857e-02f, -1.20671749e-01f, 2.55910624e-02f, -3.18824872e-02f, 1.23003520e-01f, -3.90496105e-03f, 1.81241613e-02f,
  -4.82671484e-02f, -1.33706722e-02f, -3.94215845e-02f, 1.35575682e-02f, 6.60067052e-02f, -1.01553418e-01f, -3.43974531e-02f, -1.75925773e-02f, -1.99355241e-02f, -4.34053577e-02f,
  1.96954191e-01f, 2.86117494e-01f, 3.89652923e-02f, -7.51917902e-03f, -1.18636638e-02f, -1.31024048e-01f, -1.35805048e-02f, -5.64702973e-02f, -5.04963472e-02f, 9.12980139e-02f,
  5.19594103e-02f, -5.17939664e-02f, 1.43456804e-02f, 4.52497862e-02f, -5.54105341e-02f, -6.91363662e-02f, 2.14207228e-02f, -9.59245116e-02f, 3.27074826e-02f, 3.19057591e-02f,
  7.41419867e-02f, -1.27162114e-02f, 6.21146383e-03f, 3.64498585e-03f, 3.75659503e-02f, -7.16894343e-02f, 2.07469180e-01f, 9.26910117e-02f, 3.65454219e-02f, 6.69490322e-02f,
  3.86329859e-01f, -5.75957716e-01f, 5.24048865e-01f, -1.64445098e-02f, -2.57113904e-01f, -1.39444962e-01f, -2.72523016e-01f, 1.42316185e-02f, -3.34995538e-02f, -2.70261168e-01f,
  -6.62264228e-01f, -4.16644841e-01f, -2.75027364e-01f, -1.02037966e-01f, -2.73201242e-02f, 1.88040376e-01f, 2.30399176e-01f, 5.74670076e-01f, 3.80546361e-01f, -5.27073406e-02f,
  -2.75976360e-01f, 9.89521965e-02f, 3.31056893e-01f, 2.13448018e-01f, -1.07875779e-01f, -3.15294601e-02f, 2.44622175e-02f, -1.92523569e-01f, -1.25237525e-01f, 7.84811378e-02f,
  -2.30234694e-02f, -1.30918637e-01f, 6.50426075e-02f, -8.55765492e-02f, -9.26549435e-02f, 3.34197991e-02f, 2.86411121e-02f, 1.37476353e-02f, -1.29578993e-01f, 1.26216263e-02f,
  -1.53931901e-01f, -1.25705272e-01f, -1.51737794e-01f, -1.31249741e-01f, 9.56272520e-03f, 6.31711483e-02f, -2.94032693e-02f, -1.50994165e-02f, -4.55776528e-02f, -1.12920262e-01f,
  -2.71167248e-01f, -6.59458861e-02f, 1.26680909e-02f, -1.17831990e-01f, -4.36186902e-02f, -4.01229858e-02f, -1.18078843e-01f, -4.80361879e-02f, 2.75380220e-02f, 5.31766117e-02f,
  2.44022518e-01f, 4.43177894e-02f, -4.12230492e-02f, -8.74314532e-02f, -9.88420621e-02f, -8.59371722e-02f, -1.57884359e-02f, -1.03972919e-01f, -2.12916341e-02f, 2.76119672e-02f,
  -1.67860702e-01f, 6.53258152e-03f, -1.91252083e-02f, -6.09654561e-02f, -8.52541253e-02f, 2.45315917e-02f, -7.94519782e-02f, 8.03303160e-03f, -8.67225081e-02f, -1.47940114e-01f,
  -6.32340610e-02f, -6.66509271e-02f, -1.55481547e-01f, -8.89866948e-02f, -3.26131023e-02f, -5.97535893e-02f, -5.14359623e-02f, -3.23109813e-02f, 7.69792050e-02f, -1.63729623e-01f,
  -2.65935034e-01f, -8.03190768e-02f, 9.00260732e-02f, 7.21796528e-02f, 2.80826353e-02f, -3.76894474e-02f, -2.76444340e-03f, -7.87282139e-02f, -1.37579411e-01f, 1.39895827e-01f,
  9.98347178e-02f, 5.67783192e-02f, 3.61593477e-02f, 2.77161095e-02f, 3.90594080e-02f, 3.68612260e-02f, -1.20965227e-01f, -7.02627897e-02f, 6.23095930e-02f, -8.28488544e-02f,
  -3.68423313e-02f, 1.85617238e-01f, 1.03173062e-01f, 2.60655750e-02f, -3.44371982e-02f, 1.16692528e-01f, 1.51526025e-02f, 1.46275669e-01f, 1.44646972e-01f, 1.41424865e-01f,
  8.30082893e-01f, 3.29191417e-01f, 1.25722826e-01f, -8.13182816e-03f, -2.80176159e-02f, 1.31142840e-01f, 3.55856329e-01f, 3.57508779e-01f, -5.01395203e-02f, 1.69425726e-01f,
  2.39045978e-01f, -2.88874202e-04f, 8.66841823e-02f, 7.74064735e-02f, 1.18084684e-01f, 1.17152274e-01f, -9.60127115e-02f, -9.10779312e-02f, -4.67589572e-02f, -2.83006076e-02f,
  -1.83812395e-01f, -4.53770161e-02f, 1.09992318e-01f, -7.54420040e-03f, 8.99209380e-02f, -1.28003582e-01f, 2.32904940e-03f, 7.85463676e-02f, 6.56699836e-02f, -1.46652341e-01f,
  1.30634084e-02f, 2.88411021e-01f, -3.25259626e-01f, -1.89754039e-01f, 2.72964109e-02f, 4.76029925e-02f, -2.52504051e-02f, -2.48066299e-02f, -6.35981485e-02f, -4.99253385e-02f,
  -6.98922202e-02f, -8.04934502e-02f, 5.42797558e-02f, 7.70812929e-02f, 9.02530700e-02f, -4.73884456e-02f, -2.15276424e-02f, 1.59099311e-01f, 6.32905141e-02f, 8.59942511e-02f,
  -2.18827054e-02f, -7.12082237e-02f, 9.69883949e-02f, 6.09372891e-02f, -1.22993663e-02f, -7.77084678e-02f, 1.04263134e-01f, 9.83025879e-02f, 1.21070430e-01f, 1.66714102e-01f,
  2.78426148e-02f, 1.25983313e-01f, 5.92666380e-02f, 9.59467813e-02f, 1.40197501e-01f, 1.71171337e-01f, 7.15164095e-02f, -4.97431308e-02f, 1.15331985e-01f, 2.02092770e-02f,
  -7.49521554e-02f, 3.85565422e-02f, 1.49841025e-01f, 8.15365836e-02f, -1.33457333e-01f, 7.13681653e-02f, 4.19949889e-02f, 1.65244222e-01f, 3.24079469e-02f, 1.65971369e-02f,
  -3.49295810e-02f, 6.66378289e-02f, 3.04242298e-02f, 3.96159030e-02f, 5.24807833e-02f, 4.91399355e-02f, -3.68795852e-04f, 3.04652322e-02f, 7.19040446e-03f, 8.93214494e-02f,
  -2.18705982e-01f, 1.42739594e-01f, 2.49712598e-02f, -5.22198565e-02f, 9.65448935e-03f, -1.14879303e-01f, -5.13877310e-02f, -1.47001997e-01f, -1.51853502e-01f, 4.44024839e-02f,
  -1.97170526e-02f, 9.67482179e-02f, 1.23392448e-01f, 1.24747515e-01f, -4.48695458e-02f, -4.56896797e-02f, 1.38670271e-02f, -8.36642459e-02f, -3.77610624e-02f, -1.21703535e-01f,
  -1.17416501e-01f, -1.13820419e-01f, -1.46018878e-01f, -1.30516365e-01f, -7.72394091e-02f, -1.66254908e-01f, 3.29702087e-02f, -1.15139470e-01f, 4.25064750e-02f, 4.23186123e-02f,
  3.68051052e-01f, 7.86166042e-02f, -6.85643256e-02f, 3.06362271e-01f, 3.78773920e-02f, -3.62817347e-01f, -3.50422531e-01f, -2.90857673e-01f, 1.31940126e-01f, 2.36058265e-01f,
  -1.94759276e-02f, -3.58138770e-01f, -5.37213609e-02f, -1.64903924e-01f, -4.51446027e-01f, 7.55576268e-02f, 1.21531039e-01f, -2.64185816e-01f, -7.21356571e-01f, -5.63083589e-01f,
  -8.19343999e-02f, 3.45993526e-02f, -9.28654671e-02f, -1.38192683e-01f, 3.05982620e-01f, 3.26318219e-02f, 3.77304405e-01f, 1.26137167e-01f, 5.33513948e-02f, 4.37950432e-01f,
  1.10746697e-01f, -1.15079666e-02f, -1.64767697e-01f, -1.39652133e-01f, -6.15684092e-02f, -7.36357048e-02f, -2.27939650e-01f, -4.10595834e-02f, 4.75527011e-02f, -9.58343968e-02f,
  -7.27078766e-02f, -2.07468629e-01f, 1.06313556e-01f, 5.28352857e-02f, -7.87743777e-02f, -2.38177836e-01f, 1.68427035e-01f, -6.28705546e-02f, -5.67786694e-02f, -8.01693425e-02f,
  -1.14038020e-01f, -1.16687931e-01f, -1.23341121e-01f, -1.54542893e-01f, -2.75078326e-01f, -5.10011651e-02f, -1.36644393e-01f, -1.33476242e-01f, -7.94709194e-03f, 3.54785889e-01f,
  -2.10538954e-01f, 8.33497662e-03f, 6.66474700e-02f, 9.39317420e-02f, -7.89374020e-03f, 8.91200602e-02f, -6.48399591e-02f, -9.97782722e-02f, -1.46171227e-01f, -1.00137345e-01f,
  6.36695139e-03f, 6.87367544e-02f, -1.10892937e-01f, -1.02940015e-02f, 4.99350987e-02f, -4.53374758e-02f, -1.27154768e-01f, 4.90469411e-02f, -9.15247351e-02f, 6.57467097e-02f,
  -1.17530741e-01f, -1.11489959e-01f, 1.15399420e-01f, -5.54009564e-02f, 6.72530532e-02f, -3.72944633e-03f, -1.68233793e-02f, -1.30487666e-01f, 5.84482029e-02f, -8.46923739e-02f,
  1.74163282e-01f, -1.94719329e-01f, 1.64193839e-01f, -2.13838816e-01f, -6.64968640e-02f, -6.35445267e-02f, -2.74414141e-02f, -9.66898426e-02f, -3.75282429e-02f, -2.35685110e-01f,
  -2.86036432e-01f, -3.94397378e-02f, 2.09432498e-01f, -1.80116221e-01f, -7.36618191e-02f, 6.91401353e-03f, 2.00225249e-01f, 6.55618086e-02f, -6.95663020e-02f, -1.42329246e-01f,
  1.28000066e-01f, -9.11629573e-02f, -3.57802119e-03f, 1.60911635e-01f, 6.23241402e-02f, -1.94862783e-01f, -3.82043347e-02f, 1.34810470e-02f, -1.34045422e-01f, 3.36022079e-01f,
  9.29355264e-01f, -2.07691714e-01f, -8.54201794e-01f, 1.04285106e-01f, -3.54911894e-01f, -4.15212542e-01f, -6.19607925e-01f, -2.24754393e-01f, 1.07828483e-01f, -3.45345080e-01f,
  -1.28424242e-01f, 4.37705010e-01f, -1.86651528e-01f, -1.32048950e-01f, -2.59596884e-01f, -7.37344444e-01f, -7.35533535e-01f, -3.41132224e-01f, -1.21526597e-02f, 3.61257493e-01f,
  1.98785812e-01f, 1.67760968e-01f, 8.53916109e-02f, -8.46610963e-02f, -1.23507120e-01f, -4.36509773e-02f, -5.67373514e-01f, -3.14720809e-01f, -3.07385921e-01f, -3.84163499e-01f,
  -4.96965885e-01f, -9.60361138e-02f, -3.54254209e-02f, 1.51411742e-01f, -2.12227330e-01f, 1.88644364e-01f, 1.37762561e-01f, -1.66906297e-01f, 3.68983686e-01f, -2.62485236e-01f,
  4.38481942e-02f, 1.80807739e-01f, 7.88709968e-02f, 7.83804730e-02f, -1.39612570e-01f, 5.58963455e-02f, -2.79819638e-01f, -1.20043345e-01f, -1.31538734e-01f, -1.39551863e-01f,
  1.50397390e-01f, 9.79480445e-02f, -2.01999262e-01f, -2.86478251e-01f, -3.13613981e-01f, -1.25451870e-02f, -3.46762091e-01f, -4.23060060e-02f, -2.65876710e-01f, -5.40872626e-02f,
  -6.81560189e-02f, -6.24513403e-02f, -6.63851276e-02f, 2.25545391e-02f, 1.36299953e-02f, -6.15791902e-02f, -1.83213066e-04f, -1.78871283e-04f, -8.54671076e-02f, 4.45024204e-03f,
  -4.07149792e-02f, -5.04448637e-02f, 7.15672458e-03f, -6.69522732e-02f, -1.04266688e-01f, -5.79066612e-02f, 7.02432841e-02f, -6.10753745e-02f, -1.01928622e-01f, -6.71404898e-02f,
  9.72727239e-02f, -1.00546308e-01f, 2.17119930e-03f, 1.20781921e-01f, -1.93510018e-02f, -1.89313263e-01f, 5.09210192e-02f, 9.86611471e-02f, 1.15042664e-01f, -6.53896257e-02f,
  5.60369678e-02f, -2.67084599e-01f, 6.43284544e-02f, -5.35457507e-02f, -1.01064712e-01f, -6.07274435e-02f, 3.09807132e-03f, -1.00723125e-01f, 1.01887919e-01f, 1.66884050e-01f,
  -4.09849063e-02f, 9.71335471e-02f, -2.10831597e-01f, 2.98228185e-03f, 8.92855451e-02f, 7.87614062e-02f, 6.25786185e-02f, 1.99468322e-02f, -8.43869001e-02f, 6.29858077e-02f,
  -9.64901596e-02f, 7.81935304e-02f, 2.49738634e-01f, -3.59048918e-02f, 1.51188627e-01f, 2.30967134e-01f, -1.34558856e-01f, -1.41286224e-01f, -7.75015280e-02f, -1.30334683e-02f,
  5.05863667e-01f, -9.10473838e-02f, 3.50974500e-01f, 2.04618528e-01f, 3.03094387e-01f, 2.52890676e-01f, -2.35536266e-02f, -1.11885816e-01f, 2.05609761e-02f, 1.21273078e-01f,
  8.71176086e-03f, -2.63351556e-02f, -2.18240991e-01f, -1.66681886e-01f, -2.35435829e-01f, -8.66207033e-02f, 3.68295945e-02f, 6.63159490e-02f, 1.21827029e-01f, 2.29246125e-01f,
  7.20258504e-02f, 3.01423408e-02f, 9.81503949e-02f, -7.16415271e-02f, 2.49257386e-01f, 5.71696572e-02f, 3.02627720e-02f, 1.14680469e-01f, 4.05708514e-02f, 2.93753564e-01f,
  2.43051514e-01f, 1.25256792e-01f, -7.08374232e-02f, -9.95614678e-02f, 9.23013687e-02f, -1.65981576e-02f, -5.94344810e-02f, 3.66540924e-02f, -1.13083810e-01f, -8.56709108e-02f,
  -9.46673471e-03f, -3.75571251e-02f, 2.56714504e-02f, -2.64671575e-02f, 2.33836360e-02f, -4.52041104e-02f, 1.56195294e-02f, -3.92444767e-02f, -1.44571096e-01f, -7.75229856e-02f,
  -3.02766915e-02f, 2.30935052e-01f, 1.06915101e-01f, -1.14792116e-01f, -1.78337097e-02f, -6.34234697e-02f, -1.07906997e-01f, 8.59105885e-02f, 1.01190768e-02f, 1.53609827e-01f,
  1.12241916e-01f, 1.22546583e-01f, 1.88771591e-01f, 8.61059800e-02f, 1.33336142e-01f, 9.22884569e-02f, 6.15675449e-02f, 1.16736807e-01f, -5.77245392e-02f, 6.69662431e-02f,
  -3.38026322e-02f, 7.81476423e-02f, 1.00810088e-01f, 1.95816100e-01f, 4.79449593e-02f, 1.77756459e-01f, 2.68536597e-01f, 6.71559758e-03f, 8.78329203e-02f, 4.77300435e-02f,
  1.04542777e-01f, 3.32015529e-02f, 1.38426259e-01f, -1.52886715e-02f, 4.19354439e-02f, 1.55487344e-01f, 2.38016695e-01f, 1.36798441e-01f, 1.83675662e-01f, 1.03665806e-01f,
  -2.42520615e-01f, -2.01787114e-01f, 5.91943599e-02f, -1.09677091e-01f, 1.72633287e-02f, -6.09131567e-02f, 1.11133941e-02f, -1.64207015e-02f, 2.93380972e-02f, -5.82907945e-02f,
  1.19288206e-01f, 5.05617484e-02f, -9.91387516e-02f, -8.11503753e-02f, 9.22199413e-02f, 3.73593695e-03f, 1.88975204e-02f, 8.98555815e-02f, -1.88070595e-01f, 1.46467276e-02f,
  -1.66155159e-01f, 6.57367855e-02f, -1.57363992e-02f, -5.54146655e-02f, -3.71205760e-03f, -2.09444221e-02f, 5.53335026e-02f, 1.10305279e-01f, -2.33673546e-02f, -6.67575514e-03f,
  -1.06696635e-01f, 2.85260707e-01f, 4.37725857e-02f, 1.12719811e-01f, -3.25745717e-02f, -2.05611140e-01f, 4.36379854e-03f, -4.99419756e-02f, 3.99994887e-02f, 1.93183213e-01f,
  -4.27883603e-02f, -5.29308654e-02f, -9.52044781e-03f, -3.09673697e-02f, -1.64494470e-01f, 1.62679255e-01f, 5.29820845e-02f, -3.76493372e-02f, -2.55097359e-01f, -3.12154770e-01f,
  -1.44126788e-01f, 6.88228309e-02f, 1.95675809e-02f, -3.82352583e-02f, 4.12974432e-02f, -1.20244632e-02f, 2.32123300e-01f, -2.04559620e-02f, -1.67459920e-01f, 8.57572928e-02f,
  1.56675905e-01f, -1.49856254e-01f, 4.92181890e-02f, -1.28043696e-01f, 2.85345111e-02f, 1.58612579e-01f, 1.19128972e-01f, 7.64919221e-02f, 1.23419747e-01f, 1.10563658e-01f,
  3.56242694e-02f, 9.76857617e-02f, 1.10283792e-01f, 2.24726647e-03f, 1.66887283e-01f, 7.47884139e-02f, 2.97955330e-02f, -7.46161416e-02f, 7.84232616e-02f, 5.37133440e-02f,
  -4.54235226e-02f, -1.38392568e-01f, 3.87594849e-02f, -2.92757824e-02f, -1.04450747e-01f, -2.27039587e-02f, -6.58063442e-02f, -5.35226129e-02f, -7.71358386e-02f, 4.66143414e-02f,
  -1.23847239e-01f, -2.94073801e-02f, 4.44916710e-02f, 1.14881679e-01f, 1.39125377e-01f, 3.60336304e-01f, 3.09953362e-01f, 1.67607173e-01f, 1.45112097e-01f, 1.16188288e-01f,
  1.76789343e-01f, 2.63790607e-01f, 3.84847879e-01f, 1.48787364e-01f, 3.08011949e-01f, 3.00631344e-01f, 2.73793668e-01f, 3.22014093e-01f, 1.05873451e-01f, 3.85690898e-01f,
  1.05993368e-01f, 2.91822642e-01f, 3.01074922e-01f, 3.04719120e-01f, 1.03464037e-01f, 1.49343744e-01f, 1.76890597e-01f, 9.38363969e-02f, 1.77085266e-01f, 1.30005464e-01f,
  2.23162517e-01f, -5.43405935e-02f, 1.25579894e-01f, -8.25794116e-02f, 4.64683287e-02f, 1.15257256e-01f, 7.91222900e-02f, 7.64206350e-02f, 2.31916294e-01f, 2.04497039e-01f,
  -1.56592019e-02f, 1.46182448e-01f, 2.18062252e-01f, 4.90761735e-02f, 1.30654797e-01f, -6.15507457e-03f, 2.13344190e-02f, -5.53870648e-02f, -6.32328019e-02f, -5.29206544e-02f,
  -5.57570979e-02f, 2.69762939e-03f, 2.39012223e-02f, 1.04413263e-01f, -3.20767164e-02f, -1.39978724e-02f, 6.62920624e-02f, 5.54100536e-02f, -1.47387788e-01f, 2.60275155e-01f,
  -2.99480539e-02f, 4.92011726e-01f, -6.32857025e-01f, -5.53580187e-02f, -4.37593728e-01f, -4.46029246e-01f, 5.40531352e-02f, 1.56093374e-01f, 6.72193691e-02f, 1.47079051e-01f,
  1.14622809e-01f, -2.28218228e-01f, -2.94167399e-01f, -1.17638521e-01f, -7.45409057e-02f, -7.48954266e-02f, -2.63660610e-01f, -4.99515057e-01f, -4.72136617e-01f, -2.18303781e-02f,
  3.67052555e-02f, 5.57059771e-04f, -5.72598167e-03f, -9.48594138e-02f, -1.59809850e-02f, -1.59067452e-01f, -1.44030482e-01f, -2.47478679e-01f, -3.27144474e-01f, -2.04256043e-01f,
  -1.00797139e-01f, -2.38198593e-01f, -8.45348164e-02f, -3.30357589e-02f, 7.06516355e-02f, -2.00409312e-02f, 5.53828031e-02f, 5.48367463e-02f, 8.76982212e-02f, 3.87832448e-02f,
  -1.13025174e-01f, -3.18434462e-02f, -2.37255450e-02f, 8.10933784e-02f, -9.49200541e-02f, -3.89384814e-02f, 1.27104953e-01f, -1.66176707e-01f, -2.04038575e-01f, 2.81614494e-02f,
  5.58708236e-02f, -3.17650735e-01f, -3.06154579e-01f, 9.61370766e-02f, -1.74659833e-01f, -4.62612242e-01f, 2.39030309e-02f, -1.49708360e-01f, -3.32597882e-01f, 2.47773141e-01f,
  1.12709627e-01f, 5.82611598e-02f, 7.52374083e-02f, 7.98700228e-02f, 3.44947040e-01f, 5.64935654e-02f, 1.47402585e-01f, 1.84234604e-01f, 7.64523149e-02f, 1.46576419e-01f,
  -5.59186097e-03f, 1.08021706e-01f, -6.62889471e-03f, -5.63656613e-02f, 4.61828895e-02f, -1.17103964e-01f, -3.64797562e-02f, 1.12636276e-01f, 2.92450469e-03f, -1.12554757e-03f,
  1.10004626e-01f, -5.33440784e-02f, -5.76551259e-02f, 1.38697952e-01f, -1.79206170e-02f, 4.24427055e-02f, -3.71910818e-02f, 9.19081867e-02f, 2.94483472e-02f, -1.10980853e-01f,
  3.68101209e-01f, -3.86451185e-01f, 8.83960873e-02f, 1.32705551e-02f, -1.23459548e-01f, -2.06591673e-02f, 1.37181446e-01f, 9.87306535e-02f, 4.93745096e-02f, 9.83544439e-02f,
  5.65474778e-02f, 1.44275516e-01f, 1.73247010e-02f, 1.54149771e-01f, -4.81368527e-02f, 3.37625593e-02f, 2.66741574e-01f, -8.92983451e-02f, -3.16216089e-02f, 2.44040601e-02f,
  1.76467821e-01f, 4.39295173e-02f, 2.36044168e-01f, 2.35886127e-01f, -3.67802754e-02f, -1.37645707e-01f, 2.23705366e-01f, 4.71330322e-02f, -1.94000363e-01f, 4.98020530e-01f,
  5.94554424e-01f, 4.48059857e-01f, 2.36369044e-01f, 2.58871745e-02f, -1.06769845e-01f, 5.01155332e-02f, 2.41709024e-01f, 7.61057995e-03f, -1.68197736e-01f, 1.66524187e-01f,
  3.55671458e-02f, -1.42400488e-01f, -6.70133606e-02f, -1.11535445e-01f, 1.59435824e-01f, 1.03584379e-01f, -5.83568886e-02f, 1.34910509e-01f, 1.17679043e-02f, 2.64783949e-02f,
  -6.83756247e-02f, 1.90004438e-01f, 2.29895234e-01f, 1.06473476e-01f, 2.58611403e-02f, -1.25006482e-01f, 8.46896842e-02f, 1.13240920e-01f, 6.24241978e-02f, 9.57612246e-02f,
  1.82733104e-01f, 2.42611244e-01f, -2.18645230e-01f, -5.25022745e-02f, 5.36536425e-02f, 4.23849560e-02f, -5.33511164e-03f, -4.52723168e-02f, 3.14311758e-02f, -5.11519089e-02f,
  -3.25206481e-02f, 6.26703128e-02f, -1.60407901e-01f, -2.93717925e-02f, -1.73092961e-01f, 6.14775403e-04f, -1.17149100e-01f, -1.32458597e-01f, -3.57638821e-02f, 2.10284740e-02f,
  -1.52283952e-01f, -1.19096749e-01f, -8.31840634e-02f, -2.47514948e-01f, -1.02659799e-01f, -2.53839374e-01f, 4.92107011e-02f, -4.67390381e-02f, -1.81533657e-02f, -3.78469564e-02f,
  -2.72420049e-01f, 6.51440993e-02f, -1.00767322e-01f, -2.54108071e-01f, -2.21851185e-01f, -1.18380904e-01f, -5.63273951e-02f, -9.06565040e-02f, -1.12233669e-01f, -8.50852132e-02f,
  -1.71996012e-01f, -1.94561467e-01f, -1.25019565e-01f, -1.38660431e-01f, -6.49698749e-02f, -8.74648839e-02f, 2.56529544e-02f, -1.03893079e-01f, -1.45037517e-01f, -5.95431738e-02f,
  -9.36906710e-02f, -3.55481692e-02f, -1.00769699e-01f, -1.18493780e-01f, -1.08500466e-01f, -2.44539618e-01f, -1.29932255e-01f, -4.70545664e-02f, -6.94195405e-02f, 1.13105299e-02f,
  -4.57309306e-01f, -2.95031201e-02f, 6.25879392e-02f, 2.50513941e-01f, 1.84765071e-01f, 9.60032865e-02f, 9.84508023e-02f, 1.09023623e-01f, 1.08935097e-02f, 6.78437576e-02f,
  1.10272154e-01f, 1.06708206e-01f, 6.38170019e-02f, -3.28196064e-02f, -4.09598239e-02f, -9.79647040e-02f, 8.75807479e-02f, 1.77374482e-02f, -1.84011757e-02f, -4.27055992e-02f,
  -3.51698324e-02f, -1.07054651e-01f, -8.01594332e-02f, -1.95467785e-01f, -1.09576851e-01f, -1.16856545e-01f, -1.03992961e-01f, -9.40897129e-03f, -9.73513052e-02f, -2.07554981e-01f,
  -5.10762990e-01f, -8.63761008e-02f, -1.20821670e-01f, -3.46169561e-01f, -1.30363628e-01f, 1.53973356e-01f, 7.61197042e-03f, -6.57812506e-03f, -4.86233830e-02f, 9.12951753e-02f,
  -4.10568304e-02f, -3.96277606e-02f, -1.03776626e-01f, -9.90008041e-02f, -1.80353880e-01f, -5.18331528e-02f, -1.39222190e-01f, -1.96557343e-01f, -1.54827118e-01f, 1.60325915e-01f,
  -6.41933829e-02f, -3.78938556e-01f, -2.87442744e-01f, -2.12008208e-01f, -1.21575966e-01f, -1.96842164e-01f, -2.76396334e-01f, -2.39596292e-01f, -1.19512260e-01f, -2.53115177e-01f,
  1.01131126e-01f, 4.24832888e-02f, -1.24984700e-02f, -3.55369560e-02f, -1.23666655e-02f, 3.77830379e-02f, -1.74322221e-02f, -1.04950443e-01f, 5.03078923e-02f, 1.13226539e-02f,
  -4.18376736e-02f, 4.71331738e-02f, -7.08271191e-02f, 5.74054383e-02f, 2.77151912e-03f, 1.43268615e-01f, 1.46031588e-01f, -2.21692258e-03f, 1.74998417e-02f, 1.75061166e-01f,
  2.12445483e-01f, 1.33375168e-01f, 3.05793583e-02f, 3.25908884e-02f, 1.04843698e-01f, -3.60043533e-03f, 8.59946758e-02f, 1.68570951e-01f, 2.44066752e-02f, -1.09059528e-01f,
  -4.62940037e-02f, 1.00145578e-01f, 1.07808830e-03f, 5.62860370e-02f, 1.10962577e-01f, 6.15635216e-02f, 5.70506603e-02f, -7.27672130e-02f, -1.23140588e-01f, -6.27261549e-02f,
  6.24574721e-02f, 1.21954396e-01f, -6.58617467e-02f, -1.96191803e-01f, -6.27948642e-02f, -8.72882903e-02f, -3.93519700e-02f, -3.31394896e-02f, -3.97128314e-02f, -7.61146424e-03f,
  -8.08538496e-02f, -5.59560210e-02f, 1.04835061e-02f, -6.74632713e-02f, 1.21626347e-01f, 1.14131607e-02f, 1.05483890e-01f, 1.27467602e-01f, 5.15656322e-02f, 1.08926773e-01f,
  -2.51445919e-01f, -7.92499706e-02f, -4.20867652e-02f, 4.29760814e-02f, -2.89588254e-02f, 1.27987847e-01f, 8.44850764e-02f, 6.84362128e-02f, -5.67621998e-02f, 7.60151595e-02f,
  1.03864439e-01f, -8.20318051e-03f, -7.42521584e-02f, 1.28470048e-01f, -7.37332851e-02f, 9.46331620e-02f, 1.17555112e-01f, -6.83684722e-02f, 9.78448689e-02f, 2.49740347e-01f,
  1.85966909e-01f, -1.01242311e-01f, -1.86860189e-01f, -6.28262833e-02f, 3.64216231e-02f, -1.48579568e-01f, -6.85317218e-02f, -1.82169713e-02f, -8.60541090e-02f, -2.07079783e-01f,
  4.71582770e-01f, 3.70733917e-01f, -2.73375511e-01f, 1.23326868e-01f, -1.04845181e-01f, -2.31923625e-01f, 7.15105608e-02f, 2.72641182e-02f, 1.75023034e-01f, 1.81160063e-01f,
  1.07259043e-01f, 1.20411254e-01f, 8.80332366e-02f, 2.48287488e-02f, -3.89671442e-03f, 9.82617065e-02f, -3.56104709e-02f, -1.77395478e-01f, -1.48372620e-01f, -1.16788313e-01f,
  -1.20778680e-01f, -7.50236958e-02f, 9.18755494e-03f, -8.83882772e-03f, -4.46303114e-02f, 3.56647149e-02f, -8.05620328e-02f, 3.30319516e-02f, -2.50300914e-02f, -9.43011492e-02f,
  -5.21472812e-01f, -1.07473895e-01f, -3.05133332e-02f, 3.53724658e-02f, -2.43885070e-02f, 5.52524738e-02f, 1.98742505e-02f, 3.84377986e-02f, 1.26605168e-01f, 9.75962654e-02f,
  6.34891260e-03f, 3.60758863e-02f, -1.06955022e-02f, -9.32699721e-03f, -4.44978960e-02f, -1.20193884e-01f, 3.77181694e-02f, 3.78837511e-02f, 9.14160162e-02f, 1.88066494e-02f,
  1.80048030e-02f, 4.56611551e-02f, 2.94491947e-02f, -2.60742530e-02f, -1.83059517e-02f, 6.13012053e-02f, 3.22252326e-02f, 5.12090810e-02f, -3.52654979e-02f, 8.21282789e-02f,
  1.12369269e-01f, 1.66423872e-01f, -6.88862354e-02f, 2.00847927e-02f, 1.19358003e-02f, -2.00624075e-02f, 1.57345776e-02f, 4.29036207e-02f, 7.32090101e-02f, 1.01951309e-01f,
  1.14101045e-01f, -1.60915479e-01f, -1.78525209e-01f, 4.80730534e-02f, -1.51476473e-01f, -7.44398013e-02f, 4.23599072e-02f, 3.80826965e-02f, -9.68877152e-02f, 1.13553584e-01f,
  5.47273690e-03f, 7.95784518e-02f, -9.14707035e-02f, -3.06953210e-02f, -8.55427142e-03f, -1.01866700e-01f, -2.92284675e-02f, 4.77474034e-02f, 8.09414610e-02f, 1.77045595e-02f,
  -2.47751698e-01f, -1.60554364e-01f, 6.08850420e-02f, 1.06266707e-01f, 4.65385467e-02f, -5.08622043e-02f, -1.00058310e-01f, -1.36401966e-01f, -8.23266506e-02f, -1.66028246e-01f,
  -1.89760312e-01f, -4.49537225e-02f, -5.52402362e-02f, -9.17620733e-02f, 3.96895967e-02f, -9.93609875e-02f, 8.47408921e-02f, 6.53864294e-02f, -6.42127842e-02f, 6.11688159e-02f,
  1.36237249e-01f, 1.60078302e-01f, 2.44874164e-01f, 6.60660043e-02f, 3.77825648e-02f, 6.59002215e-02f, -2.34632250e-02f, -6.47854507e-02f, -3.11623905e-02f, 2.07949802e-01f,
  2.92078286e-01f, -1.42598435e-01f, 1.11489631e-01f, 6.68030009e-02f, -3.87405790e-02f, -1.78268999e-01f, -1.31919816e-01f, -6.57847673e-02f, 1.00396171e-01f, 9.32474807e-03f,
  6.04530014e-02f, 2.35944971e-01f, 2.88162351e-01f, 7.54637420e-02f, 1.78617775e-01f, 3.61021683e-02f, 5.90427965e-02f, 1.84982255e-01f, 1.98813692e-01f, 7.02777877e-02f,
  -2.26780288e-02f, -1.83555949e-02f, 2.65728384e-02f, 6.68500084e-04f, 5.66697568e-02f, 1.14377588e-01f, -1.99698154e-02f, -1.39769882e-01f, -9.28071737e-02f, 1.80183426e-02f,
  2.76076764e-01f, -1.34944081e-01f, 1.55871779e-01f, 6.98708072e-02f, -5.76568507e-02f, -4.43867818e-02f, 2.21871454e-02f, -2.70080823e-03f, -3.10974233e-02f, -1.06317371e-01f,
  -9.14605111e-02f, -1.17589600e-01f, -4.27110381e-02f, -4.92810123e-02f, -1.50463715e-01f, 2.03182101e-02f, -4.34818007e-02f, -1.40898824e-01f, -3.35454307e-02f, -5.30293435e-02f,
  -1.57028362e-01f, -1.25248984e-01f, 1.08960094e-02f, -1.66870449e-02f, 7.45022446e-02f, 6.29633665e-03f, 2.92557850e-02f, -7.83356875e-02f, -1.04252994e-02f, 4.11962532e-02f,
  1.15654692e-01f, 1.36400059e-01f, 1.21879548e-01f, 1.96794003e-01f, 1.50760591e-01f, 9.13748294e-02f, -7.32092410e-02f, -1.02808394e-01f, -6.29308149e-02f, -3.88257019e-02f,
  5.56023419e-03f, 1.16843365e-01f, 6.54994184e-03f, -8.21317881e-02f, 1.43987447e-01f, 2.73218546e-02f, -7.79208690e-02f, -7.22057372e-02f, 1.24062903e-01f, 3.21291992e-03f,
  1.31680995e-01f, 4.28504050e-02f, 1.37930050e-01f, -5.10648414e-02f, 5.97599410e-02f, -3.66090909e-02f, 9.64075699e-02f, -2.65415036e-03f, 3.11031509e-02f, -3.69902849e-02f,
  5.57467304e-02f, -2.38372721e-02f, 2.61904120e-01f, -6.37041256e-02f, -1.06131665e-01f, -1.12574525e-01f, -1.26678515e-02f, -5.04968688e-02f, -5.57327345e-02f, -1.08209597e-02f,
  -1.39459044e-01f, -1.59399100e-02f, -1.70329865e-02f, -8.93824473e-02f, 8.16081930e-03f, 7.14516193e-02f, 7.93136582e-02f, 1.02887452e-02f, -6.46589994e-02f, -9.84508768e-02f,
  -1.35250092e-01f, 1.30921984e-02f, 1.55561402e-01f, 8.77878163e-03f, 6.97363168e-02f, 1.24109067e-01f, 1.00893460e-01f, 5.02226166e-02f, -2.58405041e-02f, -3.52607779e-02f,
  -8.40499904e-03f, 4.50508259e-02f, -3.82058263e-01f, 2.53305227e-01f, 2.09784925e-01f, -2.35939682e-01f, -4.25693810e-01f, -3.74366492e-01f, 1.39630347e-01f, 7.50473067e-02f,
  3.46724778e-01f, 2.94004083e-01f, -2.41641346e-02f, -2.66701639e-01f, -5.08054376e-01f, -5.05659997e-01f, -5.35580814e-01f, -4.66657311e-01f, -4.60999131e-01f, -1.35990024e-01f,
  1.90043792e-01f, 1.30973563e-01f, -7.81728327e-02f, -1.16879068e-01f, 5.31402946e-01f, 1.88092470e-01f, 2.26406574e-01f, 2.23116741e-01f, -7.25205690e-02f, 3.02086830e-01f,
  3.10234845e-01f, -5.77323744e-03f, -3.76160373e-03f, -5.80537952e-02f, 1.67120323e-01f, -1.07035460e-03f, -1.57741740e-01f, -9.14205462e-02f, -1.87427714e-01f, 7.59331509e-03f,
  6.15204610e-02f, -1.12212867e-01f, -5.89993298e-02f, 5.88739179e-02f, 1.94767527e-02f, -2.42088065e-01f, -2.40843594e-01f, -3.21579337e-01f, -2.59649575e-01f, -1.82138961e-02f,
  8.95047262e-02f, -2.78233793e-02f, -1.64835110e-01f, -2.20848367e-01f, -2.57247120e-01f, -4.45057973e-02f, 3.51560228e-02f, 1.41685516e-01f, -2.39546910e-01f, 1.31508321e-01f,
  9.65664536e-03f, -1.65208012e-01f, -9.63430628e-02f, 1.28235696e-02f, -2.57723890e-02f, 1.16267232e-02f, -8.83419812e-03f, 7.00364821e-03f, 1.08757988e-02f, 2.56811269e-02f,
  -1.31021068e-01f, -1.06333725e-01f, 1.31483395e-02f, -6.79869438e-04f, 9.46387881e-05f, 7.15904459e-02f, 2.12010834e-02f, 5.91793321e-02f, -1.22049339e-01f, -6.13497756e-02f,
  6.57770899e-04f, 5.24861738e-02f, 1.35683432e-01f, 2.58035269e-02f, -2.41919011e-02f, -6.93811942e-03f, 1.27280071e-01f, 5.67383096e-02f, -1.14953788e-02f, 4.11370844e-02f,
  3.97575378e-01f, -2.90771723e-01f, 2.67335385e-01f, -1.07928641e-01f, 4.67388704e-02f, 1.34931430e-01f, 1.83962911e-01f, -5.06749228e-02f, 6.02479652e-02f, -6.38442338e-02f,
  -1.01449199e-01f, -1.74682170e-01f, 5.31844683e-02f, 6.96594790e-02f, -8.30678791e-02f, -4.37535755e-02f, -2.59649813e-01f, 6.68479800e-02f, -2.10976899e-01f, 1.88987017e-01f,
  -1.42550945e-01f, -1.86547413e-01f, -1.44622162e-01f, -1.25479370e-01f, 3.62716988e-02f, -8.91547650e-02f, -6.46163535e-05f, 1.16722114e-01f, -2.94941962e-01f, 6.92442358e-02f,
  7.45412588e-01f, 1.53841317e-01f, 9.37953964e-02f, 6.93040118e-02f, -9.50798094e-02f, -1.75534025e-01f, -2.15650246e-01f, -2.02204823e-01f, -3.69995572e-02f, 9.67661142e-02f,
  1.09097965e-01f, 1.73107550e-01f, 8.89892727e-02f, 9.77560580e-02f, -5.51368967e-02f, -1.66847363e-01f, -3.05529952e-01f, 9.07144770e-02f, 6.86388696e-03f, 4.69393209e-02f,
  -3.15033086e-02f, 3.88836935e-02f, 1.70596004e-01f, -1.08619323e-02f, -5.22231087e-02f, 5.07345423e-02f, -3.90358455e-02f, -2.06240658e-02f, -1.26884937e-01f, 9.13324878e-02f,
  1.24796182e-01f, 3.29753667e-01f, 8.87723360e-03f, -4.50260937e-02f, 9.15780440e-02f, 1.29295573e-01f, 1.33567629e-02f, 2.35158596e-02f, -7.63045773e-02f, -1.75032869e-01f,
  -1.09668009e-01f, 9.10589173e-02f, 6.57159388e-02f, -4.75831591e-02f, 2.51808781e-02f, -2.65139267e-02f, 7.00026006e-02f, -8.58909413e-02f, -1.37883753e-01f, 6.45029247e-02f,
  3.85688469e-02f, -3.20519693e-02f, -1.63882554e-01f, -9.23505649e-02f, -7.05864057e-02f, -2.74771471e-02f, 2.88630407e-02f, 7.72976503e-02f, 9.09394994e-02f, 1.12689413e-01f,
  -6.24090154e-03f, 4.99470253e-03f, 1.04429647e-01f, 8.32513422e-02f, 1.20571829e-01f, -4.29270528e-02f, -9.01365001e-03f, -1.63622960e-01f, 9.37560275e-02f, 7.64539912e-02f,
  -1.33287415e-01f, 3.25975604e-02f, 5.73174804e-02f, -6.77728057e-02f, 5.74810356e-02f, 3.89422625e-02f, 3.16963978e-02f, 6.83485791e-02f, 6.97364658e-02f, -7.65180169e-03f,
  9.14462656e-02f, -5.95349371e-02f, 4.64179404e-02f, -1.12188771e-01f, -6.69857711e-02f, -1.15935899e-01f, -9.35961381e-02f, 1.09194973e-02f, -8.39890316e-02f, -7.26839602e-02f,
  -1.58912897e-01f, 2.07582623e-01f, 1.28333598e-01f, 1.15540862e-01f, 1.47444174e-01f, 3.73399071e-02f, 2.47126445e-01f, 9.40222442e-02f, -1.49618536e-01f, -2.94801276e-02f,
  -4.82836589e-02f, 1.31371930e-01f, 5.36355451e-02f, -3.13888565e-02f, -2.74683647e-02f, 7.53241125e-03f, 1.21279106e-01f, 3.21374014e-02f, -6.26406819e-02f, -1.34485096e-01f,
  -3.40956333e-03f, -2.33731214e-02f, -1.07292369e-01f, -8.51516947e-02f, 6.16377778e-02f, 6.18719272e-02f, -2.88250446e-02f, 4.62531894e-02f, -3.06919329e-02f, -1.33371711e-01f,
  -7.88891971e-01f, -4.86765712e-01f, 1.16940923e-01f, -2.64849007e-01f, 2.22740546e-01f, -2.06733570e-01f, -5.41399896e-01f, -3.92621994e-01f, -2.44374692e-01f, -1.98766544e-01f,
  1.25279963e-01f, 1.93601713e-01f, 3.40455621e-02f, 9.99764204e-02f, -2.03467056e-01f, -1.39460370e-01f, 2.71493375e-01f, 1.51123255e-01f, 1.64756134e-01f, -1.61401648e-02f,
  1.04483321e-01f, -5.48795424e-02f, -1.49871511e-02f, -5.40901721e-03f, 8.56885388e-02f, 1.59167990e-01f, 2.21409455e-01f, 1.56916693e-01f, 5.47196195e-02f, 1.37558073e-01f,
  -1.92273781e-01f, -2.52544850e-01f, 2.07389787e-01f, 3.11253786e-01f, 3.05448085e-01f, -1.26571551e-01f, -1.56323865e-01f, -6.82419315e-02f, 1.89684778e-02f, 6.67018965e-02f,
  2.19322726e-01f, 4.53907587e-02f, 4.06512767e-02f, -1.70027465e-02f, -1.31779730e-01f, -2.56813556e-01f, 2.09636409e-02f, -5.74687589e-03f, -1.67638734e-01f, 4.06050123e-02f,
  2.97336578e-01f, 1.50340497e-01f, -2.45733380e-01f, -2.12163851e-01f, -4.44920361e-01f, 1.73891976e-01f, -2.03025475e-01f, -1.63163364e-01f, -4.49026167e-01f, -4.78605628e-01f,
  1.28028587e-01f, 1.00151904e-01f, -7.43849128e-02f, -8.74218196e-02f, -2.70988755e-02f, 5.08371927e-02f, 1.28142685e-02f, 4.32279147e-02f, 1.15696505e-01f, -1.11834072e-01f,
  -4.03014682e-02f, 1.35552019e-01f, 9.69256535e-02f, -8.10962319e-02f, 1.92860693e-01f, -3.70784849e-02f, 4.55591008e-02f, 1.10391758e-01f, 1.17588706e-01f, 5.71638998e-03f,
  -1.40341833e-01f, -6.16047531e-02f, 1.11742362e-01f, -2.40735635e-02f, -5.76455370e-02f, 4.78478596e-02f, -8.52161869e-02f, -5.25286049e-02f, -1.72469363e-01f, -3.22286189e-02f,
  -4.27665621e-01f, 3.28031063e-01f, -1.95942640e-01f, -1.88691840e-02f, 9.76751819e-02f, 1.80367619e-01f, 1.04992129e-01f, -7.72116259e-02f, -7.18541369e-02f, -9.33100134e-02f,
  -1.23578958e-01f, -1.71036199e-01f, -1.44856945e-01f, 4.63668220e-02f, -6.82216585e-02f, -1.47345737e-01f, -9.43760797e-02f, 5.54430373e-02f, -1.28343686e-01f, -4.32300717e-02f,
  -4.71629687e-02f, -3.28467786e-01f, -3.85470748e-01f, -4.32955593e-01f, -2.90541798e-01f, -3.15254867e-01f, -2.01529831e-01f, -1.98620155e-01f, -3.83572668e-01f, -6.69881821e-01f,
  3.59076232e-01f, -2.76975781e-01f, 3.01461369e-02f, 1.52054697e-01f, -2.32012365e-02f, -1.00592077e-01f, -3.31956267e-01f, -3.07975560e-02f, 5.77933006e-02f, -1.43574610e-01f,
  -9.57182497e-02f, 2.64159264e-03f, 8.87695625e-02f, 1.34612828e-01f, 1.35849521e-01f, -9.42387730e-02f, 4.70353737e-02f, 1.16794311e-01f, 4.48718406e-02f, -1.13328040e-01f,
  -1.19191356e-01f, 6.97248010e-03f, 1.33269757e-01f, 1.29098713e-01f, -7.26724863e-02f, 8.50406364e-02f, 8.77298042e-02f, 6.89758360e-02f, -1.98815376e-01f, 6.11453094e-02f,
  -3.17092806e-01f, -1.02040589e-01f, -7.29667544e-02f, -8.86292830e-02f, -1.25549912e-01f, -7.59597942e-02f, -8.94594789e-02f, 2.92784274e-02f, 8.23911105e-04f, -1.24518529e-01f,
  -5.16101159e-02f, 1.64326206e-02f, -9.13012549e-02f, -1.49320625e-02f, -6.90705851e-02f, -5.11025488e-02f, -1.01010434e-01f, -1.86452061e-01f, -1.10716209e-01f, -1.62486777e-01f,
  -1.80843830e-01f, -8.07483271e-02f, -1.96614340e-01f, -1.66040450e-01f, -6.97679967e-02f, -4.80253771e-02f, -3.57170552e-02f, -1.50199845e-01f, -2.73080636e-02f, -5.16590215e-02f,
  -1.06957883e-01f, -2.51005411e-01f, -1.55124351e-01f, 6.41358197e-02f, 5.84729873e-02f, -1.32112280e-01f, -1.17924817e-01f, -1.67232886e-01f, -7.98119754e-02f, 1.34365279e-02f,
  -1.69100121e-01f, 2.27171183e-02f, -1.12615474e-01f, -1.62071958e-01f, -5.26386835e-02f, -6.13407418e-02f, -8.72663707e-02f, -1.42753735e-01f, -3.04555167e-02f, -5.48253674e-03f,
  -5.50682768e-02f, -3.91943790e-02f, -2.96448786e-02f, -1.62994981e-01f, -1.99783787e-01f, -1.46779522e-01f, 8.01129453e-03f, -8.69733021e-02f, -1.20942272e-01f, -9.87166166e-02f,
  -8.92679989e-02f, 3.16346854e-01f, 1.37942940e-01f, 1.47290349e-01f, 5.30958846e-02f, 5.91395311e-02f, 7.38371238e-02f, 4.43237610e-02f, 7.68234134e-02f, 8.04899484e-02f,
  1.25651285e-01f, 1.44878626e-01f, 8.07355270e-02f, -1.91752147e-02f, -2.46182606e-02f, 4.81406366e-03f, 4.24612723e-02f, 8.21297690e-02f, 7.26678595e-02f, -1.11005284e-01f,
  1.23274429e-02f, -6.97147697e-02f, 5.28402552e-02f, 1.16313115e-01f, 5.97455874e-02f, 6.07357845e-02f, 7.27177784e-02f, -2.36736611e-02f, 1.59651209e-02f, -5.95405102e-02f,
  5.88622212e-01f, 4.43981081e-01f, 3.57906610e-01f, -3.84705998e-02f, -1.05047807e-01f, 2.79429227e-01f, 4.45572853e-01f, 2.75087893e-01f, -1.04398191e-01f, 2.18834281e-01f,
  1.31371945e-01f, -2.88270295e-01f, -2.06893101e-01f, -1.57937407e-02f, 2.58351684e-01f, 1.39799327e-01f, 1.51595054e-03f, 3.15033235e-02f, 2.69350372e-02f, 1.03746511e-01f,
  -2.71146357e-01f, -2.66978871e-02f, 2.11537912e-01f, 6.88770637e-02f, -6.63605630e-02f, -3.08342576e-01f, 2.12534871e-02f, 8.61622617e-02f, 2.25598350e-01f, -1.46090597e-01f,
  3.82553101e-01f, 4.48553652e-01f, -2.51992702e-01f, -2.41130143e-01f, -6.68187113e-03f, -2.41231937e-02f, 6.23941002e-03f, -1.69765979e-01f, 1.96394846e-02f, -1.54313296e-02f,
  -2.52480879e-02f, -6.17960468e-02f, 2.58219223e-02f, 6.79345503e-02f, 1.09051587e-03f, 6.83212727e-02f, -1.39767425e-02f, 9.42635983e-02f, -1.02637298e-02f, 1.16043545e-01f,
  -6.96152374e-02f, -1.41119827e-02f, 1.61864251e-01f, 2.39350297e-03f, 7.64150098e-02f, -1.57857776e-01f, 1.12453170e-01f, 3.83738279e-02f, 8.92393515e-02f, 1.25308350e-01f,
  -2.57929653e-01f, -1.59673095e-02f, 8.71032551e-02f, 3.89989614e-02f, 4.71256627e-03f, 1.10991793e-02f, -8.14287812e-02f, 8.25413596e-03f, -1.58447213e-02f, -1.34720683e-01f,
  -9.17972252e-02f, 8.46191943e-02f, 1.58448756e-01f, -3.57762049e-03f, -1.46452203e-01f, 3.13934386e-02f, 1.30076826e-01f, 1.13182798e-01f, 3.70712727e-02f, 8.03933665e-02f,
  -3.95962261e-02f, 3.87588725e-03f, -5.65290339e-02f, 6.55229613e-02f, -5.75877391e-02f, 5.16250469e-02f, -6.61315471e-02f, -7.36604929e-02f, -1.30459085e-01f, -7.45198801e-02f,
  -2.35635668e-01f, 9.03534964e-02f, -1.44454926e-01f, -3.41248438e-02f, -4.24628742e-02f, 2.86153215e-03f, -3.96242104e-02f, 4.45782812e-03f, 3.65548171e-02f, 6.18792996e-02f,
  7.09516034e-02f, 6.19807206e-02f, -2.53893938e-02f, 4.10936512e-02f, -1.47450879e-01f, -1.74844295e-01f, 3.64427827e-03f, -5.47124334e-02f, -1.42518997e-01f, -7.62675926e-02f,
  -1.84898540e-01f, -1.20858304e-01f, -1.54026583e-01f, -1.51689932e-01f, -1.36052847e-01f, -4.26846802e-01f, -1.73785552e-01f, -8.49793926e-02f, -8.40901434e-02f, -1.47144824e-01f,
  -4.25044119e-01f, 5.12719154e-01f, 1.40886039e-01f, -4.87227142e-01f, 9.80956256e-02f, 1.83102533e-01f, 3.00243795e-01f, -1.19809173e-01f, -1.39650315e-01f, 2.08272219e-01f,
  4.01841879e-01f, -8.18269849e-02f, -3.86132181e-01f, -3.91598523e-01f, -5.97832978e-01f, -3.27029496e-01f, -4.13205653e-01f, -6.16297722e-01f, -4.81151313e-01f, 7.82429799e-02f,
  -3.35085392e-02f, -3.01185280e-01f, -2.46141613e-01f, -2.61973649e-01f, 1.64064109e-01f, -8.15055147e-02f, 1.53926283e-01f, 5.73831908e-02f, 1.38841733e-01f, -7.22538978e-02f,
  2.25663364e-01f, 1.53259248e-01f, -1.12856917e-01f, -6.59201741e-02f, -5.49503602e-04f, -1.52091384e-01f, -6.89536007e-03f, -1.68976098e-01f, -1.36070207e-01f, -6.52261451e-02f,
  2.19795648e-02f, 8.78754184e-02f, -1.27312571e-01f, 9.86172631e-02f, -1.28774256e-01f, -5.96780255e-02f, -3.30125034e-01f, -2.72677779e-01f, -3.06599617e-01f, 1.06748968e-01f,
  9.98373032e-02f, 1.34432331e-01f, -3.24096866e-02f, 1.02638438e-01f, 3.40896063e-02f, 1.00816093e-01f, 3.62043321e-01f, 1.58665046e-01f, 1.09039411e-01f, 1.05104700e-01f,
  5.14499657e-02f, 8.22541267e-02f, -1.02068178e-01f, 6.31853342e-02f, 1.24566726e-01f, -5.77776805e-02f, -6.90383464e-02f, 3.89670916e-02f, -3.13828811e-02f, -9.93673131e-02f,
  -2.69639641e-02f, 1.00819610e-01f, -6.83236774e-03f, -4.77832258e-02f, 3.39059196e-02f, -4.24345396e-02f, -3.44765536e-03f, 1.00704089e-01f, 4.32509296e-02f, 2.29069199e-02f,
  -4.19352651e-02f, -1.17856413e-01f, -7.75483400e-02f, -3.13514471e-02f, 2.30740294e-01f, 6.61770850e-02f, 2.37845629e-02f, 2.10603043e-01f, -8.80726129e-02f, 6.53435588e-02f,
  -1.16704874e-01f, 5.00584673e-03f, -1.46503389e-01f, -2.23947555e-01f, 1.96832744e-03f, 6.27726465e-02f, -1.67922042e-02f, -3.35266888e-02f, -1.76567808e-02f, 1.47896469e-01f,
  2.19704181e-01f, 1.11331135e-01f, -1.48150131e-01f, 1.85680197e-04f, 1.92221664e-02f, 6.98915944e-02f, -2.23946899e-01f, -3.78895849e-02f, -1.47802770e-01f, 1.16415128e-01f,
  -2.71251291e-01f, -1.03468612e-01f, -2.24098608e-01f, -2.62232631e-01f, 3.52612734e-02f, -1.48835965e-02f, 3.61058451e-02f, 1.26003429e-01f, -9.60190594e-02f, -1.25211049e-02f,
  3.43269199e-01f, 4.61005837e-01f, 1.80315375e-01f, 2.27501661e-01f, 5.36731482e-02f, 1.82479486e-01f, 2.66158015e-01f, 1.88765734e-01f, 4.54903916e-02f, 1.37137398e-01f,
  -2.75117047e-02f, -2.55809221e-02f, -8.25806800e-03f, 1.30134717e-01f, 1.52503580e-01f, 1.47198886e-01f, 1.52407870e-01f, 3.81579548e-02f, 6.54760301e-02f, -3.53354439e-02f,
  7.60498196e-02f, 9.16450396e-02f, 1.65874455e-02f, 6.40212446e-02f, 7.13500157e-02f, 4.87145595e-02f, 9.24741104e-02f, 9.28579345e-02f, 8.67177173e-02f, 1.66570365e-01f,
  -1.59523919e-01f, 4.91884351e-02f, -1.74636722e-01f, -8.86116102e-02f, -3.77068520e-02f, -1.07147932e-01f, -1.64781008e-02f, -1.74497053e-01f, -1.16071813e-01f, -1.37456700e-01f,
  -1.09814398e-01f, -8.49373862e-02f, 5.83011694e-02f, -1.25297368e-01f, -8.03000554e-02f, -9.55309272e-02f, 3.83411646e-02f, 8.69448390e-03f, 5.59815727e-02f, 8.95671025e-02f,
  1.61222480e-02f, 5.41560687e-02f, 6.85681999e-02f, -4.65723462e-02f, 4.73363809e-02f, -1.08875766e-01f, 2.64256652e-02f, 6.72798604e-02f, 2.88571194e-02f, -3.14030871e-02f,
  -6.02676794e-02f, 1.46760136e-01f, 1.97274849e-01f, 3.22039947e-02f, 1.18183019e-02f, -3.64602916e-02f, -5.54407239e-02f, -4.28397842e-02f, 3.67490500e-02f, -3.59571464e-02f,
  -1.24205528e-02f, 3.94845381e-02f, -6.26191497e-02f, -8.23718011e-02f, -1.26312584e-01f, -3.19517627e-02f, 3.48409899e-02f, -8.46009031e-02f, -5.66968098e-02f, -8.54585171e-02f,
  -5.59402704e-02f, -8.92116055e-02f, -7.11725652e-02f, 3.42655852e-02f, -1.78645581e-01f, -2.75048278e-02f, -9.27346423e-02f, 1.20683396e-02f, -6.07484803e-02f, -1.21842064e-01f,
  -2.50651568e-01f, -1.02448083e-01f, -1.63303763e-01f, -3.75325384e-04f, 5.29942364e-02f, 3.19440402e-02f, -4.01849160e-03f, -6.93859905e-02f, -1.20233810e-02f, -7.82435834e-02f,
  5.86027559e-03f, -6.37843087e-02f, 1.08544022e-01f, 1.88296307e-02f, -1.90073907e-01f, -2.26747409e-01f, -2.04705894e-02f, -1.00639135e-01f, -1.32563375e-02f, 3.30787562e-02f,
  6.05920739e-02f, -1.40548125e-01f, -9.65607837e-02f, -1.40491888e-01f, -5.69537356e-02f, -1.19846337e-01f, -1.19210467e-01f, -2.36564338e-01f, -1.66085303e-01f, -1.79219037e-01f,
  1.04446068e-01f, -5.17718196e-02f, 4.65489835e-01f, 8.68904218e-02f, 2.71439046e-01f, 4.71676081e-01f, 4.69808251e-01f, 1.22755162e-01f, -8.59999731e-02f, 4.69391942e-02f,
  -3.06976810e-02f, -2.83858180e-01f, -3.38585794e-01f, -2.51444727e-01f, 6.20054873e-03f, 4.80423421e-02f, 3.18001509e-02f, 1.50673002e-01f, 1.52595297e-01f, -3.81805119e-03f,
  -3.80183756e-02f, -6.25173599e-02f, -9.50538963e-02f, -6.97275400e-02f, -1.76163837e-01f, -1.97923958e-01f, 1.15152895e-02f, -3.15101445e-02f, 1.19842775e-01f, -3.05495560e-01f,
  -9.11913067e-02f, 6.28876239e-02f, -7.71822333e-02f, -2.27186218e-01f, 5.20052314e-02f, -3.21028642e-02f, 1.05187185e-01f, -1.22299865e-01f, -1.29566997e-01f, -9.77092013e-02f,
  -2.63370331e-02f, -5.30765131e-02f, 1.17422277e-02f, 7.09660947e-02f, 1.59899518e-02f, 1.81416962e-02f, 4.39889170e-02f, 2.32927371e-02f, -7.43959919e-02f, -6.63832296e-03f,
  -7.04694353e-03f, 1.95981532e-01f, 1.63434625e-01f, 6.25030696e-02f, 3.40624340e-02f, 7.61199445e-02f, 3.79688963e-02f, 2.29435228e-02f, 8.90172496e-02f, -5.17630465e-02f,
  1.33948559e-02f, 1.36382312e-01f, 8.65667984e-02f, -1.31289344e-02f, -2.39722934e-02f, 7.99774099e-03f, -1.00213334e-01f, 8.28688443e-02f, 8.34967270e-02f, 1.56222880e-01f,
  1.09461233e-01f, 9.42641422e-02f, 3.82788703e-02f, 1.11893430e-01f, 8.05683807e-02f, 1.24306157e-01f, 1.15042143e-01f, -1.07024722e-02f, 1.22874580e-01f, -1.83245391e-02f,
  -1.67699847e-02f, 4.14156877e-02f, 8.97899084e-03f, -2.34171143e-03f, 4.63570468e-02f, -6.06143568e-03f, 1.69919543e-02f, 9.07608196e-02f, 1.10377319e-01f, 8.96187648e-02f,
  -1.59183189e-01f, 2.07524687e-01f, -4.88948971e-02f, -1.27594396e-01f, 7.38453446e-03f, -1.82971060e-02f, 3.20022888e-02f, -1.20428562e-01f, -1.62338436e-01f, -1.37777016e-01f,
  2.95475554e-02f, 4.80061620e-02f, 8.24408419e-03f, 6.99850172e-02f, 1.49191171e-01f, 4.64362092e-02f, -1.20191135e-01f, -7.03576894e-04f, -1.38262615e-01f, 5.02165444e-02f,
  8.62702448e-03f, 1.70896932e-01f, 1.45461291e-01f, 5.59387878e-02f, 7.52783939e-02f, 4.15092632e-02f, 9.65090394e-02f, 6.75748661e-02f, 7.64815062e-02f, 3.52764428e-02f,
  -4.36627835e-01f, 1.54369935e-01f, -5.01211762e-01f, -6.18328273e-01f, -3.24696302e-01f, -4.31889445e-02f, 5.61480582e-01f, -1.46115320e-02f, -4.69849586e-01f, -4.71804217e-02f,
  -4.52990364e-03f, -1.83506668e-01f, -3.65032136e-01f, -7.86511600e-02f, 3.34220618e-01f, 1.50242820e-01f, -1.88741669e-01f, -1.75230607e-01f, 1.80718765e-01f, 4.46423620e-01f,
  1.75205469e-01f, -1.33015603e-01f, -1.46774724e-01f, -1.93866149e-01f, -3.44289839e-01f, -1.97544351e-01f, -4.73308265e-01f, -2.56671399e-01f, 1.20199151e-01f, -3.85465413e-01f,
  3.63996960e-02f, -4.79913563e-01f, 1.72939394e-02f, -1.34350941e-01f, 2.12150756e-02f, 1.07488230e-01f, 1.62948564e-01f, -1.68763489e-01f, -1.30453974e-01f, -1.48355877e-02f,
  -1.26143187e-01f, -4.27513272e-02f, -1.81102768e-01f, -5.81581108e-02f, -6.35312721e-02f, -4.98368628e-02f, -7.75418058e-02f, -9.83513966e-02f, -4.60804962e-02f, -1.84554830e-02f,
  2.17677448e-02f, -5.32656983e-02f, -1.29721403e-01f, 1.03780404e-01f, -6.62634373e-02f, -7.42750689e-02f, 7.35708419e-03f, -6.70654029e-02f, -6.96146116e-02f, -3.98119166e-02f,
  3.84280942e-02f, -1.33856356e-01f, -2.14394578e-03f, -1.43718477e-02f, 4.51073050e-02f, -1.85796261e-01f, -2.09746718e-01f, -1.75397787e-02f, 5.22879064e-02f, 4.73491475e-02f,
  5.80974557e-02f, 8.26348141e-02f, 8.20812806e-02f, -1.14947697e-02f, 2.28549354e-02f, -1.65214717e-01f, 1.98791575e-04f, 1.40792221e-01f, 9.23758522e-02f, 8.16116855e-02f,
  4.57572117e-02f, -2.40331385e-02f, -1.28400438e-02f, 1.39425591e-01f, 9.59281577e-04f, 3.42171676e-02f, -3.91613729e-02f, 9.30895060e-02f, 3.18658464e-02f, -1.66198283e-01f,
  2.01650728e-02f, 1.02898598e-01f, -1.10194661e-01f, 7.75410756e-02f, -3.21634337e-02f, -7.12665468e-02f, -1.33362427e-01f, 5.78816608e-02f, -1.87377229e-01f, 3.41766840e-03f,
  6.54528216e-02f, 1.05493423e-02f, -1.47711143e-01f, 4.36051302e-02f, 1.41664416e-01f, -6.22814521e-03f, 2.84393400e-01f, -1.32422537e-01f, 1.17668305e-02f, -6.81799650e-02f,
  7.41523579e-02f, 2.97104359e-01f, 1.32168993e-01f, 1.50315493e-01f, 6.68714568e-02f, 1.24470651e-01f, 1.33197438e-02f, 1.08755022e-01f, 1.39434785e-01f, 4.03539598e-01f,
  6.43091798e-01f, -2.62797344e-02f, 3.93942863e-01f, 1.15226947e-01f, 8.98055211e-02f, 3.29746902e-01f, 2.17662543e-01f, 1.85397372e-01f, 1.54129773e-01f, 1.77138478e-01f,
  1.63476855e-01f, 1.98568981e-02f, 6.45328835e-02f, -6.90553635e-02f, -3.61231826e-02f, -4.11193073e-03f, -6.44845963e-02f, 1.76407710e-01f, 1.49850264e-01f, 1.62878528e-01f,
  -9.15677920e-02f, -1.23152941e-01f, 4.40059565e-02f, -8.89079794e-02f, -2.27547456e-02f, -1.34331286e-01f, -5.55486940e-02f, 7.58235622e-03f, -8.02303851e-02f, -2.05913514e-01f,
  -1.65786847e-01f, 1.72195971e-01f, -7.57032633e-02f, -7.39166662e-02f, -1.15792438e-01f, -1.23511806e-01f, 9.25204307e-02f, 2.66692284e-02f, -1.59149140e-01f, -1.44907862e-01f,
  -1.00890599e-01f, -1.01470888e-01f, 6.72099814e-02f, 7.70554245e-02f, -6.11674152e-02f, 8.12849253e-02f, 7.68034682e-02f, 1.05830811e-01f, -6.22173138e-02f, -5.22294343e-02f,
  -8.28986019e-02f, 1.52648941e-01f, 1.40730083e-01f, 5.31945713e-02f, 6.24856874e-02f, 7.95512050e-02f, 5.33357151e-02f, 2.68719140e-02f, 7.33119026e-02f, 1.60382073e-02f,
  -4.28441688e-02f, 2.57848144e-01f, 1.69537514e-01f, 1.56139493e-01f, 1.53567865e-01f, 1.27361014e-01f, -4.67373990e-02f, -1.00588962e-01f, 4.57134433e-02f, 2.24121343e-02f,
  2.88691744e-02f, 9.58622545e-02f, 9.11462009e-02f, 5.94011657e-02f, 5.84332831e-02f, -1.12110777e-02f, 1.20777814e-02f, 2.29705758e-02f, -5.16018970e-03f, -2.04443149e-02f,
  -2.81333607e-02f, 2.29539201e-02f, 9.88935307e-02f, -2.86107436e-02f, 5.56122512e-02f, 1.22819580e-01f, -8.86107758e-02f, -1.73183717e-03f, -1.29742129e-02f, -1.31839111e-01f,
  -3.53626370e-01f, 2.44097516e-01f, -6.73013180e-02f, -1.75811678e-01f, -4.04590741e-03f, 3.21147181e-02f, -2.48368550e-02f, -1.02905400e-01f, -2.55820215e-01f, -1.09440252e-01f,
  -6.68755993e-02f, 1.39963850e-02f, -3.09355138e-03f, 4.85280529e-04f, -2.84721907e-02f, -2.95198727e-02f, -4.64882962e-02f, 9.81498696e-03f, -1.91398081e-03f, -8.78206417e-02f,
  -6.36042678e-04f, 8.86384994e-02f, 8.70630890e-02f, 1.00471608e-01f, 5.95094673e-02f, 8.31251070e-02f, 7.86619112e-02f, 5.91392964e-02f, 2.75878385e-02f, -9.00878385e-03f,
  4.33026850e-01f, -2.19000116e-01f, -4.58427906e-01f, 2.78037161e-01f, -2.20790774e-01f, -5.12581885e-01f, -6.52056336e-01f, -2.76946306e-01f, 1.88524559e-01f, -3.27922046e-01f,
  -1.55701801e-01f, -1.22069418e-02f, -1.55059531e-01f, -3.16601098e-01f, -4.69482034e-01f, -4.84566718e-01f, -3.51081640e-01f, -4.56827611e-01f, -4.13331509e-01f, -2.67766774e-01f,
  -3.02672058e-01f, -1.99171826e-01f, -9.20439437e-02f, -1.53421685e-01f, 4.76232804e-02f, -1.37022972e-01f, -1.82107419e-01f, -1.19214319e-01f, -3.48207414e-01f, -2.04030812e-01f,
  -2.81862080e-01f, 1.85527399e-01f, -6.47725835e-02f, -1.33451202e-03f, 4.36979486e-03f, 1.05704136e-01f, -4.68640290e-02f, 5.55065684e-02f, 1.32361442e-01f, 2.09751166e-03f,
  1.01562932e-01f, 1.75607558e-02f, 1.15314074e-01f, -1.20470613e-01f, 3.27319540e-02f, -7.11264042e-03f, -6.58009946e-02f, -2.03590430e-02f, -4.89648394e-02f, 2.37885099e-02f,
  -6.18935227e-02f, 1.37661267e-02f, 6.88442737e-02f, -4.65958901e-02f, 1.03233859e-01f, -1.03862859e-01f, -1.47043206e-02f, 1.17661551e-01f, -1.59502253e-01f, 1.59187332e-01f,
  2.37928461e-02f, 1.07773125e-01f, 2.40270495e-02f, -2.00289059e-02f, -4.69477177e-02f, 1.05360493e-01f, -6.24000803e-02f, -1.18003182e-01f, 4.07697596e-02f, -4.82377298e-02f,
  -5.28835580e-02f, -1.43628009e-02f, -6.53823465e-02f, 7.00377300e-02f, -9.02889222e-02f, -1.63141545e-02f, -8.15668106e-02f, -5.45092374e-02f, -3.39772962e-02f, -4.34577353e-02f,
  -2.90622655e-02f, 3.10589764e-02f, 3.87834124e-02f, -4.66361865e-02f, -2.47947630e-02f, -1.71140477e-01f, -6.15961105e-03f, -6.94043711e-02f, -4.74020354e-02f, -1.18606731e-01f,
  9.38545391e-02f, -2.84819961e-01f, 8.46350342e-02f, 2.13277596e-03f, 7.83098191e-02f, -4.50719222e-02f, 1.89936124e-02f, 8.65154248e-03f, 1.13861337e-01f, -3.24575230e-02f,
  -9.42660123e-02f, -2.76872497e-02f, -3.40771414e-02f, 4.12461050e-02f, -1.10509947e-01f, -6.02050275e-02f, -8.65452439e-02f, -3.51950750e-02f, -2.50023436e-02f, 1.14379190e-01f,
  -3.00084031e-03f, -6.95512146e-02f, 2.48724632e-02f, 7.00707138e-02f, 8.83818641e-02f, -8.23539943e-02f, -5.91864921e-02f, 2.26919949e-02f, -2.10621655e-01f, -6.88514486e-02f,
  -7.08474994e-01f, 3.20475362e-02f, -1.97024554e-01f, -2.60061562e-01f, -5.11738956e-02f, 3.07273269e-02f, 4.67473082e-02f, 2.73190528e-01f, 3.23831618e-01f, -7.98331648e-02f,
  -2.06084058e-01f, -9.43584517e-02f, 3.00021134e-02f, -4.50317226e-02f, -1.22703210e-01f, 4.74347621e-02f, 1.12543963e-01f, -2.94971138e-01f, -1.12991437e-01f, 6.46519102e-03f,
  -2.67798547e-02f, -2.38095164e-01f, -3.75291437e-01f, -5.00184037e-02f, -3.78298238e-02f, -2.73650408e-01f, -7.46876821e-02f, -2.02902466e-01f, -2.94436216e-01f, -3.18433702e-01f,
  -2.09401935e-01f, -2.22439051e-01f, 1.50990263e-01f, -1.68061197e-01f, -2.03647409e-02f, -7.47436881e-02f, 1.51480079e-01f, -3.82139087e-02f, 1.67343356e-02f, -6.25502169e-02f,
  -1.50374714e-02f, 3.83728705e-02f, -1.25616968e-01f, 9.61616933e-02f, -1.21894889e-01f, -2.65384346e-01f, 3.31497826e-02f, -2.11354829e-02f, 5.54117747e-02f, 2.16091245e-01f,
  1.12283722e-01f, -3.12429667e-01f, -2.55767465e-01f, 3.20298523e-02f, 2.40395740e-01f, -1.34798542e-01f, -1.06310554e-01f, -1.23153724e-01f, -2.77490795e-01f, -3.19869459e-01f,
  1.48483040e-02f, 2.35618308e-01f, 1.30638704e-01f, 3.32725123e-02f, -7.18597099e-02f, 8.54575336e-02f, 6.53876737e-02f, -6.54541999e-02f, -8.81618336e-02f, -2.57799402e-02f,
  1.76689312e-01f, 1.42536700e-01f, -9.77145135e-02f, -2.12344658e-02f, -8.27802196e-02f, -1.51278563e-02f, -1.83400199e-01f, -8.58118758e-02f, -1.37595624e-01f, -5.58706969e-02f,
  -1.86228808e-02f, -1.73181325e-01f, 1.42971605e-01f, -1.59298943e-04f, -1.96191147e-01f, 7.20048472e-02f, 1.34204865e-01f, -4.31755334e-02f, 1.30966902e-01f, 5.72200567e-02f,
  4.69744429e-02f, -4.29520989e-03f, -1.50297835e-01f, 3.02291848e-02f, 1.62085947e-02f, 1.83954194e-01f, -5.18575311e-02f, -8.86782408e-02f, 4.88962121e-02f, -1.05140895e-01f,
  -5.07130846e-02f, -1.10027529e-01f, -1.26784723e-02f, 1.51710406e-01f, -1.15942560e-01f, -3.09208389e-02f, -1.02139510e-01f, -3.55346859e-01f, 3.64308171e-02f, 1.26609236e-01f,
  -1.55688003e-02f, -2.88886428e-01f, -5.51478028e-01f, -2.78925896e-01f, 1.44317552e-01f, -4.60736990e-01f, -3.13808471e-01f, -3.23432952e-01f, -3.48934442e-01f, -4.50621575e-01f,
  8.35502088e-01f, -5.61663061e-02f, -9.80301574e-02f, 1.16103813e-01f, -1.61782444e-01f, -2.38984004e-01f, -2.82341659e-01f, -5.52316830e-02f, -2.96525136e-02f, 8.82853717e-02f,
  8.93007126e-03f, 2.37352014e-01f, 1.99901074e-01f, 7.89386407e-02f, 2.38640189e-01f, -1.38219550e-01f, 9.09066666e-03f, 2.87335008e-01f, 1.43397227e-01f, -9.41761583e-02f,
  -1.93098392e-02f, 2.55387481e-02f, 3.29102427e-01f, 1.08750276e-01f, -1.10285759e-01f, 3.62947509e-02f, -4.02200185e-02f, -1.23988263e-01f, -1.24098703e-01f, 6.26626387e-02f,
  2.08156137e-03f, 1.22685596e-01f, 7.96126872e-02f, 1.98194265e-01f, -1.77339651e-02f, 2.29891352e-02f, 1.07389301e-01f, -7.47691542e-02f, 3.26563939e-02f, -7.91711137e-02f,
  -8.63527358e-02f, -3.35480981e-02f, -3.91245931e-02f, -1.10373393e-01f, -9.52283889e-02f, -6.15823604e-02f, -5.12189828e-02f, 3.92085649e-02f, 6.11287393e-02f, 8.01813081e-02f,
  1.42812086e-02f, 1.61532890e-02f, -3.80914845e-02f, -9.17093307e-02f, -1.06658921e-01f, 1.67883962e-01f, -8.86743441e-02f, -3.64211276e-02f, 5.45342304e-02f, -3.22683342e-03f,
  1.87620893e-01f, 2.20545352e-01f, 1.20660156e-01f, -3.40492129e-02f, -4.41948697e-02f, -5.84569760e-03f, -4.17318149e-03f, -6.80482388e-02f, 5.87612353e-02f, 7.73544535e-02f,
  -9.06551331e-02f, 1.47183686e-01f, -6.20317366e-03f, 8.23424980e-02f, 4.09992710e-02f, 1.63002208e-01f, 5.16877733e-02f, -4.07156684e-02f, 3.59533802e-02f, 1.26029015e-01f,
  1.84464127e-01f, -2.65964624e-02f, 1.18522376e-01f, 8.80516693e-02f, 1.27395093e-01f, 4.95581329e-02f, 7.64812157e-02f, 4.44738455e-02f, 5.00683412e-02f, 9.47381780e-02f,
  -2.72002339e-01f, -1.30487867e-02f, -6.48861378e-03f, 5.74580990e-02f, 1.07147999e-03f, -1.07065812e-01f, -7.21261697e-03f, -1.96147650e-01f, -1.52638167e-01f, 8.24413844e-04f,
  -8.08448642e-02f, -5.51241040e-02f, 2.58249752e-02f, 1.67866219e-02f, 6.89606369e-02f, 2.35141050e-02f, 8.92387182e-02f, 3.41827944e-02f, -4.14875988e-03f, -7.07952604e-02f,
  1.00978566e-02f, 4.45125252e-02f, 1.49822623e-01f, -5.08101983e-03f, -4.87347730e-02f, 7.43899345e-02f, -1.15633309e-01f, -1.44025445e-01f, 3.71748731e-02f, -1.29517820e-02f,
  -7.70811558e-01f, 3.77402723e-01f, 4.28732842e-01f, -1.61105230e-01f, 3.69585484e-01f, 2.48480707e-01f, 1.26589000e-01f, -1.05852149e-01f, -8.34695920e-02f, 1.28379449e-01f,
  3.16033781e-01f, 8.90788734e-02f, 2.34206468e-01f, 6.91928864e-02f, -5.46849817e-02f, 2.81791061e-01f, 3.63137543e-01f, -3.35976183e-02f, -5.61690927e-01f, -4.98441070e-01f,
  2.54792739e-02f, -4.01124865e-01f, -5.30570984e-01f, -2.62244374e-01f, 2.50942022e-01f, 1.14317052e-01f, 2.44499713e-01f, -1.02727031e-02f, 2.80549109e-01f, 2.32294485e-01f,
  1.61313117e-01f, -3.33708286e-01f, -7.45786354e-02f, -1.26699090e-01f, 2.31015295e-01f, -2.84831971e-01f, -4.16613445e-02f, -1.77476898e-01f, -2.98747160e-02f, -3.82456183e-02f,
  5.73543739e-03f, -1.51818618e-01f, 1.28145367e-01f, -2.06064936e-02f, -1.31570071e-01f, -1.24999523e-01f, -1.68968812e-01f, -3.28447968e-01f, -2.14858145e-01f, -1.08821675e-01f,
  1.35135725e-01f, -2.73028553e-01f, 4.49252352e-02f, 6.58853492e-03f, -1.26179317e-02f, -7.23628849e-02f, -1.13628484e-01f, -4.31320190e-01f, -4.40939605e-01f, -3.59756887e-01f,
  -5.27606457e-02f, 3.90819944e-02f, 2.51126867e-02f, -7.37775862e-02f, -1.30821779e-01f, 1.53152913e-01f, 1.81517318e-01f, 3.55265774e-02f, -1.78746898e-02f, -5.48974727e-04f,
  2.07518682e-01f, 1.30278431e-02f, -4.76951487e-02f, 3.18893157e-02f, -4.10619974e-02f, -1.35472506e-01f, -5.72622679e-02f, -1.33171469e-01f, -5.43264560e-02f, -7.59603381e-02f,
  -1.31870732e-01f, 1.86253898e-02f, -1.37645733e-02f, -5.44166453e-02f, 1.69289500e-01f, -4.20871414e-02f, -7.50202462e-02f, -1.08348675e-01f, -3.69800627e-02f, -6.13753684e-02f,
  -1.48051158e-01f, 3.11839841e-02f, 6.63267821e-02f, -4.27145399e-02f, 1.28956243e-01f, 2.01347351e-01f, -1.50411874e-02f, 5.43244556e-02f, 2.01530129e-01f, -8.00599623e-03f,
  -1.25836298e-01f, -6.11106902e-02f, 1.07067183e-01f, -8.37405697e-02f, -1.58368409e-01f, 1.82333589e-02f, 6.43545762e-02f, 8.32782388e-02f, -3.47563885e-02f, 2.45805886e-02f,
  1.21492803e-01f, -3.31711739e-01f, -2.85370320e-01f, 6.83191791e-02f, -1.37134254e-01f, -3.04587364e-01f, -6.68029264e-02f, -3.02377015e-01f, -2.05482677e-01f, -3.59199315e-01f,
  -4.40166473e-01f, -1.29774034e-01f, -6.46568313e-02f, 1.19031757e-01f, 2.90649563e-01f, 2.58404076e-01f, 2.47536987e-01f, 2.18307033e-01f, 8.80545080e-02f, 1.06284976e-01f,
  -4.02674265e-02f, 7.78466016e-02f, 2.76856981e-02f, 4.49180864e-02f, 8.99260864e-02f, 2.46315658e-01f, 3.03366959e-01f, 7.42251202e-02f, 4.85217236e-02f, 5.87118454e-02f,
  4.47797924e-02f, -9.37779769e-02f, -1.46164924e-01f, 2.08934094e-03f, 8.81314725e-02f, 4.27761674e-02f, 1.32200763e-01f, 1.01900168e-01f, 1.03566572e-01f, 1.14533402e-01f,
  1.18079066e-01f, 3.87837850e-02f, 9.83258560e-02f, 9.21233147e-02f, 9.64256376e-02f, -6.17283694e-02f, 2.95265242e-02f, -1.65097173e-02f, -8.91632065e-02f, 1.24541536e-01f,
  5.08058928e-02f, 4.79941703e-02f, 9.36200917e-02f, -2.52098590e-02f, 1.01210751e-01f, -3.88212390e-02f, 1.01308543e-02f, 2.57380381e-02f, 1.40268087e-01f, 1.57038257e-01f,
  9.88003016e-02f, 1.21734239e-01f, 1.99190170e-01f, 8.31169337e-02f, 1.91457078e-01f, 1.40479237e-01f, -1.26028406e-02f, 1.87700782e-02f, 1.57192707e-01f, 2.86453012e-02f,
  1.46440789e-01f, -8.14856067e-02f, 1.29800528e-01f, 1.20312095e-01f, 5.40568382e-02f, -5.88042103e-02f, 6.04795516e-02f, 1.03729188e-01f, 1.38942137e-01f, -1.91288125e-02f,
  5.90659603e-02f, 1.62256598e-01f, 1.49458706e-01f, -4.64831851e-02f, -1.17993373e-02f, 2.02454086e-02f, -1.15896195e-01f, 2.80460273e-03f, 1.09786011e-01f, 6.12426847e-02f,
  1.84293658e-01f, 7.70533383e-02f, 1.80911943e-02f, 7.19296634e-02f, -3.22504640e-02f, 1.36163831e-01f, 9.81187299e-02f, 9.29900035e-02f, -5.03146313e-02f, -9.26495418e-02f,
  3.31213862e-01f, 4.32083637e-01f, 4.14663218e-02f, -6.47055060e-02f, -8.78199860e-02f, -2.35608578e-01f, 1.08150383e-02f, -1.03390783e-01f, -1.54624486e-05f, 8.54411870e-02f,
  -4.26441319e-02f, -1.26994047e-02f, 3.16875316e-02f, 3.55304256e-02f, -3.13861035e-02f, 1.40702827e-02f, -1.28362030e-01f, -5.78910969e-02f, 8.66274983e-02f, 1.11650661e-01f,
  -5.98679595e-02f, 2.16158759e-02f, 6.58247620e-02f, -5.73710017e-02f, 8.20505843e-02f, -1.40342861e-02f, -7.58770257e-02f, -3.85726569e-03f, -7.15522245e-02f, -1.07213892e-01f,
  2.43893608e-01f, -1.48947001e-01f, 7.70828426e-02f, 4.08222437e-01f, 3.05802971e-01f, 2.88063049e-01f, 2.28880182e-01f, 2.21169531e-01f, 2.72792071e-01f, 2.03891560e-01f,
  9.17066634e-02f, 1.33517176e-01f, 2.54101545e-01f, 1.19662181e-01f, 1.26844019e-01f, 1.38702512e-01f, 1.01464927e-01f, 8.87149386e-03f, 6.85288459e-02f, 1.60116628e-02f,
  9.38789845e-02f, 1.99100599e-02f, -1.70933634e-01f, -4.70677689e-02f, -2.43142582e-02f, 1.03080280e-01f, -1.23280108e-01f, -2.25053709e-02f, 5.40071093e-02f, -1.03033952e-01f,
  -6.74916729e-02f, -2.22404823e-01f, -3.31294425e-02f, -5.75897694e-02f, -7.09454641e-02f, -1.77514136e-01f, -1.75856836e-02f, -7.39874169e-02f, -1.12632677e-01f, -5.16254082e-03f,
  -1.56683892e-01f, -1.74946547e-01f, -1.09320909e-01f, -9.54282060e-02f, -2.41143033e-01f, -1.16389304e-01f, -2.22538128e-01f, -1.41403407e-01f, 2.73036510e-02f, -1.33370265e-01f,
  -4.66788411e-02f, -2.42006946e-02f, -1.42641857e-01f, -1.00059144e-01f, -6.18243553e-02f, 6.16602786e-02f, -5.81640489e-02f, -1.44069344e-01f, -1.28636599e-01f, -9.83394235e-02f,
  6.19246252e-02f, -1.33682415e-01f, 3.64382900e-02f, -5.74798845e-02f, -9.66103096e-03f, 2.98065282e-02f, 8.02536383e-02f, 4.25310731e-02f, 5.02638258e-02f, -1.36236817e-01f,
  -1.56835973e-01f, 9.66046471e-03f, 3.59590687e-02f, -1.18071176e-01f, 8.48592818e-02f, -5.34746237e-02f, -1.98099166e-02f, -8.16632137e-02f, -3.77127826e-02f, -6.01067171e-02f,
  5.80027886e-02f, -6.47830144e-02f, -1.40395194e-01f, -1.83653548e-01f, -1.15011968e-01f, -1.20493107e-01f, 3.32599394e-02f, -9.20976996e-02f, -1.90966114e-01f, -2.35942155e-01f,
  -7.29851574e-02f, 1.24528676e-01f, 8.01652893e-02f, -8.45246166e-02f, -3.00366357e-02f, -6.73651099e-02f, 1.76816031e-01f, -5.75054958e-02f, 9.90398461e-04f, 6.58715442e-02f,
  -1.43199369e-01f, -2.68854219e-02f, -3.71373221e-02f, -1.41741514e-01f, -1.04079477e-01f, -2.86136679e-02f, -4.21591811e-02f, 1.09056532e-01f, -1.43856378e-02f, -5.85067831e-02f,
  -1.29444480e-01f, 1.46592855e-01f, 1.62175342e-01f, 1.25673395e-02f, 1.24609470e-01f, 1.09004840e-01f, -5.19515574e-02f, -1.36283890e-03f, 1.34366989e-01f, 7.73580819e-02f,
  5.47952242e-02f, -1.99049503e-01f, -5.84272921e-01f, -4.49562490e-01f, -4.86704201e-01f, -2.61296451e-01f, -1.34889245e-01f, -1.80785246e-02f, -2.57278949e-01f, -2.00673059e-01f,
  2.53824294e-01f, 5.12725115e-01f, 4.64689076e-01f, 3.97272646e-01f, 6.73875272e-01f, -2.31115833e-01f, -4.32339400e-01f, 7.22229108e-02f, 4.29391354e-01f, 2.47657105e-01f,
  7.34685585e-02f, -4.95378152e-02f, -2.84413993e-03f, 5.32115018e-03f, -3.65101367e-01f, -6.19715862e-02f, -5.00510275e-01f, -2.74234831e-01f, -1.49551839e-01f, -5.57675958e-01f,
  -9.96660069e-03f, -3.65463614e-01f, 1.17677815e-01f, 1.31414175e-01f, -1.62273929e-01f, -4.93442453e-02f, -9.28870961e-02f, -2.31023744e-01f, -9.73252580e-02f, -1.42447188e-01f,
  -2.25386083e-01f, 4.11791988e-02f, -1.17088156e-02f, -2.03898355e-01f, -1.70177683e-01f, -7.38688186e-02f, -2.15233102e-01f, -3.48020345e-02f, -8.71410891e-02f, -2.44871117e-02f,
  1.66037306e-02f, -5.97871989e-02f, -8.10511410e-02f, -4.62438166e-02f, -3.17497998e-02f, 1.06045045e-01f, -1.10729165e-01f, -1.13162085e-01f, -1.83804967e-02f, -2.97241956e-01f,
  -2.94701178e-02f, 6.70101494e-02f, 2.92142872e-02f, -1.05879776e-01f, 1.11794718e-01f, 1.13806836e-01f, 8.39965045e-03f, 1.13353794e-02f, 1.11618258e-01f, 9.98477787e-02f,
  -9.22498852e-02f, -2.09019147e-02f, 5.25393523e-02f, -2.49855723e-02f, 4.36916873e-02f, 4.61485572e-02f, 5.67354336e-02f, 1.13484003e-01f, 1.61537424e-01f, -5.69794327e-02f,
  1.66088734e-02f, -3.84155400e-02f, -4.88104112e-02f, 9.86959934e-02f, 4.65281196e-02f, 3.87556143e-02f, -1.76670812e-02f, 1.40048504e-01f, 4.99667265e-02f, 2.35980819e-03f,
  2.88152933e-01f, 3.40634733e-01f, 4.72910888e-02f, 1.08852029e-01f, -1.37823820e-01f, -8.76315162e-02f, -4.65536043e-02f, -1.36797488e-01f, -1.65375009e-01f, -7.54557271e-03f,
  5.56847937e-02f, 2.01437220e-01f, 4.69805375e-02f, -3.94497886e-02f, 6.86451718e-02f, -5.62933050e-02f, 1.65535405e-01f, 1.16158172e-01f, 1.75669715e-01f, -2.14786511e-02f,
  2.43545026e-02f, 9.25264284e-02f, 1.78925589e-01f, 1.17909640e-01f, -5.70682138e-02f, 1.47235766e-01f, 1.04394764e-01f, 1.65912211e-01f, 3.14007133e-01f, 9.84101966e-02f,
  5.60045600e-01f, -4.13593762e-02f, -3.41794163e-01f, 2.98379868e-01f, 1.71627160e-02f, -2.82139275e-02f, 2.06587195e-01f, 2.07899958e-01f, 3.47572684e-01f, 2.69354582e-01f,
  1.55225724e-01f, 1.82513118e-01f, 1.04488887e-01f, 3.19786184e-02f, 1.24595635e-01f, 8.15467089e-02f, 1.61393490e-02f, -8.08909312e-02f, -2.01312359e-02f, 3.70366802e-03f,
  9.68212932e-02f, 9.16889533e-02f, -7.76622444e-02f, -4.43748385e-02f, -9.78834629e-02f, 1.08122997e-01f, -1.19627900e-01f, -9.42477733e-02f, -2.11709410e-01f, -1.63614362e-01f,
  -4.36771631e-01f, -2.37401232e-01f, 5.85978292e-02f, 1.10538699e-01f, -1.73423827e-01f, 6.49508759e-02f, 1.47999758e-02f, -7.05362707e-02f, 3.37694436e-02f, 1.16161980e-01f,
  -1.44280821e-01f, -6.16897717e-02f, -6.42174184e-02f, -1.39825836e-01f, -5.60203940e-02f, -3.35349760e-05f, -9.90927685e-03f, -1.01102583e-01f, -1.50098115e-01f, -1.14062592e-01f,
  -6.98044226e-02f, -1.43871084e-01f, -1.44673526e-01f, 7.85368681e-02f, 4.44381982e-02f, -5.05285859e-02f, -9.35566500e-02f, -9.33678821e-02f, -1.18313923e-01f, 1.15835667e-01f,
  1.00531287e-01f, -3.30920555e-02f, -1.02321021e-01f, 3.08128223e-02f, 6.54266477e-02f, -3.74959670e-02f, 1.47439586e-03f, -3.03641092e-02f, 5.41907027e-02f, -1.87060405e-02f,
  -3.63918096e-02f, 1.96928568e-02f, -6.41860394e-03f, 7.02692792e-02f, 4.18119989e-02f, -9.75000411e-02f, -2.30584685e-02f, -3.29139531e-02f, -1.16671681e-01f, 1.17126284e-02f,
  -4.64979149e-02f, -7.40165040e-02f, 7.85690323e-02f, 1.53634427e-02f, 7.80953169e-02f, 6.99521899e-02f, 1.51144221e-01f, 1.07995095e-02f, 7.51695335e-02f, -1.36584761e-02f,
  1.94639623e-01f, -2.41319053e-02f, 6.00432046e-03f, -1.80109233e-01f, -2.21113831e-01f, -2.66031232e-02f, 9.50113405e-04f, -1.36868730e-01f, -4.79374081e-02f, -4.71330620e-03f,
  -5.04485965e-02f, 2.77740434e-02f, -8.75921920e-02f, 7.46613517e-02f, 4.01939452e-02f, 3.10927741e-02f, -5.00657807e-05f, -1.83287996e-03f, -5.41472994e-02f, -9.00143944e-03f,
  8.94858465e-02f, 8.19578543e-02f, 4.68211435e-02f, 2.07652692e-02f, -3.99342515e-02f, 1.38995871e-01f, 7.17572719e-02f, 5.66777773e-02f, 4.60993201e-02f, 2.50234127e-01f,
  4.81251925e-01f, -4.32794482e-01f, -5.99036038e-01f, 3.65939200e-01f, 7.22553432e-02f, 2.55104247e-02f, 6.46950081e-02f, 3.56531650e-01f, 4.40329075e-01f, -3.51567566e-02f,
  -3.27809095e-01f, -3.19579273e-01f, -3.36762190e-01f, -3.39582950e-01f, -2.20212400e-01f, -1.39791787e-01f, -2.42083251e-01f, -3.55392903e-01f, -4.87039089e-02f, 2.26950631e-01f,
  1.84775025e-01f, 3.58464062e-01f, 3.42069447e-01f, 1.99930295e-01f, 1.41996490e-02f, -1.17710221e-03f, -1.19286485e-01f, -1.85825434e-02f, -2.16075480e-01f, -4.83940721e-01f,
  -2.74985492e-01f, -5.22902906e-02f, -1.76022127e-01f, -2.98582874e-02f, -7.26286024e-02f, 1.52645838e-02f, -8.96973759e-02f, -9.23975408e-02f, -2.74933815e-01f, -2.33100906e-01f,
  -4.57841903e-01f, -2.03213766e-01f, -4.03995037e-01f, -1.07820399e-01f, -9.86056030e-03f, 7.55834505e-02f, 6.65246509e-03f, -1.98199287e-01f, -1.27334520e-01f, -8.79737586e-02f,
  -2.53793091e-01f, -2.26052269e-01f, -8.79075155e-02f, -7.18545839e-02f, -5.11036441e-03f, -1.61853388e-01f, -2.21767351e-01f, -1.15066811e-01f, -1.50657266e-01f, 1.81667998e-01f,
  -7.12060779e-02f, -4.06044535e-02f, 9.64354351e-02f, 1.60240725e-01f, 7.71127269e-02f, -1.54643897e-02f, 3.66318896e-02f, -3.68561246e-03f, 2.18960270e-02f, 2.68483255e-02f,
  -9.83100533e-02f, -4.83986251e-02f, 7.78545365e-02f, 3.48988324e-02f, -1.08007997e-01f, -6.54968992e-02f, -1.37077317e-01f, -2.81664450e-02f, -9.64365620e-03f, 1.08755566e-01f,
  1.01124115e-01f, -4.18100655e-02f, -4.60684067e-03f, -1.05865300e-02f, -2.95518227e-02f, -6.13385290e-02f, 5.45443632e-02f, -9.65867564e-02f, -1.30987421e-01f, 9.93298292e-02f,
  3.91862363e-01f, -2.71184117e-01f, 9.16866511e-02f, 4.90594059e-02f, 4.13875319e-02f, -1.69568986e-01f, -6.12402223e-02f, 1.83484972e-01f, -7.83615336e-02f, -1.78406924e-01f,
  -2.68090427e-01f, -2.40990743e-01f, -2.00425833e-01f, -5.82781285e-02f, 1.48791462e-01f, 6.89752251e-02f, 1.02117926e-01f, 1.50561826e-02f, -1.02468999e-02f, 1.00530408e-01f,
  1.22792326e-01f, 2.79819638e-01f, 3.18293750e-01f, 6.47497624e-02f, 2.03223616e-01f, 1.67950854e-01f, 1.50944129e-01f, 1.10993236e-01f, 7.00330511e-02f, 4.91342366e-01f,
  4.74576503e-01f, 3.35973054e-01f, 2.74009049e-01f, 3.52248877e-01f, 1.50226727e-01f, 2.07507536e-01f, 3.49220604e-01f, 2.62079924e-01f, 7.30753392e-02f, 2.07336500e-01f,
  2.68110894e-02f, 1.11086674e-01f, 2.58734953e-02f, 1.69701651e-01f, 1.68489769e-01f, 2.07075238e-01f, 7.78009966e-02f, 2.99133062e-02f, 6.87299594e-02f, 4.28310968e-03f,
  8.13746378e-02f, 7.13144839e-02f, 3.72070558e-02f, 1.20731533e-01f, 4.81464230e-02f, 5.09404801e-02f, 4.14791703e-02f, 1.17867813e-02f, 1.61343478e-02f, 1.98754445e-01f,
  -4.89957072e-02f, 1.45733759e-01f, -1.78704470e-01f, -2.39962488e-01f, -4.88905460e-02f, -2.66819969e-02f, -1.23168947e-02f, -8.00854340e-02f, -4.55174074e-02f, -2.68654320e-02f,
  -6.61449954e-02f, -1.25431135e-01f, -1.01088069e-01f, -5.67054711e-02f, -5.39541133e-02f, -1.56121910e-01f, -3.04487981e-02f, -7.68139306e-03f, -4.06570453e-03f, -7.88392201e-02f,
  -6.29747882e-02f, -2.66015157e-02f, -9.59295556e-02f, 3.46619599e-02f, 3.58018130e-02f, -9.13713574e-02f, -5.49323596e-02f, -4.46956195e-02f, 2.41130311e-02f, -5.27830794e-02f,
  8.60492326e-03f, 6.20439611e-02f, 1.03135416e-02f, 1.59397662e-01f, 1.62888896e-02f, 2.77327523e-02f, -4.18733135e-02f, 5.09136505e-02f, -3.46816480e-02f, -2.17677504e-02f,
  -1.18274599e-01f, 2.71637365e-02f, 7.60002583e-02f, -1.84966829e-02f, -6.94680735e-02f, 2.75026504e-02f, 7.00655803e-02f, -3.17439949e-03f, -3.18483710e-02f, -4.26285751e-02f,
  2.18681078e-02f, -1.27132148e-01f, -3.59856561e-02f, -8.94985199e-02f, -5.18646091e-02f, -6.80501759e-03f, -6.56285957e-02f, -4.40830067e-02f, -5.24470508e-02f, -1.63774595e-01f,
  -3.14718157e-01f, -1.82020709e-01f, 1.42934611e-02f, -1.57300103e-02f, -6.12037368e-02f, -8.28372464e-02f, 4.99260984e-02f, -7.17002377e-02f, -1.06025385e-02f, -5.27029410e-02f,
  -6.44644350e-02f, -9.69081372e-03f, -1.61041077e-02f, -3.36278486e-03f, -9.42015648e-02f, -1.17592357e-01f, -1.23875856e-03f, 1.60331577e-02f, -1.30614471e-02f, 1.77062617e-03f,
  -9.42389742e-02f, -1.23531055e-02f, -6.07668050e-03f, 3.15287486e-02f, -2.16401201e-02f, -1.25015035e-01f, -4.83646011e-03f, -1.11985050e-01f, -7.00305402e-02f, -8.76097828e-02f,
  4.47082251e-01f, -2.93190420e-01f, -6.54978901e-02f, 1.46063447e-01f, 9.29658189e-02f, 9.12177935e-02f, -6.86852634e-03f, 6.20957278e-02f, 2.47716904e-01f, 4.66412865e-02f,
  -4.98926379e-02f, 1.25642195e-01f, 1.18155383e-01f, 5.91326877e-02f, 1.84687823e-01f, 1.21821292e-01f, 1.53939068e-01f, 2.09090903e-01f, 2.37363204e-01f, -5.69904074e-02f,
  -8.88849497e-02f, 1.07229473e-02f, -4.41968217e-02f, 1.07719284e-03f, -8.01426396e-02f, 5.71280122e-02f, -4.45040762e-02f, -2.59130836e-01f, -2.06632197e-01f, -7.90667981e-02f,
  -2.53400624e-01f, -3.66865583e-02f, 9.75952521e-02f, -9.48289558e-02f, -1.86302647e-01f, -4.09763306e-02f, 7.03510968e-03f, -4.82753068e-02f, -1.55772477e-01f, -1.50844514e-01f,
  -1.30363390e-01f, 3.76556371e-03f, -1.24105895e-02f, -3.23375724e-02f, -1.14515729e-01f, -6.51413649e-02f, -6.46308437e-02f, -1.03501398e-02f, 6.04481287e-02f, -4.57001179e-02f,
  -1.35635808e-01f, -5.35065420e-02f, 4.25245315e-02f, 5.27057312e-02f, 9.62869376e-02f, 2.73071863e-02f, -2.67762244e-02f, -1.00694023e-01f, 1.22497119e-02f, 4.89747152e-02f,
  9.96348634e-03f, 7.38400444e-02f, 7.98995607e-03f, 4.94436771e-02f, 1.64479688e-01f, 8.71070474e-02f, 1.29984200e-01f, 8.55252054e-03f, 2.14732647e-01f, 1.05309570e-02f,
  7.20797107e-02f, 1.79856375e-01f, 3.26670408e-02f, 7.80501664e-02f, 1.05371602e-01f, -1.13945790e-01f, 2.82365046e-02f, -8.00222997e-03f, -2.54710275e-03f, -6.18088357e-02f,
  2.02332940e-02f, 6.78429613e-03f, -2.58654624e-01f, -7.22754821e-02f, -1.31188497e-01f, -2.96646897e-02f, -3.81227098e-02f, -1.23774484e-01f, 2.05895938e-02f, -3.62805948e-02f,
  -5.02019189e-02f, 2.12598249e-01f, 1.89091578e-01f, 8.48581493e-02f, 4.66916198e-03f, -2.00699985e-01f, 4.74461354e-02f, -1.25178248e-01f, -2.13733673e-01f, -1.26038224e-01f,
  -1.52335659e-01f, 1.82615668e-02f, -1.01971723e-01f, -3.46345231e-02f, 1.40635163e-01f, 1.56735212e-01f, -5.74983135e-02f, 1.46905541e-01f, -9.31212958e-03f, -1.18249007e-01f,
  9.16334335e-03f, 5.07697761e-02f, 2.45809555e-01f, 2.69705385e-01f, 1.77265301e-01f, 2.30413079e-01f, 6.44825920e-02f, 6.85528070e-02f, 1.06774315e-01f, 1.95015341e-01f,
  3.55225950e-01f, -3.78523394e-02f, 3.99293572e-01f, -2.88172904e-02f, -2.17502654e-01f, -1.49740607e-01f, -1.38371825e-01f, -6.59892634e-02f, -2.16010585e-01f, -2.26310894e-01f,
  -2.55419284e-01f, -3.19172621e-01f, -7.18431845e-02f, -6.05107634e-04f, 2.39484131e-01f, 8.09276029e-02f, 6.35959208e-02f, 4.99620765e-01f, 3.80113810e-01f, 5.76487482e-02f,
  -2.60099024e-01f, 8.88356790e-02f, 2.70303816e-01f, 1.66390106e-01f, -1.77866489e-01f, -1.12456098e-01f, 1.44105121e-01f, 6.81797490e-02f, -1.71119254e-02f, -1.60066098e-01f,
  1.04964167e-01f, 4.49216366e-01f, 5.90672046e-02f, -1.61906227e-01f, -2.23501865e-02f, 1.01920478e-01f, 6.31336272e-02f, 4.08182219e-02f, -7.42945597e-02f, 8.60538036e-02f,
  3.34450528e-02f, 2.88047213e-02f, 7.89724141e-02f, -3.77863902e-03f, 1.54510170e-01f, 3.37194838e-02f, 1.37082979e-01f, 2.06874728e-01f, 1.03485331e-01f, -3.01716644e-02f,
  -1.31531641e-01f, -2.57049017e-02f, 1.85003236e-01f, 1.35904059e-01f, 2.09993452e-01f, 7.26972893e-02f, 6.58108220e-02f, 8.69440585e-02f, 1.76894918e-01f, 3.14560607e-02f,
  8.80868137e-02f, -1.08471788e-01f, -7.39955856e-03f, 1.37146980e-01f, 4.29470502e-02f, -6.92878589e-02f, -4.67264801e-02f, -3.08237933e-02f, 2.10155308e-01f, 1.69934303e-01f,
  1.20619051e-01f, -1.57924499e-02f, -1.99254956e-02f, 3.16583901e-03f, 1.70767337e-01f, 5.33199310e-02f, 4.52399775e-02f, -1.05978347e-01f, 6.89337924e-02f, -1.36204241e-02f,
  1.82175919e-01f, 4.78638746e-02f, 1.10244803e-01f, 1.54370517e-01f, 4.88512218e-02f, 1.50329649e-01f, 6.62078708e-02f, -7.49526247e-02f, 4.27356660e-02f, 1.23378381e-01f,
  -2.03049377e-01f, 3.92906994e-01f, -1.65504485e-01f, -8.84585083e-02f, -1.34562552e-01f, 8.44745636e-02f, -3.23331021e-02f, -1.88304931e-01f, -1.31517321e-01f, -1.00160234e-01f,
  -8.69333893e-02f, 1.89274967e-01f, 1.56272814e-01f, 9.11879316e-02f, 7.25563020e-02f, 7.22583085e-02f, -1.59583673e-01f, 8.80144257e-03f, 1.21607317e-03f, 7.04158619e-02f,
  -1.25447497e-01f, -1.63490728e-01f, -1.06928997e-01f, -7.02164993e-02f, -1.46644428e-01f, -5.44306152e-02f, -7.42687657e-02f, -1.15034752e-01f, 9.16156247e-02f, -2.24539012e-01f,
  -4.83852595e-01f, -4.25573885e-01f, -4.47422601e-02f, -7.70139694e-01f, -3.47152978e-01f, 1.42415753e-02f, -2.91779265e-02f, -1.31964430e-01f, -5.07117689e-01f, -5.12206733e-01f,
  -6.85639959e-03f, 4.58584249e-01f, 3.56358066e-02f, 2.86031932e-01f, 5.03595233e-01f, -3.40400279e-01f, -3.21443856e-01f, 1.99556202e-01f, 8.12821925e-01f, 4.46985751e-01f,
  4.39380156e-03f, -1.10032231e-01f, 1.18197933e-01f, 4.98696975e-02f, -5.02944291e-01f, -1.73438247e-02f, -3.42638850e-01f, -2.77020425e-01f, -8.03557113e-02f, -5.21788895e-01f,
  1.69873387e-01f, -2.70401865e-01f, 2.71639585e-01f, 9.59895849e-02f, -1.64088041e-01f, 1.06439777e-02f, -1.24101648e-02f, -2.43731201e-01f, 1.48054035e-02f, -2.17657208e-01f,
  -2.17396736e-01f, 1.10464446e-01f, 1.00766309e-02f, -2.04998092e-03f, -1.74183816e-01f, 8.96334201e-02f, -1.12260677e-01f, 7.52949119e-02f, -9.48570147e-02f, 8.15543085e-02f,
  -5.03511466e-02f, -1.19255848e-01f, 4.21132892e-02f, -2.84835920e-02f, 2.96895597e-02f, 1.45042762e-01f, 2.29404777e-01f, 2.65591979e-01f, 1.43987224e-01f, -5.19138694e-01f,
  -8.73446465e-02f, -5.21353520e-02f, -1.29066138e-02f, 1.01082623e-01f, -3.13958409e-03f, 9.70005020e-02f, -1.39971420e-01f, -9.36571136e-03f, 5.99901676e-02f, 1.74084641e-02f,
  5.47676645e-02f, -7.21332878e-02f, 1.58091575e-01f, -2.73131020e-02f, 1.11170048e-02f, 2.78515089e-02f, 2.35058721e-02f, -9.24347192e-02f, -1.42116934e-01f, -5.83677329e-02f,
  8.24375674e-02f, -4.34218235e-02f, -6.47688136e-02f, -2.29162909e-02f, -4.79415171e-02f, -6.71849996e-02f, -1.78782002e-03f, 1.18747495e-01f, -8.09182599e-02f, -1.90349463e-02f,
  -9.30622891e-02f, 2.12724626e-01f, -3.87519747e-01f, 7.52713010e-02f, -1.51708290e-01f, 4.69808206e-02f, -1.68206021e-01f, 9.97833535e-02f, -1.45424664e-01f, 9.12578851e-02f,
  8.00611302e-02f, 1.48865217e-02f, -8.55906606e-02f, 2.86154095e-02f, -1.80605683e-04f, 1.01129510e-01f, -7.48450160e-02f, -3.43602747e-02f, 1.21304475e-01f, 1.28434658e-01f,
  -2.15604231e-01f, -1.04632154e-02f, 5.36293723e-02f, 1.90734547e-02f, 7.08560422e-02f, 1.80983871e-01f, 1.67811468e-01f, 2.91620106e-01f, 1.10200822e-01f, -4.22788322e-01f,
  -2.49076322e-01f, 3.28593701e-01f, -5.67203343e-01f, -4.26252425e-01f, -5.95796943e-01f, -4.88609016e-01f, 1.65081352e-01f, -2.34330818e-01f, -4.93268251e-01f, 1.31372198e-01f,
  4.12476100e-02f, 8.36853534e-02f, 8.26373994e-02f, 2.06677273e-01f, 4.16018933e-01f, 5.15376806e-01f, -1.97304729e-02f, -1.15878761e-01f, -2.28930637e-01f, -2.52132684e-01f,
  -7.24012032e-02f, -1.07850410e-01f, -9.98800546e-02f, -1.83208600e-01f, -1.75270975e-01f, -1.24753766e-01f, -3.05628091e-01f, -2.60464787e-01f, -1.68113440e-01f, -1.45093977e-01f,
  5.55520594e-01f, -3.84154975e-01f, -1.53758079e-01f, -8.53315070e-02f, -1.30963221e-01f, -4.45334427e-02f, 4.75744158e-02f, -9.01122764e-02f, -8.07143897e-02f, -8.21816474e-02f,
  -1.32623821e-01f, -1.88206777e-01f, -1.78004417e-03f, 4.55450304e-02f, -9.14619491e-02f, -8.56286474e-03f, -4.52157259e-02f, -1.51815087e-01f, -5.35752997e-02f, 5.01971655e-02f,
  1.59038946e-01f, -1.54323399e-01f, -1.94753140e-01f, -2.03393158e-02f, -1.10235944e-01f, -1.61650822e-01f, -1.20669246e-01f, -2.27416486e-01f, -2.25200966e-01f, 1.21227182e-01f,
  -6.76053613e-02f, 3.42985280e-02f, 3.85633223e-02f, 7.27051869e-02f, 1.34092227e-01f, 9.33420360e-02f, 1.01169974e-01f, 7.73871094e-02f, 4.86408062e-02f, 6.36592731e-02f,
  2.81838723e-03f, 8.97562504e-02f, 8.77821818e-02f, 1.93088830e-01f, -4.72038537e-02f, 1.99072771e-02f, 1.10084832e-01f, 2.41587311e-01f, 7.78752426e-03f, -8.25966299e-02f,
  -2.01102704e-01f, -2.19769478e-01f, -1.36543080e-01f, 5.31842597e-02f, -1.67551130e-01f, -1.24649130e-01f, -9.21301991e-02f, -1.17117930e-02f, -3.53019424e-02f, -8.84068757e-02f,
  5.54242611e-01f, 2.57730260e-02f, 1.55814230e-01f, 1.02610044e-01f, -1.13705277e-01f, -9.91161317e-02f, 3.75379995e-02f, -2.30580904e-02f, -1.42070046e-02f, 7.11654276e-02f,
  -2.22150370e-01f, 1.54210245e-02f, 7.44352937e-02f, -4.14947346e-02f, 4.81376946e-02f, -2.72610709e-02f, 2.31533706e-01f, 3.11239790e-02f, -1.47349492e-01f, -1.43324226e-01f,
  8.54374021e-02f, 1.97479948e-01f, 3.67289811e-01f, 1.47754923e-01f, -1.67909637e-01f, -4.14548740e-02f, 2.37048790e-01f, 8.84167179e-02f, 2.50308722e-01f, 5.80823123e-01f,
  -4.43169087e-01f, 1.55380532e-01f, -4.42781270e-01f, 1.53414652e-01f, 5.53674161e-01f, 7.22427517e-02f, 6.75672293e-02f, -2.02308953e-01f, -7.35882148e-02f, 4.79168482e-02f,
  1.15802109e-01f, 2.26379763e-02f, -2.86851134e-02f, -5.27809709e-02f, -2.87749738e-01f, 9.89890248e-02f, 1.01454534e-01f, -2.09798962e-01f, -1.70943767e-01f, 3.39505553e-01f,
  6.02761865e-01f, 3.44296962e-01f, -7.13399947e-02f, 2.22857762e-02f, 3.18398982e-01f, 2.38181219e-01f, 7.40317255e-02f, 3.16398501e-01f, 1.63444906e-01f, 1.34578049e-01f,
  -3.77863497e-01f, -3.06352973e-01f, -3.41743678e-02f, 1.56982675e-01f, 5.50154485e-02f, -3.02537590e-01f, -1.76786378e-01f, -7.35580623e-02f, -1.73293352e-02f, -6.58024102e-02f,
  3.18752170e-01f, -1.78456828e-01f, 1.82423592e-01f, 8.12349841e-02f, 6.90270029e-03f, -1.81293145e-01f, 1.61974743e-01f, -4.72301424e-01f, -5.50484002e-01f, -2.45345175e-01f,
  4.60927755e-01f, 5.64284086e-01f, -1.51982501e-01f, -1.89361691e-01f, -4.77864921e-01f, 1.55355573e-01f, -1.55467376e-01f, -2.50001311e-01f, -4.90844846e-01f, -2.72989154e-01f,
  1.32960686e-02f, 4.25269902e-02f, 7.26183057e-02f, 7.69198760e-02f, 1.41612589e-01f, 1.41247422e-01f, 6.61842972e-02f, 1.22534838e-02f, -2.83019450e-02f, 8.68700370e-02f,
  -1.84075132e-01f, -1.68806836e-01f, -2.98938572e-01f, -1.97774962e-01f, -4.70842272e-02f, 4.36437577e-02f, -1.09732509e-01f, -3.98597643e-02f, -4.72526737e-02f, -1.42577499e-01f,
  -1.02186419e-01f, -2.13538587e-01f, -5.48752770e-02f, -2.31941655e-01f, -1.03687376e-01f, -2.32539609e-01f, -1.12906270e-01f, -1.23913422e-01f, -3.59017700e-02f, 7.40608051e-02f,
  7.97579065e-02f, 5.02027720e-02f, -2.92618632e-01f, 2.01029852e-02f, 7.82954097e-02f, 6.12194911e-02f, -6.59032445e-03f, -7.59232715e-02f, -2.00724244e-01f, -1.92548826e-01f,
  -2.09988177e-01f, -2.94003218e-01f, -1.61007196e-02f, 1.05559519e-02f, -1.69330791e-01f, -1.67944387e-01f, 2.29504660e-01f, 3.47210653e-02f, -8.60480219e-02f, -2.36850288e-02f,
  4.14757878e-02f, 1.12108231e-01f, 6.97147772e-02f, -1.96886450e-01f, -5.01145981e-02f, 1.21038675e-01f, -2.95295455e-02f, -8.71836022e-02f, -1.44305006e-01f, 2.61082556e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 78)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 78;
const float L0_fan_Bp_bar_data[] = {
  1.77799135e-01f, 2.71978348e-01f, 5.28517008e-01f, 3.20724964e-01f, 1.98012710e-01f, 2.51747370e-01f, 4.76380229e-01f, 3.57592463e-01f, 6.82679653e-01f, 3.93899977e-01f,
  4.23726380e-01f, 4.23907697e-01f, 1.56144485e-01f, 4.68555540e-01f, 4.51278389e-01f, 2.36338243e-01f, 4.86049742e-01f, 4.68616396e-01f, 4.81231660e-01f, 5.26198030e-01f,
  2.03868449e-01f, 4.48188096e-01f, 3.09534222e-01f, 4.40774292e-01f, 2.42912814e-01f, 3.83147955e-01f, 6.70851707e-01f, 1.38270825e-01f, 3.75579745e-01f, 1.28597796e-01f,
  4.47901607e-01f, 3.33540589e-01f, 4.10547763e-01f, 3.96401614e-01f, 3.00197989e-01f, 5.97375035e-01f, 1.77450031e-01f, 3.79850566e-01f, 4.94248509e-01f, 4.35936481e-01f,
  4.96042579e-01f, 5.56968629e-01f, 6.62000179e-01f, 4.73420113e-01f, 2.46195704e-01f, 3.73085856e-01f, 3.74849796e-01f, 1.69788167e-01f, 3.81889492e-01f, 4.03697997e-01f,
  9.50515792e-02f, 3.73269320e-01f, 3.95880401e-01f, 1.66227102e-01f, 3.25888574e-01f, 3.05187464e-01f, 3.43731701e-01f, 3.32129240e-01f, 5.50425231e-01f, 1.16478346e-01f,
  5.20390987e-01f, 1.76644623e-01f, 4.08850759e-01f, 1.35654211e-01f, 3.69085133e-01f, 5.66478252e-01f, 3.32806140e-01f, 7.17875659e-02f, 3.59452456e-01f, 4.68525916e-01f,
  4.95417744e-01f, 3.44825417e-01f, 3.25617790e-01f, 4.76063043e-01f, 4.19965714e-01f, 5.34890354e-01f, 3.98699701e-01f, 3.67184937e-01f
};

// L1_linear_W (Shape: 12 x 128)
const int L1_linear_W_rows = 12;
const int L1_linear_W_cols = 128;
const float L1_linear_W_data[] = {
  -7.91669637e-02f, -1.84371755e-01f, -2.28979722e-01f, -7.77110457e-02f, 6.96719959e-02f, -1.25622824e-01f, -1.61616936e-01f, -1.07205816e-01f, -5.21103702e-02f, -3.17760795e-01f,
  -1.69482365e-01f, -1.40958764e-02f, -1.97489902e-01f, -2.36165933e-02f, 1.94441900e-03f, -9.56408232e-02f, -5.75038455e-02f, 4.17791456e-02f, -7.18202814e-03f, -3.38841021e-01f,
  -1.49122179e-01f, -1.51490971e-01f, -1.44261137e-01f, -1.04917966e-01f, -1.89766094e-01f, 9.49164703e-02f, -2.86190175e-02f, 2.40235716e-01f, 2.87686944e-01f, 1.54570982e-01f,
  1.28965721e-01f, -1.69211403e-01f, 4.73398007e-02f, 1.52542442e-01f, 6.13993630e-02f, -1.72895998e-01f, 2.33335674e-01f, -5.75838722e-02f, 5.98656051e-02f, -1.31755069e-01f,
  -4.14944030e-02f, -1.46387547e-01f, -6.99188486e-02f, 1.13025300e-01f, 1.15487643e-01f, 6.70564547e-02f, 3.25512022e-01f, -1.96912915e-01f, -2.24630572e-02f, 9.86926034e-02f,
  -1.22123688e-01f, -3.98344100e-01f, -3.78614694e-01f, 3.33401829e-01f, -6.47284016e-02f, 1.02919340e-01f, -3.34453702e-01f, 3.12170118e-01f, -2.60418057e-02f, 1.97517008e-01f,
  -3.63016069e-01f, 4.03830141e-01f, 1.29516289e-01f, -5.54358363e-01f, -7.87593842e-01f, -3.30448836e-01f, 9.59660560e-02f, 5.41630089e-02f, -5.18604100e-01f, -5.16313016e-01f,
  -1.43242572e-02f, -9.66678113e-02f, -3.30440819e-01f, 3.85538395e-03f, -4.70668152e-02f, -2.21912235e-01f, -1.02195553e-01f, 3.45102161e-01f, -2.35222161e-01f, -3.15925032e-01f,
  -2.46728793e-01f, 1.53364036e-02f, -1.42300799e-01f, -1.88594431e-01f, 1.18059054e-01f, -2.10657254e-01f, 2.08891615e-01f, -7.16793656e-01f, -3.86261553e-01f, -4.22140658e-01f,
  3.27668488e-01f, -3.26323777e-01f, -2.70037293e-01f, -2.44552642e-01f, -7.06143200e-01f, 4.59102482e-01f, -1.97200716e-01f, -4.97607082e-01f, 1.29077628e-01f, -4.31264639e-01f,
  1.57509595e-01f, -2.30653167e-01f, -2.72090048e-01f, 1.05918251e-01f, 5.89459129e-02f, 6.41580969e-02f, -2.96989471e-01f, -2.80631870e-01f, 8.91862065e-02f, -1.76905140e-01f,
  -2.02697873e-01f, 2.25726366e-01f, 4.00820412e-02f, 1.74464762e-01f, 1.76338002e-01f, -3.68786246e-01f, -8.81465375e-01f, 9.32891294e-02f, -3.31975311e-01f, 1.70190737e-01f,
  -1.34437740e-01f, 2.71078646e-01f, -1.26312137e-01f, -5.05948365e-01f, -2.62691863e-02f, 4.33355212e-01f, -2.19467118e-01f, 3.65397334e-02f, -2.60033412e-04f, 1.56854823e-01f,
  -1.36490345e-01f, 8.90535563e-02f, 1.42177492e-01f, -2.67159119e-02f, -5.14596961e-02f, 1.87276676e-01f, 1.91312671e-01f, 7.44014531e-02f, 1.27411736e-02f, -5.46792969e-02f,
  -2.73427330e-02f, 9.19936299e-02f, 1.09369149e-02f, 7.98149854e-02f, -4.07458609e-03f, -1.28002629e-01f, -1.20787667e-02f, -9.19938460e-02f, -1.29479006e-01f, -9.19592679e-02f,
  -7.28791654e-02f, 9.43298116e-02f, 1.67177111e-01f, 2.16674775e-01f, -3.98357287e-02f, -8.47913548e-02f, 6.93764305e-03f, 1.05334677e-01f, 1.34200498e-01f, -1.86979428e-01f,
  3.40929590e-02f, 4.05573435e-02f, 1.30245820e-01f, 1.95858181e-01f, 2.01117843e-01f, -1.27873197e-01f, -4.60455902e-02f, -2.73156930e-02f, -7.48330951e-02f, 4.91534844e-02f,
  -2.66798049e-01f, -6.29518330e-02f, 5.79827949e-02f, -1.60376921e-01f, 2.29348451e-01f, 1.01357244e-01f, -2.69831806e-01f, -8.20306409e-03f, 2.13403419e-01f, -1.07120939e-01f,
  -6.75118387e-01f, 6.05107784e-01f, 2.84933746e-01f, -6.39898032e-02f, -9.64411199e-01f, -4.73187864e-01f, -1.27806115e+00f, 1.01286635e-01f, -2.45571718e-01f, 3.14907551e-01f,
  -4.67074126e-01f, -6.15433276e-01f, 2.58072942e-01f, -1.66367572e-02f, -2.46871218e-01f, 3.10471922e-01f, -1.78056404e-01f, -4.52724904e-01f, 1.83363080e-01f, -1.63974419e-01f,
  1.14943862e-01f, -8.34286451e-01f, 3.45675737e-01f, 2.59520471e-01f, -3.21092427e-01f, 3.58301312e-01f, -6.82500675e-02f, 6.80779666e-02f, -1.57899812e-01f, -7.81798065e-01f,
  2.77744293e-01f, -4.94406730e-01f, -1.87527090e-01f, 2.86410041e-02f, -1.10860668e-01f, -2.14244366e-01f, -3.05450022e-01f, 7.94706941e-02f, 3.42146814e-01f, -2.58286625e-01f,
  -8.20173323e-02f, 1.99017927e-01f, -4.10788208e-01f, 4.45169896e-01f, -1.47467200e-02f, -1.82839811e-01f, -1.42406538e-01f, -1.00155354e-01f, -1.18151240e-01f, 8.27227384e-02f,
  1.70358703e-01f, -6.49282098e-01f, 1.23019978e-01f, -7.18506873e-01f, 4.75966185e-02f, 4.16839458e-02f, -7.47180343e-01f, 1.18081331e-01f, -3.55751673e-03f, -8.76108482e-02f,
  1.76673397e-01f, 8.06945935e-02f, -7.40669429e-01f, 3.25342268e-01f, -1.07547268e-01f, -2.82302238e-02f, 3.93196583e-01f, 4.89208072e-01f, 2.16685414e-01f, -1.12719901e-01f,
  2.23827809e-01f, 2.72908419e-01f, 4.56847996e-02f, 2.90833354e-01f, 1.49997771e-01f, -8.52521837e-01f, 8.14071968e-02f, -7.40661006e-03f, 1.57482196e-02f, -2.51368992e-02f,
  -2.00337935e-02f, 1.27130717e-01f, 6.36667758e-02f, 1.26698196e-01f, 6.38889074e-02f, 2.03286797e-01f, 1.47936761e-01f, 2.30678484e-01f, 8.42345580e-02f, -1.91895291e-02f,
  -6.55839145e-02f, 2.26152480e-01f, 6.39788732e-02f, 6.86372817e-02f, 1.40243053e-01f, 1.78022429e-01f, 1.38042614e-01f, 1.05125450e-01f, 2.79109944e-02f, 6.36914559e-03f,
  1.78503335e-01f, -9.31500718e-02f, -3.50161493e-01f, 1.38799980e-01f, -3.68763432e-02f, -2.50616252e-01f, 1.47304207e-01f, -2.05703214e-01f, -2.50393063e-01f, -4.14204970e-02f,
  4.20859046e-02f, -1.39127627e-01f, -1.16206393e-01f, -6.06077947e-02f, 1.73887372e-01f, -1.67361468e-01f, 3.90920378e-02f, -1.34550244e-01f, 1.48901999e-01f, 7.35764578e-02f,
  -2.37912294e-02f, -2.54209459e-01f, 4.22509052e-02f, -1.93524584e-01f, -1.22331016e-01f, 9.82342660e-02f, -2.78712124e-01f, -3.35212588e-01f, 1.14287697e-01f, 4.33051288e-01f,
  8.59776288e-02f, 1.21613353e-01f, 3.86078596e-01f, -3.08875322e-01f, -4.59743470e-01f, -2.68621653e-01f, -2.34592468e-01f, 6.09277248e-01f, -2.64600903e-01f, 3.28540593e-01f,
  2.27337226e-01f, -5.35580695e-01f, -1.99007601e-01f, 7.22160116e-02f, -1.32911513e-02f, -4.84314650e-01f, -2.85527501e-02f, 3.32354963e-01f, -1.42039880e-01f, -3.38061392e-01f,
  -2.04538882e-01f, -3.13881338e-01f, 3.51293445e-01f, -8.98645073e-02f, 9.37880501e-02f, -3.29544455e-01f, 1.65437400e-01f, -4.12333339e-01f, 3.75045952e-03f, -4.59857017e-01f,
  -3.43028396e-01f, -2.42576689e-01f, -1.52189195e-01f, -1.55498683e-01f, 6.82445586e-01f, 1.05623389e-02f, 1.91121593e-01f, -1.79495603e-01f, 3.02727550e-01f, -2.68515110e-01f,
  -1.06661476e-01f, -6.15819335e-01f, -3.46645296e-01f, 6.90136552e-02f, -3.81261945e-01f, -1.50314242e-01f, -1.33746922e-01f, -2.88044155e-01f, 1.05415113e-01f, -5.42680919e-01f,
  1.09549925e-01f, 4.45618629e-01f, 1.38392240e-01f, -4.18211401e-01f, -3.06011796e-01f, -9.15273055e-02f, -6.25172257e-02f, -1.25401780e-01f, -1.03703491e-01f, -4.15877461e-01f,
  1.55181652e-02f, 1.13560386e-01f, -2.61602011e-02f, 1.32816300e-01f, -2.56974667e-01f, -1.47557398e-02f, -1.50417075e-01f, -4.62814510e-01f, -3.89476001e-01f, -1.04635708e-01f,
  4.42389131e-01f, 3.86441648e-01f, -3.67939085e-01f, -1.53989419e-01f, -4.77376133e-02f, -5.47930524e-02f, 1.78797524e-02f, -8.17765296e-02f, -3.56990993e-02f, 2.42164987e-03f,
  2.37613022e-02f, -1.76424876e-01f, -4.55086678e-03f, 6.93168417e-02f, -2.91681383e-02f, 1.92905050e-02f, 7.88109750e-02f, -9.78640746e-03f, -9.70252454e-02f, -2.96205789e-01f,
  9.43554565e-02f, -1.29847363e-01f, -2.80664444e-01f, -2.67228633e-02f, -7.45292306e-02f, -7.57307140e-03f, 1.29061803e-01f, -2.02863738e-01f, 2.01402400e-02f, 6.83049206e-03f,
  3.32695208e-02f, 9.14430991e-02f, 3.60565156e-01f, 4.51740101e-02f, 2.18371060e-02f, -4.30598017e-03f, 3.51483710e-02f, 4.34346944e-02f, -5.48150726e-02f, 6.16477169e-02f,
  8.56822282e-02f, -9.69398543e-02f, -7.08900616e-02f, 3.39151956e-02f, -2.26230860e-01f, 4.90735590e-01f, 1.64364949e-01f, 2.01830953e-01f, 7.00669885e-02f, -7.62594417e-02f,
  -1.59915403e-01f, -8.85604694e-03f, -9.20236483e-02f, -4.12183665e-02f, 2.73525715e-03f, 4.76343155e-01f, 6.96664989e-01f, 9.24768969e-02f, -1.70067117e-01f, -3.40925425e-01f,
  -9.59341899e-02f, -1.40870377e-01f, -2.27592915e-01f, 1.46843120e-01f, -6.98549390e-01f, 1.10758387e-01f, 1.47736385e-01f, 3.18654478e-01f, -6.02629781e-01f, -3.73027831e-01f,
  -1.07017003e-01f, -2.49125928e-01f, -2.18060091e-01f, 2.97558218e-01f, -2.18364552e-01f, -3.66832465e-01f, 3.45171213e-01f, 9.74325463e-02f, -5.28711200e-01f, -2.74640322e-01f,
  7.10950136e-01f, -1.73459858e-01f, -1.07314691e-01f, -2.80660629e-01f, -1.32792115e-01f, 2.47676954e-01f, -3.50546181e-01f, 1.30521253e-01f, 4.08920646e-01f, -4.46125627e-01f,
  2.52437085e-01f, -5.71165383e-01f, -6.05258465e-01f, 5.14876209e-02f, -1.00024021e+00f, 5.60051262e-01f, -1.23089157e-01f, -3.80972214e-02f, -2.10605681e-01f, -4.75195944e-01f,
  -3.23798001e-01f, -2.70592421e-01f, -5.70512675e-02f, 1.91370901e-02f, 2.67149657e-01f, -1.28901690e-01f, -4.15877253e-01f, -3.17008644e-01f, -4.79656547e-01f, 1.38083681e-01f,
  -5.39111316e-01f, 1.59473106e-01f, 2.89135218e-01f, -2.53101438e-01f, 3.02522153e-01f, 4.51377422e-01f, 5.90189584e-02f, -2.72734880e-01f, 1.65223941e-01f, -5.23708522e-01f,
  3.96985382e-01f, -3.81522238e-01f, -1.11131340e-01f, 6.82501309e-03f, -2.85888493e-01f, -4.97397065e-01f, -2.98898757e-01f, -1.87739015e-01f, -2.12846532e-01f, 2.58907795e-01f,
  3.40907276e-02f, -4.75336835e-02f, 1.00701846e-01f, -1.99324191e-02f, 8.07692334e-02f, -4.66911756e-02f, -2.78008673e-02f, -8.84051919e-02f, -1.88999608e-01f, -9.94553044e-02f,
  -8.85872841e-02f, -1.22943699e-01f, 6.05373979e-02f, -2.22299576e-01f, 4.50260788e-02f, -1.30356386e-01f, -1.45448849e-01f, 1.49509355e-01f, -4.82304282e-02f, -2.65596390e-01f,
  5.77941574e-02f, 6.39483407e-02f, -9.25637707e-02f, -2.36939229e-02f, -1.45460874e-01f, -2.07074508e-02f, 1.61641613e-02f, 1.24142848e-01f, -1.51826903e-01f, 6.51151240e-02f,
  -3.13545763e-01f, 1.23726532e-01f, -3.03202808e-01f, -1.27573565e-01f, -2.67796457e-01f, 1.12480551e-01f, 5.44911362e-02f, 7.12096468e-02f, -2.77466565e-01f, 1.58986986e-01f,
  8.60236026e-03f, 6.91113174e-02f, 4.66195568e-02f, -2.87570477e-01f, 1.43960357e-01f, -1.21177100e-02f, 5.14847934e-02f, -8.24493393e-02f, -2.41681874e-01f, -7.95741454e-02f,
  -1.76471740e-01f, -1.24744147e-01f, -6.23320527e-02f, 4.84365404e-01f, -6.59318686e-01f, -1.82168007e-01f, -6.09549642e-01f, 1.47145033e-01f, 4.88057911e-01f, 9.35733169e-02f,
  -1.02292851e-01f, 9.73508880e-02f, 3.02116185e-01f, -1.26807064e-01f, -1.06294371e-01f, 1.75493047e-01f, 1.73032477e-01f, 1.46844193e-01f, 3.81446570e-01f, -3.88361365e-01f,
  -9.23975650e-03f, -1.65783968e-02f, 6.32920954e-03f, -3.95619541e-01f, -1.42348045e-02f, 2.91299582e-01f, 2.09429935e-01f, -1.38438761e-01f, -3.61289024e-01f, -3.89584780e-01f,
  -2.06986293e-01f, 6.85511604e-02f, -3.41966420e-01f, 3.04675370e-01f, -1.21675432e-01f, -6.82088286e-02f, -4.87868994e-01f, 5.90375550e-02f, 8.28688219e-03f, 2.37448931e-01f,
  4.00144637e-01f, 2.66543567e-01f, -2.57837385e-01f, -2.53959417e-01f, -1.94138125e-01f, 1.06616512e-01f, 4.59618747e-01f, -2.42366329e-01f, -3.53231728e-02f, 1.71456467e-02f,
  5.78516908e-03f, -2.07984999e-01f, 1.93328694e-01f, 6.80205747e-02f, -6.51324019e-02f, 3.21402758e-01f, 2.26463587e-03f, -1.27610229e-02f, -1.84864372e-01f, -3.83137971e-01f,
  1.42420501e-01f, -1.63444579e-01f, -1.05270542e-01f, -6.68206632e-01f, 7.71796629e-02f, 2.38157526e-01f, 1.81048349e-01f, -3.43519568e-01f, 3.49839181e-01f, 2.91694570e-02f,
  -3.82374138e-01f, -3.23815644e-01f, -3.18730786e-03f, -1.16753399e-01f, -1.31391257e-01f, -2.88855527e-02f, -1.53215006e-01f, -5.29594898e-01f, -2.45781451e-01f, -3.48063052e-01f,
  1.39972940e-01f, 1.03442222e-01f, 2.07755212e-02f, 5.36023341e-02f, -2.66789664e-02f, 7.50219449e-02f, 1.13286212e-01f, 1.71193540e-01f, -6.81771711e-02f, 1.97059169e-01f,
  -8.18610266e-02f, 4.05833945e-02f, 7.78172165e-02f, -2.64549311e-02f, 4.48752604e-02f, 1.24488652e-01f, 5.46310842e-02f, 2.84108579e-01f, -3.70140304e-03f, 2.40778089e-01f,
  6.94535747e-02f, 1.77347735e-01f, 1.92142025e-01f, 1.91779658e-01f, 6.52726293e-02f, -2.13502467e-01f, -9.90523994e-02f, 2.35138834e-01f, -1.23703063e-01f, -9.30941328e-02f,
  3.25613946e-01f, 1.81380168e-01f, 8.56243446e-02f, 1.74926370e-01f, 2.28562519e-01f, -8.78376234e-03f, 1.61573783e-01f, 1.85216576e-01f, -6.68119639e-02f, 2.15183524e-03f,
  -1.46491658e-02f, -1.10295311e-01f, -2.66669337e-02f, -4.43192899e-01f, 8.02413300e-02f, 9.54031385e-03f, -5.59670068e-02f, 1.22709788e-01f, -9.94387195e-02f, 1.60132527e-01f,
  7.16159940e-02f, -3.96538585e-01f, -4.10046011e-01f, -5.04050195e-01f, -4.41436827e-01f, 1.87498301e-01f, -5.44426441e-01f, 3.85574281e-01f, 8.84521902e-01f, 2.42223665e-01f,
  2.06311300e-01f, -5.83566368e-01f, -1.04725718e-01f, -6.56419933e-01f, 2.40542501e-01f, 1.00445643e-01f, 6.21257350e-02f, 6.06000721e-02f, -5.71843922e-01f, 2.86685914e-01f,
  -3.26138400e-02f, -3.55049074e-02f, 3.38054150e-01f, 4.17130142e-02f, 1.59126401e-01f, 3.37311655e-01f, -2.04912722e-01f, 6.88050538e-02f, -1.25493482e-01f, -1.59187376e-01f,
  9.38705206e-02f, -3.41768146e-01f, -3.59928340e-01f, -7.02160060e-01f, -5.66049278e-01f, 2.82725245e-01f, 6.19247220e-02f, -3.09686691e-01f, -3.37049514e-01f, -4.09274489e-01f,
  2.07911715e-01f, -2.60451168e-01f, -1.42946899e-01f, 1.15617111e-01f, 5.02291083e-01f, 1.97861314e-01f, -1.97523162e-01f, 2.45796248e-01f, 4.98540908e-01f, -9.32736918e-02f,
  -1.29722506e-01f, 2.92105913e-01f, -1.57569647e-01f, 1.01528935e-01f, -1.37304664e-01f, -6.68983400e-01f, -8.65836889e-02f, -2.05506384e-01f, -2.72111416e-01f, -6.17456250e-02f,
  -2.86566973e-01f, 2.48152003e-01f, -2.72382110e-01f, 1.17541470e-01f, -5.11842333e-02f, -1.04949223e-02f, -7.23554492e-01f, -1.17742881e-01f, -5.56695163e-02f, -2.22862363e-02f,
  3.05968761e-01f, 4.43373412e-01f, -3.88351455e-02f, -5.82845472e-02f, -6.02826774e-01f, -8.06187034e-01f, 3.90237778e-01f, 3.39633256e-01f, -1.12110637e-01f, 1.16805462e-02f,
  -4.32040356e-02f, 1.07170846e-02f, 9.97547526e-03f, -7.81813413e-02f, 8.45711678e-02f, -1.06944114e-01f, -3.38122621e-02f, 3.02327517e-02f, 1.18963368e-01f, -5.21119647e-02f,
  3.71194817e-02f, 5.37630431e-02f, 1.32947788e-01f, -2.84761637e-01f, 1.38860822e-01f, -1.10169247e-01f, -1.51862428e-01f, -2.02014416e-01f, 8.25463086e-02f, -4.55679335e-02f,
  -6.73858821e-02f, -9.41538438e-02f, -1.26304403e-01f, -9.63262469e-02f, 2.33771354e-01f, -1.24143407e-01f, -2.99758017e-01f, -1.34707361e-01f, 1.99178293e-01f, 1.84027129e-03f,
  3.83229524e-01f, -1.01120614e-01f, 1.46119237e-01f, 1.40125066e-01f, -2.67480075e-01f, 1.74565569e-01f, -2.40799487e-01f, -1.62465423e-01f, 3.03375334e-01f, -2.68624693e-01f,
  2.89444447e-01f, -1.15280449e-01f, -9.30347070e-02f, 7.26584867e-02f, -3.05212885e-01f, 3.08779813e-02f, 2.59199947e-01f, 3.33100967e-02f, -4.35815454e-01f, -4.73550886e-01f,
  -2.41031870e-01f, -2.84633845e-01f, 2.48742908e-01f, 1.25000045e-01f, 5.58550537e-01f, -6.03085279e-01f, 6.85761049e-02f, -2.35832408e-01f, 2.17133939e-01f, -5.53207397e-01f,
  2.34406412e-01f, 5.31631894e-02f, 6.05431080e-01f, -1.39741436e-01f, -2.29363889e-01f, 2.67082334e-01f, -3.34856391e-01f, -4.43682112e-02f, 4.14264113e-01f, 4.81867939e-01f,
  -3.96467954e-01f, -5.60056210e-01f, -3.75179529e-01f, 1.98224690e-02f, -2.42010001e-02f, -3.85053337e-01f, 2.35194743e-01f, -1.99636891e-01f, -3.69191051e-01f, -5.58978260e-01f,
  -2.40888372e-01f, -1.28692433e-01f, -2.36972511e-01f, -6.84523284e-02f, -3.23116124e-01f, 3.12487781e-01f, -1.95826158e-01f, -2.52616078e-01f, -6.13941252e-01f, -1.30984515e-01f,
  3.75836998e-01f, 2.17923075e-01f, 2.78910566e-02f, -5.03211021e-01f, 1.18425719e-01f, -7.42392093e-02f, -3.09223890e-01f, 3.89545858e-01f, -8.46822932e-02f, 5.04949726e-02f,
  -5.84257394e-02f, -3.79205257e-01f, 2.36519247e-01f, -3.69854271e-01f, 8.89093429e-02f, 2.41866633e-01f, -5.79560161e-01f, 1.02890365e-01f, -4.36405003e-01f, -8.58799145e-02f,
  -1.72190472e-01f, -3.74887288e-01f, -4.03447002e-01f, 2.79927313e-01f, -6.93244100e-01f, -2.05958501e-01f, -3.39707971e-01f, -2.96003491e-01f, -3.45793247e-01f, -9.59858894e-02f,
  8.72680396e-02f, -1.61331922e-01f, 1.56521142e-01f, -3.81209627e-02f, -5.19154854e-02f, -6.73613489e-01f, -1.41609296e-01f, 6.85762018e-02f, -2.61263233e-02f, -2.32760206e-01f,
  -1.97329760e-01f, -3.24251279e-02f, -3.88653316e-02f, -6.29178658e-02f, -9.82928351e-02f, -1.41430557e-01f, -1.72576576e-01f, 7.43816420e-03f, -1.42759189e-01f, -3.71171534e-02f,
  3.76674049e-02f, -5.47469109e-02f, -8.69233236e-02f, -6.39032573e-03f, -1.65571958e-01f, -5.85551374e-02f, -5.29228570e-03f, -3.96895073e-02f, 2.34008674e-02f, 9.38153826e-03f,
  -2.46406749e-01f, -1.53149843e-01f, -5.90808392e-02f, -1.47453719e-03f, 2.03658178e-01f, -1.44481987e-01f, 6.05599694e-02f, 1.02747783e-01f, -2.04485580e-01f, 2.24185795e-01f,
  -4.06507663e-02f, -1.12687223e-01f, 1.09852493e-01f, 6.91421106e-02f, -1.00250423e-01f, 1.43613800e-01f, -2.83430398e-01f, 4.54860590e-02f, 8.66272226e-02f, -2.23402120e-03f,
  2.21178651e-01f, 4.91219722e-02f, -9.82461944e-02f, -1.86678827e-01f, -1.40517518e-01f, 7.44379759e-02f, -1.09179087e-01f, -1.70466274e-01f, 5.22473514e-01f, -3.43707293e-01f,
  2.96458434e-02f, -1.77890003e-01f, -7.90362656e-02f, -1.35421306e-01f, 5.53055167e-01f, -4.14138973e-01f, 6.70555308e-02f, -2.59394109e-01f, 3.72449964e-01f, 2.85700262e-01f,
  -2.86501199e-01f, 1.82353795e-01f, -2.71321118e-01f, -2.10823536e-01f, 2.62990654e-01f, -3.32260489e-01f, -4.13829476e-01f, -4.98314500e-01f, -1.74989447e-01f, -1.35503128e-01f,
  -2.06758946e-01f, -2.04194561e-02f, 4.62209910e-01f, -4.68159974e-01f, -4.62431721e-02f, 2.19186246e-01f, -5.95525280e-02f, -2.13388070e-01f, -1.70107987e-02f, -1.37067422e-01f,
  5.15681088e-01f, -1.53493941e-01f, -3.26149195e-01f, 2.27776282e-02f, -3.74023288e-01f, 5.42199910e-02f, 1.20274834e-01f, 1.93096578e-01f, -2.04545885e-01f, -2.02659652e-01f,
  -1.40449569e-01f, -1.92479432e-01f, -2.47952253e-01f, -3.60702500e-02f, -2.53352404e-01f, -4.89220440e-01f, -1.43185645e-01f, -6.43527210e-02f, -1.32653430e-01f, -3.97494525e-01f,
  -2.54472256e-01f, 4.75076661e-02f, -8.81112665e-02f, -3.46251100e-01f, -2.76992500e-01f, 4.12223861e-02f, -1.80955946e-01f, -2.73607343e-01f, -2.20059678e-01f, -9.93275717e-02f,
  1.79663286e-01f, -2.83921868e-01f, 5.28641641e-01f, 2.19812632e-01f, 1.21116407e-01f, -5.06816745e-01f, -5.68194985e-02f, -5.17616391e-01f, 6.16721343e-03f, 7.42668584e-02f,
  -1.11158684e-01f, -2.56715566e-01f, -2.42012456e-01f, 4.63103145e-01f, -1.23041615e-01f, -1.62740529e-01f, 5.34077398e-02f, 5.43720834e-02f, 1.05748199e-01f, 1.00109465e-01f,
  -3.01502813e-02f, -6.76060095e-02f, -1.47927538e-01f, -9.59108695e-02f, 4.64245006e-02f, -8.15461278e-02f, 1.77708194e-02f, -1.65839605e-02f, -2.60350823e-01f, 1.11244589e-01f,
  -1.86373055e-01f, -1.78384975e-01f, 1.42116919e-01f, 1.27178326e-01f, -5.47336861e-02f, 1.61872536e-01f, 5.28842397e-02f, -1.92772105e-01f, 4.88217641e-03f, -2.46287882e-01f,
  2.12414250e-01f, 1.36681786e-02f, 1.23133987e-01f, -9.58968922e-02f, -3.07159483e-01f, 1.68636620e-01f, 2.02665523e-01f, -3.46218944e-01f, -9.80857238e-02f, 9.30433348e-03f,
  3.18438172e-01f, 1.99766070e-01f, 2.58752316e-01f, -1.39348999e-01f, 6.71498626e-02f, 2.76316047e-01f, -3.13022345e-01f, 2.97529429e-01f, 3.55927758e-02f, 2.85260886e-01f,
  1.83543116e-01f, 2.06097588e-01f, 4.18534666e-01f, -5.93389459e-02f, 7.42039308e-02f, -4.13778543e-01f, 4.44897681e-01f, -4.30669725e-01f, -2.99445659e-01f, -4.07205164e-01f,
  -2.64504164e-01f, -3.19393277e-01f, 5.27617097e-01f, -2.66710281e-01f, -2.79356956e-01f, -2.76032150e-01f, -2.11226881e-01f, -1.43513650e-01f, -5.66916287e-01f, -2.80272335e-01f,
  -2.52749622e-01f, -2.84442037e-01f, 2.56647438e-01f, 3.32787514e-01f, 4.65774275e-02f, -1.93035826e-01f, -5.25138557e-01f, -5.44264257e-01f, 1.56240165e-01f, -2.99636543e-01f,
  3.09618920e-01f, 3.03353518e-01f, 3.79259616e-01f, -6.17956780e-02f, 5.28693974e-01f, -1.54784262e-01f, 1.66240469e-01f, -5.16839735e-02f, -1.90864250e-01f, 3.33326995e-01f,
  -4.38522667e-01f, -1.02555625e-01f, 3.67181301e-01f, -2.98103422e-01f, -2.37204745e-01f, -2.08409563e-01f, 6.12190485e-01f, -1.75468042e-01f, 9.87416413e-03f, -4.66095954e-01f,
  3.53867710e-01f, 5.14593832e-02f, -6.08420849e-01f, -3.81798372e-02f, -1.94955438e-01f, -1.50936455e-01f, 3.83049920e-02f, -2.26369709e-01f, -3.02915215e-01f, -1.27261460e-01f,
  5.22905327e-02f, -1.98414385e-01f, -4.65480745e-01f, -2.26262644e-01f, 3.64353001e-01f, -7.39273652e-02f, 1.26764983e-01f, -3.38599086e-01f, -2.49699965e-01f, -5.23825027e-02f,
  -3.30194741e-01f, -6.19133674e-02f, 3.20543021e-01f, -4.41360533e-01f, 7.83092529e-02f, 5.16419649e-01f, -1.44248037e-03f, 2.55904347e-01f, 1.54482543e-01f, 6.07932433e-02f,
  -3.17272365e-01f, 1.28346294e-01f, -6.19641505e-02f, -1.08052641e-02f, -6.78861886e-02f, -4.64637801e-02f, 2.12681796e-02f, 8.13517347e-02f, 3.33970189e-02f, 1.54151022e-01f,
  9.10902172e-02f, -1.39669374e-01f, 1.01266064e-01f, 4.48278561e-02f, 1.81946829e-01f, 6.89278319e-02f, -2.45644152e-02f, -3.84756476e-02f, -1.77204877e-01f, 1.26840740e-01f,
  6.84758425e-02f, 2.55374350e-02f, 4.32831757e-02f, -1.64153650e-02f, 1.67746525e-02f, -7.15858676e-03f, 1.20641410e-01f, 1.95333213e-01f, -5.98466322e-02f, -8.33611935e-02f,
  -1.07244276e-01f, 1.29919052e-01f, 6.21472001e-02f, 1.97714716e-01f, -6.54000118e-02f, 4.63252440e-02f, 1.72243237e-01f, -2.02717498e-01f, -2.05670133e-01f, -2.15554237e-01f,
  1.07840858e-01f, 1.42561451e-01f, 1.94705173e-01f, -3.11783403e-01f, -1.49410382e-01f, -1.43099353e-01f, -3.15717161e-01f, 6.59357682e-02f, 8.13443772e-03f, 2.69080698e-02f,
  5.03420830e-02f, 1.11452609e-01f, 3.32968324e-01f, -1.15385339e-01f, -6.08976901e-01f, -4.65503126e-01f, 2.14710727e-01f, -5.16819768e-02f, -1.08118929e-01f, 4.78631407e-01f,
  -6.54281974e-01f, -3.85135502e-01f, -9.06690490e-03f, -7.28944123e-01f, 2.35073209e-01f, 3.22457075e-01f, -1.92690924e-01f, 4.70360145e-02f, -2.97952801e-01f, 8.09678733e-02f,
  2.10215658e-01f, -5.34070909e-01f, -2.49142610e-02f, 3.39169502e-01f, -2.38084719e-01f, -1.29700646e-01f, -5.39850712e-01f, -1.52291462e-01f, -4.70716596e-01f, -1.63284212e-01f,
  -3.03120464e-01f, -2.52007335e-01f, -1.64323941e-01f, 6.37720618e-03f, -2.77169913e-01f, 3.08527172e-01f, 1.25513196e-01f, -5.90641558e-01f, -4.52756137e-01f, 2.82257766e-01f,
  2.53091872e-01f, 4.18747574e-01f, 4.19099450e-01f, -2.98082307e-02f, -5.11713743e-01f, -4.64527339e-01f, 3.21239889e-01f, 5.49722791e-01f, 3.65226597e-01f, 1.28758982e-01f,
  -1.19471386e-01f, 2.35236920e-02f, -1.83936313e-01f, -2.30285481e-01f, 1.40543997e-01f, 6.26920581e-01f, 2.31650174e-01f, 3.78918469e-01f, 1.68014750e-01f, -4.54850703e-01f,
  2.32446998e-01f, -1.27221689e-01f, -1.28556162e-01f, -2.45317280e-01f, -3.41009617e-01f, 9.68567133e-02f, -4.29253548e-01f, 1.54491782e-01f, 5.34117706e-02f, -8.30109119e-02f,
  -7.88958147e-02f, -5.54722548e-01f, -4.99212265e-01f, -2.98432499e-01f, -2.57028967e-01f, -2.97114730e-01f, -3.19026232e-01f, -5.20155668e-01f, -5.98659158e-01f, 5.22248864e-01f,
  -4.54918668e-02f, 6.68888614e-02f, 1.07604012e-01f, -7.72553608e-02f, -3.58923003e-02f, -9.86739770e-02f, 1.02227712e-02f, 5.76747134e-02f, 1.04144484e-01f, -6.43648058e-02f,
  -3.76893729e-02f, 7.35318363e-02f, 2.59382837e-02f, -1.18244663e-01f, 1.00953236e-01f, 3.79880778e-02f, 1.64963648e-01f, 7.25894868e-02f, 2.91248262e-02f, 1.60693288e-01f,
  4.95161824e-02f, 6.20977730e-02f, -1.38145655e-01f, 1.97322682e-01f, 4.65235524e-02f, 2.22140685e-01f, 2.84595862e-02f, -1.46940514e-01f, -2.45670870e-01f, 9.53621492e-02f,
  -3.49810541e-01f, -1.63604975e-01f, 1.21425904e-01f, 2.47548282e-01f, -2.22051546e-01f, 4.33725938e-02f, 1.84497789e-01f, -1.51674554e-01f, 2.56946564e-01f, 2.17786580e-01f,
  1.72966868e-01f, -1.24472506e-01f, -2.14584514e-01f, 2.21321970e-01f, -8.79746750e-02f, -2.32991904e-01f, 1.77136123e-01f, 2.58191764e-01f, 9.28503796e-02f, -1.02126159e-01f,
  -3.27900618e-01f, -2.65012890e-01f, -2.50233393e-02f, -4.61128265e-01f, -2.59467989e-01f, -9.76431146e-02f, -2.09687367e-01f, -3.39125954e-02f, 7.91853219e-02f, -5.53908944e-01f,
  -2.53524154e-01f, -2.14434937e-01f, -1.38895974e-01f, -3.48562241e-01f, -3.11769433e-02f, 1.86103061e-02f, 3.98004204e-01f, -2.02616692e-01f, 4.44982737e-01f, 3.40917826e-01f,
  -1.37571126e-01f, -1.54415518e-01f, -1.93379670e-01f, -2.92402744e-01f, -8.20596665e-02f, -2.74454147e-01f, -1.73169494e-01f, -3.08806777e-01f, -3.33655715e-01f, -1.92423031e-01f,
  2.36077517e-01f, -5.27920008e-01f, 4.47231323e-01f, -3.74300092e-01f, 3.85234624e-01f, -2.38547951e-01f, -3.98548186e-01f, -1.89729020e-01f, -2.44344562e-01f, 4.26091820e-01f,
  -4.42069501e-01f, 6.46652997e-01f, 2.96167824e-02f, 3.28657776e-02f, -3.70256990e-01f, -4.94959354e-01f, -1.71331987e-01f, 1.85513318e-01f, 3.21556747e-01f, -1.19907148e-01f,
  -6.62374729e-03f, -3.88007373e-01f, 2.57989913e-01f, 9.86143351e-02f, -3.71304870e-01f, -4.13154781e-01f, -4.04571980e-01f, -2.43065074e-01f, 2.10407391e-01f, -1.50322750e-01f,
  -2.64005870e-01f, 3.49734783e-01f, -1.66568339e-01f, -5.52599609e-01f, -2.29585528e-01f, -2.79590219e-01f, 1.84905142e-01f, -4.29007739e-01f, -1.25943452e-01f, 3.02654475e-01f,
  -2.45013908e-01f, -1.15682952e-01f, -1.19426720e-01f, -1.35856360e-01f, -2.06623182e-01f, 5.03888190e-01f, 6.05742395e-01f, -1.04984976e-01f, 9.46400017e-02f, -4.16439958e-02f,
  3.37116718e-02f, 1.38046414e-01f, 6.70197606e-02f, -6.83615915e-03f, -1.10045440e-01f, 1.09465361e-01f, 5.00411019e-02f, 9.88150239e-02f, 3.21815945e-02f, 8.74020159e-02f,
  1.75056886e-02f, 7.29143322e-02f, 1.10628270e-01f, 7.40960613e-02f, -6.06415048e-02f, 1.66594341e-01f, -7.49905501e-03f, -7.32291862e-02f, -1.15234032e-02f, -7.78343678e-02f,
  7.45856538e-02f, -7.28323236e-02f, -7.10221902e-02f, 1.76973268e-02f, 4.95246500e-02f, -9.68943909e-02f, -5.13045266e-02f, 6.38828874e-02f, 8.82752463e-02f, 1.26638278e-01f,
  -1.72322303e-01f, -1.19828336e-01f, -1.55944228e-01f, 9.20029953e-02f, -6.13469444e-02f, 2.33455971e-01f, -1.46231979e-01f, 1.93368364e-02f, 4.55301208e-03f, 4.00363982e-01f,
  2.63795584e-01f, 4.74998988e-02f, -1.59007341e-01f, 1.06326640e-01f, -2.72974819e-01f, -9.79983583e-02f, 9.00073498e-02f, -2.40974128e-01f, 1.74177617e-01f, 2.75129676e-01f,
  2.58662134e-01f, -1.40621036e-01f, -1.62536174e-01f, -4.12883282e-01f, -4.22381729e-01f, -3.51554751e-01f, -3.59655261e-01f, -1.67187139e-01f, 4.94290024e-01f, -1.03937335e-01f,
  -5.03364146e-01f, -2.45421723e-01f, -4.58321631e-01f, -2.55334020e-01f, -4.14841503e-01f, -3.24869037e-01f, -3.63238305e-01f, -3.07501465e-01f, -3.43319952e-01f, -3.60956103e-01f,
  -6.62059486e-02f, 4.69860733e-01f, -1.75377175e-01f, 1.59475163e-01f, 8.50960240e-02f, -2.44563013e-01f, -2.29997814e-01f, -1.81245178e-01f, -3.03963184e-01f, 6.32825375e-01f,
  -1.44821241e-01f, 5.90861201e-01f, -3.98792028e-01f, 2.50718087e-01f, -9.29954797e-02f, 1.43407196e-01f, -3.27881753e-01f, -1.17273331e-01f, -9.46227834e-02f, 4.33239013e-01f,
  -4.40523267e-01f, 4.76174444e-01f, -2.29464442e-01f, -2.00415626e-01f, 1.53734967e-01f, 1.03797898e-01f, -3.87116611e-01f, 4.07438695e-01f, -2.77455211e-01f, -3.05709429e-02f,
  -2.30611071e-01f, -3.52606088e-01f, -7.61101022e-02f, -4.00394350e-01f, -1.65867060e-01f, 5.21749139e-01f, 2.55695045e-01f, 2.57080615e-01f, 3.82921904e-01f, -3.22394483e-02f,
  1.82354316e-01f, -5.66663258e-02f, -3.13427210e-01f, -3.49878930e-02f, -5.77771217e-02f, -9.15813297e-02f, -1.83996856e-01f, -1.72992796e-01f, -4.54992354e-01f, -1.53633043e-01f,
  2.03276694e-01f, -4.33915794e-01f, 2.93468237e-01f, -2.79470086e-02f, -7.07279006e-03f, 1.14230914e-02f
};

// L1_linear_B (Shape: 1 x 12)
const int L1_linear_B_rows = 1;
const int L1_linear_B_cols = 12;
const float L1_linear_B_data[] = {
  -3.92524265e-02f, -5.63308746e-02f, 9.85886231e-02f, -1.68222748e-02f, -1.08767837e-01f, -4.86165509e-02f, -2.81610247e-02f, -1.06335189e-02f, 2.66956929e-02f, 1.80369560e-02f,
  -3.91367376e-02f, 5.22535332e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 25, 78
    );
    
    // Camada 1: L1_linear
    linear_forward_pgm(
        buffer1, x_out,
        L1_linear_W_data, L1_linear_B_data,
        128, 12
    );
    }
    