/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 16 (x1)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 16;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    static inline float fan_activation(float x) { return x; }

    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 1 x 120)
const int L0_fan_Wp_rows = 1;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -1.57255679e-01f, -1.34072527e-01f, -9.91411135e-02f, -3.51126909e-01f, -2.29955651e-02f, 2.95233816e-01f, 1.71551213e-01f, -1.44370109e-01f, -4.29773986e-01f, 2.86705885e-02f,
  1.15913808e-01f, -1.54184982e-01f, 1.15147531e-01f, 7.78073072e-02f, 4.79861379e-01f, 2.67911971e-01f, 6.88024834e-02f, -3.49195898e-02f, -1.19597748e-01f, -2.26581022e-01f,
  -7.75792375e-02f, 1.00358777e-01f, 1.66474476e-01f, -5.72534613e-02f, -1.18687637e-01f, -2.60676324e-01f, 2.39823032e-02f, -6.41380176e-02f, 1.20412037e-01f, 2.28451997e-01f,
  2.34223112e-01f, -1.70756519e-01f, -1.08505003e-01f, 7.11796805e-02f, -1.19709810e-02f, 5.05930446e-02f, 9.02095884e-02f, 1.17554441e-01f, -4.17871028e-02f, -6.77929446e-02f,
  -1.77297629e-02f, 3.86146046e-02f, -1.68641265e-02f, -1.99516136e-02f, -2.89386734e-02f, -7.79300183e-02f, -9.44991503e-03f, 4.19165641e-02f, -5.89096136e-02f, 2.97057088e-02f,
  -4.39261273e-02f, 8.28316361e-02f, -6.61795512e-02f, 8.15657377e-02f, 1.18191680e-03f, -4.90575098e-02f, 5.18466718e-02f, 1.93089582e-02f, 3.73574533e-02f, -5.51606305e-02f,
  7.65869452e-04f, -2.52889302e-02f, 2.62028985e-02f, -3.00777890e-02f, 1.24050193e-02f, -4.49105985e-02f, -5.89805376e-03f, 5.56573123e-02f, -5.13123348e-02f, 2.88000237e-02f,
  -1.66676696e-02f, -4.02483307e-02f, -2.24184198e-03f, 9.70354769e-03f, -4.16741706e-03f, -2.71492209e-02f, 5.69165908e-02f, -8.09831452e-03f, -5.17978473e-03f, -2.76593063e-02f,
  1.96860302e-02f, 4.48170751e-02f, -3.85371111e-02f, 1.57973114e-02f, 7.51965120e-02f, 1.15075791e-02f, -2.57269270e-03f, -1.71089470e-02f, -5.67829274e-02f, 5.71697205e-02f,
  2.40509734e-02f, -1.80613264e-01f, -2.96394732e-02f, -2.15812027e-02f, -2.79492158e-02f, 3.64844985e-02f, -5.47077460e-03f, -5.00314571e-02f, -2.80434731e-02f, 9.32260975e-03f,
  2.72518415e-02f, -4.00815569e-02f, 1.96120869e-02f, 5.07750250e-02f, 2.15753112e-02f, 7.14577362e-02f, 3.07094827e-02f, -3.28814867e-03f, -2.07000766e-02f, 1.04717454e-02f,
  -4.97527793e-02f, -5.25765531e-02f, -4.18530777e-02f, -2.22201310e-02f, -1.29144806e-02f, 5.57334628e-03f, -6.80507943e-02f, 2.05990486e-02f, 5.37782125e-02f, -9.76909604e-03f
};

// L0_fan_Wp_bar (Shape: 14 x 120)
const int L0_fan_Wp_bar_rows = 14;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -2.11406291e-01f, 2.66219437e-01f, 5.30670345e-01f, -2.10285291e-01f, -5.77866193e-03f, -1.82757258e-01f, -3.32877755e-01f, 2.61786252e-01f, -3.27064842e-01f, -2.67955810e-01f,
  -3.41765694e-02f, -3.15262944e-01f, 3.31451684e-01f, -5.79182245e-03f, 3.30543011e-01f, 3.19018126e-01f, 3.91996466e-02f, -2.09647581e-01f, 1.60949782e-01f, 2.28319958e-01f,
  2.38687485e-01f, 7.74594098e-02f, 6.56194150e-01f, 4.35232401e-01f, 1.20391227e-01f, -3.98683129e-03f, 1.95857882e-01f, 2.55156368e-01f, -4.23294455e-02f, -3.87900136e-02f,
  -1.05869085e-01f, 1.62207544e-01f, 1.30382687e-01f, 1.11936694e-02f, 1.51265576e-01f, -9.94419828e-02f, -1.23632714e-01f, -2.44019777e-02f, -3.53298075e-02f, -8.71486738e-02f,
  -1.20926276e-01f, 1.44641455e-02f, 9.37954150e-03f, 9.30507481e-03f, -5.27541675e-02f, 2.20510680e-02f, 5.64992577e-02f, 4.94208261e-02f, 4.33570519e-02f, 1.16922580e-01f,
  1.59222573e-01f, 1.13177421e-02f, 4.16631736e-02f, -1.03826776e-01f, 4.70613912e-02f, -1.09831348e-01f, -5.28393015e-02f, -3.33321355e-02f, -6.61046430e-02f, -1.80425439e-02f,
  1.52490646e-01f, -9.78438780e-02f, -7.07199425e-03f, 4.24447320e-02f, -4.66588177e-02f, 8.20086524e-03f, -2.07044557e-02f, -1.09663140e-02f, 4.32527922e-02f, -1.28586804e-02f,
  -1.48062361e-02f, 4.13211025e-02f, -9.25860647e-03f, -1.34222552e-01f, -3.14134248e-02f, -4.62421849e-02f, -6.03122113e-04f, 3.66995968e-02f, -3.66864330e-03f, 6.92335591e-02f,
  -1.01416826e-01f, -5.25943264e-02f, 9.95469466e-03f, -1.94467157e-02f, -3.09988204e-02f, -4.45474312e-02f, 2.38482747e-02f, 5.35443574e-02f, 8.84994045e-02f, -2.61678696e-02f,
  5.89795560e-02f, 3.66599083e-01f, 1.16623305e-01f, -1.46386236e-01f, -4.75873686e-02f, 3.05829681e-02f, 7.34887868e-02f, 4.01919074e-02f, 2.54494511e-02f, -8.69491720e-04f,
  -4.37398516e-02f, -2.25677080e-02f, -9.01124850e-02f, -2.65441611e-02f, 2.67352164e-03f, 3.02714705e-02f, -8.70583486e-03f, -1.72795370e-01f, -1.07700070e-02f, 1.28289312e-01f,
  -1.40093965e-02f, -1.13227656e-02f, -4.30893451e-02f, -1.90119017e-02f, -8.10773298e-02f, -4.40862887e-02f, -3.05236503e-02f, -2.87012421e-02f, 2.29950640e-02f, -8.08110982e-02f,
  9.74321306e-01f, -8.36898610e-02f, -5.26869655e-01f, 6.65288493e-02f, 3.75303775e-01f, 7.44607031e-01f, 4.45434928e-01f, 2.91644752e-01f, 3.22384626e-01f, 1.44102052e-02f,
  2.07125142e-01f, 2.24553817e-03f, -3.58806670e-01f, 3.67102116e-01f, 4.34866965e-01f, -2.85569634e-02f, 5.42018056e-01f, 2.33983427e-01f, 9.54887420e-02f, 2.46960431e-01f,
  1.03939526e-01f, 5.34230411e-01f, -4.29686904e-01f, 2.24032835e-03f, 3.59399438e-01f, -2.70012468e-01f, -2.08855465e-01f, -3.36576313e-01f, -1.72470082e-02f, 1.60931319e-01f,
  8.98851901e-02f, 4.73356843e-02f, -1.25808403e-01f, -6.83510825e-02f, 1.13554462e-03f, -4.90082838e-02f, -1.34106264e-01f, -1.60993412e-01f, -9.71736386e-02f, 6.09056931e-03f,
  -1.17915245e-02f, -1.28265808e-03f, 1.16566241e-01f, -2.05264743e-02f, 1.53649300e-01f, -6.17696866e-02f, -5.98962493e-02f, -5.69020212e-02f, -1.09687008e-01f, 5.27179241e-02f,
  -5.33567593e-02f, -7.49001354e-02f, 3.20859775e-02f, -6.43800721e-02f, -1.03795588e-01f, 6.70694485e-02f, -8.38660169e-03f, -1.03197195e-01f, 8.54300708e-02f, 1.60161510e-01f,
  1.61092117e-01f, 9.29724127e-02f, 1.03986844e-01f, -4.78718337e-03f, 7.63751119e-02f, -3.91768180e-02f, 1.27308713e-02f, -5.82034178e-02f, -6.61757514e-02f, 2.55352426e-02f,
  -3.87474969e-02f, 9.22110677e-03f, 3.91444601e-02f, 3.81979644e-02f, 8.13476592e-02f, 3.85580435e-02f, -2.93868990e-03f, 2.03672722e-02f, -2.05329172e-02f, -5.63897155e-02f,
  -1.16019003e-01f, 8.43447149e-02f, 3.81907355e-03f, -8.27863216e-02f, 4.25713733e-02f, -8.88977423e-02f, 7.97864869e-02f, 3.57354619e-02f, -9.49094146e-02f, -8.71147495e-03f,
  -7.25344270e-02f, 1.54582605e-01f, 8.35547317e-03f, 1.12640895e-02f, -1.34245068e-01f, 1.31955475e-01f, 6.40077218e-02f, 1.21678539e-01f, 2.50734929e-02f, 1.49985239e-01f,
  -6.36813929e-03f, 6.11393526e-03f, 2.77647898e-02f, -1.02876034e-02f, -1.11527137e-01f, 1.51167452e-01f, 1.53055256e-02f, -2.60677952e-02f, 4.10203263e-02f, -7.24289566e-02f,
  -3.94691676e-02f, 7.58384913e-02f, -3.36895995e-02f, -5.72250318e-03f, 3.23788784e-02f, -4.18540016e-02f, 4.55747694e-02f, -9.90464985e-02f, 2.00047530e-03f, -7.07411766e-02f,
  4.44492280e-01f, 4.84025925e-01f, 5.60432851e-01f, 2.32795939e-01f, -3.38488102e-01f, -8.94942135e-02f, -7.90076610e-03f, -1.73724353e-01f, -1.70720294e-01f, 1.84898674e-02f,
  -2.24990800e-01f, 7.38887191e-01f, -1.21231992e-02f, 2.02822849e-01f, -8.82064849e-02f, -2.87367105e-01f, 4.58462648e-02f, 3.47616114e-02f, -2.52822880e-02f, 1.00825064e-01f,
  -1.06446490e-01f, -2.10096821e-01f, 6.18815683e-02f, -1.85588896e-01f, 3.40886444e-01f, 3.07645410e-01f, -1.05941847e-01f, -1.67480633e-02f, 3.09039205e-01f, 8.75367522e-02f,
  -3.39085720e-02f, -3.01768351e-02f, 1.29763484e-01f, 1.60769910e-01f, -7.06289103e-03f, 1.05496105e-02f, 8.26072767e-02f, 9.76539329e-02f, -3.11945137e-02f, 1.77662112e-02f,
  1.89429119e-01f, 1.86347477e-02f, 8.92172605e-02f, -4.99273092e-02f, -9.04503744e-03f, 7.26544708e-02f, 6.45544827e-02f, 8.83806273e-02f, 1.57900304e-01f, 1.48939550e-01f,
  1.64250955e-01f, 1.46372899e-01f, 7.48613700e-02f, 3.63831036e-03f, 3.60721722e-02f, -5.76372668e-02f, 1.86108761e-02f, 1.67376682e-01f, 9.31609273e-02f, -9.76309739e-03f,
  6.48998320e-02f, -6.46038651e-02f, -1.26220752e-02f, 1.02801630e-02f, 1.83556741e-03f, -1.01566583e-01f, 9.51073170e-02f, -8.37471616e-03f, 3.91404480e-02f, -8.48691836e-02f,
  7.86594115e-03f, 7.01409504e-02f, -7.23254904e-02f, -6.17537228e-03f, 1.80956740e-02f, -2.52468064e-02f, 2.47862767e-02f, 2.07515955e-02f, -1.79625880e-02f, 3.18075269e-02f,
  -9.47247520e-02f, 2.76233506e-04f, 3.31804901e-02f, -5.34389913e-02f, -8.39195475e-02f, -1.07289441e-02f, 8.44173431e-02f, 1.35219142e-01f, -9.54159945e-02f, 5.15588336e-02f,
  -5.88823706e-02f, 1.73284560e-01f, -1.18116438e-02f, 3.43591161e-02f, 4.40158844e-02f, -3.59537750e-02f, 9.96588357e-03f, 8.36315006e-03f, 8.66490752e-02f, -8.81894603e-02f,
  -1.22631164e-02f, -1.70799568e-02f, -1.38011687e-02f, 4.33845446e-02f, -6.38475940e-02f, -4.28157412e-02f, 2.01775264e-02f, 1.83065273e-02f, -2.91500110e-02f, 3.72325219e-02f,
  6.76953271e-02f, 3.01402970e-03f, 1.63650550e-02f, 6.89772516e-03f, -1.21986968e-02f, -5.56998998e-02f, 5.09721935e-02f, 2.45254003e-02f, 8.10663700e-02f, 3.69525142e-02f,
  2.07008749e-01f, 1.22481674e-01f, -1.18827492e-01f, -1.57130584e-01f, -2.12647110e-01f, -7.46433735e-01f, -6.41934872e-01f, -1.61287129e-01f, 2.52480328e-01f, -3.56747285e-02f,
  -9.74555314e-02f, 2.19575390e-01f, 2.64095694e-01f, -4.15834159e-01f, -1.78346530e-01f, 1.50902286e-01f, -5.38614988e-01f, -2.39024118e-01f, 1.23531789e-01f, -2.56451041e-01f,
  -2.90308520e-02f, -3.48695487e-01f, -1.42698199e-01f, -1.53228650e-02f, -3.79422426e-01f, -2.54152566e-02f, 3.20325010e-02f, 9.96205863e-03f, -2.25533202e-01f, -4.42516133e-02f,
  -1.34921595e-01f, 2.57371426e-01f, -1.53067233e-02f, -2.67053675e-02f, -1.42289683e-01f, -1.10721871e-01f, -1.10206850e-01f, -5.35195321e-02f, 9.35064256e-02f, -1.06056836e-02f,
  6.28971457e-02f, 8.17580596e-02f, 6.57466939e-03f, 8.10607597e-02f, -2.42624842e-02f, -4.86570597e-02f, 1.69876423e-02f, -4.11306741e-03f, -3.95807251e-02f, 7.84826055e-02f,
  -2.94567086e-02f, -4.74679954e-02f, -1.35808274e-01f, 8.44983011e-03f, 2.60732602e-02f, 1.02596032e-02f, -1.28487557e-01f, -4.96879406e-02f, -5.09046242e-02f, -2.75563989e-02f,
  3.25461663e-02f, 2.13536080e-02f, -1.68379061e-02f, -2.45685671e-02f, -2.76819710e-02f, -2.23938413e-02f, -1.09193167e-02f, -2.70061847e-03f, -2.89432723e-02f, -1.88549720e-02f,
  8.49641208e-03f, 5.02369478e-02f, 6.41554892e-02f, -5.32747954e-02f, 7.68386805e-03f, 2.31402554e-03f, -1.81549489e-02f, 1.62078384e-02f, -8.25630724e-02f, -9.14317593e-02f,
  8.49262774e-02f, -7.17494786e-02f, 2.07086727e-02f, -3.79255298e-03f, -6.81741908e-02f, 8.79851729e-02f, -2.02170815e-02f, 9.60179046e-02f, 9.04652197e-03f, -5.97846434e-02f,
  -1.95209444e-01f, -3.48425731e-02f, -6.88132225e-03f, 3.74997556e-02f, -1.02947630e-01f, -7.14863688e-02f, -4.22063470e-02f, -1.70192178e-02f, -6.33946732e-02f, -6.98722340e-03f,
  -8.73301253e-02f, -8.07292983e-02f, -9.29255411e-02f, 7.37963989e-02f, 5.71768433e-02f, -8.58755037e-02f, -1.54540390e-02f, 1.31759485e-02f, -7.70483613e-02f, -1.12252254e-02f,
  4.99842353e-02f, 7.30061764e-03f, -7.50734564e-03f, -6.66559041e-02f, -2.58883368e-02f, -9.86135900e-02f, -2.66482513e-02f, 5.72874174e-02f, 8.42083693e-02f, 1.83459856e-02f,
  4.81937155e-02f, -2.22880244e-01f, 5.87502718e-01f, 8.99847001e-02f, 2.41265938e-01f, 5.00522971e-01f, 7.79359162e-01f, 9.50034428e-03f, 2.61177868e-01f, -4.83855933e-01f,
  -2.40573227e-01f, -6.43829405e-02f, 3.17808539e-01f, -2.10438892e-01f, 5.95047951e-01f, 2.55128294e-01f, 6.52237087e-02f, -5.16332574e-02f, 2.33999178e-01f, -1.35634840e-01f,
  -7.60605410e-02f, -3.21658313e-01f, 1.38283804e-01f, -4.78985935e-01f, -1.15090117e-01f, -2.86309302e-01f, -4.61354822e-01f, 2.95637101e-01f, -4.51442063e-01f, 8.30169618e-02f,
  -1.49265945e-01f, -1.02341279e-01f, -1.34208798e-01f, -6.50166124e-02f, -2.61379648e-02f, 5.49758635e-02f, 6.68024868e-02f, 1.54941738e-01f, 6.54495582e-02f, -1.27513688e-02f,
  1.93122569e-02f, -4.78433520e-02f, -1.08113661e-01f, 6.99623898e-02f, 2.47378089e-02f, -1.66683391e-01f, 8.85092653e-03f, -5.68979420e-02f, 2.25773416e-02f, 1.04676753e-01f,
  8.23737159e-02f, -5.50396144e-02f, 6.08186200e-02f, -6.76094294e-02f, 2.06207950e-02f, 3.79473716e-02f, 1.06568761e-01f, 1.10744715e-01f, -5.92195466e-02f, 3.21181193e-02f,
  8.11243989e-03f, 1.36865363e-01f, 3.74255218e-02f, -6.10667281e-02f, 1.86764007e-03f, -4.69059758e-02f, -2.23019794e-02f, -9.06427354e-02f, 3.96811105e-02f, -8.29944760e-03f,
  -7.67357042e-03f, -7.72442967e-02f, -3.18905078e-02f, 3.35293151e-02f, -5.75550199e-02f, -6.01633545e-03f, 4.42302227e-02f, -7.75852576e-02f, -3.24017275e-03f, -5.73571548e-02f,
  1.57389622e-02f, 3.70624028e-02f, -1.75565146e-02f, -2.78305151e-02f, -1.07396999e-02f, 7.21330494e-02f, -1.17212608e-01f, 7.66468942e-02f, 2.72132154e-03f, 1.59554612e-02f,
  -2.95290351e-01f, -3.10996950e-01f, -7.18047544e-02f, -1.01180948e-01f, -6.47656471e-02f, -1.11436792e-01f, -2.29779631e-02f, -9.58919302e-02f, 4.10761498e-02f, 3.43052596e-02f,
  -8.65773559e-02f, -2.19642725e-02f, -3.45848799e-02f, -1.89773422e-02f, -2.88008177e-03f, -3.73529121e-02f, 4.14826758e-02f, -4.33359183e-02f, -5.43521829e-02f, -1.47094280e-01f,
  -7.72371739e-02f, -1.33225904e-03f, 6.38263375e-02f, -1.09703451e-01f, -9.66175422e-02f, -9.36741158e-02f, -7.37092122e-02f, -6.66379416e-03f, 7.37651775e-04f, 5.19543961e-02f,
  -4.52263206e-01f, 1.82746142e-01f, -1.66143954e-01f, -2.52542317e-01f, 3.48358266e-02f, -1.27750590e-01f, -9.10372809e-02f, 4.64473329e-02f, 6.40424639e-02f, 2.28359476e-01f,
  1.92314327e-01f, -2.26109028e-02f, 3.30549091e-01f, -7.44752288e-02f, -3.94760668e-01f, 8.51810351e-02f, -3.78294766e-01f, -1.93876773e-01f, 4.62912722e-03f, -1.76447436e-01f,
  -2.64729738e-01f, 1.28556564e-01f, -1.35042205e-01f, 2.84707099e-01f, -1.30054235e-01f, -2.86725219e-02f, 7.69411400e-03f, 2.81985372e-01f, -5.70715070e-02f, 1.24141648e-01f,
  -1.50319517e-01f, 5.32885306e-02f, -2.74225622e-02f, 4.60379049e-02f, -1.41499400e-01f, -7.77970627e-02f, -5.59035651e-02f, 8.74243751e-02f, 5.52796833e-02f, -6.85802326e-02f,
  -5.43613397e-02f, 6.52525648e-02f, 1.90367736e-03f, 1.44776493e-01f, 8.70317146e-02f, -4.20605624e-03f, -3.78023908e-02f, -1.21031061e-01f, 2.18215380e-02f, -2.23915968e-02f,
  -8.92145187e-02f, -8.68148264e-03f, -7.06648082e-02f, -1.23850942e-01f, -7.92500302e-02f, 8.59008282e-02f, -6.54039010e-02f, -9.85891223e-02f, -1.17914721e-01f, -6.61384016e-02f,
  5.19618131e-02f, -5.82536012e-02f, -4.13435735e-02f, 6.56431988e-02f, 1.62561256e-02f, 5.37052862e-02f, -6.38934842e-04f, -8.04803241e-03f, -5.15668560e-03f, -1.84096191e-02f,
  2.94043627e-02f, -1.65004842e-02f, 1.42737292e-02f, -2.43504439e-02f, -4.39462103e-02f, -5.24425395e-02f, 1.37307961e-02f, -7.20789731e-02f, -1.83608159e-02f, 1.53561728e-03f,
  7.94532299e-02f, -1.48720155e-03f, 4.39696014e-03f, -6.05963506e-02f, -4.76698950e-02f, 1.33369248e-02f, 5.67405410e-02f, 4.33317348e-02f, -4.44498584e-02f, -1.88490301e-02f,
  -2.13839456e-01f, -8.10131356e-02f, 1.45274866e-02f, 1.33041531e-01f, -8.14201534e-02f, -1.19942449e-01f, -6.22590967e-02f, -1.98618975e-02f, -8.68197307e-02f, 4.25330102e-02f,
  -1.31872699e-01f, -4.14667046e-03f, -3.75596285e-02f, 4.70826551e-02f, -3.65889445e-02f, 3.29582533e-03f, 2.32447106e-02f, -7.71126673e-02f, -5.95760122e-02f, -3.66446376e-02f,
  -7.46201165e-03f, -5.69693148e-02f, 4.43591848e-02f, -5.46100214e-02f, 7.00948341e-03f, -7.92813599e-02f, -1.33670554e-01f, 4.43127751e-03f, -8.80799592e-02f, -6.27061501e-02f,
  3.32387745e-01f, -2.98694044e-01f, 1.20504573e-01f, 5.77790856e-01f, 1.63931340e-01f, -6.32567629e-02f, -6.38396069e-02f, 2.22733855e-01f, 2.98565120e-01f, -2.31614828e-01f,
  -3.10632270e-02f, -7.44443536e-02f, -4.16057587e-01f, 6.79817349e-02f, -7.54124597e-02f, -3.78077924e-01f, 1.52103081e-01f, -1.04577310e-01f, 6.78381026e-02f, 1.43594101e-01f,
  3.49980623e-01f, -2.74978355e-02f, 1.00189827e-01f, -6.09737374e-02f, 1.84646577e-01f, 3.65057588e-01f, -1.25867426e-02f, -1.55208290e-01f, 2.00142488e-01f, -1.12553455e-01f,
  -1.16435634e-02f, 1.97732612e-01f, 1.78863749e-01f, 4.33238707e-02f, 1.07013226e-01f, 2.33903378e-02f, 1.73564684e-02f, -6.70415312e-02f, 1.18385836e-01f, -2.10636016e-02f,
  -3.54030840e-02f, 3.85275558e-02f, 1.24618039e-01f, -6.72663972e-02f, 8.09089541e-02f, 9.79499593e-02f, 5.20985350e-02f, 5.57664037e-02f, 9.83522609e-02f, 2.31021661e-02f,
  6.47157505e-02f, 5.61158732e-02f, 1.54816136e-01f, -6.84334291e-03f, 9.68647525e-02f, 1.63656957e-02f, -1.24460094e-01f, -6.25008196e-02f, 3.73743214e-02f, 1.02350727e-01f,
  -1.08425029e-01f, 2.61515286e-02f, 5.73213585e-03f, 6.86300499e-03f, -5.75268269e-02f, 6.48479164e-02f, 5.36440872e-03f, -5.92587329e-02f, 3.91854756e-02f, -8.56934935e-02f,
  1.81179568e-02f, 1.17339954e-01f, 3.43630500e-02f, -9.12090484e-03f, 5.60967438e-02f, -2.91702431e-03f, -1.50111048e-02f, -3.16389091e-02f, 8.88267606e-02f, 8.86822492e-02f,
  -4.01880480e-02f, -3.66402157e-02f, -8.21252987e-02f, 9.36157908e-03f, -9.24612507e-02f, -3.06677613e-02f, -1.31432172e-02f, -4.50990312e-02f, -5.91531768e-03f, -9.93572250e-02f,
  -2.15458438e-01f, -2.69163162e-01f, -8.35053623e-03f, 1.77098978e-02f, -7.37380013e-02f, -2.58797407e-02f, -9.30335522e-02f, -3.79454456e-02f, -1.43523542e-02f, -6.79416433e-02f,
  7.66483173e-02f, -2.88930023e-03f, -7.53851682e-02f, 1.57182068e-02f, 3.10141575e-02f, -6.34757578e-02f, 6.59087673e-02f, 4.29839380e-02f, 3.65707949e-02f, 4.57731485e-02f,
  -4.82052471e-03f, -7.09865615e-02f, -1.10526318e-02f, 5.85962906e-02f, -3.66961360e-02f, 4.38830210e-03f, 1.87683938e-04f, -4.38669920e-02f, -7.09013119e-02f, -7.01715276e-02f,
  -1.58638358e-01f, 5.11824906e-01f, 2.21565112e-01f, 1.58962011e-01f, -1.50441408e-01f, 2.67388076e-01f, 1.03740349e-01f, 1.68264046e-01f, 3.23347598e-01f, 2.73222119e-01f,
  -3.14476460e-01f, 2.36174211e-01f, -1.40596643e-01f, 3.39376450e-01f, -1.39254197e-01f, 1.49208829e-01f, 3.19773763e-01f, 2.37863183e-01f, 1.90890267e-01f, 4.16755006e-02f,
  -5.42356707e-02f, -1.36482850e-01f, -1.58711225e-02f, -4.51653451e-02f, -1.51749074e-01f, -3.54046910e-03f, -4.19894278e-01f, -1.65344223e-01f, 1.08528771e-01f, -5.01468852e-02f,
  -8.91816095e-02f, -1.28844351e-01f, -2.51203543e-03f, 8.09269026e-02f, -9.11317617e-02f, 1.87613815e-02f, -7.49832317e-02f, -3.78030278e-02f, -1.09521151e-02f, 7.66117349e-02f,
  -3.78624685e-02f, 3.09118535e-02f, 1.10534601e-01f, -7.15791807e-02f, 1.12509303e-01f, 7.23784193e-02f, 8.61418471e-02f, -7.57193044e-02f, 5.03876656e-02f, 8.86491314e-03f,
  7.47956410e-02f, 3.02770101e-02f, -1.94065366e-03f, 1.16130121e-01f, -1.91665813e-02f, 2.24658777e-03f, 1.18094675e-01f, -8.57847705e-02f, 1.19224310e-01f, 1.26125872e-01f,
  2.73372494e-02f, -8.53044074e-03f, 1.72641743e-02f, -8.93099383e-02f, 1.89453587e-02f, -4.60056737e-02f, 2.87710931e-02f, -1.08035184e-01f, 2.91154236e-02f, -2.33624019e-02f,
  -1.68215984e-03f, 4.99895168e-03f, 1.25139104e-02f, 5.66514172e-02f, -3.62892263e-02f, 5.43751121e-02f, -2.17895117e-02f, -7.80894160e-02f, 8.75827074e-02f, -6.68368414e-02f,
  -2.89879125e-02f, 2.12612804e-02f, -7.64050335e-02f, -2.97746174e-02f, 6.16832376e-02f, -8.61496851e-02f, 8.62336718e-03f, 2.73408671e-03f, -6.20024167e-02f, -1.01051562e-01f,
  2.73154303e-02f, 1.33166099e-02f, 5.50764762e-02f, 9.68214311e-03f, 3.52483094e-02f, -4.55230512e-02f, 1.02284634e-02f, 3.06943171e-02f, 6.82989880e-02f, 3.37792784e-02f,
  -1.00528121e-01f, 9.56041887e-02f, 1.62357911e-02f, 3.69047821e-02f, -1.33564754e-05f, -5.94444163e-02f, -5.79344593e-02f, 7.78733343e-02f, 1.26332240e-02f, -1.46760866e-02f,
  -5.47150671e-02f, -8.91913101e-03f, 5.99378422e-02f, -6.30676150e-02f, 4.11909893e-02f, -8.04450586e-02f, -5.31922840e-03f, 5.17623238e-02f, -1.04157768e-01f, 1.39403734e-02f,
  -1.00670084e-01f, -2.69405454e-01f, -3.63193750e-01f, 1.59349293e-01f, 8.99886712e-02f, -1.35695159e-01f, -3.85947764e-01f, 8.57531801e-02f, -4.90637630e-01f, -2.97671016e-02f,
  1.97014272e-01f, -2.26932466e-01f, -4.54250544e-01f, 1.79189876e-01f, 1.52750477e-01f, -3.65729988e-01f, 2.65760124e-01f, 2.31968146e-02f, -1.42376840e-01f, 2.54442453e-01f,
  3.12082976e-01f, 5.36139369e-01f, 1.43521875e-01f, 4.97790277e-01f, 1.37003273e-01f, 3.33949417e-01f, 6.29268527e-01f, -3.08287777e-02f, 5.73964059e-01f, 1.69878095e-01f,
  -7.74587989e-02f, -1.30679846e-01f, -1.94748133e-01f, -9.38385576e-02f, 1.30986035e-01f, 1.01514064e-01f, 7.16340495e-03f, 1.95328910e-02f, -1.63715016e-02f, -1.62796918e-02f,
  -1.31520182e-02f, 4.29170094e-02f, 4.18068729e-02f, -4.24779318e-02f, 3.70384986e-03f, 6.49680421e-02f, -3.33853625e-02f, -5.84274046e-02f, -8.14876407e-02f, -8.05732757e-02f,
  -1.19095802e-01f, 5.43349702e-03f, 5.34319170e-02f, 7.20806979e-03f, -3.70565467e-02f, -1.12794721e-02f, 8.38272925e-03f, -2.63295770e-02f, 2.98362505e-02f, 3.79118435e-02f,
  1.56432882e-01f, 4.74122539e-02f, -9.59150419e-02f, -4.75290380e-02f, 7.14261085e-03f, 1.22952648e-02f, 1.31786941e-02f, -2.25734804e-02f, 6.77890657e-03f, 8.70531425e-03f,
  2.31640302e-02f, 5.57156354e-02f, 1.65269536e-03f, 5.05513549e-02f, 4.25067768e-02f, -9.48266685e-03f, -4.09524608e-03f, 2.55928207e-02f, 3.18815820e-02f, -3.80167402e-02f,
  -6.39464613e-03f, 4.11201781e-03f, 2.81333062e-03f, 1.39963478e-02f, -4.82318550e-02f, 1.58019792e-02f, 8.68564099e-02f, -8.74505490e-02f, 2.64103524e-02f, 7.23744407e-02f,
  1.43716469e-01f, 2.99446702e-01f, -1.10961996e-01f, -3.08050290e-02f, -4.63067926e-02f, 5.78622147e-02f, -2.14467831e-02f, 2.54365224e-02f, 5.53088784e-02f, -5.16641140e-02f,
  1.26237020e-01f, 4.93815765e-02f, 7.35469684e-02f, 5.27827553e-02f, 1.18254177e-01f, -2.36835908e-02f, 9.00646746e-02f, 4.60708067e-02f, 1.15378775e-01f, 2.35569924e-01f,
  8.04119036e-02f, 6.71707140e-03f, -2.00153049e-02f, -7.95504004e-02f, 1.05907619e-01f, 9.74799693e-03f, 2.73207687e-02f, 7.35787004e-02f, 6.92987591e-02f, 9.26216505e-03f,
  -3.59744370e-01f, 8.04814696e-02f, -1.35537803e-01f, -3.03240091e-01f, 2.74409622e-01f, -1.02255642e-01f, -1.42320439e-01f, 1.25824466e-01f, -2.11921513e-01f, 3.14717799e-01f,
  4.87677529e-02f, -1.58662200e-01f, -3.79120000e-02f, -4.48826343e-01f, -9.54291463e-01f, -4.94526386e-01f, -4.41309214e-01f, -2.53368795e-01f, -2.31837004e-01f, -2.72103660e-02f,
  -3.42549831e-01f, -4.49501090e-02f, -2.51598388e-01f, 3.31038177e-01f, 2.33884096e-01f, 3.01487237e-01f, 1.80959210e-01f, 3.27101856e-01f, 1.05535053e-01f, -1.19387202e-01f,
  -7.26205036e-02f, -1.34056970e-01f, 2.26688813e-02f, 4.58544381e-02f, 7.69653171e-02f, 1.14737712e-01f, 2.18026862e-02f, -7.90112391e-02f, -7.17637241e-02f, -6.11424409e-02f,
  3.78933884e-02f, -1.70981158e-02f, -1.77051462e-02f, -4.43023741e-02f, 7.36322403e-02f, 2.53630336e-02f, -6.47252426e-02f, 3.80425784e-03f, 7.34000802e-02f, -2.40846481e-02f,
  -6.51648715e-02f, 6.76345080e-02f, -1.11645274e-02f, -9.79875252e-02f, -4.48196940e-02f, -3.87553461e-02f, 3.39226685e-02f, -4.40971111e-04f, 6.93853274e-02f, -3.03523596e-02f,
  1.28080681e-01f, 5.15952185e-02f, -1.04168681e-02f, -3.85400355e-02f, -5.32130674e-02f, 2.32508276e-02f, -4.12152149e-02f, 1.00082532e-03f, 4.67313677e-02f, 3.33097018e-02f,
  4.47682254e-02f, 1.83704998e-02f, -1.07854893e-02f, 3.77443768e-02f, -3.52796055e-02f, 2.87323333e-02f, 2.52013374e-02f, 5.72172180e-02f, -1.30077116e-02f, 1.86267565e-03f,
  1.94495786e-02f, -3.05826534e-02f, -3.13867107e-02f, 6.86950982e-02f, -6.92411363e-02f, 4.36359048e-02f, 8.81651863e-02f, -3.70985307e-02f, -5.46282381e-02f, 1.20839290e-02f,
  2.05793567e-02f, 8.34861025e-02f, 5.77918664e-02f, 3.05262320e-02f, 2.62178900e-03f, -1.32769886e-02f, 3.11245210e-02f, -7.95094445e-02f, -5.22624403e-02f, -2.72431951e-02f,
  1.14085123e-01f, 6.94319457e-02f, 3.61874029e-02f, -3.58476341e-02f, 2.72630416e-02f, 1.85888410e-02f, 2.51896903e-02f, 8.88864696e-02f, 8.55072066e-02f, 6.82823267e-03f,
  1.03688203e-01f, 9.66786295e-02f, -7.43933022e-02f, 4.62576672e-02f, 3.39359902e-02f, 1.17109753e-01f, 3.31252366e-02f, 5.67975007e-02f, 6.44716918e-02f, -1.61934644e-02f,
  5.13564609e-02f, 1.96319431e-01f, -8.05384219e-02f, 4.83212359e-02f, -1.92921638e-01f, -1.14422955e-01f, -2.09673524e-01f, 1.15236133e-01f, 5.24885118e-01f, 5.58966994e-02f,
  -2.28573129e-01f, 2.27661952e-01f, -2.05562133e-02f, -2.03141317e-01f, 2.78539896e-01f, 2.74119139e-01f, 1.31434491e-02f, -7.43281543e-02f, 1.74616680e-01f, -7.65591487e-02f,
  9.72115025e-02f, -1.99937403e-01f, -1.10015035e-01f, -2.60240555e-01f, -4.49994117e-01f, -7.70790279e-02f, -1.79072902e-01f, -2.72805423e-01f, -2.29503930e-01f, -9.40574333e-02f,
  -6.49143606e-02f, 5.88604398e-02f, -1.69616029e-01f, 2.37173792e-02f, -3.65680419e-02f, -1.81040019e-01f, -1.60213485e-02f, -1.28703162e-01f, 1.61466375e-02f, 1.67596266e-02f,
  7.29815215e-02f, 7.02332258e-02f, 1.38747944e-02f, 3.10174488e-02f, -1.03503048e-01f, 4.50250246e-02f, 9.75313131e-03f, -1.07810095e-01f, -3.18814116e-03f, -8.92420560e-02f,
  -8.20132717e-02f, 5.33563644e-02f, -3.83707248e-02f, 9.39866826e-02f, 4.08965498e-02f, -4.23392616e-02f, 1.12553164e-01f, 2.11017039e-02f, 8.79125372e-02f, 1.52413949e-01f,
  1.13910064e-01f, 9.39230844e-02f, -5.32621033e-02f, 3.73186823e-03f, 1.28558045e-02f, -3.65480334e-02f, -2.80589852e-02f, 5.41542470e-02f, 9.31499824e-02f, -6.25119731e-02f,
  -4.71170954e-02f, -3.99109386e-02f, -3.41052972e-02f, -3.10283946e-03f, -2.81667393e-02f, 7.44583234e-02f, -4.30731028e-02f, 3.81233171e-02f, 3.05823144e-02f, 9.76585150e-02f,
  2.28886195e-02f, 1.20300455e-02f, 2.75236107e-02f, -3.14497501e-02f, -1.55972885e-02f, -6.50304779e-02f, -5.42661734e-03f, -5.71297668e-02f, 4.31533419e-02f, -3.44529841e-03f,
  1.08047076e-01f, 3.71077210e-01f, -5.65195968e-03f, 1.97044220e-02f, 7.27259591e-02f, -2.65005138e-02f, 7.24170581e-02f, 9.30739865e-02f, 8.89553279e-02f, 7.69241676e-02f,
  -7.40563348e-02f, -5.95024377e-02f, -3.74512114e-02f, -6.60081580e-02f, 3.82880084e-02f, 1.07850954e-01f, -1.76342241e-02f, 6.56117424e-02f, 6.89222664e-02f, -2.30545783e-03f,
  -1.24146610e-01f, -1.11001264e-02f, 1.21885613e-02f, 8.15886855e-02f, -3.58485579e-02f, 6.46993592e-02f, -1.58703737e-02f, -2.81684101e-02f, -4.85513322e-02f, 1.00585021e-01f,
  -1.52868539e-01f, 3.95889133e-01f, 5.27410746e-01f, -3.73606943e-02f, 4.31022435e-01f, 9.43090171e-02f, -2.45282575e-01f, 4.01052028e-01f, 2.77391791e-01f, -3.03534210e-01f,
  -1.97878182e-01f, -5.09780943e-02f, -1.64673805e-01f, 4.81872335e-02f, -4.03039396e-01f, -1.74436912e-01f, -1.49722949e-01f, -3.44924122e-01f, 2.51446038e-01f, -3.37991975e-02f,
  -3.77428010e-02f, -2.71251857e-01f, 1.64883323e-02f, 1.77224442e-01f, 2.49422923e-01f, 5.05283289e-02f, -4.74549651e-01f, 6.77151009e-02f, 4.84006405e-02f, 5.37148006e-02f,
  -1.83586732e-01f, -1.29078954e-01f, -6.59051584e-03f, 4.92351092e-02f, -8.08476880e-02f, -4.75432277e-02f, -5.15799113e-02f, -3.75351049e-02f, -9.36195627e-03f, 7.85725713e-02f,
  -3.82712148e-02f, 9.98650938e-02f, 8.99152234e-02f, -2.90003838e-03f, 1.12431087e-01f, 1.47519097e-01f, 1.99864507e-01f, 1.60057276e-01f, 7.89502189e-02f, 2.55622685e-01f,
  1.26749918e-01f, 7.12895766e-02f, 6.31434470e-02f, -4.28120941e-02f, 6.10379502e-03f, 1.00293338e-01f, 3.07343062e-03f, -1.58339925e-02f, 1.13251582e-02f, 2.94045266e-02f,
  1.36405695e-02f, -1.06114216e-01f, 2.60810722e-02f, -4.16215463e-03f, 1.10610481e-02f, 6.18862621e-02f, -5.75035438e-02f, -8.11479166e-02f, -5.00982720e-03f, -8.14097151e-02f,
  -3.09871174e-02f, -2.32091952e-05f, 5.26978588e-03f, -2.21136082e-02f, -8.49181637e-02f, -2.16363128e-02f, -7.58075938e-02f, -4.09839526e-02f, 5.56534864e-02f, 1.81745403e-02f,
  -7.93585088e-03f, -7.16812536e-03f, 4.11148481e-02f, -4.85805534e-02f, -1.42061915e-02f, 3.33699696e-02f, 8.74656811e-03f, 1.22485943e-01f, 2.63562240e-02f, -8.56913105e-02f,
  -6.37460470e-01f, -7.21109092e-01f, -1.21157326e-01f, -3.92192826e-02f, -4.66700085e-02f, -1.36152571e-02f, -1.18120223e-01f, 4.36665528e-02f, -1.40711963e-01f, -9.61714797e-03f,
  -7.05621764e-03f, -9.03700888e-02f, -8.55218992e-02f, -1.29898628e-02f, -4.04344499e-02f, -5.72750084e-02f, -2.47823626e-01f, -2.40621850e-01f, -2.06113309e-01f, -8.98557231e-02f,
  -5.46424128e-02f, -7.15278387e-02f, -6.08417913e-02f, 2.15750206e-02f, -1.85412057e-02f, -9.89842415e-02f, -7.80383572e-02f, 4.56429925e-03f, -6.52023554e-02f, 5.86135983e-02f,
  2.66468495e-01f, -9.88701582e-01f, 2.28331462e-02f, 3.11867535e-01f, 3.82004201e-01f, 1.47620767e-01f, 1.19073913e-01f, -7.50804469e-02f, -1.63211793e-01f, -6.33789003e-01f,
  9.48495790e-02f, -1.34956818e-02f, -2.76512563e-01f, 2.59082437e-01f, 7.03545213e-01f, -1.86216608e-01f, 1.29987448e-01f, 3.45354788e-02f, -1.77020766e-02f, -5.46821654e-02f,
  2.44213670e-01f, 2.43457735e-01f, 2.18927532e-01f, -1.02908991e-01f, 1.94237709e-01f, -1.71271786e-01f, -1.90956164e-02f, -6.54989108e-02f, 1.19346991e-01f, 2.87002474e-01f,
  -2.66743284e-02f, -2.17409387e-01f, 3.18951905e-02f, -3.52111645e-02f, -1.49608955e-01f, -6.87132627e-02f, -2.85162404e-02f, 1.81531444e-01f, 1.41104430e-01f, -3.87995271e-03f,
  -6.00050054e-02f, 8.52243006e-02f, 2.71554776e-02f, 5.32769375e-02f, -5.29545210e-02f, -6.50205761e-02f, -1.21905459e-02f, 3.38876806e-03f, -8.01930428e-02f, 5.13873287e-02f,
  8.29867553e-03f, -3.32040084e-03f, 5.78468740e-02f, -1.83057692e-02f, 1.57129373e-02f, -8.46008677e-03f, 6.00633100e-02f, -3.61491777e-02f, -2.77707186e-02f, 2.95786764e-02f,
  -1.03418104e-01f, -8.31686705e-02f, -3.55291702e-02f, 4.64173406e-02f, 6.54183626e-02f, 9.16758776e-02f, -4.01329771e-02f, 4.16670814e-02f, -3.89559269e-02f, -4.07988243e-02f,
  6.14967309e-02f, 3.29500586e-02f, 2.21321955e-02f, 9.91547480e-03f, -1.95009040e-03f, 3.21670882e-02f, 1.03552714e-01f, 2.22710706e-02f, -4.41582650e-02f, 3.94928604e-02f,
  -4.27990593e-02f, 5.80214821e-02f, -5.74368127e-02f, 7.09602376e-03f, -3.72455232e-02f, -2.51834076e-02f, -2.57335603e-02f, -2.14497149e-02f, -3.62929218e-02f, 4.57403809e-02f,
  -4.04411525e-01f, -5.54398417e-01f, -7.35222027e-02f, -8.73262901e-03f, -1.10802568e-01f, -7.03663751e-02f, -1.24549661e-02f, -3.34649049e-02f, -1.72754541e-01f, -6.36286288e-02f,
  -1.07486740e-01f, 2.61563435e-02f, -6.21340349e-02f, -2.15792321e-02f, 5.03560714e-03f, -4.53381762e-02f, -6.66793436e-02f, -8.93273726e-02f, 9.79149435e-03f, -9.88943279e-02f,
  -2.16321386e-02f, -6.64951056e-02f, 5.52190617e-02f, 4.05655392e-02f, 3.74537893e-02f, 1.19632268e-02f, -4.54829969e-02f, -2.35449225e-02f, 3.79527025e-02f, -1.00135885e-01f,
  -7.65148640e-01f, 5.69821179e-01f, -1.98370278e-01f, -3.10453977e-02f, -2.78787822e-01f, 9.51142758e-02f, 3.04064155e-01f, 3.23355831e-02f, -7.84002617e-02f, 6.72798872e-01f,
  4.09872651e-01f, -1.45794660e-01f, 3.35513502e-01f, 6.33803487e-01f, -2.89633751e-01f, 4.20480460e-01f, 4.38395381e-01f, 3.14434677e-01f, 2.33532265e-02f, -8.20566788e-02f,
  -1.96663991e-01f, 3.26837927e-01f, 1.30437657e-01f, 1.67199299e-02f, 3.02411150e-02f, -2.23768488e-01f, -5.02260141e-02f, -1.78948641e-01f, 2.11309299e-01f, -4.27625291e-02f,
  -1.98023021e-01f, -2.13578537e-01f, -1.20507300e-01f, -2.13420823e-01f, -8.35758597e-02f, -1.35620609e-01f, -6.28024489e-02f, -1.30557165e-01f, -8.46020132e-02f, -6.89298362e-02f,
  -1.78144239e-02f, -1.02112122e-01f, 3.04238573e-02f, 4.19985168e-02f, -3.85126695e-02f, -5.64999953e-02f, -2.81095994e-03f, -6.87889708e-03f, -3.17456014e-02f, 1.83608402e-02f,
  9.97211132e-03f, 4.68450412e-02f, 3.58641185e-02f, 7.06697553e-02f, -3.80651169e-02f, 3.21446285e-02f, 4.18383628e-02f, -3.41483466e-02f, 2.75397338e-02f, -2.55720466e-02f,
  1.16244111e-04f, 3.38566862e-02f, 7.80891031e-02f, 4.00838479e-02f, -3.05775944e-02f, 4.86889444e-02f, 5.75508624e-02f, -2.78959218e-02f, 7.62496330e-03f, 3.09673715e-02f,
  -8.89114514e-02f, -9.40899458e-03f, -6.18972406e-02f, 6.50852174e-02f, 4.16870527e-02f, 3.92372124e-02f, -4.15696763e-02f, -2.82220636e-02f, -1.34273395e-02f, -3.59953232e-02f,
  1.35044497e-03f, -1.70482807e-02f, 1.39670029e-01f, 2.32352111e-02f, -3.03722750e-02f, 1.41603444e-02f, 1.90470573e-02f, 4.36507277e-02f, 1.51529396e-02f, -5.25381602e-02f,
  -4.11777310e-02f, -1.68930754e-01f, 2.66998131e-02f, -5.77834882e-02f, -6.67282492e-02f, -6.67236326e-03f, -1.98708493e-02f, -7.26579949e-02f, -6.66889176e-02f, -7.16800941e-03f,
  -6.78292662e-02f, -6.56711236e-02f, -9.61567387e-02f, -3.82260457e-02f, -4.30875383e-02f, 2.30655130e-02f, 7.45076165e-02f, -3.75496000e-02f, -3.12608443e-02f, -8.16248432e-02f,
  2.74174847e-02f, -3.24412622e-02f, -1.92729831e-02f, 7.64403120e-03f, 7.24036433e-03f, -1.54077299e-02f, -1.52690843e-01f, -3.31754051e-02f, -7.17398375e-02f, 6.38357773e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 14)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 14;
const float L0_fan_Bp_bar_data[] = {
  3.91378254e-01f, 6.36862874e-01f, 3.88956547e-01f, 5.63342944e-02f, 9.06656086e-01f, 7.65391439e-02f, 3.23223263e-01f, 5.15504062e-01f, 3.00718933e-01f, 4.79819238e-01f,
  2.56389827e-01f, 5.15284419e-01f, 2.87512153e-01f, 5.60286701e-01f
};

// L1_linear_W (Shape: 12 x 16)
const int L1_linear_W_rows = 12;
const int L1_linear_W_cols = 16;
const float L1_linear_W_data[] = {
  -4.23868060e-01f, 6.35804415e-01f, -1.49133384e-01f, -2.59322315e-01f, -3.90992850e-01f, -3.50149482e-01f, -1.17272414e-01f, 1.48712337e-01f, -6.14993013e-02f, 2.74174035e-01f,
  -2.31903702e-01f, -3.19478005e-01f, -2.60847598e-01f, -3.88072699e-01f, -2.20531404e-01f, 1.49355447e+00f, -1.85668319e-01f, 5.14822483e-01f, -1.63671691e-02f, 1.53468156e+00f,
  1.13077708e-01f, 2.61585712e-01f, -6.43631697e-01f, -1.80754006e-01f, -3.71244222e-01f, -1.39261693e-01f, 3.34438533e-01f, -3.92147809e-01f, -2.96585321e-01f, -2.70954758e-01f,
  -8.96014273e-02f, 4.33348894e-01f, -2.06629485e-01f, 1.72675148e-01f, -4.35582310e-01f, 2.37515390e-01f, -1.43766537e-01f, -8.00791308e-02f, -5.36568940e-01f, 1.01518534e-01f,
  4.14937109e-01f, 1.99855700e-01f, 8.80690217e-01f, -7.88280144e-02f, -9.47108716e-02f, 4.86893058e-02f, 1.17918706e+00f, -4.25829023e-01f, -3.26966822e-01f, -4.53989804e-01f,
  1.39408231e-01f, -5.00678897e-01f, -3.05287808e-01f, 5.21808743e-01f, -3.88854295e-01f, 9.80408430e-01f, -2.18266740e-01f, -1.72562853e-01f, -6.22745454e-01f, 6.55516326e-01f,
  -1.90752104e-01f, 5.05026221e-01f, -4.54934537e-02f, 3.60282749e-01f, 1.99801758e-01f, 8.33397746e-01f, 1.03421772e+00f, -7.07575500e-01f, -1.79602891e-01f, -3.36775512e-01f,
  7.09371388e-01f, 2.33213946e-01f, -4.86469001e-01f, 2.24025548e-01f, -2.22475871e-01f, -8.78436267e-02f, -9.15085226e-02f, 1.03269053e+00f, -2.82384753e-01f, 2.99829692e-01f,
  5.19485235e-01f, -3.25411171e-01f, -4.37838852e-01f, 6.80364966e-01f, 3.86058211e-01f, -2.78762102e-01f, 6.51803017e-01f, -1.60149291e-01f, -3.05486470e-01f, 7.77128398e-01f,
  -5.76948464e-01f, -4.79431003e-01f, 7.11960614e-01f, -5.01852036e-01f, -8.05794656e-01f, -2.17585848e-03f, 1.12850972e-01f, -5.82544208e-01f, -1.30166588e-02f, 6.65363252e-01f,
  -4.70305175e-01f, -3.47347379e-01f, 5.35671353e-01f, -1.96236148e-01f, 8.20123971e-01f, -1.36252254e-01f, -4.10910606e-01f, -1.67613819e-01f, -4.81086597e-03f, 6.23343289e-01f,
  4.95895952e-01f, -7.43283689e-01f, 6.16209581e-02f, 5.20547330e-01f, -3.70114177e-01f, -3.91875356e-01f, -7.42856562e-02f, 1.27091801e+00f, -1.60369370e-02f, 2.08841160e-01f,
  -4.06655580e-01f, -3.79542083e-01f, 2.43925136e-02f, -3.05415064e-01f, 6.86919928e-01f, -1.00610219e-01f, -1.09053195e-01f, -1.86900824e-01f, -1.58194795e-01f, -5.60746312e-01f,
  9.02793348e-01f, -3.84636968e-01f, 3.54903251e-01f, 9.89785790e-02f, -3.54030520e-01f, -1.89369887e-01f, 2.64623880e-01f, -1.60209425e-02f, 8.51560414e-01f, -5.22068024e-01f,
  2.55889356e-01f, -3.39094549e-01f, -5.04685938e-02f, 1.55499637e-01f, -2.00430989e-01f, 8.73620570e-01f, 6.78233653e-02f, -3.31960946e-01f, 3.50777507e-01f, -3.58011037e-01f,
  1.28489089e+00f, 5.62362932e-03f, -4.26089942e-01f, -6.35730803e-01f, -4.06124860e-01f, -3.23579401e-01f, -5.17138302e-01f, -5.31530619e-01f, 9.08882737e-01f, -4.91701752e-01f,
  1.55374497e-01f, -6.12036288e-01f, -2.78948635e-01f, -2.88499117e-01f, -2.90529609e-01f, -3.17984879e-01f, -5.41826367e-01f, 3.74335013e-02f, 5.60227372e-02f, -4.76072669e-01f,
  5.43369889e-01f, 1.24964666e+00f, -3.40985477e-01f, -5.42027593e-01f, -3.68223935e-01f, -2.06939891e-01f, -4.14278150e-01f, -5.64876437e-01f, -3.24326992e-01f, -4.37685192e-01f,
  1.18082297e+00f, 2.21482083e-01f, -2.28356093e-01f, -4.28248107e-01f, 3.84429961e-01f, 5.05592763e-01f, -4.90539700e-01f, 1.51297987e-01f, -6.40571639e-02f, 7.09163725e-01f,
  -4.29561973e-01f, 1.81684475e-02f
};

// L1_linear_B (Shape: 1 x 12)
const int L1_linear_B_rows = 1;
const int L1_linear_B_cols = 12;
const float L1_linear_B_data[] = {
  -4.25791787e-03f, -1.89175874e-01f, -6.49727166e-01f, -1.90210834e-01f, 1.65301546e-01f, 3.50041538e-01f, -1.78067729e-01f, -2.44632617e-01f, -4.00287956e-01f, 1.79566741e-02f,
  3.53672206e-01f, -9.55265686e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 1, 14
    );
    
    // Camada 1: L1_linear
    linear_forward_pgm(
        buffer1, x_out,
        L1_linear_W_data, L1_linear_B_data,
        16, 12
    );
    }
    