/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 128 (x1)
    * Saída: 12
    * Buffer Máx: 128
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 128;
    const int FAN_MAX_BUFFER_SIZE = 128;

    // --- Funções de Ativação ---
    static inline float fan_activation(float x) { return x; }

    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 38 x 120)
const int L0_fan_Wp_rows = 38;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -2.50257254e-01f, 3.11557502e-01f, 1.84609760e-02f, -7.51421377e-02f, -1.34498730e-01f, -1.37468457e-01f, -1.14169875e-02f, -1.60746032e-03f, -4.44061607e-02f, 4.37319241e-02f,
  6.73250705e-02f, 4.69349883e-02f, 4.36686985e-02f, 2.99003348e-02f, -4.83010598e-02f, 1.14673793e-01f, 8.90975446e-02f, -1.39593696e-02f, -2.80307055e-01f, -1.20787814e-01f,
  4.94758077e-02f, 2.82564424e-02f, -1.55579522e-01f, 3.65672335e-02f, 9.52374190e-02f, 1.04758866e-01f, 3.26016769e-02f, 7.21646249e-02f, -3.77458078e-03f, 1.21604256e-01f,
  2.53146291e-01f, -1.16844304e-01f, -1.15394890e-01f, -3.69793773e-02f, -3.12429015e-02f, -1.88097674e-02f, -2.72468366e-02f, 4.70110122e-03f, -6.04375303e-02f, 4.93423715e-02f,
  -2.89324839e-02f, -2.49301689e-03f, -3.91109623e-02f, 1.03238009e-01f, -3.51885110e-02f, 3.97324376e-03f, 7.83644319e-02f, -3.50107439e-02f, -3.41777466e-02f, 6.36562407e-02f,
  -1.73507771e-03f, -1.21419877e-01f, -5.87444343e-02f, 1.67614240e-02f, -3.25305536e-02f, -5.84586486e-02f, 4.80388440e-02f, 3.19416560e-02f, -1.16302349e-01f, 1.38856843e-01f,
  2.60739704e-03f, 9.65689644e-02f, -2.21418682e-02f, -2.66835522e-02f, 2.64898408e-02f, 8.27949271e-02f, 2.79884282e-02f, 4.39147688e-02f, 1.43661071e-02f, 7.02726766e-02f,
  -7.85490870e-03f, 5.09371310e-02f, -5.11283986e-02f, 1.58834103e-02f, 4.60088328e-02f, -4.04654592e-02f, -2.64281072e-02f, 8.63779709e-02f, -4.91822697e-02f, -7.70068318e-02f,
  -2.64738481e-02f, -5.75707555e-02f, 8.70179236e-02f, 9.19667706e-02f, -6.53508157e-02f, 1.28574008e-02f, -4.63335179e-02f, 1.73282400e-02f, -3.56385894e-02f, -6.80192783e-02f,
  2.14785293e-01f, -1.41477555e-01f, 6.54858425e-02f, -4.45804819e-02f, 6.49061054e-02f, 6.87584579e-02f, 9.57571715e-02f, -7.83862844e-02f, -1.01650050e-02f, 1.02425786e-02f,
  -2.68357471e-02f, 3.99217792e-02f, 3.54147633e-03f, 2.03795973e-02f, -8.48484263e-02f, -2.22354159e-02f, 1.43288132e-02f, -4.52353582e-02f, 8.07863846e-02f, 1.22045716e-02f,
  -1.08107226e-03f, 3.67359966e-02f, 3.08453776e-02f, 6.57628775e-02f, -5.82632050e-02f, -1.34757012e-01f, 7.87351727e-02f, -3.19112390e-02f, 3.83697599e-02f, 1.72747970e-01f,
  -4.97694999e-01f, -5.29224128e-02f, 1.25259995e-01f, -1.86215445e-01f, 1.94954708e-01f, 3.01630706e-01f, 2.96353042e-01f, -5.82490228e-02f, -5.02754115e-02f, -5.65614849e-02f,
  -5.21304086e-02f, -3.92816663e-02f, -3.83193931e-03f, -1.15962289e-02f, 1.30778672e-02f, 1.08723328e-01f, 4.50462103e-02f, -1.29074991e-01f, 1.04682986e-02f, 2.80499626e-02f,
  1.07357495e-01f, 9.11656022e-03f, -2.73795575e-01f, -1.16693713e-01f, -1.06621003e-02f, -2.63894000e-03f, -1.33817149e-02f, -7.43930507e-03f, 5.55879176e-02f, 4.51448448e-02f,
  -7.43392669e-03f, -2.06979334e-01f, 4.66194414e-02f, -7.94907808e-02f, 5.63095603e-03f, -1.53232574e-01f, -4.39896286e-02f, -1.44231200e-01f, -2.47998573e-02f, 3.60888802e-02f,
  3.12271155e-02f, -1.06735239e-02f, -4.47786637e-02f, 8.27712938e-02f, -7.29898140e-02f, 5.19912206e-02f, -3.27407718e-02f, -1.67865142e-01f, -1.53600529e-03f, -5.13023846e-02f,
  1.33349597e-01f, 8.49969834e-02f, 2.99590826e-02f, 8.65914002e-02f, -4.02715765e-02f, 3.07996683e-02f, -6.51416276e-03f, -3.79674993e-02f, 5.22226244e-02f, -8.12406316e-02f,
  6.21439219e-02f, -2.33973563e-02f, 7.38929585e-03f, -1.43525517e-02f, -4.63031754e-02f, -1.77047085e-02f, -3.24462843e-03f, 1.43809449e-02f, -3.55384275e-02f, 4.99509647e-02f,
  3.08586992e-02f, -3.53058390e-02f, -2.99241822e-02f, -8.63663107e-02f, 3.25487293e-02f, -2.15398424e-04f, -7.68893063e-02f, -5.84579445e-02f, -2.22758241e-02f, 9.24773794e-03f,
  3.15460959e-03f, -1.38192661e-02f, -8.54895730e-03f, 6.38483167e-02f, -7.47173205e-02f, -3.18244323e-02f, -4.88750264e-02f, 1.16576040e-02f, -1.18121197e-02f, 1.28476452e-02f,
  -1.67755019e-02f, -1.79068539e-02f, 1.22475962e-03f, -1.04464434e-01f, 7.27030560e-02f, 1.65767185e-02f, -6.04907647e-02f, -3.53622288e-02f, -3.66323488e-03f, -6.72641844e-02f,
  6.11649901e-02f, 1.32179828e-02f, -4.14216295e-02f, -3.91996093e-02f, 2.28400179e-03f, 7.58312196e-02f, 3.43466625e-02f, 7.04066083e-03f, 1.32754892e-02f, 2.20684260e-02f,
  -2.01346800e-02f, 2.22277809e-02f, -7.73084611e-02f, -1.42538482e-02f, 1.90103129e-02f, -7.58966133e-02f, 8.68065879e-02f, 1.19259268e-01f, -2.50287130e-02f, -1.21824387e-02f,
  -9.60011557e-02f, 1.04446895e-01f, -4.07226421e-02f, 2.02480648e-02f, -1.12670884e-01f, 1.19605623e-02f, 6.92856684e-02f, -5.21185845e-02f, 4.48619053e-02f, 3.35029177e-02f,
  4.57226299e-02f, 2.80276518e-02f, 3.24514173e-02f, 4.50775102e-02f, 1.84478924e-01f, 1.89347848e-01f, 1.01940319e-01f, 8.36716294e-02f, 5.25343865e-02f, 1.98526736e-02f,
  1.34492636e-01f, 7.70195052e-02f, 8.56619626e-02f, 3.02917175e-02f, 3.06602754e-02f, -7.82025456e-02f, 2.48892568e-02f, 3.78702991e-02f, -1.59047463e-03f, 8.45091268e-02f,
  -1.61954120e-01f, -1.90996885e-01f, -1.45653542e-02f, 9.60910395e-02f, 3.89836542e-02f, 7.76696652e-02f, 4.83984165e-02f, -1.00371510e-01f, -3.09945941e-02f, 7.77009428e-02f,
  -3.29072438e-02f, 3.28441635e-02f, -2.70841941e-02f, 5.89685068e-02f, 4.75528724e-02f, -8.99850950e-02f, 5.34088872e-02f, 9.38831791e-02f, 1.71160623e-02f, -1.09084979e-01f,
  3.64444591e-02f, -1.11251898e-01f, -9.94701236e-02f, -6.42532408e-02f, 3.02773938e-02f, 8.70341584e-02f, -1.06261307e-02f, 7.58983195e-03f, -7.86235780e-02f, -4.84947041e-02f,
  1.25174774e-02f, -2.46703103e-02f, 6.68521374e-02f, 1.13842953e-02f, 3.98554280e-02f, 5.11878077e-03f, 4.53030802e-02f, -9.40185320e-03f, 4.70285630e-03f, 3.63982953e-02f,
  1.89665351e-02f, -7.59835616e-02f, 7.98679888e-02f, -8.30832571e-02f, -2.33613774e-02f, -2.24989671e-02f, 6.22208528e-02f, -1.00377724e-02f, -2.74457131e-02f, -8.00912604e-02f,
  -7.50865489e-02f, 2.55101472e-02f, -1.74839422e-02f, 2.51537468e-02f, -3.34677026e-02f, -4.36045369e-03f, 5.87281696e-02f, -6.10502027e-02f, -9.38445851e-02f, -4.38406840e-02f,
  -3.01573146e-02f, -5.66222891e-03f, -5.80747388e-02f, 3.14055234e-02f, -5.85072003e-02f, 5.65628000e-02f, -4.88758869e-02f, 6.51558712e-02f, -1.64239239e-02f, 1.62493475e-02f,
  2.43503377e-02f, 1.71448663e-02f, -4.46675308e-02f, -2.58484874e-02f, -6.17195405e-02f, -1.07397266e-01f, 6.02692850e-02f, -3.21670249e-03f, 4.53650691e-02f, 8.46545771e-03f,
  1.37851045e-01f, -3.76823582e-02f, -6.86567416e-03f, 9.48916525e-02f, -1.01939149e-01f, -5.10309730e-03f, 2.75730770e-02f, -9.41101238e-02f, 3.42970975e-02f, 6.22724257e-02f,
  1.61773879e-02f, -7.47950152e-02f, -5.57549894e-02f, -3.03363008e-03f, -3.25640664e-02f, -6.62003905e-02f, -2.44483978e-01f, -8.06475729e-02f, 3.21870670e-02f, -1.21864296e-01f,
  1.78733900e-01f, 2.17532814e-01f, 6.03356473e-02f, 1.97955314e-02f, -9.07196775e-02f, -2.54672140e-01f, -2.10971057e-01f, -1.33302465e-01f, -9.54605788e-02f, -1.07494943e-01f,
  -3.10041234e-02f, -6.16947189e-02f, -6.33634478e-02f, -1.27705514e-01f, -1.92303639e-02f, -2.20713336e-02f, -8.06383118e-02f, -5.79024665e-02f, -3.90715487e-02f, -1.73954025e-01f,
  3.45290489e-02f, 1.49864316e-01f, -7.85198286e-02f, -2.57104691e-02f, 3.40784676e-02f, 4.64187525e-02f, 1.04154997e-01f, 2.28082819e-04f, 3.40412706e-02f, 7.77692273e-02f,
  1.40054435e-01f, 9.11546871e-02f, -6.45722821e-03f, -1.76262148e-02f, -5.04316092e-02f, -6.56023473e-02f, -3.03369202e-02f, -1.06984422e-01f, -1.21067211e-01f, -1.10360555e-01f,
  -1.01023186e-02f, 1.11326523e-01f, 1.23393379e-01f, 2.54710228e-03f, -7.96487927e-02f, 1.27364323e-01f, 4.68057394e-02f, 6.29783869e-02f, -4.58288193e-02f, -6.38861805e-02f,
  -1.22198001e-01f, 1.48708764e-02f, 4.11916710e-02f, -7.33051226e-02f, 7.85031840e-02f, -3.05882990e-02f, 7.34620765e-02f, -1.62694771e-02f, -8.51093307e-02f, -5.43144830e-02f,
  5.86565733e-02f, -1.55305639e-02f, -5.10815307e-02f, -4.32848819e-02f, 3.96170951e-02f, -4.67071533e-02f, -4.78665903e-02f, 1.42363561e-02f, -1.74721126e-02f, -8.39236081e-02f,
  4.22365442e-02f, 4.87633497e-02f, 7.39578577e-03f, -2.55691502e-02f, 1.79063864e-02f, 2.06906721e-03f, 9.77942050e-02f, -2.61092372e-02f, -9.97583009e-03f, 1.75260045e-02f,
  6.21111840e-02f, 8.64058435e-02f, 3.43506187e-02f, 6.02413081e-02f, 9.67458859e-02f, -3.54301445e-02f, 4.51026745e-02f, -6.73609003e-02f, 1.67671293e-01f, 3.75862559e-03f,
  5.27877770e-02f, -6.22429289e-02f, 6.30268529e-02f, -5.40997721e-02f, -3.14236581e-02f, -9.87710338e-03f, -1.14829741e-01f, 2.07391456e-02f, -1.08592892e-02f, -8.23586881e-02f,
  -1.39398828e-01f, 3.17608342e-02f, -2.01334488e-02f, -5.26244827e-02f, 3.18534710e-02f, 1.46664426e-01f, -3.32374386e-02f, 1.64259542e-02f, 1.12253003e-01f, -2.42731944e-01f,
  5.54860011e-03f, 2.05615520e-01f, 1.91297337e-01f, 2.55702198e-01f, 9.88057926e-02f, 7.27744922e-02f, -1.16649374e-01f, -7.56691396e-02f, 2.19025835e-02f, 1.51002839e-01f,
  1.20855205e-01f, 3.60320546e-02f, 1.01043530e-01f, -5.01630306e-02f, -1.25064388e-01f, 4.05572467e-02f, 7.69332498e-02f, -1.36798993e-01f, -1.96722865e-01f, -2.05065876e-01f,
  -1.13620974e-01f, -2.43871957e-02f, -7.56086558e-02f, 3.49943899e-03f, 8.45421255e-02f, 1.24639489e-01f, 9.58002508e-02f, 2.47509405e-02f, 6.61887601e-02f, 2.20811680e-01f,
  -5.73622473e-02f, 7.03510791e-02f, -1.36926427e-01f, 1.48111125e-02f, 9.98492688e-02f, -5.84875525e-04f, -9.35616787e-04f, 9.19616073e-02f, 1.19513050e-01f, 5.42385206e-02f,
  7.79911950e-02f, 1.37400236e-02f, -4.54405742e-03f, -3.06990966e-02f, 4.86590751e-02f, -1.10803545e-01f, 4.37477194e-02f, -6.26965389e-02f, 1.62880048e-02f, 1.03144255e-02f,
  1.54014975e-01f, 1.61761895e-03f, -2.91925725e-02f, -5.38199581e-02f, 6.35844395e-02f, 1.45574994e-02f, 1.25333011e-01f, -2.72097308e-02f, -1.62507053e-02f, -8.30293968e-02f,
  -7.88883790e-02f, -2.01490615e-02f, -2.49703005e-02f, -7.15996996e-02f, 5.55382408e-02f, 1.04423881e-01f, 5.12435660e-02f, -2.87677720e-02f, -7.36859068e-02f, -2.46529281e-02f,
  -2.30543166e-02f, -7.63224810e-02f, 4.52856906e-02f, -5.89323929e-04f, 7.30483234e-02f, 4.70449738e-02f, 9.19498620e-04f, 7.58106411e-02f, -2.70533538e-03f, 1.50592439e-03f,
  -1.79628644e-03f, -6.32306039e-02f, 4.30752039e-02f, 1.30386502e-02f, 3.46688330e-02f, -1.55332219e-02f, 2.40617357e-02f, -5.55270985e-02f, -1.72305349e-02f, 7.29691163e-02f,
  2.00377721e-02f, -6.18007146e-02f, 5.41150123e-02f, -2.47690212e-02f, 2.10114289e-02f, 5.53348958e-02f, -1.12193683e-02f, -9.92773450e-04f, 2.32027154e-02f, -1.01969719e-01f,
  5.59939109e-02f, 6.22391189e-03f, 8.85712579e-02f, -4.46521901e-02f, -1.00400224e-01f, -4.82041314e-02f, 5.34637757e-02f, 2.75681671e-02f, -8.36855471e-02f, 4.71827574e-02f,
  -4.66778837e-02f, -1.27201706e-01f, -1.66036054e-01f, -2.21265592e-02f, -4.48790565e-02f, -1.43126324e-02f, -1.40985593e-01f, -5.88038452e-02f, -1.26310378e-01f, -1.96184248e-01f,
  -3.05206299e-01f, -2.44753435e-01f, -2.25751609e-01f, 1.03564069e-01f, -9.34846792e-03f, -2.64796093e-02f, -2.10663691e-01f, -1.60662279e-01f, 1.95893366e-03f, -1.46149918e-02f,
  1.13086455e-01f, 1.53520480e-01f, 6.05161302e-02f, 5.00191376e-02f, -9.00041535e-02f, -6.74272329e-02f, -9.44569632e-02f, -8.36867187e-03f, -2.27215346e-02f, 9.18062031e-02f,
  2.26779670e-01f, 6.08915240e-02f, -3.55459051e-03f, 5.48342019e-02f, 7.49259070e-02f, -1.59352645e-02f, -6.04583956e-02f, -5.58127426e-02f, -1.36507256e-02f, 2.67650299e-02f,
  -1.32760987e-01f, -2.61695564e-01f, 1.31417802e-02f, 1.69692561e-01f, 1.12662219e-01f, -1.91202294e-02f, -2.20231861e-02f, -3.22768055e-02f, 9.71440002e-02f, -1.04538887e-03f,
  7.67062418e-03f, 6.22861870e-02f, -6.97995652e-04f, 1.99371800e-02f, -1.28069194e-02f, -6.16910271e-02f, 4.22658809e-02f, -1.84907634e-02f, 1.45488046e-02f, -6.89008161e-02f,
  2.23466814e-01f, -3.84859852e-02f, -1.07096225e-01f, 2.83059366e-02f, -2.59916689e-02f, 5.29207513e-02f, -1.14589386e-01f, -5.70162609e-02f, -1.49631292e-01f, -1.71655580e-01f,
  5.95216528e-02f, -6.02955855e-02f, -7.16094151e-02f, 8.81443731e-03f, 5.39128259e-02f, 1.24287046e-02f, 2.28954107e-02f, -1.70622263e-02f, 6.52031004e-02f, 7.02746445e-03f,
  3.95784453e-02f, -2.01208536e-02f, -3.92197259e-02f, -4.44387570e-02f, 1.22575415e-03f, -3.43191251e-02f, 4.65865023e-02f, -5.73736541e-02f, -6.65695034e-03f, 3.02948034e-03f,
  -5.77564631e-03f, -7.38469362e-02f, 6.71952888e-02f, -2.60223430e-02f, -6.09949566e-02f, 6.15657195e-02f, -9.42218304e-03f, 1.51062608e-02f, 1.30202435e-02f, 6.20177463e-02f,
  1.27190173e-01f, 2.51392853e-02f, -3.33071984e-02f, -8.21746662e-02f, -3.43592986e-02f, 2.65376717e-02f, -4.13741432e-02f, 6.26801467e-03f, 6.08394742e-02f, -5.67928404e-02f,
  2.79814154e-02f, -1.95880067e-02f, 5.41207800e-03f, 2.74460241e-02f, -4.96550761e-02f, 3.62405665e-02f, 1.04761250e-01f, -5.85751608e-03f, -7.44828358e-02f, -7.52580613e-02f,
  3.12298462e-02f, 3.56432004e-03f, 2.55968031e-02f, -1.87671892e-02f, 5.64797409e-02f, 1.66389178e-02f, -4.56107035e-02f, -2.71595214e-02f, -1.29034713e-01f, -1.00110583e-01f,
  3.70846719e-01f, 1.87905371e-01f, -2.03623306e-02f, 2.88356930e-01f, 8.11772346e-02f, -9.62741449e-02f, 1.59750897e-02f, 5.09406589e-02f, 5.56863565e-03f, 1.23333558e-01f,
  -5.04415669e-02f, 2.23397892e-02f, 6.67288378e-02f, 1.48822134e-02f, -9.15918499e-02f, 5.69380112e-02f, 1.21838644e-01f, 8.71793646e-03f, -1.38707086e-01f, -4.95281890e-02f,
  7.84275830e-02f, 1.90265626e-01f, 7.18841553e-02f, 7.46144280e-02f, 1.52462959e-01f, -9.75201279e-03f, 7.60617182e-02f, -7.05015957e-02f, -8.28752294e-02f, 1.22008756e-01f,
  5.81739172e-02f, 8.41921270e-02f, -8.63085687e-02f, -9.41504259e-03f, -6.57424331e-03f, -4.28941427e-03f, 1.71874687e-02f, 3.92537788e-02f, -4.77456897e-02f, -3.14633269e-03f,
  -6.85165152e-02f, 3.97641137e-02f, -3.26176062e-02f, 2.66202670e-02f, 9.58472304e-03f, 1.69879477e-02f, 5.98418005e-02f, -9.73225757e-02f, -7.16825128e-02f, -1.28935516e-01f,
  -4.68878485e-02f, -9.25916955e-02f, -5.87072968e-02f, -9.37113166e-02f, -6.12342842e-02f, -1.65515289e-01f, 1.19545090e-03f, -1.02504067e-01f, -1.20324485e-01f, 1.05547510e-01f,
  6.69619963e-02f, -4.63834614e-04f, -8.52716863e-02f, 7.78699145e-02f, 2.67221071e-02f, -1.84389837e-02f, -6.71134219e-02f, 5.78413829e-02f, 1.69398598e-02f, 9.97562185e-02f,
  -3.48031037e-02f, -4.38633114e-02f, 2.58200783e-02f, -4.01480161e-02f, -3.57581973e-02f, -4.22208384e-02f, -1.80507563e-02f, -2.77034566e-02f, 1.31830107e-02f, 1.68990213e-02f,
  2.52852507e-04f, -6.17544577e-02f, -3.88369560e-02f, -5.16904332e-03f, -1.41054079e-01f, 6.02987856e-02f, 3.03810723e-02f, -6.06111027e-02f, 3.45532820e-02f, 5.28990924e-02f,
  2.32118160e-01f, -3.07403743e-01f, 8.70496184e-02f, 3.38115287e-03f, 7.64044970e-02f, 3.58762406e-02f, 8.70868377e-03f, 2.31800508e-02f, 9.74684954e-02f, 2.59748138e-02f,
  -2.04052799e-03f, 7.71355778e-02f, 1.01590708e-01f, 3.98110859e-02f, -1.49052888e-02f, 8.44411273e-03f, 2.30585746e-02f, 7.34330416e-02f, -5.10779582e-02f, -9.17338282e-02f,
  8.78838748e-02f, 4.92820702e-02f, 1.03088342e-01f, 3.91990095e-02f, 6.02424033e-02f, 4.11384739e-02f, 6.61403611e-02f, -1.85415298e-02f, -2.99360082e-02f, 1.81073114e-01f,
  -2.36481875e-02f, 5.88413328e-02f, -1.18812039e-01f, -5.32708541e-02f, 1.48971170e-01f, 2.22547621e-01f, 2.00233757e-01f, 8.30149055e-02f, -4.97827753e-02f, -5.92759661e-02f,
  9.21799839e-02f, -9.52599477e-03f, -2.14351304e-02f, 2.13393513e-02f, 5.33685312e-02f, -6.48558214e-02f, -5.11797145e-02f, -1.22013509e-01f, -8.68635997e-02f, 4.12880965e-02f,
  3.40922475e-02f, -1.42021447e-01f, -1.81217015e-01f, -1.56354055e-01f, -1.65193558e-01f, -9.13813561e-02f, -7.43537620e-02f, -1.31159127e-01f, -1.14028446e-01f, -2.00451419e-01f,
  6.00754358e-02f, 4.92091887e-02f, -1.03952900e-01f, -9.94312987e-02f, -3.91855463e-02f, 1.68225560e-02f, -2.30165944e-02f, -7.67351761e-02f, 6.30824342e-02f, 4.42109406e-02f,
  -7.67031610e-02f, -1.43991597e-02f, -5.41232079e-02f, 4.38940413e-02f, -2.32643578e-02f, 7.70761594e-02f, 9.43942810e-04f, 3.38029265e-02f, -4.15514689e-03f, -4.71439697e-02f,
  4.20115553e-02f, -1.66131407e-02f, 1.77938826e-02f, 4.56032641e-02f, -4.50599659e-03f, -4.51205820e-02f, 9.14256275e-02f, -4.24043313e-02f, 6.28085285e-02f, 2.69834232e-02f,
  7.97776282e-02f, 4.77700680e-02f, 8.50234851e-02f, -6.04936965e-02f, 3.87625545e-02f, -5.05416915e-02f, -5.16118295e-02f, 1.53069142e-02f, 8.55291635e-02f, 5.42603200e-03f,
  -5.00946753e-02f, 3.46357301e-02f, 7.76133090e-02f, -3.21425162e-02f, -8.98361057e-02f, -6.42792583e-02f, -4.54272926e-02f, -6.41317666e-02f, 4.63748462e-02f, -1.66958328e-02f,
  -1.52047649e-02f, -2.53712181e-02f, -1.75365601e-02f, -7.40109757e-02f, -4.39827889e-02f, 2.55433172e-02f, 4.22860049e-02f, 5.42474203e-02f, -5.00907153e-02f, 3.57454829e-02f,
  -8.07553008e-02f, 1.21393591e-01f, -1.43256724e-01f, -4.51215403e-03f, 4.79603074e-02f, 5.50698973e-02f, -3.14548699e-04f, -3.31861712e-02f, -1.86031014e-02f, -2.29926221e-02f,
  7.45670572e-02f, -5.99876978e-03f, 7.77392909e-02f, -3.12896706e-02f, -2.07509082e-02f, 8.92212801e-03f, 2.17745882e-02f, 3.21682245e-02f, -6.05394803e-02f, 6.10092543e-02f,
  4.32216413e-02f, 1.04427636e-01f, 5.62882563e-03f, -1.23307873e-02f, -5.72305545e-02f, 1.03541799e-01f, 9.97753367e-02f, 3.47497277e-02f, 2.85297837e-02f, -5.69466054e-02f,
  -1.67787209e-01f, 1.28890917e-01f, 7.94940293e-02f, -6.65428862e-02f, 8.68587196e-02f, 1.21521398e-01f, 1.50897935e-01f, -3.81358676e-02f, -2.42315885e-02f, 3.05798594e-02f,
  4.71894704e-02f, 4.49179895e-02f, -5.89652322e-02f, -7.00955465e-02f, -1.15301432e-02f, 1.08379051e-01f, 4.23994549e-02f, 7.61766313e-03f, -8.76294449e-02f, -1.37804672e-01f,
  -3.08938627e-03f, -1.66937530e-01f, -1.61070019e-01f, -7.61631355e-02f, 4.13177349e-02f, -5.24369068e-02f, 4.62976322e-02f, 6.23409934e-02f, 1.46668747e-01f, 9.83566418e-02f,
  -4.62409668e-02f, 2.81490702e-02f, 7.85802379e-02f, 1.23204097e-01f, 5.98671027e-02f, 7.75700584e-02f, -1.11567182e-02f, -5.39279077e-03f, -1.95422415e-02f, -1.14150019e-02f,
  -4.05983217e-02f, -1.57514159e-02f, 5.85493259e-02f, -4.31446359e-02f, 3.00061665e-02f, 1.88392829e-02f, 1.64175518e-02f, -1.61727576e-03f, 1.08451704e-02f, -4.28857319e-02f,
  1.55668348e-01f, 1.07197523e-01f, 9.31577832e-02f, -7.21528009e-02f, -9.68695525e-03f, 6.00087643e-02f, -6.82116076e-02f, -7.80827776e-02f, -1.20492401e-02f, -7.92873427e-02f,
  -1.25762727e-02f, 8.68674775e-04f, -3.56697440e-02f, -3.58157270e-02f, 2.34128386e-02f, 7.76457265e-02f, -4.69730049e-02f, -1.87484771e-02f, -2.03485452e-02f, -9.78846923e-02f,
  -5.77832423e-02f, 5.80261461e-02f, 2.04750933e-02f, -6.37891740e-02f, 5.55096604e-02f, 6.69491813e-02f, -1.35144778e-02f, 5.32589108e-03f, -1.43496916e-02f, 5.52044101e-02f,
  2.99762301e-02f, -6.61061332e-02f, -3.49580450e-03f, -8.58960897e-02f, 4.07316424e-02f, 3.63766216e-02f, -6.11232407e-02f, 2.88417470e-02f, 5.45709841e-02f, 6.36560395e-02f,
  -1.91780567e-01f, 8.36229250e-02f, 7.27002993e-02f, -7.00406656e-02f, 6.74261525e-02f, -5.50434552e-02f, 1.58186946e-02f, 2.96608955e-02f, 1.22287646e-02f, -6.39947802e-02f,
  -1.52577423e-02f, -3.76018807e-02f, -4.31501605e-02f, -1.13297338e-02f, -6.61530122e-02f, -8.53345096e-02f, 1.17694944e-01f, -5.33154346e-02f, 3.08926906e-02f, -2.95395609e-02f,
  1.09682113e-01f, -6.91391081e-02f, 8.20228830e-02f, 8.17618668e-02f, -6.13554493e-02f, 5.49835153e-02f, -9.00697615e-03f, 4.33158241e-02f, -5.91993369e-02f, 1.47344358e-02f,
  1.50755808e-01f, -2.96225876e-01f, -1.29537627e-01f, -1.49779037e-01f, -5.57468943e-02f, 1.64368674e-01f, 3.23385932e-02f, 1.70623347e-01f, 1.25569001e-01f, -4.25895639e-02f,
  7.46993721e-02f, 5.71787134e-02f, 1.20069809e-01f, 9.90406126e-02f, -3.24338228e-02f, -1.11663371e-01f, -8.16494972e-02f, 2.65697874e-02f, 1.01940557e-01f, 1.18627571e-01f,
  -1.10656722e-02f, -1.00510813e-01f, -4.87156250e-02f, -1.39712363e-01f, -2.05403820e-01f, -2.44688634e-02f, -1.54332548e-01f, -6.25646636e-02f, -8.78616199e-02f, -3.28320622e-01f,
  -9.05448273e-02f, 7.85611123e-02f, 7.25901499e-02f, 5.77021800e-02f, 5.72722591e-02f, 7.37120360e-02f, -1.45270843e-02f, 2.62421407e-02f, -3.84971243e-03f, -5.64571470e-02f,
  -7.83273801e-02f, 3.92830046e-03f, 1.17144790e-02f, -3.68537195e-02f, 2.48654354e-02f, 4.77595776e-02f, -6.20362982e-02f, -1.57213565e-02f, 9.70397666e-02f, 7.17375129e-02f,
  -5.53070828e-02f, -9.44715813e-02f, 1.11722007e-01f, 5.82843609e-02f, -1.96748395e-02f, 1.67917572e-02f, 3.55761126e-02f, -4.53421101e-02f, 1.54955998e-01f, -6.62679523e-02f,
  -1.35982353e-02f, 2.57267300e-02f, 6.93716705e-02f, 5.06431833e-02f, -1.81551871e-03f, 2.64057554e-02f, -8.07329491e-02f, -3.06968968e-02f, 9.98855680e-02f, -1.14191845e-01f,
  7.76817873e-02f, 7.00745219e-03f, -2.98935585e-02f, 5.25524840e-02f, 1.45702641e-02f, 2.04611998e-02f, -6.31907210e-02f, -5.57909831e-02f, 6.06656671e-02f, -3.68223600e-02f,
  -8.15229025e-03f, -4.51694690e-02f, 5.01410700e-02f, -7.74326622e-02f, 2.81567201e-02f, 1.38947675e-02f, 5.81510067e-02f, -2.65437067e-02f, -4.15076800e-02f, -4.42791507e-02f,
  1.54188117e-02f, 1.01252772e-01f, 4.61267270e-02f, 1.05211139e-01f, -1.05404861e-01f, 9.56070144e-03f, 3.79354730e-02f, -8.81206766e-02f, 3.24790552e-02f, 4.78543118e-02f,
  1.06287159e-01f, 4.98489663e-02f, -4.10670266e-02f, 2.45066243e-03f, 3.52740064e-02f, 2.08905209e-02f, -7.77902827e-02f, -1.97836626e-02f, 3.10429787e-05f, -8.59182104e-02f,
  -1.28552750e-01f, 9.52877402e-02f, 1.93435457e-02f, 8.73974711e-02f, 1.14702456e-01f, 1.83025986e-01f, -1.32347373e-02f, 1.59940403e-02f, 1.94357142e-01f, 7.52320066e-02f,
  7.89455399e-02f, -9.43933949e-02f, -1.14750706e-01f, -9.62184072e-02f, -2.17799246e-01f, -2.13147461e-01f, -1.46137804e-01f, -6.19571991e-02f, -7.04743788e-02f, -1.20295003e-01f,
  -1.09942421e-01f, -8.26007351e-02f, 5.65906428e-02f, -4.57890145e-02f, -4.82590050e-02f, -1.55669495e-01f, -1.71871379e-01f, 2.46172771e-02f, -2.33854968e-02f, -9.25947651e-02f,
  -1.12959720e-01f, 4.25328165e-02f, 6.46510124e-02f, -2.17590872e-02f, -1.57817006e-01f, 3.88107682e-03f, -2.93457910e-04f, -8.46018195e-02f, -1.06375568e-01f, -2.31669962e-01f,
  -1.12016104e-01f, 2.61887312e-02f, 9.00133103e-02f, 3.39855812e-02f, -1.50690591e-02f, 7.77930021e-03f, -2.31632050e-02f, 9.15829837e-02f, 9.43479985e-02f, 2.20751334e-02f,
  3.09750176e-04f, -5.65026291e-02f, -3.99778895e-02f, 3.44058610e-02f, 4.84800078e-02f, -3.54855657e-02f, 6.29055947e-02f, -1.28564816e-02f, 1.35130197e-01f, -2.11500712e-02f,
  5.74369635e-03f, -5.77762946e-02f, -7.72598572e-03f, 1.51739255e-01f, 1.00461781e-01f, -3.51772481e-03f, 9.96293426e-02f, 7.65715092e-02f, 1.52222484e-01f, -1.31238485e-04f,
  -5.66654615e-02f, -6.95146155e-03f, -1.35888793e-02f, 2.96197496e-02f, 1.25048757e-02f, -1.58089865e-02f, 2.77343169e-02f, -4.25518192e-02f, -5.44233955e-02f, 6.99482858e-02f,
  -4.38354202e-02f, -4.69838716e-02f, -2.71273591e-02f, 3.54163311e-02f, -7.58472830e-02f, -3.59609313e-02f, -2.40113474e-02f, -2.81525124e-02f, 6.32252842e-02f, 8.28562379e-02f,
  2.62454860e-02f, -3.90196666e-02f, 7.49401376e-02f, 3.52226906e-02f, 1.69538688e-02f, 4.47076969e-02f, 2.08742972e-02f, 3.65159139e-02f, -2.84435544e-02f, 6.74968362e-02f,
  -6.52420297e-02f, 1.93614423e-01f, -1.23920128e-01f, 1.03880223e-02f, -5.80974631e-02f, 4.84769046e-02f, -9.96767208e-02f, 4.28623892e-02f, 3.59093957e-03f, -8.65230933e-02f,
  -3.02167367e-02f, 6.44700751e-02f, -1.04736365e-01f, 9.48246382e-03f, 4.80727367e-02f, 2.16987785e-02f, 1.24883726e-02f, -5.56477159e-02f, 8.69244263e-02f, 8.55252966e-02f,
  -4.10372205e-02f, -5.61288670e-02f, -6.20054789e-02f, -7.48540089e-02f, -1.17588006e-02f, -4.25987579e-02f, 3.09304073e-02f, 6.04467047e-03f, 5.87445237e-02f, -4.80393246e-02f,
  -3.65660340e-01f, 2.63338506e-01f, -3.11811209e-01f, -1.84416562e-01f, -1.13633767e-01f, -4.97715026e-02f, 1.93598643e-01f, 1.31335348e-01f, 8.18111226e-02f, 1.46514133e-01f,
  5.93969785e-02f, 4.70662750e-02f, -8.39667022e-02f, -4.77222763e-02f, 6.88624522e-03f, 1.31671965e-01f, -2.33815052e-02f, -2.77372986e-01f, -1.95507810e-01f, -8.54404643e-02f,
  1.15788817e-01f, -1.44410003e-02f, -1.62735581e-01f, -1.20057594e-02f, 6.00204989e-02f, -9.35774595e-02f, -7.15322420e-02f, -7.04884306e-02f, 1.30177334e-01f, 2.47192699e-02f,
  1.10777151e-02f, 5.26471734e-02f, -7.75980279e-02f, 7.75016332e-03f, -1.50381196e-02f, -1.44914255e-01f, -1.71127748e-02f, -1.21005356e-01f, -1.14688806e-01f, -1.33203166e-02f,
  -6.26599090e-03f, 3.74166965e-02f, -4.58024368e-02f, 4.31973003e-02f, -7.27958754e-02f, -1.14283776e-02f, -7.65869915e-02f, -1.13322333e-01f, -5.23263663e-02f, 1.35300020e-02f,
  1.26444474e-01f, -1.25922814e-01f, -2.16011718e-01f, -6.21787757e-02f, -5.56359626e-02f, -1.94076687e-01f, 3.11568491e-02f, -7.08688051e-02f, -1.51729777e-01f, -6.92783520e-02f,
  -4.55292966e-03f, -6.82266653e-02f, 5.69211431e-02f, -2.86685247e-02f, 9.14416462e-02f, -6.02074862e-02f, 3.53561342e-02f, 4.99431714e-02f, -1.06407944e-02f, -1.06830359e-01f,
  -1.09488154e-02f, 3.30639593e-02f, -1.78192346e-03f, -6.25856668e-02f, 6.40470162e-02f, -1.62929564e-03f, 4.15597111e-02f, 1.08522341e-01f, -3.56119648e-02f, 1.15514435e-02f,
  -4.21182215e-02f, 4.62962547e-03f, 8.91527813e-03f, -3.13626486e-04f, 1.72798301e-03f, -2.16400437e-02f, 2.60774381e-02f, 3.73709872e-02f, -6.13234490e-02f, 3.78486584e-03f,
  4.82528023e-02f, -1.13758497e-01f, -3.00576002e-03f, 1.15766125e-02f, -3.15256678e-02f, 3.90230715e-02f, 5.47566451e-02f, 1.30389193e-02f, 1.80645939e-02f, 1.78881213e-02f,
  -2.68861149e-02f, -5.40674441e-02f, 1.20017245e-01f, 8.27583149e-02f, -2.76022851e-02f, 2.34151930e-02f, 1.18628249e-01f, -3.85617092e-02f, 3.90185080e-02f, 1.22840656e-02f,
  3.75324078e-02f, -1.63284272e-01f, -2.12723181e-01f, -2.15853378e-02f, 2.27906350e-02f, -9.23277661e-02f, -2.50173081e-02f, -9.27052498e-02f, -1.14189669e-01f, 5.79845756e-02f,
  -1.25390822e-02f, -1.02147803e-01f, 3.13607464e-03f, 1.00850552e-01f, -3.42601836e-02f, -2.43087351e-01f, -3.02991003e-01f, -2.09899336e-01f, 2.97432598e-02f, -1.17950156e-01f,
  -6.41865432e-02f, 9.38176662e-02f, 3.88042033e-02f, -1.11513631e-02f, -1.45467266e-01f, -9.98982266e-02f, 2.14258842e-02f, 1.26854509e-01f, -3.94609496e-02f, -1.78233571e-02f,
  7.33170565e-03f, 1.15893558e-01f, 2.38919869e-01f, 1.52365416e-01f, 2.16539234e-01f, 1.54803887e-01f, 1.95252240e-01f, 2.12229341e-01f, 2.18950845e-02f, 3.25707823e-01f,
  -1.03177272e-01f, 3.80388275e-02f, -9.90505069e-02f, 5.95163479e-02f, 8.71246830e-02f, -2.49924753e-02f, -1.04404859e-01f, 1.18438825e-01f, 5.57948872e-02f, 1.90682635e-02f,
  4.14553285e-02f, -3.69110741e-02f, 8.84435177e-02f, 1.24439925e-01f, 7.45631754e-03f, -9.51095298e-03f, 3.59464325e-02f, 1.34337932e-01f, -4.41151019e-03f, -7.57925808e-02f,
  6.67262673e-02f, 7.18706399e-02f, 5.54153323e-02f, -8.92397687e-02f, -6.91448525e-02f, -1.14398617e-02f, 5.86212948e-02f, 1.00080900e-01f, -9.87690166e-02f, 1.03056364e-01f,
  1.72915757e-02f, 1.47511242e-02f, 4.89432812e-02f, -4.97537777e-02f, 6.87986193e-03f, 8.93193670e-03f, 4.34344448e-02f, -2.10929178e-02f, -3.02381534e-02f, 1.16944797e-02f,
  7.32195526e-02f, -4.09825742e-02f, 7.58552030e-02f, -1.86629202e-02f, 6.28065467e-02f, 3.87732573e-02f, -6.40883250e-03f, 2.78880391e-02f, -5.73969148e-02f, 3.89219820e-02f,
  7.75622576e-02f, -3.68993431e-02f, 8.61528218e-02f, 1.00960605e-01f, -1.62263028e-02f, 3.25931273e-02f, 1.89435538e-02f, 3.65057811e-02f, -6.39074072e-02f, -4.34186831e-02f,
  -1.05650201e-01f, -1.30948827e-01f, -3.37114520e-02f, 4.74812351e-02f, -6.61800951e-02f, -4.28820401e-03f, 4.43405882e-02f, -5.80774695e-02f, -7.39640510e-03f, -3.55458520e-02f,
  -2.20582001e-02f, -1.45206759e-02f, -9.71958339e-02f, 3.52873206e-02f, -1.20980315e-01f, -3.34621966e-02f, -6.52884841e-02f, 3.42502147e-02f, 9.16643813e-03f, -1.93452537e-02f,
  -4.90042716e-02f, -1.70321748e-01f, -2.14883566e-01f, -8.43338072e-02f, 1.25313280e-02f, -1.70796722e-01f, -1.72723159e-01f, -7.99387321e-02f, -1.97344005e-01f, -1.26537770e-01f,
  1.91857412e-01f, 1.16516963e-01f, -4.84786779e-02f, 3.05039026e-02f, -1.82972066e-02f, -2.25089550e-01f, -1.57755822e-01f, -1.28695682e-01f, -2.74291057e-02f, 1.06612243e-01f,
  1.08059414e-01f, 3.80609408e-02f, 1.58159539e-01f, -1.49511127e-02f, -9.74458084e-02f, -1.73266411e-01f, -1.10105850e-01f, -6.49186820e-02f, -1.45402759e-01f, -2.32614968e-02f,
  -7.36153349e-02f, 1.02227896e-01f, 1.56425968e-01f, -4.56558205e-02f, 1.63522303e-01f, 9.71158743e-02f, 1.66703746e-01f, 9.67054293e-02f, 6.61183074e-02f, 6.54775053e-02f,
  -3.35904323e-02f, 1.81199014e-01f, -2.50716005e-02f, 1.30840734e-01f, 1.25499383e-01f, -4.49793115e-02f, -4.60159890e-02f, 8.12221225e-03f, -4.12689382e-03f, -2.81565334e-03f,
  8.31372142e-02f, 1.04084462e-01f, 1.33118212e-01f, -7.12065399e-02f, -1.43770147e-02f, 2.76409481e-02f, -6.00606278e-02f, 2.54534744e-03f, -8.35503936e-02f, -8.05917829e-02f,
  1.18414305e-01f, -2.15232205e-02f, -5.26575372e-02f, -1.19413562e-01f, 2.69745570e-02f, 3.93460095e-02f, -3.93915363e-02f, 7.83822015e-02f, 1.89289935e-02f, 5.06244674e-02f,
  -3.62017266e-02f, 4.21354957e-02f, -4.39711139e-02f, -3.51030156e-02f, -5.63306808e-02f, 5.44505045e-02f, -4.90341932e-02f, -6.03412017e-02f, -4.18932736e-03f, 7.62792230e-02f,
  -4.52180505e-02f, 5.71228974e-02f, -5.35837281e-03f, -7.45132491e-02f, 2.20685191e-02f, 2.05682628e-02f, 5.52507974e-02f, -2.14035027e-02f, -2.86734980e-02f, 6.74886554e-02f,
  -3.01505979e-02f, -1.24300560e-02f, 8.68500248e-02f, -1.95233729e-02f, -2.74448805e-02f, -5.72983213e-02f, 5.76344095e-02f, 2.81042550e-02f, 1.52021628e-02f, -7.91062415e-02f,
  7.37716854e-02f, -2.08000541e-02f, 2.75833141e-02f, 4.36517633e-02f, 6.68370351e-02f, 7.22536668e-02f, 9.95814949e-02f, -5.03534935e-02f, 3.87667120e-02f, -5.13589345e-02f,
  -2.81072184e-02f, -5.16514741e-02f, 3.86409052e-02f, -6.88371435e-02f, -3.94474491e-02f, -8.62307847e-02f, 1.32235093e-02f, -9.88515764e-02f, -5.47543466e-02f, 4.46292348e-02f,
  1.22459447e-02f, -1.75740451e-01f, -6.19597100e-02f, -1.55249700e-01f, -1.47697926e-02f, -5.91163710e-03f, -1.16159096e-01f, -1.59646407e-01f, -1.79198384e-01f, -2.27368921e-01f,
  1.20428771e-01f, 2.76745200e-01f, -1.56713247e-01f, -5.56180589e-02f, -2.79200703e-01f, -1.92969710e-01f, -5.55978017e-03f, 2.60250494e-02f, -7.48955235e-02f, 7.97616467e-02f,
  6.34561479e-02f, 1.07249655e-01f, -6.19742507e-03f, -6.68945443e-03f, 9.58950743e-02f, -8.44269618e-02f, -2.16553614e-01f, -1.78806726e-02f, -1.29143357e-01f, 5.05015180e-02f,
  -3.07425000e-02f, -5.01072817e-02f, 6.43078005e-03f, 2.63751540e-02f, -4.55836467e-02f, -5.13508804e-02f, -1.15654156e-01f, -6.53490052e-02f, -9.39367246e-03f, 3.57973832e-03f,
  5.66469468e-02f, 1.78695872e-01f, -1.28931805e-01f, 2.49863099e-02f, 5.64045571e-02f, -6.76713418e-04f, 1.06978610e-01f, 5.47537720e-03f, -3.41331330e-03f, 3.13084312e-02f,
  -3.59990494e-03f, 1.43268794e-01f, -2.81834020e-03f, 7.54601881e-02f, -1.22675272e-02f, 6.13455027e-02f, 1.41774580e-01f, 1.02951653e-01f, -1.98952444e-02f, 2.07598910e-01f,
  1.00502610e-01f, -4.56242673e-02f, -5.39559647e-02f, -4.59243171e-03f, 4.03528363e-02f, -1.36497304e-01f, 9.64244828e-02f, 3.18421796e-03f, -8.74234131e-04f, 1.04919478e-01f,
  -4.61912900e-03f, -6.08806908e-02f, -1.77691430e-02f, 4.83167134e-02f, 2.13009976e-02f, -9.21238493e-03f, -7.72635713e-02f, -4.65670740e-03f, 2.38453560e-02f, -2.62031071e-02f,
  6.80302363e-03f, -2.71208528e-02f, -2.29962151e-02f, 2.00501233e-02f, -1.88360214e-02f, -8.22953358e-02f, -1.40673751e-02f, 5.63305244e-02f, 5.68606593e-02f, -2.86284108e-02f,
  -4.53548245e-02f, -1.74948238e-02f, -2.83717159e-02f, 3.42628993e-02f, 1.47236269e-02f, -7.96819329e-02f, 2.08210610e-02f, 4.33456432e-03f, 8.73574689e-02f, 7.41265621e-03f,
  -1.10553779e-01f, -1.18326806e-01f, -7.15195164e-02f, 1.01976991e-01f, -1.41124979e-01f, 1.73912048e-02f, 2.21640877e-02f, -2.75468118e-02f, -2.28588879e-02f, 8.94263536e-02f,
  3.87566872e-02f, 5.49737876e-03f, 1.36384014e-02f, 4.33735065e-02f, -7.11719766e-02f, 2.59851143e-02f, 6.66214526e-02f, -1.08574785e-01f, 6.13516718e-02f, -7.58803729e-03f,
  -1.19118439e-02f, -8.75437781e-02f, -9.01846439e-02f, -8.78529921e-02f, -5.08081801e-02f, -1.83193803e-01f, -1.41804412e-01f, -1.21144675e-01f, -1.92331418e-01f, -1.77744329e-01f,
  -1.83775738e-01f, 1.73879251e-01f, 2.42084399e-01f, -8.28151107e-02f, 1.86499789e-01f, 1.08028188e-01f, 2.59821583e-02f, -4.15051877e-02f, -1.54207692e-01f, 7.68292919e-02f,
  1.70360029e-01f, -1.21171415e-01f, -4.16253647e-03f, -4.92992103e-02f, -1.94577783e-01f, -4.92064133e-02f, 1.03904516e-01f, 2.87503842e-03f, -1.89441666e-01f, -1.44076124e-01f,
  -5.67103252e-02f, -1.42084122e-01f, -6.09704182e-02f, -6.31620660e-02f, -1.40901422e-04f, 7.07247853e-02f, 1.69429138e-01f, 1.39165983e-01f, 4.87423278e-02f, 7.94270113e-02f,
  2.54411668e-01f, 1.47905409e-01f, -7.27458596e-02f, -9.78383943e-02f, 8.63656104e-02f, -2.59974599e-02f, 4.36600372e-02f, 6.32961243e-02f, 6.62396103e-02f, 9.69137822e-04f,
  1.17880411e-01f, 3.48812379e-02f, 8.98991078e-02f, 6.51802346e-02f, 6.67414591e-02f, 4.33591492e-02f, 5.03943525e-02f, -6.51932461e-03f, 4.60309573e-02f, 1.70107335e-02f,
  1.17698148e-01f, 2.01838553e-01f, 1.87696531e-01f, 5.02656028e-02f, 1.00681536e-01f, -6.34135008e-02f, 1.39193818e-01f, 1.18689351e-01f, 1.23839758e-01f, 7.51416013e-02f,
  -4.61127944e-02f, 6.14214912e-02f, 6.82503283e-02f, 2.65941750e-02f, -1.97267402e-02f, 1.02356011e-02f, 1.03712408e-02f, -3.63238156e-02f, -4.59966995e-02f, 6.17773039e-03f,
  -2.30589416e-02f, 7.43912607e-02f, -7.28546269e-03f, -6.77790195e-02f, 2.83592716e-02f, 1.00962520e-01f, 1.87024642e-02f, -7.41557702e-02f, -2.06230674e-02f, 2.58909445e-02f,
  -9.04117618e-03f, 6.22260720e-02f, -2.82723829e-02f, -7.64986426e-02f, 3.69098559e-02f, 9.58153605e-02f, 3.36739309e-02f, -6.56666681e-02f, 6.75979210e-03f, 4.27805856e-02f,
  -1.65956154e-01f, 7.02092424e-03f, -1.00400142e-01f, -1.17765039e-01f, 6.39417544e-02f, 4.13918532e-02f, 1.77157409e-02f, 3.15519869e-02f, -1.77636426e-02f, 2.42285077e-02f,
  -4.54618894e-02f, -2.44708862e-02f, 8.01010057e-02f, -3.83360311e-02f, -7.91019723e-02f, -4.75517660e-02f, -7.87012205e-02f, -3.28184888e-02f, 3.73718217e-02f, 2.56196354e-02f,
  -3.68858986e-02f, -1.37408271e-01f, -8.06637779e-02f, -7.00152516e-02f, -4.59190607e-02f, -4.72595803e-02f, -2.60180477e-02f, -7.72377402e-02f, -7.84924552e-02f, -2.70119518e-01f,
  1.74248517e-01f, -1.77872926e-01f, 2.30168700e-01f, 5.54141216e-02f, 8.73703361e-02f, -1.01904184e-01f, -2.43858919e-01f, -2.33793139e-01f, -8.49640965e-02f, -6.19662367e-02f,
  1.49317741e-01f, 1.70874879e-01f, 4.95456159e-02f, 5.54128624e-02f, -1.41052544e-01f, -3.94806266e-02f, -5.69753535e-02f, 4.11560312e-02f, 8.91991034e-02f, -1.14345213e-03f,
  -5.87208522e-03f, 3.06462981e-02f, 2.62150653e-02f, -8.14429671e-02f, -7.20142126e-02f, 5.48246279e-02f, -4.13019955e-02f, 1.10584490e-01f, 6.65063113e-02f, 9.59199145e-02f,
  4.64367837e-01f, -6.43410906e-02f, 8.67511779e-02f, 3.41684930e-02f, 1.24253586e-01f, -6.60527423e-02f, 4.14059451e-03f, -3.86525616e-02f, -2.30810083e-02f, -4.72880453e-02f,
  3.00128795e-02f, -2.13301424e-02f, -5.23373894e-02f, -6.82575107e-02f, 4.52140979e-02f, -3.23230363e-02f, -9.33620259e-02f, -3.33267897e-02f, 2.22181026e-02f, -9.62949023e-02f,
  9.16022249e-03f, 8.63332897e-02f, 1.11879975e-01f, -3.43499519e-02f, -8.00914392e-02f, 5.47900833e-02f, 7.35003725e-02f, -5.81148118e-02f, -3.36282700e-02f, 3.17215100e-02f,
  2.65485719e-02f, 3.25748660e-02f, -4.31282148e-02f, -4.68770601e-02f, -1.03661148e-02f, -1.85557771e-02f, -1.36002554e-02f, 7.60089234e-02f, 1.12056285e-02f, 1.46856774e-02f,
  -8.44475999e-03f, 4.26276661e-02f, -9.12003070e-02f, -1.12150032e-02f, -1.15747924e-03f, 2.60722749e-02f, 7.53803935e-04f, -3.01819593e-02f, -2.06937902e-02f, -6.92060664e-02f,
  8.89334455e-02f, 5.28240725e-02f, 3.96328121e-02f, -1.73638500e-02f, -1.97096411e-02f, -1.25243794e-02f, -8.57472047e-02f, -1.05707914e-01f, -7.19568878e-02f, -2.81806588e-02f,
  1.49041004e-02f, 3.62719931e-02f, 1.32825255e-01f, -2.00641844e-02f, 1.56896077e-02f, -4.83731180e-02f, 1.07986070e-01f, 8.95102248e-02f, 8.07876065e-02f, 8.34914520e-02f,
  5.76366112e-02f, -2.57545095e-02f, 7.78395906e-02f, 4.01379587e-03f, 5.68656549e-02f, -3.69982943e-02f, -4.11983840e-02f, 1.59960091e-01f, -6.99626207e-02f, -7.71256387e-02f,
  -1.24392159e-01f, 2.91506201e-02f, 1.75198868e-01f, 7.21816495e-02f, 1.81110557e-02f, 1.82019919e-01f, 4.35408726e-02f, 7.79959485e-02f, 1.47054628e-01f, -6.30226135e-02f,
  3.38290483e-01f, 3.86068046e-01f, 5.35416566e-02f, 1.77081540e-01f, -2.19798274e-02f, -2.29502797e-01f, -8.61510560e-02f, -1.01654962e-01f, 8.43090564e-03f, 1.24252908e-01f,
  2.62835454e-02f, 3.21506299e-02f, 3.39097204e-03f, -1.64908096e-01f, 1.14976754e-03f, 1.00257605e-01f, -4.36214097e-02f, -1.15318291e-01f, -2.16810048e-01f, -8.21255594e-02f,
  -1.10152818e-01f, -1.53308071e-03f, 7.77623206e-02f, -9.23612155e-03f, 1.51258931e-01f, 4.46578152e-02f, 1.59046963e-01f, 1.46903247e-01f, -9.11925687e-04f, 1.92641735e-01f,
  3.26306254e-01f, 1.89799622e-01f, -2.26538852e-01f, -3.08034234e-02f, 8.00881684e-02f, 6.18835352e-02f, -1.53738912e-02f, 2.19745487e-02f, 5.89509634e-03f, 6.19593337e-02f,
  5.41545674e-02f, 1.57015435e-02f, -4.62918319e-02f, -7.12364912e-02f, 1.46551467e-02f, 6.37203082e-03f, 7.17016011e-02f, 4.73385975e-02f, -1.08683906e-01f, -2.77717263e-02f,
  6.20726794e-02f, 2.95401420e-02f, 3.87445055e-02f, -4.74755801e-02f, -1.20588847e-01f, -1.10237695e-01f, -1.56729799e-02f, -5.74560370e-03f, -1.15444377e-01f, 2.33363941e-01f,
  -2.86382772e-02f, 3.21166068e-02f, -3.08307894e-02f, -4.99618938e-03f, -7.71384686e-03f, -7.28607178e-02f, 3.10180038e-02f, -1.68903507e-02f, -4.22722921e-02f, 6.46238253e-02f,
  -4.30349968e-02f, -4.00465019e-02f, -3.77219915e-02f, 3.23487520e-02f, 3.34200934e-02f, -3.75696681e-02f, 1.34298913e-02f, 2.91081574e-02f, -7.87205249e-03f, 3.55262798e-03f,
  6.90534562e-02f, -4.23679575e-02f, 8.02974179e-02f, -1.75330248e-02f, 1.15142921e-02f, -9.92216840e-02f, -4.00002487e-02f, 3.56489681e-02f, 6.99130222e-02f, -2.73106117e-02f,
  9.31542367e-02f, -2.65546799e-01f, 1.00204527e-01f, 2.36057397e-02f, 2.28693672e-02f, -1.08734295e-02f, -9.25771077e-04f, 4.91907299e-02f, 5.00560477e-02f, 2.40573268e-02f,
  -5.76203614e-02f, 1.38188899e-03f, 6.34206310e-02f, 3.15140635e-02f, -8.05391185e-03f, -3.95692773e-02f, 2.04436872e-02f, -4.61412705e-02f, -1.08627178e-01f, 4.67623994e-02f,
  4.03824560e-02f, -8.50398317e-02f, 2.48523317e-02f, -1.26240626e-01f, -3.52088176e-02f, -3.81013155e-02f, 8.27929564e-03f, -8.28158855e-02f, -8.42380598e-02f, 3.77299972e-02f,
  -1.77210927e-01f, 6.05993671e-03f, -1.53006185e-02f, -2.31050268e-01f, -1.94742661e-02f, 1.98980972e-01f, 1.78329378e-01f, 3.61897163e-02f, -3.20912823e-02f, -2.83106621e-02f,
  6.49980828e-02f, 1.02320403e-01f, 1.16631668e-02f, 1.50384814e-01f, 1.12675503e-01f, 1.03688613e-01f, -9.19645801e-02f, 4.57634330e-02f, 1.41138688e-01f, 4.92898114e-02f,
  -1.48435488e-01f, -9.55541357e-02f, -1.40641868e-01f, -2.45912503e-02f, -1.75007999e-01f, -1.54868379e-01f, -1.59022421e-01f, -1.67947546e-01f, 1.23437531e-02f, -3.13474894e-01f,
  -2.30598599e-02f, 1.02060810e-01f, 1.45184129e-01f, -8.90245065e-02f, -1.84628442e-02f, 4.73799743e-02f, -2.03881152e-02f, -6.62852451e-02f, 4.48539108e-02f, 5.07313153e-03f,
  -8.45463946e-02f, 4.40915115e-02f, -7.76645392e-02f, -6.44789785e-02f, -1.10668046e-02f, 8.34541544e-02f, -4.08491418e-02f, -6.12183549e-02f, 9.58552882e-02f, -3.01920362e-02f,
  -5.98964430e-02f, 3.00903451e-02f, 1.42028049e-01f, 1.04693286e-01f, 8.16677958e-02f, 1.77398208e-03f, 9.08830315e-02f, 6.48607090e-02f, 9.88035351e-02f, -1.21342968e-02f,
  -9.64313522e-02f, -1.64013077e-02f, -1.59760863e-02f, -3.15243900e-02f, 1.73766706e-02f, -5.96459173e-02f, 6.90913498e-02f, 3.73564340e-04f, -4.66183424e-02f, 4.64103408e-02f,
  -7.23348409e-02f, 7.91769773e-02f, 1.88961043e-03f, -7.03805834e-02f, -1.52987021e-03f, -1.40239438e-02f, 6.58618426e-03f, 2.13460568e-02f, 6.11562142e-03f, -3.85916047e-02f,
  3.75963338e-02f, -1.47788543e-02f, 7.92333391e-03f, 2.62192991e-02f, 1.17881633e-02f, -8.41293931e-02f, 1.24366358e-02f, 5.24490327e-02f, -1.40150089e-03f, -1.19707771e-01f,
  1.87325887e-02f, 1.07721001e-01f, -5.66406250e-02f, 9.29146260e-02f, -9.46748704e-02f, -6.95087239e-02f, 2.34001819e-02f, -2.23785788e-02f, 9.30277817e-03f, 6.13008812e-02f,
  1.14572830e-02f, 1.23482011e-02f, -6.66489010e-04f, 5.76137602e-02f, -2.14702990e-02f, 7.52813593e-02f, -3.87198594e-03f, -5.32744303e-02f, 7.60096759e-02f, -2.21048146e-02f,
  -6.46368638e-02f, -9.29360278e-03f, 4.21205945e-02f, 7.81181455e-02f, 7.01673925e-02f, -1.12150377e-03f, 1.22449614e-01f, -4.55839001e-02f, 1.89088941e-01f, -7.83962160e-02f,
  -4.67997640e-01f, -2.30160028e-01f, 1.46158487e-01f, -1.59309581e-01f, -5.95526993e-02f, -4.03261604e-03f, -1.86150342e-01f, -9.27229449e-02f, -8.09860229e-02f, -1.31848544e-01f,
  5.05515784e-02f, 1.29933104e-01f, 3.32423631e-04f, 1.13631979e-01f, -6.12660758e-02f, -8.03595707e-02f, 1.00126736e-01f, 6.62370548e-02f, -8.55170097e-03f, -2.10562479e-02f,
  -8.93300995e-02f, 3.42510566e-02f, -5.21810949e-02f, -2.65287198e-02f, -9.00058746e-02f, 4.22474276e-03f, 3.25795598e-02f, -1.05114438e-01f, 4.60210145e-02f, -9.98555496e-02f,
  1.29515141e-01f, -2.01483727e-01f, 6.82984293e-02f, -3.48402234e-03f, 1.20633081e-01f, 2.32994631e-02f, -3.59226614e-02f, 4.33563702e-02f, 9.14631411e-03f, -5.91637343e-02f,
  3.38507220e-02f, 8.31228271e-02f, 4.75634001e-02f, -2.06381758e-03f, -1.52268959e-02f, -1.09041221e-01f, 8.16095471e-02f, 4.45735380e-02f, 1.04798779e-01f, -8.53024349e-02f,
  2.32207798e-03f, -1.24033235e-01f, -1.39550865e-01f, 2.23562177e-02f, 2.01800112e-02f, 4.80412506e-02f, 1.72818694e-02f, 6.97111432e-03f, -5.32877073e-02f, -2.01114118e-01f,
  3.24611589e-02f, 3.94698866e-02f, 3.21395211e-02f, -1.20070381e-02f, 2.71759611e-02f, -2.76534762e-02f, 6.63661361e-02f, -1.91237628e-02f, 2.00903267e-02f, -1.59857273e-02f,
  -3.69429477e-02f, 1.70027129e-02f, -3.86748686e-02f, 1.40408454e-02f, 9.12031531e-02f, -1.14545494e-01f, 1.77218777e-03f, 1.61725320e-02f, 6.79494813e-03f, -7.31149167e-02f,
  -1.69589147e-02f, 2.42124237e-02f, 3.15253474e-02f, 6.00604527e-02f, -3.31348293e-02f, -6.51223436e-02f, -5.21679558e-02f, 4.50531282e-02f, -5.13272025e-02f, 1.40730711e-02f,
  -1.26572540e-02f, 1.18343934e-01f, -6.75872713e-02f, -1.09134533e-01f, -1.53735559e-02f, 3.15929800e-02f, -3.31846289e-02f, 2.36416142e-03f, -1.30640147e-02f, 1.28002127e-03f,
  1.78538244e-02f, 8.46621487e-03f, -8.50247964e-02f, 5.95893003e-02f, 3.29390578e-02f, -4.85459007e-02f, -7.67431334e-02f, -6.17603995e-02f, 2.92439405e-02f, 4.22226563e-02f,
  -5.27514592e-02f, -1.41742289e-01f, -1.22237630e-01f, -9.96847153e-02f, -1.33220851e-01f, -1.43834427e-01f, -3.52740544e-03f, -9.35530961e-02f, -7.09492266e-02f, -1.85305953e-01f,
  1.76303685e-01f, -3.13038021e-01f, -3.91358733e-01f, 1.82152092e-01f, -1.75784603e-02f, -1.86689094e-01f, -3.89773995e-01f, -8.75124633e-02f, 1.66874751e-01f, -6.37464896e-02f,
  1.17858246e-01f, 2.96625465e-01f, 1.72764972e-01f, 9.93505865e-02f, -5.47794960e-02f, -3.52391303e-01f, -2.96913147e-01f, -7.17316419e-02f, 8.97841379e-02f, 4.48458567e-02f,
  1.76988840e-01f, 4.35399525e-02f, 4.97394167e-02f, -1.71619114e-02f, 8.24981183e-02f, 8.91713500e-02f, -1.37732223e-01f, -9.86526906e-03f, 1.40606454e-02f, -3.15403417e-02f,
  3.58450525e-02f, -6.92391321e-02f, 6.74278662e-02f, 7.54726827e-02f, -2.47447602e-02f, 4.35592830e-02f, -3.80029343e-02f, -7.95756727e-02f, -3.32415216e-02f, -2.16127317e-02f,
  1.44658023e-02f, 2.80324626e-03f, -1.68436319e-02f, -2.48506628e-02f, 2.06659194e-02f, 1.08361524e-02f, -9.71658826e-02f, -4.94350158e-02f, -1.10126875e-01f, 1.08255940e-02f,
  -1.94639619e-02f, -5.43191377e-03f, -1.13245338e-01f, -4.64293063e-02f, -1.42249872e-03f, 6.51799217e-02f, -6.71799779e-02f, -2.60354765e-03f, -1.36850160e-02f, -1.07784770e-01f,
  9.79674887e-03f, 4.30261940e-02f, -4.27168794e-02f, 2.66001467e-02f, 1.67154092e-02f, -3.92258354e-02f, -6.86652679e-03f, 6.77495264e-03f, 1.41985714e-02f, -3.05400081e-02f,
  1.41439466e-02f, -6.71025664e-02f, 6.70174956e-02f, -7.79770240e-02f, 5.81034683e-02f, -3.22772078e-02f, -3.81333902e-02f, -5.82198612e-02f, 5.99161945e-02f, -7.86050316e-03f,
  -9.01538413e-03f, 4.52038907e-02f, -1.43458014e-02f, -3.59988213e-02f, -1.24971503e-02f, -6.40446991e-02f, -7.27534387e-03f, 5.12369871e-02f, 5.86710125e-02f, -1.80306658e-02f,
  2.49760360e-01f, -6.77909777e-02f, -3.29963043e-02f, 3.98244895e-02f, 1.88809875e-02f, -4.52492088e-02f, 3.94206159e-02f, 1.47978626e-02f, 6.59013838e-02f, -2.71468014e-02f,
  7.25354068e-03f, -3.83801349e-02f, -1.66731421e-02f, -4.25083861e-02f, -2.64500342e-02f, -1.39353843e-02f, 3.21988650e-02f, -4.90582511e-02f, 3.05286981e-02f, 6.35344312e-02f,
  2.48540062e-02f, -1.30366206e-01f, 7.57922679e-02f, -1.35067835e-01f, 1.53777162e-02f, 6.03903718e-02f, -1.57808065e-01f, 1.17893983e-02f, -1.14712864e-01f, -2.04885259e-01f,
  1.40258536e-01f, -9.43966284e-02f, -1.61023084e-02f, 1.97200608e-02f, -8.79930183e-02f, -1.85982063e-01f, -1.04436070e-01f, -2.00559106e-02f, 9.56581458e-02f, 6.50075206e-04f,
  -1.83550306e-02f, 1.43203065e-01f, 1.38828054e-01f, 8.01562332e-03f, -1.30215332e-01f, -4.27933373e-02f, 4.53062281e-02f, -1.26292020e-01f, -8.78985822e-02f, -5.87379858e-02f,
  1.05163410e-01f, -2.22391728e-02f, 7.23099103e-03f, 1.95947904e-02f, 2.98003741e-02f, 1.60771832e-01f, 9.15424153e-02f, -6.14937805e-02f, 6.20861687e-02f, 2.10734650e-01f,
  3.66467327e-01f, -1.28592074e-01f, 8.31600949e-02f, 6.20944388e-02f, 4.63048331e-02f, 4.26862352e-02f, -6.80056587e-03f, -5.84551692e-02f, -5.13950437e-02f, 6.43257648e-02f,
  6.67849258e-02f, 2.90467925e-02f, 1.47712352e-02f, -9.81586203e-02f, -7.66666979e-02f, 1.34219797e-02f, -8.53648111e-02f, -8.29986632e-02f, -1.38305919e-02f, -5.80019504e-02f,
  6.60733208e-02f, -1.15995154e-01f, -1.47911329e-02f, -7.03012496e-02f, -1.63668916e-01f, 5.80869280e-02f, -2.57336330e-02f, 1.15260165e-02f, -6.00835402e-03f, 1.39997229e-01f,
  6.44574389e-02f, -1.69691760e-02f, -5.64300530e-02f, 2.62070261e-02f, 6.07828260e-04f, -1.47853587e-02f, 4.98743951e-02f, 6.41572550e-02f, -7.57227018e-02f, 8.40456598e-03f,
  3.01188715e-02f, -8.79630521e-02f, -1.80151649e-02f, 9.89857614e-02f, 1.76532343e-02f, 4.32231538e-02f, -2.42506806e-02f, 2.08541378e-02f, -2.16596220e-02f, -6.15243055e-02f,
  5.63569628e-02f, -4.23428342e-02f, 4.74443436e-02f, 2.00951044e-02f, 2.64782216e-02f, -1.05324453e-02f, 7.24094361e-02f, -4.73763570e-02f, 5.11763711e-03f, 1.23881944e-03f,
  2.41690412e-01f, -3.09152305e-01f, 9.38275754e-02f, -7.02701136e-02f, -1.08856075e-02f, 4.45858464e-02f, 7.16068000e-02f, 2.50825677e-02f, -2.01408751e-02f, 4.03552391e-02f,
  -6.03183731e-02f, 3.93533222e-02f, 6.46300465e-02f, 1.80373620e-02f, 4.34307940e-03f, 2.36666929e-02f, 1.34743368e-02f, -2.49836780e-02f, -1.37696397e-02f, 8.70764256e-03f,
  -1.40344016e-02f, 5.02671339e-02f, 1.48552239e-01f, 2.03380957e-02f, 9.98046100e-02f, 1.12187155e-01f, 9.79357138e-02f, 1.68769598e-01f, 2.92365402e-02f, 1.13372102e-01f,
  3.11742663e-01f, 5.48002422e-02f, -4.87166196e-02f, 2.17638284e-01f, 1.20614737e-01f, -5.39863408e-02f, 4.13467214e-02f, 7.61748701e-02f, 4.28666137e-02f, -1.36702415e-02f,
  1.94814783e-02f, -1.51359402e-02f, 2.69823475e-03f, 3.73998880e-02f, -6.30312413e-02f, -8.60576704e-02f, 8.10951740e-02f, -6.15290143e-02f, -5.95480800e-02f, 4.64627929e-02f,
  -2.46168561e-02f, 9.91722196e-02f, 7.16031119e-02f, 1.18802056e-01f, 1.44130751e-01f, 8.98715854e-02f, 3.90846841e-02f, 1.19012661e-01f, 2.88950652e-02f, 2.14425400e-01f,
  1.14332773e-01f, 2.90748179e-01f, -7.42180198e-02f, -5.96730374e-02f, -2.86399201e-02f, 2.70689931e-02f, -3.33141983e-02f, 1.95432715e-02f, -2.22845599e-02f, 9.93751958e-02f,
  7.01143891e-02f, -1.51409740e-02f, 1.61840208e-02f, 1.43897375e-02f, 7.70033598e-02f, 8.62540975e-02f, 4.24200855e-02f, 6.42616600e-02f, -5.44681214e-02f, 1.04122929e-01f,
  1.24755271e-01f, 1.45159632e-01f, 8.90650135e-03f, -1.29267341e-02f, -6.17334992e-02f, 6.48896396e-02f, -6.34340048e-02f, -2.28642020e-02f, 1.30702239e-02f, 8.69457349e-02f,
  2.74409428e-02f, -4.70082462e-02f, -6.37497008e-02f, 4.40055802e-02f, 2.25264970e-02f, 2.50923038e-02f, 3.23913433e-02f, -4.70924787e-02f, -2.43039224e-02f, -3.22582237e-02f,
  -5.13177216e-02f, 6.75407872e-02f, -4.76534180e-02f, -2.10393978e-06f, -8.26863106e-03f, 2.26998888e-02f, -2.25894675e-02f, -9.27761868e-02f, -3.62505205e-02f, 7.17118531e-02f,
  -4.42559794e-02f, 5.54103330e-02f, -4.38963668e-03f, 1.31781045e-02f, -2.74061393e-02f, -1.75202843e-02f, 4.10149917e-02f, 4.12668474e-03f, 8.23825374e-02f, 6.14721607e-03f,
  -1.84016809e-01f, -1.76216409e-01f, 2.72681583e-02f, 1.78584699e-02f, 6.93588555e-02f, -1.77569203e-02f, 8.49195644e-02f, -8.62758011e-02f, 1.24744754e-02f, -2.68383361e-02f,
  5.95177785e-02f, 3.45002934e-02f, -1.00064538e-01f, -3.95634286e-02f, 3.47708128e-02f, 4.75111306e-02f, -5.51475212e-02f, -5.93971312e-02f, -2.98203565e-02f, 7.87588507e-02f,
  -4.41812240e-02f, -4.80044298e-02f, -1.37907714e-01f, -1.18849054e-01f, -1.18060382e-02f, -8.70109499e-02f, -3.82639803e-02f, -7.08997482e-03f, -1.90709725e-01f, -1.54388040e-01f,
  -2.75291950e-01f, -5.30093275e-02f, 1.39093995e-01f, 4.04931186e-03f, 8.31817389e-02f, 1.87812403e-01f, 1.11717917e-01f, 1.51946381e-01f, -1.69565845e-02f, -3.99908843e-03f,
  4.87442091e-02f, -3.08594834e-02f, -8.58667344e-02f, 3.82775515e-02f, 3.67782936e-02f, -1.42405573e-02f, 5.48421144e-02f, -1.79828815e-02f, -6.38359264e-02f, 1.81714706e-02f,
  -1.39841229e-01f, -1.51233062e-01f, -4.25244384e-02f, 1.74204390e-02f, -1.15647577e-01f, 3.87443625e-03f, -6.11980408e-02f, -4.32400517e-02f, -3.30037088e-04f, -2.14511529e-01f,
  -3.39474022e-01f, -1.44368289e-02f, -3.12785879e-02f, -2.85062399e-02f, 1.06606208e-01f, 2.11243462e-02f, -4.80447151e-02f, 5.17988801e-02f, 3.83029915e-02f, -4.91892770e-02f,
  3.92270871e-02f, -6.60503432e-02f, 3.78472321e-02f, 3.59399468e-02f, -3.83896269e-02f, 2.88672689e-02f, 1.09201372e-01f, -5.60865030e-02f, -3.10224481e-02f, -3.41582708e-02f,
  9.63062495e-02f, 4.21050042e-02f, 1.42705902e-01f, 3.14843692e-02f, 7.90670738e-02f, 7.23223016e-02f, 1.40437186e-01f, 7.86187723e-02f, 1.24793828e-01f, -7.97615275e-02f,
  3.61187458e-02f, -3.56527753e-02f, -5.77726290e-02f, 1.12947579e-02f, -2.53901035e-02f, -2.81533152e-02f, 5.79729956e-03f, -5.55725656e-02f, -2.86670085e-02f, 3.24165821e-02f,
  2.00595777e-03f, -4.80788983e-02f, 2.73783840e-02f, -8.72465223e-02f, -5.92796095e-02f, 4.93896864e-02f, 3.79370116e-02f, 1.26330378e-02f, -2.27878336e-02f, 8.29228759e-03f,
  -3.24862148e-03f, 9.84551944e-03f, -1.54525694e-02f, -3.27248522e-03f, 8.82884637e-02f, -1.48244752e-02f, 3.58125642e-02f, -1.49363028e-02f, -5.25340112e-03f, 6.01272807e-02f,
  -1.88558176e-01f, 3.91920984e-01f, -2.22820088e-01f, -9.66363549e-02f, 5.19612664e-03f, 2.24597864e-02f, -7.67101273e-02f, -7.79468054e-03f, 6.04519993e-02f, -3.06981560e-02f,
  1.12512978e-02f, -7.18321204e-02f, 2.75366977e-02f, -2.81916410e-02f, 2.70404555e-02f, -5.86761832e-02f, -2.32312158e-02f, -7.34756440e-02f, -3.81765068e-02f, -3.54770310e-02f,
  6.88675568e-02f, 1.43664202e-03f, -1.42483916e-02f, 1.89235099e-02f, 3.92906256e-02f, -1.05355307e-01f, -2.97700427e-02f, -1.08597279e-01f, -3.08450405e-02f, -1.21704601e-01f,
  -2.58855838e-02f, 1.04671650e-01f, 1.51695028e-01f, -1.53285861e-01f, -2.26072632e-02f, 2.00834975e-01f, 2.78860211e-01f, 6.05393723e-02f, 1.27867404e-02f, 2.72132289e-02f,
  5.93856052e-02f, -5.00112101e-02f, 6.25674576e-02f, -4.66027521e-02f, 1.41982257e-01f, 7.82604516e-02f, -8.06263164e-02f, -8.30383077e-02f, -1.46704996e-02f, -5.43452725e-02f,
  -3.22178379e-02f, -3.67155746e-02f, -1.05415769e-02f, -1.06887855e-01f, -1.56094611e-01f, -4.40521576e-02f, 5.22653610e-02f, 3.73502672e-02f, -6.07755594e-02f, -2.37070963e-01f,
  -1.43704293e-02f, 4.53910045e-02f, 4.72105034e-02f, -8.78893062e-02f, -1.81201973e-03f, 1.34762898e-02f, 7.27512389e-02f, -3.26988213e-02f, -6.66000247e-02f, -6.91319779e-02f,
  4.46711257e-02f, -4.21677716e-02f, 2.80893613e-02f, -3.22810002e-02f, 9.91787855e-03f, 8.01108778e-02f, -2.92258654e-02f, -4.53037173e-02f, 7.04988018e-02f, 3.41626853e-02f,
  2.94431616e-02f, -4.72973920e-02f, 1.21487893e-01f, 1.41192958e-01f, -7.66635761e-02f, -6.68257400e-02f, 1.12311929e-01f, 3.96878198e-02f, 1.17152460e-01f, 2.57201809e-02f,
  5.68879172e-02f, -1.30570661e-02f, -1.81687698e-02f, -7.21873417e-02f, 8.75629634e-02f, -1.96525548e-02f, -1.39216594e-02f, -7.79962633e-03f, 3.90995070e-02f, -1.92430634e-02f,
  3.42816710e-02f, 1.13415031e-03f, -2.57089268e-02f, 8.79706293e-02f, -2.27173474e-02f, 5.01806429e-03f, -1.69200562e-02f, 4.93349470e-02f, 5.97058088e-02f, 2.00657547e-02f,
  5.13490625e-02f, 5.21068275e-02f, 3.05454563e-02f, -4.37954888e-02f, -3.60352248e-02f, 4.08912450e-02f, -3.51236351e-02f, -1.46682495e-02f, 5.16219027e-02f, 8.24030936e-02f,
  1.40802130e-01f, 3.39292437e-02f, -4.14721705e-02f, 7.33635277e-02f, 1.52986394e-02f, -1.81904770e-02f, -4.16846313e-02f, -1.01723894e-03f, -1.04577038e-02f, 5.61958477e-02f,
  8.87480676e-02f, -3.82026378e-03f, 1.18986005e-02f, -4.57272828e-02f, 8.18453915e-03f, 1.89460814e-02f, 1.60153210e-03f, 4.36499938e-02f, -2.29422674e-02f, -5.60382493e-02f,
  1.10768326e-01f, 1.48961306e-01f, 1.42952353e-01f, 1.07207499e-01f, 1.26455352e-02f, 9.12374854e-02f, 1.93409294e-01f, -6.93087419e-03f, 1.32317275e-01f, 2.67046928e-01f,
  3.23241234e-01f, -1.36714978e-02f, 9.88552421e-02f, 3.19341980e-02f, -2.59392858e-01f, -3.76271784e-01f, -3.84998858e-01f, -2.87471395e-02f, -1.39000928e-02f, -1.02615356e-01f,
  4.14480977e-02f, 1.24852121e-01f, 1.61853716e-01f, 6.28833007e-03f, 3.24581303e-02f, -7.41951093e-02f, -1.68418251e-02f, 1.85525566e-01f, 9.42617953e-02f, -1.96669146e-01f,
  -3.15954052e-02f, 1.37672558e-01f, 2.11772829e-01f, 1.14426136e-01f, 6.50870800e-02f, -5.76497130e-02f, 1.16238214e-01f, 2.09093746e-02f, -6.72881398e-03f, 3.19261327e-02f,
  1.48630962e-01f, 1.73678204e-01f, -2.28442121e-02f, 5.68226650e-02f, 5.68433814e-02f, -4.01006266e-03f, -3.77900638e-02f, 2.01329127e-01f, 4.20919098e-02f, 1.20136570e-02f,
  -9.88413766e-03f, -1.69158000e-02f, 6.14962876e-02f, 7.14356527e-02f, 3.84575129e-02f, -5.98593168e-02f, 2.22523380e-02f, 1.81900278e-01f, 8.04932863e-02f, -3.78706120e-02f,
  -1.57948360e-01f, -1.05923042e-01f, 9.49855596e-02f, 3.72602209e-03f, 8.93110707e-02f, -2.30648797e-02f, 6.16386570e-02f, -1.67549010e-02f, 5.46422675e-02f, 1.47049144e-01f,
  -8.93802792e-02f, -5.10694049e-02f, 4.05651703e-02f, 1.74762774e-02f, -3.06925364e-02f, 2.66006291e-02f, 3.12270354e-02f, -2.88805901e-03f, -4.05021720e-02f, 3.99112627e-02f,
  8.39068070e-02f, -1.98007170e-02f, 3.25733759e-02f, 2.85157058e-02f, 1.43166315e-02f, 4.77806292e-02f, -7.46355951e-02f, 2.99960934e-02f, 4.86033186e-02f, -1.80691965e-02f,
  -4.32709837e-03f, 1.89350441e-03f, 5.89687005e-02f, 7.07228556e-02f, -3.58424746e-02f, 9.39395428e-02f, -6.20103218e-02f, 3.38237286e-02f, -5.83591349e-02f, 5.50213270e-02f,
  8.45729485e-02f, -7.23640174e-02f, 9.34944972e-02f, 6.87813992e-03f, -2.55651064e-02f, 4.97061247e-03f, -1.88868009e-02f, -2.22161580e-02f, 8.37225243e-02f, 6.34577870e-02f,
  -5.24375848e-02f, 1.00855799e-02f, 5.48598506e-02f, -4.54070680e-02f, -6.46465719e-02f, 2.00383421e-02f, -1.51789458e-02f, 3.12021039e-02f, -1.06004979e-02f, -1.55758010e-02f,
  -4.40930240e-02f, -7.09264204e-02f, -1.23700224e-01f, -3.85496835e-03f, -1.03360884e-01f, -1.01332419e-01f, 6.72322279e-03f, 1.41879972e-02f, -1.12224802e-01f, -5.43151284e-03f,
  -2.05319807e-01f, 6.23959750e-02f, -1.50836587e-01f, 1.52504846e-01f, 1.13641337e-01f, 4.61783633e-02f, -9.01124999e-02f, -1.10567119e-02f, 9.75571871e-02f, 9.85188633e-02f,
  1.84174851e-01f, 4.07848358e-02f, 8.43187049e-02f, -1.01103283e-01f, -1.49751306e-01f, -2.76622782e-03f, -4.38507530e-04f, -2.47567564e-01f, -3.27862650e-01f, -5.89777082e-02f,
  3.83389331e-02f, -6.91748634e-02f, -3.53729948e-02f, -7.22328648e-02f, 1.35258451e-01f, -8.63676425e-03f, 8.11543092e-02f, 4.74879704e-02f, 1.45781115e-01f, 1.12499937e-01f,
  -3.91646996e-02f, -8.20186548e-03f, -1.40118256e-01f, 7.10036457e-02f, 1.42575100e-01f, -9.61176977e-02f, -7.58829191e-02f, -2.14521089e-04f, 1.94533877e-02f, 6.51274100e-02f,
  1.03639275e-01f, 7.01267272e-02f, 7.43694678e-02f, -1.91089530e-02f, 4.42573279e-02f, -3.81210037e-02f, -8.89064968e-02f, -7.04498366e-02f, -1.56269908e-01f, -5.15821688e-02f,
  1.34245530e-01f, 1.68814316e-01f, 7.35882437e-03f, 3.69142443e-02f, -7.11145401e-02f, -8.76327157e-02f, -8.92197862e-02f, -3.79332118e-02f, -2.12529227e-01f, -1.87233731e-01f,
  -3.87092791e-02f, -3.62328775e-02f, 3.54297049e-02f, 3.89691279e-03f, -7.99248517e-02f, -3.14229243e-02f, 7.16861784e-02f, 5.84985539e-02f, 1.60908736e-02f, 4.05678563e-02f,
  -4.67252955e-02f, -2.89215408e-02f, -1.75343733e-02f, 3.11058871e-02f, -2.78491676e-02f, -3.50130349e-02f, 5.28189465e-02f, -1.08677791e-02f, 9.23175141e-02f, 1.14100110e-02f,
  -4.19043601e-02f, -1.23241274e-02f, 7.05115683e-03f, 1.11154392e-02f, 3.25601473e-02f, 3.16901132e-02f, -2.07667537e-02f, -8.04111883e-02f, -4.00230773e-02f, -1.15273381e-02f,
  -1.68920949e-01f, -7.13833002e-03f, 3.20530385e-02f, -7.93823153e-02f, 8.26534349e-03f, 4.39542122e-02f, 5.62639236e-02f, 6.73106238e-02f, 1.67159319e-01f, -5.92391454e-02f,
  5.91080971e-02f, -8.96599069e-02f, -6.07308140e-03f, -4.46543954e-02f, -7.76084587e-02f, 5.41257970e-02f, 5.61099760e-02f, -2.67141610e-02f, 2.08582021e-02f, 8.61094445e-02f,
  -1.12919379e-02f, -3.79371122e-02f, -1.92689806e-01f, -1.38170943e-01f, -6.19663624e-04f, -9.94974002e-02f, -1.38593629e-01f, -1.78207546e-01f, -1.53936476e-01f, -1.77642986e-01f,
  1.03210807e-01f, 3.32310330e-03f, 2.93661673e-02f, 2.49155983e-02f, 1.22385956e-01f, 5.72366975e-02f, -5.87145723e-02f, 2.52442621e-02f, -1.05232047e-02f, -1.07727282e-01f,
  -1.76332176e-01f, -1.88293397e-01f, -2.14278042e-01f, -1.39235973e-01f, -8.58829096e-02f, 3.41391005e-02f, 8.43599252e-03f, -4.76246253e-02f, 2.82831001e-03f, 1.07232988e-01f,
  3.83627340e-02f, 5.44952452e-02f, 1.19241916e-01f, 8.06942657e-02f, 3.35551635e-03f, 4.76987921e-02f, -4.32363488e-02f, 5.94639815e-02f, 1.22489214e-01f, 7.85275847e-02f,
  -1.52250260e-01f, 1.88062340e-01f, -5.06138355e-02f, 1.84924882e-02f, -1.89745147e-02f, 2.16462817e-02f, -3.49453762e-02f, -6.53329724e-03f, -6.05637468e-02f, 4.65775728e-02f,
  6.37576059e-02f, 1.01571068e-01f, -8.55365023e-03f, 2.71516815e-02f, 2.33942028e-02f, 6.33820742e-02f, 1.11512788e-01f, -1.92247462e-02f, -9.30865016e-03f, -1.89239439e-02f,
  -6.76016733e-02f, 1.50213122e-01f, 4.52276170e-02f, 3.70821618e-02f, 7.93310180e-02f, 3.64358611e-02f, -4.36429977e-02f, 3.46335508e-02f, 7.80493440e-03f, 7.80702084e-02f,
  1.89722609e-02f, 4.34649326e-02f, 3.45460325e-02f, 1.12208426e-02f, -4.13579941e-02f, 2.96594738e-03f, 3.68593931e-02f, 4.39926572e-02f, -4.33027782e-02f, 7.45033026e-02f,
  -1.35254972e-02f, -8.56294930e-02f, 2.79867034e-02f, -4.92047034e-02f, -1.47298388e-02f, 7.52168149e-02f, 6.47269413e-02f, -1.22581266e-01f, 7.54182506e-03f, 2.26200260e-02f,
  -4.91020386e-04f, 5.10495380e-02f, -6.88005909e-02f, 1.06478920e-02f, 5.71673103e-02f, 3.54566574e-02f, 8.21472853e-02f, -7.64749870e-02f, -2.15496439e-02f, -5.49001247e-02f,
  -3.38417023e-01f, -7.29526877e-02f, -8.13219026e-02f, -1.25601329e-02f, 1.37312114e-01f, 3.05173174e-02f, -8.96631256e-02f, 8.85370560e-03f, -1.24911973e-02f, -2.87016481e-02f,
  -2.74494477e-02f, -6.93160892e-02f, -8.08926150e-02f, 7.63752684e-02f, -5.04672304e-02f, -5.39816096e-02f, 6.59052432e-02f, -6.06888980e-02f, 3.87967601e-02f, 9.06704143e-02f,
  -4.51357253e-02f, -7.64868036e-02f, -1.93155065e-01f, -1.20689623e-01f, 6.77297264e-02f, -1.76968277e-01f, -1.05251960e-01f, 2.69769914e-02f, -3.28522585e-02f, -2.44273722e-01f,
  -2.11958840e-01f, -3.93709511e-01f, -2.15584800e-01f, -1.75713167e-01f, -1.18267827e-01f, -1.03157222e-01f, -2.26704150e-01f, -7.26912022e-02f, -6.45031966e-03f, -2.19364971e-01f,
  -1.23634964e-01f, 2.08599091e-01f, 2.06206337e-01f, 1.39402717e-01f, 1.50227979e-01f, -1.09653749e-01f, -4.30355594e-02f, 1.11507043e-01f, 2.08839208e-01f, 1.25754058e-01f,
  7.13541433e-02f, 1.78487005e-03f, 7.26397708e-02f, 7.49167502e-02f, -1.51079878e-01f, 1.26004502e-01f, -7.53672868e-02f, -1.34368643e-01f, -6.95665404e-02f, -1.17225096e-01f,
  -8.85684863e-02f, -3.27115536e-01f, 2.12947190e-01f, 1.60183743e-01f, 6.25709491e-03f, 8.36261958e-02f, -6.36084527e-02f, 3.06092054e-02f, -9.87285096e-03f, 3.41764167e-02f,
  -3.05030160e-02f, 2.89527345e-02f, 2.41729487e-02f, -3.15354541e-02f, -9.98069569e-02f, -2.92653404e-03f, 3.17154042e-02f, 8.52211863e-02f, -5.09152673e-02f, -1.27629206e-01f,
  5.09727709e-02f, -1.38221502e-01f, -5.82844652e-02f, 1.28237857e-02f, -5.39623871e-02f, 8.21983740e-02f, -4.31177253e-03f, 4.84836102e-02f, 2.93949209e-02f, -9.57304314e-02f,
  -4.71600667e-02f, 1.95611119e-02f, 1.33191459e-02f, 1.76597834e-02f, 1.38682425e-02f, -1.89876072e-02f, -1.00082587e-02f, -5.91892004e-03f, 6.53417930e-02f, -1.87696740e-02f,
  3.85398343e-02f, -2.29294738e-03f, -1.59086846e-02f, -6.16799109e-02f, -1.27232708e-02f, -4.46389848e-03f, -1.79321300e-02f, 4.02173027e-02f, -4.44064364e-02f, 5.07930480e-02f,
  7.84241185e-02f, 8.51029623e-03f, 6.03310717e-03f, 1.75249539e-02f, -1.19734425e-02f, -4.88740578e-02f, -2.61363164e-02f, 3.27303261e-03f, 7.71210194e-02f, -4.25758101e-02f,
  8.63225479e-03f, 1.00068688e-01f, -1.03694975e-01f, -8.89439229e-03f, -9.36209857e-02f, 2.05338951e-02f, 2.10432758e-04f, -3.92882191e-02f, 4.73142564e-02f, -9.80770811e-02f,
  -3.33876871e-02f, -3.86101641e-02f, -1.01192147e-01f, 8.73423740e-02f, 7.17280433e-04f, -7.04360334e-03f, 1.27878804e-02f, -3.13140079e-02f, 7.18693016e-03f, -4.04155366e-02f,
  -1.83845330e-02f, -1.16220983e-02f, -5.49761504e-02f, 2.46637594e-02f, 3.86614949e-02f, 1.54556647e-01f, -7.77102336e-02f, 4.74165231e-02f, 5.28565310e-02f, -1.39129296e-01f,
  -1.13567561e-01f, 1.71255339e-02f, -2.05689147e-01f, -1.22219667e-01f, -1.41237214e-01f, -5.21552600e-02f, -3.42738703e-02f, -4.12544720e-02f, 2.76553747e-03f, -5.63845132e-03f,
  1.97290722e-02f, -3.98559589e-03f, -5.51354252e-02f, -4.38364632e-02f, -1.27398044e-01f, -1.04584843e-01f, -1.31906718e-01f, -2.41599351e-01f, -7.21548349e-02f, 2.38673594e-02f,
  1.01878168e-02f, 2.77126674e-02f, -1.21472850e-01f, 6.37975289e-03f, 6.36335388e-02f, -5.14086569e-03f, -1.09962091e-01f, -2.07856223e-02f, -4.54462394e-02f, -4.81369533e-02f,
  -8.24566931e-02f, 9.91813242e-02f, -9.55403969e-02f, 3.43230902e-03f, -6.32527024e-02f, -6.56565279e-02f, -6.92150071e-02f, 4.84822504e-02f, 6.18866235e-02f, 6.44728541e-02f,
  7.40845650e-02f, -4.02002409e-03f, 3.92977940e-03f, 3.40881869e-02f, 7.63106719e-02f, 6.38366714e-02f, 1.96264777e-03f, -4.98268716e-02f, -1.05734475e-01f, 1.23098381e-01f,
  -1.78772677e-02f, -8.01345259e-02f, -3.45732346e-02f, -3.70484171e-03f, 1.96784772e-02f, -8.24796185e-02f, -2.96855494e-02f, 4.05184813e-02f, -9.99065489e-02f, 4.84626554e-02f,
  1.98796373e-02f, -4.67870273e-02f, 1.22880749e-02f, -1.68797642e-03f, 2.90492810e-02f, 3.99031602e-02f, 5.17820492e-02f, 8.34051520e-02f, -1.23035936e-02f, -4.50544283e-02f,
  -2.89389379e-02f, 4.42064516e-02f, -4.33307141e-03f, 4.42578793e-02f, -3.13732438e-02f, 6.93570375e-02f, -4.09587100e-02f, -1.63987279e-02f, 5.49509749e-02f, -6.46957383e-02f,
  8.72893073e-03f, 4.69906591e-02f, -5.11643328e-02f, 9.88588631e-02f, 9.92087871e-02f, -3.13722864e-02f, 2.29828376e-02f, -2.22630091e-02f, -4.32493798e-02f, 1.33157466e-02f,
  2.21827533e-02f, 5.25616147e-02f, -6.11166321e-02f, 1.02775954e-02f, -2.65177060e-03f, 1.06043918e-02f, 3.69577147e-02f, -7.56392926e-02f, -5.07205799e-02f, -6.77892715e-02f,
  7.37096891e-02f, -1.95247047e-02f, 5.58751598e-02f, 1.83518771e-02f, -1.09194390e-01f, -2.66451053e-02f, 2.17349757e-03f, -5.46495095e-02f, -6.55601993e-02f, 9.03928354e-02f,
  -5.19850198e-03f, -1.45104095e-01f, -1.47234768e-01f, -1.66089252e-01f, -8.52903537e-03f, -1.88009590e-01f, -4.93833758e-02f, -1.22857749e-01f, -2.09033072e-01f, -4.41468507e-02f,
  -4.98902589e-01f, 1.22001693e-01f, 2.59389162e-01f, -1.67114362e-01f, 1.65649399e-01f, 2.16701940e-01f, 2.21982911e-01f, -6.32047653e-02f, -1.06616110e-01f, 1.05488496e-02f,
  6.29345849e-02f, 1.02491245e-01f, 1.12580776e-01f, 8.59768987e-02f, 4.15327325e-02f, 1.42204657e-01f, 1.62395880e-01f, 2.18231250e-02f, -5.35587929e-02f, -2.87447106e-02f,
  1.02208465e-01f, -1.18552953e-01f, -2.56128103e-01f, -1.51428074e-01f, 1.06833167e-01f, 1.20148800e-01f, -2.07708906e-02f, 9.29009020e-02f, 1.47565752e-01f, 6.25766292e-02f,
  2.11819977e-01f, -4.39398885e-02f, 5.27174063e-02f, -8.49812850e-02f, 3.12294327e-02f, -1.52509943e-01f, 3.26816961e-02f, -2.49317698e-02f, -1.13277741e-01f, -4.82617319e-02f,
  1.60211176e-02f, -7.07538724e-02f, 1.11512490e-01f, 1.04924347e-02f, 4.52764286e-03f, -3.43124904e-02f, -1.27863973e-01f, -5.87816536e-02f, -7.51054883e-02f, 3.73736881e-02f,
  1.86488315e-01f, 9.79254618e-02f, -4.83990088e-02f, -5.66008985e-02f, -5.12503386e-02f, 1.08541340e-01f, 1.73833854e-02f, 5.62815219e-02f, -3.72273400e-02f, -1.97325163e-02f,
  3.85055691e-02f, 5.30826785e-02f, -3.53594916e-03f, -8.86631534e-02f, -1.79324672e-02f, -8.00640211e-02f, 6.41831476e-03f, 8.31096061e-03f, 2.11138949e-02f, -2.19990239e-02f,
  -2.54230183e-02f, 2.06806008e-02f, -1.13473935e-02f, -5.63951209e-03f, 3.51394042e-02f, 8.24167132e-02f, -1.01805315e-03f, -3.71475867e-03f, 8.65342282e-03f, -2.96509974e-02f,
  -1.46890571e-02f, -3.06363069e-02f, -1.72148068e-02f, -4.87173349e-03f, 1.32216305e-01f, -3.55259590e-02f, 3.27855833e-02f, 2.27714255e-02f, 4.57653366e-02f, 2.52706707e-02f,
  -1.09490000e-01f, 7.31502846e-02f, -7.95994923e-02f, -9.12130624e-03f, -3.00796553e-02f, -1.80052742e-02f, 8.94109160e-02f, -3.35943922e-02f, 7.40795955e-02f, 1.02951147e-01f,
  7.15418682e-02f, -2.40484830e-02f, 8.60735849e-02f, 6.37039468e-02f, -2.56235283e-02f, -3.87664251e-02f, -7.23350570e-02f, 7.91729614e-02f, 6.83244839e-02f, -1.01500731e-02f,
  8.75162333e-03f, -1.54580161e-01f, -1.98916763e-01f, -1.39514580e-02f, 5.55945300e-02f, -5.09379208e-02f, 2.68886294e-02f, -3.92817631e-02f, -5.16442284e-02f, -1.63624942e-01f,
  3.46722573e-01f, 2.15852186e-01f, -6.04966320e-02f, 1.78777173e-01f, -1.99203491e-01f, -3.13975185e-01f, -2.59352386e-01f, -1.19622618e-01f, 6.94555193e-02f, 1.89926121e-02f,
  1.03402227e-01f, 1.11885883e-01f, 9.47276428e-02f, -3.59080546e-02f, -1.30223766e-01f, -4.16845679e-02f, 4.37067822e-02f, -6.48900196e-02f, -2.44265899e-01f, -2.04157650e-01f,
  2.98405420e-02f, 1.49236754e-01f, 2.03219548e-01f, 1.23058468e-01f, 1.46706617e-02f, 5.72329648e-02f, -5.70537709e-03f, 3.75357531e-02f, 1.43550299e-02f, 2.47245550e-01f,
  -1.27585515e-01f, 1.09234959e-01f, -1.44544512e-01f, 1.22440867e-01f, 4.19585630e-02f, 5.53417057e-02f, 4.76242341e-02f, 5.43765649e-02f, 2.68185604e-02f, 4.05650325e-02f,
  -3.59217077e-02f, 6.75934628e-02f, 6.72195330e-02f, -3.58582549e-02f, 5.38958013e-02f, -4.26091328e-02f, 6.83660731e-02f, 2.03822646e-02f, 5.61555326e-02f, 3.27725038e-02f,
  4.03936431e-02f, -3.12138535e-02f, -5.99182546e-02f, -7.39468038e-02f, -1.10993512e-01f, 8.13582838e-02f, 6.27031699e-02f, -1.23223234e-02f, 2.67177448e-02f, 3.17743905e-02f,
  1.81840453e-02f, 4.87856567e-02f, -5.47136180e-02f, 4.44685221e-02f, 2.31275726e-02f, -8.09571221e-02f, -9.21941828e-03f, -7.19274059e-02f, -4.36209813e-02f, 9.68102191e-04f,
  -4.14073542e-02f, -2.14543641e-02f, -3.03042196e-02f, 2.89102737e-02f, 5.34785986e-02f, -5.34825064e-02f, 2.07272768e-02f, 2.78699975e-02f, -7.78056756e-02f, 6.80502802e-02f,
  3.25302556e-02f, 2.71911337e-03f, 1.88465174e-02f, 3.27575877e-02f, -1.55525086e-02f, 1.08969910e-02f, 1.62458476e-02f, 2.28302757e-04f, 3.18910219e-02f, 5.25967404e-03f,
  5.74527821e-03f, 3.91711714e-03f, 5.90094104e-02f, -2.45442707e-02f, 4.74289283e-02f, 2.12649200e-02f, 1.54780457e-02f, 6.55046999e-02f, 2.11353749e-02f, -7.60328993e-02f,
  1.60357524e-02f, -2.00366434e-02f, -1.67939474e-03f, 5.54895252e-02f, -1.02883976e-04f, -9.67850685e-02f, 1.80807151e-02f, 3.03036328e-02f, 2.71010026e-02f, -4.82015721e-02f,
  8.39882046e-02f, -3.36857960e-02f, -1.25529662e-01f, -1.24092720e-01f, 7.72304554e-03f, -5.02200797e-02f, -1.63766935e-01f, -1.13434181e-01f, -1.18980758e-01f, 3.40380780e-02f,
  3.01918834e-01f, -8.68110061e-02f, -1.39632644e-02f, -8.76674876e-02f, -2.47053698e-01f, -1.18797004e-01f, -1.06583638e-02f, 2.15400919e-01f, 1.32574186e-01f, -1.47354990e-01f,
  -2.25888893e-01f, -4.73420583e-02f, 1.84189752e-01f, 2.39274129e-01f, 3.32590848e-01f, 5.40680401e-02f, 9.72605422e-02f, 3.61839145e-01f, 3.01807404e-01f, 4.13724855e-02f,
  -5.24521694e-02f, -5.66468611e-02f, 1.51387587e-01f, 1.81986541e-01f, -2.03003407e-01f, -1.05500206e-01f, -9.56570432e-02f, -1.40974656e-01f, -8.14392492e-02f, -1.13020413e-01f,
  -1.92020506e-01f, 1.12024032e-01f, 1.19965360e-01f, -6.86635077e-02f, -1.56722143e-01f, 7.71009549e-02f, 7.47635886e-02f, 1.19234040e-01f, -4.02689427e-02f, -4.18817960e-02f,
  -9.15035382e-02f, -1.65381003e-02f, -3.76295708e-02f, -1.10064797e-01f, 3.31491120e-02f, 7.12052807e-02f, 6.42618686e-02f, 1.90731421e-01f, 7.53739253e-02f, -9.29868519e-02f,
  -2.24412411e-01f, -9.71689224e-02f, 5.37148630e-03f, -1.09556373e-02f, 7.38303289e-02f, 1.01179302e-01f, -7.08353221e-02f, 6.36729458e-03f, 1.44518659e-01f, -3.61654907e-02f,
  2.65510399e-02f, -4.31376547e-02f, -5.69852553e-02f, -4.77348454e-03f, -3.24838832e-02f, -8.41769483e-03f, 1.38983447e-02f, -6.85621426e-02f, 1.64143350e-02f, -2.80921571e-02f,
  1.65731106e-02f, 1.53718041e-02f, -4.45178524e-02f, 5.10455966e-02f, -4.69144098e-02f, -6.38074204e-02f, 3.99720892e-02f, -4.92787249e-02f, 3.14025730e-02f, -5.41133955e-02f,
  9.57607254e-02f, -2.67823301e-02f, -9.57347229e-02f, 2.01298576e-02f, 2.90421373e-03f, 2.72091459e-02f, 1.55933946e-02f, -6.77468106e-02f, -2.59713456e-02f, -1.62672903e-02f,
  -1.05260402e-01f, 1.36677504e-01f, -3.35514173e-02f, 1.75856978e-01f, -7.18897209e-05f, -3.24035920e-02f, -6.97052851e-02f, 7.88231045e-02f, -1.46954441e-02f, 1.45194670e-02f,
  -1.88736245e-02f, 2.79423390e-02f, 5.86506091e-02f, -1.81001872e-02f, 2.51970347e-02f, -1.96647104e-02f, -1.87857039e-02f, 5.46855899e-03f, 1.39731457e-02f, -1.53659135e-01f,
  -4.25652834e-03f, -3.37266363e-02f, 1.22875102e-01f, 6.85640201e-02f, -3.05836182e-02f, 6.87796474e-02f, -2.28303540e-02f, -7.34976903e-02f, 1.76532596e-01f, -6.99921921e-02f,
  2.89227694e-01f, 1.87332407e-01f, 2.54641294e-01f, 1.99728936e-01f, 1.53550655e-01f, 2.78819650e-01f, 1.61750153e-01f, 1.40398562e-01f, 1.44472584e-01f, 1.25212491e-01f,
  4.02113330e-03f, -2.47861221e-02f, 3.98241803e-02f, -7.37422481e-02f, 1.24592029e-01f, 1.02449320e-01f, 2.46769339e-01f, 6.82465509e-02f, 1.21025696e-01f, 2.06814826e-01f,
  2.72358824e-02f, 2.26674944e-01f, 5.98462708e-02f, 4.80677374e-02f, 1.45619661e-01f, -4.44628224e-02f, 1.47861019e-01f, 6.07059412e-02f, 5.00276797e-02f, 1.17956944e-01f,
  1.15005903e-01f, 2.58270264e-01f, -4.95479554e-02f, -1.02690324e-01f, -5.29100820e-02f, 2.11680532e-02f, 5.18692993e-02f, 7.30792107e-03f, -6.19073510e-02f, 2.00387388e-02f,
  6.18840940e-02f, 2.93928050e-02f, 1.65796671e-02f, -3.97099629e-02f, 8.69419649e-02f, -1.60931814e-02f, -3.43978219e-02f, 5.07345330e-03f, 1.04471959e-01f, -1.46612395e-02f,
  1.22922085e-01f, 1.19086325e-01f, -5.32255769e-02f, -4.59901243e-02f, 3.03814951e-02f, -7.73155689e-02f, 5.34442589e-02f, 7.08965138e-02f, 3.86215337e-02f, -1.36223854e-03f,
  -5.45137702e-03f, 3.89633258e-03f, -1.00027341e-02f, 8.76435358e-03f, -3.81075628e-02f, -6.19747899e-02f, 1.06637264e-02f, 2.28628274e-02f, -3.03244926e-02f, 2.73813624e-02f,
  -6.90014511e-02f, 4.15831581e-02f, 1.99742448e-02f, 7.40271062e-02f, -4.03774567e-02f, -3.89835401e-03f, 1.02201453e-03f, -4.90774214e-02f, -4.71851528e-02f, -2.55589820e-02f,
  -1.68865663e-03f, -3.63477878e-02f, 5.62285408e-02f, -6.64191619e-02f, 2.18780152e-02f, 9.87830479e-03f, 3.54393125e-02f, 2.83066873e-02f, -6.12510256e-02f, 3.69476564e-02f,
  -1.11275733e-01f, 4.46508937e-02f, -2.50906893e-03f, -7.55765662e-02f, 3.45508419e-02f, -4.52772118e-02f, -4.21774201e-03f, -1.17947914e-01f, 3.02283396e-03f, 5.88035770e-02f,
  -4.89176139e-02f, 2.93596578e-03f, 2.19458155e-02f, 8.80455191e-04f, 6.89523295e-02f, 5.10800965e-02f, -9.55208242e-02f, -1.81460492e-02f, -7.28887841e-02f, 1.34777641e-02f,
  -5.73837683e-02f, -1.12307906e-01f, -1.38390943e-01f, -1.08948223e-01f, -4.75437008e-02f, -8.41940418e-02f, -7.34245777e-02f, -1.52374357e-01f, -6.63392022e-02f, -1.83987707e-01f,
  -1.80033460e-01f, -1.14823841e-01f, -3.50254655e-01f, -2.42500797e-01f, -9.69384685e-02f, -9.77371335e-02f, -4.40043658e-02f, 5.77622876e-02f, -4.91666375e-03f, -1.14989951e-01f,
  1.21727988e-01f, 2.01240793e-01f, -2.69063655e-02f, -2.57925894e-02f, -1.34357437e-01f, -3.43249559e-01f, -3.69950891e-01f, -3.42288584e-01f, -1.70088168e-02f, 2.87691820e-02f,
  3.02843098e-02f, -1.66618556e-01f, -1.22503705e-01f, -3.99318710e-02f, -4.01452631e-02f, 1.05660081e-01f, -1.30348504e-01f, -7.33641610e-02f, -1.31369447e-02f, -2.68655270e-01f,
  -1.44797176e-01f, -9.52630416e-02f, 9.46678743e-02f, 9.44998413e-02f, 7.24027632e-03f, 1.23250978e-02f, 8.15523788e-03f, 4.14087586e-02f, 1.53925847e-02f, 1.19945302e-03f,
  1.20672725e-01f, 1.28102705e-01f, -2.08553392e-02f, 6.50276318e-02f, -6.73520416e-02f, -5.76039136e-04f, -4.38666493e-02f, -7.26374090e-02f, 8.30914732e-03f, -3.54293101e-02f,
  1.30447224e-01f, 3.36867273e-02f, -5.90631664e-02f, -4.53234045e-03f, 3.59516852e-02f, 9.50574316e-03f, 4.78081917e-03f, -4.30904329e-02f, -1.12631489e-02f, -1.22481184e-02f,
  -5.38078286e-02f, -8.89508501e-02f, 5.29166423e-02f, 5.18276766e-02f, -5.19158924e-03f, 8.69699270e-02f, -3.06331795e-02f, 9.70163848e-03f, -1.61298253e-02f, 5.37599809e-02f,
  -2.42757201e-02f, -7.30794072e-02f, 2.46192655e-03f, -2.12036353e-02f, -5.91128841e-02f, 3.16157527e-02f, 7.37634599e-02f, -3.38710584e-02f, -7.87707791e-03f, 7.98596665e-02f,
  6.86818035e-03f, 2.68077310e-02f, -4.62262854e-02f, 7.42709339e-02f, -3.34088057e-02f, -5.46190850e-02f, -2.05218047e-02f, 1.54813513e-01f, -4.22675014e-02f, 1.29015734e-02f,
  1.23603292e-01f, 1.81208119e-01f, -1.17279276e-01f, 4.38683247e-03f, -5.97596839e-02f, 5.04544042e-02f, 2.43310095e-03f, -3.67747396e-02f, 5.39692864e-02f, 3.32487351e-03f,
  5.20457514e-02f, -2.29063220e-02f, -6.43305331e-02f, 3.96799706e-02f, 2.35761479e-02f, 7.81483278e-02f, -8.70173331e-03f, -8.66675377e-02f, 2.31038071e-02f, -1.66606028e-02f,
  3.15540619e-02f, 6.97487667e-02f, 7.34540150e-02f, 1.69635527e-02f, -3.30330282e-02f, 7.99264088e-02f, 1.06106460e-01f, 1.03357904e-01f, 7.42070600e-02f, -2.24059094e-02f,
  3.61719400e-01f, -1.50214970e-01f, -7.60745630e-02f, 1.45561993e-01f, 5.40226698e-03f, 7.13177398e-02f, 1.35500416e-01f, 1.19772606e-01f, 9.54998210e-02f, -1.39192924e-01f,
  -1.36337444e-01f, 4.81471419e-02f, -5.57069071e-02f, -8.59499536e-03f, 1.99206278e-01f, -4.12735045e-02f, -2.61970479e-02f, 7.30029643e-02f, 2.63111651e-01f, 2.51945443e-02f,
  3.76270898e-02f, 4.06058021e-02f, 1.65277794e-01f, 4.44939807e-02f, -1.90072469e-02f, 2.93373298e-02f, -2.34329123e-02f, -9.06061679e-02f, -8.78529772e-02f, -2.34170377e-01f,
  -3.77627939e-01f, -5.19244969e-02f, 1.36725888e-01f, -1.50838494e-02f, -1.08936198e-01f, -5.13494723e-02f, -4.98340130e-02f, 1.48985256e-02f, 1.40662007e-02f, 5.13433255e-02f,
  5.54140955e-02f, -1.72615866e-03f, -1.00927688e-02f, -4.01621796e-02f, 8.22143629e-03f, -5.62197063e-03f, -1.88368820e-02f, 1.42339066e-01f, -2.30566580e-02f, -1.51593655e-01f,
  -7.95101449e-02f, -9.41976458e-02f, -1.92517228e-02f, 1.56160807e-02f, 1.21530648e-02f, 2.75298823e-02f, -1.03134468e-01f, 4.82163765e-02f, -6.33757114e-02f, -5.25183305e-02f,
  -5.30502573e-02f, -2.64960323e-02f, 2.72921491e-02f, -7.58217797e-02f, 5.56673072e-02f, 4.00155112e-02f, 7.41044292e-03f, 1.16046043e-02f, -2.06437390e-02f, 6.71915486e-02f,
  1.76687837e-02f, -2.83159800e-02f, -3.01805995e-02f, -3.91307734e-02f, -2.96210591e-02f, 8.19708705e-02f, -4.86251637e-02f, 6.31558597e-02f, -3.05687841e-02f, -4.78325738e-03f,
  -4.19492014e-02f, -5.75986411e-03f, 3.87326032e-02f, -3.38337012e-02f, 3.99631485e-02f, -1.48855485e-02f, -2.37060320e-02f, -5.98632060e-02f, -2.51204036e-02f, 7.61076510e-02f,
  -4.68858741e-02f, 2.07799956e-01f, -9.67249870e-02f, -2.39571705e-02f, 6.50134170e-03f, 3.79257865e-04f, 1.47219514e-02f, 8.12112018e-02f, -3.45058390e-03f, 2.56128311e-02f,
  -5.15880994e-02f, 3.47101204e-02f, -5.35316579e-02f, -5.97532280e-02f, 2.05249228e-02f, 7.18250573e-02f, -4.47145700e-02f, 8.63152966e-02f, 3.79782878e-02f, 2.39806902e-02f,
  -2.83747520e-02f, 4.65854518e-02f, 6.81057945e-02f, -6.93304017e-02f, 3.10383644e-02f, 5.25809675e-02f, 2.58000381e-02f, -9.50630102e-03f, 2.73928680e-02f, 6.86353445e-02f,
  -1.85219973e-01f, -3.15593034e-01f, 8.09658393e-02f, -1.12400524e-01f, -4.53941524e-02f, -5.73483668e-02f, -2.48116747e-01f, -1.89292058e-01f, -1.81079820e-01f, -1.74208596e-01f,
  -5.31777628e-02f, 1.99823812e-01f, 1.45234704e-01f, 1.15015477e-01f, 1.21658377e-01f, -1.92075804e-01f, -1.84462816e-01f, 1.67310596e-01f, 2.39989609e-01f, 1.14667021e-01f,
  -5.03964908e-02f, -4.64354903e-02f, 3.82830836e-02f, 2.18360312e-02f, -9.62381661e-02f, 4.86770459e-02f, -2.53372155e-02f, 2.62438767e-02f, 5.64625580e-03f, -3.85677665e-02f,
  9.09992829e-02f, 5.63498400e-02f, 1.36809498e-01f, -3.80113982e-02f, 9.87256393e-02f, -2.31917072e-02f, -1.16165459e-01f, 2.49739997e-02f, -3.86172943e-02f, -1.12150505e-01f,
  4.13305387e-02f, -2.00075246e-02f, 5.15060239e-02f, 1.44585241e-02f, -7.88031742e-02f, -4.51231934e-02f, -4.07593884e-02f, 1.04168497e-01f, 2.19004415e-02f, -7.76741747e-03f,
  -6.32625669e-02f, 6.42026737e-02f, 1.38584495e-01f, -1.62297189e-02f, 5.90457916e-02f, 1.05367415e-01f, 5.11938594e-02f, -1.90473720e-02f, -3.94855477e-02f, -2.15364963e-01f,
  -1.20449474e-03f, -2.00310685e-02f, 3.72924581e-02f, -4.77560237e-02f, -1.66024920e-02f, 5.14605120e-02f, -5.59778921e-02f, -1.74995977e-03f, 3.53955030e-02f, -4.09489451e-03f,
  4.28895429e-02f, 1.39595401e-02f, 7.68867787e-03f, -2.49469653e-02f, -4.45107333e-02f, -1.13097820e-02f, -1.16208456e-02f, -1.01107098e-01f, -3.64145748e-02f, 6.50969297e-02f,
  2.84455065e-02f, 6.95830956e-02f, -4.57111336e-02f, 6.37863204e-02f, -2.66027376e-02f, 2.96287220e-02f, 2.00745203e-02f, 4.27906439e-02f, 3.09869330e-02f, -1.36898654e-02f,
  -1.96758881e-01f, 1.53295815e-01f, -3.34634781e-02f, 2.85171345e-02f, -3.72056998e-02f, 2.04632543e-02f, 4.17601541e-02f, -7.33571406e-03f, 6.73248619e-02f, -2.24595219e-02f,
  1.52959228e-02f, 6.91252947e-02f, 2.58076359e-02f, -2.94185542e-02f, -3.48363146e-02f, 3.01358458e-02f, -8.74387249e-02f, 4.71368618e-02f, 2.97334902e-02f, -1.94726456e-02f,
  -5.73536307e-02f, -7.90809020e-02f, -9.89401489e-02f, -9.70953628e-02f, -2.81655267e-02f, 8.06061924e-02f, 9.29068867e-03f, -1.19033925e-01f, 2.47963388e-02f, -4.05988574e-01f,
  -4.84723002e-02f, 3.22751790e-01f, 4.70111966e-01f, -2.26833418e-01f, -2.56567806e-01f, 3.63898203e-02f, 2.71766633e-02f, -6.96111619e-02f, -1.96534410e-01f, -1.02608781e-02f,
  1.05986267e-01f, -8.70543718e-02f, -9.14433897e-02f, 4.13201600e-02f, 1.23154916e-01f, 5.74786738e-02f, -3.42021473e-02f, 2.09123939e-02f, 6.26053959e-02f, -1.15946785e-01f,
  -2.11452365e-01f, -8.12202245e-02f, 2.02639457e-02f, -7.47919604e-02f, -9.94046107e-02f, -1.55410841e-01f, 1.78138971e-01f, 1.49687156e-01f, 2.89809350e-02f, 1.12013191e-01f,
  3.37141037e-01f, 2.37279251e-01f, -1.29550785e-01f, -5.17382845e-02f, 2.75755096e-02f, 7.00720325e-02f, 5.17790671e-03f, -1.89425031e-04f, -7.23679438e-02f, 2.47555487e-02f,
  6.86325319e-03f, 6.62104413e-02f, -5.17982878e-02f, -4.59796898e-02f, -6.00930452e-02f, 4.51652557e-02f, 1.45654216e-01f, 8.49428996e-02f, 6.45293370e-02f, 1.62706465e-01f,
  -1.15546510e-01f, 6.36389256e-02f, 1.98828816e-01f, 1.83282197e-02f, 1.47109464e-01f, -7.37573653e-02f, 1.51778951e-01f, 1.71912368e-02f, 9.46302190e-02f, 1.65027380e-02f,
  -2.03644671e-02f, 1.43760014e-02f, 1.23333558e-03f, -2.19844654e-02f, -2.30268184e-02f, -2.32852716e-02f, -2.41055321e-02f, -3.62033024e-02f, 1.05790356e-02f, -1.57744810e-02f,
  2.96025947e-02f, 8.76095444e-02f, -3.20246816e-02f, 8.66710022e-03f, -7.04048127e-02f, 6.47572726e-02f, -3.09658758e-02f, 3.38091403e-02f, -6.67110365e-03f, 1.48626529e-02f,
  1.26549006e-02f, -3.07035837e-02f, 4.48934250e-02f, 1.07525811e-02f, -2.16904897e-02f, 7.53040016e-02f, -2.71044541e-02f, -3.43383327e-02f, -7.90585473e-04f, 1.92680396e-02f,
  -1.77973539e-01f, 9.22389999e-02f, -1.08728580e-01f, -3.16699632e-02f, -1.20598637e-02f, 2.87671108e-02f, -6.01084083e-02f, 8.82611796e-02f, -4.91826274e-02f, 3.86240408e-02f,
  -3.15292105e-02f, -1.06000546e-02f, 8.40260535e-02f, -2.53122579e-02f, -3.87258120e-02f, -8.47859010e-02f, -5.91104925e-02f, -2.56326534e-02f, 3.76808159e-02f, 1.92559287e-02f,
  -2.28782371e-03f, -1.25245079e-01f, -1.01773247e-01f, -5.78447320e-02f, -1.92745496e-02f, -1.68102056e-01f, 4.01047617e-02f, -4.56469227e-03f, -6.22113794e-02f, -2.21214086e-01f
};

// L0_fan_Wp_bar (Shape: 52 x 120)
const int L0_fan_Wp_bar_rows = 52;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -3.32065746e-02f, -9.60787088e-02f, -1.20773278e-01f, 6.83035403e-02f, -1.13381580e-01f, -2.21038200e-02f, -8.54043439e-02f, -3.89736816e-02f, 9.44628939e-02f, -1.37378648e-01f,
  -7.27257580e-02f, 4.73586321e-02f, -1.26477659e-01f, -3.43490019e-02f, -1.92383513e-01f, -1.85274795e-01f, -2.09003121e-01f, -1.04370296e-01f, -6.69693649e-02f, -7.67281130e-02f,
  3.19308713e-02f, -1.32596910e-01f, -7.40825832e-02f, -6.60014600e-02f, -7.41966739e-02f, -1.40039176e-01f, -1.88369125e-01f, -1.04254626e-01f, -1.78797767e-01f, -1.87009245e-01f,
  -8.88440162e-02f, 1.48812056e-01f, 6.81443959e-02f, 1.85864773e-02f, 2.57186014e-02f, 4.89962585e-02f, 6.70290589e-02f, 7.53474757e-02f, 8.76200348e-02f, -1.56772025e-02f,
  -5.08877188e-02f, -4.57179062e-02f, -7.25963861e-02f, 4.64483052e-02f, 1.10622216e-02f, 4.63810079e-02f, -8.99394155e-02f, -4.41649333e-02f, 4.29879315e-02f, 3.64395045e-02f,
  -8.03118274e-02f, -9.19685960e-02f, -5.23441248e-02f, 4.48306426e-02f, -7.53847277e-03f, -2.54115835e-02f, -3.12079266e-02f, 4.67407837e-04f, -3.17387767e-02f, -1.87003195e-01f,
  4.44427552e-03f, -2.44062040e-02f, 5.10114282e-02f, -2.23737247e-02f, 2.39573093e-03f, -4.12768573e-02f, -3.71289961e-02f, 2.31278408e-02f, 2.27175001e-02f, -7.55488649e-02f,
  6.54113367e-02f, -4.47342917e-02f, -5.26123047e-02f, -8.08067620e-02f, -4.61629927e-02f, 1.25431246e-03f, 3.06069236e-02f, -5.77030890e-02f, -3.95383798e-02f, 5.60044535e-02f,
  1.38286352e-02f, 6.87946901e-02f, 6.00961931e-02f, -7.92002529e-02f, -8.01625773e-02f, -5.97046912e-02f, -9.01298895e-02f, 1.05961241e-01f, 1.42424591e-02f, -5.91838546e-02f,
  6.98881447e-02f, -7.01959506e-02f, -9.49524194e-02f, 8.43137950e-02f, -7.95108378e-02f, 3.55104506e-02f, 2.03798548e-03f, 1.04899975e-02f, 7.31738135e-02f, -8.57709572e-02f,
  1.20371461e-01f, -6.76286547e-03f, 5.62611129e-03f, -5.46515398e-02f, -8.08550604e-03f, -5.46799637e-02f, -3.94830965e-02f, -6.81149140e-02f, -3.11571471e-02f, 3.18702720e-02f,
  -1.26781479e-01f, -1.17382832e-01f, -1.21926412e-01f, -4.46982458e-02f, -3.67845851e-03f, -8.42675418e-02f, -1.41231313e-01f, -1.03170261e-01f, -1.38643071e-01f, -2.30353907e-01f,
  2.95260161e-01f, -8.95948410e-02f, -3.63684177e-01f, 4.48268428e-02f, -1.05601475e-01f, -2.32559681e-01f, -8.54678899e-02f, -7.53303466e-04f, 1.31576702e-01f, -1.02964170e-01f,
  -1.06094189e-01f, 9.20674428e-02f, 1.85762662e-02f, -1.16194941e-01f, -1.06481701e-01f, -1.73856720e-01f, -2.29457930e-01f, -1.97205007e-01f, -1.43981054e-01f, -9.54652056e-02f,
  -2.60218922e-02f, 4.25572885e-04f, -4.62907366e-02f, -6.71056891e-03f, 2.44165683e-04f, -1.22796185e-01f, -1.16501376e-01f, -6.21442795e-02f, -1.19128592e-01f, -1.31523356e-01f,
  -2.70322710e-01f, -8.30560476e-02f, 2.55805217e-02f, -9.97226033e-03f, -9.11676586e-02f, 9.82902795e-02f, -4.01067315e-03f, -5.05115800e-02f, -7.29409456e-02f, -9.55562145e-02f,
  -5.30658476e-02f, 8.10931027e-02f, 7.66240507e-02f, -8.84401128e-02f, 8.66580978e-02f, 2.92076636e-02f, -2.95879915e-02f, -3.10843959e-02f, -2.21956950e-02f, -1.10833988e-01f,
  -1.05604887e-01f, 1.62070077e-02f, -9.88570228e-02f, 4.76827472e-02f, -1.89330764e-02f, 3.61071043e-02f, -7.99303129e-02f, -4.26329784e-02f, 1.81650370e-02f, -2.67900061e-02f,
  8.40794891e-02f, -2.84133237e-02f, -3.22308876e-02f, 5.24802096e-02f, 3.47619615e-02f, -4.74122958e-03f, -8.91978480e-03f, -6.80156946e-02f, -3.58998403e-02f, 4.06898782e-02f,
  -6.91371784e-02f, 6.61833137e-02f, -1.50173847e-02f, -6.24089874e-03f, -7.83169270e-02f, 6.81071356e-02f, 4.00855280e-02f, -7.53327459e-02f, 1.13268346e-02f, -6.21900521e-03f,
  -2.86413115e-02f, -3.99332903e-02f, 2.67830607e-03f, 5.58489896e-02f, -9.62720346e-03f, -1.67014543e-02f, -6.26579896e-02f, 3.98319811e-02f, -5.74477613e-02f, 7.66474754e-02f,
  5.40903173e-02f, -1.41736884e-02f, 8.75337720e-02f, 7.52705261e-02f, -1.12207837e-01f, -7.87221491e-02f, 3.61657105e-02f, 7.84759820e-02f, -6.91515431e-02f, -6.39959425e-02f,
  -9.64658931e-02f, 7.55608603e-02f, 5.55560365e-02f, -1.85623150e-02f, -6.61342368e-02f, -8.25100094e-02f, 8.87685269e-02f, 3.32781076e-02f, -1.41398085e-03f, -2.43685395e-02f,
  4.74983491e-02f, 1.17614470e-01f, 8.40654150e-02f, -4.23566587e-02f, -4.19686437e-02f, 1.86408160e-03f, -9.83560681e-02f, 5.30452691e-02f, 4.08605486e-02f, 1.73035577e-01f,
  1.31654451e-02f, 8.12524110e-02f, -1.01880588e-01f, 1.96944773e-02f, 1.48327440e-01f, 1.44929796e-01f, 2.28801090e-02f, 6.70349896e-02f, -3.40983532e-02f, 4.80651157e-03f,
  -4.04377840e-02f, 4.44110259e-02f, 5.12644239e-02f, -2.10981891e-02f, 6.13118596e-02f, -5.97874932e-02f, 6.88765123e-02f, -1.12946741e-01f, -5.15081584e-02f, 8.13422501e-02f,
  6.48328140e-02f, -3.99707071e-02f, -2.03131922e-02f, -6.98332489e-02f, 7.47346207e-02f, -1.72265209e-02f, 9.95275751e-02f, -5.72604612e-02f, -1.73458625e-02f, -1.38733182e-02f,
  2.23186072e-02f, -1.61417767e-01f, 4.94065136e-03f, 6.41614199e-02f, 9.47188772e-03f, -1.26524639e-04f, 7.06137344e-02f, -7.30617568e-02f, -1.12963878e-02f, -5.61743304e-02f,
  2.87847556e-02f, 4.80279736e-02f, 1.94117539e-02f, 7.05831498e-02f, 8.88942648e-03f, -6.12675585e-03f, -2.06150301e-03f, -9.53588486e-02f, -2.93515567e-02f, -1.03892505e-01f,
  4.24870625e-02f, 6.72870204e-02f, -6.01501204e-04f, -2.12604646e-02f, -5.50922975e-02f, -8.40576440e-02f, 3.38351466e-02f, -1.14779212e-01f, -4.13322309e-03f, -5.07466123e-02f,
  -6.33370876e-02f, -7.73654133e-02f, -1.05784431e-01f, 3.15099731e-02f, 6.90468214e-03f, -6.28742948e-02f, 4.81271185e-02f, 7.40491301e-02f, -3.45873809e-03f, -9.32730082e-03f,
  5.98444082e-02f, 2.82488074e-02f, 3.75277409e-03f, 1.36214904e-02f, -9.66728479e-02f, -8.82083699e-02f, -2.51076259e-02f, -6.27423078e-02f, -6.01997711e-02f, 4.27833619e-03f,
  -8.46060142e-02f, -7.43621439e-02f, 4.74953093e-02f, -2.67441962e-02f, 9.98401362e-03f, -4.58926987e-03f, 2.59726495e-02f, 1.26106832e-02f, 1.45385228e-02f, 9.31767863e-04f,
  1.23676084e-01f, -2.40624640e-02f, 3.52907740e-02f, 4.68567722e-02f, -2.90336348e-02f, -7.61444122e-02f, -5.55325113e-02f, -7.35642910e-02f, -2.41454709e-02f, -2.66154911e-02f,
  1.40858488e-02f, -4.26270515e-02f, -3.38752307e-02f, 5.08844741e-02f, 5.92647120e-02f, -7.71676823e-02f, 4.64780517e-02f, -5.03947400e-02f, -2.76957843e-02f, 3.72983478e-02f,
  -5.17182127e-02f, 8.73441398e-02f, 7.29715154e-02f, 3.10353376e-02f, 3.95795889e-02f, -8.03263485e-02f, 8.12100023e-02f, 4.24865931e-02f, 4.28748084e-03f, 1.32909983e-01f,
  7.88072273e-02f, 1.39059246e-01f, -1.11625381e-01f, 1.22165505e-03f, -5.32327145e-02f, -8.34430605e-02f, 7.84464255e-02f, 6.67956918e-02f, 1.00043364e-01f, 1.41748846e-01f,
  1.17246643e-01f, 8.07164088e-02f, 1.42289951e-01f, 5.74613772e-02f, -6.70111403e-02f, -3.24426815e-02f, 2.05251072e-02f, -4.31931764e-02f, -8.41415077e-02f, -8.56171474e-02f,
  2.42388714e-02f, 2.08724663e-02f, 3.70735824e-02f, 3.94143723e-02f, 3.45137194e-02f, 6.36136066e-03f, 2.42229681e-02f, -1.11297891e-01f, -8.23014881e-03f, 3.61333489e-02f,
  6.20891005e-02f, -8.31602439e-02f, 1.72762740e-02f, 5.53180575e-02f, -1.94487926e-02f, 3.37442495e-02f, 1.16425636e-03f, 8.80430788e-02f, 8.02373588e-02f, -1.00021595e-02f,
  -9.91059616e-02f, -9.13361274e-03f, 2.59042233e-02f, 4.06009853e-02f, -8.62730220e-02f, 4.28588390e-02f, 3.01951766e-02f, -8.67614988e-03f, 7.59303719e-02f, -7.06040785e-02f,
  -3.30377743e-02f, -9.21638459e-02f, -9.06862319e-02f, 7.27749094e-02f, 4.61175554e-02f, 4.39243251e-03f, -1.82810966e-02f, -2.86444407e-02f, -5.20097017e-02f, 5.26178069e-03f,
  -7.59048387e-02f, 8.67984295e-02f, -1.10586718e-01f, -4.49137725e-02f, -1.01601910e-02f, -2.80819368e-02f, -3.31054702e-02f, 3.34974267e-02f, -2.86908839e-02f, 4.56794761e-02f,
  -4.17533778e-02f, -2.42350809e-02f, -7.49968663e-02f, 3.11017479e-03f, -8.59888177e-03f, -7.62721971e-02f, -9.70496610e-02f, -7.41904378e-02f, -6.24929331e-02f, 4.17982787e-02f,
  -9.92139727e-02f, -7.44644925e-02f, -2.02714410e-02f, -1.03239082e-01f, -1.39518557e-02f, -1.45413829e-02f, -5.85498102e-02f, 6.05942309e-02f, 9.07553807e-02f, -7.62036219e-02f,
  2.24540606e-01f, -1.39567032e-01f, -3.63795012e-02f, -4.52894941e-02f, -3.39561631e-03f, 3.89067344e-02f, 1.46644562e-02f, -8.69585648e-02f, -4.87276763e-02f, 3.76043320e-02f,
  -6.52353093e-02f, -8.26087967e-02f, -3.46214995e-02f, 2.89334916e-03f, 8.37875009e-02f, -1.65008139e-02f, 6.14541359e-02f, -8.01758170e-02f, 7.44671971e-02f, -1.84048265e-02f,
  -4.60082525e-03f, -2.52324399e-02f, 1.08083576e-01f, 5.53413071e-02f, 8.62303600e-02f, -3.09766475e-02f, 1.09356329e-01f, 8.28886777e-02f, 8.29649791e-02f, 2.90867593e-02f,
  7.42368922e-02f, 1.13910273e-01f, -1.05235189e-01f, 6.92563206e-02f, -3.14543247e-02f, 8.02785754e-02f, 9.20413621e-03f, -1.05498964e-02f, 9.92132723e-02f, -1.08189695e-03f,
  8.87295976e-02f, -9.37342737e-03f, 4.63473722e-02f, 6.71745762e-02f, 4.05759029e-02f, -6.35108575e-02f, 5.92702515e-02f, -1.31131411e-01f, -2.59755030e-02f, -6.28166422e-02f,
  -7.76157081e-02f, -7.54156113e-02f, -9.34983268e-02f, -4.35292758e-02f, 3.02727986e-02f, 3.85848098e-02f, -3.27066146e-02f, 2.08076611e-02f, -4.45648171e-02f, -3.19126644e-03f,
  4.39835116e-02f, 5.77705801e-02f, -8.30241442e-02f, -5.08605409e-03f, 6.16094470e-02f, -6.84308857e-02f, -9.12462845e-02f, -4.41762432e-02f, -1.84358414e-02f, -3.75995785e-02f,
  -3.42334695e-02f, -6.46916330e-02f, 4.80549447e-02f, 6.42560124e-02f, 4.01128596e-03f, 5.24766706e-02f, 9.31837931e-02f, 5.28650023e-02f, 3.36167961e-02f, -1.82250217e-02f,
  3.96173745e-02f, -6.13062009e-02f, 6.50677010e-02f, 7.25672469e-02f, -8.25445130e-02f, -3.85638289e-02f, -4.74779271e-02f, -4.58578356e-02f, 1.30505161e-02f, -4.21589389e-02f,
  -1.40747176e-02f, -4.19721231e-02f, 6.03281222e-02f, -1.21531514e-02f, 3.58563624e-02f, -3.23159248e-02f, 7.15457723e-02f, -5.66731058e-02f, -7.54932016e-02f, 2.92678345e-02f,
  -6.92905188e-02f, -7.63699263e-02f, 6.77735731e-02f, -5.99934161e-02f, 2.00832710e-02f, 4.80817817e-02f, -2.92400885e-02f, -6.34935498e-02f, -1.15030808e-02f, -3.15071903e-02f,
  -2.18600929e-02f, -1.26442676e-02f, 2.52220687e-02f, 4.70464602e-02f, 3.64598893e-02f, 6.69857785e-02f, 8.34735706e-02f, 1.02314993e-03f, -5.69732860e-02f, 8.18833336e-02f,
  1.40204504e-01f, -1.12036966e-01f, 5.00194691e-02f, 6.28877357e-02f, 5.31692803e-02f, -3.89960967e-02f, -2.06950288e-02f, 2.73707900e-02f, 2.83964556e-02f, 7.86536187e-02f,
  -3.48099880e-02f, 6.83026239e-02f, -1.90161373e-02f, -4.24879789e-02f, -2.95618791e-02f, -2.11932417e-02f, 1.67109445e-02f, 6.38457760e-02f, -4.45554703e-02f, -2.89896084e-03f,
  9.94594023e-02f, 5.21503529e-03f, 7.40173161e-02f, 1.16588520e-02f, -1.54804867e-02f, -7.04253390e-02f, -4.97762226e-02f, 8.75350982e-02f, 1.66302442e-03f, 9.59850624e-02f,
  -1.94997899e-02f, 3.68273854e-02f, 5.09703644e-02f, -5.54160289e-02f, -5.33371083e-02f, -1.48687258e-01f, -3.25264223e-02f, 9.83505324e-03f, 9.08686817e-02f, -5.24436571e-02f,
  -6.13469742e-02f, -5.29591776e-02f, -1.44362718e-01f, -1.01180419e-01f, -2.04768479e-01f, -3.86933051e-02f, -1.00222372e-01f, -2.42108881e-01f, -3.88297796e-01f, -3.31318408e-01f,
  -2.07406372e-01f, -2.15895891e-01f, -1.12211399e-01f, -1.40489236e-01f, 1.26038371e-02f, 7.51070529e-02f, -2.14254134e-03f, 1.34090511e-02f, -9.49132740e-02f, 1.20726908e-02f,
  1.39108375e-02f, 1.66961700e-01f, -6.28160499e-03f, -5.62144769e-03f, 2.00663619e-02f, -7.85817206e-02f, -5.66568375e-02f, 5.33927158e-02f, 7.18821064e-02f, 3.60921957e-02f,
  2.12995913e-02f, -7.21847191e-02f, -1.09275348e-01f, -7.32768700e-02f, -1.27939433e-01f, -1.44988187e-02f, -7.02492148e-02f, -2.97578070e-02f, 4.91221659e-02f, -1.92800798e-02f,
  -1.72022115e-02f, -9.95448455e-02f, -7.20591173e-02f, 3.57823335e-02f, 7.22451285e-02f, -6.96644336e-02f, 1.37955770e-01f, 2.16369834e-02f, 9.31041390e-02f, 1.64063230e-01f,
  -4.80685569e-03f, -4.26333807e-02f, 8.94612297e-02f, -9.59061086e-03f, -2.35707052e-02f, 1.03747807e-01f, 2.17810739e-03f, -1.31863788e-01f, -2.58223042e-02f, -2.37988979e-02f,
  3.82486954e-02f, 1.75378285e-02f, 7.16855377e-02f, 3.17073124e-03f, -2.95224022e-02f, 2.73649469e-02f, -6.77040815e-02f, -9.06417668e-02f, -3.64790745e-02f, -7.19179437e-02f,
  -1.98308495e-03f, -1.24471856e-03f, 3.76584269e-02f, -1.53447250e-02f, 1.05435431e-01f, 1.00089952e-01f, -5.38751446e-02f, -8.08172300e-02f, 1.23653607e-02f, 5.40557504e-02f,
  1.60398126e-01f, -1.50414452e-01f, -1.56370234e-02f, -9.95601416e-02f, -4.00368795e-02f, 4.26603667e-02f, -6.60988828e-03f, -7.84671232e-02f, 1.34132374e-02f, -7.12785274e-02f,
  -1.54801846e-01f, -1.99679118e-02f, 5.85449636e-02f, -9.38856453e-02f, -1.33737758e-01f, -6.99242279e-02f, 2.83566993e-02f, -7.60834515e-02f, -1.14505306e-01f, -5.57526350e-02f,
  1.09595591e-02f, -1.49495140e-01f, -1.34902522e-01f, 6.57057166e-02f, 9.15173367e-02f, -1.42025143e-01f, -6.07751347e-02f, -2.99209245e-02f, 7.79257063e-03f, 1.03609346e-01f,
  2.77761519e-01f, 1.00835100e-01f, 7.44706318e-02f, 6.57172129e-02f, 1.68737888e-01f, 8.46746713e-02f, 1.20513387e-01f, -4.06136476e-02f, -3.43802152e-03f, 9.98463631e-02f,
  -4.55630161e-02f, -2.26834491e-02f, -5.85679002e-02f, -1.58561364e-01f, -1.82124361e-01f, 4.15069051e-02f, -6.43136948e-02f, -9.06135887e-02f, -7.40811303e-02f, 7.63569027e-02f,
  -2.66609322e-02f, 1.21579729e-01f, 1.40355885e-01f, 9.38617289e-02f, -4.31801230e-02f, -8.49069133e-02f, 9.46157128e-02f, 7.21025243e-02f, -5.15695065e-02f, 5.64370081e-02f,
  -5.51185906e-02f, 1.35496128e-02f, -5.59836030e-02f, -9.44046378e-02f, -1.49398940e-02f, 5.13833351e-02f, 8.53770524e-02f, 1.10855438e-01f, -4.18463051e-02f, -2.18183901e-02f,
  6.45905957e-02f, 5.11821993e-02f, -1.06277071e-01f, -1.40655581e-02f, 3.16011421e-02f, 2.71749776e-02f, -6.29009604e-02f, -2.24961601e-02f, -8.97996053e-02f, -1.17497742e-01f,
  2.86315847e-02f, -1.36580970e-02f, 8.26907679e-02f, -1.03715383e-01f, -4.69578281e-02f, -6.44642264e-02f, 4.83282935e-03f, 1.39735406e-02f, -1.26414197e-02f, -4.03672084e-02f,
  -1.04584597e-01f, -9.76837724e-02f, -5.11065349e-02f, -4.88356538e-02f, 8.54126550e-03f, -2.30400488e-02f, -6.42801225e-02f, 4.02131565e-02f, 5.84466234e-02f, 8.36919174e-02f,
  2.23902520e-02f, 5.66630848e-02f, -5.78067750e-02f, 8.67395755e-03f, 4.07546163e-02f, 4.33619739e-03f, -1.01251662e-01f, -4.15665247e-02f, 2.85444465e-02f, -2.91887391e-02f,
  5.39864488e-02f, -9.94136557e-02f, 1.04846977e-01f, -6.58756122e-02f, 1.27606830e-02f, -6.42058477e-02f, -7.74728432e-02f, -1.13663867e-01f, 7.38611817e-02f, -2.63423156e-02f,
  -4.75432687e-02f, -1.53578699e-01f, -2.42452268e-02f, 1.29448231e-02f, 7.27977082e-02f, -5.91345429e-02f, 1.35709969e-02f, -2.11632270e-02f, 8.07360783e-02f, -4.91720177e-02f,
  -9.14383307e-02f, 3.73963937e-02f, -6.77674264e-02f, -5.56323817e-03f, -1.81704592e-02f, 1.12472951e-01f, 9.14811641e-02f, -2.72848587e-02f, -6.45472333e-02f, 2.76514683e-02f,
  -4.77886805e-03f, 1.44900814e-01f, 1.52863711e-01f, 6.04303628e-02f, -8.82330835e-02f, 7.21541867e-02f, -9.58679244e-03f, -2.36588400e-02f, 6.49516955e-02f, 1.96029752e-01f,
  1.72274768e-01f, -4.79419380e-02f, 3.51940431e-02f, 2.11229678e-02f, -1.23128198e-01f, -5.35585955e-02f, 2.97025964e-03f, -2.48424523e-02f, -3.57176065e-02f, 3.62846777e-02f,
  4.24102992e-02f, 1.64030157e-02f, 4.26756628e-02f, 4.43118736e-02f, 8.71120095e-02f, 2.90878881e-02f, -1.09334014e-01f, -3.82627957e-02f, 8.10157359e-02f, -2.64709704e-02f,
  -5.97851314e-02f, 6.42125234e-02f, 1.13101549e-01f, 9.51997042e-02f, -8.86242837e-02f, -4.58591543e-02f, -4.23550904e-02f, 4.59796637e-02f, 2.39665533e-04f, 1.11605329e-02f,
  -7.91155696e-02f, 1.57736823e-01f, -7.97157511e-02f, 1.21435791e-01f, -5.20288106e-03f, 6.52727485e-02f, 2.81395633e-02f, -4.22657374e-03f, 8.15063864e-02f, -1.01727098e-01f,
  1.34350057e-03f, 1.09956980e-01f, 1.27976201e-03f, 5.91823235e-02f, -5.81170060e-02f, 3.54505517e-02f, -5.08487038e-02f, 6.67982548e-02f, 5.44457547e-02f, 5.41299246e-02f,
  5.79089217e-04f, -6.94808364e-02f, -5.67118116e-02f, -2.79090423e-02f, -5.91428839e-02f, 3.78606766e-02f, -9.33266953e-02f, 2.12906078e-02f, -8.40360075e-02f, -6.27278537e-02f,
  3.11540477e-02f, -8.72117933e-03f, -1.84693187e-02f, 3.63870375e-02f, 2.38080062e-02f, -2.57652011e-02f, 1.55685074e-03f, 1.91614300e-03f, 6.55953512e-02f, -3.26283422e-04f,
  6.30403906e-02f, -6.62904680e-02f, -7.15302005e-02f, 3.08268704e-02f, 5.04633458e-03f, -3.13219167e-02f, 4.72725816e-02f, -6.71689212e-02f, 2.07339562e-02f, 3.95999402e-02f,
  2.61047967e-02f, 2.50059122e-04f, -2.94948416e-03f, 1.08202361e-02f, -7.70067573e-02f, 4.41790521e-02f, -7.14808926e-02f, -4.03180793e-02f, -5.75799942e-02f, -4.84566800e-02f,
  4.95585315e-02f, 9.82413739e-02f, 3.97742540e-02f, 6.30541742e-02f, 3.02071292e-02f, 2.09974404e-02f, 1.00407906e-01f, 1.49792051e-02f, -4.51424122e-02f, -7.81444535e-02f,
  -7.68159330e-02f, 9.38519370e-03f, 2.50686202e-02f, 5.69826700e-02f, -8.90821964e-02f, -2.27399059e-02f, 5.36602363e-02f, 3.27837989e-02f, -2.86804158e-02f, -4.76921238e-02f,
  -8.21019411e-02f, 4.48380820e-02f, 3.96566540e-02f, 3.93235311e-02f, 6.26452118e-02f, 3.61442752e-02f, 2.55702212e-02f, 2.68540215e-02f, -8.50781053e-02f, -3.97749804e-02f,
  9.11695212e-02f, -1.16560206e-01f, -7.40439743e-02f, 2.82415673e-02f, -5.85927023e-03f, -4.80076894e-02f, 4.43795025e-02f, 1.08280376e-01f, -8.29193518e-02f, -7.49219358e-02f,
  -3.74461152e-02f, -4.65212800e-02f, -4.31231298e-02f, -6.88534752e-02f, -8.30870047e-02f, -4.54004444e-02f, -1.59513727e-01f, -1.28680080e-01f, -6.74955621e-02f, 1.32580101e-01f,
  1.55163510e-02f, -6.53269216e-02f, -5.43010458e-02f, -2.84162182e-02f, -1.05721159e-02f, -1.51435127e-02f, -7.68576488e-02f, 5.07180095e-02f, -6.27499372e-02f, -1.81443870e-01f,
  1.02122407e-02f, 1.46271542e-01f, -5.68418652e-02f, 1.50937447e-02f, 5.82917519e-02f, 6.55417051e-03f, 9.36679170e-02f, 4.45281640e-02f, 8.43312889e-02f, -7.38893300e-02f,
  8.82179663e-03f, 4.14330000e-03f, 6.35605156e-02f, 1.51472026e-02f, 1.29117817e-01f, 6.67535588e-02f, 1.12106293e-01f, 3.66076939e-02f, -5.41678779e-02f, 8.67595449e-02f,
  6.13420978e-02f, 7.65856653e-02f, 1.34398649e-02f, 7.57922232e-02f, -1.79703217e-02f, -1.20390439e-02f, 1.21097282e-01f, -2.32326724e-02f, 1.84306260e-02f, -6.69848472e-02f,
  -2.43694037e-02f, -4.08416614e-02f, 2.50571277e-02f, 7.96645954e-02f, 3.57062719e-03f, -8.20118412e-02f, -4.49491180e-02f, -5.62964864e-02f, 8.98792222e-03f, 2.54941881e-02f,
  -7.49571696e-02f, 8.86052102e-02f, -4.00000857e-03f, 3.32001671e-02f, 2.12268578e-03f, -1.36615876e-02f, 1.30521003e-02f, 1.38107464e-02f, -3.36903445e-02f, -1.51982391e-02f,
  -4.01081927e-02f, -1.13012809e-02f, -7.68599985e-03f, 6.86394200e-02f, 2.59906631e-02f, 3.73261459e-02f, 7.70152733e-02f, 2.66405679e-02f, 9.77560282e-02f, -5.34171462e-02f,
  -1.26645528e-02f, 1.51076494e-02f, -1.06891036e-01f, 2.71522570e-02f, -2.22979188e-02f, -2.33163424e-02f, -5.75477891e-02f, 9.08180028e-02f, -1.30067458e-02f, 9.79076549e-02f,
  -6.88186148e-03f, 8.93565714e-02f, 3.48808505e-02f, 6.58860058e-02f, 8.17557126e-02f, -1.37016056e-02f, -6.41485080e-02f, 1.47392862e-02f, 5.67979775e-02f, -1.66278612e-02f,
  6.48539141e-02f, -8.48958269e-03f, -1.04191482e-01f, -7.10679442e-02f, 3.83852422e-02f, -1.05438821e-01f, -7.38032609e-02f, -7.90616274e-02f, 4.95539755e-02f, -1.08578883e-01f,
  8.36134776e-02f, -8.96745473e-02f, -4.52034138e-02f, 5.61639518e-02f, 1.72847621e-02f, -2.09374893e-02f, 2.91338544e-02f, 3.06142196e-02f, 2.36086757e-03f, 9.66336280e-02f,
  1.50844812e-01f, 1.05870485e-01f, 6.45728260e-02f, 1.43702298e-01f, 3.92280594e-02f, 8.51835385e-02f, -4.72593307e-02f, -3.86334658e-02f, 3.38204354e-02f, 4.42290977e-02f,
  4.69567766e-03f, -5.31669706e-02f, 2.69049983e-02f, -2.07932349e-02f, 2.27422155e-02f, -6.97023049e-02f, 2.40983739e-02f, -7.59420618e-02f, -1.75923817e-02f, -1.15770049e-01f,
  3.20249982e-02f, 8.72079283e-03f, 7.39467591e-02f, 9.12971273e-02f, 3.82212363e-02f, 1.31150754e-02f, -2.53782589e-02f, -5.93181662e-02f, -7.80918077e-02f, -1.05430447e-01f,
  2.69198157e-02f, -8.16859379e-02f, -7.06349732e-03f, -8.95453617e-03f, -2.91138217e-02f, 2.58930158e-02f, 5.45462146e-02f, 1.52259739e-03f, 7.59418681e-02f, 7.60112628e-02f,
  -5.21044899e-03f, -1.79160181e-02f, 2.69577950e-02f, 6.05382286e-02f, -5.54353744e-02f, 7.56068751e-02f, -4.44636755e-02f, -6.89459294e-02f, 7.50088245e-02f, 1.67400632e-02f,
  -3.07036452e-02f, 2.80170073e-03f, -5.15748793e-03f, 1.19185567e-01f, -3.04748826e-02f, -5.07635623e-02f, -8.96009728e-02f, 2.77873166e-02f, -5.85309416e-03f, 8.01473670e-03f,
  -6.35041222e-02f, 5.27386181e-02f, 8.39264020e-02f, 6.33670315e-02f, 6.81069344e-02f, -6.78336546e-02f, 6.34860322e-02f, 6.37960760e-03f, 4.05955799e-02f, 8.81518200e-02f,
  1.00918472e-01f, -3.60299461e-02f, -2.74006836e-02f, -5.97438365e-02f, -8.72566700e-02f, -5.39526250e-03f, -3.41913514e-02f, -7.19559267e-02f, 1.04101613e-01f, -9.16051269e-02f,
  3.36765908e-02f, 1.11157645e-03f, 4.37809862e-02f, -3.02589461e-02f, 4.72493507e-02f, -1.13384098e-01f, -7.43925795e-02f, 5.51523305e-02f, 2.50915717e-02f, 2.69816164e-02f,
  -2.64679063e-02f, 4.17999886e-02f, 2.66035032e-02f, 8.50363541e-03f, -1.63975190e-02f, 2.35067010e-02f, -3.03566512e-02f, -2.55153961e-02f, 8.03427920e-02f, -1.25007972e-01f,
  1.11275986e-02f, 4.44716625e-02f, 1.37839422e-01f, 6.63224161e-02f, -3.99443842e-02f, 1.15973286e-01f, 2.46074144e-02f, -6.42220899e-02f, 6.00597672e-02f, 1.02129981e-01f,
  -1.09187393e-02f, -5.48509546e-02f, 7.23610222e-02f, -2.51236726e-02f, -8.90705958e-02f, -9.96397957e-02f, -1.46634787e-01f, -9.36657488e-02f, 5.66847734e-02f, -8.22307840e-02f,
  -3.09217088e-02f, -1.12282261e-01f, 6.16914406e-02f, -5.55717386e-02f, -5.86116388e-02f, 6.71665519e-02f, 1.11404054e-01f, 1.48910165e-01f, -3.88633669e-03f, 9.89697874e-03f,
  -1.30086197e-02f, -6.69686217e-03f, 5.92787042e-02f, 9.38842669e-02f, -5.81941158e-02f, 1.40012447e-02f, -3.59659456e-02f, 4.02372032e-02f, 8.09013322e-02f, 1.02784663e-01f,
  5.68506233e-02f, -3.24904509e-02f, -3.02978363e-02f, -1.17982872e-01f, -9.91254020e-03f, -2.96460977e-03f, -8.21513608e-02f, 2.98047736e-02f, -1.10839913e-02f, 7.00701773e-02f,
  3.15526426e-02f, -2.53422149e-02f, -7.21976757e-02f, -2.22289432e-02f, -8.21607783e-02f, -5.23055494e-02f, 7.29713291e-02f, 4.56658565e-03f, 9.82343331e-02f, 5.69075346e-02f,
  -1.01395212e-01f, -8.88828710e-02f, -1.45136286e-02f, 3.00758090e-02f, 6.55547455e-02f, 2.69899461e-02f, -4.56147045e-02f, -2.29367185e-02f, 7.19693378e-02f, 2.94391941e-02f,
  1.03178155e-02f, 1.26673076e-02f, 6.39209822e-02f, 9.88810807e-02f, 3.75592634e-02f, 8.77426043e-02f, -5.18004894e-02f, 1.26138227e-02f, -5.69920875e-02f, 1.07938878e-01f,
  -6.85527325e-02f, 1.24583011e-02f, -6.47464916e-02f, 5.75943887e-02f, -4.91432436e-02f, 6.84892712e-03f, 8.02314803e-02f, -6.62823245e-02f, 2.02945601e-02f, -5.19826263e-03f,
  2.40450874e-02f, -2.95417961e-02f, 3.31869051e-02f, 2.08977330e-02f, -8.45901966e-02f, 6.46945089e-02f, -2.23419182e-02f, 1.56427305e-02f, -3.82293426e-02f, 5.33600077e-02f,
  3.58970761e-02f, -1.79380400e-03f, -4.70564291e-02f, 2.28797533e-02f, -3.33104394e-02f, -3.38537954e-02f, 1.41031519e-02f, 2.99607888e-02f, -2.93631032e-02f, 1.14607150e-02f,
  3.28080244e-02f, -1.03332147e-01f, -2.57013533e-02f, 3.70809920e-02f, -7.88935795e-02f, -4.08835933e-02f, -2.46898364e-03f, 6.29028305e-02f, 5.89521341e-02f, -3.85969281e-02f,
  -1.01369932e-01f, -1.28210383e-02f, 8.52101520e-02f, -5.04663624e-02f, -4.48094234e-02f, 5.48741668e-02f, 8.58176965e-03f, -8.79866108e-02f, 7.36775175e-02f, -5.37980311e-02f,
  2.38368168e-01f, 7.90216178e-02f, 1.09683879e-01f, 1.70343578e-01f, 2.46567830e-01f, 2.46329740e-01f, 8.41940045e-02f, 1.70144111e-01f, 9.63365212e-02f, 1.17192730e-01f,
  1.51580468e-01f, 6.13845736e-02f, 7.36890174e-03f, -6.96118996e-02f, -5.68404458e-02f, -3.77569185e-03f, 3.75382304e-02f, -2.26480067e-02f, 6.61751181e-02f, 5.97027205e-02f,
  4.92072618e-03f, 4.87640686e-03f, 6.61800131e-02f, 7.82851875e-02f, 6.75229356e-02f, -4.68837097e-02f, 2.16258597e-02f, -1.52963083e-02f, 1.01032481e-02f, 2.86614373e-02f,
  3.48260291e-02f, 1.13051318e-01f, -7.73702636e-02f, 6.50101304e-02f, 1.03639081e-01f, -1.41882658e-01f, -1.97664872e-02f, -1.00893736e-01f, 1.40348347e-02f, 1.18616857e-02f,
  -8.51360932e-02f, 3.06106824e-02f, 2.51809731e-02f, -3.15265320e-02f, -1.91609021e-02f, -7.18836114e-02f, 2.37528216e-02f, -7.29642734e-02f, -7.91390166e-02f, 3.19228321e-02f,
  -1.80136207e-02f, 1.22213401e-01f, 4.34913859e-02f, 1.93645582e-02f, 8.45489372e-03f, -5.87707758e-02f, -5.57635203e-02f, -4.01822245e-03f, -2.03069393e-02f, 2.44525373e-02f,
  -5.98267131e-02f, 1.11596342e-02f, -4.45015989e-02f, 3.71128432e-02f, 2.96188854e-02f, -3.36528607e-02f, 1.40225245e-02f, 1.39827402e-02f, -3.97587046e-02f, -1.88913587e-02f,
  -5.11858352e-02f, 1.11266494e-01f, -6.36566430e-03f, 1.99694671e-02f, 9.80153754e-02f, 5.39255962e-02f, -3.17747667e-02f, 8.62695873e-02f, -1.18127167e-02f, -6.42860010e-02f,
  4.45930138e-02f, 8.37432873e-03f, 9.00536925e-02f, 2.49217870e-03f, -2.42163967e-02f, -3.25055681e-02f, 7.34544322e-02f, 1.16856163e-02f, 1.16662197e-01f, 1.77334473e-02f,
  -1.21045262e-01f, 1.32572530e-02f, 8.28797650e-03f, -1.23444073e-01f, -1.38516333e-02f, -1.07489020e-01f, 9.63680744e-02f, -7.95969889e-02f, -1.68308131e-02f, -3.56664583e-02f,
  -1.61563419e-02f, 1.85365453e-02f, 6.46196678e-02f, -1.04883939e-01f, 1.05526261e-02f, -1.86715908e-02f, 7.90648386e-02f, -6.60676211e-02f, -7.93041885e-02f, -4.45719361e-02f,
  -4.27690940e-03f, 3.77900824e-02f, 3.45286578e-02f, 2.58851703e-02f, -7.10644946e-02f, 6.89586252e-02f, -6.46058619e-02f, 7.77715119e-03f, 1.53871328e-02f, -4.67325561e-02f,
  1.60373122e-01f, -4.76008281e-03f, -2.06936058e-03f, 5.87128066e-02f, -9.30990204e-02f, -1.80263907e-01f, -1.64816946e-01f, 8.39099810e-02f, 9.50679109e-02f, 1.46466671e-02f,
  6.94010258e-02f, -3.26934606e-02f, 5.05679250e-02f, 7.42986128e-02f, -5.88995032e-02f, -9.41238254e-02f, 1.75877158e-02f, -6.34840205e-02f, -3.75417806e-02f, -7.94072077e-03f,
  8.43754336e-02f, 2.79156044e-02f, 4.77024131e-02f, 1.19443491e-01f, 7.62642771e-02f, -8.77199881e-03f, 8.81584287e-02f, -4.99770753e-02f, -8.90788510e-02f, 6.92998841e-02f,
  -1.31353885e-01f, 8.30155313e-02f, -5.38480543e-02f, -4.51456308e-02f, -2.93403324e-02f, 1.29269063e-01f, -7.14055821e-02f, 1.21650197e-01f, -3.15829553e-02f, 1.21440507e-01f,
  1.36415167e-02f, 6.59043416e-02f, 2.00756341e-02f, 5.67274354e-02f, 7.19445571e-02f, 4.58662249e-02f, 9.31513458e-02f, 1.71061978e-02f, -6.39635473e-02f, 8.06730911e-02f,
  6.30466342e-02f, 4.21414822e-02f, -1.75172847e-03f, -1.06901661e-01f, -9.24337804e-02f, -2.08986942e-02f, 3.20975669e-02f, 5.06941788e-02f, 4.76354882e-02f, 5.15478700e-02f,
  -7.17425868e-02f, 3.37546989e-02f, -9.31584761e-02f, 1.03691462e-02f, -5.91758266e-02f, -8.46614614e-02f, -8.56579468e-03f, -6.34756908e-02f, 6.51568994e-02f, -6.03603348e-02f,
  -2.77574528e-02f, -8.26603025e-02f, 2.07098797e-02f, 9.50752869e-02f, -1.72957703e-02f, -6.46042302e-02f, 5.04698195e-02f, 5.86804561e-03f, -1.54127302e-02f, 5.88055179e-02f,
  -7.48998299e-02f, -2.63631139e-02f, 1.22763161e-02f, -9.49213356e-02f, -5.09386808e-02f, 6.22704029e-02f, 6.19698986e-02f, -7.69678280e-02f, 6.55231923e-02f, -1.97275113e-02f,
  2.06421446e-02f, -1.62597060e-01f, 1.17609642e-01f, -3.85665311e-03f, 5.42238839e-02f, 2.80581415e-02f, 2.54424047e-02f, -6.87233210e-02f, 3.99729535e-02f, 9.67622697e-02f,
  -2.69243820e-03f, -5.80372754e-03f, 7.42902681e-02f, -5.94040044e-02f, -6.37242338e-03f, -1.32468101e-02f, -1.37007469e-03f, 2.29422823e-02f, 8.50240700e-03f, 6.20308779e-02f,
  -1.55851906e-02f, 6.86593503e-02f, 4.55606217e-03f, -6.58036098e-02f, -1.21495733e-02f, -3.55609059e-02f, -1.15465529e-01f, 6.95984960e-02f, -9.53942612e-02f, -1.09274993e-02f,
  4.21600342e-02f, -1.21817738e-01f, 3.04628648e-02f, -1.53867938e-02f, -1.78540885e-01f, -1.04193598e-01f, -1.50116429e-01f, -9.46389735e-02f, 4.46249023e-02f, 1.93667430e-02f,
  -6.13465197e-02f, 9.11332890e-02f, -8.91226251e-03f, 1.75703749e-01f, 1.51486605e-01f, -2.07308531e-02f, 1.46873789e-02f, 1.67951182e-01f, 1.21508889e-01f, 8.73182341e-02f,
  3.09499772e-03f, 5.15119126e-03f, 8.87322426e-02f, -3.46817542e-03f, 8.44038948e-02f, 7.31143057e-02f, -2.88855825e-02f, -2.35445960e-03f, -5.25641218e-02f, 5.24390414e-02f,
  6.79635331e-02f, 3.74827674e-03f, 7.46907964e-02f, 9.74617302e-02f, 2.90575307e-02f, -1.62584018e-02f, -4.76862006e-02f, 6.35941401e-02f, 5.15561998e-02f, 3.43014076e-02f,
  -3.57921533e-02f, 9.56544131e-02f, 2.57435907e-02f, 2.89487913e-02f, -5.45683615e-02f, -2.43732724e-02f, -2.27422025e-02f, 7.72572607e-02f, 1.13745861e-01f, -6.04544096e-02f,
  -1.28820809e-02f, -9.30406377e-02f, 5.49489283e-04f, 8.33909065e-02f, 8.00385848e-02f, -4.29173699e-03f, 4.99558896e-02f, 6.95898533e-02f, -1.49879688e-02f, -6.56080339e-03f,
  9.32330638e-02f, -5.66593297e-02f, 8.50360096e-02f, -6.08438216e-02f, -7.33556226e-02f, 4.81636263e-02f, -6.56822845e-02f, -8.83041173e-02f, 9.32865776e-03f, -3.94602828e-02f,
  -2.72576921e-02f, -3.35533172e-02f, -4.43965383e-02f, -5.43777645e-03f, 1.05510250e-01f, 5.87154888e-02f, -7.25200176e-02f, -5.47532104e-02f, -6.30209818e-02f, 3.67903933e-02f,
  4.40185480e-02f, -6.66990578e-02f, -6.84612542e-02f, 6.30998164e-02f, 1.07908039e-03f, -2.86802836e-02f, -2.14532278e-02f, -6.26228601e-02f, -6.29893318e-02f, -3.24472301e-02f,
  -1.15258113e-01f, 1.14135794e-01f, 2.41264123e-02f, 5.13179377e-02f, -9.08092409e-02f, 6.12991191e-02f, 3.28715257e-02f, 5.99873513e-02f, -5.13649769e-02f, -7.84951076e-02f,
  2.35733781e-02f, 8.83169994e-02f, 5.32215834e-02f, -8.44165012e-02f, -3.89471352e-02f, -9.04409289e-02f, 1.31501053e-02f, 6.24572448e-02f, 3.19276154e-02f, -2.40411777e-02f,
  -2.51823068e-02f, -7.68631473e-02f, 1.14758564e-02f, -1.41935460e-02f, 1.47805708e-02f, 1.34404488e-02f, 1.41000506e-02f, -7.49079213e-02f, 5.60285971e-02f, -9.59338546e-02f,
  -3.21322907e-04f, 7.14436248e-02f, -9.09432545e-02f, 5.96211217e-02f, 3.39013338e-02f, -6.69351369e-02f, -4.26678248e-02f, -5.90127707e-02f, 5.88411652e-02f, -4.96011227e-02f,
  1.17803767e-01f, 4.58105057e-02f, -2.18257364e-02f, 5.16387969e-02f, 5.47417291e-02f, 2.27459054e-02f, 2.26448663e-03f, 4.84106541e-02f, 1.58375744e-02f, 2.45637354e-02f,
  1.19411889e-02f, -2.31504999e-02f, -1.61887985e-02f, -1.78183932e-02f, 7.20341131e-02f, -9.76223499e-03f, -8.73694941e-02f, 9.13605392e-02f, 9.55597609e-02f, 1.11093953e-01f,
  5.12846634e-02f, 6.45029992e-02f, 6.96529821e-02f, -3.98453698e-02f, -4.66410071e-02f, 2.33416315e-02f, 5.34260534e-02f, 3.40854982e-03f, 1.36209372e-02f, 3.88692133e-02f,
  1.54580884e-02f, 6.79677874e-02f, 6.62582144e-02f, 6.35968596e-02f, -1.08072639e-01f, 5.73541522e-02f, 6.84322119e-02f, 3.04388329e-02f, -1.15257101e-02f, -9.73057840e-03f,
  6.66080639e-02f, -8.52739364e-02f, -9.20868218e-02f, -1.65533798e-03f, 5.19806743e-02f, 8.81961063e-02f, -9.08167586e-02f, 3.49118523e-02f, -1.15570918e-01f, 2.70308554e-02f,
  -5.51190637e-02f, -5.28148264e-02f, -2.40010470e-02f, -2.92533841e-02f, -3.36757414e-02f, -5.69963306e-02f, 6.61890134e-02f, 6.24653921e-02f, -8.49468634e-02f, -2.71695084e-03f,
  5.02066575e-02f, 4.46458459e-02f, -7.95292109e-02f, -8.47047716e-02f, 1.09621203e-02f, -7.81954154e-02f, -3.00116818e-02f, -2.52582673e-02f, -2.19435059e-02f, -3.83187830e-02f,
  9.23996493e-02f, 2.01465236e-03f, -7.34272227e-02f, -1.75538510e-02f, 2.81308517e-02f, -1.82187669e-02f, -1.21489400e-02f, -1.60435308e-02f, -2.09945776e-02f, 6.43548146e-02f,
  7.86132994e-04f, -1.02731973e-01f, 5.65120019e-02f, 1.04661420e-01f, -1.07441088e-02f, -6.96855783e-03f, -3.52408215e-02f, -8.46719369e-02f, 5.68523295e-02f, 4.94627953e-02f,
  1.51017560e-02f, -2.05606278e-02f, 2.23831013e-02f, 6.54002577e-02f, -4.36225124e-02f, 5.02576493e-02f, -1.56706944e-02f, -6.99626282e-02f, 2.21899096e-02f, -3.98188382e-02f,
  -4.84630466e-02f, -1.13255613e-01f, 2.97185816e-02f, -6.57652318e-02f, -5.13081141e-02f, -7.29461685e-02f, -7.37610310e-02f, -6.58075660e-02f, 3.58576439e-02f, -5.86773828e-02f,
  -1.49943575e-01f, 5.39896525e-02f, 3.94098908e-02f, -1.30093455e-01f, -1.48338010e-03f, 5.05434535e-02f, 4.38759774e-02f, -7.94402286e-02f, -8.75861049e-02f, -5.06940950e-03f,
  -8.38152096e-02f, -4.32554930e-02f, -2.70192288e-02f, -5.68842068e-02f, 1.15526766e-02f, -6.22793920e-02f, 6.39785528e-02f, 5.70765063e-02f, 5.86241595e-02f, 4.86780182e-02f,
  1.02208510e-01f, 2.65123639e-02f, -1.21690214e-01f, 3.39915790e-02f, -6.81934431e-02f, -2.35089045e-02f, -4.10855860e-02f, 2.30911318e-02f, 7.37952963e-02f, -8.80590975e-02f,
  -2.82501373e-02f, -1.39245778e-01f, -3.42020541e-02f, 1.53422439e-02f, 4.47512046e-02f, -8.79386999e-03f, 3.79000008e-02f, -5.56485653e-02f, -3.55967553e-03f, 7.13289753e-02f,
  7.78415725e-02f, -6.69465289e-02f, -4.59539033e-02f, -6.63040876e-02f, 8.88677686e-02f, 5.13224117e-02f, 5.04378565e-02f, 1.70598440e-02f, -5.91065809e-02f, -2.81897411e-02f,
  3.06687113e-02f, 2.45246366e-02f, 1.86654162e-02f, 5.56475595e-02f, 5.42848222e-02f, 7.31750280e-02f, -2.94152405e-02f, -1.43220732e-02f, 5.45915551e-02f, -2.10360382e-02f,
  9.41802189e-02f, -9.33505036e-03f, 7.17090666e-02f, -9.47600324e-03f, -4.45558727e-02f, -2.45103799e-02f, 3.48295420e-02f, -5.30111156e-02f, -5.87526001e-02f, -1.11007839e-01f,
  1.47213414e-02f, 2.81935595e-02f, 5.63544556e-02f, -8.96369442e-02f, 4.32841182e-02f, 5.61772510e-02f, -8.39711279e-02f, -8.99968371e-02f, -3.11072487e-02f, -4.91067115e-03f,
  -4.46988046e-02f, 3.76721285e-03f, -3.37279066e-02f, -3.52176279e-03f, -9.12006870e-02f, -8.28842223e-02f, -3.66976410e-02f, -1.64823700e-02f, -1.98016185e-02f, 3.23319398e-02f,
  6.12358525e-02f, -7.51862675e-02f, 6.02763072e-02f, -4.55240011e-02f, 2.47913674e-02f, -7.25926459e-02f, -9.15562734e-02f, -4.80496027e-02f, -8.59111547e-02f, 3.78571413e-02f,
  -6.30688965e-02f, 7.39363804e-02f, -6.12048581e-02f, 3.60627323e-02f, 2.95967758e-02f, 8.96734670e-02f, 4.52478416e-02f, -7.47803897e-02f, 4.68045846e-03f, 1.01925313e-01f,
  -1.81474164e-02f, 1.01595251e-02f, 2.39890214e-05f, 7.57030817e-03f, -8.44462365e-02f, -4.39330302e-02f, 5.60957603e-02f, 7.71638453e-02f, 4.90010902e-02f, -1.03986925e-02f,
  1.19010881e-01f, -8.16875175e-02f, 1.43555785e-02f, 8.37482810e-02f, -1.39490306e-01f, -2.38063082e-01f, -1.85100108e-01f, -1.06000006e-02f, -3.66252586e-02f, 2.18551024e-03f,
  -3.36019322e-02f, -7.34219775e-02f, -7.65002295e-02f, -4.95770201e-02f, 4.92665172e-02f, 2.77889781e-02f, -3.12503520e-03f, 7.86040630e-03f, -7.56463036e-02f, -1.78190202e-01f,
  -1.07639469e-01f, 9.52881798e-02f, 5.36339805e-02f, -1.40494993e-02f, 2.94417012e-02f, 1.02650812e-02f, -6.45710230e-02f, -8.00363123e-02f, -1.42126888e-01f, -1.60810605e-01f,
  -1.61182433e-01f, -4.19953987e-02f, -6.40633181e-02f, 1.90439075e-02f, -6.49899840e-02f, -3.46130244e-02f, -1.18939370e-01f, 4.82383259e-02f, 2.85266265e-02f, 5.71113601e-02f,
  -8.12841430e-02f, -7.91617185e-02f, 2.51484402e-02f, 4.15573567e-02f, 5.84743656e-02f, -7.60708526e-02f, 1.03362538e-01f, 9.55559611e-02f, 5.18132299e-02f, -2.84864102e-02f,
  -1.02348380e-01f, -9.84493941e-02f, 1.43830637e-02f, -2.70274989e-02f, 4.53351028e-02f, 3.33372280e-02f, -9.52094272e-02f, -1.01104401e-01f, -1.02748334e-01f, -6.91906363e-03f,
  -1.46025734e-03f, -3.45803350e-02f, -2.72749700e-02f, -4.66646627e-02f, 4.43479568e-02f, 1.02772713e-02f, 3.93811278e-02f, 2.12636441e-02f, 1.39178801e-02f, 4.52064648e-02f,
  9.06450823e-02f, -5.08074649e-02f, 3.10938749e-02f, 7.28215277e-02f, -3.86459730e-03f, -7.69571774e-03f, -4.78760935e-02f, -2.58509517e-02f, -1.54184280e-02f, 9.21769664e-02f,
  5.86132333e-02f, -6.64962381e-02f, -1.37912985e-02f, -8.16508383e-02f, -2.51609497e-02f, -2.64550000e-02f, 7.58879706e-02f, -5.17735407e-02f, -2.47325189e-02f, -8.05046316e-03f,
  2.03286216e-01f, 2.45249718e-02f, 5.08068837e-02f, -8.74189064e-02f, 2.98774000e-02f, 3.38472873e-02f, 5.15552610e-02f, -8.17275699e-03f, -5.76874055e-02f, -8.68452713e-02f,
  -1.34305045e-01f, 8.87302384e-02f, -1.30842691e-02f, -5.26469685e-02f, -5.53260297e-02f, -7.38510042e-02f, 1.38782505e-02f, -7.25195324e-03f, -5.37919775e-02f, 2.51158588e-02f,
  1.15546517e-01f, 2.85158516e-03f, 1.96130928e-02f, -5.40895909e-02f, -8.45804065e-02f, -6.89211711e-02f, -4.18395326e-02f, 5.45467213e-02f, -8.09541494e-02f, 1.34068117e-01f,
  2.44171210e-02f, 1.42747834e-01f, -3.96562330e-02f, 5.55407368e-02f, 2.45030653e-02f, -3.75608131e-02f, 1.19261570e-01f, 1.89874247e-02f, 3.14938799e-02f, -3.22350413e-02f,
  1.23815268e-01f, -3.28464508e-02f, -7.97080435e-03f, -1.65188313e-03f, 3.47309150e-02f, 8.39839801e-02f, -5.19507099e-03f, -1.87199712e-02f, 3.33398990e-02f, -4.14258167e-02f,
  4.46391068e-02f, -9.84994769e-02f, -3.86548750e-02f, 4.29420099e-02f, 4.17288430e-02f, 5.78090884e-02f, 2.58165896e-02f, -4.00432851e-03f, -3.72655801e-02f, -1.05036549e-01f,
  3.36555280e-02f, 3.80191617e-02f, -3.30244638e-02f, 3.42492424e-02f, 8.48938152e-02f, -1.92956254e-02f, 4.23550457e-02f, -2.81790122e-02f, -6.10562926e-03f, -8.86456519e-02f,
  7.01686293e-02f, 5.02583757e-02f, 8.79472196e-02f, 8.08654279e-02f, -3.75033654e-02f, 6.74328953e-02f, 4.69339229e-02f, -7.23163188e-02f, 1.04791559e-01f, 1.04841404e-01f,
  -5.66642405e-03f, 1.45452498e-02f, 1.06749050e-01f, 7.05225617e-02f, 7.20348433e-02f, 7.79341906e-02f, -6.77630082e-02f, -6.66729584e-02f, -5.59975691e-02f, -1.17713660e-01f,
  1.41883930e-02f, 6.17689900e-02f, -7.44269416e-02f, -3.90630439e-02f, -9.52414994e-04f, -6.48980662e-02f, -3.39680314e-02f, -4.75305468e-02f, -1.93554964e-02f, -5.88882193e-02f,
  -4.60540690e-02f, 9.60198119e-02f, 8.28950182e-02f, -4.34563421e-02f, -9.12809074e-02f, -5.61721660e-02f, 3.91267166e-02f, -6.15780391e-02f, -7.67957047e-03f, -5.65247238e-03f,
  -3.54828574e-02f, -5.78466021e-02f, 6.79085702e-02f, -4.47008647e-02f, -5.07116877e-02f, -7.25197047e-02f, -8.78494382e-02f, 1.70506292e-03f, -2.32651252e-02f, -4.22635563e-02f,
  -4.96773608e-02f, 1.19906761e-01f, -4.70150821e-02f, -3.49566005e-02f, -6.06339872e-02f, -2.54849587e-02f, -6.37053773e-02f, 4.03750427e-02f, 1.07340328e-01f, 1.50462259e-02f,
  8.93217996e-02f, 8.44377801e-02f, 8.28134418e-02f, -2.27951980e-03f, -7.52578005e-02f, 6.15641437e-02f, -4.56713811e-02f, 1.45871500e-02f, -7.42460340e-02f, 5.32770902e-02f,
  -4.73925732e-02f, -7.48358145e-02f, 6.25194386e-02f, -2.97399834e-02f, 7.00438023e-02f, -1.88988131e-02f, -2.15259492e-02f, -1.41632799e-02f, -9.94523540e-02f, -1.15756705e-01f,
  -2.41326421e-01f, 7.64933899e-02f, -9.62243006e-02f, 8.52186382e-02f, 9.28774476e-02f, 1.79757420e-02f, 3.91146913e-02f, 7.36594126e-02f, 3.86935137e-02f, -1.94046497e-02f,
  -4.12915908e-02f, -2.80383043e-02f, -9.61230919e-02f, -5.94637655e-02f, 1.05307199e-01f, 1.98539704e-01f, 1.22239642e-01f, -3.13839652e-02f, -1.33491037e-02f, 8.63810033e-02f,
  2.58942917e-02f, 2.51445230e-02f, 2.45931949e-02f, 1.07767515e-01f, 8.10166746e-02f, -2.19740551e-02f, 1.82351805e-02f, 2.98670437e-02f, 1.72337200e-02f, -1.70541722e-02f,
  -1.87488094e-01f, -1.82632282e-01f, 6.82691634e-02f, -2.12673862e-02f, -1.35544419e-01f, 4.52778041e-02f, -7.95422569e-02f, 1.19008180e-02f, -1.92728806e-02f, -7.84274787e-02f,
  -1.18869498e-01f, -8.38408619e-02f, 6.57001063e-02f, -3.60117555e-02f, -3.37929316e-02f, -8.74327123e-03f, -2.02672258e-02f, -1.22970846e-02f, -7.06085470e-03f, -1.62124652e-02f,
  -3.18698473e-02f, -3.80195975e-02f, -1.14633664e-01f, -1.71851255e-02f, -9.89041701e-02f, -1.06615029e-01f, -8.66563171e-02f, -4.38805856e-02f, -6.84779137e-02f, -3.62652205e-02f,
  2.04522721e-02f, 2.30161976e-02f, -8.98269638e-02f, 5.76618575e-02f, 9.06504840e-02f, 3.18129733e-02f, 3.55794877e-02f, -5.98965250e-02f, 1.74124707e-02f, 2.18171943e-02f,
  1.81005094e-02f, -3.67093235e-02f, -7.91539773e-02f, -4.23961459e-03f, -4.13926467e-02f, -4.55545895e-02f, -3.13677713e-02f, 9.09302831e-02f, -1.44339502e-02f, -6.18683286e-02f,
  -9.77093205e-02f, 7.33130053e-02f, 6.46247566e-02f, -8.53934959e-02f, -7.94127397e-03f, 8.91756043e-02f, -5.82830124e-02f, 4.02970873e-02f, -8.96360353e-02f, -2.37848144e-02f,
  -1.09027093e-02f, 8.01838469e-03f, -6.86061904e-02f, -7.69142434e-02f, 1.78815704e-02f, -3.70701402e-02f, -4.50498844e-03f, 2.50430387e-02f, -1.00647420e-01f, 3.52329109e-03f,
  -1.14423692e-01f, 2.65723448e-02f, -9.74818766e-02f, -1.24347266e-02f, -1.53840948e-02f, -6.15944378e-02f, 8.45108032e-02f, -2.77846791e-02f, 3.41656581e-02f, -3.75562534e-02f,
  3.54503468e-02f, -8.89911056e-02f, -9.25728008e-02f, -2.35477425e-02f, -5.60511462e-02f, -2.63885669e-02f, -1.01778857e-01f, -5.39434627e-02f, 1.73447803e-02f, 3.43117826e-02f,
  1.65313259e-01f, -4.26685764e-03f, -1.68879732e-01f, 1.19266294e-01f, -7.71475285e-02f, 3.23614664e-02f, 8.59714150e-02f, 6.98080808e-02f, 7.97985047e-02f, -7.66057223e-02f,
  -4.62711789e-02f, -1.06670588e-01f, -8.34363922e-02f, -1.58620775e-01f, -3.71307917e-02f, -2.34728665e-04f, -6.77710548e-02f, -1.27290249e-01f, -3.83271948e-02f, 6.03005178e-02f,
  1.50520056e-02f, -4.42143083e-02f, 7.47647882e-02f, -2.68951692e-02f, 4.65061851e-02f, -7.87455067e-02f, -5.19501697e-03f, -2.51899119e-02f, -4.64608669e-02f, 1.06073599e-02f,
  -1.57540590e-01f, -2.10670363e-02f, -8.56199861e-02f, -2.97254100e-02f, -4.23539877e-02f, 1.13871977e-01f, 2.97695771e-02f, 8.84233713e-02f, 7.96305910e-02f, 3.44120637e-02f,
  -5.36677018e-02f, -1.70004219e-02f, -1.56687181e-02f, -7.14280233e-02f, -5.76400794e-02f, -2.91611031e-02f, 1.05016433e-01f, -2.47397888e-02f, -4.46353219e-02f, -1.27917789e-02f,
  7.89262727e-02f, 4.19114642e-02f, 7.89848045e-02f, 7.28817210e-02f, -5.89192212e-02f, -1.15322247e-01f, -7.66388923e-02f, 4.57087941e-02f, 1.05514061e-02f, -2.49257199e-02f,
  3.72659229e-03f, -9.89252329e-02f, 1.93519816e-02f, 9.06715840e-02f, 8.79351795e-02f, -8.39996245e-03f, -4.41784002e-02f, -5.43264449e-02f, 8.78681988e-02f, 5.47301620e-02f,
  1.63683090e-02f, -2.47359760e-02f, -1.24381436e-03f, 6.29768670e-02f, 4.29344969e-03f, -9.09689888e-02f, 4.07348573e-02f, 3.34549919e-02f, -3.89577709e-02f, -2.75109410e-02f,
  -6.44959062e-02f, 9.71800555e-03f, 7.23761618e-02f, 6.74123615e-02f, -4.49810252e-02f, 9.38580558e-02f, 2.75150072e-02f, 5.45841306e-02f, -1.28793865e-02f, 1.93817448e-02f,
  -1.50124142e-02f, 6.68197436e-06f, -7.12750033e-02f, -6.12006560e-02f, -2.76073697e-03f, 1.78603064e-02f, 5.03307097e-02f, 8.50926787e-02f, -4.05264050e-02f, -1.80152003e-02f,
  -3.80561948e-02f, -2.09873617e-02f, 3.05314455e-02f, 8.25976208e-02f, 9.49913785e-02f, -5.44336215e-02f, 3.39519866e-02f, -2.90525891e-02f, -4.43174243e-02f, -2.89379042e-02f,
  9.74890888e-02f, -4.26539034e-02f, 7.19033778e-02f, 8.20584819e-02f, 8.19410086e-02f, -1.12661064e-01f, -6.18536808e-02f, 8.98700878e-02f, -8.87525305e-02f, 1.98124811e-01f,
  -2.97648162e-01f, 8.99428949e-02f, 2.16799174e-02f, -2.24804014e-01f, 5.11285886e-02f, -2.36165691e-02f, 1.24689586e-01f, -1.73747004e-03f, -7.38461968e-04f, -4.97369654e-03f,
  1.06702045e-01f, 2.25693546e-02f, -5.91698475e-02f, -5.45422435e-02f, -1.76660363e-02f, 9.67721418e-02f, -1.06099874e-01f, -1.98270500e-01f, -1.15670867e-01f, 2.39922805e-03f,
  -1.28240019e-01f, -7.10871145e-02f, -2.48757005e-01f, -1.68117598e-01f, -5.74396811e-02f, 2.17650905e-02f, -1.36234805e-01f, -1.67345583e-01f, 4.41128574e-02f, -1.46372139e-01f,
  -9.91561338e-02f, -1.24064805e-02f, 5.11369631e-02f, -1.04791448e-01f, 2.71952740e-04f, -8.82943943e-02f, 1.80260707e-02f, -5.06469272e-02f, -8.16941038e-02f, -9.44855139e-02f,
  5.28146811e-02f, -4.49725464e-02f, -3.74498405e-02f, -2.61496715e-02f, -7.21575171e-02f, -1.05457492e-01f, -2.97849327e-02f, -1.11682437e-01f, -7.19339848e-02f, -7.58871511e-02f,
  -7.62022585e-02f, -1.47561327e-01f, -1.49422780e-01f, 6.53573647e-02f, 3.99065353e-02f, -1.08381510e-01f, 7.67043885e-03f, 5.09488620e-02f, -1.18915126e-01f, -1.72103822e-01f,
  6.55202717e-02f, -1.44826267e-02f, -5.88056967e-02f, -8.74581859e-02f, 1.79758407e-02f, 6.38637543e-02f, -1.42217940e-02f, -1.58749186e-02f, 4.15620357e-02f, -7.16848858e-03f,
  8.50347131e-02f, 5.12565151e-02f, 6.11233823e-02f, -9.22146998e-03f, 3.61301601e-02f, 1.46821234e-02f, -7.87967518e-02f, -7.72759840e-02f, 7.19977834e-04f, -8.46947543e-03f,
  4.49350327e-02f, 3.50853279e-02f, 3.37010771e-02f, -3.82112414e-02f, 5.22244349e-02f, -1.92470625e-02f, -4.91928793e-02f, -4.15514112e-02f, -8.66822451e-02f, 5.49232699e-02f,
  -9.86337364e-02f, 7.63010159e-02f, -1.15246348e-01f, -1.01976514e-01f, -2.68582627e-02f, -5.09573333e-02f, 6.80353194e-02f, 7.01124817e-02f, -3.07093635e-02f, -8.53978992e-02f,
  8.04070309e-02f, -1.04111336e-01f, -1.42358253e-02f, -5.93397804e-02f, -2.70480532e-02f, 4.45026010e-02f, 1.26012112e-03f, -1.50167555e-01f, -3.19277830e-02f, 5.60418777e-02f,
  -5.87057583e-02f, -6.19694740e-02f, -1.21229365e-01f, -1.40958473e-01f, 2.56498577e-03f, -1.39533132e-01f, -1.58840910e-01f, -2.47369763e-02f, -6.73727915e-02f, -1.29566550e-01f,
  -1.98247284e-02f, -1.47815913e-01f, 1.20286062e-01f, -9.66826677e-02f, -1.05040312e-01f, -2.52383798e-02f, -8.25471431e-02f, -4.57235891e-03f, -8.63482952e-02f, -6.56054616e-02f,
  -1.82839315e-02f, -4.75209691e-02f, -8.98975972e-03f, 5.90613820e-02f, 1.94701795e-02f, -6.02795407e-02f, -1.57437380e-02f, 6.82827905e-02f, 1.29515290e-01f, 7.97628462e-02f,
  5.41502498e-02f, 7.67983347e-02f, -4.04760726e-02f, -2.73431186e-02f, -8.64465758e-02f, 7.14147687e-02f, -3.08512226e-02f, 8.85497555e-02f, 4.45970073e-02f, 1.93294547e-02f,
  1.31444007e-01f, -1.21114537e-01f, 3.80171053e-02f, -1.77554116e-02f, 7.10566714e-02f, 2.80205719e-02f, -6.79446086e-02f, 8.22846442e-02f, 3.43119055e-02f, -6.63925111e-02f,
  -5.24782315e-02f, 5.10240085e-02f, 1.55150695e-02f, -7.80211762e-02f, 8.62692818e-02f, 1.00974431e-02f, 6.31120950e-02f, 5.69963939e-02f, 8.39559138e-02f, -1.10889077e-01f,
  3.32223028e-02f, -8.74695554e-02f, -5.68208992e-02f, 6.12414591e-02f, 9.89111979e-03f, 3.71777378e-02f, -8.24173987e-02f, -4.48375382e-02f, 7.62389302e-02f, 4.61608358e-02f,
  6.39488772e-02f, -5.65034375e-02f, -4.40371446e-02f, 2.22235210e-02f, 5.50803281e-02f, -5.86786382e-02f, -6.19024150e-02f, 9.24851149e-02f, -3.98074575e-02f, -7.27327615e-02f,
  -8.86596590e-02f, 3.58952768e-02f, 2.24305913e-02f, -5.30181341e-02f, 7.07326829e-02f, 1.24873733e-02f, 1.14923315e-02f, -1.01714656e-02f, 6.04792722e-02f, -6.81256205e-02f,
  -7.96278864e-02f, 6.10750988e-02f, -6.83736429e-02f, 2.27896255e-02f, 6.04645163e-02f, -3.45283039e-02f, -2.49115471e-02f, 5.05003557e-02f, 5.03580458e-02f, -6.78732246e-02f,
  -9.17118136e-03f, 1.23682491e-01f, -7.46673569e-02f, 3.70639302e-02f, 1.58030062e-03f, -3.00403330e-02f, 6.81217536e-02f, -8.01375806e-02f, -3.17257084e-03f, -6.93433657e-02f,
  7.11098872e-03f, -5.71649373e-02f, 7.59300366e-02f, -3.62468772e-02f, 2.59841606e-02f, -5.31944782e-02f, 5.04526421e-02f, 8.73019397e-02f, 6.47247285e-02f, -4.40040305e-02f,
  2.56342045e-03f, -4.71308492e-02f, 6.08425029e-02f, 2.08242051e-02f, -9.74813774e-02f, -5.10569736e-02f, 5.21917008e-02f, -3.36875990e-02f, -1.27155911e-02f, 5.86389415e-02f,
  -5.01656272e-02f, -4.06220518e-02f, -4.62291725e-02f, -5.61244180e-03f, -9.95072499e-02f, -6.91605806e-02f, -6.55125231e-02f, 6.06798306e-02f, -9.92748812e-02f, 2.51332223e-02f,
  -1.15984924e-01f, -6.63520321e-02f, 1.59247071e-02f, 1.25521541e-01f, 8.17695260e-02f, 7.77317211e-04f, -3.35640758e-02f, 1.11701386e-02f, 2.06818003e-02f, 8.35165828e-02f,
  1.48218557e-01f, 1.15358576e-01f, 7.54614696e-02f, 9.28254724e-02f, -6.54068962e-03f, -2.62698736e-02f, -6.24089427e-02f, 2.44345460e-02f, 2.51630992e-02f, -7.95288594e-04f,
  -1.15199693e-01f, -1.20524503e-01f, -6.17877506e-02f, -4.04327996e-02f, -5.49850799e-02f, -1.80788878e-02f, -1.00023873e-01f, 7.40222037e-02f, 6.51750043e-02f, -1.83095057e-02f,
  7.52563179e-02f, 5.21646207e-03f, -7.04739541e-02f, 4.30302061e-02f, 6.93098605e-02f, 1.99060887e-02f, -4.15100418e-02f, -5.19537069e-02f, -6.30305614e-03f, 6.18615327e-03f,
  6.93373904e-02f, 2.38570776e-02f, -4.83428091e-02f, -7.02572614e-02f, -6.63775727e-02f, -3.61084975e-02f, -4.42657992e-02f, 6.31642491e-02f, 2.60674730e-02f, -7.49762282e-02f,
  -2.77977176e-02f, -5.88201247e-02f, 5.03451824e-02f, 9.12165567e-02f, -2.63528656e-02f, 3.21054012e-02f, 3.65536474e-02f, 1.01665556e-01f, -1.47859938e-02f, -6.22174516e-02f,
  2.03676540e-02f, -8.20198208e-02f, 5.79233542e-02f, 6.60596276e-03f, 6.01953380e-02f, -7.18611553e-02f, -5.24108447e-02f, -1.53411999e-02f, 3.96978743e-02f, -7.88787156e-02f,
  -8.01171735e-02f, 8.20797533e-02f, -9.49876383e-02f, 9.78388637e-02f, -6.18258417e-02f, -4.69350927e-02f, 6.72986284e-02f, -3.18037495e-02f, -3.35137807e-02f, -1.07390955e-02f,
  7.89218489e-03f, -1.10007070e-01f, 3.31543572e-02f, -6.84310915e-04f, 4.04743776e-02f, -9.35507640e-02f, -1.04520895e-01f, 7.13522136e-02f, -9.57270861e-02f, -4.39705588e-02f,
  -4.28164825e-02f, 1.24420412e-02f, 1.86206568e-02f, -5.26404157e-02f, 6.66086450e-02f, -7.30703771e-02f, -9.42170694e-02f, -8.14616680e-02f, 2.84555648e-02f, -4.18506078e-02f,
  -9.59118977e-02f, 6.14964589e-03f, 1.71537548e-02f, -1.04588635e-01f, -9.54767987e-02f, -1.08363628e-02f, -1.01794869e-01f, -1.11792922e-01f, -2.27956418e-02f, 2.54847743e-02f,
  -3.78821269e-02f, 2.94029973e-02f, -3.50677338e-03f, 1.10378638e-01f, 1.67941064e-01f, 1.73321560e-01f, 1.43479183e-01f, 1.09490514e-01f, 1.42459599e-02f, 2.27956586e-02f,
  -3.37508023e-02f, -8.20509046e-02f, -8.74280110e-02f, -8.49496722e-02f, 7.59640932e-02f, -4.31256555e-02f, 1.24640100e-01f, 1.07694127e-01f, -3.33209671e-02f, 9.01982114e-02f,
  -3.13956924e-02f, -3.26803960e-02f, 8.49520266e-02f, 5.08545376e-02f, -1.43335648e-02f, -8.49284381e-02f, 4.76172417e-02f, 1.29002139e-01f, 4.55552898e-03f, 7.51514062e-02f,
  -4.84313741e-02f, 3.12881507e-02f, -1.03991188e-01f, -4.36768532e-02f, -4.48121801e-02f, -1.19641267e-01f, -4.94699627e-02f, 6.28763959e-02f, -8.17341730e-02f, -5.75985387e-02f,
  6.63737431e-02f, 3.07753105e-02f, 7.78535232e-02f, -7.28209177e-03f, -1.83045343e-02f, -5.11369295e-02f, -2.43979227e-02f, -7.44872093e-02f, 2.24265121e-02f, -3.86507027e-02f,
  -2.85346564e-02f, 7.78849199e-02f, -4.21637967e-02f, 3.33973579e-02f, 4.63500433e-02f, -6.05887696e-02f, -1.16993422e-02f, 3.83043997e-02f, -1.21095128e-01f, -1.16354033e-01f,
  -7.46753365e-02f, -8.99140665e-04f, 2.31169164e-02f, 3.60998102e-02f, 1.66128818e-02f, -7.82797113e-02f, 3.09502091e-02f, 6.55581281e-02f, -1.06511656e-02f, -1.56874228e-02f,
  8.34379271e-02f, -2.67337337e-02f, -6.25885848e-04f, 4.28748727e-02f, 6.30425382e-03f, 5.77822775e-02f, 9.92326066e-02f, -9.93018784e-03f, -7.15119094e-02f, -1.15971183e-02f,
  6.06635250e-02f, -4.50909026e-02f, -6.66491017e-02f, 3.59542146e-02f, -7.21303746e-02f, -1.92790274e-02f, -8.90110955e-02f, 2.01192629e-02f, 2.59988960e-02f, -2.65975613e-02f,
  -1.06005967e-01f, 1.25617296e-01f, -1.52937233e-01f, -4.32544835e-02f, 5.69232479e-02f, 4.87110950e-02f, -5.72109781e-03f, -9.31494310e-02f, 6.11519031e-02f, -7.55613595e-02f,
  -4.13749702e-02f, -5.83387017e-02f, 2.13239752e-02f, -1.32837761e-02f, -1.72071531e-02f, 2.31725462e-02f, 5.25186211e-03f, 5.30772842e-02f, -2.28304602e-02f, -4.20159809e-02f,
  -7.24225268e-02f, -1.13705777e-01f, -3.30457115e-04f, -1.18743725e-01f, 5.31418733e-02f, -1.21739157e-01f, -6.59172758e-02f, -9.97016430e-02f, -2.26549376e-02f, -9.48337987e-02f,
  -1.83786470e-02f, -2.07678843e-02f, 9.45934579e-02f, -5.04947938e-02f, 5.32607883e-02f, -3.30328234e-02f, -8.44241213e-03f, 7.54029900e-02f, -1.07603438e-01f, -3.14333849e-02f,
  -9.96205658e-02f, -1.12403953e-03f, 2.14768965e-02f, -7.90315196e-02f, 7.51746446e-02f, 6.34770021e-02f, -1.06284514e-01f, 1.44910989e-02f, 8.61598924e-02f, -2.11681221e-02f,
  -1.09883577e-01f, -6.22478202e-02f, 3.27344015e-02f, 3.26219648e-02f, 7.75935352e-02f, 3.39542446e-03f, -4.39168550e-02f, -5.59415855e-03f, 2.61495784e-02f, 2.40533631e-02f,
  4.05584089e-02f, 5.28594553e-02f, 8.92171413e-02f, -8.34462643e-02f, -7.82837868e-02f, 3.41686308e-02f, -7.09949899e-03f, 9.47386548e-02f, 1.91888604e-02f, -8.17033723e-02f,
  -9.37013328e-02f, -7.52745941e-02f, 3.06882206e-02f, -6.67236745e-02f, -6.24395311e-02f, -3.10794208e-02f, 5.39095476e-02f, 4.94635962e-02f, -6.39138790e-03f, 5.95690049e-02f,
  1.75752095e-03f, -6.99019805e-02f, -4.97480333e-02f, -3.00487094e-02f, 2.12391615e-02f, 7.56285265e-02f, -4.42521134e-03f, 6.92864554e-03f, 6.30180091e-02f, 9.49268490e-02f,
  -4.48822267e-02f, 7.48659223e-02f, 6.61557093e-02f, 2.69240700e-02f, 5.39175682e-02f, -4.50995304e-02f, 6.91277832e-02f, 2.71045957e-02f, 8.20951071e-03f, -3.35917808e-02f,
  6.72091991e-02f, -4.07606512e-02f, 1.52021321e-02f, 7.02293217e-03f, 2.36029439e-02f, 3.27823982e-02f, 4.57229838e-02f, 5.24603203e-02f, 7.00430572e-02f, 2.94035282e-02f,
  -8.96042734e-02f, -3.28945518e-02f, -3.84286940e-02f, 4.05235514e-02f, 1.84010286e-02f, -2.93948017e-02f, -1.47566320e-02f, -7.14688599e-02f, 6.88604861e-02f, -8.38081166e-02f,
  7.79823363e-02f, -8.39596540e-02f, -7.97666758e-02f, 3.79326455e-02f, -2.51054838e-02f, -5.43521680e-02f, 4.16471809e-02f, 4.64684144e-02f, -2.23219879e-02f, -2.29872856e-02f,
  8.30556825e-02f, -7.96019807e-02f, 2.47002896e-02f, -4.74000163e-02f, 6.35462254e-02f, -2.09960062e-03f, -1.02696277e-01f, -1.01568475e-02f, -3.86469960e-02f, 6.98547438e-02f,
  5.94774410e-02f, -5.01948744e-02f, 4.02174480e-02f, 9.62173268e-02f, 1.24090929e-02f, 7.23964255e-03f, 2.30985265e-02f, 9.14807171e-02f, 5.85556962e-02f, 4.53965552e-02f,
  8.17624927e-02f, 5.09668216e-02f, -1.08253665e-01f, 2.64804866e-02f, -1.71993859e-02f, -9.84856859e-02f, -6.16202876e-02f, -4.69752178e-02f, 4.40550931e-02f, -1.13526955e-01f,
  -8.54143724e-02f, 5.47708645e-02f, -1.23433389e-01f, 3.15242037e-02f, -1.28686637e-01f, -5.93911633e-02f, -4.02883776e-02f, -3.94090824e-03f, 8.07243213e-02f, 2.60954686e-02f,
  5.75589538e-02f, 8.86519253e-02f, 2.57216897e-02f, -2.54195798e-02f, 9.41030681e-02f, -1.37231126e-02f, -4.71292883e-02f, 7.82696009e-02f, -4.57552895e-02f, -6.45243078e-02f,
  4.11079824e-02f, 4.30225134e-02f, 4.97136638e-03f, -5.31712659e-02f, -6.45295600e-04f, -9.01166350e-02f, 2.58731470e-02f, 8.71972218e-02f, -3.47092748e-02f, -1.30404104e-02f,
  1.08770393e-02f, -1.29955970e-02f, 7.88452327e-02f, 7.73393065e-02f, 3.36041152e-02f, 6.29449040e-02f, 5.10914661e-02f, -8.66481755e-03f, -9.81886387e-02f, -5.38776221e-04f,
  -3.01196910e-02f, 2.26252377e-02f, -2.02906784e-02f, -2.24149367e-03f, -7.03399554e-02f, 4.44565713e-03f, -6.59879893e-02f, 4.13180627e-02f, 2.64224820e-02f, -5.32857478e-02f,
  1.64916757e-02f, 3.40617299e-02f, -5.61913550e-02f, 6.54727146e-02f, 7.70339295e-02f, 4.08322699e-02f, -7.41653591e-02f, -2.13964600e-02f, 8.15957636e-02f, 1.51609220e-02f,
  -3.24879996e-02f, 3.63955321e-03f, 4.97181192e-02f, 2.47492529e-02f, -4.35182117e-02f, 6.88405707e-02f, -7.80132562e-02f, -6.83277845e-02f, -7.25591034e-02f, -3.76086012e-02f,
  3.79316472e-02f, -4.96205613e-02f, 5.22601046e-02f, -5.07959686e-02f, 4.06721868e-02f, -1.18400604e-02f, -8.91155079e-02f, -1.49928648e-02f, -8.53799954e-02f, 2.58714687e-02f,
  -5.93792945e-02f, -3.29418071e-02f, 4.34984304e-02f, 2.51434520e-02f, -3.98250122e-04f, -2.24498659e-02f, -8.12244322e-03f, -3.83607335e-02f, -8.13957006e-02f, 2.23995410e-02f,
  -4.15025167e-02f, 1.12603903e-02f, 1.90070923e-02f, -3.68878851e-03f, 2.21638437e-02f, -1.84495491e-03f, 9.52949468e-03f, -6.71123341e-02f, -7.74322078e-02f, -7.55904987e-02f,
  -1.01048186e-01f, -1.02623478e-01f, 3.98428477e-02f, -3.66462395e-02f, 4.10211347e-02f, -7.08737001e-02f, 1.66829489e-02f, -8.88906568e-02f, -1.19271383e-01f, -1.12631932e-01f,
  -7.24449679e-02f, -7.12094605e-02f, 6.30087331e-02f, 7.75448009e-02f, -1.51730282e-02f, 3.59997824e-02f, 7.43174553e-02f, 4.25503738e-02f, 8.90709013e-02f, -8.96978832e-04f,
  7.82449618e-02f, 8.15426782e-02f, 1.04073182e-01f, 1.33434311e-01f, 1.47796407e-01f, -1.96550731e-02f, 4.85263430e-02f, 2.61133667e-02f, 7.40261450e-02f, 9.57913399e-02f,
  -1.90787166e-02f, -4.73564724e-03f, 6.26844773e-03f, 2.27688942e-02f, -4.49276790e-02f, 1.79932043e-02f, 9.65075195e-03f, -4.39424999e-02f, -6.50874004e-02f, -8.57663155e-03f,
  3.61343939e-03f, -1.20815329e-01f, 6.38263226e-02f, -1.14663802e-02f, -4.13767025e-02f, -8.81298911e-03f, -5.03936075e-02f, 3.58345546e-03f, 2.07689106e-02f, -4.25870381e-02f,
  -9.82666388e-02f, 9.20743961e-03f, 8.96091089e-02f, -7.43813068e-02f, -2.77199829e-03f, 1.32325280e-03f, -6.22863807e-02f, 6.05833344e-02f, 5.87151460e-02f, -3.26079987e-02f,
  3.72159202e-03f, -1.93518028e-02f, 2.33445894e-02f, 6.60137534e-02f, 6.81633651e-02f, 6.96614534e-02f, -8.68118852e-02f, -1.07857890e-01f, 5.93756251e-02f, -1.05478168e-02f,
  -4.70314361e-02f, -6.14825673e-02f, -4.29666564e-02f, 9.73659307e-02f, -1.74954385e-02f, 5.49335368e-02f, -6.31913394e-02f, 5.96427135e-02f, -5.14093004e-02f, 4.41774838e-02f,
  6.99352622e-02f, 3.92917544e-02f, -1.55705139e-02f, -1.28084207e-02f, 1.09722488e-01f, -7.60735422e-02f, -2.04028352e-03f, -8.26839507e-02f, -6.48133606e-02f, 3.27816494e-02f,
  8.87338519e-02f, 8.58787969e-02f, -2.85674278e-02f, 2.90331058e-02f, 7.02637061e-02f, -2.39587086e-03f, 5.03278039e-02f, -4.83019501e-02f, -9.99489948e-02f, -4.96726530e-03f,
  -6.23665340e-02f, 7.25820884e-02f, 7.23217577e-02f, 6.99564591e-02f, -4.09695096e-02f, -1.20641720e-02f, 2.26665027e-02f, -1.58393811e-02f, -7.59041011e-02f, -7.20183773e-04f,
  1.67723261e-02f, -1.48276649e-02f, -5.34594245e-02f, -6.22445531e-03f, -9.62707624e-02f, -1.01343848e-01f, 1.10674491e-02f, 6.47994950e-02f, -7.28467479e-02f, -3.71688753e-02f,
  -7.60767087e-02f, 4.61323075e-02f, -1.91873666e-02f, -7.58216903e-02f, -1.69485342e-02f, 2.81350338e-03f, -1.00157224e-01f, -5.29705957e-02f, -2.88426690e-02f, -1.96531266e-02f,
  -1.64710522e-01f, -3.41643058e-02f, -1.05153352e-01f, -6.07360229e-02f, 1.65676802e-01f, 1.17615111e-01f, 1.91422611e-01f, -9.06369928e-03f, 4.43549156e-02f, -9.80009604e-03f,
  -6.57793880e-02f, -6.28813878e-02f, 3.79012413e-02f, -1.66148692e-02f, 8.81575420e-02f, 2.91120093e-02f, 2.32795812e-03f, 2.40540672e-02f, -3.75203788e-02f, -8.50492530e-03f,
  3.05367969e-02f, 5.12464121e-02f, -1.11817949e-01f, -6.40501827e-02f, 8.56744424e-02f, 2.03782832e-03f, 4.70292531e-02f, -3.86010781e-02f, -2.78212409e-02f, 1.08868047e-03f,
  -4.64792140e-02f, -1.18041657e-01f, 1.07042834e-01f, 3.13965864e-02f, -6.02612719e-02f, 4.18501087e-02f, 1.18063744e-02f, 1.90933235e-02f, -4.36726771e-03f, -8.25061500e-02f,
  -9.81572121e-02f, 5.39657585e-02f, -1.99631397e-02f, -9.19212475e-02f, -5.65667823e-02f, -3.86471637e-02f, -2.55143475e-02f, -1.12718984e-01f, -6.61889240e-02f, -8.77597034e-02f,
  -1.87449232e-02f, -6.44911174e-03f, 2.62601441e-03f, -3.83205339e-03f, -1.22222155e-02f, -8.77499282e-02f, -8.45744014e-02f, -5.87580763e-02f, -1.29785785e-03f, 5.05239107e-02f,
  -8.22609663e-02f, -4.85020056e-02f, 7.52081424e-02f, -1.38179027e-02f, 9.53613222e-03f, 6.53233081e-02f, 9.75405518e-03f, -7.60707036e-02f, 2.74809375e-02f, 7.34651461e-02f,
  6.34398237e-02f, -4.22376804e-02f, 1.47315906e-02f, -3.68704237e-02f, 4.21770848e-02f, -8.01614486e-04f, -4.61436994e-02f, 1.58917140e-02f, 5.20584323e-02f, -3.03212553e-02f,
  2.11638790e-02f, -2.73586158e-02f, -1.92754879e-03f, 6.46763444e-02f, -4.87066880e-02f, -6.28135428e-02f, -1.67418588e-02f, 7.68966824e-02f, 1.23951305e-02f, -5.99276759e-02f,
  -1.90982502e-02f, -8.02985430e-02f, 1.04528300e-01f, -1.49277016e-03f, -1.61586478e-02f, -1.12294517e-01f, -7.35895261e-02f, -4.35650609e-02f, -9.26281586e-02f, -5.47461808e-02f,
  -2.43734904e-02f, 6.32283539e-02f, 2.27720314e-03f, 8.79824087e-02f, 9.19040351e-04f, 4.70665805e-02f, 5.51239736e-02f, 7.15672597e-02f, 2.13811845e-02f, -6.82929158e-02f,
  4.84698452e-02f, 1.09928921e-01f, 3.22650783e-02f, 9.95613113e-02f, -6.21917583e-02f, -2.68136822e-02f, 4.64301594e-02f, -5.80853876e-03f, 4.95497659e-02f, -2.35321373e-02f,
  1.01203406e-02f, -5.70131987e-02f, 1.07949123e-01f, 7.42643997e-02f, 1.42849967e-01f, 1.18016126e-02f, 5.02541922e-02f, -3.93117853e-02f, -3.56703326e-02f, -1.54137164e-02f,
  -9.93923992e-02f, -1.12307876e-01f, -1.41954333e-01f, 2.22121477e-02f, -9.16807950e-02f, 7.75332469e-03f, 1.29660189e-01f, 1.09176137e-01f, 6.25166371e-02f, 1.08118625e-02f,
  -6.59788251e-02f, 9.71070752e-02f, 2.14350726e-02f, 9.15662497e-02f, 1.94005482e-02f, 3.97808850e-02f, -5.34791276e-02f, 8.56031328e-02f, -8.91298205e-02f, 3.94210070e-02f,
  -3.66012491e-02f, -9.25846323e-02f, -2.73350440e-02f, -7.92705864e-02f, -5.50263673e-02f, 4.17510010e-02f, 3.08324546e-02f, 1.12106770e-01f, -5.76689839e-03f, -6.12159967e-02f,
  -6.15636185e-02f, -6.09646961e-02f, -4.32201196e-03f, -6.90622255e-02f, 8.56037214e-02f, -8.93053319e-03f, 8.69230479e-02f, -3.03979144e-02f, 2.23798454e-02f, 1.09823551e-02f,
  -3.79883684e-02f, 5.33055812e-02f, -6.02351725e-02f, -3.21507454e-02f, -6.47128448e-02f, 7.61048272e-02f, -1.69134755e-02f, 6.35074228e-02f, -3.86620760e-02f, 1.03871627e-02f,
  2.23819632e-02f, 4.62241471e-02f, -5.72354533e-02f, -4.66599464e-02f, -3.76811326e-02f, -5.28617352e-02f, 2.86952294e-02f, 4.01835330e-03f, -6.18242584e-02f, -7.44841918e-02f,
  7.33603463e-02f, 6.22105077e-02f, -1.88333038e-02f, -4.21817135e-03f, -1.76200550e-02f, -8.24168995e-02f, 7.60331601e-02f, -2.36050948e-03f, 5.84433675e-02f, -7.57373078e-03f,
  5.89317568e-02f, -5.18526137e-02f, -2.79990230e-02f, -8.54790509e-02f, -1.93576422e-02f, 3.45665775e-02f, 2.56510172e-02f, -1.08506633e-02f, -1.36244074e-02f, -1.89209301e-02f,
  9.67302397e-02f, 1.75553225e-02f, -8.14619064e-02f, -1.05476774e-01f, -3.29163000e-02f, 5.86983413e-02f, -2.55517550e-02f, 7.33190551e-02f, 9.34458748e-02f, -4.10911255e-02f,
  -1.16602061e-02f, 2.53229886e-02f, 6.75194710e-02f, -5.06507754e-02f, 1.63216084e-01f, 6.28132597e-02f, -8.72104093e-02f, -5.35925180e-02f, -3.46536562e-02f, 2.81554218e-02f,
  3.09617016e-02f, 8.71312246e-02f, 1.23532936e-01f, 5.00233471e-02f, -5.31807393e-02f, 1.00091793e-01f, 1.24102592e-01f, 5.85903265e-02f, 7.61118010e-02f, 9.28994119e-02f,
  1.53503627e-01f, 9.17455778e-02f, -2.94245303e-01f, -2.59413905e-02f, -1.47424996e-01f, -1.85361236e-01f, -3.16891782e-02f, -8.74926895e-02f, 9.02817696e-02f, -4.20119464e-02f,
  -5.33783548e-02f, 9.71321017e-02f, -8.58720541e-02f, 4.32462096e-02f, -5.60685396e-02f, -1.31555229e-01f, -3.52734663e-02f, -1.13307990e-01f, -7.29426295e-02f, -5.44763058e-02f,
  -9.09690708e-02f, 8.60592052e-02f, 8.67382511e-02f, -1.67282764e-02f, -1.03878222e-01f, 3.91014852e-02f, -8.53259712e-02f, -1.30461454e-01f, -1.08082175e-01f, -7.63745755e-02f,
  -1.64501205e-01f, 2.13069394e-02f, -7.71535486e-02f, 1.13731153e-01f, -1.30872637e-01f, -6.13418557e-02f, 3.37954424e-02f, -6.76642582e-02f, -7.64576271e-02f, -6.55909255e-02f,
  -7.07156956e-02f, 4.18600738e-02f, -6.07177615e-03f, 1.99211203e-02f, -8.54104087e-02f, -4.27801125e-02f, 5.17090410e-02f, 4.22243252e-02f, 3.80214676e-03f, -7.63408933e-03f,
  -5.17863743e-02f, 2.18961406e-02f, 3.18509042e-02f, -7.36621721e-03f, 2.97731422e-02f, -8.80616978e-02f, -9.19809714e-02f, -2.61191241e-02f, 3.22352350e-02f, -2.25710496e-02f,
  8.64491761e-02f, 7.12222084e-02f, 6.87091565e-03f, -7.99848512e-03f, -3.77337746e-02f, 4.23901452e-04f, -4.12669554e-02f, 5.68226725e-02f, 3.53506505e-02f, 5.79378717e-02f,
  5.41702062e-02f, -1.44966021e-02f, 4.78761010e-02f, 8.29155836e-03f, 5.56745939e-02f, -5.34644499e-02f, 1.42540652e-02f, 8.64946097e-02f, 5.61653450e-02f, 2.55209189e-02f,
  9.99336541e-02f, 5.48437191e-03f, -7.31673688e-02f, -7.85605907e-02f, -7.77254701e-02f, -4.35358956e-02f, 7.79115632e-02f, -1.89746283e-02f, -3.93322371e-02f, 8.68142173e-02f,
  1.01166762e-01f, -2.65221484e-02f, 6.01203516e-02f, 1.74637791e-02f, -1.13921180e-01f, 8.51764604e-02f, -1.56297814e-02f, -2.95590498e-02f, 2.39996123e-03f, -3.18030640e-02f,
  3.18836346e-02f, 8.76162946e-02f, -8.89491197e-03f, -4.62328121e-02f, 1.90031268e-02f, 5.91315813e-02f, -4.78003696e-02f, 4.44598049e-02f, 8.56819898e-02f, 6.78497553e-02f,
  8.59688371e-02f, -1.61234959e-04f, 1.60039157e-01f, 6.93478212e-02f, 8.00844058e-02f, 4.29392047e-02f, 1.55182963e-03f, 5.71635105e-02f, -4.21041809e-02f, 5.54288812e-02f,
  -2.72295717e-02f, 2.50657275e-02f, -5.35888597e-02f, 1.50767043e-01f, 1.53266396e-02f, 9.12240520e-02f, 1.29835844e-01f, 1.10471606e-01f, 1.63061082e-01f, 6.10231562e-03f,
  8.51810575e-02f, 1.27525121e-01f, 1.20355666e-01f, 1.46636739e-01f, 3.70530598e-02f, 4.78659160e-02f, 1.49762869e-01f, 7.29012936e-02f, -7.66398013e-02f, 4.21181172e-02f,
  -1.61181875e-02f, 1.20972767e-02f, -1.08278021e-01f, -7.19407499e-02f, -2.99536698e-02f, 1.31214559e-01f, 6.02213256e-02f, -6.91393614e-02f, 8.22169855e-02f, -7.56917056e-03f,
  -1.55537635e-01f, -9.22610760e-02f, 7.47287944e-02f, -7.77013120e-05f, 4.13253717e-03f, -6.61893189e-02f, -2.37225145e-02f, -8.98351073e-02f, 6.39669150e-02f, -2.36245245e-02f,
  -1.01188034e-01f, -8.72578472e-02f, -7.12174922e-02f, 1.27430744e-02f, -7.51862582e-03f, -1.00735761e-01f, -4.33236398e-02f, -9.24984142e-02f, 7.03466088e-02f, -5.25510795e-02f,
  2.05325838e-02f, -7.93454126e-02f, 6.69738054e-02f, 1.06762774e-01f, -2.26831883e-02f, 4.71187793e-02f, 1.66300647e-02f, 6.19956888e-02f, 5.83702847e-02f, 6.03374764e-02f,
  4.16541658e-02f, 3.88923958e-02f, -4.49790210e-02f, -1.88271906e-02f, -5.40927947e-02f, 3.30264308e-03f, -5.14270961e-02f, -5.97017258e-03f, 1.03878975e-02f, 5.83928302e-02f,
  -5.22335880e-02f, 6.39927909e-02f, 2.82393545e-02f, -5.72847351e-02f, 2.90302504e-02f, 3.42015846e-04f, 5.72389141e-02f, -7.73294345e-02f, -7.15191290e-02f, -2.94179711e-02f,
  1.64229367e-02f, -8.90643224e-02f, -9.14152935e-02f, 3.60500962e-02f, -8.76247436e-02f, -8.84467643e-03f, 2.09881342e-03f, 3.15381289e-02f, -1.08610429e-02f, -4.76950333e-02f,
  -5.03285043e-02f, 2.71270387e-02f, 3.91537230e-03f, 9.64157805e-02f, -9.38701704e-02f, -5.99468462e-02f, 7.46638840e-03f, -8.07290897e-02f, 6.51980937e-02f, -7.58850202e-02f,
  -8.68009403e-02f, 5.04796021e-02f, -6.05892539e-02f, 4.53712419e-02f, -1.77572425e-02f, 8.67813081e-02f, 4.28331234e-02f, -5.25774285e-02f, 6.66409954e-02f, 5.48131019e-02f,
  5.54867201e-02f, 2.69999932e-02f, 1.55030359e-02f, -8.01945385e-03f, 5.21941334e-02f, -7.48526724e-03f, 1.25310831e-02f, 2.48380452e-02f, 2.13010684e-02f, -4.69377674e-02f,
  -2.72154570e-01f, -8.57946351e-02f, -5.06854393e-02f, -4.74125594e-02f, 4.57076728e-02f, -4.52546999e-02f, 1.29474878e-01f, -1.61151197e-02f, -8.98185000e-02f, -8.26146379e-02f,
  4.07217853e-02f, 2.29157191e-02f, 2.60856953e-02f, 2.81208847e-02f, -3.02220434e-02f, 5.73804490e-02f, 2.58173086e-02f, 7.33134970e-02f, -2.27915570e-02f, 3.00831697e-03f,
  7.30486810e-02f, -3.91181521e-02f, -2.11814623e-02f, -9.96567961e-03f, -3.58941145e-02f, -1.21546173e-02f, -1.17715215e-02f, 3.27348942e-03f, 3.92258875e-02f, 7.68257454e-02f,
  2.13985994e-01f, 2.03174427e-02f, 5.72610758e-02f, -4.45650183e-02f, -6.09385706e-02f, -2.14283504e-02f, 1.46814836e-02f, 2.04081945e-02f, -2.97406930e-02f, -6.47983104e-02f,
  2.43907589e-02f, -2.22497527e-02f, 7.91264549e-02f, -5.51931979e-03f, -4.62986380e-02f, -7.37551088e-03f, -1.85395814e-02f, -5.20848371e-02f, 7.62253553e-02f, -4.29380126e-02f,
  1.11106992e-01f, -2.66593732e-02f, -1.00571439e-02f, -8.74839257e-03f, 9.29080546e-02f, -7.46575072e-02f, -7.64851868e-02f, -3.72800864e-02f, 7.31979087e-02f, -3.91411036e-03f,
  -9.45046842e-02f, -1.99972782e-02f, -8.07271805e-03f, -9.03643481e-03f, -1.72736426e-03f, 1.27934164e-03f, 7.74827376e-02f, -1.70080771e-03f, -4.77468856e-02f, 7.59395014e-04f,
  -3.99565659e-02f, -3.76674421e-02f, 6.93517998e-02f, 8.42750743e-02f, -3.14521641e-02f, -7.14600831e-02f, 7.45689347e-02f, -6.35045096e-02f, 3.37714925e-02f, 3.88526507e-02f,
  7.52191991e-02f, -3.40141803e-02f, -9.62240528e-03f, 6.59303889e-02f, 2.77644768e-02f, 2.17048987e-03f, 3.42572406e-02f, -4.45511043e-02f, -4.22048829e-02f, -6.66868389e-02f,
  1.37052424e-02f, -5.08854985e-02f, 2.00407673e-03f, 6.89782575e-02f, 7.91272894e-02f, 4.57958952e-02f, -2.55911164e-02f, -9.95662436e-02f, 9.77186114e-03f, 2.08748113e-02f,
  7.31803849e-02f, 3.82911600e-02f, -7.32747391e-02f, 6.27423003e-02f, 5.98353036e-02f, -3.91413830e-02f, -9.59311202e-02f, -2.10596528e-02f, 9.53818634e-02f, 3.07091774e-04f,
  -6.81527033e-02f, 4.68124412e-02f, -6.30337074e-02f, 8.08775872e-02f, 4.92243990e-02f, -2.61814352e-02f, -3.57659347e-02f, 1.11320660e-01f, 5.31368256e-02f, 6.89884424e-02f,
  1.60264164e-01f, 1.89292189e-02f, 1.14513293e-01f, -1.63299423e-02f, 6.37318492e-02f, 1.56807795e-01f, 1.55120105e-01f, 9.03283209e-02f, 1.68069340e-02f, 5.64519279e-02f,
  5.43351322e-02f, -7.35663809e-03f, -7.48174265e-04f, 2.99538369e-03f, -6.28866032e-02f, -6.71986341e-02f, 5.80414571e-02f, 7.61025921e-02f, -3.96133121e-03f, -5.30943908e-02f,
  4.81899548e-03f, -4.76278588e-02f, -6.76055476e-02f, -6.70522749e-02f, -4.05862592e-02f, -1.01814345e-01f, 2.05946844e-02f, -7.68518597e-02f, 1.38199758e-02f, -6.73229247e-02f,
  1.33751808e-02f, -5.04643940e-05f, 3.89506966e-02f, -1.21115938e-01f, 1.56299286e-02f, -7.63769895e-02f, -2.64814682e-02f, 4.03153570e-03f, -4.37434092e-02f, -3.21721211e-02f,
  -5.70494644e-02f, 1.16866082e-03f, 4.74838959e-03f, 2.70314533e-02f, 7.33416108e-03f, -5.89264072e-02f, -6.31786957e-02f, 3.61929722e-02f, -9.07958522e-02f, 3.95994028e-03f,
  -1.33880690e-01f, 7.47384727e-02f, 1.55350089e-01f, -1.56926475e-02f, -6.26473641e-03f, 8.27665441e-03f, 8.21767524e-02f, -4.10148501e-02f, 3.65261100e-02f, -7.21246600e-02f,
  6.26368076e-02f, -6.67230561e-02f, 1.29819429e-02f, 5.24166301e-02f, 1.64760817e-02f, 4.09149416e-02f, 3.36409472e-02f, -4.71901894e-02f, -4.19853516e-02f, -6.07311837e-02f,
  6.39156625e-02f, -5.71453422e-02f, -4.90420200e-02f, -2.52621509e-02f, -4.66864556e-02f, -3.03781554e-02f, -7.30785280e-02f, -8.38065594e-02f, 8.12149867e-02f, -4.93276343e-02f,
  -7.84262493e-02f, 8.03213716e-02f, -8.99314731e-02f, -1.60180368e-02f, -6.32755971e-03f, -8.68037939e-02f, 7.94260427e-02f, 5.97013608e-02f, -8.90468433e-02f, -8.50319862e-02f,
  -2.64822971e-03f, 1.62416950e-01f, 1.48491766e-02f, -4.30307798e-02f, 7.50196427e-02f, -1.03139140e-01f, -3.59018147e-02f, -7.13113099e-02f, -4.60744575e-02f, -6.19426444e-02f,
  -6.37210831e-02f, 4.80750129e-02f, -1.10977069e-02f, 2.17771959e-02f, 5.41326068e-02f, 7.06783533e-02f, 4.61612344e-02f, -2.47912556e-02f, -9.24955830e-02f, 3.92848924e-02f,
  -5.34699708e-02f, 9.08005014e-02f, 5.12510687e-02f, -6.06978051e-02f, 8.51692930e-02f, 1.18596956e-01f, 3.62398960e-02f, -9.04188491e-03f, 7.88331628e-02f, -2.90662758e-02f,
  5.87820075e-02f, -2.05259874e-01f, -1.99910719e-02f, 1.45934805e-01f, -1.01163767e-01f, -1.70332715e-01f, -1.29694685e-01f, -4.42876145e-02f, 2.93604676e-02f, -8.85795802e-02f,
  -1.11731581e-01f, 1.59782059e-02f, -6.51751161e-02f, -1.60926655e-01f, -1.73711598e-01f, -2.57033616e-01f, -1.27593324e-01f, -1.74787804e-01f, -2.06733823e-01f, -2.01507479e-01f,
  -1.19445622e-01f, -1.11460686e-01f, -1.38075501e-01f, 6.24421798e-03f, 6.84101209e-02f, 1.41728278e-02f, -7.45505542e-02f, 2.20455956e-02f, -4.75387052e-02f, -1.28198594e-01f,
  -1.24359846e-01f, 2.64543723e-02f, 2.75944499e-03f, -3.98629420e-02f, 7.91283399e-02f, 5.64789996e-02f, 3.77194360e-02f, 1.95582602e-02f, -2.82593314e-02f, -1.42672388e-02f,
  1.25247345e-03f, -9.05627292e-03f, 1.07311040e-01f, -5.13204038e-02f, 3.74892913e-02f, -9.26345494e-03f, -2.51851939e-02f, 3.90421301e-02f, 7.62620866e-02f, 7.11119771e-02f,
  -1.00952707e-01f, -4.23903903e-03f, 1.78738162e-02f, 9.08840448e-02f, 9.13217664e-02f, -4.99971956e-02f, 2.40594111e-02f, 1.30349755e-01f, 1.06793977e-01f, 5.37562445e-02f,
  -8.41884091e-02f, 2.44515929e-02f, -1.23613356e-02f, -3.68513167e-02f, -3.66208591e-02f, 4.35354337e-02f, -3.97182740e-02f, 2.78232619e-02f, 5.87267913e-02f, -8.58507827e-02f,
  -3.38813141e-02f, -1.90809574e-02f, 1.11136737e-03f, 6.05478846e-02f, -5.61648011e-02f, -3.69725749e-02f, -3.54548320e-02f, -1.56658795e-02f, 4.61398400e-02f, -9.77338701e-02f,
  3.65332887e-02f, 8.48283544e-02f, -5.65784909e-02f, -3.29572409e-02f, -1.13590658e-01f, -3.03923097e-02f, -8.65451321e-02f, -2.32894029e-02f, 9.92082581e-02f, 6.23694547e-02f,
  1.11284979e-01f, -7.73732215e-02f, -1.17287310e-02f, 4.86348234e-02f, 1.92785189e-02f, -4.18499745e-02f, 8.80968869e-02f, -4.15367521e-02f, -5.84085984e-03f, 1.87676549e-02f,
  3.01485304e-02f, -6.17946349e-02f, 7.60418773e-02f, 1.04200672e-02f, -4.08449061e-02f, 7.51686282e-03f, -1.38594210e-01f, -9.94551629e-02f, -1.70425270e-02f, 4.89823818e-02f,
  -1.07882060e-01f, -1.10220276e-01f, -1.41289994e-01f, 7.07125738e-02f, 1.21947177e-01f, -5.27367592e-02f, -7.14698583e-02f, 2.02543829e-02f, -5.99523373e-02f, -6.17820285e-02f,
  1.51364177e-01f, -1.50128275e-01f, 3.69551852e-02f, 1.07959561e-01f, 1.17346130e-01f, 1.27153859e-01f, 9.43882689e-02f, 2.76099201e-02f, -4.95826602e-02f, -8.52824599e-02f,
  -7.52144381e-02f, -3.29341181e-02f, -7.48701766e-02f, -1.66091397e-01f, -7.42567033e-02f, 1.32115372e-02f, 1.02543734e-01f, 1.23334579e-01f, 1.40387580e-01f, 2.22078152e-03f,
  1.03979975e-01f, -5.70681831e-03f, 3.34111340e-02f, 6.91851005e-02f, 7.40238428e-02f, -1.17694829e-02f, 4.34953533e-02f, -1.45416874e-02f, 8.18573833e-02f, 8.55291188e-02f,
  -1.22149866e-02f, 5.03889658e-02f, 5.10684364e-02f, -9.75536034e-02f, 5.55919185e-02f, -3.22826393e-02f, -2.98306122e-02f, -7.83663169e-02f, -5.21109067e-02f, 9.52693224e-02f,
  -4.90716435e-02f, -6.54713809e-02f, 6.90402761e-02f, -4.87109087e-02f, -7.01682866e-02f, -2.25275178e-02f, 1.48462709e-02f, 4.97744679e-02f, -9.90172755e-03f, -1.25621874e-02f,
  -8.96687657e-02f, -3.16632502e-02f, 5.91706373e-02f, -2.65704282e-02f, -5.59214801e-02f, 1.87167227e-02f, -7.59117454e-02f, -2.10974808e-03f, -6.72708303e-02f, -2.81611271e-02f,
  -4.33966294e-02f, -3.02851684e-02f, 7.28555070e-03f, -1.06202051e-01f, 7.38248751e-02f, -6.81085438e-02f, -8.32092389e-02f, 5.02482243e-02f, -4.06773128e-02f, -7.33844042e-02f,
  -3.62274498e-02f, -7.47492388e-02f, -5.46398163e-02f, 3.03892624e-02f, -9.93793905e-02f, -5.67600131e-02f, 5.05013652e-02f, 3.53033878e-02f, -3.00420672e-02f, -4.35624225e-03f,
  -1.18524022e-03f, 4.16014083e-02f, 4.35476191e-02f, -4.65361066e-02f, -5.21086529e-03f, -6.87953159e-02f, -7.10466802e-02f, 1.72113571e-02f, 4.84423973e-02f, -7.03200772e-02f,
  -1.46673560e-01f, -1.09662138e-01f, 7.98450038e-02f, 5.66537194e-02f, 1.14477672e-01f, -4.27624509e-02f, -9.14640427e-02f, -5.68502136e-02f, -5.93469702e-02f, 8.33697915e-02f,
  4.50511239e-02f, -5.51019311e-02f, -7.28712454e-02f, 4.39971834e-02f, 6.58391640e-02f, 1.51338186e-02f, -7.29485527e-02f, 9.48184356e-02f, -5.06779961e-02f, -7.21076876e-02f,
  1.17126545e-02f, 6.29681498e-02f, 9.89529416e-02f, 6.41837865e-02f, -8.15631598e-02f, 1.10003360e-01f, -4.67045233e-02f, 1.55646224e-02f, 2.27776114e-02f, 7.11695254e-02f,
  3.14775735e-01f, -1.28134310e-01f, 1.43179923e-01f, 1.15998648e-01f, -3.56045030e-02f, 8.37726295e-02f, 4.14700136e-02f, 1.12441573e-02f, -2.72072535e-02f, 7.06435665e-02f,
  3.12063769e-02f, 5.56333661e-02f, -2.90643368e-02f, 6.44373074e-02f, 9.42430124e-02f, -5.75790852e-02f, -3.17193638e-03f, 1.12557724e-01f, 2.01109797e-01f, 9.29287598e-02f,
  -1.36356816e-01f, 7.44899213e-02f, -5.61920740e-03f, -6.66288063e-02f, -1.12630934e-01f, -8.49081762e-03f, -5.43990359e-02f, -6.17453568e-02f, -3.16835521e-03f, -3.61478552e-02f,
  3.23537178e-02f, 1.69781953e-01f, 6.86298013e-02f, -4.53900322e-02f, -2.18185131e-02f, 2.05467772e-02f, -3.65356766e-02f, -4.56514694e-02f, -8.78093392e-02f, -4.79657203e-02f,
  -1.63056422e-04f, 6.03699759e-02f, 8.11883584e-02f, 2.91547105e-02f, -8.33585858e-03f, -6.62940741e-02f, -5.30828834e-02f, -5.33039644e-02f, -1.42793562e-02f, 2.66145896e-02f,
  -1.61221385e-01f, 9.41732228e-02f, 1.03252769e-01f, 7.98474103e-02f, -6.26342222e-02f, 1.14438944e-01f, 5.75255901e-02f, -4.33607660e-02f, 5.09234890e-02f, -1.08515047e-01f,
  -3.20673585e-02f, 7.13701621e-02f, 9.61374342e-02f, 2.49175280e-02f, -2.40974184e-02f, 2.62321811e-02f, 3.85134369e-02f, -4.81478907e-02f, -3.07333227e-02f, 2.52907183e-02f,
  4.20197332e-03f, -3.81245315e-02f, 5.59956245e-02f, 1.04709305e-02f, 2.60782451e-03f, -4.24578674e-02f, 8.92674476e-02f, 3.55401710e-02f, 6.87035769e-02f, 8.11180621e-02f,
  1.48381600e-02f, 5.90959042e-02f, 3.56500223e-02f, -4.14090753e-02f, 7.03862980e-02f, 9.17878747e-02f, 8.16352759e-03f, -7.75280818e-02f, -1.69450659e-02f, 3.41857187e-02f,
  -8.93651396e-02f, 1.36096343e-01f, 1.82488887e-03f, -1.86484233e-02f, -2.22056322e-02f, 6.12012967e-02f, -3.51166911e-02f, -6.52779418e-04f, -2.63059214e-02f, -1.30954161e-01f,
  5.50520085e-02f, 1.99461114e-02f, 1.83478389e-02f, -5.38412295e-02f, 7.48200119e-02f, -2.70999931e-02f, -8.03587288e-02f, -2.49865516e-05f, 6.36994168e-02f, -7.84778744e-02f,
  -1.31438002e-01f, -6.66122958e-02f, 8.50373507e-02f, 7.06177503e-02f, -8.74394402e-02f, 1.61619291e-01f, 1.02062285e-01f, 9.56406072e-02f, -1.45919751e-02f, -3.38593200e-02f,
  -2.55247623e-01f, -9.89264026e-02f, 1.40892461e-01f, -1.26387104e-01f, -1.00902222e-01f, -1.53667167e-01f, -1.38243869e-01f, -1.58615205e-02f, -1.21336915e-01f, -1.69747949e-01f,
  -6.51888177e-02f, 1.87526587e-02f, 7.53807798e-02f, 6.54082969e-02f, 1.08947285e-01f, -9.69939828e-02f, 1.34166004e-02f, 1.63049996e-01f, 1.24319077e-01f, -1.59011390e-02f,
  -8.20840672e-02f, -2.01278124e-02f, 4.17768173e-02f, 6.97163641e-02f, 3.55907064e-03f, 9.91276652e-02f, 7.84413964e-02f, 3.01241353e-02f, 4.67760576e-04f, 2.36387216e-02f,
  2.07919076e-01f, -2.01716274e-02f, 8.32581967e-02f, 4.09719273e-02f, 3.50647569e-02f, -6.72256127e-02f, -4.56082784e-02f, -1.89371407e-03f, -6.40135333e-02f, 6.15888983e-02f,
  2.71399273e-03f, 4.88857850e-02f, 3.29522751e-02f, 7.36627355e-02f, 1.55452844e-02f, -6.47265464e-02f, 1.02161147e-01f, 8.78434554e-02f, 1.20674819e-01f, -3.89874689e-02f,
  6.27425238e-02f, -9.07930508e-02f, -9.12098289e-02f, -6.20843507e-02f, 4.35947347e-03f, -5.91961294e-02f, 7.68266916e-02f, -7.97609165e-02f, 1.08385518e-01f, -1.01078801e-01f,
  3.35789621e-02f, 4.41151336e-02f, -6.80010840e-02f, -2.58447416e-03f, -2.06935462e-02f, -5.53549454e-02f, 7.46374726e-02f, -7.22281188e-02f, 1.06979385e-01f, -9.50161088e-03f,
  -7.20783174e-02f, -5.81412874e-02f, 3.64218950e-02f, -1.26780085e-02f, -5.35139255e-02f, 3.25323604e-02f, 4.23391489e-03f, -2.98771020e-02f, -2.81689651e-02f, 1.09148165e-02f,
  8.78240634e-03f, -5.65444343e-02f, -3.71307060e-02f, 2.05238629e-02f, -1.05814226e-02f, 4.03563939e-02f, 2.97077205e-02f, 5.14065437e-02f, 1.10431518e-02f, -9.46264863e-02f,
  1.43620566e-01f, -6.70512393e-02f, -8.59810412e-03f, -1.62677448e-02f, -6.53538704e-02f, 6.34527802e-02f, 3.44612077e-02f, 6.45350516e-02f, -1.59514919e-02f, -1.59137417e-02f,
  -4.80520688e-02f, -5.58870882e-02f, -1.51487319e-02f, -2.63049342e-02f, -2.07917113e-02f, 2.46833581e-02f, 4.04512770e-02f, -5.46176098e-02f, -7.10331202e-02f, 1.08156959e-02f,
  -5.19007742e-02f, 1.63282845e-02f, 7.30995834e-02f, 1.00975893e-01f, -5.56127913e-02f, 2.13581566e-02f, 7.88994208e-02f, -6.23417273e-02f, 4.09058221e-02f, 1.64163895e-02f,
  9.97486785e-02f, -9.81000140e-02f, 5.47454134e-02f, -9.72470790e-02f, 3.61514091e-02f, 2.02909596e-02f, -2.30280254e-02f, 8.54387209e-02f, -6.75470755e-02f, -8.57849345e-02f,
  -3.99184227e-02f, -1.18023627e-01f, -6.20044954e-02f, -7.04031512e-02f, 9.61173922e-02f, 7.75234029e-02f, -2.44426541e-02f, -9.08150151e-03f, 6.06584512e-02f, 6.83061630e-02f,
  5.44000566e-02f, -1.04486324e-01f, -2.89685987e-02f, 8.23250264e-02f, -6.54959492e-03f, 4.63438071e-02f, -5.83309792e-02f, -3.87387797e-02f, -6.89564720e-02f, -8.67156684e-02f,
  -7.06595369e-03f, -6.38569593e-02f, -5.29546589e-02f, -6.64208382e-02f, 2.29474306e-02f, -1.42879086e-02f, 2.66592652e-02f, 1.88931134e-02f, 3.06836888e-02f, 3.67415063e-02f,
  -9.16898847e-02f, -7.85155594e-02f, 6.91593140e-02f, -5.84355295e-02f, -4.16368768e-02f, 6.27746852e-03f, -5.77897802e-02f, 5.44626601e-02f, -4.82181720e-02f, -4.54384694e-03f,
  -9.46562961e-02f, -4.14510034e-02f, 3.17199603e-02f, 7.33485296e-02f, 4.64705490e-02f, 4.21343744e-02f, -8.36796537e-02f, 1.17715336e-02f, 2.67308783e-02f, -5.30604310e-02f,
  -5.01293615e-02f, 6.94166869e-02f, 1.16418293e-02f, -3.93989086e-02f, 5.17089628e-02f, -6.39458969e-02f, 7.72310719e-02f, 4.02033329e-02f, 3.35977562e-02f, 4.00034375e-02f,
  5.56129292e-02f, -7.95227587e-02f, 1.57586224e-02f, -2.21720785e-02f, -2.46799644e-02f, 5.39137051e-02f, 1.10261356e-02f, -5.55877052e-02f, -1.38642150e-04f, -5.18161505e-02f,
  6.95378333e-02f, 9.46728885e-02f, 5.15137613e-02f, -8.44717845e-02f, 3.33300345e-02f, -8.30363631e-02f, 4.06643050e-03f, 4.89791930e-02f, -8.62067789e-02f, -5.41627780e-02f,
  -1.00589208e-01f, 1.17367879e-01f, 2.69811451e-02f, 8.38391334e-02f, 6.27193153e-02f, 5.56719713e-02f, -6.83188513e-02f, -2.08242871e-02f, 2.75446568e-02f, 5.80727048e-02f,
  3.78950052e-02f, 7.53114149e-02f, -1.05467737e-02f, 2.56965216e-02f, 5.11330925e-02f, -1.18883662e-02f, -3.02062556e-02f, -1.55709982e-02f, 1.95450033e-03f, -4.79817316e-02f,
  -2.34561358e-02f, 1.31794259e-01f, -1.91907752e-02f, -1.52138639e-02f, -1.69654340e-02f, 2.95593273e-02f, -2.00886372e-02f, 1.26435384e-01f, 1.14783123e-02f, 7.33597949e-02f,
  -2.52156526e-01f, -2.01766398e-02f, -8.49286765e-02f, -6.19489066e-02f, 4.94654961e-02f, 4.30366956e-02f, 3.00207287e-02f, -1.00829907e-01f, -1.79103091e-02f, -2.35808250e-02f,
  -6.27419949e-02f, 3.92639972e-02f, 5.82111217e-02f, 7.83177987e-02f, -4.34304476e-02f, -3.07541359e-02f, -5.39303161e-02f, 9.76043195e-02f, 1.35601208e-01f, 1.84857659e-03f,
  1.17214561e-01f, 1.24208890e-02f, -8.92563090e-02f, 5.35898060e-02f, -9.17676687e-02f, 3.59651074e-02f, 3.53577314e-03f, -1.06382236e-01f, 7.66871870e-02f, -1.17623195e-01f,
  1.75431952e-01f, -3.42229307e-02f, 8.16769451e-02f, 7.57408068e-02f, -7.97902569e-02f, -9.34771001e-02f, -4.33568396e-02f, -6.67858794e-02f, -1.10238098e-01f, -6.42989669e-03f,
  1.91745963e-02f, 1.98016297e-02f, -8.48894268e-02f, 7.12323701e-03f, 7.86562562e-02f, -1.65013261e-02f, -2.48733908e-02f, -9.28722098e-02f, 2.14961525e-02f, -8.20364282e-02f,
  6.74491897e-02f, -9.81725678e-02f, -1.49704190e-03f, -8.65062550e-02f, -8.98368061e-02f, 4.74242233e-02f, 4.48277891e-02f, 3.06466371e-02f, -3.56737780e-03f, -7.95444027e-02f,
  7.49391243e-02f, -6.67855516e-02f, -6.90578818e-02f, -8.65438371e-04f, 4.20762189e-02f, -7.30065405e-02f, 9.49057713e-02f, -1.46438496e-03f, 6.25033304e-02f, 2.35841312e-02f,
  -3.14664356e-02f, -2.31727473e-02f, 5.95894977e-02f, -9.15242825e-03f, 5.21392599e-02f, -1.06649540e-01f, -9.07136407e-03f, 7.29619041e-02f, -3.53815705e-02f, -6.92381635e-02f,
  -4.43619639e-02f, -6.99948594e-02f, -6.00427836e-02f, 3.21501307e-02f, -8.56107567e-03f, -3.46448570e-02f, -5.55358268e-02f, 4.70440723e-02f, -8.14159140e-02f, -2.29387102e-03f,
  1.58659697e-01f, -1.90646052e-02f, -6.82174265e-02f, -2.96421647e-02f, -1.02595218e-01f, -3.84530127e-02f, 5.37412502e-02f, -8.42576250e-02f, -2.59453058e-02f, -1.55822122e-02f,
  1.13728140e-02f, -1.89338736e-02f, -2.52890885e-02f, 3.20817903e-02f, 1.09201521e-01f, -3.13144065e-02f, -8.02385211e-02f, -1.99970347e-03f, -1.80818774e-02f, 7.78794363e-02f,
  6.50573969e-02f, -5.27831987e-02f, 1.10472895e-01f, 4.55352366e-02f, 5.11507392e-02f, 2.17178967e-02f, 1.31438911e-01f, 9.87228602e-02f, 6.38800114e-02f, -3.50251719e-02f,
  -9.31362808e-02f, -5.27115017e-02f, -7.30185360e-02f, 1.01685800e-01f, 7.71418810e-02f, 1.71862971e-02f, -2.02255011e-01f, -1.32469743e-01f, -5.79490326e-02f, 2.25696769e-02f,
  -6.85415864e-02f, 3.06848735e-02f, -1.18443891e-02f, -6.27400130e-02f, -6.74472228e-02f, -1.71221167e-01f, 7.18668522e-03f, 1.85147170e-02f, -7.21507370e-02f, -1.34582356e-01f,
  -3.48009402e-03f, -5.37747480e-02f, -5.86006045e-02f, 2.01853388e-03f, -1.78042892e-02f, 9.17762052e-03f, -5.22101521e-02f, -4.34538163e-02f, -9.26181376e-02f, 3.99744585e-02f,
  8.06337968e-02f, 6.11503385e-02f, 3.92405316e-03f, 7.86072016e-02f, 9.38515514e-02f, 3.46417241e-02f, 5.99502884e-02f, 1.26991361e-01f, -4.62603904e-02f, 4.15577367e-02f,
  1.70775056e-02f, 1.67631488e-02f, 5.49261086e-02f, 1.62766986e-02f, -1.57908467e-03f, 1.02736257e-01f, 7.33415708e-02f, 3.72184440e-02f, 4.70558628e-02f, 6.68795779e-02f,
  9.17002335e-02f, -2.39854418e-02f, -7.62235224e-02f, 8.11422020e-02f, -2.46824306e-02f, 1.02021351e-01f, 1.09184191e-01f, 1.55349169e-02f, 8.26970115e-02f, 7.20146298e-02f,
  3.59604284e-02f, -4.89491597e-02f, -4.46257517e-02f, 6.06661178e-02f, -6.49796575e-02f, 8.14962760e-02f, -3.30647267e-02f, -2.60545872e-02f, 6.45171627e-02f, -2.60386188e-02f,
  -7.50510208e-03f, -6.07403405e-02f, -5.77069893e-02f, -7.00266808e-02f, 9.08375531e-02f, 3.95192392e-02f, -6.57867566e-02f, -3.70320678e-02f, 5.22298552e-02f, 7.78196976e-02f,
  -2.77802199e-02f, -5.68073429e-02f, 2.08650157e-02f, -1.69623103e-02f, 2.27554888e-02f, 6.70669600e-02f, 4.16362584e-02f, 7.15384483e-02f, -1.23165008e-02f, 2.23782249e-02f,
  7.97565058e-02f, 7.53641054e-02f, -1.75922718e-02f, -8.20632372e-03f, -3.90071608e-02f, 8.15380067e-02f, -6.14344259e-04f, 1.34791080e-02f, 6.94118440e-02f, -3.81341912e-02f,
  -2.74263900e-02f, -2.02941810e-04f, 6.25074804e-02f, -5.59210666e-02f, 4.85744737e-02f, 1.49125438e-02f, -6.24081939e-02f, -5.77782989e-02f, 8.95961747e-03f, 2.00211778e-02f,
  3.79021131e-02f, -9.88939106e-02f, -1.09374061e-01f, -4.31796946e-02f, -9.63764340e-02f, 1.78086353e-04f, -7.03321025e-02f, -9.55629572e-02f, -5.25036044e-02f, -1.25448391e-01f,
  -3.04296687e-02f, -9.94148850e-03f, -5.44116870e-02f, 1.46310916e-02f, 1.76567433e-03f, 7.27545843e-02f, 8.36469159e-02f, 1.21703111e-02f, 1.04208797e-01f, -4.57605161e-02f,
  5.00864387e-02f, 3.29579152e-02f, 5.06295264e-02f, -5.27096614e-02f, -3.27426121e-02f, 5.62513545e-02f, 5.87525778e-02f, 3.95197459e-02f, 9.14631784e-02f, -7.25592747e-02f,
  1.07951209e-01f, 9.47808251e-02f, 3.59243341e-02f, 6.82742968e-02f, 6.79402277e-02f, 7.92287886e-02f, -4.42725047e-02f, -3.69688049e-02f, -6.24662042e-02f, -5.14366589e-02f,
  -1.18490018e-01f, 8.15492868e-02f, -6.72557056e-02f, -8.06442052e-02f, 5.88111654e-02f, 7.22056953e-03f, 6.42511696e-02f, -9.31087211e-02f, 7.24356323e-02f, -7.18190754e-03f,
  -1.61724333e-02f, 1.23437599e-03f, -1.70094222e-02f, -1.00908540e-01f, 7.34859630e-02f, 4.90866601e-02f, -3.96463647e-02f, 2.62510478e-02f, 2.65618903e-03f, 5.38735464e-02f,
  -3.56881618e-02f, -6.90933764e-02f, -1.46874199e-02f, 8.45770910e-02f, -5.16981855e-02f, -5.16877063e-02f, -5.51628731e-02f, 3.56639363e-02f, 3.98244672e-02f, -1.00482911e-01f,
  1.39989145e-03f, 4.96016107e-02f, -1.89098846e-02f, -9.01550129e-02f, -1.54941827e-02f, -5.83712794e-02f, 3.66359092e-02f, -4.14502099e-02f, 9.02698636e-02f, 4.02047224e-02f,
  3.89448963e-02f, -3.66611630e-02f, 4.71342653e-02f, 3.96333216e-03f, -1.67687237e-02f, -8.52178335e-02f, 7.88504165e-03f, 1.34251621e-02f, 8.80464613e-02f, -4.59104590e-02f,
  1.89054478e-02f, 5.29072993e-02f, 9.33668688e-02f, 7.56509155e-02f, 2.64861770e-02f, -7.41440952e-02f, 7.85069391e-02f, 6.40758201e-02f, -5.35647646e-02f, -7.04200491e-02f,
  9.92521495e-02f, 1.13406762e-01f, -4.32328247e-02f, -8.07554349e-02f, -5.70865860e-03f, 6.46614656e-02f, 9.59073305e-02f, -8.54139701e-02f, 5.03979549e-02f, 4.84974980e-02f,
  -7.75780603e-02f, -2.51264442e-02f, 6.89564869e-02f, 9.21933725e-03f, -2.21547075e-02f, 4.58736122e-02f, 4.32189442e-02f, 9.61497426e-02f, -4.91821915e-02f, -9.05648768e-02f,
  -1.60957873e-02f, -7.27249384e-02f, 9.06451941e-02f, -5.74900210e-02f, -4.12960239e-02f, -5.20273112e-02f, -4.63113338e-02f, 6.98683336e-02f, 3.25096981e-03f, -7.40022436e-02f,
  1.36220947e-01f, 1.20695256e-01f, 1.30692765e-01f, -5.95376827e-02f, 7.15101436e-02f, 5.89195192e-02f, 1.34159803e-01f, 1.22022219e-02f, 4.73765802e-04f, 6.80737942e-02f,
  -6.52042180e-02f, -9.86194611e-02f, -2.38288771e-02f, 3.71986404e-02f, 1.00018747e-01f, 7.62135489e-03f, 5.47872782e-02f, 1.57209504e-02f, 5.45828789e-02f, -3.37580510e-04f,
  -3.42085510e-02f, 4.44338955e-02f, 8.23445432e-03f, 8.69017914e-02f, -7.45200887e-02f, -7.43693560e-02f, -2.70614028e-02f, 8.37488249e-02f, 1.11630326e-02f, 8.62300172e-02f,
  1.56311132e-02f, 1.54061601e-01f, -1.06003486e-01f, -6.58313707e-02f, 9.96410102e-02f, -1.01422938e-03f, 1.37525005e-02f, 1.03250742e-01f, 7.98666328e-02f, 1.97213911e-03f,
  2.94870920e-02f, -1.34036196e-02f, 1.09654173e-01f, -1.74855012e-02f, -5.68940938e-02f, 4.18077223e-02f, 1.39466980e-02f, -2.12739315e-02f, 5.26883975e-02f, -7.08972989e-03f,
  1.86293256e-02f, 3.47543359e-02f, 1.18277937e-01f, 7.08613843e-02f, 5.91151454e-02f, -9.91633236e-02f, 4.92740497e-02f, -2.66111232e-02f, 3.85428593e-02f, 7.52029642e-02f,
  -6.30407482e-02f, -2.62075718e-02f, 8.73781070e-02f, -3.31373997e-02f, -5.21541238e-02f, -2.76575740e-02f, 7.69639388e-02f, 3.41831818e-02f, 7.02413439e-04f, -1.29521023e-02f,
  4.35393862e-02f, 3.98453847e-02f, 9.10255536e-02f, -4.98071918e-03f, 1.23841560e-03f, 8.28973800e-02f, 4.30551916e-02f, -4.00228500e-02f, 4.71231993e-03f, -3.89987566e-02f,
  8.85088220e-02f, 6.40833527e-02f, 2.83296946e-02f, -4.83983792e-02f, -6.46028593e-02f, -4.81090285e-02f, 3.54500115e-02f, 5.04490882e-02f, 7.98308328e-02f, -5.81178814e-02f,
  -1.14404954e-01f, 9.31317918e-03f, -1.14710338e-01f, -3.45210359e-02f, -8.64451453e-02f, 4.14875299e-02f, -8.97488892e-02f, -8.19915831e-02f, 7.93342367e-02f, -4.07167710e-03f,
  -1.43580036e-02f, -1.95614919e-02f, -2.65313275e-02f, 9.15741082e-03f, -3.60584049e-03f, -2.27945037e-02f, -9.05115530e-02f, -4.74605113e-02f, -6.11366332e-02f, -5.06533161e-02f,
  4.17569578e-02f, -1.05058961e-01f, -1.66263245e-02f, -3.66620719e-02f, -3.31015997e-02f, -1.39459848e-01f, 1.89647544e-02f, -7.50685185e-02f, -7.97677934e-02f, -9.60025862e-02f,
  2.91266218e-02f, -2.72644252e-01f, -3.67716819e-01f, -1.10177256e-01f, -2.46168375e-02f, -3.75573412e-02f, -1.37258083e-01f, -1.20460242e-02f, 4.21302356e-02f, -1.72648355e-01f,
  2.73335017e-02f, 1.26477495e-01f, 2.45706607e-02f, -2.05296502e-02f, -7.57046118e-02f, -1.05741180e-01f, -2.58539528e-01f, -1.77848190e-01f, -3.47099118e-02f, 6.50839508e-02f,
  3.69900614e-02f, -5.91106862e-02f, -1.14209913e-02f, -5.77621534e-02f, 3.52219790e-02f, 2.73674503e-02f, -1.56394199e-01f, 2.27682595e-03f, -4.03932817e-02f, -9.19198990e-02f,
  -1.34780958e-01f, 1.50197344e-02f, 1.21772520e-01f, 8.89204890e-02f, -5.74822985e-02f, 5.21510914e-02f, -3.97464931e-02f, -7.59887919e-02f, 7.99778551e-02f, -8.76916945e-02f,
  -6.42818660e-02f, 1.30952373e-01f, -4.03718166e-02f, -5.18851951e-02f, 1.00465387e-01f, -1.56774316e-02f, -2.00098697e-02f, -6.05658628e-02f, 5.50014973e-02f, 7.84110352e-02f,
  5.92932664e-02f, -1.44166397e-02f, -3.09589338e-02f, 5.28655620e-03f, -5.91211319e-02f, 4.53932472e-02f, -2.64590215e-02f, -3.71998250e-02f, -4.40828875e-02f, -1.07361637e-01f,
  4.17862833e-02f, -7.88439158e-03f, 3.52647342e-02f, 7.59609323e-03f, 2.93790400e-02f, -8.89066607e-02f, 2.26886887e-02f, -7.07659125e-02f, -5.74944839e-02f, -1.02926523e-03f,
  1.30866198e-02f, -4.66751121e-02f, -5.98129332e-02f, 5.30467108e-02f, -1.77910123e-02f, -1.00296684e-01f, -2.88088918e-02f, 5.74871562e-02f, -6.90129399e-02f, -3.61130312e-02f,
  -1.98324071e-03f, 5.36203058e-03f, 5.68187721e-02f, -3.16539295e-02f, -5.60006946e-02f, 5.32968268e-02f, 6.20982423e-02f, 5.41435294e-02f, 9.26358476e-02f, 7.07440674e-02f,
  -1.74394064e-02f, -1.21170357e-01f, -1.04123563e-01f, -7.09301280e-03f, -8.65968391e-02f, -3.19349915e-02f, -1.21237248e-01f, -7.37376064e-02f, 8.45009275e-03f, 8.41243044e-02f,
  7.65126348e-02f, 5.87217100e-02f, -1.13558762e-01f, -2.61818338e-02f, 6.08802922e-02f, 8.52496922e-02f, -1.08279377e-01f, -3.41912694e-02f, 8.90420005e-02f, -5.85657870e-03f,
  -6.67384267e-02f, -7.81331509e-02f, -4.09888811e-02f, -1.11247353e-01f, 1.02311462e-01f, -4.78655566e-03f, -8.60642120e-02f, 3.67385782e-02f, -9.94179025e-02f, -7.03123137e-02f,
  2.52885461e-01f, 1.59125343e-01f, 5.65046221e-02f, 3.86306867e-02f, -5.14725456e-03f, 1.66451514e-01f, 1.47440493e-01f, 6.97729066e-02f, -5.94442785e-02f, 1.05108358e-02f,
  1.40274540e-01f, -5.39731942e-02f, 7.37233926e-03f, -6.94462135e-02f, -4.83772121e-02f, -3.40807997e-02f, -1.17997177e-01f, -2.04528384e-02f, 3.49248499e-02f, -3.58184427e-02f,
  6.82241246e-02f, 9.74853113e-02f, 1.12672389e-01f, -6.64343163e-02f, -2.17561633e-03f, 1.64090469e-02f, -7.90210962e-02f, 8.13135505e-02f, 7.42933676e-02f, 4.20308299e-03f,
  -1.38210580e-02f, 2.34488383e-01f, -3.92962694e-02f, -9.47792490e-04f, 9.26233530e-02f, -8.37915242e-02f, 3.42358998e-03f, -6.30599856e-02f, -5.26925698e-02f, -3.86647172e-02f,
  -1.27008287e-02f, 2.07303204e-02f, 9.02441442e-02f, 5.34133539e-02f, 2.86848284e-02f, -9.00509953e-03f, -5.77841885e-02f, 4.45757508e-02f, -4.94266711e-02f, 1.33426599e-02f,
  -6.33125529e-02f, 3.40079069e-02f, 7.70397782e-02f, -6.05589896e-02f, -2.43666000e-03f, 2.11097784e-02f, -2.13085720e-03f, -2.79567558e-02f, 5.26859276e-02f, -1.28046889e-02f,
  -6.89572990e-02f, -6.64769486e-02f, 9.61709954e-03f, 8.09466094e-02f, 2.44431049e-02f, 4.73761559e-02f, 2.43656822e-02f, 1.76375862e-02f, 9.56277177e-03f, 1.04453452e-02f,
  -7.91097730e-02f, 5.63626140e-02f, -1.24813546e-03f, -6.56458810e-02f, -4.74256538e-02f, 3.97395715e-02f, 8.06731954e-02f, -3.84035781e-02f, 6.82895333e-02f, 2.03586370e-02f,
  -5.12959063e-02f, -3.26558910e-02f, -8.10840875e-02f, -1.00540414e-01f, -3.17236371e-02f, -1.06070034e-01f, 3.72447306e-04f, 7.56926984e-02f, -5.02388589e-02f, 5.22018075e-02f,
  -5.02622984e-02f, 1.85547307e-01f, -9.87211913e-02f, -8.86695907e-02f, 9.57319222e-04f, -6.65165856e-02f, 7.16327354e-02f, 7.74611719e-03f, -7.07138255e-02f, -6.70001358e-02f,
  6.12683892e-02f, 1.05817415e-01f, 7.72504061e-02f, -8.31767265e-03f, 3.74096818e-03f, 3.81141454e-02f, -1.85532849e-02f, -8.22034553e-02f, -2.23755855e-02f, -4.64513488e-02f,
  -1.79886296e-02f, 7.93831497e-02f, 6.38874248e-02f, -8.76680389e-02f, -7.97957033e-02f, -3.16274427e-02f, 1.87713187e-02f, -1.01718999e-01f, -2.22002389e-03f, 2.77331341e-02f,
  5.40547147e-02f, -1.52669370e-01f, 6.76893517e-02f, 5.54243959e-02f, 1.56331331e-01f, 1.00651793e-02f, -1.68172836e-01f, -6.03974536e-02f, 2.32770555e-02f, -3.03760059e-02f,
  1.10394113e-01f, 2.27598369e-01f, 1.11930534e-01f, -7.18551688e-03f, 1.01082092e-02f, -5.72286062e-02f, 5.24555966e-02f, -1.58167500e-02f, 7.92586878e-02f, 1.23039588e-01f,
  5.56811243e-02f, 1.14375032e-01f, 1.24600239e-01f, 1.18909761e-01f, 6.75633103e-02f, 1.73562139e-01f, 5.65943383e-02f, 3.30660790e-02f, 3.04619372e-02f, 1.35687999e-02f,
  9.97529104e-02f, -1.50263101e-01f, 2.92108357e-02f, 1.60378665e-01f, 1.34295613e-01f, -1.52081689e-02f, 1.46155190e-02f, 4.78788987e-02f, -2.97334194e-02f, -1.09931193e-01f,
  9.76163968e-02f, -1.84730291e-02f, -6.94648772e-02f, -5.40010538e-03f, -7.83874467e-02f, -7.04117939e-02f, -9.81420949e-02f, -3.54832485e-02f, -9.34327543e-02f, -9.44225788e-02f,
  1.02717631e-01f, 2.62371488e-02f, -3.57044376e-02f, -1.56836826e-02f, -5.21189608e-02f, 1.29824847e-01f, -7.48873875e-02f, 5.78750335e-02f, -3.52153145e-02f, -1.32973284e-01f,
  1.57995254e-01f, 1.40825674e-01f, 1.40369982e-01f, -1.63915362e-02f, -4.57288474e-02f, 3.32075544e-02f, 9.26230252e-02f, 1.43048947e-03f, 5.46624102e-02f, -5.25151156e-02f,
  -5.06485403e-02f, 9.67658907e-02f, -4.60967049e-02f, 5.98800741e-02f, 7.72882774e-02f, 9.10239518e-02f, -4.87788916e-02f, 9.58075151e-02f, 1.73720531e-02f, -1.96035653e-02f,
  -5.02895229e-02f, 1.89307369e-02f, 4.64993343e-02f, -4.98003922e-02f, -2.46857032e-02f, 1.24059655e-01f, 1.34534955e-01f, 4.84847184e-03f, 3.81219164e-02f, 5.70332557e-02f,
  3.05831917e-02f, 5.00101335e-02f, 3.82996686e-02f, -4.32008365e-03f, -2.16257256e-02f, 6.11672252e-02f, -3.83304656e-02f, 3.97108309e-02f, -5.88633157e-02f, -6.44569770e-02f,
  3.16012651e-02f, 4.95103467e-03f, -4.74127084e-02f, -3.41376103e-02f, 6.53041229e-02f, 5.56042185e-03f, 6.82460740e-02f, 8.15646350e-02f, -3.72566320e-02f, -8.22526440e-02f,
  1.47985294e-02f, 4.32504620e-03f, -8.62366185e-02f, -6.68163151e-02f, 8.48509092e-03f, 1.66528597e-02f, -4.97524925e-02f, -1.02432556e-01f, -9.81820971e-02f, -5.07096713e-03f,
  -2.55248770e-02f, 9.47703570e-02f, 3.00743375e-02f, 5.64154871e-02f, 1.62344471e-01f, 1.12188891e-01f, 2.06843168e-01f, 1.12037480e-01f, 2.07618803e-01f, 4.56152037e-02f,
  1.39895588e-01f, 1.35559171e-01f, 1.81197792e-01f, 1.33535951e-01f, 1.41000627e-02f, 1.00696512e-01f, 1.12929396e-01f, 2.51071118e-02f, 6.14517555e-02f, 1.15814082e-01f,
  1.40088433e-02f, 9.63808596e-02f, -1.04106337e-01f, -4.72988486e-02f, 1.30124539e-01f, 1.38634518e-01f, 7.99689591e-02f, 2.30874550e-02f, -2.33791173e-02f, 1.49280280e-01f,
  -8.83888602e-02f, -6.99558929e-02f, -6.99414834e-02f, -7.19180480e-02f, 2.55422015e-02f, -1.30043477e-01f, 7.56335780e-02f, -2.78729182e-02f, -7.14005828e-02f, 5.15646227e-02f,
  5.60401380e-03f, -9.86133590e-02f, 8.80748704e-02f, -2.02749157e-03f, -1.04549028e-01f, -4.26967964e-02f, 3.09145711e-02f, 7.56575167e-02f, 7.48406649e-02f, -2.68055033e-02f,
  1.13434441e-01f, -6.57557100e-02f, -1.87518205e-02f, -1.54739646e-02f, -6.36775568e-02f, 5.11233397e-02f, -4.21498157e-03f, 9.15249065e-03f, 1.48987528e-02f, -1.01940654e-01f,
  -1.95398685e-02f, 8.48269165e-02f, -8.23159888e-03f, 1.01849876e-01f, 8.98058563e-02f, 7.92696998e-02f, 1.19836181e-01f, 6.94224238e-02f, 2.13428978e-02f, 5.23164198e-02f,
  -1.88771486e-02f, -2.79964283e-02f, -1.33715821e-02f, 6.50888383e-02f, -4.43661474e-02f, 2.38645878e-02f, 9.87549219e-03f, -5.75373955e-02f, 6.69220760e-02f, -1.29688876e-02f,
  1.05873853e-01f, -7.25667626e-02f, 3.85897458e-02f, 4.95891459e-02f, 3.24903280e-02f, -3.90590727e-02f, 3.95621508e-02f, -6.38034567e-02f, 8.35078210e-02f, 2.22423691e-02f,
  -2.49300152e-02f, -7.91713521e-02f, 1.00702986e-01f, 7.00867875e-03f, 4.44369949e-02f, 3.89490277e-02f, 1.15034208e-02f, -5.39096966e-02f, 2.96272500e-03f, 5.28399320e-03f,
  -6.38028383e-02f, -6.68581724e-02f, 7.06126541e-02f, -1.19197788e-03f, 6.27945270e-03f, 1.66193526e-02f, -8.92258659e-02f, 1.15939952e-01f, 5.33321276e-02f, 4.93263751e-02f,
  2.81947874e-03f, -2.03615357e-03f, -1.70067977e-02f, 3.25912200e-02f, -3.95596167e-03f, 3.10626049e-02f, -7.94140175e-02f, 5.08064730e-03f, -8.02163929e-02f, -1.01519050e-02f,
  -1.30205855e-01f, 5.06635010e-02f, -8.88439044e-02f, 2.37742234e-02f, 8.96755010e-02f, 4.66869660e-02f, 2.79358588e-02f, -4.08989340e-02f, -3.99685688e-02f, 4.38080318e-02f,
  6.37584180e-02f, 6.69310614e-02f, 7.05899745e-02f, 6.97770566e-02f, -8.21572691e-02f, 3.01755257e-02f, -6.14728555e-02f, -2.68827882e-02f, -1.29508525e-01f, 4.20829244e-02f,
  1.71414856e-02f, 7.69908577e-02f, -1.51812686e-02f, 6.38279971e-03f, 8.98474008e-02f, 6.16415553e-02f, -2.92977747e-02f, 4.35667075e-02f, 3.43759134e-02f, 5.03395498e-02f,
  2.25351602e-02f, -7.13819116e-02f, 1.48259988e-02f, 9.74939838e-02f, -2.25072112e-02f, 4.50117402e-02f, -1.51495477e-02f, -9.57317799e-02f, -8.03901777e-02f, -9.25683305e-02f,
  3.32421958e-02f, -3.04686986e-02f, 7.88337644e-03f, 1.32652875e-02f, -1.09981909e-01f, -3.20069939e-02f, 2.63613611e-02f, -1.66265979e-01f, -4.93438877e-02f, -5.27069680e-02f,
  2.61661224e-02f, 8.38848129e-02f, -7.59035423e-02f, 9.30854026e-03f, -8.88169482e-02f, 2.64379736e-02f, -4.20871973e-02f, 3.05295028e-02f, -1.12829402e-01f, -8.99089426e-02f,
  -2.87311114e-02f, -7.73103461e-02f, 4.52263728e-02f, -1.47398433e-03f, 9.35733169e-02f, -2.29582172e-02f, -5.05088568e-02f, -8.11654627e-02f, -7.99593702e-02f, -2.18024123e-02f,
  6.26623109e-02f, 5.18220440e-02f, 3.89251262e-02f, 1.54478906e-03f, 1.96437631e-02f, 6.09841719e-02f, -2.50672828e-02f, -1.03084147e-01f, 6.08465709e-02f, 2.75865942e-02f,
  3.93678546e-02f, 5.01299053e-02f, -3.31072211e-02f, 1.89609323e-02f, -1.00595064e-01f, -1.14352055e-01f, -8.55059847e-02f, -2.90636513e-02f, -7.36488700e-02f, 4.79887873e-02f,
  8.73122662e-02f, -9.58409160e-02f, -7.45691732e-02f, 7.82476440e-02f, 2.24224497e-02f, -9.23515335e-02f, 6.95986226e-02f, -5.30239232e-02f, 1.00393957e-02f, -1.02343835e-01f,
  -7.07792863e-02f, -8.44932646e-02f, -6.72301576e-02f, -1.97396073e-02f, -1.31828552e-02f, 5.88428229e-02f, -3.67827937e-02f, 2.94779669e-02f, -5.65653294e-03f, -8.90142173e-02f,
  -1.04296908e-01f, -4.05616090e-02f, 2.54197475e-02f, -7.27161840e-02f, 5.94715364e-02f, -2.00768583e-03f, 2.34396551e-02f, 4.57147658e-02f, -1.32688478e-01f, -8.83154795e-02f,
  -2.84760952e-01f, -1.13119386e-01f, 5.20324521e-02f, -7.18191192e-02f, -2.85465140e-02f, 2.17592400e-02f, -3.11865397e-02f, 6.87876716e-02f, 6.47605956e-02f, -9.77830887e-02f,
  -5.45885786e-02f, 4.24107276e-02f, -5.83682396e-02f, -1.85139570e-02f, -6.67832866e-02f, 6.22635186e-02f, 3.84736271e-03f, 9.71370190e-02f, -1.72110461e-02f, 2.62146611e-02f,
  7.91418031e-02f, 3.17308046e-02f, -6.44593909e-02f, 7.27508068e-02f, 1.01925619e-01f, 1.23946622e-01f, 5.52074648e-02f, 6.51269779e-02f, -7.38730421e-03f, 7.03949556e-02f,
  1.73553035e-01f, -1.79509252e-01f, 4.29193266e-02f, -6.23273216e-02f, -3.23864855e-02f, -7.40057305e-02f, 2.88061295e-02f, 6.51045814e-02f, 6.16356172e-02f, 3.04150190e-02f,
  5.22332033e-03f, -1.43289035e-02f, 1.67117491e-02f, 4.43044230e-02f, -4.32563350e-02f, -2.87036579e-02f, -1.01903677e-01f, -6.87724724e-02f, 8.54603350e-02f, -4.98887412e-02f,
  -5.27480692e-02f, 1.94307268e-02f, 5.49073555e-02f, 1.08844511e-01f, -7.36467764e-02f, -7.31761083e-02f, 6.94203898e-02f, -2.75983252e-02f, -2.45594159e-02f, 5.08648995e-03f,
  -5.09666540e-02f, -8.55819136e-02f, -6.65607350e-03f, 6.74080998e-02f, -7.15457574e-02f, -3.10625564e-02f, 8.61171186e-02f, -6.27370179e-02f, 6.71443790e-02f, 3.42581905e-02f,
  3.04371491e-02f, 2.36579608e-02f, 3.50480271e-03f, 4.22394276e-02f, -6.46531209e-02f, 3.94507945e-02f, 6.68707211e-03f, -5.47720045e-02f, -1.03589753e-02f, 3.51358764e-02f,
  -8.98628905e-02f, -5.55117289e-03f, -2.74165515e-02f, -8.18014052e-03f, 4.70549650e-02f, 6.09651543e-02f, 1.14058359e-02f, -3.26149794e-03f, -8.99881795e-02f, 2.89954524e-03f,
  6.65083826e-02f, 9.84967593e-03f, 8.25958773e-02f, 5.15489606e-03f, -4.46940865e-03f, -5.49102165e-02f, -6.71045259e-02f, -3.71814594e-02f, -8.13723579e-02f, 1.16638020e-01f,
  -3.67461517e-02f, 2.49783322e-02f, 1.04177751e-01f, -2.66487300e-02f, 7.00686648e-02f, 7.42237195e-02f, 1.56476218e-02f, -6.32528737e-02f, 2.09165644e-03f, 3.01873423e-02f,
  9.07875374e-02f, -1.58186853e-02f, 9.52894762e-02f, 3.89175897e-04f, 9.80383754e-02f, 5.12249954e-02f, -3.61262239e-04f, 1.72707494e-02f, -1.83412265e-02f, -5.06523289e-02f,
  -1.83097079e-01f, 2.16346547e-01f, 8.85045901e-02f, -9.81476977e-02f, 1.96722835e-01f, 2.10768670e-01f, 2.70645022e-01f, -1.53639540e-02f, 3.02977506e-02f, 9.20929164e-02f,
  6.67242706e-02f, -1.12872764e-01f, -7.56119611e-03f, -6.01093359e-02f, 4.53105904e-02f, 7.90227354e-02f, 1.46560110e-02f, -1.26901805e-01f, -1.48849264e-01f, -7.55358934e-02f,
  -2.73060557e-02f, 8.81114881e-03f, -1.36617452e-01f, -8.37525874e-02f, 1.93859413e-02f, -9.14098173e-02f, -2.94368621e-03f, -3.87827866e-02f, 1.05119005e-01f, -5.77835701e-02f,
  -7.64435902e-02f, 1.33301793e-02f, -4.72062267e-02f, -9.31422338e-02f, 4.72494662e-02f, -1.13395713e-01f, 1.92130189e-02f, 1.11344326e-02f, -1.79654974e-02f, -6.63341209e-02f,
  3.95196304e-02f, 3.00750844e-02f, -7.80479610e-02f, -5.48438393e-02f, -7.55959600e-02f, -2.23682486e-02f, -9.12086107e-04f, -1.55517636e-02f, -6.86292648e-02f, -1.83665473e-02f,
  -5.35367653e-02f, 6.27393201e-02f, -4.73807566e-02f, -4.77965474e-02f, -1.08421594e-01f, -9.51547623e-02f, -6.41627759e-02f, -8.16094503e-03f, -1.44756451e-01f, -6.14974201e-02f,
  -2.57890560e-02f, 7.02247620e-02f, -2.99018901e-02f, 6.09037802e-02f, 2.36855652e-02f, -3.74339893e-02f, 3.18279751e-02f, 3.65397334e-02f, -1.35989673e-02f, 7.47077912e-02f,
  4.07945327e-02f, -9.32957456e-02f, -6.61827847e-02f, 7.46292099e-02f, -1.02472618e-01f, -6.09025955e-02f, -2.41357312e-02f, 3.28052714e-02f, 3.79575156e-02f, 4.42873947e-02f,
  1.41349128e-02f, -4.88846265e-02f, 3.99181619e-03f, 3.46953534e-02f, -6.73066005e-02f, -7.36383200e-02f, -2.13777460e-02f, -9.99128819e-02f, 1.18285874e-02f, 6.14862591e-02f,
  -8.40288922e-02f, 4.57104109e-02f, -3.47761996e-02f, -1.07883781e-01f, 2.06030346e-02f, 7.65252486e-03f, 9.23087224e-02f, -1.91107132e-02f, 1.20974537e-02f, -7.04239383e-02f,
  7.49647152e-03f, -9.92749706e-02f, 3.17278244e-02f, -1.14273811e-02f, 2.45608222e-02f, -1.26200899e-01f, 3.70299183e-02f, -1.41902462e-01f, -9.92359314e-03f, -9.50924456e-02f,
  -3.94879468e-02f, -1.04101248e-01f, -1.18195117e-01f, -1.59429517e-02f, -1.08840980e-01f, -1.96914524e-01f, -5.99537939e-02f, -1.35796070e-01f, -7.22772628e-02f, -2.02225879e-01f,
  2.02924758e-02f, 8.32348764e-02f, 1.35868669e-01f, 4.35725637e-02f, 1.87964439e-01f, 2.12514594e-01f, 2.02631906e-01f, -8.61385558e-03f, -8.13445896e-02f, -7.87907615e-02f,
  -9.32273641e-02f, -1.00838311e-01f, -1.27643511e-01f, -2.33487058e-02f, -9.02763009e-02f, 1.02451637e-01f, 2.96281613e-02f, -6.60042539e-02f, 9.80485454e-02f, 1.13549000e-02f,
  -1.02065295e-01f, -7.33129401e-03f, -5.47084352e-03f, -6.67100325e-02f, -4.64122649e-03f, -1.14250891e-01f, 2.52248142e-02f, 9.85235348e-02f, -3.06546427e-02f, -8.14655423e-02f,
  8.14078301e-02f, 7.32300878e-02f, -5.02031520e-02f, -1.03955917e-01f, 3.18503007e-02f, -5.34176687e-03f, 1.76042039e-02f, 3.22739631e-02f, 2.86316909e-02f, -9.85133555e-03f,
  -7.33550712e-02f, 9.75751784e-03f, -5.21866009e-02f, -1.84927844e-02f, 8.52431431e-02f, -1.95727106e-02f, 8.21003504e-03f, -1.03800055e-02f, -5.55975139e-02f, 6.21920563e-02f,
  4.40852866e-02f, 3.13532948e-02f, -1.47641255e-02f, 5.06807640e-02f, -2.56682429e-02f, -4.71552983e-02f, 1.01111010e-01f, 9.03960168e-02f, -6.54384717e-02f, -1.04814596e-01f,
  -6.32518232e-02f, -5.42889200e-02f, -6.19465783e-02f, -6.06414787e-02f, -4.13451642e-02f, -1.28064305e-02f, 5.22696376e-02f, 6.21427372e-02f, 1.71423387e-02f, 1.01341866e-02f,
  -1.67963486e-02f, 9.59823839e-03f, -1.97520964e-02f, 7.65447086e-03f, 2.98976470e-02f, -3.83981094e-02f, 3.19644921e-02f, 6.60387352e-02f, 2.70333290e-02f, -6.95847124e-02f,
  2.24530175e-02f, 9.39033702e-02f, 5.27324751e-02f, 7.94310272e-02f, -4.96831797e-02f, -1.21529000e-02f, 7.47035816e-02f, -7.45934760e-03f, 5.14724478e-02f, 2.72893999e-02f,
  -1.37091950e-01f, 1.91011317e-02f, -3.21443239e-03f, 3.55570726e-02f, 3.55161130e-02f, -4.71464880e-02f, 5.68088070e-02f, -1.99190360e-02f, -5.91741595e-03f, 8.50491747e-02f,
  -4.16010395e-02f, -5.11734560e-02f, -4.03549075e-02f, -2.12430991e-02f, -3.60621884e-02f, 4.88546863e-02f, 5.74255027e-02f, -8.12495947e-02f, -7.96269327e-02f, 4.00228351e-02f,
  -8.83922130e-02f, 5.26845939e-02f, -2.80684214e-02f, -5.41402660e-02f, 4.37605456e-02f, 7.62361661e-02f, 8.84034634e-02f, 8.18772316e-02f, 1.07316285e-01f, 5.84998727e-02f,
  9.99025032e-02f, 1.87585671e-02f, -1.92587648e-03f, 7.05082268e-02f, 1.39958842e-03f, 5.65012470e-02f, 1.35403331e-02f, 1.15805142e-01f, -3.69281881e-02f, -6.43825829e-02f,
  -4.97739902e-03f, 1.23964995e-01f, 8.79100561e-02f, 9.65209007e-02f, 4.32165489e-02f, 2.81770770e-02f, 4.47931886e-02f, 4.72424030e-02f, 6.74070418e-02f, 7.40269497e-02f,
  8.89262483e-02f, -3.37413978e-03f, -8.76821131e-02f, -5.81874438e-02f, -4.14354838e-02f, -5.23427241e-02f, -4.94375527e-02f, -9.35967490e-02f, 5.79787642e-02f, 1.49354842e-02f,
  6.51279539e-02f, -3.67483199e-02f, -1.74775179e-02f, -7.70745473e-03f, -1.21147543e-01f, 8.76223445e-02f, -7.33876154e-02f, -9.69350189e-02f, -4.57532890e-02f, 4.04640958e-02f,
  -2.42068246e-03f, -2.46968605e-02f, 4.32685763e-02f, -4.64813709e-02f, 3.18337157e-02f, -6.84412802e-03f, 3.32201011e-02f, 6.84755817e-02f, -4.92088422e-02f, -3.46451886e-02f,
  -1.55144241e-02f, 8.71900097e-03f, 2.08061235e-03f, -6.89776838e-02f, 6.06152639e-02f, 2.99044549e-02f, 2.15326343e-02f, -3.46660591e-03f, 6.36430979e-02f, -8.96279048e-03f,
  6.11300468e-02f, 2.73190811e-02f, -7.84753636e-03f, -2.00031232e-02f, 2.22128667e-02f, -9.40722134e-03f, 7.60285929e-02f, 6.82264045e-02f, 6.08845837e-02f, 8.02587047e-02f,
  -6.86198696e-02f, -3.95335369e-02f, -3.20771933e-02f, -9.26005691e-02f, 5.68565130e-02f, -7.06008747e-02f, 7.91699439e-02f, 7.46073052e-02f, 2.22479403e-02f, 1.88289490e-02f,
  4.09208983e-02f, -2.44294405e-02f, -8.51852596e-02f, 1.91206709e-02f, 8.30279514e-02f, 2.42922874e-03f, 6.93557560e-02f, -4.05242108e-02f, 6.41125739e-02f, 7.29887858e-02f,
  -4.13505733e-02f, 3.90433110e-02f, 5.17233200e-02f, 1.33804809e-02f, -9.73066315e-02f, -2.90321764e-02f, -9.65168923e-02f, 1.60528217e-02f, -5.66862971e-02f, 3.20004486e-02f,
  -6.51306137e-02f, 1.01125194e-02f, 2.00423282e-02f, 1.23463087e-02f, -1.77811291e-02f, -1.67332217e-02f, -1.02764100e-01f, -7.33975172e-02f, 5.77380229e-03f, -5.04008718e-02f,
  3.25606652e-02f, 2.85231043e-02f, 2.61192489e-03f, 5.39200604e-02f, 2.74091419e-02f, 1.35439839e-02f, 4.21620123e-02f, 2.65928525e-02f, 8.91142935e-02f, 1.05676679e-02f,
  -1.46261156e-01f, 8.55186675e-03f, -9.93872657e-02f, 1.03434790e-02f, 9.30613503e-02f, -4.25480753e-02f, 4.54478040e-02f, 4.63237315e-02f, -3.33212763e-02f, -6.60160854e-02f,
  4.92836684e-02f, 1.13783352e-01f, 7.07865804e-02f, 1.07007615e-01f, 1.13763213e-01f, 3.05172913e-02f, 7.76235610e-02f, 5.38550764e-02f, 5.34256920e-02f, -3.12495902e-02f,
  8.91696513e-02f, -5.54679446e-02f, -1.00537680e-01f, 2.44348720e-02f, 9.34262276e-02f, 1.10171355e-01f, -1.97867732e-02f, 6.30031675e-02f, -5.06318621e-02f, -8.16288292e-02f,
  5.40357605e-02f, -1.67070955e-01f, 6.68467805e-02f, 3.85508779e-03f, -8.68067294e-02f, 4.85229120e-02f, 1.52875129e-02f, -2.26571206e-02f, 6.72087967e-02f, -3.85334156e-02f,
  -4.31739017e-02f, 5.69880940e-02f, -5.04058599e-02f, -9.33548957e-02f, -1.10289142e-01f, -8.71197432e-02f, -2.10091081e-02f, 4.63265479e-02f, -2.67423410e-02f, -1.09704472e-02f,
  2.45647691e-02f, -6.30734786e-02f, 5.35761639e-02f, -1.88698638e-02f, -5.79650588e-02f, 5.27139492e-02f, 5.33836335e-02f, 8.35516304e-03f, -4.71154302e-02f, -7.85070062e-02f,
  -7.40435198e-02f, -7.65246302e-02f, -5.04218321e-03f, -3.76666598e-02f, 4.24964614e-02f, 8.63067061e-02f, -4.05163243e-02f, 8.50923955e-02f, -3.10716536e-02f, 6.03167620e-03f,
  -8.24068785e-02f, 3.65990922e-02f, -2.81538665e-02f, 9.47245806e-02f, 4.99660745e-02f, -9.04617757e-02f, 1.30671058e-02f, -5.97810112e-02f, -8.68429020e-02f, 5.00365999e-03f,
  6.22537993e-02f, -8.12223777e-02f, -6.85390681e-02f, 3.21503431e-02f, -5.11150807e-02f, 7.03476220e-02f, 3.11744306e-02f, 3.78372706e-02f, -4.30772034e-03f, 3.34153622e-02f,
  1.35926604e-01f, -1.25696268e-02f, 1.05282873e-01f, 3.09017915e-02f, 2.12249551e-02f, -6.86635152e-02f, 2.73177791e-02f, -1.77813098e-02f, -7.77598470e-02f, 7.17132315e-02f,
  -7.50278085e-02f, 5.45036644e-02f, 4.32397947e-02f, 4.82132100e-03f, -9.11587924e-02f, -1.15124891e-02f, -6.27920181e-02f, -3.59514952e-02f, 5.61697185e-02f, -5.20206168e-02f,
  1.52135603e-02f, -1.62906374e-03f, -1.23513676e-02f, 9.26893353e-02f, -5.82597330e-02f, 2.59769168e-02f, 7.50545114e-02f, 6.94211200e-03f, -1.65029913e-02f, -3.80519293e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 52)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 52;
const float L0_fan_Bp_bar_data[] = {
  5.53568006e-02f, 3.05974558e-02f, 2.90982872e-02f, 1.25105292e-01f, 9.56466720e-02f, 9.54472572e-02f, 1.48426935e-01f, -1.69635620e-02f, 1.98943503e-02f, 3.64361517e-02f,
  2.40765754e-02f, 1.78241193e-01f, 4.67542410e-02f, 4.89411242e-02f, 5.70994206e-02f, -4.32874188e-02f, 1.11202464e-01f, 2.07791794e-02f, 6.60758317e-02f, -1.11495163e-02f,
  6.26041368e-02f, 1.17198318e-01f, 1.09680407e-01f, 1.83869265e-02f, 7.31831975e-03f, -4.91240062e-02f, 8.83779954e-03f, 3.84424850e-02f, 4.88830591e-03f, -1.20301573e-02f,
  9.83050093e-02f, -9.14187171e-03f, 1.28809646e-01f, 3.64051647e-02f, 1.06781758e-01f, 6.85148090e-02f, 1.51224405e-01f, 1.13977402e-01f, 1.14524290e-01f, 7.77875707e-02f,
  1.00952946e-02f, -5.00934161e-02f, 6.13446012e-02f, -8.23715702e-03f, 2.42309738e-02f, -1.74955893e-02f, 1.43528655e-02f, 5.16166948e-02f, 1.61543608e-01f, 8.27204138e-02f,
  -1.97811946e-02f, -5.62700722e-03f
};

// L1_linear_W (Shape: 12 x 128)
const int L1_linear_W_rows = 12;
const int L1_linear_W_cols = 128;
const float L1_linear_W_data[] = {
  1.89889148e-02f, 6.70996234e-02f, -1.62039533e-01f, -1.25132054e-01f, -9.35961958e-03f, -1.07630007e-01f, -1.89142779e-01f, -1.29251286e-01f, -1.73929617e-01f, -1.32679716e-01f,
  -1.84035242e-01f, -5.58844879e-02f, -4.71985042e-02f, 1.27046248e-02f, -1.34286672e-01f, -1.39403597e-01f, -1.07836515e-01f, -1.89344823e-01f, -1.10509790e-01f, 7.88073763e-02f,
  -5.36289155e-01f, -3.83773595e-02f, 5.40122427e-02f, 2.50090342e-02f, -6.37076721e-02f, 3.98704633e-02f, 1.58145130e-01f, -1.82425743e-03f, -3.01166385e-01f, -2.86819726e-01f,
  -8.40894133e-02f, -6.82755038e-02f, 1.18654057e-01f, -8.40526447e-02f, -4.06210959e-01f, 1.21719733e-01f, -1.24226689e-01f, -1.74246415e-01f, -3.51555288e-01f, 5.34277484e-02f,
  -9.19062272e-02f, 9.03298035e-02f, -3.11950594e-01f, 2.37164080e-01f, -1.07401326e-01f, 6.04048036e-02f, -3.35216641e-01f, 3.05785209e-01f, 1.77354738e-01f, 2.22262070e-01f,
  1.03261888e-01f, 6.72627389e-02f, 2.60940015e-01f, -2.89639384e-01f, -1.90846130e-01f, -3.18693578e-01f, 1.09204508e-01f, 2.03977287e-01f, 3.03676039e-01f, -1.46698222e-01f,
  1.16544245e-02f, 8.59410837e-02f, -1.42339692e-01f, -1.28295168e-01f, 5.46850339e-02f, 1.67447448e-01f, 3.86852056e-01f, 1.79920450e-01f, -3.32906365e-01f, -1.37731701e-01f,
  1.01446345e-01f, -1.08498864e-01f, -7.34997541e-02f, 2.07797870e-01f, 2.28993073e-01f, -3.35833341e-01f, 5.31619430e-01f, 2.90553451e-01f, -4.43475321e-02f, -8.61443132e-02f,
  4.48445324e-03f, -6.77105114e-02f, -1.07199289e-01f, 6.21309988e-02f, 3.65168005e-01f, 1.20771769e-02f, -1.49387121e-01f, -1.51564822e-01f, 1.11251421e-01f, 8.25444460e-02f,
  1.81093458e-02f, 8.16098675e-02f, -1.85879115e-02f, 2.10678997e-03f, -1.48806116e-02f, 8.53077024e-02f, 1.24065280e-01f, -4.81008627e-02f, 1.95559725e-01f, -9.75236222e-02f,
  4.67158109e-02f, 2.01073155e-01f, -1.39411595e-02f, 5.05978540e-02f, -1.78889185e-02f, 1.97725236e-01f, -1.03099972e-01f, 3.47010195e-02f, -3.67267579e-02f, 2.66642898e-01f,
  -4.03008573e-02f, 4.21934575e-02f, 2.05084439e-02f, 2.03027930e-02f, 1.25620455e-01f, 1.10110641e-01f, 2.50368230e-02f, -9.42564011e-02f, 5.90427577e-01f, 3.93455569e-03f,
  3.95573117e-02f, -1.21710129e-01f, 3.97594571e-02f, -8.36189836e-03f, -1.54064566e-01f, -7.52041787e-02f, 3.26445214e-02f, 4.84138727e-02f, 1.07992835e-01f, -2.67368779e-02f,
  -5.27982116e-02f, -2.86657840e-01f, -3.04768719e-02f, 4.83376393e-03f, -3.36577892e-02f, 1.92646563e-01f, 8.69568661e-02f, -1.71126634e-01f, -2.22031280e-01f, 1.44769624e-01f,
  1.94151700e-01f, 2.27936640e-01f, 1.38836145e-01f, -1.93426728e-01f, 3.87195982e-02f, -2.83285771e-02f, -2.80733071e-02f, 2.01709390e-01f, 9.40994173e-02f, 1.02336958e-01f,
  -1.07231908e-01f, 9.35414732e-02f, 2.32036844e-01f, 8.70562866e-02f, 9.91036594e-02f, 1.14307366e-01f, -2.08796352e-01f, 1.19777143e-01f, -2.10665390e-01f, 2.14399710e-01f,
  -1.47022501e-01f, -3.73140931e-01f, -2.91606039e-01f, 7.54192993e-02f, 1.15460329e-01f, 9.31001678e-02f, -3.01548123e-01f, -3.56011748e-01f, -2.61006132e-03f, 3.36037695e-01f,
  -8.46344978e-02f, -7.51264915e-02f, -1.02400303e-01f, 1.10985897e-01f, -2.57290192e-02f, 4.91538316e-01f, -8.22478067e-03f, -4.55784112e-01f, -3.56144011e-01f, -2.15971451e-02f,
  -1.17707506e-01f, -3.25672537e-01f, 3.16828281e-01f, -2.15714127e-01f, 3.02019238e-01f, -1.66966647e-01f, 4.13250804e-01f, 1.12600923e-01f, -3.94148193e-02f, -5.57493344e-02f,
  1.99037001e-01f, 1.89831913e-01f, -3.92248690e-01f, -4.89751190e-01f, 3.19308788e-01f, -1.58581704e-01f, -1.16385110e-01f, 1.96086392e-02f, 5.99959373e-01f, 6.01388253e-02f,
  1.19459398e-01f, 3.77307355e-01f, 2.94343352e-01f, -2.09447861e-01f, 1.92766804e-02f, 2.83151209e-01f, -9.21236053e-02f, 8.00727457e-02f, -6.11321107e-02f, -1.58204660e-01f,
  -1.31469876e-01f, 2.27427810e-01f, -2.70851310e-02f, 2.75179803e-01f, 2.61484925e-02f, 2.38323092e-01f, 2.05568052e-04f, 2.06958473e-01f, -1.31513216e-02f, -1.57371238e-01f,
  7.81765506e-02f, 5.07603921e-02f, -2.33198330e-01f, -1.96967423e-01f, -1.25883847e-01f, -1.52355304e-03f, -4.35200185e-02f, -1.41606033e-01f, -3.17209843e-03f, -1.09067969e-01f,
  2.36231387e-01f, -3.30184549e-02f, -1.60170376e-01f, 2.50665694e-01f, 1.30679414e-01f, -1.26366079e-01f, 1.60875380e-01f, -5.35866106e-03f, -7.61123002e-02f, 3.83105546e-01f,
  -1.10658268e-02f, 8.64053518e-02f, 3.97774540e-02f, -8.17058682e-02f, 7.53016919e-02f, -1.63488612e-02f, 1.19443938e-01f, 1.37846321e-01f, 1.80347040e-01f, 2.51340777e-01f,
  -3.60286869e-02f, -2.33041421e-01f, -2.23601148e-01f, -1.56032190e-01f, 2.25335136e-01f, 1.31314009e-01f, 1.57945286e-02f, 1.86404353e-03f, -1.69785488e-02f, 2.18989030e-01f,
  1.51875079e-01f, -6.02392033e-02f, 2.12683454e-02f, 2.20100582e-02f, -8.96255448e-02f, 1.60052329e-01f, 1.63625285e-01f, 1.18315443e-01f, -8.00102800e-02f, 1.10586368e-01f,
  1.37171820e-01f, 1.07541427e-01f, 1.20104536e-01f, 5.02726659e-02f, 9.90862548e-02f, -1.27590284e-01f, 3.73498797e-02f, 7.49963969e-02f, 2.12132037e-01f, 1.57463271e-02f,
  4.59125750e-02f, 3.91587242e-02f, 1.08731754e-01f, 1.25855908e-01f, -1.02282606e-01f, 1.72732562e-01f, 1.34261444e-01f, 1.64008096e-01f, -4.72321315e-03f, 3.34163517e-01f,
  4.36299533e-01f, 1.93496258e-03f, -2.81855524e-01f, 8.45464766e-02f, -1.39468834e-01f, -5.39227836e-02f, 1.40440151e-01f, -7.97236264e-02f, 3.48008722e-02f, 2.21075118e-01f,
  -2.77732521e-01f, -2.27852121e-01f, -6.40563071e-02f, -1.48703575e-01f, 3.40893775e-01f, -3.17279875e-01f, 4.47728306e-01f, 1.65151104e-01f, -1.34354278e-01f, -6.20818639e-04f,
  2.14825328e-02f, -3.08695406e-01f, -1.56380713e-01f, 5.21683753e-01f, 5.55871204e-02f, -2.68996477e-01f, -2.87133127e-01f, 3.05452108e-01f, -1.42342925e-01f, 3.84383172e-01f,
  -1.67853296e-01f, 4.34650667e-02f, 4.75397438e-01f, 2.80573238e-02f, 6.71768561e-03f, 2.09547058e-01f, 3.05281281e-01f, -9.36937109e-02f, -2.60701656e-01f, 1.84394181e-01f,
  4.33403879e-01f, 2.06604928e-01f, -8.37495700e-02f, -2.09881306e-01f, -8.93793777e-02f, -1.68449461e-01f, -1.58832878e-01f, -1.83783561e-01f, -1.59151703e-01f, 5.53840352e-03f,
  -3.19545553e-03f, -3.26494500e-02f, 1.69078216e-01f, -2.51856089e-01f, -3.31355236e-03f, 2.67946243e-01f, -1.21077076e-01f, 3.83733884e-02f, 1.89188480e-01f, 3.53285782e-02f,
  1.20069692e-03f, -1.57801747e-01f, -7.36488178e-02f, 2.74065793e-01f, 8.92259851e-02f, 3.50092798e-02f, 2.22230125e-02f, 1.30544649e-02f, 1.03563979e-01f, -1.63802266e-01f,
  8.33466426e-02f, -1.25275731e-01f, -1.02953792e-01f, -4.85000759e-02f, -7.40389228e-02f, -9.23781022e-02f, -1.21636987e-01f, 8.95761177e-02f, 3.02417517e-01f, -9.94534418e-03f,
  7.21897855e-02f, 1.94879323e-01f, 1.02668203e-01f, 4.66100313e-02f, -1.35873616e-01f, -1.37220338e-01f, 1.88515872e-01f, -2.11937249e-01f, -6.82433769e-02f, 6.64553940e-02f,
  -1.21423528e-01f, -6.97969273e-02f, -1.40663832e-01f, -3.20082605e-02f, 1.76699191e-01f, -8.43705907e-02f, 1.60666376e-01f, 1.95206136e-01f, 5.39343096e-02f, 1.68952256e-01f,
  -4.71150488e-01f, -1.56870261e-01f, -1.95752438e-02f, 6.84465766e-02f, 8.04700851e-02f, -4.46603805e-01f, -6.42118454e-02f, -3.24173346e-02f, -5.19532450e-02f, 6.24393485e-02f,
  -2.79850531e-02f, -1.36562958e-01f, -3.51668671e-02f, -2.13202432e-01f, 3.12176555e-01f, -1.67823471e-02f, -8.02636147e-02f, -1.07982591e-01f, 1.50445685e-01f, -3.26427221e-01f,
  -2.13390887e-02f, 7.98381492e-02f, 1.42845765e-01f, -1.36945903e-01f, 1.98764578e-01f, 3.44468914e-02f, -6.34847805e-02f, 3.18232030e-02f, -6.13696948e-02f, -1.90509076e-03f,
  1.08454376e-01f, 2.91772150e-02f, 1.67867094e-02f, 5.10413408e-01f, -1.31713241e-01f, 4.14461419e-02f, -1.36645749e-01f, -5.74556813e-02f, -4.15570676e-01f, 2.61093050e-01f,
  4.06523108e-01f, 1.25793368e-01f, 5.20286560e-02f, 1.96937665e-01f, -3.45410407e-01f, -2.20723823e-01f, 1.77421600e-01f, 1.99063346e-01f, -2.62148827e-01f, -4.52287763e-01f,
  4.15344477e-01f, 1.94794670e-01f, -3.80668730e-01f, -3.04360658e-01f, -2.13736400e-01f, 4.06376243e-01f, -1.99708100e-02f, -4.66126800e-01f, 1.51239544e-01f, 6.84147924e-02f,
  1.81342110e-01f, 1.12273201e-01f, 4.05181617e-01f, -3.58915240e-01f, -1.42740965e-01f, -1.92547962e-01f, 2.58487254e-01f, -3.22930038e-01f, 6.25232831e-02f, 3.27939421e-01f,
  1.15474083e-01f, -2.47850388e-01f, -9.20313969e-02f, -1.56069934e-01f, -6.33739755e-02f, 1.08377822e-01f, -1.88913971e-01f, -1.41787022e-01f, 6.38731197e-02f, 9.62435454e-03f,
  -7.52936080e-02f, -7.86825642e-02f, -2.47278303e-01f, -3.66427302e-02f, -2.10298020e-02f, 1.70571938e-01f, -2.67652899e-01f, 8.09266120e-02f, 9.49924663e-02f, -1.03968635e-01f,
  5.59087694e-01f, -5.05770370e-02f, -1.56748369e-02f, -1.09031042e-02f, 2.52007954e-02f, -1.17451549e-01f, -5.40386550e-02f, 3.42078246e-02f, -8.04954469e-02f, -5.17042987e-02f,
  -4.06152979e-02f, 9.12067890e-02f, 5.55505455e-02f, -1.74890548e-01f, -8.91405120e-02f, -1.00449987e-01f, -1.07953057e-01f, 8.34560469e-02f, 9.04828683e-02f, 7.36202928e-04f,
  -9.94473845e-02f, -1.35602895e-02f, 3.69921699e-02f, -1.52814453e-02f, -1.43922180e-01f, -1.70892343e-01f, -7.33473524e-02f, -2.24414915e-02f, 3.49770486e-01f, 1.50999501e-01f,
  9.38987210e-02f, -1.70328636e-02f, 4.48229052e-02f, 1.19756907e-01f, -1.33437037e-01f, -1.72777683e-01f, 1.07387990e-01f, -1.40660271e-01f, 1.56504855e-01f, 7.15909228e-02f,
  -4.05059159e-02f, 1.97383925e-01f, 1.69503037e-02f, -8.17822665e-02f, 2.32029736e-01f, -1.11396618e-01f, -8.41737818e-03f, 2.21768077e-02f, -1.16927199e-01f, 1.46935448e-01f,
  9.00626555e-02f, -2.09909052e-01f, -1.23770051e-01f, 6.22902960e-02f, 1.84331700e-01f, 8.73813331e-02f, -4.33743261e-02f, 1.17678598e-01f, -2.17698634e-01f, -4.56777960e-02f,
  8.26774985e-02f, -1.78302899e-01f, 2.42644250e-01f, 2.70917658e-02f, -2.05379829e-01f, 4.85337079e-02f, 5.49869128e-02f, -2.00328842e-01f, 6.79020360e-02f, 9.59687382e-02f,
  2.14970052e-01f, 1.27635803e-02f, -3.16933215e-01f, 2.92443275e-01f, 4.08893347e-01f, -1.50768727e-01f, -1.83567971e-01f, -1.23647209e-02f, -9.58747976e-03f, -1.02873944e-01f,
  2.04355225e-01f, 1.74825728e-01f, 1.91825643e-01f, 2.76976854e-01f, 7.18165487e-02f, 3.82111937e-01f, 1.32074237e-01f, 1.96357116e-01f, -2.08231807e-01f, 2.94857714e-02f,
  1.16648957e-01f, 1.73290551e-01f, 3.99962068e-02f, 5.46707809e-02f, -2.22798213e-01f, 1.20028630e-01f, 2.62826025e-01f, 3.63369286e-02f, -1.92077041e-01f, 2.61208385e-01f,
  -1.79675981e-01f, 1.97798699e-01f, -3.88100237e-01f, -3.96404415e-01f, 5.24854422e-01f, -3.01777750e-01f, -1.05812974e-01f, 2.47964323e-01f, 3.26058537e-01f, 3.68168554e-03f,
  -9.94117409e-02f, 1.61764205e-01f, 6.83240891e-02f, 7.04280794e-01f, 4.03182162e-03f, -3.18317041e-02f, 2.99997125e-02f, 2.19358057e-02f, 7.50376880e-02f, -8.23757425e-02f,
  1.29225522e-01f, -4.85322028e-02f, -5.94415329e-02f, -1.10570706e-01f, 1.35839090e-01f, 7.51123056e-02f, -1.02045238e-01f, -4.04813625e-02f, 2.08195075e-01f, -5.78732491e-02f,
  -1.82123154e-01f, -1.40147209e-01f, 1.11357719e-01f, 3.76485810e-02f, -8.46688822e-02f, -6.26871660e-02f, -3.30519639e-02f, -4.40867245e-02f, -2.99069341e-02f, -4.75236699e-02f,
  -9.01075602e-02f, 4.68283355e-01f, -1.77367747e-01f, -3.25781060e-03f, 9.56925284e-03f, -8.15763250e-02f, -1.81974903e-01f, 2.27841526e-01f, -3.23803648e-02f, -6.19893670e-02f,
  -3.49202976e-02f, -1.02574818e-01f, -4.70428579e-02f, 8.37931484e-02f, 8.35994706e-02f, 1.09651750e-02f, 4.33695428e-02f, -2.34915502e-02f, -8.26941654e-02f, -6.26145303e-02f,
  6.66394383e-02f, 6.70952201e-02f, 6.11688867e-02f, 2.46940345e-01f, 1.05708040e-01f, 1.18392847e-01f, 4.72809710e-02f, 5.52887358e-02f, -1.17683776e-01f, 2.50455648e-01f,
  9.29918140e-02f, 1.61304742e-01f, 1.89972579e-01f, 9.32140648e-02f, 1.28005952e-01f, -1.97908029e-01f, 1.72757939e-01f, 2.13715702e-01f, 1.89974025e-01f, 1.09624855e-01f,
  3.63392234e-02f, 2.69938763e-02f, 2.83626895e-02f, -3.95146832e-02f, 4.83788550e-02f, 2.96797715e-02f, 2.08718345e-01f, 4.97736502e-03f, 2.80910134e-01f, 1.16068825e-01f,
  -3.59878749e-01f, 1.99284270e-01f, 2.42791444e-01f, -1.64106667e-01f, 1.56420633e-01f, 9.00179371e-02f, -1.82538003e-01f, -8.64550993e-02f, 2.20567390e-01f, -2.23695457e-01f,
  1.42217591e-01f, -1.46148011e-01f, -1.06189758e-01f, 8.17715675e-02f, 4.50616121e-01f, 5.44516966e-02f, -3.20186466e-02f, 3.37233320e-02f, 6.04618751e-02f, 3.57078999e-01f,
  -2.43081763e-01f, 5.58593608e-02f, 9.27903280e-02f, -4.52393025e-01f, -3.71373117e-01f, 1.90763965e-01f, -1.93574965e-01f, -3.27585667e-01f, 7.01970160e-02f, 1.67677984e-01f,
  -2.22124740e-01f, -1.27478272e-01f, 1.73478231e-01f, -7.76027888e-02f, -9.00107399e-02f, -2.67379045e-01f, -1.38889447e-01f, 1.26525968e-01f, -4.18961704e-01f, 3.08567524e-01f,
  -1.07029855e-01f, -3.09322655e-01f, 2.87102073e-01f, 1.62890643e-01f, -7.49147058e-01f, -3.74856740e-01f, -1.06225379e-01f, 4.40060169e-01f, 2.02559173e-01f, 3.04339975e-01f,
  1.36268631e-01f, 2.05283716e-01f, 2.78493285e-01f, 8.23957752e-03f, -5.35814390e-02f, 4.74054366e-02f, -8.51062685e-02f, -2.71451939e-03f, 1.65940642e-01f, -1.97902441e-01f,
  -6.43539056e-02f, 2.40669232e-02f, 2.99015433e-01f, -1.15804123e-02f, 6.75652847e-02f, 3.00970495e-01f, -9.04605910e-02f, -1.09234191e-01f, -1.71719622e-02f, -1.52979791e-01f,
  -4.36465554e-02f, -4.84673455e-02f, -1.15634307e-01f, -3.39483330e-03f, -3.19076818e-03f, 3.48652989e-01f, 2.79927980e-02f, -1.89602464e-01f, -2.64827162e-02f, -7.34774992e-02f,
  -7.25441873e-02f, -2.64112532e-01f, -2.10106045e-01f, -5.70959412e-02f, -1.80350821e-02f, -9.25726220e-02f, 9.37231854e-02f, -4.72184420e-02f, -8.32335372e-03f, 1.75896958e-02f,
  -1.00582778e-01f, -3.13853659e-02f, 2.36477349e-02f, -1.42370611e-01f, -9.57008079e-02f, -9.37814638e-02f, -4.67395522e-02f, -5.83552197e-02f, 9.36487764e-02f, -1.60512134e-01f,
  -5.38054183e-02f, -1.33655608e-01f, 5.25354035e-02f, 8.83897301e-03f, -2.70149447e-02f, -1.06025860e-01f, 3.64093781e-02f, -8.68055373e-02f, 2.56903976e-01f, 1.17608882e-01f,
  -2.40960464e-01f, 5.68653978e-02f, -2.47637797e-02f, 4.48402762e-02f, -1.14129931e-02f, -2.95992434e-01f, -1.01684578e-01f, 6.37191832e-02f, 1.77359924e-01f, 1.90752909e-01f,
  -2.27461562e-01f, -1.07271433e-01f, -4.66860272e-02f, -2.50140309e-01f, 2.37601280e-01f, -6.23810738e-02f, 1.31772235e-01f, 1.82310271e-03f, 2.79028833e-01f, -1.12307541e-01f,
  1.15603775e-01f, -1.62513122e-01f, -5.35963535e-01f, 1.45509124e-01f, 5.46186790e-02f, -9.55880433e-02f, 1.21910602e-01f, -4.33950126e-01f, 4.36056629e-02f, -2.54156351e-01f,
  6.58487156e-02f, -3.53602916e-01f, 2.64279306e-01f, -3.11392009e-01f, -1.76892161e-01f, -2.53078938e-01f, -1.95096970e-01f, -1.37026921e-01f, 3.52027833e-01f, 1.44617677e-01f,
  3.66057754e-01f, 4.11967486e-02f, -1.20531827e-01f, 3.86568904e-01f, -1.99991956e-01f, -2.52443731e-01f, -2.71672249e-01f, 2.75867768e-02f, 3.30960691e-01f, -4.03654814e-01f,
  -1.79852620e-01f, 5.46104610e-01f, -1.68474779e-01f, 3.03080529e-01f, -3.04942548e-01f, 3.92889697e-03f, -1.29244849e-01f, 3.32870305e-01f, 4.97094899e-01f, 3.69830400e-01f,
  -4.18968946e-01f, 2.38665030e-03f, -5.90177476e-02f, 4.19867575e-01f, -9.92128104e-02f, -1.15996517e-01f, -2.21697405e-01f, -6.92520617e-03f, -4.15603891e-02f, -4.76876274e-02f,
  -2.41484661e-02f, 1.42084599e-01f, -4.62350510e-02f, -1.25975609e-01f, 1.63208574e-01f, -1.25211686e-01f, 2.76222587e-01f, 1.83573842e-01f, 9.15990919e-02f, -6.44578859e-02f,
  -2.93893944e-02f, -5.70216104e-02f, -3.06107588e-02f, 2.41488852e-02f, -2.27966979e-01f, -3.35115381e-02f, 1.36847630e-01f, -4.44477834e-02f, 5.29182106e-02f, 6.76872432e-02f,
  -4.88540716e-02f, -1.73949704e-01f, -3.54945362e-02f, 4.75349426e-02f, -1.47278309e-01f, -2.05026232e-02f, -1.32298052e-01f, -2.22957388e-01f, 1.14619955e-01f, 1.47885559e-02f,
  4.81172130e-02f, 4.33656760e-03f, -2.44193062e-01f, -1.61263615e-01f, -5.87799288e-02f, 1.93013370e-01f, -1.56067237e-01f, -2.54203118e-02f, -2.09172502e-01f, -6.92906929e-03f,
  -2.52401590e-01f, -1.17915682e-01f, -1.67024329e-01f, -5.85486591e-02f, 5.64509816e-02f, -1.38609305e-01f, -1.13092456e-02f, -1.61402851e-01f, -2.11585119e-01f, -2.11360052e-01f,
  -1.64609596e-01f, -1.95302367e-02f, -3.28690782e-02f, 1.21986093e-02f, -9.81559715e-05f, -6.87132180e-02f, -3.47582728e-01f, -1.03151929e-02f, -6.06642142e-02f, 4.58926596e-02f,
  -1.54109001e-01f, 2.02640686e-02f, -2.45756432e-01f, 7.19729140e-02f, -2.26080958e-02f, -5.83527163e-02f, 1.96427274e-02f, -6.28785649e-03f, 1.16743736e-01f, 1.82427112e-02f,
  -6.28726780e-02f, -1.29333809e-01f, -1.41306132e-01f, -5.55694960e-02f, 3.52000482e-02f, 9.68229994e-02f, -4.87285912e-01f, -6.74354136e-02f, 7.72198066e-02f, -4.26318049e-02f,
  -2.02433348e-01f, 7.81863779e-02f, 4.19820455e-04f, -7.70184547e-02f, 1.51289448e-01f, 3.43490452e-01f, 2.83214450e-01f, -1.69132546e-01f, 1.75457105e-01f, 2.84465373e-01f,
  1.20535791e-01f, -9.69813615e-02f, 1.57452419e-01f, -2.57398099e-01f, -2.26061434e-01f, 3.73820603e-01f, 1.23540573e-01f, -7.89509937e-02f, -1.79349706e-01f, -5.05442433e-02f,
  -3.98084551e-01f, -1.61534950e-01f, -7.85271302e-02f, 8.91639441e-02f, -2.96465337e-01f, -2.00282469e-01f, 1.09303147e-01f, 8.98051187e-02f, -4.05846164e-03f, -2.62051642e-01f,
  2.92735785e-01f, 3.73954512e-02f, 6.43502995e-02f, -5.82143180e-02f, 3.09276640e-01f, -1.21890932e-01f, 1.32636409e-02f, 3.40747535e-01f, -2.57864416e-01f, 1.14346668e-01f,
  -4.06739973e-02f, -4.14988846e-01f, -1.70197979e-01f, -1.00453354e-01f, 1.30141556e-01f, -4.78035444e-03f, 7.16999313e-03f, -1.86196849e-01f, -2.08742946e-01f, -1.43500626e-01f,
  -1.23705678e-01f, -3.22250761e-02f, -5.15425205e-02f, -1.80762522e-02f, -2.76898313e-02f, -6.17326223e-05f, 5.14781177e-02f, 6.96136802e-02f, -1.07507199e-01f, 4.79516834e-02f,
  3.68087620e-01f, -6.64321333e-02f, 1.24764681e-01f, -8.04481208e-02f, 1.19433284e-01f, 2.05063850e-01f, -9.41143036e-02f, -9.33349207e-02f, 1.55096859e-01f, 2.26492301e-01f,
  -7.77709931e-02f, -1.21804349e-01f, 2.91238815e-01f, 1.86131343e-01f, -2.22245902e-02f, -6.67209700e-02f, 3.72856716e-03f, -2.28948429e-01f, 7.99899548e-02f, -1.02535844e-01f,
  1.02708139e-01f, -8.23207498e-02f, 1.37281328e-01f, 4.90546785e-03f, -6.15411289e-02f, -2.08478317e-01f, -7.89038651e-03f, 3.95997971e-01f, 1.71306059e-01f, 1.92192301e-01f,
  2.83687472e-01f, 1.00301942e-02f, 1.59586463e-02f, 1.99412674e-01f, -4.87848409e-02f, 4.29097600e-02f, 4.00826335e-03f, 3.99111472e-02f, -2.76149996e-02f, 5.70419990e-03f,
  1.15001962e-01f, -7.45355785e-02f, 3.52624580e-02f, 9.24628228e-02f, 5.67494482e-02f, -2.80919284e-01f, 1.74547937e-02f, -1.96408316e-01f, -4.43213552e-01f, 1.53466046e-01f,
  6.17868558e-04f, -3.65427248e-02f, 1.56535998e-01f, 6.78631812e-02f, -4.46606353e-02f, 5.02803847e-02f, 1.57957464e-01f, 1.10265322e-01f, 7.47516677e-02f, -1.66851319e-02f,
  -6.72790036e-02f, 2.05950841e-01f, 1.11662457e-02f, -2.12296978e-01f, 4.41922694e-02f, -1.18436597e-01f, 1.32452682e-01f, 3.20230395e-01f, 1.29308000e-01f, -1.54112568e-02f,
  -4.93091196e-02f, 7.08818901e-03f, -2.39922971e-01f, 2.04304531e-01f, -1.02680974e-01f, -1.90856919e-01f, -2.46968821e-01f, -2.44248122e-01f, 2.02566028e-01f, -1.30729163e-02f,
  5.13360137e-04f, 1.81980222e-01f, -2.40847871e-01f, -4.90533322e-01f, -1.72954306e-01f, -3.09878558e-01f, -4.93053943e-01f, -1.79554775e-01f, 1.74680993e-01f, -2.36877516e-01f,
  -4.46886010e-02f, -3.36564183e-01f, -3.52770209e-01f, 7.96381310e-02f, -4.23083678e-02f, -3.40376124e-02f, 1.46348327e-01f, -2.59315014e-01f, -2.80414104e-01f, 9.27421749e-02f,
  -1.65217638e-01f, -3.37103665e-01f, -3.02939534e-01f, -3.57778460e-01f, 4.39574420e-02f, 1.49433106e-01f, -2.73806691e-01f, 2.47803479e-01f, -1.69260576e-01f, -2.91942090e-01f,
  -2.42178991e-01f, -9.21558514e-02f, 7.27945492e-02f, -1.16535343e-01f, -6.90379366e-02f, -2.11522058e-01f, 2.86293626e-01f, -1.15661129e-01f, -7.69126192e-02f, -3.54950689e-02f,
  9.80894342e-02f, 1.63027838e-01f, -7.25370347e-02f, -1.30735859e-01f, -1.87739447e-01f, 8.98846462e-02f, -1.27893925e-01f, -1.66460201e-01f, 1.29869739e-02f, 3.35148685e-02f,
  -1.76889688e-01f, 4.31752428e-02f, -5.96290492e-02f, 9.75365937e-03f, 7.19160065e-02f, 1.24214683e-03f, -4.99587730e-02f, 1.44717962e-01f, 3.33709687e-01f, -1.59716517e-01f,
  -4.76362109e-02f, 6.21662592e-04f, 2.33987674e-01f, -1.51962996e-01f, 3.81390154e-01f, 2.39593923e-01f, -7.38947541e-02f, 1.91105142e-01f, 4.30535860e-02f, -1.40845776e-01f,
  7.61432052e-02f, -6.43942505e-02f, -7.50274062e-02f, 5.90810403e-02f, 3.12190242e-02f, 6.82555092e-03f, -9.28094536e-02f, 7.72211850e-02f, -7.16068447e-02f, 2.57136047e-01f,
  2.39594132e-02f, -5.69180213e-02f, 1.08369090e-01f, 1.04321659e-01f, 1.42107785e-01f, 1.50857195e-01f, -8.67894143e-02f, 5.31903543e-02f, 1.11444876e-01f, -9.06767230e-03f,
  -1.21221934e-02f, -1.82840317e-01f, 4.92101498e-02f, 1.54085577e-01f, -3.05463463e-01f, -2.77952373e-01f, 8.12797546e-02f, 3.10010724e-02f, 1.77685264e-02f, -7.69389421e-02f,
  -2.79056698e-01f, 1.39126718e-01f, -1.34208784e-01f, 1.27272323e-01f, -1.20225824e-01f, -3.37709747e-02f, -3.09894025e-01f, 6.76570758e-02f, -2.75549918e-01f, 1.52970344e-01f,
  2.18691051e-01f, 3.08737922e-02f, 3.21912318e-02f, -1.66954860e-01f, -1.10688321e-01f, 2.61758357e-01f, 3.61984521e-01f, 8.20918828e-02f, 1.40071988e-01f, 2.62355804e-01f,
  6.39835596e-02f, -8.93448219e-02f, -2.26219613e-02f, 2.54130423e-01f, 2.85974562e-01f, 4.21235412e-01f, 2.08026007e-01f, -2.09332094e-01f, 1.23325445e-01f, -1.90559521e-01f,
  -1.94729581e-01f, 1.35271564e-01f, 4.66273278e-01f, 3.64417672e-01f, 5.01603410e-02f, 2.13266790e-01f, 4.02143776e-01f, 3.80562246e-01f, -3.85695666e-01f, 1.30708277e-01f,
  5.65153360e-01f, 3.03035289e-01f, 3.41947138e-01f, -3.36373091e-01f, -3.40229481e-01f, 1.33891568e-01f, 4.97547060e-01f, 1.90912411e-01f, -4.29624915e-02f, 1.54851004e-01f,
  1.98456138e-01f, 2.97199786e-01f, -6.24776185e-01f, 1.71982259e-01f, -1.18899634e-02f, -2.93700218e-01f, 2.13201687e-01f, -1.68089047e-01f, 2.29040571e-02f, -5.99554740e-04f,
  -1.69766080e-02f, -7.98899755e-02f, -2.39330865e-02f, -8.70972872e-02f, 8.32459033e-02f, 4.54967618e-02f, -1.93922315e-02f, -1.01948038e-01f, -6.75447062e-02f, 9.44570005e-02f,
  9.40499157e-02f, 2.10394058e-02f, 1.29904002e-01f, 1.50814038e-02f, -1.96130395e-01f, 9.91591439e-03f, -1.04874089e-01f, -6.39810562e-02f, -1.02737568e-01f, -6.44637421e-02f,
  6.97937012e-02f, 2.55739205e-02f, -1.22435451e-01f, 1.38184458e-01f, -7.47004375e-02f, -1.56625420e-01f, -6.52734265e-02f, 3.55891660e-02f, -1.37277961e-01f, 4.50881459e-02f,
  -9.46375281e-02f, -6.94404840e-02f, 3.88816856e-02f, -4.28920612e-03f, -8.55680704e-02f, -1.62643746e-01f, 2.58359518e-02f, 1.56458989e-01f, 1.00963833e-02f, -1.07595176e-01f,
  1.06734231e-01f, 2.96173636e-02f, 4.17156547e-01f, 2.87689697e-02f, 2.18984321e-01f, -1.43636728e-03f, 5.40061407e-02f, -9.50334519e-02f, -6.98266029e-02f, -1.82474069e-02f,
  -2.56427765e-01f, -7.82784969e-02f, 1.41027579e-02f, 1.94356646e-02f, 3.68401818e-02f, -2.10924889e-03f, 2.13064894e-01f, 8.46439674e-02f, -5.81890605e-02f, 9.32240114e-03f,
  2.13074446e-01f, 2.29860485e-01f, -1.17736841e-02f, 3.69543470e-02f, 1.67605072e-01f, 1.64982587e-01f, -1.62323415e-01f, 1.22105576e-01f, 5.25691509e-02f, 1.01946518e-01f,
  1.28565356e-01f, -1.56769395e-01f, -1.86835945e-01f, -4.37633358e-02f, -5.10083996e-02f, 2.39563864e-02f, -7.86090121e-02f, -3.57313931e-01f, 1.20541468e-01f, 1.75465420e-01f,
  2.04544693e-01f, -1.06857471e-01f, -1.09617747e-02f, -1.41126797e-01f, 6.52868375e-02f, -1.80133164e-01f, 7.99270868e-02f, -2.62260083e-02f, 4.67769116e-01f, 2.84331769e-01f,
  -8.67643654e-02f, 9.32427719e-02f, -2.54079372e-01f, -3.10270730e-02f, 9.90345478e-02f, 1.29996715e-02f, -8.69709775e-02f, -1.89065393e-02f, -1.11734599e-01f, 1.30989596e-01f,
  -2.53790975e-01f, -2.06754684e-01f, -2.05639079e-01f, -6.12680428e-02f, 3.33414555e-01f, 1.02584071e-01f, 2.60538369e-01f, 1.87174067e-01f, -3.89762707e-02f, 4.44901615e-01f,
  -3.42779607e-01f, -3.35753024e-01f, 3.06712151e-01f, -6.37011416e-03f, -4.11831647e-01f, -4.30933535e-01f, 8.91875550e-02f, -8.86887312e-02f, 2.49720722e-01f, -4.45850223e-01f,
  -2.51709163e-01f, -2.21909761e-01f, 3.25892478e-01f, -3.94030213e-01f, -3.10258735e-02f, 2.12318957e-01f, -1.52920380e-01f, -2.11445078e-01f, 1.12455174e-01f, 1.18833192e-01f,
  4.79361750e-02f, 1.96690466e-02f, -1.57034010e-01f, -9.60400552e-02f, -8.17174464e-02f, 3.60792577e-02f, 1.81253739e-02f, -2.22924262e-01f, -1.61520958e-01f, -3.95954810e-02f,
  -6.14405237e-02f, 1.45693138e-01f, -9.85359773e-02f, -1.24659032e-01f, -1.23142228e-01f, -2.13306457e-01f, -4.97254496e-03f, 1.28103197e-01f, 7.79877836e-03f, -1.70898691e-01f,
  1.23838387e-01f, 6.37494633e-03f, -4.80797514e-02f, 1.22915842e-01f, -1.38997110e-02f, -7.83667490e-02f, -1.49960309e-01f, 2.36482352e-01f, 3.56866717e-02f, -1.29593879e-01f,
  -1.27157360e-01f, -3.50370305e-03f, 3.24172884e-01f, -3.18080140e-03f, 3.65923196e-01f, -4.12986241e-02f, -6.50775582e-02f, -2.07050461e-02f, -5.22437617e-02f, -1.39969848e-02f,
  -8.16652030e-02f, -6.86311722e-02f, 5.66863269e-02f, 2.16568470e-01f, -8.62538256e-03f, 2.49318853e-02f, 2.10299846e-02f, 1.89772159e-01f, 9.37729627e-02f, -9.78629757e-03f,
  -2.31666770e-02f, 4.19469364e-02f, -4.59951386e-02f, -5.70639968e-02f, -2.37248596e-02f, 1.34177417e-01f, -4.76492494e-02f, 1.70263037e-01f, 4.05516662e-03f, 7.43920431e-02f,
  2.26741731e-01f, 5.47178872e-02f, 1.24378815e-01f, -1.56132415e-01f, 1.22616261e-01f, -7.36324787e-02f, 3.69223803e-02f, -6.83647543e-02f, -5.57142310e-02f, -6.97018653e-02f,
  1.43438522e-02f, -1.25107532e-02f, 9.72941816e-02f, 1.45472884e-01f, 1.28143162e-01f, 2.41330266e-02f, -4.38108444e-01f, 1.00933701e-01f, 5.66835366e-02f, 1.36078507e-01f,
  2.74207350e-02f, -2.46995494e-01f, 8.57977644e-02f, 4.13321331e-02f, 8.86374041e-02f, -1.77830547e-01f, -1.38019934e-01f, 5.13994955e-02f, -1.75547406e-01f, 1.31443620e-01f,
  2.60697305e-01f, -3.54816139e-01f, 2.91716540e-03f, 2.61370748e-01f, 7.59779885e-02f, -9.88503247e-02f, -4.33541127e-02f, -1.20941579e-01f, -1.00107715e-01f, 1.35728106e-01f,
  8.08561966e-02f, 4.71234679e-01f, -3.45591940e-02f, 2.53976554e-01f, 1.46258384e-01f, -2.22634286e-01f, -4.29931492e-01f, -4.02482748e-01f, 2.11542085e-01f, 3.67929459e-01f,
  3.55283350e-01f, -1.47871543e-02f, 1.63808599e-01f, 1.83683619e-01f, -5.12873769e-01f, 1.55330561e-02f, 1.09195285e-01f, 2.31282925e-03f, -8.19555968e-02f, 3.00846070e-01f,
  -2.18010381e-01f, 4.44737934e-02f, -2.91696619e-02f, 5.27660549e-01f, -1.69779900e-02f, -1.35172203e-01f, 4.32604626e-02f, -1.23605855e-01f, 2.09487062e-02f, 2.66151298e-02f,
  1.86665386e-01f, 8.01588148e-02f, 1.80653587e-01f, -4.52651493e-02f, -1.57182112e-01f, 3.00615668e-01f, -1.21136032e-01f, -2.20963687e-01f, -1.19482428e-01f, 4.11992334e-03f,
  -1.41045794e-01f, 1.99509919e-01f, -1.79424793e-01f, 5.72301075e-02f, 2.30267774e-02f, -8.13884512e-02f, -1.15449004e-01f, 2.64364719e-01f, -1.00910682e-02f, 5.00769056e-02f,
  -6.41859919e-02f, -7.60629401e-02f, -8.84165242e-02f, -6.87720478e-02f, -1.05261631e-01f, -4.14668769e-02f, 2.37295344e-01f, -2.21522823e-02f, 2.62677763e-02f, 2.14402840e-01f,
  -1.91141784e-01f, -4.24051806e-02f, -1.18644200e-01f, -4.39063944e-02f, 1.36892200e-01f, 3.24495912e-01f, -1.92096040e-01f, 4.30050731e-01f, -1.74862489e-01f, 1.99544523e-02f,
  -4.01561633e-02f, -1.11993358e-01f, 3.49213570e-01f, 2.86437482e-01f, -6.43837899e-02f, -1.95212305e-01f
};

// L1_linear_B (Shape: 1 x 12)
const int L1_linear_B_rows = 1;
const int L1_linear_B_cols = 12;
const float L1_linear_B_data[] = {
  -1.71865016e-04f, 9.59548876e-02f, -7.98029378e-02f, 3.96330133e-02f, -8.88084248e-02f, 2.16641910e-02f, -4.37925272e-02f, 5.99008240e-02f, 2.01212391e-02f, -6.47053076e-03f,
  4.17293794e-02f, 3.37308720e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 38, 52
    );
    
    // Camada 1: L1_linear
    linear_forward_pgm(
        buffer1, x_out,
        L1_linear_W_data, L1_linear_B_data,
        128, 12
    );
    }
    