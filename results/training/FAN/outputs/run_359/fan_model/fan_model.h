/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 128 (x2)
    * Saída: 12
    * Buffer Máx: 128
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 128;
    const int FAN_MAX_BUFFER_SIZE = 128;

    // --- Funções de Ativação ---
    static inline float fan_activation(float x) { return x; }

    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 51 x 120)
const int L0_fan_Wp_rows = 51;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  1.85862660e-01f, 7.66334822e-03f, -1.02339625e-01f, 1.38366193e-01f, -3.90938185e-02f, -3.86147783e-03f, 4.30546813e-02f, -8.02355185e-02f, 1.43396882e-02f, -1.75244100e-02f,
  -5.77166118e-03f, 1.24505222e-01f, -2.93111540e-02f, -3.86071228e-03f, 7.74717331e-02f, -1.39542162e-01f, 1.64256603e-01f, 1.30363613e-01f, -1.02373816e-01f, 6.95278347e-02f,
  -6.32336810e-02f, -5.74784633e-03f, -1.81403071e-01f, -1.36225060e-01f, 1.07490361e-01f, -1.12669542e-02f, -9.44111347e-02f, -2.07495064e-01f, 1.02700137e-01f, -2.01151166e-02f,
  1.53712764e-01f, 4.42297943e-02f, -1.77951828e-02f, 8.75592530e-02f, -3.45325209e-02f, -1.19897602e-02f, -5.15076704e-02f, -5.07456549e-02f, -3.48393433e-02f, -3.27695720e-02f,
  8.10413137e-02f, -7.54692852e-02f, 3.64080369e-02f, -4.63073961e-02f, 2.79910211e-02f, -8.99467617e-02f, 1.02320435e-02f, 3.13820429e-02f, 7.66735002e-02f, -7.83175156e-02f,
  -9.62357521e-02f, 4.12509814e-02f, -1.35968523e-02f, 4.63250577e-02f, 2.63040606e-02f, 4.16878462e-02f, 2.41922010e-02f, 5.36949411e-02f, 3.54887359e-02f, 6.60996092e-03f,
  -6.05013445e-02f, -5.11144586e-02f, -3.49363275e-02f, -5.79938442e-02f, 4.30907905e-02f, 7.25757796e-03f, -3.29101533e-02f, 6.37625158e-02f, -6.87357262e-02f, 6.30108267e-02f,
  -2.08334532e-02f, 7.11591616e-02f, 2.69449931e-02f, -4.35523763e-02f, 2.54169479e-02f, 9.29459780e-02f, 8.26645121e-02f, 8.40120018e-02f, -3.58360377e-03f, -1.16752731e-02f,
  5.59522025e-02f, 8.25989172e-02f, 3.52977067e-02f, 3.13140117e-02f, 3.83869857e-02f, 1.64608303e-02f, -2.99782399e-02f, 4.92710844e-02f, 7.30590522e-02f, -1.35391075e-02f,
  9.14158076e-02f, -7.22877905e-02f, 1.27372304e-02f, 9.82254669e-02f, -1.70047488e-02f, -5.57610802e-02f, -7.55597651e-02f, 2.97325011e-02f, 1.69789083e-02f, 3.37524749e-02f,
  1.15303826e-02f, 8.94232932e-03f, 7.31460974e-02f, 7.47544169e-02f, -8.17158073e-03f, -1.00627067e-02f, -2.21482967e-03f, -5.08609414e-03f, 6.19631447e-02f, -7.72791579e-02f,
  4.26441208e-02f, -2.33043898e-02f, -5.34608215e-02f, 3.73370131e-03f, -5.08783162e-02f, -1.48328021e-02f, -3.10687646e-02f, -5.59258349e-02f, -7.78843164e-02f, 1.96530810e-03f,
  -1.53957671e-02f, 1.04584239e-01f, -9.72368568e-02f, 1.88652799e-02f, -3.55431214e-02f, -2.29608100e-02f, -9.48796943e-02f, -2.34241392e-02f, -1.49943575e-01f, 1.89513430e-01f,
  1.51224166e-01f, -5.97238801e-02f, 2.97342218e-03f, -5.37301786e-02f, -2.43030712e-01f, -9.19455588e-02f, -1.64594844e-01f, -8.01608860e-02f, -1.17647797e-01f, 5.71056642e-02f,
  -1.20975815e-01f, 1.21834755e-01f, -1.01547137e-01f, 2.05811530e-01f, 7.00713322e-02f, 7.85229504e-02f, 1.91284433e-01f, 6.28143921e-02f, 1.67656884e-01f, 6.09668866e-02f,
  3.60461883e-02f, 9.64339972e-02f, 1.35959350e-02f, -3.84705476e-02f, 6.87586889e-02f, 1.00124218e-01f, 4.81315702e-02f, -3.46519612e-02f, 7.69758523e-02f, -2.07921434e-02f,
  6.86704516e-02f, 2.35992316e-02f, 5.00386618e-02f, 7.51062259e-02f, -2.39200462e-02f, -2.41227821e-02f, -1.17581310e-02f, 2.97266478e-03f, -6.36262447e-02f, 3.36530022e-02f,
  2.62150262e-02f, -6.07839599e-02f, -6.54714555e-02f, 6.07827976e-02f, 1.86559334e-02f, 2.19740719e-02f, -7.07533881e-02f, -4.92488146e-02f, 3.17878351e-02f, 4.90000919e-02f,
  3.39986309e-02f, 1.98164266e-02f, 8.63218457e-02f, 8.03946182e-02f, 3.50326271e-04f, -1.94395948e-02f, 8.01420510e-02f, -1.43871072e-03f, -6.06382824e-02f, 7.04958215e-02f,
  -1.39787775e-02f, 7.24965036e-02f, -2.15351265e-02f, 1.29466653e-02f, -1.49686297e-03f, 2.19621640e-02f, 2.47493014e-02f, 5.93272299e-02f, -2.12953775e-03f, -3.26742344e-02f,
  -1.46717373e-02f, -1.56286149e-03f, -2.05452628e-02f, 1.06962539e-01f, 2.60187872e-02f, -2.25811377e-02f, 4.11569923e-02f, -3.97534706e-02f, 3.02753113e-02f, -7.11439252e-02f,
  1.24104568e-04f, 1.37693375e-01f, -1.23011833e-02f, -2.24617366e-02f, 4.28985283e-02f, -4.49446589e-02f, -7.45294914e-02f, 4.65265103e-02f, -2.31057983e-02f, 7.88044278e-03f,
  -4.06818576e-02f, -1.38516463e-02f, 4.00903225e-02f, -1.85030606e-02f, 4.07739878e-02f, 6.12004250e-02f, 5.69123402e-02f, -4.93545197e-02f, -7.79392570e-03f, 2.78553832e-03f,
  8.49252939e-02f, -6.06033355e-02f, -3.13660465e-02f, 9.12468061e-02f, 1.14102982e-01f, 2.49494687e-02f, 7.48984814e-02f, -5.45456260e-02f, 7.22167268e-02f, -3.29116508e-02f,
  -2.36368716e-01f, 2.69168347e-01f, -9.15105492e-02f, -6.04868382e-02f, 7.96791837e-02f, -1.46172926e-01f, -2.39076633e-02f, 1.20418041e-03f, 3.56970988e-02f, 2.80895948e-01f,
  6.54141977e-02f, 6.35076687e-02f, 1.01245917e-01f, 1.00103691e-02f, -5.90745211e-02f, -4.83035482e-03f, 9.95827094e-02f, 2.53972020e-02f, 1.39643401e-02f, 1.50494412e-01f,
  -7.22511187e-02f, 1.52948126e-01f, -3.67153622e-02f, 1.37999967e-01f, 5.98957054e-02f, -4.38479930e-02f, 7.32537583e-02f, -3.34511660e-02f, 9.75085609e-03f, -1.52014541e-02f,
  -1.22162811e-01f, -3.86041217e-02f, -7.73076043e-02f, -1.30099609e-01f, -2.91105341e-02f, -1.21565513e-01f, -2.08387338e-02f, -5.01784086e-02f, 3.68831083e-02f, -3.88141870e-02f,
  -9.49244872e-02f, -6.71110675e-02f, -8.29318166e-02f, 4.41170856e-02f, 7.15002343e-02f, -6.56955615e-02f, 3.04137636e-02f, -7.38750026e-02f, 3.97260673e-02f, -7.65689611e-02f,
  -8.14373121e-02f, -6.58656284e-02f, -2.42978018e-02f, 6.49326071e-02f, -2.27466896e-02f, 4.56020646e-02f, 1.31129045e-02f, -3.09518147e-02f, 1.55976638e-02f, 3.18550877e-02f,
  -4.15177979e-02f, -3.10349669e-02f, 9.66479350e-03f, -3.12847644e-02f, 3.45079340e-02f, -6.40084445e-02f, 1.29393609e-02f, 4.65297364e-02f, -1.53572159e-02f, 1.42527150e-03f,
  -2.62844190e-03f, -3.20898816e-02f, -2.67589930e-02f, 2.28725243e-02f, 4.23090011e-02f, -4.07928377e-02f, -1.99972671e-02f, 9.95502342e-03f, 6.77269930e-03f, -8.62811878e-02f,
  4.47770115e-03f, 3.26877944e-02f, 1.95677802e-02f, -9.78079438e-02f, -5.34879882e-03f, -2.97692288e-02f, 5.22085838e-02f, 4.83565265e-03f, 4.42236476e-02f, 5.02365045e-02f,
  1.29450873e-01f, 2.47199908e-01f, -5.47896884e-02f, 1.77883301e-02f, -6.12855479e-02f, 5.04704658e-03f, -7.34483600e-02f, -5.28869852e-02f, 4.20377143e-02f, 3.03882435e-02f,
  -2.84718256e-02f, 3.67789157e-02f, 7.98000023e-02f, 4.65085432e-02f, 6.61930367e-02f, 3.42901833e-02f, 7.44638443e-02f, -4.79375161e-02f, 2.53772065e-02f, 6.60807639e-02f,
  6.38277605e-02f, 6.96946308e-02f, -8.94719213e-02f, 1.99787691e-02f, 2.77878437e-02f, -1.92622058e-02f, 5.65966852e-02f, 3.61518143e-03f, -1.46036958e-02f, -8.78201891e-03f,
  -1.15005285e-01f, -3.24238837e-01f, -5.46219312e-02f, -1.25399306e-01f, 2.33238861e-01f, 1.09655015e-01f, 1.31944090e-01f, 9.71731693e-02f, -6.94109276e-02f, -1.87445179e-01f,
  1.14852324e-01f, -2.45849937e-01f, -1.07278131e-01f, -9.93523672e-02f, 8.10524523e-02f, -1.04561985e-01f, -6.88738525e-02f, 2.44595371e-02f, 3.03040408e-02f, 6.71874592e-03f,
  5.78620024e-02f, 9.65717733e-02f, 1.04272692e-02f, 8.26647878e-02f, 1.02622613e-01f, -3.09385266e-02f, -3.98206599e-02f, 7.38253817e-02f, 5.98736033e-02f, -1.07503748e-02f,
  1.72735713e-02f, -9.45444033e-02f, 9.01224744e-03f, -6.69632927e-02f, 5.34185283e-02f, -5.74130863e-02f, -3.78601328e-02f, -4.62618731e-02f, 1.96237713e-02f, 3.96185778e-02f,
  -4.06983793e-02f, 2.03496926e-02f, -6.65868148e-02f, 7.49228224e-02f, -6.92867907e-03f, 6.29344806e-02f, 3.70038263e-02f, 2.96504814e-02f, 4.94285375e-02f, 3.20020095e-02f,
  -1.97851304e-02f, -4.16490249e-02f, 7.10927472e-02f, -3.77198830e-02f, -6.42515859e-03f, 1.78137850e-02f, 2.16359533e-02f, -7.05158338e-02f, 4.01122160e-02f, -4.41587158e-02f,
  -2.98750540e-03f, -2.55671348e-02f, 5.96490577e-02f, 5.78833558e-02f, -6.93567097e-03f, 6.41175779e-04f, 5.05557610e-03f, 2.34886650e-02f, -4.04763743e-02f, -1.24264676e-02f,
  -3.60099711e-02f, -2.56597046e-02f, 6.56455979e-02f, -3.14755626e-02f, -5.78425601e-02f, -7.20359981e-02f, -3.23702954e-02f, -3.09612304e-02f, -2.88671325e-03f, -1.29171507e-02f,
  3.68629694e-02f, 1.17310211e-02f, 3.04496605e-02f, 9.81653389e-03f, 1.19858086e-02f, 3.17793004e-02f, 5.05541563e-02f, 3.27483900e-02f, 6.61333501e-02f, 3.38598154e-02f,
  -3.90436314e-02f, -2.15717748e-01f, 2.39269063e-02f, 7.58229867e-02f, -1.07142240e-01f, 2.42725275e-02f, -1.93874743e-02f, -1.43889915e-02f, -2.07775570e-02f, 1.94652416e-02f,
  6.91538602e-02f, -1.47973606e-03f, -3.81431952e-02f, -5.55659551e-03f, 4.39854711e-02f, -5.13484590e-02f, -7.00641051e-02f, -6.29305616e-02f, 3.02944016e-02f, -5.97098619e-02f,
  5.70861213e-02f, 1.47415709e-03f, -1.62934065e-02f, 2.09727883e-02f, 1.56393051e-02f, -2.71142460e-02f, -3.17137353e-02f, -6.14230335e-02f, 7.85807222e-02f, 6.14738208e-04f,
  1.75384320e-02f, -9.68520064e-03f, 2.86752909e-01f, 7.45177642e-02f, 9.62531120e-02f, -1.11815661e-01f, 1.33541983e-03f, 8.96351691e-03f, 1.03908703e-01f, -1.20687753e-01f,
  -1.95242614e-01f, 7.33302981e-02f, -1.77576900e-01f, 3.00103128e-02f, 9.60112289e-02f, -1.01383775e-01f, -5.22550456e-02f, -2.58843824e-02f, 4.49684970e-02f, 4.88090850e-02f,
  1.51923196e-02f, -1.73657313e-01f, 5.10799177e-02f, 4.42147329e-02f, 1.04290433e-02f, 8.04638639e-02f, -6.64663538e-02f, 8.76029059e-02f, -2.53847465e-02f, -6.35916218e-02f,
  6.74994662e-02f, 1.60076786e-02f, 9.52746347e-03f, 4.79090661e-02f, -8.10304955e-02f, -2.45285966e-02f, 7.15766475e-02f, 5.66754751e-02f, 7.21282437e-02f, -8.41012038e-03f,
  -4.93800156e-02f, 3.52136604e-02f, 2.04030015e-02f, 4.71877120e-02f, 9.11372229e-02f, 7.10486248e-02f, 1.03515454e-01f, 3.37226428e-02f, 1.14703707e-01f, 7.67481476e-02f,
  1.00005887e-01f, 6.44844472e-02f, 4.67096157e-02f, 5.66935986e-02f, 4.92630675e-02f, 2.96995547e-02f, 1.96418818e-02f, -6.03593960e-02f, -2.68895011e-02f, 7.16084689e-02f,
  -3.81806446e-03f, -3.43471728e-02f, -8.71518627e-03f, -3.01759616e-02f, -1.28586581e-02f, 7.05623906e-03f, -9.37954430e-03f, -7.19104186e-02f, -2.10773852e-03f, -2.71104630e-02f,
  -7.36399591e-02f, 5.57712875e-02f, -5.49139548e-03f, 3.59254554e-02f, -5.79884723e-02f, -1.14174737e-02f, 1.60295777e-02f, -5.23497723e-02f, 8.33633542e-03f, 1.20321577e-02f,
  -5.44869266e-02f, 7.03976452e-02f, 4.51257005e-02f, -3.27169821e-02f, -6.42983690e-02f, 5.61500750e-02f, 9.64008942e-02f, 4.83668633e-02f, 2.74864417e-02f, 1.13245593e-02f,
  -1.84933215e-01f, -1.94558933e-01f, 4.77284752e-02f, -2.56154146e-02f, -4.71625030e-02f, -2.11799052e-02f, 1.37912072e-02f, 5.63259125e-02f, -7.07813203e-02f, -1.69031229e-02f,
  -4.23182659e-02f, -2.73377839e-02f, 3.60167809e-02f, -6.46654889e-02f, -3.77957360e-03f, -3.97608429e-03f, -4.25363481e-02f, -7.03732520e-02f, -2.82526072e-02f, -2.95255482e-02f,
  2.43954058e-03f, -7.53535479e-02f, 1.97700653e-02f, -7.37332925e-02f, -7.69410133e-02f, 1.21604074e-02f, -4.25243080e-02f, 5.17686754e-02f, 1.77537207e-03f, 6.75895140e-02f,
  3.72635663e-01f, -1.46112949e-01f, -2.22404394e-02f, 8.17153156e-02f, 1.56624746e-02f, 1.21385213e-02f, 8.77728760e-02f, -1.51160702e-01f, 7.67564401e-02f, -1.12700164e-01f,
  -8.28658976e-03f, 1.87190458e-01f, -5.54044545e-03f, 3.68335284e-02f, 2.59225279e-01f, 9.40940008e-02f, 6.62446767e-02f, 2.21390110e-02f, -9.89137776e-03f, 7.29541853e-02f,
  4.58683223e-02f, -7.86431581e-02f, -1.74976178e-02f, -2.48360217e-01f, -1.58261368e-03f, -6.76634088e-02f, -8.77465308e-02f, -5.29805955e-04f, -1.06050456e-02f, 2.79933717e-02f,
  -2.93345209e-02f, -2.14371625e-02f, -6.64624721e-02f, -1.16790310e-01f, -2.63104439e-02f, 6.45099878e-02f, 5.13424389e-02f, 3.35646197e-02f, -5.83712710e-03f, -2.11080536e-02f,
  -8.76065623e-03f, 1.36844739e-02f, -6.64130896e-02f, 9.26724728e-03f, -4.29877825e-02f, -4.75524999e-02f, -5.06379753e-02f, 1.98472980e-02f, -7.90952817e-02f, 3.97907235e-02f,
  4.09961566e-02f, -8.84341300e-02f, 2.68050823e-02f, 3.74027677e-02f, 2.22641099e-02f, -3.99831170e-03f, -3.28913890e-02f, 6.91989087e-04f, -6.45885617e-02f, 1.47710380e-03f,
  5.58980333e-04f, -6.75262883e-03f, 3.45996656e-02f, 1.69769209e-02f, 3.99136581e-02f, 5.73883764e-02f, -1.86007973e-02f, 5.30246310e-02f, 1.13360807e-02f, 5.83318844e-02f,
  -1.32908858e-02f, -4.21168506e-02f, -1.22472970e-02f, 4.81624641e-02f, -1.64759420e-02f, -2.72939535e-04f, 6.11565262e-02f, 1.28258411e-02f, 2.84145400e-02f, 2.95416918e-02f,
  1.23980818e-02f, 4.05886732e-02f, 2.60703824e-02f, -5.50788222e-03f, -2.19122809e-03f, 6.51153401e-02f, -2.92734187e-02f, -2.48505827e-02f, -1.43646020e-02f, 2.66410764e-02f,
  -7.92659149e-02f, 4.87617962e-03f, 2.87429662e-03f, 6.10500276e-02f, 3.50029022e-03f, -4.75959964e-02f, -5.69456033e-02f, -3.23702767e-02f, -4.56928574e-02f, 5.45940623e-02f,
  -3.75416838e-02f, 5.85144795e-02f, 4.64878306e-02f, -4.05226126e-02f, -2.61411425e-02f, 2.96892934e-02f, 7.83931836e-02f, -4.80891354e-02f, -1.90702034e-04f, -1.07801789e-02f,
  -3.67175639e-02f, 8.74088928e-02f, 1.80399660e-02f, -7.43738264e-02f, -1.26680220e-02f, -4.59651696e-03f, 3.84395756e-02f, 3.95126939e-02f, 6.25322163e-02f, -4.50052172e-02f,
  3.09491515e-01f, 4.01314683e-02f, 5.17220795e-03f, 1.28905222e-01f, 6.18932471e-02f, 1.47674263e-01f, 1.02819405e-01f, 8.34827125e-02f, -5.93334548e-02f, 9.88760293e-02f,
  6.73931167e-02f, 1.30991250e-01f, -1.19327314e-01f, 8.86157062e-03f, -2.11857006e-01f, -1.20500423e-01f, 7.44302124e-02f, 9.81625617e-02f, -9.42261294e-02f, 1.03998728e-01f,
  2.34974362e-02f, -1.06185541e-01f, -1.19795986e-01f, -1.25509813e-01f, 1.61533803e-01f, 1.27838641e-01f, 2.24450082e-02f, -8.34017321e-02f, 1.24734633e-01f, -3.13148275e-02f,
  -1.68762933e-02f, -1.71507597e-02f, -1.65638572e-03f, -8.07112455e-02f, 1.98589638e-02f, 6.90956935e-02f, 8.80517885e-02f, -5.58369532e-02f, 1.83214936e-02f, -1.59320887e-02f,
  9.48003829e-02f, 4.54784147e-02f, 3.97995561e-02f, -7.97862560e-02f, 6.87375888e-02f, -2.11300235e-02f, -2.50134561e-02f, 4.14239317e-02f, -3.68152820e-02f, -3.72093432e-02f,
  -1.29098576e-02f, -2.73734760e-02f, -8.84196907e-03f, 4.26052846e-02f, -3.37447561e-02f, -4.08135429e-02f, 7.90705010e-02f, -5.40200882e-02f, 6.82887435e-02f, -4.48465236e-02f,
  -2.36396305e-02f, 2.30473932e-02f, -3.93456034e-02f, -7.59451762e-02f, -4.46119905e-02f, -6.88635558e-02f, 2.87415348e-02f, -1.11140925e-02f, 3.35637406e-02f, 4.67039980e-02f,
  1.19563984e-02f, 3.24884206e-02f, -4.38687466e-02f, 1.01421133e-01f, -5.37902117e-03f, -5.28782271e-02f, 1.78255513e-02f, -6.44259155e-02f, 8.87924712e-03f, -8.46902356e-02f,
  -4.07425351e-02f, 6.31428063e-02f, 3.51729654e-02f, 1.01812882e-02f, -6.13917001e-02f, -2.85985116e-02f, 2.46102177e-02f, -5.14836684e-02f, -5.61079755e-02f, -5.75568946e-03f,
  8.33177119e-02f, 1.96167286e-02f, -1.54252090e-02f, -4.12093103e-02f, 3.00571620e-02f, 1.83437523e-02f, -6.58198595e-02f, 6.08554780e-02f, 3.51931620e-03f, 4.16834056e-02f,
  3.85719948e-02f, 4.41697091e-02f, 4.24146429e-02f, -4.13452946e-02f, 3.11921965e-02f, -2.21418533e-02f, 8.67386174e-04f, 2.79162936e-02f, 1.98272523e-02f, 3.65264900e-02f,
  7.48292208e-02f, 5.16173206e-02f, 7.06629977e-02f, 3.45955379e-02f, -3.04798614e-02f, 3.62446234e-02f, -1.87527854e-02f, 5.92729487e-02f, 3.28828283e-02f, 2.88278367e-02f,
  1.07588395e-01f, -1.03530087e-01f, -1.45437583e-01f, 1.45644516e-01f, 3.77388149e-02f, -1.16104461e-01f, -4.10365947e-02f, 1.86773464e-01f, 1.81984574e-01f, 1.54469470e-02f,
  1.25676431e-02f, -5.32087013e-02f, -2.59793028e-02f, 3.32631692e-02f, -2.42358143e-03f, -4.74802516e-02f, 7.76183903e-02f, -1.02821283e-01f, 5.79158887e-02f, 9.97168347e-02f,
  7.85107091e-02f, 1.32783622e-01f, 2.97398362e-02f, 4.15658951e-02f, -5.79711562e-03f, 4.75862697e-02f, 1.56187326e-01f, -1.39531821e-01f, 2.78922194e-03f, -6.33218437e-02f,
  -2.44548805e-02f, -3.15421796e-03f, -1.00851297e-01f, 1.01691075e-02f, 8.60936269e-02f, 2.22491100e-02f, -4.21499126e-02f, -6.70473054e-02f, 6.94165379e-02f, -1.47053099e-03f,
  -8.95138308e-02f, 6.71304017e-02f, 4.02445532e-02f, -4.61902209e-02f, 4.88165393e-02f, 3.83723788e-02f, 1.51723418e-02f, -6.96427450e-02f, -4.40085195e-02f, -6.17312863e-02f,
  -3.30311945e-03f, -1.08206972e-01f, -6.43314701e-03f, 2.75309961e-02f, 3.18002887e-02f, -1.23198582e-02f, -5.90787549e-03f, 1.92332622e-02f, -5.22453338e-02f, -9.87807289e-03f,
  5.87793998e-02f, 3.88742313e-02f, 3.09001934e-02f, 8.42919648e-02f, 4.72148024e-02f, 5.01329370e-04f, -4.78034057e-02f, -3.55101265e-02f, -4.02838401e-02f, 8.83729849e-03f,
  -4.14603688e-02f, -1.75637146e-03f, 6.07390665e-02f, -4.98083495e-02f, -3.74555960e-02f, -4.36704606e-02f, -4.50101458e-02f, -4.97584902e-02f, -2.01095622e-02f, 1.27244517e-02f,
  -5.62242009e-02f, -2.14280337e-02f, 1.66236726e-03f, -6.60995916e-02f, -5.98162450e-02f, -5.01323342e-02f, -5.95338680e-02f, -4.25606817e-02f, 3.28870043e-02f, -7.61192758e-03f,
  1.38716638e-01f, 1.58015132e-01f, 6.15609773e-02f, 4.52096723e-02f, 3.38762440e-02f, 6.63903132e-02f, -8.86935443e-02f, 6.85240924e-02f, -4.71225381e-02f, -1.12785194e-02f,
  -5.77983223e-02f, -3.87976803e-02f, -1.09790236e-01f, -1.31518459e-02f, -2.42752824e-02f, -4.45169657e-02f, 9.99543667e-02f, -6.47724494e-02f, -1.93291996e-02f, 4.98675779e-02f,
  6.61757216e-02f, 6.20604306e-02f, 1.84392687e-02f, -1.40047548e-02f, 5.72338551e-02f, 1.19373333e-02f, 7.51302093e-02f, -2.99424566e-02f, -3.64006348e-02f, -4.54286039e-02f,
  -5.33748604e-02f, -1.96974948e-02f, 4.88239378e-02f, 2.35019363e-02f, 1.16751432e-01f, -2.15504188e-02f, 5.86489849e-02f, 7.08145127e-02f, 5.18677607e-02f, 6.05601184e-02f,
  -5.48009463e-02f, 8.61208141e-02f, -2.55700946e-02f, 5.09902798e-02f, -3.15030694e-01f, -2.36765832e-01f, -1.22178718e-02f, 4.04247455e-02f, -6.88697398e-03f, 3.13349850e-02f,
  -8.77548456e-02f, -6.82335570e-02f, -1.41525760e-01f, 1.26137048e-01f, 1.41507268e-01f, 7.86393732e-02f, 4.03381065e-02f, 4.52090129e-02f, 4.68802173e-03f, -7.00289384e-02f,
  4.26126942e-02f, -4.04983871e-02f, 1.59842055e-02f, 7.74755776e-02f, -3.52705531e-02f, -4.58296090e-02f, -2.90112663e-02f, 7.06610605e-02f, 1.62083060e-02f, -7.03919083e-02f,
  4.15040599e-03f, -2.74373703e-02f, 5.74791543e-02f, -8.06541964e-02f, 3.25588956e-02f, 7.37404004e-02f, 5.39660044e-02f, -2.15828735e-02f, 7.34092966e-02f, 6.15797229e-02f,
  3.79484072e-02f, 3.63112427e-02f, -1.50477923e-02f, -2.21339371e-02f, 3.56266536e-02f, 3.60417850e-02f, 5.89098632e-02f, 6.52116165e-02f, -1.43522741e-02f, 6.77387640e-02f,
  4.00506333e-03f, 3.42723131e-02f, 3.99293378e-02f, -4.14852947e-02f, 8.12211540e-03f, 4.53147255e-02f, 7.33372718e-02f, -6.60572797e-02f, -4.24962230e-02f, -9.05477908e-03f,
  2.24465467e-02f, 3.97576168e-02f, 5.68579659e-02f, 9.61433817e-03f, 3.17039490e-02f, 1.15670696e-01f, -4.80473042e-02f, 3.51338722e-02f, -5.02679404e-03f, -1.89905125e-03f,
  2.55542248e-03f, 5.32698892e-02f, 2.01415438e-02f, -3.78044392e-03f, -3.81578016e-03f, -7.65767023e-02f, -1.51810423e-03f, 7.29816034e-02f, 3.12895738e-02f, 2.12446507e-02f,
  -4.65493184e-03f, -1.05565280e-01f, 1.11432020e-02f, -1.98637191e-02f, 9.16412659e-03f, 7.11426809e-02f, -1.83642842e-02f, -1.90945137e-02f, -4.32366021e-02f, -7.06478283e-02f,
  2.99347490e-02f, 6.84801713e-02f, -2.51013488e-02f, 6.37328923e-02f, 6.80259094e-02f, -2.29033688e-03f, 3.32001001e-02f, 4.51501794e-02f, -1.49246501e-02f, -6.88033998e-02f,
  -1.66169219e-02f, -1.07154818e-04f, -1.06287133e-02f, 3.57197598e-02f, 7.25405216e-02f, 1.31689683e-02f, 6.70068115e-02f, -3.78313549e-02f, 3.91105330e-03f, 3.32191661e-02f,
  -1.05893128e-02f, -1.00087047e-01f, -1.47283405e-01f, -1.64063871e-01f, -1.54196635e-01f, 4.91568707e-02f, -1.50262180e-03f, -2.02226654e-01f, -1.19632155e-01f, 1.14993513e-01f,
  9.81964767e-02f, 9.68512595e-02f, 4.52667475e-02f, 8.47040787e-02f, 6.36629835e-02f, 8.71260688e-02f, 3.62463146e-02f, 7.52895474e-02f, -6.50295466e-02f, -7.97787756e-02f,
  -1.29526377e-01f, -3.79742198e-02f, 5.21054752e-02f, -7.87747055e-02f, -1.33836642e-01f, -6.26864582e-02f, 2.78223716e-02f, 3.21857221e-02f, -8.56583863e-02f, 9.79493558e-02f,
  -1.20647997e-01f, -5.33232614e-02f, 4.20453437e-02f, 3.24494913e-02f, -8.23127329e-02f, -1.06117884e-02f, 5.83974794e-02f, 1.34553149e-01f, -6.60183653e-02f, -7.04395697e-02f,
  -2.56274734e-02f, -9.93969515e-02f, -3.36235650e-02f, 3.91004942e-02f, 3.90053168e-02f, -7.30837062e-02f, 4.59672734e-02f, -1.01832062e-01f, 3.32964002e-03f, -8.78668204e-03f,
  6.13885894e-02f, -6.04984611e-02f, -4.19247076e-02f, -4.83765565e-02f, -9.45730433e-02f, 3.18962485e-02f, 9.51077715e-02f, 6.26469925e-02f, 1.98654011e-02f, -1.13689095e-01f,
  -3.81944887e-02f, -5.41086122e-02f, 5.78659251e-02f, -5.28802127e-02f, 8.62879530e-02f, -2.24983543e-02f, -3.51592712e-02f, 4.26420495e-02f, 1.12108653e-03f, -4.08306085e-02f,
  5.58424033e-02f, 1.79590769e-02f, -2.07068771e-02f, 4.79888581e-02f, -6.64949492e-02f, -5.03300764e-02f, 8.87864605e-02f, 3.43116955e-03f, 2.34143529e-02f, 5.40716909e-02f,
  -5.95768215e-05f, -2.97852070e-03f, -5.48464619e-03f, 7.65867829e-02f, 1.93154979e-02f, 1.09250918e-02f, -5.61034605e-02f, 6.59539178e-02f, -3.37681249e-02f, 7.76547343e-02f,
  -1.66856691e-01f, -2.37533107e-01f, -1.14399552e-01f, -3.20471339e-02f, 4.71563637e-02f, -1.74985137e-02f, -1.19588934e-02f, 4.88651507e-02f, -3.04670073e-02f, -7.73694143e-02f,
  -6.63204268e-02f, 5.86259700e-02f, -4.41801809e-02f, -2.60076262e-02f, 6.64691776e-02f, 6.65863696e-03f, -5.44619076e-02f, 1.94614213e-02f, 8.96081235e-03f, -2.59264931e-02f,
  -7.20560923e-02f, 6.81193545e-02f, 4.41262759e-02f, -1.79114621e-02f, 8.13004971e-02f, 2.62402240e-02f, 5.70667256e-03f, 3.40568158e-03f, -9.04410426e-03f, 9.06460977e-04f,
  1.24266796e-01f, -6.55615479e-02f, -5.08592241e-02f, 1.44610062e-01f, -8.79747514e-03f, -2.12585300e-01f, -2.87218630e-01f, 9.68489572e-02f, 5.81234805e-02f, -1.14395492e-01f,
  5.41915558e-02f, 1.12018578e-01f, -1.53914675e-01f, 1.43494785e-01f, -1.04635306e-01f, -1.84465647e-01f, 7.32122064e-02f, 7.03902617e-02f, -3.21327634e-02f, -2.82171126e-02f,
  9.13423374e-02f, 1.51698768e-01f, -5.53755946e-02f, 1.69810578e-01f, 1.11346833e-01f, 2.05163583e-02f, 8.44252557e-02f, -7.35371187e-02f, 1.91269219e-01f, -1.59209706e-02f,
  5.50277680e-02f, 9.64163989e-02f, -7.13924021e-02f, 4.43005562e-02f, -5.35404645e-02f, -9.13121328e-02f, 1.25725297e-02f, -1.95668880e-02f, -2.46388242e-02f, 3.13796289e-02f,
  -3.16290476e-04f, 1.15770120e-02f, 8.51986408e-02f, -8.58899876e-02f, 3.16522494e-02f, 3.02806124e-02f, -2.88976897e-02f, -7.13280067e-02f, 3.35912928e-02f, 1.60505604e-02f,
  -2.92690098e-02f, -6.95272088e-02f, 3.10846958e-02f, -2.02365220e-03f, 1.78752318e-02f, -1.41030867e-02f, -5.93533926e-02f, -1.38907274e-02f, -1.24869524e-02f, 2.10451782e-02f,
  -2.29757298e-02f, -5.14292344e-02f, 3.55248153e-02f, 8.05965811e-02f, 7.84938969e-03f, 4.60797995e-02f, -1.42725417e-02f, 3.90022248e-02f, 3.41958441e-02f, 4.09666374e-02f,
  3.69744636e-02f, 2.18535624e-02f, 7.30161816e-02f, -1.98785495e-02f, 2.67164297e-02f, 3.01381536e-02f, -7.12069273e-02f, 8.12960863e-02f, -1.86432954e-02f, 5.34176454e-03f,
  -5.61586209e-03f, -1.90521106e-02f, -1.84668473e-03f, 1.84271224e-02f, 2.14231201e-02f, 3.46533731e-02f, 6.62918538e-02f, 1.08040608e-02f, -8.77219513e-02f, -2.30412558e-02f,
  -4.47619669e-02f, 1.58282399e-01f, 2.92636007e-02f, -9.43309255e-03f, 4.74628694e-02f, 2.55151764e-02f, -7.86434561e-02f, 4.53207903e-02f, 2.28215251e-02f, 3.19118910e-02f,
  -6.60177618e-02f, -5.94207868e-02f, 3.03771328e-02f, 9.44051817e-02f, -1.69897657e-02f, -7.15348125e-02f, 2.53309384e-02f, 7.94138759e-02f, 6.95001930e-02f, 2.73572933e-02f,
  3.69451940e-02f, 7.13539869e-02f, 4.21620868e-02f, 1.65242907e-02f, 1.67356431e-02f, -1.75468642e-02f, -1.02456175e-02f, 3.68387485e-03f, 6.59836978e-02f, -6.21421263e-02f,
  1.00042209e-01f, 6.11830689e-03f, 1.53566867e-01f, -5.25941513e-02f, 3.70394252e-02f, 7.77626336e-02f, 9.51335058e-02f, 2.46966854e-02f, 2.25776479e-01f, -4.61648069e-02f,
  -1.13951795e-01f, 4.98671737e-03f, 2.34061442e-02f, -1.75430641e-01f, -1.60559922e-01f, 4.60052453e-02f, -1.95686162e-01f, -1.47205427e-01f, 7.42857158e-02f, -7.66904093e-03f,
  -1.01909630e-01f, -1.62961915e-01f, -2.00363308e-01f, -6.03009537e-02f, -1.45747876e-02f, -3.50709371e-02f, -3.18289012e-01f, -8.06867704e-02f, -9.58805829e-02f, 1.39970966e-02f,
  1.20302200e-01f, 8.44744667e-02f, 4.37601693e-02f, 2.59321872e-02f, -9.48905125e-02f, 2.16083489e-02f, -4.44938168e-02f, -9.78160836e-03f, 3.20871286e-02f, 8.64328630e-03f,
  5.11320494e-02f, -3.19777019e-02f, -1.21199549e-03f, -2.40616258e-02f, 2.86048818e-02f, 1.03078514e-01f, 8.88360315e-04f, -8.79031699e-03f, 1.48200365e-02f, 5.85691147e-02f,
  1.71861909e-02f, -1.59462430e-02f, -1.34533970e-02f, 4.02535014e-02f, -6.65384904e-02f, 6.76728459e-03f, 5.83346821e-02f, -5.92174716e-02f, -3.00042774e-03f, 2.35385075e-02f,
  -6.11145645e-02f, -4.81960811e-02f, -3.81266735e-02f, 8.94199535e-02f, 7.71462470e-02f, 6.01953417e-02f, 1.62575692e-02f, -5.98642416e-02f, 9.43344757e-02f, 7.17447512e-03f,
  -1.20182370e-03f, -7.87079241e-03f, 5.62262256e-03f, -2.34916080e-02f, -3.94334011e-02f, 5.19869216e-02f, 1.98026956e-03f, 6.51798472e-02f, -6.64403383e-03f, -5.76867647e-02f,
  -3.10076103e-02f, -1.73978833e-03f, -3.79244573e-02f, 3.41406390e-02f, 5.69572337e-02f, 5.71225025e-02f, -6.58185408e-02f, 7.29246512e-02f, -4.56637703e-02f, -8.42376873e-02f,
  -1.89729095e-01f, -1.48009926e-01f, -5.11010289e-02f, 2.75120530e-02f, 3.34486701e-02f, -7.10623711e-02f, -2.68252734e-02f, 7.49105960e-02f, -5.51799163e-02f, 2.81066932e-02f,
  -7.31681287e-02f, 6.16623163e-02f, 1.92513466e-02f, 6.32140115e-02f, -2.12454386e-02f, -9.20531601e-02f, -5.85324429e-02f, -6.89844415e-02f, -1.43580705e-01f, -3.74085866e-02f,
  -2.39949171e-02f, -8.88787489e-03f, 6.73162937e-03f, 1.73249431e-02f, -5.40225916e-02f, -2.48305295e-02f, -2.91083176e-02f, -5.53642139e-02f, 3.01686469e-02f, -1.04608119e-01f,
  -2.00621501e-01f, 2.36757919e-01f, -1.50487065e-01f, 1.92684814e-01f, -1.48209408e-01f, 5.52135520e-03f, 1.06338099e-01f, 3.30893695e-02f, 1.49164453e-01f, 1.09104671e-01f,
  -2.09197495e-02f, 9.90004614e-02f, 2.79103331e-02f, 2.17976600e-01f, 1.22312851e-01f, 1.73250079e-01f, 1.32672489e-01f, 4.20533977e-02f, 1.19841769e-01f, -6.96888268e-02f,
  3.85638624e-02f, 4.54471670e-02f, 3.49979065e-02f, -7.78255612e-03f, -2.17981084e-04f, -1.45130530e-01f, -1.12472899e-01f, -1.22869380e-01f, 6.75648823e-02f, -1.12955049e-01f,
  -1.14972614e-01f, -5.61316572e-02f, -9.28604454e-02f, -9.08042416e-02f, -1.15837611e-01f, -1.14251480e-01f, -1.27747253e-01f, -7.62220770e-02f, 3.39054689e-02f, 7.32121170e-02f,
  2.88007688e-02f, -4.20055427e-02f, 4.96356487e-02f, 4.60088067e-02f, 2.61675916e-03f, -1.61079746e-02f, -3.00694667e-02f, -3.63814496e-02f, 9.55058336e-02f, 4.31808271e-02f,
  9.69631076e-02f, 2.51451693e-03f, -7.50621548e-04f, 2.03563999e-02f, 3.30383889e-02f, 5.82545996e-02f, -7.98089430e-02f, -1.86746661e-02f, -3.30600031e-02f, 8.00124183e-02f,
  -5.70614673e-02f, -5.39106876e-02f, -7.64747933e-02f, -1.07100205e-02f, 4.54079881e-02f, 1.87728927e-02f, -4.21326496e-02f, 5.03719449e-02f, 3.80656347e-02f, 3.55583541e-02f,
  6.22854233e-02f, 4.80838530e-02f, 3.36137451e-02f, 4.27260250e-02f, -7.19002560e-02f, -3.78256924e-02f, -8.43047276e-02f, 4.30192873e-02f, -2.55868249e-02f, -3.30427103e-02f,
  -5.69981821e-02f, 2.69439928e-02f, -1.69668887e-02f, -1.35229323e-02f, -1.84424352e-02f, 8.35297070e-03f, 3.74654308e-02f, 2.68597878e-03f, -2.32314542e-02f, -7.39365146e-02f,
  -3.22158239e-03f, -3.34540643e-02f, -1.43351201e-02f, 7.79596493e-02f, 1.36611210e-02f, 1.49326175e-02f, -5.84326237e-02f, 6.58577234e-02f, 9.13994387e-03f, -6.37770370e-02f,
  -9.58283097e-02f, -4.83736843e-02f, -2.34245081e-02f, 9.30544361e-03f, -4.28474881e-02f, -2.14848015e-02f, 9.06495843e-03f, -3.12047619e-02f, -8.70076045e-02f, -2.13015396e-02f,
  -6.33804277e-02f, -1.99430082e-02f, -8.29828158e-02f, 5.46986349e-02f, -6.81589320e-02f, 3.70904021e-02f, -2.92090010e-02f, -5.58422692e-02f, 5.85719645e-02f, 5.69269210e-02f,
  -1.18456393e-01f, 2.38774158e-02f, -3.26613367e-01f, -2.55164169e-02f, 9.95387658e-02f, -8.39595720e-02f, -1.11273780e-01f, 1.33491000e-02f, -1.89658314e-01f, 1.61140800e-01f,
  1.10356420e-01f, -1.35791421e-01f, -7.78542161e-02f, 1.26553476e-01f, -1.40052944e-01f, -8.07292312e-02f, 8.09084922e-02f, 6.34571388e-02f, -9.78810266e-02f, 6.53078333e-02f,
  -1.34400383e-01f, 2.93010086e-01f, 5.52421249e-03f, 1.20807134e-01f, 9.02655050e-02f, 7.80987972e-03f, 2.50457585e-01f, -6.86082430e-03f, 2.27446914e-01f, 6.07697293e-02f,
  -5.34788296e-02f, 5.79264946e-04f, -5.27742840e-02f, -6.45392165e-02f, -4.64754887e-02f, 5.26177622e-02f, 2.90360879e-02f, -1.57256220e-02f, -7.19740093e-02f, -4.76979241e-02f,
  2.18952633e-02f, -6.14978224e-02f, 2.37727780e-02f, 5.62957954e-03f, -1.75181753e-03f, -6.31819218e-02f, -7.82137513e-02f, -4.89595085e-02f, -4.46486324e-02f, -9.78400856e-02f,
  -7.15508163e-02f, -8.95357877e-03f, 1.11154402e-02f, -2.47853342e-02f, -1.01829082e-01f, -1.41579853e-02f, 1.11427885e-02f, 1.49001069e-02f, -5.25772162e-02f, -1.81423258e-02f,
  1.85184982e-02f, 4.28701937e-02f, -3.11894417e-02f, 3.76697034e-02f, 1.75740253e-02f, 4.92458344e-02f, -1.20629137e-02f, 3.22715938e-02f, 4.84470365e-04f, -1.54914865e-02f,
  -6.89876899e-02f, 1.88859422e-02f, -3.19833751e-03f, 3.25351320e-02f, 3.27200908e-03f, 6.17830157e-02f, -3.00632808e-02f, 3.26541513e-02f, -1.84033699e-02f, 1.35865808e-02f,
  5.79085611e-02f, -4.24564444e-02f, 1.80116892e-02f, 2.35604532e-02f, -1.32769924e-02f, 3.96568216e-02f, 5.42930998e-02f, -3.06869131e-02f, 3.98226976e-02f, 2.54411753e-02f,
  9.40281823e-02f, 5.02484739e-02f, -4.23960611e-02f, -1.22292349e-02f, 5.46421297e-02f, -2.65487470e-02f, 1.64179634e-02f, 8.12716037e-02f, 3.91872739e-03f, 2.25349031e-02f,
  7.26625323e-02f, 1.96924862e-02f, -2.33098306e-02f, -1.39742922e-02f, -3.33830863e-02f, -8.34548287e-03f, 4.35542874e-02f, -3.95299681e-02f, 8.57205540e-02f, 6.41042963e-02f,
  6.83337152e-02f, 6.65490981e-03f, -6.36994392e-02f, 5.01886457e-02f, 8.72104391e-02f, 2.83713117e-02f, 1.91125292e-02f, 4.32659313e-03f, 1.46786887e-02f, 4.27758209e-02f,
  -3.40488553e-01f, 1.87534288e-01f, -8.60006809e-02f, -1.59218594e-01f, -1.84767157e-01f, -8.12541321e-02f, -1.99543655e-01f, 4.41862131e-03f, -6.87007830e-02f, 1.70994967e-01f,
  4.09663767e-02f, -8.12288001e-02f, 1.46715581e-01f, 3.04224584e-02f, -2.70897865e-01f, 1.81207895e-01f, -5.37618287e-02f, 2.27913633e-02f, 1.50008490e-02f, -1.53225362e-01f,
  -3.73073071e-02f, 8.60995334e-03f, 4.30323696e-03f, -1.14383493e-02f, -6.13131635e-02f, -5.97233549e-02f, -4.28886637e-02f, -6.79388270e-02f, -3.06003131e-02f, 2.12678351e-02f,
  4.68948623e-03f, 3.99959981e-02f, -3.55035253e-02f, 5.98493889e-02f, -6.62832409e-02f, -5.99276274e-02f, 2.46726964e-02f, -6.36476465e-03f, -1.19368948e-01f, -2.33369470e-02f,
  -6.08919635e-02f, 3.45532559e-02f, 1.79123245e-02f, -5.26629612e-02f, -3.25605683e-02f, -1.28866648e-02f, -5.44225052e-02f, 7.21978471e-02f, 1.70343276e-02f, 3.36813070e-02f,
  5.41282482e-02f, -1.46998465e-02f, 1.66576952e-02f, -1.97145622e-02f, -9.03024338e-03f, -3.32047828e-02f, -4.75130118e-02f, -8.20195451e-02f, 5.76015227e-02f, -7.45049864e-02f,
  3.16289924e-02f, -2.42172275e-02f, -3.60731781e-02f, 1.23065542e-02f, -3.74349505e-02f, -1.70021993e-03f, 2.13268271e-04f, 2.71151643e-02f, -5.88004477e-02f, 4.51771915e-02f,
  -1.98165495e-02f, 2.68503074e-02f, 4.25205119e-02f, -5.27657010e-02f, -2.42008809e-02f, 1.03510447e-01f, -6.00724816e-02f, -5.98857366e-02f, 9.60577000e-03f, -1.23072658e-02f,
  2.65157055e-02f, 3.23655009e-02f, 2.56737303e-02f, 3.79014872e-02f, 2.46636756e-02f, -6.39495626e-02f, 1.04657069e-01f, -3.04947961e-02f, -5.85930981e-03f, -2.40327977e-02f,
  6.46047592e-02f, 6.01134896e-02f, 1.32164747e-01f, 1.36304917e-02f, 5.52018695e-02f, 2.73351278e-02f, 4.46870849e-02f, -2.45499443e-02f, -3.95507552e-02f, 7.04842284e-02f,
  -1.43603096e-02f, -1.08147226e-01f, 2.18270766e-03f, -3.77721265e-02f, 1.48776332e-02f, 1.69265661e-02f, -3.92142907e-02f, -7.76969036e-03f, -1.63915064e-02f, -4.04849015e-02f,
  -8.70789215e-02f, -7.04378188e-02f, -2.47938335e-02f, -6.46018982e-02f, -3.89416479e-02f, -5.29187545e-02f, -3.50950807e-02f, -6.56328946e-02f, 2.65079201e-03f, -5.49253188e-02f,
  -3.27250570e-01f, -4.97002061e-03f, -1.16697446e-01f, 1.88332256e-02f, 1.85616404e-01f, 1.46494687e-01f, -1.08564518e-01f, 1.72096476e-01f, 2.90598162e-02f, 1.06310211e-01f,
  1.15203135e-01f, -1.57333836e-01f, -5.28059043e-02f, 1.14369512e-01f, -1.47688225e-01f, 5.67972623e-02f, 9.00945440e-02f, -1.30280361e-01f, -1.95691343e-02f, 5.76240905e-02f,
  8.05997103e-02f, 1.04892477e-01f, 2.33192220e-02f, 1.56163752e-01f, 4.43128832e-02f, -6.28175363e-02f, -4.47625481e-02f, -4.96523678e-02f, 1.00663759e-01f, -1.87030695e-02f,
  -1.08890921e-01f, -3.94430794e-02f, -6.97891461e-04f, 5.66512123e-02f, -4.04558815e-02f, -1.01545595e-01f, -3.53194214e-02f, -4.14694250e-02f, -2.55701616e-02f, -2.58204956e-02f,
  -1.05561271e-01f, 2.36750618e-02f, 7.38261789e-02f, -4.80174124e-02f, -5.40218838e-02f, 3.78585095e-03f, 3.37992199e-02f, 2.74601057e-02f, -2.87299398e-02f, 5.93409948e-02f,
  2.85805315e-02f, 3.49652059e-02f, 8.05019438e-02f, 7.35128447e-02f, 6.10421002e-02f, 6.62707165e-02f, 3.77696054e-03f, -4.89291325e-02f, 5.34663945e-02f, -2.85074580e-02f,
  2.02089921e-02f, -5.37749790e-02f, -1.99554861e-02f, -7.50398776e-03f, -3.59272994e-02f, 3.63985784e-02f, -4.49589901e-02f, 4.02495228e-02f, 7.48864049e-03f, 5.03116027e-02f,
  -1.44330002e-02f, -1.49737718e-02f, 1.22045772e-02f, -1.96341090e-02f, -3.67847048e-02f, -7.65778050e-02f, -1.52650224e-02f, 4.94564660e-02f, 3.23031470e-03f, 7.68998861e-02f,
  6.40573129e-02f, 4.68090586e-02f, 5.26472740e-02f, 6.22615926e-02f, -6.18707249e-03f, -3.93238850e-02f, -3.10054095e-03f, 6.22107200e-02f, 3.16028260e-02f, 1.41461296e-02f,
  -6.62858859e-02f, -7.41964728e-02f, -1.00544235e-02f, -6.98813498e-02f, -4.09096181e-02f, -6.14494132e-03f, -7.79301673e-02f, -4.60735336e-02f, -5.44160195e-02f, 2.48469468e-02f,
  -2.77594626e-02f, 4.50883619e-02f, -3.44979726e-02f, 8.68206620e-02f, 3.59059460e-02f, 7.92653635e-02f, -3.29136178e-02f, -5.32066030e-03f, 8.26190263e-02f, -1.43127814e-02f,
  -3.78064662e-02f, -2.60667633e-02f, 5.09686116e-03f, 1.21886181e-02f, 1.15751594e-01f, -5.92188761e-02f, 3.17734480e-02f, 5.05655892e-02f, -5.90251051e-02f, 5.31674847e-02f,
  3.98428254e-02f, -2.03982919e-01f, 2.11949363e-01f, 4.45140600e-02f, 6.73891455e-02f, -2.20312223e-01f, -8.42164308e-02f, 7.44855031e-02f, -7.63576999e-02f, -1.87579229e-01f,
  4.80891429e-02f, 5.61660677e-02f, -4.63494435e-02f, -1.72203332e-01f, 1.05548963e-01f, -2.37578829e-03f, -1.06112957e-01f, -7.93370306e-02f, -1.15907103e-01f, 2.97732726e-02f,
  1.53077506e-02f, -1.25220791e-01f, 1.20245904e-01f, -1.50559530e-01f, 1.05098419e-01f, 5.30578159e-02f, 1.87863037e-01f, 5.36284409e-02f, -2.55163070e-02f, 1.39328605e-03f,
  -1.24729380e-01f, 1.40775934e-01f, 2.13824734e-02f, 3.88082974e-02f, 3.42974849e-02f, -4.37975302e-02f, -4.04250296e-03f, 7.39105716e-02f, 8.28227252e-02f, -7.28062727e-03f,
  4.79383916e-02f, -3.73414514e-05f, -8.49939361e-02f, -1.61168631e-02f, -5.18392026e-02f, 3.94775439e-03f, 2.46751159e-02f, -4.16025482e-02f, -2.28233300e-02f, -8.74188989e-02f,
  2.46874336e-02f, 7.83429742e-02f, 1.22808412e-01f, -3.29184299e-03f, 8.44867304e-02f, 3.80755030e-02f, 4.39601205e-02f, -4.49802317e-02f, 4.38746177e-02f, -3.34456265e-02f,
  6.87484220e-02f, 2.42485534e-02f, -1.19258156e-02f, -4.96540256e-02f, 2.97402777e-03f, -1.41702611e-02f, 2.65551116e-02f, 6.83080181e-02f, 4.10925001e-02f, 7.52603263e-03f,
  -4.56993207e-02f, 7.05456361e-02f, -4.91413241e-03f, 7.47805834e-02f, -9.51102674e-02f, -1.63449367e-04f, 6.07507117e-03f, 8.96712299e-03f, -1.41704101e-02f, 4.22939584e-02f,
  6.02477677e-02f, 3.06408387e-02f, 6.74439222e-02f, -6.21338077e-02f, -7.14318380e-02f, 7.06252232e-02f, 2.09252983e-02f, -3.04474607e-02f, 1.88954622e-02f, -2.47828346e-02f,
  -3.67780998e-02f, 1.21186018e-01f, 7.41067249e-03f, 3.35557573e-02f, -4.06068116e-02f, -3.10126971e-02f, 3.21657322e-02f, 4.21866663e-02f, 1.49735427e-02f, -1.20365387e-03f,
  1.66256167e-02f, 7.81236887e-02f, 8.92645046e-02f, 4.46691886e-02f, 7.53505677e-02f, 3.38545851e-02f, 1.39238397e-02f, 1.00042045e-01f, 1.73713658e-02f, 7.79415295e-02f,
  5.17524779e-02f, -4.71510328e-02f, 1.64702209e-03f, 1.23431738e-02f, 4.19691242e-02f, 5.05679958e-02f, -7.11232005e-03f, 8.64545479e-02f, 7.84376711e-02f, 8.88021104e-03f,
  1.49791852e-01f, -8.13480392e-02f, 1.46219894e-01f, 5.10189272e-02f, 1.40995402e-02f, 9.99495834e-02f, 1.04378253e-01f, 1.51832467e-02f, 1.57933310e-01f, 8.28309916e-03f,
  -6.76701367e-02f, 1.02918006e-01f, -5.97129352e-02f, -7.04215979e-03f, 4.79081944e-02f, 1.28955338e-02f, 1.79196209e-01f, 1.03643186e-01f, 3.51196760e-03f, 9.56856236e-02f,
  1.01287872e-01f, 6.35705888e-02f, -5.81883043e-02f, -8.93139690e-02f, 1.31695420e-02f, 7.45309740e-02f, -8.89846608e-02f, -3.08772065e-02f, -2.76699942e-02f, -3.90839912e-02f,
  2.38929247e-03f, 4.73675430e-02f, 8.55805725e-02f, 9.08090845e-02f, 8.23450536e-02f, -1.35323768e-02f, 6.93176612e-02f, -5.36990128e-02f, 6.90712333e-02f, -4.24953140e-02f,
  3.11149862e-02f, 7.25287348e-02f, 8.11313987e-02f, -3.21220770e-03f, 8.97517428e-02f, -4.30714190e-02f, 8.88938084e-02f, 3.49911787e-02f, -4.06853147e-02f, -4.21400405e-02f,
  4.48292010e-02f, -7.13500977e-02f, 6.49444535e-02f, 5.28963506e-02f, -6.65177405e-02f, 3.12633044e-03f, 9.09896418e-02f, -3.46993990e-02f, -2.98941098e-02f, 3.30961682e-02f,
  1.33468462e-02f, 5.99072836e-02f, -4.36801240e-02f, -1.56292890e-03f, 3.02130990e-02f, -1.83342937e-02f, 4.98915464e-02f, 2.89236382e-02f, -4.91646864e-02f, 6.47579581e-02f,
  4.48872410e-02f, -4.07756083e-02f, -4.72231954e-02f, -2.17443723e-02f, -2.83416025e-02f, 5.83145320e-02f, -3.56321298e-02f, 3.96565907e-02f, -3.70378345e-02f, 5.09827211e-02f,
  5.28966412e-02f, 3.07913646e-02f, -2.20801830e-02f, -1.59734711e-02f, 5.48603311e-02f, -2.29748096e-02f, -5.50912544e-02f, -3.38995233e-02f, -4.32491209e-03f, 3.45041528e-02f,
  -1.55335302e-02f, 3.66681349e-03f, -1.77423116e-02f, -3.99497561e-02f, 4.07316051e-02f, 2.00038180e-02f, 7.58045390e-02f, -6.12255670e-02f, 7.23917186e-02f, 8.77424888e-03f,
  2.54100095e-02f, -2.86548268e-02f, 4.50165682e-02f, 7.17980489e-02f, -2.52644699e-02f, 9.66488663e-03f, 1.63536407e-02f, 4.40433584e-02f, 4.29333821e-02f, -5.63892983e-02f,
  5.48574105e-02f, -5.04914075e-02f, -2.58805323e-02f, -8.11647475e-02f, 8.66813213e-02f, -6.11119904e-02f, -3.56224105e-02f, -6.42791986e-02f, -4.22187708e-02f, -6.93947403e-03f,
  3.44585106e-02f, 1.36784971e-01f, -2.57619508e-02f, 1.19033359e-01f, 5.89385331e-02f, -6.96964115e-02f, 4.65789400e-02f, 1.04529932e-01f, -2.04838254e-02f, 1.34499177e-01f,
  5.89845562e-03f, 3.09409034e-02f, -6.86866045e-02f, 3.53190266e-02f, -2.59756744e-01f, -1.55875534e-01f, 3.47291194e-02f, 1.97173450e-02f, -1.97050557e-03f, 1.55839726e-01f,
  5.66835962e-02f, 7.90124238e-02f, 2.64359303e-02f, 2.41209473e-02f, 1.44521058e-01f, 1.07840210e-01f, 4.66884412e-02f, -2.62125786e-02f, 1.02844872e-01f, -7.18482658e-02f,
  7.21003860e-02f, 8.72583315e-02f, 9.21459273e-02f, -3.46770929e-03f, 5.50785512e-02f, -8.20951536e-03f, 4.91267629e-02f, -2.61130352e-02f, 2.38224622e-02f, 7.32019469e-02f,
  2.42706742e-02f, -5.76194609e-03f, -7.28601366e-02f, -4.98031266e-02f, 5.78951128e-02f, 2.80328114e-02f, 4.09707390e-02f, 1.07429594e-01f, 1.72138698e-02f, -5.39004337e-03f,
  2.35972367e-02f, 6.43545464e-02f, 3.42988968e-02f, -5.61393984e-03f, 2.60385554e-02f, 1.77180618e-02f, -7.76714012e-02f, -2.03508176e-02f, 8.67703408e-02f, 3.70126404e-02f,
  -6.80426210e-02f, -5.48452102e-02f, -6.55377982e-03f, -7.63333682e-03f, 3.66503224e-02f, 7.29126185e-02f, 2.39898767e-02f, 4.21769805e-02f, -3.90748978e-02f, 1.56675149e-02f,
  -4.32657450e-02f, 8.05832446e-02f, -2.04454027e-02f, -2.49745212e-02f, -2.56704334e-02f, 2.38666665e-02f, 5.53675331e-02f, 9.10864864e-03f, 3.15810069e-02f, 7.71133006e-02f,
  -7.64927566e-02f, -4.47275937e-02f, 1.35493958e-02f, -4.61788327e-02f, 4.45693396e-02f, -1.00649931e-02f, 2.16155499e-02f, -4.14860100e-02f, 4.60074693e-02f, 1.78084094e-02f,
  1.49151802e-01f, 1.26433656e-01f, 4.35506366e-02f, 7.75070116e-02f, -3.13775837e-02f, 6.39232174e-02f, -2.49672998e-02f, -7.02457596e-03f, 3.00057828e-02f, -3.17730196e-02f,
  4.46448922e-02f, 1.53133376e-02f, 1.88396201e-02f, 3.19486000e-02f, -7.64531121e-02f, 1.12304538e-02f, -1.76228136e-02f, 1.71335170e-03f, 1.84239782e-02f, 9.19068381e-02f,
  6.72807321e-02f, 4.76457961e-02f, -2.44871955e-02f, -4.87911515e-02f, 4.85177562e-02f, -4.32149470e-02f, -6.16860650e-02f, -6.18872456e-02f, -1.76022071e-02f, -1.69927385e-02f,
  -1.79622978e-01f, 1.58278912e-01f, -8.51788893e-02f, -2.21215803e-02f, -7.26753995e-02f, 2.36452129e-02f, -6.94337636e-02f, 1.84228569e-01f, -8.70590135e-02f, 1.29046574e-01f,
  9.42299366e-02f, -2.26449370e-01f, 3.92271467e-02f, 1.12490244e-01f, 2.92332377e-02f, 9.38583240e-02f, 1.03005327e-01f, 3.05067245e-02f, 3.31071094e-02f, 1.49491563e-01f,
  7.68712461e-02f, 2.56279796e-01f, 4.39131297e-02f, 1.68748707e-01f, 5.88346906e-02f, 2.98897400e-02f, 6.07226603e-02f, 2.77468581e-02f, -1.59199052e-02f, -1.01211891e-01f,
  9.39469039e-02f, 5.06426655e-02f, 5.76718450e-02f, 1.47095211e-02f, 2.72427164e-02f, -2.82995664e-02f, -9.45833027e-02f, -1.22176759e-01f, -7.23921657e-02f, -2.63249837e-02f,
  2.84672976e-02f, 3.19326147e-02f, -9.43063647e-02f, 1.93306115e-02f, -8.12628120e-03f, 7.14888331e-03f, 1.48980627e-02f, 2.71249581e-02f, -3.47441137e-02f, 3.57849300e-02f,
  -3.56819853e-02f, 5.46868667e-02f, 4.86065149e-02f, -5.01418673e-03f, -4.66965772e-02f, -3.21060084e-02f, -6.11114055e-02f, -9.60262716e-02f, 4.67225537e-02f, 2.40459573e-02f,
  1.25611024e-02f, 1.69231687e-02f, -1.67153236e-02f, 1.32645117e-02f, 2.31483318e-02f, -3.75480726e-02f, -2.57213823e-02f, 4.39421786e-03f, -4.91251610e-02f, -1.27132386e-02f,
  7.70292804e-02f, 5.78322541e-03f, -4.54247184e-02f, -1.47367194e-02f, -6.34837488e-04f, 2.96110827e-02f, 1.43761719e-02f, 2.41349041e-02f, 2.03508586e-02f, 3.73427011e-02f,
  5.59795611e-02f, 1.31501295e-02f, 4.57565524e-02f, -2.34003384e-02f, 4.15862128e-02f, 4.58787195e-03f, 7.56315365e-02f, 4.77373302e-02f, 1.84018386e-03f, -4.03603818e-03f,
  3.41337591e-01f, 2.88866729e-01f, 4.31924313e-02f, 8.45198631e-02f, -6.73539843e-03f, 8.28517452e-02f, 8.55965242e-02f, 6.38065813e-03f, 3.07610631e-02f, 2.99653336e-02f,
  -2.27983445e-02f, -3.93673172e-03f, 3.29377875e-02f, -1.67372953e-02f, 1.63305458e-02f, 6.94463179e-02f, -2.31854413e-02f, -1.11951595e-02f, 3.53707038e-02f, -4.58804071e-02f,
  -5.32602146e-03f, -8.11157003e-02f, -7.94402789e-04f, -3.38829607e-02f, -1.30104963e-02f, -3.80307814e-04f, 1.88424364e-02f, -3.89773585e-02f, -9.37086418e-02f, -8.81750695e-03f,
  1.17329225e-01f, -1.21377315e-02f, 7.29353307e-03f, 1.16990730e-01f, -1.08773805e-01f, 2.57439435e-01f, 1.59750640e-01f, -1.12124406e-01f, 7.50246048e-02f, 2.68124193e-02f,
  6.01971038e-02f, -2.85101291e-02f, -6.02704510e-02f, 2.37154007e-01f, 2.29083076e-01f, 1.42647162e-01f, 1.98541045e-01f, 9.66606587e-02f, 3.42747159e-02f, 3.79408151e-02f,
  4.01412994e-02f, 1.60824344e-01f, 8.36327765e-03f, -1.00154571e-01f, 3.18965949e-02f, -5.62522225e-02f, -1.51746599e-02f, -9.02951136e-02f, -3.82205993e-02f, -7.02872723e-02f,
  5.03919609e-02f, 1.55716408e-02f, -1.29885584e-01f, 4.65388261e-02f, 2.35138815e-02f, -4.82476354e-02f, 6.60783052e-02f, -2.55586375e-02f, -5.76061495e-02f, 5.07728420e-02f,
  3.51245776e-02f, 1.23553509e-02f, 7.39567056e-02f, -5.92705943e-02f, -1.41298352e-02f, 3.60309728e-03f, -3.02816089e-02f, -6.99250996e-02f, -7.54312351e-02f, 8.59350711e-03f,
  -2.67356299e-02f, -4.92976606e-02f, 8.62748399e-02f, 7.40587264e-02f, 4.81104255e-02f, 3.85809615e-02f, 8.62071216e-02f, 2.43638512e-02f, 6.77481443e-02f, -5.11451103e-02f,
  -1.20662311e-02f, 5.78276515e-02f, -1.33911548e-02f, 5.99922948e-02f, -5.61826455e-04f, 3.48220952e-02f, 6.14668950e-02f, -4.80061807e-02f, -2.33450250e-04f, -3.15944292e-02f,
  -3.34442109e-02f, 4.46193963e-02f, -6.42485544e-02f, -4.77904975e-02f, -4.96267565e-02f, -1.41114863e-02f, -3.24531049e-02f, -8.38064924e-02f, 5.61420619e-03f, 3.01786773e-02f,
  -6.07509315e-02f, 5.04660718e-02f, 1.91100445e-02f, -4.55167890e-02f, 5.85910901e-02f, 2.86084767e-02f, -1.47137521e-02f, -2.64539365e-02f, -2.96594091e-02f, -1.82483103e-02f,
  5.64249270e-02f, -4.48492318e-02f, 7.17528863e-03f, -5.23059107e-02f, -5.95645607e-02f, 1.70446709e-02f, 2.71293093e-02f, -1.28029156e-02f, 2.18123812e-02f, 6.26464635e-02f,
  -6.51612952e-02f, -6.03326783e-02f, -3.65739800e-02f, 6.96901903e-02f, 4.30848869e-03f, 7.76338577e-03f, 4.06541750e-02f, 2.51880544e-03f, -3.89769226e-02f, -1.63962599e-02f,
  -4.85330932e-02f, 4.87600900e-02f, -4.19139862e-02f, -9.90545750e-03f, -2.24080700e-02f, 3.08904368e-02f, -5.78986555e-02f, -8.86842515e-03f, -4.81652319e-02f, 1.12527842e-02f,
  3.85977812e-02f, 8.39114841e-03f, 1.02045760e-01f, 8.49574152e-03f, -3.29481326e-02f, -2.35034212e-01f, -1.91094145e-01f, 2.00598524e-03f, -8.47882181e-02f, 3.00745422e-04f,
  1.16598727e-02f, -6.78684711e-02f, -3.44870687e-02f, -2.33504862e-01f, -3.27190518e-01f, -1.96088001e-01f, -1.94878206e-01f, -1.19634107e-01f, -4.98648696e-02f, 1.91346128e-02f,
  -2.97407769e-02f, -1.33110568e-01f, -2.02135704e-02f, 4.35991921e-02f, 1.98190324e-02f, 2.25043565e-01f, 6.71376064e-02f, 1.68026775e-01f, 6.65097311e-02f, -2.16529444e-02f,
  -2.97337910e-03f, -5.67584522e-02f, 8.82038549e-02f, 5.33788139e-03f, 6.96804374e-02f, -2.10209526e-02f, 4.96777566e-03f, -2.76177749e-02f, -1.54847903e-02f, -6.24050945e-02f,
  -1.11308182e-02f, -1.60377230e-02f, -1.40045546e-02f, 2.60295551e-02f, -2.17611622e-02f, -3.35666984e-02f, -4.62706089e-02f, 1.07845068e-02f, 5.30307405e-02f, 7.18073323e-02f,
  -1.93829811e-03f, 1.93611812e-02f, 4.65466268e-02f, -2.13837065e-02f, 7.82612041e-02f, 2.63645370e-02f, -8.00081936e-04f, 7.17215659e-03f, 5.85839674e-02f, -8.88878331e-02f,
  -2.77273580e-02f, -3.21399868e-02f, -1.25645110e-02f, 3.78025486e-03f, 5.74333966e-03f, 5.80031909e-02f, -3.13002504e-02f, 3.41510102e-02f, 9.15101469e-02f, -9.67053622e-02f,
  2.21510362e-02f, 5.51893283e-03f, 3.39401029e-02f, -6.49399534e-02f, -2.65287887e-02f, -3.08323540e-02f, -1.60140861e-02f, 1.22657502e-02f, 3.12069943e-03f, 9.40253306e-03f,
  2.58162785e-02f, 1.28800999e-02f, 6.38897642e-02f, 4.13349420e-02f, -5.83584122e-02f, 9.10645425e-02f, 6.03460036e-02f, 2.30942760e-02f, 5.81055880e-03f, 8.95443093e-03f,
  -7.01481998e-02f, 1.62017457e-02f, 1.82984192e-02f, -5.03753796e-02f, -7.91071951e-02f, -2.65058950e-02f, -7.47710988e-02f, 2.23435145e-02f, 2.96879504e-02f, 5.41244149e-02f,
  3.69466469e-03f, -5.95512278e-02f, 1.33015933e-02f, -8.98244698e-03f, -9.24859382e-03f, -9.18664187e-02f, 8.48135632e-03f, 2.16632094e-02f, -2.00053360e-02f, -1.94774084e-02f,
  6.67003691e-02f, 2.17629839e-02f, -7.25010931e-02f, -4.71100099e-02f, -2.40196958e-02f, 1.27329561e-03f, -6.99113235e-02f, 8.46387260e-03f, -5.88709721e-03f, -5.62243983e-02f,
  1.00323886e-01f, 2.87390679e-01f, 6.93639591e-02f, -1.76944397e-03f, 8.70287716e-02f, 1.29305854e-01f, -2.15476677e-02f, 1.01010546e-01f, 2.10901320e-01f, 2.99893934e-02f,
  -5.47883986e-03f, 8.32723677e-02f, -7.19823763e-02f, 1.14116557e-01f, -3.98073494e-01f, -8.94317105e-02f, 1.07297696e-01f, 1.81087386e-02f, 1.57868311e-01f, 5.95097356e-02f,
  -6.99773729e-02f, -1.18342005e-01f, -1.81651823e-02f, 5.07069975e-02f, 9.05074254e-02f, 1.55482963e-01f, -2.50755817e-01f, 1.31128542e-02f, 2.57310364e-02f, -9.27008465e-02f,
  7.22711682e-02f, 1.44193068e-01f, 5.88724799e-02f, 6.95268735e-02f, 7.69497603e-02f, -1.83293726e-02f, 4.95776497e-02f, -7.78089911e-02f, 5.17206779e-03f, 6.80907071e-02f,
  -1.90202016e-02f, -7.96501637e-02f, 2.52577476e-02f, -3.10343280e-02f, 1.16105057e-01f, 1.03947874e-02f, -2.07235925e-02f, 6.90952316e-02f, 3.34572885e-03f, -8.31889641e-03f,
  5.70676476e-02f, 5.22800684e-02f, 6.15243874e-02f, -8.02302063e-02f, 6.01843856e-02f, 8.12827274e-02f, -1.13568418e-02f, 7.43502006e-03f, 2.41469946e-02f, 7.74969012e-02f,
  -1.49750793e-02f, -4.05941717e-03f, 5.58295138e-02f, 1.57475583e-02f, -1.06081332e-03f, -4.02122997e-02f, -7.05148056e-02f, -1.90819018e-02f, 5.39844856e-03f, -3.76506969e-02f,
  -4.79949974e-02f, 2.46540587e-02f, 6.51320145e-02f, 2.36029942e-02f, 2.81544477e-02f, 1.33198919e-02f, -2.85124592e-02f, -7.36062154e-02f, 2.40469556e-02f, -3.00910100e-02f,
  -7.93995485e-02f, -5.21474853e-02f, 2.07151473e-02f, 1.53473094e-02f, -2.11035274e-02f, 4.33890987e-03f, 2.39700377e-02f, 2.31769290e-02f, -1.47721628e-02f, -5.18587641e-02f,
  -3.15588377e-02f, -3.91712897e-02f, -2.96551697e-02f, -5.01918420e-02f, 1.07026054e-02f, -5.96125890e-03f, -6.67804778e-02f, 4.33832500e-03f, -6.86707348e-02f, -4.39252965e-02f,
  -1.28202867e-02f, 5.00792973e-02f, 4.14330401e-02f, -3.54936011e-02f, -5.05398177e-02f, 5.23134694e-02f, -9.49704722e-02f, -5.52457199e-02f, -6.35299087e-02f, 4.68909293e-02f,
  -1.03467993e-01f, 2.96635702e-02f, -1.18206153e-02f, 7.15814456e-02f, -1.55129386e-02f, -6.40624911e-02f, 6.22773357e-02f, -1.30730560e-02f, -9.18520167e-02f, -5.55838412e-03f,
  2.23539859e-01f, -1.23453096e-01f, 1.21406034e-01f, 3.36268768e-02f, 1.33349765e-02f, 3.03067893e-01f, 2.26193786e-01f, 1.13698922e-01f, -2.52076285e-03f, -1.40683636e-01f,
  -7.01763388e-03f, -2.33465638e-02f, -1.77386135e-01f, 1.33396462e-01f, 2.63557613e-01f, 3.26954317e-03f, 1.46799281e-01f, 1.16468966e-01f, -1.13980852e-01f, 3.72870383e-03f,
  -5.91504271e-04f, -4.19209227e-02f, -3.62835848e-03f, -1.33076370e-01f, 1.13381445e-01f, -8.16389173e-02f, -1.12165712e-01f, -4.72624265e-02f, 3.53086665e-02f, -2.39682500e-03f,
  7.76387975e-02f, -1.40264705e-01f, 2.72532441e-02f, -3.23585421e-03f, 1.25378668e-01f, -3.02344058e-02f, 3.14388163e-02f, -3.63739245e-02f, -1.01634078e-02f, 1.39236392e-03f,
  3.05365082e-02f, -6.97130151e-03f, 9.22877640e-02f, 9.43185482e-03f, -3.40535901e-02f, -5.24889911e-03f, -3.91941108e-02f, -2.69458480e-02f, -6.20286576e-02f, -2.62134057e-02f,
  -2.59599537e-02f, 3.71898636e-02f, -1.84653942e-02f, -3.04224472e-02f, 6.08424358e-02f, -4.93881106e-03f, 7.15913251e-02f, -5.80852677e-04f, -2.00632848e-02f, 8.16339348e-03f,
  -6.52013496e-02f, 4.54141945e-02f, 4.48916405e-02f, -1.50645953e-02f, -3.06861456e-02f, -8.69588740e-03f, 1.33728031e-02f, -5.88818714e-02f, -7.76798353e-02f, 6.54906407e-02f,
  1.12467017e-02f, 3.24909724e-02f, 5.41771166e-02f, -6.14187401e-03f, -2.76185032e-02f, -3.32457386e-02f, 3.96998506e-03f, -5.45490272e-02f, 4.55571972e-02f, 3.47785875e-02f,
  8.34803563e-03f, 3.90684195e-02f, 5.92375291e-05f, -4.80262637e-02f, 4.94894944e-02f, 1.25526870e-03f, 9.05767083e-03f, 5.85079119e-02f, -1.22384131e-02f, 6.00314997e-02f,
  -8.49382114e-03f, 3.23170200e-02f, 1.77081600e-02f, -1.64024606e-02f, 9.46864486e-03f, 1.76525097e-02f, 4.96098772e-02f, 6.28597364e-02f, 3.82761545e-02f, 4.07525226e-02f,
  -2.76152380e-02f, -7.18960864e-03f, -2.57205591e-03f, -1.31760789e-02f, 7.60909393e-02f, 5.24841174e-02f, -5.87358139e-02f, -3.65727022e-02f, 5.96773289e-02f, -3.23416702e-02f,
  5.05472422e-02f, -3.37332040e-02f, 2.72480701e-03f, 5.22843562e-02f, -3.88213969e-03f, 9.46251750e-02f, 3.89318690e-02f, -6.51699826e-02f, -3.54035571e-02f, 7.02151656e-02f,
  1.97611019e-01f, 3.89418155e-02f, -1.57706395e-01f, 2.29207754e-01f, -1.82412386e-01f, -4.44991179e-02f, -8.61327499e-02f, 8.86343494e-02f, 3.81804146e-02f, 1.09686330e-02f,
  4.99057174e-02f, 1.31633118e-01f, -1.90476759e-03f, 2.38540530e-01f, 1.39408365e-01f, 1.71086103e-01f, 2.68110365e-01f, 1.77729398e-01f, 6.79062679e-02f, 2.00461484e-02f,
  1.05251722e-01f, 1.66928589e-01f, 9.37703028e-02f, -4.12962511e-02f, -7.36140311e-02f, -5.58369011e-02f, 4.22886647e-02f, -1.82628021e-01f, 6.75061047e-02f, 9.05171689e-03f,
  -3.81145626e-02f, -1.40201217e-02f, -3.80099341e-02f, -8.41716025e-03f, 9.50255897e-04f, -2.34899353e-02f, -7.37262005e-03f, 1.80697720e-02f, -1.98407620e-02f, 1.23277195e-02f,
  -6.00595176e-02f, -1.09213106e-02f, 1.64426558e-04f, -4.19764742e-02f, -7.05957040e-02f, 4.58896384e-02f, -7.88273886e-02f, 4.70427237e-02f, -6.25359453e-03f, 5.84696271e-02f,
  -4.84724119e-02f, 6.06357902e-02f, 1.08770607e-02f, 7.09273107e-03f, 6.61882665e-03f, 3.38671505e-02f, 8.25012028e-02f, -4.20611799e-02f, 4.21377420e-02f, 1.08154647e-01f,
  -2.77259201e-03f, -5.85883530e-03f, 3.18790153e-02f, 2.02098172e-02f, -6.22233301e-02f, 2.67511755e-02f, 2.82250419e-02f, -3.42902429e-02f, 1.55841094e-02f, -2.72348803e-02f,
  3.90084833e-02f, -4.69888933e-03f, -1.80445686e-02f, 6.26397729e-02f, 4.85522673e-02f, 3.53007391e-02f, 2.88869790e-03f, 2.65428089e-02f, -4.71936958e-03f, 1.99853238e-02f,
  -4.45749089e-02f, -2.48853434e-02f, -6.29615188e-02f, 3.26836929e-02f, -6.53893221e-03f, 2.13944241e-02f, 1.07666664e-02f, -3.89494048e-03f, 2.28569494e-03f, -4.50553969e-02f,
  1.18896678e-01f, 2.16645449e-02f, -3.71743739e-02f, -7.20063299e-02f, -5.37376404e-02f, -2.65388936e-02f, -2.38240063e-02f, 5.31039052e-02f, -2.49756891e-02f, 2.06752885e-02f,
  2.14060489e-02f, -1.65166520e-02f, 5.49421273e-02f, -4.45345417e-02f, 5.38304374e-02f, -1.85010787e-02f, -1.51466932e-02f, 3.41154188e-02f, -9.18839965e-03f, -8.57151486e-03f,
  -8.32369551e-05f, -3.18278819e-02f, 4.65703383e-02f, -2.64445227e-02f, -1.98354162e-02f, -1.43796299e-02f, -3.98544185e-02f, -2.15249360e-02f, 3.79997939e-02f, -4.88183275e-02f,
  -1.19946815e-01f, -1.46826923e-01f, -2.07264990e-01f, -1.26825497e-01f, -3.02930567e-02f, 3.33451211e-01f, 1.64744183e-01f, -7.98743777e-03f, -2.15281665e-01f, 8.85570422e-02f,
  1.10593505e-01f, -1.63262829e-01f, -8.03086683e-02f, 1.00610159e-01f, -7.56368265e-02f, -4.76666018e-02f, 2.39050597e-01f, 3.99400964e-02f, -1.11357696e-01f, 4.09809090e-02f,
  -5.42280450e-02f, 3.44476998e-02f, -8.41333270e-02f, 1.15439318e-01f, -4.64865826e-02f, -3.54545712e-02f, 4.58570942e-02f, -1.18407346e-01f, 5.60385510e-02f, -5.01889773e-02f,
  1.49217412e-01f, -2.33279075e-02f, -6.77560866e-02f, -2.53499355e-02f, 2.42296401e-02f, 2.84061581e-02f, -8.54449347e-03f, -3.02372463e-02f, 3.78747173e-02f, 1.02162389e-02f,
  -4.36997339e-02f, -3.07130925e-02f, 6.49158806e-02f, -9.87548903e-02f, 3.61285568e-03f, -7.85880815e-03f, 3.54794338e-02f, 4.41797711e-02f, -3.88686955e-02f, -8.92368779e-02f,
  -6.13037869e-02f, -1.50541554e-03f, 3.01144104e-02f, 2.92410352e-03f, -4.78978977e-02f, -7.92976096e-03f, -8.80825520e-03f, -3.78306136e-02f, 6.70693144e-02f, 3.96893993e-02f,
  -7.89632648e-02f, -4.65149060e-02f, 3.83725762e-02f, -3.18745896e-02f, 4.49688584e-02f, -1.89939495e-02f, 8.24469607e-03f, -4.70612533e-02f, 4.32679206e-02f, 4.57641715e-03f,
  -4.81986860e-03f, -2.80789547e-02f, 2.33630482e-02f, 5.97910099e-02f, 7.94015173e-03f, -3.72551717e-02f, 5.49997427e-02f, 6.87341485e-03f, -3.16406228e-02f, -3.67979296e-02f,
  -5.54615743e-02f, -4.34629656e-02f, -1.98981985e-02f, -1.37762930e-02f, -4.65738848e-02f, 2.86039989e-02f, -2.97246166e-02f, -5.97193185e-03f, -3.09119783e-02f, -3.10752001e-02f,
  9.30418819e-02f, -6.30331635e-02f, 5.05901426e-02f, -3.96607257e-02f, 8.20413604e-02f, 2.48376047e-03f, -1.76201724e-02f, -1.72054861e-02f, 1.31722456e-02f, -4.51278463e-02f,
  4.07633670e-02f, 9.71554592e-02f, 3.38072069e-02f, 8.53242651e-02f, 3.22453678e-02f, -2.55217869e-02f, -1.37560107e-02f, -4.35299845e-03f, 6.77736774e-02f, -4.94784676e-03f,
  6.54211640e-02f, 5.71062081e-02f, -1.09619191e-02f, 1.16380462e-02f, 1.94136295e-02f, 1.08325087e-01f, 4.54004742e-02f, -3.02724410e-02f, 4.06592675e-02f, 1.51057104e-02f,
  -1.30684301e-01f, 1.54343963e-01f, -1.43191308e-01f, -1.63141400e-01f, -1.20263912e-01f, -1.00681029e-01f, -1.07915804e-01f, -2.74052913e-03f, -1.18853658e-01f, 1.50570169e-01f,
  1.60144046e-02f, 1.86534747e-02f, 5.98103479e-02f, 1.51735693e-02f, -2.58813113e-01f, 9.07815322e-02f, -7.67600490e-03f, -6.39744624e-02f, 2.73886062e-02f, 1.36731798e-02f,
  -7.51529410e-02f, 7.58986250e-02f, 2.17104540e-03f, 4.88025211e-02f, -4.47621569e-02f, 3.38687003e-02f, -1.59108061e-02f, -2.95599997e-02f, 6.12219889e-03f, -1.48286313e-01f,
  -2.06085593e-02f, 1.15499362e-01f, 6.87570572e-02f, -4.12870347e-02f, 1.94565263e-02f, 4.24297079e-02f, 2.14477181e-02f, 2.63033360e-02f, -8.34449902e-02f, -4.92247492e-02f,
  6.62734061e-02f, -4.35572229e-02f, 6.47128075e-02f, 6.08721795e-03f, -4.84694764e-02f, -4.45891321e-02f, 2.31505707e-02f, 5.51609807e-02f, -5.12833782e-02f, 1.42129743e-02f,
  3.43623087e-02f, 6.77347742e-03f, 3.01353838e-02f, 3.49055491e-02f, -3.93609852e-02f, -1.66169219e-02f, 4.23174277e-02f, 8.62989388e-03f, -3.72434109e-02f, 1.70728173e-02f,
  6.07056431e-02f, -1.43783204e-02f, 5.33512942e-02f, 2.32177749e-02f, 1.64947007e-03f, 1.69984046e-02f, 2.55027376e-02f, -2.64359470e-02f, -5.08364737e-02f, 3.69995944e-02f,
  -3.48018296e-02f, 4.70947884e-02f, 7.74157718e-02f, 4.68438901e-02f, -3.57367098e-02f, -2.60277856e-02f, -3.86084281e-02f, -1.60006937e-02f, 3.12210526e-02f, 3.05921882e-02f,
  -2.25514602e-02f, -2.43566167e-02f, -1.56972650e-02f, -8.18419084e-02f, 3.67658176e-02f, 3.45260128e-02f, -2.44484674e-02f, -2.09007841e-02f, 4.10358682e-02f, 2.15148125e-02f,
  -4.67154607e-02f, 3.42279784e-02f, 8.43554959e-02f, 7.26625100e-02f, -2.06549913e-02f, 2.95372475e-02f, -3.04557867e-02f, 5.87969385e-02f, -3.16986889e-02f, -7.91886821e-02f,
  1.55400941e-02f, -5.45498282e-02f, -4.61734919e-04f, 4.04009856e-02f, 5.33526465e-02f, 5.61453961e-02f, -1.98276378e-02f, 1.04939518e-02f, -1.83890741e-02f, 2.24197330e-03f,
  3.18613835e-02f, -1.71620063e-02f, 3.85914706e-02f, 6.89256340e-02f, 3.68029922e-02f, 2.82634199e-02f, -9.58592296e-02f, 4.91256751e-02f, 5.43767214e-03f, 3.29513550e-02f,
  7.09873065e-02f, 1.63639244e-02f, -5.03823608e-02f, -9.78108793e-02f, -2.52420511e-02f, 9.00988206e-02f, 1.76804706e-01f, -5.91639094e-02f, 2.01705799e-01f, 5.48976883e-02f,
  6.13476783e-02f, 1.10709704e-01f, 1.34107888e-01f, 5.55220433e-03f, 1.29758716e-01f, 1.96607262e-01f, 7.31522143e-02f, 8.80608261e-02f, -2.01547649e-02f, -1.62858441e-02f,
  7.91456376e-04f, -6.50052680e-03f, -9.97022837e-02f, -1.72099084e-01f, -1.04702950e-01f, -1.32619917e-01f, -2.00216666e-01f, 5.01636006e-02f, -1.62909910e-01f, 6.45887181e-02f,
  9.31024253e-02f, 7.45909661e-02f, -3.18126939e-02f, -2.48785783e-02f, 3.01838983e-02f, -8.02256614e-02f, -6.02596961e-02f, 8.08703620e-03f, -2.87625082e-02f, 5.98530322e-02f,
  -1.73648372e-02f, 3.30537893e-02f, 7.54415244e-03f, -2.67551094e-02f, 8.98897741e-03f, 3.04437941e-03f, -4.11161641e-03f, -4.43283208e-02f, -3.13476771e-02f, 2.89082248e-02f,
  -6.32668566e-03f, -5.18610328e-03f, 8.04289803e-03f, 3.02342381e-02f, -1.00899367e-02f, -4.11526971e-02f, -5.55072352e-02f, -6.99682012e-02f, -5.65305017e-02f, -9.14225169e-03f,
  3.79738957e-02f, -6.08018972e-02f, -3.98960244e-03f, -1.29548341e-01f, 2.59512048e-02f, -7.91204795e-02f, -4.75118831e-02f, 1.80595443e-02f, 2.59215608e-02f, -1.96484011e-03f,
  3.56311863e-03f, 2.41327677e-02f, 3.15591320e-02f, -6.09845892e-02f, -6.39250502e-02f, -2.99014524e-02f, 2.65584961e-02f, -6.01195078e-03f, 3.45876627e-02f, -1.11708611e-01f,
  3.14913802e-02f, -4.07107659e-02f, 8.18246678e-02f, 1.73304901e-02f, 4.07102555e-02f, -2.15213299e-02f, 2.18923464e-02f, 6.17154688e-02f, -1.42161306e-02f, -4.90806364e-02f,
  8.90687257e-02f, 1.34505674e-01f, 7.45500326e-02f, 6.28266344e-03f, -4.45502587e-02f, -5.25414199e-02f, 5.38493320e-02f, 3.84952649e-02f, 3.08666099e-03f, 8.34561288e-02f,
  -2.48471182e-02f, -2.40199938e-02f, -2.18582954e-02f, 5.96286245e-02f, 1.75489613e-03f, -3.75755094e-02f, 2.57144906e-02f, 5.52215353e-02f, -6.49143904e-02f, -5.96834235e-02f,
  -1.92179419e-02f, 6.17365018e-02f, 3.70934187e-03f, -1.02688879e-01f, -7.22571909e-02f, 4.27566357e-02f, 2.39124969e-02f, 2.25472059e-02f, -4.52588350e-02f, -5.07028215e-02f,
  2.61619687e-01f, 8.37740749e-02f, -1.61141856e-03f, 1.34342283e-01f, 1.59202978e-01f, 1.54148027e-01f, 5.02928346e-02f, -3.70534472e-02f, 2.11604416e-01f, -2.27758531e-02f,
  2.90117622e-03f, 1.68489330e-02f, -9.81197134e-02f, -4.16881405e-02f, -3.26090939e-02f, -1.66761324e-01f, 1.28472358e-01f, 3.12488638e-02f, 6.08035512e-02f, -1.05755869e-02f,
  -1.26971076e-06f, -9.68022197e-02f, -1.35888517e-01f, -1.50030553e-01f, 1.38175875e-01f, 3.88161913e-02f, -1.63174216e-02f, -5.68424165e-02f, -5.58510162e-02f, -3.32380794e-02f,
  4.53741439e-02f, 6.36916459e-02f, 5.37652709e-02f, 6.53991401e-02f, 1.34539967e-02f, 6.34019449e-02f, 3.86517979e-02f, 3.68962884e-02f, 3.41450758e-02f, -1.72398761e-02f,
  4.50119674e-02f, -1.80946868e-02f, -3.95175628e-02f, -7.20126182e-02f, -5.16766012e-02f, 2.81807414e-04f, -2.53701769e-02f, 5.50341383e-02f, 4.55463566e-02f, 7.00031891e-02f,
  -5.86183853e-02f, -7.20068589e-02f, 8.20159987e-02f, -5.12873456e-02f, 3.02825067e-02f, 1.82108954e-02f, -4.80249077e-02f, 6.08102903e-02f, 5.35066873e-02f, 5.04703037e-02f,
  -1.57607775e-02f, 2.28657834e-02f, -2.95203775e-02f, 7.61324018e-02f, -3.58322114e-02f, -1.82753690e-02f, -7.02576488e-02f, 8.04704241e-03f, 8.27074423e-02f, -7.27063417e-02f,
  7.66191632e-02f, -2.86752097e-02f, 9.75364819e-03f, 3.00429258e-02f, 4.38774899e-02f, -8.74632969e-03f, 2.35657897e-02f, -6.59238324e-02f, 4.49474417e-02f, -4.04746085e-02f,
  -3.76872681e-02f, 7.18634129e-02f, -1.71983540e-02f, -9.81419254e-03f, -4.38584648e-02f, -7.05048293e-02f, -4.96157371e-02f, 4.89599034e-02f, 2.91639771e-02f, 4.34685349e-02f,
  -2.45470908e-02f, -2.59207059e-02f, 3.31769697e-02f, -1.61991511e-02f, -7.31783807e-02f, -5.51380217e-02f, 5.35542592e-02f, -5.03265783e-02f, -5.91605157e-02f, -1.94369853e-02f,
  9.04637203e-03f, -6.21156730e-02f, -6.91456581e-03f, -8.18769783e-02f, 8.69292952e-03f, 1.47578465e-02f, 7.48110488e-02f, 1.09507916e-02f, -4.34300564e-02f, -1.18622258e-01f,
  2.86580212e-02f, -7.74765993e-03f, -1.87702607e-02f, 7.01425597e-02f, 3.48596508e-03f, -2.99651753e-02f, 6.03524335e-02f, 5.44751510e-02f, -4.58993167e-02f, -1.09977322e-03f,
  -1.75670564e-01f, 8.35880786e-02f, -3.54036056e-02f, -1.46980837e-01f, -1.45897716e-02f, 5.89914173e-02f, 6.95587024e-02f, 4.00327295e-02f, 2.79443022e-02f, 1.51070878e-01f,
  -1.93047933e-02f, 6.14228509e-02f, 1.36430398e-01f, 8.21853057e-02f, -1.66569687e-02f, 2.00759903e-01f, 5.67129329e-02f, 4.09450792e-02f, 1.02770001e-01f, -1.55671649e-02f,
  -3.75899859e-02f, -1.35154715e-02f, -1.88823603e-02f, 5.52901700e-02f, -1.47821456e-01f, -1.16996340e-01f, -7.35747367e-02f, 9.57951844e-02f, -2.33122613e-02f, 1.05634294e-02f,
  9.80268642e-02f, 4.99436148e-02f, -2.95536108e-02f, 7.57052302e-02f, 2.97765210e-02f, 5.80625050e-02f, 3.79338451e-02f, -1.38292452e-02f, -2.95157707e-03f, 7.46701285e-02f,
  -1.87914248e-03f, -2.85024717e-02f, -6.10052124e-02f, 4.93621565e-02f, 3.97782400e-03f, 1.23961223e-02f, 5.31798461e-03f, -2.72776349e-03f, 2.41321381e-02f, 2.16348115e-02f,
  1.35300343e-03f, -3.80256958e-02f, -7.37835392e-02f, 1.03757277e-01f, -6.23421930e-02f, -8.51242244e-03f, 2.80069225e-02f, 8.99873972e-02f, 7.52071515e-02f, -7.42958412e-02f,
  -1.60507467e-02f, 1.80112626e-02f, 6.00937344e-02f, -1.67958520e-03f, -3.25243771e-02f, -1.78529210e-02f, 3.86918299e-02f, -7.12447092e-02f, 5.95230348e-02f, -7.02887680e-03f,
  -9.30583179e-02f, -8.15004930e-02f, 3.53038758e-02f, 2.46706214e-02f, -3.02959997e-02f, -1.41938915e-03f, -4.24106456e-02f, -4.78221700e-02f, 3.30749713e-03f, -1.34272948e-01f,
  -7.10007362e-03f, -3.72294225e-02f, -2.61606574e-02f, -9.37471837e-02f, -1.15163382e-02f, -4.93913330e-02f, -1.47910528e-02f, 4.29389812e-02f, 1.58757083e-02f, -3.21319839e-03f,
  -4.81314436e-02f, -3.10650468e-02f, 4.63304855e-02f, -6.86460882e-02f, 2.31701210e-02f, -1.94849912e-02f, 8.31041262e-02f, 6.31390000e-03f, 5.03283925e-02f, -1.50993057e-02f,
  -8.44903216e-02f, 3.78273576e-02f, -3.87130640e-02f, -6.71763644e-02f, 7.73591399e-02f, -8.54610950e-02f, 6.21369258e-02f, -5.88751249e-02f, -7.75581971e-02f, 6.07329607e-02f,
  3.95785458e-02f, 2.98301987e-02f, 2.49144733e-02f, -8.79435912e-02f, 6.37925267e-02f, -9.36525017e-02f, -8.09286460e-02f, -4.20566425e-02f, 2.17251647e-02f, 4.28945944e-02f,
  -2.96136647e-01f, 2.27085948e-01f, -4.25259843e-02f, -1.93228379e-01f, -8.55693519e-02f, -2.57094894e-02f, 4.70288750e-03f, 3.05761099e-02f, 1.33260444e-01f, 2.29859114e-01f,
  1.26537895e-02f, -1.35663390e-01f, 1.29576012e-01f, 1.33785419e-02f, -2.57470846e-01f, 2.12264702e-01f, 1.58304684e-02f, 1.80175304e-02f, 4.20391299e-02f, -8.97042826e-02f,
  -6.02865927e-02f, -6.91324174e-02f, -1.81887195e-01f, -4.03999090e-02f, -2.03912303e-01f, -2.05650125e-02f, -3.48947197e-02f, -6.15291484e-02f, -6.08518533e-02f, -3.90157029e-02f,
  4.70207864e-03f, 7.00138658e-02f, -3.64507176e-02f, 1.22123188e-03f, -6.16790690e-02f, -6.21047951e-02f, -1.20594651e-02f, -8.50777403e-02f, 1.29582016e-02f, -1.19579332e-02f,
  6.48834780e-02f, -8.34011436e-02f, 1.55401919e-02f, 8.46857671e-03f, 3.69747765e-02f, -1.45761818e-02f, -6.99871927e-02f, -3.65495943e-02f, 4.42213938e-03f, -1.16412424e-01f,
  -7.06953034e-02f, -5.83532220e-03f, -2.34466493e-02f, -1.19448267e-02f, -3.74473929e-02f, -2.02589072e-02f, 5.16861677e-02f, -1.01685882e-01f, 3.85881849e-02f, -2.38017645e-02f,
  -2.36765016e-02f, -6.57791365e-03f, 2.99417302e-02f, -2.06265505e-02f, -1.68970972e-02f, -1.39489146e-02f, 1.03185855e-01f, 1.03054726e-02f, 2.50458810e-02f, -2.26932559e-02f,
  -2.25279201e-02f, -1.41218286e-02f, 2.12071463e-02f, 1.47516374e-02f, 1.82544347e-02f, -6.93045044e-03f, -2.55421381e-02f, -1.73828602e-02f, 3.32227051e-02f, 1.27165001e-02f,
  1.19944312e-01f, 5.90332299e-02f, -4.84951437e-02f, 8.40886831e-02f, 1.76724512e-02f, -9.85482801e-03f, 2.64117364e-02f, 3.93634997e-02f, -5.24553396e-02f, -8.67084488e-02f,
  1.04226395e-01f, 1.79668546e-01f, -1.53024392e-02f, -2.89750695e-02f, 3.24846469e-02f, -2.35756263e-02f, 6.10161759e-02f, 5.93026094e-02f, 3.53423283e-02f, -4.52992320e-02f,
  -6.74344152e-02f, 3.03366892e-02f, 6.65378422e-02f, -9.96972471e-02f, -4.61788662e-02f, -3.73335602e-03f, 1.93259399e-02f, 4.02756147e-02f, -4.57544066e-03f, 2.27630790e-02f,
  4.07184623e-02f, 6.35334849e-02f, -3.26733477e-02f, -5.91378957e-02f, -1.36848846e-02f, -8.17831606e-03f, -3.63637246e-02f, 2.60120500e-02f, 3.77327166e-02f, 4.37513255e-02f,
  2.45126083e-01f, -9.63039324e-03f, 9.73440474e-04f, 1.74287230e-01f, 8.72041658e-02f, -6.76368102e-02f, -2.81965192e-02f, 3.32933590e-02f, 1.25399113e-01f, -1.89037427e-01f,
  7.17069954e-02f, -8.02927017e-02f, -1.26777112e-01f, -2.54486632e-02f, 1.94777682e-01f, -6.85151964e-02f, 1.48551285e-01f, -2.11216286e-02f, 1.17787965e-01f, 1.26636803e-01f,
  1.19695492e-01f, 1.33440971e-01f, 4.14785184e-02f, 6.60946071e-02f, 7.61130732e-03f, -4.25397344e-02f, 2.58440804e-02f, -2.41571572e-02f, 1.26470381e-03f, 1.11847594e-01f,
  1.16266161e-02f, -7.24620745e-02f, -6.62142113e-02f, -4.59549855e-03f, 5.17626964e-02f, -8.02514050e-03f, 7.31090736e-03f, -1.26255276e-02f, 3.06543708e-02f, -6.29647598e-02f,
  -1.02849558e-01f, -4.84570414e-02f, 1.48605946e-02f, 2.00492758e-02f, -8.85382993e-04f, -2.77638957e-02f, 9.04229879e-02f, 4.41628657e-02f, 1.31162535e-02f, 3.91263887e-02f,
  -5.02960719e-02f, 2.61488371e-02f, -4.15428802e-02f, 2.34434176e-02f, 6.12613223e-02f, 1.97327826e-02f, -2.30626967e-02f, 4.17293143e-03f, -1.53413014e-02f, -3.19723226e-02f,
  6.23611249e-02f, -7.28929490e-02f, -4.57000993e-02f, -3.56993675e-02f, 5.84256686e-02f, -4.27272990e-02f, -1.59382280e-02f, -1.48264850e-02f, 6.08241744e-02f, -7.79675394e-02f,
  -3.53668556e-02f, 9.92215890e-03f, 7.15771616e-02f, 1.29868593e-02f, 3.96008231e-02f, -3.59691568e-02f, -1.79524776e-02f, -8.05676281e-02f, 7.35612735e-02f, -3.25245596e-02f,
  2.20090784e-02f, 2.15982050e-02f, -6.77386746e-02f, 3.46936658e-03f, 1.38671591e-03f, -4.70827147e-02f, -3.45356129e-02f, -7.08517060e-02f, -4.84208763e-02f, -4.59710509e-02f,
  8.63861144e-02f, 1.48873150e-01f, -7.26903155e-02f, -1.75222959e-02f, -7.37592876e-02f, -1.58965047e-02f, -4.41033170e-02f, -1.75662749e-02f, -2.03387309e-02f, 6.79141283e-02f,
  -9.19090526e-04f, -2.34326981e-02f, -4.04538997e-02f, -8.00373591e-03f, 2.12008301e-02f, 2.00847257e-02f, -1.07176285e-02f, 2.02401374e-02f, -4.40386608e-02f, -3.49925235e-02f,
  -2.42900234e-02f, -4.92080227e-02f, -3.12700346e-02f, 4.87206541e-02f, -7.28571713e-02f, -7.27604628e-02f, -3.95356640e-02f, -6.55820221e-02f, 1.30293556e-02f, 8.35987777e-02f,
  1.84922233e-01f, 1.86458036e-01f, -4.88783345e-02f, -6.67545572e-02f, -6.62534088e-02f, 1.16416283e-01f, 1.78288803e-01f, -6.03215257e-03f, 1.37289315e-01f, 1.51166156e-01f,
  -2.97641680e-02f, 1.54569820e-01f, 9.87544283e-02f, 1.62250981e-01f, -4.63632271e-02f, -5.21493657e-03f, 5.86939678e-02f, 9.30423439e-02f, -1.02501780e-01f, 5.19111976e-02f,
  -2.72461530e-02f, 3.38386907e-03f, -5.77912517e-02f, -9.65536907e-02f, -7.20270351e-02f, 4.75445064e-03f, -1.24836549e-01f, -1.39538884e-01f, -1.30346715e-02f, -1.97602715e-02f,
  1.65652677e-01f, 5.15773408e-02f, 3.12676951e-02f, 1.36012835e-02f, 1.05480636e-02f, 7.45282546e-02f, 6.49024616e-04f, 1.70059502e-02f, -2.92311423e-04f, 4.41102572e-02f,
  7.19859684e-03f, -6.05231896e-02f, -8.22275761e-04f, 8.59749615e-02f, 3.75755131e-02f, -1.56104024e-02f, -3.12453769e-02f, -7.63554573e-02f, 5.25550358e-02f, -7.19892234e-02f,
  -1.09047955e-02f, 6.76519005e-03f, -5.42813241e-02f, -1.10371951e-02f, 1.22381272e-02f, -3.89487632e-02f, 5.01935780e-02f, 3.04915868e-02f, 3.81143056e-02f, 3.35101001e-02f,
  -8.06827545e-02f, 3.79405208e-02f, -4.38240245e-02f, 2.31655873e-02f, -4.92279939e-02f, -4.60186303e-02f, -1.23618105e-02f, -1.10414274e-01f, 3.87942530e-02f, -4.25674208e-02f,
  -2.23693494e-02f, -2.62306258e-02f, 4.23690453e-02f, -5.61864711e-02f, 7.53158480e-02f, 6.20858669e-02f, -3.59177031e-03f, 7.81935453e-02f, -4.15758938e-02f, -6.55622594e-03f,
  4.52445727e-03f, 4.75878753e-02f, 9.18560382e-03f, -2.82510761e-02f, 2.65786070e-02f, 1.04092909e-02f, -2.28150263e-02f, -4.54232283e-02f, 5.65615483e-02f, -6.86465353e-02f,
  2.11638808e-01f, 1.04348168e-01f, 2.76651513e-02f, 8.78699273e-02f, 1.00485735e-01f, 2.09693275e-02f, 9.77937505e-02f, -4.84272055e-02f, 9.46651250e-02f, 5.27808256e-02f,
  3.06928195e-02f, -2.47688238e-02f, 8.45612120e-03f, 3.93831022e-02f, 4.64228205e-02f, -6.05878122e-02f, 4.60141115e-02f, 4.41117808e-02f, 5.53638414e-02f, -2.98680868e-02f,
  -1.36069930e-03f, -1.20544340e-02f, 2.58774143e-02f, 4.15797457e-02f, -4.07114066e-02f, 1.39721530e-02f, -4.66737486e-02f, -5.91204539e-02f, 1.14374859e-02f, -1.94661431e-02f,
  -3.94202843e-02f, 1.05173327e-01f, -2.10063323e-01f, 3.47409807e-02f, -1.25681266e-01f, -7.38461688e-02f, -7.30236992e-02f, -4.31568101e-02f, -1.28915697e-01f, 2.58549124e-01f,
  1.28506154e-01f, 7.23218918e-02f, 2.36424431e-02f, 1.74892545e-01f, -8.66298452e-02f, -3.83052528e-02f, 1.12967558e-01f, -5.85743878e-03f, -8.44272673e-02f, 4.77780513e-02f,
  1.28331194e-02f, 1.29873991e-01f, -2.97132526e-02f, 1.41305760e-01f, 2.56862361e-02f, -4.18385724e-03f, 6.03198167e-03f, 1.45371724e-02f, 1.72573194e-01f, 1.91015638e-02f,
  -1.39824646e-02f, 2.28326465e-03f, -9.03421193e-02f, -6.14652671e-02f, 5.50816627e-03f, 5.02497368e-02f, -1.07460693e-02f, -4.88344617e-02f, -4.53292988e-02f, 6.86480328e-02f,
  2.73153260e-02f, -7.39740394e-03f, 9.33392625e-03f, 1.86504200e-02f, 1.27507362e-03f, 4.45242189e-02f, 3.33470665e-02f, 6.37326092e-02f, -2.28611194e-02f, -4.47263345e-02f,
  -1.80948097e-02f, -7.59596704e-03f, 5.04714400e-02f, -4.16923128e-02f, -5.30074444e-03f, 2.48005260e-02f, -5.27549721e-02f, -8.12887177e-02f, -6.56533316e-02f, -3.59846540e-02f,
  8.04909244e-02f, 5.03707677e-02f, 1.59186148e-03f, 1.09080169e-02f, -8.64735153e-03f, 3.36971991e-02f, 6.49035722e-02f, -2.05832403e-02f, 2.23789234e-02f, -3.85045558e-02f,
  -4.66994802e-03f, -4.26461548e-02f, -2.13456843e-02f, -4.20588329e-02f, 5.98417260e-02f, -5.25535755e-02f, -5.67870885e-02f, 3.70179527e-02f, -2.97721028e-02f, 1.95800606e-02f,
  2.19234545e-02f, 3.63659821e-02f, 2.61876639e-02f, -3.96226719e-02f, -7.52961114e-02f, -9.20790583e-02f, -4.60523143e-02f, -2.92438902e-02f, -1.03767579e-02f, 3.58221866e-02f,
  3.43974717e-02f, 8.36293101e-02f, -8.76909867e-02f, 6.51785824e-03f, 4.06077765e-02f, 5.51221706e-02f, 5.30086793e-02f, -2.74052732e-02f, -1.46382498e-02f, 1.46820355e-04f,
  -3.76500338e-02f, 8.54188800e-02f, 4.70812842e-02f, -4.53920439e-02f, -3.10618374e-02f, 2.76838876e-02f, 5.81884710e-03f, 8.39483086e-03f, -2.75018979e-02f, -5.63128293e-02f,
  5.60817942e-02f, 7.69129172e-02f, -7.68801123e-02f, 7.51595646e-02f, -3.51520069e-02f, -4.06851154e-03f, 5.64348735e-02f, -5.13254814e-02f, 4.53444533e-02f, 5.05814329e-02f,
  -2.34773830e-01f, 5.78037575e-02f, 1.49990991e-01f, -1.58379734e-01f, -1.02768838e-01f, -9.13229510e-02f, 1.16741296e-03f, -2.17277303e-01f, -7.68596679e-02f, 8.95446315e-02f,
  -1.22058615e-01f, 1.72698021e-01f, 1.56347543e-01f, -1.86784431e-01f, -2.62374356e-02f, 8.93538222e-02f, -1.66668117e-01f, 6.87647238e-02f, 3.69114149e-03f, -8.17227811e-02f,
  -7.59768859e-02f, -1.04515426e-01f, 3.18180621e-02f, -1.14281714e-01f, -2.81984620e-02f, 2.26191022e-02f, -5.95569573e-02f, 1.28976300e-01f, -8.20885878e-03f, -3.46615575e-02f,
  1.23810135e-02f, 6.60517812e-02f, -1.51364114e-02f, -8.43208060e-02f, -1.07237976e-02f, -5.77600002e-02f, -4.58673574e-02f, 4.93502431e-02f, -4.50856052e-02f, -5.93123399e-02f,
  2.38581132e-02f, -2.52796151e-02f, -2.44824383e-02f, -7.64224082e-02f, -8.12436268e-02f, 1.87876448e-02f, -3.21053937e-02f, 5.99547364e-02f, -2.24384461e-02f, 3.29557993e-02f,
  -1.37781845e-02f, 6.25870824e-02f, 2.86268815e-02f, 4.44581956e-02f, -5.22159114e-02f, -4.26815152e-02f, 3.70970853e-02f, 4.16252799e-02f, -5.23664467e-02f, -3.96949761e-02f,
  -3.93162146e-02f, -4.23781686e-02f, -5.16684577e-02f, 4.06486206e-02f, 1.24812219e-02f, -7.16205910e-02f, -6.32112846e-02f, 8.83508846e-02f, -1.34476544e-02f, 3.18921581e-02f,
  -6.63860813e-02f, -6.72995821e-02f, -4.30415571e-02f, 3.76931503e-02f, -3.42118852e-02f, 8.74881726e-03f, -4.24255170e-02f, -2.16855984e-02f, -1.54257501e-02f, 5.56549728e-02f,
  3.71557139e-02f, -8.74459147e-02f, -2.95522828e-02f, -3.24663445e-02f, -8.77207611e-04f, -5.02456501e-02f, -4.61680926e-02f, -4.89123091e-02f, 7.23396614e-02f, -2.05308311e-02f,
  -7.48493597e-02f, -3.93962264e-02f, 1.23402998e-02f, 8.35708901e-02f, 9.73551869e-02f, -1.30242035e-02f, 5.18913418e-02f, -7.95147046e-02f, 4.02895212e-02f, 2.19541620e-02f,
  3.50174755e-02f, -7.13419393e-02f, -1.37817254e-03f, 4.01294082e-02f, 5.31702600e-02f, -1.46446405e-02f, 6.39612228e-02f, -1.28505649e-02f, -4.09151763e-02f, -3.61324772e-02f,
  -1.28223542e-02f, 1.59040727e-02f, -2.34375745e-02f, 3.18736508e-02f, -6.24934211e-02f, 8.96317512e-02f, 6.41037850e-03f, -4.87395301e-02f, -6.99605122e-02f, 8.76585171e-02f,
  2.63924971e-02f, -1.05330199e-01f, 1.24175241e-02f, 1.99918911e-01f, 5.67511730e-02f, 1.06598493e-02f, 1.02980882e-01f, 4.53247465e-02f, -1.39609426e-01f, 3.97863425e-02f,
  6.38776869e-02f, -3.43602635e-02f, -1.09701147e-02f, 2.45279819e-01f, 2.21458569e-01f, -1.33347020e-01f, 1.81351438e-01f, 9.10405740e-02f, -1.97163746e-01f, 3.71385403e-02f,
  6.43983707e-02f, 1.98718399e-01f, 6.83577582e-02f, 5.72176091e-02f, 1.02269411e-01f, 1.61418412e-02f, 2.18941003e-01f, -7.99268037e-02f, 2.48079523e-01f, 9.46914777e-02f,
  2.38133688e-02f, -3.82878119e-03f, -2.18079649e-02f, -9.38514769e-02f, 1.30954087e-02f, 1.02244467e-01f, 6.05237074e-02f, 3.44110318e-02f, 1.59803983e-02f, -8.56349096e-02f,
  -7.28038102e-02f, -5.58535270e-02f, 3.77385877e-02f, -5.15537038e-02f, 1.52975097e-02f, -5.28956540e-02f, -4.87218574e-02f, 6.12886325e-02f, -1.25801852e-02f, -2.13165991e-02f,
  -6.46116361e-02f, 2.06287994e-04f, 6.58951849e-02f, 5.37056066e-02f, -3.22043225e-02f, 7.02634268e-03f, -6.37588054e-02f, -1.82318818e-02f, -5.22903539e-02f, 1.84441209e-02f,
  1.58652035e-03f, -2.81354021e-02f, -2.80259680e-02f, -7.87428394e-03f, 2.91598774e-02f, -1.97404176e-02f, 4.12756726e-02f, -1.75786726e-02f, 2.67513450e-02f, -3.76663287e-03f,
  4.71823141e-02f, -3.28871310e-02f, -3.73413078e-02f, 5.53946756e-02f, -1.01763029e-02f, 1.51370903e-02f, -3.76196951e-02f, -2.58720405e-02f, -1.31980283e-02f, 1.72163192e-02f,
  -5.02065718e-02f, -1.32277645e-02f, -7.53950477e-02f, 7.61111900e-02f, -6.19539246e-02f, -3.21712978e-02f, -1.96180213e-02f, -1.90830380e-02f, 1.84753872e-02f, 6.22936338e-03f,
  4.45392914e-02f, 8.30572993e-02f, 5.66455983e-02f, 5.16794436e-02f, -2.49590296e-02f, -5.28175607e-02f, 2.54250318e-02f, 1.03261601e-02f, -7.58058354e-02f, -3.17892805e-02f,
  9.52969119e-02f, -5.24481118e-04f, 3.76106612e-02f, 1.03702135e-02f, 2.75684651e-02f, 6.01367168e-02f, 4.50433046e-02f, -5.36056794e-02f, 5.12022376e-02f, 8.49017426e-02f,
  3.52098942e-02f, -3.86912376e-02f, -5.47361709e-02f, -4.96517681e-02f, 2.29929462e-02f, 1.56103242e-02f, -2.03248076e-02f, -6.08541444e-02f, -5.41158170e-02f, -5.23641370e-02f,
  -7.01512620e-02f, -1.76326722e-01f, -2.85299748e-01f, -1.18616521e-01f, 5.15560471e-02f, 1.67986035e-01f, 7.50995725e-02f, -1.22495055e-01f, -1.90970778e-01f, 1.48445740e-01f,
  1.78803504e-01f, -8.67511556e-02f, 5.73207950e-03f, 4.45962176e-02f, 5.70811741e-02f, -2.99375281e-02f, 1.23235203e-01f, 7.08183646e-02f, -1.74427494e-01f, 1.86535064e-02f,
  -9.38541591e-02f, 2.13424295e-01f, -1.25973132e-02f, -1.24334823e-02f, 4.51177126e-03f, -1.83961883e-01f, 1.23121098e-01f, 6.60837069e-02f, 3.61198112e-02f, 9.84327495e-02f,
  2.81844474e-02f, -1.27805427e-01f, -1.00786194e-01f, -9.38958488e-03f, -8.40035453e-03f, 2.32052468e-02f, 5.33730052e-02f, 6.95845783e-02f, -2.16952041e-02f, -9.74321812e-02f,
  -2.47131512e-02f, 5.61917610e-02f, 2.09101252e-02f, -1.03652366e-02f, -1.47142643e-02f, -2.88412254e-02f, -9.45463553e-02f, -1.13172978e-02f, -7.93916360e-02f, -6.56651556e-02f,
  -9.64922011e-02f, -9.35527682e-03f, -6.96928352e-02f, 8.12033936e-03f, -3.74211594e-02f, 4.09374610e-02f, 8.85175243e-02f, 2.58738380e-02f, -6.47962168e-02f, -5.25325201e-02f,
  4.97854166e-02f, -3.04473806e-02f, 6.97094277e-02f, -5.42793795e-02f, -4.33005281e-02f, 2.53684036e-02f, -4.14441861e-02f, 7.12610222e-03f, -7.38295540e-02f, -2.58637555e-02f,
  4.96867038e-02f, -5.92822358e-02f, -3.41562666e-02f, -2.60157865e-02f, -2.60171704e-02f, 5.48597053e-02f, 2.65785772e-02f, -2.57748812e-02f, -6.86009824e-02f, -5.96647263e-02f,
  -2.16816608e-02f, 3.36489081e-02f, 2.61573121e-02f, 1.92904454e-02f, -1.01413708e-02f, -3.05806249e-02f, 8.03050026e-02f, -4.47216481e-02f, -7.01322481e-02f, -3.03027965e-02f,
  1.07983254e-01f, 3.57542746e-02f, 2.35841535e-02f, -2.97980197e-02f, 5.68578616e-02f, 9.60607678e-02f, 4.21922514e-03f, -1.97877958e-02f, 2.65148822e-02f, 5.40601574e-02f,
  8.24021026e-02f, -2.77200751e-02f, 4.77225967e-02f, -2.78490987e-02f, -5.69710247e-02f, 2.99855564e-02f, 2.69501694e-02f, 5.33393808e-02f, 5.81266135e-02f, 7.78063834e-02f,
  2.84117293e-02f, 2.66637304e-03f, 4.88963053e-02f, 3.44085619e-02f, 1.10832695e-03f, -1.74780358e-02f, -2.78086886e-02f, 5.32322447e-04f, 4.23381627e-02f, -4.73836437e-02f,
  -2.61492640e-01f, -2.12696135e-01f, -2.73676608e-02f, -1.21009469e-01f, 9.21056941e-02f, -1.30278114e-02f, 1.02230065e-01f, -6.88984096e-02f, 6.84236363e-02f, -1.50991352e-02f,
  1.44196928e-01f, -2.48131230e-01f, 1.24140464e-01f, -9.60446969e-02f, 6.14430718e-02f, 1.02606259e-01f, -5.67836091e-02f, -1.26603574e-01f, 1.44169051e-02f, -1.63833231e-01f,
  -2.77409703e-02f, -6.02325536e-02f, -5.43981940e-02f, 6.78559095e-02f, -3.80023941e-02f, -1.30578890e-01f, -2.50789430e-02f, 1.17698414e-02f, -3.69122438e-02f, 1.30927889e-02f,
  -1.50167540e-01f, -1.14929497e-01f, 1.56062078e-02f, -7.40531683e-02f, -7.53221437e-02f, -3.91472131e-03f, -4.34801951e-02f, 6.54773116e-02f, 5.47252633e-02f, -3.27978805e-02f,
  -2.22517494e-02f, 1.05382353e-02f, 4.47016247e-02f, 6.12695180e-02f, -1.24719106e-02f, 7.42544159e-02f, 7.01928809e-02f, 6.82581514e-02f, 2.42016707e-02f, -3.73463556e-02f,
  7.18774945e-02f, -9.05553848e-02f, 3.12455967e-02f, 2.77710948e-02f, 8.46729726e-02f, 1.77999940e-02f, -4.10180129e-02f, -4.01862971e-02f, -1.27561793e-01f, 5.11230230e-02f,
  -9.07438621e-02f, 8.21504593e-02f, 3.60506736e-02f, 1.86911151e-02f, -2.39156792e-03f, 6.93708509e-02f, 2.15079635e-03f, 5.47883138e-02f, -5.28374687e-03f, -5.96755706e-02f,
  -1.26828551e-02f, -3.26394662e-02f, 1.86993796e-02f, 6.72777463e-03f, 8.68313573e-03f, 1.76772121e-02f, 5.10882065e-02f, -9.12647042e-03f, 5.44247776e-02f, -3.15289162e-02f,
  -5.23575172e-02f, 4.93012331e-02f, 2.00633090e-02f, 2.94581219e-03f, 5.76198213e-02f, 7.10397139e-02f, -3.28867733e-02f, -9.00984034e-02f, 7.22741187e-02f, 6.07462926e-03f,
  -1.16697922e-01f, -2.82668591e-01f, -8.24644044e-03f, -6.80376440e-02f, 4.54743356e-02f, 5.84307499e-02f, -9.10484791e-02f, -5.31387031e-02f, 5.83160669e-03f, 6.24613650e-02f,
  -3.64154205e-02f, -4.79702242e-02f, -1.23555645e-01f, 9.16044600e-03f, 4.36972715e-02f, -2.66444869e-02f, -6.39575021e-03f, -5.39644770e-02f, -9.72175896e-02f, -6.47008345e-02f,
  -3.02779078e-02f, -4.30596955e-02f, 7.99303725e-02f, -4.29213680e-02f, 8.46736599e-04f, -1.99898519e-02f, -5.62355854e-02f, -4.07287516e-02f, -4.06411886e-02f, -7.33235627e-02f,
  8.86306092e-02f, -1.91220090e-01f, -8.77228007e-02f, -1.40257776e-01f, -7.66080171e-02f, -3.15536052e-01f, -1.48675755e-01f, -5.06954603e-02f, -7.42495880e-02f, -9.22423527e-02f,
  -8.52600783e-02f, 1.44685591e-02f, 8.87354091e-02f, -8.86243358e-02f, -5.00077307e-02f, -1.25000864e-01f, -2.29580119e-01f, -1.34642139e-01f, -2.63354741e-02f, -6.84344471e-02f,
  -2.05292013e-02f, -1.29405439e-01f, 9.38943997e-02f, 4.21301313e-02f, 2.02285945e-02f, 3.42236087e-02f, 6.69309273e-02f, 1.35144949e-01f, -4.95645069e-02f, -1.47698249e-03f,
  -7.94115663e-02f, -2.03953516e-02f, 3.31254750e-02f, 6.06514234e-03f, -1.36991767e-02f, -5.71064986e-02f, 5.07311970e-02f, 4.18371297e-02f, 1.01955682e-01f, -2.70285308e-02f,
  1.40436832e-02f, 4.08034250e-02f, -5.28163016e-02f, 6.39248407e-03f, 2.97938008e-04f, 1.23854196e-02f, -3.55976485e-02f, -3.53884995e-02f, 6.42948260e-04f, 3.31060262e-03f,
  1.72137003e-02f, -1.00351609e-01f, -3.98860462e-02f, 2.79689841e-02f, -6.33578449e-02f, -1.72086395e-02f, -6.61484851e-03f, 1.91418957e-02f, -4.12929524e-03f, -6.71491176e-02f,
  -4.14493904e-02f, -2.73630191e-02f, 8.73211026e-02f, 2.21203343e-04f, -6.81690797e-02f, 8.35811794e-02f, 3.97837125e-02f, 7.34360830e-04f, 7.86011517e-02f, 3.95951699e-03f,
  -3.91132291e-03f, -5.29533550e-02f, -4.49318625e-02f, -7.87381753e-02f, -1.95685849e-02f, -4.47175466e-02f, 7.74031207e-02f, -4.93790545e-02f, -6.68983832e-02f, -6.82544112e-02f,
  3.27339917e-02f, 3.10734287e-02f, 7.19595850e-02f, -3.94084724e-03f, 3.29946284e-03f, 2.24518646e-02f, -9.25838482e-03f, 2.49540824e-02f, 1.08352918e-02f, -8.57668146e-02f,
  -1.67931393e-01f, -1.45668834e-01f, 1.00702725e-01f, 9.47074965e-02f, 7.29482323e-02f, 2.99380720e-02f, 7.91832153e-03f, -5.96858636e-02f, -5.07453345e-02f, 1.67389924e-03f,
  -2.08691638e-02f, 2.50906311e-02f, -2.67407410e-02f, -5.24866357e-02f, -1.58474855e-02f, -3.42140049e-02f, 3.53995943e-03f, -6.65251464e-02f, -9.45669934e-02f, -3.64906490e-02f,
  -2.75050905e-02f, 3.99802402e-02f, -1.64055657e-02f, -3.58328894e-02f, 1.38191972e-03f, -3.31469178e-02f, -1.27577290e-01f, -2.88063064e-02f, -4.97884601e-02f, 3.83816101e-02f,
  -4.51836064e-02f, 5.60278706e-02f, -7.70271420e-02f, -7.57599548e-02f, -4.47212197e-02f, 5.68728372e-02f, -4.35024500e-02f, 6.97721988e-02f, -5.61472587e-02f, 5.82144707e-02f,
  -6.86823428e-02f, -6.06892966e-02f, 7.40368813e-02f, -1.30075011e-02f, -5.22892959e-02f, -6.97526857e-02f, -3.20464261e-02f, 5.97640015e-02f, -2.82707941e-02f, 3.16235945e-02f,
  -1.52975902e-01f, -7.69512653e-02f, -1.64947525e-01f, 6.27985597e-02f, -7.64271319e-02f, -7.39369094e-02f, -6.74232692e-02f, -8.50955918e-02f, 6.05719090e-02f, -1.43770967e-02f,
  1.12180538e-01f, -1.02820538e-01f, 3.84205654e-02f, 9.17687342e-02f, -3.56153809e-02f, -4.83943969e-02f, -2.75375601e-02f, 3.89655791e-02f, -2.13272329e-02f, -3.25361006e-02f,
  9.16507170e-02f, 8.35461020e-02f, 1.76336039e-02f, -9.99204144e-02f, 2.42367270e-03f, -5.26843816e-02f, -2.46739127e-02f, 9.23186634e-03f, -2.43849270e-02f, 1.11462316e-02f,
  -4.96518612e-03f, -7.04676844e-03f, 2.21408531e-02f, 6.93397671e-02f, -7.52856731e-02f, 2.81740613e-02f, 9.28891916e-03f, 5.76900542e-02f, -7.11266417e-03f, -7.02110007e-02f,
  -1.09755397e-01f, 4.67073806e-02f, -5.56028448e-02f, 8.76825452e-02f, -3.56525443e-02f, -1.36976419e-02f, 7.66115114e-02f, 6.20617829e-02f, 2.03819498e-02f, 4.31593694e-03f,
  6.48976937e-02f, -7.99955428e-02f, 4.48051877e-02f, -1.36042351e-03f, -5.27876802e-02f, -5.19077666e-02f, -4.87678126e-02f, -3.60619612e-02f, -4.89019454e-02f, -1.67098138e-02f,
  -4.43830416e-02f, -5.04313149e-02f, 3.00109759e-02f, 7.00505078e-02f, -1.42509975e-02f, -6.06083572e-02f, 3.11657339e-02f, -1.19673358e-02f, -3.51822637e-02f, -7.99548998e-02f,
  2.16159016e-01f, 7.19391033e-02f, 3.20037864e-02f, 1.28838271e-01f, -8.47328268e-03f, 1.89959928e-02f, -5.90665713e-02f, 6.23922274e-02f, 9.60782394e-02f, -2.32385192e-02f,
  -2.33340543e-02f, 9.08045936e-03f, 1.18964901e-02f, 3.35021839e-02f, -2.37948215e-03f, 6.92252442e-02f, 2.46842820e-02f, -1.32833701e-02f, 2.48274114e-02f, 8.26599598e-02f,
  -5.85176870e-02f, 7.34030083e-02f, -1.00318611e-01f, -6.10705838e-02f, -2.39120054e-04f, 5.53522818e-02f, -1.96934361e-02f, 7.09090754e-03f, 6.41441941e-02f, 7.88898841e-02f,
  1.94468752e-01f, -2.89094597e-01f, 7.42049888e-02f, -2.47954994e-01f, 5.79788815e-03f, -1.15223698e-01f, 7.21217543e-02f, -1.31191865e-01f, -2.57133301e-02f, -1.77163795e-01f,
  8.67549796e-03f, 9.35033336e-02f, 4.13617343e-02f, -2.25926504e-01f, 1.48652762e-01f, 5.88224791e-02f, -2.12387681e-01f, -1.31873935e-01f, -7.23530501e-02f, -1.65884182e-01f,
  1.05054025e-02f, -2.05810696e-01f, -1.90391541e-02f, -2.20204592e-01f, -5.52790649e-02f, -2.80408859e-02f, 1.96647160e-02f, -1.80042684e-02f, -2.11359993e-01f, 8.72172713e-02f,
  -7.89508149e-02f, -7.63113331e-03f, 1.26126211e-03f, 1.34435982e-01f, -6.88812435e-02f, -7.75853544e-03f, 8.16557407e-02f, 9.28951129e-02f, 4.33540232e-02f, -3.21050659e-02f,
  9.31853354e-02f, -4.85144183e-02f, -2.77817138e-02f, 4.47879918e-02f, 2.51935739e-02f, -2.80243028e-02f, -2.08890289e-02f, -2.33119424e-03f, -6.72316998e-02f, -2.76587624e-02f,
  -6.35044426e-02f, -7.06321420e-03f, -5.14055304e-02f, -6.35847002e-02f, -2.53186096e-02f, 4.23138849e-02f, -7.19517469e-02f, 5.74320136e-03f, -8.66162684e-03f, -6.46134699e-03f,
  -5.50239757e-02f, 2.67100073e-02f, -3.00518554e-02f, 3.32292356e-02f, -6.46041408e-02f, -1.17287524e-02f, 1.42978709e-02f, 1.35956993e-02f, -1.84372216e-02f, -3.51663269e-02f,
  1.29992011e-04f, -8.16647243e-03f, 8.41458980e-03f, -2.03699917e-02f, -3.42193432e-02f, -8.90931766e-03f, -1.43809263e-02f, -1.84039176e-02f, 2.96933372e-02f, -3.58113572e-02f,
  -2.43860036e-02f, 4.65194248e-02f, -2.60606129e-02f, 6.47608340e-02f, -6.10780343e-02f, 4.68461076e-03f, -4.02680337e-02f, 6.92403037e-03f, 2.71900166e-02f, -2.30455566e-02f,
  -4.21623364e-02f, -1.68481022e-01f, -1.67945344e-02f, 3.25101130e-02f, 2.84435824e-02f, -1.88450012e-02f, -5.55047132e-02f, -1.27593251e-02f, -9.40026864e-02f, 3.92948184e-03f,
  2.53729373e-02f, 1.44179342e-02f, 6.60717562e-02f, -4.70582806e-02f, 4.97372076e-03f, 1.03166690e-02f, -5.99733442e-02f, -6.43749461e-02f, 1.98254082e-02f, -4.90329042e-02f,
  -5.43167517e-02f, 1.99955683e-02f, -3.51947732e-02f, -1.55264242e-02f, -6.09981380e-02f, 2.46149600e-02f, -8.73044040e-03f, -1.43409160e-03f, -2.75348704e-02f, -3.13454121e-02f,
  -1.84118122e-01f, 2.03010961e-01f, 1.34077132e-01f, -7.38112163e-03f, -2.18108162e-01f, -1.19100913e-01f, -9.88483876e-02f, -4.36914116e-02f, -1.33374304e-01f, 1.69057623e-01f,
  -2.87274551e-02f, 1.88543603e-01f, 1.06560484e-01f, -2.23545339e-02f, -2.00920627e-01f, 1.68272052e-02f, -8.91873166e-02f, 5.84738776e-02f, -7.89258704e-02f, -6.16252162e-02f,
  -1.16860919e-01f, -1.41103506e-01f, -5.78065924e-02f, -6.44495413e-02f, 6.16164841e-02f, -2.04304792e-02f, 2.73680668e-02f, -1.81187317e-02f, 1.22732721e-01f, 3.01910173e-02f,
  -5.60653135e-02f, 6.32491559e-02f, -1.29541464e-03f, 5.18170409e-02f, 2.21448280e-02f, 1.27977571e-02f, 1.05223998e-01f, 2.98857912e-02f, -2.27485709e-02f, -3.75021212e-02f,
  3.77694592e-02f, 1.68368984e-02f, -5.20550050e-02f, -5.58029339e-02f, -9.62389782e-02f, -1.62909962e-02f, -1.94615535e-02f, -5.14609814e-02f, 7.49757588e-02f, -7.79539719e-02f,
  -5.80295920e-02f, 3.35736945e-02f, 3.38063799e-02f, 8.09030533e-02f, -1.96542870e-03f, -2.18891818e-02f, -1.34038627e-02f, 1.10850178e-01f, 3.17788906e-02f, -3.57539468e-02f,
  1.80405620e-02f, 2.10437160e-02f, -2.08226405e-03f, -3.49551924e-02f, 2.64651515e-02f, -7.74207804e-03f, 5.45540676e-02f, -7.08798617e-02f, 6.24448061e-02f, -3.10778078e-02f,
  -1.77732185e-02f, -5.64756207e-02f, 2.69714519e-02f, 3.11253425e-02f, -6.17485642e-02f, 7.43359851e-04f, 8.18193983e-03f, 7.03507364e-02f, -1.74643807e-02f, 8.85139965e-03f,
  -7.06961975e-02f, -8.21713135e-02f, 5.61434999e-02f, -2.21984275e-02f, 8.91732946e-02f, 2.02923291e-03f, -2.81344410e-02f, -1.24284020e-02f, -3.95255908e-02f, -1.36223137e-02f,
  1.66328978e-02f, 8.09554160e-02f, -5.05762435e-02f, -7.54131656e-03f, 2.58076098e-02f, -2.39543151e-02f, -7.77312815e-02f, -5.34076542e-02f, -3.23682129e-02f, 2.74724588e-02f,
  7.21376240e-02f, -3.90572064e-02f, -5.16448058e-02f, 3.65172774e-02f, -6.11978434e-02f, 5.72761428e-03f, 2.13785507e-02f, -2.79311463e-03f, -4.26596105e-02f, 7.68433809e-02f,
  1.15808623e-03f, -1.55665083e-02f, 3.54227386e-02f, -3.39434226e-03f, 2.79110391e-02f, 5.88497426e-03f, 6.56413361e-02f, -2.12180149e-02f, 1.01901386e-02f, 7.23521858e-02f,
  4.59116220e-01f, -1.13367923e-01f, 5.86085916e-02f, 8.45174491e-02f, -9.64009166e-02f, -9.05031040e-02f, -1.36978179e-01f, -9.96120125e-02f, 3.94375883e-02f, -2.00613528e-01f,
  -1.44497573e-01f, 1.66237280e-01f, -1.43833175e-01f, 2.47850902e-02f, 1.15800388e-01f, 3.68796512e-02f, 1.25038773e-02f, -2.62667369e-02f, 6.91711009e-02f, 9.64335427e-02f,
  1.02674909e-01f, -1.28292471e-01f, -8.84191170e-02f, -1.66811854e-01f, -4.69913073e-02f, 9.25193876e-02f, 6.49661347e-02f, -8.86121467e-02f, -5.02639217e-03f, -9.07863975e-02f,
  -2.60154158e-02f, 6.27607331e-02f, 7.81304985e-02f, -7.56179392e-02f, 3.85703593e-02f, 5.62036708e-02f, -3.70335183e-03f, 6.49355277e-02f, 4.21031415e-02f, -4.32233140e-02f,
  4.85320948e-02f, -4.97142337e-02f, 4.26190123e-02f, -4.97308858e-02f, -2.10442562e-02f, 1.63344424e-02f, 1.32123400e-02f, 5.39232008e-02f, -1.10520385e-01f, 3.58275808e-02f,
  -9.83739868e-02f, -6.79188035e-03f, -5.58266975e-02f, 4.69278060e-02f, 3.63462418e-02f, -8.77716020e-02f, 3.32740927e-03f, -4.52831239e-02f, 2.90875491e-02f, 1.85802411e-02f,
  4.88208272e-02f, 8.16922337e-02f, 4.79894653e-02f, 3.35989743e-02f, 6.84871823e-02f, -5.94005734e-02f, 3.49193960e-02f, -1.42975859e-02f, 7.21827149e-02f, -9.47712734e-02f,
  4.36126478e-02f, 6.88870549e-02f, -1.57150254e-02f, 2.13849880e-02f, 1.86251830e-02f, 6.60439655e-02f, 3.23685668e-02f, -1.26535520e-02f, 1.43356649e-02f, -1.31311752e-02f,
  1.65738128e-02f, 1.89299900e-02f, -2.55437959e-02f, 7.24145025e-03f, 1.05270126e-03f, -3.19567323e-02f, 5.34047522e-02f, -2.50776745e-02f, 3.64888087e-02f, 2.43734214e-02f,
  -4.37935777e-02f, 6.32068589e-02f, 2.28175856e-02f, -1.02885939e-01f, -5.04599027e-02f, -8.74282327e-03f, 4.21602512e-04f, -2.11032871e-02f, 2.76179519e-02f, 5.33628128e-02f,
  -3.98150133e-03f, 1.74012792e-03f, -2.41018683e-02f, 5.66603653e-02f, -4.71777171e-02f, 3.33954394e-02f, -4.73902049e-03f, 1.06856748e-02f, 6.14740737e-02f, -2.25428492e-02f,
  -3.76641750e-02f, -3.27791311e-02f, 2.98784059e-02f, 1.72810326e-03f, -3.31918262e-02f, -6.78907409e-02f, 7.14981556e-02f, -4.39435951e-02f, -8.28311592e-02f, -5.88953355e-03f,
  3.78745273e-02f, 4.33020405e-02f, -9.98954549e-02f, -1.67561293e-01f, -1.26260400e-01f, -1.01579741e-01f, -4.61217836e-02f, -1.22863933e-01f, -2.21216813e-01f, 4.68090586e-02f,
  9.37233418e-02f, -2.46666558e-02f, 1.16637230e-01f, -3.50101627e-02f, 6.76693469e-02f, 7.69364014e-02f, -8.90610665e-02f, 6.25931323e-02f, -1.56736225e-01f, -5.32071330e-02f,
  2.49802731e-02f, -4.47061434e-02f, 4.72764783e-02f, -7.35668419e-03f, -3.27449627e-02f, -1.02117606e-01f, 1.63560748e-01f, -7.92424828e-02f, 5.92590012e-02f, -2.79350542e-02f,
  -4.72040400e-02f, -1.15095370e-01f, 1.14358328e-02f, 8.79124403e-02f, -5.42061999e-02f, -5.79773597e-02f, 3.88181098e-02f, 9.74776521e-02f, 9.98431724e-03f, 7.32339825e-03f,
  6.39093220e-02f, 7.61380270e-02f, -3.90642658e-02f, -8.91199056e-03f, -8.20785016e-02f, -4.43853438e-02f, 3.86124547e-03f, 6.06465191e-02f, -5.45485802e-02f, 3.00807878e-02f,
  -9.29830223e-03f, -4.89015765e-02f, -8.38517919e-02f, 4.56713252e-02f, 6.30121753e-02f, -4.84662987e-02f, 3.60056423e-02f, 1.47083532e-02f, -2.40193270e-02f, 6.85611600e-03f,
  -4.51827087e-02f, -3.95830646e-02f, 5.31362854e-02f, 8.39044079e-02f, -2.75402255e-02f, 2.97486540e-02f, 3.34353149e-02f, 7.07311407e-02f, 2.36897189e-02f, 4.94482964e-02f,
  -7.18804970e-02f, 7.80299678e-02f, -2.19713021e-02f, -4.16182950e-02f, 1.69657078e-02f, 5.51328100e-02f, -3.74210738e-02f, -3.87179144e-02f, -5.50969020e-02f, -3.65421735e-02f,
  -8.24543089e-02f, 4.71739434e-02f, 1.01846695e-01f, 9.23861191e-02f, 5.07141389e-02f, 6.78143501e-02f, -4.27400991e-02f, 3.89682949e-02f, 3.22025344e-02f, -1.65501032e-02f,
  5.99304549e-02f, -2.99441852e-02f, 3.84758003e-02f, 8.83299187e-02f, -5.07128984e-02f, 3.85693796e-02f, 5.69495419e-03f, -5.72369881e-02f, -9.11715552e-02f, -1.40908081e-02f,
  -1.14909085e-02f, -2.58773267e-02f, 9.62549299e-02f, 5.06744161e-02f, 2.95789298e-02f, 4.63016741e-02f, 8.30862448e-02f, -4.17764932e-02f, -7.56333768e-02f, 3.01372129e-02f,
  1.01945490e-01f, 2.81956550e-02f, -7.40794698e-03f, 5.31057653e-04f, 7.82921910e-02f, 3.98959666e-02f, -2.82086805e-02f, -3.57484110e-02f, 8.37841406e-02f, -4.37892117e-02f,
  -1.00804769e-01f, 9.15616937e-03f, -2.02594146e-01f, -2.28934020e-01f, -1.48539007e-01f, -1.12054437e-01f, -1.19353451e-01f, -1.12713657e-01f, -3.11265111e-01f, -1.64165273e-02f,
  3.72259617e-02f, -1.63045034e-01f, 2.31024355e-01f, -7.26321787e-02f, -3.25341746e-02f, 9.74181443e-02f, -1.14347674e-02f, 5.05509786e-02f, -4.54334393e-02f, -6.72423095e-02f,
  3.36224996e-02f, 4.84092869e-02f, 6.40501603e-02f, 1.68789178e-02f, -1.25972494e-01f, 4.40043360e-02f, 2.15047523e-01f, 5.45272641e-02f, 7.95411617e-02f, 1.00504629e-01f,
  -4.78213020e-02f, -6.04172237e-02f, 5.95014216e-03f, -5.76402396e-02f, 4.08567600e-02f, -2.70217229e-02f, -1.60447732e-02f, 1.10879593e-01f, 2.10111998e-02f, 3.46156023e-02f,
  -2.62149312e-02f, -4.43946719e-02f, 3.41312587e-02f, -5.20303175e-02f, -1.17464103e-02f, -3.76800336e-02f, 5.06582018e-03f, -1.82915423e-02f, -5.71530759e-02f, -6.21882221e-03f,
  -8.15139338e-02f, -6.75002337e-02f, 1.67141657e-03f, 6.68689087e-02f, 6.24623224e-02f, 5.22913858e-02f, 3.34830135e-02f, -6.83779037e-03f, -5.01608960e-02f, -9.17750038e-03f,
  -3.92099395e-02f, 9.60978344e-02f, -4.99682017e-02f, -1.59141105e-02f, 1.34663712e-02f, 3.91659774e-02f, -1.40796835e-02f, 4.27784864e-03f, -6.79892749e-02f, 8.25795438e-03f,
  -1.72280949e-02f, 2.89789960e-02f, 2.46232469e-02f, 2.05158368e-02f, 4.63794135e-02f, 2.43968554e-02f, 1.73469931e-02f, -3.08493655e-02f, -7.10619241e-02f, -1.45465927e-02f,
  1.28576225e-02f, 4.01278548e-02f, 3.94954644e-02f, -5.33811748e-02f, 7.90371299e-02f, 1.99509524e-02f, -4.21481729e-02f, -3.52327805e-03f, -5.49799502e-02f, 7.21064135e-02f,
  7.42758915e-04f, 5.19071408e-02f, 6.93047792e-02f, -2.83554234e-02f, -1.58204511e-02f, -9.58664436e-03f, 8.48925952e-03f, -6.14643134e-02f, -8.50549433e-03f, -4.98111919e-02f,
  -2.45350283e-02f, -1.30016804e-02f, -4.01835479e-02f, -4.57125995e-03f, -5.57718426e-02f, -3.43522690e-02f, -2.25948468e-02f, -2.39249952e-02f, 4.06676941e-02f, -1.96736567e-02f,
  -2.06549801e-02f, -2.06987858e-02f, 3.83323170e-02f, -7.99922347e-02f, -1.76556166e-02f, -2.74567846e-02f, -5.97135834e-02f, -6.86919130e-03f, 2.52018925e-02f, -7.39795249e-03f,
  -1.28117412e-01f, 5.15934676e-02f, -6.62208423e-02f, 2.14095283e-02f, -1.32290244e-01f, -7.04427017e-03f, 1.20497301e-01f, -3.04350327e-03f, 1.43318892e-01f, -1.60936192e-02f,
  -2.90935878e-02f, 6.58033788e-02f, 1.46719262e-01f, 1.64649665e-01f, -6.03389740e-02f, 1.27085179e-01f, 4.94027883e-02f, -4.55625728e-02f, -1.74340177e-02f, -1.25341877e-01f,
  1.09369727e-02f, -5.77150285e-02f, -2.71877535e-02f, -9.98696685e-02f, -1.29251570e-01f, -1.00983150e-01f, -9.61335227e-02f, -8.05360600e-02f, -1.26786053e-01f, 6.52607083e-02f,
  -9.02388394e-02f, -2.48379242e-02f, 3.83945554e-02f, -5.88328112e-03f, -8.37393329e-02f, -2.97446526e-03f, -1.29448310e-01f, -4.24494259e-02f, 2.00974997e-02f, -2.51727346e-02f,
  -6.64919801e-03f, 3.91880609e-02f, -7.84625672e-03f, 6.53942749e-02f, 3.48595120e-02f, 7.25404769e-02f, -1.74523816e-02f, 2.72869337e-02f, -6.22573271e-02f, -5.20421658e-03f,
  -1.94580816e-02f, -7.13547617e-02f, -6.72985241e-02f, -3.53124440e-02f, -3.64534790e-03f, 8.16646889e-02f, -5.77957891e-02f, -5.97578823e-04f, -8.89077336e-02f, -9.72009450e-03f,
  -4.18496951e-02f, -2.89481599e-02f, 5.31722754e-02f, 3.66587788e-02f, -2.08618771e-02f, 7.57827889e-04f, 5.54429814e-02f, -5.49138300e-02f, -8.10754765e-03f, 6.42976090e-02f,
  -6.44533560e-02f, 3.96734430e-03f, 2.48988103e-02f, -2.49866222e-04f, -4.26145494e-02f, 9.63774417e-03f, -3.66710275e-02f, 1.35170491e-02f, -5.61034679e-02f, -1.90107990e-02f,
  3.06736119e-02f, 5.47461994e-02f, 5.03028631e-02f, 1.87645797e-02f, -3.48191261e-02f, 8.20439383e-02f, -3.39955240e-02f, -2.17487440e-02f, 2.09649950e-02f, -1.16164275e-01f,
  -1.70665801e-01f, -1.48623616e-01f, 1.92695186e-02f, -3.44683640e-02f, -7.01765195e-02f, -5.00501990e-02f, -7.74702197e-03f, 9.53544155e-02f, 4.93504927e-02f, -6.40469193e-02f,
  -1.57928877e-02f, -1.05668254e-01f, -3.04687545e-02f, 1.76237915e-02f, -7.70522207e-02f, 8.17127377e-02f, -3.87019366e-02f, -8.97036195e-02f, -1.95617136e-02f, -3.61951068e-02f,
  -7.93771222e-02f, 1.76264551e-02f, -8.26520904e-04f, 2.54679881e-02f, 2.86587030e-02f, -1.07041769e-01f, 6.76183403e-02f, 4.09201765e-03f, -8.25950429e-02f, -2.69047469e-02f,
  3.07570428e-01f, -1.57874506e-02f, -2.02968910e-01f, 1.88894600e-01f, 5.14052622e-02f, -3.13283429e-02f, -5.26977070e-02f, 1.54414415e-01f, 1.86826929e-01f, 1.30329728e-02f,
  -7.50429556e-02f, -1.28063291e-01f, -1.73498839e-01f, 6.12407140e-02f, 8.39010328e-02f, 1.20935461e-03f, 5.68409227e-02f, -5.10095619e-02f, -1.43172825e-02f, 7.63352290e-02f,
  9.26658437e-02f, 1.10811435e-01f, -1.59158781e-01f, 2.28729174e-02f, 3.32598872e-02f, 8.90874490e-02f, 2.52082925e-02f, -1.69657335e-01f, -1.27155157e-02f, -1.90191891e-03f,
  1.42811432e-01f, -1.59089677e-02f, -4.04703943e-03f, -3.59745137e-02f, 7.43983239e-02f, -5.13694361e-02f, 4.15089466e-02f, -5.81217483e-02f, -1.14177532e-01f, -2.47254465e-02f,
  -5.21437228e-02f, 9.05124918e-02f, 2.84481645e-02f, 2.46185646e-03f, 9.32643041e-02f, -2.92289816e-02f, 2.79865507e-02f, -5.36440648e-02f, -1.03065027e-02f, -1.12084150e-02f,
  1.85775794e-02f, -3.23187821e-02f, 4.40752544e-02f, -4.50695194e-02f, -4.95425649e-02f, 3.05607747e-02f, -2.25963201e-02f, -1.36435643e-01f, 5.55093102e-02f, -1.18907429e-02f,
  1.99858099e-03f, -6.92980271e-03f, 3.78622413e-02f, -1.48655651e-02f, -3.26382928e-02f, 3.62959728e-02f, 4.88444306e-02f, 1.23596452e-02f, 5.14590628e-02f, 7.24130273e-02f,
  9.06186849e-02f, 4.14741673e-02f, 3.65473554e-02f, -2.13782061e-02f, 3.14328186e-02f, 5.85456267e-02f, -6.43748343e-02f, -1.43343741e-02f, 7.52490908e-02f, -3.30361612e-02f,
  -2.03929991e-02f, 7.36389905e-02f, 4.29383814e-02f, 5.53645343e-02f, -6.57482399e-03f, 5.97346127e-02f, 3.24181952e-02f, -1.51049830e-02f, -6.73422813e-02f, 4.65488583e-02f,
  2.16523811e-01f, 1.61205456e-01f, 1.63685959e-02f, 1.24602513e-02f, -3.24794184e-03f, -5.59928343e-02f, 4.16355804e-02f, 4.67962772e-02f, 2.58106235e-02f, 5.42025492e-02f,
  2.11928468e-02f, -1.42091056e-02f, -3.36349104e-03f, -4.37410995e-02f, -4.66970801e-02f, 8.32313001e-02f, -2.89756376e-02f, 2.16165315e-02f, -5.34922117e-04f, 4.05770689e-02f,
  -4.95526344e-02f, -1.31383119e-02f, -1.29164206e-02f, 4.02651429e-02f, 2.23432966e-02f, -6.33510798e-02f, 8.43665376e-02f, -3.44727710e-02f, -5.73811233e-02f, -5.05651012e-02f,
  -1.86049104e-01f, 5.57108633e-02f, -2.21224912e-02f, 1.56807974e-02f, 2.33175308e-02f, 9.83111262e-02f, 1.91271260e-01f, 9.64944065e-02f, 2.20915116e-02f, 2.49357954e-01f,
  1.51289972e-02f, -1.58545628e-01f, -6.12265139e-04f, 1.07489660e-01f, -3.54002118e-01f, -7.70815611e-02f, 3.98013294e-02f, 1.00637332e-03f, -9.34826806e-02f, 1.01755438e-02f,
  -8.67436603e-02f, 1.60522331e-02f, -1.58704370e-01f, 3.99315953e-02f, 4.78859851e-03f, 3.75721082e-02f, -9.39928889e-02f, 4.84229587e-02f, -6.25753552e-02f, -7.53897205e-02f,
  6.39343122e-03f, 5.44555001e-02f, 4.72979099e-02f, -1.26698771e-02f, -3.32573764e-02f, 1.05369076e-01f, 5.13296723e-02f, -7.21444050e-03f, -6.81190714e-02f, 6.65548742e-02f,
  -5.05677648e-02f, 2.10065898e-02f, 5.70895188e-02f, -1.92177780e-02f, 2.98706302e-03f, -6.48036078e-02f, -1.72139779e-02f, 7.50855962e-03f, -4.57021035e-02f, 2.05029827e-02f,
  1.35128107e-02f, -4.51813526e-02f, -3.85412597e-03f, 6.71672672e-02f, -5.42937666e-02f, 5.01764305e-02f, 7.70584717e-02f, -8.18303823e-02f, 2.57505197e-02f, -6.05424345e-02f,
  4.78732539e-03f, 4.65984456e-02f, 4.79506478e-02f, -9.52537172e-03f, 6.65496141e-02f, -6.12779194e-03f, -2.05752347e-02f, 2.46076193e-02f, -1.67562552e-02f, 3.71184088e-02f,
  7.40698306e-05f, -3.03069483e-02f, -6.17994517e-02f, 6.26176372e-02f, -3.70261222e-02f, -1.01975678e-02f, -3.75154801e-02f, -2.59458311e-02f, -2.45002303e-02f, 2.86724493e-02f,
  -2.14736909e-02f, 8.00972246e-03f, 5.21089211e-02f, -2.65358649e-02f, -3.38375336e-03f, -3.12532224e-02f, 1.76323783e-02f, 2.11957805e-02f, 2.50311159e-02f, 1.26849106e-02f,
  7.04016834e-02f, -9.06494707e-02f, -1.06670083e-02f, 7.91424587e-02f, 4.02331464e-02f, -1.44134485e-03f, -8.51351321e-02f, 3.01302895e-02f, -7.71551430e-02f, 4.71326560e-02f,
  -8.25479254e-03f, 3.25680897e-02f, 4.25130781e-03f, -5.48007973e-02f, -4.51027639e-02f, 3.25005054e-02f, 4.13395949e-02f, -4.95568477e-02f, 5.41190319e-02f, -4.95774113e-02f,
  -4.22096737e-02f, 5.39054498e-02f, -3.83222513e-02f, 1.25867054e-02f, 2.45475397e-02f, 1.51703330e-02f, -7.09296912e-02f, 2.85048634e-02f, -8.46087188e-02f, 2.15675402e-03f,
  1.59851134e-01f, -7.10234791e-02f, -2.40473598e-01f, 1.65069088e-01f, 1.45773068e-01f, 1.86006224e-03f, -5.25593422e-02f, 1.09464480e-02f, -3.18198390e-02f, -6.43325895e-02f,
  6.82834908e-02f, -1.34670928e-01f, -4.67619486e-02f, 3.85060050e-02f, 4.87813056e-02f, -1.67243466e-01f, -8.08207542e-02f, -4.72601280e-02f, -9.98311266e-02f, 8.19583796e-03f,
  1.87584385e-02f, 1.88439205e-01f, -5.70849702e-02f, 1.87262684e-01f, 5.12475185e-02f, 5.41837737e-02f, 1.79102808e-01f, -5.19022644e-02f, 1.86286956e-01f, 4.90801036e-02f,
  9.47257727e-02f, 6.31874353e-02f, 4.03810069e-02f, -3.96398269e-02f, 5.71722388e-02f, -2.25353092e-02f, -6.32884055e-02f, -9.12264548e-03f, 5.41261248e-02f, 1.92379206e-02f,
  -7.59020895e-02f, -6.59396574e-02f, -7.40583055e-04f, 2.84419637e-02f, 2.09943429e-02f, 3.33454646e-02f, -2.34545153e-02f, 6.48924857e-02f, -4.93203811e-02f, -7.88773149e-02f,
  -1.12370132e-02f, -6.09883741e-02f, -5.94324544e-02f, -7.23781511e-02f, -6.86548948e-02f, -9.13488716e-02f, 3.02889701e-02f, -4.52385433e-02f, -4.05344367e-02f, -2.16349177e-02f,
  -4.92598116e-02f, 2.33097486e-02f, 2.64433445e-03f, -1.48834207e-03f, 7.53432093e-03f, 6.23452328e-02f, 7.14950189e-02f, -5.35721108e-02f, 4.92462516e-02f, 2.02760231e-02f,
  9.73331630e-02f, 2.45524887e-02f, 5.52296750e-02f, 7.14206416e-03f, 1.79531127e-02f, 2.07404271e-02f, 1.89608913e-02f, 4.57058027e-02f, 4.46642330e-03f, -5.51755168e-02f,
  -1.28161712e-02f, -3.04286834e-02f, -1.09788431e-02f, -1.69420857e-02f, 1.46665452e-02f, -3.06708217e-02f, 8.01954493e-02f, -8.60300213e-02f, 1.35635782e-03f, -1.50405392e-02f,
  8.65033418e-02f, 2.68787835e-02f, 6.00467212e-02f, 5.92518747e-02f, 1.20381964e-02f, 7.17004910e-02f, -4.40240875e-02f, -5.88053986e-02f, -7.54938871e-02f, -1.31917438e-02f,
  7.10742250e-02f, 7.50091821e-02f, 2.22838894e-02f, -6.63889060e-03f, -4.50139455e-02f, 7.23658036e-03f, 1.04551233e-01f, 5.37808351e-02f, 7.53206620e-03f, 1.02495691e-02f,
  -2.08287835e-02f, 8.81720558e-02f, -1.06328866e-02f, -8.30037985e-03f, -1.65852066e-02f, 9.02368650e-02f, 7.34607726e-02f, -2.74403300e-02f, -2.27419417e-02f, 3.79743464e-02f,
  2.06725653e-02f, 2.77488977e-01f, -7.58977681e-02f, -7.73770437e-02f, 7.32245520e-02f, -1.48731977e-01f, -1.96510836e-01f, 4.41040397e-02f, 5.70276231e-02f, 1.75147444e-01f,
  -1.04283161e-01f, 4.00583670e-02f, -1.04024075e-01f, -1.58555225e-01f, -1.33125469e-01f, -1.20513894e-01f, -1.23238146e-01f, -9.46095362e-02f, 3.59735861e-02f, 9.07452703e-02f,
  -1.00281805e-01f, -3.06251347e-02f, -2.36707732e-01f, -4.21280116e-02f, -2.34531090e-02f, 7.11431876e-02f, 6.23956881e-02f, -6.46571349e-03f, 5.19918464e-02f, -2.62413397e-02f,
  -9.76792872e-02f, 1.19074866e-01f, -9.90596041e-03f, -5.71540743e-02f, -3.42651531e-02f, 8.72418806e-02f, -1.35924630e-02f, -9.04769227e-02f, 4.21527140e-02f, 6.05820976e-02f,
  6.61668107e-02f, -4.02120203e-02f, -2.61647813e-02f, 9.64070950e-03f, -3.15617956e-02f, 5.39327003e-02f, 2.84945890e-02f, 5.10570183e-02f, 8.32779557e-02f, -6.75790310e-02f,
  1.46342590e-02f, 5.03193308e-03f, 4.46855575e-02f, -7.39345653e-03f, -1.33748902e-02f, 4.68471423e-02f, -1.90162174e-02f, -6.48170114e-02f, -4.11514118e-02f, -3.92355248e-02f,
  1.21766422e-02f, 1.87233072e-02f, -4.64646518e-02f, -1.27477916e-02f, 1.00564761e-02f, 3.36508639e-02f, -5.70845269e-02f, 3.99810029e-03f, -2.93170959e-02f, 2.68425085e-02f,
  -4.70726052e-03f, 2.11783927e-02f, 2.85445806e-02f, -2.19255723e-02f, -3.93903442e-02f, 8.16246867e-03f, 6.28565857e-03f, 5.37902825e-02f, 3.79503965e-02f, -6.13152655e-03f,
  5.47632249e-03f, -1.60748828e-02f, 9.73502640e-03f, 5.33762239e-02f, -3.06138266e-02f, 1.79247111e-02f, -7.13164359e-02f, 8.21733475e-02f, -5.17960750e-02f, -6.93939850e-02f,
  -4.10219580e-02f, 1.98775306e-01f, -6.12124205e-02f, -1.56695419e-03f, -3.46106067e-02f, -6.99098641e-03f, 1.58949681e-02f, 4.16634679e-02f, -5.81818707e-02f, 4.84189838e-02f,
  5.69468327e-02f, -5.34316301e-02f, 1.95628870e-02f, 1.46141173e-02f, 2.67020930e-02f, 1.92319918e-02f, -3.29612009e-02f, 3.16406824e-02f, -2.54178271e-02f, 7.21201077e-02f,
  7.61968642e-02f, 3.25451121e-02f, -7.83668889e-04f, -5.33680171e-02f, -4.27613743e-02f, 2.15080343e-02f, 5.66029511e-02f, 4.35253792e-02f, 8.54720995e-02f, 3.27880867e-02f,
  -8.95555094e-02f, 2.78119862e-01f, 4.55935858e-02f, 1.19663671e-01f, -2.05655843e-01f, -3.90391618e-01f, -2.96939731e-01f, 2.65189260e-02f, 2.21505299e-01f, 1.24731131e-01f,
  -7.33691454e-02f, 1.05372690e-01f, -3.28396149e-02f, -8.97990763e-02f, -9.41099748e-02f, 8.57427791e-02f, -1.81604177e-01f, -6.26122802e-02f, 7.58797079e-02f, 4.76452522e-02f,
  -2.57575549e-02f, -1.15845010e-01f, -5.34275621e-02f, -1.78029910e-02f, -1.55267641e-01f, 5.71739711e-02f, 8.20203125e-02f, -8.11773986e-02f, -3.33007984e-02f, -4.17969152e-02f,
  -1.03955500e-01f, 1.31907836e-01f, 9.24585667e-03f, 2.56103110e-02f, -6.05239570e-02f, -1.38418540e-01f, -2.17955448e-02f, -8.62165019e-02f, 5.95835270e-03f, -1.02421334e-02f,
  -9.11081396e-03f, -3.59064303e-02f, 7.60169327e-02f, 1.57263875e-02f, -8.02236889e-03f, 5.40720709e-02f, -1.42941000e-02f, -1.36600696e-02f, -3.68161425e-02f, -1.44821936e-02f,
  -2.86462829e-02f, -6.12307675e-02f, -2.48059966e-02f, 2.98143402e-02f, -5.39681362e-03f, -4.50934917e-02f, 5.25181890e-02f, -7.24476110e-03f, -3.72959711e-02f, 5.65830134e-02f,
  4.16115187e-02f, 2.53014658e-02f, 2.59013777e-03f, -4.18456569e-02f, 5.80095686e-02f, -2.22276580e-02f, -1.40036391e-02f, 2.60750242e-02f, 1.12855118e-02f, 1.73228944e-03f,
  2.01030280e-02f, 2.14187521e-02f, -4.43479605e-03f, 7.27335270e-03f, 3.91381495e-02f, -1.10828457e-02f, 4.07242775e-02f, -9.81793390e-04f, -3.58964205e-02f, 1.05376411e-02f,
  6.92697838e-02f, -3.81739251e-02f, 5.71118109e-02f, -1.00506753e-01f, -4.21682522e-02f, -8.06850195e-03f, 7.21091554e-02f, 6.77128211e-02f, 3.95808071e-02f, -9.70554352e-02f,
  3.37980292e-03f, 2.42886439e-01f, 1.07054539e-01f, 4.41377722e-02f, 3.29651497e-02f, -1.19202705e-02f, -5.23238350e-03f, 5.68969287e-02f, 4.34856229e-02f, -5.60194403e-02f,
  -8.46706554e-02f, 5.08585609e-02f, -1.86654634e-03f, -4.85155098e-02f, 1.93063337e-02f, 4.31453139e-02f, 4.92692478e-02f, 2.28095520e-02f, -9.88445058e-03f, 4.08088453e-02f,
  2.19553132e-02f, -3.01037487e-02f, -1.90847795e-02f, -4.39859703e-02f, 1.51621108e-03f, 4.41690795e-02f, -4.23048176e-02f, 2.98765302e-02f, -2.48637795e-03f, -4.79203165e-02f
};

// L0_fan_Wp_bar (Shape: 26 x 120)
const int L0_fan_Wp_bar_rows = 26;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  7.12431744e-02f, -3.27815786e-02f, -1.60958655e-02f, -1.34322584e-01f, 1.10461954e-02f, 1.47983670e-01f, 1.40322313e-01f, 3.27173769e-02f, 4.71938625e-02f, 1.38505891e-01f,
  5.93997799e-02f, 3.73572186e-02f, 1.21171504e-01f, 8.93764943e-02f, -1.25243310e-02f, 9.60654542e-02f, -1.64976083e-02f, 1.27522022e-01f, 4.89330851e-02f, 4.19304594e-02f,
  -1.07676625e-01f, 2.10299864e-02f, 1.66493524e-02f, 3.39773335e-02f, -2.96985414e-02f, -4.48303521e-02f, 2.66652200e-02f, -1.36127500e-02f, 7.66478479e-02f, 7.17421547e-02f,
  5.07417805e-02f, -5.49196973e-02f, 5.77174686e-02f, 3.83776464e-02f, 8.63142982e-02f, 1.82571057e-02f, 7.97502026e-02f, 4.33006696e-02f, 4.71945554e-02f, -5.05202673e-02f,
  8.68906453e-02f, 4.89310920e-02f, -1.59237180e-02f, -8.65751058e-02f, -3.08938827e-02f, -3.43508460e-02f, -7.00688586e-02f, 6.18902668e-02f, -2.68088914e-02f, 2.48864703e-02f,
  -6.06998466e-02f, -7.68039972e-02f, -4.87259775e-02f, -2.62296926e-02f, -7.64349103e-02f, -5.09397089e-02f, -3.73076461e-02f, 2.80547589e-02f, -4.34863530e-02f, -4.62050252e-02f,
  -2.45583653e-02f, 6.41885921e-02f, 3.29109728e-02f, -3.38388309e-02f, -5.75314313e-02f, -7.65746227e-03f, 4.59100045e-02f, -3.37080471e-02f, -5.05014658e-02f, 4.15280424e-02f,
  -6.22089840e-02f, -2.91970279e-03f, -2.82859839e-02f, -1.71390548e-02f, 7.05339685e-02f, -1.23227369e-02f, -5.77295087e-02f, -6.24127015e-02f, -1.93215795e-02f, -7.83350542e-02f,
  4.02767286e-02f, -1.77761745e-02f, 4.58658487e-02f, -4.77757454e-02f, -7.25657791e-02f, -3.72878127e-02f, -3.60080898e-02f, -1.69673767e-02f, -3.68630439e-02f, -1.23624865e-03f,
  1.23857046e-02f, 3.35698761e-02f, -5.55670783e-02f, 5.81916906e-02f, 8.09986815e-02f, 1.19391955e-01f, 6.09498611e-03f, 6.37061382e-03f, 1.31306006e-02f, -2.10306235e-02f,
  1.08323116e-02f, 7.38193020e-02f, -5.51989675e-02f, -7.13645201e-03f, -7.97154754e-02f, 5.76220267e-02f, -1.89404115e-02f, -3.58544886e-02f, -5.89995831e-02f, -1.64670926e-02f,
  3.15872543e-02f, -5.89007400e-02f, -7.68330544e-02f, 4.57461104e-02f, 2.00639921e-03f, 2.09879298e-02f, 4.34461236e-02f, -8.38632062e-02f, 3.90693694e-02f, -8.62963647e-02f,
  1.03123806e-01f, -7.38271922e-02f, 2.46514357e-03f, 8.21493939e-02f, -7.07014948e-02f, 8.18067417e-02f, 6.62508374e-03f, -1.14107698e-01f, -1.02609731e-02f, 3.19347270e-02f,
  8.73903371e-03f, -4.02238593e-02f, -9.04277936e-02f, -7.87227321e-03f, 2.77939625e-02f, -4.79413159e-02f, 9.16610584e-02f, 1.23066574e-01f, -3.63107510e-02f, -4.42395173e-02f,
  -9.55605228e-03f, 1.52580058e-02f, -1.09408036e-01f, 4.97846343e-02f, 2.72192769e-02f, -1.95920914e-02f, -8.89954194e-02f, -4.49109823e-02f, -1.43028405e-02f, 1.11116096e-01f,
  1.08806096e-01f, 6.30967505e-03f, 4.42268886e-02f, -1.91210732e-02f, -2.57734824e-02f, 7.73718432e-02f, 3.76857258e-02f, 5.74995615e-02f, 6.52056187e-02f, -7.68485293e-02f,
  8.86830091e-02f, 5.91958081e-03f, 4.36505266e-02f, 6.33180514e-02f, 1.80765316e-02f, 6.79557323e-02f, -4.23754863e-02f, -8.45853761e-02f, 3.36741172e-02f, 2.23608082e-03f,
  -9.28759798e-02f, -8.61749053e-02f, -4.18287255e-02f, 4.36164774e-02f, -9.57809687e-02f, -3.14349332e-03f, 8.41309875e-03f, 2.13539284e-02f, 5.07739037e-02f, 1.78048983e-02f,
  8.89228210e-02f, -6.16573989e-02f, -7.60083348e-02f, 5.52255623e-02f, 1.78813804e-02f, -1.38470046e-02f, -7.83611089e-03f, 2.37073544e-02f, 5.58444411e-02f, 7.77738215e-03f,
  -6.45985603e-02f, -2.85378378e-02f, 1.63102672e-02f, 1.27345361e-02f, -3.34794484e-02f, -1.82359642e-03f, -1.47172334e-02f, -6.92906231e-02f, -7.32584447e-02f, 2.50971112e-02f,
  -3.97032909e-02f, -7.63216615e-02f, -2.83842310e-02f, -2.20704600e-02f, 8.42693076e-02f, -3.26562338e-02f, 2.70286594e-02f, 4.57532927e-02f, 9.90537088e-03f, -6.09909557e-02f,
  8.59146342e-02f, -6.83466643e-02f, 7.06230178e-02f, -6.37812614e-02f, 1.52972713e-03f, 1.37090189e-02f, -2.01407708e-02f, 6.36007786e-02f, 3.20543200e-02f, 3.20147760e-02f,
  1.35846436e-02f, -4.57627028e-02f, -8.16790611e-02f, 3.41674313e-02f, -3.25069912e-02f, -9.17457342e-02f, 7.65420720e-02f, 7.71873146e-02f, -9.58608987e-04f, -2.16755274e-04f,
  -5.14053404e-02f, 5.60669377e-02f, 6.81908727e-02f, 3.14116031e-02f, -7.19678700e-02f, -8.81559178e-02f, 9.11416784e-02f, -7.95720145e-02f, -2.00795531e-02f, 1.24814333e-02f,
  3.65366079e-02f, -1.16935499e-01f, -9.74820703e-02f, 5.34472428e-02f, 2.06840448e-02f, -6.50420319e-03f, 8.58572945e-02f, -8.44394863e-02f, 1.10840602e-02f, 6.44320399e-02f,
  4.25172448e-02f, -6.95361150e-03f, 4.43754010e-02f, 9.55498889e-02f, -1.82730835e-02f, 1.38064781e-02f, 1.34332523e-01f, 1.07131340e-01f, -2.42516231e-02f, -2.17125891e-03f,
  4.62037213e-02f, 8.02624673e-02f, -1.98018923e-02f, 7.09448010e-02f, -6.87201917e-02f, -1.75257456e-02f, -2.28306949e-02f, 4.23492165e-03f, 9.76476297e-02f, 1.44195752e-02f,
  6.12332672e-02f, -3.33843683e-03f, -2.34006494e-02f, 4.71414365e-02f, 1.48653015e-02f, 8.51076543e-02f, 5.34456931e-02f, -6.36746064e-02f, 5.89547120e-03f, 1.78843569e-02f,
  -3.18866260e-02f, -8.57564211e-02f, -2.69442219e-02f, -6.54908121e-02f, 1.38975987e-02f, 1.52524430e-02f, -3.25874835e-02f, -9.43108723e-02f, -2.99952012e-02f, 4.46225666e-02f,
  -6.23018518e-02f, -3.98545377e-02f, 1.82240568e-02f, 7.19739590e-03f, -5.18050343e-02f, -2.55502127e-02f, -6.84030056e-02f, 1.64865814e-02f, -4.82502347e-03f, 6.63423613e-02f,
  6.57288507e-02f, -1.45962089e-02f, -2.55166814e-02f, -6.18420616e-02f, -4.31372337e-02f, -3.21129151e-02f, 7.81785399e-02f, 3.81242819e-02f, 7.74997398e-02f, -5.63762821e-02f,
  5.72702512e-02f, -6.92924932e-02f, 7.48380721e-02f, -3.44861648e-03f, -1.24189584e-02f, -2.54235771e-02f, -5.36995893e-03f, -1.10561112e-02f, 5.80335036e-02f, -4.98202704e-02f,
  5.80785908e-02f, 2.01962423e-02f, -5.40277958e-02f, -6.60101026e-02f, -1.74872410e-02f, 4.42384817e-02f, 1.01187766e-01f, 7.16712400e-02f, 3.32792923e-02f, -3.80217209e-02f,
  5.14392629e-02f, -9.74279642e-02f, 1.96243897e-02f, 5.04853651e-02f, -3.13581200e-04f, 2.59409603e-02f, 5.49489744e-02f, 8.29882994e-02f, 3.19712311e-02f, -1.60682257e-02f,
  4.73666415e-02f, -3.86644453e-02f, 6.29682615e-02f, 2.56883334e-02f, -3.36539187e-02f, 2.49377340e-02f, 7.39839226e-02f, 1.02399308e-02f, 7.74607062e-03f, -7.00643510e-02f,
  -9.64227766e-02f, -5.37713766e-02f, 5.11799008e-02f, 6.49988949e-02f, -3.73944007e-02f, -2.80726235e-02f, -1.93680767e-02f, -8.19460899e-02f, -5.16861975e-02f, 1.93197653e-02f,
  -5.84446751e-02f, 6.13982156e-02f, 2.11920030e-02f, -4.27553877e-02f, 7.29007497e-02f, -1.95438471e-02f, 5.14329039e-02f, 9.52418968e-02f, -3.37843448e-02f, 4.25092317e-02f,
  9.89423469e-02f, 5.57848401e-02f, -2.47482024e-02f, 2.42877472e-02f, 3.57143357e-02f, 2.36993991e-02f, -4.11970615e-02f, 7.03037158e-02f, 2.57057697e-02f, 8.13770443e-02f,
  -7.83958822e-04f, -3.20706028e-03f, -7.50396475e-02f, -3.48835774e-02f, 4.14379500e-02f, -1.00473188e-01f, 8.52185488e-02f, -1.37203848e-02f, -2.17409655e-02f, -1.11616275e-03f,
  4.70027290e-02f, 1.70665924e-02f, 4.90141697e-02f, 1.07690580e-02f, -6.30863458e-02f, 3.06952037e-02f, -2.93640811e-02f, 4.33903188e-02f, -2.87891869e-02f, 1.90754496e-02f,
  2.26626899e-02f, 1.03253620e-02f, 5.21944612e-02f, -2.80156024e-02f, -8.76867622e-02f, 5.64086288e-02f, -8.94985572e-02f, -8.41600150e-02f, -7.18277395e-02f, 1.55630037e-02f,
  -3.80634293e-02f, 5.62478676e-02f, -5.71564287e-02f, 6.16704449e-02f, -5.45343570e-02f, -7.56522268e-02f, -5.67893572e-02f, -3.40120532e-02f, 5.95949441e-02f, -6.12793900e-02f,
  -2.02861591e-03f, -8.38601962e-02f, 3.83637287e-02f, -1.95295475e-02f, -3.07432413e-02f, -4.79074195e-02f, 1.32590514e-02f, -4.47165966e-03f, 2.38721408e-02f, 4.33668308e-02f,
  -2.59822980e-02f, -1.11463144e-02f, 7.30142891e-02f, -5.96043468e-02f, -6.07245304e-02f, 7.41904899e-02f, 3.64147387e-02f, 4.28988487e-02f, -2.91771665e-02f, -7.59945288e-02f,
  -5.27237840e-02f, 1.17475623e-02f, -8.60038155e-04f, -1.63668171e-02f, 1.09294755e-02f, 8.01257342e-02f, -5.10674156e-02f, -6.51110383e-03f, 3.65032931e-03f, 7.79088959e-02f,
  1.72394402e-02f, 1.23316303e-01f, 9.47462842e-02f, -8.86850506e-02f, -3.90368178e-02f, -3.23752947e-02f, 2.62417793e-02f, -4.53486517e-02f, -2.01110560e-02f, -5.42709790e-02f,
  5.41224554e-02f, 6.16605394e-02f, 6.26758710e-02f, -2.01221346e-03f, -3.39708291e-02f, 8.72829258e-02f, 3.41699505e-03f, -1.97518691e-02f, -2.53265053e-02f, -5.35813086e-02f,
  -6.53631147e-03f, 1.85610577e-02f, 1.77982990e-02f, -4.06568497e-02f, -5.39962798e-02f, -1.16876597e-02f, -6.46253526e-02f, -8.15668404e-02f, 3.03663239e-02f, -4.24980745e-02f,
  5.99942803e-02f, -1.24321185e-01f, -6.29612058e-02f, -8.51491559e-03f, -4.21212651e-02f, 6.61334842e-02f, 5.94436340e-02f, -6.50907606e-02f, 8.94991830e-02f, -1.07727498e-01f,
  -1.30998001e-01f, 8.22625607e-02f, -1.04119383e-01f, -6.11948334e-02f, 8.77416581e-02f, -3.39792706e-02f, 9.91588831e-02f, -8.13045651e-02f, 4.78137564e-03f, -2.42802165e-02f,
  7.75171118e-03f, 5.25561124e-02f, -4.86652069e-02f, -7.92802274e-02f, 5.69176711e-02f, 7.59592950e-02f, 2.14381535e-02f, -3.38943452e-02f, -6.20973147e-02f, 5.45864366e-02f,
  -1.21253179e-02f, -1.61398482e-02f, 1.59184802e-02f, -1.17126564e-02f, -2.45748833e-02f, -1.44827738e-02f, -3.15672122e-02f, 8.40083696e-03f, 4.00108472e-02f, -4.54052687e-02f,
  -8.14792588e-02f, -3.40160429e-02f, -9.21879720e-04f, -2.25139083e-03f, -1.41863916e-02f, -4.83676791e-02f, -1.10151414e-02f, -7.80274272e-02f, -2.46069003e-02f, -6.34850487e-02f,
  -9.79189202e-02f, 2.58884598e-02f, -2.65193358e-03f, 4.30795886e-02f, 1.60472207e-02f, 5.28359748e-02f, 5.48598841e-02f, -5.30136935e-02f, 5.77442124e-02f, 7.92918876e-02f,
  -8.37779418e-02f, -1.85761750e-02f, 4.68266606e-02f, -4.02775742e-02f, -3.94262513e-03f, -7.55850673e-02f, -5.29673994e-02f, 9.08499584e-02f, 2.66111922e-02f, 9.58080404e-03f,
  -5.33699878e-02f, 8.55409130e-02f, 3.98611687e-02f, -3.54889072e-02f, 4.65884134e-02f, 8.71825069e-02f, 2.91606672e-02f, -1.12308599e-02f, -8.91643241e-02f, 2.79289484e-02f,
  2.86100395e-02f, -5.43416627e-02f, 8.15376814e-04f, 1.14813456e-02f, 1.61348395e-02f, -2.71382499e-02f, -4.92567159e-02f, 7.19188675e-02f, -3.85010913e-02f, -4.87348288e-02f,
  5.73612638e-02f, 4.55564708e-02f, -9.05266255e-02f, -6.87691942e-02f, 5.85787669e-02f, -7.55669996e-02f, -1.50552643e-02f, 8.29905123e-02f, -1.47764860e-02f, 8.41578096e-02f,
  -5.02183437e-02f, 4.58769687e-02f, -1.65815726e-02f, 2.44195778e-02f, 3.77816595e-02f, 5.07089235e-02f, -4.08279821e-02f, 1.20017231e-02f, -8.28869194e-02f, 3.23405825e-02f,
  -5.05999364e-02f, 2.15240773e-02f, 8.98452774e-02f, 1.96015704e-02f, 6.27597347e-02f, -5.86031415e-02f, -3.90059873e-02f, 5.65863177e-02f, 3.01730204e-02f, -3.64706898e-03f,
  7.89030083e-03f, -5.37563004e-02f, 7.26435333e-04f, 2.77208481e-02f, -7.42895668e-03f, 4.82984670e-02f, -5.78282997e-02f, 8.23935866e-02f, -1.96003579e-02f, -1.41561002e-01f,
  1.62606444e-02f, 7.41299912e-02f, 2.25395965e-03f, -1.35573298e-01f, 3.27945128e-02f, -5.93850240e-02f, -8.80929679e-02f, -7.05662370e-02f, 3.45976092e-02f, -2.57948078e-02f,
  3.14836688e-02f, -8.14989060e-02f, 6.56801164e-02f, 4.92579266e-02f, -1.39721856e-02f, -8.36571455e-02f, -3.17585431e-02f, 7.46816630e-03f, -5.05291298e-02f, 6.91763759e-02f,
  3.10233906e-02f, -2.00172924e-02f, -7.05346540e-02f, -9.25427303e-02f, -9.57835615e-02f, -2.93389373e-02f, -7.22587928e-02f, -3.29602323e-02f, 9.98621155e-03f, -1.59659845e-04f,
  -8.39058682e-02f, 7.33118737e-03f, 1.58095490e-02f, -5.81536032e-02f, 6.27326444e-02f, -7.63679817e-02f, -9.08522774e-03f, 8.59083310e-02f, -5.52630648e-02f, 1.08673774e-01f,
  9.53477770e-02f, 2.50759739e-02f, -7.67741061e-04f, -7.57863969e-02f, 4.03753333e-02f, 5.33909611e-02f, 4.50941995e-02f, -7.29286522e-02f, 7.37714320e-02f, -7.67441690e-02f,
  1.30544268e-02f, -1.53910834e-02f, -4.92561907e-02f, 7.50818178e-02f, -4.40833755e-02f, -7.15281814e-02f, -5.29057123e-02f, -8.87290835e-02f, 2.73535997e-02f, 1.21950051e-02f,
  -3.80923972e-02f, 5.39113432e-02f, -7.71318525e-02f, -6.15595607e-04f, -1.74540449e-02f, -8.90269130e-02f, -5.12675531e-02f, -2.17574127e-02f, -5.00187613e-02f, 1.55607015e-02f,
  -1.25071323e-02f, -1.49038499e-02f, 6.77133873e-02f, -4.18831371e-02f, -2.87912451e-02f, 5.32700531e-02f, -9.31748822e-02f, 7.74322674e-02f, -4.36940510e-03f, -4.17304076e-02f,
  5.07621132e-02f, -9.84691232e-02f, -9.23849121e-02f, -7.26412311e-02f, 3.16021219e-02f, 5.26625030e-02f, -2.91120876e-02f, 2.18462292e-03f, -8.60144570e-02f, 6.27707019e-02f,
  -3.51085551e-02f, -3.38362791e-02f, 3.52132991e-02f, 4.77516092e-02f, 8.61265361e-02f, -7.82604069e-02f, -1.20436838e-02f, 3.98583226e-02f, -8.68674591e-02f, 9.87307727e-02f,
  -7.13705122e-02f, -6.29899204e-02f, -3.84135805e-02f, 3.26352902e-02f, -3.14172022e-02f, -9.64098945e-02f, -8.41217637e-02f, 2.61462517e-02f, -6.78923428e-02f, 5.03301658e-02f,
  -6.83348700e-02f, -5.50713353e-02f, -1.21579915e-01f, 6.85164034e-02f, -1.12581760e-01f, 8.92905798e-03f, 1.20467339e-02f, -7.84854069e-02f, 1.03801511e-01f, 1.04450295e-02f,
  -5.03437519e-02f, -6.72297459e-03f, 4.93854173e-02f, 3.47348340e-02f, -1.12106442e-03f, 1.38352484e-01f, -1.77215040e-02f, -6.24035038e-02f, -2.88285166e-02f, -3.15760970e-02f,
  -2.41207220e-02f, -6.92749619e-02f, 3.79789248e-02f, 1.53518785e-02f, -1.36800781e-01f, -1.36431335e-02f, -9.61518139e-02f, -7.40017667e-02f, -1.25977322e-01f, -5.71243800e-02f,
  -4.56599519e-02f, 9.88003612e-02f, -9.29198414e-02f, 7.70436078e-02f, -4.85251434e-02f, -5.35106808e-02f, 4.84283157e-02f, 5.22912592e-02f, -1.53696239e-02f, 8.12878832e-02f,
  2.91631278e-02f, -6.01119958e-02f, 4.69028987e-02f, 6.69042626e-03f, -9.66533925e-03f, -1.98758841e-02f, 3.03266607e-02f, 2.63355672e-02f, 4.90455925e-02f, -3.96795608e-02f,
  6.04861304e-02f, -7.83029795e-02f, -9.84010398e-02f, 6.87600374e-02f, -9.48418379e-02f, -3.08943465e-02f, 2.03636996e-02f, 5.30035514e-03f, -3.35067115e-03f, -2.63118967e-02f,
  -6.95411814e-03f, -8.49447325e-02f, 5.28698713e-02f, -3.00048362e-03f, -3.27733415e-03f, 5.57957031e-02f, 6.26763180e-02f, 6.97088912e-02f, 1.55314279e-03f, -6.94775060e-02f,
  1.87449604e-02f, 2.74101049e-02f, -1.99558828e-02f, 2.28622574e-02f, -1.78199075e-02f, 2.23587360e-02f, -7.48325661e-02f, 7.53369182e-02f, -8.23902264e-02f, 7.05242977e-02f,
  8.38240534e-02f, -4.14443240e-02f, -7.38248453e-02f, -7.26030394e-02f, -5.50658293e-02f, -4.75263931e-02f, 3.92515808e-02f, 4.59558591e-02f, -7.95504898e-02f, 1.91908497e-02f,
  8.37186724e-02f, 1.37861356e-01f, 1.06545575e-02f, 7.65815098e-03f, -8.64567161e-02f, 1.36736194e-02f, 9.79988463e-03f, -5.28194308e-02f, 6.63792640e-02f, -2.86235530e-02f,
  -1.95361786e-02f, 4.49608862e-02f, 3.89087908e-02f, -3.21168117e-02f, -5.44470735e-02f, -6.68784752e-02f, -2.64467038e-02f, -2.54234914e-02f, -5.29797226e-02f, 3.89067531e-02f,
  -1.66484457e-03f, 2.41627824e-02f, 2.41007619e-02f, 7.25188926e-02f, 3.03904880e-02f, 4.04060706e-02f, 3.33363302e-02f, 3.71898487e-02f, 3.43556628e-02f, 5.26344292e-02f,
  7.89361298e-02f, -8.27159062e-02f, -6.89856634e-02f, 5.22220805e-02f, 1.25406817e-01f, 1.13848224e-01f, 5.57527542e-02f, 1.00018084e-01f, 1.64376311e-02f, 5.63735813e-02f,
  -1.13237202e-02f, 3.21612358e-02f, -1.35466214e-02f, 1.20488539e-01f, 1.20444439e-01f, 6.44228160e-02f, 7.57793263e-02f, 2.44817436e-02f, -7.19032586e-02f, 1.86828822e-02f,
  8.72818828e-02f, -2.44875550e-02f, -4.79269587e-02f, -1.06592752e-01f, -1.07304053e-02f, -7.02658743e-02f, -1.21295914e-01f, -1.04546182e-01f, -6.37946054e-02f, 5.57898618e-02f,
  6.24677539e-02f, -2.98812035e-02f, -6.77308142e-02f, 8.01886097e-02f, -3.34183313e-02f, -1.62666999e-02f, -9.63575840e-02f, 4.79219593e-02f, -1.94923785e-02f, 1.04885572e-03f,
  4.83528599e-02f, -5.65504804e-02f, 1.06283024e-01f, -8.28208402e-02f, -3.22277360e-02f, -4.77834698e-03f, 2.77053546e-02f, -4.48657013e-02f, -9.67867002e-02f, 5.80756702e-02f,
  5.06778471e-02f, 7.28260428e-02f, -2.70690992e-02f, -6.61760103e-03f, 1.57772936e-02f, 6.99494928e-02f, -5.20741157e-02f, -9.38683748e-02f, -4.50756140e-02f, 1.81224179e-02f,
  -3.55427079e-02f, 9.73644257e-02f, -1.52839581e-02f, 3.76992300e-02f, 3.61639559e-02f, -4.84102145e-02f, 7.65264630e-02f, -1.95961706e-02f, -1.91441868e-04f, 4.04606946e-02f,
  -1.43014705e-02f, 5.03434986e-02f, -6.50635511e-02f, -5.78881055e-02f, 4.87605073e-02f, -5.91463521e-02f, -4.10112329e-02f, 5.19093685e-02f, -1.01909330e-02f, 6.48688078e-02f,
  -6.84067905e-02f, 8.39790795e-03f, -8.90760124e-02f, 1.41944923e-02f, -2.01035570e-02f, -7.05039203e-02f, 2.20496929e-03f, 6.91133225e-03f, -8.89681745e-03f, -5.96902892e-02f,
  7.50602856e-02f, 4.49827053e-02f, -1.15826810e-02f, 7.00835586e-02f, -8.79696757e-02f, 3.84999663e-02f, 8.29809383e-02f, 8.31760392e-02f, -3.15872170e-02f, -3.02072130e-02f,
  3.60778347e-02f, -3.78422663e-02f, 1.01240881e-01f, 3.41113843e-02f, -4.06454280e-02f, -7.98119418e-03f, 6.53806422e-03f, 8.10637418e-03f, 3.80433351e-02f, 6.67704120e-02f,
  -1.02874078e-02f, -7.32810721e-02f, -4.60975058e-02f, 4.05485043e-03f, -4.86878864e-02f, -1.96055286e-02f, 2.37102285e-02f, -5.79231232e-02f, 3.68165672e-02f, 1.36425970e-02f,
  8.27691779e-02f, -1.75715126e-02f, -1.09005585e-01f, -7.96254948e-02f, -6.46144077e-02f, -1.09561130e-01f, -1.45585850e-01f, -1.40648270e-02f, -7.01300651e-02f, 3.09638567e-02f,
  -7.14048743e-02f, 2.42482591e-02f, 1.00477755e-01f, 7.24190241e-03f, 2.45919004e-02f, 6.61028177e-02f, -5.52267395e-02f, -1.01841144e-01f, 7.53649995e-02f, -2.58137193e-02f,
  6.54086471e-02f, -4.55913953e-02f, 4.77829427e-02f, 5.48440628e-02f, 2.39877943e-02f, -1.28892735e-02f, 2.30345540e-02f, -5.31561598e-02f, -1.18236236e-01f, 6.66516125e-02f,
  6.86947927e-02f, 4.23928071e-03f, -7.64100850e-02f, -4.57848012e-02f, -1.50943417e-02f, 7.48968078e-03f, 4.44726348e-02f, 7.27396235e-02f, 8.39594081e-02f, -9.64417532e-02f,
  9.26681310e-02f, -2.39945035e-02f, 3.16047817e-02f, -2.89979354e-02f, -4.48114015e-02f, -5.59795275e-03f, -6.86538685e-03f, -5.85274138e-02f, -7.83108454e-03f, -8.69633406e-02f,
  -2.92487927e-02f, 6.90412745e-02f, 2.79898066e-02f, -5.79305999e-02f, 5.56627735e-02f, -1.26847485e-02f, -6.75910488e-02f, -5.21411980e-03f, 4.70211580e-02f, -8.40170961e-03f,
  -1.09201027e-02f, 7.54429996e-02f, -3.71690616e-02f, 6.78931624e-02f, -3.52867693e-02f, 7.00268671e-02f, 2.42902786e-02f, -7.74313463e-03f, -1.00675821e-01f, -8.06383938e-02f,
  -1.55213634e-02f, 1.89058930e-02f, 2.27443930e-02f, -4.53789458e-02f, -8.54974315e-02f, 2.24299747e-02f, 8.36656317e-02f, 1.58974975e-02f, -4.13162857e-02f, -8.83168504e-02f,
  -2.41270997e-02f, 5.11381291e-02f, -7.44425654e-02f, 2.74915937e-02f, -4.92826737e-02f, -3.04314513e-02f, 9.33146924e-02f, 3.52755608e-03f, 6.05163053e-02f, 4.91933823e-02f,
  -5.43977283e-02f, -1.19638222e-03f, 4.32106592e-02f, -6.54885545e-02f, 3.53677794e-02f, 5.10209613e-02f, 5.01675019e-03f, -8.09971467e-02f, 5.85968718e-02f, -7.17748404e-02f,
  1.80290092e-03f, -6.24929965e-02f, 8.38633031e-02f, -7.43438005e-02f, -3.32267061e-02f, 2.55565904e-02f, -4.42403965e-02f, -2.59410720e-02f, -2.32165703e-03f, -5.82301617e-02f,
  -5.46469130e-02f, 5.54001555e-02f, -5.29039428e-02f, -5.09470887e-02f, -6.70047328e-02f, -2.55557871e-03f, -6.17920272e-02f, -6.66839555e-02f, 5.27516305e-02f, 4.14642692e-02f,
  2.43557673e-02f, 1.27658382e-01f, 8.95910710e-02f, -9.46271867e-02f, -2.48175184e-03f, 6.52940338e-03f, -6.22344725e-02f, 5.97406663e-02f, 4.09852788e-02f, 3.19881103e-04f,
  -1.32579401e-01f, -2.84145996e-02f, 1.06619194e-01f, -1.20459385e-01f, 9.97423530e-02f, -5.92677146e-02f, -1.19886570e-01f, -1.20897643e-01f, -3.22659090e-02f, -1.17940456e-01f,
  7.39852861e-02f, -1.03694044e-01f, 1.76103767e-02f, 1.32280577e-03f, -1.20680466e-01f, 6.03623614e-02f, -6.96630105e-02f, 6.43820986e-02f, -9.33019444e-02f, -5.85339479e-02f,
  -1.19067291e-02f, -8.78427774e-02f, -7.07863793e-02f, 5.88437133e-02f, 1.88156851e-02f, -4.63088453e-02f, -7.69533962e-02f, -6.28048778e-02f, -4.11656313e-02f, 1.01884596e-01f,
  7.93713480e-02f, -4.70169894e-02f, 4.88784455e-04f, 5.28810769e-02f, -4.72449884e-02f, -5.90057485e-02f, 7.05033317e-02f, -8.60052481e-02f, 9.30262078e-03f, 8.56944025e-02f,
  7.16250315e-02f, -8.92802626e-02f, -1.43164676e-02f, -9.09387693e-02f, -8.64985213e-02f, -3.24776620e-02f, 2.73775142e-02f, 2.09065452e-02f, 9.37061757e-03f, -7.52889588e-02f,
  -7.00521991e-02f, -1.82558652e-02f, 5.51565625e-02f, -2.20224857e-02f, -8.97823647e-02f, 8.49974900e-02f, -9.01481137e-03f, -6.45689815e-02f, 5.45848832e-02f, 2.42191758e-02f,
  -3.57258469e-02f, 4.29811962e-02f, -5.21727428e-02f, -3.56081501e-02f, -3.75394337e-02f, -2.77419966e-02f, -4.34166193e-02f, 8.46544281e-02f, -3.02446610e-03f, -6.10269457e-02f,
  -7.44904429e-02f, -2.67155636e-02f, 6.10487647e-02f, 6.99882489e-03f, 5.26381955e-02f, 3.34392823e-02f, 2.59278086e-03f, 3.76356989e-02f, 4.72701192e-02f, 5.61619066e-02f,
  -1.50179341e-02f, 1.93597395e-02f, -7.76569173e-02f, 2.10974971e-03f, -5.47833135e-03f, -5.30579768e-04f, -5.56533821e-02f, 9.24557373e-02f, 4.54408117e-04f, 3.40671241e-02f,
  -6.39646277e-02f, 7.38982037e-02f, -1.21394182e-02f, -2.63006485e-04f, 7.16644898e-02f, 4.84970361e-02f, 6.09874390e-02f, 8.58614314e-03f, 5.14086038e-02f, -1.23062469e-02f,
  3.43405679e-02f, 1.96122546e-02f, -3.31224985e-02f, 5.07473312e-02f, 1.37908692e-02f, -6.81173280e-02f, 8.04950669e-02f, -4.42930171e-03f, 3.29627506e-02f, 8.01561177e-02f,
  1.32689357e-01f, 1.29503176e-01f, -4.75084700e-04f, -6.03754334e-02f, -1.01033315e-01f, -7.29912966e-02f, -6.47735130e-03f, -1.03845581e-01f, 7.88647160e-02f, -4.34383936e-02f,
  -6.01852359e-03f, 1.42889097e-01f, -5.61498329e-02f, -7.75154978e-02f, -7.31598511e-02f, -1.14837578e-02f, -8.03113654e-02f, 8.56849924e-03f, -5.76903448e-02f, -5.66317998e-02f,
  4.33198884e-02f, -1.05396077e-01f, 4.54539806e-02f, -8.09918065e-03f, -8.50914121e-02f, 9.34508815e-03f, 2.42661964e-02f, -9.80369449e-02f, 9.82951000e-02f, -1.83597915e-02f,
  -4.85480251e-03f, 2.36573145e-02f, 2.82504801e-02f, 5.92707358e-02f, -3.21860686e-02f, -7.87096992e-02f, -1.81469563e-02f, 5.51042221e-02f, -8.62064213e-02f, 8.28080624e-02f,
  -4.11980487e-02f, -3.39010358e-02f, 6.05656095e-02f, 6.63621526e-04f, -7.99391121e-02f, 1.70806386e-02f, 6.62754476e-02f, -1.58606330e-03f, 5.30604459e-02f, 3.02102305e-02f,
  6.49251640e-02f, -5.90431169e-02f, -1.09264618e-02f, 8.90285224e-02f, 3.53939496e-02f, 2.62580737e-02f, 2.24337750e-03f, 5.00935577e-02f, -5.12406696e-03f, 9.02360957e-03f,
  -4.84273136e-02f, 6.07558563e-02f, 9.39376259e-05f, 5.40926307e-02f, -1.03080254e-02f, -3.05330958e-02f, -4.04278636e-02f, 1.93120725e-02f, 3.74692008e-02f, 7.54156858e-02f,
  -4.17429395e-02f, -6.00050800e-02f, -2.16178037e-02f, -4.28502075e-02f, -2.43574809e-02f, 3.22821774e-02f, -8.05810243e-02f, 3.67479064e-02f, -3.53269242e-02f, 4.78997491e-02f,
  -9.90998521e-02f, 1.99022498e-02f, -4.62992210e-03f, -2.74382308e-02f, -4.36683856e-02f, 1.67210121e-02f, 1.25794532e-02f, 7.45728686e-02f, 1.50459644e-03f, 6.25171885e-02f,
  -2.17300467e-02f, 5.69679439e-02f, 5.41942334e-03f, -1.07875923e-02f, 5.21819405e-02f, 9.01264846e-02f, -5.78547828e-02f, 9.36934203e-02f, 3.42561901e-02f, 8.84168744e-02f,
  5.35929687e-02f, 1.75031498e-02f, -8.34415928e-02f, 7.54804984e-02f, -7.38674402e-02f, -7.45143369e-02f, -5.72295785e-02f, -2.20510387e-03f, -7.07622990e-02f, -3.23430810e-04f,
  4.85618878e-03f, 5.01949526e-02f, -3.10319550e-02f, -5.81576116e-02f, 7.17584044e-02f, -4.00189683e-02f, -3.31578292e-02f, -5.80280945e-02f, 1.76967233e-02f, 2.53453218e-05f,
  3.51890996e-02f, 4.83507179e-02f, -2.29184963e-02f, -6.02683872e-02f, 6.34612069e-02f, -5.96274696e-02f, -7.19961897e-02f, 7.85421655e-02f, 3.57168987e-02f, 5.83930574e-02f,
  6.83047771e-02f, 8.73734206e-02f, -5.66151366e-02f, -3.70715819e-02f, -9.23506245e-02f, 4.43216860e-02f, -1.14738373e-02f, 5.97740598e-02f, -2.47758776e-02f, 3.11917290e-02f,
  -4.58239429e-02f, -8.58252794e-02f, -7.84854591e-02f, -8.82957801e-02f, 5.82839213e-02f, -6.57283887e-02f, -2.60329656e-02f, -6.13075532e-02f, -8.48270804e-02f, -5.93854077e-02f,
  -3.85304354e-02f, 5.65921441e-02f, 8.90971497e-02f, 6.22409396e-02f, -6.13507107e-02f, -4.17578444e-02f, 4.25061770e-02f, -2.13286579e-02f, -8.27420782e-03f, 5.38754426e-02f,
  -8.19794685e-02f, 7.94774815e-02f, 1.18237343e-02f, -6.41181096e-02f, 2.79753041e-02f, 3.11254933e-02f, -1.61960609e-02f, 2.76708305e-02f, 7.12063089e-02f, -9.21646506e-02f,
  5.95979914e-02f, -9.17159840e-02f, 3.83086801e-02f, 2.99461000e-02f, 1.47333099e-02f, -4.50124741e-02f, 4.83447202e-02f, 7.00528473e-02f, -4.74757999e-02f, 6.64549321e-02f,
  -5.23594692e-02f, 7.61399642e-02f, -3.77045870e-02f, -4.07277346e-02f, 1.94037575e-02f, 5.81550747e-02f, -8.93753618e-02f, -2.05880310e-02f, -1.47585338e-02f, -8.74276459e-02f,
  -6.75097946e-03f, 6.36774153e-02f, -4.46671061e-02f, -4.52752151e-02f, -8.10469594e-03f, -1.25698904e-02f, -6.79398030e-02f, -2.02557463e-02f, 8.04170792e-04f, 9.97111294e-03f,
  6.81851506e-02f, -4.63665761e-02f, -8.87578651e-02f, 4.06867638e-02f, 8.31071809e-02f, 2.04538330e-02f, 6.28366470e-02f, -8.88348818e-02f, 8.15724954e-02f, 4.07876931e-02f,
  3.11551038e-02f, -6.30815327e-02f, 7.35443085e-02f, 3.51177715e-02f, -5.93515858e-02f, 5.83379678e-02f, 8.14598054e-02f, -2.41675451e-02f, 6.74214065e-02f, -5.88624254e-02f,
  1.28767127e-02f, 8.78436193e-02f, 8.22913498e-02f, -9.12290961e-02f, 4.88176057e-03f, 7.50413314e-02f, -3.89311686e-02f, 8.42973068e-02f, -5.12609594e-02f, -9.53050256e-02f,
  1.63262319e-02f, 4.22452167e-02f, 7.82377049e-02f, 2.55790409e-02f, 4.42546234e-02f, 5.40879071e-02f, -1.42377801e-02f, 5.87890930e-02f, 4.03493531e-02f, -2.65193582e-02f,
  -2.07039684e-01f, 3.35035510e-02f, -9.10345912e-02f, -1.13607615e-01f, -9.67252906e-03f, -1.28505990e-01f, -8.47666804e-03f, -1.39613241e-01f, -9.31484178e-02f, 1.10651646e-02f,
  4.33374792e-02f, -1.30764330e-02f, 6.08485714e-02f, 8.54123980e-02f, -1.16142042e-01f, 1.32583737e-01f, -6.57056943e-02f, 6.25800863e-02f, 4.75514233e-02f, -9.48466957e-02f,
  -4.80653942e-02f, 9.59296152e-02f, -2.74742171e-02f, 9.79850069e-02f, -5.26766628e-02f, -8.42514262e-02f, 1.38101438e-02f, -5.52976467e-02f, 2.58064307e-02f, -3.74713875e-02f,
  1.07013024e-02f, -4.34865765e-02f, -7.32935369e-02f, 2.39008255e-02f, 6.03522873e-03f, -7.99762383e-02f, 4.94574383e-02f, -1.61006767e-02f, 2.49464530e-02f, -8.12822431e-02f,
  -2.64936648e-02f, 4.68245521e-03f, 1.31385513e-02f, 1.61472261e-02f, -5.88842891e-02f, 5.40036745e-02f, 6.61839172e-02f, 7.93133527e-02f, -4.09601144e-02f, 2.58300640e-02f,
  3.59921418e-02f, 1.30065228e-03f, -5.72530627e-02f, 2.15850491e-02f, 3.66094668e-04f, -6.67280778e-02f, -5.15820496e-02f, -6.74238652e-02f, -2.27328110e-02f, -5.98378899e-03f,
  -5.02245612e-02f, 2.08390672e-02f, -3.76188904e-02f, 1.02248989e-01f, -5.73935919e-02f, -5.19849397e-02f, -6.26725182e-02f, 6.25995696e-02f, 5.85018983e-03f, 4.26416025e-02f,
  -9.42610502e-02f, -4.01261263e-03f, -1.11931391e-01f, -9.85783264e-02f, -2.66317464e-03f, 3.89853813e-05f, -5.13742417e-02f, 8.48076195e-02f, 7.64857903e-02f, 3.11688501e-02f,
  -4.11160104e-02f, 6.66786879e-02f, -4.71667349e-02f, 7.20848367e-02f, -7.33983368e-02f, 1.80465896e-02f, -5.61472401e-02f, -6.53356314e-02f, -3.66697423e-02f, 2.32146750e-03f,
  -6.84526265e-02f, -1.24815792e-01f, 4.13482822e-02f, -7.20363855e-02f, 6.57341033e-02f, -1.11017093e-01f, -1.05845906e-01f, 3.85830067e-02f, -6.67679906e-02f, 1.43740671e-02f,
  -8.15577582e-02f, 6.78550154e-02f, -6.87566251e-02f, 1.04142264e-01f, 7.54598975e-02f, -1.82216447e-02f, -1.78605001e-02f, 6.93605747e-03f, 5.12893051e-02f, -1.96044520e-02f,
  4.27569933e-02f, -2.18695942e-02f, -4.02140245e-02f, -7.72436857e-02f, -9.04500932e-02f, -8.04555714e-02f, -1.02914020e-01f, -4.15883102e-02f, -6.89183548e-02f, 2.57868581e-02f,
  8.96989033e-02f, -1.54406652e-01f, -7.25586386e-03f, -3.92491966e-02f, 2.95495912e-02f, -2.15823483e-02f, -9.00175199e-02f, -1.08784966e-01f, -1.63335159e-01f, -9.54447016e-02f,
  1.01544864e-01f, 1.04159944e-01f, -3.72295976e-02f, 8.13602209e-02f, 1.53020009e-01f, 9.55163091e-02f, 1.09974388e-02f, -8.09868448e-04f, -1.82458460e-02f, -8.74527842e-02f,
  -1.61433537e-02f, -6.61744848e-02f, 6.17150404e-02f, 4.37345216e-03f, -7.93576166e-02f, 7.49342069e-02f, 1.36888295e-01f, 8.16409737e-02f, 1.53984837e-02f, 2.49400847e-02f,
  -4.55448776e-02f, 4.18343730e-02f, -5.14601730e-02f, -2.77186725e-02f, 4.96508777e-02f, 3.05316932e-02f, 4.32507955e-02f, 4.05423983e-04f, -5.07478714e-02f, 2.85620354e-02f,
  6.56923652e-02f, 6.78570941e-02f, -7.33297020e-02f, -1.68938618e-02f, -8.44260305e-02f, -5.67063875e-02f, -9.67029929e-02f, -7.02091604e-02f, 4.52112928e-02f, -7.21937418e-02f,
  -2.11208463e-02f, -8.22411478e-02f, 1.40985586e-02f, -7.10182637e-02f, 3.80724072e-02f, 1.86292529e-02f, 3.06453779e-02f, 9.24119055e-02f, -5.69935255e-02f, -7.38825127e-02f,
  3.24216951e-03f, -6.61357641e-02f, -1.33442180e-02f, 1.46731129e-03f, -5.11111598e-03f, 2.54202634e-02f, -6.77389801e-02f, 2.29339916e-02f, -2.15194542e-02f, 7.66360834e-02f,
  -6.62318766e-02f, 2.29356196e-02f, 5.17320372e-02f, 2.89210621e-02f, 2.89948117e-02f, -7.19600022e-02f, 6.83396636e-03f, 6.25426173e-02f, -5.73558249e-02f, -2.69537065e-02f,
  5.73254265e-02f, 4.17646095e-02f, 6.74754754e-02f, 6.96261451e-02f, 7.85613339e-03f, 8.62310156e-02f, 2.32523736e-02f, 7.30072111e-02f, -7.71831954e-03f, -7.38186538e-02f,
  4.38012145e-02f, -9.07796100e-02f, 2.35226881e-02f, -9.13055018e-02f, 7.58100227e-02f, -4.20162529e-02f, -2.57013328e-02f, -9.90528986e-02f, 9.44454297e-02f, 1.83871090e-02f,
  3.22578289e-02f, 6.95399866e-02f, -5.66303879e-02f, -6.29818588e-02f, -9.31817889e-02f, -5.54785542e-02f, -3.88851278e-02f, 2.92698815e-02f, -3.02040367e-03f, 5.49812354e-02f,
  -5.03614061e-02f, 4.75132391e-02f, -1.78212449e-02f, -5.62189519e-02f, 3.33183492e-03f, 9.74116905e-04f, -2.37327740e-02f, -4.88557294e-02f, 2.70747598e-02f, 8.60526040e-02f,
  -1.59965739e-01f, 6.66618813e-03f, 6.13930970e-02f, -1.10988729e-01f, 1.26507496e-02f, 4.76827249e-02f, 2.50745639e-02f, -7.25364909e-02f, -2.59677749e-02f, 1.21111497e-01f,
  5.58149293e-02f, -1.09883714e-02f, -5.46465106e-02f, -1.14093581e-02f, -7.29041621e-02f, -1.39350533e-01f, -1.14324272e-01f, 4.79120538e-02f, -5.84578998e-02f, 1.15723033e-02f,
  -1.25224024e-01f, -7.05303773e-02f, -6.66650608e-02f, -4.71741743e-02f, -3.54407243e-02f, 8.22824799e-03f, -4.91553657e-02f, 1.33960709e-01f, 4.47427183e-02f, -6.09503761e-02f,
  7.51540950e-03f, 2.44913716e-02f, -1.34406351e-02f, -2.47571096e-02f, 1.04609951e-01f, -2.88739800e-02f, -5.70364222e-02f, -2.28347052e-02f, -3.23629044e-02f, 3.49712186e-02f,
  9.86675173e-02f, -4.67630625e-02f, -2.93998737e-02f, 1.14377942e-02f, 2.78322725e-03f, -5.96761629e-02f, 4.77067046e-02f, 1.54607149e-03f, -3.52114476e-02f, 6.82315156e-02f,
  8.95515233e-02f, 2.30994709e-02f, 4.69408892e-02f, -5.74622974e-02f, 2.16993131e-03f, -5.35007007e-02f, -3.04677393e-02f, 3.11584901e-02f, 5.50707169e-02f, -7.93306828e-02f,
  6.50685630e-04f, -7.69134015e-02f, -2.54147183e-02f, 8.68409351e-02f, -6.88762069e-02f, -5.54780513e-02f, -6.51804879e-02f, 3.86095271e-02f, 8.26308131e-02f, 8.10338333e-02f,
  5.63128926e-02f, -3.73694091e-03f, -4.20280732e-02f, 4.06787843e-02f, -6.47359267e-02f, 6.51942864e-02f, -7.59357065e-02f, 2.27690861e-03f, -7.26900846e-02f, -1.72200166e-02f,
  9.20722168e-03f, -3.76617834e-02f, 2.04539672e-02f, -4.39672545e-02f, -5.93823232e-02f, 4.53517996e-02f, 3.08387075e-02f, -4.37870994e-02f, 5.14391670e-03f, -6.57326449e-03f,
  -5.47215119e-02f, 2.46560853e-03f, 7.52709806e-02f, 4.14421689e-03f, -8.06317702e-02f, -3.48356590e-02f, -8.06227550e-02f, 1.28497640e-02f, 2.88403779e-03f, -3.87920253e-02f,
  -4.79768142e-02f, 5.57585852e-03f, -8.43592882e-02f, -4.69407104e-02f, -6.25359416e-02f, 6.67179748e-02f, 5.39907217e-02f, 5.16864471e-02f, -1.92243792e-02f, 1.05848804e-03f,
  4.10686620e-03f, 5.28621860e-02f, 2.70034391e-02f, -7.60935396e-02f, -1.45673016e-02f, 8.12063292e-02f, 1.99862700e-02f, 7.59170428e-02f, 2.39507444e-02f, 4.27639931e-02f,
  -1.51133370e-02f, 5.47314025e-02f, 7.44209960e-02f, -3.98178920e-02f, -2.83005126e-02f, 7.22068176e-02f, -8.77255723e-02f, 1.13042584e-02f, 4.10298705e-02f, 1.17146388e-01f,
  8.05925354e-02f, 7.33365193e-02f, 2.42261449e-04f, 4.11314219e-02f, -1.67185217e-01f, -4.68204208e-02f, -1.12710543e-01f, 3.73454066e-03f, -7.78172612e-02f, -6.26004711e-02f,
  -8.88767242e-02f, -1.08845443e-01f, -4.59815376e-02f, 7.58245438e-02f, 8.45378339e-02f, -3.71817052e-02f, 4.04678360e-02f, 7.65995383e-02f, -7.34422076e-03f, 3.52613740e-02f,
  -8.82145017e-02f, 3.93153578e-02f, -2.69850288e-02f, -1.25837615e-02f, -4.74038012e-02f, 9.87281129e-02f, 2.19978709e-02f, -2.72026528e-02f, -8.22978169e-02f, -4.59773699e-03f,
  -3.93489823e-02f, -3.73910107e-02f, 2.13961173e-02f, -7.66167417e-04f, 7.80077577e-02f, -5.38614541e-02f, -2.44255997e-02f, -4.15451042e-02f, 3.38733010e-02f, 8.30936655e-02f,
  9.88991782e-02f, -5.28339334e-02f, 3.47973406e-02f, 5.94578013e-02f, 7.99818933e-02f, 7.65822679e-02f, -1.03741856e-02f, -2.99014188e-02f, 6.66367933e-02f, -4.36097123e-02f,
  7.12865964e-02f, 5.73579501e-03f, -2.33923290e-02f, 1.47128692e-02f, -2.55263913e-02f, 4.55704480e-02f, -6.36033863e-02f, -8.13966170e-02f, 1.31010339e-02f, 7.26235062e-02f,
  3.45130786e-02f, 6.13078177e-02f, 4.86269360e-03f, -7.50045702e-02f, -5.26841059e-02f, -2.88793836e-02f, 3.51124480e-02f, 3.04579567e-02f, 2.26384420e-02f, -2.95386054e-02f,
  6.35875463e-02f, -7.59404339e-03f, -4.06608321e-02f, 7.51902461e-02f, 8.26647431e-02f, -3.60254683e-02f, -2.84999460e-02f, -2.39174906e-02f, -6.61088377e-02f, 6.04559071e-02f,
  1.41353114e-03f, -3.52745503e-02f, -3.23302001e-02f, 8.21008906e-02f, -5.23792207e-02f, 3.81223783e-02f, -1.99858453e-02f, -3.07429489e-02f, 1.75280590e-02f, 3.48714888e-02f,
  5.11981286e-02f, -3.44544351e-02f, -4.48544547e-02f, 8.24764520e-02f, 7.67893270e-02f, -8.64415169e-02f, -1.34694567e-02f, 8.23273733e-02f, -8.63774272e-04f, 1.86067063e-03f,
  -6.29534423e-02f, -4.35513817e-03f, 2.80214045e-02f, 6.43439870e-03f, -1.73066165e-02f, -7.70581439e-02f, -8.36494043e-02f, 2.12017540e-02f, 6.45588264e-02f, 6.52368218e-02f,
  -3.19784023e-02f, -7.18460977e-02f, -7.93620795e-02f, 7.60525241e-02f, -5.73175773e-02f, -1.83458347e-02f, 7.41966367e-02f, 7.43613299e-03f, 1.50601054e-02f, -6.40724599e-02f,
  8.42812210e-02f, 9.08029824e-02f, -6.24604672e-02f, 3.70316766e-02f, -1.00328191e-03f, 4.40154970e-02f, -2.65852921e-02f, 8.16321895e-02f, 2.91297156e-02f, -2.36251075e-02f,
  -4.00318988e-02f, 8.95416737e-02f, 8.95002112e-02f, 3.85724357e-03f, -5.94791919e-02f, -2.79149711e-02f, 9.46629196e-02f, 7.64933452e-02f, 6.12640493e-02f, 2.71021742e-02f,
  -4.88799848e-02f, -6.72609359e-03f, 4.95033339e-02f, 1.24257256e-03f, 2.74416450e-02f, -4.75046895e-02f, 1.47713693e-02f, -2.65953578e-02f, -7.07926452e-02f, 6.25538900e-02f,
  8.79922435e-02f, -1.31968427e-02f, 1.83046591e-02f, 1.08224954e-02f, -3.42508010e-03f, -2.29548365e-02f, 1.08439391e-02f, 2.69629396e-02f, 3.38706411e-02f, -5.22291474e-02f,
  8.48478526e-02f, 5.18860519e-02f, -4.99614552e-02f, 4.57460396e-02f, -6.81584179e-02f, -3.34855616e-02f, -4.88293394e-02f, -2.08391845e-02f, 1.74271967e-02f, 8.51063877e-02f,
  -6.78754374e-02f, -5.53409234e-02f, 4.08900976e-02f, 5.21010421e-02f, 4.51410450e-02f, 9.03126132e-03f, 1.65224038e-02f, -6.70557171e-02f, 6.18311539e-02f, 1.03597250e-02f,
  -4.57440540e-02f, 1.62425283e-02f, 3.42493393e-02f, 1.10904742e-02f, -6.57566488e-02f, 4.13079374e-02f, -1.68604143e-02f, -1.85262337e-02f, -1.65195316e-02f, -5.92569970e-02f,
  3.88918296e-02f, -1.75944269e-02f, 1.62734780e-02f, -8.80697370e-02f, -5.26206307e-02f, -7.88167492e-02f, 8.60060155e-02f, 7.36211333e-03f, -6.85682818e-02f, -2.96992231e-02f,
  3.16927470e-02f, 3.61167379e-02f, -4.44698445e-02f, -9.86846723e-03f, 7.84534961e-02f, -8.18779096e-02f, -5.35555072e-02f, -7.07487809e-03f, 2.35577393e-02f, 6.18056096e-02f,
  -4.85510603e-02f, 5.11885136e-02f, -3.10790632e-02f, 4.68128622e-02f, 4.92374189e-02f, -4.84568700e-02f, -1.28114289e-02f, -3.21805961e-02f, 7.36967698e-02f, -3.11069954e-02f,
  1.10278334e-02f, -4.48831432e-02f, 5.85435070e-02f, -5.58110215e-02f, -3.53880301e-02f, -6.90452084e-02f, 9.40907970e-02f, -6.43567219e-02f, -1.74246449e-02f, 3.02838311e-02f,
  1.38263538e-01f, 7.90273771e-02f, -3.05974837e-02f, 1.38972059e-01f, -1.13023587e-01f, -1.47635952e-01f, -9.41299647e-02f, -3.64245772e-02f, 8.66825134e-02f, -8.18989500e-02f,
  -5.80243655e-02f, 6.93100914e-02f, -6.08276725e-02f, 8.02117214e-02f, -2.87723243e-02f, -1.54167250e-01f, 4.34628054e-02f, 7.69817680e-02f, -4.32433672e-02f, 1.91510767e-02f,
  -5.64285070e-02f, 2.85791215e-02f, -7.74366483e-02f, 6.50458708e-02f, 1.44125208e-01f, 1.16835728e-01f, -4.06540520e-02f, -7.60034174e-02f, -4.35332721e-03f, 4.08210680e-02f,
  -1.52782351e-03f, -3.32128443e-02f, 3.28665599e-02f, 6.67394996e-02f, -1.68780163e-02f, 6.88968971e-02f, -4.27558720e-02f, -5.47669120e-02f, 4.93889786e-02f, 8.54658708e-02f,
  7.80783966e-02f, 9.04851183e-02f, -8.03256407e-03f, -5.04646860e-02f, 6.44745901e-02f, 4.17791642e-02f, 6.80285096e-02f, 1.48444325e-02f, -2.53623798e-02f, 4.91095968e-02f,
  1.19910680e-01f, -4.04051542e-02f, 8.66554901e-02f, 3.86531241e-02f, 3.58746648e-02f, -7.02297986e-02f, -2.73058899e-02f, -3.67846787e-02f, 5.79559319e-02f, -5.90429455e-03f,
  -3.27084102e-02f, -7.26093650e-02f, -9.80300233e-02f, 7.51087368e-02f, -1.77888982e-02f, -7.88438395e-02f, -7.82027468e-03f, 6.14066957e-04f, -2.76491046e-02f, -7.43571967e-02f,
  4.10083123e-02f, 3.51859853e-02f, -6.71228617e-02f, -1.27292173e-02f, 2.64332592e-02f, 2.02134196e-02f, -5.00967316e-02f, -3.03790276e-03f, -3.17565463e-02f, -5.96489199e-02f,
  -2.52560731e-02f, -7.20598102e-02f, 3.28650884e-02f, 6.03312179e-02f, 2.37167869e-02f, 1.78121068e-02f, -3.42249535e-02f, 8.35158899e-02f, 1.66041143e-02f, -8.18566009e-02f,
  -3.04851811e-02f, -4.78589647e-02f, 3.50255668e-02f, -3.92717458e-02f, -4.18899255e-03f, 1.76544040e-02f, -2.01760046e-02f, 2.82456446e-02f, 6.78228959e-02f, -4.91651613e-03f,
  -7.43511245e-02f, -6.80101588e-02f, -2.31984723e-02f, 6.99142814e-02f, -2.57054158e-02f, -2.87008379e-02f, -8.86673182e-02f, -3.79061028e-02f, 3.58389206e-02f, -4.10287641e-02f,
  1.97888408e-02f, 4.53086197e-03f, 1.95719227e-02f, -5.50612323e-02f, 7.11319521e-02f, 6.56429306e-02f, 5.72063509e-05f, 5.81454709e-02f, 5.05157262e-02f, -6.27296418e-02f,
  1.18169449e-01f, 1.64444260e-02f, -7.52504021e-02f, -3.43724638e-02f, -2.49178484e-02f, 2.23560873e-02f, -5.57494350e-03f, -1.54594868e-01f, 1.07341567e-02f, 3.29125673e-02f,
  8.00407398e-03f, 7.69551992e-02f, 1.53251916e-01f, -3.04652583e-02f, 1.08702555e-01f, 9.96066928e-02f, -1.43234864e-01f, -9.29547623e-02f, -6.83290884e-02f, -8.08412209e-02f,
  -7.87334330e-03f, -1.55697763e-01f, -8.63676667e-02f, -1.65077463e-01f, -2.50569824e-02f, -1.01377964e-01f, -2.61274502e-02f, -1.39902683e-03f, -1.45225972e-01f, -7.35953525e-02f,
  3.74624766e-02f, -6.65296093e-02f, 3.72796841e-02f, -7.97700509e-02f, 2.91733362e-04f, -8.93376209e-03f, 5.93654066e-03f, -4.51360196e-02f, 6.55514300e-02f, 4.12719877e-04f,
  -3.32725309e-02f, 7.24902302e-02f, 4.81173061e-02f, -2.72159614e-02f, -5.20427376e-02f, -2.47554965e-02f, -3.85171175e-02f, -7.92411864e-02f, 6.60860687e-02f, -8.05074275e-02f,
  6.85492232e-02f, 4.95266244e-02f, -3.91393006e-02f, -2.33456753e-02f, 6.35011792e-02f, -4.79277931e-02f, 7.55594000e-02f, -5.10530025e-02f, 2.76733432e-02f, -1.44592971e-02f,
  5.94182611e-02f, -4.27440507e-03f, 6.78562298e-02f, 3.48937102e-02f, -4.32373621e-02f, -1.26077076e-02f, -4.09862697e-02f, 6.69238195e-02f, 4.08769731e-04f, -6.79406226e-02f,
  -6.58660680e-02f, -5.81370331e-02f, 7.17743114e-02f, -6.14288636e-02f, 5.00534438e-02f, 1.75924972e-02f, 5.09729013e-02f, -8.50510970e-02f, -2.21226718e-02f, -5.62856393e-03f,
  -3.24599072e-02f, -1.44019425e-02f, 2.61959136e-02f, -3.23836468e-02f, 7.10556731e-02f, 4.31857109e-02f, 5.06670624e-02f, 6.90837810e-03f, 8.43401924e-02f, 6.58102408e-02f,
  -1.03751987e-01f, -9.99174938e-02f, 3.82991359e-02f, -4.91273925e-02f, 1.11247543e-02f, 1.57553405e-02f, 2.64631007e-02f, -4.34286557e-02f, -8.20621476e-03f, 5.24222441e-02f,
  -1.60389841e-02f, -2.75561195e-02f, 4.78299335e-02f, 2.12190999e-03f, 4.21947800e-02f, -7.90551901e-02f, -3.41442376e-02f, 4.25985679e-02f, 9.75969061e-03f, 4.86723818e-02f,
  -5.29717617e-02f, -2.82308497e-02f, -7.75940344e-02f, -7.80059174e-02f, -6.61323369e-02f, -1.57351270e-02f, 3.43726911e-02f, 5.10542318e-02f, 5.08107059e-02f, -2.22674254e-02f,
  5.14890663e-02f, 1.30581617e-01f, 1.67609811e-01f, 8.03946629e-02f, -1.23443000e-01f, -1.79097176e-01f, -2.15118360e-02f, -6.89342767e-02f, 5.65856993e-02f, -2.77702976e-02f,
  -8.37453902e-02f, 1.71886250e-01f, -4.88269366e-02f, 1.02508313e-03f, 8.25193450e-02f, -1.09479904e-01f, 8.76029506e-02f, -2.69636307e-02f, -3.15171368e-02f, 6.30118102e-02f,
  -3.50838713e-03f, 1.45266308e-02f, 1.69752494e-01f, 9.53237563e-02f, 3.86343226e-02f, 5.12049980e-02f, 1.03834964e-01f, -8.73915777e-02f, 1.53508037e-01f, 5.19180819e-02f,
  -1.65869407e-02f, -7.40544274e-02f, 5.99440858e-02f, 6.50175288e-02f, 5.76935150e-02f, 1.55979777e-02f, -3.07573583e-02f, 7.17413649e-02f, -1.56274810e-02f, -2.67750267e-02f,
  4.71220203e-02f, -6.28123581e-02f, 7.72336200e-02f, 7.27190226e-02f, -7.42406622e-02f, -1.45213036e-02f, 2.86357157e-04f, 9.62542966e-02f, -1.40294954e-02f, 1.17341459e-01f,
  -3.09230350e-02f, 5.17635718e-02f, 6.33336082e-02f, 6.14639781e-02f, 1.83885302e-02f, 6.33340180e-02f, -7.78018590e-03f, -3.26991566e-02f, 4.18646494e-03f, 3.98364700e-02f,
  -2.38338560e-02f, 2.75917985e-02f, -5.20932861e-02f, 4.04547304e-02f, 3.45907882e-02f, -5.97725250e-02f, -8.22826400e-02f, -5.51745929e-02f, 3.25652882e-02f, 9.31141619e-03f,
  3.62263508e-02f, -3.70283425e-02f, 1.81116797e-02f, 5.67207038e-02f, -3.94785888e-02f, 4.50298376e-02f, 6.96006864e-02f, -3.09556257e-02f, 2.75229514e-02f, 9.49558765e-02f,
  -7.07371235e-02f, -3.01661752e-02f, -1.49005987e-02f, 7.84877092e-02f, -1.23667121e-02f, -2.96153910e-02f, -1.93545949e-02f, 2.66002398e-03f, 3.16953585e-02f, -7.70041496e-02f,
  -3.30043621e-02f, 8.14734697e-02f, 8.81108195e-02f, -2.52326000e-02f, -3.35826501e-02f, 6.96861148e-02f, 8.44330490e-02f, -7.55124912e-02f, 2.90755071e-02f, 8.87956563e-03f,
  -8.89531523e-02f, -3.53682712e-02f, 2.81976373e-03f, -6.40379190e-02f, -6.29692450e-02f, -4.02171798e-02f, -6.93664551e-02f, -7.11050108e-02f, -4.92652468e-02f, 7.75786340e-02f,
  -4.46467064e-02f, 2.76676938e-02f, 7.71984905e-02f, -2.21808907e-02f, 5.33891320e-02f, -1.75396132e-03f, -1.95847172e-02f, -7.75832543e-03f, -4.35357317e-02f, 1.00972407e-01f,
  -2.79460605e-02f, -3.46527360e-02f, 8.10802951e-02f, -1.29722832e-02f, -4.08392400e-02f, 1.36626428e-02f, -5.27201593e-02f, -9.17016566e-02f, -9.58970115e-02f, 6.00756034e-02f,
  5.28529100e-02f, 4.46586460e-02f, -7.67179020e-03f, -7.85522982e-02f, -2.20028441e-02f, -2.23112144e-02f, -8.46956670e-02f, -1.76869519e-02f, -3.86327580e-02f, 2.49214750e-02f,
  6.39037192e-02f, 7.84002319e-02f, -7.04287887e-02f, 7.26119056e-03f, 5.63743114e-02f, -4.34716530e-02f, -5.73532470e-02f, -3.72813568e-02f, -5.46803400e-02f, -4.76651862e-02f,
  -4.97389734e-02f, 4.04205211e-02f, 3.34257516e-03f, -7.96965417e-03f, -2.55266912e-02f, -7.09205642e-02f, -1.72446063e-03f, -2.48172600e-02f, -3.94280404e-02f, 5.78256771e-02f,
  -5.91542087e-02f, -2.49420851e-02f, -4.73245308e-02f, -8.31759498e-02f, 5.12323603e-02f, 6.48273379e-02f, 1.08753638e-02f, 5.86937815e-02f, -1.99287906e-02f, 3.99709158e-02f,
  -1.26084676e-02f, -6.70367405e-02f, 7.76143223e-02f, 4.17047180e-02f, -3.96600626e-02f, -6.81528747e-02f, 4.81398739e-02f, 5.80898412e-02f, 5.61066419e-02f, -4.86305282e-02f,
  -3.28227989e-02f, 1.33629178e-03f, 7.11081997e-02f, -7.52402097e-02f, -2.19337996e-02f, 2.87985802e-02f, -7.18965977e-02f, -1.75138284e-02f, 5.95986582e-02f, 7.24672079e-02f,
  -8.84551257e-02f, -8.45169947e-02f, -1.54503593e-02f, 8.13212153e-03f, -5.15275784e-02f, 2.28178706e-02f, -3.27911861e-02f, 8.69962499e-02f, -5.80244027e-02f, -4.10507759e-03f,
  8.49040747e-02f, -3.86179388e-02f, -1.69039406e-02f, 8.36556628e-02f, 8.67583677e-02f, -1.02590751e-02f, 7.25030601e-02f, 6.40642792e-02f, -1.00143991e-01f, 1.79447271e-02f,
  5.78229374e-04f, -1.02451243e-01f, -4.03591432e-02f, 6.25117943e-02f, -4.22688387e-03f, -4.09633480e-03f, 5.56362942e-02f, -6.26190156e-02f, -9.34312940e-02f, -4.65785004e-02f,
  -4.56440076e-02f, 5.22362813e-02f, 5.39636500e-02f, -5.25675118e-02f, -5.65934461e-03f, 4.38614674e-02f, -4.43946337e-03f, -7.72382657e-04f, 1.72426850e-02f, -4.88573126e-02f,
  -3.13765146e-02f, -4.20097895e-02f, -2.60332716e-03f, 8.14222842e-02f, -8.18908389e-04f, -2.09311880e-02f, -4.01865207e-02f, -4.92423698e-02f, -6.15477562e-02f, 6.11576065e-02f,
  3.77823226e-02f, -4.32744883e-02f, -3.89032848e-02f, -1.05608203e-01f, -1.22703165e-01f, -8.08134079e-02f, -8.63340721e-02f, -9.91393253e-02f, -9.15579200e-02f, -2.84486543e-02f,
  -7.45771006e-02f, 6.53955266e-02f, 1.21394649e-01f, -1.55275628e-01f, 4.14273608e-03f, 1.16815947e-01f, -6.22018166e-02f, -1.01969883e-01f, -7.23204464e-02f, -2.02545598e-02f,
  5.26952371e-02f, -1.01372801e-01f, 4.69695292e-02f, -1.69360712e-02f, -1.00000277e-01f, -1.14137851e-01f, -4.15469743e-02f, -8.17668959e-02f, -1.24104425e-01f, -4.48623858e-02f,
  -7.53541365e-02f, 1.04330570e-01f, 2.90154833e-02f, 1.01277992e-01f, -7.08886683e-02f, -5.09367883e-03f, -3.69941406e-02f, -5.78140281e-02f, 1.89017411e-02f, -2.99643837e-02f,
  -4.38612141e-02f, 8.17109197e-02f, -7.70145357e-02f, -8.00002590e-02f, 3.48256938e-02f, -4.14035432e-02f, -4.45763906e-03f, -1.01399481e-01f, 4.06492427e-02f, 5.67560643e-02f,
  -8.00616890e-02f, -4.07829992e-02f, -2.90252902e-02f, 6.37393892e-02f, 6.04275279e-02f, 3.74958776e-02f, 8.22726041e-02f, -7.31195956e-02f, 1.25745013e-02f, -7.84348026e-02f,
  3.62617634e-02f, -2.35514548e-02f, 1.36321876e-02f, -5.69891594e-02f, 3.05903726e-03f, -5.49280643e-02f, 4.09297310e-02f, -6.36597276e-02f, -3.14389989e-02f, 5.90651222e-02f,
  1.91796068e-02f, 7.08925799e-02f, 7.15557635e-02f, 4.59490120e-02f, 5.13602654e-03f, -5.21286577e-02f, 7.29028955e-02f, -4.84053716e-02f, 1.03436299e-02f, 3.22271846e-02f,
  -5.47809713e-02f, -1.15282536e-02f, -7.23173544e-02f, 3.18670906e-02f, -7.58017376e-02f, -5.77378236e-02f, 4.12995256e-02f, 4.94558141e-02f, -2.09927652e-02f, -5.56702912e-02f,
  -5.03022484e-02f, 9.03269947e-02f, -4.20107646e-03f, -6.38798671e-03f, 2.71954127e-02f, -7.95441587e-03f, 1.40307946e-02f, -7.17531964e-02f, -2.16048807e-02f, 1.46302748e-02f,
  3.77832204e-02f, -2.01681182e-02f, -6.62185997e-02f, -3.78635824e-02f, 1.02037601e-02f, 8.27932730e-03f, 5.89890070e-02f, -5.09162359e-02f, -6.31357878e-02f, 4.41604666e-02f,
  -4.61727986e-03f, 5.56874238e-02f, 8.80671293e-02f, -4.08277176e-02f, -2.44360557e-03f, 3.37142847e-03f, 2.63737720e-02f, -3.30746509e-02f, 2.65100505e-02f, -3.42938700e-03f,
  1.89851224e-02f, 1.10627972e-01f, -2.53494512e-02f, 3.87647413e-02f, -1.41845671e-02f, -9.97361988e-02f, -9.57700238e-02f, 1.01316996e-01f, 1.10585690e-02f, 1.35658449e-02f,
  -5.13192527e-02f, 4.33122851e-02f, -4.12223116e-02f, -5.95656894e-02f, -3.25522805e-03f, -1.90916322e-02f, 9.45986509e-02f, 4.26614136e-02f, -3.02022975e-02f, 3.23283747e-02f,
  8.12807754e-02f, -1.84728280e-02f, 3.38348262e-02f, 8.67158771e-02f, 2.79569924e-02f, 8.07378367e-02f, -5.47209829e-02f, 8.95071775e-02f, 1.24447405e-01f, 2.06384975e-02f,
  -6.72120601e-02f, -3.58517095e-02f, 5.26943877e-02f, 7.88669363e-02f, -7.73568526e-02f, 6.63753375e-02f, -2.56379452e-02f, 3.95527780e-02f, 4.84657567e-03f, 6.33087158e-02f,
  1.39496159e-02f, -4.94145975e-02f, -3.56019922e-02f, 3.81813720e-02f, -3.68131958e-02f, 9.25718769e-02f, -4.18072715e-02f, -7.15275481e-02f, -8.07047337e-02f, 3.26015688e-02f,
  5.83223663e-02f, 6.45436496e-02f, 3.14436816e-02f, 4.02427725e-02f, -3.80624123e-02f, -6.81228787e-02f, 2.82695517e-03f, -4.86924611e-02f, 8.69317949e-02f, 8.16325620e-02f,
  -4.54851463e-02f, 2.89117303e-02f, 6.44255877e-02f, -4.00529020e-02f, 4.34627309e-02f, -6.83042854e-02f, 5.00392839e-02f, 8.76060966e-03f, -3.45559977e-02f, 2.28074496e-03f,
  -5.76054566e-02f, -2.79007219e-02f, -9.06475186e-02f, -9.26383864e-03f, -1.24831069e-02f, -9.61959586e-02f, 3.04537639e-02f, -2.29932312e-02f, 6.38249815e-02f, -4.65397388e-02f,
  -1.08661577e-02f, 6.96860403e-02f, -7.96995237e-02f, -1.73901934e-02f, 4.27175919e-03f, -4.07332648e-03f, -7.38796741e-02f, -7.06139505e-02f, -3.91810499e-02f, 6.02844842e-02f,
  1.37063637e-02f, 2.89088897e-02f, -5.50165074e-03f, 2.35721655e-02f, -6.57660961e-02f, 7.69184902e-02f, -5.54471649e-02f, 2.96848938e-02f, -8.73817969e-03f, -1.27200475e-02f,
  4.57686484e-02f, 3.59081104e-02f, 4.18992192e-02f, 7.67754614e-02f, 1.47094354e-02f, 7.31904581e-02f, 2.39173640e-02f, -9.21698846e-03f, -4.45607863e-02f, -4.14399281e-02f,
  1.97702795e-02f, -3.87047953e-03f, -3.08456924e-02f, 8.70246720e-03f, 4.04632017e-02f, 7.55685866e-02f, 6.63153380e-02f, -2.81547103e-02f, -7.02399537e-02f, -1.17425167e-03f,
  -3.99994142e-02f, -1.19366162e-01f, -1.08379960e-01f, 9.51508060e-02f, 1.07634902e-01f, 1.36355355e-01f, 8.99424218e-03f, -4.59737666e-02f, -1.97384045e-01f, -1.36831962e-02f,
  4.34858575e-02f, -6.67881742e-02f, -1.48522377e-01f, 1.34557664e-01f, 1.39648885e-01f, -7.51436055e-02f, 3.65968458e-02f, 1.19714186e-01f, -9.51616559e-03f, -9.90156531e-02f,
  7.60652199e-02f, 1.12291701e-01f, 2.31762193e-02f, 1.22928225e-01f, 4.27936576e-02f, 1.01236098e-01f, 7.06164762e-02f, -3.08191534e-02f, 1.64840296e-01f, 6.07809573e-02f,
  -7.36409202e-02f, -6.54378459e-02f, -1.25167668e-02f, -2.63765771e-02f, -7.95406476e-02f, 7.57369995e-02f, 2.15432774e-02f, 2.55819988e-02f, 5.98200038e-02f, 2.18178704e-02f,
  -9.06433016e-02f, -6.45684823e-02f, 1.03317447e-01f, 3.49896625e-02f, -7.22612441e-02f, -6.90923706e-02f, -7.94422776e-02f, -3.41764912e-02f, -2.98760682e-02f, 2.41241436e-02f,
  1.93930138e-02f, -7.40102828e-02f, -5.08727916e-02f, -3.78241949e-02f, 4.88934442e-02f, 5.46280928e-02f, -4.88049351e-02f, 7.38427415e-02f, 3.79369296e-02f, 6.09864555e-02f,
  6.62881061e-02f, -1.09352209e-02f, -1.07557304e-01f, -9.00119450e-03f, 4.09739278e-02f, 8.45870003e-02f, 1.46729285e-02f, -3.09806806e-03f, 2.60398109e-02f, -7.40134269e-02f,
  4.93798777e-02f, -3.39917764e-02f, 1.84646137e-02f, -6.22729175e-02f, 4.73861247e-02f, -1.09653258e-04f, 5.76554798e-02f, 2.01414749e-02f, 4.07726504e-02f, 5.81310131e-02f,
  -5.87495454e-02f, -5.09299599e-02f, 6.37585297e-02f, -2.41535045e-02f, -4.35396768e-02f, -2.31714640e-03f, -4.43827510e-02f, -5.53121679e-02f, 7.96557069e-02f, -3.23024206e-02f,
  -1.33873105e-01f, -2.20792531e-03f, -4.57317494e-02f, -1.45687733e-03f, -3.34426910e-02f, 6.59750700e-02f, 7.82097876e-02f, 5.10358922e-02f, -1.08598895e-01f, 2.57526804e-02f,
  -2.81125912e-03f, 3.69920842e-02f, -6.16167560e-02f, 3.66293937e-02f, 1.04983561e-01f, -1.54019492e-02f, -9.77884755e-02f, -6.55001262e-03f, -2.23612040e-03f, 7.59438127e-02f,
  5.98458713e-03f, -4.57675941e-02f, -1.61138140e-02f, 3.68024483e-02f, 1.54295173e-02f, 2.64873281e-02f, -6.44382685e-02f, -6.31943271e-02f, 3.49300653e-02f, -3.60942595e-02f,
  2.16434114e-02f, 7.71831498e-02f, -2.76733171e-02f, 7.70657929e-03f, 2.29972452e-02f, 7.95508847e-02f, 1.50510356e-01f, 1.44913560e-02f, 1.18297026e-01f, 1.17575370e-01f,
  -3.57302837e-02f, -2.09869500e-02f, 1.28779532e-02f, -3.55070978e-02f, 1.20689817e-01f, 1.47151232e-01f, 1.30017966e-01f, 1.30140975e-01f, -5.35339899e-02f, -1.87929515e-02f,
  -4.08622921e-02f, -1.97518170e-02f, -1.23384878e-01f, -2.45207772e-02f, -3.43568139e-02f, -5.15290722e-02f, -1.04737177e-01f, 9.85402614e-03f, 2.66242418e-02f, 7.53809931e-04f,
  4.90507968e-02f, 8.58050957e-02f, -4.44354154e-02f, 2.35859640e-02f, -4.31687422e-02f, -5.68586625e-02f, -6.50863498e-02f, 2.97275074e-02f, 4.28430475e-02f, -4.57523875e-02f,
  1.99569892e-02f, 6.61889464e-02f, -6.53292015e-02f, -2.36258972e-02f, 3.51993255e-02f, -8.63481835e-02f, -9.06598791e-02f, -3.06550376e-02f, 1.33357253e-02f, -5.86450659e-02f,
  2.61404249e-03f, -7.74376385e-04f, 6.91993162e-02f, -5.08779995e-02f, -3.20243388e-02f, 4.00483571e-02f, 6.63594306e-02f, -8.56817365e-02f, 4.98342663e-02f, 8.86077508e-02f,
  6.95282295e-02f, 8.67595822e-02f, 5.53149618e-02f, 7.79721811e-02f, -5.03021618e-03f, -9.63746607e-02f, 2.71631517e-02f, 2.42950339e-02f, 2.76211370e-02f, -6.17421083e-02f,
  -2.69383844e-02f, -6.30550683e-02f, 4.71076444e-02f, -2.56264396e-02f, 1.65622437e-03f, -7.09041432e-02f, 2.83056870e-02f, -6.08767532e-02f, 6.66295439e-02f, -2.25190097e-03f,
  2.39361580e-02f, -3.58515121e-02f, 7.16019645e-02f, 3.99476066e-02f, -1.79323722e-02f, 7.57529065e-02f, 1.30560389e-03f, -1.24251237e-04f, -2.09931061e-02f, -4.31686901e-02f,
  7.47042298e-02f, 3.84833999e-02f, -1.22488348e-03f, 9.28908885e-02f, 3.07310559e-02f, -7.09510595e-03f, 7.17321783e-02f, 6.48265183e-02f, 1.88316777e-02f, 8.24052915e-02f,
  -4.02136222e-02f, -2.53489353e-02f, -4.24757153e-02f, 1.91951431e-02f, -4.64688390e-02f, 7.23176003e-02f, 1.00443646e-01f, -3.75207812e-02f, 7.39571154e-02f, -1.00772558e-02f,
  5.39269708e-02f, 2.34214943e-02f, 6.95018992e-02f, -5.56485802e-02f, 1.01195961e-01f, -1.42059522e-02f, 9.02455952e-03f, 7.28094801e-02f, -1.38176763e-02f, 7.42702633e-02f,
  -1.09035723e-01f, 4.32886649e-03f, -8.42546597e-02f, -2.14258465e-03f, 5.80606833e-02f, 3.64566073e-02f, -3.48856151e-02f, 8.06208253e-02f, 1.61405075e-02f, 4.50326316e-02f,
  -7.68123986e-03f, 6.88011795e-02f, 2.15418581e-02f, 2.56305076e-02f, -1.65941473e-02f, -1.41605493e-02f, -1.50348796e-02f, 7.31919855e-02f, 5.99357747e-02f, 5.64096682e-03f,
  5.14362343e-02f, 2.83288676e-02f, -5.77243045e-02f, -1.18249636e-02f, -9.26543120e-03f, 5.05075678e-02f, 2.52415892e-02f, 3.80857810e-02f, -2.57408470e-02f, -3.29196453e-02f,
  -1.02424890e-01f, 5.29228486e-02f, 4.25193757e-02f, -6.00733943e-02f, -9.13641676e-02f, 2.27426179e-02f, -7.48104453e-02f, -5.55467326e-03f, -7.43213296e-02f, -6.90725520e-02f,
  -6.75044069e-03f, -1.19797485e-02f, 5.83844297e-02f, 5.19079855e-03f, 2.19526738e-02f, 3.84948147e-03f, 3.62765905e-03f, -9.91188735e-03f, 6.05147444e-02f, -3.65553275e-02f,
  -8.81695822e-02f, -5.03248014e-02f, -6.72866553e-02f, -4.24053520e-02f, 2.24970412e-02f, -8.53824243e-02f, -7.28533193e-02f, -5.34216687e-02f, 4.10813205e-02f, 7.61730298e-02f,
  2.41005216e-02f, 3.78115810e-02f, -2.36079283e-02f, 1.51170371e-02f, -2.80284323e-02f, -8.19685161e-02f, -7.83794560e-04f, -5.31465486e-02f, 8.95203203e-02f, -1.66983437e-02f,
  -4.28204238e-03f, 8.26800093e-02f, -4.99696285e-03f, -6.68483824e-02f, -4.87093851e-02f, -4.93208766e-02f, -4.72215824e-02f, 7.39869326e-02f, 2.65791221e-03f, -1.38489418e-02f,
  6.35165628e-03f, 1.03554688e-02f, -6.85847178e-02f, -4.74646837e-02f, 8.67052451e-02f, -3.76991406e-02f, -6.91173002e-02f, -3.76520609e-03f, 8.48635584e-02f, 8.16978812e-02f,
  -3.62904519e-02f, -4.17643115e-02f, -2.16074735e-02f, -7.48187229e-02f, -5.75446039e-02f, 1.58375036e-02f, -8.55023637e-02f, -2.44698580e-02f, 5.26530966e-02f, 2.34105755e-02f,
  -8.18640888e-02f, -8.56279358e-02f, 1.99149903e-02f, 6.44629970e-02f, 1.41832104e-04f, -5.40281646e-02f, 5.38083129e-02f, 2.75597330e-02f, 2.69901399e-02f, -3.88454907e-02f,
  -7.17922226e-02f, -3.30816582e-02f, -5.41370995e-02f, 2.61642653e-02f, 9.31838714e-03f, 5.12819998e-02f, -5.32958284e-02f, -6.06993809e-02f, -6.54932559e-02f, 6.18485734e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 26)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 26;
const float L0_fan_Bp_bar_data[] = {
  6.95550814e-02f, -5.88410115e-03f, -1.18126487e-02f, 6.18074387e-02f, -2.99255587e-02f, -1.29726194e-02f, 1.77217461e-02f, 5.41330390e-02f, -7.23783225e-02f, 6.06671646e-02f,
  -1.59525336e-03f, 2.43602749e-02f, -3.63413915e-02f, 3.56735922e-02f, -1.31547088e-02f, -5.14175072e-02f, -8.13422874e-02f, -4.73229028e-03f, 1.67310564e-03f, 3.28177102e-02f,
  4.96434569e-02f, 5.98549210e-02f, -3.04211583e-02f, 7.42830634e-02f, 1.06420986e-01f, -5.45489311e-04f
};

// L1_fan_Wp (Shape: 51 x 128)
const int L1_fan_Wp_rows = 51;
const int L1_fan_Wp_cols = 128;
const float L1_fan_Wp_data[] = {
  -5.69979101e-02f, -2.18118709e-02f, -5.81653081e-02f, 1.15598939e-01f, -1.92921199e-02f, -7.43369609e-02f, 7.71878809e-02f, -5.82480095e-02f, -3.38943154e-02f, 5.86618036e-02f,
  -8.36354867e-02f, 2.46706959e-02f, -1.81217827e-02f, 1.61591098e-02f, 1.89579055e-02f, -3.58826779e-02f, -8.28903466e-02f, -6.00080471e-03f, -5.71826985e-03f, 2.19783373e-02f,
  7.03540538e-03f, -1.02511710e-02f, 8.83518383e-02f, -7.50829354e-02f, 1.03989278e-03f, -7.02976808e-02f, 8.58081132e-02f, 8.47723037e-02f, 9.72381756e-02f, 7.63162747e-02f,
  -1.23324553e-02f, 6.19764365e-02f, 7.48562515e-02f, -3.08368504e-02f, -3.50655504e-02f, -9.71344709e-02f, -5.34498924e-03f, -6.99139982e-02f, 4.68372889e-02f, 3.09834741e-02f,
  -3.75656667e-03f, 5.03632165e-02f, -9.75752473e-02f, 1.11729473e-01f, -2.10334789e-02f, 1.33317886e-02f, -6.05122447e-02f, -4.10751589e-02f, 7.48715624e-02f, -2.58264178e-03f,
  4.66674082e-02f, 4.61373329e-02f, 1.47251949e-01f, 1.06454976e-01f, -1.25013646e-02f, -1.00114003e-01f, 1.17019459e-03f, -5.40325381e-02f, -7.95412362e-02f, 4.84717265e-02f,
  1.53507024e-01f, -1.27193111e-03f, -1.91902176e-01f, 3.24118347e-03f, 1.94799572e-01f, 2.14532902e-03f, 8.67781267e-02f, -8.75394717e-02f, -8.29040632e-02f, 4.42011096e-02f,
  6.17631525e-02f, 5.57410493e-02f, 2.81392038e-02f, -1.23720549e-01f, -4.49330918e-02f, -2.91906074e-02f, 7.69620687e-02f, 8.42634216e-02f, 3.14811058e-02f, -5.79476319e-02f,
  7.32666031e-02f, 1.04849301e-01f, -1.23380616e-01f, -8.11958462e-02f, 1.54266238e-01f, 3.12160328e-02f, 1.30340338e-01f, 1.74289376e-01f, 1.11350521e-01f, 6.68617561e-02f,
  3.11331265e-02f, -6.54983073e-02f, -4.82655130e-02f, -1.75925687e-01f, 1.22425281e-01f, 1.59875602e-01f, -6.81858733e-02f, -1.24897934e-01f, 1.18718542e-01f, 2.87729185e-02f,
  -6.38888627e-02f, -1.70609564e-01f, 3.57653089e-02f, 6.72796816e-02f, 3.89420278e-02f, -1.97284557e-02f, -1.10063124e-02f, 3.48439626e-02f, -7.23674521e-03f, -1.54266255e-02f,
  2.52699628e-02f, 2.76038097e-03f, -5.61855771e-02f, 3.88485119e-02f, -8.55002087e-03f, 5.08188643e-03f, 5.35886772e-02f, -6.38336912e-02f, -1.70258321e-02f, -1.20088711e-01f,
  -3.01851686e-02f, 3.82102989e-02f, 5.07161170e-02f, -8.64201263e-02f, -8.41845721e-02f, 1.44078255e-01f, -7.52153099e-02f, 8.56375396e-02f, 2.55170278e-02f, 1.32231312e-02f,
  -2.69228257e-02f, -9.34579894e-02f, -1.52089484e-02f, 1.03410721e-01f, -4.75038290e-02f, 1.95271503e-02f, -4.45306860e-02f, 1.22365005e-01f, 8.78478363e-02f, 4.67345752e-02f,
  -4.84478101e-02f, -1.95681676e-02f, -1.07173827e-02f, -7.21222535e-02f, 1.76446941e-02f, 1.84719451e-02f, 8.73171240e-02f, 7.55418986e-02f, 5.15928818e-03f, 7.34382123e-02f,
  -1.01707265e-01f, 5.82746007e-02f, 1.27697304e-01f, -2.21004654e-02f, 6.81094453e-03f, -5.33058271e-02f, 1.19225858e-02f, 1.32000092e-02f, -6.63683414e-02f, -4.05977927e-02f,
  -9.84478667e-02f, 9.44414700e-04f, -3.61663252e-02f, -7.35808983e-02f, -3.28535736e-02f, 7.88537040e-02f, 3.66463400e-02f, 6.77111074e-02f, 8.91995523e-03f, 2.29744278e-02f,
  1.26034915e-01f, 2.86252722e-02f, 3.38010415e-02f, 1.04239389e-01f, 8.28901678e-02f, 7.82849789e-02f, 3.05959452e-02f, 1.01167396e-01f, -7.59599134e-02f, 1.15284935e-01f,
  -1.16934627e-01f, -4.18694988e-02f, 5.94701655e-02f, 5.27690612e-02f, -1.05197700e-02f, 4.85545471e-02f, -9.01150703e-02f, 1.59009977e-03f, 3.08154523e-02f, -9.41167474e-02f,
  1.17018126e-01f, 9.09667183e-03f, -1.53857013e-02f, 1.34676825e-02f, -7.95842037e-02f, 2.46862811e-03f, 5.15765436e-02f, -8.16370919e-02f, -1.01534948e-01f, 8.96946639e-02f,
  -3.36198658e-02f, -6.05761558e-02f, 1.49254695e-01f, 4.32782657e-02f, 3.49645726e-02f, -1.18336640e-01f, 5.62662259e-02f, 1.56249553e-02f, 1.77479442e-02f, -1.06008217e-01f,
  -6.11651018e-02f, 1.20799579e-01f, -1.10508889e-01f, -2.72986609e-02f, -3.72768678e-02f, -3.52991335e-02f, -6.05859458e-02f, -7.66837271e-03f, 2.42885929e-02f, 7.03231990e-02f,
  1.49536319e-03f, 8.56643766e-02f, 2.41695419e-02f, -1.42947016e-02f, 1.48217240e-03f, 3.73738594e-02f, -8.64944384e-02f, -5.13430685e-02f, 2.29165461e-02f, -1.27651706e-01f,
  -7.85004273e-02f, 6.25713170e-02f, -6.30803257e-02f, 4.72140089e-02f, 4.39479239e-02f, -3.52962315e-02f, 2.32056510e-02f, 1.13629662e-01f, -9.10013542e-02f, -4.34470549e-02f,
  -2.00313628e-02f, 9.13139358e-02f, -2.19961870e-02f, 1.78508088e-02f, -1.56166144e-02f, 5.74899651e-02f, -8.97207409e-02f, -7.77656911e-03f, 1.19819380e-01f, 1.49486149e-02f,
  5.69579601e-02f, -4.16386947e-02f, 7.73722008e-02f, 1.95786711e-02f, -3.81448194e-02f, 6.32339790e-02f, 3.14658806e-02f, -2.21970235e-03f, -6.16796166e-02f, -5.26679717e-02f,
  9.20677558e-02f, 5.22192419e-02f, -2.67539285e-02f, 2.51615122e-02f, 7.81505406e-02f, 5.97663969e-02f, -6.17109202e-02f, -1.31077871e-01f, 5.58832809e-02f, -1.64215676e-02f,
  -9.40652192e-03f, -5.94967455e-02f, -8.05280432e-02f, -5.77058606e-02f, -4.38581370e-02f, -7.65464529e-02f, 8.28891918e-02f, 7.88688883e-02f, 2.28994917e-02f, 5.19534126e-02f,
  5.25730476e-02f, 3.47181000e-02f, -4.12449054e-02f, -1.04553849e-02f, -4.12946716e-02f, 8.83841291e-02f, 1.08211555e-01f, 1.54793272e-02f, 1.03021473e-01f, 3.68441679e-02f,
  6.87179118e-02f, 2.83515900e-02f, -5.75669296e-02f, 6.69034803e-03f, -4.14375216e-02f, 2.03818046e-02f, 2.62347539e-03f, 3.17109786e-02f, -8.99371633e-04f, 3.66413817e-02f,
  3.09385043e-02f, -8.10056031e-02f, -4.25704941e-02f, -1.05414525e-01f, 1.61499903e-02f, -5.34791090e-02f, -7.99562782e-02f, -5.52850738e-02f, -5.56886457e-02f, 8.69063735e-02f,
  -1.92554682e-01f, -2.73335949e-02f, -1.65432855e-01f, -4.47810143e-02f, -2.38386970e-02f, -1.14216179e-01f, -6.09676503e-02f, -9.12903473e-02f, -9.77739021e-02f, 1.19781435e-01f,
  2.73769069e-03f, 1.02727897e-01f, 3.45108546e-02f, -2.47269962e-02f, -5.48956357e-02f, 1.04901940e-01f, 1.63187206e-01f, -9.80390236e-02f, 8.39027837e-02f, 5.86109422e-03f,
  -1.90364748e-01f, 1.08584248e-01f, -1.05651423e-01f, 5.37438318e-02f, -5.67276068e-02f, -7.15306401e-02f, 1.21700279e-01f, 1.61383033e-01f, -8.43932778e-02f, 2.48826966e-02f,
  -1.62242446e-02f, 1.29439309e-01f, 3.95592349e-03f, -1.30154192e-01f, -6.85835183e-02f, 4.52131666e-02f, -2.29980461e-02f, -6.23545311e-02f, 1.60304606e-01f, 2.73287315e-02f,
  -2.79860944e-02f, 9.96462032e-02f, 1.21444948e-01f, 2.94550229e-02f, -1.19948052e-02f, -1.49364144e-01f, 2.69169342e-02f, 2.28841871e-01f, 3.77316922e-02f, -1.18578129e-01f,
  -6.74417242e-03f, 1.44352382e-02f, -1.49317160e-02f, 5.34315147e-02f, 6.81773722e-02f, -1.11786023e-01f, -1.17644081e-02f, 6.81542009e-02f, 6.79173367e-03f, 8.40541720e-02f,
  5.61976023e-02f, -6.16105914e-04f, 3.12283053e-03f, 9.16455314e-03f, -8.66839811e-02f, -2.40944908e-03f, 5.68192452e-02f, 3.24805751e-02f, 8.96321330e-03f, 6.94211051e-02f,
  9.32738483e-02f, -7.42082745e-02f, 7.33943190e-03f, 1.41866272e-02f, 2.21242942e-02f, 5.44807538e-02f, -1.04935663e-02f, -2.44691148e-02f, 9.61640775e-02f, -6.18686453e-02f,
  1.35513376e-02f, -6.31867349e-03f, -4.59026881e-02f, -4.85662147e-02f, -1.34352967e-01f, -1.45988194e-02f, -5.50433761e-03f, -7.87701271e-03f, -1.22848675e-01f, -1.63339507e-02f,
  -1.14765190e-01f, 9.96899139e-03f, -9.40023363e-02f, -2.80994270e-02f, -1.02918684e-01f, 6.70625195e-02f, -5.98221570e-02f, -1.76828742e-01f, -1.12311333e-01f, -6.26451895e-02f,
  4.38454933e-03f, -8.19514915e-02f, -6.55532989e-04f, -2.46261340e-02f, -1.24096468e-01f, 8.91170930e-03f, -1.12001739e-01f, 1.22559937e-02f, -8.06884393e-02f, -9.45713744e-02f,
  6.10537529e-02f, -4.40210626e-02f, -8.81897956e-02f, -5.78717068e-02f, -5.71025014e-02f, -4.50990237e-02f, -1.77255217e-02f, 5.47411963e-02f, 6.86310381e-02f, -6.53674379e-02f,
  -7.85181522e-02f, -7.43481368e-02f, 5.88158369e-02f, -6.50281832e-02f, -5.21919578e-02f, -1.55694455e-01f, -8.35964680e-02f, -8.41851404e-04f, 3.66897546e-02f, 7.75254294e-02f,
  -3.13449651e-02f, -2.09459662e-01f, 4.64276560e-02f, -2.51297317e-02f, 1.03299797e-01f, 2.06436049e-02f, -1.64199788e-02f, 3.92070301e-02f, 7.03542456e-02f, 6.53545856e-02f,
  4.38423827e-02f, -2.59572063e-02f, -8.34855363e-02f, -9.73527953e-02f, -4.58382703e-02f, -3.23994569e-02f, 5.90098090e-02f, -1.55648142e-01f, -1.76309168e-01f, -1.18473627e-01f,
  -5.85480779e-02f, 3.59790102e-02f, -6.82689697e-02f, -1.01649687e-01f, 8.89386907e-02f, -2.36688601e-03f, -5.90748973e-02f, -1.44564047e-01f, 2.27071755e-02f, 1.20835997e-01f,
  -1.10204019e-01f, -6.24358132e-02f, 1.56220412e-02f, 4.13228422e-02f, -2.39343289e-02f, 5.65141253e-02f, -2.42694318e-02f, 5.49138859e-02f, -3.34512889e-02f, 1.29879981e-01f,
  1.34636998e-01f, -1.23233773e-01f, -9.94227231e-02f, 3.90949808e-02f, 1.16549969e-01f, 1.54552624e-01f, 3.10505610e-02f, -1.57464165e-02f, -1.14933014e-01f, -2.54028421e-02f,
  2.72191456e-03f, 3.79342958e-02f, -5.27572446e-03f, -7.06561506e-02f, 6.52005449e-02f, 2.07660608e-02f, -4.31659669e-02f, -4.38872874e-02f, 1.00467265e-01f, -3.62839103e-02f,
  7.03433082e-02f, 5.32935262e-02f, 3.16552632e-02f, 1.58665031e-02f, 4.42875773e-02f, 6.77609723e-03f, -7.33721927e-02f, 5.36593981e-03f, -3.95253152e-02f, -4.41419519e-02f,
  -7.69680217e-02f, 6.08096644e-02f, 6.41222149e-02f, 3.88339870e-02f, 6.22632466e-02f, -4.06825058e-02f, 7.66311064e-02f, -8.82935827e-04f, -2.16274261e-02f, -1.41833420e-03f,
  -5.50480820e-02f, 9.26934853e-02f, -4.19127867e-02f, 9.19831470e-02f, -1.21124543e-01f, -7.75391832e-02f, 1.44047774e-02f, -8.06470811e-02f, 3.43260914e-02f, 9.56942961e-02f,
  3.29348370e-02f, -6.46713972e-02f, 4.78983745e-02f, 7.90516436e-02f, 2.90257577e-02f, 3.53446975e-02f, 2.61269528e-02f, 5.07782884e-02f, 3.73806097e-02f, -4.89011779e-02f,
  5.97207695e-02f, 1.83741432e-02f, -1.17401620e-02f, 1.03409952e-02f, -5.05983047e-02f, 4.10402827e-02f, 2.22502723e-02f, 1.19002819e-01f, -6.81378692e-02f, 1.03138722e-01f,
  1.61748454e-02f, -1.64764374e-02f, -6.81695044e-02f, 3.31856161e-02f, 5.76128252e-02f, -5.72672114e-02f, -4.75906432e-02f, -8.64688680e-02f, -4.35989872e-02f, 3.31322812e-02f,
  -5.55836409e-02f, 5.24320938e-02f, 1.25570204e-02f, 6.95612654e-02f, -8.93600807e-02f, -1.75510824e-01f, 1.69313699e-01f, -2.89771687e-02f, 1.13069884e-01f, 4.60252203e-02f,
  -1.01327918e-01f, -4.18965109e-02f, 1.49057239e-01f, -1.70049459e-01f, -4.99343537e-02f, 3.21941520e-03f, 6.79636151e-02f, -1.02449872e-01f, 4.82315011e-02f, 3.25360848e-03f,
  -4.24100384e-02f, -6.50141165e-02f, -2.19053371e-04f, 1.65091947e-01f, -1.80272073e-01f, -2.43308749e-02f, 2.05726430e-01f, -6.41409457e-02f, 1.72120407e-01f, -1.10832237e-01f,
  2.80528404e-02f, 6.97100461e-02f, 7.89694935e-02f, -1.17593475e-01f, 2.83654779e-02f, -3.76945734e-02f, 4.54268418e-02f, -4.29584384e-02f, 1.14905886e-01f, 1.85771033e-01f,
  7.27177113e-02f, -1.27310455e-01f, 1.86877009e-02f, 1.14498273e-01f, -1.51328042e-01f, -8.67612511e-02f, 1.20118797e-01f, 4.34496552e-02f, 1.62894726e-02f, -3.23091373e-02f,
  1.97408181e-02f, 3.09827216e-02f, -1.70007721e-01f, -2.49134123e-01f, 1.45327881e-01f, 8.66230801e-02f, 1.45937465e-02f, -5.64178601e-02f, 1.67296566e-02f, -8.12092945e-02f,
  -1.46796908e-02f, 7.03438371e-02f, -9.49416123e-03f, -5.35998084e-02f, -7.14803711e-02f, -1.04120009e-01f, 3.14278007e-02f, 4.25773785e-02f, 5.09964265e-02f, -9.12826583e-02f,
  -6.75086752e-02f, -7.84691647e-02f, 2.27251258e-02f, -2.53612045e-02f, 6.03617541e-02f, -8.25368240e-02f, -1.09113291e-01f, 1.22404046e-01f, 5.06289266e-02f, -3.06944158e-02f,
  7.50432983e-02f, 4.76242565e-02f, 2.44033597e-02f, 5.58183994e-03f, 3.30261439e-02f, 9.14292410e-02f, 4.27542627e-02f, -2.88598184e-02f, -3.90596385e-03f, 4.74885553e-02f,
  -6.93935901e-02f, -7.64465984e-03f, 1.34002477e-01f, -4.44757193e-02f, 3.91100459e-02f, 7.60246813e-02f, 9.05723497e-02f, -6.32724911e-02f, -6.70454130e-02f, -6.93828762e-02f,
  7.13677406e-02f, -6.55827299e-02f, -1.40744373e-01f, 6.06013089e-02f, 1.08457409e-01f, 6.42907694e-02f, 6.99294135e-02f, 5.09320535e-02f, 3.30028310e-02f, 4.88990285e-02f,
  1.73797961e-02f, -2.10614596e-02f, 5.20685054e-02f, 4.68182750e-02f, 4.60200235e-02f, -5.33310249e-02f, -4.82418649e-02f, -8.35168064e-02f, 4.60988767e-02f, -7.86629990e-02f,
  -1.00669496e-01f, 5.94628640e-02f, 1.05001979e-01f, 3.79744358e-02f, -1.67257022e-02f, 9.21068713e-02f, 1.16633382e-02f, 6.00237809e-02f, 7.63888061e-02f, -5.94574250e-02f,
  -1.27361715e-01f, 1.10660762e-01f, 4.44384851e-02f, -6.17216676e-02f, -1.69600502e-01f, 7.23048523e-02f, 7.03236461e-02f, 5.01947552e-02f, -1.78540554e-02f, 4.61980067e-02f,
  2.47312598e-02f, 1.79556504e-01f, 2.22815443e-02f, -5.37708402e-02f, -3.79201695e-02f, -7.23024756e-02f, -5.36066964e-02f, 8.57025832e-02f, 6.60738945e-02f, 9.09442157e-02f,
  -1.26908168e-01f, 3.33037190e-02f, 6.17771856e-02f, -9.92739573e-02f, -2.95397490e-02f, 4.40106057e-02f, -1.73491389e-01f, -2.16648858e-02f, -6.42292872e-02f, -1.12701496e-02f,
  -7.95453936e-02f, -1.57825768e-01f, -3.83565091e-02f, 5.80560751e-02f, 1.00494765e-01f, 3.48166153e-02f, -1.36179393e-02f, -1.12755194e-01f, -2.01175451e-01f, 1.25425577e-01f,
  5.11928722e-02f, 5.67805059e-02f, 7.75425956e-02f, 7.56636783e-02f, -1.83150603e-03f, -5.70566244e-02f, -1.62949394e-02f, -4.99709323e-02f, -1.47494137e-01f, -2.39902805e-03f,
  1.54913142e-02f, 9.10748616e-02f, -3.71438041e-02f, -7.28532299e-02f, -2.36947499e-02f, 2.75503695e-02f, 2.11220309e-02f, -6.42654523e-02f, -7.91172683e-02f, -1.08086774e-02f,
  5.98922968e-02f, 9.17350724e-02f, 4.47706804e-02f, -3.99860702e-02f, 7.61180278e-03f, -4.97026332e-02f, -8.04697946e-02f, 8.68098624e-03f, 8.94870237e-02f, 9.95556563e-02f,
  -1.94104612e-02f, 1.00673974e-01f, -6.19695671e-02f, 8.41943473e-02f, 1.15409113e-01f, -9.83802788e-03f, 4.58247662e-02f, -3.45405415e-02f, 1.30325486e-03f, -5.36171533e-02f,
  -7.09478371e-03f, 3.55148725e-02f, 5.43528832e-02f, -2.93222908e-02f, -1.50224427e-02f, -6.25166073e-02f, -3.55489179e-02f, 4.06218693e-03f, 4.92264852e-02f, 1.35310809e-03f,
  5.08298688e-02f, 1.10716164e-01f, -2.94268113e-02f, 6.79494292e-02f, -2.94645410e-02f, -6.21155240e-02f, -1.37761943e-02f, 4.94090840e-02f, -8.91118646e-02f, 9.22782496e-02f,
  1.23760357e-01f, -8.87063295e-02f, -3.88374962e-02f, 3.97346392e-02f, -7.02802315e-02f, 3.08283735e-02f, 1.21235186e-02f, 9.67167690e-02f, 2.99331862e-02f, -7.57215694e-02f,
  8.13051984e-02f, -8.07920694e-02f, -5.10205775e-02f, -4.89175366e-03f, 9.14866552e-02f, 8.39981344e-03f, 2.18549613e-02f, -1.90565754e-02f, -4.42127027e-02f, 1.14500886e-02f,
  1.95374452e-02f, 3.72689813e-02f, -1.68256517e-02f, 5.76928221e-02f, -7.06555024e-02f, -9.31008980e-02f, -2.37378534e-02f, 1.54131530e-02f, -6.78887293e-02f, -1.13656744e-02f,
  -5.59400022e-02f, 5.55222444e-02f, 5.94036691e-02f, -8.68978947e-02f, -5.64121120e-02f, -1.94280073e-01f, -1.29738962e-03f, -5.63725904e-02f, 5.26432917e-02f, -4.60844636e-02f,
  1.06156006e-01f, 5.68420142e-02f, -9.81711037e-03f, 9.36467126e-02f, 3.21575068e-02f, -8.79364535e-02f, 1.51212364e-02f, -3.87429968e-02f, -7.23696351e-02f, 6.93641463e-03f,
  -4.12172303e-02f, -6.35681078e-02f, -8.60447884e-02f, -7.20518380e-02f, 2.95675024e-02f, 9.76304486e-02f, 6.41975105e-02f, 9.36054718e-03f, 1.16220199e-01f, 1.22537740e-01f,
  -1.00457489e-01f, 4.29827943e-02f, 1.10133858e-02f, -1.89652238e-02f, -7.82324374e-02f, 1.27951261e-02f, 1.66998103e-01f, -4.25386690e-02f, -8.04954544e-02f, 1.52311265e-01f,
  -6.22465238e-02f, -5.14372773e-02f, -4.73025739e-02f, 9.11520943e-02f, 1.67095691e-01f, 4.83021792e-03f, 6.29411563e-02f, -4.28769141e-02f, -4.94623445e-02f, -7.07722902e-02f,
  5.54600209e-02f, -5.51736169e-02f, -5.33624254e-02f, -1.68842915e-02f, 5.66163063e-02f, -7.88110569e-02f, 2.05738731e-02f, -4.55018133e-03f, 9.16896388e-02f, 3.16253491e-02f,
  -5.19814491e-02f, 7.49314204e-02f, 1.80814546e-02f, 1.84269957e-02f, 5.61780073e-02f, -5.16423993e-02f, -4.55160961e-02f, -1.22867890e-01f, 9.62465554e-02f, -1.34160936e-01f,
  -6.59007803e-02f, 6.49215132e-02f, -1.18353076e-01f, -1.41262040e-02f, 4.00121398e-02f, 6.12526946e-02f, 1.09415753e-02f, -2.43869815e-02f, -1.78452432e-02f, 1.22269414e-01f,
  -7.62744173e-02f, 1.37709370e-02f, -5.24168685e-02f, 1.12234734e-01f, -5.55842705e-02f, -4.04854305e-02f, 4.45403568e-02f, 8.94488916e-02f, -1.45716667e-01f, 1.48943756e-02f,
  6.10133670e-02f, -4.41009626e-02f, -4.22965772e-02f, -2.17787270e-03f, 1.61196768e-01f, 6.87116617e-03f, -1.22646634e-02f, -4.89451960e-02f, 1.08878307e-01f, -7.46941343e-02f,
  1.53930821e-02f, -4.86508533e-02f, 5.14590973e-03f, -7.44493678e-02f, -1.02418894e-03f, -8.19542110e-02f, 6.24302737e-02f, 2.81299241e-02f, -1.28179267e-01f, 6.78234622e-02f,
  -4.82849292e-02f, -5.02981693e-02f, 1.91715360e-02f, -1.14410017e-02f, -1.00058995e-01f, 7.46105835e-02f, 1.04635671e-01f, 5.68355396e-02f, 3.12814042e-02f, 5.40140644e-02f,
  -6.33090809e-02f, -8.91248286e-02f, 1.13660926e-02f, 5.04683778e-02f, 6.05831482e-02f, 3.35088931e-02f, 1.72823504e-01f, 2.17023343e-02f, 1.10551335e-01f, 1.13484301e-01f,
  -3.88634391e-02f, -1.69994146e-01f, -8.85527804e-02f, 3.15322876e-02f, -4.52751294e-02f, 3.33070271e-02f, 9.20229182e-02f, 2.71531679e-02f, -9.09769163e-02f, 1.43826008e-01f,
  6.88920841e-02f, 1.50394514e-01f, 1.89371243e-01f, -1.72078699e-01f, 4.57911193e-02f, -2.00698059e-02f, 2.41785914e-01f, 1.61477089e-01f, -1.35393932e-01f, 8.29507709e-02f,
  1.42502517e-01f, 1.14655517e-01f, 1.15093343e-01f, 1.03008471e-01f, 1.19583338e-01f, 1.26997847e-02f, 1.34958267e-01f, 2.19264373e-01f, -7.58208334e-02f, 1.90496087e-01f,
  1.09334774e-01f, -5.30402474e-02f, 2.58776117e-02f, 2.00574279e-01f, -7.33523294e-02f, -7.34663382e-02f, 1.25792190e-01f, -2.24784240e-01f, -4.72583212e-02f, -1.17086083e-01f,
  -4.14876267e-02f, 3.08257341e-02f, 6.15557171e-02f, 7.82631710e-02f, 1.51488617e-01f, 2.77862083e-02f, -1.65911186e-02f, 4.45515737e-02f, 3.97996530e-02f, 7.58067667e-02f,
  7.11440817e-02f, 5.55889271e-02f, -4.72749732e-02f, -1.04141720e-01f, 7.88678154e-02f, 8.05596858e-02f, 4.61510085e-02f, -1.79099180e-02f, -9.64522362e-02f, -8.61110911e-02f,
  -9.95180197e-03f, -8.15105066e-02f, 3.55519839e-02f, 1.72980260e-02f, 3.25915329e-02f, -6.60751909e-02f, -7.72833005e-02f, -9.02481526e-02f, 2.74615064e-02f, -2.31038872e-02f,
  4.78511862e-02f, 3.01459711e-02f, 1.25124797e-01f, 7.30407797e-03f, 7.40887970e-02f, -8.70706961e-02f, 2.17107148e-03f, -4.32748161e-03f, 4.92575727e-02f, -3.50477360e-02f,
  -4.05767933e-03f, 2.00493913e-02f, 3.59883346e-02f, 7.47888684e-02f, -1.04540847e-02f, 3.33804674e-02f, 7.14964047e-02f, -5.38789593e-02f, 1.79254618e-02f, -2.44868658e-02f,
  3.04855332e-02f, 6.97204992e-02f, -1.62167791e-02f, -1.26435766e-02f, -8.65202621e-02f, -5.28351143e-02f, 4.26122583e-02f, -9.88445953e-02f, -3.53364572e-02f, 8.95014703e-02f,
  -8.34612027e-02f, -7.03001246e-02f, 2.33559739e-02f, -1.22904275e-02f, 5.36431260e-02f, -4.00548093e-02f, -2.51816791e-02f, -5.37710376e-02f, 9.58305150e-02f, -2.70962752e-02f,
  1.84200723e-02f, 3.23963799e-02f, -6.36318550e-02f, 4.53103818e-02f, 2.20963210e-02f, 4.66069840e-02f, -5.34312949e-02f, 6.28672540e-02f, 3.66680212e-02f, -9.23937634e-02f,
  4.40952964e-02f, -8.10239464e-02f, 9.11227912e-02f, 5.37129492e-02f, -5.48559874e-02f, -9.88182332e-03f, 6.64374307e-02f, 8.71932283e-02f, -7.71062747e-02f, -1.37965530e-01f,
  1.67547509e-01f, -6.08189106e-02f, -2.54276656e-02f, -1.31152824e-01f, 8.16858038e-02f, -1.32714316e-01f, -9.25909579e-02f, -1.45576775e-01f, -3.71919312e-02f, -6.40490428e-02f,
  -1.60647795e-01f, 1.52708620e-01f, -5.17083704e-03f, 1.50568158e-04f, 5.81017695e-03f, -1.13204420e-02f, -3.50326532e-03f, -1.37337103e-01f, 3.76277193e-02f, -3.73756997e-02f,
  5.52895963e-02f, -3.56647372e-02f, 1.68123558e-01f, -6.18012017e-03f, -7.00900555e-02f, -1.66715030e-02f, 1.33438511e-02f, 1.21459499e-01f, -5.80385514e-02f, 9.20094699e-02f,
  -2.87714843e-02f, 1.51439115e-01f, -1.21084983e-02f, 3.75660174e-02f, 9.47529003e-02f, 1.53433740e-01f, -7.40724504e-02f, -3.48519646e-02f, 3.47763263e-02f, 1.74390036e-03f,
  -6.21254109e-02f, 1.12076569e-02f, 6.20456925e-03f, 1.21690989e-01f, -7.12299496e-02f, 3.33471410e-02f, -4.49022837e-02f, -8.59181657e-02f, -4.06220779e-02f, 8.32510218e-02f,
  6.22090995e-02f, -2.16703024e-02f, 8.85248259e-02f, 6.38746172e-02f, 7.11777583e-02f, -6.34444132e-02f, 6.76056892e-02f, 2.00093556e-02f, -1.01032265e-01f, 1.03306286e-01f,
  7.30753168e-02f, -5.10921851e-02f, 8.60991776e-02f, -1.34864047e-01f, 1.04218967e-01f, -1.02494463e-01f, 1.27751390e-02f, 1.00887910e-01f, -2.40430050e-02f, -9.31578316e-03f,
  1.01569936e-01f, 5.24486378e-02f, 6.81171939e-02f, -3.79432850e-02f, -9.75596681e-02f, -5.19912094e-02f, 3.58041115e-02f, -1.52021553e-02f, 7.85876811e-02f, -6.62755817e-02f,
  -4.11539786e-02f, 1.01832129e-01f, 2.67542452e-02f, 1.60748195e-02f, -2.51269434e-02f, -1.09288566e-01f, 9.57407430e-02f, -3.72252390e-02f, 9.46049467e-02f, 1.63738616e-02f,
  -3.58764641e-02f, 2.15746537e-02f, 9.29022059e-02f, 8.70520696e-02f, 1.26159247e-02f, 8.09680298e-02f, -2.21233293e-02f, 1.37098283e-02f, 2.57384423e-02f, 7.29334652e-02f,
  1.07542379e-02f, -5.11852168e-02f, -5.50254099e-02f, -4.23983410e-02f, 4.24740538e-02f, -6.43399879e-02f, -2.36421470e-02f, -2.31057052e-02f, 1.50366984e-02f, -6.43502548e-03f,
  1.17566586e-01f, -5.86499013e-02f, 5.18323705e-02f, -7.24315420e-02f, 1.01307258e-01f, 1.10327527e-01f, 3.20106596e-02f, -5.85297309e-02f, -4.39116433e-02f, 6.25657737e-02f,
  3.66237760e-02f, -3.63077112e-02f, -1.21965043e-01f, 4.55659395e-03f, -3.67484279e-02f, -1.08217940e-01f, 2.61346363e-02f, 7.97196105e-02f, 1.09803833e-01f, 1.27681836e-01f,
  -3.48632671e-02f, 8.85564238e-02f, 3.14530581e-02f, -7.20247254e-02f, -2.50109676e-02f, -1.12000637e-01f, 7.00073615e-02f, -1.64042771e-01f, -4.80039492e-02f, 1.31594002e-01f,
  -1.40607860e-02f, 6.81381747e-02f, -1.15625396e-01f, -2.47287955e-02f, 1.28013492e-01f, 3.70425321e-02f, 2.71095168e-02f, -6.61694780e-02f, -7.67823532e-02f, -5.52872270e-02f,
  -1.12395406e-01f, -1.30445724e-02f, -1.30002111e-01f, -2.02883691e-01f, 2.27126572e-02f, -9.37988162e-02f, -2.41933055e-02f, 3.70323174e-02f, 8.74540508e-02f, -3.36506441e-02f,
  -1.45742875e-02f, 1.26253605e-01f, -7.84236118e-02f, 1.04743727e-01f, -4.54708599e-02f, 1.21105321e-01f, -7.15849251e-02f, 3.23917866e-02f, -7.19800368e-02f, -5.64269125e-02f,
  1.63415596e-02f, 2.81195827e-02f, 1.05429972e-02f, -9.33878720e-02f, -6.54218271e-02f, -9.45241936e-03f, 7.22412989e-02f, 5.87533973e-03f, -6.87559023e-02f, -6.56850357e-03f,
  -1.58936232e-02f, 6.41484633e-02f, -6.09685741e-02f, 5.80742545e-02f, -8.66042897e-02f, 7.67103359e-02f, 3.41001600e-02f, 6.92078322e-02f, 1.05005270e-02f, -7.33384341e-02f,
  -8.33735913e-02f, 4.03179947e-05f, 7.89046735e-02f, -3.85893020e-03f, -7.64464866e-03f, 1.63591020e-02f, -1.65832210e-02f, 1.95386205e-02f, -1.11486159e-01f, -3.42267491e-02f,
  -8.14878047e-02f, 7.88540989e-02f, 6.02816120e-02f, 2.94103567e-02f, -8.55785608e-02f, -4.40750867e-02f, -6.57254159e-02f, 8.86610076e-02f, -5.76583967e-02f, -9.40663740e-02f,
  3.82866599e-02f, 4.81543057e-02f, -7.11729005e-02f, 4.04191576e-02f, 1.43438959e-02f, -4.50990461e-02f, -5.05146421e-02f, 2.92325579e-02f, 6.96325228e-02f, -3.54064666e-02f,
  -5.14461435e-02f, 1.08459011e-01f, -3.87299359e-02f, -3.41645302e-03f, 5.69287315e-03f, -9.48511511e-02f, 5.10665998e-02f, 5.93400910e-06f, -6.33979142e-02f, 2.14313180e-03f,
  -3.22755165e-02f, -5.53301089e-02f, -7.83978775e-02f, -6.89080870e-03f, 6.68533742e-02f, 1.08947279e-02f, -4.39063720e-02f, 3.56172249e-02f, -9.57581177e-02f, -1.29732043e-02f,
  -8.02010894e-02f, -6.97276648e-03f, 3.23151611e-02f, -9.34317261e-02f, -1.27144441e-01f, 1.45599574e-06f, 3.54578276e-03f, -5.15973754e-02f, 3.46769169e-02f, 8.96449536e-02f,
  -6.20585009e-02f, 6.54653162e-02f, -1.62013561e-01f, -6.85002282e-02f, 2.89070420e-02f, 6.74281940e-02f, 2.09378731e-03f, -6.62940815e-02f, -2.93915942e-02f, 1.33232828e-02f,
  7.47840181e-02f, -2.00780183e-02f, 5.36359623e-02f, 1.02722391e-01f, -1.01205572e-01f, 1.21257016e-02f, 6.56638443e-02f, -2.01402791e-02f, 9.30028707e-02f, -2.29416881e-02f,
  -1.54412119e-02f, 5.94403446e-02f, -1.51528120e-01f, 6.94885626e-02f, 6.83809966e-02f, 1.46306217e-01f, 1.01940334e-01f, 5.69923110e-02f, 1.05170153e-01f, 1.13065228e-01f,
  4.82375845e-02f, -7.09864404e-03f, 6.18943386e-02f, 4.58672084e-02f, -1.03351057e-01f, -5.68793900e-02f, -4.83221151e-02f, -7.19618797e-02f, 8.22503418e-02f, 2.75291596e-03f,
  2.21742559e-02f, 5.23847342e-02f, -1.46571502e-01f, -4.86638863e-03f, 4.12911884e-02f, -7.88026825e-02f, 2.36865878e-02f, 1.08735293e-01f, 6.03695028e-02f, -8.24162215e-02f,
  -3.62448804e-02f, -6.54304698e-02f, 4.35757488e-02f, -5.87719530e-02f, 1.10026570e-02f, 5.25985695e-02f, 1.40989767e-02f, 2.07560621e-02f, -3.57763767e-02f, 1.24022946e-01f,
  5.51315621e-02f, 3.87166403e-02f, 1.07068792e-02f, -4.01150770e-02f, -6.94218352e-02f, 4.52984385e-02f, -4.21182625e-02f, -1.12206601e-01f, -5.56660481e-02f, -3.58437712e-04f,
  1.97788607e-02f, -6.50467025e-03f, -3.38078998e-02f, 7.60717667e-04f, 4.77891453e-02f, 3.03986054e-02f, 1.07014831e-02f, -2.71013882e-02f, -9.94002819e-02f, -1.24225309e-02f,
  1.14070019e-03f, -1.17470123e-01f, 6.69634864e-02f, -1.16884269e-01f, 7.92423934e-02f, -3.60894576e-02f, -6.01274744e-02f, -4.89577428e-02f, -8.32495466e-02f, -5.79524674e-02f,
  1.28732519e-02f, -8.65756050e-02f, -1.12008959e-01f, -5.67538776e-02f, 4.46712039e-02f, 2.92798076e-02f, -3.10636461e-02f, 5.79321794e-02f, 6.41830415e-02f, 1.07502796e-01f,
  8.97589978e-03f, -3.87862734e-02f, 5.15092053e-02f, 8.17014724e-02f, -6.66354597e-02f, -2.24789102e-02f, 1.31872585e-02f, -4.54009278e-03f, -4.41222154e-02f, -2.92285681e-02f,
  3.68222073e-02f, -8.59426782e-02f, 3.23054753e-02f, -8.24466273e-02f, 2.32270546e-02f, -2.08753012e-02f, 1.27649859e-01f, -9.74705070e-02f, 2.12328918e-02f, -1.20328918e-01f,
  6.90648556e-02f, -2.43927315e-02f, 7.48423785e-02f, -4.42935787e-02f, 6.28857547e-03f, -3.36290523e-02f, -1.28676340e-01f, 6.99811652e-02f, -5.45373783e-02f, -3.45819592e-02f,
  -3.50006185e-02f, -8.20707083e-02f, 1.75729886e-01f, 8.14236850e-02f, 1.22731663e-01f, 2.83875428e-02f, 1.04266480e-01f, 1.15741547e-02f, 7.06444914e-03f, 3.04964967e-02f,
  6.39216006e-02f, -4.78316210e-02f, -1.50092989e-01f, -1.44291639e-01f, -6.66194782e-02f, 8.14407766e-02f, 2.52140276e-02f, -1.00116886e-01f, -1.19597249e-01f, 8.13933536e-02f,
  -2.02042218e-02f, -8.54039863e-02f, 1.03122413e-01f, 6.15752116e-02f, 1.23783397e-02f, -1.51673406e-01f, -1.75949484e-02f, -2.37458223e-03f, -9.54687893e-02f, -2.31284007e-01f,
  1.91858277e-01f, -7.15609863e-02f, -1.26781613e-01f, -4.72852886e-02f, 1.49999529e-01f, -6.89718723e-02f, -5.44188619e-02f, -5.81925660e-02f, -1.64027408e-01f, 9.51250829e-03f,
  -1.44767731e-01f, 1.35778174e-01f, 2.09598104e-03f, -1.22102596e-01f, 3.22665945e-02f, 7.31176883e-02f, -9.06424150e-02f, 3.12661268e-02f, -1.63443431e-01f, -1.87215760e-01f,
  -1.19755998e-01f, -3.32373045e-02f, 5.55010848e-02f, -9.94885489e-02f, 9.92814749e-02f, -1.04234312e-02f, -9.69290435e-02f, 2.27486026e-02f, -9.25192460e-02f, -5.21414801e-02f,
  -1.02213249e-02f, -3.47981751e-02f, -1.54477924e-01f, 8.74957293e-02f, -2.92851310e-02f, -1.11022063e-01f, -7.11062402e-02f, 2.10064352e-02f, -4.45567593e-02f, 6.42587319e-02f,
  -8.03775415e-02f, -1.04478642e-01f, -1.95711944e-02f, 7.58509561e-02f, 6.07023016e-02f, 9.84425470e-03f, 7.27109313e-02f, 1.26278456e-02f, -1.57068297e-02f, 5.95415793e-02f,
  -3.66138257e-02f, 1.02299385e-01f, -3.79721932e-02f, 5.98754324e-02f, -3.26315463e-02f, -2.98672501e-04f, -2.62690522e-02f, -4.65876944e-02f, 3.62037383e-02f, -9.17811692e-03f,
  -1.02527559e-01f, -7.45197460e-02f, -7.25311115e-02f, 1.15186416e-01f, 4.36666906e-02f, -1.04256213e-01f, 3.08663342e-02f, 5.61127998e-02f, 9.58084241e-02f, -5.39666899e-02f,
  8.71884301e-02f, -7.68542215e-02f, 1.02831550e-01f, 1.11523144e-01f, -3.18250433e-02f, 7.17297643e-02f, -9.11562052e-03f, 1.52192088e-02f, 9.14288685e-02f, 6.26406968e-02f,
  7.96382129e-03f, -6.46217093e-02f, -1.10835861e-02f, 3.91432568e-02f, 1.02554403e-01f, -7.11101890e-02f, -1.61581933e-01f, -1.18979448e-02f, -1.99316163e-02f, -5.44273444e-02f,
  1.46025629e-03f, -7.35286847e-02f, 7.06547871e-02f, -4.13229614e-02f, 3.44590768e-02f, -4.68977280e-02f, -8.42681676e-02f, -1.17826462e-01f, -1.31330729e-01f, -4.69634309e-02f,
  2.70672441e-02f, -2.92100478e-02f, 8.66199955e-02f, -9.47756246e-02f, 1.50988549e-02f, -1.66465342e-01f, 9.46508124e-02f, -1.30891157e-02f, -3.31107453e-02f, 1.02794223e-01f,
  -3.00558913e-03f, 1.12601593e-01f, -4.24758419e-02f, 2.00218633e-02f, -1.09423637e-01f, -5.11275418e-03f, -4.97043282e-02f, 4.07705456e-02f, -1.37428895e-01f, -1.83453605e-01f,
  -5.09884246e-02f, 6.24104927e-04f, -1.26302749e-01f, 4.66819145e-02f, -2.00836640e-02f, -1.64019674e-01f, 1.09481096e-01f, 1.05201481e-02f, 8.63350369e-03f, -1.42657921e-01f,
  2.33061593e-02f, 9.01501775e-02f, 1.24330804e-01f, 2.06642803e-02f, 1.23327471e-01f, 4.62899804e-02f, -1.31815165e-01f, -2.05687359e-02f, 7.59362355e-02f, 2.75991461e-03f,
  1.45096838e-01f, 6.37081340e-02f, 1.25389665e-01f, -9.44358930e-02f, -1.78810373e-01f, -4.67260219e-02f, -1.44260779e-01f, 2.62823049e-02f, -1.07696243e-01f, 4.29506376e-02f,
  4.22388799e-02f, 5.31909168e-02f, -7.53611103e-02f, -6.52373210e-02f, 1.07367598e-01f, -8.70908890e-03f, 1.12830423e-01f, 6.26165271e-02f, -4.10346054e-02f, -5.31584620e-02f,
  1.08814806e-01f, 1.54574858e-02f, 3.65163349e-02f, -3.87196057e-02f, 8.27756375e-02f, -3.46912518e-02f, 6.77157715e-02f, 9.80672017e-02f, 2.61158682e-02f, 6.15814552e-02f,
  -8.47011153e-03f, -3.75088155e-02f, 6.05452657e-02f, 1.55049842e-02f, 1.94926251e-04f, 8.65680501e-02f, -1.75566934e-02f, 3.88746746e-02f, 5.63828535e-02f, -6.21794052e-02f,
  -3.20081599e-02f, 2.63132025e-02f, -5.95645793e-02f, 2.85722297e-02f, -3.20896506e-02f, -7.15209395e-02f, 2.93593016e-02f, 5.13576716e-02f, 1.01791739e-01f, 5.71368337e-02f,
  9.94794909e-03f, 2.93673985e-02f, -1.09346777e-01f, -9.01461989e-02f, 5.31726405e-02f, 7.01759532e-02f, -4.23239879e-02f, -1.67025980e-02f, 2.53609382e-03f, -4.79013659e-02f,
  4.75195348e-02f, -4.13951315e-02f, 1.18701711e-01f, 1.05626762e-01f, 4.77677397e-02f, -6.16368726e-02f, 1.24859869e-01f, 3.89825329e-02f, -5.94895892e-02f, -1.81854516e-01f,
  -7.63959363e-02f, 3.70194353e-02f, 7.17633292e-02f, 2.43375488e-02f, -1.42388821e-01f, 9.30232853e-02f, 1.33559197e-01f, 1.04931533e-01f, 8.52369815e-02f, -8.70424435e-02f,
  6.82345554e-02f, -9.82850119e-02f, 6.37044804e-03f, 3.21451970e-03f, 1.09324185e-02f, 2.13453472e-02f, 9.90794152e-02f, -1.62817575e-02f, -4.10422087e-02f, 4.66822125e-02f,
  -5.80132976e-02f, 9.61586311e-02f, 6.59430251e-02f, -7.56056234e-02f, -2.48813089e-02f, 1.81491092e-01f, -1.81118220e-01f, -1.33235812e-01f, 1.28273576e-01f, -7.33213127e-02f,
  -7.31589943e-02f, 1.41457185e-01f, -7.22092539e-02f, 2.62254644e-02f, 4.04347889e-02f, -1.04567409e-01f, 1.47336423e-01f, -1.87253341e-01f, -5.49803749e-02f, 1.32111534e-02f,
  -7.96600804e-03f, 1.51914842e-02f, -1.81996763e-01f, -3.05710710e-04f, -9.13350284e-03f, -9.37920511e-02f, 2.31898613e-02f, -1.42751619e-01f, -4.38429452e-02f, 4.50944789e-02f,
  1.55017167e-01f, -1.74108613e-02f, -1.27919048e-01f, 1.15594350e-01f, -6.51231930e-02f, 4.01495844e-02f, 2.71637943e-02f, 1.45318553e-01f, 6.74512889e-03f, 1.06867835e-01f,
  -6.50451481e-02f, 7.26650804e-02f, -1.82979375e-01f, 1.08875044e-01f, 1.18956976e-01f, 1.14068672e-01f, -7.01736361e-02f, -7.36917704e-02f, 1.82924664e-03f, -9.99145061e-02f,
  -2.72768009e-02f, -4.03709970e-02f, -4.56700325e-02f, -4.11384255e-02f, 8.41966644e-02f, 7.89985210e-02f, 1.22143000e-01f, -3.99831031e-03f, -6.42197058e-02f, 1.26759797e-01f,
  2.84647499e-03f, -5.88080175e-02f, -4.69145514e-02f, 7.71228075e-02f, 5.61152957e-02f, 1.30266026e-01f, -3.78295332e-02f, 7.95985386e-02f, 6.75893277e-02f, 7.60561042e-03f,
  2.84233261e-02f, 3.29903816e-03f, -1.21518403e-01f, -1.61749665e-02f, 4.31803428e-02f, -4.99937572e-02f, -5.26197590e-02f, -9.37330499e-02f, 2.46056207e-02f, 7.34150037e-02f,
  -8.54134038e-02f, -2.53176261e-02f, -3.19943391e-02f, -1.01226382e-01f, 1.00089341e-01f, -7.11300075e-02f, -8.85147750e-02f, -8.25563073e-02f, -2.32234541e-02f, -8.68441239e-02f,
  -1.49356667e-02f, -2.19531022e-02f, 1.05269928e-03f, -4.68500294e-02f, -4.20260541e-02f, -4.20500748e-02f, -2.26992890e-02f, -5.14585003e-02f, 2.59273071e-02f, -7.08129304e-03f,
  4.37145308e-02f, -5.78391552e-03f, -7.66809285e-02f, 2.14948505e-02f, 7.32179359e-02f, 3.02901492e-02f, -8.40177462e-02f, -4.02153051e-03f, -7.19571784e-02f, 4.04927172e-02f,
  -6.48543462e-02f, 4.77316268e-02f, 2.53926776e-03f, -6.26561269e-02f, -2.20005233e-02f, -5.26376404e-02f, 5.73068261e-02f, 2.52341200e-02f, -6.51042238e-02f, -7.75660053e-02f,
  6.08837120e-02f, -6.77739605e-02f, -1.46632299e-01f, -1.42101228e-01f, -3.88171598e-02f, 1.23761138e-02f, 4.14826125e-02f, 4.41728830e-02f, -4.72325683e-02f, -1.48993105e-01f,
  -1.22103512e-01f, 7.27891773e-02f, -5.18906042e-02f, 9.33536440e-02f, 1.49867356e-01f, -7.14092180e-02f, 5.68751767e-02f, 9.46905315e-02f, 5.55323958e-02f, 5.44552207e-02f,
  -1.48409605e-01f, 3.12116574e-02f, -1.16074912e-01f, -2.17073947e-01f, 1.35365322e-01f, -8.26175064e-02f, -1.65564448e-01f, -1.33475855e-01f, -1.35364115e-01f, 1.05634116e-01f,
  -4.54175659e-02f, -4.15675975e-02f, 5.81175722e-02f, 2.18503065e-02f, -3.14695686e-02f, -1.55941114e-01f, -8.38934705e-02f, 1.54968932e-01f, -1.93251669e-01f, -1.22920558e-01f,
  1.02273770e-01f, 2.02763677e-01f, 1.51259289e-03f, 3.44842523e-02f, -3.86906080e-02f, 4.08998094e-02f, -3.45742702e-02f, 9.78007987e-02f, -5.38054928e-02f, -1.20426245e-01f,
  3.03172003e-02f, 1.52894426e-02f, 1.44280285e-01f, 8.74445438e-02f, -8.72530118e-02f, 1.02468561e-02f, 3.34123224e-02f, 3.44768688e-02f, 2.47133393e-02f, -3.54704037e-02f,
  1.85132250e-02f, -4.77213673e-02f, 3.44428308e-02f, 6.06856830e-02f, 2.37563010e-02f, -6.27907664e-02f, 2.88413391e-02f, -1.24215083e-02f, -2.73002163e-02f, 4.16358281e-03f,
  7.97081832e-03f, 6.58513932e-03f, -2.70607099e-02f, -8.29357095e-03f, 3.82785685e-02f, -3.36324982e-02f, 3.66459088e-03f, 6.79456294e-02f, -2.68308986e-02f, -6.16003387e-02f,
  -1.80991963e-02f, -6.61965134e-03f, -3.73085588e-02f, -6.35515228e-02f, 4.38732281e-02f, -9.61443409e-02f, 1.61495619e-02f, 6.80766627e-02f, -7.18826726e-02f, 2.50214916e-02f,
  1.47070482e-01f, 3.80155258e-02f, -1.83215532e-02f, -5.53469080e-03f, -9.35160294e-02f, -5.97780906e-02f, 9.40389484e-02f, -5.68072349e-02f, 7.73308203e-02f, -2.84504867e-03f,
  -1.04068145e-01f, -4.92022485e-02f, 1.60629228e-02f, 2.16698367e-02f, -3.38889584e-02f, 5.39046852e-03f, -1.58989150e-02f, 1.50867194e-01f, 2.62410771e-02f, -1.02514876e-02f,
  2.39811204e-02f, 9.84593667e-03f, 3.45049128e-02f, 8.64504930e-03f, 1.01988629e-01f, 1.26319662e-01f, 4.97356690e-02f, 2.67587453e-02f, 2.09255740e-02f, 3.60608138e-02f,
  1.04343303e-01f, -6.72660917e-02f, -1.07125811e-01f, 8.85159373e-02f, -2.67826803e-02f, 3.13679525e-03f, 5.74318059e-02f, 3.17653567e-02f, 6.15169331e-02f, 1.39725963e-02f,
  8.47015902e-03f, -8.28410313e-02f, 3.69434580e-02f, -4.93774526e-02f, 8.56920406e-02f, 5.99539839e-03f, -4.71271686e-02f, -3.76074761e-02f, -8.80143344e-02f, 1.07476957e-01f,
  -3.30350138e-02f, -1.61845550e-01f, 1.73068538e-01f, -4.08707224e-02f, -1.19676450e-02f, 1.89416315e-02f, 8.58455524e-02f, -4.42240983e-02f, -8.41087103e-02f, 3.94037254e-02f,
  -6.23623095e-02f, -1.47706106e-01f, 1.26754209e-01f, 2.60153841e-02f, -1.45042300e-01f, -1.59564331e-01f, -7.83697050e-03f, 5.99280745e-02f, 7.84342289e-02f, 7.54624081e-04f,
  1.00636683e-01f, 6.22647069e-02f, -1.46685779e-01f, -5.26270363e-03f, -9.18734521e-02f, 1.48950860e-01f, 1.62956142e-03f, -5.89691810e-02f, 1.05856471e-01f, 1.05146170e-01f,
  4.91492860e-02f, 2.49633640e-02f, 6.53406829e-02f, -2.06153214e-01f, -2.55871881e-02f, 7.55094439e-02f, 8.65293741e-02f, -1.62978590e-01f, 1.84772104e-01f, -5.68077229e-02f,
  3.13289389e-02f, 1.69468448e-02f, -4.68041934e-03f, -1.96567550e-03f, 5.46903200e-02f, -3.09853237e-02f, -1.15624741e-01f, -4.71359976e-02f, 1.59599539e-02f, -1.26787350e-01f,
  -3.93817611e-02f, -2.31922939e-02f, 7.27533326e-02f, 6.73685595e-02f, 1.37105078e-01f, -1.03511974e-01f, 1.22582190e-01f, 8.33070651e-02f, -8.68707970e-02f, -8.09724331e-02f,
  5.20880371e-02f, -1.40981957e-01f, 8.33011419e-03f, -1.92723460e-02f, -9.00358036e-02f, -9.30603743e-02f, -8.43428914e-03f, 4.43287343e-02f, 4.49251160e-02f, 9.72519070e-02f,
  -7.98728764e-02f, -9.51686054e-02f, -1.71975996e-02f, -3.49549688e-02f, 6.19924590e-02f, -9.40875486e-02f, -3.69422473e-02f, 1.72730200e-02f, 5.24953529e-02f, -7.12025166e-02f,
  4.30321097e-02f, -4.60599177e-02f, 6.24142122e-03f, 2.37915069e-02f, 4.16710861e-02f, 7.50369430e-02f, -2.71779615e-02f, -9.03847069e-02f, -1.37957474e-02f, -1.14100473e-02f,
  -1.09158978e-01f, 4.03776877e-02f, 2.92710920e-05f, 9.83180925e-02f, 5.20698875e-02f, 7.17019364e-02f, -8.61358345e-02f, 3.86260748e-02f, -2.60855746e-03f, -8.37443173e-02f,
  3.10965311e-02f, -2.50975657e-02f, -1.14179449e-03f, -1.02487981e-01f, 7.10195452e-02f, -1.89852994e-02f, 2.81518474e-02f, -9.48771983e-02f, -4.93273251e-02f, -4.29650284e-02f,
  -4.02160697e-02f, 2.38474458e-02f, 5.69468997e-02f, 7.65033672e-03f, 2.34342627e-02f, -5.67560876e-03f, -4.06812839e-02f, 6.63485453e-02f, -8.83410200e-02f, -5.70871234e-02f,
  -1.06198043e-01f, -9.75237936e-02f, -8.22425634e-03f, 2.07309544e-01f, 1.32014155e-02f, -8.14104229e-02f, -7.72263564e-04f, 7.74930492e-02f, -4.06980002e-03f, 4.15097969e-03f,
  1.10411725e-03f, 5.54786325e-02f, -3.46047506e-02f, -1.46737307e-01f, 9.21661686e-03f, 1.37920707e-01f, 5.35663366e-02f, 5.94906285e-02f, -1.66680023e-01f, 1.35248096e-03f,
  3.26658525e-02f, -4.94508035e-02f, 1.52232558e-01f, 7.22840056e-02f, -2.17502534e-01f, -4.96019386e-02f, -8.98205191e-02f, -8.25943018e-04f, -7.85773918e-02f, -1.62857175e-01f,
  1.02572829e-01f, -7.06602409e-02f, 2.21379064e-02f, -8.66812170e-02f, 7.72009604e-03f, -1.17963433e-01f, -6.36592954e-02f, 5.14924973e-02f, -6.31026700e-02f, 7.28318170e-02f,
  1.97194051e-03f, 1.92024171e-01f, -1.33984089e-01f, -7.51827881e-02f, -4.34271842e-02f, 4.07709479e-02f, -1.69231296e-01f, 4.46951613e-02f, -1.33071527e-01f, 3.70350853e-02f,
  -1.04214810e-01f, 5.67651689e-02f, -9.46550518e-02f, -3.04452498e-02f, 5.77509291e-02f, 7.80942217e-02f, -2.05662400e-02f, -5.93914613e-02f, -3.14122625e-02f, -1.72307082e-02f,
  8.24269429e-02f, -3.52090858e-02f, 3.58815268e-02f, -6.42793998e-02f, -5.96125610e-02f, -2.95466483e-02f, 2.82552075e-02f, 5.90538196e-02f, 5.98492548e-02f, 1.22676566e-01f,
  -3.81876864e-02f, -9.07685161e-02f, 1.15003542e-03f, -2.85149440e-02f, -7.07271025e-02f, 2.99989581e-02f, -4.40635420e-02f, 5.29528931e-02f, 4.39213067e-02f, -6.18656091e-02f,
  3.36331911e-02f, 5.07287532e-02f, 1.79043766e-02f, 1.29210409e-02f, -5.22037558e-02f, -6.26132116e-02f, -2.82988027e-02f, -1.37132317e-01f, 6.64006695e-02f, 7.50380242e-03f,
  1.08096056e-01f, 5.16932905e-02f, -1.47960829e-02f, -4.47183736e-02f, -1.04803078e-01f, -1.45817176e-01f, -3.19099762e-02f, -1.72285624e-02f, -1.01096742e-01f, 9.34193730e-02f,
  4.25469540e-02f, -1.01431813e-02f, -1.98467560e-02f, -8.81818756e-02f, -9.41559598e-02f, -8.45269710e-02f, 5.07836528e-02f, 1.54483812e-02f, -6.28306791e-02f, 2.47560535e-02f,
  -8.45021755e-02f, -3.78585495e-02f, 1.73374768e-02f, -3.60885519e-03f, -1.37327716e-01f, 1.22715002e-02f, -1.61237672e-01f, -4.27442379e-02f, 5.27308956e-02f, -4.19176109e-02f,
  -1.35530815e-01f, 9.27305222e-02f, 8.69616494e-02f, -2.13015974e-02f, -4.04200666e-02f, 4.10224348e-02f, -2.75982190e-02f, 1.04076505e-01f, -9.93604884e-02f, 8.27075988e-02f,
  -1.46605805e-01f, -8.42725337e-02f, 1.85073957e-01f, 5.79119893e-03f, -1.03422254e-02f, -1.19895458e-01f, -1.07012019e-01f, 3.48435193e-02f, -3.36842798e-02f, 8.33849311e-02f,
  -1.65040448e-01f, -1.03100367e-01f, -1.44655943e-01f, 5.61797656e-02f, 1.72579680e-02f, -2.68499143e-02f, 7.83942267e-02f, 8.17189645e-03f, -7.36469822e-03f, 4.33960035e-02f,
  4.91075553e-02f, 1.56661883e-01f, -1.64619625e-01f, 5.14480174e-02f, 1.04699634e-01f, 5.68252504e-02f, -5.41105159e-02f, -7.60806026e-03f, 1.63371131e-01f, 1.61950186e-01f,
  2.52362210e-02f, 1.20269395e-02f, -3.94576564e-02f, -1.25454471e-01f, -1.58702135e-01f, 1.13114752e-02f, 6.39924929e-02f, -5.61985150e-02f, 4.33114581e-02f, 2.13496059e-01f,
  -6.50759712e-02f, -8.81388504e-03f, -1.90884676e-02f, 7.75090083e-02f, -1.86894640e-01f, -7.43438527e-02f, 1.29690051e-01f, 2.44397283e-01f, 1.47615848e-02f, 3.96744199e-02f,
  -3.56782526e-02f, -3.33714634e-02f, 1.08152330e-01f, 6.58883899e-02f, 1.12877779e-01f, 1.93830319e-02f, -5.53058228e-03f, 6.86299428e-02f, 1.36627167e-01f, -7.25400001e-02f,
  -1.34964079e-01f, 2.82245446e-02f, -2.20759748e-03f, -3.76616716e-02f, 4.54042107e-02f, 5.82231842e-02f, 1.20116100e-01f, 8.52903351e-03f, -5.86766750e-02f, 1.92965288e-02f,
  -2.74976213e-02f, -1.11142077e-01f, 8.38309154e-02f, -3.37843336e-02f, 1.29924035e-02f, -9.81256366e-02f, 6.33997619e-02f, -8.98186397e-03f, -3.74397784e-02f, -7.95656294e-02f,
  -2.66332552e-02f, -8.06328580e-02f, -1.63726769e-02f, -5.68960328e-03f, -2.67031253e-04f, -1.23194657e-01f, -5.36046736e-02f, -1.32808477e-01f, -7.68390894e-02f, -4.02630456e-02f,
  -1.24733411e-02f, 2.55629327e-02f, -2.67532282e-02f, 4.00484714e-04f, -4.41532135e-02f, -8.17056745e-02f, -4.31016907e-02f, 5.57981879e-02f, 6.89623207e-02f, 1.98560972e-02f,
  1.77681111e-02f, -4.75176089e-02f, -2.19733603e-02f, -6.80440664e-02f, -5.83629385e-02f, 1.70127563e-02f, -1.04036555e-01f, -9.01201144e-02f, -5.01575731e-02f, -7.16552958e-02f,
  -7.42745819e-03f, 2.54700948e-02f, 1.38243726e-02f, -9.92532540e-03f, -5.89923784e-02f, -4.58794944e-02f, 7.51198903e-02f, 3.48805413e-02f, -1.11347593e-01f, -1.37403645e-02f,
  -8.78435746e-02f, -9.51492973e-03f, -7.78877959e-02f, -3.61002088e-02f, 2.41235234e-02f, 4.00401093e-03f, -3.90054076e-03f, 8.40002969e-02f, 1.60765842e-01f, -7.45858476e-02f,
  8.36219639e-02f, 7.05266669e-02f, 1.42127275e-01f, 6.12202361e-02f, -1.60007104e-01f, 9.58066583e-02f, -1.13561675e-01f, -1.28180683e-01f, -4.63675037e-02f, -1.91338316e-01f,
  7.52282962e-02f, 8.69521424e-02f, 7.79557750e-02f, 1.40992910e-01f, 5.16063534e-02f, -5.56405596e-02f, -7.85148889e-02f, 6.86025545e-02f, 1.49843916e-01f, 1.42357405e-02f,
  4.76446822e-02f, -8.24271142e-02f, -8.89936313e-02f, 1.56031862e-01f, -1.35299101e-01f, -1.74254656e-01f, 1.88095897e-01f, -1.73980221e-02f, 2.04957016e-02f, -4.88847345e-02f,
  2.53980774e-02f, 8.26548487e-02f, -2.79226489e-02f, -8.50844979e-02f, -8.12173113e-02f, 3.58854383e-02f, -9.82936919e-02f, 1.10299580e-01f, -7.54473731e-02f, -8.35052952e-02f,
  -9.93766189e-02f, 1.84609503e-01f, -2.61555947e-02f, 1.97280094e-01f, 7.18055591e-02f, -7.13501079e-03f, -4.27987427e-02f, 2.67495960e-02f, 9.08959955e-02f, 6.13739528e-02f,
  9.68591571e-02f, -7.19892085e-02f, -1.12113997e-01f, 6.39609396e-02f, 5.41704297e-02f, 2.72486433e-02f, -9.49439853e-02f, -5.43639474e-02f, -1.23181768e-01f, -3.96991745e-02f,
  -2.91907508e-02f, -1.04471281e-01f, 4.34387140e-02f, 3.24708931e-02f, -8.35654438e-02f, 3.09369769e-02f, 2.30932627e-02f, 2.20519900e-02f, -7.59682572e-03f, 3.27148214e-02f,
  -7.14645348e-03f, 5.43287909e-03f, -5.62983751e-02f, 3.01770214e-02f, -3.82904261e-02f, -5.96969505e-04f, -1.89345572e-02f, -3.36783715e-02f, 1.12691723e-01f, 6.72516674e-02f,
  4.60142456e-02f, 8.85448083e-02f, 3.88443051e-03f, -8.14090520e-02f, -1.17014036e-01f, -8.10125694e-02f, 1.26365438e-01f, -6.92600831e-02f, 3.25096473e-02f, 4.67425622e-02f,
  -2.01519001e-02f, -8.13975334e-02f, 6.06787540e-02f, 2.97327377e-02f, 8.54969844e-02f, 1.11956634e-01f, 2.42693312e-02f, 9.83037651e-02f, 9.95173603e-02f, -6.35132194e-02f,
  -2.93843728e-03f, -2.81108264e-02f, 7.32115060e-02f, 2.34037340e-02f, -1.05908513e-01f, 5.28848097e-02f, 6.34602783e-03f, 9.95880142e-02f, -1.04471505e-01f, 6.82655573e-02f,
  -6.23931475e-02f, -6.19538575e-02f, 1.20857330e-02f, -7.84863979e-02f, 2.60639992e-02f, 2.53974944e-02f, 1.46675035e-02f, -3.67987342e-02f, -4.72575426e-02f, 1.05834372e-01f,
  -5.59326038e-02f, 1.18964747e-01f, 1.43004190e-02f, 7.11132139e-02f, -4.82794158e-02f, -4.31907922e-02f, -1.14867445e-02f, -4.62868437e-02f, 5.51004857e-02f, 5.27475998e-02f,
  1.40184999e-01f, -8.30693468e-02f, -7.31213987e-02f, -6.30943179e-02f, -9.27112550e-02f, 1.82460725e-01f, -4.85866591e-02f, -5.59277385e-02f, 9.42807496e-02f, -3.90053689e-02f,
  4.81976420e-02f, 6.26670048e-02f, 1.69478968e-01f, 1.66329429e-01f, -1.83338031e-01f, 5.64453937e-02f, 9.95297953e-02f, 2.17656627e-01f, -2.92804874e-02f, -9.89474729e-02f,
  5.80698550e-02f, 5.09110466e-02f, -3.86273190e-02f, -8.80695879e-02f, 1.61045089e-01f, 9.79775190e-02f, 6.10516518e-02f, -1.90988228e-01f, 9.29684490e-02f, 1.59591641e-02f,
  -1.63322911e-01f, -1.93822563e-01f, -1.65803432e-02f, -2.44173743e-02f, -5.28374203e-02f, -1.84288081e-02f, -3.33156250e-02f, -7.57849589e-02f, -7.52725115e-04f, 1.09714359e-01f,
  -1.47669495e-03f, 1.09102309e-01f, -1.24426208e-01f, -1.49178788e-01f, 2.42974348e-02f, -1.86975077e-02f, 1.04183100e-01f, -2.32568989e-03f, 7.07795769e-02f, -1.52844451e-02f,
  6.35007620e-02f, 8.65291432e-02f, -5.31468242e-02f, 4.49157432e-02f, 3.15622985e-02f, 1.92134120e-02f, -1.44262522e-01f, -6.33938164e-02f, -1.03370391e-01f, 8.61740205e-03f,
  5.73784858e-03f, 3.51275504e-02f, -4.34889682e-02f, 3.97347733e-02f, -6.94164336e-02f, 5.36813634e-03f, 4.89655994e-02f, 6.42132014e-02f, 5.64803891e-02f, -1.68388132e-02f,
  -3.35389897e-02f, -5.09165600e-03f, -9.95923672e-03f, 8.45620409e-02f, 6.98031262e-02f, 1.05618145e-02f, -1.25659248e-02f, -5.49664721e-02f, -4.68748026e-02f, 5.39664589e-02f,
  7.72211403e-02f, -9.82085168e-02f, 3.17994431e-02f, 1.52241010e-02f, 7.48856813e-02f, 9.31697190e-02f, -4.05155160e-02f, 3.88010591e-02f, 6.60213605e-02f, 5.08185290e-02f,
  -8.16832557e-02f, -8.80863890e-02f, -1.95707213e-02f, -4.21834886e-02f, -9.68934149e-02f, -3.00495755e-02f, 9.50518250e-02f, -3.23157646e-02f, 6.15422353e-02f, 4.85500172e-02f,
  -6.25430346e-02f, -7.12669566e-02f, 7.47252479e-02f, 3.55399475e-02f, 5.91392815e-02f, 3.61681990e-02f, -5.21541387e-02f, 3.72822285e-02f, -7.36620948e-02f, -7.02244714e-02f,
  1.92422047e-02f, 7.87080824e-02f, 9.04389620e-02f, 5.25616333e-02f, 2.78430395e-02f, 1.91067718e-02f, 2.36944947e-02f, -2.62119621e-02f, 7.06875697e-02f, 6.53414987e-03f,
  -1.91385429e-02f, 1.87580734e-02f, 1.68625638e-01f, 2.23159194e-01f, -9.16374195e-03f, -1.27750874e-01f, -6.48102239e-02f, -6.38396442e-02f, 5.76334745e-02f, 4.86967042e-02f,
  -1.02957994e-01f, 8.95160958e-02f, -6.75925836e-02f, 4.19508405e-02f, 1.39530703e-01f, 3.15851234e-02f, 4.23498079e-02f, 1.44906882e-02f, -5.98756187e-02f, 3.97460535e-02f,
  1.98281199e-01f, -2.75677852e-02f, -3.01533230e-02f, 4.15011086e-02f, -1.65747434e-01f, 5.29810134e-03f, -3.56438980e-02f, 1.35221630e-01f, -5.03273569e-02f, -8.48492905e-02f,
  1.58913210e-02f, 1.59918875e-01f, -1.27489701e-01f, -5.39584421e-02f, 9.21624079e-02f, 3.16777490e-02f, 1.19591644e-02f, 1.03712119e-01f, -9.22754481e-02f, -6.16662623e-03f,
  1.17306404e-01f, -1.40566051e-01f, 1.16679505e-01f, -1.12798102e-01f, 5.73416837e-02f, 1.62028283e-01f, 1.09663764e-02f, 6.33756891e-02f, -3.80236134e-02f, 4.34209779e-02f,
  6.52755946e-02f, 9.25524831e-02f, 2.59452481e-02f, -7.36000389e-02f, 3.16259861e-02f, -3.77110429e-02f, 4.07250673e-02f, -8.04023370e-02f, 5.82014732e-02f, 3.43369655e-02f,
  -6.52111992e-02f, 8.00578520e-02f, 2.46791728e-02f, 7.47694299e-02f, 8.81861225e-02f, 4.89093661e-02f, 8.27124119e-02f, 1.22975502e-02f, -4.14692387e-02f, 2.41788756e-03f,
  -8.90618488e-02f, 9.53147933e-03f, -1.87409036e-02f, -1.20802857e-02f, -4.98894826e-02f, 1.63733568e-02f, 1.33986203e-02f, 5.52216209e-02f, 7.14744553e-02f, 4.83819507e-02f,
  8.14188644e-02f, -3.58873606e-02f, -7.13205338e-02f, 8.08764845e-02f, -5.33724576e-02f, -1.06458366e-01f, 2.99427286e-02f, 4.65540551e-02f, -3.63145806e-02f, 1.49371866e-02f,
  -9.71653759e-02f, -2.09771693e-02f, 1.63836647e-02f, 1.86150465e-02f, 1.43252322e-02f, 8.75827298e-02f, -1.26286313e-01f, -9.23361555e-02f, 4.18988168e-02f, 7.60583431e-02f,
  -6.30452484e-02f, -4.56199422e-02f, -1.01395421e-01f, -1.55741610e-02f, 3.74865755e-02f, 6.47147670e-02f, 4.48822379e-02f, 6.51166290e-02f, -3.99652719e-02f, -3.71700116e-02f,
  7.21958876e-02f, -2.44060922e-02f, 6.43232390e-02f, -4.08446230e-02f, -8.21651667e-02f, -6.41033053e-02f, 7.57231116e-02f, 5.66261169e-03f, -1.64977267e-01f, 8.87266695e-02f,
  5.24858758e-02f, 4.44150232e-02f, -1.60136782e-02f, 4.80941031e-03f, 6.06278069e-02f, 2.42226012e-02f, -6.04474097e-02f, -7.77713582e-02f, -7.21362084e-02f, -6.33660406e-02f,
  3.66620421e-02f, 1.34156510e-01f, -9.35684294e-02f, -1.28863052e-01f, -2.50483193e-02f, -9.20429602e-02f, 6.52772933e-03f, -8.83600637e-02f, 5.57745360e-02f, -7.98458755e-02f,
  -7.52538741e-02f, -3.95330153e-02f, 1.70683172e-02f, 7.81951845e-02f, 2.85827573e-02f, 6.56135455e-02f, -1.02058552e-01f, 6.26211762e-02f, 1.49823636e-01f, -9.06037465e-02f,
  -1.89095605e-02f, -1.51890159e-01f, 3.12697440e-02f, 4.19795960e-02f, 1.35573596e-01f, -2.08825916e-02f, -6.93687424e-02f, -2.20641680e-02f, 7.60885924e-02f, 8.32592603e-03f,
  1.69954989e-02f, 1.28785660e-02f, 1.03040278e-01f, 9.72039029e-02f, 6.89137429e-02f, 1.53414696e-01f, -7.87982643e-02f, -3.14917509e-03f, 1.54458791e-01f, -3.44176916e-03f,
  7.87457675e-02f, -3.71606126e-02f, 3.85895669e-02f, 1.98043063e-01f, -1.45323172e-01f, -9.57674086e-02f, -7.09526241e-02f, -8.19732323e-02f, -1.70978494e-02f, -3.04941013e-02f,
  -1.17410133e-02f, 6.90104142e-02f, 3.29287164e-02f, 8.39717090e-02f, -5.91330081e-02f, -6.32867916e-03f, -6.10298030e-02f, -1.80786476e-02f, 3.26277167e-02f, 4.66669761e-02f,
  8.82903188e-02f, -1.54707218e-02f, 8.85720104e-02f, 1.28169149e-01f, -6.60243109e-02f, 3.96544859e-02f, 5.88246547e-02f, -7.50880390e-02f, 8.52708519e-02f, -6.30508065e-02f,
  -3.45594399e-02f, 1.28553003e-01f, -7.75421783e-03f, 7.79694617e-02f, -7.90629089e-02f, -9.62363183e-02f, 6.47466704e-02f, -8.30277056e-03f, 5.77316210e-02f, 6.32660463e-03f,
  -5.54163419e-02f, -1.19947895e-01f, 8.26364309e-02f, -7.25766569e-02f, 4.35877219e-03f, -3.82402614e-02f, -7.42620155e-02f, 3.51334698e-02f, -1.05064057e-01f, -2.92181559e-02f,
  -8.65907967e-02f, -1.32938931e-02f, 4.50369790e-02f, 2.62918212e-02f, -6.65480793e-02f, 2.14537159e-02f, -1.00175679e-01f, 6.65426999e-02f, -1.35453846e-02f, -5.05843237e-02f,
  -1.10576518e-01f, 3.83826792e-02f, -7.05292150e-02f, 5.34840301e-02f, 3.39808199e-03f, -9.13677085e-03f, 1.56541336e-02f, 3.09997308e-03f, 4.82483208e-02f, 3.09102125e-02f,
  9.28949378e-03f, -1.00843132e-01f, -2.80395932e-02f, -6.18815161e-02f, -2.27327514e-02f, -6.83102310e-02f, -1.28861979e-01f, -1.02798752e-02f, -1.13384373e-01f, 9.55201015e-02f,
  5.39038666e-02f, 2.51593511e-03f, -9.65993330e-02f, 7.29561690e-03f, -3.87726240e-02f, 7.34041445e-04f, -8.88079777e-02f, -5.64876609e-02f, -4.96285334e-02f, -1.12682417e-01f,
  1.48206905e-01f, -2.75417324e-02f, -5.44574708e-02f, 3.68403550e-03f, -7.95038864e-02f, 4.50971909e-02f, 1.93378761e-01f, 7.59338867e-03f, -6.43135533e-02f, -3.13871466e-02f,
  1.08427003e-01f, 7.89029226e-02f, -2.12159418e-02f, 1.32464608e-02f, -4.71536368e-02f, -7.49226958e-02f, -1.16162412e-01f, -8.43029097e-02f, 5.16729988e-03f, -1.36164337e-01f,
  -1.05865158e-01f, -1.15895137e-01f, 3.65310013e-02f, 7.75005147e-02f, 2.66787526e-03f, -9.30130109e-02f, 2.31277216e-02f, -4.17316481e-02f, 7.38028856e-03f, -9.20308456e-02f,
  3.08052008e-03f, 1.05949096e-01f, 3.13198492e-02f, 1.87051177e-01f, 1.32426247e-01f, 5.21131791e-02f, -5.21192104e-02f, 1.72031388e-01f, 5.31739183e-02f, -6.93575367e-02f,
  1.16221696e-01f, 1.83275148e-01f, 9.82661620e-02f, -3.00759561e-02f, -6.27356544e-02f, 5.99141419e-02f, -5.61039895e-02f, -1.54486805e-01f, 5.70720583e-02f, 8.43902007e-02f,
  2.95268316e-02f, -1.07750744e-02f, -1.24753090e-02f, 3.57917398e-02f, -2.55023548e-03f, -4.71464209e-02f, 1.09722190e-01f, -6.13320693e-02f, -4.91686501e-02f, -7.70974532e-02f,
  1.27563268e-01f, 8.35576653e-02f, 5.19721806e-02f, -8.27414449e-03f, 5.50480969e-02f, -7.56727085e-02f, 1.61715709e-02f, -2.76989155e-02f, 7.34986439e-02f, 6.74167499e-02f,
  -6.38161227e-02f, 1.03526123e-01f, 1.48239089e-02f, 3.24308164e-02f, -9.10261124e-02f, -3.24501190e-03f, 1.83459182e-04f, 3.02059557e-02f, 8.15867931e-02f, -1.18753180e-01f,
  -4.85945167e-03f, -7.08312839e-02f, 8.45387131e-02f, -3.60305756e-02f, 4.19136323e-02f, 1.11666322e-01f, 5.83428852e-02f, -4.73229066e-02f, -9.99287069e-02f, 7.97219351e-02f,
  9.33594033e-02f, -7.06690103e-02f, 8.22886527e-02f, -4.61908318e-02f, -4.91616912e-02f, 9.62514430e-02f, 3.48438732e-02f, 3.85878384e-02f, -5.78189418e-02f, -6.92061055e-03f,
  -1.07474990e-01f, -5.86173125e-02f, -5.67911044e-02f, -5.28316870e-02f, -2.60348618e-02f, 4.46335450e-02f, -3.93654183e-02f, -9.33943987e-02f, -5.30446880e-02f, 1.12004653e-02f,
  1.08428173e-01f, 9.55832526e-02f, 7.36961812e-02f, -1.46577759e-02f, 1.04528569e-01f, -9.78337526e-02f, -7.58076012e-02f, 4.51982282e-02f, 4.12579104e-02f, -4.90819253e-02f,
  2.10128184e-02f, -6.88460022e-02f, -5.50018549e-02f, -6.05463609e-02f, -5.26245795e-02f, -2.73245983e-02f, -8.28735232e-02f, -1.97876006e-01f, 1.73152283e-01f, 4.98810709e-02f,
  -6.92214593e-02f, 1.93410907e-02f, -5.58090135e-02f, -5.75923249e-02f, 5.87527566e-02f, -1.44185930e-01f, -1.16981007e-02f, -1.28565818e-01f, -1.60927266e-01f, -9.71665457e-02f,
  -2.73342449e-02f, 1.07986808e-01f, 3.49007733e-02f, -5.86231314e-02f, -1.28985763e-01f, -6.82462156e-02f, -7.27111623e-02f, 5.57123236e-02f, 8.91926000e-04f, -1.63228154e-01f,
  5.04369959e-02f, -1.51090994e-01f, -6.73012361e-02f, 4.74422611e-02f, -7.14082569e-02f, -7.48566240e-02f, 3.72695103e-02f, -1.84179470e-02f, -1.26641467e-01f, 7.60666654e-02f,
  -8.65834951e-02f, 1.75232291e-02f, 1.50775030e-01f, 4.64740396e-02f, -6.32029474e-02f, 6.63260743e-02f, -1.14888422e-01f, -2.98956893e-02f, 6.59352308e-03f, -4.57596406e-02f,
  -1.20523926e-02f, -9.13823321e-02f, 4.56748437e-03f, -9.39549431e-02f, -1.11218534e-01f, -1.36624053e-01f, 5.64970896e-02f, 1.03070680e-02f, 3.66245583e-02f, -1.07081383e-01f,
  -4.82045673e-02f, 5.04994579e-02f, -1.62831042e-02f, -4.28143218e-02f, -2.33391579e-03f, -5.79447933e-02f, -9.51229595e-03f, -3.81858535e-02f, -8.40765461e-02f, -6.99087679e-02f,
  2.73678433e-02f, -3.95646393e-02f, -4.57821116e-02f, 3.08724754e-02f, 2.38664206e-02f, -3.67328674e-02f, 8.11760351e-02f, -2.35656258e-02f, -2.61538778e-03f, 1.19955331e-01f,
  3.17197032e-02f, 2.39589605e-02f, -8.99321213e-02f, -6.00751750e-02f, 4.17422317e-02f, 5.06152138e-02f, -5.53481653e-02f, -1.08994640e-01f, -4.33520451e-02f, -8.13870952e-02f,
  -5.05145751e-02f, 8.62683952e-02f, 1.06196381e-01f, -2.82782614e-02f, -7.81186000e-02f, -3.99695486e-02f, 8.07507187e-02f, -8.33643228e-03f, -6.88633844e-02f, -9.44797602e-03f,
  8.08228105e-02f, -3.34194563e-02f, 1.62708052e-02f, -6.53663501e-02f, -9.24604665e-03f, 3.78862433e-02f, 9.99078676e-02f, 5.25422134e-02f, -8.80555063e-02f, 5.44674285e-02f,
  -1.14158608e-01f, -6.02112524e-02f, 8.56697559e-02f, 7.53318742e-02f, 5.26838340e-02f, -8.38882569e-03f, 5.84596507e-02f, 8.50054249e-02f, -2.91339885e-02f, 6.04598299e-02f,
  1.27440944e-01f, -1.39562562e-02f, 1.04246758e-01f, -6.94695339e-02f, -1.58789642e-02f, 1.11136965e-01f, -5.45632988e-02f, -2.55087968e-02f, 4.40514609e-02f, 7.76693448e-02f,
  3.34870145e-02f, -7.26912618e-02f, 9.18851048e-02f, -7.62554631e-02f, 7.49377310e-02f, -4.79057692e-02f, 1.03667758e-01f, 4.99983989e-02f, 1.73928705e-03f, 1.02528833e-01f,
  -3.86548601e-02f, 3.60441022e-02f, -5.69064133e-02f, -1.43083364e-01f, 1.12162501e-01f, -1.45080388e-01f, -1.35192767e-01f, -1.21306330e-02f, -1.12155430e-01f, -3.24164554e-02f,
  -7.00374767e-02f, 4.04643901e-02f, -8.31863061e-02f, -6.69574291e-02f, 1.09990790e-01f, 6.35518208e-02f, -3.42183113e-02f, -2.30770886e-01f, -4.14142758e-02f, -5.54218553e-02f,
  2.64690183e-02f, 9.82332155e-02f, 2.42287647e-02f, -5.98673411e-02f, -1.32370204e-01f, -4.86212932e-02f, -1.13736890e-01f, 5.20976223e-02f, 2.85788788e-03f, -9.09183547e-02f,
  2.22281832e-02f, -4.50485060e-03f, -9.29075666e-03f, 5.41638024e-02f, 5.85038774e-02f, -1.07764103e-01f, -5.68058006e-02f, -2.48911064e-02f, -4.49607000e-02f, -8.30348954e-02f,
  2.37571318e-02f, -2.04920843e-02f, 6.19949810e-02f, -1.13438457e-01f, 5.16095459e-02f, -6.30823746e-02f, -1.68316085e-02f, 4.80051711e-02f, -9.23951194e-02f, 5.95239783e-03f,
  -9.56823528e-02f, -8.95826295e-02f, -1.15842700e-01f, -5.48861921e-02f, 2.18135249e-02f, 1.18530234e-02f, 1.84795931e-02f, -1.16323777e-01f, 9.77633446e-02f, 1.19949922e-01f,
  -9.72985178e-02f, -6.20002672e-02f, 3.51256244e-02f, -4.10098918e-02f, 4.51562516e-02f, 1.62668042e-02f, 7.56503865e-02f, -1.03933148e-01f, -1.12888426e-01f, 6.84711197e-03f,
  5.80329709e-02f, -1.07900640e-02f, -1.78964045e-02f, -8.11077803e-02f, 2.78304368e-02f, -1.82671193e-02f, -7.68831819e-02f, 2.82107759e-03f, -8.33564624e-02f, 1.62140597e-02f,
  -7.76608661e-03f, -9.91333649e-02f, 1.38413087e-01f, -4.14350219e-02f, -9.75596346e-03f, -5.51537471e-03f, -1.38168503e-02f, -2.69573312e-02f, -2.94240005e-02f, -3.67818289e-02f,
  -3.31185088e-02f, 8.55893269e-02f, 8.18776153e-03f, -2.04117019e-02f, 9.29100439e-03f, -4.06396613e-02f, -9.82474387e-02f, -3.00140120e-02f, 5.51597960e-02f, 2.54880264e-02f,
  -9.46954191e-02f, 4.63431105e-02f, 3.77492309e-02f, -8.03463608e-02f, -4.17746510e-03f, -1.23240240e-01f, -5.72520196e-02f, -7.46633038e-02f, 5.01529388e-02f, -1.02748148e-01f,
  -1.28675073e-01f, -7.65080899e-02f, 4.63020429e-02f, 2.41336096e-02f, -1.26207117e-02f, 8.47444832e-02f, -2.27570683e-02f, -7.43498951e-02f, -9.43954140e-02f, -3.60625274e-02f,
  -1.92473441e-01f, -3.04260701e-02f, -1.29279718e-01f, -9.22591835e-02f, 1.55084565e-01f, 1.41792133e-01f, 9.95649472e-02f, -1.34299934e-01f, 1.94505826e-02f, -1.35999635e-01f,
  -3.54882888e-02f, -3.00704800e-02f, 7.59518668e-02f, -2.83569973e-02f, -1.21671580e-01f, -1.29126579e-01f, -3.86914276e-02f, 1.64522201e-01f, 5.91830909e-02f, -1.03058748e-01f,
  -1.45007715e-01f, 6.42799512e-02f, 2.84806173e-02f, -1.50665835e-01f, 1.17841117e-01f, -2.48445813e-02f, -1.09780073e-01f, -1.16452165e-01f, -5.74111613e-03f, 2.00854577e-02f,
  -8.98134187e-02f, -2.44056016e-01f, 8.20282325e-02f, -2.01056734e-01f, -8.13844502e-02f, -8.54148492e-02f, 2.28330567e-02f, -1.92107051e-03f, -1.86047908e-02f, 1.41742423e-01f,
  -1.12704374e-01f, 1.38539180e-01f, -1.56158343e-01f, 8.03115517e-02f, -5.17948233e-02f, -3.38844508e-02f, -8.32100399e-03f, -9.40589979e-02f, -1.98754057e-01f, -1.07483137e-02f,
  -1.23114072e-01f, -4.37016860e-02f, -1.22464463e-01f, 8.46535806e-03f, -7.50572905e-02f, -8.30890238e-02f, 4.45707592e-05f, 1.27868444e-01f, 4.96736504e-02f, 8.32341835e-02f,
  7.72855431e-02f, 6.47449493e-03f, 1.80361923e-02f, -1.63154807e-02f, -4.86175083e-02f, 4.32685614e-02f, 5.26572242e-02f, -9.17161778e-02f, -1.95359793e-02f, 2.61053909e-03f,
  7.29253283e-03f, -5.74835623e-03f, 6.70066327e-02f, -2.38606706e-03f, 8.70933197e-03f, 1.07805796e-01f, -7.88327157e-02f, -9.77341011e-02f, -3.99322100e-02f, 6.09333278e-04f,
  -8.29155818e-02f, 3.81888002e-02f, 7.06482232e-02f, -1.26036599e-01f, -9.01576877e-02f, -7.57942274e-02f, -1.96889844e-02f, -7.65478387e-02f, 1.02850804e-02f, 2.88516674e-02f,
  1.17222808e-01f, -7.39444718e-02f, -8.02784935e-02f, -5.15089603e-03f, 3.17916386e-02f, -8.77954066e-02f, -6.54638931e-02f, -2.21445765e-02f, -2.83407737e-02f, 1.02393858e-01f,
  -5.64043261e-02f, -8.84101540e-02f, 8.00700933e-02f, -6.49369732e-02f, -8.03483054e-02f, 1.67964194e-02f, 5.07536046e-02f, -8.87543485e-02f, -4.80400287e-02f, 5.85074462e-02f,
  -1.43386573e-02f, 3.52505520e-02f, 5.10353856e-02f, 2.19465736e-02f, 9.95331928e-02f, -9.13666654e-03f, 4.79930155e-02f, -2.47180555e-02f, 1.04052406e-02f, -6.27889335e-02f,
  -1.67741198e-02f, -9.19811130e-02f, -5.58483079e-02f, 7.93997478e-03f, -9.30764973e-02f, -4.43406738e-02f, 2.25035455e-02f, -9.99483690e-02f, -1.23621956e-01f, 3.06622358e-03f,
  -1.68383211e-01f, -6.26587346e-02f, 6.93650097e-02f, -1.46359135e-03f, 1.89276174e-01f, 1.10146850e-02f, 3.48335505e-02f, -3.85590643e-02f, 8.05051550e-02f, 2.96560605e-03f,
  1.39269173e-01f, -1.43574148e-01f, -8.84827673e-02f, -1.78994432e-01f, -1.32185265e-01f, 2.98266653e-02f, -2.33273301e-02f, -6.90233558e-02f, -1.20125778e-01f, 1.18931951e-02f,
  -6.73087612e-02f, -4.20589596e-02f, 4.43796404e-02f, -7.34578967e-02f, -1.57438651e-01f, -6.29203618e-02f, -1.04408357e-02f, 1.13312781e-01f, -1.12784974e-01f, -6.99767247e-02f,
  1.12724893e-01f, 1.95608218e-03f, -1.45284519e-01f, 8.60824659e-02f, 3.01500000e-02f, -8.04063771e-03f, 1.01544000e-01f, 1.47674799e-01f, -7.88241252e-02f, 2.02795789e-01f,
  -2.53959578e-02f, 1.81964278e-01f, -3.59085090e-02f, -3.41969430e-02f, -5.78243732e-02f, 3.36074196e-02f, -5.30772805e-02f, 5.32036275e-02f, -9.80281159e-02f, 1.67879388e-02f,
  -6.23342255e-03f, 6.99571148e-02f, 1.56064257e-02f, 3.71395722e-02f, 1.12442389e-01f, -3.46626528e-02f, 3.29895839e-02f, 7.30790868e-02f, 5.48852421e-02f, 9.34675038e-02f,
  -1.36826588e-02f, -5.08172400e-02f, 5.08877225e-02f, 7.33874214e-04f, -5.55560067e-02f, -7.94091001e-02f, -4.11132835e-02f, 5.48478030e-02f, 8.76517594e-02f, 6.10516630e-02f,
  7.15440065e-02f, 2.49384972e-03f, 1.61069818e-03f, -2.51780059e-02f, -5.12124859e-02f, 2.07837410e-02f, 7.23771676e-02f, 1.25452578e-01f, 6.80691600e-02f, 7.25478455e-02f,
  3.39443833e-02f, 4.66880901e-03f, -8.89706835e-02f, -8.45568404e-02f, 3.05098724e-02f, -6.45403564e-02f, 4.41619568e-02f, -3.07189934e-02f, 1.46404311e-01f, 4.18922566e-02f,
  -2.76220217e-02f, -1.59914163e-03f, 9.17640552e-02f, -6.18142933e-02f, 3.78306061e-02f, 6.81106299e-02f, 3.68450172e-02f, 3.29638235e-02f, 5.86181171e-02f, 2.52411887e-02f,
  4.07741331e-02f, 1.08099893e-01f, 6.52152821e-02f, 4.76315059e-03f, 2.35792971e-03f, -5.77105284e-02f, 9.16269571e-02f, 7.53871426e-02f, -9.56408959e-03f, 7.53138289e-02f,
  3.94945070e-02f, 7.48277977e-02f, 1.44109741e-01f, 7.26947039e-02f, 5.51186204e-02f, 6.50356859e-02f, -6.12228438e-02f, -2.47420929e-03f, 7.50816688e-02f, -6.27967566e-02f,
  2.05363594e-02f, 6.95182085e-02f, 3.93844023e-03f, -3.77564691e-02f, 6.83118775e-02f, 9.33126882e-02f, 5.17791249e-02f, -1.65642411e-01f, -4.47479673e-02f, -9.95687470e-02f,
  -5.75486012e-02f, 5.10818623e-02f, 4.14503105e-02f, -1.40607685e-01f, -9.37174559e-02f, 1.59288328e-02f, 1.13712549e-02f, -9.11776349e-02f, 1.05769493e-01f, 5.51195927e-02f,
  -2.16359615e-01f, 9.19081420e-02f, -1.30336300e-01f, 6.90326914e-02f, -8.43404382e-02f, -1.01220377e-01f, -1.58638179e-01f, -4.78999652e-02f, -1.87435094e-02f, -6.06514886e-02f,
  -6.09265491e-02f, -2.05211695e-02f, -1.11520693e-01f, 9.55707394e-03f, 1.23190500e-01f, 4.46815565e-02f, 2.18534693e-02f, 1.37719452e-01f, -9.34929028e-02f, 3.42662521e-02f,
  -1.49604306e-01f, 7.81264082e-02f, -1.56507790e-01f, -8.83874893e-02f, 7.40546361e-03f, 1.13251388e-01f, -1.07821189e-01f, 1.38701707e-01f, 1.04159057e-01f, 2.84411162e-02f,
  -6.25553355e-02f, 2.72058882e-02f, 1.08652851e-02f, -1.99174106e-01f, -1.19415037e-02f, -1.85275167e-01f, -5.25565855e-02f, 7.46033639e-02f, 5.29625602e-02f, -1.00542508e-01f,
  -1.20760120e-01f, 2.58331522e-02f, -2.79015005e-02f, 8.54067281e-02f, 1.73378352e-03f, -2.41576582e-02f, -2.34467145e-02f, 1.18524268e-01f, -9.75533947e-03f, -1.77584458e-02f,
  -5.86012471e-03f, 4.59484160e-02f, 6.21857420e-02f, -7.63821695e-03f, -6.47431985e-02f, -5.04061505e-02f, 3.79454195e-02f, 4.40324135e-02f, 3.95305343e-02f, 1.02390535e-01f,
  5.91335110e-02f, 6.90664351e-03f, 6.27627596e-03f, 4.56362218e-02f, -7.68312514e-02f, -3.56735364e-02f, 6.79011568e-02f, -2.15655398e-02f, 1.46831498e-02f, 8.70867446e-03f,
  6.60776049e-02f, -6.13128468e-02f, 6.88456073e-02f, -6.53678626e-02f, -4.79216650e-02f, 7.77191296e-03f, 7.99561441e-02f, -3.17353830e-02f, -4.19365242e-02f, -2.39776243e-02f,
  -2.21240092e-02f, -4.32058610e-02f, -1.16662972e-01f, -4.71080132e-02f, 4.54928391e-02f, 5.33649400e-02f, 8.44643265e-02f, -8.27824101e-02f, 4.24242280e-02f, -1.30195105e-02f,
  2.96427142e-02f, 1.69907715e-02f, 2.04615146e-02f, -3.51387411e-02f, -7.27436766e-02f, 8.38507190e-02f, 9.40103009e-02f, -6.20965958e-02f, 4.80299722e-03f, 2.98307813e-03f,
  1.34268999e-01f, 6.79296777e-02f, 8.97707865e-02f, -2.68620010e-02f, -1.11037202e-01f, -1.53645845e-02f, 6.48958981e-02f, 4.41608690e-02f, 1.69331618e-02f, 2.48896610e-02f,
  -8.45899507e-02f, 1.74445678e-02f, -9.90870502e-03f, 7.13720918e-02f, -1.45445570e-01f, -1.78649157e-01f, -1.41915381e-01f, -1.22927427e-01f, 1.01786681e-01f, 6.79248869e-02f,
  2.39505339e-03f, -1.94765359e-01f, 4.68079224e-02f, -1.27092555e-01f, 3.28527428e-02f, -1.46067545e-01f, 1.32857189e-01f, -1.31121546e-01f, -1.87235817e-01f, -5.97695298e-02f,
  -8.01030640e-03f, 1.34847596e-01f, -2.49130633e-02f, -8.06599408e-02f, -4.45480756e-02f, -5.73983267e-02f, 6.07842319e-02f, -1.19730122e-01f, -7.16907904e-02f, -9.61184874e-02f,
  -1.11690030e-01f, -2.00886410e-02f, 1.00904964e-01f, 3.22088562e-02f, 3.88366766e-02f, 3.77322137e-02f, 4.13976014e-02f, -3.56269367e-02f, -1.26963720e-01f, 1.14455469e-01f,
  -1.04252994e-01f, -3.89402509e-02f, 1.57523394e-01f, 5.86776808e-02f, -1.42646832e-02f, 2.23507300e-01f, -7.88283348e-02f, 8.24332759e-02f, 8.17742720e-02f, 5.64437732e-02f,
  8.40904489e-02f, -1.36134177e-01f, -1.22553229e-01f, 3.22262749e-05f, -7.86857959e-03f, 1.66214234e-03f, -2.20616739e-02f, -2.31701154e-02f, -6.64040819e-02f, 5.06200418e-02f,
  -1.91241615e-02f, -1.90487392e-02f, 1.12543413e-02f, 5.40893264e-02f, -3.84048149e-02f, 1.28964260e-01f, -4.77597266e-02f, 1.52493576e-02f, -5.59285916e-02f, 3.09824757e-02f,
  -6.49149790e-02f, 5.96279725e-02f, -1.21421758e-02f, -1.11700453e-01f, 4.03457470e-02f, -8.63518938e-02f, -3.26028019e-02f, 4.05042954e-02f, -6.41050562e-02f, -1.04710467e-01f,
  -9.25758034e-02f, 8.14862084e-03f, 2.53220554e-02f, 3.49063128e-02f, 7.07503268e-03f, -9.04078037e-02f, -3.87423597e-02f, 3.33845019e-02f, 1.37632291e-04f, 2.83162687e-02f,
  -4.32909243e-02f, 1.35682896e-02f, 5.71194384e-03f, 3.62947658e-02f, 1.14336655e-01f, -6.10889420e-02f, 2.74416544e-02f, -8.71148929e-02f, 8.32493976e-02f, 5.46815917e-02f,
  -1.30954802e-01f, -9.29107144e-02f, 3.17669623e-02f, 3.27026360e-02f, -1.50754809e-01f, 1.68341231e-02f, 1.22263446e-01f, 2.93872855e-03f, -2.57996209e-02f, -2.85982178e-03f,
  3.96509543e-02f, 4.87259552e-02f, 6.49140924e-02f, 2.75286771e-02f, 6.61960104e-03f, 5.64912818e-02f, 3.50082070e-02f, 9.71420482e-02f, 6.22193106e-02f, -1.21479280e-01f,
  -1.46370092e-02f, -3.78090180e-02f, -9.97430682e-02f, -1.70684736e-02f, -8.47588331e-02f, -1.12910755e-02f, -1.48766011e-01f, 3.81139852e-02f, -1.82113387e-02f, 3.64900008e-02f,
  -8.16046596e-02f, 6.49267137e-02f, -8.22453722e-02f, 3.17551233e-02f, -1.06860988e-01f, -2.11899906e-01f, 3.15051153e-02f, 2.02953249e-01f, 9.80576500e-02f, -8.13985765e-02f,
  -1.13911301e-01f, -4.77579609e-02f, 6.85829520e-02f, -5.68625657e-03f, 1.58472225e-01f, 2.99997013e-02f, -2.61441469e-01f, 4.71488051e-02f, -1.60680816e-01f, -5.24299778e-02f,
  -7.05241859e-02f, -7.13286176e-02f, -1.66045234e-01f, -1.42178282e-01f, 9.40658711e-03f, 1.09223112e-01f, 3.82340327e-02f, -5.91050610e-02f, -1.70783296e-01f, -8.94272979e-03f,
  -5.56422807e-02f, -6.08039601e-03f, -4.77836169e-02f, -7.03177974e-02f, -1.00233093e-01f, -7.79570416e-02f, -6.36310279e-02f, 1.37694374e-01f, -1.61704496e-01f, -1.35311976e-01f,
  -7.13229403e-02f, 2.50377432e-02f, -2.21332908e-02f, 1.33782476e-01f, 9.71043203e-03f, 8.62610862e-02f, 5.69518879e-02f, -4.73940186e-03f, 4.63347323e-03f, -8.99363607e-02f,
  5.42617328e-02f, -1.65464431e-01f, 7.93265030e-02f, -2.06378307e-02f, 4.50404081e-03f, 3.56145087e-04f, -6.79088384e-02f, -6.90310895e-02f, 1.14518113e-03f, -1.62650123e-02f,
  -2.48041581e-02f, -9.47520286e-02f, 4.43419255e-02f, 1.38036415e-01f, 3.27106342e-02f, -1.11366082e-02f, -5.13349883e-02f, -4.68963608e-02f, 4.84459698e-02f, 1.00909173e-01f,
  -5.89835420e-02f, 8.29480886e-02f, 7.33487457e-02f, 1.08556159e-01f, 5.78281097e-02f, 1.25065371e-01f, -8.00564066e-02f, -1.29875764e-01f, -4.56051808e-03f, 2.77773906e-02f,
  5.17726466e-02f, -7.66228586e-02f, -1.43082645e-02f, 8.25446621e-02f, 2.93604899e-02f, -7.60154873e-02f, 8.90132412e-02f, 1.90684535e-02f, -2.54894607e-02f, 9.73248258e-02f,
  1.17153663e-03f, 1.05095476e-01f, -1.90484188e-02f, 8.78128856e-02f, 5.71258776e-02f, 3.89669091e-02f, -2.53658220e-02f, 2.66522989e-02f, -1.38061738e-03f, 5.30928969e-02f,
  -4.13301997e-02f, 3.15590724e-02f, 1.44731347e-02f, -4.20808382e-02f, -4.31284569e-02f, 5.10604978e-02f, -4.22506258e-02f, 1.74760837e-02f, 9.44466889e-02f, 8.66588503e-02f,
  5.51738776e-02f, 7.31209293e-02f, -5.01142479e-02f, -4.53615114e-02f, -7.36184567e-02f, -7.06117004e-02f, 5.70594100e-03f, 8.41517374e-02f, -4.76344228e-02f, -7.12042972e-02f,
  -3.72918993e-02f, 5.09067960e-02f, 5.53131327e-02f, 6.88834935e-02f, 7.06390217e-02f, 5.78757226e-02f, -2.82683428e-02f, -2.54210904e-02f, -7.70989954e-02f, -1.88795421e-02f,
  -5.17887529e-03f, 3.41848582e-02f, -6.03572233e-03f, -1.19718634e-01f, 1.73588976e-01f, -4.55770381e-02f, 7.75528625e-02f, -1.87461544e-02f, 2.02160031e-02f, 4.09618989e-02f,
  8.76955837e-02f, -4.24851924e-02f, 1.05533645e-01f, -1.37875825e-01f, 5.19974343e-02f, 1.42219448e-02f, 1.51100466e-02f, -1.33679463e-02f, -1.14702195e-01f, -1.00880973e-01f,
  -1.66899581e-02f, -7.39057958e-02f, 1.31883949e-01f, 6.69391267e-03f, -1.17159802e-02f, -9.61476639e-02f, -3.16697694e-02f, 1.09035766e-03f, 2.77250651e-02f, 3.13396826e-02f,
  -2.21137311e-02f, -1.16396137e-01f, -2.37540659e-02f, -3.33027355e-02f, -1.82844177e-02f, 3.89802717e-02f, -8.18617418e-02f, 4.08273153e-02f, 9.86846238e-02f, 1.44041941e-01f,
  2.41354536e-02f, 1.50013104e-01f, 5.24772564e-03f, -6.36179699e-03f, 6.68308288e-02f, -8.10221285e-02f, -6.37407824e-02f, -1.45837497e-02f, 4.87273596e-02f, 6.07467219e-02f,
  -3.97646651e-02f, -5.46546951e-02f, 5.38418768e-03f, -4.40738574e-02f, -4.99363504e-02f, 8.73765051e-02f, 2.30910797e-02f, -6.17033020e-02f, -6.35724701e-03f, -3.38482857e-02f,
  3.67280431e-02f, 8.35389048e-02f, -8.59702006e-02f, 3.22348289e-02f, 2.36845412e-03f, 6.25777394e-02f, 4.86955196e-02f, 9.63189676e-02f, 8.93479586e-03f, -4.47327569e-02f,
  2.14024466e-02f, -9.60682705e-02f, -1.04642492e-02f, 2.56245583e-02f, 4.08322252e-02f, -8.61581191e-02f, 4.84877788e-02f, 2.93991677e-02f, 7.94593245e-02f, -8.69576037e-02f,
  4.61356416e-02f, 4.57351357e-02f, -6.60392717e-02f, 4.58408296e-02f, 3.56077924e-02f, -1.14586920e-01f, -6.75705224e-02f, 2.98286639e-02f, 1.47017166e-02f, 3.36171314e-02f,
  -6.50656819e-02f, -9.15755853e-02f, -4.41048779e-02f, -3.28695476e-02f, -6.90530241e-02f, 5.78431189e-02f, 3.97177525e-02f, -8.89369920e-02f, 5.03752977e-02f, 1.84527207e-02f,
  8.30427557e-02f, 1.14295296e-01f, -2.90889777e-02f, -2.46711764e-02f, -2.42136810e-02f, 8.95217136e-02f, -8.32147803e-03f, 1.86408889e-02f, -5.01816720e-02f, 5.88147044e-02f,
  -8.47746711e-03f, 2.11053826e-02f, -7.18802446e-03f, -1.18706763e-01f, 6.13848008e-02f, -5.85740171e-02f, -7.63711631e-02f, -3.11555166e-04f, -1.40713781e-01f, 5.38466834e-02f,
  2.38677580e-02f, 1.30721950e-03f, 9.20908451e-02f, -6.47548214e-02f, -2.63772532e-03f, 8.01855233e-03f, -9.75776687e-02f, -3.62413866e-03f, -1.19153127e-01f, -5.84584586e-02f,
  5.59309945e-02f, 2.63023991e-02f, 1.10886477e-01f, -9.64898765e-02f, 7.64615759e-02f, -3.51310484e-02f, -7.25391805e-02f, -2.48554703e-02f, 4.74363416e-02f, 7.67334132e-03f,
  -2.31959790e-01f, -7.52470940e-02f, 2.09075868e-01f, 5.06112128e-02f, -3.74410674e-02f, 4.53101397e-02f, -6.04799390e-03f, -2.58574653e-02f, 1.51268467e-02f, 9.69170332e-02f,
  -9.99843255e-02f, -1.93105742e-01f, -2.32681204e-02f, 9.71233398e-02f, 7.01418445e-02f, 1.46040479e-02f, -2.72063166e-02f, -5.03556803e-02f, 3.91087011e-02f, -1.36014730e-01f,
  -1.01181671e-01f, -1.09816685e-01f, 1.01068601e-01f, -6.79344311e-02f, 1.17766462e-01f, 1.78506061e-01f, -3.39164622e-02f, -3.07542644e-02f, 1.40160304e-02f, -5.98505810e-02f,
  3.33691724e-02f, -7.97551498e-02f, 1.22164354e-01f, 1.00188218e-01f, 1.77216269e-02f, -8.50877240e-02f, 2.14059148e-02f, 9.81575325e-02f, -6.70327842e-02f, -1.30251676e-01f,
  6.87559769e-02f, 4.84895520e-03f, 8.58683288e-02f, 5.61437123e-02f, 2.29654312e-02f, -4.13171351e-02f, -5.85959218e-02f, -1.50963496e-02f, 2.42397580e-02f, -1.05473157e-02f,
  -1.04402319e-01f, -7.23716170e-02f, -8.00804142e-03f, 1.54762700e-01f, -1.44176679e-02f, 3.50296684e-02f, 7.47097060e-02f, -2.20603850e-02f, 6.61786795e-02f, 2.56853155e-03f,
  3.32388617e-02f, -2.84750164e-02f, 6.15857393e-02f, 5.89626096e-02f, -3.41598094e-02f, 2.45263819e-02f, 1.36722261e-02f, -5.98381385e-02f, -6.78886995e-02f, -1.82689354e-03f,
  -4.80712503e-02f, 8.86811092e-02f, 3.05946283e-02f, -2.48014424e-02f, -2.21269708e-02f, 7.09229857e-02f, -2.64823940e-02f, -4.36657034e-02f, -3.35969776e-02f, -1.47407334e-02f,
  5.94249777e-02f, 4.28880602e-02f, -4.09701504e-02f, 1.41155785e-02f, -4.14327607e-02f, -5.13118990e-02f, -9.82469544e-02f, -5.64709399e-03f, -3.63790989e-02f, -1.86773874e-02f,
  -6.86492100e-02f, -9.44663584e-03f, 8.18608999e-02f, 2.87011708e-03f, -1.79613121e-02f, 6.70469999e-02f, 5.60498722e-02f, -9.78916213e-02f, 8.67411196e-02f, 2.13686284e-02f,
  6.75555915e-02f, -2.94272043e-02f, -1.27574159e-02f, -5.32925362e-03f, 1.16085829e-02f, -9.26062018e-02f, 7.77294189e-02f, 8.32947530e-03f, 3.83213423e-02f, 5.10907732e-02f,
  3.79337370e-03f, -7.56948590e-02f, 6.63539246e-02f, -5.24011292e-02f, -2.07923427e-02f, -9.04818475e-02f, 1.30589143e-03f, -1.68732315e-01f, 1.60492882e-01f, 1.21906109e-01f,
  1.08795650e-01f, 9.04268995e-02f, -2.19310358e-01f, 4.04151529e-02f, -4.64779623e-02f, 1.28826424e-01f, -6.84147999e-02f, 5.91260605e-02f, -2.71622948e-02f, -4.34072092e-02f,
  1.01330467e-01f, 1.20860912e-01f, 6.77319095e-02f, 2.96969805e-02f, -1.37244284e-01f, 9.32509378e-02f, 6.08619824e-02f, -2.13018730e-01f, 1.11992948e-01f, 1.25901461e-01f,
  -2.22050488e-01f, -2.01600447e-01f, -9.48666632e-02f, 1.26840353e-01f, -1.15363806e-01f, -1.71803068e-02f, -7.63100162e-02f, -2.70305425e-02f, 1.98692578e-04f, -6.65283129e-02f,
  3.96860652e-02f, 6.30909577e-02f, -9.67771560e-02f, -3.51631418e-02f, 1.94033445e-03f, 6.66963831e-02f, 1.27191767e-02f, -2.28231438e-02f, 1.58625469e-02f, -1.03668325e-01f,
  7.65881315e-02f, 2.76534669e-02f, -1.34840757e-01f, -3.09035461e-02f, -1.95683129e-02f, -1.24142393e-02f, 1.73365086e-01f, 1.23789549e-01f, -2.24189437e-03f, -1.19269565e-01f,
  -9.94829908e-02f, -6.10154448e-03f, -2.42301803e-02f, 7.96927586e-02f, -9.80445519e-02f, -6.46970421e-02f, 6.90102056e-02f, 9.59856957e-02f, -6.76368251e-02f, -1.69342589e-02f,
  -3.02558877e-02f, 1.42860394e-02f, 8.04794207e-02f, -1.71906147e-02f, -7.94554576e-02f, -4.58267629e-02f, -1.30656332e-01f, 8.49055499e-02f, 4.24972512e-02f, -2.73592100e-02f,
  1.00252122e-01f, 7.28798732e-02f, -1.36817008e-01f, 1.16134128e-02f, 1.84250567e-02f, -8.54028016e-02f, -5.32573042e-03f, -1.01734966e-01f, -3.17063741e-02f, -5.94094209e-02f,
  -3.53547148e-02f, -6.39285296e-02f, -2.14070622e-02f, -2.07750816e-02f, -1.76880590e-03f, 8.86879861e-02f, 3.21616121e-02f, -3.42462249e-02f, 5.06401248e-02f, -9.34556648e-02f,
  6.83181584e-02f, 5.55013269e-02f, 6.76629469e-02f, -1.22252237e-02f, -1.44817578e-02f, -1.18883206e-02f, -4.74049225e-02f, -7.70667521e-03f, 1.42590227e-02f, 5.94406910e-02f,
  3.84279788e-02f, -7.16809705e-02f, -1.10983416e-01f, 6.17106147e-02f, 4.49555218e-02f, 3.94670144e-02f, 1.56256522e-03f, -3.44835892e-02f, -1.84892432e-03f, 8.78682137e-02f,
  -3.13128456e-02f, 7.45161846e-02f, 7.41919503e-02f, -1.00938575e-02f, 2.40672845e-02f, -6.93315715e-02f, 1.65954120e-02f, -5.42301089e-02f, -7.11625535e-03f, 1.99653078e-02f,
  5.40810078e-02f, 1.00947045e-01f, -2.95674913e-02f, 3.42274792e-02f, 1.78578757e-02f, 1.56187434e-02f, -1.91604286e-01f, -4.94028404e-02f, -1.33309336e-02f, 4.76907901e-02f,
  1.76276803e-01f, 4.75356095e-02f, -1.00624688e-01f, -1.90234352e-02f, 3.99917290e-02f, -1.36832982e-01f, 3.11601106e-02f, 7.44570196e-02f, -1.07360564e-01f, -1.29697025e-01f,
  3.62058245e-02f, -8.82609859e-02f, 1.49004221e-01f, -1.20196499e-01f, -5.12646846e-02f, 7.21799731e-02f, -1.62083194e-01f, 2.10516658e-02f, 1.28436700e-01f, 9.03831273e-02f,
  -3.70667167e-02f, -1.50546283e-01f, 1.45107135e-01f, 1.25328034e-01f, 5.70109449e-02f, -2.73121335e-02f, -3.39167453e-02f, 8.70917886e-02f, -6.35440126e-02f, -1.01101003e-03f,
  -5.01868725e-02f, 2.17956200e-04f, -4.64052036e-02f, -1.11785762e-01f, -1.03320748e-01f, -1.35176890e-02f, -7.34956488e-02f, 4.56644073e-02f, -8.31750557e-02f, -4.76160049e-02f,
  9.45462584e-02f, -5.67873344e-02f, -8.96518677e-03f, -1.40244633e-01f, -1.05892077e-01f, -1.44244984e-01f, 5.55476062e-02f, 4.03534286e-02f, -1.41745368e-02f, -6.47593215e-02f,
  -6.36893557e-03f, -4.44099233e-02f, 6.29998520e-02f, -2.86245048e-02f, -6.83123842e-02f, 4.48140502e-02f, 2.80355196e-02f, -2.02535931e-02f, -1.05183542e-01f, 4.81321663e-03f,
  -8.88366550e-02f, -8.70861039e-02f, 7.73335397e-02f, 2.68677995e-02f, -1.10420203e-02f, -1.82915735e-03f, 8.33888575e-02f, 5.94320660e-03f, -8.79530311e-02f, -2.01754048e-02f,
  1.12580560e-01f, -8.44055414e-02f, 5.18068932e-02f, 4.38515805e-02f, 5.52483723e-02f, 8.39134753e-02f, -8.22300836e-02f, 4.82309945e-02f, -7.08441436e-02f, 6.02211282e-02f,
  -3.21602933e-02f, -3.03045604e-02f, 2.57192906e-02f, 7.87609220e-02f, -7.34590366e-02f, 2.86965482e-02f, 3.55775058e-02f, -9.96459424e-02f, 1.76892094e-02f, 3.62568088e-02f,
  8.77311081e-03f, -4.98580635e-02f, 2.16931943e-03f, 4.25856784e-02f, -5.76010793e-02f, -1.59874354e-02f, -6.87976088e-03f, -8.76469389e-02f, -7.04982355e-02f, -2.92545408e-02f,
  7.52029940e-02f, 2.46652588e-02f, -1.26433343e-01f, 7.07613230e-02f, -3.25857550e-02f, -7.66173154e-02f, 2.48034503e-02f, 4.20243153e-03f, 6.97605759e-02f, -8.10066834e-02f,
  1.30638108e-02f, -1.74632967e-02f, -5.41543937e-04f, -1.73541810e-02f, 9.23605338e-02f, -5.42066395e-02f, 6.73458502e-02f, -3.01503409e-02f, -6.31486550e-02f, -1.06682694e-02f,
  7.83827528e-02f, -9.74926259e-03f, -1.19550396e-02f, 6.14705496e-02f, -3.29602212e-02f, -7.35273585e-02f, -1.25070676e-01f, -1.30224392e-01f, -4.33963425e-02f, -1.21956747e-02f,
  -1.24153912e-01f, -5.11712804e-02f, 1.63295209e-01f, -1.61552727e-01f, -7.80443773e-02f, 2.18003970e-02f, 6.31980821e-02f, 5.42256460e-02f, 2.33702809e-02f, 4.36657667e-02f,
  4.45831604e-02f, -1.47924751e-01f, 8.59878957e-03f, 1.02232717e-01f, -1.47925556e-01f, -1.89870328e-01f, 2.97909360e-02f, 4.47333679e-02f, 8.92500430e-02f, 7.09080473e-02f,
  1.35924324e-01f, -8.69214460e-02f, 1.46885008e-01f, 1.89637557e-01f, -5.66575415e-02f, 1.94092125e-01f, -4.73404862e-02f, 8.25664401e-02f, 6.03538379e-02f, 1.57744229e-01f,
  9.02600586e-02f, -1.41101796e-02f, 5.37428334e-02f, 1.25209652e-02f, 3.42026502e-02f, -1.69469342e-02f, 7.77817145e-02f, 5.18285930e-02f, 8.01315159e-02f, -1.36198848e-01f,
  1.08195692e-01f, -1.15317836e-01f, 2.62807664e-02f, 6.28990605e-02f, 7.39110261e-02f, 7.59555250e-02f, 8.13491940e-02f, -5.10772392e-02f, 3.21691707e-02f, -1.23968825e-01f,
  2.23950925e-03f, -1.67370606e-02f, -4.67596538e-02f, -6.79068491e-02f, -8.59152749e-02f, 2.42231172e-02f, 1.64240301e-02f, 6.34756126e-03f, -4.21489440e-02f, 6.56580850e-02f,
  -4.33206372e-02f, 2.03670543e-02f, 4.49925773e-02f, -1.01219803e-01f, 2.15225434e-03f, 8.68895873e-02f, -1.30119443e-01f, -8.78983177e-03f, 8.05482790e-02f, -7.27372095e-02f,
  -6.88439682e-02f, 4.35927361e-02f, 4.05770577e-02f, -8.13386664e-02f, 2.57119362e-04f, 7.01464638e-02f, 4.34692241e-02f, 1.46391373e-02f, -7.56602455e-03f, 3.94203849e-02f,
  -3.28280516e-02f, -3.26314159e-02f, 5.38730882e-02f, -5.67874461e-02f, 7.93195590e-02f, -1.80143174e-02f, -5.98278530e-02f, 4.63491958e-03f, -4.87906076e-02f, -5.98230846e-02f,
  2.20829248e-02f, -1.84027478e-02f, 3.63025144e-02f, 9.71816597e-04f, 1.99455768e-02f, -6.59980476e-02f, -4.89237485e-03f, -5.52007444e-02f, 1.12669845e-03f, -4.39908952e-02f,
  -1.08762132e-02f, -6.72545210e-02f, -1.96767319e-02f, -6.63565695e-02f, 7.50178425e-03f, -6.93663135e-02f, 6.58085123e-02f, 2.16785539e-03f, -9.12607089e-02f, -1.93518377e-03f,
  -9.86698940e-02f, 1.02705680e-01f, 3.01675778e-02f, -8.95665139e-02f, 5.95465414e-02f, -6.70243800e-02f, -1.15013262e-02f, 5.92705719e-02f, 5.35456836e-02f, 9.74079296e-02f,
  -5.01383990e-02f, -7.49609694e-02f, -1.62637025e-01f, -7.72604793e-02f, -1.57927126e-01f, 5.39733395e-02f, 5.54971844e-02f, -1.27494052e-01f, -4.47742343e-02f, -6.45037815e-02f,
  -1.44682536e-02f, 1.02347722e-02f, 6.90534040e-02f, 1.26253143e-01f, -6.33450523e-02f, 7.95004610e-03f, -1.31676033e-01f, 9.97307301e-02f, 6.16132990e-02f, -1.44416794e-01f,
  -4.10671458e-02f, 1.08861558e-01f, -1.27361342e-01f, -1.08144447e-01f, 8.77566785e-02f, 1.12062924e-01f, -3.61241736e-02f, -1.14822797e-01f, 1.49898976e-01f, 6.16332479e-02f,
  1.06508583e-02f, -8.23228955e-02f, 5.32628857e-02f, 7.72410706e-02f, -4.81009996e-03f, 1.30497530e-01f, -1.02141298e-01f, -1.22477904e-01f, -8.12229738e-02f, 2.41858847e-02f,
  -2.50523891e-02f, 9.84259695e-02f, -1.41210016e-02f, 1.41519234e-01f, -1.77798595e-03f, 1.20347822e-02f, 9.94984582e-02f, -6.73508598e-03f, -1.61131874e-01f, -1.24736205e-01f,
  4.90067638e-02f, 1.62001833e-01f, -1.42393792e-02f, -3.15306447e-02f, -3.94974276e-02f, -8.66776630e-02f, 6.66170556e-04f, 1.02023371e-01f, 7.87210017e-02f, -2.66087204e-02f,
  5.74347340e-02f, -1.03117628e-02f, -1.25414915e-02f, -2.18652599e-02f, -2.17113700e-02f, -6.04414083e-02f, -7.16183111e-02f, -9.10378769e-02f, 1.74044706e-02f, -7.23740235e-02f,
  8.25406536e-02f, -2.18900070e-02f, -4.59884014e-03f, 1.24848612e-01f, -8.17078073e-03f, 4.37260494e-02f, -4.23121676e-02f, -6.25371262e-02f, 3.25560011e-02f, 6.95290416e-02f,
  -2.75468603e-02f, 6.55836910e-02f, -2.97140609e-03f, 6.74950751e-03f, -3.69432680e-02f, -6.00457657e-03f, 2.87208636e-03f, 1.03615783e-01f, 3.03471945e-02f, -2.20428128e-02f,
  -7.84236193e-02f, -2.54210550e-02f, -4.83464170e-03f, 7.60748982e-02f, 3.20357606e-02f, -2.09686812e-02f, 1.15868542e-02f, 7.51271397e-02f, 3.51672769e-02f, -4.47376408e-02f,
  4.08439077e-02f, 4.65275496e-02f, 2.36363560e-02f, 4.86976467e-02f, -4.80837077e-02f, 8.15404430e-02f, -5.10275625e-02f, -2.83007231e-02f, -2.04567192e-03f, 6.05984889e-02f,
  1.46303261e-02f, 1.13053396e-01f, 2.01806352e-02f, 5.20625822e-02f, -8.14605430e-02f, 4.07041349e-02f, 6.20239526e-02f, 2.37510893e-02f, 1.08284831e-01f, 4.93662506e-02f,
  6.64081350e-02f, 1.10485025e-01f, 1.02477437e-02f, -5.42353801e-02f, -4.53722030e-02f, 8.14460367e-02f, -5.25750220e-02f, -1.99393183e-02f, 1.03759035e-01f, -6.06392883e-02f,
  1.91583857e-01f, 6.14669211e-02f, 4.88498583e-02f, 3.96726020e-02f, -1.15237720e-01f, 1.18615203e-01f, -6.67442977e-02f, 1.84617177e-01f, -5.29527441e-02f, 8.13293010e-02f,
  5.05885445e-02f, -1.41360417e-01f, 1.59800515e-01f, -1.14886895e-01f, 7.61253387e-02f, 6.22400418e-02f, 4.47694324e-02f, 1.65763795e-01f, 5.55630103e-02f, -1.35459095e-01f,
  9.77599770e-02f, -1.39451362e-02f, -1.00621134e-01f, -4.42311428e-02f, 1.10764861e-01f, -1.93359591e-02f, -2.08819613e-01f, 1.31069466e-01f, -6.24608509e-02f, -3.53686772e-02f,
  4.19929624e-02f, -5.34970462e-02f, -2.25243461e-03f, -7.08232298e-02f, 8.23148265e-02f, 5.60187027e-02f, -1.05583787e-01f, 8.51231515e-02f, 7.91538656e-02f, -8.45881253e-02f,
  8.49044099e-02f, -7.15004504e-02f, 4.31262963e-02f, -5.46120331e-02f, -1.67331338e-01f, -1.45042557e-02f, 1.24665223e-01f, 6.37335554e-02f, 1.45889493e-02f, -1.65998191e-02f,
  -5.77468425e-02f, 6.09779619e-02f, 2.81829922e-03f, 4.61027436e-02f, -9.07558277e-02f, -4.95425202e-02f, -1.29870415e-01f, 9.87100787e-03f, -9.34718773e-02f, -8.00686479e-02f,
  -2.71376707e-02f, -6.51029944e-02f, -8.29251707e-02f, -4.88801636e-02f, 6.11962192e-02f, 5.98176047e-02f, 1.33271301e-02f, -2.43310742e-02f, -5.77192679e-02f, -5.97225837e-02f,
  2.89216787e-02f, -8.17210600e-02f, 6.75642639e-02f, 6.70517012e-02f, -4.09507528e-02f, -2.78058928e-02f, 5.13018633e-04f, -9.68348607e-03f, -8.83967653e-02f, 3.63333859e-02f,
  9.61475447e-02f, 7.73559734e-02f, -5.92736751e-02f, 7.77468830e-02f, 2.67475713e-02f, 1.39109101e-02f, -1.06952481e-01f, -1.15654655e-01f, -3.50169316e-02f, -1.68093666e-02f,
  3.72563936e-02f, -6.26068702e-03f, -7.73895904e-02f, -6.71948567e-02f, -5.71296029e-02f, -5.42652048e-02f, -6.80016130e-02f, -1.44890631e-02f, 4.76029143e-02f, 2.45594457e-02f,
  2.46404596e-02f, -7.57158101e-02f, 2.37006452e-02f, 7.28048235e-02f, 2.52136402e-02f, 2.58906409e-02f, -1.13393903e-01f, 5.89561351e-02f, -5.26773483e-02f, -4.69614528e-02f,
  2.39646789e-02f, -1.67215809e-01f, -6.54209927e-02f, 1.24148857e-02f, -7.29767233e-02f, -1.96371693e-02f, -1.13031536e-01f, -6.53079303e-04f, -8.56246576e-02f, -2.23877421e-03f,
  9.34258383e-03f, -4.01140451e-02f, 3.13611180e-02f, -1.10217556e-01f, -8.24672803e-02f, -3.62185668e-03f, -3.72643918e-02f, -1.05180345e-01f, -2.37718988e-02f, 8.46553892e-02f,
  4.45546806e-02f, -1.20659523e-01f, -6.14516288e-02f, -1.48143053e-01f, 1.13070473e-01f, -9.10738707e-02f, -4.46547456e-02f, 1.34515790e-02f, -1.88973770e-01f, 1.70768395e-01f,
  1.03207327e-01f, 1.75052837e-01f, 1.91076174e-01f, -3.35152028e-03f, -7.54788443e-02f, -8.80812556e-02f, 1.31163895e-01f, 2.88468283e-02f, -1.29488871e-01f, -1.56203479e-01f,
  3.98714133e-02f, 1.52908593e-01f, 1.08907275e-01f, 1.46148009e-02f, -3.87041345e-02f, -1.59132168e-01f, 7.72377651e-04f, 4.35456261e-02f, 8.70506540e-02f, -1.35885239e-01f,
  5.89581616e-02f, -7.23421872e-02f, 1.10722706e-01f, 2.71601547e-02f, 9.26078707e-02f, 6.28640428e-02f, 4.23439108e-02f, -3.95830683e-02f, -1.08511895e-01f, -5.25172427e-02f,
  2.89299507e-02f, 1.54764906e-01f, 1.00834947e-02f, 1.03296191e-01f, -3.99632454e-02f, 4.81346026e-02f, 7.67833786e-03f, 4.57077026e-02f, -4.00292985e-02f, 5.17505668e-02f,
  2.62892600e-02f, -4.79828529e-02f, 3.61764506e-02f, -4.72980291e-02f, 4.70645875e-02f, -3.25523764e-02f, 7.45079145e-02f, 4.92682606e-02f, 4.23213653e-02f, -8.31109956e-02f,
  1.18843094e-01f, -3.62213589e-02f, -6.78755939e-02f, -4.16054539e-02f, -2.42661834e-02f, -1.23080956e-02f, 3.75229935e-03f, 5.50014004e-02f, 1.47210434e-03f, -2.05121916e-02f,
  5.96389398e-02f, 1.06949508e-01f, -8.55723955e-03f, 8.77479091e-02f, 2.95245107e-02f, -5.56925684e-02f, -8.47800672e-02f, 1.02308653e-01f, 3.40005793e-02f, -4.18924578e-02f,
  -3.77621762e-02f, -1.01011477e-01f, 3.50314043e-02f, -9.09952000e-02f, -3.09175923e-02f, -9.17379707e-02f, -4.06023627e-03f, -6.55238852e-02f, 6.67891055e-02f, 7.83110037e-02f,
  -4.29428481e-02f, 2.83507034e-02f, 4.99325097e-02f, 2.51738215e-03f, 4.08957265e-02f, 3.40176411e-02f, -3.37010156e-03f, -9.02587548e-02f, -4.27371785e-02f, -4.01501171e-02f,
  9.07899532e-03f, -1.04834815e-03f, 2.39301920e-02f, 7.00237975e-02f, 3.64762098e-02f, 1.58410929e-02f, 6.56544641e-02f, 2.33128713e-03f, 1.73457041e-02f, 1.53659349e-02f,
  3.87725532e-02f, 4.09617424e-02f, 2.41542812e-02f, -5.05900010e-02f, 5.67240901e-02f, -3.49112414e-02f, -9.46280509e-02f, -5.60200289e-02f, 8.01028088e-02f, -2.72053871e-02f,
  4.72859032e-02f, -6.88300431e-02f, 5.78195192e-02f, -5.90509409e-03f, -1.09734163e-02f, -7.35908672e-02f, 1.25952989e-01f, 6.52760193e-02f, 6.29405901e-02f, -1.42582804e-01f,
  -1.17356561e-01f, 5.66088445e-02f, 1.44907326e-01f, -6.64280131e-02f, -9.65374988e-03f, 1.37814879e-01f, -5.99340387e-02f, 3.43253314e-02f, 2.20592827e-01f, 1.31161258e-01f,
  4.73105498e-02f, 5.74772023e-02f, -1.63450632e-02f, 1.17623573e-02f, 1.71751857e-01f, -7.42357746e-02f, 7.59175196e-02f, -8.00538715e-03f, -1.04582667e-01f, -6.83128387e-02f,
  3.82655449e-02f, 1.23517737e-02f, -2.75826659e-02f, -6.24580905e-02f, 2.82561369e-02f, 6.66537210e-02f, -4.51109968e-02f, -1.29528698e-02f, 5.70623353e-02f, -6.99003711e-02f,
  8.73909742e-02f, -1.95700359e-02f, 8.13735351e-02f, 1.15418389e-01f, -6.19856380e-02f, -1.20216005e-01f, -3.86258252e-02f, -9.57276151e-02f, 1.29806146e-01f, 1.80636123e-01f,
  -2.74899527e-02f, 5.28877117e-02f, 3.91856544e-02f, 1.36874825e-01f, -6.53265044e-03f, 2.85016783e-02f, 1.27903307e-02f, -2.54292600e-02f, -3.99840660e-02f, 2.80437879e-02f,
  -6.65525049e-02f, -1.05923876e-01f, 2.74055414e-02f, -2.35003810e-02f, -5.05827107e-02f, -7.70109752e-03f, 2.86417827e-02f, -6.91075549e-02f, 1.11380756e-01f, 3.78290862e-02f,
  8.02737027e-02f, -7.98265412e-02f, 8.67069885e-02f, 5.17351273e-03f, -7.26170512e-03f, -3.32923345e-02f, 4.79073152e-02f, 8.12784210e-03f, 7.97396619e-03f, -5.90258650e-03f,
  -4.97681163e-02f, -7.33736455e-02f, 8.69799219e-03f, 1.84872299e-02f, 4.89901677e-02f, 2.78265215e-02f, 4.25098315e-02f, -1.32115325e-02f, -7.91484788e-02f, -2.10899040e-02f,
  -1.65658202e-02f, -2.42474955e-03f, -6.84099272e-02f, -1.38252854e-01f, -8.37335512e-02f, -5.27508259e-02f, -1.08823339e-02f, -1.66168027e-02f, -3.53810005e-02f, -4.13264111e-02f,
  -6.79636598e-02f, 2.61238273e-02f, -4.65005822e-02f, 3.06951348e-02f, 1.87844075e-02f, -2.95502692e-02f, -1.03086732e-01f, 2.35306360e-02f, 1.09761789e-01f, -6.36062073e-03f,
  -2.79164128e-02f, 1.38697559e-02f, 9.02911425e-02f, -2.37352178e-02f, 9.72407013e-02f, 5.61620519e-02f, 2.73643564e-02f, -2.99063586e-02f, -5.17780781e-02f, -1.43278046e-02f,
  -1.08146183e-02f, -2.17438564e-02f, -1.07516445e-01f, 6.20407313e-02f, 5.00829108e-02f, -5.58706038e-02f, -8.55950639e-03f, -6.02152310e-02f, 3.60375457e-02f, 2.16973517e-02f,
  8.75439048e-02f, -3.57775693e-03f, -5.83631359e-02f, -3.38124186e-02f, 1.22799277e-01f, 1.72800720e-01f, 4.49945033e-02f, -1.07679412e-01f, -9.70266610e-02f, -4.55917567e-02f,
  3.68623994e-02f, 1.05655594e-02f, -8.05833489e-02f, 1.43589750e-01f, -8.32011253e-02f, -3.68488729e-02f, 2.26538077e-01f, -1.24910530e-02f, 9.63790119e-02f, 4.63374285e-03f,
  -2.58492138e-02f, 1.09707460e-01f, 2.17992082e-01f, -1.35134742e-01f, 9.13730487e-02f, -2.74944748e-03f, -1.53115779e-01f, 7.61260986e-02f, 3.75060551e-02f, 4.60456647e-02f,
  -8.56373683e-02f, -2.78636478e-02f, -6.80791587e-02f, 6.62510991e-02f, -5.59615493e-02f, -2.20627654e-02f, 6.82989433e-02f, -8.88959616e-02f, -3.24086584e-02f, 1.00241505e-01f,
  2.46514417e-02f, 8.94582868e-02f, 6.96498975e-02f, -9.16146114e-02f, -7.03085139e-02f, -1.49673205e-02f, 1.22461654e-01f, 1.20729953e-01f, -3.55327874e-02f, 9.24457610e-02f,
  -4.64265794e-02f, 2.15028916e-02f, 1.83841765e-01f, 5.63266948e-02f, 6.78305179e-02f, -5.65160960e-02f, -2.29221284e-02f, 9.52459723e-02f, -3.43597978e-02f, -8.64238217e-02f,
  4.31898050e-02f, 1.14253061e-02f, 3.00588142e-02f, 8.20759758e-02f, 5.17824069e-02f, 2.14152932e-02f, -3.98192108e-02f, -1.87725555e-02f, -8.28235969e-02f, -5.07599339e-02f,
  -1.04791652e-02f, 7.51403049e-02f, -2.15717312e-02f, -7.15679154e-02f, 6.98441640e-02f, 1.42133879e-02f, 1.02301434e-01f, -5.81945404e-02f, -9.46994498e-02f, -4.94649187e-02f,
  5.81241818e-03f, -6.73231250e-03f, 5.05902246e-02f, -1.02345543e-02f, 4.32669371e-02f, -6.14534542e-02f, -9.62181464e-02f, -2.18086895e-02f, 7.19379559e-02f, -2.87093949e-02f,
  1.85054913e-02f, -5.73183335e-02f, 1.16334714e-01f, -2.22371090e-02f, -4.73508351e-02f, 4.89308797e-02f, 6.57409281e-02f, 2.17255410e-02f, 3.84299271e-02f, 3.38468291e-02f,
  -3.77578177e-02f, 1.16444163e-01f, -5.13780005e-02f, 6.32538050e-02f, 1.09265268e-01f, -6.23426549e-02f, 2.63868179e-02f, -2.58918367e-02f, -1.11641154e-01f, -6.23904429e-02f,
  1.02381423e-01f, -7.15322271e-02f, 4.59432639e-02f, -2.43979935e-02f, 3.06971036e-02f, 5.13745956e-02f, -3.01741529e-02f, -4.98312674e-02f, -7.91875124e-02f, -6.09754771e-02f,
  -3.05451080e-02f, 5.00958338e-02f, 4.00776044e-02f, -4.80293334e-02f, 2.32354496e-02f, 5.38322106e-02f, -4.25028689e-02f, 7.11983517e-02f, -1.65017396e-02f, 6.46942034e-02f,
  -1.98945012e-02f, -1.55539632e-01f, -1.31961852e-01f, -1.00589804e-02f, -8.06945041e-02f, 8.17596614e-02f, -1.42583475e-01f, -7.38658234e-02f, -6.15513735e-02f, 2.38323919e-02f,
  -6.30939305e-02f, -1.20619178e-01f, 8.15133974e-02f, 1.30963579e-01f, -1.30116746e-01f, 1.51769191e-01f, -7.07982630e-02f, -9.45369005e-02f, -4.84661795e-02f, -3.24411280e-02f,
  -1.42464470e-02f, -5.48526943e-02f, 9.07342583e-02f, 1.55761585e-01f, -2.96616089e-03f, -4.75639217e-02f, -1.12112492e-01f, 6.55810162e-02f, 1.26941934e-01f, -8.12811553e-02f,
  1.47731528e-01f, 1.60653904e-01f, -6.16482086e-02f, 7.05846027e-02f, -6.22219779e-02f, 1.82851762e-01f, -1.54327586e-01f, -1.83268279e-01f, 8.61876830e-02f, 1.52404504e-02f,
  5.78901777e-03f, -6.80426508e-02f, 1.48216411e-01f, -7.29085505e-02f, 6.05165260e-03f, -2.88262796e-02f, -3.83519661e-03f, -1.74450219e-01f, 1.52895883e-01f, -4.42943498e-02f,
  1.08334675e-01f, 1.72754765e-01f, -9.05410871e-02f, -3.31241116e-02f, 2.29334924e-02f, 6.42490610e-02f, -9.99651942e-03f, 6.00041188e-02f, 9.56506059e-02f, -5.21648079e-02f,
  4.60830666e-02f, 4.51635309e-02f, 4.44508046e-02f, 1.59165841e-02f, 7.37748388e-03f, -1.32233307e-01f, 9.31682810e-02f, 7.94578865e-02f, 6.13220967e-02f, -5.54936100e-03f,
  -3.18262577e-02f, -9.45321843e-03f, 2.61793844e-02f, 6.79024979e-02f, 1.67168658e-02f, -8.43801498e-02f, -6.41924366e-02f, 3.02067716e-02f, 7.82130733e-02f, 6.46280050e-02f,
  -7.66997784e-02f, -2.36850511e-02f, 4.92804162e-02f, -5.25973029e-02f, -8.92048776e-02f, -1.01651117e-01f, -4.29399237e-02f, 5.75011931e-02f, 3.54650989e-02f, -8.73582736e-02f,
  1.44976331e-02f, 3.57758105e-02f, 8.60642195e-02f, -2.19928776e-03f, 7.34212459e-04f, -5.30666970e-02f, -6.20490536e-02f, -1.33321077e-01f, -1.54019147e-02f, 6.34989068e-02f,
  -1.12451822e-01f, -3.05226650e-02f, -3.38312835e-02f, -8.41195136e-02f, 8.23530033e-02f, 1.16593242e-02f, 1.04865007e-01f, 7.72967711e-02f, 5.66813573e-02f, 9.86912698e-02f,
  -7.25466351e-04f, 5.15123159e-02f, -1.45031707e-02f, -1.28135726e-01f, -2.26501208e-02f, -8.34760666e-02f, -2.98480950e-02f, -9.17358696e-02f, -1.06672436e-01f, -6.67409524e-02f,
  -5.42682111e-02f, -5.78325503e-02f, -5.01981638e-02f, -2.91737989e-02f, 4.81497981e-02f, 6.25378937e-02f, 6.81305826e-02f, -3.75078730e-02f, -1.24157064e-01f, 5.12703918e-02f,
  6.60924911e-02f, -5.33184549e-03f, -1.18815891e-01f, 7.23821968e-02f, 1.87988073e-01f, 1.12893477e-01f, -2.08938699e-02f, -5.49343675e-02f, 4.02631387e-02f, 6.10278472e-02f,
  -9.41604152e-02f, -7.46563226e-02f, 1.32826617e-05f, -1.38642535e-01f, -1.58529356e-01f, 1.34234965e-01f, 1.67988464e-02f, -2.68768147e-02f, -4.15375158e-02f, -3.78971407e-03f,
  5.15724719e-02f, -1.54775083e-01f, 2.99982689e-02f, 2.93142861e-04f, -5.21959700e-02f, -4.12641000e-03f, 2.88953888e-03f, -3.17713548e-03f, -3.74879129e-02f, -1.51111379e-01f,
  1.03308804e-01f, 3.54936160e-02f, -8.06646869e-02f, 9.88382287e-03f, 4.11848612e-02f, -1.05531543e-01f, -1.07728675e-01f, -3.66653362e-03f, -4.25641611e-02f, 7.91847557e-02f,
  -3.14315222e-02f, 1.12600952e-01f, 1.44642204e-01f, 8.88338462e-02f, -1.16945907e-01f, -6.65128455e-02f, -1.69088945e-01f, 1.18240798e-02f, 5.76834008e-02f, 1.16622560e-01f,
  4.00389135e-02f, -1.06794965e-02f, -4.34152074e-02f, -6.38633147e-02f, -9.65569839e-02f, 9.76407826e-02f, -5.15662096e-02f, -5.78113310e-02f, -4.86225709e-02f, -4.40671928e-02f,
  8.20594952e-02f, 4.44026366e-02f, -2.06162371e-02f, 1.24284007e-01f, -4.03177962e-02f, -2.49498207e-02f, 8.33992809e-02f, 1.18634075e-01f, 1.48631021e-01f, 9.13872868e-02f,
  -9.67720523e-03f, 8.85892808e-02f, 8.89770687e-02f, 5.96927069e-02f, -9.52703133e-02f, 5.69817759e-02f, -5.42546846e-02f, 9.66848433e-02f, -9.36648343e-03f, 4.44746874e-02f,
  -7.83156790e-03f, -3.68119366e-02f, -9.29625183e-02f, -9.44367424e-03f, -2.59507969e-02f, 1.25585580e-02f, 6.32994622e-02f, 5.50968908e-02f, 1.26615345e-01f, -4.18699645e-02f,
  6.75495528e-03f, -9.51891765e-02f, 2.67791934e-02f, -5.09482585e-02f, -1.01328969e-01f, -3.16884071e-02f, 9.67355669e-02f, 6.66911975e-02f, 4.94477525e-03f, 4.11952697e-02f,
  9.92496833e-02f, -6.78890496e-02f, -2.55696103e-02f, 1.79523584e-02f, 5.28435521e-02f, -4.30861637e-02f, 6.05465472e-02f, -1.02323852e-02f, -7.33248740e-02f, 3.45509662e-03f,
  -1.84985157e-02f, 4.84939665e-02f, 9.66308862e-02f, -3.81630808e-02f, -4.15050983e-02f, 1.40983956e-02f, -5.95593490e-02f, 5.46831116e-02f, 1.08656555e-01f, -6.46678954e-02f,
  -7.85225853e-02f, -7.26244785e-03f, -9.23456103e-02f, -2.57595330e-02f, -6.38392195e-02f, 5.53037487e-02f, 1.50118172e-02f, 1.00567853e-02f, -1.19715050e-01f, 3.31930071e-02f,
  -1.33126095e-01f, 2.21466534e-02f, 1.57658085e-01f, 6.64427876e-02f, -1.65057972e-01f, 2.64439452e-02f, 1.26515850e-01f, -1.21995978e-01f, 2.74888594e-02f, 3.64845395e-02f,
  -1.83275118e-01f, -2.67461203e-02f, -2.31264323e-01f, 4.82706586e-03f, 5.25933616e-02f, -9.77243260e-02f, -1.54196009e-01f, -8.69824961e-02f, -8.15394148e-02f, 2.38147639e-02f,
  -5.73212164e-04f, -6.83949888e-02f, -5.45116588e-02f, 6.75410256e-02f, 1.24398775e-01f, 4.91307080e-02f, 9.75422338e-02f, 8.24374482e-02f, -1.23949252e-01f, 7.33787045e-02f,
  -1.66425630e-02f, 1.76156744e-01f, -1.28871575e-01f, -7.74157941e-02f, -1.20953247e-01f, 6.62052557e-02f, 9.07719508e-02f, 1.30403921e-01f, 1.53133810e-01f, 6.50273934e-02f,
  1.12600446e-01f, -1.61513966e-02f, 2.67431531e-02f, -9.74040404e-02f, -1.00854568e-01f, -6.40322343e-02f, 6.04859330e-02f, 5.98253012e-02f, 3.77107412e-02f, 5.85884005e-02f,
  -3.24330963e-02f, 7.16230497e-02f, 8.85859355e-02f, 2.87015270e-03f, 3.86619754e-02f, -5.08521199e-02f, 9.73695144e-02f, 9.93223637e-02f, 8.58524293e-02f, 8.43988061e-02f,
  5.24442643e-02f, 4.88571590e-03f, 5.00573888e-02f, -1.12586431e-02f, -9.26355347e-02f, -6.67260364e-02f, 5.41335307e-02f, 8.93123448e-02f, 8.27675536e-02f, -1.22776115e-02f,
  4.02607135e-02f, -1.47238284e-01f, 5.44019081e-02f, 2.20167078e-03f, 2.84275636e-02f, 2.35408940e-03f, 6.90317675e-02f, -6.86599240e-02f, -3.82593907e-02f, -2.97710355e-02f,
  -2.97804270e-02f, 3.64784859e-02f, -4.65371497e-02f, -7.60169234e-03f, 1.66451931e-02f, -9.92631242e-02f, -2.28745788e-02f, -2.26774570e-02f, 8.98370817e-02f, 5.94610795e-02f,
  3.34239043e-02f, -4.51862216e-02f, -3.84963788e-02f, -5.85680641e-02f, 1.37995016e-02f, -7.73744658e-02f, 1.20832631e-02f, -1.54963788e-02f, -4.09578122e-02f, 7.35004470e-02f,
  -5.91049530e-03f, 6.25990629e-02f, -6.33066148e-02f, 2.27421150e-02f, 3.77406105e-02f, 4.42738086e-02f, 1.46714728e-02f, 5.03492355e-02f, 4.09015492e-02f, 7.52974302e-02f,
  -1.02470949e-01f, -1.09040719e-02f, -2.02403590e-02f, 3.32291164e-02f, -6.36058860e-03f, 7.59449601e-02f, -4.57291380e-02f, -4.74439822e-02f, -1.02214940e-01f, 6.93935975e-02f,
  -2.22955849e-02f, 9.64781865e-02f, 5.75671121e-02f, 8.58006179e-02f, 1.97575595e-02f, -2.78863427e-03f, -2.76143756e-02f, 1.39666095e-01f, -1.18332364e-01f, 3.02570704e-02f,
  6.27197474e-02f, 1.43677190e-01f, 1.61349133e-01f, -2.78628375e-02f, -1.41616091e-01f, 1.25309080e-01f, 5.42408749e-02f, 5.91682903e-02f, 6.10000566e-02f, -1.09474048e-01f,
  3.19536147e-03f, 1.08530298e-01f, 4.89648283e-02f, 1.90397829e-01f, 1.60711318e-01f, 5.29513247e-02f, 8.27382356e-02f, 1.49794757e-01f, 2.60476805e-02f, 1.53522015e-01f,
  -1.16958074e-01f, -1.82171948e-02f, 2.54590288e-02f, 1.03083588e-01f, -4.14718650e-02f, -1.17756352e-02f, 1.33472010e-01f, 1.50784150e-01f, 8.39932039e-02f, -8.87802541e-02f,
  6.86282888e-02f, -2.45945752e-02f, -1.18209496e-01f, -1.16480678e-01f, -1.38474163e-02f, -1.42509460e-01f, -2.82754451e-02f, 1.38247639e-01f, -2.33421698e-02f, -1.22648254e-01f,
  -6.35719448e-02f, 8.10243413e-02f, -5.95162138e-02f, 3.62509526e-02f, 1.05178177e-01f, 1.29118264e-01f, -7.42286593e-02f, 1.59522127e-02f, 8.31503514e-03f, 6.11250848e-02f,
  -6.76087365e-02f, -7.62686208e-02f, -2.98889587e-03f, 4.99869809e-02f, -3.47165093e-02f, -3.60984653e-02f, 8.04587081e-02f, -4.43728119e-02f, -1.10365473e-01f, 8.13795999e-03f,
  -7.86039978e-02f, -3.98279950e-02f, -6.59985021e-02f, -2.47121826e-02f, -6.10253513e-02f, 1.23663815e-02f, 2.97612790e-02f, -5.98568320e-02f, -2.50977613e-02f, -1.15886800e-01f,
  8.26117992e-02f, -8.67729783e-02f, 8.50315243e-02f, -9.09027383e-02f, -2.34992951e-02f, -5.21590412e-02f, -9.36698020e-02f, 1.61078889e-02f, 4.53576911e-04f, 7.47423247e-02f,
  -6.39988035e-02f, 1.61353312e-02f, 4.28658761e-02f, -1.99823529e-02f, 3.69064622e-02f, -6.98514804e-02f, -2.40591951e-02f, -6.26308890e-03f, -9.94387865e-02f, 5.30965626e-02f,
  5.45497015e-02f, -8.69545564e-02f, 8.78351089e-03f, -8.69273767e-02f, -3.50295343e-02f, 3.73127386e-02f, -9.16220322e-02f, -6.97030947e-02f, -4.37988862e-02f, -8.36969092e-02f,
  1.51288258e-02f, -4.73614521e-02f, 5.64751551e-02f, 2.43761875e-02f, -9.88620073e-02f, 1.90917011e-02f, -7.85440058e-02f, -5.29780127e-02f, -5.79170063e-02f, -8.90014023e-02f,
  -2.59155990e-03f, -1.00330580e-02f, 4.46667634e-02f, 5.12969866e-03f, 6.45763651e-02f, -4.05601598e-02f, -1.10580638e-01f, -2.26598606e-02f, 3.34785134e-02f, -8.46271291e-02f,
  4.88985069e-02f, -2.06803996e-02f, -4.02112044e-02f, 1.23754673e-01f, 5.12564369e-02f, 5.62342517e-02f, -8.92535746e-02f, -2.42877658e-02f, 8.37266371e-02f, 2.97985692e-02f,
  8.95058140e-02f, -3.25975753e-02f, 2.92941276e-02f, 7.07569197e-02f, -1.81116790e-01f, 1.06275864e-01f, 8.73550326e-02f, -3.31417136e-02f, 9.23134908e-02f, -6.60016239e-02f,
  -3.13947834e-02f, 1.02155820e-01f, 4.73257862e-02f, 1.08274825e-01f, -7.53983855e-02f, -3.58479843e-02f, 1.29278779e-01f, 1.46865085e-01f, 5.89088537e-02f, 1.98339503e-02f,
  6.51912317e-02f, 2.31555849e-02f, 4.98510338e-02f, -9.82811749e-02f, 1.46444708e-01f, 1.02885135e-01f, 1.16215594e-01f, -1.81249395e-01f, 1.37225464e-01f, 4.91190068e-02f,
  -7.01301843e-02f, -6.00298233e-02f, 8.26328620e-02f, -1.35759979e-01f, -7.72020072e-02f, 8.06581229e-02f, 4.30485047e-02f, -1.05662242e-01f, -8.14151317e-02f, 1.22451462e-01f,
  4.92265634e-02f, 1.11667596e-01f, 1.52157722e-02f, 3.92825454e-02f, 3.46846916e-02f, 6.58976212e-02f, -2.11492945e-02f, 6.25965819e-02f, 9.30667669e-02f, -5.69410920e-02f,
  2.31909077e-03f, 7.10893050e-02f, -3.55512509e-03f, -1.03065342e-01f, -5.05385362e-02f, -7.98007771e-02f, 2.50478908e-02f, -2.23261137e-02f, -1.35241553e-01f, 4.33533899e-02f,
  -6.57168776e-02f, 6.11563697e-02f, -9.30428579e-02f, 1.15705542e-01f, -1.33486884e-03f, 2.64459103e-03f, 3.06527205e-02f, 4.63836826e-03f, -5.01031987e-02f, 6.46562204e-02f,
  7.34725781e-03f, -1.31619409e-01f, 6.94438517e-02f, 1.07112624e-01f, 7.46151060e-02f, 5.09659499e-02f, 1.83530636e-02f, -5.57520688e-02f, -7.25886896e-02f, 1.13384258e-02f,
  -5.36739565e-02f, 2.03161389e-02f, -7.33005777e-02f, 2.21671583e-03f, -3.22387405e-02f, 5.88002056e-02f, 1.15263811e-03f, 9.82206538e-02f, 2.74486970e-02f, 4.32944186e-02f,
  -9.08048917e-03f, -9.32623893e-02f, 5.38574569e-02f, 5.26036657e-02f, 6.51125163e-02f, -2.50825752e-02f, -3.62813137e-02f, -1.11444786e-01f, -1.82115529e-02f, 3.28581110e-02f,
  -1.24816664e-01f, 9.49746668e-02f, 1.15263224e-01f, 1.44193918e-02f, -4.25343290e-02f, -8.22556764e-02f, -7.51776993e-02f, 5.17492294e-02f, 6.37120977e-02f, 7.09070126e-03f,
  -6.40769303e-02f, 6.27065524e-02f, 1.83297750e-02f, -4.37930832e-03f, 4.81821895e-02f, -1.19229130e-01f, 7.50998929e-02f, -7.68452436e-02f, -4.56902310e-02f, -4.77827303e-02f,
  -3.63255590e-02f, 1.09925739e-01f, 2.40427554e-02f, 3.79403345e-02f, 2.34076977e-02f, -1.90290928e-01f, 1.98100641e-01f, 1.63743407e-01f, 1.08881101e-01f, -5.01633808e-02f,
  -2.81123184e-02f, 8.23535994e-02f, -1.99357390e-01f, -1.21882744e-01f, 7.41376802e-02f, -9.46974531e-02f, -9.69913080e-02f, 1.43616229e-01f, 5.11044897e-02f, 2.65523121e-02f,
  -3.95381637e-02f, 1.29213676e-01f, 3.03285532e-02f, -1.89444840e-01f, 6.26063794e-02f, 1.99745707e-02f, 1.68011323e-01f, -1.10569581e-01f, 1.88670177e-02f, 1.01625368e-01f,
  -1.04827046e-01f, -1.11341760e-01f, -1.96170323e-02f, -1.00907385e-02f, 1.36352360e-01f, 1.10076871e-02f, 2.21397564e-01f, 1.39298975e-01f, -1.40413746e-01f, -7.38168955e-02f,
  -2.57057510e-02f, 3.05181220e-02f, -6.18294626e-02f, 4.58019264e-02f, 1.23791181e-01f, 2.86353007e-03f, -1.33219212e-01f, 1.25072971e-01f, 8.74769129e-03f, 1.49696425e-01f,
  2.80562174e-02f, -1.04805417e-01f, 5.09879040e-03f, -8.66386853e-03f, 6.95983395e-02f, 9.49874520e-02f, -4.47448865e-02f, -1.04625501e-01f, 3.27244624e-02f, 6.06948324e-02f,
  6.94625005e-02f, -9.80107933e-02f, 4.13706265e-02f, -1.10082002e-02f, -7.83778429e-02f, 5.99450171e-02f, 4.26697806e-02f, -7.94104708e-04f, 4.38150484e-03f, 1.01869954e-02f,
  -4.32183780e-02f, -8.59008133e-02f, -6.89573064e-02f, 2.34024264e-02f, 1.80558953e-02f, 1.87946726e-02f, 6.65669516e-02f, -1.95747544e-03f, 7.89680257e-02f, 1.31773753e-02f,
  5.05043231e-02f, 4.78847809e-02f, 2.81733070e-02f, 2.61747409e-02f, 8.91052410e-02f, -8.73544142e-02f, -6.31954297e-02f, 2.09453125e-02f, -1.26586467e-01f, 6.76072836e-02f,
  -9.58738253e-02f, -4.33528461e-02f, 4.27904837e-02f, -1.13519356e-01f, -2.53435019e-02f, 2.67777499e-02f, 5.65520907e-03f, -5.95679432e-02f, 7.59156197e-02f, 1.81119423e-02f,
  5.63471504e-02f, 1.07935183e-01f, 8.51648599e-02f, 2.14205515e-02f, 5.06523512e-02f, -1.15108378e-01f, 1.07662994e-02f, -2.17530243e-02f, -7.00610280e-02f, -4.79852036e-03f,
  3.36438194e-02f, -5.47671504e-02f, -5.52705675e-02f, -1.97875407e-02f, -5.63957617e-02f, -4.10895385e-02f, -3.14052589e-02f, 6.29842281e-02f, 8.52757879e-03f, 7.23250676e-03f,
  1.73015464e-02f, -1.67348247e-03f, 8.26918185e-02f, 5.08095212e-02f, 3.63210100e-04f, 2.78572198e-02f, 1.21657820e-02f, 1.40346074e-02f, 1.16240745e-03f, 1.01054311e-02f,
  -1.04639709e-01f, -3.26297246e-02f, 6.37449790e-03f, -1.38995185e-01f, 1.99938029e-01f, 2.06977352e-02f, 2.15319544e-02f, -1.15345247e-01f, 1.30781248e-01f, -7.28561822e-03f,
  -9.96401384e-02f, 1.69402640e-02f, -2.57353839e-02f, -1.20942056e-01f, -1.14475831e-01f, 2.96624135e-02f, 1.80403590e-02f, -3.62663753e-02f, 8.21637064e-02f, 1.58408850e-01f,
  -2.20570803e-01f, -7.54377171e-02f, 1.29943177e-01f, 1.48088649e-01f, 1.29496828e-01f, -7.42650330e-02f, 8.35052654e-02f, -4.85756435e-02f, 9.67784077e-02f, -9.32562575e-02f,
  -1.07790930e-02f, 6.74417242e-02f, -1.86861176e-02f, -3.45382057e-02f, 9.41389650e-02f, 1.43235698e-01f, -9.88556519e-02f, -1.18232556e-01f, 7.20814914e-02f, -6.42179772e-02f,
  9.35249031e-03f, 3.40071134e-02f, -3.76645289e-02f, 6.61650896e-02f, 5.49048651e-03f, -9.35984850e-02f, -1.04874775e-01f, -9.19195563e-02f, -1.67236403e-01f, -9.09713283e-02f,
  -3.30846175e-04f, -2.84849927e-02f, 9.63518545e-02f, 5.55587709e-02f, 3.21325846e-02f, -1.14263266e-01f, 3.71803120e-02f, 9.13964584e-02f, 2.01724656e-02f, -6.69884980e-02f,
  2.28884462e-02f, 5.67449443e-02f, 2.65644770e-02f, 9.44050401e-02f, 5.43808527e-02f, -1.35977399e-02f, -4.05401108e-04f, -3.59337032e-02f, 6.05968852e-03f, -2.21833754e-02f,
  -5.17148338e-02f, 6.50289878e-02f, -2.70974897e-02f, 9.66038108e-02f, 1.17180012e-01f, 3.67509797e-02f, -3.58070955e-02f, -9.63446274e-02f, 6.34474494e-03f, -6.12629466e-02f,
  5.70059307e-02f, -5.21757267e-02f, -1.21663315e-02f, 7.27497637e-02f, -8.23025405e-03f, -8.65891762e-03f, -2.97208484e-02f, 1.38017833e-02f, 1.13680810e-01f, 4.22503725e-02f,
  -1.26923174e-02f, 1.22483924e-01f, -3.45898420e-02f, 8.95486027e-02f, 5.91644347e-02f, 6.37279451e-02f, -7.25609660e-02f, 7.69711882e-02f, -8.14028829e-02f, -7.70181790e-02f,
  9.01597515e-02f, -7.59491548e-02f, 5.29516079e-02f, -3.64123844e-02f, 6.17808476e-03f, 5.62760457e-02f, -8.70702192e-02f, -4.60439585e-02f, 2.96538863e-02f, 1.17170513e-01f,
  9.76868346e-02f, -3.77425067e-02f, 9.68551487e-02f, 1.09163575e-01f, 8.75008777e-02f, 6.57096133e-02f, 8.98902342e-02f, -3.97071987e-02f, 1.27642632e-01f, 1.01368465e-01f,
  4.28522043e-02f, 2.48383218e-03f, 2.75226645e-02f, 4.68638405e-04f, 5.12877330e-02f, -1.01640865e-01f, -8.48163068e-02f, 4.77753505e-02f, 9.42160860e-02f, -1.08064957e-01f,
  1.44737557e-01f, 6.90864474e-02f, 6.41829446e-02f, 2.99220271e-02f, 1.50612714e-02f, 1.30685538e-01f, 4.12590131e-02f, 8.83157551e-02f, 3.72510552e-02f, -2.34263122e-01f,
  1.18884623e-01f, -1.87090158e-01f, -1.42170042e-01f, 1.67295128e-01f, 6.42206380e-03f, -5.44218812e-03f, -2.06104577e-01f, -1.12483129e-01f, 1.99723959e-01f, 3.47870402e-02f,
  1.88141018e-02f, -1.03633463e-01f, -1.24695033e-01f, 1.47379665e-02f, -7.57219419e-02f, 6.28369302e-02f, -1.80829868e-01f, -4.49592918e-02f, -7.07474127e-02f, -1.13058366e-01f,
  1.41971027e-02f, 6.02595620e-02f, -2.13403311e-02f, -4.20653969e-02f, -9.47269201e-02f, 1.60061106e-01f, 5.50399870e-02f, 5.06730080e-02f, 1.23389348e-01f, 8.78104046e-02f,
  -7.40668178e-02f, 3.46745783e-03f, -9.12526995e-02f, -1.18092103e-02f, 1.15338359e-02f, 8.34729224e-02f, 4.25882405e-03f, 2.49968488e-02f, -9.40576643e-02f, -7.19282329e-02f,
  -3.89593020e-02f, -1.01509631e-01f, 7.99613446e-02f, 7.53649622e-02f, 2.22972371e-02f, -6.00390844e-02f, -1.01417862e-01f, 5.96028753e-03f, -4.68801856e-02f, 8.99489224e-02f,
  2.07532607e-02f, 8.64583254e-03f, -9.32594016e-03f, -3.89344362e-03f, 7.02949837e-02f, 1.24957189e-01f, 6.74358159e-02f, 7.59046227e-02f, 6.78725541e-02f, -7.39891827e-02f,
  -5.81781976e-02f, 7.73679540e-02f, -6.78739697e-02f, 4.22055274e-02f, -7.38270348e-03f, 9.11364406e-02f, 5.16685937e-03f, 5.64659648e-02f, 2.01801881e-02f, -6.73302412e-02f,
  7.31882751e-02f, -6.43566921e-02f, 1.01658009e-01f, -4.53587249e-02f, -6.42745495e-02f, 4.97459471e-02f, 1.18798636e-01f, -1.91612467e-02f, -1.20149612e-01f, 2.66403165e-02f,
  1.00927837e-02f, 1.04314856e-01f, 3.67422178e-02f, -1.15442246e-01f, 7.88259208e-02f, 4.49826121e-02f, 2.46133953e-02f, -1.04323681e-02f, -5.79636693e-02f, 5.37798591e-02f,
  -4.63778526e-02f, 3.71936373e-02f, 1.18475616e-01f, 9.37961563e-02f, -3.52026857e-02f, -4.19087820e-02f, 8.11485425e-02f, -2.34724507e-02f, -2.28297859e-02f, -7.46293515e-02f,
  1.61557958e-01f, -1.62054393e-02f, 8.54541585e-02f, -1.41033139e-02f, -1.54239655e-01f, 1.08414009e-01f, 1.32316323e-02f, 1.03840895e-01f, 5.62775731e-02f, 8.04760121e-03f,
  8.57767910e-02f, 3.14801000e-02f, -9.79097262e-02f, -1.36358486e-02f, -3.12695466e-02f, -1.50480643e-01f, 7.56624574e-03f, -8.10714141e-02f, 7.76817724e-02f, -4.43627201e-02f,
  -3.64690013e-02f, -2.16330886e-01f, 3.56052779e-02f, -1.82529747e-01f, 7.03541189e-02f, 6.16770275e-02f, -1.71213746e-01f, -4.96917181e-02f, 1.61884427e-02f, -3.93283330e-02f,
  2.37784255e-02f, 1.48966253e-01f, -4.98776697e-02f, -1.30299926e-01f, 4.37733829e-02f, 2.23315600e-03f, -3.66369262e-02f, -2.51995742e-01f, -1.11783460e-01f, 7.05906609e-03f,
  -7.86525905e-02f, -1.89876780e-02f, -2.25744285e-02f, -1.92953959e-01f, -3.28025557e-02f, 2.47169994e-02f, 8.02631304e-02f, -2.47737631e-01f, 2.92778350e-02f, -7.36487273e-04f,
  4.40586582e-02f, 1.06171049e-01f, 1.36465549e-01f, 1.53971210e-01f, -2.89391875e-02f, 8.01638141e-02f, -1.95328500e-02f, -3.42238024e-02f, 4.74971943e-02f, 1.46658316e-01f,
  -5.24954796e-02f, -9.67914686e-02f, -1.72836021e-01f, 1.06109716e-02f, -1.24453917e-01f, -3.22225951e-02f, -4.88638431e-02f, -2.51616314e-02f, 1.58606600e-02f, -7.93469921e-02f,
  3.43742855e-02f, 1.00269720e-01f, -2.72317650e-03f, -6.27116710e-02f, 6.73153102e-02f, -5.83584122e-02f, -9.27814990e-02f, -7.99628571e-02f, 3.79051007e-02f, 1.00201011e-01f,
  -4.81465571e-02f, -5.85865080e-02f, -4.08813357e-02f, -1.12549819e-01f, 5.51416464e-02f, 7.09849177e-03f, -7.21043423e-02f, 3.63527387e-02f, 2.49154922e-02f, 7.64665455e-02f,
  2.72576082e-02f, -6.01266176e-02f, -2.07072161e-02f, 5.63342273e-02f, -7.81620070e-02f, -6.47730157e-02f, 6.61273971e-02f, -5.14664128e-02f, -3.33300941e-02f, -8.18038061e-02f,
  -6.73370138e-02f, -5.88849224e-02f, -5.55253513e-02f, 3.72707993e-02f, 1.50077520e-02f, -2.97538657e-02f, -3.82929742e-02f, 2.25153379e-02f, -6.99748844e-02f, 1.85079742e-02f,
  -4.40668985e-02f, -1.22032344e-01f, -4.57001068e-02f, 7.97482580e-02f, -6.08568303e-02f, -8.77523273e-02f, -7.44699165e-02f, -3.32436664e-03f, 7.99893662e-02f, 1.10085756e-01f,
  2.13917121e-02f, 9.32207555e-02f, 9.01941303e-03f, -3.34444791e-02f, -5.15102185e-02f, -8.74931663e-02f, 2.87493356e-02f, -6.29825741e-02f, -6.41204938e-02f, -4.85255755e-02f,
  1.86014585e-02f, -7.75904581e-02f, -1.65324196e-01f, 2.26345807e-02f, -1.12409547e-01f, 9.49123949e-02f, 7.26349354e-02f, 5.88635951e-02f, -5.55581301e-02f, -7.03318836e-03f,
  7.00222030e-02f, -4.66146097e-02f, -1.27852246e-01f, -7.17960522e-02f, -1.01617388e-02f, 4.04075012e-02f, -5.48896417e-02f, -3.91969793e-02f, -2.18938235e-02f, -1.37718633e-01f,
  -1.31655410e-01f, 3.55680920e-02f, 1.98001847e-01f, 5.67593165e-02f, 1.76514890e-02f, 3.92012112e-02f, -4.30364534e-03f, 2.22248077e-01f, -3.51480208e-02f, 2.32429225e-02f,
  -1.07733801e-01f, -2.66112387e-02f, -2.05530655e-02f, -1.00265155e-02f, 6.55416176e-02f, -5.19597977e-02f, -1.81667805e-01f, 6.78116158e-02f, -1.12856515e-01f, 1.74222544e-01f,
  6.51121363e-02f, -1.86545044e-01f, 8.42311159e-02f, 1.61834165e-01f, -6.89112470e-02f, 4.31606174e-02f, 6.78908676e-02f, 1.75932094e-01f, -6.37687743e-02f, -2.32523233e-02f,
  1.22700602e-01f, 2.29893122e-02f, -5.50309010e-02f, -2.13013496e-02f, 8.11729059e-02f, -1.05809920e-01f, 1.41305506e-01f, 1.78106233e-01f, 1.75019845e-01f, -3.88828665e-02f,
  3.27751003e-02f, -1.32486848e-02f, 7.70512521e-02f, 1.04830004e-01f, 1.24815712e-02f, -6.75753206e-02f, -2.25090841e-03f, 5.39144203e-02f, -8.98326263e-02f, -5.65919057e-02f,
  5.29566295e-02f, -5.36471494e-02f, 1.82336364e-02f, -5.71049973e-02f, 2.01273039e-02f, -1.71456055e-03f, 1.88742757e-01f, 8.12805593e-02f, -5.15310578e-02f, 3.24371345e-02f,
  -3.08890622e-02f, -1.47255808e-02f, -1.45123601e-02f, -5.14984503e-02f, 9.14923847e-02f, 9.95749533e-02f, -1.95961278e-02f, -7.01212510e-02f, -8.74349326e-02f, -2.23921612e-02f,
  -6.42006099e-02f, -1.22195952e-01f, 3.77456844e-02f, 1.22557115e-02f, 4.97702546e-02f, 3.39400321e-02f, 9.64438915e-02f, -3.23897973e-02f, -3.14036533e-02f, 4.06421069e-03f,
  -6.45482987e-02f, -9.88662392e-02f, 7.01343715e-02f, -5.99789545e-02f, -6.22883737e-02f, 4.17039841e-02f, -7.00251162e-02f, -3.31924707e-02f, 5.04288934e-02f, -5.06307371e-02f,
  -3.74361798e-02f, 4.21674848e-02f, 1.17615074e-01f, -8.96103755e-02f, -1.24702705e-02f, 1.14679538e-01f, -5.06725870e-02f, -1.04793690e-01f, 1.22386329e-02f, -2.40673739e-02f,
  -4.13930714e-02f, -8.13864619e-02f, 4.73157018e-02f, 3.13590281e-02f, -8.35102051e-02f, -2.28522010e-02f, 4.03671041e-02f, 8.53620917e-02f, 3.77662443e-02f, 1.43155307e-02f,
  4.81873285e-03f, -3.76837812e-02f, -2.03650370e-02f, -7.34987333e-02f, -8.79525244e-02f, -1.67594776e-02f, -4.70253825e-02f, 5.08300215e-02f, -3.64691950e-02f, 1.02865817e-02f,
  3.88876200e-02f, 9.80216730e-03f, 1.08492132e-02f, -2.29317620e-02f, 2.48121843e-02f, 8.17676634e-02f, -2.27747280e-02f, -2.62337700e-02f, 1.67448193e-01f, -6.66746497e-02f,
  -1.65779963e-01f, 4.52320762e-02f, -8.87443684e-03f, -1.08496569e-01f, -1.14059530e-01f, -1.43267930e-01f, -3.55836302e-02f, 1.45144090e-01f, 6.17754385e-02f, -9.32330340e-02f,
  9.99065787e-02f, 2.31027021e-03f, 3.89283709e-02f, 2.29537468e-02f, 9.71928164e-02f, 1.47940014e-02f, -1.28304929e-01f, -1.37596101e-01f, 3.03000882e-02f, -4.07905243e-02f,
  8.90839100e-03f, -7.05610439e-02f, 9.66284499e-02f, -4.58215084e-03f, -5.72983325e-02f, 5.92537783e-03f, 9.84246191e-03f, -1.35555625e-01f, 7.60874301e-02f, -2.32166937e-03f,
  2.15357244e-02f, 1.40277669e-01f, -1.76421404e-01f, 1.60740897e-01f, -1.17987640e-01f, -6.83056489e-02f, -1.51977828e-02f, 1.40901908e-01f, -1.46366435e-03f, 1.16633005e-01f,
  -2.10008584e-02f, -1.97600350e-02f, -5.60668521e-02f, -8.30283612e-02f, 9.93443746e-03f, 4.03091311e-02f, -4.78941128e-02f, 7.11216629e-02f, -1.33399805e-02f, -5.41023053e-02f,
  -2.89393608e-02f, 1.23480469e-01f, -5.36693260e-02f, 3.52056734e-02f, 2.63869930e-02f, -3.27501372e-02f, -9.04296562e-02f, -3.26700136e-02f, 4.16711383e-02f, -1.48570072e-02f,
  6.22267723e-02f, -5.82054481e-02f, -6.31551147e-02f, 5.14285192e-02f, -1.07294945e-02f, -9.02709886e-02f, 5.08651603e-03f, -6.21675476e-02f
};

// L1_fan_Wp_bar (Shape: 26 x 128)
const int L1_fan_Wp_bar_rows = 26;
const int L1_fan_Wp_bar_cols = 128;
const float L1_fan_Wp_bar_data[] = {
  6.45656288e-02f, 3.93988527e-02f, -4.12948690e-02f, -2.56936718e-02f, 1.26816873e-02f, 1.07626036e-01f, 9.71814096e-02f, 7.97400344e-03f, 1.23960990e-02f, 3.30643840e-02f,
  -7.84642622e-03f, 4.28005680e-02f, 4.90968227e-02f, -4.70161345e-03f, -3.29442881e-03f, -4.78043184e-02f, -3.17224190e-02f, 1.12932473e-01f, 3.28741758e-03f, 1.08702406e-01f,
  -3.94116007e-02f, 6.56657517e-02f, -2.94689778e-02f, -9.56272110e-02f, 6.96296394e-02f, -5.71392961e-02f, -5.78046404e-02f, 7.65596256e-02f, 3.24296728e-02f, -1.96529794e-02f,
  -2.83508934e-02f, 2.21595857e-02f, 1.04230456e-01f, 1.07212909e-01f, 1.98581927e-02f, 3.49651440e-03f, 7.03847036e-02f, 4.47151102e-02f, 2.51191575e-02f, 5.66492192e-02f,
  1.10589162e-01f, 2.55389884e-02f, -2.47742254e-02f, -1.29927322e-02f, 5.99629767e-02f, 6.20403402e-02f, 4.21404652e-02f, 4.99413051e-02f, 6.35265335e-02f, 6.63890913e-02f,
  -5.33791445e-02f, -7.02007040e-02f, 9.64958817e-02f, 9.13892910e-02f, 5.44903539e-02f, -7.35543966e-02f, -2.05611009e-02f, -4.86083776e-02f, -2.71814726e-02f, 3.51621490e-03f,
  -6.40600920e-02f, 4.38060723e-02f, -7.78917372e-02f, 3.25126271e-03f, 1.29786089e-01f, 1.25850216e-01f, 6.25683293e-02f, -1.19792610e-01f, -9.76912454e-02f, -6.99424222e-02f,
  1.39032811e-01f, -3.13322805e-02f, -7.91595280e-02f, 1.43983513e-02f, -3.27747613e-02f, 8.44224542e-02f, 9.08890814e-02f, -2.19236799e-02f, 1.64662749e-02f, -4.03713919e-02f,
  4.26454730e-02f, 1.65108040e-01f, -1.92065425e-02f, 3.72001827e-02f, 1.23358734e-01f, -3.17886658e-02f, 2.09780708e-02f, 2.19735932e-02f, 9.84065533e-02f, 7.39242062e-02f,
  1.01313725e-01f, -9.84885991e-02f, 5.02515063e-02f, -3.96643355e-02f, 5.27045131e-02f, -1.98471472e-02f, 1.40402809e-01f, 1.92257017e-02f, 5.77240363e-02f, -5.33827394e-02f,
  7.71951973e-02f, 6.95226416e-02f, -3.23948562e-02f, 7.21001923e-02f, 9.51011553e-02f, 6.33396357e-02f, -5.35712689e-02f, -2.64914446e-02f, 2.04576850e-02f, 3.36872763e-03f,
  4.21874449e-02f, 7.20944554e-02f, 3.95223238e-02f, 4.73623574e-02f, 2.40492728e-02f, -6.44318685e-02f, 3.92016815e-03f, -1.39492285e-02f, -7.64082819e-02f, -1.35356160e-02f,
  5.89931309e-02f, -5.92333041e-02f, 7.53088892e-02f, -2.56253704e-02f, 3.26455780e-03f, -1.22251874e-02f, 1.01033777e-01f, 1.16865352e-01f, -4.59738970e-02f, -5.88721372e-02f,
  -8.53114501e-02f, 1.17541160e-02f, 3.62832695e-02f, -1.80444475e-02f, 1.79700879e-03f, -1.24086989e-02f, -6.76273480e-02f, 9.67390090e-02f, -2.48832144e-02f, 7.75403976e-02f,
  -2.88075581e-02f, 8.89564399e-03f, -9.51298140e-03f, -3.72615829e-02f, -4.70728613e-03f, 6.72236234e-02f, 8.29801261e-02f, 1.24157378e-02f, -4.29255702e-02f, 2.12452337e-02f,
  -4.83909324e-02f, 7.97673985e-02f, -3.33166495e-02f, 8.15888569e-02f, 3.99002805e-02f, 9.62662548e-02f, -3.15245986e-02f, 5.80319241e-02f, 9.84072015e-02f, 8.04214999e-02f,
  -4.01033163e-02f, 6.51648268e-02f, -3.55100147e-02f, 6.90175891e-02f, 3.03517282e-02f, 7.47508630e-02f, 8.31916463e-03f, -3.46319899e-02f, -4.02271636e-02f, 7.97757972e-03f,
  -5.61600588e-02f, -1.20275971e-02f, 5.74012138e-02f, 9.24608856e-02f, 3.07756756e-02f, -4.66635898e-02f, 8.27778876e-02f, -5.07684797e-02f, 3.40507329e-02f, 6.21600561e-02f,
  2.66726557e-02f, 8.26937333e-02f, -1.27461413e-02f, -7.95859843e-02f, 1.37926266e-02f, -3.68238240e-02f, 2.78362185e-02f, 1.03270099e-01f, 8.59752968e-02f, -5.09825796e-02f,
  -2.12267824e-02f, 3.81284468e-02f, 1.26656860e-01f, 7.20617026e-02f, -3.54093104e-03f, -2.17111539e-02f, -5.94575331e-02f, 4.56559099e-03f, 7.48108327e-03f, 9.58695263e-02f,
  9.22034383e-02f, 5.81244286e-03f, 5.52180447e-02f, -2.19501704e-02f, 4.78291698e-02f, 3.95303778e-02f, 6.64162040e-02f, -3.64246406e-02f, 8.49453732e-02f, -1.90745667e-02f,
  -4.59188558e-02f, 2.17552274e-03f, 1.17389530e-01f, -6.19115271e-02f, 5.18215727e-03f, -6.48472749e-04f, 1.16513055e-02f, -6.36919886e-02f, 4.03004698e-02f, 1.18491538e-02f,
  8.77230540e-02f, 1.37975765e-02f, -1.50423571e-02f, 5.04489914e-02f, -4.60040849e-03f, -7.26481751e-02f, 3.49633172e-02f, 7.47036487e-02f, -3.74864824e-02f, -4.18504551e-02f,
  6.17979988e-02f, 4.91824746e-02f, -1.19232191e-02f, 2.02155467e-02f, -6.25823438e-02f, -3.10462601e-02f, 2.22268589e-02f, 5.97564271e-03f, 1.48812849e-02f, 7.03755673e-03f,
  -2.29180939e-02f, -3.94239090e-03f, 7.82784745e-02f, 7.39536658e-02f, 6.61849231e-02f, 6.77963421e-02f, -3.05048395e-02f, 2.52682227e-03f, -5.85161150e-02f, -3.47289667e-02f,
  -1.11900305e-03f, 1.00237215e-02f, -3.91421728e-02f, -3.17041650e-02f, 2.91195568e-02f, 1.46513581e-02f, 4.64596041e-02f, -4.22416404e-02f, 5.45836240e-02f, 1.03725173e-01f,
  8.21165293e-02f, 7.53823295e-02f, -5.83332926e-02f, 4.75535654e-02f, 6.91312179e-02f, -3.87939960e-02f, 2.09319666e-02f, -7.39656687e-02f, 7.82544389e-02f, 7.17008114e-03f,
  -5.93409799e-02f, 1.41723154e-04f, -5.38141541e-02f, 1.18430585e-01f, -2.24295501e-02f, 2.71220393e-02f, 1.15259781e-01f, 9.57429335e-02f, 2.78493501e-02f, 9.78277549e-02f,
  -6.42225966e-02f, -6.74561411e-02f, 5.32126240e-02f, -5.61722368e-03f, 1.14859611e-01f, 6.75577968e-02f, -2.09895018e-02f, 5.88627234e-02f, 6.04690947e-02f, -2.56583504e-02f,
  2.73338035e-02f, -2.67223045e-02f, -1.75581966e-03f, -4.04754579e-02f, 1.27131298e-01f, 4.80957292e-02f, -2.62017436e-02f, -4.39524986e-02f, -6.58990964e-02f, 1.18926071e-01f,
  7.17957914e-02f, -4.43207920e-02f, 8.63447413e-02f, -2.37217918e-02f, 1.26005672e-02f, -1.02041662e-03f, -5.81380986e-02f, 2.03892756e-02f, -1.51697025e-02f, -9.30087417e-02f,
  -1.30170528e-02f, 5.09029515e-02f, -5.14514744e-02f, -6.65038452e-02f, -6.01365604e-02f, -5.79545498e-02f, -8.71458091e-03f, 1.46152874e-04f, -1.51859686e-01f, -7.80576393e-02f,
  2.71114931e-02f, -2.52527874e-02f, 8.43574256e-02f, -2.91711688e-02f, -4.20757085e-02f, -1.10985413e-01f, -5.20156138e-02f, -4.53788228e-03f, 3.68586965e-02f, -9.17367339e-02f,
  3.66494283e-02f, -3.18443440e-02f, -3.72594707e-02f, -8.92225057e-02f, -1.22848734e-01f, 5.91079472e-03f, -5.31107150e-02f, -1.31546780e-01f, -5.00692576e-02f, -2.30975375e-02f,
  4.74616662e-02f, 6.94324598e-02f, -2.33197305e-02f, 6.73863338e-03f, -5.53783476e-02f, 1.52308326e-02f, -6.12139404e-02f, -7.42526352e-02f, 4.82567959e-03f, 1.13770545e-01f,
  -2.37403028e-02f, 5.36932535e-02f, -1.16211455e-02f, -4.44809869e-02f, -1.10575415e-01f, -1.99093651e-02f, -6.52412102e-02f, -8.71921238e-03f, 3.28484364e-02f, 6.43830299e-02f,
  -2.88128126e-02f, -6.56747743e-02f, 7.27534071e-02f, 3.98501381e-02f, 9.44188982e-02f, -7.24620894e-02f, -1.53649803e-02f, -9.02613923e-02f, -4.32410799e-02f, 4.16546278e-02f,
  8.76696035e-02f, 8.62134174e-02f, 3.83972302e-02f, 4.01309803e-02f, 3.20084095e-02f, 2.78177802e-02f, 1.19789708e-02f, -4.57542427e-02f, 2.39114780e-02f, 4.61967252e-02f,
  -7.20664486e-02f, 3.02988514e-02f, -4.79519293e-02f, 7.89249390e-02f, 3.13376412e-02f, -9.16652381e-02f, -6.06257580e-02f, -3.12552936e-02f, 2.29713991e-02f, -8.76721088e-03f,
  7.42341066e-03f, -4.75262180e-02f, -8.37652162e-02f, -8.41909796e-02f, 1.78228971e-02f, 7.63009116e-02f, 7.88755119e-02f, 2.17733197e-02f, 4.88997214e-02f, 3.22185978e-02f,
  6.08306080e-02f, 5.48184104e-03f, 9.22893919e-03f, -3.00642904e-02f, -7.42675886e-02f, 2.56256126e-02f, 4.44176793e-02f, 8.19988623e-02f, -1.12483453e-03f, -7.95254409e-02f,
  -6.33336827e-02f, 3.63638140e-02f, -8.92081335e-02f, -2.43617464e-02f, -4.49110717e-02f, -2.55480763e-02f, 7.84732550e-02f, 3.19770374e-03f, -6.46930337e-02f, 4.22375612e-02f,
  -6.93280026e-02f, 2.34642439e-02f, -1.50651075e-02f, -2.43607722e-02f, -1.98683962e-02f, 3.05682905e-02f, 7.30128959e-02f, -7.93309584e-02f, 1.49270296e-02f, 5.52763268e-02f,
  -1.79015938e-02f, 1.48482863e-02f, -5.94029315e-02f, -4.00562100e-02f, 7.96339884e-02f, 4.16077934e-02f, -9.19077843e-02f, 4.90940809e-02f, -3.99890654e-02f, 1.57242473e-02f,
  6.11569732e-02f, 1.45825231e-02f, -3.75517346e-02f, 6.43233955e-02f, -5.15382029e-02f, 6.31327257e-02f, -3.82151268e-02f, 4.02544364e-02f, 5.98754063e-02f, 1.87103301e-02f,
  8.25544447e-02f, 4.37739752e-02f, 1.77582968e-02f, 4.89652194e-02f, 4.19442952e-02f, 1.02066966e-02f, 2.01537441e-02f, 8.34870636e-02f, -5.81320748e-02f, 6.76928610e-02f,
  -3.92030701e-02f, 3.33367195e-03f, -7.90842175e-02f, -1.88602805e-02f, 1.12507809e-02f, -5.41279539e-02f, 2.89871357e-02f, 8.45641494e-02f, -8.57239440e-02f, 2.25307755e-02f,
  -2.52793655e-02f, -5.26384264e-02f, -1.20278383e-02f, 1.22249890e-02f, 7.72020295e-02f, 3.79513763e-02f, 1.78163908e-02f, -6.24587052e-02f, -1.03624135e-01f, 7.18525350e-02f,
  4.98478077e-02f, 3.42938304e-03f, -5.78413680e-02f, 1.72800142e-02f, -1.44061707e-02f, -2.43413653e-02f, -6.74517080e-02f, 4.42165323e-02f, -8.59187171e-02f, 3.69467656e-03f,
  -7.29324017e-03f, 5.29992282e-02f, 9.27209929e-02f, 4.68126722e-02f, 5.32147251e-02f, -1.02552371e-02f, 8.10267553e-02f, 2.04605442e-02f, 3.78134288e-02f, -7.20384866e-02f,
  7.78271109e-02f, -9.30220485e-02f, -6.02586456e-02f, -1.49610490e-02f, -1.05449455e-02f, -3.83557156e-02f, -4.15208302e-02f, -9.30195749e-02f, -7.71383494e-02f, -6.37422651e-02f,
  -3.27848047e-02f, 6.83270320e-02f, 3.13243717e-02f, 8.70181546e-02f, -1.28732005e-03f, -7.35096037e-02f, 8.62077530e-03f, 2.12643668e-02f, -6.99833557e-02f, 9.36614946e-02f,
  3.69335688e-03f, -1.69542115e-02f, 1.22865168e-02f, 3.80594879e-02f, 4.23659608e-02f, 7.74332806e-02f, -4.47088704e-02f, 1.90629682e-03f, 5.38165942e-02f, 8.24909508e-02f,
  -3.70513313e-02f, 2.97851227e-02f, 2.50765271e-02f, 6.54208586e-02f, -8.16055685e-02f, -4.72390130e-02f, 8.37432295e-02f, -6.71699941e-02f, 3.63883637e-02f, 3.54001969e-02f,
  -3.12285614e-03f, -3.02272942e-02f, -7.15037584e-02f, 7.93066621e-02f, 1.15952268e-02f, -2.47114059e-03f, 7.52927735e-02f, -1.18986657e-02f, -5.63726798e-02f, -6.80680797e-02f,
  -3.12188268e-02f, 6.41340837e-02f, 4.42570783e-02f, 7.36257359e-02f, -3.30535024e-02f, -7.49330176e-03f, -3.48674133e-02f, 5.18536717e-02f, 2.37716343e-02f, 1.20082386e-02f,
  8.75929892e-02f, 3.98941115e-02f, 1.26260798e-02f, -7.83252493e-02f, -5.69987437e-03f, 6.61306009e-02f, -8.95527825e-02f, 8.11612327e-03f, 4.52344790e-02f, -9.15832911e-03f,
  -5.80195040e-02f, 4.71289828e-02f, -9.49772727e-03f, -2.65122056e-02f, 4.30620164e-02f, -7.08454028e-02f, -7.57808909e-02f, -8.11591074e-02f, -1.19552620e-01f, 3.04827001e-02f,
  1.00871492e-02f, 8.90767798e-02f, -7.11096823e-02f, 3.77356261e-02f, 5.14756469e-03f, -2.15648301e-02f, -2.15825718e-02f, 2.41771247e-02f, -6.70284107e-02f, -3.56127322e-02f,
  -2.45653582e-03f, 8.44994746e-03f, 4.47768942e-02f, 2.51139756e-02f, -9.62882303e-03f, 4.03356850e-02f, -8.75870064e-02f, -5.66885760e-03f, 1.24752382e-02f, 1.54486047e-02f,
  3.47955637e-02f, 7.44337887e-02f, -1.48706920e-02f, -2.68594343e-02f, 1.01132192e-01f, 1.13367029e-01f, 2.89487536e-03f, -3.45116183e-02f, -1.40079753e-02f, 2.03452893e-02f,
  -7.31887147e-02f, -1.17711285e-02f, 8.59034732e-02f, 7.63363168e-02f, 4.86553237e-02f, -1.60910357e-02f, -9.21349302e-02f, 4.91025187e-02f, 6.29641786e-02f, 6.44898340e-02f,
  9.33179632e-02f, 1.25335595e-02f, -3.29928659e-02f, 7.12869540e-02f, 7.90234208e-02f, 4.52894494e-02f, -7.71673322e-02f, 9.06720534e-02f, -2.93860529e-02f, -9.99104884e-03f,
  -2.83725131e-02f, -4.63611959e-03f, -6.96747303e-02f, 6.58823689e-03f, 8.04264843e-02f, 8.54265019e-02f, 1.35280620e-02f, 2.39467341e-02f, -8.88420716e-02f, -7.85757322e-03f,
  -6.65718988e-02f, -3.17125283e-02f, -5.96387722e-02f, 1.80082582e-02f, -7.86272511e-02f, 4.63653356e-02f, 5.26814610e-02f, -4.97120209e-02f, -7.11413473e-02f, 6.36914819e-02f,
  3.65797915e-02f, 6.48582503e-02f, -7.36184120e-02f, -7.88183436e-02f, -2.56483927e-02f, 6.06332496e-02f, -2.57629547e-02f, -4.63581756e-02f, 6.57762364e-02f, 9.03865471e-02f,
  3.04682497e-02f, -5.43631725e-02f, -3.51196975e-02f, -4.63177338e-02f, -3.17466073e-02f, -7.10375011e-02f, -3.72227654e-02f, 4.49202619e-02f, -3.22856270e-02f, -7.65822129e-03f,
  -6.12125136e-02f, -4.39658836e-02f, 5.66266440e-02f, -2.45375074e-02f, 7.70273656e-02f, 7.50309601e-02f, 2.65717525e-02f, 8.71500224e-02f, 3.59367877e-02f, -3.15161869e-02f,
  -5.88379242e-02f, 8.63884613e-02f, -2.96963993e-02f, -2.74169836e-02f, 7.66224563e-02f, -7.90071711e-02f, 2.78892089e-02f, -7.39114583e-02f, 4.25636396e-02f, -2.32266989e-02f,
  7.19634518e-02f, -5.28210662e-02f, -4.93373126e-02f, -6.39322400e-02f, 7.46104568e-02f, -3.37405615e-02f, 4.73514758e-02f, -6.90385550e-02f, 3.45605351e-02f, 5.71312234e-02f,
  -2.43942793e-02f, -1.34156412e-02f, -2.08857115e-02f, 4.15699035e-02f, -5.65821230e-02f, -6.56848103e-02f, 3.16723287e-02f, -5.54381832e-02f, -4.13354859e-02f, -5.96968792e-02f,
  4.73249443e-02f, 6.65374249e-02f, 3.68765965e-02f, -7.39017576e-02f, -4.38319370e-02f, 8.25621411e-02f, -8.69365185e-02f, -8.78002867e-02f, 6.24400424e-03f, -4.86188233e-02f,
  -3.70867923e-02f, 1.58192832e-02f, 8.77192393e-02f, -3.44563052e-02f, -3.82878184e-02f, 6.51752427e-02f, -5.66140488e-02f, -5.94046488e-02f, -4.61058989e-02f, -1.75585896e-02f,
  -5.14106005e-02f, -2.10831445e-02f, 3.19377668e-02f, -7.95084238e-02f, 6.22865520e-02f, -5.55175953e-02f, 7.55321756e-02f, 1.30088087e-02f, -9.18137431e-02f, -4.62663546e-02f,
  -6.40199408e-02f, 4.66633625e-02f, -5.84028952e-04f, -1.88239925e-02f, -7.50608593e-02f, -7.14825690e-02f, 6.67547793e-05f, -3.89536261e-03f, -8.51233751e-02f, 3.16372253e-02f,
  3.77937071e-02f, 8.15489069e-02f, 2.23289151e-02f, -3.45086306e-02f, 7.09732771e-02f, 3.14903110e-02f, 5.72664617e-03f, 3.26828565e-03f, -1.98133942e-02f, -7.70973638e-02f,
  -4.72432040e-02f, 8.98117386e-03f, 4.97359000e-02f, -7.47818500e-02f, 5.51415682e-02f, -8.82279593e-03f, 2.72999182e-02f, -5.72507083e-02f, 6.78806230e-02f, 1.75368674e-02f,
  4.31245863e-02f, -3.05650532e-02f, -5.39639965e-02f, 6.44867569e-02f, -4.12426330e-03f, 1.08157016e-01f, -4.79218997e-02f, -3.24435253e-03f, -4.07902943e-03f, -4.19625714e-02f,
  8.16321373e-02f, -8.69774222e-02f, 1.03884898e-01f, 1.07346684e-01f, 1.52533576e-01f, 7.18597099e-02f, 1.07441638e-02f, -7.41971098e-03f, 1.05589725e-01f, -9.92097519e-03f,
  -1.23843933e-02f, 1.63954377e-01f, 1.18403494e-01f, 2.88886409e-02f, 6.17352203e-02f, 4.20399196e-02f, 7.79282153e-02f, 8.25370178e-02f, 1.20807685e-01f, 2.77175643e-02f,
  2.16055885e-02f, -1.12303137e-03f, 2.37024482e-02f, 5.86356036e-02f, -1.08848521e-02f, 9.27814394e-02f, 6.61256984e-02f, 1.17606409e-01f, 5.84303401e-02f, -7.48510426e-03f,
  7.13745952e-02f, 1.05573140e-01f, 9.92692858e-02f, 7.45558515e-02f, -1.32899303e-02f, 7.29802921e-02f, -1.06719099e-02f, 4.27039340e-02f, 9.08936858e-02f, 3.93408686e-02f,
  1.03439063e-01f, -1.30246747e-02f, -1.01360856e-02f, 5.36192320e-02f, -7.75697380e-02f, 2.15289727e-01f, -7.03929514e-02f, 1.13053150e-01f, -5.55030257e-02f, 5.74501790e-02f,
  -1.18021689e-01f, -1.55594334e-01f, 3.17634013e-03f, -8.24961290e-02f, -2.14584004e-02f, 4.85818647e-02f, -6.31677434e-02f, 1.58196032e-01f, -2.89300433e-03f, -9.81606469e-02f,
  1.70009434e-01f, -3.56172770e-02f, -4.34916988e-02f, 4.95899841e-02f, 4.56484780e-02f, -7.16365427e-02f, -1.69063762e-01f, 5.88620752e-02f, -6.07564636e-02f, -1.66646868e-01f,
  -3.74103822e-02f, -4.36926074e-02f, 7.83668458e-02f, -4.87873964e-02f, 1.23659216e-01f, -2.17306782e-02f, -8.04307684e-02f, 7.63080195e-02f, 2.88100098e-03f, -5.47927096e-02f,
  2.07115104e-03f, 1.08907707e-01f, 1.32961795e-02f, 4.33413684e-02f, -1.42229527e-01f, -9.55040194e-03f, 3.68530080e-02f, 9.33220163e-02f, 1.47244066e-01f, -5.27532622e-02f,
  4.37860889e-03f, 9.87356976e-02f, -1.24672009e-02f, 3.44152766e-04f, -2.05836594e-02f, -2.54313536e-02f, -2.43159123e-02f, 5.39829321e-02f, 1.62582770e-02f, 3.90257798e-02f,
  1.09578423e-01f, -4.36711051e-02f, -1.22053653e-01f, -2.66811531e-02f, 4.02857363e-02f, 1.18771084e-02f, -5.12881391e-02f, 4.31415811e-02f, -9.24253315e-02f, 5.77752180e-02f,
  7.21224176e-04f, -9.27187875e-02f, 4.81988564e-02f, 4.67930622e-02f, -6.01624064e-02f, -6.67425320e-02f, -9.90079809e-03f, 3.90587971e-02f, 7.84553587e-02f, 8.02797228e-02f,
  -7.23628607e-03f, 1.00256644e-01f, 4.70290482e-02f, -1.23023242e-02f, 1.17565051e-01f, 8.14410150e-02f, 1.46449097e-02f, -3.61646786e-02f, -5.02741225e-02f, 1.10235415e-01f,
  3.06069069e-02f, 6.60565570e-02f, -4.59403247e-02f, 9.45062712e-02f, -7.65277364e-05f, 9.11465660e-02f, 2.56624892e-02f, 1.69429988e-01f, 9.86379236e-02f, 1.80121049e-01f,
  1.16766945e-01f, -8.61709937e-03f, 6.85764328e-02f, 6.76563978e-02f, 6.91887289e-02f, 4.61777598e-02f, 2.94131991e-02f, 9.44887921e-02f, -8.54379684e-03f, -5.99680021e-02f,
  -2.50061788e-03f, 1.49910420e-01f, 1.17618121e-01f, 9.76807810e-03f, 1.27008557e-01f, 6.48010373e-02f, 1.03912830e-01f, 5.12329340e-02f, -8.96130875e-02f, 1.76760438e-03f,
  1.26055151e-01f, -3.13606150e-02f, -2.18531862e-02f, 7.88094774e-02f, -6.70095831e-02f, 2.52168765e-03f, 1.26570597e-01f, -1.75309405e-01f, -2.10395440e-01f, -1.29520416e-01f,
  1.24265123e-02f, 7.55512640e-02f, 2.23354474e-02f, -6.97831511e-02f, -1.15231127e-01f, -5.23240529e-02f, -2.17210036e-02f, -1.19726963e-01f, 8.04952309e-02f, 1.25348806e-01f,
  -1.02214880e-01f, 6.95993081e-02f, 1.33001000e-01f, -2.78651007e-02f, 5.31774573e-02f, -1.25899225e-01f, -6.13304451e-02f, 1.06221758e-01f, -6.86057508e-02f, 1.15604818e-01f,
  -4.90628229e-03f, -8.32206234e-02f, -6.46624640e-02f, -8.41982365e-02f, 8.97871479e-02f, -9.59353521e-02f, 1.11918189e-01f, 3.40413079e-02f, 2.34876852e-02f, -9.09472406e-02f,
  -5.12815975e-02f, 1.13310024e-01f, -6.87134452e-03f, 1.66682564e-02f, 7.46653602e-02f, -9.99143422e-02f, -1.31507199e-02f, -7.75975138e-02f, -1.55100347e-02f, -1.12888984e-01f,
  -8.32795352e-02f, -1.07627206e-01f, 3.77578773e-02f, -1.80486262e-01f, 2.22136099e-02f, -1.68427601e-01f, -2.00326011e-01f, -1.46622732e-01f, -6.76979274e-02f, -6.13776781e-02f,
  -7.65139014e-02f, 3.94649506e-02f, -1.83370840e-02f, -2.22647358e-02f, 2.07693130e-02f, 1.09839821e-02f, -2.42473725e-02f, 2.76186783e-03f, 1.13438349e-02f, -6.94123283e-02f,
  3.03092655e-02f, 6.45749364e-03f, 6.22069426e-02f, -8.96129981e-02f, 8.63072574e-02f, -1.13978632e-01f, -1.19622469e-01f, -1.56619288e-02f, 4.73957434e-02f, -3.06020621e-02f,
  9.52312909e-03f, 8.27546865e-02f, -1.62429325e-02f, 5.27171278e-03f, -3.24641764e-02f, 2.71904264e-02f, -4.73364033e-02f, 5.63018844e-02f, -2.11747307e-02f, -5.02802283e-02f,
  -2.13007559e-03f, 1.39471553e-02f, -2.61956714e-02f, -1.07534798e-02f, 2.50376686e-02f, -1.03790071e-02f, -3.01299077e-02f, -1.13412784e-02f, -7.66175538e-02f, -1.60940811e-02f,
  3.60866860e-02f, 3.06880362e-02f, -1.32854807e-03f, -7.98770934e-02f, -7.57257119e-02f, 8.49885195e-02f, 1.99328326e-02f, 2.06626430e-02f, -1.74966864e-02f, 5.81847131e-02f,
  -2.71179024e-02f, -6.51966035e-02f, 5.32724895e-02f, 1.10370973e-02f, -2.98939105e-02f, 1.87133681e-02f, 2.02611219e-02f, -5.27398288e-03f, 6.20985404e-02f, -5.14967553e-02f,
  2.63963100e-02f, 2.39318535e-02f, -6.22796454e-02f, 2.89297830e-02f, -6.68136775e-02f, -4.24192101e-02f, 4.00225259e-02f, 3.15836594e-02f, 6.74254894e-02f, -3.85340787e-02f,
  1.22435857e-02f, -6.66324124e-02f, -2.30101217e-02f, -1.73250064e-02f, -8.23039338e-02f, -7.47637004e-02f, 4.19937335e-02f, -8.88584107e-02f, -2.25273110e-02f, 6.31558672e-02f,
  9.29690376e-02f, -2.36195959e-02f, 5.40451035e-02f, 1.42458882e-02f, 1.60016473e-02f, -6.77603036e-02f, 5.78320101e-02f, -6.78530335e-02f, -6.95824847e-02f, -1.76937301e-02f,
  3.38348374e-02f, 3.25676613e-02f, -3.87403369e-02f, -3.11825890e-02f, 5.96853606e-02f, 2.32951306e-02f, 1.95355806e-02f, 2.38990914e-02f, -1.16535630e-02f, 4.32215221e-02f,
  -9.12033543e-02f, 3.96490395e-02f, -6.20624125e-02f, 4.27365080e-02f, -8.38143518e-04f, 7.86832646e-02f, 6.35040626e-02f, 5.11626340e-02f, -9.84649286e-02f, 3.08214575e-02f,
  6.71092868e-02f, 4.67660539e-02f, 6.54053167e-02f, 1.29635250e-02f, 8.13045651e-02f, -3.64278629e-02f, -5.00939377e-02f, 1.75411887e-02f, 1.07753061e-01f, 2.07940079e-02f,
  7.35391900e-02f, 2.62339525e-02f, -3.32661183e-03f, -5.05793877e-02f, -3.59347351e-02f, -7.33003393e-02f, 6.73122779e-02f, -4.35203798e-02f, 1.02780322e-02f, 4.07938324e-02f,
  -4.82531749e-02f, 1.30219338e-02f, -5.16259894e-02f, 7.52730668e-02f, 6.30989745e-02f, 3.06917988e-02f, 3.14058326e-02f, 3.21835577e-02f, 2.83864676e-03f, 1.01142563e-02f,
  -2.10289732e-02f, -4.47089858e-02f, 1.56159401e-02f, 5.18428423e-02f, 8.07741508e-02f, 7.87999630e-02f, 2.60462202e-02f, 8.96435827e-02f, 3.62940435e-03f, 5.24240360e-02f,
  -5.15105575e-02f, -8.71171132e-02f, -1.11591369e-02f, 4.06966619e-02f, -1.92146618e-02f, 9.83908586e-03f, 5.16651422e-02f, 6.35922700e-02f, -4.63736616e-02f, 3.23659033e-02f,
  -4.17959951e-02f, 9.94371176e-02f, 6.55390844e-02f, -3.41157764e-02f, 9.25627500e-02f, -4.75013033e-02f, 7.42779374e-02f, 3.35842483e-02f, -7.51508474e-02f, -5.71524613e-02f,
  7.62482733e-02f, -2.61096191e-02f, 4.79812138e-02f, -4.72551659e-02f, 1.39512466e-02f, 3.78497019e-02f, 5.84779680e-02f, -1.34606101e-02f, -3.30271432e-03f, 3.02864285e-03f,
  1.37379039e-02f, -2.25927439e-02f, 1.05880514e-01f, -9.97748878e-03f, 7.23097399e-02f, 7.56651163e-02f, 4.39403066e-03f, -4.73122783e-02f, 2.33801100e-02f, -5.61109409e-02f,
  1.47432107e-02f, 5.96770346e-02f, -3.45570222e-02f, -9.23779141e-03f, 7.54683092e-02f, 7.02019259e-02f, 3.19835022e-02f, -4.67098951e-02f, -1.74401607e-02f, -6.98313937e-02f,
  -4.10384983e-02f, 3.23480926e-02f, 4.40942384e-02f, -3.34139727e-02f, 6.80117533e-02f, 8.62064511e-02f, 2.86324490e-02f, -1.09769493e-01f, -1.41936848e-02f, -3.24363410e-02f,
  5.14428839e-02f, -5.42960735e-03f, -1.15032911e-01f, 2.68201083e-02f, -1.28006050e-02f, -7.44953752e-02f, 7.97863677e-03f, -2.48903986e-02f, -5.24996407e-02f, -3.35691832e-02f,
  -6.25444353e-02f, 8.67975652e-02f, 7.75057226e-02f, 7.10728206e-03f, -2.67235320e-02f, -6.94646314e-02f, -7.02824583e-03f, -3.32194716e-02f, -1.71787161e-02f, -1.26519231e-02f,
  -4.68685925e-02f, -1.00612849e-01f, 2.09201779e-02f, -9.48714018e-02f, 3.23607624e-02f, 1.73927434e-02f, -4.25088517e-02f, -9.31917951e-02f, 9.12957918e-03f, 6.12279251e-02f,
  9.74664185e-03f, -3.14253308e-02f, -1.73107032e-02f, -1.02562085e-01f, -7.95875266e-02f, 2.90881805e-02f, 3.22204754e-02f, 3.71517763e-02f, -4.01444919e-02f, -2.66229659e-02f,
  2.19665281e-02f, -5.92300575e-03f, 3.14803086e-02f, -9.66269150e-03f, -5.44100404e-02f, 7.05929846e-02f, 5.58982641e-02f, 4.18416895e-02f, 4.43778820e-02f, -5.47801778e-02f,
  -3.23926844e-02f, 3.90281864e-02f, -6.45815656e-02f, -6.72867671e-02f, -8.27476680e-02f, 5.68256676e-02f, 4.01493274e-02f, -2.12332997e-02f, -7.50166550e-02f, 3.13282087e-02f,
  -7.43975490e-02f, -2.42868792e-02f, -9.33239609e-02f, -6.82315603e-02f, 2.31289677e-02f, -6.16473071e-02f, -1.23272110e-02f, 5.80060109e-02f, -7.81407952e-02f, 6.45564124e-02f,
  5.96595667e-02f, 3.94325368e-02f, 1.21948142e-02f, -7.72674605e-02f, 6.60801679e-02f, 4.55373153e-02f, 7.26997629e-02f, 7.83548802e-02f, 2.59092753e-03f, 6.43883795e-02f,
  1.13117769e-02f, 7.28137046e-02f, -6.89626187e-02f, 4.41399701e-02f, 7.48297619e-03f, 5.29862866e-02f, 3.06231417e-02f, 2.04131547e-02f, 7.03216344e-02f, 5.35756052e-02f,
  4.89401147e-02f, 6.61404757e-03f, 8.98614302e-02f, 2.16183811e-02f, 1.34778218e-02f, 8.19799304e-02f, 6.99494630e-02f, 5.61526278e-03f, -4.42657322e-02f, -3.48475315e-02f,
  5.87780401e-02f, 6.45616651e-02f, -1.38719892e-03f, -1.35220233e-02f, -7.22159967e-02f, 8.76433924e-02f, 1.94421113e-02f, 4.87554818e-02f, 1.18763767e-01f, -7.07954466e-02f,
  1.03348114e-01f, -7.79047832e-02f, -8.75881594e-03f, -8.09843540e-02f, 2.82394979e-02f, -1.43980561e-02f, 7.20278397e-02f, -5.60017824e-02f, -7.24209920e-02f, -3.98260467e-02f,
  9.00681019e-02f, 9.43324938e-02f, -2.99511477e-02f, -4.23554331e-02f, 1.05696738e-01f, 6.51822938e-03f, -4.14065868e-02f, 9.81813595e-02f, 1.05226047e-01f, -2.35814210e-02f,
  -4.15015370e-02f, 3.81977819e-02f, 6.51059300e-02f, -4.82520573e-02f, 2.41427142e-02f, -2.78797671e-02f, 3.51664089e-02f, 2.39004828e-02f, -2.41213646e-02f, 5.03094420e-02f,
  -4.32283394e-02f, -5.28220758e-02f, 4.20500338e-02f, -4.45325822e-02f, 9.55860913e-02f, -7.14242831e-02f, -7.46427923e-02f, -1.11837285e-02f, -6.37444407e-02f, 4.55389209e-02f,
  -1.20839827e-01f, -1.42429098e-01f, 1.24806307e-01f, 1.67643633e-02f, -9.77560356e-02f, -1.45460263e-01f, -2.61847377e-02f, 4.48969193e-02f, 4.22932245e-02f, 5.54756075e-02f,
  -1.13399506e-01f, -4.49339495e-05f, -1.20903000e-01f, 6.99537694e-02f, -5.45849577e-02f, -5.21518514e-02f, -5.08002331e-03f, 1.29206568e-01f, 8.36129114e-03f, 7.17824548e-02f,
  -4.60585132e-02f, -7.51827657e-02f, 3.36565338e-02f, 6.38983324e-02f, -9.37455520e-03f, -9.49496776e-02f, 1.01320539e-03f, 2.62559671e-02f, 3.83870788e-02f, 1.92907210e-02f,
  2.52293143e-02f, -1.45706274e-02f, -3.91873792e-02f, 8.57364014e-02f, 3.06543671e-02f, -1.24014830e-02f, 5.43928929e-02f, 4.88557667e-02f, 2.13539731e-02f, -2.71507949e-02f,
  -1.04138434e-01f, 2.43275668e-02f, 3.38733234e-02f, -3.22986059e-02f, -1.84949785e-02f, 1.25223130e-01f, -8.68508220e-02f, 4.96834703e-02f, 1.14712827e-01f, -5.15121259e-02f,
  -1.51821338e-02f, 8.90689641e-02f, -4.15479690e-02f, 1.01060309e-01f, 9.43479165e-02f, 7.64681399e-02f, -2.67236084e-02f, 9.23565626e-02f, 1.31418975e-02f, 3.41532566e-02f,
  8.92186631e-03f, 7.21527860e-02f, -2.69625746e-02f, 2.87118815e-02f, 6.48540929e-02f, 4.50178459e-02f, 8.60060528e-02f, -2.02269647e-02f, 1.42064625e-02f, -3.49644050e-02f,
  1.95144920e-03f, 3.25078703e-02f, 5.92391640e-02f, 8.10776651e-02f, 9.05038714e-02f, 4.84928973e-02f, 5.68267815e-02f, 1.23674899e-01f, 4.59778048e-02f, 9.84190106e-02f,
  -5.57733402e-02f, -8.61411542e-03f, -2.91259121e-02f, 8.67361203e-02f, -3.66546512e-02f, 4.09133509e-02f, -2.47724187e-02f, 6.97088391e-02f, -8.65586684e-04f, -1.84392259e-02f,
  2.58739162e-02f, 6.69687018e-02f, 6.30025845e-03f, 4.56271991e-02f, 2.37181764e-02f, 1.50662541e-01f, 8.84811282e-02f, -5.99986350e-04f, 7.97056705e-02f, 1.02325529e-01f,
  -3.16256806e-02f, -1.32287517e-01f, 4.25999649e-02f, -1.74651537e-02f, 1.32374406e-01f, 1.51079521e-01f, 1.13503970e-01f, 3.87309231e-02f, 6.40964210e-02f, 8.70606750e-02f,
  8.35583061e-02f, -2.12068157e-03f, -1.10897377e-01f, -1.32909700e-01f, -1.04476608e-01f, 4.67955507e-03f, 1.26825362e-01f, 7.30477795e-02f, -1.19410150e-01f, 9.62295383e-02f,
  2.34533567e-02f, 7.47445971e-02f, 1.96290631e-02f, 1.38177127e-01f, 3.19688357e-02f, -2.60919854e-02f, -7.46671781e-02f, 1.36089444e-01f, 4.14223820e-02f, -1.50364369e-01f,
  7.12936372e-02f, -1.89515594e-02f, 7.12848306e-02f, -5.99597432e-02f, -3.52006666e-02f, 3.53533849e-02f, -1.72901884e-01f, 2.26156488e-02f, -1.72926113e-02f, -6.04195185e-02f,
  -6.26545921e-02f, 2.71257907e-02f, -6.45970330e-02f, -1.70664787e-01f, -5.77110499e-02f, 1.19547859e-01f, -1.16201048e-03f, 4.62721325e-02f, 5.18963151e-02f, -1.08815104e-01f,
  -5.51354606e-03f, 8.55255425e-02f, -2.11916286e-02f, 3.37916464e-02f, 4.07490134e-02f, -4.78611253e-02f, 6.28808290e-02f, 8.81473869e-02f, 5.32590039e-02f, -7.68345296e-02f,
  1.87079944e-02f, 1.11725293e-01f, -4.79222275e-02f, 1.69863794e-02f, 2.42925230e-02f, -5.56683354e-02f, 4.51696366e-02f, 6.10154159e-02f, 7.05557391e-02f, 9.06877667e-02f,
  6.20666146e-02f, 4.22905758e-02f, -5.89884520e-02f, 7.44824633e-02f, 5.26307058e-03f, -3.20056677e-02f, 1.05673037e-01f, 3.00880019e-02f, 4.93613556e-02f, -6.30072504e-02f,
  9.49568003e-02f, -3.35132964e-02f, 5.03323562e-02f, 7.73934498e-02f, 4.21549892e-03f, -1.79366469e-02f, -2.41851173e-02f, 5.29701039e-02f, -7.39644188e-03f, 7.67293647e-02f,
  3.90886562e-03f, 1.51302479e-02f, 1.55369258e-02f, 6.75191125e-03f, 8.54588225e-02f, 3.59415002e-02f, 1.00026816e-01f, 9.24476162e-02f, 2.70598903e-02f, 6.24258397e-03f,
  4.32326794e-02f, -3.64622548e-02f, 6.90702647e-02f, -2.75415815e-02f, 3.30588445e-02f, -7.17830583e-02f, -7.19339028e-02f, -1.20910062e-02f, -6.15677536e-02f, -1.26333404e-02f,
  8.39428380e-02f, 4.81882095e-02f, 7.17679933e-02f, 4.35405076e-02f, 1.17161684e-01f, 3.09521221e-02f, -6.04949426e-03f, 2.14309357e-02f, 3.50036100e-02f, 8.50525200e-02f,
  -2.01299172e-02f, -2.10903622e-02f, 1.24067225e-01f, 5.48265725e-02f, -3.39352265e-02f, -4.29552868e-02f, 1.36663884e-01f, -8.01298544e-02f, 3.74489687e-02f, -7.83598125e-02f,
  9.86067206e-02f, -1.81125402e-02f, -3.93365696e-02f, -8.38373005e-02f, -3.41995545e-02f, -5.58631383e-02f, -4.06186320e-02f, -3.96290347e-02f, -1.03601992e-01f, 6.90403730e-02f,
  1.07117720e-01f, -8.38866234e-02f, 3.17816511e-02f, -1.21533632e-01f, -1.91872474e-02f, -4.47969156e-04f, 6.73039481e-02f, -2.60566603e-02f, 3.69219705e-02f, -9.68995690e-03f,
  8.51941183e-02f, 2.68182922e-02f, 1.78886905e-01f, -2.71220841e-02f, -1.14855021e-01f, -8.51463154e-02f, -3.17350775e-02f, 2.07519643e-02f, 9.25738662e-02f, -3.30728409e-03f,
  -6.00106083e-02f, -1.10473134e-01f, 1.23348765e-01f, 4.10529748e-02f, 3.58378254e-02f, -1.16794884e-01f, -2.05732454e-02f, -8.64485055e-02f, -4.42569330e-02f, 4.17552097e-03f,
  -9.69385505e-02f, -1.44476052e-02f, -2.12672576e-02f, 5.56566752e-02f, 9.51480269e-02f, 9.62354243e-02f, 1.55513408e-02f, -5.64200729e-02f, 6.02969229e-02f, 6.01416565e-02f,
  6.27338141e-02f, -2.12832284e-03f, 2.34136768e-02f, -1.74232270e-03f, -6.17278330e-02f, -6.55215457e-02f, 5.69238439e-02f, -4.85046320e-02f, 1.42144859e-02f, -2.36274693e-02f,
  -5.58487959e-02f, -9.34113413e-02f, -6.03788644e-02f, -4.38148528e-03f, -8.17845911e-02f, -3.82568240e-02f, 2.90715136e-02f, -9.57767665e-02f, 2.05931645e-02f, -4.15987894e-02f,
  -5.52139021e-02f, 1.31579310e-01f, 1.03079773e-01f, 2.21144315e-02f, -7.45435506e-02f, 1.65285692e-02f, 7.06584528e-02f, -6.35920167e-02f, 7.74886161e-02f, 6.13427758e-02f,
  3.31103839e-02f, -5.42239510e-02f, -4.80680540e-02f, 9.74638909e-02f, -5.58806472e-02f, 6.61436766e-02f, 1.90225001e-02f, -6.17410475e-03f, 1.93479750e-02f, -7.78083503e-02f,
  2.07527280e-02f, -3.64929438e-02f, -8.30028281e-02f, 4.11116444e-02f, 4.77048159e-02f, 8.23695399e-03f, 8.77663419e-02f, -1.52686602e-02f, -5.55538274e-02f, -1.40361087e-02f,
  5.37045747e-02f, 6.67939335e-02f, 2.55267899e-02f, -5.21202746e-04f, 2.36416385e-02f, -4.46567573e-02f, 6.51618242e-02f, -2.04021987e-02f, -2.35207696e-02f, 2.42950916e-02f,
  -7.21298978e-02f, -7.00462908e-02f, 1.56707559e-02f, -7.59688765e-02f, -2.10936312e-02f, -6.95360824e-02f, -1.64380725e-02f, 5.80676497e-05f, 3.08190174e-02f, -7.46825486e-02f,
  4.19652201e-02f, 9.39161032e-02f, -6.89807832e-02f, 2.01952830e-03f, 7.59062916e-02f, -3.39396819e-02f, 4.05231789e-02f, -5.74156307e-02f, -5.57655282e-02f, 1.09155960e-01f,
  8.82994831e-02f, -7.78914988e-02f, 2.54234066e-03f, -2.80857310e-02f, -9.60776657e-02f, 7.40002990e-02f, 8.95057339e-03f, -3.29447282e-03f, -9.52476934e-02f, 2.64907647e-02f,
  6.31657764e-02f, -6.63265064e-02f, -4.29151356e-02f, 6.86498433e-02f, -8.99243727e-02f, -9.48664621e-02f, -8.50824639e-02f, 8.01723567e-04f, 7.44180232e-02f, -8.89831930e-02f,
  -9.87153575e-02f, 8.97261221e-03f, 6.43784851e-02f, -1.79653633e-02f, 5.88020273e-02f, 5.39850369e-02f, 9.59404707e-02f, -6.57970905e-02f, 2.70540919e-02f, 6.37562573e-02f,
  2.84224912e-03f, -9.75284949e-02f, 8.32095221e-02f, 2.94000804e-02f, 4.56825048e-02f, 6.97760731e-02f, -8.60362574e-02f, -3.65986191e-02f, 7.40505755e-02f, -1.80418193e-02f,
  1.68582462e-02f, 4.37393971e-02f, 2.56364923e-02f, 8.98045604e-04f, -5.80698717e-03f, -2.59620752e-02f, 1.58419404e-02f, -2.37242263e-02f, 6.33414537e-02f, 3.95377167e-03f,
  5.13300486e-02f, 9.97111350e-02f, -7.20752552e-02f, -1.91971324e-02f, 8.86168405e-02f, -2.59953812e-02f, -7.17570037e-02f, 4.28178273e-02f, -4.46912050e-02f, 3.89729887e-02f,
  -7.17265978e-02f, 7.69640207e-02f, 7.70517290e-02f, 1.30489189e-02f, 2.64886729e-02f, -9.09851566e-02f, 1.08549809e-02f, -3.52783278e-02f, 3.01083550e-02f, -6.48725107e-02f,
  -2.50999462e-02f, 7.33884126e-02f, 4.34100442e-02f, 7.94822723e-02f, 3.50048617e-02f, -6.83064088e-02f, 2.82895882e-02f, 6.27258644e-02f, 7.07252845e-02f, 6.74784705e-02f,
  -2.75933985e-02f, -1.61118421e-03f, 5.19452244e-02f, 8.16684514e-02f, 1.52995521e-02f, -5.54862469e-02f, 4.41478528e-02f, 3.23868878e-02f, -7.42815062e-02f, 1.81859650e-03f,
  -7.64673799e-02f, 3.48082222e-02f, 7.67914439e-03f, 3.55912335e-02f, -7.35701770e-02f, 1.12794191e-02f, 9.56159160e-02f, 8.24081525e-02f, -3.85845196e-04f, -4.93537374e-02f,
  8.96060020e-02f, -2.18430702e-02f, 1.41292010e-02f, -6.74842298e-02f, 3.88548784e-02f, 4.90023270e-02f, -6.15095980e-02f, 8.17423686e-02f, 8.39489996e-02f, 7.48270005e-02f,
  8.93341228e-02f, -5.91301881e-02f, 3.44270319e-02f, -6.22069873e-02f, -4.13963869e-02f, 7.06070513e-02f, 6.79924563e-02f, -5.51330931e-02f, -6.59817830e-02f, 4.81288619e-02f,
  -5.88243008e-02f, -5.82300462e-02f, 2.96535599e-03f, -1.64318364e-03f, 6.27916157e-02f, 1.88602973e-02f, -9.03039724e-02f, 7.13990107e-02f, -5.35433218e-02f, 9.62887052e-03f,
  4.87188213e-02f, 3.41542102e-02f, -6.20664172e-02f, -2.10371725e-02f, -1.82415005e-02f, -4.84130047e-02f, -6.70837015e-02f, 6.15426488e-02f, -6.22921772e-02f, 2.78610699e-02f,
  7.38192641e-04f, 4.34299596e-02f, -6.64884895e-02f, -7.57359862e-02f, 9.69493538e-02f, 5.48406951e-02f, -7.43959025e-02f, -1.01107746e-01f, -5.40433973e-02f, 8.71269703e-02f,
  7.66621679e-02f, -4.75172959e-02f, 2.03074813e-02f, -2.47053206e-02f, -1.01940617e-01f, -1.28760850e-02f, -2.69731879e-02f, 6.62078708e-02f, -7.81530589e-02f, 4.83554304e-02f,
  7.59631619e-02f, -7.45366793e-03f, 7.12052220e-03f, -1.99502989e-04f, 4.30011265e-02f, 6.85377046e-02f, -3.27193439e-02f, 3.77691872e-02f, -6.78331731e-03f, -2.99403444e-02f,
  1.25901885e-02f, 1.48662683e-02f, 1.52774071e-02f, -2.90210694e-02f, 3.66317555e-02f, -5.93675338e-02f, -1.37179652e-02f, 5.44187836e-02f, 1.40761761e-02f, 6.10509235e-03f,
  -7.25663453e-02f, 2.29115095e-02f, 9.24945027e-02f, 3.78451087e-02f, 8.77837688e-02f, -6.79521710e-02f, -1.90059450e-02f, -4.84723113e-02f, 7.06171170e-02f, -2.26461068e-02f,
  -7.48521388e-02f, 1.40758594e-02f, 3.01909167e-02f, 5.55915982e-02f, 9.36218426e-02f, -5.99523932e-02f, -7.71370977e-02f, -6.40543401e-02f, 5.69387227e-02f, -6.75383210e-02f,
  -6.55817538e-02f, 8.77934918e-02f, -3.24206091e-02f, 6.03568479e-02f, -5.55267110e-02f, 8.31440911e-02f, -4.40472551e-02f, 1.88314971e-02f, 4.28699628e-02f, -3.67059782e-02f,
  4.13779803e-02f, -1.04749706e-02f, 5.32254279e-02f, 1.55360287e-03f, 2.84486953e-02f, 1.10134676e-01f, 2.30680406e-02f, -2.58742869e-02f, -1.11174397e-02f, -6.69995099e-02f,
  2.36864928e-02f, -9.56921466e-03f, 9.43029020e-03f, -2.30671950e-02f, 1.00305669e-01f, 1.02411307e-01f, -3.05891931e-02f, 2.83751041e-02f, -5.27095310e-02f, -6.67296797e-02f,
  7.44809285e-02f, 3.13939340e-02f, -7.89736286e-02f, 6.66766837e-02f, 4.03559618e-02f, -6.38306960e-02f, 2.83150375e-03f, -2.67687924e-02f, -7.12832250e-03f, -4.88022668e-03f,
  6.61994815e-02f, 4.10318300e-02f, 9.13504362e-02f, 8.98607597e-02f, 8.28084163e-03f, 7.63052031e-02f, 1.00735761e-01f, -2.56830733e-02f, 7.87643343e-02f, 1.17793925e-01f,
  6.30521178e-02f, 4.83095832e-02f, 1.43869901e-02f, 2.85625663e-02f, -1.13060832e-01f, -8.99160560e-03f, 6.36155829e-02f, -7.12286159e-02f, -7.94626027e-02f, -9.52822939e-02f,
  4.24418412e-03f, 1.18013145e-02f, 7.88151696e-02f, 1.29868954e-01f, -4.29432467e-02f, -2.15288065e-02f, 1.52326026e-03f, -2.04408392e-02f, 9.28272381e-02f, -8.57853815e-02f,
  -7.71946386e-02f, -4.91779037e-02f, -5.76595291e-02f, 8.17995593e-02f, 9.14764125e-03f, 5.95460758e-02f, -4.81492840e-02f, -2.32898034e-02f, 5.17455041e-02f, 3.11739948e-02f,
  4.55054119e-02f, 5.24431542e-02f, -3.07336561e-02f, 1.06369957e-01f, -9.76393893e-02f, 8.76271054e-02f, -4.92329933e-02f, -1.27380192e-01f, -2.91907769e-02f, -9.06023830e-02f,
  -4.39561643e-02f, 2.60370690e-02f, 3.74154001e-02f, 6.12235218e-02f, -5.26167601e-02f, -1.76638383e-02f, -5.00533618e-02f, -1.42859556e-02f, 5.60181513e-02f, -1.02458037e-02f,
  6.02558590e-02f, 5.72803104e-03f, -4.54907678e-03f, -7.11967945e-02f, -2.65203603e-02f, 8.03831816e-02f, -3.93683612e-02f, -7.41283149e-02f, 6.97915033e-02f, 4.78884764e-02f,
  -8.08366314e-02f, 7.19203353e-02f, -5.76873077e-03f, -2.02495586e-02f, -5.11472337e-02f, -3.79185192e-02f, -1.02905380e-02f, 2.70248745e-02f, 3.89091745e-02f, 5.82571924e-02f,
  -6.00080937e-04f, 4.75437418e-02f, -4.36935909e-02f, 5.01683205e-02f, 4.36269902e-02f, -4.38846909e-02f, -6.53119162e-02f, -8.88757482e-02f, 8.98074210e-02f, 2.33225822e-02f,
  5.30570820e-02f, 6.15069531e-02f, 6.75335824e-02f, 2.92618889e-02f, 4.98737488e-03f, 3.12345512e-02f, 1.03206430e-02f, -3.31055187e-02f, 1.27642661e-01f, 5.12868017e-02f,
  8.24631751e-02f, 1.01938091e-01f, -4.03800681e-02f, 1.11919314e-01f, 5.28404079e-02f, 2.65227091e-02f, 1.18330806e-01f, 1.71593111e-03f, 8.34073988e-04f, -2.57782415e-02f,
  4.68238965e-02f, -2.87798326e-02f, 8.13300833e-02f, 6.43596351e-02f, -1.35685662e-02f, 1.00528449e-01f, -2.21521296e-02f, 2.80360542e-02f, -2.60970872e-02f, -6.87130028e-03f,
  9.67498794e-02f, 2.28680801e-02f, 7.57693797e-02f, 1.30426615e-01f, -6.91863298e-02f, 7.08387196e-02f, -5.65213822e-02f, 1.45689338e-01f, 1.64163709e-01f, 8.77722427e-02f,
  1.09425835e-01f, -3.35944779e-02f, -1.36628700e-02f, 1.07636064e-01f, 1.08400933e-01f, -4.70264954e-03f, 1.58273429e-01f, 8.29869360e-02f, 2.40376797e-02f, 1.54836327e-01f,
  8.32377654e-03f, 1.17067032e-01f, -1.10774107e-01f, -6.34478778e-02f, -1.41920513e-02f, 1.08245641e-01f, 2.38601100e-02f, 1.08080819e-01f, -4.52519357e-02f, 2.48969309e-02f,
  1.34670034e-01f, 1.01055317e-01f, -3.24278488e-03f, 1.31642073e-01f, -3.19634825e-02f, -9.34553274e-04f, -6.60111615e-03f, 1.40616670e-01f, -2.40637176e-02f, 1.18004955e-01f,
  -5.33844605e-02f, 1.92748159e-01f, -6.95792735e-02f, 2.99239834e-03f, 1.99651178e-02f, 9.35797244e-02f, 8.79415944e-02f, 1.04681954e-01f, -2.41780672e-02f, 1.19303480e-01f,
  -2.35527381e-02f, 1.19394116e-01f, 1.21539757e-01f, 4.85923700e-02f, 5.24491221e-02f, -1.28704190e-01f, -1.35062829e-01f, -1.26047686e-01f, -6.51553646e-02f, -5.30145317e-02f,
  6.71980977e-02f, 2.71207411e-02f, -9.73563790e-02f, -1.09938934e-01f, 1.58799991e-01f, 1.39088765e-01f, 1.42344818e-01f, -6.26640171e-02f, 3.42767946e-02f, 1.36967972e-01f,
  3.28914970e-02f, 6.08061887e-02f, -4.13716547e-02f, -5.49743325e-02f, -3.32840122e-02f, -1.07881464e-01f, -1.72179993e-02f, -5.95808625e-02f, -8.91800970e-03f, -6.96367919e-02f,
  -1.19479280e-02f, 1.16694113e-02f, -7.05585852e-02f, -5.21483049e-02f, 8.00108463e-02f, -6.46339776e-03f, 8.10073763e-02f, 7.89994821e-02f, 6.82976246e-02f, 8.88208859e-03f,
  -1.87949371e-02f, -3.12047470e-02f, 1.73576903e-02f, -1.03131235e-01f, 9.07525420e-03f, 3.86515260e-02f, 9.38791707e-02f, -2.04862822e-02f, 2.73792408e-02f, 3.89956981e-02f,
  -9.36061423e-03f, 9.17532295e-02f, -1.70974657e-02f, 4.70018536e-02f, 4.25386019e-02f, 1.40608788e-01f, 8.42772275e-02f, 1.31933227e-01f, 8.29317719e-02f, -1.34085361e-02f,
  4.54005413e-02f, -4.11785394e-02f, 9.85176191e-02f, 1.06262662e-01f, 3.61099131e-02f, -3.81422825e-02f, 7.59473145e-02f, -3.65935713e-02f, -2.05648709e-02f, -8.43216851e-02f,
  -4.64076437e-02f, 3.06398105e-02f, 3.33166011e-02f, -6.10574186e-02f, 7.05886707e-02f, -8.34564306e-03f, 1.01506397e-01f, 3.69810462e-02f, -8.24276209e-02f, -3.91534306e-02f,
  5.77017330e-02f, -6.21783640e-03f, 6.99576959e-02f, 5.28108366e-02f, -6.92892447e-02f, 7.16127530e-02f, 3.46098058e-02f, 9.47421789e-02f, 1.64559782e-02f, -8.90550856e-03f,
  3.79191600e-02f, 2.85367444e-02f, 8.73572379e-02f, 1.25788897e-01f, -3.21156457e-02f, -1.30598256e-02f, -1.98195800e-02f, 1.35572888e-02f, -6.58523440e-02f, 5.27094714e-02f,
  7.75252357e-02f, -1.27352998e-01f, 2.31465604e-02f, -3.80398184e-02f, 3.91492434e-02f, -4.30423059e-02f, -3.18241157e-02f, -1.12914339e-01f, 3.34069245e-02f, 1.18428499e-01f,
  7.67589658e-02f, -2.06174292e-02f, 7.70632103e-02f, -9.63205248e-02f, 7.03835413e-02f, -5.12215160e-02f, -1.17546916e-02f, 5.25459051e-02f, -1.23237826e-01f, -8.88275281e-02f,
  5.91031127e-02f, -1.60816927e-02f, 7.94881433e-02f, -6.16737176e-03f, 1.46453381e-01f, 6.94259331e-02f, 9.04671475e-02f, 3.08403838e-02f, 6.50385320e-02f, 4.76031266e-02f,
  3.16509195e-02f, -4.12589610e-02f, 3.19473259e-02f, 2.73554996e-02f, -3.84339765e-02f, -7.89695606e-02f, 1.35568291e-01f, -6.72824532e-02f, -1.79810580e-02f, -1.24307759e-01f,
  -5.05370228e-03f, 5.29554412e-02f, -8.46530050e-02f, 7.34458566e-02f, -6.37451485e-02f, 1.05142809e-01f, -9.87484455e-02f, -5.72956018e-02f, 1.42616048e-01f, 9.83135030e-02f,
  7.50369653e-02f, 6.66875988e-02f, 2.41439659e-02f, 6.79584593e-02f, 4.92888084e-03f, 9.87020954e-02f, 7.12150708e-02f, -1.42433643e-02f, 6.95353895e-02f, 8.09662417e-03f,
  -3.71196158e-02f, -5.21448329e-02f, -1.07324368e-03f, -6.67131841e-02f, 7.05988556e-02f, -1.05640091e-01f, 5.70963062e-02f, -2.74336077e-02f, 8.15976411e-02f, 1.13019235e-01f,
  -9.76512302e-03f, -6.25427738e-02f, 8.60235542e-02f, -1.67087335e-02f, 8.89919326e-02f, 6.56948686e-02f, 7.07851276e-02f, -4.72925752e-02f, 8.52519944e-02f, 1.14230990e-01f,
  -5.58710583e-02f, 2.17078961e-02f, -3.97456437e-02f, -2.81810332e-02f, -5.01894094e-02f, 8.35075974e-02f, 4.58293073e-02f, 5.49158230e-02f, 2.14467961e-02f, 3.10717542e-02f,
  6.36896566e-02f, 1.03756441e-02f, 6.18532635e-02f, 2.28331629e-02f, 5.41023761e-02f, 3.18728127e-02f, -6.62535056e-03f, -1.79508664e-02f, 7.87115395e-02f, 4.08879593e-02f,
  5.62119111e-02f, 4.42134477e-02f, 3.80341597e-02f, 1.08476683e-01f, -1.91991832e-02f, 6.10560551e-02f, 3.92694771e-02f, 9.74823833e-02f, 6.11127429e-02f, 8.08279291e-02f,
  -8.72182194e-03f, 1.45322112e-02f, 6.77737780e-03f, -2.74181683e-02f, 6.78237006e-02f, 2.71735061e-02f, 3.38265598e-02f, 4.88568172e-02f, 1.43619403e-01f, 7.19580948e-02f,
  6.61073402e-02f, -7.80386571e-03f, 1.19349904e-01f, 1.68089662e-02f, 5.77176921e-02f, -9.62125137e-02f, 9.64706838e-02f, 9.15759206e-02f, 3.75300236e-02f, -1.02079343e-02f,
  -1.47244185e-01f, 9.51739624e-02f, -4.65913154e-02f, 1.42255887e-01f, -1.09677255e-01f, -3.93164121e-02f, -6.28605708e-02f, 1.27438297e-02f, 2.12653503e-02f, 5.98097481e-02f,
  7.36317486e-02f, 8.94381329e-02f, 2.29552407e-02f, 5.94645701e-02f, -1.99126750e-02f, -1.08275369e-01f, 6.49707764e-02f, 1.02522306e-01f, -3.00345924e-02f, -3.87910530e-02f,
  3.67875136e-02f, 1.21026777e-01f, -3.40508893e-02f, -6.85685724e-02f, 2.85795014e-02f, 1.24446936e-01f, -5.87602668e-02f, 2.88352873e-02f, 9.38599482e-02f, 8.52698758e-02f,
  -1.18245393e-01f, -5.28671332e-02f, -1.24522224e-01f, -7.62762502e-02f, -5.43354824e-02f, -2.07691565e-02f, 4.40368801e-02f, 1.66398194e-02f, -7.83975124e-02f, 7.31689483e-02f,
  -1.45462096e-01f, 4.32852060e-02f, 1.74761433e-02f, -4.24455777e-02f, 1.26666248e-01f, 9.43609923e-02f, 3.32145318e-02f, -4.68647778e-02f, -5.97769134e-02f, 8.31619203e-02f,
  -2.45110206e-02f, -4.70604263e-02f, -1.68085713e-02f, -6.69618994e-02f, -9.55353007e-02f, 6.08720444e-02f, -7.68011659e-02f, 9.97047499e-03f, -6.29882291e-02f, -1.03306975e-02f,
  1.82486866e-02f, -1.85279511e-02f, -3.82311530e-02f, -1.49742840e-02f, -2.01178752e-02f, 5.58098480e-02f, 4.31505144e-02f, 2.67730001e-02f, 5.48273511e-03f, -5.72273768e-02f,
  -5.29576652e-02f, -2.90437564e-02f, 4.20231111e-02f, 9.85196047e-03f, 1.25848517e-01f, 2.38712486e-02f, 1.29825041e-01f, -3.48237599e-03f, -2.16605160e-02f, -1.46727776e-02f,
  9.58093405e-02f, 6.54058065e-03f, -3.45681272e-02f, 6.63089007e-02f, 7.28297681e-02f, -5.24443574e-02f, 3.06357071e-02f, 3.06533724e-02f, 6.36346787e-02f, 6.76970780e-02f,
  1.61392149e-02f, -1.87221393e-02f, 8.52162987e-02f, 6.06806688e-02f, -3.81961726e-02f, 1.60790943e-02f, 2.67756023e-02f, 1.15419447e-01f, 9.59121212e-02f, -6.42813519e-02f,
  -2.46134065e-02f, 2.85994317e-02f, -8.15812871e-02f, 1.38283921e-02f, -8.20606649e-02f, -5.67904441e-03f, -1.38851563e-02f, -6.66091517e-02f, 9.05746594e-02f, 1.23483509e-01f,
  8.00642967e-02f, 4.51396480e-02f, 1.46217898e-01f, 9.72441435e-02f, 4.03360538e-02f, -2.28047948e-02f, 1.10168271e-01f, 9.87687409e-02f, 7.53112584e-02f, 1.16590567e-01f,
  3.81550267e-02f, 1.05956219e-01f, 8.91480520e-02f, 6.84849769e-02f, 3.37793678e-02f, 5.14604189e-02f, 1.24540448e-01f, 7.87303224e-02f, -4.19747457e-02f, -8.45012069e-02f,
  -4.92252819e-02f, -8.25563222e-02f, -3.48182283e-02f, 1.06604487e-01f, 7.91777018e-03f, -1.46969571e-03f, 1.48576312e-02f, -1.35867760e-01f, 1.01323679e-01f, 7.73686171e-02f,
  -5.67087457e-02f, -3.12764868e-02f, 5.70737496e-02f, 5.25132753e-02f, 7.21128732e-02f, 5.49190231e-02f, 3.89558561e-02f, -6.35392740e-02f, 8.48671868e-02f, -1.14322469e-01f,
  -1.18567862e-01f, -8.37966725e-02f, -6.67314511e-03f, -1.33721367e-01f, 1.15581982e-01f, -1.07546777e-01f, -2.01450661e-02f, -8.79251361e-02f, 2.14787293e-02f, -2.42498666e-02f,
  -2.29660384e-02f, 8.73055961e-03f, 2.36904472e-02f, -9.38734412e-02f, -1.58417612e-01f, -4.68778098e-03f, -4.70564291e-02f, -5.83429169e-03f, -2.67143250e-02f, 1.03739478e-01f,
  -4.39195260e-02f, 9.87525582e-02f, 5.53416880e-03f, -1.27972469e-01f, -4.79064472e-02f, 5.36677800e-02f, 1.14130219e-02f, 8.97908118e-03f, 3.22090723e-02f, 1.04290329e-01f,
  -4.48651984e-02f, 4.27137092e-02f, -3.26661766e-02f, -7.55450651e-02f, -4.62347977e-02f, 1.21321930e-02f, 1.95997488e-02f, 6.77472576e-02f, -7.46476203e-02f, 7.46147186e-02f,
  -1.47711923e-02f, -4.67013456e-02f, -3.81034464e-02f, -4.09545340e-02f, -7.84367397e-02f, -7.19122440e-02f, 7.08916336e-02f, 5.59795983e-02f, -7.53311142e-02f, -1.80007815e-02f,
  9.01759341e-02f, -3.96630503e-02f, 8.87655988e-02f, 4.52559965e-04f, 7.46666044e-02f, 2.22211331e-02f, 9.91778150e-02f, -2.63302494e-02f, -1.59870349e-02f, 6.98188394e-02f,
  -1.30850477e-02f, 2.68323459e-02f, 1.09265588e-01f, -5.50051779e-02f, -5.31246029e-02f, 2.23815255e-02f, 1.55509282e-02f, 5.91174923e-02f, 1.28819700e-02f, 4.81767766e-03f,
  3.57948430e-02f, 4.01426964e-02f, -7.43343979e-02f, 6.02754615e-02f, 3.63850333e-02f, -3.29447240e-02f, -5.83513901e-02f, 2.09339671e-02f, -4.44584526e-02f, -2.44292784e-02f,
  -4.62249890e-02f, -5.35974726e-02f, 9.78783588e-04f, 6.00695647e-02f, 6.16677701e-02f, 3.51126790e-02f, 1.34019613e-01f, 8.32744837e-02f, 2.47576716e-03f, -4.34448197e-02f,
  8.71261805e-02f, 9.76611003e-02f, -4.72840816e-02f, -4.43256125e-02f, 7.81424046e-02f, 9.63036437e-03f, -2.29346268e-02f, 6.41295984e-02f, -5.90691119e-02f, 7.30818361e-02f,
  1.11638606e-02f, -1.45575833e-02f, 1.81159619e-02f, 7.08120083e-03f, -3.34437564e-02f, 7.69200474e-02f, 2.75273137e-02f, -5.81456758e-02f, -2.50049401e-02f, 3.45879756e-02f,
  1.29830480e-01f, -2.97893081e-02f, -6.17315993e-02f, 6.64087087e-02f, 2.54503898e-02f, -4.52848561e-02f, -1.47614619e-02f, 5.27248234e-02f, 3.80668091e-03f, -5.96676096e-02f,
  -6.16982579e-02f, 6.49451315e-02f, -5.29025123e-02f, -1.06579706e-01f, 1.38633534e-01f, 8.43673497e-02f, 3.52386269e-03f, -1.37745872e-01f, 5.00256531e-02f, -6.84897229e-02f,
  3.50987464e-02f, -9.69084278e-02f, 7.33840168e-02f, -7.39151761e-02f, -1.03437617e-01f, 5.90493605e-02f, 8.44167098e-02f, 7.75936693e-02f, -3.46183106e-02f, -4.38224152e-03f,
  1.20189078e-02f, -4.87596132e-02f, -1.12747587e-01f, 3.49492840e-02f, 6.15426041e-02f, 6.28481880e-02f, -5.38356714e-02f, -1.32032661e-02f, -9.00798365e-02f, -2.13166922e-02f,
  -7.36432970e-02f, -1.11044668e-01f, 6.76368875e-03f, -1.60741992e-02f, 8.67527798e-02f, 8.76439456e-03f, 4.67995442e-02f, 8.37630108e-02f, 1.36984782e-02f, -7.41357505e-02f,
  -6.42572343e-02f, 2.04485152e-02f, 7.64278993e-02f, -2.04888470e-02f, -2.52378322e-02f, -2.92653628e-02f, 2.31977589e-02f, 5.96613213e-02f, -5.27901389e-02f, 4.43806611e-02f,
  -1.03855049e-02f, 8.57708156e-02f, 1.10850120e-02f, -1.72451735e-02f, 7.26098493e-02f, 1.38721153e-01f, -5.95656931e-02f, -2.06426792e-02f, 1.09988913e-01f, 1.44205699e-02f,
  -1.38273463e-02f, 1.68764312e-02f, 3.86097245e-02f, 1.10066514e-02f, 1.17529750e-01f, 1.06630504e-01f, 6.52578995e-02f, 3.80107537e-02f, 4.32522744e-02f, 3.44739519e-02f,
  -4.22310596e-03f, -2.50656847e-02f, 7.90006220e-02f, 5.38394190e-02f, 8.06513652e-02f, 1.13406545e-02f, 9.15907100e-02f, 1.24753073e-01f, 3.04647628e-03f, 6.63911924e-02f,
  1.14061944e-01f, 1.19027555e-01f, -1.51166087e-02f, -3.77582759e-02f, 7.92895705e-02f, 1.06518045e-01f, 5.35101369e-02f, 2.74812598e-02f, 1.31460400e-02f, 3.20675373e-02f,
  1.08251795e-01f, -1.39085883e-02f, 1.26496106e-01f, 1.46001250e-01f, -2.99819428e-02f, 3.91143523e-02f, 1.06914021e-01f, 4.50153388e-02f, -3.52228023e-02f, 1.44690126e-02f,
  7.41920024e-02f, 9.71843675e-02f, 8.39084834e-02f, 6.58131540e-02f, 1.01379342e-01f, -2.89673619e-02f, 2.67631058e-02f, -1.48214158e-02f, 1.17445678e-01f, -7.25070760e-03f,
  -9.95445102e-02f, -2.75478582e-03f, -2.88945120e-02f, 8.10566451e-03f, 3.82162593e-02f, 3.57369147e-02f, -4.43154052e-02f, 4.23849076e-02f, 1.29363239e-01f, -2.06426427e-01f,
  3.27926427e-02f, 7.32968599e-02f, -1.96840428e-02f, -2.92064510e-02f, -4.80359457e-02f, -4.43768576e-02f, 8.19148123e-03f, -9.53741372e-02f, -6.18468933e-02f, -1.81100834e-02f,
  -1.04883976e-01f, -1.08361259e-01f, 9.56019908e-02f, -2.22386643e-02f, 1.41898483e-01f, 3.88948731e-02f, 9.47017372e-02f, -2.96792574e-03f, 1.02987230e-01f, -3.14990170e-02f,
  -1.29242837e-01f, 8.55216533e-02f, -4.68593724e-02f, 1.16851747e-01f, -3.53173935e-03f, 2.24623885e-02f, 4.87731993e-02f, -9.30790305e-02f, 1.83178689e-02f, 3.56333442e-02f,
  -3.80680114e-02f, -3.56047526e-02f, -4.77911122e-02f, 2.60133836e-02f, -7.46260881e-02f, -1.67381912e-01f, 8.17347243e-02f, -1.30368680e-01f, -1.77529454e-01f, -1.60464481e-01f,
  7.35589638e-02f, -8.80229753e-03f, 7.07809522e-04f, -5.78317456e-02f, 7.59508386e-02f, -8.36290792e-02f, -1.36896223e-03f, 3.47055197e-02f, -3.73316295e-02f, -5.56358136e-02f,
  -9.17350203e-02f, -5.66785596e-02f, 3.65161113e-02f, 9.10504833e-02f, -3.41396108e-02f, -3.12460028e-03f, 9.82295815e-03f, -3.44037600e-02f, -1.10495342e-02f, 4.47411649e-02f,
  -4.01958302e-02f, -2.52401922e-02f, 2.32480224e-02f, -2.52168579e-03f, -6.16795719e-02f, -2.09309701e-02f, 8.37903395e-02f, -6.08774694e-03f, -1.81136839e-02f, -5.38224056e-02f,
  -5.97379766e-02f, -3.79071967e-03f, -3.20158564e-02f, -1.51179451e-02f, -4.99324240e-02f, 6.63959309e-02f, -6.13980554e-02f, -9.11342502e-02f, -4.61750180e-02f, 7.22296759e-02f,
  -3.32179144e-02f, -4.60043065e-02f, 2.30902992e-02f, -2.34804209e-02f, 8.44212249e-02f, 4.61754315e-02f, 6.74498230e-02f, -8.07033945e-03f, -1.90135036e-02f, 2.54330151e-02f,
  -6.66085333e-02f, 6.34117573e-02f, 5.13586290e-02f, 3.31138931e-02f, -1.93211660e-02f, 3.71632017e-02f, -1.75874047e-02f, -4.20980342e-02f, -1.43237589e-02f, 3.98505144e-02f,
  5.79351410e-02f, 2.91928556e-02f, 1.07896840e-02f, 3.87076586e-02f, 7.00121513e-03f, 5.93784042e-02f, -2.92401649e-02f, 8.73790085e-02f, 3.09773125e-02f, -5.55756614e-02f,
  2.60010362e-02f, -6.53352402e-03f, 9.80845913e-02f, 8.69095102e-02f, 4.09472175e-02f, -5.24057001e-02f, -4.02924195e-02f, 6.07231185e-02f, -6.32788017e-02f, 1.02911048e-01f,
  -7.40970820e-02f, 7.22166747e-02f, -4.27203253e-02f, 5.58814034e-02f, 9.86584462e-03f, 6.74987435e-02f, 1.21254018e-02f, -5.39294233e-05f, -8.33075717e-02f, -3.17459032e-02f,
  8.35068524e-02f, 3.77154276e-02f, -8.46333727e-02f, 1.06913388e-01f, 9.74130481e-02f, 5.60448840e-02f, 1.01541601e-01f, 3.47235985e-02f, 4.21162769e-02f, -3.93112749e-02f,
  9.88892652e-03f, 5.69730550e-02f, 9.20545682e-03f, 3.42081971e-02f, -8.00218880e-02f, -5.19187041e-02f, -6.61677048e-02f, -8.26739520e-02f, -1.41169271e-02f, -1.52676301e-02f,
  1.61318835e-02f, -1.13810115e-02f, 1.00589551e-01f, 7.39499256e-02f, -5.07053770e-02f, -5.12284636e-02f, -4.81031537e-02f, -4.27691638e-02f, 7.77641758e-02f, 9.49345678e-02f,
  5.76036274e-02f, 5.67252785e-02f, -4.67911512e-02f, 8.84892792e-02f, -5.53572886e-02f, -2.85807606e-02f, -3.93396430e-02f, 1.02124684e-01f, -9.59469453e-02f, -7.60166571e-02f,
  -2.50309762e-02f, 6.55043796e-02f, -7.21676052e-02f, -9.08400342e-02f, 7.84396604e-02f, 4.04587723e-02f, 7.77877634e-03f, -3.03770546e-02f, -7.42021948e-03f, -2.63973959e-02f,
  -6.54500648e-02f, -7.10483119e-02f, -3.33173946e-02f, -3.95182986e-03f, 1.47290332e-02f, -6.33625686e-02f, -5.99183664e-02f, 9.70450640e-02f, 3.58594507e-02f, 1.45888273e-02f,
  -2.13741809e-02f, 1.89090110e-02f, 5.22477552e-02f, -2.27016378e-02f, -1.54833905e-02f, 4.12766598e-02f, -1.10116648e-02f, -1.55476304e-02f, 3.80554162e-02f, 5.80460057e-02f,
  7.14370459e-02f, 4.20231670e-02f, 5.95590333e-03f, -6.88401759e-02f, 8.05992559e-02f, -7.46798441e-02f, -2.22163857e-03f, 8.60248432e-02f, -4.68836017e-02f, -2.24397518e-02f,
  4.48030839e-03f, -2.55284924e-02f, 7.46240420e-03f, -5.73461168e-02f, 1.01138437e-02f, -3.49720344e-02f, -5.52536175e-03f, -1.41008198e-02f, 3.16256806e-02f, 4.45036851e-02f,
  -4.61095534e-02f, 3.45252338e-03f, -4.84143496e-02f, 7.54532218e-02f, -1.84685756e-02f, 2.25369874e-02f, 5.86629808e-02f, -3.74682099e-02f, -1.14298975e-02f, -5.64108193e-02f,
  3.89044546e-02f, 3.91935511e-03f, 8.20115730e-02f, 2.69162469e-02f, 1.57429837e-02f, 8.27883855e-02f, 2.86624245e-02f, 2.35923640e-02f, 5.96345030e-02f, 9.07020345e-02f,
  -4.21352088e-02f, -4.35319655e-02f, 4.23019305e-02f, 4.45285812e-02f, -2.13360228e-02f, -1.04962997e-01f, -4.14706953e-02f, 9.14989412e-02f, -5.76292165e-02f, -7.22169057e-02f,
  4.56769243e-02f, 4.75653745e-02f, 9.20428187e-02f, -7.46442527e-02f, -1.08270496e-02f, -4.97827679e-02f, -4.62678373e-02f, -1.59210395e-02f, 2.06229743e-02f, 1.99811663e-02f,
  5.44601791e-02f, 4.82455753e-02f, -1.76225863e-02f, -2.21515447e-02f, -4.39471565e-02f, 8.58445093e-03f, 1.22246724e-02f, -5.78918681e-03f, -1.06388435e-01f, -5.30596077e-02f,
  -5.49924634e-02f, -1.47532038e-02f, -2.08348557e-02f, -8.66263285e-02f, -4.24274430e-02f, -1.70263778e-02f, 6.84768409e-02f, -2.78987959e-02f, -7.75840282e-02f, -1.44931618e-02f,
  -4.74937446e-02f, 2.39403956e-02f, -2.21281331e-02f, 1.04518093e-01f, -2.24772580e-02f, -3.72336283e-02f, 8.27814490e-02f, -4.83897738e-02f, -2.31313985e-02f, 1.03963614e-01f,
  8.64112228e-02f, -1.67564787e-02f, 8.36161524e-02f, -8.42152610e-02f, 9.38086063e-02f, 1.41087875e-01f, -7.47834444e-02f, -5.69394566e-02f, 6.61109090e-02f, 5.19209094e-02f,
  -4.64158282e-02f, -7.67001510e-02f, 4.38058041e-02f, -2.24138498e-02f, 4.95697111e-02f, 5.27494363e-02f, 8.25894028e-02f, -1.45561306e-03f, 7.24125803e-02f, 8.14526454e-02f,
  8.15724675e-03f, -8.03736970e-02f, -8.78697261e-02f, -1.71985552e-02f, 1.04002349e-01f, 1.88288540e-02f, 7.50510916e-02f, 3.92585546e-02f, 7.34756291e-02f, 3.34024876e-02f,
  -1.67068886e-03f, 5.01370728e-02f, 2.15117037e-02f, -2.98649874e-02f, -7.48681948e-02f, -5.60719147e-03f, 8.77337009e-02f, 9.13084969e-02f, 8.18489715e-02f, 1.01611137e-01f,
  8.70638564e-02f, -3.97328585e-02f, 7.32173622e-02f, -3.26853059e-02f, 3.29986736e-02f, 2.07497533e-02f, 5.06421514e-02f, 8.72576088e-02f, -3.48720178e-02f, 2.07418408e-02f,
  1.19087197e-01f, 6.94696680e-02f, 3.42851467e-02f, 8.46234933e-02f, 7.15365559e-02f, -9.44999140e-03f, 5.81478253e-02f, -2.14615893e-02f, 7.74843097e-02f, -6.92738742e-02f,
  8.70108604e-02f, 3.40282470e-02f, -4.25624400e-02f, -4.27984865e-03f, 7.84581304e-02f, 4.45951382e-03f, -6.46147579e-02f, -2.03815848e-03f, 6.70161396e-02f, -4.32372093e-02f,
  7.51719996e-02f, 9.80630964e-02f, 2.98778135e-02f, -5.47891520e-02f, -5.27780764e-02f, -4.80088256e-02f, 6.45077229e-03f, 6.55351803e-02f, 8.63864738e-03f, 7.90963620e-02f,
  2.67887171e-02f, 1.10684544e-01f, 2.30550282e-02f, -7.09802359e-02f, -1.12397652e-02f, -1.08316481e-01f, -1.32145798e-02f, 4.07940745e-02f, -4.11379077e-02f, 1.70258060e-02f,
  9.92447436e-02f, 2.97523737e-02f, -1.41904041e-01f, 6.76088408e-02f, 9.45511162e-02f, 3.34411561e-02f, -5.60174733e-02f, -1.37667000e-01f, 9.02445242e-02f, 4.80767749e-02f,
  1.09062023e-01f, -7.31538087e-02f, -6.14178963e-02f, 1.09742098e-01f, -7.60680586e-02f, -1.65251736e-02f, 2.64297761e-02f, 1.16492748e-01f, -6.90110102e-02f, -8.94847810e-02f,
  4.93903598e-03f, 7.74267390e-02f, 3.29776667e-02f, -8.07260647e-02f, 3.80044803e-02f, -1.13016590e-01f, -1.19821258e-01f, -1.09070770e-01f, 4.37018881e-03f, -1.45871446e-01f,
  2.77841631e-02f, 4.49029356e-02f, -1.84274931e-02f, 3.20477821e-02f, -1.37122557e-01f, 3.93912382e-02f, -1.42302752e-01f, -1.55362755e-01f, -2.34872345e-02f, 1.67449653e-01f,
  -8.26879442e-02f, 5.82426675e-02f, -7.48901591e-02f, -2.95274262e-03f, -8.33504051e-02f, 8.61818194e-02f, 2.12313118e-03f, 6.20915089e-05f, 8.85700285e-02f, -6.43855780e-02f,
  2.65833065e-02f, 5.30473404e-02f, -7.93207735e-02f, 4.09133136e-02f, -5.11457361e-02f, -9.25556850e-03f, -9.57957506e-02f, 1.73177477e-02f, -1.07223623e-01f, 3.15029249e-02f,
  6.39720559e-02f, -5.57892676e-03f, -1.01714261e-01f, -2.78745908e-02f, -2.27630455e-02f, -5.58100007e-02f, 1.83908977e-02f, -4.88893017e-02f, 3.68416347e-02f, 5.84644526e-02f,
  4.28993255e-02f, -1.81054790e-02f, 1.31391272e-01f, 6.77964687e-02f, 5.60900606e-02f, 9.42253172e-02f, 9.41273347e-02f, 1.27380136e-02f, 1.07377127e-01f, 1.03369288e-01f,
  -3.22754346e-02f, 2.89526843e-02f, 5.97626753e-02f, 1.50040969e-01f, 1.02963462e-01f, -8.55794363e-03f, 8.15630406e-02f, 1.14731543e-01f, 9.55518037e-02f, 9.95605215e-02f,
  4.48375475e-03f, 1.08607253e-02f, -6.94056228e-02f, -3.32414667e-04f, 1.43457696e-01f, 1.91804152e-02f, 6.49362132e-02f, 5.41624725e-02f, 5.28027378e-02f, -1.25540411e-02f,
  -4.39767353e-02f, -8.24492797e-03f, 3.41832787e-02f, 1.60991758e-01f, 6.73699230e-02f, 5.93177229e-02f, 7.19140470e-02f, 6.99489340e-02f, -7.08670989e-02f, 9.19088647e-02f,
  1.32053895e-02f, 6.52729049e-02f, 7.25609437e-02f, 4.78370674e-02f, 1.04576014e-01f, 6.76541552e-02f, 8.13214630e-02f, 1.27142472e-02f, 1.75944697e-02f, 1.13697737e-01f,
  -1.18706177e-03f, 4.46557514e-02f, 3.81620321e-03f, 1.25805691e-01f, -1.88187435e-01f, 3.00330557e-02f, -3.11951730e-02f, 4.89422195e-02f, -5.13576940e-02f, 3.48372497e-02f,
  1.08281355e-02f, 8.01184867e-03f, 3.68281640e-02f, 7.34679475e-02f, -1.32524356e-01f, 8.51453748e-03f, -1.39790475e-01f, -9.48318187e-03f, 8.10245890e-03f, -8.81904550e-03f,
  -9.36896354e-02f, -6.39248416e-02f, -8.63765031e-02f, 3.53057645e-02f, -2.30028722e-02f, -7.03967139e-02f, -1.47473454e-01f, 4.65487093e-02f, 1.87603250e-01f, -6.41004890e-02f,
  8.88097435e-02f, 2.39678904e-01f, -9.40044224e-02f, 1.31955609e-01f, 1.67273991e-02f, 1.31982848e-01f, -1.40409067e-01f, 3.02420147e-02f, -7.47402459e-02f, -3.06832511e-02f,
  -6.48763077e-03f, 5.43072782e-02f, 1.51589617e-01f, -7.92619213e-03f, 5.11485338e-02f, -8.23138803e-02f, 1.04836158e-01f, 2.36490332e-02f, 8.04233626e-02f, -8.84700641e-02f,
  1.05167031e-01f, 2.48024076e-01f, 2.95405425e-02f, 7.56230354e-02f, -2.63344254e-02f, -1.98365189e-02f, 6.41848519e-02f, -4.43773419e-02f, 1.46325409e-01f, -4.38775718e-02f,
  1.04800621e-02f, 4.68015559e-02f, 3.02734110e-03f, 6.27448782e-02f, -5.20247445e-02f, -6.03302084e-02f, -4.57265377e-02f, 9.00325086e-03f, -9.63838305e-03f, -4.56713252e-02f,
  1.02090709e-01f, -6.14930540e-02f, 2.92089097e-02f, 1.33131549e-01f, -1.38904462e-02f, -1.34687155e-01f, 1.32427022e-01f, 4.72703762e-02f
};

// L1_fan_Bp_bar (Shape: 1 x 26)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 26;
const float L1_fan_Bp_bar_data[] = {
  -4.39919047e-02f, -1.04066823e-02f, 6.49076328e-03f, 2.09957920e-02f, -3.59408855e-02f, -8.27172548e-02f, 1.35933593e-01f, 9.48110521e-02f, 3.95960994e-02f, 8.33855942e-02f,
  1.02748193e-01f, 9.38001424e-02f, 1.06480934e-01f, 8.88168626e-03f, 6.63748384e-02f, 6.48194505e-03f, 5.58092371e-02f, 8.95721391e-02f, 1.03710532e-01f, 4.47460450e-03f,
  8.70305151e-02f, -5.56932241e-02f, -5.84626421e-02f, 9.59836170e-02f, 1.23104155e-01f, -1.14254234e-02f
};

// L2_linear_W (Shape: 12 x 128)
const int L2_linear_W_rows = 12;
const int L2_linear_W_cols = 128;
const float L2_linear_W_data[] = {
  -2.33944386e-01f, 7.04440773e-02f, -4.92997840e-02f, 2.33247578e-02f, 5.00260703e-02f, 3.16944048e-02f, 1.85884871e-02f, -3.61137062e-01f, 6.69371709e-02f, -1.22469313e-01f,
  -3.03221345e-02f, -1.35493249e-01f, -9.50672254e-02f, 6.48958534e-02f, -1.41543597e-01f, 4.76455986e-02f, -1.98266640e-01f, -1.83642343e-01f, -2.96870768e-01f, 1.71024799e-01f,
  -8.57602134e-02f, 5.31788059e-02f, 5.86221293e-02f, 2.53492165e-02f, -4.62462045e-02f, -3.19769561e-01f, -2.69657224e-01f, 1.74975023e-01f, -3.02998088e-02f, -4.78187688e-02f,
  4.90969867e-02f, -1.46671943e-02f, 6.07393794e-02f, 7.89635554e-02f, -3.73343050e-01f, 8.60195309e-02f, -4.42550052e-03f, 9.06525850e-02f, 7.50830844e-02f, 1.02461934e-01f,
  2.04958260e-01f, -1.93703949e-01f, 9.67519954e-02f, -3.15968245e-02f, 1.13732152e-01f, 5.17358147e-02f, -5.05278520e-02f, 1.21573023e-02f, 9.14888084e-02f, 1.05593972e-01f,
  -2.69204795e-01f, 3.06652576e-01f, -7.62142763e-02f, 1.23543933e-01f, -5.59831522e-02f, 1.74017414e-01f, -3.17657501e-01f, 2.34505489e-01f, 1.57193482e-01f, -9.96945351e-02f,
  -2.68801779e-01f, 1.12700321e-01f, -1.14449136e-01f, 2.30378941e-01f, -3.54468912e-01f, -2.15200365e-01f, 1.89476565e-01f, -7.39628375e-02f, -2.38657922e-01f, -1.14493884e-01f,
  7.80409575e-02f, 3.87672149e-02f, 9.63363275e-02f, 1.30549833e-01f, -9.43830758e-02f, -1.55684859e-01f, -7.00036883e-02f, -1.89106897e-01f, 1.07692577e-01f, -1.85612619e-01f,
  -2.32385859e-01f, -2.21919432e-01f, 2.13039204e-01f, -2.63933659e-01f, 1.27544388e-01f, 3.64974678e-01f, -1.70975089e-01f, -1.26336664e-01f, 2.53935874e-01f, 1.85620010e-01f,
  -8.65334794e-02f, 4.16691937e-02f, -1.85769364e-01f, -4.29860987e-02f, -1.12373263e-01f, 4.34354804e-02f, 1.04813753e-02f, 1.94426194e-01f, -2.76475459e-01f, 1.08910151e-01f,
  2.94822574e-01f, -2.32885733e-01f, 1.75537020e-01f, 1.14610486e-01f, 6.07185960e-02f, -1.33797657e-02f, -1.22074611e-01f, -1.15976222e-02f, -2.74225950e-01f, 1.98557362e-01f,
  -1.23678742e-03f, -9.48734805e-02f, -1.55979693e-01f, -1.72075674e-01f, 1.05128624e-01f, -1.06412813e-01f, -7.33045042e-02f, 3.00058722e-02f, 1.73380077e-01f, -2.55279150e-02f,
  -5.52709438e-02f, -2.54771203e-01f, -5.70240943e-03f, 2.66938299e-01f, 1.49833355e-02f, -3.83589305e-02f, -1.91472158e-01f, -2.03647856e-02f, -1.76798739e-02f, -5.76336980e-02f,
  4.42703106e-02f, -2.59028554e-01f, -6.62764832e-02f, 9.60855335e-02f, 1.05019212e-01f, -3.70030314e-01f, 4.38602269e-03f, -2.03342550e-02f, 9.31287706e-02f, 7.73725659e-02f,
  1.21871814e-01f, 1.53409660e-01f, -2.39391521e-01f, 1.76704407e-01f, 6.89289123e-02f, 1.62943080e-01f, 2.59072602e-01f, -3.28107089e-01f, -4.27767262e-02f, -6.79079071e-02f,
  7.78634148e-03f, -8.39711428e-02f, -7.64782876e-02f, -1.20258950e-01f, -1.60203591e-01f, 4.71593775e-02f, -1.48836300e-01f, -1.76173538e-01f, -3.83514613e-02f, 4.37101275e-02f,
  1.31461397e-02f, 3.53419520e-02f, 1.76707909e-01f, 5.41613288e-02f, -1.16478140e-02f, 1.82824358e-01f, 1.00938134e-01f, 1.62999202e-02f, -1.10385962e-01f, 6.73923716e-02f,
  -8.64298344e-02f, 1.75578725e-02f, -1.21254124e-01f, -1.19585685e-01f, -6.61120713e-02f, 7.22424015e-02f, 8.03211555e-02f, 4.12702896e-02f, 6.78453892e-02f, 2.36750469e-01f,
  3.03657949e-02f, -2.30620265e-01f, -8.56085047e-02f, 2.85505027e-01f, -1.14842683e-01f, -6.46898374e-02f, 2.57265925e-01f, 1.02209628e-01f, -9.55974758e-02f, 1.16417654e-01f,
  -1.66503623e-01f, -1.39493659e-01f, -6.62313923e-02f, -7.73967952e-02f, -3.76929671e-01f, -2.89011508e-01f, 4.86433469e-02f, 4.85874712e-03f, 1.79936141e-01f, 1.35955274e-01f,
  6.12010583e-02f, -3.74357286e-03f, -2.95696884e-01f, -2.14468554e-01f, -2.02654928e-01f, -2.09263563e-01f, -3.96248251e-01f, -3.10697615e-01f, -1.18567333e-01f, 1.29364049e-02f,
  2.93735057e-01f, -1.41601369e-01f, -7.54806250e-02f, 1.69453964e-01f, -2.19128624e-01f, 5.98287806e-02f, 2.14833975e-01f, 1.33171931e-01f, 2.26709247e-01f, -4.19168681e-01f,
  2.55426802e-02f, -1.10375300e-01f, 3.03330392e-01f, 3.90655428e-01f, 2.85708517e-01f, 2.39983708e-01f, -4.13655818e-01f, -1.26739308e-01f, -1.32235408e-01f, -1.76737905e-01f,
  1.33542120e-01f, 1.46462500e-01f, -1.61788747e-01f, -7.48244077e-02f, -7.70852715e-02f, -8.15658793e-02f, -1.11373719e-02f, -2.48134837e-01f, -2.23177895e-02f, 1.30725741e-01f,
  -3.64151932e-02f, 2.17315882e-01f, 8.99727866e-02f, -3.68310027e-02f, -5.80719560e-02f, -1.04444534e-01f, 6.89932555e-02f, 3.21284711e-01f, -1.47945091e-01f, 1.96105111e-02f,
  -9.05377716e-02f, -1.05383895e-01f, -5.18811047e-02f, -1.22052647e-01f, -1.27383858e-01f, -1.69052795e-01f, 4.18969616e-02f, 2.74482090e-02f, -2.68189311e-01f, 1.03978388e-01f,
  -1.18025519e-01f, -3.21515352e-02f, -1.14856139e-01f, 2.17937231e-01f, -5.21547124e-02f, -7.26331398e-02f, 4.08747494e-02f, -2.44849548e-01f, -3.69831882e-02f, -8.53644535e-02f,
  -2.56630741e-02f, -6.19794764e-02f, 7.05848332e-04f, -1.51415512e-01f, 7.26598203e-02f, 1.27931191e-02f, 3.12174596e-02f, 1.04992166e-01f, 1.24350332e-01f, 1.31281808e-01f,
  -9.96900797e-02f, 1.06961258e-01f, 9.76007953e-02f, 1.52946338e-01f, 7.19583929e-02f, -8.80907923e-02f, -2.18077954e-02f, -7.66633376e-02f, -6.67949393e-02f, 5.13560511e-03f,
  -2.30439566e-02f, -2.58766580e-02f, -1.31929532e-01f, 1.46023601e-01f, 2.32517552e-02f, 1.76266745e-01f, -3.56065154e-01f, 1.11297622e-01f, -3.25106680e-01f, 1.21369049e-01f,
  1.11989304e-01f, -1.73657253e-01f, -1.19048469e-01f, -1.73812613e-01f, -1.74672961e-01f, -2.39383638e-01f, 7.37815648e-02f, 9.52222347e-02f, 1.78134456e-01f, -3.45952541e-01f,
  -1.02772266e-02f, 2.76503235e-01f, 1.69439930e-02f, -1.44736350e-01f, -2.62513906e-02f, -1.34344026e-01f, 1.24641411e-01f, -5.25745330e-03f, 3.70164096e-01f, -4.77336459e-02f,
  2.79300094e-01f, 2.10098460e-05f, -3.17010224e-01f, 1.89916015e-01f, -2.14475304e-01f, 2.53409088e-01f, 9.87669975e-02f, -1.09539591e-01f, -1.03361189e-01f, 3.49975005e-02f,
  1.49971619e-01f, -2.35791638e-01f, 2.96185613e-01f, 5.98902218e-02f, -3.39295477e-01f, -2.44089365e-01f, -2.74805099e-01f, -2.29448662e-03f, 1.45419195e-01f, -5.91300316e-02f,
  -2.82098409e-02f, -1.53003678e-01f, -4.74091470e-02f, 7.05940649e-02f, 2.21154287e-01f, -1.64472889e-02f, -1.00651361e-01f, -2.11582035e-01f, -1.66511585e-04f, -2.55527705e-01f,
  -1.50218219e-01f, 2.16934860e-01f, 1.71661705e-01f, 4.52367365e-02f, 1.31768972e-01f, 2.08628371e-01f, -2.16719136e-01f, 5.75545616e-02f, -8.89210775e-03f, -8.62603188e-02f,
  1.80825770e-01f, 2.77598556e-02f, -7.69050047e-02f, -4.59733754e-02f, 1.01122826e-01f, -4.68841866e-02f, 3.46116871e-02f, 2.78325882e-02f, 2.26183146e-01f, 1.15941145e-01f,
  2.40885183e-01f, -2.59678885e-02f, -1.10346243e-01f, -1.18206881e-01f, -2.90191412e-01f, 3.07263657e-02f, -5.55902794e-02f, 3.42730373e-01f, 2.19647810e-01f, -5.45683913e-02f,
  1.05054462e-02f, -8.73578861e-02f, 1.42407596e-01f, -3.18111062e-01f, 6.58594305e-03f, 9.53342393e-02f, 2.31044590e-02f, 2.30108038e-01f, -1.52178958e-01f, 1.03270866e-01f,
  -8.08630660e-02f, 1.28768876e-01f, -1.72396563e-02f, -6.24288991e-03f, -1.38206363e-01f, -2.80155867e-01f, 8.63607898e-02f, 1.91198975e-01f, -1.58017203e-02f, -3.70854318e-01f,
  1.12271626e-02f, -1.34463668e-01f, -2.53868818e-01f, -2.44663835e-01f, -1.44085035e-01f, -8.94736405e-03f, 1.07256114e-01f, 1.84460972e-02f, 7.79685453e-02f, -1.38226599e-01f,
  -5.66216111e-02f, -3.34218964e-02f, 6.15146644e-02f, 1.70451880e-01f, -1.24968775e-01f, -7.48522729e-02f, -8.83107111e-02f, -1.51481822e-01f, -1.10748811e-02f, 3.36970948e-02f,
  1.20942168e-01f, 8.64601359e-02f, -1.42314294e-02f, 8.46984088e-02f, -1.37154693e-02f, -9.36321244e-02f, 1.66974708e-01f, -5.72448894e-02f, -1.53640658e-01f, -1.62096262e-01f,
  -2.41500288e-01f, 1.21017676e-02f, 7.09085092e-02f, -5.98527491e-02f, -6.04289174e-02f, 1.55940548e-01f, -2.08407357e-01f, 1.57429144e-01f, 3.32558751e-01f, -3.75142485e-01f,
  -3.58785130e-02f, 2.40400285e-01f, 1.16748258e-01f, -3.09884851e-03f, -1.10014707e-01f, -1.78853303e-01f, -7.84351975e-02f, -5.74431755e-02f, -1.02313720e-01f, 3.53929937e-01f,
  1.24987535e-01f, -8.45624283e-02f, -1.76827297e-01f, -4.91799377e-02f, -3.80556405e-01f, 2.86052227e-01f, -1.33610576e-01f, 9.79539230e-02f, -1.00203447e-01f, 1.26726910e-01f,
  -6.67151809e-02f, -7.28486329e-02f, 1.18652783e-01f, 1.05075426e-01f, -6.38517290e-02f, 1.55387938e-01f, -1.77276537e-01f, 3.28766912e-01f, -2.43001670e-01f, 7.37004355e-03f,
  -2.16158912e-01f, 1.86052173e-01f, -1.58750340e-01f, 2.16703355e-01f, 1.47615552e-01f, 3.25232059e-01f, -1.74024880e-01f, -4.02661376e-02f, -1.39909759e-01f, -1.07734606e-01f,
  -2.56687284e-01f, -3.35915536e-01f, 1.99360609e-01f, 7.08946660e-02f, 4.21128154e-01f, -2.87415553e-02f, 2.26386070e-01f, 1.10463895e-01f, -8.07915181e-02f, -4.40070368e-02f,
  7.58842332e-03f, -7.82381818e-02f, -2.46768862e-01f, -1.69227347e-01f, -2.55187657e-02f, -1.88681781e-02f, -7.96798393e-02f, -2.32034698e-01f, -1.38229445e-01f, -1.53520377e-02f,
  1.17987029e-01f, -7.49250725e-02f, 1.87118307e-01f, -5.85551448e-02f, 1.79536134e-01f, -6.11894913e-02f, -1.57236472e-01f, -2.17235893e-01f, -6.37771860e-02f, 1.08623371e-01f,
  -9.36907828e-02f, 2.36530975e-01f, 1.28262818e-01f, 1.24799050e-02f, 7.57177547e-02f, 2.61710167e-01f, 1.96543679e-01f, 1.70495987e-01f, 2.47588065e-02f, 3.61790299e-01f,
  -1.38443140e-02f, 3.21006514e-02f, 6.75883144e-02f, 2.31484160e-01f, 7.88433943e-03f, 5.86052760e-02f, 3.26962858e-01f, -5.50203882e-02f, 1.81502938e-01f, -3.11019961e-02f,
  -1.76099494e-01f, 3.25499356e-01f, 1.80348113e-01f, 2.30072774e-02f, 1.17663719e-01f, 9.36765298e-02f, -2.77031083e-02f, 2.69536883e-01f, -8.33897013e-03f, -2.33987838e-01f,
  6.61774799e-02f, 1.21618528e-03f, -4.49759439e-02f, 4.73776199e-02f, 2.63074756e-01f, 1.95086405e-01f, 1.51471406e-01f, 1.05945751e-01f, 2.50927776e-01f, 1.27473995e-01f,
  7.81775042e-02f, 1.11192413e-01f, -1.79366238e-04f, -8.75413790e-02f, 8.01655874e-02f, 2.55684014e-02f, -1.55499756e-01f, -2.80789137e-01f, 1.57252565e-01f, 1.97688222e-01f,
  -7.48567656e-02f, 2.87123859e-01f, -3.36903632e-02f, 2.42330655e-02f, -6.23401545e-04f, 1.28332928e-01f, -9.20764878e-02f, 1.71780273e-01f, -1.87072411e-01f, 1.36622578e-01f,
  7.97872618e-02f, -1.75946414e-01f, -6.30864576e-02f, 9.95630547e-02f, -1.97922796e-01f, 5.37862219e-02f, -2.84287184e-01f, -3.06337420e-02f, 2.87201196e-01f, -7.18449429e-02f,
  -2.73536474e-01f, -1.00330941e-01f, -4.20223773e-02f, -6.86257407e-02f, 1.19021563e-02f, -6.40717074e-02f, 2.26245701e-01f, 1.70846567e-01f, -1.15848042e-01f, -2.07169801e-01f,
  -5.41182514e-03f, 2.87344128e-01f, 2.54651845e-01f, 1.60779823e-02f, -9.08887088e-02f, 1.91434562e-01f, 1.11435182e-01f, -7.15883821e-02f, 9.61093698e-03f, 2.17975359e-02f,
  -1.66263094e-03f, -8.62487406e-02f, -1.83842763e-01f, 2.42555097e-01f, -2.37892255e-01f, 3.22159119e-02f, -2.82931268e-01f, -1.83998123e-01f, -3.94505441e-01f, -1.32513911e-01f,
  -1.65985599e-01f, 7.43118003e-02f, 2.39394195e-02f, 3.39721292e-02f, -8.71397834e-03f, -6.76462203e-02f, -1.51667641e-02f, -3.69588919e-02f, -1.12100855e-01f, 1.07064374e-01f,
  -1.45185933e-01f, 5.09839118e-01f, -5.26100211e-02f, 4.07067575e-02f, -5.69779761e-02f, -2.42981151e-01f, 1.13941230e-01f, 6.59805760e-02f, 7.82235637e-02f, 5.47472276e-02f,
  -2.59104192e-01f, 2.69242283e-02f, 8.70020837e-02f, 1.30276233e-01f, 2.43955217e-02f, 1.58059925e-01f, -7.67457336e-02f, -7.97354802e-02f, -1.79183446e-02f, -1.13633074e-01f,
  1.33775786e-01f, -8.95471498e-02f, 5.07930480e-02f, -8.67662951e-02f, 1.99758291e-01f, -7.15890452e-02f, -7.09115416e-02f, -2.20738277e-01f, -4.10688892e-02f, 3.63628902e-02f,
  4.34181169e-02f, 1.83682919e-01f, 7.87060931e-02f, -8.09836239e-02f, -2.26541713e-01f, 1.50049672e-01f, -7.91588128e-02f, 1.81437001e-01f, 8.59037638e-02f, -2.52345800e-02f,
  7.93824419e-02f, -1.65980216e-02f, -3.93732071e-01f, 1.08668812e-01f, 9.39143449e-02f, -2.95067113e-02f, 6.45092428e-02f, 5.51858312e-03f, 6.78180456e-02f, 2.08710700e-01f,
  -7.87838921e-02f, 1.41402297e-02f, -1.40183836e-01f, -1.18365459e-01f, -7.43049011e-02f, 4.44993153e-02f, 9.82315391e-02f, -1.24805057e-02f, -8.62351805e-02f, -9.19366181e-02f,
  1.67524159e-01f, -4.10237871e-02f, 1.03648379e-01f, -1.35235280e-01f, 1.04875185e-01f, 8.27270001e-02f, -6.61178455e-02f, 1.04198426e-01f, 3.62306386e-02f, -1.36321127e-01f,
  1.28137529e-01f, -2.78189212e-01f, 1.33406624e-01f, 2.86614746e-02f, 4.07561660e-02f, 5.68696335e-02f, -3.31005603e-02f, -2.49662418e-02f, 4.13302898e-01f, 1.38689488e-01f,
  -3.40466470e-01f, 1.29308999e-01f, -5.23511507e-02f, -2.23078355e-01f, -1.59778416e-01f, -1.06746696e-01f, -8.61382261e-02f, -3.57221924e-02f, 3.87964815e-01f, -1.21843614e-01f,
  3.03184837e-01f, 5.07932389e-04f, -1.56639203e-01f, -2.49256045e-01f, -1.54311836e-01f, -1.61373168e-01f, -3.07343632e-01f, -8.85311812e-02f, 2.24884391e-01f, -7.65614137e-02f,
  -1.32261440e-01f, -1.44098192e-01f, -2.95340806e-01f, -3.24977309e-01f, 2.65606076e-01f, 2.21539572e-01f, 2.44476512e-01f, -2.02393875e-01f, -1.35178089e-01f, -2.31996015e-01f,
  -1.83693230e-01f, 1.79058224e-01f, -1.99258983e-01f, 2.51075536e-01f, 1.15843318e-01f, 3.50704044e-02f, -3.14975046e-02f, 2.43046939e-01f, -2.11338401e-01f, -2.92807132e-01f,
  -1.84127226e-01f, 7.42427930e-02f, 4.99286056e-02f, -8.43389407e-02f, -1.96582660e-01f, 7.09133148e-02f, -3.59851937e-03f, 6.66617304e-02f, -2.30820596e-01f, 5.97043298e-02f,
  -9.79527384e-02f, 2.01012436e-02f, -8.35429206e-02f, 3.19793895e-02f, 5.24283163e-02f, 1.24325175e-02f, -2.40456276e-02f, 1.72298491e-01f, 2.55057544e-01f, 1.95412248e-01f,
  7.39085451e-02f, -1.49563309e-02f, 5.44412360e-02f, 2.82832384e-02f, 6.61498830e-02f, 1.03927404e-02f, 8.00153390e-02f, 4.23465610e-01f, -7.11603165e-02f, 3.18742655e-02f,
  -1.45259470e-01f, -1.26998827e-01f, 8.80722627e-02f, 1.31687284e-01f, 3.82018983e-02f, 1.36228427e-01f, 8.27427879e-02f, 3.00550908e-02f, 6.57088161e-02f, -1.39746115e-01f,
  4.94990200e-02f, 5.77950031e-02f, -4.67243930e-03f, 3.36659439e-02f, -8.95603001e-02f, -1.10874586e-02f, 2.15631664e-01f, -1.96369514e-02f, -1.34910375e-01f, -2.94339687e-01f,
  -1.34869292e-01f, 8.29471275e-02f, 1.28095090e-01f, 2.09054425e-01f, 1.46845207e-01f, 5.69685288e-02f, 2.37150699e-01f, 1.94080830e-01f, 3.57205831e-02f, -1.11701220e-01f,
  -1.17995724e-01f, -1.43694311e-01f, -2.98758708e-02f, -7.49557391e-02f, 5.69586940e-02f, -6.54301941e-02f, 3.46572436e-02f, -5.66484369e-02f, 1.83383152e-01f, -1.78808291e-02f,
  1.08019352e-01f, 1.19736642e-01f, 8.61430839e-02f, 1.61754563e-01f, 7.01414943e-02f, 5.06477132e-02f, 2.61829048e-01f, -2.66334057e-01f, -1.36765512e-02f, -3.18019807e-01f,
  1.50331765e-01f, -1.72718748e-01f, -4.25437987e-02f, 1.26548186e-01f, -9.15999487e-02f, 8.50022659e-02f, -2.46402636e-01f, -9.20949653e-02f, 1.20294377e-01f, 2.66828984e-01f,
  4.32881922e-01f, -1.48316875e-01f, -2.48658523e-01f, -1.32605284e-01f, 3.72118019e-02f, 2.14932755e-01f, 2.71859877e-02f, 2.50642717e-01f, 2.26654917e-01f, -3.48299891e-01f,
  -3.31670761e-01f, -2.36633554e-01f, 2.10367292e-01f, 1.17120005e-01f, 2.80823529e-01f, 3.41570109e-01f, -3.14731314e-03f, 2.57662803e-01f, 1.02808394e-01f, 8.33801329e-02f,
  -3.27452689e-01f, -4.87338938e-02f, 7.50069916e-02f, -3.53252202e-01f, -1.35175101e-02f, -2.03859545e-02f, -2.32973680e-01f, -1.34442046e-01f, -1.45433024e-01f, -1.42458200e-01f,
  -1.18321337e-01f, -2.53406554e-01f, 1.75891042e-01f, -1.81350242e-02f, -6.69718683e-02f, -1.79067314e-01f, 1.17765315e-01f, -1.02421097e-01f, -1.02351934e-01f, 3.84699821e-01f,
  -1.15276240e-01f, -1.28856942e-01f, -9.53643844e-02f, 9.32658389e-02f, -3.01334485e-02f, 5.41274510e-02f, -3.42910960e-02f, 5.20967953e-02f, -1.53673002e-02f, -6.87818825e-02f,
  2.70470709e-01f, 2.26463765e-01f, 6.41722903e-02f, 8.97971839e-02f, -6.01942539e-02f, 3.46703380e-02f, 1.14976734e-01f, -9.50618908e-02f, -1.89462751e-01f, 5.46411537e-02f,
  -8.78839269e-02f, -5.77997155e-02f, -9.92291495e-02f, -8.62270296e-02f, 3.67381454e-01f, -2.31566086e-01f, 9.22791436e-02f, -7.26372888e-03f, -8.79641771e-02f, 1.60611466e-01f,
  1.03159256e-01f, 4.17683944e-02f, 1.93632417e-03f, 1.04951635e-01f, 5.78827262e-02f, 6.05916744e-03f, 1.42703027e-01f, 1.56675484e-02f, -2.15584025e-01f, -8.84539485e-02f,
  1.30909204e-01f, 6.63725734e-02f, 1.43492281e-01f, 1.44587025e-01f, -2.01629236e-01f, -7.55227655e-02f, 1.20720575e-02f, 1.16516463e-02f, 1.87844366e-01f, 6.32399023e-02f,
  -5.21372706e-02f, 1.99519560e-01f, 1.88026220e-01f, -2.71979213e-01f, -1.79237664e-01f, -1.97250724e-01f, 7.82233924e-02f, 5.50920963e-02f, 9.40846801e-02f, 1.01124451e-01f,
  -7.82696903e-02f, -6.76897988e-02f, -6.26596063e-02f, 9.75681543e-02f, 7.43179545e-02f, 1.29449004e-02f, 1.40081160e-02f, 1.02259992e-02f, -2.02227697e-01f, 1.15671884e-02f,
  -3.32746767e-02f, 7.31330141e-02f, 1.09207623e-01f, 1.39749721e-01f, -1.43322572e-01f, -9.03817117e-02f, 6.75327890e-03f, -6.21716343e-02f, 4.49532382e-02f, 3.03075254e-01f,
  2.92804062e-01f, -2.44947538e-01f, 2.08375484e-01f, 1.42896727e-01f, -3.13059241e-01f, 2.31635362e-01f, -9.53512788e-02f, 6.21171929e-02f, -2.53611535e-01f, 2.90315866e-01f,
  2.29375526e-01f, 2.49143794e-01f, -3.30703147e-02f, 1.08655693e-03f, 4.20270860e-01f, -1.30373850e-01f, -2.52966285e-01f, -3.14425901e-02f, 1.71634242e-01f, 2.22953692e-01f,
  -1.00545809e-01f, -2.31935993e-01f, 9.45821777e-02f, 1.90024465e-01f, 9.07815620e-02f, 2.30889097e-01f, 2.56845504e-01f, 1.33219644e-01f, -1.23052346e-02f, -6.12158626e-02f,
  -3.89766842e-02f, 8.99316296e-02f, 3.74733508e-01f, -3.76111835e-01f, 1.53706163e-01f, -2.47015767e-02f, 3.42028141e-02f, 1.00078389e-01f, 2.65890002e-01f, 2.91767627e-01f,
  -2.20545739e-01f, -1.38345718e-01f, -9.92627591e-02f, -7.42190406e-02f, 6.07175753e-02f, 2.55726784e-01f, 3.18091989e-01f, 4.84069884e-02f, 4.17023897e-03f, -1.12174451e-01f,
  1.29128665e-01f, 3.09571419e-02f, 9.09373909e-02f, -3.98226175e-03f, -1.42349169e-01f, -1.68520778e-01f, 1.34585962e-01f, -9.44157317e-02f, -5.04522026e-02f, -5.20440079e-02f,
  -1.64147258e-01f, 6.78807124e-02f, 7.56094903e-02f, 9.67639759e-02f, -1.12735838e-01f, 1.36059821e-02f, -1.16063662e-01f, -2.07013890e-01f, 2.03406960e-02f, -1.11261547e-01f,
  -5.66742569e-02f, 1.37840033e-01f, -1.06891207e-01f, 2.29533195e-01f, 8.56382251e-02f, 4.53534462e-02f, 3.24995234e-03f, 1.28856719e-01f, 1.02982685e-01f, -1.82156786e-01f,
  2.55338922e-02f, 1.71018824e-01f, 7.47044161e-02f, 6.60944358e-02f, -7.75368586e-02f, 9.92255062e-02f, 2.00579222e-02f, -4.19746876e-01f, -4.21589725e-02f, -9.05892402e-02f,
  1.58151180e-01f, 2.04593822e-01f, 1.73207119e-01f, -1.97454877e-02f, -1.24627858e-01f, 1.09088860e-01f, -1.38621062e-01f, -9.41832364e-02f, -4.95256148e-02f, 2.12890789e-01f,
  1.97821893e-02f, 1.21788464e-01f, 2.27418803e-02f, -4.34296615e-02f, -4.71460167e-03f, -6.86880052e-02f, 6.69843843e-03f, -3.83880585e-02f, -4.50317785e-02f, 1.23852812e-01f,
  -2.85960026e-02f, 1.10180795e-01f, -1.05512373e-01f, -6.81838347e-03f, 6.65430352e-03f, -1.38894503e-03f, -3.36794332e-02f, -2.07636371e-01f, 4.02213633e-02f, -5.23482598e-02f,
  1.04015991e-01f, 8.28378573e-02f, -1.72702819e-01f, 1.11422479e-01f, 7.58867562e-02f, 1.24103390e-02f, -2.22393915e-01f, 2.81258881e-01f, -7.00628310e-02f, -3.63606393e-01f,
  1.38368338e-01f, -2.61436939e-01f, -1.49061128e-01f, -4.80055325e-02f, 9.06977206e-02f, -2.43862554e-01f, 8.18115771e-02f, 1.70078978e-01f, 1.04846254e-01f, -7.02554211e-02f,
  -3.30547303e-01f, 2.75129765e-01f, 2.97784358e-01f, 1.64548621e-01f, 1.71463728e-01f, 2.49764189e-01f, 1.13194287e-01f, -1.52047157e-01f, -2.92575389e-01f, -1.88608870e-01f,
  -4.34063412e-02f, -1.21035971e-01f, -1.03861690e-01f, -1.21488936e-01f, -2.49295115e-01f, -2.14574456e-01f, 1.46994159e-01f, 2.42247894e-01f, -3.15497160e-01f, -2.97735929e-01f,
  -1.54873421e-02f, 1.02250203e-01f, 2.02171087e-01f, 2.46903613e-01f, 3.22924376e-01f, -8.07951614e-02f, 3.23486805e-01f, -2.48479426e-01f, 3.13382059e-01f, 2.23321006e-01f,
  1.96706533e-01f, 2.64976844e-02f, 1.24552056e-01f, 2.19017848e-01f, -1.27672419e-01f, 1.34796157e-01f, -3.25774960e-02f, -9.18763503e-03f, 1.24302484e-01f, -3.27678658e-02f,
  7.42234737e-02f, -6.26074057e-03f, 1.50779545e-01f, -1.48935616e-01f, -8.53066985e-03f, 1.26713961e-01f, -1.74501557e-02f, -1.41309677e-02f, -2.95605790e-02f, -9.54808220e-02f,
  -2.34508589e-02f, 5.60318828e-02f, 4.27743010e-02f, -1.96320355e-01f, 1.32438719e-01f, 5.45538440e-02f, -4.06107716e-02f, -2.49939784e-01f, 2.10137457e-01f, 5.34436256e-02f,
  8.42406899e-02f, -1.47756532e-01f, 1.44755229e-01f, -1.36835873e-01f, -3.44242789e-02f, 1.06759116e-01f, -3.05363476e-01f, 1.29495445e-03f, 2.22353637e-03f, -2.27311961e-02f,
  -1.31853357e-01f, -1.49569616e-01f, 5.40164299e-02f, 5.69750220e-02f, -2.31798254e-02f, 1.21519312e-01f, 8.64081364e-03f, 1.13264516e-01f, 2.85998899e-02f, 3.36977318e-02f,
  5.58567047e-03f, 2.24904463e-01f, -5.66892959e-02f, 1.25567079e-01f, 7.72165731e-02f, -4.37811501e-02f, -1.20589761e-02f, -1.27953310e-02f, -9.56896171e-02f, -2.16854095e-01f,
  -1.00184016e-01f, 7.29891285e-02f, -1.36836320e-01f, 8.97805244e-02f, -1.42485589e-01f, -3.19597684e-02f, 2.31933743e-02f, 1.04321785e-01f, 7.82208890e-02f, -1.80492446e-01f,
  -1.53646292e-02f, -2.25333244e-01f, -4.36507538e-03f, 1.46851763e-01f, 1.79899540e-02f, 1.59421880e-02f, -9.02048126e-02f, 1.09758377e-01f, -1.64512381e-01f, -8.42003673e-02f,
  -1.62150264e-01f, 1.76884174e-01f, 1.23585023e-01f, 2.31242850e-02f, 7.43374750e-02f, -3.03336710e-01f, -1.11939862e-01f, 2.46389285e-01f, 1.06213659e-01f, 6.57720864e-02f,
  -3.56668770e-01f, 3.94268751e-01f, 2.56649703e-01f, -4.65512276e-02f, 3.05470765e-01f, 1.98559657e-01f, -3.68885212e-02f, -3.43063660e-02f, 1.23455562e-01f, 1.49307817e-01f,
  -1.41115576e-01f, -6.22916967e-02f, -3.70737799e-02f, -3.54610592e-01f, -3.99393030e-02f, 2.28391707e-01f, 3.00334930e-01f, 1.54308856e-01f, 3.14318031e-01f, 3.72339845e-01f,
  1.52629599e-01f, 3.52302164e-01f, 1.25854403e-01f, 2.33242795e-01f, 1.85996041e-01f, -2.18882456e-01f, 2.81341523e-01f, 1.83023334e-01f, 1.70286924e-01f, -4.74970154e-02f,
  -2.14420989e-01f, -1.96705535e-01f, -2.88229853e-01f, -9.90714580e-02f, 2.67547250e-01f, 2.48446345e-01f, -2.69913465e-01f, -2.08927616e-01f, 1.84043601e-01f, 2.33004436e-01f,
  1.94056556e-01f, 2.96125978e-01f, -1.78327203e-01f, 5.52129261e-02f, -2.19498530e-01f, 6.27765694e-05f, 8.83748904e-02f, -1.12360157e-01f, 4.16545644e-02f, 7.91058168e-02f,
  -5.10517582e-02f, 1.55275032e-01f, 7.10153133e-02f, -3.87529582e-02f, -5.40282167e-02f, 2.84418669e-02f, -1.30402863e-01f, -4.82170330e-03f, 5.90141304e-02f, -5.74280918e-02f,
  -2.42062032e-01f, 9.15148333e-02f, -1.69501409e-01f, -7.61133293e-03f, 1.59428626e-01f, 2.88124830e-01f, -3.32657434e-02f, -7.72886202e-02f, -6.58041909e-02f, -3.99468765e-02f,
  -1.21619897e-02f, 2.99918968e-02f, 3.13141719e-02f, -1.07049339e-01f, 2.13223219e-01f, 1.85015604e-01f, 6.95504099e-02f, 3.33104655e-02f, -2.63185687e-02f, -8.95395316e-03f,
  -1.83021888e-01f, -3.64464931e-02f, 5.40167354e-02f, -1.85202248e-02f, 1.27270877e-01f, 4.97030318e-02f, -1.61388874e-01f, -9.63714570e-02f, 2.36052200e-01f, 1.93983391e-01f,
  -1.35594204e-01f, 2.49581840e-02f, 6.27363194e-03f, 1.03925616e-01f, -2.32346840e-02f, -2.89472491e-01f, -1.38582915e-01f, 1.65702999e-01f, 9.94769204e-03f, 1.21426163e-02f,
  -1.19358614e-01f, -1.14070829e-02f, -3.21796574e-02f, -1.09104611e-01f, 8.32990408e-02f, -2.44084522e-01f, -4.29570913e-01f, 3.77858989e-02f, -1.16083145e-01f, -2.12204526e-03f,
  1.74792975e-01f, -4.87064980e-02f, 4.02045436e-02f, 1.49997458e-01f, 4.30601314e-02f, 1.31654188e-01f, 1.95738059e-02f, -1.25770584e-01f, 1.57182828e-01f, 1.69548262e-02f,
  4.61237356e-02f, 1.68119922e-01f, -1.28129303e-01f, -1.10300314e-02f, -1.11291312e-01f, -9.58551839e-02f, -7.27085546e-02f, -9.08084065e-02f, 5.33830337e-02f, 8.07131082e-02f,
  9.87232700e-02f, -2.09008828e-01f, -2.75604993e-01f, -3.45672935e-01f, 2.56306529e-01f, -8.55106935e-02f, 3.50170612e-01f, -2.41477102e-01f, -2.32793435e-01f, -2.50453837e-02f,
  -2.82647878e-01f, 2.33998328e-01f, 1.53254852e-01f, 2.85103545e-02f, -3.62283736e-02f, 2.68517226e-01f, -1.94205448e-01f, -7.24377036e-02f, -9.86810029e-02f, -1.19107783e-01f,
  -3.07978272e-01f, 1.16606489e-01f, 9.53271985e-02f, 3.92496228e-01f, -1.70476496e-01f, -1.23309446e-02f, -2.50028372e-01f, 6.83556050e-02f, -2.44716063e-01f, 1.25484854e-01f,
  2.79727250e-01f, -5.20052426e-02f, -9.64952707e-02f, -1.21945269e-01f, 4.34994064e-02f, -1.75043911e-01f, 3.51793796e-01f, -2.01786891e-01f, 2.23621458e-01f, -6.11152351e-02f,
  -2.34300777e-01f, -9.21801105e-02f, -5.66193135e-03f, 1.73411444e-02f, -6.62919879e-02f, 5.94262742e-02f, -2.20057741e-02f, -4.52472791e-02f, 3.20072949e-01f, -1.93898886e-01f,
  -5.67904599e-02f, 5.47195338e-02f, 7.20614716e-02f, -9.48121175e-02f, 1.13640256e-01f, -3.78167965e-02f, 5.09332903e-02f, -1.36375755e-01f, -3.73693332e-02f, -5.31997569e-02f,
  2.56764561e-01f, 3.48593779e-02f, -1.69877172e-01f, 5.42155355e-02f, -9.00503341e-03f, -2.82450784e-02f, -1.86164916e-01f, -8.88353735e-02f, -4.33511585e-02f, -5.27330898e-02f,
  2.77876295e-02f, -9.72605944e-02f, 2.58277655e-02f, -3.60259593e-01f, -6.12327643e-02f, 1.07020870e-01f, 1.26085505e-02f, 1.15833012e-02f, -8.93110596e-03f, 1.29722487e-02f,
  9.08650979e-02f, 7.19481558e-02f, 1.04240462e-01f, -1.44229596e-02f, 2.13500969e-02f, 2.00532570e-01f, -3.01467441e-02f, 1.66760281e-01f, 5.35683781e-02f, -6.34753630e-02f,
  -1.93139777e-01f, 1.17914826e-01f, -4.89727706e-02f, 3.80097888e-02f, 8.19229633e-02f, -4.20217738e-02f, 3.32523808e-02f, -1.39272988e-01f, 4.57339510e-02f, -1.20966218e-01f,
  1.60832182e-01f, 1.72042415e-01f, -4.58880104e-02f, -3.26553844e-02f, -1.13320336e-01f, -4.36695129e-01f, 1.54423984e-02f, -9.51728784e-03f, 1.16300136e-01f, 1.18936434e-01f,
  -4.59063193e-03f, 8.13334733e-02f, 4.24632151e-03f, 6.68398142e-02f, -4.99691032e-02f, -1.77189067e-01f, -8.68817493e-02f, 1.46285444e-01f, -6.63961694e-02f, -2.23241836e-01f,
  1.44039258e-01f, 9.49973390e-02f, -1.32088140e-01f, -2.81316310e-01f, 2.78236389e-01f, -3.18933010e-01f, -2.00335354e-01f, -3.10315967e-01f, 1.27207607e-01f, 1.26991486e-02f,
  -1.67676955e-01f, -2.57692009e-01f, 1.05630100e-01f, -5.34239560e-02f, 1.56654403e-01f, 1.63491800e-01f, 1.36993021e-01f, -1.29539728e-01f, -1.17680959e-01f, -3.58689651e-02f,
  -1.44793674e-01f, -1.61966994e-01f, -8.08023810e-02f, 1.64423764e-01f, -1.93074971e-01f, -7.70252794e-02f, 1.99115258e-02f, -2.32458368e-01f, 3.40977103e-01f, -6.75925612e-02f,
  -2.25026742e-01f, 1.53686196e-01f, 5.73203266e-02f, -1.45214096e-01f, -3.59465145e-02f, 1.19102351e-01f, -2.00787768e-01f, -2.48358071e-01f, -1.66830927e-01f, 2.60042548e-01f,
  1.83057189e-01f, 2.69719243e-01f, 1.69856489e-01f, -1.74688268e-02f, -2.02501386e-01f, -1.37936085e-01f, 2.61741757e-01f, -4.60508347e-01f, -8.31912383e-02f, -1.81341738e-01f,
  -1.53464139e-01f, 2.25345846e-02f, -2.00365316e-02f, 2.26225518e-02f, 9.31222662e-02f, 3.08167818e-03f, 2.79717237e-01f, -6.77995756e-02f, -6.58771321e-02f, -5.32974899e-02f,
  -5.41493334e-02f, 2.38022164e-01f, -1.83168069e-01f, 2.22178008e-02f, 9.50197205e-02f, 1.37420639e-01f, 2.89156199e-01f, -2.08208203e-01f, 1.37881726e-01f, -1.01224802e-01f,
  -8.99383500e-02f, -5.30805476e-02f, 3.09297293e-02f, -1.13247633e-01f, -1.20080553e-01f, 1.37480810e-01f
};

// L2_linear_B (Shape: 1 x 12)
const int L2_linear_B_rows = 1;
const int L2_linear_B_cols = 12;
const float L2_linear_B_data[] = {
  -6.67937547e-02f, 7.05734566e-02f, -4.61355411e-02f, 8.12928081e-02f, -5.54305799e-02f, 2.08354145e-02f, 7.62159526e-02f, 8.17231387e-02f, -2.95138154e-02f, 6.07285164e-02f,
  -6.75352886e-02f, -5.55780604e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 51, 26
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        128, 51, 26
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_linear
    linear_forward_pgm(
        buffer1, x_out,
        L2_linear_W_data, L2_linear_B_data,
        128, 12
    );
    }
    