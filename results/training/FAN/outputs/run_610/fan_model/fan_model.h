/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 16 (x3)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 16;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    return (x > 0.0f) ? x : 0.0f;
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 6 x 120)
const int L0_fan_Wp_rows = 6;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  6.58276737e-01f, -1.41516417e-01f, 1.99235260e-01f, 3.50489505e-02f, -7.64504746e-02f, -1.20480455e-01f, -1.90166280e-01f, -3.22584575e-03f, 1.53313920e-01f, 8.95723477e-02f,
  -2.12321430e-01f, -2.04108179e-01f, -1.90143604e-02f, -1.41970947e-01f, -1.59721762e-01f, -5.58874421e-02f, 1.09872252e-01f, 2.63857067e-01f, -1.82723686e-01f, -3.33025366e-01f,
  -2.12633178e-01f, 3.01247030e-01f, 2.13233367e-01f, -5.66565767e-02f, 1.29436851e-01f, -2.68347971e-02f, 1.23722509e-01f, 2.59916991e-01f, -1.51810080e-01f, 6.07923806e-01f,
  1.72183141e-01f, 1.42018512e-01f, -5.79994023e-02f, -1.55397709e-02f, 1.98152363e-02f, 8.68374258e-02f, -3.19834873e-02f, 1.42191812e-01f, -7.31316581e-02f, 1.09731860e-01f,
  -1.01370942e-02f, 1.28118519e-03f, 2.15197951e-02f, -5.99561520e-02f, 4.69733514e-02f, -2.39433665e-02f, 8.39523897e-02f, 9.93219763e-02f, 5.96320741e-02f, -7.50408694e-02f,
  -1.51209772e-01f, 2.08863374e-02f, 8.18453357e-03f, -6.93320110e-02f, -1.32520095e-01f, -6.65013120e-02f, -7.26454929e-02f, 5.42883836e-02f, 1.47336960e-01f, 2.91387528e-01f,
  -8.35561082e-02f, 9.10330489e-02f, 4.07667756e-02f, 2.26074713e-03f, -4.33162265e-02f, -3.58287096e-02f, -2.08298815e-03f, -2.98301261e-02f, -1.27018988e-02f, 5.81299402e-02f,
  -6.43551722e-02f, -5.15870340e-02f, -4.29386040e-03f, 1.52059067e-02f, -5.46248145e-02f, 6.12162799e-02f, 5.97389154e-02f, 1.57410977e-04f, -7.23661110e-02f, 2.56426577e-02f,
  -2.74581928e-02f, 7.45295808e-02f, 9.35314037e-03f, 1.96767040e-02f, -1.65966190e-02f, 1.40068084e-02f, 1.54867033e-02f, -1.57157332e-02f, 3.45741883e-02f, -8.55299411e-04f,
  -5.03779575e-02f, -2.03091055e-01f, -4.54979949e-03f, 5.28818294e-02f, 3.64004225e-02f, -3.13691460e-02f, 7.35064372e-02f, 2.48173866e-02f, 8.68043303e-02f, -2.42183451e-02f,
  -1.01332432e-02f, 6.74521327e-02f, -5.29296510e-03f, 7.21844062e-02f, -4.35044989e-02f, 1.48997258e-03f, -5.56704961e-02f, 1.37037467e-02f, 3.49405076e-04f, 8.94548520e-02f,
  3.88370976e-02f, -4.42068800e-02f, -1.14070468e-01f, 9.57612356e-04f, 2.58791335e-02f, -5.45428172e-02f, -5.85275181e-02f, 2.21039411e-02f, -1.12213895e-01f, -1.84852228e-01f,
  4.09444004e-01f, 3.73261869e-01f, -1.52494788e-01f, 3.37415099e-01f, 9.41607058e-02f, -1.45414099e-01f, 8.27560648e-02f, 1.67785227e-01f, -7.09698396e-03f, -3.44677805e-03f,
  -1.87784049e-03f, -2.16900602e-01f, -1.09267004e-01f, -1.01634786e-01f, 7.75622055e-02f, 9.50354487e-02f, 2.22619399e-01f, 5.31704910e-03f, -1.86312243e-01f, -6.30916059e-02f,
  -1.19080871e-01f, 1.87620535e-01f, 1.63153365e-01f, 1.68758892e-02f, 1.16115384e-01f, -2.16774642e-01f, -6.01333119e-02f, 1.01511680e-01f, -1.29895940e-01f, 2.26762772e-01f,
  -2.87992597e-01f, 2.87892461e-01f, -9.16887373e-02f, 1.19038239e-01f, -4.75421958e-02f, 4.52212319e-02f, 3.94365266e-02f, 1.27594426e-01f, 4.98600975e-02f, 6.43634498e-02f,
  1.14995562e-01f, 5.68827800e-02f, 1.41471982e-01f, -5.66430204e-02f, 1.55167937e-01f, 1.34911895e-01f, 2.15675294e-01f, 1.43300846e-01f, 2.93594617e-02f, -6.83971122e-02f,
  6.20139018e-03f, 3.58334333e-02f, 1.77791610e-01f, 1.80518135e-01f, 1.21695109e-01f, 8.03132355e-02f, 6.29332215e-02f, 4.98677045e-02f, 1.09919747e-02f, 4.67110686e-02f,
  5.26384227e-02f, -1.21583641e-02f, -7.31980056e-02f, 6.84191436e-02f, 1.03862071e-02f, -6.38043042e-03f, -4.26674401e-03f, -7.98942707e-03f, -4.42274325e-02f, 3.60392258e-02f,
  -3.60014737e-02f, 3.91346253e-02f, -2.80188732e-02f, 6.82961419e-02f, -3.29419039e-02f, 6.95939362e-02f, -5.51253818e-02f, 7.34369978e-02f, -1.78117808e-02f, 7.39904866e-02f,
  -2.71624066e-02f, -4.92410846e-02f, -5.68065904e-02f, 3.30603421e-02f, 1.78526398e-02f, 5.51923849e-02f, 3.56798992e-03f, 8.02641269e-03f, 1.00323081e-01f, -7.51924003e-03f,
  -1.05512895e-01f, 5.77179641e-02f, -1.06398143e-01f, 4.14291695e-02f, -1.33402303e-01f, -3.65581736e-02f, -4.55149859e-02f, -4.80739996e-02f, -8.54894239e-03f, -4.93685454e-02f,
  7.75178596e-02f, 3.45502198e-02f, -2.85403710e-02f, -7.73228779e-02f, -2.85237860e-02f, -4.94230352e-02f, -7.56523684e-02f, -1.00626394e-01f, 2.84642912e-02f, -6.79459944e-02f,
  3.02127656e-02f, -1.11543663e-01f, -1.18731260e-01f, -6.51335716e-02f, -4.78826873e-02f, -1.81078568e-01f, -1.53771311e-01f, -8.16338882e-02f, -2.13495240e-01f, -2.11222813e-01f,
  3.18180680e-01f, -1.27376869e-01f, -5.51451325e-01f, 4.93306458e-01f, 6.09333627e-02f, -2.42555454e-01f, -5.49035430e-01f, -8.99446085e-02f, 3.40660572e-01f, -2.52569526e-01f,
  1.08781151e-01f, 3.82815927e-01f, 1.33823365e-01f, 5.62539175e-02f, -2.31207788e-01f, -4.61300850e-01f, -2.22286612e-01f, -1.42823622e-01f, -6.93965778e-02f, -6.02798387e-02f,
  1.67598411e-01f, 9.43773836e-02f, 2.58620739e-01f, 5.92317479e-03f, 2.88292356e-02f, 2.99307436e-01f, -1.35218794e-03f, 1.90722734e-01f, -1.89351901e-01f, -3.22929583e-02f,
  -3.03728580e-01f, -1.42035455e-01f, 5.15378714e-02f, 1.37920007e-01f, 1.37562808e-02f, -3.02557889e-02f, 5.78250624e-02f, 3.25815529e-02f, 1.05471052e-01f, -3.40008214e-02f,
  1.30714446e-01f, 3.86079811e-02f, 4.13716584e-02f, 1.83629356e-02f, -3.27867195e-02f, -3.86865879e-03f, 2.66647222e-03f, -4.62002642e-02f, -7.21406788e-02f, -1.49157673e-01f,
  5.37457727e-02f, -1.96919590e-02f, -4.36257683e-02f, -4.19436656e-02f, -1.40777498e-01f, 5.98582365e-02f, 1.60724167e-02f, -5.95202111e-02f, 9.35061369e-03f, 5.12820967e-02f,
  4.65264823e-03f, 1.94510557e-02f, -2.27265265e-02f, 1.15947081e-02f, 1.70983374e-02f, 3.77636589e-02f, -5.35736233e-03f, 3.66673106e-03f, 1.75113622e-02f, -4.44999151e-02f,
  2.15487815e-02f, -7.02910274e-02f, 2.24017967e-02f, -6.40144572e-02f, 2.95923129e-02f, -5.29033951e-02f, -7.27398414e-03f, 1.04236854e-02f, 2.71084998e-02f, 6.35486748e-03f,
  2.78726779e-02f, 8.55835341e-03f, 1.54297482e-02f, -1.21255638e-02f, -4.73710373e-02f, 7.36380881e-03f, 4.43115085e-03f, 1.57602634e-02f, -3.72855202e-03f, 3.85831892e-02f,
  2.80888468e-01f, 8.68833214e-02f, 5.39311729e-02f, -6.84953034e-02f, -3.06852702e-02f, 6.11235835e-02f, 4.02453728e-02f, 2.49267910e-02f, 8.30673706e-03f, 1.21831764e-02f,
  -1.35476207e-02f, -6.95448518e-02f, -2.53077485e-02f, -4.74579036e-02f, 8.55293404e-03f, 2.14657784e-02f, -5.81322657e-03f, 7.68143013e-02f, 6.36968808e-03f, 8.79868194e-02f,
  3.49672772e-02f, -7.61004463e-02f, 3.83304656e-02f, -3.62512581e-02f, 8.71469900e-02f, 4.72861789e-02f, -1.25725850e-01f, 1.10160038e-02f, -2.73421593e-02f, -1.82621162e-02f,
  -5.88578105e-01f, 3.99456590e-01f, -2.63318539e-01f, 1.46685451e-01f, -9.89299864e-02f, -2.70563602e-01f, -5.00366241e-02f, -1.45854652e-01f, -6.17826283e-02f, 2.32549772e-01f,
  -1.83706116e-02f, 6.75327778e-02f, 6.02297187e-02f, 1.40680104e-01f, -1.72805324e-01f, 1.81421429e-01f, 1.95518881e-01f, -7.92309418e-02f, -4.83451486e-01f, -1.79771513e-01f,
  3.23785245e-01f, 1.30189732e-01f, -2.69061059e-01f, -5.02245091e-02f, 4.22964007e-01f, -1.11295506e-01f, 7.00320527e-02f, 1.72646623e-02f, -1.17504954e-01f, 6.16858304e-01f,
  7.79076666e-02f, -3.05145350e-03f, -1.21241212e-01f, 5.19406376e-03f, 1.24341752e-02f, -6.85374811e-02f, -2.71096658e-02f, 2.87641641e-02f, -8.72488022e-02f, 4.16134372e-02f,
  9.34788585e-02f, -2.30132490e-02f, -1.14856333e-01f, 8.73774756e-03f, 5.63890524e-02f, -1.27019070e-03f, 6.16284087e-03f, -6.44046217e-02f, -1.77506655e-02f, 3.25709954e-02f,
  1.91931114e-01f, -8.55480880e-02f, -1.07969977e-01f, -1.39541673e-02f, -8.16385299e-02f, -1.20203137e-01f, 2.56973840e-02f, -4.95997779e-02f, -2.20227733e-01f, 1.43791825e-01f,
  2.39023119e-02f, -1.92773398e-02f, 2.51902081e-03f, -3.48875881e-03f, 2.11294591e-02f, 4.09364030e-02f, 2.21125837e-02f, 4.56709154e-02f, 4.70054671e-02f, -1.87574308e-02f,
  2.17074174e-02f, 3.69401686e-02f, 1.03803340e-03f, -2.17450559e-02f, 7.64705166e-02f, 4.21019457e-02f, 3.41053412e-04f, -3.22443806e-02f, 6.76631704e-02f, -7.89644942e-02f,
  -3.30885593e-03f, -3.38699445e-02f, 4.55409959e-02f, 2.72131171e-02f, 9.79725365e-03f, 4.70206104e-02f, -3.12175434e-02f, -1.54440049e-02f, -2.51119994e-02f, 1.27638434e-03f,
  1.57801256e-01f, -3.04508299e-01f, 2.24108353e-01f, -2.04987526e-02f, 7.96490163e-02f, 8.97811912e-03f, 4.20905575e-02f, 2.08352581e-02f, -6.42070314e-03f, 9.10823699e-04f,
  -8.26714113e-02f, -1.52448779e-02f, 6.51978105e-02f, 3.26189888e-03f, -3.41065153e-02f, 4.30966876e-02f, 2.53682472e-02f, -3.15088429e-03f, -4.51395176e-02f, 9.04323682e-02f,
  2.54307743e-02f, 2.83573363e-02f, 3.69409584e-02f, 1.10119961e-01f, 1.14865161e-01f, 1.13450307e-02f, 1.19306944e-01f, 8.06550682e-03f, -1.53639063e-01f, 1.63440287e-01f,
  3.61339808e-01f, -3.24857980e-02f, -6.13824368e-01f, -2.21710175e-01f, -3.48703451e-02f, 1.53515875e-01f, -1.90328900e-02f, 1.65240109e-01f, 1.99487880e-01f, -6.64180592e-02f,
  7.60009326e-03f, 1.31115124e-01f, 1.38873830e-01f, -7.36048669e-02f, -9.54930484e-03f, -6.29871935e-02f, -3.07266831e-01f, -2.62177050e-01f, -1.18632905e-01f, 4.79320660e-02f,
  1.39602765e-01f, -1.16515964e-01f, -2.43824258e-01f, 3.15628462e-02f, -1.42508551e-01f, 1.77137911e-01f, -1.27889007e-01f, 3.60221229e-02f, 7.91298598e-02f, -3.07615846e-01f,
  7.74224624e-02f, 6.23903275e-02f, -4.33735177e-02f, -6.51438087e-02f, 4.77924682e-02f, 1.72213674e-01f, 3.35107418e-03f, -3.79601866e-02f, 1.49269506e-01f, 1.00554572e-02f,
  -6.59839809e-02f, 7.52074644e-02f, -1.77023616e-02f, -7.88624287e-02f, -9.62646604e-02f, 2.19197813e-02f, -4.66297567e-02f, -5.52336164e-02f, 3.07637993e-02f, -2.65663043e-02f,
  7.12101236e-02f, -4.46294770e-02f, -1.78231433e-01f, 2.29566600e-02f, -1.20350029e-02f, -8.09436962e-02f, -1.93552754e-04f, 1.87715888e-02f, 6.16547428e-02f, 1.24996148e-01f,
  2.45612636e-02f, 9.05986223e-03f, 5.97539172e-02f, -4.61361632e-02f, 2.17395765e-03f, 2.62099728e-02f, 3.95208457e-03f, -7.09095374e-02f, 3.26104239e-02f, 1.88845228e-02f,
  5.33434898e-02f, -6.15413561e-02f, 2.34413985e-02f, 4.29953560e-02f, 2.59553734e-02f, -4.54366915e-02f, 2.04383545e-02f, -5.01750894e-02f, 8.11897870e-03f, -3.44769843e-02f,
  2.89536845e-02f, -1.14625390e-03f, 2.63776518e-02f, -1.57741401e-02f, -1.28143176e-03f, -6.76837638e-02f, -2.63211504e-03f, 1.16546443e-02f, 5.67891710e-02f, -8.65948480e-03f,
  1.61191136e-01f, -1.34189263e-01f, 7.58216083e-02f, 3.25867087e-02f, -5.76760955e-02f, -2.59464867e-02f, -4.48698476e-02f, -3.55528146e-02f, 2.13396233e-02f, 2.27790754e-02f,
  -3.69313993e-02f, 2.41721491e-03f, 1.72810052e-02f, 1.05125178e-02f, 4.99968976e-02f, -2.44880002e-02f, 4.37784605e-02f, 3.24118249e-02f, 1.12651102e-02f, 2.04456523e-02f,
  -9.65655595e-03f, 3.05585302e-02f, 1.58532187e-01f, 3.94616388e-02f, 3.88523452e-02f, 1.96613483e-02f, 2.92330012e-02f, -1.16841951e-02f, 8.74585435e-02f, 2.28127703e-01f,
  5.16085088e-01f, 1.23584077e-01f, -2.08172575e-01f, -1.17308259e-01f, 1.70258209e-01f, 3.21735054e-01f, 6.42987192e-01f, 1.13111593e-01f, -1.32740242e-02f, 1.82248667e-01f,
  1.08363032e-01f, -1.44526720e-01f, -1.60106465e-01f, -8.90566707e-02f, 1.38560295e-01f, 2.56666124e-01f, -1.17225192e-01f, -2.72640526e-01f, 1.11252228e-02f, 1.16746686e-01f,
  7.41600692e-02f, -5.63169159e-02f, -2.30271637e-01f, -1.20799281e-02f, -1.33890003e-01f, 2.58461013e-02f, 1.22345965e-02f, -1.38949588e-01f, 6.49070144e-02f, -5.10400355e-01f,
  -2.38377266e-02f, 1.94840820e-03f, 1.00721784e-01f, 1.75327379e-02f, 2.75368039e-02f, 2.17288472e-02f, 1.02355614e-01f, -8.87333602e-02f, 1.27899453e-01f, -6.74287304e-02f,
  3.66731249e-02f, 6.04036171e-03f, 2.54940130e-02f, -3.81940901e-02f, 8.31675082e-02f, 3.15166265e-03f, -8.78326893e-02f, -1.67000532e-01f, 1.27868634e-02f, 3.87671478e-02f,
  -2.81522479e-02f, 1.36209190e-01f, 1.26389250e-01f, 1.75496899e-02f, 1.58613369e-01f, -5.37317060e-02f, 5.79804964e-02f, -8.81248116e-02f, 2.40045376e-02f, -1.90299898e-01f,
  2.99952235e-02f, 1.93018150e-02f, 1.57579370e-02f, -5.30319696e-04f, 5.41413426e-02f, 3.15585360e-02f, -3.04174945e-02f, 5.62257618e-02f, -4.17826660e-02f, 5.76539384e-03f,
  -3.96998003e-02f, 8.63785099e-04f, -3.85903977e-02f, 5.46758324e-02f, 4.02957574e-02f, -7.19246566e-02f, 3.79005820e-02f, 4.53373529e-02f, 1.78836789e-02f, -1.72505230e-02f,
  -1.64800286e-02f, 1.27059733e-02f, -5.86191844e-03f, -8.85571018e-02f, 3.43932025e-02f, -8.11503381e-02f, -5.76084666e-02f, -2.73756627e-02f, -3.28316167e-02f, 5.20051122e-02f,
  8.91584530e-02f, -1.08211031e-02f, 6.01953045e-02f, -1.27993873e-03f, 7.48113915e-02f, 1.06490515e-02f, -2.06301883e-02f, 7.37904981e-02f, -6.79469332e-02f, 1.25573099e-01f,
  5.14683016e-02f, 8.21523815e-02f, 3.06810103e-02f, 1.26458630e-02f, 7.97590837e-02f, 8.41858163e-02f, 1.18980914e-01f, 1.31718948e-01f, -1.31225884e-02f, 6.02168068e-02f,
  1.48661926e-01f, 1.25786141e-01f, 2.30678499e-01f, 1.94794610e-01f, 5.13423495e-02f, 2.21088305e-01f, 1.42410725e-01f, 1.48862228e-01f, 2.88432628e-01f, 4.79099512e-01f
};

// L0_fan_Wp_bar (Shape: 4 x 120)
const int L0_fan_Wp_bar_rows = 4;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  6.60851717e-01f, -9.73202109e-01f, 4.54232335e-01f, 8.37392956e-02f, 1.57907650e-01f, 2.52085805e-01f, -3.00416291e-01f, -9.01515484e-02f, 2.22970992e-01f, -2.41308033e-01f,
  -2.17101663e-01f, 4.81231622e-02f, 1.28312826e-01f, 7.72876740e-02f, 1.83672950e-01f, -5.19080460e-02f, 8.87675136e-02f, 4.72720593e-01f, 6.79861546e-01f, 1.41811259e-02f,
  -2.27899402e-01f, -9.32875201e-02f, 1.71916693e-01f, 1.83167011e-01f, -2.02799231e-01f, 2.38668397e-01f, -1.06240436e-01f, -1.86111763e-01f, -1.85746029e-01f, -3.71597499e-01f,
  3.33584845e-02f, -3.28182608e-01f, 2.97741175e-01f, 1.20981194e-01f, -1.80770367e-01f, -8.04669783e-02f, -2.11919695e-02f, 5.48192933e-02f, -3.19923827e-04f, 3.79626378e-02f,
  1.40395230e-02f, 1.94704793e-02f, 4.46094237e-02f, -4.66159992e-02f, -3.25618945e-02f, -6.38259277e-02f, -4.30104248e-02f, 2.45199613e-02f, 5.18174544e-02f, -5.38870208e-02f,
  -1.70745701e-01f, 2.36648577e-03f, -1.30257718e-02f, 6.10077120e-02f, 1.86846014e-02f, 2.60016143e-01f, -7.51519948e-02f, -2.60933675e-02f, 3.18330340e-02f, -1.95605800e-01f,
  -5.08101610e-03f, 6.42010421e-02f, -2.62036249e-02f, -2.20968109e-02f, 2.87612732e-02f, 3.57509293e-02f, 6.05093054e-02f, 6.62951618e-02f, -2.26018392e-02f, 1.45783173e-02f,
  -3.22251320e-02f, 2.35544238e-02f, -2.65734028e-02f, 9.16890725e-02f, -9.67233162e-03f, 1.64265707e-02f, 9.30200145e-03f, -2.55092736e-02f, 1.66419782e-02f, -2.19181124e-02f,
  -5.18780090e-02f, 8.34941044e-02f, -6.53208699e-03f, -1.41918212e-01f, -5.03457934e-02f, 2.89381556e-02f, 7.76571855e-02f, -1.95882712e-02f, 5.24304667e-03f, 4.88630608e-02f,
  -3.00114036e-01f, 2.60227561e-01f, 2.30038427e-02f, -7.65506700e-02f, 2.18855403e-02f, -4.47679274e-02f, -2.23192084e-03f, -4.83242273e-02f, -4.81617786e-02f, -3.98111530e-02f,
  1.11122327e-02f, 1.10354438e-01f, -2.38284525e-02f, -1.00356795e-01f, 1.21072106e-01f, 2.38451939e-02f, -1.17073707e-01f, 3.66121940e-02f, 5.21852672e-02f, -1.71504728e-02f,
  -4.78557646e-02f, 1.05561413e-01f, 2.18757331e-01f, 1.48517549e-01f, 1.64739102e-01f, 2.16440544e-01f, -1.86661035e-02f, -5.88361211e-02f, 1.36041239e-01f, -9.46108066e-03f,
  -4.72742558e-01f, 1.55756459e-01f, -2.74765611e-01f, 2.55574703e-01f, 4.01851594e-01f, 3.14692736e-01f, 5.12843430e-01f, 4.10861045e-01f, 1.22182079e-01f, 1.59006521e-01f,
  7.06802607e-02f, 1.74519390e-01f, 3.08292478e-01f, 1.97460443e-01f, 2.21038893e-01f, 3.64990920e-01f, 3.59670907e-01f, -1.43636307e-02f, -2.01663092e-01f, -2.17376351e-02f,
  3.03395867e-01f, -3.73791195e-02f, -3.42867076e-01f, -8.05838183e-02f, 6.50888979e-02f, -2.28272527e-02f, -3.93693894e-02f, -1.98103357e-02f, -1.32757753e-01f, 5.04485928e-02f,
  -4.44264531e-01f, -3.77074368e-02f, 1.80869251e-01f, -2.07578335e-02f, -1.36275857e-03f, -5.43833785e-02f, -7.60597968e-03f, -1.47961438e-01f, -1.24102078e-01f, -1.09459847e-01f,
  -1.57592177e-01f, -1.16789758e-01f, 1.52863532e-01f, -8.74921381e-02f, -1.88717082e-01f, -1.35036945e-01f, -6.68051615e-02f, 9.49605331e-02f, 1.90707415e-01f, 2.53846180e-02f,
  2.24301264e-01f, -8.21664091e-03f, -1.63176581e-01f, 2.08333388e-01f, 2.03318045e-01f, 7.67092779e-02f, -3.33159976e-02f, 9.10693631e-02f, -7.01223016e-02f, -3.76805253e-02f,
  3.37699614e-02f, 1.42305657e-01f, 5.37832603e-02f, 2.31243428e-02f, 8.51834938e-02f, 1.02651507e-01f, 3.54485400e-02f, 8.45409650e-03f, 1.02531262e-01f, 1.43512310e-02f,
  -2.43769232e-02f, 4.39226739e-02f, -6.31777756e-03f, 2.99306531e-02f, 1.54569998e-01f, -8.04949626e-02f, 4.71713357e-02f, -1.13538183e-01f, -1.71359286e-01f, -9.54533741e-02f,
  3.89073193e-02f, 1.16987042e-01f, 4.94300462e-02f, 2.96877325e-02f, 2.57407222e-02f, -4.76838835e-02f, -7.29044154e-02f, -6.26856685e-02f, 1.96217094e-02f, -6.85442090e-02f,
  -2.04755023e-01f, 2.63279527e-01f, 1.01324722e-01f, 1.21564925e-01f, -1.35080695e-01f, -1.28711000e-01f, 7.41014183e-02f, -1.09209627e-01f, -1.38702631e-01f, 3.55404280e-02f,
  -1.32371753e-01f, -5.07441498e-02f, -8.57537165e-02f, -4.15325314e-02f, -2.35406429e-01f, -1.88486859e-01f, -9.99909118e-02f, 6.60412237e-02f, 7.80441239e-02f, -4.24326677e-03f,
  9.38623846e-02f, -7.66824335e-02f, -2.28618458e-01f, -4.17818874e-02f, 8.98880139e-02f, 6.96951598e-02f, -8.96530598e-02f, -1.24793060e-01f, -4.11342978e-02f, -1.42542467e-01f,
  -8.64623487e-01f, -2.12507918e-01f, -2.21537620e-01f, -1.82378903e-01f, 1.77484825e-02f, 2.55905449e-01f, -3.83611411e-01f, 3.67915630e-01f, 3.15121472e-01f, -3.20216388e-01f,
  3.05451378e-02f, 1.49903551e-03f, -3.59927386e-01f, -1.03676811e-01f, -1.73503026e-01f, -4.86530691e-01f, -6.57264590e-01f, -5.28535843e-01f, 1.23820923e-01f, 6.86583340e-01f,
  1.68827459e-01f, -3.98777097e-01f, -1.09593742e-01f, 1.57156140e-01f, 1.34568408e-01f, -1.30892590e-01f, -5.59603155e-01f, -2.21163079e-01f, 2.21817628e-01f, -6.55600250e-01f,
  -3.14571649e-01f, 1.96927726e-01f, 2.06456721e-01f, -1.40131637e-01f, -8.07757378e-02f, -3.01055387e-02f, -6.16021082e-02f, -4.39183339e-02f, 4.24247868e-02f, 1.20024934e-01f,
  -1.63091719e-02f, 2.79606193e-01f, -4.82937992e-02f, -4.99966852e-02f, -7.12543502e-02f, -2.02947925e-03f, 6.35301322e-02f, -5.04157208e-02f, -6.50882125e-02f, 1.50316909e-01f,
  -5.60068339e-02f, 9.44573507e-02f, 1.61617417e-02f, 2.21147254e-01f, 2.17376292e-01f, -3.26768756e-02f, 2.58657455e-01f, 4.10039961e-01f, 1.79496109e-01f, 1.02135064e-02f,
  -1.41683305e-02f, 5.31296507e-02f, 4.34988067e-02f, 1.17267273e-01f, -7.45932013e-02f, 2.27037049e-03f, -4.38736640e-02f, -3.08604278e-02f, -2.25561555e-03f, -6.94359839e-02f,
  4.30479348e-02f, 5.35945781e-02f, -5.60763478e-02f, -2.58867815e-02f, -4.91676405e-02f, 2.56952029e-02f, 2.22309027e-02f, -4.16885577e-02f, -4.09230068e-02f, -3.41808386e-02f,
  2.19685212e-02f, 5.88429570e-02f, -7.34009072e-02f, 9.68914479e-02f, -3.52554061e-02f, -4.76169363e-02f, -2.27843747e-02f, 1.45582125e-01f, -9.64266900e-03f, 7.67492354e-02f,
  -1.79211810e-01f, -8.65809098e-02f, -2.18335018e-01f, 1.43442541e-01f, 3.48153268e-03f, 3.69574912e-02f, -1.53410137e-01f, 1.41230121e-01f, -6.95947856e-02f, -3.12679186e-02f,
  1.25406474e-01f, -1.03586607e-01f, -1.63778752e-01f, 1.81794345e-01f, -1.62701964e-01f, 1.64499849e-01f, -3.80213745e-02f, -1.87027693e-01f, 1.50710404e-01f, 1.17900342e-01f,
  5.92728555e-02f, 6.69699013e-02f, -1.54957414e-01f, -1.69771180e-01f, 8.05901438e-02f, -1.67928278e-01f, -3.57377976e-01f, 6.42738789e-02f, -2.14504838e-01f, -5.47179937e-01f,
  2.83655971e-01f, -9.53753367e-02f, -2.29992867e-02f, 3.82780164e-01f, -9.64537486e-02f, -1.47944495e-01f, -2.64430493e-01f, 9.41294059e-02f, 1.02005139e-01f, 1.50869757e-01f,
  3.13161731e-01f, 5.07732451e-01f, 3.21874529e-01f, 1.70067430e-01f, 1.68830782e-01f, -1.56911805e-01f, -9.63939279e-02f, -1.00135477e-02f, 5.04867770e-02f, 2.48534530e-01f,
  1.71371639e-01f, -3.24582644e-02f, 1.33178815e-01f, 1.36888564e-01f, 6.81122467e-02f, 1.42954186e-01f, -7.78742954e-02f, -3.81622910e-01f, -3.17584604e-01f, -3.59472662e-01f,
  2.46398747e-01f, 3.32793817e-02f, 1.65636927e-01f, 9.57491621e-02f, -5.99052273e-02f, -3.21030733e-03f, 1.48559511e-01f, -2.10736208e-02f, 2.50497777e-02f, 4.18860465e-02f,
  1.43768311e-01f, 2.75776815e-02f, -9.61374938e-02f, -4.53447923e-02f, -1.59806386e-02f, 1.59719083e-02f, -6.25233445e-03f, -1.26833180e-02f, 3.55467200e-02f, 1.08815141e-01f,
  1.21647105e-01f, -1.21661182e-02f, -1.49160083e-02f, -5.46002164e-02f, 5.24076633e-02f, -4.45105620e-02f, -2.28482950e-02f, 5.92361912e-02f, -1.15994208e-01f, -3.34113315e-02f,
  -2.34726667e-02f, 4.21945155e-02f, 4.93204370e-02f, -6.73418939e-02f, 1.24460079e-01f, -6.94808960e-02f, -8.80760476e-02f, -5.39065935e-02f, 1.76675320e-02f, -2.10771784e-01f,
  -9.23615787e-03f, 3.00475787e-02f, 8.02541077e-02f, 5.38870059e-02f, 5.67877330e-02f, -3.91667783e-02f, -7.05738738e-02f, 7.75311440e-02f, -1.38904257e-02f, 2.55155936e-02f,
  4.56834845e-02f, -4.32779267e-02f, 1.23249507e-02f, -1.56024257e-02f, -3.43092307e-02f, 1.18835948e-01f, 1.16033025e-01f, 2.45368108e-02f, -1.13836154e-01f, -2.01454703e-02f,
  -1.54059544e-01f, 6.37685210e-02f, 1.95690870e-01f, 1.06289670e-01f, -4.32785377e-02f, -4.99521499e-04f, 9.15409178e-02f, -1.10046014e-01f, 1.19281178e-02f, 7.66039044e-02f,
  3.14464346e-02f, 8.31465498e-02f, -5.17633185e-02f, -6.09241202e-02f, -6.41756365e-03f, -2.86256783e-02f, 4.33207154e-02f, 6.99295327e-02f, 8.20133910e-02f, 1.23838075e-01f,
  6.02857135e-02f, 3.61326821e-02f, -6.30064830e-02f, -1.10121164e-03f, -1.40718669e-01f, 9.92108881e-02f, -5.26399873e-02f, -8.39866176e-02f, -1.46963090e-01f, -1.68584183e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 4)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 4;
const float L0_fan_Bp_bar_data[] = {
  -1.26111865e-01f, 9.30495560e-02f, -1.24349646e-01f, -1.84517771e-01f
};

// L1_fan_Wp (Shape: 6 x 16)
const int L1_fan_Wp_rows = 6;
const int L1_fan_Wp_cols = 16;
const float L1_fan_Wp_data[] = {
  -5.75243115e-01f, -2.11289793e-01f, -3.04958701e-01f, -1.62212878e-01f, 2.29998708e-01f, -7.36032054e-02f, -1.99859887e-01f, 2.15915814e-02f, -6.46297753e-01f, -6.13105409e-02f,
  -3.06629360e-01f, -8.37385431e-02f, -7.24652350e-01f, 1.27821326e-01f, 4.00769949e-01f, -1.17098056e-01f, 3.36004138e-01f, 2.22767115e-01f, -7.63368979e-02f, -5.64635992e-02f,
  -1.26747385e-01f, -8.43305439e-02f, -3.41732167e-02f, -2.39410073e-01f, 2.27061883e-01f, -7.32528746e-01f, 2.35559389e-01f, 1.91448241e-01f, 9.66760963e-02f, -1.22718886e-01f,
  3.87836576e-01f, 1.49421111e-01f, -5.49571991e-01f, -1.83418430e-02f, -5.24200387e-02f, 1.49230823e-01f, 2.07714960e-01f, 4.80292849e-02f, -3.77376437e-01f, -7.15114772e-02f,
  4.56106737e-02f, -1.97032336e-02f, 5.16730063e-02f, -8.01090300e-02f, -1.29050210e-01f, -2.30689898e-01f, 4.10398781e-01f, 1.68410376e-01f, -3.53747308e-01f, -2.22252291e-02f,
  -5.97599521e-02f, -3.83543931e-02f, -3.99501286e-02f, -2.26345301e-01f, 4.28773314e-01f, -5.41941859e-02f, -4.25047904e-01f, -5.73638678e-01f, -6.54538155e-01f, -5.74543834e-01f,
  4.91518497e-01f, -1.48810208e-01f, -2.78346807e-01f, -1.93330884e-01f, 6.94938004e-02f, -1.93825349e-01f, 2.56364316e-01f, 3.22000623e-01f, 2.85808474e-01f, -2.60401726e-01f,
  4.14730817e-01f, 1.57805711e-01f, -3.65332156e-01f, 7.35449255e-01f, 3.69106472e-01f, 3.77761573e-02f, -1.35303289e-01f, -2.75552869e-01f, -4.50068772e-01f, 1.71834633e-01f,
  4.79552597e-02f, -1.59198433e-01f, -1.52706243e-02f, -1.86250374e-01f, 2.50252694e-01f, 3.58717382e-01f, -4.16911870e-01f, -1.67481348e-01f, -6.45497799e-01f, -3.19603294e-01f,
  1.36076570e-01f, 3.57379764e-01f, 2.25865394e-01f, 6.68941364e-02f, -1.04715377e-01f, -2.24825382e-01f
};

// L1_fan_Wp_bar (Shape: 4 x 16)
const int L1_fan_Wp_bar_rows = 4;
const int L1_fan_Wp_bar_cols = 16;
const float L1_fan_Wp_bar_data[] = {
  -5.72954059e-01f, -3.18700045e-01f, 4.44729686e-01f, 2.68197387e-01f, 2.29993433e-01f, -5.83948269e-02f, 4.86285031e-01f, 3.69552374e-01f, -9.07820106e-01f, -6.21951759e-01f,
  -4.98222172e-01f, 1.11380517e-01f, -9.53040779e-01f, -1.22239351e-01f, -3.25687289e-01f, 5.73004410e-02f, 2.41664290e-01f, 4.05061841e-01f, -1.26991034e-01f, 7.07661584e-02f,
  1.74875006e-01f, 4.78329897e-01f, -9.21614707e-01f, -2.70421773e-01f, 4.10640180e-01f, 4.82892662e-01f, 8.75968874e-01f, 1.55780286e-01f, -1.23051897e-01f, 1.55579284e-01f,
  1.14030838e+00f, -1.64683163e-01f, -3.97827066e-02f, -1.83612168e-01f, 4.83899087e-01f, -1.52939800e-02f, 3.43633033e-02f, 2.50355452e-01f, 2.11864859e-01f, 5.46821356e-01f,
  -3.20694566e-01f, 2.33287841e-01f, -6.42493427e-01f, -3.23210597e-01f, -9.62872505e-02f, 7.19584525e-01f, -9.95019544e-03f, 3.97149682e-01f, 6.82509616e-02f, 3.07787418e-01f,
  7.01588213e-01f, 2.74899572e-01f, 3.77582498e-02f, 8.70922431e-02f, 4.50392485e-01f, 1.68741345e-01f, 6.39391363e-01f, 2.51789361e-01f, -9.43054497e-01f, -1.01887929e+00f,
  -4.43901479e-01f, 1.13556929e-01f, 5.25612891e-01f, -1.97293013e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 4)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 4;
const float L1_fan_Bp_bar_data[] = {
  6.16527013e-02f, 1.78430438e-01f, 2.07585305e-01f, 4.57239062e-01f
};

// L2_fan_Wp (Shape: 6 x 16)
const int L2_fan_Wp_rows = 6;
const int L2_fan_Wp_cols = 16;
const float L2_fan_Wp_data[] = {
  5.10733604e-01f, -1.89832836e-01f, -6.07444108e-01f, -5.79866707e-01f, -2.46921152e-01f, -1.19938441e-01f, 6.19955957e-01f, -2.24871635e-01f, -3.51772457e-01f, 5.47065318e-01f,
  3.92449081e-01f, -8.60727668e-01f, 4.04895216e-01f, -3.72647792e-01f, -4.02877145e-02f, 3.59437585e-01f, 1.80137694e-01f, 8.49832892e-01f, 2.39314392e-01f, -3.50819141e-01f,
  2.98971832e-01f, 1.38279527e-01f, -5.08403897e-01f, 7.14468598e-01f, -7.00406730e-01f, 2.92505264e-01f, 9.43341404e-02f, -3.74157503e-02f, -5.29190123e-01f, 3.91934142e-02f,
  -3.06397587e-01f, -1.19629018e-01f, 3.58373821e-01f, -4.53840643e-01f, -1.85724929e-01f, 9.14556812e-03f, -1.57052651e-01f, 9.80411023e-02f, 6.89138770e-02f, -4.63903457e-01f,
  8.49285543e-01f, -6.19185150e-01f, 4.33427721e-01f, -4.97918546e-01f, 6.88506007e-01f, 3.34622592e-01f, 1.65740121e-02f, -2.46229604e-01f, -7.12414861e-01f, -4.17473242e-02f,
  -6.41309246e-02f, 4.34172422e-01f, 2.86598235e-01f, 2.59234428e-01f, 4.11162734e-01f, 5.46253264e-01f, -5.74940324e-01f, 1.73434075e-02f, -5.18500090e-01f, 6.66579723e-01f,
  3.51153791e-01f, 3.61242481e-02f, -4.39483151e-02f, -1.89671189e-01f, -6.65021896e-01f, -4.03041750e-01f, 5.22564352e-01f, 2.52217725e-02f, 2.73926407e-01f, -4.01247153e-03f,
  -4.27225560e-01f, 1.05890465e+00f, 2.49589235e-02f, 6.32754147e-01f, -2.94681400e-01f, -1.69660524e-02f, 7.89882839e-01f, -2.18542874e-01f, 1.67614028e-01f, -2.76788443e-01f,
  -3.65049392e-01f, -3.07624638e-01f, -5.18981040e-01f, 3.93188655e-01f, -3.20556052e-02f, -2.71357775e-01f, 2.31929973e-01f, 3.18562239e-01f, 6.43216014e-01f, -4.29760456e-01f,
  -3.16799805e-02f, -4.56807673e-01f, -8.31863225e-01f, 4.22823846e-01f, 2.42610663e-01f, 8.99151564e-02f
};

// L2_fan_Wp_bar (Shape: 4 x 16)
const int L2_fan_Wp_bar_rows = 4;
const int L2_fan_Wp_bar_cols = 16;
const float L2_fan_Wp_bar_data[] = {
  4.66218382e-01f, 2.56467730e-01f, 1.24571598e+00f, -1.09424576e-01f, 6.82676911e-01f, 6.86570942e-01f, -6.99045956e-01f, 3.11454952e-01f, -3.67462337e-01f, 3.96735966e-01f,
  -8.91612649e-01f, -1.50615323e+00f, 4.89980280e-01f, -5.15225947e-01f, 4.75388646e-01f, 1.55987990e+00f, -4.33981001e-01f, -6.60556376e-01f, -3.64678890e-01f, -2.51057655e-01f,
  -1.48898721e-01f, 9.52494442e-01f, -2.09781211e-02f, 1.12470090e+00f, 3.31369877e-01f, -5.21854579e-01f, -1.03320038e+00f, -7.58063912e-01f, -5.50146878e-01f, 1.00858140e+00f,
  4.52175766e-01f, 7.40070403e-01f, -7.46272743e-01f, -2.43893728e-01f, 3.75360310e-01f, 2.46821910e-01f, 4.29050654e-01f, 1.69996187e-01f, -1.19251227e+00f, 9.04194474e-01f,
  -5.06087840e-01f, 5.23123622e-01f, -4.31864709e-01f, 4.06051427e-01f, -7.78693795e-01f, 1.31385535e-01f, 4.29755658e-01f, -6.65417790e-01f, -2.38875579e-02f, -5.48527062e-01f,
  -3.97258550e-01f, 6.58698320e-01f, 8.57177600e-02f, 6.10876381e-01f, 1.20228219e+00f, -7.03507721e-01f, -7.89985597e-01f, -6.84866488e-01f, -1.07498407e+00f, 1.14214563e+00f,
  1.02380455e+00f, 6.93790257e-01f, 5.17016232e-01f, 2.31372148e-01f
};

// L2_fan_Bp_bar (Shape: 1 x 4)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 4;
const float L2_fan_Bp_bar_data[] = {
  2.84371078e-01f, 1.66881517e-01f, 7.18151689e-01f, 4.31475431e-01f
};

// L3_linear_W (Shape: 12 x 16)
const int L3_linear_W_rows = 12;
const int L3_linear_W_cols = 16;
const float L3_linear_W_data[] = {
  7.91438103e-01f, -9.31215763e-01f, -7.43641496e-01f, 2.74857264e-02f, -6.80437624e-01f, -2.30161667e-01f, 4.14481074e-01f, -8.35761011e-01f, -4.76770371e-01f, -1.86646807e+00f,
  3.43851596e-01f, 5.37759960e-01f, -1.00497961e+00f, 3.60243410e-01f, -4.01688874e-01f, 1.47795767e-01f, -2.39202380e-01f, 6.41709924e-01f, -1.04748160e-02f, -1.07992387e+00f,
  -3.51712972e-01f, 1.03478700e-01f, 9.37104642e-01f, -3.11921120e-01f, -1.31270826e-01f, 5.24563789e-01f, 1.33804011e+00f, 1.11576188e+00f, -2.97860742e-01f, 8.41996446e-02f,
  2.77875811e-01f, 1.26730502e-01f, 8.62866998e-01f, -5.73890388e-01f, -1.44615972e+00f, 7.26991951e-01f, -4.03202772e-01f, -1.63888678e-01f, 7.79159963e-01f, 5.96754134e-01f,
  -6.61307573e-01f, -3.64367574e-01f, 1.38326454e+00f, -6.60474718e-01f, 4.07853872e-01f, -4.90859663e-03f, -4.95022625e-01f, -1.10881996e+00f, -1.34295428e+00f, 5.02901495e-01f,
  8.54129493e-02f, -4.96478558e-01f, 1.20410644e-01f, -4.03390974e-01f, -3.08965236e-01f, -1.20683753e+00f, 7.95121551e-01f, 2.63930869e+00f, -8.73186052e-01f, -1.45353585e-01f,
  -1.14717007e+00f, 1.48513794e-01f, -1.87563539e+00f, 4.01843190e-01f, 3.56668711e-01f, 7.59868562e-01f, -7.15037405e-01f, -2.01673612e-01f, -5.80487967e-01f, -9.59332347e-01f,
  -5.67900777e-01f, 4.57623482e-01f, 6.27540708e-01f, -9.40970898e-01f, -1.14527774e+00f, 7.39484206e-02f, 3.27897578e-01f, 3.08751822e-01f, -9.15265024e-01f, -5.29438257e-01f,
  -8.56097043e-01f, -1.68327010e+00f, 9.68141675e-01f, 7.31405199e-01f, 1.60863686e+00f, 1.00931323e+00f, -5.45201123e-01f, 4.88026798e-01f, 3.04385513e-01f, 3.63595486e-02f,
  4.53184962e-01f, 5.89524209e-01f, 3.77226882e-02f, 2.03411013e-01f, -2.11177260e-01f, -9.40891445e-01f, -1.01063216e+00f, -7.29703844e-01f, 9.24103931e-02f, -1.45283446e-01f,
  5.18727183e-01f, -5.15640020e-01f, -6.71067461e-02f, -8.66549075e-01f, 1.48457432e+00f, -1.32849169e+00f, 5.92784524e-01f, -8.65700662e-01f, 5.59560418e-01f, -9.92948413e-01f,
  -5.75592995e-01f, 5.03145196e-02f, 5.15929103e-01f, -1.24350083e+00f, 6.81107283e-01f, -1.28042296e-01f, -6.36953413e-01f, 3.48345876e-01f, 1.39441803e-01f, -2.29487523e-01f,
  -2.80804515e-01f, 4.91908900e-02f, -1.06164622e+00f, 6.49911642e-01f, 1.01025455e-01f, -2.93927759e-01f, -7.58790195e-01f, 5.50453246e-01f, 3.23595673e-01f, -9.03738737e-01f,
  -9.73939359e-01f, -2.02909142e-01f, -2.28597835e-01f, -1.84540972e-01f, -6.28797054e-01f, 9.89301682e-01f, -6.17919624e-01f, 5.62620699e-01f, 7.91388452e-01f, -1.49505889e+00f,
  -4.74255234e-01f, -9.94414926e-01f, 9.46861863e-01f, -2.66948760e-01f, 4.74369496e-01f, 1.02668202e+00f, 7.55530775e-01f, -6.77552164e-01f, 4.12830263e-01f, 1.16623747e+00f,
  9.59106207e-01f, 2.59744853e-01f, -1.36770666e+00f, -9.84951079e-01f, -1.37161028e+00f, 6.29632175e-01f, 6.40829325e-01f, -9.07238066e-01f, -1.01790905e+00f, -9.58621204e-01f,
  -8.42290521e-01f, 1.18885565e+00f, 5.13945282e-01f, 1.50508809e+00f, -1.32922447e+00f, 1.32326674e+00f, -1.25527406e+00f, 8.61093342e-01f, 1.54121983e+00f, -6.31660104e-01f,
  -1.71792066e+00f, -3.55499417e-01f, -8.40880454e-01f, -1.11379480e+00f, -1.13847804e+00f, 2.81689167e-01f, 1.04699039e+00f, 1.34177291e+00f, 5.44920087e-01f, -6.22787535e-01f,
  1.51616052e-01f, -8.33858490e-01f, 6.48936331e-01f, -5.35093844e-01f, -9.08456802e-01f, 1.69687164e+00f, 1.36765242e+00f, -6.12160087e-01f, 2.04263285e-01f, -1.26774740e+00f,
  -8.75664771e-01f, 5.23454607e-01f
};

// L3_linear_B (Shape: 1 x 12)
const int L3_linear_B_rows = 1;
const int L3_linear_B_cols = 12;
const float L3_linear_B_data[] = {
  -7.19344150e-03f, -3.78089249e-01f, 8.56517814e-03f, -2.96960413e-01f, -5.84921420e-01f, 2.13336349e-01f, -2.81395286e-01f, -4.66320276e-01f, 1.53584117e-02f, -1.34661004e-01f,
  1.18601143e+00f, 4.11534876e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 6, 4
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        16, 6, 4
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        16, 6, 4
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_linear
    linear_forward_pgm(
        buffer1, x_out,
        L3_linear_W_data, L3_linear_B_data,
        16, 12
    );
    }
    