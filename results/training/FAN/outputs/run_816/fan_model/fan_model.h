/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 32 (x1)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 32;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    float x3 = x * x * x;
    return 0.5f * x * (1.0f + tanhf(0.79788456f * (x + 0.044715f * x3)));
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 3 x 120)
const int L0_fan_Wp_rows = 3;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -9.46265459e-02f, -1.37779387e-02f, 5.80028355e-01f, -1.12371244e-01f, 1.36526242e-01f, 1.33823097e-01f, 1.11330397e-01f, -2.41916120e-01f, -1.71773195e-01f, -4.34721410e-02f,
  -4.87398840e-02f, -2.55508810e-01f, -1.79011583e-01f, -1.46059930e-01f, -8.52952302e-02f, 5.79229817e-02f, 5.50694242e-02f, 8.72937590e-02f, 3.23142000e-02f, -5.78996241e-02f,
  -6.51640445e-02f, 1.29805226e-02f, 1.16682313e-01f, 1.34982197e-02f, -2.05006097e-02f, 7.74187818e-02f, 1.43451944e-01f, 1.58139050e-01f, 1.03560917e-01f, -2.43174508e-02f,
  3.37791681e-01f, -1.17781982e-01f, 2.82574985e-02f, -7.01084286e-02f, 6.38346151e-02f, -8.11956227e-02f, 1.19465571e-02f, 1.03227273e-01f, -1.05496071e-01f, -6.29132539e-02f,
  3.74708362e-02f, -1.63004939e-02f, 2.16985755e-02f, 2.01014727e-02f, -6.60477430e-02f, 1.92717090e-02f, 5.71786277e-02f, -7.11423606e-02f, -1.64526491e-03f, -9.04464349e-03f,
  -6.55389996e-03f, 1.80401459e-01f, 1.48241594e-01f, 7.46809021e-02f, -1.39814848e-02f, -4.11826037e-02f, 6.66036457e-02f, 9.73603576e-02f, 1.42089069e-01f, 1.15356356e-01f,
  1.04541387e-02f, 5.33673950e-02f, -1.35067319e-02f, 2.98523530e-02f, -3.81780155e-02f, 4.67965491e-02f, -1.32903039e-01f, 1.09335324e-02f, 2.63433941e-02f, 4.19709682e-02f,
  3.41808759e-02f, 1.83375068e-02f, 1.34663573e-02f, 3.34765352e-02f, -3.45564038e-02f, 1.03224620e-01f, -4.16879095e-02f, 2.31684707e-02f, 3.47685143e-02f, 1.65618155e-02f,
  -1.63990632e-02f, 4.64411080e-02f, 4.05994104e-03f, -5.01227938e-02f, 4.80175391e-02f, -1.75100658e-02f, -7.05371946e-02f, 8.54812749e-03f, -2.93055624e-02f, 1.30314222e-02f,
  -1.63443033e-02f, 1.38453916e-01f, -9.34862420e-02f, -1.16339810e-01f, 9.23761278e-02f, 2.88628843e-02f, -3.50273810e-02f, -9.27951373e-03f, -7.49872252e-02f, -5.04886508e-02f,
  1.20704230e-02f, -7.50358263e-03f, 3.37876519e-03f, -1.50615564e-02f, 4.89425771e-02f, 9.92659945e-03f, 3.47741842e-02f, -5.96006736e-02f, -8.08051527e-02f, 4.29547541e-02f,
  1.39007956e-01f, 7.59449378e-02f, 1.15739532e-01f, 2.23417748e-02f, 8.83842781e-02f, -4.62379046e-02f, 8.92482996e-02f, 9.15274248e-02f, 4.16753143e-02f, 3.62274088e-02f,
  -2.85192639e-01f, -2.13671938e-01f, -1.32605866e-01f, -8.41193572e-02f, 1.13477008e-02f, -2.48532891e-01f, -4.28299278e-01f, -1.56865150e-01f, 2.78290194e-02f, -8.94618258e-02f,
  2.80945569e-01f, 2.45963022e-01f, 2.58600682e-01f, 1.20338798e-01f, -1.10243633e-01f, -3.58412713e-01f, -3.28292251e-01f, -1.73068911e-01f, 7.38353729e-02f, -3.55020314e-02f,
  -2.04477403e-02f, -8.43036622e-02f, 2.70544784e-03f, -1.17399797e-01f, -2.29510982e-02f, 7.17328638e-02f, -1.15599914e-03f, 1.32530020e-03f, -2.95248628e-02f, -1.98926255e-01f,
  1.06213659e-01f, -4.03054133e-02f, 5.26800081e-02f, 7.66015723e-02f, 1.38267875e-01f, -7.18844309e-02f, 4.21972834e-02f, 3.14207487e-02f, 5.53386919e-02f, -9.43980813e-02f,
  3.19734402e-02f, -3.00692418e-03f, -2.10777987e-02f, 4.94660959e-02f, 1.19578913e-02f, 1.50290169e-02f, -1.02141008e-01f, -7.96801299e-02f, -1.90561712e-02f, 9.16098505e-02f,
  3.29452269e-02f, 5.25479205e-02f, 1.77461002e-02f, -1.26313325e-02f, 2.02269796e-02f, -7.56641058e-03f, 3.25134397e-02f, 3.75535786e-02f, -1.04659095e-01f, -2.43230909e-01f,
  -7.41709396e-02f, 2.63796225e-02f, 1.43130710e-02f, -1.91274623e-03f, -4.47047949e-02f, 1.28050791e-02f, 6.24381099e-03f, -2.67816950e-02f, -6.08669668e-02f, -2.53268816e-02f,
  1.30283860e-02f, 2.72753406e-02f, 8.67137872e-03f, -4.08047857e-03f, 8.33025351e-02f, 1.42036076e-03f, -5.93135245e-02f, 2.35423110e-02f, 7.27458298e-03f, 2.38769837e-02f,
  4.11254354e-02f, 2.35523470e-02f, 8.27447623e-02f, 4.28673178e-02f, 1.78623386e-02f, -6.50122156e-03f, 1.10528897e-02f, 5.97485118e-02f, 2.17532068e-02f, -4.40799892e-02f,
  1.09482966e-02f, 9.92413163e-02f, -9.76640806e-02f, -8.90089348e-02f, -4.43336070e-02f, -2.76799928e-02f, 8.55661184e-03f, 3.82883847e-02f, 8.42901096e-02f, -3.91990803e-02f,
  -6.66084653e-03f, 5.21672238e-03f, 6.20741351e-03f, -1.55523214e-02f, -8.48653615e-02f, -1.53236678e-02f, -1.13159060e-01f, -2.70629413e-02f, 1.00382008e-02f, 1.05156936e-01f,
  4.61695492e-02f, -1.22622371e-01f, -6.97290897e-02f, -1.10865675e-01f, -3.88346426e-02f, -3.67795005e-02f, -8.72436538e-02f, -8.88604522e-02f, -1.52888626e-01f, -3.70120049e-01f,
  1.77496687e-01f, -2.41843145e-02f, 1.70922168e-02f, -4.01357515e-03f, 2.29623150e-02f, -1.07414030e-01f, -3.93104516e-02f, 2.70659234e-02f, -6.20520264e-02f, 4.96705920e-02f,
  -1.66729018e-01f, -5.57487682e-02f, 8.12128261e-02f, 1.56851515e-01f, 1.10538311e-01f, 1.61932200e-01f, 3.14196616e-01f, 3.91044557e-01f, 1.12153403e-01f, 6.92035705e-02f,
  1.54434219e-01f, 1.78916350e-01f, 1.90823451e-01f, 4.24254760e-02f, -2.81744433e-04f, -1.41717959e-02f, -5.14858961e-02f, 4.90514487e-02f, 4.24168743e-02f, 3.03006560e-01f,
  3.52361351e-02f, -1.21203184e-01f, 2.32791598e-03f, 6.97612390e-02f, -6.86896145e-02f, 3.83521691e-02f, -2.76387297e-02f, -6.41565397e-02f, -6.07226752e-02f, 3.47610600e-02f,
  -7.64888600e-02f, -1.18566528e-02f, 3.09021752e-02f, -1.83382686e-02f, 3.39996293e-02f, -1.18651427e-01f, 4.98550683e-02f, 5.01821823e-02f, -1.04916804e-02f, -1.05610713e-01f,
  -3.44032347e-02f, 5.36357090e-02f, -1.14735328e-01f, -1.54329464e-01f, 1.96957476e-02f, 1.09425738e-01f, -1.50237009e-01f, -9.90103856e-02f, -1.21534280e-02f, 7.76780769e-02f,
  1.09394126e-01f, 1.93651374e-02f, 3.35772112e-02f, -2.78246589e-02f, -6.72121271e-02f, -8.40865672e-02f, -3.27117704e-02f, 2.68498417e-02f, 6.62066117e-02f, -4.38434295e-02f,
  -9.06992406e-02f, 7.86570385e-02f, 9.14319977e-02f, -1.94813553e-02f, 8.43006596e-02f, -1.55341169e-02f, 8.16551968e-02f, -6.53719157e-02f, 4.51278239e-02f, -2.26863194e-02f,
  2.57928204e-02f, -1.76226981e-02f, -3.58545929e-02f, -1.59528404e-02f, -2.40825340e-02f, 1.79698523e-02f, 6.00184835e-02f, -2.90094074e-02f, 1.88940568e-04f, -1.04952186e-01f,
  -5.65159731e-02f, -2.45224405e-02f, 5.72563261e-02f, 1.04273282e-01f, 5.99443652e-02f, -6.09662905e-02f, -6.22627884e-02f, -1.51796108e-02f, -3.11539173e-02f, -2.74278293e-03f,
  -9.74752679e-02f, -2.08455883e-02f, -6.86866045e-03f, 5.47770634e-02f, -1.32026076e-02f, -3.73951830e-02f, 1.38357924e-02f, 2.31461041e-02f, -5.91587387e-02f, -2.22286023e-02f,
  8.13686568e-03f, 8.98469016e-02f, 1.13445871e-01f, 7.12836720e-03f, -4.00929973e-02f, 7.03774579e-03f, 7.35225379e-02f, -9.76187363e-02f, 4.41184640e-02f, 4.85227443e-02f
};

// L0_fan_Wp_bar (Shape: 26 x 120)
const int L0_fan_Wp_bar_rows = 26;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  2.58066595e-01f, 4.71285582e-01f, 2.84986198e-01f, 1.98610395e-01f, 8.97200704e-02f, 1.24702446e-01f, 3.80627632e-01f, 2.65824497e-01f, 1.54442620e-02f, 1.89404845e-01f,
  1.15886129e-01f, -3.76620330e-02f, 1.15613334e-01f, 3.61326300e-02f, 2.98038453e-01f, 2.46487662e-01f, 1.02240771e-01f, 1.38987273e-01f, -1.96777470e-02f, 1.16698571e-01f,
  -7.85839111e-02f, 7.63908327e-02f, 1.29411831e-01f, 1.09963812e-01f, 6.70890957e-02f, 1.55484804e-03f, 2.86286846e-02f, 1.20993815e-01f, 8.28033239e-02f, 1.18801206e-01f,
  1.79718975e-02f, 3.21500063e-01f, -1.81274578e-01f, -1.48745015e-01f, -8.46627355e-02f, -1.58350915e-02f, -3.55805806e-03f, -1.42388850e-01f, -1.07898777e-02f, -5.57237454e-02f,
  -6.72004074e-02f, -3.53927389e-02f, 3.18825319e-02f, 1.09249139e-02f, -4.35549021e-03f, -9.88324806e-02f, 4.98839207e-02f, 5.39975166e-02f, 4.26097363e-02f, -7.17417747e-02f,
  3.31844762e-02f, -4.37176563e-02f, 2.03948119e-03f, -1.53300986e-02f, 4.58504520e-02f, -1.85740262e-01f, 6.04318045e-02f, 4.42131944e-02f, -1.31824352e-02f, 4.06191945e-02f,
  5.18661365e-02f, 3.10831405e-02f, 6.60893694e-02f, 4.96403314e-02f, 7.85567015e-02f, -6.31608954e-03f, 6.29682606e-03f, -3.50619629e-02f, 1.35849300e-03f, 3.39582898e-02f,
  1.55462250e-02f, 2.87472765e-04f, 2.75608022e-02f, 4.69040088e-02f, 3.53482217e-02f, -4.32274342e-02f, -3.27453576e-02f, 9.74972621e-02f, -6.24061599e-02f, -3.24305706e-02f,
  -4.08773683e-02f, -4.46481742e-02f, -1.05458200e-02f, 6.20231517e-02f, 4.02290300e-02f, -4.81799580e-02f, -7.36057572e-03f, -8.31946135e-02f, -1.77711211e-02f, 4.30545211e-02f,
  -2.91689157e-01f, -6.07176311e-02f, -1.36246905e-01f, 5.65672368e-02f, -5.36779985e-02f, -1.02952674e-01f, 6.92627281e-02f, -1.00794829e-01f, 4.89442497e-02f, 7.12895812e-03f,
  -1.22106727e-02f, 6.31368998e-03f, -2.71188375e-02f, -7.27787986e-02f, -6.37638271e-02f, -1.08964227e-01f, -7.24917352e-02f, -7.62330368e-02f, -9.29282010e-02f, 1.62661429e-02f,
  -4.38077375e-02f, -1.90477282e-01f, -1.76976815e-01f, -4.64790612e-02f, -3.84305045e-02f, -1.34032890e-01f, -1.36840463e-01f, -1.01484425e-01f, -1.11480922e-01f, -1.86528578e-01f,
  -2.16106474e-01f, -1.59808770e-01f, -4.73509729e-03f, 2.99830437e-01f, 2.92720497e-01f, 3.04452747e-01f, 3.02836150e-01f, 1.15539193e-01f, 3.05261075e-01f, 1.42676920e-01f,
  -1.28157604e-02f, 1.32337540e-01f, 1.07877299e-01f, 6.40277043e-02f, 7.01471418e-02f, 2.37007022e-01f, 1.53335050e-01f, 6.42601550e-02f, 5.54514527e-02f, 1.48585498e-01f,
  2.68107355e-01f, 1.07723832e-01f, -1.71502903e-02f, 1.00876190e-01f, 5.53850979e-02f, 1.63975656e-01f, 1.26061291e-01f, -1.78825278e-02f, 3.88372242e-02f, 1.32238686e-01f,
  -1.63559258e-01f, -1.12718403e-01f, 1.99903265e-01f, -7.82247931e-02f, -1.35878056e-01f, -1.39533848e-01f, -6.76762983e-02f, -3.47082913e-02f, -1.08434759e-01f, 6.08831756e-02f,
  -9.08754319e-02f, -1.61353976e-01f, -2.85749789e-02f, -1.32987276e-01f, -7.46836364e-02f, -9.66424048e-02f, -1.14123508e-01f, 2.50786375e-02f, -1.94098614e-02f, 1.98317207e-02f,
  -7.39186481e-02f, 5.01680374e-02f, 4.79852632e-02f, -5.00575379e-02f, -5.07168174e-02f, 7.36587793e-02f, -4.15323414e-02f, -5.12697175e-02f, -4.31160517e-02f, -2.08609272e-02f,
  1.22060023e-01f, -4.99620251e-02f, 7.37857595e-02f, -6.57923669e-02f, 6.53519854e-02f, 7.98620135e-02f, -3.00135612e-02f, 4.92274612e-02f, 1.06599353e-01f, 5.19442521e-02f,
  -3.50085497e-02f, -2.52754949e-02f, 1.68648958e-02f, 9.91743803e-02f, 5.18991463e-02f, -2.36026309e-02f, 2.34858226e-02f, -7.44936839e-02f, -1.15561590e-01f, -8.67182463e-02f,
  -8.21012408e-02f, 5.89267686e-02f, 1.84571277e-02f, 4.18587178e-02f, 2.37340610e-02f, -4.23125084e-03f, 5.56836128e-02f, 5.32155633e-02f, 2.87355557e-02f, 3.41559155e-03f,
  1.57075703e-01f, 1.97547879e-02f, 4.72787544e-02f, 1.00976946e-02f, 6.07692152e-02f, -9.15799141e-02f, 1.03800856e-01f, -1.25417411e-01f, -1.25729397e-01f, 5.82954139e-02f,
  -7.81248137e-02f, -4.40992117e-02f, -8.68585631e-02f, 5.19032478e-02f, 3.59323770e-02f, -5.17085791e-02f, -7.92162120e-03f, 9.49933231e-02f, 7.55455345e-02f, -1.89601770e-03f,
  3.64482850e-02f, 4.87530231e-02f, 1.55059323e-01f, 1.43626407e-01f, 6.69336468e-02f, 1.13764971e-01f, -3.25540118e-02f, -2.54500005e-02f, 2.87237894e-02f, 1.74484372e-01f,
  -1.58924446e-01f, -7.75577649e-02f, 1.87171251e-01f, -7.94502161e-03f, 1.91975862e-01f, 8.59325677e-02f, 1.39744014e-01f, 3.52563187e-02f, 8.70543271e-02f, -1.45634450e-03f,
  -1.37701407e-01f, -1.05650693e-01f, -9.88969654e-02f, -1.63476914e-01f, -7.45222494e-02f, 9.71143395e-02f, 5.86582767e-03f, 4.09182906e-02f, -3.87564152e-02f, 7.92805031e-02f,
  6.34704977e-02f, 9.28902701e-02f, -7.46983886e-02f, 1.96390226e-02f, -3.31837907e-02f, -7.93237239e-02f, -1.36154015e-02f, 8.90183747e-02f, 7.00735226e-02f, 7.51660839e-02f,
  6.34501949e-02f, -1.37176335e-01f, -4.39085886e-02f, -1.33399338e-01f, -3.71794663e-02f, -1.27391860e-01f, 1.16754640e-02f, 3.31054702e-02f, -5.48136421e-02f, 1.45028204e-01f,
  -4.47533540e-02f, 5.66012450e-02f, -5.57152554e-02f, 4.29520532e-02f, 5.84324226e-02f, -2.04084739e-02f, -3.09642106e-02f, 5.91906020e-03f, -6.44240752e-02f, -3.64625379e-02f,
  -5.02715120e-03f, -1.48597285e-02f, 4.36840020e-02f, 1.19111603e-02f, -8.33621398e-02f, -3.64487208e-02f, 3.59719284e-02f, 2.93845329e-02f, -5.97790889e-02f, 6.42899470e-03f,
  -1.48589658e-02f, -4.09565791e-02f, 3.22455843e-03f, 7.64750615e-02f, 5.33319227e-02f, -2.82522477e-02f, 6.75305724e-02f, -2.80212201e-02f, 1.78324077e-02f, 2.53372127e-03f,
  1.03318743e-01f, 5.70135601e-02f, 7.84889832e-02f, -3.95859890e-02f, -7.66112581e-02f, 9.87367798e-03f, -8.35457966e-02f, 3.41803767e-02f, -1.42030185e-02f, -3.45062800e-02f,
  -6.07544649e-03f, 6.18310571e-02f, 2.81033237e-02f, 5.21959290e-02f, -7.15892389e-02f, -6.62072599e-02f, 6.99583441e-02f, -4.29343656e-02f, -1.33917639e-02f, 5.46715781e-02f,
  1.29444167e-01f, -1.08040273e-01f, -9.53855962e-02f, -3.54367010e-02f, 6.65278956e-02f, -8.23375210e-02f, -1.24317557e-01f, -7.38978460e-02f, 7.99209252e-02f, 1.67832226e-01f,
  3.65920849e-02f, 4.65398654e-02f, -1.71690974e-02f, 6.35962114e-02f, 1.18176363e-01f, 4.37413454e-02f, 5.86462626e-03f, 5.39366789e-02f, 1.45521853e-02f, -2.41219010e-02f,
  6.03797995e-02f, 1.33683026e-01f, 1.30920693e-01f, 1.43005013e-01f, -1.03264516e-02f, -9.09638871e-03f, 1.40066549e-01f, 1.12967625e-01f, 7.75167495e-02f, 1.17578469e-01f,
  -2.53141880e-01f, -2.42545456e-01f, -5.26394665e-01f, 7.81694129e-02f, 2.66602963e-01f, -1.22925371e-01f, -1.44077793e-01f, -5.84262833e-02f, 4.39710766e-02f, -1.26563340e-01f,
  7.90209547e-02f, 2.10664138e-01f, 5.56371212e-02f, 1.63258370e-02f, -1.43650100e-01f, -1.63035095e-01f, -1.01145782e-01f, -9.13728625e-02f, -4.25080247e-02f, 1.78243682e-01f,
  3.55965734e-01f, 2.97435313e-01f, 1.24655299e-01f, -1.60569046e-02f, 2.20915020e-01f, 2.26646587e-01f, -1.30266562e-01f, -1.09805437e-02f, 3.62968966e-02f, 1.71561614e-01f,
  -4.28702474e-01f, -3.72308344e-01f, 4.15960029e-02f, 1.71439081e-01f, -3.76346000e-02f, -1.59480795e-01f, -4.91597094e-02f, -2.97728889e-02f, -6.35174140e-02f, -1.29133269e-01f,
  -2.15485096e-02f, -5.54009676e-02f, 3.64343636e-02f, 4.43423949e-02f, -3.66984755e-02f, -1.20182648e-01f, -9.74154994e-02f, -2.18303278e-01f, -1.43041268e-01f, -2.05303028e-01f,
  3.01864862e-01f, 1.74085677e-01f, -2.56978959e-01f, -2.27632314e-01f, -2.07626432e-01f, -7.72286355e-02f, -1.30856305e-01f, -2.20201969e-01f, -3.10997009e-01f, -1.21431328e-01f,
  1.34798484e-02f, -1.50304977e-02f, -3.05556003e-02f, 1.85124334e-02f, 6.99708611e-02f, -4.05090395e-03f, 9.91364592e-04f, 4.19840440e-02f, -4.89311852e-02f, 4.85232808e-02f,
  -3.68392002e-03f, -4.43581343e-02f, 4.79531623e-02f, -6.61256462e-02f, 5.27994372e-02f, -7.25071207e-02f, 5.56661300e-02f, 3.26687582e-02f, 1.57323610e-02f, -1.85321234e-02f,
  -5.56207858e-02f, -7.24144280e-02f, 2.90930551e-02f, -1.25651518e-02f, -7.17220083e-03f, -5.85799366e-02f, -7.35067353e-02f, -4.52842750e-02f, -1.84707344e-02f, -3.95462178e-02f,
  1.21803127e-01f, -8.00739080e-02f, -1.26449093e-01f, 1.42246094e-02f, -1.81554519e-02f, -2.21766289e-02f, -2.84880176e-02f, -5.03139906e-02f, -9.14565101e-02f, -1.31109923e-01f,
  7.78423622e-03f, -4.70181182e-03f, -3.72752398e-02f, 2.42114589e-02f, 3.91349345e-02f, -5.37079424e-02f, 1.04013689e-01f, -6.75292462e-02f, -5.76329120e-02f, -6.29033446e-02f,
  2.20142249e-02f, -5.49104027e-02f, -1.42731979e-01f, -8.05420503e-02f, -7.44370967e-02f, 8.26139655e-03f, -2.09362209e-01f, -6.30715489e-02f, -2.43155345e-01f, -1.72874272e-01f,
  1.08047165e-01f, -2.50590473e-01f, 5.96613958e-02f, -1.49506092e-01f, -1.29669115e-01f, 3.03212237e-02f, -6.11085705e-02f, -2.34882962e-02f, -2.59732045e-02f, -9.48817581e-02f,
  1.95130631e-01f, 4.32984769e-01f, 3.07763517e-01f, 2.25165904e-01f, 2.07912236e-01f, -9.54090431e-02f, -1.85919687e-01f, 1.91319868e-01f, 2.44873807e-01f, -1.86590776e-02f,
  -6.57024011e-02f, -1.43932566e-01f, -3.02759428e-02f, -9.36906859e-02f, -2.10741535e-01f, 7.81238899e-02f, -1.13257185e-01f, -2.29833975e-01f, -8.77029002e-02f, -1.95482016e-01f,
  3.64095122e-01f, -1.45043865e-01f, 7.08434731e-02f, -3.62317450e-03f, -8.29155296e-02f, 4.52230014e-02f, 2.66803522e-02f, -1.11112399e-02f, 6.38007820e-02f, -1.47592813e-01f,
  -3.41275223e-02f, -4.39263098e-02f, -1.90277360e-02f, -1.26453727e-01f, -1.44569367e-01f, -5.77993579e-02f, -1.42782524e-01f, -1.14665858e-01f, -4.57963422e-02f, -5.05670458e-02f,
  -4.75506410e-02f, -1.08410083e-01f, 1.19412705e-01f, -5.92665002e-02f, -6.14205971e-02f, 5.40765002e-02f, -5.93998060e-02f, -1.58333220e-02f, 3.25075351e-02f, -1.09214947e-01f,
  -1.94952879e-02f, 7.87441134e-02f, 4.17072289e-02f, -4.89480700e-03f, 1.11509159e-01f, 3.20247114e-02f, -7.21213082e-03f, 4.73018885e-02f, 2.33706571e-02f, 4.87292558e-02f,
  2.20865346e-02f, 2.63235047e-02f, -6.15829006e-02f, 3.32936347e-02f, 2.70141624e-02f, 5.02482355e-02f, 3.36378776e-02f, 4.27339673e-02f, -6.71034604e-02f, -2.03281529e-02f,
  1.22539073e-01f, -4.73854430e-02f, -4.93404269e-02f, -4.65245508e-02f, -5.11351833e-03f, -4.27902676e-02f, -1.16346525e-02f, 2.67214165e-03f, -4.12497520e-02f, -8.12307224e-02f,
  1.03543356e-01f, 1.74906462e-01f, 1.27440155e-01f, 9.72776115e-02f, -7.21403584e-02f, -1.12908460e-01f, 1.64859071e-02f, -7.35957921e-02f, -7.74826035e-02f, -6.78177550e-02f,
  -1.73466373e-02f, 1.06276728e-01f, 4.67795655e-02f, -1.01185352e-01f, 4.73704794e-03f, 7.58734494e-02f, -1.19595543e-01f, 1.61050200e-01f, 2.49886345e-02f, -1.44671962e-01f,
  -1.52836695e-01f, 7.27754012e-02f, 3.13470066e-01f, 1.64714396e-01f, 4.07646075e-02f, 3.11716974e-01f, 2.27178082e-01f, 4.33647074e-02f, 2.53755152e-01f, -4.41117398e-02f,
  -8.42813309e-03f, 1.61014676e-01f, -4.46517408e-01f, 3.26534435e-02f, -1.42195866e-01f, -1.54718608e-01f, 6.97252899e-02f, 2.03255877e-01f, 1.14777923e-01f, -3.32638063e-02f,
  1.33274514e-02f, -1.29981384e-01f, -2.79268414e-01f, -2.41090879e-01f, -1.08814150e-01f, -5.35883494e-02f, -2.43756786e-01f, -3.92619193e-01f, -3.49626422e-01f, -9.08198506e-02f,
  -5.95068894e-02f, -1.26782939e-01f, -2.13966325e-01f, -1.37528688e-01f, -4.88460250e-02f, -1.67783380e-01f, -9.80046764e-02f, -1.60336152e-01f, -1.17342792e-01f, -1.25908211e-01f,
  -3.83039355e-01f, -1.45077482e-01f, -1.81365430e-01f, -1.36633022e-02f, -9.54394266e-02f, 7.33144432e-02f, -4.10174355e-02f, -1.19184982e-02f, 4.44442742e-02f, -3.28987204e-02f,
  -1.86358154e-01f, -3.99961025e-02f, -8.54933932e-02f, -9.45809558e-02f, -6.26626983e-02f, -5.38117737e-02f, 5.47679514e-03f, -1.32105350e-01f, -8.61150548e-02f, 3.16842794e-02f,
  4.52804193e-02f, -7.28577673e-02f, -1.50939330e-01f, -2.75152829e-03f, -4.28205431e-02f, -1.71486065e-01f, -1.08350016e-01f, 8.62415414e-03f, -2.06479467e-02f, 1.57120302e-01f,
  9.72259492e-02f, -3.70147042e-02f, 4.28528599e-02f, 1.50301559e-02f, 2.64586676e-02f, 1.34021440e-03f, -3.92469997e-03f, -3.69795412e-02f, 9.01567638e-02f, 2.59993169e-02f,
  1.28179174e-02f, 2.47495156e-02f, -9.09002498e-03f, 5.49453916e-03f, -2.99781212e-04f, 4.44843732e-02f, 3.22427019e-03f, 1.00155562e-01f, -2.37905066e-02f, -2.04662774e-02f,
  -3.12517621e-02f, 2.59727892e-02f, -1.71086751e-02f, 5.49420677e-02f, 5.06255403e-02f, 1.85307600e-02f, 1.81109887e-02f, 8.24738070e-02f, -4.39046249e-02f, -1.02889620e-01f,
  1.26791060e-01f, -1.40301764e-01f, -8.06483254e-02f, -1.34128956e-02f, -4.32244465e-02f, 7.45017081e-02f, -4.09008414e-02f, 3.05504426e-02f, -1.32868037e-01f, -4.36308496e-02f,
  -4.16205265e-02f, -6.68817712e-03f, -4.95999642e-02f, 2.46966630e-02f, -5.00583369e-03f, 4.47871201e-02f, 1.13366753e-01f, -1.03037231e-01f, -3.03242821e-02f, 1.19777597e-01f,
  1.86893806e-01f, 9.10008401e-02f, 6.44024312e-02f, 9.11428630e-02f, -3.59922126e-02f, -1.52974784e-01f, -6.18333220e-02f, -2.25310735e-02f, -1.05885252e-01f, 2.68764168e-01f,
  -1.82417095e-01f, -7.36163184e-02f, 2.21847534e-01f, -2.40449369e-01f, -3.07295024e-02f, 1.06957190e-01f, -3.72485034e-02f, -1.48715392e-01f, -2.41363626e-02f, -7.16532394e-02f,
  5.88154122e-02f, -2.24612914e-02f, -7.43158758e-02f, -7.66645819e-02f, 2.59832684e-02f, 8.01504869e-03f, -6.36787638e-02f, -8.88756886e-02f, -8.75473842e-02f, -1.44313544e-01f,
  -1.24161176e-01f, -2.41190210e-01f, -1.77494794e-01f, -1.37387425e-01f, -2.04365671e-01f, -1.54512003e-01f, -1.89778805e-02f, -4.00543287e-02f, 7.13660270e-02f, -1.19501904e-01f,
  -3.07658818e-02f, 9.55085456e-03f, -2.10249573e-02f, 5.58995968e-03f, 6.83282539e-02f, -5.89075424e-02f, 5.14117517e-02f, -8.67288634e-02f, -1.55311190e-02f, 4.29094918e-02f,
  -5.17145917e-02f, 5.53954877e-02f, 1.36621818e-02f, -6.33751526e-02f, 5.36116259e-03f, -1.22014895e-01f, -1.43449996e-02f, -5.79923391e-02f, -4.62240130e-02f, -5.77626042e-02f,
  -2.48068087e-02f, -7.29778782e-02f, -1.91740021e-02f, -3.36932056e-02f, 5.03932387e-02f, -6.22658059e-02f, -5.70024997e-02f, -8.49775150e-02f, -3.95211391e-02f, -1.65364563e-01f,
  -1.47547508e-02f, -3.80218625e-02f, -1.68108195e-02f, -8.24051127e-02f, -1.03394888e-01f, -1.17007212e-03f, 2.50069834e-02f, -5.74149266e-02f, -9.65416953e-02f, 5.26066869e-03f,
  -5.14030568e-02f, 1.23851180e-01f, -2.88105961e-02f, -4.30364721e-02f, -5.88730648e-02f, -7.42530823e-02f, 2.99455337e-02f, -5.90289794e-02f, 7.65400678e-02f, -3.24962288e-02f,
  3.63210239e-03f, 2.76708547e-02f, -6.12033680e-02f, 5.02426550e-02f, -1.22957546e-02f, -6.09289296e-02f, -3.53284739e-02f, -3.07020359e-03f, -4.38872427e-02f, 1.18146809e-02f,
  -2.02767879e-01f, 2.08207965e-01f, -4.56381887e-02f, -1.08684368e-01f, -7.93691631e-03f, 4.72152010e-02f, -6.90723583e-02f, 8.31289962e-02f, 6.83090165e-02f, -8.41742903e-02f,
  -1.76893789e-02f, -1.07207619e-01f, -1.16445124e-02f, -9.50173587e-02f, -3.61447483e-02f, 1.95435695e-02f, -1.69898286e-01f, -6.83749169e-02f, -4.05137204e-02f, -8.44873264e-02f,
  -9.91532579e-02f, -1.21223047e-01f, -1.78198680e-01f, -8.71739388e-02f, -5.25076352e-02f, -9.80874300e-02f, -6.20385073e-02f, -1.13152161e-01f, -2.17458582e-04f, -2.96485215e-01f,
  3.84982556e-01f, -5.02456427e-01f, 3.09584200e-01f, 6.81854039e-02f, -1.98853984e-01f, -1.66120231e-01f, -3.96655023e-01f, -7.56954849e-02f, -9.21234675e-03f, -1.50107101e-01f,
  -3.46379161e-01f, -5.93509786e-02f, 1.00809686e-01f, 1.62065312e-01f, 1.78932980e-01f, 5.56692705e-02f, 2.00694606e-01f, 5.01509964e-01f, 3.55479360e-01f, 9.30964295e-03f,
  -1.79915443e-01f, 5.75772300e-03f, 2.63577968e-01f, 1.93408892e-01f, -1.33405760e-01f, 1.18176527e-02f, 8.98702443e-02f, -1.48732319e-01f, -5.61178885e-02f, -2.12214887e-02f,
  -1.04356609e-01f, -7.74078891e-02f, 2.75398344e-01f, -7.46121332e-02f, -3.17443945e-02f, 1.38039559e-01f, -1.02462973e-02f, -2.17241347e-02f, -4.63736290e-03f, 2.02379953e-02f,
  -4.15959209e-02f, -5.49010895e-02f, 9.24186334e-02f, -9.96278897e-02f, 4.29312102e-02f, -1.17196692e-02f, 1.20302223e-01f, 1.76858142e-01f, 7.37456456e-02f, -1.61597207e-01f,
  -1.75913885e-01f, -2.04276517e-01f, -4.22332063e-02f, 4.76543838e-03f, 5.91910966e-02f, 1.28218621e-01f, -6.98863789e-02f, 5.92978410e-02f, 1.32244125e-01f, -4.23154309e-02f,
  -3.08480617e-02f, 3.67230549e-02f, -1.08097531e-02f, -2.42689755e-02f, 2.56485213e-03f, -1.69685539e-02f, 7.58735687e-02f, -8.59394390e-03f, 1.47062028e-02f, -1.85167952e-03f,
  6.60940830e-04f, 7.03307707e-03f, -1.83883461e-03f, -4.45135459e-02f, 3.52266394e-02f, 3.76216844e-02f, 7.81028951e-03f, -3.59265245e-02f, 4.30211388e-02f, -4.68399152e-02f,
  7.58627877e-02f, 8.39243531e-02f, 9.95833129e-02f, 1.35808708e-02f, 2.88566714e-03f, 4.45634201e-02f, 8.05547740e-03f, -4.20640148e-02f, -5.02949506e-02f, -6.65563270e-02f,
  -1.84062943e-01f, 2.41418794e-01f, 2.20384486e-02f, 1.10363409e-01f, -9.09919501e-04f, -2.50829216e-02f, -5.83855622e-03f, 1.60233292e-03f, -1.24180086e-01f, -2.32822672e-02f,
  -7.24343732e-02f, 1.17490798e-01f, -8.44205096e-02f, -5.67958280e-02f, 1.46300673e-01f, -1.73911918e-02f, -1.44673318e-01f, 2.88127363e-02f, 3.03690229e-02f, -6.14566877e-02f,
  -1.03424855e-01f, 9.59804803e-02f, 2.53155418e-02f, 9.47962422e-03f, -2.29931045e-02f, 2.09597453e-01f, -6.14343993e-02f, -4.30248082e-02f, 6.59081191e-02f, -5.66291288e-02f,
  -4.61744249e-01f, 1.22045159e-01f, 2.39790455e-02f, -1.95522040e-01f, 1.76263794e-01f, 2.23186806e-01f, 2.34562919e-01f, -4.69989004e-03f, -1.15756489e-01f, -2.68065743e-03f,
  1.47767067e-01f, 3.50387916e-02f, -1.31340012e-01f, 6.77147657e-02f, 6.85284659e-02f, 1.55960679e-01f, 1.83731988e-01f, -1.15657136e-01f, -8.17101151e-02f, -3.12874205e-02f,
  2.55619809e-02f, -1.00535333e-01f, -1.65635705e-01f, -9.14462954e-02f, -1.08927369e-01f, 4.22167219e-02f, -1.72156245e-02f, -4.84159924e-02f, 2.17989638e-01f, 1.30197957e-01f,
  -1.23240963e-01f, -5.50959557e-02f, -4.42503160e-03f, -8.07090849e-03f, 1.49369329e-01f, -1.21447854e-01f, 3.44530381e-02f, -1.15317367e-01f, 9.61962640e-02f, -7.18192607e-02f,
  8.79866332e-02f, -2.45238980e-03f, -4.27005254e-02f, -6.98030815e-02f, -8.84755105e-02f, -2.37091491e-03f, -1.68019846e-01f, -2.19265148e-01f, -1.28695101e-01f, -9.65167880e-02f,
  9.35570970e-02f, 5.08414395e-02f, -4.57746089e-02f, -6.24062978e-02f, -1.72119632e-01f, -4.88239340e-02f, -9.64919180e-02f, -1.09005913e-01f, -1.24574348e-01f, -2.21250072e-01f,
  2.53193695e-02f, 1.42725855e-02f, 4.40584160e-02f, -1.39126917e-02f, 5.18839993e-02f, 3.75452787e-02f, 6.01631962e-02f, 7.78008923e-02f, 1.58148352e-02f, -5.64960837e-02f,
  1.62100084e-02f, 3.55714858e-02f, -3.67399585e-03f, -6.48438483e-02f, -2.15548873e-02f, 8.44279602e-02f, 3.51540074e-02f, -1.98146817e-03f, -4.84653525e-02f, 6.56574965e-03f,
  1.90783832e-02f, -6.38071224e-02f, -2.62620095e-02f, -8.08506757e-02f, 9.38534588e-02f, 2.17369422e-02f, 1.18306717e-02f, 1.17613329e-02f, -1.42264187e-01f, 1.98856406e-02f,
  -3.31672221e-01f, 2.35897377e-01f, -1.13609873e-01f, -6.93623871e-02f, 1.96180660e-02f, -8.88472516e-03f, 2.25416590e-02f, -5.20092957e-02f, 5.62623776e-02f, -7.41881356e-02f,
  7.18797371e-02f, -4.70557921e-02f, -3.95981893e-02f, -2.25072354e-02f, -4.67599854e-02f, -1.13648146e-01f, 5.21253757e-02f, -3.40059064e-02f, -1.87252797e-02f, -4.14046086e-02f,
  -7.67021477e-02f, -1.79811090e-01f, -2.94104040e-01f, -2.29949027e-01f, -1.10708073e-01f, -1.70673922e-01f, -1.23017244e-01f, -1.01958051e-01f, -1.52395904e-01f, -1.87480763e-01f,
  5.07085741e-01f, 4.58925039e-01f, 5.54641597e-02f, 2.63027400e-01f, -1.06883049e-01f, -2.90463954e-01f, -1.51619285e-01f, -1.36058882e-01f, 7.87801817e-02f, 1.13917597e-01f,
  4.40112017e-02f, -1.64712921e-01f, -1.37668505e-01f, -2.33573094e-01f, -1.68052599e-01f, -2.81267893e-03f, 7.79484212e-02f, -4.11148407e-02f, -3.66694987e-01f, -1.42835513e-01f,
  -1.01131029e-01f, -1.96387675e-02f, 3.84057276e-02f, -1.61020625e-02f, 1.82999119e-01f, -8.41914639e-02f, 1.45788431e-01f, 7.29043186e-02f, 7.76957870e-02f, 4.44902956e-01f,
  1.85763896e-01f, 4.08527821e-01f, -3.50237966e-01f, -1.07077599e-01f, 8.03144053e-02f, 1.01825558e-01f, -3.31853256e-02f, 1.78029135e-01f, -2.48677842e-02f, 6.09176559e-03f,
  6.67762160e-02f, 5.41941039e-02f, 2.90624071e-02f, 5.78549877e-02f, -8.28634854e-03f, -4.23441548e-03f, 9.59095880e-02f, 3.15529816e-02f, -6.81076497e-02f, -3.07781603e-02f,
  -1.24641191e-02f, 3.66039164e-02f, -2.85726935e-02f, -4.45373803e-02f, 2.65715756e-02f, -2.06878021e-01f, 2.95633208e-02f, 4.39268984e-02f, 3.28464508e-02f, 2.77384043e-01f,
  -1.12183042e-01f, 2.33295076e-02f, -5.75434156e-02f, 9.56014767e-02f, -9.61279497e-02f, 4.11873236e-02f, 5.55617101e-02f, -6.27145469e-02f, -8.55341852e-02f, 3.68242082e-03f,
  -5.58370017e-02f, -3.26809138e-02f, -2.10289024e-02f, 6.50199782e-03f, -1.65784045e-03f, -5.04587591e-03f, 3.68369482e-02f, -4.42766026e-02f, -6.71681985e-02f, -4.27749641e-02f,
  -3.34047037e-03f, 1.86173338e-02f, 1.17356423e-02f, -5.60515895e-02f, -6.53484091e-03f, 2.97367908e-02f, -3.34912650e-02f, 3.24490592e-02f, -8.92925635e-02f, 6.96639270e-02f,
  -4.77267392e-02f, -5.53438723e-01f, 9.82148722e-02f, 5.93788996e-02f, 9.25730765e-02f, 2.00276487e-02f, 1.41956285e-02f, -2.44217739e-02f, 2.64261086e-02f, 2.12913994e-02f,
  -6.60455003e-02f, 1.04444157e-02f, 1.09002262e-01f, -6.97468072e-02f, -1.72588766e-01f, 2.41423044e-02f, -1.02355838e-01f, -3.86477113e-02f, -1.07366815e-01f, -2.27779094e-02f,
  -1.23653099e-01f, -1.59951225e-01f, -1.58015162e-01f, -7.72516355e-02f, -8.85248482e-02f, -2.55208313e-01f, -1.65141284e-01f, -1.68157309e-01f, -2.74721324e-01f, -1.09891325e-01f,
  7.32783675e-01f, -3.38280052e-01f, -1.53481171e-01f, 2.47157469e-01f, 4.66150464e-03f, 8.06280226e-02f, -1.22753710e-01f, 9.92080718e-02f, 2.80176818e-01f, -1.00381160e-03f,
  -2.32843962e-02f, 1.21628672e-01f, 1.02404825e-01f, 6.68512136e-02f, -2.89835650e-02f, -7.62422457e-02f, 8.67131948e-02f, 9.17876363e-02f, 1.93952277e-01f, 6.86591864e-02f,
  -3.05294301e-02f, 4.14450914e-02f, 2.12936580e-01f, -3.42451371e-02f, -2.17333272e-01f, -1.96721982e-02f, -1.66340664e-01f, -1.50162846e-01f, -2.43742600e-01f, -2.54286438e-01f,
  -3.58251095e-01f, -1.35870114e-01f, 6.15962297e-02f, 6.65523484e-02f, -9.77177173e-02f, 6.04141951e-02f, -2.29083467e-02f, -2.56459527e-02f, 2.91598663e-02f, -1.35305617e-02f,
  -1.40065178e-01f, -5.12284264e-02f, -7.92969614e-02f, -8.59692395e-02f, 2.59252489e-02f, 7.18836784e-02f, -9.54549387e-02f, -4.59841639e-02f, -8.94466564e-02f, -2.19456285e-01f,
  -2.46719822e-01f, -1.24518424e-02f, -6.25129032e-05f, -3.49757113e-02f, -6.42422168e-03f, 1.20365195e-01f, -1.97843805e-01f, -8.28833133e-02f, -2.48785280e-02f, -3.64755690e-02f,
  5.90635277e-02f, 3.15847923e-03f, -4.60206196e-02f, -2.31522862e-02f, 4.22438830e-02f, 8.27263221e-02f, 5.90200052e-02f, 3.85040557e-03f, -1.21839102e-02f, 1.43848155e-02f,
  -2.90627778e-02f, 5.99995889e-02f, -8.78329724e-02f, 8.40914696e-02f, 2.90933494e-02f, -5.37319891e-02f, 1.26945991e-02f, -4.04139310e-02f, -7.59631172e-02f, 1.99198665e-04f,
  1.87643897e-02f, -5.89703061e-02f, 1.81462374e-02f, -2.08069324e-01f, -4.65418659e-02f, -3.26964110e-02f, -3.70372795e-02f, -8.34793672e-02f, 1.65039338e-02f, 6.14291392e-02f,
  7.36318380e-02f, 1.72374770e-02f, 2.33080648e-02f, 4.46900204e-02f, -1.17142789e-01f, -2.75132488e-02f, -4.13324758e-02f, -8.53418000e-03f, -6.77583963e-02f, -6.13252036e-02f,
  -5.70392050e-02f, 3.50867547e-02f, -9.03987810e-02f, -1.60599090e-02f, 6.29305840e-02f, 1.04486682e-01f, -5.56888208e-02f, 8.63924772e-02f, -7.83847868e-02f, -1.54459268e-01f,
  3.69156823e-02f, 2.50016063e-01f, 3.44120264e-01f, 1.59012616e-01f, -3.64046507e-02f, 2.47070193e-01f, -1.55462604e-02f, 4.37414646e-02f, 2.74136275e-01f, 4.07068968e-01f,
  -7.13533580e-01f, 3.00191104e-01f, 3.34396809e-01f, -2.47942075e-01f, 5.90859614e-02f, 2.42047146e-01f, 4.44913983e-01f, 3.67063135e-02f, -1.30661950e-01f, 7.74028897e-02f,
  1.00756086e-01f, -2.15786248e-01f, -9.58798230e-02f, 1.17552895e-02f, -1.35946386e-02f, 2.35563233e-01f, 2.93379337e-01f, -8.06675330e-02f, -1.98281661e-01f, -2.18694180e-01f,
  -1.40688857e-02f, -2.92353749e-01f, -3.23673844e-01f, -1.12091996e-01f, -7.29183704e-02f, -1.50203452e-01f, 3.64300199e-02f, -8.15351307e-02f, 1.24545127e-01f, 2.96031870e-02f,
  -5.80324531e-02f, 1.69292502e-02f, -1.41016528e-01f, -2.13389844e-01f, -1.06661171e-02f, -9.94805098e-02f, 7.04058036e-02f, -1.30227894e-01f, -8.38912576e-02f, 2.13574879e-02f,
  -1.39382416e-02f, -4.87451740e-02f, -1.32091753e-02f, 4.56443755e-03f, -1.21817559e-01f, 7.49170873e-03f, -3.32894400e-02f, -3.95801738e-02f, 2.19889488e-02f, 1.38033971e-01f,
  6.12454638e-02f, 4.17106366e-03f, -7.83216357e-02f, 1.47632241e-01f, 3.35162543e-02f, -1.84748098e-01f, 1.03317402e-01f, -1.19220294e-01f, -1.30646273e-01f, -1.94125235e-01f,
  -1.30854519e-02f, 5.29152267e-02f, -1.42443692e-02f, -4.95626256e-02f, -8.90629888e-02f, 2.43259780e-02f, 8.55479687e-02f, -7.90979788e-02f, -5.53199314e-02f, -2.89537068e-02f,
  -3.26391459e-02f, 1.13329245e-02f, -9.70303491e-02f, 2.47514551e-03f, -1.15095228e-02f, 7.36813247e-03f, -4.84935194e-03f, -1.55624840e-02f, 4.32439260e-02f, -4.11396883e-02f,
  1.43897599e-02f, 2.20678076e-02f, 1.00030629e-02f, -2.29092781e-02f, 9.47786346e-02f, 9.44296122e-02f, -4.40190695e-02f, -6.76375777e-02f, 3.42779234e-02f, -3.25540081e-02f,
  -3.33888948e-01f, 1.01079620e-01f, -1.44281462e-01f, -1.15138978e-01f, -2.40722317e-02f, -3.11202276e-02f, -7.82633647e-02f, 4.90695052e-02f, 1.28812781e-02f, -9.37086716e-02f,
  6.23099543e-02f, -8.57024342e-02f, 2.28015962e-03f, 5.46897762e-02f, -1.33309498e-01f, -9.30567011e-02f, -3.85797992e-02f, -9.15414095e-02f, 6.16223924e-02f, -2.48450004e-02f,
  9.38124582e-02f, -1.75651386e-01f, -1.82020709e-01f, -2.81875003e-02f, -5.58169410e-02f, -2.33293548e-01f, -1.83565378e-01f, -1.92045569e-01f, -2.17492819e-01f, -3.19985598e-01f,
  -2.54873335e-01f, -1.60684988e-01f, -2.78454833e-02f, -1.90263808e-01f, -3.11830342e-01f, -3.08879435e-01f, -3.15785140e-01f, -1.07235700e-01f, -1.41474038e-01f, -1.81098416e-01f,
  -5.22469580e-02f, -7.91460797e-02f, 7.13717043e-02f, -8.26220512e-02f, -2.08283942e-02f, -2.98677851e-02f, -1.82944223e-01f, -1.60810679e-01f, -2.02542767e-01f, -2.59957522e-01f,
  -2.27657571e-01f, -1.61834389e-01f, -1.15189143e-01f, 1.31373536e-02f, -8.60703215e-02f, 2.01533958e-02f, -3.91841084e-02f, 1.33660994e-02f, 2.77462620e-02f, -9.89183225e-03f,
  7.89429024e-02f, -1.68843195e-01f, 9.26844105e-02f, -3.39458114e-03f, -5.09545207e-02f, -8.76774266e-02f, -8.08824971e-02f, 9.38899070e-02f, -8.81182477e-02f, -7.04908818e-02f,
  -5.36118224e-02f, -1.22968003e-01f, -6.87236041e-02f, -1.39401956e-02f, -1.23318478e-01f, -1.62501395e-01f, 4.42228420e-03f, -5.79795800e-02f, -7.67532885e-02f, -1.53038010e-01f,
  -3.80961411e-02f, -1.30718067e-01f, 4.62668762e-02f, 7.35715777e-02f, 5.44687221e-03f, -1.28267258e-01f, 3.55988182e-02f, 6.45018928e-03f, 7.74740875e-02f, 5.47592528e-02f,
  -1.82452556e-02f, -2.09526364e-02f, 5.84623665e-02f, -9.83575173e-03f, -5.80486171e-02f, -1.04405433e-02f, -4.19897810e-02f, -6.09351741e-03f, 3.09682935e-02f, 5.21711335e-02f,
  -4.31899130e-02f, 5.24449833e-02f, 2.96867033e-03f, 5.78805096e-02f, -2.03401577e-02f, 2.55755894e-03f, 6.04729727e-02f, -7.03607351e-02f, 1.00043781e-01f, -9.76792797e-02f,
  -9.45341736e-02f, 5.93087040e-02f, 1.19140325e-02f, 8.44348744e-02f, -5.61252981e-02f, 7.96143152e-03f, -1.26050040e-02f, -4.85038348e-02f, 3.14426534e-02f, -1.37750894e-01f,
  3.37221742e-01f, -1.46773262e-02f, 7.66825750e-02f, 4.81961742e-02f, 5.41558564e-02f, 3.91896116e-03f, 2.90378556e-02f, -1.23921633e-02f, 5.40926009e-02f, -7.05745742e-02f,
  -5.63297831e-02f, -5.54977804e-02f, 1.09356500e-01f, 1.49405543e-02f, -7.99399316e-02f, -2.24489234e-02f, -9.71497521e-02f, -7.06350803e-02f, -3.97573970e-02f, -2.40485594e-02f,
  -3.67226899e-02f, -3.52951959e-02f, -1.76121108e-02f, 1.19163565e-01f, -5.42903505e-02f, 7.20074922e-02f, 1.63375765e-01f, 4.30042110e-02f, 1.51701897e-01f, 4.62357625e-02f,
  -2.11170629e-01f, -8.34572613e-02f, -1.20791838e-01f, 3.88860032e-02f, 4.89907525e-02f, -3.63601535e-03f, -7.45499432e-02f, 2.84096394e-02f, 1.08744755e-01f, -2.76025012e-02f,
  -1.61020029e-02f, 4.83280458e-02f, -7.24164303e-03f, 3.52993086e-02f, -6.18305132e-02f, -1.63512921e-03f, 1.90991648e-02f, 1.76192019e-02f, -1.92452653e-03f, -1.69981986e-01f,
  3.00935339e-02f, 6.10646158e-02f, -2.82323323e-02f, 6.01487979e-02f, 5.68386428e-02f, 5.88286817e-02f, 8.19490328e-02f, 1.47145186e-02f, -5.09970933e-02f, 1.09209731e-01f,
  1.46364439e-02f, -1.63968399e-01f, 8.35303217e-04f, 5.22432290e-02f, 8.80265459e-02f, 2.14296784e-02f, -9.72511899e-03f, 3.18085626e-02f, -2.12958921e-02f, -5.10794967e-02f,
  -7.45783374e-02f, 9.21046548e-03f, -2.47305743e-02f, -7.85141215e-02f, -1.38774872e-01f, -2.61643883e-02f, -5.58850579e-02f, -1.09720640e-01f, 2.62025744e-02f, -2.30233967e-02f,
  -2.75470763e-02f, -1.81862172e-02f, -9.25285891e-02f, -2.73530575e-04f, -3.28485183e-02f, 2.45420691e-02f, -6.81832731e-02f, -9.97387618e-02f, -5.98225072e-02f, -1.40873343e-01f,
  2.13555992e-02f, 2.55728867e-02f, 4.32220213e-02f, 4.15254496e-02f, -8.38248953e-02f, -2.72385846e-03f, -3.89037393e-02f, -3.23813641e-03f, 7.05968365e-02f, 4.73971553e-02f,
  -1.04154432e-02f, -4.54070121e-02f, -3.86048779e-02f, 1.30196847e-02f, 2.58827154e-02f, -3.61483321e-02f, -5.51676713e-02f, 5.16725355e-04f, -9.24317688e-02f, -3.01773995e-02f,
  5.40748890e-03f, 5.66558950e-02f, -5.08860946e-02f, 3.52358818e-02f, -1.07891262e-01f, 2.42228359e-02f, -6.40452728e-02f, -1.22677267e-01f, -7.42209144e-03f, 4.19265591e-02f,
  1.16105415e-01f, -8.48698840e-02f, -1.07184879e-01f, -8.40787590e-02f, -2.68242192e-02f, -2.08375156e-02f, -5.71707089e-04f, -8.63488540e-02f, 5.21352552e-02f, -1.04391232e-01f,
  -1.02145784e-01f, -1.19298391e-01f, -1.74326114e-02f, -2.94269249e-02f, -9.54411328e-02f, -2.66645793e-02f, 1.43326102e-02f, -6.05203100e-02f, -1.05000455e-02f, -3.33160907e-02f,
  7.20305741e-02f, -4.36167531e-02f, -1.57287508e-01f, 6.10225834e-02f, -3.84203829e-02f, -6.91012591e-02f, -2.07952987e-02f, -9.56213195e-03f, 1.94420398e-04f, -8.93728510e-02f,
  8.26329291e-02f, 9.57566798e-02f, 3.37383430e-03f, -5.71924672e-02f, 3.39450836e-02f, -2.25261692e-02f, 1.35805765e-02f, 3.06246858e-02f, 2.53445525e-02f, 6.71209618e-02f,
  9.99381542e-02f, 2.53339171e-01f, 2.19941124e-01f, 4.88068089e-02f, -3.69578712e-02f, -6.25815690e-02f, -7.50226751e-02f, -4.67327870e-02f, -6.57756254e-02f, -6.02723174e-02f,
  7.33972043e-02f, 5.09718060e-02f, 6.11057281e-02f, 3.62843536e-02f, 2.64888462e-02f, 9.73779187e-02f, -1.40048694e-02f, 6.36384115e-02f, 3.61860357e-02f, -1.33086339e-01f,
  4.72205542e-02f, 5.34570776e-02f, 1.88806597e-02f, 5.61451837e-02f, 7.80619634e-03f, -8.20896327e-02f, 1.03343837e-01f, -3.13701965e-02f, 9.34136212e-02f, 8.96066949e-02f,
  8.06866810e-02f, 1.01138175e-01f, -6.06778916e-03f, 1.02723345e-01f, 4.79193814e-02f, 8.01031440e-02f, 8.31994191e-02f, 8.12753215e-02f, 4.78995144e-02f, 9.81110707e-02f,
  9.85810757e-02f, 6.07857704e-02f, -3.39421742e-02f, 3.04583125e-02f, 3.27031454e-03f, 9.85257104e-02f, -2.08581593e-02f, 9.82821733e-02f, 1.22754231e-01f, 7.14186430e-02f,
  -1.92233380e-02f, -3.79386321e-02f, 1.62178371e-02f, 8.22912157e-02f, 2.91771125e-02f, 8.36979523e-02f, -2.04325635e-02f, -5.02303578e-02f, 6.29945174e-02f, 5.64100668e-02f,
  2.34606173e-02f, 6.01360872e-02f, -1.29610850e-02f, 5.56103187e-03f, 2.96696499e-02f, 2.58363970e-03f, -4.69972529e-02f, 7.24897860e-03f, 5.57845533e-02f, 5.53380698e-02f,
  -6.68148622e-02f, -3.15754265e-02f, -8.28203186e-03f, 3.39034460e-02f, -7.28968382e-02f, -3.40229981e-02f, 9.54275429e-02f, -1.29460143e-02f, 5.39333709e-02f, 1.91575531e-02f,
  4.84637432e-02f, 5.07755689e-02f, 2.76978798e-02f, -9.02363732e-02f, -4.91533317e-02f, 4.61591184e-02f, 1.43281678e-02f, -6.51769340e-02f, -9.44900792e-03f, -1.80624193e-03f,
  5.49337342e-02f, -7.04840347e-02f, 2.32665683e-03f, 6.87800646e-02f, -3.71682867e-02f, -2.88938079e-02f, 5.27147502e-02f, -2.84639541e-02f, -3.02520581e-02f, -1.93952881e-02f,
  -7.07031414e-02f, -4.03138511e-02f, 4.92452681e-02f, 7.74293989e-02f, -2.45508254e-02f, 5.39140068e-02f, 2.93975938e-02f, 8.87490436e-02f, 5.00612184e-02f, 1.22527532e-01f,
  -4.58483487e-01f, -8.46574306e-02f, 2.17153523e-02f, -1.12488240e-01f, 3.39693129e-02f, -1.10873997e-01f, 2.61874497e-03f, 6.47970587e-02f, 6.24293648e-03f, -1.01127476e-02f,
  5.71106896e-02f, -4.19627205e-02f, -2.47158427e-02f, 2.91410182e-02f, -1.45207286e-01f, 3.38141173e-02f, -1.26892954e-01f, -1.46010086e-01f, 2.01531891e-02f, -7.46294186e-02f,
  2.29876004e-02f, 3.68394852e-02f, -1.23728365e-01f, -1.00580081e-01f, 7.01924562e-02f, -1.57981478e-02f, 1.11289062e-01f, 1.16943233e-02f, -1.14353389e-01f, 2.27886327e-02f,
  4.43534404e-01f, -1.82905272e-01f, -5.06421700e-02f, -1.35453969e-01f, 1.97282135e-02f, -2.11245213e-02f, -6.17294051e-02f, 3.81562114e-02f, 1.24394782e-02f, 1.00961953e-01f,
  -1.05931826e-01f, -4.39431667e-02f, -1.37930829e-02f, 3.75541364e-04f, 8.27404484e-02f, 8.32435340e-02f, -4.55585010e-02f, -1.45776540e-01f, -1.17482385e-02f, -1.13416286e-02f,
  -8.72739181e-02f, -2.32969284e-01f, -4.79843058e-02f, -6.30586371e-02f, -1.43364698e-01f, -1.44213557e-01f, 4.37489785e-02f, -5.35518602e-02f, 2.65536588e-02f, 7.29673281e-02f,
  7.15361722e-03f, 7.78089687e-02f, -6.52148873e-02f, -1.09220967e-02f, -1.52995130e-02f, 7.60211656e-03f, 9.58572626e-02f, 7.83608928e-02f, -3.55188213e-02f, 2.06081271e-02f,
  4.32466939e-02f, 2.47574248e-03f, 6.46448731e-02f, -2.80723460e-02f, 5.21749184e-02f, -1.92181505e-02f, -2.15944052e-02f, 6.67202547e-02f, -8.00402462e-02f, -1.37969274e-02f,
  -4.11441550e-02f, -6.42275661e-02f, 4.71500307e-02f, 7.16566369e-02f, -7.72733167e-02f, -1.11801066e-01f, -8.69992524e-02f, -4.88984399e-02f, -2.00826004e-02f, 8.07915442e-03f,
  5.51104069e-01f, -2.59702712e-01f, -3.11339484e-03f, -5.68324216e-02f, -7.22014606e-02f, -7.22842887e-02f, 2.93598659e-02f, -1.14994474e-01f, -1.26654103e-01f, 1.13850161e-01f,
  -9.03550722e-03f, 2.86330711e-02f, 7.13493824e-02f, 7.84962922e-02f, 1.19623274e-01f, 1.11732716e-02f, -1.19731419e-01f, -5.67274913e-03f, -1.50754703e-02f, 7.71355182e-02f,
  -1.28648654e-01f, 3.40351947e-02f, 3.70227806e-02f, 1.54674813e-01f, 1.95193570e-02f, 2.06023920e-02f, 1.91816181e-01f, 1.08356439e-01f, 5.69219366e-02f, 2.34074295e-01f,
  5.71600556e-01f, 1.93083704e-01f, 4.51316595e-01f, 1.55437961e-01f, 3.83113384e-01f, 3.90245795e-01f, 4.19823855e-01f, 2.12117523e-01f, -7.18428791e-02f, 1.28712296e-01f,
  5.34861535e-03f, -2.46240780e-01f, -3.09316158e-01f, -3.01991194e-01f, -1.95632458e-01f, -5.78841567e-02f, -8.28872621e-02f, -1.44301638e-01f, -1.94823667e-02f, 9.19029638e-02f,
  -1.85457498e-01f, 7.09115714e-02f, 3.50379795e-02f, -5.31113520e-02f, 1.04538286e-02f, -1.58155560e-01f, 1.55404344e-01f, 2.41455406e-01f, -4.44368552e-03f, -1.36684358e-01f,
  -1.06575293e-02f, 4.63389903e-01f, -3.07445556e-01f, -2.65035152e-01f, 1.42120332e-01f, -1.32943526e-01f, -4.85709682e-02f, 2.06104405e-02f, 2.01436430e-02f, 2.17380505e-02f,
  1.06473928e-02f, -5.70875518e-02f, 1.07786395e-01f, -1.19545450e-02f, 1.20936021e-01f, 7.11592436e-02f, -4.04303484e-02f, -7.38357827e-02f, -5.15090413e-02f, 3.37434299e-02f,
  -1.62623480e-01f, 2.51958936e-01f, 2.78985262e-01f, -6.88096695e-03f, -5.28172106e-02f, -3.67007405e-02f, 1.60354704e-01f, 4.69984394e-03f, 7.55605921e-02f, -9.68719199e-02f,
  -1.26419127e-01f, 2.33401880e-02f, 4.15456221e-02f, -5.44413365e-02f, -1.99411903e-02f, -1.14260940e-02f, 2.91612968e-02f, 5.87048531e-02f, -3.80219743e-02f, 1.20270610e-01f,
  -5.62884063e-02f, 3.17638181e-02f, 3.90456133e-02f, -3.94281857e-02f, -7.62833580e-02f, 9.57986340e-02f, 8.67586285e-02f, -2.23587397e-02f, 3.86412330e-02f, -7.40288664e-03f,
  -6.45316485e-03f, 5.59064150e-02f, 9.96795297e-02f, -4.70489375e-02f, 3.30343544e-02f, -3.15596499e-02f, 2.88582090e-02f, 8.84217676e-03f, 9.43350196e-02f, 2.11762562e-02f,
  -1.20724380e-01f, 1.08543120e-01f, -2.21622884e-01f, -8.90237316e-02f, 1.26077637e-01f, -6.18083365e-02f, -4.16443385e-02f, -1.11826994e-01f, -1.18706683e-02f, -3.25655527e-02f,
  1.58631317e-02f, -5.31737991e-02f, 6.50360286e-02f, -1.66511796e-02f, 5.54742329e-02f, 4.21904214e-02f, 1.76563151e-02f, 2.01260839e-02f, -1.65137514e-01f, -2.84357816e-02f,
  -9.96027812e-02f, 1.17938749e-01f, 7.31919482e-02f, -7.07519203e-02f, 1.13257589e-02f, -3.83487791e-02f, 1.10530723e-02f, 1.22997174e-02f, -2.81823357e-03f, -1.31279245e-01f,
  -3.75267506e-01f, -1.36821717e-01f, 4.33513559e-02f, -2.82943338e-01f, 6.27314076e-02f, 2.71969795e-01f, 3.63671839e-01f, -6.64144754e-03f, -6.35306537e-02f, -6.86229765e-02f,
  -8.94833058e-02f, -1.27417475e-01f, -1.03975162e-01f, -5.58514632e-02f, 4.73726578e-02f, 1.13480471e-01f, 2.04583071e-02f, -3.32092270e-02f, 2.06386879e-01f, 1.72434181e-01f,
  6.20241351e-02f, -1.50700971e-01f, -2.44446397e-01f, -2.20367074e-01f, -2.31245294e-01f, -1.61967739e-01f, -1.24786124e-01f, -1.51606336e-01f, -2.62630992e-02f, -9.97373015e-02f,
  2.33741865e-01f, -3.01150918e-01f, 1.29724979e-01f, -1.63292482e-01f, -1.04894578e-01f, -4.92809974e-02f, 6.26565292e-02f, -1.23705275e-01f, -8.32719058e-02f, 4.55137976e-02f,
  -1.00598030e-01f, -1.35239661e-01f, -1.21769145e-01f, -9.91681367e-02f, 2.40884665e-02f, -2.77025290e-02f, -1.35719180e-01f, -7.86512047e-02f, -7.39263073e-02f, 7.61982379e-03f,
  -1.15003817e-01f, 3.32249179e-02f, -5.84069490e-02f, 7.89571553e-02f, -1.30247518e-01f, -1.13914229e-01f, -7.70376548e-02f, -1.25616195e-03f, -2.31144093e-02f, 5.84181212e-03f,
  8.67018104e-03f, 1.00655705e-01f, 4.47634384e-02f, -6.42025322e-02f, 9.91432965e-02f, -2.91844662e-02f, 3.43891568e-02f, 6.19663261e-02f, 3.08892713e-03f, 1.42038073e-02f,
  5.66243492e-02f, -2.96927094e-02f, -7.92595595e-02f, 5.89280464e-02f, -8.13370571e-02f, -1.43099040e-01f, 2.61272825e-02f, 4.31515388e-02f, -4.39709313e-02f, -4.00688276e-02f,
  -7.93949515e-02f, 1.76886544e-02f, -5.09038046e-02f, 4.63125035e-02f, -5.89926168e-02f, -9.39615816e-02f, 3.05718407e-02f, -1.20569225e-02f, -7.17035532e-02f, -9.43243504e-03f,
  3.57163064e-02f, -1.05585054e-01f, -2.57877423e-03f, -6.91358373e-02f, -7.61946440e-02f, -4.01318520e-02f, -1.59165394e-02f, 1.67356413e-02f, -1.05757885e-01f, 1.20560406e-02f,
  -1.02076523e-01f, -6.66879490e-02f, -4.30381857e-03f, -1.83030218e-02f, 6.40048236e-02f, 1.60536483e-01f, -1.46447197e-02f, 9.85302683e-03f, 4.37179522e-04f, 8.66973400e-02f,
  -2.75202822e-02f, 1.41550735e-01f, 2.31376722e-01f, 1.13397896e-01f, -2.26509366e-02f, 1.63708881e-01f, 2.18270332e-01f, 2.05014095e-01f, 2.53949076e-01f, 4.06103939e-01f,
  5.92248976e-01f, 3.79809588e-01f, -3.39197904e-01f, 2.19554484e-01f, -2.52122879e-01f, -3.91847491e-01f, -2.65368611e-01f, -6.70280233e-02f, 1.27511606e-01f, 2.19333008e-01f,
  1.23775162e-01f, -7.89457038e-02f, 6.78546280e-02f, -1.95485815e-01f, -1.49965554e-01f, -9.26391408e-03f, -3.64895463e-02f, -2.89482266e-01f, -4.93618190e-01f, -4.75922465e-01f,
  -2.59866178e-01f, -4.58543971e-02f, -9.17369053e-02f, -4.50329222e-02f, 1.19227745e-01f, -4.60675284e-02f, 1.36064380e-01f, -1.38660610e-01f, -2.14653045e-01f, 6.85208589e-02f,
  -2.61942387e-01f, 7.58744851e-02f, -1.14008568e-01f, 5.66074736e-02f, -9.72208846e-03f, 2.02465151e-02f, 6.50416985e-02f, -1.95072107e-02f, 1.54537305e-01f, 9.90719199e-02f,
  5.78313246e-02f, -8.48777965e-02f, -3.61890048e-02f, -1.09724328e-01f, -1.66065618e-02f, -1.46404356e-01f, 4.45885630e-03f, -1.32279158e-01f, 1.44903148e-02f, 1.81406420e-02f,
  -1.08993754e-01f, -1.59517601e-01f, -1.01570822e-01f, -1.30320817e-01f, -5.38781509e-02f, -6.92593232e-02f, -2.56925300e-02f, -2.01005816e-01f, -1.09102041e-01f, 1.88308492e-01f,
  -3.46664675e-02f, 1.01855822e-01f, -3.49103436e-02f, 5.98989055e-02f, 1.02216132e-01f, 2.31330120e-03f, -8.66796356e-03f, 3.36010978e-02f, -8.14805627e-02f, 1.02572693e-02f,
  4.41069938e-02f, 3.83245200e-02f, -2.31232885e-02f, 5.14628738e-02f, -8.41498151e-02f, -8.35747197e-02f, -3.09488215e-02f, 7.51961023e-02f, -5.83676398e-02f, 9.94210131e-03f,
  1.03668254e-02f, -7.77352303e-02f, 9.12323147e-02f, -1.02541586e-02f, -2.21126936e-02f, 1.51441386e-02f, -6.43009022e-02f, -8.70722756e-02f, 1.64962541e-02f, 3.22507620e-02f,
  3.95539641e-01f, -6.13281839e-02f, 1.62432387e-01f, -2.23157685e-02f, 7.23295957e-02f, 1.14009883e-02f, 1.50932983e-01f, 6.17962703e-02f, 9.05137807e-02f, -8.41771811e-02f,
  -1.44410029e-01f, 4.21482734e-02f, 1.45821482e-01f, -1.09044045e-01f, -3.68708856e-02f, -6.35653287e-02f, 1.83067143e-01f, 4.95015942e-02f, -5.33962436e-02f, -5.07982485e-02f,
  1.61001936e-01f, -1.62449181e-02f, 1.36404648e-01f, 1.07415318e-01f, -1.46248043e-02f, 6.05757274e-02f, 5.99240996e-02f, 2.77852733e-02f, -3.06957047e-02f, 2.96860188e-01f,
  -3.82203236e-02f, 1.23507425e-01f, -2.63659209e-01f, 4.37203683e-02f, 5.05198725e-02f, 2.25478765e-02f, 2.08553169e-02f, 5.81334010e-02f, 2.00421624e-02f, 1.14679724e-01f,
  -1.40698865e-01f, -5.41673377e-02f, 4.12009694e-02f, -1.95714936e-04f, 6.19165823e-02f, 1.88875675e-01f, 1.13857612e-01f, -6.80918321e-02f, -1.48106053e-01f, -4.74951975e-02f,
  1.91874713e-01f, 3.67915779e-02f, 3.12335044e-02f, 2.02275030e-02f, 1.42667070e-01f, 1.02469474e-01f, 2.95163710e-02f, 1.94836571e-03f, -2.33743414e-02f, 9.91312787e-02f,
  -2.46947646e-01f, -2.52811879e-01f, -3.19272690e-02f, -1.90063603e-02f, -1.28595650e-01f, -1.06500007e-01f, -5.09723686e-02f, -1.35531751e-02f, -1.25833988e-01f, -6.67796806e-02f,
  -1.47411212e-01f, -9.03208479e-02f, 2.90869903e-02f, 6.98918328e-02f, -2.81686280e-02f, -5.34705482e-02f, -1.41788516e-02f, -6.96956143e-02f, -1.25140935e-01f, -1.26219496e-01f,
  1.17268600e-01f, -1.46812439e-01f, -1.72778204e-01f, -1.37331307e-01f, -3.03908903e-03f, -1.80850044e-01f, -7.99572989e-02f, -1.68207154e-01f, -7.46512860e-02f, -4.56229597e-02f,
  -5.34169823e-02f, -1.10387191e-01f, 1.22156553e-02f, -5.30631021e-02f, 2.30271574e-02f, -6.99440157e-03f, 8.08719918e-02f, 1.14291534e-01f, 9.98601094e-02f, 2.86660045e-02f,
  -8.40261877e-02f, 2.33474616e-02f, -6.41922206e-02f, -1.33381281e-02f, -5.04277386e-02f, 8.62728879e-02f, 1.79817360e-02f, 6.59414381e-02f, -1.69964544e-02f, 1.63163319e-02f,
  1.10154403e-02f, 3.77786309e-02f, -6.31944323e-03f, 1.88693944e-02f, -6.28652126e-02f, 2.08783499e-03f, -8.67362600e-03f, -3.43151614e-02f, -2.21600756e-02f, 5.34593351e-02f,
  1.76230490e-01f, -1.97799802e-01f, 1.06651545e-01f, 6.87710568e-02f, -1.21809088e-01f, -1.34113664e-02f, -1.96998147e-03f, 4.67905141e-02f, -1.18608236e-01f, 3.91421504e-02f,
  -1.56978026e-01f, 2.36152355e-02f, 7.85747916e-02f, 5.88298701e-02f, 4.57640029e-02f, 2.23189630e-02f, 1.09226674e-01f, -1.54471397e-02f, 8.45658779e-03f, 1.33806551e-02f,
  2.28219014e-02f, 8.24752226e-02f, 2.74545159e-02f, 7.91733935e-02f, 6.01355126e-03f, -7.46322870e-02f, 4.65902798e-02f, -4.96379472e-02f, -9.21291485e-02f, 1.64146811e-01f,
  -5.47200255e-02f, 9.84769464e-02f, 1.46273375e-01f, 1.77245900e-01f, 7.90882185e-02f, -2.31610939e-01f, -3.86468053e-01f, -2.52048045e-01f, 7.48056248e-02f, 6.20022155e-02f,
  1.48252845e-01f, 7.68525377e-02f, -6.88518807e-02f, -1.04072407e-01f, -3.54870230e-01f, -4.09912132e-02f, -3.11028492e-02f, -1.98003069e-01f, -3.08491230e-01f, -2.03912988e-01f,
  -9.64173749e-02f, -1.65203407e-01f, -1.57323435e-01f, -5.94417937e-02f, 2.12469831e-01f, 1.02086239e-01f, 2.44505420e-01f, 1.77737311e-01f, 1.81440592e-01f, 3.59609932e-01f,
  3.71678084e-01f, 3.61981839e-02f, -1.52611837e-01f, 3.39109898e-02f, 1.65030509e-01f, 4.46434319e-02f, -6.16756417e-02f, -7.96382036e-03f, 2.10611206e-02f, 6.26754761e-02f,
  1.38779938e-01f, 3.14587019e-02f, 5.96631989e-02f, -4.79784012e-02f, 1.28807928e-02f, -1.14410326e-01f, -1.70210972e-01f, -2.20339611e-01f, -1.59707844e-01f, 1.59778853e-03f,
  3.78110893e-02f, 1.08006693e-01f, -1.65159747e-01f, -1.83264762e-01f, 2.03475133e-02f, 7.59504288e-02f, 4.94005019e-03f, 3.43091262e-04f, -4.54604626e-02f, 1.33544594e-01f,
  4.46928293e-02f, -3.66436318e-03f, 1.11681424e-01f, 4.73159999e-02f, 1.18812788e-02f, 8.44898447e-02f, -1.50819647e-03f, 4.21614610e-02f, 2.93054874e-03f, -3.69113572e-02f,
  1.53169651e-02f, 4.52033356e-02f, 2.85806488e-02f, 8.63283649e-02f, 4.45529893e-02f, 6.99376091e-02f, -2.30990443e-02f, -1.84305720e-02f, 3.19064618e-03f, 1.20348437e-02f,
  -3.18341888e-02f, 2.12624595e-02f, 7.28464052e-02f, -7.80898407e-02f, 5.44877313e-02f, -3.56060863e-02f, 6.06447868e-02f, 1.43160708e-02f, 5.82364425e-02f, -5.33972587e-03f,
  7.33340383e-02f, -2.60756552e-01f, 1.36334643e-01f, -4.33767773e-02f, 1.58692896e-01f, 6.38630688e-02f, 1.81744605e-01f, -2.83865705e-02f, 8.45876038e-02f, 2.07178877e-03f,
  -1.04836643e-01f, -8.46782550e-02f, -1.26273080e-03f, -6.62348270e-02f, -5.10128215e-02f, -9.82297510e-02f, 5.36546074e-02f, -1.11581897e-02f, -1.41048893e-01f, 9.77977067e-02f,
  -9.09328833e-02f, -1.33083180e-01f, -1.42726630e-01f, -1.48605242e-01f, 1.01137921e-01f, -9.94314030e-02f, -6.86727539e-02f, 3.70364003e-02f, -1.88603148e-01f, -1.13316007e-01f,
  3.71675417e-02f, -4.67446685e-01f, -2.69356757e-01f, -1.47128016e-01f, -1.48081288e-01f, -1.60041556e-01f, -2.98473448e-01f, 2.92188432e-02f, -2.30850782e-02f, -3.31834584e-01f,
  -2.09967405e-01f, -5.65425344e-02f, -6.11740798e-02f, -6.31073117e-02f, 1.23875603e-01f, -3.29960793e-01f, -1.92492843e-01f, 6.06837757e-02f, 1.31232128e-01f, 8.91496465e-02f,
  -6.51747286e-02f, -9.14648175e-02f, 2.83661671e-02f, -5.97104169e-02f, -2.52334058e-01f, -1.31913528e-01f, -2.84053296e-01f, -1.37731940e-01f, -1.66989133e-01f, -3.94344866e-01f,
  -3.77407551e-01f, 5.09150885e-02f, 1.10109873e-01f, 5.80950640e-02f, -1.28309643e-02f, 5.36131598e-02f, -1.08698964e-01f, 2.41922159e-02f, 1.56465676e-02f, -6.25155047e-02f,
  -7.72506222e-02f, -1.04418788e-02f, -6.29277304e-02f, -2.98454165e-02f, -2.56363805e-02f, 5.32025062e-02f, -2.65762229e-02f, 1.01573937e-01f, -3.93363796e-02f, -7.14012831e-02f,
  -1.70742556e-01f, -1.42809704e-01f, -1.12917043e-01f, -3.80166396e-02f, 7.19929561e-02f, -5.02019338e-02f, -1.28667966e-01f, -1.12319693e-01f, -1.28125921e-02f, -1.38938278e-01f,
  -1.51059125e-03f, -6.73220605e-02f, 7.21740872e-02f, 9.22975019e-02f, -1.30988676e-02f, -2.49051955e-02f, -4.83952276e-02f, 4.61908942e-03f, 3.00858952e-02f, 2.31284257e-02f,
  8.94721523e-02f, 5.23509569e-02f, 2.78299190e-02f, 2.30270289e-02f, -5.84948882e-02f, -8.81405696e-02f, 5.54415211e-02f, -4.97096777e-02f, -5.52354567e-02f, -2.75858697e-02f,
  -5.71014844e-02f, 1.02281742e-01f, -9.17335227e-02f, 1.76632293e-02f, 8.46091099e-03f, -4.96450029e-02f, 1.75081082e-02f, 7.18939155e-02f, 1.84742529e-02f, 1.24935918e-02f,
  -6.26558065e-02f, 2.48002470e-01f, -1.83163941e-01f, 9.61704180e-02f, -1.06789507e-01f, 4.67967205e-02f, -2.95081679e-02f, -2.32296530e-02f, 7.85440356e-02f, -9.01155453e-03f,
  1.50898555e-02f, 3.53197306e-02f, -1.34351477e-02f, 5.83940297e-02f, -4.46212403e-02f, 5.23939952e-02f, -9.69646964e-03f, -6.16228841e-02f, -2.76291687e-02f, -1.06221855e-01f,
  -1.57815099e-01f, -1.07946306e-01f, -1.45976931e-01f, -6.31555496e-03f, 5.33141149e-03f, -5.57270870e-02f, -4.47970852e-02f, -1.50132338e-02f, -8.38811323e-02f, -2.41082340e-01f,
  1.73595976e-02f, -7.73640200e-02f, 3.61888111e-01f, -7.43104964e-02f, -4.08580899e-01f, -3.46080333e-01f, -5.30206561e-01f, -1.67777881e-01f, -7.29273483e-02f, -2.44169861e-01f,
  -3.50635648e-01f, -2.43647769e-01f, 2.90414989e-02f, 9.08598974e-02f, 1.83715776e-01f, 1.12537155e-03f, 2.50430763e-01f, 3.48941922e-01f, 1.20590024e-01f, -1.99847892e-01f,
  -1.97799653e-01f, 1.55952126e-01f, 3.42802525e-01f, 1.33407995e-01f, 2.49392688e-02f, 6.72643110e-02f, 2.16723919e-01f, 1.59089237e-01f, 2.88895033e-02f, 1.37191728e-01f,
  -2.69117299e-02f, -3.37693579e-02f, -3.25307176e-02f, -2.95227300e-03f, -1.64232624e-03f, -2.16551330e-02f, -4.16403115e-02f, 1.41903564e-01f, -5.12404703e-02f, 2.06597671e-02f,
  -1.79284781e-01f, -7.87814986e-03f, -7.13908672e-02f, -7.09692538e-02f, -8.27950910e-02f, -1.04071060e-03f, 7.81935826e-02f, 3.02817971e-01f, 5.98952547e-02f, -3.57348882e-02f,
  -1.08484842e-01f, -1.02056548e-01f, -9.09325555e-02f, 2.89448388e-02f, -3.40327546e-02f, 3.37590575e-02f, 4.11055796e-02f, -7.03589851e-03f, 1.36636525e-01f, 5.19068427e-02f,
  -4.44088988e-02f, 7.41660688e-03f, 3.82703394e-02f, -1.51058286e-02f, -2.17991471e-02f, 2.02626176e-02f, -1.22622419e-02f, -3.08697466e-02f, 2.91841608e-02f, -4.58388496e-03f,
  2.98515372e-02f, 4.14697528e-02f, -4.10180539e-02f, 2.75899889e-03f, -5.29511124e-02f, 6.08293377e-02f, -4.46514413e-02f, 4.33282321e-03f, -2.93369200e-02f, 3.06955706e-02f,
  -2.25269794e-03f, -4.22070026e-02f, 6.74317181e-02f, 5.50887771e-02f, 2.89773624e-02f, 7.76360407e-02f, 5.05328923e-02f, -3.05391885e-02f, 4.61678095e-02f, -1.42862210e-02f,
  -2.12140039e-01f, 9.14272666e-02f, -1.07913181e-01f, -1.83448289e-02f, -8.50706846e-02f, 4.31351922e-03f, -8.72108266e-02f, 9.33206752e-02f, -5.19411750e-02f, -3.18884589e-02f,
  -6.43204674e-02f, -1.05192699e-01f, -3.29765193e-02f, 4.30377806e-03f, -5.07652797e-02f, -1.28956005e-01f, -1.38566732e-01f, -1.86412483e-02f, 3.96107277e-03f, -1.50705844e-01f,
  -5.04358634e-02f, -2.32137263e-01f, -3.16145271e-01f, -2.56734967e-01f, -1.20604992e-01f, -2.91383058e-01f, -1.12557419e-01f, -1.25704154e-01f, -1.59299791e-01f, -2.20760882e-01f,
  3.95441800e-01f, -3.26144576e-01f, -2.21995294e-01f, 2.60189116e-01f, -5.38129359e-02f, -3.26848149e-01f, -5.89605868e-01f, -3.52466017e-01f, 1.56530384e-02f, -1.70434769e-02f,
  7.02713504e-02f, 2.72444844e-01f, 6.45973757e-02f, -1.93095747e-02f, -1.89053968e-01f, -3.81351978e-01f, -2.28874251e-01f, -4.51920331e-02f, 2.22945977e-02f, 2.09736854e-01f,
  1.71345398e-01f, 1.99179828e-01f, 2.60001361e-01f, 4.13802676e-02f, 2.31719106e-01f, 1.34834662e-01f, -7.32703076e-04f, 9.06424150e-02f, 2.89729908e-02f, 2.33350605e-01f,
  2.87633002e-01f, 2.91242152e-02f, -2.65667564e-03f, 1.47847608e-01f, 8.00608695e-02f, -4.16031778e-02f, -9.03832316e-02f, 5.40411042e-04f, -3.58842313e-02f, -7.62396259e-03f,
  1.06274270e-01f, 1.06948301e-01f, 5.45449294e-02f, -2.28303168e-02f, -1.32574199e-03f, -7.61650801e-02f, -6.96884692e-02f, 4.13604733e-03f, -1.62669733e-01f, -2.00211001e-03f,
  -1.74920466e-02f, 1.38512507e-01f, -1.45452037e-01f, -2.22608298e-01f, -6.70564771e-02f, -2.69859619e-02f, -1.98474050e-01f, -5.00751659e-02f, -2.29896992e-01f, 3.73421460e-02f,
  6.28220737e-02f, 9.76933260e-03f, -2.15353090e-02f, -1.21368639e-01f, -3.28856260e-02f, -4.92005143e-03f, 7.29654208e-02f, -5.19423448e-02f, 3.30158770e-02f, -1.57797132e-02f,
  -7.12596402e-02f, 3.10277436e-02f, -6.49161041e-02f, -1.85688473e-02f, 6.51928708e-02f, 2.72006895e-02f, -2.07345784e-02f, -9.78573486e-02f, -3.52360159e-02f, 3.87495495e-02f,
  6.38751313e-02f, -1.78335775e-02f, 1.05211064e-01f, -3.41031216e-02f, -3.44994217e-02f, 4.42249002e-03f, 4.15164651e-03f, 8.95258226e-03f, 2.36194953e-02f, 2.53382623e-02f,
  2.91764364e-02f, -1.98310316e-01f, 5.90231083e-02f, 2.67187022e-02f, 1.21468154e-03f, 1.91660542e-02f, -2.11577844e-02f, 1.74036585e-02f, 6.56023026e-02f, -5.52309938e-02f,
  9.42677446e-03f, -7.51636550e-02f, -8.35571215e-02f, -8.89890362e-03f, 5.82166351e-02f, -2.43226141e-02f, -1.17318302e-01f, 4.74626664e-03f, -1.11213714e-01f, 1.68732367e-02f,
  -5.31213358e-02f, -2.10188776e-01f, -1.80355340e-01f, -3.43648434e-01f, -5.19563965e-02f, -8.11032876e-02f, -2.62980700e-01f, -1.31279796e-01f, -3.67410779e-01f, -3.38848025e-01f,
  -3.26599687e-01f, 7.49348253e-02f, 7.76377693e-02f, -2.38159493e-01f, -1.24080136e-01f, -3.59489322e-02f, 6.35128245e-02f, -5.61401285e-02f, -1.36054397e-01f, 1.84594654e-02f,
  -1.11468155e-02f, -1.91309497e-01f, -7.27934465e-02f, -3.72569598e-02f, 4.84708883e-02f, 6.94534332e-02f, 2.97681689e-02f, -6.14786148e-02f, -6.39104545e-02f, -7.78716654e-02f,
  3.79287116e-02f, -1.15268998e-01f, -1.72300979e-01f, -1.29385144e-01f, -7.66848326e-02f, -1.29094645e-01f, 6.20139912e-02f, -8.48416984e-02f, -7.42397681e-02f, 9.39953793e-03f,
  2.59692878e-01f, -1.99323222e-01f, 4.59801443e-02f, -3.64201516e-02f, 7.54732490e-02f, 3.53929289e-02f, -9.13674906e-02f, -1.29676163e-01f, -1.02740377e-01f, -4.96582575e-02f,
  -8.64179656e-02f, -2.79044546e-02f, -1.99154001e-02f, 5.03183864e-02f, 5.88944592e-02f, 2.28302162e-02f, -2.32716445e-02f, -8.16553384e-02f, -2.56450512e-02f, 5.33000231e-02f,
  3.48269604e-02f, -3.81430029e-03f, 1.50962053e-02f, 8.17707479e-02f, -2.92509794e-02f, -2.04572883e-02f, 1.18372619e-01f, 5.02070449e-02f, 9.15755332e-02f, -6.99122325e-02f,
  1.35324031e-01f, 1.42764943e-02f, -5.54126352e-02f, 4.72865701e-02f, -3.68770026e-02f, -8.40500928e-03f, 5.52742444e-02f, 6.20290004e-02f, 5.84010081e-03f, -6.79638311e-02f,
  4.11476754e-03f, 8.17580819e-02f, 9.56255719e-02f, -7.50194341e-02f, 7.97904134e-02f, 1.25231314e-02f, -8.13018065e-03f, 2.29902472e-02f, -3.76014970e-02f, -7.85898343e-02f,
  -5.92591390e-02f, 4.05345969e-02f, -4.08683484e-03f, 9.10046995e-02f, -2.83348318e-02f, 4.41142693e-02f, 1.60778612e-02f, 9.15293992e-02f, -3.67368571e-02f, -1.54385134e-03f,
  -3.58183049e-02f, -3.27558070e-02f, 1.43310251e-02f, -3.70382480e-02f, -4.33029942e-02f, -3.63748744e-02f, -1.05931476e-01f, 2.76571549e-02f, -1.35648772e-01f, 2.01646853e-02f,
  5.44564985e-03f, -5.66817075e-02f, 4.06230949e-02f, 8.65915865e-02f, -4.37025800e-02f, 8.62294883e-02f, -2.89513282e-02f, 5.83349280e-02f, 6.64698109e-02f, 8.29523876e-02f,
  1.35867208e-01f, 1.36841953e-01f, 4.33356203e-02f, 5.88198425e-03f, 7.15091974e-02f, 1.52192842e-02f, 1.65776849e-01f, 5.45200557e-02f, 1.35501564e-01f, 1.06724463e-01f,
  4.99625690e-02f, -3.28743428e-01f, -4.97213900e-01f, -2.21955106e-01f, -2.11014867e-01f, -1.50392145e-01f, -8.87001827e-02f, -5.53967208e-02f, -5.61512597e-02f, -1.97092429e-01f,
  -1.95538536e-01f, -5.65298181e-03f, -1.13038123e-01f, 2.56243739e-02f, -8.45618695e-02f, -3.02712619e-01f, -3.06885719e-01f, -2.19876453e-01f, 9.66479182e-02f, 1.67249441e-02f,
  -9.70168114e-02f, -1.24035351e-01f, -6.54662773e-02f, -1.73894130e-02f, -2.29063198e-01f, -1.90523177e-01f, -2.05495477e-01f, -2.03490287e-01f, -1.26122594e-01f, -3.71377587e-01f,
  -2.80610859e-01f, 9.14107412e-02f, 1.90734118e-02f, 2.17438042e-02f, -1.48104876e-01f, 1.04158066e-01f, -3.98670994e-02f, -1.09559046e-02f, -3.62883620e-02f, -6.23770538e-05f,
  -1.14890803e-02f, 1.10104315e-01f, 1.63532514e-02f, 5.61687462e-02f, 3.68237086e-02f, 4.55914512e-02f, 2.37239189e-02f, 2.09616423e-02f, 6.55007269e-03f, -6.49055243e-02f,
  -2.78981142e-02f, 9.37523022e-02f, -4.58982512e-02f, 5.04496088e-03f, 1.55023828e-01f, 1.56887382e-01f, 4.08145227e-02f, 1.78296924e-01f, 1.22315265e-01f, -1.04681231e-01f,
  -2.69226986e-03f, -3.22507396e-02f, 1.37161352e-02f, 7.26620108e-02f, -1.72552187e-02f, 7.37474114e-03f, -7.85082057e-02f, 9.46938153e-03f, 6.68835640e-02f, -8.89718458e-02f,
  -6.66101873e-02f, 4.62989993e-02f, 5.05570322e-02f, -8.14170465e-02f, -4.41733897e-02f, -4.01968062e-02f, -5.58114387e-02f, -6.11370951e-02f, 4.15889770e-02f, -2.09797267e-02f,
  -1.70393009e-02f, -1.93041451e-02f, 7.52782077e-02f, -6.54968470e-02f, -7.84258824e-03f, -7.89933205e-02f, 5.55876754e-02f, 3.46301608e-02f, 9.25946161e-02f, 6.24342337e-02f,
  -1.41262561e-01f, 1.40181005e-01f, -1.01212263e-01f, 1.47441342e-01f, 9.07513127e-03f, -8.55541453e-02f, 6.43847277e-03f, 8.42188671e-02f, -2.43325569e-02f, -7.11800009e-02f,
  7.19579458e-02f, -5.65261878e-02f, -9.19749290e-02f, -8.82258862e-02f, 5.05792275e-02f, 1.26024745e-02f, -9.33003612e-03f, -1.03584424e-01f, 6.94354922e-02f, -2.48180181e-02f,
  -8.01980123e-02f, -3.35323438e-02f, 1.12210743e-01f, 2.60025971e-02f, 9.20985639e-03f, 3.04190926e-02f, 2.63572969e-02f, 1.13019772e-01f, 4.78944965e-02f, -1.78577632e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 26)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 26;
const float L0_fan_Bp_bar_data[] = {
  1.97546795e-01f, 7.81598315e-02f, 9.64771435e-02f, 2.55309314e-01f, 1.79330602e-01f, 3.18400055e-01f, 2.17788160e-01f, 5.83000481e-01f, 1.38650894e-01f, 4.81508106e-01f,
  6.04469657e-01f, 2.69036382e-01f, 2.81052351e-01f, 5.62505797e-02f, 2.40108371e-02f, 2.03938484e-01f, 4.39711630e-01f, 3.89217883e-01f, 4.94016618e-01f, 1.55293837e-01f,
  2.40335345e-01f, 2.30159670e-01f, 3.46174479e-01f, 3.80107969e-01f, 7.69638494e-02f, -1.93281714e-02f
};

// L1_linear_W (Shape: 12 x 32)
const int L1_linear_W_rows = 12;
const int L1_linear_W_cols = 32;
const float L1_linear_W_data[] = {
  -6.65350020e-01f, -4.51493114e-01f, -4.34396714e-01f, -2.72030652e-01f, 1.35310425e-03f, -9.10253748e-02f, -1.48416325e-01f, -3.13477248e-01f, 5.59077673e-02f, 5.27130246e-01f,
  -1.53368348e-02f, 4.46304023e-01f, 3.56612094e-02f, -2.09694952e-01f, -1.73092142e-01f, -2.61671603e-01f, -1.21986084e-01f, -4.15901005e-01f, 6.78830827e-03f, -5.03314175e-02f,
  2.79839456e-01f, 3.47526260e-02f, -2.40526766e-01f, -2.14438904e-02f, -4.01641220e-01f, -1.11722872e-01f, -5.22230029e-01f, 8.78056586e-01f, -2.78287947e-01f, 4.16731447e-01f,
  -2.33930275e-01f, 8.60249639e-01f, 3.68496217e-02f, 5.18008530e-01f, -2.09916420e-02f, -5.28011084e-01f, 1.85478315e-01f, 7.34952241e-02f, 5.71541965e-01f, 2.45278567e-01f,
  -5.05259275e-01f, -4.27243531e-01f, 8.52928162e-01f, -2.65925139e-01f, 3.62640023e-02f, 5.52443743e-01f, -2.47717589e-01f, -4.34605807e-01f, 7.67592609e-01f, -3.81394595e-01f,
  3.66883814e-01f, -1.72262475e-01f, 1.27943218e-01f, -4.57652599e-01f, -1.41351968e-01f, -2.91733176e-01f, 3.06897670e-01f, -1.69739515e-01f, -4.25689101e-01f, 3.03001881e-01f,
  -3.54034066e-01f, -4.76630591e-02f, -1.41451940e-01f, 6.11945510e-01f, 3.80317509e-01f, 2.93406337e-01f, 2.54791409e-01f, 2.68192321e-01f, 6.30947411e-01f, 2.47968465e-01f,
  -3.51041168e-01f, -3.40740800e-01f, -5.58105633e-02f, 1.18576214e-01f, -1.62234351e-01f, -3.52554023e-01f, 2.15384021e-01f, 7.91689396e-01f, -2.00319123e-02f, -4.82247651e-01f,
  5.52981831e-02f, -2.77819373e-02f, 9.57320482e-02f, 1.80393070e-01f, 3.11404057e-02f, -2.72621095e-01f, -4.86320466e-01f, -3.10597062e-01f, -3.76586288e-01f, -2.12956995e-01f,
  -2.76288807e-01f, 3.21194410e-01f, 1.06050193e+00f, 2.19608709e-01f, 9.76628885e-02f, -2.78102189e-01f, -3.96117270e-02f, 7.33470246e-02f, 2.83550583e-02f, -1.31353781e-01f,
  3.19763571e-01f, -2.54322261e-01f, -3.20378512e-01f, -1.08757310e-01f, 1.04351193e-01f, -3.16856921e-01f, -7.14500546e-02f, 2.88485438e-01f, 6.01643085e-01f, -2.59383529e-01f,
  7.20067620e-01f, -3.67351741e-01f, -2.74714321e-01f, 1.00664628e+00f, 7.71540999e-02f, -1.37814477e-01f, -6.07308559e-02f, -2.08708152e-01f, -2.42575556e-01f, 5.22988498e-01f,
  -5.06423414e-01f, -1.79563537e-01f, -9.29481983e-02f, 1.45900128e-02f, -1.50624558e-01f, -6.88881814e-01f, 6.03061259e-01f, 2.08689779e-01f, -2.34888211e-01f, -6.43509686e-01f,
  -5.09217262e-01f, -1.28028661e-01f, 2.26944238e-01f, -5.92670858e-01f, -1.98059440e-01f, 3.90867842e-03f, 1.35755911e-01f, -3.25505704e-01f, -1.64808244e-01f, 2.31424510e-01f,
  3.78167957e-01f, -1.20088883e-01f, -1.12093210e-01f, 6.69900298e-01f, -4.70152766e-01f, 3.94883841e-01f, 4.93065923e-01f, 1.69887185e-01f, 1.66439578e-01f, 3.02762806e-01f,
  2.22056974e-02f, -5.32905817e-01f, 5.49145937e-01f, -1.46599442e-01f, 6.80004060e-01f, -5.81645370e-02f, 1.15136527e-01f, 1.75828904e-01f, -3.50989960e-02f, 2.06492711e-02f,
  1.83703735e-01f, 4.36981291e-01f, 2.55914927e-01f, -3.76877636e-01f, -4.37206268e-01f, -3.47497016e-02f, -6.23959713e-02f, 2.72763371e-01f, 5.21249101e-02f, 3.60236555e-01f,
  -4.99686331e-01f, 8.46817732e-01f, -2.48209760e-01f, -4.27021354e-01f, -2.48364851e-01f, -1.43327639e-02f, 6.50742292e-01f, -4.76204544e-01f, 9.05071199e-02f, 1.12239785e-01f,
  8.92816260e-02f, 1.28313631e-01f, -2.16412917e-01f, -1.37738036e-02f, 1.13405108e+00f, 5.29153764e-01f, -6.32639080e-02f, -2.17418909e-01f, -3.61888349e-01f, -1.64726675e-02f,
  3.48121463e-03f, -2.00792179e-01f, 1.06715247e-01f, 1.52526006e-01f, -2.22555041e-01f, -1.12041004e-01f, -3.95734727e-01f, 6.82694018e-01f, 5.62590778e-01f, -3.02197963e-01f,
  -4.30927612e-02f, -6.26208723e-01f, -2.41997272e-01f, -3.09082359e-01f, -3.47624242e-01f, 3.53754967e-01f, -5.56885958e-01f, 1.02898562e+00f, -1.39739022e-01f, -1.52991772e-01f,
  -3.21150690e-01f, -2.66465455e-01f, 7.51185343e-02f, -2.17877015e-01f, -1.70901462e-01f, -2.48872727e-01f, -5.20722419e-02f, 6.63903505e-02f, -3.10273264e-02f, -3.72497559e-01f,
  7.60242641e-01f, 2.14801729e-01f, -7.68291727e-02f, -1.74528867e-01f, -2.99122453e-01f, -1.37496009e-01f, -1.57768831e-01f, -4.15289760e-01f, -2.18595844e-02f, 3.27157140e-01f,
  1.51809230e-01f, 6.28785729e-01f, 1.41915575e-01f, 5.75350821e-01f, -4.52596433e-02f, -3.14902246e-01f, -1.08701482e-01f, -2.04849526e-01f, 4.89910156e-01f, 4.37705033e-02f,
  -2.38722354e-01f, 5.48901618e-01f, -2.20705628e-01f, 2.76897520e-01f, -4.76007387e-02f, 1.19863287e-01f, -5.68570137e-01f, -4.12871316e-03f, -1.44382864e-01f, 5.01834333e-01f,
  -1.78491920e-01f, -3.23923349e-01f, -1.85287759e-01f, -5.71533918e-01f, -1.74512267e-01f, -1.54195666e-01f, 4.99668010e-02f, -5.01955152e-01f, 2.42943406e-01f, 6.31883860e-01f,
  -7.09797204e-01f, 3.23063135e-01f, -2.88379997e-01f, 3.53138745e-01f, 3.25803369e-01f, -1.88191265e-01f, 2.62931385e-03f, -2.29975313e-01f, -1.98445365e-01f, 4.74732637e-01f,
  -2.22594857e-01f, -2.44000033e-01f, 7.44683146e-01f, -2.42050841e-01f, -3.26722980e-01f, -1.25704944e-01f, -4.21714634e-01f, 7.42169619e-02f, 4.81774092e-01f, 5.54733992e-01f,
  -4.55524147e-01f, 1.43820019e-02f, -1.62761390e-01f, -2.02484146e-01f, -2.88574696e-01f, -6.59782439e-02f, 1.27241965e-02f, -1.22126155e-01f, 1.65606484e-01f, 1.71591774e-01f,
  5.68901077e-02f, -6.38118759e-02f, 6.39558792e-01f, 6.80460781e-02f, -2.20999420e-01f, 3.24412733e-02f, -5.46926260e-02f, 7.08325028e-01f, -1.60401061e-01f, -2.02836201e-01f,
  -6.33629337e-02f, -4.04044777e-01f, 2.26159602e-01f, 4.31786746e-01f, -2.42600858e-01f, -3.65312785e-01f, -3.67879182e-01f, 1.02282003e-01f, 1.23606697e-01f, -1.90511078e-01f,
  -9.84079540e-02f, -3.21944863e-01f, 1.96861908e-01f, 6.96749985e-02f, 7.54912436e-01f, -4.22906935e-01f, -1.15128204e-01f, 1.12455487e+00f, -1.69935703e-01f, -3.10513169e-01f,
  4.37732115e-02f, 3.30152422e-01f, 1.94509789e-01f, 2.83658087e-01f, 2.61975586e-01f, -2.99477994e-01f, -2.48145089e-01f, -1.18319139e-01f, 1.15446061e-01f, -2.32891276e-01f,
  6.24280393e-01f, -2.43882090e-01f, -5.18675633e-02f, -2.62571126e-01f, -2.69870818e-01f, -1.68530494e-01f, -4.49235678e-01f, -1.27878681e-01f, 4.83195841e-01f, 5.41672669e-02f,
  -5.05667143e-02f, 9.10851300e-01f, -2.76593119e-01f, 6.33057475e-01f, -2.33352989e-01f, 6.21691048e-02f, 3.21857221e-02f, -3.33663970e-01f, -2.81080633e-01f, -1.61016345e-01f,
  3.34779710e-01f, -2.12116972e-01f, 1.33519500e-01f, 1.51377320e-01f, 8.00153464e-02f, 3.26195449e-01f, -2.96423048e-01f, -1.91438109e-01f, 5.51386297e-01f, -3.98795694e-01f,
  4.48275581e-02f, -3.67544711e-01f, -2.22289041e-01f, -1.76521584e-01f, 1.65330291e-01f, -5.02598345e-01f, 1.73324481e-01f, 3.90082985e-01f, -3.06759238e-01f, 3.66736501e-01f,
  -3.00453156e-01f, -9.28154588e-02f, -3.84045392e-02f, -1.79576799e-01f, 1.22464240e+00f, -3.29351962e-01f, 1.19728342e-01f, -2.91035354e-01f, -1.94442436e-01f, -2.30213195e-01f,
  -2.02240601e-01f, -4.01746184e-01f, 4.07038555e-02f, -1.35418966e-01f
};

// L1_linear_B (Shape: 1 x 12)
const int L1_linear_B_rows = 1;
const int L1_linear_B_cols = 12;
const float L1_linear_B_data[] = {
  -2.56841272e-01f, -1.13947831e-01f, 1.66497588e-01f, -1.39031224e-02f, -4.81157415e-02f, 3.09234351e-01f, -3.90685722e-02f, -1.80327594e-01f, -6.43640012e-03f, -1.28154904e-02f,
  -1.99950442e-01f, 1.35982513e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 3, 26
    );
    
    // Camada 1: L1_linear
    linear_forward_pgm(
        buffer1, x_out,
        L1_linear_W_data, L1_linear_B_data,
        32, 12
    );
    }
    