/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 64 (x3)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 64;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    static inline float fan_activation(float x) { return x; }

    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 12 x 120)
const int L0_fan_Wp_rows = 12;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  8.97006467e-02f, 1.35716066e-01f, 5.17960079e-02f, 1.21540040e-01f, 2.07080636e-02f, -6.47913665e-02f, -1.69373989e-01f, 1.24803305e-01f, 1.28038302e-01f, 1.63188696e-01f,
  2.29369566e-01f, 2.91400731e-01f, 1.36780724e-01f, 2.19072908e-01f, 1.29468367e-02f, 1.52924806e-02f, 6.86557442e-02f, 9.49918777e-02f, -1.39414728e-01f, 9.01595205e-02f,
  2.19541758e-01f, 2.02188283e-01f, 2.15748787e-01f, 6.97599277e-02f, 2.63763756e-01f, 4.23278213e-02f, 1.14238426e-01f, 8.04459006e-02f, 1.62963450e-01f, 2.02552900e-01f,
  1.74550693e-02f, 2.12627679e-01f, 4.95104827e-02f, 1.43288508e-01f, 5.84969372e-02f, 1.73846751e-01f, 7.69519713e-03f, 1.67370796e-01f, 1.01825669e-01f, 1.71784773e-01f,
  1.97142556e-01f, 1.20161109e-01f, 1.22497745e-01f, 1.40994877e-01f, 1.28944412e-01f, 7.97389299e-02f, 1.23874858e-01f, 1.37053251e-01f, 2.06819177e-01f, 4.06784005e-02f,
  1.79681763e-01f, 1.79220498e-01f, 9.89271253e-02f, 1.06333405e-01f, 9.52901170e-02f, 6.83575869e-02f, 3.56120244e-02f, 1.65081203e-01f, 5.31682447e-02f, 7.05370679e-02f,
  2.84195449e-02f, -1.05132163e-01f, -4.78479713e-02f, 3.24618407e-02f, -1.11749783e-01f, -3.33623700e-02f, -1.17848674e-02f, -4.29503657e-02f, -1.37300506e-01f, 3.88576649e-02f,
  2.84195156e-03f, 1.62030589e-02f, 2.47454792e-02f, -1.73903212e-01f, 1.59696620e-02f, -8.58320370e-02f, -7.84612820e-02f, 1.14044258e-02f, -3.69841643e-02f, -8.76932591e-02f,
  -2.99515221e-02f, -1.37837842e-01f, -2.14882735e-02f, -1.13068715e-01f, -9.28516090e-02f, -7.28404447e-02f, -1.09220138e-02f, -2.37673987e-02f, -1.34432260e-02f, 6.75861631e-03f,
  2.71961209e-03f, 8.44708830e-02f, -6.25358894e-04f, 6.58225119e-02f, 7.62279406e-02f, 5.97329140e-02f, 1.32254913e-01f, 6.50398508e-02f, -4.39264672e-03f, 7.42119327e-02f,
  9.19642448e-02f, 1.19385548e-01f, 7.67650679e-02f, 3.16637792e-02f, 1.61495805e-02f, -6.98042195e-03f, 6.54656962e-02f, 1.02595016e-02f, 8.09324831e-02f, 2.51095407e-02f,
  1.42564833e-01f, 6.74436428e-03f, -3.00808307e-02f, 4.91156317e-02f, 9.15839337e-03f, 2.08766740e-02f, 1.54208299e-03f, 5.30158728e-02f, 1.02214953e-02f, 6.09183125e-02f,
  -1.29211796e-02f, -1.88967824e-01f, 1.55590385e-01f, -2.19334081e-01f, -1.98134020e-01f, -1.92956343e-01f, 3.97028662e-02f, -2.51627445e-01f, -2.48163566e-01f, -1.35270059e-01f,
  -3.56182188e-01f, -2.75246441e-01f, -1.84390053e-01f, -9.41149816e-02f, -1.05116293e-02f, 1.18022010e-01f, 2.69756436e-01f, 2.15010002e-01f, 2.31106784e-02f, -1.26685575e-01f,
  -2.12968796e-01f, -1.61230505e-01f, -8.19367915e-02f, 2.29360890e-02f, -1.41891271e-01f, -1.38973132e-01f, -5.33434749e-02f, -9.38334092e-02f, -1.04210384e-01f, -2.72819586e-02f,
  -9.26996544e-02f, -9.91454497e-02f, -8.41523111e-02f, -1.44464254e-01f, -1.18464597e-01f, -1.90967798e-01f, -1.51927352e-01f, -1.39626279e-01f, -1.86438560e-01f, -1.26340568e-01f,
  -1.00223213e-01f, -7.06673041e-02f, -4.20721695e-02f, -1.80379689e-01f, -2.78610885e-02f, -4.21898589e-02f, 1.62188075e-02f, 5.47298305e-02f, -1.32209420e-01f, -2.34319553e-01f,
  -1.92285776e-01f, -1.19735457e-01f, 4.78229159e-03f, -6.28123805e-02f, -1.14981033e-01f, -1.05053045e-01f, -2.06460834e-01f, -9.98076722e-02f, -8.55179578e-02f, -6.68204799e-02f,
  -9.99899860e-03f, 3.96756306e-02f, 1.16068885e-01f, 3.06444094e-02f, 8.94850567e-02f, -2.09076460e-02f, 1.10412821e-01f, 3.97720337e-02f, 8.91267657e-02f, 6.61794394e-02f,
  1.34670120e-02f, 8.65816846e-02f, 7.06422403e-02f, 5.55723198e-02f, 8.26513022e-02f, 1.13169223e-01f, 1.16765603e-01f, 2.48791464e-02f, 1.96480192e-02f, 8.38751867e-02f,
  8.32514092e-02f, 8.27901140e-02f, 9.94479880e-02f, 4.77485619e-02f, 1.16156243e-01f, 2.21310139e-01f, 1.70139715e-01f, 9.27074775e-02f, 5.99149205e-02f, 1.22598507e-01f,
  -3.64514321e-01f, -2.05881089e-01f, -1.99577883e-01f, -7.92222172e-02f, -2.07979873e-01f, -1.58261552e-01f, -2.16187388e-01f, -9.34712067e-02f, -1.62567720e-01f, -6.32120222e-02f,
  -1.28596023e-01f, -1.36225164e-01f, -2.05160230e-01f, -5.23279905e-02f, -8.74709934e-02f, -1.66237906e-01f, -1.96038619e-01f, -8.52921978e-02f, -1.67362288e-01f, -1.28735587e-01f,
  -9.56097320e-02f, -1.30770892e-01f, -2.30096340e-01f, -7.82411769e-02f, -2.01596677e-01f, -6.25945404e-02f, -1.31269500e-01f, -1.46758690e-01f, -9.89552960e-02f, -9.34934020e-02f,
  -4.57173139e-01f, 1.24797896e-01f, 9.31294933e-02f, -7.11867511e-02f, 1.54245272e-01f, 1.30984053e-01f, 4.06196788e-02f, 2.03994219e-03f, -1.57143176e-01f, 3.66326012e-02f,
  1.65442199e-01f, 1.99775010e-01f, 2.27592111e-01f, 2.46372655e-01f, 8.40031058e-02f, 5.42304367e-02f, -9.86921862e-02f, -1.04453294e-02f, -5.38406074e-02f, 7.43334889e-02f,
  1.88498661e-01f, -1.40607670e-01f, -1.25975832e-01f, -1.25758633e-01f, -2.01495271e-02f, 1.66374862e-01f, -4.68981639e-02f, 2.26208400e-02f, 7.58214965e-02f, 1.98622182e-01f,
  1.38816893e-01f, 2.63405461e-02f, 8.41954350e-02f, 3.42192390e-04f, -2.99530253e-02f, -1.33628428e-01f, 1.22368634e-02f, -5.72404116e-02f, -9.16740205e-03f, -3.61897312e-02f,
  8.37241337e-02f, 7.35042542e-02f, 2.83567719e-02f, -6.01967517e-03f, -6.11794926e-02f, 1.15444660e-02f, -1.01860054e-01f, -4.24289051e-03f, -5.75249344e-02f, -1.76247646e-04f,
  7.65617043e-02f, -5.44842221e-02f, 8.54045674e-02f, -2.07885113e-02f, -6.33925386e-03f, 2.34987233e-02f, 4.43317033e-02f, 7.75646642e-02f, -4.35064472e-02f, -8.01903382e-02f,
  -4.13095430e-02f, 5.24445586e-02f, 1.98247209e-02f, 6.45793453e-02f, -1.21093439e-02f, 5.90993501e-02f, 1.09731719e-01f, 8.61629024e-02f, 1.11523025e-01f, -3.41092944e-02f,
  5.05343340e-02f, 1.12436056e-01f, -1.41724087e-02f, -3.90521158e-03f, -3.19332927e-02f, -1.80647448e-02f, 6.87197372e-02f, 4.64878567e-02f, 7.35061690e-02f, -1.16296120e-01f,
  5.66404276e-02f, 7.43428916e-02f, -9.02065914e-03f, 3.31861973e-02f, 4.78675738e-02f, 4.95135337e-02f, 3.62334959e-02f, 9.97028202e-02f, 1.44785903e-02f, -3.86384092e-02f,
  -4.41478305e-02f, 1.09940432e-01f, 4.54403050e-02f, 1.06226057e-01f, 6.23187050e-02f, 4.28882800e-02f, 7.37524331e-02f, 1.24574685e-02f, 5.52939624e-02f, -3.96932475e-02f,
  -3.55073176e-02f, -1.86171066e-02f, -1.89616885e-02f, 1.05615631e-01f, -3.85330394e-02f, 1.52113186e-02f, 4.50484417e-02f, 4.37782817e-02f, 1.14810333e-01f, 1.85143738e-03f,
  -9.87230539e-02f, -5.67699559e-02f, -3.02432273e-02f, 1.37664884e-01f, 1.08053029e-01f, 4.75918613e-02f, 5.11151664e-02f, -1.33675635e-02f, 2.88684033e-02f, -1.54315114e-01f,
  4.82256681e-01f, 3.26947123e-01f, 8.28691795e-02f, -2.47357953e-02f, -1.29909366e-01f, 6.88372413e-03f, 7.25614578e-02f, 1.46165520e-01f, 9.09408089e-03f, 1.77447915e-01f,
  8.32911432e-02f, -1.54887527e-01f, -1.82442169e-03f, -2.17393581e-02f, 3.49240676e-02f, 7.09248036e-02f, 3.50973234e-02f, -1.17598623e-01f, -8.40385482e-02f, -1.19283963e-02f,
  -2.32489377e-01f, -1.11339353e-01f, 9.19898748e-02f, 4.05021245e-03f, -4.29794937e-02f, -1.16063513e-01f, 1.48597032e-01f, 8.70110169e-02f, -2.92539336e-02f, -5.81756569e-02f,
  1.19321704e-01f, 2.57592320e-01f, -5.89509197e-02f, -6.12601265e-03f, -8.82118754e-03f, 1.74367696e-01f, -1.85319479e-03f, 1.35023996e-01f, -1.53181795e-02f, 1.43594416e-02f,
  -7.93186128e-02f, -1.16230128e-02f, 6.31991029e-02f, 1.63189005e-02f, 5.80732934e-02f, 1.70133002e-02f, 9.20736119e-02f, 8.33217874e-02f, 1.08896315e-01f, 1.83419604e-02f,
  -3.89698297e-02f, -1.01409510e-01f, 2.02074964e-02f, 3.63261178e-02f, 1.04492828e-01f, -6.03473634e-02f, 1.76175445e-01f, 1.86109096e-01f, 1.60589725e-01f, 2.49722481e-01f,
  6.22067750e-02f, -9.09963101e-02f, -2.37387344e-02f, -6.05520271e-02f, -6.26033619e-02f, -1.31635193e-03f, -9.52861309e-02f, -1.25765711e-01f, -3.98770757e-02f, -2.51566060e-03f,
  -1.19767904e-01f, 4.09219749e-02f, -6.56479672e-02f, -2.64072176e-02f, -1.78498313e-01f, -4.93633561e-02f, -5.48017137e-02f, -4.27427143e-02f, -1.01508014e-01f, 1.49225527e-02f,
  -7.11921379e-02f, -1.38842702e-01f, -1.21168673e-01f, -7.61710703e-02f, -4.14691493e-02f, -7.62358010e-02f, -1.20999841e-02f, -2.90705133e-02f, 4.14891876e-02f, -1.12167686e-01f,
  2.00781286e-01f, 3.34945172e-02f, 1.46447688e-01f, 1.22153513e-01f, 1.08263247e-01f, 7.53087327e-02f, 4.67491597e-02f, 7.13539869e-02f, -3.45942006e-02f, 4.68353145e-02f,
  1.98770668e-02f, 1.36600062e-01f, 1.60883367e-01f, 2.46163905e-02f, 1.97467059e-02f, 5.71556315e-02f, 5.06429337e-02f, -9.28716836e-05f, 2.50006691e-02f, 6.32626610e-03f,
  4.55087200e-02f, 1.66085914e-01f, 1.59072027e-01f, 1.63675457e-01f, 1.21962778e-01f, 7.45783895e-02f, 1.78843662e-01f, 1.27204061e-01f, 2.62312770e-01f, 2.76300728e-01f,
  4.50849175e-01f, 5.11559285e-02f, -3.82690489e-01f, 3.48784804e-01f, -1.30154908e-01f, -1.34190068e-01f, -2.65959710e-01f, 9.27618966e-02f, 3.29781175e-01f, -3.20658693e-03f,
  3.24213272e-03f, 1.43699184e-01f, 4.91413437e-02f, 2.54257359e-02f, -8.45046192e-02f, -3.11834276e-01f, -1.81690931e-01f, -1.07057661e-01f, -5.97689338e-02f, 9.71336849e-03f,
  8.60254467e-02f, 4.30468768e-02f, 2.45762736e-01f, 1.20540842e-01f, -1.53891556e-02f, 3.60143669e-02f, -1.71791956e-01f, 1.98360253e-03f, -8.22721198e-02f, -1.49939135e-01f,
  -2.04133034e-01f, 2.42249370e-01f, 1.00050243e-02f, 1.41695842e-01f, 2.83512454e-02f, 1.16914921e-01f, 2.04994380e-02f, 4.23286743e-02f, 1.05567992e-01f, 1.06725641e-01f,
  1.96080543e-02f, 6.88621253e-02f, 1.30256265e-01f, 3.78539898e-02f, 1.44839257e-01f, 2.17283517e-02f, 1.60713062e-01f, 4.95691635e-02f, -3.86653095e-02f, 1.53242657e-02f,
  2.20657252e-02f, -3.81033905e-02f, -4.90338728e-02f, -5.21802194e-02f, -2.92678867e-02f, -1.53124426e-02f, -7.35959336e-02f, 5.22699580e-02f, 7.59396181e-02f, 1.41303465e-01f,
  1.01857133e-01f, -1.13165947e-02f, -4.29226719e-02f, -3.51200253e-02f, 1.55672804e-02f, 2.54792497e-02f, -4.79439124e-02f, -8.34136680e-02f, -9.17650238e-02f, 5.63051030e-02f,
  2.04615612e-02f, -8.76255110e-02f, 3.09242457e-02f, 1.16363410e-02f, -2.27365140e-02f, -9.28594470e-02f, -9.25348625e-02f, 6.50428142e-03f, -3.54143977e-02f, -6.23645149e-02f,
  -3.19943465e-02f, -7.35159740e-02f, 3.43131833e-02f, -2.48298179e-02f, -8.87444541e-02f, -1.38023898e-01f, -1.20935217e-02f, -2.52913292e-02f, 5.56636937e-02f, 1.74565278e-02f,
  9.07085538e-02f, -2.12664977e-02f, 1.33490667e-03f, -1.82352010e-02f, 7.82912001e-02f, 2.31222380e-02f, -8.12389990e-05f, 1.05190575e-01f, 7.66796470e-02f, 1.89789310e-02f,
  6.28575385e-02f, 6.21685497e-02f, -2.45046373e-02f, -2.06575356e-03f, -2.03307699e-02f, 2.98446640e-02f, 3.27640325e-02f, 2.66928282e-02f, 2.64482722e-02f, 1.43726662e-01f,
  1.22398250e-01f, 5.18343598e-02f, 1.93716828e-02f, 6.33402914e-02f, 2.59864423e-02f, 1.53212892e-02f, -2.54953969e-02f, 6.76026940e-02f, 5.38130179e-02f, 7.43048936e-02f,
  -3.37889880e-01f, 4.75808270e-02f, -3.16318125e-02f, -1.12436181e-02f, 1.90833718e-01f, 1.78814068e-01f, 1.37329437e-02f, 1.38314841e-02f, -1.00471213e-01f, -7.71372020e-02f,
  1.13203004e-01f, 3.84181663e-02f, -2.17468180e-02f, -4.58644778e-02f, -4.91227359e-02f, -6.31391034e-02f, -1.41949551e-02f, -2.24094063e-01f, -2.64427476e-02f, -8.94680023e-02f,
  2.49879416e-02f, -1.03228182e-01f, -3.87397036e-02f, -5.12872376e-02f, -1.73871517e-01f, -1.77905023e-01f, -3.99720855e-02f, -2.01888070e-01f, -2.09814712e-01f, -3.23724717e-01f,
  -3.39477658e-01f, -1.69199742e-02f, -4.07576747e-02f, -1.30321339e-01f, -2.70342361e-02f, -1.20228730e-01f, -7.67446235e-02f, -1.16565876e-01f, -9.04459432e-02f, -1.31553352e-01f,
  -9.77424085e-02f, 1.21057117e-02f, -8.44301656e-02f, -1.38259277e-01f, -1.14620849e-01f, -1.34543553e-01f, 3.33233438e-02f, -6.62361532e-02f, -5.12755513e-02f, -1.44067228e-01f,
  -6.51973039e-02f, -1.21867739e-01f, -1.65760756e-01f, -3.60064171e-02f, -9.68705490e-02f, -4.29565497e-02f, -1.16773464e-01f, -1.87192768e-01f, -2.33806476e-01f, -2.89434016e-01f,
  -5.68097383e-02f, 3.01446067e-03f, 6.55637607e-02f, 3.11233494e-02f, 9.50716087e-04f, 2.67680101e-02f, -5.14062829e-02f, 1.91656034e-02f, 5.96241392e-02f, -2.23950744e-02f,
  1.19005069e-02f, 1.95232518e-02f, 1.09839998e-01f, -4.45061475e-02f, 6.81726038e-02f, 3.85474302e-02f, -8.64706840e-03f, -3.24382484e-02f, 1.38093838e-02f, 1.28861498e-02f,
  -8.91649444e-03f, -3.41819599e-02f, 1.01448014e-01f, -5.05325645e-02f, 6.05547521e-03f, 3.83012481e-02f, 7.87659585e-02f, 5.14952093e-02f, 6.36851490e-02f, 6.74992278e-02f,
  -1.07189072e-02f, 1.53887242e-01f, -2.06800044e-01f, -1.32819578e-01f, -2.53083427e-02f, -1.40923113e-01f, -9.48872231e-03f, -1.03040919e-01f, -7.19276965e-02f, -7.98563734e-02f,
  -4.86094616e-02f, -8.59368220e-02f, -2.77315732e-02f, 2.41662804e-02f, -5.30563667e-02f, -9.17587280e-02f, -2.76246015e-02f, -8.57583359e-02f, -6.27919957e-02f, -9.44888145e-02f,
  -5.95044810e-03f, -9.88884568e-02f, -1.19798772e-01f, -9.40287784e-02f, -1.87020168e-01f, -6.59873113e-02f, -4.05359678e-02f, -2.15307400e-01f, -2.43350074e-01f, -2.59924173e-01f,
  3.58684450e-01f, 2.77375609e-01f, 5.53510562e-02f, 2.40229234e-01f, -7.01678395e-02f, -2.70768050e-02f, 4.84860018e-02f, -3.77193950e-02f, 2.87124980e-02f, 1.44837514e-01f,
  -7.94268772e-02f, -1.38619453e-01f, -1.81454509e-01f, -2.04012692e-01f, -2.34350547e-01f, 1.37845606e-01f, 4.69285324e-02f, -1.31158143e-01f, -2.66718715e-01f, -8.30141753e-02f,
  -3.45494859e-02f, 6.97571933e-02f, -6.82652593e-02f, 6.37537017e-02f, 2.79417634e-01f, -5.34966663e-02f, 1.31007269e-01f, -1.64991785e-02f, -6.86207712e-02f, 2.43694708e-01f,
  1.79802209e-01f, 1.55285642e-01f, -1.52946562e-01f, -7.13975951e-02f, 8.96319523e-02f, 4.51345257e-02f, -1.28536136e-03f, 8.13862160e-02f, 1.30463215e-02f, 5.63739091e-02f,
  5.63199893e-02f, 6.24750229e-03f, 2.07884908e-02f, -8.13819095e-02f, 3.22713666e-02f, -5.05729690e-02f, 3.15731689e-02f, -1.02132507e-01f, -1.53391901e-02f, 9.21531767e-02f,
  -2.10111476e-02f, 4.08053659e-02f, 5.60618415e-02f, -1.12351619e-01f, -9.74928737e-02f, -2.42078513e-01f, 9.35056247e-03f, -4.84923134e-03f, -4.61118817e-02f, 2.37801924e-01f,
  -1.41941977e-03f, -1.02885216e-02f, -8.10780078e-02f, 2.27566939e-02f, -3.48816067e-02f, -6.86766431e-02f, 4.80017066e-02f, 4.77525927e-02f, -6.05452321e-02f, 2.82885507e-03f,
  -1.06092263e-02f, -5.45559227e-02f, 3.80493264e-04f, 1.34020823e-03f, 6.65124580e-02f, -3.59035693e-02f, -6.43775985e-02f, -3.98858823e-02f, -5.46094030e-02f, -7.92322457e-02f,
  2.81488127e-03f, -1.31371960e-01f, 9.83305573e-02f, -1.72499508e-01f, -3.90962549e-02f, 1.13034230e-02f, 1.13870874e-02f, 4.66896258e-02f, 2.32074615e-02f, 9.40718651e-02f,
  1.33876652e-01f, -3.18989217e-01f, 9.54507738e-02f, -7.61357835e-03f, 2.01331768e-02f, -1.07806750e-01f, 4.46748212e-02f, -5.32032028e-02f, 3.29259075e-02f, 1.15333021e-01f,
  -6.68487251e-02f, -2.57241689e-02f, -3.18096280e-02f, -8.05880129e-02f, -6.16658479e-03f, -8.08244571e-02f, 3.83505188e-02f, 1.49078015e-03f, -1.29525587e-01f, 9.17150304e-02f,
  2.66698878e-02f, -5.42414114e-02f, -1.79210454e-02f, -1.12050632e-02f, 6.82643440e-04f, -1.08435929e-01f, 3.11214030e-02f, -1.07767321e-01f, -1.49734333e-01f, 1.43184811e-01f,
  -7.89457038e-02f, 3.46591055e-01f, 1.51691377e-01f, 1.76682472e-01f, 1.40845105e-01f, 1.17333956e-01f, 2.89684385e-01f, 1.36044577e-01f, -1.21725589e-01f, 1.67884424e-01f,
  3.05444390e-01f, 2.11313471e-01f, 1.45372882e-01f, 2.74239834e-02f, 2.70180684e-02f, 2.03147843e-01f, 8.08068272e-03f, -5.83004691e-02f, 2.20214408e-02f, -1.74309947e-02f,
  1.44640133e-01f, 4.81013171e-02f, -5.19521609e-02f, -1.42236529e-02f, 8.70927647e-02f, -5.53098433e-02f, 1.86826997e-02f, 7.62988925e-02f, -5.69137074e-02f, 4.57751416e-02f,
  2.26542428e-01f, -4.33202498e-02f, 1.38567826e-02f, 7.37641081e-02f, 6.32116422e-02f, -4.49507758e-02f, 1.40361115e-01f, -7.68131614e-02f, 3.47604044e-02f, 3.51984352e-02f,
  1.37805700e-01f, 4.30054329e-02f, 3.01669054e-02f, 1.39013320e-01f, 9.55846161e-02f, 7.10509121e-02f, -2.61667073e-02f, -2.93233693e-02f, -3.63575085e-03f, 9.80500653e-02f,
  1.43336862e-01f, 1.14425041e-01f, -2.09346041e-02f, 9.09173861e-03f, -2.84568444e-02f, 9.08442810e-02f, 5.34490161e-02f, -9.43606496e-02f, 5.83258756e-02f, 7.45514035e-02f,
  -3.33565250e-02f, 4.22496237e-02f, 2.24412382e-02f, -3.64410840e-02f, -1.39588956e-02f, -1.54222801e-01f, 3.50135006e-02f, 4.76920195e-02f, -8.94394666e-02f, -1.46010444e-01f,
  -7.94780105e-02f, -9.88180749e-03f, -6.57191277e-02f, -1.99266393e-02f, 5.69221824e-02f, -3.79147194e-02f, 1.99700613e-02f, 2.74427105e-02f, -8.23667422e-02f, -6.24189302e-02f,
  -7.72536099e-02f, -2.63209511e-02f, -5.67971841e-02f, -1.28560811e-02f, -1.19759120e-01f, -6.20751223e-03f, -7.89982453e-02f, -1.05353100e-02f, -1.52561581e-02f, -8.91678631e-02f,
  1.16617382e-01f, -7.72851408e-02f, 1.18074909e-01f, 1.36428252e-01f, 1.02373004e-01f, 4.41880412e-02f, 1.64319035e-02f, 6.03886172e-02f, 4.84965555e-02f, 4.29632217e-02f,
  7.06963763e-02f, 1.27175571e-02f, 4.62539010e-02f, 8.35500434e-02f, 2.57448070e-02f, 1.61659885e-02f, 1.30493850e-01f, 8.43302906e-02f, 1.45802712e-02f, 3.04440241e-02f,
  2.85621621e-02f, 1.62544437e-02f, 1.35754690e-01f, 6.71472102e-02f, 1.84554234e-02f, 1.20782845e-01f, 1.80325553e-01f, 9.67330784e-02f, 1.46688834e-01f, 2.11840764e-01f,
  -1.69484526e-01f, -1.13203794e-01f, 2.35583261e-01f, -6.78839833e-02f, -2.06627492e-02f, 6.75943028e-03f, -3.22024912e-01f, -2.14335710e-01f, -1.07958987e-01f, -1.41735390e-01f,
  1.32764280e-02f, 4.45453962e-03f, 5.75452372e-02f, -4.71763462e-02f, -1.54606268e-01f, -1.81819052e-01f, -8.91396925e-02f, 1.08578674e-01f, 1.19802594e-01f, -3.70114893e-02f,
  -2.45533943e-01f, -2.16197371e-01f, -2.08668604e-01f, -1.70984879e-01f, -1.08784206e-01f, -7.79344440e-02f, 5.02484143e-02f, -6.40283059e-03f, 5.05443774e-02f, -4.14444357e-02f,
  2.29505852e-01f, -5.40926903e-02f, -8.48403797e-02f, -1.70814723e-01f, -1.27772793e-01f, -5.44105992e-02f, -1.88332886e-01f, -1.08106442e-01f, -1.39148384e-01f, -1.48379520e-01f,
  -1.00593224e-01f, -1.39103547e-01f, -1.42695960e-02f, -1.04284361e-01f, -2.22362101e-01f, -1.55093759e-01f, -1.67465419e-01f, -2.27416307e-01f, -1.03599392e-01f, -1.20212980e-01f,
  -2.53889322e-01f, -2.23391369e-01f, -1.58029087e-02f, -6.50199577e-02f, -1.26043350e-01f, -1.61407925e-02f, -1.15103997e-01f, 9.39203147e-03f, 2.21384410e-02f, -1.77528575e-01f,
  -8.55904371e-02f, 1.18182629e-01f, 6.36486560e-02f, 1.04057854e-02f, -2.42315028e-02f, 1.50948331e-01f, 1.79440454e-01f, 1.03009671e-01f, 8.20481181e-02f, 1.53357089e-01f,
  1.16150819e-01f, 9.48747471e-02f, 1.14502333e-01f, 4.57676165e-02f, 1.67238280e-01f, 3.86086516e-02f, 1.44098520e-01f, 4.54452820e-02f, 1.16450720e-01f, 5.87376654e-02f,
  -2.32648640e-03f, 1.21618427e-01f, 8.58451575e-02f, 2.88619623e-02f, 1.78632110e-01f, 2.12146770e-02f, 1.22304134e-01f, 7.10410625e-02f, 6.50812313e-02f, 1.49351820e-01f,
  -6.93276376e-02f, 2.26352736e-03f, -1.19188361e-01f, -1.67057246e-01f, -1.45410508e-01f, -1.23085663e-01f, -3.74706089e-02f, -1.60244852e-01f, -5.16523309e-02f, -5.29166311e-02f,
  -1.51216090e-01f, -1.17448948e-01f, -6.09868355e-02f, -1.30947515e-01f, -1.47115320e-01f, -1.63806349e-01f, -1.45328790e-01f, -4.93094586e-02f, -1.22047402e-01f, -6.47561401e-02f,
  -2.31154710e-01f, -1.31411821e-01f, -9.48642343e-02f, -2.15754174e-02f, -1.31688759e-01f, 1.54818525e-03f, -5.22451475e-02f, -1.14795573e-01f, -8.18403289e-02f, -1.68614879e-01f,
  3.18204552e-01f, -1.36068508e-01f, 8.54581594e-03f, 8.91922489e-02f, -4.49511707e-02f, 1.09546989e-01f, -8.52183700e-02f, -8.30758661e-02f, -1.37047872e-01f, -1.32616773e-01f,
  -2.20163092e-01f, 2.60812026e-02f, -3.20779756e-02f, 1.50851160e-02f, 1.77415609e-02f, -7.63344988e-02f, -1.40022067e-02f, 2.16845691e-01f, 1.49089977e-01f, 9.99288708e-02f,
  -5.17395604e-03f, 7.38603324e-02f, 1.08478598e-01f, 8.17958191e-02f, -2.48750038e-02f, 1.06266942e-02f, -1.73959434e-01f, -6.50268048e-02f, -4.02094610e-02f, 5.66944294e-02f,
  -8.17518532e-02f, 3.11283488e-02f, -1.37876179e-02f, -9.34102293e-03f, -6.39403760e-02f, 1.12798959e-01f, -2.05333065e-02f, -5.70546510e-03f, -1.28322560e-02f, -3.36406194e-02f,
  9.65848640e-02f, 7.13358223e-02f, 1.27936050e-01f, 1.44264800e-02f, -2.96884663e-02f, -3.24855819e-02f, 2.99239233e-02f, 7.26454556e-02f, -2.94029023e-02f, -1.09393485e-01f,
  6.42172992e-02f, 6.52751252e-02f, -2.63107172e-03f, -2.24051028e-02f, -7.79813826e-02f, 3.26826200e-02f, -9.07236412e-02f, -8.62061456e-02f, -8.33552331e-03f, -1.08680598e-01f,
  7.25278333e-02f, 1.50201172e-02f, -6.51023835e-02f, 4.47358079e-02f, -1.41268875e-02f, -1.33041339e-03f, 7.33145606e-03f, 2.39961110e-02f, -7.27405250e-02f, 6.78106174e-02f,
  5.38839549e-02f, -6.44146800e-02f, 2.98882239e-02f, -3.43851224e-02f, -1.08270824e-01f, -4.97608595e-02f, -2.83791143e-02f, -1.85680911e-02f, -2.78879981e-02f, 8.02735146e-03f,
  3.98377925e-02f, 1.01254255e-01f, -2.82523930e-02f, 3.36968079e-02f, -2.53379662e-02f, -4.99322452e-03f, 4.85982671e-02f, 2.45008487e-02f, -3.60850357e-02f, -1.82922892e-02f,
  -1.12897545e-01f, -1.83588676e-02f, -8.26290995e-02f, -2.13520415e-02f, 2.21908875e-02f, -2.54885890e-02f, -2.88784262e-02f, -1.00641325e-02f, 5.64742163e-02f, 1.19646834e-02f,
  3.80283371e-02f, 3.64244245e-02f, 4.78444099e-02f, -1.26039926e-02f, 1.40605479e-01f, 2.88943294e-02f, 5.91633134e-02f, -3.89064662e-02f, 6.78940937e-02f, -8.83017629e-02f,
  3.00067291e-02f, -5.60636744e-02f, 1.68589409e-02f, 8.59549362e-03f, -4.82637435e-02f, 1.07008532e-01f, -4.29783389e-02f, -1.23467040e-03f, 1.47978086e-02f, -8.34159479e-02f,
  -4.03303236e-01f, 2.38655791e-01f, -1.66528434e-01f, 1.17572226e-01f, 1.40608490e-01f, -7.81847984e-02f, -4.94980216e-02f, -7.82333389e-02f, -1.44782970e-02f, 7.06162825e-02f,
  5.90946339e-02f, -3.99532169e-02f, 6.00171238e-02f, -3.98697294e-02f, -3.09665084e-01f, -5.09057827e-02f, 1.92762800e-02f, -2.75669456e-01f, -3.43789935e-01f, -4.41581570e-02f,
  1.76276147e-01f, -3.83717492e-02f, -7.79596418e-02f, 6.85670897e-02f, 2.41653204e-01f, -1.28989145e-02f, 1.81715816e-01f, 1.73972175e-02f, 9.44484100e-02f, 1.14152752e-01f,
  7.52382576e-02f, 8.35610479e-02f, -9.17151663e-03f, 1.20538451e-01f, 1.42951101e-01f, 3.59849893e-02f, 7.83415958e-02f, 7.96211138e-02f, 1.17748834e-01f, 6.04608245e-02f,
  4.96231280e-02f, 3.32517698e-02f, 1.37878925e-01f, 3.94122601e-02f, 4.16313559e-02f, -7.53728226e-02f, 1.23079889e-01f, -4.98004556e-02f, -5.14505766e-02f, 5.56467362e-02f,
  9.53371599e-02f, 5.85705452e-02f, 3.88936624e-02f, 8.67918059e-02f, 6.29728287e-02f, -4.77746464e-02f, 1.25343636e-01f, 1.20447554e-01f, -9.43774730e-02f, 2.06279606e-01f,
  1.00623012e-01f, -4.92399111e-02f, -4.82060723e-02f, 3.75297964e-02f, 3.70988138e-02f, 7.93822929e-02f, -2.41373349e-02f, 5.94461150e-02f, -2.57117813e-03f, 7.50003979e-02f,
  7.75322467e-02f, -1.05639651e-01f, -5.81731275e-02f, 1.13555156e-02f, -1.11613423e-01f, 4.80893021e-03f, -5.63955605e-02f, -7.97042176e-02f, 3.02403681e-02f, -3.32492143e-02f,
  -9.28105135e-03f, -4.39142473e-02f, 1.36817917e-02f, -4.48269509e-02f, 1.60590634e-02f, -5.04963286e-02f, -1.04341954e-01f, -2.16096453e-02f, -1.10227959e-02f, 1.25214476e-02f,
  5.81780784e-02f, -5.26724793e-02f, 6.65955991e-02f, 2.49826536e-02f, -5.24132848e-02f, 9.03143883e-02f, 4.51414250e-02f, 3.10925655e-02f, 4.69668508e-02f, 2.54574530e-02f,
  5.19116931e-02f, -2.52915230e-02f, 2.79752873e-02f, -5.67456754e-03f, 1.42029384e-02f, 4.71397974e-02f, 1.15458877e-03f, -5.82344756e-02f, 8.63746461e-03f, 8.73207301e-02f,
  9.47766006e-02f, 4.68346896e-03f, -1.17061771e-01f, -4.56173792e-02f, 2.52828393e-02f, -7.16028586e-02f, 3.37787457e-02f, -3.10369767e-02f, -2.38916099e-01f, 1.13743693e-01f,
  -7.88188167e-03f, 8.42963010e-02f, 1.46151870e-01f, -1.37512162e-01f, 6.42579049e-02f, 4.13679108e-02f, 3.06788713e-01f, 1.04818791e-01f, -2.68009573e-01f, 2.11549345e-02f,
  -2.31840555e-02f, -2.22716719e-01f, -2.35225052e-01f, -1.22275956e-01f, 1.17646419e-01f, 1.80940330e-01f, 1.08011968e-01f, 1.61634579e-01f, 5.09909093e-02f, 1.05603226e-01f,
  -4.09293063e-02f, -3.94847244e-02f, -6.45098016e-02f, 8.10255110e-02f, -2.43915748e-02f, -1.59530401e-01f, -4.32690158e-02f, -7.69735873e-02f, -1.82334539e-02f, -4.31271084e-02f,
  6.72729090e-02f, 1.08330175e-02f, 1.41887767e-02f, -9.69668105e-02f, -9.13739726e-02f, -2.24760287e-02f, 1.36361376e-03f, -1.81420967e-02f, 3.73812243e-02f, -3.36559638e-02f,
  -8.31810087e-02f, 3.54909501e-03f, -2.00947709e-02f, -4.02923338e-02f, -3.26940790e-02f, -3.69256027e-02f, -5.78930527e-02f, -1.22111598e-02f, -1.15594240e-02f, 1.85938962e-02f,
  -9.37454328e-02f, 5.99073097e-02f, -7.34003112e-02f, 3.27788964e-02f, -2.81278752e-02f, 8.62010848e-03f, 5.63301779e-02f, -1.85249262e-02f, 7.22992346e-02f, -7.10557327e-02f,
  -5.68073131e-02f, 2.61176797e-03f, 7.61651099e-02f, 1.56108560e-02f, 3.41221914e-02f, 2.53170822e-02f, -9.65685695e-02f, 3.83575335e-02f, -4.53798845e-02f, -1.62275657e-02f,
  3.89469825e-02f, -2.24748217e-02f, -8.62271711e-02f, 6.10879399e-02f, -1.74967889e-02f, 7.20020533e-02f, -1.05640128e-01f, 5.44586591e-02f, 3.29956263e-02f, 7.32835680e-02f,
  -5.50514981e-02f, 5.77437133e-02f, -5.86301684e-02f, 1.34749413e-02f, 6.92455992e-02f, -5.08242287e-02f, 1.85432173e-02f, -4.17855084e-02f, 4.15527970e-02f, 6.38798103e-02f,
  -3.17184091e-01f, 1.16811832e-02f, 3.43782529e-02f, 2.37630010e-02f, 9.50792208e-02f, 1.44412266e-02f, -5.05589135e-02f, 9.18145999e-02f, -8.85270387e-02f, 8.64508525e-02f,
  2.15164293e-02f, -5.69317080e-02f, -1.02873735e-01f, -1.65108696e-03f, -3.80711332e-02f, 1.66322868e-02f, -2.72695664e-02f, 5.41228913e-02f, 9.84399114e-03f, -8.79053771e-02f,
  -7.84567520e-02f, 3.17186378e-02f, -6.25810102e-02f, 5.83121851e-02f, 1.95319299e-02f, 2.82453969e-02f, -8.36222898e-03f, 4.79903594e-02f, -5.69492802e-02f, -5.13924807e-02f
};

// L0_fan_Wp_bar (Shape: 40 x 120)
const int L0_fan_Wp_bar_rows = 40;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  6.64355576e-01f, -1.45326242e-01f, -5.49308836e-01f, 3.25693153e-02f, -2.73668915e-01f, -1.99498191e-01f, -1.86593115e-01f, 6.25285208e-02f, 2.56861955e-01f, -2.07551882e-01f,
  -2.32158929e-01f, 2.47194409e-01f, -9.25579574e-03f, -6.83732331e-02f, -4.80959378e-02f, -3.71273905e-01f, -2.94647008e-01f, -1.85058698e-01f, -2.19796263e-02f, 1.53219048e-02f,
  -4.33815494e-02f, 1.29838228e-01f, 1.85378686e-01f, 3.93396653e-02f, -4.32379879e-02f, -1.17528200e-01f, -3.81938457e-01f, -1.03555471e-01f, -1.91742003e-01f, -2.25157693e-01f,
  -4.64804947e-01f, -2.24815518e-01f, -2.33445138e-01f, 9.88520086e-02f, -1.61861703e-01f, 1.21084936e-01f, -3.96024622e-02f, -9.70716774e-03f, -1.74649972e-02f, -6.77580461e-02f,
  -1.28462300e-01f, 9.14712995e-02f, 1.24837011e-01f, -6.93883672e-02f, -3.91503945e-02f, 5.37928641e-02f, -1.18129797e-01f, -3.42687890e-02f, -7.60930777e-02f, -3.52566093e-02f,
  -1.67704448e-02f, -1.87493842e-02f, -6.34924471e-02f, -1.67837977e-01f, -1.50669590e-01f, -8.11790302e-02f, -2.59283364e-01f, -3.86280380e-02f, -2.18710497e-01f, -9.46444552e-03f,
  -7.49078840e-02f, -8.14863965e-02f, -8.19477513e-02f, 2.45927330e-02f, 6.25485331e-02f, -1.05109707e-01f, 5.71588473e-03f, -1.78812575e-02f, -4.62216092e-03f, 1.39361396e-02f,
  -4.72819805e-02f, -1.15034848e-01f, -5.32439239e-02f, -5.66458777e-02f, -1.50128379e-01f, 4.99708876e-02f, 5.68272371e-04f, -2.85518467e-02f, -3.63160707e-02f, 3.86940241e-02f,
  4.50979061e-02f, -2.70026416e-04f, 1.72187609e-03f, -1.93625514e-03f, -5.16920723e-02f, -7.28628039e-02f, -7.07542598e-02f, -1.59778772e-03f, 1.58138379e-01f, -7.87232164e-03f,
  2.37987593e-01f, -1.35746837e-01f, 5.92534952e-02f, 2.10540611e-02f, -9.89145488e-02f, -8.68605822e-02f, -4.31374758e-02f, 1.17392745e-03f, 4.96950038e-02f, -4.73972149e-02f,
  -1.45522887e-02f, 9.63563100e-02f, -3.47454883e-02f, -1.25120506e-01f, -2.33044047e-02f, -8.58500898e-02f, 7.42226690e-02f, 8.07514265e-02f, 9.24962088e-02f, 8.23464841e-02f,
  -4.33876645e-03f, 2.21585110e-02f, 1.59644142e-01f, -5.65652549e-02f, 3.02065294e-02f, 1.73509985e-01f, 3.34037580e-02f, 5.70539683e-02f, 1.04403280e-01f, -3.84029970e-02f,
  -1.98290631e-01f, -1.57897741e-01f, -2.96467304e-01f, 2.51160741e-01f, 2.60657370e-01f, -6.78309426e-02f, -2.12467194e-01f, -2.86414832e-01f, 1.34377465e-01f, 4.51618955e-02f,
  2.01927572e-02f, 2.44525179e-01f, -5.29121235e-02f, 1.88309383e-02f, -2.05175206e-01f, -1.41937867e-01f, 6.13646694e-02f, -4.16550552e-04f, -4.62753586e-02f, -1.97477899e-02f,
  2.63676256e-01f, 1.21725410e-01f, 2.27149273e-03f, 7.96478149e-03f, 1.09502628e-01f, 1.55152500e-01f, -7.63278082e-02f, 1.07667193e-01f, -6.58816565e-03f, 3.42276782e-01f,
  -5.53516373e-02f, -1.45222768e-01f, -1.16625004e-01f, 1.79629877e-01f, 9.83913913e-02f, -1.37036294e-01f, -8.16588849e-03f, -7.58579075e-02f, -7.06495643e-02f, -4.83149476e-02f,
  8.52793977e-02f, -3.22098248e-02f, 1.85940444e-01f, -1.45657957e-02f, 4.01655119e-03f, -1.72120556e-01f, -1.35116920e-01f, -1.44310117e-01f, -3.19359213e-01f, -1.79127567e-02f,
  3.33881110e-01f, 1.94745392e-01f, -2.11824387e-01f, -2.93658316e-01f, -2.61373043e-01f, -1.17077164e-01f, -1.56403109e-01f, -4.53500077e-02f, -4.16926771e-01f, -7.55853876e-02f,
  -9.92247164e-02f, -9.93507262e-03f, 3.92091163e-02f, -1.41387228e-02f, 3.62837501e-02f, 3.37810256e-02f, 4.64260951e-02f, -1.92699432e-02f, 3.62398960e-02f, -8.68424773e-02f,
  6.46910965e-02f, -5.64949587e-02f, -3.26381214e-02f, -3.52554396e-02f, 1.94809791e-02f, -3.03768832e-02f, 3.16878743e-02f, -1.04824722e-01f, -9.54088494e-02f, -1.02286436e-01f,
  3.57759520e-02f, -8.04843158e-02f, 9.76747721e-02f, 4.92286086e-02f, -5.24508692e-02f, -1.99034303e-01f, -1.80028155e-02f, -6.34017661e-02f, -1.75745040e-01f, -4.50222977e-02f,
  -3.21046934e-02f, -2.85763592e-02f, 1.82345510e-02f, -1.64169427e-02f, 2.27765553e-02f, 3.98063809e-02f, 3.74626145e-02f, 1.67992860e-02f, -1.04191460e-01f, -1.17694914e-01f,
  -4.53320658e-03f, -1.66884810e-01f, 2.24035680e-02f, -2.52352245e-02f, 7.37529621e-02f, 4.98028584e-02f, 4.06143302e-03f, 7.55117238e-02f, -2.09098041e-01f, 1.46914497e-01f,
  2.81951055e-02f, -1.12682626e-01f, -1.67626292e-01f, -1.30418614e-01f, -6.61398694e-02f, -6.18336014e-02f, -2.21154511e-01f, -1.15477741e-01f, -3.74781221e-01f, -2.48401836e-01f,
  -3.28799427e-01f, 2.30180234e-01f, 1.14151137e-02f, 1.09657936e-01f, 1.33976698e-01f, 1.34552211e-01f, 1.62170097e-01f, 4.25685942e-03f, -7.49103799e-02f, -9.01576970e-03f,
  4.10492718e-02f, -1.61669625e-03f, 1.25537917e-01f, -3.96263301e-02f, 7.23260492e-02f, 1.58014655e-01f, 2.05576837e-01f, 2.81198956e-02f, -3.00940126e-01f, -2.20034122e-01f,
  4.02068309e-02f, -9.35523733e-02f, -1.90869376e-01f, 1.05997268e-02f, 1.72713012e-01f, -3.68773788e-02f, 3.65620144e-02f, 1.46951824e-01f, 1.62065849e-01f, 2.41218820e-01f,
  -1.17395863e-01f, 8.01107958e-02f, -2.99028326e-02f, -1.17578313e-01f, -1.40962834e-02f, -1.15504399e-01f, -1.66715220e-01f, -8.21202807e-03f, 1.08455226e-01f, -1.42250970e-01f,
  9.35765877e-02f, 4.07340676e-02f, 1.10912248e-01f, -6.47174269e-02f, -2.38740727e-01f, -2.37632021e-01f, -2.06364244e-01f, -2.20195770e-01f, -2.33611420e-01f, -1.28521204e-01f,
  2.17179373e-01f, -1.53295761e-02f, -1.72070429e-01f, -4.46438743e-03f, -9.81455669e-02f, -9.82468501e-02f, -1.53234258e-01f, -7.25149661e-02f, -7.21342713e-02f, -9.49984416e-02f,
  6.04840294e-02f, 4.27731797e-02f, 8.03262144e-02f, 7.93049559e-02f, -7.53856217e-03f, 7.31978416e-02f, 1.43670261e-01f, -2.15574354e-03f, 4.76653911e-02f, 1.05967512e-03f,
  2.58096475e-02f, -4.69544008e-02f, -5.80082573e-02f, 7.26000294e-02f, 1.06681146e-01f, -8.66165198e-03f, 7.40757957e-02f, 1.12758487e-01f, 2.34004278e-02f, -8.16984549e-02f,
  2.78393249e-03f, -1.12246886e-01f, -3.32772061e-02f, -8.80955830e-02f, 7.99385533e-02f, 4.02164310e-02f, -4.83481362e-02f, -3.86008993e-02f, -5.83713129e-02f, -1.37452665e-03f,
  -9.15740579e-02f, 1.07462265e-01f, 2.05880385e-02f, 4.74901199e-02f, 6.45974651e-02f, -1.35126626e-02f, 1.37724265e-01f, 4.60468158e-02f, 4.83911037e-02f, -1.48803264e-01f,
  -1.11759253e-01f, -1.95250124e-01f, 8.28925446e-02f, 2.08851192e-02f, -1.52526751e-01f, -8.38440731e-02f, 5.32983355e-02f, -4.18151505e-02f, -1.49767950e-01f, -1.25854418e-01f,
  1.33828428e-02f, -6.89307824e-02f, -2.51538128e-01f, -9.61400717e-02f, -1.30806223e-01f, -1.37182757e-01f, -1.93947330e-01f, -5.75437881e-02f, -2.40099847e-01f, -2.46861741e-01f,
  -5.11131227e-01f, 2.60210428e-02f, 1.69289917e-01f, -2.85677344e-01f, 1.45984692e-02f, 1.60683729e-02f, 1.97998106e-01f, -5.27761169e-02f, -1.24415942e-01f, 2.56992847e-01f,
  1.82350963e-01f, -2.73066819e-01f, -4.97116931e-02f, -2.57949203e-01f, -2.96881467e-01f, 1.34056732e-01f, 1.06773064e-01f, -3.22496772e-01f, -4.13609773e-01f, -1.49103895e-01f,
  -1.04221970e-01f, -3.56071681e-01f, -4.29689497e-01f, -3.07123363e-01f, -5.40707894e-02f, -2.34842718e-01f, 9.01128054e-02f, -1.71542034e-01f, -3.15309502e-02f, 5.60218208e-02f,
  1.90740064e-01f, -1.81625053e-01f, 6.22705892e-02f, -1.75380230e-01f, -6.41535521e-02f, -2.41919374e-03f, -6.84192404e-02f, -9.22023281e-02f, -7.37794191e-02f, 5.66538237e-02f,
  -6.76136091e-02f, -6.22582547e-02f, -2.08030030e-01f, -6.55289069e-02f, -1.18345290e-01f, -1.38673410e-01f, 6.28892891e-03f, -1.89251512e-01f, -1.05328321e-01f, 1.81498587e-01f,
  7.00272247e-02f, -1.26884192e-01f, -7.61947706e-02f, 3.82227637e-02f, -1.06217392e-01f, -1.59667462e-01f, 3.19114104e-02f, 1.96572263e-02f, -1.77851282e-02f, 1.32494837e-01f,
  5.51789738e-02f, 2.09099818e-02f, -1.51063073e-02f, 1.26655539e-03f, 6.30776510e-02f, 6.62524030e-02f, 5.64714484e-02f, -2.20176391e-02f, -1.22946687e-01f, -7.61800632e-02f,
  6.91043511e-02f, 6.65921271e-02f, 5.43695465e-02f, -9.29872170e-02f, -6.56900704e-02f, -5.29288501e-02f, -8.04401338e-02f, 8.12567770e-03f, 9.24342778e-03f, -3.41237858e-02f,
  -1.18027508e-01f, 2.41914648e-03f, -5.01470529e-02f, -1.01719350e-01f, -4.05864231e-02f, 3.94740812e-02f, 4.02066112e-02f, -3.30779962e-02f, -1.37146086e-01f, 1.34634627e-02f,
  3.41659114e-02f, -7.48920515e-02f, 7.01549202e-02f, 5.03673963e-03f, 8.67278129e-02f, -2.41800062e-02f, 2.08366781e-01f, 3.40028144e-02f, 7.09600896e-02f, 3.03586982e-02f,
  -6.97035715e-02f, 9.19023752e-02f, 8.37390721e-02f, 1.70507863e-01f, 7.00979400e-03f, 1.84131805e-02f, 2.13185489e-01f, -6.95929155e-02f, 7.39963055e-02f, 1.49004355e-01f,
  2.16098621e-01f, 3.91689949e-02f, 7.79645517e-02f, 1.31240621e-01f, -2.07958948e-02f, -9.10866112e-02f, 6.10629134e-02f, 7.04120100e-02f, 1.08796611e-01f, 3.25837612e-01f,
  -1.85814127e-01f, -2.26882324e-01f, -3.75089407e-01f, -1.51261434e-01f, -2.80236490e-02f, 6.83103572e-04f, -1.86825439e-01f, 1.54149219e-01f, 1.78210139e-01f, -8.54104478e-03f,
  9.54510421e-02f, 1.49228498e-01f, 1.05385529e-02f, -3.82284857e-02f, -1.63437739e-01f, -2.64154136e-01f, -4.14573282e-01f, -2.77897179e-01f, 8.15486982e-02f, 1.74741909e-01f,
  1.13323525e-01f, 1.00533618e-02f, 1.10981911e-01f, 8.16859975e-02f, 4.06669863e-02f, 1.36580959e-01f, -8.23643357e-02f, -7.79115409e-03f, -3.98805290e-02f, -1.29724726e-01f,
  -1.15931191e-01f, 4.02527601e-02f, 4.63763475e-02f, -4.84944023e-02f, -1.82901442e-01f, -7.08132237e-02f, -7.84819424e-02f, -1.03847854e-01f, 7.76039064e-02f, 3.10677886e-02f,
  -2.33097398e-03f, 1.65880650e-01f, 1.72518753e-02f, 1.34580778e-02f, -3.00113373e-02f, 1.35451570e-01f, -3.96661349e-02f, -1.63396463e-01f, -2.04191163e-01f, -2.77724415e-02f,
  -3.46878618e-02f, -2.16378212e-01f, -2.88718224e-01f, -5.79308830e-02f, -2.90216431e-02f, -1.16248697e-01f, 1.79238603e-01f, 4.84418236e-02f, 8.88024420e-02f, 6.26897812e-02f,
  -5.07550873e-02f, -3.91061604e-03f, 9.11166295e-02f, 2.45446507e-02f, 8.29337537e-02f, 4.18683477e-02f, 3.99060585e-02f, -1.22288235e-01f, 2.12404542e-02f, -1.57790147e-02f,
  8.44141617e-02f, 3.23992744e-02f, 6.99116513e-02f, 4.58396450e-02f, -1.55604370e-02f, -6.29627556e-02f, 6.25303909e-02f, -8.51254910e-02f, -7.38076866e-02f, 1.12443389e-02f,
  2.95880847e-02f, 4.60605696e-02f, -9.92427394e-03f, 1.13979891e-01f, -1.57591440e-02f, -8.75734016e-02f, 6.39344230e-02f, 1.51041225e-01f, 1.12198964e-01f, 3.87806408e-02f,
  1.60175577e-01f, -6.33190274e-02f, -3.42520475e-02f, 5.61175570e-02f, -1.04469530e-01f, 2.50308271e-02f, 1.70652792e-02f, -1.32764027e-01f, -1.84662156e-02f, 9.86181051e-02f,
  1.44509867e-01f, 1.60987765e-01f, -1.28104584e-02f, 1.08659968e-01f, 1.04136646e-01f, 8.94733816e-02f, -4.72906046e-02f, -1.37005255e-01f, -6.48814738e-02f, 5.62860370e-02f,
  -8.32942277e-02f, -6.47618249e-02f, -2.28334382e-01f, -1.91091985e-01f, -2.75190978e-04f, -6.23874031e-02f, 4.99483049e-02f, 1.25827700e-01f, 1.08773075e-01f, 1.00078844e-01f,
  3.72777790e-01f, -2.01607838e-01f, 2.08789960e-01f, 2.66831070e-01f, 1.20356388e-01f, 1.70906648e-01f, 1.65804982e-01f, 1.96157128e-01f, 1.45053059e-01f, 1.26014590e-01f,
  3.04983798e-02f, 4.06487845e-02f, 6.59094751e-02f, 7.91366845e-02f, 1.50994933e-03f, 1.06934465e-01f, 1.30118743e-01f, 2.36648038e-01f, 2.02057824e-01f, 5.39506450e-02f,
  -2.77322140e-02f, 2.35289410e-02f, 7.60624325e-03f, 1.90727282e-02f, 6.01204038e-02f, 1.07725754e-01f, 2.38129608e-02f, -6.23269528e-02f, -3.46574709e-02f, -5.74600399e-02f,
  5.79250455e-02f, 9.64935720e-02f, 3.23211625e-02f, -1.96544513e-01f, -6.32882565e-02f, 1.48761179e-02f, 5.37505792e-03f, -8.22220147e-02f, -2.06885651e-01f, -1.09717250e-01f,
  -5.03229387e-02f, 2.38037407e-02f, -2.51270663e-02f, -1.17421657e-01f, -5.85574396e-02f, -1.00735836e-01f, -1.15364350e-01f, 1.27920300e-01f, -1.03574842e-02f, 5.89069948e-02f,
  1.16824508e-02f, 2.72362921e-02f, 1.38574252e-02f, 1.02799788e-01f, 1.32707283e-01f, -4.02734056e-02f, 9.47897285e-02f, 1.09294057e-01f, 2.20196843e-02f, 8.04696325e-03f,
  1.02642611e-01f, 1.47286475e-01f, 2.18146205e-01f, 1.12927340e-01f, -6.05273852e-03f, -4.57771979e-02f, -1.98104717e-02f, 7.28348345e-02f, 1.42869458e-01f, 8.68592411e-02f,
  -6.39836639e-02f, 1.14740662e-01f, 1.60831094e-01f, 1.70518711e-01f, 1.04537249e-01f, -2.29747710e-03f, -7.15141697e-03f, -4.88321483e-02f, -6.57445267e-02f, 2.02165712e-02f,
  1.12957895e-01f, 5.99126481e-02f, -1.31737247e-01f, -1.02882758e-02f, -9.27934945e-02f, 1.10438071e-01f, -6.21722639e-03f, 5.02551114e-03f, -1.42527698e-02f, -1.52805476e-02f,
  -1.57864347e-01f, 1.93984583e-01f, 5.32616265e-02f, -4.68866564e-02f, -2.58918069e-02f, -1.66461065e-01f, 2.95751654e-02f, -1.21531531e-01f, -1.86998725e-01f, -5.33238538e-02f,
  -4.86261733e-02f, 5.27370758e-02f, -7.32088834e-02f, 5.08013852e-02f, 1.52007993e-02f, -7.52085149e-02f, -1.22264221e-01f, 1.15315907e-01f, 5.82693666e-02f, 3.65266353e-02f,
  -2.78458856e-02f, 9.36427861e-02f, 1.44841507e-01f, 1.47734985e-01f, 2.32322048e-02f, 9.17881057e-02f, 2.58243382e-02f, -2.19830796e-02f, 6.82785138e-02f, -5.19351512e-02f,
  7.48925060e-02f, 7.41989836e-02f, -2.08777800e-01f, 1.97062008e-02f, -5.60021251e-02f, -3.02721679e-01f, -3.05427790e-01f, -1.19814791e-01f, 1.36351034e-01f, -2.20360145e-01f,
  -4.03992906e-02f, 1.31263882e-01f, 7.67954141e-02f, -6.46020919e-02f, -2.19107628e-01f, -3.73338342e-01f, -3.00428778e-01f, -2.15204433e-01f, -1.18950345e-01f, -2.35536501e-01f,
  -1.12594310e-02f, 3.10308281e-02f, 2.85991887e-03f, -6.64419755e-02f, 8.88832845e-03f, 7.57278800e-02f, 2.56354059e-03f, -4.87622246e-02f, -5.65278381e-02f, 2.52174847e-02f,
  1.02070667e-01f, -5.96162491e-02f, -1.58928126e-01f, -3.35188466e-03f, 2.14849576e-01f, -1.49162054e-01f, -1.41786793e-02f, -2.82773119e-03f, 9.68605876e-02f, -8.01156163e-02f,
  -8.04006308e-02f, -6.55876324e-02f, 5.49819842e-02f, -1.06514178e-01f, -1.94517031e-01f, -9.42533687e-02f, -1.24547131e-01f, -1.47106007e-01f, -1.06680527e-01f, -1.90824792e-02f,
  -1.42343849e-01f, -1.26763418e-01f, -2.69142948e-02f, 4.88203950e-02f, -7.16210380e-02f, -4.27513979e-02f, 5.67332171e-02f, 9.77079496e-02f, -3.15760337e-02f, 1.46175623e-01f,
  -7.19887316e-02f, 2.47638915e-02f, -7.68156275e-02f, -7.52657279e-02f, -9.05298889e-02f, 4.14689779e-02f, -8.16904753e-02f, 3.84511091e-02f, 1.68365892e-02f, 1.32277757e-01f,
  6.87940791e-03f, 3.87727469e-02f, 4.08604071e-02f, 6.12522662e-02f, -7.79362619e-02f, -4.42052037e-02f, -6.47233874e-02f, -7.01222792e-02f, -1.21853940e-01f, -4.47231941e-02f,
  2.41638198e-02f, -1.17655592e-02f, 1.79665640e-01f, 1.01238959e-01f, -2.76461653e-02f, -6.39592037e-02f, -1.30361125e-01f, -3.26873511e-02f, -5.03184237e-02f, -6.19020909e-02f,
  3.26193392e-01f, -2.80829012e-01f, 3.76606244e-03f, -1.34705558e-01f, 1.25955433e-01f, 5.62732248e-03f, 1.21321417e-02f, -3.91825214e-02f, -1.37851564e-02f, -3.14057656e-02f,
  -6.72220513e-02f, 8.41345042e-02f, 9.20653436e-03f, -9.62820798e-02f, -1.70583561e-01f, -5.45618199e-02f, -6.68532625e-02f, -4.37211432e-02f, -1.20361261e-01f, 1.55182853e-02f,
  -3.75857204e-02f, -2.36519173e-01f, 3.24245989e-02f, 1.50658801e-01f, 4.92207482e-02f, 5.70631772e-02f, 2.28136867e-01f, 1.35390893e-01f, 2.23717522e-02f, 1.04767092e-01f,
  3.77665639e-01f, 8.82723704e-02f, 1.96621791e-01f, 4.71334308e-02f, -1.29010201e-01f, 5.96143156e-02f, -5.24634048e-02f, -2.16249432e-02f, 7.00160861e-02f, -3.08545935e-03f,
  5.26257865e-02f, 3.18215676e-02f, 8.29658583e-02f, 1.16903424e-01f, 3.52750905e-02f, -6.79029450e-02f, -4.03206423e-03f, 6.86226487e-02f, 4.27205712e-02f, 2.59032305e-02f,
  -1.23834787e-02f, -5.07282056e-02f, 7.76835112e-03f, -4.44506519e-02f, -1.74854808e-02f, 1.67006105e-02f, -1.14714831e-01f, -9.42237116e-03f, -9.36190784e-02f, 3.99274752e-02f,
  4.25141081e-02f, 2.42474735e-01f, 1.27615184e-01f, 1.83648877e-02f, -1.75998565e-02f, 5.52186221e-02f, -3.56505066e-02f, -2.73372643e-02f, 9.28736106e-03f, -5.70443496e-02f,
  7.33928680e-02f, -2.86032427e-02f, -7.37390742e-02f, -3.78680415e-02f, -6.20975383e-02f, -2.79670395e-02f, 4.79167663e-02f, 6.24524280e-02f, 9.44811404e-02f, -7.78477192e-02f,
  -8.68096831e-04f, -5.57135418e-02f, -6.81996271e-02f, -1.55285178e-02f, 1.04670245e-02f, -7.36719044e-03f, 3.22770281e-03f, -3.59600037e-02f, -1.90843977e-02f, 4.71943952e-02f,
  -1.81204274e-01f, -1.15434006e-01f, -4.59961705e-02f, 3.67353633e-02f, -4.56744246e-02f, -3.12278122e-02f, -2.00968888e-02f, 4.38517146e-02f, -3.09700277e-02f, -5.21123670e-02f,
  4.73392680e-02f, 1.43662274e-01f, 1.20757498e-01f, 7.41415098e-02f, -7.12598637e-02f, -2.10042410e-02f, -1.01716421e-03f, 3.22172977e-02f, -7.77196065e-02f, 1.01852985e-02f,
  -5.26282080e-02f, 2.00951248e-02f, -9.06277299e-02f, -9.88314450e-02f, -7.11955577e-02f, -2.15828810e-02f, 2.46985815e-02f, -1.20666705e-01f, -1.26950935e-01f, -1.44110367e-01f,
  -6.96876645e-02f, 2.51852751e-01f, 1.51045173e-01f, 2.26808414e-01f, 6.31054416e-02f, -6.67173266e-02f, 1.80520922e-01f, 6.82512745e-02f, 7.21953288e-02f, 1.18348464e-01f,
  1.01311669e-01f, 1.33835629e-01f, -7.68353045e-02f, -1.11274067e-02f, -4.20363359e-02f, 4.98905592e-02f, 2.30123345e-02f, 1.10510126e-01f, 9.43861753e-02f, 1.09749578e-01f,
  -1.14655152e-01f, 1.64149046e-01f, 6.70866147e-02f, 1.07079491e-01f, 9.22767743e-02f, 2.77949907e-02f, 9.09082741e-02f, 4.08323780e-02f, 9.08965468e-02f, -1.06958330e-01f,
  -1.52495041e-01f, -2.96888113e-01f, 2.94585854e-01f, 1.15622163e-01f, -1.89554933e-02f, -2.84832418e-01f, -6.10996783e-01f, -4.69045311e-01f, -1.71977356e-01f, -6.41770149e-03f,
  -4.26926315e-02f, 2.49019600e-02f, 7.40267336e-02f, 3.41930352e-02f, -1.92236751e-01f, -1.92789540e-01f, -1.16914287e-02f, 1.24050919e-02f, -1.51124999e-01f, -5.92402443e-02f,
  1.31071657e-01f, 1.49166182e-01f, 7.56083131e-02f, 1.23341441e-01f, 2.89018452e-01f, 1.31476671e-01f, 2.35355318e-01f, 2.67566592e-01f, 2.12348416e-01f, 3.76659721e-01f,
  4.38249141e-01f, -1.11932471e-01f, 7.28622600e-02f, 5.28364955e-03f, 1.66199192e-01f, -7.75414407e-02f, 8.82559121e-02f, 5.58615103e-02f, 5.52482642e-02f, 1.01257581e-02f,
  1.57532573e-01f, 1.00441150e-01f, 2.54050307e-02f, 1.63998529e-01f, -3.97398248e-02f, 4.07596352e-03f, -7.47959539e-02f, -1.00360908e-01f, -1.04291752e-01f, 4.63922359e-02f,
  6.34432137e-02f, 7.61632398e-02f, -7.05397129e-02f, -2.44288638e-01f, -2.05256969e-01f, 1.42595634e-01f, 7.92739987e-02f, 8.53266418e-02f, 1.01981396e-02f, 6.51394874e-02f,
  -4.28836979e-02f, 3.10389698e-02f, 1.06590623e-02f, -8.43977556e-03f, -1.69359595e-01f, -7.32810795e-02f, 3.96185182e-02f, 5.81224039e-02f, -1.46004874e-02f, -5.42707704e-02f,
  6.00553229e-02f, -1.11439396e-02f, 4.05102894e-02f, -3.64180580e-02f, 1.38234764e-01f, 2.49591976e-01f, 5.67344949e-02f, 1.01716451e-01f, 1.69177562e-01f, 8.88890773e-02f,
  -6.00122474e-03f, 7.00877160e-02f, 6.98938519e-02f, -1.20113961e-01f, -2.58853901e-02f, 5.91841005e-02f, 6.11121766e-02f, -7.05483407e-02f, 6.91721588e-02f, 1.12520613e-01f,
  4.25769128e-02f, 7.76549578e-02f, 1.69894412e-01f, 6.64088828e-03f, 8.20299089e-02f, 1.11518539e-01f, 5.91956414e-02f, 9.95759740e-02f, 1.18495226e-01f, 1.78464539e-02f,
  -6.88311458e-02f, -1.52398152e-02f, 3.67739089e-02f, 7.63779208e-02f, -5.66883758e-03f, 4.60712425e-03f, 3.52833122e-02f, -1.52909644e-02f, -2.35415474e-02f, 4.49517146e-02f,
  -1.09175071e-01f, -1.36601150e-01f, -1.08936429e-01f, -1.31346315e-01f, 5.47413193e-02f, -6.99308887e-02f, 7.11873993e-02f, -7.10984692e-02f, -1.51416108e-01f, -2.32805341e-01f,
  2.53208935e-01f, -4.12168294e-01f, -5.46900928e-02f, -1.56904176e-01f, 1.06883876e-01f, 1.70361459e-01f, 2.45066240e-01f, 1.07257552e-01f, 3.17012146e-02f, -1.87801849e-02f,
  -1.36580840e-01f, -2.23914519e-01f, -1.55546010e-01f, -5.58874570e-02f, 1.34687066e-01f, 1.29081239e-03f, -3.55723780e-03f, 1.07233994e-01f, 3.36903036e-01f, 1.08732291e-01f,
  6.44708797e-02f, 6.18928969e-02f, 3.33412625e-02f, -6.70920163e-02f, -1.24678001e-01f, 6.53974786e-02f, -2.27330700e-01f, -9.82025340e-02f, -1.76230669e-01f, -2.68463939e-01f,
  -5.83445393e-02f, -4.25610036e-01f, 2.17546806e-01f, -2.60329358e-02f, -1.69326007e-01f, 1.24850301e-02f, 1.39309406e-01f, 2.61214208e-02f, -2.92899814e-02f, 4.96735461e-02f,
  -4.40264456e-02f, -8.61965790e-02f, -1.73325807e-01f, -7.99620301e-02f, -8.37094430e-03f, 5.06910607e-02f, -9.25284699e-02f, -1.91907108e-01f, -1.59135461e-01f, -8.99540633e-02f,
  -2.14809760e-01f, -5.99889159e-02f, -4.73141447e-02f, -9.26022157e-02f, -1.59426928e-01f, -3.60956080e-02f, -2.08683327e-01f, -1.62239358e-01f, -1.12451777e-01f, -1.96292643e-02f,
  1.05040848e-01f, 4.11741138e-02f, -1.31219029e-01f, -5.01165204e-02f, -2.26392318e-02f, -1.01304285e-01f, 1.95363289e-04f, -1.26076296e-01f, -7.95874596e-02f, -2.29760762e-02f,
  -1.28958777e-01f, -1.06643595e-01f, -7.38047957e-02f, 7.86725581e-02f, -8.95124972e-02f, 3.68345492e-02f, -5.19083254e-02f, -1.89958997e-02f, -3.80650498e-02f, 1.68166477e-02f,
  -1.72022562e-02f, 4.03309353e-02f, 4.84230891e-02f, -9.36264694e-02f, 2.44771317e-02f, 2.27918290e-02f, 1.11878179e-01f, -8.29007884e-04f, 1.80643855e-03f, 1.28585175e-01f,
  -5.15861921e-02f, 1.39164701e-01f, 1.22829556e-01f, -5.53979240e-02f, -2.45212838e-02f, 5.43269888e-02f, 2.21597496e-02f, 5.24252579e-02f, -5.28689735e-02f, 1.27752408e-01f,
  -1.54398665e-01f, -3.37515809e-02f, -8.63642246e-02f, -8.38586763e-02f, 1.41195670e-01f, 3.91909704e-02f, 8.33985358e-02f, -1.06535386e-02f, -5.78256138e-02f, 8.71019363e-02f,
  -3.41622997e-03f, 1.89523041e-01f, 1.05913036e-01f, 1.00761853e-01f, 1.08790072e-02f, 1.40675396e-01f, 1.23139195e-01f, 9.40596908e-02f, 1.98717996e-01f, 2.60963798e-01f,
  -4.51708078e-01f, -1.19150519e-01f, -1.13432139e-01f, -2.33085275e-01f, 1.00286230e-01f, -9.62110760e-04f, -1.43705666e-01f, -1.84290390e-02f, -1.59147590e-01f, -3.25255960e-01f,
  -1.42057911e-01f, 9.52161998e-02f, -1.44502103e-01f, -1.67483255e-01f, -3.03949326e-01f, -4.63882029e-01f, -3.94326806e-01f, -1.40933752e-01f, 1.25183582e-01f, 1.16172075e-01f,
  6.40814677e-02f, -1.68245852e-01f, -1.44985437e-01f, -4.88541182e-03f, -1.12017393e-01f, 3.21102031e-02f, -4.97926101e-02f, -8.40785131e-02f, -9.50154476e-03f, -1.40637785e-01f,
  -9.66278985e-02f, 1.13862567e-01f, 1.26187325e-01f, -2.58443481e-03f, 8.03904310e-02f, 5.63323162e-02f, 4.59294841e-02f, 7.62189031e-02f, -3.27432677e-02f, -1.41880944e-01f,
  -5.83189838e-02f, 5.98153137e-02f, 8.12737942e-02f, 7.92772025e-02f, -6.83150217e-02f, -4.73674908e-02f, -9.89700481e-02f, -1.04677446e-01f, -2.66449228e-02f, 1.56514600e-01f,
  -2.80550891e-03f, -3.95608507e-02f, 9.97531693e-03f, 9.98673290e-02f, 1.19431369e-01f, 6.48008138e-02f, 7.07815588e-02f, 2.17067391e-01f, 8.62386376e-02f, 2.31031775e-02f,
  -6.66328222e-02f, 5.10763936e-02f, 3.35621424e-02f, -5.35113662e-02f, -1.00298002e-01f, 6.18252391e-03f, -1.06073469e-01f, -5.64262494e-02f, 1.44198790e-01f, -1.04134887e-01f,
  -1.00601129e-01f, -1.36968549e-02f, 3.27268243e-02f, -9.79563296e-02f, -4.46665622e-02f, -2.41625980e-02f, -1.11637302e-01f, -7.76371881e-02f, -1.17642343e-01f, -6.23273700e-02f,
  -5.18950038e-02f, 1.58528447e-01f, -1.19164027e-01f, -1.79869141e-02f, 5.67887202e-02f, -1.80627629e-02f, -3.38407047e-02f, 1.26508772e-01f, -7.42920041e-02f, 2.69067083e-02f,
  -2.19091937e-01f, 5.15534692e-02f, -3.44998240e-01f, 1.14334807e-01f, -1.12144068e-01f, 1.39987199e-02f, -3.28934193e-02f, 4.19501290e-02f, 2.41010766e-02f, -2.79015675e-02f,
  1.12572283e-01f, -1.04412213e-01f, -6.67116866e-02f, -4.69466031e-04f, -1.47090573e-02f, -3.16760093e-02f, -1.71762258e-01f, 5.35739167e-03f, 7.45741129e-02f, 6.55719936e-02f,
  -7.05182031e-02f, -1.89845502e-01f, -1.81104437e-01f, -1.10712402e-01f, 6.28363788e-02f, -7.20495954e-02f, -8.50718766e-02f, 1.37490734e-01f, -7.87964687e-02f, -2.35495329e-01f,
  -5.98649383e-01f, 1.28260791e-01f, -3.37999880e-01f, -3.46349150e-01f, -2.83243597e-01f, -1.60913214e-01f, 2.25804806e-01f, -2.01993715e-02f, -3.54749747e-02f, 1.45193085e-01f,
  1.46738470e-01f, 9.22533646e-02f, 2.83442825e-01f, 2.14090541e-01f, 2.71375835e-01f, 9.99749824e-02f, -1.54714838e-01f, -2.81273872e-01f, 1.87977105e-02f, 1.75985601e-02f,
  2.68172156e-02f, -1.51261790e-02f, -2.22587734e-01f, 5.42030623e-03f, -7.64384717e-02f, 6.01759106e-02f, 5.62083384e-04f, -5.94098754e-02f, 7.33790025e-02f, -6.42963871e-02f,
  1.12773657e-01f, -3.24618697e-01f, 8.51811748e-03f, -1.10566452e-01f, -1.50332674e-01f, -6.03125840e-02f, -3.92986536e-02f, -9.51789990e-02f, -4.93274853e-02f, 1.34032872e-02f,
  -2.20715806e-01f, -4.69418727e-02f, -1.72356591e-01f, 3.95114049e-02f, -7.25099742e-02f, -8.46091211e-02f, -3.97728644e-02f, -4.33511697e-02f, 1.80045068e-02f, 2.84095760e-03f,
  5.02274325e-03f, -2.25498661e-01f, -9.23211649e-02f, -4.69311737e-02f, -9.20881033e-02f, -8.61740261e-02f, 9.97561887e-02f, -1.21178858e-01f, -9.53581408e-02f, 1.37258440e-01f,
  6.99844435e-02f, 1.27750605e-01f, 1.48757333e-02f, -6.23286068e-02f, 6.19295612e-02f, 6.10016659e-03f, -2.56919134e-02f, 1.09435864e-01f, 4.38407734e-02f, 3.23430859e-02f,
  1.21756345e-02f, 8.79659783e-03f, 9.85273793e-02f, 4.80446070e-02f, -2.44030114e-02f, -2.42013782e-02f, -1.07277885e-01f, 1.96442246e-01f, -2.53731105e-02f, -3.99008803e-02f,
  -7.53966346e-02f, 4.04158665e-04f, -1.20337225e-01f, 3.44011560e-02f, -9.72310305e-02f, -7.08433315e-02f, -5.12414426e-03f, -8.86674970e-02f, -8.91138688e-02f, -1.93946771e-02f,
  3.10381651e-01f, -5.81999905e-02f, 8.22830200e-03f, 1.29950531e-02f, -1.05557293e-01f, -7.82946572e-02f, 4.94687892e-02f, -6.17139153e-02f, -9.00517404e-02f, -3.96572575e-02f,
  2.06946339e-02f, -1.28108459e-02f, 1.20062171e-03f, 4.99895134e-04f, 8.16258192e-02f, -3.70165519e-02f, 2.76646595e-02f, -5.37257940e-02f, 1.09373786e-01f, 4.07710373e-02f,
  2.85856668e-02f, 7.76730403e-02f, 7.52303675e-02f, 1.67798981e-01f, 4.01201099e-02f, 1.02480620e-01f, 1.33386999e-01f, 1.94552764e-02f, 4.85603921e-02f, 3.06502879e-01f,
  -4.70678359e-01f, -1.62365392e-01f, -1.83539104e-03f, -3.07708532e-01f, 5.52576631e-02f, 8.86523947e-02f, 1.33117393e-01f, 6.52950108e-02f, 7.71189258e-02f, -7.84308314e-02f,
  -1.03651416e-02f, 1.08405106e-01f, -1.50246015e-02f, -7.67972171e-02f, 2.07405947e-02f, -2.00369164e-01f, -1.19283572e-01f, -1.67479336e-01f, 9.81741995e-02f, 1.39222547e-01f,
  2.28946969e-01f, -5.32053877e-03f, -1.04604311e-01f, -5.56275696e-02f, -1.92685351e-01f, -1.22410737e-01f, -6.19829819e-02f, -6.34848773e-02f, 9.01724771e-02f, -2.65406042e-01f,
  -1.92927852e-01f, -3.40520367e-02f, 9.11663771e-02f, 4.37149554e-02f, 1.66223615e-01f, 8.16181824e-02f, 2.15133011e-01f, 9.52769667e-02f, 1.23313650e-01f, 5.94443940e-02f,
  8.87867622e-03f, 1.09908506e-01f, 1.19644940e-01f, 5.97350374e-02f, 3.78218889e-02f, -8.27439800e-02f, -4.72939014e-02f, 1.04035005e-01f, -1.99562013e-02f, 1.58815190e-01f,
  1.21271983e-01f, -1.45117128e-02f, -1.39859185e-01f, 2.94283442e-02f, 1.70308694e-01f, -2.40733176e-02f, 1.19643379e-02f, 9.18097347e-02f, 5.57971746e-02f, -6.54038191e-02f,
  5.36369644e-02f, -1.03227571e-01f, -8.55742693e-02f, -6.51176721e-02f, -9.54694375e-02f, -5.28996773e-02f, -1.20013230e-01f, -6.90088496e-02f, -6.52554035e-02f, -9.89458337e-02f,
  -3.56690139e-02f, 3.38325799e-02f, 4.89912480e-02f, -4.77204993e-02f, -2.34402139e-02f, -1.35797217e-01f, -2.38406863e-02f, -1.08143337e-01f, -4.65360358e-02f, -2.20581284e-03f,
  -5.92991449e-02f, -3.22251059e-02f, -1.17265984e-01f, -8.01425800e-02f, -2.13053413e-02f, -1.36820510e-01f, 4.93665971e-02f, 7.59380832e-02f, 1.12948582e-01f, 9.96527150e-02f,
  -3.76079500e-01f, 1.70622349e-01f, -1.53989255e-01f, -9.16853249e-02f, -3.97332571e-02f, -7.35897524e-03f, -8.27362016e-02f, -3.24077569e-02f, -1.50219232e-01f, -8.03858042e-02f,
  -3.69066256e-03f, -1.85377032e-01f, -9.05125663e-02f, -7.46807680e-02f, 1.24484688e-01f, -8.44753534e-02f, -3.15289497e-02f, -2.47686267e-01f, -8.72029439e-02f, 1.46421064e-02f,
  -1.29467025e-01f, -5.60510643e-02f, -2.26391315e-01f, -9.76199731e-02f, -2.51727104e-02f, -8.47380757e-02f, -1.44118443e-01f, -1.26628608e-01f, -1.15243137e-01f, -3.44793707e-01f,
  -4.49832380e-01f, -3.35488796e-01f, 3.59889448e-01f, -1.17529176e-01f, 2.15247124e-01f, 1.60698459e-01f, 3.18518989e-02f, -1.50813133e-01f, -2.28313759e-01f, -1.80457756e-01f,
  -4.81913358e-01f, -3.91143441e-01f, -2.12849602e-01f, -8.74743387e-02f, 2.64505260e-02f, 2.87932783e-01f, 3.86913091e-01f, 3.16961199e-01f, 1.71449125e-01f, -1.12487320e-02f,
  -4.85468693e-02f, 2.94111818e-02f, -2.63314322e-02f, -2.30833776e-02f, -1.40743256e-01f, -1.13366686e-01f, 2.08446667e-01f, 5.99366762e-02f, 5.01227081e-02f, 1.05260655e-01f,
  -5.96450865e-02f, -3.17200691e-01f, 8.53809640e-02f, -1.02339759e-01f, -3.95333208e-02f, -1.69184119e-01f, -1.97102085e-01f, -5.69019988e-02f, -7.41929933e-02f, -8.88811499e-02f,
  -1.21324912e-01f, -2.02127788e-02f, -7.72001147e-02f, 8.09060503e-03f, -3.21622863e-02f, -9.14077833e-02f, 1.39176473e-02f, 6.84253722e-02f, 1.82607695e-02f, -1.07159890e-01f,
  1.09476157e-01f, 2.08448917e-02f, 7.48662427e-02f, 9.63516235e-02f, 8.38917419e-02f, 1.02898650e-01f, -1.78323854e-02f, -3.84943858e-02f, 8.14192183e-03f, -2.32335791e-01f,
  7.82603845e-02f, -1.68075591e-01f, -2.61659757e-03f, -7.20076039e-02f, 1.83238480e-02f, 3.12990658e-02f, 1.28267273e-01f, -1.05802298e-01f, 9.84881260e-03f, -8.74072462e-02f,
  -2.07840372e-02f, -4.87430245e-02f, -5.01850732e-02f, -7.77538642e-02f, -6.23375960e-02f, -1.51344970e-01f, -7.73378164e-02f, 5.75561309e-04f, 5.46385609e-02f, -4.13503964e-03f,
  -1.12121642e-01f, 7.32294843e-02f, 8.83429572e-02f, -3.21530290e-02f, -7.69800926e-03f, -4.39791605e-02f, -8.11232254e-02f, -1.27443165e-01f, -1.99817065e-02f, -9.54064354e-02f,
  -3.16146165e-01f, 3.30528527e-01f, -1.88085139e-01f, -3.38520743e-02f, 7.04622865e-02f, 5.02200276e-02f, -1.11625515e-01f, 9.43696946e-02f, 4.14588563e-02f, 2.13351566e-02f,
  5.63283563e-02f, -4.47264649e-02f, -1.03092074e-01f, -4.10455614e-02f, -6.65850490e-02f, 8.12701732e-02f, -1.26595259e-01f, 1.21436752e-02f, 1.06951527e-01f, -1.97876394e-02f,
  2.70182677e-02f, 3.26246507e-02f, -7.53362030e-02f, -5.00376262e-02f, 5.00733666e-02f, 6.69680387e-02f, -1.96611434e-02f, 2.09133811e-02f, 1.93414629e-01f, -7.72237778e-02f,
  -3.72292191e-01f, -2.46394917e-01f, -3.72335911e-01f, -2.70927846e-01f, -5.41380383e-02f, 2.04560552e-02f, 1.22483432e-01f, 2.58226782e-01f, 1.35311037e-02f, -2.86413312e-01f,
  -1.21900976e-01f, -2.26410359e-01f, -2.38834277e-01f, -4.56143841e-02f, -6.02862239e-02f, -3.25181901e-01f, -3.79995644e-01f, -1.18621834e-01f, 1.96030159e-02f, 2.52365887e-01f,
  8.79783928e-02f, -1.05639257e-01f, 5.77490637e-03f, 4.44154851e-02f, -2.38175139e-01f, -7.81676248e-02f, -1.82149991e-01f, -2.57374048e-02f, -1.16511628e-01f, -2.64454454e-01f,
  -3.60114962e-01f, 8.58977139e-02f, 1.52183890e-01f, 4.68739532e-02f, -1.53120503e-01f, -4.16900665e-02f, -2.20286357e-03f, -1.02669850e-01f, 1.24778515e-02f, -3.65440059e-03f,
  -6.82008564e-02f, 6.54734597e-02f, -8.73875543e-02f, -3.76897417e-02f, -2.00199354e-02f, -5.39876483e-02f, 5.18325455e-02f, 5.33838458e-02f, -1.02328710e-01f, 1.19062386e-01f,
  6.99412525e-02f, -3.21874931e-03f, 2.00683940e-02f, 2.66570121e-01f, 1.57379195e-01f, 2.33576931e-02f, 1.39391094e-01f, 2.25865573e-01f, 1.67397738e-01f, 3.88072096e-02f,
  1.13207050e-01f, -1.36955470e-01f, -8.79265741e-03f, -2.38728384e-03f, 6.46479847e-03f, -1.75731201e-02f, 3.43279578e-02f, 1.90104879e-02f, 4.00705598e-02f, -8.47407728e-02f,
  -5.58283087e-03f, 5.40913194e-02f, -2.98635401e-02f, -1.12815745e-01f, -3.35574616e-03f, 5.30613437e-02f, 6.67472929e-02f, -1.61236301e-02f, 6.50302158e-04f, 9.91842821e-02f,
  4.28953208e-02f, 1.38474613e-01f, -1.37810901e-01f, 6.51620850e-02f, 8.04202408e-02f, -1.04328175e-03f, 4.24055718e-02f, 3.07191927e-02f, -9.47108790e-02f, -5.86987771e-02f,
  -3.56435150e-01f, 1.33716390e-01f, -3.22308630e-01f, 3.43380645e-02f, -4.02684510e-02f, -2.34316569e-02f, -1.85059398e-01f, 6.93926180e-04f, -1.48164392e-01f, 6.15661554e-02f,
  1.47725105e-01f, -3.16252373e-02f, -1.89542159e-01f, 1.73386186e-02f, 2.42474750e-02f, 1.11165866e-01f, 1.24453120e-01f, -1.28636748e-01f, 4.24893536e-02f, 6.89893365e-02f,
  9.20410231e-02f, -3.38744074e-02f, 4.67690714e-02f, 7.99622387e-02f, 8.31577033e-02f, -8.86586234e-02f, -5.95297702e-02f, -5.05271628e-02f, -4.71461080e-02f, -4.10092920e-02f,
  2.00825199e-01f, 2.90088564e-01f, 1.64765999e-01f, -1.94605868e-02f, -3.04427236e-01f, -2.53800958e-01f, -2.67341863e-02f, -7.17104673e-02f, -6.97635859e-03f, 1.37721658e-01f,
  -2.37411559e-02f, -4.74931717e-01f, -1.25935391e-01f, -1.60135388e-01f, -7.37079158e-02f, 2.43663892e-01f, 1.07669882e-01f, -1.21914588e-01f, -3.61573100e-01f, -2.90156215e-01f,
  -1.82513028e-01f, -1.09166771e-01f, -7.24268928e-02f, -9.95236412e-02f, 1.53171763e-01f, -1.45240754e-01f, 2.43120372e-01f, -7.38595128e-02f, -5.91508150e-02f, 2.13643968e-01f,
  -2.38405634e-02f, 5.61076999e-02f, -1.18244566e-01f, -1.87433496e-01f, -1.18328393e-01f, -5.49400151e-02f, 1.08958809e-02f, 1.17859513e-01f, -1.25304833e-01f, 5.88764176e-02f,
  -2.01482207e-01f, -1.29311904e-03f, -1.65689245e-01f, -1.48814246e-01f, -9.47215930e-02f, -8.52205083e-02f, 6.49298280e-02f, 8.55997130e-02f, 8.81730020e-02f, -3.86118330e-02f,
  -1.21669270e-01f, -1.33757040e-01f, -4.13509831e-03f, 1.16352893e-01f, 1.91310525e-01f, -2.12622821e-01f, -5.30468598e-02f, -6.08179197e-02f, -9.19290036e-02f, 3.23628187e-01f,
  7.71574527e-02f, 3.60841602e-02f, -5.10908291e-02f, 7.86906555e-02f, 7.22049847e-02f, -3.47047262e-02f, 5.88584598e-03f, -3.51548232e-02f, 6.26917034e-02f, -4.61666286e-02f,
  2.55352668e-02f, 4.41043600e-02f, -1.37073621e-02f, 1.31021053e-01f, 1.03994310e-01f, -1.53960008e-02f, -4.49230857e-02f, 8.05330053e-02f, 6.85767904e-02f, 6.98123500e-02f,
  -2.20832620e-02f, 2.01372001e-02f, -6.58537596e-02f, -3.73704620e-02f, 2.32854709e-02f, 7.40446374e-02f, -3.93808857e-02f, -2.60137860e-02f, 6.11032769e-02f, -9.22691729e-03f,
  -1.05692476e-01f, -2.06217170e-01f, 2.42989957e-01f, -2.41045803e-02f, -9.60341915e-02f, -8.39446485e-02f, -6.11499790e-03f, -7.42290244e-02f, -3.13613750e-02f, -6.05461560e-02f,
  -1.95537791e-01f, -3.46753150e-02f, 6.53854907e-02f, -5.56297712e-02f, -7.29335770e-02f, -1.27992943e-01f, -2.89780524e-04f, -1.34060577e-01f, -1.51665717e-01f, -5.29447980e-02f,
  1.56611636e-01f, -7.30628222e-02f, -8.35315362e-02f, -2.56276689e-02f, 4.31211554e-02f, -1.03373736e-01f, -1.49124041e-01f, -1.70816019e-01f, -5.93948439e-02f, 3.07103217e-01f,
  -2.22090632e-01f, -4.08426255e-01f, -2.88411915e-01f, -4.26448435e-01f, -3.44753146e-01f, -1.76469341e-01f, -1.28786311e-01f, -1.36999071e-01f, -3.36246222e-01f, -3.52932513e-01f,
  -3.37511972e-02f, 1.39893055e-01f, 1.65489152e-01f, 1.29101604e-01f, 2.72794992e-01f, -1.30181372e-01f, -2.45535910e-01f, 1.37954578e-01f, 4.32906657e-01f, 1.14406645e-01f,
  -3.60673703e-02f, -3.08486633e-02f, 1.48013774e-02f, -3.37827601e-04f, -1.80378512e-01f, 2.87491027e-02f, -2.88382709e-01f, -1.88241556e-01f, -1.81319743e-01f, -3.49044144e-01f,
  3.04856151e-01f, -1.32938266e-01f, -1.09788395e-01f, -6.28273189e-02f, -1.21536426e-01f, -1.21013960e-02f, 4.19184156e-02f, -1.09430686e-01f, -1.19395293e-01f, -1.35850251e-01f,
  -8.60590786e-02f, -5.99730164e-02f, 1.72092408e-01f, 6.90641552e-02f, -2.95361434e-03f, 1.20795637e-01f, -1.25607416e-01f, -3.64857577e-02f, -1.09856382e-01f, -1.26742776e-02f,
  -2.63548810e-02f, -1.97585709e-02f, 1.47820627e-02f, -8.27742275e-03f, -2.77980641e-02f, 5.05602211e-02f, 1.35846222e-02f, -1.10673420e-01f, 9.72689092e-02f, -5.44457287e-02f,
  7.39176571e-02f, -3.86514738e-02f, -8.64767432e-02f, 9.94315371e-02f, 9.16711837e-02f, 1.52383121e-02f, 2.23721862e-02f, 2.92330049e-03f, -3.78256403e-02f, -3.69987860e-02f,
  1.41079230e-02f, -3.64313871e-02f, 6.75414205e-02f, -6.30235672e-02f, -2.22623348e-03f, -8.44021663e-02f, 2.62709428e-02f, -4.36692797e-02f, 5.59986942e-02f, -4.93120588e-02f,
  -8.70486423e-02f, -1.36116922e-01f, -6.62412196e-02f, 6.62736781e-03f, -1.94718868e-01f, -6.21692725e-02f, -2.03281511e-02f, 7.15116635e-02f, 7.91040435e-02f, -7.68602863e-02f,
  1.40417203e-01f, 1.84261054e-02f, 2.93502752e-02f, 5.76371141e-02f, -4.81952503e-02f, -8.70717689e-02f, -1.78684264e-01f, -7.41431909e-03f, -1.66416727e-02f, -1.61378775e-02f,
  -4.44510691e-02f, 1.79740459e-01f, 4.74772826e-02f, -3.36381570e-02f, -3.15931514e-02f, -1.09236054e-02f, -9.06389486e-03f, -4.20399010e-02f, 9.11016017e-03f, -1.80416983e-02f,
  -6.36091754e-02f, 5.88692948e-02f, 1.64536387e-01f, 1.19991653e-01f, 7.64811933e-02f, 2.47786149e-01f, 2.00981215e-01f, -1.39636686e-02f, 2.51630545e-01f, 1.16275968e-02f,
  6.36744320e-01f, -3.21840346e-01f, 2.03374416e-01f, 1.69814572e-01f, 1.37294412e-01f, 2.14803293e-01f, 1.83283985e-01f, 1.64000347e-01f, 1.27709329e-01f, 3.90115529e-02f,
  -8.07732940e-02f, -3.67276706e-02f, -8.19735676e-02f, -8.60027894e-02f, -1.13861740e-01f, -1.44785225e-01f, -1.06598340e-01f, 1.23731785e-01f, 3.35730344e-01f, 1.37473851e-01f,
  -1.18652962e-01f, -1.63248498e-02f, 3.06666400e-02f, 1.22762863e-02f, -2.02849463e-01f, -6.73819557e-02f, -3.73278670e-02f, -6.23705238e-02f, -2.00145409e-01f, -2.95624554e-01f,
  -1.11572906e-01f, 8.02210048e-02f, 1.25618517e-01f, -1.72484308e-01f, -2.86395345e-02f, -1.08263055e-02f, 2.50196699e-02f, -3.93480156e-03f, -7.77236894e-02f, -4.08489071e-02f,
  -4.34055813e-02f, -3.52898762e-02f, 2.84286477e-02f, 9.21081901e-02f, 6.42145127e-02f, 8.20331573e-02f, -1.14721023e-01f, 3.63244116e-02f, -3.60543132e-02f, -2.78113279e-02f,
  -7.02923760e-02f, 1.17592469e-01f, 1.13511294e-01f, 8.43425244e-02f, 1.87981986e-02f, 1.20543867e-01f, -6.97201565e-02f, -6.10763505e-02f, 9.13116857e-02f, -2.54349709e-02f,
  -1.09868944e-02f, -4.52470593e-02f, 6.95025250e-02f, 9.75678340e-02f, 7.16638118e-02f, 6.07613400e-02f, -2.75495462e-02f, -3.06952298e-02f, 1.13140553e-01f, 1.31502533e-02f,
  -4.24679369e-02f, 1.38263598e-01f, 6.88333660e-02f, 1.21993832e-02f, -9.16742068e-03f, 4.92547192e-02f, -1.30641656e-02f, 9.04240739e-03f, -4.09630798e-02f, 3.24624940e-03f,
  1.09444179e-01f, 2.47049388e-02f, 6.50109798e-02f, -7.18280599e-02f, -5.15135899e-02f, 5.45071587e-02f, 3.17800455e-02f, -9.83025134e-02f, 5.67022376e-02f, -7.33933672e-02f,
  -2.48209909e-01f, 8.28284472e-02f, -1.09947743e-02f, -3.31743062e-02f, 2.45661438e-02f, -4.18532379e-02f, -5.04945479e-02f, -2.07458392e-01f, -1.44752875e-01f, 1.51461037e-02f,
  6.55442923e-02f, 1.03949264e-01f, 6.31831959e-02f, -2.36868933e-02f, 2.10697159e-01f, 1.47549778e-01f, -8.52226764e-02f, -2.25636531e-02f, -1.43218234e-01f, -5.28595895e-02f,
  -5.57265729e-02f, 1.69714972e-01f, 9.37767103e-02f, 1.23750970e-01f, 6.60317689e-02f, 1.39159665e-01f, 1.23218574e-01f, 9.99414846e-02f, 1.54249921e-01f, 1.37550995e-01f,
  5.15615344e-01f, 3.34781736e-01f, 1.67222470e-01f, 7.78506473e-02f, 3.98458540e-02f, 1.95374921e-01f, 3.52854639e-01f, 1.21159501e-01f, -4.57172319e-02f, 1.11259885e-01f,
  2.43459210e-01f, 4.48052734e-02f, -5.85906319e-02f, -7.95259401e-02f, -2.42084283e-02f, 6.43750727e-02f, -8.11133161e-02f, -5.12983650e-02f, 5.12815975e-02f, 4.34341729e-02f,
  -1.55869365e-01f, -6.94418699e-02f, 6.96812123e-02f, -6.83596134e-02f, -1.23710796e-01f, -2.19332770e-01f, 4.62302864e-02f, -6.05138689e-02f, -1.05671085e-01f, -2.66728789e-01f,
  1.02298865e-02f, 2.68012136e-01f, -9.25363228e-02f, 5.46379983e-02f, 9.46926102e-02f, 4.17231135e-02f, 9.19161588e-02f, 7.98776075e-02f, 1.57281369e-01f, 1.38701558e-01f,
  5.45306690e-02f, 3.80900949e-02f, 9.45603624e-02f, 7.08867386e-02f, 3.87405194e-02f, 1.38955861e-01f, 1.01060666e-01f, 1.47025481e-01f, -2.10619755e-02f, 9.47941989e-02f,
  -6.72652870e-02f, 1.04397446e-01f, 3.00408036e-01f, 1.54792935e-01f, 8.80570486e-02f, 5.58670498e-02f, 6.60479516e-02f, 1.77690480e-02f, 3.57787162e-02f, 1.68105483e-01f,
  -5.25979558e-03f, 1.77986115e-01f, 4.90496270e-02f, 1.29110709e-01f, -4.61742133e-02f, 1.30381763e-01f, -1.18906252e-01f, 6.77163713e-03f, -1.08349964e-01f, -4.27384162e-03f,
  4.94771451e-02f, -7.59207876e-03f, 1.66440040e-01f, 9.08373855e-03f, -7.07429200e-02f, 6.36421517e-03f, 8.00413266e-02f, -1.63009372e-02f, 7.22912257e-04f, -2.44255271e-03f,
  -6.09416962e-02f, -7.97801018e-02f, -1.94907919e-01f, -5.38682789e-02f, -1.35734349e-01f, 3.23609561e-02f, -1.71995878e-01f, -1.00714087e-01f, -1.65430792e-02f, -3.16124037e-02f,
  -7.36835152e-02f, -3.75377648e-02f, -1.54819891e-01f, -1.06286250e-01f, -8.69459286e-02f, -1.31900519e-01f, -1.11452803e-01f, -1.82263389e-01f, -8.93236697e-02f, -1.37019455e-02f,
  9.36990082e-02f, -1.55495003e-01f, -7.74672180e-02f, -2.01781075e-02f, -1.48638159e-01f, -1.01527520e-01f, -9.14558843e-02f, -2.19645705e-02f, -6.36809925e-03f, -2.38603931e-02f,
  -1.79411501e-01f, 1.09239565e-02f, 1.36028618e-01f, -2.56109033e-02f, -6.32576793e-02f, -1.31520703e-01f, -9.76366997e-02f, -5.05498052e-02f, -1.67000383e-01f, -1.33079335e-01f,
  -1.78145513e-01f, 4.85172449e-03f, 6.39727414e-02f, 1.91465497e-01f, 1.15063764e-01f, 1.54028565e-03f, 4.71649058e-02f, 7.56216585e-04f, -6.94563165e-02f, -4.81269844e-02f,
  -1.87006012e-01f, 1.26548111e-01f, 6.67873072e-03f, 1.09416500e-01f, 1.08340150e-02f, 5.13699576e-02f, 3.18976194e-01f, 1.32108107e-01f, 4.98307161e-02f, 3.47911790e-02f,
  1.91218644e-01f, 4.64854799e-02f, -1.11036174e-01f, 6.94395155e-02f, 1.53371811e-01f, 1.31422982e-01f, 1.12697072e-01f, 3.61446477e-02f, 8.82549211e-02f, 3.81033570e-01f,
  -7.58873969e-02f, -3.29613209e-01f, -5.73659725e-02f, -3.64991054e-02f, -4.39605080e-02f, 9.47547797e-03f, 2.36455016e-02f, 1.10789225e-01f, -2.75923666e-02f, 3.76182012e-02f,
  -1.27753643e-02f, -1.21551588e-01f, 6.83257282e-02f, -7.13768974e-03f, 1.51812151e-01f, -6.49051974e-03f, -1.47691950e-01f, -4.13305499e-02f, -1.28256828e-01f, 3.28038260e-02f,
  1.57829374e-01f, -3.13673280e-02f, -1.93949014e-01f, -1.05460264e-01f, -5.93270548e-02f, -9.82379541e-02f, -6.37753755e-02f, 8.48065391e-02f, -3.05968165e-01f, 6.54681996e-02f,
  -9.58496407e-02f, -3.21325250e-02f, -1.13463707e-01f, 1.47350477e-02f, 1.88524961e-01f, 1.48284033e-01f, 1.69184253e-01f, 1.84048817e-01f, 1.19666122e-01f, -4.14970145e-02f,
  1.28407016e-01f, -7.68397748e-02f, -1.07717291e-01f, -1.89247668e-01f, -1.08253613e-01f, -2.62902919e-02f, 1.35355935e-01f, -8.53228569e-03f, -1.51667893e-01f, -1.92498028e-01f,
  -1.47592202e-01f, 7.05897063e-02f, -9.65997390e-03f, 3.49400006e-02f, 6.85572326e-02f, 6.16866276e-02f, 1.71446323e-01f, -4.16718647e-02f, 8.57319776e-03f, -1.03043556e-01f,
  -1.65644273e-01f, -3.69302839e-01f, -1.92332324e-02f, -4.88168634e-02f, -3.20495293e-02f, -7.66082928e-02f, -4.11297232e-02f, -1.14999354e-01f, -1.53973415e-01f, -1.41561165e-01f,
  -6.75640926e-02f, -8.46676528e-02f, 7.63173550e-02f, 8.34004283e-02f, 1.16082251e-01f, 7.85006732e-02f, 5.34810461e-02f, 1.04453363e-01f, -3.51280756e-02f, -1.39556065e-01f,
  1.01731673e-01f, -1.27342209e-01f, -8.92586857e-02f, -6.01062998e-02f, -9.41551104e-03f, -6.69047236e-02f, -8.98488835e-02f, 1.55768311e-02f, -2.40723267e-01f, -2.09238067e-01f,
  -5.11931598e-01f, -2.33505890e-01f, 1.56426787e-01f, -2.72551805e-01f, 1.25131711e-01f, 6.14961460e-02f, -1.22857906e-01f, -9.61402729e-02f, -6.35615587e-02f, -1.51179865e-01f,
  1.09112866e-01f, 3.00122146e-02f, 1.92824937e-02f, 1.48943499e-01f, -1.44823208e-01f, -1.15870990e-01f, -1.00685917e-01f, -3.07882372e-02f, 1.88140437e-01f, 4.19847444e-02f,
  1.26844779e-01f, 1.08547360e-02f, -1.32987440e-01f, -2.59415563e-02f, -3.04291517e-01f, -2.62782097e-01f, -2.83903964e-02f, -1.23847224e-01f, -5.76879270e-02f, -2.95640498e-01f,
  -5.49491346e-02f, 1.97405927e-03f, 1.49625167e-01f, -1.16199084e-01f, 3.21733728e-02f, -1.70532726e-02f, -5.94859309e-02f, 7.49418810e-02f, 8.63600075e-02f, -2.42550597e-02f,
  -6.96082115e-02f, 6.14897162e-02f, -8.82121101e-02f, 5.76107204e-02f, -3.26837450e-02f, -2.19863057e-01f, 3.74357961e-02f, 1.91983834e-01f, 7.28324875e-02f, 7.76830595e-03f,
  -5.72838522e-02f, -2.00118303e-01f, -1.59576192e-01f, -3.75102572e-02f, -9.29420143e-02f, 9.88822430e-03f, 2.49850582e-02f, -1.79373354e-01f, 2.31964681e-02f, -4.91808861e-01f,
  -2.89455261e-02f, 2.20099520e-02f, 1.91349193e-01f, -9.96022299e-02f, -9.31412354e-02f, -7.45486142e-03f, -3.18778232e-02f, 1.04618095e-01f, 5.91400079e-02f, -1.47702888e-01f,
  1.83528647e-01f, 2.20519025e-02f, -2.55432818e-02f, -1.64958581e-01f, -7.51121864e-02f, 3.57880518e-02f, 1.72006823e-02f, -6.70104148e-03f, -1.88876912e-01f, -4.48322035e-02f,
  -1.51316244e-02f, -6.53746501e-02f, 1.10259205e-02f, -1.05596349e-01f, -1.29248202e-01f, -3.13480385e-02f, 1.05543457e-01f, 8.90172273e-02f, 5.03930971e-02f, -1.55901285e-02f,
  -2.30279922e-01f, 3.06238830e-01f, -2.21199125e-01f, -5.90299852e-02f, -7.27193290e-03f, -1.35443127e-02f, -8.10221806e-02f, 1.51565135e-01f, 2.87960246e-02f, -1.22784488e-01f,
  -2.98577752e-02f, -2.26420075e-01f, -1.37805387e-01f, 1.16790999e-02f, 4.78516594e-02f, -5.70775531e-02f, -1.30493447e-01f, 3.44044417e-02f, 4.10200730e-02f, -2.09984392e-01f,
  -8.81018937e-02f, -1.78023309e-01f, -2.67502725e-01f, -2.43511274e-01f, -2.51668543e-01f, -1.84922501e-01f, -1.81372076e-01f, -1.86268330e-01f, -2.57396042e-01f, -5.80948830e-01f,
  -1.61028858e-02f, -3.17461640e-01f, 1.76078916e-01f, 1.62226543e-01f, 1.64477870e-01f, 2.85271257e-01f, 2.14202389e-01f, 1.15573339e-01f, 6.62981421e-02f, -4.87733297e-02f,
  -1.04044244e-01f, -1.42164677e-01f, -1.46022081e-01f, -4.34616208e-03f, -1.93496216e-02f, 1.58873387e-02f, 9.58932266e-02f, 1.70787826e-01f, 1.66141570e-01f, 1.77704468e-01f,
  9.15881246e-03f, -8.21125731e-02f, -9.94650051e-02f, 6.93827271e-02f, -1.52656317e-01f, 8.48443285e-02f, 4.86271940e-02f, 2.60428730e-02f, -3.58909406e-02f, -1.37214035e-01f,
  2.83460796e-01f, -1.88661382e-01f, 1.65424577e-03f, -1.85828775e-01f, -5.86513281e-02f, -1.91476211e-01f, -4.37321253e-02f, -2.57661231e-02f, -4.57295869e-03f, 7.83751458e-02f,
  -1.01704471e-01f, -3.40664312e-02f, -2.39108242e-02f, -6.91215619e-02f, -4.85600292e-04f, -3.22003998e-02f, -4.63914275e-02f, -1.02720305e-01f, -8.17360282e-02f, 7.92602673e-02f,
  -8.95975605e-02f, 1.83179360e-02f, 9.46280826e-03f, 4.29017469e-02f, -3.66188399e-02f, -6.06524721e-02f, -4.66651693e-02f, -1.22697115e-01f, 2.70405039e-02f, -3.15892138e-02f,
  1.95263624e-01f, -5.64999096e-02f, -7.95592815e-02f, 1.06501140e-01f, -5.97499171e-03f, 2.02283412e-02f, 3.98295186e-02f, 7.37369880e-02f, 8.44617188e-02f, -3.53655368e-02f,
  -9.70968902e-02f, 1.06769241e-01f, 1.59493119e-01f, 5.66024072e-02f, -3.88535261e-02f, 4.49718833e-02f, 1.20533474e-01f, 4.24156301e-02f, -1.17226943e-01f, 3.15722525e-02f,
  -8.24535713e-02f, -9.78131033e-03f, -1.03440821e-01f, -1.50864273e-01f, -8.66073370e-02f, -7.85309598e-02f, 1.13313468e-02f, -3.89872156e-02f, -2.47614775e-02f, -2.60244198e-02f,
  -4.83941007e-03f, 4.24292423e-02f, -4.56668027e-02f, -9.43087861e-02f, -1.56209156e-01f, -1.78794250e-01f, 9.87841096e-03f, -1.33758113e-01f, 7.64997229e-02f, 5.92561513e-02f,
  1.30123645e-01f, -2.03852244e-02f, 1.45267453e-02f, 2.16776915e-02f, 1.57772228e-01f, 1.26537174e-01f, -2.07514927e-01f, -3.21113095e-02f, 4.97874357e-02f, 1.16766594e-01f,
  -5.51863573e-02f, 1.28998712e-01f, 2.33059362e-01f, 1.02690928e-01f, 4.52652611e-02f, 2.56189972e-01f, 9.48907062e-02f, 1.20409951e-02f, 1.16879188e-01f, 9.86318439e-02f,
  5.52359164e-01f, 2.80810148e-01f, 1.75935045e-01f, 9.74763334e-02f, -2.70786405e-01f, -8.95819664e-02f, -1.35573536e-01f, -7.34521896e-02f, 3.75784114e-02f, 1.62854493e-01f,
  1.84704632e-01f, 4.49439920e-02f, 5.80717884e-02f, -8.92426539e-03f, 9.03451815e-02f, -2.00890396e-02f, 6.10094704e-02f, 4.34376933e-02f, 3.49310189e-02f, 1.61728710e-01f,
  -4.19276319e-02f, 1.91197500e-01f, 1.80391848e-01f, 8.77883285e-02f, 9.95937511e-02f, 7.19421431e-02f, 7.51666725e-02f, 1.37589499e-01f, 9.42107514e-02f, 2.09310517e-01f,
  3.17910075e-01f, 3.81363779e-01f, -1.36882186e-01f, -7.86888376e-02f, -2.96783522e-02f, 1.73212677e-01f, 8.99052098e-02f, -1.62188206e-02f, -6.87674806e-02f, 3.33767012e-02f,
  -6.35331403e-03f, 1.21806465e-01f, -5.44495657e-02f, 7.58471191e-02f, 3.27130519e-02f, 7.94060603e-02f, 1.19373359e-01f, 1.24185130e-01f, 9.25288722e-03f, -4.71382141e-02f,
  -1.20718181e-01f, -7.02145100e-02f, -7.78676718e-02f, -4.15827520e-02f, -3.14265601e-02f, -1.00838862e-01f, 6.00804687e-02f, 8.61726850e-02f, 9.91792530e-02f, 2.91233689e-01f,
  1.42242201e-02f, 9.44802612e-02f, 2.08520502e-01f, 2.07089111e-01f, 2.24958807e-01f, 2.22171228e-02f, 1.39608905e-02f, -3.58744198e-03f, 8.86258483e-02f, 1.05594166e-01f,
  -7.93361217e-02f, 1.04746707e-01f, 9.32544749e-03f, 7.69518362e-03f, -1.60772540e-02f, 7.55323935e-03f, 8.40806495e-03f, -8.89771990e-03f, -2.02259291e-02f, -1.57625005e-02f,
  4.89499830e-02f, -2.25303806e-02f, 1.86551604e-02f, 9.04797241e-02f, -5.75453192e-02f, 8.06116611e-02f, 5.07736392e-03f, -5.78083273e-05f, 5.98458350e-02f, 7.12455884e-02f,
  -1.78110003e-01f, -2.25322500e-01f, 1.21391207e-01f, 1.08140409e-02f, -2.07284000e-02f, -3.21425982e-02f, -4.48049754e-02f, -1.17092796e-01f, -1.20308742e-01f, 3.41771916e-02f,
  -2.23217756e-02f, 1.77423321e-02f, 1.54123306e-02f, -7.76903182e-02f, 9.71681699e-02f, -7.40992725e-02f, -1.06528610e-01f, -1.93135545e-01f, -7.65651986e-02f, -1.07826374e-01f,
  -1.75162733e-01f, -1.66938469e-01f, -2.56295204e-01f, -2.05772966e-01f, 6.61006151e-03f, -1.16444394e-01f, -1.39212981e-01f, -1.20003425e-01f, -1.46261305e-01f, -2.37247124e-02f,
  -8.12081695e-01f, 2.19280243e-01f, 1.52726978e-01f, -3.13380420e-01f, -3.13250981e-02f, 7.63594732e-02f, 1.62053511e-01f, 4.05999832e-02f, -2.03999475e-01f, 1.19243421e-01f,
  -2.82531399e-02f, -9.48731080e-02f, -1.08098783e-01f, 3.47524160e-03f, -9.70176756e-02f, 1.16527207e-01f, -5.88338450e-02f, -1.70621008e-01f, -2.65778929e-01f, -4.97488528e-02f,
  -6.41099438e-02f, -1.57691970e-01f, -2.95525283e-01f, -6.12093024e-02f, 1.22923777e-01f, -8.43494609e-02f, 1.45016000e-01f, -6.79172426e-02f, 1.39923573e-01f, 3.88248563e-02f,
  3.76714081e-01f, -1.25915602e-01f, -1.97351407e-02f, -3.87892611e-02f, -3.90124395e-02f, -1.03660442e-01f, -1.32218942e-01f, 3.72111588e-03f, 7.07542943e-03f, 8.86361077e-02f,
  -2.11609341e-02f, -2.25785729e-02f, -7.80162513e-02f, 6.67927861e-02f, 6.29255921e-02f, 3.14365141e-02f, 4.42609042e-02f, -4.70084213e-02f, 4.64857742e-02f, 7.22130239e-02f,
  9.51141044e-02f, 3.19655277e-02f, 7.82468095e-02f, 4.36308011e-02f, 2.88947858e-02f, -7.71544874e-02f, 9.70657989e-02f, 2.39596553e-02f, 1.18897622e-03f, 2.50734650e-02f,
  2.10918374e-02f, -2.66327579e-02f, 1.08275320e-02f, -1.34973899e-01f, -1.11583166e-01f, -3.39555256e-02f, -1.66807938e-02f, -2.54261075e-03f, -1.64579302e-01f, -9.51602459e-02f,
  2.81693898e-02f, 3.43959704e-02f, -4.58057821e-02f, -2.39821430e-02f, 1.11163385e-01f, 1.84649695e-02f, 8.22432637e-02f, 1.19320378e-01f, -1.29654566e-02f, -1.10247858e-01f,
  -2.75512645e-03f, 6.25851303e-02f, 9.38952267e-02f, 9.59431231e-02f, 7.73006007e-02f, -3.19675468e-02f, -1.47606069e-02f, 6.61928952e-02f, 2.87250318e-02f, -4.44814675e-02f,
  3.61131042e-01f, -2.72660822e-01f, 1.35758044e-02f, -4.05961499e-02f, -2.28102207e-02f, 8.77159759e-02f, -7.04816952e-02f, -3.60044874e-02f, 2.53977090e-01f, 1.13831222e-01f,
  2.21036986e-01f, -3.80572639e-02f, -3.35885771e-02f, 1.13486070e-02f, 6.39067516e-02f, 1.00935943e-01f, 3.57153192e-02f, 7.55727291e-02f, 1.13915034e-01f, 2.09756583e-01f,
  2.15202227e-01f, 3.52003202e-02f, 1.78052261e-01f, 1.67987570e-01f, -5.98974675e-02f, 9.83190387e-02f, 1.08427852e-01f, 4.57650647e-02f, 6.13421798e-02f, 1.30580112e-01f,
  1.20649628e-01f, -2.53318757e-01f, -4.78104889e-01f, -7.35138282e-02f, -2.76255280e-01f, -2.53274918e-01f, -3.86080742e-01f, -5.05370349e-02f, 1.75103247e-02f, -2.24778846e-01f,
  -1.54614925e-01f, 1.46397814e-01f, -6.25506938e-02f, -1.59711212e-01f, -2.23720044e-01f, -4.50232118e-01f, -3.73929232e-01f, -1.63289532e-01f, -2.92439386e-02f, 4.77389321e-02f,
  -1.21831506e-01f, -1.43706828e-01f, -1.23858005e-01f, -1.13997377e-01f, -6.83742315e-02f, -1.21550359e-01f, -2.26785645e-01f, -1.56656414e-01f, -3.15342695e-01f, -4.01508391e-01f,
  -5.16529940e-02f, 1.35185957e-01f, -3.30631854e-03f, 3.35372351e-02f, 5.37858997e-03f, 2.27782726e-02f, -6.42568991e-02f, 1.36674240e-01f, 1.45519182e-01f, 4.95946594e-02f,
  4.79115546e-02f, 1.00963619e-02f, 8.45647678e-02f, 1.61978588e-01f, -1.35436365e-02f, 7.58823156e-02f, 1.42883748e-01f, 1.33154511e-01f, 8.79512206e-02f, 1.10468239e-01f,
  8.23614933e-03f, 1.08792439e-01f, 6.95011690e-02f, 3.84948589e-02f, 9.67683941e-02f, 3.45100425e-02f, 3.48202921e-02f, 1.44645631e-01f, 5.79128414e-02f, 1.14693120e-01f,
  -1.66132540e-01f, 1.36538222e-01f, 6.53055077e-03f, 1.49990380e-01f, 1.54029459e-01f, 1.18026644e-01f, 1.21641308e-02f, 5.54017797e-02f, 7.75229782e-02f, 5.17101400e-02f,
  1.64893165e-01f, 5.90841621e-02f, 3.49889998e-03f, -4.34938669e-02f, -1.51798818e-02f, 4.56061512e-02f, -2.82280776e-03f, 2.85528637e-02f, 4.55816202e-02f, 1.81786522e-01f,
  1.36145586e-02f, 6.22543134e-02f, -2.67744251e-02f, -5.96635118e-02f, -7.56623819e-02f, -6.65044859e-02f, -5.54686040e-02f, -3.23210694e-02f, -1.13194704e-01f, 1.26539478e-02f,
  1.79570600e-01f, -6.62083030e-02f, -1.52395308e-01f, 4.53535579e-02f, 1.31403893e-01f, 5.32962717e-02f, 6.22848719e-02f, 2.40534097e-02f, -2.56045032e-02f, 7.84860253e-02f,
  1.04782745e-01f, -3.09814326e-02f, -3.49400267e-02f, 1.82547629e-01f, 1.17852792e-01f, 3.89249884e-02f, 3.87159251e-02f, 1.22051299e-01f, -5.11417305e-03f, 5.61781712e-02f,
  4.71016690e-02f, 1.26706764e-01f, 1.39878005e-01f, 1.33778438e-01f, 1.79915950e-01f, 1.98695045e-02f, -5.92773408e-03f, -2.23747622e-02f, -1.12632230e-01f, 1.00166695e-02f,
  4.25459534e-01f, -2.65180379e-01f, 1.21216327e-01f, 1.27075791e-01f, -1.89467534e-01f, -1.84705600e-01f, -2.62711078e-01f, -9.23875794e-02f, 1.46115333e-01f, -2.08072476e-02f,
  1.07363380e-01f, 3.38124275e-01f, 2.87479013e-01f, 2.44365066e-01f, 1.34328261e-01f, -2.90241092e-02f, -4.82584536e-02f, 2.37466827e-01f, 2.01252744e-01f, 4.54235859e-02f,
  2.50396319e-02f, -1.04353219e-01f, 1.21744633e-01f, 9.29601938e-02f, -5.79884090e-02f, 1.67766616e-01f, -1.39607415e-01f, -8.92792344e-02f, -1.12858973e-01f, 1.02106802e-01f,
  2.70478338e-01f, 2.44034395e-01f, 2.30718747e-01f, 7.31935278e-02f, 2.56656911e-02f, 5.98878562e-02f, -1.54206986e-02f, -2.91925464e-02f, -1.16783515e-01f, -1.26521930e-01f,
  -1.64446514e-02f, -8.68773181e-03f, -3.77402008e-02f, -1.56414822e-01f, -2.57502377e-01f, -1.66135266e-01f, -4.66093384e-02f, 2.04752889e-02f, -6.56527132e-02f, -1.83882918e-02f,
  1.57203116e-02f, -4.32780646e-02f, -1.43807929e-03f, -1.87355652e-02f, -3.90717648e-02f, 1.11636110e-01f, 2.39552986e-02f, -6.19231202e-02f, 4.60001566e-02f, -1.54757261e-01f,
  1.88289192e-02f, 3.24113593e-02f, 6.99944794e-02f, 5.78342602e-02f, -3.28704752e-02f, -4.94113788e-02f, -5.05899712e-02f, -2.02593561e-02f, 5.93682081e-02f, -1.62571743e-01f,
  -1.16200127e-01f, 1.37484267e-01f, 1.17105201e-01f, 5.03459647e-02f, 1.53520629e-01f, -4.66626324e-02f, -6.68903887e-02f, -1.88555568e-02f, 1.07232891e-02f, -1.18151523e-01f,
  1.82526335e-02f, -1.56004071e-01f, 2.34380085e-02f, -1.50319654e-02f, -1.01064309e-01f, 1.20872490e-01f, 4.69216704e-02f, 2.48644128e-02f, -6.62044734e-02f, -1.76400974e-01f,
  -1.62358373e-01f, 4.37856793e-01f, 1.30895674e-01f, 2.00198516e-01f, 1.52491689e-01f, 3.36901750e-03f, 2.36233696e-01f, 3.97842154e-02f, 2.99794935e-02f, 5.15832938e-02f,
  -8.04638565e-02f, 1.19487152e-01f, -2.12203991e-02f, -6.59165606e-02f, -1.61104091e-02f, 7.16905966e-02f, 6.50067851e-02f, 1.92139894e-01f, 1.03785051e-02f, -8.03672448e-02f,
  -1.78359091e-01f, 6.18159436e-02f, 7.55793080e-02f, 1.86220948e-02f, -1.77147239e-02f, 1.52719617e-01f, 8.26946273e-02f, -9.23736468e-02f, 4.27853242e-02f, -1.34425610e-01f,
  -5.01909137e-01f, -5.65871075e-02f, -1.53181747e-01f, 1.89005598e-01f, 3.64729851e-01f, 3.22526693e-01f, 3.37099910e-01f, 1.69071510e-01f, 2.08168983e-01f, 6.01863042e-02f,
  -5.25916666e-02f, 1.24108113e-01f, 1.61682263e-01f, 8.41070116e-02f, 7.39474967e-02f, 3.02178323e-01f, 3.54938447e-01f, 2.25821026e-02f, 8.65883529e-02f, 4.15326953e-02f,
  1.64416075e-01f, 1.29597351e-01f, -2.25513116e-01f, -1.81732364e-02f, 2.29047194e-01f, 1.19783901e-01f, 1.86303958e-01f, 5.96060902e-02f, 7.70960152e-02f, 1.15641616e-01f,
  -1.51134431e-01f, -2.35834002e-01f, 1.65731475e-01f, 1.66950130e-03f, -1.80781201e-01f, -2.62969077e-01f, -1.13596439e-01f, -1.77727729e-01f, 3.05598807e-02f, -6.00875914e-02f,
  7.37173557e-02f, -6.65989518e-02f, 5.14027569e-03f, -1.06361359e-02f, -1.34245083e-01f, -1.40610099e-01f, -1.22946076e-01f, -2.99671292e-02f, 1.18950710e-01f, 2.47434266e-02f,
  -1.28053585e-02f, 5.74418195e-02f, 4.67873141e-02f, 1.58172682e-01f, 1.26972467e-01f, 9.02606323e-02f, -1.91668663e-02f, -3.31872590e-02f, 1.70840193e-02f, -1.01078831e-01f,
  1.73033878e-01f, 5.95761873e-02f, 3.37346718e-02f, -1.06334276e-01f, 1.10568327e-03f, -5.21462969e-02f, 1.99115020e-03f, 7.98039436e-02f, 1.08029887e-01f, -3.12906615e-02f,
  -3.95133980e-02f, -6.42153341e-03f, 7.22654685e-02f, -2.65610851e-02f, -1.61704972e-01f, -4.84667979e-02f, -1.86434090e-02f, -1.22185133e-01f, -1.43000424e-01f, -6.86555281e-02f,
  -1.05678007e-01f, -6.39680028e-02f, -9.29430202e-02f, -1.09059483e-01f, -1.35787800e-01f, -1.22753307e-01f, -1.16313294e-01f, -1.32886603e-01f, -2.43044086e-03f, -3.70131955e-02f,
  2.10419372e-01f, -3.94652113e-02f, 7.66434446e-02f, -3.46303284e-02f, -4.09764126e-02f, -1.51548833e-01f, -6.09774217e-02f, -4.58078943e-02f, 1.18867978e-01f, 4.20545489e-02f,
  3.35635133e-02f, -2.36150682e-01f, -9.14354846e-02f, -8.56044516e-02f, -7.27069974e-02f, -6.16320260e-02f, -1.38377175e-01f, -8.86300113e-03f, 1.10062689e-01f, 1.02852555e-02f,
  -5.25032505e-02f, -5.11111729e-02f, 1.05586454e-01f, 1.29373729e-01f, 1.34900779e-01f, 2.90901251e-02f, 6.61170557e-02f, 3.21683176e-02f, -3.36961821e-02f, 5.86693771e-02f,
  -8.16481188e-03f, -1.48901492e-01f, 3.02868932e-01f, 2.19523162e-01f, 1.46104068e-01f, 4.26557846e-02f, -2.86055766e-02f, 1.33675247e-01f, 1.42078549e-01f, -6.28116494e-03f,
  1.04103498e-01f, 1.15959987e-01f, 1.94967598e-01f, 1.38466924e-01f, 2.28834137e-01f, 1.54511526e-01f, 1.38223648e-01f, 2.45379671e-01f, 2.11926103e-01f, 1.00731425e-01f,
  1.88038528e-01f, -7.64419604e-03f, 6.78826645e-02f, 1.60777867e-01f, 1.08687364e-01f, 1.82226449e-01f, 1.45577401e-01f, 1.39829054e-01f, 1.37767941e-02f, 1.47005588e-01f,
  1.05261365e-02f, -9.85935703e-02f, 1.33531362e-01f, -1.55286025e-02f, -5.81564605e-02f, -2.07627729e-01f, 3.15200612e-02f, -3.41789834e-02f, -1.27904611e-02f, 4.76911515e-02f,
  -2.81183068e-02f, -1.16593033e-01f, -1.30811051e-01f, -1.13068357e-01f, -1.14315905e-01f, -1.29153252e-01f, -3.55008096e-02f, 1.48084641e-01f, 2.12947816e-01f, 3.12728062e-02f,
  -1.83140729e-02f, -6.38840273e-02f, 8.78044292e-02f, 7.00909719e-02f, 6.79377699e-03f, 4.82291803e-02f, -8.05668756e-02f, -3.67025211e-02f, 8.99154469e-02f, 6.77083060e-02f,
  1.52414724e-01f, -8.93763173e-03f, 3.27905491e-02f, -3.56646739e-02f, -1.11831883e-02f, -5.06526753e-02f, 4.20565046e-02f, 9.47239548e-02f, 7.36178011e-02f, -1.55385152e-01f,
  1.23398446e-01f, 2.36689404e-01f, 9.02358294e-02f, 2.00509764e-02f, 5.89455105e-02f, 7.58939516e-03f, -7.10924938e-02f, 4.03551832e-02f, 7.53792226e-02f, 4.39845771e-02f,
  5.59741864e-03f, -4.43812571e-02f, 2.43814085e-02f, 7.63389692e-02f, 1.02151828e-02f, 2.37839893e-01f, 1.38762072e-01f, 4.76868870e-03f, -7.41674826e-02f, 4.05537002e-02f,
  -3.89560126e-02f, 3.49003583e-01f, 5.75440340e-02f, -5.86991757e-02f, -3.98034826e-02f, 1.85736567e-02f, 8.44968483e-02f, 3.50608416e-02f, -1.15655154e-01f, -1.15609756e-02f,
  -1.53262541e-01f, -9.28509608e-02f, -5.30791469e-02f, -1.12233637e-02f, -1.30347937e-01f, -1.67548463e-01f, -8.67579952e-02f, 1.13794111e-01f, 1.51630044e-01f, -2.42125038e-02f,
  2.38302797e-02f, 6.29648864e-02f, 1.12938101e-03f, 7.53816217e-02f, 1.84370987e-02f, -6.12713844e-02f, -1.09313600e-01f, -3.25086899e-02f, -1.16610646e-01f, -1.28541633e-01f,
  -5.23945391e-01f, 3.51076901e-01f, -6.55258968e-02f, 7.89968297e-03f, 2.08968922e-01f, 2.17237979e-01f, 3.58600855e-01f, 1.71695650e-01f, 5.62511757e-02f, 5.55735566e-02f,
  1.15777314e-01f, -3.15328911e-02f, -4.65467758e-02f, -9.09421369e-02f, -3.93874347e-02f, 5.54171428e-02f, 1.46064371e-01f, -1.55092105e-01f, -2.19342515e-01f, -3.58786806e-02f,
  5.82486987e-02f, -8.21013898e-02f, -3.13621074e-01f, -1.74567506e-01f, 7.87919983e-02f, -5.79035282e-02f, -2.38159951e-02f, 6.95385635e-02f, 8.92330110e-02f, -4.63092141e-02f,
  -4.70364355e-02f, 9.00327861e-02f, 2.72913165e-02f, 5.41355759e-02f, 1.35318870e-02f, -1.48137033e-01f, -3.32260430e-02f, 5.76680014e-03f, 3.82355563e-02f, 7.04334080e-02f,
  -5.91145121e-02f, 1.06012216e-03f, 2.27193721e-02f, -3.80794555e-02f, -6.21966763e-07f, 4.86385189e-02f, 1.13545977e-01f, 4.91802990e-02f, 1.76432252e-01f, 8.57811347e-02f,
  1.03316389e-01f, 5.60138971e-02f, 2.93055743e-01f, 2.36886397e-01f, 2.13902779e-02f, -2.39144266e-02f, 7.95764402e-02f, 3.15955654e-02f, 6.63430095e-02f, 4.03347425e-02f,
  -1.63425282e-02f, 1.07033014e-01f, 3.17490511e-02f, 8.19207653e-02f, -2.97739748e-02f, 1.13610394e-01f, 1.79585833e-02f, 8.64420645e-03f, -1.52333174e-02f, -6.44061565e-02f,
  9.12804604e-02f, 1.78703815e-01f, 1.83064491e-01f, 4.15024310e-02f, -8.51886719e-02f, 1.40279144e-01f, 1.46783497e-02f, 9.37084183e-02f, -1.89929083e-02f, 6.36604801e-02f,
  -2.78238822e-02f, 7.28374124e-02f, -4.23584580e-02f, -8.15193634e-04f, 1.32520005e-01f, 5.37236929e-02f, -2.16588750e-02f, 4.48916703e-02f, 6.74704015e-02f, 2.54820008e-02f,
  3.50648880e-01f, 9.75433066e-02f, -5.38371913e-02f, 1.64720088e-01f, -2.62998939e-02f, -4.85105477e-02f, -1.54924374e-02f, 2.10557878e-02f, 4.31429371e-02f, 1.35925896e-02f,
  -2.25775763e-02f, -1.73579693e-01f, 6.70765415e-02f, 5.33264689e-02f, -1.60070568e-01f, -1.19416408e-01f, 8.60666409e-02f, 1.83433056e-01f, 1.17943078e-01f, 5.38382791e-02f,
  5.76753244e-02f, -7.62384292e-03f, 5.09326942e-02f, 3.62747982e-02f, 1.67984366e-02f, 2.98825512e-03f, -1.63356036e-01f, 1.37227308e-02f, -1.23562396e-01f, -1.99307218e-01f,
  4.21215266e-01f, -1.85717121e-01f, -2.58941174e-01f, 3.62224311e-01f, 3.71591076e-02f, -3.55647914e-02f, -2.87284642e-01f, 2.39404738e-02f, 2.39566103e-01f, -5.76071069e-02f,
  1.11330776e-02f, 2.19216064e-01f, 1.18924208e-01f, -1.73845086e-02f, -8.11690316e-02f, -1.79720923e-01f, -5.07782176e-02f, 8.42706114e-02f, 1.98917598e-01f, 1.36578247e-01f,
  1.82024036e-02f, -2.59970874e-02f, 6.00972548e-02f, -6.17204756e-02f, 2.68539833e-03f, 1.23491094e-01f, -2.58293986e-01f, -1.62125871e-01f, -2.72727579e-01f, 1.44251883e-02f,
  6.83361739e-02f, 5.55906072e-02f, -3.20219807e-02f, 1.05806865e-01f, -5.44560030e-02f, -8.72562826e-02f, -2.00457051e-02f, -9.32883844e-02f, -9.86579210e-02f, -5.25973812e-02f,
  5.34647033e-02f, -5.02841435e-02f, 2.35369094e-02f, 5.75088114e-02f, -4.40522991e-02f, 1.08370021e-01f, -1.67749375e-01f, -2.12371513e-01f, -8.89379010e-02f, -8.88100788e-02f,
  8.57399851e-02f, -9.68030829e-04f, -9.70371068e-02f, -1.96394175e-01f, -1.01687185e-01f, -5.30684069e-02f, -2.78228611e-01f, -8.84793922e-02f, -1.11339509e-01f, -1.25943080e-01f,
  1.28515465e-02f, 3.62468744e-03f, -5.97852878e-02f, -1.14309415e-01f, 8.31054226e-02f, 5.50205307e-03f, 8.25201347e-02f, -3.47860791e-02f, 4.16699946e-02f, -1.81127861e-01f,
  -1.08963102e-02f, 2.78281812e-02f, 6.95733204e-02f, -8.59436113e-03f, -2.22329586e-03f, -1.42623499e-01f, 7.02603813e-03f, -4.49619219e-02f, -7.48158097e-02f, -3.36776115e-02f,
  -1.02248393e-01f, -2.64227646e-03f, -1.35450900e-01f, 2.95284875e-02f, 6.12275265e-02f, 1.10765006e-02f, 5.83176501e-02f, 9.00632665e-02f, 7.56679475e-02f, -8.17099214e-02f,
  3.02854814e-02f, -7.44436383e-02f, 1.57213453e-02f, -2.80087031e-02f, -9.10968482e-02f, -8.96632001e-02f, -6.89896643e-02f, -6.21012459e-03f, -6.00913167e-02f, -1.56614006e-01f,
  -3.52163650e-02f, -5.67027032e-02f, -3.22036035e-02f, -1.30371004e-01f, 6.09810017e-02f, 1.71611900e-03f, -1.61613315e-01f, -9.40556750e-02f, -1.17969820e-02f, -7.99574330e-02f,
  -1.56203195e-01f, 1.98968574e-02f, 1.25403047e-01f, -5.27853146e-02f, 5.11803329e-02f, 3.16251814e-02f, -1.04237951e-01f, -1.51854828e-01f, -1.08130254e-01f, -3.14794064e-01f,
  -1.87289640e-01f, 1.15624219e-02f, -4.37111035e-02f, 8.87428969e-02f, 6.84497282e-02f, 7.39766732e-02f, -1.13984093e-01f, -1.31182894e-01f, 8.98930803e-02f, 1.40279695e-01f,
  6.64644316e-02f, -1.23918608e-01f, -1.62832171e-01f, -3.11360478e-01f, -5.69960356e-01f, -1.15381785e-01f, -2.17839256e-01f, -3.82617563e-01f, -4.43866193e-01f, -8.07024315e-02f,
  -9.48465392e-02f, -7.38349780e-02f, -2.60511756e-01f, -7.43537024e-02f, 1.73632085e-01f, -4.72518019e-02f, -5.84837236e-02f, -1.29841790e-01f, -7.66212195e-02f, 8.80838707e-02f,
  -1.15037903e-01f, 4.67277355e-02f, -7.37546235e-02f, -3.80235352e-02f, 6.85055926e-02f, -3.09485625e-02f, 3.43176536e-02f, -1.18502848e-01f, -1.29164785e-01f, -1.41819045e-01f,
  8.75962302e-02f, 1.17399558e-01f, -3.74246985e-02f, -1.03638522e-01f, -3.75790074e-02f, -6.39840513e-02f, -7.64072686e-02f, -2.63655216e-01f, -2.69871145e-01f, -3.15686055e-02f,
  -2.21388116e-02f, 2.31442917e-02f, -1.20853841e-01f, -7.71081224e-02f, 4.98716198e-02f, -1.76358268e-01f, -6.31425083e-02f, 9.07303691e-02f, -8.19090828e-02f, -1.47313140e-02f,
  5.47729954e-02f, 6.10746555e-02f, -1.79657396e-02f, 3.18900794e-02f, -6.19339617e-03f, 9.87436324e-02f, -2.83796750e-02f, -6.66960031e-02f, 9.31972042e-02f, -2.03596652e-02f,
  -4.92688417e-02f, -4.71848473e-02f, 7.34020099e-02f, 2.94929687e-02f, 8.43419787e-03f, -3.23511288e-02f, -7.57266060e-02f, -1.89169839e-01f, -4.89225835e-02f, 9.70468670e-02f,
  -3.42443585e-02f, -5.38254455e-02f, 8.12389106e-02f, -7.20824897e-02f, 1.93935074e-02f, 2.63928156e-02f, 2.93206535e-02f, -1.31463274e-01f, -2.45946590e-02f, -1.43148094e-01f,
  -2.02678561e-01f, -1.23311765e-01f, -4.82575260e-02f, -2.31624261e-01f, -1.45213798e-01f, 4.09994423e-02f, 5.91065995e-02f, -1.91234276e-01f, 1.62798706e-02f, -8.11504722e-02f,
  -3.62544283e-02f, 2.18985435e-02f, 1.95784923e-02f, 1.16220107e-02f, 8.13511983e-02f, 3.77475992e-02f, -1.55474633e-01f, -3.57234217e-02f, -5.86613603e-02f, -3.79925556e-02f,
  -2.01541618e-01f, -1.97565153e-01f, -1.29396632e-01f, -1.23664804e-01f, 1.01302817e-01f, -1.36281520e-01f, -1.03170253e-01f, -9.83296931e-02f, -1.60199672e-01f, -1.41499057e-01f,
  9.93617773e-02f, 1.16044439e-01f, 1.39608607e-01f, 1.13892138e-01f, -7.14475736e-02f, -2.81063110e-01f, -4.22058702e-01f, -2.25623891e-01f, 1.47548750e-01f, 3.74066792e-02f,
  2.86890194e-02f, -8.58094469e-02f, -1.79859195e-02f, -1.06721431e-01f, -2.55414695e-01f, 4.60073128e-02f, 1.43953055e-01f, -7.99282864e-02f, -3.06135476e-01f, -3.21975023e-01f,
  2.36626174e-02f, -2.09268345e-03f, -1.09736752e-02f, -5.86683862e-02f, 2.10626438e-01f, 6.85841292e-02f, 1.87754437e-01f, 5.67754693e-02f, 1.86739806e-02f, 3.76448005e-01f,
  2.18883216e-01f, 2.35894814e-01f, -1.77792251e-01f, -6.07133321e-02f, -5.37910685e-02f, -1.01884268e-01f, -4.36847173e-02f, 7.67153949e-02f, -1.21990763e-01f, 1.49626896e-01f,
  -2.23727077e-02f, 1.59904489e-03f, 1.07781731e-01f, -8.93821418e-02f, -1.11010127e-01f, -1.61624119e-01f, -1.34425044e-01f, -1.48933813e-01f, -8.61615539e-02f, 7.05456883e-02f,
  -1.30600289e-01f, 1.77749079e-02f, -4.29282933e-02f, -7.16284513e-02f, -9.96773094e-02f, -4.96955700e-02f, -5.21670729e-02f, -4.23170216e-02f, -1.81391135e-01f, 8.73792991e-02f,
  5.46582714e-02f, -3.51477973e-02f, -6.40850142e-02f, -1.95503887e-02f, -1.22131653e-01f, 1.18235610e-02f, 7.84146041e-02f, -3.72482464e-02f, 2.46240292e-02f, -3.39796543e-02f,
  -6.45259991e-02f, -6.67684479e-03f, 5.43691516e-02f, 8.57998524e-03f, 1.56597421e-02f, 2.84390207e-02f, -2.84512807e-02f, -5.69889247e-02f, 1.11840032e-02f, 3.79303172e-02f,
  -4.86238189e-02f, 7.62581453e-02f, 1.53544560e-01f, -3.64757255e-02f, -3.49858478e-02f, -2.28025783e-02f, 5.58146536e-02f, -1.07798517e-01f, 1.84973571e-02f, 9.91204977e-02f,
  1.14937007e-01f, -2.31501386e-01f, 1.53100967e-01f, -3.57818566e-02f, 4.58105505e-02f, -4.03687581e-02f, 7.35388994e-02f, -7.44402111e-02f, 1.60433333e-02f, -1.13398261e-01f,
  -1.47325188e-01f, -4.96338047e-02f, 5.87845445e-02f, -2.17952151e-02f, -1.20569229e-01f, 3.14221755e-02f, -1.42740846e-01f, -1.40382692e-01f, -1.51837289e-01f, -9.16360468e-02f,
  -1.90845355e-01f, -2.60504067e-01f, -1.81253031e-01f, -1.87905893e-01f, 6.87286854e-02f, -2.33933881e-01f, 2.89050154e-02f, -1.82457775e-01f, -2.45915473e-01f, -1.78216159e-01f,
  -9.31272358e-02f, 1.99649081e-01f, 6.95201829e-02f, 1.64234266e-01f, 2.71741420e-01f, 2.57070512e-01f, 4.02901083e-01f, 2.46989146e-01f, -5.35023659e-02f, 1.56628951e-01f,
  9.20339450e-02f, -2.10850149e-01f, -1.86054066e-01f, -2.30554268e-01f, 5.34737036e-02f, 1.86218128e-01f, 4.22574989e-02f, -1.44360244e-01f, -7.70907104e-02f, 1.27874371e-02f,
  2.36731004e-02f, 4.54387963e-02f, -7.34940767e-02f, -8.42213705e-02f, 6.06105151e-03f, -9.36414972e-02f, -2.43576169e-02f, 6.42031804e-02f, 7.19709545e-02f, -1.14031188e-01f,
  -3.20784599e-01f, 1.85449436e-01f, -6.58985898e-02f, -1.48081586e-01f, -8.11131522e-02f, -1.22863978e-01f, -1.33849666e-01f, -7.13654757e-02f, 2.91479863e-02f, -4.41885777e-02f,
  6.79445639e-02f, -6.08093664e-02f, -2.07781401e-02f, -8.42308532e-03f, 2.22640336e-02f, -4.34609642e-03f, 4.95004375e-03f, -1.00726992e-01f, -7.11624026e-02f, -5.46611361e-02f,
  -4.69012670e-02f, 1.54660508e-01f, 1.79724440e-01f, 1.80791944e-01f, -1.37919458e-02f, -4.60235998e-02f, -2.27255803e-02f, -9.97747630e-02f, 1.14135649e-02f, -5.71561642e-02f,
  9.13022831e-02f, 1.15270294e-01f, 1.34469107e-01f, 8.95579830e-02f, 3.62407253e-03f, -7.20670670e-02f, 2.25377344e-02f, -4.71817106e-02f, -2.12797150e-02f, -1.14963939e-02f,
  -9.23240036e-02f, 5.72037958e-02f, -4.93026525e-03f, -2.41897814e-03f, -1.26897423e-02f, 5.37185930e-02f, 2.57576667e-02f, -1.29977107e-01f, -9.86245796e-02f, 1.91605184e-02f,
  1.08973673e-02f, 6.49255514e-02f, -6.81266263e-02f, -1.30313203e-01f, -5.16244248e-02f, -2.19432991e-02f, 8.68414938e-02f, -6.01246767e-02f, -1.14669167e-01f, 8.33175629e-02f,
  -1.49539948e-01f, 2.02367008e-01f, -8.95023048e-02f, -2.63360590e-02f, -1.81310996e-02f, -1.05047368e-01f, -2.31828783e-02f, -8.28871727e-02f, -8.95771012e-02f, -9.11862701e-02f,
  -2.26909313e-02f, -1.18681811e-01f, -5.09077758e-02f, -7.66527057e-02f, -4.69333492e-02f, -5.62634915e-02f, -1.74118266e-01f, -4.85544950e-02f, 5.89055605e-02f, -7.72828609e-02f,
  -1.42915016e-02f, 1.01468645e-01f, -3.80925871e-02f, 5.41080944e-02f, -1.71652827e-02f, 4.75627035e-02f, -6.33308887e-02f, -9.89246219e-02f, 3.36078629e-02f, -4.18362692e-02f,
  -1.39800876e-01f, 4.25376922e-01f, 3.09267759e-01f, -2.99560279e-01f, 1.37407631e-01f, 3.11269641e-01f, 5.07687092e-01f, 8.76372531e-02f, -2.25991175e-01f, 2.83682764e-01f,
  1.54296160e-01f, -3.84525895e-01f, -2.39924178e-01f, -2.57072803e-02f, 8.34369138e-02f, 3.07806551e-01f, 1.16165586e-01f, -1.26229435e-01f, -1.80398390e-01f, -1.05499640e-01f,
  -1.66690797e-01f, -3.29781137e-02f, -6.14165291e-02f, -2.37866133e-01f, -1.83710903e-01f, -3.19072276e-01f, 5.68263680e-02f, -4.47841808e-02f, 1.48553699e-01f, -1.38337523e-01f,
  1.27368078e-01f, 3.46244156e-01f, -2.53162980e-01f, -2.36769333e-01f, 1.17823973e-01f, -9.52466670e-03f, 4.71412055e-02f, 5.71489893e-03f, -2.80715246e-02f, 1.01399913e-01f,
  1.39940485e-01f, 1.61179632e-01f, 1.33123621e-01f, 1.18515484e-01f, 1.07014365e-01f, 5.15725836e-02f, 8.61942023e-02f, 3.80230844e-02f, 4.53809835e-02f, 9.44683999e-02f,
  -5.25764190e-02f, 4.99730296e-02f, 1.31017923e-01f, 5.07792942e-02f, 4.81417924e-02f, -2.08605677e-01f, 1.96221501e-01f, 1.77820143e-03f, 8.20353180e-02f, -1.29994750e-01f,
  -4.21773680e-02f, -3.93667594e-02f, 6.92009330e-02f, -1.16324387e-02f, -3.29336822e-02f, -4.38899919e-02f, -5.02045220e-03f, 9.17894915e-02f, 5.71054146e-02f, -7.57518485e-02f,
  -8.23804364e-02f, -9.90922470e-03f, 7.11003393e-02f, 8.40232074e-02f, -2.53852177e-03f, 2.98374612e-02f, 6.11277446e-02f, 8.97997022e-02f, 2.30228398e-02f, -8.06301646e-03f,
  -2.42969729e-02f, 4.22001630e-02f, 3.28103546e-04f, 2.89443545e-02f, 5.25456890e-02f, -5.17568514e-02f, 8.70520398e-02f, 2.06520315e-02f, -1.13672338e-01f, 8.17406252e-02f,
  -3.05542618e-01f, 2.20585421e-01f, -2.41930395e-01f, -1.16371758e-01f, 8.84717777e-02f, -9.29083005e-02f, -4.34981212e-02f, -6.55052364e-02f, 3.33030820e-02f, -4.44664359e-02f,
  1.24805510e-01f, 6.37675524e-02f, 1.05220824e-01f, 2.54154671e-02f, -1.28449515e-01f, 3.55643295e-02f, 7.99696892e-02f, -6.98660761e-02f, 3.21064936e-03f, -9.95334461e-02f,
  -1.20845262e-03f, -1.90051161e-02f, -2.22099125e-01f, -5.52536659e-02f, -1.54836476e-01f, -1.94244266e-01f, 1.24927796e-02f, -2.39022058e-02f, -6.20241137e-03f, -2.43110642e-01f,
  4.56806570e-01f, -2.01473664e-02f, 9.74554867e-02f, 1.11957029e-01f, -2.04426348e-02f, -1.23059988e-01f, -1.69529498e-01f, -5.10612614e-02f, 1.82626620e-01f, -2.17961352e-02f,
  2.01137662e-01f, 2.02711135e-01f, 1.12183325e-01f, 8.71793553e-02f, 1.30898386e-01f, -4.23751883e-02f, -6.90534785e-02f, 1.69154644e-01f, 1.58708349e-01f, 9.35362652e-02f,
  -1.13069333e-01f, 4.12015691e-02f, 1.42847039e-02f, -1.05893929e-02f, -2.60287840e-02f, 5.38205504e-02f, -4.93220501e-02f, -2.44273413e-02f, -6.84655234e-02f, -1.77558064e-02f,
  1.69930533e-01f, -3.80517021e-02f, 7.70697221e-02f, -6.39720932e-02f, 7.04858918e-03f, -3.18555497e-02f, 6.30247146e-02f, -1.64446409e-03f, -8.44272003e-02f, -8.48934129e-02f,
  -1.44945979e-01f, -8.91509466e-03f, -6.71165762e-03f, -5.92222959e-02f, -1.47444576e-01f, -8.37676302e-02f, 5.76541536e-02f, -4.04626727e-02f, -3.07334750e-03f, -2.98253018e-02f,
  4.10808437e-02f, -3.12981717e-02f, -6.25101104e-02f, -5.28993160e-02f, 1.47073548e-02f, 7.29208738e-02f, 5.23349978e-02f, 7.64450729e-02f, -4.29014862e-03f, -9.02967353e-04f,
  1.06633648e-01f, 1.69343427e-01f, 6.37834147e-02f, 6.01812964e-03f, 4.53490168e-02f, 9.33572799e-02f, 3.79084460e-02f, -2.25578062e-02f, -7.61820525e-02f, -8.06318894e-02f,
  3.79700623e-02f, -1.77866556e-02f, -1.11277439e-01f, 1.01787210e-01f, 4.75597940e-02f, 9.54947472e-02f, -8.93779248e-02f, -3.08135450e-02f, 4.96962145e-02f, -3.81771326e-02f,
  7.35262558e-02f, 3.03539857e-02f, -3.32040386e-03f, 1.11422107e-01f, 5.34435920e-02f, 1.22700661e-01f, 5.11395633e-02f, 1.50711447e-01f, 8.00340697e-02f, -6.79726899e-03f,
  -1.12702407e-01f, 1.14574470e-01f, 8.56614038e-02f, -1.63107201e-01f, -5.21421880e-02f, -3.91138829e-02f, -4.35131341e-02f, -7.92193711e-02f, -8.94392878e-02f, -3.96793298e-02f,
  -9.60771888e-02f, -2.79181544e-02f, -7.60860741e-02f, -1.01858974e-02f, -5.17079234e-03f, 8.01894534e-03f, -3.96345146e-02f, -4.20845896e-02f, 1.45923793e-02f, -3.01811118e-02f,
  -2.40949541e-02f, 5.05243391e-02f, 3.02757937e-02f, -1.78847499e-02f, -1.44119160e-02f, -6.46616369e-02f, 6.68640509e-02f, -1.36771128e-01f, 4.29962091e-02f, -1.05808727e-01f,
  1.09933995e-01f, -1.33771464e-01f, 3.08707058e-02f, -4.63458523e-02f, -1.89440802e-01f, -1.83470584e-02f, -1.91801518e-01f, -7.98477232e-02f, -1.19345546e-01f, -2.43631154e-01f,
  -4.75047389e-03f, 3.96719307e-01f, 1.27386183e-01f, 2.31164634e-01f, 1.08184837e-01f, -2.69648135e-01f, -3.24316800e-01f, 2.42416173e-01f, 4.03175980e-01f, 4.53397259e-03f,
  -1.35016637e-02f, -3.93625498e-02f, -3.33923250e-02f, 3.27495113e-02f, -9.20098051e-02f, 1.23873867e-01f, -1.74019501e-01f, -1.43380597e-01f, -9.63511765e-02f, -3.11834127e-01f,
  3.53742272e-01f, -6.74403906e-02f, -3.07582645e-03f, -8.42940584e-02f, -5.71284480e-02f, 9.06523764e-02f, -9.13345721e-03f, -4.59122472e-02f, 1.40497815e-02f, -2.31004562e-02f,
  1.65457688e-02f, -1.46863222e-01f, 5.61621971e-02f, 4.84685861e-02f, -1.11823350e-01f, 8.07767808e-02f, -8.39001834e-02f, -1.19115710e-01f, -7.77378902e-02f, 6.14461973e-02f,
  -6.06290661e-02f, -9.63485241e-03f, 1.31835267e-01f, 4.02649352e-03f, -8.50236695e-03f, 1.02138463e-02f, -2.32859571e-02f, 4.69965022e-03f, 8.30362961e-02f, -1.16980091e-01f,
  3.44160758e-02f, 4.68560532e-02f, 2.36734580e-02f, 1.07013872e-02f, 3.43331136e-02f, 4.05690745e-02f, 6.62463382e-02f, -1.07535854e-01f, 7.59658590e-02f, -1.88227668e-02f,
  1.96985677e-02f, -2.66746115e-02f, -2.19790321e-02f, -7.10601211e-02f, -6.34546280e-02f, 1.86361484e-02f, -2.36176718e-02f, 1.79602820e-02f, -1.03139179e-02f, 6.44503087e-02f,
  7.05383494e-02f, 5.29189520e-02f, -4.66066506e-03f, -4.31477278e-02f, -8.41961130e-02f, -5.55758663e-02f, -9.46722552e-02f, -3.02452389e-02f, 6.68976754e-02f, -5.18851057e-02f,
  2.61855155e-01f, 5.39612696e-02f, -2.26677656e-02f, 7.62658659e-03f, -9.12450999e-02f, -9.57908630e-02f, -3.22796181e-02f, 4.86392416e-02f, 3.69263589e-02f, 9.38390195e-02f,
  8.76864605e-03f, -1.17131412e-01f, -1.87761318e-02f, -9.31834057e-02f, -2.13822834e-02f, -4.02709767e-02f, -5.38275875e-02f, 6.48801029e-02f, -6.67584464e-02f, 9.18574922e-04f,
  -1.05851151e-01f, -1.04859315e-01f, 1.79566786e-01f, 5.16514368e-02f, 4.72161062e-02f, 1.76141858e-01f, 1.24654070e-01f, 3.86289693e-02f, 7.81474710e-02f, -1.49538070e-01f,
  1.04157135e-01f, -1.02368899e-01f, 3.69855687e-02f, -2.71036159e-02f, 2.91222055e-02f, 1.47977725e-01f, 3.69016618e-01f, 5.54551482e-02f, -2.00733036e-01f, 1.17933460e-01f,
  -2.67737266e-02f, -3.04122657e-01f, -3.50265026e-01f, -2.26158813e-01f, -6.33106306e-02f, 2.31534928e-01f, 1.63169295e-01f, -8.34181160e-02f, -7.45301321e-02f, 7.23505989e-02f,
  -5.19744381e-02f, 1.00215105e-02f, 7.11926073e-02f, -7.23126009e-02f, 6.26226515e-03f, -1.89193532e-01f, 4.72030044e-02f, -1.54409736e-01f, -7.05922469e-02f, -2.62257725e-01f,
  1.64494023e-01f, -8.43037814e-02f, -3.01168468e-02f, -5.36026731e-02f, 2.64070090e-02f, -1.30430818e-01f, -1.14427187e-01f, -1.35482922e-01f, -7.82964528e-02f, -5.18156029e-03f,
  -8.77672210e-02f, 8.35812371e-03f, 3.93357128e-02f, -1.28277883e-01f, 1.28730312e-01f, -1.83247831e-02f, -4.71804775e-02f, -6.68936670e-02f, -1.16486877e-01f, -8.47194120e-02f,
  -1.63066775e-01f, -1.48111368e-02f, 7.68718794e-02f, -6.82204915e-03f, -8.96254107e-02f, -1.49339348e-01f, 2.58476082e-02f, -6.97211400e-02f, -5.77041283e-02f, 9.32811573e-02f,
  3.43932882e-02f, -1.93543043e-02f, 3.86336967e-02f, 1.24386497e-01f, 1.18670747e-01f, 2.34660935e-02f, 5.36951534e-02f, -1.39132096e-02f, -4.47054915e-02f, 3.85442749e-02f,
  -1.51027635e-01f, 1.03074759e-01f, 8.72786269e-02f, 2.24812664e-02f, -1.06484052e-02f, -6.41106740e-02f, 5.31603433e-02f, -4.69781533e-02f, -2.59570163e-02f, 8.76301620e-03f,
  -2.58049518e-02f, -5.36454357e-02f, 3.66388597e-02f, -4.96565737e-02f, -2.22603157e-02f, -6.61074668e-02f, 1.97532307e-02f, -3.22781093e-02f, -3.50662619e-02f, -4.27085953e-03f,
  1.12742677e-01f, -1.74493238e-01f, 2.29806304e-02f, -7.61180446e-02f, -3.73652093e-02f, -1.90859333e-01f, 7.94967413e-02f, 4.82135080e-02f, 6.61443844e-02f, 2.31514405e-02f,
  -9.20098051e-02f, 9.95201990e-02f, -5.39927697e-03f, 4.62977663e-02f, 2.29228705e-01f, 3.00968904e-02f, 3.43045928e-02f, 3.73208933e-02f, 1.07359961e-02f, 7.23039825e-03f,
  -3.73623371e-02f, 9.30617228e-02f, 1.57129034e-01f, -3.89775448e-02f, 5.15347347e-02f, 2.00754747e-01f, 6.93243220e-02f, 5.00135981e-02f, 1.18153796e-01f, 3.88637066e-01f,
  1.16718650e-01f, 1.38325527e-01f, 4.26911451e-02f, 1.29982144e-01f, 2.95550823e-01f, 3.19315642e-01f, 4.09691215e-01f, 1.35550946e-01f, 5.17343879e-02f, 1.72302872e-01f,
  1.23269640e-01f, -2.43303314e-01f, -1.76968634e-01f, -3.14103484e-01f, -2.11763218e-01f, 1.16046993e-02f, 7.28945285e-02f, -2.14382455e-01f, -7.92722106e-02f, -1.74175259e-02f,
  2.14953184e-01f, 2.59857893e-01f, 7.68152848e-02f, -2.85917576e-02f, -7.80128932e-04f, 6.88974261e-02f, 9.01084691e-02f, 1.44019619e-01f, -7.56067857e-02f, -1.84847966e-01f,
  -3.15081090e-01f, 1.23570159e-01f, -8.86885300e-02f, -4.12395317e-03f, 8.69731829e-02f, -7.60745630e-02f, 2.07245648e-02f, -7.48144463e-02f, -1.09248802e-01f, -1.68312177e-01f,
  1.84038840e-02f, 2.86853649e-02f, -1.93241060e-01f, -1.13849550e-01f, 1.09308422e-01f, 2.50480194e-02f, -7.76356924e-03f, -2.35905528e-01f, -3.63002479e-01f, -1.46689400e-01f,
  -4.14751954e-02f, 1.90586016e-01f, 1.59864947e-01f, 1.28472541e-02f, -2.21872672e-01f, 1.11745251e-02f, 2.02515461e-02f, -1.53525904e-01f, -4.52647470e-02f, -1.42251581e-01f,
  -9.42784175e-02f, -1.07581817e-01f, 8.68077129e-02f, 1.19151130e-01f, 3.27001438e-02f, -1.73202250e-02f, -1.52884349e-01f, -2.58905198e-02f, -1.08799756e-01f, 3.19896378e-02f,
  -6.38305396e-02f, -4.61581014e-02f, -8.87661502e-02f, -3.65547016e-02f, -5.32002300e-02f, 1.63840801e-02f, 6.95133284e-02f, 5.55257462e-02f, 3.67875444e-03f, 1.46658704e-01f,
  8.49249214e-02f, -1.37257516e-01f, -4.38600630e-02f, 3.51154469e-02f, 9.53914151e-02f, -1.11936204e-01f, 8.02908558e-03f, 5.91347367e-02f, 1.74069367e-02f, -4.85920114e-03f,
  6.40492737e-02f, 1.40525490e-01f, -1.02107555e-01f, 9.71031934e-02f, 4.99537773e-02f, -1.26431182e-01f, 6.71192035e-02f, -3.89092676e-02f, -6.99175596e-02f, -2.46248096e-01f,
  -7.03989491e-02f, -1.92439750e-01f, -5.29339239e-02f, 3.77208786e-03f, 2.19988301e-02f, -7.12529104e-03f, 1.39113471e-01f, 4.45588231e-02f, -1.21931173e-01f, -3.74388471e-02f,
  7.57124182e-03f, 6.78304732e-02f, 1.01141296e-01f, -6.83505982e-02f, -1.32215157e-01f, 5.67893274e-02f, 2.24832296e-02f, 5.98159991e-02f, 1.16242759e-01f, 2.81381756e-01f,
  4.13952231e-01f, 5.83872020e-01f, 6.29543066e-02f, -1.52356774e-01f, -1.67305171e-01f, -8.54454115e-02f, 2.79907644e-01f, 7.85915405e-02f, -4.59386185e-02f, 1.06866740e-01f,
  -6.41748756e-02f, -2.91118741e-01f, -7.86476359e-02f, -4.61266637e-02f, 4.07749526e-02f, 2.07280293e-01f, 1.36345044e-01f, -9.69406497e-03f, -1.88754737e-01f, -2.74511632e-02f,
  -1.29820839e-01f, 6.86785877e-02f, 1.28869310e-01f, 1.30970525e-02f, 9.62437913e-02f, -3.89098153e-02f, 1.31393328e-01f, 2.47659720e-02f, 1.18976988e-01f, 1.98080286e-01f,
  -8.62616487e-03f, 3.81604701e-01f, -4.53673065e-01f, -3.11263483e-02f, 6.42918423e-02f, -5.96638536e-03f, -1.26345664e-01f, 7.00220391e-02f, -6.54694885e-02f, -1.30022345e-02f,
  7.25497529e-02f, -5.79799190e-02f, -1.43133581e-01f, -1.04455784e-01f, -1.72818433e-02f, -7.97259808e-02f, 8.69228393e-02f, 1.26086369e-01f, 6.44640326e-02f, 9.86826420e-02f,
  1.25270262e-02f, -7.42298365e-02f, 5.73877878e-02f, -1.72694698e-02f, -2.99587240e-03f, -2.04180434e-01f, -3.98014151e-02f, -5.56104146e-02f, 3.75092290e-02f, 6.69853613e-02f,
  -2.31857970e-01f, 6.89292848e-02f, 5.10530770e-02f, -1.13672167e-01f, -1.75384372e-01f, -1.15119442e-01f, 2.49885023e-03f, -1.51718184e-01f, -9.54540521e-02f, -3.43832973e-04f,
  -1.18229486e-01f, -8.57215971e-02f, -1.14003226e-01f, 7.55116791e-02f, -1.44907072e-01f, -8.91865522e-04f, -8.42173174e-02f, -4.18451130e-02f, -1.09292984e-01f, -2.82688271e-02f,
  -1.29708901e-01f, 1.17865251e-02f, 3.74216847e-02f, -4.00364883e-02f, -8.24714154e-02f, -1.65997490e-01f, -9.49115008e-02f, -2.03266386e-02f, -1.74354371e-02f, -1.74525678e-02f,
  -1.71372861e-01f, -3.07936013e-01f, -1.39215916e-01f, 6.58565536e-02f, 1.10317357e-01f, 1.07888453e-01f, 6.07829317e-02f, -3.47295031e-03f, 1.73517670e-02f, 2.67306548e-02f,
  1.68473691e-01f, 2.03686976e-03f, 3.68146854e-03f, 8.65498185e-02f, -8.01500827e-02f, 1.03428345e-02f, -5.45675643e-02f, 5.23107462e-02f, 1.32917222e-02f, 8.42098594e-02f,
  -1.37811480e-02f, -1.72246844e-01f, -1.98556304e-01f, -1.36849403e-01f, -1.03926644e-01f, -3.01047206e-01f, -1.22519411e-01f, -5.28989695e-02f, -1.17215522e-01f, -2.36175563e-02f,
  -4.94293831e-02f, 3.96973699e-01f, -1.53133228e-01f, 6.21577762e-02f, -1.23507148e-02f, 1.39744684e-01f, 4.02894616e-01f, 1.88345760e-01f, -1.56458728e-02f, 4.88526933e-02f,
  -1.22055918e-01f, -1.83705121e-01f, -1.67352781e-01f, -1.77239895e-01f, -3.33768763e-02f, 1.66353241e-01f, 2.17826217e-01f, -1.26942724e-01f, -1.80897295e-01f, -1.73181351e-02f,
  2.91402657e-02f, 1.75609499e-01f, -8.71251151e-02f, 1.09402156e-02f, 1.45154864e-01f, -4.78639174e-03f, 1.37812003e-01f, 7.68134221e-02f, 5.70113100e-02f, -4.22305912e-02f,
  -3.84495884e-01f, -6.09404743e-02f, -1.07792504e-01f, 7.64371157e-02f, -1.57204762e-01f, -1.90259069e-01f, -1.76936448e-01f, -1.70670316e-01f, -2.30170310e-01f, -9.60925296e-02f,
  -1.57613039e-01f, -4.83242571e-02f, -1.86172485e-01f, -9.09000486e-02f, -3.18763927e-02f, -6.79158196e-02f, -6.56390190e-03f, -2.99381628e-03f, -2.02673391e-01f, -1.23470172e-01f,
  4.57768142e-02f, 5.83960935e-02f, -7.36877089e-03f, 1.26481503e-01f, -1.81737021e-01f, -2.52057482e-02f, -5.27650043e-02f, -9.98311788e-02f, -5.05308919e-02f, 7.70817846e-02f,
  -5.01343794e-02f, 1.06852852e-01f, 7.55345076e-02f, 1.51299834e-01f, 9.32217389e-02f, 3.55922058e-02f, -7.46144280e-02f, 5.10744378e-02f, 3.25204991e-02f, -9.38976258e-02f,
  -2.25106671e-01f, 5.08346632e-02f, -9.65023637e-02f, -1.05156332e-01f, -2.91608442e-02f, 8.91113561e-03f, -1.02635995e-02f, 1.11229569e-01f, -1.27193332e-02f, 2.64928881e-02f,
  7.78433681e-02f, 6.14041835e-02f, 3.91112678e-02f, 2.18701623e-02f, -8.87627527e-03f, -3.61100435e-02f, -4.34312969e-02f, 8.97725224e-02f, 9.83030163e-03f, -2.65190881e-02f,
  4.36817063e-03f, -1.87093075e-02f, 9.00575966e-02f, 8.46474692e-02f, -1.08049046e-02f, -7.53445476e-02f, -1.07807349e-02f, -5.44563159e-02f, 1.36718052e-02f, -5.83419986e-02f,
  -1.03671275e-01f, -6.49666600e-03f, -8.80068317e-02f, -2.83359345e-02f, -1.69456810e-01f, -3.94194610e-02f, 3.09880376e-02f, 1.28156751e-01f, -5.34383543e-02f, -3.13034840e-02f,
  2.04214990e-01f, 2.13555753e-01f, 1.45144667e-02f, 1.24962069e-01f, 1.80963543e-03f, 7.72823915e-02f, 5.41805327e-02f, 2.75386777e-02f, 1.23604080e-02f, 1.98832244e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 40)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 40;
const float L0_fan_Bp_bar_data[] = {
  1.50545523e-01f, 2.16368400e-02f, 1.73015803e-01f, 1.46996677e-01f, 1.98126614e-01f, 2.26182863e-01f, 1.40460938e-01f, -2.33857512e-01f, 3.46298784e-01f, 2.12924302e-01f,
  1.71557978e-01f, 2.83888251e-01f, 9.98562798e-02f, 5.68896413e-01f, 3.44697647e-02f, 2.85438389e-01f, 2.37404674e-01f, 1.27025530e-01f, -9.27415267e-02f, 1.26327187e-01f,
  1.50325388e-01f, -1.32805526e-01f, 2.04755172e-01f, -1.55400410e-01f, 9.03240219e-02f, 1.08609490e-01f, 2.35790387e-01f, 1.43860087e-01f, 8.15243199e-02f, 8.95257369e-02f,
  1.65222988e-01f, 2.14623854e-01f, 1.23294033e-01f, 2.02037841e-01f, 3.83949876e-02f, 5.33680767e-02f, 2.03338757e-01f, 2.91117072e-01f, 2.30590343e-01f, 1.69928625e-01f
};

// L1_fan_Wp (Shape: 12 x 64)
const int L1_fan_Wp_rows = 12;
const int L1_fan_Wp_cols = 64;
const float L1_fan_Wp_data[] = {
  -2.45355461e-02f, 8.62565450e-03f, 2.28550956e-02f, 9.48859379e-03f, -1.34399831e-02f, -3.65016721e-02f, -7.14664981e-02f, -1.56807695e-02f, 3.11687030e-02f, -1.42317787e-01f,
  4.10448238e-02f, -3.64383794e-02f, -3.43277343e-02f, -6.35353923e-02f, 1.25418425e-01f, -7.46380389e-02f, 1.53355449e-01f, -1.67645454e-01f, -1.54257774e-01f, 6.48261905e-02f,
  6.11009113e-02f, -3.44978785e-03f, 4.37629633e-02f, 7.47786788e-03f, 1.57911509e-01f, -1.17700666e-01f, -1.08339414e-01f, -3.48352753e-02f, 1.13111369e-01f, -9.14545134e-02f,
  1.16404906e-01f, -3.93722467e-02f, -1.28275165e-02f, 1.24615170e-01f, 6.69562221e-02f, 2.42712304e-01f, 1.39221614e-02f, -1.60540730e-01f, 2.72523873e-02f, -1.43241107e-01f,
  3.51024657e-01f, -3.03334882e-03f, -1.39425918e-01f, -7.53318071e-02f, -1.22187145e-01f, -5.33025414e-02f, -4.73162532e-03f, -3.61129554e-04f, 6.77668527e-02f, -4.14221883e-02f,
  -2.13067129e-01f, -1.31538510e-01f, 8.24613646e-02f, -1.71176419e-01f, -1.13723084e-01f, -5.09556606e-02f, -2.07957372e-01f, -6.74001873e-02f, -8.85036662e-02f, -2.50103325e-02f,
  -9.03333798e-02f, -2.53380239e-01f, -1.91596299e-01f, 4.62776236e-03f, 8.57674703e-02f, -2.73134131e-02f, 7.12299347e-02f, -5.42125944e-03f, 7.80845806e-02f, 1.60814852e-01f,
  1.40822873e-01f, -6.81828751e-05f, -6.62540719e-02f, 5.87359108e-02f, 1.59573287e-01f, 2.26199746e-01f, 4.13072156e-03f, 1.29547730e-01f, 4.77851592e-02f, 5.73583208e-02f,
  -8.50046501e-02f, -5.95953055e-02f, -2.45192260e-01f, -7.92755745e-03f, 4.46660742e-02f, -1.98502336e-02f, -4.93049026e-02f, 6.82605803e-02f, -2.14564100e-01f, -2.59999484e-01f,
  1.95461258e-01f, -1.33622333e-01f, -2.91425735e-01f, -6.44865632e-02f, -9.88450553e-03f, 4.46866713e-02f, -1.30484283e-01f, -1.28489092e-01f, 5.59087144e-03f, 2.28599191e-01f,
  -1.79480150e-01f, 7.61196613e-02f, -1.84440479e-01f, 4.35492992e-02f, 2.11418375e-01f, -4.22415659e-02f, -4.08169851e-02f, 1.04366779e-01f, 1.25969931e-01f, 3.67801897e-02f,
  -9.84556824e-02f, 5.27477711e-02f, -1.77527875e-01f, 1.08295426e-01f, 1.12314716e-01f, 3.93454581e-02f, 1.19572595e-01f, -1.61405161e-01f, -3.50625999e-02f, -5.07198721e-02f,
  -1.57292590e-01f, 1.51758984e-01f, 7.82446116e-02f, 1.55039668e-01f, -6.13608249e-02f, -2.68236727e-01f, 2.01037489e-02f, 7.02568144e-02f, -1.15360029e-01f, 8.08930770e-03f,
  -1.04778685e-01f, -6.57021254e-02f, 5.89193357e-03f, -1.36946231e-01f, -4.26321067e-02f, 9.65505093e-02f, 2.43993383e-02f, -5.21981083e-02f, -3.56418379e-02f, -1.42246142e-01f,
  1.69238506e-03f, 4.51666676e-02f, 1.50034074e-02f, -3.56259532e-02f, -1.07183568e-01f, -1.18353233e-01f, 2.10215643e-01f, 1.08792834e-01f, -1.34239867e-02f, -1.53551385e-01f,
  2.06493407e-01f, -7.99428970e-02f, -9.14353803e-02f, 4.34013456e-02f, 1.69878572e-01f, 1.10746495e-01f, -4.86582667e-02f, 9.78191867e-02f, 9.06220600e-02f, 9.77955684e-02f,
  -1.79897249e-02f, -1.02510042e-01f, -4.86142151e-02f, -8.96904059e-03f, -9.44270194e-02f, -2.08381712e-01f, -1.07529268e-01f, 1.33086875e-01f, -5.17165959e-02f, 3.66272740e-02f,
  1.32266402e-01f, 6.01376174e-03f, -8.27688947e-02f, 2.71344818e-02f, 9.69060436e-02f, 1.49612159e-01f, 5.99565357e-02f, -6.55260533e-02f, 1.61726158e-02f, 9.50663313e-02f,
  9.97875854e-02f, 1.46255903e-02f, 1.82734147e-01f, 1.78278789e-01f, 5.60804084e-02f, 1.77315533e-01f, -5.57764731e-02f, -3.31928693e-02f, 7.63337687e-02f, 3.25094573e-02f,
  1.87012944e-02f, 3.28545779e-01f, -4.15948778e-03f, 3.26316580e-02f, 4.65086475e-02f, -1.04677100e-02f, 5.09180762e-02f, -1.80250276e-02f, -2.04673707e-02f, -1.13851782e-02f,
  -8.55474398e-02f, 3.72202322e-03f, -1.15205258e-01f, -1.07661009e-01f, -5.20716086e-02f, -1.41667053e-01f, 8.95824954e-02f, -1.94249884e-03f, -1.04037799e-01f, 7.14098737e-02f,
  -8.71478021e-03f, 1.81104645e-01f, -1.89513732e-02f, 1.19318776e-01f, -7.13494271e-02f, -1.89774130e-02f, 2.73351401e-01f, -1.87796667e-01f, -2.15642363e-01f, -5.86755425e-02f,
  9.57165286e-03f, 1.06381804e-01f, 1.95237651e-01f, 8.06264486e-03f, -1.29671082e-01f, 1.81795433e-01f, -6.89945137e-03f, 9.24265459e-02f, -1.43962234e-01f, -2.74151772e-01f,
  -2.99372263e-02f, -9.36313868e-02f, 1.34631306e-01f, -3.99781018e-03f, 1.67388156e-01f, 2.97460221e-02f, -9.29130018e-02f, 8.38048831e-02f, -1.29508495e-01f, -1.12494744e-01f,
  6.32761419e-02f, 5.10410368e-02f, 7.15516806e-02f, 1.21956140e-01f, 9.40753031e-04f, 7.35678747e-02f, -9.09743160e-02f, -1.35175705e-01f, -2.69161165e-02f, -3.46508354e-01f,
  2.83862222e-02f, 1.65780187e-01f, 1.25201330e-01f, 5.70279509e-02f, -1.90672725e-01f, -1.59249052e-01f, 3.14461887e-02f, 6.44113123e-02f, -7.82191604e-02f, 5.64927645e-02f,
  -8.65773708e-02f, 7.24389553e-02f, -1.32239521e-01f, -3.20739225e-02f, 4.40081395e-03f, 5.96928149e-02f, -9.40149203e-02f, 5.44257537e-02f, 3.74095105e-02f, -5.61072007e-02f,
  -2.55773868e-02f, -1.24176852e-01f, -5.21441922e-02f, -1.60763055e-01f, 1.83568686e-01f, -1.29414275e-01f, -5.32454401e-02f, 2.52145797e-01f, -8.84709060e-02f, 4.07860167e-02f,
  6.57033324e-02f, 2.63754845e-01f, 1.89490572e-01f, -1.95972368e-01f, -3.55111808e-01f, -3.41791771e-02f, -1.66907489e-01f, 2.30459958e-01f, 2.84931660e-01f, 1.12609722e-01f,
  -1.67544857e-01f, -2.49768287e-01f, -2.35850736e-01f, 8.09578598e-02f, -1.72198266e-01f, -2.24975497e-01f, 7.81584233e-02f, 2.26073697e-01f, -1.16939386e-02f, 3.52746129e-01f,
  -3.03223103e-01f, 9.24119279e-02f, 1.20823281e-02f, 1.76536709e-01f, 4.51733097e-02f, 1.36766911e-01f, 6.52745962e-02f, -4.12116051e-02f, 9.21102837e-02f, 3.49472277e-02f,
  -8.66861939e-02f, 1.21754423e-01f, -2.74103880e-01f, -2.78988540e-01f, 3.63564752e-02f, 4.68539335e-02f, -8.12280551e-02f, -5.40903769e-02f, -8.92528445e-02f, -1.64420024e-01f,
  4.77846451e-02f, 9.48561728e-02f, 1.37543485e-01f, -3.71803381e-02f, -1.10472091e-01f, -1.56335846e-01f, 2.36385297e-02f, 3.13936472e-02f, 5.40562645e-02f, -9.43741128e-02f,
  -2.82304194e-02f, 2.97405627e-02f, -1.16188027e-01f, -1.43860698e-01f, 2.78390525e-03f, -3.70196067e-02f, 2.89817620e-02f, 8.38186592e-02f, -7.84218758e-02f, 2.08760463e-02f,
  -2.84440126e-02f, 5.56183048e-02f, -1.00878598e-02f, 9.25700516e-02f, -1.18005924e-01f, 6.56837896e-02f, 1.98158085e-01f, 1.32869676e-01f, 1.36385262e-01f, 9.69374180e-03f,
  -1.84009206e-02f, -1.65157512e-01f, -7.68721104e-02f, 7.00176433e-02f, 1.52240872e-01f, 2.10164040e-02f, 9.50713977e-02f, 4.15241942e-02f, 2.15619609e-01f, -1.76204979e-01f,
  -1.41770408e-01f, 1.52391382e-04f, -8.10289979e-02f, -1.99921913e-02f, 1.04838401e-01f, -8.02073255e-02f, -8.11635330e-02f, -5.23886718e-02f, 6.91228509e-02f, -2.25205123e-02f,
  1.31150782e-02f, -2.13220045e-02f, 2.05594487e-02f, -9.77372006e-02f, 9.36948732e-02f, -2.16888219e-01f, 1.53701186e-01f, 3.97611931e-02f, -6.07266426e-02f, -1.76537126e-01f,
  -9.35289934e-02f, 3.70241493e-01f, -6.99438676e-02f, 1.08033165e-01f, -1.17970459e-01f, -8.26439112e-02f, 1.77711528e-02f, 1.26767591e-01f, 1.01531520e-01f, -7.63662020e-03f,
  7.71918371e-02f, 4.17619795e-02f, -7.10787028e-02f, 3.85667868e-02f, -2.57375203e-02f, 2.09715571e-02f, -4.15936895e-02f, 9.54197794e-02f, -5.84539659e-02f, 1.24472111e-01f,
  -1.71040282e-01f, -2.11877152e-02f, 1.54564977e-01f, -5.25998846e-02f, -9.54806618e-03f, -9.55229402e-02f, -9.90376845e-02f, 1.62162900e-01f, -1.31292403e-01f, -1.82088763e-01f,
  -1.31757155e-01f, 1.08244367e-01f, -1.42950770e-02f, -1.25980219e-02f, 1.43883124e-01f, -2.25662887e-02f, 4.40699682e-02f, 1.36916593e-01f, -5.66275492e-02f, -6.52356073e-02f,
  -7.16338828e-02f, 3.98400277e-02f, -2.21143186e-01f, 1.66057959e-01f, -5.63550219e-02f, 9.29821059e-02f, 1.84600979e-01f, -4.13934812e-02f, 1.05538359e-02f, 5.39211743e-02f,
  7.76457563e-02f, 5.16139604e-02f, 1.07132848e-02f, 1.47907306e-02f, -1.18923835e-01f, 2.37414986e-02f, 1.88653618e-02f, -2.15165362e-01f, -1.08165286e-01f, 9.16881636e-02f,
  2.39429772e-02f, 2.64022648e-01f, -2.20071942e-01f, -5.95763363e-02f, 1.77059099e-01f, 8.83179381e-02f, 1.35306731e-01f, -1.18474096e-01f, 1.04003169e-01f, 1.48419142e-01f,
  -8.33357349e-02f, -5.70486076e-02f, -1.06262475e-01f, -1.14160001e-01f, 2.83136684e-03f, 1.68627501e-01f, 3.33090760e-02f, 7.73272365e-02f, 8.61631930e-02f, 8.10339861e-03f,
  -2.36686487e-02f, 1.46186769e-01f, -7.05807880e-02f, 1.33388460e-01f, -2.45994329e-01f, 3.07849441e-02f, 3.95025201e-02f, -2.18023341e-02f, -9.26801041e-02f, -8.72177258e-02f,
  6.00489266e-02f, 9.54029933e-02f, -3.24806005e-01f, -8.50904509e-02f, 1.14246443e-01f, 1.06262110e-01f, -5.83021380e-02f, 8.48854557e-02f, -1.99730128e-01f, -8.68999511e-02f,
  -2.26926833e-01f, -1.32415732e-02f, -4.77653444e-02f, 1.89054132e-01f, -1.41995922e-02f, 2.11974397e-01f, -1.64736528e-02f, 6.63443133e-02f, -6.05294518e-02f, 1.11165248e-01f,
  1.47835925e-01f, -1.07001834e-01f, -2.73432508e-02f, 1.28814772e-01f, -1.91555813e-01f, 6.01380542e-02f, -1.19710416e-01f, -1.49955094e-01f, 1.31908074e-01f, 5.25906608e-02f,
  2.10212901e-01f, -2.79667974e-01f, 4.70693298e-02f, -3.53534706e-02f, 1.46078616e-01f, 2.83685952e-01f, -1.90356001e-01f, -1.29833996e-01f, 2.17709750e-01f, 1.20218925e-01f,
  1.99810311e-01f, 2.08285227e-01f, 1.20216012e-01f, 1.40414163e-01f, 1.46164104e-01f, -7.13187456e-02f, 7.61471689e-02f, 1.06743768e-01f, 9.54775959e-02f, 8.98207501e-02f,
  1.92443326e-01f, 1.75270453e-01f, 1.54567137e-01f, -5.56403911e-03f, 5.55456094e-02f, -8.52928385e-02f, -1.57994181e-01f, -1.48755878e-01f, 2.48929903e-01f, -6.38929978e-02f,
  -4.94963005e-02f, -1.24149442e-01f, -1.13852315e-01f, 1.45753726e-01f, -5.52816913e-02f, -1.09667942e-01f, 3.41248125e-01f, 1.05419690e-02f, -1.00962311e-01f, -1.99346259e-01f,
  9.27783549e-02f, -9.87172127e-02f, 1.08850382e-01f, 1.61129460e-02f, 1.17993310e-01f, 2.42151439e-01f, 8.59402120e-02f, 1.04625449e-01f, 1.51306927e-01f, 3.25208455e-02f,
  1.49367556e-01f, -1.90202504e-01f, 2.84002330e-02f, -3.86306532e-02f, -9.20185223e-02f, -5.35223931e-02f, 9.32777673e-02f, -1.39630893e-02f, -5.30049987e-02f, 8.93779546e-02f,
  6.60786256e-02f, 1.12254724e-01f, 1.41925037e-01f, 1.05079107e-01f, -1.65132016e-01f, 4.51427996e-02f, 4.88508865e-02f, -8.85447208e-03f, -6.37788922e-02f, -2.57418573e-01f,
  -3.51615883e-02f, 1.02422275e-01f, -5.72219715e-02f, 6.36364426e-03f, -2.93906510e-01f, -1.23242475e-01f, 1.17621096e-02f, -2.08027139e-02f, -1.67588261e-03f, 4.46649268e-02f,
  -8.93329177e-03f, 2.10211590e-01f, 5.49843311e-02f, -7.73375928e-02f, -4.57447991e-02f, -5.61140105e-02f, 4.68490906e-02f, 1.07379124e-01f, 1.03148162e-01f, -4.76308540e-03f,
  2.59084208e-03f, 1.61692910e-02f, 4.66746502e-02f, 4.82248627e-02f, 3.52225870e-01f, -2.64310855e-02f, 8.42119008e-02f, -1.26002908e-01f, 2.25553632e-01f, -1.16561718e-01f,
  -2.24913210e-02f, 2.64228657e-02f, -3.13556083e-02f, 1.97059825e-01f, 2.12721154e-02f, -2.86507420e-02f, -2.01768391e-02f, 9.36855674e-02f, 2.91894376e-01f, -1.41776010e-01f,
  -1.22479506e-01f, 7.85039738e-02f, -1.67009309e-02f, 1.59707537e-03f, -7.19118416e-02f, 3.08469445e-01f, -2.51082063e-01f, -3.23365837e-01f, 8.41397792e-02f, -1.40124187e-01f,
  -1.74785957e-01f, -2.91021496e-01f, 2.94106573e-01f, 6.13218732e-02f, -4.73656654e-02f, -4.65912744e-02f, -2.23287895e-01f, -7.82482922e-02f, -7.69067509e-03f, -1.38590440e-01f,
  8.91773328e-02f, 3.19417000e-01f, -1.29055828e-01f, 1.79019317e-01f, -8.25372040e-02f, -1.84008837e-01f, -3.51172090e-02f, -4.90866788e-02f, 2.13532835e-01f, 1.85176417e-01f,
  -8.04753229e-03f, 1.11735538e-01f, -3.37949917e-02f, -6.44598827e-02f, 8.19491781e-03f, -7.14338049e-02f, -1.05600832e-02f, -2.42181093e-01f, 6.22617379e-02f, -2.13127166e-01f,
  -1.16040349e-01f, 3.43961567e-02f, -2.65173544e-03f, -1.51494324e-01f, 8.03991854e-02f, -6.82151169e-02f, 3.51117402e-02f, -8.40612799e-02f, 6.52861455e-03f, 6.73127025e-02f,
  -1.15332436e-02f, -4.78969812e-02f, 1.62462994e-01f, -1.34097725e-01f, -7.80000016e-02f, 2.49911904e-01f, -5.85068911e-02f, -5.53337671e-02f, 1.18795574e-01f, -6.07631542e-02f,
  1.05211504e-01f, -2.01926559e-01f, 2.10264921e-01f, -1.45232245e-01f, 1.49772152e-01f, 3.48309651e-02f, 2.74056941e-01f, -1.51126266e-01f, 1.49917617e-01f, -1.96838051e-01f,
  -1.64305307e-02f, -2.48111978e-01f, -1.06575057e-01f, -9.00177732e-02f, 1.81701928e-01f, -1.48707673e-01f, 3.90764773e-02f, -5.29357567e-02f, 1.21982619e-02f, -1.54846475e-01f,
  4.29123864e-02f, 5.85133135e-02f, -1.00525238e-01f, -5.46486080e-02f, 1.31733060e-01f, -8.70854035e-02f, 7.16659129e-02f, -1.52171895e-01f, 6.09277412e-02f, 1.59762788e-03f,
  -1.15364820e-01f, 1.20005205e-01f, -4.17079665e-02f, -3.80657651e-02f, 2.21914519e-02f, 5.02960272e-02f, 3.80300954e-02f, 5.07829897e-02f, -1.07871987e-01f, -5.58193140e-02f,
  1.09098554e-01f, 1.36889696e-01f, 3.55565846e-02f, -4.36092950e-02f, 1.11164793e-01f, 2.52182912e-02f, 1.15924940e-01f, 1.60482138e-01f, 5.83746247e-02f, 3.87176722e-02f,
  -1.36320606e-01f, 2.09604762e-02f, 1.19078368e-01f, 2.41737776e-02f, -2.96962671e-02f, -1.00620605e-01f, 2.23466322e-01f, -2.06327010e-02f, -1.78796396e-01f, -2.64840387e-02f,
  2.40926430e-01f, 3.15799266e-01f, -1.49940699e-01f, -1.19030073e-01f, -5.97357415e-02f, 2.17970442e-02f, 4.02116664e-02f, 9.17288661e-02f, -2.02693924e-01f, 1.57621577e-01f,
  2.72971336e-02f, 1.37854114e-01f, -1.04950257e-01f, 2.55793035e-01f, -2.74876431e-02f, -2.50047445e-03f, -9.23850238e-02f, 1.26778930e-01f, -4.60035913e-02f, -1.00736335e-01f,
  1.32937670e-01f, 6.51141331e-02f, -2.06389278e-02f, -1.69928506e-01f, 7.65185803e-02f, -1.12224907e-01f, -1.03574574e-01f, -2.71529675e-01f, 4.74639609e-02f, 2.06368104e-01f,
  2.95622926e-02f, 2.48270527e-01f, -1.75239649e-02f, -1.92217276e-01f, -1.54336095e-02f, 4.90063094e-02f, 3.03695917e-01f, 3.20831865e-01f
};

// L1_fan_Wp_bar (Shape: 40 x 64)
const int L1_fan_Wp_bar_rows = 40;
const int L1_fan_Wp_bar_cols = 64;
const float L1_fan_Wp_bar_data[] = {
  -6.98093325e-03f, 3.58638130e-02f, 1.06095271e-02f, 3.43131661e-01f, 2.89313756e-02f, 2.59351492e-01f, 5.55714825e-03f, 1.64291143e-01f, 1.98848411e-01f, 1.45692244e-01f,
  -2.38157157e-02f, 1.83782607e-01f, 1.15878262e-01f, 6.85878173e-02f, -3.80185813e-01f, 2.66636968e-01f, 3.96651089e-01f, -1.02188639e-01f, 1.63560152e-01f, -2.47918814e-01f,
  -2.03988567e-01f, 2.77046841e-02f, -1.48283795e-01f, -7.41296783e-02f, 3.63303959e-01f, -8.54515210e-02f, -8.35338831e-02f, -1.76172033e-02f, 8.94742906e-02f, 1.70639291e-01f,
  1.08238243e-01f, 6.48703873e-02f, -2.44421646e-01f, 2.00351179e-01f, -4.53263193e-01f, 1.28438443e-01f, -1.23480774e-01f, -3.57135236e-01f, 5.84145561e-02f, 4.19627339e-01f,
  -1.11389160e-01f, 5.33925705e-02f, 1.06783219e-01f, 5.49721643e-02f, -4.18665439e-01f, 7.82928802e-03f, 3.75524640e-01f, -2.62297392e-01f, 2.34144971e-01f, 2.38201823e-02f,
  1.10180667e-02f, 6.12901747e-02f, -1.74000859e-01f, 8.10158923e-02f, 3.43313999e-02f, 9.24758017e-02f, 1.28001049e-02f, -9.09872651e-02f, 1.03319073e-02f, -7.58283213e-02f,
  9.69242901e-02f, -3.38327587e-02f, 2.09834903e-01f, 1.79576665e-01f, 2.79127657e-01f, 5.83719239e-02f, 1.75245240e-01f, -7.75554404e-02f, 2.10715264e-01f, 2.39145935e-01f,
  1.46367431e-01f, 1.83944643e-01f, 2.35750332e-01f, 2.82381088e-01f, 2.14026526e-01f, 9.95982140e-02f, 4.07604054e-02f, 5.30442446e-02f, -1.07068934e-01f, -1.20305739e-01f,
  3.84797364e-01f, 9.18427259e-02f, -1.08980142e-01f, -1.49334550e-01f, -1.78054392e-01f, 3.08863908e-01f, -2.03331694e-01f, -1.39538422e-01f, 4.79842335e-01f, 3.05267751e-01f,
  2.39425123e-01f, -3.33456159e-01f, 1.82946771e-01f, -3.57081965e-02f, -1.63737666e-02f, -7.97275603e-02f, 8.30490664e-02f, 5.87266497e-02f, 1.66042279e-02f, 8.70251134e-02f,
  3.38859181e-03f, 3.70709673e-02f, 2.11773336e-01f, -1.45441741e-01f, 7.63383806e-02f, 2.22514048e-02f, -3.16794306e-01f, 2.25916117e-01f, -4.82475460e-02f, -2.41408125e-01f,
  -5.43491617e-02f, -2.44286776e-01f, 2.27826729e-01f, 7.17361644e-02f, 1.16736390e-01f, 1.88545227e-01f, 6.98883533e-02f, 3.18627715e-01f, -3.51546928e-02f, -1.02162220e-01f,
  -1.64220154e-01f, -3.87566835e-01f, 9.61149856e-02f, 2.46019214e-02f, -1.01688288e-01f, 9.60571691e-02f, -2.87093133e-01f, 1.00656912e-01f, 2.74129510e-01f, 5.61448894e-02f,
  1.71540946e-01f, 1.47380888e-01f, 2.64713198e-01f, 1.32988304e-01f, 1.67796448e-01f, 1.80414945e-01f, -1.03974473e-02f, 2.54629284e-01f, 1.69916853e-01f, 5.28364927e-02f,
  1.65060475e-01f, 6.21857047e-02f, 5.46972267e-02f, -2.40263894e-01f, 6.91565946e-02f, 2.34194472e-02f, -3.29138041e-02f, -2.52717912e-01f, 5.45589477e-02f, 2.23074824e-01f,
  9.78659317e-02f, -1.12935886e-01f, 5.06979190e-02f, 2.82606691e-01f, 2.87354469e-01f, 9.07111354e-03f, -2.49081757e-02f, -1.11483738e-01f, 1.03195652e-01f, -1.18843406e-01f,
  4.49100196e-01f, 2.51751393e-04f, 4.02506441e-02f, -2.79629946e-01f, 1.76978260e-01f, 3.56273800e-01f, 2.12046802e-01f, -6.00069296e-03f, -2.65320271e-01f, -3.34386587e-01f,
  -5.20270646e-01f, 1.40595868e-01f, 2.11344182e-01f, -2.05306321e-01f, -5.10548688e-02f, -1.22685961e-01f, 5.16902916e-02f, 7.71131590e-02f, 7.99921453e-02f, 6.30341247e-02f,
  7.32363239e-02f, 1.51083052e-01f, 3.47854793e-02f, 2.59060115e-01f, -8.99727456e-03f, -2.46364102e-01f, 9.91511568e-02f, -7.68562034e-02f, -2.31875047e-01f, 8.72305930e-02f,
  -1.87815264e-01f, -1.70801133e-01f, 4.06247303e-02f, 1.98513240e-01f, 2.55041689e-01f, 2.58612514e-01f, -6.83999583e-02f, 2.07108721e-01f, 2.62285799e-01f, 2.13475764e-01f,
  2.02691033e-01f, 1.09255210e-01f, 8.99640564e-03f, 2.47448366e-02f, -9.93804783e-02f, -2.24262848e-01f, 1.95339844e-01f, 1.86180621e-02f, 1.51458353e-01f, 1.43777594e-01f,
  1.07697517e-01f, 2.07346812e-01f, 5.50059415e-02f, -1.15493089e-01f, 5.45138530e-02f, -2.00599626e-01f, 4.09414798e-01f, 2.01007846e-04f, 1.31811667e-02f, -1.18275639e-02f,
  1.82932258e-01f, 3.61268036e-02f, 3.33652526e-01f, -1.26720920e-01f, 1.36080831e-01f, 1.86409652e-01f, -9.79680195e-02f, 3.24043840e-01f, -3.51954401e-02f, -3.32662374e-01f,
  -2.27109566e-01f, -4.93679829e-02f, 2.84370989e-01f, 1.00656867e-01f, -9.55124125e-02f, 2.15729311e-01f, -2.38269672e-01f, 7.12485686e-02f, 1.37446404e-01f, -7.46749863e-02f,
  1.00691147e-01f, -1.22610833e-02f, 2.79687136e-01f, 1.16675317e-01f, -1.03575900e-01f, 2.04779372e-01f, 1.73572525e-02f, 2.38481015e-02f, 1.73262283e-01f, -4.96608049e-01f,
  1.03963457e-01f, 8.32720771e-02f, -6.92622364e-03f, 3.13664526e-01f, -5.98381385e-02f, -3.39681245e-02f, 5.70260286e-02f, 1.53708244e-02f, 1.04523972e-02f, 7.92249441e-02f,
  6.65900782e-02f, 9.08101425e-02f, 3.91484685e-02f, -3.30827083e-03f, 1.75984427e-01f, 1.26791075e-01f, 6.36342093e-02f, 2.55299844e-02f, 9.57751945e-02f, -1.59651846e-01f,
  -3.20640415e-01f, -4.70568240e-02f, 4.36530501e-01f, 1.80395633e-01f, 1.47773638e-01f, -1.47795631e-02f, 4.67933603e-02f, -1.76721185e-01f, 2.00152397e-03f, -1.71100706e-01f,
  4.85451043e-01f, 1.28605604e-01f, -1.70869514e-01f, -1.61141083e-01f, 2.06428081e-01f, -4.74222042e-02f, 2.32658654e-01f, 2.96165738e-02f, -9.19335186e-02f, 6.48724753e-03f,
  7.53036737e-02f, -4.82851379e-02f, 2.31038071e-02f, -4.67095435e-01f, -4.69087884e-02f, 1.17244564e-01f, 1.84399560e-02f, 1.70436159e-01f, 4.01569791e-02f, -5.36375791e-02f,
  -1.10989243e-01f, 7.97312632e-02f, 2.39464417e-02f, -1.43899992e-01f, 2.88275152e-01f, -8.90796483e-02f, 5.39731756e-02f, -2.05739722e-01f, 1.33594677e-01f, 2.59035885e-01f,
  1.63582087e-01f, 1.13909811e-01f, 2.02747226e-01f, -3.66685480e-01f, 1.47165522e-01f, -1.71824336e-01f, 9.81047284e-03f, 3.71176034e-01f, 5.15359379e-02f, 1.80367067e-01f,
  2.13002414e-01f, 2.05203369e-01f, 1.56825483e-01f, 2.16515884e-01f, 2.40061983e-01f, 3.48450094e-01f, 6.25969693e-02f, 7.81915784e-02f, 3.36655080e-01f, 1.26164794e-01f,
  2.78849155e-01f, 1.78516328e-01f, -9.00439098e-02f, 2.14338437e-01f, -1.01300649e-01f, 2.73338914e-01f, -1.14557296e-01f, 2.65692710e-03f, 1.06284238e-01f, -2.13923864e-02f,
  -3.53647433e-02f, 1.39368981e-01f, -3.21374685e-01f, 1.01479016e-01f, 9.69530195e-02f, -2.81941295e-01f, -1.18782580e-01f, -5.76081239e-02f, -1.31015882e-01f, 3.04106288e-02f,
  -1.15909837e-01f, -9.29568782e-02f, -8.64968076e-03f, 2.86869913e-01f, -3.16778064e-01f, 4.25527580e-02f, -1.49134517e-01f, 9.98094603e-02f, -6.78820759e-02f, 3.08111072e-01f,
  1.61739558e-01f, 4.09663506e-02f, 7.15301484e-02f, -6.55336902e-02f, -1.40543193e-01f, -1.20838434e-01f, 3.23768169e-01f, -2.01354921e-01f, 1.02042504e-01f, 6.66343719e-02f,
  -1.98533043e-01f, -1.02012604e-02f, 1.77740697e-02f, -1.55485898e-01f, -3.58677059e-02f, -2.51934640e-02f, 1.51539236e-01f, 4.20095325e-01f, 1.02791479e-02f, -6.28955886e-02f,
  1.53809890e-01f, 6.12466596e-02f, 2.60812312e-01f, -3.62700708e-02f, 1.66866705e-01f, 1.47682294e-01f, 1.41253635e-01f, 1.39375195e-01f, 1.89214975e-01f, 1.84670731e-03f,
  -4.85509597e-02f, 1.84001729e-01f, -6.03652261e-02f, 6.17486285e-03f, -3.49082872e-02f, -7.54056945e-02f, -1.52799964e-01f, -8.74521136e-02f, -1.37991831e-01f, 1.32166266e-01f,
  1.46221325e-01f, -1.98137760e-02f, 8.83904099e-02f, -2.23057508e-01f, -9.15875137e-02f, -1.38654009e-01f, 2.00522780e-01f, -3.80926840e-02f, -7.72457644e-02f, -1.92194536e-01f,
  -1.15655744e-02f, 1.74788103e-01f, 1.23734765e-01f, 5.71904071e-02f, -2.35783663e-02f, -1.75648272e-01f, 3.88550386e-02f, 9.62677300e-02f, 1.47261605e-01f, 1.87232569e-01f,
  2.01189250e-01f, 9.90999565e-02f, 2.67824709e-01f, 3.66261750e-01f, -1.07096717e-01f, -1.92738339e-01f, -1.12774201e-01f, -4.01331693e-01f, 1.99342310e-01f, 9.40191075e-02f,
  -2.42603481e-01f, 1.80724919e-01f, 8.48300382e-02f, -8.17117840e-02f, -6.53815223e-03f, 2.36100554e-01f, 1.22338489e-01f, -1.24175005e-01f, 2.56588757e-01f, 7.11447597e-02f,
  9.60916355e-02f, 1.86436757e-01f, -9.87418890e-02f, -1.88604519e-01f, 9.04041380e-02f, 1.66677564e-01f, -3.57618555e-03f, 1.83707952e-01f, 1.25509501e-01f, 1.27608150e-01f,
  -6.45911619e-02f, 1.43731475e-01f, -2.02339552e-02f, -2.31350306e-02f, 1.18790776e-01f, 1.64037079e-01f, 1.62815154e-01f, 6.44967891e-03f, -4.50251177e-02f, 9.37718600e-02f,
  -2.05989063e-01f, 3.48116457e-02f, -2.52396286e-01f, 7.77229369e-02f, 2.11206049e-01f, -7.08606020e-02f, 6.19650558e-02f, -6.29122183e-02f, -2.12891355e-01f, 9.99326631e-03f,
  6.38157725e-02f, -7.98809715e-03f, 3.95922244e-01f, -3.73792611e-02f, -2.51582980e-01f, -8.90605450e-02f, 2.21913517e-03f, -4.95119020e-02f, 2.51682233e-02f, -3.70058194e-02f,
  -3.45346212e-01f, 4.02818918e-01f, -3.02167505e-01f, -1.46276519e-01f, 1.77696139e-01f, 8.41440856e-02f, 1.02148049e-01f, 3.64471301e-02f, 1.18917793e-01f, 1.51528537e-01f,
  1.36036903e-01f, -5.29318862e-02f, -6.00509197e-02f, 1.70093611e-01f, 2.82307994e-03f, -1.67073071e-01f, 1.60788491e-01f, -6.56044856e-02f, -1.56475755e-03f, -1.27091005e-01f,
  -1.34137884e-01f, 3.64418365e-02f, -6.18187152e-03f, -2.92481005e-01f, 1.07444435e-01f, -3.14684033e-01f, -5.96206784e-02f, -9.24808756e-02f, 2.15541780e-01f, 2.62598097e-01f,
  -2.61869222e-01f, 1.27644524e-01f, 7.60188559e-03f, 9.32046324e-02f, 1.52532324e-01f, 1.54107034e-01f, -6.27097487e-02f, 2.22687721e-01f, 2.99715698e-01f, 1.78423315e-01f,
  1.22109205e-01f, 1.86248541e-01f, 1.86510205e-01f, 1.48903444e-01f, -2.28418767e-01f, -9.59138349e-02f, -1.49972022e-01f, 3.26065682e-02f, 5.22025302e-02f, -1.15974508e-01f,
  1.96949467e-01f, 1.39509782e-01f, -1.85782924e-01f, 7.42453486e-02f, -2.98842937e-02f, 1.52777389e-01f, 1.35596231e-01f, 6.35089679e-03f, -1.35754108e-01f, 1.76006854e-01f,
  1.28577188e-01f, 1.28814608e-01f, -4.33162414e-02f, -2.96003103e-01f, -1.14137061e-01f, 3.04684311e-01f, -2.44451359e-01f, 7.58814514e-02f, -5.33918105e-02f, 2.97626972e-01f,
  4.17522378e-02f, -8.13775212e-02f, 3.33428532e-02f, 1.80665165e-01f, -1.98551323e-02f, 1.13612905e-01f, -4.17447239e-02f, 2.02785239e-01f, -2.67864734e-01f, -6.91567957e-02f,
  9.38875154e-02f, -3.62441361e-01f, 1.92830443e-01f, -3.71157899e-02f, -2.03657240e-01f, -8.38221982e-02f, -2.44731037e-03f, -2.58570701e-01f, 2.20178127e-01f, 7.62030929e-02f,
  -7.77456537e-02f, -2.06840843e-01f, 3.79187316e-01f, 4.17268753e-01f, -2.21054345e-01f, 2.62408137e-01f, -1.34783192e-02f, 2.80440152e-01f, 2.51873016e-01f, 5.44696897e-02f,
  8.90102237e-03f, 2.52748281e-01f, 2.60225087e-01f, 2.01752976e-01f, -6.45956723e-03f, 2.04748333e-01f, 8.32046345e-02f, 7.49754012e-02f, 4.08352427e-02f, -1.45321310e-01f,
  2.11328581e-01f, 6.18490390e-03f, -7.92570934e-02f, 6.35542274e-02f, 1.93176866e-01f, 2.83330083e-01f, -7.91052207e-02f, -1.17165446e-02f, 2.56754458e-01f, 1.11134775e-01f,
  -5.64050414e-02f, 1.14113636e-01f, 1.34174690e-01f, 2.33646795e-01f, 1.76630139e-01f, 4.81626913e-02f, 7.41066784e-02f, -1.55195653e-01f, 9.74841490e-02f, 1.29799590e-01f,
  -1.91265404e-01f, 3.68948638e-01f, -9.72555727e-02f, 1.65531449e-02f, 2.26601847e-02f, -1.56713217e-01f, 2.28085905e-01f, -1.02226526e-01f, 2.90365368e-02f, 1.01931199e-01f,
  -2.02049464e-01f, 1.49731502e-01f, -1.87841997e-01f, 1.68093860e-01f, -9.25982520e-02f, -2.83165306e-01f, 2.42586836e-01f, -8.40704739e-02f, 8.52686316e-02f, -1.39869675e-01f,
  6.30466342e-02f, -1.28474146e-01f, 2.87356675e-01f, 4.79216903e-01f, -2.33900011e-01f, -6.75101355e-02f, 3.26629251e-01f, 4.12321597e-01f, -1.21982908e-02f, 2.75293201e-01f,
  1.98809072e-01f, 2.73166969e-02f, 2.01793164e-01f, 6.03789017e-02f, 1.82782501e-01f, -6.41024411e-02f, -7.79148191e-02f, 7.65637159e-02f, 4.30866145e-02f, 1.08913861e-01f,
  -4.08036895e-02f, 1.80964202e-01f, 1.11341946e-01f, -8.51699263e-02f, 1.19856142e-01f, -1.20883115e-01f, 7.60123599e-03f, 4.61891480e-03f, -4.72049594e-01f, -5.38243279e-02f,
  7.66481012e-02f, 8.93203914e-02f, -1.69869363e-01f, 8.42909068e-02f, -4.16502729e-02f, -2.44527534e-01f, -1.58957310e-03f, -1.15111560e-01f, 1.12730309e-01f, -9.24044698e-02f,
  -6.39796779e-02f, -1.73319608e-03f, 1.64641917e-01f, 1.62681103e-01f, 3.58217239e-01f, -4.15466726e-02f, 1.96817502e-01f, 1.49841636e-01f, 3.42771560e-01f, -1.47649705e-01f,
  3.45079631e-01f, 1.58612207e-01f, 9.05866399e-02f, -2.73852348e-01f, 4.74273205e-01f, -8.98666307e-02f, 9.49072242e-02f, 1.21639483e-02f, 8.94554779e-02f, 3.86335775e-02f,
  -4.47640032e-01f, -1.16259959e-02f, 4.25777063e-02f, 9.54141095e-02f, 7.26416111e-02f, -1.31403193e-01f, 1.07448623e-01f, 1.50000334e-01f, -1.42075848e-02f, 6.67747557e-02f,
  4.05804999e-02f, -2.26497084e-01f, -1.70560673e-01f, -1.31233752e-01f, 9.74014923e-02f, -8.22657049e-02f, 4.52323630e-02f, -1.83806241e-01f, 5.94918206e-02f, -9.77266859e-03f,
  -1.80041671e-01f, -4.37667929e-02f, 1.23017617e-01f, 4.12265025e-02f, 1.09538667e-01f, -1.10404022e-01f, -8.37508142e-02f, 4.72761914e-02f, 3.69185992e-02f, 1.10602543e-01f,
  -1.36516271e-02f, 1.20150536e-01f, 2.91151702e-01f, -8.59970599e-03f, -5.50766736e-02f, -5.11134528e-02f, 1.60305783e-01f, 9.87102091e-02f, -2.45646805e-01f, 2.01806232e-01f,
  2.20670253e-01f, -3.17172930e-02f, -8.93993378e-02f, -1.20169997e-01f, -2.23635733e-01f, 7.12035149e-02f, -1.56096444e-01f, -3.19403976e-01f, 3.33553478e-02f, 1.59373432e-02f,
  -3.54894608e-01f, 1.01193048e-01f, -3.49551201e-01f, 1.28951436e-02f, -2.57468671e-01f, -8.85742679e-02f, -8.91855266e-03f, 1.23415254e-01f, 1.09987976e-02f, 1.23832144e-01f,
  -2.48149291e-01f, 9.32945460e-02f, -2.08121881e-01f, 1.48654312e-01f, 2.54827559e-01f, 1.05313966e-02f, 6.30417168e-02f, -1.17500894e-01f, 1.82955805e-02f, 3.06911301e-02f,
  7.45175853e-02f, 2.27388456e-01f, -2.04674631e-01f, 1.52593270e-01f, 1.45461410e-01f, 9.75048393e-02f, -1.11699857e-01f, 2.43015274e-01f, 2.85870194e-01f, 6.07094504e-02f,
  1.57123178e-01f, 3.09181269e-02f, 2.73063183e-01f, 2.13849425e-01f, 2.90681183e-01f, 9.28842425e-02f, 1.65913731e-01f, 1.77184075e-01f, 1.63934231e-01f, 2.45856643e-01f,
  1.85495540e-01f, 1.30515099e-01f, 9.76197422e-02f, -1.69112176e-01f, -2.81952899e-02f, 1.08650923e-01f, 4.24754433e-02f, -2.30656251e-01f, 5.23166172e-02f, 4.27412502e-02f,
  1.24331586e-01f, -2.50138938e-01f, -1.39769420e-01f, 2.32639670e-01f, 2.11862490e-01f, 2.92504400e-01f, -2.24381704e-02f, 8.05075560e-03f, 1.88802350e-02f, -5.46695068e-02f,
  5.35430670e-01f, -7.44714364e-02f, 7.85669833e-02f, 3.50453667e-02f, 6.13152981e-02f, 3.86591882e-01f, 1.39164567e-01f, 2.87344605e-01f, -3.11632544e-01f, -3.26096743e-01f,
  -1.93931013e-01f, 1.08941339e-01f, 1.51732430e-01f, -2.92536050e-01f, 3.39501724e-02f, 1.02080137e-01f, 2.00667325e-02f, -3.16609815e-02f, 1.16692424e-01f, 9.54869986e-02f,
  9.89591107e-02f, 6.63733035e-02f, 7.80369714e-02f, 2.41539195e-01f, -3.69185433e-02f, 1.23676188e-01f, 1.07725792e-01f, -3.11200380e-01f, -2.62309816e-02f, -5.96229248e-02f,
  7.45650232e-02f, 1.66834891e-01f, 1.76357731e-01f, 1.18574724e-01f, 1.07226245e-01f, -3.95459197e-02f, 1.01461738e-01f, 1.56222075e-01f, 2.53486216e-01f, -1.25388131e-02f,
  -2.35820413e-02f, 5.89813888e-02f, 9.11480933e-02f, 8.47064629e-02f, -4.07844037e-02f, -2.38602072e-01f, 2.63517052e-01f, -8.09541866e-02f, -1.63774684e-01f, 1.14192486e-01f,
  5.18109277e-02f, 1.25830173e-02f, -6.82926103e-02f, -2.35342890e-01f, 2.38672376e-01f, -2.72219745e-03f, -1.88068196e-01f, -4.56883609e-02f, 2.14439005e-01f, 3.16790521e-01f,
  2.15756387e-01f, -7.02647418e-02f, 1.65592611e-01f, -1.60262778e-01f, 4.30629849e-02f, -1.92547858e-01f, 2.66492784e-01f, 3.41362178e-01f, 2.29923338e-01f, -5.65795861e-02f,
  1.49997860e-01f, 7.64441714e-02f, 4.78559770e-02f, -9.47681144e-02f, -3.45603912e-04f, -2.29519904e-01f, 1.69429377e-01f, 2.54496988e-02f, 6.24436773e-02f, -2.95538493e-02f,
  -9.44234207e-02f, -1.31442785e-01f, 2.24454552e-02f, -1.44506902e-01f, 1.02580167e-01f, -1.16874650e-01f, 2.92800456e-01f, 1.61411941e-01f, 1.31693929e-01f, 5.93020499e-01f,
  -1.11355774e-01f, 7.17457980e-02f, 1.41474098e-01f, 3.79445791e-01f, 2.38771588e-01f, 9.83887017e-02f, 9.44583416e-02f, 2.23552249e-02f, 2.48947386e-02f, 8.64596746e-04f,
  8.96315277e-02f, 2.78689295e-01f, -7.45073706e-02f, 4.27054167e-02f, 7.46205002e-02f, -2.86497176e-02f, 2.91986857e-02f, 1.07347764e-01f, -9.47033986e-04f, -1.98065434e-02f,
  1.12222150e-01f, -6.43496886e-02f, -4.16479856e-02f, -3.76359016e-01f, 2.29693532e-01f, 1.00326955e-01f, -5.07620275e-02f, 8.80924612e-02f, 1.45667017e-01f, -7.62685537e-02f,
  3.80872071e-01f, 3.99175167e-01f, 1.00549079e-01f, -1.55083597e-01f, 1.64355114e-01f, 6.53361902e-02f, -8.72908160e-02f, 9.47247073e-02f, 3.47671449e-01f, -1.58069342e-01f,
  2.99987141e-02f, -1.57944575e-01f, 7.74715170e-02f, 8.94638225e-02f, -2.10770816e-01f, 1.18794098e-01f, -4.39217597e-01f, -3.60077560e-01f, -3.03606808e-01f, 3.36598098e-01f,
  -1.89178586e-01f, -2.09551081e-01f, 2.72057027e-01f, -1.15917847e-02f, 3.69339921e-02f, 2.66744554e-01f, 8.81863758e-02f, 1.00881644e-01f, -1.88211262e-01f, 3.06307465e-01f,
  3.01993847e-01f, 3.47373128e-01f, -1.41300425e-01f, -3.41450602e-01f, 6.11303411e-02f, -7.16903284e-02f, -3.73107463e-01f, -1.35109633e-01f, -1.37467049e-02f, -1.63932163e-02f,
  2.37038806e-01f, 7.65413716e-02f, 2.12813318e-01f, 2.48822659e-01f, 1.38054013e-01f, 5.78280129e-02f, 1.08042834e-02f, 1.19543880e-01f, -3.59697342e-02f, 9.00745094e-02f,
  1.34856224e-01f, 1.61160722e-01f, 1.18291758e-01f, 1.66597605e-01f, -3.04615408e-01f, 1.41284853e-01f, 5.65965809e-02f, -1.30120367e-01f, 1.73018098e-01f, -1.79182395e-01f,
  4.46447311e-03f, -8.87173973e-03f, -3.97119001e-02f, 5.33738956e-02f, -7.13163912e-02f, -1.40855923e-01f, 1.32218506e-02f, 1.49452299e-01f, -6.00480437e-02f, 5.75966313e-02f,
  -4.32652459e-02f, 1.34609267e-01f, 3.21015716e-01f, -3.07984762e-02f, 8.05926248e-02f, -1.76609904e-01f, -1.11929707e-01f, 1.95375741e-01f, -1.30916357e-01f, 3.09651226e-01f,
  -1.36814311e-01f, -1.33761823e-01f, -8.72725919e-02f, 2.28297278e-01f, 8.85609537e-02f, 3.64817232e-02f, 2.49927491e-01f, 1.36126891e-01f, -7.53769800e-02f, 1.70934439e-01f,
  -2.54359126e-01f, -1.36659220e-01f, -2.37376556e-01f, 2.61727590e-02f, 1.59397230e-01f, 3.68390262e-01f, -1.96848795e-01f, -8.07256717e-03f, 7.40738213e-02f, -1.87512413e-01f,
  -1.55037746e-01f, -2.82322198e-01f, 3.10526043e-01f, -4.05730829e-02f, 6.67477921e-02f, -6.83020577e-02f, 2.30063833e-02f, -3.41296010e-02f, 2.31757872e-02f, -1.61842518e-02f,
  1.29735023e-01f, 1.41057819e-01f, -7.62787610e-02f, 9.02569816e-02f, 2.35736296e-02f, 1.22188807e-01f, -4.52353470e-02f, -8.10069591e-02f, 2.39023253e-01f, 6.26226217e-02f,
  4.08759639e-02f, 1.68748707e-01f, -1.85028896e-01f, 3.94473635e-02f, -2.24658996e-01f, 4.14871275e-02f, -2.64637843e-02f, 6.68239444e-02f, -4.39360440e-02f, -1.34607023e-02f,
  2.12680876e-01f, 1.87385097e-01f, 7.15146661e-02f, -1.22324817e-01f, -2.44673938e-01f, -1.00773960e-01f, -5.35794139e-01f, -2.60329276e-01f, 2.01959521e-01f, 2.77635306e-01f,
  1.51494622e-01f, -1.21720703e-02f, 2.64993370e-01f, 8.26258957e-03f, -4.53087054e-02f, -1.78578734e-01f, 7.02327341e-02f, 1.30060136e-01f, 1.42442554e-01f, -1.72141582e-01f,
  -2.24608451e-01f, 1.70892835e-01f, 2.89672762e-02f, -2.22916529e-01f, 3.20388407e-01f, 9.95182768e-02f, 2.46619388e-01f, -1.89245403e-01f, 1.23226317e-02f, -4.10235710e-02f,
  2.64724940e-01f, 5.41673005e-01f, -2.21462876e-01f, -2.17115909e-01f, -7.89237991e-02f, 2.35888615e-01f, 1.08447157e-01f, 3.69602829e-01f, 1.31818071e-01f, 2.44553417e-01f,
  1.86501890e-01f, 7.86429867e-02f, 2.72772014e-01f, 2.39694700e-01f, 2.60806650e-01f, -3.37747112e-03f, -7.92897046e-02f, 1.13895230e-01f, 3.12961116e-02f, 1.03774458e-01f,
  8.52153376e-02f, -1.01032227e-01f, 2.97607481e-01f, 1.75552845e-01f, -7.35076563e-03f, 7.14916736e-02f, 3.03006291e-01f, 1.07477196e-01f, 2.00017571e-01f, -1.26268610e-01f,
  1.61808610e-01f, -2.28730053e-01f, -1.50743678e-01f, 1.31404670e-02f, 1.93674594e-01f, 3.03702414e-01f, 7.35801160e-02f, -1.41506702e-01f, 2.31917277e-01f, -1.57270551e-01f,
  1.63740307e-01f, -1.45597637e-01f, 9.82197840e-03f, 3.86410922e-01f, 3.23408432e-02f, -2.03355923e-01f, -1.64964110e-01f, 4.37005907e-02f, 1.32909566e-01f, -2.12053791e-01f,
  8.51913728e-03f, -1.08943984e-01f, 2.84941006e-03f, -9.66228098e-02f, 6.95882887e-02f, 1.28603995e-01f, 1.09865203e-01f, -1.52242659e-02f, 2.29527891e-01f, 6.40554279e-02f,
  9.50946733e-02f, -1.03208333e-01f, 1.59019426e-01f, 2.78426230e-01f, -6.48618266e-02f, 1.50153443e-01f, 1.20302521e-01f, 4.98161986e-02f, 8.89698137e-03f, 1.31735161e-01f,
  2.64698952e-01f, -4.71795052e-02f, 1.33543164e-01f, 2.97216605e-02f, 1.23683132e-01f, -4.31274287e-02f, 1.49804518e-01f, 2.69736703e-02f, -2.35718817e-01f, -2.89976764e-02f,
  7.06373602e-02f, 2.08284274e-01f, 4.45960388e-02f, -6.06599031e-03f, 9.27871168e-02f, -1.69465691e-01f, 1.89155981e-01f, -6.77498579e-02f, 9.30368435e-03f, -1.69754058e-01f,
  1.71568111e-01f, -4.18517962e-02f, -4.62713279e-02f, 4.86637726e-02f, 5.35085425e-02f, 3.99204865e-02f, 8.32138434e-02f, 1.94047704e-01f, 5.66215962e-02f, 1.56763941e-01f,
  1.62839979e-01f, -7.44680464e-02f, -2.66612060e-02f, 7.02456161e-02f, 1.86140582e-01f, -3.30844730e-01f, 3.52462351e-01f, -2.91102558e-01f, -3.42163518e-02f, -2.08921924e-01f,
  1.58058017e-01f, -1.11415125e-01f, -2.17517495e-01f, 3.68694514e-02f, -4.98959683e-02f, 5.15587218e-02f, 3.44980098e-02f, -5.47878183e-02f, 3.17108668e-02f, 1.77007407e-01f,
  -8.84664357e-02f, -4.96980846e-02f, -1.60839260e-01f, -3.72721627e-02f, 1.86668932e-01f, 1.27692953e-01f, 3.64862293e-01f, 1.37605160e-01f, -5.94266020e-02f, 2.61037916e-01f,
  -1.11497678e-02f, 8.79225954e-02f, -4.86943163e-02f, 5.85688353e-02f, -6.14448823e-02f, 1.42002907e-02f, 9.05511454e-02f, 4.64495048e-02f, 5.34037873e-02f, -1.06478266e-01f,
  1.70393344e-02f, -4.04793024e-02f, 1.36316856e-02f, 2.92852577e-02f, 6.17926717e-02f, 1.13072217e-01f, -5.65078631e-02f, 7.05502629e-02f, -1.38836160e-01f, -1.39008418e-01f,
  3.41880061e-02f, 5.78335449e-02f, -2.24184850e-03f, -1.46083340e-01f, -7.48423934e-02f, 5.48374988e-02f, 1.68074936e-01f, -3.44873145e-02f, -2.00822383e-01f, -6.30357042e-02f,
  2.03362167e-01f, 6.16367301e-03f, -7.23529384e-02f, -1.37247115e-01f, -4.97572720e-02f, -7.03908876e-02f, 1.30259991e-01f, 1.31061435e-01f, -1.88232273e-01f, -1.73626048e-03f,
  8.63044783e-02f, -8.27636123e-02f, -1.23076383e-02f, -4.83824573e-02f, -4.75990996e-02f, -2.71812856e-01f, 1.84736013e-01f, 1.45818800e-01f, 6.80100173e-02f, 8.45453814e-02f,
  -2.99676694e-02f, 1.13962904e-01f, -9.54518281e-03f, 1.50584146e-01f, 3.14776212e-01f, -5.72674088e-02f, 6.01464547e-02f, -3.49627495e-01f, -2.57602453e-01f, 1.52133837e-01f,
  -1.94611520e-01f, -3.38443518e-02f, 6.90260604e-02f, -2.57221520e-01f, 1.27264634e-01f, 2.51416892e-01f, 3.73887122e-02f, 1.46477446e-01f, -6.74567819e-02f, -2.60655314e-01f,
  1.50637358e-01f, 3.09104342e-02f, 9.87762138e-02f, 1.67660356e-01f, 1.48277581e-01f, -3.46704982e-02f, 1.59843206e-01f, 6.86422959e-02f, 1.01069793e-01f, 5.00882491e-02f,
  1.19565979e-01f, 9.57184881e-02f, -1.83484241e-01f, 1.81769714e-01f, -2.11534854e-02f, 1.82726815e-01f, -2.27625534e-01f, -4.02098596e-02f, 1.34899274e-01f, 1.44214123e-01f,
  -2.37884402e-01f, -1.21662304e-01f, -1.04994126e-01f, 5.57843372e-02f, -2.53278524e-01f, -1.14396758e-01f, 2.28142992e-01f, 1.76228166e-01f, 7.45312274e-02f, -8.41544494e-02f,
  -2.10368842e-01f, -2.91608535e-02f, -2.80727476e-01f, 3.19313258e-01f, -4.19091210e-02f, -2.22298373e-02f, -4.87651639e-02f, 3.08930635e-01f, 9.31810960e-02f, -2.01257262e-02f,
  6.12780824e-02f, 1.98616326e-01f, -4.40257695e-03f, 1.28941476e-01f, -6.21363930e-02f, 8.07391033e-02f, -5.60005121e-02f, -6.96540717e-03f, -2.24768057e-01f, -2.90715754e-01f,
  2.07938015e-01f, -1.95065722e-01f, -2.43470091e-02f, -1.81398749e-01f, 9.50323790e-02f, -2.72324160e-02f, 2.54618973e-01f, 4.86959308e-01f, -8.60861782e-03f, -7.63049200e-02f,
  3.79858911e-01f, 3.58408451e-01f, 2.15776101e-01f, 1.18537657e-01f, 1.60926610e-01f, 8.65780935e-02f, 1.01522408e-01f, 1.71626568e-01f, 9.92010981e-02f, 1.20187610e-01f,
  1.00734711e-01f, 6.61584958e-02f, 1.61906511e-01f, 2.50353962e-01f, 1.57119662e-01f, 1.62345022e-01f, -9.53790247e-02f, -1.23585001e-01f, 1.02665804e-01f, 4.20815088e-02f,
  -1.19729772e-01f, 7.70873623e-03f, -1.14726953e-01f, 6.33693635e-02f, -6.19465299e-02f, -6.57107383e-02f, 3.25396135e-02f, -1.41998634e-01f, 1.52418196e-01f, -4.78526726e-02f,
  -3.30897719e-02f, 1.71448320e-01f, 1.95282936e-01f, -2.96884298e-01f, 2.97761798e-01f, 3.11134942e-02f, 8.17144848e-03f, -3.61188650e-02f, 2.51871884e-01f, 4.46905434e-01f,
  -6.74005151e-02f, -2.76951730e-01f, 1.20504133e-01f, 7.24887773e-02f, 2.64592856e-01f, -1.05694249e-01f, 2.54239272e-02f, -1.36628345e-01f, 1.45984992e-01f, -3.98969129e-02f,
  -1.31284535e-01f, 8.34661946e-02f, 2.44944811e-01f, -1.93436071e-01f, 5.80789968e-02f, -1.63328215e-01f, 2.24176422e-02f, -1.25617132e-01f, 1.17351547e-01f, 2.26920974e-02f,
  7.11739734e-02f, -1.61700279e-01f, -4.65909354e-02f, 1.13413550e-01f, 1.69490576e-02f, 4.03003395e-03f, -8.74148905e-02f, 4.91037369e-02f, 1.99821107e-02f, 1.32311642e-01f,
  1.50770798e-01f, 3.82154696e-02f, 8.54896456e-02f, 2.14466050e-01f, 6.18409365e-02f, 3.23442519e-02f, 2.36765191e-01f, 2.31475696e-01f, 2.97351964e-02f, 1.41167998e-01f,
  -5.77752069e-02f, 1.95382491e-01f, -7.73382336e-02f, 9.56522010e-04f, -1.72931612e-01f, -1.62550464e-01f, -2.30518192e-01f, -1.04611807e-01f, 1.73745081e-01f, 4.71184514e-02f,
  -2.62928814e-01f, -6.21823296e-02f, 8.96588992e-03f, -3.50139067e-02f, -1.52195662e-01f, -6.60260618e-02f, -2.01532543e-01f, 2.92004019e-01f, 1.37769863e-01f, 8.63530561e-02f,
  1.52343903e-02f, 3.09542894e-01f, 9.74482074e-02f, -4.26353142e-02f, 6.33931831e-02f, 5.04572988e-01f, 6.74663261e-02f, -3.76480162e-01f, 4.04355735e-01f, 1.73494279e-01f,
  -1.77407071e-01f, 1.38610080e-01f, 1.36186212e-01f, 1.00379169e-01f, -6.06123172e-02f, -7.16593042e-02f, 3.52186598e-02f, 1.61226824e-01f, 8.97126570e-02f, 2.42877677e-01f,
  -1.55947581e-01f, 3.81028163e-03f, -1.89467788e-01f, -2.92527735e-01f, -1.95575729e-02f, -3.65093470e-01f, -4.65117907e-03f, 3.14386100e-01f, -3.12074088e-02f, -3.78300697e-02f,
  -9.40202177e-02f, -1.48743719e-01f, 7.93078989e-02f, 5.52300438e-02f, 6.15893826e-02f, 1.01204179e-01f, -7.02028051e-02f, 9.45656151e-02f, 9.88577604e-02f, 2.33585779e-02f,
  3.57359163e-02f, 1.25872493e-01f, 1.26497960e-02f, 3.20190601e-02f, -2.69417576e-02f, 1.35072902e-01f, 6.34902492e-02f, -3.05910408e-03f, -1.30517051e-01f, -6.02418669e-02f,
  -2.49723688e-01f, 9.80359390e-02f, -1.74495980e-01f, 3.59715102e-03f, -1.56390108e-02f, 4.66338992e-02f, 2.41824966e-02f, 7.69715831e-02f, 1.41443476e-01f, 1.58100039e-01f,
  1.52012363e-01f, 2.53998786e-01f, -1.22317344e-01f, 1.12959957e-02f, -3.08966964e-01f, 2.07360595e-01f, 4.13649604e-02f, 3.22259814e-01f, 1.47591278e-01f, 8.07023197e-02f,
  6.88135922e-02f, 7.83313159e-03f, 2.35716924e-01f, 8.92582461e-02f, 8.60368833e-03f, -5.59017770e-02f, 5.79663590e-02f, 1.36219129e-01f, -1.87968388e-01f, -1.35976270e-01f,
  -2.11715415e-01f, -1.70019612e-01f, 3.79006028e-01f, 2.33559012e-01f, 3.05829585e-01f, 2.15839106e-03f, 1.01219214e-01f, -2.98206210e-01f, 2.26550400e-01f, -7.93355424e-03f,
  2.50041448e-02f, 2.88896374e-02f, 1.40518069e-01f, -1.36293108e-02f, -2.52525657e-01f, 1.37612194e-01f, 1.30852476e-01f, 2.93600738e-01f, 3.56149167e-01f, 8.70104581e-02f,
  1.91209570e-01f, 1.71044320e-01f, 1.23905402e-03f, 6.66867718e-02f, 1.22408837e-01f, 9.36660543e-02f, 3.21295746e-02f, 1.43524826e-01f, -4.77148890e-02f, 1.26340896e-01f,
  1.57141179e-01f, -2.30525941e-01f, -1.47171021e-01f, 6.15729988e-02f, -4.06819224e-01f, 9.85604897e-02f, -1.90639183e-01f, 2.11453870e-01f, -5.11214547e-02f, 1.72089398e-01f,
  -1.06307268e-01f, 1.81105733e-01f, 2.58995563e-01f, 1.01078160e-01f, 5.37630133e-02f, 1.62942424e-01f, -1.46929130e-01f, 4.24552001e-02f, 3.51022817e-02f, 2.10781336e-01f,
  6.81604296e-02f, 5.24731800e-02f, 6.95361644e-02f, 1.54482499e-01f, 1.70088798e-01f, -8.22552219e-02f, 1.46511957e-01f, -1.31347090e-01f, -1.48013651e-01f, 1.46321982e-01f,
  5.64060137e-02f, 2.86695212e-02f, -2.67251611e-01f, -1.13365196e-01f, -8.81234780e-02f, 3.33413593e-02f, 1.81342214e-01f, 2.68709034e-01f, 3.03308696e-01f, 2.26990841e-02f,
  9.14125368e-02f, -3.56751308e-02f, 1.38186783e-01f, 1.37305483e-01f, -1.09655432e-01f, -9.60189626e-02f, 4.31700945e-02f, 1.65871218e-01f, -3.13128501e-01f, 2.74146069e-02f,
  -7.74410274e-03f, 1.13703229e-01f, 7.00619593e-02f, 8.29411447e-02f, 1.98873371e-01f, -2.12595910e-02f, 1.27861217e-01f, 1.55696243e-01f, -2.90221050e-02f, 9.46594551e-02f,
  4.28074375e-02f, 1.34914100e-01f, -5.94611391e-02f, -1.80068955e-01f, 2.56805886e-02f, 6.26232699e-02f, 5.85900322e-02f, -1.18598700e-01f, 2.18602598e-01f, 5.16675413e-02f,
  2.24172041e-01f, -1.84369788e-01f, 1.25729237e-02f, -9.14942473e-02f, 7.61629716e-02f, 7.70698115e-02f, 9.51126404e-03f, 7.54881129e-02f, 7.47650163e-03f, 1.24474131e-01f,
  3.67703795e-01f, -3.72676663e-02f, 1.46199197e-01f, 6.55979384e-03f, 6.43617287e-02f, -8.13487992e-02f, -9.37310383e-02f, -1.61724508e-01f, -3.25380921e-01f, -1.86679102e-02f,
  1.49624437e-01f, 2.11655483e-01f, -2.93874405e-02f, 1.60465941e-01f, -9.80578959e-02f, -3.12387850e-02f, 8.84113312e-02f, -1.55436680e-01f, 1.55384779e-01f, 2.32630908e-01f,
  -1.07676148e-01f, 4.10208143e-02f, 9.33397338e-02f, 2.80017942e-01f, 4.13689613e-02f, 3.40959042e-01f, -1.13812320e-01f, -3.48047435e-01f, 1.79825023e-01f, 1.34196654e-01f,
  4.67301682e-02f, -2.22606957e-01f, 7.66010582e-02f, -2.39923537e-01f, 7.79444650e-02f, 3.49467658e-02f, -1.09556586e-01f, -5.86763471e-02f, -9.71740633e-02f, 1.61533263e-02f,
  -8.20556190e-03f, 2.92671528e-02f, -1.12236969e-01f, 9.09680908e-04f, 5.21516539e-02f, 4.34573740e-02f, -3.21485512e-02f, 2.00770050e-02f, 1.47650853e-01f, -2.40948126e-01f,
  -1.99289426e-01f, -4.05686796e-02f, 3.08708638e-01f, 9.10728872e-02f, -1.80690125e-01f, -5.38324891e-03f, 2.80397296e-01f, -2.54512914e-02f, 7.68389478e-02f, 2.19926342e-01f,
  1.51673213e-01f, -4.05448645e-01f, -3.94903198e-02f, -2.30900627e-02f, -2.23906115e-01f, -1.57960162e-01f, 3.27630997e-01f, -4.16403413e-01f, -4.30056974e-02f, -4.65864949e-02f,
  3.30352783e-02f, 2.05589145e-01f, -2.70850390e-01f, -1.61657482e-01f, -3.19823235e-01f, -5.11878014e-01f, -3.82437527e-01f, 3.11990052e-01f, 3.46182734e-02f, -1.44936785e-01f,
  1.89376101e-02f, -2.69450963e-01f, -1.79153353e-01f, -2.47350149e-02f, 2.21280023e-01f, 3.13991308e-02f, 2.92213500e-01f, 4.43226695e-02f, 1.72892317e-01f, 5.79185635e-02f,
  -4.83501963e-02f, -1.09654352e-01f, -6.96512535e-02f, -3.21395129e-01f, -4.28097069e-01f, -9.76885036e-02f, 1.12121995e-03f, 1.78698711e-02f, -9.51860324e-02f, 7.08184838e-02f,
  3.09653729e-02f, 1.33499295e-01f, 1.93186313e-01f, 6.10289909e-02f, 6.28359467e-02f, 1.95751134e-02f, 1.30265012e-01f, -7.73314107e-03f, 1.76759630e-01f, 9.62752923e-02f,
  -4.34597917e-02f, 1.53936625e-01f, -2.59309381e-01f, 1.49327323e-01f, 2.11834833e-01f, -2.44919747e-01f, 3.07244152e-01f, -1.79277256e-01f, 1.49317766e-02f, 1.22730538e-01f,
  -1.08663313e-01f, 1.49842992e-01f, 6.22377135e-02f, -1.43717483e-01f, -6.03225604e-02f, 1.51512697e-01f, -1.68830618e-01f, 2.29489490e-01f, -5.51021360e-02f, -1.54267335e-02f,
  3.87021936e-02f, 1.97618246e-01f, -3.45843196e-01f, -2.78037518e-01f, -1.62292153e-01f, 2.49173999e-01f, 2.66410261e-02f, 3.61739516e-01f, 9.64622349e-02f, 3.23487371e-01f,
  -7.70235583e-02f, -3.08663715e-02f, -2.05596074e-01f, -6.40262887e-02f, 2.24276453e-01f, -1.61801338e-01f, 1.14297763e-01f, -1.78105041e-01f, -1.90129831e-01f, 6.79315105e-02f,
  1.18215583e-01f, -1.65300831e-01f, -1.57425895e-01f, -4.78779338e-02f, 1.71682626e-01f, 2.75394201e-01f, 7.57845119e-02f, -1.49478480e-01f, 1.06526047e-01f, 2.96341598e-01f,
  3.47438991e-01f, 7.84341767e-02f, 2.34374702e-02f, 2.65021682e-01f, 1.17833883e-01f, 5.26914932e-02f, 1.03372507e-01f, 1.72213539e-02f, 1.50867715e-01f, 8.26427937e-02f,
  2.42135480e-01f, 1.04150094e-01f, 2.03035176e-01f, 1.45763531e-01f, -9.49896201e-02f, -1.14266938e-02f, 1.12500802e-01f, 2.29409710e-01f, -2.16777693e-03f, -1.80131793e-01f,
  7.38104954e-02f, 1.36559546e-01f, 1.07614249e-01f, -5.04297912e-02f, -9.59322304e-02f, 1.88161340e-02f, 9.22146998e-03f, -3.00095886e-01f, -1.66695789e-01f, 1.45998508e-01f,
  -3.44582200e-02f, 1.42084822e-01f, 1.20958671e-01f, 3.69179132e-03f, -1.81658581e-01f, 1.70653060e-01f, -3.39288190e-02f, 2.83742487e-01f, -1.76873624e-01f, 4.20680717e-02f,
  -2.83917636e-01f, -1.77110091e-01f, 3.77375692e-01f, 2.89416648e-02f, -1.43187240e-01f, -6.31600246e-02f, -3.92156065e-01f, 4.95223589e-02f, 1.97272506e-02f, -1.70183882e-01f,
  1.31953597e-01f, 1.45522086e-02f, 8.72049779e-02f, 5.84723540e-02f, -1.18992357e-02f, 1.51495179e-02f, -3.18839997e-01f, -1.53667212e-01f, -3.53651680e-02f, -3.61662328e-01f,
  -6.40520304e-02f, 2.32007831e-01f, -1.25035029e-02f, 7.57790031e-03f, 2.66197845e-02f, -3.05377841e-01f, 1.93110287e-01f, 1.39758885e-01f, 1.63872331e-01f, -1.37394875e-01f,
  1.44752294e-01f, 5.71140200e-02f, 1.17665924e-01f, 2.06691504e-01f, -1.11567996e-01f, 2.58225769e-01f, -9.71771330e-02f, -5.23014627e-02f, 1.87155288e-02f, -1.83230639e-01f,
  -1.78127512e-01f, 1.78714529e-01f, 3.62059623e-01f, 3.30049783e-01f, 3.18024099e-01f, -2.31451876e-02f, -3.47150266e-02f, -2.11126357e-01f, 8.76109228e-02f, -3.15506399e-01f,
  2.34506562e-01f, -6.95781317e-03f, 1.24885589e-01f, 5.43870777e-02f, 1.12972513e-01f, 1.00134090e-01f, 3.03321332e-01f, -7.14184344e-03f, -1.46584272e-01f, -1.52586475e-01f,
  -8.25375766e-02f, -8.09716620e-03f, -1.32360915e-02f, -3.26173961e-01f, 4.03405651e-02f, -6.23527393e-02f, -1.99090883e-01f, -3.87862213e-02f, 1.22808203e-01f, -1.97804466e-01f,
  4.06509340e-02f, -1.78278401e-01f, -1.46279447e-02f, -5.25440387e-02f, 2.41282359e-01f, -4.27337810e-02f, -1.74613073e-02f, -2.35968456e-02f, 1.15417682e-01f, 1.06266037e-01f,
  2.25345567e-01f, 1.47855476e-01f, 3.74979019e-01f, 5.14350161e-02f, 9.94910821e-02f, -1.54600561e-01f, -8.93063992e-02f, 2.41636604e-01f, 1.02187477e-01f, 3.44835609e-01f,
  9.48796421e-02f, 2.36285120e-01f, 9.76914242e-02f, -6.20251074e-02f, 1.78917691e-01f, 7.98996091e-02f, 1.52994484e-01f, 8.95975083e-02f, 3.26238759e-02f, 9.05164406e-02f,
  1.59672618e-01f, 1.72209769e-01f, 1.61290631e-01f, -6.96495771e-02f, 3.12857240e-01f, -2.23726958e-01f, -4.30486858e-01f, 1.13279603e-01f, -2.87861437e-01f, 4.92210127e-02f,
  2.71783113e-01f, -9.63575095e-02f, 2.22286373e-01f, -1.92044843e-02f, -4.43859518e-01f, 2.76671469e-01f, 2.21692324e-01f, 2.88090944e-01f, 9.47147161e-02f, 2.47679986e-02f,
  8.54855999e-02f, -1.73279047e-01f, 3.10644448e-01f, 5.07599786e-02f, 2.46092245e-01f, 1.35801211e-01f, 4.98885959e-02f, 4.08116609e-01f, 5.36786728e-02f, -2.40145594e-01f,
  3.04540366e-01f, -2.04246238e-01f, -2.90603131e-01f, 1.96473584e-01f, 3.89732391e-01f, 1.17619283e-01f, -1.50996283e-01f, 2.70164967e-01f, 4.97081280e-02f, 5.32799177e-02f,
  9.37438011e-02f, 1.04275960e-02f, -8.96697119e-02f, -8.26991647e-02f, 1.01567857e-01f, 6.75925165e-02f, 4.09201346e-02f, -1.48260728e-01f, -1.90432876e-01f, 2.09973767e-01f,
  -5.65077998e-02f, 5.67846857e-02f, -1.57650933e-01f, 3.12537514e-03f, 2.04793856e-01f, -6.77710176e-02f, -7.01488787e-03f, -1.02243125e-01f, -1.34507000e-01f, -7.50836954e-02f,
  -1.46273032e-01f, -2.16107331e-02f, -5.63182123e-02f, 6.85216039e-02f, -1.19228490e-01f, 9.79542658e-02f, 8.46564621e-02f, 1.92858409e-02f, 5.81011027e-02f, 8.46957974e-03f,
  1.07605517e-01f, -3.00213713e-02f, 1.68409888e-02f, -1.09240137e-01f, -1.01563847e-02f, -7.49647692e-02f, 1.34745846e-03f, -3.03813666e-02f, 2.51719177e-01f, -1.83394756e-02f,
  -2.30637193e-01f, -1.36438251e-01f, 8.54280367e-02f, -2.69142389e-02f, 2.20751427e-02f, 1.04948372e-01f, -5.64328246e-02f, -8.43444914e-02f, 8.05535764e-02f, 5.44656580e-03f,
  1.62884697e-01f, -4.31931615e-01f, 2.30532870e-01f, -1.96890995e-01f, 1.02556478e-02f, 1.39203697e-01f, 2.97690600e-01f, -1.05951689e-01f, -1.02910297e-02f, -3.97884920e-02f,
  -2.82989275e-02f, 1.23209313e-01f, 2.73340970e-01f, 2.25537091e-01f, -4.87341620e-02f, -4.45047505e-02f, 1.03889659e-01f, 3.04561019e-01f, 8.04196205e-03f, -2.32927680e-01f,
  2.98410654e-01f, -3.28150392e-01f, 3.64424549e-02f, 1.82582468e-01f, 4.69386876e-02f, -2.83955447e-02f, -2.02250943e-01f, 6.18163794e-02f, 1.28191724e-01f, 6.36028051e-02f,
  1.33560421e-02f, 1.73673898e-01f, 9.92772542e-03f, 4.79797833e-02f, -3.94469798e-02f, 1.07201576e-01f, 7.54100643e-03f, 5.41856810e-02f, 9.18713361e-02f, 1.48461133e-01f,
  6.15390614e-02f, -1.21098287e-01f, 5.77808209e-02f, -5.81966564e-02f, -5.91502339e-02f, -3.16090316e-01f, 2.25971401e-01f, 4.17868122e-02f, -1.64456651e-01f, 1.71397105e-01f,
  7.21281320e-02f, 1.53863609e-01f, -2.17943862e-01f, 5.91688789e-02f, 1.73246354e-01f, -1.71094820e-01f, -3.16354454e-01f, 5.97920232e-02f, -3.28902781e-01f, 7.57569298e-02f,
  -2.13332325e-01f, -2.61745691e-01f, -2.74716139e-01f, -3.16061944e-01f, -5.52378036e-02f, -9.18182731e-02f, -3.32372844e-01f, 4.80087958e-02f, -1.92649260e-01f, -3.63965034e-02f,
  -7.86891300e-03f, 1.29528105e-01f, -7.23421052e-02f, -6.35850504e-02f, 3.27248484e-01f, -1.95691347e-01f, -2.37438723e-01f, 1.11467905e-01f, 2.90643573e-02f, 7.12356940e-02f,
  -1.47397578e-01f, 2.28384092e-01f, -1.71304092e-01f, 1.83615252e-01f, -8.91247466e-02f, 3.36704664e-02f, 1.13861121e-01f, -1.15183286e-01f, -1.85532689e-01f, -1.25125468e-01f,
  3.53693098e-01f, -1.53917223e-01f, 3.00720725e-02f, 1.23783804e-01f, 8.81101042e-02f, 1.21930219e-01f, -3.64867374e-02f, 7.35296905e-02f, -4.43207286e-02f, -1.68554664e-01f,
  1.35970116e-01f, -1.20800011e-01f, 1.41162246e-01f, 2.02436689e-02f, 5.03550321e-02f, -1.85577974e-01f, -6.68690503e-02f, -6.86011538e-02f, -5.53238485e-03f, 8.72347131e-02f,
  1.30661741e-01f, 2.11720645e-01f, 8.75059962e-02f, 1.74621418e-01f, -4.78209965e-02f, 1.39645010e-01f, -6.79913834e-02f, -4.14209208e-03f, 1.93058699e-01f, -2.67712653e-01f,
  4.66124974e-02f, 3.90744880e-02f, -2.23504931e-01f, 1.25607997e-01f, -2.16933161e-01f, -2.98618555e-01f, -2.82645430e-02f, -1.70858055e-01f, -1.58862934e-01f, 9.77262110e-02f,
  -2.15314820e-01f, 1.13280728e-01f, -1.74575850e-01f, -1.46591142e-01f, -9.46596544e-03f, 1.24158345e-01f, -1.01483040e-01f, 1.12509221e-01f, 5.94033441e-03f, -3.51920947e-02f,
  -2.47113019e-01f, 3.71881276e-02f, 3.42593670e-01f, -8.86857286e-02f, 2.96660382e-02f, 9.62303355e-02f, 3.43201943e-02f, -9.26175863e-02f, 1.47228315e-01f, 5.50791360e-02f,
  -2.07124813e-03f, -1.02712207e-01f, 1.69668011e-02f, -8.82124826e-02f, 3.75468373e-01f, 1.25384733e-01f, 1.37939170e-01f, 2.06010059e-01f, 2.05712512e-01f, 1.18502649e-02f,
  5.55338450e-02f, 4.34524491e-02f, 3.48777114e-03f, 9.72723216e-02f, 3.08846422e-02f, 1.36423782e-01f, -3.63053940e-02f, 6.48457855e-02f, 6.44989163e-02f, -3.67636024e-03f,
  1.66771431e-02f, -1.07906595e-01f, -2.58950204e-01f, -2.60574906e-03f, -3.21779639e-01f, -2.39252836e-01f, 2.52079815e-02f, -1.72899272e-02f, 1.41270906e-01f, -3.06072272e-02f,
  -3.16768199e-01f, -2.10994884e-01f, -5.63629232e-02f, 2.75008917e-01f, 1.98706403e-01f, -1.79009121e-02f, 1.32404594e-02f, -1.52741998e-01f, 4.30136137e-02f, -2.86461413e-02f,
  2.76000798e-01f, 1.15508579e-01f, 2.53776848e-01f, 3.20935071e-01f, 1.54009849e-01f, 2.47637555e-01f, -1.17490761e-01f, -2.67383784e-01f, -2.37988070e-01f, -1.31246790e-01f,
  3.68038118e-01f, -4.91098352e-02f, -1.92954138e-01f, 1.09151110e-01f, -1.61102153e-02f, -1.58313453e-01f, -1.23084471e-01f, 2.14312926e-01f, -1.70515999e-02f, -8.31230953e-02f,
  1.72646269e-01f, 8.23023170e-02f, -1.68887272e-01f, 9.88993794e-02f, -1.24666356e-01f, -1.14822671e-01f, -1.23937748e-01f, -1.31238818e-01f, -1.14192612e-01f, -8.42075571e-02f,
  5.79446927e-02f, 7.68913403e-02f, 8.83813351e-02f, 1.69880800e-02f, -1.51357828e-02f, 2.24181116e-02f, 4.57509607e-02f, 8.00621063e-02f, 8.48140940e-02f, 3.65015380e-02f,
  -9.96412616e-03f, 7.52476379e-02f, 5.37413694e-02f, 4.04278487e-02f, -1.12257153e-01f, -3.15063111e-02f, 3.89288634e-01f, 1.00068301e-01f, -3.83834094e-01f, -7.51058459e-02f,
  9.16106775e-02f, 2.03398854e-01f, -2.72810817e-01f, -1.45380855e-01f, 3.70122641e-01f, 1.20819032e-01f, -1.58014715e-01f, -3.09255213e-01f, 1.45617932e-01f, 1.01123713e-01f,
  1.15319984e-02f, 5.29847853e-02f, -6.85286298e-02f, 4.27625515e-02f, 8.99274126e-02f, 5.13217459e-03f, -3.19491401e-02f, -9.53684598e-02f, 2.14142710e-01f, -1.00394972e-01f,
  1.83688372e-01f, 2.49179393e-01f, -1.20777264e-02f, -4.13840488e-02f, 1.40667975e-01f, -1.73927441e-01f, -7.90440738e-02f, -6.17592990e-01f, 2.74137229e-01f, 2.79998511e-01f,
  6.59219623e-02f, 2.42247626e-01f, -1.23151027e-01f, 3.14992517e-01f, -1.90619156e-02f, -2.62806900e-02f, -1.26776351e-02f, -3.02797973e-01f, 1.80052698e-01f, 1.93631768e-01f,
  -1.90728530e-01f, -1.85504511e-01f, -2.90417314e-01f, -3.07166785e-01f, -2.83225589e-02f, 8.64433497e-02f, 1.20113596e-01f, -6.38804585e-02f, 1.31064309e-02f, 9.99761671e-02f,
  -1.63793424e-03f, -9.61326808e-03f, 4.23208661e-02f, 1.37080997e-02f, 2.42807224e-01f, -1.40421763e-01f, 1.16064027e-01f, -1.15302429e-01f, 1.58520490e-01f, -1.12053245e-01f,
  -7.85603300e-02f, -8.10128376e-02f, 2.43474945e-01f, 2.53090948e-01f, -2.79419590e-02f, 6.94731325e-02f, 1.94808885e-01f, 3.39877903e-02f, -9.85997692e-02f, 2.67372817e-01f,
  1.68554246e-01f, -6.43460751e-02f, -2.39660159e-01f, 1.63564533e-01f, -1.98230967e-01f, 1.05460294e-01f, -5.57277054e-02f, -4.42047566e-01f, -5.23907058e-02f, -9.16213468e-02f,
  -2.78854758e-01f, -1.86762229e-01f, -2.82279372e-01f, -9.65408981e-02f, -4.80114669e-01f, -1.01363368e-01f, 1.33197859e-01f, 6.31327257e-02f, -5.09774406e-03f, -8.81471634e-02f,
  2.63727516e-01f, -1.24669701e-01f, -2.53434718e-01f, 1.53680637e-01f, 1.47593960e-01f, -1.31308183e-01f, 1.90145984e-01f, 2.00439873e-03f, 1.65195704e-01f, -2.30347794e-02f,
  1.90243796e-01f, 2.38202363e-01f, 5.23773171e-02f, -1.36016920e-01f, -1.50084719e-02f, 9.47200358e-02f, 2.47989178e-01f, 1.23638272e-01f, 2.02201650e-01f, 1.68660372e-01f,
  8.23341683e-02f, 5.74302953e-03f, -2.53200829e-02f, 1.68960661e-01f, 1.63015157e-01f, 2.06978649e-01f, 1.68399364e-01f, 2.32706606e-01f, 1.82930648e-01f, 3.70962843e-02f,
  -5.73375523e-02f, -2.40841433e-01f, -2.50872336e-02f, 1.87881708e-01f, 3.10852319e-01f, 2.24286228e-01f, 9.29217692e-03f, -9.84534323e-02f, -1.18158720e-01f, -1.47620320e-01f,
  1.81591976e-02f, 6.71676248e-02f, 5.75230002e-01f, 2.37233073e-01f, 8.57824981e-02f, 1.29570365e-01f, 3.92004937e-01f, -2.07130775e-01f, 1.39456093e-01f, 5.92280738e-02f,
  -1.12681471e-01f, 9.60247889e-02f, 9.52625945e-02f, 1.77666023e-01f, 1.22254685e-01f, -5.12761474e-01f, 3.73614937e-01f, 1.24042645e-01f, -1.68779809e-02f, -1.74023196e-01f,
  4.36737873e-02f, -2.95158625e-02f, -9.44060385e-02f, -2.47579083e-01f, -4.10258444e-03f, 2.15727389e-02f, 2.75377691e-01f, -6.00677989e-02f, -1.88827410e-01f, -3.30763519e-01f,
  1.55766517e-01f, 2.51897186e-01f, 3.13117117e-01f, 3.69116366e-02f, 1.29931094e-02f, -1.46644995e-01f, -5.31376041e-02f, -1.07571654e-01f, 1.09813549e-01f, 1.19251519e-01f,
  -1.40063807e-01f, 3.22710097e-01f, 2.33803820e-02f, 8.82012323e-02f, 1.21503986e-01f, -1.15045093e-01f, 3.40773687e-02f, 1.09448262e-01f, 8.32860023e-02f, 1.81421861e-01f,
  -5.50545938e-03f, -4.65833396e-03f, -1.53212711e-01f, -1.67077798e-02f, 8.09898004e-02f, -1.28161997e-01f, -9.98396650e-02f, 9.51440930e-02f, 3.27761233e-01f, 1.82530597e-01f,
  2.08838984e-01f, -2.73930013e-01f, 1.18458368e-01f, 4.90780454e-04f, 4.00965661e-01f, -3.23640555e-01f, -4.36577201e-03f, 1.98321596e-01f, 1.59763739e-01f, 2.37368062e-01f,
  -3.54061536e-02f, -2.45068610e-01f, 9.83968526e-02f, 8.62888619e-02f, 3.83464038e-01f, -3.02755117e-01f, 2.11661775e-02f, -3.54143471e-01f, -1.09905384e-01f, -6.29842877e-02f,
  -2.10574940e-02f, 1.19591311e-01f, -3.54245692e-01f, -2.57302254e-01f, -2.28088588e-01f, -1.38613939e-01f, 1.30038876e-02f, 3.09267007e-02f, 3.46695371e-02f, 7.50149414e-02f,
  1.52668461e-01f, 1.28221093e-02f, -2.33095884e-01f, -3.81140858e-01f, 1.61791176e-01f, 1.38148814e-01f, 2.69550145e-01f, 3.45062554e-01f, -1.68765932e-01f, -1.51529074e-01f,
  -5.19494563e-02f, -1.14617743e-01f, -1.38005123e-01f, 7.09250644e-02f, 7.52570182e-02f, -2.76762005e-02f, -1.33174971e-01f, 8.15251023e-02f, 9.78625342e-02f, 1.43067360e-01f,
  -1.78724043e-02f, 3.27139646e-02f, -2.94532478e-02f, -4.32586446e-02f, 8.50147679e-02f, 2.05585193e-02f, 8.59443843e-02f, -3.35579477e-02f, -9.67644304e-02f, 4.29640617e-03f,
  -5.31472825e-03f, 2.45593503e-01f, -7.39295781e-02f, -3.00396293e-01f, 1.96778476e-01f, 1.67740390e-01f, -1.70845613e-01f, -3.39596830e-02f, -1.12549864e-01f, 2.87639827e-01f,
  -3.38606358e-01f, -3.02909147e-02f, -4.66405563e-02f, -1.99756473e-01f, -2.73117632e-01f, 9.09034610e-02f, -4.12270576e-01f, -1.65053099e-01f, -1.33115575e-01f, 9.32571441e-02f,
  -3.47292304e-01f, -1.89679578e-01f, -3.53515953e-01f, 4.42143939e-02f, -2.78999895e-01f, 1.14943936e-01f, -8.36272985e-02f, 3.93103473e-02f, 8.98422748e-02f, -1.76769495e-02f,
  -1.23943053e-01f, 7.43717477e-02f, 2.57606268e-01f, -2.73615956e-01f, -2.97192961e-01f, -7.92359114e-02f, 4.70857993e-02f, 7.75853395e-02f, 1.74347032e-02f, -2.42525036e-03f,
  -2.02176914e-01f, 2.76936870e-02f, 1.60871506e-01f, 2.97404617e-01f, 8.72592479e-02f, -4.99772727e-02f, 1.13383114e-01f, 1.10072149e-02f, 2.48578042e-01f, 9.71416011e-02f
};

// L1_fan_Bp_bar (Shape: 1 x 40)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 40;
const float L1_fan_Bp_bar_data[] = {
  2.05862626e-01f, 1.60084248e-01f, 1.14073515e-01f, 2.16131344e-01f, 1.65519223e-01f, 9.86689478e-02f, -1.07362136e-01f, 1.99755877e-01f, 1.99908093e-01f, 3.00823987e-01f,
  1.29283607e-01f, -3.27587612e-02f, 1.00497022e-01f, 8.02005678e-02f, 1.67651251e-01f, 1.34829879e-01f, 1.45139739e-01f, 1.00628339e-01f, 6.84784586e-03f, 1.72289073e-01f,
  2.19282582e-01f, -2.46728212e-02f, 1.54475495e-01f, 1.27746584e-02f, 2.26527706e-01f, 2.14915335e-01f, 1.20051332e-01f, 1.90285355e-01f, 2.10539043e-01f, 1.63149953e-01f,
  3.52634005e-02f, -2.06014901e-01f, 2.63556391e-01f, 1.80048004e-01f, 7.70960525e-02f, 2.97358245e-01f, 1.07656591e-01f, 1.26531497e-01f, 1.04284875e-01f, 1.43148467e-01f
};

// L2_fan_Wp (Shape: 12 x 64)
const int L2_fan_Wp_rows = 12;
const int L2_fan_Wp_cols = 64;
const float L2_fan_Wp_data[] = {
  7.98304155e-02f, 7.79271498e-02f, 4.01486903e-02f, -4.82577309e-02f, -4.63979654e-02f, 4.88417745e-02f, -1.17196046e-01f, -5.03866263e-02f, -1.49514256e-02f, -2.59509951e-01f,
  -1.04037814e-01f, -2.09473018e-02f, 1.19152717e-01f, -1.50688946e-01f, -5.13220467e-02f, 7.58669898e-02f, 2.03880772e-01f, 1.46636302e-02f, -1.77752957e-01f, 3.56176905e-02f,
  -1.63870722e-01f, -2.47879386e-01f, -5.28588668e-02f, -9.81905311e-02f, -1.33601263e-01f, -3.95740643e-02f, -9.94363055e-02f, 1.68108299e-01f, 1.40513882e-01f, 2.71884650e-02f,
  -7.14531317e-02f, -1.82720125e-01f, 6.02103435e-02f, -7.79069262e-03f, -8.29112716e-03f, 2.74178833e-01f, 1.35525111e-02f, -3.40186618e-02f, -2.81525552e-02f, 2.31975596e-02f,
  -2.03807980e-01f, 4.90172878e-02f, 1.10682212e-01f, 1.38892531e-01f, 1.05569866e-02f, 4.50956076e-02f, 2.04065770e-01f, -5.33665810e-03f, -1.06844775e-01f, 9.72625464e-02f,
  -1.54601350e-01f, -1.27514794e-01f, 1.75676152e-01f, -4.20959108e-02f, -4.86682169e-02f, 1.90389365e-01f, 7.36434534e-02f, 1.89745411e-01f, -1.53591469e-01f, 2.15846762e-01f,
  1.30232140e-01f, -3.35327983e-02f, 1.42024770e-01f, 8.46692324e-02f, 1.31602496e-01f, 1.18830338e-01f, 4.76593412e-02f, -4.37875390e-02f, 8.05406570e-02f, -1.08412564e-01f,
  -2.19063610e-02f, -1.23748355e-01f, -1.17145255e-02f, 2.32683308e-02f, 1.90128051e-02f, -1.61883570e-02f, -1.90189868e-01f, 6.98938295e-02f, 2.90488899e-01f, -3.24985117e-01f,
  2.30804849e-02f, -3.35397832e-02f, 1.07975863e-01f, 1.21179856e-01f, -1.94762200e-01f, 2.21464515e-01f, -2.22332962e-02f, 1.14545345e-01f, 1.94914564e-01f, -9.14861709e-02f,
  -1.44911945e-01f, -2.08016664e-01f, -1.17823526e-01f, 2.02661395e-01f, 8.75037983e-02f, 1.15313657e-01f, 7.32234865e-02f, -3.97983789e-02f, 3.20484601e-02f, 1.72453105e-01f,
  -5.91695830e-02f, -1.11108422e-01f, -1.41338930e-01f, 1.78366095e-01f, 1.89493760e-01f, -9.93394554e-02f, 6.91004395e-02f, 1.45192876e-01f, 2.29140684e-01f, -4.22609113e-02f,
  -5.16235605e-02f, -3.72309349e-02f, -1.32659912e-01f, 6.57941541e-03f, 1.07294619e-01f, 1.07213587e-01f, 1.13860629e-01f, -5.99326566e-02f, -2.39838108e-01f, 1.16323546e-01f,
  1.66317046e-01f, 2.43801717e-02f, 1.14508644e-01f, -1.12911642e-01f, 1.06809177e-01f, -5.87037485e-03f, -1.22027077e-01f, 9.90625024e-02f, 6.61531836e-02f, 1.58701763e-01f,
  -3.63740139e-02f, -1.03067487e-01f, -2.66452637e-02f, 3.30322534e-02f, -1.31597582e-04f, 5.36222272e-02f, 5.01422435e-02f, -1.87650230e-02f, 1.86450273e-01f, -1.39831990e-01f,
  2.99170315e-02f, -1.87823996e-02f, 2.30608657e-01f, 1.73309311e-01f, -1.29298810e-02f, -2.07420945e-01f, 1.89985722e-01f, 2.62376815e-01f, 4.31379080e-02f, 6.26645759e-02f,
  -1.38881937e-01f, 7.17631727e-02f, 2.94560045e-01f, 1.08650468e-01f, -1.09471664e-01f, -2.82288175e-02f, 3.88002358e-02f, 9.90876481e-02f, -1.68693233e-02f, 1.68898642e-01f,
  1.16437979e-01f, 5.92824370e-02f, -7.43474737e-02f, 7.93926492e-02f, 2.35791970e-02f, -8.39255378e-02f, -3.31449248e-02f, 6.05525682e-03f, 1.82046011e-01f, -4.07031700e-02f,
  -2.08216265e-01f, 5.91173731e-02f, 6.53951615e-02f, -4.97445986e-02f, 1.02352627e-01f, 1.59099475e-01f, 5.45906983e-02f, -3.56434919e-02f, -6.69436827e-02f, 6.52919859e-02f,
  1.10188849e-01f, 8.50622877e-02f, -2.74769634e-01f, -3.07705682e-02f, 7.21309856e-02f, 1.59348786e-01f, -1.46638572e-01f, -6.69116154e-02f, -1.28349811e-01f, 2.08977442e-02f,
  -1.99084878e-01f, 1.90291628e-01f, -2.17983618e-01f, -1.27567977e-01f, -1.06369136e-02f, -7.20426207e-04f, 7.81861916e-02f, -2.96664774e-01f, -3.92749645e-02f, -1.32459760e-01f,
  -5.53161241e-02f, 1.45098537e-01f, -5.27142696e-02f, -2.67303344e-02f, -8.72816816e-02f, 2.89919436e-01f, -2.20026121e-01f, 1.07427992e-01f, 7.00064525e-02f, -1.86461270e-01f,
  1.48940712e-01f, 2.92624682e-01f, 5.28520755e-02f, -2.45196208e-01f, -6.58746436e-02f, -4.98774238e-02f, -2.62024552e-01f, -1.74543545e-01f, -4.56221700e-02f, 1.36571955e-02f,
  -1.09618872e-01f, 6.53012320e-02f, -1.25114098e-01f, -4.11103629e-02f, 1.14480622e-01f, 9.00173113e-02f, 1.70093089e-01f, 6.82094470e-02f, 5.46303466e-02f, 1.43055335e-01f,
  -1.41845450e-01f, -1.42576844e-01f, 1.40788808e-01f, -2.33250018e-02f, -1.93769466e-02f, 6.01412728e-02f, 1.98154017e-01f, -1.98799232e-03f, -1.73438191e-02f, -1.53063327e-01f,
  1.32209852e-01f, 6.10697493e-02f, 1.18096799e-01f, 1.42659992e-01f, -3.60178277e-02f, -1.47466838e-01f, 1.95138633e-01f, 7.80276442e-03f, 3.80417034e-02f, -1.35960907e-01f,
  -3.94146442e-02f, -1.61670938e-01f, -2.52625085e-02f, -1.38681099e-01f, -2.31578797e-01f, -4.86553274e-03f, -2.59638369e-01f, -5.96805736e-02f, 7.02151004e-03f, 8.77952725e-02f,
  9.95559990e-02f, -1.64361462e-01f, -1.00900643e-01f, -1.46816209e-01f, 2.27140561e-01f, 1.39959631e-02f, -6.40380057e-03f, -4.78183255e-02f, 2.47994617e-01f, 1.31992251e-01f,
  -3.41306984e-01f, 2.26559758e-01f, 7.31701851e-02f, -5.61316386e-02f, 1.52150825e-01f, 1.04650088e-01f, -1.68506846e-01f, -1.37297288e-01f, -1.09504230e-01f, -2.35689729e-01f,
  -1.02951206e-01f, 2.31724195e-02f, -9.00251493e-02f, 2.05877665e-02f, -1.52258649e-01f, 1.07421368e-01f, -1.12587571e-01f, 4.93157245e-02f, -6.56251088e-02f, -4.75873798e-02f,
  1.94852754e-01f, -9.45762023e-02f, -9.50379372e-02f, 9.49319452e-02f, -1.06859140e-01f, -8.27574357e-02f, 2.66158208e-02f, -3.08115352e-02f, -2.47131549e-02f, -4.65637483e-02f,
  1.29316226e-01f, 7.40725547e-02f, 1.14059728e-02f, -6.48445338e-02f, 6.43990338e-02f, 1.12353347e-01f, -1.09133750e-01f, 1.49935648e-01f, 1.80987313e-01f, -6.04276396e-02f,
  2.42902581e-02f, -1.65109366e-01f, 1.84861720e-01f, 3.12022772e-02f, 5.72221875e-02f, 1.20283633e-01f, 8.39053616e-02f, -1.51760820e-02f, -2.77958423e-01f, 1.17515042e-01f,
  -2.62657523e-01f, -9.35997441e-02f, -1.34062380e-01f, -3.87394018e-02f, 5.86032681e-02f, -6.71078265e-02f, 3.72766852e-02f, 2.19581738e-01f, 1.24702930e-01f, 1.22093923e-01f,
  -2.64764894e-02f, -9.99583900e-02f, 1.44935757e-01f, -8.64366218e-02f, -1.96328759e-01f, 1.68044288e-02f, 2.32818760e-02f, 1.57612681e-01f, -1.55783102e-01f, -2.41818666e-01f,
  4.87260073e-02f, -8.38535279e-02f, 1.63135454e-01f, -1.85086951e-01f, 2.08065789e-02f, 1.45202115e-01f, -2.44094878e-02f, 1.22061670e-01f, 4.78707589e-02f, -4.86298017e-02f,
  1.44412085e-01f, -3.87542993e-02f, -5.71334586e-02f, -2.27208789e-02f, 6.36592731e-02f, -1.36644104e-02f, -1.81108281e-01f, 9.12849903e-02f, 7.28272721e-02f, 8.39703381e-02f,
  -9.56232622e-02f, 2.46408656e-02f, 6.71110228e-02f, 2.28962637e-02f, -1.01698413e-01f, 4.56967130e-02f, 5.61616607e-02f, 6.92296922e-02f, 1.25417352e-01f, 4.60026041e-02f,
  -6.03900217e-02f, -1.52262360e-01f, 3.05557381e-02f, 6.87122047e-02f, -3.01162433e-02f, 1.92169338e-01f, -8.21544826e-02f, -3.16946171e-02f, 9.05688331e-02f, 9.08258781e-02f,
  3.00118793e-03f, 5.91706634e-02f, -6.04097173e-02f, -5.36219701e-02f, -4.81222533e-02f, -1.28719524e-01f, -4.36497554e-02f, -4.42324504e-02f, -5.09619415e-02f, 7.39874765e-02f,
  1.64755151e-01f, 4.05024242e-04f, 1.16363898e-01f, -9.52919424e-02f, -4.50542718e-02f, -1.39283361e-02f, 5.91195635e-02f, 1.37299165e-01f, 1.44827530e-01f, 8.20883289e-02f,
  -5.82541116e-02f, -6.20971993e-02f, -3.17152083e-01f, -3.78832996e-01f, -9.41079855e-03f, 1.49955135e-03f, 1.12296753e-01f, -1.53842002e-01f, -1.10311434e-01f, -5.70706241e-02f,
  -1.37206614e-01f, 1.35396659e-01f, 1.24737300e-01f, -3.94005813e-02f, 4.16983711e-03f, -9.31301415e-02f, -1.86427519e-01f, -4.73646298e-02f, 1.17616870e-01f, -9.24923271e-03f,
  1.73143651e-02f, 3.69386114e-02f, 1.91496804e-01f, 1.17191032e-01f, -2.82944322e-01f, 8.88816863e-02f, 1.27668113e-01f, 2.36868057e-02f, 5.07160265e-04f, 1.43533096e-01f,
  4.14960878e-03f, 5.55703510e-03f, 3.92939150e-03f, 1.96719080e-01f, -1.91346511e-01f, -1.61767647e-01f, 7.73990378e-02f, 6.49465621e-02f, 2.89584734e-02f, 1.75104477e-02f,
  7.53108179e-04f, -3.86524573e-02f, 2.33213454e-01f, -6.63952157e-02f, 8.19950849e-02f, 5.03078923e-02f, -4.35447730e-02f, -9.74329934e-02f, 1.09855784e-02f, -1.88016400e-01f,
  2.02770397e-01f, 1.19445458e-01f, -6.44699410e-02f, -1.09952956e-01f, 8.86428952e-02f, 1.28896490e-01f, -2.22371116e-01f, 1.66006293e-02f, 6.40675705e-03f, 2.12308660e-01f,
  3.55774499e-02f, -1.56844735e-01f, -2.08174706e-01f, 2.54495651e-01f, -1.12389870e-01f, -1.03655770e-01f, 2.07440838e-01f, 2.22108498e-01f, 2.08529338e-01f, 3.48676220e-02f,
  -1.03170231e-01f, 2.06987485e-01f, 4.36753929e-02f, -1.46914408e-01f, -7.79917371e-03f, 6.39353693e-02f, -1.90021589e-01f, -5.21973893e-03f, 5.98291568e-02f, 6.00352325e-02f,
  1.97727039e-01f, 1.51761815e-01f, -5.41893281e-02f, 1.40755415e-01f, 5.59432432e-02f, 7.80043751e-02f, 2.12547064e-01f, -4.09823493e-04f, 7.89879262e-02f, 3.89828682e-02f,
  -4.62853946e-02f, 8.10957421e-03f, -9.00992304e-02f, 4.44977880e-02f, 1.11612938e-01f, 3.79969738e-02f, -1.31921563e-02f, -1.60077989e-01f, 1.32264644e-01f, -8.03386346e-02f,
  1.13795228e-01f, -1.01314820e-01f, 9.86113846e-02f, -7.98785090e-02f, -4.70903032e-02f, 2.44529955e-02f, -1.81100622e-01f, -1.85521394e-01f, -1.60373211e-01f, 2.26034950e-02f,
  -2.00527757e-01f, -4.44639847e-02f, 1.97217613e-01f, -5.18731028e-02f, -1.44033223e-01f, 9.31654349e-02f, 1.65947467e-01f, -1.05629951e-01f, 5.77594750e-02f, -1.64328337e-01f,
  -2.61192471e-02f, 1.35201558e-01f, 1.04146019e-01f, 3.07342294e-03f, -1.71039224e-01f, 1.61792621e-01f, -1.86480433e-01f, 1.86489671e-01f, 9.07938927e-02f, 6.54117614e-02f,
  1.05112076e-01f, 8.23754966e-02f, -1.23872720e-01f, -8.71812627e-02f, -2.34532371e-01f, -5.62858582e-02f, -1.44944757e-01f, 2.16691956e-01f, 4.92419787e-02f, -1.84662063e-02f,
  -1.00631796e-01f, -9.56683829e-02f, 3.83906029e-02f, 1.60371348e-01f, 1.23112999e-01f, 2.56532151e-03f, 7.96292946e-02f, 1.66420341e-01f, 9.90739316e-02f, -9.89463031e-02f,
  1.41385734e-01f, 6.36092527e-03f, 3.04835662e-02f, -7.53617510e-02f, -3.58314812e-02f, 1.38919905e-01f, 3.65887843e-02f, 1.60616264e-02f, 2.71759987e-01f, 1.41001707e-02f,
  1.20080836e-01f, -1.35584265e-01f, 1.23489305e-01f, -1.63305148e-01f, 7.33385086e-02f, -7.93280527e-02f, 9.20515582e-02f, 6.82893619e-02f, -2.89502125e-02f, 1.58306196e-01f,
  -7.21594458e-03f, -1.79972239e-02f, 1.29837811e-01f, -1.28638104e-01f, -1.63506135e-01f, -5.62345833e-02f, -4.05767001e-03f, -1.52073845e-01f, -7.71007612e-02f, 1.93861146e-02f,
  -6.90442696e-02f, -1.18577078e-01f, -8.73191953e-02f, -1.02782607e-01f, 1.73981607e-01f, 1.49223313e-01f, 2.30612889e-01f, 1.42497767e-03f, -1.09211728e-01f, 1.82688326e-01f,
  -1.85766280e-01f, 3.28710452e-02f, 1.89399928e-01f, 8.61679316e-02f, 1.06646918e-01f, 1.04200706e-01f, 4.25483733e-02f, -2.47317195e-01f, -1.41741663e-01f, -1.13521621e-01f,
  7.47956261e-02f, 1.77890807e-01f, -6.08422942e-02f, -1.01140983e-01f, 3.16519327e-02f, 1.69963136e-01f, -1.50818676e-01f, 1.12235062e-01f, 1.35700539e-01f, -1.02738410e-01f,
  9.45909321e-03f, -8.28395337e-02f, -5.00282133e-03f, -1.50191918e-01f, -6.56969994e-02f, -5.25405817e-02f, 4.70212549e-02f, -5.37020341e-02f, -4.14019562e-02f, -2.48840824e-01f,
  3.21392082e-02f, -5.98751381e-02f, -4.29947600e-02f, 1.71659991e-01f, 1.80994406e-01f, -3.83159984e-03f, -2.60252282e-02f, 1.64451852e-01f, 8.68097693e-03f, 5.03743924e-02f,
  -1.13608927e-01f, 1.81374431e-01f, 1.78088963e-01f, 1.18204400e-01f, 6.74997121e-02f, 2.04531014e-01f, 8.19695890e-02f, -4.77333600e-03f, -1.53613240e-01f, 8.18512812e-02f,
  1.27407340e-02f, 6.89817518e-02f, 4.17559873e-03f, 6.81107938e-02f, -4.88881841e-02f, 8.39096233e-02f, 5.01104072e-02f, 4.35277559e-02f, -2.66242120e-02f, -1.18379798e-02f,
  -1.00492507e-01f, 1.78230107e-01f, 1.35141283e-01f, 3.61571796e-02f, -7.84712285e-03f, -3.00597586e-02f, 2.77253129e-02f, 6.25060275e-02f, 2.69403547e-01f, 1.93872094e-01f,
  -1.77089885e-01f, 5.70243187e-02f, 9.20587704e-02f, 3.83416824e-02f, 6.16388842e-02f, -1.84524581e-01f, -9.33828577e-02f, 1.02791032e-02f, -7.73759037e-02f, 2.03337684e-01f,
  1.03552498e-01f, -1.07807375e-01f, 1.27349287e-01f, 1.66921411e-02f, -4.27881740e-02f, -5.58827557e-02f, 5.58768697e-02f, 1.67751387e-01f, -7.39076510e-02f, 1.90288663e-01f,
  -5.36069237e-02f, 1.55249005e-02f, -1.03787646e-01f, 1.27342880e-01f, -8.96387454e-03f, -6.15843423e-02f, 1.18701637e-01f, -3.44869830e-02f, -1.43766209e-01f, -1.38509795e-01f,
  -1.79428503e-01f, 1.26882985e-01f, 1.79105662e-02f, -6.29639775e-02f, 1.14665173e-01f, -1.56470001e-01f, -9.37045366e-02f, 3.65406275e-02f, 1.37991697e-01f, -2.74021566e-01f,
  -1.74068704e-01f, -1.53781146e-01f, -2.77344114e-03f, 7.11384043e-02f, -2.30813965e-01f, 1.79275870e-02f, -7.76369199e-02f, 2.23497823e-02f, -5.18258661e-02f, 2.04715893e-01f,
  1.25659123e-01f, 5.20640649e-02f, -2.22971618e-01f, 1.23708911e-01f, -3.56547758e-02f, 3.39683220e-02f, 3.30926239e-01f, -4.52922247e-02f, 3.29916209e-01f, -4.17383201e-03f,
  -6.83296770e-02f, -1.50167719e-01f, 8.95449668e-02f, -2.27860317e-01f, -3.32300551e-04f, 2.63057113e-01f, 2.11953849e-01f, 9.48011205e-02f, 5.76189905e-03f, 8.34439993e-02f,
  -1.70103237e-01f, 1.54024482e-01f, -1.77149937e-01f, 8.28142986e-02f, -2.22670406e-01f, -1.17618926e-01f, 7.82408789e-02f, 1.02317922e-01f, -6.10883273e-02f, 3.40494029e-02f,
  -1.18127294e-01f, 7.02484697e-02f, 2.04263613e-01f, -1.12544529e-01f, 5.12293726e-02f, 7.76429847e-02f, 4.81416620e-02f, 1.11379541e-01f, -1.05220526e-02f, -2.92673949e-02f,
  -1.73427194e-01f, -1.95429191e-01f, -1.41181275e-02f, -1.30797178e-01f, 7.93495625e-02f, -1.40558537e-02f, 2.95908581e-02f, -9.36806723e-02f, -8.55614990e-02f, -5.36471121e-02f,
  -2.14393203e-05f, 5.16603626e-02f, -2.73652911e-01f, -2.74988674e-02f, 5.59532419e-02f, 1.05986558e-02f, -7.06730038e-02f, 2.31496990e-02f
};

// L2_fan_Wp_bar (Shape: 40 x 64)
const int L2_fan_Wp_bar_rows = 40;
const int L2_fan_Wp_bar_cols = 64;
const float L2_fan_Wp_bar_data[] = {
  -8.54486823e-02f, 2.74696261e-01f, -2.22474840e-02f, 3.17739487e-01f, 1.99830368e-01f, 2.60410905e-01f, 8.34432151e-03f, 2.34271809e-01f, 5.07331677e-02f, 1.25345722e-01f,
  3.48622620e-01f, 2.71929592e-01f, -1.92297280e-01f, 8.19088817e-02f, -3.50494087e-01f, -6.88037425e-02f, 8.08211565e-02f, -1.38402775e-01f, 2.87989825e-01f, -9.29002687e-02f,
  -2.21042428e-02f, 2.93055654e-01f, -1.34821981e-01f, 3.69956009e-02f, 3.77971649e-01f, 3.11217517e-01f, 1.62594080e-01f, 1.71618983e-01f, 3.28814775e-01f, 4.89276648e-01f,
  -6.54036105e-02f, 1.15668267e-01f, 1.03819974e-01f, -7.54594579e-02f, 1.46277115e-01f, -1.99813973e-02f, 7.15815574e-02f, -3.79065424e-02f, 4.29270193e-02f, 3.43860835e-01f,
  -1.69963673e-01f, -4.94424105e-02f, 9.40317661e-02f, 1.77197367e-01f, 1.02357298e-01f, -5.15036991e-05f, -1.15356751e-01f, -1.51021391e-01f, -1.30715361e-02f, 8.05979744e-02f,
  -2.83689231e-01f, 4.20251310e-01f, -6.71609268e-02f, 3.04908186e-01f, -3.19114476e-01f, 1.33357853e-01f, 2.29914322e-01f, -3.43153859e-03f, -1.17681228e-01f, 4.23986614e-01f,
  1.48305669e-01f, 1.74183279e-01f, 1.05012901e-01f, 1.05682842e-01f, 1.59844190e-01f, 1.73167408e-01f, 3.93754482e-01f, 2.66975224e-01f, 1.32398203e-01f, 1.50377005e-01f,
  1.88822687e-01f, 6.80223033e-02f, 4.17600721e-02f, 1.21566532e-02f, 1.40497237e-01f, 4.30402398e-01f, -2.73662835e-01f, -1.39527172e-01f, 6.17798679e-02f, 1.76682308e-01f,
  1.94106534e-01f, -2.22973779e-01f, 1.82077527e-01f, 1.22439049e-01f, 3.78112495e-01f, 6.83523491e-02f, -2.35094577e-01f, 1.39465779e-01f, 3.06731135e-01f, 2.84185946e-01f,
  5.19832075e-02f, 3.07794243e-01f, 1.61947682e-01f, 1.90561667e-01f, -2.23853346e-02f, 2.01786190e-01f, 3.07067364e-01f, 1.60439849e-01f, -8.73910561e-02f, -2.54319668e-01f,
  6.30955249e-02f, -2.36950368e-01f, 2.59062022e-01f, 2.45277405e-01f, -5.01560986e-01f, -7.73897395e-02f, -4.45535362e-01f, 1.55788407e-01f, 1.78560853e-01f, 8.62074345e-02f,
  2.23845318e-01f, -7.56832063e-02f, 3.28691676e-02f, 5.30421808e-02f, -2.59485058e-02f, 1.17226161e-01f, 9.35694054e-02f, -2.29646116e-01f, -1.37112111e-01f, -1.86377585e-01f,
  3.60039668e-03f, -1.46355286e-01f, -6.17932156e-02f, -3.58351320e-02f, -3.04119647e-01f, -7.75506347e-02f, -7.54501717e-03f, 1.62006952e-02f, 2.10559562e-01f, 1.89985186e-01f,
  3.80737513e-01f, 1.06270470e-01f, -1.32060170e-01f, 4.59634960e-02f, 1.04888663e-01f, -3.08372211e-02f, 2.50058979e-01f, -2.83582509e-01f, -5.31524457e-02f, 2.16233000e-01f,
  9.29045156e-02f, -2.59058356e-01f, 2.54128873e-01f, 2.81546235e-01f, 1.83040485e-01f, -1.65061310e-01f, 1.86695531e-01f, -4.04580794e-02f, 3.05944979e-01f, -1.81197360e-01f,
  -9.89704356e-02f, -4.74045351e-02f, 2.41476104e-01f, 7.07797036e-02f, 4.50446568e-02f, 2.60084212e-01f, 4.45975177e-02f, -4.29538116e-02f, 2.45112106e-02f, 1.54706061e-01f,
  3.50402802e-01f, 4.93487250e-03f, -1.86806619e-01f, -1.63939089e-01f, -1.89193152e-02f, -2.23431945e-01f, 2.50625908e-01f, 5.70062511e-02f, -2.39894971e-01f, -1.42791018e-01f,
  -7.71722719e-02f, 1.76906481e-01f, -2.66295969e-02f, -4.39953431e-02f, 6.48496449e-02f, -1.58088398e-03f, 1.61890730e-01f, 1.92157134e-01f, -1.30592601e-03f, 3.12472910e-01f,
  7.46317580e-02f, -8.81089792e-02f, -2.63036460e-01f, -1.90893918e-01f, 1.38073713e-01f, 3.54521126e-02f, -3.78377348e-01f, 1.16857678e-01f, 6.09660372e-02f, -7.56927654e-02f,
  2.17690915e-01f, -1.99965313e-02f, 1.24715947e-01f, 1.45015895e-01f, 4.82512591e-03f, 1.82443008e-01f, -1.21507920e-01f, 1.14795409e-01f, 2.79848188e-01f, -4.12056446e-02f,
  1.53522298e-01f, -6.48693666e-02f, 2.02644244e-01f, -8.34786743e-02f, -2.89389580e-01f, 3.22746113e-02f, 4.42765325e-01f, -4.02097017e-01f, 1.39004827e-01f, -2.46164411e-01f,
  3.18777449e-02f, 1.12383038e-01f, -8.31566826e-02f, 5.93460619e-01f, 1.71855502e-02f, 3.88964623e-01f, -1.90681033e-02f, -2.06307590e-01f, -2.50610355e-02f, 1.55245177e-02f,
  -7.64120370e-02f, 8.11243504e-02f, 1.26946852e-01f, -1.74679443e-01f, -1.25743896e-01f, 2.64191389e-01f, -1.38275564e-01f, -2.41226062e-01f, 2.28954256e-01f, 2.77978092e-01f,
  1.82884410e-01f, 3.07817489e-01f, 1.81390643e-01f, 2.83232898e-01f, 2.25190654e-01f, -1.01872072e-01f, 2.58246157e-02f, 1.41283706e-01f, -3.55904698e-01f, -2.77479917e-01f,
  -7.99864382e-02f, -1.99819393e-02f, -9.63501930e-02f, 2.28833258e-01f, -1.21233575e-01f, 1.77060187e-01f, 1.33216586e-02f, -3.18304747e-01f, 1.45480365e-01f, 8.59505758e-02f,
  -2.25717071e-02f, -3.84309143e-01f, 3.30539010e-02f, 7.65740871e-02f, 2.45745301e-01f, 2.17292011e-01f, -1.12934494e-02f, -1.59902364e-01f, -9.51095149e-02f, 2.28024140e-01f,
  2.23300502e-01f, -1.09639227e-01f, 1.33179903e-01f, 3.16435009e-01f, 1.04749002e-01f, -1.29336119e-01f, -4.53982837e-02f, 3.41469437e-01f, -5.29783189e-01f, 1.17825344e-01f,
  -1.93997577e-01f, -1.09983064e-01f, 2.00219616e-01f, -3.11895490e-01f, -1.17822491e-01f, -2.21211717e-01f, 1.79571033e-01f, 2.96860427e-01f, 6.06925674e-02f, 9.30608585e-02f,
  -1.41619399e-01f, 3.14505786e-01f, 2.76295871e-01f, -6.29018843e-02f, -5.20278886e-03f, 8.71237665e-02f, -8.88283029e-02f, -1.51933968e-01f, -1.82222247e-01f, -1.34519100e-01f,
  1.83497891e-02f, 6.32590577e-02f, 2.76990294e-01f, -1.37266576e-01f, 3.64390552e-01f, 3.51031214e-01f, -1.57906130e-01f, 2.32142687e-01f, 1.73138663e-01f, -1.44165233e-01f,
  -1.67102307e-01f, -1.65357828e-01f, 4.87900265e-02f, -3.19724768e-01f, 1.15776248e-01f, 2.18814328e-01f, 4.77323383e-01f, -6.66869432e-02f, -1.68043092e-01f, -3.09037231e-02f,
  1.76631391e-01f, -2.17111744e-02f, 2.00970117e-02f, 1.71277493e-01f, -1.83659300e-01f, -1.24418102e-01f, 1.45095348e-01f, -7.32345805e-02f, 4.01821941e-01f, -9.50458497e-02f,
  2.22438753e-01f, 1.14783542e-02f, 2.23427847e-01f, 2.08058670e-01f, -3.95486988e-02f, 1.21740445e-01f, 2.42164776e-01f, 3.83396536e-01f, 1.09946422e-01f, -2.24890634e-02f,
  1.92929476e-01f, 2.85437107e-01f, -2.47824222e-01f, -4.33651879e-02f, 1.54438719e-01f, -7.18109682e-02f, -3.26124057e-02f, -2.66457349e-01f, -1.64493263e-01f, -3.47610205e-01f,
  4.90312755e-01f, 5.07545531e-01f, 5.78763187e-02f, 4.13756996e-01f, 2.66533315e-01f, 7.25073591e-02f, 1.83356151e-01f, 3.36174630e-02f, -7.91692920e-03f, 1.44479930e-01f,
  6.18602242e-03f, 7.75587261e-02f, -2.19749548e-02f, -1.90652430e-01f, -1.21224545e-01f, -3.26432884e-01f, 2.04959914e-01f, 1.07885592e-01f, 3.50527018e-01f, 2.01875582e-01f,
  -2.68264323e-01f, 1.46760643e-01f, 7.12830946e-02f, -8.59466419e-02f, -1.87999874e-01f, -1.06528416e-01f, -1.02949031e-01f, -3.54955405e-01f, 1.16032891e-01f, 1.64569393e-01f,
  -4.12638672e-02f, 5.41010723e-02f, 1.04146171e-02f, -8.61332342e-02f, -6.37586936e-02f, -2.42258266e-01f, 1.12773463e-01f, -4.23428379e-02f, 1.90997161e-02f, -1.29900128e-01f,
  5.62878363e-02f, 1.55049443e-01f, 1.19042039e-01f, -7.51459450e-02f, 3.65890674e-02f, 2.21651360e-01f, -5.43621443e-02f, 9.57765877e-02f, 2.17760831e-01f, -3.29698734e-02f,
  1.63789600e-01f, -4.02174145e-02f, -9.88664571e-03f, 3.33630532e-01f, 1.52861714e-01f, 2.65390217e-01f, 5.90568855e-02f, 3.04404259e-01f, -3.76311272e-01f, 3.73556793e-01f,
  2.36686453e-01f, 1.04839608e-01f, 6.93104193e-02f, 1.83013499e-01f, -1.44476555e-02f, -4.45718974e-01f, -2.98868626e-01f, -1.36402547e-01f, 2.08541512e-01f, 1.42249644e-01f,
  -3.15501094e-02f, 2.58292288e-01f, 1.13041699e-01f, 2.35228259e-02f, 8.54254067e-02f, 1.55967087e-01f, 3.78717631e-01f, 2.73049951e-01f, 2.36926436e-01f, -1.52597904e-01f,
  2.93498449e-02f, -6.23207632e-03f, -1.84495851e-01f, -2.56082416e-01f, 3.60791713e-01f, -1.14731975e-01f, -2.50201851e-01f, 1.16794482e-01f, 2.31621951e-01f, 6.81940168e-02f,
  1.40525877e-01f, 1.43760011e-01f, 1.68500677e-01f, -1.75887883e-01f, -4.64002136e-03f, 2.18803719e-01f, 6.52139774e-03f, 1.58559214e-02f, -2.38978285e-02f, -1.08630963e-01f,
  -5.03105670e-02f, 1.27052993e-01f, 2.27694400e-02f, 3.73012990e-01f, -7.38214627e-02f, 5.22867218e-02f, -2.23823175e-01f, 5.45247532e-02f, -6.73215538e-02f, 1.20350078e-01f,
  -5.40514477e-02f, -1.61809683e-01f, 1.64912418e-01f, -3.42367850e-02f, 1.69686198e-01f, 1.17527142e-01f, 2.22056121e-01f, -8.98194313e-03f, 2.77194709e-01f, 9.12855845e-03f,
  2.66384352e-02f, 4.56708610e-01f, -4.06258047e-01f, -1.36013910e-01f, 2.92882353e-01f, 1.85403511e-01f, -9.52364206e-02f, -3.29614468e-02f, -3.76010537e-02f, -2.89529562e-01f,
  7.61357769e-02f, -7.42286369e-02f, -1.02209784e-01f, -1.53210521e-01f, 1.37484983e-01f, -1.51771739e-01f, -1.12865292e-01f, 2.74289340e-01f, 6.90327287e-02f, 2.76656181e-04f,
  -6.37237635e-03f, -1.67687923e-01f, 3.39341640e-01f, -4.07849908e-01f, 3.70704755e-02f, 2.74979383e-01f, -1.42225400e-01f, 1.98093042e-01f, -1.37905419e-01f, 2.84545749e-01f,
  -6.21209852e-02f, 1.70882538e-01f, -3.16157714e-02f, 1.46828249e-01f, 3.94641221e-01f, -8.11998267e-03f, 5.57484590e-02f, 7.22059757e-02f, -4.90605563e-01f, 6.38564900e-02f,
  3.16934377e-01f, -1.32469982e-01f, 3.37439090e-01f, -1.72345564e-01f, 1.04518205e-01f, -2.55842119e-01f, 2.48013750e-01f, 1.85415432e-01f, -3.51663142e-01f, -9.04450119e-02f,
  -1.52454330e-02f, -1.33654531e-02f, 1.51266530e-01f, 2.23152526e-02f, 1.61986008e-01f, -1.06350809e-01f, 1.90288574e-01f, 1.30844817e-01f, 1.96461722e-01f, 1.39596611e-01f,
  -1.16697013e-01f, 6.33613244e-02f, 3.89179364e-02f, 8.76983479e-02f, -2.60286063e-01f, 2.18952388e-01f, -2.37279698e-01f, -1.47093892e-01f, 1.76817864e-01f, 1.87655047e-01f,
  -2.28059769e-01f, -2.27986380e-01f, 2.80116230e-01f, 1.35037407e-01f, 3.76253158e-01f, 1.21609122e-01f, -3.21047604e-01f, 3.45587656e-02f, 3.51397991e-01f, -2.44428486e-01f,
  -7.81182498e-02f, 4.18433733e-02f, 1.19592480e-01f, -1.32431820e-01f, 5.97101673e-02f, -2.48569250e-01f, 2.18959942e-01f, -2.39833459e-01f, 2.81087279e-01f, 1.21345520e-01f,
  1.01056218e-01f, 1.52228639e-01f, 2.85972785e-02f, 2.82610208e-02f, -6.86619431e-02f, -1.79747224e-01f, -2.32030243e-01f, -3.61791179e-02f, 1.37461022e-01f, -5.48633970e-02f,
  1.82796612e-01f, -1.61570281e-01f, 6.94440603e-02f, -1.70742691e-01f, -2.70326883e-01f, -8.90563205e-02f, 2.26517498e-01f, -2.57624716e-01f, -1.08991131e-01f, -1.29579601e-03f,
  2.78374285e-01f, 5.63471690e-02f, -1.30858377e-01f, -1.54010832e-01f, 1.45244628e-01f, -9.86284614e-02f, 1.29611101e-02f, -2.21091047e-01f, -4.33558412e-02f, -5.40726744e-02f,
  -1.94714338e-01f, -1.60748973e-01f, -1.67012513e-02f, -2.31711775e-01f, -9.80923176e-02f, 6.29751906e-02f, 9.31194127e-02f, -3.03016957e-02f, -1.28920332e-01f, -4.86956239e-02f,
  2.65117258e-01f, -9.87376720e-02f, 1.99935526e-01f, 4.99462821e-02f, -2.83835083e-02f, 1.31038561e-01f, 1.98569849e-01f, 7.55187646e-02f, 7.83971101e-02f, 1.04860216e-01f,
  -2.51501799e-01f, 7.20242709e-02f, 2.47647405e-01f, 1.44750774e-01f, -9.07802507e-02f, -4.29526240e-01f, 1.37085199e-01f, -1.76400229e-01f, -7.20119029e-02f, 2.32563347e-01f,
  -8.41647908e-02f, 1.72069386e-01f, 7.97738284e-02f, 7.10215271e-02f, 7.74354041e-02f, -1.94043234e-01f, 6.67793602e-02f, 2.26125881e-01f, 1.05853625e-01f, -4.85630095e-01f,
  1.03895247e-01f, -5.88960759e-02f, -4.90406118e-02f, 1.41156986e-01f, 3.14151317e-01f, 2.58618623e-01f, 2.57451952e-01f, -2.52394110e-01f, 9.17098746e-02f, 7.69103914e-02f,
  3.57423812e-01f, -1.40228733e-01f, 2.01073587e-02f, 7.55058229e-02f, -7.12417737e-02f, -2.97276497e-01f, 1.60512596e-01f, 6.15205616e-02f, 7.04268962e-02f, -2.09510833e-01f,
  2.37342834e-01f, 1.02875076e-01f, -4.61135693e-02f, 2.13976070e-01f, -3.36319394e-02f, 3.20313126e-01f, 2.21725643e-01f, 3.67428869e-01f, -9.64178666e-02f, 2.86333442e-01f,
  1.57747880e-01f, 3.38704288e-02f, 2.21456274e-01f, -9.00019854e-02f, 1.47439525e-01f, 5.87761179e-02f, -4.37756002e-01f, 5.62135316e-02f, 1.32615596e-01f, -9.59525257e-02f,
  3.00084710e-01f, 1.62144005e-01f, 1.59573689e-01f, 3.60350102e-01f, 2.08673388e-01f, -1.46130219e-01f, -1.30089387e-01f, 3.23415488e-01f, 2.39117309e-01f, -1.24720216e-01f,
  1.73741981e-01f, 2.34317221e-02f, 3.64077352e-02f, 1.62303790e-01f, -6.07833676e-02f, -3.86658847e-01f, 9.89676639e-02f, 1.90411612e-01f, -1.24644153e-01f, -2.31353059e-01f,
  1.13669164e-01f, 3.01729232e-01f, -2.42728293e-01f, -1.91180483e-02f, -7.44683892e-02f, 2.77492940e-01f, -2.36159936e-01f, 1.19918520e-02f, -1.63895428e-01f, 7.28258714e-02f,
  -5.04764199e-01f, -1.34479657e-01f, 1.79447383e-01f, 8.56434777e-02f, 9.35981274e-02f, 2.68545207e-02f, -2.31179789e-01f, -3.20623606e-01f, 8.13038647e-02f, -1.32904202e-01f,
  -3.02347898e-01f, 1.45951554e-01f, 2.36605201e-02f, -3.00256312e-01f, 6.78622872e-02f, -8.38785022e-02f, 1.29545191e-02f, 2.14480579e-01f, 4.20896616e-03f, 4.57909368e-02f,
  1.93319228e-02f, -1.43112168e-01f, -1.20824330e-01f, 1.92610174e-01f, -1.09179020e-01f, -2.83647534e-02f, -3.06075532e-02f, -1.24165304e-01f, 5.53462990e-02f, -2.23455057e-01f,
  -1.93574518e-01f, 3.00247759e-01f, -1.68221369e-01f, 2.19547421e-01f, -2.15295270e-01f, 8.85643251e-03f, 1.15190431e-01f, -5.47150988e-03f, -5.75063527e-02f, 9.88209322e-02f,
  1.18806712e-01f, -1.79150715e-01f, 8.42950493e-02f, 1.36894688e-01f, 1.80705875e-01f, 2.39584632e-02f, 1.11308247e-01f, 7.37952217e-02f, 1.52922034e-01f, -5.86089380e-02f,
  3.56936455e-02f, 2.41128236e-01f, -2.13718846e-01f, -1.39200181e-01f, 3.64588499e-01f, 1.45689979e-01f, 3.09376046e-03f, -2.60400586e-02f, 1.39992341e-01f, 1.14860274e-01f,
  -3.52367669e-01f, 1.46943554e-02f, 1.50372446e-01f, -2.69614935e-01f, 2.37381570e-02f, 1.78721756e-01f, -3.93846512e-01f, 1.01021498e-01f, 6.01354539e-02f, -1.87119395e-02f,
  -1.55753177e-02f, -5.54188155e-03f, 1.24224663e-01f, 9.42457169e-02f, 8.36537257e-02f, 1.12506464e-01f, 8.53499472e-02f, 6.10557459e-02f, -2.36500353e-01f, -7.42824003e-02f,
  2.05453075e-02f, -8.61054435e-02f, -6.78111687e-02f, 6.80630282e-02f, 1.23152688e-01f, -2.16728643e-01f, 1.59364611e-01f, 9.28161070e-02f, 3.24595988e-01f, -4.81118351e-01f,
  6.22341484e-02f, 2.13208824e-01f, 2.48650849e-01f, -5.57273813e-02f, 1.41349360e-01f, -2.32988223e-01f, 1.25971347e-01f, 3.69857252e-01f, -3.44388574e-01f, -7.59504214e-02f,
  -1.25262588e-01f, -1.76253654e-02f, 2.62942433e-01f, -7.44331926e-02f, -1.84601501e-01f, 5.55096567e-02f, 9.07422602e-02f, 1.66862682e-01f, -3.03668737e-01f, -1.04954146e-01f,
  -1.25044137e-01f, 9.38923657e-02f, -3.69811714e-01f, 2.56468982e-01f, 5.39976731e-02f, 1.11917689e-01f, 7.97967315e-02f, -7.39066163e-03f, 2.10567459e-01f, 1.70129627e-01f,
  -3.32546271e-02f, -2.86891401e-01f, 7.24970251e-02f, -3.68812770e-01f, 5.84870353e-02f, 2.38492548e-01f, 2.13624090e-01f, 4.46425639e-02f, 1.08326852e-01f, 1.08515965e-02f,
  4.57365401e-02f, 1.69258758e-01f, -2.55309612e-01f, 1.47780433e-01f, 1.56070322e-01f, 3.26323718e-01f, -3.12124239e-03f, -3.57929170e-02f, 3.19542080e-01f, -3.92543763e-01f,
  -1.65955320e-01f, 1.92579210e-01f, 2.46579032e-02f, 2.77784914e-01f, 2.22582519e-01f, -5.38414828e-02f, 1.49245307e-01f, 3.05616200e-01f, 6.89785182e-02f, -6.75510541e-02f,
  1.38026953e-01f, 3.58447582e-01f, 2.86561936e-01f, 2.19333172e-01f, 2.66302198e-01f, 5.64543009e-02f, 9.65593904e-02f, 1.46047309e-01f, -4.15534496e-01f, -5.48731275e-02f,
  2.17339993e-01f, -2.87839640e-02f, 1.12273380e-01f, 8.94779861e-02f, -5.87278157e-02f, 3.28942955e-01f, 1.73524797e-01f, -9.85928848e-02f, -1.36718556e-01f, 3.03140968e-01f,
  1.87473729e-01f, 2.78732389e-01f, -4.22741733e-02f, 7.77433515e-02f, -5.57873584e-02f, 2.49547973e-01f, 6.50828658e-03f, -2.57003486e-01f, -1.25078216e-01f, 6.08213767e-02f,
  -3.24252844e-01f, -1.64182410e-01f, -9.49921981e-02f, 1.29681796e-01f, -2.32074618e-01f, 5.90619035e-02f, 6.91490769e-02f, 2.04690546e-01f, -8.85744840e-02f, 3.26484293e-02f,
  1.02546498e-01f, 2.20459387e-01f, -4.26369697e-01f, 7.23509640e-02f, 1.41650423e-01f, 2.88168550e-01f, -8.43272656e-02f, -1.55137196e-01f, 9.74667631e-03f, 1.00158462e-02f,
  -1.00242935e-01f, 3.62095460e-02f, 2.84672752e-02f, 4.83496562e-02f, -3.61380726e-02f, 1.59033760e-01f, -2.41895065e-01f, 3.16882044e-01f, 1.79488331e-01f, -1.68266743e-02f,
  3.06194782e-01f, 8.31774324e-02f, 3.45574729e-02f, -1.25886366e-01f, 7.57929459e-02f, -4.61511388e-02f, 2.38253653e-01f, 1.75038382e-01f, 3.70675325e-01f, -1.91249475e-01f,
  -1.75468415e-01f, 2.94016957e-01f, 1.31330594e-01f, -9.49160680e-02f, 6.37233108e-02f, 7.74922147e-02f, -1.90511215e-02f, -3.04721564e-01f, -1.22691028e-01f, -2.89262176e-01f,
  3.19725096e-01f, 2.66675949e-01f, 4.32661436e-02f, 3.58820140e-01f, 1.71780303e-01f, 4.66610491e-02f, 7.10087791e-02f, 3.15616101e-01f, 2.84307808e-01f, 1.26583904e-01f,
  1.82250053e-01f, -1.12934066e-02f, -2.91964114e-01f, -1.71948895e-01f, -6.01201691e-02f, 9.38882232e-02f, -2.32885152e-01f, -7.59489834e-02f, 3.88398231e-03f, 3.07442307e-01f,
  6.57364577e-02f, 5.66266142e-02f, 2.02079907e-01f, -2.00944655e-02f, 7.14476183e-02f, 5.63129224e-02f, -3.06708571e-02f, 2.28704050e-01f, 4.88878712e-02f, -1.46005191e-02f,
  -2.65923232e-01f, 1.51634812e-01f, 7.55858272e-02f, 5.17474115e-02f, -1.83996364e-01f, 4.61581051e-01f, -1.33331895e-01f, 1.22281387e-01f, -2.26168334e-01f, 1.18089281e-01f,
  2.36926544e-02f, 9.40424502e-02f, 2.50509918e-01f, 3.04215252e-01f, 2.62580633e-01f, 2.04403531e-02f, -2.21856702e-02f, 1.69591367e-01f, 9.64995325e-02f, 1.55754313e-01f,
  1.26973897e-01f, 4.20756415e-02f, 1.34153724e-01f, -8.99948254e-02f, -6.18350841e-02f, 2.07242191e-01f, -8.92822072e-03f, 3.20931561e-02f, -5.20886779e-02f, 5.86406142e-02f,
  1.51600108e-01f, -1.76107436e-01f, 2.11403474e-01f, -1.31735638e-01f, -1.97313204e-01f, 1.11883089e-01f, 4.67221029e-02f, 2.23454446e-01f, -1.02974018e-02f, -7.90732503e-02f,
  -7.90718198e-02f, 1.77113324e-01f, 2.52288252e-01f, 4.25452560e-01f, -1.75898224e-02f, -5.97006083e-02f, 1.29969761e-01f, 3.93199846e-02f, 2.86829472e-01f, -3.26389015e-01f,
  1.45074859e-01f, 4.28317813e-03f, -9.44119543e-02f, -1.99115157e-01f, 7.96031728e-02f, 5.32728657e-02f, -3.76243144e-02f, 1.42236546e-01f, 2.25048989e-01f, -8.67697224e-02f,
  2.14658812e-01f, -1.72410712e-01f, 1.65248231e-03f, -6.22594096e-02f, 2.46822104e-01f, -1.20203979e-01f, 1.15692255e-03f, 2.38736533e-03f, 1.27894685e-01f, -2.76425295e-02f,
  -1.21891670e-01f, 1.34546861e-01f, -1.64426625e-01f, -1.27263471e-01f, -2.21329883e-01f, -7.09961206e-02f, -9.65801775e-02f, 2.38182515e-01f, 1.78425372e-01f, 9.37667638e-02f,
  1.24727443e-01f, 4.66982871e-02f, 1.83928043e-01f, 1.18484952e-01f, 2.93228298e-01f, -1.94998700e-02f, 1.57563239e-01f, 3.42089921e-01f, 1.32173464e-01f, 2.39196956e-01f,
  1.60508931e-01f, -4.24302101e-01f, 9.95617285e-02f, 9.86609757e-02f, -1.84549540e-02f, 2.95979716e-02f, -2.33276427e-01f, 8.29538479e-02f, 7.00145215e-02f, -1.56493206e-02f,
  1.72991343e-02f, 3.74752492e-01f, 2.02217046e-02f, 2.60775000e-01f, -7.94521868e-02f, -7.41533116e-02f, 3.04260887e-02f, 2.49485582e-01f, -1.44121423e-01f, 4.86555137e-02f,
  -2.67851297e-02f, 3.69973816e-02f, 6.45333156e-02f, -1.67812556e-01f, 2.44567022e-01f, 3.59364539e-01f, -1.72246173e-01f, -5.49526252e-02f, 1.22282296e-01f, 1.98974982e-01f,
  2.06271608e-04f, 1.48336947e-01f, 3.92399542e-02f, 6.53767288e-02f, 4.41487208e-02f, -9.92543027e-02f, 2.84813732e-01f, -9.82858986e-02f, 1.36028662e-01f, -1.80774435e-01f,
  9.51691195e-02f, 9.18949395e-02f, -2.07359567e-01f, -1.24112666e-01f, 9.35589224e-02f, -9.85687673e-02f, -3.12468648e-01f, 1.79636061e-01f, -3.40926707e-01f, 8.36424588e-04f,
  -1.46790013e-01f, 1.25623912e-01f, 5.07526658e-02f, -1.14599138e-01f, 1.21060228e-02f, 1.66352049e-01f, 3.82749960e-02f, -1.35688245e-01f, 2.42219180e-01f, 1.36778235e-01f,
  -4.00425524e-01f, 3.55888367e-01f, -2.40603596e-01f, 3.04142907e-02f, 3.14305693e-01f, -1.29124388e-01f, -2.94451769e-02f, -3.57463628e-01f, 2.71211207e-01f, 8.57277885e-02f,
  -2.41697114e-02f, -1.99541822e-01f, 1.56418979e-01f, 1.43753424e-01f, 2.70939618e-01f, 1.41989693e-01f, 2.75704563e-02f, -3.37729156e-02f, -9.74305123e-02f, 6.31185248e-03f,
  -1.15964841e-02f, -2.19132707e-01f, 1.23684838e-01f, -4.85936105e-02f, 1.68017313e-01f, -1.53588310e-01f, 4.27879930e-01f, 1.86836541e-01f, -2.15880394e-01f, -1.09924562e-02f,
  8.02843794e-02f, 4.33632694e-02f, -1.28342450e-01f, -7.17694387e-02f, 1.29568875e-01f, 1.58648062e-02f, 9.31984335e-02f, 2.84407586e-01f, 3.14287722e-01f, 7.64310658e-02f,
  8.26650783e-02f, 6.39979392e-02f, 1.46964371e-01f, 3.32314968e-02f, 2.07505122e-01f, -1.05202943e-02f, -1.22898042e-01f, 3.25993747e-01f, 1.14216834e-01f, 1.35965616e-01f,
  2.81700671e-01f, 1.33508205e-01f, 3.60377014e-01f, -9.96111110e-02f, 3.32421929e-01f, 1.07979372e-01f, -2.99080778e-02f, 9.79639441e-02f, -6.37180805e-02f, 2.83176422e-01f,
  1.28222376e-01f, 1.47419184e-01f, -1.25833273e-01f, 2.11099029e-01f, -3.42426822e-02f, -4.00844514e-01f, -1.56806126e-01f, -1.27303535e-02f, -3.22683156e-01f, 2.92950988e-01f,
  -1.10745512e-01f, 1.76428318e-01f, 1.97078541e-01f, -5.28832972e-02f, 1.59074813e-02f, 8.26398432e-02f, 3.29289883e-02f, 2.74118707e-02f, -2.81423703e-02f, -2.36143082e-01f,
  3.76990102e-02f, 1.50198087e-01f, 2.09048212e-01f, 1.80484161e-01f, 1.08301388e-02f, 6.67242333e-02f, 4.61867824e-02f, -1.56335235e-02f, 1.59176812e-01f, 2.28453726e-01f,
  -4.43480104e-01f, 6.05657436e-02f, 4.52741951e-01f, 6.20956458e-02f, 2.27839172e-01f, 1.41633987e-01f, 1.91106543e-01f, 8.40385035e-02f, -2.25777447e-01f, -5.13213594e-03f,
  -9.84539986e-02f, -9.16881636e-02f, -5.25790632e-01f, -4.58992273e-02f, -2.68171936e-01f, 1.17087781e-01f, 3.58004123e-02f, 2.70810634e-01f, -1.04909077e-01f, 1.75484359e-01f,
  3.17418069e-01f, -3.79678421e-02f, -1.64329447e-02f, 2.30525628e-01f, -2.60841902e-02f, -6.76044375e-02f, -3.69104296e-02f, 6.93564266e-02f, 1.11232452e-01f, 1.26922414e-01f,
  3.23496200e-02f, -2.19132513e-01f, 1.19683392e-01f, 1.34256050e-01f, 3.15437913e-01f, -1.66610777e-01f, -3.29310931e-02f, 4.91759479e-02f, -1.75884247e-01f, 1.99415863e-01f,
  2.80233681e-01f, 2.15286925e-01f, 4.52434301e-01f, -2.05286101e-01f, 4.88835067e-01f, 1.64871693e-01f, 4.82499339e-02f, -7.62026161e-02f, -4.37189728e-01f, -2.19741240e-01f,
  4.95949872e-02f, -1.09223209e-01f, -8.81992206e-02f, 7.44730905e-02f, -5.13913669e-02f, 2.13398874e-01f, -1.19968101e-01f, 8.34553987e-02f, 1.43902704e-01f, 8.02004114e-02f,
  -2.25973763e-02f, -6.49773180e-02f, -1.20275132e-01f, -3.73279214e-01f, 2.62228787e-01f, 9.36224163e-02f, -4.20198947e-01f, -2.61127889e-01f, -7.30244219e-02f, 1.11205705e-01f,
  1.18888207e-01f, -3.42451334e-01f, 1.68865144e-01f, 2.05368195e-02f, -1.20306457e-03f, 2.30282426e-01f, -9.75568313e-03f, 1.88761711e-01f, 1.78044751e-01f, -1.94758147e-01f,
  -4.46947180e-02f, -1.89886510e-01f, 2.27946788e-01f, 5.79650626e-02f, -5.11238992e-01f, -2.58511841e-01f, -1.75734032e-02f, -5.91312230e-01f, -1.44451439e-01f, 2.44549185e-01f,
  4.48433638e-01f, 1.95908397e-01f, 1.44349381e-01f, 2.10533276e-01f, -3.19873653e-02f, 3.40250999e-01f, 8.57055932e-02f, -1.92919094e-02f, 6.35495931e-02f, 1.78216800e-01f,
  -4.76529598e-02f, 1.18022256e-01f, -1.96557656e-01f, -4.86576140e-01f, 3.34628910e-01f, -1.27068624e-01f, -1.98024049e-01f, 3.19327503e-01f, -2.12117769e-02f, 9.94392782e-02f,
  -5.94922295e-03f, 2.11676255e-01f, -4.20551980e-03f, 3.99178267e-01f, -1.18402138e-01f, -1.39973089e-01f, 1.37943299e-02f, 1.41884327e-01f, 1.90123349e-01f, -1.34651745e-02f,
  2.32008874e-01f, -4.47895983e-03f, 3.52442920e-01f, 4.90578443e-01f, -5.25835007e-02f, -8.19109306e-02f, 3.48167010e-02f, 4.31042373e-01f, -4.92649414e-02f, -2.45530158e-01f,
  2.50542790e-01f, 2.41638869e-01f, 9.88826081e-02f, -1.46169007e-01f, 3.71393502e-01f, 1.39005870e-01f, -8.56111869e-02f, 1.75225988e-01f, 1.90960765e-01f, 5.14781773e-02f,
  -1.30459458e-01f, 9.74969417e-02f, -3.34144682e-02f, 2.05745682e-01f, 2.62401044e-01f, 4.45670970e-02f, 1.09413676e-02f, -4.87919934e-02f, 3.27143669e-02f, -2.66951948e-01f,
  -4.86171022e-02f, 1.49528878e-02f, 2.61631072e-01f, -7.12645948e-02f, 2.22505897e-01f, 2.75091380e-02f, -9.72055644e-02f, -7.22640827e-02f, -3.24107222e-02f, 6.48966432e-02f,
  6.41136542e-02f, 2.31893837e-01f, 3.03060003e-02f, 4.26091999e-02f, 1.85868174e-01f, 2.82540359e-02f, -1.81256533e-01f, 3.61719638e-01f, 3.73095199e-02f, -1.95408821e-01f,
  2.45181441e-01f, -2.34187156e-01f, -2.42480472e-01f, -6.33509159e-02f, 2.09210724e-01f, 1.96532026e-01f, 1.51763991e-01f, 1.64197728e-01f, -1.36430532e-01f, 7.96903670e-02f,
  3.24294031e-01f, -1.43157586e-01f, -3.73147666e-01f, -8.91818032e-02f, -6.75730407e-02f, -4.03555155e-01f, -3.64834480e-02f, 1.11211330e-01f, -3.76108885e-02f, -2.13480607e-01f,
  3.16551954e-01f, 9.18938965e-02f, 6.28469288e-02f, 3.35139215e-01f, 1.40413687e-01f, 1.06078736e-01f, -1.30914718e-01f, -4.81540635e-02f, -1.17654443e-01f, 1.05163313e-01f,
  8.68833810e-02f, -1.20526150e-01f, 1.03389919e-01f, 1.49581470e-02f, 2.95361191e-01f, -2.31394973e-02f, -8.06276724e-02f, -1.84667483e-01f, 3.37446004e-01f, -3.52606237e-01f,
  1.42412066e-01f, -7.71404207e-02f, 2.25797340e-01f, -1.60599321e-01f, 2.52473284e-03f, -1.90465208e-02f, 1.06572315e-01f, 3.25134508e-02f, 2.93445110e-01f, 1.26350328e-01f,
  1.06679484e-01f, -1.97708476e-02f, -1.33893773e-01f, 2.72694649e-03f, 7.91647006e-03f, 5.94772398e-02f, 1.57878384e-01f, 6.83965832e-02f, 5.75088896e-02f, 1.64275959e-01f,
  -3.62506241e-01f, -2.60777492e-02f, -1.37886539e-01f, -1.70345947e-01f, -1.88531995e-01f, 3.66432786e-01f, 2.48256192e-01f, 1.73287928e-01f, 3.93524557e-01f, -1.65746495e-01f,
  -1.08908653e-01f, 2.85263956e-01f, -2.98720002e-01f, -2.09019601e-01f, 1.31408244e-01f, -9.04870331e-02f, -7.01257288e-02f, 6.81287870e-02f, 2.16742873e-01f, 1.70901954e-01f,
  2.25159332e-01f, 3.68504375e-02f, 7.06286505e-02f, -7.66758099e-02f, 1.49967819e-01f, 1.23466864e-01f, -1.59145832e-01f, 8.90795514e-02f, 1.20095119e-01f, -5.96383214e-03f,
  4.05678302e-02f, -9.24759209e-02f, 3.65938693e-01f, 1.07365496e-01f, 3.47209454e-01f, 1.69114992e-01f, 3.53987724e-01f, 7.96485916e-02f, -1.21093586e-01f, 1.48123518e-01f,
  1.93053335e-01f, 8.93081799e-02f, 2.85349935e-01f, -1.34844622e-02f, -2.88922876e-01f, -1.12757415e-01f, 1.96877465e-01f, -3.89684409e-01f, -1.53704420e-01f, -1.27182484e-01f,
  2.51941197e-02f, -3.45646665e-02f, 3.21364880e-01f, 2.69397378e-01f, 1.45311743e-01f, 3.15530300e-01f, -7.79510438e-02f, 1.45902961e-01f, 3.36102426e-01f, 3.81344825e-01f,
  2.58639529e-02f, 1.47920236e-01f, -3.24837118e-02f, 1.67136401e-01f, 7.83593766e-03f, -2.99528390e-01f, 1.98146880e-01f, -1.37897968e-01f, -3.33861142e-01f, -5.82763962e-02f,
  5.31871058e-02f, -2.04532951e-01f, 2.44548857e-01f, 4.95476991e-01f, 3.81541774e-02f, 2.81694263e-01f, 3.68889123e-01f, -7.55120069e-02f, 5.90428971e-02f, 4.27434482e-02f,
  1.15412526e-01f, 8.91668573e-02f, 3.80088836e-02f, 8.52666497e-02f, -2.67101657e-02f, -4.87097912e-02f, -3.01702730e-02f, 7.51580149e-02f, 2.19762817e-01f, 6.16511554e-02f,
  6.37745559e-02f, 2.59528935e-01f, 1.95872393e-02f, 1.80341512e-01f, -5.12981452e-02f, -3.58396359e-02f, -8.13329518e-02f, 5.22018149e-02f, -2.81492323e-01f, -6.02632901e-03f,
  -6.52273223e-02f, -1.18982308e-01f, -1.75274566e-01f, 1.75994962e-01f, -1.64437667e-01f, -2.92799342e-02f, -1.50679901e-01f, -1.08292505e-01f, 4.75158468e-02f, 1.67730853e-01f,
  1.53354242e-01f, -3.05734247e-01f, 9.35874283e-02f, 1.70344949e-01f, 1.61586881e-01f, 7.90103972e-02f, 1.09723426e-01f, 2.04443216e-01f, 4.48430283e-03f, 3.72473508e-01f,
  -1.21365182e-01f, 1.76173419e-01f, 1.84530184e-01f, 1.00715652e-01f, 1.53343707e-01f, 1.31169587e-01f, 1.11538641e-01f, 3.32287699e-01f, -3.61718446e-01f, -1.16964001e-02f,
  5.08973956e-01f, -1.38865769e-01f, 2.10106820e-01f, -2.88275659e-01f, 2.40717471e-01f, 1.09983712e-01f, 2.61297047e-01f, 5.57267249e-01f, -1.39944285e-01f, 2.92513222e-01f,
  2.26493403e-01f, 1.83975607e-01f, 1.24372989e-01f, 3.51860225e-02f, 1.71883851e-01f, 1.21297933e-01f, 2.08455045e-03f, 1.44336864e-01f, 2.62550712e-01f, 3.09732437e-01f,
  -2.24957898e-01f, -1.20907836e-01f, 5.32863364e-02f, -1.90244894e-02f, 3.44909310e-01f, 9.30075422e-02f, -1.03663519e-01f, 5.05632013e-02f, 2.17979357e-01f, 6.04255274e-02f,
  1.58828169e-01f, -9.05241817e-02f, -2.35785633e-01f, -1.87615782e-01f, -8.63571018e-02f, 8.05793628e-02f, 1.61283478e-01f, 3.14831764e-01f, 1.19018413e-01f, -2.80329417e-02f,
  -9.59472060e-02f, -2.70541400e-01f, 1.12999007e-01f, 5.59000392e-03f, -3.82505864e-01f, -3.17305803e-01f, -1.28788024e-01f, 1.90563962e-01f, 2.15803474e-01f, 1.05175920e-01f,
  1.21771678e-01f, -6.67962134e-02f, 1.26501113e-01f, 1.33989424e-01f, -2.87731707e-01f, 2.08855003e-01f, 1.20342441e-01f, -1.20395973e-01f, 1.75268110e-03f, 3.30524929e-02f,
  -1.78147689e-01f, -3.45174633e-02f, -1.28789008e-01f, -4.22776610e-01f, 3.94541413e-01f, -2.63908893e-01f, -1.24753239e-02f, -1.12543646e-02f, -2.05840349e-01f, -1.48459122e-01f,
  1.08280614e-01f, 1.35725111e-01f, 6.03790879e-02f, -5.75209036e-02f, 5.58252726e-03f, -1.75793990e-02f, 2.32885359e-03f, 5.39276451e-02f, 1.91567168e-01f, -2.73742020e-01f,
  1.61308353e-03f, -1.99186131e-01f, -2.79979885e-01f, -1.48819461e-01f, 1.08597405e-01f, 2.28129122e-02f, 1.59840018e-01f, 8.93028826e-02f, 1.37613058e-01f, 8.02349225e-02f,
  2.98987385e-02f, -5.19084819e-02f, 1.81533843e-01f, 1.60905913e-01f, -9.01312977e-02f, 3.16962786e-02f, -2.00206086e-01f, -3.44636083e-01f, -2.64911264e-01f, 1.53630212e-01f,
  -9.37585086e-02f, 3.18704508e-02f, -2.23538563e-01f, 1.56761885e-01f, -1.77038275e-02f, -1.88661013e-02f, -2.02319980e-01f, -1.36911601e-01f, 1.12468816e-01f, 1.08498372e-01f,
  -2.05984399e-01f, 1.51799172e-01f, 3.10160547e-01f, -9.99177396e-02f, 5.27141243e-02f, 1.78861782e-01f, 2.18116418e-01f, 4.56765778e-02f, 2.02083215e-01f, 1.75383851e-01f,
  1.18426263e-01f, 5.66217303e-03f, 4.06381823e-02f, 2.36302819e-02f, 1.05097681e-01f, 1.46474257e-01f, 1.49257183e-01f, -4.98060770e-02f, -2.57754922e-02f, -1.05344370e-01f,
  1.88891850e-02f, 3.11758667e-01f, -1.43323421e-01f, -1.36232316e-01f, 2.01952904e-01f, -5.11667728e-02f, 2.75309861e-01f, 2.69374177e-02f, -8.46626610e-02f, 5.45957983e-02f,
  1.23117656e-01f, 2.26057202e-01f, -3.75837199e-02f, -7.38654509e-02f, 7.05802813e-02f, -5.41457385e-02f, -8.74113888e-02f, 6.19771369e-02f, 5.11200950e-02f, -1.66065291e-01f,
  6.46788105e-02f, 2.33961672e-01f, 1.16340749e-01f, -1.33348852e-01f, -1.55398473e-02f, 1.32677466e-01f, -1.05929868e-02f, 1.85225204e-01f, -2.40546107e-01f, 2.19667092e-01f,
  -1.06322914e-01f, -1.28612697e-01f, 1.07654728e-01f, 1.89740613e-01f, -4.04326245e-02f, -1.97423592e-01f, 1.54882088e-01f, 1.85151726e-01f, 1.74733549e-01f, 8.41022804e-02f,
  4.86496557e-03f, -1.99831992e-01f, 2.36216858e-01f, 2.71375597e-01f, -1.36120141e-01f, 2.62572020e-01f, 2.80874044e-01f, -1.54933766e-01f, -3.08033586e-01f, -1.47633597e-01f,
  1.06202908e-01f, 7.22650737e-02f, 2.66162977e-02f, 2.40373369e-02f, -1.42829567e-01f, -1.58329159e-01f, 1.47303924e-01f, -7.88578093e-02f, -1.20456601e-02f, -3.27548862e-01f,
  6.35662824e-02f, 4.92312014e-01f, -3.22657824e-01f, 6.91770986e-02f, 3.06790888e-01f, -1.21231839e-01f, -2.70190299e-01f, -1.44826099e-01f, 7.90128335e-02f, -3.65408868e-01f,
  5.28237820e-02f, -3.63675207e-01f, -2.01619387e-01f, 2.15931877e-01f, 1.85065404e-01f, 1.90571606e-01f, -7.20758960e-02f, 2.71413792e-02f, 6.68995529e-02f, -1.49508566e-01f,
  -9.30746272e-03f, 1.51400149e-01f, 2.88602531e-01f, -2.45915130e-01f, -2.00890489e-02f, 1.20643973e-01f, 3.18539105e-02f, -1.46044955e-01f, 4.44070846e-02f, 5.50650209e-02f,
  -1.79467052e-01f, 1.63454026e-01f, -2.65476137e-01f, 1.58425376e-01f, 2.19392091e-01f, -4.66552190e-02f, 1.33479282e-01f, 2.15338558e-01f, 1.06589338e-02f, -3.01544905e-01f,
  7.03827664e-02f, 1.07736671e-02f, 3.01864922e-01f, 1.57024756e-01f, 1.93383113e-01f, -9.97992009e-02f, 1.71046942e-01f, 4.94487494e-01f, -5.73773347e-02f, 1.15880810e-01f,
  -1.15029231e-01f, -8.34004134e-02f, -4.37495857e-01f, 1.19295061e-01f, -6.23532236e-02f, 1.86621711e-01f, 1.70378372e-01f, -1.20636754e-01f, -4.64292131e-02f, -3.55480351e-02f,
  1.04689635e-01f, 7.32209941e-04f, 3.39938462e-01f, -2.08968725e-02f, -1.92944586e-01f, 2.37674147e-01f, -4.50421393e-01f, 3.00015479e-01f, 1.22794949e-01f, -1.50447786e-01f,
  2.01416180e-01f, 3.22570831e-01f, 5.29999472e-03f, -1.97290823e-01f, -3.72965813e-01f, -1.34455428e-01f, 2.56042212e-01f, 3.15157413e-01f, 2.18057945e-01f, 8.11565295e-03f,
  1.08438991e-01f, 1.68297112e-01f, 7.53244460e-02f, 4.90223467e-02f, 8.53256583e-02f, 2.23809127e-02f, 3.41337733e-02f, -1.03857033e-02f, 7.31663033e-02f, -2.99222022e-01f,
  3.71662602e-02f, 7.65188932e-02f, 2.07692504e-01f, -1.88247606e-01f, -5.16804226e-04f, 4.64561135e-02f, 6.83763772e-02f, -8.63610581e-02f, 1.39135450e-01f, 2.93677133e-02f,
  1.17555775e-01f, -4.54435870e-02f, 1.12528995e-01f, 2.68367864e-02f, -2.41281968e-02f, 3.26848440e-02f, -8.40929449e-02f, 4.39608516e-03f, 6.54920563e-02f, 2.95572933e-02f,
  -5.02411872e-02f, 2.12178588e-01f, -4.33278009e-02f, 6.02810010e-02f, -1.31609365e-01f, 2.00161664e-03f, 1.83892697e-01f, 3.96679729e-01f, 1.41962796e-01f, 8.97265449e-02f,
  -2.13921219e-01f, 3.92426372e-01f, 3.32999110e-01f, 3.56535912e-01f, 8.65054354e-02f, 7.30939209e-02f, 3.80921394e-01f, 3.10775369e-01f, -2.12983742e-01f, 7.21727237e-02f,
  3.23484868e-01f, 2.18105182e-01f, -1.52944535e-01f, -1.78851441e-01f, 1.54186666e-01f, -2.40886714e-02f, 2.17913434e-01f, 1.91205040e-01f, -1.93153530e-01f, 2.30190456e-01f,
  4.76130784e-01f, -6.03402965e-02f, -1.79795790e-02f, 3.12217057e-01f, 1.08800709e-01f, 2.59880960e-01f, 8.18753392e-02f, 4.77890931e-02f, -4.63176966e-02f, 1.91439483e-02f,
  -1.29257008e-01f, -3.77442271e-01f, 1.05782993e-01f, -4.77339588e-02f, 2.34211937e-01f, 2.28558034e-01f, -2.02350080e-01f, 1.37555659e-01f, -2.09140107e-01f, -8.39059502e-02f,
  -2.01127052e-01f, 1.55774012e-01f, -1.38920426e-01f, -4.67755571e-02f, -1.26106873e-01f, 1.77955672e-01f, -2.60741055e-01f, 7.69154578e-02f, 1.66889742e-01f, 1.87391862e-01f,
  -9.14881676e-02f, -1.07058972e-01f, 1.24272086e-01f, -4.61180881e-02f, -9.15878043e-02f, 3.81538980e-02f, -1.85233623e-01f, 1.53509393e-01f, 6.02394901e-02f, 1.89539026e-02f,
  1.18398629e-01f, 1.17277503e-01f, 1.96835458e-01f, 2.49751627e-01f, 1.14615798e-01f, 1.78908691e-01f, 2.35494584e-01f, 2.34798148e-01f, -5.57252765e-03f, 4.30850178e-01f,
  1.75878733e-01f, 3.66877973e-01f, 2.60835513e-02f, 1.61219060e-01f, -1.58091232e-01f, -2.38216408e-02f, -2.12672889e-01f, 1.47884086e-01f, 1.90326780e-01f, 2.69632995e-01f,
  3.90413672e-01f, 3.20041746e-01f, 7.19840899e-02f, 4.08397138e-01f, -7.35623837e-02f, 2.13620216e-02f, 3.68829519e-02f, 1.70743063e-01f, -9.00443569e-02f, 6.53549582e-02f,
  3.23147066e-02f, 6.34624511e-02f, 2.89405197e-01f, 3.14996541e-01f, -1.01571299e-01f, -2.10568115e-01f, 2.29610562e-01f, 1.60033733e-01f, -1.29831284e-01f, -6.45110011e-02f,
  2.64722973e-01f, 5.01082651e-02f, -4.02885497e-01f, -9.73767936e-02f, 3.41707140e-01f, -1.38915796e-02f, 1.33616365e-02f, 1.46996170e-01f, 7.90309608e-02f, -9.72730666e-02f,
  1.71239935e-02f, 1.05911963e-01f, -1.18790036e-02f, 5.59850708e-02f, 2.16747805e-01f, -2.55238116e-01f, -1.86498627e-01f, -7.40498826e-02f, 1.69260874e-01f, -9.93651748e-02f,
  -1.61571667e-01f, -1.13335080e-01f, -8.72561038e-02f, -5.34009449e-02f, 7.42553398e-02f, -1.10321619e-01f, 9.98471826e-02f, 6.18013181e-02f, -2.18410324e-02f, 8.58406536e-03f,
  -1.38205305e-01f, -3.22185248e-01f, 2.05204077e-02f, -1.33155165e-02f, 3.38110738e-02f, -1.04052484e-01f, -1.52031049e-01f, -6.55994490e-02f, 2.62997359e-01f, -6.27748445e-02f,
  -8.86109248e-02f, -4.35003452e-02f, -2.55930126e-01f, -3.55197102e-01f, 1.93893686e-01f, -5.53382300e-02f, 8.87407139e-02f, -1.84621215e-01f, 7.82026630e-03f, 3.65348577e-01f,
  2.47525141e-01f, 2.69835293e-01f, 3.15349698e-01f, -2.08981946e-01f, -1.56843498e-01f, 2.11774617e-01f, -6.71379790e-02f, 3.57496552e-02f, -7.89202303e-02f, 1.73936822e-02f,
  5.42167388e-02f, -6.22004755e-02f, 1.60446957e-01f, -2.03212887e-01f, 5.55821732e-02f, 4.90598269e-02f, -1.31338045e-01f, 1.81499690e-01f, -1.89691335e-01f, 1.80696230e-02f,
  2.10486993e-01f, 2.35269755e-01f, -3.63166928e-02f, 1.04880281e-01f, 2.04270422e-01f, -2.22579494e-01f, 1.62861750e-01f, 2.82180667e-01f, 1.55090943e-01f, 1.06660156e-02f,
  1.12578692e-02f, 1.07039012e-01f, 3.15903984e-02f, 4.36838925e-01f, 1.33397982e-01f, -2.06743181e-02f, 9.65366066e-02f, 1.71824787e-02f, -2.15284064e-01f, -6.27812669e-02f,
  -5.38752377e-02f, 9.80028510e-03f, -4.90070507e-02f, -1.51279330e-01f, 1.63648620e-01f, -4.01176699e-02f, 2.58550137e-01f, -4.62964959e-02f, 2.94285357e-01f, -1.00449227e-01f,
  -2.25767002e-01f, 4.19790834e-01f, 1.78305000e-01f, -1.54475629e-01f, 1.35567993e-01f, -3.68929237e-01f, 2.22107932e-01f, 7.95665309e-02f, 1.07295942e-02f, -6.03207126e-02f,
  -2.84629077e-01f, -1.68793306e-01f, 2.31955618e-01f, -1.60790220e-01f, -1.45743325e-01f, -5.87180257e-02f, 1.91352516e-02f, 6.21295236e-02f, -1.13749824e-01f, -2.16716364e-01f,
  1.95426606e-02f, 1.87037721e-01f, -6.11456968e-02f, -7.24984556e-02f, -5.01011759e-02f, -1.44582912e-01f, 3.81989107e-02f, 5.03662974e-02f, 3.70882452e-02f, 1.83112230e-02f,
  -1.38511136e-01f, -1.21038251e-01f, 1.10571794e-01f, -2.57964224e-01f, -5.23917601e-02f, -1.17907189e-02f, 9.64253247e-02f, -7.86968097e-02f, 4.25528921e-02f, 2.96102822e-01f,
  -9.04127434e-02f, 3.82940322e-02f, -2.30619043e-01f, -1.21978216e-01f, 1.08170725e-01f, 1.81440264e-01f, -2.75883704e-01f, -1.85425118e-01f, 1.21681683e-01f, -2.49424607e-01f,
  3.29278894e-02f, 1.73324913e-01f, -9.92037356e-02f, -4.50526476e-02f, 7.80366808e-02f, -8.59359205e-02f, -1.09648027e-01f, -1.16293199e-01f, -9.34562925e-03f, -1.12004206e-01f,
  -2.43394785e-02f, 7.77899101e-02f, 6.84313998e-02f, -2.85955489e-01f, 2.77091358e-02f, -9.87916887e-02f, -7.89300948e-02f, -4.35140580e-02f, 1.11371703e-01f, 1.75309449e-01f,
  -2.83882618e-01f, 3.18853766e-01f, 4.26913723e-02f, -2.86695212e-02f, 1.48903400e-01f, -1.79505751e-01f, -1.33242205e-01f, 1.21004209e-01f, 2.49018341e-01f, -1.19196527e-01f,
  8.44056383e-02f, -1.26306206e-01f, 3.98800708e-02f, 3.78734805e-02f, 1.11146279e-01f, 2.19385818e-01f, 6.54090121e-02f, -1.06879078e-01f, 1.59014717e-01f, 1.23970605e-01f,
  1.67874038e-01f, -4.17616606e-01f, 2.17758968e-01f, -4.29632105e-02f, 9.54298973e-02f, -1.29662499e-01f, 1.81843817e-01f, 1.54862970e-01f, -2.63359427e-01f, -2.81544924e-02f,
  2.57388443e-01f, -1.93160474e-01f, 2.29963914e-01f, -2.98229933e-01f, -1.35802791e-01f, 7.44711757e-02f, 1.20510243e-01f, 1.80828813e-02f, 1.96248695e-01f, 4.33581322e-02f,
  1.79643974e-01f, -4.42108437e-02f, 4.93021011e-02f, 2.53293514e-01f, -7.05994442e-02f, -9.69702303e-02f, -6.85706437e-02f, 2.83561587e-01f, 4.53600824e-01f, 1.42931953e-01f,
  3.14479768e-01f, 4.20163035e-01f, 4.25271988e-02f, -3.31015252e-02f, 7.94955865e-02f, 8.80880132e-02f, 1.54351771e-01f, 4.13937062e-01f, 7.02464283e-02f, 5.88456355e-02f,
  2.42805928e-02f, 3.06051999e-01f, -3.09800267e-01f, -3.71269807e-02f, 4.25915033e-01f, -4.04983088e-02f, 1.12009034e-01f, 1.62631739e-02f, 2.38701887e-02f, 1.70762733e-01f,
  1.25136554e-01f, 6.16994016e-02f, -2.26938486e-01f, 2.49723271e-01f, 7.28486478e-02f, 3.64945680e-01f, 8.96314625e-03f, 9.01973844e-02f, 2.38934726e-01f, 3.43329012e-01f,
  -1.97857827e-01f, -1.37136906e-01f, -1.10345304e-01f, -1.11879185e-01f, -2.82428801e-01f, -1.26862243e-01f, -8.16665590e-02f, 2.19386712e-01f, -2.40699679e-01f, 3.16598386e-01f,
  1.68284804e-01f, 1.29789352e-01f, 7.63577446e-02f, -3.56734842e-02f, -9.88692194e-02f, 1.51229531e-01f, -1.79445833e-01f, 2.70261019e-01f, 2.03707635e-01f, 2.38064006e-02f,
  -1.20301187e-01f, 3.07184514e-02f, -9.99823287e-02f, 3.77015732e-02f, -7.81855509e-02f, -9.92623866e-02f, 5.53342029e-02f, 3.26413848e-02f, -2.53977805e-01f, -6.79793535e-03f,
  -2.79484361e-01f, -1.39964789e-01f, -1.11121163e-01f, -3.34506631e-02f, 6.70569614e-02f, -2.75300235e-01f, 1.06102526e-01f, -2.23049372e-01f, 1.30281478e-01f, 2.01601043e-01f,
  1.86585426e-01f, -3.06799352e-01f, -8.23892131e-02f, 4.09635991e-01f, 1.60133131e-02f, -1.42316565e-01f, 3.36439282e-01f, -1.66603714e-01f, 1.12108640e-01f, 5.48859715e-01f,
  -2.74802566e-01f, 7.90444668e-03f, -1.99402735e-01f, -8.29019621e-02f, 5.29420935e-02f, -9.20984671e-02f, -1.47287637e-01f, -9.74859968e-02f, -2.12653920e-01f, 5.37182353e-02f,
  1.72903374e-01f, -4.38893773e-02f, -3.62925860e-03f, 2.61966527e-01f, 1.47176504e-01f, 9.58661437e-02f, 1.79628432e-02f, 1.95253283e-01f, 5.46283461e-02f, -5.11135682e-02f,
  3.56731951e-01f, 1.14739455e-01f, 4.06264290e-02f, -4.82182860e-01f, 3.14103484e-01f, 8.36490020e-02f, -1.91737086e-01f, 1.10007927e-01f, 1.71421230e-01f, -2.05697760e-01f,
  -4.03110161e-02f, -1.00792475e-01f, 5.62599336e-04f, -1.02861807e-01f, 4.25073132e-02f, -1.11308999e-01f, 1.76889405e-01f, 9.90031958e-02f, 1.55937791e-01f, -4.44606513e-01f,
  2.02630743e-01f, 2.43576504e-02f, -1.46176323e-01f, 1.57818943e-01f, 1.60140157e-01f, 5.75932190e-02f, 5.97450845e-02f, 2.03839704e-01f, 1.54545559e-02f, 3.58314484e-01f,
  1.40140355e-01f, 2.50300288e-01f, 1.52236924e-01f, 3.88370544e-01f, -2.26128623e-02f, 3.47218931e-01f, -8.04534554e-02f, 2.55714115e-02f, -4.64826226e-02f, -3.01341772e-01f,
  -2.75017023e-01f, 2.06685618e-01f, -2.30193332e-01f, 4.90592085e-02f, 9.91995782e-02f, 4.13527787e-01f, 3.90563875e-01f, 2.08982870e-01f, 2.00084690e-02f, 1.84602007e-01f,
  1.59310073e-01f, 7.10483789e-02f, 3.21356468e-02f, -1.01515085e-01f, 2.65164971e-01f, -1.44255087e-01f, 1.40865356e-01f, 2.01640755e-01f, 1.12622201e-01f, -1.71712101e-01f,
  3.46756965e-01f, 2.33647212e-01f, -1.20364882e-01f, 5.90601675e-02f, 3.33281428e-01f, 1.59345418e-01f, 1.53594008e-02f, -8.24268684e-02f, 1.47751316e-01f, -3.33421379e-02f,
  -2.49526143e-01f, 2.38984190e-02f, 1.84688568e-01f, -8.18943381e-02f, 2.99925804e-02f, -9.47839841e-02f, -1.69628590e-01f, 1.93336889e-01f, 1.33127555e-01f, -1.76000342e-01f,
  -8.14309269e-02f, -2.23209728e-02f, 1.25339210e-01f, -1.95969604e-02f, -1.67493880e-01f, 1.65083855e-01f, 3.84783775e-01f, -1.84134677e-01f, -3.16082053e-02f, -1.79912224e-02f,
  1.05270565e-01f, -9.41519737e-02f, 4.74655777e-02f, 9.79409181e-03f, -7.30946613e-03f, 2.37813145e-01f, 2.10916266e-01f, 6.47002012e-02f, 2.47900501e-01f, 6.70944229e-02f,
  1.16795376e-01f, 3.56018901e-01f, -3.27755392e-01f, 3.09497744e-01f, -2.90940376e-03f, -2.10410342e-01f, -1.25871822e-01f, -1.76782951e-01f, 3.29739809e-01f, -4.87860106e-02f,
  4.10958193e-02f, 2.23794151e-02f, 2.04833761e-01f, 1.09295063e-01f, 2.39996500e-02f, 1.95419893e-01f, -1.44811749e-01f, 1.89265266e-01f, -2.91474462e-02f, -2.03274578e-01f,
  -1.05120301e-01f, -3.12697850e-02f, 7.89626241e-02f, -3.38589042e-01f, 1.25568643e-01f, 7.35851331e-03f, 1.39156520e-01f, 1.60890475e-01f, -2.87212968e-01f, 1.96899518e-01f,
  -2.22865060e-01f, 7.34871998e-02f, -2.26428658e-01f, 7.59927332e-02f, 2.28428558e-01f, -7.75860529e-03f, -4.30554375e-02f, 1.10966809e-01f, -9.43663344e-03f, 6.84478208e-02f,
  1.45173937e-01f, -1.11942746e-01f, -3.10991053e-02f, 6.42405869e-03f, 1.06573135e-01f, -9.27788392e-02f, 4.00307998e-02f, 1.13017358e-01f, -7.94130042e-02f, 8.77668634e-02f,
  -7.52006397e-02f, 8.58138576e-02f, -2.34763265e-01f, -4.70572896e-02f, 2.63810307e-01f, 8.80858228e-02f, -1.93576831e-02f, 1.53646525e-02f, -1.35942316e-02f, -1.68039992e-01f,
  -1.52672485e-01f, 9.22244117e-02f, 4.37615328e-02f, -2.50905842e-01f, 2.31771693e-01f, -3.44020963e-01f, 1.41483560e-01f, 1.28593832e-01f, 1.45934969e-01f, 5.19603826e-02f,
  -3.20517689e-01f, 6.24970980e-02f, -2.61397541e-01f, -1.04006536e-01f, 1.19148239e-01f, -3.20153832e-01f, 2.58701771e-01f, 4.02458042e-01f, -6.62616035e-03f, 2.33446583e-01f,
  2.38067865e-01f, -1.41643226e-01f, 3.07512451e-02f, 1.67869359e-01f, 1.48466766e-01f, 9.41201225e-02f, -9.15970951e-02f, 1.14760660e-01f, 1.20622411e-01f, 3.78903635e-02f,
  2.22605616e-01f, -1.13368608e-01f, 2.77783453e-01f, 5.76355960e-03f, 1.22053530e-02f, 2.62749512e-02f, -3.01452391e-02f, 1.69113770e-01f, 3.95614654e-02f, 7.20183998e-02f,
  8.23902115e-02f, -1.05332427e-01f, 3.48380297e-01f, -3.18201393e-01f, -1.80517301e-01f, 8.93481299e-02f, -2.40934733e-02f, 1.15900077e-01f, 1.62484143e-02f, 5.53178862e-02f,
  7.16666058e-02f, 2.79511541e-01f, 8.95833224e-02f, 2.05551147e-01f, -2.50479449e-02f, 1.28528714e-01f, 1.76796705e-01f, 1.94224969e-01f, 8.78869370e-02f, 3.33423376e-01f,
  3.76833118e-02f, 1.45288333e-01f, 2.70413101e-01f, 9.50199664e-02f, 8.21780413e-02f, 2.52390444e-01f, -3.04915570e-02f, 2.11908948e-02f, 1.80908948e-01f, -1.41575739e-01f,
  -1.02896459e-01f, 1.55763224e-01f, -4.12566423e-01f, 1.20527625e-01f, -2.76260734e-01f, -8.19903612e-02f, 3.00270051e-01f, -1.10437023e-02f, 5.98112643e-02f, 2.15830263e-02f,
  7.72269890e-02f, 3.10463995e-01f, 1.62642077e-01f, 3.34711343e-01f, 3.19254071e-01f, -1.09364666e-01f, 1.39221042e-01f, -7.04638287e-02f, 6.16646484e-02f, -3.28225195e-02f,
  -3.26321200e-02f, -1.96476400e-01f, -6.05643327e-05f, 1.06303029e-01f, 9.22450423e-02f, -1.04734391e-01f, 2.86038723e-02f, 1.78636327e-01f, -9.96201113e-02f, 3.96095328e-02f,
  -1.83829263e-01f, 1.77720010e-01f, -7.56118074e-02f, -1.86984822e-01f, -7.76814967e-02f, 1.04996234e-01f, -1.18576437e-01f, -1.40590042e-01f, 9.84557644e-02f, 2.27370441e-01f,
  1.94824874e-01f, 1.45256624e-01f, -1.69451952e-01f, -7.19689950e-02f, -2.20038034e-02f, 2.34089762e-01f, -2.76287913e-01f, 8.13569725e-02f, 2.12344006e-01f, -9.78201330e-02f
};

// L2_fan_Bp_bar (Shape: 1 x 40)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 40;
const float L2_fan_Bp_bar_data[] = {
  2.67965257e-01f, 2.84592479e-01f, -4.40196972e-03f, 3.69887054e-02f, 2.26545990e-01f, 1.15837887e-01f, 7.56129101e-02f, 1.82699531e-01f, 1.11102872e-01f, -2.89473254e-02f,
  -6.54027537e-02f, 7.86497667e-02f, 2.24700153e-01f, 2.36904159e-01f, 7.77290165e-02f, 1.57398582e-01f, 1.43260792e-01f, 1.32195324e-01f, 1.58360079e-01f, 1.73469856e-01f,
  4.34077941e-02f, 1.47020698e-01f, 2.10960701e-01f, 1.59223139e-01f, 3.40851128e-01f, -1.30151987e-01f, 2.03653425e-03f, 3.79610360e-02f, 1.17656425e-01f, 1.85374156e-01f,
  1.37117729e-01f, 5.19228959e-03f, 2.23849583e-02f, 3.63575434e-03f, 2.48956501e-01f, -2.34606601e-02f, 3.61236297e-02f, 1.31209478e-01f, 4.62264232e-02f, 2.01027781e-01f
};

// L3_linear_W (Shape: 12 x 64)
const int L3_linear_W_rows = 12;
const int L3_linear_W_cols = 64;
const float L3_linear_W_data[] = {
  9.41311270e-02f, -1.39629140e-01f, -1.26767114e-01f, -3.05945668e-02f, -4.46606055e-02f, 1.41756609e-01f, -1.67156160e-01f, -1.91568837e-01f, 1.53951287e-01f, -1.79070479e-03f,
  -2.89188832e-01f, -1.40728593e-01f, -3.78820263e-02f, -3.04992020e-01f, -2.66673982e-01f, -7.07610846e-02f, 1.40160978e-01f, -1.21455185e-01f, -1.65607110e-01f, -1.12715028e-01f,
  -7.41614997e-02f, -1.18165962e-01f, 4.17635217e-02f, 8.22550133e-02f, 1.35990037e-02f, -4.59341019e-01f, -2.35177726e-01f, -3.64657104e-01f, -1.53299883e-01f, -2.24371836e-01f,
  1.53046966e-01f, -2.50190143e-02f, -7.32140392e-02f, -1.14401668e-01f, -5.10244351e-03f, 2.00135946e-01f, -5.05796492e-01f, -7.74265230e-02f, 1.15285501e-01f, 1.49533734e-01f,
  -2.34340787e-01f, -4.81371954e-02f, 1.04791127e-01f, -3.30246799e-02f, -4.20833565e-03f, -1.85576305e-01f, -2.49917090e-01f, -8.80274102e-02f, -3.27897966e-01f, 2.28915453e-01f,
  1.10449933e-01f, 2.25665331e-01f, -1.82594769e-02f, -3.14445138e-01f, -2.27149561e-01f, 1.87555268e-01f, 1.83377296e-01f, 1.81693926e-01f, -1.17707938e-01f, -1.20517477e-01f,
  -2.70008552e-03f, -8.78768116e-02f, 2.42522031e-01f, 1.71057075e-01f, -3.65823656e-01f, 8.77466947e-02f, -2.42998078e-02f, 1.63982380e-02f, -1.20637454e-01f, -9.16680396e-02f,
  4.15300503e-02f, 8.50589275e-02f, -1.34042338e-01f, -3.88617143e-02f, -1.02249436e-01f, 9.48807970e-02f, 7.66592622e-02f, -2.67262697e-01f, 1.74659207e-01f, -7.98207149e-02f,
  2.99727201e-01f, 4.23687585e-02f, 2.06499755e-01f, -4.35079813e-01f, 3.59463781e-01f, 1.46516994e-01f, -3.19255650e-01f, -8.38702098e-02f, 1.87225983e-01f, 9.65620019e-03f,
  9.07969773e-02f, -3.15724552e-01f, -2.47985750e-01f, -1.35284215e-01f, 2.05364987e-01f, 2.87026614e-02f, -3.22506845e-01f, -1.99134111e-01f, -9.09450650e-02f, -1.48239881e-01f,
  1.64667457e-01f, 1.36037290e-01f, 2.59280711e-01f, -2.05658302e-02f, 1.10680796e-01f, 1.79402009e-01f, -2.55479425e-01f, 1.17792055e-01f, -3.87401313e-01f, -2.70186841e-01f,
  -3.58599812e-01f, -2.79181421e-01f, -1.99912697e-01f, -1.84703022e-01f, 1.01051137e-01f, 2.22718403e-01f, 1.46929055e-01f, 1.32625669e-01f, -5.68774223e-01f, 1.34007886e-01f,
  9.52610299e-02f, -3.49444121e-01f, 7.52597451e-02f, 3.77012305e-02f, -5.64296603e-01f, 1.38726443e-01f, 4.39432524e-02f, 1.62811931e-02f, -2.85598218e-01f, 1.02770209e-01f,
  -3.40994112e-02f, 2.57694572e-01f, 1.38772011e-01f, -8.86990204e-02f, 1.42278120e-01f, 5.83229540e-03f, 1.07812159e-01f, 6.51857331e-02f, -1.12386882e-01f, -1.68815315e-01f,
  -1.89940587e-01f, -5.31127714e-02f, -3.81890565e-01f, 7.43172392e-02f, -2.68819511e-01f, 3.40538509e-02f, 1.57644078e-01f, -2.37347752e-01f, 2.98146401e-02f, 2.23558247e-01f,
  -9.59106907e-02f, -3.40267360e-01f, 2.22476423e-01f, 1.19260848e-01f, -4.79479492e-01f, -2.45484635e-01f, 2.79634506e-01f, 6.19909726e-02f, -1.10114582e-01f, 3.36445421e-01f,
  3.96883190e-01f, -3.25968593e-01f, -3.21568459e-01f, -1.26291765e-02f, -4.41622704e-01f, -2.35021964e-01f, -1.18055932e-01f, -3.04687712e-02f, -1.99950069e-01f, 2.53966421e-01f,
  4.45326157e-02f, -3.31662148e-01f, -3.90539408e-01f, 2.77610540e-01f, 5.90277128e-02f, -1.35626078e-01f, -3.12854022e-01f, -1.66903302e-01f, -1.15721663e-02f, 1.74756572e-01f,
  1.32741868e-01f, -1.92354932e-01f, 4.00163740e-01f, -2.47325690e-04f, -2.72203892e-01f, -1.48953900e-01f, -1.42647624e-01f, -2.97947496e-01f, 4.66198772e-02f, 1.58583790e-01f,
  -3.70939016e-01f, 1.86069347e-02f, -1.65602639e-01f, 3.22162956e-02f, -2.60801792e-01f, -9.35609490e-02f, 1.27169073e-01f, -2.06480250e-01f, -3.57964039e-02f, -1.14970967e-01f,
  1.69565901e-01f, 1.16945244e-01f, -1.00089133e-01f, -8.85243863e-02f, -1.29260749e-01f, 1.28286511e-01f, -5.55459000e-02f, 4.72547978e-01f, 2.18405146e-02f, 5.46751916e-02f,
  8.40511397e-02f, 1.40063867e-01f, 6.54606968e-02f, -1.35840818e-01f, 1.96345955e-01f, 1.24706931e-01f, -6.12181425e-01f, -2.19576374e-01f, 2.27859765e-01f, 1.54845295e-02f,
  -3.75941694e-01f, -6.01213351e-02f, 1.21433936e-01f, 2.15260908e-01f, 1.94503739e-01f, 1.09520026e-01f, -2.97791511e-02f, 6.56246990e-02f, -3.92879337e-01f, -1.16052710e-01f,
  -2.17676878e-01f, 1.61362424e-01f, -2.60105103e-01f, -4.69629377e-01f, 1.65857524e-01f, -5.24914190e-02f, 6.27094954e-02f, 1.26520500e-01f, 2.63356298e-01f, 1.14688694e-01f,
  -3.89346421e-01f, -1.93872601e-01f, 1.21168084e-01f, 3.69064435e-02f, -2.47798860e-01f, -3.53980541e-01f, 1.83310524e-01f, -3.52978587e-01f, 5.74209765e-02f, 1.94685891e-01f,
  -2.00668961e-01f, 2.85198212e-01f, 4.37953174e-02f, 2.17798762e-02f, -1.37148365e-01f, -5.10626547e-02f, 2.72365481e-01f, -7.55469352e-02f, -1.25392243e-01f, -1.54145211e-01f,
  -2.98079818e-01f, -2.46764377e-01f, 1.61246546e-02f, 1.77570820e-01f, -2.56156027e-01f, -3.59659016e-01f, 2.26855278e-02f, -3.74148339e-01f, -1.75523147e-01f, 1.39818415e-01f,
  8.58335793e-02f, -3.67873073e-01f, -1.82484046e-01f, 7.00945184e-02f, -3.84403579e-02f, -2.90717095e-01f, -3.27206314e-01f, -2.81101882e-01f, 1.30346090e-01f, -3.67569476e-02f,
  -1.14957243e-01f, -5.58884144e-01f, -1.03827298e-01f, 2.45998994e-01f, -1.20516233e-01f, 1.51723877e-01f, -1.72263101e-01f, 5.21243475e-02f, 7.09617184e-03f, 1.28992870e-01f,
  1.22345924e-01f, 2.30547935e-02f, 1.79513499e-01f, 3.38899605e-02f, -2.58984447e-01f, -1.51269034e-01f, -3.94723296e-01f, -7.01061040e-02f, 3.97770666e-02f, -7.69661367e-02f,
  9.57861990e-02f, 2.03939434e-02f, 1.87555298e-01f, 2.18578547e-01f, -1.09743871e-01f, 2.18491092e-01f, 1.05542637e-01f, -3.32064591e-02f, -1.39392689e-01f, 1.47340819e-01f,
  6.82001784e-02f, 1.88669324e-01f, -1.95160761e-01f, -5.67221306e-02f, -1.35936663e-01f, -2.29233056e-01f, 8.96022767e-02f, 1.25377846e-04f, -9.41503420e-02f, 1.01667553e-01f,
  4.74667221e-01f, 4.30911891e-02f, 5.42930625e-02f, 1.43737584e-01f, 2.53280196e-02f, 8.24738145e-02f, 1.80664197e-01f, 1.00723185e-01f, 1.41117841e-01f, 1.67437166e-01f,
  3.00570756e-01f, 8.81049931e-02f, 7.40928352e-02f, -4.54158112e-02f, 2.97314584e-01f, -8.12188610e-02f, -2.46211946e-01f, 4.65330690e-01f, -1.06512763e-01f, 3.44696045e-01f,
  -1.89087898e-01f, 1.12792365e-01f, -3.91973823e-01f, 1.65291354e-02f, 9.53494608e-02f, 7.63117224e-02f, 3.38504761e-02f, -3.21935296e-01f, -1.67984068e-01f, 1.27039492e-01f,
  1.36345267e-01f, -4.57782477e-01f, -3.32213044e-01f, -3.12365234e-01f, 1.56045943e-01f, -1.73783656e-02f, -4.22063097e-02f, 1.62197307e-01f, 1.45129219e-01f, 1.75323367e-01f,
  -4.34380621e-02f, -1.68963864e-01f, 1.51339859e-01f, -3.22318912e-01f, 1.04615748e-01f, -2.78164983e-01f, -1.07298769e-01f, 2.06356600e-01f, 5.47391362e-02f, -1.77927077e-01f,
  -4.70452802e-03f, -2.79824793e-01f, 4.55254018e-02f, 2.31384680e-01f, 1.98197722e-01f, 7.63698369e-02f, -4.50931847e-01f, -5.95722683e-02f, 1.79999754e-01f, -3.72292101e-01f,
  3.67676839e-02f, -1.47433989e-02f, 3.95434648e-02f, 1.17185950e-01f, 1.93998456e-01f, -2.40654975e-01f, -3.30920168e-03f, -3.51583995e-02f, 1.50449881e-02f, -5.64031117e-02f,
  -7.49649182e-02f, 1.37529999e-01f, 7.17519745e-02f, 3.61209273e-01f, 4.04293835e-02f, 1.20705485e-01f, -1.20383576e-01f, 3.96738201e-01f, 1.59856290e-01f, -3.38548958e-01f,
  -2.68609136e-01f, -1.94618955e-01f, 9.65803713e-02f, 8.42822567e-02f, -1.41699761e-01f, 7.25198612e-02f, -1.80032417e-01f, 4.02010620e-01f, 1.83898225e-01f, 1.98782027e-01f,
  1.53291106e-01f, 2.51695365e-01f, 2.23056599e-01f, 2.21604928e-01f, -2.32205495e-01f, -3.29996496e-02f, -3.14194083e-01f, -3.49763036e-01f, -3.35467122e-02f, -3.72588485e-01f,
  1.40701041e-01f, -2.88460881e-01f, 6.59842640e-02f, -4.79502857e-01f, 1.27101496e-01f, 1.11779653e-01f, -1.02513418e-01f, 1.68784380e-01f, -4.71109986e-01f, 1.09897956e-01f,
  -5.27673602e-01f, 2.09390879e-01f, 1.81311280e-01f, -2.06145361e-01f, -4.13355321e-01f, -5.02833903e-01f, 4.16642278e-02f, 2.14601740e-01f, -4.22299653e-01f, -1.93792045e-01f,
  1.47324413e-01f, -2.93455571e-01f, -1.90997630e-01f, 7.15520531e-02f, -3.99932593e-01f, -4.68502268e-02f, -6.14811182e-02f, -5.02692759e-01f, -2.92250719e-02f, 2.27395251e-01f,
  -8.19697678e-02f, -6.46980107e-02f, 1.54637516e-01f, -7.16536939e-02f, 2.48132423e-02f, -1.19719498e-01f, -1.87902436e-01f, -5.17126173e-02f, -1.21841878e-01f, -3.84199917e-02f,
  5.48372120e-02f, -1.16904624e-01f, 2.42839530e-02f, 2.02012613e-01f, -1.54015317e-03f, 6.94342032e-02f, -1.13802843e-01f, 3.32487553e-01f, -1.02022886e-01f, 3.74106653e-02f,
  -2.21571654e-01f, 6.35971799e-02f, -1.91887170e-01f, -3.24875772e-01f, -1.64308056e-01f, 4.79782633e-02f, 7.36225247e-02f, -2.68698007e-01f, 8.91599879e-02f, -5.02681494e-01f,
  -1.72384724e-01f, 3.39651972e-01f, -1.95524663e-01f, -4.37521003e-03f, 1.87947333e-01f, -2.52988517e-01f, -9.46534574e-02f, 9.71127301e-02f, 1.42245874e-01f, -1.56294082e-05f,
  -4.14921224e-01f, -1.15406357e-01f, -3.11249401e-02f, 1.88182548e-01f, 7.22035882e-04f, -3.22764814e-01f, -2.86196657e-02f, -2.76728719e-01f, -1.33048519e-01f, 6.24211468e-02f,
  1.72406495e-01f, -3.85021031e-01f, 1.13751806e-01f, 3.76343280e-02f, 8.24778154e-02f, 2.52801895e-01f, -3.16922724e-01f, 2.45456174e-01f, 7.12068826e-02f, -3.41359198e-01f,
  7.99748674e-02f, -1.85567334e-01f, -1.53459549e-01f, 8.34101960e-02f, -6.43373430e-02f, -1.34728357e-01f, 1.68263689e-02f, 1.55921593e-01f, -8.40167180e-02f, -8.02787095e-02f,
  -2.93852419e-01f, 9.65307206e-02f, -6.44010380e-02f, 1.42366961e-01f, 2.64374286e-01f, 3.13877195e-01f, 4.42751274e-02f, 3.84514749e-01f, 5.91831096e-02f, -3.33708405e-01f,
  -3.21089625e-01f, 2.76297241e-01f, 1.20145101e-02f, 1.32866604e-02f, 5.00641942e-01f, -6.34306297e-02f, 2.35680435e-02f, 3.78773987e-01f, 3.28171670e-01f, -3.41783375e-01f,
  -6.88378587e-02f, -5.02206087e-01f, 2.07871422e-01f, 2.54297978e-03f, -1.02183089e-01f, 7.93495178e-02f, -4.94172305e-01f, -2.10843936e-01f, -2.33482122e-01f, 4.07887297e-03f,
  1.90557659e-01f, 6.78956062e-02f, -7.63023645e-02f, 6.38756081e-02f, -3.76276106e-01f, 3.24423850e-01f, 2.15991423e-01f, -1.30482689e-01f, 4.12862271e-01f, -4.07482177e-01f,
  1.73513427e-01f, -9.57131758e-02f, -2.47816503e-01f, -2.07153887e-01f, 1.37071416e-01f, -3.73025909e-02f, 2.06651509e-01f, -9.43825692e-02f, -9.99061763e-02f, -1.61249146e-01f,
  1.48411304e-01f, -1.11130498e-01f, -3.62242311e-01f, -1.68119818e-01f, -3.91742259e-01f, -5.01484692e-01f, -8.39446578e-03f, 1.31864637e-01f, 1.99667901e-01f, 4.23470624e-02f,
  -2.28898078e-01f, 2.48438329e-01f, -5.11798225e-02f, 3.07493713e-02f, 7.77100958e-03f, -1.52765051e-01f, -1.50085226e-01f, 1.88714534e-01f, 4.62231226e-02f, -2.07616717e-01f,
  -3.19067925e-01f, -7.69503415e-02f, -1.17133101e-02f, 1.52494088e-01f, 1.59711719e-01f, 2.30758160e-01f, 1.05839305e-01f, -4.11621928e-01f, -1.35402888e-01f, 1.79409772e-01f,
  -4.24454696e-02f, 4.27666977e-02f, 1.05370782e-01f, 1.61083460e-01f, 3.07489663e-01f, 3.12686175e-01f, -2.93995738e-01f, -5.47495067e-01f, 1.01430349e-01f, 2.74590433e-01f,
  -4.13222402e-01f, -3.16342384e-01f, -2.77942717e-01f, -3.07247669e-01f, -3.23265493e-01f, 2.67754979e-02f, -5.59029952e-02f, 2.01974377e-01f, -5.99753797e-01f, -1.13954745e-01f,
  3.15957516e-02f, 1.29524961e-01f, -4.48388904e-01f, 1.26521230e-01f, 1.78353831e-01f, 1.12453438e-01f, 5.83110899e-02f, -1.01078026e-01f, -1.27701670e-01f, -3.50631103e-02f,
  -4.07605320e-01f, 1.44318998e-01f, -1.54491156e-01f, 8.94394591e-02f, -2.33459994e-01f, -1.91466272e-01f, -1.89032778e-02f, 2.07517128e-02f, 5.86885912e-03f, -7.44927824e-02f,
  -7.53118843e-02f, 5.54932058e-02f, 5.34614213e-02f, -2.18057305e-01f, -1.38714910e-01f, -6.49464801e-02f, -1.67115450e-01f, -2.30123997e-01f, 1.46333547e-02f, -1.68204367e-01f,
  -6.16806298e-02f, 1.93442822e-01f, 1.28038049e-01f, -2.92316496e-01f, -2.01437443e-01f, 3.75206977e-01f, 2.80134916e-01f, 1.07180260e-01f, 1.68754607e-01f, 2.02715900e-02f,
  -7.24157924e-03f, -2.40104482e-01f, 3.83711398e-01f, 1.27043456e-01f, -4.79131222e-01f, -5.38133755e-02f, -2.54449457e-01f, 2.46079192e-02f, -2.25211054e-01f, -2.52324581e-01f,
  -1.33688767e-02f, 2.25343823e-01f, -3.02861154e-01f, 1.58771709e-01f, 2.26407245e-01f, -3.63195717e-01f, -3.25912595e-01f, 2.41144821e-01f, -5.57712652e-02f, 2.22486049e-01f,
  3.80783826e-01f, -4.15304631e-01f, -2.81158715e-01f, -3.58650774e-01f, 9.08296853e-02f, 7.37499967e-02f, 8.96692872e-02f, -3.33151937e-01f, -1.85496017e-01f, -2.38599882e-01f,
  1.23507299e-01f, 2.39267439e-01f, -4.71982688e-01f, 9.96885523e-02f, 3.25057179e-01f, -5.83238266e-02f, -1.17208272e-01f, -2.45205477e-01f, 2.39094093e-01f, -7.54624531e-02f,
  -1.18288793e-01f, 1.82539642e-01f, -3.25304866e-01f, 1.28793731e-01f, 2.11362362e-01f, -1.30479902e-01f, -1.21018954e-01f, 8.91468301e-02f, -8.13556276e-03f, -9.39881206e-02f,
  7.57471994e-02f, 1.38951585e-01f, 1.31899267e-01f, 1.31813124e-01f, 1.60322502e-01f, -1.23614118e-01f, 1.29816294e-01f, 1.22442178e-01f, 2.29895666e-01f, 2.52617270e-01f,
  3.59322518e-01f, -3.39813262e-01f, -2.47136936e-01f, -2.75974303e-01f, -4.45813313e-03f, 2.38186091e-01f, 3.58515978e-02f, 2.55214810e-01f, 2.04729438e-01f, -1.80880070e-01f,
  -1.62425071e-01f, 3.71799767e-01f, -1.39410540e-01f, -1.97633162e-01f, 7.57559091e-02f, -1.53734893e-01f, -1.53386474e-01f, -2.07163736e-01f, -3.44548553e-01f, 2.93903410e-01f,
  1.59575492e-01f, 2.57727325e-01f, -2.32912853e-01f, -2.01179817e-01f, 1.16461866e-01f, -2.44556934e-01f, -2.63367477e-03f, -5.32540046e-02f, 2.27135286e-01f, -2.46410400e-01f,
  -1.42487198e-01f, 8.33153129e-02f, 1.14678025e-01f, -1.76202506e-01f, -6.22354634e-02f, -2.83133149e-01f, -6.68877959e-02f, -3.75404172e-02f, 4.74770814e-02f, -3.93142283e-01f,
  9.28729773e-02f, -3.19606066e-02f, 1.42220244e-01f, 1.80632383e-01f, 7.59470835e-02f, -3.47861946e-01f, -3.17590892e-01f, -3.43841255e-01f
};

// L3_linear_B (Shape: 1 x 12)
const int L3_linear_B_rows = 1;
const int L3_linear_B_cols = 12;
const float L3_linear_B_data[] = {
  -1.68896407e-01f, 1.11706920e-01f, 1.35559186e-01f, -1.34715766e-01f, -2.21329834e-02f, 1.31949723e-01f, -6.14732318e-02f, 3.78863253e-02f, -2.74936892e-02f, 6.95206225e-03f,
  3.57293598e-02f, -1.47418663e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 12, 40
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        64, 12, 40
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        64, 12, 40
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_linear
    linear_forward_pgm(
        buffer1, x_out,
        L3_linear_W_data, L3_linear_B_data,
        64, 12
    );
    }
    