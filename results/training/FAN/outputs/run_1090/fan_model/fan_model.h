/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 64 (x3)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 64;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    return (x > 0.0f) ? x : 0.0f;
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 25 x 120)
const int L0_fan_Wp_rows = 25;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  3.36382896e-01f, -2.64005005e-01f, 5.04102334e-02f, 6.16639853e-02f, 4.14559320e-02f, 5.49677163e-02f, 8.59077871e-02f, -3.15520540e-02f, -5.37981018e-02f, -1.99315563e-01f,
  -9.52251107e-02f, -1.17052540e-01f, -1.27383634e-01f, -8.66070315e-02f, 1.40371174e-01f, -8.65121409e-02f, -2.13209897e-01f, 6.58989251e-02f, 1.26043707e-01f, -4.73122559e-02f,
  -1.19766079e-01f, -1.41578987e-02f, -9.68352985e-03f, 5.16021177e-02f, -3.24798763e-01f, -1.19656183e-01f, -2.07328647e-01f, -1.09252565e-01f, -1.10319577e-01f, -4.78023887e-01f,
  -1.28266379e-01f, 5.51327355e-02f, -7.71694109e-02f, -7.64332265e-02f, -6.71780184e-02f, -1.02933601e-01f, -1.92920938e-02f, -1.42026767e-01f, -3.10396608e-02f, -6.98664486e-02f,
  -1.51053611e-02f, -3.23439389e-02f, -5.47619611e-02f, -8.97293612e-02f, -9.68993157e-02f, -1.23187024e-02f, -8.42842162e-02f, -1.35471031e-01f, -1.21337455e-02f, -1.42989308e-01f,
  -2.36053839e-01f, -6.34959266e-02f, -1.28060747e-02f, -1.46422341e-01f, -6.06757738e-02f, -5.99199384e-02f, -1.13963410e-01f, -1.78523496e-01f, 1.01443324e-02f, -2.78444946e-01f,
  -5.45428321e-02f, 7.98977539e-02f, 2.04032548e-02f, -4.36781459e-02f, 7.09666759e-02f, 1.97208393e-02f, 2.45505534e-02f, -1.05599768e-01f, 6.29181415e-02f, 7.89822340e-02f,
  2.82440279e-02f, 2.60031130e-03f, -1.31156314e-02f, 1.08859800e-02f, -2.91217808e-02f, 5.83160343e-03f, -5.87973706e-02f, -2.08122246e-02f, 1.51813040e-02f, -8.07197168e-02f,
  -1.02696300e-01f, 4.82449718e-02f, 2.94969417e-02f, -5.72934560e-02f, -8.10652971e-03f, -2.73994971e-02f, 2.45967042e-02f, -3.56232282e-03f, 6.11279868e-02f, 1.18606761e-02f,
  -3.38183828e-02f, 1.19439769e-03f, -1.08615234e-01f, -1.35637552e-01f, -1.21640816e-01f, -1.41240984e-01f, -2.42278948e-02f, -9.15392041e-02f, -3.28930048e-03f, -5.47324754e-02f,
  -5.36823533e-02f, 1.64581637e-03f, -8.78751725e-02f, -1.30135342e-01f, -6.39835075e-02f, -3.40004340e-02f, -8.43858570e-02f, -5.47976494e-02f, -3.87020372e-02f, -1.18444830e-01f,
  -5.65310493e-02f, -4.93091866e-02f, -2.10912451e-02f, -7.02166036e-02f, 3.19689848e-02f, -4.97478247e-02f, -5.92214689e-02f, -1.65861577e-01f, 8.16513672e-02f, -1.52710766e-01f,
  -2.38978282e-01f, 1.41649038e-01f, 7.69817531e-02f, -1.62651092e-01f, -8.73488486e-02f, 1.33673707e-02f, -6.73459992e-02f, 5.53966835e-02f, 1.28617719e-01f, -3.62993255e-02f,
  1.50734484e-01f, 1.15322180e-01f, 1.39218137e-01f, 1.71100214e-01f, 1.58399910e-01f, -9.54069421e-02f, -8.59506130e-02f, -1.73946813e-01f, -2.61824802e-02f, -1.26245126e-01f,
  -1.01363674e-01f, -1.14558674e-01f, -1.34064853e-01f, 1.12236224e-01f, 1.71274096e-02f, 1.17429294e-01f, 9.95648056e-02f, -2.49442901e-03f, 1.52579099e-01f, -1.36721656e-01f,
  2.29200482e-01f, 6.99693933e-02f, 1.64719269e-01f, 2.47820653e-02f, 1.68316767e-01f, 9.82200801e-02f, 1.44633740e-01f, 1.40515417e-01f, 7.35046491e-02f, 9.88651514e-02f,
  1.89320073e-01f, 2.85995733e-02f, 2.14256063e-01f, 1.16848618e-01f, 2.70098988e-02f, 8.98326784e-02f, 3.57639194e-02f, 8.55044946e-02f, 1.22087635e-01f, 8.24102387e-02f,
  1.27117395e-01f, -9.89924092e-03f, 7.56589845e-02f, 1.18048362e-01f, 2.04706103e-01f, 9.51259285e-02f, 4.53868769e-02f, 1.46563724e-01f, 1.43171206e-01f, 9.34890136e-02f,
  -3.66050713e-02f, 3.38201672e-02f, -2.58362293e-02f, -7.13459775e-02f, -7.44582266e-02f, -7.47937430e-03f, 4.43319877e-04f, 5.42065408e-03f, -3.56007405e-02f, -6.61754906e-02f,
  3.09574623e-02f, -9.53588858e-02f, -5.62819131e-02f, 3.47991548e-02f, -8.46157074e-02f, -1.20343857e-01f, -1.76101495e-02f, -2.78413054e-02f, -1.20841227e-02f, -6.88224584e-02f,
  -1.24435173e-02f, -1.01101361e-01f, -6.61528632e-02f, 2.26412155e-02f, -4.81736213e-02f, 2.13219877e-03f, -1.12735003e-01f, -1.20773636e-01f, -1.54756231e-03f, -2.12787032e-01f,
  1.11190297e-01f, 1.20961368e-01f, 1.69950873e-01f, 1.40406340e-01f, 1.58582523e-01f, 2.76550293e-01f, 1.82437122e-01f, 1.98204324e-01f, 1.69674411e-01f, 8.29138383e-02f,
  1.52201548e-01f, 2.07578942e-01f, 2.11834848e-01f, 2.01472133e-01f, -1.45962148e-03f, 1.18426464e-01f, 1.33732453e-01f, -2.36003287e-03f, 4.56963815e-02f, 5.84467165e-02f,
  1.31991297e-01f, -3.94329662e-03f, 6.84745535e-02f, 2.26601332e-01f, 2.09113866e-01f, 4.89174090e-02f, 2.16609612e-01f, 7.98126236e-02f, 1.89962238e-01f, 1.01849452e-01f,
  -1.51490336e-02f, -1.55328900e-01f, -8.94198641e-02f, -5.07468097e-02f, 1.01175666e-01f, 1.31118298e-01f, -9.57978815e-02f, -3.61113623e-02f, -7.59388029e-04f, -1.06846966e-01f,
  7.91151151e-02f, -3.58357374e-03f, -7.80655220e-02f, 2.11427417e-02f, -2.68033072e-02f, -2.25545377e-01f, -9.34278071e-02f, -9.96031016e-02f, -4.91151847e-02f, 1.01571135e-01f,
  -7.15681165e-02f, -3.85890272e-03f, 1.16108181e-02f, 5.58295324e-02f, -9.48656201e-02f, -9.68560874e-02f, -1.92566201e-01f, -7.95168653e-02f, -6.18541203e-02f, -3.60711962e-01f,
  -8.14265236e-02f, 1.18673429e-01f, 1.02217145e-01f, 4.23735753e-02f, 1.96521416e-01f, -3.65246385e-02f, 8.77409130e-02f, -3.58641567e-03f, 7.72575065e-02f, -4.43709940e-02f,
  6.19594194e-02f, 1.46181434e-01f, 5.19459881e-02f, 3.51215154e-02f, 6.61132336e-02f, 1.04132727e-01f, 8.26165825e-02f, 9.03384909e-02f, 7.83164799e-02f, 1.70339365e-02f,
  1.71222277e-02f, 1.37229696e-01f, 5.21713011e-02f, -7.80573720e-03f, 1.41918242e-01f, 1.02642737e-01f, 4.15276848e-02f, 5.27494811e-02f, 8.33344553e-03f, -7.14254379e-02f,
  8.27769861e-02f, -5.43125905e-02f, 2.23050229e-02f, -2.63292640e-02f, -8.32709521e-02f, 8.21295474e-03f, -3.91562879e-02f, -6.06194362e-02f, 3.42974886e-02f, 1.56598315e-02f,
  -2.21997537e-02f, -9.12099481e-02f, -4.73963935e-03f, -1.48759931e-01f, -3.69120464e-02f, -1.08793490e-01f, -8.82760584e-02f, -2.62965057e-02f, -4.25664373e-02f, -4.62866686e-02f,
  -2.60600206e-02f, 5.95089532e-02f, -1.10155970e-01f, -3.09299305e-02f, -2.53565721e-02f, 1.00608161e-02f, -2.59663556e-02f, -1.26083642e-01f, -9.87371281e-02f, 7.18954136e-04f,
  -2.91779608e-01f, 1.99720934e-01f, -1.10416166e-01f, -8.59311894e-02f, -8.41511786e-02f, 8.89637787e-03f, 2.80949147e-03f, 2.57858969e-02f, 1.14123300e-01f, 3.51411873e-03f,
  8.24009925e-02f, 1.63036468e-03f, 5.47341891e-02f, 8.15444961e-02f, 8.44801515e-02f, -3.93100418e-02f, -3.61515544e-02f, 1.24050602e-02f, 4.84992899e-02f, 4.85388935e-02f,
  -6.55734120e-03f, -1.14884779e-01f, -9.68294442e-02f, -1.05720967e-01f, 4.95127849e-02f, -8.80393833e-02f, -3.83632295e-02f, 3.16410363e-02f, -1.03908084e-01f, -2.43144095e-01f,
  2.25519150e-01f, 1.50679097e-01f, 1.30092919e-01f, 2.09513530e-01f, 1.40332505e-01f, 4.76356177e-03f, -1.04157150e-01f, -8.55410472e-02f, -6.86757565e-02f, 1.52133688e-01f,
  1.29283890e-01f, -6.62566498e-02f, -8.35409686e-02f, -1.32605091e-01f, -9.79560893e-03f, 9.47559699e-02f, 2.84446806e-01f, 1.38844088e-01f, -1.28099605e-01f, -1.22636959e-01f,
  7.41426498e-02f, 2.40792900e-01f, 1.34832442e-01f, 2.10605003e-02f, 1.90222397e-01f, 4.59895805e-02f, 1.76761597e-01f, 1.77718237e-01f, 9.52173322e-02f, 4.24827546e-01f,
  1.81611598e-01f, 9.70106050e-02f, -1.73108652e-02f, 8.16685781e-02f, 6.34867549e-02f, -4.21784073e-02f, 4.34903465e-02f, -2.85716467e-02f, -4.38147150e-02f, 2.84467805e-02f,
  1.59916610e-01f, -5.08701056e-02f, -2.07982715e-02f, -7.59854401e-03f, 3.14596444e-02f, -1.01167008e-01f, 5.18793166e-02f, 2.11576689e-02f, 7.34957159e-02f, 1.92933306e-02f,
  7.95048773e-02f, 1.38549998e-01f, 1.65690258e-01f, -6.42319620e-02f, 2.88773160e-02f, 3.03125493e-02f, -3.08444798e-02f, -2.05623992e-02f, 3.23307738e-02f, 1.54997632e-01f,
  -4.02450785e-02f, 1.44201547e-01f, 9.06957611e-02f, -7.11313412e-02f, 9.87389535e-02f, 6.67303130e-02f, 3.44777256e-02f, 1.33716792e-01f, -6.39739558e-02f, -2.08859518e-02f,
  -4.90895659e-02f, -5.45096770e-03f, -1.07392855e-01f, -2.24759076e-02f, -5.59709817e-02f, -5.87961227e-02f, 2.77800672e-02f, -7.08878115e-02f, 1.15738260e-02f, -3.59748453e-02f,
  -5.67495115e-02f, 1.53280254e-02f, -5.78269083e-03f, -9.64960605e-02f, -9.35704634e-02f, -1.07843064e-01f, -1.40494391e-01f, -1.07402958e-01f, -8.57341737e-02f, -1.05045415e-01f,
  -2.81503238e-02f, -1.77821457e-01f, 7.61768371e-02f, 4.72021550e-02f, 1.14672594e-01f, 2.77808625e-02f, 1.78178191e-01f, 5.47588766e-02f, 1.41564667e-01f, -2.88991965e-02f,
  4.13631322e-03f, -1.26642631e-02f, 1.02764964e-01f, 1.32177239e-02f, 6.45957291e-02f, 3.03022377e-02f, 1.26677200e-01f, 1.83840445e-03f, -1.27080467e-03f, -2.68673953e-02f,
  1.00983374e-01f, -1.79859474e-02f, -4.31141723e-03f, 2.53864937e-02f, 1.14631630e-01f, -3.72354425e-02f, -2.14876961e-02f, 3.27145979e-02f, -1.73244607e-02f, -7.07603693e-02f,
  -1.03888944e-01f, -5.81102259e-02f, -2.13623077e-01f, 1.21559151e-01f, -8.85591283e-02f, -1.56860560e-01f, -1.88535973e-01f, -5.37297726e-02f, 1.46735966e-01f, -6.89483210e-02f,
  1.40139550e-01f, 1.78248838e-01f, 3.69787849e-02f, 4.12086807e-02f, 4.93663549e-02f, -2.23991632e-01f, -1.14770353e-01f, -6.45798668e-02f, 5.80839328e-02f, -3.04862321e-03f,
  4.90754358e-02f, 7.11660683e-02f, 1.86373264e-01f, 5.12899160e-02f, -4.49451953e-02f, 2.59015244e-02f, -7.30972141e-02f, -3.69276479e-02f, -1.40566930e-01f, -4.47701871e-01f,
  -2.21917763e-01f, -2.91454762e-01f, -1.85065661e-02f, 7.38423169e-02f, -1.88316107e-02f, -1.29934683e-01f, -2.09279787e-02f, -6.95684850e-02f, 1.12034157e-02f, -1.73625685e-02f,
  -6.45046309e-02f, -2.62176804e-02f, 9.21279117e-02f, -4.68978938e-03f, -3.80381644e-02f, -9.32948738e-02f, 1.09583013e-01f, -1.13928169e-01f, -1.15693003e-01f, -6.53055310e-02f,
  2.35997830e-02f, -4.24612537e-02f, -5.80163375e-02f, -8.55465159e-02f, -8.40838850e-02f, 2.77610924e-02f, -1.23532094e-01f, -1.42379269e-01f, -1.53853953e-01f, -1.81074813e-01f,
  4.34777625e-02f, -3.42609617e-03f, 1.10050015e-01f, -1.97435562e-02f, 1.08419456e-01f, -4.68213558e-02f, 2.96505895e-02f, 1.03096634e-01f, 7.51837716e-02f, 3.36475223e-02f,
  1.53412521e-01f, -4.85440642e-02f, 1.87459029e-02f, 1.01143241e-01f, 4.01845500e-02f, 6.87448531e-02f, -3.91222797e-02f, 4.60201390e-02f, 9.48135033e-02f, -1.01616094e-02f,
  1.09183088e-01f, 1.29973684e-02f, 1.86622739e-02f, 4.59381677e-02f, 3.85156833e-02f, 7.05540478e-02f, 6.20615296e-02f, 8.53662267e-02f, 1.41798452e-01f, 8.73288587e-02f,
  1.79944038e-01f, -6.28993288e-02f, -1.42509624e-01f, 2.12736651e-02f, -1.06429361e-01f, -2.08424088e-02f, -5.58625534e-02f, 5.43384347e-03f, -1.67984832e-02f, -9.45696011e-02f,
  6.16784096e-02f, -3.28918472e-02f, 5.95813096e-02f, -5.40635698e-02f, -6.01814762e-02f, -1.85724907e-02f, 2.65463032e-02f, -1.05102122e-01f, -8.19959939e-02f, -5.94055541e-02f,
  2.41436847e-02f, -9.27344263e-02f, -3.30391563e-02f, -1.39452651e-01f, -7.25355074e-02f, -3.26123014e-02f, -1.13263279e-02f, -1.18767761e-01f, 4.86406311e-02f, -5.21348184e-03f,
  -2.58988887e-01f, 3.72265846e-01f, 1.74197197e-01f, -6.22801594e-02f, 1.07531615e-01f, 2.04277337e-01f, 3.73387039e-01f, 6.68071508e-02f, -1.66750431e-01f, 9.53396186e-02f,
  2.30197713e-01f, 5.10621071e-03f, -7.86720514e-02f, -4.91591766e-02f, -2.89089829e-02f, 1.82672113e-01f, 3.40616778e-02f, -1.17042467e-01f, -2.96356291e-01f, -4.83940132e-02f,
  7.29278848e-03f, -1.16129793e-01f, -3.07221651e-01f, -1.78333431e-01f, 7.65833929e-02f, -1.75986260e-01f, -4.09077900e-03f, -6.72133863e-02f, -9.76675842e-03f, 1.35360479e-01f,
  7.19402581e-02f, 2.09375218e-01f, -9.86615345e-02f, 3.83405276e-02f, 1.01436131e-01f, -2.00395323e-02f, 4.89539392e-02f, 7.69973779e-03f, 1.34218810e-02f, 6.68466464e-02f,
  7.16235638e-02f, 8.14555660e-02f, 3.47872414e-02f, 7.30118230e-02f, 1.67316906e-02f, 2.90574729e-02f, 7.79271647e-02f, 4.03029844e-02f, -3.03378571e-02f, 9.24317837e-02f,
  1.77493274e-01f, 1.54815853e-01f, 6.94472641e-02f, 1.10023960e-01f, 1.10338293e-01f, -7.80178700e-03f, 1.72942594e-01f, 7.41229020e-03f, 5.91662079e-02f, -4.10787836e-02f,
  1.67660844e-02f, 2.50111353e-02f, 3.68190892e-02f, -5.34532666e-02f, -5.28109632e-02f, -2.28130687e-02f, -3.05171721e-02f, -5.17467186e-02f, -1.23151824e-01f, -1.17573943e-02f,
  6.94365725e-02f, -8.99507850e-03f, 2.17924220e-03f, -2.48507112e-02f, -4.13828194e-02f, 2.15284880e-02f, -1.21812262e-02f, 6.57610744e-02f, -7.25058466e-02f, 7.47909071e-03f,
  -5.15907742e-02f, 6.63788170e-02f, 6.48988113e-02f, -6.40241336e-03f, 3.96895781e-02f, -4.97709848e-02f, -1.04446085e-02f, 5.78122400e-02f, 5.96668683e-02f, 1.26185426e-02f,
  -5.61031401e-02f, 2.95039024e-02f, -9.62283164e-02f, -2.16330253e-02f, -5.81933074e-02f, 2.78152805e-03f, 3.04005276e-02f, -2.54356721e-03f, -7.13178068e-02f, -5.22562042e-02f,
  -4.22009267e-02f, -5.47117665e-02f, 3.39321084e-02f, -6.27027154e-02f, -8.30671638e-02f, -7.79361129e-02f, 6.20755600e-03f, 8.27750191e-03f, 4.64578122e-02f, 3.05332020e-02f,
  7.65650719e-02f, -1.42303690e-01f, -1.47819623e-01f, -1.05114378e-01f, -8.81736130e-02f, -1.95031181e-01f, -1.38146028e-01f, -1.40542611e-01f, -1.09874375e-01f, -4.48975004e-02f,
  7.77961314e-02f, -2.38418996e-01f, -2.27668270e-01f, -8.83415937e-02f, -2.09331155e-01f, -6.07291646e-02f, -1.55904084e-01f, -2.16130801e-02f, 1.10223098e-02f, -1.60516456e-01f,
  -2.58493930e-01f, 3.66216153e-02f, -3.42914872e-02f, 7.21565038e-02f, 1.52090266e-01f, -3.02124415e-02f, 7.47595802e-02f, 1.64793164e-01f, 1.52139753e-01f, -7.81311765e-02f,
  -4.71997410e-02f, 3.65208574e-02f, -3.80183640e-03f, 4.64450946e-04f, -2.50516348e-02f, 2.02164784e-01f, -1.24424817e-02f, -3.64671722e-02f, -4.91757095e-02f, 6.14034832e-02f,
  6.91904267e-03f, -2.70202756e-01f, -6.22960702e-02f, -3.42305414e-02f, -1.64863959e-01f, -1.21238083e-01f, -6.58981502e-02f, -1.17904872e-01f, -5.41088954e-02f, -1.78967506e-01f,
  -1.55035809e-01f, -1.28280342e-01f, -1.94893643e-01f, -2.10449025e-02f, -1.19035587e-01f, -1.30693123e-01f, -5.79807125e-02f, 1.08989123e-02f, -4.53909151e-02f, -2.23426223e-01f,
  -1.03607960e-01f, -2.45968431e-01f, -1.00272074e-01f, -6.33493885e-02f, -1.96671024e-01f, -1.46416090e-02f, -6.61473870e-02f, -7.56166056e-02f, -4.22901101e-02f, 5.03815562e-02f,
  3.56449559e-02f, 2.96103973e-02f, 8.23618844e-02f, 8.30252245e-02f, 1.65770780e-02f, 1.21324524e-01f, 2.62395497e-02f, 1.49696037e-01f, 1.57873690e-01f, 1.33900046e-01f,
  3.89695540e-02f, 1.29399136e-01f, 4.40761968e-02f, 1.82464242e-01f, 1.83222324e-01f, 1.55991809e-02f, 7.65436292e-02f, 2.53935695e-01f, 8.12441185e-02f, 3.88075411e-02f,
  2.25309022e-02f, 2.38669589e-02f, 1.56761874e-02f, 1.21051691e-01f, 5.61571680e-02f, 9.55896303e-02f, 8.93291160e-02f, 1.91438477e-02f, 1.64023936e-01f, 3.03512570e-02f,
  -4.27284203e-02f, -1.58733428e-02f, 4.74894382e-02f, -1.36015797e-02f, -7.48079792e-02f, -1.12792671e-01f, -5.81546351e-02f, -8.02533329e-02f, -1.75136402e-01f, -1.61817044e-01f,
  -1.31689534e-01f, -9.71312150e-02f, -5.70678711e-02f, -7.26704448e-02f, 8.67803916e-02f, 8.72319005e-03f, -5.88528672e-03f, 8.57250020e-02f, -9.42209922e-03f, -7.18833804e-02f,
  3.48054282e-02f, 3.15447040e-02f, -6.40281662e-02f, -3.34891342e-02f, 2.91021653e-02f, 9.91393626e-02f, -1.53895030e-02f, 1.20732866e-01f, 1.16220310e-01f, 1.79656923e-01f,
  1.14037722e-01f, 3.02686065e-01f, 3.37545663e-01f, 3.47547755e-02f, 6.41769171e-02f, 2.23436564e-01f, 3.38136494e-01f, 1.28365323e-01f, -4.41067107e-02f, 2.74914086e-01f,
  5.28243184e-02f, -1.32616341e-01f, -7.55117536e-02f, 4.91337068e-02f, -1.64871216e-02f, 1.30241334e-01f, 4.90808822e-02f, -9.78461355e-02f, -1.55980483e-01f, -2.20902730e-02f,
  -2.74310596e-02f, 5.68978637e-02f, 1.34912878e-02f, -5.74804051e-03f, 1.86297715e-01f, 4.84548099e-02f, 2.66641200e-01f, 2.21966192e-01f, 1.45849019e-01f, 2.16135621e-01f,
  4.67401110e-02f, 2.53560662e-01f, 4.76301908e-02f, -2.76504960e-02f, 1.15880072e-01f, 4.23523299e-02f, 6.04689401e-03f, -9.34533868e-03f, 7.50173554e-02f, 2.82716621e-02f,
  1.61718592e-01f, -2.63812989e-02f, 2.79702209e-02f, -1.91063043e-02f, 4.71617095e-02f, 1.59843564e-01f, 4.94655296e-02f, 2.02092770e-02f, 1.21579058e-01f, 1.74032032e-01f,
  1.56304576e-02f, 1.79334104e-01f, 1.68890938e-01f, 1.34950861e-01f, 1.39893368e-01f, 1.00893304e-02f, 2.40145490e-01f, 1.95346609e-01f, 1.69452980e-01f, 2.51699686e-01f,
  1.65519968e-01f, 7.87921622e-02f, 2.74263159e-03f, -9.38331112e-02f, 2.66213324e-02f, 7.05640949e-03f, 3.11722737e-02f, -2.29829531e-02f, -3.34462412e-02f, 8.76568332e-02f,
  1.35304155e-02f, 1.36271194e-01f, 3.44233960e-02f, 8.90281573e-02f, -2.48120464e-02f, 3.41501087e-03f, 1.08561635e-01f, 8.15075561e-02f, 4.22216812e-03f, 7.06302077e-02f,
  -3.34375445e-03f, 1.84210390e-01f, 4.63840086e-03f, -2.89819259e-02f, 1.18318871e-01f, 4.75252606e-02f, -5.26245916e-03f, 2.20673401e-02f, 4.81756218e-02f, -4.81838398e-02f,
  -1.09433696e-01f, -2.18610112e-02f, -2.11914144e-02f, 1.19741745e-02f, -3.83909754e-02f, 9.19523984e-02f, 3.30409817e-02f, -4.57961150e-02f, 7.53401266e-03f, 1.27677768e-01f,
  1.70521259e-01f, 1.56594440e-01f, 1.46747172e-01f, 9.13529620e-02f, 6.84349090e-02f, 6.05533794e-02f, 8.58559087e-02f, 2.93372478e-02f, 9.49304104e-02f, 2.27807444e-02f,
  8.60091522e-02f, -3.04524310e-05f, -4.49085832e-02f, 7.94716030e-02f, 1.15326039e-01f, -2.72031743e-02f, -2.48255511e-03f, 9.08163786e-02f, -2.13119350e-02f, 7.16705918e-02f,
  3.14439505e-01f, 1.65623903e-01f, 1.04226135e-01f, 2.30775192e-01f, 2.62367669e-02f, -4.75098491e-02f, -1.08094081e-01f, -5.39924726e-02f, 1.71691477e-01f, 1.34911194e-01f,
  6.50152564e-02f, 9.12051555e-03f, -1.60800554e-02f, -1.20448060e-01f, -1.27601802e-01f, 8.06525946e-02f, 2.11962223e-01f, -4.82900515e-02f, -2.27778792e-01f, -6.74801543e-02f,
  3.89626138e-02f, -3.35793495e-02f, 3.39729637e-02f, -7.15045780e-02f, 2.13501096e-01f, -9.27760154e-02f, 5.55114001e-02f, 7.58701488e-02f, -4.97448549e-04f, 3.55454177e-01f,
  2.10399449e-01f, -4.49927114e-02f, -1.02562029e-02f, -8.04060418e-03f, -4.49435003e-02f, 3.35245505e-02f, -8.97946283e-02f, 1.73886865e-02f, 2.27844510e-02f, 3.77024636e-02f,
  3.18312421e-02f, 3.62614542e-02f, 1.12255037e-01f, 3.12838256e-02f, -9.66691747e-02f, -7.99547434e-02f, -8.42344481e-03f, 1.62931141e-02f, -1.16109945e-01f, -6.55437410e-02f,
  5.04790619e-02f, 5.06808944e-02f, -6.60787821e-02f, -1.33862600e-01f, -1.27791107e-01f, -2.91310921e-02f, 8.53745546e-03f, -1.68229081e-02f, -7.24632666e-02f, -3.54995169e-02f,
  -1.00741768e-02f, -7.39971325e-02f, -3.91601026e-02f, -3.61491693e-03f, 3.16571482e-02f, 8.09508264e-02f, 3.70185226e-02f, -1.02976732e-01f, -1.06967956e-01f, -4.23118025e-02f,
  -1.19608194e-01f, -1.32588759e-01f, -3.11881881e-02f, -1.01667047e-01f, -1.24828033e-01f, -9.17962417e-02f, -1.87337119e-02f, -1.57814950e-01f, -4.84027527e-02f, 3.17932963e-02f,
  -7.26716891e-02f, -2.69043967e-02f, -9.32212994e-02f, -7.20602125e-02f, 1.49285663e-02f, -1.03065036e-01f, -1.25357717e-01f, -8.45820010e-02f, -1.19411185e-01f, -1.25791393e-02f,
  -4.12822142e-02f, -1.93745196e-01f, 6.94673136e-02f, 3.39147146e-03f, 1.39445430e-02f, -8.00061505e-03f, 1.24041662e-01f, -3.25820334e-02f, -6.29666671e-02f, -1.09125793e-01f,
  1.36589315e-02f, 6.36617839e-02f, 1.34255271e-02f, -3.97466868e-02f, 5.86434221e-03f, -2.17122808e-02f, 2.58125588e-02f, -4.55539972e-02f, 2.42793560e-02f, 4.34897244e-02f,
  5.87722883e-02f, 9.56194848e-03f, 3.20200510e-02f, -5.00810631e-02f, -1.23655304e-01f, -5.32503091e-02f, -1.43629223e-01f, 5.35606928e-02f, -1.94661885e-01f, -1.08784266e-01f,
  7.66283333e-01f, 6.29754364e-02f, -1.30138323e-01f, 2.22197503e-01f, -7.25257967e-04f, 1.37153462e-01f, 2.53044903e-01f, 2.86590040e-01f, 6.51195198e-02f, 1.92368925e-02f,
  2.34365538e-02f, -5.44216074e-02f, -4.52297144e-02f, -4.68414389e-02f, 1.91501960e-01f, 2.35071182e-02f, -6.81322888e-02f, -5.71133010e-02f, 1.41782403e-01f, -4.53834012e-02f,
  -8.17511529e-02f, -1.06070846e-01f, 7.42154866e-02f, -2.42914613e-02f, -1.71689212e-01f, -4.25752886e-02f, -1.60098448e-01f, -1.14983745e-01f, -1.48810253e-01f, -3.66227388e-01f,
  -3.10059726e-01f, 5.59310243e-02f, 2.84688063e-02f, -5.52538335e-02f, -1.10437863e-01f, 4.29679602e-02f, -8.41578585e-04f, -7.60238767e-02f, -1.94396209e-02f, -1.14385255e-01f,
  -4.54071872e-02f, -5.55520467e-02f, -1.40920945e-03f, -1.43193737e-01f, 9.60743129e-02f, -3.79813090e-02f, 4.28882577e-02f, 6.19840734e-02f, -3.94963026e-02f, -2.23811362e-02f,
  -1.43610418e-01f, -6.38460442e-02f, 1.36063308e-01f, -9.40320939e-02f, -2.50006970e-02f, 2.71597859e-02f, -7.02506900e-02f, -6.34237155e-02f, 2.67688389e-04f, 2.50266260e-03f,
  4.63185497e-02f, -1.13138989e-01f, -5.48962876e-02f, 1.40555292e-01f, 6.96154758e-02f, -6.92820251e-02f, -5.45281991e-02f, -9.33757238e-03f, 2.61203703e-02f, 4.37367242e-03f,
  -3.38101201e-02f, 2.81092729e-02f, -3.66761759e-02f, 1.00176716e-02f, -9.49023105e-03f, 9.68137756e-03f, 5.83652891e-02f, 2.14031674e-02f, -2.55836248e-02f, 2.91882735e-02f,
  7.30296038e-03f, 7.70295644e-03f, -1.29255131e-01f, -2.58868579e-02f, -1.68416593e-02f, 1.97759317e-03f, -1.25093814e-02f, -1.96706615e-02f, 4.48411480e-02f, 1.29385367e-01f,
  1.38165921e-01f, 1.22756667e-01f, -2.35056765e-02f, -6.90355804e-03f, 3.94349396e-02f, -1.40355248e-02f, -6.75895363e-02f, 2.18059253e-02f, 3.75274732e-03f, 1.55377369e-02f,
  -1.95899233e-03f, 5.37358634e-02f, -2.10728380e-03f, -9.51362103e-02f, 4.46425825e-02f, -8.29262882e-02f, 7.14996904e-02f, 6.44060373e-02f, 7.62319565e-02f, -4.02578749e-02f,
  -2.69308276e-02f, 1.54475853e-01f, 9.17972177e-02f, 3.02476678e-02f, 3.19564976e-02f, 7.18559250e-02f, 2.13305261e-02f, 1.19276762e-01f, 1.08769022e-01f, 2.24704996e-01f,
  5.74781954e-01f, -2.17334479e-01f, 8.11796412e-02f, 7.41373748e-02f, 1.05150789e-01f, 2.66469002e-01f, 2.06861138e-01f, 1.73938930e-01f, -3.73486727e-02f, -1.59133255e-01f,
  -7.00797141e-02f, -3.96750197e-02f, -1.90835744e-01f, -1.73660710e-01f, 8.80637988e-02f, -1.25512004e-01f, -7.78265521e-02f, 5.63261397e-02f, 7.46615306e-02f, 2.42967159e-02f,
  -1.28576040e-01f, -4.32090610e-02f, 8.68278369e-02f, 3.50190997e-02f, -2.12068602e-01f, -7.11848289e-02f, -5.29072396e-02f, -5.10620810e-02f, -1.38491347e-01f, -2.52003461e-01f,
  -1.12229481e-01f, 2.06225008e-01f, 8.69694352e-02f, 3.85774560e-02f, -8.03281832e-03f, -2.22580563e-02f, 2.82956362e-02f, -1.25985354e-01f, 2.27727294e-02f, 1.30100744e-02f,
  1.37413049e-03f, -5.93582280e-02f, 4.20236923e-02f, -3.53950053e-03f, -5.29721472e-03f, 7.58304074e-02f, -2.41118278e-02f, -5.96118644e-02f, -3.96284200e-02f, -2.48758290e-02f,
  -1.13188155e-01f, 3.19236889e-02f, 1.83472529e-01f, -2.65183896e-02f, 6.62007406e-02f, 2.66226809e-02f, -3.26786041e-02f, -4.16871868e-02f, 1.36440605e-01f, -1.82634279e-01f,
  3.59004587e-02f, 7.50748143e-02f, 2.68981252e-02f, -1.56878065e-02f, 5.23349596e-03f, 1.09589435e-02f, 1.33949175e-01f, 3.28192078e-02f, -6.08698092e-02f, 4.05314118e-02f,
  1.83721986e-02f, 1.04560748e-01f, 2.19518710e-02f, 5.08155078e-02f, 2.65150703e-02f, -3.71259786e-02f, 3.92023697e-02f, 7.23752007e-03f, 5.21799698e-02f, 1.14994764e-01f,
  5.00886068e-02f, 2.52053048e-02f, 2.27592010e-02f, 6.87068179e-02f, 2.94014607e-02f, 1.63085267e-01f, 7.03810379e-02f, 7.27325529e-02f, 1.88653152e-02f, 1.00012273e-01f,
  -3.15913737e-01f, 1.22330286e-01f, -5.20163998e-02f, -5.30045666e-02f, -2.05864664e-02f, -9.84281767e-03f, 2.31934013e-03f, -1.08395375e-01f, -4.39951345e-02f, -1.15242086e-01f,
  8.08819085e-02f, 7.64360186e-03f, 5.70330163e-03f, 1.01283416e-02f, 3.27897631e-02f, -6.69176783e-03f, -1.35192245e-01f, -2.82723252e-02f, -9.46573168e-02f, -3.57831568e-02f,
  -5.61199449e-02f, -2.41688285e-02f, 5.80849536e-02f, -3.26102115e-02f, -4.04163115e-02f, 2.75882799e-02f, -5.29497908e-03f, -4.65913340e-02f, 1.74540177e-01f, 9.87952296e-03f,
  -2.11641118e-01f, 5.81634864e-02f, -1.18952177e-01f, -1.99101910e-01f, 1.84039101e-01f, 1.23954311e-01f, -3.37971784e-02f, -1.27299145e-01f, -2.04279333e-01f, 4.13831696e-02f,
  1.85327500e-01f, 4.33561243e-02f, -8.07503313e-02f, 1.47077695e-01f, -6.43873028e-03f, 3.02548297e-02f, 1.20142754e-02f, -1.43773109e-01f, -3.59615162e-02f, 1.03217304e-01f,
  1.78868324e-01f, -2.24116668e-02f, -2.72251368e-01f, -3.51778269e-02f, 6.38952926e-02f, -4.54728752e-02f, 7.19505362e-03f, 5.65362461e-02f, 2.35746682e-01f, 2.83551276e-01f,
  2.32561141e-01f, -1.53906951e-02f, 2.55383868e-02f, 6.08393215e-02f, -9.83138452e-04f, -6.15435876e-02f, -2.04273053e-02f, -1.33944377e-02f, -7.91310146e-03f, -1.60787463e-01f,
  1.54177830e-01f, 6.45573810e-02f, -9.71723348e-02f, -9.04344767e-02f, 3.58913578e-02f, -1.09379262e-01f, -1.79995388e-01f, -1.90643370e-01f, -1.34972125e-01f, -8.95838663e-02f,
  2.00255230e-01f, 6.62520081e-02f, -1.48996830e-01f, -3.63166854e-02f, -1.39361948e-01f, 3.53661552e-02f, 7.75807537e-03f, 1.17044570e-02f, -6.09851368e-02f, 1.62771472e-03f,
  -1.82413757e-02f, 5.69848455e-02f, -1.84593480e-02f, 3.58588621e-02f, -2.86814547e-03f, 9.22594517e-02f, 1.23299278e-01f, 4.22956198e-02f, -4.27381974e-03f, -5.82622550e-02f,
  -5.67405671e-02f, 2.49781064e-03f, 4.46340926e-02f, -1.18935131e-03f, 6.01626784e-02f, -3.69254909e-02f, 1.57267377e-01f, 8.48689005e-02f, 3.10473684e-02f, -3.40145035e-03f,
  -8.71027485e-02f, -1.22877676e-02f, 4.46064435e-02f, -8.86433050e-02f, 6.28918037e-02f, 6.31775334e-02f, -6.46005245e-03f, 5.56492768e-02f, -6.08236156e-02f, 8.08120072e-02f,
  -2.68892020e-01f, 2.40187764e-01f, 3.97726558e-02f, -2.94145811e-02f, 7.23680258e-02f, -7.22719282e-02f, 2.23842710e-02f, 6.13668635e-02f, 1.14651255e-01f, -5.15081100e-02f,
  -1.08650615e-02f, -4.59957160e-02f, -5.36770299e-02f, -2.09295787e-02f, -1.33797303e-01f, -7.95768981e-04f, -6.81039542e-02f, -6.83368146e-02f, 5.54751430e-04f, -4.08429354e-02f,
  -1.45247191e-01f, -1.32650241e-01f, -1.56489551e-01f, -2.03105792e-01f, -1.23193584e-01f, 4.07614559e-02f, 1.15522519e-02f, 5.99485487e-02f, 4.04720306e-02f, -1.81808740e-01f,
  1.69426315e-02f, -1.94896072e-01f, 1.55655712e-01f, -6.80731311e-02f, 6.28657788e-02f, 2.83638358e-01f, 1.27383679e-01f, 2.22180590e-01f, 6.35252073e-02f, -9.50244591e-02f,
  -4.15725354e-03f, -8.80756080e-02f, 2.32958402e-02f, -1.63519174e-01f, 2.85628028e-02f, -1.33153453e-01f, -1.53103188e-01f, -1.05051935e-01f, 1.76315084e-01f, 9.59866568e-02f,
  -7.82568231e-02f, -1.23661034e-01f, -5.96395433e-02f, -3.19802836e-02f, -1.20011680e-01f, 9.11816210e-02f, -2.16286387e-02f, 2.25800145e-02f, -1.06789038e-01f, -4.14920539e-01f,
  3.42514031e-02f, -5.52915595e-03f, 7.60560036e-02f, -1.61139652e-01f, 9.70829427e-02f, 1.71016455e-02f, -1.37321819e-02f, -8.14679172e-03f, 2.33706813e-02f, 5.46038784e-02f,
  -4.74797301e-02f, -7.68846422e-02f, -3.29039805e-02f, -7.88443834e-02f, 8.26228932e-02f, 4.60902266e-02f, -3.69231366e-02f, -3.48914340e-02f, 4.58571613e-02f, 5.18844016e-02f,
  -1.47337303e-01f, -1.65660288e-02f, 1.10031433e-01f, 1.01170585e-01f, 8.19928385e-03f, 3.24740708e-02f, 1.17729671e-01f, 5.94697706e-02f, 1.14516810e-01f, 3.02269440e-02f,
  -8.03856626e-02f, 1.47321783e-02f, -5.18293679e-02f, -7.21957535e-02f, -1.89431310e-02f, -6.50774166e-02f, -5.17102405e-02f, 3.23264673e-03f, -1.12787755e-02f, 4.45907488e-02f,
  3.26875523e-02f, 3.49875242e-02f, 4.55178134e-02f, 3.74444164e-02f, 9.74889379e-03f, 5.75299468e-03f, -2.44975463e-02f, -3.02636065e-02f, 1.60243991e-03f, 3.24414968e-02f,
  9.96618420e-02f, 1.29575461e-01f, 1.59851741e-02f, -8.05216432e-02f, -3.61355282e-02f, -2.26168670e-02f, -1.89570896e-02f, -3.96649614e-02f, 5.54167330e-02f, 4.73242775e-02f,
  8.47251117e-02f, -7.01095909e-03f, -1.19431615e-01f, 4.06653993e-02f, 9.53229368e-02f, 6.19131476e-02f, -3.79127897e-02f, -4.62301560e-02f, 5.65726608e-02f, 1.95363820e-01f,
  -4.03802842e-02f, 1.31978961e-02f, 4.36150692e-02f, 7.05984533e-02f, 1.35482058e-01f, 8.72279555e-02f, -5.95113970e-02f, -8.01929086e-03f, 4.07775640e-02f, 2.76692808e-02f,
  6.74518803e-03f, 2.61578113e-01f, 1.16293758e-01f, 1.93650454e-01f, 1.64480940e-01f, 2.39528969e-01f, 2.06822753e-01f, 1.36992157e-01f, 1.54904440e-01f, 1.55239582e-01f,
  3.44291538e-01f, 1.94855705e-01f, 6.65622652e-02f, -9.82705951e-02f, -2.96167016e-01f, -1.81736827e-01f, 1.89641714e-01f, -2.81397551e-02f, 9.03597549e-02f, 3.33305337e-02f,
  -1.14392519e-01f, -1.56242192e-01f, -7.90262967e-02f, -4.24627066e-02f, -8.83988850e-03f, 3.43830436e-01f, 1.32253960e-01f, 4.46494780e-02f, -2.31291144e-03f, -7.72186145e-02f,
  -9.90758389e-02f, 2.02817526e-02f, -3.30710746e-02f, 4.87378724e-02f, 1.27822101e-01f, -6.08718656e-02f, 6.74156100e-02f, -6.25910908e-02f, -3.11825983e-02f, 3.07753652e-01f,
  -1.36080422e-02f, 8.81521478e-02f, 3.64896320e-02f, -1.07506722e-01f, -1.66277681e-02f, 8.28769654e-02f, 6.93513528e-02f, 1.81343645e-01f, 1.01193547e-01f, 1.22481331e-01f,
  -9.73132551e-02f, -1.27598308e-02f, -7.20842034e-02f, -8.07801560e-02f, 8.62173885e-02f, -1.28501495e-02f, 1.45066023e-01f, 5.10559231e-02f, 1.25163525e-01f, 9.97154936e-02f,
  -8.48461594e-03f, -1.69082075e-01f, -8.05982649e-02f, 2.50031669e-02f, 4.11699340e-02f, -1.08553596e-01f, -3.67817609e-03f, 1.51325017e-01f, -6.80104420e-02f, 3.46782327e-01f,
  1.98205076e-02f, -1.19129360e-01f, -3.06467805e-03f, -6.99748751e-04f, 3.97898443e-02f, -4.72750422e-03f, -1.14549048e-01f, -6.12847507e-02f, 4.30431962e-02f, 8.38340670e-02f,
  -6.80854023e-02f, -9.33196098e-02f, -5.69896549e-02f, -1.07646123e-01f, -4.14503478e-02f, -1.30930334e-01f, 2.28679599e-03f, 1.08529450e-02f, -8.22127461e-02f, -3.21225002e-02f,
  -9.40990355e-03f, -5.83639741e-02f, -2.26747803e-02f, 2.41494700e-02f, -7.48511031e-02f, -5.63788489e-02f, -1.18506499e-01f, -1.47811905e-01f, -1.52001098e-01f, -1.28295660e-01f,
  7.45031843e-03f, -1.89584613e-01f, 1.68492466e-01f, 7.52058178e-02f, 1.56780034e-02f, 6.18077517e-02f, 2.55788062e-02f, -1.41320527e-02f, -2.59433761e-02f, -3.99503484e-02f,
  -1.25718461e-02f, 9.19738561e-02f, -3.15499604e-02f, 1.37938514e-01f, -4.96244151e-03f, -2.54540928e-02f, -2.44267434e-02f, 7.03082755e-02f, -5.51349344e-03f, 7.22857416e-02f,
  7.54914880e-02f, 3.01113464e-02f, 1.00917630e-01f, 7.87756890e-02f, 1.08161874e-01f, 2.82769445e-02f, 1.65635958e-01f, 8.73886943e-02f, 1.63609192e-01f, 4.10583526e-01f,
  -2.93616410e-02f, -8.31663832e-02f, -5.62166087e-02f, 1.78190947e-01f, 1.77239310e-02f, 7.59115675e-03f, -8.50366661e-04f, 1.53883457e-01f, 2.21551672e-01f, 1.20991722e-01f,
  3.40237431e-02f, 2.41112504e-02f, -5.18688597e-02f, -4.70243655e-02f, -1.90395582e-02f, 5.35570197e-02f, -8.14461261e-02f, -2.32031390e-01f, -1.09969780e-01f, -1.56651050e-01f,
  -8.47574696e-02f, -6.35576695e-02f, 3.21338065e-02f, 7.64004067e-02f, -7.80366659e-02f, 9.58410501e-02f, -7.25968601e-03f, -1.90566331e-01f, -1.24469660e-01f, -3.97031277e-01f,
  -2.06142560e-01f, -2.14526713e-01f, 1.77563112e-02f, -4.07201014e-02f, -1.41769946e-01f, 2.64069531e-02f, -8.32509398e-02f, -1.81082673e-02f, 1.93557125e-02f, 6.40534610e-02f,
  5.46040721e-02f, -5.62827848e-02f, -8.66881683e-02f, -1.37591392e-01f, -1.38656711e-02f, -1.05132684e-02f, -3.13430093e-02f, -4.65569738e-03f, 2.71461792e-02f, -2.06557158e-02f,
  8.32701027e-02f, -3.21866237e-02f, 8.10769014e-03f, 1.02105230e-01f, 8.95591080e-02f, -3.44120115e-02f, 5.78802042e-02f, -1.08839586e-01f, -8.09352398e-02f, -3.41398418e-02f,
  3.20176780e-02f, -5.16317748e-02f, -7.31093362e-02f, -1.45673141e-01f, 4.48754020e-02f, 1.21600218e-01f, -1.14892490e-01f, -8.97543654e-02f, -1.11166704e-02f, -1.07276089e-01f,
  4.06595618e-02f, 6.91256374e-02f, 2.81415395e-02f, 9.32338685e-02f, 3.03647090e-02f, -4.25749049e-02f, 2.41174195e-02f, 5.89745631e-03f, -1.61189586e-02f, 3.70274559e-02f,
  -4.08617482e-02f, 3.89096700e-02f, 1.23403519e-01f, 1.74566382e-03f, -4.75969240e-02f, -1.63278237e-01f, 5.90234101e-02f, 8.19876790e-02f, -5.85661680e-02f, -5.20538017e-02f,
  4.00556326e-01f, -1.33987799e-01f, 6.69016913e-02f, -3.37159149e-02f, -3.77248190e-02f, 1.03849083e-01f, 9.49991774e-03f, 4.31037173e-02f, -7.92649463e-02f, 6.61884621e-02f,
  -7.35302716e-02f, -9.72453319e-03f, 1.32445972e-02f, 4.97039184e-02f, 1.01493806e-01f, 4.02187631e-02f, 7.23870993e-02f, 8.26291088e-03f, 5.93114831e-02f, 1.00740336e-01f,
  1.92312613e-01f, 9.13762227e-02f, 1.41472250e-01f, 1.19948670e-01f, 1.29077464e-01f, -1.88563149e-02f, 8.28763843e-03f, 6.48402348e-02f, -2.57627410e-03f, 2.09254339e-01f,
  -3.24184716e-01f, 3.37115794e-01f, -1.14072347e-02f, 5.78569956e-02f, 3.21669817e-01f, 1.68717667e-01f, 1.95113078e-01f, -1.28006414e-02f, -2.30940734e-03f, 2.57796645e-01f,
  -1.80086512e-02f, 1.31980926e-02f, -2.11309329e-01f, -2.07607616e-02f, -2.48796970e-01f, 1.81438789e-01f, 1.04151808e-01f, -1.26994371e-01f, -2.09335685e-01f, 1.62384257e-01f,
  1.81142107e-01f, -4.28256020e-02f, -2.35973760e-01f, -8.71021952e-03f, 1.56036973e-01f, 3.07833906e-02f, 1.67880923e-01f, 8.70308205e-02f, 1.60582483e-01f, 2.55851537e-01f,
  -1.99977402e-02f, -7.00771883e-02f, 7.99156949e-02f, 8.17081481e-02f, -3.95181240e-04f, -5.16403504e-02f, 2.80132368e-02f, -2.36465596e-02f, 4.09755595e-02f, 9.71590132e-02f,
  5.64266331e-02f, -2.56853807e-03f, -8.59263167e-02f, 4.78739589e-02f, 6.60016686e-02f, 3.34656239e-02f, 7.35091195e-02f, -3.88190635e-02f, -8.58784690e-02f, 6.30296096e-02f,
  6.88617378e-02f, 1.42946348e-01f, 1.66638773e-02f, -4.74031903e-02f, -4.28027958e-02f, -2.28849594e-02f, 6.63812160e-02f, 8.64327028e-02f, 8.98721255e-03f, 1.60199389e-01f,
  4.20105569e-02f, -2.67009195e-02f, -6.53976649e-02f, 2.33322233e-02f, -2.00073607e-02f, -6.44525653e-03f, -6.45602569e-02f, -2.86937431e-02f, 2.12655892e-03f, 6.67128945e-04f,
  -1.85187291e-02f, 3.13446298e-02f, -9.78787616e-02f, 1.41793611e-02f, 6.89055547e-02f, 5.48385233e-02f, -3.22853513e-02f, -4.83114608e-02f, 1.84166047e-03f, 4.02192660e-02f,
  3.50657329e-02f, 5.04429489e-02f, 4.59190756e-02f, -4.59601469e-02f, 1.03842497e-01f, -1.28316330e-02f, 2.26834938e-02f, -6.48686523e-03f, -5.30587547e-02f, 4.32087481e-02f,
  -1.12502854e-02f, -1.97635386e-02f, 8.28884393e-02f, 1.32132778e-02f, 4.87270653e-02f, -3.70958187e-02f, 3.66618782e-02f, -4.91113886e-02f, -4.17488031e-02f, 2.74803489e-02f,
  -5.98457456e-02f, -9.01236832e-02f, 7.72377700e-02f, 3.77374105e-02f, 5.86890206e-02f, 3.06083597e-02f, 1.21621840e-01f, 3.24205458e-02f, 7.68249854e-02f, 9.49304700e-02f,
  -1.38653191e-02f, 1.12128779e-01f, 2.05038972e-02f, 1.09920003e-01f, 9.18048322e-02f, 4.09455039e-02f, -1.42299188e-02f, -4.19619679e-03f, -6.62658438e-02f, 1.51457667e-01f,
  2.75525182e-01f, -4.71964300e-01f, 2.74841994e-01f, 1.94109216e-01f, -2.26714134e-01f, 6.15023412e-02f, -2.74325103e-01f, 6.69443607e-02f, 8.05004537e-02f, -1.74953103e-01f,
  -1.40997887e-01f, 1.19562350e-01f, 9.75612327e-02f, 1.66026831e-01f, 3.03264648e-01f, -5.89820407e-02f, 4.95830737e-02f, 2.57415146e-01f, 5.20151496e-01f, 1.39488906e-01f,
  -1.12690993e-01f, 9.87341255e-02f, 2.85301983e-01f, 2.96047002e-01f, -8.66977498e-02f, 6.77726492e-02f, -5.88671464e-05f, 1.09044857e-01f, 5.01211062e-02f, -2.23724931e-01f,
  1.80737868e-01f, -5.81471343e-03f, 1.55771419e-01f, 6.13999143e-02f, 2.01273710e-02f, 1.82023183e-01f, -8.42030253e-03f, 1.04965165e-01f, 8.45199823e-02f, 1.50449082e-01f,
  8.52211118e-02f, 4.96425927e-02f, 4.50465865e-02f, 6.77035227e-02f, 7.48330578e-02f, 2.04799220e-01f, 1.96164981e-01f, 1.70195356e-01f, 2.31368378e-01f, 1.32296100e-01f,
  -7.41525590e-02f, -1.47704139e-01f, 1.90845300e-02f, 1.62279457e-01f, 2.15703145e-01f, 1.19606435e-01f, -2.43248455e-02f, 1.67383343e-01f, 1.98497981e-01f, -3.80253121e-02f,
  1.09828208e-02f, -5.97534515e-02f, -1.00093214e-02f, 3.66681931e-03f, -6.21640608e-02f, -5.49101420e-02f, -7.82615244e-02f, -1.77586637e-03f, -4.29535806e-02f, -2.73209512e-02f,
  1.07693568e-01f, -1.65993012e-02f, -3.11036091e-02f, 1.56398024e-02f, -8.26774258e-03f, -4.71544340e-02f, 3.91711965e-02f, 1.85815115e-02f, 1.29248857e-01f, 6.52656481e-02f,
  3.28161530e-02f, 2.57976493e-03f, -7.59071633e-02f, 5.79814725e-02f, -2.92997435e-02f, 1.00760281e-01f, 4.57850620e-02f, -5.75609952e-02f, 7.58822933e-02f, 7.25625604e-02f,
  -7.41241872e-02f, 6.72230646e-02f, 9.03390720e-02f, 1.50423184e-01f, 9.25270543e-02f, 1.83614075e-01f, 1.34203389e-01f, 1.71063676e-01f, 1.25707150e-01f, 8.54753479e-02f,
  1.05452426e-01f, 9.87526551e-02f, 4.23890911e-02f, 1.55359179e-01f, 1.11804649e-01f, -9.26674996e-03f, 8.42924416e-02f, 1.12356015e-01f, 1.35369211e-01f, 1.44301444e-01f,
  9.42212716e-02f, 8.06021690e-02f, 1.77875698e-01f, 7.04593882e-02f, 8.58706534e-02f, 1.26319677e-01f, 8.42970088e-02f, 3.80292870e-02f, 2.12599337e-01f, 3.54126319e-02f,
  8.35394323e-01f, 1.07555896e-01f, -6.61885142e-02f, 2.83856630e-01f, -2.52417922e-02f, -1.15994066e-01f, -9.30055231e-02f, 5.78355715e-02f, 1.11810453e-01f, 1.45240843e-01f,
  -1.32097647e-01f, -3.10403183e-02f, -1.00181133e-01f, -2.51286387e-01f, -1.53957754e-01f, -5.92710041e-02f, -1.61755323e-01f, -1.18833547e-02f, 1.16138831e-02f, -8.25546589e-03f,
  -5.15626445e-02f, 2.19386354e-01f, 2.84660727e-01f, 1.30677372e-01f, 1.38031572e-01f, -1.50412470e-01f, -2.93389857e-02f, -5.75815775e-02f, -3.20481323e-02f, 1.46080583e-01f,
  -1.20008528e-01f, 1.81494981e-01f, -1.68048173e-01f, 1.50714153e-02f, 5.00673950e-02f, 6.14198530e-03f, -8.13736096e-02f, 7.75513984e-03f, -8.84807855e-03f, 4.65229452e-02f,
  -2.32493300e-02f, 5.82928732e-02f, 3.69942598e-02f, 1.86381377e-02f, 9.64550972e-02f, 9.58270133e-02f, 2.87601668e-02f, 7.68646598e-02f, -3.03735323e-02f, -2.42994111e-02f,
  -6.05947226e-02f, -6.07862920e-02f, 1.06790677e-01f, -2.12098286e-03f, -2.17609201e-02f, -3.55782434e-02f, 1.22806123e-02f, -7.74014667e-02f, -7.08810389e-02f, 1.06185324e-01f,
  -9.75374505e-02f, 4.66862246e-02f, 1.15173422e-02f, 5.99423945e-02f, 1.11459114e-01f, -8.12910721e-02f, -5.67189939e-02f, -1.50767425e-02f, 2.92510539e-02f, 1.12940073e-01f,
  3.41437384e-02f, -7.71785295e-03f, -4.13779914e-03f, 2.71000694e-02f, 3.05835884e-02f, -3.24812159e-02f, 3.17812413e-02f, 1.13611892e-02f, -3.73040549e-02f, 1.54308900e-01f,
  -1.72069967e-02f, -4.75872727e-03f, -5.74472882e-02f, 2.88634188e-02f, 4.17964906e-03f, -3.79766822e-02f, -1.35660609e-02f, -7.50413164e-02f, -5.49450284e-03f, 5.03962077e-02f,
  -2.33045239e-02f, -2.75659412e-01f, 1.58677146e-01f, 1.52941961e-02f, 6.33249851e-03f, 2.47428026e-02f, 7.54252970e-02f, 1.83739718e-02f, 5.39901629e-02f, 1.11451477e-01f,
  -2.05325466e-02f, -1.77831277e-02f, -4.85774726e-02f, 3.92617248e-02f, 5.20552993e-02f, 8.01845640e-02f, 7.01249689e-02f, 2.31696442e-02f, 1.64108779e-02f, 5.09081669e-02f,
  6.47200495e-02f, 1.06977500e-01f, 5.94161972e-02f, 3.69156413e-02f, -5.33397645e-02f, -3.72628830e-02f, -4.92594205e-02f, 2.12302711e-03f, -1.38620034e-01f, 1.51969930e-02f,
  4.17438656e-01f, -4.42069918e-01f, 4.99047115e-02f, 2.30698586e-02f, -2.76974738e-01f, -1.44022509e-01f, -2.47185037e-01f, -2.02823896e-02f, -3.18617225e-02f, -9.37352702e-02f,
  -2.06750602e-01f, 4.51838644e-03f, 1.01549998e-01f, 1.99253857e-01f, 2.77487725e-01f, 1.33897886e-01f, 4.34967969e-03f, 2.82844007e-01f, 3.33553791e-01f, 1.42270491e-01f,
  -9.80511010e-02f, 6.77415356e-02f, 1.27781302e-01f, 1.81985021e-01f, -1.04618944e-01f, 1.79696202e-01f, -5.20211384e-02f, -2.00921938e-01f, -1.22212663e-01f, -1.74873307e-01f,
  1.75589114e-01f, -1.57659262e-01f, 9.88368914e-02f, 1.14070764e-02f, -7.55711421e-02f, 9.17037576e-02f, 4.98101972e-02f, 3.25277746e-02f, -3.85650550e-03f, 4.02230173e-02f,
  -3.30293924e-02f, 6.54766634e-02f, 1.25401571e-01f, 7.43553415e-03f, -1.86323822e-02f, 4.84070554e-03f, 8.94029662e-02f, 6.65131733e-02f, 9.05199051e-02f, -4.49864417e-02f,
  -1.37846082e-01f, -7.74993822e-02f, -7.23098814e-02f, -1.12251692e-01f, -1.45713305e-02f, -5.09807952e-02f, 2.73907520e-02f, -7.29993656e-02f, -4.22125421e-02f, 3.45687121e-02f,
  -1.05302058e-01f, 5.83515801e-02f, 3.56001221e-02f, -8.93885642e-02f, -4.96963449e-02f, -3.02356202e-02f, 8.06450620e-02f, -2.99873273e-03f, 6.50441274e-02f, -1.28252367e-02f,
  1.09169772e-02f, -8.70949961e-03f, -1.02950539e-02f, -7.34726116e-02f, 3.60904597e-02f, -7.41451383e-02f, 4.37707379e-02f, 7.86759183e-02f, -3.82345840e-02f, -3.85376811e-02f,
  -2.48573758e-02f, -7.38150850e-02f, 7.38416836e-02f, 2.30628997e-02f, -3.53917654e-04f, 3.61077525e-02f, 2.83294749e-02f, -1.80802476e-02f, -3.07675004e-02f, -2.37305127e-02f,
  1.44813983e-02f, -2.19567176e-02f, 1.67270258e-01f, -1.58110186e-02f, 3.70631255e-02f, 3.81734297e-02f, -1.82375945e-02f, 6.12976775e-03f, -6.78935871e-02f, -2.07509543e-03f,
  -2.96871085e-03f, 1.06388349e-02f, 8.49866215e-03f, 6.71645924e-02f, 1.32481148e-02f, -1.71348397e-02f, -6.48452118e-02f, 1.22163288e-01f, 7.04016238e-02f, -3.99560481e-02f,
  -3.47711444e-02f, -6.65638642e-03f, 1.24037117e-02f, 4.91633788e-02f, -1.76418740e-02f, 6.28449395e-02f, 5.76951392e-02f, 2.92683654e-02f, 1.40067607e-01f, 1.17807522e-01f,
  -3.77631895e-02f, -2.25721687e-01f, -5.62548578e-01f, 5.50718755e-02f, -1.61400363e-01f, -6.60131201e-02f, -2.09594488e-01f, -7.54543394e-02f, -5.41722961e-02f, -1.05522826e-01f,
  2.38100495e-02f, 2.08269015e-01f, 9.57192928e-02f, -1.50893524e-01f, -1.86443120e-01f, -1.96549430e-01f, -2.12301031e-01f, -3.32100183e-01f, -3.65841165e-02f, 4.55603972e-02f,
  8.99792910e-02f, -2.86096744e-02f, -8.70314613e-02f, -2.12167427e-02f, -6.61428869e-02f, 9.98810828e-02f, -2.45100766e-01f, -2.80638516e-01f, -1.23806268e-01f, -3.03589582e-01f,
  -1.43348873e-01f, -3.11809987e-01f, -1.67539388e-01f, -9.92999673e-02f, -2.70697981e-01f, -1.80653840e-01f, -3.63169275e-02f, -1.30902305e-01f, -1.11098371e-01f, -1.48617715e-01f,
  -1.58174321e-01f, -1.29059523e-01f, -1.07245475e-01f, -1.22240052e-01f, -1.56275377e-01f, -2.09239900e-01f, -1.47705749e-01f, -3.43776375e-01f, -2.96679497e-01f, -1.90579459e-01f,
  -5.92190363e-02f, -1.82615563e-01f, -1.49613023e-01f, -1.21173926e-01f, -1.72081828e-01f, -7.58304521e-02f, -2.56847501e-01f, -2.23516554e-01f, -2.72607327e-01f, -2.02773958e-01f,
  1.38993308e-01f, 5.28784283e-02f, 8.40006247e-02f, 1.57242328e-01f, 1.02894716e-01f, 4.36072350e-02f, 6.13226332e-02f, 7.00217634e-02f, 1.56769603e-01f, 1.69420708e-02f,
  1.03667714e-02f, 8.12453479e-02f, 1.00906007e-01f, 4.71173301e-02f, 1.66142255e-01f, 1.11727856e-01f, 1.11274846e-01f, 2.96563003e-02f, 1.72695160e-01f, 1.00990616e-01f,
  5.17885499e-02f, 4.71253181e-03f, 8.29102471e-02f, 4.48315144e-02f, 6.30481243e-02f, 1.03297457e-02f, 1.31054834e-01f, 9.54690576e-02f, 9.47281197e-02f, 2.00877041e-01f,
  2.39299104e-01f, -2.95419395e-01f, 7.76349530e-02f, -1.17586613e-01f, -3.70826274e-02f, -3.29777487e-02f, -1.21054938e-03f, 2.20059846e-02f, -3.85981463e-02f, -8.53177309e-02f,
  -1.61478341e-01f, -1.34766906e-01f, -1.05069526e-01f, -1.65905401e-01f, -1.28280133e-01f, -1.36590786e-02f, 4.52466123e-02f, -6.24648146e-02f, -1.28332660e-01f, -1.47603497e-01f,
  -1.15666986e-01f, 8.73984769e-03f, 1.20555080e-01f, -3.38115208e-02f, -2.72581950e-02f, -3.89563814e-02f, -1.00215070e-01f, -6.02603666e-02f, -1.19914785e-02f, 7.21461326e-02f,
  2.48238757e-01f, -3.94652672e-02f, -9.49483439e-02f, 2.39408925e-01f, 9.08752158e-02f, 1.79188848e-02f, -3.10057476e-02f, 3.06133181e-02f, 9.07779485e-02f, -5.21803349e-02f,
  5.84125938e-03f, 9.83346477e-02f, 1.37365833e-01f, 2.09981464e-02f, 1.38653755e-01f, -1.92780048e-01f, -4.57965443e-03f, 5.17592020e-02f, 2.26478577e-01f, 1.40364587e-01f,
  1.28589064e-01f, 1.97128162e-01f, 3.39428037e-01f, 1.49892330e-01f, -2.50311587e-02f, 1.50650620e-01f, -6.50771707e-02f, 3.40119787e-02f, -1.07878586e-02f, -1.12647019e-01f,
  -1.02743231e-01f, -4.58363444e-02f, 2.43624717e-01f, 2.26797491e-01f, -1.39449565e-02f, 1.10588200e-01f, -9.36102495e-03f, 1.07503340e-01f, 8.68522078e-02f, -1.15480293e-02f,
  9.78419110e-02f, 2.34241188e-02f, 5.96291535e-02f, 2.92166453e-02f, 2.46467404e-02f, 1.11180224e-01f, 8.39478821e-02f, 1.23222969e-01f, 1.27703607e-01f, 1.95764750e-02f,
  2.32573450e-02f, 1.18184529e-01f, -7.17472211e-02f, 1.14029162e-01f, -2.55372729e-02f, 1.45702958e-01f, -4.39067297e-02f, 9.43258870e-03f, -1.10990484e-03f, -5.35236932e-02f,
  -1.96087267e-02f, -4.48656268e-02f, -1.61412865e-01f, -9.43545327e-02f, -1.25219673e-01f, -3.36494856e-02f, -1.09562941e-01f, -5.04094772e-02f, -5.07850051e-02f, 1.86370816e-02f,
  4.56805108e-03f, -5.26059465e-03f, -8.30874518e-02f, -7.50214159e-02f, 2.02351483e-03f, -1.00052059e-01f, 1.92013197e-02f, -4.00368357e-03f, 4.00406197e-02f, 1.83585696e-02f,
  2.36191023e-02f, -7.45106339e-02f, -3.97386961e-02f, -1.10001393e-01f, 1.38252359e-02f, -1.15373973e-02f, -6.86209500e-02f, -1.36401504e-01f, -5.19487672e-02f, -4.91384082e-02f,
  1.48762390e-01f, 2.37860814e-01f, 8.06229748e-03f, 1.42917529e-01f, 1.60772353e-01f, 1.56659260e-01f, 8.83525759e-02f, 1.31395027e-01f, 1.20443098e-01f, 1.32101133e-01f,
  1.05829984e-01f, 1.68589443e-01f, 1.98235229e-01f, 1.15682192e-01f, 1.26542553e-01f, 1.30659074e-01f, 1.32345796e-01f, 1.38869971e-01f, 1.89496219e-01f, 6.48161247e-02f,
  1.59812585e-01f, 1.09333880e-01f, 4.77036908e-02f, 1.71204835e-01f, 6.10403679e-02f, 2.11732194e-01f, 1.04772955e-01f, 1.67631656e-01f, 6.79591745e-02f, 1.40071377e-01f,
  4.89125222e-01f, -4.07945551e-02f, -8.02897364e-02f, 1.11801580e-01f, 1.32778987e-01f, 9.93430316e-02f, 6.11346476e-02f, -1.02818906e-01f, 2.20989082e-02f, 5.80360331e-02f,
  1.38826352e-02f, 5.94346561e-02f, -1.05089076e-01f, -1.12884399e-02f, -1.12761855e-02f, -3.09703816e-02f, 8.28522444e-02f, 2.70782132e-02f, 2.01004177e-01f, 3.13920200e-01f,
  2.29947940e-01f, 2.71590173e-01f, 2.08011374e-01f, 2.07963176e-02f, 2.08836749e-01f, 6.21280586e-03f, -1.37904853e-01f, 1.51441753e-01f, 4.65420308e-03f, 2.12094873e-01f,
  6.82615563e-02f, 1.47464231e-01f, -9.10194814e-02f, -1.82265043e-02f, -7.11585730e-02f, 1.28931422e-02f, 1.48594184e-02f, -5.94949462e-02f, 1.75079647e-02f, -6.59345463e-02f,
  2.45311838e-02f, -5.04876114e-02f, 1.01274461e-01f, 3.43174972e-02f, 9.22813341e-02f, 1.44423485e-01f, -1.31937740e-02f, -5.36662638e-02f, -1.86563917e-02f, 6.65602684e-02f,
  1.38412789e-01f, 2.24219989e-02f, 2.58446559e-02f, -3.81136276e-02f, -4.37894054e-02f, 1.44226281e-02f, -1.73417311e-02f, 2.19604857e-02f, -1.26589239e-01f, 2.61617787e-02f,
  4.91489470e-02f, -5.23111504e-03f, -6.53633028e-02f, -1.02607682e-01f, -6.74377903e-02f, -7.82992318e-02f, 2.04570242e-03f, -3.46797965e-02f, -3.71256992e-02f, 9.23566800e-03f,
  -5.05265631e-02f, 8.60278159e-02f, 1.09263202e-02f, 2.86433510e-02f, 1.99937951e-02f, -6.17649481e-02f, 4.24374901e-02f, -6.58855289e-02f, -3.80555317e-02f, 2.50186957e-03f,
  2.70241741e-02f, 3.91048491e-02f, 2.70904340e-02f, 5.95417097e-02f, 2.33761538e-02f, -9.82268676e-02f, 1.39776766e-01f, 1.04592644e-01f, -6.08567428e-03f, -1.04587059e-03f,
  -1.44341052e-01f, -1.58386931e-01f, 1.41154258e-02f, 5.27819898e-03f, -4.06958610e-02f, -7.86207765e-02f, -9.19597521e-02f, 7.00007891e-03f, -3.15481462e-02f, 4.63835336e-02f,
  3.08023524e-02f, -9.16769579e-02f, -1.10468611e-01f, -4.70250025e-02f, -2.72526760e-02f, -2.32402273e-02f, 1.32565573e-02f, -9.61233675e-02f, -4.77636494e-02f, -6.43014163e-02f,
  -1.85522195e-02f, -7.23354816e-02f, -5.49317710e-02f, -1.27809614e-01f, 9.82171483e-03f, -1.42863821e-02f, 2.01239400e-02f, -7.97058120e-02f, -3.68498731e-04f, -7.78692663e-02f,
  2.14836314e-01f, 1.69513255e-01f, 2.84842253e-01f, -1.43443242e-01f, -1.25140905e-01f, -3.99966575e-02f, -1.06212847e-01f, -8.44110176e-02f, -1.13882378e-01f, -1.32685080e-01f,
  -1.43804356e-01f, -2.43134335e-01f, -3.67243327e-02f, -1.69978872e-01f, 7.20540062e-02f, -2.01805476e-02f, 1.07432842e-01f, 4.37563062e-02f, -1.58811644e-01f, -2.51887858e-01f,
  -3.87092233e-01f, -5.44428453e-02f, 1.58131689e-01f, -1.05111219e-03f, -1.76075637e-01f, -2.71208227e-01f, 1.50150210e-01f, 1.55156270e-01f, -6.55101016e-02f, -6.39994889e-02f,
  2.76201777e-02f, 1.42353058e-01f, -1.37495205e-01f, 2.68714502e-02f, -2.35447064e-02f, 5.67376567e-03f, -8.83298740e-02f, 1.03565834e-01f, -6.63935319e-02f, 5.71982525e-02f,
  -1.30950939e-02f, -2.02542786e-02f, -7.35384524e-02f, 5.06995544e-02f, -1.11385509e-02f, -1.19462766e-01f, 3.04204039e-02f, 2.00261131e-01f, 1.54812545e-01f, -6.40230924e-02f,
  -4.90780026e-02f, -5.02042994e-02f, 1.04193337e-01f, 4.69909720e-02f, 1.15664268e-03f, -9.50039029e-02f, 5.85132800e-02f, 1.10616624e-01f, 9.22894385e-03f, 2.54198294e-02f,
  -6.71288818e-02f, 9.04687569e-02f, 6.42809644e-02f, 7.48184323e-02f, -3.20836641e-02f, 6.78038299e-02f, 2.31367592e-02f, 4.61388975e-02f, 1.10719286e-01f, 5.71334884e-02f,
  2.29507741e-02f, -1.46307563e-02f, 7.83038959e-02f, 6.18067943e-02f, -2.80110594e-02f, 5.53089492e-02f, 4.81931046e-02f, 2.75151096e-02f, 9.33684185e-02f, 5.55984043e-02f,
  3.21757793e-02f, 8.58051851e-02f, -2.14988762e-03f, 1.48331921e-04f, -6.51829392e-02f, 1.35034686e-02f, 4.82962877e-02f, -5.50180450e-02f, -4.62741777e-02f, 7.90733024e-02f,
  -1.66143209e-01f, 1.37393117e-01f, -1.48288161e-01f, -6.09453730e-02f, 6.02511726e-02f, -3.00759617e-02f, 1.02884443e-02f, -5.62975481e-02f, -2.11322103e-02f, -9.52386558e-02f,
  1.06668822e-03f, -5.10036387e-02f, -2.82351170e-02f, 1.16668351e-01f, -2.56341323e-02f, -2.99783684e-02f, -4.17649234e-03f, -7.25621879e-02f, 5.57394661e-02f, -2.15466134e-03f,
  6.85696006e-02f, -1.05534881e-01f, -6.62356690e-02f, -7.87382200e-02f, -7.17385709e-02f, -1.05831131e-01f, -6.66274950e-02f, -1.03287384e-01f, -8.03017318e-02f, -1.34350568e-01f,
  3.18477273e-01f, 1.67422295e-01f, 2.38183528e-01f, -3.38522047e-02f, -8.24028850e-02f, -9.62976217e-02f, -1.97198063e-01f, -4.77564521e-02f, -5.50753213e-02f, -6.40264153e-03f,
  3.08788307e-02f, -2.59518683e-01f, -8.29157680e-02f, -5.94148710e-02f, -2.11291209e-01f, 3.20997797e-02f, 1.20993972e-01f, 1.02016679e-03f, -4.25649107e-01f, -2.87640631e-01f,
  -2.71465391e-01f, -4.27879430e-02f, 8.23079348e-02f, -3.03224362e-02f, 6.80624247e-02f, -2.62562335e-01f, 2.44224548e-01f, 2.23143697e-01f, -1.40035590e-02f, 2.91737735e-01f,
  3.69183235e-02f, 2.18614131e-01f, -8.43899101e-02f, -9.38435376e-04f, 1.19699381e-01f, 5.71902394e-02f, 3.06111053e-02f, 1.50981680e-01f, 1.18293576e-01f, 1.59337863e-01f,
  3.72028500e-02f, -4.04946943e-04f, -4.42640930e-02f, 1.05285598e-02f, 1.00916073e-01f, -7.47740492e-02f, 1.46062240e-01f, 1.91243380e-01f, 3.37737612e-02f, 8.07029903e-02f,
  -7.74981976e-02f, 5.62267639e-02f, 1.04602538e-01f, 3.12413834e-02f, 9.55490768e-03f, 3.80783603e-02f, 9.85897034e-02f, 1.39952907e-02f, 1.45587996e-01f, 2.16762900e-01f,
  -1.44395545e-01f, 1.21300509e-02f, 4.12971675e-02f, -2.40587462e-02f, -7.48208584e-03f, 7.20920265e-02f, 1.43032344e-02f, -1.18432743e-02f, -1.59140661e-01f, 1.02411851e-01f,
  2.40958780e-02f, -1.01942517e-01f, 7.68559426e-03f, 2.61169132e-02f, -1.43050432e-01f, 8.36204290e-02f, -1.94390118e-03f, 5.24174534e-02f, 7.55029768e-02f, 7.20853209e-02f,
  -4.24390063e-02f, 1.54898629e-01f, 8.24076459e-02f, 6.68664426e-02f, -4.76932116e-02f, 2.63550803e-02f, 2.23492514e-02f, 1.94505788e-02f, -6.97937608e-02f, 3.16749550e-02f,
  1.26198651e-02f, -6.63573220e-02f, 1.06865823e-01f, -9.30834189e-02f, 7.61108100e-02f, 3.61508429e-02f, 1.24822892e-02f, -1.12456677e-03f, 8.07166025e-02f, 2.50591971e-02f,
  -4.30717170e-02f, 4.76358645e-02f, 1.02956317e-01f, 2.39260538e-04f, -1.00759909e-01f, -8.13072920e-02f, -3.43201831e-02f, 5.77527508e-02f, -7.45551735e-02f, 2.52168812e-02f,
  7.46922428e-03f, 3.39446813e-02f, -1.35455519e-01f, -1.52714853e-03f, -1.51941683e-02f, -2.61348575e-01f, -4.04987205e-03f, -8.52244496e-02f, -1.48009315e-01f, -9.82773006e-02f,
  6.54520929e-01f, 8.99098814e-02f, -4.04707193e-02f, 3.81146759e-01f, 1.27302364e-01f, -1.68629780e-01f, -1.76723689e-01f, -1.30377322e-01f, -4.08636481e-02f, 3.64584401e-02f,
  8.95811692e-02f, 1.47763193e-01f, 1.44756079e-01f, -1.67845935e-02f, -1.16465464e-01f, -2.80702244e-02f, -1.88857112e-02f, 3.99245601e-03f, -6.14374243e-02f, -1.98794492e-02f,
  3.85166742e-02f, 1.52558267e-01f, 1.87098354e-01f, 8.08713138e-02f, 2.12047696e-01f, 3.81944589e-02f, -8.27916414e-02f, 2.16398403e-01f, 1.29238904e-01f, 4.10105288e-01f,
  2.06310019e-01f, 1.09074093e-01f, -5.12305237e-02f, 9.72729698e-02f, 1.40112221e-01f, 1.11991530e-02f, 2.82652155e-02f, 3.44349779e-02f, 8.39194655e-02f, 5.31956218e-02f,
  9.89270657e-02f, 1.22280143e-01f, 1.31360188e-01f, 1.10318385e-01f, 8.99004638e-02f, 1.19754322e-01f, 7.22958194e-03f, 1.11251324e-01f, 2.95306165e-02f, 1.02687180e-01f,
  1.37921408e-01f, 9.97843593e-02f, 4.56686616e-02f, 2.21542772e-02f, 9.53369513e-02f, 1.56349674e-01f, 2.00444516e-02f, 9.78305712e-02f, 2.20858981e-03f, 6.82262182e-02f,
  5.03951460e-02f, 3.99794467e-02f, -1.05518244e-01f, 2.08261199e-02f, -6.19620644e-02f, 2.19413545e-02f, -3.69950058e-03f, 4.27372957e-04f, -8.08530394e-03f, 2.34436523e-02f,
  2.94968411e-02f, -2.37131882e-02f, 4.18900279e-03f, 4.55385540e-03f, 2.82519590e-02f, -1.09879544e-03f, -2.24088668e-03f, -5.25539592e-02f, -2.52033528e-02f, 3.92498076e-02f,
  2.01142188e-02f, 1.98250841e-02f, 7.38012344e-02f, 1.53627330e-02f, 5.98326661e-02f, -8.00335128e-03f, 2.36062482e-02f, -1.65017024e-02f, -2.91564595e-02f, -7.39486590e-02f,
  8.42215195e-02f, -3.48251536e-02f, 1.09139524e-01f, 4.23593819e-02f, -1.15057006e-02f, 7.92981461e-02f, 8.80999491e-02f, -2.74873637e-02f, 1.58726946e-01f, 1.34214163e-01f,
  -3.08334152e-03f, 1.18132427e-01f, 1.63662091e-01f, 7.12737516e-02f, 9.61923376e-02f, 3.01656267e-03f, 8.00626725e-02f, 1.13264360e-01f, -6.75812513e-02f, -3.33155990e-02f,
  4.47824001e-02f, -8.89996141e-02f, 3.75858769e-02f, -1.02884904e-01f, 7.64466450e-02f, 2.68167183e-02f, 6.13001771e-02f, -6.96742348e-03f, -1.56054214e-01f, -1.40189722e-01f
};

// L0_fan_Wp_bar (Shape: 14 x 120)
const int L0_fan_Wp_bar_rows = 14;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  1.55538693e-01f, -7.96989426e-02f, 4.28458929e-01f, 1.92272767e-01f, -2.03667238e-01f, -3.88162762e-01f, -5.42651534e-01f, -2.01546878e-01f, -6.82187974e-02f, 2.20503360e-02f,
  -1.91586033e-01f, -1.93909094e-01f, 7.31114745e-02f, -2.63152495e-02f, -1.19726367e-01f, 1.53540086e-03f, 1.20260112e-01f, 1.96548745e-01f, -1.90956578e-01f, -3.77160430e-01f,
  -3.21586549e-01f, 1.45187691e-01f, 2.38726974e-01f, 1.03621542e-01f, 1.96063936e-01f, -4.75219861e-02f, 4.95448172e-01f, 2.78172344e-01f, -7.13309273e-03f, 3.73883158e-01f,
  2.67791510e-01f, 2.70801842e-01f, -1.13722540e-01f, -1.94275811e-01f, 3.50589715e-02f, -3.87527384e-02f, -1.23800181e-01f, 2.51772940e-01f, -9.64693278e-02f, 1.91209853e-01f,
  -1.34516060e-02f, -1.64595813e-01f, -1.31176025e-01f, -3.02772760e-01f, -2.15035111e-01f, -1.64101243e-01f, 1.02581896e-01f, 3.00513152e-02f, 2.42606163e-01f, -1.75935235e-02f,
  -3.29518884e-01f, -1.68066666e-01f, 1.23580202e-01f, -8.43455046e-02f, 7.36136734e-02f, 3.67415734e-02f, 4.82218713e-02f, 1.78852141e-01f, 1.09067477e-01f, 1.49476290e-01f,
  -8.97309370e-03f, -1.07434921e-01f, -3.87168340e-02f, -9.60667208e-02f, -1.00834541e-01f, -5.28867319e-02f, 7.36071989e-02f, -2.59376317e-02f, -8.36667269e-02f, -1.42881554e-02f,
  -3.60029936e-02f, 6.71548769e-02f, -4.60742451e-02f, 1.05162576e-01f, 4.92010079e-02f, -1.72238685e-02f, -1.27838001e-01f, 3.98653485e-02f, 1.99449807e-03f, 3.37195769e-02f,
  -7.26431534e-02f, 8.30732659e-02f, 2.80234050e-02f, -2.47985478e-02f, 4.47341353e-02f, 3.57977021e-03f, 5.20377867e-02f, 1.87313519e-02f, 1.21899933e-01f, 1.39917552e-01f,
  -1.32133484e-01f, -1.01578377e-01f, 2.34192377e-03f, -9.49455351e-02f, 9.39234793e-02f, -2.40181871e-02f, -4.14930992e-02f, -1.05889691e-02f, 2.66397018e-02f, -1.24668971e-01f,
  -1.10907108e-01f, 1.86105818e-02f, 1.21937960e-01f, -4.10540551e-02f, -1.68483853e-01f, -1.65395662e-02f, -9.87066254e-02f, -2.01911360e-01f, -1.08853221e-01f, -9.63620022e-02f,
  -7.20314384e-02f, -2.18062639e-01f, -2.60624558e-01f, -1.41286522e-01f, 7.99301546e-03f, -2.18863338e-01f, -1.21628158e-01f, -1.16687298e-01f, -1.43384397e-01f, -3.32706064e-01f,
  1.31013781e-01f, 8.54732189e-03f, 1.60644427e-01f, -2.55230572e-02f, 7.23716915e-02f, 2.14259699e-01f, 3.30285311e-01f, 1.32695004e-01f, -4.03690971e-02f, 1.07669555e-01f,
  5.04443683e-02f, -3.73998471e-02f, -9.45965722e-02f, 3.98480073e-02f, 3.23568247e-02f, -6.68003857e-02f, -1.13650067e-02f, -4.59300959e-03f, 4.93928753e-02f, -4.01921906e-02f,
  -1.51094660e-01f, -1.27256056e-02f, -1.41951367e-01f, -8.73929709e-02f, -8.60317126e-02f, 2.49049198e-02f, -9.09755304e-02f, -6.11229474e-03f, -3.80170941e-02f, -1.25605389e-01f,
  2.41681904e-01f, 1.36597529e-01f, -3.48713845e-02f, -2.33071268e-01f, -3.69009608e-03f, -1.17742360e-01f, 9.73223150e-02f, -1.38778947e-02f, 1.65713631e-04f, -1.19189806e-01f,
  -1.37757421e-01f, -2.45222691e-02f, -2.01135967e-02f, -5.07167988e-02f, 4.94917594e-02f, -9.36836898e-02f, -5.29635996e-02f, -5.52095613e-03f, 2.65312530e-02f, -1.16352238e-01f,
  -1.41250277e-02f, -6.06453046e-03f, 1.78438216e-01f, 5.22557795e-02f, 3.64505425e-02f, -3.23243402e-02f, 2.91202012e-02f, 2.62568276e-02f, -2.20640786e-02f, 6.31345343e-03f,
  1.28995329e-01f, 7.06427395e-02f, -3.04019749e-02f, -2.73574274e-02f, 5.73881939e-02f, -8.81327689e-02f, -5.49331959e-03f, 4.90540154e-02f, 1.77913364e-02f, 1.53190792e-01f,
  3.06539088e-01f, 1.51930898e-01f, 1.26528889e-01f, 1.57432020e-01f, 1.83219612e-01f, 1.59998648e-02f, 9.99715850e-02f, 1.41362473e-01f, 2.36221880e-01f, 2.75898036e-02f,
  2.24816203e-01f, 2.89603651e-01f, 1.55018732e-01f, 2.13851959e-01f, 1.11398138e-01f, 1.81377530e-01f, 1.65631920e-01f, 1.27582341e-01f, 4.26090658e-02f, 5.72605478e-03f,
  -2.17642207e-02f, 5.50565980e-02f, -6.54725507e-02f, -4.99304533e-02f, 3.58848199e-02f, -1.14283711e-01f, 7.30726123e-02f, -1.31050833e-02f, -3.38524021e-02f, 2.96658874e-02f,
  -8.49491879e-02f, 2.46610343e-02f, 1.01404563e-01f, -1.58396978e-02f, 5.61606288e-02f, -2.03894842e-02f, -9.00406316e-02f, -6.75515505e-03f, -8.50735083e-02f, -1.42580763e-01f,
  -3.97124998e-02f, -2.72074901e-02f, 7.90354982e-02f, -7.27280416e-03f, -9.31967571e-02f, 2.80310903e-02f, 4.82469238e-02f, 1.03341741e-02f, -4.38790536e-03f, 2.01027989e-02f,
  -7.21625626e-01f, -5.40876508e-01f, 2.42822215e-01f, -1.20099718e-02f, 3.60825062e-01f, 2.99179405e-01f, 3.15746099e-01f, 2.93390620e-02f, -7.07553774e-02f, -1.01935238e-01f,
  -3.40747446e-01f, -2.72881091e-01f, -2.18943328e-01f, -2.69963980e-01f, -6.15801997e-02f, 2.21466184e-01f, 2.48250976e-01f, 2.43531018e-01f, 2.87973255e-01f, 2.12489828e-01f,
  8.21695030e-02f, 5.35441488e-02f, -2.32397169e-01f, -2.38275662e-01f, -1.40759186e-03f, 3.29815708e-02f, 1.40220448e-01f, 1.24822352e-02f, -7.44126365e-02f, 1.01152435e-02f,
  1.11483648e-01f, -1.49272025e-01f, 6.54840395e-02f, -2.90224344e-01f, -2.87752636e-02f, -9.17501897e-02f, -4.60295565e-02f, -9.80663300e-02f, -4.41999696e-02f, 3.93072329e-02f,
  -7.68088102e-02f, -1.27057657e-01f, -9.58176702e-02f, 1.68632586e-02f, 8.34820047e-02f, -2.82883700e-02f, -7.17375502e-02f, -6.06902689e-02f, -6.46133497e-02f, -8.03538933e-02f,
  -1.40406147e-01f, -1.69772655e-02f, 7.49919787e-02f, 8.86904728e-03f, -3.67965810e-02f, -7.97232985e-02f, -1.09296896e-01f, -8.14549699e-02f, -1.20830826e-01f, -1.72163208e-03f,
  6.95208684e-02f, -3.50186676e-02f, -1.47611439e-01f, 1.20578809e-02f, -4.02667746e-02f, -2.41228323e-02f, 6.80261925e-02f, 2.43720729e-02f, 9.12062544e-03f, 2.93116756e-02f,
  -3.74871753e-02f, 6.02525324e-02f, -1.19326264e-01f, -1.08040189e-02f, -1.64223373e-01f, -7.20945969e-02f, -2.00883355e-02f, -1.33983612e-01f, -6.85736537e-02f, -2.10785687e-01f,
  -5.46822697e-02f, 2.33645793e-02f, -2.58156992e-02f, -4.22936790e-02f, -9.80758592e-02f, -3.39712463e-02f, 1.23256333e-02f, -1.12777799e-01f, 3.22852097e-02f, -6.62048440e-03f,
  9.68976617e-02f, -1.12935014e-01f, 5.68660907e-02f, -9.14723799e-02f, 3.49457934e-02f, -1.07395537e-01f, -1.37855142e-01f, 5.91223612e-02f, 5.38441874e-02f, 3.49909775e-02f,
  -3.18857692e-02f, 8.02015979e-03f, -4.61643077e-02f, 6.19522445e-02f, 1.01114430e-01f, 1.45453513e-01f, -2.12524161e-01f, 9.99233425e-02f, 2.68205702e-02f, 1.00503422e-01f,
  -1.93592906e-02f, 1.19221620e-01f, 1.29537746e-01f, 1.97975889e-01f, 2.49056201e-02f, 1.99572816e-01f, 2.84091234e-01f, 2.14641348e-01f, 1.70835361e-01f, 3.22709620e-01f,
  7.43697762e-01f, -2.97592700e-01f, -5.86265232e-03f, 1.62386402e-01f, -6.86256513e-02f, 1.40094131e-01f, -1.43031210e-01f, 8.20067823e-02f, 2.51653288e-02f, -3.85861956e-02f,
  1.63846418e-01f, 3.97397161e-01f, 3.83833528e-01f, 2.68990785e-01f, 1.05107307e-01f, -2.03649551e-01f, -2.78122663e-01f, 1.58705920e-01f, 2.83735394e-01f, 1.41098112e-01f,
  -8.82780850e-02f, -9.61798429e-02f, 7.38068223e-02f, -1.05434217e-01f, -2.90847480e-01f, -2.92681530e-03f, -1.77155167e-01f, -2.74768949e-01f, -2.02099130e-01f, -3.64327878e-01f,
  -3.58304493e-02f, 8.17356482e-02f, 2.22008333e-01f, 4.77903225e-02f, -9.79658365e-02f, 3.89435291e-02f, 7.06046298e-02f, -1.57007858e-01f, -7.15412199e-02f, -1.56068757e-01f,
  -1.59235850e-01f, -1.17904030e-01f, 4.38685268e-02f, -2.37734057e-02f, -1.73299223e-01f, 5.43364659e-02f, -1.70939676e-02f, 2.60561332e-03f, 1.79056562e-02f, -1.52022624e-02f,
  -6.30016848e-02f, 4.25055213e-02f, -9.77909938e-02f, 7.31239170e-02f, 1.18104793e-01f, 5.77382296e-02f, 9.41900164e-03f, -2.92505380e-02f, 1.11596137e-01f, -3.88038382e-02f,
  1.97546985e-02f, 7.69839957e-02f, -4.44900692e-02f, 5.89825027e-02f, 7.59727508e-02f, 3.77785638e-02f, 1.01105824e-01f, -1.51204728e-02f, -4.69375737e-02f, -3.07421889e-02f,
  7.27645233e-02f, 3.70515212e-02f, 3.82825695e-02f, 4.51063551e-02f, 5.87762147e-02f, -7.06281327e-03f, -6.40012994e-02f, -9.74286273e-02f, -1.80089269e-02f, 4.48493995e-02f,
  2.96301134e-02f, -6.99846670e-02f, 4.18390334e-02f, -9.13277790e-02f, -9.50067267e-02f, 1.01919442e-01f, -9.21230093e-02f, 5.46299666e-02f, 3.52603979e-02f, -5.47588877e-02f,
  -2.13047415e-01f, 3.64615351e-01f, 4.63770553e-02f, -2.55787652e-02f, -2.25306123e-01f, -4.74879034e-02f, 7.16627464e-02f, -1.55328074e-02f, -2.07895860e-01f, -1.28088430e-01f,
  -1.55709106e-02f, 3.87811698e-02f, -5.08180745e-02f, -1.21872397e-02f, 5.50657213e-02f, 3.98748778e-02f, 7.79876672e-03f, 1.00796565e-01f, -8.79274458e-02f, -1.46282345e-01f,
  -1.48480773e-01f, 7.07700923e-02f, 2.00801626e-01f, 1.90893367e-01f, 5.33875749e-02f, 2.65286446e-01f, 1.62919089e-02f, -8.98006186e-02f, 1.67536438e-01f, -5.53772040e-02f,
  -8.68667781e-01f, 3.00156891e-01f, -1.41013816e-01f, -3.37906033e-01f, 2.43955076e-01f, 3.07750106e-01f, 5.48800886e-01f, 2.50864565e-01f, -1.30474478e-01f, 9.93797779e-02f,
  3.96443829e-02f, -1.41881824e-01f, -1.65801868e-02f, 1.63144723e-01f, 2.23985195e-01f, 4.24728394e-01f, 4.16082382e-01f, -1.49459347e-01f, -1.98552400e-01f, 2.17591114e-02f,
  3.43805365e-02f, -2.33241484e-01f, -5.36148250e-01f, -2.00567067e-01f, -1.91629261e-01f, -1.13172121e-01f, -3.73965390e-02f, -8.49026218e-02f, 2.08336309e-01f, 7.22736269e-02f,
  -1.53220981e-01f, -9.90113020e-02f, 8.59122723e-02f, -2.50990875e-02f, -6.26092479e-02f, -1.65713206e-01f, -7.56612718e-02f, -1.51674196e-01f, -7.05917850e-02f, 1.27181429e-02f,
  -1.19049311e-01f, 1.24602057e-02f, -8.35576952e-02f, -6.21550009e-02f, -1.47575989e-01f, -7.94843286e-02f, -3.02798878e-02f, -5.51668219e-02f, 2.11645171e-01f, 6.10421970e-02f,
  2.12786168e-01f, 3.49208452e-02f, -4.10422832e-02f, 2.45921388e-01f, 1.62563518e-01f, -8.18570843e-04f, -5.93970977e-02f, -4.37183604e-02f, 1.79331955e-02f, -1.89731404e-01f,
  6.47753552e-02f, -5.04312329e-02f, 6.45859241e-02f, 2.25837324e-02f, -1.48400173e-01f, -3.07699759e-02f, -4.77648759e-03f, -2.99542174e-02f, 4.50414680e-02f, -1.57195151e-01f,
  9.60494354e-02f, 1.95092157e-01f, 5.32226972e-02f, -1.08673973e-02f, -1.18592702e-01f, -6.92040994e-05f, 8.58928412e-02f, -1.38686402e-02f, 5.48805110e-02f, 3.65586579e-02f,
  -6.62762821e-02f, 6.49820864e-02f, -8.22994560e-02f, -2.24461015e-02f, 7.67093301e-02f, -4.31421064e-02f, -3.96648124e-02f, -5.24404272e-03f, -3.59854586e-02f, 8.12762883e-03f,
  -1.97149694e-01f, 2.35810086e-01f, -8.60813111e-02f, -1.40775470e-02f, -4.41521481e-02f, -6.43142611e-02f, -4.83052954e-02f, -3.30563039e-02f, -5.98408096e-02f, 6.66666478e-02f,
  3.85667831e-02f, -4.81297001e-02f, -8.32049176e-02f, -4.98318970e-02f, -1.53383866e-01f, -1.22468345e-01f, 4.11400981e-02f, 1.39269279e-02f, 1.51707515e-01f, 3.61910202e-02f,
  -2.54249871e-02f, 4.87423129e-02f, 9.99658462e-03f, 1.74213558e-01f, 1.78743795e-01f, -9.53825712e-02f, -4.00092006e-02f, -1.31400004e-01f, 7.23531544e-02f, -2.21859902e-01f,
  -3.59198719e-01f, -4.17272180e-01f, -7.77098387e-02f, -1.01723984e-01f, 8.20768252e-02f, 6.42217621e-02f, -3.74112278e-01f, -9.45334211e-02f, 1.94970831e-01f, -3.39783311e-01f,
  9.07647423e-03f, 3.47265482e-01f, -1.29236072e-01f, 2.87291547e-03f, -5.70213348e-02f, -3.93337786e-01f, -1.97434098e-01f, -1.40122361e-02f, 4.28276360e-01f, 3.30396682e-01f,
  2.65491933e-01f, 1.09946355e-01f, 1.20983310e-01f, 1.95663184e-01f, -1.50466010e-01f, 2.59243138e-02f, -2.00926047e-02f, 6.29342394e-03f, 1.74718983e-02f, -3.01511616e-01f,
  -5.38913123e-02f, -1.52855247e-01f, 1.59869000e-01f, -6.15535937e-02f, 1.11643719e-02f, -2.46912286e-01f, -2.18903735e-01f, 3.62403225e-03f, 2.95986123e-02f, -1.84647888e-02f,
  -1.24187194e-01f, 9.52081606e-02f, -5.82974143e-02f, 8.03948045e-02f, 1.06702447e-01f, -4.91613299e-02f, 5.56263737e-02f, 9.04840305e-02f, -9.09133162e-03f, -6.88707083e-02f,
  -2.90724244e-02f, 1.67296156e-01f, -9.29710045e-02f, -3.86290327e-02f, -1.96832165e-01f, 9.94224921e-02f, -2.77577322e-02f, -1.08658426e-01f, 6.66368613e-03f, -4.25726682e-01f,
  1.58141479e-01f, 6.05755374e-02f, 1.28738489e-02f, -1.18165508e-01f, 3.40892114e-02f, 2.29327809e-02f, -5.88563979e-02f, 6.82439357e-02f, 4.93388660e-02f, -6.96973205e-02f,
  5.81808649e-02f, 8.63560364e-02f, 4.28091213e-02f, -7.00478330e-02f, 2.91705430e-02f, 5.05681224e-02f, 1.23519741e-01f, -3.80602628e-02f, 4.02066410e-02f, 5.01508452e-02f,
  5.99381514e-02f, -6.59141913e-02f, 1.90683119e-02f, 3.12916636e-02f, -6.89863693e-03f, -1.98333874e-01f, 9.31703970e-02f, 3.18267383e-02f, -1.43662989e-01f, 4.64676060e-02f,
  -4.63232175e-02f, 2.99975336e-01f, -4.24771570e-02f, -1.99873913e-02f, 7.73066655e-02f, 5.21922186e-02f, -3.79362074e-03f, 4.06110846e-03f, 5.63411973e-02f, -1.34474590e-01f,
  1.82502717e-02f, -4.72320542e-02f, -8.63165036e-02f, -2.07780097e-02f, -7.75837228e-02f, -1.01723544e-01f, -6.13150075e-02f, -1.61303431e-02f, 5.63653223e-02f, 7.35289529e-02f,
  -1.64949447e-01f, -4.91009690e-02f, -2.40446180e-01f, -3.28960031e-01f, -8.99355039e-02f, -5.99449500e-02f, -1.76284835e-01f, -6.55142497e-03f, -2.18868703e-01f, -5.37624419e-01f,
  -1.04130596e-01f, -2.35397946e-02f, -3.98438960e-01f, -2.09386542e-01f, -2.33192101e-01f, -1.64219007e-01f, -4.72664863e-01f, -5.27079776e-02f, 5.60416169e-02f, -3.21706325e-01f,
  -8.93578082e-02f, 2.19643682e-01f, 1.34927899e-01f, 1.71681821e-01f, 1.59061551e-01f, -1.70760602e-01f, -1.51434869e-01f, -5.08183502e-02f, 1.25335991e-01f, -1.37483075e-01f,
  -8.79352689e-02f, -1.77963525e-02f, 9.15863514e-02f, 6.75625578e-02f, -4.81121317e-02f, 3.07353377e-01f, -2.45021954e-01f, -1.83268655e-02f, -1.05806209e-01f, -2.61766285e-01f,
  1.14583246e-01f, -9.90141090e-03f, 2.52070162e-03f, 1.31310925e-01f, 5.78464083e-02f, -7.70863742e-02f, -1.41552567e-01f, -1.05434611e-01f, 6.13990501e-02f, 2.01399297e-01f,
  -3.66701111e-02f, 3.42991948e-02f, -2.13133320e-02f, 1.89767890e-02f, -8.81782398e-02f, -1.21462047e-01f, -9.86243635e-02f, -5.15074320e-02f, 6.74645677e-02f, 6.95046503e-03f,
  -2.36084014e-01f, -2.83090651e-01f, -2.39316791e-01f, 7.64688328e-02f, -9.25137699e-02f, -5.83828650e-02f, -1.88163761e-02f, -1.25128021e-02f, 2.87545305e-02f, -2.10981846e-01f,
  -1.34523898e-01f, -1.41338140e-01f, -8.18277150e-02f, -1.01203650e-01f, -1.29370674e-01f, -8.03964362e-02f, 2.35801563e-02f, -4.90832813e-02f, -1.36840399e-02f, 1.54558077e-01f,
  9.15493593e-02f, -1.08383596e-01f, 1.00947551e-01f, -8.36236775e-02f, -3.90229560e-02f, -7.56106228e-02f, -1.09719746e-01f, -2.33241022e-02f, 9.48772430e-02f, 6.20227680e-02f,
  3.40896249e-02f, -8.19966849e-03f, -7.61195794e-02f, 1.88676730e-01f, -6.65396638e-03f, -7.23221451e-02f, -1.73469055e-02f, 1.49416592e-04f, 6.20062649e-02f, 1.32765695e-01f,
  3.97832602e-01f, 1.57148875e-02f, 7.90853351e-02f, 2.30222661e-02f, 5.27262948e-02f, -1.42071426e-01f, -1.32864416e-01f, 9.97060016e-02f, 8.53182226e-02f, 3.37983482e-02f,
  -9.69451442e-02f, 1.20438798e-03f, -4.72540706e-02f, -2.37932757e-01f, -1.01849273e-01f, -1.07213475e-01f, 4.99978568e-03f, 6.98963404e-02f, -2.57993620e-02f, -4.23667468e-02f,
  -4.35699895e-02f, -1.39054641e-01f, 8.68012458e-02f, 2.61916518e-01f, 5.73549159e-02f, 1.38064593e-01f, 2.11778224e-01f, -4.40344401e-02f, 2.22523540e-01f, 3.03760711e-02f,
  3.18461567e-01f, -6.89985454e-02f, -2.90288813e-02f, -1.57666773e-01f, -1.93337694e-01f, 9.13369842e-03f, -7.80116618e-02f, -1.36263937e-01f, -1.36752263e-01f, -4.68239486e-02f,
  -1.28128201e-01f, 6.36568060e-03f, 9.29766968e-02f, 5.29065132e-02f, 8.54203403e-02f, -1.25882477e-01f, -1.98500201e-01f, 1.75369769e-01f, 1.91081330e-01f, 4.67054844e-02f,
  -1.86426312e-01f, -1.81051537e-01f, -2.33124599e-01f, -1.17948584e-01f, -1.80197403e-01f, 7.01039284e-02f, -3.30788553e-01f, -2.48043478e-01f, -1.74646303e-01f, -3.20802361e-01f,
  6.28811359e-01f, 4.09808382e-02f, 1.18598163e-01f, 7.55385682e-02f, -8.88137426e-03f, 6.70747310e-02f, 1.84780031e-01f, 1.22146301e-01f, 1.30766749e-01f, 1.28358930e-01f,
  1.65404985e-03f, -2.04902086e-02f, 8.92131962e-03f, -6.70400262e-02f, -6.63699210e-02f, 9.88262799e-03f, -4.55776304e-02f, -2.29890794e-02f, 8.65596458e-02f, 8.43680650e-02f,
  4.54808995e-02f, 7.13256076e-02f, 6.11517988e-02f, 7.45048299e-02f, 1.65414391e-03f, 1.08850606e-01f, 7.31886178e-02f, 2.53682286e-02f, 1.01710252e-01f, -3.67470942e-02f,
  -2.25316063e-01f, 9.36684310e-02f, -8.81597400e-02f, -1.03220604e-01f, -3.21809947e-02f, 4.31428067e-02f, 8.26876312e-02f, 5.06251007e-02f, -3.85607891e-02f, -1.65130123e-01f,
  -5.14748804e-02f, -1.38943985e-01f, 8.06543827e-02f, -1.06463395e-01f, -4.76712957e-02f, -4.71898653e-02f, 4.54682186e-02f, 1.88097388e-01f, 4.55651134e-02f, -8.65918547e-02f,
  4.70163263e-02f, 5.25327809e-02f, -9.31875035e-02f, -6.32834807e-02f, -8.56616870e-02f, 4.00074199e-02f, 1.32002970e-02f, -4.82682288e-02f, -1.10740706e-01f, -5.99423200e-02f,
  3.03445429e-01f, 1.04699999e-01f, 1.73246682e-01f, 3.43718305e-02f, 3.63769010e-02f, 5.14409803e-02f, 1.00035340e-01f, -2.74332054e-02f, 2.01141953e-01f, 8.01694989e-02f,
  1.47706032e-01f, 7.04475641e-02f, -7.00943545e-02f, -4.96789906e-03f, 3.84330042e-02f, 3.33356783e-02f, 3.26200835e-02f, 5.71284071e-02f, 1.14826679e-01f, 1.40367344e-01f,
  -7.06252679e-02f, -4.32412373e-03f, 2.80236363e-01f, 1.77311614e-01f, 6.28153384e-02f, 1.49931088e-01f, 1.11674249e-01f, 1.00201339e-01f, 1.15842946e-01f, -5.30003645e-02f,
  -4.22758728e-01f, -4.60109890e-01f, 2.52424419e-01f, -8.53366479e-02f, 1.53036729e-01f, 1.82983741e-01f, 2.70583451e-01f, -4.81630266e-02f, -2.25563213e-01f, -2.65529789e-02f,
  -2.20008999e-01f, -9.86153334e-02f, -1.42320931e-01f, -1.35658741e-01f, -1.48750078e-02f, 1.93134397e-01f, 2.60705143e-01f, 2.08180249e-01f, 3.08406889e-01f, 1.81397334e-01f,
  1.26473129e-01f, -1.64282136e-02f, -2.10244775e-01f, -2.43169926e-02f, 8.57041031e-03f, 6.92306235e-02f, 2.30154395e-02f, -9.20491740e-02f, -1.91739693e-01f, -8.47001374e-02f,
  3.33716661e-01f, -2.75828660e-01f, 3.88873145e-02f, -3.40615988e-01f, -5.20710386e-02f, -9.08243507e-02f, 1.44639751e-03f, -2.60057747e-02f, -4.47528474e-02f, 1.14437990e-01f,
  -3.15732546e-02f, -1.15906253e-01f, 6.03933297e-02f, -1.99173447e-02f, 1.67140029e-02f, -6.13063399e-04f, -7.89732933e-02f, -2.99171340e-02f, -6.06075637e-02f, 5.90635911e-02f,
  -6.02357052e-02f, -3.11048068e-02f, 1.26188621e-01f, 4.48301435e-02f, -3.27073485e-02f, 2.50875764e-02f, -3.07717244e-03f, -1.01158516e-02f, -3.82604934e-02f, -4.38465849e-02f,
  1.53000923e-02f, 1.53084442e-01f, 6.47548884e-02f, -1.70458201e-02f, -2.94133686e-02f, 8.29603896e-03f, 5.72272427e-02f, 5.52188940e-02f, 7.15490803e-02f, -1.82684977e-02f,
  5.21856302e-04f, 1.42197564e-01f, -2.50878055e-02f, -2.35679299e-02f, 9.96270776e-02f, -2.10847948e-02f, -2.55313702e-02f, 9.10210516e-03f, -1.08801723e-01f, 1.11339157e-02f,
  -1.00650042e-01f, 1.40220402e-02f, -4.10778560e-02f, -3.87960933e-02f, -3.82989869e-02f, -8.97758678e-02f, -4.89144176e-02f, -7.62120038e-02f, -3.62866558e-02f, 2.97926436e-03f,
  1.57419264e-01f, -1.37528092e-01f, 6.98976144e-02f, -8.77411738e-02f, -1.66435000e-02f, -1.97243631e-01f, -2.75061317e-02f, -5.62808625e-02f, -4.81605940e-02f, 8.01868439e-02f,
  -6.45770505e-02f, 7.96741918e-02f, 3.18273231e-02f, -2.30259728e-02f, 1.11376308e-01f, 9.63848922e-03f, -1.26837507e-01f, 1.26992121e-01f, -1.03494592e-01f, -3.34930271e-02f,
  -1.24712445e-01f, 8.67444649e-02f, 1.04725249e-01f, 7.36746937e-02f, 9.16391462e-02f, 1.19559683e-01f, 2.54596472e-01f, 2.01757252e-02f, 3.71466810e-03f, 1.68298051e-01f,
  -2.68164515e-01f, -8.93901587e-02f, -4.42842633e-01f, -5.92593476e-02f, 2.08713725e-01f, 6.70736805e-02f, 2.04869360e-01f, -6.59709200e-02f, 1.03225922e-02f, -4.34605964e-02f,
  -7.05883140e-03f, 3.32626961e-02f, 1.38373554e-01f, 2.86148816e-01f, 1.62231922e-01f, 1.51687637e-01f, 2.37513512e-01f, 1.15046337e-01f, 1.21389911e-01f, 1.93201333e-01f,
  3.42034012e-01f, -8.98464024e-02f, -2.53467590e-01f, 8.22575390e-02f, 2.36556992e-01f, 4.80524898e-02f, -9.47339162e-02f, 7.53477141e-02f, 8.41025189e-02f, 4.19055045e-01f,
  -2.23300114e-01f, -2.49539301e-01f, 9.17616189e-02f, -6.53290823e-02f, 2.13189851e-02f, 1.35949567e-01f, 8.38402659e-02f, -1.28867058e-02f, -5.64569719e-02f, 3.42127308e-02f,
  1.26484260e-01f, 9.21121240e-02f, 1.01271749e-01f, -2.36598775e-02f, -9.46563929e-02f, -1.60462916e-01f, -6.27907366e-02f, -1.13056108e-01f, -9.08639207e-02f, 1.52346846e-02f,
  3.37048143e-01f, -1.42017715e-02f, -2.82372832e-01f, 2.38468554e-02f, 5.06759398e-02f, -4.70635481e-02f, -1.66775361e-01f, -2.76077390e-02f, -2.34935105e-01f, 6.61201403e-02f,
  -1.48665324e-01f, 7.84302428e-02f, 3.55598181e-02f, 1.51149079e-01f, 1.36290282e-01f, 1.47555485e-01f, 1.73439980e-01f, 1.87064782e-02f, 7.18248039e-02f, 2.91485954e-02f,
  8.21164921e-02f, -6.68578222e-02f, 5.42851463e-02f, -1.02804095e-01f, -2.43923534e-02f, 3.48655134e-02f, 2.27272898e-01f, 9.34007615e-02f, -1.56320271e-03f, -9.92912278e-02f,
  -7.98166320e-02f, 6.15511574e-02f, 3.90529213e-03f, 3.26275557e-01f, -1.06021866e-01f, -2.44335961e-02f, 5.02920486e-02f, -1.31219402e-01f, -6.64227903e-02f, 5.36848418e-02f,
  -3.82693887e-01f, -1.43366754e-01f, 1.33644253e-01f, -6.21263050e-02f, -3.86161432e-02f, -1.37418643e-01f, -2.11040244e-01f, -1.02118686e-01f, -1.54662341e-01f, -5.94902784e-02f,
  -1.78688988e-01f, -3.14427018e-02f, -1.18738875e-01f, -1.06554553e-02f, 1.44299464e-02f, -1.53875604e-01f, -4.55527082e-02f, 1.23503752e-01f, 9.09076333e-02f, -7.85291791e-02f,
  3.12947743e-02f, -6.25857115e-02f, -1.03820555e-01f, 2.25113668e-02f, 2.39559282e-02f, -4.32258435e-02f, -1.93688095e-01f, -1.52007028e-01f, -1.49580941e-01f, -1.39584184e-01f,
  -4.77487147e-01f, -2.21900776e-01f, -1.48601562e-01f, 8.58868361e-02f, 2.37282515e-01f, -3.43525037e-02f, -5.67759037e-01f, -5.46446219e-02f, 2.15367630e-01f, -3.41299772e-01f,
  5.30222356e-02f, 1.86749250e-01f, -1.37352824e-01f, -1.02957107e-01f, -4.96877283e-01f, -6.20642304e-01f, -4.58495557e-01f, -3.50436866e-01f, -1.03844479e-01f, 7.66335651e-02f,
  1.60819784e-01f, 1.19920531e-02f, -1.27571949e-03f, 6.12135753e-02f, -4.02434431e-02f, 1.76841468e-01f, -1.52628943e-01f, 8.05028826e-02f, -2.09545456e-02f, -2.69571513e-01f,
  -2.43221760e-01f, 1.29225761e-01f, 2.09034383e-01f, -3.19104567e-02f, 4.60335389e-02f, 8.49301293e-02f, -1.29460972e-02f, -1.86665934e-02f, 1.27892733e-01f, -1.03785172e-01f,
  7.38696977e-02f, 1.16008207e-01f, 5.09560034e-02f, 4.51232865e-02f, 2.47217109e-03f, -1.78227574e-01f, -7.25211129e-02f, -1.05714336e-01f, -5.39121032e-02f, 2.76124626e-02f,
  7.11193820e-03f, -1.18870273e-01f, -1.76954299e-01f, -1.09013520e-01f, -1.38180330e-02f, 1.43025011e-01f, 6.25270456e-02f, 1.88204467e-01f, 4.29340862e-02f, 3.13233747e-03f,
  -1.60319552e-01f, -1.80757642e-02f, 8.42471197e-02f, 1.34586617e-01f, 2.00384390e-02f, 3.04005034e-02f, -1.43411653e-02f, -1.20371953e-01f, 1.03910007e-01f, 1.97829641e-02f,
  1.69306528e-02f, -7.16650411e-02f, -6.07719310e-02f, -1.49328262e-01f, -5.66748381e-02f, -9.91048589e-02f, -7.52687082e-02f, -1.36360839e-01f, -2.96847746e-02f, 1.61677934e-02f,
  -7.88233429e-02f, 8.63885880e-02f, 3.59434858e-02f, -4.52969875e-03f, -7.85913914e-02f, -5.20138144e-02f, -4.86674573e-04f, -2.82114986e-02f, -8.01153034e-02f, -7.23653883e-02f,
  -7.29010031e-02f, -4.88647930e-02f, -1.52733833e-01f, -2.52410304e-02f, 1.53585654e-02f, 4.55612764e-02f, 6.69717044e-02f, -4.66761691e-03f, 2.11575013e-02f, -1.13495909e-01f,
  5.84247708e-02f, -1.59329444e-01f, -1.54778585e-01f, 7.91991279e-02f, 6.69301301e-02f, 1.15100779e-01f, -1.09066673e-01f, -1.72450468e-01f, 9.85500515e-02f, 1.28559262e-01f,
  -1.96708348e-02f, -2.09979147e-01f, -1.30052209e-01f, -1.16132140e-01f, 9.08164158e-02f, -1.12132281e-01f, -1.12476006e-01f, 1.13396168e-01f, -2.32049540e-01f, -3.81859094e-01f,
  3.50039840e-01f, 9.63738412e-02f, 2.91076213e-01f, 3.86171699e-01f, 4.53538418e-01f, 4.21212137e-01f, 3.91216129e-01f, 2.57792264e-01f, 2.19496623e-01f, 9.92152616e-02f,
  2.08191186e-01f, -1.35517698e-02f, 4.65068668e-02f, 7.30816200e-02f, 1.88723207e-01f, 1.37336805e-01f, 1.68211192e-01f, 7.33443052e-02f, 9.98964459e-02f, 1.57174766e-01f,
  5.04340604e-02f, -5.56598278e-03f, -7.31367618e-02f, 4.65347841e-02f, 8.64236876e-02f, 5.57812257e-03f, 9.76977497e-02f, 8.32876265e-02f, 1.35749519e-01f, -3.07123736e-02f,
  1.21151768e-01f, 1.36072785e-01f, -8.31741691e-02f, -1.71427563e-01f, -1.04845464e-01f, -2.33582854e-01f, -4.88545634e-02f, -6.66042119e-02f, -1.19529910e-01f, -8.40820894e-02f,
  1.20786307e-02f, -7.01236278e-02f, -3.15161608e-02f, -1.01093560e-01f, -1.29084498e-01f, -1.16269626e-01f, -5.35586029e-02f, 1.45022735e-01f, 1.75265387e-01f, 4.17755246e-02f,
  3.38596515e-02f, 8.61580670e-02f, 6.11188561e-02f, 1.36036724e-01f, 7.29434118e-02f, -1.08971039e-03f, 2.58943848e-02f, -3.37623805e-02f, 9.58510637e-02f, -1.13886207e-01f,
  1.30324051e-01f, 2.88217533e-02f, 1.64627489e-02f, -1.29519459e-02f, 8.62618908e-02f, 1.34525085e-02f, 4.83911857e-02f, 1.22845218e-01f, 1.24047615e-01f, -1.29557699e-01f,
  -1.59101076e-02f, 1.38083965e-01f, 9.86052752e-02f, 6.28161654e-02f, -2.85440292e-02f, -5.79405911e-02f, -2.98271906e-02f, 6.32320568e-02f, 1.16608590e-02f, -1.00723863e-01f,
  6.03989474e-02f, 8.14869851e-02f, -1.30767636e-02f, 2.52588540e-02f, -8.42433572e-02f, 8.69827345e-02f, -5.74612506e-02f, -1.44930273e-01f, -4.25177962e-02f, -4.08984162e-02f,
  3.30822393e-02f, 1.39166847e-01f, 5.18641621e-02f, -2.92299204e-02f, -5.67141101e-02f, -1.46332145e-01f, 5.78010306e-02f, 5.35571873e-02f, 1.62864253e-02f, 2.91707851e-02f,
  -5.74545301e-02f, -5.66096120e-02f, 3.88283166e-03f, -1.19673438e-01f, -1.38527840e-01f, -6.42272234e-02f, -3.33540924e-02f, 1.36724249e-01f, 1.15338415e-01f, -1.37344133e-02f,
  3.36140804e-02f, 1.61818638e-02f, 1.15241259e-01f, 1.20706491e-01f, -4.46731672e-02f, -4.54147952e-03f, -2.00834032e-02f, -4.47260253e-02f, 7.94907808e-02f, -8.89727026e-02f,
  2.02926800e-01f, -2.99397022e-01f, -5.49872279e-01f, -3.37814838e-01f, -3.38434339e-01f, -9.16406363e-02f, -1.51335970e-01f, 1.93001151e-01f, 8.18399130e-05f, -4.52675849e-01f,
  -9.23970044e-02f, 2.18821272e-01f, -4.10881313e-03f, 1.31452501e-01f, 8.09433162e-02f, -4.31444436e-01f, -4.77509141e-01f, -1.53393045e-01f, 4.21619773e-01f, 2.67873555e-01f,
  3.96645889e-02f, -1.58764925e-02f, 2.81920098e-02f, -1.71910003e-02f, -3.08699012e-01f, -1.85497597e-01f, -5.18959761e-01f, -1.27238572e-01f, -1.31684154e-01f, -5.87086201e-01f,
  -4.67103124e-01f, 5.40895984e-02f, 3.61658707e-02f, 1.22914881e-01f, -9.86033231e-02f, 1.41903251e-01f, -4.11978923e-02f, -4.82230000e-02f, -3.75396498e-02f, -8.65456369e-03f,
  7.87900388e-02f, 4.39005718e-03f, 4.23847772e-02f, 4.98771369e-02f, -1.33475503e-02f, 5.34116887e-02f, 5.24776764e-02f, 1.66402444e-01f, 1.35799563e-02f, -5.43132015e-02f,
  9.92400572e-03f, 9.17337611e-02f, 1.62166767e-02f, 1.09442145e-01f, 2.24497423e-01f, 3.18850987e-02f, 5.69708385e-02f, 7.31312484e-02f, 1.42709566e-02f, -1.41276047e-01f,
  5.51543478e-03f, -5.42284399e-02f, -1.57168843e-02f, 4.15852033e-02f, 1.37497991e-01f, -4.68148515e-02f, -3.47152948e-02f, -2.33138744e-02f, 9.75563154e-02f, 4.46771421e-02f,
  -1.67705975e-02f, -2.46005896e-02f, 9.94750708e-02f, -5.96742593e-02f, -1.51511654e-01f, 3.09326053e-02f, 2.82501560e-02f, -8.62347484e-02f, 1.05314860e-02f, 3.45743671e-02f,
  1.46855459e-01f, 1.02987081e-01f, -2.39326060e-02f, 8.99755731e-02f, -6.98768487e-03f, -1.70570929e-02f, -7.12485760e-02f, 7.30631873e-02f, -1.04480740e-02f, -1.28364302e-02f,
  1.26869685e-03f, -8.85309726e-02f, -1.70356721e-01f, 2.35275365e-02f, -5.16069448e-03f, -8.63344520e-02f, -1.87780216e-01f, 9.27461535e-02f, 9.13115963e-03f, 5.12378775e-02f,
  3.35815251e-02f, 1.39297009e-01f, 2.26996467e-02f, -3.70823853e-02f, 4.66134883e-02f, 8.39375183e-02f, -2.39019608e-03f, 1.05062276e-01f, 4.05022129e-02f, -1.20370410e-01f,
  2.77567357e-02f, 1.38302401e-01f, 1.90240070e-01f, 3.47325690e-02f, 1.58698961e-01f, 4.10402603e-02f, 6.79105818e-02f, -6.55916007e-03f, 1.05641536e-01f, -8.67814422e-02f,
  -1.07741964e+00f, 9.45672840e-02f, -1.91476882e-01f, -3.06412339e-01f, -1.97298914e-01f, -1.59864202e-01f, -6.29500821e-02f, -3.20024579e-03f, -2.02096492e-01f, 1.31578045e-03f,
  2.26911917e-01f, 1.48690015e-01f, -1.34322327e-02f, 3.02630942e-02f, -2.30807066e-01f, -1.95458680e-01f, -3.69315147e-01f, -6.17759645e-01f, -2.92144448e-01f, 1.56778142e-01f,
  -3.63419279e-02f, -5.04034162e-01f, -5.62340081e-01f, -1.59148172e-01f, 4.78016399e-02f, 9.12519097e-02f, -3.02263722e-02f, -1.50454849e-01f, -3.63483168e-02f, -2.35307634e-01f,
  2.73460627e-01f, -7.06323460e-02f, -6.80990964e-02f, -2.25831062e-01f, -9.84035730e-02f, -1.62786826e-01f, -7.44500831e-02f, -1.14407819e-02f, 1.53160775e-02f, 9.25649479e-02f,
  -1.69468030e-01f, -7.20211118e-02f, -1.53636634e-01f, 1.26060389e-04f, -2.32688952e-02f, 8.67252201e-02f, 3.84335592e-02f, -5.49524650e-03f, -9.63597819e-02f, 1.79998487e-01f,
  2.32317820e-02f, -6.32716566e-02f, 5.17437458e-02f, 1.03259586e-01f, 6.28356859e-02f, -1.05018869e-01f, 3.30528826e-01f, 5.45869134e-02f, 1.14245526e-01f, 2.77851403e-01f,
  7.99731389e-02f, 1.82207495e-01f, 6.52646124e-02f, 9.08339694e-02f, 6.14443235e-02f, -1.07834823e-01f, -1.12789841e-02f, 2.40015127e-02f, -9.10241082e-02f, 9.01023304e-05f,
  1.37496637e-02f, -5.88843450e-02f, -1.11885943e-01f, 8.23829398e-02f, 8.82166252e-02f, -8.32825229e-02f, -1.20108746e-01f, 1.28879681e-01f, 6.38987347e-02f, 2.62590195e-03f,
  -7.39740431e-02f, -6.20085653e-03f, 2.09563095e-02f, 1.92770343e-02f, 1.01784216e-02f, 5.08324243e-02f, -6.07530884e-02f, -3.24804615e-03f, -9.46778222e-04f, -1.42126605e-01f,
  1.30854532e-01f, -2.92280287e-01f, -1.48733005e-01f, 6.13947921e-02f, -4.11340147e-02f, 1.10217161e-01f, 8.33604336e-02f, 7.62022063e-02f, -4.59236056e-02f, 4.82952520e-02f,
  2.05593649e-02f, 1.44479424e-01f, 1.93779562e-02f, 1.67987749e-01f, 2.85500102e-02f, 1.11956976e-01f, 8.69706124e-02f, 4.10800464e-02f, -5.80114685e-02f, 1.43552557e-01f,
  3.49753797e-02f, -1.18338525e-01f, -3.64933871e-02f, 1.06807634e-01f, 1.00665808e-01f, -7.37305582e-02f, 2.06368953e-01f, 7.31833801e-02f, 1.92517694e-02f, 2.72086531e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 14)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 14;
const float L0_fan_Bp_bar_data[] = {
  2.16747612e-01f, -2.47977953e-02f, 1.87325567e-01f, 1.84335113e-01f, 1.01282090e-01f, 1.03597581e-01f, 1.14648513e-01f, -1.16331816e-01f, -2.68737208e-02f, -3.82970236e-02f,
  1.34674996e-01f, 2.18925789e-01f, -1.32745221e-01f, 2.70804048e-01f
};

// L1_fan_Wp (Shape: 25 x 64)
const int L1_fan_Wp_rows = 25;
const int L1_fan_Wp_cols = 64;
const float L1_fan_Wp_data[] = {
  -4.63243527e-03f, 7.37076299e-03f, -8.44077915e-02f, 6.08300790e-02f, 5.10506667e-02f, -3.53309629e-03f, 5.26807308e-02f, -1.04342274e-01f, 3.17125246e-02f, 1.21288992e-01f,
  8.95013474e-03f, 5.77193834e-02f, -3.23671773e-02f, -7.13807717e-02f, -5.98286428e-02f, 2.63858237e-03f, 1.04033217e-01f, 1.18789792e-01f, 1.26562089e-01f, 2.83177011e-02f,
  -8.99128690e-02f, -4.60714586e-02f, 5.40454462e-02f, 3.84551808e-02f, 1.97948650e-01f, 5.23100384e-02f, 7.69419000e-02f, 1.30016565e-01f, 4.57686633e-02f, -2.26136252e-01f,
  -1.44874632e-01f, -2.72533838e-02f, 1.46800622e-01f, -8.58804435e-02f, 1.07265323e-01f, -2.68710661e-03f, -2.06748784e-01f, 1.46584734e-02f, 2.93662325e-02f, -9.59055573e-02f,
  -5.48276678e-02f, 2.66622216e-01f, -4.45347764e-02f, 2.26062670e-01f, -1.66012943e-01f, 3.52259278e-02f, -7.11127073e-02f, 1.39853477e-01f, 2.25979045e-01f, -5.41102849e-02f,
  2.16719061e-01f, -3.62953916e-02f, 1.24265470e-01f, 1.12217084e-01f, -2.12327659e-01f, -1.19724253e-03f, -5.62730655e-02f, 1.55815661e-01f, 1.03029190e-02f, 6.32169545e-02f,
  -1.62672833e-01f, 7.70042017e-02f, -3.89253721e-02f, -4.02364314e-01f, -5.43972291e-02f, 4.10536118e-02f, -8.42621624e-02f, -1.69770215e-02f, -3.45912784e-01f, 9.09266397e-02f,
  -7.96657428e-02f, 9.47449133e-02f, 8.13724566e-03f, 1.00150064e-01f, 1.35604471e-01f, -5.38549013e-02f, -5.62595166e-02f, -9.72325951e-02f, 7.86211714e-02f, 3.37682702e-02f,
  1.19237080e-01f, 2.23204955e-01f, -2.14877561e-01f, -5.50435185e-02f, 3.62898968e-02f, 1.22250784e-02f, -2.38261037e-02f, 7.23266676e-02f, 8.54939073e-02f, 2.13322658e-02f,
  -3.67279015e-02f, 1.55824006e-01f, -2.31395531e-02f, -2.63179932e-02f, 1.15810148e-01f, 4.02176939e-02f, 6.33075106e-05f, -6.84486553e-02f, -1.32492539e-02f, 6.62161261e-02f,
  -4.91875149e-02f, 1.64622009e-01f, -4.58451994e-02f, 1.51423872e-01f, -1.28256738e-01f, -1.51191838e-02f, -1.55631840e-01f, -1.60387754e-01f, 2.22821231e-03f, 7.87515491e-02f,
  -9.41176433e-03f, 1.71954319e-01f, -1.98983774e-02f, -1.29354671e-01f, 1.25611037e-01f, 2.71223821e-02f, 1.12411290e-01f, 5.44807315e-02f, 7.79976100e-02f, 3.38521838e-01f,
  -2.02198476e-01f, -1.67614967e-01f, -8.72111320e-02f, -2.25585714e-01f, 2.12218136e-01f, 7.89214596e-02f, 1.67519599e-01f, -7.23223388e-02f, 5.20571545e-02f, 1.93749554e-02f,
  -5.64305298e-02f, -4.30281386e-02f, -2.27860129e-03f, 4.42295372e-02f, -9.70267039e-03f, -4.34919223e-02f, 4.42751050e-02f, 8.84930044e-02f, -7.22824037e-02f, -5.52534163e-02f,
  3.16327773e-02f, 2.79029552e-02f, 4.21410426e-02f, -7.44719931e-04f, 1.61484569e-01f, 7.58907646e-02f, 1.32052556e-01f, -6.47101849e-02f, -7.88003206e-03f, 1.57959327e-01f,
  4.35742848e-02f, 4.92267637e-03f, 1.23326652e-01f, 6.71204478e-02f, 5.04432544e-02f, -2.77151987e-02f, -6.51489794e-02f, 2.66491789e-02f, -3.18256527e-01f, 1.57405641e-02f,
  6.23953156e-02f, 6.08553626e-02f, 3.14987332e-01f, -3.02798785e-02f, -1.36396229e-01f, 4.13168371e-02f, 2.18683466e-01f, 3.13648909e-01f, 1.10130504e-01f, -2.69094780e-02f,
  1.74684137e-01f, 2.22532451e-01f, 1.84485734e-01f, -7.06959376e-03f, 1.40361709e-03f, -1.79671928e-01f, -1.80464879e-01f, -2.37934124e-02f, -2.97744215e-01f, 8.27937201e-02f,
  1.52430505e-01f, 2.52141476e-01f, -5.27235746e-01f, -7.39994794e-02f, 2.60980666e-01f, -6.75682584e-03f, 2.66712040e-01f, -2.14214399e-02f, 8.98314491e-02f, -7.66454041e-02f,
  1.20086446e-01f, -5.07201441e-02f, -2.26961717e-01f, 8.84778276e-02f, 7.42627680e-02f, -2.16562971e-01f, -2.86496361e-03f, -4.64123003e-02f, -1.41601503e-01f, -7.65010118e-02f,
  -7.07584396e-02f, -1.19215570e-01f, 1.26919746e-01f, -2.21195996e-01f, -1.15176715e-01f, 3.13113932e-03f, 7.08335489e-02f, -1.79767609e-01f, -9.57068335e-03f, 2.45316714e-01f,
  -8.05060416e-02f, -2.07139663e-02f, 1.12856634e-01f, 6.43442199e-02f, -1.33934632e-01f, -8.33296254e-02f, -3.72534804e-02f, -2.13072430e-02f, 1.10304188e-02f, 7.67427459e-02f,
  -3.66401998e-03f, 1.88435733e-01f, -1.48805261e-01f, -3.37782614e-02f, -9.22093689e-02f, -1.36472121e-01f, -1.10284552e-01f, -5.90496138e-02f, -7.14150146e-02f, 2.37193406e-02f,
  -3.09650660e-01f, 3.53059024e-02f, -1.32676452e-01f, 3.29826385e-01f, -2.52952158e-01f, 7.08073825e-02f, -8.96165147e-04f, -9.30145034e-04f, -1.79156572e-01f, 7.88503811e-02f,
  -1.02835163e-01f, -1.30965635e-01f, 4.60957997e-02f, -8.65086988e-02f, -1.05387516e-01f, 1.36362482e-02f, 3.58647890e-02f, 2.78003603e-01f, 1.47285804e-01f, 1.75541103e-01f,
  -2.86772698e-01f, -2.40422487e-02f, 8.65601599e-02f, -1.49650246e-01f, 4.36028779e-01f, -2.53743380e-01f, -9.35326666e-02f, 1.93267595e-02f, 1.01149650e-02f, -3.16966176e-02f,
  7.66712129e-02f, -1.65493321e-02f, 2.16552898e-01f, 7.03150332e-02f, -1.08104877e-01f, 1.79958865e-02f, -3.77547555e-02f, 1.53095633e-01f, 3.07441056e-02f, 1.03081614e-02f,
  -5.74064965e-04f, -1.27927616e-01f, -7.83875808e-02f, -1.31749570e-01f, 9.10885409e-02f, 8.85587111e-02f, -1.26849562e-01f, -1.69428408e-01f, -2.16977461e-03f, -4.69752075e-03f,
  -1.52677938e-01f, 2.39847273e-01f, 7.05782920e-02f, -1.15531728e-01f, 1.55562535e-01f, -7.00734407e-02f, 1.56942979e-01f, 9.61894542e-02f, 8.24965164e-03f, -2.17073206e-02f,
  1.95103455e-02f, -2.84099095e-02f, -2.40155423e-04f, -2.17362237e-03f, -2.93553807e-02f, -3.15887816e-02f, 5.64756058e-02f, 8.36607665e-02f, -2.27590755e-01f, 1.78980201e-01f,
  -1.37041509e-01f, -1.20017216e-01f, -8.92215148e-02f, -8.36038142e-02f, 1.18743069e-01f, 8.88539776e-02f, 3.32708471e-02f, 3.16614509e-02f, 3.04380502e-03f, 7.06020519e-02f,
  4.82453369e-02f, -3.10623795e-01f, 1.90060094e-01f, 1.67430624e-01f, 6.85908794e-02f, 3.33737165e-01f, -1.48896948e-01f, -5.06891385e-02f, -1.45226732e-01f, -1.16367929e-01f,
  -7.20144659e-02f, -6.94272146e-02f, 7.84607604e-02f, -5.74830584e-02f, -1.56721726e-01f, -1.03051014e-01f, -4.25007045e-02f, -5.59037402e-02f, -1.95195861e-02f, 7.98524767e-02f,
  4.80865426e-02f, 6.21532612e-02f, 2.91124806e-02f, -5.29340580e-02f, -2.11614855e-02f, -4.60974984e-02f, -6.69182613e-02f, -3.24995164e-03f, -1.75042167e-01f, -2.84959041e-02f,
  -7.95547739e-02f, 1.76173523e-01f, -1.25144914e-01f, -2.16058642e-02f, -6.12830520e-02f, -1.35129005e-01f, 7.22236037e-02f, 1.99280083e-01f, -4.57962602e-02f, 9.43009108e-02f,
  -4.22409130e-03f, -8.46606866e-02f, -2.21897033e-03f, -4.59804945e-02f, 2.17734247e-01f, 1.05002001e-02f, -1.37275413e-01f, -8.26693624e-02f, -2.13444874e-01f, -3.11896019e-02f,
  -1.31779745e-01f, -7.89362118e-02f, -7.06814826e-02f, -8.19661021e-02f, -4.32605855e-02f, -5.55607118e-03f, -1.80087075e-01f, 7.53941685e-02f, -3.59036438e-02f, -3.70185487e-02f,
  -2.47026384e-01f, -2.48595066e-02f, -1.86448827e-01f, 1.44490406e-01f, 3.80144179e-01f, 6.76096976e-02f, 3.75809558e-02f, -1.14936247e-01f, -2.52421200e-01f, 1.21074906e-02f,
  -4.78561409e-02f, 2.58450001e-01f, 3.83640528e-01f, -1.47108018e-01f, 2.73026135e-02f, -4.84886542e-02f, 6.89703971e-02f, -9.60801821e-03f, -7.02092648e-02f, 4.08307556e-03f,
  8.53520855e-02f, -2.06151262e-01f, 1.63892373e-01f, 7.97943249e-02f, 2.53731143e-02f, -1.27116784e-01f, -4.89468873e-02f, -6.93959668e-02f, -1.49746627e-01f, 4.69591841e-02f,
  6.48846058e-03f, 5.90002649e-02f, -5.53724915e-02f, -5.93994223e-02f, -1.88553959e-01f, -1.45571634e-01f, 6.94211796e-02f, 2.51138024e-03f, -7.74472728e-02f, -1.11795656e-01f,
  -9.03078169e-02f, 3.02878805e-02f, 2.18017116e-01f, -1.57149240e-01f, 1.47782564e-01f, 2.07921609e-01f, 8.33895057e-03f, 1.25770122e-01f, 1.92564175e-01f, 1.54149562e-01f,
  -1.66461580e-02f, -9.97403562e-02f, 3.50497842e-01f, 2.26520114e-02f, 7.71265179e-02f, -4.03874546e-01f, 3.87778699e-01f, -3.03875595e-01f, 7.52287656e-02f, 6.91362396e-02f,
  7.59670809e-02f, -4.14654501e-02f, 2.96655029e-01f, 1.52488172e-01f, 2.70635426e-01f, 7.70563409e-02f, 3.49768281e-01f, -4.64977354e-01f, 6.81652129e-02f, -2.69084007e-01f,
  -2.09420279e-01f, -9.04264972e-02f, 3.90754230e-02f, -1.52409812e-02f, -1.38119340e-01f, -5.43644018e-02f, -1.46572188e-01f, 1.08449250e-01f, -1.16149321e-01f, 1.61197688e-02f,
  -1.69684276e-01f, -1.18591085e-01f, -2.16152286e-03f, 4.92098043e-03f, 1.22176893e-02f, 3.63578685e-02f, -1.17608450e-01f, -1.12830520e-01f, -6.79013506e-03f, -4.43827286e-02f,
  -2.00571179e-01f, 2.58356705e-02f, 1.81703910e-01f, 1.63984497e-03f, -1.48312733e-01f, -2.01879099e-01f, -5.28054871e-02f, -9.15549397e-02f, -4.25803885e-02f, 7.48570040e-02f,
  -6.05920441e-02f, -1.63662732e-01f, -1.17737673e-01f, -1.98150948e-01f, 3.97579372e-02f, -4.71440777e-02f, -4.86826040e-02f, 5.08877970e-02f, 3.33433121e-01f, -1.21488616e-01f,
  -4.42445511e-03f, -4.02646810e-02f, -2.92696148e-01f, -1.87478393e-01f, 2.98100710e-01f, 1.94104202e-02f, -2.23606855e-01f, -1.96610183e-01f, 1.16395548e-01f, -1.02327384e-01f,
  -1.00857966e-01f, -3.44887823e-01f, -9.01996046e-02f, -1.02653608e-01f, 1.73753068e-01f, -2.28547037e-01f, -1.56547621e-01f, -1.11399919e-01f, -5.24182543e-02f, -4.35460284e-02f,
  5.01624122e-02f, 5.80708031e-03f, 2.97609627e-01f, 1.00430980e-01f, 8.44838321e-02f, -7.02338740e-02f, -3.72610167e-02f, 2.63936430e-01f, 3.71996313e-01f, -1.33442834e-01f,
  -1.83951020e-01f, 3.04762930e-01f, -1.77954435e-02f, 4.96526482e-03f, 6.53576627e-02f, 1.34621128e-01f, -1.00315541e-01f, 2.26037041e-03f, 4.42524478e-02f, 6.61405772e-02f,
  2.32554413e-02f, -2.65359301e-02f, 7.33435676e-02f, 3.89276451e-04f, 2.08424345e-01f, 7.18245432e-02f, -5.56674320e-03f, -2.13306043e-02f, -2.84920540e-02f, 7.49597400e-02f,
  6.82695732e-02f, -2.89010387e-02f, -4.88306172e-02f, -2.18645018e-02f, -8.54350850e-02f, -1.12795532e-01f, 1.85847014e-01f, 1.58107340e-01f, 5.59983328e-02f, 1.58993930e-01f,
  -9.10528898e-02f, 4.85116728e-02f, 1.32117808e-01f, -1.17328301e-01f, -7.08056316e-02f, -3.56694311e-02f, 2.47195080e-01f, 1.22065857e-01f, 4.12489753e-03f, 5.56784794e-02f,
  -1.08107775e-01f, 1.39532939e-01f, 6.00780770e-02f, -1.02484971e-01f, 1.29943967e-01f, -1.50053412e-01f, 7.20616721e-04f, 1.44790396e-01f, -1.52202636e-01f, 1.45705253e-01f,
  -4.03036214e-02f, -1.92050368e-01f, 8.30159895e-03f, -1.40293702e-01f, -2.33815953e-01f, 5.19425087e-02f, -7.92764351e-02f, 8.43614563e-02f, 2.04071105e-01f, -1.77757978e-01f,
  -9.76302251e-02f, -2.39181072e-01f, 1.51950374e-01f, 1.21321477e-01f, 4.91684116e-02f, -1.32493734e-01f, -2.14124069e-01f, 1.12718262e-01f, -1.31328210e-01f, -1.44695371e-01f,
  2.82639246e-02f, -1.93305630e-02f, -4.17374521e-02f, -2.50151008e-03f, 5.64663373e-02f, 1.14187159e-01f, -1.32987782e-01f, 8.97324737e-03f, 9.79384482e-02f, -7.61116147e-02f,
  -3.69827785e-02f, 4.96099554e-02f, -6.36998266e-02f, -1.97628692e-01f, -1.82616580e-02f, -8.33578929e-02f, -3.55898961e-02f, -1.65749472e-02f, 5.06527163e-03f, -2.07710817e-01f,
  -8.43147188e-02f, -7.95079693e-02f, 1.30298659e-01f, -1.11272007e-01f, -2.41571620e-01f, -1.01336785e-01f, 1.38664708e-01f, 6.37650769e-03f, -7.36041972e-03f, -2.56697297e-01f,
  1.10463679e-01f, 3.37525979e-02f, 6.51613399e-02f, 1.27470389e-01f, 1.12903655e-01f, 3.43185361e-03f, -5.87028787e-02f, 7.87988752e-02f, -1.08477533e-01f, -4.76640351e-02f,
  -2.04358816e-01f, -1.76603124e-02f, -2.42916852e-01f, 1.19363122e-01f, -1.42615378e-01f, -5.01927435e-02f, -1.75119177e-01f, -3.91627848e-03f, -3.40720564e-01f, 1.48549035e-01f,
  3.72157425e-01f, 1.35135829e-01f, 1.46030471e-01f, -2.49266420e-02f, 6.19347161e-03f, -3.16229939e-01f, 8.56011659e-02f, -4.50862907e-02f, 3.39324206e-01f, 2.52421528e-01f,
  -2.66216025e-02f, 9.50343721e-03f, -6.19313940e-02f, 7.11027011e-02f, -4.79023875e-04f, -6.26894981e-02f, -1.06523752e-01f, 2.60316068e-03f, 1.33876260e-02f, -5.65485423e-03f,
  6.89683631e-02f, -1.12143070e-01f, -5.36269159e-04f, -1.31621379e-02f, -7.63968900e-02f, 2.29990184e-02f, 3.61553729e-02f, -1.25744222e-02f, 4.05831821e-02f, -4.42392901e-02f,
  -4.16538827e-02f, -7.06766360e-03f, -6.91026598e-02f, 2.13874280e-02f, -4.43531573e-02f, 8.16115215e-02f, 8.36179703e-02f, -1.86305419e-01f, -1.49884420e-02f, -1.68858804e-02f,
  -1.60775129e-02f, 1.81710571e-02f, -7.97951072e-02f, 1.35169834e-01f, -3.00933458e-02f, -1.39317170e-01f, -1.10728599e-01f, -1.79112703e-02f, 3.62103544e-02f, 8.27477276e-02f,
  -9.69715491e-02f, -3.14429961e-02f, 1.63834155e-01f, 2.33185142e-01f, -3.55801694e-02f, -4.66096997e-02f, -2.44940430e-01f, 7.86883906e-02f, 3.02559435e-01f, -9.47690308e-02f,
  3.14180762e-01f, 1.20374635e-01f, -2.09133819e-01f, -1.00103952e-01f, -2.62921780e-01f, -1.08199619e-01f, -6.63594380e-02f, 1.19239181e-01f, -3.50317918e-02f, -1.82392091e-01f,
  -1.73992097e-01f, 1.30515933e-01f, -2.53233522e-01f, -7.21700490e-02f, -1.24648273e-01f, 5.86231006e-03f, 2.19087191e-02f, 9.05280188e-02f, 1.28251329e-01f, -5.88582531e-02f,
  1.40494153e-01f, -2.79789958e-02f, -5.26543427e-03f, 5.31928148e-03f, 4.61383238e-02f, -4.36328846e-04f, 3.00294068e-02f, 1.08767815e-01f, 4.09918744e-03f, 1.65796410e-02f,
  -1.41182646e-01f, -2.95397006e-02f, -4.02809456e-02f, -5.92247443e-03f, -1.40378416e-01f, 1.33058466e-02f, 8.75969231e-02f, 6.28857985e-02f, 2.12640297e-02f, 6.91446140e-02f,
  1.35538325e-01f, -3.13818008e-02f, 5.40774949e-02f, 7.71553740e-02f, 1.95548356e-01f, -1.48787415e-02f, -1.40515361e-02f, -5.45467250e-03f, -3.37354124e-01f, -1.22599795e-01f,
  9.54034105e-02f, -7.23367706e-02f, -5.16160578e-02f, -1.85959086e-01f, -1.94098547e-01f, 2.16699883e-01f, -4.83573884e-01f, -1.13542173e-02f, -2.39640221e-01f, -1.85509250e-01f,
  -1.16916619e-01f, 2.69956857e-01f, 2.61272818e-01f, -1.58077762e-01f, 5.28930545e-01f, -1.22625105e-01f, -1.27706215e-01f, -1.73686460e-01f, 1.67102009e-01f, -1.69266164e-02f,
  -1.90037210e-02f, -3.06898296e-01f, -2.03343555e-01f, 8.42102244e-02f, 6.90271631e-02f, -8.16299394e-03f, -2.74320185e-01f, 2.68919524e-02f, 3.25047486e-02f, 1.19025722e-01f,
  -1.85930151e-02f, 1.73710987e-01f, 2.48084888e-02f, 9.60364491e-02f, 7.05878213e-02f, -1.08638756e-01f, -6.75366223e-02f, 2.43800282e-02f, 1.32360473e-01f, 5.38931862e-02f,
  -1.82981808e-02f, -1.35158196e-01f, -1.23649240e-01f, -6.21555559e-02f, -9.83380526e-02f, -1.64270028e-01f, 1.71541721e-01f, -5.67848934e-03f, -4.02089991e-02f, -1.33242071e-01f,
  2.97248140e-02f, -3.30653228e-02f, -6.01030476e-02f, -4.81426008e-02f, 2.79596802e-02f, -5.31846620e-02f, 2.27247868e-02f, -8.56474880e-03f, 1.39628857e-01f, 4.90740500e-02f,
  -9.29438602e-03f, -9.78446659e-03f, -2.43842185e-01f, -2.55040199e-01f, -1.58302620e-01f, -8.43395069e-02f, 3.15782577e-01f, -3.03216606e-01f, -7.22077042e-02f, -3.46924886e-02f,
  -5.67800738e-02f, 6.99673444e-02f, -1.40898660e-01f, -1.24512322e-01f, -6.12007827e-02f, 2.36714259e-01f, 2.19186068e-01f, -1.46762297e-01f, 1.42773613e-01f, -6.03010831e-03f,
  2.95281619e-01f, -7.46115856e-03f, 1.71000466e-01f, -1.49876446e-01f, -1.23859927e-01f, -9.46556330e-02f, -3.80241200e-02f, 2.94182956e-01f, -1.96892217e-01f, -1.51194319e-01f,
  -2.41666943e-01f, -1.12678474e-02f, 5.83656244e-02f, -7.75266020e-03f, -1.95994861e-02f, 3.50069553e-02f, 8.55267197e-02f, 2.46358901e-01f, -6.51649460e-02f, 3.05374581e-02f,
  1.21470712e-01f, 3.76750305e-02f, 3.34625952e-02f, -3.59426625e-02f, -4.60106991e-02f, -1.63057268e-01f, -1.49363756e-01f, 1.70113206e-01f, 2.59875000e-01f, 4.66134995e-02f,
  2.18210876e-01f, -1.29635677e-01f, 1.81706652e-01f, -2.56589800e-01f, -1.82446148e-02f, -8.35365579e-02f, 1.94704365e-02f, -5.94129832e-03f, -2.87123501e-01f, -1.98648602e-01f,
  2.69559268e-02f, 1.26796335e-01f, -4.15971279e-02f, -8.45684633e-02f, -9.38277245e-02f, 2.86403507e-01f, -6.18654825e-02f, -6.61800504e-02f, -1.84930712e-01f, -5.83347492e-02f,
  2.04466581e-01f, 1.07807256e-01f, 1.34023294e-01f, -2.38661334e-01f, 4.20007557e-01f, 8.32338072e-03f, 9.74052176e-02f, 6.30937517e-02f, -1.09815113e-01f, 3.35017927e-02f,
  2.48106107e-01f, 9.06536579e-02f, 3.05411667e-01f, -1.01943605e-01f, 1.34656489e-01f, -1.60184577e-01f, -3.69689912e-01f, -2.38186434e-01f, -3.52862105e-02f, -4.22530919e-02f,
  1.68133035e-01f, -3.77399921e-01f, -3.32225226e-02f, -1.39917105e-01f, -9.52429399e-02f, 2.61182696e-01f, -9.78587419e-02f, -4.09143902e-02f, -1.35438383e-01f, 1.67639647e-02f,
  1.45923018e-01f, -1.04550608e-01f, -3.74061801e-02f, 4.64652777e-02f, -9.95305628e-02f, 1.94126554e-02f, 3.89228645e-03f, -5.10663912e-02f, -1.24527263e-02f, 6.95176125e-02f,
  -8.06698427e-02f, -3.85522470e-02f, -1.82695925e-01f, 1.19028324e-02f, -9.77330729e-02f, 9.25299600e-02f, -7.12331980e-02f, -6.81713670e-02f, -1.87008038e-01f, 2.06600036e-03f,
  -1.48793951e-01f, -6.62477165e-02f, 1.03324674e-01f, 1.67741492e-01f, 4.70563658e-02f, 8.60962272e-02f, 1.85537383e-01f, -2.26599425e-01f, -2.00990751e-01f, 9.85833183e-02f,
  -3.60226214e-01f, -3.90823185e-02f, 2.43255958e-01f, -1.35860696e-01f, -2.79915720e-01f, -1.03325307e-01f, -1.86705813e-01f, -1.04236372e-01f, -1.03795402e-01f, -2.76868463e-01f,
  1.90042164e-02f, -7.92512670e-02f, 1.12766422e-01f, 5.10217771e-02f, 5.56525737e-02f, 2.32564315e-01f, 2.24576235e-01f, -1.05193611e-02f, -1.04782790e-01f, 1.55836388e-01f,
  -7.41570303e-03f, 2.71388203e-01f, -2.11679284e-02f, -1.58343509e-01f, -9.39381942e-02f, -6.63702264e-02f, 3.40789765e-01f, -4.55568060e-02f, -1.12894334e-01f, -8.18553269e-02f,
  3.13423723e-02f, 1.28055915e-01f, 1.81739666e-02f, -6.75898194e-02f, -1.11465715e-01f, 7.66949058e-02f, 1.81758553e-02f, -5.15968129e-02f, 9.22532678e-02f, -1.21187232e-02f,
  -2.23354883e-02f, 3.49649340e-02f, 8.47525597e-02f, 1.23232357e-01f, -8.12293068e-02f, -9.49092433e-02f, -5.23129068e-02f, 1.31732533e-02f, -8.81038904e-02f, -1.40428945e-01f,
  -5.70696481e-02f, -1.60406590e-01f, -6.41477704e-02f, -3.00303221e-01f, 1.95004761e-01f, 6.24544881e-02f, 2.45654341e-02f, -5.00401389e-03f, 1.16637543e-01f, -1.38996199e-01f,
  1.12061575e-01f, 8.19682926e-02f, -2.96081905e-03f, 7.73844644e-02f, 5.57728931e-02f, 1.34851560e-02f, -9.30989608e-02f, 6.15621135e-02f, -1.50701433e-01f, 4.58791889e-02f,
  1.94071066e-02f, -3.08238417e-01f, 5.63695431e-02f, -9.66005698e-02f, 2.77914256e-01f, -1.37518451e-01f, -8.77810419e-02f, 3.36803384e-02f, 8.74061063e-02f, -2.36721292e-01f,
  -1.50685832e-01f, 1.85853645e-01f, -2.89271742e-01f, 6.33256659e-02f, -3.26427817e-01f, -1.97823271e-01f, 2.33723342e-01f, 1.33318052e-01f, 1.75813124e-01f, -3.67582679e-01f,
  -1.40830144e-01f, 3.95677378e-03f, -1.48144335e-01f, 1.14873461e-01f, -6.98035210e-02f, 1.05691671e-01f, 1.53702766e-01f, 2.73174290e-02f, -1.74218729e-01f, 6.43856153e-02f,
  -2.64961477e-02f, 5.41038699e-02f, -1.58268571e-01f, -1.86926331e-02f, 2.28868350e-01f, -1.75707042e-01f, -4.67772782e-02f, -1.06933556e-01f, -2.52331525e-01f, 1.37341127e-01f,
  -6.13816641e-02f, -1.91967964e-01f, -6.33397326e-02f, -1.05465591e-01f, 4.47169244e-02f, -2.98576569e-03f, 4.70449477e-02f, -1.05993807e-01f, -1.43458307e-01f, -1.21479288e-01f,
  -8.77900198e-02f, -1.69717781e-02f, 1.94419682e-01f, 2.93851942e-02f, -3.83924432e-02f, -2.10810512e-01f, -2.75602303e-02f, 2.88656056e-01f, -1.02613583e-01f, -1.83176119e-02f,
  -5.29114045e-02f, -2.11751938e-01f, -3.84571850e-02f, -1.42222434e-01f, -2.92025339e-02f, -1.55202463e-01f, 3.21689039e-01f, -1.09241553e-01f, 3.06892674e-02f, -1.38300471e-02f,
  -3.45672667e-02f, -9.63204727e-02f, 2.34926388e-01f, -4.88421097e-02f, 3.41958165e-01f, -1.40374348e-01f, -2.13674784e-01f, -7.03773275e-02f, -5.57776168e-02f, 2.52684414e-01f,
  -3.68872344e-01f, 7.37299547e-02f, -2.25501046e-01f, 8.60234499e-02f, 2.41349354e-01f, 3.79953883e-03f, -2.82709766e-03f, -5.91712482e-02f, 3.36308144e-02f, 1.76089369e-02f,
  5.10909967e-02f, 6.30786642e-02f, -5.94306290e-02f, 2.84065190e-03f, 6.72522113e-02f, 3.53406323e-03f, 7.25222705e-03f, 2.15898678e-02f, 9.35816914e-02f, 1.29623309e-01f,
  2.02420816e-01f, 9.41300169e-02f, 7.70130083e-02f, 9.36623290e-03f, 1.94081008e-01f, 1.47128806e-01f, 2.87784070e-01f, 8.76068100e-02f, 5.56901507e-02f, 2.31084898e-01f,
  1.20776743e-02f, 1.24487385e-01f, 3.23638873e-04f, -1.36905275e-02f, -1.40315458e-01f, -1.74122348e-01f, -1.96716622e-01f, 1.70601644e-02f, -1.01491608e-01f, 2.33946204e-01f,
  -6.57531619e-02f, -2.18646228e-01f, 1.64368093e-01f, 1.53189644e-01f, -2.39773214e-01f, 5.59785739e-02f, 1.63426772e-01f, 2.43563503e-01f, -2.65807156e-02f, 1.83501527e-01f,
  -1.09249480e-01f, 2.94450074e-01f, 4.76435013e-02f, -4.81896326e-02f, -4.90314476e-02f, -1.85270131e-01f, -2.87974268e-01f, -2.60967582e-01f, -1.46747857e-01f, -7.84869641e-02f,
  2.15505078e-01f, 2.07854912e-01f, -1.31180972e-01f, -2.66713440e-01f, 1.73824623e-01f, 7.04246387e-02f, 3.39567184e-01f, 1.03382617e-01f, -3.46616268e-01f, 1.10999197e-01f,
  -1.66427549e-02f, -1.49920568e-01f, -7.02953711e-02f, 9.42390263e-02f, -9.08127055e-03f, -9.72998068e-02f, 7.46834576e-02f, 6.25716224e-02f, 4.84431013e-02f, 9.36655607e-03f,
  -7.38568157e-02f, 4.51108962e-02f, 6.57407045e-02f, -1.03202999e-01f, -1.17930755e-01f, 7.43377656e-02f, -2.32313983e-02f, -9.35539678e-02f, 6.60153804e-03f, -2.23172501e-01f,
  1.45419657e-01f, -3.37627567e-02f, 2.39644032e-02f, 5.31864688e-02f, 4.77403700e-02f, 1.94733217e-01f, -3.52798760e-01f, -9.38398615e-02f, -1.94171995e-01f, -9.25462097e-02f,
  1.17415011e-01f, 7.60824382e-02f, -1.26453082e-03f, 1.25568181e-01f, -1.77489385e-01f, -4.34303284e-02f, -2.80089490e-02f, -3.67161781e-02f, 1.20628990e-01f, -6.15743920e-02f,
  1.07867524e-01f, -2.06292927e-01f, 1.82362162e-02f, -1.63438246e-01f, -1.20218933e-01f, -2.10128456e-01f, 3.17477696e-02f, -2.09695604e-02f, -2.67478246e-02f, -1.78251848e-01f,
  -1.22970842e-01f, -1.90449394e-02f, -1.19009659e-01f, 1.04096411e-02f, 2.23132119e-01f, -1.91656202e-01f, 3.17408323e-01f, 1.20993018e-01f, -1.19213022e-01f, -7.94567615e-02f,
  -2.37525851e-02f, 1.83116183e-01f, 6.18527569e-02f, -1.31526023e-01f, 1.69398226e-02f, 1.08112298e-01f, -1.22994341e-01f, 8.70884657e-02f, -1.95583269e-01f, 1.34725213e-01f,
  -9.32930410e-02f, -1.00129016e-01f, -4.43850905e-02f, -1.06671520e-01f, 3.67995389e-02f, -2.24889349e-02f, 2.86103077e-02f, -5.30692451e-02f, 1.46361813e-01f, -6.68052733e-02f,
  1.64485395e-01f, 4.20018891e-03f, -6.19736202e-02f, -6.86328039e-02f, -1.94169298e-01f, -7.67710432e-02f, -4.53410950e-03f, 1.21771865e-01f, -2.10197061e-01f, -6.18958250e-02f,
  -1.16373956e-01f, 9.21910256e-02f, 1.75218746e-01f, 1.57563388e-01f, -1.10745132e-01f, 1.46242052e-01f, 1.85679823e-01f, -1.56034946e-01f, 2.35587787e-02f, -1.97460484e-02f,
  2.24220365e-01f, 5.01061007e-02f, 1.01528279e-01f, 1.26531839e-01f, -1.19914159e-01f, -3.23245339e-02f, -4.34312299e-02f, -1.26075065e-02f, -1.40120849e-01f, -7.24688992e-02f,
  2.79039219e-02f, -5.12687489e-02f, 3.19169424e-02f, -1.39375195e-01f, -1.76463097e-01f, 1.06067434e-01f, -5.42133033e-01f, -7.78941512e-02f, -1.36587813e-01f, 8.81964937e-02f,
  1.76756620e-01f, 1.53336423e-02f, 6.15163241e-03f, 2.18883172e-01f, -2.17131436e-01f, 2.20719218e-01f, 1.47906942e-02f, 2.83571035e-02f, 2.27906868e-01f, 1.24746844e-01f,
  -4.55312990e-02f, 9.25525185e-03f, -7.09070778e-03f, -1.42804906e-01f, -5.93738966e-02f, -1.36233076e-01f, -1.90276168e-02f, -9.49189141e-02f, 1.40509903e-01f, 2.91095097e-02f,
  -1.51802778e-01f, -1.18100516e-01f, 3.63403521e-02f, 6.21160269e-02f, -2.75242068e-02f, 3.59325819e-02f, -5.99781573e-02f, -1.96685046e-01f, -5.53791635e-02f, -8.55396222e-03f,
  6.58114851e-02f, -1.02511495e-01f, 1.27773911e-01f, -6.91754967e-02f, -1.69107437e-01f, 1.69543605e-02f, -1.21432155e-01f, 1.38839826e-01f, 8.28923285e-02f, -2.57646769e-01f,
  2.02447042e-01f, 3.30600468e-03f, 3.77722941e-02f, -1.71241928e-02f, 2.66338186e-03f, 2.12960243e-01f, 2.52415240e-01f, 2.66882516e-02f, -4.47836220e-02f, -2.49055192e-01f,
  1.76449046e-01f, -2.86968619e-01f, -1.51963294e-01f, -2.90410846e-01f, -4.93245274e-02f, -6.62623271e-02f, 3.13278019e-01f, 9.01103020e-02f, 1.43797085e-01f, 1.47449136e-01f,
  1.42827764e-01f, 6.74372464e-02f, 1.69003364e-02f, -2.92057812e-01f, 2.73297518e-01f, -1.17159203e-01f, -2.64203936e-01f, 1.58133611e-01f, -3.64657901e-02f, 2.67881062e-02f,
  -1.29528299e-01f, -5.33072874e-02f, -9.46742594e-02f, 6.40822500e-02f, 5.93279302e-02f, -6.61368445e-02f, -1.46433875e-01f, 1.04851007e-01f, 7.53505379e-02f, -1.40570477e-01f,
  3.95816052e-03f, 1.00584567e-01f, -6.67041838e-02f, -4.34424076e-03f, 4.04000506e-02f, -4.69444208e-02f, -1.66003048e-01f, 2.80163419e-02f, 2.54434440e-02f, 1.26020372e-01f,
  -1.12662725e-01f, 6.93234578e-02f, -1.06960051e-01f, 3.97984385e-02f, -7.21813515e-02f, -1.03059158e-01f, -1.04648709e-01f, -4.29534465e-02f, -6.77943528e-02f, 3.82902101e-02f,
  -6.58510029e-02f, -7.15503693e-02f, -9.30613726e-02f, -5.78940436e-02f, -3.39125395e-02f, -8.63045678e-02f, 1.15176484e-01f, 2.25716998e-04f, -1.07086830e-01f, 2.09920835e-02f,
  1.27444118e-01f, -5.75070232e-02f, -2.36422420e-01f, -3.21500719e-01f, 7.09627494e-02f, 1.18500911e-01f, -1.41312167e-01f, -9.38308239e-02f, 7.38866404e-02f, 1.21647015e-01f,
  2.35475838e-01f, -1.32128382e-02f, 4.38357033e-02f, 2.40155831e-02f, 6.46268204e-02f, -1.43464636e-02f, 3.25259902e-02f, 1.15046091e-01f, 7.23633543e-02f, -5.70669472e-02f,
  -1.55143887e-01f, 1.20784514e-01f, -2.96673439e-02f, 5.25180064e-02f, -4.79988866e-02f, 2.04142824e-01f, -7.63023868e-02f, -2.80132294e-01f, -9.60901454e-02f, -3.07648890e-02f,
  -2.96852589e-02f, -7.62594789e-02f, 2.13895068e-02f, -1.84876602e-02f, -5.00765257e-02f, -1.67716630e-02f, 4.58907969e-02f, -2.60353610e-02f, 8.44476819e-02f, 2.58130934e-02f,
  -5.60708381e-02f, -1.87875088e-02f, 9.00769159e-02f, -2.53521949e-02f, -3.73754418e-04f, 8.34900662e-02f, 1.86991238e-03f, -4.70062383e-02f, -5.66000678e-02f, 2.44710390e-02f,
  -3.27394670e-03f, -1.10024311e-01f, 2.33205110e-02f, 1.23613305e-01f, -7.63679668e-03f, -7.36579522e-02f, -6.12587221e-02f, -9.57502872e-02f, -1.66898042e-01f, 3.05203758e-02f,
  4.16237302e-02f, -1.40955940e-01f, 2.57859677e-02f, 2.02105995e-02f, 2.13940628e-02f, 8.37632865e-02f, -1.02932816e-02f, 2.86376663e-02f, 5.81769906e-02f, 2.11821392e-01f,
  -2.16582656e-01f, 2.45033558e-02f, -9.40090418e-02f, 1.59655213e-01f, -8.03131834e-02f, -1.78786367e-01f, -1.73473030e-01f, 7.93695152e-02f, -2.93902665e-01f, -1.11315094e-01f,
  9.82269198e-02f, 2.87898898e-01f, 1.60186827e-01f, 1.65431932e-01f, 1.07044421e-01f, -1.60726339e-01f, 1.43463135e-01f, 1.55826584e-01f, 2.57272329e-02f, -1.67865664e-01f,
  2.17122197e-01f, 1.01746038e-01f, 4.90806289e-02f, 2.15404816e-02f, 2.32137635e-01f, -7.58758411e-02f, 5.10005914e-02f, 6.83080703e-02f, 2.42454205e-02f, 3.49134430e-02f,
  6.26792088e-02f, 5.59800416e-02f, 9.39328820e-02f, 1.19379781e-01f, 9.44862738e-02f, 7.01136282e-03f, 3.70645411e-02f, -8.84724781e-04f, -4.03525494e-02f, 9.70895514e-02f,
  1.63457990e-01f, -1.14621714e-01f, -6.55107796e-02f, 1.14305884e-01f, 1.85917065e-01f, 9.27395076e-02f, 1.29990637e-01f, 2.82352977e-02f, -6.56875893e-02f, -5.06885089e-02f,
  -8.19172710e-02f, -2.15092018e-01f, -1.13596156e-01f, -6.26687855e-02f, -9.32161734e-02f, -6.15820140e-02f, 1.17861390e-01f, 1.04842849e-01f, 9.71132964e-02f, 1.62678063e-02f,
  1.56400502e-01f, 3.56311835e-02f, 1.71721373e-02f, 7.85742551e-02f, 1.88428129e-03f, 1.28861070e-01f, -2.81063765e-01f, -1.69514231e-02f, -6.71756417e-02f, 4.12585549e-02f,
  -4.49035764e-02f, -1.35621384e-01f, 1.08872555e-01f, -6.46639690e-02f, -1.00274943e-01f, 9.02059749e-02f, -1.05533540e-01f, -4.67081964e-02f, 1.61482081e-01f, -1.39300480e-01f,
  -2.50194501e-02f, -8.77723545e-02f, -2.98729772e-03f, 1.21394970e-01f, 6.08973280e-02f, -9.41831991e-02f, 5.38105816e-02f, -3.09194643e-02f, -6.12210371e-02f, -1.61553189e-01f,
  -4.28637974e-02f, -6.91710552e-03f, -1.68566719e-01f, 2.73993779e-02f, 3.12544852e-02f, -1.17751941e-01f, -4.88965660e-02f, -2.14472085e-01f, -1.25771508e-01f, -2.62690842e-01f,
  3.72459926e-02f, -8.20855051e-02f, -4.09375094e-02f, -1.92649186e-01f, -2.11710840e-01f, -3.22734676e-02f, 8.35129768e-02f, 1.10251240e-01f, -4.95766513e-02f, 6.59650331e-03f,
  -2.06822038e-01f, -1.11276530e-01f, -1.00800633e-01f, -4.78922501e-02f, -1.10655680e-01f, 1.06602475e-01f, 1.47053465e-01f, -4.81799245e-02f, -2.44318563e-02f, -1.29767507e-01f,
  -3.72476988e-02f, -1.36035755e-01f, 9.40226763e-02f, 6.38159662e-02f, 5.63391261e-02f, 2.41674436e-03f, 2.01058835e-01f, -2.27063790e-01f, -1.37086272e-01f, -2.82831222e-01f,
  8.69052038e-02f, -1.06941476e-01f, 6.29988611e-02f, -9.38747376e-02f, -2.67548978e-01f, -2.17455506e-01f, -4.15348053e-01f, -5.77615909e-02f, 2.25706637e-01f, -7.70771131e-02f,
  3.27922851e-01f, 1.63980365e-01f, -4.27543223e-02f, -1.05364919e-02f, 7.28558525e-02f, 2.93416589e-01f, 3.26474681e-02f, 8.52014795e-02f, -1.32599905e-01f, 3.06237012e-01f
};

// L1_fan_Wp_bar (Shape: 14 x 64)
const int L1_fan_Wp_bar_rows = 14;
const int L1_fan_Wp_bar_cols = 64;
const float L1_fan_Wp_bar_data[] = {
  3.86186701e-04f, 1.93149313e-01f, -1.56187385e-01f, -8.20216089e-02f, -4.80566509e-02f, 1.92695379e-01f, 1.93013817e-01f, 1.45216048e-01f, 3.85295078e-02f, 7.31434673e-02f,
  3.12233299e-01f, 5.98388202e-02f, 7.92979300e-02f, -3.47697511e-02f, -4.01550867e-02f, 1.90992087e-01f, 1.53300747e-01f, 2.57837296e-01f, 1.11553155e-01f, 1.58382952e-01f,
  4.25544716e-02f, 2.75013506e-01f, 1.10070989e-01f, 7.54524246e-02f, 2.28465676e-01f, -5.27729020e-02f, -1.28836468e-01f, 5.66179603e-02f, 7.80908689e-02f, 1.01925574e-01f,
  -1.02531552e-01f, -2.45927349e-02f, 9.64635685e-02f, -2.16001868e-02f, -6.46000430e-02f, -1.16238825e-01f, -1.21565990e-01f, -1.25183895e-01f, -1.42819822e-01f, 1.40217528e-01f,
  7.06353635e-02f, 9.57737416e-02f, -4.22673784e-02f, 6.48933798e-02f, 2.77774364e-01f, 2.10996166e-01f, -1.98426560e-01f, -2.42025539e-01f, -1.47080109e-01f, -4.72774915e-02f,
  1.78781986e-01f, -2.15617746e-01f, -3.55152905e-01f, -1.20618738e-01f, -1.69656023e-01f, 3.70278358e-01f, 9.51310843e-02f, 4.21448871e-02f, 4.36772853e-02f, -1.72422882e-02f,
  2.59498984e-01f, -2.41732702e-01f, 2.96014518e-01f, 3.76928508e-01f, -1.94972381e-02f, 1.13248020e-01f, 1.83311835e-01f, 3.05846870e-01f, 1.05270296e-01f, 1.40949413e-01f,
  1.38851419e-01f, 6.82088882e-02f, 1.69430599e-02f, -5.01619540e-02f, 4.95243371e-02f, 2.68221032e-02f, 1.77466124e-01f, -2.71427296e-02f, -6.03919253e-02f, 7.11776689e-02f,
  -1.58565566e-01f, -1.09495543e-01f, -1.25932485e-01f, 3.95746008e-02f, -1.40158847e-01f, 3.26444656e-02f, -9.02449489e-02f, -7.88735449e-02f, 1.67169228e-01f, 1.29028499e-01f,
  -5.18772900e-02f, 1.54050842e-01f, -9.89534557e-02f, -5.65708503e-02f, -2.09396303e-01f, 4.92425114e-02f, -3.20445225e-02f, -1.06903933e-01f, -5.35604917e-02f, 2.92094424e-02f,
  4.77277488e-02f, -1.32637471e-01f, -6.53525698e-04f, -3.05308700e-01f, -1.18806064e-01f, 2.30749279e-01f, -2.31982768e-01f, 2.12909341e-01f, 1.08065367e-01f, 1.17922924e-01f,
  2.51586884e-01f, 1.71612188e-01f, -1.63130447e-01f, 1.82233572e-01f, 1.86973557e-01f, 2.00362980e-01f, -3.66966456e-01f, 2.00207159e-01f, -2.84345031e-01f, 5.52705646e-01f,
  -5.34250177e-02f, -1.51031688e-01f, -1.84518695e-01f, 1.38731256e-01f, 1.43878281e-01f, 1.60219952e-01f, 3.44901867e-02f, 2.90954392e-02f, -1.12152874e-01f, 9.21927113e-03f,
  4.97958921e-02f, 1.24174930e-01f, 1.64020527e-02f, 1.05203107e-01f, 8.74903128e-02f, -4.56741042e-02f, -2.83076186e-02f, 1.12970300e-01f, -4.25925478e-02f, -1.12614773e-01f,
  -6.79770857e-02f, 9.63120237e-02f, 3.58017609e-02f, -4.48402539e-02f, -1.98145762e-01f, -8.68789330e-02f, 3.89971882e-02f, 7.73531990e-03f, 1.82899311e-02f, 2.17953734e-02f,
  -2.25884259e-01f, -3.83522920e-02f, 6.00176677e-02f, -9.07256231e-02f, -1.50783628e-01f, -5.04207462e-02f, 5.51782660e-02f, 1.89352751e-01f, -4.86043282e-03f, 8.78859162e-02f,
  -6.27392530e-02f, 1.97639242e-01f, -3.87332141e-02f, -4.82935458e-03f, 8.15332904e-02f, -2.14960217e-01f, -3.57980989e-02f, -5.04787378e-02f, 1.29892111e-01f, -6.38526604e-02f,
  -1.14804432e-01f, 1.17945321e-01f, 1.07044406e-01f, -1.49610266e-01f, 1.82712287e-01f, -9.95208323e-02f, -1.20511651e-01f, 9.36955810e-02f, -7.94767976e-01f, -1.38058677e-01f,
  8.76861513e-02f, 2.80468941e-01f, 1.67350575e-01f, -1.41773000e-01f, 1.22508653e-01f, -6.22786675e-03f, -4.87786019e-04f, 9.75051001e-02f, -1.06402509e-01f, 3.93147051e-01f,
  -1.88166365e-01f, -1.51862666e-01f, -1.43677637e-01f, 9.99625772e-02f, 2.45727357e-02f, -1.87759578e-01f, -2.24365130e-01f, -4.82278466e-02f, -9.31691602e-02f, -5.80877205e-03f,
  -1.71337798e-01f, 1.41511947e-01f, 5.52340061e-04f, 8.42664018e-02f, -6.49283975e-02f, 6.25705346e-02f, 5.73986359e-02f, -1.11355603e-01f, -4.42335792e-02f, 2.51629323e-01f,
  -5.14807776e-02f, 1.21175341e-01f, -1.27276957e-01f, 9.02600959e-02f, 7.12697133e-02f, 3.42928246e-02f, 8.32673609e-02f, 5.90788797e-02f, 2.79050898e-02f, 3.85734849e-02f,
  -3.82266976e-02f, 7.22450912e-02f, -1.40086055e-01f, 1.79546978e-02f, 1.36619434e-02f, -1.01946481e-01f, 1.65255740e-01f, 8.77157077e-02f, -1.70830935e-01f, 2.73793619e-02f,
  -5.67950197e-02f, -5.13367504e-02f, -1.64071172e-01f, 3.18319321e-01f, 3.07042412e-02f, 2.13903219e-01f, 6.21353909e-02f, 2.96612799e-01f, -3.38524245e-02f, 1.04315095e-02f,
  -3.27999890e-01f, 6.45136461e-02f, -7.62727782e-02f, -1.69511691e-01f, -2.89683372e-01f, 3.06832820e-01f, -4.04927939e-01f, 1.42509267e-01f, 1.63910389e-01f, 2.84284264e-01f,
  -2.46350572e-01f, 2.78693318e-01f, 2.79470861e-01f, -1.48276538e-01f, 4.67966497e-01f, -1.92531139e-01f, 5.24971262e-03f, 2.26735417e-02f, -1.29463941e-01f, 1.66782513e-01f,
  -1.29727066e-01f, 2.87076414e-01f, 1.07115462e-01f, 1.54043853e-01f, 8.90330225e-02f, 5.25501790e-03f, -1.18448660e-01f, 1.71849176e-01f, 9.78027657e-02f, 2.83449348e-02f,
  7.84728155e-02f, 2.16994345e-01f, 2.68521100e-01f, 2.58920550e-01f, 8.39624330e-02f, -1.67851076e-02f, -1.32493284e-02f, 9.30929407e-02f, 1.29117399e-01f, -1.89931951e-02f,
  1.44193560e-01f, -7.97272325e-02f, 1.82061031e-01f, -9.96033251e-02f, -1.12223573e-01f, 2.16230899e-02f, -1.48011789e-01f, 1.38442829e-01f, 4.67358418e-02f, -6.03796868e-03f,
  7.65500814e-02f, 2.46663252e-03f, -2.41976634e-01f, 1.35855451e-01f, 3.27129290e-02f, 3.05633694e-01f, 1.71975657e-01f, -1.00749388e-01f, 1.52263463e-01f, -5.51653318e-02f,
  3.06469039e-04f, -1.39506042e-01f, -8.42837989e-02f, -2.52673060e-01f, -2.55501360e-01f, -7.36068562e-02f, -1.19836759e-02f, -1.28875881e-01f, 8.93806070e-02f, 3.05564076e-01f,
  -4.06034976e-01f, 1.15158983e-01f, 2.53097862e-01f, 2.90559623e-02f, 1.24846175e-01f, 6.92717731e-02f, 1.58518523e-01f, 3.15126665e-02f, 1.95455357e-01f, 1.79584950e-01f,
  1.87497228e-01f, 2.09055707e-01f, 2.28918701e-01f, 1.23068072e-01f, 9.55364481e-02f, 1.12750471e-01f, -1.56435847e-01f, -1.01760119e-01f, 2.12143824e-01f, -2.24719625e-02f,
  9.16088074e-02f, -3.08098737e-02f, 1.21752523e-01f, 2.50165969e-01f, -1.11299746e-01f, 3.38034123e-01f, -1.30084739e-03f, 3.03659350e-01f, 1.70433417e-01f, -7.14073852e-02f,
  -6.13696524e-04f, 1.54465139e-01f, 2.20143288e-01f, 1.99336514e-01f, 2.65790910e-01f, 1.31701142e-01f, -8.31327662e-02f, 3.20434868e-01f, 2.99277097e-01f, -1.25283569e-01f,
  -1.40732676e-01f, 1.50958160e-02f, 1.76138237e-01f, -1.03578761e-01f, 3.02756041e-01f, 1.06580973e-01f, -1.36724338e-01f, -1.31061062e-01f, 1.42380774e-01f, -7.48249218e-02f,
  -6.88842088e-02f, 7.01275244e-02f, 5.52762933e-02f, 6.55951053e-02f, 9.11887959e-02f, 2.30131447e-02f, -2.27512457e-04f, 3.61935228e-01f, 9.93717387e-02f, -1.27009556e-01f,
  9.01975930e-02f, 1.24669597e-01f, 7.82609805e-02f, 3.82080495e-01f, -3.52387130e-01f, 1.56651717e-03f, 5.17044812e-02f, -7.20562637e-02f, -9.76224430e-03f, -1.07389018e-01f,
  -7.92610198e-02f, 1.84979305e-01f, 2.44892746e-01f, -1.44492313e-01f, 1.24371827e-01f, -1.44822925e-01f, -1.52520105e-01f, -3.40890288e-02f, -1.60795525e-01f, 1.66915972e-02f,
  -1.32336810e-01f, 4.32761274e-02f, 1.47179840e-02f, 5.25396392e-02f, -1.17421880e-01f, -1.10708773e-01f, -1.15382280e-02f, -3.63638997e-02f, 4.09603268e-02f, 1.17365368e-01f,
  1.85482770e-01f, 7.77577087e-02f, 9.64162797e-02f, 1.25613630e-01f, -4.53958139e-02f, 9.69415978e-02f, 8.58542174e-02f, 1.56004861e-01f, -5.00491261e-02f, 1.12600937e-01f,
  6.10672086e-02f, -2.57952679e-02f, 2.31809258e-01f, -1.44782081e-01f, 5.35060326e-03f, 6.63584396e-02f, 8.02247319e-03f, 2.07960159e-01f, 9.94705632e-02f, 1.70179546e-01f,
  -5.51250242e-02f, 2.32152313e-01f, 1.44145846e-01f, 7.63657242e-02f, 4.65942286e-02f, 1.35772154e-01f, 4.78508294e-01f, -2.82033011e-02f, 2.13669345e-01f, -1.52599350e-01f,
  9.09600630e-02f, 2.69614786e-01f, 9.74973813e-02f, 1.13244586e-01f, 1.32759437e-01f, 4.30519581e-01f, 3.43773901e-01f, -3.85240406e-01f, -2.23730758e-01f, -3.17082942e-01f,
  -4.47909385e-01f, 5.60064949e-02f, 9.84258354e-02f, -8.61821398e-02f, -3.33284698e-02f, 7.80149624e-02f, 5.74727729e-02f, -1.83461204e-01f, -6.97009414e-02f, -8.35434869e-02f,
  6.58512935e-02f, -2.08918974e-02f, 7.22500756e-02f, -1.76279824e-02f, 8.79908875e-02f, 4.48212773e-02f, -1.34060010e-01f, 2.12346539e-01f, 6.00842992e-03f, 2.67700970e-01f,
  -2.40983933e-01f, -1.72455788e-01f, -2.81508826e-02f, -2.42845044e-02f, 8.58646780e-02f, -3.43357101e-02f, 8.36139470e-02f, 4.20068465e-02f, -4.98802140e-02f, -1.27707003e-02f,
  5.71300872e-02f, -5.70445508e-02f, -1.88005686e-01f, -2.22777754e-01f, -3.28015769e-03f, -5.62546030e-02f, 2.41984382e-01f, -3.58281046e-01f, 2.55653650e-01f, -1.05044961e-01f,
  1.69468999e-01f, 2.10530922e-01f, -4.94737774e-02f, -1.56620383e-01f, 1.62377562e-02f, -3.41438688e-02f, 4.39700365e-01f, -2.22709984e-01f, 9.31245610e-02f, -2.05624700e-01f,
  4.70636696e-01f, -1.79267213e-01f, 2.42869765e-01f, -1.69376716e-01f, 3.52408499e-01f, 2.87554562e-01f, 4.57768172e-01f, 3.42208385e-01f, 1.38515770e-01f, -7.02561662e-02f,
  -1.44755179e-02f, -1.79021552e-01f, 1.77632898e-01f, -1.21580899e-01f, -3.70205671e-01f, -3.00827324e-01f, 7.77353868e-02f, 4.36540335e-01f, 7.82692730e-02f, 2.26929992e-01f,
  -5.19127659e-02f, -5.39650977e-01f, 3.10941339e-02f, -2.91955583e-02f, 6.10174201e-02f, 3.23160924e-02f, -1.64516836e-01f, -2.02414189e-02f, 1.60927549e-02f, 1.04375288e-01f,
  6.08913340e-02f, -1.00178979e-02f, -4.74383533e-02f, -1.36941060e-01f, -8.18233863e-02f, 5.11272177e-02f, 2.13804990e-01f, 1.60756275e-01f, -3.83429490e-02f, 1.64532542e-01f,
  -1.31272510e-01f, -6.10409454e-02f, 2.18818467e-02f, -1.00743473e-01f, -2.79689860e-02f, 1.45033095e-02f, 1.19858973e-01f, 8.85521993e-02f, -1.07579693e-01f, -5.43578304e-02f,
  1.21997215e-01f, 7.87859224e-03f, 1.03709690e-01f, -3.54019582e-01f, 1.43445715e-01f, 1.23796009e-01f, 1.47761196e-01f, 5.56076355e-02f, 2.85044342e-01f, 2.88327131e-02f,
  -2.69655287e-01f, -1.86904177e-01f, 1.41972527e-01f, -3.13199103e-01f, -2.68444549e-02f, -3.30708683e-01f, 1.68118104e-01f, -7.12869465e-02f, 3.00861716e-01f, -7.58752376e-02f,
  -2.28671432e-01f, 4.66830403e-01f, -1.71427876e-01f, 5.63919097e-02f, -9.01220217e-02f, 5.75706176e-02f, 5.53835750e-01f, 1.14574209e-01f, -6.65671304e-02f, -1.33092493e-01f,
  6.72110468e-02f, -1.21390983e-03f, 5.72000891e-02f, 1.36628896e-01f, 4.23083782e-01f, -1.05118014e-01f, 3.55829507e-01f, 1.20452613e-01f, 1.59208268e-01f, -6.56016022e-02f,
  3.01190376e-01f, 4.81017008e-02f, 2.50791043e-01f, 1.55431017e-01f, 3.42891701e-02f, -4.72683571e-02f, 4.95693013e-02f, -7.57048652e-02f, 2.79619303e-02f, 2.96403289e-01f,
  -7.86752552e-02f, 2.97900945e-01f, 1.48604408e-01f, 9.44362208e-02f, 1.80456564e-01f, 2.44668603e-01f, 3.15607160e-01f, 1.69004753e-01f, 1.52895704e-01f, 2.74797529e-01f,
  1.35505393e-01f, -2.40028501e-02f, -8.67994800e-02f, 1.31435543e-01f, 1.85595170e-01f, 1.45195350e-01f, 9.85002220e-02f, 5.77877834e-02f, -1.65298641e-01f, 1.39649734e-01f,
  -3.46236169e-01f, -1.21361564e-03f, 1.07924484e-01f, -1.40196428e-01f, -2.58927137e-01f, -7.84376934e-02f, -3.39977592e-02f, -3.12725127e-01f, -2.86685258e-01f, -2.70184726e-01f,
  -3.02827656e-02f, 7.82450140e-02f, -1.35833532e-01f, 6.82486817e-02f, 2.85142541e-01f, 1.09133787e-01f, 4.92323726e-01f, 3.01097333e-02f, 9.27641988e-02f, -3.23562562e-01f,
  5.72403133e-01f, 3.11537981e-01f, 9.73940641e-02f, -3.37014914e-01f, -1.05559424e-01f, 1.49230540e-01f, 1.60193712e-01f, -6.96641207e-02f, -1.07636891e-01f, 4.01945382e-01f,
  3.93396392e-02f, 5.66892363e-02f, 7.86486790e-02f, 1.55282721e-01f, 1.45444106e-02f, -3.58212516e-02f, -1.79257374e-02f, -2.28128564e-02f, 1.25494385e-02f, 1.52000383e-01f,
  -1.07393295e-01f, 2.34410539e-01f, 1.78829297e-01f, -4.17364538e-02f, -2.88052801e-02f, 3.83284651e-02f, 1.44416597e-02f, -1.69084504e-01f, 1.02001272e-01f, -6.27571419e-02f,
  1.45976797e-01f, -1.62104577e-01f, -2.23938469e-02f, -8.84209052e-02f, 5.07670082e-02f, 1.64959416e-01f, 4.20470946e-02f, -1.23931244e-01f, 2.65639573e-01f, -2.47762978e-01f,
  2.66669244e-01f, -4.51424792e-02f, 2.00021163e-01f, 1.54676422e-01f, 1.12179011e-01f, -3.02377809e-03f, -7.11306483e-02f, -1.17899232e-01f, 4.07411247e-01f, -6.57974631e-02f,
  -5.69363013e-02f, 1.79759040e-02f, 9.55842435e-02f, -1.81950048e-01f, -1.61885798e-01f, -6.11521713e-02f, 1.17158838e-01f, 3.45152438e-01f, 4.41820294e-01f, -3.60319950e-03f,
  1.07787736e-01f, -1.92381933e-01f, 1.25749102e-02f, -1.20948516e-01f, 2.91038841e-01f, -3.54641050e-01f, -5.72661877e-01f, 1.87471092e-01f, 2.28683837e-02f, 3.76701862e-01f,
  -5.64766765e-01f, 4.71567363e-02f, -2.62651086e-01f, -2.97203958e-01f, 1.18279673e-01f, 6.47920221e-02f, 2.02959701e-01f, -3.06636356e-02f, -4.07042056e-02f, 9.62208509e-02f,
  -1.65598497e-01f, 3.84113677e-02f, 1.88943654e-01f, -2.01647341e-01f, -1.09110400e-01f, -4.96091433e-02f, 2.56358385e-01f, 1.17496356e-01f, -1.98851600e-01f, 1.44967381e-02f,
  3.09442952e-02f, 2.22203076e-01f, 5.15338816e-02f, 1.19429752e-01f, 8.88398439e-02f, 1.12546399e-01f, 4.22778949e-02f, -1.73743010e-01f, 3.98327410e-01f, 3.13250631e-01f,
  -7.41863041e-04f, 1.15564525e-01f, 1.22173056e-02f, 1.20254844e-01f, 3.39961797e-01f, 7.86443613e-03f, 6.73688203e-02f, 1.81426659e-01f, 4.13709491e-01f, 9.68268067e-02f,
  -1.65344000e-01f, 6.16908744e-02f, -1.21904485e-01f, 2.68666297e-01f, 2.43490189e-01f, -6.42024398e-01f, 2.96220034e-01f, -4.98706192e-01f, -1.31841721e-02f, -5.48757538e-02f,
  -2.98190087e-01f, 1.14892282e-01f, 5.08435667e-01f, -2.41023690e-01f, 1.93949491e-01f, -6.04901314e-02f, -2.75130123e-01f, 4.05510813e-02f, -3.05473562e-02f, -8.94008428e-02f,
  2.05786332e-01f, -5.75287342e-02f, -2.05723971e-01f, -2.69800484e-01f, 2.00885445e-01f, 1.12397550e-02f, 1.02291591e-01f, 2.83130556e-01f, 4.20160079e-03f, 7.70560419e-03f,
  5.05540818e-02f, 2.32081562e-01f, -8.45201015e-02f, -2.32127239e-03f, 1.34810060e-01f, -6.86894506e-02f, 1.60124809e-01f, -4.35057506e-02f, -7.19614625e-02f, 1.08861879e-01f,
  -2.45191589e-01f, -1.87454939e-01f, 1.11172736e-01f, -1.70803294e-01f, -3.81144956e-02f, 5.75574711e-02f, 2.55500287e-01f, 1.66288063e-01f, 1.26498759e-01f, 1.59031242e-01f,
  -1.20482007e-02f, 5.89609630e-02f, 2.89577484e-01f, 5.34385554e-02f, -1.94220245e-01f, -1.13570102e-01f, 5.91760725e-02f, -3.92367154e-01f, 8.23333785e-02f, 2.92837732e-02f,
  1.83938146e-01f, 1.05848037e-01f, 1.83156416e-01f, 2.26103812e-01f, -1.33666605e-01f, 9.89028066e-03f, 2.90750533e-01f, 1.50483400e-01f, 9.42286327e-02f, 2.45620087e-01f,
  1.71792254e-01f, -8.11954215e-02f, -2.09626749e-01f, 7.20890909e-02f, 2.67616838e-01f, 4.62919511e-02f, -2.23745182e-02f, -2.60529649e-02f, 2.07207590e-01f, -1.00243822e-01f,
  4.50998634e-01f, -2.31530935e-01f, 3.38048637e-01f, -2.77712673e-01f, -6.61989808e-01f, -6.26800805e-02f, 2.77255744e-01f, 1.32746309e-01f, -2.28154838e-01f, 1.11399539e-01f,
  3.95850837e-02f, -4.34273183e-01f, 3.19577098e-01f, -9.50480178e-02f, -2.36211549e-02f, 9.88102630e-02f, 2.17366725e-01f, 2.39787787e-01f, 2.42918819e-01f, 4.88338247e-02f,
  4.41434681e-02f, 1.60985127e-01f, 7.45445788e-02f, 1.83594190e-02f, -1.09628260e-01f, 2.13979095e-01f, 8.01987797e-02f, 9.30984691e-02f, -1.04808696e-01f, 1.83879629e-01f,
  1.49536431e-01f, 1.29926771e-01f, 1.65109247e-01f, 3.12398784e-02f, 5.43452911e-02f, -9.79382265e-03f, 5.73637243e-03f, -2.69077778e-01f, -5.39971404e-02f, -9.53741521e-02f,
  -1.39992878e-01f, 1.51295476e-02f, -3.97469066e-02f, 6.34834245e-02f, -4.36999761e-02f, -1.46460503e-01f, -2.64959391e-02f, -1.64860874e-01f, 6.99566007e-02f, -2.51717400e-03f,
  -1.60182402e-01f, 1.43136129e-01f, 1.78381622e-01f, -2.43295386e-01f, -2.55160004e-01f, -1.39074713e-01f, 3.15792370e-03f, -1.21237030e-02f, 1.45701900e-01f, -1.77751154e-01f,
  -2.35370219e-01f, 6.44909143e-02f, -2.40856037e-01f, 1.68331489e-01f, 3.46180201e-01f, 2.29323376e-02f, 5.97910166e-01f, -1.13239445e-01f, 2.81968445e-01f, 5.07901497e-02f,
  1.80924460e-01f, -1.03566624e-01f, -1.92740694e-01f, 1.97089583e-01f, -1.26028910e-01f, 2.25213796e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 14)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 14;
const float L1_fan_Bp_bar_data[] = {
  1.14707761e-01f, -4.85685132e-02f, -1.12045527e-01f, 3.11079752e-02f, -9.23785046e-02f, -2.66117621e-02f, 1.57387748e-01f, 2.05188289e-01f, 1.24315666e-02f, 2.32258871e-01f,
  -2.25650854e-02f, 1.95658833e-01f, -7.86300842e-03f, -1.12360358e-01f
};

// L2_fan_Wp (Shape: 25 x 64)
const int L2_fan_Wp_rows = 25;
const int L2_fan_Wp_cols = 64;
const float L2_fan_Wp_data[] = {
  8.61484185e-02f, -4.36133817e-02f, 1.82148650e-01f, 3.77345324e-01f, 3.43709737e-02f, -4.69313003e-02f, 2.50915229e-01f, 3.00406851e-02f, -2.62894303e-01f, 1.29889265e-01f,
  -1.27234757e-01f, 3.30860108e-01f, 1.38425320e-01f, 3.33048478e-02f, -3.28287691e-01f, -3.56143475e-01f, 1.43314004e-01f, -8.65755323e-03f, -1.43741012e-01f, -4.25886512e-02f,
  2.03075148e-02f, 6.28096089e-02f, -2.95734080e-03f, -1.85052633e-01f, 2.64171939e-02f, -7.72525445e-02f, -7.73332641e-02f, -2.90553153e-01f, 2.69119352e-01f, -1.81320220e-01f,
  -1.45929143e-01f, -1.04699858e-01f, 2.52298743e-01f, 4.62947115e-02f, 2.12674618e-01f, 2.19883546e-01f, 3.08782935e-01f, 1.61820620e-01f, -1.42578125e-01f, 1.25704631e-01f,
  -7.54709691e-02f, -2.10269950e-02f, -1.42582338e-02f, 9.92687345e-02f, -3.72047782e-01f, 2.77417898e-01f, -7.97244012e-02f, -3.82024795e-02f, -3.42367202e-01f, 1.85800761e-01f,
  -1.03000164e-01f, 1.51011005e-01f, 1.68702036e-01f, -2.70308554e-01f, -1.09904118e-01f, -1.85912792e-02f, -3.87116112e-02f, -2.79064566e-01f, -1.55422336e-03f, 2.90885478e-01f,
  -1.46561280e-01f, 1.85600705e-02f, -2.10818797e-01f, 1.74215645e-01f, 4.36109006e-02f, -3.27661932e-01f, 1.95423752e-01f, -3.29306275e-01f, 4.10845727e-02f, -1.53684504e-02f,
  -1.01443030e-01f, -1.57054931e-01f, -8.15154165e-02f, -2.61680540e-02f, -1.50067598e-01f, -1.20355085e-01f, -3.01880538e-01f, 7.76129663e-02f, 1.69182658e-01f, -2.14176979e-02f,
  1.34399876e-01f, -2.90097116e-04f, 8.46826583e-02f, 6.55826107e-02f, 7.71825165e-02f, -2.08618045e-01f, 3.05040088e-02f, 7.10667074e-02f, -8.98466930e-02f, -1.90342233e-01f,
  1.56439107e-03f, -2.55527228e-01f, 1.12157203e-01f, 2.49847751e-02f, 6.32841364e-02f, -2.46972427e-01f, 1.61863551e-01f, 7.88445324e-02f, -1.85851958e-02f, 1.37426227e-01f,
  1.57204151e-01f, -5.03513813e-02f, -6.28158227e-02f, 1.36036932e-01f, 4.58219610e-02f, 1.30512714e-01f, 1.20233633e-01f, -2.35790968e-01f, 2.54844218e-01f, -9.42945629e-02f,
  -2.16086447e-01f, -9.08639878e-02f, -5.11725992e-02f, -2.87402030e-02f, 2.02083647e-01f, 2.00326085e-01f, 1.59506109e-02f, -1.00727819e-01f, -5.53312898e-02f, -1.05633505e-01f,
  -7.45749995e-02f, 4.96196486e-02f, -9.06591266e-02f, 3.89735065e-02f, -9.81071219e-02f, 2.51328927e-02f, -2.53035903e-01f, -3.15672010e-01f, 8.77125636e-02f, -4.03199755e-02f,
  2.49336615e-01f, 1.28325149e-01f, 4.24022712e-02f, -9.02923290e-03f, 1.74554765e-01f, 2.24249084e-02f, -1.63287938e-01f, -9.03029069e-02f, 7.22996965e-02f, 1.91395327e-01f,
  2.29574628e-02f, -2.11284887e-02f, -2.09412491e-03f, 1.40529186e-01f, 1.26730222e-02f, 6.34202659e-02f, 1.42970439e-02f, 1.45620376e-01f, 2.58581668e-01f, -1.37439622e-02f,
  1.13015771e-01f, 1.96185812e-01f, 2.03695029e-01f, -2.44335324e-01f, 7.73947984e-02f, -1.84991345e-01f, -3.81731056e-02f, -1.80233017e-01f, -4.89715207e-03f, 1.67902093e-02f,
  3.85165542e-01f, -1.85478911e-01f, -2.29257271e-01f, -2.64408678e-01f, 1.47222519e-01f, -4.81493287e-02f, 2.05691755e-01f, 7.34480843e-02f, -2.07186714e-01f, -4.42208862e-03f,
  -2.26143926e-01f, 3.49221081e-01f, -1.12647451e-01f, 6.19273260e-02f, -1.64093584e-01f, -4.74160090e-02f, -1.24692596e-01f, 7.39111975e-02f, 8.88507366e-02f, -4.55498397e-02f,
  -1.77409023e-01f, -1.82048418e-02f, 3.93410912e-03f, -4.79006805e-02f, 1.55792862e-01f, 1.56720906e-01f, 1.39994258e-02f, 2.02864349e-01f, -7.88122937e-02f, 2.76815258e-02f,
  -6.20467998e-02f, -4.03270349e-02f, 7.52645964e-03f, 2.33937547e-01f, 9.34614390e-02f, 6.89195171e-02f, 1.82252284e-03f, -3.38510945e-02f, 1.32950619e-01f, 1.99208722e-01f,
  8.86442736e-02f, 6.04201481e-02f, 1.98059916e-01f, -5.61108440e-02f, 1.82113927e-02f, 1.45034194e-01f, 4.41723578e-02f, -5.30674122e-03f, 5.88147063e-03f, 6.62733987e-02f,
  2.14378625e-01f, 1.30872831e-01f, 3.17346215e-01f, 2.12815151e-01f, 2.91026607e-02f, -3.19172419e-03f, 2.68480852e-02f, 1.66965932e-01f, -2.32737884e-01f, 4.71287668e-02f,
  3.70817631e-02f, 1.88713875e-02f, -1.15602963e-01f, 2.90951997e-01f, -3.52241486e-01f, -1.35235161e-01f, -1.83134109e-01f, 6.55111894e-02f, -2.12931912e-02f, -1.88788652e-01f,
  -8.75610933e-02f, -2.39701837e-01f, -8.15540478e-02f, 2.83886660e-02f, 6.00443548e-03f, 2.41659693e-02f, -1.05720356e-01f, 3.87742549e-01f, 2.33419940e-01f, -8.11778232e-02f,
  -6.02072328e-02f, -1.23231404e-01f, -1.80421114e-01f, -3.37423801e-01f, -2.62947798e-01f, -1.77314967e-01f, 5.99692948e-03f, 5.32510467e-02f, 1.47899523e-01f, 1.82100683e-01f,
  -1.12439431e-01f, -1.06684685e-01f, 8.26134086e-02f, -1.44891322e-01f, 1.30720392e-01f, -9.99287739e-02f, 1.38644576e-01f, -1.67168424e-01f, -1.36761785e-01f, -1.21779732e-01f,
  -5.83722861e-03f, 1.24248557e-01f, -1.50538310e-01f, -1.74157605e-01f, 9.99890193e-02f, -1.86310243e-02f, 2.64687557e-02f, -8.31912085e-02f, 8.39090347e-02f, 8.15498009e-02f,
  6.78165779e-02f, 1.15699256e-02f, 1.86913386e-01f, 5.35143912e-02f, -5.89998104e-02f, 1.35082915e-01f, -1.35579482e-01f, 5.28159104e-02f, 2.33608365e-01f, -1.84914488e-02f,
  -6.86870813e-02f, -1.41186044e-01f, 1.16402373e-01f, -1.95877492e-01f, 3.31142694e-01f, -2.71472603e-01f, 1.40042201e-01f, 4.66261655e-02f, 2.85143852e-01f, 1.65111870e-01f,
  1.80415064e-01f, -1.60026550e-01f, -1.59291938e-01f, -5.92493713e-02f, 1.19511932e-01f, 2.37375796e-01f, -4.72943000e-02f, -4.04797643e-02f, -4.42375354e-02f, -3.74769680e-02f,
  7.85679445e-02f, 1.98307991e-01f, -3.39470834e-01f, 2.32448369e-01f, 1.09378576e-01f, -8.30666870e-02f, 1.48148447e-01f, -7.12703988e-02f, -1.33827294e-03f, 2.41353288e-01f,
  -6.31619990e-02f, -1.51086017e-01f, -7.44698867e-02f, -3.26202631e-01f, 4.60806042e-02f, -2.40865517e-02f, -1.61992628e-02f, 1.61558449e-01f, -5.06837256e-02f, 1.44034140e-02f,
  1.36960866e-02f, 1.23308338e-01f, -5.01255170e-02f, -1.99459180e-01f, 7.00703785e-02f, -2.93111145e-01f, -2.76242465e-01f, 1.55322291e-02f, 2.76377331e-02f, -1.02398947e-01f,
  -1.47125602e-01f, 2.33635902e-01f, 7.29694171e-03f, -2.02565491e-02f, -1.99476317e-01f, -3.49723138e-02f, -3.29988331e-01f, -5.12010120e-02f, -1.76469833e-01f, 4.60272580e-02f,
  -1.43549100e-01f, -5.90936095e-02f, -6.39842302e-02f, 1.89483777e-01f, -2.95167357e-01f, 1.79242224e-01f, -1.62588894e-01f, 2.83500791e-01f, 6.11444004e-02f, 2.20568761e-01f,
  6.57504424e-02f, -1.60389245e-02f, -2.62053043e-01f, -1.77551061e-01f, -1.21072471e-01f, -3.28809708e-01f, 5.79847693e-02f, -3.79772671e-02f, -1.62956432e-01f, -3.17831427e-01f,
  2.34514266e-01f, 2.59639435e-02f, 1.27086505e-01f, 8.95408355e-03f, 1.62939578e-01f, 4.07487564e-02f, 4.17145193e-02f, 1.14066184e-01f, -5.62895834e-02f, -1.37105927e-01f,
  -1.19104855e-01f, 2.34582033e-02f, 1.22436285e-01f, -1.24488719e-01f, -8.45934600e-02f, 3.04188699e-01f, -9.30981115e-02f, 1.34322673e-01f, 2.67433822e-01f, -1.60902530e-01f,
  -1.64831132e-01f, -1.90320462e-01f, 1.35532450e-02f, 9.39853340e-02f, -1.41595721e-01f, 1.12329125e-01f, 1.20179139e-01f, 4.22910750e-02f, 2.15164870e-02f, 1.71504617e-01f,
  1.85848102e-01f, 2.26553708e-01f, -1.99321538e-01f, -5.07270694e-02f, 9.44047123e-02f, 1.25446200e-01f, -4.93448153e-02f, -1.09365165e-01f, -2.04998270e-01f, 1.28913922e-02f,
  -2.13092908e-01f, -2.35319287e-02f, 1.57867730e-01f, 2.38097776e-02f, 4.62343218e-03f, 1.98810622e-01f, 2.22695880e-02f, -5.87406568e-02f, -2.77111679e-01f, 1.96877822e-01f,
  -5.42941839e-02f, 5.18910736e-02f, -1.12814933e-01f, 6.07552901e-02f, -2.40944270e-02f, 2.51412123e-01f, -2.00946048e-01f, -3.55217844e-01f, -3.06908190e-01f, -1.32191196e-01f,
  2.18919128e-01f, 6.77048489e-02f, -8.09581205e-02f, -2.92457759e-01f, 1.36854038e-01f, -1.96490020e-01f, -1.91258434e-02f, 2.02546686e-01f, -5.35147041e-02f, 2.66318321e-01f,
  1.08820483e-01f, -1.80300772e-01f, -5.30957766e-02f, -1.78532600e-01f, -1.88559324e-01f, 9.26096886e-02f, -2.47157216e-01f, -7.16399848e-02f, -1.83520213e-01f, -1.33746237e-01f,
  1.14492066e-01f, 3.56842965e-01f, -1.25850663e-01f, 2.28525735e-02f, 7.41971880e-02f, -2.01078147e-01f, 1.26698092e-01f, -1.23132477e-02f, 4.10905890e-02f, 6.03762306e-02f,
  3.30919176e-01f, 3.03571939e-01f, -1.15267811e-02f, 4.93352115e-02f, 1.20560743e-01f, -2.20938362e-02f, 2.19903365e-01f, 1.54088512e-01f, 1.17392793e-01f, 3.16575058e-02f,
  7.52240866e-02f, 2.07103923e-01f, -1.83442719e-02f, 2.03097716e-01f, 2.09407687e-01f, 6.17147312e-02f, 1.07423365e-01f, 1.66842882e-02f, 3.97450253e-02f, -4.77499403e-02f,
  1.64413694e-02f, 3.25680017e-01f, 1.68914735e-01f, -1.33724496e-01f, 3.69541831e-02f, -2.01256886e-01f, 2.05603894e-02f, -9.34647843e-02f, 9.17934477e-02f, -3.34031805e-02f,
  6.67191893e-02f, 8.46767873e-02f, 2.24270090e-01f, 6.81674555e-02f, -2.00046152e-01f, -1.81675166e-01f, 1.36075586e-01f, 1.91628367e-01f, 9.54494476e-02f, -6.13782834e-03f,
  -2.81453997e-01f, 5.52456975e-02f, 8.73749629e-02f, 1.09164953e-01f, -1.24005765e-01f, -3.42281871e-02f, -2.27110181e-02f, -2.96023060e-02f, 3.91783714e-02f, 2.19454437e-01f,
  6.10478930e-02f, -1.99109614e-01f, -1.83989499e-02f, 1.52748734e-01f, -2.25506034e-02f, 7.29289874e-02f, 3.75998095e-02f, 2.21667960e-01f, -1.94839850e-01f, 3.00032705e-01f,
  -1.77061573e-01f, -2.32270226e-01f, -3.44021320e-02f, 1.08451784e-01f, -2.04666466e-01f, -2.14464679e-01f, 5.80083020e-02f, -4.31206822e-02f, -1.80096909e-01f, -4.88096252e-02f,
  1.27989769e-01f, -4.61161435e-02f, -2.41681576e-01f, -6.37362003e-02f, -4.31922562e-02f, -1.08428821e-01f, 2.95884550e-01f, 7.21012056e-03f, -2.14386657e-01f, 7.63524743e-03f,
  -1.75590232e-01f, -1.88055206e-02f, -1.36884570e-01f, -1.90866724e-01f, -2.76912838e-01f, -1.31861150e-01f, -1.76681623e-01f, 1.32490367e-01f, 1.66626766e-01f, 2.11227804e-01f,
  -2.17317209e-01f, -3.40237506e-02f, 6.65522963e-02f, -1.53500363e-02f, -1.11100271e-01f, -5.15473001e-02f, -1.65272534e-01f, 4.16262075e-03f, -1.89124033e-01f, 1.48620144e-01f,
  -7.61443526e-02f, -1.25321984e-01f, -4.88830134e-02f, 2.72735022e-02f, 1.24288157e-01f, -9.27554816e-02f, 3.90549600e-01f, -4.05872352e-02f, -6.98259985e-03f, 4.71879840e-02f,
  1.97061807e-01f, -1.54871807e-01f, -1.31774647e-02f, -2.12626502e-01f, 1.62314847e-01f, 2.50123143e-01f, 1.90873221e-01f, 5.89488745e-02f, 1.40463635e-01f, -3.27417143e-02f,
  1.19003616e-01f, -2.18456268e-01f, 2.63673812e-01f, -1.12307020e-01f, 1.11019745e-01f, 1.79253727e-01f, 5.12142591e-02f, -1.29693165e-01f, 7.86204860e-02f, -1.65347904e-01f,
  1.75691396e-01f, 8.57598260e-02f, -3.05501488e-03f, 7.97457695e-02f, 2.35543385e-01f, -1.31906688e-01f, 6.26105890e-02f, -1.86006740e-01f, 1.07662648e-01f, 3.30669247e-02f,
  8.47061798e-02f, -5.08332178e-02f, 1.24248192e-01f, 1.19404532e-01f, 1.27607614e-01f, -4.83130552e-02f, -1.35556713e-01f, 2.44965389e-01f, 3.13784838e-01f, -1.60978079e-01f,
  -1.38416156e-01f, 4.89277869e-01f, 2.48817608e-01f, -9.26467255e-02f, 6.20203763e-02f, -1.58560380e-01f, 1.68990679e-02f, -1.44847974e-01f, -2.77686954e-01f, 3.72659117e-01f,
  4.58126254e-02f, -1.49435923e-01f, 8.42969865e-02f, 8.97599035e-04f, 1.91074386e-02f, 1.69437215e-01f, 1.81242377e-02f, 7.72677967e-03f, 2.61005282e-01f, -7.98857585e-02f,
  -1.06888376e-02f, -8.26929882e-02f, 1.48975074e-01f, 1.86909944e-01f, 3.05508167e-01f, -3.44561189e-01f, -1.87102064e-01f, 9.46543738e-02f, 4.92771454e-02f, -4.43871543e-02f,
  -6.73952105e-04f, 2.67886668e-01f, 7.10047185e-02f, -2.53495593e-02f, -2.22052976e-01f, -1.59309864e-01f, -8.12543631e-02f, -6.48424923e-02f, -2.19104392e-03f, -6.85608834e-02f,
  -2.07934469e-01f, 8.82249512e-03f, -1.81333214e-01f, 1.16251737e-01f, -2.41404414e-01f, 1.44465804e-01f, 1.64060965e-01f, 1.03275478e-01f, 1.17155857e-01f, 6.29314035e-02f,
  -2.10148498e-01f, 4.17869575e-02f, -1.20633483e-01f, -9.45357978e-02f, 2.43131280e-01f, -1.16193630e-01f, 1.90798506e-01f, 2.68562704e-01f, -3.49907540e-02f, -2.65142024e-01f,
  4.88799885e-02f, -1.06300049e-01f, -2.26826176e-01f, 1.45054966e-01f, -1.49801835e-01f, -1.09736405e-01f, -9.60353315e-02f, -1.32897094e-01f, 1.48233458e-01f, -1.99195266e-01f,
  1.78897351e-01f, -1.39348581e-01f, -1.94645017e-01f, -3.09258044e-01f, 1.14416972e-01f, 2.03665316e-01f, 2.29496434e-02f, 2.59104013e-01f, -2.25925520e-02f, -4.11822237e-02f,
  -1.88068673e-01f, -8.75695646e-02f, 3.04204732e-01f, 1.89642847e-01f, -1.00911364e-01f, -3.79738444e-03f, -1.17971197e-01f, -4.00874875e-02f, 4.04485911e-02f, -9.47974250e-03f,
  2.24846244e-01f, -1.66281592e-02f, 1.10499144e-01f, -1.14172492e-02f, -8.99324659e-03f, -1.61083058e-01f, -1.85101360e-01f, -2.56651521e-01f, -2.61750109e-02f, 2.26234138e-01f,
  9.84639153e-02f, -1.35175377e-01f, 1.44434106e-02f, 2.13978942e-02f, -4.45423611e-02f, 1.27851084e-01f, 2.38052872e-03f, 3.18416715e-01f, -1.24950759e-01f, 1.51307225e-01f,
  3.15081388e-01f, -1.51646165e-02f, -9.70476940e-02f, 1.36952832e-01f, 1.56033739e-01f, 1.44251017e-02f, -8.89064074e-02f, -1.25131711e-01f, -2.04098567e-01f, 1.25106409e-01f,
  2.31076777e-01f, 2.36527249e-01f, 9.93796736e-02f, -1.87350109e-01f, 1.36987150e-01f, 1.83466449e-02f, -2.33559132e-01f, 1.65600210e-01f, -1.78715721e-01f, -2.46534180e-02f,
  -6.93104938e-02f, -1.35289341e-01f, -1.44349098e-01f, 2.86787122e-01f, 2.22972199e-01f, 1.95108235e-01f, -1.59109220e-01f, -1.46683514e-01f, -2.90939033e-01f, 2.46412560e-01f,
  1.73685119e-01f, 4.02201675e-02f, 3.08780707e-02f, -2.19396636e-01f, 1.01024814e-01f, 7.93214068e-02f, 3.13556157e-02f, -7.90267885e-02f, -2.47326177e-02f, 2.17944756e-01f,
  1.21299853e-03f, -3.64954740e-01f, -3.39137405e-01f, -3.09477020e-02f, -1.57037154e-01f, 7.19969198e-02f, 1.60598800e-01f, -2.07867756e-01f, -2.26055413e-01f, -1.12700008e-01f,
  5.84020801e-02f, 4.14114237e-01f, -6.55725673e-02f, -6.03260994e-02f, 1.16786495e-01f, 1.60776898e-01f, 8.25265050e-02f, -1.52574256e-01f, 2.01960742e-01f, 1.71593636e-01f,
  1.05164334e-01f, -1.77684929e-02f, 2.02460811e-01f, -3.48909125e-02f, 4.55402723e-03f, 7.33635807e-03f, -4.13575880e-02f, -1.46505907e-01f, 1.48724496e-01f, 4.07777071e-01f,
  -1.55277938e-01f, 2.04185873e-01f, -1.60219818e-01f, 7.41617680e-02f, 2.46158820e-02f, -9.74182934e-02f, -1.22708760e-01f, -1.20214443e-03f, 1.13909185e-01f, 4.64317769e-01f,
  -2.05570236e-02f, -5.78976981e-02f, -3.10754746e-01f, 1.31760627e-01f, -7.40011223e-03f, -2.40274355e-01f, -3.75928096e-02f, 2.99978524e-01f, 3.24590027e-01f, 1.35875866e-01f,
  3.25873584e-01f, 4.93151955e-02f, -1.73309743e-02f, 9.52299535e-02f, 8.24810192e-02f, -1.91459566e-01f, -4.62686926e-01f, 5.23101278e-02f, 1.00556158e-01f, -2.03666836e-03f,
  -8.22665989e-02f, 2.91504990e-02f, 1.52105004e-01f, 4.70869690e-01f, 3.53600770e-01f, -1.14932626e-01f, -2.86063492e-01f, -5.11018075e-02f, 2.60168849e-03f, 4.11042832e-02f,
  -1.24161087e-01f, 1.06837630e-01f, -1.31090283e-01f, -1.27092361e-01f, -5.03479242e-02f, 2.32651293e-01f, 3.67630184e-01f, -2.60732900e-02f, -2.35363677e-01f, -6.05886988e-02f,
  -6.97406530e-02f, -4.02890295e-02f, -8.17135051e-02f, -3.95126343e-02f, 8.45064744e-02f, 2.10698675e-02f, -8.76615569e-02f, 1.45898372e-01f, 3.40260006e-02f, 2.08534390e-01f,
  -4.85537909e-02f, 1.56964913e-01f, 1.33835874e-03f, 8.14189091e-02f, 1.78423375e-01f, -6.30143061e-02f, -1.31562110e-02f, -1.57680482e-01f, -3.82893950e-01f, -4.09961194e-01f,
  -1.17762692e-01f, -3.04529518e-01f, -1.59372203e-02f, -2.32573524e-01f, -2.93533742e-01f, 3.71655077e-02f, 3.96812595e-02f, 8.68169665e-02f, -6.04127198e-02f, 2.64684647e-01f,
  -1.41022176e-01f, 6.17669374e-02f, -9.23914388e-02f, -4.80098352e-02f, -1.17894530e-01f, -1.09360829e-01f, -3.10157955e-01f, 1.49973273e-01f, -3.79597872e-01f, 3.04608345e-02f,
  7.93272164e-03f, -9.10061598e-02f, -4.31178361e-01f, -9.63985175e-03f, 8.73005837e-02f, 1.59057274e-01f, -1.91340059e-01f, -3.97156835e-01f, 1.69973716e-01f, -1.34347394e-01f,
  1.24333084e-01f, -2.11045012e-01f, 1.61680967e-01f, 3.88747454e-02f, -6.76922798e-02f, 2.19429716e-01f, 2.15708554e-01f, 8.45656097e-02f, 5.51988967e-02f, -2.22585443e-02f,
  -1.16495550e-01f, 1.66513585e-02f, -2.14963645e-01f, -2.29481310e-01f, -2.07445368e-01f, 1.46608362e-02f, -1.33918047e-01f, -1.00979976e-01f, 2.18331829e-01f, 3.03089827e-01f,
  1.15328766e-01f, -9.91296992e-02f, 2.22606450e-01f, 1.72018960e-01f, -4.93857898e-02f, 2.18692452e-01f, -1.27178561e-02f, 3.02217919e-02f, -4.31777202e-02f, -9.85344499e-02f,
  -1.02336317e-01f, -1.38960600e-01f, 7.87798688e-02f, 5.55029437e-02f, -6.23820126e-02f, -2.17371628e-01f, 1.70010179e-01f, -3.20132077e-01f, 1.70826286e-01f, -1.11668995e-02f,
  1.03910953e-01f, -9.72574428e-02f, -2.93648876e-02f, 3.04288659e-02f, -1.51221156e-01f, 1.24279797e-01f, -2.22500667e-01f, -1.92671761e-01f, 1.35766134e-01f, -3.75348926e-01f,
  -1.20976582e-01f, 1.21610895e-01f, 2.97783881e-01f, 4.56219614e-02f, 8.80006850e-02f, -9.02971160e-03f, 2.35649303e-01f, 2.03200430e-01f, 1.48434602e-02f, 3.46976966e-02f,
  -8.14749599e-02f, -5.39348610e-02f, -7.14149475e-02f, -1.09267451e-01f, -2.65816242e-01f, 3.00727010e-01f, -1.82035238e-01f, 1.40056401e-01f, 2.84512132e-01f, -2.09554225e-01f,
  8.79040211e-02f, 4.84070927e-02f, 2.72008944e-02f, -4.41905856e-02f, -2.11915448e-01f, 1.53967887e-01f, -2.18844023e-02f, -8.38733390e-02f, -1.20122619e-01f, 1.61072865e-01f,
  9.74069238e-02f, 9.16118324e-02f, 2.77624160e-01f, 1.86758161e-01f, 2.46552140e-01f, 9.29164048e-03f, 2.64052272e-01f, 9.33352113e-02f, -5.28254621e-02f, 7.02451319e-02f,
  1.51230648e-01f, 2.26010084e-02f, 1.09466039e-01f, 5.87092675e-02f, -8.45789015e-02f, -1.25967013e-02f, 8.63302127e-02f, -1.39873903e-02f, 1.94767918e-02f, 1.14971876e-01f,
  5.19327521e-02f, 4.05530035e-02f, 1.59350559e-01f, -1.80902377e-01f, 2.35140488e-01f, 4.41079289e-02f, 3.05854511e-02f, -2.07913190e-01f, 1.77317992e-01f, -3.01311091e-02f,
  5.35138417e-03f, -8.30027014e-02f, -1.53201833e-01f, 1.32319525e-01f, 1.82403505e-01f, 4.29725647e-02f, 3.94854039e-01f, -5.22648469e-02f, 5.71785457e-02f, -4.21528034e-02f,
  1.33089721e-01f, 1.20002799e-01f, 7.25074299e-03f, -5.88420182e-02f, -3.49226803e-01f, 8.70866328e-02f, 1.92907572e-01f, -2.76253253e-01f, 7.87167251e-03f, -1.96230128e-01f,
  3.08835786e-03f, 1.27011880e-01f, -1.50587395e-01f, -3.18227075e-02f, -1.34983554e-01f, 3.25750336e-02f, 3.33579965e-02f, 1.22980699e-01f, -1.36031434e-01f, 1.51001066e-01f,
  -2.17833258e-02f, 2.28111506e-01f, -3.07221442e-01f, -1.45901933e-01f, 2.25066662e-01f, 8.35202932e-02f, 3.73260095e-03f, 2.01136947e-01f, -1.16031162e-01f, -6.72786832e-02f,
  1.57558456e-01f, -1.32417649e-01f, -3.24110948e-02f, -5.05686961e-02f, 6.71202987e-02f, 3.47650535e-02f, -2.51791961e-02f, -7.82785192e-02f, -4.89438809e-02f, 4.55176607e-02f,
  3.23711783e-02f, -1.72241643e-01f, 1.07206412e-01f, 2.83061743e-01f, -3.07415128e-01f, -2.63122529e-01f, 6.59751222e-02f, -7.30469599e-02f, 5.50455181e-03f, -3.77140671e-01f,
  -1.87312752e-01f, -7.13843182e-02f, 3.06621678e-02f, -1.85627028e-01f, -1.08260490e-01f, -1.71939433e-01f, 2.04070821e-01f, 4.34146613e-01f, 2.86751568e-01f, -1.79210141e-01f,
  -4.69619483e-01f, -2.00976074e-01f, 1.10185236e-01f, 2.65689373e-01f, 1.18022285e-01f, 1.32730901e-01f, 7.35774040e-02f, -7.62146711e-02f, -1.00720279e-01f, -1.24699347e-01f,
  -2.06606627e-01f, 2.40178123e-01f, -6.44058958e-02f, 1.88029766e-01f, 2.66254544e-01f, -8.62733647e-03f, 2.34104842e-01f, -1.49639830e-01f, 3.40275764e-02f, -8.26624706e-02f,
  -5.90571295e-03f, -9.31376144e-02f, -6.44530449e-03f, 9.06434730e-02f, -2.77342312e-02f, 3.66787970e-01f, -8.52380916e-02f, 2.29694188e-01f, -1.74309522e-01f, -4.05933261e-02f,
  8.40984210e-02f, 1.93505794e-01f, -1.65204048e-01f, -3.48696113e-02f, -5.47300428e-02f, 7.67343193e-02f, 5.82527295e-02f, -7.92125091e-02f, -2.24759683e-01f, 6.48243076e-05f,
  -2.63863355e-01f, -8.63702074e-02f, 1.29266933e-01f, -2.51471132e-01f, 1.83985487e-01f, 1.82293370e-01f, -5.54645434e-02f, -1.91036463e-01f, -3.30304168e-02f, -1.61376558e-02f,
  -4.94711809e-02f, -2.94748545e-02f, -2.95402080e-01f, 2.83326339e-02f, 1.15247726e-01f, -9.11611840e-02f, -1.00029454e-01f, -9.96258035e-02f, 1.83787886e-02f, -9.01201926e-03f,
  4.81909886e-02f, -1.07504893e-02f, -4.63822961e-01f, 2.46309489e-01f, 1.19244836e-01f, 1.72034621e-01f, -2.09375098e-01f, 1.79669857e-01f, -2.28503346e-01f, -9.92158502e-02f,
  -2.67128617e-01f, -1.20813958e-01f, -3.90941481e-04f, -8.44430253e-02f, 1.13520540e-01f, -1.33658558e-01f, -6.81349076e-03f, 2.14707926e-02f, -4.29348573e-02f, 1.74402878e-01f,
  3.14362526e-01f, -1.02932341e-01f, -3.32615757e-03f, 1.09656751e-01f, 1.38826847e-01f, 9.88582149e-02f, 1.06779806e-01f, 1.21879339e-01f, 1.07731409e-01f, -3.50807488e-01f,
  5.89836873e-02f, 1.00058176e-01f, -1.80190969e-02f, -6.00662194e-02f, -1.37120008e-01f, -2.06425101e-01f, 1.35271192e-01f, 6.10429458e-02f, -6.30965307e-02f, -3.45727131e-02f,
  -7.12981001e-02f, -2.69912153e-01f, -3.74533162e-02f, -1.23602703e-01f, 2.27003358e-02f, -1.08955920e-01f, 3.98280583e-02f, 1.52360007e-01f, 1.63498119e-01f, 1.30522713e-01f,
  8.26317146e-02f, 2.80386776e-01f, -7.87406287e-04f, 1.04223154e-01f, 2.33532310e-01f, -1.64479762e-01f, 9.01818052e-02f, 1.06940176e-02f, 5.68443686e-02f, -6.16330579e-02f,
  2.51978457e-01f, 1.83672942e-02f, 1.43897906e-01f, -1.34192988e-01f, -4.64413129e-02f, 3.91514599e-01f, 2.43638322e-01f, -1.50278538e-01f, -7.09380507e-02f, 4.06549312e-02f,
  -3.81162502e-02f, 3.21686149e-01f, -4.31907624e-02f, 8.08674172e-02f, 3.07472479e-02f, -2.14202896e-01f, 2.72413995e-02f, -2.01236323e-01f, -3.11168730e-01f, 3.08508158e-01f,
  2.27029547e-01f, -6.51996434e-02f, 2.41301790e-01f, -4.16061372e-01f, -9.09549445e-02f, 3.02099168e-01f, 1.71751022e-01f, 2.32804324e-02f, -1.27097830e-01f, 5.61524443e-02f,
  -1.20184571e-01f, 1.04772728e-02f, 4.07977477e-02f, 2.35786200e-01f, 6.23476878e-02f, -2.23944589e-01f, 6.56186119e-02f, -1.01656571e-01f, 8.51869881e-02f, -2.94128388e-01f,
  -6.69066906e-02f, -7.32584372e-02f, -2.72748798e-01f, -9.07693356e-02f, 1.20972097e-02f, -6.48709834e-02f, -1.97737157e-01f, 2.72762701e-02f, -9.96789634e-02f, -1.95889145e-01f,
  1.35932669e-01f, -1.11966103e-01f, -1.74162090e-01f, 8.29402804e-02f, -4.23598215e-02f, 2.66862661e-01f, -7.53803626e-02f, 1.55159593e-01f, 9.15317796e-03f, 1.08494878e-01f,
  8.74061425e-06f, -3.05607051e-01f, -1.53549686e-01f, 1.12919614e-01f, -1.61194447e-02f, -2.29877174e-01f, -2.69369539e-02f, -2.10113693e-02f, 3.15855265e-01f, -7.45667564e-03f,
  2.97936559e-01f, 1.91565063e-02f, -2.86365092e-01f, 1.02250248e-01f, 1.85839668e-01f, -7.45400190e-02f, 2.19182894e-01f, 2.32448559e-02f, -1.82731792e-01f, 1.26425162e-01f,
  2.79204160e-01f, -1.01844594e-01f, -2.83653259e-01f, 1.92632765e-01f, 2.18752697e-01f, 6.46995082e-02f, 8.83257762e-02f, -1.75159141e-01f, -2.06996903e-01f, 3.12650591e-01f,
  1.63765594e-01f, -7.86889791e-02f, 1.26557678e-01f, 7.99132064e-02f, -6.15370087e-02f, -1.78542882e-01f, 3.63590121e-01f, 2.18425527e-01f, -1.04286455e-01f, -3.70818451e-02f,
  1.10196583e-02f, -1.14374653e-01f, 1.12690911e-01f, -3.62981223e-02f, -1.02614194e-01f, -4.29249555e-02f, -5.30509651e-02f, 2.03251153e-01f, -1.59089297e-01f, 1.10488115e-02f,
  -9.53665972e-02f, 5.44676669e-02f, 3.78962383e-02f, 1.50176644e-01f, -7.59581774e-02f, 1.40072763e-01f, 1.13810852e-01f, 1.39954701e-01f, 3.66307139e-01f, 3.00939590e-01f,
  -2.20333695e-01f, 8.58943537e-02f, -6.88990131e-02f, 7.33026117e-02f, 3.04952681e-01f, -4.43779863e-02f, 1.87479451e-01f, 1.10703960e-01f, -1.33268729e-01f, -3.43365878e-01f,
  -2.59424224e-02f, 2.19436139e-01f, -1.70409025e-04f, 2.84854144e-01f, -2.79664755e-01f, 1.42450199e-01f, -1.09538443e-01f, -2.16274217e-01f, 2.52264202e-01f, -1.17569594e-02f,
  4.15593050e-02f, 1.96504146e-01f, -3.98900330e-01f, 4.88674901e-02f, -9.35953856e-02f, -1.60959825e-01f, -2.21092571e-02f, 8.29111412e-02f, -8.87641385e-02f, 2.49114379e-01f,
  -1.48939103e-01f, -6.36167452e-02f, -1.85309261e-01f, 1.86735988e-02f, 4.40016435e-03f, -1.01855651e-01f, 3.21575612e-01f, 1.56861648e-01f, -3.99081931e-02f, -1.18031008e-02f,
  2.95800269e-01f, 1.51459113e-01f, 2.23107696e-01f, -6.22481927e-02f, -3.20459194e-02f, -1.79454181e-02f, 5.61961457e-02f, 2.12546781e-01f, 2.58317977e-01f, 1.65575534e-01f,
  1.72540471e-01f, 1.15724432e-03f, 1.67823821e-01f, -1.79042146e-01f, -1.05052412e-01f, 9.95506346e-02f, 1.26815334e-01f, 2.68227533e-02f, 1.55553401e-01f, -1.06845692e-01f,
  -4.12086882e-02f, 1.22449443e-01f, 7.83783272e-02f, -1.11724257e-01f, 1.43240288e-01f, 3.53299342e-02f, 1.07692823e-01f, -8.45800713e-02f, -2.37664089e-01f, 1.09295182e-01f,
  2.09033877e-01f, -2.59032041e-01f, -1.18686378e-01f, -1.96927026e-01f, 1.11657336e-01f, 1.38207087e-02f, -1.06168553e-01f, 1.79732904e-01f, -1.59217685e-01f, 1.86809003e-02f,
  3.62959176e-01f, 2.38507897e-01f, -1.57080814e-01f, 2.42450446e-01f, -4.30334717e-01f, -6.84203114e-03f, -3.19887459e-01f, 1.17086090e-01f, 2.25455761e-01f, 9.34236050e-02f,
  6.37441054e-02f, -1.18979169e-02f, 3.04374814e-01f, -4.93221208e-02f, -1.31191418e-01f, -1.73814073e-02f, -2.17139021e-01f, -2.23121360e-01f, -2.57497668e-01f, -4.93427068e-02f,
  1.42703250e-01f, 2.47609869e-01f, -9.51447487e-02f, 3.01462233e-01f, 8.69951583e-03f, -5.94471171e-02f, -7.31946155e-02f, -1.57598704e-01f, -1.04868665e-01f, -1.05851233e-01f,
  8.90660435e-02f, -3.58761549e-02f, -7.06392378e-02f, -4.97593693e-02f, -1.18722156e-01f, 5.47636040e-02f, -7.14089498e-02f, -1.33086517e-01f, -2.48456031e-01f, -4.86204773e-02f,
  8.15377608e-02f, -2.01448068e-01f, 1.38992012e-01f, -2.30252787e-01f, -3.97248380e-02f, 9.86097828e-02f, -4.12191562e-02f, -1.52816027e-01f, 1.56266063e-01f, 6.80552199e-02f,
  -8.13628584e-02f, 1.76956654e-01f, -8.04384276e-02f, -2.05239877e-01f, -1.51801214e-01f, -2.60014255e-02f, 9.92908236e-03f, 6.06110729e-02f, -4.30002928e-01f, -2.12109700e-01f,
  3.39075118e-01f, -1.79758295e-01f, -6.12511896e-02f, 5.26504740e-02f, 7.98225105e-02f, 2.81174749e-01f, -4.86371331e-02f, -1.66429691e-02f, -1.15669511e-01f, 1.02491431e-01f,
  1.82620417e-02f, 6.28805086e-02f, 1.47023559e-01f, -1.32079452e-01f, -2.93352306e-01f, 1.12318330e-01f, 1.00014977e-01f, 7.61216208e-02f, 1.54886439e-01f, 1.16955847e-01f,
  -1.65289238e-01f, 2.01421037e-01f, 9.73363500e-03f, -5.08809404e-04f, -2.16445580e-01f, -7.84060359e-02f, -1.75516456e-01f, 1.21971350e-02f, -6.33374974e-02f, -5.40187173e-02f,
  -7.73518384e-02f, -9.19554457e-02f, -4.22338909e-03f, 2.44769320e-01f, -2.07792103e-01f, 3.08649540e-01f, 7.00055156e-03f, -2.88426541e-02f, 1.29867375e-01f, -5.40214255e-02f,
  2.01334003e-02f, 1.73444703e-01f, 2.30967075e-01f, 1.23739079e-01f, 8.70684385e-02f, 7.22555444e-02f, 1.44496694e-01f, -3.81126776e-02f, 3.88369374e-02f, -4.85448241e-02f,
  -2.32056126e-01f, 2.38668278e-01f, -9.90479067e-02f, 1.06628679e-01f, -2.24565461e-01f, 5.53788468e-02f, -1.47469014e-01f, 1.99842140e-01f, 2.39074692e-01f, -8.32663104e-02f,
  -1.55548275e-01f, 4.34784554e-02f, 4.70967442e-01f, -2.22863909e-02f, -4.17194337e-01f, 6.44852147e-02f, -5.58653250e-02f, 3.82067978e-01f, 1.37155890e-01f, -1.71278924e-01f,
  -3.82720083e-01f, 7.47588510e-03f, 1.74208984e-01f, -2.14361638e-01f, 5.47319390e-02f, -1.18421659e-01f, -4.77732271e-02f, 1.40430316e-01f, 3.05889487e-01f, -2.80164540e-01f,
  -1.49158165e-01f, -2.79020816e-01f, -1.29909977e-01f, -4.07721214e-02f, 2.58982062e-01f, 8.37745965e-02f, 8.01042840e-03f, 1.99875951e-01f, 2.91775137e-01f, -2.93336697e-02f,
  1.71114683e-01f, 7.97782540e-02f, 1.43995360e-01f, 7.60915652e-02f, 1.78440437e-01f, 1.94948450e-01f, 5.58304004e-02f, 8.68120864e-02f, -1.91804349e-01f, -1.06623389e-01f,
  -1.13561690e-01f, 4.95760143e-02f, 5.67201450e-02f, 1.32371187e-01f, -1.02155253e-01f, -3.36531848e-01f, 3.99246402e-02f, 3.50562781e-02f, -1.96373835e-02f, 1.82968250e-03f,
  -2.33108122e-02f, -2.06119820e-01f, -5.06970957e-02f, 1.98824942e-01f, -1.32692024e-01f, -2.06871822e-01f, -1.61031798e-01f, 3.45981061e-01f, 4.89231944e-02f, -1.54280379e-01f,
  -5.00894070e-01f, 7.88671821e-02f, -3.03357244e-01f, -2.26644482e-02f, 7.73465112e-02f, 3.30132157e-01f, -1.71313390e-01f, 2.04837441e-01f, 2.03637004e-01f, -2.12022454e-01f,
  -1.28642842e-01f, 5.81306126e-03f, 2.03375995e-01f, 2.34217927e-01f, -2.30179012e-01f, -6.05744570e-02f, -1.18220923e-02f, 2.01483771e-01f, -8.95473510e-02f, 1.33721545e-01f,
  -1.41199976e-01f, 2.27847755e-01f, -1.93173103e-02f, 1.64730355e-01f, -1.80189833e-01f, -1.58751935e-01f, -8.82474557e-02f, -1.48513280e-02f, 4.06271853e-02f, 2.95471549e-01f,
  5.82424086e-03f, 3.57434712e-02f, 1.19013518e-01f, 6.66822866e-02f, -3.19238119e-02f, -6.01035729e-02f, 3.53529640e-02f, -4.19436485e-01f, 8.51901546e-02f, 1.77476838e-01f
};

// L2_fan_Wp_bar (Shape: 14 x 64)
const int L2_fan_Wp_bar_rows = 14;
const int L2_fan_Wp_bar_cols = 64;
const float L2_fan_Wp_bar_data[] = {
  -2.47704163e-01f, -2.56539464e-01f, -2.17796013e-01f, -8.89395103e-02f, -1.29363209e-01f, 1.20213397e-01f, -3.37903529e-01f, -2.11176217e-01f, 1.99886978e-01f, -3.34342152e-01f,
  -5.41133463e-01f, 3.56825814e-02f, -2.14425132e-01f, 3.66444401e-02f, 4.82320547e-01f, -1.11718439e-01f, 2.71155953e-01f, 1.57922342e-01f, -1.93405882e-01f, -4.59333628e-01f,
  -5.16473204e-02f, -2.95459360e-01f, -6.31329477e-01f, 1.50902212e-01f, -2.56950378e-01f, -1.91015437e-01f, 3.10881436e-01f, 2.34861434e-01f, -9.55517218e-03f, -2.13874027e-01f,
  4.64072615e-01f, -2.44647175e-01f, 1.64184533e-02f, 2.55891740e-01f, -1.16617948e-01f, 2.00071812e-01f, -3.38914633e-01f, 7.23593384e-02f, -2.43766919e-01f, 1.07606925e-01f,
  -7.55483508e-01f, -1.38084427e-01f, -1.37912720e-01f, 1.72966421e-01f, 4.97280687e-01f, -1.18384771e-01f, 4.13446538e-02f, 2.42409065e-01f, 1.12040251e-01f, 4.14194800e-02f,
  3.57395202e-01f, 2.06760183e-01f, -1.82386618e-02f, 3.05931956e-01f, 2.55203068e-01f, -2.34966278e-02f, -1.50236830e-01f, -8.71207751e-03f, 1.82419330e-01f, 1.37085781e-01f,
  2.89059635e-02f, 6.25157729e-02f, 1.67757839e-01f, 1.06842071e-01f, 1.59881249e-01f, 2.98807591e-01f, -1.35573357e-01f, 2.95579851e-01f, 1.21083148e-01f, 4.94133495e-02f,
  1.81293115e-01f, -8.17221701e-02f, -3.56151640e-01f, -3.04644912e-01f, 1.01386741e-01f, 2.89605767e-01f, 3.22957695e-01f, -8.90852287e-02f, -4.49476600e-01f, 1.84081718e-01f,
  -1.60225019e-01f, -9.64216962e-02f, -6.50136080e-03f, 1.45190552e-01f, 4.64298397e-01f, 3.63398641e-01f, 3.50967526e-01f, 2.15600729e-01f, -2.63334461e-03f, -2.92938352e-01f,
  -1.07315563e-01f, -2.21588582e-01f, -5.01068018e-04f, 2.46640831e-01f, -2.20769301e-01f, -3.28767262e-02f, 5.80937207e-01f, -4.28079873e-01f, 1.74757764e-02f, -2.72305965e-01f,
  1.53495193e-01f, 2.66109169e-01f, -1.52135352e-02f, 2.35823303e-01f, -2.45711774e-01f, -7.10489377e-02f, -2.87695050e-01f, 4.36313629e-01f, -1.49313867e-01f, 3.83467406e-01f,
  -1.80158421e-01f, 3.35148096e-01f, -6.95989370e-01f, 2.89423674e-01f, -5.68080060e-02f, 4.18596063e-03f, 1.80397063e-01f, -2.26666704e-01f, 4.38813902e-02f, -7.61930868e-02f,
  -7.50704184e-02f, 1.99035645e-01f, 7.00531453e-02f, 3.78905296e-01f, -7.79591054e-02f, -7.40156393e-04f, 1.01527125e-02f, 1.76681787e-01f, 1.44459214e-02f, -1.26109421e-01f,
  1.11283131e-01f, 4.32354352e-03f, 1.42322287e-01f, -1.37971453e-02f, -2.41644353e-01f, -1.40341103e-01f, 1.88429743e-01f, 2.20729306e-01f, 2.99489144e-02f, 3.48742194e-02f,
  -2.64281183e-01f, 3.36615928e-02f, 3.92965496e-01f, -2.65733041e-02f, 4.64896768e-01f, 8.08382556e-02f, 1.52944038e-02f, 3.25762987e-01f, -2.62322761e-02f, 1.10321507e-01f,
  -9.62643549e-02f, 1.70055732e-01f, 3.86288464e-02f, 3.66265327e-02f, 2.94395864e-01f, -2.37413153e-01f, 2.86862105e-01f, -3.03363115e-01f, 3.48632574e-01f, -1.44004390e-01f,
  -2.24718437e-01f, 4.38581973e-01f, 2.82048285e-01f, 3.09319824e-01f, 2.42126465e-01f, -2.21741766e-01f, -1.80097863e-01f, 2.01752428e-02f, 3.05196226e-01f, -8.76509622e-02f,
  3.39706242e-02f, -4.94673073e-01f, 2.23267257e-01f, -1.54381767e-01f, -1.44284308e-01f, -2.08476812e-01f, 3.76201421e-01f, -1.96826771e-01f, 2.99107045e-01f, 3.57207865e-01f,
  1.48525089e-01f, 5.48297107e-01f, 9.72252861e-02f, 1.88302785e-01f, -1.14058562e-01f, -7.90846627e-03f, 1.66950986e-01f, 1.71926051e-01f, 2.11288452e-01f, 3.68999988e-01f,
  -1.37753084e-01f, -8.25102534e-03f, 8.53849575e-02f, 4.62663978e-01f, -3.13981324e-01f, 3.55321258e-01f, 5.42658232e-02f, 1.39831513e-01f, 1.98599726e-01f, -2.16728523e-01f,
  6.70279860e-02f, -5.44047207e-02f, -2.34381586e-01f, 1.26599288e-02f, 2.76371747e-01f, 1.07084319e-01f, -3.01979870e-01f, 3.57855171e-01f, 3.04490149e-01f, 6.58456683e-02f,
  -3.17502558e-01f, 1.48315847e-01f, 1.19082808e-01f, 8.28769431e-02f, 2.14557368e-02f, 1.52344763e-01f, -2.77667403e-01f, -2.02590197e-01f, 4.90518883e-02f, -3.28277439e-01f,
  -1.42991841e-02f, -1.61992580e-01f, 3.95276934e-01f, 2.48531982e-01f, -1.08347803e-01f, 5.64018227e-02f, 1.99936241e-01f, -2.81885594e-01f, 2.28898168e-01f, -1.64085031e-01f,
  -3.91331613e-01f, -4.29796381e-03f, -1.39976561e-01f, -5.15672028e-01f, -6.53023794e-02f, 4.39456329e-02f, 2.16008395e-01f, 7.24982321e-01f, -1.15200523e-02f, 2.11261138e-01f,
  -2.58047819e-01f, -4.18554246e-02f, -1.81182370e-01f, -1.30119681e-01f, 1.71773434e-01f, -3.98131013e-01f, -7.05888867e-02f, -8.02635476e-02f, 4.54496853e-02f, -5.85401505e-02f,
  5.20856321e-01f, 3.30572277e-01f, -8.05868730e-02f, 3.74836087e-01f, 3.23141813e-01f, 3.82608443e-01f, 5.94863854e-02f, -2.19453022e-01f, -1.85571276e-02f, -4.92103361e-02f,
  -3.04533839e-01f, 3.79253086e-03f, 3.05487961e-02f, 6.11873716e-02f, -2.70696998e-01f, 1.31973535e-01f, -8.26662257e-02f, -5.94804250e-02f, -1.02983102e-01f, 2.63832778e-01f,
  -2.51146704e-01f, -1.56581342e-01f, 3.09832305e-01f, 1.59071460e-01f, 2.32161507e-01f, -2.44208537e-02f, -2.74761230e-01f, 4.30778176e-01f, 2.85650492e-01f, -1.54248595e-01f,
  -1.93325654e-02f, -7.59594217e-02f, -5.36597252e-01f, -2.13602424e-01f, 2.80887336e-01f, 3.28047752e-01f, -3.83530915e-01f, -1.12939499e-01f, 5.18960692e-02f, -2.89954454e-01f,
  -1.91110551e-01f, 2.39715651e-02f, -3.37600291e-01f, -1.82460651e-01f, 1.98952317e-01f, 4.57805842e-02f, 4.56777781e-01f, 1.23330757e-01f, 8.17310363e-02f, -1.05398498e-01f,
  -1.17092244e-01f, 4.59740579e-01f, -3.90222788e-01f, -1.19212950e-02f, -3.10141981e-01f, 2.13926345e-01f, -4.73409845e-03f, -5.95783368e-02f, 1.92726970e-01f, 2.44667470e-01f,
  8.58516898e-03f, 9.42236856e-02f, -6.65200502e-02f, -1.09664381e-01f, -7.98266456e-02f, -2.98895776e-01f, 6.60590753e-02f, -1.31260589e-01f, 9.02087614e-02f, -8.05758126e-03f,
  1.22779921e-01f, -1.05889052e-01f, 6.94303215e-02f, 3.75453293e-01f, 4.86883931e-02f, 3.06517750e-01f, 2.79310524e-01f, 1.20789900e-01f, 8.74524489e-02f, 1.53750330e-01f,
  2.75384545e-01f, 1.20922171e-01f, 2.27388754e-01f, 2.70752400e-01f, -3.75420414e-02f, -2.15656906e-01f, 2.48984814e-01f, 1.44356102e-01f, 2.01243550e-01f, -1.62933365e-01f,
  2.69739240e-01f, 4.89250302e-01f, 4.17249762e-02f, 3.06855619e-01f, -1.54208288e-01f, 2.30014443e-01f, 5.04252195e-01f, -5.36411822e-01f, 3.39070201e-01f, -2.28642479e-01f,
  1.49864122e-01f, 1.28333434e-01f, 2.10020095e-01f, -3.32886904e-01f, -1.92600802e-01f, -1.37435019e-01f, 5.68740070e-01f, 1.01293430e-01f, -8.89237002e-02f, 3.90446603e-01f,
  -5.86164951e-01f, 7.08632991e-02f, -3.44829857e-01f, 2.74925381e-01f, -3.45463365e-01f, 1.04369290e-01f, 2.03797713e-01f, -1.33207425e-01f, 1.15168825e-01f, -1.74481854e-01f,
  1.64494991e-01f, 3.15483719e-01f, -4.22399044e-01f, -6.90866634e-02f, -6.78122416e-02f, 2.22750768e-01f, 3.45123470e-01f, 5.76939881e-02f, 5.72680756e-02f, 4.60644662e-01f,
  -1.92370117e-01f, -9.80642438e-02f, -1.61883533e-01f, 1.38826624e-01f, 4.43362683e-01f, 1.60829559e-01f, 3.25453401e-01f, 4.00125325e-01f, 1.24852538e-01f, 2.20418990e-01f,
  5.45386970e-01f, 3.51190656e-01f, 1.00334324e-01f, 2.77749717e-01f, 3.36052954e-01f, 3.38916689e-01f, 2.12754771e-01f, 1.07744411e-01f, -2.52489597e-02f, 2.83177435e-01f,
  3.85219574e-01f, 4.80616957e-01f, 2.84913212e-01f, 2.56333560e-01f, -8.01049098e-02f, -1.41203567e-01f, 2.36640498e-01f, 2.11468995e-01f, 4.21409428e-01f, -2.15781137e-01f,
  1.72091857e-01f, 8.08445141e-02f, -2.55855471e-02f, -5.44556797e-01f, 2.45239809e-01f, 6.23889975e-02f, 4.31586653e-02f, 3.20804983e-01f, 2.24957526e-01f, 1.13209985e-01f,
  -2.31097490e-01f, -1.63609460e-01f, 6.31662130e-01f, 2.93417841e-01f, 1.39225125e-01f, 1.86461955e-01f, 3.32203670e-03f, 2.58665830e-01f, -5.46436012e-01f, -2.46299729e-01f,
  -1.14628434e-01f, -2.48154715e-01f, 9.31827053e-02f, -8.48953612e-03f, 3.15190136e-01f, -2.60907590e-01f, -9.64586139e-02f, -1.83127806e-01f, -1.52588272e-02f, -2.19124518e-02f,
  -7.81293735e-02f, -8.85842592e-02f, 1.23296916e-01f, 3.06618541e-01f, -2.41171435e-01f, 5.28993547e-01f, -1.40276119e-01f, -2.68975884e-01f, -1.04914285e-01f, 1.46530867e-01f,
  2.00806856e-01f, -7.96460919e-03f, 5.23662977e-02f, 2.47394398e-01f, 9.81761441e-02f, 1.09988116e-01f, -5.20979241e-02f, 2.18370855e-02f, -6.22492619e-02f, 7.09017040e-03f,
  -1.86192021e-01f, -1.12222299e-01f, 2.96854615e-01f, 2.97904104e-01f, 1.51182607e-01f, 2.28691533e-01f, 1.14937112e-01f, -2.23964632e-01f, 3.23869467e-01f, -5.68575487e-02f,
  1.73229828e-01f, 2.32937816e-03f, -4.35623154e-02f, 3.32628161e-01f, -4.38956261e-01f, -1.85300857e-02f, -3.21205854e-01f, 4.44214314e-01f, 8.03625137e-02f, 2.18544349e-01f,
  -1.60777792e-01f, -2.42464826e-01f, -4.23949510e-01f, 3.83077651e-01f, 2.31385410e-01f, 1.95331991e-01f, 1.18039832e-01f, -8.60261694e-02f, -9.60686803e-02f, 4.10332114e-01f,
  6.58594668e-02f, -1.58774659e-01f, 2.11194828e-01f, 1.59294695e-01f, 4.15709257e-01f, -3.58530492e-01f, -2.69615501e-01f, -1.31061032e-01f, -4.49957550e-01f, 1.21714242e-01f,
  3.76335144e-01f, -4.55727130e-02f, -1.50967479e-01f, 2.52043698e-02f, 1.99404851e-01f, 5.82706273e-01f, -6.42326614e-03f, 3.26723605e-01f, 3.64274204e-01f, -2.18018800e-01f,
  2.62720197e-01f, -2.71747559e-02f, 1.35629922e-01f, 4.14810330e-01f, -9.45994779e-02f, 1.71830699e-01f, 2.04168901e-01f, 2.23413169e-01f, 3.15817520e-02f, -4.95141372e-02f,
  1.13532551e-01f, -1.74216107e-01f, -1.26115516e-01f, 1.17866479e-01f, 1.85084894e-01f, 1.32268056e-01f, 1.12323701e-01f, -5.33238128e-02f, -4.00862038e-01f, -3.75308216e-01f,
  -2.45283350e-01f, -2.18948573e-01f, 8.68851021e-02f, -1.90672696e-01f, -3.16711634e-01f, 3.05466026e-01f, 2.54436672e-01f, -1.43946812e-01f, 1.10959224e-01f, 2.93429464e-01f,
  -2.30637416e-01f, 1.22171871e-01f, -1.03190579e-01f, 1.85751077e-02f, 4.96573508e-01f, 5.36528081e-02f, -5.90488606e-04f, -3.79187018e-02f, -4.31992024e-01f, -1.70430601e-01f,
  -6.74040467e-02f, -3.96774933e-02f, -4.22070734e-02f, -1.01564683e-01f, 1.85697839e-01f, 2.39256769e-01f, 1.80799022e-01f, -7.93920383e-02f, -1.29967136e-02f, -6.31393716e-02f,
  8.45205784e-02f, 1.89420149e-01f, 2.82359302e-01f, 5.22998907e-02f, 1.16364703e-01f, 1.41496494e-01f, 2.43733391e-01f, 1.84631735e-01f, -7.98602626e-02f, 7.02739283e-02f,
  2.18274966e-01f, 6.41263798e-02f, -2.60109961e-01f, 2.74461173e-02f, -2.63241917e-01f, 1.85558021e-01f, 3.20861101e-01f, 1.51577845e-01f, 1.53771073e-01f, 3.13352227e-01f,
  1.06359318e-01f, -2.22091779e-01f, 1.03753276e-01f, 2.04661950e-01f, -3.36722612e-01f, 5.81556819e-02f, 8.54048431e-02f, 3.80476654e-01f, 2.50475049e-01f, 7.98931196e-02f,
  -6.22792393e-02f, 3.73923033e-01f, -1.27012521e-01f, -1.64081976e-01f, 3.29843223e-01f, 4.71710712e-01f, 3.00685585e-01f, -2.49527339e-02f, -4.25146744e-02f, 3.33471686e-01f,
  2.35857666e-01f, -5.58026493e-01f, -2.89614409e-01f, 1.67471677e-01f, -1.11925416e-03f, 1.03658661e-01f, -5.12196660e-01f, -1.48487210e-01f, 6.67431653e-01f, -1.52234524e-01f,
  3.68583709e-01f, -3.59032601e-01f, -3.31697553e-01f, -2.22374752e-01f, 5.53403258e-01f, -8.34907666e-02f, 3.38557631e-01f, 2.78149366e-01f, -2.12975547e-01f, 1.08221591e-01f,
  -2.34604299e-01f, -9.43118185e-02f, -3.91875952e-01f, 1.03317142e-01f, -2.77502954e-01f, 5.46323776e-01f, 1.95819303e-01f, -1.36027415e-03f, 5.82765527e-02f, -1.68477356e-01f,
  1.99311152e-01f, -2.25388676e-01f, -1.67751536e-01f, 2.04146102e-01f, -3.05745360e-02f, 3.27399343e-01f, -1.80892155e-01f, 1.98581785e-01f, -4.79938090e-01f, 1.13553248e-01f,
  9.23360810e-02f, 1.33677721e-01f, -7.69909620e-02f, 3.59611928e-01f, 2.32649152e-03f, -7.46849030e-02f, 4.55263168e-01f, 1.65578678e-01f, -3.55659425e-01f, 1.65435374e-01f,
  1.24526888e-01f, -7.82871097e-02f, 5.56059718e-01f, 4.87668626e-02f, -7.72616327e-01f, 1.79585770e-01f, -2.74989545e-01f, -3.38425875e-01f, 4.16508347e-01f, 4.84100223e-01f,
  2.54263759e-01f, -6.32921606e-02f, 4.11778808e-01f, -6.67836098e-03f, 7.87621439e-02f, -2.55342662e-01f, -4.82583530e-02f, -4.13082764e-02f, -1.22908913e-01f, 1.49504706e-01f,
  -4.91709501e-01f, 5.74262813e-02f, 1.75547570e-01f, -1.00699201e-01f, 2.16888160e-01f, -7.69021332e-01f, -2.61984337e-02f, -2.36744344e-01f, 6.44022942e-01f, -9.33605134e-02f,
  2.39239912e-02f, -7.99974129e-02f, -8.64321664e-02f, 1.80076107e-01f, -7.30914712e-01f, -2.11013649e-02f, -3.09710234e-01f, 2.65031517e-01f, -9.61021110e-02f, 5.02234459e-01f,
  1.05174229e-01f, -3.20543274e-02f, 2.32637618e-02f, -3.88500035e-01f, 1.14714123e-01f, 6.34803250e-02f, 2.13814259e-01f, -1.55856371e-01f, -6.60453290e-02f, 2.16008171e-01f,
  -2.77933627e-01f, 1.42378911e-01f, 3.76480073e-01f, 2.60713488e-01f, 1.73582867e-01f, 2.33967230e-01f, -5.88156767e-02f, 3.01875055e-01f, 1.72036305e-01f, 7.60845616e-02f,
  2.76008546e-01f, 2.22195953e-01f, 3.05939615e-01f, 2.82337040e-01f, 3.79137188e-01f, 5.82320280e-02f, 2.40389079e-01f, 2.94758212e-02f, 1.17756408e-02f, 3.37657668e-02f,
  5.66228181e-02f, -7.73644820e-03f, 1.80417761e-01f, 1.23294316e-01f, -2.11050630e-01f, -7.16329180e-03f, 3.46022487e-01f, -8.27893987e-02f, 2.44929288e-02f, 1.83293700e-01f,
  1.11619560e-02f, 1.63389325e-01f, 1.29467383e-01f, -6.22747429e-02f, -8.25259611e-02f, -4.13467944e-01f, -4.77242887e-01f, -2.05726419e-02f, 2.57640064e-01f, -3.41878176e-01f,
  -3.44289511e-01f, -9.04668421e-02f, 3.73976111e-01f, -8.25252682e-02f, -6.94892332e-02f, -2.22103536e-01f, 5.52571714e-01f, 1.52828649e-01f, -2.30961487e-01f, -4.85016257e-01f,
  -1.44920558e-01f, 2.62380481e-01f, 4.40104187e-01f, -3.55609357e-01f, 1.33265644e-01f, -1.33541122e-01f, -3.97050334e-03f, 7.67793646e-03f, 8.68618935e-02f, 3.26815732e-02f,
  -2.32700258e-01f, -3.58400792e-01f, -2.78422982e-01f, 2.54087120e-01f, -2.33082801e-01f, 1.09760892e-02f, -1.65407777e-01f, 1.69683382e-01f, 1.76845729e-01f, -1.79863513e-01f,
  1.53886005e-01f, -3.47520523e-02f, -1.45098967e-02f, 2.01497361e-01f, 2.80584246e-01f, 2.44991183e-01f, 8.45544562e-02f, 1.29242420e-01f, 5.33139050e-01f, 8.85385424e-02f,
  8.77312273e-02f, 1.89291000e-01f, 7.18184859e-02f, 2.19169199e-01f, 4.25142646e-01f, 3.24202418e-01f, 3.51172507e-01f, 3.64808679e-01f, -9.90369245e-02f, 2.45769992e-01f,
  9.19751003e-02f, -1.10456474e-01f, 3.74289274e-01f, 1.34036809e-01f, 2.11243168e-01f, -1.10490553e-01f, 7.85859823e-02f, -4.99951899e-01f, 7.93385208e-02f, 3.69912893e-01f,
  -1.49430230e-01f, 3.58779341e-01f, -2.10636735e-01f, 1.48420081e-01f, -9.63088870e-02f, -2.45689943e-01f, 2.30771616e-01f, 6.61773980e-02f, 1.46245196e-01f, 2.31752202e-01f,
  -3.20066065e-01f, -3.12281013e-01f, -4.62875813e-01f, -1.15733095e-01f, 2.46466659e-02f, -4.43103164e-01f, 1.83566809e-01f, -1.55749485e-01f, 3.01248282e-01f, 1.48559675e-01f,
  -8.22866186e-02f, 4.18365121e-01f, 1.00417472e-01f, 2.17800930e-01f, 3.69781554e-01f, 2.43088543e-01f, 2.61238843e-01f, -6.63723201e-02f, 1.83210552e-01f, 4.47924644e-01f,
  4.90999315e-03f, -5.98011315e-02f, -2.62574479e-02f, 2.51204520e-01f, 1.03070006e-01f, -2.08514214e-01f, 3.75824332e-01f, 7.96304867e-02f, -4.51006033e-02f, -1.29261762e-01f,
  3.55990529e-01f, 3.02071273e-01f, 3.35699856e-01f, -1.42948195e-01f, -2.15066299e-02f, 2.13661954e-01f, 1.20760359e-01f, 2.41572306e-01f, 1.31321177e-01f, -2.96030670e-01f,
  4.87564690e-02f, 3.91580194e-01f, -3.34667526e-02f, -1.54897243e-01f, 2.49707937e-01f, -1.41227454e-01f, -7.91213512e-02f, 1.45559803e-01f, 1.36017669e-02f, 1.23588756e-01f,
  8.73837247e-03f, 1.43294960e-01f, 3.61598283e-01f, -3.11464310e-01f, -4.66764182e-01f, 5.36356270e-01f, 2.94583172e-01f, -7.34044537e-02f, -1.69906914e-01f, -2.17868879e-01f,
  2.64757629e-02f, -1.48414701e-01f, 1.82389542e-01f, -2.43240744e-01f, 1.60861358e-01f, -4.07518387e-01f, 2.77948111e-01f, -2.26393953e-01f, 6.02251738e-02f, -9.53845307e-02f,
  4.81813610e-01f, -3.31407011e-01f, 1.25635443e-02f, 2.68894792e-01f, 4.18016374e-01f, 9.90126282e-02f, 2.50160545e-01f, 5.05721331e-01f, -7.35834427e-03f, 3.38268757e-01f,
  1.34929523e-01f, -1.32388219e-01f, 7.34865889e-02f, 1.33698210e-01f, 1.66998789e-01f, 6.04104139e-02f
};

// L2_fan_Bp_bar (Shape: 1 x 14)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 14;
const float L2_fan_Bp_bar_data[] = {
  7.66420597e-03f, 2.02384025e-01f, 9.57868993e-02f, 2.31023088e-01f, -1.51673043e-02f, 2.41535395e-01f, 1.44236013e-01f, 1.55542850e-01f, 4.33865152e-02f, -2.05518119e-02f,
  2.22497024e-02f, -5.89078404e-02f, 9.98363942e-02f, 2.03484684e-01f
};

// L3_linear_W (Shape: 12 x 64)
const int L3_linear_W_rows = 12;
const int L3_linear_W_cols = 64;
const float L3_linear_W_data[] = {
  -2.15719119e-01f, -2.17227504e-01f, -9.51154158e-02f, -1.35653630e-01f, -4.75310721e-02f, -3.33622426e-01f, -8.33961740e-02f, 1.25049368e-01f, 3.38013262e-01f, -1.50813997e-01f,
  -1.66627079e-01f, 2.33218502e-02f, -2.71817856e-02f, -2.85779685e-01f, -2.00063586e-01f, 6.15854822e-02f, -1.29283503e-01f, 2.12127730e-01f, -2.79872656e-01f, -1.15515046e-01f,
  1.16912303e-02f, 4.22266461e-02f, -4.41008300e-01f, -2.48871967e-02f, -1.14980042e-01f, -2.37480104e-01f, 1.33563235e-01f, 1.35350212e-01f, 8.10081288e-02f, 8.14419240e-02f,
  -1.06319547e-01f, 1.44569948e-01f, 3.46601844e-01f, 1.65105551e-01f, -1.75146013e-01f, 1.86612755e-01f, 3.47217396e-02f, -2.05852538e-01f, 1.89364284e-01f, -2.85583556e-01f,
  -3.77047509e-01f, -6.97718412e-02f, 6.29701316e-02f, 6.19544499e-02f, 5.59324352e-03f, 9.08819064e-02f, -3.18185031e-01f, 2.87000269e-01f, -3.17386001e-01f, -2.44411469e-01f,
  4.42771107e-01f, -5.43439925e-01f, 1.49527684e-01f, -6.74645007e-01f, -5.37545025e-01f, -1.24509029e-01f, 1.55417338e-01f, -4.39552456e-01f, 1.80205494e-01f, 1.62213109e-02f,
  -6.57297134e-01f, -1.00974813e-01f, 9.21210945e-02f, -3.26370507e-01f, -1.87269464e-01f, 2.07811087e-01f, -5.68893477e-02f, 2.26767838e-01f, -7.59032667e-02f, 1.96767114e-02f,
  -1.14449441e-01f, 3.56893808e-01f, -3.95701915e-01f, -1.01149522e-01f, -3.05408873e-02f, -1.94251433e-01f, 4.07227188e-01f, -2.10045636e-01f, -4.20013666e-01f, 1.95415884e-01f,
  1.07753858e-01f, -2.87815809e-01f, -3.04588098e-02f, -2.40610570e-01f, -2.16867954e-01f, -1.02560952e-01f, -8.84529129e-02f, -5.77521324e-02f, 1.46899059e-01f, 3.36084254e-02f,
  -1.41344100e-01f, -3.33290428e-01f, -2.29401410e-01f, -6.30573705e-02f, 3.87651950e-01f, -3.24868321e-01f, -1.53778508e-01f, 3.93490136e-01f, 2.73635149e-01f, -2.09297732e-01f,
  1.84613556e-01f, -1.83719590e-01f, 2.57102460e-01f, 4.05094713e-01f, -2.68116295e-01f, 3.85666400e-01f, 2.19138470e-02f, -2.45185703e-01f, -1.24189354e-01f, -2.50780255e-01f,
  -2.47059241e-01f, -1.10206425e-01f, -4.02196795e-02f, -1.42064497e-01f, -1.52001545e-01f, -4.25412625e-01f, 2.81490356e-01f, -2.78470755e-01f, -9.72924381e-02f, -5.57277381e-01f,
  -4.20910120e-01f, 5.39377183e-02f, 8.97612721e-02f, -4.27635014e-01f, -6.69999063e-01f, 1.11943066e-01f, -5.79650924e-02f, 3.44293863e-01f, 7.66827613e-02f, 2.99922258e-01f,
  -6.11211881e-02f, 1.61736965e-01f, 3.42437714e-01f, 7.92310312e-02f, 3.05099100e-01f, -5.13608813e-01f, -3.41735393e-01f, -4.28733826e-01f, 1.17766084e-02f, 1.89309806e-01f,
  -3.45405862e-02f, -1.73036769e-01f, 2.11217284e-01f, -2.90469795e-01f, 4.90661204e-01f, 3.27018052e-01f, 7.65594542e-02f, -2.61999846e-01f, 1.27690464e-01f, -1.71448961e-01f,
  2.59144723e-01f, -2.40697917e-02f, 6.60103559e-02f, 3.32565635e-01f, 7.40131084e-03f, 2.49723226e-01f, -2.46452913e-01f, 6.99275658e-02f, -3.81652594e-01f, -1.86258987e-01f,
  3.10027264e-02f, -5.60598001e-02f, 6.33881614e-02f, 5.72008491e-01f, -4.13977683e-01f, -4.39124823e-01f, 4.91372913e-01f, -8.48435238e-03f, -5.86524792e-02f, 4.46038879e-02f,
  4.41755682e-01f, 5.43081462e-01f, -1.54805019e-01f, -3.06922905e-02f, 2.58665174e-01f, 2.65692294e-01f, 1.60484433e-01f, -4.61557359e-02f, -2.14727208e-01f, -5.54041803e-01f,
  2.10075110e-01f, -9.12207901e-01f, 4.51806607e-03f, 3.90365541e-01f, 1.11284420e-01f, -3.13319415e-01f, -2.92752504e-01f, -6.51263654e-01f, -4.31336194e-01f, 2.46669739e-01f,
  7.50425905e-02f, -1.30232289e-01f, -2.46264800e-01f, 1.22568436e-01f, -3.18248235e-02f, -4.79496084e-02f, -9.01803970e-02f, -4.47810143e-02f, 5.39943110e-03f, -7.40632787e-02f,
  1.10910185e-01f, 4.03473005e-02f, -3.09316188e-01f, 3.25218320e-01f, 1.09291859e-01f, -6.85565919e-02f, 1.20060772e-01f, 1.98206186e-01f, 4.84047458e-03f, 2.48675764e-01f,
  2.87251890e-01f, 2.99212158e-01f, 5.39367320e-03f, -2.26806954e-01f, 1.06726982e-01f, -6.93786098e-03f, 7.93366879e-02f, 4.46257591e-02f, 1.45766795e-01f, 1.14043809e-01f,
  -2.49371082e-01f, 3.00668418e-01f, -1.61909908e-01f, -2.62604415e-01f, 6.68237954e-02f, -2.24842370e-01f, -2.33244032e-01f, 3.28262001e-01f, -3.10401589e-01f, 5.53650498e-01f,
  -2.75469840e-01f, 4.40254584e-02f, 3.54858860e-02f, 2.97158480e-01f, 2.38817468e-01f, 5.49344197e-02f, -3.32138717e-01f, -2.51534969e-01f, 2.39311606e-01f, 1.98759645e-01f,
  1.59196675e-01f, 1.03912108e-01f, 1.56667933e-01f, 2.51060188e-01f, -2.09020317e-01f, 5.48374653e-01f, -7.57861853e-01f, 2.27360621e-01f, -2.12696105e-01f, -1.18472719e+00f,
  9.75223854e-02f, -2.31447667e-01f, -1.18375935e-01f, -1.06669702e-01f, -6.81259871e-01f, -8.78998935e-01f, 1.59092933e-01f, -3.27476896e-02f, -1.92646012e-01f, -3.25057417e-01f,
  -2.16481328e-01f, -2.91404963e-01f, -1.94799155e-01f, -1.64468884e-01f, -3.92065644e-01f, 2.34145403e-01f, 1.15544967e-01f, 4.41900454e-02f, 1.66423082e-01f, 2.53679305e-01f,
  1.37319146e-02f, -2.25985423e-01f, -3.20775092e-01f, -1.04781680e-01f, -2.82730669e-01f, 5.72034828e-02f, 6.70701340e-02f, 3.09122592e-01f, 1.18411884e-01f, 7.73613453e-02f,
  -5.15217364e-01f, 3.37694466e-01f, 3.56581002e-01f, -1.52692601e-01f, -4.92415503e-02f, 2.48339787e-01f, 2.98628122e-01f, -8.70864540e-02f, -2.70712048e-01f, -2.29703173e-01f,
  -3.28977227e-01f, 8.22184086e-02f, -1.26950771e-01f, -3.11374247e-01f, -7.10823596e-01f, 1.27381340e-01f, 4.07189548e-01f, -1.37424827e-01f, -5.56555986e-01f, -3.95446690e-03f,
  4.18519139e-01f, 1.31393418e-01f, 1.95682704e-01f, 2.27959484e-01f, -3.95425647e-01f, -1.14965700e-01f, -2.38890439e-01f, 4.20431718e-02f, 4.90438193e-02f, -1.80873513e-01f,
  1.71535522e-01f, -4.81310748e-02f, 2.50301093e-01f, -2.72739798e-01f, -1.10873409e-01f, 2.09230334e-01f, 1.97848767e-01f, -7.68001378e-02f, 9.09950491e-03f, -2.68263757e-01f,
  -8.18495974e-02f, -8.63270685e-02f, 2.95254737e-01f, 2.50398517e-01f, 1.26484051e-01f, 4.14940476e-01f, -1.61802443e-03f, -2.63419658e-01f, 5.37868619e-01f, 2.54517168e-01f,
  7.93471038e-02f, 9.97479409e-02f, -4.15636927e-01f, 5.56725115e-02f, 1.99122727e-01f, 1.90809548e-01f, -4.26569939e-01f, -4.42859113e-01f, -2.83755034e-01f, 4.36957963e-02f,
  1.97126672e-01f, 1.68778598e-01f, -9.38699171e-02f, 8.66533071e-02f, -3.55264395e-01f, -4.43613052e-01f, -3.44385207e-01f, 1.00212820e-01f, -1.96449146e-01f, 2.94072092e-01f,
  -4.32876408e-01f, -3.34709764e-01f, 4.84881580e-01f, 8.41449946e-02f, 2.96193689e-01f, -4.56377305e-03f, -3.52905959e-01f, 9.23729017e-02f, -3.31734749e-03f, -2.57463664e-01f,
  3.42631906e-01f, -1.66832153e-02f, -2.72711784e-01f, 3.55641454e-01f, 3.80842328e-01f, -6.15083538e-02f, -2.98926085e-01f, -3.73878181e-01f, 1.44711003e-01f, 2.08925381e-02f,
  -2.11819500e-01f, -6.31753564e-01f, -7.04129413e-02f, -1.69115946e-01f, -7.97956735e-02f, -4.40276146e-01f, 3.26999873e-01f, -1.49214372e-01f, -4.29177359e-02f, -1.51669264e-01f,
  1.13837898e-01f, 2.85153389e-01f, 1.03316754e-01f, 1.02929600e-01f, 1.12839684e-01f, 2.09640786e-01f, -9.21016783e-02f, -4.13464695e-01f, -3.41111392e-01f, 2.91973382e-01f,
  -3.71915787e-01f, 3.05730134e-01f, 3.75917107e-01f, 2.77520984e-01f, 2.67167479e-01f, -4.76948321e-01f, 1.60754427e-01f, 4.34637278e-01f, 3.90696555e-01f, 1.61873356e-01f,
  -3.99700254e-01f, -9.75601077e-02f, -1.04025565e-01f, 1.77700236e-01f, 2.65025180e-02f, -2.89774179e-01f, 4.64080483e-01f, 5.26524261e-02f, 1.85141429e-01f, -4.74204332e-01f,
  -2.40812153e-01f, 2.62365341e-01f, 2.18684539e-01f, 9.51918066e-02f, -3.49177808e-01f, -1.13365628e-01f, 2.75424421e-01f, -3.05209488e-01f, 2.20176980e-01f, -2.25442648e-01f,
  -4.85460460e-02f, 3.96147855e-02f, -1.40207529e-01f, 3.43178779e-01f, 3.10451478e-01f, -3.49207371e-01f, 6.80290768e-03f, -2.67713517e-01f, -1.62708640e-01f, 3.52453977e-01f,
  -1.81569085e-01f, -8.97963345e-02f, 5.54238677e-01f, 4.81272072e-01f, -5.05080540e-03f, -1.98742487e-02f, -2.04021037e-01f, -8.79163444e-01f, 8.19702744e-02f, 1.22047991e-01f,
  -2.25028157e-01f, 3.41000050e-01f, -5.32775700e-01f, -2.95277327e-01f, -8.00699174e-01f, -3.82866383e-01f, 7.12668821e-02f, -2.16831416e-01f, 1.79949611e-01f, -1.50826678e-01f,
  -1.41709391e-02f, 2.33288342e-03f, -5.19986525e-02f, -2.25944668e-01f, -2.03770801e-01f, -1.03577010e-01f, -1.37074277e-01f, -3.42471123e-01f, 2.89187692e-02f, -1.82542503e-01f,
  -1.64164543e-01f, -1.80598840e-01f, -2.73516506e-01f, 2.16604816e-03f, 1.19040698e-01f, -3.25595915e-01f, -1.35821670e-01f, -8.43397528e-02f, 1.04130916e-02f, 2.33907759e-01f,
  -9.51088220e-02f, -3.45445424e-02f, -1.06049046e-01f, 2.34732389e-01f, -5.13379313e-02f, 1.06905632e-01f, -1.36558414e-01f, -3.32025349e-01f, 3.59784424e-01f, 1.35963947e-01f,
  -4.05196071e-01f, 3.20307314e-01f, -3.03500414e-01f, 1.42633794e-02f, 2.10377201e-01f, 8.75971764e-02f, -1.13905519e-01f, 1.74733490e-01f, -3.33871692e-01f, 2.23505631e-01f,
  -2.93375105e-01f, -2.98697025e-01f, -1.99682623e-01f, -1.53352275e-01f, 3.14700186e-01f, 1.18420094e-01f, 1.39290811e-02f, 1.87531739e-01f, -1.81931987e-01f, 2.17144266e-01f,
  -2.82351851e-01f, 2.81089783e-01f, -1.80966761e-02f, -4.05205667e-01f, -6.34699047e-01f, 1.17741682e-01f, -1.44321501e-01f, -1.13470949e-01f, -1.26114517e-01f, -6.08137012e-01f,
  -4.43956703e-01f, -1.19942077e-01f, -2.85412222e-01f, -3.21924627e-01f, 2.15184793e-01f, -2.36297414e-01f, -2.55869359e-01f, -5.20865731e-02f, 1.82622969e-02f, 1.89418733e-01f,
  -8.08463097e-02f, 4.03716378e-02f, -5.03076553e-01f, 4.62376922e-02f, -1.19621858e-01f, -1.69591099e-01f, 1.34065762e-01f, -1.14898957e-01f, 3.84439766e-01f, 4.08402413e-01f,
  3.29801917e-01f, -5.24820993e-03f, 5.80921359e-02f, 3.26535165e-01f, -1.71110749e-01f, -2.53974851e-02f, 1.45545647e-01f, -5.15722260e-02f, 4.31443870e-01f, 6.32774308e-02f,
  5.01983702e-01f, -2.49307036e-01f, 1.25370294e-01f, 3.73059303e-01f, -6.00427628e-01f, 3.13242763e-01f, 3.29240710e-01f, -2.63540328e-01f, -1.83089569e-01f, -3.81903440e-01f,
  4.82030421e-01f, -2.41189942e-01f, -4.60254133e-01f, -2.00478032e-01f, 2.89963573e-01f, 2.46923491e-01f, -4.48551267e-01f, 1.48626819e-01f, -1.33313790e-01f, -2.69302636e-01f,
  3.01656246e-01f, 2.93991324e-02f, -3.22683811e-01f, -5.49907386e-02f, -4.96649653e-01f, -1.20095275e-01f, -2.51099110e-01f, 1.28475785e-01f, -4.91108805e-01f, -2.53050268e-01f,
  7.88687840e-02f, -2.55439550e-01f, 5.10807395e-01f, 1.29014691e-02f, 4.12024409e-02f, 3.59359123e-02f, 2.66264975e-01f, -1.69127136e-01f, -6.07464984e-02f, 3.77447516e-01f,
  2.55898625e-01f, 1.76352367e-01f, 2.06506819e-01f, -2.87807971e-01f, -2.24828348e-01f, 3.34482491e-01f, 2.59078532e-01f, 2.27034822e-01f, -9.20208767e-02f, 2.39038631e-01f,
  5.52454090e-04f, 6.79481551e-02f, 4.85133231e-01f, 2.06959054e-01f, -9.42578539e-02f, -2.08921600e-02f, 2.02109069e-01f, -1.36845201e-01f, 1.01942249e-01f, -2.16673166e-02f,
  2.80663431e-01f, 6.71773076e-01f, -3.03068370e-01f, -5.62081099e-01f, 3.81970823e-01f, -4.21111017e-01f, -3.87074113e-01f, 5.20417571e-01f, 4.51077819e-02f, -3.56020212e-01f,
  -1.36673987e-01f, -1.70305476e-01f, 5.60469389e-01f, 3.73822033e-01f, 2.21912578e-01f, 1.15860462e-01f, 1.29624814e-01f, 5.71836233e-02f, 4.01744515e-01f, -3.46376210e-01f,
  -2.68978000e-01f, 3.52133602e-01f, 1.93001106e-01f, -2.10243762e-01f, 2.54570812e-01f, 2.00500101e-01f, -8.68754447e-01f, 2.65932322e-01f, -3.64283681e-01f, -4.93262976e-01f,
  1.25760496e-01f, 3.36863309e-01f, 1.80555940e-01f, -1.98443130e-01f, 2.11811736e-01f, 1.37655169e-01f, -1.02723300e-01f, -2.20332056e-01f, 1.05659775e-01f, -6.19049072e-01f,
  2.51943737e-01f, -5.95437735e-02f, -5.84995672e-02f, 6.88181743e-02f, 3.54785770e-01f, 1.75380319e-01f, 5.03816977e-02f, 2.98401326e-01f, 1.57194644e-01f, -3.23486596e-01f,
  1.98386446e-01f, -3.11166674e-01f, 8.84912759e-02f, -2.12302774e-01f, -4.37507480e-02f, 5.32187633e-02f, -4.17920530e-01f, -2.54587531e-01f, 4.54334319e-01f, -6.31464049e-02f,
  1.38565883e-01f, -3.19802649e-02f, 1.89860418e-01f, 1.52423665e-01f, 2.79446274e-01f, 7.99808130e-02f, -3.35665226e-01f, 9.66407582e-02f, -2.66676664e-01f, 1.07301414e-01f,
  1.12321906e-01f, 1.11913681e-02f, -2.52615148e-03f, 1.30811408e-01f, -4.59622771e-01f, -5.47894053e-02f, -1.07580297e-01f, -1.97180822e-01f, 9.22165662e-02f, 4.48140562e-01f,
  -2.36409158e-01f, -1.40512317e-01f, -3.99052203e-01f, 2.07382403e-02f, 4.61756080e-01f, -2.15287939e-01f, -2.40908384e-01f, 2.85902679e-01f, -5.61799943e-01f, -1.96959376e-01f,
  -5.17243624e-01f, 5.08000031e-02f, -6.64381444e-01f, -1.57585889e-01f, -2.06470445e-01f, -4.20151740e-01f, -9.11258683e-02f, -7.06670403e-01f, 2.53338933e-01f, 5.75973630e-01f,
  4.64453161e-01f, 1.22658752e-01f, -8.98486555e-01f, -2.04556659e-01f, 5.45031391e-02f, -1.28280252e-01f, 1.10801466e-01f, -1.14222005e-01f, 4.06029075e-02f, 1.79961458e-01f,
  1.83212087e-01f, -5.67872822e-02f, 2.56605089e-01f, 3.15430723e-02f, -2.42969945e-01f, -6.32857382e-02f, -1.49544731e-01f, -2.40656316e-01f, 9.48805287e-02f, 4.98391967e-03f,
  2.89531857e-01f, 2.26613954e-02f, 2.64219850e-01f, 1.35888100e-01f, -3.17472368e-01f, -1.46021575e-01f, -5.42547166e-01f, -2.79432088e-01f, 1.55168772e-01f, -6.68302327e-02f,
  -2.36753523e-01f, 2.35095754e-01f, 3.45568091e-01f, -3.47009361e-01f, 4.50231731e-02f, 3.85521978e-01f, 2.68028527e-01f, -5.93995377e-02f, 6.41035512e-02f, -6.25079274e-02f,
  3.87032062e-01f, 4.42694485e-01f, -6.23073936e-01f, -5.66919506e-01f, 1.21406130e-01f, -1.03949174e-01f, 3.69925082e-01f, -1.62919968e-01f, -8.48788694e-02f, 7.67649934e-02f,
  3.42583627e-01f, 1.41176715e-01f, -4.82101560e-01f, -3.47421318e-01f, -1.09832597e+00f, -4.85085934e-01f, 2.07729489e-01f, 1.71284765e-01f, -6.97135746e-01f, 6.95860684e-02f,
  2.23524496e-01f, -8.12405795e-02f, -3.41813654e-01f, -1.23872444e-01f, -5.48289001e-01f, -3.78032655e-01f, 3.34984243e-01f, 2.84136198e-02f
};

// L3_linear_B (Shape: 1 x 12)
const int L3_linear_B_rows = 1;
const int L3_linear_B_cols = 12;
const float L3_linear_B_data[] = {
  -8.18437263e-02f, 4.46060039e-02f, 6.07025065e-02f, -1.29896700e-02f, -6.19179867e-02f, 4.56030779e-02f, 4.52298000e-02f, 5.86844496e-02f, 7.14012459e-02f, 5.81604615e-02f,
  -8.62946734e-02f, -8.01587924e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 25, 14
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        64, 25, 14
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        64, 25, 14
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_linear
    linear_forward_pgm(
        buffer1, x_out,
        L3_linear_W_data, L3_linear_B_data,
        64, 12
    );
    }
    