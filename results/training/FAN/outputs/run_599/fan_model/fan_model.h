/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 16 (x2)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 16;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    static inline float fan_activation(float x) { return x; }

    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 6 x 120)
const int L0_fan_Wp_rows = 6;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  4.06312853e-01f, -4.47940946e-01f, 2.57881254e-01f, 1.08385429e-01f, -2.21258134e-01f, -2.09208637e-01f, -4.72627431e-01f, -3.44748914e-01f, 1.00102901e-01f, 2.80757863e-02f,
  6.63338741e-03f, 2.22270146e-01f, 1.92002073e-01f, 1.30779013e-01f, 1.11029046e-02f, -2.21299157e-01f, -1.21656619e-01f, 3.95503640e-01f, 2.29849562e-01f, 4.54339273e-02f,
  -2.16089770e-01f, -5.99370431e-03f, 2.23872140e-01f, 1.17655687e-01f, -1.07582388e-02f, 1.75591201e-01f, -1.22919522e-01f, -1.11705422e-01f, -1.36502698e-01f, 2.12237239e-01f,
  3.39319468e-01f, -1.91320196e-01f, 1.07890859e-01f, 9.04466286e-02f, 1.53824529e-02f, 6.07637800e-02f, 2.22609956e-02f, 4.16470431e-02f, -1.14758816e-02f, 7.27149844e-02f,
  -1.87275968e-02f, -2.75699589e-02f, -1.30098043e-02f, 1.64614450e-02f, -6.61370382e-02f, 2.74049733e-02f, 1.73322769e-04f, 2.09440496e-02f, 6.85617328e-03f, -2.59302873e-02f,
  -4.19013686e-02f, -9.12366807e-02f, -1.38749436e-01f, -1.25127763e-01f, -8.03353712e-02f, 1.35012409e-02f, -1.28712907e-01f, 4.05428596e-02f, -1.09487936e-01f, 9.54322889e-02f,
  -2.94100009e-02f, 6.49626413e-03f, -2.07428820e-02f, -2.60256082e-02f, -1.04306795e-01f, 1.36591615e-02f, -1.51161002e-02f, -1.66843906e-02f, -1.49134640e-02f, -2.80875526e-02f,
  -5.03609469e-03f, 2.56521013e-02f, -1.93590578e-02f, 3.33678089e-02f, 3.66509482e-02f, -4.72471379e-02f, -2.37874668e-02f, 3.67249474e-02f, 1.69631168e-02f, -3.21756466e-03f,
  3.71533372e-02f, -5.06498218e-02f, -2.94591337e-02f, 1.31429546e-02f, -1.00034989e-01f, 5.05715422e-02f, 1.51801221e-02f, -7.50190988e-02f, 5.08547667e-03f, -6.15507253e-02f,
  3.01655065e-02f, -4.17019688e-02f, 2.39766791e-01f, 4.99292761e-02f, 5.36273383e-02f, -7.38432445e-03f, 6.71963319e-02f, 2.05066819e-02f, 4.98677157e-02f, 2.06931718e-02f,
  3.05133034e-02f, 1.21489644e-01f, 7.10120017e-04f, -6.29394222e-03f, 5.07993475e-02f, 3.01326588e-02f, -5.48267514e-02f, -7.86978286e-03f, 7.63079431e-03f, -3.99883762e-02f,
  -3.21308412e-02f, 5.88979311e-02f, 1.01424322e-01f, 9.34998170e-02f, 2.84400266e-02f, 3.99085768e-02f, 9.70830992e-02f, 5.22527322e-02f, -2.98366100e-02f, 8.59567896e-02f,
  -7.54851341e-01f, 4.60483521e-01f, -2.27566332e-01f, 1.62989572e-02f, 2.76970476e-01f, 8.01529661e-02f, 2.06550449e-01f, -7.44085759e-02f, -5.34337722e-02f, 3.00949737e-02f,
  3.31586272e-01f, -5.36618270e-02f, 1.09269470e-02f, -2.81365272e-02f, -7.33362809e-02f, 3.06518227e-01f, 2.06111297e-01f, -2.92671442e-01f, -3.58975172e-01f, 1.97802052e-01f,
  2.71362931e-01f, -1.38189927e-01f, -5.88679910e-01f, -5.64210117e-02f, 4.04856913e-02f, -1.13837712e-01f, -2.46762037e-02f, -5.30940574e-03f, 2.15906218e-01f, 3.30693461e-02f,
  -9.62254927e-02f, 3.24982181e-02f, 8.50090235e-02f, 1.41468728e-02f, 8.78161713e-02f, -8.08294863e-02f, -3.09158992e-02f, -1.06319062e-01f, -7.56612569e-02f, -4.30793390e-02f,
  1.31692916e-01f, 2.57105753e-02f, -3.53789777e-02f, -6.03708811e-03f, -4.40994166e-02f, 1.52188959e-02f, -3.48252468e-02f, -1.10334314e-01f, -5.06431200e-02f, 7.49634579e-02f,
  2.56130517e-01f, 1.32841542e-01f, -6.09397739e-02f, 1.17175855e-01f, 4.64943238e-03f, 1.85788888e-02f, 6.91673160e-02f, 9.75188091e-02f, 1.52505068e-02f, -1.06546566e-01f,
  5.64585105e-02f, -6.33498505e-02f, 2.00937949e-02f, -1.63256321e-02f, 2.99069360e-02f, -7.31768757e-02f, 4.11289558e-02f, 9.30546317e-03f, 1.01875411e-02f, -1.02358185e-01f,
  8.49698037e-02f, 3.20177674e-02f, 4.62498069e-02f, -2.15601344e-02f, 4.58397679e-02f, 4.88499366e-03f, 8.06274451e-03f, -5.60797378e-03f, 7.81193301e-02f, 3.00690718e-02f,
  5.52591234e-02f, 1.44359833e-02f, -8.15740507e-03f, -6.59417734e-02f, 8.65445435e-02f, -7.39474688e-03f, 3.77366170e-02f, -3.65258902e-02f, -7.55354762e-02f, 3.99342738e-02f,
  -7.92974383e-02f, 8.64124224e-02f, -7.14034960e-02f, 2.46242266e-02f, 7.93319603e-04f, 2.63398215e-02f, 3.11966036e-02f, 5.06593436e-02f, 6.79522753e-02f, 2.29784586e-02f,
  3.52333672e-02f, -3.39235067e-02f, -5.16115353e-02f, 3.06500285e-03f, -6.24362417e-02f, -1.45136612e-03f, 9.07887369e-02f, -4.40766700e-02f, 7.77842030e-02f, 7.46769756e-02f,
  1.14328647e-02f, -6.66657090e-02f, -1.32296294e-01f, -9.79175717e-02f, 5.46320900e-02f, -4.21426632e-02f, -9.68448222e-02f, -9.72437784e-02f, -5.67861274e-02f, -1.95928916e-01f,
  1.00126632e-01f, 2.77894676e-01f, 3.68549466e-01f, 8.23452026e-02f, 9.82265174e-02f, 1.15348719e-01f, 4.46847469e-01f, 1.52465671e-01f, -1.33509353e-01f, 2.45988756e-01f,
  -2.07152233e-01f, -2.58682042e-01f, -6.31656572e-02f, -1.20085470e-01f, -1.38444100e-02f, 3.66615415e-01f, 3.27248603e-01f, 1.98142171e-01f, 6.85628578e-02f, -1.71402156e-01f,
  -1.68009534e-01f, 3.13061029e-02f, -2.23205984e-01f, -1.25745520e-01f, 2.33095437e-01f, 4.99705635e-02f, 1.97266579e-01f, 2.82367524e-02f, 4.54374366e-02f, 6.06988311e-01f,
  3.83869052e-01f, 1.46353573e-01f, -6.56995401e-02f, -7.20639825e-02f, 9.01742950e-02f, -3.82044464e-02f, -6.35572709e-03f, 1.21408567e-01f, -3.80548611e-02f, 4.89975326e-02f,
  -9.50829461e-02f, -4.57564741e-02f, 1.45982550e-02f, 4.04471382e-02f, 9.41317752e-02f, 5.31995855e-02f, 8.35507642e-03f, 4.24326696e-02f, 6.84693456e-02f, 4.85196486e-02f,
  -1.58676645e-03f, -2.55637746e-02f, 1.17414244e-01f, -6.79464173e-03f, 5.96356429e-02f, -9.11859274e-02f, 6.28956780e-02f, 4.72084768e-02f, 3.17058228e-02f, 1.86373815e-01f,
  4.31695618e-02f, -2.98509859e-02f, -1.92750208e-02f, -3.86201553e-02f, -2.15240121e-02f, -5.51743573e-03f, -3.55482586e-02f, 2.47127675e-02f, -1.92710049e-02f, -3.29089053e-02f,
  2.63530575e-02f, -1.94235910e-02f, -6.31093010e-02f, -4.13767248e-02f, -3.94221069e-03f, -2.46110093e-02f, 4.01020311e-02f, 1.23052008e-03f, -3.67603153e-02f, -3.07417661e-02f,
  3.45933205e-03f, -3.95910628e-02f, -8.95781517e-02f, -1.51973767e-02f, -1.23309689e-02f, 5.79668134e-02f, -1.23919975e-02f, -4.03084606e-02f, -1.37551185e-02f, -1.06023259e-01f,
  -1.36052556e-02f, -1.78576782e-01f, 2.22973898e-01f, 5.84944300e-02f, 2.29037032e-02f, 6.92091808e-02f, 7.13309795e-02f, 1.62005760e-02f, 2.17190590e-02f, 1.17965899e-01f,
  -4.87155318e-02f, 7.37427697e-02f, 2.34442856e-02f, -2.30944203e-03f, -8.42357893e-03f, -2.53327470e-03f, 2.83656945e-03f, 5.17273918e-02f, -7.59433284e-02f, 4.75803278e-02f,
  4.51127142e-02f, 9.88007635e-02f, 4.94675711e-02f, 1.30340040e-01f, 7.66252130e-02f, -1.14057958e-02f, 8.46379399e-02f, 1.86344236e-01f, -4.83656898e-02f, 2.31630802e-01f,
  -2.18458056e-01f, -1.03037795e-02f, -3.30692172e-01f, 1.47180995e-02f, 1.97845981e-01f, 6.51546046e-02f, -1.45671710e-01f, 1.63787752e-01f, 1.96595952e-01f, -2.96562582e-01f,
  -9.47032273e-02f, -1.26686832e-02f, -2.75603682e-01f, -1.32134154e-01f, -4.16691095e-01f, -4.20915663e-01f, -2.70225823e-01f, -3.89305383e-01f, -1.87631652e-01f, 2.11752638e-01f,
  1.44712478e-01f, -3.32346782e-02f, -1.17028719e-02f, -7.60927796e-02f, 1.10789306e-01f, -2.65801996e-02f, -1.12330630e-01f, 2.71168530e-01f, 1.56885475e-01f, -5.51934987e-02f,
  -2.75281101e-01f, 1.14190377e-01f, -1.45457357e-01f, 6.28433423e-03f, -1.14292234e-01f, -7.89926946e-02f, -1.09200798e-01f, 3.24955918e-02f, -2.13757847e-02f, -9.73903462e-02f,
  -1.70138896e-01f, -1.33292228e-02f, -5.11303954e-02f, 1.99857969e-02f, -3.42595726e-02f, -4.06946577e-02f, -5.05292509e-03f, -1.07113399e-01f, -1.52490377e-01f, 4.51021688e-03f,
  7.17991218e-02f, -3.01757380e-02f, -5.25853001e-02f, -1.31472901e-01f, -5.56128845e-02f, -1.26381144e-01f, 2.75085378e-03f, 6.04376197e-02f, -1.19962193e-01f, -4.56456803e-02f,
  -1.32168597e-02f, -6.04170375e-02f, 5.62517531e-02f, 6.93208501e-02f, 1.98514070e-02f, 4.81496155e-02f, 5.56562357e-02f, -6.79671839e-02f, 1.54328004e-01f, 3.97136509e-02f,
  -5.53184981e-03f, -1.99247370e-04f, 1.33264880e-03f, -5.46640605e-02f, -4.80209962e-02f, -2.99446881e-02f, -1.46630825e-02f, -9.57109109e-02f, 4.74248044e-02f, 1.65469106e-02f,
  -2.35139001e-02f, 2.98369844e-02f, -9.92968772e-03f, 1.70497689e-02f, 8.49865898e-02f, -4.54973094e-02f, 2.95685530e-02f, 1.02616958e-01f, 6.78665638e-02f, -2.46715210e-02f,
  -1.07647264e-02f, -1.75054371e-01f, -1.53221533e-01f, -3.85725722e-02f, -2.09812205e-02f, 3.37381139e-02f, 6.64088503e-03f, -6.77327588e-02f, -5.79291955e-02f, -7.84545317e-02f,
  -4.80277929e-03f, -2.37882305e-02f, -8.72242898e-02f, 1.05243877e-01f, -3.69609855e-02f, -2.20340844e-02f, -8.10791831e-03f, -6.79102689e-02f, 8.18948746e-02f, 6.01042360e-02f,
  -6.34340420e-02f, -8.55046213e-02f, -5.54099828e-02f, -3.88836488e-02f, 3.74113321e-02f, -8.03665742e-02f, -1.40372634e-01f, -5.90442009e-02f, -1.69268340e-01f, -1.84299931e-01f,
  3.47482800e-01f, 6.28173470e-01f, -2.65685201e-01f, 4.58709419e-01f, -3.33621681e-01f, -2.87758768e-01f, -9.92632359e-02f, -1.01148434e-01f, 5.69255464e-02f, 3.19730878e-01f,
  5.01502603e-02f, -9.63719040e-02f, -1.26268324e-02f, 6.57091325e-04f, -3.45029607e-02f, 1.90936700e-01f, 2.28435308e-01f, -2.85242461e-02f, -6.86271667e-01f, -5.71860433e-01f,
  -7.85732493e-02f, 1.19291939e-01f, 3.29346210e-01f, 1.56606026e-02f, 1.13268703e-01f, -3.06255907e-01f, 1.61385924e-01f, 5.99816293e-02f, -7.14258328e-02f, 5.91062725e-01f,
  -1.37151167e-01f, 2.63108790e-01f, -2.00885504e-01f, 1.32241964e-01f, -2.30946839e-02f, 4.86531965e-02f, -6.92146569e-02f, 4.74245660e-03f, -8.58380571e-02f, 7.36670718e-02f,
  2.86601819e-02f, 1.45669794e-02f, -6.55362383e-02f, 3.40446306e-04f, 1.10889170e-02f, -4.50184196e-02f, 6.65265620e-02f, 3.01153436e-02f, 7.20535517e-02f, -9.28241014e-02f,
  1.85371414e-02f, 2.86731515e-02f, 1.26890475e-02f, -1.40008600e-02f, -6.99612945e-02f, -1.20902404e-01f, 7.43460795e-03f, -7.22032338e-02f, 8.36691645e-04f, 1.62952438e-01f,
  -6.43499242e-03f, -6.93081087e-03f, -1.76992342e-02f, 4.12772633e-02f, -6.13235356e-03f, 3.26091573e-02f, 1.19873127e-02f, 8.85709189e-03f, -1.46940220e-02f, -9.69735254e-03f,
  2.23417766e-02f, 3.58684883e-02f, -1.38981119e-02f, 5.98781295e-02f, 4.08784822e-02f, 5.14176600e-02f, -1.68904953e-03f, 5.39842397e-02f, -1.41808148e-02f, 1.15489580e-01f,
  -1.06729995e-02f, -6.14430234e-02f, 9.17704701e-02f, -1.15601392e-02f, 9.55131948e-02f, -1.42729310e-02f, -1.11539951e-02f, 1.89255867e-02f, -7.28022680e-02f, 5.03001958e-02f,
  2.29315888e-02f, -9.24214274e-02f, 1.01285934e-01f, 3.03487666e-02f, -8.40127096e-03f, -3.75738069e-02f, 6.89587276e-03f, -4.82825097e-03f, -5.13932854e-03f, -5.49866110e-02f,
  -4.82078381e-02f, -4.29804251e-02f, 8.53822976e-02f, -1.93847679e-02f, -7.72057921e-02f, -3.70704345e-02f, 1.83389690e-02f, -5.68676814e-02f, -3.82701471e-03f, 3.51398066e-02f,
  3.72648984e-02f, -1.31907359e-01f, -1.63407192e-01f, -3.96753810e-02f, -8.16596076e-02f, -1.27960503e-01f, -1.67265028e-01f, -8.40129480e-02f, -1.71374619e-01f, 3.17172594e-02f,
  2.56153733e-01f, -4.16202158e-01f, 2.51801699e-01f, -2.04224497e-01f, -4.30835336e-02f, 1.05639644e-01f, -7.22348839e-02f, -2.25265566e-02f, -3.68063822e-02f, -1.40786216e-01f,
  -7.25574195e-02f, -3.16347717e-03f, 1.26499012e-02f, -2.35821828e-02f, 2.11805671e-01f, -1.85310002e-02f, 1.95013642e-01f, 3.30928236e-01f, 4.29032713e-01f, 1.14804685e-01f,
  -1.92055270e-01f, -1.74151152e-01f, -1.22393928e-02f, 5.00416942e-02f, -1.03625081e-01f, 2.94807963e-02f, -2.49449059e-01f, -3.39623839e-01f, -7.21506551e-02f, 1.85397267e-01f,
  -7.82781318e-02f, 7.27774203e-02f, 1.22556761e-01f, -5.69613911e-02f, -1.77868620e-01f, -2.49034129e-02f, -4.32025716e-02f, 1.28805777e-03f, -1.32688507e-01f, -7.28650019e-02f,
  -1.54375667e-02f, -1.65440571e-02f, 5.59482314e-02f, -4.30292748e-02f, -1.09539218e-01f, -3.79374065e-02f, -1.00529743e-02f, -3.20767574e-02f, -4.26667519e-02f, -9.26085636e-02f,
  -1.32014245e-01f, -4.93694544e-02f, 8.38142112e-02f, -6.12027310e-02f, -7.39844516e-02f, 4.26289514e-02f, -1.08245216e-01f, 9.10520256e-02f, 3.05347294e-02f, -1.98528260e-01f,
  -5.12245297e-02f, -5.64550282e-03f, 3.84831950e-02f, -2.33352315e-02f, 2.46717948e-02f, -4.44564521e-02f, 8.52490962e-02f, -6.07678890e-02f, 6.82931021e-02f, -7.90647045e-02f,
  5.41979782e-02f, 4.61042039e-02f, -3.33315991e-02f, -1.44527918e-02f, 1.98181681e-02f, 5.87033294e-02f, 5.11068292e-02f, -3.35076489e-02f, 6.26033247e-02f, 7.19403662e-03f,
  2.55466048e-02f, 1.53744016e-02f, -4.72523309e-02f, -2.41936278e-02f, 7.46535957e-02f, 3.80969271e-02f, 4.73981313e-02f, 1.09161064e-02f, -1.17652835e-02f, 8.28078613e-02f,
  -4.16006982e-01f, 1.29000321e-01f, -2.87451968e-02f, 8.27459469e-02f, -1.23819886e-02f, -9.38243568e-02f, -1.08799770e-01f, -8.78599882e-02f, -3.17306630e-02f, -1.14211723e-01f,
  -2.36363485e-02f, -6.46319762e-02f, -7.20412582e-02f, -8.54659081e-02f, 3.46228257e-02f, -8.61795470e-02f, -9.85531136e-03f, -6.70577167e-03f, 9.45676584e-03f, -7.92873055e-02f,
  -1.04397975e-01f, -4.44738641e-02f, -1.10541649e-01f, -5.25713414e-02f, -8.90684128e-02f, 9.18608382e-02f, -1.03076965e-01f, -1.77095518e-01f, 1.11171193e-01f, -4.13462877e-01f
};

// L0_fan_Wp_bar (Shape: 4 x 120)
const int L0_fan_Wp_bar_rows = 4;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  4.21274364e-01f, -5.08147120e-01f, -2.76999384e-01f, 4.13986534e-01f, 4.33432013e-01f, -1.95779562e-01f, -1.07944882e+00f, -5.10579348e-02f, 4.27818209e-01f, -5.63126020e-02f,
  5.23143351e-01f, 4.64875996e-01f, 8.99413601e-02f, 2.76122481e-01f, -3.94766062e-01f, -6.13843322e-01f, -5.66223621e-01f, -6.56171799e-01f, -2.97084730e-02f, 4.18407112e-01f,
  1.77287310e-02f, -1.58143371e-01f, -2.97189027e-01f, -9.39860791e-02f, 3.80373269e-01f, 4.12056506e-01f, -5.72817139e-02f, 2.04567343e-01f, -1.11584656e-01f, -6.12664111e-02f,
  4.39333647e-01f, 2.43245512e-01f, 5.41198328e-02f, 1.10866755e-01f, 1.29984885e-01f, -1.51384780e-02f, -2.92789135e-02f, -5.60062900e-02f, 2.18312182e-02f, -7.68919215e-02f,
  1.75890699e-01f, 1.42426312e-01f, 1.89249367e-01f, 8.68315902e-03f, -5.81215583e-02f, 1.85165349e-02f, -1.00032881e-01f, -3.76753539e-01f, -2.21023619e-01f, -1.00678774e-02f,
  -3.21602225e-02f, 1.16488226e-02f, -2.02691168e-01f, -9.34086218e-02f, -2.05648184e-01f, -2.67189533e-01f, -3.35382787e-03f, 3.39204073e-01f, -5.10122553e-02f, 3.53277087e-01f,
  3.67784575e-02f, 2.65865829e-02f, 6.63647354e-02f, -2.87128910e-02f, -1.30931526e-01f, -7.36792386e-02f, 1.11402564e-01f, -1.80066422e-01f, 6.11921437e-02f, -8.51365253e-02f,
  -5.17270081e-02f, 1.34832516e-01f, -2.09479719e-01f, 7.31250783e-03f, 3.73940566e-03f, -4.85676201e-03f, 5.85870035e-02f, -1.01781249e-01f, 2.46834737e-04f, -1.02790743e-01f,
  -3.01935952e-02f, 9.09854248e-02f, 4.42861728e-02f, -2.33830488e-03f, 9.33239702e-03f, -6.40993342e-02f, 7.44867846e-02f, -2.78986283e-02f, 1.20750390e-01f, -3.60008925e-02f,
  -6.83599040e-02f, -2.46996388e-01f, 1.61206722e-01f, 8.75553861e-02f, -7.58294612e-02f, 3.23040523e-02f, 1.07140899e-01f, -4.62231748e-02f, 1.01143442e-01f, -4.04914767e-02f,
  -4.02767658e-02f, -2.01120317e-01f, 2.27447432e-02f, -1.65595144e-01f, 4.07514013e-02f, -5.58509491e-02f, -9.61103886e-02f, 5.95715940e-02f, -1.33066759e-01f, 5.74562401e-02f,
  -1.31129712e-01f, -3.43217432e-01f, 2.38602422e-02f, -1.51738703e-01f, 1.55860707e-01f, 5.86387515e-03f, -1.19608492e-01f, -8.26113299e-02f, -2.36599058e-01f, -5.16610444e-01f,
  1.42283332e+00f, 2.10850984e-01f, 2.88726628e-01f, 3.11171740e-01f, 1.89035431e-01f, 2.26816297e-01f, 3.17366242e-01f, 1.07732646e-01f, -2.31709797e-02f, 1.16439171e-01f,
  3.97948116e-01f, 2.23280206e-01f, 1.56428650e-01f, -9.35872272e-02f, 2.45642200e-01f, -2.29471281e-01f, -5.27439475e-01f, -7.50013143e-02f, 1.44388169e-01f, 2.36522779e-02f,
  -2.46476501e-01f, -3.87030914e-02f, 9.05805454e-02f, -2.34284282e-01f, -1.16063744e-01f, -1.09658174e-01f, -1.44775033e-01f, -7.55253062e-02f, -1.56694323e-01f, -6.07363820e-01f,
  -1.09650139e-02f, 4.99794692e-01f, -1.65360197e-01f, -1.10824719e-01f, 2.91336179e-02f, -1.36899769e-01f, 3.92828928e-03f, -1.31323650e-01f, -8.26366693e-02f, -1.60469279e-01f,
  -9.59375352e-02f, -6.78485632e-02f, 1.16663769e-01f, -3.31610143e-02f, -3.59066110e-03f, 1.10531999e-02f, 7.25337416e-02f, 4.18099053e-02f, -8.96825492e-02f, -8.02781899e-03f,
  2.40113083e-02f, 1.56856433e-01f, 2.82372564e-01f, 8.14979821e-02f, 1.48307532e-01f, 1.78410262e-02f, 2.16758758e-01f, -1.21496683e-02f, 1.70843378e-01f, 1.01263054e-01f,
  2.63920370e-02f, -8.12181011e-02f, 5.05152456e-02f, 5.46759218e-02f, 7.05292821e-02f, -1.02996193e-01f, -3.93380001e-02f, -4.41215634e-02f, 9.89316031e-02f, 1.16061280e-02f,
  -6.30160868e-02f, 7.58270547e-02f, 5.92888445e-02f, -8.97271466e-03f, -4.93669249e-02f, 5.39486669e-03f, -5.28158918e-02f, -1.29953828e-02f, 7.60483071e-02f, -2.24168450e-02f,
  1.31243497e-01f, -4.23312485e-02f, -3.32809798e-02f, -1.27155306e-02f, -8.93982276e-02f, 1.04074672e-01f, -4.58290726e-02f, 2.23294646e-02f, -1.00472840e-02f, -1.23340815e-01f,
  -4.31769967e-01f, 3.37965429e-01f, -2.16201842e-02f, 5.69780134e-02f, 7.49843642e-02f, -7.47779235e-02f, 1.48855343e-01f, -3.73005085e-02f, -1.56720981e-01f, -1.55666932e-01f,
  -3.10105309e-02f, -3.29191200e-02f, 4.56841663e-02f, -5.31959310e-02f, 1.12582529e-02f, -2.27555539e-02f, 1.05618365e-01f, 1.49457112e-01f, -7.75185525e-02f, -1.12157561e-01f,
  -1.24740340e-01f, -1.05926320e-01f, -1.01876967e-01f, -3.33133340e-02f, 8.45961794e-02f, -7.73959830e-02f, -1.64172187e-01f, -8.13108683e-02f, 6.64777309e-02f, -2.42202729e-01f,
  5.61087072e-01f, 3.52815598e-01f, 5.08183002e-01f, 1.21364839e-01f, 7.93044865e-02f, -2.98924685e-01f, -2.21417800e-01f, -2.72452146e-01f, -3.55922394e-02f, 1.77461669e-01f,
  3.22409719e-01f, -2.57562280e-01f, -4.20165248e-02f, -1.73653960e-01f, -1.14809848e-01f, -1.88446809e-02f, 1.34095535e-01f, -1.07789636e-01f, -6.63199067e-01f, -5.25520086e-01f,
  -3.24220300e-01f, -1.75892245e-02f, 7.66376927e-02f, -1.45144626e-01f, 1.70309141e-01f, -2.76120812e-01f, 2.61170834e-01f, 3.07386667e-01f, 6.62527829e-02f, 6.31085813e-01f,
  5.04945040e-01f, 4.15133685e-01f, -4.15988505e-01f, 4.78447527e-02f, 2.56636888e-01f, -2.09294967e-02f, -1.15909599e-01f, 1.28624454e-01f, 5.38190790e-02f, 3.06498189e-03f,
  2.08660349e-01f, 5.16781695e-02f, 1.31327540e-01f, 3.03057823e-02f, -8.79646018e-02f, -1.10258996e-01f, -1.90726444e-02f, -8.41889381e-02f, -6.39893860e-02f, -1.88952610e-02f,
  -1.56317577e-01f, 7.44466335e-02f, 2.14549690e-01f, -2.69110620e-01f, -1.61935195e-01f, -3.89013253e-02f, 1.02994433e-02f, -2.19648369e-02f, -4.56677116e-02f, 7.22913584e-03f,
  -3.02448981e-02f, 1.18861757e-01f, 1.63560048e-01f, -3.36799398e-02f, -8.38524997e-02f, 5.93339279e-02f, 3.02462373e-02f, -1.19065046e-02f, -2.81929728e-02f, 1.25989616e-02f,
  -1.28220230e-01f, -2.71307528e-02f, -6.06291108e-02f, -1.14097483e-02f, -4.42760587e-02f, 8.82652327e-02f, 6.76156059e-02f, -5.14923371e-02f, -1.47340409e-02f, -5.12086228e-02f,
  -5.91515601e-02f, 6.76731914e-02f, 1.57258406e-01f, -1.28781289e-01f, -2.99871564e-02f, -4.48291451e-02f, 3.53062451e-02f, -2.39418298e-02f, -1.51671423e-02f, 7.92698264e-02f,
  -2.93054402e-01f, -1.57623366e-01f, 3.95079590e-02f, 3.29958787e-03f, 1.44399390e-01f, 1.85435057e-01f, 1.64013609e-01f, -6.56367838e-02f, 1.84742242e-01f, -1.43901587e-01f,
  -2.77412608e-02f, -9.72577408e-02f, 5.79308718e-02f, 1.40115805e-02f, -2.55966544e-01f, 2.63194963e-02f, 4.13038880e-02f, -1.87438242e-02f, -3.34166698e-02f, 5.44566847e-02f,
  -8.90177384e-04f, -3.05727512e-01f, -5.20827353e-01f, -1.90427303e-01f, -1.37433305e-01f, -5.18291593e-01f, -1.04646757e-01f, -9.88747180e-02f, -8.76418799e-02f, -3.74076217e-01f,
  -7.77742922e-01f, 4.18924600e-01f, -1.06193221e+00f, -9.62757528e-01f, -7.93764591e-01f, -1.60739720e-02f, 1.11875743e-01f, 1.71292812e-01f, -3.56827855e-01f, -2.48042002e-01f,
  3.11148137e-01f, 3.29456866e-01f, 5.12426952e-03f, 2.96578199e-01f, 3.54468554e-01f, -3.34166884e-01f, -1.12751591e+00f, -6.52454853e-01f, 4.20586579e-02f, 2.46943220e-01f,
  4.93340008e-02f, -6.68868005e-01f, -4.60223824e-01f, -4.10451777e-02f, -1.12100236e-01f, 6.81323186e-02f, -1.03935373e+00f, -5.92355311e-01f, 5.46360314e-01f, -7.81538248e-01f,
  1.42670423e-01f, -2.18553558e-01f, -3.41345608e-01f, -3.28250788e-03f, -1.97803661e-01f, 1.49921343e-01f, 1.67877972e-01f, -1.46610022e-01f, 1.04857050e-01f, -7.62089118e-02f,
  -3.00561845e-01f, 8.23818296e-02f, -5.11012822e-02f, -2.87207663e-02f, -1.69156373e-01f, -1.09655835e-01f, -1.71199396e-01f, -2.25085035e-01f, -1.22387901e-01f, 1.81119666e-01f,
  -4.60985415e-02f, -2.51902550e-01f, -4.42913435e-02f, 7.03651011e-02f, 2.79125601e-01f, -1.03413440e-01f, 1.09176382e-01f, 6.05897009e-02f, -8.96014646e-02f, 7.33417422e-02f,
  -5.61013408e-02f, 1.40786931e-01f, 1.64907202e-01f, 1.76831894e-02f, -3.05558927e-02f, 2.57527176e-02f, -6.45039231e-02f, -9.22177508e-02f, 1.63897239e-02f, 1.16493747e-01f,
  -3.72118205e-02f, -1.32369399e-01f, -9.03845429e-02f, -6.49499893e-02f, -9.37806293e-02f, 2.23977752e-02f, -2.98471712e-02f, 5.91174606e-03f, -1.85178816e-01f, -9.08429325e-02f,
  -1.08364196e-02f, -8.19557160e-02f, -8.60043392e-02f, 1.61912382e-01f, -2.31623650e-01f, -1.07429072e-01f, 2.78564375e-02f, 1.36681661e-01f, 7.54525363e-02f, 5.96901178e-02f,
  2.78242081e-01f, -1.93314627e-02f, 1.64073817e-02f, 2.06295729e-01f, -7.02853426e-02f, 5.67854494e-02f, -7.85899833e-02f, 1.26412541e-01f, 1.00929546e-03f, -6.67194203e-02f,
  9.19883102e-02f, 5.32491729e-02f, 4.66136001e-02f, 2.54540056e-01f, -1.65508747e-01f, 9.12581384e-02f, 1.34173051e-01f, -1.15792721e-03f, 1.02715626e-01f, -7.29565509e-03f,
  -1.48946896e-01f, 3.21829785e-03f, 2.07139000e-01f, -1.53142288e-01f, -7.13770883e-03f, 1.67594734e-03f, 4.16387953e-02f, 1.40904129e-01f, 2.20339969e-01f, 2.26647764e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 4)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 4;
const float L0_fan_Bp_bar_data[] = {
  -2.38084104e-02f, 1.71016470e-01f, 9.92168486e-01f, 1.61943603e+00f
};

// L1_fan_Wp (Shape: 6 x 16)
const int L1_fan_Wp_rows = 6;
const int L1_fan_Wp_cols = 16;
const float L1_fan_Wp_data[] = {
  1.58473283e-01f, -1.70684680e-02f, 8.79624188e-02f, 3.41135234e-01f, -1.59264848e-01f, 4.39797461e-01f, 6.28488719e-01f, -1.83115497e-01f, 3.03166330e-01f, -4.68016475e-01f,
  -6.81954503e-01f, 6.88958228e-01f, -6.15837455e-01f, -3.88731182e-01f, -2.75511649e-02f, 2.98513491e-02f, 1.19990565e-01f, 5.16878128e-01f, 2.78310329e-01f, 1.88714206e-01f,
  8.02780330e-01f, 1.40338510e-01f, 2.19234545e-02f, 1.99502170e-01f, -6.41842127e-01f, -3.77841949e-01f, 2.29035825e-01f, -7.53629133e-02f, 2.24746287e-01f, 2.38242865e-01f,
  2.41310820e-01f, -9.84164029e-02f, -4.26962942e-01f, -6.24352217e-01f, -4.88583833e-01f, -8.13738406e-02f, -2.71899432e-01f, 2.12175250e-01f, -7.88943112e-01f, 3.01065564e-01f,
  -1.58771098e-01f, 6.34819940e-02f, -7.56973863e-01f, 5.23601174e-01f, 8.12334493e-02f, 1.32479474e-01f, -2.62426972e-01f, -3.41639593e-02f, -9.76983905e-02f, -1.09260428e+00f,
  -2.20382378e-01f, 2.48911932e-01f, 4.97695982e-01f, 3.85214984e-01f, -1.24325551e-01f, 4.66391563e-01f, -6.59307063e-01f, -4.30464596e-02f, -2.00748622e-01f, 3.41127694e-01f,
  -3.33484560e-01f, -2.89841235e-01f, 2.10527442e-02f, 2.19205528e-01f, -3.52405697e-01f, 1.10438913e-02f, 1.71933860e-01f, -3.71138714e-02f, 8.61462280e-02f, -5.07349968e-02f,
  -7.45873749e-01f, 4.20446783e-01f, 2.53178567e-01f, -1.02061659e-01f, 1.04740798e-01f, -2.59779543e-01f, 2.28846610e-01f, 1.67843133e-01f, -2.27905557e-01f, 4.28667575e-01f,
  -5.33906221e-01f, -4.19107437e-01f, -2.34935194e-01f, 1.77605972e-01f, 2.03821346e-01f, -8.04944932e-02f, 2.62445658e-01f, -1.71804413e-01f, -6.58075631e-01f, 4.02740017e-02f,
  1.74242020e-01f, 2.64571279e-01f, 7.27370307e-02f, 2.70680804e-02f, 6.23564422e-01f, -2.05254748e-01f
};

// L1_fan_Wp_bar (Shape: 4 x 16)
const int L1_fan_Wp_bar_rows = 4;
const int L1_fan_Wp_bar_cols = 16;
const float L1_fan_Wp_bar_data[] = {
  6.40824854e-01f, 9.44353223e-01f, 1.13022864e+00f, 9.86434400e-01f, 1.08219993e+00f, -4.07772866e-04f, 3.84487182e-01f, -6.61971509e-01f, -1.41093004e+00f, -1.54598758e-01f,
  4.45992291e-01f, 7.54230917e-02f, -5.71611941e-01f, -4.12635475e-01f, -7.32541025e-01f, 1.12929773e+00f, 3.15840304e-01f, -6.64655209e-01f, -1.28524944e-01f, 7.80785441e-01f,
  6.50605440e-01f, 9.23493922e-01f, -9.92827296e-01f, -5.66531718e-01f, 2.14192301e-01f, -3.90427083e-01f, -9.81937200e-02f, 6.36303961e-01f, -1.71341574e+00f, -2.38744840e-01f,
  1.03145754e+00f, 4.90512140e-02f, 3.26197445e-01f, -3.31058167e-02f, -6.56151474e-01f, -2.12583512e-01f, 2.05987439e-01f, 7.09836245e-01f, 9.16459680e-01f, -6.28317833e-01f,
  1.84890032e-01f, -7.70428479e-01f, -1.06055570e+00f, 6.10828638e-01f, 7.86438167e-01f, 7.06906199e-01f, -1.09335673e+00f, 6.26779616e-01f, 3.75299156e-01f, -4.53284860e-01f,
  2.94709168e-02f, -2.04142526e-01f, 3.06115836e-01f, 5.39253533e-01f, -8.06531429e-01f, 1.68061423e+00f, -1.97605461e-01f, 3.91438425e-01f, 1.03829756e-01f, -1.35744497e-01f,
  1.29053438e+00f, -1.39890516e+00f, 6.11911654e-01f, 6.42631769e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 4)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 4;
const float L1_fan_Bp_bar_data[] = {
  2.59635657e-01f, 1.12907994e+00f, -3.27041924e-01f, 5.93350828e-01f
};

// L2_linear_W (Shape: 12 x 16)
const int L2_linear_W_rows = 12;
const int L2_linear_W_cols = 16;
const float L2_linear_W_data[] = {
  -1.29880756e-01f, 8.91059041e-02f, 5.56494176e-01f, 2.47591957e-01f, 2.29932442e-01f, -8.78091395e-01f, -6.42531812e-01f, -5.18295169e-01f, 6.34605289e-01f, 4.11799908e-01f,
  -2.13981003e-01f, -6.12849355e-01f, -1.91195026e-01f, -1.14287031e+00f, 7.46658146e-01f, 2.14545175e-01f, -8.66774991e-02f, -5.11982501e-01f, 5.45651436e-01f, -1.30660713e+00f,
  3.60489309e-01f, 9.74392593e-01f, 2.89851665e-01f, 4.01020259e-01f, -1.00888669e-01f, 4.47332084e-01f, 1.04424870e+00f, 7.42322206e-01f, 3.01483124e-01f, -5.22567272e-01f,
  9.71704602e-01f, -9.84959781e-01f, -5.31491697e-01f, -8.47401679e-01f, 3.30092907e-01f, 1.00285876e+00f, -8.33926976e-01f, 3.47993702e-01f, 4.68213648e-01f, 6.01014733e-01f,
  -2.77666360e-01f, 7.24501967e-01f, -1.60148013e+00f, 1.53344417e+00f, 4.20265406e-01f, 1.30598471e-01f, -4.53215271e-01f, -1.06336462e+00f, 9.84567225e-01f, 7.08031535e-01f,
  -1.59722239e-01f, -1.53581762e+00f, -1.02700174e+00f, -5.64237177e-01f, 9.27982554e-02f, -8.82530808e-01f, 1.93185675e+00f, -1.06370401e+00f, 8.37097093e-02f, -9.45852637e-01f,
  3.78046744e-02f, -1.77508995e-01f, -7.70207107e-01f, 6.32284224e-01f, -1.19665134e+00f, -2.96677142e-01f, 3.38913798e-01f, 3.10666233e-01f, -5.59184134e-01f, 1.27391469e+00f,
  1.00114904e-01f, 3.62310588e-01f, -8.82771313e-01f, 9.72705662e-01f, 8.74468982e-01f, 5.33852518e-01f, -3.78284484e-01f, -9.10655618e-01f, -1.85139164e-01f, 8.58606815e-01f,
  1.03713143e+00f, -1.22356474e-01f, -1.03540921e+00f, 3.88037384e-01f, 3.25502396e-01f, 5.80535471e-01f, -1.33079314e+00f, 2.74851352e-01f, -9.63596627e-02f, 2.15052024e-01f,
  8.50273192e-01f, -1.74281931e+00f, 7.88128793e-01f, -2.97052592e-01f, -7.59832263e-01f, -4.61456031e-01f, 8.61760378e-01f, 1.62653446e+00f, -8.77779663e-01f, -5.30485153e-01f,
  -6.43756509e-01f, -1.20535672e+00f, 7.30148733e-01f, 6.92937851e-01f, -5.96389592e-01f, -8.96749854e-01f, -1.48086703e+00f, 1.07539856e+00f, -1.36043870e+00f, 7.15919554e-01f,
  -6.89153552e-01f, -1.12562382e+00f, 2.64558643e-01f, 7.78702796e-01f, -1.81759283e-01f, -1.69463038e-01f, 8.24561775e-01f, 1.34245086e+00f, 1.82070851e-01f, 6.06273338e-02f,
  7.63019741e-01f, 1.34919071e+00f, 9.57143605e-01f, 1.62258849e-01f, -1.05336225e+00f, 6.02364421e-01f, -4.49449986e-01f, 5.05857542e-03f, -1.05547011e+00f, 9.71832216e-01f,
  9.76643205e-01f, 7.24125624e-01f, 3.60333234e-01f, 1.37872905e-01f, 6.46321893e-01f, -7.20737875e-01f, -1.52145877e-01f, -7.95995235e-01f, -1.35752010e+00f, -1.46993387e+00f,
  -6.90604270e-01f, 5.00420451e-01f, 4.30704445e-01f, -1.24504316e+00f, 6.79541111e-01f, -1.49136364e+00f, -1.36316895e+00f, 2.30746463e-01f, 1.02154052e+00f, -1.27899125e-01f,
  -8.09487224e-01f, 5.25870025e-01f, -8.13574493e-02f, -1.47355974e+00f, -1.24372053e+00f, 5.89360356e-01f, -1.37300277e+00f, -8.19683969e-01f, -1.09693182e+00f, 8.98595512e-01f,
  -6.69745147e-01f, 1.17331982e+00f, -6.41037226e-01f, 8.06037903e-01f, -8.28084826e-01f, -2.87897563e+00f, 1.00329816e+00f, -1.07622910e+00f, -8.99362922e-01f, -8.63274753e-01f,
  8.68107259e-01f, -4.31609184e-01f, 5.40385127e-01f, -1.44952941e+00f, 1.91547528e-01f, -7.63520300e-01f, -1.22838527e-01f, -1.63054895e+00f, 7.54488528e-01f, -3.94870937e-02f,
  4.96566415e-01f, -9.16908264e-01f, -1.42779601e+00f, -9.19865891e-02f, -7.31647670e-01f, -9.90946054e-01f, 1.09722674e+00f, -6.00985922e-02f, -1.28132033e+00f, 1.01951015e+00f,
  -7.58574486e-01f, -1.49337494e+00f
};

// L2_linear_B (Shape: 1 x 12)
const int L2_linear_B_rows = 1;
const int L2_linear_B_cols = 12;
const float L2_linear_B_data[] = {
  -3.61322314e-01f, -2.35048085e-01f, 1.68618143e-01f, -8.44508290e-01f, 1.71449766e-01f, -3.75868157e-02f, 5.54090440e-01f, 2.28935003e-01f, -4.38587338e-01f, 5.32580554e-01f,
  -3.03728849e-01f, 2.01328415e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 6, 4
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        16, 6, 4
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_linear
    linear_forward_pgm(
        buffer1, x_out,
        L2_linear_W_data, L2_linear_B_data,
        16, 12
    );
    }
    