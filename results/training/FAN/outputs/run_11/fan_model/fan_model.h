/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 16 (x1)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 16;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    static inline float fan_activation(float x) { return x; }

    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 6 x 120)
const int L0_fan_Wp_rows = 6;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -2.68953949e-01f, -1.68000370e-01f, -3.95106710e-02f, 9.97728482e-02f, 8.50449353e-02f, 1.36841893e-01f, 3.99348944e-01f, -2.73083132e-02f, 2.69884765e-01f, -1.55815780e-01f,
  2.51966268e-01f, -8.55317861e-02f, 5.02328351e-02f, 1.70032799e-01f, 4.27724868e-01f, 1.52487904e-01f, 2.85414141e-02f, -1.51206125e-02f, -6.46318914e-03f, -5.98796941e-02f,
  5.44514842e-02f, 1.76334858e-01f, 2.13345855e-01f, -4.41425927e-02f, 7.29053840e-03f, -2.10055113e-01f, -8.26065466e-02f, -2.45588701e-02f, -1.07513607e-01f, 6.11031391e-02f,
  1.55073702e-01f, 2.94135865e-02f, 1.02809727e-01f, -1.23554710e-02f, -5.54625876e-02f, -1.29016461e-02f, -1.08363852e-01f, -3.56498808e-02f, 9.33257192e-02f, -4.33284566e-02f,
  -5.32294847e-02f, -2.28552781e-02f, 9.75369364e-02f, 6.44117594e-02f, -5.23351170e-02f, -4.49901959e-03f, 5.85399047e-02f, 6.57945052e-02f, -6.51794225e-02f, 3.24319825e-02f,
  9.24894884e-02f, -1.77523475e-02f, 3.88324959e-04f, -1.02161646e-01f, -3.65728401e-02f, 7.46733509e-03f, -1.95314605e-02f, -5.13561256e-02f, -3.95839103e-02f, -2.10138373e-02f,
  4.28948961e-02f, -2.96544489e-02f, 5.49427979e-02f, -4.37996583e-03f, 3.53223234e-02f, 3.48278545e-02f, 1.47689683e-02f, -2.79945806e-02f, 1.77328195e-02f, -1.92626007e-02f,
  -1.53668290e-02f, 3.08486093e-02f, 3.08584291e-02f, 4.59386036e-02f, -3.53820324e-02f, 1.03500281e-02f, -1.47621436e-02f, 9.15685575e-03f, 1.69157446e-03f, 6.96648881e-02f,
  -2.68255398e-02f, -1.59910452e-02f, -8.54433049e-03f, -1.95872895e-02f, 2.09828243e-02f, 7.52880331e-03f, -6.58549145e-02f, -1.25067355e-02f, 1.07688718e-02f, -3.27213183e-02f,
  -4.04275626e-01f, -4.64517176e-01f, 1.91913284e-02f, 6.33313283e-02f, 3.44909821e-03f, -2.85640266e-02f, 5.35904877e-02f, 7.34927505e-02f, -1.00756474e-01f, -3.65581567e-04f,
  -4.13751155e-02f, -2.87520178e-02f, -1.56969339e-01f, 1.84603259e-02f, -3.57930921e-02f, 1.04915593e-02f, -7.36306608e-02f, -9.65839773e-02f, 1.92339588e-02f, -6.06628694e-02f,
  -6.61340207e-02f, -1.21240495e-02f, 4.21674326e-02f, 5.60884625e-02f, -1.11065926e-02f, -7.20906712e-04f, -7.88480230e-03f, 2.78428905e-02f, -7.76504204e-02f, -6.56284094e-02f,
  -1.86441571e-01f, -2.47711807e-01f, -1.45622209e-01f, 2.73973405e-01f, -1.60425141e-01f, -4.29014206e-01f, -7.55814910e-02f, -7.64340982e-02f, -1.61313847e-01f, 1.85254693e-01f,
  -2.27421522e-01f, 3.40886593e-01f, -1.88080162e-01f, 4.65251878e-02f, -9.62119773e-02f, -3.44751954e-01f, -1.45193145e-01f, 5.81743121e-02f, -1.39063269e-01f, -2.32650433e-02f,
  -7.35782683e-02f, 5.29733347e-03f, 1.08583411e-02f, -1.12374768e-01f, 1.17820978e-01f, 1.09011546e-01f, 2.84240901e-01f, -1.38410166e-01f, 1.88041076e-01f, 2.39843559e-02f,
  -3.55503410e-02f, -7.74907395e-02f, 1.21747039e-01f, -2.07575206e-02f, 8.56696069e-03f, 1.81935076e-02f, 1.03020005e-01f, -1.08689885e-03f, 3.85205843e-04f, -3.70466360e-03f,
  -4.71838424e-03f, -6.72763214e-02f, 7.55789876e-02f, 4.61354181e-02f, -2.07794774e-02f, -1.84237752e-02f, 6.00220114e-02f, -6.87460415e-03f, 3.55445407e-02f, 5.07198460e-02f,
  9.20750014e-03f, 2.82395054e-02f, -2.33709887e-02f, -4.16455045e-02f, -7.49328509e-02f, -7.04266652e-02f, -2.67734122e-03f, -6.91751614e-02f, 4.60422374e-02f, -1.74904969e-02f,
  -9.96826682e-03f, -3.22968885e-03f, 4.29070294e-02f, 1.35392360e-02f, -2.61878651e-02f, 7.03314543e-02f, -2.08530528e-03f, -1.35873444e-03f, -7.22128665e-03f, -3.00207641e-02f,
  -2.73683015e-02f, 8.01344868e-03f, -4.83050793e-02f, -3.27052958e-02f, -2.47371048e-02f, 2.14875694e-02f, -9.87955462e-03f, -3.29843313e-02f, 5.09206485e-03f, 3.38481218e-02f,
  -3.65258344e-02f, -3.42043377e-02f, -8.13327581e-02f, 2.83844322e-02f, -5.19074127e-02f, -3.49939428e-02f, -5.29887490e-02f, 3.76332086e-03f, 6.00936403e-03f, -6.59108832e-02f,
  -2.14138106e-01f, -1.45242527e-01f, -8.72299746e-02f, 4.03207354e-02f, 2.43636835e-02f, 2.74376813e-02f, -6.69118389e-02f, 2.08867211e-02f, -9.24570784e-02f, -3.15702483e-02f,
  8.68068263e-02f, 1.01861201e-01f, -8.48184600e-02f, -6.22207951e-03f, -7.60239139e-02f, 7.95788225e-03f, 3.86892981e-03f, -4.33005579e-03f, -5.45701059e-03f, 2.15133466e-02f,
  5.94793335e-02f, 1.84601208e-03f, 4.45479341e-02f, 7.48682916e-02f, 5.63304499e-02f, 7.34827965e-02f, 5.86499795e-02f, 3.53899673e-02f, -2.03938186e-02f, -3.20839994e-02f,
  6.67350531e-01f, 1.52077377e-01f, 2.35889658e-01f, 5.08864105e-01f, 2.47822151e-01f, -3.96264255e-01f, -5.49989119e-02f, 1.25345945e-01f, 4.00234759e-01f, -3.18382472e-01f,
  6.14901120e-03f, 1.07452862e-01f, -8.84851441e-02f, 1.58901140e-02f, 3.28796446e-01f, -1.49170488e-01f, -1.29969455e-02f, 1.62221678e-03f, 2.37219483e-02f, 9.36263427e-02f,
  1.83173239e-01f, -7.80536905e-02f, 1.63717493e-01f, -6.79502785e-02f, 1.60894349e-01f, 1.71352923e-01f, 1.96238421e-02f, 2.38050334e-02f, -3.76859456e-02f, -4.60480824e-02f,
  -1.09929129e-01f, 3.96600505e-03f, 1.35992244e-01f, -1.43886283e-02f, 2.59961151e-02f, -1.11944014e-02f, -2.98693590e-02f, -2.32861042e-02f, 6.74352422e-02f, 2.16545333e-04f,
  -6.26690984e-02f, -2.62080841e-02f, -6.80817291e-04f, 2.89265532e-02f, 6.90904111e-02f, 9.33166668e-02f, 6.28036782e-02f, 2.49867886e-02f, 2.25900132e-02f, 2.42221765e-02f,
  5.79291694e-02f, 8.08921903e-02f, 4.52257693e-02f, -5.23724556e-02f, 1.13500558e-01f, 1.02390815e-02f, -3.24700586e-02f, 1.39108915e-02f, 3.23262624e-02f, 3.95085802e-03f,
  -6.40174299e-02f, -3.08740772e-02f, -1.12229846e-02f, -2.17588432e-02f, -5.53638348e-03f, -5.19572310e-02f, 1.04919774e-02f, -5.61916418e-02f, 7.15920329e-02f, -6.05144762e-02f,
  1.78263392e-02f, 8.90824646e-02f, 6.79389574e-03f, 6.84046596e-02f, -3.55176628e-02f, 2.44333851e-03f, -1.21655129e-03f, -5.15931398e-02f, -2.03008205e-02f, 1.04060117e-02f,
  -2.45146025e-02f, 3.07855643e-02f, -2.26342734e-02f, -6.42138124e-02f, -6.05760254e-02f, 7.49607682e-02f, 9.62494034e-03f, 1.55997891e-02f, 1.65478643e-02f, -6.86250627e-02f,
  -8.60620290e-02f, 3.26673649e-02f, -4.49969508e-02f, 2.56841211e-03f, -5.12681492e-02f, 5.26117440e-03f, 2.76502538e-02f, 3.35786976e-02f, -5.17730042e-02f, -3.38457115e-02f,
  -1.30337132e-02f, 2.98377983e-02f, -2.51385812e-02f, 1.29239140e-02f, 1.11019276e-02f, -7.53642917e-02f, -5.70206121e-02f, -1.51698822e-02f, 3.22284847e-02f, 6.77118602e-04f,
  -2.12042443e-02f, -6.46016672e-02f, -2.55807247e-02f, -2.04862398e-03f, -6.21156730e-02f, -4.92504127e-02f, 4.04332206e-02f, 3.71112558e-03f, -4.11919989e-02f, -4.71116491e-02f,
  -8.24901640e-01f, 3.04690879e-02f, 1.12988852e-01f, -2.91648179e-01f, -2.41877571e-01f, -6.24739945e-01f, -2.90052831e-01f, -1.65064018e-02f, -2.31393114e-01f, 3.56209204e-02f,
  2.93557458e-02f, -3.35825533e-02f, 1.46054611e-01f, -7.40170628e-02f, -5.36235213e-01f, 8.70192870e-02f, -2.74656445e-01f, -2.00559199e-02f, -3.06096394e-02f, -1.59658879e-01f,
  -1.20918185e-01f, -2.55372167e-01f, 1.16086960e-01f, 3.41054723e-02f, -1.33855760e-01f, 9.24137831e-02f, -6.48896443e-03f, 1.23104706e-01f, -1.72971934e-02f, -5.89813776e-02f,
  8.61461088e-02f, 1.55699268e-01f, 3.82611416e-02f, -1.63902771e-02f, -7.65915215e-02f, -2.36259550e-02f, -2.52686180e-02f, 8.33230764e-02f, 2.42010467e-02f, -2.90030194e-03f,
  -1.52208209e-02f, -3.07662729e-02f, 1.61907189e-02f, -3.02883028e-03f, -6.70519248e-02f, 4.45880648e-03f, -5.42270541e-02f, -1.06711509e-02f, 5.29704243e-02f, 3.60840261e-02f,
  3.75357978e-02f, 5.65990135e-02f, -3.39558721e-02f, 1.65210443e-03f, 3.36429477e-02f, 2.12008078e-02f, -4.20592986e-02f, 1.92073490e-02f, -3.56924869e-02f, -8.70789960e-02f,
  -5.80918305e-02f, -8.78560841e-02f, -1.48978187e-02f, 2.94399187e-02f, -4.17751111e-02f, 3.86655866e-03f, -5.02655841e-02f, 2.34609358e-02f, -4.10424396e-02f, -4.02841792e-02f,
  -3.52500640e-02f, 7.58276181e-03f, -4.64833565e-02f, -3.00642233e-02f, -4.14990932e-02f, 2.36124229e-02f, 1.94680374e-02f, 1.86486896e-02f, -4.62207310e-02f, -3.35022397e-02f,
  8.56942907e-02f, -4.67786081e-02f, 6.27954453e-02f, -7.96624168e-04f, -2.51008850e-02f, -7.39206269e-04f, -6.00129701e-02f, 1.64217111e-02f, 3.42706405e-02f, -1.29841045e-02f,
  -2.49870103e-02f, -1.59612432e-01f, 2.47367527e-02f, -2.93247961e-03f, 8.47937614e-02f, 7.17406580e-03f, 1.01368912e-02f, -9.72216055e-02f, -1.72080752e-02f, -5.57256863e-02f,
  -3.73570360e-02f, 1.43003026e-02f, -5.80948070e-02f, 5.72162913e-03f, 6.13834197e-03f, -2.48659193e-03f, 2.11423505e-02f, 1.66438576e-02f, -4.65579852e-02f, 1.25865452e-02f,
  4.64546541e-03f, -7.67182484e-02f, -4.46525216e-02f, -3.56582291e-02f, -9.51013342e-02f, 3.16127297e-03f, -2.50135139e-02f, 1.83085036e-02f, 2.22365335e-02f, 4.33936268e-02f,
  4.68407311e-02f, -5.81706315e-03f, 1.36135453e-02f, -1.26520589e-01f, 1.08272605e-01f, 8.56412873e-02f, -7.36758947e-01f, 1.13877259e-01f, -2.36062348e-01f, -1.38613805e-01f,
  6.26372620e-02f, -1.80834129e-01f, -2.44850263e-01f, 2.62507141e-01f, 1.33561656e-01f, -5.92777617e-02f, 2.66350687e-01f, -7.83949718e-02f, 1.04531445e-01f, 1.02257848e-01f,
  9.02764127e-02f, 2.92401552e-01f, 1.91149965e-01f, 2.15550497e-01f, 9.59138051e-02f, 1.01078264e-01f, 1.10106327e-01f, -4.27514389e-02f, 2.81671762e-01f, 1.25760555e-01f,
  -2.43332200e-02f, -3.12210083e-01f, 5.05055487e-02f, -1.71076506e-02f, 7.41210282e-02f, -2.56833481e-03f, -1.01039998e-01f, -8.13207775e-02f, -4.35350798e-02f, -5.81184886e-02f,
  -3.32646929e-02f, 4.38127816e-02f, 3.53561379e-02f, 2.25470662e-02f, -8.30475017e-02f, -3.60599607e-02f, 1.11609856e-02f, 3.32997739e-02f, -2.60181706e-02f, -3.37349288e-02f,
  -4.57700714e-02f, 2.04298440e-02f, 9.41445120e-03f, -5.77384233e-02f, -3.08687333e-02f, -1.24156158e-02f, -1.09712690e-01f, 8.46233964e-03f, -1.48329811e-04f, 2.49239635e-02f,
  4.81653325e-02f, -8.73595178e-02f, 6.42867312e-02f, -6.00941479e-02f, 5.40701672e-02f, 6.77748490e-03f, -3.87351867e-03f, -3.49316113e-02f, -7.12953284e-02f, -2.34799813e-02f,
  1.92167461e-02f, -2.09176447e-02f, -1.61975566e-02f, -7.62790218e-02f, -4.65731882e-02f, 3.42323557e-02f, -1.11072194e-02f, 2.48431657e-02f, 1.33012049e-02f, 3.03259380e-02f,
  -9.83883906e-03f, 1.07282521e-02f, -1.90196075e-02f, 2.81587876e-02f, -3.35610583e-02f, 7.20704487e-03f, -4.55067307e-03f, 4.69154306e-02f, -6.17843457e-02f, -2.24599801e-02f,
  1.06740683e-01f, 1.75316006e-01f, -1.05194353e-01f, -1.38996327e-02f, 4.54929322e-02f, 8.15510452e-02f, 5.44791371e-02f, 1.00973800e-01f, 7.80616775e-02f, 7.53317177e-02f,
  2.76023317e-02f, -6.25855476e-02f, -3.96004282e-02f, 5.98374568e-02f, 6.79530501e-02f, 4.78353314e-02f, -2.89736106e-03f, -2.30134856e-02f, -2.35402063e-02f, 6.74764514e-02f,
  5.28763570e-02f, -8.99948329e-02f, -7.50405118e-02f, 1.18512996e-01f, 2.41217073e-02f, -2.39545237e-02f, 1.08388498e-01f, -9.70308855e-02f, 8.40234309e-02f, -7.26790950e-02f,
  2.35169334e-03f, -5.62038496e-02f, 4.88392979e-01f, -2.12722793e-01f, 5.28523512e-02f, -2.22488731e-01f, -1.45972287e-02f, -8.31047371e-02f, 2.59452701e-01f, -3.93161058e-01f,
  -3.05671304e-01f, 2.96909422e-01f, -6.54835105e-02f, -4.22440469e-01f, 2.30441302e-01f, -1.12332962e-01f, -2.69217759e-01f, -1.24567978e-01f, 1.48400724e-01f, 2.13453434e-02f,
  8.27032998e-02f, -3.25235337e-01f, -2.09725052e-02f, -1.37151718e-01f, -4.42970954e-02f, 6.02898151e-02f, -2.30711251e-01f, 7.00339806e-05f, -2.06585974e-01f, -4.41085473e-02f,
  -4.77721356e-02f, 4.53064628e-02f, 2.25723186e-03f, 1.16877414e-01f, 5.84045947e-02f, -8.33936557e-02f, -2.12957300e-02f, 3.17602493e-02f, 1.05212331e-01f, 2.25175992e-02f,
  5.95990717e-02f, 1.13764647e-02f, 7.00761080e-02f, 8.78822282e-02f, -5.18929139e-02f, 1.70551911e-02f, 1.28464133e-01f, 4.38492484e-02f, -2.27677636e-02f, -4.09175493e-02f,
  3.19983177e-02f, -6.93280324e-02f, -2.63007358e-02f, 1.28600597e-02f, 7.59834498e-02f, 1.79039966e-02f, 6.18069209e-02f, -1.18861934e-02f, 3.62521992e-03f, 8.85280222e-03f,
  -5.91989197e-02f, -5.91723546e-02f, 5.17972559e-02f, -9.29820910e-02f, 1.43558513e-02f, -6.36349106e-03f, -1.47357536e-02f, -3.56715508e-02f, 1.75720081e-02f, -3.69211622e-02f,
  -4.45498265e-02f, 3.44157545e-03f, -5.34573942e-02f, -3.73695455e-02f, -4.14257608e-02f, 3.10694828e-04f, 5.56729473e-02f, -1.86335575e-03f, -2.73477565e-02f, 1.43445432e-02f,
  -2.97562834e-02f, -1.45538300e-02f, 2.43223570e-02f, -4.14961316e-02f, -5.62002696e-02f, -3.38579603e-02f, -1.11783199e-01f, 6.73480798e-03f, -3.65751702e-03f, -6.30975876e-04f,
  -6.60700398e-03f, -6.11783154e-02f, 3.81991528e-02f, -3.13528553e-02f, -4.37659100e-02f, -6.67395396e-03f, 5.90673946e-02f, -1.73359457e-02f, -1.78029723e-02f, -1.09408116e-02f,
  -7.72597790e-02f, 4.16567374e-04f, -1.75829139e-02f, -7.18198493e-02f, 1.22252880e-02f, -3.04696299e-02f, -8.68343711e-02f, 1.49093131e-02f, -3.98684666e-02f, 1.10211631e-03f,
  -1.34796463e-02f, 3.63185480e-02f, 7.72368163e-02f, 8.60359054e-03f, -6.39039204e-02f, -4.95921671e-02f, 3.66055556e-02f, 4.82446626e-02f, -5.70973717e-02f, -3.59673612e-02f
};

// L0_fan_Wp_bar (Shape: 4 x 120)
const int L0_fan_Wp_bar_rows = 4;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -1.07838714e+00f, 1.78185999e+00f, 7.31052160e-01f, 4.82473135e-01f, -1.24049222e+00f, 5.92511296e-01f, 3.91605854e-01f, -9.44057480e-02f, 4.35677141e-01f, 5.57223737e-01f,
  -9.44907367e-01f, 1.02518022e+00f, -2.53692746e-01f, 5.49249351e-01f, -8.89471948e-01f, 3.48246843e-01f, 7.02720210e-02f, 2.17087373e-01f, 5.06919697e-02f, -1.66030735e-01f,
  -3.08209658e-01f, -5.39922357e-01f, -5.44013940e-02f, -3.04932714e-01f, -3.85803133e-01f, 1.76995367e-01f, -7.18240023e-01f, 8.84381384e-02f, -1.56972066e-01f, -5.39630689e-02f,
  -1.45513609e-01f, -4.78623390e-01f, 2.43790764e-02f, 3.51486713e-01f, -1.59539476e-01f, -8.48527029e-02f, 1.00746460e-01f, -5.48861101e-02f, -5.16254567e-02f, 1.23224981e-01f,
  5.57563119e-02f, -1.22824498e-01f, 3.37271132e-02f, 1.77316964e-01f, 1.43417135e-01f, -1.20508084e-02f, 1.03924118e-01f, 6.28250837e-02f, 1.27676770e-01f, 2.04234496e-01f,
  1.04519144e-01f, 1.70039997e-01f, -9.53834727e-02f, 1.04984023e-01f, -5.49281649e-02f, 1.73697695e-01f, 2.64927059e-01f, -5.47914952e-02f, 1.23420440e-01f, 8.41940567e-02f,
  -8.68576095e-02f, 1.34846091e-01f, -2.60271668e-03f, 7.90067203e-03f, -1.95855298e-03f, -1.54196262e-01f, 7.90581927e-02f, -3.63526434e-01f, 2.90827006e-01f, -2.28243425e-01f,
  -1.54239938e-01f, -9.40041337e-03f, -1.08764626e-01f, 2.26921201e-01f, 1.52528640e-02f, 2.04827607e-01f, -8.10669586e-02f, -6.22928515e-02f, 1.22683816e-01f, -6.37116730e-02f,
  -4.53471914e-02f, 9.51326564e-02f, -3.99136953e-02f, -5.77135161e-02f, 9.62475687e-02f, 1.05032124e-01f, -3.46878450e-03f, 1.19870231e-01f, -2.27642581e-02f, -2.09954023e-01f,
  -1.78444758e-01f, -1.48520142e-01f, -4.68540154e-02f, -2.55965125e-02f, 1.46722183e-01f, -1.30315423e-01f, 6.23885542e-02f, 9.94061977e-02f, 1.12902686e-01f, -1.82580531e-01f,
  1.28195822e-01f, -6.25981912e-02f, -8.54905769e-02f, -1.11048125e-01f, -8.08555782e-02f, 8.67710412e-02f, -3.43989171e-02f, -5.09458408e-02f, -2.07304195e-01f, -2.48699591e-01f,
  -1.19574890e-01f, -1.26234084e-01f, 8.88297260e-02f, -5.88691942e-02f, -5.70414811e-02f, -1.92782357e-01f, -6.92374557e-02f, 1.64417863e-01f, -1.15934469e-01f, -3.47072631e-02f,
  -1.02585793e+00f, -1.25584269e+00f, 4.66653079e-01f, -7.53237247e-01f, 8.60152766e-02f, 6.41356230e-01f, 6.45616353e-02f, -2.57503003e-01f, -1.00903893e+00f, -6.64148331e-01f,
  -2.71703482e-01f, 1.59645155e-02f, -2.24686444e-01f, -3.53831768e-01f, 6.75386786e-01f, -4.81631577e-01f, -1.19605847e-01f, -3.67876828e-01f, -3.24471474e-01f, -2.69160867e-01f,
  -1.16842702e-01f, -6.12607658e-01f, 3.79714012e-01f, -5.41463941e-02f, 3.13018523e-02f, 1.18165882e-03f, 1.42039239e-01f, 3.73540193e-01f, 3.31890255e-01f, 2.10843369e-01f,
  2.04458386e-01f, -4.29665864e-01f, -9.89320315e-03f, 8.51309225e-02f, -4.02194237e-05f, 1.37857690e-01f, 2.66023248e-01f, 3.20791185e-01f, 1.97055459e-01f, -6.75738677e-02f,
  -4.69467752e-02f, 1.73951864e-01f, -7.52044842e-02f, 9.34650525e-02f, -6.21954277e-02f, -1.16093201e-03f, 1.52304426e-01f, -8.74905065e-02f, -1.66182909e-02f, 7.31752291e-02f,
  2.52792872e-02f, 8.17852765e-02f, -2.89254580e-02f, -1.24790603e-02f, 5.22675738e-02f, -1.85382515e-02f, 1.22336522e-01f, 2.50554621e-01f, -5.75228129e-03f, -4.82796356e-02f,
  -8.41731206e-02f, 4.13896926e-02f, -1.02535971e-01f, 6.37941211e-02f, -9.23670530e-02f, 3.43714288e-04f, -4.01873849e-02f, -5.36147803e-02f, 8.79517198e-02f, -4.67635095e-02f,
  -7.77967796e-02f, -5.51146604e-02f, -1.26914978e-01f, 1.85322449e-01f, -3.36085632e-02f, -1.11203134e-01f, 4.51594368e-02f, 2.62980573e-02f, -8.33612010e-02f, 1.15551110e-02f,
  -7.69377276e-02f, 2.16180086e-02f, -5.85312545e-02f, 2.92843748e-02f, -1.09463677e-01f, 3.37798148e-02f, 4.85735796e-02f, -1.12410732e-01f, 1.11256838e-01f, 3.78529727e-02f,
  -1.97818801e-01f, -8.64516199e-01f, -1.33917481e-01f, 4.08975482e-02f, 3.96304019e-02f, -1.10612869e-01f, -2.03617871e-01f, -1.72855601e-01f, 2.98640062e-03f, 1.11676175e-02f,
  6.82516620e-02f, 5.18672690e-02f, -1.02875549e-02f, 5.55224903e-02f, 4.75964211e-02f, -2.00815499e-03f, -1.11496903e-01f, 1.25432953e-01f, -1.48009639e-02f, 3.31912786e-02f,
  -2.14010058e-03f, 5.62459454e-02f, 8.25542361e-02f, -6.83659986e-02f, 1.12123345e-03f, -6.65456802e-02f, -1.37583956e-01f, 6.05490282e-02f, 4.88690026e-02f, 4.84505109e-02f,
  -1.45125520e+00f, 2.72096060e-02f, -2.21635267e-01f, -1.02214956e+00f, 4.56362486e-01f, -1.53276160e-01f, -7.01490223e-01f, 1.09861232e-01f, -1.12349488e-01f, 3.03949416e-02f,
  -5.51412761e-01f, -6.86908960e-01f, 6.71208203e-02f, -9.25276458e-01f, -1.08723629e+00f, -5.82020104e-01f, -1.42955363e+00f, -7.98571885e-01f, 3.93872708e-02f, -5.35280347e-01f,
  -4.74168956e-01f, -3.30069870e-01f, -4.04584676e-01f, 6.83137536e-01f, 2.08517954e-01f, 2.40904748e-01f, -3.54791321e-02f, 8.35079491e-01f, -3.02536011e-01f, 2.88206846e-01f,
  -1.63929373e-01f, 1.71053261e-01f, -1.55324098e-02f, 2.84031361e-01f, -1.11768454e-01f, 3.62886935e-02f, -1.59682423e-01f, 1.19001769e-01f, 4.14964855e-02f, 4.86218594e-02f,
  -1.07463494e-01f, 2.31333897e-01f, -6.19585905e-03f, 2.81109691e-01f, 7.12512955e-02f, 5.17394505e-02f, 2.22231522e-01f, 1.59116641e-01f, 8.80707726e-02f, 2.27585301e-01f,
  -2.29732506e-02f, -7.73516856e-03f, -2.59917945e-01f, -1.23731621e-01f, -1.22598819e-01f, -4.76032980e-02f, 5.31735756e-02f, 1.22853585e-01f, -7.30332658e-02f, 1.57806545e-01f,
  -1.66420236e-01f, -5.91192022e-02f, -6.63273484e-02f, 2.06585661e-01f, -6.99607059e-02f, 2.15413332e-01f, -2.09164154e-02f, -6.65983036e-02f, 1.47645190e-01f, -2.00584605e-01f,
  1.21839261e-02f, -1.77886993e-01f, 5.09185977e-02f, 4.65823850e-03f, -1.39054313e-01f, 4.85139387e-03f, -1.97770119e-01f, 6.12157993e-02f, -8.77436176e-02f, -7.46842623e-02f,
  -9.45843756e-03f, -1.83076352e-01f, -1.03152737e-01f, 2.28651777e-01f, -6.37589209e-03f, 1.70415312e-01f, 1.93503007e-01f, 2.89527271e-02f, -6.34211674e-02f, -1.35572121e-01f,
  -7.71041095e-01f, -5.53844273e-01f, 6.72767311e-02f, 2.12988213e-01f, -8.19751471e-02f, -1.96774930e-01f, -3.40868711e-01f, 1.79929450e-01f, -1.41486198e-01f, -2.63215378e-02f,
  6.76931143e-02f, -2.70978719e-01f, -2.63252884e-01f, -1.30499244e-01f, -1.42748386e-01f, -1.37268558e-01f, -3.27600002e-01f, -9.88211557e-02f, -2.63856679e-01f, 4.04930227e-02f,
  -6.06867671e-02f, 8.83503184e-02f, 3.00960671e-02f, 1.21835761e-01f, 3.76839004e-02f, -2.67125256e-02f, -2.27340162e-01f, 3.57987583e-02f, 7.53233284e-02f, -5.64812049e-02f,
  2.22956151e-01f, -4.06307042e-01f, -3.07949007e-01f, -7.70591676e-01f, -3.51291865e-01f, -2.49981165e-01f, 2.55875587e-01f, -8.38340521e-01f, -5.85271657e-01f, -3.88305753e-01f,
  -4.44356799e-01f, 2.16123417e-01f, 1.14410532e+00f, -7.31344581e-01f, 9.78250086e-01f, 6.97244883e-01f, -8.14597785e-01f, 5.38047776e-02f, -9.16962475e-02f, -6.50456011e-01f,
  -3.07839870e-01f, -7.98958242e-01f, 5.25732219e-01f, -6.67441845e-01f, -5.23058236e-01f, -7.53495753e-01f, 3.16742212e-01f, 2.26757780e-01f, -4.62399513e-01f, 8.70446637e-02f,
  -7.42527694e-02f, -1.37529656e-01f, -3.09553742e-01f, 1.81377366e-01f, -1.26107797e-01f, 1.17570773e-01f, -3.15164775e-02f, 5.25414407e-01f, -2.33665779e-02f, 6.23811968e-02f,
  2.44000241e-01f, 5.88524193e-02f, -3.49568278e-01f, 2.31250718e-01f, 1.08608067e-01f, -1.69487938e-01f, -5.67587325e-03f, -2.65142769e-01f, 6.38928562e-02f, 2.23609820e-01f,
  -8.48056823e-02f, -3.51955704e-02f, -1.10660993e-01f, -4.29618508e-02f, -6.72765151e-02f, -2.80205101e-01f, 3.12173396e-01f, 1.83287323e-01f, -6.61379322e-02f, -1.38751626e-01f,
  -6.22443017e-03f, 2.95809567e-01f, 9.63915065e-02f, 9.16388705e-02f, 9.05771255e-02f, -1.91490412e-01f, -5.84210232e-02f, 1.89356338e-02f, 5.55400215e-02f, -5.50896116e-02f,
  -2.73451149e-01f, -1.69701174e-01f, -9.39566866e-02f, 1.72942400e-01f, 2.50310195e-03f, 4.13124077e-02f, 4.30219285e-02f, 7.44770542e-02f, -1.26629844e-01f, -1.20221570e-01f,
  -9.41913351e-02f, 2.42379196e-02f, -1.16686501e-01f, 1.76521838e-01f, -1.25160843e-01f, 3.07016104e-01f, -6.74710721e-02f, 6.18148297e-02f, 9.40642655e-02f, 8.01573172e-02f,
  -1.27424940e-01f, -3.21880043e-01f, -3.13811302e-01f, -7.65158311e-02f, -2.10746676e-01f, -4.95145097e-02f, 8.98927636e-03f, -2.80559659e-01f, -1.52828833e-02f, -8.72537345e-02f,
  -1.40708387e-01f, 2.81492025e-02f, -1.45912901e-01f, -2.31737733e-01f, -1.54086854e-02f, -1.72239557e-01f, -1.30337570e-02f, -1.73084550e-02f, -1.15894303e-01f, -8.31953511e-02f,
  7.22243488e-02f, -8.60422701e-02f, 2.81850636e-01f, -1.10420659e-01f, -1.27742425e-01f, 2.75910765e-01f, -2.73132861e-01f, 1.53272286e-01f, 1.31584778e-01f, -7.05881268e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 4)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 4;
const float L0_fan_Bp_bar_data[] = {
  1.11910284e+00f, 1.21843040e+00f, 1.59587121e+00f, 4.25448179e-01f
};

// L1_linear_W (Shape: 12 x 16)
const int L1_linear_W_rows = 12;
const int L1_linear_W_cols = 16;
const float L1_linear_W_data[] = {
  -4.03989315e-01f, 4.66701359e-01f, -2.01524615e+00f, 1.56095934e+00f, 1.23970497e+00f, -2.42823052e+00f, 1.87201166e+00f, -4.99671727e-01f, -1.37380826e+00f, 2.26102281e+00f,
  -5.38821518e-01f, -1.74512219e+00f, 7.67426431e-01f, -6.78937495e-01f, -1.77526808e+00f, 1.48869790e-02f, -1.82978660e-01f, 1.41466165e+00f, 1.69289088e+00f, -2.09403610e+00f,
  1.44439757e-01f, -1.52892721e+00f, 5.62220037e-01f, -1.63492239e+00f, -1.71701133e+00f, -1.90820909e+00f, 2.33605051e+00f, -1.93335259e+00f, -1.03613138e+00f, -1.58946621e+00f,
  -1.50540674e+00f, 6.16193473e-01f, -1.14295915e-01f, -1.03932643e+00f, 9.15428102e-01f, -9.52793360e-01f, -2.07410049e+00f, 5.91517627e-01f, 1.20422697e+00f, 1.39814830e+00f,
  9.87257361e-01f, -1.13601387e+00f, 9.59210455e-01f, -1.34506929e+00f, -1.34331858e+00f, 1.22789788e+00f, -8.15681443e-02f, -1.30506229e+00f, 6.61289215e-01f, -9.64760855e-02f,
  -4.42813724e-01f, -2.72918034e+00f, -1.19699371e+00f, 2.11703986e-01f, -8.28459918e-01f, -4.54331487e-01f, -4.55128044e-01f, -1.08172104e-01f, -1.22829926e+00f, 1.12127334e-01f,
  -5.26890635e-01f, -1.65288997e+00f, 1.29467762e+00f, -8.65383506e-01f, 8.47113013e-01f, -1.24849248e+00f, 8.22175145e-01f, 9.77575123e-01f, -4.13155854e-01f, 7.30035186e-01f,
  1.66854405e+00f, -1.93813837e+00f, -1.32771206e+00f, 2.17037439e+00f, 1.01944983e+00f, 1.16885805e+00f, 2.59430081e-01f, 7.80407488e-01f, 2.71690696e-01f, -4.99657184e-01f,
  1.62608886e+00f, -6.20732367e-01f, 1.16613448e+00f, -2.74999261e-01f, -2.61660609e-02f, 2.22027683e+00f, -2.74729878e-01f, -1.43807852e+00f, -6.44729495e-01f, -2.07341909e+00f,
  -1.22350836e+00f, 1.15226197e+00f, 9.96356308e-01f, -1.17798471e+00f, -2.13191867e+00f, -3.63084793e-01f, -1.14071405e+00f, 9.02269006e-01f, -1.95347059e+00f, -1.11299622e+00f,
  1.49517751e+00f, 2.58233011e-01f, 2.01011848e+00f, -1.15222442e+00f, 2.41635346e+00f, -1.66436374e+00f, -2.19083738e+00f, 1.87007499e+00f, -1.18139195e+00f, -1.76902592e-01f,
  5.06921530e-01f, -1.21759713e+00f, 5.76899290e-01f, -1.43489397e+00f, 1.18872695e-01f, 1.50632754e-01f, -1.95031628e-01f, -1.28217518e+00f, -8.90049398e-01f, 2.27469951e-01f,
  -3.92156988e-02f, 8.59629810e-01f, -1.80194542e-01f, 1.42786264e+00f, -1.04438090e+00f, -1.14940774e+00f, 2.75978118e-01f, 1.15133202e+00f, -1.16605684e-01f, 1.37723958e+00f,
  -1.87594974e+00f, 1.61023760e+00f, -1.95362997e+00f, 1.35033333e+00f, -2.24567819e+00f, 2.03089309e+00f, 2.11068201e+00f, 2.00878248e-01f, 1.10438883e+00f, -1.10867202e+00f,
  -9.31657851e-01f, -1.68779254e+00f, -1.07425880e+00f, -8.66706908e-01f, -5.10997295e-01f, 2.84134924e-01f, 4.20359015e-01f, 1.10003829e+00f, 6.16477393e-02f, -6.88199341e-01f,
  3.90513271e-01f, -3.63663316e-01f, 3.19310218e-01f, -1.72134608e-01f, -1.81489158e+00f, 9.88759279e-01f, -1.29024351e+00f, 1.30384624e+00f, -1.77904129e+00f, 7.08109975e-01f,
  -2.37488604e+00f, 4.65752184e-01f, -2.42444813e-01f, 1.26004553e+00f, 1.53275311e+00f, 1.32674381e-01f, -1.47818995e+00f, 1.24857545e+00f, -1.92193174e+00f, 1.77962339e+00f,
  1.18387965e-02f, -8.30276489e-01f, -1.30191445e+00f, 4.63084400e-01f, 7.09052920e-01f, -1.23206806e+00f, -5.51079392e-01f, -9.11651731e-01f, -4.57882471e-02f, 7.61694431e-01f,
  9.01498437e-01f, -6.38736367e-01f, -1.88326240e+00f, 2.30250835e+00f, 1.64602995e+00f, 1.56198609e+00f, -1.01477778e+00f, 9.40530896e-01f, 1.26312315e+00f, -1.62991881e-02f,
  -5.95899820e-01f, -1.58263218e+00f
};

// L1_linear_B (Shape: 1 x 12)
const int L1_linear_B_rows = 1;
const int L1_linear_B_cols = 12;
const float L1_linear_B_data[] = {
  -2.85795536e-02f, 1.07201278e+00f, -5.95882118e-01f, -5.57501435e-01f, -7.95703053e-01f, -2.21970618e-01f, 1.04488146e+00f, -5.61087549e-01f, 1.75063026e+00f, -1.06541705e+00f,
  -5.57341039e-01f, -9.07521367e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 6, 4
    );
    
    // Camada 1: L1_linear
    linear_forward_pgm(
        buffer1, x_out,
        L1_linear_W_data, L1_linear_B_data,
        16, 12
    );
    }
    