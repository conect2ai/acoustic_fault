/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 16 (x2)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 16;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    return (x > 0.0f) ? x : 0.0f;
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 1 x 120)
const int L0_fan_Wp_rows = 1;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -1.05535567e-01f, 4.23626840e-01f, 1.28131196e-01f, -3.73675302e-02f, -1.08110644e-01f, -6.22357279e-02f, -2.45661754e-02f, 2.02286944e-01f, -5.65609969e-02f, 4.14760917e-01f,
  -1.49341717e-01f, 1.32938296e-01f, -1.24020120e-02f, -1.87420938e-02f, -4.76524353e-01f, -2.41933852e-01f, -1.62285686e-01f, 2.87292642e-03f, -1.33633420e-01f, 2.17276081e-01f,
  -1.95035860e-01f, -2.54149616e-01f, -1.18442416e-01f, -4.05723676e-02f, 4.15790714e-02f, 1.92290246e-01f, 1.17943853e-01f, 9.33594108e-02f, 1.09654509e-01f, 2.57043485e-02f,
  -1.00972101e-01f, 3.72892544e-02f, 6.22923151e-02f, 1.04930334e-01f, 1.25469584e-02f, 9.13635492e-02f, 5.30793220e-02f, -3.71067971e-02f, -1.25796452e-01f, 5.82782552e-02f,
  1.59960240e-02f, -4.69691567e-02f, -7.16537191e-03f, -1.20530061e-01f, 3.69130634e-02f, -3.41886990e-02f, -7.00202286e-02f, -9.03267264e-02f, 4.23084572e-02f, -7.75616020e-02f,
  1.76346917e-02f, -5.29343337e-02f, -5.55224903e-03f, -7.26309940e-02f, -7.44467452e-02f, -8.27890076e-03f, -1.05413437e-01f, 2.66798846e-02f, 7.58435130e-02f, -2.56260186e-02f,
  4.46346365e-02f, -1.48695232e-02f, -2.99145356e-02f, 1.11112129e-02f, -2.94355359e-02f, 8.99166241e-02f, -8.67536515e-02f, -1.58773400e-02f, -1.08731361e-02f, 1.41467638e-02f,
  -4.47069593e-02f, 7.06189275e-02f, -7.02717006e-02f, 2.96942163e-02f, -5.90669550e-02f, 5.41499667e-02f, 5.97957894e-03f, 3.37918140e-02f, 2.18265806e-03f, -2.37486809e-02f,
  1.16899982e-02f, -8.47501308e-03f, 6.54730722e-02f, -9.29747671e-02f, 4.18835729e-02f, -4.74491678e-02f, -8.49979743e-02f, 3.17802764e-02f, -5.46290241e-02f, 9.02636070e-03f,
  6.67960569e-02f, 2.40889773e-01f, 7.16058491e-03f, -3.93599644e-02f, -2.00618636e-02f, -9.70049873e-02f, -9.92407557e-03f, 9.33722034e-02f, 1.12520486e-01f, -6.22958019e-02f,
  3.15323360e-02f, -1.06055290e-02f, 8.77059624e-03f, -3.55872773e-02f, -4.20947969e-02f, 5.47351465e-02f, 5.51283546e-02f, 4.21842709e-02f, 9.44798738e-02f, 2.89931670e-02f,
  1.01104230e-01f, 3.30098942e-02f, -1.66637264e-02f, -4.40455638e-02f, -2.24650446e-02f, 3.97202410e-02f, -4.25642822e-03f, 4.37397957e-02f, -1.14158252e-02f, 1.36217652e-02f
};

// L0_fan_Wp_bar (Shape: 14 x 120)
const int L0_fan_Wp_bar_rows = 14;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -4.16165069e-02f, 4.46908504e-01f, -4.11139429e-01f, 1.06608629e-01f, -1.35750562e-01f, 4.78850216e-01f, 6.11294329e-01f, -9.25783068e-02f, -1.93037018e-01f, 5.52844107e-01f,
  3.43952924e-01f, -2.97691584e-01f, 2.48774081e-01f, 8.23372781e-01f, -3.27778831e-02f, 4.63113576e-01f, 6.23895347e-01f, 4.76510882e-01f, -2.91352302e-01f, 5.02588414e-02f,
  -5.01164272e-02f, 7.09911227e-01f, 8.08316022e-02f, -8.32153857e-02f, 2.75832444e-01f, -5.34961164e-01f, 1.23967260e-01f, -4.95964706e-01f, 2.04798758e-01f, 5.86365126e-02f,
  1.43013149e-01f, 8.93524736e-02f, -7.94562027e-02f, -8.27454850e-02f, -2.69264393e-02f, 1.29311785e-01f, -1.38291910e-01f, -9.96826738e-02f, -1.38823360e-01f, -1.88897997e-02f,
  7.66236847e-03f, -5.26531152e-02f, 2.62273438e-02f, -2.22783517e-02f, -1.15396567e-02f, -4.26248610e-02f, -6.77757561e-02f, -3.10295206e-02f, -1.81845039e-01f, 7.09470585e-02f,
  -1.15921535e-01f, 2.65861745e-03f, 9.40172151e-02f, 9.47957039e-02f, -1.31804511e-01f, 1.28164649e-01f, 7.65181482e-02f, -4.56709452e-02f, -5.67968264e-02f, 6.60948530e-02f,
  6.37838319e-02f, 8.91193673e-02f, 5.28923646e-02f, 7.40006641e-02f, 1.26509592e-02f, -5.77333495e-02f, 8.78477935e-03f, -1.81380697e-02f, -1.83112714e-02f, 1.35462180e-01f,
  -1.91579953e-01f, -3.68795805e-02f, 1.62897706e-01f, 2.73402687e-02f, 1.10551789e-01f, 1.69195067e-02f, -6.82021771e-03f, -1.84072405e-02f, -4.93485145e-02f, -1.07549049e-01f,
  -7.67460763e-02f, 1.57510471e-02f, 7.27462843e-02f, -2.09992323e-02f, 1.14000298e-01f, -4.62410897e-02f, 1.36559010e-01f, 1.36693314e-01f, -1.44630685e-01f, -6.04920797e-02f,
  1.89986303e-01f, 1.98355123e-01f, -8.16127211e-02f, 5.85428514e-02f, -9.91771743e-02f, 7.31842890e-02f, 8.87517631e-02f, 4.27352339e-02f, 4.33748253e-02f, 1.69173479e-02f,
  9.13791582e-02f, -3.61245684e-02f, 1.27654141e-02f, -8.58190805e-02f, -1.78655043e-01f, 1.90053046e-01f, 1.61970332e-01f, -1.54987648e-01f, -8.45653564e-02f, -3.77391353e-02f,
  1.82625562e-01f, -3.86337861e-02f, -6.15170784e-02f, 8.38431641e-02f, 9.21214074e-02f, 1.15080327e-01f, -6.17296286e-02f, -7.69157708e-02f, -1.02339514e-01f, 5.40023949e-03f,
  -7.08424985e-01f, 3.09643626e-01f, 4.10213560e-01f, 1.03861697e-01f, 8.00308809e-02f, 6.72739804e-01f, 5.22802711e-01f, 1.85174063e-01f, 5.61441422e-01f, -1.72652468e-01f,
  -4.44979042e-01f, -1.30095363e-01f, 7.10263029e-02f, -1.87625766e-01f, 4.47915107e-01f, 5.49591839e-01f, 3.78957331e-01f, 9.82941240e-02f, 2.39856854e-01f, -2.14758694e-01f,
  1.19321616e-02f, -3.67626548e-01f, -1.01930648e-01f, -3.88768345e-01f, -2.59967506e-01f, -3.04247320e-01f, -5.99234700e-01f, 9.77042541e-02f, -3.66439939e-01f, 2.86884546e-01f,
  -1.48374602e-01f, -2.72452712e-01f, -2.93750256e-01f, 1.51389241e-01f, -5.09387143e-02f, 1.42635843e-02f, 8.25227797e-02f, 5.59949987e-02f, 7.40353425e-04f, -1.04292288e-01f,
  -8.90207440e-02f, -8.37061554e-02f, 7.99512640e-02f, -2.35716850e-02f, 1.53826937e-01f, -1.08104214e-01f, -2.88267545e-02f, -6.90130368e-02f, -7.00418353e-02f, 7.71187898e-03f,
  -2.16658562e-02f, 1.53286710e-01f, -4.99819964e-02f, 1.52401239e-01f, -3.66068818e-02f, 7.30729401e-02f, 2.18274727e-01f, 9.16632786e-02f, 9.47718993e-02f, 1.42400846e-01f,
  3.59031595e-02f, 2.94094503e-01f, 4.30474468e-02f, 1.91403925e-02f, -7.59102851e-02f, -7.72003010e-02f, -6.82737380e-02f, -1.28756180e-01f, 1.03663780e-01f, -7.79845938e-02f,
  -8.25839788e-02f, -1.04067959e-01f, 4.42616455e-03f, 3.32006812e-02f, -4.32038978e-02f, -1.24238737e-01f, -2.35013086e-02f, -6.40736967e-02f, -1.24723405e-01f, -2.62157649e-01f,
  7.26155937e-02f, 2.01097429e-01f, -1.44601986e-01f, -6.17050901e-02f, 7.86262602e-02f, 2.56629232e-02f, -4.53062691e-02f, 1.17680199e-01f, -4.86824028e-02f, 4.39775512e-02f,
  3.37223262e-01f, 2.95162976e-01f, -4.54535484e-02f, -1.00596540e-01f, 5.77083491e-02f, -1.28055707e-01f, 2.49948695e-01f, 3.17038596e-02f, 2.68529803e-01f, -1.51199447e-02f,
  -1.12190272e-03f, -1.13594659e-01f, -2.28300933e-02f, -7.68892542e-02f, -1.03630619e-02f, 4.39934917e-02f, 7.40273893e-02f, 2.59770155e-02f, 1.24957040e-01f, -8.97597820e-02f,
  -9.58011895e-02f, 2.68512480e-02f, 3.66196893e-02f, -1.67639136e-01f, -1.27639800e-01f, -6.25725165e-02f, -1.07207693e-01f, 5.87913673e-03f, 3.28586921e-02f, 1.23444632e-01f,
  2.49095231e-01f, 1.53071359e-01f, 4.87712920e-01f, 4.75197196e-01f, -5.61854690e-02f, -1.75009459e-01f, -9.70641971e-02f, 2.99570620e-01f, 6.97614372e-01f, -3.73584658e-01f,
  -2.07596064e-01f, 5.36552106e-04f, -1.74266160e-01f, -4.90258522e-02f, 2.67599165e-01f, 5.64627126e-02f, 5.20011961e-01f, -4.81648967e-02f, 3.62440646e-01f, 3.72917593e-01f,
  4.22208577e-01f, -2.48479452e-02f, 2.70842820e-01f, 8.76955241e-02f, 2.54375279e-01f, 3.64578933e-01f, 4.85448800e-02f, 6.60256073e-02f, -1.39755741e-01f, -1.58061221e-01f,
  -9.99163613e-02f, 7.54790902e-02f, 6.19498231e-02f, -4.99021709e-02f, 1.25262260e-01f, -1.46948211e-02f, -2.89174020e-01f, -1.96875378e-01f, 1.35981366e-01f, 8.75965282e-02f,
  -2.35731024e-02f, 1.19474344e-01f, 7.35182762e-02f, 1.24844812e-01f, 4.04875986e-02f, 2.59890348e-01f, 2.91921526e-01f, 1.28822312e-01f, -6.62313253e-02f, -6.18372411e-02f,
  2.24279836e-01f, 3.54297534e-02f, 2.10496917e-01f, 1.90522186e-02f, 1.37587130e-01f, 1.91979364e-01f, -1.09505020e-02f, 4.68570106e-02f, 4.98629324e-02f, 1.22084096e-01f,
  -1.93240732e-01f, 1.36463059e-04f, 1.18067712e-02f, 1.12138726e-01f, 1.33656904e-01f, 3.38129653e-03f, 1.10168584e-01f, -4.65024635e-02f, 1.64917439e-01f, 1.02229252e-01f,
  8.16007778e-02f, -3.41126435e-02f, 3.66553292e-02f, 6.27704710e-02f, -7.06440657e-02f, 3.04643344e-02f, -3.83556820e-03f, 3.79058272e-02f, -1.31209090e-01f, -6.90521449e-02f,
  -1.37618601e-01f, -1.69254407e-01f, -2.12022010e-02f, -5.11292480e-02f, 1.27710085e-02f, 1.01653449e-01f, 7.52592012e-02f, -3.18575650e-02f, 1.55643165e-01f, -1.18677001e-02f,
  1.33532472e-02f, 2.49039888e-01f, 9.26712677e-02f, -1.34288743e-01f, 4.55917940e-02f, 2.53034644e-02f, 3.49344201e-02f, 8.40139315e-02f, 1.34866029e-01f, 2.92477738e-02f,
  -8.01386014e-02f, 7.15219975e-02f, -1.38668483e-02f, 6.84484765e-02f, -5.00180721e-02f, 1.47946596e-01f, 3.76719795e-02f, -8.23924914e-02f, 3.77519540e-02f, -1.57275915e-01f,
  -6.04576059e-02f, -8.78985450e-02f, 1.77689239e-01f, 1.04964800e-01f, -3.54731977e-02f, -8.99150446e-02f, 8.36519524e-02f, -4.67081219e-02f, 3.75184454e-02f, 1.41667143e-01f,
  2.42556721e-01f, -3.75935435e-01f, -5.70868492e-01f, -3.91744345e-01f, -3.87855284e-02f, -6.54165447e-01f, -4.68171567e-01f, -1.33217171e-01f, 1.39796957e-01f, 1.44036105e-02f,
  2.44589988e-03f, -2.28655115e-02f, 2.45947927e-01f, -3.23838681e-01f, -1.59358099e-01f, 1.97242066e-01f, -5.99880934e-01f, -3.72468591e-01f, 2.57884145e-01f, -2.73598880e-01f,
  -6.05852306e-02f, -2.21472308e-02f, -1.78985938e-01f, 2.88081050e-01f, -3.59323472e-01f, -1.22834221e-01f, 1.40281901e-01f, 2.15393260e-01f, -3.14518750e-01f, 1.70335788e-02f,
  -4.05413434e-02f, 1.85638875e-01f, -9.17906016e-02f, 3.21259201e-02f, -2.50837713e-01f, -7.75798261e-02f, -1.49632305e-01f, 1.96197942e-01f, 1.26371473e-01f, -1.99683961e-02f,
  -9.69470963e-02f, 6.68592602e-02f, -1.40496835e-01f, 2.40603372e-01f, 3.86308990e-02f, -4.62476769e-03f, -1.15533872e-02f, -6.31467476e-02f, 1.34343347e-02f, 4.99373898e-02f,
  -3.91237549e-02f, -5.92532121e-02f, -1.61168590e-01f, -1.02285944e-01f, -2.71031242e-02f, 6.14655502e-02f, -1.49073869e-01f, -3.25749367e-02f, -1.36406511e-01f, -4.19035479e-02f,
  8.11875146e-03f, 4.20403667e-02f, 8.63195118e-03f, 6.50165081e-02f, 4.66288552e-02f, 1.70747004e-02f, 4.59640548e-02f, 3.74819003e-02f, 2.62305960e-02f, -8.85040164e-02f,
  -1.04819573e-01f, -4.46333364e-02f, 1.16416372e-01f, -1.05098598e-01f, -1.71210393e-01f, 4.64298464e-02f, 2.44602207e-02f, 4.63666767e-02f, -1.79915294e-01f, -7.96577930e-02f,
  8.58689547e-02f, -9.61217061e-02f, 6.20817803e-02f, -4.34145294e-02f, 3.83421741e-02f, 1.79633498e-01f, 1.49624631e-01f, 1.79753341e-02f, -2.58660000e-02f, -3.83760966e-02f,
  -2.81913102e-01f, -9.70011577e-02f, 1.92399994e-02f, 4.87193353e-02f, 1.31644709e-02f, -9.66719091e-02f, -4.68229242e-02f, -1.07510008e-01f, -1.52818412e-01f, 7.36225769e-02f,
  -1.30278096e-01f, -1.40371844e-01f, -1.96066663e-01f, 1.40603278e-02f, 5.44904321e-02f, -1.35596588e-01f, -7.55651249e-03f, -1.48599632e-02f, -1.21080548e-01f, -1.66689664e-01f,
  9.39885806e-03f, 1.78226933e-03f, 3.89528088e-02f, -9.74858478e-02f, -3.41046229e-02f, 2.56108344e-02f, -1.94144592e-01f, -2.39271540e-02f, 6.88429773e-02f, -2.32995152e-02f,
  1.45725578e-01f, 5.46490550e-01f, 5.17958045e-01f, 2.71479696e-01f, 2.62336105e-01f, -2.81378657e-01f, -1.35763913e-01f, 4.21774864e-01f, 1.49795786e-01f, -5.73897548e-02f,
  -2.71792203e-01f, 3.02437097e-01f, -1.06428757e-01f, 4.47386093e-02f, -6.67518198e-01f, -3.63261193e-01f, -4.34596837e-01f, -2.06446156e-01f, 1.46622762e-01f, 5.86893074e-02f,
  -5.94953261e-02f, -3.38517904e-01f, -1.50027588e-01f, 1.92291275e-01f, 4.08220202e-01f, 2.23902240e-01f, -4.86196160e-01f, 1.95138663e-01f, 6.94105402e-02f, -3.47939543e-02f,
  -7.23046288e-02f, 1.10461839e-01f, 1.00976303e-01f, -2.04784796e-02f, -1.07061394e-01f, 1.17293862e-03f, -8.09200704e-02f, 3.60286273e-02f, 3.73266079e-02f, 3.56300808e-02f,
  7.01645911e-02f, 3.11862379e-02f, 2.08421633e-01f, 1.52594939e-01f, 1.60937816e-01f, 1.30765975e-01f, 1.92575976e-02f, -1.01613731e-03f, 2.35022954e-03f, 1.56309962e-01f,
  4.33487706e-02f, 8.95215049e-02f, -1.11686520e-01f, -3.43837813e-02f, -6.52057305e-02f, 8.20641667e-02f, -1.60429776e-02f, -1.17635421e-01f, 1.22192875e-01f, 1.05084427e-01f,
  1.50435111e-02f, -2.49025956e-01f, 2.79413573e-02f, 5.25929928e-02f, 1.01131003e-03f, 1.17681688e-02f, -8.13114718e-02f, -3.18436585e-02f, -1.31842028e-02f, -3.22866626e-02f,
  1.47076333e-02f, 1.57674372e-01f, 2.47509405e-02f, 3.32939178e-02f, -6.20821379e-02f, 8.41939971e-02f, 5.74333244e-04f, -2.58327816e-02f, -5.35091124e-02f, 5.37475273e-02f,
  8.69513378e-02f, -2.18247890e-01f, 7.10789561e-02f, -4.10645306e-02f, 1.01454705e-01f, 3.72534767e-02f, 5.63452393e-03f, 1.38528779e-01f, -1.05006687e-01f, -1.12703167e-01f,
  -6.83759153e-01f, -7.64438629e-01f, -1.80076212e-01f, 8.86381716e-02f, -5.12633845e-02f, -5.15763499e-02f, 2.14152830e-03f, 1.30513489e-01f, -9.45141837e-02f, -1.05427384e-01f,
  3.53711867e-03f, 4.78134193e-02f, -1.58454433e-01f, 2.72715148e-02f, -1.62056625e-01f, -9.87368822e-02f, -1.65947050e-01f, -9.69001129e-02f, -1.25471801e-01f, -1.94128044e-02f,
  -5.14852144e-02f, -9.22727287e-02f, -7.49777332e-02f, -1.40239047e-02f, -1.20032348e-01f, 2.99564973e-02f, -2.74134297e-02f, 6.86674267e-02f, -9.47876573e-02f, -4.02215049e-02f,
  -1.51363158e+00f, 3.22650969e-01f, -1.35127798e-01f, -6.23101354e-01f, 8.41046572e-02f, 7.16362521e-02f, -1.93775132e-01f, 5.02390601e-02f, -3.86162758e-01f, 4.11981732e-01f,
  1.75035343e-01f, -6.64759398e-01f, 4.31504935e-01f, -2.29308397e-01f, -8.16202283e-01f, 1.54608265e-01f, -4.01828438e-01f, -1.56956255e-01f, -7.00204298e-02f, -3.97070855e-01f,
  -3.50746870e-01f, 1.27578869e-01f, 1.36459591e-02f, 4.52806085e-01f, -2.62917668e-01f, -1.11237362e-01f, 7.43101835e-02f, 3.03863406e-01f, -1.24372475e-01f, 3.62491868e-02f,
  -6.61732256e-02f, 8.18272233e-02f, 6.33014217e-02f, 8.14262852e-02f, -6.63243309e-02f, 4.67358381e-02f, -1.83559269e-01f, -8.30752477e-02f, -5.73598221e-02f, -8.78069177e-02f,
  -8.82441476e-02f, 7.36794919e-02f, -2.31599435e-01f, 1.61147207e-01f, 4.39650044e-02f, 1.11571677e-01f, 7.22727180e-02f, -5.25288023e-02f, 6.76150471e-02f, 3.98557028e-03f,
  7.90087655e-02f, -4.39195149e-02f, 8.58843699e-02f, -1.91454869e-03f, 7.75325894e-02f, 8.83813277e-02f, -2.87880152e-02f, -7.08535090e-02f, -1.26964197e-01f, -4.49920893e-02f,
  -1.45315886e-01f, -5.02812164e-03f, -1.35993818e-03f, 1.21689864e-01f, 1.17649548e-02f, 1.15999460e-01f, -1.04381179e-03f, 4.11130041e-02f, -7.69588128e-02f, 4.97600473e-02f,
  -1.74537271e-01f, -8.56796280e-02f, 1.84802935e-02f, -7.99133331e-02f, -7.27003217e-02f, -5.13656549e-02f, 1.77425407e-02f, -2.36920137e-02f, -1.79622591e-01f, -2.63302140e-02f,
  1.96526689e-03f, 1.49967540e-02f, -3.01317289e-03f, 2.79779322e-02f, 9.93604138e-02f, -5.10112755e-02f, 3.43660335e-03f, -7.77869066e-03f, 2.61028297e-02f, -1.15870135e-02f,
  -1.41962260e-01f, -2.43723691e-01f, 5.19878864e-02f, -4.99140434e-02f, -1.15232437e-03f, 2.04583164e-02f, -2.15564668e-02f, -5.38171567e-02f, -6.87359571e-02f, -1.25909135e-01f,
  8.42730030e-02f, 1.71265528e-02f, -1.59870639e-01f, -1.08002089e-02f, 5.79213500e-02f, -3.18432637e-02f, -8.66476670e-02f, -1.53125510e-01f, -6.25995100e-02f, -3.67999598e-02f,
  4.52412330e-02f, -4.66080122e-02f, -1.13351904e-01f, -9.16720331e-02f, -8.99832845e-02f, -2.82204244e-03f, -1.41750023e-01f, 4.27389182e-02f, -5.20956181e-02f, 1.67378392e-02f,
  9.75279629e-01f, -6.95387721e-01f, -3.12709250e-02f, 4.91310656e-01f, 5.69770932e-01f, 3.91915083e-01f, 6.07899010e-01f, -2.69449297e-02f, 7.40574002e-02f, -5.42539179e-01f,
  3.62814106e-02f, -1.86134219e-01f, -3.60714853e-01f, 3.21538001e-01f, 9.11823511e-01f, -2.63855040e-01f, 3.87547404e-01f, 3.11325938e-01f, -7.55352527e-02f, 1.87706813e-01f,
  4.13510531e-01f, 4.87405002e-01f, 5.93672767e-02f, -1.96419790e-01f, 3.70904148e-01f, -2.65040696e-01f, 3.02215237e-02f, -2.97660410e-01f, 2.18780432e-02f, 2.85021693e-01f,
  2.25422278e-01f, 5.82902767e-02f, 6.37754574e-02f, -1.21995702e-01f, -1.62876725e-01f, 8.91092233e-03f, -5.78297898e-02f, 1.65618837e-01f, 1.18455127e-01f, -7.10015371e-02f,
  -1.29453063e-01f, 8.19701478e-02f, 5.16287908e-02f, -7.95497149e-02f, 5.89929037e-02f, 1.18764959e-01f, 4.97849658e-02f, -1.56341791e-01f, -1.36371374e-01f, 2.20070146e-02f,
  2.85885353e-02f, -6.16107583e-02f, 6.75812736e-02f, -8.52007195e-02f, -2.76351739e-02f, -4.20237444e-02f, -1.28883496e-01f, -2.17541996e-02f, 1.78819466e-02f, 1.07226335e-01f,
  1.66094657e-02f, -9.10499543e-02f, 6.23101704e-02f, 3.25709581e-02f, 8.53799358e-02f, 7.91399032e-02f, 6.55504763e-02f, 6.83055678e-03f, 1.67493578e-02f, 6.71622306e-02f,
  5.52957021e-02f, 8.06095004e-02f, 2.69494485e-04f, 5.24508692e-02f, 6.70618042e-02f, 9.84862596e-02f, 7.26508722e-03f, 8.18356872e-02f, -7.48567358e-02f, 3.97646315e-02f,
  -2.87602935e-02f, 6.74980739e-03f, -8.22351500e-02f, -8.01344141e-02f, 3.57580893e-02f, 4.72145900e-02f, -1.50179610e-01f, -4.02916363e-03f, 9.73974820e-03f, 5.74478991e-02f,
  -2.67686427e-01f, -4.10025209e-01f, -1.14719555e-01f, -5.79828117e-03f, -2.33350992e-02f, -1.63307078e-02f, -8.77731815e-02f, 7.74040595e-02f, -4.89450060e-02f, 4.07543927e-02f,
  -4.17575128e-02f, -6.12796843e-02f, -1.10474385e-01f, 9.06914547e-02f, 4.00584526e-02f, -7.66555890e-02f, -1.15068257e-01f, -9.73319933e-02f, 7.46705458e-02f, -1.11129761e-01f,
  -3.61941829e-02f, 5.45998625e-02f, 4.58582006e-02f, 1.00122198e-01f, -3.74180116e-02f, -9.57236961e-02f, -4.87241037e-02f, -5.53496368e-02f, -4.00478058e-02f, -1.07944347e-01f,
  4.53840494e-01f, 3.44167531e-01f, 3.15683037e-01f, 6.28730774e-01f, 3.87776911e-01f, -2.63814181e-01f, -3.00229162e-01f, 5.34193337e-01f, 5.86776972e-01f, -4.55091238e-01f,
  -7.20542250e-03f, -1.90329477e-01f, -2.53557980e-01f, 2.64928669e-01f, -4.82891709e-01f, 1.20817713e-01f, 3.13040972e-01f, -2.45335139e-02f, 3.04551423e-01f, 2.29373440e-01f,
  3.50673348e-01f, -1.51988696e-02f, 1.89361840e-01f, 2.72576332e-01f, 3.12425852e-01f, 1.68675438e-01f, -1.74155578e-01f, -3.26888748e-02f, -2.10262701e-01f, -9.25103277e-02f,
  -3.24653238e-02f, 3.39909792e-01f, 3.46848592e-02f, -9.01549757e-02f, 7.33042359e-02f, 1.12419441e-01f, -1.62187532e-01f, -1.95296392e-01f, -5.92047088e-02f, 2.53797080e-02f,
  -8.98914859e-02f, -1.22234911e-01f, -1.17772005e-01f, -1.18399307e-01f, 1.08147725e-01f, 1.18275210e-01f, 1.60713151e-01f, 6.47780448e-02f, 1.31638214e-01f, 2.20552862e-01f,
  1.34572342e-01f, 5.73996007e-02f, 1.80534869e-01f, -2.26674587e-01f, 5.10054901e-02f, 1.30291656e-01f, -1.18177772e-01f, -2.12669559e-02f, -3.98796946e-02f, 2.47884132e-02f,
  2.52908707e-01f, 1.28956825e-01f, -5.38680218e-02f, -1.68735549e-01f, -1.18811227e-01f, -7.64040127e-02f, -5.21455668e-02f, -1.95115447e-01f, 4.47916910e-02f, -1.36267677e-01f,
  -9.68820229e-02f, -3.65108065e-02f, 1.23371318e-01f, 4.62948568e-02f, -5.56624401e-03f, 2.16078516e-02f, -1.40280157e-01f, -1.06065802e-01f, 1.94051981e-01f, -5.71470708e-02f,
  -9.36258361e-02f, -1.19380152e-03f, 5.53102456e-02f, 1.31807383e-02f, -7.16968477e-02f, -1.28537476e-01f, 1.20870583e-02f, 9.19101387e-02f, -8.87395367e-02f, -8.01580325e-02f,
  -4.11571920e-01f, 1.80743113e-01f, -1.12327822e-01f, -1.24720290e-01f, -1.75183535e-01f, -8.88362378e-02f, -3.48646170e-03f, 4.17262502e-02f, 2.40960270e-02f, 6.71708584e-02f,
  -1.20588444e-01f, -1.90236375e-01f, 1.80255733e-02f, -9.47787985e-02f, 1.53584275e-02f, -1.46547064e-01f, -1.63511664e-01f, -9.92430374e-02f, -1.87730417e-01f, -9.06648301e-03f,
  -2.67148595e-02f, -1.02213912e-01f, -5.93420751e-02f, 5.73698990e-02f, -6.95200115e-02f, -2.70730704e-01f, 1.05240062e-01f, 1.73192099e-02f, -1.51050212e-02f, 3.21859084e-02f,
  -5.12607872e-01f, -4.63132150e-02f, -4.18649822e-01f, -2.10810706e-01f, -5.92945755e-01f, -2.75076658e-01f, -2.05837414e-01f, -1.16629273e-01f, 3.73914808e-01f, 4.94799644e-01f,
  -1.38281614e-01f, 2.41569519e-01f, 4.08760220e-01f, -6.54286817e-02f, -6.67506754e-02f, 4.60016251e-01f, -3.17185313e-01f, 1.16430879e-01f, -1.07953874e-02f, -2.51128435e-01f,
  -1.92132056e-01f, -1.33243352e-02f, -3.95292968e-01f, -2.95013320e-02f, -4.43772465e-01f, -1.07905842e-01f, -1.73463300e-01f, -2.48456880e-01f, -3.99245232e-01f, -2.37389758e-01f,
  -7.42666900e-01f, -2.50673413e-01f, -4.96368438e-01f, -7.27509558e-02f, -2.88443327e-01f, -5.12374043e-02f, -7.49135539e-02f, 9.53011774e-03f, -9.82213020e-02f, 1.10993147e-01f,
  1.93270922e-01f, 8.22534114e-02f, 3.37596424e-02f, 1.40144050e-01f, 2.50323359e-02f, -1.56292960e-01f, -1.19094692e-01f, -1.80718452e-01f, 3.76417935e-02f, -1.84266806e-01f,
  -1.41422793e-01f, -1.91069365e-01f, -3.30808908e-01f, -7.50009194e-02f, -2.72614121e-01f, -7.51159266e-02f, -4.99928668e-02f, -1.53850973e-01f, -1.87436312e-01f, -2.46215072e-02f,
  1.20628469e-01f, -9.50690955e-02f, -8.00699741e-02f, -8.42416137e-02f, -2.78190225e-02f, -6.39762357e-02f, 3.21987309e-02f, 3.54159959e-02f, -1.25593916e-02f, -1.94355100e-01f,
  2.05957573e-02f, 2.93617100e-02f, -4.16971371e-02f, -1.25653803e-01f, 1.24155559e-01f, 1.24249615e-01f, 1.71403531e-02f, -2.64151059e-02f, 8.87657106e-02f, 2.68787313e-02f,
  2.69530490e-02f, -3.81580293e-02f, 5.58103211e-02f, 2.70833075e-02f, -1.22701414e-01f, -9.95059684e-02f, -9.37790275e-02f, -9.34274271e-02f, 4.66286801e-02f, -2.71699429e-02f,
  -1.93236664e-01f, -1.04487881e-01f, 1.21918105e-01f, -6.67154342e-02f, 1.30081698e-01f, 4.73214537e-02f, 9.97307971e-02f, 8.63732118e-03f, 4.45982404e-02f, -5.65568618e-02f,
  -5.82171753e-02f, 1.19415283e-01f, -1.84787199e-01f, 9.44625959e-02f, 1.21815979e-01f, 1.25871622e-03f, -4.86329123e-02f, 4.48318161e-02f, -1.46633118e-01f, -8.80667195e-02f,
  -4.48770374e-02f, 3.71244773e-02f, 1.84277341e-01f, -1.11022905e-01f, -8.44749212e-02f, -1.59051642e-02f, 2.52440781e-03f, -5.83507866e-02f, -2.22945154e-01f, 2.36324798e-02f,
  -1.05620086e-01f, -2.78856605e-01f, -7.49853790e-01f, -4.22868013e-01f, 4.90649909e-01f, 1.91085979e-01f, -1.33193493e-01f, 1.78802818e-01f, -3.65872264e-01f, 4.57513243e-01f,
  3.50737780e-01f, -2.31974244e-01f, -1.64678141e-01f, -1.27092496e-01f, -4.02379245e-01f, -4.39244062e-01f, -5.75219244e-02f, -1.12296857e-01f, -2.39922017e-01f, 1.09377243e-01f,
  -2.93273240e-01f, 3.54085386e-01f, -5.10712981e-01f, 5.02305269e-01f, 3.62297744e-01f, 4.45925519e-02f, 4.27061826e-01f, 2.31903434e-01f, 2.48994440e-01f, 1.40357926e-01f,
  -4.94355746e-02f, -2.76866049e-01f, -1.82875976e-01f, -7.29136541e-02f, 8.17579180e-02f, 1.78316787e-01f, 8.12737271e-02f, 3.67474742e-02f, -6.81676045e-02f, -1.38579622e-01f,
  4.65727784e-02f, -7.91363642e-02f, 1.14768324e-02f, -6.54438064e-02f, 4.61068712e-02f, -5.21306135e-02f, -1.50768414e-01f, -1.95724871e-02f, -1.91454217e-01f, -1.06755883e-01f,
  -2.18935102e-01f, 7.40000405e-06f, 5.57453707e-02f, -6.37848601e-02f, -1.45816222e-01f, -1.52763845e-02f, 3.56732658e-03f, -6.89275414e-02f, 1.23158790e-01f, -3.95730697e-02f,
  1.28830999e-01f, 1.64359048e-01f, -3.39676603e-03f, -5.68546988e-02f, -4.69651967e-02f, -1.20097138e-02f, -2.42098607e-02f, 1.93864554e-02f, -7.83361420e-02f, 3.12773813e-03f,
  1.54093817e-01f, -2.83816159e-02f, 1.11974582e-01f, 1.22000158e-01f, 3.08022741e-02f, 1.58967823e-02f, 2.75006294e-02f, 4.22055833e-02f, -4.13409173e-02f, -7.67110288e-02f,
  1.05450191e-01f, 5.81665821e-02f, 6.20031841e-02f, 1.87371761e-01f, 5.24028903e-04f, -4.22283337e-02f, 9.64502469e-02f, -2.88557005e-03f, -1.41843066e-01f, 5.95551729e-02f,
  -1.35356719e-02f, 1.23630650e-01f, 8.24004039e-03f, -6.66289032e-02f, 6.08414365e-03f, 2.20362991e-01f, -2.19024234e-02f, -6.56104833e-02f, 6.17791899e-03f, 8.72524306e-02f,
  8.89309719e-02f, 2.97926944e-02f, 2.37753928e-01f, 9.51369330e-02f, -7.44379237e-02f, 9.69476104e-02f, 1.47992596e-01f, 1.31921485e-01f, 1.19343013e-01f, 2.26518363e-02f,
  2.02284753e-01f, 5.04832491e-02f, 4.11280207e-02f, 2.95999143e-02f, 1.41550139e-01f, 4.31010164e-02f, -2.35848613e-02f, -1.54297752e-02f, 1.30609348e-01f, -5.82530461e-02f,
  -2.59449631e-01f, -4.76093382e-01f, -1.00185327e-01f, 2.07212999e-01f, 1.83854342e-01f, -1.89738452e-01f, -5.63726425e-01f, 1.81225225e-01f, -6.24979138e-01f, -1.78847551e-01f,
  -1.15993507e-02f, -3.67346078e-01f, -3.48383874e-01f, 1.89238600e-02f, 2.50341177e-01f, -5.12316287e-01f, 9.92706716e-02f, 3.23531367e-02f, -2.11209431e-01f, 3.46848279e-01f,
  9.37427655e-02f, 3.59929651e-01f, 3.10923398e-01f, 7.01479793e-01f, 1.23251610e-01f, 4.27574605e-01f, 6.37817383e-01f, 1.66179314e-01f, 5.86912811e-01f, 7.58510306e-02f,
  -1.21349111e-01f, -2.10581586e-01f, -1.11368693e-01f, -5.66344038e-02f, 1.78765282e-01f, 6.74439548e-03f, 2.00667813e-01f, 4.17228788e-02f, 1.02833277e-02f, -1.05545491e-01f,
  -1.87665857e-02f, 1.39384657e-01f, 6.97040036e-02f, -1.93648203e-03f, 7.81201851e-03f, 7.82293901e-02f, -5.50366640e-02f, -1.08890526e-01f, -1.07712545e-01f, -6.83548525e-02f,
  -1.59217194e-01f, -8.45595300e-02f, -1.14921823e-01f, 1.45607054e-01f, 9.26322415e-02f, 7.22715557e-02f, 4.26807255e-02f, -9.26877335e-02f, -5.54555096e-02f, 8.19655601e-03f,
  1.26635447e-01f, -1.19531631e-01f, -1.93018243e-01f, -3.80775612e-03f, -8.25498104e-02f, -4.04157937e-02f, -1.13090217e-01f, -1.07623711e-02f, -1.21425733e-01f, -1.06110588e-01f,
  1.07837059e-02f, 3.88958268e-02f, -1.61075354e-01f, -1.43110994e-02f, 7.94444308e-02f, -1.00816727e-01f, 5.25130965e-02f, -7.35935643e-02f, 4.30315398e-02f, -5.88517673e-02f,
  -1.39502674e-01f, 7.30890334e-02f, 6.96349191e-03f, 5.29183075e-02f, -7.00044110e-02f, 1.30539134e-01f, 3.86900418e-02f, -5.43274246e-02f, -5.95276281e-02f, 7.96997845e-02f,
  8.51920694e-02f, 2.57549435e-01f, 7.56557519e-03f, 7.31353387e-02f, -1.02760889e-01f, -1.00463644e-01f, -8.19470063e-02f, 1.19529814e-02f, 8.80324766e-02f, -1.08694285e-01f,
  2.49096811e-01f, 1.08671136e-01f, 2.83015873e-02f, 1.54252887e-01f, 1.10664666e-01f, 5.83640160e-03f, -2.30708998e-02f, 5.28331324e-02f, 7.16274902e-02f, 2.68071979e-01f,
  1.25379145e-01f, 3.59318405e-02f, -2.81245285e-03f, 6.54737130e-02f, 1.54474542e-01f, 8.50006789e-02f, 1.00300103e-01f, 1.60095945e-01f, 1.20176628e-01f, 1.13169573e-01f,
  -1.97824940e-01f, -2.58147329e-01f, 5.30978620e-01f, -5.55671990e-01f, 4.31650728e-01f, 4.39303100e-01f, 2.48034567e-01f, -1.67369619e-01f, -3.82862419e-01f, -6.45478606e-01f,
  -2.74032325e-01f, -3.23311388e-02f, 4.05996710e-01f, -3.93609196e-01f, 7.38943875e-01f, 3.26470405e-01f, -2.74364859e-01f, -2.98319727e-01f, 5.75639158e-02f, -3.66694719e-01f,
  -2.12768055e-02f, -4.05489355e-01f, 5.46440721e-01f, -2.55438268e-01f, 5.57951964e-02f, -1.97845623e-01f, -2.27431640e-01f, 3.20589751e-01f, -4.28411573e-01f, 2.40508258e-01f,
  -1.24887839e-01f, -3.58237445e-01f, 4.35281508e-02f, 5.75608946e-02f, -1.71784982e-02f, 1.07286580e-01f, -2.54981685e-02f, 2.86785394e-01f, 3.72827761e-02f, -2.17862446e-02f,
  1.30861074e-01f, 7.80609553e-04f, -3.02657396e-01f, 8.43269229e-02f, 7.74532929e-02f, -3.08686611e-03f, 9.01152119e-02f, 7.58697912e-02f, -7.67978653e-02f, 1.81780174e-01f,
  2.49538049e-01f, 8.81177709e-02f, 5.73251536e-03f, -1.62936464e-01f, 5.67157120e-02f, -1.62757233e-01f, 8.58241692e-03f, 2.33663708e-01f, 8.04198254e-03f, -6.84200674e-02f,
  4.21226136e-02f, 3.32996824e-05f, -2.44781114e-02f, -7.57684633e-02f, -5.95058016e-02f, -1.11998208e-01f, -7.25943893e-02f, -5.91847450e-02f, 5.09757139e-02f, -1.69505607e-02f,
  -1.83690246e-02f, -1.27922565e-01f, 1.79153751e-03f, 2.55642552e-02f, -1.15181208e-01f, -9.60779190e-02f, 1.07767656e-01f, 1.23137264e-02f, -8.01623389e-02f, 3.86849232e-02f,
  -9.49081331e-02f, 4.54325415e-02f, 3.21535915e-02f, 3.09417881e-02f, -3.02256271e-02f, 1.99586973e-01f, -1.68811485e-01f, 1.01579450e-01f, 3.40169184e-02f, 1.92599013e-01f,
  -4.71608192e-01f, -8.34523976e-01f, -1.25972420e-01f, -1.31509602e-01f, -1.35428637e-01f, 7.59932846e-02f, 5.53570054e-02f, -1.17257044e-01f, -7.99823552e-02f, -1.19340569e-01f,
  -5.84340729e-02f, 6.34771539e-03f, -3.28005403e-02f, -4.74167131e-02f, -2.68207416e-02f, -6.64896369e-02f, -1.31730124e-01f, -1.72053173e-01f, -1.16677143e-01f, -8.64288956e-02f,
  -8.87164176e-02f, -1.04508750e-01f, 1.10939406e-01f, -5.63856550e-02f, -1.54179841e-01f, -9.39710159e-03f, -9.73679945e-02f, 4.80569229e-02f, 3.56504209e-02f, 2.39496548e-02f,
  -7.73139238e-01f, 5.21611273e-01f, 1.17500655e-01f, 5.28571606e-01f, -2.73964167e-01f, 6.89155534e-02f, 2.08255365e-01f, 5.20073734e-02f, -3.49452168e-01f, 8.57242644e-02f,
  4.17120636e-01f, -2.09157959e-01f, 3.98959219e-01f, 6.22583330e-01f, 1.01730898e-01f, 5.31610787e-01f, 5.82269609e-01f, 2.76601493e-01f, 2.58117139e-01f, 4.12784547e-01f,
  3.53022337e-01f, 6.10630155e-01f, 6.41356647e-01f, 3.77483666e-01f, 3.02241594e-01f, 1.42374635e-01f, 2.93764323e-01f, 1.08896010e-01f, 4.13720578e-01f, -1.70972571e-03f,
  1.22449242e-01f, 1.16778575e-02f, -1.02964580e-01f, -1.69586018e-01f, 1.34555832e-01f, -1.31444737e-01f, -1.22731668e-03f, -9.81080309e-02f, -5.65019846e-02f, 6.82442114e-02f,
  -1.31477803e-01f, -1.11584097e-01f, 4.61551398e-02f, -9.04388800e-02f, -1.76126301e-01f, -1.28039882e-01f, 4.29461524e-02f, -1.99321266e-02f, 3.40436539e-03f, 8.96323919e-02f,
  4.36059199e-02f, 9.77001116e-02f, 8.41733068e-02f, 4.91282940e-02f, -3.52370106e-02f, -1.44252941e-01f, -4.74553816e-02f, -1.49056381e-02f, 1.03914671e-01f, -6.67760223e-02f,
  -1.35611787e-01f, 3.77447009e-02f, 3.37608345e-02f, 4.60821250e-03f, 5.96623123e-02f, 1.14619598e-01f, 3.06703746e-02f, -5.43558188e-02f, 1.31636560e-02f, 9.35112834e-02f,
  1.53141379e-01f, 5.12388349e-02f, -1.47587627e-01f, -5.22938967e-02f, -1.72185469e-02f, -3.84646766e-02f, 9.65052247e-02f, 6.33091154e-03f, -3.65087464e-02f, -9.72272735e-03f,
  -3.05391522e-03f, -1.01629809e-01f, 3.74526083e-02f, 5.01638427e-02f, 5.35642058e-02f, 8.37997794e-02f, -2.91541461e-02f, -9.52444524e-02f, 1.42947286e-01f, 5.86499386e-02f,
  2.72933155e-01f, 1.78751692e-01f, 3.11064720e-02f, -1.18987620e-01f, 8.48223642e-02f, -1.32197276e-01f, -6.18182756e-02f, 2.04772308e-01f, 1.36083484e-01f, 2.78483629e-02f,
  -5.85769825e-02f, -1.10580638e-01f, 8.83311871e-03f, -6.87813312e-02f, 9.24840569e-02f, 1.32787973e-01f, 8.48385990e-02f, -1.18167311e-01f, -4.69961762e-02f, 1.30547984e-02f,
  1.03423335e-01f, -9.52644944e-02f, 2.22048163e-02f, 1.10068969e-01f, -1.20343473e-02f, 2.24544648e-02f, -1.92157179e-01f, -7.84031823e-02f, 8.92047808e-02f, 8.36957991e-02f,
  2.86701441e-01f, 2.72526890e-01f, -1.03219621e-01f, -8.20637867e-02f, -1.86623842e-01f, -6.10006094e-01f, -3.75681221e-01f, -3.64543140e-01f, 1.66117754e-02f, 1.85872182e-01f,
  -1.88410029e-01f, 6.17458642e-01f, 2.27798164e-01f, -3.09218049e-01f, -6.42948925e-01f, -2.07675204e-01f, -4.92891252e-01f, -6.01785183e-02f, 6.14648499e-02f, 9.48706791e-02f,
  -1.73510954e-01f, -4.74903941e-01f, -4.57015008e-01f, -1.29720587e-02f, -9.65276584e-02f, 2.71700203e-01f, -3.11236411e-01f, 1.50295243e-01f, -1.28234982e-01f, -1.29147083e-01f,
  -2.02320382e-01f, 1.66117400e-01f, 1.13388918e-01f, 4.25641984e-02f, -1.84962392e-01f, 4.40092497e-02f, 8.93326253e-02f, 5.59388138e-02f, 1.36174008e-01f, 4.99618240e-02f,
  3.36612105e-01f, -1.61051992e-02f, -1.67637598e-02f, -1.02085117e-02f, 2.08082825e-01f, 9.20879468e-02f, 1.16644371e-02f, -5.68561591e-02f, 1.84947893e-01f, 3.94682623e-02f,
  2.26742879e-01f, 1.08036369e-01f, 3.01694702e-02f, 8.43384340e-02f, 2.77730022e-02f, -6.78783655e-02f, 6.21758588e-02f, 8.26880410e-02f, 1.17491513e-01f, -4.58911024e-02f,
  -9.07610878e-02f, 3.24958414e-02f, -1.67904094e-01f, 5.45061566e-02f, 5.07983267e-02f, -2.87570506e-02f, 1.58372447e-01f, -3.13166417e-02f, 2.16552496e-01f, 7.08778203e-02f,
  7.25628659e-02f, 1.17769741e-01f, -1.76269617e-02f, 2.24311221e-02f, 4.12631519e-02f, 6.67362288e-02f, -2.26972671e-03f, 1.45857856e-01f, 5.55483215e-02f, -9.52488855e-02f,
  -8.75978544e-02f, -1.15455762e-01f, 1.45799518e-01f, -2.35231649e-02f, -2.95914728e-02f, 1.49913326e-01f, 9.47475340e-03f, 8.44745263e-02f, -5.11922799e-02f, -2.08190680e-02f,
  -2.71710694e-01f, -2.33592212e-01f, 4.84897904e-02f, 2.09654003e-01f, 7.67659843e-02f, 4.42302302e-02f, -1.18045174e-01f, -3.81666459e-02f, -1.31876096e-01f, -4.96201590e-02f,
  1.52808838e-02f, 1.08367004e-01f, -1.98857903e-01f, -5.87038435e-02f, 1.05083035e-02f, -2.89527267e-01f, -4.96346764e-02f, 7.79123977e-03f, -2.67207563e-01f, -5.10348044e-02f,
  1.65897310e-01f, 2.77130276e-01f, 1.38836071e-01f, 4.36202064e-02f, 1.74178153e-01f, -1.18764669e-01f, 7.15293735e-02f, 2.19297573e-01f, 3.69610451e-02f, 2.67894790e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 14)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 14;
const float L0_fan_Bp_bar_data[] = {
  4.49893743e-01f, 8.20684135e-01f, 6.22740328e-01f, 1.68669656e-01f, 5.73329568e-01f, 7.82793343e-01f, 7.90035188e-01f, 7.41542757e-01f, 2.81209588e-01f, 6.97129011e-01f,
  4.94766533e-01f, 8.18567336e-01f, 5.59578419e-01f, 6.00080788e-01f
};

// L1_fan_Wp (Shape: 1 x 16)
const int L1_fan_Wp_rows = 1;
const int L1_fan_Wp_cols = 16;
const float L1_fan_Wp_data[] = {
  9.51024666e-02f, 5.29736042e-01f, 3.14592570e-01f, -1.02274343e-02f, 1.19547978e-01f, -4.27686244e-01f, 2.07467750e-01f, -6.55275881e-02f, -3.86858106e-01f, 6.12070411e-02f,
  -2.59659309e-02f, -1.87873155e-01f, -1.59465894e-01f, -1.51525572e-01f, 2.71458268e-01f, -1.17282383e-01f
};

// L1_fan_Wp_bar (Shape: 14 x 16)
const int L1_fan_Wp_bar_rows = 14;
const int L1_fan_Wp_bar_cols = 16;
const float L1_fan_Wp_bar_data[] = {
  3.24241251e-01f, -1.23799193e+00f, 1.13351178e+00f, 4.29998696e-01f, 3.62962000e-02f, 3.46204698e-01f, -3.27475011e-01f, -2.65995622e-01f, 8.32142591e-01f, 8.29749107e-02f,
  9.70397472e-01f, -5.00922129e-02f, -1.58137269e-02f, -1.90425530e-01f, 4.29367691e-01f, 5.59924126e-01f, 3.08161199e-01f, -3.60585183e-01f, -2.83390522e-01f, 7.64331281e-01f,
  1.03524768e+00f, -5.23455203e-01f, 4.92094398e-01f, -4.36595172e-01f, 8.53357077e-01f, 3.77767473e-01f, 3.95576246e-02f, -3.81967366e-01f, 8.65892470e-01f, 7.98367143e-01f,
  1.48503855e-01f, -5.02398312e-01f, 8.19358766e-01f, 9.93958533e-01f, 7.44418442e-01f, 6.37918174e-01f, 4.34160113e-01f, -2.25432739e-01f, -2.08925441e-01f, 1.89477220e-01f,
  -9.50482607e-01f, 2.94680446e-01f, 1.58689946e-01f, -1.94795087e-01f, 3.64078671e-01f, -7.70699009e-02f, 9.81487095e-01f, -4.47176218e-01f, -2.34710872e-01f, 6.62073433e-01f,
  -2.01297700e-01f, -5.33100367e-01f, 1.41883880e-01f, -1.10798143e-01f, 7.93782473e-01f, 6.53253734e-01f, 6.97923243e-01f, 7.31033683e-01f, -3.18358213e-01f, 1.05536926e+00f,
  8.75860751e-01f, -4.80625272e-01f, 2.26648524e-01f, 6.13216579e-01f, -2.39461377e-01f, 4.28979427e-01f, 1.57911375e-01f, -1.05036430e-01f, 5.84133685e-01f, -3.15418929e-01f,
  7.19012558e-01f, -3.98787916e-01f, 1.70528576e-01f, 6.02839351e-01f, -4.54468369e-01f, 4.40158062e-02f, -3.28823447e-01f, -2.89401561e-01f, 1.70758486e-01f, 6.15918338e-01f,
  3.73946488e-01f, -3.21207076e-01f, 8.61541033e-01f, 3.65006387e-01f, -4.55650479e-01f, -2.51860738e-01f, -3.87949735e-01f, -4.18756127e-01f, 1.08317626e+00f, -8.61651957e-01f,
  -1.57932732e-02f, 1.08238840e+00f, 8.75940844e-02f, 1.39960051e-01f, 1.19629271e-01f, 5.53239882e-01f, -7.26760864e-01f, -6.32602125e-02f, 1.25738353e-01f, 1.08502366e-01f,
  -2.09509522e-01f, -5.01409709e-01f, 2.25846708e-01f, 1.04490376e+00f, 2.08145082e-02f, -6.61336184e-01f, -1.63540125e-01f, 1.52381867e-01f, 7.77554393e-01f, 9.52492595e-01f,
  7.81500638e-01f, -2.70182133e-01f, 3.28498811e-01f, 4.60240722e-01f, -1.63651049e-01f, 6.04512930e-01f, 5.65841496e-01f, -4.50073570e-01f, 3.86038423e-01f, 1.69679388e-01f,
  6.02730930e-01f, 9.29659188e-01f, 4.64328527e-01f, 7.71153629e-01f, 4.33918297e-01f, -7.22585797e-01f, -8.00697923e-01f, 1.69512182e-02f, 5.99819958e-01f, -6.05026037e-02f,
  -3.66371006e-01f, 7.04699337e-01f, 5.38249493e-01f, 2.19750196e-01f, 3.37545753e-01f, -4.56911504e-01f, 2.33183905e-01f, 2.53403246e-01f, 3.17927241e-01f, -7.38447607e-01f,
  -4.38233435e-01f, 9.83761668e-01f, -4.92641300e-01f, 7.29360402e-01f, 6.57998323e-02f, 6.84600770e-01f, 3.40095460e-02f, 5.23720562e-01f, 5.71625382e-02f, 1.71593234e-01f,
  7.19029605e-01f, 6.46030188e-01f, -6.50222540e-01f, 4.16832954e-01f, 9.85005498e-01f, -5.56404114e-01f, -6.38158321e-01f, 9.39185172e-02f, 3.54506373e-01f, 9.90224481e-01f,
  7.53088474e-01f, -8.81050229e-01f, 4.80944246e-01f, 7.47467458e-01f, -4.53165248e-02f, 6.85390711e-01f, -3.00259799e-01f, 3.94083261e-01f, -7.18754157e-02f, -4.51893866e-01f,
  6.91280365e-01f, -3.58264595e-02f, -6.17918611e-01f, 3.85469735e-01f, 5.24826884e-01f, 2.29742125e-01f, 2.45068356e-01f, -5.22756696e-01f, 9.85135660e-02f, -1.42633393e-01f,
  -1.73064202e-01f, 1.15981436e+00f, 9.92681086e-01f, 6.54685616e-01f, 3.36194396e-01f, 4.23183620e-01f, 1.56790063e-01f, 2.99935006e-02f, -6.92240596e-01f, 8.06101859e-01f,
  4.25376333e-02f, 1.98992640e-01f, 4.98992026e-01f, 2.06069753e-01f, 8.02245855e-01f, 3.72338027e-01f, 5.15803657e-02f, 9.00614858e-01f, -3.03010464e-01f, 9.97535646e-01f,
  -4.13430244e-01f, -6.14784025e-02f, 4.24891979e-01f, 9.07433212e-01f, 8.18459690e-01f, -2.01965094e-01f, 7.50962257e-01f, -3.34157720e-02f, 3.18905085e-01f, 1.97504207e-01f,
  3.45036238e-01f, -1.24274224e-01f, 3.71910393e-01f, 4.55947638e-01f, 8.00993860e-01f, -6.51648521e-01f, 8.04290950e-01f, 8.37929666e-01f, -6.45693898e-01f, -1.35292217e-01f,
  8.05834234e-01f, 3.76054883e-01f, 1.63979337e-01f, -3.14586967e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 14)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 14;
const float L1_fan_Bp_bar_data[] = {
  -9.27216262e-02f, 5.54896832e-01f, 1.07798243e+00f, 1.82141587e-01f, 8.99165049e-02f, 5.40903687e-01f, 2.19259381e-01f, 4.06598896e-01f, 7.91099370e-01f, 2.59509891e-01f,
  3.42595786e-01f, 1.18632987e-01f, 2.22303033e-01f, 5.70028663e-01f
};

// L2_linear_W (Shape: 12 x 16)
const int L2_linear_W_rows = 12;
const int L2_linear_W_cols = 16;
const float L2_linear_W_data[] = {
  -1.03049606e-01f, 6.19435132e-01f, 1.71426281e-01f, -7.35930085e-01f, 6.04366302e-01f, -9.44887280e-01f, -4.33603406e-01f, -6.99801669e-02f, 4.39400613e-01f, -6.35375857e-01f,
  -1.04094040e+00f, 6.34902157e-03f, 4.82553303e-01f, -3.78479809e-01f, 2.76598483e-01f, -9.75969732e-01f, 3.25148344e-01f, 3.41378421e-01f, 3.72436464e-01f, -3.15523386e-01f,
  6.38402179e-02f, 3.80391181e-02f, -3.75377774e-01f, 9.00558829e-01f, -8.55830014e-01f, -2.26727948e-01f, -1.12639666e+00f, -1.79969084e+00f, 6.46241680e-02f, 1.89471710e-02f,
  3.07682157e-01f, 1.30954802e-01f, -7.08717406e-01f, -4.36248571e-01f, 2.67411061e-02f, 5.25696516e-01f, -1.05536461e+00f, 3.98548394e-01f, -7.42015183e-01f, 3.32764119e-01f,
  2.75190473e-01f, 3.40494543e-01f, -9.07208443e-01f, -5.81628621e-01f, -1.38833630e+00f, -9.12829757e-01f, -2.33336002e-01f, 3.93789023e-01f, -3.62371564e-01f, -5.20546138e-01f,
  -3.04661006e-01f, -1.09246218e+00f, -9.06306744e-01f, 3.98557514e-01f, -5.98761618e-01f, -1.25026250e+00f, 9.79960933e-02f, -1.70437749e-02f, -4.37138885e-01f, 5.86750686e-01f,
  -8.03532377e-02f, 6.01140916e-01f, 1.19468868e-01f, -6.80109978e-01f, 6.17338359e-01f, -5.42103231e-01f, -7.35036612e-01f, 2.23638505e-01f, 6.03064239e-01f, -5.38731217e-01f,
  -1.16360760e+00f, -1.23509502e+00f, 6.61455572e-01f, -5.54502249e-01f, 3.26902151e-01f, 1.78952754e-01f, 1.05911799e-01f, 2.87242204e-01f, 1.18993372e-01f, 2.17922479e-01f,
  3.32423866e-01f, 1.84160411e-01f, 2.53246129e-01f, 3.14104766e-01f, 4.72169787e-01f, -6.65695071e-01f, -2.52681941e-01f, -1.65506322e-02f, -1.49099493e+00f, 6.65746152e-01f,
  4.43818718e-01f, 3.57554048e-01f, 3.05428326e-01f, -8.06643307e-01f, -1.90200180e-01f, -6.57852054e-01f, 1.90431811e-02f, -2.90393502e-01f, -8.24664235e-02f, 5.28149247e-01f,
  -1.04531753e+00f, -1.25171021e-01f, 1.17454961e-01f, -3.21261793e-01f, -1.18457782e+00f, 6.70866907e-01f, 4.17363763e-01f, -1.08384657e+00f, -5.15947282e-01f, 3.27271745e-02f,
  -7.09757924e-01f, 4.81078714e-01f, -8.33145916e-01f, 3.13895077e-01f, 4.73865479e-01f, -5.26404202e-01f, -1.10164082e+00f, -7.97602534e-01f, -1.10628498e+00f, -7.58936703e-01f,
  -5.41803002e-01f, -8.40228975e-01f, 4.70513940e-01f, 2.50060588e-01f, 5.66156447e-01f, 2.85791725e-01f, 2.22814843e-01f, -6.82003319e-01f, -1.71707839e-01f, 5.30360937e-01f,
  -3.89229745e-01f, 3.71054292e-01f, 7.37406850e-01f, 1.65157095e-01f, 1.87312171e-01f, -8.52956116e-01f, -9.33163539e-02f, -3.80731821e-01f, -7.36458123e-01f, -5.46150267e-01f,
  -1.06052017e+00f, -9.41294611e-01f, 3.23163778e-01f, 5.22104740e-01f, -2.73515254e-01f, -3.96622330e-01f, -1.32105812e-01f, 4.80553925e-01f, -1.07854271e+00f, -6.70553386e-01f,
  -1.29753518e+00f, 6.03317916e-01f, 4.64340895e-01f, -8.60391259e-01f, 4.86372858e-01f, -5.77195168e-01f, 1.86219648e-01f, 1.66131631e-01f, -7.31317282e-01f, -2.11935379e-02f,
  -1.84431657e-01f, -5.65179825e-01f, -9.30072904e-01f, -9.49341655e-01f, -1.86623484e-01f, 5.58078229e-01f, -2.48320237e-01f, 3.78926486e-01f, 4.87002224e-01f, 6.40924275e-01f,
  -3.40363801e-01f, -5.33556879e-01f, -6.97845757e-01f, -6.50313079e-01f, 5.70118785e-01f, -6.92622364e-01f, -1.24294184e-01f, 7.82522202e-01f, -7.28341699e-01f, -4.19273764e-01f,
  -4.46859092e-01f, 3.33324552e-01f, 9.51067030e-01f, -1.60565257e-01f, -5.32853186e-01f, 8.49392489e-02f, 3.78923416e-01f, 7.20174968e-01f, -1.00179017e+00f, -1.14168979e-01f,
  -7.47199655e-01f, 1.64291158e-01f
};

// L2_linear_B (Shape: 1 x 12)
const int L2_linear_B_rows = 1;
const int L2_linear_B_cols = 12;
const float L2_linear_B_data[] = {
  -1.40073851e-01f, 1.09669417e-01f, -4.15426463e-01f, -3.57009798e-01f, 5.48086941e-01f, -6.79467525e-03f, 3.38252559e-02f, -7.35193342e-02f, 1.69999711e-02f, -2.51272358e-02f,
  1.77700967e-01f, 6.27097040e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 1, 14
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        16, 1, 14
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_linear
    linear_forward_pgm(
        buffer1, x_out,
        L2_linear_W_data, L2_linear_B_data,
        16, 12
    );
    }
    