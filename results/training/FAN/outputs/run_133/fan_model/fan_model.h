/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 64 (x4)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 64;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    return (x > 0.0f) ? x : 0.0f;
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 6 x 120)
const int L0_fan_Wp_rows = 6;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -3.03236723e-01f, 4.94253561e-02f, -9.16560069e-02f, -1.45656601e-01f, -2.59154618e-01f, -9.72051248e-02f, -1.07664764e-01f, -9.71075520e-02f, 7.90825263e-02f, 1.79374218e-01f,
  -3.29398811e-02f, 7.68669769e-02f, 1.84353858e-01f, 2.72770803e-02f, -2.53327936e-01f, 2.14657500e-01f, -6.36330619e-02f, 4.86564673e-02f, 8.33309293e-02f, -9.72977355e-02f,
  8.75819549e-02f, -1.75481159e-02f, 8.20067748e-02f, 1.73634604e-01f, -1.49687335e-01f, 1.00220390e-01f, -6.48541003e-02f, 4.15379703e-02f, 1.43125415e-01f, 5.43953385e-03f,
  -3.67867351e-02f, 1.06354736e-01f, 9.11258440e-03f, 4.71151881e-02f, -6.44104481e-02f, -1.21967318e-02f, 1.22745121e-02f, -6.19053766e-02f, -5.30629680e-02f, 1.63639616e-02f,
  -4.12978381e-02f, -8.32464471e-02f, 2.25269143e-02f, 6.18700571e-02f, -9.33927223e-02f, -8.25147405e-02f, 2.75419140e-03f, -7.74101391e-02f, -6.92640170e-02f, -3.25593911e-02f,
  -7.13519305e-02f, -6.15141429e-02f, -2.74773221e-02f, -1.20225374e-03f, -4.96040583e-02f, -4.30390164e-02f, 1.07043840e-01f, 1.05916401e-02f, -1.06307596e-01f, 2.57910881e-02f,
  -1.03452638e-01f, -2.72393525e-02f, 1.12174563e-01f, 3.35040316e-02f, 2.54857205e-02f, -7.51963165e-03f, 7.18138814e-02f, 1.80446617e-02f, 4.54570688e-02f, 4.34249826e-02f,
  -2.09721196e-02f, 4.76546511e-02f, 5.97534962e-02f, 4.18912247e-03f, -3.83011103e-02f, 6.97322050e-03f, 4.27904241e-02f, -1.82443894e-02f, -5.42849228e-02f, 1.22805154e-02f,
  4.54097353e-02f, 1.91641244e-04f, 6.35094708e-03f, 1.70703456e-02f, -4.65349033e-02f, 1.09614329e-02f, 5.68000823e-02f, 2.47114487e-02f, -7.42925629e-02f, -4.57609519e-02f,
  5.35101816e-02f, 4.03561480e-02f, 1.19667500e-01f, -1.41346576e-02f, 8.88768956e-03f, 4.53846529e-02f, -4.69987132e-02f, -2.87251268e-02f, 1.09797373e-01f, -4.68096463e-03f,
  -3.87770571e-02f, 3.14937010e-02f, -9.46806967e-02f, -1.12717696e-01f, -2.49151848e-02f, 7.72235496e-03f, -4.39135469e-02f, -6.45695776e-02f, -8.88063163e-02f, -9.52626914e-02f,
  -9.82889310e-02f, 8.44091643e-04f, -4.74581532e-02f, -7.43892044e-02f, -6.77723065e-02f, -7.15639070e-02f, -3.90273519e-02f, -8.17094836e-03f, -7.92972818e-02f, 1.09387264e-01f,
  1.09829523e-01f, -2.71998286e-01f, 1.30231932e-01f, 3.46503854e-02f, 4.15530540e-02f, -1.47183016e-01f, -2.01078862e-01f, 1.96725756e-04f, 5.08099534e-02f, -2.07885340e-01f,
  -8.26809853e-02f, 2.29777470e-02f, -1.94354370e-01f, -2.14536767e-02f, -1.20645866e-01f, -5.60032651e-02f, -8.04329589e-02f, 9.10383984e-02f, 2.21690774e-01f, -6.94732741e-02f,
  1.29394114e-01f, -3.38299247e-03f, 5.27906865e-02f, 3.80029120e-02f, -7.21680224e-02f, 2.17812866e-01f, -9.76515487e-02f, 1.40405104e-01f, -8.78415070e-03f, -8.17722157e-02f,
  -1.72089040e-01f, 1.50638884e-02f, -3.53358686e-02f, 4.82740812e-03f, -5.63958026e-02f, 4.82352264e-03f, 5.19854166e-02f, -5.91344724e-04f, 4.85645086e-02f, 2.41243523e-02f,
  -6.60363659e-02f, -3.32903750e-02f, 1.65139772e-02f, 1.43410310e-01f, 3.92702445e-02f, 2.36980207e-02f, 2.53802314e-02f, 2.03369334e-02f, -4.84734401e-02f, -1.44696198e-02f,
  -3.03776972e-02f, -4.03829501e-04f, 5.11259139e-02f, 5.49700744e-02f, 5.39032258e-02f, 4.07134034e-02f, -1.90493725e-02f, 8.92184325e-04f, 9.66128241e-03f, -1.55194309e-02f,
  8.94553959e-02f, 7.21551478e-04f, 2.68409252e-02f, -1.38470501e-01f, -9.06116813e-02f, 3.75321209e-02f, -7.05211461e-02f, -2.80931871e-02f, -1.65708214e-02f, -1.70633316e-01f,
  -6.22867160e-02f, 5.52182049e-02f, 8.03715065e-02f, 1.29503664e-02f, 9.00710002e-02f, -3.22517455e-02f, 3.64102684e-02f, -7.13376179e-02f, 4.55080718e-02f, -1.22315856e-02f,
  -3.31518240e-02f, -3.49287018e-02f, -3.47759277e-02f, -3.13512720e-02f, -1.06276888e-02f, -5.73920310e-02f, -3.69158164e-02f, -3.88718322e-02f, -4.04106826e-02f, -5.63106798e-02f,
  -2.73383826e-01f, -1.45825386e-01f, -4.96728346e-02f, -6.12139776e-02f, -5.22478074e-02f, -1.80502664e-02f, 1.83122642e-02f, 3.71883623e-02f, -8.50587413e-02f, -9.42964200e-03f,
  -2.89124344e-02f, -5.90362288e-02f, 1.41024580e-02f, 8.63876939e-02f, -2.33381148e-02f, -6.67393953e-02f, 2.39513833e-02f, 4.28288914e-02f, -5.68127632e-02f, -9.88211408e-02f,
  1.20393815e-03f, -6.16646968e-02f, 7.79059455e-02f, 6.63999617e-02f, 1.04763526e-02f, -8.44869576e-03f, 1.03209555e-01f, 1.27155989e-01f, -8.92463326e-03f, 1.24562271e-02f,
  8.45436007e-02f, -5.69485277e-02f, -1.98304839e-02f, 2.19831437e-01f, 9.37514827e-02f, 4.36704494e-02f, 9.00629684e-02f, 1.08053438e-01f, -2.26260886e-01f, 5.47013758e-03f,
  2.00488582e-01f, -1.48680642e-01f, -1.00600816e-01f, 5.06010279e-02f, 5.91379181e-02f, -1.49310887e-01f, 1.97012022e-01f, -5.08999638e-02f, -7.53761679e-02f, 2.99886037e-02f,
  8.78735557e-02f, 1.51538715e-01f, 7.40513280e-02f, 2.83462778e-02f, 1.46178573e-01f, -1.36823170e-02f, 7.93097541e-02f, -7.65506476e-02f, 1.54976025e-01f, 4.98305075e-02f,
  1.72552206e-02f, 4.87918630e-02f, 9.08061564e-02f, -1.15694858e-01f, 9.31853801e-02f, 1.78200901e-02f, -4.47608642e-02f, 3.81606407e-02f, -1.28100723e-01f, 3.99357378e-02f,
  -2.35013179e-02f, -6.07340299e-02f, -3.57662700e-03f, -1.34125398e-02f, -1.71076804e-02f, -6.57554939e-02f, 4.24361676e-02f, -4.15968001e-02f, 3.54349017e-02f, -2.77834143e-02f,
  1.62537601e-02f, -7.03267902e-02f, -5.03318347e-02f, -4.56893444e-02f, -3.68383899e-02f, -1.29301539e-02f, -6.70868754e-02f, -2.11343039e-02f, 4.72141318e-02f, 1.53613202e-02f,
  -3.02333720e-02f, -3.22525650e-02f, -1.15469899e-02f, -5.29947989e-02f, 9.27897450e-03f, 5.45364281e-04f, 6.74729645e-02f, -4.05933708e-02f, -3.34297791e-02f, 9.02601108e-02f,
  3.69169712e-02f, 6.54914230e-02f, 5.75819388e-02f, -6.30637631e-02f, -1.40675073e-02f, -1.12345077e-01f, -6.57379180e-02f, -3.43424864e-02f, -2.60970127e-02f, 2.12797411e-02f,
  -3.03668119e-02f, -6.53362721e-02f, -5.30592864e-03f, 4.85832505e-02f, 3.64446864e-02f, -1.20873628e-02f, 6.42182305e-02f, 5.38711511e-02f, 5.56484796e-02f, -3.35479975e-02f,
  1.27518475e-01f, 7.61325806e-02f, -6.35480043e-03f, 3.89407501e-02f, -3.65309939e-02f, 8.08849484e-02f, -5.04308306e-02f, 1.94930453e-02f, -5.15386499e-02f, 8.21170658e-02f,
  4.89023998e-02f, -6.55070618e-02f, -2.91269682e-02f, 7.05800531e-03f, -1.86239481e-02f, -5.21361567e-02f, -1.18372357e-02f, 1.44858494e-01f, 7.34137520e-02f, 1.87992789e-02f,
  3.70763335e-03f, 1.93863567e-02f, 1.26915211e-02f, 1.39728822e-02f, -1.84507072e-02f, -1.20626735e-02f, -1.21169537e-01f, 3.50513197e-02f, 1.07033044e-01f, -8.56060311e-02f,
  -3.70813668e-01f, 1.51161507e-01f, 1.58880576e-01f, -1.33732438e-01f, -1.17502503e-01f, -9.66462120e-03f, -3.12514789e-02f, -1.38112545e-01f, -9.08978954e-02f, 1.45696744e-01f,
  -1.08141199e-01f, 1.59198105e-01f, 5.53180538e-02f, -1.30565632e-02f, -9.66169909e-02f, 6.58896938e-02f, -9.91328135e-02f, 1.14336319e-01f, -1.00562647e-02f, -1.78580850e-01f,
  -1.67280897e-01f, -7.47690424e-02f, -7.65224472e-02f, -8.29802305e-02f, -2.57997531e-02f, -4.37999591e-02f, -1.41682222e-01f, -1.93342324e-02f, -3.66581306e-02f, 4.84855436e-02f,
  -7.42855892e-02f, -4.52700928e-02f, 9.76984017e-03f, 3.22647654e-02f, -8.57720990e-03f, -2.69419644e-02f, 1.69224329e-02f, 8.14787596e-02f, -2.49757227e-02f, -7.21504167e-03f,
  1.09515384e-01f, 6.52119936e-03f, -6.46380261e-02f, 8.09719563e-02f, 1.47282714e-02f, 3.52745093e-02f, -9.76890624e-02f, 6.31846413e-02f, 4.52120006e-02f, 9.55398977e-02f,
  5.16320579e-02f, -1.34757545e-03f, 1.69837717e-02f, 4.22203653e-02f, 7.60079129e-03f, -4.87003364e-02f, 1.25289606e-02f, 8.77245236e-03f, 3.99177335e-02f, -5.36320582e-02f,
  1.32258320e-02f, -3.65544856e-02f, 3.39691900e-02f, -1.44560414e-03f, -8.71827069e-04f, -1.66133046e-02f, 7.60499667e-03f, -3.11852898e-02f, -2.35571526e-02f, -8.17164779e-02f,
  -3.67788710e-02f, -5.29036783e-02f, 2.96106953e-02f, 8.01223293e-02f, -2.93234382e-02f, 4.09751339e-03f, 4.37488556e-02f, 5.62737994e-02f, -5.46254143e-02f, -9.39700380e-02f,
  5.14837392e-02f, -1.04712829e-01f, -1.98976286e-02f, -6.46027699e-02f, 3.18584777e-02f, 1.05695818e-02f, 5.00737391e-02f, 7.49992877e-02f, -1.88250914e-02f, -1.72559451e-02f,
  -1.39180541e-01f, -8.76376778e-02f, 3.97406258e-02f, 5.03056869e-02f, -2.84034777e-02f, 5.13263233e-02f, -9.68817528e-03f, 6.62594512e-02f, 6.83792084e-02f, -1.11755803e-02f,
  -5.94752654e-02f, 1.45369405e-02f, -1.98558420e-02f, -3.38176228e-02f, -1.68516412e-02f, -5.84106101e-03f, -8.84236619e-02f, -1.11369103e-01f, 5.11768647e-03f, 1.09648304e-02f,
  -3.22852773e-03f, 2.06135605e-02f, -4.25038636e-02f, -9.63397603e-03f, -4.90589812e-02f, -1.85117610e-02f, -3.38799600e-03f, 5.23937866e-03f, -6.09475821e-02f, -2.58059893e-02f,
  1.37838023e-02f, -9.10340622e-02f, -3.62606905e-02f, -2.59310100e-02f, -1.74928289e-02f, 1.27336979e-01f, 1.00105561e-01f, -1.59216076e-01f, -1.80576459e-01f, -1.19240992e-01f,
  1.39897928e-01f, -9.00117010e-02f, 2.54686531e-02f, 6.04573041e-02f, 3.60347241e-01f, 1.15247443e-01f, 2.33560458e-01f, 1.59871072e-01f, -7.91082438e-03f, -1.06678151e-01f,
  3.95730659e-02f, 1.55721709e-01f, 1.79070011e-01f, 1.82749275e-02f, -7.16332793e-02f, -7.65439942e-02f, 2.70771887e-03f, -1.51372291e-02f, 1.58209234e-01f, 8.72793198e-02f,
  1.01086885e-01f, -1.70654207e-01f, -6.04472458e-02f, -7.02375872e-03f, -3.84159684e-02f, -1.81982983e-02f, 1.10046960e-01f, 2.31343675e-02f, 2.93415990e-02f, 3.28032449e-02f,
  -3.64046507e-02f, -1.20944325e-02f, -1.94716007e-02f, 7.08126128e-02f, 1.70240626e-02f, -6.82222396e-02f, -5.81738837e-02f, 1.06983349e-01f, -2.92805880e-02f, -5.17504150e-03f,
  4.86389399e-02f, 1.29498258e-01f, -5.52610755e-02f, 3.38284299e-02f, 6.49488494e-02f, 2.20392998e-02f, 4.68333736e-02f, 5.52612776e-03f, 3.70589793e-02f, -7.35541955e-02f,
  -2.71558054e-02f, -5.04250973e-02f, 4.03468050e-02f, 7.04132244e-02f, 8.02120045e-02f, -8.43056105e-03f, -2.47711968e-02f, -4.27985052e-03f, -2.90304516e-02f, 7.29685575e-02f,
  -5.42673143e-03f, -7.07630590e-02f, 1.12234782e-02f, -2.05929149e-02f, 2.54878514e-02f, -1.42709445e-02f, 3.58724711e-03f, -1.52083281e-02f, 3.16379382e-03f, 4.30567674e-02f,
  8.15875530e-02f, -5.72950654e-02f, -5.80310635e-02f, 3.04442290e-02f, 6.55155480e-02f, -2.68143024e-02f, -7.11690709e-02f, -1.49833458e-02f, 1.85077395e-02f, 1.28063604e-01f,
  3.17479186e-02f, -1.62326604e-01f, -3.60430554e-02f, -3.00740544e-02f, 1.57914981e-02f, 1.21496268e-01f, -5.69471531e-03f, 4.00227262e-03f, -3.34185213e-02f, -5.12099359e-03f,
  1.30283581e-02f, 4.37976420e-03f, 3.12961340e-02f, -4.86585125e-02f, 1.03068966e-02f, 3.25817727e-02f, 7.17062056e-02f, -4.63866480e-02f, -6.11651093e-02f, 1.50230480e-02f,
  3.77361216e-02f, 2.73935683e-02f, 1.46791916e-02f, 6.43916577e-02f, -1.08025167e-02f, -5.50224297e-02f, 2.74859276e-02f, -7.14822412e-02f, -1.45360660e-02f, -2.00778842e-02f,
  1.08481850e-02f, -1.13444224e-01f, 2.08949700e-01f, -1.67775795e-01f, 1.01398401e-01f, -1.77050710e-01f, -3.98265496e-02f, -2.84911203e-03f, 5.92585467e-03f, -8.69328901e-02f,
  7.66590750e-03f, 2.15843648e-01f, 2.06551746e-01f, -3.22359085e-01f, 1.08127408e-01f, 6.77369460e-02f, -2.47877479e-01f, -1.21840984e-01f, 7.17478339e-03f, -6.53003603e-02f,
  -2.48516649e-02f, -2.31341600e-01f, -4.62613218e-02f, -9.47827399e-02f, -7.91535527e-02f, -3.80335003e-02f, -7.07986802e-02f, 1.72100365e-02f, -1.51366442e-01f, 3.17746177e-02f,
  -1.16319142e-01f, 5.39122755e-03f, 7.05731735e-02f, 7.54768476e-02f, 2.18201950e-02f, -7.75205716e-02f, -3.53691727e-02f, 4.54490371e-02f, 1.33962056e-03f, 6.20546527e-02f,
  5.03724255e-02f, 3.68497595e-02f, 3.55605222e-02f, -1.38453785e-02f, -1.07796483e-01f, 4.45534997e-02f, 9.05296654e-02f, 2.85324901e-02f, 8.90506506e-02f, 6.87198117e-02f,
  8.93405005e-02f, -4.20271605e-02f, -9.83745679e-02f, -3.17407735e-02f, -3.54328491e-02f, 6.92082429e-03f, 5.75134493e-02f, 1.20840609e-01f, 2.65051834e-02f, 1.12678349e-01f,
  -8.42848495e-02f, 8.43462050e-02f, -1.21216634e-02f, 9.97063890e-03f, -3.49294581e-02f, -6.62942836e-03f, -4.93641980e-02f, 1.85194518e-02f, -4.04841714e-02f, -7.24334568e-02f,
  4.40462492e-02f, -1.16556864e-02f, 8.48116912e-03f, -1.74033251e-02f, -1.59218330e-02f, -8.54749754e-02f, 6.06359588e-03f, 4.61636931e-02f, -4.93419468e-02f, -4.98956181e-02f,
  8.37981608e-03f, 2.44351830e-02f, -9.08712484e-03f, -9.99750942e-03f, -5.26219979e-02f, 2.50739213e-02f, 5.22150248e-02f, -7.93860629e-02f, -3.60829420e-02f, 9.94536933e-03f,
  -2.59118617e-01f, -2.59135425e-01f, -5.29193059e-02f, -3.63938175e-02f, -6.72997907e-02f, -2.31860857e-02f, 9.75231677e-02f, -1.00194225e-02f, -1.17330439e-01f, -2.99256351e-02f,
  -2.11733039e-02f, 1.04409093e-02f, -2.37927195e-02f, 2.21320335e-03f, -3.57782189e-03f, -5.11731580e-02f, -6.05410226e-02f, -6.62351623e-02f, -4.42791507e-02f, -7.08155632e-02f,
  2.43287068e-02f, -5.33143757e-03f, 1.05388403e-01f, -2.23755222e-02f, 5.46075776e-03f, -3.89056467e-02f, -1.35886529e-03f, 7.93409869e-02f, 9.67970192e-02f, 3.44886519e-02f
};

// L0_fan_Wp_bar (Shape: 52 x 120)
const int L0_fan_Wp_bar_rows = 52;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -2.44506057e-02f, -1.83249335e-03f, 4.26236987e-02f, 4.05587442e-03f, 7.88190886e-02f, 2.09819481e-01f, 2.24390671e-01f, -2.49467120e-02f, -1.02883086e-01f, 8.69447812e-02f,
  7.21356366e-03f, -5.00923768e-02f, 6.33259416e-02f, 4.75326516e-02f, 1.46194220e-01f, -5.24793714e-02f, 4.40911204e-02f, 2.91428622e-02f, -2.37171389e-02f, -1.15019038e-01f,
  -1.01464372e-02f, 5.97508699e-02f, 2.55635809e-02f, -1.26210883e-01f, 8.34862739e-02f, -1.83284163e-01f, -2.40534153e-02f, -9.11105424e-02f, 8.15610867e-03f, 3.19788083e-02f,
  3.73251215e-02f, -5.26496954e-02f, 4.32289094e-02f, -4.90956791e-02f, -2.67941765e-02f, 3.49324830e-02f, -2.62865294e-02f, 6.41378313e-02f, 1.85132287e-02f, 6.30999207e-02f,
  4.83221412e-02f, 9.86428838e-03f, 3.70316617e-02f, -3.75913791e-02f, -5.73753975e-02f, 9.85550806e-02f, -1.88669544e-02f, 3.98119446e-03f, -1.40554041e-01f, 3.95164192e-02f,
  -7.80131593e-02f, -5.61970361e-02f, 1.35570299e-02f, -7.40478234e-03f, -4.63767648e-02f, -8.32758769e-02f, -1.79638586e-03f, -2.12960946e-03f, 7.65428618e-02f, -4.15847152e-02f,
  -3.13087255e-02f, -3.86589244e-02f, 1.38596138e-02f, 1.84077099e-02f, 1.21643573e-01f, -7.35059828e-02f, 4.10989299e-02f, -2.80674058e-03f, -1.49420261e-01f, -3.60209681e-02f,
  -1.54625699e-01f, -6.45301165e-03f, 2.51810905e-02f, 4.32391465e-02f, -4.02940884e-02f, -1.24166291e-02f, 1.53265968e-01f, -4.88715172e-02f, 1.52355134e-02f, 9.48857740e-02f,
  -8.26897919e-02f, -1.14533201e-01f, 7.78883230e-03f, 5.70855998e-02f, 1.10942073e-01f, 1.45377051e-02f, -2.51466595e-03f, -9.11976397e-03f, -3.87328304e-02f, -1.51276095e-02f,
  -1.96080636e-02f, 2.72048358e-02f, -6.02927655e-02f, -6.08724095e-02f, -9.09871608e-02f, 6.57660514e-03f, 4.70047183e-02f, 3.98284197e-02f, -4.42691334e-02f, 5.96993901e-02f,
  1.00855306e-01f, -8.69540200e-02f, -4.32777889e-02f, -1.24826416e-01f, -7.70710930e-02f, 2.08591651e-02f, -8.76936037e-03f, -1.62172839e-02f, -2.37620510e-02f, -9.82903987e-02f,
  -1.19993858e-01f, -7.75180105e-03f, 9.92670842e-03f, 1.05980895e-01f, 4.92227674e-02f, -8.55759308e-02f, -7.12776706e-02f, -1.93324666e-02f, 1.33429155e-01f, 2.07864046e-02f,
  2.19527259e-01f, -1.48089111e-01f, -2.97619790e-01f, -5.08218184e-02f, 2.08608150e-01f, 3.51329371e-02f, -5.71744479e-02f, 1.82119701e-02f, -5.97545616e-02f, -1.91422198e-02f,
  5.63117787e-02f, 5.52470125e-02f, -2.94653803e-01f, 1.11550301e-01f, 1.87278986e-01f, -1.55131459e-01f, 1.70594513e-01f, 6.69863299e-02f, -2.96918936e-02f, 7.25354254e-02f,
  4.06608582e-02f, 2.16368884e-01f, -8.78555477e-02f, 1.68796360e-01f, 1.41756758e-01f, -1.46302864e-01f, 2.81676278e-02f, -1.64030686e-01f, 1.42089337e-01f, 1.11580543e-01f,
  5.83156534e-02f, 1.34007388e-03f, 5.41359372e-02f, 1.56536624e-02f, -8.96550715e-03f, 9.03416984e-03f, -5.35448678e-02f, -9.70778540e-02f, -1.87152624e-02f, -4.89127729e-03f,
  -5.11346944e-02f, 2.95828246e-02f, 9.31451563e-03f, 5.69624975e-02f, 1.53107285e-01f, 7.85168167e-03f, -4.11042944e-02f, -4.22860384e-02f, -2.02089697e-02f, 4.78679277e-02f,
  -6.19862191e-02f, -2.53316539e-04f, -3.32926884e-02f, -1.50162652e-01f, 1.49383182e-02f, 2.23432090e-02f, -8.94682258e-02f, -5.99895231e-03f, 3.06067914e-02f, 3.14623341e-02f,
  6.18811250e-02f, 6.05800860e-02f, 7.50069739e-04f, 1.72829051e-02f, -1.33132236e-02f, -4.29097051e-03f, 7.60183856e-02f, -1.11314267e-01f, -2.67063025e-02f, 1.97989307e-02f,
  -1.26502458e-02f, -1.32812619e-01f, -2.26676594e-02f, 7.29089081e-02f, 5.27717955e-02f, -5.81517033e-02f, 9.24169645e-03f, 4.07863073e-02f, -3.59850973e-02f, -4.73370701e-02f,
  -7.28573278e-02f, -8.11652094e-03f, 4.58893403e-02f, -7.59505704e-02f, -2.06666384e-02f, 9.53152403e-02f, 6.42879382e-02f, 8.46076105e-03f, -5.72309305e-04f, 1.43825905e-02f,
  -6.43261075e-02f, -5.49337789e-02f, 3.84063390e-03f, 1.72254201e-02f, -1.27667949e-01f, 6.50827289e-02f, 6.09946102e-02f, 7.70411417e-02f, 1.73637830e-02f, -9.07835457e-03f,
  4.53547807e-03f, -8.39018375e-02f, 4.05955613e-02f, 5.87639399e-02f, 7.58842900e-02f, -1.00174826e-02f, -7.66486451e-02f, -5.20968251e-06f, -6.27265684e-03f, 2.81818188e-03f,
  2.80562192e-02f, -2.08926387e-02f, -6.35083839e-02f, -9.34775323e-02f, -3.53674255e-02f, -3.69201750e-02f, -6.52211532e-02f, -1.82266310e-02f, -2.52588596e-02f, -7.40185454e-02f,
  7.14815259e-02f, 1.77019879e-01f, 1.40465423e-01f, 1.53828755e-01f, -9.69359949e-02f, -1.92111805e-01f, -1.46593228e-01f, 6.95516989e-02f, -1.86750725e-01f, 1.72011778e-02f,
  1.76263358e-02f, 2.18250081e-02f, 3.97085398e-03f, -1.04778431e-01f, 6.57236055e-02f, -1.43527612e-01f, 9.81069207e-02f, -1.10084854e-01f, -8.54448453e-02f, 2.07727566e-01f,
  -7.19985515e-02f, 9.57114920e-02f, 1.80818647e-01f, 2.07649037e-01f, 9.94113460e-02f, 6.49450347e-02f, 3.25740486e-01f, 2.81741675e-02f, 1.61224112e-01f, 1.43023089e-01f,
  -8.45004618e-02f, -3.11115198e-02f, -2.15476733e-02f, -1.48190781e-01f, 6.45886511e-02f, -7.76689798e-02f, 7.50044500e-03f, -3.76833440e-03f, -3.20397913e-02f, 1.12348644e-03f,
  -1.02335535e-01f, 2.62271706e-02f, 2.68748719e-02f, -1.46077529e-01f, 9.79855210e-02f, 4.87426557e-02f, -5.40439896e-02f, -5.54819824e-03f, -9.51204225e-02f, -1.36623848e-02f,
  -3.91970091e-02f, -4.88097742e-02f, 4.46152613e-02f, 5.81191480e-02f, 8.61925632e-02f, 4.80755093e-03f, 2.40584426e-02f, 7.49942288e-02f, -9.27594770e-03f, -1.85320657e-02f,
  5.25433160e-02f, 9.47065465e-03f, -1.82127953e-02f, -2.77708452e-02f, -9.90258828e-02f, -1.02029696e-01f, -6.26283213e-02f, 1.31909642e-02f, -4.93284315e-02f, -4.58924565e-03f,
  -6.60611093e-02f, -6.74352646e-02f, -6.72539510e-03f, 4.76656742e-02f, -3.05789057e-02f, -1.89777851e-01f, -3.82010490e-02f, 3.69600058e-02f, -1.09101199e-02f, 4.60465380e-04f,
  -2.19276808e-02f, 1.20878154e-02f, -7.75667727e-02f, -8.23212508e-03f, 1.73838455e-02f, 3.91108803e-02f, 1.17005385e-01f, -7.86462650e-02f, -2.11458914e-02f, -1.16267819e-02f,
  9.33774486e-02f, 1.71852723e-01f, 2.53092963e-03f, -4.09842608e-03f, -9.82200652e-02f, -6.82317466e-02f, -1.56791523e-01f, -2.98275258e-02f, 1.33241177e-01f, 9.90648288e-04f,
  5.72743304e-02f, 1.05225609e-03f, -5.83969429e-03f, 1.90379433e-02f, 7.14262202e-02f, -2.80561410e-02f, 7.20203370e-02f, -7.80263394e-02f, 1.30822197e-01f, 3.85122634e-02f,
  4.18894514e-02f, -1.70616746e-01f, -2.85663139e-02f, -2.02452391e-02f, 7.21140485e-03f, -9.26801842e-03f, -1.87122282e-02f, 9.50834006e-02f, -7.37477168e-02f, -9.04479809e-03f,
  -2.49240976e-02f, 3.42498757e-02f, -3.07043970e-01f, -6.29218370e-02f, 1.65369853e-01f, 1.82656869e-01f, 6.72998503e-02f, 8.12417641e-02f, -3.06308657e-01f, 1.20841667e-01f,
  1.73706353e-01f, -9.76082310e-02f, -1.90285012e-01f, 2.12343872e-01f, 6.65103644e-02f, -2.34440193e-01f, 1.52176961e-01f, 2.15213209e-01f, -4.56332974e-02f, 1.46872044e-01f,
  -1.14274872e-02f, 2.81353503e-01f, -7.14634657e-02f, 2.04467803e-01f, 2.23393336e-01f, -1.93204507e-02f, 1.23632737e-01f, -1.33003145e-01f, 2.94875950e-01f, 1.13884538e-01f,
  5.93103170e-02f, 2.68245991e-02f, 9.71286092e-03f, -3.41448784e-02f, 6.65541589e-02f, 1.35474131e-01f, 4.22592610e-02f, -3.63552682e-02f, 3.03405221e-04f, -2.86613852e-02f,
  5.06636836e-02f, -3.79381962e-02f, 2.40507862e-03f, 2.78923027e-02f, 5.59791215e-02f, 9.81417075e-02f, 1.27695536e-03f, -5.89022860e-02f, -3.64629216e-02f, 3.46641839e-02f,
  -1.28175288e-01f, 4.82154191e-02f, -7.27872401e-02f, -5.12783043e-02f, -9.49382186e-02f, 9.53680929e-03f, -2.47987127e-03f, 1.57294311e-02f, 5.28061092e-02f, 5.70516326e-02f,
  3.35247293e-02f, 2.42725983e-02f, 8.81402194e-02f, -3.07920743e-02f, -4.19455171e-02f, 1.25730205e-02f, 4.59743738e-02f, 7.65250111e-03f, -4.71439585e-02f, 3.40742804e-03f,
  -4.15090937e-03f, 6.92541152e-03f, 7.17661679e-02f, 1.04850985e-01f, 5.44927046e-02f, 3.04755606e-02f, 5.83327115e-02f, 5.97188016e-03f, -3.19803879e-02f, -2.21186634e-02f,
  2.13616639e-02f, -3.75376530e-02f, -1.11980792e-02f, -4.13407087e-02f, 3.01292557e-02f, -2.20881682e-03f, 7.05820397e-02f, 4.08261307e-02f, -4.30108681e-02f, -3.23854201e-02f,
  3.20040025e-02f, 5.38287386e-02f, 2.47942191e-02f, 5.46059906e-02f, -1.58055127e-01f, 2.24785842e-02f, -2.49896497e-02f, 9.01201740e-02f, -3.07535361e-02f, 1.43195000e-02f,
  8.54748785e-02f, -3.25257592e-02f, 2.41518505e-02f, -6.87227994e-02f, 9.90805449e-04f, -3.11127901e-02f, -4.06733640e-02f, -2.63145119e-02f, -5.26291393e-02f, -3.19384485e-02f,
  6.18342012e-02f, 6.23742007e-02f, -1.56820983e-01f, -6.36175796e-02f, -2.95965839e-02f, 1.10533368e-02f, 5.22398204e-02f, 9.78157818e-02f, 9.59085897e-02f, -8.32073390e-02f,
  7.87656102e-03f, -8.41532648e-03f, -4.25629169e-02f, -4.57888516e-03f, 1.07299641e-01f, -4.54842672e-02f, -4.73894738e-02f, 1.81095116e-03f, -1.08477041e-01f, 1.27279162e-02f,
  3.05778291e-02f, -1.00254558e-01f, -5.19036539e-02f, -3.29180621e-02f, 4.92167100e-02f, -2.31692642e-01f, -3.54252453e-03f, -1.01608239e-01f, -1.03652626e-01f, 1.83115005e-01f,
  3.23889442e-02f, 1.87916815e-01f, -2.46149153e-02f, 8.24242160e-02f, 1.18072428e-01f, 1.49887338e-01f, 2.82205045e-01f, 3.67880464e-02f, 1.89663440e-01f, 9.29706544e-03f,
  -2.04793364e-02f, -6.82638586e-02f, -4.91414107e-02f, -1.08945869e-01f, 1.01441093e-01f, 2.23946217e-02f, 5.04065901e-02f, -8.81280676e-02f, -1.77115239e-02f, -9.11510065e-02f,
  6.34707510e-02f, -1.09435534e-02f, 5.40279299e-02f, -8.68492201e-02f, -5.54449856e-02f, 5.32790534e-02f, -1.40657285e-02f, -4.64869849e-02f, -5.37943058e-02f, 1.24292308e-02f,
  3.53357308e-02f, -2.82739922e-02f, -9.79261752e-03f, 3.08487583e-02f, 4.33644094e-02f, -2.78148451e-04f, 8.76995549e-03f, 1.24144427e-01f, -2.78121489e-03f, 9.97250085e-04f,
  1.07186221e-01f, -2.67648045e-02f, -6.20238297e-02f, -7.61651322e-02f, 2.23063072e-03f, -8.40683058e-02f, -7.98192322e-02f, 1.32113444e-02f, 6.47460436e-03f, 8.23385417e-02f,
  -6.25645816e-02f, 2.06340589e-02f, -5.80127537e-02f, 4.26384844e-02f, 7.97547102e-02f, -5.41713536e-02f, -8.37347806e-02f, -2.01616213e-02f, 8.47745910e-02f, -5.55310659e-02f,
  -9.25907958e-03f, 5.91618381e-02f, -1.47579825e-02f, -8.03343058e-02f, -2.26696879e-02f, 4.91905212e-02f, -1.51967863e-03f, 6.91592842e-02f, 7.23255500e-02f, -3.47625390e-02f,
  2.76115276e-02f, 1.62482142e-01f, 2.40740869e-02f, -2.10186001e-02f, -4.87869494e-02f, -3.73698622e-02f, -2.89511587e-02f, -6.25817180e-02f, -1.99815463e-02f, -2.78961137e-02f,
  9.60876495e-02f, -6.87284172e-02f, 2.12425143e-02f, 8.96463469e-02f, -1.04370364e-03f, 1.96575541e-02f, 5.95799610e-02f, 8.40501562e-02f, 1.48197174e-01f, 9.63106230e-02f,
  2.22168386e-01f, 4.77269143e-02f, 1.15799587e-02f, 9.78965089e-02f, 9.06950533e-02f, -3.93473916e-02f, 9.47040245e-02f, 6.71173036e-02f, 2.10157186e-02f, -3.86329964e-02f,
  1.47376150e-01f, 4.48629819e-02f, 1.06214426e-01f, 2.91437954e-01f, 5.27180126e-03f, -1.72077969e-01f, -1.75810710e-01f, 5.35524376e-02f, 6.75319135e-02f, -3.09021212e-02f,
  -8.67742598e-02f, 1.27442315e-01f, -2.13885978e-01f, 5.07954806e-02f, -2.32574657e-01f, -2.42771462e-01f, -6.04569279e-02f, 8.98934603e-02f, -4.60460335e-02f, 1.04765274e-01f,
  -4.54564467e-02f, -8.03660005e-02f, 1.23418085e-01f, 1.15212470e-01f, 1.85111001e-01f, 1.66561663e-01f, 7.58215189e-02f, 1.04345549e-02f, 1.90456167e-01f, -1.59987688e-01f,
  -2.17439793e-02f, 4.19399478e-02f, 7.35220835e-02f, 4.82993387e-02f, -3.22840512e-02f, -3.37996036e-02f, -2.21958682e-02f, 1.26885355e-01f, -9.08953696e-03f, 6.49461299e-02f,
  -3.91129814e-02f, -4.56174649e-02f, 4.13274132e-02f, 3.23023014e-02f, 4.26054746e-02f, 5.66195101e-02f, 1.04715727e-01f, 3.53320725e-02f, 1.30151302e-01f, -1.25586865e-02f,
  7.69306570e-02f, 4.61259075e-02f, 3.57867144e-02f, -8.62265006e-02f, -1.57996695e-02f, -1.71667114e-02f, 6.31172881e-02f, 9.24441777e-03f, 1.02232486e-01f, -2.03371253e-02f,
  -1.23744145e-01f, -1.48070753e-01f, -1.90955326e-02f, 1.00907832e-01f, -4.82316501e-02f, 1.90931070e-03f, 5.35493810e-03f, -3.01698614e-02f, -6.93846401e-03f, 7.87761714e-03f,
  1.37712853e-02f, 1.21130846e-01f, -2.13280302e-02f, 1.05508603e-01f, -3.71426940e-02f, 1.16362888e-02f, -4.97880727e-02f, 3.05784326e-02f, 2.24284586e-02f, 1.05150685e-01f,
  3.53063978e-02f, -3.84483375e-02f, 2.50283554e-02f, 3.61893252e-02f, -4.75796834e-02f, 3.31223160e-02f, 2.00038757e-02f, 2.12092996e-02f, -2.73422841e-02f, -2.61504799e-02f,
  -1.45978153e-01f, -3.69337089e-02f, -4.69923727e-02f, -5.74874207e-02f, 1.86497215e-02f, 9.68638342e-03f, -3.15841436e-02f, -2.35716011e-02f, -8.75473097e-02f, 2.14398792e-03f,
  -3.49669345e-02f, 8.56074691e-03f, -5.49370721e-02f, 3.77086140e-02f, -3.43215913e-02f, 3.41881067e-02f, -8.19552913e-02f, -8.83152410e-02f, 3.68503183e-02f, 7.86686987e-02f,
  1.82824396e-02f, -9.38317552e-03f, -3.09325960e-02f, 6.35657907e-02f, 4.09323536e-02f, 1.42707536e-02f, -1.11777382e-02f, 4.96869236e-02f, 2.44055074e-02f, -1.73762254e-02f,
  5.08134626e-02f, 1.69299841e-01f, 3.02930009e-02f, 2.20091134e-01f, 6.20708801e-02f, 5.35901682e-03f, 7.04105794e-02f, 1.82755783e-01f, 2.08867282e-01f, 1.19418018e-01f,
  -4.36555333e-02f, 2.34620467e-01f, 9.94531345e-03f, 1.05621286e-01f, 2.37714291e-01f, 9.05071720e-02f, 2.76576251e-01f, 5.64525165e-02f, 8.83482546e-02f, 1.86515987e-01f,
  7.82102197e-02f, 1.70519456e-01f, -1.07085764e-01f, -4.31373790e-02f, -1.49684966e-01f, -1.34014815e-01f, -1.64407983e-01f, -7.77657032e-02f, -8.44978541e-03f, -7.48043181e-03f,
  -9.95339546e-03f, 6.78889900e-02f, 2.35954486e-02f, -8.91424119e-02f, 1.16458498e-02f, -6.30872846e-02f, 4.61545438e-02f, -5.90291284e-02f, 5.49945561e-03f, -3.19247576e-03f,
  -4.05352935e-03f, 4.07028347e-02f, 9.20917764e-02f, -9.15337726e-02f, 1.12742782e-01f, -6.31886050e-02f, -4.70209643e-02f, -4.16930616e-02f, 1.34241749e-02f, -5.05794808e-02f,
  -5.81896454e-02f, -8.26973766e-02f, 5.39922379e-02f, 4.56038341e-02f, -7.57432878e-02f, 6.14549331e-02f, 1.73199025e-03f, -7.88290403e-04f, 3.38216648e-02f, 8.79062489e-02f,
  -7.59103987e-03f, 1.17934290e-02f, -4.09775339e-02f, 1.58263966e-02f, 7.33223483e-02f, -1.37970403e-01f, 1.43040540e-02f, 6.27816189e-03f, -2.80094799e-02f, -4.02867831e-02f,
  5.97158261e-02f, -4.74064872e-02f, -2.60507558e-02f, 5.09406477e-02f, 5.59690855e-02f, -5.29959574e-02f, -4.15910073e-02f, -3.96062136e-02f, 7.10962014e-03f, -2.14606840e-02f,
  -4.76485044e-02f, 1.12850172e-02f, -2.99012996e-02f, -7.64852688e-02f, 3.93544883e-02f, -2.59370059e-02f, -8.14659670e-02f, -6.10688813e-02f, 5.70232570e-02f, -2.93834135e-02f,
  7.04562515e-02f, 2.58550435e-01f, 9.29838570e-04f, 1.81668792e-02f, 5.05318716e-02f, 2.25907974e-02f, 1.72950551e-01f, 8.17278847e-02f, 2.79178750e-02f, -5.64154759e-02f,
  -1.36720377e-03f, 4.57040593e-02f, 3.55484821e-02f, -1.10074438e-01f, 4.18578871e-02f, 5.45176640e-02f, 5.01259975e-03f, -5.20641021e-02f, 1.47166252e-01f, 4.37389202e-02f,
  -5.77869676e-02f, -3.97105031e-02f, 1.12187769e-02f, -2.52478607e-02f, -2.48373747e-02f, -1.48503900e-01f, 3.18187810e-02f, -3.69961374e-02f, 2.32493579e-02f, 5.22595793e-02f,
  2.24744812e-01f, 3.75685096e-02f, 1.18240714e-01f, 1.68602169e-01f, 1.78164616e-01f, 9.45210084e-02f, 2.54710913e-01f, 1.33466989e-01f, 2.31041804e-01f, -9.22743306e-02f,
  -2.64923591e-02f, 1.06713362e-01f, -1.21181004e-01f, -1.92723051e-02f, -1.09895654e-01f, 1.02346921e-02f, 2.45442037e-02f, 3.66299562e-02f, 2.06216455e-01f, -5.23576960e-02f,
  -5.13948733e-04f, -1.00094147e-01f, -1.25756487e-02f, -1.42697424e-01f, -1.92125775e-02f, 1.86061580e-02f, -1.04351118e-01f, 1.00756690e-01f, -1.16086572e-01f, -9.87732876e-03f,
  -3.77742946e-02f, 1.34612799e-01f, -8.94230977e-03f, 5.08044213e-02f, -1.07512288e-01f, 8.10290426e-02f, 1.23991808e-02f, -5.20129763e-02f, 4.03591357e-02f, -4.74682897e-02f,
  -3.65509167e-02f, -8.11843798e-02f, 1.57395247e-02f, -5.52641898e-02f, 8.66032541e-02f, -3.27946059e-02f, 5.42287380e-02f, 6.98105544e-02f, 8.45472142e-02f, -1.79045815e-02f,
  -5.63234203e-02f, 4.98619936e-02f, 1.26060816e-02f, 8.95078108e-02f, 4.64576706e-02f, 2.46055469e-01f, 8.39345157e-02f, -5.21353856e-02f, -9.62946862e-02f, 1.62474424e-01f,
  2.85578184e-02f, 1.10381782e-01f, 5.96766546e-02f, -1.47026390e-01f, -3.76497731e-02f, -8.83036703e-02f, -2.20317096e-02f, -6.34548217e-02f, 6.86407962e-04f, -6.78150281e-02f,
  -2.15581059e-02f, 7.55254850e-02f, -6.57105297e-02f, 1.37440292e-02f, 7.71853849e-02f, -5.07403016e-02f, -2.03035232e-02f, -1.18039258e-01f, 6.78254366e-02f, -8.61680806e-02f,
  9.37004462e-02f, 3.48744579e-02f, -1.09744251e-01f, -2.02468745e-02f, 1.06454000e-01f, -3.21919157e-04f, -9.39657167e-02f, -7.29087144e-02f, -5.99903464e-02f, -8.04205090e-02f,
  -1.12453267e-01f, 2.85442509e-02f, -2.09835488e-02f, 5.66868596e-02f, -9.84227732e-02f, -4.11631837e-02f, 7.88407517e-04f, -7.74710774e-02f, -4.13544066e-02f, 9.28235799e-03f,
  8.23536515e-02f, -4.62229177e-02f, 9.45858434e-02f, -4.96346205e-02f, 5.93079105e-02f, 3.53508294e-02f, -1.87061280e-02f, 7.47542456e-02f, -2.26665307e-02f, -1.23474129e-01f,
  -8.60503390e-02f, -1.75005570e-02f, -5.80515377e-02f, 7.51259178e-02f, -8.45148787e-02f, 9.62224379e-02f, 1.60144828e-02f, -2.11698245e-02f, -4.96054590e-02f, 8.17178190e-03f,
  -4.02785361e-01f, 2.02611506e-01f, 5.78023233e-02f, 6.87135756e-02f, -1.94695398e-01f, 3.19837332e-01f, 3.44156772e-01f, 3.51789631e-02f, 1.54983163e-01f, 2.60313779e-01f,
  2.39283651e-01f, 7.97787905e-02f, 1.73599094e-01f, 1.70999780e-01f, 1.65197849e-01f, 1.73561782e-01f, 1.56446978e-01f, 2.22788811e-01f, -6.57706484e-02f, -2.46414598e-02f,
  -2.41984427e-02f, 1.14015304e-01f, 1.05798490e-01f, -1.24616854e-01f, -8.22300091e-02f, -1.74630865e-01f, -6.85917437e-02f, -1.03601255e-01f, 4.61773500e-02f, 5.31604588e-02f,
  -9.03766528e-02f, -2.08966509e-01f, -3.38191092e-02f, 1.13565780e-01f, 2.30431855e-02f, -4.30502370e-02f, -6.00229241e-02f, -6.90369084e-02f, -7.11303353e-02f, 8.31568334e-03f,
  -8.26363824e-03f, -1.27483293e-01f, 9.70162973e-02f, 7.37120025e-03f, 3.37962769e-02f, -3.36616077e-02f, 4.24763151e-02f, 2.13842429e-02f, 7.49088973e-02f, -1.51603147e-02f,
  6.95191920e-02f, -3.29063199e-02f, 1.37580603e-01f, 9.19643268e-02f, -2.65431684e-02f, -7.99653959e-03f, 1.58963557e-02f, 7.74244815e-02f, 2.91555692e-02f, 5.83985634e-02f,
  6.24234304e-02f, -6.92616925e-02f, -6.11826777e-03f, -3.59460190e-02f, 8.63575116e-02f, -7.03069121e-02f, -3.58854420e-02f, 9.61315557e-02f, 3.23033892e-02f, 6.99805981e-03f,
  8.43978971e-02f, 2.09774934e-02f, 3.70837003e-02f, 7.27629438e-02f, -4.91399951e-02f, 3.00018489e-02f, 1.77547392e-02f, -8.52855518e-02f, 3.29341590e-02f, 7.53823221e-02f,
  2.99135391e-02f, 9.88697559e-02f, -6.89416528e-02f, 6.23041429e-02f, -4.42577712e-02f, 4.27633971e-02f, 5.35930134e-02f, 4.86348793e-02f, 1.01139642e-01f, 1.25580177e-01f,
  9.00495499e-02f, -5.76984882e-02f, 3.15648876e-02f, -3.53639247e-03f, -3.18147205e-02f, -1.10245394e-02f, -4.02137525e-02f, 1.11847129e-02f, 5.57591468e-02f, 1.97810866e-02f,
  5.71307587e-03f, -4.03231122e-02f, -4.70715500e-02f, 1.67226754e-02f, 7.09502632e-03f, 1.03365161e-01f, 6.20297343e-02f, 1.60224363e-02f, 5.25997318e-02f, 4.78557013e-02f,
  -8.28518197e-02f, -2.07861122e-02f, 6.11122809e-02f, -2.35790107e-02f, 3.50222588e-02f, 3.44895162e-02f, -8.98937955e-02f, 3.08917742e-02f, -1.27040949e-02f, 3.58407944e-02f,
  9.12354514e-02f, -2.40731224e-01f, -2.97932774e-01f, 1.16128577e-02f, 9.48712081e-02f, 3.83373946e-02f, -4.40056659e-02f, 1.64824247e-01f, -8.03505257e-02f, 1.51958838e-02f,
  1.17710985e-01f, -1.75790268e-03f, -2.33262241e-01f, 5.97693212e-02f, 5.05235307e-02f, -1.48824781e-01f, 8.45005438e-02f, 6.53252006e-02f, -5.36194891e-02f, 2.86528133e-02f,
  2.16878310e-01f, 1.56651467e-01f, 1.09919228e-01f, 3.69742662e-01f, 1.01395644e-01f, 1.48982674e-01f, 2.82897621e-01f, 8.81748125e-02f, 3.88457119e-01f, 1.55452862e-01f,
  -6.47205338e-02f, -1.11147083e-01f, -8.25161301e-03f, 2.80190520e-02f, 3.91099826e-02f, 1.25594050e-01f, 7.58392960e-02f, 5.66130094e-02f, -2.48499326e-02f, -6.08467609e-02f,
  6.48169592e-03f, 3.19701387e-03f, 1.16563700e-01f, 4.19302769e-02f, -2.06872951e-02f, -4.39477190e-02f, 5.58400676e-02f, 6.97164843e-03f, -4.31739837e-02f, -1.78124185e-03f,
  -6.90362751e-02f, -9.75295156e-03f, 2.44779941e-02f, 1.24707175e-02f, -7.58593455e-02f, 1.98479393e-03f, 1.25237763e-01f, -4.27263007e-02f, -5.80058759e-03f, 6.14479259e-02f,
  3.15560028e-02f, 4.15221276e-03f, -5.98794147e-02f, -1.02120332e-01f, 6.80475216e-03f, -7.07053095e-02f, -2.13135444e-02f, -3.73650566e-02f, -5.60779385e-02f, 1.03902733e-02f,
  -1.69842523e-02f, 3.38309743e-02f, -4.85682078e-02f, 2.00742087e-03f, 1.25437945e-01f, -3.21229510e-02f, 4.67795739e-03f, -2.92149354e-02f, -1.07265607e-01f, -6.98183626e-02f,
  9.98703018e-03f, 3.10415961e-03f, -4.19786125e-02f, 8.11196119e-02f, 4.34916057e-02f, 2.96059018e-03f, -4.27355729e-02f, -1.22618573e-02f, 4.56801690e-02f, 1.01866052e-01f,
  1.15085416e-01f, -2.81213466e-02f, -9.55877900e-02f, 3.45548615e-02f, 4.87107858e-02f, -5.15083596e-03f, -3.76841053e-02f, 6.48011193e-02f, 9.88486260e-02f, -5.29479608e-02f,
  4.12744023e-02f, 2.75471117e-02f, 2.34815106e-02f, -2.88335532e-02f, 1.05952062e-01f, -6.03927998e-03f, -3.00846118e-02f, 3.90665829e-02f, 1.04051903e-01f, 3.55943479e-02f,
  1.09774219e-02f, -3.90827879e-02f, 6.25178963e-02f, -1.09212868e-01f, -1.95473079e-02f, 1.06455944e-02f, 5.95683455e-02f, 5.70390485e-02f, -2.94573624e-02f, -5.88269904e-02f,
  1.97242156e-01f, -5.47041260e-02f, 1.61872879e-01f, 2.15915382e-01f, 5.85496090e-02f, 1.40762761e-01f, 1.34556979e-01f, 9.24781896e-03f, 2.59663641e-01f, -1.15598388e-01f,
  -1.11653246e-01f, 1.39197379e-01f, -3.19990478e-02f, -1.03975302e-02f, -1.47395343e-01f, -6.07014485e-02f, 4.86083366e-02f, 1.68923158e-02f, 8.89628530e-02f, 5.53239323e-02f,
  -1.95450895e-02f, -5.65638691e-02f, -9.38608218e-03f, -1.75667197e-01f, 1.26196697e-01f, 6.62293285e-02f, -1.98800206e-01f, 8.42963681e-02f, -1.29309678e-02f, -3.68616916e-02f,
  1.05935568e-02f, 4.90676463e-02f, 7.83775467e-03f, -1.68109253e-01f, 2.95889359e-02f, -5.72532304e-02f, 8.83097351e-02f, 9.74331573e-02f, 5.72348200e-02f, 7.42655769e-02f,
  1.19726323e-01f, -3.21740136e-02f, 6.16938882e-02f, 7.57668093e-02f, 1.60999801e-02f, -7.74962008e-02f, 5.22530936e-02f, -1.21686487e-02f, 8.25429708e-02f, -9.05628502e-03f,
  4.14806092e-03f, 9.49210897e-02f, -9.03310161e-03f, -1.17081247e-01f, 2.49397680e-02f, 1.98093504e-02f, -3.34106311e-02f, 3.68677974e-02f, 1.62761519e-03f, 2.91972043e-04f,
  -5.98475002e-02f, -4.12507430e-02f, -9.22827236e-03f, 8.10934007e-02f, 8.41808133e-03f, -1.23476371e-01f, 3.80398482e-02f, -2.51060724e-02f, 3.71949449e-02f, 7.74118863e-03f,
  8.37738439e-02f, 7.44303465e-02f, 7.84116834e-02f, 7.16025159e-02f, 1.92354876e-03f, -1.36288077e-01f, -2.75195148e-02f, -3.85697884e-03f, -3.59421410e-03f, 3.08888294e-02f,
  -2.34141204e-04f, -7.05229957e-03f, -5.32176420e-02f, 8.13326146e-03f, 2.34584883e-02f, 8.14515352e-02f, -1.41445771e-02f, 1.67958196e-02f, -4.30520959e-02f, 6.51654880e-03f,
  -6.24646656e-02f, -2.00867742e-01f, 2.09878869e-02f, -1.42572567e-01f, -4.46824729e-02f, -8.83272737e-02f, 1.52400648e-02f, -4.64379042e-02f, 9.37526971e-02f, -7.40862563e-02f,
  -7.83223938e-03f, 6.02268539e-02f, 6.49360269e-02f, -3.84589471e-02f, -5.65880090e-02f, 1.14591438e-02f, 5.99153340e-02f, -9.86109227e-02f, 9.99420602e-03f, -1.07203528e-01f,
  1.31408200e-01f, 7.44874962e-03f, -3.19336504e-02f, -1.88779403e-02f, -6.11824505e-02f, 7.15868920e-03f, -3.38000916e-02f, 3.52657959e-02f, -1.55636091e-02f, -5.25558426e-04f,
  2.88765341e-01f, 6.76094219e-02f, 1.57752514e-01f, 2.64220208e-01f, 3.59039381e-02f, -2.00848639e-01f, -3.51829380e-02f, 3.77214514e-02f, 2.60131836e-01f, -1.73396379e-01f,
  7.85524324e-02f, 3.14010796e-03f, -1.13379896e-01f, 1.66875258e-01f, -7.97301531e-02f, -1.85469970e-01f, 2.92208623e-02f, -3.55848558e-02f, 1.28221840e-01f, 8.52696374e-02f,
  2.81663507e-01f, 1.21822511e-03f, 7.23187476e-02f, -1.05141744e-01f, 1.72795668e-01f, 2.01556295e-01f, 4.07658843e-03f, 2.73728147e-02f, -6.68542981e-02f, -1.31633699e-01f,
  -6.82874024e-02f, 8.11583772e-02f, -5.47817582e-03f, 1.86446812e-02f, 5.99429682e-02f, -2.01077964e-02f, -7.66317621e-02f, -1.03177905e-01f, 4.39248420e-02f, 2.61597242e-02f,
  3.50386798e-02f, -2.50427127e-02f, 1.88199803e-02f, -6.13674112e-02f, 7.54846781e-02f, 5.00193797e-02f, 1.45637780e-01f, 1.37517378e-01f, -2.50795055e-02f, 2.22698711e-02f,
  8.20459798e-02f, 1.11436784e-01f, 1.15868866e-01f, -1.02925219e-01f, 6.71676099e-02f, 2.24870704e-02f, -1.03613185e-02f, -5.38760498e-02f, 6.45108819e-02f, 8.10139477e-02f,
  -2.05344651e-02f, -1.05465595e-02f, 2.27150414e-02f, -7.29918629e-02f, 2.87498012e-02f, 7.77296200e-02f, 9.70466658e-02f, -8.55536480e-03f, 5.44729941e-02f, 1.61238499e-02f,
  3.81570160e-02f, -1.04251271e-02f, 2.83196680e-02f, -4.23663221e-02f, 2.53317207e-02f, -2.23125927e-02f, -9.46524665e-02f, -8.97826478e-02f, -3.87192257e-02f, 5.10765947e-02f,
  5.19596003e-02f, -6.80975523e-03f, 1.96888410e-02f, -1.36423305e-01f, -9.64934751e-03f, 1.06685022e-02f, -3.72147374e-02f, 7.56929349e-03f, 6.01252019e-02f, -4.49740514e-02f,
  -2.28167735e-02f, -3.75415348e-02f, 5.84202595e-02f, -7.23417178e-02f, -1.58098768e-02f, 2.06654146e-02f, 3.60516123e-02f, 6.91942638e-03f, -1.34485858e-02f, 1.26147224e-02f,
  2.70979721e-02f, -5.73015139e-02f, -1.22612290e-01f, -3.11169736e-02f, 4.08478752e-02f, -1.13115488e-02f, -3.87228578e-02f, 8.70674103e-02f, -1.61512047e-02f, 4.57649156e-02f,
  2.29681954e-02f, 3.25602740e-02f, 8.85376055e-03f, 6.47616163e-02f, 8.11514705e-02f, -1.86978336e-02f, -3.60258040e-03f, -1.28122345e-02f, -5.89632727e-02f, -2.64858548e-02f,
  1.23692602e-01f, -3.22811157e-01f, 6.77808523e-02f, 1.23462558e-01f, 1.88035026e-01f, -2.08595451e-02f, 9.07455981e-02f, -8.27057064e-02f, -9.92718861e-02f, -2.59139478e-01f,
  -6.07526191e-02f, -8.04794673e-03f, -1.22830048e-01f, -3.24563533e-02f, 1.93944484e-01f, -1.28286526e-01f, 1.32478163e-01f, -1.43580576e-02f, 9.00825784e-02f, -1.79928709e-02f,
  5.79297729e-02f, 1.07888699e-01f, 6.33782148e-02f, 9.59405452e-02f, -2.47314945e-02f, 1.40043562e-02f, -5.00274003e-02f, -6.91182464e-02f, 7.62827918e-02f, 7.03278929e-02f,
  -6.94428906e-02f, -1.08474046e-01f, -4.70824279e-02f, -6.16471730e-02f, -5.15860915e-02f, -1.05949543e-01f, 3.68464626e-02f, 8.04519653e-02f, 3.84589173e-02f, -1.87406689e-02f,
  -8.60603526e-02f, -1.45307919e-02f, 7.94625282e-02f, -1.16920155e-02f, 6.25850335e-02f, 4.81915809e-02f, -6.88278303e-02f, 2.83215921e-02f, 6.23704446e-03f, 9.34537724e-02f,
  5.26499338e-02f, 6.19493723e-02f, 1.06101580e-01f, 5.11174724e-02f, 3.69283445e-02f, 5.10178171e-02f, 2.85699293e-02f, 1.53674213e-02f, -2.48395428e-02f, -5.89716695e-02f,
  -6.52917940e-03f, -3.22479680e-02f, -1.45030752e-01f, 1.00076869e-02f, -1.67109910e-02f, 1.70352757e-02f, 5.55069968e-02f, 5.16247340e-02f, 2.65767612e-02f, -9.38126370e-02f,
  -1.01241628e-02f, -2.65499614e-02f, -2.39406619e-02f, 3.59815247e-02f, -1.11181520e-01f, 1.23735238e-03f, 5.08231223e-02f, 3.46650928e-02f, -7.99914151e-02f, -2.22733468e-02f,
  5.05087525e-02f, 1.69589818e-02f, -1.81943234e-02f, -1.26538547e-02f, -3.64817455e-02f, -9.19991136e-02f, -5.16027072e-03f, -4.17525880e-02f, -3.77113521e-02f, 1.88827906e-02f,
  -1.88048735e-01f, -2.85547286e-01f, -6.90477416e-02f, 1.11661607e-03f, -1.32073117e-02f, -7.34490752e-02f, 1.07521497e-01f, -4.07640859e-02f, -4.20379862e-02f, 2.05211240e-04f,
  7.76999369e-02f, 6.24764115e-02f, -2.21776702e-02f, 2.67584976e-02f, 4.07146178e-02f, -9.61550921e-02f, -1.11291915e-01f, -6.80878535e-02f, -4.80195880e-03f, 7.33917356e-02f,
  -1.05810530e-01f, 6.59433827e-02f, 1.25039130e-01f, 8.04336220e-02f, -4.56408306e-04f, -3.63571718e-02f, 2.61659510e-02f, 6.25176430e-02f, 1.34425998e-01f, -1.32594388e-02f,
  1.74442977e-01f, -2.81920552e-01f, 5.35040945e-02f, -8.50646850e-03f, 2.02992652e-03f, -8.38078856e-02f, 1.83118135e-01f, -1.77015170e-01f, -5.40678985e-02f, -2.00577632e-01f,
  -5.30268364e-02f, 1.31008103e-01f, 1.02784567e-01f, -1.78302541e-01f, 3.30925196e-01f, 8.64068195e-02f, 7.27053266e-03f, -5.15114749e-03f, 8.45060349e-02f, -1.24738619e-01f,
  7.51459098e-04f, -1.42732337e-01f, 9.52297971e-02f, -2.52389222e-01f, -1.25969172e-01f, -9.46402773e-02f, 6.59326985e-02f, 2.00645238e-01f, -1.67930499e-01f, 8.01580250e-02f,
  4.08252701e-03f, -1.32892966e-01f, 1.11355609e-03f, -2.27451837e-03f, -1.01842046e-01f, -2.49573626e-02f, 1.18141711e-01f, 1.75950751e-01f, 5.38616404e-02f, -6.86512887e-02f,
  -1.94107722e-02f, -1.66232307e-02f, -6.22574463e-02f, -2.60124225e-02f, -5.00622801e-02f, -1.09863937e-01f, -7.48903751e-02f, 7.64801726e-02f, -8.41655955e-02f, 1.11282580e-01f,
  7.26877078e-02f, -1.79401264e-02f, 4.90105525e-02f, -9.98649150e-02f, -1.26955993e-02f, -2.75769792e-02f, 7.37220272e-02f, 8.70174691e-02f, -3.62466201e-02f, -2.53312085e-02f,
  -6.86607743e-03f, -4.10814025e-02f, 2.50166189e-02f, -5.72865754e-02f, -1.18030291e-02f, -8.75057653e-02f, -8.69032890e-02f, 1.74786765e-02f, 2.51325388e-02f, 8.76314044e-02f,
  -4.12509730e-03f, -8.72282013e-02f, 1.43918851e-02f, 3.30569111e-02f, -4.93839569e-02f, -8.36639404e-02f, 8.90791193e-02f, -7.10888579e-02f, 4.58375923e-02f, 2.97156144e-02f,
  8.80712345e-02f, 3.73979732e-02f, 5.42061068e-02f, 1.82746898e-03f, -9.68843047e-03f, 1.37612805e-01f, 3.25434767e-02f, -6.49939552e-02f, -2.81388853e-02f, 1.07211061e-01f,
  -9.43187103e-02f, -1.75074175e-01f, -8.09027180e-02f, -5.72885536e-02f, -1.75365414e-02f, 7.54325241e-02f, -6.40983880e-02f, -4.89067845e-02f, -1.00536942e-01f, -4.71746400e-02f,
  2.30694842e-02f, 4.80009103e-03f, -8.36569667e-02f, -9.09810662e-02f, 9.97812208e-03f, -3.60920243e-02f, 6.57069683e-03f, -8.93064067e-02f, -7.44327297e-03f, -5.87563291e-02f,
  -4.44151312e-02f, -3.98999527e-02f, 3.24670635e-02f, -1.20795488e-01f, -5.07366508e-02f, 3.14721316e-02f, -1.32608891e-01f, 7.07168281e-02f, -1.23668853e-02f, 1.95443891e-02f,
  -6.59096763e-02f, 7.32602701e-02f, -1.02642380e-01f, 6.75185397e-03f, -2.00399876e-01f, 1.88233659e-01f, 2.19370246e-01f, 6.40557613e-03f, 4.62246872e-03f, 3.13470542e-01f,
  1.64781630e-01f, -7.70303011e-02f, 2.09765643e-01f, 2.58029342e-01f, -4.61096764e-02f, 1.19458921e-01f, 1.02503270e-01f, 1.04073226e-01f, 3.70614529e-02f, 5.40163890e-02f,
  -7.03881979e-02f, 2.34530970e-01f, -3.36373737e-03f, 2.55003497e-02f, 7.30252266e-02f, -1.21729366e-01f, -1.23725357e-02f, -5.99761382e-02f, 9.60727781e-02f, -5.47436066e-03f,
  1.10168710e-01f, 2.81654634e-02f, -1.07475154e-01f, 1.92061923e-02f, -1.21147253e-01f, 6.04073284e-03f, 1.88156590e-02f, -3.71872224e-02f, -7.70311728e-02f, 6.63391501e-02f,
  6.30508438e-02f, -8.60513896e-02f, 3.24066915e-02f, -2.14652158e-02f, 7.55440742e-02f, -4.33992445e-02f, -4.36520763e-02f, 1.37350885e-02f, 4.13662493e-02f, 9.72366706e-02f,
  5.77436164e-02f, -4.60813101e-03f, 1.05715850e-02f, 9.44325235e-03f, -1.21024676e-01f, 1.55306514e-02f, -2.27516480e-02f, 7.20554441e-02f, -6.06282167e-02f, -7.48079047e-02f,
  -5.27533516e-02f, 5.48970066e-02f, 2.20993198e-02f, 6.74330667e-02f, -1.32663146e-01f, -4.11721952e-02f, 2.50641126e-02f, -3.01180687e-02f, -1.23750260e-02f, 2.36446075e-02f,
  -1.06840115e-02f, -1.16961889e-01f, 3.28081362e-02f, -1.09557230e-02f, 5.90775497e-02f, 8.19763690e-02f, 3.47403176e-02f, 6.11024424e-02f, 4.98813111e-03f, 8.78741685e-03f,
  7.46458247e-02f, -8.35699588e-02f, -2.02822480e-02f, 3.64355333e-02f, 4.26139235e-02f, 1.73471700e-02f, -4.33601439e-02f, 2.69408319e-02f, 8.19576681e-02f, -1.23253778e-01f,
  9.99026597e-02f, 1.78162441e-01f, 2.17939308e-03f, -1.03979073e-01f, 1.19277835e-02f, -5.51375300e-02f, -3.10052950e-02f, 5.27075939e-02f, -4.00911309e-02f, 6.84306026e-02f,
  4.95272204e-02f, -8.07174966e-02f, 2.18896079e-03f, -6.58495501e-02f, -8.14152882e-02f, 2.11410336e-02f, 5.66351749e-02f, 2.04621535e-02f, 1.00087393e-02f, -5.24035431e-02f,
  -7.98034072e-02f, 5.02965553e-03f, 3.89361866e-02f, -1.19286999e-02f, 5.02826273e-02f, 6.74527809e-02f, -1.01399474e-01f, 7.36362487e-02f, -3.37029546e-02f, 8.09590220e-02f,
  -1.12470940e-01f, 5.23600876e-02f, -1.75924033e-01f, -1.14813939e-01f, 1.30069822e-01f, -1.08886091e-02f, 2.58367192e-02f, -3.20376381e-02f, -5.65915927e-03f, 1.26311839e-01f,
  -3.27057131e-02f, -5.05922586e-02f, -6.46850467e-02f, -2.82070935e-01f, -4.07833129e-01f, -2.25536942e-01f, -1.17579773e-01f, 7.71749318e-02f, -7.31877759e-02f, 1.30145941e-02f,
  -1.16369292e-01f, -3.92070562e-02f, -1.57517821e-01f, 7.87612945e-02f, 1.12420209e-01f, 1.13878332e-01f, 1.36065006e-01f, 1.35236651e-01f, 2.97752321e-02f, 4.00095284e-02f,
  -6.70733452e-02f, -3.53710279e-02f, -2.49262936e-02f, -3.88815440e-02f, -1.13864588e-02f, 9.40706283e-02f, 7.06727579e-02f, -1.03266221e-02f, -1.93620636e-03f, 3.66546176e-02f,
  2.28345674e-02f, -5.56087978e-02f, -1.42870462e-02f, -1.01354100e-01f, 3.67511660e-02f, 4.47859466e-02f, -6.61532301e-03f, 4.05182019e-02f, 2.70476211e-02f, -1.23737268e-01f,
  -2.39426252e-02f, 9.66720935e-03f, 1.04357369e-01f, -4.39020544e-02f, -5.19834924e-03f, -2.61576679e-02f, 2.11212151e-02f, 7.31674731e-02f, 8.34829137e-02f, -3.35179828e-02f,
  9.65248272e-02f, -6.67239726e-02f, -8.63751844e-02f, -4.84032631e-02f, -6.39911043e-03f, -2.59220097e-02f, -1.00784011e-01f, 7.08696246e-02f, 3.43605950e-02f, 2.81935707e-02f,
  -6.41021207e-02f, -5.16056046e-02f, -6.21756576e-02f, 1.56312548e-02f, -4.56543127e-03f, -2.18195133e-02f, -7.62045905e-02f, -2.58509014e-02f, -2.70926580e-02f, 2.12698095e-02f,
  -3.35910693e-02f, -1.53068891e-02f, -2.84035783e-03f, 7.83832222e-02f, -1.88426545e-03f, 5.36541268e-02f, 1.16740279e-02f, 2.35964265e-02f, 7.44730383e-02f, 2.15472113e-02f,
  5.58352144e-03f, -2.31867121e-03f, -5.75605668e-02f, 2.05767527e-02f, 4.63374006e-03f, 2.78243553e-02f, -1.24620376e-02f, -4.30368967e-02f, -5.47770225e-02f, -1.56363305e-02f,
  1.37788150e-02f, 2.11299375e-05f, 1.13122433e-01f, -6.90482631e-02f, 3.52856889e-02f, -3.34109589e-02f, 1.11440338e-01f, -4.40340973e-02f, 5.02471365e-02f, -3.87333743e-02f,
  1.71468288e-01f, -5.56358844e-02f, 2.19362658e-02f, 3.73142064e-02f, 3.25432904e-02f, -1.91714056e-02f, 8.57309327e-02f, -1.55880554e-02f, -1.29108112e-02f, -3.77799720e-02f,
  -4.05565947e-01f, 2.15769991e-01f, 1.33396117e-02f, -5.30265225e-03f, -1.22924089e-01f, 2.21488371e-01f, 2.12544128e-02f, 9.48488787e-02f, -1.05777398e-01f, 5.15598580e-02f,
  -1.53871447e-01f, -2.45432220e-02f, 1.21307045e-01f, 1.12366863e-03f, 1.02270007e-01f, 7.14127496e-02f, 6.43392503e-02f, -4.13277224e-02f, 5.94362952e-02f, -1.30138695e-02f,
  2.77005620e-02f, 1.24648428e-02f, 5.80595955e-02f, 9.26223770e-02f, -1.13623746e-01f, -4.51182872e-02f, -8.60188380e-02f, -5.64862564e-02f, -2.75950730e-02f, -1.29694462e-01f,
  -1.26978740e-01f, -2.39884466e-01f, -9.25454646e-02f, -7.20572844e-02f, -1.54687651e-02f, 1.40164038e-02f, -5.15658371e-02f, -8.89305398e-02f, -3.64740007e-02f, 1.17734186e-01f,
  -7.53978193e-02f, 9.02089104e-03f, -4.92324121e-03f, 8.06957390e-03f, 1.32568888e-02f, -9.39127877e-02f, -5.64341731e-02f, -5.65255359e-02f, -3.84974889e-02f, 8.30712393e-02f,
  5.34940325e-02f, 1.22254984e-02f, 7.40358187e-03f, -1.20583810e-02f, -3.72823514e-03f, -4.21778522e-02f, 1.17319832e-02f, 9.05500725e-03f, 1.48070604e-02f, -4.18550223e-02f,
  6.99795857e-02f, 6.78429157e-02f, -8.14623758e-02f, 2.90500205e-02f, 1.26429778e-02f, -3.39800008e-02f, -9.10717770e-02f, -6.27142983e-03f, 6.65956438e-02f, 5.09263799e-02f,
  1.82999037e-02f, -1.79129746e-02f, -6.54717237e-02f, -7.30035314e-03f, -4.31809090e-02f, -9.10613388e-02f, -3.91642526e-02f, -2.82776654e-02f, -2.75330478e-03f, -4.57319729e-02f,
  4.38213870e-02f, -6.45711273e-02f, -6.69270158e-02f, 7.25651905e-02f, 7.69917518e-02f, -1.51117984e-02f, 6.69063488e-03f, -2.49380227e-02f, -3.52962837e-02f, -1.84287056e-02f,
  -1.62188485e-01f, -1.38624072e-01f, -1.26427561e-01f, -5.62534332e-02f, -1.34856012e-02f, -3.48854437e-02f, 9.39580984e-03f, 4.39725146e-02f, -5.65951839e-02f, 6.87841028e-02f,
  -3.59387845e-02f, -3.38291414e-02f, -8.85391142e-03f, -1.02813728e-02f, 5.72126843e-02f, -9.08936784e-02f, 3.41927297e-02f, -1.16412394e-01f, -9.77464486e-03f, 9.86534054e-04f,
  6.73945025e-02f, -3.15871499e-02f, 2.96117999e-02f, 1.26804262e-02f, 2.74744034e-02f, -4.39959355e-02f, -4.18544821e-02f, 2.89345402e-02f, -1.26666750e-03f, 7.07728863e-02f,
  -1.14248008e-01f, -1.26842454e-01f, 2.26771712e-01f, -2.29649082e-01f, 3.45661528e-02f, 1.04993954e-01f, 1.18778542e-01f, -1.43431455e-01f, -1.92203328e-01f, -2.49733284e-01f,
  -9.37468745e-03f, 7.08571896e-02f, 1.77960381e-01f, -1.11949198e-01f, 3.21367741e-01f, 9.95602831e-02f, -1.14335842e-01f, -6.04904033e-02f, -2.80042924e-03f, -1.18224241e-01f,
  -1.51169319e-02f, -1.15985796e-01f, 9.32724327e-02f, -1.06024109e-01f, -3.71888839e-02f, -5.51384091e-02f, 5.07981293e-02f, 1.53689981e-01f, -1.11689366e-01f, 4.15961966e-02f,
  7.60633275e-02f, -4.19856347e-02f, 6.11641146e-02f, 9.10179541e-02f, 4.30330448e-02f, 2.18970776e-02f, 4.15732935e-02f, 1.13656290e-01f, 8.08574036e-02f, -4.86192154e-03f,
  3.43392566e-02f, -1.55261718e-02f, -1.30010054e-01f, -3.04278508e-02f, -1.53555915e-01f, -3.58597450e-02f, 1.75931200e-03f, 1.67600103e-02f, 6.51857182e-02f, 6.28667697e-03f,
  -2.51084249e-02f, 2.27046385e-02f, -8.08515027e-02f, -1.20185204e-01f, -7.20593929e-02f, -3.88986319e-02f, 1.14088371e-01f, 5.12155257e-02f, -2.43248474e-02f, -5.31889275e-02f,
  -4.79764156e-02f, 3.86984386e-02f, -1.74623076e-02f, 1.02480501e-02f, 3.33465199e-04f, -6.18313439e-02f, 2.06469260e-02f, 4.31409329e-02f, -6.45873602e-03f, -3.38079073e-02f,
  6.94692461e-03f, 2.12582061e-03f, 1.44813349e-02f, 1.44077362e-02f, -9.36396867e-02f, 1.64489746e-02f, 6.70462698e-02f, -1.71991196e-02f, -7.73491412e-02f, -5.87383425e-03f,
  -4.84373756e-02f, -2.63927504e-02f, -7.80239627e-02f, -4.54691760e-02f, 1.00829430e-01f, 3.78845930e-02f, -3.02704424e-02f, 1.28013482e-02f, 7.50983283e-02f, 6.45354539e-02f,
  -9.48110223e-03f, -1.83204934e-01f, 9.10907611e-02f, -1.69694219e-02f, -1.89976953e-02f, 1.65979471e-02f, 4.53862436e-02f, -3.73097397e-02f, 2.50369427e-03f, 2.19667777e-02f,
  -4.17943150e-02f, -4.57549002e-03f, -4.39379225e-03f, -6.16799109e-03f, -1.65723283e-02f, -3.00759375e-02f, -5.65121844e-02f, 6.61097988e-02f, 3.46677378e-02f, 1.90738554e-03f,
  8.22940003e-03f, -3.67893837e-02f, -1.45439416e-01f, -2.95714457e-02f, -1.23947687e-01f, 4.91089420e-03f, -8.60472955e-03f, 4.15276960e-02f, -2.47676354e-02f, -4.36259322e-02f,
  -2.94355466e-03f, -3.20420146e-01f, -2.10371882e-01f, -2.09610090e-01f, -3.06959618e-02f, -1.54629782e-01f, -1.84649885e-01f, -2.24121995e-02f, -1.04086310e-01f, 5.34903407e-02f,
  4.22660299e-02f, -1.93678916e-01f, 1.08654626e-01f, -3.06659639e-01f, -2.23436639e-01f, -5.61539382e-02f, -1.93304271e-01f, -1.03754826e-01f, 4.70901933e-03f, -5.72446808e-02f,
  -1.37473181e-01f, -1.14436567e-01f, -2.42586568e-01f, 1.03302889e-01f, -1.01767175e-01f, 1.04052573e-01f, 7.97121227e-02f, 3.31075229e-02f, 5.46134263e-02f, -1.41932949e-01f,
  -1.52106956e-01f, -9.63299200e-02f, -1.05012886e-01f, 2.63944035e-04f, -5.90570681e-02f, 1.34364158e-01f, 6.73599169e-02f, 7.84096029e-03f, 3.59276086e-02f, -3.72848548e-02f,
  6.92447126e-02f, 3.88657898e-02f, -4.70640697e-02f, 4.72415760e-02f, 4.58602468e-03f, 7.55818188e-03f, 2.07883641e-02f, 7.73739964e-02f, -4.31800857e-02f, -1.10408224e-01f,
  -1.90109387e-02f, 5.87944351e-02f, 1.96476728e-02f, -6.06809817e-02f, -3.44387144e-02f, -1.57023463e-02f, -6.93572760e-02f, 1.29826311e-02f, 6.53914884e-02f, -1.11905664e-01f,
  4.05917391e-02f, 4.70804833e-02f, -2.95898393e-02f, -4.60718982e-02f, -5.52839774e-04f, 4.05383715e-03f, 3.61524113e-02f, -4.06696554e-03f, -5.12011349e-02f, -3.43260057e-02f,
  5.09589240e-02f, -2.50192415e-02f, 7.26110637e-02f, 5.02363965e-03f, 1.68250389e-02f, -1.47503596e-02f, 2.20752899e-02f, -3.90244424e-02f, 2.89790798e-02f, -3.37865427e-02f,
  2.51734499e-02f, -2.92590596e-02f, 1.42644020e-02f, 4.21197563e-02f, -6.53136224e-02f, 3.39430720e-02f, 4.50072577e-03f, -9.97580811e-02f, -5.80753610e-02f, 3.05395033e-02f,
  -3.83333536e-03f, 1.20143197e-01f, -1.90536845e-02f, -8.66459534e-02f, -2.98577156e-02f, 6.02762029e-02f, -5.40795885e-02f, 3.04845133e-04f, -4.11272086e-02f, 6.04855493e-02f,
  9.87618342e-02f, -7.79907405e-03f, 1.24362200e-01f, -1.66935083e-02f, -2.67265067e-02f, -1.42640416e-02f, 2.39003655e-02f, -8.10292724e-04f, 5.73351569e-02f, -5.87018728e-02f,
  8.72802958e-02f, 1.31335720e-01f, 7.76819438e-02f, 8.52978230e-03f, 1.76456217e-02f, 1.31249735e-02f, -2.07821280e-02f, 3.34836915e-02f, 5.61224371e-02f, -4.79015633e-02f,
  3.12528908e-01f, -2.72259027e-01f, 6.23087920e-02f, 2.47686252e-01f, 1.28833950e-01f, -6.79657906e-02f, -2.64006294e-02f, 2.33566798e-02f, 1.59650251e-01f, -2.43582904e-01f,
  6.45138547e-02f, -1.90704897e-01f, -1.47865921e-01f, -6.44729706e-03f, 2.35672906e-01f, -1.15304127e-01f, 1.37505442e-01f, -9.40861329e-02f, 3.16065550e-02f, 1.54269293e-01f,
  1.77087739e-01f, 1.45547733e-01f, 4.56950255e-02f, -7.87373856e-02f, 1.50767475e-01f, -2.61070998e-03f, 6.78757727e-02f, -9.19154137e-02f, 1.31141022e-01f, -1.15145380e-02f,
  6.33649230e-02f, 3.85618992e-02f, -6.89240322e-02f, -1.00638404e-01f, -3.06352042e-02f, 4.93106432e-03f, -7.15107545e-02f, -3.61742489e-02f, 5.79659268e-02f, -2.18431894e-02f,
  -6.82154894e-02f, -2.60368716e-02f, 7.53623322e-02f, 3.48051637e-02f, -5.64917438e-02f, 7.40189776e-02f, 9.34032276e-02f, -1.63030196e-02f, 4.92512137e-02f, -3.49517427e-02f,
  5.68131283e-02f, -9.49741304e-02f, -3.26919779e-02f, -7.56358504e-02f, -3.36663015e-02f, -1.93780586e-02f, -2.41769124e-02f, -4.12943820e-03f, -5.81932776e-02f, 7.34719587e-03f,
  -1.07999332e-02f, -8.77883285e-02f, 4.00839970e-02f, 5.59108295e-02f, -1.06313014e-02f, 4.28524427e-02f, -4.85698581e-02f, 4.95742224e-02f, -9.52545274e-03f, 3.42485718e-02f,
  7.59944096e-02f, 2.24094633e-02f, 5.73110059e-02f, 4.08978052e-02f, -8.23257118e-02f, -2.76700780e-02f, -2.02892181e-02f, 5.94543815e-02f, 3.46296392e-02f, -4.12135990e-03f,
  -3.70673798e-02f, 1.04371822e-02f, 9.56948940e-03f, 4.72289473e-02f, -3.40772755e-02f, -1.50306160e-02f, -2.59632375e-02f, -2.45679896e-02f, -3.64887826e-02f, 5.11335619e-02f,
  -1.30842164e-01f, -2.62857899e-02f, -1.11485953e-02f, -5.34392968e-02f, -5.16697057e-02f, -7.81924836e-03f, 6.33478723e-03f, 8.76817852e-03f, -6.45988062e-02f, -1.81320887e-02f,
  -1.12424999e-01f, 3.90549228e-02f, -4.52694111e-02f, 4.67690080e-02f, 4.75479215e-02f, -1.62158292e-02f, -3.84938531e-02f, -3.51281390e-02f, -1.15007967e-01f, -1.45821394e-02f,
  -5.63575141e-02f, -6.79603443e-02f, -5.83057031e-02f, 1.75959636e-02f, -9.48212855e-03f, 3.87897976e-02f, -1.97021626e-02f, 3.34195271e-02f, -1.02801733e-01f, 8.12649075e-03f,
  -1.28692389e-01f, 2.79857904e-01f, -7.97604993e-02f, -5.95615879e-02f, 1.21636555e-01f, -1.73994780e-01f, -1.28490791e-01f, -7.25046918e-02f, 5.67660332e-02f, -1.42290935e-01f,
  -1.39997751e-01f, 5.85428476e-02f, 7.43573904e-03f, 5.21899611e-02f, -8.54178704e-03f, 7.98920542e-02f, 7.63237625e-02f, -1.65318232e-02f, 2.12360054e-01f, -3.20992917e-02f,
  1.10777266e-01f, 3.52830403e-02f, 9.91347358e-02f, 1.49292380e-01f, -1.94327999e-02f, 1.71447080e-02f, -1.67833529e-02f, 7.09153488e-02f, -1.83647219e-02f, 1.43236950e-01f,
  5.20369411e-02f, -7.89967850e-02f, -8.91339332e-02f, -4.43934835e-02f, -1.01934388e-01f, -7.15688467e-02f, -3.22522782e-02f, -3.97435613e-02f, 2.07144618e-02f, 2.71419827e-02f,
  -1.10185822e-03f, 1.31794289e-02f, -2.65303329e-02f, -4.13112864e-02f, 5.17847613e-02f, -4.45422009e-02f, 8.74054822e-05f, -1.46617303e-02f, -5.45155294e-02f, 9.56242979e-02f,
  3.50735821e-02f, 4.09616753e-02f, -1.35036162e-03f, 2.45289057e-02f, 4.62464876e-02f, 1.05412856e-01f, 4.74368744e-02f, -7.75129870e-02f, 6.29290268e-02f, 2.19279062e-02f,
  -4.80915830e-02f, 9.82999280e-02f, 6.60918951e-02f, 7.03659505e-02f, 1.73330419e-02f, -3.03064957e-02f, -7.25622028e-02f, 2.08925810e-02f, 1.17394231e-01f, -1.41672119e-02f,
  7.16480911e-02f, 8.42081308e-02f, 6.28215866e-03f, -6.28694221e-02f, 6.78387210e-02f, 8.98219123e-02f, -3.25438753e-02f, -1.93255246e-02f, -6.69594705e-02f, -3.52528021e-02f,
  6.08376134e-03f, -3.27235321e-04f, -3.76509838e-02f, -6.52760044e-02f, -5.39451502e-02f, -1.64985936e-02f, 3.97825949e-02f, 1.53452093e-02f, 2.64670625e-02f, -1.74866635e-02f,
  7.04517141e-02f, 6.13464750e-02f, 2.73523498e-02f, -3.47686373e-02f, 6.49555847e-02f, -5.80642652e-03f, 1.68819129e-02f, 1.99919697e-02f, -3.24553736e-02f, 5.28292060e-02f,
  -3.18609215e-02f, -1.94517784e-02f, -4.05184999e-02f, -7.34852478e-02f, 4.99659777e-02f, 1.37581443e-02f, 8.42192490e-03f, 1.11870453e-01f, -6.41675219e-02f, 4.73578349e-02f,
  -2.76308879e-02f, 5.10285273e-02f, -3.87612917e-02f, -5.86657971e-03f, -8.28357413e-02f, 2.96104774e-02f, 4.20451872e-02f, -6.37747347e-02f, 5.81929497e-02f, 6.76854625e-02f,
  -5.57297319e-02f, 1.65108368e-01f, -6.80824444e-02f, -1.59537734e-03f, 5.34822717e-02f, -7.80714080e-02f, -1.37532741e-01f, 1.03246614e-01f, 1.61686823e-01f, -2.91596837e-02f,
  -7.46462271e-02f, 1.49895415e-01f, -2.05593556e-02f, 2.43092068e-02f, -1.35069788e-01f, -1.76435839e-02f, -1.59736231e-01f, -1.23183183e-01f, 3.34114581e-02f, 9.63412151e-02f,
  1.49351796e-02f, -3.28754098e-03f, -6.03289157e-02f, 3.32702212e-02f, -1.66523978e-01f, 3.91110685e-03f, -1.72794834e-01f, 1.64566785e-02f, -1.64763462e-02f, -4.42152843e-02f,
  -8.13906267e-02f, -2.21180320e-02f, -2.11715281e-01f, -8.94292071e-02f, -4.65364307e-02f, -9.39448401e-02f, -5.92780225e-02f, -9.68925431e-02f, 5.05842790e-02f, -1.86279062e-02f,
  1.25985127e-02f, -5.71919121e-02f, 1.27088621e-01f, -1.48182223e-02f, -5.59068620e-02f, -3.71392705e-02f, -6.09698473e-03f, -1.33595869e-01f, 9.63568036e-03f, -3.05924956e-02f,
  3.01766358e-02f, -6.84328154e-02f, -9.21094567e-02f, -4.89904359e-02f, -1.29537046e-01f, -9.06426460e-02f, -1.69738289e-02f, -1.47408813e-01f, -9.15098935e-02f, -2.77352184e-02f,
  -1.86987706e-02f, 6.80989698e-02f, 1.43530732e-02f, -4.20316719e-02f, -3.03153694e-02f, 5.36990426e-02f, 1.35894656e-01f, -1.21152308e-02f, -6.67356402e-02f, -2.42646430e-02f,
  -7.50984028e-02f, 6.72819326e-03f, 9.08552557e-02f, -3.01365126e-02f, -1.00922603e-02f, -5.63210882e-02f, -3.32171209e-02f, 1.89043698e-03f, 2.73571219e-02f, -3.63310501e-02f,
  -2.53389403e-02f, -8.09103437e-03f, 1.32363830e-02f, -1.12271868e-02f, -4.61110026e-02f, -4.53703925e-02f, 1.00490965e-01f, -2.50009485e-02f, 4.43687625e-02f, -7.04702130e-03f,
  -1.43132895e-01f, -1.16968587e-01f, -5.51641397e-02f, -1.43484268e-02f, 7.72505403e-02f, -1.55377552e-01f, 7.46999159e-02f, -5.18970042e-02f, 3.73703870e-03f, -2.04151385e-02f,
  3.37484456e-03f, -1.50173334e-02f, -3.99401877e-03f, -1.84645690e-02f, 1.94258604e-03f, -6.79917708e-02f, -5.86819686e-02f, -7.92108551e-02f, -1.74923286e-01f, -5.01094684e-02f,
  1.16193267e-02f, -1.42701287e-02f, 5.27316220e-02f, 9.32821445e-03f, -8.18401575e-02f, -3.75227630e-02f, 5.65882996e-02f, -9.83159468e-02f, -9.86099541e-02f, -3.08690984e-02f,
  -5.18472791e-01f, 1.29352763e-01f, 3.65569174e-01f, -2.10153416e-01f, -6.89363405e-02f, 2.60553539e-01f, 1.65703490e-01f, 1.28611952e-01f, -3.13040949e-02f, 9.37248170e-02f,
  -5.63177913e-02f, 1.26710078e-02f, 1.68515623e-01f, -2.37859190e-02f, 1.38866082e-01f, 1.47602782e-01f, 6.11941256e-02f, 5.95511608e-02f, 7.72957057e-02f, -3.58538516e-02f,
  -1.86217960e-03f, -7.68197281e-03f, 1.45950273e-01f, 7.79234469e-02f, 6.00761324e-02f, -4.54005264e-02f, -5.94938137e-02f, 1.50924521e-02f, -3.23405452e-02f, 1.10889658e-01f,
  -2.21650124e-01f, -1.94703728e-01f, -3.24175060e-02f, -6.62556142e-02f, 2.90191229e-02f, 6.02560863e-02f, 7.12266425e-03f, -7.96617493e-02f, -8.41429755e-02f, 2.42731255e-02f,
  5.52727794e-03f, -7.44040161e-02f, -3.19002829e-02f, -4.37341221e-02f, 2.06358209e-02f, -9.37303528e-03f, 2.13346118e-03f, 6.77304938e-02f, -4.17164154e-02f, 9.40507278e-02f,
  6.22422285e-02f, 6.88743033e-03f, 5.27271554e-02f, -2.23351680e-02f, 3.29194106e-02f, 1.00843646e-01f, 7.46758888e-03f, 1.01172037e-01f, 7.29505867e-02f, 1.66667870e-03f,
  1.45973757e-01f, 1.66540146e-02f, 9.40645952e-03f, -2.34928019e-02f, -9.11782868e-03f, -2.11279895e-02f, -5.29336333e-02f, -1.11696810e-01f, -5.33510409e-02f, -3.73661742e-02f,
  -1.11548170e-01f, -2.64056176e-02f, -4.66467664e-02f, 5.50998375e-02f, 1.38765452e-02f, 3.15406360e-02f, 3.41115743e-02f, -6.78086802e-02f, 1.04579665e-01f, -1.08872876e-02f,
  -2.35770922e-02f, -9.63924155e-02f, 5.99060357e-02f, 8.09391961e-03f, 1.92428634e-01f, 8.57150089e-03f, -5.75632378e-02f, 7.67377019e-02f, -5.40425070e-02f, 5.51323183e-02f,
  -2.98248202e-01f, -1.35695085e-01f, -1.65979341e-01f, -9.34972093e-02f, -6.49750456e-02f, 1.69388857e-02f, 1.46760035e-03f, -4.37419349e-03f, -8.93172100e-02f, 2.97755133e-02f,
  -3.77267487e-02f, -3.62734273e-02f, -4.26829197e-02f, 5.10324761e-02f, 4.74066176e-02f, 2.43702997e-02f, -5.40195107e-02f, 9.00878757e-02f, 2.44785715e-02f, 8.17220807e-02f,
  -5.37416060e-03f, -2.13399976e-02f, -3.75029743e-02f, -3.19664069e-02f, 4.14621718e-02f, 7.58691654e-02f, -6.20423779e-02f, -2.70011276e-02f, 3.44924629e-02f, -1.04242470e-02f,
  3.35892141e-01f, -1.04851775e-01f, 2.60834880e-02f, 1.73640117e-01f, 5.08344546e-02f, -1.12670816e-01f, -4.93836813e-02f, 1.36012569e-01f, 1.17972627e-01f, -1.53869241e-01f,
  -6.21418804e-02f, -8.61501470e-02f, -9.69731659e-02f, 1.24621443e-01f, 7.93971494e-02f, -1.47371054e-01f, 1.03103213e-01f, -1.07492030e-01f, 9.43203196e-02f, 1.87366843e-01f,
  1.95224419e-01f, 3.53736207e-02f, 2.07563117e-01f, 1.12173192e-01f, 1.69687688e-01f, 1.21740535e-01f, 2.02694852e-02f, -4.76296768e-02f, 5.74749745e-02f, -9.56429392e-02f,
  -4.12453935e-02f, 3.29101123e-02f, -6.25925809e-02f, 3.32767032e-02f, 3.73902470e-02f, -5.06263375e-02f, -7.02642873e-02f, -1.19505562e-02f, -5.17416261e-02f, 4.64344025e-02f,
  -5.33459112e-02f, 8.81438628e-02f, -1.45944618e-02f, 6.75164089e-02f, -3.31240967e-02f, 6.05558939e-02f, 9.69581958e-03f, 5.92535809e-02f, -4.98824529e-02f, -3.57717536e-02f,
  -4.66706511e-03f, 1.10456184e-03f, 7.38240108e-02f, 5.01492694e-02f, -2.99057104e-02f, 4.72332444e-03f, -1.82109848e-02f, -2.14852467e-02f, 2.09651459e-02f, 4.12583947e-02f,
  1.47626773e-02f, 2.55888924e-02f, -2.85187215e-02f, 4.46218513e-02f, 2.16876194e-02f, -8.91001970e-02f, 1.65385734e-02f, -2.19635852e-02f, -6.20223805e-02f, -4.68159420e-03f,
  1.09489048e-02f, -9.00829304e-03f, -8.44548792e-02f, -7.78519660e-02f, -3.45827937e-02f, 7.79119432e-02f, -8.33798852e-03f, -2.88915355e-02f, -2.73640677e-02f, 5.02760932e-02f,
  5.09141423e-02f, -4.42484021e-02f, 1.96770467e-02f, 5.94021454e-02f, -1.50621962e-02f, -1.28695428e-01f, -7.20859831e-03f, 7.53101474e-03f, 1.11339986e-01f, 6.31898418e-02f,
  -2.26027369e-01f, -3.78909782e-02f, 3.58230472e-02f, -7.46175721e-02f, -1.89798214e-02f, -6.27405718e-02f, 6.35523051e-02f, -1.43325534e-02f, -5.92471734e-02f, 2.96296347e-02f,
  -5.67961112e-02f, 1.19500779e-01f, -4.76087146e-02f, 7.03745633e-02f, -7.48679116e-02f, 7.16105774e-02f, 5.25638573e-02f, 7.89415278e-03f, 5.95279643e-03f, -1.35356626e-02f,
  4.77701332e-03f, -2.16427837e-02f, 7.50480890e-02f, 1.46693826e-01f, -5.50212041e-02f, 1.95998549e-02f, 7.24931061e-02f, -7.15960041e-02f, 6.46939203e-02f, 5.22191674e-02f,
  7.68281817e-02f, 1.21820539e-01f, 1.26068518e-01f, 1.74595013e-01f, -1.47031799e-01f, -1.05691992e-01f, -6.38734549e-02f, 3.65574472e-02f, -6.29180372e-02f, 7.60678351e-02f,
  3.06636710e-02f, 1.41693473e-01f, -9.15326923e-03f, -8.51237550e-02f, -6.52669370e-02f, -2.83876602e-02f, 1.00045606e-01f, -5.14008142e-02f, 6.33430853e-02f, 7.80607462e-02f,
  -5.03893159e-02f, -5.50005138e-02f, 3.50676961e-02f, 4.21784371e-02f, -2.71018445e-02f, 1.88731819e-01f, 1.26730978e-01f, 2.56714150e-02f, 7.00289756e-02f, -4.52996492e-02f,
  -7.21168742e-02f, 5.30640930e-02f, 4.55924459e-02f, 1.10098375e-02f, -3.79437767e-02f, 5.09484746e-02f, 9.35388431e-02f, -4.49778163e-04f, -3.15846913e-02f, 7.69973248e-02f,
  -1.31499330e-02f, 1.48051560e-01f, -4.51990813e-02f, 4.04407941e-02f, -1.63619407e-02f, 5.55472225e-02f, 1.91725045e-02f, 2.75555253e-02f, 6.82712868e-02f, 4.46574911e-02f,
  1.38313428e-01f, -4.94749732e-02f, 1.07058786e-01f, 1.35811999e-01f, -3.61494278e-03f, 2.61218417e-02f, -2.34093983e-02f, 4.67037894e-02f, 6.53837323e-02f, -1.23142069e-02f,
  -1.47354268e-02f, -1.01923130e-01f, -7.87495971e-02f, 1.86116528e-02f, 4.88297679e-02f, -1.95150837e-01f, -2.75466945e-02f, 7.62739927e-02f, -7.11534098e-02f, -9.44329947e-02f,
  1.39903780e-02f, 2.56101806e-02f, -5.62163927e-02f, 5.88590279e-03f, -5.28369546e-02f, -1.39957340e-02f, 6.61112892e-04f, -1.29114008e-02f, -3.46000120e-02f, 3.60018462e-02f,
  -2.77687497e-02f, 3.62685546e-02f, 1.20296240e-01f, 3.36605869e-02f, -8.22687242e-03f, -6.41036257e-02f, 7.87240043e-02f, 1.01556703e-02f, 5.32384822e-03f, 1.63410351e-01f,
  -8.50364275e-04f, 9.92072001e-02f, 3.88411172e-02f, -7.04665035e-02f, -6.71551079e-02f, 1.87070780e-02f, 3.65649387e-02f, 5.49230315e-02f, 1.48576796e-01f, -4.61290553e-02f,
  7.79961497e-02f, 3.21476385e-02f, 1.12915868e-02f, 5.16568683e-02f, -1.46102095e-02f, 7.67333433e-02f, -3.01214885e-02f, -1.52877392e-02f, 2.29126468e-01f, 4.40919250e-02f,
  1.07268892e-01f, -8.39992091e-02f, -2.81826556e-02f, 6.47637174e-02f, -7.14626610e-02f, -8.76153931e-02f, 5.70640452e-02f, 1.02749035e-01f, 3.82976606e-02f, -6.49720372e-04f,
  6.08732812e-02f, -3.68160754e-01f, -1.07116379e-01f, -1.54161319e-01f, -2.00725012e-02f, -1.68518558e-01f, -1.83067039e-01f, -1.12629242e-01f, -8.72007236e-02f, -9.26264301e-02f,
  -7.93260708e-02f, 1.10447124e-01f, 1.47623867e-01f, -3.10066968e-01f, 9.62153524e-02f, 7.72790462e-02f, -2.97450542e-01f, 4.92341705e-02f, 9.36098471e-02f, -7.04619661e-02f,
  5.27105965e-02f, -1.89468622e-01f, -9.12602469e-02f, -6.80711418e-02f, -1.38020024e-01f, 2.47484613e-02f, 1.16223134e-01f, 9.48754102e-02f, -1.59340233e-01f, -1.01840347e-01f,
  -1.38859257e-01f, -2.55051758e-02f, -1.27178403e-02f, 9.69409943e-02f, 4.45493050e-02f, 1.90770836e-03f, 1.11192264e-01f, 5.91349192e-02f, 4.05157618e-02f, 3.65714170e-02f,
  2.04299632e-02f, -1.12389615e-02f, -5.82154058e-02f, 3.34066935e-02f, 8.69144574e-02f, -8.02658126e-02f, 8.83713458e-03f, 3.39386100e-03f, -3.22234631e-02f, 9.91779659e-03f,
  -1.16331778e-01f, -4.08801138e-02f, -1.00985803e-01f, -4.17691171e-02f, 3.95970941e-02f, -1.19135574e-01f, 2.73260530e-02f, 4.35137339e-02f, -5.71119541e-04f, -5.04613034e-02f,
  -3.34233651e-03f, 5.31322807e-02f, 2.81388573e-02f, 2.01749541e-02f, 1.16990507e-02f, -1.22317886e-02f, -1.18175540e-02f, 7.85908848e-02f, 1.68751553e-02f, 4.74194214e-02f,
  -3.25742997e-02f, -3.74724232e-02f, 4.73671108e-02f, 7.90361464e-02f, -8.37614015e-03f, 1.06166862e-01f, -3.17084491e-02f, 2.48507578e-02f, -3.47652659e-03f, -4.31506336e-03f,
  -2.69154031e-02f, 9.41428468e-02f, -2.64115259e-02f, 2.52179541e-02f, 2.93252487e-02f, 6.74287677e-02f, -2.67268773e-02f, -5.92030305e-03f, -9.74696502e-02f, -2.00740881e-02f,
  -1.39438882e-01f, 5.51610766e-03f, 1.65963471e-02f, -3.48782390e-02f, 2.39766948e-02f, -8.14587547e-05f, 1.54901249e-02f, -7.20117539e-02f, -1.48545401e-02f, 1.54772252e-02f,
  -1.76762491e-02f, -9.24931467e-02f, 9.77949053e-02f, 1.08903227e-02f, 8.20674971e-02f, -3.88403721e-02f, 5.27819656e-02f, 3.47701013e-02f, -1.37628615e-02f, -3.06577003e-03f,
  -3.27395163e-02f, -7.74974003e-02f, 4.56272252e-02f, -5.44355139e-02f, -5.42231910e-02f, -4.09971662e-02f, 1.36969695e-02f, 6.25172034e-02f, 3.45982574e-02f, -1.81633718e-02f,
  -8.18776637e-02f, 7.51746148e-02f, -2.25866795e-01f, -2.09664702e-02f, -2.10253775e-01f, -1.69306248e-01f, -1.04244515e-01f, -1.45351589e-01f, -1.50166983e-02f, 8.62335265e-02f,
  -9.46806297e-02f, -1.13720268e-01f, 1.82623222e-01f, 3.30542214e-03f, 1.83313601e-02f, 2.15622708e-01f, -4.37784009e-02f, 9.21100751e-02f, 8.76601320e-03f, -1.14546247e-01f,
  1.06364802e-01f, -2.19818559e-02f, 1.12433061e-01f, -6.44469336e-02f, -9.96772423e-02f, -1.12155313e-02f, 6.69991970e-02f, -1.50916219e-01f, -7.05102831e-02f, -1.35612756e-01f,
  -1.40344396e-01f, -1.13655321e-01f, -4.41866368e-02f, 1.68947112e-02f, -1.28168510e-02f, -4.44368124e-02f, -4.97312620e-02f, -3.20653357e-02f, -5.66387810e-02f, -6.09626509e-02f,
  -4.54275198e-02f, 6.62973570e-03f, -5.89450411e-02f, 2.52367789e-03f, -1.47053208e-02f, -2.27675475e-02f, 8.72663502e-03f, 6.96026832e-02f, 1.10793211e-01f, -1.93556249e-02f,
  -4.62825550e-03f, 1.41069787e-02f, 2.44470639e-03f, 2.53418684e-02f, 3.18177640e-02f, 1.37903970e-02f, 4.14873734e-02f, -8.52649100e-03f, -3.24694254e-02f, -2.59423256e-02f,
  -1.15379356e-01f, -4.91956831e-04f, -2.29533482e-02f, 4.24440689e-02f, -1.67150628e-02f, 1.15185371e-02f, 1.56920142e-02f, 7.24308267e-02f, 4.89201844e-02f, -2.73511391e-02f,
  3.94607820e-02f, -1.64019801e-02f, -5.28605543e-02f, -8.51268247e-02f, -8.10759813e-02f, -5.30198403e-02f, -3.37523110e-02f, 2.45109797e-02f, -5.50917499e-02f, 6.66033104e-02f,
  6.64640218e-02f, -6.80790916e-02f, 1.25773216e-03f, 7.99535513e-02f, 2.14470625e-02f, 6.95625395e-02f, -3.04832514e-02f, 4.68433276e-02f, -5.23409843e-02f, 1.40148168e-02f,
  -3.63566168e-03f, -1.37558892e-01f, -3.66022903e-03f, -4.97498550e-02f, 6.98084757e-02f, -1.13976570e-02f, -2.30430905e-02f, 1.08484300e-02f, -3.37528884e-02f, -9.78893787e-03f,
  8.06664377e-02f, 5.34126796e-02f, -5.56379929e-02f, -5.59897348e-02f, 4.87206690e-03f, 9.99347959e-03f, 4.06656275e-03f, -2.70662289e-02f, 1.45648876e-02f, -4.09808606e-02f,
  1.37415007e-02f, 3.07064820e-02f, 4.15279120e-02f, -1.14141345e-01f, 1.05181143e-01f, 4.28143237e-03f, -3.01812328e-02f, -1.40880644e-01f, -6.16244264e-02f, -5.51358983e-02f,
  -3.10759962e-01f, 3.24131735e-02f, -6.18487820e-02f, -1.74692854e-01f, 1.14427758e-02f, -4.96059880e-02f, -1.18333980e-01f, 3.77132334e-02f, -3.59743461e-03f, 1.72486436e-02f,
  1.39464960e-02f, -1.87697798e-01f, 1.41403258e-01f, -2.55054682e-01f, -1.37568787e-01f, -9.39604193e-02f, -1.23522066e-01f, -1.40222684e-01f, -7.60302693e-02f, -1.02829710e-02f,
  -1.50042802e-01f, -1.59206554e-01f, -2.35594779e-01f, 2.45625805e-02f, -8.60907957e-02f, 1.10200373e-03f, 7.07605900e-03f, 2.13178750e-02f, -7.62368664e-02f, -1.41151184e-02f,
  -9.73577797e-02f, 1.13972344e-01f, -3.85648124e-02f, -1.03862621e-01f, -4.50071841e-02f, -3.73854972e-02f, -1.08252913e-02f, -3.47446911e-02f, -8.50496367e-02f, -1.27667869e-02f,
  -1.21643290e-01f, 3.80353145e-02f, -6.11381084e-02f, -4.74784188e-02f, -1.92990229e-02f, 1.12445489e-01f, 5.22300899e-02f, 3.08186654e-02f, -6.01751991e-02f, -4.33481559e-02f,
  -2.22128499e-02f, 5.62536307e-02f, 6.53269142e-02f, 8.59802589e-03f, -4.66409065e-02f, 8.72779358e-03f, -1.01504497e-01f, -7.05026090e-02f, -1.31371692e-02f, -3.50408778e-02f,
  -1.05227856e-02f, -7.95745384e-03f, -1.39294893e-01f, 7.85200670e-02f, 1.58048496e-02f, -2.81766057e-02f, -5.36625460e-02f, 7.62478486e-02f, -5.23509681e-02f, -5.04531898e-02f,
  -6.59878273e-03f, -1.82121769e-02f, 2.74742313e-04f, -3.04381475e-02f, -9.59757939e-02f, 7.09238276e-03f, -5.17168678e-02f, -5.69547340e-02f, 3.27137746e-02f, -1.81646183e-01f,
  1.41868338e-01f, -2.34372914e-02f, -7.84109682e-02f, -2.23639468e-03f, 1.04610033e-01f, -5.04093468e-02f, 8.28499869e-02f, -3.36649716e-02f, 5.62456734e-02f, -4.74428572e-02f,
  9.41345468e-02f, 1.42130420e-01f, -7.98286647e-02f, -6.85397983e-02f, -9.10942927e-02f, 2.43909284e-02f, 2.52035223e-02f, -9.27790180e-02f, 3.30053410e-03f, -1.15673635e-02f,
  3.73522006e-02f, -1.39426291e-02f, 4.97752391e-02f, -6.45493492e-02f, -1.40206644e-03f, 1.19104274e-01f, 1.68305650e-01f, 2.21930910e-02f, 3.16594802e-02f, 5.50974272e-02f,
  1.25403866e-01f, 1.15268186e-01f, -2.42970269e-02f, 2.43738536e-02f, -8.72075185e-02f, -3.71528491e-02f, -3.55763547e-02f, -1.26972357e-02f, 6.51763694e-05f, 1.29616717e-04f,
  -1.03526063e-01f, 1.40258633e-02f, -2.66203851e-01f, -8.77180323e-02f, -2.13490903e-01f, -2.38288000e-01f, -2.20105276e-01f, -9.65714231e-02f, 8.75039250e-02f, 1.75256103e-01f,
  5.27117327e-02f, -2.14491691e-02f, 1.71429902e-01f, 3.34173255e-02f, -3.83626036e-02f, 1.58005312e-01f, -1.42946159e-02f, -1.12645254e-02f, -2.28696428e-02f, -2.01659277e-01f,
  3.00285388e-02f, -8.20549652e-02f, -6.23956658e-02f, -9.93061140e-02f, -2.17857465e-01f, -8.29145014e-02f, 1.21962734e-01f, -9.40403715e-02f, -7.39281550e-02f, -1.02435902e-01f,
  -7.87831917e-02f, -1.35417730e-01f, -1.07524045e-01f, -5.73128015e-02f, -8.36025178e-02f, -7.16054365e-02f, -3.70222740e-02f, -6.97549656e-02f, -8.42128173e-02f, 1.11799221e-02f,
  4.41173278e-02f, -6.90418035e-02f, -7.22528771e-02f, -2.58201398e-02f, 2.34099887e-02f, -3.50528862e-04f, -1.63343977e-02f, 5.91550022e-02f, -4.15724106e-02f, -8.70538526e-04f,
  -5.66943996e-02f, -4.13375944e-02f, -3.23191239e-03f, 6.87971115e-02f, 8.82276520e-03f, -3.02050263e-02f, 5.25575690e-02f, -4.60550301e-02f, -2.68370844e-02f, -4.15042881e-03f,
  -4.37167063e-02f, 8.07412621e-03f, -7.88632408e-02f, -1.03551568e-03f, -1.07475631e-01f, 6.27903193e-02f, 7.26123750e-02f, -2.26723794e-02f, 3.70293600e-03f, -4.02090997e-02f,
  6.92543685e-02f, -7.11506680e-02f, 3.23958807e-02f, 3.12401559e-02f, -2.76060048e-02f, 3.03448420e-02f, -4.14878763e-02f, -1.60231590e-02f, 3.50334272e-02f, 5.93283661e-02f,
  -2.02800203e-02f, -3.46030146e-02f, 7.26556256e-02f, -2.22919299e-03f, -1.16448671e-01f, 5.89556396e-02f, -3.07060443e-02f, 8.61782506e-02f, 8.32762718e-02f, -6.34267405e-02f,
  -5.55055849e-02f, -1.21635206e-01f, -4.88237329e-02f, -3.89465466e-02f, 5.48612922e-02f, -3.21598873e-02f, -6.06785715e-03f, 3.17936391e-02f, -6.86080987e-03f, -1.26507014e-01f,
  2.03961786e-02f, 3.44216870e-03f, -7.96709284e-02f, 5.19647151e-02f, -1.03950109e-02f, -1.66804101e-02f, 3.61641459e-02f, 1.07918903e-02f, -1.04734022e-02f, -6.89295530e-02f,
  -4.48842160e-02f, -3.75258401e-02f, 1.90930460e-02f, 4.06490602e-02f, 3.86762135e-02f, 3.02218236e-02f, -7.32285231e-02f, 5.26119880e-02f, -5.93035519e-02f, -6.36285916e-03f,
  8.62357691e-02f, 1.34696543e-01f, 2.00956777e-01f, 4.29626517e-02f, 6.99909627e-02f, -2.65615303e-02f, -5.36863171e-02f, 8.90811980e-02f, 1.01580784e-01f, 2.31651366e-02f,
  2.75495723e-02f, 1.33656710e-01f, -7.30467364e-02f, -1.59042198e-02f, -1.94072559e-01f, -1.99880108e-01f, -1.63697079e-01f, -6.38565794e-02f, -3.06128226e-02f, -1.05685227e-01f,
  -4.46381532e-02f, -1.18073680e-01f, -1.21967420e-01f, 1.72278751e-02f, 2.01937020e-01f, 1.68927848e-01f, -8.51196498e-02f, 6.84728175e-02f, 7.71654025e-02f, 1.41316548e-01f,
  3.71045843e-02f, -1.19731821e-01f, -5.73696159e-02f, 3.88414748e-02f, -5.69008105e-02f, 4.35837656e-02f, -3.97291742e-02f, 3.67103331e-02f, 2.04568240e-03f, 7.65426308e-02f,
  3.90989557e-02f, -1.08954851e-02f, 8.10260605e-03f, 2.06971876e-02f, 6.59834221e-02f, 2.96894908e-02f, -1.39226774e-02f, 3.30609940e-02f, 1.53876200e-01f, 3.13559137e-02f,
  2.39296909e-02f, 2.98202913e-02f, -5.23781106e-02f, -4.93702106e-02f, -9.10993367e-02f, 7.45788589e-02f, 9.25459142e-04f, -3.13581713e-02f, 1.12703092e-01f, 2.01749709e-02f,
  4.53572012e-02f, 2.15287044e-04f, 1.01940244e-01f, 8.31016600e-02f, 7.00533465e-02f, 1.19367056e-02f, -4.10050936e-02f, -8.41183290e-02f, -4.06962223e-02f, -1.57056132e-03f,
  -7.81453326e-02f, -1.19189426e-01f, -4.20923941e-02f, -3.74767259e-02f, 7.59228691e-02f, 7.07180821e-04f, -6.66525364e-02f, 4.10881303e-02f, -3.28407548e-02f, 3.49349827e-02f,
  2.86106896e-02f, -2.39594318e-02f, 4.52319421e-02f, -5.06177023e-02f, 5.46706244e-02f, -1.90194827e-04f, 2.72053163e-02f, 1.30427122e-01f, -6.59103245e-02f, -4.83299159e-02f,
  -2.65452206e-01f, -2.87453234e-01f, -5.62009364e-02f, -4.65652496e-02f, 1.56500228e-02f, 3.11597600e-04f, -7.43639469e-02f, 2.72544380e-02f, -5.87386526e-02f, -5.55666387e-02f,
  -8.15152936e-03f, -3.17358039e-02f, -1.06705584e-01f, 1.52664445e-03f, -7.82827437e-02f, -3.05161602e-03f, -2.66798772e-02f, -1.13648660e-01f, -1.08309850e-01f, -3.15569545e-04f,
  2.39809528e-02f, -1.13119498e-01f, 6.01001345e-02f, -2.00699996e-02f, -6.42153621e-02f, 3.27534974e-02f, -7.42329732e-02f, 1.22085631e-01f, -3.66957746e-02f, -1.19564936e-01f,
  2.49898821e-01f, 2.98430294e-01f, 2.27183148e-01f, 1.33720577e-01f, -1.13923997e-01f, -6.32806942e-02f, -5.44206053e-02f, -3.36568467e-02f, 1.30832240e-01f, 5.93151823e-02f,
  -1.98528379e-01f, 8.31966847e-02f, -2.17131659e-01f, 6.69776499e-02f, -7.87801370e-02f, -9.42391157e-02f, 4.38753515e-02f, 8.87312442e-02f, -4.63014692e-02f, 1.07112214e-01f,
  -8.10634196e-02f, -2.83590615e-01f, -1.04411058e-02f, -8.09215307e-02f, 5.66397049e-02f, 7.00838566e-02f, -1.23839699e-01f, 6.65017962e-02f, 6.33069575e-02f, 4.82183471e-02f,
  1.75801534e-02f, 3.67438644e-02f, 1.20390654e-01f, 1.13087691e-01f, -9.65262589e-04f, 6.19518338e-03f, 3.17964517e-02f, 1.34199470e-01f, 1.11787729e-01f, -6.79085439e-04f,
  -1.01688147e-01f, -1.51733398e-01f, 3.28787714e-02f, -7.77136236e-02f, 1.47803083e-01f, 1.62955169e-02f, 4.31209952e-02f, 6.87639043e-02f, 9.13224276e-03f, 3.23167816e-02f,
  3.62333097e-03f, 1.32656202e-01f, 1.36402562e-01f, 3.63631621e-02f, 9.29593518e-02f, 1.33663297e-01f, 1.71330515e-02f, 1.11160539e-01f, 4.12422940e-02f, 5.05139381e-02f,
  -8.78261253e-02f, -2.11511482e-03f, 5.89557411e-03f, 4.65161949e-02f, 7.78761785e-03f, -6.46089315e-02f, 4.99145314e-02f, -2.73560621e-02f, 5.68965152e-02f, 1.99731048e-02f,
  3.45911905e-02f, 7.86672831e-02f, -2.65677050e-02f, -7.86256716e-02f, -1.57947484e-02f, -6.60830066e-02f, 4.91272565e-03f, -7.48291686e-02f, 4.20555398e-02f, 3.02972961e-02f,
  -1.17131710e-01f, -3.88155542e-02f, -6.12244643e-02f, 2.39351057e-02f, -2.48777140e-02f, -2.43315008e-04f, -8.50240290e-02f, 4.76351902e-02f, -8.14327691e-03f, -5.13306409e-02f,
  8.15028548e-02f, 4.02855687e-02f, 1.79424539e-01f, 5.14463224e-02f, 5.31703494e-02f, 1.20164961e-01f, -6.92770332e-02f, 1.86241872e-04f, 6.46540746e-02f, -5.43210134e-02f,
  -6.90448433e-02f, -8.60031173e-02f, -3.46250534e-02f, 1.12116888e-01f, 4.89136092e-02f, -6.24476299e-02f, 2.38459799e-02f, -1.40272910e-02f, 3.20464261e-02f, 4.03334014e-02f,
  -5.07456660e-02f, -5.67615703e-02f, 4.69753444e-02f, 8.49732980e-02f, 8.56180638e-02f, 3.51858325e-02f, -2.41094325e-02f, 1.03923500e-01f, 1.68497916e-02f, 9.20742601e-02f,
  -3.66549455e-02f, 1.83575340e-02f, -1.18431911e-01f, -1.66949987e-01f, 5.85450698e-03f, -3.09728920e-01f, -1.51069522e-01f, 5.80070168e-03f, 9.38612670e-02f, 5.12240939e-02f,
  -3.50326784e-02f, 1.23152457e-01f, 8.63516927e-02f, -9.41320583e-02f, 4.22875397e-03f, -6.71770647e-02f, -2.77905434e-01f, -1.45780593e-01f, 3.65871154e-02f, -2.28618041e-01f,
  -1.27431005e-01f, -1.40920073e-01f, -1.58675566e-01f, -9.42015555e-03f, -1.20052390e-01f, -4.66908626e-02f, 7.47953802e-02f, -6.26925752e-02f, -1.33018956e-01f, 2.98222695e-02f,
  -1.26283066e-02f, 1.44455582e-01f, -1.15104720e-01f, -2.05465686e-03f, -1.24768361e-01f, -9.44247544e-02f, -2.02762082e-01f, 2.74749007e-02f, 5.41459210e-02f, 7.48147443e-03f,
  -1.96894426e-02f, 9.83724371e-02f, -8.61356407e-03f, 2.80462969e-02f, 5.01646921e-02f, 6.50923774e-02f, 3.53527628e-02f, 4.25214656e-02f, -8.54653642e-02f, 3.78095061e-02f,
  -9.61820781e-03f, -3.23053682e-03f, 1.77357774e-02f, -3.00113182e-03f, 4.65097614e-02f, 1.56207392e-02f, -2.59097219e-02f, -2.56234221e-02f, -5.59465438e-02f, 3.54898651e-03f,
  -4.02882434e-02f, -6.43359125e-02f, -8.79882127e-02f, 1.30772442e-02f, 1.87340081e-02f, 5.68419741e-03f, -9.41666402e-03f, -3.49646993e-02f, 5.60142361e-02f, 5.14318384e-02f,
  1.02055565e-01f, 9.46260542e-02f, -5.02715558e-02f, -1.00896277e-01f, -9.73253995e-02f, 8.81122127e-02f, -8.67471695e-02f, 3.79974805e-02f, 5.54439314e-02f, 1.03156632e-02f,
  -2.46193036e-02f, -4.17948291e-02f, 7.23416591e-03f, -2.17778254e-02f, -1.87421869e-02f, 8.95782560e-02f, -7.10624550e-03f, -5.15965279e-03f, 6.49410533e-03f, -4.15010042e-02f,
  -8.52143466e-02f, -7.44623393e-02f, -6.86366707e-02f, 3.73224765e-02f, -1.24133872e-02f, -7.20472708e-02f, -4.30600047e-02f, 1.06930928e-02f, -5.70965707e-02f, -1.15095481e-01f,
  -4.95790839e-02f, -3.38581391e-02f, -6.68893382e-02f, -2.15338748e-02f, -3.93063910e-02f, -2.73034046e-03f, 6.66221082e-02f, 4.13896143e-02f, -1.07434966e-01f, 5.31014502e-02f,
  -1.08665451e-02f, 6.99444190e-02f, 3.52189280e-02f, -8.22480395e-02f, 3.55628207e-02f, 8.72879326e-02f, -3.63619365e-02f, 7.09242001e-02f, -2.66394168e-02f, 2.47370508e-02f,
  1.37255937e-01f, 4.70048413e-02f, 8.05965364e-02f, 2.06929862e-01f, -4.37487699e-02f, -1.27625927e-01f, -9.22558531e-02f, 1.24342188e-01f, 4.38159741e-02f, -1.10655949e-01f,
  5.95632866e-02f, -1.13540992e-01f, -7.23671168e-02f, 2.28419334e-01f, 1.59245059e-02f, 1.12196743e-01f, 1.32523969e-01f, 5.04496507e-02f, 6.94286376e-02f, 1.37625515e-01f,
  1.48742497e-01f, 8.19037706e-02f, 1.39561400e-01f, 4.04478125e-02f, -1.46400928e-02f, 1.12183340e-01f, 6.64107576e-02f, -2.88551021e-02f, 2.50159036e-02f, -2.85446998e-02f,
  -2.68893111e-02f, 5.93019761e-02f, 2.36850753e-02f, -5.38302474e-02f, 2.80753244e-02f, -6.19279817e-02f, -1.52719393e-01f, -2.00314634e-02f, -7.47136548e-02f, 2.32937448e-02f,
  -3.02063990e-02f, -1.35175623e-02f, 6.31131455e-02f, -1.81914940e-02f, -5.49781248e-02f, 1.24713406e-02f, 6.42430857e-02f, -1.72411688e-02f, 3.31403464e-02f, -3.77750513e-03f,
  -3.51310242e-03f, -6.80898204e-02f, -4.23848294e-02f, -4.26614173e-02f, 7.59058073e-02f, -7.13445945e-03f, -9.50492769e-02f, 9.34077799e-03f, 3.34364995e-02f, -3.59403365e-03f,
  1.45672247e-01f, -3.31354104e-02f, -2.28038672e-02f, -9.95700136e-02f, -2.98169591e-02f, 1.58375166e-02f, -1.82818975e-02f, -7.70838857e-02f, -1.01284362e-01f, -4.95376065e-02f,
  -4.88277823e-02f, 1.07913893e-02f, 3.50822993e-02f, -4.73031178e-02f, 5.43520488e-02f, -9.72884819e-02f, -6.60166219e-02f, 3.00273187e-02f, 7.49981850e-02f, -4.27290797e-02f,
  4.46554683e-02f, -2.30268110e-02f, -3.21380384e-02f, -6.29834533e-02f, 1.78547297e-02f, 2.75324378e-02f, 6.45087585e-02f, -5.78898601e-02f, -3.74472067e-02f, 1.32584617e-01f,
  2.19235513e-02f, 1.91510335e-01f, -1.85595471e-02f, -3.80010046e-02f, -4.86088917e-02f, -1.08394802e-01f, 9.32509825e-03f, 1.03021838e-01f, 3.88787277e-02f, -4.49676327e-02f,
  -9.05746073e-02f, -1.31108388e-01f, -1.26715437e-01f, 5.55233583e-02f, -2.78881788e-02f, -3.17985266e-02f, 1.01330113e-02f, 3.60497497e-02f, -5.85203171e-02f, 1.16168872e-01f,
  -1.06825549e-02f, -2.78584007e-03f, -3.18040811e-02f, 5.99112501e-03f, 5.16926758e-02f, 1.82890128e-02f, -9.89476368e-02f, 1.38194337e-02f, -3.95382345e-02f, 9.19568092e-02f,
  -1.96992502e-01f, 1.09953381e-01f, 2.98610181e-01f, -1.80062816e-01f, 2.40731463e-01f, 2.53581524e-01f, 2.64014751e-02f, 7.66761005e-02f, -1.65882528e-01f, -1.60872877e-01f,
  -1.26514629e-01f, 1.12443924e-01f, 1.27476305e-01f, -1.42078087e-01f, 1.89903274e-01f, 5.90286925e-02f, 5.31127118e-02f, 1.31162666e-02f, 1.97184771e-01f, 3.32242181e-03f,
  1.65729485e-02f, -7.56201893e-02f, 2.06245914e-01f, 5.01670241e-02f, 1.04763024e-01f, -1.41106382e-01f, -1.31428674e-01f, -1.49208363e-02f, -5.93676902e-02f, 9.27792788e-02f,
  3.87565605e-02f, -1.13462262e-01f, 2.08031178e-01f, 8.15763921e-02f, 5.07498533e-02f, -3.92623842e-02f, 9.57331955e-02f, -7.48098502e-03f, 2.46572960e-02f, -5.54631231e-03f,
  2.82019973e-02f, -1.66725013e-02f, -2.62623392e-02f, -4.10610139e-02f, 1.22096598e-01f, 4.80894633e-02f, 1.61557615e-01f, 1.24357767e-01f, 6.18046895e-02f, 1.26741767e-01f,
  6.98702484e-02f, 1.08151183e-01f, 1.74456798e-02f, -1.43159747e-01f, 4.11342271e-02f, -1.45678055e-02f, -5.75131439e-02f, 1.53731162e-04f, 3.43933399e-03f, 1.07232621e-02f,
  1.32041737e-01f, -8.44611879e-03f, 2.35734526e-02f, -5.28812744e-02f, -4.26831543e-02f, -6.98268041e-02f, -2.17791218e-02f, 9.35411267e-03f, -2.66881976e-02f, 2.28337874e-03f,
  -1.75762679e-02f, -7.61567988e-03f, -2.73618940e-02f, 3.37910019e-02f, -4.70484011e-02f, 3.77798937e-02f, -1.24892965e-01f, -7.87509084e-02f, -3.56944799e-02f, -1.26656651e-01f,
  3.23797972e-03f, -8.51793289e-02f, -1.02950647e-01f, -5.72160967e-02f, -3.60622518e-02f, 1.08992077e-01f, -2.55625676e-02f, -1.41942343e-02f, 8.92756432e-02f, -9.84263327e-03f,
  -2.49151755e-02f, -2.04036191e-01f, 8.69086161e-02f, -1.14609776e-02f, 1.95751134e-02f, -3.18839215e-02f, 5.46897314e-02f, -1.13851890e-01f, 3.91926169e-02f, 9.29030254e-02f,
  -7.76785845e-03f, -4.31495383e-02f, 8.53547826e-03f, -1.20210506e-01f, -4.24068607e-02f, -1.71640832e-02f, -9.89243165e-02f, -7.62878880e-02f, -2.92473137e-02f, -8.68523046e-02f,
  5.68991825e-02f, 5.58816567e-02f, -6.30475804e-02f, -1.62664317e-02f, -9.26599801e-02f, -4.94485721e-02f, -1.15615301e-01f, -1.25440851e-01f, 1.13431498e-01f, 4.40839604e-02f,
  -1.34609770e-02f, 1.50663510e-01f, 7.55404234e-02f, 1.85364157e-01f, 1.95714589e-02f, 2.26840064e-01f, 2.23125920e-01f, -4.36992496e-02f, 2.60833472e-01f, 5.27175590e-02f,
  -5.34936748e-02f, 1.78037748e-01f, 4.44240123e-03f, 1.68597370e-01f, 1.15438528e-01f, 1.55095503e-01f, 8.48653018e-02f, 1.51516348e-01f, 1.36422291e-01f, 1.42995909e-01f,
  4.05996554e-02f, 6.86602667e-02f, -9.37356353e-02f, -1.80728003e-01f, -2.06412766e-02f, -1.55524030e-01f, -5.99874742e-02f, -1.01794861e-02f, -1.31344244e-01f, -7.20713567e-03f,
  -3.28366049e-02f, 6.44026995e-02f, -1.04215741e-01f, -1.21850967e-01f, -1.30621895e-01f, -7.10804462e-02f, 1.33117465e-02f, 6.38634115e-02f, -4.76091430e-02f, 6.38534427e-02f,
  -4.14523818e-02f, -2.27652490e-02f, 9.38533247e-02f, 7.08801448e-02f, 2.98341718e-02f, -5.69290966e-02f, 4.20288332e-02f, -9.40208957e-02f, -5.44141494e-02f, -5.91915287e-02f,
  -3.23395692e-02f, 1.12122577e-02f, -7.86410496e-02f, -3.18915471e-02f, -6.41984046e-02f, 7.80535415e-02f, -1.50764864e-02f, 3.65328602e-02f, 6.75938353e-02f, 9.01842341e-02f,
  -1.91164557e-02f, 4.88083512e-02f, -1.67115647e-02f, -5.93744144e-02f, 6.00030506e-03f, -1.57582220e-02f, 9.00674835e-02f, 7.31432885e-02f, -7.16788024e-02f, 8.09403956e-02f,
  1.25920340e-01f, -3.67021374e-02f, 4.79801930e-02f, -5.35870232e-02f, -6.55140402e-03f, -2.32529845e-02f, -8.27720985e-02f, -4.21655998e-02f, -3.33948694e-02f, -9.76833701e-02f,
  -2.89678462e-02f, 7.52073005e-02f, 3.99774984e-02f, -3.10241189e-02f, 1.30070727e-02f, -6.84591150e-03f, 3.34525518e-02f, -2.49654315e-02f, -5.52492738e-02f, -3.91143933e-02f,
  1.78312540e-01f, 2.94660032e-01f, 4.21273671e-02f, -3.94126736e-02f, -1.51132336e-02f, -3.83210145e-02f, 5.71849942e-02f, 1.81446690e-02f, 1.12472974e-01f, 5.84410802e-02f,
  -1.22691728e-02f, -9.33421552e-02f, 8.97412538e-04f, -2.49200873e-02f, 5.68744689e-02f, 6.10987805e-02f, -1.14024095e-02f, -2.14806572e-02f, -1.34108737e-02f, -3.07012927e-02f,
  -8.87710452e-02f, 7.45053962e-02f, 9.14992951e-03f, -2.34748702e-03f, -3.20242122e-02f, -1.07097015e-01f, 9.13518593e-02f, -1.35335371e-01f, -5.88272065e-02f, 4.07520588e-03f,
  2.53943235e-01f, 1.85335755e-01f, 2.20549509e-01f, 1.97412342e-01f, -4.26365361e-02f, 1.20279878e-01f, 9.37614143e-02f, 2.72167567e-02f, 3.34645897e-01f, 2.30158214e-02f,
  -1.60564527e-01f, 2.38808751e-01f, -8.52199867e-02f, 7.12072179e-02f, -9.52156410e-02f, -6.98721334e-02f, 1.29290313e-01f, 1.08472571e-01f, 1.33116990e-01f, 9.62791145e-02f,
  9.18840021e-02f, -1.79652393e-01f, -1.30455181e-01f, -1.03613086e-01f, 6.04000054e-02f, 1.11728251e-01f, -2.14894846e-01f, -1.82015494e-01f, -4.64699902e-02f, -9.62182954e-02f,
  -1.07510850e-01f, 1.49375632e-01f, -1.18970009e-03f, -7.20229372e-03f, -4.09696139e-02f, -6.88190907e-02f, 1.03099959e-03f, -7.72325173e-02f, -3.87544930e-02f, 2.04991680e-02f,
  1.26247644e-01f, -7.69233853e-02f, 4.53478396e-02f, 4.49190922e-02f, -2.75857355e-02f, 4.26366515e-02f, 2.47801151e-02f, 1.12855576e-01f, 1.92251448e-02f, 3.27695496e-02f,
  9.10132080e-02f, 2.87428666e-02f, -3.92062962e-02f, 7.90974051e-02f, 1.69547256e-02f, -1.72087736e-02f, 2.33665444e-02f, 5.08194529e-02f, 5.90457134e-02f, 2.67673284e-02f,
  9.47741643e-02f, -6.19760640e-02f, -7.84833729e-02f, -1.40026540e-01f, -6.24323450e-02f, -4.43917513e-02f, -1.34128127e-02f, -6.07262477e-02f, -1.11667090e-03f, -5.18387854e-02f,
  3.46663631e-02f, 2.89624948e-02f, -5.03871106e-02f, 8.94644111e-02f, 8.78059715e-02f, 8.50121975e-02f, 4.51988466e-02f, 5.40738516e-02f, 7.13218302e-02f, -2.17579175e-02f,
  9.05596018e-02f, 1.68450624e-02f, 1.81772932e-02f, -2.96370201e-02f, -6.54402561e-03f, -9.74758789e-02f, 4.15086001e-02f, 4.14671190e-02f, 3.92716751e-02f, -7.54340179e-03f,
  6.64121062e-02f, 1.96893305e-01f, -2.04810463e-02f, 2.95277573e-02f, -3.38280648e-02f, -1.56488977e-02f, -3.39046419e-02f, 9.98566598e-02f, 8.24796483e-02f, 5.35293333e-02f,
  -2.96014510e-02f, -3.34353335e-02f, 5.08360041e-04f, 2.67552678e-02f, 4.98578176e-02f, 4.56160940e-02f, 2.53039580e-02f, -3.38424705e-02f, -2.94833723e-02f, 4.68808152e-02f,
  4.54493687e-02f, -3.27963904e-02f, 4.56099771e-03f, -5.03710397e-02f, -3.09370197e-02f, -4.48324382e-02f, 9.21190828e-02f, 7.85941184e-02f, -6.95564272e-03f, 2.66349409e-03f,
  -1.50992021e-01f, 7.90227726e-02f, 8.55262652e-02f, 4.66441810e-02f, -5.89123648e-03f, -1.80868149e-01f, -1.53297693e-01f, 2.19309330e-02f, 3.49386148e-02f, -4.43317257e-02f,
  -2.34045163e-02f, 1.34391755e-01f, -1.61504652e-02f, 5.44723868e-02f, -2.36287117e-01f, 3.06121763e-02f, -4.94133756e-02f, -1.31494984e-01f, -4.47152480e-02f, 1.05772801e-01f,
  2.47556139e-02f, 1.60137057e-01f, 2.42659021e-02f, 1.86569363e-01f, 2.99478765e-04f, 1.15300626e-01f, -6.20672219e-02f, -2.28609610e-02f, 3.22625507e-04f, -8.00206326e-04f,
  -1.17921345e-01f, 1.48021579e-01f, 4.32615913e-02f, 5.93026876e-02f, -5.72228879e-02f, 1.98056567e-02f, -1.15930974e-01f, 2.28880160e-02f, -8.14268067e-02f, 5.49054984e-03f,
  1.15991645e-01f, 6.93119988e-02f, -8.68168697e-02f, 8.23384151e-03f, 6.34042621e-02f, 1.20045379e-01f, 1.10721104e-01f, -7.23931268e-02f, 1.34052262e-01f, 7.05090985e-02f,
  1.32698983e-01f, -4.82549518e-02f, -1.20205879e-02f, 1.50104833e-03f, -1.08003087e-01f, -3.26768830e-02f, -4.79521789e-02f, 2.49842211e-04f, 5.65156527e-02f, -8.45847949e-02f,
  -2.35301461e-02f, -4.83711855e-03f, 4.93615754e-02f, 4.45467904e-02f, 4.11187075e-02f, 5.04818633e-02f, -1.24872983e-01f, -5.02866022e-02f, 7.66164437e-02f, 4.70511205e-02f,
  -2.09928658e-02f, 2.87661292e-02f, -2.46517616e-03f, -2.16775090e-02f, 2.81486996e-02f, 7.44357184e-02f, 9.70919803e-03f, -7.88410828e-02f, -3.79886366e-02f, 1.18165724e-02f,
  5.11521026e-02f, -2.67171562e-02f, 1.12129949e-01f, -3.39992903e-02f, -6.46517277e-02f, -1.03469372e-01f, -1.42525723e-02f, 1.21936493e-01f, 1.11124195e-01f, 1.13758892e-01f,
  -8.51763338e-02f, 6.50003031e-02f, -2.42099911e-02f, 8.86286125e-02f, -5.19473962e-02f, 6.03919812e-02f, -2.12270506e-02f, -2.73852255e-02f, -1.52127827e-02f, 9.04581994e-02f,
  1.88324600e-02f, -2.84503270e-02f, -4.44397777e-02f, -8.06325004e-02f, 5.01992106e-02f, -2.37042326e-02f, -4.82240021e-02f, -1.62267014e-02f, -7.01780170e-02f, -8.20701197e-02f,
  4.26908284e-02f, 1.10928670e-01f, -8.01866800e-02f, -4.27787080e-02f, -5.33553772e-02f, -1.67182714e-01f, -9.25651342e-02f, 3.69810895e-03f, 3.01424991e-02f, -1.96019132e-02f,
  -3.73941541e-01f, 2.95287162e-01f, 1.19867258e-01f, 5.01698367e-02f, 1.29739821e-01f, 2.57911235e-01f, 1.14685437e-02f, 3.20239551e-02f, 1.10990450e-01f, -1.13999143e-01f,
  -1.94417074e-01f, 1.37035092e-02f, -3.19177061e-02f, 7.51705095e-02f, -4.39419635e-02f, 2.38834947e-01f, 4.57486212e-02f, 2.05829199e-02f, 1.25453115e-01f, -3.63985784e-02f,
  -1.57505106e-02f, -4.59770709e-02f, 8.15675929e-02f, 8.45587850e-02f, -6.06717616e-02f, -2.13574432e-02f, -1.01488799e-01f, 1.82802193e-02f, 4.90730777e-02f, -1.64494496e-02f,
  4.93755974e-02f, -1.86853539e-02f, -4.32105511e-02f, 1.06488280e-02f, -8.89062285e-02f, -5.16873971e-02f, 1.38047356e-02f, 2.80268658e-02f, -9.74799991e-02f, -8.56434032e-02f,
  -1.20404266e-01f, -3.54888104e-02f, 4.73116785e-02f, -8.71721506e-02f, 1.12234741e-01f, -5.39888628e-02f, 4.59890626e-02f, -7.82046467e-03f, -6.64508250e-03f, 4.79652062e-02f,
  8.65278691e-02f, 1.01738200e-01f, 3.33505571e-02f, 1.91957317e-02f, -8.66284221e-02f, 1.51347190e-01f, 1.69203170e-02f, -5.52114286e-02f, 8.89380183e-03f, 9.82280150e-02f,
  -1.12544112e-02f, 2.25492492e-02f, -8.02542269e-02f, 1.28848217e-02f, -3.34952138e-02f, -4.15420644e-02f, 6.13436624e-02f, 1.23667940e-02f, -5.69811016e-02f, 2.36202627e-02f,
  -2.60911565e-02f, 1.76266506e-02f, 5.33065610e-02f, -6.93506375e-02f, -1.96029190e-02f, -1.35654658e-01f, -3.20415720e-02f, -5.40643372e-02f, -9.23908222e-03f, -4.39534672e-02f,
  -5.38742766e-02f, 9.47027132e-02f, -2.29504611e-02f, -1.47780776e-02f, 5.34554236e-02f, 2.53176335e-02f, -9.39764921e-03f, -5.00932559e-02f, -1.94151718e-02f, 9.24845412e-03f,
  1.07194558e-01f, 8.94945860e-02f, -2.14260444e-02f, -1.40100718e-02f, -4.76550125e-02f, 4.11137268e-02f, -6.09228481e-03f, 7.72394091e-02f, 2.56173648e-02f, -1.27978558e-02f,
  -4.63278778e-02f, 1.05789560e-03f, 1.20169427e-02f, -6.18128926e-02f, 5.53594828e-02f, -1.34608301e-03f, 1.10607604e-02f, -2.69623492e-02f, -4.49337922e-02f, -7.14746416e-02f,
  -8.09833184e-02f, 6.27714992e-02f, -3.49897519e-02f, -8.07082877e-02f, -5.95234632e-02f, -2.74653714e-02f, 3.74262743e-02f, 6.57603319e-04f, 6.09012730e-02f, 7.53415972e-02f,
  -9.46930423e-02f, -2.30990186e-01f, -6.56572431e-02f, 9.28708166e-03f, -3.29886749e-02f, 4.78447489e-02f, 2.52443016e-01f, -2.39814639e-01f, -2.43651539e-01f, -2.54895724e-02f,
  1.70075804e-01f, 1.52557448e-01f, 9.54189897e-02f, -5.10653332e-02f, 2.19154820e-01f, 9.37316120e-02f, -1.01834007e-01f, 8.71762633e-02f, -1.56507432e-01f, -1.43927485e-01f,
  -4.93733771e-02f, 1.86361391e-02f, 1.21821351e-01f, -7.75778666e-02f, 4.52108160e-02f, -1.37956798e-01f, 1.22168921e-01f, 1.04156822e-01f, 9.64396596e-02f, 2.20035776e-01f,
  -1.07778385e-02f, -1.66236594e-01f, 2.76955385e-02f, -3.65560479e-03f, -1.27191273e-02f, -3.40252817e-02f, 7.34939277e-02f, 1.38131946e-01f, -4.23709229e-02f, 2.55846940e-02f,
  3.28398459e-02f, -1.08818114e-01f, -2.96838768e-02f, 8.82923305e-02f, 2.81569269e-03f, -7.86548853e-02f, 3.08598951e-02f, 2.21603643e-02f, -3.86679284e-02f, 1.44673809e-02f,
  -4.88765538e-03f, 1.06647061e-02f, 5.62801957e-02f, 2.70032473e-02f, 2.64137816e-02f, 3.89423929e-02f, 6.75628260e-02f, 1.55624032e-01f, -7.78393671e-02f, -1.44203845e-02f,
  5.24486182e-03f, 6.05006590e-02f, -8.73859823e-02f, -4.61573601e-02f, 1.72917396e-02f, -7.46751428e-02f, 3.30439135e-02f, 5.31559885e-02f, -1.73575971e-02f, -1.10214120e-02f,
  -5.97756822e-03f, 1.40871694e-02f, -2.31397152e-03f, 3.01776752e-02f, 9.42591205e-02f, 4.16155681e-02f, 4.29545566e-02f, 2.55903881e-02f, 6.06003366e-02f, 7.12191127e-03f,
  -6.11930303e-02f, 6.56426921e-02f, -2.99270339e-02f, 6.39294758e-02f, -9.97112319e-03f, 4.34829220e-02f, 1.37523860e-02f, -1.58568751e-02f, 5.20719662e-02f, 1.42974064e-01f,
  -1.58629686e-01f, -2.13252217e-01f, -6.37230650e-02f, -5.31222448e-02f, 2.56051794e-02f, -1.25605632e-02f, -2.19866969e-02f, -1.47020251e-01f, -9.32429451e-03f, -5.98695800e-02f,
  2.13721003e-02f, 8.69298819e-03f, -1.83647703e-02f, -2.14206353e-02f, 1.04593024e-01f, -6.01931661e-02f, 4.86103930e-02f, 2.75229830e-02f, -3.08379587e-02f, 3.27525698e-02f,
  3.19952741e-02f, -4.41069249e-03f, 6.89071193e-02f, -1.48653284e-01f, -3.72256264e-02f, 9.03880820e-02f, -1.00339770e-01f, 2.18342245e-02f, -1.45709952e-02f, 6.66362792e-02f,
  -5.31388760e-01f, -3.28320563e-02f, -4.52706553e-02f, 3.94013301e-02f, 2.08767448e-02f, 2.22458676e-01f, 1.58300459e-01f, 5.73929772e-02f, -3.26011702e-02f, 2.30286360e-01f,
  1.27043709e-01f, -8.74237195e-02f, -8.59400034e-02f, 2.45218799e-01f, 1.98757723e-02f, 2.14415807e-02f, 2.21289858e-01f, 1.48425490e-01f, 9.22734514e-02f, -1.02771439e-01f,
  1.71381216e-02f, 2.14445591e-01f, 1.10445753e-01f, 1.24712802e-01f, 1.20630026e-01f, -1.39107136e-02f, 3.24691609e-02f, 8.20758790e-02f, 1.98761478e-01f, 1.42456830e-01f,
  -1.19796395e-01f, -1.86665237e-01f, -4.62742001e-02f, -1.25121295e-01f, 6.62221946e-03f, -4.19481024e-02f, -5.33491708e-02f, 6.40955493e-02f, -8.98011699e-02f, -2.02003494e-02f,
  -8.70658457e-02f, -5.94994910e-02f, 4.30251891e-03f, -1.24475248e-02f, -8.35475922e-02f, 1.07255407e-01f, 8.23960155e-02f, 2.08568014e-02f, -2.04006154e-02f, 3.09935063e-02f,
  1.12376325e-01f, 5.12008704e-02f, 1.64371040e-02f, 8.90030041e-02f, 8.56516808e-02f, 1.04683757e-01f, 4.26073037e-02f, -5.51123684e-03f, -5.83712831e-02f, -6.20759651e-03f,
  2.31324825e-02f, 1.87748726e-02f, -9.45064984e-03f, 4.86561805e-02f, -4.19442449e-03f, 2.46853530e-02f, -8.58786143e-03f, 1.98118016e-02f, 5.02148680e-02f, -2.69205756e-02f,
  -1.72780380e-02f, 2.39344295e-02f, -6.18073381e-02f, 1.14181498e-02f, 2.30120192e-03f, -3.99726443e-02f, 7.48143811e-03f, -1.52145009e-02f, 2.53974479e-02f, 2.49248557e-02f,
  -1.70274116e-02f, -4.33089137e-02f, 1.12088472e-01f, -1.54886823e-02f, 8.66839066e-02f, 1.06657222e-02f, -2.29084659e-02f, 8.52326974e-02f, -7.47801689e-03f, -4.44514640e-02f,
  -1.18112661e-01f, -1.45750687e-01f, 8.91667232e-02f, -2.45115068e-02f, -3.13091949e-02f, 1.95569098e-02f, -3.88102457e-02f, 2.60582119e-02f, -4.85869236e-02f, -2.30759121e-02f,
  4.51915190e-02f, 4.77414168e-02f, -1.41644077e-02f, -1.35203078e-02f, 7.49402046e-02f, 5.09046987e-02f, -2.68883668e-02f, -1.00021645e-01f, 5.05704060e-02f, 2.05629617e-02f,
  5.90910874e-02f, -3.75851896e-03f, 6.24584891e-02f, 4.20064293e-02f, 1.10094048e-01f, 3.06355562e-02f, -7.31811374e-02f, -9.20403302e-02f, 5.74209467e-02f, 4.75309379e-02f,
  -2.05589384e-01f, -1.43814147e-01f, -2.39989072e-01f, -1.84597865e-01f, 9.49049592e-02f, -3.25513259e-02f, -7.24022388e-02f, -9.18079726e-03f, -7.93502852e-03f, 1.46807060e-01f,
  6.06867149e-02f, -1.13364242e-01f, 6.16928749e-02f, -3.33224267e-01f, -2.11255491e-01f, -2.23746553e-01f, -2.43591368e-01f, -4.40672822e-02f, -1.10366456e-01f, -4.67294641e-02f,
  -1.68533549e-01f, -1.67177305e-01f, -2.33568326e-01f, 9.17241275e-02f, -4.33012960e-04f, 2.73148939e-02f, 1.09803528e-01f, 9.90561321e-02f, 7.33021051e-02f, -6.32249936e-02f,
  -3.51370312e-02f, -5.42866662e-02f, -1.41031779e-02f, -4.34153639e-02f, 7.40235671e-02f, 3.88531014e-02f, -4.57713418e-02f, 7.31560737e-02f, 1.02033922e-02f, 6.87016025e-02f,
  1.13258861e-01f, 5.49422428e-02f, -7.85864070e-02f, 1.32970959e-02f, 1.52392298e-01f, 3.58190499e-02f, -6.59890398e-02f, -3.85710262e-02f, -4.03383095e-03f, -9.25546214e-02f,
  -5.20731434e-02f, -4.14225273e-02f, -1.89689565e-02f, 2.93576457e-02f, -8.76048431e-02f, 3.64413075e-02f, -7.25580975e-02f, 1.32537752e-01f, 5.27651124e-02f, -4.94784713e-02f,
  1.17213711e-01f, 2.43777391e-02f, -5.26942164e-02f, 5.70797245e-04f, -8.36959332e-02f, 5.10654263e-02f, -6.13712333e-02f, 5.73146604e-02f, 2.94551700e-02f, 3.52971181e-02f,
  3.37248035e-02f, 1.79716866e-04f, -4.93651591e-02f, 1.03614539e-01f, -6.37508109e-02f, -6.96492940e-02f, -1.45332199e-02f, 2.26656832e-02f, -1.08211152e-02f, -2.83183157e-02f,
  -3.71288955e-02f, -1.54397672e-03f, 6.19929843e-02f, 2.03812178e-02f, 3.19024362e-02f, -1.24963326e-03f, 6.45910250e-03f, 2.04995554e-02f, 4.80460897e-02f, 8.96786805e-03f,
  2.12248042e-02f, 1.46040991e-01f, -2.79919170e-02f, 5.49795106e-02f, 1.54295126e-02f, -1.16190240e-01f, 6.22495152e-02f, -4.77863848e-02f, 7.69257769e-02f, 1.67022925e-02f,
  8.00043717e-02f, 5.00594862e-02f, 9.49237198e-02f, -5.84126636e-02f, 9.94761586e-02f, 1.10480038e-03f, 9.44533274e-02f, -1.04489448e-02f, 3.33697349e-02f, 1.35364234e-02f,
  3.87993269e-02f, 1.94731522e-02f, 1.82034243e-02f, -4.01955247e-02f, -1.99704012e-03f, 4.78066541e-02f, 3.15797254e-02f, 1.30065214e-02f, 1.43488757e-02f, 7.11775944e-02f,
  1.02596395e-01f, 3.44776690e-01f, 1.54050559e-01f, 1.68697983e-01f, -1.44401282e-01f, -1.62729919e-01f, 4.78491150e-02f, 4.81575131e-02f, -5.24567552e-02f, 1.12534046e-01f,
  -4.92004156e-02f, 1.25792692e-04f, 1.07707016e-01f, 2.32648700e-01f, 4.94948365e-02f, 7.02169091e-02f, 1.29978836e-01f, -2.31653918e-02f, 5.08181378e-02f, 2.68248349e-01f,
  7.21965954e-02f, 2.78125167e-01f, 1.93168208e-01f, -6.44027255e-03f, 2.12347969e-01f, -2.44612843e-02f, 1.23327345e-01f, 1.40642747e-02f, 1.09642245e-01f, 6.58062771e-02f,
  -2.63964068e-02f, 4.44560833e-02f, 2.74349153e-02f, 4.08999026e-02f, -7.62122497e-03f, 1.13469949e-02f, 4.68886718e-02f, -8.19921643e-02f, -1.07101031e-01f, 4.78912964e-02f,
  -1.72205418e-02f, 4.19860370e-02f, 4.12699617e-02f, 2.50424612e-02f, -3.48180570e-02f, -5.79612963e-02f, 5.77736907e-02f, -3.01865656e-02f, 6.53696135e-02f, 1.59390643e-02f,
  -3.08231879e-02f, -2.47977264e-02f, -1.88521333e-02f, 3.11016757e-03f, 2.04915926e-02f, 7.45751336e-02f, 8.82248878e-02f, -4.29544635e-02f, 5.05197048e-02f, 9.93863344e-02f,
  -7.96177611e-03f, 5.03484905e-02f, -2.95837615e-02f, 2.13455707e-02f, 3.31778489e-02f, 2.41679233e-02f, -4.82475683e-02f, -8.59346613e-02f, -1.94298811e-02f, 1.74194444e-02f,
  -5.63576967e-02f, -2.64337007e-02f, 5.56127317e-02f, 5.55564277e-02f, 8.24851170e-02f, -9.01193097e-02f, -1.24929123e-01f, 1.05732016e-01f, -1.53959077e-02f, -1.24800406e-01f,
  5.10826223e-02f, 6.93785623e-02f, 2.47022305e-02f, -5.89869022e-02f, -9.82809067e-03f, -9.40883756e-02f, 3.13821286e-02f, 9.70762074e-02f, -3.12407892e-02f, 7.11988509e-02f,
  6.14723153e-02f, 2.81539917e-01f, -3.09670139e-02f, -3.19513790e-02f, -5.41123673e-02f, -1.13209011e-02f, 3.95837650e-02f, 2.56192572e-02f, 1.10170297e-01f, -5.82572408e-02f,
  -4.52507809e-02f, -9.78037342e-03f, -2.43587438e-02f, -7.04823527e-03f, -1.21820075e-02f, 8.58259276e-02f, 7.27920085e-02f, -6.06470928e-02f, -4.45219763e-02f, 7.30758756e-02f,
  -3.36382836e-02f, 9.20880064e-02f, -5.62537368e-03f, 4.86163702e-03f, 1.65559992e-03f, -3.73646952e-02f, 6.02267198e-02f, -4.62587737e-03f, 2.26536933e-02f, 1.85476154e-01f,
  2.04862103e-01f, -2.48588189e-01f, -8.63839239e-02f, 2.22618029e-01f, 2.07180440e-01f, 1.15276299e-01f, 1.60509512e-01f, 1.14585437e-01f, 2.39059046e-01f, -1.38935149e-01f,
  -6.20193146e-02f, -6.99177310e-02f, -1.80457801e-01f, 6.10345118e-02f, 2.58970678e-01f, -1.28912032e-01f, 1.75817758e-01f, -4.46136389e-03f, 4.36056107e-02f, 5.65491803e-02f,
  1.97948724e-01f, 1.17075488e-01f, -1.43629372e-01f, -3.66246775e-02f, 3.97588909e-02f, -2.25727156e-01f, -7.90826753e-02f, -1.25877246e-01f, -1.09339796e-01f, -2.26196810e-03f,
  5.75333983e-02f, 2.20927764e-02f, -3.97163779e-02f, -3.97111066e-02f, -1.78582501e-02f, -6.04308657e-02f, -1.23053625e-01f, 1.04784193e-02f, 2.17387415e-02f, -9.97220352e-03f,
  1.92447882e-02f, -1.01243511e-01f, 3.09538599e-02f, -2.84952540e-02f, 1.47431657e-01f, 1.30081810e-02f, -1.63760167e-02f, -1.10093787e-01f, -9.60026160e-02f, -6.02888968e-03f,
  -1.81373246e-02f, 3.87763791e-03f, -2.16713902e-02f, -1.30603909e-01f, -1.65435094e-02f, 5.33275306e-02f, -2.23884378e-02f, -8.48242640e-02f, -6.18317015e-02f, 4.74755615e-02f,
  -5.71544170e-02f, 2.10476480e-02f, 1.62061136e-02f, -1.82577446e-02f, -3.64095606e-02f, 2.50859614e-02f, 2.47261040e-02f, 3.80211184e-03f, -2.55782083e-02f, -9.65878665e-02f,
  1.64808687e-02f, 7.42566437e-02f, -2.35775057e-02f, 9.75067355e-03f, 2.21295375e-02f, 3.33159976e-02f, 3.06758061e-02f, -2.57223449e-03f, -4.89306115e-02f, 4.64644209e-02f,
  -2.32873932e-02f, 3.70899700e-02f, -2.87753735e-02f, 2.84980633e-04f, -6.92368299e-02f, 1.74794253e-02f, 4.74184081e-02f, -4.05763462e-02f, -3.09642730e-03f, 1.11304931e-01f,
  4.84633520e-02f, -1.50035515e-01f, -3.36058959e-02f, -6.95193484e-02f, -8.69854763e-02f, 2.13974062e-02f, 3.43437947e-04f, -7.27108344e-02f, 6.67142821e-03f, 4.62231822e-02f,
  3.16570885e-02f, -3.34463939e-02f, -8.37472677e-02f, 6.37259409e-02f, -1.09882625e-02f, 6.25451878e-02f, -2.59640943e-02f, -3.76853794e-02f, 2.12756754e-03f, -4.16472107e-02f,
  -6.92939907e-02f, -3.83025743e-02f, 7.43177608e-02f, -2.20657494e-02f, 1.48383509e-02f, -8.01172182e-02f, -7.35475421e-02f, -1.88864060e-02f, 3.60336192e-02f, 3.05041894e-02f,
  2.01164588e-01f, -1.16085172e-01f, 1.94877386e-01f, 2.73048103e-01f, -4.69947495e-02f, 7.38517940e-02f, 9.10952836e-02f, 1.05390280e-01f, 2.87971854e-01f, -3.78822582e-03f,
  -1.28547683e-01f, -4.17973734e-02f, -1.20910473e-01f, 1.73560884e-02f, 9.89926457e-02f, -4.32744920e-02f, 8.01880062e-02f, -2.02168658e-01f, 1.10925645e-01f, 1.89849600e-01f,
  5.86449839e-02f, 2.58093816e-03f, -1.54193686e-02f, -7.96138868e-02f, 5.45697697e-02f, -2.73276139e-02f, -1.29139304e-01f, -1.44864321e-01f, -6.36959299e-02f, -2.14162186e-01f,
  6.86422661e-02f, 3.26955579e-02f, -2.39860658e-02f, -3.23693343e-02f, -2.21226569e-02f, -8.37929696e-02f, -1.32884115e-01f, -9.12964121e-02f, -2.40583122e-02f, -1.28644407e-02f,
  4.18781973e-02f, -5.09731798e-03f, 3.37070078e-02f, 3.75662232e-03f, 1.12464745e-02f, 3.76811139e-02f, 6.02464490e-02f, 1.68495229e-03f, -9.24556851e-02f, -9.23787281e-02f,
  6.61591589e-02f, 4.96426113e-02f, 6.47620708e-02f, -1.96636081e-01f, 1.32270632e-02f, -3.78306513e-03f, -4.69192117e-02f, -6.24465570e-02f, -5.92044042e-03f, -3.85304131e-02f,
  3.59644671e-03f, 1.09888064e-02f, 5.93097545e-02f, -2.52141096e-02f, 3.18933837e-02f, -3.35225128e-02f, -7.70413280e-02f, 3.16638686e-02f, 9.67332814e-03f, -1.74936764e-02f,
  1.94434039e-02f, -8.59795231e-03f, 3.26373316e-02f, 7.72408396e-02f, 9.26600248e-02f, 3.27388458e-02f, 4.13117185e-02f, 9.15386379e-02f, 8.88188630e-02f, -3.17356363e-02f,
  -9.02835801e-02f, -2.09091455e-02f, 1.96323293e-04f, 6.18460635e-03f, -4.48416024e-02f, -1.39930984e-02f, 8.25694725e-02f, 8.99503455e-02f, 5.23382835e-02f, -6.66612526e-03f,
  -4.52470453e-03f, -4.43460513e-03f, 2.19464209e-02f, -1.81190763e-02f, 1.49473064e-02f, 9.80644822e-02f, -3.49233076e-02f, 8.70760456e-02f, 1.42682316e-02f, 4.21134494e-02f,
  5.02248779e-02f, 1.08156353e-01f, -5.70037998e-02f, 4.05978747e-02f, -4.71846461e-02f, 6.12370260e-02f, 1.15481662e-02f, -5.64393960e-02f, -3.11276522e-02f, 1.80314053e-02f,
  -1.04638524e-02f, -8.87405053e-02f, 7.48299249e-03f, -8.19721818e-02f, 5.89265488e-02f, -1.28695339e-01f, -5.43221310e-02f, -1.20528534e-01f, -6.11818256e-03f, -3.32317762e-02f,
  -4.25883718e-02f, 2.78653175e-01f, 7.72279054e-02f, 2.49685701e-02f, -1.40024582e-02f, -3.13662320e-01f, -8.97515863e-02f, 7.50650242e-02f, -7.86581933e-02f, 1.47439793e-01f,
  9.85699072e-02f, 1.54821174e-02f, 6.91626444e-02f, -1.28173083e-01f, -3.66133630e-01f, -1.74265310e-01f, -2.32446596e-01f, -8.05060044e-02f, -2.67242789e-02f, 1.81420326e-01f,
  -1.98416095e-02f, -2.43306551e-02f, -4.99525853e-02f, 1.48977518e-01f, 8.40794370e-02f, 1.32169768e-01f, 1.19287863e-01f, 1.60617083e-01f, 2.71192733e-02f, 3.18699740e-02f,
  -1.01620726e-01f, 8.75371024e-02f, 1.29376978e-01f, -8.65569413e-02f, -5.35584018e-02f, -1.42085284e-03f, 6.57960400e-03f, 3.70320678e-02f, -9.89189446e-02f, -2.89662648e-02f,
  -4.82050739e-02f, -1.20784687e-02f, 4.19067815e-02f, -2.09144745e-02f, 8.49723350e-03f, -1.46273514e-02f, 1.02114137e-02f, 9.24777761e-02f, -3.97576280e-02f, -7.87550658e-02f,
  4.72279489e-02f, -3.31089459e-02f, -2.25436892e-02f, -3.11209001e-02f, -2.64427392e-03f, 1.21436007e-02f, -2.64079385e-02f, -5.28920256e-03f, -7.22121373e-02f, -3.38847749e-02f,
  1.26940727e-01f, -4.19372208e-02f, -4.74771075e-02f, -1.14400268e-01f, -7.67346993e-02f, -2.72105937e-03f, -6.26114756e-02f, -3.78059521e-02f, 4.03991826e-02f, 1.34573713e-01f,
  2.60419678e-02f, -1.12947136e-01f, -1.06807910e-01f, -5.93383200e-02f, 4.66672145e-02f, -9.93309356e-03f, 9.06015839e-03f, 2.12842990e-02f, 1.42493667e-02f, 1.15528479e-02f,
  4.85010818e-02f, -1.07609533e-01f, 7.82229751e-03f, 4.61493712e-03f, -3.96319944e-03f, 2.50127576e-02f, 5.40284486e-03f, -5.55221550e-02f, -5.50485076e-03f, -2.12984215e-02f,
  4.24042344e-03f, 1.13046572e-01f, -5.22020385e-02f, 6.38350472e-03f, 1.59386210e-02f, -1.34694576e-01f, -8.10579285e-02f, -4.00639884e-03f, 5.62618449e-02f, -8.27616379e-02f,
  7.27603957e-02f, -7.38085434e-02f, -1.21559948e-01f, -1.31474435e-01f, -1.05093922e-02f, -1.25125572e-02f, 7.59745836e-02f, 8.20224583e-02f, -6.85757175e-02f, -1.56999752e-03f,
  6.70431331e-02f, -1.09931780e-02f, 1.68971792e-02f, 1.03549033e-01f, -5.91787063e-02f, -2.89323591e-02f, 7.33083254e-03f, 2.12848671e-02f, -5.83387017e-02f, -8.49090144e-02f,
  2.11059317e-01f, -2.39095181e-01f, -1.25145525e-01f, -2.36117557e-01f, -7.30795562e-02f, -1.55910268e-01f, -2.27997750e-01f, -1.85016632e-01f, -1.08900011e-01f, -1.16444036e-01f,
  -1.95382774e-01f, -9.16642882e-03f, 8.45129043e-02f, -7.10946247e-02f, 1.47861853e-01f, 2.21359938e-01f, -1.34690613e-01f, 8.38265195e-02f, 7.56784976e-02f, -1.39471725e-01f,
  4.41577807e-02f, -1.54173616e-02f, 8.87464806e-02f, -5.49142584e-02f, -1.93690941e-01f, 4.69169840e-02f, 1.05463095e-01f, -1.31040394e-01f, -1.40260488e-01f, -1.52923986e-01f,
  8.81876647e-02f, 8.56918693e-02f, 5.79703506e-03f, 6.21721037e-02f, -1.95726883e-02f, 5.27137741e-02f, -2.89260480e-03f, 2.35465448e-02f, 5.48191834e-03f, -1.96293816e-02f,
  -4.61656749e-02f, 1.11654356e-01f, 2.77052261e-02f, -2.18863338e-02f, 9.26624984e-03f, -3.34270149e-02f, 4.13811132e-02f, 2.69757342e-02f, -9.35386643e-02f, 2.82973126e-02f,
  -7.10044950e-02f, -4.93627004e-02f, -8.21517631e-02f, -3.22551504e-02f, -4.63965815e-03f, -1.26426205e-01f, 6.64633587e-02f, 2.87162643e-02f, -9.48099792e-03f, -2.70039476e-02f,
  7.67874792e-02f, -3.13469768e-02f, 6.11635596e-02f, 4.43535931e-02f, 2.79739909e-02f, 5.79097457e-02f, 8.26761778e-03f, 6.09897375e-02f, -6.08376600e-02f, 2.63611451e-02f,
  -4.38603126e-02f, 6.49932846e-02f, 3.45618241e-02f, 5.74579351e-02f, -1.91902707e-03f, 4.38037477e-02f, 3.48777026e-02f, 2.82576885e-02f, 5.14768735e-02f, 8.32814947e-02f,
  3.96787003e-02f, 4.71816659e-02f, -1.10730631e-02f, 3.53590734e-02f, -1.91162135e-02f, -1.85705721e-03f, -5.64046763e-03f, -1.60851609e-02f, 2.36255135e-02f, -6.91551641e-02f,
  -3.37361475e-03f, -6.11260124e-02f, -2.51654088e-02f, -2.99677718e-02f, -1.96019169e-02f, 3.89602631e-02f, -3.13435122e-02f, -4.87688817e-02f, -1.01119280e-02f, -6.92327172e-02f,
  6.97415508e-03f, 2.12839674e-02f, 1.06160520e-02f, -3.87321115e-02f, -1.10494107e-01f, -9.54014212e-02f, -5.12461662e-02f, 1.06635541e-02f, -1.65209159e-01f, -2.99712047e-02f,
  -6.79013506e-03f, 3.09332293e-02f, -2.83588730e-02f, 3.89103293e-02f, 2.35050097e-02f, 2.02951934e-02f, 2.84197535e-02f, -2.42818482e-02f, -9.03303642e-03f, -2.45519336e-02f,
  2.08381325e-01f, -1.73683703e-01f, -9.08897743e-02f, -7.74284974e-02f, -9.64806974e-02f, 1.33982837e-01f, 2.31604680e-01f, -1.60846442e-01f, -9.08887312e-02f, -1.65301953e-02f,
  4.17505987e-02f, 3.76144089e-02f, 1.48289651e-01f, 1.56869069e-01f, 1.16683833e-01f, 1.59389511e-01f, 1.05429992e-01f, 1.93983927e-01f, -4.56604511e-02f, 6.45547733e-02f,
  -1.86129417e-02f, 1.25775799e-01f, 6.97193593e-02f, -1.00060314e-01f, 1.84708163e-01f, -1.69571295e-01f, -7.07526598e-03f, -6.15015589e-02f, -1.12425923e-01f, 9.10276622e-02f,
  1.06255375e-01f, -4.37744446e-02f, 4.01658826e-02f, -3.97586375e-02f, -3.45026217e-02f, 1.40872574e-03f, 5.55213504e-02f, 8.81194025e-02f, -6.39660209e-02f, -1.36381999e-01f,
  -2.55969688e-02f, -7.33424574e-02f, 1.37836104e-02f, -1.01645336e-01f, 7.46923685e-02f, -1.06638558e-01f, -1.01134486e-01f, -9.19578001e-02f, -7.13960975e-02f, 5.77169769e-02f,
  -8.34685415e-02f, -3.97009514e-02f, 6.64845631e-02f, -1.31858215e-01f, -8.67387727e-02f, -1.81953590e-02f, -6.78175595e-03f, -9.58866552e-02f, 1.60987452e-02f, -4.80127186e-02f,
  6.72076494e-02f, 2.08200980e-02f, -3.30565535e-02f, -2.83966083e-02f, 5.50834164e-02f, 4.81605232e-02f, -4.34834175e-02f, -5.07811643e-02f, 1.68390793e-03f, 6.66036680e-02f,
  -4.29465026e-02f, -4.80380887e-03f, -9.05806664e-03f, 5.14019877e-02f, 1.29687376e-02f, -5.07954061e-02f, 2.77288072e-03f, -4.98277806e-02f, 1.99869722e-02f, -1.56162903e-01f,
  -5.07093966e-02f, -2.35621668e-02f, 2.00367812e-02f, -1.05091907e-01f, 9.69581977e-02f, -6.25522584e-02f, 1.18630817e-02f, 9.13559347e-02f, -4.89722118e-02f, 1.05285741e-01f,
  3.01898587e-02f, -1.35014936e-01f, -2.87434701e-02f, -2.50928290e-02f, -2.28499025e-02f, -3.55061032e-02f, -6.45535812e-02f, 3.57592888e-02f, 6.96987361e-02f, -6.30440861e-02f,
  -4.39901836e-02f, 6.68180967e-03f, -3.20247747e-02f, 3.73691469e-02f, -1.43009191e-02f, -8.00892934e-02f, 4.67162468e-02f, -5.35006635e-02f, -8.82313550e-02f, -2.13350579e-02f,
  -2.09589712e-02f, 1.11071900e-01f, -3.09100226e-02f, -3.00072450e-02f, -8.26707482e-02f, 4.87118326e-02f, -5.38600087e-02f, -3.06528974e-02f, -1.04131959e-01f, 2.56448481e-02f,
  -2.59237796e-01f, 1.19542122e-01f, -1.66483670e-02f, -3.17961663e-01f, 4.92459163e-02f, -1.68523803e-01f, -2.41742313e-01f, 2.96308696e-02f, -1.91491842e-02f, -9.75516513e-02f,
  -1.64642304e-01f, -4.46988568e-02f, 4.56786007e-02f, -1.20929079e-02f, 3.05984933e-02f, 1.12453505e-01f, -1.33125082e-01f, -1.70765683e-01f, 7.76028633e-02f, -7.79396445e-02f,
  -4.40302975e-02f, -3.98585163e-02f, 4.54686396e-02f, 3.32943797e-02f, -3.99708897e-02f, -4.25827987e-02f, -4.19684388e-02f, 1.32718146e-01f, -8.51402059e-02f, 1.03008188e-01f,
  -1.39249265e-01f, -6.07849993e-02f, 9.66956168e-02f, 6.49720780e-04f, -6.01278655e-02f, -3.82215753e-02f, -8.50434005e-02f, -7.81520829e-03f, 1.59588400e-02f, 5.48627321e-03f,
  3.77773237e-03f, -8.55237767e-02f, 6.88971803e-02f, 1.89283006e-02f, -1.48150139e-02f, 6.89778626e-02f, 8.08306970e-03f, -1.01106517e-01f, 2.94905007e-02f, 1.17455415e-01f,
  8.16189647e-02f, 5.64282164e-02f, -1.11823812e-01f, -3.27688307e-02f, -4.75718491e-02f, 9.55222361e-03f, 3.30476761e-02f, 1.16764214e-02f, -1.34123683e-01f, 1.81755424e-02f,
  9.96550769e-02f, -1.10976361e-01f, -5.07091619e-02f, -2.79676653e-02f, -1.23484880e-02f, -1.35354465e-02f, 1.10048592e-01f, -6.01649564e-03f, -6.25196099e-02f, -7.68009797e-02f,
  -5.55366687e-02f, 2.32177246e-02f, -1.44247506e-02f, 3.52834240e-02f, -5.39435772e-04f, -2.09676865e-02f, -1.02122769e-01f, 2.13318542e-02f, 1.21621741e-02f, 7.89703894e-03f,
  -6.01161905e-02f, 7.17964321e-02f, 5.45595624e-02f, -4.13188413e-02f, 4.39186729e-02f, -3.67115326e-02f, -7.95280859e-02f, 4.62597422e-02f, 8.25897157e-02f, 2.98496033e-03f,
  -2.95917064e-01f, -1.83571905e-01f, -5.13311662e-02f, -1.24690816e-01f, -2.79339179e-02f, -8.09636991e-03f, -4.69715297e-02f, 2.08554324e-02f, -4.41313423e-02f, -2.59114001e-02f,
  3.89270708e-02f, 6.55073160e-03f, 1.49671687e-02f, 3.25405784e-02f, 1.71060804e-02f, 1.53973643e-02f, 6.44641966e-02f, -6.55201450e-02f, -2.09982153e-02f, 7.00547993e-02f,
  4.00181189e-02f, -2.87813097e-02f, -4.62511778e-02f, -8.65342934e-03f, -1.10985721e-02f, -5.47663271e-02f, -7.17121959e-02f, 3.48229222e-02f, -1.69423129e-02f, 2.64441166e-02f,
  1.37339421e-02f, -3.70910540e-02f, 2.24537835e-01f, -7.59018725e-03f, -6.65156469e-02f, 5.56254312e-02f, 2.42038980e-01f, 2.76509747e-02f, -2.86901146e-02f, 1.71168707e-02f,
  6.28967863e-03f, 2.09417060e-01f, 4.78056297e-02f, 3.90220918e-02f, 1.05469041e-01f, -4.73684520e-02f, -7.31706247e-02f, -3.17825042e-02f, -1.04200162e-01f, -1.00957595e-01f,
  -8.02601874e-02f, -1.86831981e-01f, -6.86198100e-02f, -1.16078556e-01f, 1.28055185e-01f, 6.21686354e-02f, 3.80091078e-04f, 3.48201133e-02f, 6.48280606e-02f, 1.03941895e-01f,
  -1.55638605e-02f, 4.97007929e-02f, -4.34056371e-02f, 1.73421502e-02f, -3.78728695e-02f, -1.25470236e-01f, 7.43355528e-02f, 1.31906137e-01f, -4.42174543e-03f, 4.51130569e-02f,
  1.91797428e-02f, 1.35526750e-02f, -1.35859428e-02f, -2.61826999e-02f, -5.16490266e-02f, 5.31394668e-02f, -6.21493869e-02f, -2.10047923e-02f, 7.48290345e-02f, 1.32878929e-01f,
  2.80239228e-02f, 1.64362136e-02f, 2.11157296e-02f, 5.42164184e-02f, 2.45871507e-02f, 2.60124560e-02f, 8.49280208e-02f, 1.26354218e-01f, 5.75507544e-02f, -8.26461315e-02f,
  -1.26777455e-01f, -1.29929213e-02f, 2.35336497e-02f, 2.74505317e-02f, 1.80883508e-03f, -3.29717025e-02f, -1.03417352e-01f, 8.76025110e-02f, 4.19444293e-02f, 4.72624712e-02f,
  1.04455771e-02f, -2.64994260e-02f, -2.09668279e-02f, -1.38000390e-02f, -4.07314710e-02f, 1.24635883e-01f, 1.64737687e-01f, 1.42860999e-02f, -1.12263925e-01f, -8.27500150e-02f,
  5.83258271e-03f, -3.60979848e-02f, -1.17905054e-03f, 2.51816902e-02f, 1.21340267e-02f, -4.56175655e-02f, 1.26404166e-01f, 1.20056912e-01f, -7.99837187e-02f, -5.00439033e-02f,
  3.77710275e-02f, -1.12502709e-01f, 1.18589494e-02f, 2.74887551e-02f, 3.33042964e-02f, 3.36766578e-02f, -7.80442581e-02f, 8.15898329e-02f, -1.29966915e-01f, -2.27041747e-02f,
  7.96096493e-03f, 5.90116307e-02f, 1.16504710e-02f, 1.63298193e-03f, -3.37078162e-02f, -3.17222960e-02f, -7.19079822e-02f, 1.50485837e-03f, -5.26446141e-02f, 9.75806341e-02f,
  1.04272114e-02f, -7.07064047e-02f, 5.62452488e-02f, 3.15376744e-02f, -1.36454105e-01f, 6.52397349e-02f, 1.14313394e-01f, -5.23364730e-03f, -7.51366317e-02f, -7.93598890e-02f,
  -4.34313208e-01f, 1.03494644e-01f, 2.78050750e-02f, -1.14613913e-01f, 5.68495085e-03f, 1.98389515e-02f, -4.30638343e-02f, 1.05337568e-01f, -1.24371506e-01f, -5.66252209e-02f,
  -5.22263795e-02f, -1.64258599e-01f, 7.69507438e-02f, 1.93646140e-02f, -9.27501917e-03f, 1.27428994e-01f, 5.70286997e-02f, -1.18797518e-01f, 1.03800967e-01f, -8.65335986e-02f,
  4.37598825e-02f, 1.60308167e-01f, 1.63053066e-01f, 5.77110574e-02f, -9.51928347e-02f, -7.40239769e-02f, -8.54301006e-02f, 2.88065318e-02f, -3.10854632e-02f, 1.66464038e-02f,
  -2.65903562e-01f, -2.25982457e-01f, -8.34393874e-02f, -1.28220499e-01f, -7.93852955e-02f, -6.24723509e-02f, 1.14933020e-02f, 3.96064632e-02f, 4.75697704e-02f, -1.82479247e-02f,
  4.14620228e-02f, 2.37269532e-02f, 2.25374810e-02f, 1.49719059e-01f, 4.95613217e-02f, -4.51373979e-02f, 5.39899021e-02f, -5.92502533e-03f, -9.12271887e-02f, 1.36830553e-01f,
  8.08734819e-02f, -8.31540115e-03f, -4.07254733e-02f, 6.13968354e-03f, -7.18926638e-02f, 1.70509762e-03f, 7.78989960e-03f, -7.59907952e-03f, -5.28785437e-02f, -1.21292099e-01f,
  1.31761983e-01f, 6.31538779e-02f, -4.30976637e-02f, 1.13694021e-03f, 4.98542599e-02f, -3.64861488e-02f, -5.86016923e-02f, -6.64995611e-02f, 7.78819202e-03f, 3.54748592e-02f,
  9.15510766e-03f, -1.89391673e-01f, -2.59311707e-03f, 7.77938068e-02f, -8.28685686e-02f, -2.29156483e-02f, 6.37440197e-03f, 6.72474504e-03f, 4.30558482e-03f, 3.17416410e-03f,
  8.47798306e-03f, 2.40291599e-02f, 2.25603562e-02f, -2.80611422e-02f, -1.19342938e-01f, 6.09787814e-02f, -1.47368331e-02f, 2.11137850e-02f, -9.23637394e-03f, 3.11932862e-02f,
  -3.53064299e-01f, -2.74019033e-01f, -7.39641860e-02f, -1.30639493e-01f, -2.46470515e-02f, 2.90409159e-02f, -2.16976050e-02f, -1.63883697e-02f, -1.25160022e-02f, -5.02692014e-02f,
  4.94889803e-02f, -5.88087412e-03f, 2.85284165e-02f, 9.16388934e-04f, 7.72202983e-02f, -6.31860420e-02f, -3.32375318e-02f, -3.03659681e-02f, -1.14258133e-01f, -1.28757684e-02f,
  -8.32734443e-03f, -4.03036773e-02f, -8.73293802e-02f, 8.51348974e-03f, -4.66714054e-02f, 1.43622551e-02f, -3.38857137e-02f, 7.27111250e-02f, -5.85272089e-02f, 2.87614930e-02f,
  -3.47600169e-02f, -1.28047064e-01f, -1.22682706e-01f, -6.33491203e-02f, -2.30623931e-02f, -1.79857090e-01f, -2.91456640e-01f, 7.81865939e-02f, -2.38130346e-01f, -8.19341242e-02f,
  -1.71483502e-01f, -6.45636991e-02f, -2.07371190e-01f, -1.46781400e-01f, -4.67753746e-02f, -1.42394051e-01f, 6.43845052e-02f, 5.87290823e-02f, 1.46274865e-01f, -2.41510496e-02f,
  1.14184134e-01f, 1.06912531e-01f, 1.70424893e-01f, 2.98433602e-01f, 1.74090676e-02f, 2.21619144e-01f, 3.24023753e-01f, 1.84713230e-01f, 3.20294261e-01f, 7.61478469e-02f,
  -1.75287932e-01f, -1.28941298e-01f, 1.29103810e-02f, -4.77001928e-02f, 3.11557110e-02f, 4.09149751e-03f, -6.91870302e-02f, 1.07880048e-01f, -3.24855372e-02f, 5.81877865e-02f,
  -5.64838015e-02f, -2.36843210e-02f, 1.12085510e-02f, 2.64941845e-02f, -7.88611174e-02f, 7.51976445e-02f, 3.44173349e-02f, 3.71343433e-03f, -2.46465933e-02f, 1.20724984e-01f,
  8.68638139e-03f, 9.80515592e-03f, 8.99735093e-03f, 1.25695020e-01f, 5.24986275e-02f, 7.20095180e-04f, 1.20886620e-02f, 1.94529817e-02f, 5.87497242e-02f, 6.43780977e-02f,
  -3.36691104e-02f, 1.81913581e-02f, -7.53344595e-02f, 3.71013433e-02f, -1.15500791e-02f, -1.17501281e-02f, 2.83457484e-05f, 2.89157387e-02f, 2.30460558e-02f, -6.61609322e-02f,
  1.19734056e-01f, -5.80567233e-02f, -1.07090995e-02f, 5.10100499e-02f, -6.25256300e-02f, -9.15757194e-02f, -3.99481058e-02f, 1.30141452e-01f, -3.15912627e-02f, 2.17237370e-03f,
  -5.06513603e-02f, 5.63886724e-02f, -1.40817342e-02f, 9.21941102e-02f, -1.72753520e-02f, 3.09663452e-02f, 1.90246422e-02f, 8.30951333e-03f, -6.90047219e-02f, -1.60210785e-02f,
  -2.67782863e-02f, 1.09447069e-01f, 6.04910664e-02f, 3.46623026e-02f, -1.07356347e-01f, -3.69266979e-02f, -5.96835651e-02f, -2.50011906e-02f, 9.47325826e-02f, -2.47858483e-02f,
  4.81181853e-02f, 9.11592878e-03f, 8.15397874e-02f, -3.28676142e-02f, 5.56163043e-02f, -3.11361235e-02f, 9.10446700e-03f, 7.39909895e-03f, 4.70423773e-02f, 1.60154641e-01f,
  2.73903576e-03f, -1.44716606e-01f, -9.11785848e-03f, -2.97999233e-02f, 1.13235302e-01f, -7.34414980e-02f, -5.83888665e-02f, 5.64883612e-02f, 5.16678765e-03f, -1.92009676e-02f,
  9.99289379e-02f, 3.73198614e-02f, -1.27317846e-01f, 4.06133458e-02f, 1.49071872e-01f, 1.18288726e-01f, 1.42859519e-01f, 1.04603589e-01f, -2.19723303e-02f, 7.09640384e-02f,
  -1.01392262e-01f, 2.28373008e-03f, -2.44594794e-02f, -7.09959194e-02f, -9.73552838e-02f, -2.71251537e-02f, 9.98530462e-02f, 6.90209791e-02f, 1.58724131e-03f, 2.11883947e-01f,
  1.36411507e-02f, -2.75082737e-02f, -1.56258896e-01f, -1.62128165e-01f, 7.58729354e-02f, -4.04639132e-02f, 3.26530971e-02f, 8.65046382e-02f, -5.21313287e-02f, -6.98632449e-02f,
  -1.19282221e-02f, -7.68528655e-02f, -1.09928638e-01f, 6.21161498e-02f, 1.34471714e-01f, 8.96863565e-02f, 1.01085380e-01f, -5.06124878e-03f, -6.81580752e-02f, -6.75735772e-02f,
  9.19358432e-02f, 1.64395478e-02f, -6.09609205e-03f, -3.81567180e-02f, -3.96491289e-02f, -9.93696675e-02f, -6.00539036e-02f, 3.56043950e-02f, -3.40782106e-02f, -1.32900447e-01f,
  -8.01391006e-02f, 3.20795700e-02f, 1.10164933e-01f, 1.12073027e-01f, 2.68063303e-02f, 2.65125814e-03f, 6.01322055e-02f, 6.47018338e-03f, -4.98987315e-03f, -4.74564321e-02f,
  1.31954148e-01f, 1.91336945e-01f, 6.72985911e-02f, -2.53745895e-02f, -1.53563976e-01f, -9.71683189e-02f, 2.32945550e-02f, -2.52904985e-02f, -6.80331737e-02f, -4.07047346e-02f,
  -2.94133406e-02f, 1.77922305e-02f, -1.13240764e-01f, 5.90183437e-02f, 1.49803400e-01f, -5.24899103e-02f, 8.70473217e-03f, 7.47054070e-02f, 7.80053064e-02f, 2.22544782e-02f,
  -3.81569611e-03f, 1.26218900e-01f, -5.86173758e-02f, 6.84326142e-02f, -1.97033156e-02f, -1.30321672e-02f, 1.19187161e-01f, -1.47653595e-01f, -7.99693353e-03f, 8.22882652e-02f,
  1.74645007e-01f, 2.13218510e-01f, -8.35764855e-02f, 2.87019629e-02f, 1.71398427e-02f, 7.30133057e-02f, 1.09042659e-01f, 7.20954640e-03f, -9.50764585e-03f, 3.29234749e-02f,
  5.76763675e-02f, -6.57624751e-02f, 1.14347562e-01f, -1.21715451e-02f, 1.70584489e-02f, -4.09227014e-02f, -5.39686903e-03f, -2.06746478e-02f, 5.54611720e-02f, 5.51083218e-03f,
  7.29810596e-02f, 7.38315582e-02f, 2.33357213e-02f, 7.63828009e-02f, -1.24308933e-02f, 1.48822200e-02f, 1.52787089e-01f, -3.40911699e-03f, 9.26019102e-02f, -4.55805361e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 52)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 52;
const float L0_fan_Bp_bar_data[] = {
  1.37672424e-01f, -1.86377745e-02f, -3.31206024e-02f, 1.14283480e-01f, 2.63532922e-02f, 1.77066028e-01f, 9.70604569e-02f, 1.78720370e-01f, 1.37122259e-01f, 5.88761782e-03f,
  1.25215814e-01f, 1.11706171e-03f, -1.16971787e-02f, 1.61268964e-01f, 8.01218487e-03f, 9.98010486e-02f, 6.23967983e-02f, 1.17904739e-02f, 1.81951188e-02f, 4.87945937e-02f,
  5.43176532e-02f, 1.23550542e-01f, 1.25638574e-01f, 1.02564335e-01f, 2.23429613e-02f, 6.29083440e-02f, -3.83543186e-02f, 5.91995157e-02f, -1.06625557e-02f, 4.64202799e-02f,
  -8.57971385e-02f, -8.96846727e-02f, -5.01406332e-03f, 1.20307021e-01f, 8.66756663e-02f, 1.42596051e-01f, 6.95284680e-02f, 1.96850225e-01f, 1.31366000e-01f, 1.00562774e-01f,
  -2.01291367e-02f, -2.83494238e-02f, 1.02434412e-01f, 6.30875975e-02f, 1.17837079e-01f, -6.35784119e-02f, 2.78129652e-02f, 3.34136598e-02f, 2.60334220e-02f, 1.28849864e-01f,
  1.55483961e-01f, 1.81448102e-01f
};

// L1_fan_Wp (Shape: 6 x 64)
const int L1_fan_Wp_rows = 6;
const int L1_fan_Wp_cols = 64;
const float L1_fan_Wp_data[] = {
  -4.25915755e-02f, -2.88673211e-02f, 6.13537012e-03f, -9.80529748e-03f, -8.47669132e-03f, -1.48458272e-01f, 1.99268579e-01f, 2.76916437e-02f, -9.63699892e-02f, -5.43906027e-03f,
  -5.65248393e-02f, 7.77168646e-02f, -9.45431367e-02f, -7.65001327e-02f, -1.34893313e-01f, -1.38617188e-01f, -1.92576408e-01f, -8.57054740e-02f, -1.06392913e-01f, -2.62473226e-02f,
  -3.84258553e-02f, -2.15581805e-01f, -3.37271243e-02f, -1.06819659e-01f, -9.71876383e-02f, 1.60400767e-03f, 8.29944834e-02f, -9.11955759e-02f, 1.35079801e-01f, 1.06236979e-01f,
  7.12293666e-03f, -8.79548937e-02f, 6.54322132e-02f, 1.16862044e-01f, 1.73139200e-01f, -1.14153534e-01f, 7.99804553e-02f, 1.17397860e-01f, 6.92761987e-02f, 1.01398855e-01f,
  1.96319491e-01f, 6.43682182e-02f, 5.79133928e-02f, 9.50351879e-02f, -2.13515153e-03f, 9.11895111e-02f, 2.44425200e-02f, 6.47677630e-02f, -3.68277146e-03f, 1.25096217e-01f,
  -9.45163146e-02f, 5.54217547e-02f, -5.97823486e-02f, 3.72905396e-02f, -1.57812089e-01f, -9.36842337e-02f, -9.26457047e-02f, 1.53039411e-01f, -7.87978694e-02f, 1.44988611e-01f,
  -3.55326175e-03f, 4.33742218e-02f, -4.82608788e-02f, -1.17643446e-01f, 2.85494626e-02f, 8.99304301e-02f, 8.54060277e-02f, -2.20031794e-02f, -8.43636841e-02f, -2.08380399e-03f,
  -8.76471326e-02f, 2.70805597e-01f, -2.72704661e-02f, -2.49216165e-02f, 8.43168572e-02f, 2.04727769e-01f, 9.19312052e-03f, 9.00196098e-03f, 2.60850545e-02f, -2.57458761e-02f,
  -7.70103633e-02f, 1.43765584e-01f, -1.36253595e-01f, 9.73623693e-02f, -2.62461342e-02f, 5.68664167e-03f, 4.25124504e-02f, 1.22144476e-01f, 2.31021270e-01f, 7.68216103e-02f,
  -1.88090995e-01f, -1.40918642e-01f, -5.25612384e-02f, 8.23913738e-02f, -1.56442419e-01f, 1.99396744e-01f, -7.11035281e-02f, -5.79587482e-02f, 4.22349349e-02f, 1.56891823e-01f,
  -4.86720400e-03f, -1.44215032e-01f, -1.41579509e-01f, -1.65116906e-01f, -9.12076011e-02f, 1.94301769e-01f, 1.00351132e-01f, -2.92141438e-02f, -2.32124422e-02f, 1.36973053e-01f,
  -6.95357472e-02f, -4.70066220e-02f, -9.62418783e-03f, -1.11271553e-01f, 1.86816946e-01f, -5.57676144e-02f, -1.35675177e-01f, -1.50968328e-01f, 8.59899595e-02f, 5.40787540e-02f,
  -2.67601535e-02f, 2.27379166e-02f, 5.55322021e-02f, 8.94305706e-02f, 6.83017448e-02f, 9.55351889e-02f, -5.33860885e-02f, -6.97454661e-02f, 3.11195869e-02f, -4.92651761e-02f,
  5.49352057e-02f, -2.87550446e-02f, 4.92356718e-02f, 4.51049097e-02f, -1.37024477e-01f, -6.35296777e-02f, 3.38804573e-02f, -1.43766806e-01f, -1.45934066e-02f, -5.83376512e-02f,
  2.46471586e-03f, 3.88565958e-02f, 3.68373170e-02f, -5.84840588e-02f, 2.83616893e-02f, 1.61374852e-01f, 8.09048563e-02f, 8.85106027e-02f, -9.92881879e-02f, 6.48906603e-02f,
  8.90599936e-02f, 6.53232634e-02f, -2.98362765e-02f, 6.12182170e-02f, -6.20025359e-02f, 6.72851503e-02f, -1.34639563e-02f, -1.14766015e-02f, -4.51049395e-02f, 4.78032455e-02f,
  -6.94303364e-02f, -1.39978394e-01f, -1.65331468e-01f, 1.19335845e-01f, 1.39804006e-01f, -4.00779545e-02f, -6.12587631e-02f, -1.58828527e-01f, -3.90640534e-02f, 3.87426950e-02f,
  1.34306580e-01f, -1.40577927e-01f, -6.34340048e-02f, -1.14220716e-01f, 5.80200665e-02f, 1.72685385e-01f, -8.49796981e-02f, -7.79911503e-02f, 2.50848308e-02f, -2.58845657e-01f,
  -6.49316087e-02f, -3.09923496e-02f, 1.98058933e-01f, 1.39535680e-01f, -2.15641186e-02f, -1.55220166e-01f, 1.06666602e-01f, -1.64471090e-01f, 5.36168180e-02f, -2.15391621e-01f,
  7.49808475e-02f, 9.35668722e-02f, -2.85434853e-02f, 5.74090630e-02f, 1.38488729e-02f, 5.78275546e-02f, 1.19242780e-01f, 2.02804245e-02f, 1.16905965e-01f, -5.10675460e-02f,
  -1.59168586e-01f, 1.99192196e-01f, -9.28455815e-02f, -1.34542257e-01f, -6.50695860e-02f, -2.45127842e-01f, 1.70667797e-01f, -1.91043273e-01f, 6.02908656e-02f, 1.13789374e-02f,
  7.36987144e-02f, -1.04924314e-01f, -9.04605761e-02f, -7.05256462e-02f, -7.01429844e-02f, -1.73402354e-02f, -1.64427966e-01f, -1.70048431e-01f, -5.51691279e-02f, 9.64514017e-02f,
  7.24642798e-02f, -1.45397142e-01f, 1.65023938e-01f, -1.95275769e-01f, -6.94834739e-02f, 6.01057038e-02f, -4.39274274e-02f, -5.25216088e-02f, 2.29452088e-01f, -3.41236219e-02f,
  1.11473715e-02f, 1.45143405e-01f, -1.86133515e-02f, -8.61673336e-03f, 1.44526795e-01f, -6.56423271e-02f, 5.50156683e-02f, 9.37206112e-03f, 6.24012426e-02f, 1.58084184e-01f,
  4.70123328e-02f, 5.14552891e-02f, -5.09959795e-02f, -1.05202064e-01f, 6.71576932e-02f, 1.68621123e-01f, -2.07831055e-01f, -9.21192914e-02f, 1.02449775e-01f, -1.40139237e-01f,
  -1.26819953e-01f, -6.09985031e-02f, 2.06050687e-02f, -7.66483918e-02f, 1.13935746e-01f, 1.39503628e-01f, -7.17466101e-02f, -7.23929480e-02f, -1.14823855e-01f, 1.48546537e-02f,
  -7.60650411e-02f, -3.41934599e-02f, -9.28309187e-02f, -6.59844205e-02f, 1.82322264e-02f, -7.79142603e-03f, 4.56446372e-02f, -1.44156098e-01f, -2.33536121e-02f, 2.55806483e-02f,
  7.92697445e-02f, 1.57726228e-01f, 1.45526722e-01f, 1.51114026e-02f, 2.47964244e-02f, -1.37373924e-01f, -3.87879126e-02f, 2.26801217e-01f, -1.98944211e-01f, -3.37904617e-02f,
  4.26518545e-02f, -2.89550945e-02f, 7.63320476e-02f, -6.08592946e-03f, 2.45070048e-02f, 1.59984715e-02f, 1.83914617e-01f, 3.70834395e-02f, 8.56596902e-02f, 5.10896847e-04f,
  -1.12742670e-01f, -1.86410230e-02f, 3.41994017e-02f, 1.33178413e-01f, 3.01800333e-02f, 3.29282992e-02f, 1.19036973e-01f, -1.39068589e-01f, -1.53440148e-01f, 2.01799255e-02f,
  1.22815289e-01f, -2.35615060e-01f, 5.20946309e-02f, -1.19190305e-01f, -4.84969541e-02f, 2.06232574e-02f, -6.35090377e-03f, 1.46181002e-01f, 9.06849876e-02f, 9.94102210e-02f,
  -2.02618521e-02f, -7.54805207e-02f, -4.58147116e-02f, 4.83438186e-02f, -5.43074161e-02f, -4.00777301e-03f, -1.11537032e-01f, -3.29041816e-02f, 1.46363199e-01f, 9.44269374e-02f,
  1.90392397e-02f, -4.58376110e-03f, -9.30619016e-02f, -3.19620296e-02f, -1.33897439e-01f, 1.11691371e-01f, 7.56481737e-02f, 2.59380311e-01f, -4.96063046e-02f, -1.02924146e-02f,
  -1.92966118e-01f, 6.22313702e-03f, -9.32767093e-02f, 1.12508833e-01f, -4.30388451e-02f, -8.96904469e-02f, 4.21068035e-02f, 3.25503647e-01f, 4.12587561e-02f, 4.17262353e-02f,
  -1.88781306e-01f, 1.66681811e-01f, -5.71775995e-02f, 1.91654742e-01f, 2.60712299e-03f, 7.75935277e-02f, -1.89064234e-01f, 4.37039286e-02f, -1.08646952e-01f, -6.91684932e-02f,
  2.43202627e-01f, 1.75161123e-01f, 5.07803960e-03f, 1.36284292e-01f, -2.01281473e-01f, 5.04827537e-02f, 4.15973403e-02f, 1.56881660e-01f, 8.85937586e-02f, 8.97799879e-02f,
  2.23695319e-02f, 2.80958526e-02f, 5.38821816e-02f, 2.06032440e-01f, -2.28186939e-02f, -1.44116327e-01f, -1.12630859e-01f, 3.67796905e-02f, 1.17621474e-01f, -1.21129639e-01f,
  -7.86987245e-02f, -1.38116658e-01f, 2.02119768e-01f, -1.68074355e-01f, 7.23443106e-02f, 2.34454498e-02f, 1.63348600e-01f, 1.63084105e-01f, -5.73993176e-02f, 6.27794489e-02f,
  -3.00292838e-02f, -1.33461673e-02f, 3.71070981e-01f, -9.93658975e-02f
};

// L1_fan_Wp_bar (Shape: 52 x 64)
const int L1_fan_Wp_bar_rows = 52;
const int L1_fan_Wp_bar_cols = 64;
const float L1_fan_Wp_bar_data[] = {
  3.89757752e-02f, -4.45088819e-02f, -7.07953647e-02f, 2.91714780e-02f, -9.07265916e-02f, -8.90071318e-02f, 1.05322376e-01f, 6.15345016e-02f, -3.29975411e-02f, 1.12416007e-01f,
  -7.53357112e-02f, 5.17120250e-02f, -7.32722580e-02f, 5.33899218e-02f, -9.20610428e-02f, -3.97928953e-02f, -5.49058281e-02f, 1.13037869e-01f, -2.84305159e-02f, -1.69192925e-02f,
  -2.58055352e-05f, -1.12959899e-01f, -8.62478688e-02f, 1.24644199e-02f, 1.46006122e-02f, -1.98382124e-01f, 1.26512557e-01f, 2.49827560e-02f, 7.17280358e-02f, -8.57130438e-02f,
  -4.15681899e-02f, -1.15839064e-01f, 9.07475129e-02f, 1.08953826e-01f, 1.44764930e-01f, -6.83047846e-02f, -2.22640932e-02f, 3.38231772e-02f, 8.88250917e-02f, 1.17914431e-01f,
  1.75506249e-01f, 2.81035751e-02f, 8.90688673e-02f, 8.02199766e-02f, 9.53307282e-03f, 1.45008191e-01f, 3.01805744e-03f, 1.14413857e-01f, 8.77578482e-02f, 7.71515891e-02f,
  -1.34003192e-01f, 5.90881109e-02f, -2.68447604e-02f, -3.08354609e-02f, -1.44040316e-01f, -2.52301302e-02f, -2.98472606e-02f, 1.49604708e-01f, -4.32258323e-02f, 9.54068005e-02f,
  4.98061813e-02f, 1.19599387e-01f, -8.08234513e-02f, -1.29035100e-01f, -3.01356371e-02f, -1.50423810e-01f, -4.49091680e-02f, -8.26614052e-02f, 4.79298979e-02f, 6.96921274e-02f,
  -4.15178307e-04f, -9.00072083e-02f, 9.58731323e-02f, -9.56700221e-02f, 1.21759728e-01f, -2.43539155e-01f, -4.99828579e-03f, 1.31019071e-01f, 2.40564808e-01f, 1.92540899e-01f,
  4.27345708e-02f, 4.47515734e-02f, 2.24526927e-01f, -1.55858204e-01f, 1.64832741e-01f, 2.75581986e-01f, -1.90636858e-01f, 7.23598823e-02f, 9.12955180e-02f, -1.22174166e-01f,
  -9.24114604e-03f, 3.44494507e-02f, -1.15891494e-01f, -1.60510942e-01f, 5.13665862e-02f, 1.11942783e-01f, 9.73726958e-02f, -1.02923863e-01f, -1.48909748e-01f, 5.00571877e-02f,
  1.07087068e-01f, -5.46953604e-02f, 6.19349964e-02f, -1.24772124e-01f, -2.13668514e-02f, -9.99318808e-02f, -1.39413580e-01f, -1.12259381e-01f, 1.36750996e-01f, -9.98020917e-02f,
  8.47963020e-02f, 5.14881983e-02f, -7.20528588e-02f, 8.72214660e-02f, -3.38849500e-02f, 1.27340168e-01f, -5.49570285e-02f, 1.13340408e-01f, 1.90435931e-01f, 8.32258016e-02f,
  1.19312294e-01f, -3.88311339e-03f, 2.36227047e-02f, -1.94089174e-01f, -1.38203666e-01f, -1.67204663e-01f, 1.09486073e-01f, 5.91065176e-02f, 4.29596193e-02f, 9.34829190e-02f,
  1.37648404e-01f, 3.14562395e-02f, 1.03156447e-01f, 2.38184873e-02f, -8.53210539e-02f, 1.31156325e-01f, -5.07657714e-02f, 6.08229898e-02f, -1.56234102e-02f, 2.01862127e-01f,
  9.52873081e-02f, 1.09122336e-01f, -8.07259381e-02f, -5.68871684e-02f, -1.83710456e-02f, 1.33849919e-01f, -3.49555612e-02f, 1.84273392e-01f, -5.59686050e-02f, 3.55040506e-02f,
  1.48863614e-01f, 1.11229502e-01f, 1.94827110e-01f, 8.53580609e-02f, -1.94107220e-01f, -5.87136671e-02f, 1.21382743e-01f, 1.08315706e-01f, -1.53598785e-01f, 7.26829395e-02f,
  2.27721762e-02f, 3.93830128e-02f, 1.33256376e-01f, 8.20088089e-02f, 1.00673863e-03f, -1.73459187e-01f, -1.30068392e-01f, -7.57952183e-02f, -9.14136320e-02f, 1.45959675e-01f,
  2.14927107e-01f, -8.72357655e-03f, 8.12157115e-04f, 2.55820721e-01f, -3.45682241e-02f, 1.58741727e-01f, 1.88575108e-02f, -2.02360917e-02f, -3.91963981e-02f, -7.94373602e-02f,
  -7.58851599e-03f, -1.60311088e-01f, 1.49475724e-01f, 1.71946526e-01f, 1.23692658e-02f, -4.71933894e-02f, 6.39632903e-03f, 1.16588235e-01f, 1.12069033e-01f, 1.53667167e-01f,
  -1.46569712e-02f, -7.28873685e-02f, 7.33565018e-02f, 1.69138238e-01f, 8.02034363e-02f, 1.05429506e-02f, 8.75345767e-02f, 1.58819586e-01f, 8.36679116e-02f, -6.23860285e-02f,
  1.48805045e-02f, 8.03884771e-03f, -5.73181883e-02f, -8.54622014e-03f, -6.36187717e-02f, -7.63183013e-02f, 9.55837592e-02f, -1.50130436e-01f, 5.94525672e-02f, 1.75186038e-01f,
  1.48646370e-01f, 1.77782401e-01f, 6.21954650e-02f, -1.04203098e-01f, 4.63342629e-02f, 1.19380064e-01f, -1.34785816e-01f, -9.34740752e-02f, 8.04838538e-02f, -2.36749370e-02f,
  1.28215149e-01f, -1.23159193e-01f, 5.71827367e-02f, 4.50869882e-03f, 1.20173497e-02f, 5.41641526e-02f, 8.20412636e-02f, -1.94775350e-02f, 1.86090216e-01f, -1.38200104e-01f,
  3.03473603e-02f, 2.42882725e-02f, -2.03280505e-02f, 9.39003080e-02f, 2.35801205e-01f, -7.65576661e-02f, 4.75980043e-02f, 1.33658126e-01f, 8.08911920e-02f, 2.96932340e-01f,
  1.73796356e-01f, 1.69899091e-01f, -2.03815073e-01f, -1.65055618e-01f, -4.89226207e-02f, 1.53466403e-01f, -4.49165776e-02f, 1.15898177e-01f, 1.93537340e-01f, -1.03900015e-01f,
  -6.22113124e-02f, -5.71731068e-02f, 3.83462198e-02f, 1.17089204e-01f, -7.83072412e-03f, 4.13052216e-02f, 6.20703660e-02f, 5.35150319e-02f, -6.01105094e-02f, 1.46881845e-02f,
  -5.24463169e-02f, 1.19037919e-01f, 6.53643832e-02f, 1.07092857e-01f, 5.28063299e-03f, 7.64178559e-02f, -1.20058179e-01f, -3.76625150e-03f, -1.07047915e-01f, -2.92564351e-02f,
  1.68592155e-01f, 1.37680769e-01f, 1.54613018e-01f, 1.19806558e-01f, 6.41602799e-02f, 8.86184722e-03f, -1.55745670e-01f, 4.88314070e-02f, 2.17051767e-02f, 1.69894785e-01f,
  1.51550725e-01f, -2.41596848e-02f, -9.40991268e-02f, 1.76643699e-01f, -1.37886822e-01f, -1.09349772e-01f, -1.76516548e-02f, 1.26669198e-01f, 1.02131791e-01f, -3.65126543e-02f,
  -1.19435340e-01f, 1.16222180e-01f, 1.00784421e-01f, -1.15380678e-02f, -2.91946381e-02f, 4.13240306e-02f, -4.88152727e-02f, 5.18828444e-02f, 5.07335551e-02f, 2.12667175e-02f,
  1.71389073e-01f, -4.33664694e-02f, -1.53161183e-01f, 6.02120236e-02f, 7.25274608e-02f, 3.55628435e-03f, 2.65607703e-02f, 4.06731293e-02f, 7.20745176e-02f, 6.73283190e-02f,
  -8.38419572e-02f, 1.97846889e-02f, 2.16027170e-01f, -1.99726567e-01f, -9.68124643e-02f, 4.43514325e-02f, 1.66666461e-03f, 3.36972959e-02f, 2.20301107e-01f, 4.36450690e-02f,
  1.20636947e-01f, 1.31772822e-02f, 9.04265493e-02f, -1.40751544e-02f, 1.65275618e-01f, -8.81389156e-02f, -1.43383294e-02f, -3.04518551e-01f, -3.13723795e-02f, -1.22756837e-02f,
  1.31754413e-01f, -7.64140487e-02f, 1.29961103e-01f, 9.57268700e-02f, -5.50004914e-02f, 1.42330527e-01f, 4.55912389e-02f, -5.93947545e-02f, 9.42774490e-02f, 1.42565109e-02f,
  3.00047845e-01f, -1.69709418e-02f, 3.61010917e-02f, -9.61901993e-02f, -1.81096643e-01f, 1.25058489e-02f, 1.99214026e-01f, -5.25522865e-02f, 7.71283582e-02f, -3.21588144e-02f,
  7.38264024e-02f, -8.51016343e-02f, 1.37054911e-02f, -5.82110286e-02f, 1.62730962e-01f, -6.68340325e-02f, 7.91030303e-02f, 3.16276960e-02f, 1.40273601e-01f, -1.88238248e-02f,
  7.92713985e-02f, -1.36160985e-01f, 8.64264145e-02f, -8.13653916e-02f, -3.17972116e-02f, 1.46178436e-02f, 2.03052580e-01f, 9.99100581e-02f, -9.79170278e-02f, 2.11315095e-01f,
  3.27897593e-02f, 9.08347741e-02f, -9.86548290e-02f, 1.93364173e-01f, 3.48852738e-03f, 1.78682785e-02f, -1.09478846e-01f, 7.84266293e-02f, 2.03420073e-01f, -1.87012590e-02f,
  4.89112511e-02f, 4.57486361e-02f, -8.90650526e-02f, 1.18140489e-01f, 6.11839406e-02f, 3.93051803e-02f, 5.40799610e-02f, 1.22982331e-01f, 2.36884132e-02f, 1.25299077e-02f,
  -2.32489705e-01f, -2.39566922e-01f, 1.77903380e-02f, 4.83595300e-03f, 8.22541192e-02f, -9.40799713e-02f, 1.31929487e-01f, 1.35827661e-01f, 1.32521152e-01f, 1.51024789e-01f,
  1.59471989e-01f, -1.22842528e-01f, 7.47156814e-02f, -1.93075556e-02f, 2.31008396e-01f, 8.81642476e-02f, 8.55655149e-02f, 1.59985404e-02f, 6.09687380e-02f, 2.13256881e-01f,
  1.54523462e-01f, 9.20587704e-02f, 5.65415844e-02f, -1.08520715e-02f, 1.91720389e-02f, -2.76135746e-02f, 2.42253598e-02f, -1.04113761e-02f, -3.75344902e-02f, 5.94523884e-02f,
  -2.12237909e-02f, 1.24473549e-01f, 4.27644663e-02f, -2.27530859e-02f, -7.62310848e-02f, -9.51450318e-02f, -8.42464492e-02f, -5.52316569e-02f, 4.44050916e-02f, -1.61329150e-01f,
  1.71366498e-01f, -9.52952281e-02f, -5.75939976e-02f, 8.48503336e-02f, 9.13254246e-02f, 9.85636637e-02f, 1.28740883e-02f, 6.19043820e-02f, 1.44773871e-01f, -2.22987011e-02f,
  -2.53896303e-02f, 7.32691064e-02f, 1.57164261e-01f, -4.43738438e-02f, -4.31997776e-02f, -1.13679610e-01f, 2.92947404e-02f, 7.87899271e-02f, -4.69380262e-04f, -4.96681705e-02f,
  -5.07582873e-02f, -7.55253062e-02f, 6.26825467e-02f, -1.13602668e-01f, 1.10636950e-02f, -6.29947707e-02f, 1.27958721e-02f, -7.23510757e-02f, 1.06366567e-01f, -1.52720213e-01f,
  6.46258844e-03f, 4.47200499e-02f, 4.68143485e-02f, 5.74605837e-02f, 3.78452637e-03f, -4.08758502e-03f, 1.00339778e-01f, 1.49907768e-02f, 2.25570291e-01f, 8.07287022e-02f,
  -1.05474778e-01f, 1.28466282e-02f, 2.33723726e-02f, -3.31787579e-02f, 1.05718292e-01f, -1.51221931e-01f, 1.78925261e-01f, -4.29737680e-02f, -7.85141662e-02f, 5.61703220e-02f,
  2.23006293e-01f, 5.89191765e-02f, 6.84318244e-02f, 1.52495235e-01f, -2.97573227e-02f, 9.62534100e-02f, 1.15669340e-01f, 2.90156752e-02f, 1.38435438e-01f, -8.96604881e-02f,
  -1.12924818e-02f, 3.16110142e-02f, 1.56284750e-01f, -4.39386293e-02f, 1.18356898e-01f, 5.04618175e-02f, 6.77851681e-03f, 2.11617857e-01f, -5.84449247e-02f, 1.95342034e-01f,
  -1.64884776e-01f, 9.47697610e-02f, 2.51828860e-02f, 8.64396840e-02f, -1.19561113e-01f, 2.25586951e-01f, 1.15114942e-01f, 5.46473637e-02f, -1.18160836e-01f, 2.27417648e-02f,
  1.68035284e-01f, -1.12346075e-02f, 4.73969430e-02f, 3.14055979e-02f, 1.28099769e-01f, 1.50444224e-01f, 3.87159549e-02f, 2.54328176e-02f, 6.10189773e-02f, 1.03283308e-01f,
  5.95361032e-02f, 7.54248425e-02f, -1.38777822e-01f, 1.49417743e-01f, 4.33967225e-02f, -8.64110887e-03f, -6.84261620e-02f, 1.16376132e-01f, -1.23972381e-02f, 4.00902256e-02f,
  -8.45370591e-02f, -3.66016701e-02f, -1.69745773e-01f, 1.50610097e-02f, 3.80976535e-02f, -1.26575783e-01f, 2.37236395e-02f, 2.36167889e-02f, -1.17211387e-01f, 1.78809315e-01f,
  1.01449080e-01f, 1.43660560e-01f, 9.85516757e-02f, 3.10790096e-03f, 2.05507558e-02f, 4.47861925e-02f, 8.40018913e-02f, -9.23100784e-02f, -9.93657485e-03f, 7.46673346e-02f,
  -4.67699207e-02f, 1.86416328e-01f, 1.64922085e-02f, 2.57647708e-02f, -3.70961390e-02f, 1.45053208e-01f, -8.91751796e-02f, 1.04205936e-01f, -8.40856582e-02f, -7.75690898e-02f,
  4.92159203e-02f, 1.07206227e-02f, 8.36482197e-02f, 5.50416186e-02f, 1.84204489e-01f, -1.49165183e-01f, -8.83921385e-02f, -8.37933570e-02f, 7.08885342e-02f, 1.38195222e-02f,
  -1.12935357e-01f, 1.21944353e-01f, 7.33405817e-03f, -2.71521211e-02f, 7.88025856e-02f, -4.52287542e-03f, 1.36187360e-01f, 2.06065610e-01f, 1.31885841e-01f, 6.38629198e-02f,
  1.03270277e-01f, 1.84028283e-01f, 5.18644601e-02f, -5.50136492e-02f, -1.52581080e-03f, 7.73424357e-02f, 1.11952171e-01f, 2.00215369e-01f, 5.43541908e-02f, -1.54705301e-01f,
  -1.54943496e-01f, -1.80646613e-01f, -1.03010595e-01f, -8.62649083e-02f, -7.73206428e-02f, 2.43368402e-01f, 2.08313167e-01f, -1.61711738e-01f, 1.51824206e-01f, -3.79379117e-03f,
  1.06214419e-01f, 5.27029373e-02f, -7.42219097e-04f, -8.49526599e-02f, 1.50805950e-01f, 2.24309355e-01f, -2.11088285e-01f, -1.48974359e-02f, -5.84080182e-02f, -8.14712234e-03f,
  3.50025535e-01f, -3.41040827e-02f, 3.96645367e-02f, 4.78363829e-03f, -7.86054805e-02f, -1.04235381e-01f, -1.22095883e-01f, 1.94795862e-01f, 1.54794231e-01f, -1.15840867e-01f,
  -1.19237371e-01f, 2.44291022e-01f, 1.17610142e-01f, 1.37930557e-01f, -7.28498101e-02f, 7.27691054e-02f, 1.25389904e-01f, 5.93936630e-02f, -7.79591724e-02f, -9.41157490e-02f,
  6.30669156e-03f, 1.51602253e-01f, -3.69937867e-02f, -1.23699047e-02f, 2.28480082e-02f, 5.98288327e-03f, 2.18134642e-01f, 9.84941348e-02f, -1.18689403e-01f, 7.15956390e-02f,
  -3.61191854e-02f, -6.57305419e-02f, -4.53388654e-02f, 6.86287284e-02f, 8.50112960e-02f, -9.94584709e-02f, 6.14640377e-02f, -2.25482732e-01f, 4.98899743e-02f, -2.82785725e-02f,
  -1.34940758e-01f, -2.09809497e-01f, 9.48595405e-02f, 8.57637227e-02f, -1.10382386e-01f, 9.91090760e-02f, -4.04758984e-03f, -3.91702354e-02f, 1.56562164e-01f, -4.38590022e-03f,
  1.32495582e-01f, 4.87523600e-02f, 2.00688317e-02f, -3.70078385e-02f, -2.09650069e-01f, -3.81924212e-02f, 1.40886292e-01f, 7.29359165e-02f, 1.24791510e-01f, -1.25622794e-01f,
  2.13844612e-01f, -1.20380014e-01f, 6.98250979e-02f, 1.56975865e-01f, -2.76337937e-02f, -7.66422823e-02f, 4.79626395e-02f, 1.73643649e-01f, 1.25493944e-01f, 1.18878365e-01f,
  2.11888954e-01f, -1.27390295e-01f, -1.04603373e-01f, 1.35387436e-01f, -3.03388089e-02f, -1.26858175e-01f, 8.10936540e-02f, 5.41066676e-02f, -1.50197325e-02f, 1.14801656e-02f,
  -4.45006751e-02f, 6.88176006e-02f, 8.90663490e-02f, 4.92984371e-04f, -3.78881558e-03f, -5.46952561e-02f, -7.04341829e-02f, 1.77911714e-01f, -1.02599254e-02f, -5.87160094e-03f,
  -5.13579510e-02f, -1.01635844e-01f, -5.43874167e-02f, 1.33384317e-01f, -2.59415023e-02f, 2.62185093e-02f, 1.48422075e-02f, -4.54057381e-02f, 1.17500775e-01f, -4.85114567e-02f,
  1.17194923e-02f, -1.68412998e-01f, 3.82963270e-02f, -1.31112784e-01f, -1.00234011e-02f, -2.03426108e-01f, 6.05668165e-02f, 1.92827180e-01f, 1.04033686e-01f, -4.62454148e-02f,
  2.11462658e-02f, 5.95734417e-02f, 1.95775345e-01f, 5.06620631e-02f, 6.20130561e-02f, 7.97253549e-02f, 3.88449728e-02f, 9.09408405e-02f, 1.64556243e-02f, 5.99447899e-02f,
  3.73351537e-02f, -2.12583140e-01f, 3.67390811e-02f, -6.34868667e-02f, -7.47788474e-02f, 1.23218067e-01f, 1.66156858e-01f, 7.20769316e-02f, -7.02111647e-02f, 1.90818653e-01f,
  -7.64827430e-02f, 2.39508487e-02f, 2.63164043e-02f, 5.04136877e-03f, 1.56330802e-02f, -1.42486528e-01f, 8.77715368e-03f, -6.37304857e-02f, 1.07199565e-01f, -6.68746904e-02f,
  1.95839256e-01f, 1.41611785e-01f, 1.59977823e-02f, 1.67148799e-01f, -1.04604341e-01f, 9.51051805e-03f, -1.11591160e-01f, 1.95809662e-01f, 1.75431103e-01f, 1.99317321e-01f,
  1.78041309e-02f, 1.13500282e-01f, 1.60710990e-01f, -4.24286984e-02f, -1.21307664e-01f, -4.78759855e-02f, 1.60488546e-01f, -3.12040281e-02f, 1.59681775e-02f, 4.87630069e-02f,
  1.19999848e-01f, 8.40389282e-02f, 1.32237561e-02f, 7.99958855e-02f, 1.55165140e-02f, -1.90530289e-02f, 3.86598927e-04f, 4.93034385e-02f, -2.25952175e-02f, -1.80062689e-02f,
  1.74911022e-02f, -1.33885026e-01f, -3.01905721e-03f, -8.99434369e-03f, 9.28600803e-02f, -4.30586599e-02f, -1.22160450e-01f, -6.83119297e-02f, 3.67350355e-02f, 5.76241538e-02f,
  1.00871235e-01f, -1.22724682e-01f, 8.76194164e-02f, 1.44713104e-01f, -7.37540722e-02f, 2.31530607e-01f, 7.43965060e-02f, 8.76186639e-02f, 7.68828318e-02f, -6.15177602e-02f,
  -1.01485848e-01f, -4.07046489e-02f, 7.80403465e-02f, -9.90831926e-02f, 3.35134491e-02f, 8.24023336e-02f, -2.52118539e-02f, 6.75882399e-02f, -8.15128312e-02f, 7.30266720e-02f,
  -9.35657918e-02f, -1.72414146e-02f, -1.07544966e-01f, -7.84165878e-03f, -5.23990057e-02f, -1.31828904e-01f, 2.77064797e-02f, -3.22595648e-02f, 1.99054301e-01f, 1.07133888e-01f,
  2.03301623e-01f, -1.23879902e-01f, -8.85234401e-03f, -8.76103044e-02f, 1.10293768e-01f, -1.22078449e-01f, 3.91567834e-02f, -3.82954963e-02f, 1.04493387e-01f, 1.28301354e-02f,
  -7.22153336e-02f, 5.03576696e-02f, 3.61233577e-02f, -2.96017155e-02f, 1.93987321e-02f, -1.07711069e-02f, 3.85597125e-02f, 8.19424689e-02f, -2.16938451e-01f, 7.03996718e-02f,
  5.27890027e-02f, -1.00979827e-01f, 3.64776216e-02f, -5.87155968e-02f, 1.13065682e-01f, 1.20881788e-01f, 1.16652839e-01f, 2.04808727e-01f, 1.92450330e-01f, 5.52487560e-02f,
  1.38602734e-01f, -7.81564564e-02f, -2.81277448e-02f, 2.74012923e-01f, -1.13897398e-01f, 8.69752839e-02f, 1.09535351e-01f, -1.93299167e-02f, -1.02238417e-01f, 1.11585580e-01f,
  -1.14259735e-01f, -7.68663064e-02f, 6.36999309e-02f, 2.09152997e-01f, 7.41397962e-02f, -1.30817592e-01f, -2.05937982e-01f, 2.10167557e-01f, -3.96662615e-02f, -6.55443072e-02f,
  -6.18524402e-02f, 5.98059334e-02f, -1.50856555e-01f, -4.38641198e-02f, -4.29629199e-02f, -8.23999196e-02f, 1.51518002e-01f, -1.88370287e-01f, -3.85846347e-02f, -1.17595971e-01f,
  -7.88650215e-02f, -9.24221147e-03f, 6.76782802e-03f, 5.31978346e-02f, -1.43683003e-02f, -7.14288419e-03f, 1.19490810e-01f, 1.20481513e-01f, 4.49727550e-02f, -1.29955653e-02f,
  -4.27266806e-02f, -1.03897206e-01f, -8.09012875e-02f, -5.99665754e-02f, 2.76358604e-01f, 1.10756867e-01f, 2.30594929e-02f, -2.38820794e-03f, -5.77097908e-02f, 6.67704344e-02f,
  -4.24760431e-02f, 9.52119902e-02f, 1.79781005e-01f, 4.77586798e-02f, -3.33364448e-03f, 5.74848726e-02f, -1.02731556e-01f, 1.13031141e-01f, -3.79546285e-02f, -1.06157690e-01f,
  1.01335961e-02f, 5.82075939e-02f, -3.50607932e-02f, 1.70841515e-01f, -8.31623189e-03f, -5.94966859e-02f, -2.06260309e-01f, 6.05134629e-02f, 3.77551503e-02f, 9.24151111e-03f,
  2.08230801e-02f, -5.78123741e-02f, -6.36726618e-02f, 1.89219743e-01f, -7.29050115e-02f, 2.13155095e-02f, 1.64719164e-01f, -6.39397502e-02f, 1.39762148e-01f, 9.22392309e-02f,
  -5.22891693e-02f, -7.81636164e-02f, 6.24219254e-02f, 3.59273925e-02f, -7.04953521e-02f, 2.09404156e-01f, 4.83936854e-02f, 3.33185494e-02f, 1.62242283e-03f, 1.36282519e-01f,
  -6.13356456e-02f, -8.21275264e-03f, -1.25565395e-01f, -2.45198384e-02f, 1.15172379e-01f, 5.93020441e-03f, -4.30348031e-02f, 1.70591678e-02f, 1.96958974e-01f, -1.21579699e-01f,
  -4.10186909e-02f, -1.27495795e-01f, 2.14903057e-01f, -8.26076120e-02f, -9.20202509e-02f, 1.63622752e-01f, 9.73213743e-03f, -2.68768501e-02f, 8.32766220e-02f, 4.55396138e-02f,
  -2.12265216e-02f, 7.11149499e-02f, 1.25286222e-01f, -6.85531087e-03f, 3.99640277e-02f, 1.79379042e-02f, -1.26014680e-01f, -6.98686615e-02f, 1.05787076e-01f, -8.67561847e-02f,
  1.02524750e-01f, -8.10753405e-02f, 9.47563723e-02f, 8.87603983e-02f, -9.90658998e-02f, 1.02400310e-01f, 2.30810288e-02f, -1.19967580e-01f, -1.10724933e-01f, -3.93249765e-02f,
  2.58609235e-01f, 6.97016716e-02f, -5.01365438e-02f, -1.28473178e-01f, 1.08220242e-01f, 8.10410902e-02f, 6.80232123e-02f, -2.79987808e-02f, 1.22591436e-01f, 1.11105517e-01f,
  -2.81429626e-02f, 3.48642049e-03f, -7.82462582e-02f, -7.72523805e-02f, 1.88563168e-01f, 3.76960523e-02f, -6.63346350e-02f, 2.45904289e-02f, 5.10644950e-02f, -5.93662784e-02f,
  3.51123400e-02f, 7.24601522e-02f, -2.91811563e-02f, -4.43032831e-02f, -3.03594880e-02f, 8.42185244e-02f, -8.34372342e-02f, -9.31405500e-02f, -9.54015702e-02f, 9.67993066e-02f,
  1.73644960e-01f, 2.40778685e-01f, -1.18956558e-01f, -2.86569595e-02f, -3.65005955e-02f, -2.64325980e-02f, -8.79824758e-02f, 1.73606798e-02f, 1.37264013e-01f, 1.59965060e-03f,
  5.31840185e-03f, 1.13725148e-01f, -4.30505425e-02f, -1.74323842e-02f, 1.09507404e-02f, 1.75245628e-02f, 8.12707096e-02f, -5.26502449e-03f, 3.67345400e-02f, -9.75245759e-02f,
  -1.82336465e-01f, 2.76995480e-01f, -1.17147155e-02f, -1.20713182e-01f, 8.63374248e-02f, 1.28416315e-01f, -2.26822402e-03f, 3.75191383e-02f, -9.58523154e-02f, 7.92886466e-02f,
  3.16923521e-02f, -7.94410482e-02f, -1.06557876e-01f, 8.98938701e-02f, -5.55772074e-02f, 8.13475102e-02f, 5.12841307e-02f, 2.06777547e-02f, 1.52597770e-01f, 2.50305980e-01f,
  -1.66680172e-01f, -1.27421021e-01f, 3.56854573e-02f, 2.65411735e-01f, -9.57779735e-02f, 1.06472194e-01f, 5.51347770e-02f, -5.96362092e-02f, 5.50983250e-02f, 2.04492718e-01f,
  -1.93761736e-01f, 1.26358986e-01f, -5.05826660e-02f, 5.63160069e-02f, 1.14566870e-02f, 8.15644264e-02f, -6.16335124e-02f, 1.76864211e-02f, -8.06021169e-02f, 2.28898779e-01f,
  -1.11926973e-01f, -1.59404472e-01f, -2.63584964e-02f, -2.19768882e-02f, 1.00247487e-01f, 6.02890998e-02f, 6.80493610e-03f, -1.90143630e-01f, 1.07517049e-01f, 4.23037745e-02f,
  -2.01239213e-01f, 2.10800409e-01f, 3.20038199e-02f, 1.48949221e-01f, 1.80573054e-02f, 7.22352266e-02f, 5.22003919e-02f, -1.17829561e-01f, 1.41090557e-01f, 1.52198702e-01f,
  1.54178709e-01f, 1.12359390e-01f, 7.65346959e-02f, 6.01139590e-02f, -1.87112778e-01f, -1.03545070e-01f, 1.69019233e-02f, -6.69396594e-02f, 9.80618689e-03f, -6.51629195e-02f,
  1.98360801e-01f, 1.28994048e-01f, -1.57916978e-01f, 1.82389528e-01f, 6.89695850e-02f, -2.21522935e-02f, -5.02947494e-02f, 9.24214795e-02f, 1.77698791e-01f, 7.22892210e-02f,
  1.07818052e-01f, -1.25806168e-01f, 6.30812570e-02f, 2.23616078e-01f, 3.41035500e-02f, 1.01574838e-01f, 7.67962560e-02f, 1.16853289e-01f, -1.27379515e-03f, 1.32600009e-01f,
  -7.11816102e-02f, -2.65350826e-02f, 1.00059614e-01f, 7.04010651e-02f, -1.59698367e-01f, 1.52701110e-01f, 1.40923122e-02f, 5.99357150e-02f, 5.41129857e-02f, 4.08428442e-03f,
  -1.56215101e-01f, -7.83840939e-02f, -6.90530464e-02f, 8.33771080e-02f, 1.22499935e-01f, -9.70353261e-02f, -1.25139266e-01f, -3.51843312e-02f, 2.78310925e-01f, 1.86390609e-01f,
  1.38783017e-02f, -9.40354839e-02f, 1.84482336e-01f, -1.34714628e-02f, -1.51239887e-01f, 9.57412198e-02f, 5.11768982e-02f, -4.41750586e-02f, 1.43547118e-01f, -1.74637437e-02f,
  5.42233652e-03f, 1.54002875e-01f, 1.14771828e-01f, 6.18592314e-02f, 1.18983619e-01f, 1.61229283e-01f, 1.23531826e-01f, 8.71893913e-02f, -1.98252350e-01f, -8.69932920e-02f,
  -5.73339239e-02f, -7.89380372e-02f, 1.27060309e-01f, 2.18266305e-02f, 1.83644235e-01f, 3.39740538e-03f, -1.01331487e-01f, -6.04285225e-02f, -4.53198627e-02f, -1.76061168e-01f,
  -3.76107660e-03f, 1.68650195e-01f, 2.56369889e-01f, -3.86267342e-02f, 5.98007515e-02f, -2.49650441e-02f, 1.26925871e-01f, 2.86862135e-01f, 3.02280653e-02f, 3.24266255e-02f,
  3.50952372e-02f, 5.31518422e-02f, 2.77875699e-02f, 1.51634306e-01f, -1.11961499e-01f, -2.97235958e-02f, 1.75007433e-01f, 4.51476313e-02f, -4.35475074e-02f, 3.32315788e-02f,
  1.70101598e-02f, -7.48976832e-04f, -8.20390731e-02f, 4.79223169e-02f, -5.64566292e-02f, -7.25907981e-02f, -7.52251372e-02f, 4.92103118e-03f, 1.91404492e-01f, -5.77522703e-02f,
  -8.51460695e-02f, -4.67399657e-02f, 2.56668031e-01f, -1.46308653e-02f, -5.35192639e-02f, -2.46644299e-02f, 1.12129390e-01f, 7.16853291e-02f, -1.26379192e-01f, -8.26075748e-02f,
  1.80713341e-01f, -4.83501656e-03f, 6.67314604e-02f, 9.91069898e-03f, -2.02923447e-01f, 1.34402007e-01f, 7.51594231e-02f, -3.45347216e-03f, 2.88004968e-02f, 7.78809786e-02f,
  8.28189403e-02f, 4.89093782e-03f, -1.00529134e-01f, 1.17199406e-01f, -5.20836450e-02f, -3.43454555e-02f, -1.50858518e-02f, 6.58295453e-02f, 6.31841645e-02f, 4.09942456e-02f,
  -1.73038706e-01f, 1.71141654e-01f, -5.32592647e-03f, -7.77275264e-02f, 2.14922093e-02f, 2.03120969e-02f, 1.11126229e-01f, 9.93048027e-02f, -2.01421063e-02f, -1.46305516e-01f,
  1.21988639e-01f, 2.11492762e-01f, -3.60797234e-02f, -6.49615899e-02f, 3.94405760e-02f, 1.38608024e-01f, -3.89385261e-02f, 3.95771898e-02f, -9.90911154e-04f, 4.22445424e-02f,
  7.94857219e-02f, 6.56344965e-02f, -7.64434859e-02f, 2.17276886e-01f, 7.11488724e-02f, 5.59860505e-02f, 1.00966506e-01f, -6.39086142e-02f, -1.41062006e-01f, 9.57287773e-02f,
  -2.73415428e-02f, 3.65234725e-02f, 5.14510348e-02f, -1.16089739e-01f, -1.04001433e-01f, -9.34289675e-03f, 1.92405805e-01f, 1.51102364e-01f, 3.30164991e-02f, -1.67828396e-01f,
  7.09346607e-02f, 2.47052759e-02f, -2.17264101e-01f, 2.03177273e-01f, 5.38327731e-02f, 1.35425463e-01f, 8.42804834e-03f, 4.85937111e-02f, 1.01727478e-01f, 2.09384561e-02f,
  7.42128938e-02f, 7.38556087e-02f, -3.69189270e-02f, 6.56189546e-02f, -6.54597825e-04f, -7.94327706e-02f, 1.45579517e-01f, 7.20158070e-02f, -2.91884206e-02f, 1.39934614e-01f,
  -3.46068032e-02f, 3.85125689e-02f, -8.85773823e-02f, -1.11799166e-01f, -4.74846736e-02f, -4.95847054e-02f, -1.04316451e-01f, 3.62256765e-02f, -4.55519324e-03f, 4.95134816e-02f,
  1.42886400e-01f, -2.09509775e-01f, -7.87318591e-03f, -1.23193488e-01f, -1.04849394e-02f, -8.91806632e-02f, 1.01521462e-01f, -7.94190392e-02f, 1.87779725e-01f, 1.13343738e-01f,
  4.10006680e-02f, -1.30467921e-01f, 7.58019388e-02f, 1.43245801e-01f, 2.70264030e-01f, -5.91443032e-02f, -9.99981165e-02f, 1.25098759e-02f, 1.01229846e-01f, 6.39914423e-02f,
  1.69631243e-01f, 1.24766760e-01f, 1.40894234e-01f, 1.22198962e-01f, -2.71602552e-02f, 2.03380108e-01f, -2.66434811e-02f, 1.06375881e-01f, 8.21076930e-02f, 9.39607546e-02f,
  1.68301612e-02f, 8.43951777e-02f, -4.15279046e-02f, -9.41675752e-02f, -1.24298342e-01f, -4.11592945e-02f, -7.25597423e-03f, 4.78174277e-02f, -9.46573541e-02f, 1.28370732e-01f,
  6.07257970e-02f, 1.76274180e-01f, -3.56214643e-02f, -2.00554863e-01f, -1.07987616e-02f, 1.09058172e-01f, 5.46048880e-02f, 8.09923932e-02f, -3.79625685e-03f, -1.62885785e-02f,
  -1.87038220e-02f, 7.64055178e-02f, -8.63388106e-02f, 7.21350834e-02f, -5.82459457e-02f, 1.57974869e-01f, 1.81040391e-02f, -4.64639589e-02f, -6.68252781e-02f, 9.03347582e-02f,
  -2.07387526e-02f, 6.58966303e-02f, -1.52991936e-01f, -9.35429633e-02f, -2.27708947e-02f, 3.54362205e-02f, -4.98202480e-02f, -6.97259977e-02f, 1.13306552e-01f, -8.25767815e-02f,
  -1.31247878e-01f, 1.97076142e-01f, 7.94561431e-02f, 9.50839669e-02f, 1.81970671e-01f, -8.98635685e-02f, 2.32741237e-02f, 1.46965683e-01f, 8.28858018e-02f, -7.62508288e-02f,
  -3.69367772e-03f, 1.91758424e-01f, 2.93755475e-02f, 2.20819503e-01f, 6.22894503e-02f, 1.16159074e-01f, -2.41601318e-02f, 2.12797642e-01f, -7.33884051e-02f, 1.06075883e-01f,
  -1.29754826e-01f, -8.84137824e-02f, 4.11291383e-02f, 1.15126362e-02f, 6.51494414e-02f, 1.43078476e-01f, 2.43985817e-01f, -1.39820725e-01f, -1.38104245e-01f, -6.90187663e-02f,
  7.98482075e-02f, 1.09436944e-01f, -1.17837653e-01f, 2.05352992e-01f, 7.34152645e-02f, 8.57969299e-02f, 1.33797616e-01f, -3.52274664e-02f, 5.40184267e-02f, 4.15707938e-02f,
  7.93751180e-02f, 1.39667884e-01f, -5.82558364e-02f, 4.16956097e-02f, 1.12070426e-01f, 6.90403134e-02f, -3.76300961e-02f, 9.10076201e-02f, -8.23236927e-02f, 1.09003320e-01f,
  -4.76397797e-02f, 4.22916822e-02f, -6.47435188e-02f, 5.98014332e-02f, 8.06173123e-03f, 8.10879096e-03f, -8.82822052e-02f, -3.63335162e-02f, -4.30041812e-02f, 1.35653894e-02f,
  3.01852208e-02f, -1.38135493e-01f, 4.43785004e-02f, 5.37895225e-02f, -8.13306347e-02f, 2.36283556e-01f, 5.87358996e-02f, 9.63118151e-02f, 1.23339914e-01f, -5.63754812e-02f,
  8.47359896e-02f, 5.92354089e-02f, 4.86153401e-02f, -1.21240029e-02f, -1.16710858e-02f, 1.22580864e-01f, -3.17709595e-02f, 1.49629429e-01f, 1.20477706e-01f, 1.04028136e-01f,
  -1.65570118e-02f, 1.44508272e-01f, -7.15507641e-02f, 6.68225437e-02f, -7.62077644e-02f, -8.73412043e-02f, 7.67192170e-02f, 2.28080209e-02f, 1.53383076e-01f, 1.32290989e-01f,
  2.48525679e-01f, -4.75427471e-02f, -1.20030649e-01f, -1.45330727e-01f, 1.11022331e-01f, 5.75331375e-02f, -1.39032915e-01f, 1.31527588e-01f, 5.86784929e-02f, 1.37968689e-01f,
  -3.50846611e-02f, -3.43313627e-03f, 1.45575941e-01f, 1.76105931e-01f, 6.64165616e-02f, 1.26554593e-01f, 9.35459137e-02f, 1.31002858e-01f, -1.44375786e-01f, -2.65046433e-02f,
  1.03402426e-02f, -4.14227024e-02f, 6.26738071e-02f, -3.61745469e-02f, 4.86188531e-02f, 9.38838050e-02f, 6.56966716e-02f, 8.91587958e-02f, 1.05509805e-02f, 4.59109986e-04f,
  4.14282531e-02f, 4.37332615e-02f, 2.16011740e-02f, 1.47423521e-01f, 9.54664946e-02f, -5.36377765e-02f, 1.21720128e-01f, 1.02741726e-01f, -1.02318145e-01f, 2.54489388e-02f,
  -1.86073519e-02f, 5.21478429e-02f, 1.16104754e-02f, 8.86717960e-02f, -8.36229473e-02f, -6.80724606e-02f, 1.30998502e-02f, 4.20829430e-02f, 4.41554524e-02f, 3.42177898e-02f,
  -1.16878018e-01f, 6.08630665e-03f, -1.71551004e-01f, 6.02288768e-02f, -2.07947679e-02f, -1.09785266e-01f, -1.21984303e-01f, 3.21447924e-02f, 7.91989192e-02f, 1.56413054e-03f,
  -7.02695549e-02f, 6.91703288e-03f, 1.90519288e-01f, -3.52124870e-02f, 7.68717602e-02f, -1.13418937e-01f, 7.38103315e-02f, 1.23455208e-02f, -1.43117150e-02f, -4.72634546e-02f,
  8.55341330e-02f, -6.38925135e-02f, 9.35631320e-02f, -6.91100881e-02f, 6.34516180e-02f, 1.50733277e-01f, 3.09016611e-02f, 4.81849238e-02f, -1.25186946e-02f, -1.45232882e-02f,
  1.05503805e-01f, 3.69664878e-02f, -2.08614208e-02f, 1.44194275e-01f, -9.40115936e-03f, -8.79009068e-02f, 3.54141183e-03f, 5.35211563e-02f, 5.47411814e-02f, 9.56875607e-02f,
  -6.63786307e-02f, -3.70626301e-02f, -1.23195564e-02f, 9.02339965e-02f, -4.85308804e-02f, 7.27308393e-02f, -4.09197714e-03f, 4.06979136e-02f, 4.29142043e-02f, 1.18189506e-01f,
  9.88945067e-02f, 1.31161371e-03f, -7.51683563e-02f, -9.03048441e-02f, 9.56991315e-02f, 5.07920906e-02f, -1.11753248e-01f, 1.37892231e-01f, 3.65501456e-02f, 4.05928083e-02f,
  7.75237381e-02f, 8.33465979e-02f, -2.72113159e-02f, -1.31683096e-01f, -1.12535842e-01f, 3.02435737e-02f, -6.34677783e-02f, 9.24772173e-02f, 5.63461408e-02f, 4.37263846e-02f,
  -4.91634458e-02f, 1.34857953e-01f, -4.73249033e-02f, 1.15727283e-01f, -4.41102125e-02f, 6.03017025e-02f, -1.13373801e-01f, 6.11871667e-03f, -3.82994935e-02f, -1.34379834e-01f,
  7.04150125e-02f, 1.32035673e-01f, -1.00964263e-01f, 2.35375464e-02f, 4.43575010e-02f, 7.68723860e-02f, -1.61300711e-02f, 4.30079401e-02f, 7.32718855e-02f, -2.89577879e-02f,
  1.30494451e-02f, 1.19498096e-01f, 6.66068196e-02f, 1.04631402e-01f, -5.57142757e-02f, -1.31901093e-02f, 2.08793834e-01f, 1.58988144e-02f, -9.87028033e-02f, 1.00540526e-01f,
  -9.15858150e-02f, 3.58013175e-02f, -9.27725527e-03f, -1.11607812e-01f, -7.20832795e-02f, -8.55429694e-02f, -1.45621225e-01f, 5.77126071e-02f, 1.20960653e-01f, 1.14276886e-01f,
  1.03787787e-01f, -1.37117997e-01f, 3.73485079e-03f, -8.15366432e-02f, -5.02643697e-02f, -1.19268037e-01f, -2.79283221e-03f, -2.63619877e-04f, 6.59374446e-02f, 3.34333256e-02f,
  3.72328982e-02f, -5.78129254e-02f, 1.38863713e-01f, 1.68968543e-01f, 1.51761949e-01f, -8.92434716e-02f, 7.59619325e-02f, -1.09512217e-01f, 3.19305733e-02f, 4.77251187e-02f,
  2.26127300e-02f, 2.12215297e-02f, 1.16086349e-01f, 9.02489349e-02f, -2.11402425e-03f, 2.10243896e-01f, -1.91070244e-03f, 1.30254224e-01f, 5.89572117e-02f, 1.56855106e-01f,
  -1.14952192e-01f, 6.91339672e-02f, 1.32909253e-01f, 1.78284980e-02f, -1.42419443e-01f, -6.20100014e-02f, 1.10338204e-01f, -5.13056181e-02f, -6.83562458e-02f, 1.36481687e-01f,
  2.20226999e-02f, 2.00716570e-01f, 9.11393855e-03f, -9.64590982e-02f, 8.75507519e-02f, -2.57512145e-02f, 1.07430041e-01f, 9.20980200e-02f, 1.34913567e-02f, 1.56982020e-01f,
  1.54947639e-01f, 3.49872038e-02f, -3.58462743e-02f, 1.33330017e-01f, -1.44970104e-01f, 9.22902599e-02f, -4.27023098e-02f, -1.26344245e-02f, 1.19711757e-02f, -7.03151003e-02f,
  -6.55805022e-02f, 9.17231366e-02f, -2.71465518e-02f, 6.63866848e-02f, -1.06702708e-01f, -9.94339306e-03f, -1.55145060e-02f, -1.13716908e-02f, 6.28504483e-03f, -2.48650536e-01f,
  -8.13153386e-02f, 8.42390954e-02f, -3.77587974e-02f, 2.69995425e-02f, 1.29879281e-01f, -1.22150294e-01f, 3.41779776e-02f, 1.48511112e-01f, -4.69420105e-02f, -1.55185670e-01f,
  7.06411898e-02f, -1.37730017e-01f, -6.99081123e-02f, 1.62691444e-01f, 5.84576689e-02f, 1.84905156e-01f, 1.30659835e-02f, 1.02975227e-01f, -9.84111875e-02f, 1.34564638e-01f,
  -3.88100147e-02f, 1.34869009e-01f, 1.05525188e-01f, -1.05939331e-02f, -8.01747963e-02f, -7.24331960e-02f, 1.98500186e-01f, -1.37222096e-01f, -1.29385933e-01f, -7.91263357e-02f,
  2.17166990e-01f, -4.68716472e-02f, -8.69521648e-02f, 9.94617958e-03f, 8.65576714e-02f, -5.28180823e-02f, -1.84132177e-02f, -5.16555412e-03f, 6.63782060e-02f, 6.47957548e-02f,
  6.06775954e-02f, 2.31859228e-03f, -3.10304705e-02f, 1.84829891e-01f, 2.42717385e-01f, -2.82871450e-04f, 2.53254380e-02f, 1.39024496e-01f, -7.15530068e-02f, 6.73341751e-02f,
  1.86782554e-02f, -4.44029681e-02f, 1.07907735e-01f, 8.63893703e-03f, -3.60288285e-02f, 1.66718632e-01f, 1.14916086e-01f, -2.88927229e-03f, -3.87224816e-02f, -5.84312491e-02f,
  2.87519712e-02f, 3.23712081e-02f, 4.23929207e-02f, -1.12179972e-01f, 5.70220500e-02f, 8.35965294e-03f, -8.91363434e-03f, -3.61270197e-02f, 2.76125949e-02f, 1.52664566e-02f,
  1.34562328e-01f, 1.31577253e-01f, 5.18560894e-02f, -3.68377306e-02f, 5.29926158e-02f, 1.34790381e-02f, 3.93475639e-03f, -3.31617752e-03f, 2.53780950e-02f, 7.86326081e-02f,
  8.38861912e-02f, 3.33709903e-02f, -4.22942126e-03f, 9.11585540e-02f, -2.03786250e-02f, 2.14907169e-01f, 1.48249865e-01f, 2.23906413e-02f, -6.56638294e-02f, -7.16507360e-02f,
  -1.27634192e-02f, -1.23440875e-02f, -9.92339477e-02f, -2.91605182e-02f, 1.86404496e-01f, -6.20029308e-02f, -1.43273562e-01f, 1.14840031e-01f, 5.08723147e-02f, 6.30225465e-02f,
  1.01526111e-01f, -9.71745253e-02f, -1.49899581e-02f, -3.23548056e-02f, -2.74460670e-02f, 1.32999616e-02f, -6.00318890e-03f, -7.00614303e-02f, 7.82135352e-02f, 5.44979535e-02f,
  -8.59119669e-02f, 8.18040743e-02f, 4.23014238e-02f, 9.30191949e-02f, -5.15618138e-02f, -6.80359975e-02f, -5.24569638e-02f, -1.26161883e-02f, -5.96204363e-02f, -6.28248379e-02f,
  -1.31488562e-01f, -3.33937816e-02f, 4.41568345e-02f, -9.86241698e-02f, -6.23107068e-02f, -7.41279870e-02f, 2.91320570e-02f, 9.86616686e-02f, 4.19689715e-02f, 2.61666486e-03f,
  1.41142949e-01f, 1.63509905e-01f, 7.18403608e-02f, -2.89349277e-02f, 5.81057332e-02f, 1.34358123e-01f, 1.05471894e-01f, 5.09702251e-04f, -1.07732929e-01f, 2.38127708e-01f,
  1.65665135e-01f, 2.20555905e-02f, 2.17308879e-01f, 3.40762432e-03f, -6.39119223e-02f, 1.88172415e-01f, -2.69901869e-03f, 2.47321390e-02f, -3.58665846e-02f, -1.22936286e-01f,
  7.23461434e-02f, 4.07434348e-03f, 7.34318048e-02f, 1.81121692e-01f, 2.47671381e-02f, 1.15923788e-02f, -6.56089708e-02f, -6.76386878e-02f, 4.34583947e-02f, 2.20857978e-01f,
  -9.25517920e-03f, 8.17395970e-02f, -2.23011971e-02f, 1.69779599e-01f, 1.77430455e-02f, -1.57801569e-01f, -4.11764160e-02f, 3.97732295e-02f, -5.91078885e-02f, 3.98796005e-03f,
  4.58715931e-02f, -6.86950162e-02f, -9.71897021e-02f, -1.62170470e-01f, -2.61471104e-02f, -8.42496604e-02f, 1.59029327e-02f, -1.47181362e-01f, 6.90846816e-02f, 1.12911247e-01f,
  -4.67472002e-02f, 3.03261578e-01f, 2.47520711e-02f, -5.95283806e-02f, -7.01381639e-03f, -1.50623515e-01f, 1.00691929e-01f, 1.64890245e-01f, -6.95326701e-02f, -1.27722710e-01f,
  2.33736653e-02f, 1.18787855e-01f, 8.82056355e-02f, 1.06174193e-01f, -2.09120959e-02f, 5.65288626e-02f, 1.63669646e-01f, -4.80498886e-04f, 5.80186583e-02f, 6.49832338e-02f,
  -8.89293551e-02f, -7.94542879e-02f, -7.84280822e-02f, 2.14185670e-01f, 7.98251256e-02f, 7.93714076e-02f, 1.00078195e-01f, -9.35178399e-02f, -9.18923616e-02f, 1.29983127e-01f,
  -7.40731061e-02f, -1.04585908e-01f, 1.10743148e-02f, -5.75891733e-02f, -7.21113831e-02f, 8.14841911e-02f, 9.21392441e-02f, 1.75139546e-01f, 5.36550805e-02f, 8.13976675e-02f,
  1.04801714e-01f, -1.06820107e-01f, -2.09414735e-01f, 9.29626748e-02f, 5.37975058e-02f, 7.83107579e-02f, 4.59815823e-02f, -1.61402538e-01f, 8.48243684e-02f, 1.06140099e-01f,
  1.52569413e-01f, 1.24953546e-01f, 1.24943502e-01f, 4.76240925e-02f, 5.30227534e-02f, 1.73796847e-01f, 1.81346849e-01f, -9.57562625e-02f, -6.44244999e-02f, 8.76438245e-02f,
  -6.86430559e-02f, -7.69407749e-02f, -3.76978293e-02f, -1.03849418e-01f, 1.72879815e-01f, -1.71146005e-01f, -2.89649051e-02f, 1.86355934e-01f, 2.34092191e-01f, 1.64234996e-01f,
  2.91177724e-02f, -1.44706905e-01f, 1.23984165e-01f, 2.20882609e-01f, -1.35892704e-01f, -1.76312491e-01f, 1.52036190e-01f, -6.51971772e-02f, 9.27696377e-02f, -2.01592579e-01f,
  -4.56194989e-02f, -6.37526885e-02f, 1.15217932e-01f, 1.53881520e-01f, 8.65719914e-02f, 6.21093735e-02f, 1.76736906e-01f, -2.15034172e-01f, -1.16782300e-02f, 6.66784868e-02f,
  1.00442767e-01f, 1.47949308e-02f, 1.84482515e-01f, 6.93116784e-02f, 1.85020685e-01f, 5.79292588e-02f, 1.58443153e-01f, 2.36638874e-01f, 1.30996272e-01f, 2.53627419e-01f,
  -2.37057090e-01f, -1.29801959e-01f, -1.01458028e-01f, 1.06321424e-01f, 1.07418641e-03f, 3.41998152e-02f, 2.72198822e-02f, -8.85263979e-02f, -1.90785415e-02f, 6.06332757e-02f,
  -5.22844307e-02f, 1.64656132e-01f, 3.41489315e-02f, 6.60775304e-02f, 1.19060360e-01f, 1.49523482e-01f, 1.03952579e-01f, -2.55529620e-02f, 1.31638065e-01f, 2.05383897e-01f,
  -4.76045124e-02f, 7.63023049e-02f, 2.93286163e-02f, 2.07922738e-02f, -8.23690593e-02f, -2.23296434e-02f, 1.64617114e-02f, -3.29315774e-02f, 1.81998432e-01f, -1.57759696e-01f,
  8.04242194e-02f, 9.10914317e-02f, 6.43763319e-02f, 7.75485933e-02f, -4.53014672e-02f, -2.27735322e-02f, 1.87517241e-01f, 1.97973669e-01f, 8.86841491e-03f, 7.01489672e-02f,
  3.87404002e-02f, 2.70023812e-02f, -3.47809680e-02f, -1.22990616e-01f, 3.99549957e-03f, 1.35274574e-01f, 6.27607107e-02f, 4.22312208e-02f, -9.87381041e-02f, 7.01721162e-02f,
  1.64799005e-01f, -8.72462168e-02f, -9.69113261e-02f, -5.87185659e-02f, -6.02551028e-02f, 6.66857585e-02f, 1.94196865e-01f, -8.92951712e-02f, -1.91176068e-02f, 2.64582299e-02f,
  1.90374732e-01f, 1.98200822e-01f, 9.77797285e-02f, -2.03596298e-02f, -7.26573393e-02f, -2.35996902e-01f, 2.50722896e-02f, 7.87177086e-02f, 1.47156358e-01f, 8.92621204e-02f,
  1.86556727e-01f, -2.00795367e-01f, 6.48901798e-04f, -5.58358058e-02f, 1.19534768e-01f, -5.17334305e-02f, -5.55060292e-03f, 1.67078093e-01f, 2.46912315e-02f, 1.15992561e-01f,
  -3.69156338e-02f, 9.91073847e-02f, -9.22330320e-02f, 3.93519085e-03f, 2.07300723e-01f, 3.10184378e-02f, -1.78492609e-02f, 7.22761080e-02f, -9.68788490e-02f, 1.15743540e-02f,
  -2.43084803e-02f, -2.79991701e-02f, -2.05950923e-02f, 7.95594901e-02f, -1.12072527e-01f, 5.90837896e-02f, 8.52435082e-03f, 8.57940316e-02f, 1.09730504e-01f, -9.09502208e-02f,
  -2.54589003e-02f, -1.86855756e-02f, -2.08587181e-02f, -2.08751112e-01f, 1.18299909e-01f, 1.04118429e-01f, 1.12389125e-01f, -3.99421109e-03f, -2.62756012e-02f, -8.22464004e-02f,
  1.65205196e-01f, 1.45245880e-01f, 9.83319059e-02f, -1.18325442e-01f, -3.22937332e-02f, -8.93368572e-02f, 6.38639629e-02f, 1.33575186e-01f, 1.45789742e-01f, 2.37945952e-02f,
  1.28454462e-01f, 1.01115130e-01f, -1.87990032e-02f, 1.00342654e-01f, -5.54475226e-02f, 1.16388485e-01f, 1.32625312e-01f, 1.23236887e-01f, -7.37210885e-02f, 5.61977476e-02f,
  1.27349883e-01f, 5.39635727e-03f, -2.19690070e-01f, -1.98589601e-02f, 5.35688698e-02f, 5.22855781e-02f, -9.60290208e-02f, 6.54937103e-02f, 1.19054578e-02f, 1.94128051e-01f,
  -4.03304286e-02f, 8.96912348e-03f, 3.44844051e-02f, -1.86303798e-02f, 8.86442736e-02f, -2.94877756e-02f, -5.80220073e-02f, 4.98953201e-02f, -2.12975129e-01f, 2.74261206e-01f,
  2.75332090e-02f, -8.96246508e-02f, 8.95284936e-02f, 2.46847406e-01f, 2.02400684e-02f, 9.69023108e-02f, -1.76040852e-03f, 8.27157050e-02f, -3.20504978e-02f, 1.26735970e-01f,
  -9.37098637e-02f, 1.58485010e-01f, -1.01788685e-01f, 8.13301802e-02f, 3.06809898e-02f, 1.01122193e-01f, 2.94542551e-01f, 1.86349750e-01f, -1.65202722e-01f, 2.06640083e-02f,
  -1.44146429e-03f, 1.32306784e-01f, -1.57979548e-01f, 2.14617595e-01f, -4.28165905e-02f, -9.36696231e-02f, 6.93339929e-02f, 1.44568339e-01f, -5.93755916e-02f, -9.70283225e-02f,
  -1.11230575e-01f, -1.33267015e-01f, -2.78365612e-02f, 1.05298646e-01f, 4.93710451e-02f, -6.10883608e-02f, -1.31461978e-01f, 4.46232297e-02f, -2.03078002e-01f, -1.92325581e-02f,
  1.22199077e-02f, -6.20924756e-02f, 2.08588481e-01f, 8.02517161e-02f, -1.17787674e-01f, -2.34273463e-01f, 2.06645980e-01f, 8.29111263e-02f, 3.23005132e-02f, -6.01483174e-02f,
  3.78550850e-02f, 8.81182179e-02f, 9.39300805e-02f, 1.06808931e-01f, 3.38470899e-02f, -1.10282563e-01f, 9.01815593e-02f, 1.08697318e-01f, -3.60910222e-03f, -3.92982922e-02f,
  -5.48036247e-02f, 9.97553170e-02f, 1.62466541e-01f, 1.23315699e-01f, -6.44280538e-02f, 3.48761044e-02f, -2.08827332e-02f, 1.20589331e-01f, 8.90359189e-03f, -3.74007679e-04f,
  -4.79629338e-02f, -1.22167550e-01f, -7.20709264e-02f, 5.25154583e-02f, 4.19600913e-03f, 8.89460668e-02f, -1.36703566e-01f, -7.68091977e-02f, 1.23011142e-01f, -2.05610301e-02f,
  4.64217737e-02f, -9.16004479e-02f, -5.97073250e-02f, 2.90595144e-02f, 7.85327181e-02f, -2.66643893e-03f, -2.19217315e-02f, 3.84244360e-02f, -2.79483404e-02f, -6.81654690e-03f,
  1.73051238e-01f, -5.25173917e-02f, -5.59034664e-03f, -4.65943143e-02f, -4.30236086e-02f, -8.34297948e-03f, -1.23365536e-01f, 2.07086623e-01f, 1.00865744e-01f, -1.45290876e-02f,
  -3.56920660e-02f, 1.80909216e-01f, 4.00904566e-03f, 9.52707827e-02f, 9.04492587e-02f, 3.15330587e-02f, -7.37963915e-02f, 4.01278399e-03f, 1.18654661e-01f, -4.49359044e-02f,
  -3.36641334e-02f, 4.52555493e-02f, 1.61620736e-01f, -1.12235978e-01f, -4.48559746e-02f, 1.27322495e-01f, 1.35992184e-01f, 3.36772203e-02f, -2.49422360e-02f, -9.98921841e-02f,
  1.32555456e-03f, 1.80070810e-02f, 4.26507220e-02f, 1.18721649e-01f, 7.24733844e-02f, 2.50215661e-02f, -2.86032353e-02f, 2.63392255e-02f, 7.66294450e-03f, 3.05672903e-02f,
  -1.28122017e-01f, -1.45860342e-03f, -8.46581534e-02f, -1.08607382e-01f, 1.54368177e-01f, 7.04610795e-02f, 1.78402200e-01f, 1.28919020e-01f, -9.22459736e-03f, -9.33502167e-02f,
  -1.69754088e-01f, 2.21681312e-01f, -5.56586646e-02f, 4.35437970e-02f, 1.19127765e-01f, -7.12301210e-02f, -8.69812444e-02f, 1.91059455e-01f, -6.19391678e-03f, -5.17644882e-02f,
  1.97732896e-01f, -2.61910912e-02f, 4.94975746e-02f, -2.39137355e-02f, -1.48967355e-01f, 8.10168535e-02f, 1.63235933e-01f, 5.96647374e-02f, 1.18390791e-01f, 1.88205689e-01f,
  -4.44140378e-03f, 2.87543721e-02f, -8.41403157e-02f, 1.03117771e-01f, 4.38757092e-02f, -1.82086349e-01f, -7.75575340e-02f, -8.16149265e-02f, 6.32707775e-02f, -9.87682641e-02f,
  1.60585959e-02f, -6.85730800e-02f, 2.04247907e-01f, 3.14247161e-02f, -2.86247190e-02f, -6.47673383e-02f, 2.43110284e-01f, -8.50033611e-02f, -1.88581750e-01f, 2.92368308e-02f,
  -4.04601023e-02f, -7.02675506e-02f, 2.19097689e-01f, 1.36620507e-01f, 1.03327051e-01f, 4.59307693e-02f, 7.03303441e-02f, 1.34363309e-01f, 6.47475943e-02f, 1.82850286e-01f,
  1.45742387e-01f, 5.41031919e-02f, -1.08618803e-01f, 1.21576793e-01f, -5.64210899e-02f, 1.06705308e-01f, 1.14925347e-01f, -9.19812620e-02f, -1.22487217e-01f, -2.23886684e-01f,
  -1.58432037e-01f, -4.14089300e-02f, -5.40105216e-02f, 1.60735890e-01f, 1.07690729e-01f, -1.82897881e-01f, 1.91696510e-01f, -1.85295381e-02f, 3.78992930e-02f, 8.57254341e-02f,
  2.79588178e-02f, -9.03291439e-05f, 8.09076130e-02f, 1.27641067e-01f, -1.39319077e-01f, -2.76044663e-02f, 6.70192540e-02f, 7.65890181e-02f, 2.93693960e-01f, -1.40440948e-02f,
  -5.01439348e-03f, -1.07546717e-01f, 1.32281873e-02f, -3.95733491e-02f, 7.68698081e-02f, 1.09111816e-01f, 1.35450572e-01f, -6.17647022e-02f, -1.22231856e-01f, 2.08882302e-01f,
  6.37113641e-04f, 6.99747056e-02f, 8.50747600e-02f, 1.12754159e-01f, 1.18244752e-01f, 5.62144630e-02f, -1.31542860e-02f, -7.01856464e-02f, -8.33735168e-02f, 1.33079067e-01f,
  7.48203695e-02f, -1.05707385e-01f, 5.53722959e-03f, 4.47803810e-02f, 5.49317189e-02f, 1.65382445e-01f, -2.24339575e-01f, -1.21490970e-01f, -1.41896093e-02f, -6.17618226e-02f,
  9.72364098e-02f, 1.10816807e-01f, -8.49915072e-02f, 4.61244807e-02f, 1.23049855e-01f, -6.23308762e-04f, -5.86718321e-02f, 1.37744874e-01f, -1.19596422e-01f, 1.41626224e-01f,
  -1.09134100e-01f, 4.13148627e-02f, -1.08812757e-01f, -2.63152886e-02f, -1.92831337e-01f, 1.21705905e-01f, -1.95750222e-01f, 3.27807069e-02f, -1.79012686e-01f, -1.15872577e-01f,
  -2.57266369e-02f, -6.46212921e-02f, 7.34628588e-02f, -2.12931708e-01f, -8.00064057e-02f, -4.13518250e-02f, 1.19874850e-01f, 7.56981075e-02f, -9.97266769e-02f, -7.18642622e-02f,
  3.62340314e-03f, 4.82122116e-02f, 1.28837168e-01f, -3.75510938e-03f, 3.03681120e-02f, -5.45742661e-02f, -1.92393199e-01f, -2.28879675e-02f, -9.36256573e-02f, 2.59404242e-01f,
  6.96803033e-02f, 1.13755517e-01f, -2.51198262e-02f, 2.90662587e-01f, -9.93532017e-02f, 3.72253582e-02f, 9.46267322e-02f, 1.39082208e-01f, -8.14289972e-02f, 1.24038868e-01f,
  3.01356409e-02f, -4.05286066e-02f, -1.79481164e-01f, -1.44994045e-02f, 1.67067245e-01f, -7.29547292e-02f, -2.07876146e-01f, 1.38112709e-01f, -2.42548175e-02f, 8.52727816e-02f,
  -3.72316763e-02f, -8.18172246e-02f, 2.77516153e-02f, -2.63566133e-02f, 3.56330462e-02f, -1.98587831e-02f, 2.10218765e-02f, -7.90110230e-03f, -7.93932122e-04f, 1.28379747e-01f,
  6.86712936e-02f, -9.99291167e-02f, -8.46150890e-03f, -2.36053187e-02f, 4.21639495e-02f, 1.26588970e-01f, 1.10827103e-01f, -1.56368259e-02f, -1.50409155e-02f, 1.07164413e-01f,
  1.27378881e-01f, 5.96018992e-02f, -1.53369615e-02f, 3.69411930e-02f, 2.13834401e-02f, 1.56173855e-01f, 7.03993253e-03f, -1.09907977e-01f, 7.66187441e-03f, -9.50807258e-02f,
  5.54943876e-03f, -9.15974081e-02f, -9.93343368e-02f, 5.20708635e-02f, 1.33324385e-01f, -9.74263251e-03f, -1.84963681e-02f, 1.67606950e-01f, 5.60174026e-02f, -1.12758473e-01f,
  -5.20525407e-03f, -1.01508029e-01f, -5.39554581e-02f, 6.46734536e-02f, 1.19825736e-01f, -2.71527208e-02f, 1.01566277e-01f, 7.35440254e-02f, -5.09511773e-03f, 1.71612933e-01f,
  3.73000577e-02f, 2.93554086e-02f, -8.34715739e-02f, -1.18571622e-02f, -1.48378044e-01f, 6.57613799e-02f, 1.24155641e-01f, 9.66003165e-02f, 1.29226642e-02f, 1.36830807e-01f,
  9.69040394e-02f, 4.58541177e-02f, 2.81756334e-02f, -4.60599139e-02f, 1.28142983e-01f, -6.78759590e-02f, 7.33452216e-02f, 4.84955646e-02f, 2.78576706e-02f, -2.24561393e-02f,
  6.18426129e-03f, 6.50651902e-02f, 3.34720388e-02f, 6.22779950e-02f, 6.85812533e-03f, 8.92567486e-02f, -1.77387486e-03f, 8.56015980e-02f, 1.71512160e-02f, 5.64310253e-02f,
  -7.92793408e-02f, 8.57021660e-02f, -5.37570454e-02f, 8.39574113e-02f, -1.02288656e-01f, 8.49974807e-03f, -1.26801342e-01f, 7.24484846e-02f, 1.31900227e-02f, -3.41731794e-02f,
  6.29690513e-02f, -2.41459217e-02f, -9.29091573e-02f, 1.08669102e-01f, 8.45650733e-02f, 7.79263861e-03f, -1.83767378e-02f, -2.73728129e-02f, -3.25084664e-02f, 3.41119505e-02f,
  1.16894953e-01f, -2.40915501e-03f, 1.03096031e-01f, -4.19847965e-02f, -1.08561054e-01f, 7.69748259e-03f, 2.86266543e-02f, 1.32200092e-01f, 1.42085224e-01f, 8.10900852e-02f,
  -7.85743892e-02f, 2.34936908e-01f, -1.57696411e-01f, 6.04954064e-02f, 1.25565687e-02f, -4.97504994e-02f, -1.97426025e-02f, 3.65239047e-02f, 4.07539532e-02f, -2.80229207e-02f,
  9.60042421e-03f, 7.23093748e-02f, 5.61766811e-02f, 1.95753500e-02f, -8.88039619e-02f, 1.39001280e-01f, 8.58966112e-02f, 1.32091297e-02f, 6.36792928e-02f, -1.42643929e-01f,
  5.26971705e-02f, 1.81272879e-01f, 6.62467554e-02f, 1.76708139e-02f, 2.06862450e-01f, 8.90346989e-02f, -1.45237803e-01f, 1.69027537e-01f, -3.55046615e-02f, -7.51246810e-02f,
  1.10423878e-01f, 5.28500788e-02f, 1.35161340e-01f, -1.56715475e-02f, -8.41948688e-02f, -2.03297079e-01f, -5.68925962e-02f, 2.74699032e-02f, 2.35447027e-02f, 2.25587994e-01f,
  4.62666666e-03f, -5.03879897e-02f, 1.76045313e-01f, 1.75619215e-01f, 1.08543396e-01f, 1.37832254e-01f, -1.35209844e-01f, -5.51658832e-02f, -6.96763918e-02f, 1.18723184e-01f,
  -1.76105455e-01f, 2.00018689e-01f, 6.60915114e-03f, 6.73780264e-03f, 2.18995810e-02f, 6.90292642e-02f, -4.51242886e-02f, -8.10651705e-02f, -6.93997666e-02f, -9.80181545e-02f,
  -1.63920298e-01f, 1.63594723e-01f, 2.28696421e-01f, -8.95806327e-02f, -1.45488828e-01f, 1.64663061e-01f, 1.81538239e-01f, 1.60228059e-01f, 3.39081814e-03f, 7.31498674e-02f,
  2.42419839e-02f, -1.71491474e-01f, -9.81136411e-02f, -1.00475229e-01f, 2.16612160e-01f, 2.12288305e-01f, -7.42788240e-02f, -9.60678235e-02f, 8.74370262e-02f, -1.81470010e-02f,
  1.41834408e-01f, -5.82538508e-02f, -2.95802765e-02f, 2.50341613e-02f, -6.80301746e-04f, -3.80867235e-02f, -2.96784751e-02f, 8.83421004e-02f, 1.27690256e-01f, 9.22357962e-02f,
  -7.96426013e-02f, -1.82526067e-01f, -2.82685161e-02f, -3.78721319e-02f, -6.15476482e-02f, -2.85186678e-01f, 8.95328820e-02f, -2.48433333e-02f, 1.77996323e-01f, 1.53830424e-01f,
  1.70969889e-01f, -3.28686573e-02f, 2.35477522e-01f, -1.26751244e-01f, 1.98705256e-01f, 7.32997209e-02f, -3.07850307e-03f, 2.15369835e-02f, -1.90840825e-01f, 5.90460971e-02f,
  9.05579701e-02f, -6.14230745e-02f, 3.62570584e-02f, -7.55597949e-02f, 1.17974430e-01f, -3.19721061e-04f, 3.33676822e-02f, -1.02584355e-01f, -9.01244953e-02f, -2.55913399e-02f,
  7.48030096e-02f, 9.10327956e-02f, 1.01175830e-01f, -2.67871097e-03f, -1.59618480e-03f, -2.24636614e-01f, -1.00761309e-01f, -6.59911036e-02f, 7.64059350e-02f, -2.33937010e-01f,
  1.62653372e-01f, 5.34857251e-02f, 4.77023859e-04f, 1.23403288e-01f, -1.05810583e-01f, -1.34048809e-03f, 5.77379279e-02f, 1.57312319e-01f, 6.23916723e-02f, 5.12661114e-02f,
  1.15655169e-01f, -7.79583901e-02f, 7.26625025e-02f, -1.05997980e-01f, -2.91267186e-02f, -1.13663994e-01f, 1.13214388e-01f, 1.60052747e-01f, 1.23394601e-01f, 3.17269862e-02f,
  3.92199382e-02f, 5.22304215e-02f, 4.87171523e-02f, -1.77462157e-02f, -4.00470849e-03f, -1.69379741e-01f, -3.85863706e-02f, 2.11607069e-02f, 1.34686992e-01f, 1.02570248e-05f,
  8.69154930e-02f, -2.07387898e-02f, -1.06244721e-01f, 2.66581774e-03f, -6.21095374e-02f, -1.46084756e-01f, 5.79856150e-02f, 2.77428720e-02f, 2.30026066e-01f, -1.37296751e-01f,
  -2.48516654e-03f, -1.93353891e-02f, 1.54735753e-02f, 8.44471231e-02f, 1.60961032e-01f, -1.24255516e-01f, 2.07873166e-01f, 1.71949044e-01f, -7.44393617e-02f, 2.99997143e-02f,
  8.96539092e-02f, -1.06453430e-02f, 2.38162950e-01f, 5.10077849e-02f, -5.69468252e-02f, 5.61381243e-02f, 6.24891110e-02f, 3.21435370e-02f, 1.78844612e-02f, -4.15360890e-02f,
  5.46699055e-02f, -1.92515161e-02f, 4.08723354e-02f, 1.96230441e-01f, 1.79684848e-01f, 8.90929103e-02f, -8.82119685e-02f, 9.85126793e-02f, 3.28506753e-02f, 6.14944212e-02f,
  -1.14123635e-01f, 1.49667516e-01f, 5.72824059e-03f, 7.74274990e-02f, -1.11016355e-01f, 1.92057222e-01f, 1.40088484e-01f, 5.43018915e-02f, 2.66705602e-02f, 1.56342819e-01f,
  -9.21786502e-02f, -4.65682633e-02f, 3.81585211e-02f, 2.30154768e-02f, 7.67093897e-02f, -9.91769880e-03f, 6.41683117e-02f, 1.12316124e-01f, 9.23866183e-02f, -9.13968310e-03f,
  -4.52478975e-02f, 4.45419177e-02f, 3.33520904e-04f, 3.59894894e-02f, -5.06719854e-03f, -6.63833246e-02f, -2.07560677e-02f, -2.18345389e-01f, -1.35934085e-01f, 3.08976341e-02f,
  8.09995309e-02f, 1.94258258e-01f, 8.33374262e-02f, -1.36701137e-01f, 1.39535621e-01f, 6.42765090e-02f, -5.41724972e-02f, 3.91897187e-02f, 2.55823191e-02f, -7.63260853e-03f,
  5.33706695e-02f, -4.73210216e-02f, -1.60902925e-02f, 5.77272363e-02f, 1.50560681e-02f, 3.35421935e-02f, 2.66064741e-02f, -1.49135403e-02f, 5.55594126e-03f, -1.09209523e-01f,
  -3.95264216e-02f, -2.77001504e-02f, -5.86196072e-02f, 9.56323668e-02f, 6.29416928e-02f, -2.19949223e-02f, -8.26694071e-02f, 2.58947886e-03f, 1.24655820e-01f, 1.99946657e-01f,
  3.41165178e-02f, 5.93823008e-02f, 9.73978359e-03f, -1.45676702e-01f, -4.07279953e-02f, -8.11052695e-02f, 8.72488916e-02f, 1.19378828e-01f, 2.90963911e-02f, -1.60193965e-01f,
  8.25968459e-02f, -3.31629887e-02f, 7.42495805e-02f, 4.13305499e-02f, -1.30957574e-01f, 1.12719499e-02f, 5.58625534e-02f, 2.11217664e-02f, 2.67680287e-02f, -1.71375591e-02f,
  1.16138309e-01f, 1.01914741e-01f, -1.92357004e-02f, 1.58088267e-01f, -3.93480882e-02f, -2.82940902e-02f, -2.88288314e-02f, 1.26991138e-01f, -1.81466676e-02f, -7.32649397e-03f,
  8.39854255e-02f, -3.88294831e-02f, 1.36813978e-02f, 7.23646730e-02f, 9.66350734e-02f, 1.83061033e-01f, 2.24061478e-02f, 6.63343146e-02f, 4.59192768e-02f, 1.90516904e-01f,
  8.10974538e-02f, 1.09470554e-01f, -1.22025505e-01f, 1.99256688e-02f, -8.16740617e-02f, -2.14670952e-02f, -1.67341772e-02f, 1.28869250e-01f, 6.08844534e-02f, 8.76451563e-03f,
  -5.69425859e-02f, 1.11285120e-01f, 4.66098711e-02f, -6.27602264e-02f, -4.83349934e-02f, 2.44501774e-04f, -1.21587917e-01f, 1.25732765e-01f, 2.72004660e-02f, -4.91268039e-02f,
  4.79368567e-02f, 3.06522101e-02f, 1.45308703e-01f, 1.06727727e-01f, 8.10304359e-02f, -2.72277240e-02f, -1.70588922e-02f, -1.02478102e-01f, 5.35066659e-03f, -1.94717402e-04f,
  2.05022722e-01f, 1.90731093e-01f, 1.36117399e-01f, -1.95829451e-01f, 7.82545581e-02f, 2.77682301e-02f, -1.51169831e-02f, -4.92717065e-02f, 1.70554370e-02f, 1.14135459e-01f,
  2.76958328e-02f, 1.28910914e-01f, -1.45678222e-03f, -6.03443496e-02f, 3.57163325e-02f, 1.10936105e-01f, -8.38635787e-02f, 1.71985999e-01f, 5.41132083e-03f, -8.25643241e-02f,
  -4.62784292e-03f, 3.41948979e-02f, -5.48744462e-02f, 3.73916924e-02f, 2.60675196e-02f, -7.72670358e-02f, -1.69931445e-02f, 1.34852976e-01f, 1.01015359e-01f, 1.08831838e-01f,
  -4.87709902e-02f, 1.07922658e-01f, 1.50441647e-01f, 2.03440040e-01f, 1.94632277e-01f, -1.43693453e-02f, -1.69790208e-01f, -4.79760878e-02f, 1.79969016e-02f, 1.74488558e-03f,
  -1.49754286e-01f, 1.47136733e-01f, 8.83393139e-02f, 3.59894820e-02f, 4.87501360e-02f, 2.16837198e-01f, 1.99715011e-02f, -2.12090984e-01f, -8.66033062e-02f, -3.59380506e-02f,
  -2.50502545e-02f, 1.41504616e-01f, 1.97115675e-01f, 3.27741727e-02f, 9.89438966e-02f, 7.33157173e-02f, 6.32130653e-02f, 1.70493305e-01f, 1.88394710e-02f, 9.94547904e-02f,
  -7.54260123e-02f, -1.21536925e-02f, -1.35750428e-01f, -6.90064356e-02f, 1.18870214e-01f, 2.10973576e-01f, -2.59436034e-02f, -2.11352762e-02f, 2.61808280e-02f, 7.33041838e-02f,
  2.52893418e-02f, 1.27916962e-01f, 1.04501620e-01f, -7.90143088e-02f, 7.06052631e-02f, 6.70175776e-02f, 5.88826090e-02f, 1.34172812e-01f, 1.10694587e-01f, -5.34827225e-02f,
  1.89212058e-02f, -1.75469816e-01f, 8.55217949e-02f, 7.30673447e-02f, 1.54381931e-01f, -2.96745300e-02f, 1.25974700e-01f, -9.58643332e-02f, -4.94901426e-02f, 1.39612272e-01f,
  -6.32585883e-02f, -1.26431093e-01f, -4.94636633e-02f, -6.88882023e-02f, 2.40870908e-01f, -5.04203513e-02f, -3.32840905e-02f, -1.11662827e-01f, -9.15467292e-02f, -4.57763635e-02f,
  1.50961816e-01f, -8.04618448e-02f, 6.44236654e-02f, 1.33747578e-01f, 8.23084638e-03f, -1.17012262e-01f, 3.25493887e-02f, -9.50259045e-02f, 1.93383098e-01f, -4.40071337e-02f,
  -1.55243203e-02f, 3.03649008e-02f, 4.74083982e-03f, 1.12249628e-02f, 5.59509313e-03f, -4.93082963e-02f, 6.76498236e-03f, -7.17313364e-02f, -7.28095844e-02f, 1.22525051e-01f,
  1.10697046e-01f, -5.92473242e-03f, -3.49871293e-02f, 6.76013455e-02f, 1.40130669e-01f, 1.15039982e-01f, -7.17570037e-02f, 8.12224671e-02f, -4.93274517e-02f, -2.62927506e-02f,
  -1.24580346e-01f, -1.01676751e-02f, 4.24317755e-02f, 2.05781981e-02f, 7.71654770e-02f, 6.65112734e-02f, -4.78564724e-02f, 6.81683794e-02f, 4.08088714e-02f, 5.36543503e-02f,
  -2.43890402e-03f, 1.13635279e-01f, -9.12053231e-03f, -9.60193351e-02f, -5.49306162e-02f, -8.37188438e-02f, -2.97100674e-02f, -1.31167127e-02f, 4.45514955e-02f, -9.32222381e-02f,
  5.88755272e-02f, 1.37900636e-01f, -4.40998003e-02f, 1.54086307e-01f, 9.51166973e-02f, -2.78402865e-02f, 2.26046387e-02f, -8.52785632e-02f, 5.86050302e-02f, 2.30110567e-02f,
  -1.43186757e-02f, -1.66912630e-01f, -1.97944473e-02f, 6.17057309e-02f, 1.93733200e-02f, -2.20300034e-02f, 9.40456092e-02f, 1.19108394e-01f, 1.12827249e-01f, 3.60864797e-03f,
  9.62012336e-02f, 3.40848193e-02f, 8.76954943e-02f, -2.90869437e-02f, -6.21333756e-02f, 1.32698298e-01f, 7.93230161e-02f, 4.64242883e-02f, 7.41453655e-03f, -6.09601662e-02f,
  -1.09780572e-01f, 3.71076949e-02f, -3.32290381e-02f, 2.69597936e-02f, -2.11071558e-02f, -4.49705608e-02f, -4.13459167e-02f, 5.12122847e-02f, 8.79079327e-02f, 1.67687878e-01f,
  6.08217604e-02f, -4.55043577e-02f, 4.72474620e-02f, -8.75527784e-02f, -1.28717363e-01f, 1.89564154e-01f, 8.44134912e-02f, 1.04453623e-01f, 4.32280526e-02f, 2.18390860e-03f,
  -9.35567729e-03f, 1.14993313e-02f, 4.82345857e-02f, -5.39620034e-02f, 5.47160469e-02f, 1.27773285e-01f, 7.54499286e-02f, 9.71327350e-02f, -2.12955564e-01f, -5.16862934e-03f,
  1.32958084e-01f, -1.73010811e-01f, -8.51086602e-02f, -1.48879766e-01f, 6.00397997e-02f, 1.83538020e-01f, 2.07253471e-01f, 2.44781941e-01f, 2.24797577e-01f, 1.99448973e-01f,
  9.71813798e-02f, -6.76047206e-02f, -1.11715674e-01f, 2.50984073e-01f, -4.75654230e-02f, 2.16395766e-01f, 1.06749810e-01f, -1.50395870e-01f, -1.18728802e-01f, 4.49929275e-02f,
  -1.18702658e-01f, -1.37404829e-01f, 8.86463076e-02f, 4.48532924e-02f, 4.24429439e-02f, -1.30060896e-01f, -2.30467066e-01f, 9.22380760e-02f, 1.60117134e-01f, 3.13053257e-03f,
  -1.18183931e-02f, 9.52271372e-02f, -8.71862099e-02f, -3.32400203e-03f, 9.20541808e-02f, -1.03560127e-01f, 1.55440286e-01f, -1.78210959e-01f, -5.61754182e-02f, -1.28052291e-02f,
  7.68369250e-03f, 3.11524272e-02f, -1.72938034e-02f, 2.08098590e-02f, 3.95636773e-03f, 8.39432876e-04f, 1.03870869e-01f, 1.55720785e-01f, 1.31220549e-01f, -2.42392924e-02f,
  6.70036301e-02f, -1.12258345e-01f, -8.34958181e-02f, -1.80995628e-01f, 2.84538895e-01f, 2.37758476e-02f, -3.08690593e-03f, 8.86706859e-02f, 9.30908769e-02f, -4.05193046e-02f,
  1.33120909e-01f, 1.70503363e-01f, 2.13773344e-02f, 2.52849944e-02f, 9.33807064e-03f, 1.26810014e-01f, -9.17672589e-02f, 5.15918732e-02f, -5.95607124e-02f, -5.56755401e-02f,
  5.99120036e-02f, -2.38886327e-01f, -1.06119730e-01f, 1.24243408e-01f, 1.48498058e-01f, 1.76101863e-01f, -4.05385531e-02f, -8.43303874e-02f, 1.48664385e-01f, 2.26417363e-01f,
  -7.42168203e-02f, -5.76479249e-02f, 2.45859139e-02f, 7.22604692e-02f, 1.26393943e-03f, -1.03608452e-01f, -3.65508795e-02f, 9.69215184e-02f, -6.24728166e-02f, 4.94640134e-02f,
  -3.79913710e-02f, -5.04428856e-02f, 6.86728805e-02f, -6.49802089e-02f, -5.84295727e-02f, -1.50262350e-02f, -4.30014357e-03f, 1.23787843e-01f, 1.06731772e-01f, -6.52494431e-02f,
  1.04006499e-01f, -6.19346201e-02f, 8.31628740e-02f, 2.37831831e-01f, 3.35895643e-02f, 3.74228209e-02f, -1.61555544e-01f, -2.31757700e-01f, -2.75570005e-02f, -1.99165922e-02f,
  9.82904211e-02f, 1.81139514e-01f, 1.75376832e-01f, -1.09569132e-01f, 7.92955980e-02f, -3.51057351e-02f, 6.38311207e-02f, 6.61606016e-03f, -1.09487347e-01f, 9.09472480e-02f,
  -3.05559766e-02f, -4.01955657e-02f, 2.81622782e-02f, 9.33898017e-02f, 1.27624884e-01f, 7.62859583e-02f, 7.58676082e-02f, -2.28639573e-01f, -3.29872556e-02f, -1.61353906e-03f,
  -5.77593148e-02f, -2.07811639e-01f, 2.03618165e-02f, -3.50163295e-03f, 1.18730642e-01f, -4.12675738e-02f, 6.20888099e-02f, 6.14423119e-02f, 1.39106438e-01f, 5.24236113e-02f,
  1.28434792e-01f, -1.34802669e-01f, 1.46501614e-02f, 3.96159552e-02f, -9.74846408e-02f, 1.21574933e-02f, 1.48632869e-01f, -1.72441795e-01f, 1.54425293e-01f, -1.63301736e-01f,
  4.48121428e-02f, -7.59138986e-02f, 1.69551730e-01f, 8.12551975e-02f, -1.99746322e-02f, 6.78761154e-02f, 6.98455721e-02f, 3.28529961e-02f, 4.90634702e-02f, 1.20522901e-01f,
  1.60330445e-01f, -1.93743020e-01f, 6.73094243e-02f, 3.05889770e-02f, 1.48868904e-01f, -1.25460356e-01f, 2.11006910e-01f, 6.25307560e-02f, 8.90980959e-02f, 2.37023383e-01f,
  -1.70852989e-01f, -2.99827792e-02f, 9.74867120e-03f, 1.86163113e-01f, -1.26091705e-03f, -3.27866594e-03f, 9.87270251e-02f, 6.03665784e-02f, -8.10140669e-02f, 8.57475773e-02f,
  -7.51917586e-02f, 9.20514241e-02f, 8.36086348e-02f, 1.19745389e-01f, 4.39345241e-02f, 1.00850046e-01f, 3.59437764e-02f, 1.16890647e-01f, -3.95340249e-02f, 1.07944533e-01f,
  1.03596255e-01f, 1.24070868e-02f, -2.38862424e-03f, 5.48802279e-02f, -1.33588805e-03f, 3.87333632e-02f, -3.05741467e-02f, -9.00352821e-02f, -1.35040939e-01f, 1.25832886e-01f,
  -4.08330485e-02f, 4.00887942e-03f, -1.00441091e-01f, -5.77961914e-02f, -6.32108469e-03f, 7.70955682e-02f, 1.13428049e-02f, -1.15718804e-01f, 2.16468405e-02f, -2.93783061e-02f,
  -7.09211603e-02f, 1.55016065e-01f, 1.65934861e-01f, 1.26481399e-01f, 1.02746874e-01f, -4.54365201e-02f, 8.47415030e-02f, 8.18514302e-02f, 9.92964357e-02f, -3.68120112e-02f,
  -3.59282494e-02f, 9.88231748e-02f, -6.91987528e-03f, 2.00886667e-01f, 7.49606341e-02f, 6.42016605e-02f, -8.24997798e-02f, 6.88259825e-02f, -7.26642087e-02f, 1.00461490e-01f,
  -4.35351543e-02f, -1.40644744e-01f, 1.15235494e-02f, 2.71315686e-02f, 1.40591085e-01f, 1.61492944e-01f, 1.08653039e-01f, -1.00392938e-01f, -1.17624536e-01f, -1.28308624e-01f,
  2.72710901e-02f, -5.60588576e-02f, -9.35380831e-02f, 7.37797990e-02f, 3.02405283e-02f, 1.11126445e-01f, 3.38909612e-03f, 3.22883949e-03f
};

// L1_fan_Bp_bar (Shape: 1 x 52)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 52;
const float L1_fan_Bp_bar_data[] = {
  6.20553158e-02f, -2.54859328e-02f, 5.70603870e-02f, 1.64613202e-01f, 8.99592042e-02f, -4.30041971e-03f, 4.18166816e-03f, 9.27618891e-02f, 8.68321508e-02f, 2.29555946e-02f,
  1.96097028e-02f, -1.49255861e-02f, 1.21485271e-01f, 2.89252214e-02f, 1.16195507e-01f, 1.15742475e-01f, 1.25400513e-01f, 8.90376866e-02f, 4.31634933e-02f, 1.32420838e-01f,
  -5.83073609e-02f, 1.37127161e-01f, 7.66281858e-02f, 7.87510276e-02f, 5.47687039e-02f, -1.99323911e-02f, 3.90071087e-02f, 3.85316573e-02f, 4.55660261e-02f, 1.21646170e-02f,
  1.22681178e-01f, 2.80995481e-02f, 7.05865398e-02f, 5.06453635e-03f, 1.42906429e-02f, 4.70650978e-02f, 9.63025540e-02f, -2.20128465e-02f, -4.45400272e-03f, 3.52986678e-02f,
  4.05239686e-02f, -1.21239200e-02f, 7.60523975e-02f, 7.03374296e-02f, 1.07486792e-01f, -3.57529279e-05f, 1.15407303e-01f, 3.73935811e-02f, 4.50414233e-02f, -1.36542320e-02f,
  6.28768504e-02f, 1.54352099e-01f
};

// L2_fan_Wp (Shape: 6 x 64)
const int L2_fan_Wp_rows = 6;
const int L2_fan_Wp_cols = 64;
const float L2_fan_Wp_data[] = {
  -5.72118796e-02f, 3.21176052e-02f, -6.65828064e-02f, 6.87855035e-02f, -1.42098591e-02f, 7.21211284e-02f, -1.00879930e-02f, -8.99262875e-02f, 1.58070073e-01f, 1.15546435e-01f,
  -6.73947632e-02f, 1.80954546e-01f, -1.92220174e-02f, -7.03777298e-02f, -2.84610800e-02f, 1.56958714e-01f, 8.80324375e-03f, -4.86067645e-02f, -1.88005511e-02f, -3.05254851e-02f,
  -8.80811587e-02f, -1.30268872e-01f, 8.47900808e-02f, -2.67728195e-02f, 1.84566602e-02f, 2.27817073e-02f, 4.03819717e-02f, -1.31870583e-01f, -1.91408202e-01f, -7.98111856e-02f,
  -1.21655762e-02f, 1.16920006e-02f, -4.16822061e-02f, -1.02274999e-01f, -8.32261145e-02f, -3.04964017e-02f, 8.37688893e-02f, 1.13901012e-01f, 1.16673939e-01f, 3.27815451e-02f,
  -1.12884566e-01f, -9.73001048e-02f, 1.87610403e-01f, 1.89400926e-01f, 8.43038708e-02f, -2.00793538e-02f, -5.25368117e-02f, 9.28462893e-02f, -9.05410498e-02f, -9.75367501e-02f,
  4.63149585e-02f, 1.55737288e-02f, 1.28355399e-01f, -1.02824010e-02f, -7.34639466e-02f, 8.16661417e-02f, 1.19698733e-01f, 8.92080590e-02f, -1.56553283e-01f, -7.92876109e-02f,
  1.24832168e-01f, 2.18339965e-01f, 1.31372094e-01f, -5.99544458e-02f, 1.01290092e-01f, 9.44660753e-02f, 4.99253068e-03f, 6.87163174e-02f, -2.00485415e-03f, 7.55933598e-02f,
  9.15127173e-02f, -6.36729598e-02f, -3.54396701e-02f, 1.20985294e-02f, -3.18263546e-02f, -1.70691997e-01f, 1.98581629e-02f, 7.77551299e-03f, -6.70778006e-02f, 1.52840437e-02f,
  -8.04236382e-02f, 1.51777610e-01f, 4.46811169e-02f, 2.60476168e-06f, 7.62270540e-02f, 4.36908714e-02f, 1.56986296e-01f, -4.07597236e-03f, 2.54393239e-02f, -5.25385886e-02f,
  -2.48119980e-02f, -7.30498433e-02f, 1.00525878e-02f, -3.76923010e-02f, -4.36909460e-02f, 1.03485025e-01f, 1.15334660e-01f, 9.50445756e-02f, -1.49318008e-02f, -1.49164791e-03f,
  7.12051522e-04f, 1.07580535e-01f, -2.42118277e-02f, -7.56627531e-04f, 4.97346781e-02f, 4.17132787e-02f, 4.07358669e-02f, -1.02938846e-01f, 4.19319794e-02f, -9.46687162e-02f,
  3.10826190e-02f, -1.25076219e-01f, 1.09723032e-01f, -2.31162123e-02f, -7.48458132e-02f, 5.07348916e-03f, -3.52599379e-03f, 9.73937139e-02f, 1.35760918e-01f, -2.81320903e-02f,
  -6.21883459e-02f, -1.21559799e-01f, 1.38885468e-01f, 1.07579127e-01f, -1.34035408e-01f, -9.29051936e-02f, 1.23313166e-01f, -1.83965843e-02f, 5.41854575e-02f, -2.32777130e-02f,
  2.49168407e-02f, 2.40936838e-02f, -2.12403946e-02f, 8.21423978e-02f, 1.18882842e-02f, 4.18421766e-03f, 2.92624757e-02f, 1.29688352e-01f, -3.57441902e-02f, 1.20308220e-01f,
  1.92737188e-02f, 1.38001405e-02f, -1.70146748e-02f, 1.13504708e-01f, 1.30926579e-01f, 4.04329039e-02f, -1.41845465e-01f, 4.68211398e-02f, -3.38707455e-02f, 2.67417748e-02f,
  -5.12410179e-02f, 9.47360471e-02f, -9.85934865e-03f, -1.04559086e-01f, 2.53667440e-02f, -3.68896723e-02f, -1.28092825e-01f, -1.20981559e-01f, -8.88379989e-04f, 1.29519524e-02f,
  9.65034738e-02f, -2.08066646e-02f, -6.84490725e-02f, -8.03334191e-02f, -1.05487742e-02f, 7.73372948e-02f, -9.88668017e-03f, 1.19754732e-01f, -3.36288139e-02f, -1.23839185e-01f,
  1.47363171e-01f, 1.35633452e-02f, 8.97621959e-02f, -8.39354023e-02f, 5.62020615e-02f, 2.61125173e-02f, 8.75038058e-02f, 5.83412386e-02f, -3.89400832e-02f, 1.26125906e-02f,
  5.17399013e-02f, 3.86950448e-02f, -7.19242916e-02f, 9.55189764e-02f, -5.22497781e-02f, 7.12260082e-02f, -3.26018073e-02f, -1.53777197e-01f, 1.91530548e-02f, 1.32019460e-01f,
  -1.89571325e-02f, 1.55708175e-02f, -4.43071723e-02f, 6.63796067e-02f, 7.29133710e-02f, 6.55358806e-02f, 6.97131529e-02f, -1.30222887e-02f, 7.57601038e-02f, -4.33945749e-03f,
  -1.27533466e-01f, -2.47839075e-02f, 1.07062928e-01f, -1.25061899e-01f, 6.23378195e-02f, 1.15242988e-01f, -3.33723500e-02f, -5.68357334e-02f, -4.38724123e-02f, 5.46628237e-02f,
  7.81341940e-02f, 1.62575260e-01f, -3.00797690e-02f, -1.07032292e-01f, -9.34340246e-03f, 1.82562564e-02f, -4.02614148e-03f, 6.18612207e-02f, 4.00708951e-02f, 1.20280251e-01f,
  8.19173902e-02f, 6.86450163e-03f, -8.91779736e-02f, 5.65800816e-02f, 4.97362614e-02f, 1.07907481e-01f, 9.14069638e-02f, 9.75570455e-03f, 2.97931954e-02f, 2.35835882e-03f,
  -8.32283273e-02f, -5.79582229e-02f, 4.17363271e-02f, 5.27541377e-02f, 2.21750010e-02f, -1.15714371e-01f, 4.25773934e-02f, -7.41820130e-03f, -8.00987259e-02f, -2.43411101e-02f,
  -1.71808768e-02f, -3.80687825e-02f, -8.07984266e-03f, -1.41084166e-02f, -1.58341348e-01f, -4.35264409e-02f, 6.63955212e-02f, -2.16749478e-02f, -1.28841743e-01f, 1.05212703e-01f,
  8.88329744e-02f, 6.78484812e-02f, 1.16728678e-01f, -1.39841139e-01f, -1.90797467e-02f, 9.72159058e-02f, -4.73271646e-02f, -6.95339069e-02f, -3.10210381e-02f, 2.27375831e-02f,
  4.39261086e-02f, 4.57160845e-02f, -9.31580812e-02f, -4.72753048e-02f, -5.22059388e-02f, 1.86790586e-01f, 7.62024671e-02f, 2.28975296e-01f, -3.58459130e-02f, -4.92714047e-02f,
  -7.76732117e-02f, 4.90130410e-02f, 1.00838475e-01f, -2.06333157e-02f, -4.05906215e-02f, -1.52285278e-01f, 8.02848712e-02f, -1.15901798e-01f, -1.06399298e-01f, -6.31879345e-02f,
  6.77250251e-02f, -2.00572051e-02f, 1.35216162e-01f, -7.60618821e-02f, -3.52226831e-02f, -1.81429312e-01f, -4.43347618e-02f, -1.18389681e-01f, -8.91434550e-02f, 1.17189527e-01f,
  1.69563442e-02f, -2.29932248e-05f, -1.22435100e-01f, 8.69850442e-03f, 3.93049978e-03f, 7.33735338e-02f, -9.22546312e-02f, -4.44829762e-02f, 3.67046520e-02f, 1.12150043e-01f,
  3.19362171e-02f, -9.75967422e-02f, 9.37357768e-02f, 1.38863131e-01f, -5.35636917e-02f, 1.20708972e-01f, -7.01854900e-02f, 4.29962911e-02f, -1.37326077e-01f, -1.46977287e-02f,
  -1.51570916e-01f, -5.95727488e-02f, 3.77081856e-02f, -6.66303113e-02f, 1.47433835e-03f, -1.43379852e-01f, 5.85664883e-02f, 1.01998493e-01f, 1.92285627e-02f, 9.15716588e-02f,
  9.06191319e-02f, 7.16827586e-02f, -4.20471616e-02f, 1.02791615e-01f, 7.35540688e-02f, 1.14651009e-01f, 1.52565809e-02f, 5.16363494e-02f, 4.14452795e-03f, 8.24874490e-02f,
  -3.89058739e-02f, 8.69132951e-02f, -5.84623357e-03f, -8.39259923e-02f, 8.07205811e-02f, 7.17598274e-02f, 9.98115167e-02f, -1.21980585e-01f, -1.02396667e-01f, 3.27403471e-02f,
  3.38526629e-02f, 1.39312476e-01f, -1.22096598e-01f, 4.71611731e-02f, -1.09527055e-02f, -2.80891862e-02f, -3.60443071e-03f, -2.21691653e-02f, -1.81511287e-02f, -5.98457865e-02f,
  1.21272150e-02f, -9.89697278e-02f, 8.57969820e-02f, -3.96551974e-02f, -2.41014324e-02f, 3.43546383e-02f, 5.43191023e-02f, 8.89925112e-04f, 1.16228670e-01f, 6.92097172e-02f,
  -8.38911161e-02f, -1.45885080e-01f, 1.18656963e-01f, 6.41803816e-02f, 4.63542677e-02f, -1.33748204e-02f, 4.13856320e-02f, -3.65604199e-02f, 5.93032166e-02f, 1.49435818e-01f,
  1.61065757e-02f, 7.92777240e-02f, 1.10521227e-01f, -8.44777673e-02f, 2.95784622e-02f, 4.99567650e-02f, 9.54269171e-02f, 1.27710700e-01f, 2.65505612e-02f, -7.76440650e-02f,
  -8.35276768e-02f, 1.27149180e-01f, 4.57806662e-02f, 1.11273080e-01f
};

// L2_fan_Wp_bar (Shape: 52 x 64)
const int L2_fan_Wp_bar_rows = 52;
const int L2_fan_Wp_bar_cols = 64;
const float L2_fan_Wp_bar_data[] = {
  7.19071999e-02f, -3.69390063e-02f, -1.17678167e-02f, 1.10496454e-01f, -3.33765075e-02f, 1.36263715e-02f, -5.31811500e-03f, 4.77367155e-02f, 6.16290346e-02f, 1.00173987e-01f,
  -6.50238842e-02f, 1.10758990e-01f, 9.55228731e-02f, -1.02027982e-01f, 1.27653182e-01f, 1.48204893e-01f, 5.01578189e-02f, 5.46550341e-02f, -1.08586244e-01f, -5.59452400e-02f,
  1.03208296e-01f, 1.88703630e-02f, -3.69508639e-02f, -5.47621474e-02f, -1.03820479e-02f, -5.04047610e-02f, 4.66404893e-02f, -9.85722467e-02f, -1.78388786e-02f, -2.05572266e-02f,
  -1.45988494e-01f, -6.98031262e-02f, 5.22347316e-02f, 9.19997245e-02f, 6.76238909e-02f, 8.60413387e-02f, -1.68694239e-02f, 1.82173118e-01f, 1.88248098e-01f, 1.04546323e-01f,
  -5.00471927e-02f, -7.55260838e-03f, 1.80113032e-01f, 8.36651027e-02f, 1.03612356e-01f, -6.94589540e-02f, 7.92307332e-02f, 4.93807830e-02f, -2.02357359e-02f, 1.91847190e-01f,
  7.64980912e-02f, 1.28580391e-01f, -1.49426963e-02f, -4.69762310e-02f, -9.15237069e-02f, 6.87789395e-02f, 5.59118576e-02f, 5.19618541e-02f, -3.26631255e-02f, -4.08095215e-03f,
  1.01489007e-01f, 1.28573790e-01f, -6.62635313e-03f, 9.19210464e-02f, 4.65638936e-02f, 2.81586051e-02f, 3.15633677e-02f, 5.56700006e-02f, -2.58743041e-03f, 9.34493393e-02f,
  -1.22456014e-01f, -1.09042130e-01f, 7.94370547e-02f, 2.09539071e-01f, 1.45036066e-02f, 1.31566316e-01f, -1.29153188e-02f, -1.78371021e-03f, -9.27158594e-02f, 1.98739842e-01f,
  9.42075774e-02f, 8.74951854e-02f, 2.64884010e-02f, -1.16922684e-01f, 2.44355835e-02f, 3.04506160e-02f, -6.82729390e-03f, -4.28418666e-02f, 9.29370970e-02f, -2.54294984e-02f,
  6.04491606e-02f, -4.70509194e-02f, -2.09061578e-01f, -3.75915430e-02f, -1.57309584e-02f, -1.18961453e-01f, -7.29548708e-02f, 4.67008539e-02f, 6.82843775e-02f, 8.58701393e-02f,
  -6.63625225e-02f, 2.18239687e-02f, 5.62704764e-02f, 4.44924980e-02f, -1.52301669e-01f, -4.05173749e-02f, 1.78582162e-01f, 1.18273444e-01f, 1.21740848e-01f, -9.84618813e-02f,
  8.98011699e-02f, 1.87546700e-01f, 5.98463640e-02f, -2.41557118e-02f, -6.06285781e-02f, -3.13179791e-02f, -5.47192954e-02f, 7.76416659e-02f, -3.39530520e-02f, 4.73739877e-02f,
  2.19778307e-02f, -5.37765361e-02f, 4.28542681e-02f, -5.99653646e-02f, 9.61478427e-02f, 1.49518743e-01f, 1.02394760e-01f, 1.08846091e-01f, -8.39885920e-02f, 6.01427257e-02f,
  1.18115107e-02f, -5.59508875e-02f, 1.59281921e-02f, -4.02366519e-02f, -1.74895152e-01f, -1.62790418e-01f, 1.77944358e-02f, -3.37998271e-02f, 2.23254874e-01f, 6.96710274e-02f,
  -9.61994976e-02f, 2.15553835e-01f, -1.31592602e-01f, -2.72887889e-02f, 9.56062227e-02f, 8.62287655e-02f, 1.95495054e-01f, -4.78345528e-03f, 1.24081664e-01f, -2.17254966e-01f,
  1.33836731e-01f, 1.18321024e-01f, 5.67886867e-02f, 2.02802196e-01f, 1.42920092e-01f, 1.08660705e-01f, -1.08584762e-01f, 6.28025085e-02f, -5.80200851e-02f, 7.82105997e-02f,
  -1.58775598e-01f, 1.67837411e-01f, 1.47289708e-01f, 1.43993363e-01f, -1.21838562e-01f, -8.52487460e-02f, 5.33242337e-02f, 3.89301218e-02f, -1.62414964e-02f, 2.46662915e-01f,
  -3.92347425e-02f, -8.58730525e-02f, -2.70920098e-02f, -1.62722632e-01f, -1.55043244e-01f, 2.60749876e-01f, -2.70775229e-01f, -1.65407732e-01f, -1.17054246e-02f, -6.90999180e-02f,
  -2.02773288e-01f, 2.07989752e-01f, -7.94429332e-02f, -1.59170449e-01f, -8.82138237e-02f, -1.25693142e-01f, 6.70003816e-02f, 1.22910634e-01f, 2.57726550e-01f, -1.81590304e-01f,
  5.86044677e-02f, 1.37916818e-01f, 1.19884036e-01f, 2.57313270e-02f, 6.29657656e-02f, -5.43739200e-02f, 1.26214579e-01f, 4.10138369e-02f, -2.45841339e-01f, -3.08526512e-02f,
  1.00719661e-01f, -1.01223655e-01f, -4.20127101e-02f, -1.23460174e-01f, -1.91708982e-01f, 6.81630969e-02f, 6.60395846e-02f, 6.83429688e-02f, -1.38360439e-02f, 1.42290801e-01f,
  2.29233235e-01f, 7.30555132e-02f, 1.32678822e-02f, 1.81441560e-01f, -1.85428318e-02f, 1.47160277e-01f, 1.70546055e-01f, 1.62501320e-01f, -8.78506452e-02f, 9.21857581e-02f,
  3.98713946e-02f, 2.38315269e-01f, 2.81438679e-01f, 8.42244253e-02f, -1.61078438e-01f, -8.20174441e-02f, 5.33049181e-02f, 2.49619558e-01f, -2.49931328e-02f, -5.12855593e-03f,
  6.60555586e-02f, -1.32900342e-01f, -7.28349807e-03f, 6.04899926e-03f, -1.19515270e-01f, 1.13626301e-01f, -1.11882053e-01f, 1.28782690e-01f, 1.44797424e-02f, 3.20287608e-02f,
  -7.13676540e-03f, -1.36833206e-01f, -8.87657925e-02f, -3.04766279e-02f, 1.56451583e-01f, 1.33421332e-01f, 6.37026653e-02f, 1.05953544e-01f, 1.26075834e-01f, -5.08709513e-02f,
  1.48978546e-01f, 6.87714741e-02f, 1.45137340e-01f, -4.63336445e-02f, -5.52087985e-02f, 4.07918319e-02f, -6.25759959e-02f, -2.36812606e-02f, 1.19347259e-01f, -1.13213815e-01f,
  -1.45245818e-02f, -3.15876603e-02f, -1.51483700e-01f, -3.23820822e-02f, 7.77037768e-03f, -8.25002491e-02f, 1.54764593e-01f, 2.52390616e-02f, -1.52080983e-01f, 1.60793528e-01f,
  -5.06340303e-02f, -2.23917007e-01f, 5.83627038e-02f, 3.11240945e-02f, 2.01437950e-01f, 8.85041337e-03f, 1.42081350e-01f, -1.18233375e-01f, 1.04579203e-01f, 2.83770710e-02f,
  1.83022469e-01f, 2.35544279e-01f, 7.72538483e-02f, 1.09792508e-01f, 1.79139152e-01f, 3.01224232e-01f, 1.33614495e-01f, 2.52801448e-01f, -1.75394982e-01f, 1.39258787e-01f,
  1.24269880e-01f, 2.24641815e-01f, -1.07575888e-02f, -1.46492779e-01f, -1.62850730e-02f, -1.25446931e-01f, 7.43770599e-03f, 2.74143308e-01f, -2.72609532e-01f, -4.93389703e-02f,
  -1.37473434e-01f, 1.37654051e-01f, -5.36392778e-02f, 2.02618346e-01f, -1.60343885e-01f, -2.08439171e-01f, -5.99319674e-02f, -3.05076037e-02f, -2.20141821e-02f, 1.18537523e-01f,
  -2.68697627e-02f, -1.11311309e-01f, 2.27254890e-02f, -6.80740774e-02f, 2.64304224e-02f, 1.76100761e-01f, 2.08636209e-01f, -1.84126422e-01f, -5.57222813e-02f, 1.23275906e-01f,
  1.19145356e-01f, 2.92633940e-02f, -4.42591775e-03f, 2.78411489e-02f, -1.21253114e-02f, 3.61675173e-02f, -4.98777162e-03f, -9.67693850e-02f, 8.38044137e-02f, 1.96100950e-01f,
  -2.12089904e-02f, 6.62086084e-02f, -3.85843520e-03f, -6.42412603e-02f, 8.30324367e-04f, 1.96305096e-01f, -6.74735336e-03f, -2.56779045e-02f, -5.07561527e-02f, -1.66019216e-01f,
  1.02479078e-01f, 1.15637273e-01f, 5.93846776e-02f, -8.61317292e-02f, 3.07474658e-02f, -1.73219725e-01f, 5.99665940e-02f, -1.21075995e-01f, -2.13201717e-01f, -8.42979029e-02f,
  -2.09822375e-02f, -5.67834713e-02f, 7.84512833e-02f, 5.24557345e-02f, 1.52260661e-01f, -1.38887037e-02f, -1.23242401e-01f, 1.70252874e-01f, 7.27901682e-02f, 1.38560221e-01f,
  -6.95268661e-02f, -1.54686421e-01f, 7.11173937e-02f, 1.45714104e-01f, 9.20438021e-02f, -1.49326816e-01f, 1.08838119e-01f, -1.83267274e-03f, 1.43072322e-01f, 9.04695392e-02f,
  -8.12698007e-02f, 5.49398828e-03f, 6.57322779e-02f, 4.30049002e-02f, 6.26229495e-02f, 9.68492925e-02f, 3.29783782e-02f, -2.85410769e-02f, 3.55958790e-02f, -7.44248927e-02f,
  1.63984895e-02f, 6.57907948e-02f, -9.40006226e-03f, 8.82268772e-02f, -1.18586123e-02f, -7.15408549e-02f, -4.91468236e-02f, -6.67579323e-02f, 3.43748033e-02f, 1.29946351e-01f,
  -3.54361683e-02f, 1.80044651e-01f, 7.16973543e-02f, -1.21788859e-01f, -1.45095378e-01f, 2.90851425e-02f, -6.25887066e-02f, -1.14560410e-01f, 1.05748206e-01f, -8.73771496e-03f,
  -4.77347896e-02f, -3.38460431e-02f, 6.10806122e-02f, -9.34186727e-02f, -3.18608023e-02f, 1.93813831e-01f, -1.03956223e-01f, 2.64105834e-02f, 9.70903132e-03f, 2.67203450e-02f,
  -8.30510259e-02f, 3.32468585e-03f, 8.32942650e-02f, 3.02599296e-02f, 1.67715833e-01f, 5.76430224e-02f, 8.19760654e-03f, -9.76216421e-02f, 3.79470661e-02f, 4.65320125e-02f,
  3.73863503e-02f, -4.75515015e-02f, -2.19224039e-02f, -7.37750381e-02f, -4.38234955e-02f, -1.27955750e-01f, -1.08557671e-01f, 1.46578759e-01f, -5.83144650e-02f, 1.63686320e-01f,
  5.06080873e-02f, -5.80420531e-02f, 1.33206606e-01f, 3.21018547e-02f, -3.20333242e-02f, 5.95688857e-02f, 2.01823473e-01f, -1.05269663e-01f, 4.75974493e-02f, 8.85254443e-02f,
  1.40392452e-01f, 6.14171736e-02f, -6.27544075e-02f, -5.71894534e-02f, -6.36031330e-02f, 5.81488274e-02f, -8.80273730e-02f, -3.90476175e-02f, 1.02741845e-01f, 1.06229261e-01f,
  -9.43982683e-04f, 8.27502608e-02f, -1.48732204e-03f, -7.44694797e-03f, 1.83016375e-01f, 1.08519539e-01f, -1.34779900e-01f, 9.35981795e-03f, -2.39156857e-02f, 3.87612730e-02f,
  9.07953233e-02f, -1.85109779e-01f, 1.31486118e-01f, 1.26493186e-01f, 6.36432990e-02f, -6.20053820e-02f, -1.90899178e-01f, 4.47137393e-02f, 8.69466364e-02f, -2.92933565e-02f,
  -2.26267502e-02f, -2.50708219e-02f, -8.27252492e-02f, -1.03374228e-01f, 1.08239554e-01f, -5.93765676e-02f, 1.28595442e-01f, -1.56929076e-01f, -1.83132797e-01f, 6.38638884e-02f,
  7.12753609e-02f, 2.12427214e-01f, 9.44770724e-02f, -3.57525833e-02f, 3.56692597e-02f, 8.07017311e-02f, 1.41416341e-01f, 1.56067237e-01f, 1.40683562e-01f, -6.00771569e-02f,
  9.89819318e-02f, -5.57324775e-02f, 1.44866884e-01f, 1.00640962e-02f, 8.17881823e-02f, -1.01947784e-02f, 1.18771140e-02f, 2.67979294e-01f, 2.00641397e-02f, 1.21129625e-01f,
  1.71140321e-02f, -1.56646416e-01f, -6.15113266e-02f, -9.89716686e-03f, -1.11828119e-01f, 1.02643915e-01f, -2.31096125e-03f, 9.61391777e-02f, -1.09344408e-01f, 8.73814803e-03f,
  -7.70254955e-02f, 5.40751033e-02f, 1.91929974e-02f, 1.16235092e-01f, -7.42919594e-02f, 1.72000438e-01f, 4.41537704e-03f, 1.56601481e-02f, 1.76198736e-01f, -3.08333300e-02f,
  -1.30621091e-01f, 1.11044114e-02f, -1.84740666e-02f, -1.58516988e-01f, 1.47638068e-01f, -9.53921005e-02f, 3.74477245e-02f, 6.95406124e-02f, -1.30942896e-01f, 1.12885475e-01f,
  -6.62660897e-02f, 1.71417624e-01f, 6.10618852e-02f, 5.59035055e-02f, 1.27994463e-01f, 9.21171084e-02f, -8.46863165e-02f, -1.85177907e-01f, -5.11607621e-03f, 3.47127765e-02f,
  -3.61679196e-02f, -5.53805828e-02f, -1.02382302e-01f, 5.08526452e-02f, 1.85618326e-01f, -3.23445946e-02f, 2.67538782e-02f, -6.47436604e-02f, 4.80599962e-02f, 1.78048193e-01f,
  6.61609024e-02f, 6.17680065e-02f, 1.24837995e-01f, -1.97356865e-02f, 1.68317020e-01f, -5.62936701e-02f, 1.78217500e-01f, -1.00310855e-01f, 1.79758426e-02f, -8.80960748e-02f,
  7.36452416e-02f, 5.45005091e-02f, 3.76311168e-02f, -1.64725818e-02f, -1.84640400e-02f, -3.10615916e-02f, 1.00620471e-01f, -2.37042992e-03f, -3.26535068e-02f, 3.04112062e-02f,
  2.64936313e-02f, 9.07050073e-02f, -1.25604406e-01f, 2.32913997e-02f, 4.98802029e-02f, 4.21011448e-02f, -4.40103374e-02f, -3.94083001e-02f, 6.06499314e-02f, -4.43314351e-02f,
  -4.83865775e-02f, 7.15865269e-02f, -1.24440014e-01f, 8.85512978e-02f, 8.42841640e-02f, -1.43212918e-02f, 2.08639400e-03f, 1.98363602e-01f, -1.34869352e-01f, -2.34709326e-02f,
  3.50304805e-02f, -7.15091974e-02f, 7.59918690e-02f, -6.38598576e-02f, -2.91567575e-03f, -1.15174435e-01f, 9.78128016e-02f, 3.55169810e-02f, -9.74093303e-02f, -1.74851380e-02f,
  1.08278908e-01f, 1.53387457e-01f, 1.03706181e-01f, -2.21668612e-02f, 5.61797656e-02f, 1.46940902e-01f, 1.58245817e-01f, 3.82400043e-02f, -1.41512692e-01f, 1.21616416e-01f,
  7.44188279e-02f, 1.52466223e-01f, 2.15236861e-02f, -8.98509324e-02f, 4.71745320e-02f, -4.17396612e-02f, -1.45759434e-01f, -6.45108595e-02f, -1.11329384e-01f, 7.76632056e-02f,
  -6.45366013e-02f, 1.50251314e-01f, 6.27183616e-02f, 1.43064424e-01f, 4.07097451e-02f, -4.66202386e-02f, -9.42633152e-02f, 3.07550225e-02f, 6.76404834e-02f, -2.18953304e-02f,
  -1.17254041e-01f, -3.74531932e-02f, 1.29177615e-01f, -2.92151626e-02f, -5.43601029e-02f, -1.95406983e-03f, 1.41429499e-01f, -2.33112387e-02f, -1.43357858e-01f, 1.28700152e-01f,
  -4.29017721e-17f, -7.16730928e-13f, -4.90590966e-13f, -3.74780502e-12f, -1.54166905e-11f, -4.79616607e-12f, 1.06234766e-16f, 1.06598828e-26f, -4.60444108e-25f, -2.15620664e-32f,
  -6.70989279e-32f, -1.76444112e-31f, -1.52768054e-32f, -1.30037951e-12f, -1.65037043e-15f, -1.00279707e-19f, 6.50813407e-30f, -2.08596623e-15f, -6.26403876e-26f, -2.02599396e-12f,
  -7.06651000e-33f, -3.10932074e-19f, 1.48772401e-29f, -9.04881378e-11f, -4.96271322e-32f, 1.15505850e-31f, -2.44627398e-32f, 1.60745316e-21f, -1.68468735e-31f, -1.53676009e-12f,
  2.46931083e-21f, -3.33531217e-18f, -4.34228447e-28f, -3.91266410e-32f, -1.32096048e-31f, -9.00242554e-12f, -1.84486737e-17f, 1.36801702e-27f, 3.96106243e-32f, 8.51850605e-32f,
  -1.60872750e-31f, 1.30749343e-31f, -1.26602042e-14f, -1.91653735e-10f, 1.00660784e-32f, 9.61068605e-28f, -7.01421852e-31f, 3.68278560e-32f, 3.85233559e-27f, 4.43001562e-32f,
  -8.30089794e-32f, 1.75786364e-34f, -4.04680467e-13f, -6.47503930e-20f, -8.08293319e-14f, 8.93458344e-32f, 1.93211646e-25f, -4.77649864e-12f, 6.78139072e-29f, 5.32508392e-31f,
  -6.41561511e-13f, 1.84779087e-32f, -1.28572430e-10f, 6.57118551e-31f, 4.32129987e-02f, 2.42936704e-02f, -1.96985696e-02f, 5.12950793e-02f, 3.43933180e-02f, 1.54272597e-02f,
  8.24315995e-02f, -3.34804542e-02f, -1.17869653e-01f, 3.43214311e-02f, -4.06539217e-02f, -2.10087240e-01f, 3.77269946e-02f, -3.43165174e-02f, -3.54479589e-02f, 1.70016885e-02f,
  -1.39293075e-01f, 9.27381068e-02f, 1.30473366e-02f, 6.92299902e-02f, -3.23407315e-02f, 1.07414842e-01f, -2.40758876e-03f, -2.30286233e-02f, 1.91054773e-02f, -1.30720228e-01f,
  -9.46175307e-02f, 1.05341963e-01f, -1.74173024e-02f, 3.81481759e-02f, 3.56716961e-02f, 1.26260594e-02f, 1.09706514e-01f, -1.00475689e-02f, -1.69866730e-03f, 1.18671684e-03f,
  -2.08645742e-02f, 5.95965013e-02f, -5.03373407e-02f, -2.30336003e-02f, 6.70304149e-02f, -2.12411378e-02f, 1.60783846e-02f, -9.46075171e-02f, 6.31431043e-02f, -5.32561950e-02f,
  -1.17617035e-02f, -1.61466330e-01f, 9.02562812e-02f, 8.04728596e-04f, -6.56636357e-02f, -4.71551344e-02f, -4.83000427e-02f, -2.25816737e-03f, 9.72921997e-02f, 1.41194992e-04f,
  -9.20947045e-02f, -6.36460856e-02f, 1.35821685e-01f, 2.61869635e-02f, -1.62147671e-01f, -8.29057992e-02f, 2.04762314e-02f, 5.72746620e-02f, 3.13118333e-03f, 1.01838298e-01f,
  -4.28274320e-03f, 1.11709580e-01f, 3.77212875e-02f, -8.15874413e-02f, 8.37208778e-02f, -3.25964577e-02f, -1.96004823e-01f, -7.00265244e-02f, 1.56921729e-01f, -1.21801533e-01f,
  1.10814601e-01f, 1.57653704e-01f, -5.70808463e-02f, -4.74594645e-02f, -5.78452758e-02f, 8.76158550e-02f, 3.59831788e-02f, 2.01467261e-01f, 8.65017623e-02f, -1.01651974e-01f,
  5.64464480e-02f, 7.58564621e-02f, -2.65005976e-03f, 2.12891474e-02f, 1.50121003e-02f, 1.03942327e-01f, 9.10788402e-02f, 8.00129250e-02f, -1.02894224e-01f, 1.95456177e-01f,
  1.60581917e-01f, 1.95411161e-01f, 1.71944320e-01f, -4.99162264e-02f, 3.82162631e-02f, 1.10011876e-01f, 3.07303220e-02f, 1.49552710e-02f, 1.18260376e-01f, 1.91806823e-01f,
  -7.65909068e-03f, -1.80602923e-01f, 1.15103871e-01f, -7.33598769e-02f, 1.36218695e-02f, 2.32077506e-03f, -1.11840758e-02f, 1.63133014e-02f, 6.92348033e-02f, -2.61164121e-02f,
  -1.04388587e-01f, 6.35711476e-02f, 8.26797560e-02f, -7.98006505e-02f, -6.27272427e-02f, 6.99812220e-03f, 2.22135019e-02f, 1.39092609e-01f, -3.54928933e-02f, -1.21902630e-01f,
  1.57861084e-01f, 1.47356942e-01f, 4.28292118e-02f, 7.42313638e-02f, -9.31647886e-03f, 8.03595781e-02f, -5.83605990e-02f, 3.64185870e-02f, -5.68317845e-02f, -1.19180448e-01f,
  9.29780081e-02f, 1.16075061e-01f, -5.66441864e-02f, 1.84003133e-02f, 5.67386113e-02f, 1.23107463e-01f, 1.21129183e-02f, 2.41277739e-01f, 7.22361729e-02f, 2.01144114e-01f,
  5.59967756e-02f, 2.56136432e-02f, -8.61966535e-02f, 1.33682750e-02f, 1.44229963e-01f, 4.95135449e-02f, -8.80418867e-02f, -3.43225822e-02f, -7.88087398e-02f, -5.33159226e-02f,
  -2.18448073e-01f, -4.65492979e-02f, -9.58078429e-02f, -1.79632306e-01f, 3.45029347e-02f, -7.99735487e-02f, -1.91167798e-02f, -5.27762510e-02f, -7.59449229e-02f, 8.31664503e-02f,
  -2.25675702e-02f, 1.06383532e-01f, -5.35869189e-02f, -2.99796974e-03f, 2.52350628e-01f, 1.49951413e-01f, 1.37260005e-01f, -1.95496321e-01f, -2.84878872e-02f, -4.89031635e-02f,
  1.99452806e-02f, 1.69432384e-03f, 4.38692868e-02f, -5.66856265e-02f, 6.24788404e-02f, 1.15857236e-01f, 9.43065733e-02f, 1.27395689e-01f, 4.60477285e-02f, 3.12887575e-03f,
  5.10503016e-02f, -8.82483125e-02f, -1.52538503e-02f, 1.24828428e-01f, 2.33603448e-01f, -1.22807555e-01f, -2.15592869e-02f, -8.46638158e-03f, -4.12322953e-03f, -4.88380305e-02f,
  2.38574259e-02f, 1.49164855e-01f, -1.13720549e-02f, 1.40673906e-01f, 1.09979101e-01f, -1.60940334e-01f, -7.85076842e-02f, 5.87262623e-02f, -9.08426195e-03f, 1.29214406e-01f,
  1.67501062e-01f, 1.15968883e-02f, 5.20062037e-02f, 8.28142166e-02f, 5.53229749e-02f, 2.93159541e-02f, -7.41502643e-02f, 1.04603358e-01f, -8.27964470e-02f, 9.49029028e-02f,
  -8.57090354e-02f, 1.04368225e-01f, -8.61015692e-02f, 1.15642279e-01f, 1.60700843e-01f, 1.18990846e-01f, 4.27927934e-02f, 2.09081937e-02f, -7.48472661e-02f, -1.04925502e-02f,
  -1.25261009e-01f, 1.61939487e-01f, 1.75979912e-01f, -2.27699196e-03f, 2.49642543e-02f, -7.27266595e-02f, -1.40069827e-01f, 2.53077187e-02f, 6.98752180e-02f, 6.49966598e-02f,
  -6.21129945e-02f, 1.48473635e-01f, 1.35413706e-02f, -4.39714976e-02f, -2.96285227e-02f, 4.42324392e-02f, 7.62094557e-02f, 6.23912141e-02f, 1.95945531e-01f, -4.91057448e-02f,
  1.00490525e-02f, 1.09948292e-02f, 1.44422814e-01f, 2.23497748e-01f, -5.63629456e-02f, -1.18036736e-02f, 9.42792445e-02f, 3.14164571e-02f, -7.44910687e-02f, -2.81503256e-02f,
  -2.04950292e-02f, -3.57093364e-02f, 5.76889068e-02f, 7.08721206e-02f, -9.35224257e-03f, -6.69052601e-02f, -6.89540282e-02f, -2.07183778e-01f, 6.05696104e-02f, 1.23142421e-01f,
  9.04158205e-02f, 3.02314032e-02f, -1.59246866e-02f, 1.32637650e-01f, -1.56520009e-01f, 4.65916656e-03f, 4.06568423e-02f, 8.98615569e-02f, 1.10149853e-01f, -1.90075934e-02f,
  2.96761170e-02f, -3.05611379e-02f, 1.85055971e-01f, 1.61701515e-01f, 3.88876791e-03f, -2.16561966e-02f, 1.10510858e-02f, -5.79631366e-02f, -1.38204932e-01f, 1.68291144e-02f,
  -2.02934034e-02f, 4.37071286e-02f, 2.63019223e-02f, -8.17654580e-02f, -1.15466282e-04f, 6.46165758e-02f, -1.05284296e-01f, 1.05616726e-01f, 7.19521120e-02f, -1.02196969e-02f,
  5.52231271e-04f, 1.35448232e-01f, 1.25780910e-01f, -3.10705211e-02f, 1.24814129e-02f, -2.40063980e-01f, -8.40934291e-02f, 1.46095559e-01f, -5.63989691e-02f, -1.61119401e-01f,
  -3.66957597e-02f, -7.88954273e-02f, -9.21819080e-03f, 1.88871205e-01f, -8.99701342e-02f, 7.25943148e-02f, 6.20031878e-02f, -3.92315127e-02f, 4.43117470e-02f, 5.97425774e-02f,
  6.43798634e-02f, -1.44948228e-03f, 1.44994572e-01f, -2.22194046e-02f, -8.15710351e-02f, 2.10433244e-03f, 7.00621819e-03f, -3.59452143e-02f, 9.93876252e-04f, -5.93985838e-04f,
  -9.69362855e-02f, 8.10671076e-02f, -3.52144521e-03f, 1.28851645e-02f, 1.10699445e-01f, 2.56902575e-01f, -5.24643697e-02f, 1.90490067e-01f, 4.54094484e-02f, 5.88226914e-02f,
  2.02461272e-01f, -7.89374337e-02f, -3.14996094e-02f, 1.21940285e-01f, -3.27812880e-02f, -6.03014603e-02f, -1.20385289e-01f, 6.68438077e-02f, -1.04641490e-01f, 2.07632422e-01f,
  9.76398513e-02f, -1.25950044e-02f, -3.96806700e-03f, -6.44357130e-02f, -4.96037528e-02f, -6.62783906e-02f, -1.24754332e-01f, -3.16418372e-02f, -7.81699866e-02f, 6.58405945e-02f,
  5.47979260e-03f, 4.74796519e-02f, -2.40897853e-02f, 9.34042186e-02f, -1.47423863e-01f, -6.41768426e-02f, 9.26617011e-02f, 1.01062939e-01f, -2.03801990e-02f, 1.68041065e-01f,
  -5.99043304e-03f, 1.52243108e-01f, -8.81388709e-02f, -2.06747577e-02f, 1.70178950e-01f, -1.54146422e-02f, 3.91605981e-02f, 1.44478023e-01f, -2.37217061e-02f, -1.63296927e-02f,
  9.58849415e-02f, 8.94812718e-02f, -7.55595118e-02f, -2.98681781e-02f, 1.39610812e-01f, 8.14729258e-02f, 1.55508980e-01f, -4.86117080e-02f, 2.65771765e-02f, 1.64299179e-02f,
  1.34778731e-02f, -5.37146442e-03f, 1.88425686e-02f, 1.97916292e-03f, 3.58705632e-02f, -1.06839528e-02f, -6.18091039e-02f, -1.43487481e-02f, -2.05724668e-02f, -1.91028982e-01f,
  -1.06879193e-02f, -2.78448779e-02f, -2.06276961e-02f, -5.81142679e-02f, -1.21371903e-01f, 8.43879357e-02f, 5.27675152e-02f, 3.33138742e-02f, 2.44854949e-03f, 1.05327018e-01f,
  1.39142796e-02f, -2.59576887e-02f, 5.66158742e-02f, -5.70849776e-02f, -8.23644847e-02f, 1.08932212e-01f, 6.35816604e-02f, 1.22514300e-01f, 9.49052945e-02f, 8.57097358e-02f,
  4.87322137e-02f, 8.12598690e-03f, 1.37905637e-02f, 4.56288867e-02f, -1.12711750e-02f, 1.41322641e-02f, -6.03386164e-02f, -6.06546402e-02f, 7.06131458e-02f, 3.39480303e-02f,
  -6.84544072e-02f, -7.55317435e-02f, 3.49058420e-03f, 1.74353309e-02f, -1.41675035e-02f, -1.10155247e-01f, 7.02428073e-02f, -1.66941881e-02f, -8.14239383e-02f, -2.95581166e-02f,
  -7.33355992e-03f, -2.28807889e-03f, 1.06636450e-01f, -4.10813745e-03f, -5.14016449e-02f, -7.05263317e-02f, 1.15607247e-01f, 5.03203981e-02f, -1.08044460e-01f, -1.05199561e-01f,
  -1.51769053e-02f, 5.10159433e-02f, 1.02567717e-01f, 1.10627681e-01f, -4.75894697e-02f, 1.25915796e-01f, 2.51542404e-02f, -5.61025292e-02f, 1.52712107e-01f, 7.84140080e-03f,
  -1.24153942e-01f, 3.16199427e-03f, 3.44874114e-02f, 1.33151218e-01f, 1.88421458e-01f, -1.60012186e-01f, -5.44130728e-02f, -4.44097146e-02f, 6.61747856e-03f, -3.16562615e-02f,
  -1.62423506e-01f, 1.60893127e-02f, 1.62448347e-01f, 5.25141321e-02f, 1.56398728e-01f, -6.75532147e-02f, 5.04168011e-02f, -2.01497167e-01f, 2.25225598e-01f, -5.98580316e-02f,
  3.56580690e-03f, -4.30663116e-02f, -1.34311244e-01f, 1.23688567e-03f, 1.98289499e-01f, 1.02081791e-01f, 1.76366821e-01f, -1.24741755e-01f, 2.06675362e-02f, 1.18204981e-01f,
  2.32524633e-01f, 1.00361340e-01f, 1.35270834e-01f, 2.33460385e-02f, 1.04244672e-01f, 1.25961890e-02f, 1.33842781e-01f, -1.02720097e-01f, 1.45893782e-01f, 1.70450415e-02f,
  3.46059911e-02f, 1.55484349e-01f, -3.50622721e-02f, 4.35549840e-02f, -4.05651005e-03f, -1.51267305e-01f, 5.71551993e-02f, 8.29098932e-03f, -7.80849606e-02f, -1.02206632e-01f,
  -3.26634496e-02f, 8.36316869e-02f, -4.84552719e-02f, -2.53785290e-02f, -4.96567897e-02f, 1.31042615e-01f, -1.00144841e-01f, 3.52387875e-02f, 3.62478681e-02f, -4.59100977e-02f,
  5.27012609e-02f, -6.11666776e-02f, -1.11272395e-01f, -9.08921845e-03f, 1.00240663e-01f, 9.84696746e-02f, 2.82186419e-02f, 2.78965831e-01f, -4.07553650e-03f, 1.62044689e-01f,
  8.70265886e-02f, 7.61098191e-02f, 2.42638379e-01f, 9.52721089e-02f, 7.92518184e-02f, 2.74260924e-03f, -4.51146364e-02f, -1.67491183e-01f, 5.28154820e-02f, 1.30510822e-01f,
  -1.05246164e-01f, 1.40097573e-01f, 7.11171627e-02f, -1.81634441e-01f, -5.97355366e-02f, -8.39975476e-02f, -4.62328158e-02f, 2.68578026e-02f, -4.62472998e-02f, -3.87874432e-02f,
  5.75094367e-04f, 7.36013427e-02f, -1.35494890e-02f, -6.80050850e-02f, 1.33124396e-01f, 1.69282630e-01f, -1.03747211e-01f, 4.18530963e-02f, 2.43502438e-01f, 1.75622180e-01f,
  8.14067423e-02f, 4.26062346e-02f, -4.27805260e-02f, 1.16453446e-01f, -6.20530695e-02f, -1.27610210e-02f, 1.89495116e-01f, -2.53551044e-02f, -3.22279185e-02f, 1.78123057e-01f,
  -5.96317984e-02f, 7.61581063e-02f, 8.82542804e-02f, 1.34561449e-01f, -1.13528356e-01f, 3.77920866e-02f, 2.27135345e-01f, 2.11290270e-01f, 1.44427493e-01f, -4.86322418e-02f,
  8.72209016e-03f, 1.08298488e-01f, 3.90434414e-02f, -1.10885482e-02f, 2.92951856e-02f, 7.81834200e-02f, 1.31730614e-02f, 1.08236566e-01f, -8.45860019e-02f, -2.24378675e-01f,
  1.99737772e-02f, -2.25077465e-01f, 8.33722763e-03f, 1.23772509e-02f, 1.52678221e-01f, -1.65348664e-01f, -6.34321347e-02f, 9.94477049e-02f, 1.06042936e-01f, 9.19831470e-02f,
  1.65988673e-02f, 1.47949368e-01f, 6.23583160e-02f, 1.72576040e-01f, 1.01183765e-02f, 3.52474451e-02f, -1.41813293e-01f, 2.25223199e-01f, 2.74574727e-01f, 2.82191843e-01f,
  1.60215318e-01f, 2.49180719e-01f, 5.52733876e-02f, -2.97275409e-02f, -2.39876565e-02f, 1.22083217e-01f, 1.53677747e-01f, 4.29568850e-02f, -1.53857201e-01f, -1.53069034e-01f,
  1.51778474e-01f, 5.71380407e-02f, -1.17408857e-01f, -5.75130507e-02f, -1.73347313e-02f, 2.34374657e-01f, -6.96608946e-02f, -1.74121708e-01f, 9.62542519e-02f, -5.63072972e-02f,
  6.75998628e-02f, 4.73542139e-02f, 6.83735162e-02f, -4.69700806e-02f, 1.61038250e-01f, 8.23610127e-02f, 2.42971368e-02f, 1.02384947e-01f, 1.58414856e-01f, 9.18078423e-02f,
  -1.02834716e-01f, -8.72369036e-02f, 3.11714932e-02f, 4.45142761e-02f, 1.44213572e-01f, 1.15153939e-01f, -9.78903845e-04f, 4.12586629e-02f, 1.12937912e-01f, 6.00083321e-02f,
  -3.46493116e-03f, -5.81635945e-02f, -1.34419456e-01f, -1.68917626e-01f, 5.19575700e-02f, -3.27387154e-01f, 3.01523916e-02f, -7.01424945e-03f, 1.02278905e-03f, -5.06240986e-02f,
  -1.77701071e-01f, 2.44570926e-01f, 1.90144524e-01f, 1.99078888e-01f, -3.54336463e-02f, 2.35238105e-01f, 3.53062563e-02f, -7.88905099e-03f, -9.46263969e-03f, -1.09511718e-01f,
  -1.37767106e-01f, 1.45773053e-01f, 1.77173197e-01f, 4.52562124e-02f, 1.87906519e-01f, 1.34464890e-01f, 1.59537494e-01f, 1.19152486e-01f, 1.56299137e-02f, 9.30744410e-02f,
  -3.12545560e-02f, 1.32259220e-01f, -1.09130464e-01f, -8.02876949e-02f, 1.53591573e-01f, 5.90219982e-02f, -2.80518048e-02f, -7.75370970e-02f, 1.03576891e-01f, -3.03621963e-03f,
  5.83668984e-02f, -1.97488874e-01f, 9.60307792e-02f, -3.37477103e-02f, 3.41424420e-02f, -1.78420804e-02f, -4.41563055e-02f, -4.90494370e-02f, 2.32785359e-01f, 1.38540538e-02f,
  -4.34226170e-02f, -5.61552122e-02f, 1.52381673e-01f, 1.39112607e-01f, -4.73198108e-02f, -1.07286692e-01f, -2.48980410e-02f, 9.83581543e-02f, 9.31952521e-02f, 1.14604287e-01f,
  -2.51600277e-02f, 1.25679955e-01f, 8.60633701e-02f, -1.14620887e-01f, 1.01192825e-01f, -1.27399877e-01f, -1.60539150e-01f, -1.08684152e-01f, 6.34384975e-02f, -2.05586672e-01f,
  1.10849820e-01f, -1.70024633e-02f, -1.43588349e-01f, 5.12378849e-02f, -1.45888314e-01f, 1.24040261e-01f, 2.74492241e-02f, 1.64671302e-01f, 9.87810194e-02f, 5.07583935e-03f,
  1.23675667e-01f, 2.92425044e-02f, -1.56461317e-02f, -2.17255745e-02f, 5.03474697e-02f, 1.33039668e-01f, 5.68554327e-02f, 1.38610139e-01f, 3.05544436e-02f, 1.60706758e-01f,
  9.44866017e-02f, 9.76525471e-02f, 9.21220556e-02f, 3.91906314e-02f, 3.93676572e-02f, 3.25938836e-02f, -4.00577448e-02f, 7.09448755e-02f, 1.92827120e-01f, 1.42632335e-01f,
  -3.33457068e-02f, -7.96448886e-02f, 1.13696046e-01f, -1.00314543e-01f, -4.37716655e-02f, -2.59089395e-02f, 7.51667246e-02f, -1.03700906e-02f, 1.52717261e-02f, -6.08470328e-02f,
  -1.56153128e-01f, 5.06416038e-02f, 2.05150381e-01f, -9.79662240e-02f, -9.08561572e-02f, -9.06187221e-02f, 1.93091318e-01f, 5.03658280e-02f, -1.47411123e-01f, -1.76466212e-01f,
  3.25897560e-02f, 1.29769176e-01f, -1.04281016e-01f, 2.43945159e-02f, 9.29156542e-02f, -8.33875313e-03f, 4.33174483e-02f, -1.34534359e-01f, -3.99493128e-02f, -7.50470832e-02f,
  -5.22674508e-02f, -4.94297706e-02f, 2.02150837e-01f, 1.29478887e-01f, -5.97180054e-02f, 1.40883520e-01f, -1.54839158e-01f, -1.06029287e-01f, 1.17182553e-01f, -7.22849295e-02f,
  1.01061635e-01f, 1.90872177e-01f, 6.65303436e-04f, -2.48682961e-01f, 4.32519838e-02f, 1.10781938e-01f, -1.65746380e-02f, 1.51329771e-01f, 7.24105164e-02f, -1.38305891e-02f,
  1.81082934e-02f, 6.48544580e-02f, -1.14351466e-01f, 1.28157541e-01f, -8.41527432e-02f, 1.10142790e-01f, 1.17338233e-01f, -3.42135131e-02f, -2.16106186e-03f, -7.31512085e-02f,
  -9.36355591e-02f, -8.49996433e-02f, -3.53940427e-02f, 1.00391418e-01f, -3.95743400e-02f, -4.19085845e-03f, -6.75972365e-03f, 1.43697150e-02f, -6.50868937e-02f, 1.52260691e-01f,
  -2.46581882e-01f, -1.21765919e-01f, 8.11794400e-02f, -1.16042271e-01f, -7.14262128e-02f, 1.21874332e-01f, 8.55048522e-02f, -1.78137794e-01f, -4.96854074e-02f, 5.56172132e-02f,
  -7.45408610e-02f, 8.36713910e-02f, 2.34255806e-01f, -1.53321058e-01f, 1.77805126e-01f, 8.66805166e-02f, -2.43542623e-02f, 7.62067065e-02f, 9.41275060e-02f, -1.17617205e-03f,
  6.64982572e-02f, 1.11031272e-01f, 2.44696066e-02f, 4.69847070e-03f, 1.02723919e-01f, -6.91253915e-02f, -7.82988500e-03f, -1.65700525e-01f, 4.38111164e-02f, 1.97835535e-01f,
  8.89803991e-02f, 1.02906905e-01f, 2.04491266e-03f, 1.71165064e-01f, 1.64683670e-01f, 2.28691474e-01f, -1.77580670e-01f, 1.53417543e-01f, 2.25872975e-02f, 2.72072226e-01f,
  -1.29619181e-01f, 6.91948980e-02f, -1.63562894e-01f, 4.79598232e-02f, 4.37759608e-02f, -6.81241509e-03f, 4.34708782e-02f, -2.16417257e-02f, 3.22509781e-02f, -1.09268099e-01f,
  -1.40300378e-01f, 3.88957672e-02f, 1.13171488e-01f, 4.35269512e-02f, -7.82910585e-02f, -2.23832726e-02f, -8.08647797e-02f, -3.72685096e-03f, 1.44651055e-01f, 1.32278904e-01f,
  -2.09972765e-02f, 2.22783964e-02f, -7.36933127e-02f, -1.11221917e-01f, 3.57774757e-02f, -1.32128503e-02f, 1.58689976e-01f, -2.26086657e-02f, 1.66772887e-01f, 1.12175316e-01f,
  8.10236484e-02f, 4.24581766e-02f, -6.32358762e-03f, 1.98274761e-01f, 1.40498757e-01f, 2.54258309e-02f, 5.19389771e-02f, 5.63324355e-02f, 7.79771283e-02f, -1.05603941e-01f,
  -5.51287420e-02f, -2.65913066e-02f, -6.10230602e-02f, 2.21556444e-02f, -2.29988210e-02f, -7.35175470e-03f, 2.93600876e-02f, 1.00401357e-01f, 3.41401924e-03f, -1.78597737e-02f,
  9.41136107e-03f, 2.40299851e-01f, 7.05930665e-02f, -2.10536253e-02f, 1.30362317e-01f, 5.36022410e-02f, 1.83935210e-01f, -1.36490926e-01f, -6.81984127e-02f, 6.82088584e-02f,
  4.92063053e-02f, -7.94431120e-02f, 1.11232270e-02f, 1.07727528e-01f, -8.43186155e-02f, 8.98006335e-02f, 1.32063642e-01f, -5.89622855e-02f, 2.96972729e-02f, -2.61612181e-02f,
  -8.23948234e-02f, 7.22520938e-03f, 3.75973359e-02f, 7.31360912e-02f, 6.84246793e-02f, -6.38892949e-02f, 8.27265829e-02f, 3.98346335e-02f, 9.75894034e-02f, 1.06714375e-01f,
  -6.96549308e-04f, -6.78797290e-02f, 9.97370258e-02f, 7.99361616e-03f, 6.43111318e-02f, 3.69095020e-02f, 6.02910034e-02f, 9.29982513e-02f, 3.07886563e-02f, 1.29489779e-01f,
  1.11660048e-01f, 4.99011353e-02f, -6.05213572e-04f, -1.96410753e-02f, -1.67501122e-02f, 1.24924602e-02f, 3.25312205e-02f, 1.55499160e-01f, -1.03334181e-01f, -3.62964459e-02f,
  1.31830186e-01f, 1.23066969e-01f, 3.83296534e-02f, 3.57056409e-02f, 4.60909121e-02f, 1.19237294e-02f, 4.35355231e-02f, 1.06581256e-01f, 4.14834432e-02f, -4.06128401e-03f,
  1.57309517e-01f, -1.10516928e-01f, -6.88314065e-02f, 7.10869655e-02f, 4.59068082e-02f, -2.31690649e-02f, 1.31664425e-01f, 4.57974970e-02f, -8.72125998e-02f, 6.28476962e-02f,
  3.92936654e-02f, 9.35620889e-02f, 4.87592816e-02f, 5.06910980e-02f, 7.65154436e-02f, 3.04377265e-02f, 8.23623314e-02f, 4.72729132e-02f, 3.97470482e-02f, -1.88126951e-03f,
  1.04554474e-01f, -1.74480174e-02f, 5.03566116e-02f, -2.14813799e-02f, -3.36632021e-02f, 2.46758740e-02f, 9.11130086e-02f, 8.23718384e-02f, 9.93945673e-02f, -3.54268365e-02f,
  -1.14622153e-01f, 1.00051932e-01f, 9.52080637e-02f, 9.38367248e-02f, 7.81825110e-02f, 5.92525005e-02f, 7.27254525e-02f, 2.91564185e-02f, 1.00152686e-01f, -1.65568441e-02f,
  2.78628841e-02f, 4.88236286e-02f, 9.66411531e-02f, 5.60377724e-02f, 1.98288746e-02f, 1.77059714e-02f, -9.84975025e-02f, 7.30244294e-02f, 7.12538585e-02f, -3.85860838e-02f,
  2.47208085e-02f, -3.40318680e-02f, 7.14795962e-02f, 3.63003872e-02f, -2.96330894e-04f, 4.63448912e-02f, 1.18722975e-01f, 8.58902112e-02f, 9.75063071e-02f, 3.42296548e-02f,
  3.51118930e-02f, 6.69316500e-02f, 1.29590467e-01f, -2.92822570e-02f, -2.79848240e-02f, -1.22698873e-01f, -1.72587082e-01f, 1.20356977e-01f, 1.66113511e-01f, 9.77884084e-02f,
  1.90727189e-02f, -8.07766169e-02f, -1.52970120e-01f, 3.73956412e-02f, 1.39801428e-01f, -1.04004368e-01f, -1.40697524e-01f, -1.92219368e-03f, 2.43187383e-01f, -7.89267197e-03f,
  6.05995432e-02f, -1.18921630e-01f, 2.15517074e-01f, -4.85284515e-02f, 1.77925244e-01f, -7.88647607e-02f, -1.25925150e-02f, -1.99983846e-02f, -1.01159833e-01f, 6.23680018e-02f,
  1.31829577e-02f, 1.91829965e-01f, 1.44118503e-01f, -8.78066197e-02f, -1.14703715e-01f, 1.02722488e-01f, 2.24733621e-01f, 7.37390965e-02f, 6.53953329e-02f, 3.51528861e-02f,
  3.43387350e-02f, -4.42586802e-02f, 1.69270813e-01f, -1.19455084e-01f, 4.70490456e-02f, 2.24561155e-01f, 3.50954221e-03f, 5.28227389e-02f, -1.60837233e-01f, -2.47595105e-02f,
  -2.28498206e-01f, 7.31907785e-02f, -1.11009255e-01f, -5.15523888e-02f, -6.75073871e-03f, -1.50876433e-01f, 3.32492888e-02f, -3.92019153e-02f, 1.67692304e-02f, 1.76829435e-02f,
  8.92260969e-02f, 1.98291242e-01f, 1.13569051e-01f, 6.69822395e-02f, 9.37676243e-03f, 1.63518578e-01f, -4.51750401e-03f, -8.41674209e-02f, 2.27417350e-01f, 5.93281235e-04f,
  -2.02988803e-01f, -3.27662826e-02f, 6.16223179e-02f, -5.58494404e-02f, 1.37390733e-01f, -3.76378372e-02f, 2.92382911e-02f, -1.61734025e-03f, -6.91403598e-02f, 1.15741588e-01f,
  -2.30774079e-02f, 2.44253073e-02f, 4.43286635e-02f, -5.44250198e-02f, 9.12260339e-02f, -6.21211268e-02f, -6.72748536e-02f, -7.55213052e-02f, 1.45782292e-01f, 4.01948392e-02f,
  -3.13664414e-02f, -2.60916390e-02f, -1.90201670e-01f, 1.29827783e-01f, 1.45086765e-01f, 2.03575075e-01f, 1.53811499e-01f, -6.20822795e-02f, 7.74601772e-02f, 2.31614321e-01f,
  1.90146446e-01f, 1.04678363e-01f, 2.39108726e-01f, 4.28417213e-02f, 1.53639197e-01f, -7.81540349e-02f, 1.35253608e-01f, -6.45160228e-02f, 2.99427435e-02f, -4.07924168e-02f,
  1.00301094e-01f, 1.30417943e-01f, -2.72990181e-03f, -7.35735800e-03f, -1.08433142e-01f, -4.47003655e-02f, 1.82773843e-02f, -1.89452264e-02f, -2.16128472e-02f, -5.23212887e-02f,
  -4.99059353e-03f, 5.92571776e-03f, -1.75546095e-01f, -5.93556203e-02f, 1.64607465e-01f, 6.21330030e-02f, -1.13458782e-01f, 2.23978460e-02f, -1.39454929e-02f, -1.25955015e-01f,
  -3.62144224e-03f, -8.63144547e-02f, -7.57689625e-02f, 7.60181025e-02f, 6.66921139e-02f, -2.31050789e-01f, 2.97091976e-02f, -1.48727879e-01f, -1.27259135e-01f, 3.73276100e-02f,
  1.45219401e-01f, -4.11694050e-02f, -2.26365011e-02f, 8.73526335e-02f, 1.63617074e-01f, -6.49268106e-02f, -8.55531916e-02f, -3.54406238e-02f, 1.12938704e-02f, 3.86762694e-02f,
  1.07644759e-02f, 4.60300371e-02f, -5.35274856e-02f, 1.08066969e-01f, 1.41533181e-01f, 5.13715073e-02f, 5.01696616e-02f, 3.15141566e-02f, -1.32357761e-01f, -6.02491535e-02f,
  -5.76336570e-02f, 2.88729779e-02f, 4.57381532e-02f, -2.04922378e-01f, -1.40517175e-01f, -1.31201044e-01f, -2.78138909e-02f, 2.95190811e-02f, -1.05540760e-01f, -7.17187151e-02f,
  -1.98418677e-01f, 1.60405800e-01f, -6.72451314e-03f, -1.11566029e-01f, -1.22264326e-01f, -1.36067092e-01f, 7.23012015e-02f, -3.83412056e-02f, 1.49524823e-01f, 1.49808107e-02f,
  6.53505996e-02f, 1.32787852e-02f, 1.41022012e-01f, 9.23858583e-03f, -4.76409271e-02f, 9.84391570e-02f, 7.05038682e-02f, 1.58611368e-02f, -5.63878305e-02f, -5.07164188e-02f,
  1.55769855e-01f, 5.03499247e-02f, -8.93504918e-02f, 1.03891283e-01f, 1.06108159e-01f, 1.05331309e-01f, 1.09915793e-01f, 6.45645410e-02f, -1.67688861e-01f, 4.97502834e-02f,
  -5.84087744e-02f, -1.26486003e-01f, 1.69852525e-01f, -1.43892109e-01f, 1.85131505e-01f, 1.35660395e-01f, -3.90635133e-02f, 4.02414948e-02f, -1.49084300e-01f, -3.97511572e-02f,
  8.13328773e-02f, 1.42401010e-01f, -1.10501997e-01f, -5.45373149e-02f, 8.20744038e-02f, -2.02948555e-01f, 4.30787988e-02f, 1.02717780e-01f, 5.50356433e-02f, -5.88799752e-02f,
  -3.06560863e-02f, -4.38111281e-04f, 1.83143795e-01f, 2.24703774e-02f, 1.86362818e-01f, 2.69076563e-02f, 9.75555032e-02f, 1.32882848e-01f, 1.71551481e-01f, 1.21144637e-01f,
  1.40586048e-01f, -9.67758372e-02f, 1.77365780e-01f, 3.46898887e-04f, 1.86678499e-01f, -3.59814777e-03f, 1.68623939e-01f, -1.53612077e-01f, 2.39562646e-01f, 2.17632145e-01f,
  -2.86046527e-02f, 1.45288959e-01f, -2.63713319e-02f, -8.33101198e-02f, 1.34457216e-01f, 3.37562971e-02f, -8.46517235e-02f, 1.22576449e-02f, 1.71955362e-01f, 3.91989425e-02f,
  -1.50692523e-01f, -2.49931887e-02f, 7.51302689e-02f, 1.53422281e-01f, -9.90084857e-02f, 8.66218805e-02f, -1.12645701e-03f, 1.58235803e-02f, 8.59979913e-03f, -1.79739386e-01f,
  5.21961153e-02f, -9.03079490e-05f, -1.00402944e-01f, -5.40665351e-02f, 1.26918450e-01f, 6.45848736e-02f, 4.85441424e-02f, 1.60177529e-01f, -7.65688345e-02f, -4.00314257e-02f,
  3.60231064e-02f, 2.80744266e-02f, 1.42946877e-02f, 1.74459338e-01f, 7.14322478e-02f, -1.25187844e-01f, 1.13818340e-01f, 1.54557467e-01f, -8.23157355e-02f, 7.42690191e-02f,
  1.14514008e-01f, 3.28516285e-03f, 7.66817182e-02f, -2.77520716e-02f, -2.54402477e-02f, 5.63954115e-02f, 5.85384741e-02f, 1.67200878e-01f, 7.64215365e-02f, -3.40086110e-02f,
  2.38387827e-02f, 2.56211739e-02f, -1.21353967e-02f, 5.50600998e-02f, 1.17493071e-01f, 1.45254403e-01f, 1.87310169e-03f, -1.15584195e-01f, -1.27475075e-02f, 1.87280048e-02f,
  -4.57072780e-02f, 1.33770585e-01f, -1.51437104e-01f, -1.19465115e-02f, 1.19201504e-01f, -2.17179041e-02f, -1.30519107e-01f, 4.17365395e-02f, -6.23421371e-03f, -1.13088317e-01f,
  -2.35587042e-02f, 3.00435256e-02f, -5.51450551e-02f, 1.13318175e-01f, 1.57093048e-01f, -9.61849466e-02f, 7.97070861e-02f, 7.61006474e-02f, 6.17318638e-02f, -1.03150895e-02f,
  8.10316205e-02f, 4.96223345e-02f, 9.13993642e-02f, -4.41073105e-02f, -2.58401758e-03f, -2.39631534e-01f, -1.47100901e-02f, 1.46193802e-01f, 3.26153748e-02f, -2.20721383e-02f,
  -3.76145244e-02f, 9.76174250e-02f, -1.66874915e-01f, 1.28994972e-01f, 4.35099415e-02f, -2.25567236e-03f, 6.54917657e-02f, -4.85018920e-03f, -3.98683846e-02f, 2.81331111e-02f,
  1.14231899e-01f, 8.64758268e-02f, 7.38519281e-02f, 1.15916915e-02f, 2.84119826e-02f, -6.43246397e-02f, -2.61925608e-01f, -1.99153423e-02f, 6.87242951e-03f, -6.84337318e-02f,
  -2.63400935e-02f, -7.09024444e-02f, 2.66435314e-02f, -4.72536590e-03f, -1.12775363e-01f, 1.19644657e-01f, 3.68377455e-02f, 1.07758731e-01f, 4.36291993e-02f, -2.99657024e-02f,
  4.01487499e-02f, 1.34314418e-01f, 3.49998474e-02f, -2.25844428e-01f, -3.67527977e-02f, 9.85639319e-02f, 9.67841223e-02f, -3.84006351e-02f, -1.18866257e-01f, -1.30998746e-01f,
  -1.42334970e-02f, 8.34360942e-02f, -6.62844554e-02f, 1.28421128e-01f, 6.27843291e-02f, -1.13104954e-01f, 3.12788747e-02f, 6.33152351e-02f, -4.11584489e-02f, 4.44064625e-02f,
  2.15856776e-01f, 3.18902172e-02f, 6.67267367e-02f, -1.96586270e-02f, -2.63295509e-02f, 2.25623921e-02f, 8.54500905e-02f, 1.68230072e-01f, -3.45218815e-02f, 2.51109693e-02f,
  8.59369710e-02f, -2.64359470e-02f, -1.21233501e-01f, -1.37484968e-01f, 2.18313448e-02f, 6.73473533e-03f, 1.72681496e-01f, 5.19017391e-02f, -1.07169807e-01f, 1.90404922e-01f,
  9.51409340e-02f, 3.49367969e-02f, -6.35893643e-03f, 2.94426203e-01f, -1.22205943e-01f, 3.18809226e-02f, -4.09860164e-02f, -8.62946287e-02f, -1.43843159e-01f, 1.71456113e-01f,
  6.34973645e-02f, 8.66266787e-02f, 1.94966659e-01f, -1.05930017e-02f, 5.82366548e-02f, -1.31169427e-02f, -1.08269997e-01f, 9.96251628e-02f, 5.31663038e-02f, -1.03473971e-02f,
  -6.97602779e-02f, -1.75590217e-02f, -1.12256683e-01f, -8.90621170e-02f, 8.29574987e-02f, 4.93559092e-02f, 2.84603890e-02f, 5.15624806e-02f, 4.11887765e-02f, -1.18443228e-01f,
  1.67889938e-01f, 3.10659353e-02f, -6.89730421e-03f, 6.60100952e-02f, 2.37283707e-01f, -5.02718100e-03f, 1.87077746e-01f, 1.20344773e-01f, -1.69121362e-02f, 3.21163982e-02f,
  2.18860388e-01f, 1.98362470e-02f, 7.84224644e-03f, 4.78448384e-02f, -4.88063730e-02f, -4.47896831e-02f, 6.05632924e-02f, 5.69766574e-02f, 5.81991263e-02f, 9.25070494e-02f,
  7.10057020e-02f, 7.92158470e-02f, 6.26550913e-02f, -4.58895899e-02f, -3.32417563e-02f, 1.56790465e-01f, -1.42122665e-02f, 2.18865007e-01f, 6.04569465e-02f, -1.22785963e-01f,
  1.04789343e-02f, 1.75008878e-01f, 1.88269764e-01f, -8.18369687e-02f, -1.16670206e-01f, 3.96507643e-02f, 1.44554406e-01f, 5.54019250e-02f, 4.64038849e-02f, 3.90938856e-02f,
  2.85788253e-02f, -1.01539381e-01f, 2.02272713e-01f, -1.63440168e-01f, -5.38517050e-02f, -9.91379097e-02f, -1.06824532e-01f, -5.96342310e-02f, 3.23479697e-02f, 1.19067185e-01f,
  1.67450115e-01f, 4.69244942e-02f, -2.77913157e-02f, 1.78071305e-01f, 2.03101829e-01f, 1.81979284e-01f, 1.89901106e-02f, -8.64135996e-02f, 1.05490968e-01f, 8.09900016e-02f,
  5.94840124e-02f, -1.26167580e-01f, 9.42704603e-02f, 1.01194717e-01f, 1.32715464e-01f, 1.50590047e-01f, 2.34192014e-02f, 2.29193661e-02f, -7.53964558e-02f, 1.06264859e-01f,
  5.05697317e-02f, 2.24984474e-02f, 7.52511322e-02f, 2.79005792e-04f, 5.38793728e-02f, 2.86914539e-02f, -2.04911027e-02f, 1.29640073e-01f, 1.45583093e-01f, 1.37147263e-01f,
  4.10902537e-02f, -3.65158580e-02f, 7.04667941e-02f, -6.06820621e-02f, -3.47337611e-02f, 1.11971736e-01f, -1.20404936e-01f, -2.55209226e-02f, 7.79063851e-02f, -1.44557292e-02f,
  -1.03046291e-01f, -8.73458087e-02f, -1.31054610e-01f, 4.51561622e-03f, 3.46156247e-02f, 2.16921773e-02f, -2.08297335e-02f, 1.45988360e-01f, 3.80423740e-02f, -8.18856582e-02f,
  -3.84932337e-03f, 1.03357360e-01f, 2.86908709e-02f, -5.19783609e-02f, 8.73033404e-02f, -2.50840317e-02f, -1.03277594e-01f, 5.07874079e-02f, 5.80207333e-02f, 1.52370274e-01f,
  1.84395626e-01f, 4.56680581e-02f, -7.50346705e-02f, -1.00702196e-01f, -3.96606401e-02f, 1.86017767e-01f, -4.25523259e-02f, 6.53646514e-03f, -2.28195451e-02f, -6.10298291e-02f,
  -6.26459271e-02f, 6.14383258e-02f, 2.22372971e-02f, 1.49044082e-01f, -8.81478861e-02f, 2.51876805e-02f, 6.24184348e-02f, -1.74602494e-02f, 6.00441508e-02f, -1.27642348e-01f,
  -8.32047760e-02f, -5.03719449e-02f, 1.34798184e-01f, 1.32486537e-01f, 5.47482632e-02f, 3.78416330e-02f, 7.06708804e-02f, -2.60046567e-03f, 5.04490808e-02f, 5.14555760e-02f,
  -5.04084155e-02f, 6.24909922e-02f, -9.53462496e-02f, -5.97807355e-02f, -8.58252719e-02f, -1.97008997e-02f, 4.94893547e-03f, -1.39808029e-01f, -1.13390828e-03f, 8.73961300e-02f,
  -9.32591558e-02f, 2.39469141e-01f, 2.28727958e-03f, -2.25508362e-01f, -3.45390476e-02f, 2.19367400e-01f, -8.65679681e-02f, -5.99581078e-02f, 1.22275196e-01f, -1.71818346e-01f,
  8.64475369e-02f, -1.90763056e-01f, -1.43225526e-03f, -2.74961051e-02f, 1.11912191e-01f, 1.11648336e-01f, -1.69929519e-01f, -4.37587686e-02f, 1.29986286e-01f, 1.90931603e-01f,
  9.35394615e-02f, 8.87847617e-02f, 1.64284170e-01f, 1.10339880e-01f, 1.42717525e-01f, 1.92571878e-01f, -5.57116419e-02f, -6.06349553e-04f, 1.18530922e-01f, 8.11563358e-02f,
  2.10791063e-02f, -1.14975840e-01f, 3.55139375e-02f, -3.60048227e-02f, -1.07957218e-02f, -3.30632101e-05f, -2.50527054e-01f, 6.40233560e-03f, -1.12252012e-01f, 2.89212286e-01f,
  6.19358830e-02f, 1.31034687e-01f, 1.16685346e-01f, -3.11173201e-02f, -5.93218133e-02f, 8.37814808e-02f, 1.94321275e-01f, -8.13636407e-02f, -1.63463894e-02f, 8.92748460e-02f,
  1.52817369e-01f, 1.70195147e-01f, -2.98346002e-02f, 1.24889344e-03f, 3.61618958e-02f, -1.74607467e-02f, -1.89089298e-01f, 9.16576982e-02f, 3.58800963e-02f, -4.10455018e-02f,
  1.98498555e-02f, 3.64044048e-02f, -1.69907995e-02f, 2.98917685e-02f, -5.58923073e-02f, -3.35660651e-02f, 6.81209862e-02f, 1.56772956e-01f, -3.03669907e-02f, 1.50121197e-01f,
  5.10291606e-02f, -2.26355083e-02f, 5.47339208e-02f, 1.77510917e-01f, 5.17270155e-02f, 4.08033878e-02f, -3.84289399e-02f, -1.54283911e-01f, 1.34005509e-02f, -1.28577827e-02f,
  -2.48149689e-03f, -1.29706576e-01f, 1.09336600e-01f, -5.74784502e-02f, 1.33712977e-01f, -6.08819462e-02f, -1.99677557e-01f, -1.20042376e-01f, -4.78998385e-02f, -1.24103539e-01f,
  2.63264161e-02f, 1.04552194e-01f, 1.12670071e-01f, -1.76162459e-02f, -6.66261092e-02f, 1.43617811e-02f, 2.10226074e-01f, 1.21119715e-01f, -7.66540840e-02f, -7.79808760e-02f,
  6.08154088e-02f, 1.59658879e-01f, 1.61008462e-01f, -6.09966181e-02f, 1.16234586e-01f, 8.99878219e-02f, 1.37746632e-01f, 1.09500170e-01f, -3.34244743e-02f, 1.10098176e-01f,
  2.72122957e-02f, 8.06831270e-02f, -1.15408726e-01f, 2.76354793e-02f, 1.56525448e-02f, -8.72992445e-03f, 3.99855301e-02f, -6.78173602e-02f, 4.79926728e-02f, 1.51662990e-01f,
  2.09560823e-02f, 7.16350749e-02f, 1.07506707e-01f, 1.60222396e-01f, 3.21023073e-03f, 1.77177951e-01f, 1.00220971e-01f, 4.46076952e-02f, -6.00836333e-03f, -1.37995794e-01f,
  -9.29166451e-02f, 5.90415113e-03f, -5.33407256e-02f, -3.71233135e-01f, -5.44816777e-02f, -2.87247635e-02f, -7.12906793e-02f, 7.70459101e-02f, -2.08149642e-01f, 2.01214179e-01f,
  1.60200626e-01f, 1.00338638e-01f, -1.08872898e-01f, 2.14736909e-01f, 2.07535073e-01f, 1.40026035e-02f, 1.20134383e-01f, -1.34061977e-01f, -1.04943596e-01f, 1.02743335e-01f,
  -7.56627768e-02f, 2.07122788e-01f, 1.66433051e-01f, 3.44909192e-03f, 4.53242660e-02f, -8.11094046e-02f, 2.35819141e-03f, 9.50013697e-02f, -7.35887662e-02f, 5.00318334e-02f,
  -1.09038770e-01f, -7.52553567e-02f, 9.81525630e-02f, -4.09100857e-03f, 1.12872273e-01f, -1.45048490e-02f, 2.58632824e-02f, -2.00162649e-01f, -4.13536429e-02f, -1.84712008e-01f,
  1.12416357e-01f, -8.35880041e-02f, -8.54766667e-02f, -1.44013390e-01f, 1.13369729e-02f, 2.09037200e-01f, 1.25087738e-01f, 1.44854337e-01f, -1.19686522e-01f, -1.69311881e-01f,
  1.47466421e-01f, 1.18043639e-01f, -1.57946870e-01f, -1.40339127e-02f, 1.32697374e-01f, 9.06635523e-02f, 7.07331970e-02f, 5.73986918e-02f, 6.09088056e-02f, 1.56351086e-02f,
  -8.31765216e-03f, 1.15490869e-01f, -2.94413120e-02f, 7.32361823e-02f, -5.42131364e-02f, 8.06392543e-03f, -3.96670550e-02f, 1.20618165e-01f, -1.01447785e-02f, -1.19918667e-01f,
  9.33654308e-02f, -4.96370159e-03f, 6.36603311e-02f, -1.35628730e-01f, -1.30919099e-01f, -1.32055670e-01f, 1.71055228e-01f, 1.47596642e-01f, -8.70376527e-02f, -1.15028150e-01f,
  7.90291056e-02f, -3.50961462e-02f, 1.05301209e-01f, 5.21421991e-02f, 6.06680475e-02f, 4.57895622e-02f, -1.22006722e-01f, -1.10704184e-03f, 1.48806944e-02f, 1.97416618e-01f,
  1.30942971e-01f, 5.98545000e-02f, 8.71695857e-03f, 8.90397504e-02f, 1.86675653e-01f, 1.21563382e-01f, 9.53415036e-02f, -7.70543739e-02f, -1.03683352e-01f, -5.48171327e-02f,
  5.61709478e-02f, 9.69896242e-02f, 1.98012263e-01f, 7.04949126e-02f, 5.96020073e-02f, 2.32383803e-01f, 4.70636354e-04f, 1.29769325e-01f, -8.52258950e-02f, -1.65134713e-01f,
  -7.22642839e-02f, -1.95352361e-02f, 4.40046517e-03f, 8.01598355e-02f, 3.65813375e-02f, 4.36617583e-02f, -5.91174467e-03f, -3.39003392e-02f, -9.76825133e-02f, 1.77664831e-01f,
  -6.50707483e-02f, -9.79099981e-03f, 7.01847672e-02f, 5.95172383e-02f, -4.25532348e-02f, 1.01865098e-01f, -6.58119842e-02f, 1.30649403e-01f, 1.35056823e-01f, 9.57850739e-02f,
  -2.69567370e-02f, 1.65844157e-01f, -2.44504400e-02f, 2.01156929e-01f, 1.04345016e-01f, 2.34500051e-01f, 1.07910097e-01f, -2.79590841e-02f, 3.91706862e-02f, 1.74899533e-01f,
  -1.88534349e-01f, -6.81243837e-02f, -8.71018097e-02f, 2.71664709e-01f, -2.49822721e-01f, 2.36813307e-01f, -8.08772445e-02f, -1.39083996e-01f, -8.75857696e-02f, -4.87626828e-02f,
  -8.99922922e-02f, -6.33667633e-02f, -2.98634265e-02f, -1.67518675e-01f, -2.05773890e-01f, 7.53943548e-02f, 8.95477012e-02f, 7.87453651e-02f, -4.51917648e-02f, 1.47125283e-02f,
  -1.64410397e-01f, -4.09420468e-02f, 1.90905586e-01f, 1.42801300e-01f, -7.75663406e-02f, 9.39521566e-02f, 9.21531320e-02f, 1.20861717e-01f, -1.16794482e-01f, -6.38664141e-02f,
  2.12396964e-01f, -6.84244093e-03f, 8.40081200e-02f, 1.96303904e-01f, 3.86330225e-02f, 7.54778683e-02f, 9.17500556e-02f, 1.30829275e-01f, -1.00947134e-01f, -3.42418067e-03f,
  2.61200339e-01f, 9.48757827e-02f, 1.51169002e-01f, -1.58290952e-01f, 8.16508308e-02f, 6.77406266e-02f, 7.02895001e-02f, 1.24641933e-01f, 1.27143681e-01f, 1.05712987e-01f,
  2.92414464e-02f, -5.76634482e-02f, -1.03751987e-01f, 3.07261776e-02f, -3.72473411e-02f, -3.19855601e-01f, 6.49720570e-03f, -6.17777593e-02f, -5.06867655e-02f, 1.20208748e-01f,
  -1.46936759e-01f, 4.35223170e-02f, 8.53004903e-02f, 4.85685579e-02f, -4.39370945e-02f, 1.40556812e-01f, -2.09099967e-02f, 3.79541181e-02f, 6.00384958e-02f, -2.03538179e-01f,
  -1.29272923e-01f, 1.53611735e-01f, -6.52077720e-02f, 1.36070669e-01f, 1.84265822e-01f, 1.89859793e-02f, 1.31731287e-01f, -8.23444426e-02f, -5.27020805e-02f, -1.59727465e-02f,
  -6.33550659e-02f, 1.14850223e-01f, -9.42845792e-02f, -2.29194481e-02f, 2.72166040e-02f, 9.26144887e-03f, 5.45987953e-03f, 4.26890999e-02f, 1.00193426e-01f, -1.23884179e-01f,
  -2.67636236e-02f, -1.77647457e-01f, 1.22226320e-01f, -9.45703834e-02f, -4.74180877e-02f, -9.48120803e-02f, -4.25506569e-02f, 1.25228181e-01f, 1.23330481e-01f, 1.41950503e-01f,
  -3.42961475e-02f, -6.52696416e-02f, 8.98268670e-02f, -3.61982587e-04f, -2.36491218e-01f, -4.84923124e-02f, 4.64430042e-02f, 6.69063330e-02f, -5.44103682e-02f, -1.89538021e-02f,
  8.52772519e-02f, -4.20696512e-02f, 2.02782750e-02f, -4.06868719e-02f, -9.11665186e-02f, -7.74691775e-02f, -2.83005368e-02f, 5.17609622e-03f, 9.92720798e-02f, 5.59598729e-02f,
  -4.05161902e-02f, 9.56119150e-02f, -1.64721720e-02f, -8.40119869e-02f, -3.92801315e-02f, -5.59085533e-02f, 5.76509237e-02f, 2.56263558e-02f, 1.38296515e-01f, -8.92923921e-02f,
  1.72898844e-01f, 5.70272580e-02f, 1.35764107e-01f, 1.48436680e-01f, 7.24920779e-02f, 2.53417678e-02f, 9.43745822e-02f, 1.84381977e-01f, 1.11225680e-01f, 2.03938484e-01f,
  -8.81380364e-02f, 1.35059386e-01f, 8.47982541e-02f, 6.61490709e-02f, 8.84082075e-03f, -5.77507168e-02f, 1.62696410e-02f, -1.37524400e-02f, 1.51523259e-02f, 1.94219068e-01f,
  -1.15219265e-01f, 4.29673195e-02f, -4.28442247e-02f, -1.20742489e-02f, -4.42112312e-02f, 1.68258339e-01f, -5.37654310e-02f, -1.04394697e-01f, -5.66849671e-02f, -4.19751182e-02f,
  -2.16599042e-03f, 3.47391218e-02f, -5.32000884e-02f, -9.96523071e-04f, -3.55288237e-02f, -5.04861996e-02f, -3.30937319e-02f, 7.37654567e-02f, 4.10083607e-02f, -8.66165087e-02f,
  9.14642140e-02f, 5.87300286e-02f, 9.56339911e-02f, -5.45654399e-03f, -1.98379625e-02f, 2.07385886e-02f, 5.26319146e-02f, 8.44074190e-02f, 8.08723420e-02f, 1.10170692e-01f,
  5.89843355e-02f, 2.71153618e-02f, -1.75574020e-01f, -1.66180953e-02f, 7.38329217e-02f, -1.32277980e-01f, 2.04556331e-01f, 2.01504424e-01f, -3.90249789e-02f, -3.99088264e-02f,
  -1.01784490e-01f, -8.64461884e-02f, -3.23573016e-02f, 2.23137319e-01f, -6.16179667e-02f, 3.19837965e-02f, -2.68210173e-02f, -1.13835067e-01f, -3.69260833e-02f, -5.17165810e-02f,
  -1.47172436e-02f, -2.58135702e-02f, 5.47927469e-02f, -7.22811073e-02f, 1.52464032e-01f, 1.41079035e-02f, -4.45216112e-02f, 6.64591268e-02f, 1.18376993e-01f, 1.76903203e-01f,
  6.73737451e-02f, 1.23443484e-01f, -1.90641191e-02f, -8.49701315e-02f, 2.00186267e-01f, 2.11412665e-02f, 8.27969387e-02f, 4.29552309e-02f, 1.84600487e-01f, -1.78347051e-01f,
  7.11473450e-02f, 1.77429244e-01f, 4.50265110e-02f, 8.57754573e-02f, 1.91093594e-01f, -7.32178912e-02f, 1.50814623e-01f, 1.46392301e-01f, 6.94627836e-02f, 1.44832432e-01f,
  -2.18010321e-02f, -1.14489585e-01f, -1.55179307e-01f, 1.37989089e-01f, 7.33409077e-02f, 5.84352128e-02f, 4.27072421e-02f, 5.94000630e-02f, -2.57138293e-02f, 9.64694843e-02f,
  1.52622880e-02f, -1.36497930e-01f, 1.10866606e-01f, -7.97146037e-02f, -1.70825839e-01f, -8.09463300e-03f, 1.04353905e-01f, -6.14682958e-02f, 1.10396869e-01f, 3.46925482e-02f,
  -1.30453974e-01f, 1.59623269e-02f, -2.14825813e-02f, 3.22493501e-02f, -1.13100605e-03f, 9.14148167e-02f, 1.09864488e-01f, -5.85095212e-02f, 1.37795389e-01f, 1.22104045e-02f,
  -3.98669217e-04f, -9.85936671e-02f, 1.07154272e-01f, -9.98667534e-03f, -1.85821708e-02f, -7.46301282e-03f, -1.08652256e-01f, 7.98058789e-03f, 1.13728471e-01f, 9.23041999e-02f,
  1.32660985e-01f, -8.29525590e-02f, -3.82977724e-02f, 1.08987458e-01f, 6.90799057e-02f, 6.77774847e-02f, 1.44209653e-01f, 8.06524009e-02f, 5.18622100e-02f, -8.42486918e-02f,
  1.30990431e-01f, -1.29195228e-01f, 7.72328163e-03f, 4.56466898e-02f, 2.77785789e-02f, 4.44407389e-02f, -1.18274661e-02f, -7.50801265e-02f, -1.60001576e-01f, 4.72724065e-02f,
  1.03111453e-01f, -2.48675160e-02f, -5.44174388e-02f, -6.32976964e-02f, 3.74681018e-02f, 9.54371840e-02f, -3.94802280e-02f, -4.34064195e-02f, 1.23346627e-01f, 1.29560292e-01f,
  -6.35381043e-02f, -3.04244887e-02f, -4.32201810e-02f, -5.32120280e-02f, -3.02147269e-02f, 6.21680208e-02f, -2.00852030e-03f, 1.86302975e-01f, 5.63070029e-02f, -1.39947012e-01f,
  -7.53750056e-02f, 1.13882355e-01f, -5.91217121e-03f, -1.24387182e-02f, 1.52050510e-01f, -3.65241170e-02f, 2.59054359e-02f, -1.36853173e-01f, -5.13581410e-02f, 1.88838597e-03f,
  -6.02977024e-03f, 1.21352054e-01f, -1.35063738e-01f, -2.97769206e-03f, -2.43792087e-02f, 6.67826384e-02f, -2.61430368e-02f, 1.34091591e-02f, 1.18440293e-01f, 4.37346697e-02f,
  3.82877402e-02f, 3.96007225e-02f, -3.65850376e-03f, -2.78344303e-02f, -2.53675245e-02f, 1.09738126e-01f, 8.05107579e-02f, -5.49531095e-02f, -1.32003324e-02f, -2.97866203e-02f,
  -5.53941354e-02f, -3.62874530e-02f, -4.93818782e-02f, 3.09514962e-02f, -1.94173157e-02f, 2.21045226e-01f, 2.94711348e-02f, -3.80228311e-02f, 7.27342963e-02f, 4.80753034e-02f,
  2.25767773e-02f, 7.05127120e-02f, 1.31678343e-01f, -1.01227388e-01f, -1.71080799e-04f, 5.75951450e-02f, 6.17500730e-02f, 1.57774225e-01f, -6.64835051e-02f, -2.98207235e-02f,
  -1.35241570e-02f, 3.02277971e-02f, -1.21250629e-01f, -7.32648093e-03f, 1.00922901e-02f, 8.66833050e-03f, -7.29633868e-02f, 1.36338538e-02f, -1.30378185e-02f, 1.40466303e-01f,
  -5.85653856e-02f, 1.20552562e-01f, 1.53905451e-01f, -5.03458455e-02f, -1.49859607e-01f, 1.89247578e-01f, -4.69549857e-02f, -1.55519798e-01f, 9.10885185e-02f, 1.26510203e-01f,
  1.29944444e-01f, -6.36853874e-02f, 1.37195820e-02f, -1.04837187e-01f, 7.77289644e-02f, 2.03078389e-01f, -1.50103480e-01f, -6.52476922e-02f, 6.99868724e-02f, -3.93867455e-02f,
  1.25294879e-01f, -1.24016248e-01f, -2.79891863e-02f, 6.57270029e-02f, 6.78113326e-02f, 1.67081263e-02f, 5.05496338e-02f, -1.49502503e-02f, 6.69722930e-02f, 1.00461118e-01f,
  5.94306141e-02f, 1.08016603e-01f, 1.03526711e-01f, 1.05691627e-01f, -1.73368573e-01f, -1.42759353e-01f, 1.15125827e-01f, 2.29253024e-01f, -1.65277217e-02f, 1.35969833e-01f,
  1.79789782e-01f, -9.71057545e-03f, 1.24279171e-01f, 8.91845822e-02f, 8.76688063e-02f, 7.84040093e-02f, 2.38644108e-01f, 3.10605466e-02f, -3.81846800e-02f, 1.67738810e-01f,
  2.04597726e-01f, 1.57233924e-01f, -5.22512123e-02f, -9.25938338e-02f, 4.87788469e-02f, 1.56690046e-01f, -2.91116666e-02f, 1.69120859e-02f, 4.56266403e-02f, 3.40643227e-02f,
  3.83653790e-02f, 7.86481872e-02f, 8.78424346e-02f, 1.95762828e-01f, -3.44837829e-02f, 7.39711747e-02f, 1.41880393e-01f, -4.09468729e-03f, -1.35113776e-01f, 1.84554290e-02f,
  2.68009380e-02f, -2.66851094e-02f, 1.79591060e-01f, 2.25432873e-01f, -3.06554642e-02f, 1.39175549e-01f, -3.01131327e-02f, 1.06088728e-01f, -5.27827032e-02f, 1.46285862e-01f,
  -4.29921113e-02f, 2.09446818e-01f, -9.31701809e-02f, 5.82265332e-02f, -1.40795141e-01f, -4.16851304e-02f, 9.01336148e-02f, 3.68787013e-02f, 1.91839144e-01f, -4.47080508e-02f,
  -1.44466013e-02f, -1.69240788e-01f, -1.04107715e-01f, 6.08139634e-02f, 1.43180355e-01f, 5.58142960e-02f, -3.35874669e-02f, 2.80587678e-03f, -1.03427216e-01f, -1.46970838e-01f,
  1.65279388e-01f, 1.65135741e-01f, 7.78953312e-03f, 7.80935725e-03f, 2.80982647e-02f, -1.28805533e-01f, 1.83969989e-01f, -5.04644141e-02f, 1.13213308e-01f, -6.27888879e-03f,
  2.59944707e-01f, 1.21289343e-01f, 1.28604427e-01f, 6.76808283e-02f, 1.83768257e-01f, 8.93807486e-02f, 3.30744572e-02f, -6.52925298e-02f, 6.44092187e-02f, 1.45526499e-01f,
  1.21159941e-01f, -8.84436294e-02f, 3.83282639e-02f, 9.25880149e-02f, 4.13603932e-02f, 6.63829669e-02f, -2.97098123e-02f, -7.23918378e-02f, -1.38373271e-01f, -2.28962496e-01f,
  -5.91154303e-03f, 6.64679185e-02f, 1.52475044e-01f, -2.17666596e-01f, -2.37029288e-02f, 1.93796039e-01f, -1.86428398e-01f, -3.10253445e-02f, -3.84148620e-02f, 2.21369967e-01f,
  8.05003643e-02f, 1.26802385e-01f, -8.51603299e-02f, -2.36506555e-02f, 2.27952510e-01f, 1.30500734e-01f, -1.83151327e-02f, 1.05687886e-01f, 1.43290302e-02f, 4.86472808e-02f,
  -1.90099597e-01f, 1.41298756e-01f, 9.78501663e-02f, -1.37059670e-02f, -1.57346457e-01f, -1.12901472e-01f, -1.25735164e-01f, 8.59590918e-02f, -4.78018299e-02f, -1.06960954e-02f,
  -5.36327995e-02f, -1.83443502e-02f, -7.30121285e-02f, 1.52993262e-01f, 5.89051247e-02f, 8.29322077e-03f, -4.86987308e-02f, -2.35421360e-01f, -9.59117562e-02f, 9.73895472e-03f,
  -1.06032886e-01f, -1.93605363e-01f, 4.50909324e-02f, -1.67558655e-01f, -1.17090866e-01f, 2.48277009e-01f, 9.31066722e-02f, -4.02025953e-02f, -1.00109108e-01f, -4.73310351e-02f,
  1.35870621e-01f, 5.10947928e-02f, 2.03698248e-01f, -8.85759592e-02f, 1.61297560e-01f, -3.95999104e-03f, 6.60917088e-02f, 8.59247074e-02f, -3.75614986e-02f, 5.50999753e-02f,
  6.33863956e-02f, 1.46597385e-01f, 9.84982625e-02f, 4.64732439e-04f, -1.25686182e-02f, 6.26956448e-02f, -1.57635584e-01f, -3.47178839e-02f, 6.04173690e-02f, -1.34079337e-01f,
  1.75542742e-01f, 6.07641339e-02f, -1.26719132e-01f, 7.66542368e-03f, -1.26276761e-01f, -1.06869461e-02f, -4.99926694e-03f, 2.57268250e-01f, -2.42465660e-02f, -2.47529913e-02f,
  -2.23754160e-02f, -1.72100052e-01f, -9.10996180e-03f, -1.75034683e-02f, -5.83004542e-02f, 1.85372829e-02f, 1.24763921e-01f, 5.23041300e-02f, 1.58659741e-01f, 5.47788292e-02f,
  2.79746577e-02f, -3.35662216e-02f, 1.01022013e-01f, 1.37440279e-01f, 4.39470932e-02f, 9.20882896e-02f, -2.09479146e-02f, -1.89203605e-01f, 1.93994597e-01f, 3.48553546e-02f,
  1.58045575e-01f, 2.14295797e-02f, 1.08793952e-01f, -1.56413004e-01f, 2.44223580e-01f, 1.10601187e-01f, -5.41457208e-03f, 6.24601170e-02f, 1.85896024e-01f, -1.28732949e-01f,
  1.42408267e-01f, 1.80320233e-01f, 1.41206915e-02f, 1.15662694e-01f, 4.19618934e-02f, -1.86748132e-02f, -1.95081234e-01f, 1.75019622e-01f, 8.13664496e-03f, 2.55148066e-03f,
  6.81364313e-02f, 1.35933980e-01f, -8.56483635e-03f, 1.15784757e-01f, 2.10978743e-02f, 3.87836322e-02f, -3.03000361e-02f, 1.67347901e-02f, 8.11925903e-02f, 4.23517637e-02f,
  -3.62694114e-02f, -1.69865415e-02f, 4.49523628e-02f, 1.91996843e-01f, -6.23455876e-03f, 2.10366711e-01f, 1.81863699e-02f, 1.36554137e-01f, 5.13389371e-02f, 2.45397866e-01f,
  -2.50105619e-01f, -2.75491942e-02f, 3.93774137e-02f, 2.78752953e-01f, -2.22771719e-01f, 7.86538869e-02f, -1.75017625e-01f, -4.29232530e-02f, -6.03771955e-02f, -9.66783389e-02f,
  -1.97368562e-02f, -7.84680173e-02f, -7.88138732e-02f, -2.41120562e-01f, -1.95573419e-01f, -4.36619744e-02f, 1.99665483e-02f, -8.37701485e-02f, -7.85769224e-02f, 3.65014300e-02f,
  -6.87953606e-02f, -6.60463125e-02f, 2.89138287e-01f, 5.45619763e-02f, -7.59659801e-03f, -7.94690475e-02f, -9.40522999e-02f, -3.56578603e-02f, 8.64600912e-02f, -6.09521903e-02f,
  1.10504165e-01f, -5.51777408e-02f, 7.71485223e-03f, 1.56196386e-01f, 1.37809560e-01f, 1.40661955e-01f, 1.37825415e-01f, 1.69642732e-01f, -9.61540826e-03f, -6.68800622e-02f,
  1.73409432e-01f, 1.25270993e-01f, 2.05622956e-01f, -1.61582991e-01f, -4.04399261e-02f, -4.14109454e-02f, -2.03732848e-02f, -9.62572452e-03f, 6.94805384e-02f, 1.28910214e-01f,
  5.84388617e-03f, 2.41747916e-01f, 1.25378117e-01f, -1.37790263e-01f, -1.28503338e-01f, 1.28926769e-01f, 5.71313724e-02f, -7.33973831e-02f, 2.56135643e-01f, 1.46864131e-01f,
  5.97756729e-02f, -2.62853764e-02f, -1.01586714e-01f, -3.23629417e-02f, 7.52524147e-03f, 1.87959433e-01f, -2.16869041e-01f, 5.84956491e-04f, -3.75175737e-02f, 8.23040754e-02f,
  -5.96493818e-02f, 1.24844899e-02f, 2.21783683e-01f, 8.44760090e-02f, 3.10656056e-02f, 5.86549975e-02f, 1.73077418e-03f, -5.24015203e-02f, -1.67650376e-02f, 1.59272462e-01f,
  1.82895377e-01f, 9.59646478e-02f, 8.61870423e-02f, -1.58886779e-02f, -6.31616563e-02f, -1.13280445e-01f, -4.11675088e-02f, 5.53331897e-02f, -1.87098200e-03f, 2.57969886e-01f,
  7.59179443e-02f, -9.94794145e-02f, 1.95152119e-01f, 1.31958574e-01f, 1.03146538e-01f, 1.58025876e-01f, 2.65766799e-01f, -1.49345949e-01f, 4.96834666e-02f, 8.48748609e-02f,
  6.62423596e-02f, 1.63360372e-01f, -3.03085055e-02f, -2.27787215e-02f, -2.07465868e-02f, 1.40310124e-01f, -1.68613046e-01f, -1.95030812e-02f
};

// L2_fan_Bp_bar (Shape: 1 x 52)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 52;
const float L2_fan_Bp_bar_data[] = {
  2.45490000e-02f, -2.71563400e-02f, -2.23559439e-02f, 1.49090648e-01f, 4.34555821e-02f, -6.19665207e-03f, 5.22518791e-02f, -1.54933371e-02f, -3.33865844e-02f, 6.98027760e-02f,
  -3.10844232e-11f, 1.63656683e-03f, 4.28305380e-02f, -2.87097469e-02f, 7.25505576e-02f, 5.21406196e-02f, 3.98901254e-02f, 8.26070551e-03f, -2.97649670e-02f, 7.28618577e-02f,
  6.54256120e-02f, 9.66677591e-02f, 7.34801814e-02f, -1.35924742e-02f, 3.90817448e-02f, 4.36993362e-03f, 4.16273959e-02f, -4.55893809e-03f, -4.02196012e-02f, 6.24653138e-02f,
  1.09432451e-01f, -4.92105931e-02f, 5.37313968e-02f, 2.94153821e-02f, 1.02263324e-01f, -2.47429311e-02f, 5.99238910e-02f, 4.13731448e-02f, 1.46245912e-01f, 6.11087903e-02f,
  4.31160443e-02f, 2.18927115e-02f, 5.81543595e-02f, -1.59403961e-02f, 5.31568900e-02f, 5.66778937e-03f, -2.84019355e-02f, 1.79575682e-02f, 5.38226292e-02f, -4.01162636e-03f,
  -3.60413417e-02f, -4.76420857e-02f
};

// L3_fan_Wp (Shape: 6 x 64)
const int L3_fan_Wp_rows = 6;
const int L3_fan_Wp_cols = 64;
const float L3_fan_Wp_data[] = {
  -6.59178272e-02f, -2.85136737e-02f, 3.42413746e-02f, 6.75453171e-02f, -5.09743169e-02f, -1.38632385e-02f, -3.94249186e-02f, -1.09574884e-01f, 9.64804962e-02f, -9.11287740e-02f,
  4.05351445e-02f, 1.40711233e-01f, -2.01890152e-02f, 7.05113709e-02f, -6.13600761e-02f, 2.89685428e-02f, -6.58073947e-02f, 8.26846808e-02f, 8.83897319e-02f, 5.49070984e-02f,
  -2.35540676e-03f, 6.03288636e-02f, -2.95946719e-32f, 6.99156197e-03f, -1.02864638e-01f, -6.01344220e-02f, 7.95960650e-02f, -8.79331902e-02f, 3.11157349e-02f, -1.21754427e-02f,
  -6.60958365e-02f, 2.77417917e-02f, -3.47402990e-02f, 3.82932723e-02f, -5.56177832e-02f, -1.12020306e-01f, -7.85444230e-02f, 3.37679535e-02f, -1.61442496e-02f, 7.25326836e-02f,
  3.10917571e-02f, -6.24429137e-02f, 5.69690391e-02f, -7.05527589e-02f, -5.97756123e-04f, 1.58879906e-01f, 1.24732964e-01f, 1.13646075e-01f, 3.67860757e-02f, 4.75193635e-02f,
  -7.05699101e-02f, 1.22777127e-01f, 8.89916718e-02f, -4.47606966e-02f, -1.05667166e-01f, 1.09812595e-01f, -1.12562682e-02f, 7.72433877e-02f, 1.63825884e-01f, -3.02892029e-02f,
  -1.41311079e-01f, 2.19335146e-02f, 2.92901210e-02f, 1.50629893e-01f, -1.50838077e-01f, -6.50298446e-02f, -7.46480599e-02f, 3.80031578e-02f, -8.76773745e-02f, 1.78767685e-02f,
  -2.10340157e-01f, 3.70668567e-04f, -1.40331239e-01f, -7.09730387e-02f, -4.27313000e-02f, -6.94416538e-02f, -3.47653925e-02f, -8.52094963e-02f, -1.03393115e-01f, -5.85855432e-02f,
  -2.61389613e-02f, 9.31607559e-02f, 4.82805148e-02f, -8.73741880e-03f, 3.86312120e-02f, -5.35831451e-02f, 1.95741023e-33f, 4.92946617e-02f, -1.52512901e-02f, -3.91481370e-02f,
  -4.34922194e-03f, -6.50772154e-02f, -1.21725202e-01f, 5.60014024e-02f, 3.83489393e-02f, -1.40223742e-01f, 4.13656123e-02f, 4.67927642e-02f, 6.48197532e-02f, -1.54302821e-01f,
  -6.38215570e-03f, -1.22255012e-01f, -3.74636725e-02f, -3.49735767e-02f, -3.73844020e-02f, 3.93784828e-02f, 1.01185098e-01f, -6.70779347e-02f, -1.35493472e-01f, 6.80636391e-02f,
  -1.08191192e-01f, -5.10908216e-02f, -3.83694433e-02f, -1.79592725e-02f, 7.87621737e-02f, -6.16742894e-02f, -1.46805808e-01f, -1.97758339e-02f, -1.10233054e-01f, 9.17829275e-02f,
  -1.07072756e-01f, 5.25754550e-03f, 9.55093801e-02f, -3.84986168e-04f, -1.44333571e-01f, -5.61072901e-02f, -1.23490088e-01f, 4.32598926e-02f, 6.00396395e-02f, -9.38004106e-02f,
  2.01860606e-03f, -7.03694299e-02f, -7.15149269e-02f, 9.11677256e-02f, 3.96499150e-02f, -4.36644116e-03f, -4.86084670e-02f, 5.62999174e-02f, 4.30400530e-03f, -1.36374712e-01f,
  -1.29121646e-01f, -1.92848053e-02f, 1.00884445e-01f, -6.96006641e-02f, 5.34138381e-02f, -2.35473681e-02f, -1.42579481e-01f, -1.19630046e-01f, 2.06659883e-02f, 1.55480308e-02f,
  2.74726548e-32f, 4.59277965e-02f, 1.34464681e-01f, 5.03192842e-02f, -3.41844596e-02f, 4.44832481e-02f, -1.51267229e-03f, 5.13750091e-02f, 5.54918833e-02f, 7.27833956e-02f,
  6.22352809e-02f, -2.75958497e-02f, -6.80297567e-03f, 6.50472194e-02f, 1.83535169e-03f, -1.49710327e-02f, 6.47983700e-02f, 5.67275621e-02f, 2.25382559e-02f, 1.58072673e-02f,
  -7.18889534e-02f, 7.38063529e-02f, 3.94183658e-02f, -1.69838503e-01f, -1.52709842e-01f, -3.36206332e-02f, 8.79858248e-03f, -1.05192102e-01f, 4.28987853e-02f, -1.39638945e-01f,
  9.33698937e-02f, 5.52108847e-02f, 2.53325943e-02f, -8.26309472e-02f, 9.65413228e-02f, -3.46803069e-02f, -1.19961850e-01f, 3.58326584e-02f, 1.59165829e-01f, -1.52530083e-02f,
  4.64775413e-03f, -1.50519744e-01f, -1.50333031e-03f, 1.06146410e-01f, 4.59752269e-02f, 9.00802165e-02f, 1.48762697e-02f, -6.32707998e-02f, -2.81268191e-02f, 2.03718059e-02f,
  1.17813431e-01f, -1.64269619e-02f, 2.51921527e-02f, 1.29984990e-01f, 7.13702515e-02f, 1.22545488e-01f, 1.95395201e-02f, 7.22301230e-02f, -9.54954997e-02f, 6.48518950e-02f,
  2.35268511e-02f, -5.30403759e-03f, 1.09801359e-01f, -1.03794694e-01f, 5.42113612e-34f, 2.14535352e-02f, -9.81050283e-02f, 1.13092780e-01f, 1.52117833e-01f, -6.85028266e-03f,
  7.22276270e-02f, -2.43970957e-02f, 2.84203384e-02f, -5.19294813e-02f, -8.51373672e-02f, -5.93537912e-02f, -6.30465820e-02f, -6.28284216e-02f, 1.16003394e-01f, -3.02109774e-02f,
  2.41709258e-02f, -1.96753256e-02f, 5.94974160e-02f, -8.24462436e-03f, 1.83121130e-01f, -7.03581870e-02f, 7.62371272e-02f, 1.73694178e-01f, 1.25210926e-01f, -2.23062690e-02f,
  -1.58212587e-01f, 8.78410339e-02f, -1.86413918e-02f, 2.48171011e-04f, 1.42051548e-01f, 1.08878270e-01f, -1.66293219e-01f, 1.25652075e-01f, -3.00927367e-02f, 2.67504249e-02f,
  7.69707337e-02f, 2.87055355e-02f, 8.94683227e-02f, 2.33309958e-02f, 5.19678853e-02f, 1.16168289e-02f, 2.04701461e-02f, -3.67329419e-02f, -7.28377178e-02f, 2.91898623e-02f,
  1.06352299e-01f, -4.72928630e-03f, 2.64806211e-01f, -6.55977204e-02f, 1.15497634e-01f, -1.14753088e-02f, -2.56515164e-02f, -5.11566084e-03f, -1.17966509e-03f, 9.26412269e-02f,
  -1.07724741e-01f, -5.76855727e-02f, -5.05764447e-02f, -6.72219619e-02f, 3.75584438e-02f, -2.14628447e-02f, 7.79809281e-02f, -7.89060146e-02f, -1.40017117e-31f, -2.34305989e-02f,
  -4.46919389e-02f, 5.49675412e-02f, 4.38953042e-02f, 1.97623912e-02f, 5.17949164e-02f, -4.62269969e-02f, -1.15082905e-01f, 1.25541434e-01f, -1.44872263e-01f, -4.41024713e-02f,
  -1.03717417e-01f, -5.30595705e-03f, 1.32157579e-01f, 1.84198786e-02f, -9.01908875e-02f, -1.82416126e-01f, -2.47307923e-02f, -8.17203242e-03f, -1.20975748e-01f, -9.37779993e-03f,
  -3.43066342e-02f, 4.82345782e-02f, -3.13709415e-02f, 2.83858646e-02f, -5.80909438e-02f, 1.70614792e-03f, -6.74697682e-02f, 9.66343191e-03f, 7.54491240e-02f, -3.12102661e-02f,
  -1.11333327e-02f, 1.04411475e-01f, -7.13948384e-02f, -6.75431779e-03f, 8.91527347e-03f, 1.28014639e-01f, 9.94493254e-03f, 5.01353592e-02f, 1.09223574e-01f, -3.60517018e-02f,
  -8.97469074e-02f, -4.76395711e-03f, -1.22179054e-02f, -4.57962975e-02f, 9.03163850e-02f, 1.10852093e-01f, -8.08318853e-02f, 1.87845826e-02f, -5.45219034e-02f, -4.14370326e-03f,
  3.10248304e-02f, -8.29055458e-02f, 5.88320270e-02f, 1.63328871e-02f, 3.38447914e-02f, 3.88127901e-02f, 5.36591336e-02f, 8.30441788e-02f, 1.02456044e-02f, 2.86683775e-02f,
  -8.26826394e-02f, 8.07972923e-02f, 8.77870819e-32f, -9.60753113e-03f, -2.06857156e-02f, 1.79807432e-02f, -4.58076149e-02f, 7.11021051e-02f, -2.84587499e-02f, -7.24481232e-03f,
  9.31169912e-02f, -1.94016993e-02f, -1.10423788e-01f, -2.40550400e-03f, 7.05782548e-02f, 6.22631833e-02f, 3.45780253e-02f, 6.62607551e-02f, 5.03504537e-02f, 1.22191838e-03f,
  -1.59249939e-02f, -3.24013717e-02f, 6.18092343e-02f, 2.06976309e-02f, -7.04860464e-02f, 2.15904415e-02f, 1.06735602e-01f, 4.96212672e-03f, -4.42825668e-02f, 4.91610542e-02f,
  -1.59315784e-02f, 1.27469167e-01f, -6.15722537e-02f, -1.25449151e-01f, 8.72912072e-03f, -9.93048474e-02f, 2.64919605e-02f, 2.73011904e-02f, 7.80231599e-03f, -4.95116152e-02f,
  -9.44679826e-02f, -3.11135370e-02f, -1.64013684e-01f, -3.93509911e-03f
};

// L3_fan_Wp_bar (Shape: 52 x 64)
const int L3_fan_Wp_bar_rows = 52;
const int L3_fan_Wp_bar_cols = 64;
const float L3_fan_Wp_bar_data[] = {
  6.78918511e-02f, -4.38145548e-02f, 6.15208372e-02f, -5.26561104e-02f, 7.63698965e-02f, 6.99389428e-02f, -1.12660103e-01f, 8.82088766e-02f, -1.88880432e-02f, 1.14789724e-01f,
  -2.15592086e-01f, 2.11232714e-03f, -5.92310727e-02f, -9.84900817e-03f, 1.03337690e-01f, -6.30053803e-02f, -2.35755388e-02f, -8.84265676e-02f, -1.43099546e-01f, 4.28809635e-02f,
  9.66595113e-02f, -9.91931930e-02f, 9.46389679e-32f, 9.21355635e-02f, 2.38696441e-01f, 2.39670519e-02f, -9.54802707e-03f, -5.30098192e-02f, -5.66192046e-02f, 5.18228076e-02f,
  -2.22555045e-02f, -3.57450284e-02f, 1.00210115e-01f, 1.10189080e-01f, 2.17370480e-01f, 6.93672523e-02f, 4.98785637e-02f, -1.74929276e-02f, 2.96001378e-02f, -9.64140240e-03f,
  9.24530327e-02f, -6.37587439e-03f, 7.95518607e-02f, 1.23366177e-01f, -1.12132333e-01f, 1.70774125e-02f, -3.18684913e-02f, 4.17213701e-02f, -1.66925311e-01f, -1.44226626e-01f,
  1.23387547e-02f, -9.02266204e-02f, -1.10628441e-01f, 1.14285521e-01f, 5.37143312e-02f, 2.58550067e-02f, 1.08671166e-01f, -7.64257386e-02f, -2.00037763e-01f, -2.79117245e-02f,
  9.15924534e-02f, 9.19865593e-02f, 3.70593369e-02f, -2.68211216e-02f, -3.67221721e-02f, 2.04392057e-02f, 6.57881517e-03f, -4.15462554e-02f, -1.18541447e-02f, -4.41151001e-02f,
  -1.04390852e-01f, -7.88574740e-02f, -5.01420796e-02f, -1.80370361e-02f, -3.32851037e-02f, 5.74747100e-02f, 3.73369530e-02f, -6.58634678e-02f, -5.04504405e-02f, 1.22453660e-01f,
  4.97899577e-02f, -5.15088497e-04f, 1.74539864e-01f, 6.43054321e-02f, -3.63511331e-02f, 1.02498569e-01f, 3.78465798e-33f, 1.25391083e-02f, -7.30570629e-02f, -9.49187949e-02f,
  1.25219554e-01f, -1.56455621e-01f, 1.30735310e-02f, 3.91334780e-02f, -1.14443582e-02f, -6.93945736e-02f, 1.23324148e-01f, 1.18726097e-01f, -5.82670420e-02f, -1.57829709e-02f,
  4.02317531e-02f, 2.37469170e-02f, -6.47753552e-02f, -7.11487234e-02f, -5.74729592e-02f, 8.21313113e-02f, 9.81030017e-02f, -3.85089442e-02f, -1.56806096e-01f, 1.09551989e-01f,
  -2.50944532e-02f, 4.69325259e-02f, 1.98869005e-01f, 9.60692577e-03f, -6.38679564e-02f, 7.91274086e-02f, -1.37470942e-02f, -5.85101657e-02f, 2.21083574e-02f, 1.03949033e-01f,
  -8.44005942e-02f, 1.60051242e-01f, 1.05006725e-01f, 8.60840306e-02f, -1.42592117e-01f, 6.94511458e-02f, -1.36930361e-01f, 2.05240026e-01f, 9.94411856e-02f, -7.85591677e-02f,
  4.69646566e-02f, 4.52477048e-04f, -7.20380470e-02f, 5.54166324e-02f, 6.79117739e-02f, -1.18130200e-01f, 9.60247368e-02f, 2.20846217e-02f, 1.22230455e-01f, 5.05824089e-02f,
  -4.17484753e-02f, 1.61981985e-01f, 5.24057001e-02f, 5.42101935e-02f, 4.82846722e-02f, 5.03877290e-02f, -4.02049869e-02f, -7.99126700e-02f, -9.15294215e-02f, 1.48446932e-01f,
  -6.46774036e-32f, -6.88780099e-02f, -1.06461979e-01f, 6.60272092e-02f, 5.42985685e-02f, 6.02167621e-02f, 1.34661898e-01f, -5.15576638e-02f, -1.27379015e-01f, 8.25754181e-02f,
  -5.92515059e-02f, -2.17600778e-01f, -1.06462732e-01f, 1.72595397e-01f, -3.52561064e-02f, 3.01222187e-02f, -1.71742439e-02f, 1.18389778e-01f, -1.17739081e-01f, 3.14842761e-02f,
  -4.19811085e-02f, -2.17330921e-03f, 1.20920464e-01f, -1.06224261e-01f, 8.95875171e-02f, 1.05901666e-01f, 1.27651095e-01f, -5.47692999e-02f, -9.17195436e-03f, -7.18250051e-02f,
  1.60013705e-01f, -1.24998234e-01f, 9.14775059e-02f, -1.41676784e-01f, -1.22178090e-03f, -8.58754292e-02f, 3.83150913e-02f, 8.12705755e-02f, 1.41993910e-01f, -5.56595065e-02f,
  1.26089737e-01f, -1.19969971e-01f, 4.16717865e-03f, -4.99359285e-03f, 4.44710366e-02f, -6.95536807e-02f, 2.10067313e-02f, -5.37714325e-02f, -1.16126083e-01f, 3.91943753e-02f,
  -1.92004517e-02f, 7.22792149e-02f, -1.29284739e-01f, 2.33949511e-03f, 5.28969429e-02f, -8.98910984e-02f, 1.20942621e-02f, -5.69425821e-02f, -8.07162374e-03f, -1.34493010e-02f,
  -8.08931291e-02f, 1.02925420e-01f, 1.13921277e-01f, -5.18994369e-02f, -5.32950096e-32f, 6.88837469e-02f, 1.50727123e-01f, 2.06057150e-02f, -2.98454668e-02f, -7.15210289e-03f,
  -5.17190136e-02f, 4.65389229e-02f, 7.78072625e-02f, -1.25023779e-02f, 7.52804205e-02f, 1.32584393e-01f, 1.25638172e-01f, 7.91306719e-02f, -1.13140494e-02f, 4.88363206e-02f,
  9.10119042e-02f, 5.40679470e-02f, 1.17657259e-01f, -2.54509989e-02f, 6.86603636e-02f, 1.16722114e-01f, -3.80275548e-02f, -7.38834590e-02f, 3.66259702e-02f, -8.74374732e-02f,
  -3.18925679e-02f, -5.83036840e-02f, 1.82814524e-02f, 3.59428972e-02f, -8.11917633e-02f, -2.57495418e-03f, 5.77207208e-02f, -1.08877243e-02f, 1.11196727e-01f, -1.95261929e-02f,
  -8.46480727e-02f, -9.82735083e-02f, 1.17724258e-02f, 4.48994600e-04f, -3.61404382e-02f, -5.48670851e-02f, 3.86116654e-02f, 1.49047989e-02f, 1.23185821e-01f, 1.35926843e-01f,
  -5.04877754e-02f, 1.38781384e-01f, -1.05030751e-02f, -6.48883730e-02f, 5.13945781e-02f, -2.36439165e-02f, 9.57418457e-02f, 5.49172692e-04f, -1.11523941e-01f, 6.40336871e-02f,
  1.32214963e-01f, 2.20946640e-01f, 2.75513411e-01f, -4.91397157e-02f, 2.99684312e-02f, -2.16379464e-01f, -1.66207328e-01f, 1.26964271e-01f, 7.73953268e-33f, 1.87321790e-02f,
  -3.78309079e-02f, -1.06148899e-01f, -4.56595458e-02f, 6.54246006e-03f, -1.11305667e-02f, 7.57226124e-02f, -1.06535591e-01f, -1.21207528e-01f, 1.48123518e-01f, -1.83310724e-04f,
  -5.35047092e-02f, 1.45157665e-01f, 5.56878336e-02f, -8.60004276e-02f, 1.07229419e-01f, 5.57887778e-02f, -1.81661099e-01f, 1.06814861e-01f, -1.34193823e-01f, -7.94604346e-02f,
  9.07434821e-02f, 2.34263726e-02f, -6.12216219e-02f, 1.42305061e-01f, 2.48838931e-01f, 7.02368990e-02f, 1.08306535e-01f, 4.28908952e-02f, -1.13957420e-01f, 1.21414833e-01f,
  1.62309110e-01f, -1.17223457e-01f, -7.12524205e-02f, 6.44281805e-02f, 9.56608728e-02f, 5.91087453e-02f, 1.60934925e-01f, -2.09264383e-02f, -9.82338339e-02f, -4.52429727e-02f,
  5.98994009e-02f, 5.56560233e-02f, -3.70539352e-02f, -2.49404050e-02f, -8.43421221e-02f, 5.83047867e-02f, 8.64571109e-02f, 8.86496902e-02f, 6.70661330e-02f, 7.77293965e-02f,
  2.63227448e-02f, -5.71288280e-02f, -5.49272411e-02f, 1.33800074e-01f, 2.70020306e-01f, 8.16626027e-02f, 1.23458922e-01f, 9.91534349e-03f, -1.90344065e-01f, -1.07214330e-02f,
  9.08950865e-02f, -1.03633992e-01f, -3.15397188e-34f, 1.76998284e-02f, 2.44419768e-01f, 2.32193828e-01f, -1.90939233e-02f, 2.63059407e-01f, 1.43877059e-01f, 1.14970598e-02f,
  -1.56448651e-02f, 2.18882456e-01f, -4.66594361e-02f, 2.42540017e-02f, 1.45972192e-01f, 2.51135319e-01f, 9.78181213e-02f, 3.92618030e-02f, 6.08381033e-02f, 1.59176469e-01f,
  1.34571910e-01f, -7.05922469e-02f, -5.71440198e-02f, 2.02368677e-01f, 2.67677337e-01f, -1.34480581e-01f, 1.06809475e-01f, 2.63578929e-02f, -1.86326310e-01f, 2.10697539e-02f,
  1.75114170e-01f, 8.93981010e-03f, 7.18987212e-02f, 3.96194533e-02f, 1.52617782e-01f, -2.04291657e-01f, 1.76025659e-01f, -9.86153260e-02f, -1.16970554e-01f, -1.17405176e-01f,
  2.73650795e-01f, -1.10041901e-01f, 1.81271821e-01f, -1.24080621e-01f, -2.86685620e-02f, -1.42329633e-02f, 7.66956359e-02f, -1.05872124e-01f, 4.62825224e-02f, -1.21873014e-01f,
  8.92964080e-02f, 5.42538650e-02f, 2.54474506e-02f, 1.19337076e-02f, -1.13119192e-01f, -1.96786467e-02f, 9.58869979e-03f, -1.62382517e-02f, -2.50259740e-03f, 6.89924806e-02f,
  -9.45005864e-02f, -4.52117138e-02f, 4.33556512e-02f, -1.90224759e-02f, 6.42793477e-02f, -1.08892575e-01f, -7.29251863e-33f, 7.90896043e-02f, -6.35924563e-02f, 2.12662339e-01f,
  3.86285223e-02f, 2.42728330e-02f, -9.01235081e-03f, 2.78959572e-02f, -5.54632805e-02f, 8.71702060e-02f, 7.65503868e-02f, 1.27964079e-01f, 2.74213795e-02f, -2.10535843e-02f,
  2.30253175e-01f, 1.09787798e-02f, 1.66634712e-02f, -2.11817861e-01f, 3.42234061e-03f, 1.57925576e-01f, 4.62477691e-02f, -1.04787545e-02f, -3.02100927e-03f, 1.99898377e-01f,
  -1.40673205e-01f, 2.43361238e-02f, -1.52743667e-01f, -2.93081463e-03f, 1.88547418e-01f, -7.73031339e-02f, 1.94845498e-01f, 9.15857702e-02f, -2.69548632e-02f, 1.92262847e-02f,
  1.72649603e-02f, 3.18367817e-02f, 1.83916893e-02f, 6.23996742e-02f, 1.17732152e-01f, 1.40441179e-01f, 2.61472225e-01f, 1.08652718e-01f, 6.60387203e-02f, -2.33248435e-02f,
  1.03368059e-01f, 8.26248154e-02f, 6.36876598e-02f, -9.06536449e-03f, -1.79318693e-02f, -7.58207869e-03f, 3.46762575e-02f, -3.26704830e-02f, -1.48759916e-01f, 1.11360289e-01f,
  -1.48426056e-01f, -1.48788214e-01f, -3.94815430e-02f, 2.35266328e-01f, 7.25929216e-02f, -7.49446228e-02f, 1.58133894e-01f, -2.00520664e-01f, 1.43142372e-01f, 4.89715189e-02f,
  -9.63745794e-33f, 1.20980546e-01f, -1.05369568e-01f, -4.51960452e-02f, 2.24931777e-01f, 2.99199913e-02f, -1.35728136e-01f, 1.34009078e-01f, -2.12079398e-02f, -1.18754677e-01f,
  2.80316472e-01f, 2.44739816e-01f, -1.91691723e-02f, 1.30463089e-03f, 2.30898499e-01f, -8.91575962e-02f, -4.73712832e-02f, -1.62187353e-01f, -1.98648479e-02f, 1.66327223e-01f,
  -4.33978401e-02f, -1.60358667e-01f, 7.53194094e-03f, 1.64549127e-01f, -1.74204797e-01f, 1.06152639e-01f, 1.23454496e-01f, -1.42173216e-01f, 2.67752498e-01f, -1.79727674e-01f,
  -9.87639576e-02f, 1.74884602e-01f, 1.38648957e-01f, 1.93911627e-01f, -1.09283350e-01f, 1.28208563e-01f, -9.36569832e-03f, 2.17427433e-01f, 1.15915738e-01f, 1.83063298e-01f,
  5.22117168e-02f, 3.91703583e-02f, -3.11071593e-02f, -1.54922483e-03f, 4.97717457e-03f, -7.90012553e-02f, -2.59715505e-02f, -7.00265355e-03f, -6.83208033e-02f, 3.71735953e-02f,
  -5.82922138e-02f, 3.78246345e-02f, -5.66766970e-02f, -1.20791309e-01f, -7.15850964e-02f, -1.02638401e-01f, 8.90314057e-02f, 5.87658305e-03f, 1.08165398e-01f, -3.06850877e-02f,
  -8.77134576e-02f, -4.80659446e-03f, 5.13300784e-02f, -7.82763660e-02f, 1.13323333e-31f, 5.00510968e-02f, 1.33324221e-01f, -6.35197328e-04f, -8.30146819e-02f, 5.72589226e-02f,
  -7.24077672e-02f, 5.93889654e-02f, 2.63441959e-03f, -2.40848381e-02f, 1.20603278e-01f, 4.32542451e-02f, 1.31550536e-01f, 7.71903694e-02f, -2.29788125e-02f, -3.65376733e-02f,
  6.24222755e-02f, -2.09149607e-02f, 6.90161437e-02f, 4.54042107e-02f, -4.86479923e-02f, 9.28644165e-02f, -1.12474663e-02f, -7.46948943e-02f, -2.79023796e-02f, 1.88331287e-02f,
  -1.26091197e-01f, -1.49795905e-01f, 4.66661826e-02f, -5.69065064e-02f, -4.28511053e-02f, 3.31987292e-02f, 9.49542150e-02f, -1.26870751e-01f, 1.03561595e-01f, -1.00108787e-01f,
  -1.80101350e-01f, -9.28374827e-02f, 1.05345294e-01f, -1.05676912e-01f, 2.95641683e-02f, -1.95364594e-01f, 5.21214642e-02f, 2.39046384e-02f, 6.92012608e-02f, 2.48818547e-02f,
  2.75269877e-02f, -1.03431955e-01f, -1.21891722e-01f, -3.77250426e-02f, -4.35400233e-02f, -4.43794504e-02f, -3.39623876e-02f, 1.75168738e-01f, 1.12245919e-03f, -9.75309610e-02f,
  -2.00342298e-01f, 2.28103712e-01f, 6.33207560e-02f, -1.58650090e-03f, 1.87563941e-01f, 4.58269194e-02f, -2.69216932e-02f, 1.44238889e-01f, 2.14255004e-32f, 4.42162231e-02f,
  -7.78942332e-02f, -1.41182974e-01f, 1.93510994e-01f, -2.07694411e-01f, -2.11533643e-02f, 8.31162632e-02f, -4.84522283e-02f, -4.29212302e-02f, 2.52522558e-01f, 1.78889930e-01f,
  6.79447129e-02f, -3.60843502e-02f, 1.06518820e-01f, 4.67401668e-02f, -1.42932475e-01f, -1.24705344e-01f, -3.19316089e-02f, 1.82207495e-01f, 1.03442989e-01f, -1.32877022e-01f,
  -1.15287878e-01f, 1.76707983e-01f, 2.28420794e-02f, 1.08850457e-01f, 3.49563330e-01f, -7.47413635e-02f, 9.64631545e-05f, 9.06777233e-02f, 7.31594115e-03f, 7.49829635e-02f,
  -2.77646668e-02f, 1.26238450e-01f, -8.09697658e-02f, 1.69815838e-01f, 1.51164234e-01f, 7.23963976e-02f, -2.30591357e-01f, 7.14617148e-02f, -1.98314041e-01f, 2.59298176e-01f,
  -4.95957918e-02f, -6.74277917e-02f, -1.21481150e-01f, -7.31541291e-02f, 5.86445555e-02f, -3.06867119e-02f, 6.11389577e-02f, -1.21905252e-01f, 5.30671328e-02f, 5.08299805e-02f,
  3.48660797e-02f, -1.23788239e-02f, 1.15106799e-01f, 8.62369910e-02f, -3.54326796e-03f, -2.02779427e-01f, 1.26339514e-02f, 7.37250522e-02f, -1.23972885e-01f, 1.34916484e-01f,
  3.75389755e-02f, 1.44463718e-01f, -4.49960312e-32f, -8.37054178e-02f, 2.44499482e-02f, 5.00569046e-02f, 1.60818435e-02f, 8.33122060e-02f, 2.19401494e-01f, -7.41860047e-02f,
  2.20070392e-01f, 1.92865089e-01f, -4.61837649e-02f, -1.70342758e-01f, 2.59224009e-02f, 1.19135782e-01f, -6.77459463e-02f, 2.47283220e-01f, 9.31487158e-02f, 1.73482165e-01f,
  1.69524074e-01f, -1.05165625e-02f, -4.41314951e-02f, 1.71153829e-01f, 1.38000189e-03f, -2.01268733e-01f, 7.81352744e-02f, -1.28712226e-02f, 1.22092381e-01f, 5.68627231e-02f,
  -2.68372267e-01f, 1.38634086e-01f, 1.26390308e-01f, -1.01766177e-01f, 1.03184327e-01f, 1.11809252e-02f, 6.70856014e-02f, 1.44652426e-01f, 5.69185466e-02f, -8.07825699e-02f,
  -8.61224234e-02f, 8.40722322e-02f, -8.52889847e-03f, -4.29162261e-04f, 1.09749064e-02f, 8.30123201e-02f, 2.23517697e-02f, -2.73609366e-02f, 4.58749533e-02f, 2.47940067e-02f,
  -9.86850783e-02f, 6.39424101e-02f, -1.00819217e-02f, 6.06918894e-02f, -4.83421907e-02f, 8.73817578e-02f, 1.28407523e-01f, 2.45594103e-02f, 1.40562169e-02f, -3.91188636e-02f,
  -1.02168722e-02f, 1.33163288e-01f, 1.81463882e-02f, 1.57602325e-01f, 1.00524776e-01f, 6.31176680e-02f, 6.92936655e-33f, 3.56428996e-02f, 9.94394422e-02f, -9.59051549e-02f,
  -3.54651995e-02f, -8.56652185e-02f, -8.55203047e-02f, 3.16196531e-02f, 1.44518644e-01f, -9.02630016e-02f, 8.02380964e-02f, 9.19638798e-02f, 7.56184682e-02f, -1.08911460e-02f,
  -9.98948291e-02f, 6.63289949e-02f, 3.14728022e-02f, 1.25148788e-01f, 1.34580374e-01f, -6.14284426e-02f, 1.90657914e-01f, 7.02275708e-02f, -6.04264922e-02f, -3.02408468e-02f,
  1.70496449e-01f, -1.27241351e-02f, 1.18245929e-01f, 1.18723862e-01f, -3.78073379e-02f, 2.32319117e-01f, -1.79902986e-01f, -7.10770413e-02f, 1.80159900e-02f, 6.50159344e-02f,
  1.61085308e-01f, 8.19129720e-02f, 6.89508542e-02f, -1.21242076e-01f, -1.68897182e-01f, 1.15157969e-01f, -2.45085493e-01f, 6.61654472e-02f, 5.77981658e-02f, -4.51603085e-02f,
  8.49599019e-02f, -6.94228485e-02f, 5.86771257e-02f, 3.55453342e-02f, -1.06310368e-01f, 4.38888371e-02f, 7.49792755e-02f, 1.12918586e-01f, -1.97113708e-01f, 8.51941630e-02f,
  -1.26563516e-02f, -8.70681256e-02f, -1.61818385e-01f, -1.00702040e-01f, -1.31899968e-01f, -5.30329309e-02f, -1.25765167e-02f, 1.96482703e-01f, 1.92610770e-01f, -8.12797472e-02f,
  1.72859633e-32f, 6.96582943e-02f, 6.84028938e-02f, 8.84797722e-02f, 1.24849506e-01f, -9.95147899e-02f, -4.68604751e-02f, 1.24240546e-02f, 1.16787866e-01f, -1.74426623e-02f,
  4.96453233e-03f, 1.73645288e-01f, 1.63486063e-01f, 4.90003452e-02f, 1.27015069e-01f, 7.85172731e-02f, 8.30124244e-02f, -6.38451502e-02f, 2.33822986e-01f, 1.01526929e-02f,
  7.68281072e-02f, 6.99782595e-02f, -4.33902964e-02f, 1.08832128e-01f, -5.18576242e-02f, -1.03296153e-01f, -6.73512295e-02f, 4.86141667e-02f, 2.14729942e-02f, 1.20283991e-01f,
  6.96516931e-02f, -3.13469730e-02f, 1.30421408e-02f, 1.08235344e-01f, 5.20391278e-02f, 9.04072672e-02f, 5.23359813e-02f, 9.78656560e-02f, 3.09302825e-02f, 3.46918516e-02f,
  1.46648772e-05f, 1.49177192e-02f, 2.79505625e-02f, -2.40816139e-02f, -6.00550659e-02f, 8.25570673e-02f, 1.13816157e-01f, -1.66167185e-01f, 1.12259366e-01f, -1.40472189e-01f,
  -6.76261727e-03f, -5.90317324e-02f, -1.10022336e-01f, -2.22699251e-02f, -1.74263529e-02f, 3.73805426e-02f, -1.02029815e-01f, 1.67847350e-01f, -3.05682439e-02f, 7.21796136e-03f,
  1.23334982e-01f, 4.86424081e-02f, 9.13728308e-03f, 1.26727715e-01f, 7.68448575e-32f, -2.12439466e-02f, -1.08120561e-01f, 1.23918287e-01f, 2.33813435e-01f, -7.49669895e-02f,
  8.73082578e-02f, -1.18336100e-02f, -1.54650249e-02f, 1.87625680e-02f, 1.26529515e-01f, -8.26851279e-02f, -1.16787873e-01f, 4.03464809e-02f, 1.86731726e-01f, 7.28408843e-02f,
  -4.53585349e-02f, -2.02731833e-01f, -9.89725739e-02f, 7.20495433e-02f, -6.01943284e-02f, -2.22009290e-02f, -9.09105465e-02f, 2.47228891e-01f, 6.64683152e-03f, 1.78000510e-01f,
  8.55421796e-02f, 4.16275635e-02f, -6.52099401e-02f, 5.91446944e-02f, 2.86477387e-01f, -7.19046816e-02f, 6.84488416e-02f, 1.39294595e-01f, -1.08368479e-01f, 1.32428810e-01f,
  1.83829457e-01f, 3.00614238e-01f, -6.90774173e-02f, 2.68118620e-01f, 1.13037266e-01f, 3.26071322e-01f, 5.03007174e-02f, -3.45563069e-02f, -9.37709934e-04f, 4.34824526e-02f,
  -1.01677842e-01f, -1.43159285e-01f, 7.25819394e-02f, -8.58388282e-03f, -4.54943813e-02f, -1.15497559e-01f, -1.15143582e-02f, 1.16250012e-02f, -2.43607029e-01f, -1.63932040e-01f,
  -1.59335122e-01f, 2.40774944e-01f, 5.28237745e-02f, 1.94907392e-04f, 1.76556379e-01f, -1.25652075e-01f, 3.63610871e-02f, 3.57612260e-02f, -2.11663627e-32f, -6.98920758e-03f,
  -1.52703732e-01f, 1.65959485e-02f, 9.30491537e-02f, 7.59467855e-02f, 9.92672797e-03f, 3.08795944e-02f, -2.17277229e-01f, -7.66618326e-02f, 2.11950824e-01f, 1.38657689e-02f,
  -9.21421126e-03f, 1.01564273e-01f, 1.45004168e-01f, -1.57232042e-02f, -1.83022339e-02f, -2.85378277e-01f, -2.04190522e-01f, 2.06240416e-01f, -1.38637692e-01f, -3.30787152e-02f,
  6.31539896e-02f, 2.47913413e-03f, -2.16339573e-01f, 1.72631577e-01f, 6.76755607e-02f, -2.49660000e-01f, 7.88477436e-02f, -2.63771415e-01f, 1.23046823e-01f, 6.87220916e-02f,
  1.55539904e-03f, 9.53109935e-02f, -8.97917077e-02f, 9.16574299e-02f, 1.25325039e-01f, 1.76360995e-01f, 1.30577683e-01f, 3.06494627e-02f, 2.51454920e-01f, 3.37900333e-02f,
  -5.09541146e-02f, -5.17265387e-02f, -2.09694784e-02f, 4.58144583e-03f, 2.40473598e-02f, -7.90375285e-03f, 1.43163219e-01f, -9.49585661e-02f, 1.31478727e-01f, -4.42514084e-02f,
  1.28957272e-01f, -6.72080601e-03f, 1.13815494e-01f, 1.36120990e-01f, 1.34125710e-01f, -3.77814360e-02f, -6.01173453e-02f, 1.20969616e-01f, 7.48076709e-03f, 2.11423170e-02f,
  -4.81257550e-02f, 3.24035250e-02f, -1.27128374e-31f, -6.26473576e-02f, -7.17102513e-02f, 1.87869698e-01f, 1.26555776e-02f, 9.39674228e-02f, 1.83484197e-01f, -6.85847625e-02f,
  -4.41620648e-02f, 2.70112842e-01f, -8.18544552e-02f, -1.43340498e-01f, -1.09605014e-01f, 5.90049662e-02f, 2.14205962e-03f, 1.80772960e-01f, 3.78277190e-02f, 4.79634181e-02f,
  6.90164194e-02f, -5.57629615e-02f, -7.23355711e-02f, 5.42208590e-02f, 1.53200373e-01f, 8.70328918e-02f, 1.54970855e-01f, 4.30225357e-02f, -2.13844124e-02f, 1.26144603e-01f,
  -8.13562199e-02f, -4.51413095e-02f, 2.10400417e-01f, -6.46522865e-02f, -6.40051588e-02f, 2.09247284e-02f, 3.76527011e-02f, 5.12839071e-02f, 1.96705565e-01f, 1.09865323e-01f,
  6.62917942e-02f, -4.45897272e-03f, 2.58699715e-01f, 1.05830848e-01f, -1.89261325e-02f, -9.62916166e-02f, -5.17330552e-03f, -4.89972644e-02f, 8.39913413e-02f, -1.43955881e-02f,
  3.40268053e-02f, -5.52158020e-02f, 3.62652726e-02f, 1.00786410e-01f, -1.05831131e-01f, 5.42931296e-02f, 1.09068483e-01f, 5.50197624e-02f, -2.62421779e-02f, 2.81081945e-02f,
  -1.07498996e-01f, 6.25823811e-02f, -8.52341279e-02f, 7.98830763e-02f, 1.21800698e-01f, -1.61548853e-01f, -4.00925506e-32f, 9.94236395e-02f, 1.01212084e-01f, 1.53147921e-01f,
  1.09731577e-01f, 5.17375134e-02f, -1.65135916e-02f, 2.33261138e-02f, -4.37877215e-02f, 1.12415209e-01f, 8.09736608e-04f, 2.14723237e-02f, 8.45512226e-02f, -1.50587251e-02f,
  2.41650194e-01f, 2.01488305e-02f, -1.48151696e-01f, -1.67995974e-01f, -6.19418994e-02f, -6.85070548e-03f, 1.57143325e-01f, 1.11966347e-02f, -1.88264400e-02f, 1.15529768e-01f,
  -7.19615072e-02f, 1.00268587e-01f, -2.32536808e-01f, 6.41212687e-02f, 9.90031362e-02f, 1.45693664e-02f, 2.34256402e-01f, 9.56563875e-02f, -1.24799483e-01f, 9.71096233e-02f,
  4.38763797e-02f, -7.03434497e-02f, -9.87689346e-02f, 1.26818255e-01f, 1.84216574e-01f, 1.07603632e-01f, 2.34297171e-01f, -3.91974598e-02f, -4.99140099e-02f, 1.21521272e-01f,
  6.73749968e-02f, 1.25379905e-01f, -5.22262491e-02f, 9.82992500e-02f, -9.18936059e-02f, 6.12352788e-02f, -8.15046579e-02f, 2.28868630e-02f, -5.92023991e-02f, 8.92326981e-03f,
  -1.45102972e-02f, 7.12442771e-02f, -6.44899253e-03f, 6.55632243e-02f, 6.83185384e-02f, 1.23922810e-01f, 5.37816212e-02f, 1.53677732e-01f, 6.92306012e-02f, 5.57714924e-02f,
  7.76075550e-33f, 1.12914562e-01f, 9.05653685e-02f, 5.12752421e-02f, -6.78412393e-02f, -4.79368642e-02f, -1.97202444e-01f, 1.30346790e-01f, 2.09149659e-01f, -9.91198197e-02f,
  9.04238969e-02f, 1.97034687e-01f, 8.74178335e-02f, -7.86865428e-02f, -7.31650591e-02f, -8.04038905e-03f, 8.06323066e-02f, 1.06420703e-01f, 1.42847538e-01f, -1.99970100e-02f,
  1.51794061e-01f, 4.74674031e-02f, 1.18455805e-01f, -6.26369417e-02f, 9.14077461e-02f, 1.44887000e-01f, 6.83378577e-02f, 1.15401722e-01f, 1.33283243e-01f, 2.01721862e-01f,
  -1.84869215e-01f, 9.38067213e-02f, 9.95521713e-03f, 9.04886499e-02f, 1.65737540e-01f, 1.35776307e-02f, -7.56278187e-02f, -1.06922112e-01f, 1.38812279e-02f, 1.31842151e-01f,
  -1.69857025e-01f, -6.92653609e-03f, -8.45926702e-02f, 1.09243594e-01f, 8.23197663e-02f, 1.12380147e-01f, 3.46758701e-02f, 7.94497784e-03f, -3.99171561e-02f, 1.22823671e-01f,
  3.96395251e-02f, -3.96475615e-03f, 7.03957826e-02f, 1.41100511e-01f, -7.95717388e-02f, 1.41959518e-01f, 6.72723278e-02f, 2.03140706e-01f, 1.12979002e-01f, 4.93573882e-02f,
  3.45090404e-02f, -4.44960855e-02f, 1.60919852e-03f, 1.29031286e-01f, 3.49422102e-32f, 1.32876962e-01f, 7.76174292e-02f, 7.24042132e-02f, -2.39018407e-02f, 2.45396439e-02f,
  -8.39508846e-02f, 1.48870766e-01f, -7.07171187e-02f, -1.02755114e-01f, 6.82231039e-03f, 1.33561686e-01f, 1.19109280e-01f, -1.03832223e-02f, 7.11195841e-02f, -1.27614498e-01f,
  -3.19921002e-02f, 1.08599558e-01f, 1.77312791e-02f, -5.74670620e-02f, 8.70496780e-02f, -9.21054780e-02f, 5.02537973e-02f, 1.32368222e-01f, -9.01876390e-02f, 1.49278566e-01f,
  -1.37021497e-01f, -8.93642902e-02f, 2.78085649e-01f, -3.59774381e-03f, -1.82310775e-01f, 1.17579572e-01f, 3.09657659e-02f, 3.08495318e-03f, -2.20385008e-02f, -1.16971806e-02f,
  -6.49112090e-02f, 5.80439605e-02f, 1.02477446e-01f, -4.44324538e-02f, -1.62586272e-01f, -1.42951906e-02f, -3.12175034e-05f, 8.65081256e-06f, 8.32666501e-06f, -7.92313676e-06f,
  -3.82453027e-06f, 1.30311128e-05f, 2.26343745e-05f, 3.88484987e-05f, 3.68929359e-05f, 4.02229525e-05f, 8.30165955e-05f, 4.66919857e-07f, 2.17171364e-05f, -3.30276998e-05f,
  6.72697497e-05f, -5.73492725e-04f, -4.53701932e-06f, 6.05061359e-05f, 4.44685747e-06f, 2.08216006e-04f, 1.08545290e-04f, 5.96960308e-05f, -5.66333373e-40f, -9.01668386e-07f,
  -1.30722792e-05f, 2.27601613e-05f, -2.02675756e-06f, -4.52528802e-05f, -3.80837955e-05f, -3.86420425e-06f, 3.25942005e-06f, 1.04596284e-05f, -3.25685542e-04f, -1.49722791e-05f,
  -6.73100731e-05f, -6.68166322e-05f, 8.71860084e-06f, 3.71656497e-05f, 7.23198946e-06f, -1.53651054e-04f, 1.09597248e-04f, -3.56185956e-06f, -1.71398024e-05f, 3.08847884e-05f,
  6.81328238e-05f, -1.39819686e-05f, -1.43984682e-04f, -4.41817110e-06f, -1.21801997e-04f, -1.87539717e-05f, -6.45264208e-07f, -4.17976662e-05f, 2.51678944e-06f, 3.19999344e-06f,
  1.56951046e-05f, -6.18197882e-05f, 6.99379962e-05f, -6.70832196e-06f, -6.48915884e-05f, 7.71858686e-06f, -1.08394051e-05f, -9.98054020e-05f, 3.80225379e-06f, 1.78703685e-05f,
  -4.62577632e-03f, 1.17157526e-01f, 3.75909917e-02f, -2.45247036e-02f, -2.62871142e-02f, -2.80243549e-02f, -1.06670536e-01f, -9.73744839e-02f, -6.42427281e-02f, -6.45991648e-03f,
  1.40412942e-01f, -1.03432134e-01f, -9.47012305e-02f, 9.80852470e-02f, 2.67953366e-01f, 2.00696275e-01f, 3.49161088e-01f, -1.68538973e-01f, -2.87495218e-02f, -1.19962484e-01f,
  -1.66477159e-01f, 6.77247047e-02f, -1.97367515e-32f, -4.94789556e-02f, 3.48045938e-02f, -4.21870016e-02f, 1.28647238e-01f, 5.59531860e-02f, 4.94018644e-02f, 3.64820808e-02f,
  -1.45119458e-01f, 1.42284781e-01f, 2.92320624e-02f, 1.03415713e-01f, -5.05064949e-02f, 8.63407105e-02f, 1.40920565e-01f, -6.23125210e-02f, 5.02811112e-02f, -5.60126007e-02f,
  -1.36311978e-01f, 1.40033454e-01f, -2.26496175e-01f, 9.69583616e-02f, 4.77679931e-02f, -2.80732173e-03f, -1.54746056e-01f, 1.35841176e-01f, 3.74832936e-02f, -3.13952863e-02f,
  -6.15090355e-02f, -1.55215962e-02f, 4.81036678e-02f, -3.97981107e-02f, 2.21903995e-01f, -9.88942683e-02f, -5.86395003e-02f, 5.89073868e-03f, -1.01998039e-01f, 3.28124821e-04f,
  3.41494717e-02f, -2.11541146e-01f, 5.88621832e-02f, -1.31764263e-01f, -6.68398291e-02f, -3.42660658e-02f, -1.46243544e-02f, 1.25545477e-02f, 4.19066548e-02f, 5.86628914e-03f,
  2.82296687e-02f, 4.78945449e-02f, 6.47145957e-02f, -7.35684559e-02f, -2.60003507e-02f, 1.06180437e-01f, 1.62554845e-01f, 4.38024290e-02f, -2.56370068e-01f, -4.43928242e-02f,
  -1.97269320e-01f, 1.61341697e-01f, 1.12759136e-01f, 9.29439589e-02f, 1.85727656e-01f, 4.14166860e-02f, -1.15066181e-32f, 8.53384510e-02f, -7.97754750e-02f, 8.79156888e-02f,
  9.58222672e-02f, -1.10883184e-01f, -1.27332732e-01f, 4.19921391e-02f, 1.96996123e-01f, -6.27483567e-03f, 1.40684709e-01f, 1.84723496e-01f, 7.18043819e-02f, -1.99088246e-01f,
  7.54235089e-02f, 2.92299502e-02f, 7.99272060e-02f, 4.01118025e-02f, 6.40359074e-02f, -1.32613629e-01f, 2.71154404e-01f, -5.62237054e-02f, 7.73683637e-02f, 1.44225955e-01f,
  4.71835397e-02f, 1.76315233e-02f, -1.61180068e-02f, 1.00501709e-01f, 1.50356650e-01f, 1.48929879e-01f, -2.08655193e-01f, 1.55897215e-01f, -1.62517652e-01f, 2.34836817e-01f,
  3.32598500e-02f, 1.43246487e-01f, 2.01342031e-01f, 1.41503811e-01f, -1.91118345e-01f, 2.03505635e-01f, -3.27094607e-02f, 2.73176759e-01f, 7.47597963e-03f, 7.04379678e-02f,
  1.69441551e-02f, 1.26041070e-01f, -6.26026914e-02f, 1.31838575e-01f, 3.86612006e-02f, 6.83089867e-02f, -6.46943524e-02f, -1.13261016e-02f, 1.36555836e-01f, -6.30947724e-02f,
  -6.45859838e-02f, 1.05534822e-01f, 2.00816736e-01f, 2.29342043e-01f, 3.67997169e-01f, 5.59959821e-02f, -6.21610787e-03f, -1.28888756e-01f, -1.29801258e-01f, 1.81195199e-01f,
  -4.97827111e-33f, 2.59705000e-02f, -6.47012740e-02f, 7.86928833e-02f, 9.09782127e-02f, 1.56566322e-01f, -1.53049365e-01f, 1.16181366e-01f, -9.87442508e-02f, -1.88918393e-02f,
  1.61433723e-02f, 7.98256770e-02f, 1.17636666e-01f, 1.72027815e-02f, -2.66817790e-02f, -1.44852892e-01f, 1.63059740e-04f, -8.15188885e-03f, -5.52988797e-02f, 1.60276964e-01f,
  -6.65941238e-02f, -7.14221075e-02f, 8.73760879e-03f, 1.43851817e-01f, -7.44094476e-02f, 8.39908272e-02f, 5.88111915e-02f, 1.01584770e-01f, 7.78039992e-02f, -6.55927435e-02f,
  -1.41159683e-01f, 8.73941779e-02f, 2.08120525e-01f, -1.40242934e-01f, 2.36124899e-02f, -2.26832442e-02f, 1.67117659e-02f, -5.17971553e-02f, 2.00800270e-01f, 2.16891449e-02f,
  -1.46879449e-01f, 6.71105366e-03f, 8.36091302e-03f, 3.82274576e-03f, -1.20930769e-03f, 8.29946175e-02f, -4.17881552e-03f, -4.46153507e-02f, 1.87778771e-01f, 7.29641169e-02f,
  5.48402686e-03f, 4.95268852e-02f, 8.80296603e-02f, -1.84774026e-02f, 4.64042239e-02f, 2.07919270e-01f, 2.19473019e-01f, 8.85833576e-02f, 5.36338054e-02f, 5.92420511e-02f,
  -9.87908691e-02f, -1.18412226e-01f, -3.13012823e-02f, -2.33540498e-02f, -6.61084270e-32f, -2.21748855e-02f, 1.09247323e-02f, 2.31696412e-01f, 5.41959628e-02f, 1.72394440e-01f,
  9.95296463e-02f, -2.32895315e-02f, -1.13656938e-01f, 2.02241108e-01f, -4.48443182e-03f, -4.54598106e-03f, -5.85999340e-02f, 7.45206326e-02f, 1.21616982e-01f, -3.99857410e-04f,
  -1.54894982e-02f, -4.30281572e-02f, -4.04996201e-02f, 9.66844186e-02f, -1.44689143e-01f, 6.33258894e-02f, 1.34468466e-01f, 9.96760800e-02f, 6.59349114e-02f, 1.33128509e-01f,
  -1.84196547e-01f, -4.77609830e-03f, 1.54805765e-01f, -1.15972176e-01f, 2.26581201e-01f, -3.70269530e-02f, 7.57904444e-03f, -9.75657925e-02f, 1.01978658e-02f, -3.97280157e-02f,
  -3.16928960e-02f, 1.78236842e-01f, 2.45100290e-01f, -8.49139392e-02f, 2.47803897e-01f, -1.39534771e-01f, -4.18822207e-02f, -4.28316481e-02f, 9.22273695e-02f, -4.34534252e-02f,
  -4.74448763e-02f, -3.66037712e-02f, -2.13069454e-01f, 6.47729263e-03f, 4.83302306e-03f, 1.35909505e-02f, -1.20205365e-01f, -6.47785217e-02f, -3.35427225e-02f, -1.87058657e-01f,
  2.39832345e-02f, -3.15389447e-02f, 4.49967347e-02f, -1.03695616e-01f, 3.85993533e-02f, 3.05536240e-02f, 3.82192321e-02f, -7.09109306e-02f, 2.19059705e-32f, 1.14147238e-01f,
  9.26918536e-02f, -4.55351695e-02f, -7.24410778e-03f, -1.23434447e-01f, -1.07269228e-01f, 1.08748212e-01f, -2.47441325e-02f, -2.10213780e-01f, 9.80704948e-02f, 1.81514472e-01f,
  1.62449703e-01f, 4.28858846e-02f, -3.62464972e-02f, 1.41652124e-02f, -7.34812068e-03f, 4.93184701e-02f, 6.15841113e-02f, 3.17205228e-02f, 9.92567241e-02f, 2.39821225e-02f,
  -8.74207541e-02f, 7.88290892e-03f, -3.21766660e-02f, 7.29381368e-02f, 2.30041612e-03f, -5.58918379e-02f, -2.79558171e-02f, 8.49512592e-03f, -6.71396479e-02f, 9.76184830e-02f,
  -3.87616418e-02f, -1.57266390e-02f, 7.50367194e-02f, 4.93251346e-02f, 2.75729541e-02f, -4.72574122e-02f, -2.48549506e-02f, 1.26289397e-01f, -8.37451890e-02f, -8.95478204e-03f,
  -7.93974996e-02f, 7.13995174e-02f, 7.06303194e-02f, 5.57921715e-02f, 1.07034102e-01f, 1.45054245e-02f, 1.16866179e-01f, -6.40567243e-02f, 5.82973026e-02f, -2.59861792e-03f,
  -4.53243637e-03f, 7.92097375e-02f, 4.82937694e-02f, 1.25437723e-02f, 4.62416969e-02f, 4.69382061e-03f, 1.38342893e-02f, -7.53245652e-02f, 5.20191863e-02f, -2.25142133e-03f,
  -4.47229519e-02f, 3.66657786e-02f, 5.16074402e-40f, -3.70691158e-02f, -2.37120911e-02f, 1.26925465e-02f, 7.28679076e-02f, 1.47301871e-02f, 1.20563887e-01f, -7.92801380e-02f,
  -4.89432476e-02f, 1.02699868e-01f, -3.30399349e-02f, -5.62809221e-02f, -5.48200198e-02f, 6.94218501e-02f, 3.75106335e-02f, 9.04659182e-02f, -6.35587499e-02f, 2.70468611e-02f,
  -4.95951772e-02f, 1.57478470e-02f, -5.68886511e-02f, 5.58865406e-02f, -8.23880360e-03f, -2.87630670e-02f, 1.86692625e-02f, -4.03233618e-02f, 3.60907055e-02f, -2.24260730e-03f,
  -6.31668940e-02f, -2.03065015e-02f, 1.33174568e-01f, -6.07784986e-02f, 4.33048606e-03f, -1.11612706e-02f, -3.57427746e-02f, 4.63985652e-02f, 8.01027566e-02f, 3.96606885e-02f,
  9.88590252e-03f, -4.31875102e-02f, 8.61795023e-02f, 6.60784692e-02f, -2.22474308e-04f, 2.52270536e-03f, -1.20418251e-03f, 7.30246320e-05f, 2.00940034e-04f, -1.29728182e-03f,
  -5.11530470e-06f, -1.18251708e-04f, -5.59628916e-07f, 3.12742341e-05f, 2.99222938e-06f, -7.42770266e-04f, -5.13363034e-07f, -8.85062691e-05f, 4.70951054e-05f, -1.66394559e-04f,
  4.93693642e-06f, -1.13076121e-05f, -9.01718522e-08f, -6.07430906e-08f, -2.03201065e-15f, -2.74685008e-04f, 5.42359959e-40f, 8.75961928e-16f, -5.88302385e-07f, -2.42496408e-05f,
  -1.20206438e-04f, -2.23359093e-04f, 4.94745471e-08f, -3.37675031e-16f, -1.82788295e-04f, -1.54783585e-04f, -4.82725263e-05f, -3.39238934e-04f, -1.05818780e-03f, 1.60939799e-05f,
  -1.33088601e-04f, -3.69872383e-10f, 8.45062749e-16f, -4.39846190e-06f, -4.06121501e-07f, -5.61853597e-07f, -4.22117728e-06f, 8.08528269e-15f, 5.82811726e-14f, -1.20894547e-04f,
  -1.58523981e-04f, -1.35707960e-04f, -7.42862085e-07f, -1.53933498e-11f, -1.05072679e-04f, -3.82038503e-04f, 6.83997200e-07f, -2.38623586e-04f, -9.36990546e-06f, -1.90903648e-09f,
  -1.87232533e-14f, -1.22199175e-08f, -6.25479370e-05f, -5.99936931e-04f, -7.94056032e-05f, -2.46638956e-06f, -6.43820158e-06f, -1.06512334e-05f, 2.71662604e-03f, 4.57665399e-02f,
  -5.94139695e-02f, 3.82724665e-02f, 1.99569650e-02f, 1.52391605e-02f, 2.96370797e-02f, 1.68792069e-01f, 5.93119152e-02f, 5.68642318e-02f, -3.62984575e-02f, -3.91250849e-02f,
  1.93891600e-01f, 2.12504759e-01f, 7.47163892e-02f, -7.91014135e-02f, -5.21797873e-02f, 2.33638763e-01f, -1.38109371e-01f, 1.95566550e-01f, 1.48765355e-01f, -6.44253939e-02f,
  -4.31383652e-33f, 1.17816431e-02f, 1.84548303e-01f, 2.37102687e-01f, -7.39050731e-02f, 1.49784088e-01f, -2.18550619e-02f, 2.10752012e-03f, 2.10669339e-01f, 1.25675231e-01f,
  -1.27981275e-01f, 5.95380776e-02f, 1.56357557e-01f, 6.97271824e-02f, -2.56027095e-02f, 8.21795613e-02f, 9.46097225e-02f, 2.72288263e-01f, 2.55849838e-01f, -1.23382121e-01f,
  2.15142563e-01f, 1.23089552e-01f, 2.21196607e-01f, -4.27068248e-02f, 2.88412511e-01f, 2.00135522e-02f, -1.62019879e-01f, 2.33300045e-01f, 1.43684000e-01f, 1.28509447e-01f,
  -1.59395486e-02f, -2.84826495e-02f, 1.03685416e-01f, 6.24673851e-02f, 2.12600261e-01f, -8.56572390e-02f, 5.48194386e-02f, 1.88014228e-02f, 1.13623917e-01f, 8.29806849e-02f,
  -2.58145179e-03f, -7.77110681e-02f, -3.71922478e-02f, -5.40364794e-02f, -2.16583852e-02f, -3.11735924e-02f, 3.54107097e-02f, -3.01779695e-02f, 7.37252384e-02f, -1.86933234e-01f,
  3.64310034e-02f, -8.96023959e-02f, 3.12683769e-02f, -1.45103373e-02f, 4.16754633e-02f, 1.42070958e-02f, -5.96523657e-03f, 5.97611107e-02f, 6.04386032e-02f, 2.23006699e-02f,
  1.41477138e-01f, -6.94401637e-02f, -1.47098601e-01f, 2.10539877e-01f, 5.13199307e-33f, -1.32983983e-01f, -2.06494868e-01f, -2.61223707e-02f, 1.88635692e-01f, -5.95918037e-02f,
  2.09178045e-01f, -8.65269527e-02f, -8.99627134e-02f, 1.93723112e-01f, -3.24340574e-02f, -1.98616743e-01f, -2.56572455e-01f, 3.55044566e-02f, 5.61355203e-02f, 1.57266751e-01f,
  9.82893780e-02f, -5.03904633e-02f, -1.65417969e-01f, 7.84437880e-02f, -1.15188032e-01f, -3.24353985e-02f, -6.74706176e-02f, 3.28406841e-02f, -2.92094517e-03f, 6.07467853e-02f,
  2.48182729e-01f, 4.65452373e-02f, -2.63819903e-01f, 2.65216548e-03f, 2.46934295e-01f, -1.81056380e-01f, 2.52156169e-04f, 6.40093386e-02f, -1.76713660e-01f, 1.93474382e-01f,
  2.39820614e-01f, 1.52344137e-01f, -1.23743556e-01f, 5.64921126e-02f, 6.26702681e-02f, 2.40398198e-01f, 8.17119777e-02f, 6.01608586e-03f, 7.19328001e-02f, -2.05483939e-02f,
  7.87721276e-02f, 8.77664611e-02f, -4.05554334e-03f, -1.20978422e-01f, 7.23377541e-02f, -1.04285933e-01f, 1.23273566e-01f, -1.05261812e-02f, 1.05199136e-01f, 4.45078164e-02f,
  9.06294957e-02f, 4.80500832e-02f, 7.45099261e-02f, 8.45389292e-02f, 2.00871661e-01f, 3.00162528e-02f, -1.46747738e-01f, 2.29563162e-01f, -4.06325751e-35f, -1.04043715e-01f,
  -1.58833906e-01f, -3.45105529e-02f, 1.09191097e-01f, -1.45002946e-01f, 1.05508447e-01f, -5.80013432e-02f, 6.08514771e-02f, 9.82970670e-02f, -4.64832820e-02f, -1.05001673e-01f,
  -1.79982647e-01f, -1.56408157e-02f, -1.47054508e-01f, 1.68170199e-01f, 2.03924254e-01f, 1.11862376e-01f, -1.24999397e-01f, 2.19445154e-02f, 5.24238646e-02f, -5.99242486e-02f,
  -1.23497963e-01f, 7.47623816e-02f, 2.94409152e-02f, 6.69483691e-02f, 3.06433022e-01f, 1.88460723e-01f, -2.12771878e-01f, 2.06576094e-01f, -1.89800505e-02f, -2.03311160e-01f,
  -4.85749170e-02f, -2.58482415e-02f, -5.35036363e-02f, 1.48028731e-01f, 2.41019383e-01f, 3.29607469e-03f, -1.90366238e-01f, 1.27161637e-01f, -1.82343751e-01f, 1.27313167e-01f,
  5.29038757e-02f, -4.84394142e-03f, 1.13439783e-02f, 6.72668889e-02f, -3.96631323e-02f, -5.88254631e-02f, 1.97366178e-01f, -7.75443017e-02f, 1.21043935e-01f, -3.68876942e-02f,
  1.63252298e-02f, 5.82131632e-02f, 1.67568699e-01f, 6.52010292e-02f, -1.37809515e-01f, -8.78540501e-02f, -1.22380838e-01f, 7.33631104e-02f, -2.42424402e-02f, 6.10215627e-02f,
  2.07688995e-02f, 7.55079538e-02f, 8.08343149e-32f, -4.04488519e-02f, -8.13806579e-02f, 1.29764229e-01f, 8.18077624e-02f, -1.32199666e-02f, 1.82675887e-02f, -5.34620471e-02f,
  1.57812610e-01f, 1.46412581e-01f, 2.30841246e-02f, 1.37354527e-02f, -1.26828194e-01f, -9.40635577e-02f, 9.39979032e-02f, 3.72479334e-02f, 2.53456365e-02f, -1.42202675e-02f,
  9.88407582e-02f, -1.05550162e-01f, 1.19511999e-01f, 4.02217992e-02f, -2.06771418e-02f, -2.60398388e-02f, 2.17228368e-01f, 4.78533059e-02f, -1.92922179e-03f, 1.49237454e-01f,
  -1.20434701e-01f, 3.96901406e-02f, 5.32035753e-02f, -7.50475517e-03f, 7.34790647e-03f, 2.40542993e-01f, -3.70141026e-03f, 1.26501381e-01f, 1.00347549e-01f, 1.46156400e-01f,
  -7.82651305e-02f, 7.69980699e-02f, 3.23615782e-02f, 2.19535351e-01f, -3.03291231e-02f, -5.31724356e-02f, 7.44021079e-03f, -5.47883138e-02f, -4.98491749e-02f, 1.17644921e-01f,
  -5.67778982e-02f, -3.69015150e-02f, -1.92568805e-02f, 7.35612586e-03f, 1.40177738e-02f, -4.28666472e-02f, -4.35074121e-02f, 9.89419874e-04f, -2.38408707e-03f, -1.15283005e-01f,
  -9.85266045e-02f, 1.11374175e-02f, -1.52971566e-01f, 1.11935083e-02f, 1.08298257e-01f, -1.52239427e-01f, 1.06607906e-33f, 9.76060554e-02f, 1.43075287e-01f, 4.15175185e-02f,
  -2.44147003e-01f, 4.14287634e-02f, -1.55151382e-01f, 5.18823229e-02f, 1.20791227e-01f, -1.16444312e-01f, -5.38172908e-02f, 9.98374373e-02f, 1.78505659e-01f, -2.76311915e-02f,
  -1.02034681e-01f, -8.09684023e-02f, 1.12539276e-01f, 1.24156743e-01f, 1.54930249e-01f, -1.23324357e-01f, 9.08450410e-02f, 2.95839682e-02f, 8.06546360e-02f, -9.13372487e-02f,
  4.17003147e-02f, -8.52529407e-02f, -1.77870139e-01f, -1.71830002e-02f, 1.55335635e-01f, -4.36573066e-02f, -2.31873989e-01f, 1.24643594e-01f, -1.87560599e-02f, -1.07802689e-01f,
  1.68952331e-01f, -1.70389652e-01f, -2.11062953e-01f, -1.81076944e-01f, 8.24380144e-02f, -6.23576306e-02f, -6.46741362e-03f, -2.96670288e-01f, -8.68555903e-02f, 4.00923342e-02f,
  -1.68883204e-01f, 6.75119460e-02f, -1.63411237e-02f, -3.98220532e-02f, 8.96093473e-02f, -8.54094978e-03f, 4.26843874e-02f, -6.59857839e-02f, 2.20206171e-01f, -1.42493974e-02f,
  1.55566454e-01f, 1.08832195e-01f, 3.95504795e-02f, 4.76891585e-02f, -9.22182426e-02f, 1.57090500e-01f, -1.23391002e-01f, 1.84447933e-02f, 3.11177913e-02f, -1.67406220e-02f,
  -6.77288694e-32f, -6.00915514e-02f, -5.84305339e-02f, 2.25443676e-01f, -1.20448433e-01f, 1.69497594e-01f, 8.08985531e-02f, -8.74846056e-02f, 3.15194093e-02f, 2.34494716e-01f,
  -2.76491910e-01f, -1.43141463e-01f, -1.35461777e-01f, 8.82903188e-02f, 5.31090461e-02f, 6.13253042e-02f, 7.99585208e-02f, 7.99183100e-02f, 7.74490908e-02f, -1.01323478e-01f,
  7.25895464e-02f, 1.63314827e-02f, 1.95137724e-01f, -6.58273846e-02f, 1.53203532e-01f, -2.06777602e-02f, -3.09630126e-01f, 1.74063012e-01f, -8.74301717e-02f, -7.95661435e-02f,
  1.88413441e-01f, 3.71080986e-03f, 4.44092862e-02f, 8.64625648e-02f, 1.11655667e-01f, -1.55912682e-01f, -2.25234404e-02f, 1.35316774e-01f, 1.19981878e-01f, -5.41216433e-02f,
  2.10583329e-01f, -1.92173138e-01f, 7.97170252e-02f, -1.27196416e-01f, 1.36810288e-01f, 2.39508264e-02f, 7.41168186e-02f, -7.23402500e-02f, -1.68772548e-01f, -8.11602697e-02f,
  -8.03026464e-03f, 1.79369286e-01f, -2.42113113e-01f, 4.29436862e-02f, -2.22987290e-02f, -1.43557757e-01f, -3.36378999e-02f, 8.98966044e-02f, 1.85072780e-01f, -1.94239467e-01f,
  1.45569229e-02f, -1.64734162e-02f, 1.13141276e-01f, 8.71837884e-02f, 2.14291019e-32f, 3.60113196e-02f, 2.10742936e-01f, -1.42109856e-01f, 1.56997547e-01f, -8.02104622e-02f,
  1.90657213e-01f, 6.30188510e-02f, -6.45373166e-02f, -7.88660347e-03f, 1.92495212e-01f, 2.54903678e-02f, 6.09234609e-02f, 2.34145671e-01f, 1.12517416e-01f, 8.93449709e-02f,
  -3.72930653e-02f, -6.55691102e-02f, 1.67436510e-01f, 1.14452772e-01f, 5.69340438e-02f, 1.15450747e-01f, -1.45036250e-01f, -2.39052996e-02f, -8.08963180e-02f, -7.30605721e-02f,
  1.94001362e-01f, -1.63659453e-01f, -1.26078740e-01f, 6.79470506e-03f, 3.31581719e-02f, -9.51649472e-02f, 1.61082804e-01f, -2.02609450e-02f, -3.24526653e-02f, 1.15729325e-01f,
  -1.48219764e-01f, 1.52195367e-04f, -7.23842531e-02f, -6.90141097e-02f, 7.64506757e-02f, 1.44548893e-01f, 4.03672494e-02f, 2.89528631e-02f, -4.10746895e-02f, 6.31698072e-02f,
  5.96749522e-02f, -6.53783465e-03f, -1.19102277e-01f, 1.46173611e-01f, 8.68519172e-02f, 7.79712424e-02f, -2.19600901e-01f, 1.70094684e-01f, -4.81233038e-02f, -5.15913218e-02f,
  -2.40132987e-01f, 7.61955092e-03f, -1.11274347e-01f, 2.50040796e-02f, -2.25444715e-02f, 6.05751236e-04f, 2.28647068e-01f, -1.30682394e-01f, -2.36027599e-32f, 1.83040768e-01f,
  1.67254597e-01f, -2.45924050e-04f, -8.91409665e-02f, -1.56428944e-02f, -1.58021435e-01f, 1.36357486e-01f, 8.22752118e-02f, -2.14895204e-01f, 2.31841028e-01f, 2.45006785e-01f,
  1.43947065e-01f, 7.96285942e-02f, 2.19701626e-03f, -9.89075303e-02f, 1.63192376e-01f, -2.20630481e-03f, 2.06816643e-01f, -6.52116686e-02f, 1.49253368e-01f, -1.13009429e-03f,
  2.53493488e-02f, 1.46634728e-01f, 1.34855479e-01f, 9.90646034e-02f, -1.68405086e-01f, -1.86874121e-01f, 2.70771712e-01f, -5.34969848e-03f, -9.65791643e-02f, 2.95719147e-01f,
  -9.72756278e-03f, 3.24311256e-02f, 1.77194118e-01f, -4.22006324e-02f, -1.32033244e-01f, 3.25221941e-02f, -2.08600294e-02f, 1.68338448e-01f, 1.23287477e-01f, -1.16900824e-01f,
  -6.87858760e-02f, 1.85141694e-02f, 2.28760857e-02f, 1.72091611e-02f, -4.13055047e-02f, -9.58948117e-03f, -7.31307715e-02f, -6.34414777e-02f, 5.74733615e-02f, 5.46921119e-02f,
  -1.52687980e-02f, 8.40227604e-02f, -2.13483170e-01f, -9.21380445e-02f, -4.95586656e-02f, 1.49020642e-01f, -3.88971195e-02f, -7.31994584e-02f, -1.16962632e-02f, -4.82398272e-02f,
  -4.33817646e-03f, -8.42209682e-02f, 2.54387557e-32f, 6.22003824e-02f, 3.23310494e-02f, 1.32923931e-01f, 8.26847255e-02f, -4.67912890e-02f, 1.10907257e-01f, 3.11210621e-02f,
  -1.87504396e-01f, 4.54284921e-02f, 1.58226237e-01f, 1.46963939e-01f, 2.82039065e-02f, 4.99270968e-02f, 1.98910415e-01f, -5.10898009e-02f, 5.42429686e-02f, -1.32756561e-01f,
  -6.08831346e-02f, 3.65552828e-02f, -2.92678792e-02f, 4.35882658e-02f, 9.19597596e-03f, 6.57978207e-02f, -4.75165099e-02f, -9.69896652e-03f, -7.07835108e-02f, -1.03164524e-01f,
  9.37635750e-02f, -1.81504101e-01f, 1.38290793e-01f, 1.51614934e-01f, -5.11397868e-02f, 4.47664671e-02f, 8.95822141e-03f, -8.77045617e-02f, -1.27133042e-01f, 1.79669812e-01f,
  7.05260262e-02f, -4.01859768e-02f, 1.95770755e-01f, 4.28441260e-03f, 2.16899719e-02f, 8.29982907e-02f, 1.99297182e-02f, -1.49392597e-02f, 6.27504438e-02f, -4.28714640e-02f,
  -8.90177935e-02f, 9.63903442e-02f, -3.00039947e-02f, 4.21529710e-02f, -5.73883541e-02f, 1.64675098e-02f, 1.68788582e-01f, 2.34647542e-02f, -8.74930024e-02f, -1.30987838e-01f,
  -3.80806252e-02f, 1.65104255e-01f, -1.23266522e-02f, 2.80421466e-01f, 1.05956763e-01f, -4.44283560e-02f, -3.92779829e-32f, 1.33350389e-02f, 1.63755447e-01f, -4.47649583e-02f,
  6.18285984e-02f, -7.52691086e-03f, -2.06766482e-02f, 4.76419646e-03f, 2.36041918e-01f, -6.54615983e-02f, 1.84838157e-02f, -3.70634720e-02f, 2.78587779e-03f, 6.14287481e-02f,
  -1.55017540e-01f, 1.32587448e-01f, 2.54449528e-02f, 2.29141489e-01f, 2.38397673e-01f, -1.30752698e-01f, 2.00548485e-01f, 2.89711468e-02f, -3.68666239e-02f, -1.22435644e-01f,
  2.38337561e-01f, -1.37072369e-01f, 1.93387158e-02f, 1.65654778e-01f, 2.57707611e-02f, 1.99282259e-01f, -5.27778864e-02f, -1.13608778e-01f, 1.22556664e-01f, 1.42605484e-01f,
  1.30364269e-01f, -2.82366797e-02f, 1.36391133e-01f, -1.16420742e-02f, -1.51349083e-01f, 6.56711012e-02f, -2.20189005e-01f, 3.26019302e-02f, 4.07808498e-02f, -1.87581517e-02f,
  -6.70024659e-03f, 2.24342924e-02f, 7.45538101e-02f, 1.02892369e-01f, -1.71391163e-02f, 5.18946350e-02f, 6.21916689e-02f, -1.14290863e-02f, -7.88509939e-03f, 1.41602498e-03f,
  4.54726294e-02f, 1.39408916e-01f, -1.10668361e-01f, 5.12029231e-02f, -2.18327958e-02f, 8.78826901e-02f, -1.64930429e-02f, -8.76855403e-02f, 1.09641120e-01f, 8.27366393e-03f,
  -2.73900910e-33f, 8.11739415e-02f, 6.34545758e-02f, 8.72243270e-02f, 3.18676308e-02f, 2.89845634e-02f, -1.14580601e-01f, 5.33710048e-02f, 1.48346305e-01f, 6.18942594e-03f,
  1.70070119e-02f, -4.28015977e-04f, 1.76124886e-01f, -7.67113641e-02f, -9.36727822e-02f, -1.41973970e-02f, 9.58388522e-02f, 1.92914069e-01f, 1.70655638e-01f, -1.67005718e-01f,
  1.59151524e-01f, -9.05607268e-02f, 1.89783186e-01f, 6.56381324e-02f, 1.01142742e-01f, 9.45791528e-02f, -1.49034411e-01f, 1.04336560e-01f, 2.28548363e-01f, 1.11075854e-02f,
  -8.31289887e-02f, 1.99591875e-01f, 1.12633608e-01f, -5.49847521e-02f, 8.43744278e-02f, -1.09581590e-01f, 3.77870424e-06f, 4.14203517e-02f, -3.59710045e-02f, 1.32533774e-01f,
  -7.81663433e-02f, -8.82678032e-02f, 1.02789812e-02f, -6.42405152e-02f, -2.68146745e-03f, -3.09522934e-02f, -1.86451264e-02f, 2.38269679e-02f, -4.52101640e-02f, -3.81089747e-02f,
  -4.27713729e-02f, -1.40885599e-02f, -4.36499268e-02f, 2.46340297e-02f, -7.53581077e-02f, -6.92389682e-02f, -5.91654815e-02f, -4.54339618e-03f, -1.92207135e-02f, -6.58574626e-02f,
  1.17275193e-02f, -5.41713126e-02f, -1.27372891e-02f, -3.17142438e-03f, -6.09382663e-40f, 5.80228167e-04f, -2.97496598e-02f, -4.66575511e-02f, 1.33730669e-03f, -5.58248200e-02f,
  -2.10596491e-02f, -3.32120247e-03f, -4.88723665e-02f, -4.95138913e-02f, -6.68672379e-03f, -8.09651334e-03f, -1.03440015e-02f, -4.36327979e-02f, -1.39453756e-02f, -4.69213352e-02f,
  -1.62197453e-38f, -6.53254688e-02f, -3.70589681e-02f, 2.08499213e-03f, -3.52607407e-02f, -4.66701575e-02f, -5.25604635e-02f, -7.64222955e-03f, -6.89199418e-02f, -5.04743075e-03f,
  8.12287536e-03f, -8.23145285e-02f, -1.56117848e-03f, -5.22951223e-02f, -1.13532133e-02f, -3.54507775e-03f, -2.39006430e-02f, -2.67722625e-02f, -3.50362808e-02f, 6.14550663e-03f,
  -2.36870889e-02f, -7.19914958e-03f, -3.61117534e-02f, -1.50394486e-02f, 7.01401616e-03f, -1.91492797e-03f, -2.34915577e-02f, -2.88511254e-02f, -3.05547472e-02f, -2.76519395e-02f,
  -3.64197157e-02f, -1.94362663e-02f, -2.57154275e-02f, -1.78866554e-02f, -1.51357045e-02f, -2.81354859e-02f, -2.89853057e-03f, -7.07949884e-03f, -4.47200350e-02f, -4.84934822e-02f,
  -2.93041803e-02f, -3.15400548e-02f, -2.36766562e-02f, -4.35564108e-02f, 1.12202642e-02f, -4.31418419e-02f, -1.32023199e-02f, -2.62720082e-02f, 5.14240103e-40f, -1.17511414e-02f,
  -3.35271582e-02f, -4.36657071e-02f, -2.99169924e-02f, -3.22289132e-02f, -3.64624597e-02f, -1.85754187e-02f, -1.82711817e-02f, -4.52305228e-02f, -2.34226231e-02f, -2.07671821e-02f,
  -2.43610200e-02f, -2.32271496e-02f, -3.44164148e-02f, -4.67395186e-02f, -4.70688980e-38f, -2.71882508e-02f, -2.12689992e-02f, -2.92013381e-02f, -2.96504740e-02f, -2.46277787e-02f,
  -3.39025445e-02f, -2.30257828e-02f, -4.00988013e-02f, -2.94708759e-02f, -2.21458040e-02f, -5.04942350e-02f, -2.01897100e-02f, -4.77756374e-02f, -3.38008218e-02f, -1.72621012e-02f,
  -2.78549083e-02f, -7.89740123e-03f, -2.31497455e-02f, 1.92478322e-03f, -2.32359432e-02f, -3.10589969e-02f, -2.93447655e-02f, -8.20251554e-03f, -3.64658460e-02f, 5.05962595e-03f,
  -5.24725467e-02f, -6.91455901e-02f, -6.16298132e-02f, 3.39040486e-03f, -4.66988198e-02f, -4.97632921e-02f, 1.04851678e-01f, -8.77735112e-03f, 5.33143952e-02f, -3.15649286e-02f,
  -2.82251984e-02f, 1.13201579e-02f, -1.06442131e-01f, 2.04423554e-02f, -2.17544772e-02f, 1.01072699e-01f, -7.75701180e-02f, -3.80885564e-02f, -4.11000811e-02f, -1.70267895e-01f,
  5.72341867e-02f, -1.32942647e-01f, -7.15341621e-32f, 6.81927875e-02f, -1.83608904e-02f, 1.83804512e-01f, 1.31978365e-02f, 1.27343073e-01f, 2.74581071e-02f, 2.91595515e-02f,
  -1.46711677e-01f, 8.36405456e-02f, 2.31309291e-02f, 6.39373139e-02f, 2.38488000e-02f, 1.29315807e-02f, 1.83404014e-01f, -8.41929913e-02f, 4.15171683e-02f, -1.91410452e-01f,
  -5.23214526e-02f, 2.84001194e-02f, -7.55383670e-02f, -1.53661733e-02f, 1.10468663e-01f, 8.68049860e-02f, -8.92390013e-02f, 6.95396513e-02f, -2.08784238e-01f, -1.09313548e-01f,
  1.74887702e-01f, -2.93444425e-01f, 1.69175267e-01f, 1.43385574e-01f, -3.96076776e-02f, 1.76730491e-02f, -4.35047131e-03f, -9.71609652e-02f, -6.93119615e-02f, 1.55360594e-01f,
  2.29196295e-01f, 2.35485546e-02f, 2.96236753e-01f, -8.96797478e-02f, -2.42575575e-02f, -3.36860679e-02f, 5.24895452e-02f, -3.20935175e-02f, 4.92018089e-02f, 4.42560315e-02f,
  -5.77783249e-02f, -5.03518991e-02f, 5.23819439e-02f, 7.24998023e-03f, -6.66070282e-02f, 3.20906006e-02f, -5.36302291e-02f, -3.13817225e-02f, -8.87149274e-02f, -3.96174006e-02f,
  -1.33549020e-01f, -7.61428475e-03f, -5.45918085e-02f, -6.30299151e-02f, 9.08949375e-02f, -1.22984521e-01f, 1.62514798e-31f, 1.16443269e-01f, 4.74393629e-02f, 2.34816857e-02f,
  -8.40372071e-02f, -2.23223288e-02f, -1.10694103e-01f, 5.75402752e-02f, 3.28938030e-02f, -1.54871583e-01f, 6.71742111e-02f, 8.07924494e-02f, 8.78155828e-02f, -5.20821102e-02f,
  5.55894850e-03f, -8.02902803e-02f, 5.99207059e-02f, -1.76015198e-02f, 7.75154904e-02f, -6.31984994e-02f, 1.13873117e-01f, -4.12259400e-02f, 7.42203137e-03f, 6.88937902e-02f,
  -3.26236673e-02f, -3.80134247e-02f, -1.06762111e-01f, -5.32394685e-02f, 9.08682644e-02f, -7.69026428e-02f, -1.40042111e-01f, 1.33584812e-01f, -6.04521073e-02f, 1.34814233e-02f,
  6.87917918e-02f, -5.35144396e-02f, -1.20458245e-01f, -8.85472260e-03f, 1.23098064e-02f, 4.06551622e-02f, -4.97943237e-02f, -6.90251142e-02f, 7.53959361e-03f, 6.00939691e-02f,
  1.41744863e-03f, -7.93968737e-02f, -8.62249881e-02f, 2.18619592e-02f, -1.44820720e-01f, 1.02500673e-02f, -1.71581537e-01f, 1.77149981e-01f, 4.17127162e-02f, -1.14767797e-01f,
  -1.24372477e-02f, 2.29682829e-02f, 3.39015126e-01f, 1.54271862e-02f, 3.84912729e-01f, -5.78274764e-02f, -1.71043858e-01f, 3.98898646e-02f, -1.08838409e-01f, 7.86973462e-02f,
  -5.21134188e-33f, -8.72910097e-02f, 1.35553420e-01f, -1.24187283e-01f, 5.99454194e-02f, 9.33928266e-02f, 1.82080090e-01f, -7.62711978e-03f, 3.25239375e-02f, 1.85225800e-01f,
  3.05198617e-02f, -3.21516059e-02f, 2.89957430e-02f, 2.38431543e-01f, 7.05852211e-02f, 6.50490373e-02f, -1.99235454e-02f, 9.03113633e-02f, -3.66978161e-02f, -1.81206241e-02f,
  -1.60997003e-01f, 2.13771984e-01f, 3.36133353e-02f, -1.34926260e-01f, 9.74374823e-03f, -8.02705809e-02f, 3.56435627e-02f, 8.28315038e-03f, -1.13358632e-01f, -2.40455545e-03f,
  4.41918746e-02f, -1.07353486e-01f, 4.11048494e-02f, -1.82808504e-01f, 9.58669633e-02f, -1.88136436e-02f, -1.64417341e-01f, -5.13062142e-02f, 1.84574798e-01f, -2.71875143e-01f,
  6.89103752e-02f, -1.46584794e-01f, 4.82582254e-03f, 1.14856372e-02f, -2.75307912e-02f, 2.64447788e-03f, -3.02246790e-02f, -1.40568744e-02f, -1.48126734e-02f, -2.14278270e-02f,
  -7.77656306e-03f, -2.35950574e-02f, 3.01036257e-02f, 1.33152781e-02f, -2.91214176e-02f, -4.54426333e-02f, -5.08886613e-02f, -3.74487638e-02f, -3.50297131e-02f, -2.97055300e-02f,
  -7.95755163e-03f, 3.39503749e-03f, -2.73605902e-02f, -2.52966639e-02f, -6.59961614e-33f, -2.54007317e-02f, -2.56805886e-02f, -4.43288125e-02f, -2.95505784e-02f, -5.49951866e-02f,
  -3.44496034e-02f, -2.77769174e-02f, -7.47472513e-03f, -4.75396439e-02f, -3.65222916e-02f, -3.18977572e-02f, -2.61487905e-02f, -4.00509536e-02f, -3.22398916e-02f, -4.50625643e-02f,
  -3.69011632e-38f, -1.31932208e-02f, -1.52189601e-02f, -3.26270424e-02f, -1.98989902e-02f, -4.25319783e-02f, -4.59737517e-02f, -1.74080972e-02f, -2.64832582e-02f, -3.91889848e-02f,
  -2.65841950e-02f, -2.65106075e-02f, -3.73891592e-02f, -6.45062141e-03f, -4.10750806e-02f, -3.37118842e-02f, -3.41913179e-02f, -2.75103822e-02f, -3.02370954e-02f, -2.26671007e-02f,
  -2.96164751e-02f, -2.89032515e-02f, -3.92186940e-02f, -2.83068754e-02f, -4.68692221e-02f, -1.57378782e-02f, 6.52199313e-02f, 3.25385407e-02f, 8.20768476e-02f, 1.82886757e-02f,
  4.29392308e-02f, 8.30808356e-02f, -1.06130175e-01f, 1.30622417e-01f, -1.68144107e-01f, 1.61194235e-01f, -9.08114016e-02f, -2.11287484e-01f, 2.71257088e-02f, -1.23710483e-01f,
  2.90236592e-01f, 9.77719352e-02f, 3.92369360e-01f, -1.00367434e-01f, -1.00434281e-01f, 1.33225815e-02f, -1.55463107e-02f, 9.61557329e-02f, 4.77836801e-34f, -3.15876231e-02f,
  1.30322188e-01f, -8.65478888e-02f, 3.73534970e-02f, -1.81015227e-02f, 5.86184040e-02f, 4.71834652e-02f, 1.08267546e-01f, 9.16293040e-02f, 1.32390186e-01f, 1.35497227e-01f,
  1.56609371e-01f, 2.30883986e-01f, -1.11775890e-01f, 6.08117804e-02f, 1.86081212e-02f, 1.06646337e-01f, 1.54893715e-02f, 1.25798464e-01f, -1.57054156e-01f, 2.31890902e-01f,
  -1.35435432e-01f, -4.78529856e-02f, -9.20274556e-02f, 5.86552657e-02f, 2.48827357e-02f, -1.45435423e-01f, -6.75355867e-02f, 1.51449898e-02f, 5.12765720e-02f, -1.45159215e-01f,
  7.09846839e-02f, -2.87029952e-01f, 6.82328120e-02f, -4.57747169e-02f, -1.15857646e-01f, -1.34278610e-01f, 1.53691381e-01f, -2.76589155e-01f, -1.19637065e-01f, -1.48260817e-01f,
  5.34370393e-02f, 4.50934470e-02f, 1.65331718e-02f, 3.96296233e-02f, -4.92673144e-02f, 7.01697096e-02f, 7.94818029e-02f, 4.67851050e-02f, 3.68470588e-04f, -2.35996731e-02f,
  1.15760408e-01f, -1.14794344e-01f, 9.11082774e-02f, 1.01550780e-01f, 8.92809778e-02f, -1.11183353e-01f, 1.18129276e-01f, 9.85454991e-02f, -1.05564214e-01f, 7.58373812e-02f,
  -2.17079185e-02f, 1.52771190e-01f, 5.22223651e-34f, -5.60485423e-02f, 7.96090290e-02f, -3.87568176e-02f, -2.27228865e-01f, 9.14656594e-02f, -4.43994142e-02f, -2.61007678e-02f,
  1.36573076e-01f, 1.69167854e-02f, -1.52261391e-01f, -6.61500543e-02f, 6.39985204e-02f, 9.31761712e-02f, -2.94410914e-01f, 5.21480292e-02f, 8.86930525e-02f, 2.05330193e-01f,
  1.17935851e-01f, -8.02860186e-02f, 2.69892607e-02f, 6.97324648e-02f, 9.65848714e-02f, -2.99654394e-01f, 1.57243654e-01f, -1.32949091e-03f, 4.71584573e-02f, 1.20211177e-01f,
  -1.45902401e-02f, 1.00742266e-01f, -1.41825423e-01f, -6.85223117e-02f, 9.99027416e-02f, -1.40843749e-01f, 1.28595546e-01f, -1.10747740e-01f, 9.86865605e-04f, -2.92698532e-01f,
  5.25108129e-02f, -8.90915468e-02f, -2.02515647e-01f, -2.25032166e-01f, -4.10078606e-03f, -3.21961194e-02f, -7.17497990e-02f, -2.20435038e-02f, 3.33636217e-02f, -4.46681269e-02f,
  -1.77000165e-02f, -1.84834022e-02f, -1.54734578e-03f, 2.26750431e-04f, 5.67802191e-02f, 1.24015287e-02f, -1.23402057e-02f, -1.90282892e-02f, -3.72525603e-02f, -4.79075424e-02f,
  -6.42450824e-02f, 3.63954753e-02f, -4.76400740e-02f, 2.27085669e-02f, -2.68292706e-02f, -2.79136859e-02f, -5.04351139e-40f, -3.23885754e-02f, -4.13161442e-02f, -4.09530587e-02f,
  -4.37387899e-02f, -3.70205007e-02f, -3.28200310e-02f, -7.24262446e-02f, 1.62231773e-02f, -3.53926122e-02f, -9.32291374e-02f, -8.23227093e-02f, -6.70848414e-02f, -3.79746035e-02f,
  -5.07659428e-02f, -3.75797674e-02f, -5.17220336e-31f, 9.19337012e-03f, -6.35098340e-03f, -7.41014928e-02f, 8.87019187e-03f, -3.55050191e-02f, -2.56964136e-02f, -4.49826047e-02f,
  -8.20680801e-03f, -5.26877083e-02f, -4.11711410e-02f, 4.93431743e-03f, -6.54594749e-02f, 1.58723928e-02f, -4.51447405e-02f, -6.25022724e-02f, -6.30311593e-02f, -1.56646874e-02f,
  -3.79240443e-03f, -5.82226701e-02f, -6.20612642e-03f, -4.17573489e-02f, -4.77616005e-02f, -8.00149888e-03f, -4.67973910e-02f, -2.96992902e-02f, -3.69754098e-02f, -2.56286338e-02f,
  2.19828598e-02f, -7.64819384e-02f, -1.24061815e-02f, 1.43609075e-02f, -8.85874480e-02f, -1.88715779e-03f, -1.98146123e-02f, 3.14744264e-02f, -7.47553259e-02f, -6.52487874e-02f,
  -7.03422576e-02f, -9.35525298e-02f, 1.90445483e-02f, -4.92197834e-02f, 2.08777916e-02f, -6.18407242e-02f, -8.04471225e-02f, -1.59927215e-02f, 1.25225827e-01f, -6.08964600e-02f,
  -1.11542318e-31f, 6.83503151e-02f, 1.10583708e-01f, -1.80037748e-02f, -4.68585938e-02f, -1.08909700e-03f, -7.89724961e-02f, 5.47279119e-02f, 4.83254492e-02f, -6.47233799e-02f,
  1.25874922e-01f, 8.57705772e-02f, 1.24055639e-01f, 9.66825336e-02f, 6.45899074e-03f, -3.83572392e-02f, 8.79341885e-02f, -2.08155550e-02f, 7.29954466e-02f, 2.18151556e-03f,
  -1.56669561e-02f, 8.42652991e-02f, -3.42918858e-02f, -2.15459410e-02f, 1.33871753e-02f, -4.76949029e-02f, -8.35911930e-02f, -1.27505749e-01f, 8.59392881e-02f, -5.43438159e-02f,
  -7.06882998e-02f, 6.51983097e-02f, 4.47006673e-02f, -5.77645190e-02f, 7.36355633e-02f, -6.26555011e-02f, -1.69584244e-01f, -1.03697941e-01f, 1.07974701e-01f, -2.82520074e-02f,
  -1.14799971e-02f, -1.37918591e-01f, -2.61161593e-03f, -5.69593944e-02f, -8.53074156e-03f, 9.52531919e-02f, -2.10597292e-02f, -7.72397295e-02f, 1.34647742e-01f, 2.39661569e-03f,
  1.63176984e-01f, -5.54005727e-02f, -8.23836587e-03f, 1.06725082e-01f, 6.42260537e-02f, 7.11721107e-02f, -2.19462514e-01f, 2.76949294e-02f, -2.30345353e-01f, 1.88060120e-01f,
  7.54730627e-02f, 1.19158417e-01f, 7.07316548e-02f, -1.74326487e-02f, -1.17711606e-31f, -1.63476076e-02f, -1.11045696e-01f, 1.82561487e-01f, 7.64109707e-03f, 3.16385627e-02f,
  9.62009951e-02f, -6.39781505e-02f, 1.31600842e-01f, 1.32122874e-01f, -1.15204066e-01f, -1.43705457e-01f, -1.79505106e-02f, 6.69344142e-02f, 1.27668325e-02f, 1.50864825e-01f,
  6.87862560e-02f, 6.62059709e-02f, -2.57756133e-02f, -1.50168166e-01f, 1.67620599e-01f, -1.08502150e-01f, 1.14449479e-01f, -1.28478743e-02f, 2.03383386e-01f, -5.40754274e-02f,
  -1.20504864e-01f, -4.45077149e-03f, -8.20473060e-02f, -2.31634602e-02f, 1.79300979e-01f, 1.80840883e-02f, -4.29821061e-03f, 1.31846040e-01f, -1.54181421e-02f, 7.52980309e-03f,
  2.10943818e-01f, 1.80293322e-01f, -8.18836614e-02f, 2.41214037e-01f, 1.47704128e-02f, 7.25554004e-02f, 3.53107730e-08f, 2.79819883e-08f, 6.66002475e-10f, 2.19096545e-08f,
  3.09026866e-08f, 2.19792115e-10f, -1.55071747e-10f, -2.89482396e-11f, 9.79956602e-11f, 1.06121667e-10f, 1.67375037e-11f, 3.02623682e-09f, -9.82528903e-09f, -1.68570247e-09f,
  -3.58969299e-10f, 8.75460482e-10f, 4.45094323e-10f, -2.41763254e-09f, 3.03376657e-10f, 5.62155389e-09f, 1.28952224e-10f, -1.12693934e-08f, -5.16836709e-40f, 1.40408196e-09f,
  -3.42067569e-10f, -6.77641943e-10f, -7.23215154e-10f, -4.58405258e-10f, 2.50220344e-10f, 1.93658589e-10f, 6.81989620e-09f, -6.00000827e-10f, 3.62782998e-10f, 9.26674959e-10f,
  -1.77029030e-10f, 5.74086612e-10f, -6.29612085e-10f, 8.87321883e-10f, 1.26895050e-09f, 3.09376358e-10f, -1.61525834e-10f, -1.85143859e-10f, -1.54769815e-08f, 5.28125599e-10f,
  -1.10550243e-10f, -2.10067910e-08f, -1.68730363e-08f, -1.20887718e-08f, -2.42007997e-10f, -3.47125440e-10f, -7.87625132e-10f, 5.08093878e-09f, -1.73655673e-10f, 6.40965170e-10f,
  3.80595444e-10f, -3.88759425e-09f, 3.51021823e-10f, -3.65677932e-10f, -2.93457383e-08f, -1.35904150e-08f, 1.38184486e-09f, -8.63870575e-09f, -4.15814272e-10f, -1.08858682e-08f,
  6.62309304e-03f, 5.34788668e-02f, -3.23189646e-02f, -6.10689037e-02f, -1.21068023e-03f, -1.65932346e-02f, -9.27637294e-02f, 8.12046081e-02f, -3.02240271e-02f, 9.12719369e-02f,
  2.93508377e-02f, 2.93971170e-02f, 1.99445292e-01f, 1.11216053e-01f, 7.75554702e-02f, -9.00264755e-02f, -4.37269136e-02f, 1.41240999e-01f, -9.50242579e-02f, 1.63592905e-01f,
  6.32658973e-02f, -9.07199457e-03f, -2.92496423e-33f, -1.02449639e-03f, 1.37682736e-01f, 1.31034732e-01f, -3.09458748e-02f, 8.84393901e-02f, 9.15708020e-03f, -1.37207629e-02f,
  1.89159229e-01f, 6.69174492e-02f, -5.27387895e-02f, 1.26164556e-02f, 8.83601308e-02f, 8.17190111e-02f, -4.70152013e-02f, 8.03967342e-02f, 2.25773230e-02f, 2.32898548e-01f,
  1.39566526e-01f, -6.45697415e-02f, 1.61066324e-01f, 1.06792405e-01f, 2.82480698e-02f, -1.96335148e-02f, 1.45952314e-01f, 4.54259776e-02f, -9.96210948e-02f, 1.52884528e-01f,
  -2.43772864e-02f, 1.35746732e-01f, -2.07198970e-02f, -7.92403370e-02f, 6.95676506e-02f, 1.75533053e-02f, 1.51377365e-01f, -5.09988666e-02f, 2.76702493e-02f, -4.15174365e-02f,
  -3.13809179e-02f, 1.90331116e-02f, -5.01714386e-02f, 8.65874928e-04f, 4.67878468e-02f, 6.89403862e-02f, 1.71898063e-02f, -7.60060921e-02f, -6.42320514e-02f, 2.47393642e-02f,
  -9.88045335e-02f, -2.13131253e-02f, -1.62446171e-01f, 1.04487166e-01f, -9.86013934e-03f, -5.68151735e-02f, -2.56114993e-02f, -1.25267327e-01f, 1.83716416e-01f, 1.60003930e-01f,
  3.53570700e-01f, -8.56450424e-02f, 7.41385669e-03f, 6.37586489e-02f, -1.26549721e-01f, 7.09240958e-02f, -1.66185349e-33f, -4.97072972e-02f, 1.22532090e-02f, -1.09786890e-01f,
  7.31838793e-02f, -1.85474493e-02f, 1.16678312e-01f, 4.59429622e-02f, 8.02983996e-03f, -2.42798347e-02f, 1.79309994e-01f, -3.89743745e-02f, -9.03107459e-04f, 2.40763009e-01f,
  6.95020109e-02f, 6.82272539e-02f, 1.83984134e-02f, 5.46083786e-02f, -5.90384305e-02f, 5.46930321e-02f, -1.47557408e-01f, 1.81172162e-01f, -7.22160265e-02f, 1.77588239e-02f,
  -7.81569630e-02f, 2.47387309e-02f, 1.89443856e-01f, 9.32535273e-04f, -1.56330511e-01f, 9.76714641e-02f, 6.56487793e-02f, -8.98316354e-02f, 1.90018490e-01f, -1.35949731e-01f,
  -1.88122876e-02f, 8.88264701e-02f, -5.29991649e-02f, -7.45591372e-02f, 5.17877340e-02f, -9.49297175e-02f, -1.31336510e-01f, 1.68136984e-01f
};

// L3_fan_Bp_bar (Shape: 1 x 52)
const int L3_fan_Bp_bar_rows = 1;
const int L3_fan_Bp_bar_cols = 52;
const float L3_fan_Bp_bar_data[] = {
  4.49039740e-03f, 1.69286169e-02f, 4.12984192e-02f, 4.54518571e-03f, 1.50037708e-03f, 5.28499596e-02f, -1.89487338e-02f, 1.31350402e-02f, -2.51879506e-02f, 6.06871322e-02f,
  1.21579887e-02f, 2.21477896e-02f, 3.27986740e-02f, -2.73189507e-02f, -2.99019087e-02f, -1.02319680e-02f, 3.82799245e-02f, 1.57388076e-02f, -2.15016045e-02f, -2.80638069e-05f,
  4.48426455e-02f, 4.88460772e-02f, 1.05788693e-01f, -4.05004323e-02f, 2.43927464e-02f, 3.21553461e-02f, 1.85872579e-03f, 6.58878535e-02f, -5.37545746e-03f, 7.51750097e-02f,
  -4.66697179e-02f, -4.87880222e-03f, -2.99861636e-02f, 7.84930140e-02f, 2.83617172e-02f, 3.10991262e-03f, -9.31323133e-03f, 8.19705240e-03f, -2.95968298e-02f, -3.98301072e-02f,
  -2.49812827e-02f, -1.06871910e-02f, 5.21192178e-02f, -4.08388674e-02f, 2.86889505e-02f, 5.50433574e-03f, -5.06930202e-02f, -2.00056732e-02f, -4.64353934e-02f, -1.36664209e-08f,
  5.60640246e-02f, 8.60285312e-02f
};

// L4_linear_W (Shape: 12 x 64)
const int L4_linear_W_rows = 12;
const int L4_linear_W_cols = 64;
const float L4_linear_W_data[] = {
  8.51437673e-02f, -1.23655424e-01f, -4.83064093e-02f, -7.78666213e-02f, -1.14798658e-01f, 6.47080764e-02f, -2.21420690e-01f, 1.42689124e-01f, 2.25812569e-01f, 1.80223927e-01f,
  -1.01753473e-01f, -1.51867904e-02f, 1.89073324e-01f, -1.58359483e-01f, -1.06835343e-01f, 4.81896065e-02f, 6.36306405e-02f, 1.11550666e-01f, 8.39412659e-02f, 5.10034747e-02f,
  5.97763471e-02f, -1.57984242e-01f, -3.28026980e-01f, -9.42182168e-02f, 9.72463787e-02f, -2.78621376e-01f, -9.93584916e-02f, -2.79554456e-01f, 8.66713449e-02f, 5.17898835e-02f,
  1.69058666e-01f, 2.24582914e-06f, -8.15973058e-02f, 9.55014862e-03f, 6.13660133e-03f, -1.25128748e-02f, 1.02152966e-01f, -8.33782740e-03f, -7.90995255e-05f, -1.49317123e-02f,
  4.87413034e-02f, -1.03276178e-01f, -2.91107297e-01f, 4.71997887e-01f, -1.57811165e-01f, -4.88521643e-02f, 1.97305977e-01f, 1.50583327e-01f, -1.94022879e-01f, 9.81743410e-02f,
  6.52361335e-03f, -5.28841540e-02f, 1.31557107e-01f, 2.92067826e-01f, -2.12114424e-01f, -3.86246340e-03f, -1.37051314e-01f, -2.17354804e-01f, -4.10027541e-02f, 1.45451367e-01f,
  -2.52832174e-01f, 1.95819227e-09f, -8.09203312e-02f, -3.64981323e-01f, -1.11173593e-01f, 1.82496924e-02f, -1.14856847e-01f, -5.07614203e-02f, -6.78555220e-02f, -2.44042743e-02f,
  -9.64331552e-02f, -6.02507479e-02f, 6.40650615e-02f, 1.55422688e-01f, 4.96030711e-02f, -1.33310199e-01f, 6.17877878e-02f, -1.14212148e-01f, -2.64065396e-02f, -3.07669584e-02f,
  3.72509994e-02f, 1.18278742e-01f, 1.69835061e-01f, 1.19009323e-01f, 1.09367132e-01f, -1.47641957e-01f, -2.44986966e-01f, -2.01283425e-01f, -7.20569072e-03f, -3.02021788e-03f,
  6.86722174e-02f, -1.24961622e-01f, 1.30683959e-01f, -9.25912857e-02f, 5.05598709e-02f, -1.43418060e-06f, 2.33174667e-01f, -2.93908715e-01f, 1.86176449e-01f, 2.04770684e-01f,
  -1.22867912e-01f, -8.03775247e-03f, -2.33317050e-03f, -1.07003793e-01f, -4.96422857e-01f, -3.46932530e-01f, -2.60068804e-01f, -3.04833293e-01f, -2.93076038e-02f, -4.72306320e-03f,
  -1.02860138e-01f, 1.35702208e-01f, -2.64059216e-01f, -1.80129841e-01f, -1.71070285e-02f, -4.04082201e-02f, 1.84723586e-01f, -2.09927753e-01f, 1.55136660e-01f, -2.76380982e-02f,
  1.91635430e-01f, -9.38374549e-02f, 4.30192426e-02f, 1.39782494e-02f, -2.33043864e-01f, 7.43100581e-10f, -1.31465465e-01f, 5.70492931e-02f, 1.33815050e-01f, -6.72188401e-02f,
  -4.31030765e-02f, 2.41673738e-02f, 6.40512109e-02f, 2.25762986e-02f, -1.11183347e-02f, -1.03904493e-01f, 1.11336999e-01f, -1.53333127e-01f, 4.82046306e-02f, -1.27555981e-01f,
  -1.28391013e-01f, 5.59106059e-02f, 4.09389623e-02f, -1.84668958e-01f, 1.14276282e-01f, 8.53825919e-03f, -1.59126863e-01f, 8.78876895e-02f, -1.92047030e-01f, 2.44206879e-02f,
  1.03994980e-01f, -1.42409667e-01f, -1.50509467e-02f, 6.74573183e-02f, 1.19145382e-02f, -7.79404640e-02f, -1.58368442e-02f, -1.87764987e-01f, -2.27981552e-01f, -4.98791860e-06f,
  1.69553101e-01f, -2.80223578e-01f, 9.60727036e-03f, -7.94378668e-02f, -1.26549259e-01f, 1.17102023e-02f, 4.73402627e-03f, -4.11106646e-01f, 1.97934046e-01f, 1.00228965e-01f,
  -8.67063925e-02f, -9.05951262e-02f, -2.39238024e-01f, 2.64573634e-01f, -2.97942847e-01f, -1.23900278e-02f, -1.67861715e-01f, -2.95336157e-01f, -5.50007783e-02f, 2.25717463e-02f,
  -1.51783735e-01f, -1.23677462e-01f, 2.98932105e-01f, 2.27164924e-02f, 1.74051166e-01f, -5.22410497e-02f, -3.31985131e-02f, -2.07364425e-01f, -2.68102884e-01f, -2.35917536e-10f,
  -4.10893381e-01f, 3.00594181e-01f, -4.71572690e-02f, 2.92773265e-02f, 9.87613797e-02f, -1.23803765e-01f, -8.33342224e-02f, 1.24415057e-02f, 2.48077102e-02f, 1.02822654e-01f,
  -1.20888785e-01f, 7.80274794e-02f, -2.01627657e-01f, 1.07464321e-01f, -1.36403427e-01f, -2.11180776e-01f, -6.03288412e-02f, 1.62100755e-02f, -3.20889086e-01f, 9.65876728e-02f,
  -3.99902731e-01f, -5.44378459e-01f, -1.86344177e-01f, -2.26677179e-01f, 1.51720986e-01f, 1.55537501e-01f, 6.60593575e-03f, -2.51126379e-01f, -1.25874266e-01f, 3.84218432e-02f,
  -2.13616058e-01f, 2.15675756e-01f, -2.16688678e-01f, -5.38388907e-04f, -3.66284996e-01f, 1.42196104e-01f, -2.96293199e-01f, -1.39730588e-01f, -2.56496608e-01f, -8.57146904e-02f,
  1.08683249e-03f, 1.87578678e-01f, -3.69657636e-01f, 7.76654780e-02f, 3.96352969e-02f, 2.23171070e-01f, 6.94377422e-02f, -3.53575200e-01f, 5.57172485e-02f, -2.24572688e-01f,
  1.98718324e-01f, 9.59384665e-02f, -1.66418478e-02f, 6.21463284e-02f, -6.40976429e-02f, -2.79730529e-01f, -1.51721731e-01f, -6.54064072e-03f, -1.68786749e-01f, 1.66823238e-01f,
  4.54772748e-02f, -1.83085397e-01f, 1.11777186e-01f, -1.25226329e-09f, 1.00209013e-01f, -3.37623417e-01f, -1.04996795e-02f, 1.85029656e-01f, 1.56044021e-01f, -3.84385549e-02f,
  -6.99248910e-02f, 1.20212629e-01f, 1.41685069e-01f, -8.72234069e-03f, -2.23544434e-01f, -3.00850756e-02f, -1.79863214e-01f, 1.43103272e-01f, 1.16642162e-01f, 9.89886150e-02f,
  -6.88049793e-02f, 1.17711790e-01f, -1.55891672e-01f, -1.38205245e-01f, -1.82348508e-02f, -5.01040705e-02f, -1.47972494e-01f, 1.44718215e-01f, -6.89494163e-02f, 1.92162678e-01f,
  2.17219859e-01f, 1.08623579e-01f, -2.19410852e-01f, -2.03464463e-01f, 5.28259650e-02f, 8.77992883e-02f, 1.23077951e-01f, 3.95741845e-05f, -1.40330404e-01f, 9.53025818e-02f,
  -2.62223005e-01f, -1.69042364e-01f, 1.28228143e-01f, -2.47841608e-02f, -9.49179812e-04f, 7.37133995e-02f, -3.35485846e-01f, -1.04213856e-01f, 1.66968685e-02f, -2.86057204e-01f,
  -2.62647212e-01f, 1.76503584e-01f, 1.64777085e-01f, 1.30346522e-03f, 2.17178166e-01f, -1.29942945e-03f, 2.46570222e-02f, 2.83316872e-03f, -3.70854139e-01f, 2.62295306e-02f,
  3.49951573e-02f, 2.27626450e-02f, 7.86354358e-04f, -3.74579996e-01f, -5.17358743e-02f, -2.07438357e-02f, 9.65592712e-02f, 5.43742718e-10f, 1.34617195e-01f, -5.87869063e-02f,
  6.76309317e-02f, -3.83723937e-02f, -8.89993608e-02f, -1.13518082e-01f, -1.58490874e-02f, -6.88094869e-02f, -1.59936264e-01f, 5.85433654e-02f, 6.20454922e-02f, 2.63700020e-02f,
  2.27744341e-01f, -1.13292694e-01f, -6.72507957e-02f, -1.16339430e-01f, 2.03209668e-02f, -1.78952634e-01f, -7.01190829e-02f, 9.82051268e-02f, 7.52298310e-02f, 1.88493699e-01f,
  -3.15389514e-01f, -8.64417329e-02f, -1.34936109e-01f, -1.89822748e-01f, 5.18833287e-03f, 1.01397559e-01f, 1.45112634e-01f, 1.59649830e-02f, 1.98654339e-01f, -6.16015829e-02f,
  4.65156697e-02f, -6.37743051e-06f, -1.08610548e-01f, 6.80982992e-02f, -4.91735972e-02f, 1.11473829e-01f, -1.84031233e-01f, 1.14106992e-02f, -7.77960871e-04f, 3.07142385e-03f,
  -1.83442309e-01f, -2.74919093e-01f, 9.16234106e-02f, -1.81634143e-01f, 9.57929716e-02f, -1.34248286e-01f, 1.55170828e-01f, 7.95629174e-02f, -1.22147240e-01f, 1.08190030e-01f,
  -3.67190987e-02f, -3.12636257e-03f, 3.11242431e-01f, 1.10728689e-03f, -3.02124321e-01f, 3.91539373e-03f, -2.45940253e-01f, -2.50082780e-02f, 7.08007487e-03f, -1.49086937e-01f,
  1.43959925e-01f, -1.93738622e-10f, -9.40635204e-02f, -3.07409078e-01f, -1.50360195e-02f, -5.66679388e-02f, 3.73796709e-02f, -5.36835231e-02f, -2.70823874e-02f, -8.19710642e-02f,
  7.75301382e-02f, -2.05676734e-01f, 1.00542016e-01f, -2.05091268e-01f, 1.53565288e-01f, -4.62745205e-02f, -4.43118103e-02f, 3.60993668e-02f, 1.05569743e-01f, -2.12159362e-02f,
  1.10936153e-03f, -2.52977699e-01f, 1.03104226e-01f, 9.85537991e-02f, -3.88142057e-02f, 1.12752751e-01f, 2.02977564e-02f, -1.35903463e-01f, 5.60793793e-03f, 1.93754196e-01f,
  1.57283768e-01f, 9.60151032e-02f, -6.84835687e-02f, -3.42350364e-01f, -2.15407848e-01f, -1.00188600e-02f, -7.36980811e-02f, 4.28084135e-02f, -1.53941050e-01f, -9.46317893e-03f,
  -1.44444391e-01f, 6.77294731e-02f, 3.29813547e-03f, -2.68005162e-01f, 4.28225368e-01f, 1.72683120e-01f, 2.80681439e-02f, -6.61418744e-05f, -2.62263864e-01f, 8.53090733e-02f,
  -2.11433038e-01f, 1.13657549e-01f, -1.85001984e-01f, -2.44547054e-01f, 1.22809000e-02f, 4.17257622e-02f, -1.29977223e-02f, -5.35753854e-02f, -3.19906116e-01f, 7.03400932e-03f,
  -2.43554771e-01f, -2.81466711e-02f, -1.86830889e-02f, -3.08680926e-02f, 5.07499017e-02f, 2.25279018e-10f, -2.53821671e-01f, -5.73983639e-02f, -1.41518591e-02f, -9.62245539e-02f,
  -2.19641738e-02f, 6.69725686e-02f, -3.48253213e-02f, 2.06756145e-02f, -2.28661448e-01f, 5.41399308e-02f, 5.14253713e-02f, -3.88948582e-02f, 6.48920015e-02f, 1.17929734e-01f,
  2.12804228e-01f, -8.25268999e-02f, -2.34246448e-01f, 1.81438431e-01f, -1.73242286e-01f, 1.47818118e-01f, -2.27797806e-01f, -2.09714219e-01f, 2.09173933e-01f, -1.86515436e-01f,
  1.12931184e-01f, 2.59184148e-02f, 8.26537237e-02f, -2.71497667e-01f, -3.08275700e-01f, -2.00557113e-01f, -2.80700147e-01f, 8.31400901e-02f, -1.39572218e-01f, -3.35369732e-05f,
  -6.70693517e-02f, -7.32887238e-02f, -1.19911708e-01f, -1.78582340e-01f, 1.09322004e-01f, -8.56205076e-02f, -2.89909240e-05f, 9.25960839e-02f, -7.24489838e-02f, -2.93160141e-01f,
  -9.40144435e-02f, 2.29044840e-01f, -2.35948652e-01f, 1.79748297e-01f, 1.08955488e-01f, -1.82330564e-01f, 6.45801872e-02f, -2.12757077e-04f, -3.45235690e-02f, 3.04247681e-02f,
  -1.93727672e-01f, 2.24695783e-02f, 1.88146830e-01f, 9.37231444e-03f, 2.23482519e-01f, 9.72220004e-02f, -5.15017547e-02f, 1.82897151e-01f, -1.10371977e-01f, -3.15968605e-11f,
  3.38940173e-02f, 2.41431501e-02f, -1.08188011e-01f, 1.62984561e-02f, 4.97598425e-02f, -7.01507628e-02f, 1.03973197e-02f, -4.26157974e-02f, 8.65554288e-02f, -1.58216178e-01f,
  1.24903381e-01f, 1.56054392e-01f, 1.56928807e-01f, -6.93680495e-02f, -1.45101741e-01f, -2.04019800e-01f, 1.49282143e-01f, -7.18042031e-02f, -8.52816701e-02f, 1.41418114e-01f,
  -4.06574532e-02f, -2.94108957e-01f, 4.98335436e-03f, -3.11458051e-01f, 9.49703604e-02f, -2.09997401e-01f, -1.60058707e-01f, 8.27074572e-02f, -4.29304726e-02f, 2.29249984e-01f,
  3.87501791e-02f, -3.76928508e-01f, -1.17798612e-01f, -4.71062685e-06f, 1.08834073e-01f, -2.24873841e-01f, -1.95309579e-01f, 1.15881465e-01f, -4.43310551e-02f, 1.00528650e-01f,
  9.81363351e-04f, -2.74519790e-02f, 1.71959743e-01f, -1.16013139e-01f, -6.57641068e-02f, 1.26858884e-02f, 2.67045259e-01f, -5.38992211e-02f, -2.85723090e-01f, 1.36293054e-01f,
  -1.19206116e-01f, -2.50666320e-01f, 1.84203088e-02f, 6.93176640e-03f, 1.58896044e-01f, 2.28825733e-02f, 2.25505501e-01f, -2.54995730e-02f, -1.68002367e-01f, -2.76130468e-01f,
  1.49246724e-02f, 6.80784648e-03f, 8.14922750e-02f, -4.85375351e-10f, 3.97582026e-03f, -7.52310902e-02f, -8.82518962e-02f, -4.91354316e-02f, 1.18981861e-01f, -2.22009346e-02f,
  6.21760869e-03f, 4.11436297e-02f, 8.00753310e-02f, 1.94378778e-01f, -2.11717188e-01f, -1.89456120e-01f, -1.72032595e-01f, -3.98104712e-02f, -1.39343426e-01f, 1.47082552e-01f,
  -1.11999661e-01f, -2.56200194e-01f, 1.94499105e-01f, -3.27539116e-01f, -7.69645348e-02f, 1.73839033e-01f, -7.70102069e-02f, 2.63964415e-01f, -2.74533749e-01f, 1.04177315e-02f,
  -8.40352103e-02f, 8.33617598e-02f, 1.34043828e-01f, -1.93835050e-01f, -1.76482886e-01f, 1.26305327e-01f, 2.01407105e-01f, 1.23755019e-02f, 7.32709616e-02f, 6.47731349e-02f,
  2.08677903e-01f, -2.97955126e-01f, 4.23718393e-02f, -8.83631334e-02f, -2.54435604e-03f, -2.78317839e-01f, -6.63260147e-02f, 1.09337226e-01f, -7.71965012e-02f, -1.30856201e-01f,
  -1.90084279e-01f, -6.55211462e-03f, 3.73316482e-02f, 9.31555778e-02f, -1.45048514e-01f, -6.31192848e-02f, 3.02814282e-02f, -4.79365773e-02f, -1.16118990e-01f, -1.26973450e-01f,
  -1.76304847e-01f, -3.56677757e-03f, -1.69875741e-01f, -2.50857964e-04f, -2.76970919e-02f, -1.58931628e-01f, -9.52841267e-02f, 1.17626698e-11f, -2.53925830e-01f, 6.39951825e-02f,
  1.67473063e-01f, -2.41366285e-03f, -7.42949396e-02f, 2.99140140e-02f, -4.40101773e-02f, -5.19555286e-02f, 8.82482156e-02f, -1.76769853e-01f, 1.31150514e-01f, 9.50965583e-02f,
  -2.03601912e-01f, 1.20313786e-01f, -1.17214046e-01f, -1.26190305e-01f, 1.78600818e-01f, -1.03492312e-01f, 2.20525175e-01f, 1.93771347e-01f, -3.20581883e-01f, -1.55501559e-01f,
  -6.15391508e-02f, -2.14432031e-01f, 5.41497245e-02f, 2.37320848e-02f, -2.88663536e-01f, -2.05528215e-01f, -3.05631310e-01f, 6.99055046e-02f, -2.15815797e-01f, 2.12011915e-02f,
  1.65174872e-01f, 2.33703828e-03f, 1.06840402e-01f, -1.08998820e-01f, 2.47717276e-01f, 1.35206625e-01f, -2.05135614e-01f, -4.21821661e-02f, -8.26322124e-04f, 1.05257608e-01f,
  -4.88496646e-02f, 9.99112055e-02f, -2.04108842e-02f, -1.33125886e-01f, 9.16767940e-02f, -1.68075144e-01f, -2.48630300e-01f, -2.66467065e-01f, 8.82516280e-02f, 8.62395167e-02f,
  2.33267415e-02f, -1.83298495e-02f, -2.11877555e-01f, -1.56019017e-01f, 2.09963605e-01f, 1.65208001e-02f, 1.22206375e-01f, 2.80398786e-01f, -3.08386926e-02f, -9.35415998e-02f,
  -1.42441718e-02f, 3.36286443e-10f, 9.02082995e-02f, -5.59356064e-02f, 1.02788694e-02f, -1.17173187e-01f, 6.36426061e-02f, 7.18537197e-02f, 3.32282223e-02f, -1.07464520e-02f,
  8.36848244e-02f, 1.63208738e-01f, -9.56210271e-02f, 7.10766623e-03f, 2.07413808e-01f, 1.79743528e-01f, -1.00611389e-01f, 8.83598849e-02f, -9.48107541e-02f, -1.70878693e-01f,
  -2.49866724e-01f, -2.16431871e-01f, 1.51934382e-02f, -3.21689904e-01f, -1.80323317e-03f, -3.15301009e-02f, 9.19071808e-02f, 3.63347046e-02f, 5.76473884e-02f, 2.28595674e-01f,
  -1.67902127e-01f, 1.37416378e-01f, 1.62689433e-01f, -3.27489637e-02f, -2.05006704e-01f, 7.01732570e-05f, -2.11026803e-01f, 1.59824684e-01f, -1.22170281e-02f, -3.52133922e-02f,
  -2.97164559e-01f, -2.87380312e-02f, -4.73972817e-04f, 5.72191104e-02f, 2.41027549e-01f, 2.09380940e-01f, 2.28662789e-01f, -1.27894491e-01f, 1.25118569e-01f, -2.59077102e-01f,
  -2.53427655e-01f, -2.04859629e-01f, 8.13263357e-02f, -2.20341664e-02f, -1.22566400e-02f, -2.36400440e-02f, -1.59658462e-01f, -2.88545974e-02f, -2.47317061e-01f, -2.40259673e-02f,
  -9.63496119e-02f, -2.08671719e-01f, -1.44245187e-02f, -3.31592970e-02f, 2.61080451e-02f, 1.84392449e-11f, 6.22198135e-02f, -1.94285825e-01f
};

// L4_linear_B (Shape: 1 x 12)
const int L4_linear_B_rows = 1;
const int L4_linear_B_cols = 12;
const float L4_linear_B_data[] = {
  -9.49328765e-03f, -1.77886952e-02f, -1.51073770e-03f, -1.50381420e-02f, -8.08910839e-03f, 3.92401740e-02f, -7.51838507e-03f, -9.52378437e-02f, -1.12866990e-01f, 8.98423344e-02f,
  8.27106088e-02f, -1.71715561e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 6, 52
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        64, 6, 52
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        64, 6, 52
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L3_fan_Wp_data, L3_fan_Wp_bar_data, L3_fan_Bp_bar_data,
        64, 6, 52
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 4: L4_linear
    linear_forward_pgm(
        buffer1, x_out,
        L4_linear_W_data, L4_linear_B_data,
        64, 12
    );
    }
    