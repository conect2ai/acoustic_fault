/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 64 (x3)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 64;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    float x3 = x * x * x;
    return 0.5f * x * (1.0f + tanhf(0.79788456f * (x + 0.044715f * x3)));
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 25 x 120)
const int L0_fan_Wp_rows = 25;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  4.97983724e-01f, -3.24814737e-01f, -2.69206077e-01f, 1.34230098e-02f, 1.67420641e-01f, -6.05423562e-02f, 8.71927440e-02f, -1.10976465e-01f, -3.62738414e-04f, -1.61964417e-01f,
  8.16711113e-02f, -3.59026273e-03f, 9.45174973e-03f, -9.30557027e-02f, 2.06972331e-01f, 1.27250962e-02f, 2.58469507e-02f, 2.37380955e-02f, -1.73808318e-02f, 6.23439951e-03f,
  5.33733293e-02f, 3.96977477e-02f, -4.07048538e-02f, -2.09282950e-01f, -8.41857418e-02f, -1.06798485e-01f, 5.38971238e-02f, -4.99235606e-03f, -3.27420682e-02f, 7.16883466e-02f,
  1.08114429e-01f, -2.30989158e-02f, -4.12042215e-02f, -7.18177781e-02f, -2.39122175e-02f, 1.84583459e-02f, -1.38618043e-02f, 8.42807665e-02f, 7.42447823e-02f, 1.13345739e-02f,
  4.99485917e-02f, -2.35070288e-02f, 2.34141015e-02f, 3.14022154e-02f, 3.19091827e-02f, -4.54455689e-02f, -8.66580289e-03f, -5.70583120e-02f, -4.92753126e-02f, -7.97840804e-02f,
  -7.02401176e-02f, -6.21642098e-02f, -2.87056603e-02f, -6.93116933e-02f, -1.41702443e-02f, 1.90889705e-02f, -7.86069781e-02f, 3.39624006e-03f, -5.71286399e-03f, -7.15102116e-03f,
  -8.36100355e-02f, -5.24212047e-03f, -7.57326884e-03f, 2.49344707e-02f, -7.53218085e-02f, -3.43565037e-03f, 2.35798210e-02f, 6.70563579e-02f, -2.13765027e-03f, 1.12497620e-03f,
  4.13726158e-02f, 3.99683602e-02f, 1.34910829e-02f, -2.12764312e-02f, 2.38781236e-02f, 9.03612282e-03f, 2.71693221e-03f, 2.69176392e-03f, -3.23252641e-02f, 4.39674444e-02f,
  -2.48478167e-02f, 3.20005231e-02f, 2.02270932e-02f, 7.68143311e-03f, -5.49192689e-02f, -5.16151357e-03f, -4.11188416e-02f, -6.44986928e-02f, 4.99642566e-02f, 4.69046943e-02f,
  7.21716434e-02f, -4.17212322e-02f, 2.44436879e-02f, 3.67754512e-02f, 2.02218676e-03f, -2.27778535e-02f, -1.47205079e-02f, -3.44622917e-02f, 2.40934659e-02f, 3.40991020e-02f,
  -4.53760214e-02f, -1.75660383e-02f, 3.24659422e-02f, 2.04546712e-02f, 2.79118796e-03f, 2.44487748e-02f, 5.62223755e-02f, 6.56198785e-02f, 6.97275177e-02f, -3.73406820e-02f,
  -5.51250502e-02f, 4.67098393e-02f, 1.63083337e-02f, -1.08499415e-02f, 4.33460157e-03f, 1.31476941e-02f, 1.15011409e-02f, -3.87782305e-02f, 7.05722272e-02f, -1.54149178e-02f,
  5.33733010e-01f, 9.31956992e-02f, -1.54485941e-01f, 8.57962370e-02f, 1.29114762e-01f, 2.01468527e-01f, 6.13863654e-02f, 5.88162169e-02f, 3.10299337e-01f, 2.42896844e-02f,
  -5.21571599e-02f, 6.99980259e-02f, -9.94582474e-02f, 8.42530504e-02f, 4.43599885e-03f, -1.36675507e-01f, 1.22035548e-01f, 1.29591480e-01f, 2.57515535e-02f, 7.99154565e-02f,
  2.20615510e-02f, 9.35508981e-02f, -2.23491907e-01f, 4.27241990e-04f, 1.78105697e-01f, 2.70137992e-02f, -1.82514563e-01f, -1.36335716e-01f, -5.32070547e-02f, -3.87282781e-02f,
  -2.00165231e-02f, 4.63244356e-02f, -4.24793027e-02f, 3.39348335e-03f, 2.28192527e-02f, 4.49474975e-02f, 3.00028212e-02f, -1.99381709e-02f, -2.32292954e-02f, -4.96474386e-04f,
  5.79118654e-02f, -2.20920481e-02f, 1.97685994e-02f, -3.68195698e-02f, 8.48696381e-02f, -2.27923468e-02f, 4.74639609e-02f, 2.96005849e-02f, 4.84670810e-02f, -2.06284542e-02f,
  1.75179634e-02f, 3.21822912e-02f, 5.86942770e-04f, 1.34588620e-02f, -2.55568475e-02f, 7.81868119e-03f, -5.62361267e-04f, 4.72068647e-03f, 2.82150414e-02f, 9.36501250e-02f,
  9.46726799e-02f, 1.19151026e-02f, -5.47176823e-02f, -3.45394313e-02f, 7.51145929e-02f, 1.88773032e-02f, -1.79985110e-02f, -2.10513771e-02f, -6.29611453e-03f, 1.68548431e-02f,
  2.90539097e-02f, -2.15212759e-02f, 3.61343734e-02f, 3.64205167e-02f, 9.85262915e-03f, 3.48914750e-02f, -4.95508797e-02f, 2.40948386e-02f, 3.90768498e-02f, -2.68439762e-02f,
  -5.43122133e-03f, 3.00509054e-02f, -2.90673450e-02f, -2.71655396e-02f, -1.34844379e-02f, -2.13113762e-02f, 3.13797109e-02f, -3.28700282e-02f, -2.08738297e-02f, -5.36412671e-02f,
  1.02713987e-01f, -1.30868144e-02f, -2.42364360e-03f, 6.27690479e-02f, -5.26808053e-02f, 2.40462720e-02f, -8.67699552e-03f, 2.64912192e-02f, -2.02193111e-02f, -1.89860945e-03f,
  1.30865164e-02f, -1.22929970e-02f, -3.30741853e-02f, 3.29267532e-02f, -1.49473622e-02f, -4.40236107e-02f, 1.13399988e-02f, -6.82344486e-04f, 8.78184382e-03f, -1.70904603e-02f,
  7.86282402e-03f, 7.74275810e-02f, 1.70337036e-02f, 4.79481965e-02f, 7.52980076e-03f, 4.67310995e-02f, 1.27795935e-02f, 3.57441753e-02f, -1.46517367e-03f, -1.81224328e-02f,
  2.88930476e-01f, -2.51453757e-01f, -1.46028817e-01f, 1.44571066e-01f, 2.01080702e-02f, -2.52895970e-02f, -3.40024047e-02f, -8.38493109e-02f, 1.14561692e-02f, -1.05932303e-01f,
  4.81621474e-02f, 6.56904131e-02f, 6.73537201e-04f, 6.33575097e-02f, 2.84907728e-01f, 7.81978965e-02f, 1.52795166e-01f, -1.22525925e-02f, 3.56016234e-02f, -3.75271253e-02f,
  -9.09497961e-02f, 1.11908503e-01f, 1.22099388e-02f, -1.20019808e-01f, -1.31819129e-01f, -1.56909242e-01f, 1.91586837e-01f, -1.76748365e-01f, -7.59063810e-02f, 1.63285900e-02f,
  -3.42809670e-02f, -1.40612433e-02f, -6.34054840e-02f, -4.41579428e-03f, -5.81624173e-02f, 5.16291820e-02f, 7.64771784e-03f, -1.82492845e-02f, -1.70438346e-02f, -3.82216051e-02f,
  3.60287018e-02f, 4.31985445e-02f, 4.05252818e-03f, -3.69577929e-02f, -6.50363639e-02f, -1.35665219e-02f, -4.89814207e-02f, 1.60239264e-02f, -7.34069422e-02f, -5.18905697e-03f,
  8.77582468e-03f, 1.30757028e-02f, 5.82168363e-02f, 2.28281412e-02f, -3.85112222e-03f, 5.70054259e-03f, -1.66550186e-02f, 3.64772230e-02f, -2.74839569e-02f, -3.34200636e-03f,
  6.75878450e-02f, 8.20725262e-02f, -2.91932672e-02f, -2.89928410e-02f, 1.36011401e-02f, -1.87927373e-02f, 4.35868371e-03f, 4.87582684e-02f, -2.63627898e-02f, 4.48303260e-02f,
  4.18053679e-02f, 2.47385390e-02f, -2.76216716e-02f, 3.97932269e-02f, -1.34807928e-02f, 2.37226952e-02f, 6.72995448e-02f, 6.40843110e-03f, 3.19928699e-03f, 8.86291265e-03f,
  2.64657568e-02f, -5.51037304e-03f, -1.15475906e-02f, 5.93711995e-02f, -1.26878796e-02f, -3.60189937e-02f, 4.63368073e-02f, -1.55105079e-02f, 5.94487041e-02f, -1.92891080e-02f,
  -1.29693318e-02f, -1.48962550e-02f, -5.42311296e-02f, -3.19357552e-02f, 4.88531636e-03f, -4.37766314e-03f, 5.76911345e-02f, -4.07095775e-02f, -1.16107119e-02f, 7.22983554e-02f,
  -9.75114107e-02f, 5.84191037e-03f, 4.08278629e-02f, 4.19842191e-02f, -2.00057328e-02f, 1.75964516e-02f, -6.43394073e-04f, 1.42103462e-02f, 6.21439517e-02f, 4.67312410e-02f,
  3.91932763e-02f, 2.62660943e-02f, 2.19749194e-03f, 2.78946944e-02f, 3.92728373e-02f, -6.10167673e-03f, 5.09538390e-02f, -6.61754087e-02f, -1.57819558e-02f, 2.06165817e-02f,
  3.93740356e-01f, -1.76499844e-01f, 2.66522467e-01f, -8.48178342e-02f, 4.16631885e-02f, 1.20145611e-01f, 9.79019180e-02f, 4.62894626e-02f, 1.33891866e-01f, -1.37332603e-01f,
  -1.78822186e-02f, 5.85113242e-02f, -2.63672881e-02f, -1.69886917e-01f, 5.75322360e-02f, -1.32286012e-01f, -8.85794610e-02f, -6.72621727e-02f, -8.71037841e-02f, -2.02465802e-02f,
  -3.46791632e-02f, -3.23554456e-01f, -5.32544814e-02f, -2.15716854e-01f, -1.30705740e-02f, 3.23243998e-02f, -5.74845262e-02f, 1.27360383e-02f, -5.03376052e-02f, -3.96713018e-02f,
  3.75227667e-02f, 4.70872223e-02f, 9.51946676e-02f, 1.12371899e-01f, 1.23153552e-02f, 6.17730580e-02f, -5.83226699e-03f, 6.75224140e-02f, 8.24999064e-02f, 5.08958125e-04f,
  4.91934977e-02f, 2.60113236e-02f, -3.64150479e-02f, -1.65007561e-02f, 4.98639010e-02f, -5.29557988e-02f, 3.28172892e-02f, 1.19095938e-02f, 4.09442782e-02f, -8.33371829e-04f,
  -3.28751430e-02f, -2.54018535e-03f, 2.42894758e-02f, 5.83215966e-04f, -4.75737639e-03f, -8.78710579e-03f, -3.19765210e-02f, 4.84952442e-02f, 5.54002915e-03f, 1.85959432e-02f,
  -9.92029831e-02f, 6.61873221e-02f, -2.72502024e-02f, 5.06815985e-02f, -4.11026888e-02f, -3.01702172e-02f, -3.86719853e-02f, -3.59139405e-02f, -4.31215018e-03f, -2.15992760e-02f,
  -3.75467120e-03f, 4.40174043e-02f, 4.79366779e-02f, 2.06172951e-02f, -2.60393675e-02f, -5.92395139e-04f, -5.28088445e-03f, -8.58188141e-03f, 2.69383402e-03f, -1.69404782e-02f,
  4.51202355e-02f, 2.25213654e-02f, 6.28360503e-05f, -4.45624739e-02f, 2.11032443e-02f, 3.47952619e-02f, 1.78376473e-02f, -1.74602550e-02f, 2.17903554e-02f, -5.93096577e-02f,
  -1.60257742e-01f, -1.21236145e-01f, 3.42778824e-02f, -6.78821951e-02f, 4.01187204e-02f, 2.36755665e-02f, -5.18706106e-02f, 2.37287972e-02f, -4.12038043e-02f, 5.91334477e-02f,
  5.72579540e-02f, -3.65304351e-02f, -7.85704178e-05f, -1.86160847e-03f, -1.07627464e-02f, -2.36847848e-02f, -4.75278348e-02f, 1.05326325e-02f, -5.68360649e-02f, -2.78823338e-02f,
  -7.71961212e-02f, -7.11885020e-02f, -2.76489742e-02f, -7.02640489e-02f, -1.32604111e-02f, 1.81106608e-02f, -2.20162664e-02f, -1.25095192e-02f, -7.52258301e-02f, 4.31476943e-02f,
  -2.53420651e-01f, -2.00076938e-01f, 4.51043993e-02f, -3.14600408e-01f, 2.15459391e-01f, -7.95811415e-02f, -1.57179877e-01f, 1.76357925e-02f, -5.44635803e-02f, -1.75988182e-01f,
  5.91610745e-02f, -2.02144697e-01f, 3.05976141e-02f, 2.61850674e-02f, 1.24383889e-01f, 1.60612598e-01f, -6.55936226e-02f, -1.57141745e-01f, 4.07134481e-02f, -2.94077154e-02f,
  7.14318454e-02f, 1.16479963e-01f, 3.76291536e-02f, 1.39669016e-01f, -6.02996035e-04f, -1.24880441e-01f, 1.69863235e-02f, 6.75643235e-02f, -5.69368005e-02f, 4.24511805e-02f,
  1.57825276e-02f, -9.84962359e-02f, -1.48172863e-02f, -3.71394004e-03f, -4.63663600e-02f, -2.56123319e-02f, -3.81639414e-02f, 4.45163101e-02f, 8.69217888e-03f, -2.98300106e-02f,
  7.01419497e-03f, 2.12407811e-03f, 6.60362020e-02f, 7.24656582e-02f, -7.16856867e-02f, -6.02314360e-02f, 4.09810757e-03f, -6.13484271e-02f, -3.21717933e-02f, 1.22190313e-02f,
  4.88198139e-02f, -9.71635897e-03f, -5.39848469e-02f, 1.85579993e-03f, 4.83838469e-03f, -6.45337254e-02f, -1.96854062e-02f, 5.37999757e-02f, -8.20209682e-02f, -3.19019705e-02f,
  9.98527408e-02f, 3.37452739e-02f, -2.73050424e-02f, 6.06287410e-03f, -2.99954787e-03f, 2.54146196e-02f, -6.89698607e-02f, 3.20901647e-02f, -9.38722044e-02f, 4.51445058e-02f,
  3.37435603e-02f, -1.08119771e-01f, 4.41940054e-02f, -4.03863266e-02f, -6.77868128e-02f, -6.88373893e-02f, -7.79399835e-03f, -1.17250914e-02f, 7.59875122e-03f, 2.44755410e-02f,
  -6.24438226e-02f, -3.16954292e-02f, -5.50313704e-02f, -2.90913805e-02f, -3.43516171e-02f, -1.30280284e-02f, 5.50200650e-03f, -7.65095428e-02f, -1.07941646e-02f, 6.78207278e-02f,
  -2.62948692e-01f, -2.03936949e-01f, -1.35203563e-02f, -1.42952576e-01f, 2.42795832e-02f, -1.80050563e-02f, 4.47095819e-02f, -3.10966857e-02f, -7.46168792e-02f, 1.93096958e-02f,
  -1.30277704e-02f, -3.89306024e-02f, 1.21278018e-02f, 6.97969599e-03f, 1.77308004e-02f, 8.60727392e-03f, -7.17420131e-02f, -2.91353092e-02f, -8.07938799e-02f, 3.04589868e-02f,
  -6.96356222e-02f, 6.78692386e-02f, 4.81342636e-02f, -4.08538356e-02f, 1.51222367e-02f, 2.31228564e-02f, -6.94053108e-03f, -2.37824954e-02f, 5.22683114e-02f, 1.18776113e-02f,
  -2.67521799e-01f, -2.87941005e-02f, -2.49371350e-01f, 5.02804518e-02f, -5.43133318e-02f, -1.25360548e-01f, -2.01814622e-01f, -6.28593341e-02f, 6.32293448e-02f, -2.16546636e-02f,
  -4.08459604e-02f, -5.14657982e-02f, 2.84889638e-02f, 4.83458191e-02f, 2.99484935e-02f, 7.39850402e-02f, -3.59988585e-02f, -3.86448801e-02f, 1.21532105e-01f, -2.39947326e-02f,
  -2.32718065e-02f, 4.67698835e-02f, -8.41528773e-02f, 8.49220678e-02f, -8.25343877e-02f, -9.71269514e-03f, 3.13673057e-02f, -7.25816190e-02f, -6.06794395e-02f, -1.06591202e-01f,
  3.50107253e-02f, 2.78447792e-02f, -9.10324305e-02f, -2.13380028e-02f, -9.49088633e-02f, -9.89962965e-02f, -7.71070644e-02f, 9.81685147e-03f, 7.68960938e-02f, 9.64972377e-02f,
  -2.98245270e-02f, -3.60289179e-02f, 1.30263320e-03f, -3.60138677e-02f, -1.38744349e-02f, 1.46024544e-02f, 5.98826334e-02f, -1.72878802e-02f, -4.22530845e-02f, -6.63366839e-02f,
  2.14517824e-02f, -1.57220010e-03f, -3.06219365e-02f, 3.67986150e-02f, -8.86228122e-03f, 1.27080479e-03f, -2.35466496e-03f, -4.45855223e-02f, -7.29627386e-02f, -2.31425725e-02f,
  -6.20601811e-02f, 2.83326562e-02f, -5.07637858e-02f, 9.16008055e-02f, 7.64619336e-02f, 1.70677900e-02f, 4.57768254e-02f, 3.69995348e-02f, 1.03286751e-01f, 5.48296757e-02f,
  -3.47110024e-03f, 4.11420092e-02f, 7.55160078e-02f, 3.95611580e-03f, 3.96874510e-02f, -1.07003577e-01f, -1.18276030e-02f, 1.17533049e-02f, -4.08723317e-02f, -1.53208235e-02f,
  4.00351062e-02f, -3.07551026e-03f, -1.26880314e-02f, 2.88144574e-02f, -8.72299820e-03f, 1.81680620e-02f, 3.03360783e-02f, -2.33589821e-02f, -6.50235564e-02f, -1.93869341e-02f,
  1.12494275e-01f, 7.86677226e-02f, -2.72550397e-02f, -4.16184813e-02f, 2.87450925e-02f, -1.29606519e-02f, -3.40844877e-02f, -1.93029903e-02f, 3.68918828e-03f, -4.55391034e-02f,
  -4.65665907e-02f, 2.49607787e-02f, -1.59252957e-02f, -3.38128619e-02f, -6.17407635e-03f, -4.81541501e-03f, -4.65018414e-02f, 1.58388894e-02f, -5.07220719e-03f, -1.08319610e-01f,
  3.35885137e-02f, -1.32209447e-03f, 1.84821580e-02f, 5.75265326e-02f, -3.84452194e-02f, -1.37990201e-02f, -1.48223285e-02f, -3.04015761e-04f, -3.50790024e-02f, 2.96253506e-02f,
  9.44585204e-02f, -2.06296459e-01f, 2.40309432e-01f, -7.52241164e-02f, 1.48061648e-01f, -3.26158502e-03f, 2.99833273e-03f, 2.69574835e-03f, -4.21842858e-02f, -1.60146892e-01f,
  -5.61566502e-02f, 1.23380991e-02f, -8.92641544e-02f, -8.28591064e-02f, 1.04904942e-01f, -2.25757599e-01f, -9.60142761e-02f, -7.45062009e-02f, -2.32045837e-02f, -5.46306148e-02f,
  2.46002227e-02f, -1.06533431e-01f, 8.94943178e-02f, -9.87742841e-03f, 2.90033072e-02f, 2.55663469e-02f, -3.45645621e-02f, 8.11317489e-02f, 3.94202583e-02f, 1.19778059e-01f,
  -2.82536019e-02f, -6.32525384e-02f, -5.53075001e-02f, -5.77394292e-02f, -4.75960672e-02f, -1.35944057e-02f, 4.44320589e-02f, 5.02900258e-02f, 3.23074358e-03f, 1.45654501e-02f,
  -7.40767717e-02f, 5.50841466e-02f, 5.29551432e-02f, 2.58625168e-02f, -3.06882225e-02f, 8.01331624e-02f, 3.42478491e-02f, 4.08636332e-02f, -2.24411711e-02f, 4.18823548e-02f,
  8.66478961e-03f, -1.37180777e-03f, -4.32697237e-02f, -4.88248579e-02f, 5.17030470e-02f, -1.10088736e-02f, 4.08929996e-02f, -6.14934426e-04f, 2.68471558e-02f, -2.51528807e-02f,
  3.05194743e-02f, -1.56034986e-02f, 5.89070432e-02f, -3.96451950e-02f, 4.86006588e-02f, 2.89954208e-02f, 1.68206226e-02f, 1.69331804e-02f, 7.62693882e-02f, -3.30082066e-02f,
  -2.44293436e-02f, -1.90537777e-02f, 7.12299533e-03f, -4.80670109e-02f, -3.72432992e-02f, -4.46233824e-02f, -1.35387143e-03f, -3.17099527e-03f, -3.52228470e-02f, -1.00447088e-02f,
  -1.24599868e-02f, 2.84496956e-02f, 1.74019753e-03f, 5.18671833e-02f, -3.49614769e-02f, -3.23371068e-02f, -6.64260238e-02f, -4.54666978e-03f, -1.34702576e-02f, -1.19894976e-02f,
  -3.35455298e-01f, -1.75210759e-01f, -1.04949638e-01f, -3.58379004e-03f, -9.18571129e-02f, 6.86405459e-03f, -4.38814498e-02f, 3.92085128e-03f, -6.64799362e-02f, 2.84022409e-02f,
  -5.89467399e-03f, -4.16820906e-02f, 2.11230261e-04f, -3.44892032e-02f, -3.70661430e-02f, -4.92789224e-02f, -5.00016399e-02f, -1.06832057e-01f, -4.82283905e-02f, -2.70921029e-02f,
  1.44659784e-02f, -6.29972816e-02f, 8.49590898e-02f, 2.36870125e-02f, -4.20944579e-02f, 1.18960184e-03f, -2.72147190e-02f, 5.83664365e-02f, 6.59245485e-03f, -1.69368200e-02f,
  -4.26630080e-02f, 1.50869027e-01f, -1.28792927e-01f, -1.31248608e-01f, -7.71562522e-03f, -1.54035389e-01f, -3.16123478e-02f, -4.88434769e-02f, -9.45082605e-02f, 3.04976225e-01f,
  -1.34998187e-01f, 1.51002958e-01f, -3.33861746e-02f, -1.76944509e-01f, -2.52332270e-01f, -1.83345318e-01f, -6.99049607e-02f, 5.29191010e-02f, -5.24778515e-02f, 1.37188714e-02f,
  -1.21567816e-01f, -1.39580980e-01f, -1.12317353e-01f, -1.75111312e-02f, -2.42316872e-02f, 8.49939138e-02f, 1.60480440e-01f, -2.74029709e-02f, 3.08151804e-02f, -7.24859387e-02f,
  -1.57036155e-01f, -1.45410951e-02f, 5.21827750e-02f, -1.83567731e-03f, -3.55837308e-03f, 2.26843785e-02f, 8.76121745e-02f, -4.38762382e-02f, -4.47038300e-02f, 3.57589386e-02f,
  9.06732529e-02f, 2.72019561e-02f, -1.24090929e-02f, -8.79409164e-03f, 2.37819329e-02f, -3.09383515e-02f, -2.99196336e-02f, -3.26649100e-02f, -4.93592471e-02f, -4.67003360e-02f,
  -6.63499832e-02f, 1.77363157e-02f, 1.45407277e-03f, 2.03893632e-02f, -4.56161164e-02f, -1.03029259e-03f, 4.24390892e-04f, 7.88942650e-02f, 6.36731163e-02f, 4.57825288e-02f,
  1.77174881e-02f, 7.09842518e-02f, -7.34239593e-02f, -2.22289469e-02f, -6.27126023e-02f, -8.23599696e-02f, -7.42712244e-03f, -5.49853686e-03f, 6.57645315e-02f, 1.55439703e-02f,
  1.61860865e-02f, -1.06340717e-03f, -2.31987312e-02f, 4.40695090e-03f, 3.03844232e-02f, -1.73406191e-02f, 2.63987482e-02f, -2.79303938e-02f, -7.84607381e-02f, -3.83562185e-02f,
  -1.79392267e-02f, -5.06078526e-02f, -6.94373203e-03f, 4.64209095e-02f, -1.56017682e-02f, -4.51637479e-03f, 3.93193476e-02f, -3.22331302e-02f, -2.02663541e-02f, 3.14624161e-02f,
  7.29136616e-02f, 2.01870039e-01f, -1.37914401e-02f, -5.13901450e-02f, 3.87630053e-02f, 2.78042071e-02f, -9.08621624e-02f, 5.92832044e-02f, -4.79372405e-02f, -3.87972593e-02f,
  7.78571218e-02f, 3.34174559e-02f, 1.18225977e-01f, -4.21488360e-02f, -5.72582819e-02f, 2.97680981e-02f, 1.03602847e-02f, 1.86673980e-02f, 1.04456730e-01f, 7.94488266e-02f,
  6.36918470e-02f, 2.15670038e-02f, 8.64296034e-02f, -4.69464473e-02f, 2.11359207e-02f, 3.51889879e-02f, 3.77211981e-02f, -4.72823307e-02f, -9.76930931e-03f, 2.23277863e-02f,
  -4.63873670e-02f, -1.45292416e-01f, -7.80240307e-03f, -8.20616335e-02f, -2.52579502e-03f, 2.19939798e-01f, 7.11330697e-02f, -7.34911710e-02f, -2.69548029e-01f, -8.91229697e-03f,
  2.12905556e-01f, -1.58352122e-01f, 1.20363779e-01f, -2.32658423e-02f, 1.43277690e-01f, -6.27210960e-02f, 1.51673064e-01f, 1.43004805e-01f, -9.38043147e-02f, 1.31013170e-01f,
  -4.71561076e-03f, 8.03819150e-02f, 1.73760921e-01f, 9.94731933e-02f, 1.55292451e-01f, -5.59310764e-02f, 1.61049694e-01f, -3.10566090e-02f, 2.31331050e-01f, 2.83501707e-02f,
  7.92598426e-02f, -6.45266995e-02f, -2.66832206e-02f, 2.88422089e-02f, 1.30490497e-01f, 4.75847051e-02f, 4.14113589e-02f, -3.89690064e-02f, 6.36465028e-02f, 1.10616675e-02f,
  -3.46074402e-02f, 2.12019607e-02f, -8.04678258e-03f, -2.43941750e-02f, -7.84163773e-02f, 2.73145493e-02f, 8.47663637e-03f, 4.63554859e-02f, 8.79848655e-03f, -2.04808004e-02f,
  5.94327115e-02f, -9.53385606e-03f, -4.05950025e-02f, -7.82747287e-03f, -8.73335078e-03f, 3.07391435e-02f, 3.06187235e-02f, -9.58162476e-04f, 5.77961619e-04f, -3.18029933e-02f,
  -6.42159581e-02f, -6.07375279e-02f, 2.20130775e-02f, 3.71351093e-02f, -3.27032758e-03f, -5.80911385e-03f, -3.78251970e-02f, 4.83399965e-02f, -1.70635730e-02f, 6.29729999e-04f,
  -5.35662286e-03f, -6.87981676e-03f, -8.32180679e-02f, 4.74364683e-02f, 3.48904580e-02f, -5.56210652e-02f, -2.21966077e-02f, 2.92959977e-02f, -8.01767930e-02f, 1.27710449e-02f,
  6.65281957e-04f, -3.12726665e-03f, 1.08913310e-01f, 1.09594567e-02f, 3.98434624e-02f, 6.86043128e-03f, -7.47478846e-03f, 2.84469407e-02f, 1.27091343e-02f, 2.68022511e-02f,
  3.35030630e-02f, -7.52525637e-04f, 1.26950843e-02f, 8.25041346e-03f, 3.69232707e-02f, 5.53032942e-02f, -4.73254621e-02f, 2.27592681e-02f, -2.73733865e-02f, 3.15427668e-02f,
  4.70884107e-02f, 3.99266630e-02f, -5.50847128e-02f, -5.45230834e-03f, 5.20560071e-02f, 1.87884849e-02f, -5.05404137e-02f, -2.57500932e-02f, -9.83174983e-03f, 6.91482648e-02f,
  6.31214976e-02f, 1.27070406e-02f, -2.84183901e-02f, -2.10811291e-02f, -1.17563559e-02f, 1.76279210e-02f, -9.86728147e-02f, 4.10161242e-02f, 8.57239366e-02f, 2.95603033e-02f,
  -4.61680181e-02f, -6.64451122e-02f, -5.60175478e-02f, 1.56996667e-01f, 2.11165980e-01f, 6.86753765e-02f, -1.37742106e-02f, 2.00354010e-01f, -4.78686579e-02f, 7.07513988e-02f,
  3.89149971e-02f, -2.24943653e-01f, -1.65358692e-01f, 1.39935046e-01f, -1.12795487e-01f, -2.12094262e-01f, 1.76705152e-01f, -4.61115129e-02f, -9.06971619e-02f, 8.98716375e-02f,
  2.26212256e-02f, 1.46957621e-01f, -2.65808348e-02f, 2.05235213e-01f, 1.14560775e-01f, 9.74057987e-02f, 9.31137502e-02f, -3.57761532e-02f, 1.64837360e-01f, -2.95938719e-02f,
  -6.65521100e-02f, -1.05008535e-01f, 4.56463769e-02f, -4.62449854e-03f, 6.82835653e-02f, 3.07879448e-02f, -7.83408582e-02f, -3.27260345e-02f, -3.17294374e-02f, -9.02263075e-03f,
  -4.25763130e-02f, -4.32905145e-02f, 5.18611930e-02f, 3.60816494e-02f, 3.77532803e-02f, 1.20193269e-02f, -6.07795082e-02f, -2.51422985e-03f, -6.40973374e-02f, -2.27287188e-02f,
  1.28811048e-02f, 1.91876441e-02f, -1.57702551e-03f, -4.33502644e-02f, -1.49028720e-02f, 1.73330829e-02f, 1.84713360e-02f, -5.16283214e-02f, 3.23451422e-02f, 6.11305311e-02f,
  2.42136121e-02f, 2.47498509e-02f, -4.29969132e-02f, -4.06849384e-03f, 4.31694789e-03f, 4.23749536e-03f, 3.53002851e-03f, -4.76001576e-02f, 1.19398604e-03f, -2.20636893e-02f,
  3.88168953e-02f, -2.08107531e-02f, -5.68240182e-04f, 4.00338043e-03f, 3.56227644e-02f, 3.76377888e-02f, -9.06756986e-03f, -3.09869517e-02f, 5.77877499e-02f, -2.11381051e-03f,
  -3.94891463e-02f, -2.11950932e-02f, -1.30276363e-02f, 8.31945091e-02f, 2.00690012e-02f, -1.27506536e-02f, 6.64871112e-02f, -2.54689716e-02f, 4.02195239e-03f, -4.23224503e-03f,
  1.09377265e-01f, 1.55616477e-01f, -2.90735974e-03f, -2.89758667e-02f, -1.74195541e-03f, 1.65202655e-02f, 5.16476966e-02f, 4.87898104e-02f, 4.44242172e-03f, 8.24155062e-02f,
  1.53413871e-02f, -2.25254870e-03f, 7.28414068e-03f, -1.95072405e-02f, 7.30590569e-03f, 1.66186150e-02f, 1.55675784e-02f, -1.09329252e-02f, 4.38622236e-02f, 2.51666214e-02f,
  9.26253013e-03f, -8.48717894e-03f, -2.21836120e-02f, 8.69451985e-02f, 7.35640004e-02f, -1.50042344e-02f, 5.70409372e-02f, -5.13818339e-02f, 1.97830237e-02f, -3.28587070e-02f,
  3.67724597e-01f, -3.32169771e-01f, 9.64833498e-02f, -1.66136175e-01f, -5.97655065e-02f, -1.46992072e-01f, -4.49312814e-02f, -1.85272619e-01f, -1.58338144e-01f, -1.34668797e-01f,
  -5.13111763e-02f, 6.51580617e-02f, 1.69005841e-02f, -1.45895287e-01f, 1.97015345e-01f, -2.68609039e-02f, -4.96747158e-02f, 2.40562595e-02f, -5.69468737e-02f, 5.42709678e-02f,
  1.04189338e-03f, -1.15751050e-01f, 7.76463747e-02f, -7.47689381e-02f, -1.85659574e-03f, 4.47829515e-02f, 1.10905617e-01f, -1.64882280e-03f, 1.56812426e-02f, -3.19186486e-02f,
  1.15935624e-01f, -6.87312260e-02f, 9.98271406e-02f, 6.82744384e-02f, 1.30743280e-01f, 5.93780838e-02f, 2.04169024e-02f, 4.93708700e-02f, -5.56397485e-03f, -2.75216326e-02f,
  8.65207240e-02f, 2.23212056e-02f, -1.27234468e-02f, -1.90853756e-02f, -6.72047064e-02f, 6.53345808e-02f, -2.60464232e-02f, -2.53527220e-02f, 1.81804206e-02f, 2.90443730e-02f,
  1.75463203e-02f, -8.71839561e-03f, 8.53088498e-03f, 3.82270329e-02f, 1.76116042e-02f, -1.04195572e-01f, 4.02556220e-03f, 4.32722308e-02f, 1.95516851e-02f, -2.83113420e-02f,
  5.15155531e-02f, 1.00340100e-03f, 1.96992494e-02f, -2.98074149e-02f, 1.83078106e-02f, -5.38298488e-03f, -4.19494361e-02f, 2.75466517e-02f, 6.76215068e-02f, 5.04140146e-02f,
  -2.56203841e-02f, -2.31183749e-02f, -3.64835523e-02f, 1.92678645e-02f, 1.69132669e-02f, -3.19717340e-02f, 2.65452843e-02f, -7.41315947e-04f, -6.02544844e-02f, 3.76490913e-02f,
  -4.70916294e-02f, -6.40382469e-02f, 9.26864985e-03f, -4.15533409e-02f, -1.19365491e-02f, 4.73207906e-02f, -4.59315218e-02f, -5.14622703e-02f, 3.10621858e-02f, 9.71387029e-02f,
  -6.70551062e-02f, -9.00446400e-02f, 7.25339800e-02f, -3.99540961e-02f, 7.91719649e-03f, 6.97961194e-04f, -3.32031818e-03f, -1.01135271e-02f, -2.95951888e-02f, 1.60339475e-02f,
  -2.69597564e-02f, 4.14791750e-03f, 1.67597365e-02f, -4.15926613e-03f, 5.93976292e-04f, -1.88512951e-02f, 7.75259137e-02f, -3.78119275e-02f, -2.04861239e-02f, -2.01523937e-02f,
  6.55854344e-02f, -2.21937224e-02f, 1.42501015e-02f, 4.12189737e-02f, 2.60151603e-04f, 8.33123401e-02f, 3.36926170e-02f, -4.40601148e-02f, -1.55122904e-02f, -2.35748105e-02f,
  -9.04356539e-02f, 1.39051536e-02f, -5.00169322e-02f, 1.06876448e-01f, -6.78176507e-02f, 6.69277310e-02f, 1.03222631e-01f, 2.24389751e-02f, -1.11500755e-01f, 2.91324705e-02f,
  9.15758461e-02f, 4.07336727e-02f, -3.96461748e-02f, 3.26739103e-01f, 1.69078484e-01f, 1.92669276e-02f, 1.62523240e-01f, 1.15588330e-01f, -6.74057677e-02f, 5.04197180e-02f,
  3.42494622e-02f, 2.35941157e-01f, 5.05120941e-02f, 3.12128179e-02f, 4.33878228e-02f, -5.47854304e-02f, 1.91419855e-01f, 2.52216272e-02f, 1.93334281e-01f, 9.62383226e-02f,
  8.69063511e-02f, 9.84568056e-03f, -5.14518954e-02f, 1.01442356e-02f, -5.86888269e-02f, 6.20428519e-03f, 8.66470218e-04f, 5.38787991e-02f, 2.57237740e-02f, -1.64837465e-02f,
  -4.56174612e-02f, 1.57235656e-02f, 9.84634757e-02f, -2.78100539e-02f, -9.35819000e-03f, -1.56516694e-02f, -2.60042539e-03f, -3.27978395e-02f, -3.99029180e-02f, 3.33295427e-02f,
  -1.25476480e-01f, -1.13926046e-01f, 4.13739448e-03f, 5.09215854e-02f, -6.14514425e-02f, -4.64850180e-02f, -8.06789622e-02f, 3.74172926e-02f, 4.08381922e-03f, -2.81147864e-02f,
  -1.55232167e-02f, -4.09859270e-02f, -7.23937079e-02f, -2.04526316e-02f, -2.47674226e-03f, 1.79427788e-02f, 2.62862779e-02f, 9.08871144e-02f, -6.91374466e-02f, -4.21937816e-02f,
  -4.56236936e-02f, 9.40832943e-02f, 2.87640598e-02f, -4.52861935e-02f, -3.06300446e-02f, 3.85526638e-03f, 2.35475581e-02f, 3.95502970e-02f, -6.83527961e-02f, -3.76667008e-02f,
  2.65666600e-02f, 4.83384095e-02f, -6.77301511e-02f, -8.40454455e-03f, -4.45751920e-02f, -3.56835090e-02f, 2.57229358e-02f, -4.42064330e-02f, -5.26029170e-02f, -3.68265808e-02f,
  -5.05779870e-03f, 1.75356269e-02f, 5.10735549e-02f, -3.14818807e-02f, 2.19619982e-02f, 7.56074395e-03f, 8.07097554e-02f, 2.48438790e-02f, -1.26311341e-02f, 7.12850317e-02f,
  -1.31291645e-02f, 1.55123509e-02f, -6.89779893e-02f, 2.42482182e-02f, -2.17192504e-03f, -4.14158180e-02f, 6.97973138e-03f, -6.59783185e-03f, 5.06421588e-02f, -3.35066542e-02f,
  -7.28636608e-02f, -1.95494276e-02f, -1.96258835e-02f, -1.03224874e-01f, 4.00349200e-02f, -1.16260024e-02f, -6.42260164e-02f, 5.27646951e-03f, -1.20415827e-02f, 3.13417204e-02f,
  3.85830909e-01f, -2.56328523e-01f, -7.33671114e-02f, -1.86109040e-02f, 7.67243579e-02f, -2.33959168e-01f, -1.09599419e-01f, -1.09060928e-01f, -8.24168473e-02f, -1.16479076e-01f,
  3.56590934e-03f, 8.51757228e-02f, -1.33797541e-01f, -9.76467282e-02f, -1.81936860e-01f, -2.71540254e-01f, -1.31173849e-01f, -6.26571663e-03f, -3.69604379e-02f, -1.05873816e-01f,
  -2.12368816e-02f, -1.93990335e-01f, -1.83311731e-01f, -1.51948825e-01f, 4.42115702e-02f, 1.72848683e-02f, 5.16018048e-02f, -2.29004957e-03f, 3.01145613e-02f, -2.09608451e-02f,
  -5.07391766e-02f, 1.31965512e-02f, 9.06694084e-02f, -2.38702130e-02f, 7.01682735e-03f, 3.64307500e-02f, -1.17543647e-02f, -3.40871736e-02f, 1.99258234e-02f, -2.93897130e-02f,
  -3.08781993e-02f, -2.24358812e-02f, 1.30130639e-02f, -2.87122745e-02f, -4.76803724e-03f, -4.85230330e-03f, -1.99809577e-02f, 4.03286628e-02f, -2.66575571e-02f, -2.05960646e-02f,
  -3.25365104e-02f, 7.06949756e-02f, 7.85153359e-02f, -2.13765539e-02f, -4.33997065e-03f, 7.67068490e-02f, 2.62344889e-02f, 4.97324206e-02f, -5.22311181e-02f, -1.30953426e-02f,
  -4.94747758e-02f, -2.72821318e-02f, -2.34291814e-02f, 2.18847045e-03f, -4.18504141e-02f, 2.72533037e-02f, -3.45001779e-02f, 4.07336690e-02f, 4.33423324e-03f, 1.70097966e-02f,
  1.22312762e-01f, 1.11000702e-01f, 2.29172930e-02f, 2.28611380e-02f, -1.64159611e-02f, 3.90473232e-02f, 4.56005037e-02f, 3.54128145e-02f, 5.34443893e-02f, 3.70165966e-02f,
  -4.56186272e-02f, 9.11398232e-03f, -2.44669095e-02f, 1.50209032e-02f, -1.95409004e-02f, 6.85452148e-02f, 3.81463654e-02f, 1.94709636e-02f, -4.11264189e-02f, -5.34786247e-02f,
  -7.71900490e-02f, -3.05457443e-01f, -2.43630856e-02f, 3.47403735e-02f, -6.65254965e-02f, 1.36768250e-02f, -4.42802757e-02f, 6.20495342e-02f, -7.61534348e-02f, -1.37081712e-01f,
  5.75055704e-02f, -3.04261949e-02f, 5.19226817e-03f, 3.39672752e-02f, -1.79581549e-02f, -5.23653068e-03f, -6.26888201e-02f, -4.55079116e-02f, -2.39210892e-02f, 3.01925262e-04f,
  7.78111257e-03f, -9.31931958e-02f, -5.05755795e-03f, -1.24539817e-02f, 3.87809426e-02f, 5.92101626e-02f, 3.40979584e-02f, 4.21286337e-02f, 3.95222530e-02f, -5.78985317e-03f,
  3.88920635e-01f, -2.85573546e-02f, 2.73740683e-02f, 6.69138953e-02f, 6.88580424e-02f, -3.11438352e-01f, -2.37518802e-01f, 3.11920140e-02f, -1.77651681e-02f, -1.83259070e-01f,
  -2.93653482e-03f, -1.57096907e-02f, -2.71503665e-02f, -1.17196120e-01f, 1.36216516e-02f, -1.90925132e-02f, -4.99036610e-02f, -3.49609256e-02f, 6.38795123e-02f, 1.16404384e-01f,
  9.97549295e-02f, -1.11218672e-02f, 9.43906605e-02f, 2.87520960e-02f, 8.52675512e-02f, 1.07863806e-01f, 8.70259628e-02f, -3.11761238e-02f, -1.66045316e-02f, -1.04772694e-01f,
  4.09350581e-02f, 1.58124477e-01f, -2.38149446e-02f, -5.40140346e-02f, 4.35536131e-02f, -7.64366705e-04f, -3.69722992e-02f, -4.13298421e-02f, 2.09334921e-02f, 2.86098919e-03f,
  -3.10667343e-02f, 6.35981187e-02f, -2.76335664e-02f, -2.84902025e-02f, -5.17420750e-03f, 1.18954107e-02f, -2.03169193e-02f, -4.30763140e-02f, 1.11132767e-02f, -1.60949230e-02f,
  -2.57450975e-02f, 5.15068590e-04f, -4.32659760e-02f, -6.26181439e-02f, -6.67150249e-04f, 2.96486355e-02f, 1.02577321e-02f, 2.50142682e-02f, 2.22337209e-02f, 7.05897855e-03f,
  -5.37145175e-02f, 5.15920706e-02f, 2.06631627e-02f, 1.69192087e-02f, -2.63282005e-02f, 5.82035780e-02f, -2.02407669e-02f, -2.93877386e-02f, 2.44961437e-02f, -4.10416983e-02f,
  -8.51550139e-03f, 1.63161531e-02f, 3.67509387e-02f, -5.77796102e-02f, 2.22280100e-02f, 2.29793526e-02f, 3.83527465e-02f, 6.92564528e-03f, -3.04747410e-02f, 2.37257313e-02f,
  1.67891115e-03f, 1.51293539e-02f, -1.17262146e-02f, -7.61590758e-03f, -1.46868248e-02f, -4.80298512e-02f, -4.24824096e-02f, -5.31132193e-03f, 1.79795790e-02f, 4.18287218e-02f,
  -4.83053364e-02f, 2.31983125e-01f, -3.92904365e-03f, 6.35769293e-02f, -2.33927500e-02f, 7.36939628e-03f, 1.88616607e-02f, -5.43266907e-03f, -2.26086173e-02f, 3.83436643e-02f,
  -2.38176249e-03f, -1.78490039e-02f, -1.58759754e-03f, -2.72442736e-02f, -2.95405183e-02f, 1.77904647e-02f, 4.68949899e-02f, -4.57148254e-02f, -1.93215925e-02f, 4.90722917e-02f,
  5.60593084e-02f, 4.21980992e-02f, -1.80492122e-02f, 4.26605754e-02f, 2.98672430e-02f, -3.66685241e-02f, -3.57715115e-02f, -5.32991551e-02f, 3.62959281e-02f, -3.82374525e-02f,
  -1.28027096e-01f, -1.76204473e-01f, -1.22470625e-01f, 1.82281900e-02f, 3.59981842e-02f, 7.42809251e-02f, 9.49249938e-02f, -7.98821524e-02f, -1.30058974e-01f, 1.44264810e-02f,
  7.99021646e-02f, -5.11146225e-02f, -3.38503197e-02f, 8.12894329e-02f, 1.05358042e-01f, 9.20476913e-02f, 4.34407778e-02f, 2.69753151e-02f, -3.43975686e-02f, -1.54730320e-01f,
  -4.89501022e-02f, 1.57201797e-01f, 6.43506050e-02f, -1.06801942e-01f, 4.87711653e-02f, -1.49844125e-01f, 6.48066252e-02f, 7.07598031e-03f, 5.19420393e-02f, 5.77506311e-02f,
  1.29756406e-01f, -1.37040466e-01f, -6.97229058e-02f, -4.68360931e-02f, -5.04138581e-02f, -5.81802800e-02f, 3.63640301e-02f, 3.77104282e-02f, 5.15047349e-02f, -3.13877575e-02f,
  1.25743933e-02f, -6.78864270e-02f, -3.48920673e-02f, 1.65422242e-02f, 8.65447742e-04f, -8.54622014e-03f, 1.88870840e-02f, 1.14321269e-01f, -2.59072036e-02f, 5.80603965e-02f,
  -2.21415795e-02f, 1.00414664e-01f, -3.13281566e-02f, -7.78537884e-04f, 8.22688267e-02f, 5.84463635e-03f, -1.92046873e-02f, -3.75572778e-02f, -3.01262736e-03f, -2.66265683e-02f,
  -4.46137041e-02f, -5.33797145e-02f, -2.02025007e-02f, 4.70663793e-02f, -5.79166450e-02f, 7.92896748e-02f, 3.28894630e-02f, 3.98887359e-02f, -4.30013798e-02f, 7.55165098e-03f,
  2.68431548e-02f, 2.24282816e-02f, -5.98070547e-02f, -1.43574299e-02f, 9.97082330e-03f, -2.20063981e-02f, 3.42258662e-02f, -1.18018489e-03f, -2.85468617e-04f, 2.60372218e-02f,
  5.19013666e-02f, 1.60271779e-03f, -2.40837689e-02f, 5.57881221e-02f, 3.13866846e-02f, 2.06359513e-02f, 2.38447394e-02f, 7.69432932e-02f, -7.08847260e-03f, -2.09608581e-02f,
  -1.00347258e-01f, -1.72676116e-01f, 3.42227928e-02f, 7.76471198e-02f, -3.88808474e-02f, 1.42425008e-03f, -2.59614792e-02f, -3.39374342e-03f, -9.07315612e-02f, -5.48506491e-02f,
  -1.85775757e-02f, 1.44389952e-02f, -2.16651894e-02f, -4.83961068e-02f, 4.02121432e-02f, -6.56041503e-03f, -2.62462590e-02f, -2.62588318e-02f, 2.61248071e-02f, -4.22183453e-04f,
  7.25738928e-02f, -1.67901684e-02f, -3.96221690e-02f, -1.38951624e-02f, -4.15287688e-02f, 5.47543913e-02f, -4.77826037e-02f, -7.18385652e-02f, -1.37915288e-03f, 3.59476835e-04f,
  1.32745594e-01f, 3.74078890e-03f, 1.65038452e-01f, 2.93132365e-01f, 5.29303029e-02f, 1.03856049e-01f, 8.95712152e-02f, -2.83912048e-02f, 1.65974811e-01f, -8.52758661e-02f,
  1.03390671e-01f, 6.09169416e-02f, -5.61492629e-02f, 2.47440487e-01f, 1.46861792e-01f, -4.24415804e-02f, 2.67442554e-01f, 1.28485173e-01f, -9.65597034e-02f, 1.56013429e-01f,
  9.92509872e-02f, 1.06225319e-01f, 7.78341293e-02f, -9.02653635e-02f, 9.65256914e-02f, -8.09200704e-02f, 5.90751357e-02f, -1.20479636e-01f, 7.65639544e-02f, -4.42915931e-02f,
  5.58764972e-02f, -1.43025117e-02f, 8.48306417e-02f, -5.21331467e-02f, 7.48150423e-02f, -2.29151882e-02f, 1.55298924e-02f, -2.38783993e-02f, 7.32107982e-02f, -3.54337730e-02f,
  -4.26235944e-02f, -5.59934750e-02f, 2.14010160e-02f, -4.73916084e-02f, 2.74524800e-02f, 4.70766760e-02f, 4.26363796e-02f, 3.53115760e-02f, 1.00380871e-02f, 3.76948677e-02f,
  6.01889305e-02f, -1.25677967e-02f, 7.94198364e-02f, -4.48626429e-02f, 6.51509687e-02f, 5.59005700e-02f, 4.81318161e-02f, -1.79024020e-04f, -1.55416166e-03f, 4.28559780e-02f,
  5.04447706e-03f, -1.92472897e-02f, -2.62405295e-02f, 7.51304557e-04f, 1.13946768e-02f, 9.44219250e-03f, 5.64858541e-02f, -2.96633635e-02f, -2.20597349e-02f, 4.61864397e-02f,
  8.98837019e-03f, -1.41961798e-02f, -2.75237840e-02f, -4.63201739e-02f, 7.08003864e-02f, -3.61184822e-03f, 4.16041091e-02f, -8.72032866e-02f, 1.20629128e-02f, 6.14317134e-02f,
  3.52645442e-02f, 3.53855863e-02f, -3.21144275e-02f, 1.17629999e-02f, 1.30344212e-01f, -3.63842845e-02f, -4.46442366e-02f, 9.72941238e-03f, 3.06383315e-02f, 2.24026982e-02f,
  9.43075418e-02f, 9.58287194e-02f, 2.25019250e-02f, 4.13348852e-03f, 5.19580245e-02f, -4.32186350e-02f, 3.70332599e-02f, -5.52825257e-02f, 3.95481735e-02f, -7.43033066e-02f,
  4.45040204e-02f, 1.00337677e-02f, -6.87851012e-03f, -2.70711705e-02f, 6.27362058e-02f, 1.34526845e-02f, 7.66662583e-02f, 6.86001182e-02f, 5.54018170e-02f, -5.59629984e-02f,
  -3.98049736e-03f, -4.95236926e-02f, 4.47042026e-02f, 1.83958448e-02f, 3.62228751e-02f, 1.97061654e-02f, -1.63322967e-02f, 4.58941981e-02f, -4.12026094e-03f, -8.51694567e-05f,
  7.97520503e-02f, -6.89396635e-02f, -1.58856794e-01f, 1.42468825e-01f, 5.04509956e-02f, -3.04463357e-02f, 2.17546448e-02f, 1.32498309e-01f, -1.10298142e-01f, 8.69296044e-02f,
  1.86448380e-01f, -2.38330171e-01f, 3.97856161e-03f, -9.91240665e-02f, -2.35514119e-02f, -1.30792931e-01f, -8.83570164e-02f, -3.41969058e-02f, -8.24916661e-02f, 4.34201956e-03f,
  -3.31509970e-02f, 9.86687392e-02f, 3.66545878e-02f, 1.04638778e-01f, 1.29340872e-01f, 1.02963462e-01f, 1.71521559e-01f, -5.82699245e-03f, 1.16631448e-01f, -2.80728973e-02f,
  7.42230639e-02f, 8.40633139e-02f, -6.04800917e-02f, 3.78814875e-03f, 6.75381646e-02f, 7.45791644e-02f, -6.97772345e-03f, -7.46712461e-02f, -8.45798850e-02f, 2.14205100e-03f,
  -3.09440028e-02f, 8.48958790e-02f, -7.62937963e-02f, -3.65424938e-02f, -5.38706854e-02f, 5.48503958e-02f, -3.77444066e-02f, -4.31255577e-03f, -1.09932255e-02f, -5.02318963e-02f,
  4.12238063e-03f, -3.30978609e-03f, 5.50463889e-03f, 2.87147257e-02f, -5.43217808e-02f, -2.23615281e-02f, -2.89643388e-02f, 2.82548200e-02f, 4.06362563e-02f, -4.04730402e-02f,
  -1.60320047e-02f, -3.73758934e-02f, 3.87871787e-02f, 9.10896529e-03f, 2.40426604e-02f, 6.54866397e-02f, -8.77260696e-03f, 4.88815680e-02f, 4.35407385e-02f, 5.25948480e-02f,
  1.60288122e-02f, 9.05592516e-02f, -8.16119369e-03f, -2.11732113e-03f, -4.43218648e-02f, -3.94806080e-02f, -5.89836575e-02f, 5.30725755e-02f, 1.91939343e-02f, 6.94737770e-03f,
  3.08261719e-02f, -3.39280702e-02f, 3.80990617e-02f, -2.26841476e-02f, -8.70039910e-02f, 5.84560446e-02f, 6.88949153e-02f, 3.69888395e-02f, -1.54236248e-02f, 6.87246993e-02f,
  9.94480550e-02f, 2.64128029e-01f, 3.61379460e-02f, 4.41281125e-02f, -6.16288856e-02f, 4.53274623e-02f, -1.44108996e-01f, -2.01976970e-02f, -2.13076975e-02f, -5.30146621e-02f,
  -2.81208614e-03f, 1.07635427e-02f, 1.55902021e-02f, 7.29028583e-02f, -1.78068113e-02f, 1.67797916e-02f, -5.01052151e-03f, -1.59594119e-02f, 9.13093165e-02f, 6.33794814e-02f,
  8.84634852e-02f, 6.59209937e-02f, -9.04190317e-02f, 3.56199257e-02f, 4.14821692e-02f, -6.94796219e-02f, 2.87881922e-02f, -4.27567807e-04f, 2.99825054e-02f, -4.37282436e-02f,
  1.40029177e-01f, 2.35710107e-02f, -9.50221643e-02f, -9.35712829e-02f, -1.58699732e-02f, -6.21538050e-02f, -2.28947565e-01f, -2.98691448e-02f, -3.23027313e-01f, -1.94432493e-02f,
  -2.69082431e-02f, -3.56776491e-02f, -9.71733406e-02f, -1.90848596e-02f, -3.65753882e-02f, -9.43185538e-02f, 2.11967900e-02f, 9.64595824e-02f, -2.46261377e-02f, 4.50368449e-02f,
  4.89225537e-02f, 8.04162025e-02f, 6.59920722e-02f, 1.31029263e-01f, 1.46584287e-01f, 1.41882315e-01f, 2.63411760e-01f, 1.08122997e-01f, 1.21284299e-01f, 1.21961636e-02f,
  3.04302275e-02f, -2.41418723e-02f, 3.29842716e-02f, -1.06023513e-02f, 6.96250275e-02f, -1.14378729e-03f, 8.87440369e-02f, -8.26233346e-03f, -6.31418750e-02f, -5.47344871e-02f,
  4.48912353e-04f, -3.52202095e-02f, -3.46866846e-02f, -8.92617628e-02f, -4.17904221e-02f, -6.95862770e-02f, -3.63529138e-02f, 2.77952384e-02f, -3.29111554e-02f, -2.60777138e-02f,
  -5.20117320e-02f, 1.03083909e-01f, 2.23997254e-02f, 1.64238717e-02f, -4.50925715e-02f, 2.57586781e-03f, -1.52052997e-03f, -4.87422943e-03f, 8.96823034e-02f, -5.00782579e-02f,
  4.94135432e-02f, -3.52467038e-02f, -1.60583556e-02f, 5.02266958e-02f, -3.39426771e-02f, -3.90071757e-02f, 7.11847991e-02f, 2.80995909e-02f, 1.86461955e-02f, 1.25329113e-02f,
  3.36063914e-02f, -3.96319740e-02f, -1.35216322e-02f, -6.85870573e-02f, 5.01605533e-02f, -2.36368682e-02f, 1.97904985e-02f, 8.83727446e-02f, -1.43656477e-01f, 3.01491302e-02f,
  -4.94627580e-02f, 1.19049000e-02f, -5.95500544e-02f, 9.52899829e-02f, 4.59423475e-02f, -1.40193686e-01f, -4.26989421e-02f, -3.74139100e-02f, -2.60813776e-02f, -3.97822727e-03f,
  2.38343015e-01f, 1.03437379e-01f, -4.05977666e-02f, 6.27139807e-02f, -2.32427306e-02f, 6.20282767e-03f, 4.94556986e-02f, 3.07401065e-02f, 2.39253845e-02f, -4.68079001e-03f,
  5.29196709e-02f, 3.84927057e-02f, 1.48101732e-01f, -1.14139607e-02f, 2.76380498e-02f, -1.68273989e-02f, 2.07132120e-02f, 2.28826385e-02f, 5.25196902e-02f, 1.21879123e-01f,
  1.38995752e-01f, 9.87195969e-02f, 6.14768080e-02f, -7.11023435e-02f, 4.67792302e-02f, 1.03304602e-01f, 3.56252193e-02f, 2.89672315e-02f, 9.84617919e-02f, 1.44545035e-02f,
  -1.11616291e-01f, 1.34815825e-02f, 9.04597864e-02f, 1.07779682e-01f, -7.13511854e-02f, -3.13304573e-01f, -1.93249792e-01f, 1.08144134e-01f, 1.24434784e-01f, 3.27814296e-02f,
  2.29834802e-02f, 1.51002213e-01f, -9.56393592e-03f, 7.78607577e-02f, -2.97884971e-01f, -1.54945478e-01f, -1.04753062e-01f, 1.87025759e-02f, 2.95777898e-02f, -1.38158202e-02f,
  -3.01674521e-03f, -9.41614136e-02f, -1.70992002e-01f, -3.96567620e-02f, 2.69876234e-03f, 6.93726465e-02f, 5.00754714e-02f, -7.15818480e-02f, 7.35251280e-03f, -7.01506734e-02f,
  -4.59904522e-02f, 1.21237367e-01f, 8.60697553e-02f, 1.10388333e-02f, -1.07657257e-03f, -3.72197665e-02f, -1.22563407e-01f, 1.73379816e-02f, 3.65660265e-02f, -1.30654750e-02f,
  -1.58373173e-02f, -5.04837744e-03f, -4.41713119e-03f, 7.18660504e-02f, -2.48671509e-03f, 8.61074328e-02f, -2.93299695e-03f, -5.25488593e-02f, 9.40035433e-02f, 7.54518211e-02f,
  -6.11032508e-02f, 2.56414656e-02f, 9.83360503e-03f, 2.11470574e-02f, -1.53766312e-02f, 6.65677106e-03f, -6.81120008e-02f, 7.36486400e-03f, -3.30248438e-02f, -4.65359353e-03f,
  -8.08890210e-04f, 4.40550745e-02f, 1.74145680e-02f, 2.95732450e-02f, -2.56792288e-02f, 5.49450032e-02f, -5.81502058e-02f, -1.29097924e-02f, -9.29602683e-02f, -7.11214691e-02f,
  -2.24185809e-02f, 4.93290043e-03f, 3.40324640e-02f, -5.29287523e-03f, 1.56211322e-02f, 3.45622674e-02f, -2.44715717e-02f, 5.31146750e-02f, -4.80905920e-02f, 8.00433476e-03f,
  6.61894083e-02f, -8.03882554e-02f, 2.59130299e-02f, -6.53966283e-03f, -6.34988695e-02f, -1.43202418e-03f, 4.92211729e-02f, 6.98056538e-03f, 6.61552399e-02f, -5.30840792e-02f,
  -6.59878924e-02f, 8.17301795e-02f, 5.85170723e-02f, -2.28003599e-02f, -3.33132446e-02f, 2.17142957e-03f, -3.50294113e-02f, 3.72878388e-02f, -6.68025464e-02f, 7.12248171e-03f,
  -1.16383350e-02f, 5.00893854e-02f, -9.74650979e-02f, 6.87035872e-03f, -6.55063568e-03f, -3.59657593e-02f, -1.61707643e-02f, -2.56911907e-02f, 8.58399924e-03f, 3.52360904e-02f,
  5.79155125e-02f, -9.24381763e-02f, 4.72786985e-02f, -1.53919440e-02f, -3.03376820e-02f, 3.33744995e-02f, 2.83325259e-02f, 5.00580929e-02f, -2.38142144e-02f, -4.87274975e-02f,
  -2.46221483e-01f, 5.68733700e-02f, -3.14302109e-02f, -1.11479968e-01f, -1.15803249e-01f, -5.43068834e-02f, 9.44718644e-02f, -4.79236767e-02f, 3.92320417e-02f, 6.60280287e-02f,
  -1.57452859e-02f, 2.74536423e-02f, 1.83569923e-01f, -5.64781316e-02f, 3.82028036e-02f, 2.20472395e-01f, -1.06657669e-01f, -5.37655726e-02f, 4.44935933e-02f, -1.52658656e-01f,
  -3.98489498e-02f, -1.35571495e-01f, 4.64926623e-02f, -1.63343534e-01f, -1.42695263e-01f, 1.43803684e-02f, 2.04962324e-02f, 7.77709335e-02f, -1.26878574e-01f, -4.78172824e-02f,
  1.77220535e-02f, -4.12816778e-02f, 2.12460253e-02f, -2.53008455e-02f, -2.76630502e-02f, -9.71604511e-03f, 1.90260280e-02f, 2.63030138e-02f, -4.31621559e-02f, -5.11621200e-02f,
  2.29861084e-02f, -2.40280163e-02f, -3.54102291e-02f, 4.72403951e-02f, -2.95522772e-02f, 7.92821422e-02f, 3.97437215e-02f, -4.06332240e-02f, 2.82525867e-02f, 1.40500031e-02f,
  1.10606529e-01f, -2.93101999e-04f, -7.21202651e-03f, -5.98381050e-02f, -6.57267263e-03f, 2.07559112e-02f, 3.59485745e-02f, 3.62358280e-02f, -4.25879434e-02f, -1.89711452e-02f,
  7.02727120e-04f, -6.56699911e-02f, -1.39219817e-02f, -3.34176682e-02f, 3.11239529e-02f, -2.17181202e-02f, -6.94128722e-02f, 6.68332204e-02f, 2.32925713e-02f, -5.09377169e-05f,
  -6.30533695e-02f, 1.65389460e-02f, 1.86662783e-03f, -3.65476571e-02f, -2.06126850e-02f, 5.50671481e-03f, -5.87419840e-04f, 9.00746733e-02f, -3.71766016e-02f, 3.55328433e-02f,
  2.89470460e-02f, 4.96670231e-03f, 2.66453400e-02f, -6.73809729e-04f, 1.29342880e-02f, 3.80117446e-02f, -5.60601391e-02f, 4.14180197e-02f, -2.16015987e-02f, -5.72436191e-02f,
  -5.69623746e-02f, 4.04269062e-03f, 6.85077161e-02f, -2.23982912e-02f, 4.25125211e-02f, 1.12331379e-02f, 7.12593133e-03f, -7.22749755e-02f, 1.16301151e-02f, -4.81545702e-02f,
  -5.43378517e-02f, 1.44990413e-02f, -6.04996905e-02f, -1.50999594e-02f, -3.53080556e-02f, 2.70432923e-02f, -1.78167652e-02f, 3.43574677e-03f, -2.72769257e-02f, 2.41554721e-04f,
  -5.62409721e-02f, 8.39930959e-03f, 2.25500818e-02f, -6.33462891e-02f, -5.66524453e-02f, -2.97239907e-02f, -2.03021951e-02f, 9.50538088e-03f, -4.04970348e-02f, 6.03522025e-02f,
  1.35151133e-01f, 7.97636807e-02f, 2.25613974e-02f, 3.28989118e-01f, 1.62876308e-01f, 2.39526525e-01f, 2.03566328e-01f, 1.56782418e-01f, 4.19671863e-01f, -8.38877633e-02f,
  -2.00288650e-02f, -1.24926537e-01f, -1.36492729e-01f, 8.35026149e-03f, 2.54241880e-02f, 6.60167113e-02f, 2.41972014e-01f, 1.26766384e-01f, 2.28044227e-01f, -3.90468426e-02f,
  1.24984607e-01f, 2.42905654e-02f, -1.41904801e-01f, -2.16973603e-01f, -1.64065755e-03f, -2.77385749e-02f, -1.39371216e-01f, -7.56455883e-02f, -1.17755197e-01f, 5.30459806e-02f,
  -2.63377894e-02f, 8.81221890e-02f, -4.23072800e-02f, -3.93330716e-02f, 1.87905747e-02f, -4.19741087e-02f, -4.54085171e-02f, -1.60371214e-02f, -5.21131046e-02f, 6.97428081e-03f,
  -4.53250371e-02f, -4.91159968e-02f, 6.79694489e-02f, -2.72198431e-02f, 5.11380658e-02f, -2.11646762e-02f, 1.61429346e-02f, 6.30434752e-02f, -8.29295889e-02f, -2.74899397e-02f,
  -4.68222797e-03f, 3.75907086e-02f, -3.30468081e-02f, 4.51820716e-02f, -3.30135296e-03f, 4.37826104e-02f, 4.13243584e-02f, 3.74844000e-02f, 3.88439163e-03f, 6.54654577e-02f,
  -2.37528626e-02f, 9.05489922e-02f, -4.46969010e-02f, -3.09906844e-02f, 2.27508377e-02f, -4.05996591e-02f, -3.20383441e-03f, -2.83152275e-02f, 1.28838327e-02f, -4.11953107e-02f,
  6.00456484e-02f, 3.45050767e-02f, 5.04335836e-02f, -6.24801451e-03f, 1.07282788e-01f, -2.31892038e-02f, -2.92531922e-02f, 3.53739187e-02f, 1.10847898e-01f, 3.03477068e-02f,
  1.47964424e-02f, -1.42716169e-02f, -7.75011331e-02f, -7.33731985e-02f, 5.87319443e-03f, 2.80914139e-02f, -2.01584473e-02f, -2.39420217e-02f, 2.04586349e-02f, 3.90173085e-02f,
  1.96600944e-01f, 2.03113586e-01f, 1.10701742e-02f, -4.93862992e-03f, -2.19932459e-02f, -7.52983093e-02f, 2.63229962e-02f, 8.44000466e-03f, 3.25977318e-02f, 7.65627425e-04f,
  4.39402694e-03f, -2.86955363e-03f, 1.61532257e-02f, 4.60623354e-02f, -9.63721424e-03f, 1.66373160e-02f, 5.81690436e-03f, 9.33120400e-02f, 4.48328108e-02f, -1.89060885e-02f,
  -5.63938022e-02f, 4.18107286e-02f, -2.92790346e-02f, 1.07334834e-02f, -4.06571710e-03f, -7.91180413e-03f, 4.54777926e-02f, -1.54505717e-02f, -3.02917045e-02f, 3.84384170e-02f,
  4.50866781e-02f, 1.17483430e-01f, -1.17372483e-01f, -5.28915077e-02f, -8.06151703e-02f, -3.62849049e-02f, 5.12166545e-02f, -3.79559696e-02f, -1.36754617e-01f, 2.31553674e-01f,
  9.63710342e-03f, 2.20956337e-02f, -6.72979951e-02f, 8.71246681e-02f, 4.04741243e-02f, 1.49049852e-02f, 1.70859128e-01f, 7.85741732e-02f, -1.24421805e-01f, 1.57385901e-01f,
  7.62665132e-03f, 2.19330207e-01f, -7.41921738e-02f, 2.17404068e-02f, -6.64734170e-02f, -8.13320279e-02f, 2.50509828e-01f, -7.52908513e-02f, 5.63564748e-02f, 7.19794910e-03f,
  -6.37628064e-02f, -9.22192782e-02f, -9.05378908e-03f, -3.29578705e-02f, 4.80412245e-02f, -3.66591364e-02f, 1.50309326e-02f, -1.02905808e-02f, -6.55511171e-02f, -4.17359397e-02f,
  -5.35029918e-02f, -4.51690592e-02f, 3.93608175e-02f, -6.64223582e-02f, -7.25207850e-02f, -4.30237092e-02f, -7.93872923e-02f, -6.37479126e-02f, -4.71396558e-02f, -1.50869325e-01f,
  -4.49254028e-02f, -1.22104369e-01f, 2.44136248e-02f, 1.95194443e-03f, 1.84714627e-02f, -5.41855358e-02f, -3.14095989e-02f, -3.56083512e-02f, 1.02054346e-02f, -2.30772868e-02f,
  -1.88754611e-02f, -2.32497435e-02f, 4.85365279e-02f, -2.61739045e-02f, 1.27789034e-02f, 1.07974540e-02f, -1.78412665e-02f, 3.43815386e-02f, -2.17145812e-02f, 3.84507440e-02f,
  5.60226217e-02f, -5.40762991e-02f, -4.38089808e-03f, -5.85171394e-02f, 1.57095585e-02f, -2.38403603e-02f, 1.85868423e-02f, 1.23328650e-02f, -2.71569900e-02f, 4.88246828e-02f,
  8.14147573e-03f, -1.54098682e-02f, -4.86379378e-02f, -2.22424716e-02f, -3.10131237e-02f, -6.01579249e-02f, -1.38446867e-01f, -6.25879765e-02f, 2.52935756e-02f, 4.05435637e-02f,
  1.98718518e-01f, 2.60577798e-01f, 1.41660180e-02f, -4.94850539e-02f, 1.30393235e-02f, 2.42425571e-03f, -6.87375711e-03f, 1.41364951e-02f, 9.02649537e-02f, 3.97053808e-02f,
  3.95695157e-02f, 5.54259196e-02f, 3.23256687e-03f, 8.61396268e-03f, -1.62585266e-02f, -5.10337437e-03f, 9.58036780e-02f, 9.15787593e-02f, 7.05975518e-02f, -7.07729980e-02f,
  -3.00021991e-02f, 3.50716226e-02f, -1.85024068e-02f, 7.79111171e-03f, 1.18359341e-03f, 8.15280452e-02f, 7.35958144e-02f, -4.34072539e-02f, -7.27586299e-02f, 4.53040861e-02f,
  -8.01293179e-02f, 1.74773306e-01f, -9.30594280e-02f, -1.42525256e-01f, -2.09709242e-01f, -7.51205534e-02f, -1.48956403e-01f, -1.44641325e-01f, -1.40571119e-02f, 1.77619204e-01f,
  -3.58688831e-02f, 1.70022130e-01f, 2.20774695e-01f, -1.38477504e-03f, -3.06309704e-02f, 2.19513401e-01f, -9.34696048e-02f, 5.94147854e-02f, 4.49733660e-02f, -3.03530358e-02f,
  -6.08103722e-02f, 6.34281244e-03f, 1.55839836e-02f, -2.56306939e-02f, -9.32927355e-02f, -3.18746781e-03f, -1.05185613e-01f, 9.98420827e-03f, -6.89642653e-02f, 5.95494062e-02f,
  3.58805098e-02f, 7.92571902e-02f, -4.00577448e-02f, 2.89688222e-02f, -8.23805183e-02f, -9.63768549e-03f, -5.35336360e-02f, 5.10284826e-02f, -6.19445592e-02f, 1.29098827e-02f,
  3.14040110e-02f, 1.50236664e-02f, 5.76619506e-02f, 2.65140347e-02f, -3.77764292e-02f, -4.11091186e-03f, -4.72817086e-02f, -4.44400981e-02f, 4.17137966e-02f, 3.09321340e-02f,
  3.13260891e-02f, -8.00373778e-02f, -7.24396110e-02f, 7.79209137e-02f, -3.86817195e-02f, 9.09798592e-03f, 3.64695489e-02f, 4.46682386e-02f, 5.51136620e-02f, -1.56400520e-02f,
  6.49118796e-02f, 3.34810582e-03f, 5.72036281e-02f, -7.16812536e-02f, -4.64747883e-02f, -1.48651274e-02f, -2.11808942e-02f, 3.95793468e-02f, -3.52436677e-02f, -4.91311178e-02f,
  -6.32055402e-02f, -8.06293392e-05f, -5.50967678e-02f, -8.32534395e-03f, -3.72892246e-03f, -3.75616141e-02f, 2.56500393e-02f, 6.12487318e-04f, -1.79642439e-02f, -3.96306366e-02f,
  2.57410537e-02f, 2.92758979e-02f, -2.59081423e-02f, 9.51373484e-03f, -3.22166979e-02f, 3.94912958e-02f, 2.90720854e-02f, 1.25312470e-02f, -9.64181311e-03f, -6.05079606e-02f,
  1.85315982e-02f, 9.97476429e-02f, 3.73316593e-02f, 5.64815030e-02f, -2.52375472e-02f, -8.00406337e-02f, 4.38599139e-02f, -1.42552564e-02f, 8.93217996e-02f, -4.49858001e-03f,
  -1.25639094e-02f, -1.38952527e-02f, -5.63573986e-02f, 5.24510667e-02f, 1.65937692e-02f, -1.10104596e-02f, 7.08580464e-02f, -5.09809051e-03f, -4.62578423e-02f, -6.58423966e-03f,
  -3.50036360e-02f, 3.50867473e-02f, -2.44736448e-02f, -1.35437315e-02f, 3.86334956e-03f, 1.16152391e-02f, 8.73160362e-03f, -9.91436653e-03f, -2.79984926e-03f, 3.78768779e-02f,
  2.11994141e-01f, -1.99746266e-01f, -2.30201200e-01f, -1.08026909e-02f, 1.70205787e-01f, 5.14548793e-02f, -1.71434730e-02f, 1.51302487e-01f, 1.03232823e-01f, -1.06457379e-02f,
  1.21436007e-01f, -2.47276902e-01f, -1.60232082e-01f, 4.34490629e-02f, 1.45412907e-01f, -5.03421761e-02f, 4.61267401e-03f, -2.09579151e-02f, 2.63624303e-02f, -9.43563655e-02f,
  1.11185938e-01f, 1.44446388e-01f, -1.21813893e-01f, 6.79962933e-02f, -5.23967445e-02f, -1.40137240e-01f, -2.39202455e-02f, -1.65163413e-01f, -7.92736560e-02f, 6.15483038e-02f,
  -4.51616608e-02f, -8.97739455e-03f, -2.74724346e-02f, -1.08376136e-02f, 4.49224003e-03f, -2.36713085e-02f, -2.87569091e-02f, -5.74060902e-02f, -3.53585742e-02f, -2.77441517e-02f,
  -2.85484474e-02f, 2.18194891e-02f, 3.87741476e-02f, -5.91444364e-03f, 5.58453575e-02f, 3.43944714e-03f, 9.74404439e-03f, -2.68954355e-02f, 9.38096270e-03f, 8.31929594e-03f,
  -7.60174021e-02f, -1.75398570e-02f, 5.57893068e-02f, -7.00324774e-02f, -4.31458727e-02f, 2.24878397e-02f, -4.54351716e-02f, -7.91767165e-02f, -2.24199612e-02f, 1.45385535e-02f,
  -1.10494616e-02f, 2.41153147e-02f, 6.43709525e-02f, 2.75974609e-02f, 1.48351770e-02f, 3.55964452e-02f, 3.13136578e-02f, 2.05532815e-02f, 7.45703876e-02f, -3.39581259e-02f,
  1.23716835e-02f, -9.13227908e-04f, 9.25619826e-02f, -2.91247386e-02f, -1.01981424e-02f, 4.97670732e-02f, -8.69574863e-03f, -3.48400995e-02f, 2.67163329e-02f, 5.15461005e-02f,
  -2.55723186e-02f, 9.50580090e-03f, -5.86521551e-02f, -2.52965465e-02f, 3.31946351e-02f, 4.35097888e-02f, 5.01538962e-02f, -7.93111399e-02f, -2.82241334e-03f, 7.22102448e-03f,
  2.62535941e-02f, -3.06952596e-02f, -2.29184087e-02f, -2.26800442e-02f, -4.69778031e-02f, 1.02298204e-02f, 1.60555150e-02f, 2.55447831e-02f, -6.71354607e-02f, 1.90848671e-02f,
  -3.21543962e-02f, 4.70145606e-02f, -1.18405819e-02f, -7.83465710e-03f, -1.92430874e-04f, 5.64783663e-02f, 7.65883131e-03f, -2.44925916e-02f, -2.32328158e-02f, 3.01232841e-02f,
  1.08726807e-02f, -5.20180957e-03f, 3.92159037e-02f, 2.43037231e-02f, 4.50838953e-02f, -5.32235205e-02f, -1.67781562e-02f, -5.51613420e-02f, 8.98862444e-03f, -5.43304197e-02f,
  1.77600786e-01f, -1.34287253e-01f, 1.68247551e-01f, 1.24351243e-02f, -6.06327951e-02f, -4.06005293e-01f, -2.49817416e-01f, -2.45019682e-02f, 2.76871435e-02f, -2.24916473e-01f,
  -5.81863038e-02f, -1.10092284e-02f, 1.25043094e-02f, -2.97269315e-01f, -6.23034255e-04f, -4.01416123e-02f, -9.75934342e-02f, -1.67410940e-01f, 1.25386760e-01f, 5.97439148e-02f,
  9.47562829e-02f, -1.92258060e-01f, 5.82536161e-02f, -2.75305286e-02f, -8.87870602e-03f, 1.52827233e-01f, 1.66278794e-01f, 9.25769284e-02f, -3.68196219e-02f, -8.71896818e-02f,
  -1.08575977e-01f, -7.60314800e-03f, -2.03873795e-02f, -1.08831665e-02f, -5.25692031e-02f, -1.64523050e-02f, 2.21957825e-02f, -4.71016876e-02f, 5.85276969e-02f, 1.44750336e-02f,
  8.06523114e-03f, 1.51615068e-02f, -5.11697270e-02f, -3.41941528e-02f, 7.82520324e-03f, 4.87833396e-02f, 6.19278736e-02f, -4.34349179e-02f, 1.80394374e-04f, -1.16119878e-02f,
  4.21549045e-02f, -4.39020135e-02f, 2.43446268e-02f, -1.59114674e-02f, 7.07579777e-02f, -1.40904542e-02f, -3.42548685e-03f, 1.73292831e-02f, -6.39129579e-02f, -5.02976775e-02f,
  1.85382050e-02f, -6.14471547e-02f, -3.63302566e-02f, -4.29184064e-02f, 2.22477168e-02f, 1.25795649e-02f, -6.46686628e-02f, 3.88180502e-02f, 5.71068935e-02f, 5.65110445e-02f,
  4.03660024e-03f, 4.71757129e-02f, -8.18524510e-02f, 3.91675085e-02f, 7.48283323e-03f, -1.16993085e-01f, -8.19020532e-03f, -3.15391179e-03f, 1.06871374e-01f, -1.40386410e-02f,
  -1.26381414e-02f, 3.99552397e-02f, -3.87957669e-03f, -1.82418749e-02f, -5.79311326e-02f, 1.43110119e-02f, -4.17135581e-02f, 6.93178400e-02f, 4.29110788e-02f, 2.39872467e-02f,
  -1.27441853e-01f, 8.62790942e-02f, 2.32170653e-02f, -5.53101525e-02f, 3.08846217e-02f, -3.45569775e-02f, -4.59093740e-03f, -3.66960913e-02f, 1.05331205e-01f, -4.53651249e-02f,
  1.16541404e-02f, 1.11473771e-02f, -1.27393240e-02f, 5.96378371e-02f, -3.64051461e-02f, -1.38792042e-02f, -1.02729462e-02f, 7.86245912e-02f, 4.34861183e-02f, 6.03287555e-02f,
  4.89828363e-02f, 7.19708949e-02f, -4.93995100e-03f, 3.20700556e-02f, -3.88385765e-02f, 4.59715165e-02f, 3.26545797e-02f, 3.33872177e-02f, -1.61434803e-02f, 7.97474757e-02f
};

// L0_fan_Wp_bar (Shape: 14 x 120)
const int L0_fan_Wp_bar_rows = 14;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  2.91045289e-02f, 1.01291865e-01f, -4.37281802e-02f, 3.24629880e-02f, 4.62418981e-02f, -9.64915454e-02f, -9.33837220e-02f, 9.56098363e-02f, -2.16525137e-01f, 4.68628556e-02f,
  3.64172123e-02f, -7.69330338e-02f, 6.26570210e-02f, -6.79729432e-02f, 3.04459836e-02f, -1.74522907e-01f, 1.71602666e-02f, -9.71179381e-02f, -3.77124548e-02f, 2.39882231e-01f,
  -6.52921423e-02f, 1.30239621e-01f, 1.21346628e-02f, 1.39822483e-01f, 5.54143032e-03f, 5.08959927e-02f, 2.78301239e-01f, 1.35412917e-01f, 2.83570718e-02f, -5.82746789e-02f,
  -1.33465882e-02f, 4.72964393e-03f, -6.51526228e-02f, -1.10143654e-01f, 4.32603136e-02f, 4.24407385e-02f, -8.98422487e-03f, -1.20940963e-02f, -5.50143234e-03f, -3.76191102e-02f,
  -4.62443614e-03f, -7.51065388e-02f, 1.98809989e-03f, 1.59684345e-02f, -3.77624668e-02f, 1.78477243e-02f, -2.22142995e-03f, -3.17037925e-02f, -1.56448353e-02f, 3.92888300e-02f,
  1.74091309e-02f, -5.64447232e-03f, -5.04850633e-02f, -7.09905475e-02f, -2.31388751e-02f, -5.72045445e-02f, -2.03350727e-02f, 8.43930095e-02f, -2.37388015e-02f, -1.36919348e-02f,
  5.74813783e-02f, 3.79403718e-02f, -4.75945547e-02f, -1.37440354e-01f, 4.03401963e-02f, -1.25571266e-02f, -9.16773751e-02f, -1.17713809e-02f, -4.52211648e-02f, 6.92398176e-02f,
  -3.00032031e-02f, 3.98785248e-02f, -9.22879726e-02f, 3.47769000e-02f, 1.82105880e-02f, -6.91341376e-03f, 3.63644287e-02f, 2.02486571e-02f, 8.33794028e-02f, -3.85463610e-02f,
  -5.47758937e-02f, 7.93177634e-02f, -5.90125518e-03f, 5.02803400e-02f, 5.18733123e-03f, 8.97327363e-02f, 4.97425646e-02f, -3.16647217e-02f, -2.81565450e-02f, -8.48857239e-02f,
  1.29592299e-01f, 2.71553665e-01f, 4.80330689e-03f, 1.53895179e-02f, 5.48752584e-02f, -5.53266006e-03f, -4.38467786e-02f, -4.56131883e-02f, 5.37761627e-03f, 1.05806373e-01f,
  7.42925555e-02f, -5.58939278e-02f, 2.81619132e-02f, 7.82924071e-02f, -2.19161864e-02f, 3.94629091e-02f, 5.62413484e-02f, -1.27903372e-02f, 4.73460034e-02f, 3.76412310e-02f,
  5.66866882e-02f, 5.35377860e-02f, -5.62937930e-02f, -1.85534842e-02f, 1.55070229e-02f, 7.46435300e-02f, 4.27719317e-02f, 6.78265095e-02f, -3.07037625e-02f, -1.03964381e-01f,
  1.75850704e-01f, -2.51277149e-01f, -7.88121149e-02f, -2.06125721e-01f, -7.82651752e-02f, -2.24429503e-01f, -1.45952433e-01f, -2.69359738e-01f, -1.18930422e-01f, -3.03355217e-01f,
  -1.37865439e-01f, 9.03060511e-02f, 1.48219019e-01f, -2.64001787e-01f, 2.61818916e-01f, 1.54870108e-01f, -1.84183285e-01f, -1.05331205e-01f, 5.60711417e-03f, -1.25330791e-01f,
  -1.01459790e-02f, -1.77649215e-01f, 5.98253608e-02f, -1.89317256e-01f, -2.45669991e-01f, -8.43286514e-02f, 1.09672286e-01f, 6.10722750e-02f, -2.60352433e-01f, -5.83765954e-02f,
  -2.83998065e-02f, -2.49509085e-02f, -7.15500265e-02f, 6.51413202e-03f, -4.37747948e-02f, -2.05945410e-02f, 6.19717576e-02f, 1.16268612e-01f, 1.91354621e-02f, 4.92789783e-02f,
  8.58964548e-02f, 4.17791866e-02f, -1.10795639e-01f, 1.11518055e-01f, -1.10942787e-02f, -6.07010722e-02f, -2.90267691e-02f, -4.05618623e-02f, -2.59471461e-02f, 3.11378073e-02f,
  -4.11016867e-02f, 9.01457854e-03f, -9.30759460e-02f, 1.84699502e-02f, 4.01488142e-05f, -4.43005413e-02f, 6.05410822e-02f, 5.96866608e-02f, 8.31690356e-02f, -4.79614995e-02f,
  -3.52292173e-02f, 9.66461301e-02f, 4.82577942e-02f, -8.28123242e-02f, -6.24325946e-02f, -4.45496403e-02f, -6.32720487e-03f, -2.09019072e-02f, -4.30289432e-02f, -9.12218243e-02f,
  -6.35626838e-02f, -1.28300693e-02f, -3.17621380e-02f, 1.05059184e-02f, -4.23390903e-02f, 5.96454786e-03f, 4.16570576e-03f, -2.84455810e-02f, -1.14994712e-01f, -5.09395525e-02f,
  5.20030111e-02f, -4.26458288e-03f, -4.57387455e-02f, 1.89806074e-02f, 6.21843636e-02f, 5.03133722e-02f, -8.25182125e-02f, -4.47146781e-02f, -6.67559057e-02f, 3.20665874e-02f,
  7.56055256e-03f, -8.90916809e-02f, -8.42808560e-02f, -7.59457499e-02f, 1.19647775e-02f, 1.41959777e-02f, 2.54055392e-02f, -4.39087711e-02f, -1.65451653e-02f, -1.87166706e-02f,
  -2.27535516e-03f, 3.13556045e-02f, -1.55978240e-02f, -2.96989512e-02f, -5.51769957e-02f, -1.17434025e-01f, 4.50607836e-02f, -2.95449570e-02f, -3.83590907e-02f, -7.39889294e-02f,
  -8.32062438e-02f, -1.98864825e-02f, 5.39774671e-02f, -1.28038945e-02f, -2.72619706e-02f, 3.95364873e-02f, 1.54820969e-02f, 2.33806986e-02f, 9.03028324e-02f, -4.45330814e-02f,
  -3.41830730e-01f, 4.09843028e-02f, -2.49204010e-01f, -2.46234506e-01f, 1.52084738e-01f, -2.94963688e-01f, -2.13977456e-01f, 5.38228378e-02f, -7.25549310e-02f, 9.23920050e-02f,
  4.73958254e-02f, -4.48220260e-02f, 1.99464202e-01f, -2.70671397e-01f, -2.00524047e-01f, -1.75037030e-02f, -3.26427788e-01f, -1.38098389e-01f, 2.44214330e-02f, -1.11355364e-01f,
  -7.55307153e-02f, 2.85131279e-02f, -1.48494706e-01f, 2.06789792e-01f, -1.37033969e-01f, 1.51957208e-02f, 1.58878133e-01f, 1.33974493e-01f, -1.23181783e-01f, 9.20024663e-02f,
  -3.45684141e-02f, 1.17024705e-01f, 4.21200581e-02f, -7.29105622e-02f, -3.28986198e-02f, 1.16782151e-02f, -9.44155753e-02f, 2.63169967e-02f, 2.05230638e-02f, -1.84731334e-02f,
  2.82915216e-02f, 4.95717712e-02f, -8.23501572e-02f, 6.31047934e-02f, -3.00815459e-02f, -4.91804704e-02f, 6.49893563e-03f, -3.27424183e-02f, 1.05513902e-02f, -7.17002749e-02f,
  -7.75199607e-02f, -5.59344771e-04f, -1.44050330e-01f, -1.91698279e-02f, -4.62936759e-02f, 3.90996449e-02f, -1.36435255e-01f, -3.98809947e-02f, -9.46627185e-02f, -4.82360162e-02f,
  -4.91312779e-02f, -5.42424060e-02f, -4.29610834e-02f, 1.17166795e-01f, -5.23539521e-02f, 1.97503679e-02f, -2.50144526e-02f, 1.54104270e-02f, -6.55548135e-03f, 5.55641428e-02f,
  6.50318861e-02f, 3.45196063e-03f, 7.26066669e-03f, -6.06609285e-02f, -2.67121177e-02f, 7.64289638e-03f, -1.54826958e-02f, 4.50233966e-02f, -1.15775324e-01f, -5.29158860e-03f,
  5.02358153e-02f, -4.23288532e-02f, 2.02277564e-02f, -5.40426336e-02f, 6.10873476e-02f, 9.21012089e-03f, -4.70772646e-02f, -5.39116673e-02f, 4.66398988e-03f, 7.58138299e-03f,
  3.60477902e-02f, 6.56168684e-02f, 6.98887929e-02f, 8.75009075e-02f, 5.96230812e-02f, -4.95797135e-02f, -7.34641310e-03f, -9.52538550e-02f, -2.99574733e-02f, -3.72152403e-02f,
  4.67267819e-03f, -1.48912296e-02f, -3.19336839e-02f, -2.55234670e-02f, 3.96382473e-02f, 7.63996597e-03f, -8.10403004e-03f, 8.83750990e-02f, -2.39402242e-02f, 2.68884352e-03f,
  -1.68430321e-02f, 5.64071350e-02f, -2.05925889e-02f, -1.14537263e-02f, -2.16892175e-02f, -2.10723025e-03f, -5.52545302e-02f, 1.57574508e-02f, 1.94637682e-02f, 3.37939300e-02f,
  3.24156493e-01f, -3.13894272e-01f, 4.50136773e-02f, 2.58816928e-01f, 2.92405099e-01f, 1.42172515e-01f, 3.47696483e-01f, 1.18272211e-02f, 2.66721725e-01f, -1.61740690e-01f,
  -4.74622510e-02f, -4.50380705e-02f, -8.90581682e-02f, 1.18083116e-02f, 1.80676207e-01f, -6.49703145e-02f, 6.07381724e-02f, -1.94256399e-02f, 4.47075740e-02f, -1.77931320e-02f,
  1.10366128e-01f, 4.41657491e-02f, 1.28909331e-02f, -1.24471188e-01f, 8.03179964e-02f, 1.39934681e-02f, -7.97205642e-02f, 9.97758936e-03f, -6.34410605e-02f, 3.69390808e-02f,
  4.69073057e-02f, 2.74716113e-02f, 7.58154616e-02f, -4.55056876e-02f, 1.07600715e-03f, -6.52445853e-02f, -4.97127995e-02f, -1.01005491e-02f, 7.31080100e-02f, -9.24891513e-03f,
  -6.85308054e-02f, -2.21852176e-02f, 5.05341142e-02f, 6.48965314e-02f, 7.25305872e-03f, -2.17209847e-04f, 2.46763825e-02f, -8.87286738e-02f, -2.05958895e-02f, -9.17490479e-03f,
  -2.18025432e-03f, -4.55665477e-02f, -4.53143977e-02f, -7.46192336e-02f, -8.15338194e-02f, 4.68282998e-02f, -5.39434627e-02f, -4.69713882e-02f, -3.04072779e-02f, 5.14809266e-02f,
  3.47306207e-02f, -2.69825552e-02f, -2.31244508e-03f, 1.12751490e-02f, 1.16554310e-03f, 5.69444187e-02f, -6.93906695e-02f, 2.08444633e-02f, -8.51831362e-02f, 2.29346715e-02f,
  -1.10338442e-04f, -1.81916691e-02f, -2.85241567e-02f, 5.87142631e-02f, 3.30188386e-02f, -2.85659507e-02f, -5.77359088e-02f, -8.19436535e-02f, -2.71949521e-03f, -1.29101109e-02f,
  7.94206262e-02f, 3.12389769e-02f, -3.76077779e-02f, 9.72113982e-02f, 1.34065030e-02f, 1.75075023e-03f, -5.65771051e-02f, 6.80665579e-03f, 1.50184231e-02f, -4.93663363e-02f,
  -1.30034029e-01f, -1.32062569e-01f, 4.16743085e-02f, -7.81921223e-02f, -1.61356181e-02f, -6.57311603e-02f, 3.80534641e-02f, -2.13970579e-02f, 1.12231635e-02f, 2.93485280e-02f,
  -1.10093076e-02f, 6.72832131e-02f, -5.00739440e-02f, 7.71937240e-03f, -3.88553552e-02f, -5.34730777e-02f, 5.46288416e-02f, -5.00599146e-02f, 3.05764508e-02f, -1.25280112e-01f,
  -3.81140672e-02f, -5.11953048e-02f, 2.63783662e-03f, 1.44796725e-02f, -3.35395848e-03f, -1.98899228e-02f, -9.50087700e-03f, -1.84398927e-02f, -9.58618447e-02f, -1.22683691e-02f,
  -3.58128726e-01f, -6.12251349e-02f, 4.96129952e-02f, -1.92196921e-01f, -8.70384946e-02f, 1.51427895e-01f, 1.36960879e-01f, -8.04314315e-02f, 3.80531041e-04f, 1.31973118e-01f,
  1.45902066e-02f, -6.53949752e-02f, 1.83571696e-01f, -4.75063995e-02f, 1.05521455e-01f, 1.27531454e-01f, 1.33370021e-02f, 3.96449380e-02f, -1.17991775e-01f, -2.06617713e-01f,
  -8.90990198e-02f, -2.08311737e-01f, -7.31768087e-02f, -1.85701042e-01f, -1.66038379e-01f, -1.43681660e-01f, 4.41976823e-02f, -5.64665198e-02f, -4.34552617e-02f, -6.02818420e-03f,
  -1.40474394e-01f, -2.57685870e-01f, -7.86631927e-02f, 2.07773857e-02f, -1.71538144e-02f, 1.20095164e-02f, -1.60244200e-02f, 6.71995729e-02f, 8.30550771e-03f, -1.11277312e-01f,
  2.60315686e-02f, -1.80650242e-02f, -3.11600175e-02f, -3.56140248e-02f, 2.07729116e-02f, -3.29657011e-02f, -1.24474270e-02f, 5.85336573e-02f, 1.71462949e-02f, 2.88337115e-02f,
  -5.59926732e-03f, 5.34300401e-04f, -7.38045154e-03f, 1.03235124e-02f, -6.24419190e-03f, -1.76284593e-02f, 2.54549459e-02f, 2.97039631e-03f, 8.94383248e-03f, -4.27181125e-02f,
  -1.20122004e-02f, 2.91982526e-03f, -2.28220206e-02f, 2.54982132e-02f, -3.15618608e-03f, 1.55806616e-02f, 2.65264381e-02f, -4.83261459e-02f, -1.39828194e-02f, -1.97885875e-02f,
  1.05142370e-02f, 2.12089568e-02f, -6.39862195e-02f, 1.69273950e-02f, 1.08158831e-02f, 1.52085302e-02f, -6.85765967e-02f, -6.78704157e-02f, 1.07955649e-01f, 6.23198897e-02f,
  -5.46976328e-02f, 8.63232743e-03f, 4.52560261e-02f, -2.52679382e-02f, -2.77458765e-02f, -4.94098105e-03f, -1.87389017e-03f, -3.24459784e-02f, -4.10985127e-02f, 9.05116424e-02f,
  -1.42716303e-01f, -1.60832018e-01f, -5.51422499e-02f, -1.97400115e-02f, -7.14624720e-03f, -3.45844366e-02f, -2.95309965e-02f, -7.59072974e-02f, 3.84027697e-02f, -5.22733293e-02f,
  3.05963978e-02f, 8.84017721e-03f, -1.36233428e-02f, -2.53613740e-02f, 5.30811660e-02f, 4.65749763e-02f, -6.32922631e-03f, 4.91573848e-02f, -9.32587404e-03f, 9.03381221e-03f,
  -6.61919117e-02f, -3.61598320e-02f, 3.51492316e-02f, -6.63827593e-03f, 1.08366646e-02f, -1.75412819e-02f, -3.94800454e-02f, 7.76356012e-02f, 6.19290024e-02f, 3.87797244e-02f,
  4.89185005e-03f, -3.83382499e-01f, -7.50821605e-02f, 4.54885289e-02f, 3.83311026e-02f, -1.63079470e-01f, -2.63843447e-01f, -2.22421177e-02f, -6.90871701e-02f, -1.59414351e-01f,
  -2.77742762e-02f, 1.54652551e-01f, -1.19579799e-01f, 4.69831675e-02f, 2.18148649e-01f, -8.81398544e-02f, 6.50327131e-02f, 3.56471911e-02f, 3.68964635e-02f, 2.39140354e-02f,
  1.59629107e-01f, 1.67295009e-01f, 1.06285408e-01f, 2.23947972e-01f, 6.35628402e-02f, 1.71292543e-01f, 2.27017984e-01f, 1.87490582e-02f, 1.89864188e-01f, 2.06318662e-01f,
  -3.11248028e-03f, -1.27263619e-02f, -1.24602476e-02f, 7.86245242e-02f, 2.82914266e-02f, -3.09080742e-02f, -1.25606824e-02f, 4.89896908e-02f, 4.17491160e-02f, -4.26423685e-05f,
  -2.19914615e-02f, 2.58368198e-02f, 4.97416183e-02f, 8.45269039e-02f, -2.47230437e-02f, 1.42978495e-02f, -2.93426272e-02f, 5.33848219e-02f, 3.09280623e-02f, -7.01335892e-02f,
  -4.05061655e-02f, 1.98461507e-02f, -1.25640957e-02f, 3.21862772e-02f, -7.29955211e-02f, -4.85037379e-02f, 1.51673155e-02f, -1.22731319e-02f, 2.25746185e-02f, 5.99445999e-02f,
  -2.15722937e-02f, 6.72684796e-03f, -5.46514653e-02f, -2.84098811e-03f, -1.44364964e-02f, -1.06902458e-01f, -1.27273098e-01f, -5.81115391e-03f, 8.81496351e-03f, -6.67453045e-03f,
  -2.07241010e-02f, -4.94700819e-02f, 1.14499278e-01f, -1.08558454e-01f, -1.54271787e-02f, 5.88584505e-02f, -7.73896789e-03f, 1.17462641e-02f, 3.51444557e-02f, -8.28516632e-02f,
  1.20357731e-02f, 7.12364316e-02f, 3.12831514e-02f, -7.05000339e-03f, -5.52626774e-02f, -7.99321476e-03f, 5.11177368e-02f, -8.33554193e-02f, -4.03640047e-02f, -2.74394974e-02f,
  -5.74442297e-02f, -2.31690183e-02f, 1.19175646e-03f, 6.54415190e-02f, -9.21005290e-03f, 1.21633493e-04f, 5.69718294e-02f, 4.17319089e-02f, -2.73029823e-02f, -9.58631933e-02f,
  1.11678652e-02f, 9.82852001e-03f, -7.07690492e-02f, 7.11295381e-02f, 1.21351756e-01f, -1.29826695e-01f, 6.11075163e-02f, 5.53661175e-02f, 2.16671322e-02f, -1.28328213e-02f,
  1.58676524e-02f, -1.13365516e-01f, 5.03836013e-02f, 1.90582387e-02f, -9.03631374e-03f, -4.75982949e-02f, 1.96669362e-02f, 2.02355236e-02f, -4.64101285e-02f, 1.07567422e-01f,
  -2.60810047e-01f, 2.28473738e-01f, 1.30510945e-02f, 4.00049865e-01f, -2.12516263e-01f, -2.33510748e-01f, 1.81412906e-03f, 1.90238617e-02f, -3.62168252e-02f, 1.98284954e-01f,
  1.77005425e-01f, -1.07196532e-01f, 1.76393256e-01f, 3.08643550e-01f, 4.33303230e-02f, 2.36255303e-01f, 2.00847909e-01f, 5.82502037e-02f, 4.93544526e-02f, 5.53618520e-02f,
  6.76689446e-02f, 1.39017209e-01f, 2.67274082e-01f, 1.44649053e-03f, 5.99110015e-02f, 5.74170500e-02f, 1.75777897e-01f, -5.64660914e-02f, 8.06339830e-02f, -3.10465042e-02f,
  -1.83955599e-02f, 1.22947460e-02f, 2.39812373e-03f, -9.10434648e-02f, -1.61931291e-02f, -7.81143084e-02f, -7.47294631e-03f, -2.91443989e-02f, -4.37864624e-02f, 4.39563915e-02f,
  -4.31342050e-02f, -6.13056235e-02f, 3.50480005e-02f, -6.51598535e-03f, -3.64429317e-02f, -3.79867293e-02f, -6.17129803e-02f, -1.38637470e-02f, 2.76565924e-02f, -6.76302537e-02f,
  -1.15119964e-02f, 2.43128054e-02f, 4.86634560e-02f, 9.10851881e-02f, -6.73586875e-03f, 2.31979601e-02f, 2.87496615e-02f, -7.37763420e-02f, -4.89930920e-02f, -6.66360697e-03f,
  -9.59467962e-02f, -4.79060635e-02f, 4.09476161e-02f, -2.58657392e-02f, 1.10897673e-02f, 7.46126249e-02f, 5.80217913e-02f, 4.62477207e-02f, -4.69375886e-02f, 2.79644709e-02f,
  4.85468134e-02f, -4.89194086e-03f, -5.17243333e-03f, -1.02474098e-03f, 1.49336625e-02f, 1.98173383e-03f, -2.31336541e-02f, 1.94190610e-02f, 2.88606063e-02f, -9.06427111e-03f,
  2.62954477e-02f, -9.38413292e-03f, 3.14199813e-02f, -1.27283065e-02f, -1.21872630e-02f, -1.55126899e-02f, 7.87571371e-02f, 5.49599230e-02f, 6.54800311e-02f, -5.84865697e-02f,
  5.90110719e-02f, 1.47672683e-01f, 9.01395231e-02f, -9.34812278e-02f, 4.48130220e-02f, -5.20232208e-02f, -5.48216701e-03f, -8.59411508e-02f, -1.35881733e-02f, 9.18328483e-03f,
  -6.28664121e-02f, -7.93254282e-03f, 9.35863610e-03f, 1.57537442e-02f, 1.31197670e-03f, 2.24140566e-02f, 8.76636133e-02f, -3.66741829e-02f, 4.42369431e-02f, 5.59383712e-04f,
  7.06413463e-02f, -1.89755317e-02f, -2.20277049e-02f, -1.79323070e-02f, 2.83133462e-02f, 2.60053966e-02f, -1.15719624e-01f, -7.27140456e-02f, 2.64870878e-02f, -5.66726303e-05f,
  -2.08584175e-01f, -1.31056234e-01f, -2.87318856e-01f, -2.19748378e-01f, 6.58490434e-02f, -1.53122455e-01f, -9.47879702e-02f, -3.13881114e-02f, -4.92628999e-02f, 1.49739280e-01f,
  2.48399135e-02f, -2.93391526e-01f, 1.13401197e-01f, -3.65811974e-01f, -3.57959807e-01f, -1.66105330e-01f, -3.31670642e-01f, -1.49646923e-01f, -9.67468396e-02f, -8.44385475e-02f,
  -1.26766235e-01f, -1.33469298e-01f, -3.45600635e-01f, 6.05813712e-02f, -9.85954478e-02f, 8.45337436e-02f, 1.90479338e-01f, 1.15923412e-01f, -8.05705264e-02f, -6.08724076e-03f,
  -1.50664166e-01f, -6.44503236e-02f, -4.67429049e-02f, 1.05161211e-02f, 3.05927615e-03f, 1.00391261e-01f, 6.15431815e-02f, -2.93928403e-02f, -1.17485318e-03f, -7.91530982e-02f,
  5.43478737e-03f, -1.60662122e-02f, -8.42109472e-02f, -3.31900492e-02f, 2.38581672e-02f, -2.38834843e-02f, -4.87770438e-02f, 4.69513685e-02f, -5.29755801e-02f, -1.46078631e-01f,
  -7.26904646e-02f, -9.96057019e-02f, 3.42200883e-02f, 1.83627848e-02f, -7.81752242e-05f, -6.18362837e-02f, 3.45786028e-02f, -1.45023605e-02f, -1.32617438e-02f, 9.07830137e-04f,
  6.38111532e-02f, 9.47977901e-02f, -6.37568021e-03f, -6.73574256e-03f, 2.10800320e-02f, -2.43374659e-03f, 3.34805511e-02f, 2.59992853e-02f, 7.49060884e-02f, 4.11309376e-02f,
  -3.75428461e-02f, -9.57879610e-03f, 1.25295306e-02f, -2.35346556e-02f, -2.08470840e-02f, -2.26612221e-02f, 2.07411610e-02f, 7.15090288e-03f, -2.89561991e-02f, -2.60146745e-02f,
  5.26048951e-02f, -6.56242855e-03f, 6.33014273e-03f, 1.90741979e-02f, 2.75780186e-02f, -4.49283086e-02f, 5.46550341e-02f, 2.92321574e-02f, 4.84743640e-02f, 4.05323468e-02f,
  7.91776329e-02f, 5.97007340e-03f, 1.98093913e-02f, -6.74567604e-03f, 6.03037793e-03f, 6.13688342e-02f, 8.45208019e-03f, -2.29630359e-02f, 4.64129969e-02f, 1.23119885e-02f,
  6.90745339e-02f, 2.13836003e-02f, 5.70801869e-02f, 1.97035819e-02f, 4.80970964e-02f, 6.07525138e-03f, 1.87552813e-02f, 1.31106660e-01f, 2.23517027e-02f, -3.40987369e-02f,
  5.85737750e-02f, 2.28587594e-02f, 8.94682631e-02f, 4.88806888e-02f, -4.74284030e-02f, 5.29091842e-02f, 4.80481759e-02f, -1.16028404e-02f, 3.91539112e-02f, 5.96858514e-03f,
  1.30543560e-01f, -7.70446584e-02f, 2.75896881e-02f, 1.94125339e-01f, -1.73684154e-02f, -2.29835749e-01f, -2.11257309e-01f, 1.44759253e-01f, -1.46105960e-01f, -2.72063259e-02f,
  -4.06801794e-03f, -1.15467794e-01f, 6.82711378e-02f, 4.66859378e-02f, 8.28665644e-02f, -1.17597148e-01f, 8.77655596e-02f, -1.20934233e-01f, -5.98717034e-02f, 2.06303686e-01f,
  1.17775291e-01f, 1.05667055e-01f, 1.80326700e-01f, 1.84872702e-01f, 5.71891107e-02f, 2.17177987e-01f, 1.52548254e-01f, 6.77706003e-02f, 1.97292283e-01f, -8.44601542e-03f,
  -1.14441611e-01f, -4.16334495e-02f, 1.07569015e-02f, -6.86196610e-04f, 1.07070781e-01f, 1.45911584e-02f, -4.35630046e-02f, 4.77083810e-02f, 3.32873538e-02f, 5.29857865e-03f,
  -6.66914210e-02f, 4.38805670e-02f, -4.77515757e-02f, -6.11353032e-02f, -4.14219089e-02f, -7.68565983e-02f, -5.22102900e-02f, -6.56297952e-02f, -9.26710069e-02f, 1.19625866e-01f,
  -2.25638580e-02f, -6.96520582e-02f, -2.24118754e-02f, -9.33302846e-03f, 1.12996794e-01f, 2.80676726e-02f, -9.24175698e-03f, -3.47341560e-02f, -1.38269821e-02f, 4.52455170e-02f,
  2.33026668e-02f, 3.87661234e-02f, -4.01472254e-03f, -2.38825455e-02f, -7.92645440e-02f, 1.65445618e-02f, -1.68474130e-02f, 5.24749607e-03f, -3.46204191e-02f, -3.25427875e-02f,
  5.44500500e-02f, 7.81268720e-03f, -7.22962432e-04f, 5.71294986e-02f, 7.85310045e-02f, 2.69964132e-02f, -1.15060210e-02f, -2.67042499e-02f, 6.39308542e-02f, -8.62549320e-02f,
  7.37842871e-03f, -2.98509665e-04f, 2.54420191e-02f, -7.88120031e-02f, 8.53435919e-02f, 5.81784025e-02f, 3.84131558e-02f, 6.97139977e-03f, -3.66284400e-02f, -2.92252768e-02f,
  6.24722689e-02f, 2.49860302e-01f, -1.54422559e-02f, -1.08286450e-02f, -7.57566690e-02f, -6.42293915e-02f, 2.19735727e-02f, 1.13770589e-02f, 8.04372802e-02f, 4.43752632e-02f,
  8.15816969e-02f, -6.66831210e-02f, 4.49065045e-02f, -2.51621492e-02f, -9.90522653e-03f, 8.14799219e-02f, 7.34207034e-02f, 9.32277832e-03f, 4.34552729e-02f, 1.14471681e-01f,
  2.83855889e-02f, -1.27862230e-01f, 5.39895408e-02f, -4.00519148e-02f, 1.61591079e-02f, -6.08657487e-02f, -9.20937955e-02f, 7.53922984e-02f, -3.00940275e-02f, 8.70316697e-04f,
  2.35488355e-01f, -7.02266619e-02f, 6.30716383e-02f, -2.28060149e-02f, -1.85526878e-01f, 1.07605338e-01f, 2.88787752e-01f, -1.90793619e-01f, -2.29076669e-01f, 6.16762564e-02f,
  1.15535751e-01f, 1.75535858e-01f, 1.38084590e-01f, 1.13386065e-01f, 1.56116217e-01f, 6.49613217e-02f, -1.74309667e-02f, 9.21535045e-02f, -1.28824860e-01f, 9.84359533e-03f,
  -5.72329238e-02f, 2.88757570e-02f, 1.25956178e-01f, -1.61469847e-01f, 1.22000590e-01f, -7.94835016e-02f, -4.45401967e-02f, 1.84924141e-01f, -5.26862592e-03f, 8.59586969e-02f,
  5.31812310e-02f, -2.18835212e-02f, 4.05417159e-02f, 2.85068601e-02f, 4.27098153e-03f, 6.29702434e-02f, 7.37453997e-02f, 1.77989870e-01f, 3.86173241e-02f, 2.13795062e-02f,
  4.32857722e-02f, -2.88098976e-02f, -1.36280786e-02f, -8.91652051e-03f, -9.41442922e-02f, -5.84910996e-02f, -9.19638723e-02f, 1.62075786e-03f, -1.39785288e-02f, 2.89663747e-02f,
  4.32817079e-02f, 4.66876617e-03f, 1.81216449e-02f, 1.10571766e-02f, -1.66211966e-02f, -5.82414633e-03f, 3.35120894e-02f, 2.15045344e-02f, -5.78781031e-02f, -7.63552710e-02f,
  -6.47349358e-02f, -1.50041794e-02f, -3.02437749e-02f, 1.72831099e-02f, 3.14145349e-02f, 3.81325977e-03f, -7.22976110e-04f, -2.15181685e-03f, 7.25408122e-02f, 7.32437968e-02f,
  -1.63554288e-02f, -3.61803994e-02f, 4.31416221e-02f, 1.76914670e-02f, -9.08874944e-02f, -4.78971042e-02f, 1.23791762e-01f, 2.60652825e-02f, 2.17771647e-03f, 3.51759382e-02f,
  3.32857540e-04f, 1.78150460e-02f, -1.16939675e-02f, -3.06767237e-04f, 9.83954687e-03f, 4.20805253e-02f, -1.59054715e-02f, -4.91042330e-04f, 3.92659344e-02f, 1.22600302e-01f,
  -7.93297887e-02f, -5.52367941e-02f, -6.33470155e-03f, -1.08529763e-04f, 3.16043422e-02f, -1.49453999e-02f, -6.26913458e-03f, -1.15377484e-02f, -2.89955717e-02f, 1.71259958e-02f,
  -4.05825712e-02f, -6.81977300e-03f, -2.05453169e-02f, 3.71070355e-02f, 2.65098102e-02f, -4.35500443e-02f, 3.42244692e-02f, 9.14448779e-03f, 4.29738015e-02f, -3.21302451e-02f,
  1.03280291e-01f, 5.40153906e-02f, 3.92714590e-02f, -4.92373891e-02f, -2.06201542e-02f, 1.34666666e-01f, -5.54058701e-03f, -5.32822451e-03f, -8.81890878e-02f, 2.84476206e-02f,
  -2.86781371e-01f, -4.46581095e-02f, -1.73671424e-01f, 4.43313085e-02f, -2.27293491e-01f, 7.48282373e-02f, 1.34769261e-01f, -1.18481115e-01f, -1.22373506e-01f, 2.45062709e-01f,
  1.05248675e-01f, -1.79274425e-01f, 1.66817695e-01f, 1.88528836e-01f, -2.20929444e-01f, 1.60274401e-01f, 6.97407052e-02f, 8.82686451e-02f, -8.47893581e-02f, 5.25235832e-02f,
  -1.39842257e-01f, 1.24354698e-01f, -2.30155550e-02f, 3.60271782e-02f, -6.00394495e-02f, -5.26416115e-02f, 2.70053409e-02f, -9.58112478e-02f, -1.76427625e-02f, -1.20257929e-01f,
  3.58748622e-02f, 7.43933320e-02f, 3.42315547e-02f, 7.27558555e-03f, -8.11715145e-03f, 1.93260517e-02f, 2.58398559e-02f, -2.52679759e-03f, -3.62313353e-02f, -8.04523975e-02f,
  2.42954493e-02f, -1.78040732e-02f, 9.10752788e-02f, -2.98215020e-02f, -9.60640684e-02f, -4.85198088e-02f, 4.99493023e-03f, -6.35458156e-02f, -7.44021265e-04f, 2.04459839e-02f,
  -8.89341231e-04f, -1.42516084e-02f, -1.62485447e-02f, 7.00226948e-02f, -7.33376518e-02f, 4.01143916e-02f, 2.43479349e-02f, -2.91967839e-02f, -6.67316392e-02f, -6.01215139e-02f,
  1.00870878e-02f, 8.31270008e-04f, 8.42668638e-02f, -1.97038110e-02f, -2.12209672e-02f, -2.29854994e-02f, 1.39526334e-02f, 1.02905631e-02f, -5.57318144e-02f, 8.86851922e-02f,
  -9.15181451e-03f, -3.59401852e-02f, -9.43736732e-03f, 3.30880918e-02f, 2.34322928e-04f, 2.11559236e-02f, 3.03841028e-02f, -7.07532093e-02f, -2.91083138e-02f, -2.48198714e-02f,
  3.15757953e-02f, 2.53492990e-03f, 3.55027281e-02f, 5.46370074e-02f, 3.39899049e-03f, -5.95919229e-02f, -4.93398160e-02f, 3.13812541e-03f, 7.79115856e-02f, -6.26219213e-02f,
  7.75498673e-02f, -6.66266754e-02f, 1.22260086e-01f, 3.90973873e-02f, -3.72129343e-02f, 3.91235612e-02f, 4.96785454e-02f, -6.06468646e-03f, -2.11285260e-02f, -3.01515474e-03f,
  -2.33345572e-02f, 1.32942759e-02f, 2.74693165e-02f, 2.71812715e-02f, -7.54442215e-02f, 3.39102261e-02f, 9.89120081e-02f, -8.98142755e-02f, -4.10777405e-02f, -2.85928976e-02f,
  4.34519425e-02f, 2.59417705e-02f, 1.53802149e-02f, 3.29174921e-02f, 2.03166213e-02f, 6.51466921e-02f, -3.49464789e-02f, -1.03494218e-02f, -2.72241980e-02f, 2.61067189e-02f,
  1.08639039e-02f, 3.56287122e-01f, 2.46938393e-01f, 1.28258049e-01f, -1.06924981e-01f, -3.79947126e-01f, -1.35752007e-01f, -7.76429055e-03f, -8.95295851e-03f, 1.26924723e-01f,
  -1.02700047e-01f, 3.54111254e-01f, -3.54705788e-02f, 5.90193085e-02f, -3.07608247e-01f, -2.29048610e-01f, -4.24874127e-02f, -4.44303937e-02f, -5.78004830e-02f, 1.03749864e-01f,
  -7.48386830e-02f, -5.25809191e-02f, 2.96905637e-02f, 3.50441262e-02f, 1.38148159e-01f, 2.08664760e-01f, 3.77353095e-02f, -4.96463012e-03f, 1.97297603e-01f, -1.03993759e-01f,
  -3.57472487e-02f, 2.57096458e-02f, 1.07384034e-01f, -4.28914912e-02f, -5.76659031e-02f, 1.11757834e-02f, 6.47535222e-03f, -7.73915183e-03f, 2.59096194e-02f, -1.62425882e-03f,
  5.85911907e-02f, 1.38827264e-02f, 8.25984105e-02f, -3.49013731e-02f, -1.00713419e-02f, 7.16441274e-02f, 5.91120161e-02f, 5.85630499e-02f, 4.32422906e-02f, 3.73868532e-02f,
  8.52376521e-02f, 3.94536816e-02f, -1.00068459e-02f, -2.63531283e-02f, 3.88429314e-02f, -1.80211607e-02f, -3.33419517e-02f, 1.70148630e-02f, 8.36577266e-03f, -4.07764735e-03f,
  -3.97050902e-02f, -4.99443710e-02f, -3.83897647e-02f, 8.44938606e-02f, -5.47785405e-03f, -5.04564345e-02f, -1.49065992e-02f, 4.25644740e-02f, -2.67395359e-02f, -1.37720378e-02f,
  -4.24352065e-02f, 4.65682931e-02f, -4.24395278e-02f, -3.88270579e-02f, 7.51749650e-02f, 2.61010136e-02f, -2.41676252e-02f, 2.61749886e-02f, -3.80410217e-02f, 2.41553839e-02f,
  6.48838282e-03f, -4.78684083e-02f, 4.41070609e-02f, -1.89113189e-02f, -7.19646737e-02f, 2.15921402e-02f, 4.45182845e-02f, -1.61588934e-04f, 1.71549711e-02f, 7.85826892e-03f,
  -3.35544012e-02f, 1.19067162e-01f, 7.29289427e-02f, -2.94521507e-02f, -2.91945115e-02f, -2.07978599e-02f, -2.60228477e-02f, -2.28507891e-02f, 5.35533056e-02f, -6.21379614e-02f,
  3.47806178e-02f, 1.10696349e-02f, -3.46814911e-03f, -4.67503406e-02f, -1.29070096e-02f, -1.05704470e-02f, 9.07792896e-02f, -2.14942941e-03f, -8.96619353e-03f, 1.66848265e-02f,
  9.99336615e-02f, 2.57076975e-02f, -2.40579657e-02f, -4.28381050e-03f, -5.16635291e-02f, -2.02370547e-02f, 4.18920256e-02f, 5.42361327e-02f, -1.62608679e-02f, -2.57009249e-02f,
  1.48215041e-01f, -1.67784572e-01f, -9.48826596e-02f, 7.22712427e-02f, 1.10747784e-01f, -7.05151334e-02f, -9.53940488e-03f, 1.39200121e-01f, -6.39695749e-02f, -1.13578320e-01f,
  9.16545105e-04f, -1.24624588e-01f, -2.26717949e-01f, 1.36388540e-01f, 2.17995852e-01f, -1.70524612e-01f, 9.79459062e-02f, -1.05787292e-02f, 3.28998617e-03f, -5.34663759e-02f,
  9.84096676e-02f, 1.85036704e-01f, 1.06266730e-01f, 2.30888844e-01f, 5.64500093e-02f, 1.86990649e-01f, 1.16977461e-01f, 4.92152162e-02f, 1.89344615e-01f, -2.32875650e-03f,
  3.56015302e-02f, -3.59239499e-03f, 3.39374095e-02f, -6.51281774e-02f, -4.52863201e-02f, 8.96831527e-02f, -4.36524786e-02f, 5.69912419e-02f, 6.81578591e-02f, 4.63745184e-02f,
  -1.59758521e-04f, 6.62662312e-02f, 7.52101615e-02f, 6.59995601e-02f, 6.08548597e-02f, 2.21803188e-02f, 5.51348142e-02f, -6.48608506e-02f, -2.33560652e-02f, -8.42860863e-02f,
  -6.85618445e-02f, 3.51370871e-02f, -5.81588931e-02f, 2.23198868e-02f, -3.02503929e-02f, 5.24019487e-02f, 2.88990065e-02f, -2.65607126e-02f, -4.38674539e-02f, -5.20187942e-03f,
  4.63982932e-02f, -8.64952132e-02f, 1.61810871e-02f, 5.74102961e-02f, -7.88084883e-03f, 5.23287281e-02f, 3.88132483e-02f, -4.29498740e-02f, -3.40317860e-02f, -7.17401803e-02f,
  9.80980415e-03f, 2.54708342e-02f, -9.62804109e-02f, -2.22899150e-02f, -6.01873454e-03f, -5.98024949e-02f, 4.87759784e-02f, 3.72889228e-02f, -7.52616078e-02f, 9.07905865e-03f,
  -2.21799184e-02f, -1.57409552e-02f, 1.84942987e-02f, 9.47864130e-02f, 3.62696499e-03f, 2.74189431e-02f, -6.30619600e-02f, -1.08550452e-02f, 7.30651617e-02f, 5.23175411e-02f,
  -5.23600467e-02f, -1.23286925e-01f, 2.66251564e-02f, 1.84499677e-02f, -4.61047664e-02f, -4.00847420e-02f, -3.14947553e-02f, 5.68043161e-03f, -4.73617390e-02f, -2.81467997e-02f,
  5.75894900e-02f, 9.65117738e-02f, 1.49218561e-02f, 1.32997315e-02f, 3.72539437e-03f, 3.73263955e-02f, -5.38431779e-02f, 2.40366738e-02f, 3.61449718e-02f, 1.69817137e-03f,
  -4.73268442e-02f, 1.10819474e-01f, 1.82082783e-02f, 7.69904181e-02f, 2.48076045e-03f, -1.72909796e-02f, 2.75399964e-02f, -2.23823003e-02f, 1.22348042e-02f, -7.96385631e-02f,
  2.49693960e-01f, 9.46785882e-02f, -2.12281078e-01f, -5.52684590e-02f, -2.37781089e-02f, 8.32987055e-02f, -2.32391525e-02f, 6.69424161e-02f, -5.29342405e-02f, 1.33919582e-01f,
  1.55607820e-01f, 1.78995043e-01f, 3.41288336e-02f, 2.46095449e-01f, 1.62434280e-01f, 1.11026466e-01f, 1.00591108e-01f, 3.14755030e-02f, 4.73467857e-02f, 1.25992671e-01f,
  1.14655189e-01f, 2.21885622e-01f, -4.50689569e-02f, 3.61174494e-02f, 1.78500354e-01f, -7.54830018e-02f, 1.14280395e-01f, -1.41404450e-01f, 9.96393636e-02f, 4.61607650e-02f,
  8.24604481e-02f, 9.13988575e-02f, -4.39747237e-02f, -3.36062759e-02f, -6.50997385e-02f, 5.11207208e-02f, -1.10127673e-01f, -7.39437640e-02f, -8.54799673e-02f, 7.87954405e-03f,
  5.30132763e-02f, 1.15189804e-02f, -9.11873020e-03f, 8.35362915e-03f, 6.82285801e-02f, -3.27392183e-02f, 7.01758172e-03f, -4.96666431e-02f, -3.90913859e-02f, 1.27111122e-01f,
  -3.72232385e-02f, 2.74459794e-02f, -8.88685957e-02f, -5.71514033e-02f, -8.61311480e-02f, 2.44820374e-03f, 4.42139171e-02f, -6.87742606e-02f, 2.30106078e-02f, 3.65355499e-02f,
  7.71882311e-02f, 8.93849507e-03f, 7.04111308e-02f, 5.07460833e-02f, 3.15091722e-02f, -4.64135483e-02f, -4.00920883e-02f, -8.20776746e-02f, -7.03917164e-03f, 7.04131871e-02f,
  -2.30305046e-02f, -4.43798229e-02f, 1.18491694e-03f, 1.56717300e-02f, 3.22567001e-02f, -3.59823704e-02f, 4.24542241e-02f, 1.19348234e-02f, 1.52341351e-02f, -9.35404971e-02f,
  -2.50227787e-02f, 5.80112673e-02f, 5.31485230e-02f, -4.49950472e-02f, -1.67516191e-02f, -1.56366359e-02f, 3.43351178e-02f, 4.22602519e-02f, -9.37874615e-02f, -2.65915729e-02f,
  7.87196383e-02f, 1.74515605e-01f, -4.69975807e-02f, 3.20615619e-02f, -9.16328952e-02f, 1.96001176e-02f, -6.78558648e-02f, 6.67577833e-02f, 6.28927052e-02f, -4.87814583e-02f,
  4.72300015e-02f, -4.86764126e-02f, 5.87256365e-02f, 3.13363783e-02f, -7.00059533e-02f, 9.91500020e-02f, 3.70119326e-02f, -5.50382286e-02f, -3.71313468e-02f, 2.58556008e-02f,
  3.16093415e-02f, 1.38075855e-02f, -6.94067255e-02f, -4.02886048e-02f, 1.24003729e-02f, -3.71076874e-02f, -1.26621453e-02f, -5.09180911e-02f, 5.30549325e-02f, 1.23599954e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 14)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 14;
const float L0_fan_Bp_bar_data[] = {
  1.28944337e-01f, 1.39238406e-02f, 1.97510168e-01f, 1.82994127e-01f, 1.52934283e-01f, 2.22721677e-02f, 4.96761501e-02f, 1.49309531e-01f, 7.14351237e-02f, 1.65858582e-01f,
  7.70909935e-02f, 1.20943204e-01f, 5.44227436e-02f, 3.93103510e-02f
};

// L1_fan_Wp (Shape: 25 x 64)
const int L1_fan_Wp_rows = 25;
const int L1_fan_Wp_cols = 64;
const float L1_fan_Wp_data[] = {
  5.15491962e-02f, 1.15607977e-02f, 1.56290680e-02f, -1.06516033e-01f, -4.81059663e-02f, 1.44981584e-02f, 3.02638486e-02f, 3.10375262e-03f, 9.44559425e-02f, 1.07749492e-01f,
  6.46450324e-03f, 1.07745983e-01f, 8.47336557e-03f, -1.37700304e-01f, -3.48625220e-02f, -6.09555244e-02f, -3.50716487e-02f, -1.87335331e-02f, 2.04478856e-02f, 7.66691417e-02f,
  -1.23425154e-02f, -4.79606166e-02f, -1.48774898e-02f, 1.65036604e-01f, -6.26781629e-03f, -2.12917626e-01f, -2.04514921e-01f, -1.23873748e-01f, -1.81863710e-01f, 1.26346648e-01f,
  8.97636935e-02f, -7.14963749e-02f, -7.94410780e-02f, -1.26537621e-01f, 8.27513710e-02f, -1.36557758e-01f, -2.95462795e-02f, -1.43673420e-01f, -2.28854325e-02f, 3.80720347e-02f,
  -7.73841962e-02f, -5.91433607e-02f, -1.45036906e-01f, 1.17585793e-01f, 1.12589963e-01f, -1.13807956e-03f, -7.77186081e-02f, 2.46818573e-03f, -1.87757872e-02f, 3.04329302e-02f,
  4.96597067e-02f, -1.01064652e-01f, 2.28808120e-01f, -6.43436909e-02f, 4.83079888e-02f, -3.66677083e-02f, 2.48329550e-01f, 1.73263282e-01f, 1.09357156e-01f, -8.86024907e-02f,
  1.87908828e-01f, 5.23154531e-03f, -7.72867203e-02f, -9.71233547e-02f, -4.42765355e-02f, 5.57735935e-02f, -6.46222034e-05f, -2.84265000e-02f, 6.76546171e-02f, 3.20648625e-02f,
  7.83700962e-03f, -4.67064157e-02f, -7.29769692e-02f, -5.55310957e-02f, -3.22684534e-02f, -8.34381729e-02f, 1.03565767e-01f, 7.07362294e-02f, -6.50316253e-02f, 1.12952674e-02f,
  -5.20188129e-03f, -1.27924178e-02f, -6.72408193e-02f, -1.51233878e-02f, 1.11984812e-01f, 3.48966308e-02f, 1.54368756e-02f, -8.05887207e-02f, 1.44184768e-01f, 1.54477969e-01f,
  -2.66530309e-02f, 6.31135404e-02f, 2.07341194e-01f, 1.29283100e-01f, -9.20865238e-02f, 1.88888639e-01f, -9.41330716e-02f, 1.09279297e-01f, -7.15470612e-02f, 1.96254656e-01f,
  -3.85807268e-02f, 1.96092665e-01f, 4.08370011e-02f, 1.15883671e-01f, 5.38979284e-02f, 3.19789760e-02f, 7.41922355e-04f, -8.52800086e-02f, 2.54838206e-02f, -2.04124544e-02f,
  -1.02692693e-01f, -8.94426182e-02f, 7.08128437e-02f, 4.99535464e-02f, -1.95041560e-02f, 1.04458950e-01f, 3.72384675e-02f, 1.48173332e-01f, -1.51271643e-02f, 1.03329219e-01f,
  -1.72435477e-01f, -1.08003737e-02f, -6.74856901e-02f, 4.76155616e-02f, -1.62195504e-01f, -7.46127814e-02f, 1.28563270e-01f, -1.21637933e-01f, -5.82332276e-02f, 3.02028507e-02f,
  -1.41359214e-02f, -9.74656865e-02f, 6.05005994e-02f, -7.87668303e-02f, -2.54870635e-02f, 4.60988656e-02f, -2.78718472e-02f, -1.42227024e-01f, -9.76907462e-02f, -9.51543078e-02f,
  6.24150373e-02f, -1.20420791e-01f, -1.07298501e-01f, 1.83575589e-03f, 1.37265828e-02f, -6.19791411e-02f, -3.29639316e-02f, -1.30030870e-01f, 6.68225661e-02f, 1.95662808e-02f,
  -9.31759849e-02f, 5.32498176e-04f, -1.30674064e-01f, 1.00965261e-01f, -6.92794919e-02f, 1.36790186e-01f, -2.42205188e-02f, 1.06348343e-01f, 6.75607547e-02f, 5.54525144e-02f,
  -9.05474722e-02f, 5.44506386e-02f, -1.01371549e-01f, 1.15153819e-01f, 8.22108239e-02f, -2.17888560e-02f, 3.51881646e-02f, 1.06562920e-01f, 6.41746297e-02f, -9.03759524e-03f,
  -2.71326527e-02f, -1.61659587e-02f, 5.22716269e-02f, -5.34111541e-03f, -8.73386953e-03f, 2.60572471e-02f, 2.95243692e-02f, 2.97717787e-02f, -6.76073432e-02f, 2.39248708e-01f,
  -6.66300356e-02f, 4.78315689e-02f, 9.18544531e-02f, 1.75244018e-01f, 1.14755549e-01f, -1.13523886e-01f, 3.84885371e-02f, 4.01425734e-02f, -1.00701779e-01f, -1.56556085e-01f,
  9.68438163e-02f, 8.87250751e-02f, -5.13905436e-02f, 7.32042789e-02f, 5.65432161e-02f, 1.51258530e-02f, 9.01654735e-02f, -8.36157203e-02f, -2.81731728e-02f, 1.71753690e-01f,
  2.15571863e-03f, -1.00368507e-01f, -1.25288188e-01f, -1.08492590e-01f, -1.61335822e-02f, -1.18277214e-01f, -1.04784742e-01f, 1.10782266e-01f, 3.10504367e-03f, -1.15883984e-01f,
  -6.15043603e-02f, -9.57890674e-02f, 9.47965458e-02f, 4.52674888e-02f, -3.39426138e-02f, 5.65834306e-02f, -1.56611636e-01f, -2.74050143e-02f, -1.32005930e-01f, 3.57886404e-02f,
  -1.05408072e-01f, 1.18286267e-01f, 4.73209955e-02f, -3.64132263e-02f, -8.66972730e-02f, 1.02444708e-01f, -8.88396055e-02f, -1.82869192e-02f, 1.42438561e-01f, -1.92643583e-01f,
  -1.33668736e-01f, 7.07285181e-02f, 2.99476199e-02f, -5.05502746e-02f, -1.89283583e-02f, -1.32315531e-01f, 1.11432977e-01f, 2.12284755e-02f, 4.06732634e-02f, 7.23185483e-03f,
  -2.78914869e-02f, -1.12580858e-01f, 6.73059095e-03f, 2.71891326e-01f, -1.74222752e-01f, -7.52070993e-02f, 2.22572267e-01f, 1.40310124e-01f, 9.91097242e-02f, -2.12464973e-01f,
  -3.94743420e-02f, 8.03836957e-02f, 1.08562082e-01f, -2.18376115e-01f, 2.34353337e-02f, 4.42795679e-02f, -4.03305925e-02f, 1.97882336e-02f, -1.30812645e-01f, -2.76412889e-02f,
  -2.58816164e-02f, 8.34828243e-02f, 9.88707393e-02f, -1.70508027e-01f, -2.79482603e-02f, -3.71070183e-03f, 9.85031947e-02f, -8.80668033e-03f, 2.48910263e-02f, 3.72249447e-02f,
  4.81761731e-02f, -2.47096688e-01f, -1.57264303e-02f, -2.27516033e-02f, -1.86326522e-02f, 1.52616762e-02f, -3.79849933e-02f, -1.78349800e-02f, -1.38128906e-01f, -1.86486356e-02f,
  2.82713231e-02f, 5.20280637e-02f, 2.58480606e-04f, 4.15437110e-02f, -4.81090769e-02f, 1.73189163e-01f, 9.46572274e-02f, 1.46806762e-01f, -4.70274277e-02f, -8.85163024e-02f,
  1.25861680e-02f, 2.63934117e-02f, -1.10031821e-01f, 1.96223587e-01f, 2.11751893e-01f, 5.50370896e-03f, -8.36572871e-02f, -2.38711410e-03f, 1.16304518e-03f, 1.45118520e-01f,
  -3.67373340e-02f, -4.94081974e-02f, -7.83357173e-02f, -3.64790671e-02f, 1.15961030e-01f, 1.22912765e-01f, 5.97932888e-03f, -7.15484750e-03f, 2.90006667e-01f, 7.56852403e-02f,
  -1.06897607e-01f, 1.85104907e-01f, -5.24153113e-02f, 2.59396285e-01f, 1.43289566e-01f, -2.09865108e-01f, -1.21636100e-01f, 8.46052244e-02f, 1.14072926e-01f, -1.00887932e-01f,
  7.19249621e-02f, 6.47358373e-02f, -2.04952396e-02f, -5.49711287e-02f, 1.75547600e-01f, 4.85029928e-02f, -7.40055228e-03f, 2.09403038e-02f, 8.27703625e-02f, -1.09867625e-01f,
  3.14257033e-02f, -1.35140240e-01f, -2.88252216e-02f, -6.15369305e-02f, -1.36967441e-02f, -1.15685593e-02f, -5.34191951e-02f, -1.17094507e-02f, 1.39974132e-01f, -1.36116996e-01f,
  2.15891317e-01f, 2.14738008e-02f, 5.69039583e-02f, 1.88391209e-02f, -1.76770866e-01f, 4.37496565e-02f, -1.75111651e-01f, 5.35693057e-02f, -1.17463358e-01f, 7.87891186e-05f,
  1.07054003e-01f, -3.02259736e-02f, 7.56756663e-02f, 1.14742935e-01f, 1.11407079e-01f, 1.01782568e-01f, 1.03099905e-01f, -8.19136500e-02f, 4.00652084e-03f, 1.22610554e-01f,
  5.69084883e-02f, 1.01332285e-01f, 1.79360315e-01f, 3.08134202e-02f, 6.34107143e-02f, 1.17933436e-03f, 1.07471861e-01f, -6.23208731e-02f, 3.11175976e-02f, 2.75397301e-02f,
  1.18947826e-01f, 1.63766608e-01f, -5.03038988e-02f, -1.50702253e-01f, 1.80826560e-01f, 2.17235684e-01f, 1.92369863e-01f, 1.60675168e-01f, 1.11937001e-01f, -2.74234321e-02f,
  1.15486465e-01f, -1.06095232e-01f, 6.14728685e-03f, 1.85159082e-03f, 2.58320812e-02f, -6.19100519e-02f, 4.65267040e-02f, 7.04462379e-02f, -1.37111738e-01f, -4.44953144e-02f,
  6.92413189e-03f, -3.82963195e-02f, -1.49757247e-02f, 1.76922113e-01f, 1.11953132e-01f, 1.78011045e-01f, -3.88416760e-02f, 1.30604461e-01f, 9.23356693e-03f, -4.51948345e-02f,
  -5.37134334e-02f, 1.04567170e-01f, -5.22952117e-02f, 1.39421627e-01f, -2.81877339e-01f, 8.96946713e-03f, -6.84281811e-02f, 5.72082624e-02f, 2.66861647e-01f, -1.42393455e-01f,
  1.19417556e-01f, -1.38958722e-01f, 8.75992998e-02f, -2.48510633e-02f, -2.54366286e-02f, 5.46944253e-02f, 3.23081985e-02f, -1.03607699e-01f, 6.21933900e-02f, -1.20605893e-01f,
  -1.62089065e-01f, 1.66267052e-03f, 3.32872458e-02f, -1.85898572e-01f, -9.86813605e-02f, -1.01759121e-01f, -1.27064034e-01f, 6.85235113e-02f, -1.19688706e-02f, 2.94527225e-02f,
  -3.49451303e-02f, 2.89122164e-02f, 2.15109475e-02f, 1.31513607e-02f, -8.75935033e-02f, -2.69177675e-01f, 1.35822594e-01f, 4.53386083e-02f, -1.09156094e-01f, -1.89564601e-01f,
  -1.72978401e-01f, 6.93341047e-02f, -1.14998356e-01f, -1.34676561e-01f, 8.02477524e-02f, 6.43913373e-02f, -5.01086228e-02f, -2.03082293e-01f, 1.63797021e-01f, -3.84215005e-02f,
  2.15592030e-02f, 2.61815568e-03f, 6.71895444e-02f, 3.48760337e-02f, 8.23626388e-03f, 1.07567549e-01f, 1.94137339e-02f, -1.24262590e-02f, -7.03261495e-02f, 3.50133458e-04f,
  5.06882183e-03f, -1.23446360e-02f, -1.40176918e-02f, -1.37888983e-01f, -8.61344337e-02f, -4.54950966e-02f, -2.59575676e-02f, 5.26654795e-02f, -2.44829878e-01f, -7.84576461e-02f,
  9.39185440e-04f, 7.25404471e-02f, -1.59803987e-01f, 1.05654314e-01f, 7.45566338e-02f, 1.45816267e-01f, -1.55726478e-01f, -9.15907994e-02f, 1.67787582e-01f, -2.01641917e-01f,
  8.52788910e-02f, -1.29377231e-01f, 7.06931651e-02f, -1.86593801e-01f, 2.08214242e-02f, -1.38819873e-01f, -4.52329330e-02f, -7.36650899e-02f, 3.49864364e-02f, 3.29704285e-02f,
  -9.89899710e-02f, 1.09419569e-01f, 6.59091175e-02f, 2.53326334e-02f, 1.45623967e-01f, 1.38800547e-01f, 4.93804775e-02f, -3.33218351e-02f, 1.44467548e-01f, 9.88407880e-02f,
  2.11238220e-01f, -1.65026300e-02f, -7.80643197e-04f, -5.84125668e-02f, 1.98298305e-01f, 1.44979343e-01f, 6.87263906e-02f, -9.11407322e-02f, 1.78944871e-01f, -6.80939481e-02f,
  -1.48430437e-01f, 2.34153315e-01f, 1.25908017e-01f, -9.13893506e-02f, 9.74811763e-02f, -5.32916188e-02f, 9.99799371e-03f, 2.55446322e-02f, 2.63041421e-03f, 2.92155724e-02f,
  1.53583558e-02f, 6.07131645e-02f, -5.14115207e-02f, -1.92606431e-02f, -4.37076986e-02f, -1.01576969e-01f, -6.78761229e-02f, 4.31758016e-02f, -5.10198325e-02f, -2.38212589e-02f,
  2.71050483e-02f, -4.23475057e-02f, -1.51691958e-01f, 1.58066377e-02f, 4.81254328e-03f, -5.35197258e-02f, -2.66392559e-01f, -1.23258578e-02f, 1.96258858e-01f, 1.87735874e-02f,
  -1.11680388e-01f, -2.74676234e-01f, -3.48723680e-02f, -2.55421609e-01f, 8.70483592e-02f, 1.37590421e-02f, 1.02347322e-01f, -1.19208813e-01f, 4.69695888e-02f, -1.46330103e-01f,
  -1.12703487e-01f, -4.78983782e-02f, 5.92508502e-02f, 1.09350219e-01f, 1.90643929e-02f, -1.29125463e-02f, -6.58864230e-02f, 4.87832129e-02f, 1.58897951e-01f, 1.77029334e-02f,
  -4.56903540e-02f, -1.11711651e-01f, 9.99267995e-02f, -8.22375566e-02f, -1.99183196e-01f, -9.12751481e-02f, -2.77995616e-02f, -1.70697004e-01f, 1.26776353e-01f, -9.39584374e-02f,
  6.04329258e-02f, 4.42152843e-02f, 1.68347925e-01f, 9.20239650e-03f, -1.00371011e-01f, 1.23717517e-01f, 1.95836369e-02f, -3.32095884e-02f, 5.53611927e-02f, 2.45654471e-02f,
  2.04147130e-01f, -1.41221909e-02f, 8.98838416e-02f, 5.61124198e-02f, 2.46936120e-02f, -1.27815083e-01f, 5.33849634e-02f, -9.81088355e-02f, 5.45304865e-02f, -3.28310728e-02f,
  -7.92391747e-02f, -7.68480152e-02f, 3.49891023e-03f, 6.28495449e-03f, 1.25049368e-01f, -5.68656921e-02f, 1.35504872e-01f, 8.47517252e-02f, -1.08373705e-02f, 4.71048355e-02f,
  -1.94753438e-01f, 1.24486960e-01f, 8.78439378e-03f, 1.11711256e-01f, -1.16450511e-01f, -5.24915531e-02f, 1.29200250e-01f, -6.75638840e-02f, 1.01743579e-01f, 6.91029206e-02f,
  9.20294374e-02f, 9.30190608e-02f, 5.92536069e-02f, -4.22522053e-02f, 6.36021346e-02f, 7.51229450e-02f, 4.88846973e-02f, 1.13428958e-01f, 9.29473639e-02f, -5.01816487e-03f,
  2.19728658e-03f, -1.26157245e-02f, 1.46522522e-01f, -9.59834680e-02f, 1.03205442e-01f, -2.59078816e-02f, 9.88332927e-02f, 9.41192582e-02f, -3.53455693e-02f, -3.99900507e-03f,
  1.47706404e-01f, 2.14461848e-01f, 1.27351359e-01f, 1.85429499e-01f, 1.46302804e-01f, -9.92819760e-03f, 5.15781790e-02f, -4.81439531e-02f, 1.45844981e-01f, 1.24612637e-01f,
  9.71834362e-02f, -3.82397696e-02f, 5.38447015e-02f, 3.92302163e-02f, 1.92675263e-01f, 8.18908140e-02f, 1.16587104e-02f, -1.95238531e-01f, 4.80479524e-02f, -1.69679239e-01f,
  7.83005506e-02f, -8.73189270e-02f, 1.10611795e-02f, 5.91635704e-02f, 1.58233754e-02f, -5.09781251e-03f, -8.74446034e-02f, -9.05880854e-02f, 1.34347290e-01f, -6.50255829e-02f,
  7.55584314e-02f, 3.90447415e-02f, -6.83597848e-02f, -1.91020444e-01f, -1.10793516e-01f, 3.01505744e-01f, 1.35093793e-01f, 2.36125723e-01f, 1.87167197e-01f, -1.34103253e-01f,
  -5.68567067e-02f, 3.59490141e-02f, 9.53592137e-02f, 6.94841519e-02f, 5.73242679e-02f, 2.15018645e-01f, -1.17175104e-02f, 2.39686117e-01f, 2.18750641e-01f, 1.23830270e-02f,
  1.46887898e-01f, 1.67513609e-01f, 2.15740487e-01f, 1.64730810e-02f, -1.29822493e-01f, 5.93242534e-02f, 1.75702393e-01f, -1.08947389e-01f, 1.43267319e-01f, 1.63587034e-01f,
  5.64960353e-02f, 6.80520013e-02f, -1.37403950e-01f, 1.36139423e-01f, -4.77118045e-02f, 1.58753559e-01f, -9.78271365e-02f, 1.52605489e-01f, 2.22460479e-01f, -5.51555604e-02f,
  -1.34600535e-01f, 5.06653078e-02f, 1.56607226e-01f, 1.08111337e-01f, -5.94037324e-02f, 6.08825572e-02f, 5.11021800e-02f, -5.12307547e-02f, -4.46653403e-02f, -9.79596749e-02f,
  -4.58600633e-02f, 1.71803877e-01f, 3.44966091e-02f, 1.57661792e-02f, -1.22795984e-01f, -1.35173071e-02f, -4.91336137e-02f, -1.38039626e-02f, 1.61630549e-02f, -2.49239672e-02f,
  1.25095740e-01f, 3.14790383e-02f, -1.38944775e-01f, -5.97250648e-02f, 1.55307651e-02f, 5.81161901e-02f, -7.68854767e-02f, 1.95411146e-01f, -6.34665117e-02f, 2.29464192e-02f,
  -1.36980563e-01f, -3.52485143e-02f, -9.78491679e-02f, 8.89284909e-02f, 8.91278312e-02f, -4.24716994e-02f, 8.11379962e-03f, -8.02512988e-02f, -1.06298536e-01f, -5.15570603e-02f,
  -2.89948694e-02f, -1.93371311e-01f, -7.91756436e-02f, 5.91513440e-02f, -9.74096134e-02f, -1.49352834e-01f, -1.89714044e-01f, -7.15056201e-03f, 1.19015031e-01f, 1.46254450e-02f,
  -4.23333198e-02f, 1.55389115e-01f, -2.68793609e-02f, -7.78989866e-02f, -1.32642701e-01f, 1.97742328e-01f, 1.30384713e-01f, -2.10643914e-02f, 1.71630368e-01f, -4.85823676e-02f,
  8.56221095e-02f, -1.08653329e-01f, -1.57776296e-01f, 9.95281413e-02f, 1.14160575e-01f, -1.44319728e-01f, -1.28547177e-01f, 6.83000535e-02f, 1.42407343e-02f, 4.36378084e-02f,
  1.05365984e-01f, -8.21493752e-03f, 6.64904639e-02f, -3.41935307e-02f, -7.51945972e-02f, 1.40754417e-01f, 2.94472128e-02f, 2.40952987e-02f, -5.45275118e-03f, -2.42826268e-02f,
  1.09163024e-01f, 1.38654383e-02f, 2.30642371e-02f, 1.27479643e-01f, 2.61743786e-03f, -3.81182767e-02f, 2.78582666e-02f, 1.85061991e-02f, 9.26883239e-03f, -1.12427473e-02f,
  6.82107806e-02f, 9.30109024e-02f, 8.18447396e-03f, -6.76511973e-02f, 5.17978966e-02f, 1.13933794e-02f, 3.87704093e-03f, 3.20109539e-02f, -5.25091700e-02f, -7.94542283e-02f,
  -8.93836692e-02f, 1.38387665e-01f, -1.99275520e-02f, -3.91773619e-02f, 8.67773667e-02f, -2.04906851e-01f, -1.93167165e-01f, 2.47811396e-02f, 5.22720441e-02f, 2.45905318e-03f,
  -7.57085606e-02f, -1.92978993e-01f, 4.59592603e-02f, 8.14798176e-02f, 1.86035372e-02f, -2.20205784e-02f, -1.89317688e-02f, -1.43724069e-01f, -4.97967228e-02f, 4.36353832e-02f,
  -1.99787006e-01f, 6.80840164e-02f, 1.10678703e-01f, -6.27650768e-02f, -1.78558696e-02f, -1.88003451e-01f, -1.08310916e-01f, 1.71020225e-01f, 1.23267733e-01f, -2.78533131e-01f,
  5.33147603e-02f, 3.48900072e-02f, -1.74757153e-01f, 1.00704566e-01f, -2.05713860e-03f, -2.08112001e-02f, 9.04351007e-03f, -1.10308461e-01f, -2.37914398e-02f, 3.88160981e-02f,
  -1.71331912e-02f, -8.77397656e-02f, -1.82468772e-01f, -4.08169813e-02f, -1.97594389e-02f, -1.07375503e-01f, -1.14278212e-01f, 1.00626245e-01f, 3.78362983e-02f, -6.87024975e-03f,
  -2.19584890e-02f, -1.17506392e-01f, 2.36382812e-01f, 6.92447694e-03f, 1.67018138e-02f, 1.05138935e-01f, -6.24700859e-02f, 1.76380612e-02f, -2.41262585e-01f, 1.37801804e-02f,
  -5.13741607e-03f, 2.20123053e-01f, 6.30297288e-02f, 9.74573791e-02f, -4.76911515e-02f, 9.10642445e-02f, -1.00019090e-01f, 8.65946338e-02f, 7.04815090e-02f, -5.10755777e-02f,
  -1.11902803e-01f, 1.45555243e-01f, -9.21379253e-02f, -1.37336433e-01f, -7.38024339e-02f, -8.28120857e-02f, 1.50371119e-01f, -1.43022984e-02f, -9.76589546e-02f, 3.36960666e-02f,
  -2.83944085e-02f, -6.57281131e-02f, -1.37295455e-01f, 2.81511277e-01f, -5.50249964e-02f, -7.74689615e-02f, 2.28213117e-01f, 1.07701160e-01f, 4.38201539e-02f, -1.56861648e-01f,
  -1.88956097e-01f, 9.73603353e-02f, 7.04891086e-02f, -2.14527830e-01f, -2.07502730e-02f, -1.51540563e-02f, -7.33820647e-02f, 6.24142364e-02f, -9.56960395e-03f, -9.16553102e-03f,
  -1.63182944e-01f, -6.13719486e-02f, -7.66454861e-02f, 1.11805335e-01f, 2.77398303e-02f, 1.01614175e-02f, -3.57725769e-02f, 3.53871472e-02f, -1.51946745e-03f, -5.58978394e-02f,
  6.07592575e-02f, 1.69387814e-02f, 7.93947354e-02f, 1.32087186e-01f, -5.00108786e-02f, 6.57188967e-02f, -1.16951630e-01f, 3.98341240e-03f, -1.99388471e-02f, 3.31300125e-02f,
  1.80945128e-01f, -2.47300059e-01f, -4.92233075e-02f, -1.95087492e-01f, -1.25982285e-01f, 3.43792140e-02f, 7.36479536e-02f, -2.00796071e-02f, -6.93583041e-02f, -1.09709539e-01f,
  -9.82099101e-02f, -2.48247623e-01f, 2.10853806e-03f, -1.75355881e-01f, -8.54972303e-02f, -7.37389782e-03f, -4.01037335e-02f, -1.63566366e-01f, -2.12212324e-01f, -6.63094828e-03f,
  6.22366294e-02f, -2.73078363e-02f, -7.66100287e-02f, 1.02921143e-01f, -6.01171479e-02f, -6.03481978e-02f, -1.20049275e-01f, -1.24386914e-01f, 5.51935062e-02f, -3.00996676e-02f,
  2.35826615e-03f, -1.33742243e-01f, 4.03120890e-02f, -4.19580899e-02f, -1.44221738e-01f, 1.05828056e-02f, 2.47059166e-01f, 5.65402173e-02f, -6.29596710e-02f, -1.49224430e-01f,
  -6.61147833e-02f, 8.50526914e-02f, -4.83256616e-02f, 1.34021509e-03f, 5.01187034e-02f, -4.22909409e-02f, -2.32484657e-02f, -9.81002823e-02f, -7.38425180e-02f, -9.41744894e-02f,
  3.61287482e-02f, -7.45072775e-03f, 6.94039166e-02f, 1.01716757e-01f, 7.04879239e-02f, 5.29935136e-02f, 6.90160394e-02f, 6.34362623e-02f, -8.29569623e-02f, -3.56317178e-04f,
  1.30768806e-01f, 4.73768450e-02f, -4.42969538e-02f, -6.29745126e-02f, 1.16744228e-01f, 1.44325882e-01f, -2.36985134e-03f, 6.19705208e-02f, 1.66844100e-01f, 5.96755669e-02f,
  -7.90728256e-02f, 9.10614505e-02f, 3.05745155e-02f, -8.22355878e-03f, -1.01175331e-01f, 1.64610252e-01f, -8.06634724e-02f, 1.97252795e-01f, 1.09880634e-01f, 6.25681356e-02f,
  9.59677994e-03f, -6.12913072e-02f, -2.91482359e-02f, 3.11346352e-02f, 3.16775367e-02f, -4.86617871e-02f, -2.62369793e-02f, 2.92478898e-03f, 4.56068404e-02f, 6.61537647e-02f,
  -1.07468709e-01f, 1.26444623e-01f, 9.50158983e-02f, 1.37749061e-01f, -4.28759819e-03f, 9.62699950e-03f, -1.44840851e-01f, 4.08006832e-02f, -8.07562917e-02f, 1.24060802e-01f,
  -4.84501570e-02f, 9.87409949e-02f, -1.94733664e-02f, -4.89473157e-02f, -7.76572991e-03f, 5.16857393e-02f, 2.22739317e-02f, -1.47941351e-01f, 6.92335069e-02f, -1.16514461e-02f,
  -4.27013077e-02f, -1.22157848e-02f, 5.49041629e-02f, -3.66250686e-02f, -6.78107217e-02f, -1.58622414e-01f, 4.61728647e-02f, -1.95757180e-01f, -6.99110404e-02f, 8.78848732e-02f,
  6.77941814e-02f, -8.85519385e-02f, 9.72639844e-02f, -1.42728522e-01f, 2.28126273e-01f, -3.94496545e-02f, -5.04885241e-02f, 5.34334704e-02f, -2.89563745e-01f, -2.20145937e-02f,
  -1.77959710e-01f, 1.51523724e-01f, -1.01132663e-02f, 5.63481897e-02f, 1.16142660e-01f, -4.74919938e-02f, -7.27350451e-03f, 1.98468164e-01f, 3.20852399e-02f, 7.35455751e-02f,
  1.67946786e-01f, -6.96720779e-02f, -5.97831234e-03f, 2.46978343e-01f, 1.41809896e-01f, 6.73359483e-02f, 9.71931890e-02f, -3.53535302e-02f, 2.33452655e-02f, -6.18141592e-02f,
  8.47886577e-02f, -4.35726345e-02f, 1.91701483e-02f, -3.03584238e-05f, 6.46560714e-02f, 3.64628285e-02f, -1.01503938e-01f, -6.29637539e-02f, 1.62810594e-01f, 1.70618147e-01f,
  2.56361365e-01f, -3.21527086e-02f, 8.69995058e-02f, 1.16411559e-01f, 8.73917863e-02f, -8.46117064e-02f, 1.05203763e-01f, 1.50965393e-01f, -9.11298096e-02f, 9.38512161e-02f,
  5.72092831e-02f, 6.24096626e-03f, 6.05150824e-03f, 4.55039889e-02f, -6.65378049e-02f, 1.24442257e-01f, 8.52214545e-02f, 9.05581713e-02f, -1.01468146e-01f, 4.79992628e-02f,
  8.63259658e-02f, -1.26262501e-01f, -6.95373416e-02f, 1.48546770e-01f, 1.93978418e-02f, 1.67169441e-02f, -5.61785437e-02f, 1.06175235e-02f, 1.33810937e-01f, 1.17855649e-02f,
  9.69161987e-02f, 1.16785444e-01f, -3.76145616e-02f, -1.74995571e-01f, -1.52621001e-01f, -7.25876912e-02f, -1.31232524e-02f, 1.26379237e-01f, -1.51047595e-02f, 7.32057020e-02f,
  -1.26310825e-01f, 1.25598297e-01f, -5.64830378e-02f, -3.28465588e-02f, 4.31368947e-02f, -1.64002717e-01f, -1.01297468e-01f, 8.78212079e-02f, 4.85261418e-02f, -4.80408482e-02f,
  -1.12935171e-01f, -9.40427482e-02f, 6.78561777e-02f, 2.16121390e-03f, -6.16988540e-02f, -9.48928297e-03f, -6.92826807e-02f, -5.42637631e-02f, 3.38186733e-02f, 5.81383966e-02f,
  -1.13981195e-01f, 2.09418402e-04f, 1.51424363e-01f, 2.00312771e-02f, 2.00082451e-01f, -2.29097381e-01f, -3.90653918e-03f, 1.33400097e-01f, 4.07638401e-02f, -4.76697199e-02f,
  3.23577807e-03f, -1.98335703e-02f, -5.27490899e-02f, 1.05348572e-01f, -9.32855830e-02f, 2.77133379e-02f, -3.40573974e-02f, -6.57901634e-03f, 8.52847248e-02f, -1.06862336e-01f,
  -1.07972359e-03f, -8.72671828e-02f, -3.74100101e-03f, -8.56150240e-02f, 6.95611387e-02f, -1.31216481e-01f, -2.21717935e-02f, -6.56487495e-02f, -3.05758696e-02f, 5.50372712e-02f,
  3.81256379e-02f, -1.47483140e-01f, 2.77417570e-01f, 7.13926256e-02f, 1.29410578e-03f, 7.90770501e-02f, 1.42279742e-02f, -1.50645539e-01f, -3.81730199e-01f, -8.21722671e-02f,
  -2.01783136e-01f, 2.61784524e-01f, 2.11850286e-01f, 1.02618180e-01f, 7.90097266e-02f, 2.02526022e-02f, 8.00427124e-02f, 6.10584626e-03f, 3.27243581e-02f, -1.97957568e-02f,
  -1.03162713e-02f, 9.66321081e-02f, -1.44561365e-01f, -3.14121619e-02f, 1.27851829e-01f, 6.84845373e-02f, 8.60192478e-02f, -1.24821350e-01f, 5.27370125e-02f, -4.42618355e-02f,
  -2.17826944e-02f, 2.22833566e-02f, 2.13894621e-02f, -1.99234225e-02f, 2.79653490e-01f, -2.64678985e-01f, 1.67672664e-01f, 3.07098001e-01f, 1.16908371e-01f, 2.74853498e-01f,
  9.51364785e-02f, -2.10431635e-01f, 6.00555316e-02f, -1.94063364e-03f, 6.33039325e-02f, -1.77494794e-01f, -8.17276984e-02f, 2.80768219e-02f, -1.91679150e-02f, 7.25612640e-02f,
  -9.09744650e-02f, -1.19032087e-02f, -4.87871058e-02f, 4.42202091e-02f, 6.93609491e-02f, 8.44209269e-02f, 5.55897178e-03f, 8.13805312e-03f, 3.03424546e-04f, 1.05898216e-01f,
  4.72481037e-03f, 1.70713976e-01f, 1.47779986e-01f, 1.36094153e-01f, -1.24571405e-01f, 9.49180350e-02f, 1.31069541e-01f, 1.62668929e-01f, 1.24112748e-01f, 7.87255466e-02f,
  1.46535799e-01f, -3.76904607e-02f, -8.91448408e-02f, -5.73497228e-02f, 2.14781255e-01f, -5.92170469e-02f, -1.37333617e-01f, 6.41026497e-02f, -5.82607985e-02f, -6.96777329e-02f,
  -1.87863141e-01f, 1.22362740e-01f, -4.86261919e-02f, 4.01284359e-02f, -2.91363597e-02f, -5.30779734e-02f, 5.36776297e-02f, -9.03650373e-02f, 3.20814364e-03f, -2.09939908e-02f,
  1.07528508e-01f, -4.87318262e-02f, -1.39993608e-01f, 3.37239727e-02f, -1.75891593e-01f, 3.84811163e-02f, -1.96534798e-01f, 1.09388262e-01f, -1.50211260e-01f, 6.13072924e-02f,
  5.73975518e-02f, -1.44184917e-01f, -3.88741381e-02f, -2.26712435e-01f, -1.47690490e-01f, 2.15967134e-01f, -1.67174429e-01f, 1.83507413e-01f, -1.52836397e-01f, -1.61521047e-01f,
  1.05678402e-01f, -4.83881645e-02f, 1.63973138e-01f, -1.56282596e-02f, 3.51182073e-02f, 9.99254454e-03f, -2.22141743e-02f, 1.41758159e-01f, 5.75232506e-03f, 6.28276840e-02f,
  -9.05796215e-02f, 5.03895357e-02f, -7.63804615e-02f, -1.14539444e-01f, -3.26390527e-02f, 4.36929315e-02f, -2.28643250e-02f, -4.09909971e-02f, 4.85224165e-02f, 3.25834788e-02f,
  -2.03562871e-01f, -5.34900017e-02f, 4.16650996e-02f, -1.79925356e-02f, -1.26736715e-01f, -3.22008803e-02f, 9.56820324e-02f, 5.38947470e-02f, -1.51889175e-01f, -2.23888978e-01f,
  6.40066713e-02f, -2.70289689e-01f, 8.81290343e-03f, 1.13817733e-02f, 4.30825651e-02f, -1.92995995e-01f, 1.19572550e-01f, -2.70150453e-01f, -1.36398539e-01f, -8.25765207e-02f,
  1.55791610e-01f, 6.61560297e-02f, -7.54345804e-02f, -1.47305466e-02f, 2.37711910e-02f, 1.20762959e-01f, 2.06657618e-01f, 1.22750849e-01f, 4.99739684e-03f, -1.51864946e-01f,
  5.37076853e-02f, -7.46211186e-02f, -1.98480964e-01f, -6.80896565e-02f, 1.99732222e-02f, -1.06604725e-01f, 2.38676578e-01f, -1.72391653e-01f, 1.25690222e-01f, 8.83779898e-02f,
  2.10530236e-01f, -4.42618690e-02f, -6.03716485e-02f, 8.44369978e-02f, -6.95173889e-02f, -8.54662806e-03f, -2.96942610e-02f, 6.19119126e-03f, -5.97788729e-02f, -7.58208008e-03f,
  -4.15860191e-02f, -6.96365535e-02f, -8.32731873e-02f, -6.01576362e-03f, -1.25162110e-01f, 2.57126950e-02f, -1.03084199e-01f, 2.98729055e-02f, 2.59206705e-02f, -5.41894920e-02f,
  1.00575946e-01f, 1.46147683e-01f, -1.37978971e-01f, 5.98680880e-03f, 6.74067885e-02f, 5.09058051e-02f, 2.15098681e-03f, 1.32827327e-01f, 3.16459127e-02f, -8.62363949e-02f,
  -2.06222609e-01f, -1.07127041e-01f, -2.09120847e-02f, 1.77958682e-01f, 6.87219948e-02f, 7.10197911e-03f, 3.68281640e-03f, -8.82843286e-02f, -6.64656460e-02f, 1.35064209e-02f,
  -5.25296293e-03f, 9.42761153e-02f, -1.50208883e-02f, 1.43998284e-02f, -1.57223091e-01f, -1.49928316e-01f, -1.34241879e-01f, 6.98447004e-02f, 1.37617990e-01f, -7.94784278e-02f,
  -1.51083082e-01f, 1.16836250e-01f, -7.73665085e-02f, 2.53339522e-02f, -7.44092092e-02f, 1.23230472e-01f, 2.05959886e-01f, -1.36516854e-01f, 1.10266671e-01f, -1.33231342e-01f,
  6.74952893e-03f, 5.20921163e-02f, -2.39480555e-01f, 2.69505847e-02f, 1.50508046e-01f, -3.61353904e-02f, -2.20410928e-01f, -1.10071748e-01f, 6.79522054e-03f, -8.81152507e-03f,
  2.26606522e-02f, 6.87171123e-04f, 1.49046481e-01f, 7.62059391e-02f, -1.06447870e-02f, -3.33527289e-02f, -3.97190861e-02f, -1.43345892e-01f, -2.64164153e-02f, -1.14475377e-01f,
  4.92845438e-02f, -1.57441106e-02f, -4.32392918e-02f, 3.29512097e-02f, -6.72561601e-02f, -9.62963402e-02f, 7.52257630e-02f, -5.68795949e-02f, 1.39972091e-01f, -2.01628022e-02f,
  -4.64574434e-02f, -3.27948667e-02f, -1.18519939e-01f, 1.25021607e-01f, 8.93698260e-03f, 1.33174464e-01f, -2.59860083e-02f, -6.08408451e-02f, -3.53895314e-02f, -3.09393909e-02f,
  9.17481259e-02f, 1.67389482e-01f, 4.64510843e-02f, 1.25944614e-01f, 1.18773304e-01f, 1.10933937e-01f, -2.33188327e-02f, 7.52633512e-02f, 3.32445814e-03f, 1.34145737e-01f,
  1.64570957e-01f, -5.39345853e-02f, -2.74077971e-02f, -5.37163876e-02f, 1.09264880e-01f, -9.83064547e-02f, 8.94262195e-02f, 7.71221891e-03f, 1.36907190e-01f, 1.28769949e-01f,
  -6.38850555e-02f, -6.41013756e-02f, 1.89010743e-02f, 7.11170286e-02f, -5.53021953e-02f, 1.69910997e-01f, 3.73675972e-02f, 3.83669958e-02f, 9.48936213e-03f, -9.85634550e-02f,
  2.94412766e-02f, 1.71026990e-01f, -5.84485307e-02f, -5.10376804e-02f, -1.36535764e-02f, -7.14436322e-02f, -1.22992676e-02f, -4.76770774e-02f, -7.07271248e-02f, -3.11354939e-02f,
  7.93269277e-02f, 2.10938952e-03f, -3.11992913e-02f, -1.54217500e-02f, -1.39578879e-02f, -2.06267253e-01f, -9.01222453e-02f, 5.06793931e-02f, 4.97702546e-02f, -1.05359601e-02f,
  -1.49783352e-02f, -9.05822366e-02f, 1.51483551e-01f, -2.75160577e-02f, 7.77381882e-02f, -1.60759948e-02f, -1.14927515e-01f, -4.24557291e-02f, -1.43973038e-01f, 6.76692799e-02f,
  2.34781690e-02f, -8.18228945e-02f, -3.60087603e-02f, -3.97804603e-02f, 3.15193180e-03f, 5.31911328e-02f, -4.12550718e-02f, 5.56746759e-02f, 6.48078993e-02f, -6.06000684e-02f,
  -2.34063994e-02f, 8.96188058e-03f, 1.36226028e-01f, -9.04698204e-03f, -1.47362696e-02f, 7.38195404e-02f, 4.09301147e-02f, 4.46277037e-02f, 3.13192680e-02f, -1.19886603e-02f,
  -9.96687412e-02f, 7.81684294e-02f, -2.60736030e-02f, 2.24014875e-02f, -1.65685937e-01f, -1.40575534e-02f, 2.52636429e-02f, -2.05232538e-02f, 2.63353735e-01f, -2.09506273e-01f,
  8.74806046e-02f, 1.51727781e-01f, -6.86870608e-03f, 1.86924770e-01f, -5.38320690e-02f, -1.82258375e-02f, 7.94589613e-03f, 2.36735791e-02f, 5.71865365e-02f, 3.18196490e-02f,
  -3.88052985e-02f, -6.38296781e-03f, 2.97393035e-02f, 1.61019057e-01f, 3.63111645e-02f, 8.41186121e-02f, 6.37339428e-03f, 1.30682260e-01f, -6.42525181e-02f, -8.67876783e-02f,
  -8.51176959e-03f, 6.95599541e-02f, 5.46796173e-02f, 6.56241626e-02f, -2.68461630e-02f, 8.05356875e-02f, -2.93162391e-02f, 8.01670644e-03f, 1.43474385e-01f, 9.38062966e-02f,
  -4.12466079e-02f, -2.12404937e-01f, -1.22395769e-01f, -1.66889161e-01f, -1.65697753e-01f, -9.75615382e-02f, 4.14352939e-02f, -1.27017468e-01f, 6.60487637e-02f, -3.64760011e-02f,
  -8.61296058e-03f, -1.50861889e-01f, 4.63826247e-02f, -2.21671149e-01f, -7.95718133e-02f, -5.54357320e-02f, -1.64065491e-02f, -5.60638420e-02f, -8.79213065e-02f, 8.61842781e-02f,
  2.48614587e-02f, -3.87205966e-02f, 2.38558296e-02f, 9.07622352e-02f, -1.61268368e-01f, -7.25441352e-02f, 5.94203435e-02f, -8.98302123e-02f, 6.47206679e-02f, -1.94002986e-01f,
  7.58403689e-02f, -1.06975213e-01f, 2.12268710e-01f, -7.69588500e-02f, 4.50194106e-02f, 1.63438935e-02f, 1.66429445e-01f, 1.66651413e-01f, -1.06475867e-01f, 5.59050255e-02f
};

// L1_fan_Wp_bar (Shape: 14 x 64)
const int L1_fan_Wp_bar_rows = 14;
const int L1_fan_Wp_bar_cols = 64;
const float L1_fan_Wp_bar_data[] = {
  3.55439037e-02f, 1.30746976e-01f, 9.97745246e-03f, 5.64614385e-02f, 2.95193493e-02f, 1.34140849e-01f, 9.89120305e-02f, 1.12184972e-01f, -8.54275450e-02f, 9.80398878e-02f,
  -2.48248801e-02f, 1.32307902e-01f, 7.17534944e-02f, 7.57693350e-02f, 1.17947541e-01f, -1.20949626e-01f, 1.71354055e-01f, 8.30500796e-02f, -3.39093730e-02f, 8.87345299e-02f,
  7.19774002e-03f, 1.11585259e-01f, 5.60573637e-02f, 2.60799527e-01f, 2.06187025e-01f, -9.94190052e-02f, -2.25372583e-01f, -6.48420528e-02f, -1.99947193e-01f, 3.21786076e-01f,
  2.53795564e-01f, 1.09806441e-01f, -8.46624374e-02f, -2.00596333e-01f, -6.63927794e-02f, -1.60986513e-01f, -1.21820368e-01f, -3.65321897e-02f, 1.03451973e-02f, -2.24325210e-02f,
  -2.47355640e-01f, -2.21718177e-01f, -1.79080814e-01f, 3.35868597e-02f, 2.01635554e-01f, -1.40431195e-01f, -1.42202571e-01f, 1.90553650e-01f, 5.40271625e-02f, 3.85804512e-02f,
  4.04824037e-03f, 1.94892719e-01f, 5.11611223e-01f, 8.91019683e-03f, 1.72262356e-01f, 7.92058408e-02f, -5.76175600e-02f, 2.57543623e-01f, -2.96732858e-02f, -1.10750072e-01f,
  8.73155519e-02f, -4.90927435e-02f, -9.69786663e-03f, 3.64455651e-03f, 6.26831800e-02f, -4.55583148e-02f, 3.55241224e-02f, 1.42101914e-01f, 6.22013211e-02f, 1.06821388e-01f,
  7.78604299e-02f, -1.26511035e-02f, 1.34287938e-01f, 4.47785370e-02f, 4.80502285e-02f, -9.01581123e-02f, 5.05537614e-02f, -1.13182925e-01f, -8.65016691e-03f, -5.34801697e-03f,
  -4.02123928e-02f, -3.66203561e-02f, 5.17148785e-02f, -5.15269190e-02f, 1.62582710e-01f, 3.03194784e-02f, 1.12879828e-01f, 6.81385258e-03f, -2.39744306e-01f, -5.00668306e-04f,
  2.10871082e-02f, 1.00740083e-01f, -1.45708904e-01f, -8.27121809e-02f, 3.11207958e-02f, -5.65446280e-02f, -1.54544041e-02f, 1.86604276e-01f, 1.49108976e-01f, -1.59941614e-02f,
  1.54803097e-01f, -1.11724824e-01f, -2.10271049e-02f, 6.44600615e-02f, 1.56190693e-01f, 2.45737642e-01f, 2.59134531e-01f, 5.64849041e-02f, -1.47073939e-01f, 1.70932692e-02f,
  1.62853345e-01f, -1.11924797e-01f, 1.97216552e-02f, -1.96145736e-02f, 1.91967413e-01f, 2.74313651e-02f, -7.99303278e-02f, -1.52896792e-01f, -2.96698548e-02f, 2.50836343e-01f,
  2.19371423e-01f, 1.28275394e-01f, 3.44280571e-01f, -1.93142347e-04f, -8.80566910e-02f, 1.16846107e-01f, 2.25570440e-01f, 1.90624356e-01f, -1.54083697e-02f, 5.62193394e-02f,
  3.09996605e-02f, -3.91858257e-02f, 1.36764631e-01f, -3.82361412e-02f, -1.73415318e-02f, 7.32876807e-02f, 1.27278417e-01f, 3.16719972e-02f, -2.40663514e-02f, -1.72009561e-02f,
  1.35924414e-01f, -5.52026853e-02f, -5.08403443e-02f, 9.54995677e-02f, 1.00924782e-01f, 2.31190827e-02f, 7.78734609e-02f, -9.41666588e-02f, 2.84481317e-01f, 7.39797428e-02f,
  2.26207189e-02f, 3.26802842e-02f, -2.72066575e-02f, -2.61575878e-02f, -1.33487508e-01f, 7.50598833e-02f, -5.67604862e-02f, 1.17780805e-01f, 4.10089456e-02f, 8.46385211e-02f,
  -9.86462831e-02f, 1.65132239e-01f, -5.12604776e-04f, 5.55530638e-02f, 1.67182654e-01f, -8.14588042e-04f, -7.27332234e-02f, 2.13631600e-01f, 1.45518407e-01f, 3.82721871e-02f,
  -1.33664487e-02f, -5.23309410e-02f, 2.17029434e-02f, 1.32921673e-02f, 2.66602561e-02f, -1.05915286e-01f, 1.73170995e-02f, -3.27447020e-02f, 3.01344786e-02f, 2.59588547e-02f,
  -8.23127031e-02f, 1.46201044e-01f, 1.46143869e-01f, 1.98178291e-01f, 2.36570507e-01f, -1.02696739e-01f, 7.26126134e-02f, 1.62948027e-01f, 1.70363069e-01f, 2.16404088e-02f,
  1.93934083e-01f, 1.94366463e-02f, 4.06220593e-02f, 1.11675739e-01f, 1.14718720e-01f, 1.45094633e-01f, -1.18298896e-01f, 3.47560905e-02f, -9.19175055e-03f, 1.57253623e-01f,
  3.40811983e-02f, 2.40376174e-01f, -2.12281663e-02f, 1.39463514e-01f, -1.74751449e-02f, 1.78787231e-01f, 4.44143452e-02f, 2.22575963e-01f, 2.56802976e-01f, 1.91923827e-01f,
  -1.01289287e-01f, 1.42969638e-01f, 1.14609532e-01f, 1.36550277e-01f, 1.93394318e-01f, 1.28768206e-01f, 2.26287067e-01f, -1.86275169e-01f, -3.39786783e-02f, -1.60243601e-01f,
  1.27709597e-01f, -9.51585844e-02f, -1.18755460e-01f, 5.16001545e-02f, 6.40471503e-02f, -1.33367507e-02f, -1.74139991e-01f, -8.12071860e-02f, -2.59303348e-03f, -9.72223356e-02f,
  -1.70418710e-01f, -6.63088933e-02f, 9.29709151e-03f, -2.16893941e-01f, -1.28236249e-01f, -4.58326265e-02f, 1.14052661e-01f, -6.12603538e-02f, -1.29533038e-01f, 1.53365254e-01f,
  -2.31214672e-01f, -7.41968229e-02f, -1.59768984e-01f, 9.91990268e-02f, -1.33396685e-01f, -3.76426168e-02f, 9.53910872e-02f, -1.82416916e-01f, 2.89411284e-02f, -2.91750282e-01f,
  -2.13852644e-01f, 2.55833983e-01f, 7.04313889e-02f, 2.11998016e-01f, -1.63033843e-01f, -3.61277908e-02f, 1.40841812e-01f, 5.26662217e-03f, 1.05904460e-01f, 2.34258324e-02f,
  1.64974988e-01f, 7.16261640e-02f, 8.86690393e-02f, -5.70721216e-02f, 2.03127474e-01f, 1.43598363e-01f, 7.28634149e-02f, 1.37700066e-01f, 5.88895530e-02f, -1.56981722e-01f,
  4.85992096e-02f, 3.04446695e-03f, 1.91025455e-02f, 3.71656083e-02f, 1.71864167e-01f, 1.01713471e-01f, 9.40742344e-02f, 8.72508716e-03f, 1.13696575e-01f, 1.64419979e-01f,
  -1.24336354e-01f, -1.89021736e-01f, -2.47238293e-01f, -5.05953059e-02f, -1.91976890e-01f, -4.80816774e-02f, 7.93132037e-02f, -1.39315695e-01f, 1.51940323e-02f, -4.57409136e-02f,
  1.17158920e-01f, -4.99110296e-02f, 2.04146933e-02f, -2.00783119e-01f, -6.30700067e-02f, -5.62725142e-02f, 4.14068401e-02f, 4.95661199e-02f, 6.00282177e-02f, 1.44433841e-01f,
  6.02568910e-02f, 2.14299168e-02f, 9.71964672e-02f, -4.91241701e-02f, -1.32650807e-01f, 1.09701850e-01f, 2.11569682e-01f, -1.62641242e-01f, 1.56831861e-01f, -1.77805990e-01f,
  1.99094474e-01f, 2.71866582e-02f, 3.56857866e-01f, 2.05636159e-01f, 2.64178127e-01f, -1.17061988e-01f, 1.69499099e-01f, 5.66129908e-02f, -3.43036391e-02f, 1.39076514e-02f,
  -1.22575532e-03f, 1.35375097e-01f, 9.92277190e-02f, 8.69582519e-02f, 7.05802962e-02f, 1.05341129e-01f, -4.84003779e-03f, 1.02738179e-01f, 8.55485722e-02f, 1.28418952e-01f,
  1.27708748e-01f, 1.70246854e-01f, 1.44392133e-01f, 2.22947970e-01f, 9.95676816e-02f, 1.76173538e-01f, 7.59727359e-02f, 1.02247648e-01f, 8.99860933e-02f, 1.36168450e-01f,
  2.69013867e-02f, 6.46409839e-02f, 2.54572500e-02f, 3.67548726e-02f, 2.53153503e-01f, 6.36394098e-02f, 2.09617808e-01f, -3.35443206e-02f, 3.15658510e-01f, -6.71024844e-02f,
  -1.80913284e-01f, 1.58075705e-01f, -1.53166994e-01f, -7.80552551e-02f, -1.40600458e-01f, 1.06666662e-01f, -1.41226575e-01f, 1.45485654e-01f, 9.39664245e-02f, -2.32177023e-02f,
  6.25351518e-02f, -4.98084649e-02f, -1.56376764e-01f, -1.89666562e-02f, -5.00454977e-02f, 1.49857685e-01f, -1.71478391e-01f, -5.93783334e-03f, 8.53834732e-04f, -5.28106466e-03f,
  -1.35080352e-01f, -5.87265603e-02f, -1.86396539e-01f, 3.61483514e-01f, -4.04690243e-02f, -5.52243963e-02f, -1.31180212e-01f, -2.15795770e-01f, -6.48365244e-02f, 1.69373259e-01f,
  -1.57164484e-01f, 1.12805486e-01f, 9.61987153e-02f, -1.08061895e-01f, 1.66376919e-01f, 6.54453933e-02f, 1.62228987e-01f, 6.41086102e-02f, 1.58430845e-01f, 1.10811003e-01f,
  1.47220477e-01f, -2.97484919e-02f, 6.37098029e-02f, 1.52008191e-01f, 1.19485252e-01f, 6.64413050e-02f, 2.93706935e-02f, 6.35332661e-03f, 7.29425400e-02f, 1.43966183e-01f,
  8.83945357e-03f, -3.36329117e-02f, 1.66323185e-01f, 8.47905949e-02f, 1.61194220e-01f, -1.90597102e-02f, 1.51504233e-01f, 3.74865420e-02f, -3.44699100e-02f, -1.32182434e-01f,
  -5.77476136e-02f, -6.28941655e-02f, -1.26492068e-01f, -4.63426672e-02f, -1.79199427e-02f, -5.00722118e-02f, 9.97852981e-02f, 1.42050236e-01f, 1.60211071e-01f, -2.23483965e-02f,
  6.17119186e-02f, -8.85686055e-02f, -1.29780576e-01f, 1.07922801e-03f, -4.62844335e-02f, 5.76637946e-02f, 1.45289630e-01f, -5.57315163e-02f, -7.31646642e-02f, -3.50412242e-02f,
  1.55869395e-01f, -1.66055664e-01f, -1.16798934e-03f, -7.71671608e-02f, 1.91475153e-01f, -1.00471959e-01f, -4.08578850e-02f, -1.24044880e-01f, 1.94403946e-01f, 7.41023719e-02f,
  1.67058229e-01f, 1.34213224e-01f, 1.61295921e-01f, -4.93271165e-02f, 1.45496055e-01f, -7.98285678e-02f, 8.29322413e-02f, 9.65211540e-02f, -1.49916690e-02f, 1.46822453e-01f,
  2.30319314e-02f, 4.31772508e-02f, 5.09858243e-02f, 4.88094464e-02f, 9.70393643e-02f, -6.20623119e-02f, 8.92723501e-02f, 1.45063205e-02f, 1.15876183e-01f, 1.05646424e-01f,
  6.35878369e-02f, 1.33927733e-01f, 9.31765512e-02f, 1.30801097e-01f, 1.13218889e-01f, 1.03215411e-01f, 6.54117092e-02f, 1.81886569e-01f, 2.29431346e-01f, 1.77422717e-01f,
  1.06752597e-01f, -1.89611653e-03f, 1.53673917e-01f, 1.18439995e-01f, -1.57460161e-02f, -1.02766063e-02f, 2.56220788e-01f, -4.31618057e-02f, -1.40787438e-01f, 1.35193527e-01f,
  7.08567649e-02f, 3.24895754e-02f, -1.40119433e-01f, 2.60724872e-01f, -1.11964338e-01f, 2.39688635e-01f, 1.02873497e-01f, -9.50971153e-03f, -9.03328806e-02f, -9.32785571e-02f,
  6.83345646e-02f, -8.73927213e-03f, 3.10546309e-02f, -5.10926545e-02f, -1.15099445e-01f, -1.66911781e-02f, -7.41522387e-02f, 1.25641391e-01f, 3.27314576e-03f, 3.40991497e-01f,
  1.28002882e-01f, 1.20776519e-01f, 5.87226711e-02f, -5.34679890e-02f, -1.27876416e-01f, 2.11077482e-01f, -1.36075854e-01f, 1.25197887e-01f, -6.55447096e-02f, 2.34090343e-01f,
  -8.62107202e-02f, -6.50114492e-02f, 1.60025865e-01f, 5.86177148e-02f, 1.55977696e-01f, 1.30965933e-01f, 1.47143528e-01f, 4.22491767e-02f, -3.90798692e-03f, 2.65937716e-01f,
  5.08357659e-02f, -4.34700064e-02f, -5.77340275e-03f, 1.09507285e-01f, -6.19321167e-02f, 1.74795821e-01f, 1.40257388e-01f, 5.59437051e-02f, 6.95555881e-02f, -2.47745793e-02f,
  1.00735128e-01f, 8.66676420e-02f, -3.10073823e-01f, 7.42353648e-02f, -2.89111049e-03f, 1.04880325e-01f, -8.37487504e-02f, 3.20683658e-01f, 3.19775462e-01f, 2.37278998e-01f,
  1.40739176e-02f, -1.64410189e-01f, 3.05629130e-02f, -2.73523241e-01f, 9.10156444e-02f, -1.73252429e-05f, -1.36940494e-01f, -5.09717315e-02f, 1.36078959e-02f, -1.81959033e-01f,
  -5.79012707e-02f, -5.63141815e-02f, 1.08610667e-01f, -3.92198227e-02f, -1.16267100e-01f, -1.67796522e-01f, 4.72220220e-02f, 1.22863397e-01f, 1.96099088e-01f, 2.29974657e-01f,
  1.58048823e-01f, -1.19205460e-01f, -5.72749302e-02f, 3.96656722e-01f, -1.55758396e-01f, 2.45038241e-01f, 1.05965026e-01f, -1.10935010e-01f, -1.09368034e-01f, -5.94756976e-02f,
  -7.17545673e-02f, 2.23165646e-01f, 1.25817060e-01f, -2.49945939e-01f, 2.06257426e-03f, 3.08756530e-01f, 1.32438287e-01f, 2.02839659e-03f, 1.45362854e-01f, 2.58496869e-02f,
  8.14447030e-02f, 8.98343027e-02f, 9.97509342e-03f, 1.19571000e-01f, 9.89482403e-02f, 1.23492780e-03f, 1.15741186e-01f, 2.14953739e-02f, 1.68184415e-01f, 1.81194901e-01f,
  1.19068287e-01f, -5.73706292e-02f, 3.93640101e-02f, -7.07339346e-02f, 1.19628683e-01f, -1.17919240e-02f, -1.36166245e-01f, 3.90454084e-02f, -1.25366628e-01f, 3.13626952e-03f,
  1.09930523e-01f, 1.99836388e-01f, 3.40176731e-01f, 1.68493181e-01f, 6.97188154e-02f, 7.71051347e-02f, -6.44012988e-02f, 1.07386254e-01f, -2.14023903e-01f, 4.68148664e-02f,
  1.03685945e-01f, -1.40044009e-02f, 3.91256027e-02f, 7.59558156e-02f, 3.03172059e-02f, 8.86141881e-02f, 1.65797994e-01f, 1.26622349e-01f, -9.73348022e-02f, -1.31261483e-01f,
  -1.41701162e-01f, 1.83554381e-01f, 5.19018210e-02f, -1.28686905e-01f, 2.85709411e-01f, -9.70423520e-02f, -4.49547125e-03f, -1.69384673e-01f, -5.23282923e-02f, 3.40832919e-01f,
  -1.59398869e-01f, 1.05092198e-01f, -1.92423478e-01f, -6.63928539e-02f, 5.77237606e-02f, 4.50053997e-03f, -3.60008702e-02f, -2.79856980e-01f, 2.30849624e-01f, 1.54704958e-01f,
  8.76823887e-02f, 2.83319037e-02f, 1.21678546e-01f, 8.70869830e-02f, 1.27421603e-01f, 4.92584854e-02f, -3.01264189e-02f, 2.74483055e-01f, 1.17053531e-01f, 8.45037550e-02f,
  -4.98700254e-02f, 4.15212549e-02f, 1.10757075e-01f, 7.21118152e-02f, 6.63075298e-02f, 1.62121296e-01f, 1.01858273e-01f, -2.41877399e-02f, 4.98829745e-02f, 5.23138717e-02f,
  3.19277942e-02f, 7.61770457e-02f, 7.47636557e-02f, 9.62775797e-02f, -1.91881135e-01f, 4.92525510e-02f, 1.08866848e-01f, 1.46090478e-01f, -5.28467707e-02f, -9.63720158e-02f,
  -4.52551171e-02f, -1.55137196e-01f, -6.28755167e-02f, 1.56606615e-01f, -8.38005096e-02f, -7.25317001e-02f, 1.40890211e-01f, -2.09517360e-01f, -2.09343329e-01f, 1.05539054e-01f,
  8.51823464e-02f, 9.13249105e-02f, -7.75507325e-03f, -2.25439444e-01f, 3.80250700e-02f, 2.39368025e-02f, 1.61354467e-01f, 6.29895031e-02f, 7.30121210e-02f, -2.17087135e-01f,
  1.39477223e-01f, 1.61483571e-01f, -1.90672636e-01f, 9.09340307e-02f, 1.12335727e-01f, 5.94271719e-02f, 9.01062936e-02f, -1.76034167e-01f, 1.28947675e-01f, 2.50599146e-01f,
  9.65676606e-02f, -1.25037313e-01f, 1.41738534e-01f, 2.74261713e-01f, -1.07309103e-01f, 1.32774144e-01f, 6.92623183e-02f, -5.14183454e-02f, 5.90212904e-02f, 5.28491065e-02f,
  1.55340908e-02f, 4.25640829e-02f, 8.70888904e-02f, 2.84247479e-04f, 2.36895424e-03f, -2.39236392e-02f, 1.54797360e-01f, 1.35919163e-02f, 1.40989302e-02f, 1.72762677e-01f,
  1.35089114e-01f, -6.55212766e-03f, 7.42473677e-02f, -1.09695727e-02f, 3.66106868e-01f, 4.62558270e-02f, 1.48193613e-01f, 1.67386487e-01f, 2.17354119e-01f, -6.83476925e-02f,
  -2.43382022e-01f, -8.73544067e-02f, 1.30596906e-01f, 3.62715453e-01f, -1.00828536e-01f, 3.15076023e-01f, -2.49533176e-01f, 2.45721787e-01f, -1.37599304e-01f, 9.63024795e-02f,
  2.66960775e-03f, 3.32696848e-02f, -9.80874300e-02f, 2.10202083e-01f, -7.18968213e-02f, -1.46974862e-01f, -1.27281491e-02f, -2.15165660e-01f, 1.02214843e-01f, -1.25699230e-02f,
  -2.23202363e-01f, -1.24757364e-01f, -8.98944736e-02f, -6.54411390e-02f, -2.78289393e-02f, 2.08773211e-01f, -6.34429902e-02f, 6.63893372e-02f, 1.90634146e-01f, 1.99796721e-01f,
  -6.71031103e-02f, -1.83373034e-01f, -5.71243316e-02f, 1.18362263e-01f, -1.18939124e-01f, -2.21496463e-01f, 1.98696822e-01f, -1.30345821e-01f, 1.17263727e-01f, -8.12461786e-03f,
  9.16983485e-02f, 8.80511403e-02f, 1.97141722e-01f, 1.34925634e-01f, 5.04592359e-02f, -1.33538181e-02f, 7.98014030e-02f, 2.21480858e-02f, 8.51507038e-02f, -3.20094973e-02f,
  7.48804882e-02f, 5.81677556e-02f, 6.97284788e-02f, -4.54917885e-02f, -7.78757259e-02f, -1.45234734e-01f, 1.71352386e-01f, 6.92246780e-02f, 5.43515235e-02f, -3.81306489e-03f,
  5.29541522e-02f, 1.98505707e-02f, -6.91287369e-02f, 1.60203889e-01f, 1.72843233e-01f, 1.01245120e-01f, -5.02175018e-02f, -9.91844609e-02f, -6.98922649e-02f, -7.18773855e-03f,
  -1.53502272e-02f, 1.43971264e-01f, 1.71351224e-01f, 8.24214742e-02f, 2.69705318e-02f, 8.86740535e-02f, 1.25115737e-01f, -3.00035626e-02f, 6.89828843e-02f, 2.30056718e-01f,
  1.98106721e-01f, -8.51829201e-02f, -1.59517065e-01f, -4.60950239e-03f, 9.48012844e-02f, -1.89358220e-01f, 1.78190380e-01f, 6.37690648e-02f, 2.23642781e-01f, 9.06190425e-02f,
  -4.81784530e-03f, 1.13474227e-01f, -1.00078896e-01f, 1.63245529e-01f, -3.67818438e-02f, 2.01176092e-01f, 2.25675434e-01f, -9.39277709e-02f, -9.31903534e-03f, -9.35906842e-02f,
  1.74793243e-01f, 2.09305525e-01f, 5.56954779e-02f, 7.40053356e-02f, 7.39359856e-03f, 1.33507460e-01f, -9.99821648e-02f, 1.25701115e-01f, 1.67482272e-01f, -1.35890022e-01f,
  -1.13132279e-02f, 1.80117711e-01f, 1.83634281e-01f, 7.15933219e-02f, -3.59303430e-02f, 1.81931555e-01f, 1.38612598e-01f, 1.53581202e-02f, 1.74225662e-02f, 1.86144784e-01f,
  1.12800904e-01f, 1.89229295e-01f, 1.24531314e-01f, 8.79194140e-02f, 2.14039996e-01f, 6.90364391e-02f, 1.42699465e-01f, -2.08492488e-01f, -1.19314551e-01f, -1.81548461e-01f,
  -5.27836382e-02f, -1.06986485e-01f, -4.15016524e-02f, -1.37138404e-02f, 2.46295080e-01f, -9.38539132e-02f, 6.42979741e-02f, 3.66491079e-02f, -8.71816874e-02f, 1.34363979e-01f,
  1.12288155e-01f, -1.02748729e-01f, -1.53030276e-01f, 1.97407342e-02f, 1.52968645e-01f, 2.14938596e-01f, -5.19681461e-02f, -1.93356231e-01f, 1.47752771e-02f, 2.14655120e-02f,
  -1.23411857e-01f, 2.06109479e-01f, 1.85166940e-01f, -5.42816147e-02f, 2.43054047e-01f, -2.74824530e-01f, -1.41663268e-01f, -3.64996605e-02f, -1.21350372e-02f, 3.37723553e-01f,
  1.25281081e-01f, -4.25077826e-02f, -2.05348409e-03f, 3.59022737e-01f, -9.76950452e-02f, 8.44089407e-03f
};

// L1_fan_Bp_bar (Shape: 1 x 14)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 14;
const float L1_fan_Bp_bar_data[] = {
  8.16137791e-02f, 1.90702514e-04f, 1.06350519e-01f, 1.63604081e-01f, 8.76577571e-02f, 1.12874359e-01f, 1.14041522e-01f, 9.30250436e-02f, 1.25866085e-01f, 1.04962468e-01f,
  8.10714588e-02f, 2.91589834e-02f, 7.23505691e-02f, 7.20009357e-02f
};

// L2_fan_Wp (Shape: 25 x 64)
const int L2_fan_Wp_rows = 25;
const int L2_fan_Wp_cols = 64;
const float L2_fan_Wp_data[] = {
  1.48288488e-01f, 1.19671531e-01f, -2.43903454e-02f, -1.41693314e-03f, 1.34508669e-01f, -4.53808904e-02f, 1.69570949e-02f, 1.41552687e-01f, 8.01530853e-02f, -6.11508936e-02f,
  -2.04317402e-02f, -4.72752787e-02f, 1.75656080e-01f, -6.79687709e-02f, 7.31508881e-02f, 6.71700910e-02f, 2.30586007e-02f, -1.10853286e-02f, 6.43540993e-02f, 1.56619363e-02f,
  1.91643432e-01f, 9.80968773e-02f, 1.44852675e-04f, 6.81941258e-03f, 5.38591668e-02f, 1.39838487e-01f, 4.30477969e-02f, -1.29276335e-01f, -9.36633721e-02f, 1.44421114e-02f,
  -6.59129471e-02f, 1.54620409e-01f, -1.33997932e-01f, -6.62372857e-02f, -9.63735804e-02f, 1.00121073e-01f, -2.13972479e-01f, -2.24616881e-02f, -6.59756511e-02f, -3.10697835e-02f,
  -3.90531532e-02f, -6.30273521e-02f, -2.98959203e-02f, 7.24663064e-02f, 1.58306863e-02f, -1.29148830e-02f, -6.72647730e-02f, -3.44248638e-02f, -4.50338796e-02f, 5.42464890e-02f,
  -1.14495069e-01f, 7.37291127e-02f, -9.62275937e-02f, -2.88294461e-02f, 6.13150299e-02f, 1.12023078e-01f, 1.29860923e-01f, -4.57317643e-02f, -2.42714584e-01f, -5.33671156e-02f,
  -1.36579156e-01f, 4.54971008e-02f, 1.30929455e-01f, 7.73045495e-02f, -3.16753611e-02f, 3.94388661e-02f, -7.66592771e-02f, -8.00770521e-02f, 7.90504888e-02f, -3.86502296e-02f,
  -2.23709159e-02f, 8.80093500e-02f, 1.16926447e-01f, 5.24188997e-03f, -7.87274092e-02f, -5.92760444e-02f, 1.02384590e-01f, 4.53530718e-03f, 3.96098457e-02f, 1.15016229e-01f,
  -1.44083621e-02f, 3.22647505e-02f, 2.71724481e-02f, 1.03733968e-02f, 1.84286550e-01f, 1.68349650e-02f, 1.10403039e-02f, -1.95039883e-02f, -3.06615457e-02f, 1.72259542e-03f,
  8.47517848e-02f, -1.36067793e-01f, -1.36420071e-01f, 1.58079505e-01f, -1.11423932e-01f, 1.92163125e-01f, -1.36380985e-01f, -1.30305022e-01f, -1.17099479e-01f, 4.77202795e-03f,
  -1.61576077e-01f, -6.29004836e-02f, -1.57724425e-01f, 4.61293533e-02f, 5.10266311e-02f, -1.30879208e-01f, -7.64871836e-02f, 5.73129766e-02f, 2.66195368e-02f, -7.73738921e-02f,
  -8.05699639e-03f, -7.71476626e-02f, -3.36459763e-02f, -5.71994111e-03f, -7.58577660e-02f, -7.08561018e-02f, -6.90000281e-02f, -1.29434629e-03f, 2.16052984e-03f, 1.00636259e-01f,
  9.95916221e-03f, 4.88300174e-02f, -2.51838833e-01f, 1.00523397e-01f, -1.89502969e-01f, -3.86233069e-02f, 2.50991285e-02f, 1.52468830e-01f, 4.16470990e-02f, -5.35587780e-02f,
  -8.34247917e-02f, 2.39430536e-02f, 7.36252293e-02f, 4.45203707e-02f, -1.77361462e-02f, -3.68504897e-02f, 5.46549521e-02f, -8.00687633e-03f, 3.10226008e-02f, 5.32555999e-03f,
  5.77445850e-02f, -1.13118425e-01f, 3.91942821e-02f, -3.30692269e-02f, 7.67291784e-02f, -5.64053766e-02f, -4.97507863e-02f, -7.28849694e-02f, 1.06857993e-01f, 7.43338764e-02f,
  -3.87519747e-02f, -7.72178024e-02f, 5.17593250e-02f, -5.21803424e-02f, 7.25385696e-02f, 5.03501929e-02f, -9.77423042e-02f, 9.22940969e-02f, -6.73885271e-02f, 1.94100291e-02f,
  -1.37252018e-01f, -1.50866613e-01f, -1.00310676e-01f, 7.36181438e-02f, -6.42387271e-02f, -1.57086581e-01f, 7.92389587e-02f, -3.38770486e-02f, 1.43969998e-01f, -9.22251940e-02f,
  -1.21490017e-01f, 2.29465775e-02f, 4.36675176e-02f, -1.55893505e-01f, 9.23082083e-02f, -1.01531902e-02f, 5.13035757e-03f, -9.04709697e-02f, 7.60533810e-02f, -1.46091953e-01f,
  -6.93212524e-02f, 1.03574559e-01f, -9.95438397e-02f, 1.16234511e-01f, -3.27196009e-02f, 2.58522362e-01f, -7.08448142e-02f, -1.08863771e-01f, -1.71945378e-01f, 6.21436536e-02f,
  -1.04406960e-01f, 2.00063050e-01f, 3.92196774e-02f, -1.23328738e-01f, 9.01105180e-02f, 1.11122087e-01f, 1.13830589e-01f, -1.31080240e-01f, 3.23800780e-02f, -2.78261323e-02f,
  -4.91018780e-02f, -1.13608405e-01f, -1.08778486e-02f, 4.78252489e-03f, 1.82932597e-02f, -7.17003644e-02f, 2.00606585e-02f, -9.71012041e-02f, 3.26648392e-02f, -6.99910289e-03f,
  8.67835879e-02f, -1.09078132e-01f, -6.84280321e-03f, -7.69059360e-02f, 3.72688361e-02f, 3.71875092e-02f, 3.19452807e-02f, -2.56246142e-02f, 1.48982823e-01f, 1.65227726e-01f,
  6.51388466e-02f, 2.70583238e-02f, 2.08772216e-02f, -1.88685983e-01f, -1.65792719e-01f, -9.46183950e-02f, -1.71737038e-02f, 1.97647959e-01f, -6.43521175e-02f, -7.89737999e-02f,
  1.07428141e-01f, -1.91982731e-01f, 5.99804856e-02f, 1.71199590e-01f, 9.02412236e-02f, 7.72075951e-02f, 4.27325293e-02f, -7.78208226e-02f, -5.31572774e-02f, 3.11179273e-02f,
  1.46912083e-01f, -1.12473063e-01f, -1.13471866e-01f, 1.35197863e-01f, 3.68737243e-02f, -7.16222078e-02f, 4.68533002e-02f, 1.05649233e-01f, -1.32273912e-01f, 1.22129560e-01f,
  -8.23115185e-02f, 6.89367950e-02f, -2.90077422e-02f, 1.69310108e-01f, 1.14218280e-01f, -1.37208223e-01f, -2.43408587e-02f, -1.01354390e-01f, 1.25125283e-02f, 2.94954777e-02f,
  -5.08140363e-02f, -5.35364896e-02f, -1.97685838e-01f, -1.23309195e-01f, -9.59170684e-02f, -1.54810131e-01f, 3.44764367e-02f, 2.32122373e-02f, 9.88617633e-03f, 1.47218416e-02f,
  -2.11106911e-02f, -1.09820276e-01f, -8.81035998e-02f, 7.38447458e-02f, -3.11779464e-03f, 2.13955231e-02f, 2.00513769e-02f, -2.43210122e-01f, 4.96016219e-02f, -4.92909737e-02f,
  -5.69214076e-02f, -1.53429627e-01f, 1.91955268e-02f, 1.19754687e-01f, -2.16513965e-03f, 1.50899023e-01f, 1.97813734e-02f, -2.16161981e-01f, -9.10743326e-03f, -5.18981256e-02f,
  3.08943391e-02f, 7.56354854e-02f, -1.04862219e-02f, -2.20317736e-01f, -4.60808910e-02f, -7.26187006e-02f, 9.92571563e-02f, 1.26411453e-01f, -1.91971976e-02f, 1.10265650e-01f,
  -7.43765980e-02f, -1.15891539e-01f, 5.06048650e-02f, 2.16601114e-03f, 1.14434972e-01f, -9.00929943e-02f, 1.16671756e-01f, 2.07796022e-01f, 1.30305082e-01f, -7.39365667e-02f,
  1.46469362e-02f, -6.50303811e-02f, -1.11827336e-01f, 1.07046492e-01f, -1.43446222e-01f, -1.74895655e-02f, -1.55082939e-03f, -6.52866960e-02f, -3.41398157e-02f, 9.77493152e-02f,
  4.77617681e-02f, 1.17506631e-01f, -8.71732645e-03f, 8.07412341e-02f, -5.40933199e-02f, 9.19043720e-02f, -4.17673551e-02f, -1.99158099e-02f, -3.74701712e-03f, 9.53456238e-02f,
  -5.21223359e-02f, -1.63033083e-02f, -1.04827369e-02f, 7.84960017e-02f, -6.52611395e-03f, 5.09334654e-02f, 6.26701266e-02f, 1.11654066e-02f, -4.14080918e-02f, 5.89261614e-02f,
  1.02130864e-02f, 4.15705070e-02f, -6.18807673e-02f, -2.71639763e-03f, 8.31989944e-02f, -4.68042400e-03f, -1.33138955e-01f, -4.56899703e-02f, 2.22190674e-02f, -8.79058912e-02f,
  -4.55401167e-02f, 1.36075631e-01f, 1.13645606e-01f, 2.97877425e-03f, -1.03500612e-01f, -1.84928790e-01f, 1.77184880e-01f, -7.14147557e-03f, -8.41983780e-03f, 1.60027355e-01f,
  -3.59714441e-02f, -1.37537077e-01f, -5.15332408e-02f, -4.26853746e-02f, 1.02188878e-01f, 2.20144447e-02f, 1.21961720e-01f, -7.87737668e-02f, -1.49571985e-01f, 1.97253406e-01f,
  2.08139777e-01f, -2.20346510e-01f, -1.77871779e-01f, 9.94159952e-02f, -1.03201330e-01f, -1.00969963e-01f, -2.32588463e-02f, -4.22420464e-02f, 1.43218815e-01f, -6.69046640e-02f,
  -1.00172795e-01f, -8.42454582e-02f, -7.95618892e-02f, 5.12834080e-02f, -1.36028394e-01f, -1.20290652e-01f, 8.97535235e-02f, 1.04716577e-01f, -5.14805084e-03f, 6.43102080e-02f,
  -9.12762731e-02f, -5.52784652e-02f, -5.57873324e-02f, -1.41583933e-02f, -1.07361354e-01f, 5.05321659e-02f, -5.25354668e-02f, 1.82450060e-02f, -3.99560146e-02f, -7.43711516e-02f,
  -5.11984481e-03f, 1.67109240e-02f, -2.97122486e-02f, -3.02204620e-02f, 1.66050643e-01f, -1.71890557e-01f, 1.96895115e-02f, 7.28473905e-03f, -4.77954373e-02f, -7.08939880e-02f,
  1.23316117e-01f, 1.14418723e-01f, 2.21190546e-02f, 1.33011818e-01f, -1.32725611e-02f, -1.05459690e-01f, -1.12874486e-01f, -1.95591077e-01f, -3.79934050e-02f, -8.85313079e-02f,
  1.26766071e-01f, 8.13808478e-03f, 1.03204504e-01f, 1.53823886e-02f, 5.90164997e-02f, 4.63089347e-02f, 6.65507317e-02f, 9.08175558e-02f, 1.32472804e-02f, -1.65842116e-01f,
  1.23259701e-01f, -5.74594922e-02f, 7.30212312e-03f, -1.07759692e-01f, 1.60980776e-01f, 3.84331495e-03f, 1.21242739e-01f, -3.35306674e-02f, 9.27787216e-04f, 6.69710040e-02f,
  -1.56582415e-01f, 6.68247649e-03f, -1.11976057e-01f, 9.08466652e-02f, -7.21372664e-02f, 2.38972962e-01f, 1.04205422e-02f, 2.66869436e-03f, -4.70782667e-02f, -1.06156871e-01f,
  -1.34160623e-01f, -3.04330699e-02f, 1.11407921e-01f, -1.20658400e-02f, 6.47770837e-02f, 3.22737284e-02f, 7.23811053e-03f, 4.70231399e-02f, 2.72739604e-02f, -9.61358771e-02f,
  -6.50203321e-03f, -1.04537636e-01f, 2.73530278e-02f, -6.19279556e-02f, -4.85918298e-03f, -1.25320897e-01f, 4.42260168e-02f, -2.25834832e-01f, 1.61362678e-01f, 1.33191749e-01f,
  5.72033925e-03f, -7.17457309e-02f, -2.47853883e-02f, -6.02793619e-02f, 8.59415606e-02f, -6.71169534e-02f, -3.12252976e-02f, -2.61849184e-02f, -2.90755406e-02f, 6.11740202e-02f,
  -2.23047689e-01f, -8.31341371e-02f, -7.78370872e-02f, 6.42633289e-02f, -1.69267938e-01f, -4.16444018e-02f, -9.98234283e-03f, -3.15994807e-02f, 6.68693334e-02f, -3.25537432e-04f,
  3.65413800e-02f, 2.42211819e-02f, 3.90171632e-03f, -6.22868203e-02f, 6.24147914e-02f, 2.72610169e-02f, 7.90720657e-02f, -3.02374456e-02f, -2.13474900e-01f, -2.98035908e-02f,
  7.83917457e-02f, 9.69706774e-02f, -7.00915977e-02f, 1.66104540e-01f, -3.03472509e-03f, 1.08144291e-01f, -2.08443508e-01f, -8.59811977e-02f, -1.12194084e-01f, 1.46380723e-01f,
  -3.67676429e-02f, 8.41281042e-02f, -2.62776073e-02f, -1.33493453e-01f, 1.10476919e-01f, 7.34805763e-02f, 6.66343933e-03f, -7.97358155e-02f, 2.14828029e-02f, -4.29373123e-02f,
  -5.81092872e-02f, -1.25288904e-01f, -5.36454879e-02f, -6.24605902e-02f, -4.06138748e-02f, -2.10575107e-02f, -2.36508697e-02f, -5.85115887e-02f, -2.65708882e-02f, -9.90145206e-02f,
  6.03166819e-02f, -9.21205990e-03f, -9.71796289e-02f, 3.65189984e-02f, 7.56099969e-02f, 7.23584518e-02f, -9.27101728e-03f, 2.79853716e-02f, 7.83900023e-02f, 1.57545805e-01f,
  1.14756107e-01f, -1.97584983e-02f, 1.38377726e-01f, -1.80533916e-01f, -5.79047063e-03f, -2.68561877e-02f, 1.14118233e-01f, 1.46958351e-01f, 4.15359698e-02f, 5.57101853e-02f,
  2.54825532e-01f, -1.50630280e-01f, 5.85750975e-02f, 1.90964967e-01f, 9.83624756e-02f, 1.26004934e-01f, -8.27432871e-02f, -6.78597316e-02f, -1.48116751e-02f, 1.10541724e-01f,
  1.19600162e-01f, -1.47031456e-01f, -1.73378345e-02f, 1.47906661e-01f, 1.96415007e-01f, -2.30874792e-02f, 5.79642765e-02f, 9.12316516e-02f, 6.15727296e-03f, 8.76566395e-02f,
  2.19080038e-02f, 4.41198312e-02f, 8.54498148e-02f, 1.86839178e-01f, 1.13108851e-01f, -2.03622267e-01f, 7.85311908e-02f, 1.40261546e-01f, 3.92350974e-03f, -7.19594676e-03f,
  9.49908048e-02f, 4.17543501e-02f, 2.18602177e-02f, 9.95552912e-02f, 2.19281837e-02f, 1.27134115e-01f, 3.12155187e-02f, 1.51968837e-01f, 6.71341196e-02f, 1.90626811e-02f,
  -9.67986509e-03f, 1.00974910e-01f, 3.72233540e-02f, 8.88273343e-02f, -9.01307259e-03f, 1.49779886e-01f, 1.39402702e-01f, -5.86054996e-02f, -3.56514715e-02f, 5.30992374e-02f,
  8.03858042e-02f, 1.54477090e-01f, -9.70845073e-02f, -1.64546147e-01f, -8.25327411e-02f, 6.81521967e-02f, -7.17071891e-02f, 1.96065143e-01f, 1.36955217e-01f, 6.90775365e-02f,
  -3.72144803e-02f, -2.47095972e-02f, -9.47464928e-02f, 9.01303068e-02f, -1.97123975e-01f, 4.07074355e-02f, -1.05287902e-01f, -1.58414006e-01f, 4.57694009e-02f, -7.53771216e-02f,
  -1.46166738e-02f, 1.41998887e-01f, -1.04204163e-01f, -1.55894428e-01f, -6.71833679e-02f, 1.09765179e-01f, 9.92538035e-02f, 6.73447475e-02f, -1.20771706e-01f, -1.34430125e-01f,
  1.74266249e-01f, -8.92963260e-02f, 1.25596032e-01f, -6.91652372e-02f, -1.65682975e-02f, 1.67044640e-01f, 2.33227778e-02f, -6.52733296e-02f, 1.19538136e-01f, -1.86252908e-03f,
  -5.59713542e-02f, 9.93153304e-02f, -4.80618067e-02f, -1.51438555e-02f, 1.08670834e-02f, -4.54499014e-02f, -4.51790355e-02f, 5.48849553e-02f, 5.80409076e-03f, -1.83414742e-02f,
  -7.19847307e-02f, 9.77887679e-03f, 3.07215806e-02f, -1.62592232e-02f, 6.58011856e-03f, -8.58405780e-04f, 2.53174193e-02f, 1.86892301e-02f, -6.45606071e-02f, 5.85439689e-02f,
  1.45422325e-01f, 9.28067043e-03f, 3.93714607e-02f, -8.12034458e-02f, -6.89414889e-02f, 3.45805362e-02f, -4.65431772e-02f, -5.29396161e-02f, -7.00799972e-02f, 1.57871321e-01f,
  -3.12700570e-02f, 1.23908460e-01f, -1.33264177e-02f, -1.61664784e-01f, -6.55226335e-02f, -1.43042058e-01f, 4.46627736e-02f, -1.32655039e-01f, -6.03626063e-03f, 9.57521573e-02f,
  -6.09294185e-03f, -6.98181540e-02f, -9.69416127e-02f, 1.91829950e-01f, 4.99151871e-02f, -1.43036529e-01f, 1.65191248e-01f, -6.05988652e-02f, -5.70846722e-02f, 1.16603412e-01f,
  2.56249845e-01f, -4.01561558e-02f, -5.94388321e-02f, 3.22287041e-03f, 6.52508512e-02f, -3.15644853e-02f, -2.30665635e-02f, 1.86467953e-02f, -2.18203172e-01f, -1.19659059e-01f,
  -1.25591382e-01f, -4.12865318e-02f, -1.37473419e-01f, 1.48522973e-01f, -8.57731774e-02f, 2.57964265e-02f, -8.64412263e-02f, 2.63631959e-02f, 3.16331983e-02f, 3.64031713e-03f,
  1.56732667e-02f, -6.58440217e-02f, -5.54053187e-02f, 6.39834478e-02f, -5.37941940e-02f, 3.48787382e-02f, 3.28886770e-02f, 2.63203643e-02f, -8.91081840e-02f, -3.62642668e-02f,
  -2.27126982e-02f, -3.03371027e-02f, 4.20841873e-02f, -1.45079717e-01f, 6.85684308e-02f, -2.83965608e-03f, 3.47126909e-02f, -2.78041903e-02f, 1.86204407e-02f, -1.16555363e-01f,
  -4.18886095e-02f, 1.31962635e-02f, 1.01246890e-02f, 1.50804780e-02f, -6.37615472e-02f, -3.13421153e-02f, -7.90320784e-02f, -1.54954448e-01f, -4.12888937e-02f, -1.90472886e-01f,
  1.01809070e-01f, -1.45074174e-01f, 1.24323837e-01f, 1.31346211e-01f, 6.11409321e-02f, -4.50377762e-02f, -7.51693472e-02f, 3.42080519e-02f, 6.26783893e-02f, -1.59936160e-01f,
  1.85337842e-01f, -5.16734347e-02f, -3.36145759e-02f, 4.34714295e-02f, 1.90331250e-01f, -1.34420514e-01f, -5.28323762e-02f, 1.83444723e-01f, -1.21010877e-01f, -6.12961426e-02f,
  -1.67113200e-01f, 1.11893564e-01f, -5.54999672e-02f, -8.28485787e-02f, -1.60509631e-01f, 1.38277352e-01f, -1.95433959e-01f, 1.46350637e-01f, -5.72019219e-02f, 5.44808321e-02f,
  1.19930285e-03f, -4.45683394e-03f, -1.55988827e-01f, 3.23129594e-02f, -5.63857332e-02f, -4.26293351e-02f, -9.59521011e-02f, -1.94782503e-02f, 1.90328073e-03f, 8.66834745e-02f,
  -7.75350183e-02f, 9.78870243e-02f, -5.35733290e-02f, 3.72433849e-02f, -7.53430501e-02f, 1.27193749e-01f, -5.29173315e-02f, 2.05645844e-01f, -8.92205387e-02f, -1.63256809e-01f,
  -2.61213761e-02f, 5.76040931e-02f, -2.23656688e-02f, -2.26171166e-02f, -1.64026901e-01f, 1.05285924e-02f, 2.18249951e-02f, 2.42340341e-02f, 2.44948398e-02f, 3.32307890e-02f,
  2.13315234e-01f, 9.98928100e-02f, 4.37915288e-02f, -1.70776561e-01f, 2.03895003e-01f, -2.63280142e-03f, -4.86767516e-02f, 1.65759742e-01f, -3.46497037e-02f, -4.30226279e-03f,
  -9.75240394e-02f, -6.61855340e-02f, -2.10046805e-02f, 9.64008719e-02f, -5.48480712e-02f, -7.61230737e-02f, -1.05540484e-01f, 7.38796517e-02f, 1.18055537e-01f, -5.16142100e-02f,
  -5.60852140e-02f, -3.21993940e-02f, -4.59276401e-02f, -1.61408365e-01f, -7.63834193e-02f, -1.22318476e-01f, 2.14703470e-01f, 1.02910914e-01f, 1.21256746e-01f, -2.24871591e-01f,
  -7.75264129e-02f, -4.02176231e-02f, 9.84734297e-02f, -6.51880726e-02f, -6.04673140e-02f, -4.34217267e-02f, 8.67407992e-02f, 6.88011572e-02f, -7.94957764e-03f, -2.26876326e-02f,
  1.32547282e-02f, -1.80481654e-02f, 4.03117202e-02f, -4.46608849e-02f, 7.12821027e-03f, 3.76746873e-03f, 8.54669437e-02f, 1.60438251e-02f, 6.54248744e-02f, -1.63238831e-02f,
  1.61213870e-03f, -1.38399899e-01f, 5.57299927e-02f, 5.35452440e-02f, -5.88007122e-02f, 3.18171941e-02f, 7.72691146e-02f, -1.39618039e-01f, 1.29230201e-01f, 1.66854076e-02f,
  -4.12084162e-02f, -1.70013104e-02f, 2.47143786e-02f, -2.66658310e-02f, -1.93038806e-01f, -8.84205624e-02f, -7.10453242e-02f, 9.59611163e-02f, -1.70774177e-01f, 5.03170229e-02f,
  -3.41407284e-02f, -1.11074932e-01f, 6.18192479e-02f, -1.30366031e-02f, -4.02283967e-02f, -4.78384458e-02f, -1.21389143e-02f, -1.07573107e-01f, -5.46628237e-02f, 1.00013152e-01f,
  -5.06398566e-02f, -6.75362721e-02f, -1.80774406e-01f, -2.78499313e-02f, -1.09817060e-02f, 7.08864406e-02f, -2.25428388e-01f, 1.22742288e-01f, -7.22099841e-02f, 1.16516985e-01f,
  -8.05791765e-02f, 8.64833146e-02f, -4.06798767e-03f, 7.58370757e-02f, 6.21812865e-02f, -3.26870568e-02f, 7.11178929e-02f, 5.13798036e-02f, -1.08792923e-01f, -1.10445008e-01f,
  -5.45878597e-02f, 1.29993170e-01f, 4.07537222e-02f, 4.09857593e-02f, 1.21324077e-01f, 8.32640901e-02f, 1.03789501e-01f, 8.14624969e-03f, 8.32991861e-03f, 1.13191362e-02f,
  9.60919857e-02f, 1.45748720e-01f, 3.27423476e-02f, 1.09162450e-01f, -1.28426505e-02f, 4.13733907e-02f, -2.77480036e-02f, 5.02546020e-02f, -4.04157862e-02f, 4.42581736e-02f,
  8.08618367e-02f, -2.27058288e-02f, -8.62330720e-02f, -1.24705322e-01f, -1.34937838e-01f, -5.70301572e-03f, -5.81355616e-02f, 1.66865572e-01f, 3.42316143e-02f, 9.01412442e-02f,
  -2.63432972e-02f, -2.16474966e-03f, -1.24007344e-01f, 6.30085766e-02f, -2.31114179e-01f, 3.84310819e-02f, 2.12553721e-02f, -1.91515043e-01f, -4.65027876e-02f, -2.39484116e-01f,
  -4.86990856e-03f, 6.14152104e-02f, -7.37575218e-02f, -5.99808320e-02f, -1.39685512e-01f, 2.17243731e-02f, -4.92987074e-02f, -1.13767155e-01f, -8.73112381e-02f, 2.51090853e-03f,
  -2.56999861e-02f, 1.05106801e-01f, 7.22071826e-02f, 3.31737138e-02f, 1.22099161e-01f, 1.56504214e-01f, 5.32120652e-02f, -2.03861386e-01f, -2.18364764e-02f, 1.42726749e-01f,
  2.51621623e-02f, 9.95919630e-02f, -3.01957466e-02f, 1.09782092e-01f, -8.49969778e-03f, 1.30602449e-01f, -9.39723030e-02f, -6.00635894e-02f, -4.37994301e-02f, 1.03774220e-01f,
  2.77032331e-02f, 6.61383048e-02f, -6.79803640e-02f, 4.65082228e-02f, 1.46837784e-02f, 3.48936655e-02f, 3.93416137e-02f, 3.28455716e-02f, -7.58334622e-02f, -7.90857673e-02f,
  4.19223029e-03f, -6.98874667e-02f, -6.85188770e-02f, 1.29526295e-02f, 3.87055725e-02f, -1.40280589e-01f, -3.44101451e-02f, -6.66055530e-02f, 2.31527742e-02f, -9.41346809e-02f,
  -1.18429720e-01f, 8.73586163e-02f, 7.54502490e-02f, -2.08292585e-02f, -4.18971330e-02f, -1.45368159e-01f, 1.50855914e-01f, -9.23786964e-03f, -6.63426518e-02f, 1.16870344e-01f,
  4.41664979e-02f, -1.57751068e-01f, -2.00706422e-02f, -1.95919007e-01f, 4.47563715e-02f, -2.90599349e-03f, 2.85914671e-02f, -1.57957133e-02f, -1.33000880e-01f, 1.54492944e-01f,
  2.08312780e-01f, -1.86360762e-01f, -1.75036326e-01f, 1.00897379e-01f, -2.01467544e-01f, 4.25987095e-02f, -1.19104400e-01f, -1.69684161e-02f, 1.57034978e-01f, 9.62786749e-03f,
  8.54822621e-02f, -2.94926334e-02f, -6.98731989e-02f, -1.50016637e-03f, 7.18455687e-02f, -4.46786396e-02f, 8.67754780e-03f, 8.55511576e-02f, 9.97345001e-02f, 1.00830622e-01f,
  -8.79226776e-04f, 8.80107563e-03f, -3.68535481e-02f, 4.03135754e-02f, 9.20979455e-02f, 1.03334159e-01f, -2.35897899e-02f, 5.88434674e-02f, 1.08923325e-02f, -3.41699719e-02f,
  4.04151343e-02f, 5.36492802e-02f, 6.22889586e-02f, -1.37840495e-01f, 2.06949022e-02f, -2.49433033e-02f, -6.01349100e-02f, 7.16044381e-02f, 9.50645357e-02f, -1.68650776e-01f,
  2.26097424e-02f, -3.84373590e-02f, 8.19644928e-02f, -1.61790714e-01f, -1.13390923e-01f, -3.45887383e-03f, -1.29563347e-01f, 2.17127241e-02f, -8.66053402e-02f, -8.72476101e-02f,
  1.63737256e-02f, 1.44947171e-01f, -4.09071445e-02f, 2.43962910e-02f, 1.53823020e-02f, -5.24122268e-02f, 9.18927044e-02f, -2.17313185e-01f, 4.75097634e-02f, 9.17166322e-02f,
  -5.69296330e-02f, -6.68696836e-02f, 1.94528401e-02f, 2.29783580e-02f, -2.98405420e-02f, -8.12558085e-03f, -2.21603420e-02f, 1.34709597e-01f, -1.37176573e-01f, 1.42847314e-01f,
  -9.24858376e-02f, -3.07966489e-03f, 8.14204514e-02f, 1.37474969e-01f, 1.19126260e-01f, 1.04299940e-01f, 3.33509920e-03f, -1.31430104e-01f, -3.26688662e-02f, -6.59235716e-02f,
  3.39207277e-02f, 5.32963276e-02f, -1.39139727e-01f, -5.42107783e-02f, -8.46152231e-02f, -3.46121006e-02f, -1.80157557e-01f, -1.43280074e-01f, 7.44801536e-02f, 1.40394447e-02f,
  -8.14655051e-02f, 4.19785082e-02f, -1.97309279e-03f, -1.07525088e-01f, 4.88749966e-02f, -4.89100851e-02f, -4.31990586e-02f, 6.76904097e-02f, -1.79537714e-01f, -1.42110839e-01f,
  -5.25351465e-02f, -1.07602999e-01f, 2.66992413e-02f, -4.62453393e-03f, -6.86208606e-02f, 1.36584371e-01f, 1.25126451e-01f, -3.24180797e-02f, 1.65196866e-01f, -2.37760514e-01f,
  1.91073164e-01f, 1.17864080e-01f, 1.51855528e-01f, 1.26731098e-01f, 7.32605979e-02f, 6.76734326e-03f, 4.12253030e-02f, -1.67576283e-01f, -3.63038108e-02f, 2.07671300e-01f,
  5.47093514e-04f, 2.72472459e-03f, -1.20672449e-01f, 1.32279336e-01f, -5.41477799e-02f, 1.36722580e-01f, 3.60983051e-02f, -6.75113825e-03f, -5.59432358e-02f, 8.87046531e-02f,
  -2.39991210e-03f, -1.62229896e-01f, 7.18806032e-03f, -1.79082781e-01f, -3.26179750e-02f, -2.80743111e-02f, 1.22999437e-01f, -6.50926381e-02f, 6.70040101e-02f, -7.77484179e-02f,
  3.37364897e-02f, -7.06059113e-02f, 2.74727903e-02f, 3.69418133e-03f, -3.72591205e-02f, 1.32375568e-01f, -1.96261909e-02f, 7.10264668e-02f, -1.19831357e-02f, -8.03047791e-02f,
  -4.34540994e-02f, 4.28243726e-02f, 2.48620342e-02f, 7.59988949e-02f, -7.02743419e-03f, -9.74072982e-03f, -4.49186228e-02f, -5.06145023e-02f, 1.09159224e-01f, 5.37557825e-02f,
  6.82582483e-02f, -1.17598586e-01f, 4.22858708e-02f, -1.95153505e-02f, -3.19342837e-02f, 1.09474901e-02f, 7.41916448e-02f, -9.38504264e-02f, -7.53905103e-02f, 4.48914096e-02f,
  8.68310630e-02f, -1.16133034e-01f, -9.81755182e-03f, 1.33243911e-02f, -3.55917737e-02f, -3.60592939e-02f, -6.46941215e-02f, -1.50120750e-01f, 1.92786843e-01f, -5.77836707e-02f,
  1.51697695e-01f, 1.33268833e-01f, 2.79990137e-02f, -7.10345507e-02f, -4.45938855e-02f, -9.83904153e-02f, 4.17062715e-02f, -4.45902236e-02f, 1.32287249e-01f, 2.73162848e-03f,
  -4.99248914e-02f, 1.54045150e-01f, 2.05309764e-01f, -1.35087997e-01f, -8.40425566e-02f, 1.63618669e-01f, -1.54861763e-01f, -5.43688647e-02f, -1.37936071e-01f, 9.43764448e-02f,
  6.45006076e-02f, -1.60263583e-01f, 7.13740587e-02f, 6.40570372e-02f, -1.60310820e-01f, 1.13228792e-02f, 1.45848185e-01f, 9.57580283e-02f, -9.76916552e-02f, -6.36625011e-03f,
  1.56274036e-01f, -2.69108750e-02f, 9.07616317e-02f, 7.50165433e-02f, 1.17401347e-01f, 4.42846529e-02f, 9.22628194e-02f, 2.73813307e-02f, 8.61478820e-02f, -6.41234219e-02f,
  9.65406075e-02f, 3.28698126e-03f, 9.59780961e-02f, -2.71362718e-02f, 1.37985582e-02f, -1.65581182e-01f, 1.46818578e-01f, 1.68089509e-01f, -7.03903660e-02f, -4.70382199e-02f,
  7.72522390e-02f, 7.54778609e-02f, 8.67249817e-03f, -1.38899535e-01f, -4.01337892e-02f, -7.30398148e-02f, -7.01836497e-02f, 1.06979534e-01f, -1.54222220e-01f, -1.43410619e-02f,
  -1.07830264e-01f, 1.33478776e-01f, -1.30744308e-01f, 1.95276905e-02f, -3.73750925e-02f, -6.27525523e-02f, -9.86279827e-03f, -7.93996602e-02f, 2.09365529e-03f, -4.40128893e-02f,
  1.40308775e-02f, 9.33475676e-04f, -3.34674269e-02f, 2.15472206e-02f, 1.70345716e-02f, 1.27183974e-01f, -1.10964507e-01f, -1.64390411e-02f, -1.60115093e-01f, 1.03855200e-01f,
  -4.78169434e-02f, 7.10656941e-02f, 1.15514420e-01f, 1.23441249e-01f, -1.67737961e-01f, -1.63650230e-01f, -1.67036325e-01f, 5.73320091e-02f, 8.96040499e-02f, 1.34288296e-01f,
  -4.74583209e-02f, -1.06573198e-02f, -3.75340916e-02f, -1.30024806e-01f, 7.41084665e-03f, -9.24153402e-02f, -9.21431184e-02f, 1.66602284e-02f, -2.23104027e-03f, -6.36963770e-02f,
  1.44365681e-02f, -1.02149730e-03f, -4.38717008e-02f, -5.54005802e-02f, -5.16862571e-02f, -3.79686095e-02f, -3.34912091e-02f, -3.15087214e-02f, 4.75152656e-02f, 4.70257923e-02f,
  -9.17534083e-02f, -6.04901789e-03f, 5.36184534e-02f, -9.51659456e-02f, 3.52845080e-02f, 7.93503076e-02f, -8.27401876e-02f, -1.34731783e-02f, -3.43957916e-02f, 1.12987719e-02f,
  1.21144243e-01f, -7.12982565e-02f, 1.10802516e-01f, 1.71162263e-01f, 1.36480913e-01f, 6.89831674e-02f, -4.05366719e-02f, -1.13513499e-01f, -4.58086766e-02f, 4.21528792e-04f,
  -6.33955374e-02f, 1.54978663e-01f, -6.70679808e-02f, 8.23636204e-02f, -8.93156007e-02f, 6.94556981e-02f, -8.55154619e-02f, 5.64398281e-02f, 8.53470042e-02f, 1.12371951e-01f,
  1.04824966e-02f, 1.90512374e-01f, -2.79844869e-02f, -8.84069428e-02f, 2.11344302e-01f, -2.08136871e-01f, 1.21630147e-01f, -4.79335822e-02f, -8.42361674e-02f, -2.08775580e-01f,
  8.76768529e-02f, -2.03212261e-01f, 7.53882080e-02f, 1.31118774e-01f, -1.02931568e-02f, -6.65078089e-02f, -1.17121853e-01f, -8.33289772e-02f, 6.45134076e-02f, -9.29131210e-02f,
  -5.24955355e-02f, -8.25526472e-03f, 7.56308809e-02f, -3.94713730e-02f, 1.00584157e-01f, 1.68110039e-02f, 7.51417428e-02f, -7.34765604e-02f, 4.60430495e-02f, 1.11811515e-03f,
  9.91918333e-03f, 7.76018798e-02f, -1.05352312e-01f, -5.13361879e-02f, 4.82132882e-02f, 2.56022736e-02f, 3.60264257e-02f, -1.56157147e-02f, 4.99137584e-03f, -7.76654631e-02f,
  4.92899232e-02f, -4.90791500e-02f, -2.02968702e-01f, 1.00771442e-01f, -1.39162615e-01f, 9.67641994e-02f, 4.60577803e-03f, -6.96420297e-02f, -2.45988537e-02f, 1.87749684e-01f,
  -2.01856554e-01f, -1.45394042e-01f, -2.03078851e-01f, -1.01537459e-01f, 4.65533957e-02f, -1.19779266e-01f, -1.05826527e-01f, -1.14136368e-01f, -1.24991210e-02f, -4.75924723e-02f,
  -8.87148306e-02f, 4.23634164e-02f, 8.13747495e-02f, -4.88025621e-02f, -1.28581494e-01f, 8.50406811e-02f, -3.16427611e-02f, -6.33433182e-03f, 1.03185348e-01f, 7.80926421e-02f,
  -4.45227996e-02f, 9.43306983e-02f, -1.19861066e-01f, 7.08325282e-02f, -1.21128470e-01f, -4.82614152e-02f, 5.55057861e-02f, 1.12430647e-01f, 1.24256074e-01f, -3.31513099e-02f,
  9.80515704e-02f, 8.03302750e-02f, -2.51216572e-02f, 2.60528945e-03f, 2.31379028e-02f, -4.32382636e-02f, -6.06551580e-02f, -7.45928660e-02f, 1.26006410e-01f, 3.36442925e-02f,
  -6.47791699e-02f, 3.27837057e-02f, 4.97937687e-02f, -9.39206854e-02f, 3.71521153e-02f, 3.52973351e-03f, 2.46752277e-02f, -1.35022886e-02f, -1.61383271e-01f, -2.56213732e-02f,
  -3.12342383e-02f, 3.28284539e-02f, 9.24770385e-02f, -8.62951949e-02f, 1.40704196e-02f, 1.22897014e-01f, 1.22352578e-01f, -1.64101824e-01f, 7.30618685e-02f, -1.38020515e-01f,
  8.14186409e-02f, 1.38911158e-01f, 8.05362538e-02f, 1.48758888e-01f, 5.64337447e-02f, 1.21017344e-01f, 4.80699092e-02f, -1.19896777e-01f, -4.30596732e-02f, 1.09695829e-01f,
  8.50905702e-02f, -1.81671754e-01f, 9.38960351e-03f, 1.02053545e-01f, -1.26267835e-01f, 5.23590669e-02f, 6.20715357e-02f, -3.16432901e-02f, -7.34289140e-02f, 8.42621252e-02f,
  5.73200658e-02f, 6.80508697e-03f, -3.55932303e-02f, 8.44421759e-02f, -1.30694807e-01f, 6.11259229e-02f, 2.48254716e-01f, 9.22544003e-02f, 1.59633085e-01f, -2.88948864e-02f,
  7.30757490e-02f, -1.40092418e-01f, -7.93310925e-02f, -9.92477015e-02f, 1.33983195e-02f, 1.15608171e-01f, -5.77359311e-02f, 1.15389444e-01f, 9.02660936e-03f, -9.79643501e-03f,
  -1.35783464e-01f, -8.20261762e-02f, -6.50159568e-02f, -2.68763006e-02f, -7.23271742e-02f, 3.96936610e-02f, -2.94799693e-02f, -3.75664560e-03f, -2.97168009e-02f, -9.59249362e-02f,
  1.05810329e-01f, 3.17924842e-02f, 1.39965732e-02f, -1.56008258e-01f, 3.70885734e-03f, 5.37957586e-02f, -6.85114041e-02f, -6.46548346e-02f, 2.93126609e-02f, 9.44369361e-02f,
  1.93110272e-01f, -9.50834081e-02f, 1.77659333e-01f, -1.97150663e-01f, -1.00175761e-01f, -1.27101745e-02f, 2.01309994e-02f, -1.94079086e-01f, 2.06677154e-01f, 1.29668623e-01f,
  1.38821065e-01f, 5.12350164e-02f, -2.29157098e-02f, 1.90276146e-01f, 7.52970129e-02f, 1.74899593e-01f, -4.45617810e-02f, -1.03089623e-01f, 9.74977389e-02f, 5.73603697e-02f,
  -4.57333289e-02f, -2.26911716e-02f, 1.40543640e-01f, 4.68077213e-02f, 1.54115617e-01f, 2.39888653e-02f, -1.55912787e-01f, -8.93588737e-02f, -3.76751013e-02f, 4.11128346e-03f,
  -1.54168829e-02f, 3.18435282e-02f, 4.25265618e-02f, 1.89584494e-01f, 1.78008266e-02f, -1.49560958e-01f, 1.91432923e-01f, 1.06113560e-01f, -6.63821027e-02f, 1.06326051e-01f,
  2.04711240e-02f, 9.11852121e-02f, -6.39770553e-03f, 9.74177271e-02f, -1.17541514e-02f, -7.37967193e-02f, 1.44633383e-01f, -3.16847228e-02f, -5.45194931e-02f, -4.80492637e-02f,
  4.49121557e-02f, 2.17917971e-02f, 1.64985448e-01f, 2.18765456e-02f, -9.92797241e-02f, 3.60153057e-02f, -1.15307502e-01f, 8.82251188e-03f, -2.37408318e-02f, -4.83132526e-02f,
  1.59743667e-01f, 3.32327932e-02f, -9.76628587e-02f, 1.53254271e-02f, 3.42718475e-02f, -1.28755733e-01f, 5.93652427e-02f, 3.01480200e-02f, 1.79873556e-01f, 5.89872487e-02f,
  7.14425221e-02f, 1.22336924e-01f, 8.38042516e-03f, 4.71718162e-02f, 9.12163034e-03f, -1.02530487e-01f, -6.08511902e-02f, -7.43037313e-02f, -1.09028094e-01f, -4.02651913e-02f,
  -3.74092311e-02f, 7.42499977e-02f, -8.07636231e-02f, 1.55543491e-01f, -1.59933567e-01f, 7.46357888e-02f, -6.74811304e-02f, 7.91952759e-03f, -2.56794572e-01f, -2.40104832e-02f,
  -1.15494080e-01f, -1.54904827e-01f, 3.00885029e-02f, -4.98962477e-02f, 1.69891611e-01f, -5.95692603e-04f, -3.93909700e-02f, -1.08627401e-01f, 1.04043074e-01f, 4.30387408e-02f
};

// L2_fan_Wp_bar (Shape: 14 x 64)
const int L2_fan_Wp_bar_rows = 14;
const int L2_fan_Wp_bar_cols = 64;
const float L2_fan_Wp_bar_data[] = {
  2.51601040e-01f, 9.33655128e-02f, 3.83899361e-02f, -6.02583922e-02f, 1.04257703e-01f, 4.94176112e-02f, 7.82043040e-02f, 6.23556003e-02f, 8.35099816e-02f, 2.67149806e-02f,
  2.50018179e-01f, 5.49581163e-02f, 6.08386025e-02f, -6.64003491e-02f, 1.94744349e-01f, -2.96709985e-02f, 1.65094629e-01f, 8.00951123e-02f, 6.60229400e-02f, -1.07717840e-02f,
  -4.22061831e-02f, 2.45511040e-01f, 4.97809127e-02f, 1.25244841e-01f, 1.91665933e-01f, -5.01042865e-02f, 6.36466742e-02f, -3.79418246e-02f, -1.62513301e-01f, -7.97298700e-02f,
  -9.02298167e-02f, 1.35117531e-01f, -2.37409561e-03f, 3.60099338e-02f, 6.89993575e-02f, 3.12167645e-01f, -1.45467430e-01f, 9.85945296e-03f, -1.34521872e-01f, -1.82599351e-01f,
  1.32595643e-01f, -1.87757716e-01f, -4.51888293e-02f, -3.57157826e-01f, 1.29184369e-02f, -2.70500779e-03f, -1.73454031e-01f, 3.49362455e-02f, -7.20683411e-02f, -9.20833200e-02f,
  -2.14647010e-01f, -1.58251062e-01f, -1.12833843e-01f, 7.26480410e-02f, -4.98748980e-02f, 3.40223253e-01f, 4.91887890e-02f, 2.92754203e-01f, 3.97086889e-01f, 1.69892624e-01f,
  5.85775822e-02f, -1.55542325e-02f, 1.83682844e-01f, 1.16508424e-01f, 3.89568321e-02f, 1.00977957e-01f, -3.17253098e-02f, 1.04786649e-01f, 3.79237160e-02f, -1.17117941e-01f,
  -1.24049392e-02f, 6.71669468e-02f, -2.09605042e-02f, -1.01759173e-02f, 3.67303342e-02f, -2.86551602e-02f, 6.79702982e-02f, -9.20016244e-02f, 8.44812095e-02f, -3.62778716e-02f,
  6.94551915e-02f, 1.01494797e-01f, -1.61895789e-02f, 1.09453820e-01f, -8.43489543e-02f, 3.34090367e-02f, 9.75163281e-02f, -4.29097340e-02f, 1.23464711e-01f, 1.88773572e-01f,
  -1.03990011e-01f, 6.62271455e-02f, -2.78423503e-02f, 1.10260040e-01f, 1.91540524e-01f, -2.58292630e-02f, 2.08768159e-01f, 9.10334103e-03f, 2.04913825e-01f, 2.40291253e-01f,
  -1.79412623e-03f, -2.08598018e-01f, 2.60254256e-02f, -1.53004348e-01f, 1.41376462e-02f, -3.41376057e-03f, -1.55361950e-01f, 1.62479118e-01f, -3.73156853e-02f, -6.14399510e-03f,
  7.15682656e-02f, 1.85331568e-01f, -1.84399057e-02f, 6.21920638e-02f, 2.51336038e-01f, 1.40364230e-01f, -1.35847226e-01f, -2.15545133e-01f, 3.35507691e-01f, -2.65662909e-01f,
  2.11452022e-01f, 1.90546110e-01f, 7.98437372e-02f, -2.42465332e-01f, -6.84944615e-02f, -1.40195295e-01f, 1.95765108e-01f, 2.95682669e-01f, 4.50618565e-03f, 1.43917456e-01f,
  5.61732333e-03f, 1.11013710e-01f, 1.32008493e-01f, 1.84048638e-01f, 6.02887236e-02f, 5.26926965e-02f, -2.69621201e-02f, 1.51870668e-01f, 4.80711982e-02f, 1.05184123e-01f,
  1.04746133e-01f, 5.57520986e-02f, 9.37643796e-02f, 3.62454653e-02f, 1.49794102e-01f, -1.75348353e-02f, 5.69941960e-02f, -2.05494747e-01f, 2.49082685e-01f, 1.03952445e-01f,
  5.73416948e-02f, 3.57395522e-02f, 1.53383479e-01f, 9.81753133e-03f, 4.08881158e-02f, -7.22644478e-02f, -6.41555563e-02f, 5.40612303e-02f, -5.91243245e-02f, 6.90201148e-02f,
  -2.50875592e-01f, -2.36861676e-01f, -1.58214182e-01f, -9.84710753e-02f, -4.31287382e-03f, -4.24540006e-02f, 8.58966708e-02f, 1.11430436e-01f, 1.52177274e-01f, -9.37894955e-02f,
  9.19286013e-02f, 8.29044804e-02f, 1.63760126e-01f, -2.24640593e-01f, 2.11282715e-01f, -6.70108944e-02f, -1.04654126e-01f, 1.67338520e-01f, 3.41504514e-01f, -1.30812809e-01f,
  -1.49680853e-01f, 3.03999364e-01f, -6.98698387e-02f, 2.12537214e-01f, -2.74852943e-02f, 4.06390369e-01f, -2.13619456e-01f, -2.26857051e-01f, -9.11201462e-02f, 3.42547208e-01f,
  -3.78690772e-02f, 3.41577888e-01f, 4.73155789e-02f, 1.61965396e-02f, 1.38290346e-01f, 1.02616996e-01f, -1.48987928e-02f, 1.18235052e-01f, 1.86592996e-01f, 2.06162259e-02f,
  6.38909116e-02f, 1.00892849e-01f, 1.25084650e-02f, -1.29098194e-02f, -1.20920278e-01f, 6.82571754e-02f, 4.15815711e-02f, 7.51772299e-02f, 7.98303634e-02f, -1.86231166e-01f,
  2.38440976e-01f, -5.24531715e-02f, -1.14679515e-01f, 1.61901399e-01f, 8.60711709e-02f, 1.86316162e-01f, -2.74677314e-02f, 1.39491245e-01f, -1.57692537e-01f, -5.31849228e-02f,
  3.39281082e-01f, -3.63929838e-01f, 1.45212829e-01f, -1.44268632e-01f, 9.53254104e-02f, 1.92873359e-01f, 8.34614635e-02f, -2.49411702e-01f, 2.95981050e-01f, 3.39638740e-01f,
  3.24636549e-01f, 1.80430487e-01f, -2.02180922e-01f, 1.51650146e-01f, 2.28108793e-01f, -7.71248862e-02f, 1.36764362e-01f, 2.55680144e-01f, 7.10360929e-02f, -8.32322389e-02f,
  1.06586903e-01f, 2.31056556e-01f, 5.46491556e-02f, -3.44854556e-02f, 1.84416682e-01f, 4.37394917e-01f, 2.32610762e-01f, 2.19565965e-02f, 2.72425771e-01f, -8.18137228e-02f,
  3.39839458e-01f, -1.90773442e-01f, 4.53313082e-01f, 3.09919685e-01f, -1.21817194e-01f, -2.07498297e-01f, 8.74290913e-02f, 8.11544135e-02f, 6.06679246e-02f, 8.30395818e-02f,
  6.53893501e-02f, -5.40041104e-02f, -7.18877912e-02f, -2.52195280e-02f, -2.78761759e-02f, -1.73348367e-01f, 1.00338586e-01f, 8.20018426e-02f, 5.81156984e-02f, -1.75941978e-02f,
  8.84647816e-02f, 6.71748817e-02f, -8.37674551e-03f, 2.98723839e-02f, 8.15258399e-02f, 2.47042160e-02f, 2.46231146e-02f, -1.24147028e-01f, 4.38060099e-03f, -2.83991024e-02f,
  5.59275262e-02f, 1.83872599e-02f, -2.43836027e-02f, 5.97828440e-02f, 5.55714853e-02f, 4.01186831e-02f, 2.21432969e-01f, -2.38980055e-01f, 8.22424367e-02f, 9.39192325e-02f,
  1.21693790e-01f, 2.07077846e-01f, -1.73685774e-01f, -6.39357194e-02f, -1.26003951e-01f, -2.73777843e-01f, -1.44024909e-01f, 2.83129245e-01f, 1.12180179e-02f, 1.32971495e-01f,
  -1.84163034e-01f, 5.62120304e-02f, -1.91888690e-01f, 2.39639178e-01f, 8.87516662e-02f, 6.73505291e-02f, -1.11478306e-01f, 4.97676820e-01f, 1.60589010e-01f, -2.41419107e-01f,
  1.80961460e-01f, -2.29081407e-01f, 2.07939535e-01f, -6.65471926e-02f, 7.38075450e-02f, 1.96092539e-02f, 2.74698824e-01f, 1.30309991e-03f, 3.69531631e-01f, 1.93817794e-01f,
  1.30389661e-01f, 1.04845591e-01f, 2.49554589e-01f, 2.81021386e-01f, 1.04333043e-01f, 2.49707863e-01f, 7.84799308e-02f, 4.44259457e-02f, -1.20427711e-02f, 1.50437310e-01f,
  4.16220538e-02f, 2.47243896e-01f, -2.10509938e-03f, 1.78839043e-01f, 1.52132839e-01f, 1.39616176e-01f, 2.08012536e-01f, 1.22015812e-01f, 3.92276933e-03f, 6.05490170e-02f,
  1.41567603e-01f, -9.62761045e-03f, -4.45718728e-02f, 5.55536561e-02f, 1.57952905e-01f, -9.16277096e-02f, 8.99642408e-02f, -1.72886662e-02f, 1.05597220e-01f, -5.45577146e-02f,
  -9.84986350e-02f, 2.73876823e-02f, -5.46570048e-02f, -1.57484915e-02f, -6.41529972e-04f, -8.98416562e-04f, 3.00209560e-02f, 3.37482244e-01f, -9.82353687e-02f, -8.39295387e-02f,
  2.36606393e-02f, -1.19800657e-01f, 1.72994822e-01f, -2.25035846e-01f, 3.37297618e-02f, 4.13737260e-02f, -1.91457987e-01f, -4.43696231e-02f, -2.51886249e-01f, -8.77041835e-03f,
  5.63947633e-02f, 3.01785301e-02f, 3.35772410e-02f, -3.93511765e-02f, -1.62324503e-01f, 2.59942472e-01f, 1.49917910e-02f, -8.30113292e-02f, 3.22157264e-01f, 4.68185604e-01f,
  2.66404092e-01f, 2.01076478e-01f, 2.34095529e-01f, -2.95319080e-01f, 1.74378708e-01f, -2.73163486e-02f, 1.47551030e-01f, 2.28707358e-01f, 7.80335963e-02f, 3.40828039e-02f,
  2.01740339e-01f, 2.20454946e-01f, -6.85871169e-02f, -3.73841040e-02f, -4.50929739e-02f, -3.88798527e-02f, 1.39263839e-01f, 1.85117237e-02f, 1.35505483e-01f, 3.65969986e-02f,
  2.88770169e-01f, 5.70594519e-02f, 5.17685190e-02f, 1.51082620e-01f, 2.00497150e-01f, -2.85001788e-02f, 6.28900602e-02f, 3.02453283e-02f, 1.42654210e-01f, 2.52343565e-02f,
  3.61516714e-01f, 2.51345724e-01f, 5.80421090e-02f, 2.68067688e-01f, 2.09101602e-01f, -1.04402229e-01f, -2.16247454e-01f, -3.93779457e-01f, 1.98187947e-01f, 2.63168335e-01f,
  1.80756953e-02f, 8.83211568e-02f, 2.82375336e-01f, -2.77530134e-01f, 2.72332489e-01f, 9.81186181e-02f, -3.68185714e-02f, 3.64225507e-01f, 3.70847248e-02f, -3.92208487e-01f,
  6.77790716e-02f, 1.70427456e-01f, -2.90012330e-01f, -3.98677021e-01f, 3.47628266e-01f, 1.42543130e-02f, 2.72271901e-01f, -2.41797537e-01f, -1.95714280e-01f, 2.31820539e-01f,
  8.75926986e-02f, 2.85268813e-01f, 8.85155518e-03f, 4.39099997e-01f, 8.66926089e-02f, 6.32618546e-01f, 2.46407866e-01f, -1.24820158e-01f, 6.58397526e-02f, 1.10265784e-01f,
  2.06624586e-02f, -1.10427439e-02f, -1.15050197e-01f, 5.89565262e-02f, 6.45409897e-02f, 7.25258291e-02f, 1.20285772e-01f, 1.07116595e-01f, 1.08352736e-01f, 5.65160736e-02f,
  4.48978618e-02f, 1.00073203e-01f, 9.75549296e-02f, 1.32236004e-01f, 1.39825106e-01f, 2.98918664e-01f, -2.22679004e-01f, 3.83074701e-01f, -8.97693411e-02f, -1.04492940e-02f,
  6.68404028e-02f, 4.11947258e-02f, 3.81251723e-02f, 1.53053477e-02f, -6.63104951e-02f, -9.58418846e-02f, -2.27367222e-01f, 2.61617273e-01f, -1.47318438e-01f, 2.60233551e-01f,
  3.89320403e-01f, -5.20340018e-02f, 8.55342597e-02f, 9.48403627e-02f, 8.31056982e-02f, -8.33760574e-02f, -2.68892109e-01f, 6.74092993e-02f, 9.84092057e-02f, -3.09103757e-01f,
  -2.19205290e-01f, -1.37121394e-01f, 4.85765599e-02f, 5.11696413e-02f, -2.73426175e-02f, -2.01502685e-02f, -2.95297086e-01f, -3.14746201e-02f, 3.87121469e-01f, -1.93194255e-01f,
  -1.85867235e-01f, -1.49109915e-01f, 9.52778757e-02f, 1.40676215e-01f, -1.46012068e-01f, 8.26659650e-02f, 4.04174060e-01f, 3.10418814e-01f, -4.81704995e-02f, -3.04725409e-01f,
  1.15847677e-01f, 6.94673210e-02f, 1.30447298e-01f, 7.24867582e-02f, -7.41940215e-02f, 8.65892470e-02f, 8.38034675e-02f, -8.93723741e-02f, 3.43839712e-02f, 3.79218496e-02f,
  3.24466079e-02f, -1.74011499e-01f, 1.03952177e-01f, 5.62086478e-02f, 8.81122984e-03f, -9.05934814e-03f, 8.10475722e-02f, 1.17464490e-01f, 4.04211991e-02f, 3.06486115e-02f,
  2.66391300e-02f, 8.96138176e-02f, 1.47676812e-02f, -9.55592319e-02f, 3.36436518e-02f, 4.32082005e-02f, 1.11557007e-01f, -6.29961677e-03f, -4.04707156e-02f, -1.76518150e-02f,
  1.03948548e-01f, 3.66438888e-02f, 2.44513065e-01f, -2.18983218e-01f, 1.27361387e-01f, 1.74149394e-01f, 2.22620070e-01f, 2.59135664e-01f, -2.14715749e-01f, -3.60027142e-02f,
  -9.60618109e-02f, -2.60640740e-01f, -1.08338274e-01f, 1.88576669e-01f, -6.39636070e-02f, 1.34282336e-01f, -2.25437835e-01f, 4.61806804e-02f, -2.03288421e-01f, 2.48300493e-01f,
  -5.64026786e-03f, 6.75898641e-02f, -1.27977535e-01f, 3.55627686e-01f, 1.35012358e-01f, -2.02415794e-01f, 2.18602523e-01f, -1.54787704e-01f, 3.76510054e-01f, -8.31279233e-02f,
  1.39666557e-01f, 1.58202872e-01f, 2.96300620e-01f, -8.06244910e-02f, 2.70808160e-01f, 1.56120196e-01f, -1.16381899e-01f, -3.85245942e-02f, 3.82028818e-02f, -1.05449319e-01f,
  -4.05703671e-03f, -1.09177288e-02f, 1.23721942e-01f, 4.56821620e-02f, 6.11763075e-03f, 1.03733294e-01f, -9.31975916e-02f, -4.76446524e-02f, -4.50269841e-02f, -1.48926992e-02f,
  3.71278711e-02f, 1.38482302e-02f, -4.04164866e-02f, -1.23708896e-01f, 7.19562769e-02f, -1.89638417e-02f, -6.92045614e-02f, 1.93655074e-01f, 1.89329907e-01f, 6.99403435e-02f,
  -8.10229927e-02f, 1.75546318e-01f, -3.68364118e-02f, 1.19077507e-02f, 7.67531767e-02f, -8.41875002e-03f, 1.87575921e-01f, -8.76698494e-02f, 6.51773289e-02f, -2.93555465e-02f,
  1.32803485e-01f, -8.77446830e-02f, 1.56110674e-01f, -1.12128425e-02f, 3.21514219e-01f, 1.54336974e-01f, 1.74745563e-02f, 1.19905800e-01f, 4.27414440e-02f, 2.38850251e-01f,
  -6.39922079e-03f, -6.78888634e-02f, 2.38421157e-01f, 1.95525158e-02f, 1.06419198e-01f, 9.34751853e-02f, 3.27594191e-01f, -4.81615774e-02f, 2.57479072e-01f, 3.04789811e-01f,
  4.55713868e-01f, -6.86268210e-02f, 3.10671270e-01f, 3.76981020e-01f, -4.14104871e-02f, -2.86482036e-01f, 1.09764770e-01f, 2.52801538e-01f, -9.09046978e-02f, 2.41236493e-01f,
  -8.73195082e-02f, 1.11963607e-01f, 6.74421340e-02f, 4.93530259e-02f, 7.39988163e-02f, 1.36840791e-01f, -2.21309941e-02f, -1.25257438e-02f, 1.41306892e-01f, 2.76753604e-01f,
  -7.62411579e-02f, 1.53576955e-01f, 3.43814604e-02f, 1.29187807e-01f, 6.92532212e-02f, 1.17537253e-01f, 7.05291554e-02f, 7.73552582e-02f, 9.10595879e-02f, 5.64636476e-02f,
  1.10631786e-01f, 9.31491144e-03f, 1.04652166e-01f, 1.56709716e-01f, -6.48248419e-02f, 9.97252837e-02f, -1.38065279e-01f, -1.72298625e-01f, -4.36486863e-02f, -7.37483948e-02f,
  -2.51333147e-01f, 2.25397110e-01f, -6.88203424e-02f, -1.19090915e-01f, -1.74234435e-01f, -3.54523718e-01f, 1.58357322e-01f, 4.28754948e-02f, -1.21978119e-01f, 3.63641798e-01f,
  -9.78921354e-03f, -2.70523190e-01f, 1.89770877e-01f, -1.49716660e-01f, 2.16036618e-01f, 1.15847819e-01f, 1.40561670e-01f, -3.76504034e-01f, -6.34401366e-02f, 1.76046759e-01f,
  3.24174702e-01f, -2.35891372e-01f, -3.11705619e-02f, 3.72949988e-01f, 1.27177723e-02f, 2.62975305e-01f, -4.94187772e-02f, -6.76834807e-02f, 1.86270904e-02f, 9.70231369e-03f,
  3.98395546e-02f, 6.76329657e-02f, -2.20418781e-01f, 1.38129219e-01f, -2.25570146e-02f, 1.78333953e-01f, -3.28005515e-02f, 5.27153276e-02f, 2.06243634e-01f, 1.31392747e-01f,
  5.27819507e-02f, 1.84392169e-01f, 2.28843734e-01f, 1.24359727e-01f, -8.82929042e-02f, 1.18220918e-01f, 1.34620115e-01f, 2.05819551e-02f, 6.13601841e-02f, 2.05846995e-01f,
  4.05506641e-02f, 6.59190789e-02f, 8.14720616e-02f, 1.94400340e-01f, 1.23908699e-01f, 6.39039874e-02f, 1.00836784e-01f, -3.90589945e-02f, -5.55285960e-02f, 3.02649409e-01f,
  -1.95141360e-01f, -2.57173508e-01f, -1.63087174e-01f, 3.13529037e-02f, -1.13496311e-01f, 3.00686181e-01f, 7.49062374e-02f, 4.43326728e-03f, -9.12935957e-02f, -2.52676815e-01f,
  -1.17258467e-01f, -2.43722592e-02f, -2.14873314e-01f, 2.00250864e-01f, -1.86774746e-01f, -2.10352823e-01f, 1.13150612e-01f, 1.79428011e-01f, 1.68574303e-01f, 1.11318141e-01f,
  2.12523006e-02f, -2.45754659e-01f, -1.41981253e-02f, 2.75650531e-01f, 1.98020220e-01f, 1.55116946e-01f, -2.70812307e-02f, 2.27070913e-01f, 4.82622683e-01f, 7.44301081e-02f,
  2.25736722e-01f, -2.81139575e-02f, -1.59429297e-01f, -9.64814350e-02f, -2.69653946e-02f, -1.08331563e-02f, 6.96603879e-02f, 3.97194028e-01f, 7.80890658e-02f, 1.06297977e-01f,
  -1.50378466e-01f, -2.24250168e-01f, -2.49306802e-02f, -1.02873147e-02f, 3.03653814e-02f, 8.06987211e-02f, 6.76681697e-02f, 7.57058933e-02f, 5.57771437e-02f, -1.39785623e-02f,
  1.29330128e-01f, -5.43221869e-02f, 9.02588293e-02f, 6.71281144e-02f, 8.75218399e-03f, 1.41009465e-01f, -7.94319883e-02f, 1.03193097e-01f, 1.54718146e-01f, 6.31974591e-03f,
  1.56866591e-02f, 6.16192399e-03f, 2.18735170e-02f, -2.53714975e-02f, 7.95064494e-02f, -1.25293374e-01f, -3.02258611e-01f, 3.15532446e-01f, -1.09749012e-01f, 2.12407529e-01f,
  -8.78642034e-03f, -1.61058396e-01f, -5.05129546e-02f, 1.84201300e-01f, -1.95348158e-01f, -2.57589757e-01f, -3.01528066e-01f, -2.24345084e-02f, 2.59276718e-01f, -1.82670221e-01f,
  -3.07495266e-01f, 8.36640131e-03f, -1.19797280e-02f, -2.49537200e-01f, 2.86508407e-02f, 3.66603062e-02f, -1.84981793e-01f, -8.34740549e-02f, 1.88533425e-01f, -1.91747546e-01f,
  -1.45380691e-01f, -2.45270645e-03f, 8.36925954e-03f, 1.48296937e-01f, 4.25510742e-02f, 2.72680610e-01f, -1.32689238e-01f, 1.04441047e-01f, -2.27565944e-01f, -1.77285999e-01f,
  6.63491264e-02f, 4.06315982e-01f, 2.63919085e-01f, 6.40189275e-02f, -3.03672347e-02f, -1.80140119e-02f, 1.56943016e-02f, 1.03273168e-01f, -4.72922400e-02f, -9.10459235e-02f,
  7.51119405e-02f, 1.31295189e-01f, 3.98207903e-01f, 1.94714114e-01f, -3.39485630e-02f, 1.69426966e-02f, 1.69318065e-01f, -7.79116452e-02f, -3.23631018e-02f, 1.72499582e-01f,
  1.40780985e-01f, -3.40788186e-01f, -6.48414269e-02f, 1.82613432e-01f, 4.24356433e-03f, 1.69914901e-01f, 1.42543331e-01f, -3.18922520e-01f, -9.85537395e-02f, -6.67099357e-02f,
  -2.95297541e-02f, -3.70735019e-01f, -1.39006138e-01f, -4.78858911e-02f, 2.80610546e-02f, 2.99019516e-01f, -8.65255147e-02f, 7.52331465e-02f, 1.77462542e-04f, 5.59747070e-02f,
  -1.80468768e-01f, -3.45292017e-02f, 7.27860034e-02f, -1.10356517e-01f, 4.84285578e-02f, -6.30039275e-01f, 9.69472900e-02f, 1.98465601e-01f, -1.58634454e-01f, 8.26513395e-03f,
  1.16964504e-01f, 1.75249010e-01f, -2.65056223e-01f, -5.75506948e-02f, 7.43999658e-03f, 4.94035929e-01f, -2.02026814e-01f, 3.81247699e-01f, -5.28138727e-02f, 3.34890485e-01f,
  4.52783346e-01f, -5.07469065e-02f, 3.18054467e-01f, -9.65247452e-02f, -4.46575023e-02f, 1.17950037e-01f
};

// L2_fan_Bp_bar (Shape: 1 x 14)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 14;
const float L2_fan_Bp_bar_data[] = {
  1.35510117e-01f, 7.53920823e-02f, 8.00785124e-02f, 4.87379543e-02f, 1.79601274e-02f, 2.87536588e-02f, 7.05950856e-02f, 1.32148027e-01f, 2.30513643e-02f, 1.26243874e-01f,
  1.67159423e-01f, 5.12214936e-02f, 1.29761934e-01f, 3.82253230e-02f
};

// L3_linear_W (Shape: 12 x 64)
const int L3_linear_W_rows = 12;
const int L3_linear_W_cols = 64;
const float L3_linear_W_data[] = {
  -8.08881894e-02f, -2.42060766e-01f, -2.23301575e-01f, 5.89476712e-03f, -8.27786252e-02f, 2.70412654e-01f, 1.55801177e-01f, -6.61982447e-02f, -1.32898495e-01f, 2.67994374e-01f,
  2.02056482e-01f, 9.47880074e-02f, 3.43964025e-02f, -3.05906475e-01f, 2.06629083e-01f, 1.08838618e-01f, 1.74779698e-01f, 2.64649600e-01f, 2.43773550e-01f, -1.61514387e-01f,
  -7.27628358e-03f, -2.38614857e-01f, 1.70666724e-01f, -4.87286933e-02f, 2.62555480e-02f, -2.53855109e-01f, -1.51806593e-01f, -1.62040398e-01f, -2.82459825e-01f, -1.76475629e-01f,
  -2.82898359e-02f, -2.26595432e-01f, -1.07867464e-01f, 1.60404071e-01f, 5.14921136e-02f, -1.79096386e-01f, -2.91332364e-01f, 1.92113936e-01f, -1.04452670e-01f, -1.63583353e-01f,
  -2.44534090e-01f, -1.87421933e-01f, 1.26834914e-01f, -5.64591438e-02f, -2.42491797e-01f, 3.13358128e-01f, -1.08897537e-01f, 2.36533880e-01f, 2.43609697e-01f, -3.09412718e-01f,
  -4.25713152e-01f, -1.07858859e-01f, -3.88693720e-01f, 4.26330626e-01f, -6.62956983e-02f, -2.61024743e-01f, -3.30075651e-01f, -3.47279668e-01f, -6.11367822e-02f, 4.66647655e-01f,
  -1.05829723e-02f, 3.60061526e-02f, -1.47181898e-01f, -8.93869400e-02f, 8.33141804e-02f, -2.39425197e-01f, -3.42857167e-02f, 1.71941668e-01f, 1.72102541e-01f, 7.80140758e-02f,
  -7.71532133e-02f, -2.91683018e-01f, -2.67688930e-03f, -1.49390057e-01f, -2.63152808e-01f, -1.86019540e-01f, -9.53632966e-03f, 1.78517044e-01f, 6.43568709e-02f, 3.14033151e-01f,
  -6.05909824e-02f, -1.10183604e-01f, 3.15767340e-02f, 5.61791509e-02f, 4.76255976e-02f, 7.84019604e-02f, -2.47246787e-01f, 2.11090207e-01f, -9.25998613e-02f, -1.16574049e-01f,
  -6.72983080e-02f, 1.10317826e-01f, 7.95982312e-03f, -1.12466745e-01f, -2.91933507e-01f, -1.80058718e-01f, -6.33406192e-02f, 2.57138819e-01f, 1.53546467e-01f, 1.37451306e-01f,
  1.05773591e-01f, 3.42533469e-01f, -3.89657058e-02f, 2.04832584e-01f, -4.80757914e-02f, 2.25315094e-01f, 3.43843341e-01f, -1.28965735e-01f, -9.12346840e-02f, 3.35672230e-01f,
  -3.06508005e-01f, -1.93678960e-01f, 2.04341918e-01f, 3.73734921e-01f, 8.57559666e-02f, -1.05581969e-01f, -3.09291840e-01f, 8.27868506e-02f, 3.17610800e-01f, 3.10876012e-01f,
  -2.65269309e-01f, -1.30954191e-01f, 3.16528857e-01f, -3.36704671e-01f, -4.93155897e-01f, -2.25770369e-01f, -1.27251238e-01f, 3.22074413e-01f, 1.02089234e-01f, 1.19786754e-01f,
  8.79283696e-02f, -1.96029231e-01f, 3.67696173e-02f, -2.76948363e-01f, -1.31977051e-01f, 2.12255210e-01f, -1.95531830e-01f, 2.18770534e-01f, -1.24782950e-01f, -1.48826867e-01f,
  -3.48676369e-02f, -7.12880418e-02f, 1.71321392e-01f, -1.63040146e-01f, 1.28122762e-01f, 2.19424322e-01f, -2.35252932e-01f, -4.58535068e-02f, 1.74707741e-01f, 1.06337175e-01f,
  -1.24106859e-03f, -2.34329522e-01f, 6.98821396e-02f, 6.34115189e-02f, 4.79399860e-02f, -2.79290587e-01f, 1.38868496e-01f, 2.66803056e-01f, 5.81990108e-02f, 2.99272180e-01f,
  -1.05287172e-02f, -1.21052146e-01f, 2.04626508e-02f, -1.91734806e-01f, -1.56223387e-01f, -1.73675537e-01f, 2.80241221e-01f, -2.94863824e-02f, -1.71681568e-01f, 1.81400180e-01f,
  1.42815122e-02f, -1.42746285e-01f, -1.66350186e-01f, -2.11979181e-01f, -5.51277921e-02f, 2.01209500e-01f, 2.44824499e-01f, -1.86982363e-01f, -1.65634334e-01f, -3.36104035e-01f,
  -2.86638618e-01f, -2.61769772e-01f, 2.01924875e-01f, 2.01225966e-01f, 5.22539377e-01f, -3.23384643e-01f, 2.57457733e-01f, -2.49805972e-01f, -1.73810244e-01f, -2.55773276e-01f,
  -1.83962360e-01f, -4.95361865e-01f, 2.47503355e-01f, 2.17819419e-02f, 1.77471507e-02f, -2.46506259e-01f, 7.34594986e-02f, -1.65881574e-01f, -1.00997882e-03f, 6.38820454e-02f,
  -1.42963886e-01f, -1.99598223e-01f, -1.15493834e-01f, -2.34351233e-01f, 7.83697218e-02f, -2.23010972e-01f, -4.93195206e-02f, -1.08232282e-01f, -1.75220519e-02f, -1.37519509e-01f,
  6.43734038e-02f, 2.33384207e-01f, 1.32119611e-01f, 2.24893630e-01f, -1.59758225e-01f, 9.80217978e-02f, -5.45081645e-02f, -7.19257221e-02f, 1.71277910e-01f, 1.24874957e-01f,
  -6.31836727e-02f, 3.01564693e-01f, 7.77638927e-02f, 2.54444480e-01f, -2.07824335e-01f, -1.49741828e-01f, 1.32519379e-01f, -1.61498085e-01f, 8.50929171e-02f, 4.53855157e-01f,
  -1.53366804e-01f, 9.84332636e-02f, 2.71811694e-01f, -3.26489747e-01f, -1.60138816e-01f, 2.31285259e-01f, -8.57461393e-02f, 2.17875361e-01f, 2.06162080e-01f, -1.08776055e-01f,
  -1.78243831e-01f, -1.94974989e-01f, -3.89621526e-01f, 4.18247432e-02f, 1.86872363e-01f, -4.74783033e-01f, -4.37119037e-01f, -4.31183547e-01f, -4.41289037e-01f, 2.94415861e-01f,
  -3.26596320e-01f, 1.01140670e-01f, 3.25389326e-01f, 2.39687055e-01f, 2.36254752e-01f, -3.83620709e-01f, 1.13276526e-01f, 2.99908251e-01f, 2.86866605e-01f, 2.51803339e-01f,
  -1.95292681e-01f, -1.14336014e-01f, 1.32195890e-01f, 2.16416523e-01f, 3.65818143e-01f, 2.05470473e-02f, 2.54578311e-02f, 4.31283973e-02f, 1.54097229e-01f, 1.45280883e-01f,
  3.21914494e-01f, 7.79577419e-02f, 1.21029787e-01f, -2.02170655e-01f, -5.54622710e-02f, 2.68138926e-02f, -3.16054933e-03f, -1.23623759e-01f, 1.92079514e-01f, 2.35946160e-02f,
  3.73245291e-02f, 3.09539407e-01f, 4.72330339e-02f, 1.56362891e-01f, -2.29093865e-01f, -2.46959209e-01f, 2.11783633e-01f, 2.83011496e-01f, 4.38817963e-02f, -1.08444262e-02f,
  2.72343993e-01f, 5.21358192e-01f, 2.04359204e-01f, -3.24320644e-01f, -1.28746629e-01f, -7.29346052e-02f, 1.52747676e-01f, 1.69350579e-01f, 6.43122103e-03f, 2.33714491e-01f,
  3.24326515e-01f, -3.01876873e-01f, -3.97279710e-01f, -3.22793454e-01f, 2.47112796e-01f, -1.45203903e-01f, -2.74180323e-01f, -2.00241119e-01f, 3.17123920e-01f, 1.36325955e-01f,
  -7.01604113e-02f, 2.81864945e-02f, 9.70390141e-02f, -2.85041749e-01f, -3.13682944e-01f, 8.67790505e-02f, 2.61192232e-01f, 2.63469070e-01f, -3.21121246e-01f, -3.72606099e-01f,
  1.14188507e-01f, 4.32086885e-02f, 1.88790426e-01f, -2.26711825e-01f, -2.67091006e-01f, -1.74928308e-01f, -1.00856073e-01f, -1.16144523e-01f, 1.90836862e-01f, -1.30564999e-02f,
  1.04841463e-01f, 1.42529890e-01f, -4.43498604e-02f, 1.10495433e-01f, -2.04725489e-01f, -1.66412413e-01f, -1.23931505e-01f, 7.29973242e-02f, -2.41728611e-02f, 1.71894044e-01f,
  2.27238089e-02f, 9.53922421e-02f, -8.65162164e-02f, 9.79763195e-02f, 1.11077018e-02f, -1.24904819e-01f, -2.36499399e-01f, -3.78349036e-01f, -2.69891143e-01f, 5.30848056e-02f,
  2.78697848e-01f, -2.95071661e-01f, -1.87809512e-01f, -2.34885484e-01f, -2.97975894e-02f, -2.92343557e-01f, -2.72341549e-01f, 3.24032694e-01f, -1.95132598e-01f, -5.92543855e-02f,
  2.27251410e-01f, 7.38920867e-02f, -3.43878597e-01f, 1.76659465e-01f, 6.20459486e-03f, -2.96983212e-01f, -7.01228604e-02f, 1.86963603e-01f, -2.66894013e-01f, 3.88992876e-01f,
  1.56528890e-01f, -1.67391673e-01f, -2.41447911e-01f, 1.92397669e-01f, -4.08682406e-01f, 1.96542293e-01f, -5.82188666e-01f, 3.71905088e-01f, -2.37266839e-01f, -3.08922142e-01f,
  3.04467499e-01f, 2.03841045e-01f, -4.40007806e-01f, 4.06574100e-01f, 1.20873479e-02f, -1.16512716e-01f, 9.16581303e-02f, 6.04233369e-02f, 7.67343910e-03f, -1.19089875e-02f,
  1.95629939e-01f, 1.84885368e-01f, 2.94650555e-01f, -6.46779463e-02f, 3.76990438e-02f, 1.53146069e-02f, 1.86925009e-02f, 1.49043016e-02f, -2.58209109e-01f, 1.67012021e-01f,
  -4.39175181e-02f, -2.13451162e-01f, -3.22906524e-02f, 1.40754566e-01f, -1.45800933e-01f, -2.25407425e-02f, 9.37534124e-02f, 4.54643406e-02f, -4.98048961e-02f, 2.22380489e-01f,
  3.40295166e-01f, 6.19327053e-02f, 3.19857121e-01f, -1.37996599e-01f, -2.93777347e-01f, 2.07577765e-01f, 6.35326505e-02f, 2.17402533e-01f, 3.24786186e-01f, -2.60289490e-01f,
  -3.29677463e-01f, -1.39799684e-01f, 1.87887102e-01f, 2.30843678e-01f, -1.45421885e-02f, 1.33558333e-01f, -9.75081325e-03f, -3.86743575e-01f, 8.89402777e-02f, 5.27227968e-02f,
  1.83234021e-01f, 2.41612390e-01f, -3.47985238e-01f, -1.41035900e-01f, 3.26596677e-01f, -2.46341467e-01f, -1.03368521e-01f, -4.38206136e-01f, -3.28228116e-01f, 2.32748926e-01f,
  2.19208807e-01f, 4.87892330e-01f, -2.82336444e-01f, -5.64268649e-01f, 4.42196652e-02f, -1.29372001e-01f, 2.20341280e-01f, -1.16390586e-01f, 4.23674360e-02f, 3.40639651e-02f,
  -7.44863302e-02f, 1.36793420e-01f, -1.21159658e-01f, 7.67289400e-02f, 9.66631100e-02f, -1.82866186e-01f, -1.97431371e-02f, 1.80460900e-01f, 3.67932692e-02f, 3.31702381e-02f,
  1.47965923e-01f, 1.48220614e-01f, 1.16966948e-01f, 9.96472538e-02f, -6.98215216e-02f, 3.10110040e-02f, -7.49358982e-02f, 1.61372036e-01f, 1.78493530e-01f, 1.50587767e-01f,
  1.28231019e-01f, 5.83026521e-02f, -6.60229251e-02f, -2.79290229e-01f, -2.59233803e-01f, 2.09809214e-01f, 1.78122535e-01f, 2.47116327e-01f, 1.96381316e-01f, 1.65154919e-01f,
  -1.87576205e-01f, 2.16723785e-01f, -2.34031737e-01f, 2.09067643e-01f, 2.54566729e-01f, 1.19382977e-01f, -1.17709532e-01f, -2.13164344e-01f, 1.07196845e-01f, -2.43588269e-01f,
  2.34910697e-01f, 2.39559799e-01f, -2.23145485e-01f, -2.48431526e-02f, -1.94920093e-01f, 1.84056818e-01f, 1.83742955e-01f, 2.08504647e-01f, 6.09188825e-02f, 3.37460071e-01f,
  6.89135641e-02f, -3.16843718e-01f, -1.27515525e-01f, -3.30057055e-01f, 4.35614705e-01f, 3.49266768e-01f, -1.21610954e-01f, 1.30400062e-01f, -3.51496786e-01f, -5.19584000e-01f,
  1.30370021e-01f, -2.26817638e-01f, -1.31358042e-01f, 1.26875445e-01f, -8.41494948e-02f, 1.65970102e-02f, -1.27276957e-01f, -2.86994725e-01f, 6.48001209e-02f, 4.39061150e-02f,
  -9.57246497e-02f, -2.16972291e-01f, 1.63562715e-01f, -1.41393244e-01f, -2.69756429e-02f, -1.35282427e-01f, 1.56937778e-01f, -3.12717319e-01f, 1.89753785e-03f, 3.26245800e-02f,
  -1.73323691e-01f, 2.19374165e-01f, -1.44931704e-01f, 5.14848903e-02f, 1.58498839e-01f, 7.53725246e-02f, 4.78612036e-02f, 2.10425034e-01f, -1.59963623e-01f, -2.81703204e-01f,
  3.21459651e-01f, 2.40412772e-01f, -1.63236652e-02f, -2.71594990e-02f, -1.19623423e-01f, 1.26132309e-01f, 9.05956924e-02f, -1.17127530e-01f, 2.05022637e-02f, -1.81821823e-01f,
  -1.66393533e-01f, -2.05661461e-01f, 1.02734812e-01f, -2.98360914e-01f, 2.39482507e-01f, -6.93095997e-02f, 7.85566717e-02f, -1.13324068e-01f, 2.77136505e-01f, 1.75135821e-01f,
  -3.14594418e-01f, 5.35971159e-03f, -2.21850842e-01f, 3.01950872e-01f, -2.98964143e-01f, -1.26625776e-01f, 4.03323233e-01f, -3.17585975e-01f, -3.78915101e-01f, -4.02052432e-01f,
  2.94795185e-01f, 7.53093809e-02f, -1.70660049e-01f, 3.21589053e-01f, -3.62559736e-01f, -2.79278904e-01f, 1.10602088e-01f, 6.89570084e-02f, -1.32349059e-01f, -2.33246565e-01f,
  1.37337908e-01f, -2.93969102e-02f, -1.34768099e-01f, -1.26191035e-01f, -3.12385052e-01f, 3.31753194e-02f, -6.66095167e-02f, 1.49918407e-01f, -2.89230376e-01f, -1.76128685e-01f,
  2.13355005e-01f, 1.10956967e-01f, -2.23068357e-01f, 4.71748505e-03f, -5.76161630e-02f, 6.53746352e-02f, -4.23697904e-02f, 1.80034265e-01f, -2.07597569e-01f, -1.16746295e-02f,
  -1.02370970e-01f, -3.08822393e-01f, -2.98999697e-01f, 1.44566000e-01f, 2.59126216e-01f, -8.88231397e-02f, -3.11279058e-01f, 1.17116354e-01f, 3.09655577e-01f, 3.04002706e-02f,
  -4.43077385e-01f, -1.68886304e-01f, 2.54439980e-01f, -1.04761980e-01f, 2.69348055e-01f, 8.02359730e-03f, 1.32593900e-01f, -1.01174995e-01f, -1.53618217e-01f, 3.03264469e-01f,
  1.04095638e-01f, -1.79693978e-02f, -1.09073326e-01f, 1.30041167e-01f, 3.28253716e-01f, -1.97195843e-01f, 1.37045398e-01f, -2.60607958e-01f, 2.54323810e-01f, 1.64768562e-01f,
  -2.58968055e-01f, 6.73415363e-02f, 1.65358543e-01f, -4.58169609e-01f, -3.08084786e-01f, 7.91853443e-02f, -6.60765022e-02f, -5.97086608e-01f, -5.07939756e-01f, 3.81325811e-01f,
  -3.00501972e-01f, -8.39394927e-02f, 3.72650772e-02f, 1.97521280e-02f, 1.57479391e-01f, 1.98960871e-01f, -3.00624836e-02f, 1.98993132e-01f, 2.10749686e-01f, -1.39127657e-01f,
  -3.47728468e-02f, 2.47350842e-01f, -1.12317160e-01f, 1.77106246e-01f, -2.23059967e-01f, 1.66296158e-02f, -1.49416000e-01f, 3.27367820e-02f, 5.77061772e-02f, -3.11264604e-01f,
  -1.84711352e-01f, -1.00095041e-01f, -5.21384813e-02f, -2.55106062e-01f, -1.49272397e-01f, 8.37536454e-02f, 2.47092932e-01f, 1.93948165e-01f, -2.92807817e-01f, -1.28629625e-01f,
  -7.23009184e-02f, -3.42771232e-01f, 1.37109086e-01f, -2.47307852e-01f, 3.18585634e-02f, 3.01926076e-01f, -3.08524311e-01f, -2.35667914e-01f, -6.00798279e-02f, 9.91576910e-02f,
  -3.32061231e-01f, -6.83687106e-02f, -2.50232637e-01f, -4.14094090e-01f, 1.01114795e-01f, 2.39002764e-01f, 2.21762136e-01f, -3.44733149e-01f, -1.93089500e-01f, 3.37273806e-01f,
  1.89432681e-01f, 3.09503794e-01f, -3.07454169e-03f, -3.52248847e-01f, 3.96145880e-02f, -3.80984128e-01f, 9.13103297e-03f, 4.00546193e-02f, 2.25147888e-01f, 1.02752909e-01f,
  -4.04821217e-01f, 1.49516761e-01f, 2.65618324e-01f, -3.62183124e-01f, -1.62589759e-01f, -2.70908535e-01f, -2.65378654e-01f, 1.68081030e-01f, 1.41677126e-01f, 9.25935507e-02f,
  3.96623015e-02f, -1.89443201e-01f, -6.34093583e-02f, 1.61123902e-01f, 8.72461572e-02f, -1.34081831e-02f, -9.52238962e-02f, 1.41326403e-02f, -2.63153136e-01f, 1.00019947e-01f,
  8.71162042e-02f, 4.74087521e-03f, 1.11560747e-01f, -3.14116865e-01f, 1.51304141e-01f, -2.00453296e-01f, 1.18201509e-01f, -2.16790661e-01f, 3.94559838e-02f, 7.73072999e-04f,
  3.94432247e-02f, 5.08408733e-02f, -1.54195264e-01f, -1.57287613e-01f, 1.07954010e-01f, -1.84131518e-01f, 3.45462799e-01f, -2.74773180e-01f, 6.43149242e-02f, 1.38766736e-01f,
  1.66108936e-01f, -1.84861541e-01f, 3.17876309e-01f, 8.39956626e-02f, 7.08889961e-02f, 2.85649866e-01f, 1.91057727e-01f, 1.04781777e-01f, -1.78618550e-01f, -2.28258401e-01f,
  2.52464950e-01f, -2.30962127e-01f, -1.48150951e-01f, -1.90165177e-01f, 2.48209104e-01f, -2.84236282e-01f, 2.35364631e-01f, -3.03800672e-01f, -1.64513141e-01f, -3.67759496e-01f,
  -5.29077709e-01f, -1.30858406e-01f, -2.50214219e-01f, -1.01760566e-01f, 2.21485615e-01f, 1.00358546e-01f, 2.97284842e-01f, 5.16053855e-01f
};

// L3_linear_B (Shape: 1 x 12)
const int L3_linear_B_rows = 1;
const int L3_linear_B_cols = 12;
const float L3_linear_B_data[] = {
  2.94655506e-02f, 5.51296994e-02f, 2.57450845e-02f, 1.83043722e-02f, -2.79173590e-02f, 7.13154078e-02f, 4.41170745e-02f, -4.01319601e-02f, -8.85400269e-03f, 3.11025660e-02f,
  -1.08536296e-01f, 9.62673053e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 25, 14
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        64, 25, 14
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        64, 25, 14
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_linear
    linear_forward_pgm(
        buffer1, x_out,
        L3_linear_W_data, L3_linear_B_data,
        64, 12
    );
    }
    