/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 128 (x1)
    * Saída: 12
    * Buffer Máx: 128
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 128;
    const int FAN_MAX_BUFFER_SIZE = 128;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    float x3 = x * x * x;
    return 0.5f * x * (1.0f + tanhf(0.79788456f * (x + 0.044715f * x3)));
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 12 x 120)
const int L0_fan_Wp_rows = 12;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  3.92872602e-01f, 1.99036658e-01f, 2.03865677e-01f, 1.32313237e-01f, 3.13739255e-02f, 8.67909715e-02f, -1.79836266e-02f, -2.58559808e-02f, 9.66186523e-02f, 1.28694117e-01f,
  -9.66641232e-02f, -1.13593459e-01f, -9.83280912e-02f, -1.41285121e-01f, 4.22614366e-02f, 1.71716660e-01f, 1.24851458e-01f, 1.22727253e-01f, 7.94387758e-02f, 6.39513656e-02f,
  5.43804951e-02f, 2.01095209e-01f, 2.57009476e-01f, 1.55528635e-01f, 2.20549792e-01f, 1.52531475e-01f, 1.21000275e-01f, 1.65075883e-01f, 2.35368893e-01f, 3.25467259e-01f,
  1.15594760e-01f, 2.12856457e-01f, -2.43640989e-02f, 2.72921361e-02f, -6.61206339e-03f, 8.73187780e-02f, 4.81005944e-03f, 8.67925435e-02f, -2.61415988e-02f, 9.61516798e-02f,
  5.37619404e-02f, 1.62681658e-02f, 1.66093302e-03f, 9.79225058e-03f, 1.19511724e-01f, -3.04874964e-03f, 5.68619631e-02f, 1.28869250e-01f, 2.72741225e-02f, 5.51354811e-02f,
  -5.85756563e-02f, 1.42272443e-01f, 1.89747348e-01f, 3.53142209e-02f, 1.13852993e-01f, 1.61005288e-01f, 1.47925541e-01f, 1.36984110e-01f, 2.28082433e-01f, 1.97389156e-01f,
  5.38657606e-02f, -8.60523526e-03f, 4.83880565e-02f, -4.03015651e-02f, 5.15167192e-02f, -2.36818120e-02f, -4.51119151e-03f, -5.79577964e-03f, -1.14451731e-02f, 5.27715590e-03f,
  -4.14620303e-02f, -4.35911790e-02f, -1.52727757e-02f, -4.04653177e-02f, -2.39955727e-02f, 3.39475349e-02f, 3.41882668e-02f, 1.66313816e-02f, 4.41151150e-02f, 6.49751797e-02f,
  -1.53451478e-02f, -4.70405817e-02f, -2.38586627e-02f, 3.18941362e-02f, 8.86965767e-02f, -8.52220878e-03f, -1.82700716e-03f, -3.57596241e-02f, -1.74923595e-02f, -3.94197963e-02f,
  -1.84562236e-01f, -1.85510203e-01f, 1.46764427e-01f, 2.17138361e-02f, 1.62451752e-02f, 1.09224573e-01f, -1.04805809e-02f, 1.02054127e-01f, -4.72366884e-02f, 1.33206815e-01f,
  8.40782598e-02f, 2.16303784e-02f, -2.03274526e-02f, -6.33118600e-02f, -5.45135550e-02f, 3.48277129e-02f, 4.97151911e-02f, -1.83411036e-02f, -5.86763248e-02f, 3.77310738e-02f,
  2.69829836e-02f, 1.66920185e-01f, 6.71899468e-02f, 7.79569309e-05f, 1.32052854e-01f, -1.08656827e-02f, 1.17922500e-01f, 9.42230672e-02f, 7.33933300e-02f, 1.52062193e-01f,
  3.87195349e-02f, -2.28312150e-01f, -5.97610883e-03f, -2.34930590e-02f, -6.25667349e-02f, -1.32339060e-01f, -2.11292580e-01f, -1.00034751e-01f, -4.72660270e-03f, -9.62263718e-02f,
  -9.22394767e-02f, 2.65366957e-02f, 5.44171222e-02f, -2.67075356e-02f, 3.49517399e-03f, -1.26537696e-01f, 2.06106566e-02f, -1.86796009e-03f, 2.76254658e-02f, 9.81987119e-02f,
  -2.38942523e-02f, 7.30199218e-02f, 3.17344256e-02f, 6.98271990e-02f, 6.22748807e-02f, 8.09578318e-03f, 1.48985600e-02f, 8.52064341e-02f, 9.84492898e-03f, 8.96699727e-02f,
  1.50974959e-01f, -2.25061506e-01f, -4.40146998e-02f, 3.08367163e-02f, 4.60885055e-02f, -5.63315898e-02f, 2.20723897e-02f, 5.75248301e-02f, -1.06852148e-02f, -3.39480024e-03f,
  -5.53812981e-02f, -6.64820746e-02f, -1.90717299e-02f, 2.55806092e-02f, -9.07116085e-02f, -8.60264525e-02f, -9.89705175e-02f, -6.07160628e-02f, -7.91710541e-02f, 3.32123265e-02f,
  1.97948199e-02f, 6.11553006e-02f, 6.39486313e-02f, -1.24859333e-01f, -5.49003519e-02f, 8.46787989e-02f, -7.99748674e-02f, -5.99385565e-03f, -1.02284558e-01f, 2.76252329e-02f,
  -6.78916136e-03f, 3.72371972e-02f, -6.68177083e-02f, -7.41389319e-02f, -2.91973306e-03f, 6.30650595e-02f, 4.77216206e-03f, -6.86434517e-03f, 4.98111956e-02f, 7.65840188e-02f,
  5.61223663e-02f, -1.05289817e-02f, -1.92707665e-02f, -1.59336105e-02f, -6.39358070e-03f, 4.82862815e-02f, -5.28275641e-03f, 5.30363508e-02f, 1.27647892e-01f, 2.30396669e-02f,
  -2.02139076e-02f, 2.00339872e-02f, 1.19919986e-01f, 7.36187622e-02f, 7.33185485e-02f, 5.87249771e-02f, 8.13084990e-02f, 5.96803389e-02f, 2.50127073e-02f, -2.40855757e-02f,
  1.22386068e-01f, -1.99952021e-01f, 3.59603837e-02f, -1.09098479e-01f, 6.61829710e-02f, -4.58063409e-02f, -3.48081477e-02f, 6.80309674e-03f, -9.54859331e-02f, -7.56717622e-02f,
  -4.93855327e-02f, -7.43878111e-02f, 5.46030812e-02f, -1.48437917e-02f, -2.33104639e-02f, -2.02576481e-02f, -2.68522650e-02f, 1.06728569e-01f, 3.66788171e-02f, 3.60754617e-02f,
  -7.48868752e-03f, 1.07541926e-01f, 1.69531479e-01f, 1.18253648e-01f, 3.67720961e-03f, 1.37469649e-01f, 7.81658143e-02f, 9.46789160e-02f, 9.47338566e-02f, 3.15045901e-02f,
  -4.34724748e-01f, 8.65642652e-02f, -1.41764179e-01f, -5.48682399e-02f, 4.20550033e-02f, 1.41615734e-01f, 2.06662565e-01f, 1.44290119e-01f, 5.44806682e-02f, 4.41242903e-02f,
  1.29452243e-01f, 6.96900161e-03f, 1.13309152e-01f, 8.38613808e-02f, 5.52260540e-02f, 1.48829281e-01f, 2.40596935e-01f, -1.42114731e-02f, -8.69958401e-02f, 4.11097379e-03f,
  1.22592874e-01f, 4.04213555e-02f, -1.68231949e-01f, -3.80443484e-02f, 1.00082397e-01f, 1.16330773e-01f, 9.38963443e-02f, 4.37440276e-02f, 1.37732327e-01f, 1.12105690e-01f,
  -1.93845093e-01f, -1.88955396e-01f, 1.69326574e-01f, 8.21927860e-02f, 3.21961008e-02f, 9.16307271e-02f, 7.45774209e-02f, 7.46047199e-02f, -4.03420962e-02f, 9.60136726e-02f,
  -9.04356712e-04f, 6.59884065e-02f, 7.71214366e-02f, 9.69342366e-02f, 1.55417249e-03f, 2.37163883e-02f, 1.40939221e-01f, 8.96529853e-02f, 1.51534244e-01f, -2.92531942e-04f,
  2.05920100e-01f, -1.90684684e-02f, -1.76330935e-02f, 1.45638898e-01f, 2.89751571e-02f, 8.43074247e-02f, 5.85565418e-02f, -1.24663617e-02f, -5.50524183e-02f, 9.73946229e-02f,
  -2.10203137e-02f, -6.12064376e-02f, -7.22539648e-02f, -2.53217835e-02f, -2.05737725e-02f, -7.19227770e-04f, 3.54536548e-02f, -2.83971429e-02f, -5.09963334e-02f, -7.20206089e-03f,
  2.43245922e-02f, 1.94806624e-02f, 1.46773746e-02f, -4.64384183e-02f, 4.10341099e-02f, 5.31287445e-03f, 2.87626125e-03f, 3.97776626e-02f, -1.45924818e-02f, 6.37487276e-03f,
  3.06423157e-02f, -5.57177253e-02f, -7.55070224e-02f, 2.24291496e-02f, -2.97752433e-02f, -2.60814782e-02f, -3.66062857e-02f, 3.84755135e-02f, -1.30370602e-01f, -6.23470210e-02f,
  1.92647234e-01f, 1.57788381e-01f, 1.82861388e-02f, -6.48288848e-03f, 1.05251230e-01f, 1.68307684e-02f, 1.40198737e-01f, -1.49672171e-02f, 7.89396688e-02f, 6.00761957e-02f,
  9.01320353e-02f, 4.28354740e-02f, 9.14572701e-02f, 3.33690904e-02f, 1.41168954e-02f, 4.27922420e-02f, 1.52765915e-01f, 6.31757230e-02f, 8.74157846e-02f, 1.36024058e-01f,
  1.33466557e-01f, 5.86248040e-02f, 6.91461265e-02f, 9.22280997e-02f, 1.60008967e-01f, 3.34481150e-02f, 4.55800667e-02f, 1.08339213e-01f, 9.88158956e-02f, 1.64489761e-01f,
  2.22290635e-01f, -2.47947618e-01f, -1.76643506e-01f, 5.13989516e-02f, -1.48692220e-01f, -2.19156906e-01f, -2.84453779e-01f, 5.76627906e-03f, 9.00494456e-02f, -4.40380238e-02f,
  -6.36259913e-02f, 2.87818071e-02f, 1.50685562e-02f, -1.01055339e-01f, -1.02772273e-01f, -1.02864414e-01f, -1.62331820e-01f, -5.05499393e-02f, 4.47573774e-02f, -2.70366166e-02f,
  5.70901521e-02f, 1.45841390e-01f, 8.87691751e-02f, 6.20593652e-02f, 8.38914048e-03f, 4.04485241e-02f, 2.88697127e-02f, -7.11953500e-03f, -1.51239857e-01f, -6.67196363e-02f,
  7.50749782e-02f, -3.04886922e-02f, 1.16202056e-01f, 4.81666066e-02f, 6.76055476e-02f, 6.41254783e-02f, 8.78585279e-02f, -3.95752303e-02f, -7.22546354e-02f, 9.57595780e-02f,
  -3.73793580e-02f, -1.25509147e-02f, -1.44961959e-04f, -4.66056392e-02f, 1.35196727e-02f, -6.63757771e-02f, -3.17261331e-02f, -6.14844672e-02f, -5.75233670e-03f, -1.06969967e-01f,
  -1.25035942e-01f, -1.51097458e-02f, -6.76901191e-02f, -6.90207258e-02f, -1.89843830e-02f, -4.69003655e-02f, -2.53789849e-03f, 8.89672264e-02f, 5.86308688e-02f, 1.32015884e-01f,
  9.49448645e-02f, -3.03614885e-02f, -3.68188545e-02f, -8.77111107e-02f, -2.80668940e-02f, -1.12072835e-02f, -5.86693408e-03f, -9.86647010e-02f, -1.20857410e-01f, -7.25543499e-02f,
  -6.41806191e-03f, 1.54761337e-02f, -3.84234893e-03f, -4.42392230e-02f, 2.30553523e-02f, -1.05994254e-01f, -4.04843055e-02f, -5.71339577e-02f, -5.21247908e-02f, -3.70567404e-02f,
  -1.96691770e-02f, -4.67074923e-02f, -4.68782261e-02f, -1.40440166e-02f, -5.73036596e-02f, -9.38874111e-02f, -5.69984317e-02f, -1.40529154e-02f, -4.01632972e-02f, -1.26300707e-01f,
  2.18478709e-01f, -1.36629999e-01f, 1.59724042e-01f, 4.04997654e-02f, -3.93347405e-02f, -5.39357103e-02f, 2.24070475e-02f, 1.68634374e-02f, 1.00814693e-01f, 1.29788756e-01f,
  4.94418070e-02f, 5.24858683e-02f, -7.69371614e-02f, -4.63828668e-02f, -2.53768116e-02f, 1.12953559e-01f, 3.66049111e-02f, 5.98452836e-02f, -7.28477463e-02f, 4.01520617e-02f,
  5.93111552e-02f, 1.47328541e-01f, 7.55330101e-02f, 3.45179439e-02f, -3.68185225e-04f, 5.46492189e-02f, 1.34084970e-01f, 1.71227187e-01f, 5.63518144e-02f, 1.82698101e-01f,
  -4.55914512e-02f, -1.45962432e-01f, -3.01767826e-01f, -4.36046533e-02f, -1.11246705e-01f, -1.73668697e-01f, -2.53856391e-01f, -5.59890829e-02f, -3.47587354e-02f, -8.40186626e-02f,
  -7.11974874e-02f, -4.72737513e-02f, -1.59506015e-02f, -8.25022236e-02f, -2.36967683e-01f, -1.15996592e-01f, -2.51357526e-01f, -1.90794185e-01f, -9.58977044e-02f, -8.49686190e-02f,
  -7.77849257e-02f, -1.00551426e-01f, -6.21586516e-02f, -1.85286403e-02f, -6.44335151e-02f, -1.12064108e-01f, -1.00519799e-01f, -1.08862281e-01f, -1.91531003e-01f, -4.11252044e-02f,
  -2.41236806e-01f, -1.82353556e-01f, 8.10966790e-02f, 6.28210977e-02f, -2.21610852e-02f, 1.16790898e-01f, -7.26212487e-02f, 2.79689599e-02f, 8.19199383e-02f, -1.58486124e-02f,
  -2.07098690e-03f, 2.52972990e-02f, -8.05300009e-03f, 4.59487690e-03f, -1.67000364e-03f, 8.72420222e-02f, 4.71585877e-02f, 8.66795108e-02f, 3.64660285e-02f, 4.64378744e-02f,
  2.09568851e-02f, 2.23388476e-03f, -5.44667803e-02f, 4.95464653e-02f, 1.18215643e-02f, -6.33048192e-02f, -4.63470481e-02f, 2.49222703e-02f, -6.38639480e-02f, 1.40300408e-01f,
  4.19401424e-03f, -1.93414111e-02f, -4.53868834e-03f, 7.64642144e-03f, -6.58407435e-02f, -3.02086249e-02f, 7.96054862e-03f, -1.42923251e-01f, -6.52112588e-02f, 7.65247224e-03f,
  -1.19958911e-02f, -7.36180246e-02f, -1.42616987e-01f, -7.12731332e-02f, -5.87471165e-02f, -9.94239226e-02f, -8.13651159e-02f, -2.77663115e-02f, -6.91138208e-02f, 4.07232232e-02f,
  5.70362918e-02f, -2.10339911e-02f, 3.77862677e-02f, -6.32028580e-02f, 1.56251236e-03f, -1.05080204e-02f, -2.97425352e-02f, -1.19680524e-01f, -1.12913206e-01f, -8.44601616e-02f,
  -4.36783396e-02f, -2.91357674e-02f, -8.28149822e-03f, 2.45767981e-02f, 1.09370552e-01f, 1.67285427e-01f, -2.32033129e-03f, 1.01274103e-01f, 5.40739931e-02f, -7.33060390e-02f,
  3.19708623e-02f, -4.82585095e-02f, -7.97137320e-02f, 7.84411877e-02f, -2.88508255e-02f, -3.17297690e-02f, 1.15839392e-01f, 3.49770975e-03f, 1.09978385e-01f, 2.72001233e-02f,
  2.57479157e-02f, -1.06585465e-01f, -6.78836331e-02f, -2.05979142e-02f, 1.48788579e-02f, -1.06769979e-01f, 2.19290685e-02f, -9.08448622e-02f, -1.29525200e-01f, 4.15063575e-02f,
  4.23960000e-01f, 3.56617033e-01f, 8.61323103e-02f, 7.83667192e-02f, -5.56633286e-02f, 6.60382807e-02f, 2.31015310e-01f, 7.74274468e-02f, 1.68575555e-01f, 1.98462233e-01f,
  1.64064988e-01f, 1.60792559e-01f, 5.22977225e-02f, 5.63480891e-02f, 1.79126725e-01f, 1.04961671e-01f, -4.05328162e-02f, 5.18465042e-02f, 1.92751184e-01f, 1.33294716e-01f,
  2.76436917e-02f, 3.60662974e-02f, 8.01783577e-02f, 1.22888973e-02f, -7.35772029e-02f, 1.18819200e-01f, 1.73245400e-01f, 1.96515158e-01f, 1.98455319e-01f, -2.85259709e-02f,
  7.94534534e-02f, 3.75495195e-01f, 8.63985866e-02f, 1.45198524e-01f, 1.18829489e-01f, 1.94155157e-01f, 6.66704327e-02f, 1.55276835e-01f, 1.77520320e-01f, 2.08724022e-01f,
  1.82590395e-01f, 1.57694459e-01f, 2.27768458e-02f, 5.64066209e-02f, 9.84859541e-02f, 1.52784869e-01f, 1.54226556e-01f, 2.15021953e-01f, 9.45221633e-02f, 1.22694194e-01f,
  3.94922160e-02f, 2.11162314e-01f, 1.37185350e-01f, 7.92779773e-02f, 1.68347418e-01f, 1.91625088e-01f, 2.30468720e-01f, 2.40109056e-01f, 2.39430726e-01f, 1.96641579e-01f,
  -1.74608842e-01f, -1.38398215e-01f, -1.22968696e-01f, -1.99406166e-02f, -1.33050233e-01f, -8.74025449e-02f, -1.38027459e-01f, 1.19568426e-02f, -1.09181337e-01f, -1.37971789e-01f,
  -8.19993839e-02f, -1.16165772e-01f, -5.59545681e-02f, 2.02141702e-03f, -5.49818762e-02f, -8.04916173e-02f, -8.79702643e-02f, -7.73978755e-02f, -8.07011724e-02f, 1.06462173e-03f,
  -5.89152984e-02f, -3.84420045e-02f, -7.43786544e-02f, -5.07351793e-02f, -7.56110717e-03f, -6.89105093e-02f, -1.12869412e-01f, 4.93521802e-02f, -7.95030445e-02f, 7.29675442e-02f,
  1.19667299e-01f, 2.34367892e-01f, 8.86672512e-02f, 2.09867597e-01f, 1.49623558e-01f, 1.19707994e-01f, 1.54992148e-01f, 1.93927675e-01f, 2.10761234e-01f, 2.35612616e-01f,
  2.53083020e-01f, 1.15656778e-01f, 1.91697761e-01f, 8.52504373e-02f, 1.69636726e-01f, 7.97861889e-02f, 1.63322821e-01f, 1.68439880e-01f, 1.24764517e-01f, 1.66864187e-01f,
  7.15596974e-02f, 1.26602829e-01f, 2.08892763e-01f, 8.88673663e-02f, 1.29329517e-01f, 2.34266311e-01f, 2.42146030e-01f, 2.36890689e-01f, 3.15921903e-01f, 1.73044905e-01f,
  -2.68034220e-01f, 8.20478201e-02f, 2.82657683e-01f, -4.23671082e-02f, 6.42088503e-02f, 2.21537307e-01f, 2.53714859e-01f, 6.76210299e-02f, -2.10889801e-02f, -1.33471331e-02f,
  -6.97900578e-02f, -1.61874011e-01f, -1.29242400e-02f, -4.66333777e-02f, 1.07342690e-01f, 1.89029649e-01f, 1.94210976e-01f, 1.73278764e-01f, 1.13994345e-01f, -1.58938579e-02f,
  -8.14399943e-02f, -4.29864563e-02f, -8.32375586e-02f, 1.23725526e-01f, 1.43435717e-01f, -1.90564152e-02f, 1.21444650e-01f, 1.47377461e-01f, 1.82079449e-01f, 7.87819475e-02f,
  1.16038717e-01f, 4.00881805e-02f, 5.12903444e-02f, -7.72032440e-02f, -1.55202961e-02f, 1.39192427e-02f, -5.89693896e-03f, 7.04603270e-02f, 2.89705098e-02f, 3.93687971e-02f,
  -1.08720949e-02f, 2.86858133e-03f, 8.34454671e-02f, -2.86325924e-02f, 2.82187257e-02f, 2.83134375e-02f, 6.17682040e-02f, 1.09017417e-01f, 6.57995343e-02f, -6.89688325e-02f,
  3.29571143e-02f, 5.61587550e-02f, 4.16420028e-02f, 5.03270701e-02f, 1.27277195e-01f, 6.33351924e-03f, 9.78307277e-02f, 3.19446288e-02f, 2.92640030e-02f, 2.29060296e-02f,
  -6.97158799e-02f, 3.80689576e-02f, -9.05965455e-03f, 3.56563972e-03f, -1.07061878e-01f, -6.03713542e-02f, 1.18690040e-02f, -1.33402478e-02f, 3.57360877e-02f, 1.38783152e-03f,
  5.11558317e-02f, -9.88729373e-02f, -4.95661944e-02f, 3.81184071e-02f, -6.02819920e-02f, 1.64916366e-02f, 5.63051775e-02f, -7.84910768e-02f, -9.21387002e-02f, 1.17283212e-02f,
  -2.35456810e-03f, -4.97796200e-02f, -9.47082322e-03f, 2.58486923e-02f, -5.04619554e-02f, 1.45486351e-02f, -1.10368393e-01f, -1.25175744e-01f, -9.35522560e-03f, -1.25468057e-03f,
  -2.67434448e-01f, 9.03566852e-02f, -6.20342493e-02f, -4.96838018e-02f, 1.10545345e-01f, 2.97597833e-02f, 3.95727605e-02f, -3.08525022e-02f, -9.13002267e-02f, -7.74828047e-02f,
  -6.01540990e-02f, 1.58720594e-02f, -1.48938010e-02f, 6.47167116e-02f, -3.40173058e-02f, -5.80931976e-02f, -6.01683222e-02f, 9.75707099e-02f, 8.99612904e-02f, 9.72054452e-02f,
  -2.36514825e-02f, 2.73527093e-02f, -5.33242822e-02f, 8.83740410e-02f, 9.78532583e-02f, 3.45522128e-02f, 8.97744000e-02f, 9.03952122e-02f, 1.01934426e-01f, -5.11007337e-03f,
  4.37368631e-01f, -1.20211326e-01f, -1.45790577e-01f, 1.29007101e-01f, 1.03625782e-01f, 8.00834820e-02f, 2.29328070e-02f, -4.92172614e-02f, 5.25166206e-02f, 2.64139175e-02f,
  -8.00439343e-02f, -1.13183595e-01f, -6.77197054e-02f, -1.51771471e-01f, -1.97629139e-01f, -2.06190526e-01f, -1.38669834e-01f, -8.76139924e-02f, 3.03649828e-02f, 1.43886894e-01f,
  8.77096131e-02f, 1.73466384e-01f, -6.02780376e-03f, 1.86047554e-02f, -9.51322541e-02f, 5.27930968e-02f, -1.55316964e-01f, -4.11321782e-02f, -1.24632511e-02f, -1.64279357e-01f,
  -8.05370659e-02f, 4.88255732e-02f, -3.24206091e-02f, -1.16414621e-01f, -2.31019240e-02f, -5.22591956e-02f, 3.18347141e-02f, -6.60513118e-02f, -2.92313863e-02f, 3.58213745e-02f,
  -1.34706534e-02f, 5.28526232e-02f, -5.76006547e-02f, -4.89332639e-02f, 7.33356997e-02f, -2.17161961e-02f, 8.24852008e-03f, -4.39459980e-02f, -1.57033727e-02f, -2.88228095e-02f,
  -2.24441569e-02f, 7.89027587e-02f, 2.31284127e-02f, -6.55505583e-02f, 7.34202517e-03f, 5.21829166e-03f, -5.07331677e-02f, 4.07053977e-02f, -1.34200171e-01f, 9.17722583e-02f,
  2.26655807e-02f, 6.75811023e-02f, -3.16292495e-02f, -4.25709300e-02f, 7.57880285e-02f, 2.85179149e-02f, 6.04772307e-02f, 3.84492869e-03f, 4.83087339e-02f, 3.71110532e-03f,
  1.77487056e-03f, 1.64384153e-02f, 5.69439828e-02f, 5.33385463e-02f, -1.06429100e-01f, -5.41776754e-02f, 6.97728917e-02f, -1.22648656e-01f, -5.47315963e-02f, -7.30727986e-02f,
  -3.98915336e-02f, 2.87249219e-02f, 2.47556623e-02f, -8.70979205e-02f, -6.52990267e-02f, 5.59258759e-02f, 5.28535657e-02f, -2.14890167e-02f, 6.41245693e-02f, 1.00385562e-01f,
  1.60245076e-02f, -1.68993860e-01f, 6.38356805e-02f, 1.51093388e-02f, 5.91928400e-02f, -1.01791829e-01f, -4.19684276e-02f, 2.02941597e-02f, -4.84650284e-02f, -9.42165703e-02f,
  -6.25791624e-02f, 2.29256251e-03f, -1.62006225e-02f, -7.28901923e-02f, 5.66207692e-02f, 6.05838560e-03f, 8.18182379e-02f, 9.49704647e-02f, -4.36963849e-02f, -3.93054288e-05f,
  -2.44095884e-02f, 8.86287466e-02f, 3.33247371e-02f, -5.91025800e-02f, -1.29146418e-02f, -3.13239060e-02f, -1.10087246e-01f, -5.16473837e-02f, -3.73038724e-02f, 1.15137897e-01f,
  -2.43970379e-01f, 1.57530323e-01f, -2.38663808e-01f, 1.49124324e-01f, -4.33801971e-02f, -1.13804922e-01f, -1.56842530e-01f, -6.20430745e-02f, 1.43952131e-01f, 9.14765000e-02f,
  -1.05491653e-01f, 5.12825027e-02f, 6.55860305e-02f, -1.23668015e-01f, -1.99889019e-01f, 8.64442158e-03f, 5.66699542e-03f, -2.51324505e-01f, -2.87990987e-01f, -7.48026595e-02f,
  -1.71562359e-02f, 1.00520700e-01f, -1.77171513e-01f, -1.38561055e-03f, 1.95558831e-01f, 1.15326069e-01f, 6.01452263e-03f, 7.34437406e-02f, 5.30157275e-02f, 2.55548328e-01f,
  -1.68805555e-01f, -5.27272783e-02f, -1.39304280e-01f, 4.42492850e-02f, -2.34343521e-02f, -9.07707065e-02f, -2.19870601e-02f, 4.00125049e-02f, 3.99896614e-02f, 4.74205008e-03f,
  -1.47072673e-02f, 2.35729106e-02f, 2.06685215e-02f, -3.35186608e-02f, 3.45185101e-02f, -7.78931007e-02f, 6.17469312e-04f, -1.01114213e-01f, -7.89205283e-02f, -4.98247407e-02f,
  -3.51263620e-02f, -2.54544280e-02f, -1.37605190e-01f, 1.24561973e-02f, -6.12705052e-02f, -2.61476282e-02f, -1.03273056e-01f, -5.40209264e-02f, -1.37398377e-01f, 1.03743207e-02f,
  5.57449311e-02f, 1.06445819e-01f, 7.39403293e-02f, 1.15872800e-01f, 6.72807842e-02f, -2.51222309e-02f, 3.59921679e-02f, 4.81737554e-02f, -1.59068941e-03f, 1.03357188e-01f,
  -9.90940910e-03f, -1.57776661e-02f, 2.69921143e-02f, -1.38900653e-02f, 5.50434329e-02f, 4.37098965e-02f, -6.24834299e-02f, 8.23894888e-02f, -3.21710540e-04f, -3.79952835e-03f,
  6.80935904e-02f, -5.93004264e-02f, 4.83361930e-02f, 9.17555615e-02f, 7.70294815e-02f, -5.79051524e-02f, 1.02802135e-01f, -1.83439832e-02f, 1.88163843e-03f, 2.24907640e-02f,
  9.91415158e-02f, -8.02328959e-02f, -5.12541831e-02f, -1.71117634e-02f, 2.94263549e-02f, -8.31221044e-02f, -1.39775965e-02f, -8.11047778e-02f, -6.77184761e-02f, -6.24378510e-02f,
  -1.64369136e-01f, -9.91612673e-02f, 3.32068540e-02f, -7.98063278e-02f, -1.26538187e-01f, -1.13208912e-01f, -3.69912386e-03f, -9.26478058e-02f, -1.47523269e-01f, -8.68202373e-02f,
  -7.98338875e-02f, -1.80181473e-01f, -1.35762289e-01f, -7.07823783e-02f, -4.67560068e-03f, -1.59095198e-01f, -1.96371928e-01f, -2.27574185e-02f, -2.50729710e-01f, -9.33077279e-03f,
  -3.67069058e-02f, 9.77873243e-03f, -1.21347725e-01f, 4.21697050e-02f, 2.17468411e-01f, 2.05448985e-01f, 1.92493543e-01f, 1.83431938e-01f, 7.31092272e-03f, -9.82266366e-02f,
  -1.95814326e-01f, -3.00523758e-01f, -3.00312191e-01f, -3.14726233e-01f, -2.13339880e-01f, -1.68976355e-02f, -1.09446369e-01f, -2.64944971e-01f, -1.57069534e-01f, -2.26737559e-02f,
  1.58542003e-02f, -7.25707188e-02f, -8.35907981e-02f, -2.91149225e-03f, 3.53715196e-02f, -6.13015704e-02f, -4.93544936e-02f, -9.58705917e-02f, -9.44982395e-02f, -2.17763722e-01f,
  -2.51975238e-01f, 1.08942352e-01f, -1.17044680e-01f, -8.60717669e-02f, -5.44114858e-02f, -1.50030740e-02f, -4.26184312e-02f, -1.71854757e-02f, -1.28692225e-01f, -6.69570044e-02f,
  -4.37179692e-02f, -8.57192650e-03f, 7.10139144e-03f, -6.75668791e-02f, -8.84429961e-02f, -6.59471974e-02f, -3.50617394e-02f, -8.03177431e-02f, -1.57026440e-01f, 5.19617386e-02f,
  -1.28731683e-01f, 1.58578139e-02f, -9.39767808e-02f, 8.44844244e-03f, 8.89793446e-04f, -1.38963118e-01f, -1.43093109e-01f, 7.34246150e-02f, 2.23579258e-02f, -1.32034123e-01f,
  1.09576539e-03f, -1.02088023e-02f, 4.46355492e-02f, 8.63059834e-02f, 2.22729053e-02f, 6.69436753e-02f, 4.06108573e-02f, 2.33170483e-02f, -5.10116071e-02f, 6.34845048e-02f,
  5.56129627e-02f, 4.09036092e-02f, -1.56118078e-02f, 1.26110032e-01f, 6.06337264e-02f, 2.84701940e-02f, 8.00988376e-02f, 8.13921839e-02f, 4.35685255e-02f, 1.19844466e-01f,
  1.97162926e-02f, 5.44800349e-02f, 5.74019663e-02f, 9.26570371e-02f, 1.40310705e-01f, 1.09068483e-01f, 1.12205327e-01f, 6.31507337e-02f, 2.82985661e-02f, 1.46721572e-01f,
  -1.82172328e-01f, -1.98428944e-01f, -6.87258691e-02f, -1.67520359e-01f, -6.31322190e-02f, -9.33057442e-02f, -8.09931383e-02f, -6.01559617e-02f, -8.53285417e-02f, -4.12023440e-02f,
  -8.62716883e-02f, -1.22030884e-01f, -5.13244458e-02f, -6.06136285e-02f, -1.07415840e-01f, -6.55427203e-02f, -6.22086786e-02f, -1.51064724e-01f, -8.10499117e-02f, 5.84514774e-02f,
  -1.35060376e-03f, -5.27938977e-02f, -1.01791628e-01f, -1.09868027e-01f, -5.76760769e-02f, -1.40937254e-01f, -1.80506140e-01f, -1.13894612e-01f, -6.36663288e-02f, -1.42308012e-01f,
  3.96974772e-01f, -1.99063301e-01f, -1.60470441e-01f, -2.29789112e-02f, -2.00068861e-01f, -1.87759563e-01f, -1.96464807e-01f, 7.34808668e-02f, 2.70165522e-02f, -6.79323450e-02f,
  -1.37006804e-01f, 1.19195199e-02f, 8.37130323e-02f, -4.01843973e-02f, 1.69609245e-02f, -1.85894489e-01f, -1.54912964e-01f, 3.77411023e-02f, 3.79612893e-02f, 6.20722361e-02f,
  -6.63860589e-02f, -1.04153171e-01f, 1.08265162e-01f, -1.86311901e-02f, -3.18860896e-02f, -6.43369555e-02f, 5.93012292e-03f, -9.02402624e-02f, -8.14555064e-02f, -2.05801591e-01f,
  1.51156649e-01f, 1.46912485e-01f, 4.43831226e-03f, -1.00330196e-01f, -3.06183044e-02f, 9.06446800e-02f, -4.76591699e-02f, 1.31220117e-01f, -2.96331290e-02f, -4.85110693e-02f,
  -8.00832808e-02f, 8.03903639e-02f, -7.53823817e-02f, 4.67028506e-02f, -5.98183088e-02f, 8.96753594e-02f, 2.95916516e-02f, -4.90292301e-03f, -2.30155587e-02f, -2.62177084e-04f,
  -2.01532871e-01f, -1.58758074e-01f, 2.44113281e-02f, -8.35450217e-02f, 8.52116495e-02f, -3.03617343e-02f, 2.39420962e-03f, -1.65474378e-02f, -3.50391716e-02f, 5.05986214e-02f,
  -8.71734470e-02f, 5.37446141e-02f, -3.00540999e-02f, 1.50025010e-01f, 1.31049812e-01f, 7.26544484e-02f, -2.43495405e-02f, 7.77277863e-03f, -1.53215947e-02f, 7.68682137e-02f,
  1.24908604e-01f, 5.06607518e-02f, 9.77724418e-02f, 1.72266215e-01f, -2.88183894e-03f, 6.29932210e-02f, 1.85882617e-02f, 8.52879733e-02f, 6.95041344e-02f, 6.80872351e-02f,
  4.83484119e-02f, 7.53998309e-02f, 4.84773815e-02f, -8.66504945e-03f, 4.69768755e-02f, -6.24083355e-03f, 1.12626597e-01f, 4.53737155e-02f, 1.06512345e-01f, 3.19922864e-02f,
  1.22738861e-01f, -4.28182259e-02f, 4.70032953e-02f, 7.51330098e-03f, -2.09008493e-02f, -1.05240934e-01f, -3.94449122e-02f, -6.31724969e-02f, -2.09690314e-02f, 2.17074044e-02f,
  -6.45349994e-02f, 2.14724895e-02f, 4.58140597e-02f, -3.35661992e-02f, -4.64740582e-02f, 7.60093937e-03f, -1.05167210e-01f, -4.44382615e-03f, 2.85311658e-02f, 1.62034929e-02f,
  -4.80707139e-02f, -5.15637659e-02f, 1.22933790e-01f, -7.82802887e-03f, 4.64298613e-02f, -3.18347998e-02f, 5.24911173e-02f, 3.97920348e-02f, 2.76506525e-02f, -3.70359346e-02f,
  -2.59911895e-01f, -2.80016810e-01f, -7.78200775e-02f, 3.98035683e-02f, 1.59452945e-01f, -6.49321526e-02f, -2.43217215e-01f, -9.29292962e-02f, 7.01726899e-02f, -7.39216581e-02f,
  2.41480749e-02f, 2.66650468e-01f, 1.17598079e-01f, 1.54364914e-01f, -1.21756405e-01f, -2.76514262e-01f, -1.38126805e-01f, -3.88988331e-02f, 8.03737268e-02f, 2.09684700e-01f,
  1.03270091e-01f, 1.21805482e-01f, 1.02370478e-01f, 2.92303953e-02f, 7.50440955e-02f, 1.02436900e-01f, -8.49166885e-02f, 1.03267856e-01f, 3.94159779e-02f, -8.19300041e-02f,
  -1.63506687e-01f, -1.15680791e-01f, -1.36563201e-02f, 1.01971649e-01f, 2.65440978e-02f, 2.26032510e-02f, -3.44021209e-02f, -3.24886404e-02f, 4.17925417e-02f, -2.84465030e-02f,
  -3.51782492e-03f, 6.49561733e-03f, -7.08992127e-03f, 2.02009063e-02f, -6.44247904e-02f, 2.68373434e-02f, 1.71696451e-02f, 3.11981291e-02f, -3.66397314e-02f, 6.64748400e-02f,
  -3.87888923e-02f, 4.57758680e-02f, -1.34877473e-01f, -8.54171813e-02f, 2.23207846e-02f, 1.02412924e-01f, -3.62179652e-02f, -5.09326495e-02f, 1.56039186e-02f, -9.87014025e-02f,
  -4.24537584e-02f, 5.40765934e-02f, 4.89205606e-02f, -7.14870989e-02f, -2.43476685e-02f, -1.26976967e-02f, -1.62682142e-02f, -2.33631562e-02f, 4.27432880e-02f, -3.22379395e-02f,
  3.98049951e-02f, -3.94476429e-02f, 2.52633318e-02f, 4.98394743e-02f, -1.71661507e-02f, -6.99647516e-02f, 9.50114056e-02f, -3.92658822e-02f, -3.51090208e-02f, -1.82812326e-02f,
  -2.14993898e-02f, -4.73376140e-02f, 6.45628124e-02f, -1.17828008e-02f, -3.21736932e-02f, -2.02155840e-02f, -3.19732279e-02f, 3.31814252e-02f, -4.36877497e-02f, -4.78000604e-02f,
  -1.07993009e-02f, -9.93719790e-03f, -1.62913427e-01f, 5.81936203e-02f, -2.35684533e-02f, 1.70776155e-02f, -2.61486713e-02f, 4.07660604e-02f, 2.23194100e-02f, -1.23948865e-01f,
  -3.88576165e-02f, -1.33486679e-02f, -8.74755755e-02f, -1.94335077e-02f, 3.31344455e-02f, -8.59760866e-02f, -1.18937418e-01f, 3.54017280e-02f, -5.71686104e-02f, -7.36533627e-02f,
  -6.80786930e-03f, 1.95783694e-04f, -1.79793373e-01f, -6.99891662e-03f, 3.08645889e-02f, -1.39144510e-01f, -6.23359606e-02f, -6.46213070e-02f, -1.13056704e-01f, -2.01917842e-01f
};

// L0_fan_Wp_bar (Shape: 104 x 120)
const int L0_fan_Wp_bar_rows = 104;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -3.78585160e-01f, 4.56552893e-01f, -4.00736541e-01f, -2.63445020e-01f, -4.37118188e-02f, 2.48843640e-01f, 5.73301792e-01f, 1.87370911e-01f, 2.15207394e-02f, 2.63716787e-01f,
  -5.84825948e-02f, -2.66302764e-01f, -2.73491800e-01f, -6.25732646e-04f, 1.52514771e-01f, 3.70031983e-01f, 2.12003872e-01f, -2.21707866e-01f, -3.23765844e-01f, 7.56365582e-02f,
  2.16255009e-01f, -2.87625194e-01f, -2.68910348e-01f, -1.30738735e-01f, -3.72170396e-02f, -1.79675281e-01f, -2.02394277e-01f, -1.19746499e-01f, 1.10668950e-01f, 1.47640239e-02f,
  -3.13112378e-01f, -3.53020161e-01f, -2.22617239e-01f, -3.76793742e-01f, -2.36601293e-01f, 2.22828612e-02f, 1.39194041e-01f, -1.53311759e-01f, -1.24529071e-01f, -1.28964037e-01f,
  -2.54183292e-01f, 2.92100646e-02f, -2.76751161e-01f, -6.41494915e-02f, -1.29258245e-01f, -1.84207112e-02f, -1.76974893e-01f, -1.39001399e-01f, -2.23190174e-01f, -1.09432802e-01f,
  2.25143731e-01f, -1.36351913e-01f, -3.42585832e-01f, 1.00000449e-01f, -1.29705397e-02f, -2.31740385e-01f, -2.27729127e-01f, -7.62814283e-02f, -1.37230143e-01f, -1.65866300e-01f,
  5.05971387e-02f, 8.06252435e-02f, 5.27835004e-02f, -2.87910718e-02f, 1.02631897e-01f, 2.64599978e-04f, 1.21745365e-02f, 9.71456897e-03f, -9.32671726e-02f, -1.27578303e-01f,
  -1.00702196e-01f, -5.31973839e-02f, -9.35130417e-02f, -1.59696899e-02f, -1.18197300e-01f, -3.41795459e-02f, 1.54065937e-01f, 8.66776928e-02f, 4.55823122e-03f, -4.36847210e-02f,
  -2.36439705e-02f, -4.99312244e-02f, -6.95367083e-02f, 7.36377165e-02f, 1.38064489e-01f, 8.61206949e-02f, 1.51836202e-01f, -5.24634682e-02f, -7.04796091e-02f, -9.31155682e-02f,
  -2.99265206e-01f, 9.48339328e-03f, -3.07978634e-02f, 7.34569430e-02f, -1.60426468e-01f, -1.75912604e-01f, -6.33649379e-02f, 2.34158449e-02f, -6.36017397e-02f, -1.12901472e-01f,
  -7.71009177e-02f, 1.10833058e-02f, -4.83740605e-02f, 1.92264467e-02f, -9.06557068e-02f, 1.89241697e-03f, 2.61504084e-01f, -9.01615899e-03f, 3.80902775e-02f, -9.73953381e-02f,
  1.50613084e-01f, 1.50826871e-01f, -1.92547999e-02f, 4.08387650e-03f, 8.76877159e-02f, -1.50300264e-01f, -1.93260506e-01f, -6.27464578e-02f, -3.36868502e-02f, -4.69966512e-03f,
  3.38768572e-01f, -2.99194902e-01f, 2.95264333e-01f, -7.26078972e-02f, -2.44716585e-01f, -1.45814329e-01f, -2.76735574e-01f, -1.34092242e-01f, -1.66059881e-01f, -1.39711633e-01f,
  -4.07603607e-02f, -6.71688840e-03f, 1.22193106e-01f, 1.48046881e-01f, 1.39983609e-01f, -1.29139081e-01f, 4.03018780e-02f, 2.79419661e-01f, 2.78241545e-01f, -3.21520232e-02f,
  -1.17624417e-01f, -2.83163451e-02f, 6.41152710e-02f, 3.79744880e-02f, -1.31929338e-01f, -1.05836548e-01f, -6.87241852e-02f, -6.56519756e-02f, -1.32935807e-01f, -5.67587763e-02f,
  8.04966837e-02f, -1.04454368e-01f, 4.97205295e-02f, -7.96196908e-02f, -4.02374454e-02f, 2.41753701e-02f, 8.76408666e-02f, -4.59452532e-02f, -7.00681955e-02f, -9.75989923e-02f,
  -1.06469445e-01f, -2.93635521e-02f, -4.33210023e-02f, 1.15790153e-02f, -1.33261159e-01f, -7.15027228e-02f, -2.81348471e-02f, -5.83334900e-02f, -4.21348959e-02f, -2.77633257e-02f,
  -1.68507352e-01f, -1.44888148e-01f, 1.57437623e-02f, -1.00854672e-01f, 2.15847436e-02f, 3.36182863e-02f, 1.18225748e-02f, 5.48192859e-02f, 3.75580341e-02f, 4.07044124e-03f,
  -2.07658354e-02f, 7.35190883e-02f, -7.41960341e-03f, -4.32641953e-02f, -9.10604000e-02f, -5.91269843e-02f, -5.80986105e-02f, 3.44800740e-03f, 3.71408127e-02f, -1.07822284e-01f,
  -8.41804370e-02f, -1.00834399e-01f, -1.62066065e-03f, -7.33160526e-02f, 1.05921865e-01f, -9.35662724e-03f, -5.89373242e-03f, -1.07115135e-01f, 7.01392740e-02f, -4.15800884e-03f,
  -2.91080698e-02f, 2.59160530e-03f, -2.18341574e-02f, -1.38166487e-01f, -7.16847479e-02f, -5.42832240e-02f, -5.12184750e-04f, 3.26459929e-02f, 8.55996180e-03f, -5.94171137e-02f,
  -1.28526986e-01f, 2.14824662e-01f, -3.39261256e-02f, 1.03596330e-01f, -5.50176650e-02f, 3.34758312e-02f, 9.66561362e-02f, -3.45888175e-02f, 5.17194718e-03f, 7.13558570e-02f,
  -7.88756534e-02f, 1.17894605e-01f, 4.04943936e-02f, -6.45795763e-02f, -1.04544304e-01f, -8.22247267e-02f, -7.60665610e-02f, 3.05227637e-02f, -3.72876003e-02f, -1.36183813e-01f,
  -2.75733024e-02f, -1.90668907e-02f, 2.35917214e-02f, 5.10464832e-02f, -7.45472312e-02f, 1.64076630e-02f, 9.41251218e-02f, -4.33911122e-02f, 6.64067864e-02f, -8.48339126e-02f,
  4.02372390e-01f, 1.84080854e-01f, 4.05647933e-01f, 1.55780539e-01f, -1.46336168e-01f, -2.69331306e-01f, -3.69461209e-01f, -3.20612341e-01f, -8.03332031e-02f, 1.51341960e-01f,
  1.37668014e-01f, 8.75089467e-02f, 4.89324424e-03f, -9.95375514e-02f, -2.18121320e-01f, -1.03997819e-01f, 1.27473166e-02f, -6.11778460e-02f, -2.34636202e-01f, -2.93550521e-01f,
  -2.13812441e-01f, -5.97463995e-02f, -6.58456683e-02f, -1.11843131e-01f, 2.36688882e-01f, 7.82079995e-02f, 2.24352971e-01f, 2.59776890e-01f, 1.79156631e-01f, 5.20537674e-01f,
  5.06142318e-01f, 3.06599319e-01f, -2.32445449e-01f, 7.55895823e-02f, 1.73142821e-01f, 7.25599378e-02f, 4.96329553e-02f, 7.03724921e-02f, -2.82555129e-02f, 6.65719286e-02f,
  8.00707191e-02f, 7.37938508e-02f, -5.53326197e-02f, 1.20519690e-01f, -3.68931554e-02f, -4.84066010e-02f, 3.12899426e-02f, 7.38108484e-03f, -3.73067781e-02f, 7.38307014e-02f,
  -1.09079249e-01f, 1.28664570e-02f, -5.16988412e-02f, -1.97269052e-01f, -1.58973690e-02f, -8.54576454e-02f, -5.90651147e-02f, -6.70309039e-03f, -7.77447075e-02f, 2.50367463e-01f,
  -8.95016640e-02f, 3.98590378e-02f, 5.76248653e-02f, 5.63734472e-02f, -3.93551029e-02f, 5.95936030e-02f, 4.98711653e-02f, -8.94531384e-02f, -1.70174967e-02f, -2.16970090e-02f,
  -3.74349467e-02f, 4.88821566e-02f, -3.71030271e-02f, 1.43367155e-02f, 6.98528290e-02f, 3.27542610e-02f, 6.37147725e-02f, -2.90299151e-02f, 5.36677502e-02f, -3.28796357e-02f,
  5.39806671e-02f, -5.35642281e-02f, 5.67575544e-02f, -6.60620257e-02f, 1.24180526e-01f, 4.28240374e-02f, -8.11377540e-03f, 5.20751886e-02f, -4.57288772e-02f, 8.34494308e-02f,
  -2.25078553e-01f, -3.35962176e-01f, 1.48879498e-01f, -8.83505195e-02f, 8.55524018e-02f, 4.51319059e-03f, 1.20686762e-01f, 2.07271110e-02f, 1.36932552e-01f, -7.82958418e-03f,
  -1.23555353e-02f, 1.37389570e-01f, -5.23393601e-03f, -6.22783378e-02f, -1.20216705e-01f, -7.94987194e-03f, -7.00161010e-02f, -7.01127872e-02f, -1.15813747e-01f, 1.05584944e-02f,
  -1.75171167e-01f, -4.23062712e-01f, -3.44416380e-01f, -3.40366125e-01f, -7.89154023e-02f, -3.92637491e-01f, -1.00762740e-01f, -2.04610556e-01f, -3.35058868e-01f, -2.79390812e-01f,
  7.76161999e-02f, 4.35098976e-01f, 2.68267810e-01f, -2.73164541e-01f, 1.22923665e-01f, 1.76192299e-01f, 2.73887277e-01f, -1.85173810e-01f, -2.67557532e-01f, 1.71463162e-01f,
  3.58274728e-01f, -1.15151331e-01f, -1.45943716e-01f, -1.40678793e-01f, -1.51994765e-01f, -1.62473574e-01f, -2.86392599e-01f, -3.14084560e-01f, -2.62948573e-01f, -1.74246207e-01f,
  -1.31777450e-01f, -3.94662023e-02f, -1.47777110e-01f, -2.21723542e-01f, 1.16227582e-01f, -1.01618834e-01f, 2.68693894e-01f, 2.64278799e-01f, 2.64386863e-01f, 6.45109192e-02f,
  3.78104925e-01f, 2.36128747e-01f, -3.35887522e-01f, -8.80708694e-02f, 2.54465520e-01f, -2.53092587e-01f, -1.25926644e-01f, -1.53489023e-01f, -1.60860732e-01f, -7.16058314e-02f,
  2.11627290e-01f, 3.88710462e-02f, 7.90150836e-02f, 4.58054952e-02f, 8.69813655e-03f, -2.59482861e-02f, -1.26129642e-01f, -2.41345033e-01f, -1.42928332e-01f, 5.82312420e-02f,
  1.16584465e-01f, 3.02120596e-01f, 2.08144352e-01f, -1.10360622e-01f, 1.27725676e-01f, -6.71157148e-03f, 3.30102026e-01f, 1.84517473e-01f, 8.92881304e-02f, 1.69531763e-01f,
  -5.68335913e-02f, -2.00724462e-03f, -6.28373995e-02f, 2.43903231e-02f, -1.75405324e-01f, -5.35963513e-02f, 2.54580341e-02f, -9.11379792e-03f, -1.43745854e-01f, 4.25808728e-02f,
  -3.17067141e-03f, 2.94487868e-02f, -3.69868651e-02f, -2.73903627e-02f, -9.97972339e-02f, 8.33296031e-02f, -1.05450176e-01f, -1.36614412e-01f, 3.24524231e-02f, 4.30933759e-02f,
  -5.04219793e-02f, -3.27955522e-02f, 4.90394905e-02f, -6.78638965e-02f, -1.01431124e-01f, -1.51143774e-01f, -1.20111428e-01f, 7.37566128e-02f, -1.07953893e-02f, 8.63639787e-02f,
  -6.76065609e-02f, -3.30063589e-02f, -1.40918657e-01f, -1.21845618e-01f, -2.12735850e-02f, 2.78515695e-03f, -1.23948557e-02f, -1.94218799e-01f, 3.88924703e-02f, 1.73858851e-02f,
  1.47658899e-01f, -1.82553843e-01f, 1.23187276e-02f, -1.13456465e-01f, -1.88181311e-01f, -4.94465567e-02f, -2.21925214e-01f, -3.99255566e-02f, -1.24915533e-01f, 1.44185454e-01f,
  -2.01101661e-01f, -2.69480526e-01f, -1.38587996e-01f, -3.06677938e-01f, -9.19381082e-02f, -3.83287311e-01f, 1.67596787e-01f, -8.81020799e-02f, -1.36250347e-01f, -1.78160712e-01f,
  2.80077219e-01f, 3.46195966e-01f, 2.09191501e-01f, 1.62581205e-01f, 2.25688875e-01f, 1.10606648e-01f, 2.86028653e-01f, 8.28712210e-02f, -2.91477293e-02f, 5.69619164e-02f,
  1.34858876e-01f, -3.98884900e-02f, 3.98380356e-03f, -1.10679930e-02f, -1.32415190e-01f, 6.91698492e-02f, -3.89460959e-02f, -3.59070264e-02f, -9.40018669e-02f, 1.53668731e-01f,
  1.44669801e-01f, 2.12672740e-01f, 1.20985387e-02f, 4.77764606e-02f, 1.89572155e-01f, 1.23331919e-02f, 1.00501932e-01f, 2.56978095e-01f, 1.26449391e-01f, 1.13386989e-01f,
  -3.40686142e-02f, 1.27708286e-01f, -2.38896787e-01f, -5.08233644e-02f, 6.08915277e-02f, -1.24366008e-01f, -1.30004361e-01f, -5.82248382e-02f, 2.35488955e-02f, -5.54830208e-02f,
  5.52784391e-02f, -2.97327247e-02f, -1.23456446e-02f, 1.85348006e-04f, -2.12021470e-02f, -4.93879877e-02f, -2.97189429e-02f, -1.28031552e-01f, -1.16356678e-01f, -4.09000330e-02f,
  1.17326364e-01f, 1.86219066e-01f, 7.63732120e-02f, -2.34115552e-02f, -1.11137830e-01f, -9.42885205e-02f, 4.81395684e-02f, -1.03753872e-01f, -1.35701433e-01f, -5.45887947e-02f,
  -2.30166733e-01f, 9.26063657e-02f, -3.10229883e-02f, -7.94591531e-02f, 5.31823002e-03f, -5.44295758e-02f, 4.96478043e-02f, -8.48559081e-04f, 1.99822150e-02f, -2.94065140e-02f,
  1.39483539e-02f, -1.11411631e-01f, -6.19064867e-02f, -5.40403761e-02f, 2.49052830e-02f, 7.32218400e-02f, 5.69185242e-02f, -5.89114090e-04f, 5.25207929e-02f, -1.28824517e-01f,
  -4.89318818e-02f, 3.43984663e-02f, -3.38829570e-02f, -6.99294955e-02f, -7.38292709e-02f, -9.50358286e-02f, 7.19259866e-03f, -5.77810481e-02f, -7.13109747e-02f, 4.12452668e-02f,
  -2.61757731e-01f, -1.93559200e-01f, -1.44299090e-01f, -1.35011241e-01f, 1.46887898e-02f, -5.11341766e-02f, -2.03512795e-02f, -3.95231880e-02f, -7.47340149e-04f, -1.16428286e-01f,
  4.28614542e-02f, -1.18728705e-01f, -5.92273660e-02f, -3.29144225e-02f, -7.81007931e-02f, -3.26163732e-02f, -5.66757880e-02f, -6.93843327e-03f, -4.36589457e-02f, 1.79210976e-02f,
  -6.02685921e-02f, -6.41454533e-02f, -1.06392637e-01f, -2.58227680e-02f, -7.32389465e-02f, -7.73408636e-02f, -7.71683827e-02f, -9.39662308e-02f, -1.82541028e-01f, -2.31415108e-01f,
  -3.56954634e-02f, -3.42768490e-01f, 4.00656998e-01f, -1.11388311e-01f, 2.29187962e-02f, -1.19920872e-01f, -1.36278912e-01f, -2.79902101e-01f, -1.96383402e-01f, -8.88775736e-02f,
  -3.46903890e-01f, -2.04470500e-01f, -1.97505981e-01f, -2.70153377e-02f, -9.41006020e-02f, 7.41310120e-02f, 2.48776808e-01f, 3.38466167e-01f, 3.27548325e-01f, -2.83743180e-02f,
  -3.89537737e-02f, 1.28527790e-01f, 8.00580084e-02f, -2.98581049e-02f, -7.32303560e-02f, 4.23930623e-02f, -8.47248733e-02f, 4.75400090e-02f, -6.54944777e-02f, 2.55629092e-01f,
  2.30837032e-01f, -9.59970951e-02f, 3.21225896e-02f, -1.79894671e-01f, -9.81914550e-02f, -7.66155571e-02f, -6.02366626e-02f, 3.78598236e-02f, -2.06868276e-01f, -3.60281318e-02f,
  -9.42196473e-02f, -8.15188885e-02f, -9.50319245e-02f, -8.85884836e-02f, -1.00063987e-01f, -5.24494648e-02f, -3.36555131e-02f, -3.29454839e-02f, -1.13175310e-01f, -2.01880243e-02f,
  -1.53609499e-01f, -8.72642621e-02f, -1.27352744e-01f, -2.60260463e-01f, -1.04374059e-01f, -4.50998225e-04f, -1.35733277e-01f, -1.86576545e-01f, -5.17714173e-02f, -5.68971857e-02f,
  -1.24269547e-02f, -1.31551489e-01f, -1.05723165e-01f, -1.04795381e-01f, -1.93333194e-01f, -1.27640173e-01f, 1.02554103e-02f, -1.76448300e-01f, -1.33255005e-01f, -4.01181467e-02f,
  -1.29954770e-01f, -1.56377614e-01f, -2.08851889e-01f, 2.44059321e-03f, -6.34791180e-02f, -4.63864282e-02f, -1.06088050e-01f, -1.72566861e-01f, -1.80949956e-01f, -7.59333000e-02f,
  -8.61511901e-02f, -3.25611979e-02f, -7.15941712e-02f, -9.84780341e-02f, -1.52149796e-01f, -2.49325320e-01f, -8.90733898e-02f, -1.79714173e-01f, -2.17120647e-02f, -6.43070713e-02f,
  -1.20241553e-01f, 8.24807771e-03f, 1.06382445e-01f, 4.93844189e-02f, 1.21989876e-01f, -9.73226354e-02f, -3.28276353e-03f, 7.26910159e-02f, 1.01163834e-01f, 9.76332948e-02f,
  -6.57202378e-02f, 1.27625063e-01f, 1.06150530e-01f, -2.29103472e-02f, 1.34127155e-01f, 1.13914564e-01f, -1.52371794e-01f, -1.68309882e-02f, -4.19649407e-02f, -2.46705972e-02f,
  1.86520591e-02f, 1.35289937e-01f, 1.69607565e-01f, -4.38167192e-02f, -7.03815743e-02f, 2.49239981e-01f, 4.61112224e-02f, 5.92096150e-02f, 1.53538600e-01f, 3.60626616e-02f,
  5.52139103e-01f, 2.26469129e-01f, 3.14737201e-01f, 3.59980524e-01f, 2.21590042e-01f, 1.13711521e-01f, 1.53990790e-01f, -2.11266819e-02f, 5.56280874e-02f, 1.69617027e-01f,
  1.43902957e-01f, 5.01583628e-02f, -7.89296776e-02f, -5.75017370e-03f, 4.55432981e-02f, 2.05688365e-02f, 5.08147329e-02f, 7.57509470e-02f, -2.54537798e-02f, 2.24665850e-01f,
  2.11618721e-01f, 1.34859562e-01f, 1.52169615e-01f, 4.79998998e-03f, 2.14850679e-01f, 1.42290905e-01f, 1.93690751e-02f, 1.72015682e-01f, 2.36961395e-01f, 3.50374132e-01f,
  2.75263667e-01f, 4.70462888e-02f, -1.33785754e-01f, -6.19660467e-02f, -3.00797317e-02f, -4.61595729e-02f, 1.87840499e-02f, -1.35886014e-01f, -1.21841148e-01f, -7.82780051e-02f,
  -3.08521856e-02f, 4.00655158e-02f, 6.24433681e-02f, -7.75577128e-02f, -1.11035269e-03f, -1.25941291e-01f, -9.79616269e-02f, -1.46800682e-01f, -1.51068777e-01f, -2.81083789e-02f,
  -1.79737788e-02f, 9.79715139e-02f, 5.77522665e-02f, -5.13102151e-02f, 9.65873972e-02f, 1.54348165e-02f, -4.40164022e-02f, 4.03518341e-02f, -1.40388086e-02f, -4.29178290e-02f,
  9.10410136e-02f, 1.58485696e-01f, 7.60458410e-02f, 3.78353857e-02f, -2.70068981e-02f, -9.13863778e-02f, 1.36900665e-02f, 3.42512205e-02f, 4.52532396e-02f, 1.32534057e-02f,
  6.02801666e-02f, -3.39321839e-03f, 2.10754126e-02f, 6.22072034e-02f, -2.12482270e-02f, 1.81512292e-02f, -2.29868088e-02f, -6.13216795e-02f, 6.74847094e-03f, -2.90073715e-02f,
  6.55037984e-02f, -1.50424257e-01f, -8.31570253e-02f, -1.73012614e-01f, -2.05796465e-01f, 2.28161663e-02f, 3.41028273e-02f, -1.11159205e-03f, -8.60352814e-03f, -4.91834506e-02f,
  -3.82465035e-01f, -1.49876833e-01f, 8.02978426e-02f, -1.59639835e-01f, 9.62486714e-02f, -1.08322106e-01f, -2.11484358e-02f, -1.66429505e-01f, -9.85034704e-02f, -4.54032831e-02f,
  -2.06007976e-02f, -2.50428002e-02f, -5.45127951e-02f, -4.40164655e-02f, 1.73427872e-02f, -6.81233630e-02f, -8.40471983e-02f, -1.01229288e-01f, -1.71404511e-01f, -6.24321662e-02f,
  -2.09480597e-04f, 2.92193349e-02f, -9.80376974e-02f, -4.23426814e-02f, -7.40784407e-02f, -3.04450039e-02f, -3.29725482e-02f, -1.08463600e-01f, -4.11631539e-02f, -8.74568075e-02f,
  -1.29071251e-01f, -1.12286232e-01f, -7.25616962e-02f, -9.04720929e-03f, 2.80726925e-02f, 1.52053356e-01f, 3.19933712e-01f, 2.39111826e-01f, 7.01982751e-02f, 3.21651250e-01f,
  -1.17064975e-01f, -4.32901919e-01f, -2.81923503e-01f, -1.72905087e-01f, -1.63431183e-01f, 4.41239029e-01f, 2.91528463e-01f, -1.82458013e-01f, -2.68770665e-01f, 1.63937565e-02f,
  6.73997700e-02f, -1.38129489e-02f, -2.86276877e-01f, -1.04778327e-01f, -7.68784657e-02f, -9.12581086e-02f, 1.79257393e-02f, -1.49440467e-01f, -1.40685245e-01f, -1.12726599e-01f,
  1.33157492e-01f, -2.40765631e-01f, 1.40456157e-02f, -1.60975561e-01f, 3.55906188e-02f, 7.45506063e-02f, -6.40610117e-04f, -1.07940771e-02f, -5.40275639e-03f, 1.15371987e-01f,
  -1.57998443e-01f, -1.02295034e-01f, -2.56959349e-01f, -6.58297241e-02f, -1.49077401e-01f, -3.65685262e-02f, -1.43908218e-01f, -1.54101312e-01f, -2.26396486e-01f, -8.45733956e-02f,
  -1.76060423e-01f, -1.14023648e-01f, -1.31692141e-01f, -2.59490460e-02f, -1.94480732e-01f, -1.04889460e-01f, -6.90864623e-02f, -1.47009552e-01f, -7.73486346e-02f, 1.43945873e-01f,
  1.84851393e-01f, 1.62576467e-01f, 1.95929315e-03f, 4.10441607e-02f, 1.60976965e-02f, -7.55440593e-02f, -1.15817457e-01f, 5.34068607e-02f, 1.03925141e-02f, 8.25471357e-02f,
  -3.32545526e-02f, 1.34369835e-01f, -1.10516317e-01f, -9.58881341e-03f, -3.47029476e-04f, -3.11820419e-03f, -3.63694690e-02f, 1.26593396e-01f, 6.38315978e-04f, 2.90439520e-02f,
  -6.28594756e-02f, -1.27576634e-01f, -3.18265110e-02f, -1.01975128e-01f, 8.95239264e-02f, -9.75152999e-02f, 9.26203132e-02f, -7.40294158e-02f, -2.68312078e-02f, 2.71816049e-02f,
  1.28471240e-01f, -1.25468627e-01f, 5.07744849e-02f, -4.03375775e-02f, 9.45526958e-02f, 9.30042379e-03f, -6.37719501e-03f, -2.69539822e-02f, 6.05691187e-02f, 3.24846394e-02f,
  -1.68280587e-01f, -7.05307722e-02f, -7.71443695e-02f, 8.90386570e-03f, -5.66613935e-02f, 6.99430555e-02f, 1.12705743e-02f, -2.06196886e-02f, -1.21119861e-02f, 4.61586565e-02f,
  5.48571385e-02f, 2.28828028e-01f, 1.54962927e-01f, 2.23254219e-01f, 4.88136010e-03f, 1.57487422e-01f, 2.35807687e-01f, 1.26333103e-01f, 3.43967937e-02f, 4.47348148e-01f,
  2.53495008e-01f, -3.83473843e-01f, 1.66201577e-01f, 1.76318422e-01f, 9.97982398e-02f, 2.46879663e-02f, 7.97843561e-02f, 3.09872143e-02f, 6.88536018e-02f, 9.27386060e-02f,
  -2.59410501e-01f, -2.73795485e-01f, 2.96820712e-04f, -8.38140771e-02f, -9.60114375e-02f, 1.70894131e-01f, 1.27018064e-01f, 1.48235932e-01f, -4.70325910e-02f, -2.19490662e-01f,
  -1.48948669e-01f, -5.65569215e-02f, -1.19068131e-01f, -1.25300605e-02f, 1.02048077e-01f, -3.64451967e-02f, 1.32165283e-01f, -1.43366128e-01f, -1.65608555e-01f, 7.27980658e-02f,
  2.07297638e-01f, -1.61514699e-01f, 5.37342280e-02f, -2.24376410e-01f, -7.83417895e-02f, -2.30462048e-02f, 9.00017750e-03f, 5.04897954e-03f, -7.67841637e-02f, 8.49227309e-02f,
  -1.41670361e-01f, -1.21403813e-01f, 4.41323183e-02f, 6.21607080e-02f, 1.20507151e-01f, -4.34522144e-02f, 1.36543475e-02f, 9.65855643e-03f, -5.63401682e-03f, -7.73844868e-02f,
  -3.56642492e-02f, -1.55287936e-01f, -2.71273479e-02f, -9.39649995e-03f, -1.87513363e-02f, 2.98724566e-02f, -3.74241844e-02f, -1.42358616e-01f, -1.64024323e-01f, 8.83651376e-02f,
  -5.74091775e-03f, 1.89560741e-01f, 3.54297608e-02f, 7.51239574e-03f, 9.52919200e-03f, -8.14586952e-02f, 3.98216546e-02f, -1.61353480e-02f, 3.89911118e-03f, 8.45631808e-02f,
  -5.72795495e-02f, -4.45074029e-02f, 8.85165557e-02f, 7.11149946e-02f, 6.62975684e-02f, 9.20925960e-02f, 1.01187102e-01f, 6.51726052e-02f, 4.30615395e-02f, 6.43951148e-02f,
  -8.11300427e-02f, 1.93007924e-02f, 4.32383828e-02f, 2.11750474e-02f, -1.11630142e-01f, 6.79317117e-02f, 3.02973669e-02f, -8.06156322e-02f, 5.80104925e-02f, 3.15182097e-03f,
  2.92117596e-01f, -1.65567487e-01f, 1.26155168e-01f, -1.22283168e-01f, 4.14295308e-02f, -9.70778614e-03f, -8.89819711e-02f, -1.01637155e-01f, 5.91754913e-02f, -7.80069232e-02f,
  -3.67439836e-02f, 3.61649469e-02f, 7.61898905e-02f, 1.90952402e-02f, 1.43799633e-01f, 1.12395711e-01f, -7.98177347e-02f, -2.17386354e-02f, -1.08080715e-01f, -7.62357935e-03f,
  -5.30098379e-02f, 1.05878450e-01f, 2.42589265e-01f, 1.30098552e-01f, -2.50009354e-02f, 5.73525950e-02f, 8.52253959e-02f, 4.91095781e-02f, 6.60474747e-02f, 2.75697500e-01f,
  -4.72597629e-01f, 3.33534837e-01f, 8.63765702e-02f, -2.04733387e-01f, -2.23390713e-01f, -1.83565930e-01f, 2.33617380e-01f, -1.01091608e-01f, -2.43509874e-01f, 1.89110368e-01f,
  1.89931765e-01f, -1.80695206e-01f, -2.03856096e-01f, -1.51878908e-01f, -2.16702536e-01f, 4.85951751e-02f, -2.52560437e-01f, -4.03539926e-01f, -5.23370206e-01f, -2.38737762e-01f,
  -1.99448287e-01f, -4.56836700e-01f, -5.07679343e-01f, -2.49072567e-01f, -6.86608031e-02f, -2.39764512e-01f, -1.69227868e-01f, -2.87877053e-01f, -1.99965730e-01f, -1.14407077e-01f,
  2.95181721e-01f, -1.31680101e-01f, -2.71946732e-02f, -3.49914543e-02f, 2.68821046e-02f, -1.73696168e-02f, 5.51911816e-02f, 7.43821934e-02f, 1.30497143e-01f, 2.14882329e-01f,
  -6.59341812e-02f, -8.75518471e-02f, -7.46062323e-02f, 5.76895438e-02f, 1.11079738e-01f, 8.64496175e-03f, 1.04417048e-01f, -2.94735152e-02f, 5.29423840e-02f, 2.14186653e-01f,
  2.51174510e-01f, 4.52151746e-02f, 1.71918735e-01f, 1.64282635e-01f, 9.17047560e-02f, 2.53164992e-02f, 6.42310306e-02f, -4.81064022e-02f, 3.79863493e-02f, 5.72653860e-02f,
  -2.82899681e-02f, 1.57694295e-01f, -8.65583960e-03f, -2.50309892e-02f, 1.80512801e-01f, 3.10073122e-02f, 6.21571578e-02f, 1.51639491e-01f, 1.14078773e-02f, -2.19955519e-02f,
  1.50870919e-01f, 9.33648571e-02f, 4.54803929e-03f, -7.31939152e-02f, -1.23010233e-01f, 5.94179817e-02f, -2.03737598e-02f, 1.71017811e-01f, 5.84236607e-02f, 1.59917716e-02f,
  5.73882572e-02f, 1.04147293e-01f, 2.31656581e-02f, 8.20771977e-02f, 9.80104208e-02f, 3.07469442e-02f, -5.79106696e-02f, -3.32149379e-02f, -1.20157167e-01f, 4.18828577e-02f,
  7.48308450e-02f, -1.75194442e-01f, 1.41987633e-02f, -5.22256605e-02f, 3.82758561e-03f, 9.65031609e-02f, 7.42357746e-02f, -1.81196909e-02f, -3.41078416e-02f, -2.49166433e-02f,
  3.18291970e-02f, 3.91349606e-02f, 7.72471353e-02f, 7.52911270e-02f, -1.05602272e-01f, -5.34592643e-02f, 1.75204143e-01f, 6.56426921e-02f, -2.93971598e-02f, 9.01265368e-02f,
  1.76609203e-01f, 9.78876725e-02f, -3.52440141e-02f, 1.38684034e-01f, 2.57826839e-02f, -1.37949094e-01f, 2.98163164e-02f, 1.49093317e-02f, -7.05777630e-02f, 7.28098080e-02f,
  -4.80132759e-01f, -1.10265762e-01f, -6.87278867e-01f, -1.24131218e-02f, 2.88378686e-01f, -1.25477701e-01f, -1.09835900e-01f, -1.55785054e-01f, 2.86618602e-02f, -9.77670550e-02f,
  1.67206734e-01f, 1.97993889e-01f, -8.57273638e-02f, 6.08130693e-02f, -1.88183755e-01f, -1.50141150e-01f, -7.69996420e-02f, -2.79378533e-01f, 7.36677945e-02f, 4.21312153e-01f,
  5.41293502e-01f, 2.74808079e-01f, -6.15371689e-02f, 2.32240167e-02f, 1.69368953e-01f, 2.05191791e-01f, -1.57972038e-01f, 1.55060843e-01f, 1.53328747e-01f, 7.66961798e-02f,
  -3.55364054e-01f, -4.78885174e-01f, 9.67829823e-02f, 2.96271324e-01f, 4.61669415e-02f, -3.26468170e-01f, -1.46116659e-01f, -1.79180890e-01f, -8.40411037e-02f, -1.27319217e-01f,
  1.69953287e-01f, -8.52522850e-02f, 1.29049674e-01f, -5.72609901e-02f, -1.14509091e-01f, -3.16775948e-01f, -2.36845300e-01f, -3.24223787e-01f, -5.21505117e-01f, -2.43294254e-01f,
  4.23504680e-01f, 2.83417225e-01f, -3.25386316e-01f, -2.59313494e-01f, -4.01126832e-01f, 3.10771028e-03f, -2.00319991e-01f, -1.71896234e-01f, -5.86786747e-01f, -3.88660371e-01f,
  -9.38581824e-02f, 2.97894478e-02f, -2.40092315e-02f, -6.67840689e-02f, 1.12226829e-01f, 1.26774481e-03f, 1.85412839e-02f, 1.65534317e-02f, -4.91190329e-02f, -4.67933193e-02f,
  -1.09475650e-01f, -1.60404697e-01f, -8.70195106e-02f, -5.28029650e-02f, 1.35977224e-01f, 3.30730714e-02f, 3.14804651e-02f, 5.92059121e-02f, -7.67005933e-03f, 8.46032146e-03f,
  1.54489074e-02f, -6.95706010e-02f, 7.21947402e-02f, 4.88910973e-02f, -1.48726985e-01f, -5.03928326e-02f, -1.19873639e-02f, 4.61628325e-02f, -2.00200509e-02f, -8.06645378e-02f,
  -4.73344475e-02f, -5.72265089e-02f, -8.89640227e-02f, 1.08808344e-02f, -1.80785581e-02f, -4.86683100e-02f, 4.47664596e-02f, -2.21702978e-02f, -1.93077907e-01f, -1.84540123e-01f,
  -8.06427523e-02f, -9.10023376e-02f, -2.44824626e-02f, 1.61904190e-02f, -1.70600135e-02f, -1.28839418e-01f, 4.35626246e-02f, -1.26921693e-02f, -8.63990486e-02f, -4.69364710e-02f,
  -6.72838613e-02f, -3.92723130e-03f, -2.68059701e-01f, -2.67614394e-01f, -3.70277762e-02f, -5.50764287e-03f, -1.84310704e-01f, -7.04244897e-02f, -2.59627044e-01f, -3.33283335e-01f,
  -2.14630291e-01f, -3.18002403e-01f, -3.98211360e-01f, 1.88306533e-02f, 3.78961891e-01f, -2.13544294e-01f, -6.26509964e-01f, -4.33775604e-01f, -4.64427704e-03f, -1.08712114e-01f,
  2.61718184e-01f, 4.84070539e-01f, 1.39872119e-01f, 2.82462928e-02f, -4.26883847e-01f, -4.34316635e-01f, -2.69450963e-01f, -3.24126691e-01f, -5.20730764e-02f, 3.47836286e-01f,
  2.71503121e-01f, 1.97869092e-01f, 9.73286107e-03f, 8.52359310e-02f, 2.89570063e-01f, 2.54561782e-01f, -1.11883529e-01f, 2.45867863e-01f, -2.99911760e-02f, -4.32504416e-02f,
  2.36792624e-01f, -2.12026089e-01f, 7.87647963e-02f, 3.42920721e-01f, 3.26427877e-01f, -1.66835114e-01f, -2.26244852e-01f, -1.40201047e-01f, -3.88684534e-02f, -1.92888439e-01f,
  2.75792301e-01f, 9.97711793e-02f, 1.15938447e-01f, 1.14061549e-01f, 1.14052393e-01f, -1.22315966e-01f, -1.04701526e-01f, -2.65737623e-01f, -4.26646858e-01f, -1.18794471e-01f,
  2.54757673e-01f, 2.86260039e-01f, -2.95716494e-01f, -3.51610243e-01f, -4.44594711e-01f, 6.70496523e-02f, -1.65889725e-01f, -6.54747710e-02f, -4.95894998e-01f, -3.58804792e-01f,
  1.08577192e-01f, 3.17021832e-02f, 5.72253838e-02f, -1.31637424e-01f, 1.10293729e-02f, 1.34182079e-02f, -1.74730252e-02f, -3.84667143e-02f, 8.68613720e-02f, -7.85029903e-02f,
  -4.76595294e-03f, -4.05374095e-02f, -6.49689287e-02f, -3.25036012e-02f, 9.18858647e-02f, -4.98330332e-02f, -2.46170871e-02f, -1.47469014e-01f, 8.88225362e-02f, -5.57537563e-02f,
  6.32981062e-02f, 3.96641009e-02f, 6.12983927e-02f, -2.61372775e-02f, -7.22293407e-02f, -1.39655352e-01f, -1.92912519e-02f, 5.42382151e-02f, 4.07512262e-02f, 1.95007809e-02f,
  1.02411471e-01f, -6.34222850e-02f, -1.66661050e-02f, 5.93230538e-02f, 1.12777643e-01f, 9.54176784e-02f, 6.84899092e-02f, 1.37197301e-02f, 6.90788180e-02f, -5.87930344e-02f,
  -1.28079548e-01f, -7.10316300e-02f, -9.61889029e-02f, -8.80988613e-02f, 4.48526591e-02f, 4.48756432e-03f, 4.69181165e-02f, -1.06510920e-02f, -1.32029131e-03f, 1.34149849e-01f,
  -1.92826495e-01f, -2.56843656e-01f, -1.23109758e-01f, -2.25179195e-01f, 4.07184958e-02f, -9.76944566e-02f, -1.91166103e-01f, 4.61700419e-03f, -3.65479350e-01f, -4.86213297e-01f,
  -2.34293357e-01f, -1.49010196e-01f, -4.57556486e-01f, -5.16469300e-01f, -2.81607062e-01f, 1.64002433e-01f, 3.43050271e-01f, 1.01033963e-01f, -2.13516518e-01f, -8.61198306e-02f,
  -3.03597283e-02f, -7.46294558e-02f, -3.09690684e-01f, -4.22518738e-02f, 1.85018063e-01f, 8.83146897e-02f, -1.21800110e-01f, -1.20414309e-01f, 1.41686738e-01f, 3.79741192e-01f,
  2.09543914e-01f, -1.69899642e-01f, -8.50037038e-02f, -1.82566702e-01f, -3.55470896e-01f, -2.37801149e-01f, -3.98520470e-01f, -3.18679750e-01f, -1.62159763e-02f, -3.99860382e-01f,
  -1.71417832e-01f, -3.97121072e-01f, 1.24958970e-01f, -4.61768620e-02f, -1.57400280e-01f, 1.06091298e-01f, 7.03021809e-02f, -1.85444847e-01f, -1.55802455e-03f, -1.82556286e-01f,
  -2.71730363e-01f, 1.18123196e-01f, -1.69575483e-01f, -1.67480543e-01f, -2.11618677e-01f, -9.03759897e-03f, -1.99393451e-01f, -1.25758499e-01f, -9.03624445e-02f, -4.34707962e-02f,
  -1.93312056e-02f, -4.40272130e-03f, -6.38421625e-02f, 1.58063080e-02f, -7.45673850e-02f, -1.70509443e-01f, -1.51424065e-01f, 2.84449402e-02f, -1.31912500e-01f, 1.18216965e-02f,
  9.11770612e-02f, -8.23218822e-02f, 6.00134991e-02f, 6.50186613e-02f, 4.64723706e-02f, -8.03942140e-03f, -8.29136223e-02f, 5.04011549e-02f, 6.35528117e-02f, -2.67728660e-02f,
  7.41622150e-02f, -5.67836128e-02f, -7.05681667e-02f, -9.93211847e-03f, 5.54979779e-03f, -6.66368082e-02f, -1.04739610e-03f, 1.11852810e-01f, -1.45377545e-02f, 8.42249468e-02f,
  4.05010507e-02f, 5.81079423e-02f, -1.51860297e-01f, 1.46841854e-01f, 1.29639199e-02f, -6.48982078e-02f, -7.97692984e-02f, 8.43589678e-02f, -2.26173829e-02f, 6.17428422e-02f,
  8.78209472e-02f, 8.94875303e-02f, -1.22600190e-01f, 5.51978638e-03f, -3.27799395e-02f, -7.02781081e-02f, -1.08394146e-01f, 8.35477188e-02f, -1.32164165e-01f, -2.51461230e-02f,
  7.02232793e-02f, 1.13079481e-01f, -2.08612174e-01f, -5.63258491e-02f, 1.22815907e-01f, 2.52795629e-02f, 1.19804695e-01f, 8.57955366e-02f, 7.09642768e-02f, 1.14462584e-01f,
  2.16010753e-02f, 3.51119101e-01f, 2.10719243e-01f, 1.61349580e-01f, 1.69582859e-01f, 2.04660028e-01f, 6.86692446e-02f, 2.03907788e-01f, 3.56020868e-01f, 3.95130098e-01f,
  -4.92657423e-01f, -2.19888926e-01f, -2.70885795e-01f, -4.32832837e-01f, -4.24896300e-01f, -2.54802823e-01f, -4.31359708e-01f, -1.96860701e-01f, -2.99823284e-01f, -3.35521162e-01f,
  -7.31754154e-02f, 2.68661410e-01f, 2.27157101e-01f, 2.29140315e-02f, 1.07680745e-01f, -4.39518809e-01f, -3.99041563e-01f, -3.31821829e-01f, -1.03903301e-01f, -1.82260692e-01f,
  -3.66452485e-01f, -4.35811907e-01f, -3.53219986e-01f, -1.67133689e-01f, -1.83118984e-01f, -1.63090035e-01f, -2.77887762e-01f, -2.74861038e-01f, -2.43037477e-01f, -4.29453880e-01f,
  1.91026688e-01f, -4.85965461e-02f, -1.69703120e-03f, -5.20851202e-02f, 4.89951158e-03f, 5.97465821e-02f, 2.63949540e-02f, -2.94323210e-02f, 1.79257635e-02f, -9.69417617e-02f,
  -1.08676761e-01f, -3.52194086e-02f, 3.86314876e-02f, -2.74214875e-02f, -1.25434563e-01f, -2.42868979e-02f, -9.78690982e-02f, -3.81867103e-02f, -6.04009740e-02f, 5.56263849e-02f,
  9.89752784e-02f, -1.38643309e-01f, 1.17545865e-01f, 1.57553125e-02f, 9.26616713e-02f, 6.04193918e-02f, 7.38176005e-03f, -7.53270928e-04f, 1.87789634e-01f, -5.20396233e-02f,
  -1.86768144e-01f, 5.98667413e-02f, 8.08134750e-02f, -5.64758442e-02f, 1.31151685e-02f, -3.92298251e-02f, -2.39744615e-02f, 3.94524373e-02f, 9.29534733e-02f, -4.87974770e-02f,
  -1.26563564e-01f, 5.88325076e-02f, 5.34522422e-02f, -8.89252722e-02f, -8.67573097e-02f, 6.58254921e-02f, -1.02202579e-01f, -4.43510488e-02f, 7.81404600e-02f, -1.11125536e-01f,
  -5.08811511e-02f, -5.92345633e-02f, -5.50191058e-03f, 1.22311236e-02f, -5.69370016e-02f, -1.05629012e-01f, 7.20563531e-02f, -2.06244141e-02f, 2.00008955e-02f, -5.31587983e-03f,
  2.16103509e-01f, 3.01090591e-02f, -1.03843398e-01f, 4.44208384e-02f, 3.50037180e-02f, 8.89118090e-02f, 7.23550692e-02f, -7.16782659e-02f, -1.11317178e-02f, 6.75171195e-03f,
  1.11907303e-01f, 1.19439717e-02f, 4.64010686e-02f, 3.24210040e-02f, 2.71816514e-02f, 2.28377674e-02f, -1.26267433e-01f, -6.68817312e-02f, 2.76807621e-02f, -1.48139975e-03f,
  2.17829868e-02f, -8.23704973e-02f, 1.96170732e-02f, 1.30770579e-01f, 8.90123919e-02f, 5.55050895e-02f, 1.51538402e-01f, 1.59962207e-01f, 1.91140510e-02f, -9.87965390e-02f,
  6.38566852e-01f, 1.79422796e-01f, -6.74321577e-02f, -1.06542343e-02f, -2.91778803e-01f, -1.25633880e-01f, -1.20064639e-01f, 1.07382819e-01f, 1.73918620e-01f, 2.83108074e-02f,
  8.62326398e-02f, 1.25141427e-01f, 1.28447860e-01f, 9.71720889e-02f, 1.03818633e-01f, 5.13372757e-02f, 5.72940111e-02f, 1.25841632e-01f, -6.48610890e-02f, 3.84195931e-02f,
  -4.07997072e-02f, -3.09630856e-03f, 1.29711956e-01f, 8.61780345e-02f, -8.09609666e-02f, -3.58129814e-02f, -4.57736738e-02f, -2.37071142e-01f, -1.86411127e-01f, -2.79036798e-02f,
  -3.06730747e-01f, -4.58332263e-02f, 1.74383223e-01f, 1.07199207e-01f, -5.81387803e-02f, 1.61970779e-01f, 1.98661499e-02f, -1.50609789e-02f, 7.74991736e-02f, 8.07725079e-03f,
  -5.34909265e-03f, -9.19630527e-02f, -1.28848135e-01f, -1.28623024e-01f, -1.99200138e-02f, -5.44826314e-02f, -3.49438973e-02f, 6.10160455e-02f, 1.64580755e-02f, -2.94271037e-02f,
  7.21961707e-02f, -9.04662386e-02f, -1.89460833e-02f, 9.06117484e-02f, 1.71476126e-01f, 6.57144934e-02f, 1.39871268e-02f, 6.85773343e-02f, 4.60078903e-02f, 1.55998915e-01f,
  8.57435763e-02f, 1.67728752e-01f, -1.26171466e-02f, -7.34584108e-02f, 1.28065988e-01f, -8.62096623e-03f, -4.88575138e-02f, -3.43621112e-02f, 2.34428141e-02f, 1.87884048e-02f,
  -1.80180240e-02f, -1.27170989e-02f, 3.74096483e-02f, -1.12613648e-01f, -3.96448448e-02f, -4.70330231e-02f, 4.33008373e-02f, -5.64468151e-04f, -1.04171343e-01f, -8.20597038e-02f,
  -8.44966620e-02f, -1.26575511e-02f, -1.21515162e-01f, -9.20825303e-02f, -9.93070155e-02f, -9.95014384e-02f, -4.35646810e-02f, -8.87823328e-02f, -4.07574102e-02f, -3.78005728e-02f,
  -2.87454873e-01f, -4.77026664e-02f, 1.31282628e-01f, 1.78221568e-01f, -5.03819548e-02f, 3.04680206e-02f, 4.49359640e-02f, -5.13753146e-02f, -1.16078369e-01f, -8.91576633e-02f,
  -2.16516666e-02f, 5.67614064e-02f, 3.51681262e-02f, 1.32744890e-02f, -1.58014253e-01f, -3.97844501e-02f, 7.99008980e-02f, 3.71520706e-02f, 6.80803657e-02f, 2.91407630e-02f,
  9.50613692e-02f, 5.28248167e-03f, -4.94519472e-02f, 7.69325122e-02f, 1.14733860e-01f, 6.59375712e-02f, -3.91564937e-03f, 2.16077045e-02f, -1.23600245e-01f, 6.86072335e-02f,
  -3.59163821e-01f, -3.68056148e-01f, 1.55080780e-01f, 1.94109797e-01f, 3.31329912e-01f, 1.70415953e-01f, 2.28144694e-02f, 6.64901286e-02f, 1.12887444e-02f, -7.90210441e-02f,
  -1.73662767e-01f, -2.03649148e-01f, -1.96910083e-01f, -1.29777357e-01f, -1.26569435e-01f, 7.61837959e-02f, 1.62719309e-01f, 1.21487811e-01f, 1.25291467e-01f, 1.72657937e-01f,
  4.38969508e-02f, 1.24680631e-01f, 5.12159951e-02f, 3.38762952e-03f, 1.07739806e-01f, 7.31827915e-02f, 1.33791327e-01f, 8.36345181e-02f, 8.38608146e-02f, 1.20270170e-01f,
  9.67988744e-02f, -3.26798797e-01f, 8.77780244e-02f, -2.32170016e-01f, -1.44337982e-01f, -1.18611470e-01f, 1.72655936e-02f, -1.24962069e-01f, -9.45888683e-02f, -6.56582788e-02f,
  -1.39160649e-04f, -1.29377618e-01f, -1.02297038e-01f, 1.09604793e-02f, 3.49278115e-02f, 3.55979651e-02f, 1.96400401e-03f, 1.24980160e-03f, -7.39824697e-02f, -1.66868016e-01f,
  -3.61378603e-02f, -4.04626541e-02f, -3.04079019e-02f, 3.59557234e-02f, -1.72983199e-01f, -4.70790081e-02f, -8.78862813e-02f, -1.10670060e-01f, -8.79957974e-02f, 8.70685056e-02f,
  -1.58350095e-02f, 3.62647232e-04f, -4.30196611e-04f, 4.98593077e-02f, 4.00658883e-03f, 1.25816837e-01f, 1.53188244e-01f, 4.25109714e-02f, 4.57345881e-02f, 1.62373073e-02f,
  1.25764996e-01f, 1.03125080e-01f, -4.19287272e-02f, 6.42943159e-02f, -2.40594167e-02f, -2.70644855e-02f, 6.42694384e-02f, -1.76981036e-02f, -6.05817605e-03f, 4.91030477e-02f,
  -1.65647622e-02f, -3.54718342e-02f, 5.57529032e-02f, 3.85099463e-02f, 2.89704278e-03f, -2.11050026e-02f, 7.90202096e-02f, -1.04358956e-01f, -6.25377707e-03f, 1.81934126e-02f,
  3.02329779e-01f, -2.12445617e-01f, 5.39455153e-02f, -1.80284902e-02f, 5.25776669e-02f, -9.02924687e-02f, 1.41085852e-02f, -3.64275239e-02f, 6.65953457e-02f, 1.28548384e-01f,
  3.67986262e-02f, 8.52938183e-03f, -4.81445454e-02f, 5.15467338e-02f, 1.61304712e-01f, 8.29836428e-02f, -8.36719200e-02f, 1.73470227e-03f, -5.84018007e-02f, -7.29915127e-02f,
  4.24242616e-02f, 1.30645216e-01f, 1.88179865e-01f, 1.65355444e-01f, 1.15518108e-01f, 3.87198851e-02f, 1.74727142e-01f, 5.77973537e-02f, 3.05211004e-02f, 1.46667793e-01f,
  4.29631442e-01f, -1.62555203e-01f, 1.53576180e-01f, 2.87847966e-01f, 2.82029122e-01f, 2.63268977e-01f, 2.82746345e-01f, 1.15596391e-01f, 6.95675164e-02f, 5.97754903e-02f,
  6.78174645e-02f, -5.05782031e-02f, 4.36476618e-02f, -3.92029621e-02f, 9.44781378e-02f, -4.41253483e-02f, 1.56667903e-02f, 2.10771725e-01f, 9.16462019e-02f, 3.90627235e-02f,
  4.41685617e-02f, 5.93059771e-02f, 2.19798967e-01f, 4.90915328e-02f, -1.22682154e-01f, 8.24540257e-02f, 2.93756146e-02f, -4.61571030e-02f, -1.26761094e-01f, -2.13814050e-01f,
  -2.82898486e-01f, -1.42827735e-03f, 1.18596599e-01f, -1.10572241e-01f, -1.03439949e-01f, -6.01442307e-02f, 6.11089543e-03f, 3.35671231e-02f, -7.40361363e-02f, -5.40808253e-02f,
  -7.29037449e-02f, -5.66507177e-03f, -7.29449317e-02f, -6.19633049e-02f, 4.56978418e-02f, 1.23782409e-02f, -5.48580438e-02f, 8.00576308e-05f, 5.63937388e-02f, -7.45421741e-03f,
  -1.74241319e-01f, -5.66655882e-02f, -3.81581951e-03f, 2.76261121e-02f, -7.46077597e-02f, 4.38788943e-02f, -4.18301113e-02f, -5.81531450e-02f, 8.97718966e-02f, -4.77499664e-02f,
  1.40363574e-01f, 3.35619710e-02f, 1.99715812e-02f, -1.10763505e-01f, -1.31894961e-01f, -6.90582097e-02f, -8.07166174e-02f, 4.01479043e-02f, 4.03840235e-03f, 2.19267737e-02f,
  1.13941498e-01f, 1.14065245e-01f, 5.24321720e-02f, 8.25512782e-02f, 5.36590070e-02f, 7.90051147e-02f, -5.19878939e-02f, 5.90301454e-02f, 6.81183934e-02f, 1.30750045e-01f,
  4.56704237e-02f, 2.41149887e-02f, -3.72352973e-02f, -1.01734579e-01f, 4.71932516e-02f, 7.55918398e-02f, -5.00660017e-02f, -9.27615464e-02f, 2.89965495e-02f, 1.30654335e-01f,
  -5.37009165e-02f, 2.79936910e-01f, -4.19237502e-02f, -2.13627204e-01f, -1.79752663e-01f, 1.84751153e-02f, 6.65417984e-02f, -5.69173060e-02f, -1.52592286e-01f, -6.16703220e-02f,
  -2.53656111e-03f, 2.22547329e-03f, -3.92006151e-02f, -2.55309697e-02f, 8.88023302e-02f, -7.63257369e-02f, -1.00008823e-01f, -6.15013503e-02f, -1.84713244e-01f, -8.72547850e-02f,
  -1.39180660e-01f, -4.40917425e-02f, 1.18571274e-01f, 1.13571651e-01f, -1.61188636e-02f, 4.29311804e-02f, 3.47953755e-03f, -8.29137769e-03f, 9.39520746e-02f, 5.08307405e-02f,
  -1.91342190e-01f, -5.62080085e-01f, 6.15693152e-01f, -1.76013872e-01f, -1.43172359e-02f, -1.44878626e-02f, -4.91917938e-01f, -4.74058896e-01f, -1.58320367e-01f, -4.06919241e-01f,
  -1.52999923e-01f, -1.99128445e-02f, 1.98364064e-01f, 1.92985713e-01f, -1.84921286e-04f, -1.29454479e-01f, 1.37552693e-01f, 4.74460095e-01f, 2.65533417e-01f, -3.54991019e-01f,
  -3.08115989e-01f, -5.76304905e-02f, 8.98441672e-02f, -8.49777237e-02f, -2.26516485e-01f, 4.65681888e-02f, 8.28663632e-02f, -1.50006078e-02f, 2.43835337e-02f, -1.38833711e-03f,
  1.77495748e-01f, -3.45406741e-01f, 2.02378586e-01f, -4.86059114e-02f, 1.99729241e-02f, -5.98833244e-03f, -1.70552246e-02f, -1.29032210e-02f, -1.39784634e-01f, -3.97940725e-02f,
  -2.68610790e-02f, -5.74273132e-02f, -7.93031678e-02f, -9.66985896e-02f, -1.23969384e-01f, -2.01718554e-01f, 3.17903124e-02f, 7.68695697e-02f, 3.25124450e-02f, -1.19415835e-01f,
  -3.51578355e-01f, -7.11157098e-02f, 2.71462590e-01f, 9.87591743e-02f, -1.06728874e-01f, 2.50635475e-01f, -1.98300928e-02f, -1.12684771e-01f, 2.07825959e-01f, -2.01008543e-01f,
  1.30403703e-02f, 1.38756573e-01f, 6.34787604e-02f, -1.71195772e-02f, -7.26498291e-02f, 6.87379614e-02f, 1.64334148e-01f, 2.04670411e-02f, -6.87514944e-03f, 2.69645955e-02f,
  2.81259902e-02f, 4.47055772e-02f, 7.17233121e-03f, -4.28970940e-02f, 7.33726472e-02f, -5.84163563e-03f, -2.46663615e-02f, -8.05566534e-02f, 8.30578655e-02f, 2.18320396e-02f,
  3.49364206e-02f, 7.57295638e-02f, 8.66839662e-02f, -4.03659344e-02f, -1.32131083e-02f, 9.87924635e-02f, 2.76900828e-03f, 8.17895085e-02f, 2.28810571e-02f, 7.67100304e-02f,
  1.56948343e-01f, 1.72149599e-01f, -4.57107238e-02f, 8.55988637e-03f, -2.11014971e-02f, -7.11162090e-02f, -7.07540661e-03f, -4.65582274e-02f, 6.69770613e-02f, -4.73223552e-02f,
  -5.76525331e-02f, -4.37528603e-02f, 7.80604035e-02f, 6.18055351e-02f, 1.26580402e-01f, -3.09241321e-02f, -1.93314806e-01f, 2.97701731e-02f, 5.90338223e-02f, -2.32544363e-01f,
  -1.54441282e-01f, 2.97832601e-02f, 1.67627886e-01f, 1.78939894e-01f, -1.28055185e-01f, 2.97646642e-01f, 1.86736107e-01f, 9.07497108e-02f, 2.32304052e-01f, -1.00906081e-01f,
  3.56076747e-01f, 2.85953969e-01f, -4.19638231e-02f, 1.28716584e-02f, -2.28954554e-02f, -1.04007653e-04f, 9.85044912e-02f, 2.27103066e-02f, 1.17838651e-01f, 4.21291590e-02f,
  -3.17192152e-02f, -1.51780352e-01f, -1.58220977e-01f, -9.95229557e-03f, -5.76684587e-02f, 1.01614058e-01f, 1.45243093e-01f, 4.17839624e-02f, -7.67901447e-03f, -6.19334131e-02f,
  1.10199749e-01f, 1.86336666e-01f, 6.97563067e-02f, 7.78257623e-02f, 4.47681919e-02f, -9.20580029e-02f, 6.71665594e-02f, 6.79141656e-02f, 4.78640832e-02f, 5.92387980e-03f,
  -3.07468295e-01f, -1.17456824e-01f, -7.61326551e-02f, 7.13910535e-02f, 8.71051401e-02f, 3.06858048e-02f, -6.44257059e-03f, 8.62419382e-02f, 8.43742937e-02f, -2.40576994e-02f,
  -4.69777063e-02f, 3.11797019e-02f, -8.08839500e-03f, -1.20639205e-01f, -2.98174210e-02f, -1.09238327e-01f, -8.76999497e-02f, -1.19575419e-01f, 9.87970736e-03f, -1.03492327e-01f,
  5.71603794e-03f, -2.46291682e-02f, -9.76086035e-02f, -4.41825166e-02f, -1.84826538e-01f, 5.99584496e-03f, -1.14050128e-01f, -6.92799240e-02f, -1.52800158e-01f, 2.23487150e-02f,
  -6.91581741e-02f, 7.92274158e-03f, -9.10379142e-02f, -1.55539095e-01f, -1.84911877e-01f, -1.00499928e-01f, -7.59495124e-02f, -9.80164632e-02f, -1.94150701e-01f, -3.75950680e-04f,
  -2.52630878e-02f, -1.34427890e-01f, -2.19874933e-01f, -3.50298621e-02f, -1.32612363e-01f, -7.08368570e-02f, 2.37160828e-02f, -5.58058284e-02f, -1.54747158e-01f, -4.47560363e-02f,
  -1.78679183e-01f, 4.84923311e-02f, 1.02452517e-01f, 7.62922987e-02f, -5.12992479e-02f, 1.63688175e-02f, 9.25584286e-02f, -6.33407906e-02f, 3.51664913e-03f, 9.20320973e-02f,
  -1.18445143e-01f, -5.13742864e-01f, -8.54315907e-02f, 3.47135030e-02f, 1.73984859e-02f, 8.20725709e-02f, -1.92840829e-01f, -6.81125605e-03f, 2.47473530e-02f, -4.64839153e-02f,
  -6.94236904e-02f, -1.99883301e-02f, 2.06907317e-02f, -5.13379797e-02f, 4.00952958e-02f, -4.48547229e-02f, -3.53140719e-02f, 1.24476381e-01f, 1.16321728e-01f, 6.70279115e-02f,
  1.81601405e-01f, 1.43940493e-01f, -1.20027363e-03f, 6.37545139e-02f, 6.53389841e-02f, -4.31776904e-02f, -1.55608244e-02f, 5.26380464e-02f, 7.09956437e-02f, 2.75582820e-01f,
  5.57536542e-01f, 1.33065239e-01f, -5.19294083e-01f, 1.33891732e-01f, -1.99273616e-01f, -2.93465376e-01f, -1.59058005e-01f, -2.94645354e-02f, 1.70675844e-01f, 1.64129645e-01f,
  6.34660199e-03f, -2.25092936e-02f, -2.27709144e-01f, -3.30064476e-01f, -4.33417052e-01f, -2.17533767e-01f, -8.66610482e-02f, -4.59211916e-01f, -5.71574152e-01f, -4.19590086e-01f,
  -6.21935092e-02f, -9.03358087e-02f, -1.65179729e-01f, -2.11305916e-01f, 1.63342641e-03f, -2.27043927e-01f, -2.05494985e-01f, -2.46408880e-01f, -3.38313192e-01f, -2.58673970e-02f,
  -2.53360987e-01f, -1.04194596e-01f, -2.96627432e-01f, 4.55331132e-02f, 7.47966990e-02f, 8.02608847e-04f, 9.15740058e-03f, -4.61588316e-02f, 1.72178939e-01f, -3.80730890e-02f,
  -1.24137372e-01f, 3.19523141e-02f, -3.09438482e-02f, -8.61663893e-02f, -1.52848646e-01f, -1.78187311e-01f, -1.84812129e-01f, -1.58089086e-01f, -1.33639440e-01f, -1.20091280e-02f,
  -1.01395007e-02f, -2.43025213e-01f, -3.17570597e-01f, -2.46985555e-01f, -4.12563741e-01f, -1.89030051e-01f, -2.31853619e-01f, -2.27300420e-01f, -4.67598528e-01f, 1.61457628e-01f,
  1.56752229e-01f, 5.58973812e-02f, -7.40283430e-02f, -1.45017430e-01f, 6.71797544e-02f, 4.53532785e-02f, 5.23374751e-02f, 1.29754573e-01f, 8.78714845e-02f, 9.00989845e-02f,
  -7.10922405e-02f, 1.26546025e-01f, 4.10527997e-02f, -3.80156711e-02f, -1.91766784e-01f, -4.47642133e-02f, 1.45644814e-01f, 8.21079314e-03f, -3.08681056e-02f, 7.96497315e-02f,
  -4.14326712e-02f, -2.91203596e-02f, 5.20178527e-02f, -3.64332013e-02f, 3.08717936e-02f, -7.34431371e-02f, 8.57037306e-02f, -8.34511966e-02f, -7.88998902e-02f, 8.64846632e-02f,
  2.94134859e-02f, -8.11159089e-02f, 2.18396097e-01f, -7.82476291e-02f, -3.52326268e-03f, -8.24631378e-03f, 9.77106839e-02f, 1.43478975e-01f, 1.97822958e-01f, 1.21251084e-02f,
  -1.08340286e-01f, 1.00033432e-01f, -1.19919531e-01f, 5.71766943e-02f, -8.94039646e-02f, -2.23607700e-02f, 1.20062217e-01f, -1.12452514e-01f, -1.10272370e-01f, 1.22088745e-01f,
  1.16994135e-01f, 4.11669873e-02f, 6.23660460e-02f, 2.07776204e-02f, 5.97652458e-02f, -2.35458985e-02f, -5.68599626e-02f, -1.13429748e-01f, -1.93282753e-01f, 3.56641650e-01f,
  5.93204439e-01f, 1.39311895e-01f, 2.14259937e-01f, 5.15311919e-02f, -1.14248984e-01f, -2.78611705e-02f, -1.26597717e-01f, 7.93112665e-02f, 5.32400794e-02f, 5.37846535e-02f,
  1.50744945e-01f, 2.13119492e-01f, 2.02013835e-01f, 1.44274846e-01f, -4.00460772e-02f, 4.79227565e-02f, -2.02754140e-02f, 1.15539819e-01f, 5.89371026e-02f, -7.76265189e-03f,
  -2.14340370e-02f, -3.92684117e-02f, 1.55931547e-01f, -1.42692840e-02f, 1.21666901e-01f, 1.05209246e-01f, -2.54385034e-03f, 7.52785951e-02f, 3.13298367e-02f, 1.65889859e-01f,
  2.62702703e-01f, 2.54594743e-01f, -1.89432412e-01f, -6.46013916e-02f, -4.08719294e-03f, 2.92926263e-02f, 2.32662186e-02f, 4.88993376e-02f, -3.06367632e-02f, -1.41507387e-01f,
  6.67966008e-02f, 5.17415777e-02f, -5.49256057e-02f, -4.68890555e-02f, 1.29870628e-03f, 7.63623789e-02f, 1.53858334e-01f, 2.22599525e-02f, -2.99638379e-02f, 9.99686494e-02f,
  -3.40909921e-02f, 4.30219062e-02f, 8.73660967e-02f, -2.98644621e-02f, 4.46679816e-02f, 8.02167580e-02f, -4.36253287e-02f, 1.02997310e-01f, 4.86736484e-02f, 1.48410484e-01f,
  8.80866125e-02f, 7.20836073e-02f, 3.41125787e-03f, 1.73313752e-01f, 1.89939961e-01f, 1.33391157e-01f, -4.38882783e-02f, -5.79030700e-02f, 8.82260352e-02f, -5.03322668e-02f,
  5.81807597e-03f, -8.40166956e-02f, 2.56173238e-02f, 4.04062904e-02f, 6.08698651e-02f, 1.32461786e-01f, 1.55927881e-03f, 1.54582784e-02f, -3.90418433e-02f, -3.32400464e-02f,
  1.77567750e-02f, -4.25834805e-02f, 1.47257641e-01f, 8.10730755e-02f, 1.06650636e-01f, 9.56007019e-02f, -5.13608940e-02f, 1.73351783e-02f, 9.36200917e-02f, 1.37314238e-02f,
  -3.32837790e-01f, -2.08218172e-01f, -6.66975752e-02f, -9.74995457e-03f, 3.66984569e-02f, 8.04033428e-02f, 1.12393834e-01f, 3.43343392e-02f, 3.62137519e-02f, -3.88264954e-02f,
  -4.29721549e-02f, -3.63788791e-02f, 3.76208685e-02f, -8.99951831e-02f, -5.52621670e-02f, 5.20106889e-02f, 1.26710758e-01f, -6.64234068e-03f, -1.19386055e-01f, -7.41158845e-04f,
  -1.68272570e-01f, -1.61140069e-01f, -2.04477862e-01f, -7.86171481e-02f, -8.13539028e-02f, -8.27872381e-02f, -9.07486156e-02f, -1.69353426e-01f, -1.14280038e-01f, -1.52716592e-01f,
  3.52306902e-01f, 1.55350193e-01f, 1.48161486e-01f, 7.75653273e-02f, 1.22968100e-01f, 7.69797415e-02f, 1.59115583e-01f, 1.06480442e-01f, 4.68359701e-02f, 6.85160607e-02f,
  -2.14456946e-01f, -2.67024398e-01f, -3.11312020e-01f, -1.90543279e-01f, -7.20696524e-02f, 1.42539605e-01f, 3.67613286e-02f, 2.70072166e-02f, 1.81115430e-03f, 5.49839064e-02f,
  -2.87265778e-02f, 1.19499788e-01f, 1.93251222e-01f, 1.88774280e-02f, -1.79727804e-02f, -1.33579403e-01f, 3.92264128e-02f, 6.28532991e-02f, -4.50536758e-02f, 1.91008896e-01f,
  6.18769117e-02f, 4.04867227e-04f, -1.50039867e-01f, -1.70921609e-01f, 1.46344332e-02f, 1.06143914e-01f, 1.15787663e-01f, -3.60263810e-02f, -5.80770746e-02f, 8.76514986e-02f,
  2.90780012e-02f, -5.50461821e-02f, 6.79569691e-02f, -3.53358388e-02f, 6.55326694e-02f, 6.06015623e-02f, 1.12596331e-02f, 6.67209923e-02f, -5.16072810e-02f, -1.09969482e-01f,
  -5.26184216e-02f, 5.33641204e-02f, -6.99485168e-02f, -3.77947763e-02f, -1.02168173e-01f, -7.40357712e-02f, -1.32639363e-01f, -1.17817037e-01f, -5.56972111e-03f, -1.96930133e-02f,
  2.45509227e-03f, -1.16027661e-01f, 2.24145688e-02f, 5.06656012e-03f, -2.89258882e-02f, 1.20017249e-02f, 7.72717595e-02f, -7.20570050e-03f, 1.25257000e-01f, 4.75250073e-02f,
  3.61349955e-02f, 1.23431951e-01f, 1.52475059e-01f, 1.19970977e-01f, -1.33914836e-02f, 1.39023494e-02f, 1.57519311e-01f, -7.07431361e-02f, -5.19747883e-02f, -1.48102948e-02f,
  1.16909944e-01f, 9.62575898e-02f, 1.19283758e-01f, 1.09906949e-01f, 9.10140574e-02f, -1.08781168e-02f, 9.02718976e-02f, -2.34312173e-02f, -4.62082885e-02f, 1.04644243e-03f,
  5.79073317e-02f, -2.28162423e-01f, 2.76600048e-02f, 3.91225666e-02f, 1.01840541e-01f, -2.38629822e-02f, 2.25530677e-02f, 8.10850561e-02f, 5.54899778e-03f, -7.96496868e-03f,
  -6.94466159e-02f, 8.35323632e-02f, -2.80450378e-02f, 7.48624802e-02f, 6.34272695e-02f, -5.58975004e-02f, 1.02404514e-02f, 5.83486930e-02f, -3.89128327e-02f, -4.06165794e-02f,
  -6.05862327e-02f, 1.58488508e-02f, 1.14999324e-01f, 7.80410618e-02f, -5.11100702e-02f, -6.55784365e-03f, 6.68154880e-02f, 5.79171740e-02f, 9.96468682e-03f, 2.36064177e-02f,
  -1.25722304e-01f, 1.97792292e-01f, -8.99629518e-02f, 6.23928048e-02f, 2.62974322e-01f, 3.25683117e-01f, 3.45770299e-01f, 2.19931319e-01f, 2.40430757e-01f, 2.51046587e-02f,
  9.74704549e-02f, 9.47401226e-02f, 1.01595648e-01f, 6.46971837e-02f, 1.03838414e-01f, 2.37114355e-01f, 2.14251176e-01f, -7.66533017e-02f, 5.40923029e-02f, 1.29531682e-01f,
  1.79703161e-01f, 1.01638876e-01f, -1.30101487e-01f, -2.06795353e-02f, 1.12534031e-01f, -1.27242059e-02f, 2.15754241e-01f, 1.36357203e-01f, 1.10148966e-01f, 1.46204188e-01f,
  -3.13719958e-01f, -1.15675710e-01f, 3.94100212e-02f, -1.40365615e-01f, -8.13396648e-02f, -1.79134011e-02f, 2.09206734e-02f, -7.46226311e-02f, 1.20731212e-01f, 1.14923241e-02f,
  5.43519715e-03f, 3.04936804e-02f, -1.20050780e-01f, -4.60674614e-02f, 1.02990947e-03f, -6.44878820e-02f, -1.23274863e-01f, 4.42338958e-02f, 1.34588033e-02f, -1.48090068e-02f,
  -7.82126337e-02f, -7.47757629e-02f, -4.44625244e-02f, 1.10977134e-02f, 4.61045951e-02f, 5.08738607e-02f, -4.33033668e-02f, -1.26407504e-01f, 2.23126411e-02f, -3.63187715e-02f,
  -9.20502767e-02f, 1.29621536e-01f, -1.09661609e-01f, 1.06808813e-02f, -6.05061986e-02f, -1.90351643e-02f, 7.67994905e-03f, 1.80993542e-01f, 1.45751894e-01f, -1.38530293e-02f,
  4.58946340e-02f, 4.35868315e-02f, -7.81835094e-02f, 2.93813013e-02f, -1.22952327e-01f, -6.15681000e-02f, -2.04859693e-02f, -3.39741968e-02f, -2.06402168e-01f, 1.43575165e-02f,
  1.28504522e-02f, 8.84541720e-02f, -1.58867046e-01f, 2.76209023e-02f, -8.12137201e-02f, -8.69221836e-02f, -1.25249811e-02f, 5.24089485e-02f, 3.22352313e-02f, 7.75994658e-02f,
  1.11976117e-01f, -2.08381802e-01f, -9.16822115e-04f, 8.23976919e-02f, 2.12814137e-02f, -6.46753535e-02f, -1.12651914e-01f, 2.47963369e-02f, 4.59548309e-02f, 6.89344853e-02f,
  -1.05479188e-01f, -1.24615833e-01f, -4.29881550e-02f, -5.75863477e-03f, 5.78856505e-02f, -1.31824939e-02f, 4.73287739e-02f, -1.55193722e-02f, 8.25138614e-02f, 9.50914994e-02f,
  8.55337530e-02f, 1.75541908e-01f, -1.10601513e-02f, 2.87366677e-02f, 5.76057509e-02f, -2.54700612e-02f, -3.31140347e-02f, 4.07195725e-02f, 1.91509482e-02f, 1.39381168e-02f,
  6.93492472e-01f, 2.95530468e-01f, -4.10809554e-02f, 2.12579653e-01f, -4.63140570e-02f, -7.02661127e-02f, 2.27788240e-02f, 5.17564788e-02f, 1.00633919e-01f, 1.98720202e-01f,
  1.90897614e-01f, 1.40504971e-01f, 3.30514796e-02f, 1.37788460e-01f, 1.36037320e-01f, 7.40326010e-04f, -2.66215391e-02f, 5.96766248e-02f, -2.50299796e-02f, 1.37807310e-01f,
  6.22106530e-02f, 1.72984675e-01f, 1.49152130e-01f, 1.15052620e-02f, -1.65208150e-02f, 3.20764296e-02f, -8.57797563e-02f, -7.19040399e-03f, -2.31450386e-02f, 1.43501148e-01f,
  1.31331459e-01f, 1.52594224e-01f, -1.30898520e-01f, -8.08662921e-02f, -2.58359574e-02f, -6.00366406e-02f, 2.86128442e-03f, -9.88097489e-02f, -1.31369382e-02f, 4.23910171e-02f,
  -1.18980192e-01f, 3.66072841e-02f, -2.43901066e-03f, -1.68238543e-02f, -9.37651470e-02f, -7.21517503e-02f, -1.16993356e-02f, -4.20183763e-02f, -2.37657037e-02f, 5.14104916e-03f,
  -1.09470092e-01f, -7.41267130e-02f, -1.38402715e-01f, -4.50195186e-02f, -9.34066996e-02f, -3.49421650e-02f, 2.39526276e-02f, 2.97510941e-02f, 3.06072254e-02f, -3.51831242e-02f,
  -1.89898349e-02f, 2.43571270e-02f, 1.06787421e-01f, 7.48825669e-02f, 1.21525176e-01f, -2.06193104e-02f, 6.70041218e-02f, -7.04317242e-02f, 2.43579186e-02f, 6.02922067e-02f,
  -7.32580060e-03f, 3.52210775e-02f, -2.45022196e-02f, 1.01786353e-01f, -3.23927067e-02f, 5.89400344e-02f, -4.85632196e-02f, -1.81170329e-02f, 6.47200048e-02f, 2.07423065e-02f,
  1.28405139e-01f, -5.22052385e-02f, -1.55556081e-02f, -1.38326036e-02f, -1.93862058e-02f, 4.99786697e-02f, 9.76698622e-02f, -6.07532170e-03f, -4.22464572e-02f, 1.00953810e-01f,
  -6.12003393e-02f, -9.16233286e-02f, 1.31190419e-01f, 4.49166484e-02f, -4.16298136e-02f, -1.66480854e-01f, -1.70002040e-02f, -1.51212841e-01f, -1.61178440e-01f, 3.36030945e-02f,
  -9.28322002e-02f, -5.52250072e-02f, -4.00812179e-02f, -5.27717918e-02f, -7.02990741e-02f, -4.33519818e-02f, -1.26762301e-01f, -2.91583333e-02f, -4.75200489e-02f, -2.06667095e-01f,
  -6.80866465e-02f, -1.77678332e-01f, -5.10321483e-02f, -1.92165568e-01f, -5.46609163e-02f, -1.23611644e-01f, -9.40617919e-02f, -7.42775574e-02f, -1.14654109e-01f, -7.25751519e-02f,
  5.78623891e-01f, -1.10372677e-01f, 6.64571971e-02f, 1.33936480e-01f, -1.25179052e-01f, -6.99013770e-02f, -1.93909302e-01f, 8.28924030e-02f, 4.00229990e-02f, 1.18136697e-01f,
  7.73188919e-02f, 1.25764102e-01f, 2.92598128e-01f, 2.28463188e-01f, 2.44487777e-01f, -5.12204915e-02f, 1.51552320e-01f, 2.25892633e-01f, 9.82704982e-02f, -1.29292915e-02f,
  -9.35761780e-02f, -2.31711920e-02f, 1.18424073e-01f, 1.24135695e-01f, -1.41406879e-01f, 5.57800196e-02f, -5.75945666e-03f, -1.34468615e-01f, -8.10452476e-02f, -1.49979219e-01f,
  -2.10947767e-01f, 4.07711193e-02f, 1.59550950e-01f, 6.21784739e-02f, 1.53028695e-02f, 6.74194172e-02f, -6.24931157e-02f, 1.87167488e-02f, -9.48871896e-02f, -1.20024055e-01f,
  -8.15386325e-02f, 6.54660463e-02f, -2.48092078e-02f, -1.36425257e-01f, -1.31974012e-01f, -3.48365828e-02f, -4.15385179e-02f, 1.46767750e-01f, -3.75819625e-03f, 1.26090869e-02f,
  -7.26171508e-02f, -7.76557103e-02f, -1.06637210e-01f, 4.85504121e-02f, 1.43096577e-02f, 2.91846618e-02f, -8.36159512e-02f, 1.61644928e-02f, -1.27384271e-02f, 3.86611857e-02f,
  2.53052544e-02f, 4.92446274e-02f, 6.78780675e-02f, 1.75270438e-01f, 1.44278675e-01f, 1.72274888e-01f, -1.29443437e-01f, -1.09123990e-01f, 1.55461356e-01f, -7.48709515e-02f,
  -1.31343126e-01f, -1.95799265e-02f, -8.63241032e-02f, -1.16309106e-01f, 1.15518317e-01f, -5.87559156e-02f, -4.88043167e-02f, 2.52645388e-02f, 8.36122409e-02f, 6.45930544e-02f,
  1.09210998e-01f, -8.98022801e-02f, -6.11437000e-02f, -8.47769454e-02f, -8.13868344e-02f, 5.26394323e-02f, 3.06746345e-02f, 1.89409852e-02f, -1.35481264e-02f, -2.91083995e-02f,
  -1.56481668e-01f, 3.46794933e-01f, 9.42248181e-02f, -4.09518629e-02f, -1.61841333e-01f, -7.80016258e-02f, -8.28611851e-03f, -1.14440471e-01f, 1.09653678e-02f, -1.30719185e-01f,
  -1.35945052e-01f, 5.36856726e-02f, 1.03213586e-01f, -2.91005280e-02f, -4.68888916e-02f, 4.38260213e-02f, 2.20992472e-02f, 4.98139474e-04f, -5.10045402e-02f, -1.14027858e-01f,
  4.24116515e-02f, -9.42004696e-02f, 5.28679490e-02f, -9.50932410e-03f, -6.08273186e-02f, 1.75019875e-01f, 9.38993469e-02f, 3.98378186e-02f, 1.47185922e-01f, 1.96984992e-03f,
  -1.18054472e-01f, 1.92234948e-01f, 3.49577725e-01f, -2.51674373e-02f, -1.23271786e-01f, -1.97672546e-01f, -7.88826346e-02f, -8.61765444e-02f, -7.07093859e-03f, 2.32636482e-01f,
  -5.44058084e-02f, -2.97688901e-01f, 9.74002630e-02f, -1.75557792e-01f, -1.61625430e-01f, 3.11214119e-01f, 2.62375414e-01f, -4.45873924e-02f, -5.99507391e-01f, -6.47171795e-01f,
  -3.15300524e-01f, -1.90365732e-01f, -1.87610120e-01f, -3.71548422e-02f, 2.15987444e-01f, -1.72354393e-02f, 3.59449983e-01f, 7.16118291e-02f, 2.14400142e-01f, 3.91369939e-01f,
  2.32087553e-01f, 1.79154560e-01f, -1.37505040e-01f, -1.67417228e-01f, -2.80419216e-02f, 3.08580846e-02f, -1.84894651e-02f, 1.53471693e-01f, 5.11204228e-02f, 1.10476658e-01f,
  2.04055430e-03f, 5.95031753e-02f, -1.67382527e-02f, 6.07953481e-02f, -6.58925399e-02f, -2.16592744e-01f, 4.13556658e-02f, 1.95844695e-02f, -1.40168499e-02f, 8.36824998e-02f,
  -1.18552715e-01f, -2.10867316e-01f, 5.88452555e-02f, -2.58791707e-02f, -1.40727814e-02f, -2.20861658e-01f, 6.52207211e-02f, -1.03207819e-01f, 8.22602063e-02f, 2.36428425e-01f,
  -5.47837168e-02f, -4.11155038e-02f, 7.78996944e-02f, 1.08344473e-01f, -8.50236565e-02f, 5.65339513e-02f, 3.84858958e-02f, -7.35830469e-03f, 1.12673258e-02f, 1.99771915e-02f,
  4.31738198e-02f, 4.67349030e-02f, -3.62878367e-02f, 8.96220878e-02f, 7.76976869e-02f, -1.12895183e-01f, -4.64083366e-02f, 6.68649599e-02f, 1.15379691e-01f, 3.58934216e-02f,
  -9.86004174e-02f, -3.12137343e-02f, 8.52158293e-02f, -1.08603053e-02f, 2.33852804e-01f, 2.06986908e-02f, -2.02050619e-03f, -1.87323079e-01f, -2.38352031e-01f, -9.75275859e-02f,
  -1.98001668e-01f, -1.14412405e-01f, 1.10495538e-01f, -1.75477654e-01f, 4.89212498e-02f, 3.63835506e-02f, 5.83198108e-02f, -7.04268645e-03f, 5.26885455e-03f, -3.24727446e-02f,
  -1.46030292e-01f, -7.91277215e-02f, 1.67179674e-01f, 5.87009490e-02f, -2.32595414e-01f, 6.40794411e-02f, -7.12477043e-02f, -2.14080781e-01f, -2.19207257e-01f, -1.46261126e-01f,
  -3.20443772e-02f, -3.70105684e-01f, -2.68871665e-01f, -8.63572955e-02f, -1.15095839e-01f, -4.14303571e-01f, -1.33678660e-01f, -1.22175924e-01f, -9.20252204e-02f, -1.52600378e-01f,
  7.20761836e-01f, 1.74354818e-02f, -5.13834119e-01f, 4.25755799e-01f, 1.93872806e-02f, -3.83784413e-01f, -6.47375703e-01f, -3.44810367e-01f, 3.56050313e-01f, -1.06817642e-02f,
  1.49849117e-01f, 3.13499123e-01f, 7.53440037e-02f, -3.07751209e-01f, -5.90166211e-01f, -5.93280494e-01f, -5.29378653e-01f, -5.41738272e-01f, -5.83601058e-01f, -3.82782757e-01f,
  1.46172158e-02f, 1.15196027e-01f, -6.55991435e-02f, -1.54896602e-01f, 3.06158334e-01f, 2.35849082e-01f, -3.74596193e-02f, 9.09981653e-02f, -1.38809398e-01f, 2.87915170e-01f,
  -2.38520861e-01f, -2.28933647e-01f, -9.78436768e-02f, 8.80138874e-02f, 9.90283489e-02f, 1.07267246e-01f, -8.79681930e-02f, 4.48920913e-02f, 1.70616463e-01f, -1.57818258e-01f,
  1.45940647e-01f, -7.47891217e-02f, -2.05872860e-02f, 9.45976190e-03f, -1.21172696e-01f, -7.35875964e-02f, -9.87906680e-02f, -2.12800369e-01f, -1.22785248e-01f, -1.31302729e-01f,
  1.28043428e-01f, 9.30595547e-02f, -1.43751249e-01f, -2.34297991e-01f, -2.56188452e-01f, 1.32890359e-01f, -3.73191014e-02f, -6.43404648e-02f, -1.37958482e-01f, 9.58264917e-02f,
  -1.42131746e-02f, 1.20637320e-01f, 1.00385152e-01f, 7.27049680e-03f, 1.52588822e-02f, 1.85067013e-01f, 1.88749516e-03f, -5.57741001e-02f, -6.00100048e-02f, -2.90851928e-02f,
  -3.12832072e-02f, -7.35216727e-03f, -1.34328187e-01f, -6.33699745e-02f, -2.18710732e-02f, 2.85406765e-02f, 5.00148013e-02f, -4.98038419e-02f, -1.07894786e-01f, 6.44867346e-02f,
  -4.04182673e-02f, 3.07474434e-02f, 1.26848012e-01f, -8.99160504e-02f, 1.21579003e-02f, -1.06643401e-02f, 6.96149096e-02f, 2.55195741e-02f, 1.04174502e-01f, -4.51045930e-02f,
  2.19042212e-01f, -1.68590873e-01f, 1.12764463e-01f, -2.28527710e-01f, -5.06145172e-02f, 1.04360003e-02f, 1.49256855e-01f, -1.70108452e-02f, 1.90001845e-01f, 1.27769178e-02f,
  -1.62535891e-01f, 7.84184784e-02f, 6.33791229e-03f, -2.38456409e-02f, -1.56661183e-01f, -6.14191219e-02f, -2.36058012e-02f, 9.50412378e-02f, 2.00737524e-03f, 2.35483125e-01f,
  3.79557088e-02f, -1.36256218e-01f, 4.53432128e-02f, 3.67833860e-02f, 4.39338870e-02f, 3.48061137e-02f, -5.51195331e-02f, 5.18575124e-02f, -7.52653135e-03f, 1.07058570e-01f,
  7.60942996e-01f, 1.53665736e-01f, -3.22315902e-01f, 2.79458046e-01f, -6.40759051e-01f, -4.89687771e-01f, -2.65131235e-01f, 1.15365714e-01f, -1.80980638e-01f, -1.08669557e-01f,
  -3.81332546e-01f, -2.63794154e-01f, -1.09332010e-01f, -5.78152314e-02f, 3.88116181e-01f, 1.95154235e-01f, 1.06429420e-01f, 3.25882167e-01f, 1.08619370e-01f, -1.52017727e-01f,
  -1.78741291e-01f, 2.66499996e-01f, 5.37362695e-01f, 2.51610845e-01f, -1.22219369e-01f, -1.37681082e-01f, -3.41087021e-02f, -7.33055845e-02f, -1.80351868e-01f, -6.05229251e-02f,
  -5.32696769e-02f, -4.40990627e-02f, -1.52326539e-01f, -7.10957078e-03f, -1.92975789e-01f, 8.30613151e-02f, 7.41441175e-02f, 1.22476257e-01f, 3.95346098e-02f, -1.45289391e-01f,
  -3.20690662e-01f, -1.21717811e-01f, -3.34561378e-01f, -1.53215110e-01f, -1.19231239e-01f, -5.86761907e-02f, 2.21557006e-01f, 2.46693403e-01f, 2.05116883e-01f, -1.36214450e-01f,
  -3.19721133e-01f, -3.81821692e-01f, -3.50369185e-01f, -1.61518157e-01f, -2.64398232e-02f, -5.81830414e-03f, -1.61577553e-01f, -3.00835907e-01f, 2.62546185e-02f, 2.33776495e-01f,
  -2.14869622e-02f, -7.98309147e-02f, -2.88955905e-02f, -1.25136629e-01f, 1.59465566e-01f, 1.63752381e-02f, -1.06217731e-02f, -6.97070081e-03f, -1.47720203e-01f, -1.03173107e-02f,
  8.33946094e-02f, -2.10436177e-03f, -8.79889429e-02f, 5.14828451e-02f, -1.11450180e-02f, -1.72699139e-01f, 7.46832788e-03f, 1.38052357e-02f, -3.31068337e-02f, 9.04135257e-02f,
  -4.60021421e-02f, -1.01018719e-01f, 3.33261080e-02f, -2.22101901e-02f, 1.41518442e-02f, 2.73187109e-03f, -6.75991550e-02f, -2.99331881e-02f, 7.32959956e-02f, -6.67618290e-02f,
  1.55674547e-01f, 9.10127256e-03f, 8.38209018e-02f, 3.55387889e-02f, -1.23653188e-01f, -1.44060880e-01f, -1.10842533e-01f, 1.19750492e-01f, -1.87823907e-01f, -2.11590007e-01f,
  -2.21549913e-01f, 7.18349367e-02f, -4.10920717e-02f, 1.71464924e-02f, -4.58156131e-02f, -5.23486063e-02f, 1.76656172e-01f, -5.62600680e-02f, -6.33179992e-02f, -2.77680736e-02f,
  9.06288996e-02f, 7.91846365e-02f, 1.16507910e-01f, -2.99613122e-02f, -1.07149974e-01f, 8.85408279e-03f, -7.76402205e-02f, -1.67620346e-01f, -1.91442892e-02f, 2.94785470e-01f,
  -1.97292894e-01f, 1.35335639e-01f, 4.10520494e-01f, 2.10852146e-01f, 2.35905394e-01f, -7.59667754e-02f, -3.19960028e-01f, -1.88539922e-01f, 2.17179552e-01f, 7.17739749e-04f,
  1.26529904e-03f, 2.13007852e-02f, 1.02561630e-01f, -2.24881709e-01f, -5.04962623e-01f, -2.60460883e-01f, -8.37295726e-02f, -1.67808577e-01f, -4.05719399e-01f, -4.43434089e-01f,
  -2.96242326e-01f, -1.37150258e-01f, -1.77237704e-01f, -5.72531596e-02f, 3.23998958e-01f, 4.93069328e-02f, 3.34043264e-01f, 2.34136388e-01f, -5.77985570e-02f, 2.10307151e-01f,
  2.98217945e-02f, 2.67825186e-01f, -1.23967305e-01f, -1.64872035e-02f, 1.42095432e-01f, -6.48826435e-02f, -8.27434883e-02f, 1.37581274e-01f, 5.71748009e-04f, 5.30130416e-02f,
  4.87601236e-02f, -1.19837277e-01f, 2.70708520e-02f, -6.35923445e-02f, -8.66118968e-02f, -1.46168381e-01f, -4.25197221e-02f, -1.29662812e-01f, 4.08563279e-02f, 1.37305749e-03f,
  -1.18527092e-01f, -7.81714916e-02f, 6.00681342e-02f, 8.70694071e-02f, 2.59845164e-02f, 2.71029640e-02f, 7.58649558e-02f, 9.97519195e-02f, -2.91515458e-02f, 2.33958010e-02f,
  -1.06589217e-02f, -5.21385893e-02f, -6.81850407e-03f, 5.29084764e-02f, -8.12373236e-02f, 1.49882391e-01f, 2.83123236e-02f, -7.84522388e-03f, -9.39563960e-02f, -5.86040877e-02f,
  2.55996305e-02f, -2.90399604e-02f, 1.42568588e-01f, -2.71642823e-02f, -3.45270261e-02f, 4.25523147e-02f, -1.00110635e-01f, -5.71348965e-02f, -5.69471978e-02f, 3.82317565e-02f,
  -1.61619112e-01f, 6.06017224e-02f, 9.44639072e-02f, 1.16528841e-02f, 2.07372587e-02f, 1.14103742e-01f, 6.93611652e-02f, 2.92664580e-02f, 3.49009857e-02f, -6.72410205e-02f,
  1.26823157e-01f, -8.10666978e-02f, 8.92520621e-02f, -1.68026745e-01f, 1.57219589e-01f, 1.39947221e-01f, 1.32724270e-01f, -1.89212430e-02f, 6.80713356e-02f, -9.68971848e-02f,
  -1.58335711e-03f, -1.04690045e-01f, 1.35820448e-01f, -5.05293608e-02f, -1.94310829e-01f, -4.92174774e-02f, -1.28183484e-01f, 8.86543691e-02f, -1.93943139e-02f, 5.66200539e-02f,
  -9.54052210e-02f, -2.20391586e-01f, -2.16527492e-01f, -9.03447792e-02f, 2.73216404e-02f, -1.45784453e-01f, -3.85171138e-02f, -8.25288668e-02f, -2.29060307e-01f, -2.41580278e-01f,
  -4.10803676e-01f, -3.45491588e-01f, 5.30776102e-03f, -3.84554714e-01f, -2.43954286e-01f, -1.43204167e-01f, -1.76096797e-01f, 6.40312731e-02f, -1.00779824e-01f, -8.76010805e-02f,
  3.08483150e-02f, 2.17064451e-02f, -1.91192433e-01f, -8.61472189e-02f, -1.60616815e-01f, -1.42672136e-01f, -3.23718011e-01f, -1.06129296e-01f, 1.51155442e-01f, 3.71350348e-02f,
  -1.37027025e-01f, -2.66714245e-01f, -1.76408395e-01f, 7.94018060e-02f, -4.43464816e-02f, -9.54823717e-02f, -6.16884977e-02f, -2.03683302e-01f, -2.15567142e-01f, -3.20756137e-01f,
  2.46202260e-01f, -8.06934536e-02f, 8.43194425e-02f, -1.76708654e-01f, 7.59804845e-02f, 4.77986261e-02f, 4.89921123e-02f, 7.11802617e-02f, 1.83422137e-02f, -7.36424178e-02f,
  -1.30842015e-01f, 8.06547981e-03f, -1.32065371e-01f, 8.00764859e-02f, -7.63507038e-02f, -1.15959160e-02f, -1.05786435e-01f, -1.22145601e-01f, -1.50219813e-01f, -1.17767416e-02f,
  -3.98873806e-01f, -3.05684686e-01f, -1.34326413e-01f, 2.43556104e-03f, -3.76602821e-02f, -1.12469487e-01f, 2.52467036e-01f, -6.74454644e-02f, -4.76174727e-02f, -3.42550129e-01f,
  -3.86682786e-02f, 3.77573259e-03f, -3.12290657e-02f, 8.55180472e-02f, 1.02713004e-01f, 9.47401971e-02f, 1.79166161e-02f, -1.97258480e-02f, -1.87911578e-02f, 6.00384474e-02f,
  1.79824103e-02f, 1.70836031e-01f, 8.55128393e-02f, -7.45035931e-02f, -2.09134929e-02f, -1.07548922e-01f, -4.11883108e-02f, 6.97860047e-02f, 2.21952107e-02f, -1.12601668e-01f,
  1.82996541e-02f, -7.72391036e-02f, -5.66332862e-02f, 2.73774713e-01f, 1.07591003e-01f, 5.85545935e-02f, -4.86096404e-02f, 1.68399557e-01f, 1.30021930e-01f, 8.35551098e-02f,
  1.36755630e-01f, 1.07893877e-01f, -1.38366535e-01f, -4.84741330e-02f, -3.99676748e-02f, 5.72649091e-02f, -2.00141966e-01f, 6.69944510e-02f, -7.19234943e-02f, -2.35714689e-02f,
  6.65949658e-02f, -9.36905593e-02f, 3.98627669e-02f, 2.29620878e-02f, 1.53135866e-01f, 2.22205706e-02f, -1.05589457e-01f, -1.77309588e-01f, 2.28315834e-02f, 7.20753521e-02f,
  -2.08171934e-01f, -2.45797828e-01f, -2.49876723e-01f, -9.86148864e-02f, -5.75640909e-02f, -1.62231505e-01f, 1.13059625e-01f, 6.32596165e-02f, -8.83685276e-02f, -7.02961385e-02f,
  5.45297205e-01f, -1.29132017e-01f, -5.93015254e-01f, 9.03103575e-02f, -3.09725016e-01f, -4.26440209e-01f, -4.18848187e-01f, 1.36204615e-01f, 2.05406129e-01f, -1.25391334e-01f,
  -1.40717670e-01f, 1.15921445e-01f, 6.93284646e-02f, -9.33757052e-02f, -3.95838991e-02f, -4.30030882e-01f, -4.20531958e-01f, -2.70547450e-01f, -1.12727910e-01f, -1.00961216e-02f,
  -1.76856462e-02f, 1.11576371e-01f, 1.26516819e-01f, 9.38632339e-03f, -2.01650653e-02f, -6.68265149e-02f, -1.83785945e-01f, -1.52375132e-01f, -2.99498856e-01f, -2.28096366e-01f,
  -1.50986075e-01f, -1.48832858e-01f, -1.97281502e-02f, 9.65575352e-02f, -1.70487631e-02f, 1.23204060e-01f, 2.26793438e-02f, -1.38604874e-02f, 1.25265330e-01f, -3.38873751e-02f,
  -1.24120019e-01f, 1.09281735e-02f, 3.71784978e-02f, -1.51459202e-01f, 1.39899245e-02f, 3.96610759e-02f, 1.98428072e-02f, -1.45595104e-01f, -1.74318433e-01f, -4.11896370e-02f,
  -2.25092947e-01f, -2.90712506e-01f, 1.14076883e-02f, -2.09245831e-01f, -8.31533372e-02f, -5.26573174e-02f, -6.23008795e-02f, -6.56558350e-02f, -2.44169965e-01f, 1.48096949e-01f,
  -2.18757819e-02f, -5.75215444e-02f, -1.97200458e-02f, -5.28791873e-03f, 1.59375578e-01f, -5.51453829e-02f, 1.79470591e-02f, 2.84229331e-02f, -6.52812198e-02f, -6.04528636e-02f,
  -6.72616437e-02f, 1.76030546e-02f, 3.22813503e-02f, 3.76242884e-02f, -4.12483700e-02f, 9.15666018e-03f, 1.88021772e-02f, -2.67372001e-02f, -2.56563146e-02f, -6.65657446e-02f,
  -7.65523985e-02f, -1.47642598e-01f, -3.69457109e-03f, 1.24127679e-01f, -1.35582626e-01f, -7.62914345e-02f, 4.06621136e-02f, 2.48426516e-02f, 6.59598485e-02f, -2.31856238e-02f,
  3.23436290e-01f, -2.23341763e-01f, 2.34361589e-01f, 1.00437745e-01f, -2.33557597e-02f, -1.21505886e-01f, -4.40414734e-02f, -1.99255198e-02f, -5.03331237e-03f, -1.29956356e-03f,
  -7.08732903e-02f, 3.04453950e-02f, -9.13712755e-02f, -5.68631850e-02f, -7.98356831e-02f, 2.25429721e-02f, -2.89520677e-02f, -5.66999577e-02f, -2.11801734e-02f, -6.19703010e-02f,
  1.00583136e-01f, 1.57758482e-02f, 2.31420711e-01f, 7.58498237e-02f, 5.50115779e-02f, 2.03824222e-01f, -2.35868469e-02f, 5.57823367e-02f, -3.89822610e-02f, 2.39528522e-01f,
  3.58646065e-01f, -4.12337445e-02f, 2.16155037e-01f, 1.10963091e-01f, 3.41790885e-01f, 3.09431612e-01f, 3.91327351e-01f, 2.61524349e-01f, 2.18759105e-02f, 1.53282702e-01f,
  -9.94514674e-02f, -3.20676416e-01f, -2.64891833e-01f, -2.68606544e-01f, -1.39274746e-01f, 4.54061292e-02f, 5.50003685e-02f, 8.40578675e-02f, 1.42472163e-01f, 7.00830743e-02f,
  -4.70307991e-02f, 2.18886346e-01f, 6.75839037e-02f, 2.14140676e-02f, 3.49840112e-02f, -1.30195111e-01f, 8.81100893e-02f, 4.96682040e-02f, -1.64636914e-02f, -7.51473382e-02f,
  -1.67590827e-01f, 2.29983822e-01f, -1.57631069e-01f, -2.42319345e-01f, -1.10180587e-01f, -1.19584948e-01f, -4.56670970e-02f, -5.09647094e-02f, -2.04210859e-02f, 2.00454164e-02f,
  -2.28053629e-02f, -1.00244731e-01f, -9.22464132e-02f, -1.16660167e-02f, 8.78809690e-02f, 1.21589974e-01f, -3.73804085e-02f, -8.43869299e-02f, -1.44902812e-02f, -9.89708751e-02f,
  -7.51236379e-02f, 4.65745069e-02f, 9.84448269e-02f, -1.85154453e-02f, -6.00309856e-02f, -4.50390689e-02f, -6.63817227e-02f, -7.35857338e-02f, 1.96607821e-02f, -7.05948174e-02f,
  -1.97480559e-01f, -8.33834410e-02f, -7.28535354e-02f, 1.13018956e-02f, 6.00728430e-02f, 8.12919214e-02f, 1.10622741e-01f, -5.34845702e-02f, -1.82382073e-02f, 8.72882232e-02f,
  -3.45185064e-02f, 5.71158715e-02f, 8.55982751e-02f, 1.37154043e-01f, 5.24903946e-02f, 8.66664499e-02f, 1.36252671e-01f, 3.48263159e-02f, 1.79515500e-02f, 3.11077088e-02f,
  7.76076689e-02f, 3.55041623e-02f, 7.91872591e-02f, -3.82139087e-02f, -2.16060430e-02f, -2.42269207e-02f, 6.89021721e-02f, 9.06081498e-03f, -4.35513332e-02f, 1.00592375e-01f,
  9.98084620e-03f, 7.90893137e-02f, -1.94074884e-01f, -7.18340352e-02f, 4.51621450e-02f, -3.10053546e-02f, -6.43276945e-02f, 1.77340731e-02f, 2.74233166e-02f, -2.35418528e-02f,
  -9.27131027e-02f, 2.21568402e-02f, 4.73053865e-02f, -4.70975880e-03f, 1.14892192e-01f, 7.68164694e-02f, -7.01078176e-02f, 2.76729539e-02f, -5.75412624e-02f, -1.22992568e-01f,
  1.67163182e-02f, 8.68202299e-02f, 1.64274931e-01f, 7.23370761e-02f, -1.85027290e-02f, -1.13759311e-02f, 1.04631804e-01f, 1.22135421e-02f, 9.88622755e-02f, -1.43996170e-02f,
  3.33495289e-01f, 6.88030601e-01f, -6.27092898e-01f, 3.17038566e-01f, -1.86611429e-01f, -4.34929997e-01f, -1.27416193e-01f, 2.13233214e-02f, 1.39967695e-01f, 2.33770132e-01f,
  -5.22715524e-02f, -1.11020997e-01f, -7.63701648e-02f, -1.05743103e-01f, -2.73244232e-01f, 9.98838767e-02f, 2.16027379e-01f, -4.24486905e-01f, -5.14782608e-01f, -7.26189138e-03f,
  4.14651662e-01f, 4.49428052e-01f, 2.91355371e-01f, 1.51560411e-01f, 2.67873079e-01f, -2.97393035e-02f, 2.72670314e-02f, 1.08813800e-01f, 4.37282398e-02f, 1.96846142e-01f,
  -3.48294526e-01f, -9.73137990e-02f, -3.08426648e-01f, 1.98137641e-01f, -2.64544278e-01f, -1.08310953e-01f, -1.10264584e-01f, -1.98632419e-01f, -2.25039005e-01f, 1.86323419e-01f,
  -9.82871428e-02f, 3.92439514e-02f, -1.37930378e-01f, 9.48491842e-02f, 1.07447155e-01f, -6.14299588e-02f, 1.22241154e-01f, -2.00132847e-01f, -1.54539153e-01f, -3.27415884e-01f,
  2.88101077e-01f, -2.03577384e-01f, -5.61131775e-01f, -2.38164753e-01f, -3.79015625e-01f, -3.98382634e-01f, -2.94141173e-01f, -3.40715498e-01f, -4.67443436e-01f, 3.27667952e-01f,
  -7.89882690e-02f, -3.16733937e-03f, 7.06892554e-03f, 1.58666611e-01f, 1.84100822e-01f, 4.09944542e-03f, 2.20962763e-02f, 1.56029478e-01f, 1.16280876e-01f, 5.20775579e-02f,
  -1.90822128e-02f, -7.21570328e-02f, -2.68593967e-01f, -5.52872606e-02f, 1.98688582e-02f, -1.43305629e-01f, -1.03942193e-01f, 2.22194001e-01f, -1.31895924e-02f, -1.42510533e-01f,
  9.96793061e-03f, -4.57469597e-02f, -2.82889809e-02f, -2.39521116e-02f, 5.46490354e-03f, -1.11023575e-01f, 6.60256222e-02f, 4.31652889e-02f, -7.54048228e-02f, -5.86815774e-02f,
  2.77997375e-01f, -2.73323953e-01f, 1.46895900e-01f, -8.51204060e-03f, -3.02204378e-02f, 2.86601633e-02f, 4.74070981e-02f, -6.84078783e-02f, 4.12264988e-02f, 4.40332890e-02f,
  5.84046450e-03f, 2.65742000e-02f, 7.78764933e-02f, 1.84009761e-01f, -1.24354415e-01f, 1.55825280e-02f, 3.42809051e-01f, -3.47758122e-02f, 9.46708694e-02f, -1.16092518e-01f,
  3.64310145e-01f, 2.28181750e-01f, -7.52150863e-02f, 3.09839915e-03f, -9.37111378e-02f, 5.41364737e-02f, 9.76536870e-02f, -1.34332087e-02f, -2.64982998e-01f, 4.61411715e-01f,
  4.26033914e-01f, -1.57003120e-01f, -7.85030201e-02f, 3.70450228e-01f, 2.94504195e-01f, 3.09568584e-01f, 2.54369617e-01f, 2.44688988e-01f, 2.09676430e-01f, 2.41583273e-01f,
  1.69548467e-01f, 2.90627301e-01f, 2.70286918e-01f, 1.29412994e-01f, 3.35166045e-02f, 4.98246327e-02f, 1.27418473e-01f, -9.15149506e-03f, 1.10534199e-01f, 9.55872685e-02f,
  5.35445772e-02f, 5.05062193e-02f, 6.92690760e-02f, -6.03974015e-02f, 6.45422041e-02f, 1.16871253e-01f, -8.09938386e-02f, -8.51699337e-02f, -3.32433917e-02f, -9.80043560e-02f,
  -3.01521957e-01f, -2.14163974e-01f, 7.73898140e-02f, -5.68071827e-02f, -6.74693212e-02f, -8.04003477e-02f, -6.17108718e-02f, -2.12814789e-02f, 2.42178254e-02f, -6.31922483e-02f,
  -1.31564245e-01f, -1.30833477e-01f, 6.68885279e-03f, -1.30144402e-01f, -1.82048470e-01f, -1.42860031e-02f, -1.02603205e-01f, -5.06925061e-02f, -9.72387567e-03f, -1.46510795e-01f,
  2.87060253e-02f, -1.48206977e-02f, -1.54117167e-01f, 3.70271690e-03f, -5.41570224e-02f, 7.50574246e-02f, -5.82835861e-02f, -1.44177422e-01f, 9.94457211e-03f, -7.12237060e-02f,
  2.09737226e-01f, 3.73570621e-02f, 2.07483228e-02f, -7.76714459e-03f, -3.17316055e-02f, -4.72538806e-02f, -8.70504975e-03f, 5.25491312e-03f, 4.66733649e-02f, -1.91077232e-01f,
  -1.92732960e-01f, -2.52054390e-02f, 9.69153363e-04f, 7.45613575e-02f, 4.42353487e-02f, -7.74935633e-02f, -5.81788458e-02f, -1.44335300e-01f, -8.37760139e-03f, 8.02254379e-02f,
  -3.26154456e-02f, -1.87845260e-01f, 1.70000140e-02f, -4.97722849e-02f, -4.44396921e-02f, -3.90180647e-02f, 3.45310792e-02f, 8.78176168e-02f, -6.72996491e-02f, 9.09317806e-02f,
  -5.39595038e-02f, 8.26953575e-02f, 4.19281796e-02f, -5.46631813e-02f, -2.14749247e-01f, -5.98025136e-02f, 5.79572225e-04f, -4.43005711e-02f, 2.84843799e-02f, -6.51693940e-02f,
  -8.77690837e-02f, -1.27058979e-02f, -8.99706855e-02f, -1.12386867e-01f, -5.58983162e-02f, -6.57249615e-02f, 1.69156864e-02f, -2.54940651e-02f, -6.33774027e-02f, -1.40862182e-01f,
  -1.59159128e-03f, -2.88323257e-02f, 9.37547907e-02f, -2.79358029e-03f, -1.43858297e-02f, 1.45520777e-01f, -9.15599614e-02f, 2.47529075e-02f, 5.41214012e-02f, 9.66435447e-02f,
  1.35074966e-02f, -2.66872823e-01f, 2.36261822e-03f, 1.41280189e-01f, 1.77111968e-01f, 2.81430960e-01f, 2.59797305e-01f, 1.20094202e-01f, 2.45343179e-01f, 5.49678318e-02f,
  3.08744200e-02f, 1.23343349e-01f, 1.73584566e-01f, 9.16544870e-02f, 3.91673185e-02f, 1.70412809e-01f, 2.19646111e-01f, 4.07304838e-02f, 1.48646995e-01f, 7.01805204e-02f,
  2.01832801e-01f, 6.98439404e-03f, -6.66882396e-02f, -1.39002930e-02f, 6.08417578e-03f, 5.56445122e-02f, 1.15931906e-01f, 1.10894911e-01f, -4.58802879e-02f, 1.12031348e-01f,
  -2.05660611e-01f, -1.93391979e-01f, -4.53352705e-02f, -1.23738162e-01f, -1.40969515e-01f, -7.35775381e-02f, 3.57129201e-02f, -1.26412600e-01f, -8.24672952e-02f, -6.94501176e-02f,
  -1.50326848e-01f, -1.38967425e-01f, -8.48705769e-02f, -1.12208851e-01f, -6.97011054e-02f, -1.30212978e-01f, -1.00990511e-01f, 8.06280151e-02f, 2.28578132e-03f, -2.96371467e-02f,
  -3.01629957e-02f, 6.90249652e-02f, -7.08836094e-02f, 1.10491872e-01f, 7.10048378e-02f, -3.32798399e-02f, -1.21021479e-01f, 2.34723324e-04f, 3.03817261e-02f, 1.97484680e-02f,
  2.32292414e-01f, 1.43167511e-01f, 9.39156488e-02f, 5.84692508e-02f, 1.37482300e-01f, 2.56605353e-02f, -5.99398836e-03f, 6.24924935e-02f, 1.76382706e-01f, 6.66581932e-03f,
  3.09536066e-02f, 1.04703657e-01f, 4.15210687e-02f, 1.23303659e-01f, 4.76150960e-02f, -5.37019335e-02f, 8.35945904e-02f, 1.44373747e-02f, -6.20144196e-02f, 3.21476161e-02f,
  1.44470995e-02f, -8.95477906e-02f, -4.60591987e-02f, -9.49016362e-02f, 4.68510538e-02f, 4.36362997e-02f, -1.00890985e-02f, -3.63438688e-02f, 7.43780285e-02f, -4.32278663e-02f,
  7.07010925e-02f, 4.97211218e-02f, 8.34978744e-02f, -5.35238497e-02f, -1.61997780e-01f, -2.07024634e-01f, -6.69487342e-02f, -4.09214525e-03f, -5.45362905e-02f, -1.44967046e-02f,
  -2.76849531e-02f, -1.94730699e-01f, -1.32042617e-01f, 4.08016779e-02f, -5.77834509e-02f, -5.46939597e-02f, -5.91260903e-02f, 5.98622113e-02f, 1.33936787e-02f, -3.84796932e-02f,
  -7.07634017e-02f, 9.92227420e-02f, 1.94112822e-01f, 1.91209212e-01f, 1.79397970e-01f, 1.48288533e-01f, -6.77127019e-02f, 5.83614931e-02f, -5.34468815e-02f, 1.00929856e-01f,
  -2.10491911e-01f, -1.38626948e-01f, -1.63526982e-01f, -3.73416305e-01f, 9.71332863e-02f, 8.09301063e-02f, -3.10331166e-01f, -2.76460171e-01f, -1.93655550e-01f, -1.26407847e-01f,
  7.45186359e-02f, 7.55044669e-02f, -2.99774140e-01f, -2.15612471e-01f, -3.81739706e-01f, -4.47743237e-01f, -3.47640604e-01f, -3.40020895e-01f, -1.11097343e-01f, 2.35003740e-01f,
  1.62833959e-01f, -1.05337873e-01f, -1.49848059e-01f, 1.26665048e-02f, 3.60495085e-03f, -3.52330729e-02f, -9.61500779e-02f, -1.62868440e-01f, -3.49472389e-02f, -1.97424993e-01f,
  -2.83900052e-01f, -2.47798160e-01f, 5.08623682e-02f, -6.39499947e-02f, 1.50795117e-01f, 1.53543949e-01f, -3.20466310e-02f, -5.51352575e-02f, 5.82524724e-02f, -1.34604946e-01f,
  4.80216183e-02f, 1.51242912e-01f, -4.63043712e-02f, 2.44347192e-02f, 1.75762959e-02f, -4.98051047e-02f, -1.04511932e-01f, -5.39555624e-02f, -1.72197074e-01f, 1.85483113e-01f,
  1.09594733e-01f, -4.01028842e-02f, -2.73684025e-01f, 3.29640470e-02f, -1.28206432e-01f, -6.94108456e-02f, 4.05605771e-02f, 7.49133974e-02f, -1.89748317e-01f, -2.70830154e-01f,
  -8.55699778e-02f, -9.18185860e-02f, 3.22436378e-03f, 2.33626049e-02f, -1.24459798e-02f, -7.61996955e-02f, -7.62858987e-02f, -6.74372092e-02f, 4.75286990e-02f, 3.72675322e-02f,
  -4.70161028e-02f, -3.58376442e-03f, -1.76199898e-02f, -7.57944509e-02f, -8.44829902e-02f, -1.06261835e-01f, -4.82219197e-02f, -1.55850127e-01f, 1.28899524e-02f, -4.87359241e-03f,
  -6.48034178e-03f, -8.45899507e-02f, -9.39894617e-02f, -7.95574114e-02f, -2.37513632e-02f, -8.22246149e-02f, 3.10823862e-02f, -1.05769169e-02f, -9.64813158e-02f, 3.92549522e-02f,
  -2.75969505e-01f, 1.06010392e-01f, -2.76952714e-01f, -2.68348940e-02f, -1.25319049e-01f, 1.42931536e-01f, 9.28277001e-02f, 8.79332274e-02f, 7.16317743e-02f, -1.17421545e-01f,
  2.83465702e-02f, -1.43872365e-01f, -6.76805526e-02f, 6.07076436e-02f, 2.15879083e-02f, 5.78437224e-02f, -1.42497420e-01f, -1.80758238e-01f, -5.54250777e-02f, 1.53867096e-01f,
  -9.50313658e-02f, -2.45010152e-01f, -3.03688079e-01f, -2.20422029e-01f, -9.74042639e-02f, -2.94035912e-01f, -1.89664498e-01f, -1.39002576e-01f, -3.51915509e-01f, -3.21012020e-01f,
  -6.01025701e-01f, 1.68250397e-01f, 1.95702150e-01f, -1.80018216e-01f, -3.57695520e-01f, -4.35795724e-01f, -3.25495481e-01f, -2.91099638e-01f, -9.66898873e-02f, 7.34606683e-02f,
  1.14103563e-01f, -9.27785933e-02f, 1.34683922e-01f, -1.60552144e-01f, -2.14403003e-01f, 1.64276436e-01f, 1.03568539e-01f, -1.84592903e-01f, -4.52705741e-01f, -6.04791045e-01f,
  -4.41337764e-01f, -4.26316887e-01f, -4.00854856e-01f, -1.55581072e-01f, -9.48281661e-02f, -1.52359188e-01f, 4.50884849e-02f, -1.17162764e-01f, -2.36600816e-01f, -8.68530869e-02f,
  2.00500175e-01f, -2.30417192e-01f, -1.41425654e-01f, -1.45607129e-01f, -2.63936147e-02f, 2.83008683e-02f, -4.75818068e-02f, 3.47582251e-02f, -1.24447644e-02f, 4.37678806e-02f,
  -3.97949247e-03f, 1.04663176e-02f, 4.24639927e-03f, -1.22291699e-01f, -3.00889313e-02f, -4.06073406e-02f, -2.07243413e-02f, -1.09380856e-01f, 2.58815382e-02f, 1.45732313e-01f,
  1.11996323e-01f, -2.68789642e-02f, 8.91012549e-02f, -2.69515309e-02f, -1.07350394e-01f, -1.65893972e-01f, 7.59432316e-02f, -1.59014583e-01f, -4.24858630e-02f, 1.16745993e-01f,
  1.44927219e-01f, 8.13188329e-02f, -7.25823715e-02f, -3.80736254e-02f, 4.15211124e-03f, -9.64132324e-03f, 6.44444451e-02f, 4.49743718e-02f, -1.07249403e-02f, 7.99291879e-02f,
  1.11545194e-02f, -1.83353890e-02f, -6.53646663e-02f, 1.61085315e-02f, -8.17187876e-03f, -8.01320896e-02f, -1.18081227e-01f, 4.20132354e-02f, 1.11516543e-01f, 2.98985690e-02f,
  -3.12309302e-02f, 1.92004610e-02f, 7.91558847e-02f, -1.31203681e-01f, -4.51134369e-02f, 4.98223454e-02f, 4.07678708e-02f, 6.88499883e-02f, -7.46259373e-03f, -3.00238375e-02f,
  -4.14336659e-02f, -2.29867101e-01f, 4.67849933e-02f, 1.08317574e-02f, 8.06865618e-02f, 4.96781282e-02f, 1.07366517e-01f, 3.58856618e-02f, -3.31866071e-02f, -7.25489184e-02f,
  -4.06051390e-02f, 1.84480712e-01f, 6.66020736e-02f, 9.85898823e-02f, -7.86701143e-02f, 5.58761097e-02f, 6.40805438e-02f, -3.61486636e-02f, 8.60372484e-02f, 2.46261865e-01f,
  2.60351270e-01f, 8.90470296e-02f, 1.04779519e-01f, 1.78998411e-01f, 9.80276540e-02f, 2.25101337e-02f, 1.34603783e-01f, 1.73159570e-01f, 8.32022801e-02f, 3.04920703e-01f,
  4.48827624e-01f, 5.02377674e-02f, 9.13252011e-02f, 1.20498233e-01f, 1.46002211e-02f, -8.00889060e-02f, -2.35100910e-01f, -8.46570954e-02f, 2.54876968e-02f, 2.11062536e-01f,
  1.69549540e-01f, 2.15093195e-01f, 2.05461428e-01f, 1.32436588e-01f, 5.49318902e-02f, 5.20210043e-02f, -7.67318392e-03f, 2.42210001e-01f, 2.07805052e-01f, 2.13896230e-01f,
  2.28426486e-01f, 1.40415758e-01f, 7.84390420e-02f, 7.20930919e-02f, 1.95561603e-01f, 1.28024608e-01f, 9.58011895e-02f, 1.87670365e-01f, 9.93520841e-02f, 1.51517749e-01f,
  2.38550127e-01f, 2.23346412e-01f, -6.48419559e-02f, 1.19061835e-01f, -3.37236226e-02f, -7.80219072e-03f, -3.35442722e-02f, -1.11281358e-01f, 5.87314963e-02f, -9.19226781e-02f,
  -2.53456011e-02f, -4.49827267e-03f, -1.65978298e-02f, -5.94522953e-02f, 3.43563147e-02f, -3.94285321e-02f, 5.00126742e-02f, 3.60353105e-02f, -2.14222260e-02f, -1.23757077e-02f,
  1.65055677e-01f, 9.15353596e-02f, -7.10377917e-02f, -1.57178491e-01f, -7.19489530e-02f, 5.53918295e-02f, -1.16104141e-01f, 4.77528572e-02f, -7.94136748e-02f, 3.37547325e-02f,
  9.26366970e-02f, 5.77053502e-02f, 3.97932269e-02f, 7.14379251e-02f, 2.16404319e-01f, 5.84715605e-03f, 5.22978529e-02f, 6.93758130e-02f, 1.30565450e-01f, 1.52428085e-02f,
  6.58416674e-02f, 1.35626465e-01f, -8.33861008e-02f, 1.13906585e-01f, 7.84797445e-02f, -2.21478697e-02f, 1.63961630e-02f, -2.93475520e-02f, -7.00719561e-03f, -5.29419817e-02f,
  5.21993637e-02f, -1.07715437e-02f, -5.71121946e-02f, 4.91602719e-02f, -7.97827467e-02f, 6.63771778e-02f, 9.58385840e-02f, -4.22575325e-02f, -3.86169292e-02f, -1.64275467e-02f,
  -2.73801476e-01f, -1.95152551e-01f, 2.76534483e-02f, -4.73178085e-03f, 2.96387319e-02f, -5.59872612e-02f, 1.80735663e-02f, -3.12516503e-02f, -1.00754514e-01f, -1.65469125e-02f,
  -8.56726244e-02f, -8.99266601e-02f, -2.79561579e-02f, -5.24225645e-02f, -1.44615918e-01f, -8.84739980e-02f, -1.22840196e-01f, -5.19681200e-02f, -5.99264428e-02f, -2.18296666e-02f,
  -1.80967197e-01f, -1.64008856e-01f, -1.37776166e-01f, -8.39418396e-02f, -1.73047096e-01f, -1.38893917e-01f, -2.44908497e-01f, -1.34049848e-01f, -1.35697514e-01f, -1.25032410e-01f,
  -2.10926622e-01f, -3.62260491e-02f, 1.08241495e-02f, 6.82441657e-03f, 2.47184448e-02f, -3.47002894e-01f, -3.72983724e-01f, -3.97434831e-01f, -2.53066629e-01f, -1.27530709e-01f,
  -2.57122487e-01f, 3.00753936e-02f, 1.17909573e-01f, 1.67068273e-01f, 1.36094213e-01f, 1.21240474e-01f, 4.29025531e-01f, 4.02229100e-01f, 2.56087691e-01f, 1.28135219e-01f,
  1.33360982e-01f, 1.81248933e-01f, 2.12048560e-01f, 1.68700904e-01f, 1.84689820e-01f, 9.50422585e-02f, 9.25485790e-02f, 1.32892236e-01f, 1.89691678e-01f, 5.80332220e-01f,
  -2.97763012e-02f, -3.42941850e-01f, -1.30212754e-01f, -4.37713191e-02f, 1.19164512e-01f, 7.59487301e-02f, -8.36968720e-02f, 1.92957520e-02f, -3.33786011e-03f, 6.23055622e-02f,
  1.78233370e-01f, -1.60285067e-02f, 4.05823626e-02f, 3.33287939e-02f, -4.42172252e-02f, -2.54539251e-01f, 6.28051385e-02f, 2.30210330e-02f, -8.63290280e-02f, 3.85605507e-02f,
  3.42483610e-01f, 8.03743452e-02f, -1.53314620e-01f, -1.64543852e-01f, -1.34540901e-01f, 2.24022418e-01f, -1.80196688e-02f, -1.99578665e-02f, -2.42456824e-01f, 8.55476689e-03f,
  -2.34134831e-02f, 4.39903289e-02f, -1.27130419e-01f, 3.75954434e-02f, 5.41652776e-02f, 1.59296338e-02f, 1.08537540e-01f, 9.96449590e-02f, 4.48733242e-03f, -9.57151726e-02f,
  1.15359262e-01f, 1.47855151e-02f, 6.89595267e-02f, -8.83421600e-02f, 4.26184125e-02f, -1.27431422e-01f, 2.93807443e-02f, -4.32509370e-02f, 7.60079101e-02f, -1.53999418e-01f,
  -1.50479190e-03f, 5.31379767e-02f, -1.74055956e-02f, 1.41571000e-01f, -1.14740707e-01f, 1.86096393e-02f, -1.67534649e-02f, 1.16862962e-02f, -1.00918472e-01f, 3.49240303e-02f,
  -3.77826869e-01f, -1.85576871e-01f, -7.17628673e-02f, -5.97897284e-02f, 2.78078788e-03f, 9.58877504e-02f, 3.48136649e-02f, 9.40739438e-02f, -6.66233972e-02f, 1.97284650e-02f,
  -2.11034566e-01f, -1.96687086e-03f, -1.52660593e-01f, 7.49159679e-02f, 4.07621672e-04f, -1.77952111e-01f, -7.92654753e-02f, -1.15950089e-02f, -1.44832805e-01f, -7.76258931e-02f,
  9.41611975e-02f, -2.01304913e-01f, -1.45238116e-01f, -2.18520671e-01f, -2.47162312e-01f, -1.54467016e-01f, -1.96642935e-01f, -1.29010260e-01f, -4.52021897e-01f, -3.64829659e-01f,
  3.92858028e-01f, -3.34890664e-01f, -2.65505929e-02f, 1.87431946e-01f, 1.06531128e-01f, -9.09062661e-03f, -6.76059797e-02f, -3.05204019e-02f, 1.12050615e-01f, 6.06084540e-02f,
  1.57011673e-01f, 2.25264668e-01f, 1.39037326e-01f, 2.41895970e-02f, 2.27587596e-02f, -4.48362753e-02f, -7.24609047e-02f, 1.43763676e-01f, 2.01680735e-01f, 8.63021314e-02f,
  7.98118338e-02f, -1.47572784e-02f, 1.30163416e-01f, 1.53625570e-02f, -3.81636731e-02f, 5.31752668e-02f, -2.62918007e-02f, -2.27335189e-02f, -7.07405508e-02f, -5.51683791e-02f,
  1.01257153e-02f, -7.82216266e-02f, 9.68515426e-02f, 1.08187214e-01f, 3.23339738e-03f, -1.02011161e-02f, -1.20427841e-02f, -9.43200290e-02f, -3.92631963e-02f, -2.59956270e-02f,
  9.05414224e-02f, 7.55321886e-03f, 6.59060478e-02f, -9.25998092e-02f, 1.03422590e-02f, 8.43112692e-02f, 7.81035423e-02f, 4.31845076e-02f, -1.04174271e-01f, -1.07772447e-01f,
  6.03760481e-02f, 1.46952450e-01f, 9.06013250e-02f, 8.94382000e-02f, -1.16875665e-02f, 1.51935250e-01f, 5.23609556e-02f, 8.52244794e-02f, 7.50548616e-02f, -1.40048536e-02f,
  1.87039837e-01f, 3.58812660e-01f, 3.26213062e-01f, 1.14586800e-01f, -1.15083558e-02f, 3.06266807e-02f, 3.87510061e-02f, 4.99669947e-02f, 1.74190402e-01f, 9.82274637e-02f,
  -5.97402342e-02f, 2.22596936e-02f, -4.06396128e-02f, 1.79399744e-01f, 1.34456143e-01f, 9.38106924e-02f, -1.65801533e-02f, -9.66365822e-03f, 7.75510594e-02f, 1.40950289e-02f,
  1.45797417e-01f, 3.15585881e-02f, 1.17486073e-02f, -1.76738366e-01f, -3.79698165e-02f, 7.22488090e-02f, 2.00307101e-01f, 1.10357739e-01f, 1.58884376e-01f, 4.41458784e-02f,
  -1.67134836e-01f, 1.35779411e-01f, 7.52578825e-02f, 3.82580683e-02f, 1.46931941e-02f, -9.03763995e-02f, -9.02857631e-02f, -8.48989114e-02f, -1.77945703e-01f, -2.34687150e-01f,
  -1.77050531e-01f, -8.74703974e-02f, 2.56945249e-02f, 1.95243657e-02f, 6.03671707e-02f, 3.68850790e-02f, 1.21672684e-02f, -4.42414321e-02f, -1.22395046e-01f, -1.42548233e-01f,
  -1.07180864e-01f, -4.22002375e-02f, 1.38574064e-01f, 3.01644411e-02f, 3.58145460e-02f, 1.80178598e-01f, 3.29711963e-03f, 2.83997110e-03f, -1.73738152e-02f, 1.67430621e-02f,
  -1.65453970e-01f, 1.36203736e-01f, -3.98372896e-02f, 2.46321738e-01f, 1.97915360e-01f, 3.09597030e-02f, 1.86991751e-01f, 1.16883792e-01f, 1.88751489e-01f, 1.13284461e-01f,
  9.96008143e-02f, 2.58536726e-01f, 2.46969417e-01f, 1.49502784e-01f, 2.09155947e-01f, 1.71268433e-01f, 2.48840719e-01f, 3.55747677e-02f, -8.43648389e-02f, 7.11053833e-02f,
  2.69826382e-01f, 2.25338310e-01f, 6.81823045e-02f, 4.25075889e-02f, 1.86327994e-01f, 2.91885048e-01f, 2.50396132e-01f, 9.63105038e-02f, 2.03987777e-01f, 3.13787967e-01f,
  -8.94201398e-02f, -6.53865337e-02f, -4.55385484e-02f, 4.57553528e-02f, 3.16039380e-03f, -1.28810704e-02f, -1.02595739e-01f, -1.35684013e-01f, 3.41765992e-02f, -3.46722128e-03f,
  -6.30755797e-02f, -4.84387390e-02f, 4.80718911e-02f, -2.63843648e-02f, -1.39627427e-01f, -1.00469902e-01f, -2.46635191e-02f, 5.02811931e-02f, 7.70516619e-02f, -6.75259158e-02f,
  -1.00556482e-02f, -8.78177285e-02f, -1.22551918e-01f, 6.49615237e-03f, 1.22100674e-02f, -5.21636680e-02f, -5.70853241e-03f, 2.63912436e-02f, -4.53606211e-02f, -7.66211152e-02f,
  2.35770047e-02f, -5.59522361e-02f, -7.83130899e-02f, -4.97557111e-02f, -9.01414156e-02f, -7.97884837e-02f, -8.67875740e-02f, 7.14677721e-02f, 8.18754286e-02f, -3.55882421e-02f,
  -1.00905009e-01f, -1.41423773e-02f, 2.88892947e-02f, -5.61038703e-02f, -3.00958417e-02f, -2.04414520e-02f, -4.98052351e-02f, -8.50740373e-02f, -1.88719615e-01f, -3.09811942e-02f,
  -4.73496653e-02f, 6.16156124e-03f, -9.59745869e-02f, -9.11259949e-02f, -8.82271305e-02f, -9.23781693e-02f, -9.38487053e-02f, -1.95263382e-02f, 4.49089631e-02f, 2.96836384e-02f,
  2.73470253e-01f, -2.12186258e-02f, 1.17414005e-01f, 8.57945159e-02f, -5.68089746e-02f, -4.42610942e-02f, 1.09224744e-01f, 1.74616203e-02f, -5.25915958e-02f, 3.52818109e-02f,
  -6.85587758e-04f, -4.35719527e-02f, -9.17279273e-02f, -4.29945067e-02f, -1.58967674e-01f, -1.37962475e-01f, -4.43057679e-02f, 1.80355832e-01f, 5.85200861e-02f, -9.95409265e-02f,
  -9.48077142e-02f, 2.41018608e-02f, -2.87063941e-02f, -1.05366416e-01f, 8.17898512e-02f, -4.82330583e-02f, -9.99373794e-02f, -1.22101508e-01f, -7.88424611e-02f, -1.20595671e-01f,
  1.19698653e-02f, 4.36566323e-01f, 3.79408151e-02f, 3.75534706e-02f, 2.55801350e-01f, 1.72865000e-02f, -8.77331421e-02f, -5.92044294e-02f, 2.22423859e-02f, 1.56971812e-01f,
  5.44028655e-02f, 3.29914726e-02f, 9.10778046e-02f, -1.01919912e-01f, -1.88544393e-01f, 3.51380631e-02f, 1.02821358e-01f, 8.21001269e-03f, -2.60266125e-01f, -1.13302074e-01f,
  7.69402236e-02f, 1.16714180e-01f, -1.53936585e-02f, 1.00669633e-04f, 2.92112917e-01f, -7.99608976e-02f, 1.20135024e-01f, 1.97000474e-01f, -8.81351356e-04f, 3.37207198e-01f,
  -2.25256994e-01f, 3.08890283e-01f, -5.41483641e-01f, 4.32091504e-02f, 1.44628450e-01f, -1.85924441e-01f, 3.85026708e-02f, 1.28020987e-01f, 4.31432724e-02f, 3.07570379e-02f,
  4.82384525e-02f, 3.91432866e-02f, 1.17758431e-01f, 9.57763940e-02f, 1.45402834e-01f, -1.15619726e-01f, -1.45061072e-02f, -7.60947019e-02f, -1.31005973e-01f, 5.83967566e-02f,
  2.72480398e-01f, 1.30317912e-01f, 4.85809259e-02f, -6.98338225e-02f, 1.14486460e-02f, -1.54259637e-01f, -6.27929866e-02f, 1.15420558e-02f, -3.11876833e-01f, -1.84570123e-02f,
  6.30908534e-02f, 2.53268760e-02f, 1.11855246e-01f, 3.30441771e-03f, -1.24279730e-01f, 4.36659381e-02f, 2.01642394e-01f, 6.73624650e-02f, -9.70537886e-02f, 9.04145911e-02f,
  -1.28461421e-02f, -1.52854502e-01f, -8.77724141e-02f, -8.12623184e-03f, -9.96522829e-02f, 1.95723608e-01f, -1.62516460e-02f, -3.12054511e-02f, -8.16406030e-03f, -1.67964045e-02f,
  6.87606558e-02f, 8.72006938e-02f, 8.19011852e-02f, 1.70500204e-02f, -1.36537170e-02f, -1.19886145e-01f, -9.45378169e-02f, -1.28001556e-01f, 7.56139681e-02f, 1.06651876e-02f,
  -2.99752295e-01f, -3.42876077e-01f, -2.67409444e-01f, 2.68217064e-02f, 1.86889246e-01f, -7.67206633e-03f, -1.64368842e-02f, 5.68503095e-03f, 5.94001710e-02f, 1.00878552e-02f,
  -1.03424720e-01f, -1.68525606e-01f, 8.34308639e-02f, -4.40654084e-02f, -5.10168709e-02f, -7.43001476e-02f, 1.69677541e-01f, -3.44678224e-03f, 1.93489273e-03f, 2.05268383e-01f,
  1.36560664e-01f, -1.00681879e-01f, -1.94189653e-01f, -1.11573167e-01f, 7.21951798e-02f, -3.05200934e-01f, -3.55112046e-01f, -3.56028676e-01f, -4.61814135e-01f, -4.07201976e-01f,
  -1.33303612e-01f, 5.78928627e-02f, -5.15346602e-02f, 1.13864847e-01f, 6.71957433e-02f, -2.20705010e-02f, -1.82426088e-02f, -5.53146079e-02f, 7.08273277e-02f, 1.11689076e-01f,
  4.01910581e-02f, 1.01128519e-01f, 1.49432719e-01f, 1.07215174e-01f, 6.22521378e-02f, 4.12967540e-02f, 1.33451983e-01f, 2.78955512e-02f, -7.91014917e-03f, -2.75525991e-02f,
  5.99683858e-02f, 4.43292782e-02f, 1.18547626e-01f, 1.34380519e-01f, 6.42263889e-02f, 6.98259249e-02f, 4.17812243e-02f, 9.19441134e-02f, 4.52395007e-02f, 9.39907283e-02f,
  -3.05674784e-03f, -9.34855342e-02f, 8.49763826e-02f, 1.04641184e-01f, -2.54441146e-02f, 1.33837685e-01f, 3.03368662e-02f, -3.37752216e-02f, 1.42464310e-01f, 1.31502211e-01f,
  4.73913029e-02f, 2.01516002e-02f, -4.55000736e-02f, 8.74324739e-02f, 1.42971613e-03f, 8.97569358e-02f, -1.17943011e-01f, -7.40490928e-02f, 5.86755760e-02f, 6.51818216e-02f,
  2.29009185e-02f, -5.14734425e-02f, -8.22457299e-02f, 2.62365509e-02f, 2.47441381e-02f, -5.21549657e-02f, -9.12224576e-02f, 5.72010428e-02f, -2.07588058e-02f, 2.76267286e-02f,
  1.44714311e-01f, -3.38308811e-02f, -4.87974994e-02f, 3.13962214e-02f, -8.46708640e-02f, 9.03775617e-02f, 6.99781403e-02f, 5.31369112e-02f, 1.05871022e-01f, 3.47410142e-02f,
  1.36606842e-01f, 2.20550057e-02f, 4.87664901e-02f, 1.08038336e-02f, 1.30632073e-01f, 1.73054561e-02f, -2.07277872e-02f, 2.84893364e-02f, 5.73887713e-02f, -6.18928112e-02f,
  5.27693108e-02f, 7.74787068e-02f, 2.05743939e-01f, 6.66005239e-02f, -6.18425906e-02f, 6.43816292e-02f, 7.56410733e-02f, -3.62879527e-03f, 7.80769661e-02f, 5.58962934e-02f,
  1.14355810e-01f, -9.73440781e-02f, -9.26470086e-02f, -9.33896080e-02f, 4.52490747e-02f, -2.80732773e-02f, -2.95007527e-02f, 6.70107529e-02f, 1.15577206e-01f, 3.98628302e-02f,
  7.12817833e-02f, -4.60441271e-03f, -2.29863524e-02f, -2.45108809e-02f, 3.44662033e-02f, -2.44846642e-02f, -6.31145434e-03f, -4.54438590e-02f, 3.28964181e-02f, 1.08031757e-01f,
  7.34532773e-02f, 3.44553404e-02f, -1.94526110e-02f, 7.03780865e-03f, 2.98791216e-03f, 3.84889124e-03f, -3.33798453e-02f, 4.88260686e-02f, -7.14129508e-02f, 1.26530021e-01f,
  4.19405609e-01f, 9.85120460e-02f, 2.76317596e-01f, 4.34404202e-02f, 1.38473168e-01f, 1.17138162e-01f, 2.77723938e-01f, 1.68115169e-01f, 6.14851378e-02f, 7.93219134e-02f,
  -1.06226154e-01f, -2.46790960e-01f, -1.46626145e-01f, -1.06524505e-01f, 2.80695409e-02f, -2.52355635e-02f, 2.99501661e-02f, 1.35541320e-01f, 6.80788755e-02f, 5.95199689e-02f,
  -8.77053961e-02f, 7.38280863e-02f, 4.05344293e-02f, -7.11951032e-03f, -1.11293793e-01f, -1.28439695e-01f, 6.34790957e-02f, 4.54963259e-02f, -2.00539418e-02f, -3.79181057e-02f,
  8.87499228e-02f, 7.11744800e-02f, -4.33079079e-02f, -2.40127742e-01f, -6.25345707e-02f, 4.98344526e-02f, 4.35196050e-02f, -8.75830427e-02f, -1.33822439e-02f, -5.18306717e-02f,
  1.88299268e-02f, 3.58827747e-02f, 1.13571651e-01f, 2.80076172e-02f, 4.98680584e-02f, 1.24399811e-02f, 4.06321920e-02f, 6.01134188e-02f, -2.20244918e-02f, -7.97578469e-02f,
  -6.63132891e-02f, 7.38433227e-02f, 2.88164038e-02f, -9.70436726e-03f, -1.34479124e-02f, -6.58184886e-02f, -1.43310949e-02f, 5.55729792e-02f, -8.23824033e-02f, -6.46861121e-02f,
  -1.72095031e-01f, -2.94889156e-02f, -2.17850972e-02f, 4.85643819e-02f, 3.55804898e-02f, 1.16438545e-01f, 1.64087608e-01f, -3.01068909e-02f, 1.85403258e-01f, 8.72930065e-02f,
  1.38084739e-01f, 9.99903083e-02f, 9.00987461e-02f, 4.77246009e-02f, -7.60650337e-02f, 2.81242710e-02f, 1.78033292e-01f, -5.00610098e-02f, -5.74403480e-02f, 9.66250226e-02f,
  -3.68123055e-02f, 1.34564385e-01f, 3.45957689e-02f, 4.02124673e-02f, 7.24310204e-02f, 6.18849471e-02f, -4.44836654e-02f, 2.93673966e-02f, 2.21088883e-02f, 5.23993857e-02f,
  -2.21864879e-01f, 2.40113866e-02f, -3.50256599e-02f, -5.95184639e-02f, -3.66570801e-02f, -3.65407765e-02f, -8.57683793e-02f, -1.45169690e-01f, -1.21547811e-01f, -2.63284110e-02f,
  -2.24416833e-02f, 2.87015233e-02f, -2.52241408e-03f, -5.56506626e-02f, 1.18966192e-01f, 5.11841215e-02f, -6.58362880e-02f, 9.48257968e-02f, -9.43650603e-02f, -5.81881925e-02f,
  -1.44194663e-01f, 9.08234864e-02f, 4.88022715e-02f, -1.22852139e-02f, -3.99123318e-02f, -1.99372927e-03f, 7.50734061e-02f, 4.05645296e-02f, 8.23416486e-02f, 8.60870034e-02f,
  -4.82168853e-01f, -8.37523788e-02f, -3.82012010e-01f, -1.59015521e-01f, -9.59800258e-02f, -9.59712043e-02f, 1.69378936e-01f, 1.83646619e-01f, 2.31876850e-01f, 1.35623828e-01f,
  3.62778082e-02f, -1.11247689e-01f, -4.30613786e-01f, -2.95688063e-01f, -3.81979078e-01f, -1.05316199e-01f, -3.69535238e-01f, -4.46434319e-01f, -1.53522283e-01f, 4.00825977e-01f,
  6.57666251e-02f, -2.59733647e-01f, -3.03875953e-01f, -8.99631158e-02f, 2.47050494e-01f, -1.57133222e-01f, -2.32898518e-01f, -3.33189338e-01f, -3.46875608e-01f, -4.33487028e-01f,
  5.99496923e-02f, 4.49161455e-02f, 1.77120685e-03f, -3.14609170e-01f, 5.55711277e-02f, 1.85380727e-01f, 1.92877486e-01f, 3.64662595e-02f, 1.46566778e-02f, 1.60447702e-01f,
  7.69297704e-02f, 3.04507732e-01f, 9.82910842e-02f, 2.30537459e-01f, 2.49064252e-01f, 2.49960124e-01f, -9.02320296e-02f, -1.37352720e-01f, -2.40838334e-01f, 2.34770671e-01f,
  -1.34730250e-01f, -2.61194527e-01f, -3.68358880e-01f, -1.60052314e-01f, 1.98885590e-01f, -2.67885536e-01f, 8.81583765e-02f, 2.08282501e-01f, -2.20973998e-01f, -1.21349869e-02f,
  1.19986258e-01f, 1.38840199e-01f, 1.44963667e-01f, 6.49035871e-02f, 1.98481441e-01f, -4.99003306e-02f, 1.20840780e-01f, 5.95521107e-02f, 8.49591270e-02f, 1.11917198e-01f,
  1.43698141e-01f, 1.43196747e-01f, 2.38623619e-01f, 1.77091360e-01f, -6.33705556e-02f, -8.37994516e-02f, 1.48264375e-02f, -2.25644652e-02f, 3.98101434e-02f, -1.26392543e-01f,
  -5.00134230e-02f, 3.52882617e-03f, -8.38463008e-02f, 3.03816870e-02f, -1.47550270e-01f, 3.00543662e-02f, 6.77716359e-02f, 1.40760973e-01f, 1.96981147e-01f, 3.01514678e-02f,
  7.72902220e-02f, -1.87780917e-01f, -2.66917306e-03f, 7.48037398e-02f, 1.14496887e-01f, 1.26210451e-01f, -7.67933354e-02f, 2.78373100e-02f, 6.42150640e-02f, 3.04885536e-01f,
  1.39575094e-01f, 2.44284898e-01f, 1.38308302e-01f, 1.70155868e-01f, 1.19063437e-01f, 6.70106336e-02f, -7.08955666e-03f, -3.28382522e-01f, -3.20074677e-01f, 2.22719967e-01f,
  -1.53512478e-01f, -1.46983564e-01f, -4.72885579e-01f, -1.74498290e-01f, 8.70810673e-02f, -2.57320464e-01f, -1.73066944e-01f, 1.03234969e-01f, -1.78070024e-01f, 2.05355994e-02f,
  -6.99836075e-01f, 2.59058863e-01f, 3.60147566e-01f, -3.63737196e-01f, 2.14531850e-02f, 2.21491933e-01f, 3.14716905e-01f, 4.93242517e-02f, -1.32348284e-01f, 3.00279930e-02f,
  -1.91266965e-02f, -2.06013590e-01f, 9.58067551e-03f, 8.79414566e-03f, 2.10632369e-01f, 4.16433811e-01f, 2.57304907e-01f, -7.95866400e-02f, 1.47914151e-02f, -5.74985519e-02f,
  -8.87734536e-03f, -1.08602040e-01f, -2.12066472e-01f, -1.36693820e-01f, -1.83078907e-02f, -4.07644957e-02f, 1.24413982e-01f, 2.58654710e-02f, 1.34381071e-01f, 2.04438884e-02f,
  4.04657453e-01f, -2.01405827e-02f, -7.07863718e-02f, -1.30225688e-01f, 6.05880134e-02f, -1.18316926e-01f, -3.79305705e-02f, -1.31103229e-02f, 7.95699060e-02f, 3.91314626e-02f,
  -7.43887713e-03f, -2.54982095e-02f, 1.13854244e-01f, 1.38713837e-01f, -5.05232662e-02f, 5.19291796e-02f, 6.95853606e-02f, 4.21737768e-02f, 2.22708777e-01f, 2.33050197e-01f,
  1.39885396e-01f, 1.04971044e-02f, 9.57385972e-02f, 3.16411585e-01f, 2.62015045e-01f, -1.35032341e-01f, 2.87118047e-01f, 5.30582704e-02f, 1.07562959e-01f, -1.34709701e-01f,
  6.84210584e-02f, -1.37580141e-01f, 6.50337115e-02f, -9.17519554e-02f, -5.14107645e-02f, 3.91216204e-02f, -1.00244612e-01f, -5.50115220e-02f, -4.02344652e-02f, -4.39964142e-03f,
  1.51791647e-01f, 1.91249311e-01f, 3.70800160e-02f, -1.04474202e-01f, -7.63416514e-02f, 1.60245359e-01f, 3.04850172e-02f, -5.04981801e-02f, 6.42925277e-02f, 8.00056756e-02f,
  -3.13798562e-02f, 1.44534901e-01f, 5.82538061e-02f, 8.05924386e-02f, 5.40525168e-02f, 4.59238216e-02f, 2.02393420e-02f, 4.28425558e-02f, 1.56582985e-02f, -5.71882129e-02f,
  1.74403057e-01f, 3.85929942e-02f, -6.69814721e-02f, -4.46695201e-02f, -7.19873309e-02f, -7.00580776e-02f, -4.69151102e-02f, -1.05321348e-01f, 4.45938036e-02f, 6.09227084e-02f,
  9.25496817e-02f, -1.91133946e-01f, 6.13987483e-02f, 1.31327379e-02f, -1.29736513e-01f, -1.36266962e-01f, -2.34200656e-01f, -1.51220486e-01f, 1.53293997e-01f, 7.59877861e-02f,
  -2.50153593e-03f, -1.81831032e-01f, -1.60340339e-01f, 5.30552715e-02f, 8.09979439e-03f, -2.49022961e-01f, -3.35303061e-02f, -4.64667454e-02f, 1.33697700e-03f, -3.09466660e-01f,
  -4.89649206e-01f, 1.90195218e-02f, -2.25914065e-02f, -1.57984406e-01f, 4.14999276e-02f, 1.65210322e-01f, 2.06807360e-01f, 1.63002387e-02f, -4.51180190e-02f, -3.75279598e-02f,
  2.28152368e-02f, 1.29680395e-01f, 6.42000884e-02f, 6.58766180e-02f, 2.03876749e-01f, 2.78803766e-01f, 1.09585442e-01f, -1.65065692e-03f, -8.92230310e-03f, 3.12878117e-02f,
  1.61807418e-01f, 1.09255053e-02f, -2.54428357e-01f, -6.07930385e-02f, 7.81975836e-02f, 1.61961883e-01f, -1.77195873e-02f, 2.81271301e-02f, 1.60373989e-02f, 1.52042016e-01f,
  3.23396415e-01f, -3.40681553e-01f, 3.10648642e-02f, -1.19990319e-01f, -1.10141598e-01f, -5.89467809e-02f, -1.00831769e-01f, -2.25466952e-01f, -1.65067673e-01f, 4.49605808e-02f,
  -3.36892940e-02f, -1.71783000e-01f, -3.23699191e-02f, -1.29829675e-01f, -6.74358979e-02f, -5.53887971e-02f, -6.42595440e-02f, -1.85072094e-01f, 5.52575756e-03f, 1.01530515e-02f,
  1.12357408e-01f, -1.63484409e-01f, -1.16351910e-01f, -3.57359722e-02f, 6.90978616e-02f, -1.06434263e-01f, 1.25744836e-02f, -9.47353318e-02f, -8.14900100e-02f, -7.23312274e-02f,
  9.61342007e-02f, 4.90941182e-02f, 3.02030705e-03f, -1.28090726e-02f, 1.33796846e-02f, 8.57562199e-02f, 1.21513501e-01f, 6.94222450e-02f, 1.01801805e-01f, 1.19053863e-01f,
  2.11349851e-03f, 8.89458954e-02f, -1.49572473e-02f, 2.29152180e-02f, -7.12238550e-02f, -1.90585218e-02f, -6.55770376e-02f, 4.89397794e-02f, -7.81604461e-03f, -9.75434706e-02f,
  -4.76550777e-03f, -7.29259104e-02f, -1.43356711e-01f, -3.33282761e-02f, -5.81579357e-02f, -2.41718702e-02f, -7.37300515e-02f, 5.21605881e-03f, -3.03065795e-02f, -4.29271497e-02f,
  4.34248835e-01f, -1.25413969e-01f, 4.21462171e-02f, 2.14869268e-02f, -4.92481850e-02f, -7.99798593e-02f, 1.19492546e-01f, -3.29579525e-02f, 6.63943496e-03f, 8.11026394e-02f,
  -5.31177316e-03f, 1.39294360e-02f, 1.35274336e-01f, -1.07360017e-02f, 1.02094814e-01f, -7.61972666e-02f, -4.67880964e-02f, 4.30278771e-04f, 7.31897447e-03f, -1.54169882e-02f,
  1.07466936e-01f, 1.06215023e-01f, 1.87616974e-01f, 2.10751444e-01f, 1.96425579e-02f, 1.27151757e-01f, 1.47844955e-01f, 1.65659726e-01f, 1.44710258e-01f, 8.74290019e-02f,
  -5.10243654e-01f, -4.69762206e-01f, 3.38646442e-01f, -2.36119509e-01f, 7.20210597e-02f, -3.36575694e-02f, -3.74165982e-01f, -1.82086274e-01f, -4.69134524e-02f, -3.34091395e-01f,
  -1.74577788e-01f, -1.23746749e-02f, -2.77028173e-01f, -3.75588462e-02f, -2.14077815e-01f, -3.39712083e-01f, -5.50483726e-02f, 2.36584857e-01f, 4.62459743e-01f, 2.17470497e-01f,
  -1.17593706e-01f, 1.76107846e-02f, 2.55040556e-01f, 1.86740950e-01f, -1.67901993e-01f, -1.20922908e-01f, 1.82256009e-02f, -1.48673907e-01f, -2.62383074e-01f, -4.11657721e-01f,
  -3.07352334e-01f, -2.05754191e-01f, 3.91850859e-01f, 9.07097608e-02f, 1.41229659e-01f, -2.01276630e-01f, -1.47564307e-01f, 1.86066981e-02f, -7.73765966e-02f, 1.01427995e-02f,
  -8.52984041e-02f, -6.42391890e-02f, -2.00590745e-01f, 6.52240589e-02f, -1.26517236e-01f, -1.04926236e-01f, 2.29874805e-01f, 1.73076272e-01f, 7.83768296e-02f, -1.20657817e-01f,
  -1.35479912e-01f, -1.10214517e-01f, -1.02284722e-01f, -1.16997194e-02f, -1.09057486e-01f, 1.39410272e-01f, -9.31857675e-02f, -9.10590664e-02f, 1.39968786e-02f, -5.02158046e-01f,
  -2.80450452e-02f, 8.03676322e-02f, 1.26912072e-02f, -3.72600602e-03f, -3.86213958e-02f, -3.06312870e-02f, 7.08465278e-02f, -1.37411743e-01f, 5.38198799e-02f, -5.13809137e-02f,
  8.04795995e-02f, -1.80855840e-02f, 7.58742690e-02f, -2.82227062e-02f, -3.43091860e-02f, -1.50164152e-02f, -5.33367358e-02f, 1.17288761e-01f, 2.02325657e-02f, -1.53284539e-02f,
  2.04922222e-02f, -5.47648333e-02f, 1.51794150e-01f, 6.53947219e-02f, 9.61508453e-02f, 1.33895546e-01f, -4.58198562e-02f, 9.67158079e-02f, -6.98939338e-02f, -3.74850519e-02f,
  -2.03782886e-01f, 4.01429415e-01f, -2.87979901e-01f, -5.19774593e-02f, -6.13788329e-02f, 2.11112693e-01f, 6.15784479e-03f, 5.15745021e-02f, 2.02407744e-02f, 7.70349521e-03f,
  -5.19575849e-02f, -1.68062672e-01f, -1.58768848e-01f, 8.09140503e-02f, -4.86179292e-02f, -5.61664961e-02f, -2.37090647e-01f, -1.90307468e-01f, 1.42636150e-01f, -7.32295066e-02f,
  -8.26879814e-02f, -1.69953912e-01f, -4.73953217e-01f, -2.83028334e-01f, -2.45654121e-01f, -2.04212084e-01f, -2.11668283e-01f, -6.02787472e-02f, -1.72735721e-01f, -5.64095795e-01f,
  -2.51921445e-01f, -5.42948186e-01f, -7.33473748e-02f, -7.30582058e-01f, -4.29804593e-01f, -2.12461248e-01f, -2.52796710e-01f, -2.52632201e-01f, -3.55296850e-01f, -5.08116603e-01f,
  -2.28122234e-01f, 1.06793597e-01f, -6.97713345e-03f, 2.51586527e-01f, 4.11338151e-01f, -1.74571499e-01f, -4.77316789e-02f, 4.49864984e-01f, 3.96992207e-01f, -1.65453402e-03f,
  -1.50842950e-01f, -2.15084478e-01f, 2.77084023e-01f, -2.65340544e-02f, -5.49257755e-01f, -2.18415573e-01f, -2.32004598e-01f, -1.94853917e-01f, 7.63459131e-02f, -3.84883761e-01f,
  -2.35679105e-01f, -4.48625907e-02f, 9.29923803e-02f, 2.12635085e-01f, -7.29070231e-02f, 5.54233082e-02f, -8.82903859e-02f, 1.36681393e-01f, 8.81010145e-02f, -1.35915816e-01f,
  -8.98948088e-02f, -4.32085022e-02f, -9.84333456e-02f, -1.14531800e-01f, -1.60850048e-01f, -9.90969036e-03f, 9.23684612e-03f, 2.37482369e-01f, 1.08040534e-02f, -8.42770748e-03f,
  -2.23591793e-02f, 5.80013730e-02f, -1.23813062e-03f, 8.55968371e-02f, 3.64624262e-02f, 2.19311982e-01f, 8.15559085e-03f, -7.34509826e-02f, 2.30209991e-01f, -4.17897761e-01f,
  -6.35429174e-02f, -7.32933730e-02f, -7.01573193e-02f, -1.85822025e-02f, 1.20915212e-01f, 7.19899908e-02f, -8.90288502e-02f, -1.48483953e-02f, 1.63149491e-01f, 1.08355843e-01f,
  -3.36443856e-02f, 3.33502889e-02f, 3.01237516e-02f, -7.93945789e-03f, 4.22670245e-02f, -9.74253044e-02f, 6.74757808e-02f, -3.88118140e-02f, -3.15094087e-03f, 8.52459222e-02f,
  7.39234611e-02f, -7.41912276e-02f, -3.43510248e-02f, 9.10292715e-02f, 1.42620370e-01f, 1.66848078e-02f, -7.77745172e-02f, 6.86410889e-02f, -1.67089090e-01f, 6.97226077e-03f,
  -4.03156668e-01f, 3.71991217e-01f, -3.50786179e-01f, 7.74986623e-03f, -1.30641967e-01f, -4.96970266e-02f, -4.10098545e-02f, 2.12708026e-01f, -7.18832016e-02f, -1.85124859e-01f,
  1.64237753e-01f, -5.11158854e-02f, -4.37664725e-02f, 5.90698533e-02f, -1.81727123e-03f, 3.76451910e-02f, 3.27019617e-02f, -9.03971568e-02f, 8.09822679e-02f, -4.73821089e-02f,
  1.08609078e-02f, 7.39652589e-02f, -1.43748060e-01f, -4.20321822e-02f, -3.10529675e-02f, 4.81772088e-02f, -1.19273931e-01f, -3.29452986e-03f, 2.31239840e-01f, -4.61361617e-01f,
  4.65693474e-01f, -5.40972531e-01f, -6.44553244e-01f, 1.42206013e-01f, -2.38279864e-01f, -2.88468987e-01f, -5.04425466e-01f, 5.58600873e-02f, 2.76788712e-01f, -4.93687332e-01f,
  -3.03417921e-01f, 2.17079505e-01f, -8.78843386e-03f, 6.10458925e-02f, 3.75674553e-02f, -4.37886477e-01f, -4.37425107e-01f, -7.23155439e-02f, 2.90551275e-01f, 2.30118930e-01f,
  -4.21247743e-02f, 2.28011191e-01f, 3.83835733e-01f, 2.01566011e-01f, -1.11791685e-01f, -9.69266668e-02f, -4.23222184e-01f, -1.81223691e-01f, -2.47998819e-01f, -4.26653296e-01f,
  -2.87346631e-01f, -2.07719833e-01f, -8.07765871e-02f, 9.36669335e-02f, -1.19680323e-01f, 1.45015074e-02f, 1.19968668e-01f, 3.43675949e-02f, 7.51016438e-02f, -5.04590059e-03f,
  -4.20509987e-02f, 6.11081794e-02f, 2.32096091e-01f, 4.24658461e-03f, 7.35917985e-02f, -2.15416830e-02f, 7.40807205e-02f, -3.34150414e-03f, -3.69807035e-02f, -1.68839961e-01f,
  -1.07911818e-01f, -1.60568640e-01f, -5.56447078e-03f, -2.16023088e-01f, -1.26703223e-02f, 1.14904650e-01f, -2.24645901e-02f, -3.62389870e-02f, -7.81232715e-02f, -1.30723700e-01f,
  8.38011354e-02f, 7.50968582e-04f, -1.07924035e-02f, -3.31686577e-03f, 1.41209662e-01f, -8.23979229e-02f, 1.05182879e-01f, -4.81336936e-02f, 7.30429962e-02f, 5.82736507e-02f,
  -1.67348627e-02f, -1.03584573e-01f, 9.85427275e-02f, -3.83955538e-02f, 8.42678994e-02f, -3.36504988e-02f, -1.26204878e-01f, 3.19090821e-02f, 1.21256553e-01f, -5.44772707e-02f,
  -8.47360864e-03f, -8.55315477e-03f, 5.17063290e-02f, 1.77125651e-02f, -7.74404854e-02f, -4.54080440e-02f, -1.13242552e-01f, 1.00368634e-01f, 1.80626512e-01f, 2.84919366e-02f,
  2.76818752e-01f, -1.96368620e-01f, -5.01039214e-02f, 4.71341386e-02f, 3.35152186e-02f, -3.83977927e-02f, 6.08049408e-02f, 6.48267940e-02f, 1.30308168e-02f, 2.82749720e-02f,
  -1.13857709e-01f, 5.07766008e-02f, -6.65771356e-03f, -1.75981894e-02f, 1.62579581e-01f, -4.56573181e-02f, -1.18805736e-01f, -1.47163823e-01f, 5.26217632e-02f, 2.75316741e-02f,
  -2.83665471e-02f, 9.09088477e-02f, 1.83783531e-01f, -6.52502626e-02f, 2.93889958e-02f, 2.06536740e-01f, 1.98813085e-03f, 1.79248359e-02f, 2.76307091e-02f, -7.32026026e-02f,
  3.34971100e-01f, 1.25753686e-01f, 2.04586208e-01f, -4.68451232e-02f, -3.79442036e-01f, -3.50141793e-01f, -1.96632937e-01f, 1.20507188e-01f, 1.69301145e-02f, -4.94369827e-02f,
  -2.67653495e-01f, -2.21446529e-01f, -4.33910824e-02f, 8.45820159e-02f, 1.86232507e-01f, 7.23415464e-02f, -6.39356114e-03f, 2.08635718e-01f, 1.19906388e-01f, -2.43289798e-01f,
  -2.68170983e-01f, -1.15324795e-01f, 6.78938404e-02f, 1.67046189e-01f, 8.44908729e-02f, 3.78936008e-02f, 1.00778908e-01f, 3.42058465e-02f, -3.23226638e-02f, 3.47583860e-01f,
  -1.47554744e-02f, 3.59013736e-01f, -5.00763990e-02f, -1.05344892e-01f, -8.44653919e-02f, 1.21813484e-01f, -9.82011557e-02f, 3.87356728e-02f, -1.62413362e-02f, 2.40446329e-02f,
  -1.24552660e-01f, -2.69491132e-02f, -8.30938295e-02f, -8.21255445e-02f, -6.35696128e-02f, 4.52741943e-02f, -2.71296501e-02f, 1.88816965e-01f, -7.45226536e-03f, 3.61448328e-04f,
  -3.15029770e-01f, -1.69123828e-01f, -5.91717176e-02f, -1.22604020e-01f, 5.24757244e-02f, -1.40785053e-01f, 4.39105146e-02f, 1.68353885e-01f, 1.61053598e-01f, 2.48932779e-01f,
  -2.43892744e-01f, -1.63019687e-01f, -1.47310063e-01f, -7.54838586e-02f, -5.39792441e-02f, -6.60454482e-02f, -8.83264914e-02f, -8.23739320e-02f, -1.23893358e-02f, 3.99148948e-02f,
  -3.03654391e-02f, -6.83776364e-02f, -7.08544850e-02f, -3.40169519e-02f, -3.24805491e-02f, -6.63959458e-02f, -7.45188370e-02f, 8.28485284e-03f, -4.78014313e-02f, 1.79813448e-02f,
  4.32080142e-02f, 5.47885336e-02f, 2.36248765e-02f, 3.75191942e-02f, 9.23377499e-02f, 6.24567382e-02f, -5.72840916e-03f, -1.14649283e-02f, -1.44749478e-01f, -2.27031559e-02f,
  -2.30756029e-01f, -3.22910994e-01f, -5.27476752e-03f, 1.84634060e-01f, -4.67924625e-02f, -5.19216470e-02f, -1.13154808e-02f, 3.96962389e-02f, -4.09175716e-02f, 1.53003171e-01f,
  3.79667953e-02f, 7.23182186e-02f, -3.93604897e-02f, -1.02329217e-02f, -1.01381630e-01f, -3.08644511e-02f, -2.69625694e-01f, -6.85953796e-02f, -1.07984036e-01f, -8.46416056e-02f,
  -1.59445882e-01f, -1.09363668e-01f, -1.15747407e-01f, -9.65403616e-02f, -9.32502151e-02f, -4.94993106e-02f, -1.67918384e-01f, -8.43254179e-02f, -2.01089457e-02f, -2.52157208e-02f,
  3.17043811e-01f, 2.05100775e-01f, 4.61819947e-01f, -7.73172826e-02f, -3.00993323e-01f, -2.26322234e-01f, -2.56818295e-01f, -1.81823879e-01f, -2.15448231e-01f, -1.12253003e-01f,
  -1.97904751e-01f, -3.00071210e-01f, -1.77418560e-01f, -7.36060143e-02f, 2.61010587e-01f, 1.49796709e-01f, 2.28551522e-01f, 4.50615764e-01f, 2.55894482e-01f, 2.41396744e-02f,
  -3.49843949e-02f, 2.88876235e-01f, 4.37413067e-01f, 1.91260263e-01f, -6.53598160e-02f, -2.55646497e-01f, 1.57373220e-01f, 8.80114883e-02f, 1.40601814e-01f, 1.53285354e-01f,
  1.26578525e-01f, 1.45351008e-01f, -2.72975117e-01f, -8.42234269e-02f, 7.51305595e-02f, 1.25736266e-01f, 4.15287986e-02f, 2.61669755e-01f, 4.93662842e-02f, 8.47996920e-02f,
  -2.29617525e-02f, 1.64610505e-01f, -1.30616739e-01f, 1.72187705e-02f, -6.54318109e-02f, 1.23442970e-02f, 1.67522803e-01f, 2.55293161e-01f, 2.55075302e-02f, 7.02042058e-02f,
  -2.69781053e-01f, 5.17871454e-02f, 7.27861598e-02f, -2.21295692e-02f, 7.18901455e-02f, -2.58258820e-01f, -7.19580352e-02f, 1.82880629e-02f, 2.84000523e-02f, 1.40487716e-01f,
  -1.54744938e-01f, 1.92401364e-01f, 1.53275073e-01f, 7.59591982e-02f, -1.17099006e-02f, -1.02692753e-01f, 1.99548882e-02f, 4.45073936e-03f, -8.01451388e-04f, 1.35574579e-01f,
  -7.25450441e-02f, 4.56831194e-02f, 2.06316918e-01f, 1.58818383e-02f, -1.64154157e-01f, 2.27317102e-02f, 6.79336488e-02f, -9.90646146e-03f, -9.42551997e-04f, 5.84216381e-04f,
  -1.70516416e-01f, -1.03033535e-01f, -2.92424969e-02f, 7.69848675e-02f, -1.13853598e-02f, -1.96120478e-02f, -4.41856831e-02f, 6.74931034e-02f, -4.69304994e-02f, -3.88839915e-02f,
  -3.86618972e-01f, 1.42368523e-03f, -1.48920596e-01f, 6.87074885e-02f, -5.25158159e-02f, -6.00673854e-02f, -2.65206039e-01f, 4.72782664e-02f, 3.96690145e-03f, 9.53267515e-02f,
  2.97188442e-02f, -5.82043380e-02f, -6.03879131e-02f, -1.85380541e-02f, -5.37240952e-02f, -1.32816389e-01f, 2.25843340e-02f, -4.95534874e-02f, -5.83530888e-02f, 6.49731308e-02f,
  -1.26222715e-01f, -2.11367220e-01f, -3.44002306e-01f, -2.78943002e-01f, -3.39566916e-01f, -4.58027631e-01f, -1.89294368e-01f, -2.16576979e-01f, -2.92787373e-01f, -3.69610816e-01f,
  -4.77825433e-01f, 1.20671451e-01f, -4.69207428e-02f, -4.49503064e-01f, -4.31253225e-01f, -6.51930720e-02f, -4.96638305e-02f, -1.57630682e-01f, -2.83879042e-01f, -1.29658476e-01f,
  2.32608527e-01f, 9.47962031e-02f, 8.41626897e-02f, 2.42542058e-01f, 2.91498989e-01f, 9.97804552e-02f, -2.66613275e-01f, -2.42222741e-01f, -7.16198906e-02f, -1.04227766e-01f,
  -1.97546497e-01f, -3.51655126e-01f, -3.51423532e-01f, -1.89215362e-01f, -2.27898225e-01f, -1.01363584e-01f, -2.81560928e-01f, -3.32565248e-01f, 2.83783078e-02f, -3.29359591e-01f,
  3.19089532e-01f, -2.54965216e-01f, 6.66252449e-02f, -1.49866343e-01f, -7.78404921e-02f, 1.10728450e-01f, 3.21958438e-02f, -9.69249457e-02f, -6.63802912e-03f, 6.35384694e-02f,
  -1.50044486e-01f, -1.13563620e-01f, -6.68140501e-02f, -5.85168190e-02f, -1.91036046e-01f, 4.03568819e-02f, -2.48243660e-01f, -2.32360631e-01f, -9.73251760e-02f, 2.40154922e-01f,
  4.02726643e-02f, -1.67638794e-01f, -9.91460122e-03f, 2.23496348e-01f, 7.57850781e-02f, -6.76231608e-02f, 1.60684362e-01f, -4.99702580e-02f, 1.11482497e-02f, -2.48813108e-01f,
  -8.55280459e-02f, 1.44256920e-01f, -9.88246575e-02f, -1.44422248e-01f, 8.35843161e-02f, 6.31481558e-02f, -1.08084835e-01f, -2.15353742e-01f, 2.01740619e-02f, 1.71483144e-01f,
  -7.46202320e-02f, 1.28192538e-02f, 7.07895905e-02f, 4.79301810e-02f, 2.39383355e-02f, -2.40058288e-01f, 1.57689229e-01f, -2.31394134e-02f, 6.41556904e-02f, -6.68845000e-03f,
  7.73686543e-03f, -2.51977574e-02f, -1.00039326e-01f, 1.19228333e-01f, 7.78458193e-02f, -7.47603774e-02f, -4.32617441e-02f, 1.36724725e-01f, -1.73391461e-01f, -1.09426439e-01f,
  1.79495916e-01f, 2.14611307e-01f, 1.36120796e-01f, -1.44957647e-01f, -1.51508823e-01f, 8.50202888e-03f, 1.28785288e-02f, 3.72139341e-03f, -5.03669642e-02f, 6.49317494e-03f,
  4.68120053e-02f, -5.15857115e-02f, -2.77522020e-02f, -9.19061154e-02f, 1.09283451e-03f, -1.41982939e-02f, -3.23296487e-02f, -1.64141700e-01f, -8.35697278e-02f, 1.05058789e-01f,
  6.25598207e-02f, -5.10826744e-02f, 1.72539353e-01f, 1.07742891e-01f, 7.50510395e-02f, 3.57270241e-02f, 2.65216202e-01f, 2.32207447e-01f, 3.18376541e-01f, 9.18988883e-02f,
  -4.78538811e-01f, 4.20078009e-01f, 3.05772781e-01f, 9.68985632e-03f, 3.93284917e-01f, 1.89342514e-01f, 2.17435703e-01f, -1.80560976e-01f, -8.12236741e-02f, 2.10531607e-01f,
  4.30034667e-01f, 6.51693642e-02f, 5.24864197e-02f, -2.57847514e-02f, -3.42593074e-01f, 1.14559650e-01f, 1.39743745e-01f, -1.88203514e-01f, -4.45538521e-01f, -2.89370149e-01f,
  7.24135637e-02f, -1.40113860e-01f, -3.30441177e-01f, -2.45470583e-01f, 6.86275437e-02f, -9.37413648e-02f, 2.68172383e-01f, 1.08737566e-01f, 8.06552470e-02f, 1.21010251e-01f,
  1.78400412e-01f, 1.31254867e-01f, -1.42216131e-01f, 1.25619352e-01f, 3.59077662e-01f, -1.70619011e-01f, -8.59345868e-02f, -1.12436280e-01f, 6.93693906e-02f, -8.47589374e-02f,
  1.47164181e-01f, -1.18703224e-01f, 1.38694704e-01f, -1.88647717e-01f, -1.71888247e-01f, -6.90489858e-02f, -2.21830875e-01f, -3.50473583e-01f, -3.52916360e-01f, -5.26672713e-02f,
  1.72215119e-01f, 8.50747526e-02f, 2.18526796e-02f, -1.23775586e-01f, -2.09764138e-01f, -1.55234963e-01f, -1.72449857e-01f, -4.50079590e-01f, -3.86366189e-01f, -3.31192374e-01f,
  -5.67879640e-02f, 9.82596353e-03f, 5.49348406e-02f, -8.35728571e-02f, -2.15429161e-02f, 2.99249291e-02f, 1.64240282e-02f, 1.30365714e-01f, -4.33614030e-02f, -5.05828671e-02f,
  6.58713207e-02f, -2.56743506e-02f, -1.85699314e-02f, 8.10604095e-02f, -5.71556315e-02f, 1.99304912e-02f, -3.65993641e-02f, -1.09733023e-01f, -6.37050718e-03f, -1.02927007e-01f,
  -5.34255281e-02f, 1.35898096e-02f, -9.13444608e-02f, -9.61643606e-02f, 7.25751221e-02f, 1.07230008e-01f, -4.75111157e-02f, -4.80825230e-02f, 1.50380582e-02f, -6.31899461e-02f,
  -3.52157235e-01f, 1.13252252e-01f, -7.13004246e-02f, -8.55095237e-02f, 7.91414380e-02f, -3.28450054e-02f, 2.50421278e-02f, 5.72236776e-02f, 1.52917385e-01f, -5.19980676e-02f,
  2.15061121e-02f, -1.91106033e-02f, 1.66607156e-01f, -1.16045885e-01f, -9.34138745e-02f, 2.97149904e-02f, 8.40391517e-02f, 1.38080895e-01f, -1.35884255e-01f, 5.94573617e-02f,
  -3.33961509e-02f, -2.18484476e-01f, -1.85743243e-01f, -6.91327974e-02f, -1.08230449e-01f, -2.34713674e-01f, -2.08943442e-01f, -3.36417943e-01f, -3.36139649e-01f, -3.68378431e-01f,
  4.58254337e-01f, -4.04628545e-01f, -2.19355270e-01f, 2.97870338e-02f, -2.26086006e-01f, -2.85283238e-01f, -3.74471754e-01f, -1.63356945e-01f, 7.37085193e-02f, -4.01693881e-01f,
  -1.77756533e-01f, 2.98877150e-01f, 2.91716546e-01f, 1.85423329e-01f, 3.43921967e-02f, -5.39816976e-01f, -3.84174109e-01f, 4.99632470e-02f, 3.26792628e-01f, -5.15431538e-02f,
  -8.44580680e-02f, 2.90671494e-02f, 2.02953517e-01f, 2.20527197e-03f, -2.05026656e-01f, -6.08188771e-02f, -3.34713638e-01f, -1.22568510e-01f, -2.36962318e-01f, -3.64820063e-01f,
  -2.69982159e-01f, 7.84520879e-02f, 8.03253874e-02f, 1.74779013e-01f, -1.06388703e-01f, 2.01652050e-02f, -8.18369761e-02f, 7.18956217e-02f, 2.14486178e-02f, -7.03431740e-02f,
  3.38812917e-02f, 8.30884501e-02f, 2.37137839e-01f, 6.93513602e-02f, -9.11895558e-03f, 3.55757289e-02f, 4.06397097e-02f, 4.45231609e-02f, 8.43100846e-02f, -1.36461869e-01f,
  -1.48760647e-01f, -9.51309726e-02f, 1.06081106e-01f, -1.38056695e-01f, 5.96387014e-02f, 2.18301117e-01f, -2.24366337e-01f, -8.68629571e-03f, 9.54755545e-02f, -2.74380445e-01f,
  -8.23940560e-02f, -2.61996780e-02f, -9.78477150e-02f, -1.20468577e-03f, -7.23351585e-03f, -3.40744630e-02f, 2.02487875e-03f, 2.24455670e-02f, 3.04385107e-02f, 1.71035025e-02f,
  -2.04424709e-02f, -7.13350400e-02f, 2.90063526e-02f, -7.71245733e-02f, -1.96765196e-02f, -2.76105646e-02f, -4.98935021e-02f, -4.27407995e-02f, -4.77655977e-02f, -1.50804576e-02f,
  8.47731531e-02f, -9.72477195e-04f, 1.47853419e-02f, -2.27379594e-02f, -5.65845929e-02f, 8.30564573e-02f, -1.63148139e-02f, -6.98628742e-03f, 9.78251100e-02f, 1.19719496e-02f,
  6.67559505e-02f, -7.83700403e-03f, -1.15623325e-01f, 1.03872105e-01f, -7.28818402e-02f, -3.72646041e-02f, -4.10333015e-02f, -5.34949638e-02f, 4.95446660e-02f, 1.86537746e-02f,
  3.78842205e-02f, 1.09155707e-01f, 5.45003228e-02f, 3.80465463e-02f, -2.36008111e-02f, 3.74957100e-02f, -1.56394124e-01f, -8.47988725e-02f, 3.04304734e-02f, -1.80152029e-01f,
  -2.30573505e-01f, 3.91006097e-02f, 1.59306481e-01f, -5.66201378e-03f, -5.69396652e-02f, 1.07701048e-01f, -1.09910466e-01f, -1.33260980e-01f, 3.16047929e-02f, -2.11507633e-01f,
  -5.63560605e-01f, 2.04839155e-01f, 1.37357354e-01f, 4.62241955e-02f, -8.75930861e-02f, -1.24518357e-01f, -2.28811085e-01f, -1.13605097e-01f, -1.52721792e-01f, 2.44094757e-03f,
  8.22211355e-02f, 8.76156390e-02f, 6.05321825e-02f, 1.50821432e-01f, -6.83606341e-02f, -1.06213652e-02f, 1.78787142e-01f, 1.04915999e-01f, -6.34599179e-02f, 5.16502783e-02f,
  1.20283090e-01f, 3.39085534e-02f, 2.95583084e-02f, 6.86677173e-02f, 3.11764777e-01f, 1.07126743e-01f, 7.72611573e-02f, 5.31437322e-02f, 9.11777094e-02f, 4.55863446e-01f,
  4.11191970e-01f, -1.32449985e-01f, 7.76458979e-02f, -2.04689670e-02f, -5.78515120e-02f, 4.39468920e-02f, -8.14654157e-02f, -1.31738535e-03f, -5.15748672e-02f, 1.04255810e-01f,
  5.58857322e-02f, -5.43480627e-02f, -6.20245561e-02f, -1.80786336e-03f, 9.27988440e-02f, 6.20415360e-02f, -1.43731073e-01f, 2.81899180e-02f, 4.99024428e-02f, 6.67425222e-04f,
  1.45773560e-01f, 3.91172506e-02f, 1.01651968e-02f, -3.25465687e-02f, -1.68860376e-01f, -9.15270206e-03f, -9.30220038e-02f, -7.93943240e-04f, -1.24415681e-01f, 2.72746384e-03f,
  -8.12437609e-02f, -8.32445621e-02f, 6.07997961e-02f, -1.15613759e-01f, -7.53266290e-02f, -9.88853946e-02f, -1.71283372e-02f, -1.05061149e-02f, -1.38925135e-01f, -1.55701160e-01f,
  7.57090598e-02f, -1.01861013e-02f, -5.41596077e-02f, 5.36920354e-02f, 7.87882581e-02f, 1.40200881e-02f, 5.63010760e-02f, 7.05326796e-02f, -3.20925117e-02f, 4.15029004e-02f,
  -1.07602581e-01f, 9.99563932e-02f, 8.07806477e-02f, 6.36617169e-02f, 1.65000409e-01f, 4.14022570e-03f, 3.85059640e-02f, -4.18656878e-03f, -5.00109978e-02f, 9.88368914e-02f,
  3.65221649e-01f, -2.68791616e-01f, 3.03596687e-02f, 9.12203416e-02f, 1.20078221e-01f, 8.48364830e-03f, 1.56284824e-01f, 1.62673026e-01f, 1.33445501e-01f, 1.81666553e-01f,
  7.23252946e-04f, 1.14416264e-01f, 1.02732956e-01f, 2.50276159e-02f, -3.96005996e-02f, -6.72568083e-02f, 8.15061945e-03f, 2.33190339e-02f, 5.40992357e-02f, 1.26147211e-01f,
  9.11163073e-03f, -9.20602456e-02f, 1.75349023e-02f, -4.63540182e-02f, -1.57350332e-01f, -1.88857485e-02f, 1.06296830e-01f, -1.89424306e-02f, -6.31029010e-02f, -7.28786588e-02f,
  7.59994909e-02f, 3.77744273e-03f, -4.04761970e-01f, 7.64136687e-02f, 2.07897902e-01f, -2.69139946e-01f, -2.92973489e-01f, -2.78682292e-01f, 1.72849104e-01f, 2.02179790e-01f,
  2.82335252e-01f, 9.58921984e-02f, -2.48486683e-01f, -2.58916914e-01f, -5.65523684e-01f, -4.24582094e-01f, -2.89214432e-01f, -4.31124508e-01f, -3.77206653e-01f, -2.08781153e-01f,
  5.58191761e-02f, 3.06682959e-02f, -1.67939752e-01f, -1.86728969e-01f, 3.50175381e-01f, 1.22149296e-01f, 2.62634899e-03f, -1.17213828e-02f, -1.50277726e-02f, 2.23771092e-02f,
  -1.33342715e-02f, 3.82421836e-02f, -9.36766416e-02f, 7.31234103e-02f, 1.16208844e-01f, 4.63226512e-02f, -1.19642675e-01f, -1.28914490e-01f, 9.01990011e-02f, -9.55861658e-02f,
  8.00989717e-02f, 1.34601432e-03f, 1.16019443e-01f, 8.08852836e-02f, -4.32313867e-02f, -7.68419430e-02f, -1.34332329e-01f, -3.21920544e-01f, -2.83505201e-01f, 9.09341201e-02f,
  5.32064885e-02f, -9.36145708e-02f, -3.73939753e-01f, -1.58211559e-01f, -1.24157190e-01f, -2.27897689e-01f, -6.49682283e-02f, 9.40052867e-02f, -1.98523268e-01f, -5.03167287e-02f,
  4.69954722e-02f, -1.69822108e-02f, 7.74887353e-02f, 1.04062498e-01f, 4.36780229e-02f, 4.89787348e-02f, -2.25027744e-02f, -7.26340264e-02f, -6.02782518e-02f, 5.95771968e-02f,
  -6.40255511e-02f, 7.54193813e-02f, -1.05657279e-01f, -2.61047576e-02f, -7.91584551e-02f, -1.02454282e-01f, 3.33908945e-02f, -2.61652339e-02f, -1.44054532e-01f, -5.35145355e-03f,
  -1.50658891e-01f, -1.41392574e-02f, 1.51910633e-01f, -2.55959202e-02f, -6.10234849e-02f, -8.46538097e-02f, 6.47011697e-02f, 7.31047755e-03f, -1.67611912e-02f, 8.81885588e-02f,
  1.45292610e-01f, -1.61690205e-01f, 4.56435718e-02f, -1.81698039e-01f, 7.51166791e-02f, 2.48897120e-01f, 2.38684922e-01f, -8.75381473e-03f, 2.92832162e-02f, -8.60543400e-02f,
  -4.80989814e-02f, -1.01497769e-01f, 2.09109168e-02f, 1.96983851e-02f, -4.32032570e-02f, -4.72832955e-02f, -1.14032291e-01f, -4.04672436e-02f, -1.71610296e-01f, 2.25008518e-01f,
  3.48741002e-03f, -1.56068504e-01f, -2.31961340e-01f, -1.24515533e-01f, -1.16646364e-01f, -2.68359691e-01f, -6.76719099e-02f, -6.85633868e-02f, -2.18453124e-01f, -1.26129657e-01f,
  2.71468133e-01f, 3.43426317e-01f, 2.41630852e-01f, -1.18015587e-01f, 6.52928054e-02f, 4.89052609e-02f, 1.11760899e-01f, -6.95992857e-02f, -1.79884881e-02f, 2.35325649e-01f,
  1.73033223e-01f, 3.06336153e-02f, -1.45363867e-01f, -1.11991510e-01f, 4.72403392e-02f, -8.97773504e-02f, -1.67715013e-01f, -2.82015577e-02f, -1.02842279e-01f, -8.73924419e-02f,
  -1.97622292e-02f, 4.78413291e-02f, 5.12238368e-02f, -5.12186885e-02f, 9.49065313e-02f, -1.14905573e-01f, 1.12921782e-02f, 1.56790927e-01f, 1.47392243e-01f, 2.07095966e-02f,
  3.01623523e-01f, 2.71444559e-01f, -1.23097748e-01f, -2.23116074e-02f, -2.59848647e-02f, -2.48280261e-02f, 6.09752201e-02f, -2.29201838e-02f, -3.36793885e-02f, -9.83204599e-03f,
  5.60122803e-02f, 2.90660206e-02f, -3.10036335e-02f, 3.12357978e-03f, -4.51063477e-02f, -5.66298775e-02f, 6.46374896e-02f, -1.32237431e-02f, -1.07224854e-02f, -4.61152233e-02f,
  7.21117258e-02f, 1.09058782e-01f, -4.74600382e-02f, -1.49216607e-01f, -5.07762246e-02f, -8.49356204e-02f, -8.92892759e-03f, 1.82833578e-02f, -1.06265433e-01f, -1.76328167e-01f,
  -1.93490952e-01f, 1.92562714e-02f, 5.30911125e-02f, -2.24245135e-02f, -1.02524824e-01f, -5.72847687e-02f, -1.01336427e-01f, -9.20564234e-02f, -1.42013356e-01f, 1.01771075e-02f,
  -6.88968301e-02f, 2.77637653e-02f, -5.83093129e-02f, -1.49008662e-01f, -1.17220379e-01f, 1.03750467e-01f, -9.47723091e-02f, -8.95575806e-02f, -5.23117110e-02f, 2.90043633e-02f,
  -7.85555020e-02f, -6.61691278e-02f, 4.28352356e-02f, -2.29514018e-02f, 3.34841944e-02f, -1.08056165e-01f, -1.25777513e-01f, -1.25281051e-01f, -8.42820257e-02f, -1.01593055e-01f,
  2.20627803e-02f, 1.76718533e-01f, -9.05882791e-02f, 8.92150924e-02f, 6.08335659e-02f, 1.23083808e-01f, 1.58406124e-01f, 1.35511324e-01f, -6.57525798e-03f, -8.12943056e-02f,
  5.68662547e-02f, 3.41050401e-02f, 1.85482819e-02f, -2.24705157e-03f, -1.32929988e-03f, -2.59052194e-03f, 1.59202516e-01f, 3.45710032e-02f, 3.90999354e-02f, 4.35200930e-02f,
  5.64103648e-02f, -9.97732580e-02f, -1.50600314e-01f, -1.48294970e-01f, -2.58035570e-01f, -1.82923570e-01f, -1.75170839e-01f, -1.23064294e-01f, -1.09479204e-01f, -3.03281039e-01f,
  -4.05371964e-01f, -3.89719009e-01f, -1.85196757e-01f, -2.77979612e-01f, -3.02412629e-01f, -8.04939792e-02f, -2.30678320e-01f, -9.24070403e-02f, -1.66072860e-01f, -3.53485256e-01f,
  6.31994829e-02f, 3.26478451e-01f, 1.83656022e-01f, 1.81846261e-01f, 1.73836365e-01f, -4.24447477e-01f, -3.79959732e-01f, -1.01017915e-01f, 4.33435202e-01f, 3.23127270e-01f,
  5.46342842e-02f, 3.03730369e-03f, 9.20057704e-04f, -6.58258870e-02f, -2.74168581e-01f, -3.29395644e-02f, -2.88437784e-01f, -1.59187779e-01f, -1.87561184e-01f, -4.04449224e-01f,
  3.01393688e-01f, -4.48516943e-03f, -3.10714617e-02f, 1.05196266e-02f, -1.67073250e-01f, -7.29172304e-02f, 2.39345289e-04f, -1.26038626e-01f, -5.02176136e-02f, -1.96964979e-01f,
  -9.31015015e-02f, 6.34084940e-02f, 1.86838135e-02f, 1.24805599e-01f, 1.99438054e-02f, 9.43248570e-02f, -1.12468161e-01f, -6.16061985e-02f, -1.12989098e-02f, 6.56486377e-02f,
  -6.22129589e-02f, -5.79674169e-02f, -3.24442349e-02f, 2.72808801e-02f, 7.75632188e-02f, -2.30873674e-02f, 1.84455551e-02f, 3.29430066e-02f, -8.92563909e-02f, -1.79156914e-01f,
  -5.81987649e-02f, 1.12909265e-02f, -6.91471919e-02f, 6.99233413e-02f, 7.73356482e-02f, -7.27727637e-02f, -1.17018947e-03f, 6.76056668e-02f, 8.58210698e-02f, 7.00977892e-02f,
  -2.66917832e-02f, -1.15083948e-01f, 2.64096968e-02f, -2.86799073e-02f, 6.90733790e-02f, -8.47102329e-02f, 2.75567826e-02f, -8.10097903e-02f, 5.52195050e-02f, -2.86578536e-02f,
  -3.92639190e-02f, -9.65648666e-02f, -1.40953019e-01f, -4.54739742e-02f, -1.29202351e-01f, -3.72621790e-02f, -3.62394825e-02f, 1.44795895e-01f, -4.81816120e-02f, -6.30051196e-02f,
  3.47047687e-01f, -4.69084736e-03f, 1.97592340e-02f, 7.14954436e-02f, -1.06428675e-01f, -7.22384602e-02f, -1.37639433e-01f, 3.51652084e-03f, -3.54147814e-02f, -5.66704869e-02f,
  1.53733976e-02f, 6.01026975e-02f, 7.29391947e-02f, 7.52577484e-02f, -2.92031094e-02f, -2.58090291e-02f, -2.02512033e-02f, 4.04956266e-02f, -1.89013593e-02f, 3.80497240e-02f,
  -2.44126067e-01f, 5.56822494e-02f, 6.97809383e-02f, -6.29370147e-03f, 4.02772538e-02f, 1.63259968e-01f, 2.12003544e-01f, 1.23636253e-01f, 1.39084622e-01f, -5.73450066e-02f,
  7.30111241e-01f, 3.98420662e-01f, -2.54803121e-01f, 1.91457361e-01f, -1.29941478e-01f, -7.37900585e-02f, 2.62344211e-01f, 2.02103451e-01f, -4.08417881e-02f, 1.41622692e-01f,
  4.36661169e-02f, -8.00403878e-02f, 2.88296454e-02f, -1.98010057e-01f, 4.70892303e-02f, 4.41719070e-02f, -1.00316241e-01f, -2.16665000e-01f, -2.72888482e-01f, -2.04991013e-01f,
  8.66387561e-02f, 2.35552609e-01f, 1.61919758e-01f, 6.27505500e-03f, 1.28526583e-01f, -2.39457130e-01f, 1.52873322e-01f, 4.03413847e-02f, -3.68495323e-02f, -1.20672241e-01f,
  -2.41002947e-01f, 2.25943342e-01f, -3.37196499e-01f, -7.42972596e-03f, 2.72618663e-02f, 2.51105875e-01f, 9.59236771e-02f, 3.98157910e-02f, 2.53532648e-01f, 5.50901145e-02f,
  1.83369033e-02f, 1.12831616e-03f, 1.86297253e-01f, 1.03722528e-01f, 7.82061368e-02f, -8.64209831e-02f, 1.84574783e-01f, 5.00079663e-03f, 8.44738930e-02f, -1.63460989e-02f,
  -4.42315191e-02f, 1.18516423e-01f, 3.16988863e-02f, -1.36009663e-01f, -3.30087058e-02f, -1.28424838e-01f, -2.18520612e-02f, -1.41718462e-01f, -7.88039416e-02f, 1.50581256e-01f,
  3.85613702e-02f, 7.56471008e-02f, 5.86240105e-02f, 4.82081290e-04f, 2.00011328e-01f, 4.28722091e-02f, 4.98030335e-02f, -3.61396512e-03f, -1.01208417e-02f, 1.02571376e-01f,
  3.39006237e-03f, -4.67077047e-02f, 1.09834215e-02f, 1.02722257e-01f, -4.92414869e-02f, 1.35213077e-01f, 4.30812724e-02f, 1.14616223e-01f, 8.88456106e-02f, 1.61625759e-03f,
  -2.83129681e-02f, -2.06816588e-02f, -6.55175820e-02f, 8.62353668e-02f, 1.55803934e-02f, -7.53010064e-02f, -1.62743554e-02f, -5.16947545e-02f, 1.46391153e-01f, 1.65449709e-01f,
  -6.18160069e-02f, -5.35470210e-02f, -4.09697331e-02f, -6.81490973e-02f, 7.52472878e-02f, -4.87559251e-02f, 3.50496136e-02f, -7.50613138e-02f, -1.97381005e-02f, 1.90161113e-02f,
  -7.46208504e-02f, -1.38266115e-02f, 2.29036286e-01f, 4.32882197e-02f, -5.65623865e-02f, -1.10381112e-01f, -2.23433021e-02f, -1.10408843e-01f, -4.42480259e-02f, -1.86471820e-01f,
  9.47505683e-02f, -3.84596288e-02f, -5.97676001e-02f, -1.03831753e-01f, -1.19679570e-01f, -1.43118232e-01f, -9.76346359e-02f, -6.92263842e-02f, -4.83887829e-02f, 9.96028855e-02f,
  1.96503386e-01f, -2.56038129e-01f, 1.60109445e-01f, 1.78558424e-01f, 2.00803906e-01f, 2.15222955e-01f, 2.92798519e-01f, 1.97235554e-01f, 1.92207098e-01f, 9.44737196e-02f,
  -2.98256278e-01f, -4.55107242e-01f, -3.74999911e-01f, -2.89008409e-01f, -2.02998951e-01f, 1.62247002e-01f, 2.39035085e-01f, -1.06322831e-02f, -3.46851386e-02f, 8.30191001e-02f,
  4.16259132e-02f, 2.39683315e-01f, 1.65734321e-01f, 1.02792177e-02f, 1.30594477e-01f, 7.95752257e-02f, 1.28526002e-01f, 7.01960996e-02f, -6.72312230e-02f, -9.06847864e-02f,
  -2.61071116e-01f, -1.05611630e-01f, 1.10804103e-01f, -1.12975828e-01f, -1.29738569e-01f, -1.21331722e-01f, -6.08818233e-02f, -1.16932273e-01f, -1.70715936e-02f, 7.94077516e-02f,
  -1.42057240e-01f, -1.31628990e-01f, -2.60558903e-01f, -4.45964597e-02f, 1.28024593e-01f, -4.36533801e-02f, 1.55792329e-02f, -9.27769169e-02f, -1.39926031e-01f, -1.14705294e-01f,
  -2.09471896e-01f, 8.54580943e-03f, 9.48785543e-02f, 4.54061590e-02f, -1.40995264e-01f, -1.51732028e-01f, 5.66886142e-02f, 3.50543596e-02f, 5.91871664e-02f, 1.49182379e-01f,
  2.58949436e-02f, -8.16510897e-03f, 2.06732508e-02f, 1.92343704e-02f, -2.81272102e-02f, 1.05760008e-01f, 8.19779113e-02f, -5.84712811e-02f, 1.06543623e-01f, 1.10000275e-01f,
  -8.75711143e-02f, -4.52411734e-02f, 4.07527946e-02f, -4.39800955e-02f, -6.18870519e-02f, 2.65578795e-02f, -1.84884761e-02f, -2.62129097e-03f, -1.62061542e-01f, -1.99780036e-02f,
  -8.13470483e-02f, 4.87442240e-02f, 7.41657540e-02f, -1.26165479e-01f, -3.84755321e-02f, 1.19182654e-02f, -3.35441306e-02f, 2.54660402e-03f, -8.54557827e-02f, 1.60591111e-01f,
  2.03518331e-01f, -5.25136255e-02f, 6.94890022e-02f, -1.13820903e-01f, -1.14535131e-01f, -3.06873098e-02f, -3.26970406e-02f, -1.10216416e-01f, 3.29881534e-02f, -1.07707068e-01f,
  -2.55981702e-02f, -2.25762725e-01f, -1.39940888e-01f, -6.46241307e-02f, 2.60408465e-02f, 9.26809385e-02f, -8.52535143e-02f, -1.03941318e-04f, 4.20045853e-03f, -3.19306701e-02f,
  -4.27829660e-02f, 1.67688504e-01f, 2.24463910e-01f, 8.62167850e-02f, -1.21414647e-01f, 1.22073188e-01f, 5.22195473e-02f, 1.28220022e-01f, -1.31477427e-03f, 3.68882298e-01f,
  -5.97053111e-01f, 7.97696114e-02f, 1.69475824e-01f, -3.81390452e-01f, 1.86953664e-01f, 3.90649140e-01f, 4.49116230e-01f, 6.68643191e-02f, -2.44035408e-01f, -1.38408199e-01f,
  8.43587369e-02f, -2.19033346e-01f, -1.72048897e-01f, 1.26894668e-01f, 1.92341223e-01f, 2.76208907e-01f, 2.95992553e-01f, 1.44395903e-01f, 1.92484707e-01f, 7.79993162e-02f,
  2.63657067e-02f, -7.56303221e-02f, -1.93796277e-01f, 5.66257723e-03f, -3.02489191e-01f, -1.97306782e-01f, -2.01344229e-02f, -9.76647735e-02f, 1.17232524e-01f, -2.39696413e-01f,
  -6.28707707e-01f, -3.17122012e-01f, 2.37741366e-01f, -7.75709078e-02f, 1.75590347e-02f, -1.42119393e-01f, 2.03428902e-02f, -1.93068594e-01f, -1.69658754e-02f, -1.62120700e-01f,
  -1.37613624e-01f, -4.02958728e-02f, -1.71641871e-01f, -1.55879334e-01f, -3.34753245e-01f, -1.23150915e-01f, -5.18921725e-02f, -9.41438377e-02f, -1.21384241e-01f, -3.84332903e-04f,
  3.18838507e-01f, 1.62044149e-02f, -1.42171815e-01f, 7.75773972e-02f, -1.36920333e-01f, -6.97549507e-02f, -5.29026501e-02f, -1.66058138e-01f, -5.71830757e-02f, -3.78253013e-01f,
  -2.87335273e-03f, 8.09035227e-02f, 3.28665636e-02f, -3.26200724e-02f, 6.72257468e-02f, -4.05022539e-02f, 4.50891964e-02f, 6.92868158e-02f, -6.88252226e-02f, -8.25836062e-02f,
  -3.33958641e-02f, 2.56910771e-02f, -3.48941647e-02f, -1.02195829e-01f, -4.68435884e-02f, 5.04131354e-02f, 2.81016603e-02f, 1.99250621e-03f, 6.50202855e-02f, 6.60007447e-03f,
  -3.64797786e-02f, -1.60013810e-02f, -7.09966756e-03f, -3.80161498e-03f, -2.70467456e-02f, 1.24986425e-01f, -1.06681228e-01f, -4.50690910e-02f, -1.19978450e-01f, -4.09985073e-02f,
  -5.02905250e-01f, 3.57299596e-01f, -4.23154384e-01f, -6.96395412e-02f, -9.83546823e-02f, 5.19090258e-02f, -1.02488503e-01f, -3.73259410e-02f, -7.72393644e-02f, -1.70284867e-01f,
  -1.39533132e-02f, -1.38377234e-01f, -2.21522093e-01f, 7.52771199e-02f, -1.78036168e-01f, -1.63648203e-01f, -3.88961583e-02f, -2.54689395e-01f, 9.67493206e-02f, -3.30688097e-02f,
  -1.09950919e-02f, -1.79568619e-01f, -4.10871029e-01f, -1.95679814e-01f, -3.37306201e-01f, -3.20859969e-01f, -1.47174209e-01f, -2.39159063e-01f, -6.02943636e-02f, -3.78140420e-01f,
  2.22924873e-02f, 2.65701413e-01f, -1.14643037e-01f, -9.05125067e-02f, -2.07523480e-01f, -2.61278212e-01f, 3.11615225e-02f, 1.17947329e-02f, 1.39780745e-01f, 3.18107873e-01f,
  3.90704907e-03f, -2.34741613e-01f, -1.14882633e-01f, -1.14100024e-01f, 1.12218678e-03f, 2.08210647e-01f, 9.32882577e-02f, -2.51181841e-01f, -4.09172773e-01f, -3.72920603e-01f,
  -1.89168930e-01f, -3.18259209e-01f, -2.31377676e-01f, -4.64105420e-02f, -1.08474925e-01f, -2.99618304e-01f, 7.09919333e-02f, -1.71322018e-01f, -1.09278522e-01f, 7.85229076e-03f,
  -6.80648908e-02f, -8.58422220e-02f, -4.41761054e-02f, -2.70686615e-02f, 8.33879337e-02f, 1.44545168e-01f, 2.07694783e-03f, 2.62332242e-03f, 1.78609695e-03f, 1.30082697e-01f,
  8.45769867e-02f, 4.02310379e-02f, 5.84170176e-03f, -1.20614972e-02f, -1.45503012e-02f, -6.58937022e-02f, 9.03100073e-02f, -6.27824217e-02f, 8.99593681e-02f, 1.03396207e-01f,
  3.77481058e-02f, -4.64938805e-02f, 3.73615846e-02f, -5.47274835e-02f, -7.01902956e-02f, -1.45475671e-01f, -5.02706766e-02f, -3.52367833e-02f, 4.45160046e-02f, 6.36930689e-02f,
  1.17660828e-01f, 1.88924611e-01f, -6.20440878e-02f, -9.46396664e-02f, 1.55409738e-01f, 3.35922800e-02f, -2.22830568e-02f, 1.33404555e-02f, 3.12109175e-03f, 1.48230106e-01f,
  8.09252784e-02f, 3.86042558e-02f, 2.29313970e-02f, 1.34095028e-01f, -2.89955996e-02f, -9.18368530e-03f, 7.86292553e-02f, 1.23937605e-02f, -4.94101224e-03f, 1.49971247e-01f,
  -4.37820964e-02f, 1.08882666e-01f, -9.57857445e-02f, -1.16034150e-01f, -9.25650299e-02f, -6.49219006e-02f, -1.21957459e-01f, -1.05274945e-01f, -6.44986778e-02f, 5.23330644e-02f,
  -2.24511668e-01f, -2.68426508e-01f, 1.89839542e-01f, -1.25028836e-02f, 5.52244559e-02f, 1.71121344e-01f, -1.86672196e-01f, 6.68522492e-02f, -4.98372503e-02f, -4.78253141e-02f,
  -1.34221911e-01f, -8.32636505e-02f, -6.56163460e-03f, 2.88151056e-02f, 8.71537905e-03f, -1.19601823e-01f, 1.49483174e-01f, 9.46635380e-02f, -4.11175862e-02f, 1.05311118e-01f,
  9.55243707e-02f, 4.99935634e-02f, 1.20494291e-01f, 1.27532750e-01f, 8.12078714e-02f, -8.29598829e-02f, -6.55937120e-02f, 4.44937013e-02f, 1.28580891e-02f, 1.17992498e-01f,
  5.35183489e-01f, -1.10862814e-01f, -1.23999581e-01f, 2.24159092e-01f, -1.90368459e-01f, -4.90370765e-02f, -1.20339595e-01f, 3.98943350e-02f, 1.35964677e-01f, -2.06213668e-02f,
  -1.86298698e-01f, 8.31648111e-02f, 9.82318893e-02f, 2.88147461e-02f, 7.65443668e-02f, -1.80434380e-02f, 6.23490363e-02f, -7.19699031e-03f, 6.20243475e-02f, 2.66195443e-02f,
  1.15960157e-02f, 1.01452626e-01f, 1.73439220e-01f, 7.44254217e-02f, -1.18487090e-01f, 1.37946643e-02f, -2.08473746e-02f, -1.16787329e-01f, -1.66716635e-01f, 3.78575623e-02f,
  9.93963555e-02f, -2.19684675e-01f, -7.86996484e-02f, -2.30361484e-02f, -1.00312270e-01f, 5.37167415e-02f, -2.60669272e-02f, 2.81024259e-02f, -5.79351280e-03f, 6.64302111e-02f,
  -9.09876376e-02f, 2.27995794e-02f, -1.14043258e-01f, -2.04623304e-02f, 2.42890641e-02f, -5.88193312e-02f, -4.87067886e-02f, -1.55144900e-01f, 5.85821681e-02f, -6.44712076e-02f,
  -3.28580476e-02f, -1.21986359e-01f, -1.56722516e-01f, -8.39238316e-02f, -5.52657098e-02f, 6.02583662e-02f, -4.24149260e-02f, -1.40226617e-01f, 1.06031196e-02f, -8.16746652e-02f,
  6.60506310e-03f, 6.96876692e-03f, 4.97260690e-02f, 3.00356131e-02f, 5.44366241e-02f, -8.36188421e-02f, 5.36572598e-02f, -3.10153561e-03f, 4.48011383e-02f, 8.40702131e-02f,
  -7.49001354e-02f, 6.55047148e-02f, 8.39421079e-02f, -1.79568008e-02f, 1.17619587e-02f, 6.53168634e-02f, 4.61791418e-02f, 2.77764797e-02f, -2.99203545e-02f, 1.66488633e-01f,
  7.42222890e-02f, 1.56425297e-01f, 1.91684254e-02f, 1.42997041e-01f, -5.81291616e-02f, 1.18533187e-02f, 1.77781805e-01f, 3.69893089e-02f, -2.29141079e-02f, 2.87238099e-02f,
  9.83529985e-02f, -1.47638798e-01f, 1.15191147e-01f, 3.63287404e-02f, 2.15769429e-02f, -1.45473465e-01f, 5.39042894e-03f, -1.99001357e-02f, -6.62688687e-02f, -6.27362877e-02f,
  -1.08327851e-01f, -7.34243542e-02f, -7.94721842e-02f, -1.49872794e-03f, 1.03689119e-01f, -5.04442826e-02f, -6.21130392e-02f, -5.07816747e-02f, 2.60679480e-02f, 5.04190056e-03f,
  -7.86594115e-03f, -1.08617702e-02f, 9.25069153e-02f, 5.33726811e-02f, -2.73707323e-02f, 8.65653530e-02f, -8.07777941e-02f, -3.54522727e-02f, -2.16884222e-02f, 2.11483777e-01f,
  -5.88432789e-01f, -1.34508774e-01f, 3.02437246e-01f, -3.94430727e-01f, 1.56177953e-01f, 1.32142261e-01f, -2.32012764e-01f, -8.18379894e-02f, -1.71999857e-01f, -1.63238972e-01f,
  1.11637011e-01f, -2.27665991e-01f, -2.18544707e-01f, -1.33961201e-01f, -2.10054800e-01f, -1.29353898e-02f, 8.70264880e-03f, -6.76247180e-02f, -1.11759596e-01f, -1.29813448e-01f,
  -1.69421047e-01f, -2.28378490e-01f, -1.11535691e-01f, -1.28150299e-01f, -1.37687996e-01f, -8.21798444e-02f, 1.74522400e-01f, -8.19032416e-02f, 1.01659678e-01f, -5.90420747e-03f,
  -2.04370469e-01f, -2.97091389e-03f, 1.63995340e-01f, -6.91631809e-02f, 7.54790455e-02f, 9.59887728e-02f, -2.28626542e-02f, -3.68652791e-02f, 1.51425796e-02f, -5.61944656e-02f,
  5.26186777e-03f, 4.82386984e-02f, -1.07340842e-01f, -1.99108627e-02f, -9.47094262e-02f, -1.61723554e-01f, 7.90907443e-02f, 1.67551152e-02f, -5.09221368e-02f, 1.76276788e-01f,
  7.51456469e-02f, -2.41956890e-01f, -1.98734790e-01f, 7.75962099e-02f, 7.56826624e-02f, 1.64868031e-02f, -9.39692472e-05f, 2.19878498e-02f, -8.13746750e-02f, -3.51761520e-01f,
  3.78566608e-03f, 7.52372295e-02f, 6.42602816e-02f, 4.29446995e-02f, -9.41465199e-02f, 1.99296437e-02f, -8.71206168e-03f, -5.90768233e-02f, -9.60899051e-05f, -7.50040263e-02f,
  8.46393853e-02f, 3.45074013e-02f, 3.69582362e-02f, -2.60000341e-02f, 4.68717925e-02f, -1.56322286e-01f, -8.84847045e-02f, -5.27748168e-02f, -5.01438342e-02f, 1.24883957e-01f,
  -9.67591181e-02f, -1.05564006e-01f, 1.98295955e-02f, -8.90684407e-03f, 5.96492440e-02f, 7.06620216e-02f, 9.32804495e-02f, -6.40606657e-02f, -5.09334393e-02f, 3.90954241e-02f,
  -2.31315836e-01f, 2.98987478e-01f, -3.90050709e-01f, -7.42844939e-02f, -4.43348289e-03f, 1.59396529e-01f, 8.23885277e-02f, 9.52059850e-02f, 3.60443480e-02f, -4.57557337e-03f,
  -2.58737095e-02f, -1.29538596e-01f, -1.55917928e-01f, 3.12507153e-02f, -2.20584627e-02f, -2.44640205e-02f, -1.47799060e-01f, -7.03553408e-02f, 1.05428249e-01f, 3.07452306e-03f,
  -1.04245301e-02f, -3.36266875e-01f, -4.80717570e-01f, -1.32067963e-01f, -1.18988879e-01f, -3.60592723e-01f, -2.11979330e-01f, -1.41967118e-01f, -1.78610593e-01f, -4.11998987e-01f,
  -3.44667472e-02f, 1.80299163e-01f, 1.45804673e-01f, 1.88930668e-02f, 2.08413810e-01f, 2.79410630e-01f, 4.09727514e-01f, 2.30069399e-01f, -2.71892622e-02f, 9.45286229e-02f,
  -4.12273593e-02f, 5.56718335e-02f, 1.55293360e-01f, 8.15434530e-02f, 2.15941951e-01f, 7.03138337e-02f, 3.92181650e-02f, 1.23249516e-01f, 1.01036718e-02f, 1.04515702e-01f,
  -2.10045800e-02f, 8.15389007e-02f, -7.04923123e-02f, 1.95553731e-02f, 6.54116869e-02f, -5.32520749e-02f, 4.22379784e-02f, 1.30744010e-01f, 2.20473595e-02f, -8.34851265e-02f,
  -1.78040713e-01f, 9.29026529e-02f, -1.05304152e-01f, -1.55717611e-01f, -3.85530330e-02f, -1.37254879e-01f, -4.09488790e-02f, -6.47613630e-02f, 1.19024785e-02f, -1.86672565e-02f,
  -1.10669151e-01f, -5.33300564e-02f, -2.24165451e-02f, 2.48442777e-02f, 2.42638756e-02f, -2.39940779e-03f, 2.83808224e-02f, -1.31883370e-02f, 6.86159208e-02f, 6.34298623e-02f,
  5.51900081e-02f, -1.64478898e-01f, -8.92838016e-02f, 1.24626182e-01f, 1.18507817e-02f, -1.96816796e-03f, -6.41273335e-02f, -4.44713905e-02f, 1.43198548e-02f, -1.23799324e-01f,
  -1.15088098e-01f, -1.88882813e-01f, 6.34025335e-02f, 1.27480581e-01f, 1.54242292e-01f, 4.01398167e-03f, 3.47852483e-02f, -9.58670005e-02f, -5.20346388e-02f, -2.49000471e-02f,
  -1.09242305e-01f, -1.03517666e-01f, -6.36323839e-02f, -1.15279995e-01f, -1.21807575e-01f, -1.05859442e-02f, 3.52987368e-03f, 6.27615601e-02f, -5.42409830e-02f, 6.31917566e-02f,
  -3.60856019e-02f, 5.62591366e-02f, 4.71094884e-02f, 7.00349957e-02f, -4.61944044e-02f, 2.22120862e-02f, -1.53802738e-01f, -4.84495573e-02f, -1.04009109e-02f, -1.23667940e-01f,
  4.84212376e-02f, 2.58857071e-01f, -8.15496296e-02f, 5.29912673e-02f, -1.92198120e-02f, 4.19990420e-02f, -2.76427511e-02f, -1.44332975e-01f, -1.38270175e-02f, -2.15728227e-02f,
  -1.41442977e-02f, 2.01547984e-02f, -1.50985960e-02f, -3.23458351e-02f, -7.48123303e-02f, -4.24404815e-02f, -3.83844711e-02f, 1.26816127e-02f, 7.81850889e-02f, -1.00920223e-01f,
  5.41260205e-02f, -2.03895345e-01f, -2.41865933e-01f, -4.30069454e-02f, -5.45790754e-02f, -1.57215044e-01f, -6.18166849e-02f, -1.41597033e-01f, -8.43288600e-02f, -1.36710197e-01f,
  2.48752579e-01f, -1.07034683e-01f, -1.57290976e-02f, 2.65914679e-01f, 1.23515896e-01f, -7.92654306e-02f, -1.37209460e-01f, -4.35516275e-02f, 1.41458049e-01f, 1.52822390e-01f,
  -1.42669812e-01f, 2.34064549e-01f, 8.08352754e-02f, 9.32799056e-02f, -2.71572974e-02f, 1.40968099e-01f, 2.36392677e-01f, 3.41721982e-01f, 2.07516775e-01f, 2.22535312e-01f,
  2.84559816e-01f, 2.34069690e-01f, 1.27222165e-01f, 1.35761708e-01f, 3.22348565e-01f, 1.56293362e-01f, 1.70597643e-01f, 7.25694820e-02f, 1.57814607e-01f, 4.90442187e-01f,
  7.15464028e-03f, -2.18442753e-01f, 2.10315567e-02f, -1.46878054e-02f, 3.77623886e-02f, 1.16019789e-02f, 9.84559581e-02f, -4.45817634e-02f, -3.05423010e-02f, 8.50611925e-02f,
  -7.71247819e-02f, -2.88925394e-02f, 2.61795381e-03f, 4.65536071e-03f, 7.61478534e-03f, -3.80385295e-02f, -2.83628386e-02f, -9.60139483e-02f, -8.10517818e-02f, -1.18501127e-01f,
  2.12981522e-01f, -8.65762010e-02f, -2.44304344e-01f, -2.77315110e-01f, -1.81985304e-01f, 9.35751796e-02f, -1.93401992e-01f, 6.01835325e-02f, -1.73106819e-01f, 5.85051067e-02f,
  3.32929380e-02f, -7.54773617e-02f, -6.96353614e-02f, 4.43047136e-02f, 1.18829802e-01f, -3.39419283e-02f, -5.75552229e-03f, 5.96019514e-02f, 8.00132751e-02f, 8.72725155e-03f,
  1.05945012e-02f, 1.21897310e-01f, 6.20312616e-02f, -5.34166396e-03f, 9.93464738e-02f, 1.19977191e-01f, 5.84645681e-02f, -3.13270539e-02f, 5.53330258e-02f, 6.36641160e-02f,
  1.55959025e-01f, 8.29137042e-02f, 1.11946158e-01f, 6.86244518e-02f, 1.29958421e-01f, 2.81010438e-02f, 1.75852284e-01f, 1.53104544e-01f, 8.91550928e-02f, -2.49320306e-02f,
  -7.55486786e-02f, -3.28546405e-01f, 2.24347740e-01f, -1.15742683e-01f, 4.03764163e-04f, -1.13674834e-01f, -4.47258428e-02f, -1.23287514e-01f, 4.58263867e-02f, 1.95389036e-02f,
  -5.37368190e-03f, -1.24839291e-01f, -1.36873797e-01f, -8.73907581e-02f, 1.77184746e-01f, -5.23440018e-02f, 2.94514094e-02f, 1.59268454e-01f, -6.28804043e-02f, -1.61687195e-01f,
  -4.00977097e-02f, -7.38573149e-02f, -1.19459324e-01f, -1.35063946e-01f, -1.28418714e-01f, -1.18098035e-02f, -2.39247739e-01f, -1.28071234e-01f, -2.21671820e-01f, -1.65243804e-01f,
  6.30308092e-01f, 6.76605344e-01f, -1.63540170e-01f, 1.09061375e-01f, -4.36085105e-01f, -2.82091022e-01f, 2.55019605e-01f, 4.08196360e-01f, 1.48126662e-01f, 2.95723259e-01f,
  -1.72215834e-01f, -4.59609509e-01f, -6.54001385e-02f, -2.42430627e-01f, 1.57324001e-02f, 2.79244214e-01f, 1.05873458e-01f, -1.56688020e-01f, -4.98850644e-01f, -3.85361910e-01f,
  -2.05432937e-01f, 1.99386671e-01f, 2.26315632e-01f, 1.04744330e-01f, 1.44864351e-01f, -1.63160995e-01f, 1.91517800e-01f, 1.04404494e-01f, 1.77179985e-02f, 2.09127609e-02f,
  -2.67110556e-01f, 6.61650300e-01f, -5.21058679e-01f, -1.53723031e-01f, -8.86149406e-02f, -2.35917997e-02f, -1.39990479e-01f, -4.50424477e-02f, -2.33147107e-02f, 9.83725116e-02f,
  -2.22073600e-01f, -1.43245444e-01f, -8.77415016e-02f, -6.73808604e-02f, 6.68191910e-02f, -1.71729043e-01f, 2.56039351e-01f, 4.74932417e-02f, 1.06328741e-01f, 2.12313905e-02f,
  -3.63517880e-01f, -1.71313688e-01f, 1.33986026e-01f, 1.00426838e-01f, 8.46092310e-03f, -2.10954413e-01f, 1.75326448e-02f, -3.21010686e-02f, 1.42814741e-01f, 4.46191043e-01f,
  -1.06294319e-01f, 1.39223058e-02f, 7.53608579e-03f, 1.95840582e-01f, -2.73393933e-02f, -1.40406996e-01f, 6.70627952e-02f, -1.42851006e-02f, -2.61600427e-02f, -1.37973549e-02f,
  -7.02272356e-02f, 1.51976915e-02f, -8.86943787e-02f, 1.10232107e-01f, 1.75679266e-03f, 8.95470455e-02f, -1.67337522e-01f, 1.80113792e-01f, 1.14917688e-01f, -7.10564293e-03f,
  -5.79362176e-02f, -9.91048887e-02f, -1.53126597e-01f, 9.75735858e-02f, 3.31056304e-02f, -7.38513991e-02f, -3.47484238e-02f, -3.65893841e-02f, 1.95485458e-01f, 8.59069377e-02f,
  -7.52153769e-02f, -2.00790197e-01f, -1.14148647e-01f, 3.20686363e-02f, 2.03446120e-01f, -7.26518854e-02f, -4.44526924e-03f, 5.50770164e-02f, 1.44940075e-02f, -4.13725972e-02f,
  -4.30573076e-02f, -8.39652121e-02f, 2.01339021e-01f, -7.66037554e-02f, -2.61284590e-01f, -1.33300111e-01f, -8.58053416e-02f, -1.92514643e-01f, -3.20771597e-02f, -2.69810613e-02f,
  9.05260164e-03f, -2.81932224e-02f, -3.49445641e-02f, 4.11258861e-02f, -5.23099042e-02f, -2.25040108e-01f, 1.79936383e-02f, -1.09484889e-01f, -9.51270759e-02f, 4.50498879e-01f,
  4.82121378e-01f, 4.91817743e-02f, -1.99894249e-01f, 1.31806612e-01f, 5.82161285e-02f, 7.09008649e-02f, -8.75041261e-02f, 9.00321230e-02f, 3.21206897e-02f, -1.63430385e-02f,
  9.66393873e-02f, 7.05638081e-02f, 4.84166145e-02f, -1.91125050e-01f, -1.78729892e-01f, -2.15661034e-01f, -2.80310124e-01f, -1.84799686e-01f, -4.64583375e-02f, -9.23612416e-02f,
  -1.63322076e-01f, -7.58998841e-02f, -1.18707858e-01f, -1.14353068e-01f, -7.56350756e-02f, 6.73510833e-03f, -5.81477396e-02f, 2.63630580e-02f, -1.10496536e-01f, -2.11497828e-01f,
  -1.72804579e-01f, 4.97327223e-02f, -1.17120445e-01f, -4.03107032e-02f, -1.36686023e-02f, -4.73403335e-02f, -1.04486793e-01f, 2.64451001e-02f, 3.58749852e-02f, 8.41955990e-02f,
  4.01509963e-02f, 1.36795817e-02f, -1.19025171e-01f, 7.36317337e-02f, 6.45295307e-02f, 4.93127666e-02f, 1.55790925e-01f, -3.20983678e-02f, -7.38410875e-02f, -7.59653524e-02f,
  -7.49275908e-02f, 2.17739400e-03f, -1.66330319e-02f, 1.43927544e-01f, -3.55911441e-02f, -5.86645454e-02f, 1.20284587e-01f, 5.32412864e-02f, -1.71680674e-02f, 2.48908520e-01f,
  -3.68840039e-01f, -6.86346041e-03f, 6.74020052e-02f, 7.44266734e-02f, 1.41573340e-01f, 1.77317336e-01f, 1.25941336e-01f, 6.13029022e-03f, 4.39170823e-02f, 5.34333140e-02f,
  -4.03325595e-02f, -5.99564053e-02f, 3.19224522e-02f, -8.66271183e-02f, -1.73936844e-01f, -7.44698271e-02f, -6.65798038e-02f, -1.53738707e-01f, -8.40702876e-02f, -1.19539410e-01f,
  -8.12340900e-03f, -4.47999015e-02f, -8.97067860e-02f, -1.58068195e-01f, -1.41414285e-01f, 4.79780398e-02f, -1.77814335e-01f, -3.16029787e-02f, -9.26023349e-02f, -2.09926859e-01f,
  5.74982986e-02f, -1.53889984e-01f, -9.46076587e-02f, -2.09164709e-01f, -1.62108000e-02f, -6.49482906e-02f, 2.59470902e-02f, 3.89903635e-02f, 2.89770383e-02f, -7.71432146e-02f,
  3.73064168e-02f, -4.91298698e-02f, -2.42288150e-02f, -3.08431424e-02f, 1.01578012e-01f, 1.35248378e-01f, 1.31442592e-01f, -1.11575900e-02f, -6.98415339e-02f, 1.39351143e-02f,
  -1.17906416e-02f, 8.46723542e-02f, 3.99313495e-02f, 1.71534687e-01f, 1.16233811e-01f, 1.20137176e-02f, 1.12501413e-01f, 1.91522744e-02f, 1.87709741e-02f, 1.87161058e-01f,
  2.34478906e-01f, 3.73050682e-02f, 3.01075429e-01f, 2.12091193e-01f, 2.69851804e-01f, 2.02650517e-01f, 2.83818871e-01f, 1.93718418e-01f, -3.87401460e-03f, -8.86491463e-02f,
  -2.77025431e-01f, -3.92299116e-01f, -2.33448446e-01f, -2.88253516e-01f, -1.23657651e-01f, 2.03039050e-01f, 1.86925605e-01f, 1.40605316e-01f, 3.14055681e-02f, 6.29275143e-02f,
  -7.24084734e-04f, 1.76266566e-01f, -1.40852835e-02f, 2.08072886e-02f, 5.24034612e-02f, -1.85921922e-01f, 2.70763729e-02f, 1.59344271e-01f, -1.78784132e-02f, -1.50088137e-02f,
  -9.58229974e-02f, 6.31523207e-02f, -6.41057268e-02f, -2.86969334e-01f, -6.30128235e-02f, -1.96700111e-01f, -9.32588428e-02f, -2.26758659e-01f, -5.51748797e-02f, 4.52378765e-02f,
  3.19531374e-02f, -1.35731146e-01f, -4.46253382e-02f, 3.49815674e-02f, 5.73993437e-02f, -3.02981567e-02f, -7.37456381e-02f, -8.07962716e-02f, -1.66000471e-01f, -1.63513154e-01f,
  -4.58883569e-02f, 1.11760564e-01f, 2.69446492e-01f, -6.56064823e-02f, -3.92559096e-02f, -7.46575594e-02f, -2.20887233e-02f, 2.32773107e-02f, -1.89697389e-02f, 3.56705277e-03f,
  -4.35151570e-02f, 1.04770817e-01f, 1.73751876e-01f, -3.28926444e-02f, 5.94647788e-03f, -1.30890608e-02f, 1.36275068e-01f, 9.42584965e-03f, 1.69261038e-01f, 6.88645020e-02f,
  9.55782682e-02f, -3.19619924e-02f, -4.16854322e-02f, 5.39603531e-02f, -1.17382400e-01f, 1.56920403e-01f, 1.13829032e-01f, -1.35520309e-01f, -1.25102937e-01f, -2.31382865e-02f,
  4.19045091e-02f, 3.82159278e-02f, -1.35339648e-01f, -1.44236445e-01f, 5.82289621e-02f, -5.49057834e-02f, -1.06224544e-01f, -9.19605345e-02f, -4.83901277e-02f, 7.63227865e-02f,
  -2.45670050e-01f, -1.64089307e-01f, -3.62983495e-02f, -5.42036071e-02f, 2.53074449e-02f, -9.53966081e-02f, -2.31526107e-01f, -1.13296159e-01f, 2.19554510e-02f, 1.20677799e-01f,
  6.51842579e-02f, -7.26962909e-02f, -7.57637247e-02f, -9.64074805e-02f, 7.26548359e-02f, 1.22788660e-01f, -6.14280403e-02f, 4.29681093e-02f, -1.54405162e-01f, -9.39754620e-02f,
  5.40838875e-02f, 1.70884371e-01f, 1.82197198e-01f, 9.10018459e-02f, 1.90351892e-03f, 4.44001816e-02f, 6.62041157e-02f, -1.22530879e-02f, 8.71790498e-02f, 1.22193985e-01f,
  -1.29212111e-01f, 3.69417965e-01f, -8.53635445e-02f, 1.45146742e-01f, -9.53117833e-02f, -3.01303804e-01f, -1.18288733e-01f, 3.56453587e-03f, 1.29756704e-01f, 1.42952949e-01f,
  3.45554426e-02f, -5.00330217e-02f, 1.46019652e-01f, -6.07486442e-02f, -1.98192433e-01f, -1.03726024e-02f, -6.46024197e-02f, -2.39503965e-01f, -4.98202533e-01f, -4.38291103e-01f,
  -2.55628318e-01f, -1.08603463e-01f, -5.97060733e-02f, -4.61034402e-02f, 1.78890347e-01f, 2.83530056e-02f, 2.72778213e-01f, 1.91119649e-02f, -1.79106385e-01f, 1.08543977e-01f,
  1.77076802e-01f, -8.47688019e-02f, -1.57175645e-01f, -1.01374850e-01f, 4.58432846e-02f, 3.21864747e-02f, -1.36375621e-01f, 8.05472303e-03f, -8.36929753e-02f, -6.91635832e-02f,
  -1.12019673e-01f, -7.51239806e-02f, -8.78329203e-02f, -4.49956954e-02f, -4.43512984e-02f, -1.90127745e-01f, -5.50662205e-02f, -1.06098920e-01f, -9.55640450e-02f, 2.93232165e-02f,
  -1.08294390e-01f, -1.75871685e-01f, -1.20313745e-03f, 8.26942027e-02f, -1.18409082e-01f, -2.47503266e-01f, 1.38235316e-01f, -9.70584825e-02f, -9.94145796e-02f, 3.42078120e-01f,
  8.00581202e-02f, 7.51071796e-02f, -1.85164213e-02f, -4.43539815e-03f, 9.05470699e-02f, 6.51538670e-02f, 3.53170224e-02f, 5.79147823e-02f, -4.68133800e-02f, 7.96758309e-02f,
  -3.32026742e-02f, 1.26646012e-01f, 1.49426721e-02f, 9.48563740e-02f, 5.15318941e-03f, -6.73071742e-02f, 8.03700928e-03f, 9.53297839e-02f, -5.40747344e-02f, 3.62426676e-02f,
  -5.60987219e-02f, -5.90893179e-02f, 1.90318022e-02f, 1.05155438e-01f, -1.75822422e-01f, 5.73207401e-02f, -9.47535932e-02f, -9.18967947e-02f, -6.08902192e-03f, -1.88276559e-01f,
  3.95553470e-01f, -2.75197446e-01f, 2.39177823e-01f, -4.19994704e-02f, 1.29199289e-02f, -6.07474670e-02f, 6.86982498e-02f, -3.59829627e-02f, 2.23661214e-02f, -1.15603484e-01f,
  -1.76241562e-01f, -2.06082724e-02f, 1.09471582e-01f, 1.29607096e-02f, -6.19528629e-02f, -6.61004409e-02f, 1.65208112e-02f, -1.13415699e-02f, -1.66915670e-01f, 6.46944866e-02f,
  1.22259974e-01f, -8.17457512e-02f, 1.35069281e-01f, 1.42188475e-01f, 1.58431549e-02f, -7.18334243e-02f, 1.32217214e-01f, 1.31602913e-01f, -6.29506558e-02f, 4.47024047e-01f,
  2.83329040e-01f, -1.83218494e-02f, 1.81091160e-01f, 2.37846568e-01f, -3.11515480e-01f, -2.88613856e-01f, -4.16039884e-01f, -2.34386891e-01f, -2.69852486e-02f, -7.60231316e-02f,
  -1.84906736e-01f, -1.87915757e-01f, -8.46872777e-02f, -1.38093099e-01f, -2.96783894e-01f, -2.00767890e-01f, 4.92431782e-02f, 1.30140394e-01f, -1.62280381e-01f, -2.34524369e-01f,
  -1.93831757e-01f, 1.37447178e-01f, 1.43398777e-01f, 2.07288101e-01f, 3.65807980e-01f, 8.17497820e-02f, 2.60649443e-01f, 2.28076309e-01f, -6.00776810e-04f, 3.21253031e-01f,
  1.72590300e-01f, 2.36601740e-01f, -4.03821729e-02f, 4.30266634e-02f, 1.28291950e-01f, -2.84101814e-03f, -7.66093135e-02f, 2.58859783e-01f, -1.32692397e-01f, 7.93312192e-02f,
  -1.05253182e-01f, 2.50975899e-02f, -4.91564209e-03f, 1.17738266e-02f, -3.75214890e-02f, -9.07055512e-02f, 1.49030432e-01f, 1.56439483e-01f, 1.83066383e-01f, -1.84842083e-03f,
  -1.04080550e-01f, -9.21255052e-02f, -9.34245139e-02f, -1.46800220e-01f, -4.75682579e-02f, 1.95633732e-02f, -6.87237158e-02f, 5.86769730e-02f, -8.06799084e-02f, 1.80261567e-01f,
  6.28593117e-02f, -1.09256534e-02f, 5.58153875e-02f, 2.55502071e-02f, -1.26007915e-01f, -3.94262336e-02f, 1.69268139e-02f, 2.78142840e-02f, -3.60834189e-02f, -1.00260660e-01f,
  -7.65008945e-03f, 9.84465424e-03f, 5.53289652e-02f, 4.22535054e-02f, 9.81029868e-02f, 1.62595019e-01f, 1.17736775e-02f, 1.05186984e-01f, 2.46308558e-02f, 3.55809182e-02f,
  -2.17109974e-02f, 1.59813650e-02f, 1.35853723e-01f, 5.22535034e-02f, 3.45632322e-02f, 1.70602068e-01f, 1.34594127e-04f, -5.52179813e-02f, 2.10180599e-02f, -9.97968670e-03f,
  1.54932713e-04f, -2.36958131e-01f, -4.71540838e-02f, 3.48468944e-02f, 5.94126992e-02f, 2.17018016e-02f, 7.58900121e-02f, -4.91832495e-02f, 1.09974623e-01f, -7.77571872e-02f,
  -1.61154494e-01f, -9.00809914e-02f, 7.47398213e-02f, -8.35035220e-02f, -1.02342755e-01f, -5.03977798e-02f, -8.04325491e-02f, -1.39228284e-01f, -1.98176697e-01f, -2.46242024e-02f,
  -1.03854358e-01f, -3.73215616e-01f, -2.85365939e-01f, -3.02880019e-01f, -6.04095012e-02f, -2.10388511e-01f, -2.45324761e-01f, -2.25962639e-01f, -4.12610978e-01f, -4.00768846e-01f,
  5.30112624e-01f, -3.60033631e-01f, -4.35857922e-01f, -1.72893792e-01f, -2.93312073e-01f, -1.81011096e-01f, -7.91449025e-02f, 1.31789997e-01f, 6.96491599e-02f, -2.61757046e-01f,
  2.49191711e-04f, 6.18418574e-01f, 3.49220127e-01f, 4.01076794e-01f, 3.71765375e-01f, -3.13560933e-01f, -3.70404810e-01f, -4.81828023e-03f, 4.48581040e-01f, 1.70619041e-01f,
  5.17038703e-02f, 9.73245949e-02f, 2.50960559e-01f, 3.37572545e-02f, -4.34034526e-01f, -9.40097868e-02f, -3.48465532e-01f, -2.91343123e-01f, -2.50604898e-01f, -5.25351822e-01f,
  -2.18419954e-01f, 2.84645651e-02f, 1.63894653e-01f, 2.58987844e-01f, -2.44461417e-01f, 1.29698172e-01f, -1.55130057e-02f, -1.27138063e-01f, 3.25031430e-02f, -1.26161605e-01f,
  -1.43430799e-01f, 1.59062117e-01f, 9.35519412e-02f, -1.51611999e-01f, -8.30153078e-02f, 7.18373358e-02f, -7.77152777e-02f, -1.38995955e-02f, -5.11041097e-02f, -8.02615136e-02f,
  -1.72516778e-01f, -1.91042453e-01f, -1.58398345e-01f, -1.11968413e-01f, -8.98230001e-02f, 1.20783903e-01f, -3.63296509e-01f, -3.63359675e-02f, 6.09004088e-02f, -5.33076704e-01f,
  4.79465723e-02f, -8.64425302e-02f, 1.75022446e-02f, -6.39322922e-02f, -3.60714979e-02f, 1.03447558e-02f, 4.84194309e-02f, 5.50999679e-02f, -2.47028619e-02f, -4.33073528e-02f,
  9.76979956e-02f, 8.30540955e-02f, 1.87868387e-01f, -5.40572926e-02f, 2.32747365e-02f, -8.06035250e-02f, -8.19152892e-02f, -6.26538470e-02f, 8.66345018e-02f, 4.77066636e-02f,
  7.17945397e-02f, 3.49033996e-02f, -7.17121661e-02f, 1.19311720e-01f, 8.50046501e-02f, -2.90894676e-02f, 1.22152427e-02f, 3.78716774e-02f, 7.56573752e-02f, -2.47120187e-02f,
  1.50141418e-01f, 2.09682584e-01f, -5.91367148e-02f, 1.27380297e-01f, -1.31962940e-01f, 1.09820943e-02f, -6.41741529e-02f, -4.65544127e-02f, -3.31451297e-02f, 1.93405766e-02f,
  9.56374854e-02f, 1.53209239e-01f, -1.40320538e-02f, -4.85768691e-02f, -3.37567851e-02f, 1.12716276e-02f, 5.61417490e-02f, 4.17213887e-02f, 6.62921593e-02f, -2.12356180e-01f,
  -2.90632397e-01f, 1.49188474e-01f, 2.07718492e-01f, -7.87494779e-02f, -6.93555996e-02f, 1.09965980e-01f, -2.17577875e-01f, -1.62683100e-01f, 2.63136238e-01f, -1.83731392e-01f,
  6.63519740e-01f, -5.32368422e-01f, -4.74509900e-04f, 1.52573362e-01f, 4.09300476e-02f, -1.37381002e-01f, -5.76517940e-01f, -1.88732564e-01f, 3.87909519e-03f, -3.08113843e-01f,
  1.91569164e-01f, 7.54415929e-01f, 6.95834637e-01f, 4.54024523e-01f, 3.86692047e-01f, -5.36288917e-01f, -5.16664624e-01f, 3.84154111e-01f, 4.26329285e-01f, -3.94467600e-02f,
  -1.34799659e-01f, -7.46997967e-02f, 1.60189927e-01f, -1.12114094e-01f, -4.96462643e-01f, 1.45574063e-01f, -4.88444865e-01f, -2.75477469e-01f, -2.19493955e-01f, -3.54612768e-01f,
  3.67497727e-02f, 4.46465313e-02f, 1.26796216e-01f, 2.11834475e-01f, -3.45470384e-02f, -2.62901909e-03f, -1.38853252e-01f, -1.30047113e-01f, 5.68292327e-02f, -1.40308365e-01f,
  1.39864519e-01f, 7.50141665e-02f, 6.28392026e-02f, -1.52635962e-01f, -1.98556423e-01f, -4.19122912e-03f, -2.84417689e-01f, -9.36983377e-02f, -1.34096742e-02f, -1.98077969e-02f,
  -2.37250224e-01f, 5.93570210e-02f, 1.30490154e-01f, -2.46555880e-01f, -1.58902317e-01f, 2.87194431e-01f, -3.31929594e-01f, -1.87486485e-01f, 6.61383942e-03f, -6.87363863e-01f,
  -9.04048607e-03f, 1.53618574e-01f, 9.92577337e-03f, -5.72638623e-02f, -7.55276456e-02f, 1.10999137e-01f, 1.02954730e-02f, -5.91794848e-02f, -2.17675772e-02f, -1.18987687e-01f,
  1.55124158e-01f, 5.40036894e-02f, 2.23676674e-03f, -1.11960277e-01f, -6.42104521e-02f, -7.94296935e-02f, 1.28256097e-01f, -5.90387881e-02f, -4.77453209e-02f, -5.13529330e-02f,
  1.17798641e-01f, 6.10880814e-02f, 2.63479743e-02f, -1.46641815e-03f, 1.24341853e-01f, 3.11180912e-02f, 1.85781252e-02f, 3.52767520e-02f, 4.41781580e-02f, -9.10553113e-02f,
  8.47699419e-02f, 2.61343151e-01f, 4.99207005e-02f, 9.89113599e-02f, -6.29473701e-02f, 4.67350408e-02f, -7.85109103e-02f, -3.15104686e-02f, 1.03108205e-01f, 6.16554059e-02f,
  -3.45122628e-02f, 9.39111486e-02f, -5.86810037e-02f, -8.17626864e-02f, -8.72751996e-02f, -8.97156745e-02f, -9.24322084e-02f, 1.02323309e-01f, -8.17382932e-02f, -2.59888291e-01f,
  -2.73105383e-01f, 8.34324136e-02f, 1.67982712e-01f, 2.83672400e-02f, -9.62485746e-02f, 1.96339443e-01f, -2.74791121e-01f, -2.53250211e-01f, 2.51064867e-01f, -5.16719520e-01f,
  5.29116511e-01f, -1.28449306e-01f, 1.47887900e-01f, 1.64014950e-01f, 1.31327853e-01f, -1.05561838e-01f, -1.81517839e-01f, -2.08568767e-01f, -1.18942484e-02f, 4.02003266e-02f,
  6.11424670e-02f, 1.55266732e-01f, 7.56182373e-02f, -7.39592910e-02f, -9.26319212e-02f, -8.22681338e-02f, -2.81321499e-02f, 1.70225278e-01f, 1.32000580e-01f, 1.75077453e-01f,
  -3.15044046e-04f, 1.37986541e-01f, 2.36489102e-01f, 3.35478224e-02f, 9.24552828e-02f, -4.90886997e-03f, 8.49364046e-03f, 5.93602397e-02f, 8.02133307e-02f, 1.01436287e-01f,
  2.48415977e-01f, 1.83726832e-01f, 1.67147326e-03f, 1.26768211e-02f, 2.29556486e-01f, -2.04834528e-02f, 7.36318231e-02f, -8.06021541e-02f, 1.68956164e-02f, -9.24958512e-02f,
  2.10789423e-02f, 1.16945282e-01f, 4.91416045e-02f, 1.36349738e-01f, 1.74416211e-02f, 1.71666853e-02f, 1.36694402e-01f, -6.59395475e-04f, 1.59163792e-02f, -3.24942954e-02f,
  9.49690342e-02f, 1.20326802e-01f, 5.20353578e-02f, -8.12566802e-02f, 6.87213689e-02f, 2.00489879e-01f, 6.55791909e-02f, 6.96262643e-02f, -1.97122581e-02f, -3.41582969e-02f,
  1.16832107e-01f, 2.63531625e-01f, 2.70253599e-01f, 1.31189033e-01f, 2.35724337e-02f, 3.66571955e-02f, 9.45970044e-02f, -3.23793218e-02f, 1.62916377e-01f, 1.87806889e-01f,
  7.68311555e-03f, 1.91347636e-02f, 5.06459968e-03f, 2.30548605e-02f, 3.16102237e-01f, 2.79629439e-01f, 7.25131035e-02f, 9.00431443e-03f, 2.10239783e-01f, -6.88710669e-03f,
  4.72183265e-02f, 3.88547895e-04f, 2.41123319e-01f, 8.99179373e-03f, 8.39363560e-02f, 2.53674567e-01f, 2.18576670e-01f, 1.37019619e-01f, 2.15532988e-01f, 1.42906189e-01f,
  -3.37358803e-01f, 1.86540976e-01f, 6.33676425e-02f, -1.23913713e-01f, 8.30946490e-02f, 9.13280770e-02f, -2.78626587e-02f, -1.76812306e-01f, -1.35868996e-01f, -1.77442521e-01f,
  5.35109499e-03f, -3.05905510e-02f, 1.12872243e-01f, 3.36842462e-02f, 2.98367850e-02f, 1.33544961e-02f, 9.48132798e-02f, -2.87995934e-02f, -5.46083264e-02f, 4.35591228e-02f,
  -2.15811189e-02f, 2.18984187e-02f, 7.42135628e-04f, -8.30935389e-02f, -9.18144062e-02f, 7.99861401e-02f, 6.04233192e-03f, -2.71924362e-02f, 3.98316830e-02f, -5.73238246e-02f,
  6.92457080e-01f, 2.55994231e-01f, -6.24943078e-01f, 1.62828907e-01f, -2.37444654e-01f, -2.25235015e-01f, 1.53782547e-01f, 9.81032774e-02f, 3.27115151e-04f, 1.24711536e-01f,
  1.41476467e-01f, 3.39788422e-02f, -1.60871372e-01f, -2.46897951e-01f, -1.89307973e-01f, -1.92187056e-01f, -2.03349546e-01f, -2.81899691e-01f, -2.88916558e-01f, -1.27027199e-01f,
  7.04113469e-02f, 1.72834352e-01f, 1.41103849e-01f, -3.26712579e-02f, -1.88149169e-01f, -1.20492794e-01f, -2.22097456e-01f, -2.55404651e-01f, -3.63758177e-01f, -4.01912600e-01f,
  -4.41130310e-01f, 1.22803405e-01f, -1.53632283e-01f, 1.65522117e-02f, 2.07443926e-02f, -1.92389283e-02f, 3.65627967e-02f, -5.45328781e-02f, 1.91779271e-01f, 9.38738585e-02f,
  -7.66832978e-02f, 2.01073624e-02f, 6.25612214e-02f, 3.84887829e-02f, 7.27905333e-02f, 2.09879084e-03f, -1.30465597e-01f, -6.98333681e-02f, -1.11646168e-01f, 6.68723732e-02f,
  1.11460991e-01f, -2.10621450e-02f, -2.18612552e-02f, -3.63729708e-02f, -5.99161014e-02f, -2.18279898e-01f, -8.14970508e-02f, -1.65049568e-01f, -2.12244689e-01f, 5.05156703e-02f,
  1.29545736e-03f, 4.57274215e-03f, 9.83809531e-02f, 5.07435016e-02f, 1.54901728e-01f, 6.88459352e-02f, 6.75472245e-02f, -1.17158834e-02f, 7.11616725e-02f, 4.57572266e-02f,
  9.12550166e-02f, 1.02477677e-01f, 1.37539580e-01f, 9.62699279e-02f, 1.62218679e-02f, 5.36219478e-02f, 1.47081092e-02f, 8.41721818e-02f, -5.42735234e-02f, 1.04009368e-01f,
  1.70339160e-02f, -1.58044677e-02f, 4.46406044e-02f, -4.06086966e-02f, -3.10006156e-03f, 2.64962055e-02f, -8.57169554e-02f, 6.37617335e-03f, 4.01215106e-02f, -4.99078892e-02f,
  2.06932634e-01f, 1.80270709e-02f, 4.12772074e-02f, -7.66604915e-02f, 2.06956523e-03f, -7.89361149e-02f, 1.00548677e-01f, 3.18338871e-02f, 1.92301453e-03f, -3.37557644e-02f,
  5.09765260e-02f, 1.48509711e-01f, 1.16992369e-01f, -2.17858665e-02f, -2.69227996e-02f, -8.04463699e-02f, 1.95133284e-01f, -6.78217933e-02f, 3.85350436e-02f, 4.97345366e-02f,
  1.37636989e-01f, 1.76258788e-01f, 1.10744521e-01f, -4.48532216e-02f, -3.20970565e-02f, -9.60546285e-02f, 3.29972319e-02f, 6.19439641e-03f, -1.08263850e-01f, 2.38629848e-01f,
  5.76000869e-01f, -5.17803319e-02f, -5.29271781e-01f, -9.62154940e-02f, -2.77841538e-01f, -3.98811847e-01f, -4.77607131e-01f, -1.68091267e-01f, 2.05574604e-03f, -1.87607691e-01f,
  -1.50304288e-01f, 1.01990834e-01f, -1.51938096e-01f, -1.80301681e-01f, -2.93623239e-01f, -4.25134391e-01f, -3.21778327e-01f, -2.65276015e-01f, -3.29548925e-01f, -1.37781456e-01f,
  -6.41090274e-02f, -5.84576614e-02f, 3.96261178e-02f, -3.70465182e-02f, -2.22331118e-02f, -1.57719329e-01f, -3.24816287e-01f, -2.07428977e-01f, -3.14011455e-01f, -2.55464196e-01f,
  -3.46287012e-01f, 6.80597574e-02f, -1.55534446e-01f, 1.70994237e-01f, -1.13027625e-01f, 1.65901080e-01f, -4.41379100e-02f, -9.45583452e-04f, 1.64304197e-01f, -8.46956298e-02f,
  2.52667759e-02f, 1.14546251e-02f, 1.56926826e-01f, 4.23916057e-02f, -1.16507158e-01f, -1.39184305e-02f, -2.11999744e-01f, -2.40722418e-01f, -1.00505732e-01f, -1.25680164e-01f,
  7.97920972e-02f, -2.16954902e-01f, -3.83821093e-02f, -2.01829016e-01f, -1.24823891e-01f, -1.36853263e-01f, -1.95922419e-01f, -2.66765486e-02f, -1.62873760e-01f, 1.23582073e-01f,
  -3.77601311e-02f, 4.95806430e-03f, 3.57067250e-02f, -8.47292393e-02f, 2.77878102e-02f, -3.16386968e-02f, 7.56921619e-02f, 4.43506129e-02f, -6.56639645e-03f, -1.30469585e-02f,
  -6.24478720e-02f, -1.10627048e-01f, 4.84278165e-02f, 8.42310339e-02f, -5.92704527e-02f, -7.84737542e-02f, -9.46594998e-02f, -1.65738408e-02f, 7.56679848e-02f, -3.93103249e-02f,
  1.49398355e-03f, -2.77545676e-02f, -5.20840846e-02f, 8.01884905e-02f, -8.80281404e-02f, -7.80044496e-02f, 6.38855696e-02f, 5.75735644e-02f, 3.10384203e-02f, -2.51490157e-02f,
  1.68846011e-01f, -1.58273682e-01f, 8.86937380e-02f, 1.74101442e-01f, -1.67356983e-01f, -1.04133546e-01f, 1.81524716e-02f, 2.66179889e-02f, 7.23619908e-02f, 5.90105839e-02f,
  -9.75177214e-02f, 1.06377238e-02f, -3.54183502e-02f, 8.25903118e-02f, 1.69220213e-02f, -8.74157622e-02f, 9.77551937e-03f, -1.18609844e-02f, -2.82367393e-02f, -4.54687215e-02f,
  -7.89536461e-02f, 1.50656849e-01f, 2.12038815e-01f, 8.87843594e-02f, 5.53285293e-02f, 1.81665495e-01f, -8.54477212e-02f, -1.36766776e-01f, 4.81744967e-02f, 2.43919671e-01f,
  4.27177995e-01f, -3.00344080e-01f, -1.41613662e-01f, 2.46054083e-01f, -3.17546785e-01f, -4.81171846e-01f, -6.11177921e-01f, -2.20672935e-01f, 2.44710997e-01f, -4.15165156e-01f,
  -5.66908360e-01f, 6.50696605e-02f, 1.15806051e-01f, 1.86447066e-03f, -2.55403310e-01f, -4.88173038e-01f, -2.17798918e-01f, 1.16317756e-01f, 8.83342475e-02f, -3.17250788e-01f,
  -2.39789605e-01f, 2.06605271e-01f, 3.76185596e-01f, 3.09081137e-01f, 1.46597594e-01f, 5.05400449e-02f, -1.40821617e-02f, 1.02693192e-03f, -1.29549578e-01f, 1.23889789e-01f,
  -1.58198223e-01f, 2.47857839e-01f, -2.29144707e-01f, 1.81506008e-01f, -7.69865066e-02f, 1.02095827e-01f, -2.00083449e-01f, 1.64401025e-01f, 1.13141090e-02f, -9.61396694e-02f,
  -8.80640224e-02f, -1.84782427e-02f, 9.98107120e-02f, -1.93782542e-02f, -2.35143155e-02f, 7.27452058e-03f, 1.54115692e-01f, 2.48546034e-01f, 1.79543689e-01f, 8.90436172e-02f,
  -2.73142606e-01f, -1.87257662e-01f, 4.74141054e-02f, -1.67838797e-01f, 1.99478880e-01f, 1.13117285e-01f, -6.25749156e-02f, 1.20356902e-01f, -1.53134326e-02f, 6.77365763e-03f,
  -4.55333106e-02f, -6.01321906e-02f, -1.17212400e-01f, 1.08641617e-01f, -2.38828063e-02f, -9.13370252e-02f, 1.44283921e-01f, -5.32660820e-02f, 2.16525942e-02f, 8.84358510e-02f,
  5.35044409e-02f, 1.43409539e-02f, 3.40227075e-02f, 3.86475725e-03f, 6.15834482e-02f, 8.94901454e-02f, -6.34915754e-02f, -1.09379359e-01f, 1.25502929e-01f, 2.40879562e-02f,
  7.36767128e-02f, 2.53745019e-02f, -3.70898545e-02f, -6.81672129e-04f, -7.91900307e-02f, 5.59086949e-02f, 3.24420445e-02f, 2.63835443e-03f, -6.87767416e-02f, 5.04275039e-02f,
  -1.70661941e-01f, -3.99765223e-01f, -1.23927720e-01f, 6.12185486e-02f, -1.06624328e-01f, 4.42033224e-02f, -9.22326371e-02f, 2.32284963e-02f, 1.21129028e-01f, 1.00715414e-01f,
  -4.70784381e-02f, -6.19144291e-02f, 1.06616151e-02f, 3.39853242e-02f, -3.65043953e-02f, 4.98097278e-02f, -2.13946536e-01f, -1.42886132e-01f, -1.45389080e-01f, 9.33383405e-02f,
  1.05742729e-04f, -2.76995182e-01f, -1.54913530e-01f, -2.90498793e-01f, -5.77630252e-02f, -9.07393768e-02f, -2.03953251e-01f, -1.45693675e-01f, -3.20160687e-01f, -3.89148414e-01f,
  -2.24676996e-01f, 3.41540426e-01f, -3.97884548e-02f, -1.27711102e-01f, -8.60752314e-02f, -1.50005175e-02f, 1.81488603e-01f, 1.70358703e-01f, 4.82165394e-03f, 1.22688748e-01f,
  1.60777790e-03f, -1.31244540e-01f, -7.28666876e-03f, 5.49907424e-02f, 7.47065917e-02f, 2.18512446e-01f, 8.68834555e-02f, -7.02686757e-02f, -1.48005337e-01f, -1.28533915e-01f,
  -6.34512901e-02f, -1.41680241e-01f, -1.37841821e-01f, 3.46051231e-02f, -3.32121141e-02f, -2.17248313e-02f, 3.95908765e-02f, -1.50853351e-01f, 9.74463597e-02f, 6.54362440e-02f,
  -7.86947384e-02f, 1.94288194e-02f, -5.15319826e-03f, 7.88176283e-02f, 2.55821552e-02f, -6.62138537e-02f, 5.18523343e-02f, -8.90990999e-03f, -2.43314225e-02f, 6.96303770e-02f,
  7.61949643e-02f, 2.26785298e-02f, 2.07226556e-02f, 2.40245536e-02f, -7.09725469e-02f, -6.10061288e-02f, -9.37751494e-03f, 7.75546357e-02f, -1.05532650e-02f, -4.45249826e-02f,
  -8.96580666e-02f, -1.40455902e-01f, -8.21234137e-02f, -1.08831562e-01f, -3.06716375e-03f, -1.34063721e-01f, -4.38949652e-02f, -1.14042815e-02f, 8.46764306e-04f, -1.51791275e-01f,
  -8.13555270e-02f, 1.44957006e-01f, 2.05829479e-02f, -7.03539103e-02f, -7.94422403e-02f, 4.03723568e-02f, -8.08552094e-03f, -9.79097560e-02f, -1.05594415e-02f, -4.73107137e-02f,
  -2.15968471e-02f, -1.34574533e-01f, -6.11847043e-02f, -1.66458706e-03f, -7.83175454e-02f, -6.21312335e-02f, 3.49508934e-02f, -2.66180001e-02f, -8.17003623e-02f, -8.79128184e-03f,
  -5.63569665e-02f, -1.49344662e-02f, -7.48200491e-02f, -3.67651992e-02f, -6.41583204e-02f, -6.24797726e-03f, 5.93119226e-02f, 2.22319160e-02f, 2.85392981e-02f, 1.03226677e-01f,
  -5.31916087e-03f, -3.13405581e-02f, -1.03632525e-01f, 9.53506976e-02f, -8.97454657e-03f, 3.93381566e-02f, -5.04431548e-03f, -9.72192176e-03f, 1.73299399e-04f, -2.51326803e-02f,
  -1.12819020e-02f, 8.85862578e-03f, -3.47286537e-02f, -4.73007938e-04f, -3.10330950e-02f, -4.33765836e-02f, -3.94779705e-02f, 7.29779974e-02f, -2.55576149e-02f, 1.25847654e-02f,
  -4.46263179e-02f, -3.24889012e-02f, -9.72906426e-02f, 1.28620975e-02f, -1.04919642e-01f, -1.81439772e-01f, -1.10079437e-01f, -9.90125909e-02f, -6.71759546e-02f, -1.09194621e-01f,
  -3.63147378e-01f, 1.60491094e-02f, -1.18158787e-01f, -4.72373664e-01f, -5.67889512e-02f, 2.29834735e-01f, 2.80855089e-01f, -5.19329570e-02f, -1.51170477e-01f, 7.05862492e-02f,
  -1.11921340e-01f, -3.11799258e-01f, -4.54817802e-01f, -5.05115427e-02f, 5.36862314e-02f, 2.74544030e-01f, 2.72202455e-02f, -1.33912235e-01f, -1.77118480e-01f, 2.56117016e-01f,
  6.12150319e-02f, -2.30660811e-01f, -2.12396041e-01f, -1.69023037e-01f, -2.99666435e-01f, -3.04566681e-01f, -3.50597233e-01f, -2.02958748e-01f, 1.57044187e-01f, -2.12944046e-01f,
  -1.63979921e-02f, -7.69609883e-02f, 8.17864144e-04f, -1.00961499e-01f, -7.79172033e-02f, 2.29633227e-02f, -9.74201337e-02f, -1.48518935e-01f, -1.04109451e-01f, 1.76465325e-03f,
  -2.58422464e-01f, 1.05920853e-03f, -2.05848381e-01f, -4.83386889e-02f, -6.55428767e-02f, 1.17364444e-01f, -1.30551964e-01f, -3.79352756e-02f, 5.54209836e-02f, 1.07451864e-01f,
  1.22360058e-01f, 1.72055036e-01f, -1.17355008e-02f, 1.63856059e-01f, 1.89547643e-01f, 1.10126939e-02f, -1.21331261e-02f, 1.58081278e-01f, 2.03602493e-01f, 1.62291396e-02f,
  2.72989720e-01f, -1.08597890e-01f, -1.31807774e-01f, -1.47811800e-01f, -2.32568327e-02f, -1.48095535e-02f, -3.98760699e-02f, 1.58971343e-02f, -1.13279214e-02f, -1.22567371e-01f,
  -2.28237752e-02f, 6.13781177e-02f, -4.24279310e-02f, 7.56092891e-02f, 2.63373181e-02f, -8.90368819e-02f, 1.85507555e-02f, 7.16830119e-02f, -5.43482660e-04f, -3.82502303e-02f,
  -5.46931177e-02f, 4.98352833e-02f, -1.14863433e-01f, 6.71426803e-02f, 1.42043918e-01f, 8.98729935e-02f, -2.25753654e-02f, 3.07309702e-02f, -9.55752190e-03f, 1.33631349e-01f,
  -4.97480094e-01f, 1.55237943e-01f, -2.26901278e-01f, -8.95003974e-02f, -1.98635831e-02f, -6.81421254e-03f, -1.61945358e-01f, 1.29939392e-01f, -1.78895786e-01f, -8.33873823e-02f,
  -9.01959240e-02f, 4.85067330e-02f, -1.12398878e-01f, -9.60137025e-02f, -1.31733268e-01f, 5.45129664e-02f, 6.06808998e-02f, -9.11937878e-02f, 4.36327159e-02f, 3.36987786e-02f,
  1.47709206e-01f, 2.13448226e-01f, -1.19352885e-01f, -6.57789584e-04f, 1.23584352e-01f, 6.13440201e-02f, -1.62679866e-01f, 1.32338181e-02f, 2.42231637e-02f, 1.40358806e-02f,
  -4.67198133e-01f, 1.06028385e-01f, 1.38878733e-01f, -3.08784068e-01f, 1.19433947e-01f, 3.27354848e-01f, 4.87684846e-01f, 2.63724238e-01f, -2.86317527e-01f, -1.65969327e-01f,
  1.40179113e-01f, -1.37222454e-01f, -2.08447456e-01f, 1.03426479e-01f, 2.22777769e-01f, -1.27968729e-01f, -2.03047633e-01f, -4.60890979e-02f, 2.06378281e-01f, 2.68576771e-01f,
  3.97866592e-02f, -5.02299517e-02f, -2.38112301e-01f, -1.01440825e-01f, -3.18515152e-01f, -2.28833765e-01f, -3.12171251e-01f, -2.14560717e-01f, 4.12519835e-02f, -4.52554405e-01f,
  -3.64148647e-01f, 1.15165249e-01f, 8.94888341e-02f, -1.07095940e-02f, -1.17811799e-01f, -2.65746117e-01f, -2.88121253e-02f, -9.24734026e-02f, -1.01692222e-01f, -1.70601204e-01f,
  -5.12576364e-02f, 3.84506620e-02f, -3.09585966e-02f, 1.93434298e-01f, 7.71714747e-02f, 2.05159694e-01f, 1.24495685e-01f, 1.41829595e-01f, -2.72188187e-01f, 6.45155013e-02f,
  2.31716827e-01f, -2.08500326e-01f, -9.75524113e-02f, 4.50476855e-02f, 8.06393027e-02f, -1.09893866e-01f, 2.14757010e-01f, 3.43310311e-02f, -1.27453789e-01f, -5.31271636e-01f,
  3.06934696e-02f, 1.27802506e-01f, 3.06405663e-01f, 2.70544946e-01f, -4.35955152e-02f, -1.17948893e-02f, -8.96737799e-02f, 4.23416160e-02f, -3.16986814e-02f, 4.59928550e-02f,
  9.89625603e-02f, 5.33162020e-02f, 1.44734100e-01f, -1.60405517e-01f, -8.39301124e-02f, -2.15060394e-02f, -1.68900475e-01f, -1.52906433e-01f, -1.18188746e-01f, -8.43930244e-02f,
  -1.65922381e-03f, -1.61271319e-01f, -8.18628296e-02f, -4.10480313e-02f, 7.69513622e-02f, -2.64475513e-02f, -1.69218928e-02f, 1.10486679e-01f, 1.58017904e-01f, 7.20631480e-02f,
  -2.61620253e-01f, 2.40820080e-01f, -4.49751675e-01f, 1.38188884e-01f, -1.17480725e-01f, -1.78919882e-01f, -1.90763623e-01f, 8.45858231e-02f, -4.50559296e-02f, 1.02411002e-01f,
  2.60637522e-01f, -3.03455326e-03f, -6.17692210e-02f, 2.34083325e-01f, -5.30280732e-03f, 3.49537991e-02f, 7.72895440e-02f, -4.67581116e-02f, -7.02853948e-02f, 2.03764495e-02f,
  -3.56745683e-02f, -1.75008848e-01f, -3.39911312e-01f, -2.65846282e-01f, -1.89490661e-01f, -2.46847466e-01f, -2.68447369e-01f, -2.95480460e-01f, -2.86972612e-01f, -4.05725151e-01f,
  -6.51609838e-01f, 2.55480647e-01f, 2.36731052e-01f, -5.75782418e-01f, -2.53604084e-01f, -1.20676234e-01f, 1.51603252e-01f, -2.07760677e-01f, -2.68166691e-01f, 2.63636202e-01f,
  1.34202674e-01f, -1.11211903e-01f, 1.40209138e-01f, -6.79961070e-02f, 2.42163874e-02f, 2.98158795e-01f, 5.23869544e-02f, -1.39941648e-01f, -4.34268802e-01f, -2.92632312e-01f,
  -1.28204748e-01f, -3.87643576e-01f, -2.89457411e-01f, -1.95710689e-01f, -1.45775393e-01f, -2.57241637e-01f, 8.95898491e-02f, -2.23219469e-01f, 9.19827074e-02f, 1.36177883e-01f,
  3.50525349e-01f, -1.62851661e-01f, -1.31012365e-01f, -1.07638441e-01f, 9.11295647e-05f, -3.21416222e-02f, -1.24162594e-02f, -1.78435557e-02f, -2.15936452e-02f, 6.56351894e-02f,
  -1.08942710e-01f, -1.15140244e-01f, -9.73571837e-02f, 1.95487849e-02f, -7.51208887e-02f, 6.88272938e-02f, -9.16445814e-03f, -5.36683872e-02f, 2.77082361e-02f, 2.43623957e-01f,
  1.76525310e-01f, 1.51127798e-03f, 8.08044970e-02f, 6.23903275e-02f, -1.28642758e-02f, -5.62195070e-02f, 1.77539699e-02f, -1.58656523e-01f, 4.58550379e-02f, 6.33633658e-02f,
  -7.66627640e-02f, 1.08360741e-02f, -2.01277602e-02f, -8.01290572e-02f, 1.08959965e-01f, 1.17028588e-02f, -2.94164289e-02f, 9.14937332e-02f, -1.25164449e-01f, -6.86159655e-02f,
  -1.49193145e-02f, 1.27271429e-01f, 5.41617423e-02f, 6.47312552e-02f, -2.96904147e-02f, -4.50333916e-02f, 1.15272067e-01f, 1.27709404e-01f, 6.77708462e-02f, -4.48110700e-02f,
  -6.70272037e-02f, -6.06828369e-02f, 8.07076599e-03f, 4.75265160e-02f, 1.37746349e-01f, -5.48659153e-02f, -2.07569823e-02f, 8.94499719e-02f, -2.53824405e-02f, 2.74858642e-02f,
  -1.16845183e-01f, -6.01357259e-02f, 1.31874293e-01f, -9.58124921e-02f, 3.34196235e-03f, -1.43385474e-02f, -6.57174736e-03f, -6.47381470e-02f, -2.38940436e-02f, -3.10645835e-03f,
  -3.45606939e-03f, -2.98327208e-02f, 1.47958681e-01f, 5.19036613e-02f, -6.25228733e-02f, -5.13201719e-03f, 7.48707652e-02f, -7.59618357e-02f, -9.60980058e-02f, 1.56065658e-01f,
  1.05126768e-01f, 5.89250727e-03f, 1.45430058e-01f, 3.77852544e-02f, -8.67118612e-02f, -4.35954370e-02f, 2.13038146e-01f, 6.42432868e-02f, 1.26244634e-01f, 2.78695643e-01f,
  -4.89418566e-01f, 3.25481325e-01f, 2.97160238e-01f, -2.03456879e-01f, -8.13453048e-02f, 1.36518151e-01f, 2.61307389e-01f, -1.30320802e-01f, -2.79060662e-01f, 1.12430215e-01f,
  -6.82310909e-02f, -2.56494790e-01f, 2.96037495e-02f, 1.72888953e-02f, 5.24689294e-02f, 2.85426617e-01f, 2.92353272e-01f, 1.41395122e-01f, -2.66409069e-01f, -2.60249257e-01f,
  -4.68290932e-02f, -2.31243655e-01f, -1.93619341e-01f, -6.42391518e-02f, -1.79058518e-02f, -9.49991047e-02f, 2.49573842e-01f, 6.38713390e-02f, 1.76438615e-01f, 1.50269777e-01f,
  -1.89137133e-03f, 8.77831951e-02f, 5.30140363e-02f, -4.16806638e-02f, 5.04466034e-02f, -1.39292017e-01f, 3.49383242e-02f, -1.34210195e-02f, 1.05895303e-01f, 9.02137086e-02f,
  -5.18172495e-02f, 1.56695217e-01f, 4.71933512e-03f, 7.39543661e-02f, -1.17504336e-01f, -1.36932224e-01f, 8.85385722e-02f, -3.58829573e-02f, 2.75118556e-02f, -4.25899215e-02f,
  1.04104742e-01f, -6.52591437e-02f, -1.49499834e-01f, -7.30385035e-02f, 6.14925660e-02f, -7.22052902e-02f, -3.82685848e-02f, -1.45061657e-01f, 4.69547417e-03f, -1.83473602e-01f,
  -6.48927037e-03f, 2.41119508e-02f, 1.13336772e-01f, 3.19275334e-02f, 5.13622388e-02f, 1.14191748e-01f, 1.87271193e-01f, -3.50554250e-02f, 8.97236913e-02f, -1.09340169e-01f,
  -6.97892904e-02f, -2.00691283e-01f, -1.73607506e-02f, 6.81006685e-02f, -1.03531264e-01f, 5.23889139e-02f, 1.01634964e-01f, 1.10376095e-02f, 3.35938595e-02f, -4.93091419e-02f,
  4.61082086e-02f, 1.13729313e-01f, 3.24414647e-03f, 3.62649672e-02f, 1.63576573e-01f, 1.99655965e-01f, -2.46458724e-01f, -1.35686919e-01f, -1.15237236e-01f, -2.02376023e-02f,
  -1.68017566e-01f, 3.17025959e-01f, -1.10868074e-01f, 1.76252201e-01f, 9.44200680e-02f, -5.93675813e-03f, -1.10260285e-01f, -4.66740355e-02f, 2.74616741e-02f, 1.07368024e-03f,
  -1.94197036e-02f, 2.13245628e-03f, 1.49989784e-01f, 1.85949530e-03f, -2.30254710e-01f, -2.21461207e-01f, 1.22402860e-02f, -1.76377431e-01f, -3.52394511e-03f, -1.58028379e-01f,
  1.34548359e-02f, -2.60517448e-01f, -4.23607230e-01f, -2.21689463e-01f, -2.88541764e-01f, -3.75640333e-01f, -9.31765512e-02f, -1.79224119e-01f, -2.87496090e-01f, -3.14870775e-01f,
  -2.83155441e-01f, -1.14764921e-01f, -2.34257966e-01f, 5.17441630e-01f, 1.38989925e-01f, -2.09616095e-01f, -3.27698082e-01f, -1.22156009e-01f, 2.91219503e-01f, 2.71965504e-01f,
  2.61577249e-01f, 3.52761447e-01f, 3.59474868e-01f, 1.26599714e-01f, -9.88823771e-02f, 5.99507801e-02f, 1.22320019e-01f, -2.71365345e-01f, -3.40891749e-01f, -3.03786933e-01f,
  1.32842615e-01f, 1.04669286e-02f, -1.35324880e-01f, -4.09238636e-02f, 2.00253457e-01f, 2.16880724e-01f, 2.17158049e-01f, -4.39428948e-02f, -1.17068239e-01f, 9.06989202e-02f,
  1.16403596e-02f, -2.24168599e-01f, -6.68947324e-02f, -3.27293649e-02f, -9.29955468e-02f, 2.27589868e-02f, -7.56619498e-02f, 9.95511860e-02f, 5.17767221e-02f, -8.74470025e-02f,
  5.22043556e-02f, 2.25645527e-02f, 7.73352385e-02f, -1.77716315e-02f, -8.78905654e-02f, 2.10851692e-02f, 1.14378437e-01f, -1.31643489e-01f, -8.14729407e-02f, 3.15420330e-02f,
  1.53893605e-01f, 6.50288761e-02f, -1.69735983e-01f, -9.84008312e-02f, -2.28004560e-01f, 1.14650289e-02f, -3.15857828e-01f, -2.72637486e-01f, -2.14466766e-01f, -1.12788305e-01f,
  -6.98887035e-02f, -1.95194528e-01f, -9.51387659e-02f, 1.59198698e-02f, 2.96371039e-02f, 9.39230695e-02f, 8.96205381e-02f, -2.75532175e-02f, -1.17016129e-01f, 1.37302568e-02f,
  7.40736946e-02f, -1.06015392e-01f, -2.23742146e-02f, 4.05980237e-02f, 1.45110443e-01f, -4.63101380e-02f, -6.92480281e-02f, -1.30690128e-01f, -1.60333231e-01f, 7.57262483e-02f,
  5.80614954e-02f, -5.41035384e-02f, 9.55974404e-03f, -1.58262789e-01f, 1.98712461e-02f, -9.25200880e-02f, 2.62217559e-02f, -6.43947162e-03f, 6.39235824e-02f, 9.38542187e-02f,
  4.40212250e-01f, -7.68620148e-02f, 1.96726784e-01f, -1.33878440e-02f, -1.04338616e-01f, 5.16116507e-02f, 3.48235704e-02f, -1.12067968e-01f, 1.59740057e-02f, -6.47065639e-02f,
  -2.20046446e-01f, -1.50755703e-01f, 6.58490583e-02f, -6.22705892e-02f, -5.93841188e-02f, 5.46737015e-02f, 5.00844568e-02f, -1.56000853e-02f, -3.82129066e-02f, 1.39595000e-02f,
  1.74433202e-01f, -1.07439466e-01f, -2.46048607e-02f, 8.37351456e-02f, 5.90188242e-02f, -3.17698643e-02f, -1.17950402e-01f, -1.34395182e-01f, -1.18751645e-01f, -1.32687002e-01f,
  -5.83746910e-01f, 2.64761895e-01f, 2.39175946e-01f, -1.13545179e-01f, 2.74821669e-01f, 5.46922125e-02f, -6.40909448e-02f, -1.15914688e-01f, 1.33362457e-01f, 1.01836674e-01f,
  1.14664353e-01f, -1.03631780e-01f, 1.66796725e-02f, -4.51771207e-02f, -2.20118403e-01f, 2.37310469e-01f, 2.31703147e-01f, -1.87877208e-01f, -5.48880279e-01f, -4.19802755e-01f,
  -5.24153970e-02f, -2.04356417e-01f, -4.80773956e-01f, -8.79676342e-02f, 2.99757659e-01f, 8.69549960e-02f, 3.41385871e-01f, 1.58453032e-01f, 2.93735445e-01f, 5.43421924e-01f,
  5.71344532e-02f, -1.02971941e-02f, -1.23119637e-01f, 3.45629407e-03f, 7.49607310e-02f, -2.37589419e-01f, -3.10786013e-02f, 5.25233857e-02f, -7.36122951e-02f, 3.61389667e-02f,
  1.22309722e-01f, 4.97163832e-02f, 1.44497305e-01f, -6.77440241e-02f, -1.44475952e-01f, -2.94736266e-01f, -1.66108057e-01f, -2.74802268e-01f, -1.51851892e-01f, -1.32122561e-01f,
  1.80123359e-01f, -1.61496714e-01f, -1.15616888e-01f, -1.01770805e-02f, -3.18995141e-03f, -1.68446258e-01f, -9.83916298e-02f, -3.05174850e-04f, -2.14411393e-01f, 2.53219977e-02f,
  2.96983887e-02f, 1.82027090e-02f, 5.02453931e-03f, 6.15239562e-03f, -1.06005862e-01f, 1.90057158e-01f, 1.77626431e-01f, 4.26153243e-02f, 2.41377410e-02f, 2.48517655e-03f,
  4.43690009e-02f, -9.36406776e-02f, -1.23142980e-01f, 4.79173735e-02f, 1.51474793e-02f, -5.44720888e-02f, 8.79299361e-03f, -9.36665386e-02f, 4.32751849e-02f, 5.63016906e-03f,
  -4.46051620e-02f, 1.37111237e-02f, -7.66565674e-04f, -3.97934914e-02f, 2.11001948e-01f, 3.38407792e-02f, 2.24707630e-02f, -1.33675233e-01f, 3.70336212e-02f, 5.92476167e-02f,
  -2.20569387e-01f, -9.29557234e-02f, 7.47034028e-02f, -3.98346372e-02f, 2.99449768e-02f, 2.05876492e-02f, 3.39095257e-02f, 2.43813358e-02f, -8.10911879e-03f, -1.61903352e-01f,
  -1.07497074e-01f, -1.23298667e-01f, 2.05542386e-01f, -3.47864404e-02f, -1.20547377e-01f, 4.10937220e-02f, -1.35979038e-02f, -1.13933399e-01f, -5.72173446e-02f, 3.33240954e-03f,
  5.33868670e-02f, -2.96103209e-01f, -4.40268695e-01f, -6.16364665e-02f, -1.43571384e-02f, -4.81592476e-01f, -8.23680609e-02f, -1.54476374e-01f, -3.74467373e-01f, -4.42536503e-01f,
  6.64239526e-01f, 6.42271042e-01f, 5.42404354e-02f, 1.16793044e-01f, 5.72858192e-02f, 1.26384288e-01f, 4.51377481e-01f, 4.56973970e-01f, 2.40632325e-01f, 2.16208950e-01f,
  2.35732794e-01f, 2.34101014e-03f, 7.35328868e-02f, -2.00087726e-02f, 1.91431284e-01f, 1.85935214e-01f, -3.09489556e-02f, -5.64106442e-02f, 6.23232163e-02f, -5.47143742e-02f,
  -1.61494929e-02f, 1.96078792e-01f, 1.96989760e-01f, 1.18704095e-01f, 2.34805644e-02f, -1.31650239e-01f, -1.07312400e-04f, 1.20689437e-01f, 3.33464965e-02f, -1.89420637e-02f,
  -4.83308703e-01f, 1.30741045e-01f, -8.64808634e-02f, -1.29965484e-01f, -1.48893788e-01f, 9.57267135e-02f, 1.16512524e-02f, -1.21976426e-02f, 9.09691602e-02f, 4.30065952e-02f,
  -1.29258662e-01f, 4.96930033e-02f, -1.20149240e-01f, -1.51471412e-02f, -9.41067841e-03f, 1.94407031e-02f, -1.15788262e-02f, 7.04876631e-02f, -8.67300928e-02f, 1.89070925e-02f,
  -2.00613625e-02f, -3.38573791e-02f, -8.45051650e-03f, -5.69559038e-02f, 4.51521501e-02f, -6.43645376e-02f, 5.84953763e-02f, 7.32122883e-02f, -9.30870473e-02f, 9.49564427e-02f,
  -6.61429837e-02f, 9.97171253e-02f, -1.28316879e-01f, -1.21605553e-01f, -1.01923965e-01f, -5.40270470e-02f, 1.07836593e-02f, -4.49607112e-02f, -5.08490577e-02f, 7.41483271e-02f,
  5.22290496e-03f, -1.60824761e-01f, -6.01389222e-02f, -1.13859981e-01f, -1.07514828e-01f, -1.99263934e-02f, 1.05012953e-01f, -1.45570278e-01f, -2.15713218e-01f, -4.93129939e-02f,
  -2.01695591e-01f, 9.86339971e-02f, -1.88537296e-02f, -9.73069072e-02f, -5.97462542e-02f, -5.73485382e-02f, -6.51877970e-02f, 5.20653687e-02f, 4.48020920e-02f, 1.24636106e-01f,
  -1.97441354e-01f, -3.85577381e-01f, -1.47396281e-01f, 8.96936655e-02f, -6.38380349e-02f, -3.26753315e-03f, -5.76952249e-02f, -4.76380512e-02f, -5.47622107e-02f, -4.30745259e-02f,
  6.42880276e-02f, -5.03140762e-02f, 3.09164748e-02f, -3.21382694e-02f, -9.62831974e-02f, 5.64009650e-03f, 9.89411548e-02f, 2.37773228e-02f, -9.60917026e-02f, 2.85189338e-02f,
  7.35864118e-02f, 4.56645042e-02f, 2.78456006e-02f, -5.22855297e-03f, -6.61647990e-02f, -1.20369799e-01f, -1.33846045e-01f, -5.33492230e-02f, 1.16235949e-02f, 1.33917049e-01f,
  1.84419900e-01f, -3.55242670e-01f, 3.75497729e-01f, 1.57983378e-01f, 5.26675344e-01f, 5.36277175e-01f, 3.85709524e-01f, 1.20259054e-01f, 8.89809281e-02f, -6.76049516e-02f,
  -1.68500498e-01f, -2.71493226e-01f, -2.08563790e-01f, -1.80048302e-01f, -1.33452952e-01f, 2.02296063e-01f, 1.65418759e-01f, -1.70941185e-02f, 1.92725822e-01f, 1.74517468e-01f,
  3.25203547e-03f, 3.39570711e-03f, -9.52629894e-02f, -1.68970615e-01f, -1.54060811e-01f, -2.42032371e-02f, -1.12688914e-01f, -7.79737905e-03f, -3.19879502e-03f, -1.41437471e-01f,
  -9.89441350e-02f, 1.12359434e-01f, 3.11834570e-02f, -2.39450440e-01f, -1.33231536e-01f, -1.86098412e-01f, 3.02474294e-02f, -1.97914630e-01f, -6.68963566e-02f, -1.62398349e-02f,
  -1.13090970e-01f, -2.62201987e-02f, -7.11507127e-02f, 1.35981459e-02f, 2.34447420e-02f, -1.37561858e-01f, -8.28182250e-02f, -1.16084069e-01f, -5.22683114e-02f, -7.02541396e-02f,
  -1.62844673e-01f, 1.23778045e-01f, 8.74364749e-02f, -2.25297380e-02f, -1.22533381e-01f, -4.69347499e-02f, -4.23444398e-02f, 2.83890180e-02f, -7.09116161e-02f, -8.07054788e-02f,
  -3.29905480e-01f, -8.45446214e-02f, 3.14036123e-02f, 1.58474874e-02f, 5.65532073e-02f, 1.00435823e-01f, -1.97410844e-02f, -5.05285896e-02f, 9.81464423e-03f, -6.38804287e-02f,
  -1.65441483e-02f, -7.19427615e-02f, -1.58363059e-02f, -1.24008670e-01f, -6.81815743e-02f, -2.28446350e-02f, 1.11552797e-01f, -1.00108385e-01f, -1.20667137e-01f, -2.48594210e-02f,
  -1.36753209e-02f, -9.08477902e-02f, -6.18821718e-02f, -4.35403250e-02f, -1.01243362e-01f, -1.49060100e-01f, -1.73422635e-01f, -7.53654763e-02f, -1.61329642e-01f, -8.69400278e-02f,
  -3.70039195e-01f, 1.20589286e-01f, 9.81063172e-02f, -1.82169512e-01f, -7.59164318e-02f, -1.09433427e-01f, -5.58827445e-02f, 4.21356708e-02f, 4.17200550e-02f, 1.16551384e-01f,
  -1.32291559e-02f, 5.74577563e-02f, -3.98721173e-02f, -6.00463301e-02f, 1.61174029e-01f, 4.75097895e-02f, -1.91008568e-01f, -6.62503839e-02f, -6.65960386e-02f, -5.82576171e-02f,
  -1.18142217e-01f, 9.51204374e-02f, 1.06075540e-01f, -1.90212969e-02f, 2.02120654e-02f, 6.33687004e-02f, 1.01532906e-01f, 1.23653725e-01f, 2.04462469e-01f, 1.05286703e-01f,
  2.94635072e-03f, 3.24569374e-01f, 2.95287728e-01f, -1.90894961e-01f, -1.10521074e-03f, 8.02450478e-02f, 8.39691535e-02f, -1.62619337e-01f, -2.36582801e-01f, -1.72444806e-01f,
  2.42833734e-01f, -5.70660755e-02f, -1.41458079e-01f, -2.56933242e-01f, -1.05724365e-01f, -1.55065313e-01f, -1.37785569e-01f, -3.32179487e-01f, -3.23873997e-01f, -3.99370760e-01f,
  -4.19481456e-01f, -3.80914211e-01f, -3.05638283e-01f, -1.65771008e-01f, -2.81067729e-01f, -6.37325644e-02f, 8.75237659e-02f, 1.13317743e-01f, 1.39421925e-01f, -2.29319021e-01f,
  -3.59436095e-01f, 3.33984107e-01f, -2.47189775e-01f, -1.32997185e-01f, 1.45092800e-01f, -1.69787202e-02f, 1.26049826e-02f, 1.31924331e-01f, 1.36700973e-01f, -9.32418834e-03f,
  -1.21974070e-02f, -1.67972185e-02f, -7.74910972e-02f, -1.38125017e-01f, -1.15469669e-03f, -1.62406281e-01f, -7.82392770e-02f, 1.20744342e-02f, -6.50125146e-02f, 4.89051044e-02f,
  -6.84628412e-02f, 1.22574672e-01f, 1.29515246e-01f, 6.47601262e-02f, 2.06887200e-01f, 3.10405740e-03f, 2.44460806e-01f, 1.57397032e-01f, 2.43259132e-01f, -1.24124978e-02f,
  -1.35978729e-01f, 2.68170959e-03f, -9.98058245e-02f, -1.77197587e-02f, -4.17418331e-02f, -1.16346389e-01f, -1.48986354e-01f, -1.44123137e-01f, 3.26318294e-02f, -5.93613386e-02f,
  -5.33853769e-02f, 1.21293947e-01f, -4.84191440e-02f, -4.15659212e-02f, -1.02795087e-01f, -2.19452451e-03f, 8.53442680e-03f, -7.35926926e-02f, 2.86981277e-02f, 1.53899882e-02f,
  -7.41252154e-02f, -7.47489706e-02f, 5.38933985e-02f, -5.10722063e-02f, 1.17040649e-01f, -4.31352518e-02f, 3.77472043e-02f, -1.60007328e-02f, -7.70759508e-02f, 3.49117890e-02f,
  -4.16270435e-01f, 3.18136156e-01f, -1.93707481e-01f, -5.45471162e-02f, 1.53121412e-01f, 1.32946476e-01f, 2.19946191e-01f, 1.11404717e-01f, 6.83215111e-02f, -1.10830545e-01f,
  3.10369823e-02f, -2.09998898e-02f, -7.88540114e-03f, -9.13150683e-02f, -1.05238833e-01f, 1.10012172e-02f, -5.79563715e-02f, -1.87879190e-01f, -1.29038543e-02f, 6.50132522e-02f,
  2.12946497e-02f, 2.26707868e-02f, -1.76822186e-01f, 9.54003073e-03f, 5.66015299e-03f, -7.71869421e-02f, -8.54988694e-02f, -1.29526719e-01f, 9.42373276e-02f, -2.27482691e-01f,
  2.81309754e-01f, -1.57390118e-01f, 1.40544221e-01f, 7.20000789e-02f, -3.84831838e-02f, 6.09836541e-02f, 4.55975026e-01f, 1.98668435e-01f, 2.81298384e-02f, 9.24311876e-02f,
  -3.74061942e-01f, -4.87438649e-01f, -4.64944720e-01f, -3.52061272e-01f, -1.68458655e-01f, 4.45091069e-01f, 3.25674057e-01f, 5.27948141e-02f, 8.95919278e-02f, 1.42589435e-01f,
  8.16730484e-02f, 2.30986685e-01f, 9.67160538e-02f, -4.27285731e-02f, 2.61858385e-02f, 6.47514537e-02f, 8.33576173e-02f, -1.34514868e-01f, -2.66888738e-01f, -1.47087634e-01f,
  2.93235689e-01f, -3.85291815e-01f, 1.40511006e-01f, -2.72089481e-01f, -2.87901629e-02f, 5.95803931e-02f, 2.18710169e-01f, 1.08224869e-01f, -1.81742609e-01f, -4.91972305e-02f,
  -2.12915242e-01f, -2.98004746e-01f, -2.63459623e-01f, -1.38055936e-01f, -1.95055467e-03f, -4.12990451e-02f, -1.48894593e-01f, -1.09757535e-01f, -1.48766592e-01f, -7.99170956e-02f,
  -3.94418389e-01f, -2.65887976e-01f, -2.52040297e-01f, 6.93846401e-03f, -1.01971231e-01f, -1.22586988e-01f, -1.07172713e-01f, -2.51980752e-01f, -1.48074612e-01f, 2.04935595e-01f,
  9.61103514e-02f, 1.01868980e-01f, -4.68734689e-02f, 1.27910867e-01f, 3.68547030e-02f, 1.60343926e-02f, -1.38644844e-01f, 1.49354408e-03f, -1.12309881e-01f, -8.13469570e-03f,
  -3.21850590e-02f, 9.32649150e-02f, 1.01658307e-01f, 6.21567406e-02f, -7.02272132e-02f, 2.15125401e-02f, -6.39984682e-02f, -8.09591562e-02f, -3.42784375e-02f, 3.16023938e-02f,
  5.95383197e-02f, 1.04726069e-01f, 6.75025210e-03f, 1.45333529e-01f, 6.51528910e-02f, -8.39339718e-02f, 1.46187574e-01f, -8.14092159e-02f, -1.70467924e-02f, -3.63689810e-02f,
  4.03574347e-01f, -4.62902963e-01f, 4.20275182e-01f, -4.65711057e-02f, 1.21058412e-01f, -2.52591103e-01f, 8.62608179e-02f, -8.92855227e-02f, 1.58039143e-03f, -1.65161967e-01f,
  -3.34069103e-01f, -9.79887396e-02f, -1.30726799e-01f, -8.34574923e-02f, 2.29355738e-01f, 7.25897700e-02f, 5.28183654e-02f, 6.09206930e-02f, 5.05725443e-02f, 7.74945319e-02f,
  -6.04335852e-02f, 1.06681623e-01f, 2.34903902e-01f, 1.45778805e-01f, 1.06985696e-01f, 1.14740431e-01f, 2.63343006e-01f, 2.34263539e-02f, 1.19912080e-01f, 7.14552343e-01f,
  -5.39991319e-01f, -2.88237810e-01f, 2.89699912e-01f, -1.80382356e-01f, -2.08465010e-01f, -2.92493105e-01f, -4.44877952e-01f, -4.10802811e-01f, -2.97632009e-01f, -1.43783540e-01f,
  -1.66664291e-02f, 3.11048597e-01f, 2.61079252e-01f, 2.55044550e-01f, 8.66735503e-02f, -2.78014522e-02f, 1.08126491e-01f, 3.38566840e-01f, 2.48664901e-01f, -1.44884475e-02f,
  4.63275313e-02f, 6.33403286e-02f, 9.41591561e-02f, 2.45046876e-02f, 4.89652045e-02f, 1.22061968e-01f, 1.01257622e-01f, 1.41366664e-02f, 6.44615963e-02f, 2.36441165e-01f,
  4.36078638e-01f, -3.51356715e-01f, 8.78500640e-02f, 3.15502775e-03f, 4.21874821e-02f, -2.14075938e-01f, -1.33852243e-01f, 3.63693349e-02f, -1.63009986e-01f, -5.05345650e-02f,
  -1.88518949e-02f, -1.40490100e-01f, -5.00220545e-02f, 5.90592250e-02f, 2.42033806e-02f, -1.48056880e-01f, 7.80875012e-02f, -1.92489587e-02f, -8.55030790e-02f, -5.79397082e-02f,
  4.40496579e-02f, -5.93923442e-02f, 8.20388049e-02f, -1.07029103e-01f, -3.22461464e-02f, 1.38527989e-01f, -9.16590989e-02f, -1.53545752e-01f, -8.04048404e-02f, -3.37686972e-03f,
  -2.68579219e-02f, 1.23994902e-01f, -2.50258557e-02f, 4.00378220e-02f, 1.45694256e-01f, -3.26485969e-02f, -3.99956964e-02f, 6.45122677e-02f, 1.29516646e-01f, 8.01917240e-02f,
  -6.67319149e-02f, -2.57359650e-02f, 5.11740781e-02f, -1.85993224e-01f, 7.97116756e-02f, 7.31217628e-03f, 2.63966490e-02f, 3.30019519e-02f, -4.79414575e-02f, -1.27044439e-01f,
  -3.19857262e-02f, -3.92474867e-02f, 1.16555728e-01f, -5.58841415e-02f, -1.87922772e-02f, 6.29160702e-02f, -4.34532948e-02f, 5.40515035e-02f, 1.96077675e-01f, -9.20248106e-02f,
  7.80287609e-02f, 3.45967598e-02f, -6.90834522e-02f, -1.46151960e-01f, -9.74330455e-02f, -6.84287176e-02f, -5.72690405e-02f, -8.19749609e-02f, -5.97136281e-02f, -5.00383675e-02f,
  -1.04740798e-01f, -9.25510377e-02f, 8.60824734e-02f, 6.36918768e-02f, -3.27626057e-02f, -6.89731762e-02f, 8.47241580e-02f, 7.34967068e-02f, 1.41375130e-02f, -1.39044791e-01f,
  -1.12477049e-01f, -9.97803509e-02f, 2.64454838e-02f, 3.65917571e-02f, -5.77843040e-02f, -1.18098343e-02f, 2.15076208e-01f, 3.52821872e-02f, -9.86740552e-03f, -2.95870770e-02f,
  -2.50255316e-01f, 1.46725737e-02f, 7.49109387e-02f, 1.36551484e-01f, 2.63916880e-01f, 3.15865934e-01f, 2.53156096e-01f, 1.95770487e-01f, 2.29067251e-01f, 6.79002553e-02f,
  7.86837861e-02f, 2.02344105e-01f, 1.89717308e-01f, 1.80465564e-01f, 1.23507254e-01f, 1.62524521e-01f, 2.11688191e-01f, -2.39672419e-03f, 1.59213319e-02f, 1.25284657e-01f,
  3.08398679e-02f, -3.70076783e-02f, -1.67975128e-01f, 9.41110123e-03f, 6.04509283e-03f, -3.67403924e-02f, 1.39326900e-01f, 6.95478469e-02f, 6.65845945e-02f, -1.42282411e-01f,
  1.01093650e-02f, 7.81464018e-03f, -7.44340718e-02f, 9.04532596e-02f, -4.89835851e-02f, -1.19026966e-01f, 5.19415103e-02f, -6.50378391e-02f, 6.36461005e-02f, 7.38449395e-02f,
  1.07922703e-02f, -8.65492821e-02f, 4.43784408e-02f, 2.15221737e-02f, 1.71298951e-01f, 8.19093212e-02f, 1.45429149e-01f, 1.55906364e-01f, 1.03325784e-01f, 4.79023978e-02f,
  8.92730951e-02f, 1.97452888e-01f, 2.13109419e-01f, 1.67117551e-01f, 4.60018739e-02f, 1.71952769e-01f, 1.18369639e-01f, 1.87428351e-02f, 2.04240531e-01f, 1.78344384e-01f,
  1.50127381e-01f, 3.94634902e-02f, 8.38138014e-02f, 1.03304029e-01f, 1.60840884e-01f, 8.89523178e-02f, 3.72640006e-02f, 1.12033479e-01f, 1.60229027e-01f, 6.08941875e-02f,
  1.03280932e-01f, 1.00877143e-01f, 1.63840637e-01f, -8.47458616e-02f, -9.33047757e-02f, -7.44660273e-02f, -1.10016003e-01f, 8.01460445e-02f, 1.36691332e-01f, 6.75240308e-02f,
  2.75169536e-02f, -4.87951450e-02f, -6.52480572e-02f, 4.17406298e-02f, 9.57169291e-03f, 5.98008744e-02f, 5.41249150e-03f, 1.02341115e-01f, -7.38034472e-02f, -1.34629741e-01f,
  1.94518745e-01f, 7.86343664e-02f, -1.70981884e-01f, -7.18500242e-02f, -1.47470906e-01f, -3.65689397e-02f, -5.72458236e-03f, -7.97513127e-02f, -7.47516155e-02f, 4.13906723e-02f,
  -4.60422821e-02f, -1.33103833e-01f, -1.16940975e-01f, 2.72353948e-03f, -1.79883428e-02f, 1.68657731e-02f, -1.43504888e-02f, -5.02747335e-02f, -7.81787261e-02f, 3.20830159e-02f,
  -1.52486665e-02f, 7.92975724e-02f, -2.09314507e-02f, -5.78759946e-02f, 6.46519735e-02f, -3.66037749e-02f, -1.57442018e-02f, -7.82379135e-02f, -2.29896605e-02f, -2.86329240e-02f,
  3.97368312e-01f, 5.40659502e-02f, 2.41920888e-01f, 1.52780846e-01f, -1.54442051e-02f, 1.41884014e-01f, 1.26735494e-01f, 1.23688661e-01f, 1.32585072e-03f, 1.39380023e-01f,
  1.60525844e-01f, -6.86036572e-02f, -5.56196608e-02f, 9.23380479e-02f, 3.21265459e-02f, -5.81236277e-03f, -9.77774709e-02f, 1.33925438e-01f, 2.74788365e-02f, 5.70284985e-02f,
  -1.06889658e-01f, 2.62684878e-02f, 3.62908132e-02f, -2.99388450e-02f, -2.27704197e-02f, -5.36161400e-02f, 1.43186674e-02f, -3.00922096e-02f, -3.81709523e-02f, -8.20373595e-02f,
  -1.85789615e-02f, 1.64297953e-01f, 6.03456050e-02f, -2.66990848e-02f, 4.67903726e-02f, 1.30884916e-01f, 4.95772623e-02f, 3.39311510e-02f, -1.12433702e-01f, 1.49945496e-02f,
  3.59983556e-02f, 3.58864889e-02f, 7.98209682e-02f, -2.81299558e-02f, -4.41262405e-03f, 8.34189132e-02f, 1.47007093e-01f, -3.97246704e-02f, -1.02863520e-01f, 1.27050459e-01f,
  4.80266139e-02f, 9.54196602e-02f, 3.98397818e-02f, -6.54249918e-03f, 3.70805375e-02f, -2.91676093e-02f, 5.66393845e-02f, 7.86283761e-02f, -5.92051493e-03f, 4.39393967e-02f,
  4.98143435e-02f, 2.50109248e-02f, 1.57967940e-01f, 1.51165083e-01f, 1.69379145e-01f, -4.40123193e-02f, -3.12722549e-02f, -6.44118860e-02f, 9.60502774e-02f, 6.28374442e-02f,
  -9.00933798e-03f, 9.16504562e-02f, 1.70471013e-01f, -7.25709274e-02f, 9.82196331e-02f, 4.62188125e-02f, -1.16538722e-02f, 3.86757664e-02f, 1.05495490e-01f, 6.67804852e-02f,
  1.34551883e-01f, -1.25499204e-01f, -1.01722376e-02f, -7.68688321e-02f, 3.26941535e-02f, 6.84487894e-02f, -5.76533489e-02f, 4.04572003e-02f, -3.57724763e-02f, -1.75936203e-02f,
  -1.07908048e-01f, 2.23824486e-01f, -9.11539793e-02f, 8.12334754e-03f, -3.89685631e-02f, -9.35863145e-03f, 5.49350120e-02f, 5.99011779e-03f, -9.63786542e-02f, -3.97491194e-02f,
  3.19437981e-02f, 5.68253472e-02f, 5.89336455e-02f, 3.20385247e-02f, 8.54527727e-02f, -1.05696917e-01f, 4.30423301e-03f, 1.05517492e-01f, 4.69839647e-02f, 3.87573689e-02f,
  2.73259971e-02f, 1.33395335e-02f, -3.58813093e-03f, -6.68915287e-02f, -1.03937522e-01f, -1.19482100e-01f, -1.01317793e-01f, -9.06404406e-02f, -6.60589933e-02f, -3.39238942e-02f,
  -1.11802720e-01f, 2.99586236e-01f, -5.78390732e-02f, -1.13999486e-01f, -4.99831736e-02f, 1.57964844e-02f, 1.89202189e-01f, 1.45882098e-02f, 3.58696398e-03f, 1.73369527e-01f,
  1.56241342e-01f, -7.34191090e-02f, -8.62840265e-02f, -3.86429206e-02f, 3.72906849e-02f, 8.44993144e-02f, -1.47099525e-01f, -1.25862390e-01f, -1.42472669e-01f, -5.96740097e-02f,
  1.60304278e-01f, 2.29232952e-01f, 9.26206335e-02f, -7.47096017e-02f, -2.40612607e-02f, 6.38230816e-02f, 1.49558336e-01f, 1.62691146e-01f, 1.38822734e-01f, -9.77548808e-02f,
  2.02876359e-01f, -1.20775457e-02f, -5.34473471e-02f, -1.03332877e-01f, 8.45302269e-02f, 9.70171392e-03f, 2.81103887e-02f, 8.51102397e-02f, 6.09448850e-02f, 3.26283202e-02f,
  -1.31911173e-01f, -6.56543896e-02f, 7.95542300e-02f, 1.16340131e-01f, 1.49981990e-01f, 2.64268508e-03f, -1.27146810e-01f, -1.65326655e-01f, -1.73325613e-01f, -9.89007391e-03f,
  -1.40310869e-01f, -5.65478429e-02f, -2.07370352e-02f, -4.28777002e-02f, -3.47072608e-03f, -1.38926268e-01f, -5.39491586e-02f, -1.67710297e-02f, -1.14701606e-01f, -4.01428640e-02f,
  -1.52333289e-01f, 4.32982408e-02f, -8.16608071e-02f, 1.79018676e-02f, 1.94446463e-02f, 3.35234962e-02f, 1.98270723e-01f, 1.09811641e-01f, 1.10967852e-01f, 1.46419734e-01f,
  -7.31190518e-02f, 6.52630404e-02f, 2.37292007e-01f, 1.20213732e-01f, 4.74063419e-02f, 1.30157813e-01f, 1.74884006e-01f, 2.75500100e-02f, 4.74687330e-02f, 1.32006824e-01f,
  1.12671264e-01f, 4.50305380e-02f, 1.33086331e-02f, 1.45495132e-01f, 5.77485301e-02f, -1.61393844e-02f, 8.14805478e-02f, 1.57399073e-01f, -1.40870316e-02f, -2.32603345e-02f,
  3.58839691e-01f, -9.61567611e-02f, -1.43463099e-02f, -2.07559839e-01f, -4.07697447e-02f, 6.37389868e-02f, 3.69720533e-02f, -7.59216677e-03f, 1.86669618e-01f, 7.35873803e-02f,
  -1.97391044e-02f, 3.04772891e-02f, 1.44571200e-01f, 5.00110723e-02f, 1.16327167e-01f, 1.77694168e-02f, -5.96230179e-02f, -1.74894780e-01f, -7.52477720e-02f, 1.19812349e-02f,
  -7.31690899e-02f, -9.84554663e-02f, 2.17573233e-02f, -2.14055069e-02f, 2.71850149e-03f, -3.02122422e-02f, 8.21516663e-02f, 2.42372174e-02f, -3.33148763e-02f, 1.06917530e-01f,
  4.19281095e-01f, -1.17850192e-01f, 3.27281862e-01f, 3.30420464e-01f, -3.85181069e-01f, -3.56584311e-01f, -4.99091238e-01f, -2.08927870e-01f, 8.82535875e-02f, 5.38103050e-03f,
  -2.22715214e-01f, -1.15561463e-01f, 3.15613747e-01f, -3.60273868e-02f, 2.40632948e-02f, -1.65902808e-01f, 5.35115339e-02f, 1.40217558e-01f, -1.24589510e-01f, -5.90337217e-01f,
  -3.51747602e-01f, 1.11354806e-01f, 1.61509842e-01f, -3.56111303e-02f, 4.57214229e-02f, -3.47542553e-03f, 1.32006183e-01f, 1.51181951e-01f, -1.19758211e-01f, 1.89232036e-01f,
  1.27105772e-01f, 1.28526121e-01f, -2.27789834e-01f, 6.79534301e-02f, 6.44348413e-02f, -7.98490364e-03f, -5.30017391e-02f, 1.34507731e-01f, -1.49436086e-01f, 6.15849905e-02f,
  -3.29245254e-02f, -6.79885596e-02f, 8.90460238e-02f, -2.65892711e-03f, -2.38484200e-02f, -7.60567263e-02f, -6.14272605e-04f, 8.90434161e-02f, 8.52708966e-02f, -1.20891906e-01f,
  -3.33948821e-01f, -1.07111380e-01f, 2.47886702e-02f, -1.42554387e-01f, -9.05101970e-02f, -3.13122757e-03f, -1.80516168e-01f, -1.03152663e-01f, 1.48562109e-02f, 3.27479690e-02f,
  -1.79645240e-01f, 1.07693806e-01f, -1.07811458e-01f, -5.73500916e-02f, -1.24066435e-01f, -9.16660950e-03f, -3.51093598e-02f, -1.80649444e-01f, -9.55690816e-02f, -2.19921887e-01f,
  -8.15052465e-02f, -2.00399339e-01f, -5.83039820e-02f, 6.93519413e-02f, 5.75499013e-02f, -1.76988263e-02f, -1.19304597e-01f, 1.92400757e-02f, 5.67660183e-02f, 6.23937435e-02f,
  4.85039242e-02f, 1.37351304e-01f, 1.03404991e-01f, -3.38252634e-02f, -1.17926560e-01f, 1.06721371e-01f, -1.45507110e-02f, -1.81894228e-01f, -2.49455292e-02f, -1.52215019e-01f,
  2.76415080e-01f, 9.90965962e-02f, 3.33096720e-02f, 1.55217322e-02f, -7.86527842e-02f, -4.81785759e-02f, -3.36834826e-02f, -2.27284394e-02f, 1.87215835e-01f, -7.55622610e-03f,
  -1.11933090e-01f, 8.29515141e-03f, 4.71151546e-02f, 5.34206745e-04f, -2.11613059e-01f, -1.67758480e-01f, -2.72806287e-01f, -2.15005949e-02f, -1.17161497e-02f, -1.08912230e-01f,
  1.42339393e-02f, -1.17877819e-01f, -2.12643240e-02f, 8.66946131e-02f, 5.23279868e-02f, 6.36654496e-02f, -6.39085472e-02f, -1.53028637e-01f, -1.36838621e-02f, -2.30731204e-01f,
  4.92234826e-01f, 1.65228561e-01f, -3.11670780e-01f, 2.42488325e-01f, 1.34263054e-01f, 1.34660318e-01f, 2.32314155e-01f, 1.84399903e-01f, 7.30251074e-02f, -1.52496640e-02f,
  4.24153097e-02f, -2.03777090e-01f, -3.55923057e-01f, -3.64599824e-01f, -2.77355134e-01f, -2.23971739e-01f, -3.02132785e-01f, -3.69313568e-01f, -1.63720995e-01f, 2.48467937e-01f,
  2.97571421e-01f, 5.52508116e-01f, 2.71627963e-01f, 4.89731431e-02f, 6.06301390e-02f, -2.42791951e-01f, 7.09563121e-02f, 7.09588751e-02f, -1.79400191e-01f, -5.65311372e-01f,
  -3.10485274e-01f, 2.65525222e-01f, -1.49810925e-01f, 6.42848611e-02f, 1.75926507e-01f, 7.24468380e-02f, 8.80995616e-02f, 9.64517593e-02f, -3.86199243e-02f, -3.13532241e-02f,
  -2.43158359e-02f, -8.96053687e-02f, -9.34631657e-03f, -9.97319967e-02f, 1.87304825e-01f, 6.77597001e-02f, 1.40576467e-01f, -6.17238618e-02f, -3.06182325e-01f, 2.69609075e-02f,
  4.66048950e-03f, 9.17103514e-02f, 8.07872340e-02f, 4.97795567e-02f, -3.52081284e-02f, -1.47680104e-01f, -2.95088161e-03f, -9.14448872e-02f, -1.98958188e-01f, -1.78019069e-02f,
  1.03800803e-01f, -2.10928366e-01f, -6.20443150e-02f, 1.19622469e-01f, 1.48617044e-01f, -4.45707627e-02f, -1.29112586e-01f, -1.13669708e-01f, -4.30161767e-02f, -7.81001803e-03f,
  -1.72244444e-01f, -1.55418560e-01f, -1.33323014e-01f, -7.52816051e-02f, -2.21985266e-01f, -1.84932258e-02f, -1.71950117e-01f, -1.25131533e-01f, -1.22836180e-01f, 1.45148352e-01f,
  6.77159652e-02f, -5.44441193e-02f, 1.00906163e-01f, 2.87293326e-02f, -7.09783658e-02f, -6.43304214e-02f, 1.05602266e-02f, -8.48678574e-02f, 2.86084972e-02f, 2.40823299e-01f,
  1.73713118e-01f, 1.80427954e-02f, -1.90994278e-01f, -1.20431378e-01f, -4.36950549e-02f, -1.60764813e-01f, -1.05226003e-01f, -1.25506073e-01f, -1.73721805e-01f, -7.92075917e-02f,
  -1.54350802e-01f, -1.82401091e-01f, -2.29746159e-02f, -1.80893719e-01f, 6.78139552e-02f, -8.54241326e-02f, -1.08234115e-01f, -1.56297073e-01f, -2.45166332e-01f, -2.03130133e-02f,
  1.99142043e-02f, 4.60426025e-02f, 6.14383556e-02f, -1.35286570e-01f, 4.11120355e-02f, -5.10311946e-02f, -9.77649074e-03f, -2.81648468e-02f, -9.92247984e-02f, 1.69708684e-01f,
  -2.58083671e-01f, -1.94960207e-01f, -2.30211243e-01f, -3.15223753e-01f, -2.87525207e-01f, -2.91021675e-01f, -2.92027384e-01f, -1.38114303e-01f, -3.42668705e-02f, -1.78122595e-01f,
  -2.08497256e-01f, 1.65200997e-02f, -3.54578376e-01f, 7.98915606e-03f, 1.14948392e-01f, -8.36039558e-02f, -1.83163241e-01f, 1.01970300e-01f, 2.59201288e-01f, 4.99730378e-01f,
  1.62185028e-01f, 2.47040600e-01f, 3.78376424e-01f, 2.18837649e-01f, 4.38939333e-02f, 6.93923654e-03f, -7.59802992e-03f, -3.23650651e-02f, -7.66285649e-03f, -2.31552601e-01f,
  -1.73934996e-01f, 2.84874216e-02f, 1.51761532e-01f, 1.16197444e-01f, -1.15038352e-02f, 8.05065781e-02f, -2.82540582e-02f, -1.86525173e-02f, -1.50708392e-01f, -1.72473013e-01f,
  -2.39443153e-01f, 1.18223729e-03f, -2.86880195e-01f, 5.83127402e-02f, 7.61303157e-02f, 1.02777831e-01f, 1.24197058e-01f, 1.55306727e-01f, 4.47553582e-03f, 6.47459477e-02f,
  -1.00623921e-01f, -9.45380628e-02f, -2.83136874e-01f, -5.92613183e-02f, 1.41180068e-01f, -2.90718060e-02f, 5.75605109e-02f, 9.71785784e-02f, 9.93016213e-02f, -2.32675567e-01f,
  7.44185820e-02f, 4.39131074e-02f, -4.76687886e-02f, -1.63827017e-01f, -1.76872835e-02f, -3.55205797e-02f, 3.47299539e-02f, 3.78994867e-02f, -1.31420925e-01f, -1.46533668e-01f,
  -1.02128237e-01f, -1.75236072e-02f, 9.29942075e-03f, 6.64609969e-02f, 1.03246102e-05f, 7.12709734e-03f, -4.55023386e-02f, 1.40186235e-01f, 1.21744201e-01f, 1.10683315e-01f,
  4.53022803e-04f, 1.35186287e-02f, -1.25360824e-02f, 2.91430708e-02f, 3.85552272e-02f, 4.80059125e-02f, 4.79393080e-02f, 1.91781633e-02f, 7.11421445e-02f, 1.48769440e-02f,
  -9.32310745e-02f, 3.29859674e-01f, -3.08363527e-01f, 5.55970445e-02f, -1.11135952e-01f, 5.70338964e-02f, -1.55138105e-01f, -3.33222980e-03f, -1.31878525e-01f, -4.49361512e-04f,
  -4.83834222e-02f, -4.33504814e-03f, -1.76298976e-01f, 8.68166834e-02f, -1.07180458e-02f, -1.38054520e-01f, -1.28484741e-01f, -2.65844971e-01f, -7.06013739e-02f, -2.98711620e-02f,
  -1.97789639e-01f, -2.14750975e-01f, -4.63837028e-01f, -3.58902454e-01f, -2.01491177e-01f, -2.54960984e-01f, -2.62334287e-01f, -3.18866223e-02f, -1.79393306e-01f, -3.74265939e-01f,
  2.40433648e-01f, -4.84830290e-01f, -6.06527664e-02f, 1.55785114e-01f, 2.06291899e-01f, 2.58171201e-01f, -3.69849131e-02f, 8.00712407e-02f, 2.00722381e-01f, -1.66778639e-02f,
  -4.11195531e-02f, 5.98251447e-02f, 1.36233792e-01f, -2.04592887e-02f, 1.21676467e-01f, -3.00777908e-02f, 2.22290028e-02f, 9.64657888e-02f, 1.84605375e-01f, -1.86326783e-02f,
  6.93317428e-02f, 3.79781723e-02f, -1.40232937e-02f, 3.28801721e-02f, -1.63207009e-01f, -7.90905673e-03f, 1.08644161e-02f, -1.28664345e-01f, -1.96818411e-01f, -1.81525081e-01f,
  -1.82821333e-01f, -5.13230525e-02f, 9.37948152e-02f, -1.07808091e-01f, -8.83265138e-02f, -8.62033740e-02f, -2.43561175e-02f, 2.53152605e-02f, -7.13078231e-02f, -1.10132433e-01f,
  5.66376299e-02f, 3.35899554e-02f, 2.14822050e-02f, 4.88574477e-03f, -1.27930984e-01f, -1.29057229e-01f, -9.24864709e-02f, -1.00797750e-01f, -5.86137064e-02f, -2.52521411e-02f,
  -2.78103985e-02f, 5.60898520e-02f, -5.49642891e-02f, 6.64077029e-02f, 2.04986557e-02f, 1.13167040e-01f, -1.06716640e-01f, 6.09486625e-02f, 1.66458953e-02f, 4.89738621e-02f,
  -1.68496165e-02f, 3.35879140e-02f, -6.88805580e-02f, 5.57448491e-02f, 5.99702001e-02f, 2.52060369e-02f, 7.53976479e-02f, 4.10261378e-03f, 1.14198439e-01f, 3.88185643e-02f,
  2.87273340e-02f, 7.21678734e-02f, 2.45322119e-02f, -1.72381569e-02f, -2.96050105e-02f, -1.11222651e-03f, -3.95931602e-02f, -9.94243994e-02f, -9.39801112e-02f, 7.90456012e-02f,
  1.69568434e-02f, -9.94124636e-02f, -1.95180587e-02f, -9.84980613e-02f, -5.81042022e-02f, -7.54663348e-02f, -1.32058505e-02f, -1.16039239e-01f, -8.24096501e-02f, -1.16994247e-01f,
  -2.22813189e-02f, 1.43999621e-01f, 1.08137377e-01f, 6.57467544e-02f, -7.36572146e-02f, -1.52965412e-01f, 1.38119966e-01f, -5.26123233e-02f, -5.22420406e-02f, -2.81501357e-02f,
  5.01562878e-02f, -8.27588364e-02f, -1.53437987e-01f, -6.37127981e-02f, 9.80272815e-02f, 9.70657989e-02f, 3.66297700e-02f, 1.12605646e-01f, -1.08138129e-01f, 4.24289750e-03f,
  -8.82519130e-03f, -1.27334648e-03f, 1.85900647e-02f, 1.01531884e-02f, 1.21860690e-01f, 3.84408375e-03f, 4.49128933e-02f, -7.36189857e-02f, 7.87873566e-02f, 6.46182150e-02f,
  -6.62558913e-01f, -1.21817074e-03f, 1.11082405e-01f, -2.12981194e-01f, 1.14024378e-01f, 1.29878640e-01f, 2.06489846e-01f, 5.33019006e-02f, -9.09934640e-02f, -1.71330962e-02f,
  4.56737261e-03f, -1.10602468e-01f, 4.45671119e-02f, -7.38733634e-02f, -1.03560112e-01f, 2.10028574e-01f, 2.82233298e-01f, -2.60430202e-02f, -5.17838970e-02f, -5.72281331e-02f,
  1.07765593e-01f, -1.46783277e-01f, -2.94119865e-01f, -1.12852976e-01f, 1.20845795e-01f, 2.05115695e-02f, 1.11921079e-01f, -1.22818030e-01f, 1.57949939e-01f, 1.25871643e-01f,
  3.17552805e-01f, -3.21032405e-01f, -6.53701425e-02f, -1.73566982e-01f, -1.50846764e-01f, -1.31649077e-01f, -8.88483599e-03f, -1.87943190e-01f, -1.23324834e-01f, -9.69896019e-02f,
  -2.44001336e-02f, -7.19512925e-02f, 3.61709967e-02f, 5.13835736e-02f, -3.09507623e-02f, 4.76098480e-03f, -6.43980652e-02f, -3.00801247e-02f, 9.42886621e-02f, -1.39964102e-02f,
  1.28181413e-01f, 3.46356556e-02f, 2.38284026e-03f, 7.60543440e-03f, -8.51600915e-02f, 6.42410964e-02f, 2.48876624e-02f, 1.02966493e-02f, 4.04995494e-02f, 1.80875994e-02f,
  6.99054822e-03f, 2.72003710e-02f, -4.77050580e-02f, -8.64394680e-02f, 2.28483006e-02f, 1.03704631e-01f, -2.39774846e-02f, -9.90712345e-02f, 5.12133725e-03f, 3.00597697e-02f,
  -9.65713263e-02f, 1.09891839e-01f, 2.02698726e-02f, -8.99813697e-02f, -9.51873511e-02f, -7.57330656e-02f, 4.38691676e-02f, -3.90727557e-02f, -8.51215422e-02f, -1.66482955e-01f,
  -1.36163801e-01f, 4.03831489e-02f, -5.85788302e-02f, 3.34174484e-02f, 2.53861994e-02f, -7.87932146e-03f, 5.21390364e-02f, -4.15899325e-03f, -7.14927241e-02f, 8.23225603e-02f,
  1.90330431e-01f, -6.17643036e-02f, 2.05677167e-01f, 2.64008958e-02f, -9.49621275e-02f, -9.61156413e-02f, -9.45931226e-02f, -4.67156842e-02f, -6.56036288e-02f, 5.09627834e-02f,
  -3.97003107e-02f, -1.62442494e-02f, -6.64820597e-02f, 2.56883521e-02f, -9.90204960e-02f, -3.14204283e-02f, -5.21327890e-02f, -3.07239816e-02f, 7.71363825e-02f, 2.23275516e-02f,
  -2.60951202e-02f, 8.66282210e-02f, 8.06639269e-02f, 1.73581243e-01f, 7.40186423e-02f, 1.11989453e-01f, -2.34471448e-02f, 1.34045988e-01f, 3.70534579e-03f, 7.42746294e-02f,
  6.19369149e-01f, -3.40397060e-01f, 3.00896820e-02f, 2.25450441e-01f, -4.75915074e-02f, -7.33935311e-02f, -2.29994267e-01f, -1.00407280e-01f, 9.43404809e-03f, -1.10603221e-01f,
  1.72110293e-02f, 2.04279035e-01f, 1.41274899e-01f, 2.16096818e-01f, 6.61489889e-02f, 4.16473398e-04f, -1.67564998e-04f, 2.18195304e-01f, 2.76702374e-01f, -1.75214428e-02f,
  -1.88582152e-01f, 1.21408817e-03f, 1.95981890e-01f, -4.00503576e-02f, -1.78827196e-01f, 4.89151143e-02f, 1.36189908e-02f, -7.15447813e-02f, -8.75149220e-02f, -2.46658668e-01f,
  -2.91099548e-01f, -3.99666578e-02f, 1.32986963e-01f, -7.84196928e-02f, -2.49694538e-04f, -4.32045758e-02f, 6.79117739e-02f, 2.12774780e-02f, -1.03808515e-01f, -1.60411760e-01f,
  -6.95025325e-02f, -4.54231910e-02f, -8.90537631e-03f, -1.42864048e-01f, -1.19421370e-02f, 4.30372581e-02f, -8.94947872e-02f, -9.87418517e-02f, 5.10965176e-02f, -6.04205132e-02f,
  -1.18576452e-01f, 3.54603790e-02f, -4.78913449e-02f, 6.39503375e-02f, 6.85895905e-02f, 1.81016222e-01f, -1.98972151e-02f, 4.03084978e-02f, 1.21132899e-02f, -5.69683313e-02f,
  6.29888177e-02f, 3.82332839e-02f, 8.78992230e-02f, 1.35051593e-01f, 1.23057142e-01f, 6.80603683e-02f, 4.51935232e-02f, -2.59482339e-02f, 1.78040609e-01f, 2.42806971e-02f,
  -1.86851829e-01f, 1.14317708e-01f, 1.03004184e-02f, 7.02699088e-03f, 3.22164334e-02f, 4.21362109e-02f, -1.15351059e-01f, -4.99876775e-03f, 5.72383143e-02f, 3.46097499e-02f,
  1.09595940e-01f, -1.63641825e-01f, -3.06194983e-02f, -1.42670259e-01f, -2.05453977e-01f, -1.11074902e-01f, -1.60745736e-02f, 1.78920070e-03f, 4.81732674e-02f, -1.22527860e-01f,
  -2.94988483e-01f, 4.44849968e-01f, 5.13664633e-02f, 9.65343490e-02f, -3.43465358e-02f, -8.50545391e-02f, 1.29505768e-01f, 3.17084976e-02f, -1.50825948e-01f, -1.76867902e-01f,
  -1.34763047e-01f, 4.62697186e-02f, -7.57937431e-02f, -7.14732148e-03f, 1.15802698e-01f, -2.03784667e-02f, 6.80156425e-02f, 4.27885875e-02f, -6.01181434e-03f, -2.09467962e-01f,
  -1.08430535e-01f, 2.82382406e-02f, 1.18373759e-01f, 1.17839821e-01f, 4.99852709e-02f, 2.45712280e-01f, 5.22751510e-02f, -3.59312929e-02f, 1.83763981e-01f, 1.36848271e-01f,
  -7.37864822e-02f, -6.43607974e-01f, -3.78811479e-01f, -1.19544953e-01f, -1.31008238e-01f, 8.62718076e-02f, -7.47671425e-02f, -6.69710413e-02f, 5.94570488e-03f, -2.55918860e-01f,
  -2.62320161e-01f, -1.99450761e-01f, -3.64248186e-01f, -2.60634392e-01f, -4.53086644e-02f, -1.63520783e-01f, -1.06022634e-01f, -8.64686668e-02f, 1.92150995e-01f, 1.23300835e-01f,
  6.21817634e-02f, -1.45640090e-01f, -8.58609751e-02f, -1.58840463e-01f, -2.39771560e-01f, -9.08002704e-02f, -2.50896871e-01f, -1.81717306e-01f, -1.54299781e-01f, -4.04885709e-01f,
  -2.08552971e-01f, 5.22659384e-02f, 1.74294010e-01f, 1.97744165e-02f, 7.01703597e-03f, -3.76736633e-02f, 7.02332482e-02f, 1.89233031e-02f, -1.78368017e-02f, 5.21803237e-02f,
  3.36401649e-02f, -6.89909458e-02f, 4.21323702e-02f, -2.87323296e-02f, 1.35976523e-01f, 3.52043360e-02f, 4.30103913e-02f, 4.52493951e-02f, 1.40056647e-02f, 6.35523126e-02f,
  -1.26083300e-01f, 8.16463828e-02f, -4.30954155e-03f, 1.98935509e-01f, 2.22014427e-01f, 6.75750524e-02f, 7.04768747e-02f, 1.83915094e-01f, 1.01591900e-01f, 7.44941533e-02f,
  -6.96995929e-02f, -1.17277279e-01f, 1.51239350e-01f, -7.20724929e-03f, 7.75243789e-02f, 1.19683027e-01f, 8.01983848e-02f, 8.75140652e-02f, 1.20251179e-01f, -2.14197505e-02f,
  7.80455768e-02f, -4.41860855e-02f, 1.04899049e-01f, 2.77796704e-02f, -5.65304002e-03f, -1.26324162e-01f, -6.84460104e-02f, 3.48943062e-02f, 7.66030625e-02f, -2.20911764e-02f,
  1.76525488e-01f, 6.36244044e-02f, -1.83327541e-01f, 6.07025698e-02f, -8.34027305e-02f, 9.06111449e-02f, -9.05006602e-02f, 3.30622979e-02f, 1.26623092e-02f, -1.23627044e-01f,
  -3.22866261e-01f, 1.89085096e-01f, 2.97440588e-03f, -1.34338066e-01f, 7.47343600e-02f, -1.35102561e-02f, 8.27883929e-02f, 3.17704231e-02f, 7.69921467e-02f, 2.07301199e-01f,
  3.81100774e-02f, 3.29182763e-03f, 4.04325686e-02f, 1.22054420e-01f, 1.89102098e-01f, 2.47897357e-01f, 1.33819550e-01f, 4.50762641e-03f, -8.06098804e-02f, -7.87121132e-02f,
  -7.41594359e-02f, 8.56096745e-02f, 6.38419837e-02f, 4.70513850e-02f, 2.13746041e-01f, 1.73243955e-02f, 5.02008498e-02f, 1.58777952e-01f, 6.47308528e-02f, 1.49840504e-01f,
  2.42903635e-01f, -7.76819959e-02f, 7.41424318e-03f, 2.32513130e-01f, 1.15931503e-01f, -2.64714599e-01f, -3.98972362e-01f, -3.93673718e-01f, -1.51888579e-01f, 5.15144281e-02f,
  2.30047107e-01f, 5.69589213e-02f, 8.89389664e-02f, -5.82770146e-02f, -6.48498014e-02f, -2.04207733e-01f, 4.86820899e-02f, 7.91458264e-02f, -9.29582641e-02f, -9.41939279e-02f,
  4.17675935e-02f, 3.32255274e-01f, 2.29318649e-01f, -4.40331772e-02f, 2.20633820e-02f, 1.16527237e-01f, 1.95147187e-01f, 2.87161499e-01f, -3.40128317e-02f, 1.18039958e-01f,
  1.50973022e-01f, 7.54172131e-02f, -9.71823856e-02f, 1.86538637e-01f, 3.43113482e-01f, -9.13241804e-02f, -1.85714066e-01f, -6.48271963e-02f, -3.50940488e-02f, -1.18014418e-01f,
  1.00574374e-01f, -2.99457833e-03f, -1.74285583e-02f, -8.10020193e-02f, 5.86026274e-02f, -2.31112316e-01f, 9.05571580e-02f, -1.88942477e-01f, -7.30226636e-02f, -1.20893761e-03f,
  -1.64789893e-02f, 2.36212179e-01f, 4.90245298e-02f, -1.52351156e-01f, -1.75534368e-01f, 1.81920767e-01f, -7.08702877e-02f, -5.20334579e-02f, -7.51355290e-03f, -2.11745396e-01f,
  1.43965175e-02f, 7.30362087e-02f, 3.82302888e-02f, 2.49531791e-02f, 1.26566114e-02f, -3.75287533e-02f, 2.17878670e-02f, 1.19955972e-01f, 2.13266872e-02f, -7.96690658e-02f,
  -1.37682498e-01f, 2.74415016e-02f, -1.12077095e-01f, -4.17139754e-03f, 5.13130426e-02f, 2.09017426e-01f, 9.22528952e-02f, 1.03704885e-01f, 1.21544175e-01f, 1.09089456e-01f,
  -2.78795674e-03f, -9.50533375e-02f, 3.47583406e-02f, -6.03289194e-02f, 8.21627304e-02f, 1.41475499e-01f, 2.93222014e-02f, 1.41858101e-01f, 8.38990510e-02f, 7.38211498e-02f,
  8.94281417e-02f, 3.35205197e-01f, -1.68394431e-01f, -8.58291835e-02f, 6.87586591e-02f, -4.72921841e-02f, 1.38257429e-01f, 4.99994569e-02f, 1.05059236e-01f, 1.90541148e-02f,
  -1.12414435e-01f, -8.99966508e-02f, -2.68581416e-02f, -1.70625165e-01f, -1.18382223e-01f, -1.34794340e-01f, 1.06560670e-01f, -9.50812176e-02f, -1.23666883e-01f, 2.85030715e-02f,
  -1.56463664e-02f, -1.47464931e-01f, 3.43778171e-02f, -2.11454809e-01f, -2.96516865e-02f, -8.81872177e-02f, 6.39394438e-03f, -2.08781257e-01f, -1.51341960e-01f, -2.56504297e-01f,
  2.05174327e-01f, 8.42938945e-02f, -1.61979310e-02f, 1.01946823e-01f, 7.59715810e-02f, -1.84082374e-01f, -3.42764497e-01f, -3.14688921e-01f, -1.88187420e-01f, 2.00581178e-03f,
  7.30708167e-02f, 6.79199994e-02f, -7.99373444e-03f, 7.96588063e-02f, -1.90161362e-01f, -2.80552655e-01f, -2.47497872e-01f, 5.23877293e-02f, 8.51649605e-03f, 4.20184657e-02f,
  -2.12999526e-02f, 1.33820713e-01f, 2.01579869e-01f, 1.59339830e-01f, 1.07372425e-01f, 7.39055052e-02f, 7.55556747e-02f, 1.11501753e-01f, -4.42847311e-02f, 8.75554085e-02f,
  2.68419355e-01f, 1.05766937e-01f, 2.82067545e-02f, 2.18807101e-01f, 2.03577146e-01f, 1.33643612e-01f, 1.12308539e-01f, 1.38374075e-01f, -5.35365790e-02f, -1.30356982e-01f,
  7.27865845e-02f, 1.39471635e-01f, 5.28199412e-02f, 8.54316577e-02f, 8.51633772e-02f, 9.23216566e-02f, -3.60501669e-02f, -5.77414483e-02f, -6.92733377e-02f, 1.19396031e-01f,
  -2.41492558e-02f, 9.32762250e-02f, -1.48377180e-01f, -1.87073618e-01f, -1.58727095e-01f, 2.84068119e-02f, 2.36650184e-02f, 2.11995728e-02f, 2.03864574e-02f, -1.02773651e-01f,
  -7.22953081e-02f, -1.13497168e-01f, 6.40861467e-02f, -9.96571034e-02f, -1.66663706e-01f, -1.72652856e-01f, -1.24325238e-01f, -6.65728003e-02f, -1.14967681e-01f, 6.27048239e-02f,
  -5.80672175e-02f, -1.52204126e-01f, -1.11069448e-01f, -3.57085727e-02f, 5.85629754e-02f, -6.23422191e-02f, 3.57775278e-02f, 7.64549598e-02f, 9.22690034e-02f, 7.61345327e-02f,
  -8.79639760e-03f, -2.47526937e-03f, 3.70867513e-02f, 8.75039920e-02f, 2.56011393e-02f, -9.86775011e-02f, -6.95257485e-02f, -7.15120733e-02f, 4.77999337e-02f, -6.36881404e-03f,
  -1.21511273e-01f, 2.02153698e-01f, -9.58746001e-02f, -5.51790223e-02f, 8.18539113e-02f, 7.35193416e-02f, 3.64183113e-02f, 1.65785551e-01f, 1.76251173e-01f, -5.53991385e-02f,
  1.17415577e-01f, 1.51404887e-01f, 1.66045390e-02f, 5.27466871e-02f, 5.80863543e-02f, 8.03598762e-02f, 1.38380587e-01f, -1.12405568e-01f, -7.18349963e-02f, 1.53138682e-01f,
  4.67735305e-02f, -1.96483791e-01f, -2.23722070e-01f, -1.90690219e-01f, -2.09776431e-01f, -1.01310976e-01f, 7.66668618e-02f, -2.92939786e-02f, -1.06814841e-03f, -1.60235763e-01f,
  3.20696607e-02f, 1.45238265e-01f, 3.29730213e-01f, 8.61633942e-03f, 2.87769616e-01f, 2.38460541e-01f, 3.77502173e-01f, 1.27090439e-01f, -5.88754602e-02f, 9.01527554e-02f,
  1.18458085e-01f, -2.67403632e-01f, -1.51478976e-01f, -3.57097059e-01f, -2.61433363e-01f, -1.14179432e-01f, 5.53875230e-02f, -2.18991548e-01f, -8.69897977e-02f, -4.09283228e-02f,
  -9.05448049e-02f, 4.58518043e-02f, -8.65141451e-02f, -1.95934996e-01f, -1.60341769e-01f, -1.16207309e-01f, 2.36773640e-01f, 1.11544430e-01f, 1.01871215e-01f, -3.09164822e-01f,
  1.35755818e-03f, 3.07211459e-01f, -2.31538549e-01f, -2.30073467e-01f, 8.87380987e-02f, -1.10737137e-01f, -3.40801366e-02f, 4.30124141e-02f, -5.19858636e-02f, -3.49156968e-02f,
  2.70196535e-02f, -1.01231009e-01f, 9.13056657e-02f, -3.65809463e-02f, 7.41371959e-02f, 8.64993874e-03f, 4.07411382e-02f, 7.81340990e-03f, -1.36531472e-01f, 1.18461978e-02f,
  -1.53568670e-01f, 2.01518282e-01f, 3.34232777e-01f, 6.52144626e-02f, -1.40223160e-01f, -6.18580952e-02f, 1.24909244e-02f, -1.06785990e-01f, 9.60273817e-02f, -2.63995498e-01f,
  -1.74739882e-01f, -8.55959654e-02f, 4.89022732e-02f, -1.27122670e-01f, -1.50396630e-01f, 5.15861772e-02f, -6.33359104e-02f, -4.66633439e-02f, -4.06359285e-02f, 9.01946127e-02f,
  1.03914775e-02f, -1.74834821e-02f, 1.09708887e-02f, 6.72023520e-02f, 2.34968942e-02f, 4.28753607e-02f, 9.86372307e-03f, 1.03253081e-01f, 1.66647032e-01f, 7.29466677e-02f,
  4.69593853e-02f, 9.09138247e-02f, 1.75420657e-01f, -6.26988634e-02f, -4.31635156e-02f, -2.35086754e-02f, 3.13116014e-02f, -5.61573915e-02f, 9.04857218e-02f, 1.41736388e-01f,
  -1.16568439e-01f, 2.72714376e-01f, -1.62271082e-01f, -8.83602500e-02f, 1.98734269e-01f, 6.20424608e-03f, 4.38025743e-02f, 6.41091540e-03f, 1.74510881e-01f, -4.78890985e-02f,
  2.07292680e-02f, 2.00504959e-02f, 5.70822181e-03f, 9.07504633e-02f, -1.62764173e-02f, 3.17974314e-02f, 1.09780699e-01f, 6.58736005e-02f, 1.61498841e-02f, 5.16616516e-02f,
  3.98421176e-02f, 1.66733600e-02f, 3.60476710e-02f, -1.12943739e-01f, -2.29541156e-02f, -1.09634161e-01f, -9.49411541e-02f, -9.94605105e-03f, 1.10620139e-02f, -1.52201891e-01f,
  -4.27849501e-01f, 3.39865148e-01f, 1.46753326e-01f, -2.00060666e-01f, 1.90938145e-01f, 4.15806532e-01f, 5.51273108e-01f, 1.79371938e-01f, -1.56485125e-01f, 1.80959851e-01f,
  2.00452164e-01f, -2.42825493e-01f, 2.68034674e-02f, -1.37379142e-02f, 2.35376850e-01f, 2.66147673e-01f, 1.03091724e-01f, -5.55526838e-02f, -1.64336890e-01f, 3.87257487e-02f,
  6.70814887e-02f, -1.83672830e-01f, -3.93596947e-01f, -1.46492064e-01f, -6.60075545e-02f, -1.83920458e-01f, 5.06678969e-02f, 4.40871343e-02f, 2.13139459e-01f, -1.11305721e-01f,
  -1.05248362e-01f, 1.39951259e-01f, 4.91108447e-02f, -2.28250638e-01f, -2.09386200e-02f, -4.13991921e-02f, -4.53432091e-02f, -1.29847437e-01f, -6.28071651e-02f, -7.28179701e-03f,
  -2.33181149e-01f, -9.54516605e-02f, -5.11734411e-02f, 1.04425140e-01f, -1.50882006e-01f, 9.03550088e-02f, -9.27316695e-02f, -3.55230793e-02f, -9.51345190e-02f, 2.53205597e-02f,
  1.97582737e-01f, -6.24250881e-02f, -4.47331667e-02f, 1.13441795e-01f, 4.07591723e-02f, -1.88365951e-01f, -3.76766175e-02f, -1.58462718e-01f, -6.59953281e-02f, -3.02722871e-01f,
  9.71498899e-03f, -4.50709909e-02f, 9.59201455e-02f, -4.87022698e-02f, -6.01216219e-02f, -4.54734489e-02f, 2.43117567e-02f, 1.98237330e-01f, 3.63801699e-03f, -1.42280728e-01f,
  6.92104697e-02f, 3.62360068e-02f, -2.79239155e-02f, 1.97016560e-02f, -1.76997408e-02f, 6.05618656e-02f, 1.06680393e-01f, 1.88795313e-01f, 1.75375130e-03f, -4.11836170e-02f,
  -8.60831738e-02f, 7.33278040e-03f, -1.72601119e-01f, 5.15059009e-02f, 9.35892165e-02f, 1.41469061e-01f, -7.42719695e-02f, -2.98544653e-02f, -9.51219201e-02f, 4.73414771e-02f,
  -3.06218743e-01f, 3.14978838e-01f, -2.37452805e-01f, -1.54361911e-02f, -3.15769389e-02f, -1.79443620e-02f, 1.89985320e-01f, 5.91789931e-02f, 3.23393568e-02f, -5.54335639e-02f,
  9.79147628e-02f, 6.90040141e-02f, 1.18762270e-01f, 1.18028678e-01f, 7.93762431e-02f, -8.27114750e-03f, 1.22960031e-01f, 1.26334161e-01f, -8.41747299e-02f, -6.72949776e-02f,
  2.79377420e-02f, 3.50166298e-02f, -1.36845574e-01f, 1.82459101e-01f, -1.25622749e-01f, -2.75914133e-01f, -1.46234065e-01f, -1.18091151e-01f, 1.14367176e-02f, -1.53379738e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 104)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 104;
const float L0_fan_Bp_bar_data[] = {
  3.46568733e-01f, 4.64571267e-01f, 2.99533546e-01f, 4.41084504e-01f, 1.18596911e-01f, 5.19513130e-01f, 2.96300918e-01f, 4.96152669e-01f, 5.16817689e-01f, 3.60410601e-01f,
  2.34753087e-01f, 1.36957273e-01f, 2.71705359e-01f, 2.65575975e-01f, 1.69058099e-01f, 2.57047415e-01f, 4.32623744e-01f, 5.47096729e-01f, 3.25999081e-01f, 4.58012909e-01f,
  3.71526003e-01f, 3.41259807e-01f, 1.98349267e-01f, 2.60969073e-01f, 5.32738745e-01f, 3.25971782e-01f, 3.78456056e-01f, 4.84676301e-01f, 9.50799882e-02f, 2.53182799e-01f,
  2.90703624e-01f, 3.25845867e-01f, 3.55201215e-01f, 3.75418723e-01f, 2.49094978e-01f, 2.53242671e-01f, 2.86634713e-01f, 2.76808977e-01f, 3.43094617e-01f, 2.59426206e-01f,
  1.70815080e-01f, 3.27307075e-01f, 7.77786672e-02f, 3.78079951e-01f, 2.47475132e-01f, 5.06848454e-01f, 2.86236942e-01f, 2.98602194e-01f, 3.62270206e-01f, 2.61401862e-01f,
  2.00977862e-01f, 4.27005619e-01f, 3.23880970e-01f, 1.71990409e-01f, 1.27467647e-01f, 2.84827471e-01f, 2.07442045e-01f, 2.95359433e-01f, 2.77704835e-01f, 4.99998569e-01f,
  4.38454449e-01f, 2.64647037e-01f, 3.83325070e-01f, 5.22222698e-01f, 3.30331653e-01f, 2.62918681e-01f, 2.86532015e-01f, 5.62316537e-01f, 2.63882637e-01f, 4.62778896e-01f,
  2.95230955e-01f, 3.42747152e-01f, 2.78609961e-01f, 2.82484770e-01f, 3.47208083e-01f, 4.67420816e-01f, 1.86680585e-01f, 3.67048860e-01f, 1.26973256e-01f, 7.43390014e-03f,
  3.51346999e-01f, 2.94757366e-01f, 3.80441844e-01f, 5.01853943e-01f, 1.90673515e-01f, 2.31431052e-01f, 5.69539249e-01f, 2.97827125e-01f, 6.54937387e-01f, 4.46093529e-01f,
  3.83243524e-02f, 2.57059187e-01f, 1.97978497e-01f, 5.07724524e-01f, 4.74641740e-01f, 3.79457653e-01f, 4.46977317e-01f, 4.91220325e-01f, 4.50891972e-01f, 1.60775393e-01f,
  3.68161321e-01f, 2.64331013e-01f, 4.44795638e-01f, 2.02665657e-01f
};

// L1_linear_W (Shape: 12 x 128)
const int L1_linear_W_rows = 12;
const int L1_linear_W_cols = 128;
const float L1_linear_W_data[] = {
  -7.28764012e-02f, -1.27203137e-01f, -1.40900910e-01f, 3.51890884e-02f, -1.11040339e-01f, -7.84961879e-02f, -1.78509131e-01f, -7.70563306e-03f, 2.18681842e-02f, -1.10500507e-01f,
  -2.20079124e-02f, -3.45172375e-01f, -1.53123839e-02f, -7.23814517e-02f, -1.12686427e-02f, 4.91012670e-02f, -6.67125285e-02f, -3.71112153e-02f, -1.73836261e-01f, 8.31075385e-02f,
  2.56037861e-02f, 1.95389807e-01f, 1.94956988e-01f, 7.46609494e-02f, -3.00928224e-02f, -5.32819778e-02f, -6.32540107e-01f, -2.06419125e-01f, 1.85014904e-02f, -5.55025160e-01f,
  1.86513681e-02f, -1.35824800e-01f, -4.05226201e-01f, 7.68995658e-02f, 4.70740706e-01f, 2.22492024e-01f, 2.16750100e-01f, 1.42433614e-01f, 5.44813052e-02f, -9.99257863e-02f,
  -1.13376617e-01f, -2.71782964e-01f, -3.35659027e-01f, -1.21427486e-02f, -1.97654665e-01f, -7.10696727e-02f, -2.73776114e-01f, 9.31723230e-03f, -3.06211323e-01f, -7.44410694e-01f,
  1.83744803e-02f, -2.18277603e-01f, -3.44444573e-01f, 1.93847954e-01f, 2.18121380e-01f, -1.03091821e-01f, -1.84557974e-01f, -8.14659372e-02f, -2.18738273e-01f, 2.46597394e-01f,
  -3.57469499e-01f, 3.58041376e-02f, -1.06713837e-02f, -2.14723706e-01f, -3.13289911e-01f, -2.85254061e-01f, -4.75911014e-02f, -2.98669338e-01f, 2.65467882e-01f, -6.83458298e-02f,
  -3.02739382e-01f, 2.30458215e-01f, 7.41285235e-02f, 3.56680840e-01f, -1.98043838e-01f, -1.58745810e-01f, 2.31770216e-03f, -5.14112890e-01f, 2.99671710e-01f, -5.40283918e-02f,
  1.22108802e-01f, -9.48649794e-02f, 2.49847949e-01f, -4.43831891e-01f, -1.14877678e-01f, 1.06071338e-01f, -3.05475891e-01f, -1.24236465e-01f, 1.55819217e-02f, -1.86212912e-01f,
  -3.42624448e-02f, -7.68283606e-01f, 1.45273075e-01f, -1.09774970e-01f, -2.52862513e-01f, -1.74665257e-01f, 2.68425852e-01f, 1.31024539e-01f, -4.20239776e-01f, 1.17898829e-01f,
  1.81595460e-01f, 1.61455542e-01f, -1.09285809e-01f, 9.67205539e-02f, 2.84835041e-01f, -4.14705664e-01f, -5.80066323e-01f, -4.13393110e-01f, -5.67236781e-01f, -9.48738828e-02f,
  -1.15369320e-01f, -4.63118628e-02f, -4.02867109e-01f, -2.09592775e-01f, 7.71391615e-02f, 5.97235747e-02f, -1.73364505e-01f, -4.24198985e-01f, 2.80278951e-01f, 3.17310959e-01f,
  -2.89216987e-03f, -2.96636671e-01f, -2.25833595e-01f, 2.86352307e-01f, -2.83080161e-01f, 2.26251744e-02f, -1.94313332e-01f, -3.10646921e-01f, -5.52348830e-02f, -7.53934160e-02f,
  -1.32201957e-02f, -2.56826822e-02f, 1.03362463e-03f, 8.62606708e-03f, 3.60751413e-02f, 7.14095160e-02f, -1.03916712e-01f, 4.70043495e-02f, -1.01296090e-01f, 1.65519714e-01f,
  -1.77354932e-01f, -4.74281982e-02f, -1.36753440e-01f, 2.10283622e-01f, -6.48493692e-02f, 9.41387862e-02f, -1.88524351e-01f, 1.86088070e-01f, -1.93671390e-01f, -2.72778898e-01f,
  2.73600202e-02f, -1.11133322e-01f, -6.79127634e-01f, 1.58384651e-01f, -6.88964501e-02f, -4.64440763e-01f, 7.74782971e-02f, -9.24572200e-02f, 1.74177676e-01f, -2.93271571e-01f,
  -3.59034352e-02f, -2.64461935e-01f, -5.66205382e-01f, -2.90756077e-01f, 1.25492439e-01f, 2.23042697e-01f, 1.06590100e-01f, -2.26277724e-01f, 1.26187965e-01f, 2.59466678e-01f,
  -1.54093474e-01f, -5.64958854e-03f, 2.04089448e-01f, -1.81332916e-01f, -1.68914162e-02f, 2.13574737e-01f, 3.50594223e-01f, -3.58364396e-02f, 1.74194336e-01f, 1.36140347e-01f,
  -3.90340000e-01f, -1.06454276e-01f, 2.20313936e-01f, -7.72090778e-02f, -7.68932283e-01f, 2.66574740e-01f, 1.24220565e-01f, -1.80659860e-01f, -2.26040989e-01f, 2.75026649e-01f,
  -1.98834136e-01f, 2.41788492e-01f, 4.28355895e-02f, -4.91669625e-01f, -1.39760599e-02f, 1.57299731e-02f, -8.27570558e-01f, -4.15576547e-01f, -1.99704841e-02f, -3.49679321e-01f,
  4.75853562e-01f, 2.50986636e-01f, 1.23135827e-01f, -6.48943007e-01f, 1.85396358e-01f, 4.58360463e-03f, 4.91778314e-01f, -2.61486113e-01f, -3.71318221e-01f, -4.08636816e-02f,
  2.23271266e-01f, 1.26866968e-02f, -4.66047078e-01f, -3.94696146e-01f, -1.35966703e-01f, 1.72297508e-01f, -4.43293959e-01f, 1.58140093e-01f, 8.77412483e-02f, -6.92523003e-01f,
  1.44362107e-01f, -2.48264000e-01f, -2.79032797e-01f, -6.06357157e-01f, 5.04956603e-01f, 8.76846135e-01f, 1.28906041e-01f, 3.57808173e-02f, 2.58716375e-01f, 6.71103075e-02f,
  -6.33720383e-02f, -1.41776443e-01f, -3.57591152e-01f, -1.03656426e-01f, -4.23560947e-01f, 5.07724062e-02f, -2.57089287e-01f, 3.22557464e-02f, 7.41793588e-03f, 1.63846239e-01f,
  -3.21404815e-01f, -1.33481041e-01f, 1.19314790e-02f, 6.41264096e-02f, -2.00953931e-01f, 1.99524894e-01f, -3.87402475e-01f, -4.98620659e-01f, 1.70073152e-01f, -1.67668000e-01f,
  5.28910220e-01f, 1.19032897e-01f, -1.31404653e-01f, -6.43200576e-02f, -1.64521039e-01f, 2.84970980e-02f, 3.08843613e-01f, 2.06460699e-01f, 1.35542735e-01f, 1.33421987e-01f,
  1.19821280e-01f, 6.51401654e-02f, 5.11990264e-02f, 1.46820292e-01f, 1.12091079e-01f, -5.63735664e-02f, 1.65426992e-02f, -6.18535914e-02f, -6.83762431e-02f, 2.05440912e-02f,
  3.27808596e-02f, -1.18014127e-01f, 1.89346984e-01f, -1.90130860e-01f, 1.99596018e-01f, -3.39956701e-01f, -1.23912856e-01f, -3.04314137e-01f, -3.76513116e-02f, 3.09188336e-01f,
  -3.80610496e-01f, 2.00729609e-01f, -2.31398031e-01f, -3.59999210e-01f, -4.04826343e-01f, 2.09861264e-01f, -4.49621230e-01f, -2.80686915e-01f, -7.04579279e-02f, -5.56676745e-01f,
  -5.73041923e-02f, -5.67111857e-02f, -4.03333485e-01f, -1.71021253e-01f, -6.59350380e-02f, -9.63074993e-03f, 1.10815160e-01f, 5.86448967e-01f, 4.24344651e-02f, -5.51054478e-01f,
  -7.70484209e-02f, -2.51324326e-01f, -3.68806750e-01f, -3.61945689e-01f, 1.77842557e-01f, -6.73389016e-03f, -4.50313658e-01f, 2.47974500e-01f, 7.22938180e-02f, 5.71793877e-02f,
  -2.97234863e-01f, -2.46312961e-01f, -4.17470723e-01f, -1.21410869e-01f, -4.30009365e-01f, 6.48199245e-02f, 6.70410991e-02f, -1.17383555e-01f, 3.55848461e-01f, -6.27961233e-02f,
  -2.21468300e-01f, -1.83067620e-01f, 1.26582101e-01f, -7.14231655e-02f, -4.45405483e-01f, 1.61158934e-01f, -2.67320991e-01f, 5.33563733e-01f, 5.05685925e-01f, 1.21270962e-01f,
  -4.31963652e-02f, 2.54205853e-01f, -3.09859842e-01f, -3.18287015e-01f, 1.85719043e-01f, 1.51484264e-02f, -2.70516872e-01f, -1.04279310e-01f, -1.21052243e-01f, -4.02120501e-01f,
  -1.61516875e-01f, 4.17358935e-01f, -1.91016644e-01f, 1.84345618e-02f, 2.64070421e-01f, 2.06725560e-02f, -4.52884566e-03f, -3.15084398e-01f, -1.02849908e-01f, -2.59977698e-01f,
  -1.97785601e-01f, 2.16556996e-01f, 1.73714887e-02f, 2.32434019e-01f, 1.77284822e-01f, -4.55488324e-01f, -6.08472407e-01f, 3.05950850e-01f, -6.40503839e-02f, -1.34911701e-01f,
  9.75672826e-02f, -2.98470199e-01f, 2.00568318e-01f, -1.96644410e-01f, -1.87431231e-01f, -2.54979074e-01f, -2.03325525e-01f, -1.56000435e-01f, -1.67696044e-01f, 4.62011337e-01f,
  5.09942276e-03f, 6.72458336e-02f, -1.85145438e-01f, 2.99135327e-01f, -2.54844755e-01f, 3.19025844e-01f, 9.89877619e-03f, -1.38969362e-01f, 1.96940616e-01f, 8.41599330e-02f,
  2.56066293e-01f, 1.97732702e-01f, -3.28349601e-03f, -2.29045436e-01f, -1.60276458e-01f, -1.80278629e-01f, 2.37762183e-02f, -1.50888443e-01f, 1.09254017e-01f, -2.31173867e-03f,
  8.73394012e-02f, 2.38587186e-02f, -2.29839599e-04f, 7.21031800e-02f, 6.52393699e-02f, 1.48327231e-01f, 9.40546691e-02f, -1.14573106e-01f, 2.54678547e-01f, -3.29927921e-01f,
  1.73418552e-01f, -3.20439972e-02f, 1.51497975e-01f, -2.88346618e-01f, -8.87118280e-02f, 1.74440041e-01f, -3.07080925e-01f, 2.41011493e-02f, 3.95438790e-01f, -2.22461343e-01f,
  -2.09140003e-01f, 2.00704351e-01f, -3.08685869e-01f, -2.41770014e-01f, -1.85894847e-01f, 2.06805915e-01f, -4.56551224e-01f, 1.96444720e-01f, -1.90016702e-02f, -1.12958878e-01f,
  3.50435644e-01f, 6.19188882e-02f, -1.67505831e-01f, -2.26915851e-01f, -2.15385243e-01f, 1.27192605e-02f, -1.98254734e-01f, -5.82136065e-02f, -2.67870545e-01f, -2.12076977e-01f,
  -2.18822643e-01f, -1.06541589e-01f, -9.01344419e-02f, 2.60277003e-01f, -5.25038183e-01f, -4.55700010e-01f, -2.67366260e-01f, 1.75105885e-01f, -3.64096552e-01f, -1.63874418e-01f,
  -4.40790981e-01f, -1.15977407e-01f, 3.26094516e-02f, 1.74909785e-01f, 4.72531766e-02f, -2.33560309e-01f, -3.84401716e-02f, -3.36978912e-01f, -4.45354939e-01f, -3.13674033e-01f,
  -2.05588698e-01f, -3.78385186e-02f, 8.95517915e-02f, 3.77497077e-01f, -1.11757472e-01f, 1.28566086e-01f, 3.27860922e-01f, -5.24875820e-01f, -1.73879385e-01f, 8.45540836e-02f,
  2.46880636e-01f, 3.34358186e-01f, -3.58385324e-01f, -4.92314667e-01f, -1.76411010e-02f, 2.18801469e-01f, -6.77648187e-02f, -3.63210589e-01f, -3.69938998e-03f, 3.92339557e-01f,
  2.03111038e-01f, -4.07385796e-01f, 2.67575234e-01f, -8.69002864e-02f, -2.79423654e-01f, -3.82784426e-01f, -3.52532595e-01f, -7.76529014e-02f, -3.10000569e-01f, -4.41767663e-01f,
  -1.06424652e-01f, -3.74916852e-01f, -3.31663877e-01f, -1.70090333e-01f, -2.25086048e-01f, -8.26997399e-01f, 3.65730047e-01f, 6.25833988e-01f, 2.50899851e-01f, 4.20586944e-01f,
  4.27275538e-01f, -5.84214985e-01f, 2.42884144e-01f, -2.85138160e-01f, 4.89559770e-02f, 2.17216611e-01f, -3.33609372e-01f, -4.30972576e-01f, -2.57594854e-01f, -4.40721929e-01f,
  1.20555041e-02f, -6.74264669e-01f, -6.34441912e-01f, 1.14123829e-01f, -3.84834915e-01f, 3.56070757e-01f, -2.08120733e-01f, -1.27058625e-02f, -3.42450142e-01f, -4.12226766e-01f,
  1.30171046e-01f, 3.98725063e-01f, -1.19213365e-01f, -1.07008822e-01f, 1.65006462e-02f, -4.24863882e-02f, -2.76299119e-01f, -1.05774710e-02f, 1.18500046e-01f, 3.50263603e-02f,
  -1.67626351e-01f, -1.40766159e-01f, 4.03158180e-02f, -7.75268376e-02f, -3.64240147e-02f, -1.70858264e-01f, -1.55156568e-01f, -1.95257902e-01f, 2.29699060e-01f, -2.98642814e-02f,
  -1.55078173e-01f, -1.07890688e-01f, 2.01598570e-01f, -4.61942032e-02f, 9.99214873e-02f, 1.20716594e-01f, -2.18135327e-01f, -2.82055996e-02f, 2.57106632e-01f, 1.98279068e-01f,
  -3.83539826e-01f, -3.46490622e-01f, -2.35149831e-01f, -6.89024329e-02f, 8.33166838e-02f, 3.09386045e-01f, -2.69167244e-01f, 6.73320219e-02f, -6.28779292e-01f, 1.57329202e-01f,
  -1.43522453e-02f, -4.48778793e-02f, -1.42345861e-01f, 1.62043288e-01f, -6.11781999e-02f, 7.87060186e-02f, 7.67067969e-02f, -2.68383354e-01f, 4.96504158e-02f, -1.59102276e-01f,
  -8.71413052e-02f, 4.22555655e-01f, 2.12181091e-01f, -4.20312136e-01f, 6.37901008e-01f, 1.32585481e-01f, 3.08379978e-02f, -5.97510561e-02f, -3.16907018e-01f, -1.65158197e-01f,
  5.42762764e-02f, 2.62753535e-02f, 4.36509788e-01f, -3.41307402e-01f, -6.58591092e-01f, -7.01313317e-02f, 8.81199464e-02f, 2.18162984e-01f, 8.12992677e-02f, -4.59737852e-02f,
  1.05690792e-01f, -7.12557957e-02f, -4.03283626e-01f, 6.37566447e-02f, -4.77163702e-01f, -1.75450072e-01f, 2.11601973e-01f, -2.81840593e-01f, -1.89458802e-02f, 2.34801233e-01f,
  -7.31051490e-02f, 5.34279235e-02f, 2.22386941e-01f, 9.54207256e-02f, -1.87899455e-01f, -1.52584344e-01f, -5.73161095e-02f, -2.56012768e-01f, 1.78890243e-01f, -3.29403132e-01f,
  1.15572251e-01f, -2.91762471e-01f, -4.40515846e-01f, 4.63307261e-01f, 8.35322589e-03f, -4.09286439e-01f, 3.19591224e-01f, 3.45621973e-01f, -3.57445210e-01f, -1.29151404e-01f,
  -1.38474889e-02f, -7.33284205e-02f, -2.07556688e-04f, 1.38340920e-01f, 2.77518132e-03f, -2.36438930e-01f, -1.79270267e-01f, 1.95502490e-01f, 1.70550216e-02f, 4.45531219e-01f,
  3.83360088e-01f, 1.56709969e-01f, -3.53861243e-01f, 2.65845239e-01f, -2.87582308e-01f, 1.54426740e-02f, 9.64537412e-02f, 7.99650028e-02f, -1.66035563e-01f, 2.49782264e-01f,
  -1.94052905e-01f, -8.83988515e-02f, 8.45483784e-03f, -6.36617765e-02f, -7.77420029e-02f, -4.91357088e-01f, -1.21161059e-01f, -7.43787438e-02f, 2.22701237e-01f, -4.78007853e-01f,
  1.72611296e-01f, 1.45096347e-01f, 1.38366640e-01f, 5.19350767e-02f, 8.57853889e-02f, -5.58784790e-02f, -6.74593300e-02f, 1.57873288e-01f, 1.34315982e-01f, 1.22013807e-01f,
  2.10575253e-01f, 3.45622487e-02f, -2.65285876e-02f, -9.94619131e-02f, 1.37562960e-01f, 1.97119027e-01f, 1.33030444e-01f, 5.68868294e-02f, -2.49638870e-01f, 4.23680022e-02f,
  2.81735212e-01f, 1.05313137e-01f, 1.73705444e-01f, -1.10771053e-01f, 1.35076582e-01f, -1.96928397e-01f, -5.06390452e-01f, -4.95331258e-01f, -7.43598491e-02f, -1.36892974e-01f,
  -2.15999871e-01f, 2.83795506e-01f, 9.67271402e-02f, 5.10830618e-02f, 1.17998838e-01f, -8.28623474e-02f, 1.49585575e-01f, -2.26091057e-01f, 5.63409291e-02f, -1.43808722e-01f,
  6.55487478e-02f, -3.52766871e-01f, 3.08828354e-01f, 3.89779806e-01f, -3.51063818e-01f, 8.59865099e-02f, 9.24168825e-02f, 1.52297616e-01f, -5.52252382e-02f, -1.06472418e-01f,
  2.90515274e-01f, 5.07053137e-01f, -5.52005410e-01f, -1.08429879e-01f, 2.85462826e-01f, -1.11684874e-01f, 8.10869336e-01f, 6.32054508e-02f, -2.08115205e-02f, -1.55829489e-01f,
  6.26742542e-02f, -1.33496061e-01f, -4.30739850e-01f, -1.81341365e-01f, 2.26967130e-02f, -3.88051361e-01f, 1.08447202e-01f, -1.96253270e-01f, 1.20296255e-01f, -3.96519333e-01f,
  -7.45508075e-02f, -3.82775486e-01f, -3.77883345e-01f, 8.56474191e-02f, -2.88197815e-01f, -4.21006292e-01f, -7.58032203e-02f, -6.01746619e-01f, -1.75283894e-01f, -6.65903464e-02f,
  9.19271931e-02f, -1.86661124e-01f, -2.45526582e-01f, 4.92397606e-01f, 2.09003732e-01f, -4.72570151e-01f, 3.87643903e-01f, 2.57808149e-01f, -3.10222745e-01f, 8.79589319e-02f,
  8.54259804e-02f, 6.00554109e-01f, 1.12046637e-01f, -1.08961038e-01f, 3.24428350e-01f, -2.00961843e-01f, -7.87220150e-02f, -5.80312312e-01f, -3.72386873e-01f, 4.76236939e-01f,
  2.40489721e-01f, -2.85841227e-01f, 2.67653670e-02f, 8.17391425e-02f, -4.98705357e-01f, -5.12322448e-02f, -3.26881945e-01f, 4.14864808e-01f, -5.37370741e-01f, 2.02536210e-01f,
  -1.46068960e-01f, -4.61981624e-01f, 3.03723812e-01f, -2.74455339e-01f, -4.79268581e-02f, -3.82930487e-02f, 3.44905525e-01f, 3.31021883e-02f, 4.83181208e-01f, 1.10567752e-02f,
  -1.44193629e-02f, -1.33656159e-01f, -2.08240420e-01f, -6.34068623e-02f, 1.08711272e-01f, -7.61151314e-02f, -3.28692466e-01f, -2.34248087e-01f, -3.34506094e-01f, 1.60301179e-02f,
  -1.07932538e-01f, 4.07918282e-02f, 5.71072027e-02f, 1.30912930e-01f, 7.27817938e-02f, -4.31592241e-02f, 9.29381847e-02f, -3.08395177e-02f, 7.89256543e-02f, 5.38001470e-02f,
  2.71714091e-01f, -7.99837857e-02f, -3.04550350e-01f, 5.29993586e-02f, -9.26235765e-02f, 1.80548579e-02f, 7.74338916e-02f, -3.42006013e-02f, -2.13768352e-02f, -3.60545306e-03f,
  2.24932477e-01f, -2.54325807e-01f, -8.24454874e-02f, 2.16261759e-01f, 3.65479857e-01f, -4.76499274e-02f, -3.53485160e-02f, 1.48138642e-01f, 1.28925562e-01f, -1.93857297e-01f,
  6.62170276e-02f, -3.37186545e-01f, -7.21762657e-01f, -7.56621480e-01f, -1.92102477e-01f, -1.47944465e-01f, 1.51263058e-01f, -4.52618420e-01f, -3.84928077e-01f, -4.97722208e-01f,
  2.09498957e-01f, -4.20090944e-01f, 2.81675369e-01f, 2.75895178e-01f, -7.51227364e-02f, 2.81217664e-01f, 3.93742211e-02f, 2.98559129e-01f, -6.87222719e-01f, 4.56319213e-01f,
  -2.52559394e-01f, -3.08624089e-01f, -1.92817807e-01f, -2.07553849e-01f, 6.54072165e-02f, -3.13265562e-01f, -2.59715557e-01f, -4.94836181e-01f, -4.48645979e-01f, 2.35379457e-01f,
  2.09187821e-01f, -3.21022600e-01f, 8.15558508e-02f, 1.41310319e-01f, 5.68420219e-04f, 1.91483662e-01f, -6.96901530e-02f, -3.21254671e-01f, -2.94045091e-01f, -2.87481219e-01f,
  -4.90154251e-02f, -3.47807765e-01f, 4.99857336e-01f, 4.79377210e-01f, -1.53110296e-01f, -6.10576391e-01f, -1.05116159e-01f, 1.34555981e-01f, -3.98265898e-01f, 2.49324441e-01f,
  -1.07172288e-01f, 2.43834391e-01f, -9.83759463e-02f, -4.99708593e-01f, 1.12490050e-01f, 1.90772593e-01f, -2.49307469e-01f, -5.54143377e-02f, 2.23571226e-01f, 4.96662170e-01f,
  -2.71695256e-01f, -1.27130991e-03f, -1.25693440e-01f, 3.77258539e-01f, -2.78976321e-01f, -6.43816113e-01f, -3.17637101e-02f, -3.81012499e-01f, -4.23943162e-01f, 4.02451068e-01f,
  5.86385541e-02f, 3.81269641e-02f, -3.89795512e-01f, -5.96429147e-02f, 1.18839681e-01f, -2.74396598e-01f, -1.06827468e-01f, 1.22801088e-01f, -6.83902383e-01f, -4.35478628e-01f,
  1.94731221e-01f, -1.39690891e-01f, -3.61698419e-01f, 4.59800810e-02f, -4.39846516e-02f, 3.08943719e-01f, -2.91788518e-01f, 8.27110484e-02f, -1.20903760e-01f, -1.20028220e-01f,
  -2.90223323e-02f, -3.01672101e-01f, -1.03443921e-01f, 9.01791230e-02f, -6.06902480e-01f, -2.89752364e-01f, -3.56453918e-02f, 9.86976624e-02f, -1.71697259e-01f, -1.46685898e-01f,
  1.32144213e-01f, -2.82629937e-01f, -1.22658536e-01f, -5.41641004e-02f, -2.69339889e-01f, 4.08419259e-02f, -3.14171612e-01f, -2.39102240e-03f, -1.81467131e-01f, -3.52800041e-02f,
  3.49329978e-01f, -2.21747339e-01f, -1.03444219e-01f, -1.77315578e-01f, 2.03345284e-01f, -1.81580171e-01f, 1.19244687e-01f, 2.75594324e-01f, -2.60400206e-01f, 1.33128036e-02f,
  4.38073695e-01f, -1.45093396e-01f, -2.80058682e-01f, -3.42520416e-01f, 6.52526170e-02f, -6.96785524e-02f, -1.00111969e-01f, -1.82465315e-01f, -1.73516106e-02f, -3.32333297e-01f,
  3.99425119e-01f, -3.57030302e-01f, -2.59193778e-01f, -2.32826754e-01f, -3.11434958e-02f, 1.53853282e-01f, -2.33043492e-01f, -1.29093647e-01f, -1.08065285e-01f, -3.09817582e-01f,
  -2.34610826e-01f, -9.55289528e-02f, 1.59466311e-01f, -1.98686630e-01f, -1.41137227e-01f, 1.38133451e-01f, -8.93088952e-02f, -4.06329751e-01f, 1.84588566e-01f, -2.23587289e-01f,
  -1.85369968e-01f, -1.18303999e-01f, 3.20391625e-01f, -2.61823013e-02f, 1.73530862e-01f, -2.25538939e-01f, -8.99113640e-02f, -1.29252046e-01f, 1.70101419e-01f, -2.12229982e-01f,
  1.93433285e-01f, 2.59898484e-01f, 9.36546475e-02f, -1.23315506e-01f, -2.38816947e-01f, 2.66445398e-01f, 2.85419583e-01f, -2.79157646e-02f, -2.59243667e-01f, -6.46181330e-02f,
  -1.41713232e-01f, -5.03284335e-01f, -4.62092429e-01f, 3.06220561e-01f, 5.86174848e-03f, 1.25124052e-01f, -1.60837129e-01f, -3.44306320e-01f, -1.06744096e-01f, 9.02664289e-02f,
  -7.69854933e-02f, 3.74513268e-01f, -1.83506534e-01f, -4.25258167e-02f, 9.54521000e-02f, 1.77992657e-01f, 4.96422723e-02f, -2.07479075e-02f, -4.71644700e-01f, 9.91116539e-02f,
  -9.84555557e-02f, -2.24797383e-01f, -4.06248122e-01f, -6.48092210e-01f, -2.73499906e-01f, -2.90460974e-01f, -1.61942616e-01f, -5.68855181e-02f, 1.49640188e-01f, -2.13546187e-01f,
  2.93845117e-01f, -2.94038802e-01f, 4.18216169e-01f, 2.31956840e-01f, 4.23995465e-01f, -6.91367537e-02f, -1.01185486e-01f, -3.08082163e-01f, -1.09196916e-01f, -1.54720739e-01f,
  1.00265339e-01f, -3.08966041e-02f, -8.08571279e-02f, -1.69799834e-01f, -2.37839609e-01f, -4.48215514e-01f, 4.12454493e-02f, 2.37508759e-01f, -1.96375832e-01f, -7.37438351e-02f,
  -3.09223145e-01f, -2.10295483e-01f, -3.73369336e-01f, 2.76181191e-01f, 2.77861990e-02f, 1.92695502e-02f, 4.42950353e-02f, 4.23193239e-02f, 4.15231213e-02f, 6.06947243e-02f,
  3.77535522e-02f, -3.19742821e-02f, -8.47275853e-02f, 1.70367599e-01f, 8.32191780e-02f, 4.71933791e-03f, 3.53158712e-01f, 1.93983123e-01f, -5.07738143e-02f, 1.87926263e-01f,
  -2.11986199e-01f, 1.85556095e-02f, 3.40011150e-01f, 3.04072320e-01f, -2.49596730e-01f, 1.25284091e-01f, 4.85961046e-03f, -2.03406274e-01f, -7.60863349e-02f, 1.07515253e-01f,
  -2.97513455e-01f, -5.01425385e-01f, -2.33034454e-02f, 3.77819836e-01f, 4.96974401e-02f, 4.37430561e-01f, 3.55792224e-01f, -4.84767288e-01f, -1.77400317e-02f, -1.72922790e-01f,
  1.40700310e-01f, -2.65604407e-01f, -2.02625617e-01f, 3.60432237e-01f, 1.90029055e-01f, 3.21497172e-01f, 1.64902627e-01f, -3.71956617e-01f, -2.33840108e-01f, 2.34157056e-01f,
  4.54223417e-02f, -2.38499805e-01f, -1.41981170e-01f, -1.60908073e-01f, -2.21649095e-01f, -1.06754161e-01f, -1.06385075e-01f, -2.77507216e-01f, -1.45666018e-01f, 2.52839655e-01f,
  -4.68941003e-01f, 5.17833829e-02f, 1.03601724e-01f, -2.01046333e-01f, -3.51039112e-01f, -2.72579700e-01f, -9.40677151e-02f, 1.36293128e-01f, -2.51653671e-01f, -3.02312851e-01f,
  -1.20055685e-02f, 2.18980253e-01f, -1.98740691e-01f, -2.43584052e-01f, -5.84602095e-02f, 5.32850660e-02f, -7.29002729e-02f, 2.31454689e-02f, -2.89618354e-02f, 3.90271358e-02f,
  -5.18526137e-01f, -1.78993821e-01f, -1.71693221e-01f, -1.55438021e-01f, -1.79421231e-01f, -2.83569157e-01f, -8.20191391e-03f, -1.43572658e-01f, 6.91415846e-01f, 1.60793662e-02f,
  -1.13752387e-01f, 1.36118531e-01f, -1.09901786e-01f, -1.68494850e-01f, 1.35799363e-01f, -4.46101367e-01f, 6.15994968e-02f, 4.72534150e-01f, -4.00571585e-01f, -2.22032562e-01f,
  -4.49095190e-01f, -4.70730543e-01f, 2.96943523e-02f, -2.79355824e-01f, -3.50564241e-01f, -2.65631527e-01f, -2.16325358e-01f, -3.87176429e-03f, -3.86620492e-01f, -2.01974303e-01f,
  -2.03371227e-01f, -4.48840708e-01f, -1.06615461e-01f, -9.97913480e-02f, 6.65107787e-01f, -4.11546320e-01f, 5.97195089e-01f, -1.01178505e-01f, -8.98690075e-02f, -5.16574532e-02f,
  1.53892646e-02f, -3.61783713e-01f, 1.81547672e-01f, -1.77856296e-01f, 1.82840899e-01f, 1.05906576e-01f, 1.03903092e-01f, 1.32832542e-01f, -1.91507533e-01f, -3.07026118e-01f,
  1.31676525e-01f, -1.09318398e-01f, 1.49522319e-01f, -8.11929908e-03f, -1.27658597e-03f, 1.01238936e-02f, 1.24012018e-02f, -9.71098244e-02f, 5.71071170e-02f, -7.40353623e-03f,
  -1.08257964e-01f, -1.67909991e-02f, 2.31451280e-02f, -1.14035547e-01f, 1.96109071e-01f, 2.08494082e-01f, -8.82056132e-02f, 1.86960194e-02f, 1.82858452e-01f, -1.41013876e-01f,
  -2.18270630e-01f, 2.21748248e-01f, 2.17466846e-01f, -1.89873442e-01f, -2.84482539e-01f, 2.82704949e-01f, -3.21163714e-01f, -4.36337702e-02f, 3.16809684e-01f, 3.05053502e-01f,
  1.32918030e-01f, 1.77666172e-01f, 1.47038236e-01f, -2.77831972e-01f, -2.49334767e-01f, -2.56291479e-01f, 4.31645632e-01f, 5.59555948e-01f, -2.55488008e-01f, -3.39726418e-01f,
  -2.81663775e-01f, 1.51609187e-03f, -4.69405264e-01f, -2.49663055e-01f, -1.30064636e-01f, 3.79882812e-01f, 1.73359856e-01f, -9.18183476e-02f, -2.42913529e-01f, 1.13859074e-02f,
  -2.25752071e-01f, -2.23019663e-02f, 6.69517696e-01f, -4.44598526e-01f, 2.57631183e-01f, -5.86160004e-01f, -4.45986502e-02f, -3.97711575e-01f, 1.94496080e-01f, -1.38474330e-01f,
  -1.91833645e-01f, 2.50162214e-01f, -5.18694878e-01f, 2.15103656e-01f, 2.91135818e-01f, 2.50931680e-01f, 6.35298416e-02f, 2.49399960e-01f, -3.74653051e-03f, -2.89872587e-01f,
  -1.21455848e-01f, -5.88310421e-01f, -8.94126296e-02f, -2.46021807e-01f, -5.46086371e-01f, -2.71441191e-01f, -1.85776055e-01f, -8.81042331e-02f, -4.63750243e-01f, 3.81861776e-01f,
  -1.52300760e-01f, 3.71791065e-01f, 3.95116776e-01f, 2.45179787e-01f, -4.51105863e-01f, -8.58042464e-02f, -4.23477530e-01f, -2.87581235e-01f, -2.22604632e-01f, -5.23711517e-02f,
  -8.74937624e-02f, -3.20000678e-01f, 2.29364589e-01f, -6.79755926e-01f, 4.26472463e-02f, -1.66309431e-01f, -1.45043328e-01f, 1.71689540e-01f, -4.61471319e-01f, -4.57706023e-03f,
  3.13462049e-01f, 5.36231138e-02f, 1.34747759e-01f, 2.45949496e-02f, -2.29552582e-01f, -3.13645713e-02f, -5.06753683e-01f, -8.16658065e-02f, -5.24283648e-02f, 2.61836141e-01f,
  2.41167232e-01f, -5.95519543e-01f, -3.90830040e-02f, -1.75493002e-01f, -4.47458297e-01f, 2.88000554e-01f, -3.32815886e-01f, -9.97021794e-02f, 7.34415203e-02f, -5.94505854e-02f,
  -6.45053908e-02f, -8.37041363e-02f, 4.77254012e-04f, -4.37318385e-02f, -9.27900970e-02f, -1.02961168e-01f, 3.23972315e-01f, 2.57431358e-01f, -9.47860330e-02f, -2.09971592e-01f,
  1.13012820e-01f, 8.53129104e-03f, -2.00977884e-02f, 8.78151506e-03f, 1.65790319e-01f, 1.24204814e-01f, 1.58625409e-01f, -1.75715666e-02f, 9.91168097e-02f, -9.28926468e-02f,
  6.16245810e-03f, 1.27358973e-01f, -2.57937610e-01f, 2.18939736e-01f, 1.71110094e-01f, 1.20894954e-01f, -2.39893615e-01f, -4.65874113e-02f, -3.57053913e-02f, -2.81330675e-01f,
  -1.84062421e-01f, -3.16930473e-01f, 8.93861577e-02f, -1.89710408e-01f, -1.18179329e-01f, 1.78046271e-01f, -1.78746924e-01f, 2.77496010e-01f, -2.32107624e-01f, 3.04482102e-01f,
  -1.45788938e-01f, 2.15759873e-01f, 2.40094334e-01f, 2.30549738e-01f, -1.87443748e-01f, -9.59119946e-02f, 1.82419285e-01f, 2.91275471e-01f, -3.02316874e-01f, 1.35736346e-01f,
  -2.07753599e-01f, 2.96275675e-01f, -3.71157944e-01f, -1.51196986e-01f, -3.89879905e-02f, -2.26796195e-01f, -2.21974805e-01f, -1.97627604e-01f, -1.75174654e-01f, -4.00466174e-01f,
  -4.63743478e-01f, -4.10152525e-01f, -1.86245158e-01f, 3.17680925e-01f, 4.83285636e-02f, -3.26857924e-01f, -3.39656740e-01f, -2.15893209e-01f, -2.38437161e-01f, -4.14634645e-01f,
  2.18696728e-01f, -1.02722794e-01f, 6.21748436e-03f, -1.60268843e-01f, -1.56900838e-01f, -5.26422560e-02f, -1.19952671e-01f, -9.27889943e-02f, 7.41309896e-02f, 1.80389717e-01f,
  5.01416802e-01f, -3.95340264e-01f, -4.28943098e-01f, -1.47585064e-01f, -2.79620349e-01f, -1.95358858e-01f, 3.90981287e-01f, -3.12819630e-01f, -2.88705617e-01f, 2.46825144e-01f,
  -2.90524304e-01f, -2.84754425e-01f, 4.36706662e-01f, -1.96643442e-01f, -5.77987283e-02f, -1.48119688e-01f, -2.70485371e-01f, -2.98710503e-02f, -4.09124345e-01f, -9.88445655e-02f,
  -8.93078595e-02f, -3.59860688e-01f, 3.83396372e-02f, -1.32797554e-01f, 3.62275571e-01f, -3.19642127e-01f, -2.40390539e-01f, -1.82675272e-01f, -3.42045575e-01f, -2.29024425e-01f,
  -1.44676387e-01f, -2.92212814e-01f, -1.35088384e-01f, -4.83650059e-01f, -1.55275866e-01f, 3.65725875e-01f, -3.40570986e-01f, 1.21903270e-01f, -1.35776177e-01f, -3.00631255e-01f,
  -8.90321136e-02f, -4.87164617e-01f, 3.23919743e-01f, 6.10816002e-01f, -3.16910475e-01f, -4.97000337e-01f, 3.80973279e-01f, -2.01866925e-01f, -2.61410803e-01f, -2.42271379e-01f,
  -1.16225444e-01f, 3.11726838e-01f, -2.88106471e-01f, -5.57637155e-01f, -1.82608604e-01f, -1.84018508e-01f, -2.53020167e-01f, -1.24586888e-01f, -4.28336523e-02f, 5.60019165e-02f,
  9.64307971e-03f, 1.78180393e-02f, -1.18000410e-01f, -1.78080220e-02f, -5.23701310e-02f, 5.78125454e-02f, 1.99928824e-02f, 7.17760995e-04f, -2.86608748e-02f, -1.96297374e-02f,
  1.15572378e-01f, -2.12044790e-01f, -2.12748408e-01f, -3.01894486e-01f, -2.66677290e-01f, 1.63668826e-01f, 8.97530690e-02f, 1.57471970e-01f, -2.52999634e-01f, 2.51728326e-01f,
  -7.12503120e-02f, -1.61543265e-01f, -7.53843039e-02f, -9.02862921e-02f, -3.96130122e-02f, 6.48873508e-01f, 3.24849397e-01f, -3.06680858e-01f, 1.46710932e-01f, -2.25232258e-01f,
  -1.19062379e-01f, 3.81370867e-03f, -2.51460910e-01f, -3.51408124e-01f, -2.94469506e-01f, -1.64540246e-01f, -3.89528185e-01f, -3.64292920e-01f, 8.09830427e-02f, -1.20735005e-01f,
  6.21598251e-02f, -2.54888624e-01f, 1.02871604e-01f, 1.88097239e-01f, -1.53212640e-02f, 3.80496830e-02f, -2.09802493e-01f, 2.53839027e-02f, -2.52772123e-01f, -5.17431736e-01f,
  1.86468840e-01f, -1.58176452e-01f, -2.43814498e-01f, 3.42060983e-01f, -4.04664934e-01f, -2.11438671e-01f, -3.37421447e-01f, -8.90352726e-02f, -3.11085790e-01f, -1.10932618e-01f,
  -4.33407754e-01f, -2.48911418e-02f, -1.40810043e-01f, 2.09315374e-01f, -1.52006865e-01f, 3.27398390e-01f, -1.89505711e-01f, 2.28722215e-01f, -2.12753713e-01f, -1.18301436e-01f,
  -6.33999035e-02f, -1.61156312e-01f, -1.00002818e-01f, 1.58366233e-01f, -1.48840964e-01f, 2.93686926e-01f, -2.23944843e-01f, -4.87705618e-01f, -2.10295394e-01f, 4.70717698e-01f,
  4.70639616e-02f, 3.48617077e-01f, 1.18506392e-02f, 1.05812706e-01f, -1.15692057e-01f, -3.11115265e-01f, -9.72774178e-02f, 2.02393383e-01f, -5.14307201e-01f, 4.87028390e-01f,
  -2.26995591e-02f, 3.07729393e-01f, -2.92119205e-01f, -1.84740826e-01f, -2.32405975e-01f, -1.49320722e-01f, 8.58993754e-02f, 1.26476347e-01f, -2.00414330e-01f, -4.15925592e-01f,
  1.07755519e-01f, -8.41548666e-02f, 2.99632579e-01f, 2.81751342e-02f, 2.18620047e-01f, -5.39217889e-01f, -1.27998814e-01f, 1.75441086e-01f, 1.51759997e-01f, 3.58706772e-01f,
  -2.36514747e-01f, -3.84979844e-01f, -1.68939587e-02f, 9.70071778e-02f, 2.10309893e-01f, -8.36724788e-03f, 4.08402115e-01f, -3.35585147e-01f, -1.52906910e-01f, -2.67006427e-01f,
  -3.57911021e-01f, -2.62683779e-01f, 1.08984910e-01f, -4.66237590e-02f, 5.49747944e-01f, 2.15139419e-01f
};

// L1_linear_B (Shape: 1 x 12)
const int L1_linear_B_rows = 1;
const int L1_linear_B_cols = 12;
const float L1_linear_B_data[] = {
  -8.34273472e-02f, 1.66280285e-01f, 1.47551090e-01f, -1.16362923e-03f, -1.73754580e-02f, -1.65528338e-02f, 1.39551796e-02f, 4.56548966e-02f, 3.48084159e-02f, -3.57424431e-02f,
  4.04771157e-02f, 3.38266068e-03f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 12, 104
    );
    
    // Camada 1: L1_linear
    linear_forward_pgm(
        buffer1, x_out,
        L1_linear_W_data, L1_linear_B_data,
        128, 12
    );
    }
    