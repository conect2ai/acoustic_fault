/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 32 (x1)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 32;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    static inline float fan_activation(float x) { return x; }

    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 12 x 120)
const int L0_fan_Wp_rows = 12;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  3.64848554e-01f, 3.82044733e-01f, 7.94900674e-03f, 2.51182377e-01f, -1.40219957e-01f, 4.69590090e-02f, 3.52714390e-01f, 2.73811400e-01f, 9.60559770e-02f, 1.84658527e-01f,
  -1.76552549e-01f, -4.40032303e-01f, -3.07920426e-01f, -3.13134640e-01f, 2.46536490e-02f, 4.09197509e-01f, 1.49209976e-01f, -1.40151024e-01f, -2.15700015e-01f, -1.21137081e-02f,
  -4.89306636e-02f, 1.75667718e-01f, 2.20073089e-02f, 5.86935617e-02f, 1.53003693e-01f, 7.51890466e-02f, 1.44742265e-01f, 8.24238956e-02f, 3.45690139e-02f, 1.59768209e-01f,
  -1.44596487e-01f, 3.86447534e-02f, -1.27899513e-01f, -1.27295971e-01f, -1.33353239e-02f, 4.62647602e-02f, 7.50378221e-02f, 1.82613224e-01f, -4.75074910e-02f, 6.59142435e-02f,
  -6.59416895e-03f, 3.61643769e-02f, -4.76811118e-02f, 3.30802016e-02f, 1.19744331e-01f, 7.16576651e-02f, 8.75255913e-02f, 8.81705955e-02f, 9.80576053e-02f, 5.80037199e-02f,
  -7.43969828e-02f, 1.33920172e-02f, 5.09324446e-02f, 6.04605898e-02f, -1.19479094e-02f, -7.68070593e-02f, 1.31487370e-01f, 1.22497074e-01f, 9.66388658e-02f, 2.94200152e-01f,
  4.29887064e-02f, -1.07432991e-01f, -7.49927312e-02f, 5.71882818e-03f, -1.35539062e-02f, -1.96364038e-02f, -1.77270230e-02f, 2.46113748e-03f, -1.78746833e-03f, 4.07182425e-02f,
  1.32094580e-03f, 5.86628960e-03f, -5.48720360e-02f, 5.92315458e-02f, -4.30461466e-02f, 5.93166053e-03f, 5.30893169e-02f, 3.99508812e-02f, -5.28832711e-02f, 2.34345756e-02f,
  -6.07519038e-02f, -4.91865575e-02f, 5.34606799e-02f, 2.28381269e-02f, -4.72442806e-03f, 8.33622813e-02f, 8.84904116e-02f, -9.52840596e-02f, 4.37602699e-02f, 4.47887890e-02f,
  1.88150838e-01f, -3.18834871e-01f, 1.40114158e-01f, -2.90991762e-03f, 4.16292511e-02f, 6.08376488e-02f, 4.93579246e-02f, -2.19819508e-02f, -7.94712231e-02f, 1.15750268e-01f,
  -4.59411740e-02f, 4.56719175e-02f, 8.73810723e-02f, 2.55454481e-02f, -9.26197600e-03f, 1.44474646e-02f, 4.50776853e-02f, -4.42444310e-02f, 2.07128692e-02f, 1.01251617e-01f,
  1.11049540e-01f, 1.83012605e-01f, 1.04554810e-01f, 3.48296985e-02f, 1.06653377e-01f, -1.88511703e-02f, 8.07307139e-02f, 1.77663311e-01f, 1.62605211e-01f, 4.60631996e-01f,
  -7.14868665e-01f, 2.52707601e-01f, -3.62213224e-01f, -3.18203092e-01f, -1.07642032e-01f, 9.47150812e-02f, 2.16929123e-01f, 1.11409061e-01f, -5.92477620e-02f, -1.23688057e-01f,
  5.56802452e-02f, 7.83137679e-02f, 4.03264202e-02f, 3.70588861e-02f, 1.54776841e-01f, 1.70671523e-01f, 6.23899847e-02f, -3.24905694e-01f, -3.24495465e-01f, -2.47024864e-01f,
  -2.44094785e-02f, -2.05874428e-01f, -3.08575958e-01f, -1.57209143e-01f, -2.66796410e-01f, -1.92669019e-01f, 2.98720170e-02f, -2.72549037e-02f, 9.83512178e-02f, -2.67212927e-01f,
  -3.97738516e-01f, -3.44845533e-01f, -1.75244123e-01f, 4.94293757e-02f, -1.55900642e-01f, -2.29973644e-01f, -1.18216321e-01f, -2.11421311e-01f, -6.71717748e-02f, -8.31919014e-02f,
  -8.18282142e-02f, -1.68891177e-01f, -1.15783043e-01f, -1.16312608e-01f, -1.07474543e-01f, -1.11402288e-01f, -2.85410620e-02f, -1.72941372e-01f, -1.75427273e-02f, -1.63121864e-01f,
  1.28897458e-01f, -1.08231835e-01f, -1.32699251e-01f, 5.88748641e-02f, -1.29068885e-02f, -6.06336957e-03f, 1.00691663e-02f, -9.01864991e-02f, 7.36690983e-02f, -1.71615541e-01f,
  -3.29465866e-02f, -8.22005421e-02f, 1.47905380e-01f, 3.04236747e-02f, 1.36333749e-01f, 6.52395487e-02f, 3.39181982e-02f, 7.81699196e-02f, 6.76556081e-02f, -5.56520633e-02f,
  1.73865899e-01f, 9.04057696e-02f, 7.84524158e-02f, 4.38421071e-02f, 8.26209784e-02f, 2.04319432e-02f, 4.82774377e-02f, 1.61958605e-01f, 9.29392055e-02f, 4.69080545e-02f,
  1.03293695e-01f, 6.33357018e-02f, 8.35734829e-02f, 5.74124232e-02f, 2.03219235e-01f, 1.04905576e-01f, 1.00966364e-01f, 7.61355311e-02f, 1.64382719e-02f, 2.10594642e-03f,
  5.65501228e-02f, 2.66732514e-01f, -3.10490042e-01f, -2.23346025e-01f, -2.04274520e-01f, -3.97711620e-02f, -1.33643031e-01f, -1.64068937e-01f, -1.09786950e-01f, -1.30881473e-01f,
  -8.38609114e-02f, -2.26107955e-01f, -8.21593106e-02f, -4.40804102e-02f, -1.24334000e-01f, -1.45927712e-01f, 3.36654671e-02f, -1.48808703e-01f, 6.39041839e-03f, -1.43357441e-01f,
  -1.28833409e-02f, -5.64654432e-02f, -1.09906964e-01f, -2.58679409e-02f, -1.56075861e-02f, -1.85394391e-01f, -1.79159820e-01f, -2.20149875e-01f, -1.49715296e-03f, -1.16789542e-01f,
  7.00443015e-02f, -6.24424934e-01f, -3.39086987e-02f, 5.77620342e-02f, -1.26112595e-01f, -2.30246887e-01f, -4.37046587e-01f, -1.92597583e-01f, -4.83510755e-02f, -3.41199964e-01f,
  -1.65643081e-01f, 2.98276931e-01f, 1.73231781e-01f, 2.01563075e-01f, 7.98340142e-02f, -2.89853305e-01f, -1.10433199e-01f, 3.84877712e-01f, 2.52406299e-01f, 1.08147703e-01f,
  -1.53022038e-03f, 2.31590644e-02f, 1.71940267e-01f, 2.22616389e-01f, 2.17733183e-03f, 2.13904642e-02f, -1.38929814e-01f, 1.53918676e-02f, -2.14092117e-02f, 1.79426879e-01f,
  9.54165459e-02f, 8.52313545e-03f, 1.00288913e-01f, 1.64343372e-01f, -1.69874858e-02f, 7.31193274e-02f, -1.45862077e-03f, -1.47406766e-02f, 1.61542837e-02f, -2.29510665e-02f,
  6.17890321e-02f, 3.10285203e-02f, 5.01399636e-02f, 4.41401862e-02f, -2.10882891e-02f, -2.15714914e-03f, 4.76901270e-02f, 1.57246932e-01f, 3.32706161e-02f, -4.69696708e-02f,
  6.70712963e-02f, -3.26926149e-02f, -6.54301345e-02f, -1.39141887e-01f, -5.83752468e-02f, 1.40283763e-01f, -1.45189520e-02f, 1.31499574e-01f, -1.52275257e-03f, -5.55589534e-02f,
  7.11695701e-02f, 2.65672579e-02f, 3.79873738e-02f, 1.08845355e-02f, -6.35173842e-02f, 3.93201262e-02f, 2.64540967e-02f, -5.80645017e-02f, 2.21018214e-02f, -1.26554118e-02f,
  -4.57824441e-03f, -2.11162809e-02f, 1.39968954e-02f, -5.89340702e-02f, 6.56648129e-02f, -2.63091102e-02f, 2.25598877e-03f, -5.38506247e-02f, 5.31763509e-02f, 1.94158237e-02f,
  1.05165035e-01f, 3.51297185e-02f, 2.77816039e-02f, 2.94463914e-02f, 1.79072004e-02f, 1.12774856e-02f, 4.41790149e-02f, 6.76082671e-02f, -1.28492611e-02f, 5.40363602e-03f,
  -3.14260334e-01f, -7.92260617e-02f, 1.76292136e-02f, 3.07984725e-02f, -2.84197237e-02f, -6.02749698e-02f, 2.53482349e-02f, 4.62131463e-02f, 7.53284916e-02f, -2.42917743e-02f,
  -5.28328419e-02f, -4.73262593e-02f, -9.10820365e-02f, -1.76900104e-02f, -1.36021748e-01f, -6.42376170e-02f, -3.56860869e-02f, 7.96347633e-02f, -1.09131306e-01f, -1.09229051e-01f,
  -9.45901349e-02f, -1.71290904e-01f, -8.73198807e-02f, -1.82340875e-01f, -6.26501217e-02f, 3.08555067e-02f, -2.21940801e-01f, -1.32239878e-01f, -1.75914302e-01f, -3.77802938e-01f,
  5.06597102e-01f, -2.39101022e-01f, -1.44744843e-01f, 2.04178751e-01f, 6.85169250e-02f, -5.92293590e-02f, -3.58571649e-01f, -5.14884591e-02f, -8.84670485e-03f, -1.89121589e-01f,
  2.06338212e-01f, 2.41492063e-01f, -3.04479506e-02f, -1.20189004e-01f, -1.10681310e-01f, -4.60233688e-01f, -6.09711945e-01f, -1.99381635e-01f, 7.54363984e-02f, 3.82050015e-02f,
  -1.69690520e-01f, 1.38107508e-01f, 3.34781140e-01f, -3.12864780e-02f, -2.08124518e-01f, -1.99352413e-01f, -1.67144164e-01f, 3.28443684e-02f, -2.33122602e-01f, -6.18842483e-01f,
  -1.90252692e-01f, 6.39000311e-02f, 1.06128457e-03f, 3.03099514e-03f, 4.33005057e-02f, -1.39407769e-01f, -8.12219530e-02f, -2.11137924e-02f, -1.12171993e-02f, -1.25224531e-01f,
  -3.18990313e-02f, -1.85120869e-02f, 2.48635318e-02f, -9.73045975e-02f, -8.22056383e-02f, -3.18572074e-02f, -7.87472129e-02f, -9.12636593e-02f, -1.67122677e-01f, -1.11745417e-01f,
  -5.17527871e-02f, 3.52864228e-02f, 6.94798306e-02f, -1.23945698e-01f, -6.85417503e-02f, 7.45138377e-02f, -6.40521869e-02f, -4.83734235e-02f, -1.15176246e-01f, -3.48557025e-01f,
  3.96992750e-02f, 8.93736258e-02f, 5.06592579e-02f, 7.71708935e-02f, 5.91286309e-02f, 1.02587454e-01f, 2.02809125e-02f, 2.60773785e-02f, 3.60404924e-02f, 6.22331612e-02f,
  9.09581780e-02f, 6.05863854e-02f, 3.44230514e-03f, 4.24185507e-02f, -1.21827582e-02f, 1.26720056e-01f, -5.22222742e-03f, -3.53057757e-02f, 7.00600911e-03f, 3.07793147e-03f,
  7.78872520e-02f, 5.42587638e-02f, 6.63959980e-02f, 4.99577671e-02f, -1.61137292e-03f, 6.04364574e-02f, 7.08530024e-02f, 1.46324351e-01f, 1.45027205e-01f, 1.09288342e-01f,
  1.11210579e-02f, 1.36546493e-01f, -2.27837235e-01f, -7.61267170e-02f, -7.51387328e-02f, -8.11281949e-02f, -1.29138350e-01f, -9.13305581e-02f, 4.70883213e-02f, -6.04526065e-02f,
  5.53443618e-02f, -2.89816316e-02f, -9.13093612e-02f, -1.26648918e-01f, -6.15600869e-02f, -1.43298790e-01f, -7.36127645e-02f, -1.35076657e-01f, -9.62920189e-02f, -8.33958760e-02f,
  -1.14712492e-01f, -1.53289676e-01f, -8.87132213e-02f, -1.91331461e-01f, -4.72283512e-02f, -9.84461829e-02f, -2.36499459e-01f, -2.16651320e-01f, -1.36720344e-01f, -2.52500504e-01f,
  -1.29932070e+00f, -3.27402860e-01f, 2.27593228e-01f, -4.56782103e-01f, 2.45483175e-01f, 2.89231479e-01f, 9.23709050e-02f, 1.04780599e-01f, -1.63256526e-01f, -1.44051999e-01f,
  1.65727139e-02f, -9.40539092e-02f, 2.70619504e-02f, 1.06693245e-01f, -6.44979486e-03f, -2.75875032e-02f, 1.52059361e-01f, -2.90971212e-02f, 2.22298857e-02f, -1.70190766e-01f,
  -7.76329190e-02f, -2.54225045e-01f, -3.94292176e-01f, -5.82483299e-02f, 6.42993525e-02f, 1.35641411e-01f, 2.18962386e-01f, -8.66475254e-02f, 1.24658346e-01f, -2.59576589e-01f,
  -2.28546411e-01f, -3.46185505e-01f, 5.76989315e-02f, -1.41145647e-01f, 3.56150307e-02f, -1.59187734e-01f, -1.42845884e-01f, -1.15975186e-01f, -6.84870332e-02f, -1.44212395e-01f,
  -1.22625515e-01f, -1.47901028e-01f, -9.21997204e-02f, 1.82282329e-02f, -8.84527713e-02f, -6.50152639e-02f, 2.87151486e-02f, -1.52620822e-02f, 3.89454626e-02f, -3.71599533e-02f,
  -2.05409192e-02f, -1.66306719e-01f, -1.00698741e-02f, 1.41886666e-01f, 6.26821863e-03f, -4.43122424e-02f, -1.47778178e-02f, -7.24857524e-02f, 5.57950810e-02f, -2.17214301e-01f,
  -1.43018320e-01f, 4.07259651e-02f, 1.01682864e-01f, -1.56391300e-02f, 6.99201077e-02f, 4.09055836e-02f, 6.48308545e-02f, 3.00425626e-02f, 2.50343829e-02f, 1.04166359e-01f,
  9.23835263e-02f, 7.38024935e-02f, 7.15969801e-02f, -1.79621726e-02f, 1.27656788e-01f, 8.21811110e-02f, 2.15820763e-02f, 7.48484880e-02f, 6.38550222e-02f, 8.73637795e-02f,
  6.48681521e-02f, 1.03917070e-01f, 4.40094657e-02f, 1.53324023e-01f, 8.10260996e-02f, 1.31868333e-01f, -1.24396561e-02f, 8.29321295e-02f, 9.31613445e-02f, 2.18724962e-02f,
  -1.50848970e-01f, 2.23305732e-01f, -2.94546783e-01f, -4.30589207e-02f, -1.54626429e-01f, 2.54132412e-03f, -2.88057849e-02f, -3.58139537e-02f, -7.98792019e-02f, -1.06690869e-01f,
  -2.86134612e-02f, -9.51431841e-02f, -5.07453717e-02f, -3.42138484e-03f, -1.20752655e-01f, -1.23397186e-01f, -1.08951233e-01f, -3.00655756e-02f, 1.01359549e-03f, -9.66841727e-02f,
  -2.00855357e-04f, -7.08506107e-02f, -2.49184772e-01f, -4.20623198e-02f, -9.00519118e-02f, -9.57534388e-02f, 5.10489233e-02f, 1.62225757e-02f, -1.25829754e-02f, -1.55987442e-01f,
  -2.75878340e-01f, 1.20284475e-01f, 1.79560840e-01f, -3.79869640e-02f, -4.16431166e-02f, -1.70915965e-02f, 1.15761705e-01f, -1.52153696e-03f, -1.41578242e-01f, -1.01790391e-02f,
  -6.14098869e-02f, -3.59019130e-01f, -3.44607353e-01f, -2.62174308e-01f, -3.69064212e-02f, 1.96442753e-02f, 1.64275393e-01f, -1.77317679e-01f, -4.23126906e-01f, -2.88030744e-01f,
  -2.64854252e-01f, 1.73900370e-02f, -6.71096370e-02f, -1.02951869e-01f, -6.69304878e-02f, -1.75194457e-01f, 1.87557697e-01f, 1.20225303e-01f, -2.04163240e-04f, -8.65921751e-02f,
  -3.33240211e-01f, 2.43712738e-02f, -2.56172150e-01f, -2.27189437e-01f, -1.15363061e-01f, -2.31520846e-01f, -2.75065839e-01f, -2.02612653e-01f, -1.43178463e-01f, -7.60631859e-02f,
  -1.57834142e-01f, -2.18047813e-01f, -8.78686830e-02f, -1.11008994e-01f, -7.49807507e-02f, -1.48656011e-01f, -8.70688483e-02f, -6.45791069e-02f, -1.26858577e-02f, -2.30304748e-01f,
  -1.68064862e-01f, -1.78255897e-03f, 9.18970183e-02f, -4.67297882e-02f, -1.64114043e-01f, -1.83345303e-01f, 1.28073068e-02f, -1.88878268e-01f, -3.03522833e-02f, -1.50402144e-01f,
  -1.07119471e-01f, 1.61380172e-01f, 2.33120359e-02f, 2.29794011e-01f, 5.59765399e-02f, 8.49404857e-02f, 6.64884448e-02f, 8.06699321e-02f, 6.88860565e-02f, 1.53767571e-01f,
  6.08537048e-02f, -1.89673458e-03f, 1.12220056e-01f, 6.08606003e-02f, -8.84243660e-03f, 2.22256869e-01f, 1.43696412e-01f, 2.05259264e-01f, 1.33133769e-01f, 1.71403632e-01f,
  5.44658676e-02f, 1.32659614e-01f, 9.77013782e-02f, 1.27577171e-01f, 1.41540125e-01f, 1.47590786e-01f, 7.66894519e-02f, 1.19696528e-01f, 1.50931627e-01f, 1.65146366e-01f,
  -2.84667879e-01f, 4.82588820e-02f, -3.24799448e-01f, -2.16606632e-01f, -1.61485836e-01f, -1.74616545e-01f, -1.63259804e-01f, -9.57848579e-02f, -1.37757629e-01f, -1.99473903e-01f,
  -1.31774008e-01f, -1.65080860e-01f, -5.92062920e-02f, -6.26769811e-02f, -1.67129293e-01f, -1.85579196e-01f, -2.39017364e-02f, -1.54798195e-01f, -1.34119719e-01f, -7.66892880e-02f,
  -5.82669042e-02f, -2.20912009e-01f, -3.47403675e-01f, -2.03350067e-01f, -7.96701461e-02f, -3.20806384e-01f, -1.67701736e-01f, -2.33716980e-01f, -2.09555894e-01f, -2.75846690e-01f,
  -1.46641657e-01f, -2.22602695e-01f, -3.61072242e-01f, 1.34036183e-01f, 3.68109584e-01f, 3.17173153e-01f, 4.13155675e-01f, 1.03441216e-01f, -6.00099154e-02f, -9.50073302e-02f,
  -2.14586169e-01f, -2.78869212e-01f, -3.01661313e-01f, -3.99357378e-01f, -2.96120077e-01f, 9.15072113e-02f, 3.80470231e-02f, -2.36991465e-01f, -1.01730861e-01f, 1.30325511e-01f,
  2.63943315e-01f, 1.86689928e-01f, -2.37024322e-01f, -1.66469783e-01f, 1.79278880e-01f, 2.66833156e-02f, -1.16745397e-01f, -7.01950565e-02f, -2.15158880e-01f, -2.00020626e-01f,
  -3.65252286e-01f, -2.73116767e-01f, -6.33940920e-02f, -2.23911822e-01f, -2.12419316e-01f, -1.32541940e-01f, -1.63423359e-01f, -2.22715840e-01f, -1.67938441e-01f, -2.60219276e-01f,
  -2.08969042e-01f, -1.65172681e-01f, -1.99205354e-01f, -1.51814133e-01f, -2.92348769e-02f, -6.01680838e-02f, -1.66735366e-01f, -2.10175961e-01f, -2.64269859e-01f, -2.84709424e-01f,
  -8.18673447e-02f, -2.03918770e-01f, -1.89089730e-01f, -2.33390898e-01f, -2.47150525e-01f, -3.13794702e-01f, -1.84142902e-01f, -1.23899736e-01f, -2.71010369e-01f, -9.07568634e-03f,
  -7.62316436e-02f, 2.68294103e-02f, 7.97714293e-02f, 8.96622017e-02f, 1.14708751e-01f, 5.53126596e-02f, 1.44791707e-01f, 1.37372732e-01f, 7.58941025e-02f, 2.29691759e-01f,
  8.19981843e-02f, 1.10472972e-02f, 6.15192205e-02f, 1.16267897e-01f, 3.29530798e-03f, 7.14354366e-02f, 7.13411272e-02f, 4.41811085e-02f, 4.74326499e-02f, 7.93271959e-02f,
  6.70532463e-04f, 1.09947085e-01f, 9.34505537e-02f, 6.71151429e-02f, 8.27222317e-02f, 2.20848087e-04f, 1.25423580e-01f, 8.27766508e-02f, 1.07851580e-01f, 5.87164238e-02f,
  3.93190309e-02f, -3.36435378e-01f, -2.35664416e-02f, -8.39800537e-02f, -8.28394517e-02f, -2.70283669e-01f, -8.96484703e-02f, -1.98591456e-01f, -1.91161633e-01f, -1.23306625e-01f,
  -1.93298131e-01f, -1.55149370e-01f, -1.15122460e-01f, -1.18382655e-01f, -5.12159280e-02f, -1.74644783e-01f, -3.78509201e-02f, -9.29430351e-02f, -1.66029736e-01f, -1.19128242e-01f,
  -1.24281943e-02f, -1.82235315e-02f, -8.68664682e-03f, -1.03845172e-01f, -8.55371952e-02f, -5.59799932e-02f, -2.05030814e-02f, -3.52212810e-04f, -1.46199077e-01f, 1.60344169e-01f,
  -7.74246514e-01f, 5.65933406e-01f, 4.20520931e-01f, -4.16918486e-01f, 1.42385051e-01f, 3.14201802e-01f, 5.96411109e-01f, 1.41119629e-01f, -1.72103196e-01f, 8.53902772e-02f,
  1.30893454e-01f, -3.07708502e-01f, -2.35076949e-01f, -6.74015731e-02f, 3.23912427e-02f, 2.58938909e-01f, 2.05961958e-01f, -1.19284861e-01f, -1.61334813e-01f, 1.16608977e-01f,
  3.39682400e-02f, -7.21803233e-02f, -2.63183236e-01f, -7.24603012e-02f, -4.71126884e-02f, -4.01427656e-01f, -9.46680643e-03f, -7.98443612e-03f, 4.06065304e-03f, -1.98577419e-01f,
  -1.33173936e-03f, 1.03092119e-01f, -8.10010582e-02f, -7.45025948e-02f, 5.78809977e-02f, -1.41896024e-01f, -9.09694880e-02f, -9.32173207e-02f, -3.84626836e-02f, 5.81736602e-02f,
  -7.56740384e-03f, -1.36559876e-02f, 2.33712383e-02f, 6.41325265e-02f, 4.90057329e-03f, 3.05972137e-02f, -2.40516756e-02f, 3.49691100e-02f, 2.83323936e-02f, 6.42116219e-02f,
  1.99414954e-01f, 3.89935896e-02f, 1.48025498e-01f, 1.28337622e-01f, 1.86630175e-01f, 6.00658171e-02f, 6.28831908e-02f, -6.47488758e-02f, 5.93713894e-02f, -2.50764072e-01f,
  -9.45395231e-02f, 6.37572557e-02f, 2.76216920e-02f, 4.65438177e-04f, -1.96385719e-02f, -3.21895182e-02f, -1.27515979e-02f, -2.23617963e-02f, 5.15722819e-02f, -1.43715188e-01f,
  3.28824185e-02f, 1.14967534e-02f, 4.75886054e-02f, -7.79670775e-02f, -9.62055102e-02f, 4.86520901e-02f, 2.45226361e-02f, 8.98196734e-03f, 4.36778255e-02f, -3.07332389e-02f,
  8.68239556e-04f, 8.46439227e-02f, 1.22537045e-02f, -3.03750504e-02f, 1.16037719e-01f, -3.81165929e-03f, -3.54092452e-03f, -6.08945265e-02f, -3.24944183e-02f, 6.60236739e-03f,
  -1.11746058e-01f, 1.72371864e-01f, -1.77885100e-01f, 4.60954709e-03f, -1.56957761e-03f, 2.21280311e-03f, -3.67988385e-02f, 7.21836910e-02f, 6.61281422e-02f, 7.84461498e-02f,
  9.97337624e-02f, -4.37152609e-02f, -2.52573062e-02f, 2.69470513e-02f, -5.30045331e-02f, -8.50876048e-02f, -1.90211181e-03f, -3.41832265e-02f, 7.70436972e-02f, 9.60035995e-02f,
  6.45808652e-02f, -3.75911966e-02f, -1.35939747e-01f, -4.96592671e-02f, -6.50232732e-02f, -1.24584123e-01f, -4.36773412e-02f, -9.80737805e-02f, -8.87505617e-03f, -1.30010128e-01f,
  -3.18803370e-01f, -4.58766997e-01f, -5.25675416e-01f, -3.43874812e-01f, -3.37633103e-01f, -1.70268372e-01f, -4.16826546e-01f, -1.79163516e-01f, -1.94412842e-01f, -3.62281352e-01f,
  -6.66301772e-02f, -3.50243226e-02f, -1.83556601e-01f, -1.46740988e-01f, -3.50865513e-01f, -5.11055827e-01f, -6.01027966e-01f, -4.16588634e-01f, -2.18388617e-01f, -1.24340981e-01f,
  -7.80577809e-02f, -2.65026480e-01f, -1.18563712e-01f, -1.60541043e-01f, -2.25929245e-01f, -8.48444775e-02f, -3.11640739e-01f, -6.15634434e-02f, -8.94790664e-02f, -3.87001067e-01f,
  -6.04313910e-01f, -3.61116111e-01f, -4.87800464e-02f, -1.80833265e-02f, -8.70767683e-02f, -7.92295933e-02f, -1.49676025e-01f, -1.51304215e-01f, -4.57191616e-02f, -2.13823721e-01f,
  -1.58144578e-01f, -5.22736087e-02f, -1.27339214e-01f, -1.52794495e-01f, -2.13281989e-01f, -1.75674543e-01f, -5.51696457e-02f, -2.27208525e-01f, -1.35291204e-01f, -1.33810118e-01f,
  1.45637402e-02f, -3.72482464e-02f, -1.39993817e-01f, -1.71101391e-01f, -1.20117016e-01f, 6.13823906e-03f, -1.17694765e-01f, -6.77504614e-02f, -6.37816861e-02f, -2.28043497e-01f,
  1.47610232e-01f, 8.66836905e-02f, 1.67947724e-01f, 1.38398960e-01f, 1.15653686e-01f, 1.64573267e-01f, 6.47977740e-02f, 7.32374713e-02f, 1.10182829e-01f, 1.79546177e-01f,
  5.01237027e-02f, 5.49438857e-02f, 3.77876870e-02f, 9.25488025e-03f, 7.82155320e-02f, 6.91193789e-02f, 1.07134886e-01f, 7.39142373e-02f, 1.32748425e-01f, 1.43546104e-01f,
  1.08033925e-01f, 1.57027468e-01f, 9.42391902e-02f, 9.55292881e-02f, 7.37658367e-02f, 8.44521374e-02f, 4.02552150e-02f, 1.99940562e-01f, 1.66942716e-01f, 4.87454198e-02f,
  -5.26365824e-04f, 5.34006692e-02f, -3.13893199e-01f, -1.40412465e-01f, -1.52252644e-01f, -6.89612255e-02f, -1.75687402e-01f, -1.43043086e-01f, -1.72716454e-01f, -1.69341758e-01f,
  -8.24588761e-02f, -1.86337262e-01f, -2.10843012e-01f, -5.63914478e-02f, -1.48582324e-01f, -1.51452765e-01f, -9.30238143e-02f, -2.02981457e-01f, -3.05878855e-02f, -2.46382933e-02f,
  -4.57240231e-02f, -1.29272580e-01f, -2.22674683e-02f, -7.06487447e-02f, -8.26497674e-02f, -1.25182644e-01f, -1.83679879e-01f, -7.64449835e-02f, -8.70156214e-02f, -1.17678151e-01f,
  -7.97491297e-02f, 4.40290838e-01f, -2.06180140e-01f, 1.33219615e-01f, 3.51710200e-01f, 1.84322029e-01f, 2.33932748e-01f, 1.11158900e-02f, 1.06484428e-01f, 2.23498553e-01f,
  1.52553067e-01f, -2.17191234e-01f, -2.55287111e-01f, -3.05602372e-01f, -3.86371613e-01f, 5.59728332e-02f, 1.59230411e-01f, -3.50110412e-01f, -4.16842878e-01f, -3.15332301e-02f,
  1.52143985e-01f, 1.57519668e-01f, -1.82271883e-01f, -8.38644207e-02f, 3.39552015e-01f, 2.89668478e-02f, 1.20258838e-01f, 2.59006858e-01f, 9.03896838e-02f, 3.97186607e-01f,
  -2.21460432e-01f, 1.64874971e-01f, -2.58395314e-01f, 9.78586599e-02f, 4.09542508e-02f, -1.01940125e-01f, -7.79206306e-02f, -7.83849135e-02f, 5.70698082e-03f, -2.35128254e-02f,
  8.29161331e-02f, -2.85745915e-02f, 1.64091904e-02f, 2.73694079e-02f, 7.36680999e-02f, -8.58571902e-02f, -6.57538772e-02f, -1.44953653e-01f, -1.49279967e-01f, -7.92471692e-03f,
  1.04224145e-01f, 8.82380903e-02f, 2.91868206e-02f, -2.61842087e-02f, -7.44471401e-02f, -4.11933437e-02f, -5.76107241e-02f, 4.52820286e-02f, -1.08795725e-01f, 2.14774664e-02f,
  -3.43273580e-02f, 5.29064015e-02f, 6.65339231e-02f, 1.29525987e-02f, 1.14822490e-02f, -6.83972985e-02f, 1.88376009e-03f, 5.12767322e-02f, -7.35255715e-04f, -2.46678814e-02f,
  -7.23855868e-02f, -3.38940583e-02f, -7.36367479e-02f, -6.91528097e-02f, 7.80410878e-03f, -4.82557565e-02f, 3.52113582e-02f, -6.87770098e-02f, -1.72741916e-02f, -2.50409618e-02f,
  -4.23089415e-02f, -9.30177495e-02f, -5.42159937e-02f, -9.33151543e-02f, 1.26097933e-04f, -3.56160998e-02f, -2.28340495e-02f, 4.79462966e-02f, -5.21746427e-02f, 3.35387103e-02f,
  -2.35632733e-01f, -3.73624265e-01f, -6.36746436e-02f, -9.47409645e-02f, 6.92475364e-02f, -5.31359948e-02f, 3.87546644e-02f, 5.85208088e-02f, 6.89913556e-02f, -4.69807014e-02f,
  4.60981540e-02f, -7.59441033e-02f, -3.31675797e-03f, -3.28744240e-02f, -6.79757521e-02f, 2.30275914e-02f, 1.37990728e-01f, -4.28367406e-02f, -8.63522440e-02f, 7.54551291e-02f,
  9.59178582e-02f, 7.20958635e-02f, -2.08453506e-01f, -3.94453742e-02f, 2.22101752e-02f, -1.29049018e-01f, -5.55161797e-02f, -3.77842709e-02f, -1.99627966e-01f, -1.12810312e-02f,
  -2.84966767e-01f, 1.42787829e-01f, -1.65329367e-01f, -1.24827530e-02f, -5.24931587e-02f, -2.51846641e-01f, -3.83823514e-01f, -1.62860826e-01f, 1.72978658e-02f, -3.84390615e-02f,
  1.83539569e-01f, 2.10588485e-01f, 1.99114457e-01f, 6.30855709e-02f, -3.17836910e-01f, -2.75946289e-01f, -3.38085741e-01f, -3.64060283e-01f, -3.32162410e-01f, -2.99326181e-01f,
  -1.40729234e-01f, -1.15532413e-01f, -1.94012895e-01f, -6.65485859e-02f, 1.00410208e-01f, 1.19254544e-01f, 7.70741701e-02f, 1.55527562e-01f, -3.93131003e-03f, 2.14563027e-01f,
  2.08418608e-01f, 2.90776268e-02f, -2.52318501e-01f, -6.73883483e-02f, -6.47301748e-02f, -3.19110416e-02f, -5.64302541e-02f, -6.60812035e-02f, -6.64026185e-04f, -1.15847975e-01f,
  -3.91885415e-02f, -1.17589481e-01f, -1.42507628e-01f, -4.49894592e-02f, -1.06665514e-01f, -4.89232391e-02f, -1.73186794e-01f, -1.60956249e-01f, -7.53533542e-02f, -3.63383666e-02f,
  -4.50033043e-03f, -4.18328531e-02f, -1.42646328e-01f, -1.10541493e-01f, -1.43216923e-01f, -5.18511087e-02f, 6.50954992e-02f, -2.22937595e-02f, -1.41746730e-01f, 1.04653753e-01f,
  -1.46423042e-01f, 9.07083228e-02f, 1.26517609e-01f, 1.32840276e-02f, 8.45263079e-02f, 1.04580082e-01f, 3.14891487e-02f, -1.45820193e-02f, 4.63875197e-03f, 5.11258794e-03f,
  1.18795887e-01f, 1.22354543e-02f, -3.13410233e-03f, -3.73846926e-02f, 1.14487417e-01f, -1.46017550e-02f, -4.18813154e-02f, 2.28569121e-03f, 8.87768995e-03f, -8.91098101e-03f,
  6.57497868e-02f, -4.97018918e-02f, -5.02428487e-02f, 3.27856280e-02f, 4.95476127e-02f, -1.48384785e-02f, -3.33855823e-02f, 4.92324568e-02f, 3.95159498e-02f, -7.17926845e-02f,
  3.48725557e-01f, -2.42049158e-01f, 1.35550881e-02f, -1.56550482e-01f, -6.46081492e-02f, -7.55751180e-03f, -5.17346188e-02f, -1.12389475e-01f, -5.77106848e-02f, 4.89685358e-03f,
  -1.09255292e-01f, -7.02988058e-02f, -1.65473518e-03f, -5.45122139e-02f, -1.37841746e-01f, -8.57487991e-02f, -1.89154968e-01f, 4.10905667e-02f, -7.49512613e-02f, 6.23142645e-02f,
  -4.00079004e-02f, -1.36381134e-01f, 3.20606977e-02f, 7.97168314e-02f, -6.82457956e-03f, -1.45158887e-01f, -3.62868309e-02f, -5.94910905e-02f, -9.59622636e-02f, -1.60987094e-01f,
  1.33178949e-01f, 1.76923543e-01f, 7.27764785e-01f, 2.31778622e-01f, 1.80830225e-01f, 4.56964225e-02f, 1.34265661e-01f, -1.16905659e-01f, -7.59297088e-02f, 1.10211827e-01f,
  5.72465472e-02f, -1.73877314e-01f, -1.11432925e-01f, -1.74823105e-01f, -1.46584541e-01f, 1.49163261e-01f, 1.51588684e-02f, -2.79083988e-03f, -1.63019300e-01f, -1.66931838e-01f,
  -2.47097552e-01f, -6.22630380e-02f, -1.10568389e-01f, -1.02019057e-01f, 1.54369354e-01f, -7.28131086e-02f, 2.27722466e-01f, 1.40088663e-01f, -9.65522975e-02f, 2.70268947e-01f,
  5.61113715e-01f, 2.28940561e-01f, -1.40074596e-01f, -2.50738084e-01f, 8.74902830e-02f, -9.31060985e-02f, 6.52130507e-03f, -3.78449522e-02f, -2.87943077e-03f, -3.65187041e-02f,
  5.93889169e-02f, -7.69053847e-02f, 5.06734550e-02f, -1.93098933e-02f, 4.93247844e-02f, 5.12135513e-02f, 3.37803811e-02f, 4.36956026e-02f, -4.01019379e-02f, 3.58363017e-02f,
  9.63233504e-03f, 1.50120005e-01f, 2.69630671e-01f, -6.05808059e-03f, -1.22804819e-02f, -6.15016408e-02f, 1.11452311e-01f, 2.88147721e-02f, 9.98946950e-02f, -8.82737059e-03f,
  -2.94974279e-02f, 1.39975036e-02f, 2.92888633e-03f, -1.70426648e-02f, -4.02135402e-02f, -6.63574189e-02f, 1.03457104e-02f, 6.00436120e-04f, -1.23588368e-02f, -2.15878757e-03f,
  -6.35155588e-02f, -3.36414650e-02f, 1.70261357e-02f, -1.72880217e-02f, -1.13650799e-01f, 1.24838538e-01f, 1.10732736e-02f, 1.48961004e-02f, -3.52879353e-02f, -8.91087428e-02f,
  -6.41799495e-02f, -8.89743026e-03f, 1.05366027e-02f, -5.59799336e-02f, -9.05277655e-02f, 1.07192574e-02f, 4.21344899e-02f, -9.41294432e-02f, 5.35317045e-03f, 9.41426586e-03f,
  -1.59931734e-01f, -3.84974517e-02f, -7.95106068e-02f, -1.62495673e-02f, 4.33606505e-02f, -4.42338847e-02f, 2.75440365e-02f, -9.83752683e-03f, -6.61007874e-03f, 3.94594073e-02f,
  -3.04810349e-02f, 7.78855290e-03f, 4.46306653e-02f, -5.32551333e-02f, -5.04335277e-02f, -5.10626882e-02f, -9.95932892e-02f, -1.10652866e-02f, -5.15607297e-02f, 1.15732707e-01f,
  -1.19331986e-01f, -1.00600593e-01f, -8.49198326e-02f, -1.22250430e-02f, -3.57823223e-02f, -9.03939903e-02f, -7.53104314e-02f, -3.23469713e-02f, -6.07919469e-02f, -1.87734857e-01f
};

// L0_fan_Wp_bar (Shape: 8 x 120)
const int L0_fan_Wp_bar_rows = 8;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  3.48473340e-01f, -6.96007490e-01f, -2.67722547e-01f, 6.27631903e-01f, 4.15560782e-01f, 5.01153231e-01f, 1.67430386e-01f, 4.18133944e-01f, 5.28203368e-01f, 2.26009220e-01f,
  9.10160877e-03f, 4.10337299e-01f, 3.78763467e-01f, 2.20265687e-01f, 1.87653765e-01f, 2.43598610e-01f, 4.65836465e-01f, 8.91162455e-02f, 2.24319667e-01f, 3.45919490e-01f,
  4.99222934e-01f, 7.68830553e-02f, -2.34711736e-01f, 2.93475087e-03f, -1.45534992e-01f, 3.64115983e-01f, -1.28373072e-01f, -2.17695847e-01f, -2.01007411e-01f, -1.29348591e-01f,
  -6.21321857e-01f, -1.10510394e-01f, 3.92426878e-01f, 1.68515090e-02f, -1.31316289e-01f, -1.38089776e-01f, 1.87956207e-02f, -3.31887603e-01f, -3.06913316e-01f, 1.08418036e-02f,
  -2.69758608e-02f, -1.07162766e-01f, -7.21098557e-02f, -6.45722225e-02f, -7.92880803e-02f, -1.84735090e-01f, -1.16061188e-01f, 7.80578256e-02f, 1.54079527e-01f, -1.07861571e-01f,
  -6.55535832e-02f, 5.60753830e-02f, -8.28865692e-02f, 8.11683610e-02f, -2.27986649e-02f, 1.76692620e-01f, -2.30686173e-01f, -8.25687274e-02f, 9.03241411e-02f, 6.46918938e-02f,
  2.62773752e-01f, -1.90104872e-01f, -1.23166993e-01f, 2.20665649e-01f, 1.12713195e-01f, 2.32108831e-01f, 6.34073839e-02f, 6.96971221e-03f, 2.62473822e-01f, -9.20884833e-02f,
  5.51359318e-02f, 1.84136212e-01f, 3.46724913e-02f, 2.14205787e-01f, -2.04985719e-02f, -1.64920926e-01f, -1.83149725e-01f, -9.08705741e-02f, -2.11087644e-01f, -1.52931362e-01f,
  -6.34977371e-02f, 1.11695249e-02f, -3.78282011e-01f, -2.20878005e-01f, -5.71181476e-02f, 1.01596199e-01f, 3.86953428e-02f, -1.00633278e-01f, -2.49762144e-02f, -6.66093156e-02f,
  1.69597883e-02f, 3.34648281e-01f, 2.19708994e-01f, -2.81498767e-02f, -2.42775127e-01f, -3.94395053e-01f, -1.29915148e-01f, -2.23070875e-01f, -2.74693966e-01f, -4.23015095e-02f,
  -1.40952721e-01f, -2.13504657e-01f, -1.88915566e-01f, -1.43877685e-01f, -3.80488150e-02f, 2.85756737e-02f, -1.16074055e-01f, 1.27011508e-01f, 1.07201606e-01f, -1.23124942e-01f,
  -1.05683930e-01f, 2.20114931e-01f, 1.84939578e-01f, 2.07992435e-01f, 1.56336531e-01f, 4.10896510e-01f, -2.11236760e-01f, -1.72071494e-02f, 1.08529121e-01f, 2.61484206e-01f,
  5.62319815e-01f, 2.98376381e-01f, 4.23556060e-01f, 1.82315901e-01f, -6.91754997e-01f, -8.08205009e-01f, -5.98440289e-01f, -3.77433151e-01f, -4.10898894e-01f, -4.05419409e-01f,
  -7.20984936e-01f, -3.58655959e-01f, 5.50157204e-03f, 2.60477334e-01f, 4.73414749e-01f, 2.83302724e-01f, 8.12395334e-01f, 1.11001408e+00f, 3.99701208e-01f, -6.72469288e-02f,
  3.26127522e-02f, 3.24159205e-01f, 6.32804632e-01f, 3.83136749e-01f, 2.36451671e-01f, -2.60670245e-01f, 1.79822501e-02f, 2.36625925e-01f, -3.95783857e-02f, 1.02028453e+00f,
  -5.14294021e-02f, 3.82350087e-02f, -6.53810024e-01f, -1.10141903e-01f, 4.70959432e-02f, 6.35026395e-02f, -1.14751026e-01f, 1.96469188e-01f, -8.56454670e-02f, -1.42979538e-02f,
  -1.25234231e-01f, 2.42215991e-01f, 1.78818300e-01f, 2.03640699e-01f, -1.28908277e-01f, -2.38142431e-01f, 3.81425470e-01f, 6.22142792e-01f, 1.91003963e-01f, -1.03362426e-02f,
  1.75684318e-01f, -1.70347914e-01f, -1.42690167e-01f, -4.60075706e-01f, 2.50489056e-01f, 1.82667658e-01f, -1.51467666e-01f, 3.16242538e-02f, -4.14247513e-01f, 1.50657415e-01f,
  -8.89872387e-02f, 2.10710511e-01f, 1.01794504e-01f, 1.91754922e-01f, 1.90613270e-01f, -9.17601511e-02f, 2.57320821e-01f, 1.27201319e-01f, 1.05682962e-01f, 8.81763771e-02f,
  -8.89239609e-02f, -2.30452627e-01f, 1.99422799e-02f, -2.56085515e-01f, -2.88093746e-01f, 4.80525289e-03f, 1.04644530e-01f, 1.20862843e-02f, -1.00698750e-02f, -1.90005645e-01f,
  -6.78077936e-02f, -6.37399852e-02f, -1.09612599e-01f, 2.41752341e-01f, -1.93863213e-01f, 2.39837706e-01f, -1.74495101e-01f, -1.30090281e-01f, 1.11525021e-02f, -7.71672204e-02f,
  -5.06496012e-01f, -2.88370132e-01f, -3.06683362e-01f, 1.08974941e-01f, 5.54528274e-02f, -1.23117246e-01f, -1.91468641e-01f, -3.65234435e-01f, -2.32838333e-01f, -2.95568049e-01f,
  -1.49827287e-01f, -1.73048735e-01f, -9.08848271e-02f, 3.64521235e-01f, -3.03704470e-01f, -4.07735616e-01f, -1.75990984e-01f, -6.05047904e-02f, -7.46745393e-02f, -1.87724113e-01f,
  1.00283973e-01f, -8.35665524e-01f, -7.58777559e-01f, -4.41976547e-01f, -5.70180357e-01f, -7.98744917e-01f, -6.25437796e-01f, -6.19575620e-01f, -8.62171888e-01f, -5.63271821e-01f,
  -1.35515201e+00f, 4.13134754e-01f, 2.85016000e-01f, -2.87945539e-01f, 8.71136725e-01f, 7.77901337e-02f, -1.70905024e-01f, -8.22538376e-01f, -3.64850789e-01f, 2.07014546e-01f,
  5.12484312e-01f, 3.73828858e-01f, 2.87653387e-01f, 1.09394431e-01f, -7.00256407e-01f, 2.01368749e-01f, 4.89192188e-01f, -4.63429689e-01f, -9.23336625e-01f, -4.82148051e-01f,
  1.69957325e-01f, -4.64283973e-01f, -8.71502638e-01f, -4.13573235e-01f, 5.60573697e-01f, 3.18352699e-01f, 5.13296604e-01f, 4.16082799e-01f, 6.16796970e-01f, 7.58321345e-01f,
  7.22804844e-01f, -7.99966156e-02f, -8.64608437e-02f, 1.41312420e-01f, 4.63191569e-01f, -2.17093900e-01f, -2.14755699e-01f, -4.70142514e-02f, -1.55310571e-01f, -1.41048685e-01f,
  5.02558470e-01f, -8.69505405e-02f, 3.41809988e-01f, 8.54122415e-02f, -1.40025601e-01f, -2.82090127e-01f, -2.93517411e-01f, -6.58470035e-01f, -6.84134662e-01f, -3.80355805e-01f,
  5.92786908e-01f, 2.96805769e-01f, -2.72719145e-01f, -2.36521110e-01f, -2.57472128e-01f, -3.27084726e-03f, -6.84712874e-03f, -2.24032536e-01f, -6.05261624e-01f, -2.01591298e-01f,
  -8.78114998e-02f, 6.28349409e-02f, 9.92267430e-02f, -2.04389486e-02f, -5.08648483e-03f, -7.36697484e-03f, 2.66648471e-01f, 1.16186596e-01f, -1.14615686e-01f, -4.60606404e-02f,
  3.07992306e-02f, 2.92876884e-02f, -2.59863436e-01f, -1.38789602e-02f, -2.49707373e-03f, -3.26580368e-02f, 3.29666995e-02f, -1.41834989e-01f, -2.36859620e-02f, -1.37143999e-01f,
  3.52059267e-02f, 1.10910676e-01f, 6.67930022e-02f, -1.54880986e-01f, 1.14521287e-01f, -2.51402501e-02f, 1.08224772e-01f, 3.93152870e-02f, 3.35789323e-02f, 6.52298145e-03f,
  -2.45560840e-01f, -8.17805342e-03f, 1.32613093e-01f, -3.13585311e-01f, -2.20173784e-02f, 6.16172180e-02f, 2.48242125e-01f, -3.45913619e-02f, 1.39719650e-01f, -3.04692417e-01f,
  -1.12215452e-01f, -9.35412478e-03f, 1.67052701e-01f, -6.46672472e-02f, -2.02741072e-01f, -3.43404710e-02f, 2.16272205e-01f, 1.89838752e-01f, -1.07033685e-01f, -4.58435006e-02f,
  -2.13036928e-02f, -5.03970504e-01f, -1.88778102e-01f, -7.17299357e-02f, 8.72732475e-02f, -1.36683360e-01f, 5.21154627e-02f, -3.76025401e-02f, -2.93622196e-01f, -4.18360651e-01f,
  -1.32399344e+00f, -8.31897795e-01f, -2.99900562e-01f, -6.35029912e-01f, -8.66430160e-03f, -4.55409326e-02f, -1.03644931e+00f, -2.37759694e-01f, 2.82563627e-01f, -4.03566241e-01f,
  -3.06580186e-01f, -4.74115282e-01f, -6.01723313e-01f, -5.23502707e-01f, -1.12047338e+00f, -9.04929280e-01f, -7.94345498e-01f, -8.47769439e-01f, -3.11791956e-01f, 2.78095424e-01f,
  1.87150717e-01f, -1.47113234e-01f, -2.74348050e-01f, 2.53842413e-01f, 1.90329701e-01f, -6.41308120e-03f, 5.41709550e-02f, -1.17908530e-01f, 5.52476794e-02f, -7.75284410e-01f,
  -7.45184660e-01f, -4.14118886e-01f, 3.86785328e-01f, -1.99148521e-01f, 4.37321186e-01f, 1.63184702e-01f, -1.32346317e-01f, 1.06948033e-01f, 2.71445483e-01f, 7.53773972e-02f,
  -2.71193683e-01f, 4.71933454e-01f, 4.64262106e-02f, 1.06551133e-01f, -6.53492138e-02f, -7.84074143e-02f, 2.91198343e-01f, 1.98704466e-01f, 5.88749051e-02f, 4.93142933e-01f,
  -3.32151353e-01f, -3.87087852e-01f, -6.32877707e-01f, 4.34694976e-01f, 4.80827272e-01f, 2.73705482e-01f, 3.38295400e-01f, 4.54232097e-01f, 2.77992278e-01f, -4.09935296e-01f,
  2.84974843e-01f, -2.67276410e-02f, 8.74893740e-02f, 8.85364506e-03f, -1.68861881e-01f, 1.24757133e-01f, -1.11271217e-01f, 2.88740136e-02f, 5.93946651e-02f, 2.81467065e-02f,
  2.40416061e-02f, -2.97405990e-03f, 1.62792150e-02f, -3.74865204e-01f, -9.57986265e-02f, 1.04783386e-01f, -1.85489580e-01f, 1.31816464e-02f, -2.87536532e-01f, 9.49094445e-02f,
  -2.65536577e-01f, -1.85867518e-01f, -4.40687053e-02f, 2.97550019e-02f, -2.92170104e-02f, -3.81776355e-02f, 1.29059449e-01f, 2.87593305e-01f, -5.50065539e-04f, 1.93899095e-01f,
  -7.04137862e-01f, 3.12201738e-01f, -5.76494157e-01f, -1.37251616e-01f, -2.81229317e-01f, 1.68484181e-01f, -6.70911446e-02f, 6.22843914e-02f, -2.71634936e-01f, -1.89568505e-01f,
  -1.54115081e-01f, -2.59054899e-01f, -1.65363401e-01f, 1.93386063e-01f, 4.54928055e-02f, -2.73268551e-01f, -2.80102015e-01f, -3.49999845e-01f, 6.93432288e-03f, 4.11491156e-01f,
  -1.33252397e-01f, -5.58005571e-01f, -1.15194988e+00f, -6.22928619e-01f, -2.43845612e-01f, -5.97270727e-01f, -7.43383408e-01f, -9.80838910e-02f, -7.59037077e-01f, -1.25485706e+00f,
  1.10206747e+00f, 1.40976952e-03f, -1.03123307e+00f, 7.31294930e-01f, -5.87382555e-01f, -8.08726609e-01f, -6.50420964e-01f, -3.22325416e-02f, 5.46690106e-01f, -2.12281108e-01f,
  -3.73698413e-01f, 2.17502192e-01f, 5.63333452e-01f, -2.05954939e-01f, -2.81205952e-01f, -3.29867482e-01f, -5.60734868e-01f, -4.44729090e-01f, -9.34719563e-01f, -1.04708159e+00f,
  -7.00003505e-01f, -2.26683542e-01f, -4.78213020e-02f, -2.21715629e-01f, -1.01478949e-01f, 1.26149440e-02f, -1.59991793e-02f, -3.40377808e-01f, -5.41841984e-01f, -2.93206066e-01f,
  -2.26049259e-01f, -3.56451780e-01f, -1.79294366e-02f, -4.21436504e-02f, 1.13002136e-01f, 2.29451373e-01f, 9.73203108e-02f, 1.48602337e-01f, 3.05761337e-01f, 2.30478168e-01f,
  -9.08176824e-02f, -4.36008200e-02f, 3.91811356e-02f, -6.15944602e-02f, 2.23432537e-02f, -2.02403948e-01f, -7.09592998e-02f, -6.12081140e-02f, 9.16626602e-02f, -1.91336870e-01f,
  -3.61416340e-01f, -3.29388529e-01f, 1.00002870e-01f, 1.00489929e-01f, -1.33296564e-01f, -7.04450980e-02f, -5.85318469e-02f, -1.14189439e-01f, -2.87007224e-02f, 3.81773949e-01f,
  5.84085546e-02f, 3.34726512e-01f, 3.46432365e-02f, 1.04421020e-01f, 1.87483579e-01f, 1.51828393e-01f, 9.68030095e-02f, 1.18036121e-01f, -1.60305388e-02f, 1.21372797e-01f,
  1.48354396e-01f, -5.47672026e-02f, -4.85847268e-04f, 5.48069738e-02f, -1.46250248e-01f, -9.38475206e-02f, 5.28973229e-02f, -3.84533070e-02f, -1.98532641e-02f, 5.22034392e-02f,
  -2.42568692e-03f, -8.77889171e-02f, -3.35530844e-03f, -1.69746820e-02f, -3.47817123e-01f, -4.83478308e-02f, -1.89379513e-01f, -1.74465805e-01f, 4.30067480e-02f, -1.58123881e-01f,
  1.02098215e+00f, -2.80980617e-01f, 2.68049181e-01f, 3.67723368e-02f, -8.04871544e-02f, -6.11983426e-02f, -6.98329583e-02f, 2.06024889e-02f, 1.15433693e-01f, -1.77493885e-01f,
  -4.06976402e-01f, -3.63632478e-02f, 1.13558322e-01f, -1.13322034e-01f, 1.59057006e-02f, -2.35968068e-01f, -2.13040505e-02f, -4.23919335e-02f, -1.35727167e-01f, -1.93984658e-01f,
  -2.82972343e-02f, 1.61405593e-01f, 4.26782280e-01f, 3.38145077e-01f, 9.85630229e-02f, 1.28507301e-01f, 2.60609418e-01f, 6.10083006e-02f, 1.33804023e-01f, 6.17343307e-01f,
  -1.05167425e+00f, -4.11671251e-01f, 5.43318391e-01f, -1.00947869e+00f, 5.65786183e-01f, 7.74951756e-01f, 1.03732860e+00f, 2.01088294e-01f, -5.01658499e-01f, 1.19329877e-01f,
  -4.49064732e-01f, -5.99170685e-01f, -8.38769436e-01f, -2.42165223e-01f, 1.23444349e-01f, 7.74138570e-01f, 5.81129909e-01f, 2.16624454e-01f, 7.24443853e-01f, 7.01141059e-01f,
  1.14040431e-02f, -5.07863164e-01f, -7.81621814e-01f, -3.93977821e-01f, -3.63840610e-01f, -1.15823168e-02f, -1.60980985e-01f, -3.94345105e-01f, 6.86449045e-03f, -3.67696434e-01f,
  5.50367869e-02f, -5.23129106e-01f, 2.92091191e-01f, -2.70736843e-01f, -1.41859680e-01f, -6.75838366e-02f, 1.91252440e-01f, -2.06673697e-01f, -1.42991170e-01f, -9.88074578e-04f,
  -3.07548076e-01f, -1.71913862e-01f, -1.92775592e-01f, -1.77860633e-02f, -7.75352269e-02f, 4.25004847e-02f, -1.64280191e-01f, -1.45120531e-01f, -1.92209795e-01f, 2.92178988e-02f,
  -3.38812335e-03f, -8.30533952e-02f, 6.27454966e-02f, 2.72446424e-01f, 9.48697701e-02f, -2.02971641e-02f, -1.59338355e-01f, -1.01596400e-01f, -1.97229367e-02f, -1.60854146e-01f,
  1.36475086e-01f, 1.29624614e-02f, 1.26613021e-01f, 5.38229793e-02f, 8.22649449e-02f, 5.55079766e-02f, 2.23310348e-02f, 1.74089223e-01f, 7.27006942e-02f, 5.24260104e-02f,
  3.05708479e-02f, 4.20725197e-02f, 9.40644648e-03f, 3.80434990e-02f, -2.23865464e-01f, -1.78195581e-01f, 9.18799490e-02f, -2.45485395e-01f, -5.81114739e-02f, -9.47079435e-02f,
  -1.16857164e-01f, -7.60406023e-03f, -1.66383803e-01f, 2.50478778e-02f, 6.92931861e-02f, -2.87976898e-02f, 2.02959720e-02f, -2.73850877e-02f, -9.04544964e-02f, 2.28530467e-02f,
  -1.70853674e-01f, 1.17431283e-01f, -8.02276284e-02f, -6.56572059e-02f, -8.13858025e-03f, -1.35343075e-01f, -2.81880021e-01f, -3.49651016e-02f, -1.06287308e-01f, 5.72572052e-02f,
  -7.24633187e-02f, -1.09717339e-01f, -2.35378578e-01f, -3.19444649e-02f, 2.35359579e-01f, -5.26415855e-02f, -9.45083424e-02f, -1.86385829e-02f, -1.18808624e-04f, -8.48135874e-02f,
  -1.60359025e-01f, 2.27574006e-01f, 3.05179834e-01f, 2.94066340e-01f, 9.76815075e-02f, 3.58401567e-01f, 3.60274911e-01f, 2.50873238e-01f, 4.42006379e-01f, 3.57108593e-01f,
  -8.60938013e-01f, -5.89246273e-01f, -4.43028569e-01f, -1.49285042e+00f, -5.75512826e-01f, -1.84078306e-01f, -2.35057399e-01f, -3.11062112e-02f, -7.62382627e-01f, -8.38329792e-01f,
  5.96534647e-02f, 9.78545070e-01f, 2.89874315e-01f, 6.16362274e-01f, 8.53945017e-01f, -7.42016852e-01f, -7.79387414e-01f, 4.87361223e-01f, 1.36992812e+00f, 6.08785510e-01f,
  3.43584642e-02f, -1.81666210e-01f, 1.47693574e-01f, 4.24767248e-02f, -8.76923978e-01f, 1.80815011e-01f, -8.40173602e-01f, -2.99536914e-01f, -9.60157514e-02f, -1.16345811e+00f,
  3.27475101e-01f, -4.75368023e-01f, 2.14073434e-01f, 6.01475593e-03f, -1.71567321e-01f, 3.37726399e-02f, 1.48217112e-01f, -1.51840031e-01f, -3.10717523e-02f, -2.26370469e-01f,
  -8.47024918e-02f, 1.57687068e-01f, 2.78620981e-02f, 1.33755013e-01f, -1.61566347e-01f, 8.96799788e-02f, -1.34127587e-01f, -1.33372560e-01f, -1.10279426e-01f, 1.51905501e-02f,
  6.72485754e-02f, -8.16972330e-02f, -1.91079170e-01f, 9.65354890e-02f, 1.35795072e-01f, 6.08047284e-02f, 8.32937583e-02f, 1.03907637e-01f, 1.61747769e-01f, -5.30673921e-01f,
  -6.72720000e-02f, 1.02164485e-01f, -9.56491083e-02f, -1.95007827e-02f, -4.79891011e-03f, -6.04269356e-02f, -1.22299947e-01f, 8.54011625e-02f, 1.19909018e-01f, 3.78873348e-02f,
  4.92018163e-02f, -1.46106079e-01f, 7.67138153e-02f, -1.33929044e-01f, -8.05469900e-02f, -1.48145214e-01f, -7.32428804e-02f, -2.60966774e-02f, -1.29304022e-01f, -1.77860230e-01f,
  3.51932086e-02f, 5.88275492e-02f, -2.47002199e-01f, 1.30006522e-01f, -9.28569064e-02f, 5.77212721e-02f, -6.68363320e-03f, 1.51724860e-01f, 5.21342531e-02f, -9.68372747e-02f,
  1.04810677e-01f, 2.51065522e-01f, -3.15778375e-01f, 1.29244000e-01f, -1.72628477e-01f, -1.50919288e-01f, -2.48237059e-01f, 6.00198917e-02f, 1.05601661e-02f, 2.07907304e-01f,
  1.62251487e-01f, 3.34673212e-03f, -2.63234407e-01f, -6.53361082e-02f, -2.29442921e-02f, -2.71683037e-02f, -1.91056982e-01f, 1.55928582e-01f, 1.31524727e-02f, -2.45768502e-01f,
  -2.38731980e-01f, -7.20363781e-02f, 1.84091389e-01f, 6.02962859e-02f, 1.32770091e-01f, 1.87766492e-01f, 1.70984238e-01f, 1.41474977e-01f, 2.39461914e-01f, -3.58523697e-01f,
  1.26534343e+00f, -4.59352940e-01f, 9.60190237e-01f, 9.93925557e-02f, 2.60627657e-01f, 4.22793865e-01f, 2.84028649e-01f, 3.79961096e-02f, -1.79721221e-01f, -3.37449342e-01f,
  -8.21102411e-02f, -9.75019932e-02f, 7.51976892e-02f, 6.42227102e-03f, 3.94083261e-01f, -1.33458912e-01f, -2.32189801e-02f, 6.15418434e-01f, 5.96712947e-01f, -1.52680174e-01f,
  -5.77283502e-01f, -1.15773186e-01f, 2.19684497e-01f, 1.38683230e-01f, -5.04214406e-01f, -2.24319547e-01f, 3.15278396e-02f, 1.63859144e-01f, -8.41200799e-02f, -6.75298750e-01f,
  2.29848213e-02f, 1.77532211e-01f, -3.94315757e-02f, -1.46018997e-01f, 1.16347767e-01f, -2.07066074e-01f, -4.82876599e-02f, -9.76339281e-02f, 2.08943356e-02f, -2.78981149e-01f,
  -3.87445018e-02f, -1.55738499e-02f, 1.88583910e-01f, -7.67650306e-02f, 1.08528443e-01f, -2.47659367e-02f, -1.13798566e-02f, 8.42727944e-02f, 1.44087180e-01f, -5.78606352e-02f,
  -3.84758621e-01f, 4.44715209e-02f, 3.25688213e-01f, 1.30232245e-01f, 2.63473779e-01f, 2.87505835e-01f, 9.24277753e-02f, -6.67774528e-02f, 2.22626776e-01f, -3.23942304e-01f,
  -1.42438516e-01f, 1.40780762e-01f, 2.64423698e-01f, -1.57127857e-01f, 2.47950796e-02f, 1.11585893e-01f, 3.00625376e-02f, 3.09423264e-02f, 8.32986087e-02f, 5.56877516e-02f,
  -3.10676498e-03f, 3.95144038e-02f, 1.84983104e-01f, -1.43310875e-01f, -8.98685455e-02f, 9.98057202e-02f, 3.67252082e-02f, -2.18903437e-01f, 2.57133305e-01f, -1.47620244e-02f,
  1.78532973e-01f, -1.25516541e-02f, 7.09580211e-03f, 1.15343526e-01f, -4.62994576e-02f, 1.72201190e-02f, -1.98966023e-02f, -5.19420020e-02f, -1.27549008e-01f, -1.20935373e-01f,
  -6.57467544e-01f, 6.51009262e-01f, -2.05390021e-01f, -1.69318110e-01f, 1.27836391e-01f, 1.28810644e-01f, 4.03443202e-02f, -1.25318944e-01f, -2.13518754e-01f, -1.79409683e-01f,
  -4.37987000e-02f, -2.29447689e-02f, 1.03197969e-01f, 2.55762483e-03f, 4.36205938e-02f, -1.48106758e-02f, -1.26840442e-01f, 1.92129575e-02f, -1.04849085e-01f, -2.85685033e-01f,
  -2.29429290e-01f, -1.02745675e-01f, 4.01936062e-02f, -3.14107426e-02f, -1.52117461e-01f, 3.21255662e-02f, -7.56726190e-02f, -3.95211875e-02f, 3.64732295e-01f, -4.47277933e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 8)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 8;
const float L0_fan_Bp_bar_data[] = {
  4.93923783e-01f, 1.03399408e+00f, 1.03715599e+00f, 7.11393654e-01f, 1.09764290e+00f, 1.29977536e+00f, 6.55816436e-01f, 1.43355083e+00f
};

// L1_linear_W (Shape: 12 x 32)
const int L1_linear_W_rows = 12;
const int L1_linear_W_cols = 32;
const float L1_linear_W_data[] = {
  -1.44768700e-01f, -8.30697417e-02f, -4.44352835e-01f, -8.84145439e-01f, 1.20005824e-01f, 2.52829760e-01f, -7.83805922e-02f, 5.21498084e-01f, -1.98794037e-01f, -9.10589993e-02f,
  1.59266487e-01f, -8.83880019e-01f, -6.02511689e-02f, -1.12816900e-01f, 3.64663780e-01f, -2.43289471e-01f, 1.72240630e-01f, -3.64474863e-01f, 8.06585476e-02f, 3.80920708e-01f,
  -3.87829691e-01f, -1.28934905e-01f, -6.62366524e-02f, -2.46736035e-01f, -7.25739777e-01f, -8.59979212e-01f, -1.79401743e+00f, 6.09331131e-01f, -4.88665044e-01f, -6.97670281e-01f,
  7.78658926e-01f, -9.42221701e-01f, 2.68863499e-01f, -7.12797046e-02f, 3.18625242e-01f, -2.94464737e-01f, -4.55717370e-02f, -1.76379383e-01f, 2.15775464e-02f, -4.81322110e-01f,
  -3.12943071e-01f, -5.20165563e-01f, 6.49943389e-03f, -2.68065631e-01f, -3.24845433e-01f, -5.22204526e-02f, 4.23390627e-01f, 3.20532680e-01f, -2.24473149e-01f, -4.04582024e-01f,
  -1.72527209e-01f, -8.19669664e-01f, 5.44892289e-02f, -3.88713866e-01f, -1.25010878e-01f, 6.05569631e-02f, 3.12436372e-01f, -5.20354986e-01f, -1.41464353e+00f, -1.18645430e+00f,
  4.21650678e-01f, -1.26988924e+00f, 1.04640317e+00f, 7.63295889e-01f, -9.57888216e-02f, 2.04378609e-02f, -5.86433411e-01f, 4.01411533e-01f, 1.99236766e-01f, 1.86293170e-01f,
  2.30256608e-03f, 4.24704224e-01f, 7.16977835e-01f, 7.43447393e-02f, 1.97468236e-01f, 4.05352861e-01f, -6.43186092e-01f, 9.65816155e-02f, 5.95288754e-01f, 2.73561388e-01f,
  1.14447105e+00f, 1.85300529e-01f, -4.89939958e-01f, -4.24837738e-01f, 2.89586931e-01f, -8.45814526e-01f, -4.49142426e-01f, -5.90245008e-01f, -9.17779207e-01f, 3.27981234e-01f,
  -1.06391764e+00f, -8.13971981e-02f, -8.03158522e-01f, -8.11870337e-01f, 6.54383600e-01f, 4.83833551e-01f, -3.51833344e-01f, -2.91647077e-01f, -1.96473375e-01f, 3.46761167e-01f,
  -6.18907511e-01f, -2.43776478e-02f, 9.74750966e-02f, -1.76768088e+00f, -2.52536982e-01f, 6.53611496e-02f, 1.75828815e-01f, 2.15563819e-01f, -2.94315815e-01f, 3.48869860e-01f,
  -4.30312991e-01f, -2.89835244e-01f, 3.81240427e-01f, -7.20938155e-03f, -1.41994268e-01f, 4.83943939e-01f, 4.44197923e-01f, 9.54795033e-02f, -1.12541858e-02f, -6.05244815e-01f,
  -7.23263919e-01f, -9.89384234e-01f, 2.03248814e-01f, 3.72099280e-01f, -1.08441138e+00f, 1.10848260e+00f, 1.10126287e-01f, -8.59798908e-01f, -2.96343207e-01f, 5.45209795e-02f,
  2.50266671e-01f, 6.19307868e-02f, 2.82718331e-01f, 1.19975716e-01f, 1.59583598e-01f, 2.72260278e-01f, -3.88709567e-02f, -2.73297988e-02f, -7.71144867e-01f, 8.55735660e-01f,
  -9.53224376e-02f, 9.41356793e-02f, 5.72331920e-02f, 1.52572796e-01f, 6.64280951e-01f, 2.14357123e-01f, -1.09750919e-01f, 9.63798702e-01f, 4.05162841e-01f, 1.14464082e-01f,
  5.50457649e-02f, 3.44025880e-01f, 1.89272687e-01f, -8.99975479e-01f, 7.16328382e-01f, 3.59687209e-01f, 5.25550902e-01f, -1.56649458e+00f, -1.24114168e+00f, -9.35460210e-01f,
  3.97900313e-01f, 2.33550876e-01f, 4.87308502e-01f, 8.18272471e-01f, 1.92428946e-01f, 4.09588069e-01f, -9.07164961e-02f, 7.50280857e-01f, -9.22790021e-02f, 6.43634915e-01f,
  4.16721046e-01f, 5.89735471e-02f, 4.03910667e-01f, 3.35989684e-01f, -6.78704083e-01f, 3.27895939e-01f, -7.19882071e-01f, -2.94080973e-02f, 9.08089161e-01f, -9.37830746e-01f,
  4.21505660e-01f, 2.13230684e-01f, 9.79922861e-02f, -8.30840468e-01f, 1.98283583e-01f, -2.76527733e-01f, -9.69653904e-01f, -2.20872477e-01f, 1.04162097e+00f, -5.98427236e-01f,
  -9.14131939e-01f, -1.11640489e+00f, 2.33598631e-02f, -1.74365081e-02f, -1.24599352e-01f, 4.13248122e-01f, -7.00980902e-01f, 6.83041513e-02f, -2.46194214e-01f, 1.99365243e-01f,
  -3.46588433e-01f, 3.15063655e-01f, 3.67000908e-01f, 3.09000555e-02f, 7.79432833e-01f, -4.66814071e-01f, 4.49051589e-01f, -2.71899015e-01f, -4.77573693e-01f, 4.32533622e-01f,
  -4.10049170e-01f, -8.57735097e-01f, -7.24861681e-01f, -2.47158166e-02f, 1.47708386e-01f, 6.48172379e-01f, -1.12493300e+00f, 1.22845471e+00f, -1.72090364e+00f, -1.62418520e+00f,
  -7.55029142e-01f, -1.13567305e+00f, -1.28633618e+00f, -3.47663760e-01f, 2.46758927e-02f, -3.67339164e-01f, 3.36789161e-01f, -5.28455913e-01f, -1.82761773e-01f, 1.56523064e-02f,
  -3.58512342e-01f, -5.45579493e-01f, -2.42149577e-01f, -5.26264250e-01f, -9.83017236e-02f, 1.77430645e-01f, -1.36725873e-01f, 2.93690801e-01f, -5.30178323e-02f, -2.70356327e-01f,
  1.81584910e-01f, 2.19736502e-01f, 2.40157932e-01f, 7.16934144e-01f, 6.41817823e-02f, 1.68779314e-01f, -1.64738446e-01f, -1.06370561e-01f, 4.12736207e-01f, 4.96674664e-02f,
  1.10182166e+00f, -7.74363756e-01f, -1.13442481e+00f, 4.51122820e-01f, -8.08066666e-01f, -1.15934038e+00f, -4.23688889e-01f, -2.94426113e-01f, 2.81721503e-01f, 1.16282485e-01f,
  4.59832042e-01f, 9.28920880e-02f, -9.17617977e-02f, 3.76372933e-01f, -2.95456126e-02f, -3.85439768e-02f, -4.90576655e-01f, 3.35939348e-01f, 1.34821460e-01f, -3.57171506e-01f,
  -1.75568983e-01f, -5.05929589e-01f, -1.85976565e-01f, -1.82837725e-01f, 4.16234851e-01f, -4.20601666e-01f, -1.78014874e-01f, 1.73412431e-02f, -4.11791176e-01f, 4.51381892e-01f,
  1.65569745e-02f, -6.25370562e-01f, -4.13720727e-01f, -1.01216054e+00f, -2.63306648e-01f, 1.04107237e+00f, -9.72882569e-01f, 2.08332539e-01f, 2.78448522e-01f, -9.71333385e-02f,
  -6.54490829e-01f, 4.00450408e-01f, -1.23209789e-01f, 2.82890260e-01f, 1.94593191e-01f, 4.89114895e-02f, 2.57603705e-01f, 4.27489504e-02f, -2.99493611e-01f, 1.83938488e-01f,
  -9.02875483e-01f, -3.33866358e-01f, 8.40008914e-01f, 2.87563205e-01f, -9.00099277e-01f, -1.42958000e-01f, -3.46187890e-01f, -1.35722423e+00f, 4.57253963e-01f, 6.68980420e-01f,
  4.54174966e-01f, 3.52672577e-01f, -5.57316065e-01f, 2.44389147e-01f, 1.33751702e+00f, -1.42131194e-01f, -6.32402360e-01f, -1.27219617e+00f, -1.55325580e+00f, -9.62634146e-01f,
  2.44386002e-01f, 1.43286854e-01f, -1.98845387e-01f, -3.04764658e-01f, -1.67043190e-02f, -2.20400527e-01f, 9.61949751e-02f, 8.57756853e-01f, 2.67067581e-01f, -4.34631318e-01f,
  9.96520817e-02f, 4.11957026e-01f, -1.04970997e-02f, -6.05734438e-02f, -4.80214298e-01f, -4.70060736e-01f, 8.16350698e-01f, -2.39559859e-01f, 1.79032907e-01f, 1.78224295e-01f,
  -3.00690204e-01f, -4.94827151e-01f, 6.54224992e-01f, 9.85561758e-02f, -8.25065851e-01f, -3.87386322e-01f, 7.41923451e-01f, -1.60802937e+00f, -2.44732901e-01f, 6.65543795e-01f,
  1.14611232e+00f, -1.47006226e+00f, 8.72321613e-03f, 1.01658314e-01f, -2.05945700e-01f, 1.98631942e-01f, 3.37755941e-02f, -3.20785701e-01f, 2.50737309e-01f, -6.97839975e-01f,
  -2.38185182e-01f, -2.23121017e-01f, 3.98573987e-02f, -1.01391971e+00f, 2.32400835e-01f, 1.15578279e-01f, -9.19433355e-01f, 5.62252581e-01f, -5.24747610e-01f, 2.85615265e-01f,
  -1.77450851e-01f, 1.59900236e+00f, -7.43931681e-02f, 5.26830316e-01f, -3.04178536e-01f, 5.84359825e-01f, -7.06516087e-01f, 1.15072660e-01f, -1.68030381e-01f, -6.25362456e-01f,
  -1.16783786e+00f, -5.77943981e-01f, -2.78700709e-01f, 1.17910993e+00f
};

// L1_linear_B (Shape: 1 x 12)
const int L1_linear_B_rows = 1;
const int L1_linear_B_cols = 12;
const float L1_linear_B_data[] = {
  6.15631580e-01f, -5.83683476e-02f, 1.63367435e-01f, -6.10102832e-01f, 1.42589316e-01f, -7.92659447e-03f, 5.13892114e-01f, -5.81604362e-01f, -6.93105161e-01f, 1.42283499e-01f,
  -8.53061080e-01f, 1.00689128e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 12, 8
    );
    
    // Camada 1: L1_linear
    linear_forward_pgm(
        buffer1, x_out,
        L1_linear_W_data, L1_linear_B_data,
        32, 12
    );
    }
    