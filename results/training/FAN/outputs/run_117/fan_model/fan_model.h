/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 64 (x2)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 64;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    float x3 = x * x * x;
    return 0.5f * x * (1.0f + tanhf(0.79788456f * (x + 0.044715f * x3)));
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 25 x 120)
const int L0_fan_Wp_rows = 25;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  3.88949625e-02f, -1.48272604e-01f, 1.55176014e-01f, -2.30409473e-01f, -1.13012917e-01f, -3.33482772e-01f, -1.97709486e-01f, -1.60011351e-01f, -1.16573997e-01f, -1.21685542e-01f,
  -1.68336034e-01f, -3.20723914e-02f, 4.28275168e-02f, -3.51309031e-01f, -2.62838215e-01f, -1.33205578e-01f, -1.76200002e-01f, -7.09378645e-02f, -3.08912136e-02f, -6.83564842e-02f,
  -8.28360319e-02f, -1.99644119e-01f, -1.11993179e-01f, -5.26578687e-02f, -1.53436556e-01f, 8.94427970e-02f, 1.26739442e-01f, 8.35081488e-02f, -1.05936006e-01f, -4.87766750e-02f,
  -2.72979354e-03f, 5.99387027e-02f, -2.14666547e-03f, 1.57880166e-03f, 1.75789967e-02f, 5.81797138e-02f, 7.18580484e-02f, 1.23794585e-01f, -3.96372862e-02f, -3.96224335e-02f,
  8.22146088e-02f, -1.09007601e-02f, -5.29673556e-03f, 1.33693283e-02f, -4.84459922e-02f, -1.59477703e-02f, -7.77591243e-02f, -3.60128246e-02f, -1.28283888e-01f, -6.55044615e-02f,
  -2.69580428e-02f, -4.67557125e-02f, -5.18539250e-02f, -5.15806396e-03f, 3.41611356e-02f, -1.71308815e-01f, 3.09960898e-02f, 9.75917093e-03f, -2.98985951e-02f, -1.56903695e-02f,
  1.00011686e-02f, 4.28280719e-02f, 2.88752113e-02f, -8.39802399e-02f, 2.66654976e-02f, -4.99551333e-02f, -5.08336313e-02f, 1.14290267e-02f, 7.92426243e-02f, -6.57779165e-03f,
  -6.28264248e-02f, 1.59738101e-02f, -2.26823799e-02f, 2.01659538e-02f, 9.64793712e-02f, 3.00896307e-03f, 9.02359188e-02f, -5.05253905e-03f, -1.24311205e-02f, -2.64116004e-02f,
  -6.49819672e-02f, -3.03138178e-02f, -2.51800828e-02f, 1.20304655e-02f, -8.97994936e-02f, -4.12814412e-03f, -1.17283845e-02f, -3.05515639e-02f, 4.27223146e-02f, 9.21868160e-02f,
  3.83790620e-02f, 2.04708010e-01f, 1.37933046e-02f, -1.01895750e-01f, 7.95134231e-02f, -6.61679963e-03f, 2.47486643e-02f, -5.08284271e-02f, 8.55604708e-02f, 7.95816537e-03f,
  8.65577757e-02f, 1.41111398e-02f, 3.63388620e-02f, -5.61741181e-03f, -4.30644304e-02f, -4.60760705e-02f, 4.80699055e-02f, 4.81209382e-02f, -6.02308996e-02f, 5.25254803e-03f,
  8.75555649e-02f, 5.05427532e-02f, 3.47691998e-02f, 4.31413017e-03f, 1.80784669e-02f, -3.41020920e-03f, -1.38075836e-02f, 1.21591091e-02f, -1.27420025e-02f, -2.00960245e-02f,
  -2.11703390e-01f, -3.51406664e-01f, 3.33931744e-02f, -1.96681917e-01f, 2.37379402e-01f, -5.24154939e-02f, -1.38665080e-01f, -5.14440276e-02f, 3.16244103e-02f, -1.61722451e-01f,
  1.85007900e-02f, -1.23430967e-01f, -3.30958813e-02f, -3.07469755e-01f, 2.13716656e-01f, -1.14084639e-01f, -2.41299644e-01f, -1.38968945e-01f, -1.53868105e-02f, -1.37777135e-01f,
  3.83754484e-02f, -1.08116858e-01f, -4.37761620e-02f, 5.62183410e-02f, -2.68793926e-02f, -6.73567355e-02f, 8.64142850e-02f, 1.72922805e-01f, -8.89652148e-02f, 5.02831638e-02f,
  -9.31618176e-03f, -1.18505694e-01f, -3.84724140e-02f, -5.63302869e-03f, -4.80671488e-02f, 3.58517468e-02f, 3.24390158e-02f, 9.59699452e-02f, 5.27947508e-02f, -7.21812854e-03f,
  -1.64895821e-02f, 2.85996199e-02f, 1.56705156e-02f, 2.44408026e-02f, -1.73248053e-02f, 1.79300830e-02f, 3.46494466e-02f, -1.36064347e-02f, 2.60214005e-02f, -3.41796279e-02f,
  -4.84408140e-02f, -4.51476090e-02f, -6.02084631e-03f, -9.18305293e-02f, 4.73519824e-02f, 3.89584824e-02f, 8.82862695e-03f, -1.07254069e-02f, -2.56086159e-02f, 2.10658531e-03f,
  -8.04676563e-02f, 8.26458186e-02f, 1.86865442e-02f, 6.06787801e-02f, -5.26133813e-02f, 4.03071456e-02f, -4.60358113e-02f, 2.57631261e-02f, 3.66880782e-02f, -5.66123333e-03f,
  3.79211940e-02f, 2.94039818e-03f, 1.00245718e-02f, -7.45613594e-04f, 2.01119948e-02f, -6.09715395e-02f, 8.75967592e-02f, -4.17859331e-02f, 1.78798325e-02f, 5.42256944e-02f,
  -2.75183022e-02f, 2.69415751e-02f, -5.46839572e-02f, -9.60830227e-03f, -1.74687395e-03f, 5.23007326e-02f, -1.54124610e-02f, -8.65021870e-02f, 1.61734261e-02f, 3.23911719e-02f,
  -1.45122141e-01f, -2.35559449e-01f, 8.91284458e-03f, 3.49723659e-02f, 8.80830139e-02f, -3.42425033e-02f, 6.66473433e-03f, -4.39788448e-03f, -3.32278535e-02f, -7.15057785e-03f,
  4.33960650e-03f, 5.24384975e-02f, 1.79005060e-02f, 7.09632486e-02f, 4.17784378e-02f, 5.42799607e-02f, -3.63101140e-02f, 4.27359827e-02f, -1.69735719e-02f, 2.46817823e-02f,
  2.33686995e-04f, 5.92785003e-03f, 3.32348943e-02f, 2.82016699e-04f, -1.74635462e-02f, 1.42984781e-02f, -4.10063751e-02f, -4.79339249e-02f, 1.10468371e-02f, 8.32555257e-03f,
  9.31714941e-03f, -2.47020274e-01f, 3.40392977e-01f, 3.99158895e-02f, 2.58244630e-02f, -4.59184870e-02f, -1.09644480e-01f, 1.01887874e-01f, -1.21553212e-01f, -2.07672521e-01f,
  -1.40137598e-01f, 8.87411926e-03f, -1.13378927e-01f, 6.60060570e-02f, 1.79530635e-01f, -3.53454761e-02f, -5.80227152e-02f, -8.71012434e-02f, 8.67689699e-02f, -1.59191992e-02f,
  6.67506605e-02f, -1.77602783e-01f, 1.51412100e-01f, 7.36143673e-03f, 8.97255093e-02f, 7.74139538e-02f, -9.44581404e-02f, 4.06854227e-02f, 4.76071835e-02f, 4.02722657e-02f,
  -3.56667787e-02f, 4.32726257e-02f, -3.90733853e-02f, 1.66386552e-02f, 1.99405719e-02f, -5.17237596e-02f, 7.66995922e-03f, -3.84564884e-02f, 2.47217044e-02f, -2.69292276e-02f,
  -4.88382429e-02f, 1.99516695e-02f, 7.06614628e-02f, 1.00772679e-02f, -4.82899882e-02f, 9.94074158e-03f, 2.76078302e-02f, 3.61066014e-02f, 1.37433698e-02f, 5.43820560e-02f,
  3.69642004e-02f, 1.00647174e-01f, 9.41514149e-02f, -4.19989079e-02f, 3.44396308e-02f, -4.35472205e-02f, 2.69955909e-03f, 3.80905457e-02f, -3.51133868e-02f, -3.85160632e-02f,
  7.25484341e-02f, -1.09568208e-01f, 4.16594595e-02f, 5.23020066e-02f, 3.22229341e-02f, 8.62712506e-03f, -2.53662001e-02f, 5.27679250e-02f, -1.85394976e-02f, 3.65675688e-02f,
  -5.05397134e-02f, 2.11730432e-02f, 1.54824313e-02f, -2.15073004e-02f, -6.08934313e-02f, 5.58351167e-03f, 1.19515182e-02f, -5.91990612e-02f, -4.08498272e-02f, 2.72547528e-02f,
  -3.88432369e-02f, -1.82064287e-02f, 1.26458732e-02f, -5.05477265e-02f, 1.67485010e-02f, -2.65803877e-02f, 3.02849673e-02f, 4.34280112e-02f, 2.93513238e-02f, 4.45738062e-03f,
  -2.89764732e-01f, -3.00586224e-01f, 3.17061925e-03f, -4.38245088e-02f, -7.57158771e-02f, -1.16418218e-02f, 3.11244074e-02f, 4.99330312e-02f, -4.56342176e-02f, 1.36654759e-02f,
  -4.42038514e-02f, -1.39590309e-04f, -2.99010873e-02f, -2.44156364e-02f, -3.87040451e-02f, -4.78508733e-02f, -1.06433652e-01f, -1.37296900e-01f, -9.53158587e-02f, 2.73997756e-03f,
  -9.14651975e-02f, -8.26745033e-02f, 5.56593873e-02f, 2.08995193e-02f, -1.15681496e-02f, 1.03201028e-02f, -1.47964451e-02f, 5.48340455e-02f, 3.51123512e-02f, -7.85391405e-02f,
  7.27803931e-02f, -6.62954673e-02f, 1.26020059e-01f, 6.21865429e-02f, 2.44421866e-02f, 2.76970193e-02f, 1.54746855e-02f, 4.59642336e-02f, 3.26053083e-01f, -2.44726717e-01f,
  -2.54414622e-02f, -6.60592169e-02f, 4.35765907e-02f, 5.25068305e-03f, 2.06778258e-01f, 2.49300748e-01f, 5.06618842e-02f, 2.57514287e-02f, 1.37415171e-01f, -1.58115968e-01f,
  7.04576150e-02f, -1.46105707e-01f, 1.15761183e-01f, -1.00157060e-01f, -1.37510553e-01f, 2.18907967e-02f, -2.41682425e-01f, 3.09814308e-02f, -2.34846368e-01f, 4.25586291e-03f,
  2.13037118e-01f, 3.81657891e-02f, -2.06880897e-04f, 3.49331610e-02f, 5.80249587e-03f, 3.66309844e-02f, -6.93952590e-02f, 4.94852178e-02f, 1.25402763e-01f, 6.37151487e-03f,
  -5.35744131e-02f, 5.57477996e-02f, 4.40821312e-02f, -3.61883603e-02f, 6.00468330e-02f, 5.55252135e-02f, 2.05850713e-02f, -1.16610862e-02f, -1.43011725e-02f, 5.10370657e-02f,
  -5.12177497e-03f, 5.22524342e-02f, -1.60468090e-02f, -5.30747920e-02f, 2.10149866e-02f, 9.51791927e-02f, -2.25326903e-02f, -7.89712593e-02f, -1.09422086e-02f, 4.04580571e-02f,
  -4.98939566e-02f, 3.31606492e-02f, -5.36770560e-03f, 5.62989227e-02f, -7.50506716e-03f, 1.16498535e-02f, 7.20636826e-03f, -7.22303838e-02f, 3.03325728e-02f, -4.63608876e-02f,
  -3.89825478e-02f, 1.08798305e-02f, 4.30674739e-02f, -1.97831038e-02f, -1.45126106e-02f, 8.00873898e-03f, -3.33317630e-02f, -5.49863204e-02f, 4.78223898e-02f, 6.82192966e-02f,
  -1.56262815e-02f, 3.95273976e-02f, -3.87873389e-02f, 3.83262779e-03f, 1.17301054e-01f, -3.90084907e-02f, -6.65353909e-02f, 2.45519839e-02f, 6.31547272e-02f, -4.16653529e-02f,
  -1.53506070e-01f, -2.95646042e-01f, -6.09694161e-02f, -4.40062536e-03f, 3.68346013e-02f, -1.84669085e-02f, 5.39996289e-02f, -4.85743023e-02f, 3.32955318e-03f, -4.95417714e-02f,
  -5.04541136e-02f, -2.61327829e-02f, -4.73480746e-02f, 3.40812467e-02f, 3.39896157e-02f, 5.40896738e-03f, -3.95586193e-02f, 3.94757837e-03f, -7.32591003e-02f, -3.99746150e-02f,
  -1.31243303e-01f, -8.57355818e-02f, 7.24843442e-02f, -3.09477430e-02f, -3.85584384e-02f, -6.67285174e-02f, -7.08506582e-03f, 6.99944869e-02f, -3.76764238e-02f, 2.52462719e-02f,
  -5.02972305e-01f, 6.51231036e-02f, 1.04243919e-01f, -3.74341160e-02f, -8.09896961e-02f, -2.76109308e-01f, -9.70775411e-02f, -2.85503399e-02f, -2.73083746e-01f, 8.58161598e-02f,
  1.56744555e-01f, 5.57628609e-02f, 1.44615486e-01f, 3.91780697e-02f, -1.96466506e-01f, 8.69955681e-03f, -1.39119789e-01f, 2.76432112e-02f, -9.39308554e-02f, 2.58369837e-02f,
  -4.05844003e-02f, -3.27457339e-02f, 1.75061479e-01f, 1.21834651e-01f, 4.83574085e-02f, 2.98799369e-02f, 2.31296510e-01f, 1.11201443e-01f, 1.36295512e-01f, -4.94022258e-02f,
  4.87489924e-02f, -1.25549398e-02f, 3.40114534e-02f, 3.49493884e-03f, -1.63622089e-02f, -1.54854748e-02f, 4.47774976e-02f, -5.00346348e-02f, 5.45960106e-02f, 1.13196317e-02f,
  -4.10974547e-02f, -1.61452126e-02f, -6.72027245e-02f, -1.17493179e-02f, 6.11078786e-03f, 4.04144377e-02f, -2.85467296e-03f, -4.32364903e-02f, 3.77197415e-02f, 1.44519024e-02f,
  -3.38540152e-02f, 6.83537312e-03f, -1.27123315e-02f, -5.20229265e-02f, 5.74661642e-02f, 4.62732576e-02f, 8.14303756e-03f, -1.51720252e-02f, -4.68702726e-02f, -6.87653199e-02f,
  -4.74008992e-02f, -5.02537973e-02f, 1.33532295e-02f, 1.01831362e-01f, -1.82232261e-02f, 6.50699902e-03f, 1.23257060e-02f, 5.14925271e-02f, 3.39440666e-02f, 4.99479249e-02f,
  3.65997255e-02f, -1.38387075e-02f, 8.34227949e-02f, 1.23748751e-02f, -7.45226294e-02f, -5.00960201e-02f, 3.01762596e-02f, 9.02195461e-03f, -6.85702637e-02f, -3.64952832e-02f,
  8.13307762e-02f, -4.11982723e-02f, 1.69392265e-02f, 2.30557099e-02f, 7.88095593e-03f, 3.55460942e-02f, 6.15646988e-02f, 4.50491272e-02f, 1.29898246e-02f, -4.82398272e-03f,
  -3.59919518e-02f, -9.41214040e-02f, -8.11798219e-03f, -2.51876619e-02f, 3.99756581e-02f, 7.16633946e-02f, -3.02493647e-02f, -3.41861285e-02f, -5.27304448e-02f, -4.06043902e-02f,
  4.16255854e-02f, -1.23782037e-02f, -6.43857494e-02f, 5.58614656e-02f, -3.85181233e-02f, 1.17183495e-02f, 9.41233151e-03f, 2.56529190e-02f, -6.29224032e-02f, 6.77942857e-02f,
  1.18970238e-02f, -1.23564534e-01f, -1.32562220e-02f, -1.49395708e-02f, -6.50875419e-02f, -6.91733416e-03f, -8.31424296e-02f, -3.55142057e-02f, -2.38250056e-03f, 3.64043899e-02f,
  1.13138512e-01f, -1.29247278e-01f, 2.58721083e-01f, -1.69109125e-02f, -1.03097796e-01f, -3.46053898e-01f, -1.30045235e-01f, -1.70897141e-01f, -5.78027144e-02f, -2.25044399e-01f,
  -1.41172752e-01f, 2.60673016e-01f, 1.67082492e-02f, -3.56637508e-01f, 1.44729733e-01f, 6.25329837e-02f, -2.01773539e-01f, -2.69575100e-02f, 8.61932933e-02f, -5.18911369e-02f,
  9.12224725e-02f, -3.26450139e-01f, 5.13946265e-02f, -1.70006543e-01f, -1.16065465e-01f, 1.24060422e-01f, -4.41462360e-02f, 1.71844184e-01f, -1.84191629e-01f, 1.53538650e-02f,
  -4.36850414e-02f, 5.54358400e-02f, -3.62329260e-02f, 2.82955617e-02f, -4.65594046e-02f, -4.96746637e-02f, 4.22944166e-02f, 7.67338127e-02f, 5.74285910e-02f, 2.98241731e-02f,
  -2.14972626e-03f, 2.35482547e-02f, -2.64758337e-02f, -5.52983582e-03f, -2.16653533e-02f, 1.05119795e-02f, -7.06591271e-03f, 1.48770083e-02f, -4.60826941e-02f, 8.39953497e-02f,
  4.84751686e-02f, 3.48691508e-04f, -2.07683370e-02f, -7.53379334e-03f, 4.46579009e-02f, 9.98628512e-03f, 2.52281968e-03f, 7.92817697e-02f, -1.56908985e-02f, -2.76210830e-02f,
  -5.11517096e-03f, 3.67988981e-02f, -4.60857898e-02f, -4.47788946e-02f, 1.68591086e-02f, -1.10246809e-02f, -5.67680337e-02f, -5.89089515e-03f, 1.05713546e-01f, -2.35512685e-02f,
  1.79484591e-03f, -4.00065146e-02f, -6.68257698e-02f, -2.95047797e-02f, -6.68009697e-03f, -5.31082340e-02f, 3.68528441e-02f, -3.05949915e-02f, -3.73134948e-02f, -3.48437615e-02f,
  2.92956699e-02f, 1.22167598e-02f, -3.03321797e-02f, -2.99420170e-02f, 1.63959879e-02f, 4.77521755e-02f, -4.36427183e-02f, 2.86214333e-02f, -5.86659275e-02f, -7.31815100e-02f,
  -1.25345230e-01f, -8.86543747e-03f, -9.23457649e-03f, -3.35724726e-02f, 7.75097534e-02f, 1.36311371e-02f, 6.02739640e-02f, 2.60097254e-02f, 2.90415343e-02f, -4.36655208e-02f,
  4.64159101e-02f, -5.32537028e-02f, -1.52721312e-02f, 4.65434481e-04f, 2.90648062e-02f, -5.04557788e-02f, 3.14813331e-02f, 4.15619202e-02f, -1.01625258e-02f, 6.55997619e-02f,
  -6.86074197e-02f, -2.92637683e-02f, 7.52442852e-02f, -5.94101399e-02f, -7.97334537e-02f, 6.06030598e-02f, 7.67457997e-03f, 3.16196531e-02f, 2.12929212e-02f, 1.64250806e-02f,
  -6.65739179e-02f, -2.50608265e-01f, -2.97992319e-01f, -6.24516383e-02f, 1.77369729e-01f, -2.08500296e-01f, -2.70960271e-01f, 3.41643281e-02f, -4.23400328e-02f, 3.23280245e-02f,
  2.19619215e-01f, -2.12867573e-01f, 1.13178948e-02f, -3.12932506e-02f, 5.62676564e-02f, -2.17159986e-02f, -3.93454470e-02f, -1.50442600e-01f, -8.30995478e-03f, 2.25830753e-03f,
  -9.44514126e-02f, 1.96892962e-01f, -1.34493947e-01f, 1.47911176e-01f, -6.31918535e-02f, -8.16655681e-02f, 1.81770176e-01f, -2.68353038e-02f, 1.15737421e-02f, 9.78616625e-03f,
  -4.81923930e-02f, 5.32911867e-02f, -9.52661186e-02f, -1.07130013e-01f, 4.79218699e-02f, -3.27544957e-02f, -8.92399698e-02f, 5.06251538e-03f, 1.26136327e-03f, -2.38067023e-02f,
  -2.42323242e-02f, -1.86777636e-02f, -4.51096930e-02f, 3.14691104e-02f, 2.18451349e-03f, -4.95225191e-02f, 3.05610336e-02f, -2.11289786e-02f, -7.26098493e-02f, -2.91576702e-02f,
  -2.94923317e-02f, -1.11050215e-02f, -1.35723455e-02f, -2.61193956e-03f, -2.93894066e-03f, 8.34883600e-02f, -7.24648312e-02f, -4.27780561e-02f, 3.88326719e-02f, -1.32453041e-02f,
  9.42624807e-02f, -1.89692732e-02f, 6.42364100e-03f, -2.33594570e-02f, 2.22516432e-02f, 7.12245628e-02f, -1.79177579e-02f, 3.76135600e-03f, 5.46909263e-03f, 5.25375120e-02f,
  5.82560860e-02f, -3.93003412e-02f, 1.81313176e-02f, -7.02371914e-03f, 2.25277785e-02f, -4.15945910e-02f, -1.85758173e-02f, -3.86324525e-02f, -4.14391756e-02f, -2.43161768e-02f,
  -1.27971256e-02f, -1.25579387e-02f, -2.48498172e-02f, -4.20643017e-03f, -1.52948983e-02f, 2.04981007e-02f, 6.47927374e-02f, 1.07459035e-02f, 3.97399776e-02f, 9.97223542e-04f,
  -3.02846469e-02f, 7.77517557e-02f, -4.02547382e-02f, 1.19206021e-02f, -1.54933771e-02f, 9.72760201e-04f, -2.09988467e-02f, 4.81871590e-02f, 3.03126574e-02f, 5.10739721e-02f,
  9.39614139e-03f, -1.04011372e-02f, -6.24349713e-03f, 4.07115854e-02f, 8.95072054e-03f, 2.61769909e-02f, 2.81119440e-02f, -2.50850078e-02f, 3.14253867e-02f, 2.87401844e-02f,
  2.35093646e-02f, 1.92766767e-02f, -3.54965706e-03f, 1.56599544e-02f, -1.30887760e-03f, 3.93616892e-02f, 3.27294739e-03f, -2.83549745e-02f, 1.00350663e-01f, -5.58826653e-03f,
  2.64523327e-02f, 2.62306124e-01f, 2.78332159e-02f, 4.34342474e-02f, -1.99798450e-01f, 5.81757687e-02f, 3.81449461e-02f, 7.33304396e-02f, 1.15675991e-02f, 2.14717671e-01f,
  -9.10039172e-02f, 6.53043464e-02f, 8.25846121e-02f, 9.07567888e-02f, -2.66670913e-01f, 3.82565521e-02f, 9.59181562e-02f, 1.14959955e-01f, 3.16421837e-02f, 9.96932313e-02f,
  -7.46211223e-03f, -1.55201033e-02f, 4.49009473e-03f, 1.45812044e-02f, -4.68642488e-02f, 5.34334108e-02f, 1.01119103e-02f, -3.57686877e-02f, 1.02897115e-01f, -9.99899656e-02f,
  8.20429847e-02f, -1.21405115e-02f, -1.55662578e-02f, 1.27074020e-02f, 2.84544770e-02f, -2.03472767e-02f, 1.56726353e-02f, -7.27917105e-02f, -2.45652124e-02f, 4.34060959e-04f,
  2.36073621e-02f, -1.80123318e-02f, 7.33094802e-03f, -5.86846247e-02f, 2.90928483e-02f, -3.18808854e-02f, -4.24888656e-02f, -7.36687239e-03f, 1.62196737e-02f, -4.03851867e-02f,
  -5.80588281e-02f, 3.19688395e-03f, 1.23277679e-02f, 5.99015579e-02f, -3.42772007e-02f, -2.45716944e-02f, 2.61547044e-02f, -2.90721785e-02f, 5.39115593e-02f, 1.30885863e-03f,
  -5.32847084e-02f, -2.09722910e-02f, -3.55722234e-02f, -8.93372297e-03f, 1.06331566e-02f, -2.89416052e-02f, 1.87235773e-02f, -1.39662987e-02f, -7.68763572e-03f, 1.79581475e-02f,
  1.66679285e-02f, -1.95016910e-04f, 4.57595624e-02f, 3.75395007e-02f, 1.57740060e-02f, 2.35579952e-04f, 9.38630570e-03f, 2.79008783e-02f, 1.80132426e-02f, -3.23129967e-02f,
  -4.37929714e-03f, -3.63863842e-03f, -2.89459340e-03f, 1.52498009e-02f, 1.86146284e-03f, 2.42063415e-05f, 5.30049838e-02f, 2.71679163e-02f, 5.01791993e-03f, -5.62525168e-02f,
  3.36239815e-01f, 2.00188532e-01f, 7.09530339e-02f, 5.23458719e-02f, 2.77734492e-02f, -2.29999609e-02f, 4.27323990e-02f, 6.90336898e-03f, 8.75908583e-02f, -2.40931679e-02f,
  3.27284746e-02f, 4.18958068e-02f, 1.24104591e-02f, 8.40445701e-03f, 1.43013354e-02f, -1.20271477e-04f, 5.74220680e-02f, 5.95493764e-02f, -2.86157392e-02f, 4.58181091e-02f,
  2.78048366e-02f, -4.97558899e-03f, -3.19046862e-02f, 1.04499822e-02f, -2.84384447e-03f, -5.17464094e-02f, -3.00095137e-02f, 1.21152401e-03f, -6.41299412e-02f, 1.16578797e-02f,
  -1.13390088e-02f, -3.28765363e-01f, 5.51846102e-02f, -1.46586865e-01f, 5.65643907e-02f, 3.86883587e-01f, 2.38974229e-01f, 6.13333732e-02f, -1.85588956e-01f, -1.40891373e-01f,
  3.18682492e-02f, -3.18033516e-01f, 3.61999646e-02f, -1.33409709e-01f, 3.34102631e-01f, -3.69629562e-02f, 1.04389310e-01f, -2.85252891e-02f, -8.16856548e-02f, 4.33551557e-02f,
  2.21842080e-02f, -8.96501914e-02f, 6.99026361e-02f, -6.25661165e-02f, 3.90752517e-02f, -1.23845883e-01f, 3.98218408e-02f, 6.06787130e-02f, -6.21483251e-02f, -8.92359540e-02f,
  -4.04098295e-02f, -1.70779198e-01f, 3.95106561e-02f, -5.88003471e-02f, 1.93689659e-01f, 9.62131694e-02f, 5.87969124e-02f, -2.84817331e-02f, 1.45288222e-02f, 2.58916505e-02f,
  2.77339313e-02f, 2.36421940e-03f, -4.95710224e-02f, 4.66594324e-02f, 1.11256167e-02f, -5.05770147e-02f, 1.97888818e-02f, -5.81193389e-03f, -3.16170976e-02f, 2.23757401e-02f,
  5.20795304e-03f, 2.73140930e-02f, 7.65145496e-02f, -7.35500380e-02f, 8.37434828e-02f, -5.33866994e-02f, -3.31281945e-02f, -6.54057134e-03f, 2.08320674e-02f, -1.61870662e-02f,
  1.59331001e-02f, -1.26614809e-01f, -3.51639427e-02f, -5.14462241e-04f, -3.76361832e-02f, 3.20273973e-02f, 5.82918040e-02f, 5.31163514e-02f, -1.51342563e-02f, 3.87284867e-02f,
  -1.37008633e-02f, -1.86021850e-02f, 4.08037342e-02f, 2.69785281e-02f, 4.67946306e-02f, -1.96829019e-03f, 3.94562483e-02f, -7.29031265e-02f, 5.45744598e-02f, 3.34552526e-02f,
  -7.97481611e-02f, -2.22602077e-02f, 2.38690563e-02f, 8.43252316e-02f, 3.07494029e-03f, -3.72150987e-02f, -1.02529377e-01f, -4.29849280e-03f, -3.28369923e-02f, 1.02414928e-01f,
  -9.27837100e-03f, -2.58243740e-01f, -1.81396734e-02f, 1.60272662e-02f, -5.16969003e-02f, 1.33598164e-01f, -7.22728996e-03f, 2.04200130e-02f, -3.40089351e-02f, 4.72049303e-02f,
  -3.74376867e-03f, 6.46550506e-02f, -3.71885188e-02f, 9.64645147e-02f, 3.98630314e-02f, -1.13541044e-01f, -7.19343945e-02f, -1.14058647e-02f, 6.60319775e-02f, -3.66000272e-02f,
  1.06228581e-02f, -4.11080942e-02f, 3.12725566e-02f, 7.81558976e-02f, 6.89713098e-03f, -2.21842732e-02f, -5.63325621e-02f, -5.14001548e-02f, 2.35907803e-03f, -3.86386216e-02f,
  6.58906698e-02f, -3.58623825e-02f, 3.95134538e-01f, 2.26418927e-01f, -1.50830343e-01f, 7.62985647e-03f, 1.95370167e-01f, 5.73867634e-02f, 3.98885399e-01f, -1.60340786e-01f,
  -3.13350260e-01f, 1.89067140e-01f, 4.13566828e-02f, -8.80530011e-03f, 1.02751523e-01f, 1.02089986e-01f, 5.41973801e-04f, -1.22248037e-02f, 1.43323511e-01f, 8.06389824e-02f,
  8.34842175e-02f, -1.10220656e-01f, 1.03126705e-01f, -9.07204598e-02f, -8.67229179e-02f, 1.75660197e-02f, -2.26713076e-01f, 1.22969948e-01f, -2.29237467e-01f, -5.40899113e-02f,
  -8.30708593e-02f, 1.61094651e-01f, -7.23717064e-02f, -4.36555734e-03f, -1.09193742e-01f, 1.64749417e-02f, 5.20875631e-03f, 5.63206449e-02f, 3.12716477e-02f, -2.16751657e-02f,
  -3.90049145e-02f, 3.20099443e-02f, -4.40844987e-03f, 4.71312664e-02f, 8.26122835e-02f, 2.72756014e-02f, -4.53649722e-02f, -8.18589777e-02f, 5.14765494e-02f, -4.82157841e-02f,
  -3.16546522e-02f, -1.91480890e-02f, -2.05550715e-02f, 2.85941418e-02f, 1.46138696e-02f, -4.35115434e-02f, 1.32861137e-01f, -6.64136410e-02f, -8.69674608e-02f, 2.54558935e-03f,
  5.57878166e-02f, 3.71138044e-02f, -4.16623652e-02f, 4.75300178e-02f, -4.69525391e-03f, -1.16107255e-01f, 8.93363147e-04f, 1.71987452e-02f, -4.96356469e-03f, -1.73575301e-02f,
  -6.21515960e-02f, -1.29360345e-03f, -2.87295859e-02f, 3.09794694e-02f, 5.19249998e-02f, 1.01466276e-01f, 2.37884559e-02f, -3.16997282e-02f, -3.30604576e-02f, -3.19317579e-02f,
  7.20264912e-02f, 9.87634435e-03f, 1.22416243e-02f, 1.28455842e-02f, -2.94458051e-03f, 5.57220876e-02f, 4.84492145e-02f, 6.98916912e-02f, 3.36946012e-03f, -2.85109188e-02f,
  -1.81905195e-01f, 1.00671709e-01f, -5.82378991e-02f, -9.10615548e-02f, 1.21122207e-02f, -8.95176157e-02f, 7.45375156e-02f, -5.53161874e-02f, 2.84193233e-02f, 8.03097561e-02f,
  -4.10152748e-02f, -2.21737921e-02f, -5.64332455e-02f, 9.60076973e-03f, 3.05792466e-02f, -2.68292837e-02f, 1.05272517e-01f, -2.73658596e-02f, -1.25686198e-01f, -9.52941403e-02f,
  -3.29801552e-02f, -4.72981762e-03f, -1.41018387e-02f, -3.33663286e-03f, -1.15934223e-01f, -1.11432120e-01f, -3.12296003e-02f, -1.12593723e-02f, -7.00210854e-02f, 8.14926811e-03f,
  3.37460846e-01f, 1.13309205e-01f, 1.60610929e-01f, 9.96365026e-02f, 1.39430121e-01f, 1.11824431e-01f, -7.99314082e-02f, 1.72286287e-01f, -7.94062838e-02f, -1.56269833e-01f,
  8.83582979e-02f, 6.55139387e-02f, -8.73121023e-02f, 1.52259581e-02f, 1.52842641e-01f, -1.72002256e-01f, 1.36469126e-01f, 6.63968641e-03f, -4.65642288e-02f, 1.99080765e-01f,
  7.61540011e-02f, 7.15606958e-02f, 6.68024868e-02f, 1.04531288e-01f, 6.81133196e-02f, 4.13666293e-02f, -7.31662959e-02f, 4.11788486e-02f, 1.05360016e-01f, -4.66671139e-02f,
  9.66561586e-02f, 6.69382559e-03f, -2.00282466e-02f, -7.03756809e-02f, 1.06605247e-01f, -2.06108354e-02f, -7.57885948e-02f, -2.14211736e-02f, 9.94468760e-03f, 3.60500216e-02f,
  -8.26824978e-02f, 1.21950611e-01f, 1.97400898e-02f, -7.34896585e-02f, -8.10163245e-02f, 8.37777648e-03f, -5.96925803e-03f, 8.74054432e-03f, 5.44393994e-02f, 4.93386462e-02f,
  5.19570187e-02f, 1.57424789e-02f, -2.54261610e-03f, -5.76581471e-02f, 3.92452143e-02f, 5.67678884e-02f, -9.72975232e-03f, 2.86889691e-02f, 1.06753763e-02f, 1.04681931e-01f,
  -3.42643447e-02f, -3.31971049e-02f, 1.28556713e-02f, 2.08763573e-02f, 5.48828803e-02f, 2.62133218e-02f, 5.33751585e-03f, 1.30378909e-03f, 2.23818589e-02f, 3.45880613e-02f,
  8.19178820e-02f, 1.70060284e-02f, -7.55543187e-02f, -3.07953525e-02f, -1.01326620e-02f, -4.06830609e-02f, 1.25053180e-02f, 5.17111272e-02f, 8.30356330e-02f, -6.34234324e-02f,
  -1.51828518e-02f, 7.26420060e-02f, 2.51808576e-02f, -7.85395056e-02f, -3.91543992e-02f, 1.64527670e-02f, 7.08182855e-03f, 5.32387430e-03f, -8.01407099e-02f, -4.62080948e-02f,
  2.04197764e-01f, 1.47344351e-01f, -6.03643022e-02f, 6.84767514e-02f, -5.25511540e-02f, -3.90445930e-03f, -9.72171575e-02f, 1.05562219e-02f, 1.59059372e-02f, 2.83062570e-02f,
  -1.74355879e-02f, -5.49194477e-02f, 6.55109882e-02f, 2.54515614e-02f, 6.32953504e-03f, -1.33052301e-02f, 4.17933939e-03f, 3.44210267e-02f, 3.16547304e-02f, 1.28523961e-01f,
  1.05476394e-01f, 7.79610425e-02f, 8.54150203e-05f, 4.39565107e-02f, -8.11926350e-02f, 3.05285621e-02f, -7.29461340e-03f, -4.43713218e-02f, -1.73244085e-02f, 4.66610352e-03f,
  -1.80216003e-02f, -1.25664920e-01f, 1.50830969e-01f, 1.55113608e-01f, -1.61663443e-01f, 1.22388355e-01f, 3.13346744e-01f, -1.58690348e-01f, -3.59430090e-02f, 6.56631216e-02f,
  -8.70201215e-02f, 1.82626754e-01f, -8.07533637e-02f, 1.31159008e-01f, 1.48598284e-01f, 2.36561783e-02f, 1.46348700e-01f, 8.92862305e-02f, -1.52883425e-01f, -4.13638577e-02f,
  -4.34646197e-02f, 6.24845363e-03f, 2.73213685e-01f, -2.00618535e-01f, 8.66962597e-02f, -1.36639364e-02f, -2.24109925e-02f, -5.92192486e-02f, 1.37524486e-01f, 2.31929105e-02f,
  -3.93564850e-02f, -1.16652846e-01f, 9.57938060e-02f, -5.44627681e-02f, -3.04945055e-02f, -1.69693641e-02f, 5.10510691e-02f, 1.21438764e-01f, 4.25330028e-02f, 2.39576865e-02f,
  -1.84503756e-02f, 9.43203364e-03f, 4.50311694e-03f, 5.07541327e-03f, 1.55626638e-02f, -3.03675346e-02f, 7.56430998e-02f, 1.17532566e-01f, -1.15982266e-02f, 7.47939199e-02f,
  1.04448915e-01f, 8.72589499e-02f, 3.12797613e-02f, -3.01148314e-02f, 5.11266175e-04f, 6.56640381e-02f, 1.43418342e-01f, 7.84491003e-02f, 5.13040312e-02f, 5.32543752e-03f,
  -3.39463428e-02f, -1.34402374e-02f, -5.52222319e-03f, -4.02439684e-02f, -8.90143216e-02f, -6.97249845e-02f, 5.06160706e-02f, -1.45715743e-03f, -8.74492079e-02f, 4.96439927e-04f,
  -5.11982851e-02f, 5.75441588e-03f, -4.36130054e-02f, 2.77483948e-02f, 4.50878367e-02f, 2.55630165e-02f, -3.32163088e-02f, -5.36248051e-02f, -1.73597168e-02f, 3.09869591e-02f,
  -1.99589748e-02f, -4.22099754e-02f, 5.52322157e-03f, -2.73065697e-02f, -4.40907031e-02f, 2.48749983e-02f, -4.91879992e-02f, 8.26382115e-02f, -1.95782110e-02f, -2.32424773e-02f,
  -2.62772083e-01f, -1.54825717e-01f, 4.94918637e-02f, 4.61065024e-02f, -2.36383770e-02f, -9.21450648e-03f, 9.85902250e-02f, -2.59356536e-02f, -5.14819548e-02f, -5.36602437e-02f,
  -3.59800062e-03f, 1.03634764e-02f, -4.78845127e-02f, -1.60254855e-02f, 6.24596104e-02f, -2.85783224e-03f, 2.71657798e-02f, -6.55450523e-02f, 1.20601309e-02f, -8.26434046e-02f,
  2.08788346e-02f, -1.75224710e-02f, 2.88518649e-02f, -8.54307786e-02f, -3.77279446e-02f, 5.22266626e-02f, -4.48637158e-02f, 4.00558859e-02f, 1.89064331e-02f, 5.94976991e-02f,
  -1.72881380e-01f, 4.08363968e-01f, 2.22772017e-01f, -1.11388810e-01f, -2.69190341e-01f, -2.03388199e-01f, -2.00067267e-01f, 1.26264393e-01f, 8.13359395e-03f, 1.10696144e-01f,
  -1.05376527e-01f, 1.31615162e-01f, 1.46968961e-01f, -3.35983336e-02f, -1.16363749e-01f, 1.83302268e-01f, -4.44618799e-02f, -5.22134043e-02f, 9.24545303e-02f, 3.55260521e-02f,
  -3.66111584e-02f, -6.55545294e-02f, 5.76617047e-02f, 5.21840528e-02f, -7.80907348e-02f, 1.56698411e-03f, -5.90298958e-02f, -3.05532152e-03f, -1.16434030e-01f, 5.68803586e-03f,
  -8.89218003e-02f, 2.30096169e-02f, 5.33277635e-03f, 8.97294953e-02f, -3.83324847e-02f, -3.21654938e-02f, -3.40200700e-02f, -9.74454880e-02f, -1.02381170e-01f, -3.66558060e-02f,
  -2.01401673e-02f, -2.20998898e-02f, 2.78668813e-02f, -5.64817674e-02f, -6.34900527e-03f, -1.25864477e-04f, -2.29853466e-02f, -3.75955552e-03f, -1.33421330e-03f, 4.37337756e-02f,
  7.19262473e-03f, 3.92296165e-02f, 1.94286052e-02f, 3.14027853e-02f, -6.14429300e-05f, 9.96776577e-03f, 2.25320226e-03f, 8.87874421e-03f, 9.44843665e-02f, 1.72734205e-02f,
  2.70414986e-02f, 5.87798357e-02f, 2.95939436e-03f, 1.82373542e-02f, 4.15894166e-02f, -3.97161506e-02f, -4.74514216e-02f, 4.32862267e-02f, 3.27060632e-02f, -6.05483074e-03f,
  8.22649058e-03f, -1.53537095e-02f, -5.05243465e-02f, 1.00445263e-02f, -2.08628029e-02f, -1.74989887e-02f, -3.75898257e-02f, 2.90681608e-02f, -6.82235956e-02f, -3.38348150e-02f,
  -1.85750611e-02f, -2.58540809e-02f, -4.10201065e-02f, -8.58308654e-03f, 2.65264958e-02f, -2.45692674e-02f, 1.05115827e-02f, 7.62720853e-02f, 3.57650965e-02f, -9.61409882e-03f,
  8.42674598e-02f, 2.31998831e-01f, -6.21601054e-03f, -1.22401398e-02f, 4.56447601e-02f, -4.33668634e-03f, 9.16415453e-02f, 7.18963966e-02f, 6.69217855e-02f, 2.18604542e-02f,
  -1.29881382e-01f, -3.01533900e-02f, 5.67384576e-03f, -7.75275053e-03f, -6.27010223e-03f, -5.37970774e-02f, 3.23701985e-02f, -7.36701563e-02f, -2.32292395e-02f, 4.21462320e-02f,
  2.34863535e-02f, -3.53843980e-02f, 3.34801860e-02f, -6.64282218e-02f, -4.94365580e-02f, 7.28517212e-03f, -3.48298550e-02f, -4.40102778e-02f, 2.84561273e-02f, 2.60071624e-02f,
  1.90012172e-01f, 3.07258815e-01f, 7.22615793e-02f, -9.53320414e-02f, 2.92856172e-02f, 1.44861653e-01f, 1.79387152e-01f, -1.05561912e-01f, 1.19658490e-03f, 1.45897463e-01f,
  -1.70593888e-01f, 9.01939198e-02f, -4.71825115e-02f, -1.58857375e-01f, -2.06224695e-01f, -1.50643304e-01f, -1.20696090e-01f, -1.48158111e-02f, -2.05555677e-01f, -1.05282456e-01f,
  -1.44252136e-01f, -2.20900774e-01f, -3.18914145e-01f, -1.09322689e-01f, -6.63950145e-02f, -3.16329673e-02f, -1.24124996e-01f, -6.84560314e-02f, 1.55921346e-02f, 1.62443183e-02f,
  -2.75223013e-02f, -2.87915245e-02f, 2.28447113e-02f, 4.52056378e-02f, -5.41577339e-02f, 7.90532157e-02f, 6.10165633e-02f, 1.08673116e-02f, -7.41332173e-02f, -1.53481588e-02f,
  2.30653621e-02f, 2.90836813e-03f, 4.47923541e-02f, 9.79177281e-03f, 6.37963042e-02f, 4.53666523e-02f, -5.43532558e-02f, -2.64707636e-02f, -2.05911826e-02f, 4.63923737e-02f,
  -3.72262858e-02f, 1.96286589e-02f, -6.06274744e-03f, -1.58422459e-02f, -8.53950605e-02f, -9.88403894e-03f, 4.38992567e-02f, 3.61463130e-02f, 1.63928382e-02f, 2.71371342e-02f,
  1.01974867e-01f, 4.60844897e-02f, 2.33038072e-03f, -2.87010055e-02f, -6.42898772e-03f, -3.30037996e-02f, 3.46211120e-02f, 1.82951279e-02f, -1.48672052e-02f, 6.03863271e-04f,
  -4.50619832e-02f, 6.27757423e-03f, -2.28499379e-02f, 4.37667891e-02f, 2.22153626e-02f, 8.12394172e-02f, -1.58754718e-02f, -2.16528890e-03f, 5.48954718e-02f, -1.00737438e-01f,
  -2.33437540e-03f, -2.43124198e-02f, 6.95295855e-02f, -8.42295587e-03f, -3.97780202e-02f, -9.03810412e-02f, -2.10906174e-02f, 1.87960435e-02f, -8.33650529e-02f, 4.22824286e-02f,
  5.73687442e-03f, 1.47150114e-01f, -5.85038178e-02f, -2.46328637e-02f, 3.46703231e-02f, -3.01412027e-02f, -4.50121835e-02f, -7.11078802e-03f, 2.40266565e-02f, -5.41137718e-02f,
  4.01119962e-02f, -1.64352190e-02f, 3.88577431e-02f, -5.33969514e-02f, -5.77844456e-02f, -1.31889526e-02f, 8.12263116e-02f, 7.64204413e-02f, -3.33361402e-02f, 2.45677549e-02f,
  4.37552072e-02f, 1.15909777e-03f, 2.47150995e-02f, -6.31539300e-02f, -5.28936693e-03f, 7.05374554e-02f, 5.42231053e-02f, 1.21412262e-01f, 9.57222655e-03f, 5.70753403e-02f,
  -7.86466226e-02f, -5.47182262e-02f, 1.05301030e-01f, -1.13869622e-01f, 2.88046837e-01f, 1.60585478e-01f, -2.78695114e-02f, 1.73481882e-01f, 1.64069906e-01f, -2.22250819e-01f,
  -8.67194906e-02f, -1.42027944e-01f, -1.95183098e-01f, -1.56323481e-02f, -1.20938003e-01f, 1.50857475e-02f, -6.56441674e-02f, -2.31897086e-02f, 1.91295877e-01f, -1.24956548e-01f,
  1.97652459e-01f, -1.23089798e-01f, 1.57257821e-02f, -2.71928366e-02f, 1.61208734e-02f, 1.16064653e-01f, -1.97803259e-01f, 1.32735908e-01f, -2.90302169e-02f, 7.65618235e-02f,
  2.15795953e-02f, 6.38133585e-02f, 4.77095172e-02f, 2.89126523e-02f, -5.42170778e-02f, 6.07105754e-02f, -2.02173349e-02f, 1.92987844e-02f, 2.97515523e-02f, -7.62722874e-03f,
  -6.02192357e-02f, 2.41346788e-02f, -7.02622859e-03f, 3.76301408e-02f, 1.47018537e-01f, -1.23060811e-02f, 7.14031234e-02f, 6.85768202e-02f, -9.37771518e-03f, 1.42959043e-01f,
  1.16693050e-01f, 6.48114681e-02f, -3.16789397e-03f, -3.96159291e-02f, 3.11112287e-03f, 1.95195805e-02f, 5.48650995e-02f, 3.02498955e-02f, 3.69179286e-02f, 5.91699369e-02f,
  4.42840643e-02f, 7.75008276e-02f, -1.90188852e-03f, -5.67512922e-02f, -1.73275899e-02f, 3.32067087e-02f, -2.67762169e-02f, 2.85892026e-03f, -1.71749517e-02f, 2.42646299e-02f,
  -8.13475028e-02f, -2.36805249e-02f, 7.84447044e-02f, 9.79585350e-02f, -3.77585292e-02f, -3.57173122e-02f, -9.70459655e-02f, -2.42168214e-02f, 1.21260723e-02f, -2.30679307e-02f,
  -2.63269376e-02f, 4.83156145e-02f, -5.03819585e-02f, 4.88180667e-02f, 1.43283252e-02f, 2.38547958e-02f, 1.14124395e-01f, 5.47246672e-02f, -3.34954299e-02f, -4.32725698e-02f,
  -1.15975678e-01f, -6.41287565e-02f, -3.79634909e-02f, -6.45737455e-04f, -8.68399143e-02f, -3.19706611e-02f, 4.36493792e-02f, 7.70552736e-03f, -2.95797549e-02f, -4.36628014e-02f,
  4.24654782e-02f, -3.83409597e-02f, 1.82985552e-02f, 5.25256507e-02f, 3.79836326e-03f, -2.50524655e-02f, 1.81944687e-02f, -4.89187464e-02f, 2.22721533e-03f, -3.05667166e-02f,
  -7.65928552e-02f, -4.45228592e-02f, -3.44438963e-02f, 8.44129652e-04f, -7.87331387e-02f, -3.33808213e-02f, 2.95573543e-03f, -3.10639497e-02f, 4.53197993e-02f, 3.26642171e-02f,
  1.44546941e-01f, -2.04620764e-01f, -1.81484133e-01f, -5.98293133e-02f, -9.16118398e-02f, 7.56607875e-02f, 1.77719012e-01f, -1.64792165e-01f, -1.30266473e-01f, -1.34769427e-02f,
  1.42770723e-01f, -4.38774750e-02f, 8.89476240e-02f, 9.99503508e-02f, 2.16757014e-01f, 1.35818124e-01f, 1.07074857e-01f, 1.26315868e-02f, -1.09239116e-01f, -1.18356392e-01f,
  -6.02952130e-02f, 5.47533967e-02f, 1.25726357e-01f, -1.80032268e-01f, -3.36954221e-02f, -1.01051003e-01f, 9.05929729e-02f, -1.10463448e-01f, -4.47808392e-02f, 3.36221382e-02f,
  1.36144698e-01f, -7.18324929e-02f, -1.85289755e-02f, -4.05687653e-02f, 3.68633606e-02f, 5.15143722e-02f, 6.05511479e-02f, 4.16900776e-02f, -4.98706736e-02f, -2.62983162e-02f,
  2.94452123e-02f, 9.26937719e-06f, -2.26563327e-02f, -4.55452316e-02f, -6.00171387e-02f, -3.39539945e-02f, -2.79994477e-02f, -2.52433084e-02f, -1.03619248e-01f, 2.46325452e-02f,
  4.46178652e-02f, 7.05619808e-03f, -4.22855280e-02f, -4.55142707e-02f, -4.21887748e-02f, -7.24352151e-02f, 3.02544180e-02f, -8.36796034e-03f, 3.37523073e-02f, -6.41854852e-02f,
  5.54964952e-02f, -9.69275981e-02f, -4.91901450e-02f, 1.20574925e-02f, -3.16843353e-02f, -1.23384334e-02f, -5.99083342e-02f, 3.86409834e-02f, -5.05139157e-02f, 3.81591432e-02f,
  3.60010900e-02f, 1.16846990e-02f, -8.06066543e-02f, -1.28157958e-02f, -2.42012162e-02f, 4.30871034e-03f, 2.88376063e-02f, -2.34547686e-02f, 2.78934538e-02f, 8.14074464e-03f,
  3.56538482e-02f, 1.30198046e-03f, -3.94865684e-03f, 8.46841633e-02f, 2.48822640e-03f, -2.49352008e-02f, -1.02187712e-02f, -2.55056415e-02f, 7.13741733e-03f, 3.95770930e-02f,
  6.08849747e-04f, -1.64728791e-01f, -3.43935564e-02f, 1.41020874e-02f, -1.60798002e-02f, 1.66206565e-02f, 1.51667884e-02f, -8.78735259e-03f, -2.12203916e-02f, 2.54467502e-02f,
  -2.49688104e-02f, -2.69642919e-02f, -1.87966619e-02f, 3.94760817e-02f, -3.36589850e-03f, 2.77557373e-02f, 1.32002020e-02f, -1.05324313e-02f, -2.44094688e-03f, 4.36429400e-03f,
  -1.50609808e-02f, -1.61365489e-03f, -2.55282652e-02f, -1.90534331e-02f, 1.49702439e-02f, 3.91497230e-03f, -5.39431497e-02f, -4.19130456e-03f, 9.60231666e-03f, 1.36417681e-02f,
  -5.60842119e-02f, 5.97170778e-02f, -4.37042564e-02f, 1.03368070e-02f, 4.61166650e-02f, 2.05447644e-01f, 1.40407700e-02f, 8.64146873e-02f, -2.32016310e-01f, 1.04849100e-01f,
  1.15791194e-01f, -3.77218686e-02f, -1.00120708e-01f, 3.49680930e-01f, 4.31782752e-02f, -1.18903801e-01f, 1.55592531e-01f, 7.95112550e-02f, -1.47654533e-01f, 2.95885038e-02f,
  -1.14901245e-01f, 1.16750509e-01f, 5.39316349e-02f, 5.23009785e-02f, 1.68420821e-01f, -6.82012886e-02f, 9.01891366e-02f, -5.32765724e-02f, 2.94625163e-01f, 1.17463246e-01f,
  9.54145417e-02f, -1.58867724e-02f, 3.72876897e-02f, -7.23819807e-03f, 6.51371107e-03f, 3.16303745e-02f, 3.52578685e-02f, 1.52889118e-02f, 2.00710129e-02f, -9.19643976e-03f,
  -3.85991260e-02f, -4.30672150e-03f, 1.33886840e-02f, -8.04687385e-03f, -3.05109136e-02f, 3.45002078e-02f, 8.52158014e-03f, 2.72971429e-02f, 1.33829312e-02f, 6.46213070e-02f,
  -7.51788542e-02f, 5.50653078e-02f, -3.92168909e-02f, -3.71700376e-02f, -1.12255879e-01f, 3.44390632e-03f, -3.42004225e-02f, -3.07815988e-02f, -5.82569614e-02f, -2.00624093e-02f,
  1.30793834e-02f, -1.00554585e-01f, 4.06656088e-03f, 3.15581970e-02f, 4.36486453e-02f, 1.06815202e-02f, 1.18958876e-02f, 4.19963524e-02f, -2.20372342e-02f, 1.16598355e-02f,
  -7.07144737e-02f, 3.95173393e-02f, 3.46773304e-02f, -1.88560225e-02f, 1.04193715e-02f, -1.12840096e-02f, -5.03534265e-02f, -1.41960876e-02f, -4.84762900e-02f, 1.16085233e-02f,
  -2.36977413e-02f, -3.99004482e-02f, 4.69044549e-03f, -3.39602190e-03f, -3.78790535e-02f, -2.93539022e-03f, 1.90728903e-02f, 3.49810570e-02f, -2.32781917e-02f, -9.91033390e-03f,
  -1.25992540e-02f, -7.56797045e-02f, -6.26006350e-02f, 1.13811055e-02f, 2.83749978e-04f, 6.03432022e-02f, -3.40779126e-02f, 5.00346273e-02f, -3.74714248e-02f, -5.13728559e-02f,
  1.00116439e-01f, -1.23630802e-03f, -4.85172197e-02f, 1.91621354e-03f, 3.47078070e-02f, -1.04067766e-03f, -9.54945236e-02f, -1.71270389e-02f, -6.12753071e-02f, -3.50452051e-03f,
  2.08864249e-02f, -4.54614535e-02f, -2.59434879e-02f, -1.95064489e-02f, 6.14670813e-02f, -2.41242312e-02f, -2.19290461e-02f, 1.86364595e-02f, 4.18777838e-02f, -3.45092379e-02f,
  2.11881667e-01f, -1.57299265e-01f, -1.77679762e-01f, 9.05999094e-02f, 3.09154056e-02f, -1.21968701e-01f, -2.19988778e-01f, 1.45386547e-01f, -6.81263134e-02f, -3.33024077e-02f,
  7.49730244e-02f, -9.32549611e-02f, -2.12296396e-02f, 5.76579012e-03f, -1.79593696e-03f, -8.31097215e-02f, 2.76916903e-02f, -7.61361569e-02f, 4.15301919e-02f, -4.93327975e-02f,
  4.14556265e-02f, 1.23132691e-01f, -4.58509959e-02f, 1.02686532e-01f, -2.67259758e-02f, 7.10414946e-02f, 1.25388011e-01f, -7.37662986e-02f, -1.45589781e-03f, 1.45398062e-02f,
  6.98397681e-02f, 9.48445052e-02f, 2.63334475e-02f, -5.19911200e-02f, 4.75642970e-03f, 2.13469937e-02f, -2.04878524e-02f, -1.59183264e-01f, -8.01396966e-02f, -4.29462567e-02f,
  -2.87944227e-02f, 4.34755608e-02f, 1.26491720e-02f, -4.94326130e-02f, 1.81183405e-02f, -6.34135753e-02f, -1.12125184e-02f, -5.31526953e-02f, 1.12446519e-02f, -2.32783775e-03f,
  -2.42259242e-02f, -3.94393951e-02f, -4.09773402e-02f, 1.54284723e-02f, -2.16552988e-02f, -2.62863804e-02f, -1.85928345e-02f, -3.14579643e-02f, -1.66572183e-02f, -2.97902301e-02f,
  4.91819950e-03f, 1.01836529e-02f, -1.78003069e-02f, 2.27364413e-02f, -2.46074963e-02f, 6.81354180e-02f, -5.25101125e-02f, -1.20853847e-02f, 2.32732166e-02f, 3.47380750e-02f,
  5.43482043e-02f, 1.52350655e-02f, 8.72459933e-02f, -6.50174469e-02f, 2.50039212e-02f, -3.85347903e-02f, -7.37822354e-02f, 3.81426662e-02f, 1.42862676e-02f, 1.25253974e-02f,
  2.68062800e-02f, 1.75444279e-02f, 7.04262219e-03f, 4.28444445e-02f, -2.05888655e-02f, -1.33790113e-02f, 4.92028482e-02f, 1.88464404e-03f, -2.88870130e-02f, -1.29822381e-02f,
  1.10952280e-01f, 2.19729900e-01f, 1.58972126e-02f, 2.41575250e-03f, -7.70547241e-02f, 9.74861998e-03f, -1.66965425e-02f, -2.61002537e-02f, -4.36049588e-02f, -1.78141333e-02f,
  -7.91302249e-02f, -4.16757800e-02f, -1.18095009e-02f, -1.98073909e-02f, 3.46447155e-02f, 3.76094319e-02f, 6.05764624e-04f, -5.45337573e-02f, -5.84068662e-03f, 5.02641574e-02f,
  5.82495369e-02f, -4.32865173e-02f, 1.03995316e-02f, 8.36402401e-02f, 7.51937926e-02f, 1.59976992e-03f, 1.55448159e-02f, -3.83968018e-02f, -2.77296404e-05f, -4.61813956e-02f,
  1.79493085e-01f, -1.36186508e-02f, -1.57398522e-01f, 3.46706301e-01f, 1.28381595e-03f, -6.76964223e-02f, 1.54325143e-02f, 5.95937073e-02f, 7.71297142e-02f, 8.77754912e-02f,
  1.03963494e-01f, -2.05429271e-02f, -1.67054534e-01f, 3.04761291e-01f, 7.94307590e-02f, 3.23674865e-02f, 2.56497651e-01f, 1.23634264e-01f, 5.15398532e-02f, 1.25908768e-02f,
  1.80077896e-01f, 3.38453352e-01f, 2.47807615e-02f, 9.73012745e-02f, 5.90008423e-02f, 1.14176814e-02f, 2.20147014e-01f, -1.17362447e-01f, 1.36288717e-01f, 2.51641050e-02f,
  -9.61986631e-02f, 7.01630414e-02f, -1.92481745e-02f, -2.44706348e-02f, -1.13892264e-03f, -4.09503505e-02f, 8.20960198e-03f, -6.58877715e-02f, 5.48204733e-03f, -3.83264609e-02f,
  -5.08730821e-02f, -3.04675731e-03f, 9.40445364e-02f, -1.96055276e-03f, 4.40444164e-02f, -2.70358771e-02f, 2.51607895e-02f, -8.80438536e-02f, -4.95176576e-02f, -5.87108126e-03f,
  -7.25563616e-02f, -2.18800129e-03f, 2.54754163e-02f, 1.47534078e-02f, -1.36955632e-02f, -2.05223472e-03f, -2.12225951e-02f, -8.69045183e-02f, -4.80286479e-02f, 6.07648529e-02f,
  7.79057965e-02f, 3.44385579e-02f, -2.37929691e-02f, -2.34695077e-02f, 2.93708742e-02f, 5.63115887e-02f, 2.64346544e-02f, 1.19938971e-02f, 4.69488762e-02f, 4.48272415e-02f,
  6.09014882e-03f, -3.25795934e-02f, 1.75664276e-02f, -9.56924539e-03f, 5.07812239e-02f, 1.97767504e-02f, -1.54087469e-02f, -1.68028250e-02f, 1.49630187e-02f, 1.50402375e-02f,
  3.05966828e-02f, -3.95031646e-02f, 4.85335430e-03f, -1.48520516e-02f, -1.10518262e-02f, -3.04011442e-02f, 9.23968013e-03f, -4.37120162e-02f, -4.57776450e-02f, -1.40873985e-02f,
  5.70067577e-02f, 2.05463484e-01f, 3.32392268e-02f, -7.00401515e-02f, 6.25891164e-02f, 3.05300243e-02f, 2.85269115e-02f, -1.80743672e-02f, 1.64949484e-02f, 3.49838333e-03f,
  -8.28554388e-03f, 2.23041093e-03f, 7.64202839e-03f, 3.01905791e-03f, -3.10440175e-02f, 4.58776429e-02f, 6.21334910e-02f, -1.66266970e-02f, 8.37486163e-02f, 3.39213386e-02f,
  -9.57397715e-05f, -5.69173470e-02f, 1.65509917e-02f, 3.55619267e-02f, 4.28924412e-02f, 7.82504007e-02f, -1.19464397e-02f, -4.01171520e-02f, 2.23752037e-02f, 2.11223159e-02f,
  -4.88482982e-01f, 1.02290452e-01f, 5.59333898e-02f, -1.70170203e-01f, -2.04091728e-01f, 2.86596924e-01f, -1.54152303e-03f, -1.01149872e-01f, 2.15986725e-02f, 5.24217524e-02f,
  -5.78751974e-02f, -1.25524914e-02f, 1.46817550e-01f, -6.37972504e-02f, -7.27400258e-02f, 3.22738558e-01f, -1.55015469e-01f, -5.23046181e-02f, -2.52628066e-02f, -3.06498587e-01f,
  -1.78551689e-01f, -2.47264251e-01f, -1.94628090e-01f, -1.85879156e-01f, -1.23106852e-01f, -1.73100874e-01f, -2.33843297e-01f, 4.44572717e-02f, -1.00237742e-01f, 1.19930707e-01f,
  -9.20725018e-02f, -1.11993067e-01f, 2.11285371e-02f, 8.72557759e-02f, -1.07633196e-01f, -2.61977054e-02f, -1.18811037e-02f, 1.10080235e-01f, -5.06007746e-02f, 6.62992820e-02f,
  5.31032458e-02f, -4.60615046e-02f, -3.56126018e-03f, 7.50789195e-02f, -3.50051862e-03f, 3.15498337e-02f, 6.03531003e-02f, -8.82964116e-03f, -6.20400067e-03f, 2.43672952e-02f,
  -1.73859168e-02f, 5.86006008e-02f, -8.70243087e-03f, 4.81159277e-02f, -1.26651768e-02f, -9.56233032e-03f, -1.27983326e-02f, 1.47127323e-02f, 1.14583477e-01f, -5.01095727e-02f,
  6.40135035e-02f, -2.44020391e-03f, 6.73693651e-03f, 5.74369207e-02f, 1.21230679e-02f, -9.95949097e-03f, 8.13174099e-02f, -1.05129285e-02f, 1.16277365e-02f, -1.21588157e-02f,
  -5.11708446e-02f, 3.55015174e-02f, 4.85317186e-02f, 7.04202205e-02f, -7.57881030e-02f, -3.94195877e-02f, -1.36954449e-02f, 2.50055417e-02f, -3.96072082e-02f, 3.95750962e-02f,
  7.18898326e-02f, -3.74448486e-02f, -2.63973046e-02f, -1.97027102e-02f, 3.10392417e-02f, -3.82327387e-04f, 4.96200696e-02f, 1.94245037e-02f, -7.15931579e-02f, 1.07851839e-02f,
  -2.08935495e-02f, -7.53426701e-02f, -3.48818265e-02f, -2.27828976e-03f, 1.45711761e-03f, -1.22334575e-02f, -3.32815130e-03f, 5.42412028e-02f, 8.62244982e-03f, 3.50062996e-02f,
  -1.07637636e-01f, -9.86624733e-02f, 2.17088033e-02f, 4.83471602e-02f, 5.85181452e-02f, -4.14110534e-02f, -4.44398820e-02f, -1.06094822e-01f, -4.47906479e-02f, 5.14328061e-03f,
  -5.34368828e-02f, -7.71557465e-02f, -3.44468541e-02f, -8.87941197e-02f, -7.13687995e-03f, -3.60174440e-02f, -5.23151904e-02f, -2.60974020e-02f, 9.43811834e-02f, 3.93073484e-02f,
  -6.61912560e-02f, -3.87794256e-01f, -3.66301858e-03f, -1.48752527e-02f, -4.54189070e-02f, 2.61071008e-02f, 1.13134809e-01f, -1.40201911e-01f, -1.11925192e-01f, -1.39362291e-01f,
  8.23647678e-02f, -2.54349913e-02f, -3.67292240e-02f, 5.79335354e-02f, 1.36403561e-01f, 1.10139683e-01f, -2.11714692e-02f, 9.15992707e-02f, 1.06063029e-02f, -8.16889629e-02f,
  4.45458200e-03f, 1.18487384e-02f, 2.44602896e-02f, -1.70164645e-01f, 5.56560606e-02f, -5.69389723e-02f, 2.29232237e-02f, 1.89411528e-02f, 7.92401955e-02f, 8.13853517e-02f,
  -1.14200048e-01f, -1.12404257e-01f, -7.16862008e-02f, -6.12408482e-02f, -2.72482987e-02f, 3.29582603e-03f, 1.92933753e-02f, 5.98094016e-02f, 4.04771306e-02f, 1.57782261e-03f,
  2.66734958e-02f, -1.54103674e-02f, 3.21357995e-02f, 3.51228490e-02f, -1.16859846e-01f, -1.24030188e-01f, 3.49076539e-02f, 5.54860160e-02f, -4.00148481e-02f, 5.01043126e-02f,
  -3.27565148e-02f, 5.34501150e-02f, -6.69586137e-02f, 4.70745824e-02f, 7.96460360e-03f, -6.47151098e-02f, 7.57603645e-02f, 5.86009435e-02f, 2.69393735e-02f, -5.44973202e-02f,
  -8.73603486e-03f, 3.29493172e-02f, -6.20703772e-02f, -3.21539231e-02f, 1.88697074e-02f, -5.44493645e-03f, -3.00201513e-02f, 3.65548618e-02f, -1.50338123e-02f, -5.24596646e-02f,
  7.51080215e-02f, -4.58948761e-02f, 1.30595695e-02f, 4.69545741e-03f, 1.52948042e-02f, -1.58178061e-02f, 3.01282213e-04f, 7.13404194e-02f, 3.01771611e-03f, 6.70106150e-03f,
  -2.64327321e-02f, -2.93889549e-02f, 4.14028689e-02f, 7.99676345e-04f, -6.17368966e-02f, 2.33809315e-02f, 2.13727001e-02f, -2.70489207e-03f, 6.11558277e-03f, 6.29479215e-02f,
  -2.48962209e-01f, -2.51241177e-01f, -4.22899276e-02f, 4.37281206e-02f, -1.90015268e-02f, -4.04812358e-02f, -6.05003946e-02f, -3.64145786e-02f, -6.30548671e-02f, 5.81069551e-02f,
  -6.96509108e-02f, 9.26683471e-03f, 1.32951904e-02f, 1.64281987e-02f, 1.38319414e-02f, -3.68133523e-02f, 4.52599749e-02f, 7.02746678e-03f, -3.98659296e-02f, -1.68662705e-02f,
  -4.56980281e-02f, 1.69022623e-02f, 5.89388842e-03f, -6.41707256e-02f, 5.84559590e-02f, 4.04519290e-02f, -8.82300884e-02f, -1.41485520e-02f, 4.71603498e-02f, -2.28632819e-02f,
  2.30156347e-01f, -1.78613424e-01f, -1.25424594e-01f, -3.13787442e-03f, -5.21212742e-02f, -3.49692583e-01f, -4.91956808e-02f, -1.84239686e-01f, -1.50095120e-01f, -5.03403768e-02f,
  3.01718544e-02f, 1.02086067e-01f, 1.27739459e-01f, -2.06888363e-01f, -1.49062291e-01f, -1.52611792e-01f, -2.67833769e-01f, -5.96783236e-02f, -5.37394024e-02f, 2.81204414e-02f,
  2.88549927e-03f, -1.15463864e-02f, -9.39088129e-03f, -4.85584559e-03f, -7.40371132e-03f, 1.04142368e-01f, 2.06244320e-01f, 1.29048437e-01f, -4.22885455e-02f, -1.62415560e-02f,
  -9.13388357e-02f, 2.63104979e-02f, -5.36180884e-02f, -4.44917157e-02f, -6.50471151e-02f, 7.44082732e-03f, 1.99148804e-02f, 3.97436917e-02f, 8.56240877e-05f, -2.12875158e-02f,
  2.62769312e-02f, -7.42586190e-03f, -6.65900484e-02f, -3.02619208e-03f, 4.38013300e-02f, -3.53672728e-03f, -3.77027132e-02f, -4.77963351e-02f, -1.21428231e-02f, 1.07664810e-02f,
  -1.06498292e-02f, -4.24129553e-02f, -3.65565084e-02f, -1.87051166e-02f, 3.85241471e-02f, -7.90432189e-03f, -7.11707398e-02f, 2.31444724e-02f, -3.44452937e-03f, -6.84971139e-02f,
  2.80363988e-02f, 1.45737613e-02f, 5.80114871e-02f, 6.32873848e-02f, 3.57664376e-02f, 7.14360327e-02f, 2.20719427e-02f, -1.37864118e-02f, 5.82319610e-02f, -2.00776421e-02f,
  -3.57460193e-02f, 1.80005133e-02f, 1.43243279e-03f, -2.86874399e-02f, -8.26421380e-03f, 4.82662395e-02f, 7.03870654e-02f, 1.56214321e-02f, -2.10182648e-02f, -4.44347374e-02f,
  1.66777838e-02f, -7.03945337e-03f, -8.84107966e-03f, 4.38974276e-02f, -2.22091451e-02f, -8.49804748e-03f, 3.68760079e-02f, 1.54746708e-03f, -4.97209048e-03f, -1.54194208e-02f,
  -1.34311974e-01f, -1.23154163e-01f, 3.91686801e-03f, 6.45689741e-02f, 2.69520618e-02f, -1.63378753e-02f, -5.42158484e-02f, -6.77252188e-02f, 2.25265175e-02f, 1.19087566e-02f,
  -1.90690178e-02f, 2.06523743e-02f, 4.90697473e-02f, 6.05403483e-02f, -1.21511845e-02f, -4.59367447e-02f, 7.56068453e-02f, -2.90055741e-02f, -4.23185667e-03f, 8.23066570e-03f,
  7.13750273e-02f, 1.73040871e-02f, 1.07723018e-02f, -2.52734385e-02f, -1.91754848e-02f, 5.50208353e-02f, 1.09514957e-02f, -6.30680025e-02f, 1.89261511e-02f, -7.68658146e-02f,
  -3.43856961e-01f, 1.36364162e-01f, -3.77918296e-02f, 5.57677727e-03f, -4.00884859e-02f, 4.63719778e-02f, -2.23474815e-01f, 6.31819367e-02f, -2.16849655e-01f, -2.70514116e-02f,
  -2.92548668e-02f, 1.63663030e-01f, -9.93635356e-02f, 2.51575738e-01f, 7.82938525e-02f, 7.01165199e-02f, 2.25315422e-01f, 1.66305214e-01f, 1.05089180e-01f, 2.32457332e-02f,
  7.10781962e-02f, 2.20655546e-01f, 2.53640443e-01f, 1.81034341e-01f, 1.27486706e-01f, 2.62500476e-02f, -2.27102004e-02f, 1.14939306e-02f, 2.52495974e-01f, 1.05757155e-01f,
  7.40328878e-02f, -1.18559122e-01f, -7.21910745e-02f, 9.96484142e-03f, -2.77301744e-02f, -8.14498067e-02f, -3.01078837e-02f, -2.22380236e-02f, -3.06723621e-02f, 4.48658690e-02f,
  -7.51235581e-04f, -1.55089712e-02f, 9.67641994e-02f, 2.86092586e-03f, -5.20582572e-02f, 1.07772707e-03f, 3.36784683e-02f, 5.73558547e-02f, 4.02671769e-02f, 5.89222834e-02f,
  3.35916840e-02f, 6.35617077e-02f, -2.57561132e-02f, 4.10702229e-02f, -1.94967929e-02f, -1.00057200e-01f, -1.67015172e-03f, 4.86114882e-02f, 8.45934823e-02f, -7.83808008e-02f,
  -5.75106293e-02f, -7.70622790e-02f, 9.19528902e-02f, 8.36301711e-04f, 3.63278575e-02f, 2.29766890e-02f, -3.97204533e-02f, 5.89963160e-02f, -4.16843034e-02f, -3.44531536e-02f,
  3.50318551e-02f, 2.30324045e-02f, -2.64848694e-02f, -5.89366406e-02f, 9.61790793e-03f, -1.42036099e-02f, 1.23953978e-02f, 6.42916560e-02f, -2.52535772e-02f, 1.81080587e-02f,
  -4.48980629e-02f, 4.63072807e-02f, 6.29339144e-02f, -6.57551643e-03f, -4.68448922e-02f, -1.84208937e-02f, 4.79410179e-02f, 2.42336150e-02f, 2.91491468e-02f, 4.89482842e-02f,
  1.89839061e-02f, -1.08475640e-01f, -2.15712711e-02f, 4.82574925e-02f, 2.96988729e-02f, 3.57804634e-02f, -6.82624150e-03f, 4.25253175e-02f, -5.61046340e-02f, -3.88364010e-02f,
  -3.52058969e-02f, -5.38218592e-04f, -2.99628358e-02f, -2.03285343e-03f, 8.60083550e-02f, -7.06790388e-02f, -9.11723450e-03f, -5.11265509e-02f, 2.36313082e-02f, -3.95211652e-02f,
  2.52168588e-02f, -6.67396635e-02f, 6.64309552e-03f, 6.54742792e-02f, 3.33048292e-02f, -3.65503766e-02f, -1.07717887e-02f, -7.44791180e-02f, 6.42607808e-02f, 7.65048247e-03f,
  4.97404307e-01f, -2.04135135e-01f, -4.31751609e-02f, 1.96074083e-01f, 1.76800624e-03f, 1.89211875e-01f, 2.00944066e-01f, -1.28662273e-01f, 2.39540428e-01f, -1.61515102e-01f,
  1.23805732e-01f, 9.39373076e-02f, -4.40248810e-02f, 2.15229124e-01f, 2.69891530e-01f, 1.36420563e-01f, 1.53824568e-01f, 1.50478750e-01f, 9.38263759e-02f, -2.51620635e-02f,
  9.11919028e-02f, 1.14476718e-01f, -3.21393535e-02f, -1.30918220e-01f, -5.05225025e-02f, -1.38608128e-01f, -1.96018755e-01f, -1.09748900e-01f, -9.94194746e-02f, 3.35144880e-03f,
  7.94314127e-03f, -2.23058276e-03f, -5.01535125e-02f, 4.27202471e-02f, -7.79900327e-02f, -8.59272182e-02f, 1.03704222e-02f, 6.40544519e-02f, 8.73242840e-02f, -2.38346085e-02f,
  5.34779280e-02f, 3.40117551e-02f, 8.07113498e-02f, 2.47860067e-02f, 2.78276694e-03f, 3.22702676e-02f, 3.95252705e-02f, 4.20264751e-02f, -4.37581837e-02f, 6.67848885e-02f,
  1.74943171e-02f, -1.66741852e-02f, 5.65577038e-02f, 2.89075822e-02f, 1.17298057e-02f, 3.51827405e-02f, 3.86534184e-02f, -8.81960467e-02f, 3.93091366e-02f, 4.67184037e-02f,
  -3.99691537e-02f, -7.03614205e-03f, 2.47247126e-02f, 3.20836785e-03f, 1.01600230e-01f, 3.17761279e-03f, 2.77825203e-02f, 1.53165888e-02f, 6.44907951e-02f, 9.46529023e-03f,
  4.78281826e-02f, -8.34808976e-04f, 4.51279692e-02f, 3.59610692e-02f, 3.04729231e-02f, 1.27427867e-02f, 6.47344207e-03f, 1.23649277e-02f, 3.54249924e-02f, -3.28698345e-02f,
  -9.91067104e-03f, 2.64794957e-02f, -6.03683330e-02f, -2.86485013e-02f, 5.62186129e-02f, -4.08347137e-02f, -5.07758418e-03f, -5.64658782e-03f, -1.60470456e-02f, 1.11496747e-02f,
  -1.52579248e-02f, -8.97132307e-02f, -7.88950622e-02f, 7.71080703e-03f, 3.41603421e-02f, 3.66963632e-02f, 4.46118154e-02f, -1.70675479e-02f, -2.73917373e-02f, 4.45439182e-02f,
  -8.56700465e-02f, -1.19688874e-02f, -5.90286963e-02f, 8.21551755e-02f, 1.86016187e-02f, 3.71591188e-02f, -5.55878431e-02f, -1.68693755e-02f, -6.58809692e-02f, -5.23579307e-02f,
  -4.84352484e-02f, 1.83736179e-02f, 3.52503471e-02f, 2.63428688e-03f, 3.27551551e-02f, -4.82429639e-02f, -5.35559421e-03f, -2.36505251e-02f, 1.77756641e-02f, -8.41283053e-03f,
  -2.91340619e-01f, -3.84541526e-02f, -2.22446933e-01f, -3.92996967e-01f, 2.08124951e-01f, 1.65078625e-01f, -2.84868091e-01f, 2.20952883e-01f, 7.81727284e-02f, -4.13675420e-02f,
  -1.02530167e-01f, -1.81047231e-01f, -5.52459806e-02f, -2.40497202e-01f, -8.56079832e-02f, -1.67831376e-01f, -1.66627601e-01f, -1.70235246e-01f, 8.83890837e-02f, -7.95853585e-02f,
  -6.25355681e-03f, -5.26339151e-02f, -1.89559609e-01f, 3.54406595e-01f, -4.71764579e-02f, -4.29467997e-03f, 5.37556000e-02f, 1.01868205e-01f, -5.12182340e-02f, 3.35822515e-02f,
  7.84106739e-03f, -1.22084893e-01f, -7.78786978e-03f, 3.02979667e-02f, -5.32195009e-02f, -1.85191371e-02f, -8.26049000e-02f, 5.24517056e-03f, 4.10616817e-03f, -1.35815125e-02f,
  -6.11771904e-02f, 3.12042478e-02f, 8.58664233e-03f, 1.06394783e-01f, 1.40086962e-02f, 2.44120713e-02f, 1.81628868e-03f, 2.32602339e-02f, -1.99971274e-02f, -2.46688314e-02f,
  -3.29631604e-02f, -6.92434385e-02f, -9.08901840e-02f, -3.49183083e-02f, -5.96006624e-02f, -7.90396407e-02f, -4.70804609e-02f, 2.97988262e-02f, -7.83998054e-03f, 1.42981121e-02f,
  -1.05738416e-02f, 2.15955656e-02f, -1.75684541e-02f, 2.66179405e-02f, 5.26471771e-02f, -1.12338178e-02f, -2.41716914e-02f, 2.54066952e-04f, 3.44562940e-02f, -3.08949836e-02f,
  4.79723141e-02f, -4.12026122e-02f, 1.52787818e-02f, -2.08763406e-03f, -6.32961839e-02f, -2.11503375e-02f, -3.58937745e-04f, -1.47859901e-02f, 4.30555344e-02f, 3.82313393e-02f,
  2.65881303e-04f, -3.17852646e-02f, 1.00654270e-02f, -1.28510566e-02f, 3.54957655e-02f, -1.71385594e-02f, -2.01892313e-02f, 5.50468173e-03f, 1.75911542e-02f, 1.26339402e-02f,
  2.05291491e-02f, -2.02646293e-02f, 7.12468326e-02f, 5.58705591e-02f, 2.55361516e-02f, 5.79529665e-02f, -2.33750083e-02f, 6.00661077e-02f, 1.41201410e-02f, 4.18839157e-02f,
  -1.66347772e-02f, -5.03513068e-02f, 5.79997934e-02f, -2.71155927e-02f, -9.04378481e-03f, 4.56693582e-02f, -9.29130688e-02f, -8.89810640e-03f, -7.09728803e-03f, 7.87779987e-02f,
  1.91140976e-02f, -2.98785046e-03f, 8.70959251e-04f, 5.04438356e-02f, 3.62585783e-02f, -7.11538047e-02f, 3.64150703e-02f, -4.24017496e-02f, -3.18512842e-02f, 7.40652829e-02f
};

// L0_fan_Wp_bar (Shape: 14 x 120)
const int L0_fan_Wp_bar_rows = 14;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  3.69660527e-01f, -4.08837557e-01f, -9.32737254e-03f, 2.96015054e-01f, 3.11700493e-01f, 1.38252050e-01f, 4.19409513e-01f, -5.67219108e-02f, 1.88562065e-01f, -3.60297680e-01f,
  -2.73413137e-02f, -6.41686171e-02f, -1.50783509e-01f, 2.13828124e-02f, 3.73579800e-01f, -9.22456309e-02f, 1.50751665e-01f, 1.55972183e-01f, -9.26897582e-03f, 4.76819389e-02f,
  9.73737016e-02f, 1.40295848e-01f, -8.53588805e-02f, -2.28531510e-01f, 1.31067961e-01f, -1.36718050e-01f, -1.42289951e-01f, -1.27846915e-02f, -4.83899005e-02f, 1.69297054e-01f,
  4.07274663e-02f, 5.76960146e-02f, 9.39602703e-02f, -1.79759096e-02f, -4.63444963e-02f, -1.01554573e-01f, -3.92635912e-02f, 2.77723018e-02f, 4.28525284e-02f, -8.19427818e-02f,
  -7.60816932e-02f, -2.25234721e-02f, 2.02805623e-02f, 1.89719535e-02f, 6.88267201e-02f, 1.10851340e-02f, -3.64864059e-02f, -6.87798411e-02f, -7.12382272e-02f, -4.03550267e-02f,
  -1.31271454e-02f, -7.55205080e-02f, 8.33201129e-03f, -1.23490766e-01f, -2.14133933e-02f, 1.04486011e-02f, -4.49210927e-02f, -1.72105469e-02f, -4.78251837e-02f, 2.89924815e-03f,
  -3.71164717e-02f, 2.04151552e-02f, -3.59874852e-02f, 2.39252904e-03f, 5.78396171e-02f, 1.28359012e-02f, 3.78606729e-02f, -1.94715448e-02f, 6.47959560e-02f, 9.81648862e-02f,
  8.85654017e-02f, 4.79892530e-02f, 5.36103658e-02f, 7.82260001e-02f, -2.42443308e-02f, -5.99199068e-03f, -5.21727465e-03f, -9.42073297e-03f, -4.76699062e-02f, -2.82169450e-02f,
  2.78200302e-02f, 4.64098081e-02f, -3.15805189e-02f, -1.12832010e-01f, -4.43684775e-03f, 3.71717736e-02f, -5.58045097e-02f, -1.94960348e-02f, -2.60708109e-02f, 6.93758130e-02f,
  -2.11034250e-02f, -2.06177190e-01f, 2.91514602e-02f, -4.00199890e-02f, -3.28321122e-02f, -9.07407701e-02f, 3.44080850e-02f, 2.81023253e-02f, -1.71570890e-02f, 2.05522720e-02f,
  -7.00044930e-02f, 6.08595926e-03f, -3.42040844e-02f, -1.45987449e-02f, 2.36828476e-02f, -1.04559109e-01f, -8.56610537e-02f, 2.43530367e-02f, 1.68840954e-04f, -8.40970203e-02f,
  -9.97157767e-03f, 5.23550902e-03f, 5.22015393e-02f, -3.48617765e-03f, -6.48461133e-02f, -3.59222703e-02f, -7.22204819e-02f, 1.13142841e-02f, -8.78207013e-02f, 1.21259112e-02f,
  3.63169342e-01f, 6.25365674e-02f, -2.55372584e-01f, 6.74030110e-02f, -1.11891121e-01f, 3.16911608e-01f, 2.77211726e-01f, 1.00490279e-01f, 1.22581333e-01f, 1.94357604e-01f,
  1.55150577e-01f, -8.60975757e-02f, 7.20954835e-02f, 1.38226688e-01f, 5.82292341e-02f, 1.70046166e-01f, 1.59312546e-01f, 7.53624514e-02f, 1.12665161e-01f, 1.53686643e-01f,
  2.71018278e-02f, 2.04174891e-01f, -1.78936452e-01f, 4.95850295e-03f, 1.46384398e-02f, -9.12124515e-02f, -1.49007916e-01f, -1.01828441e-01f, -6.80852309e-02f, -2.87324693e-02f,
  -3.85833494e-02f, -8.29114299e-03f, -9.11449045e-02f, -4.26550992e-02f, -1.37749640e-02f, 6.94619957e-03f, -2.80256290e-02f, 1.55899096e-02f, -1.37610748e-01f, 5.34789115e-02f,
  5.02686836e-02f, -2.26444732e-02f, 8.55342299e-02f, -6.72402838e-03f, 4.91889678e-02f, -7.83742815e-02f, -5.17447032e-02f, -7.36041414e-03f, -5.02806306e-02f, 4.28251810e-02f,
  -4.65544797e-02f, -3.53166685e-02f, -2.21975078e-03f, -1.95486248e-02f, -1.48853287e-01f, -8.01494531e-03f, -5.72956027e-03f, -5.67305721e-02f, 2.35694461e-02f, 6.11597486e-02f,
  4.66163829e-02f, -6.47556782e-03f, 1.05448842e-01f, 2.28509773e-02f, -2.06537303e-02f, -6.71232641e-02f, -6.08593337e-02f, -2.57988423e-02f, 4.30591814e-02f, 6.96521103e-02f,
  -5.38535379e-02f, -3.73787172e-02f, 9.53168720e-02f, 1.02477027e-02f, 9.74902958e-02f, 9.63276997e-02f, 2.79889465e-03f, 1.13567384e-02f, 3.51560675e-02f, -7.93396607e-02f,
  -1.78206377e-02f, 8.80200695e-03f, -2.31575146e-02f, -7.81714022e-02f, -6.18195124e-02f, -1.80127975e-02f, 1.05439119e-01f, 1.85751077e-02f, -7.45832324e-02f, -1.76131930e-02f,
  1.14463836e-01f, 1.99294373e-01f, -6.89897453e-03f, 2.28392817e-02f, -5.85325360e-02f, 9.99896973e-02f, 7.30412379e-02f, 1.17943965e-01f, 1.54630491e-03f, 7.19280243e-02f,
  3.41913961e-02f, 5.51120192e-02f, 5.59675470e-02f, -1.70187093e-02f, -6.04062490e-02f, 2.55326889e-02f, -1.11264205e-02f, -5.58629408e-02f, -3.47474366e-02f, -4.35298570e-02f,
  -8.30531940e-02f, 8.26146230e-02f, 2.28627641e-02f, -5.15405275e-02f, -1.64624341e-02f, -4.07127589e-02f, 8.71083513e-03f, -1.89099871e-02f, -3.55049372e-02f, -7.33621465e-03f,
  -1.18660808e-01f, -2.25372806e-01f, -1.11262135e-01f, -1.29937187e-01f, -2.30134919e-01f, -1.82323918e-01f, -1.42399184e-02f, -2.59931237e-01f, 4.35074829e-02f, 2.08327044e-02f,
  -1.08801223e-01f, 2.81684473e-02f, 2.09458277e-01f, -9.23449248e-02f, 2.81302720e-01f, 3.22277516e-01f, -1.06380053e-01f, 8.84924084e-02f, 4.35369536e-02f, -1.78510278e-01f,
  -1.77474320e-02f, -1.39254898e-01f, 1.20895028e-01f, -3.00990969e-01f, -2.03231037e-01f, -1.38769627e-01f, 1.72714859e-01f, -8.90672505e-02f, -1.79519877e-01f, -1.73840253e-03f,
  -8.11561868e-02f, -1.66851208e-01f, -5.72967865e-02f, -1.23492870e-02f, -9.40865502e-02f, 1.95340980e-02f, 1.09507758e-02f, 6.86663985e-02f, 5.72634046e-04f, -9.63523015e-02f,
  6.94118589e-02f, 3.04585235e-04f, -5.15819974e-02f, 1.45470258e-02f, -4.61486168e-02f, -7.85940364e-02f, -5.45299724e-02f, -1.89959258e-02f, 2.72696046e-03f, -5.23348385e-03f,
  8.49947147e-03f, -5.58703691e-02f, -4.04614136e-02f, 8.08274150e-02f, 9.73912422e-03f, -4.87235039e-02f, 7.80323520e-02f, 2.85227541e-02f, -4.43442687e-02f, -6.91192374e-02f,
  -6.72409385e-02f, 3.36216651e-02f, -2.20841472e-03f, -9.76471417e-03f, -4.82361950e-02f, -2.70988755e-02f, 1.04989810e-02f, 6.63947165e-02f, 5.36025204e-02f, -4.28903252e-02f,
  -3.23199108e-03f, 3.74876149e-02f, -8.40324312e-02f, -6.18842104e-03f, -1.19702267e-02f, 7.01863179e-03f, 1.01472370e-01f, -3.90857309e-02f, 3.59166190e-02f, 1.36220723e-03f,
  4.31432053e-02f, -4.21554260e-02f, 4.62875552e-02f, 5.73017001e-02f, -7.09732398e-02f, 8.33338648e-02f, -5.52474596e-02f, 3.41927120e-03f, 7.67126039e-04f, 9.53822304e-03f,
  -5.51433787e-02f, -2.00904980e-01f, -2.71243323e-02f, -1.04972035e-01f, 2.11223196e-02f, -5.65684400e-02f, -2.52815019e-02f, -5.39180301e-02f, -8.34614635e-02f, -6.13474660e-02f,
  -2.02949867e-02f, 8.53679702e-02f, -2.08828766e-02f, 5.21149905e-03f, 7.11843222e-02f, -3.48007567e-02f, 2.62418017e-02f, -2.60526617e-03f, -1.54519696e-02f, -4.03882265e-02f,
  2.74205282e-02f, 2.93350928e-02f, 8.32180381e-02f, -1.10200336e-02f, 4.84709674e-03f, 4.32404429e-02f, -7.09044784e-02f, -8.40657856e-03f, -2.63555460e-02f, 3.01938411e-02f,
  -1.63869828e-01f, -1.55493945e-01f, 8.60587880e-02f, 2.99247086e-01f, -7.41777429e-03f, -4.74583566e-01f, -4.39262301e-01f, 1.16437510e-01f, -1.02928869e-01f, -8.59770477e-02f,
  -6.71146363e-02f, 2.96648301e-04f, -1.28517523e-01f, 1.26257330e-01f, 3.16984147e-01f, -1.32530689e-01f, 1.94791242e-01f, -2.48162914e-02f, 1.25657842e-01f, 2.16701269e-01f,
  3.09801221e-01f, 1.81375295e-01f, 3.62914145e-01f, 2.48233214e-01f, 3.09147686e-02f, 2.95663565e-01f, 3.69854927e-01f, 2.61051115e-02f, 2.41026402e-01f, -4.86545376e-02f,
  -1.79220796e-01f, 1.14781447e-02f, 2.39328481e-02f, -4.62802313e-02f, 6.42514080e-02f, -1.02922767e-01f, -3.68346311e-02f, 1.87266013e-03f, 6.62127957e-02f, 1.16531905e-02f,
  -4.73231077e-02f, 7.78008550e-02f, 6.20547347e-02f, 2.84529068e-02f, -1.11251675e-01f, 8.17670003e-02f, 2.75238999e-04f, -3.27803358e-03f, -6.19265921e-02f, -4.82685901e-02f,
  -9.39851720e-03f, -1.11915851e-02f, 5.80346398e-02f, 1.85767822e-02f, 6.41971529e-02f, 1.35533847e-02f, 4.94813286e-02f, -7.92007372e-02f, -3.53099816e-02f, 9.00752395e-02f,
  -6.86341524e-02f, -1.48804514e-02f, 1.32337352e-03f, -2.60395911e-02f, -3.98309082e-02f, -7.47002708e-03f, 3.55583169e-02f, -3.16755623e-02f, 2.46589668e-02f, -2.37543713e-02f,
  -6.98352279e-03f, 7.83564076e-02f, 1.17126843e-02f, -3.39631028e-02f, 5.76632284e-02f, 1.29809631e-02f, 4.35233079e-02f, 4.47042510e-02f, 2.03692708e-02f, -3.85149121e-02f,
  5.76291308e-02f, 1.11592943e-02f, -4.77511026e-02f, -5.85699156e-02f, -5.26104607e-02f, 3.59326303e-02f, -1.35795483e-02f, -4.45716679e-02f, 9.83587746e-03f, 3.40041667e-02f,
  -8.10303837e-02f, 2.02736318e-01f, 1.80420559e-02f, -4.75929342e-02f, 4.16949466e-02f, -2.31674593e-02f, 3.84025872e-02f, 3.57206189e-03f, 2.61968076e-02f, 7.99387135e-03f,
  4.00416069e-02f, 7.05878139e-02f, -4.02789982e-03f, 4.30182350e-04f, 5.18881343e-02f, -3.13107600e-03f, 8.00411683e-03f, 2.66386718e-02f, 3.85214463e-02f, 1.07627191e-01f,
  4.61270250e-02f, -8.21401551e-02f, 9.83393490e-02f, -6.13519140e-02f, -1.84335504e-02f, -2.16882061e-02f, 6.49482608e-02f, -1.69688032e-03f, 7.93529823e-02f, 3.58417295e-02f,
  8.23559612e-02f, -6.71485662e-02f, -2.72375375e-01f, -1.57825321e-01f, -6.69227913e-02f, -4.28496063e-01f, -3.85741979e-01f, -7.53016844e-02f, 1.67344570e-01f, 3.30786891e-02f,
  -5.10011204e-02f, 9.10271108e-02f, 9.45421904e-02f, -2.23385677e-01f, -1.12175502e-01f, 2.00125426e-01f, -3.35820824e-01f, -1.26098976e-01f, 6.83668703e-02f, -1.93144038e-01f,
  4.01872694e-02f, -8.25059414e-02f, -1.71675205e-01f, -2.30740919e-03f, -2.40568101e-01f, -3.08994092e-02f, 5.01715876e-02f, -7.82395452e-02f, -2.56615162e-01f, -1.58973753e-01f,
  -1.36943772e-01f, 1.61890939e-01f, -3.72111350e-02f, 2.54799519e-02f, -1.17510311e-01f, -6.92453012e-02f, -1.13548152e-01f, -1.48428297e-02f, 1.05728293e-02f, -1.73836201e-02f,
  -2.59414446e-02f, 1.60849527e-01f, 9.73280333e-03f, 1.54872462e-01f, 2.57945955e-02f, -3.27895284e-02f, 2.69922372e-02f, -7.03935474e-02f, 2.29651630e-02f, -4.65886258e-02f,
  -5.08488975e-02f, 2.41024652e-03f, -7.06634074e-02f, 2.68340781e-02f, -4.32398021e-02f, 1.37265408e-02f, -3.64409797e-02f, -3.78355496e-02f, -6.01087846e-02f, 2.11692024e-02f,
  6.61367029e-02f, 5.18191755e-02f, 1.06021315e-02f, -4.91160527e-03f, -2.64426768e-02f, -6.98110983e-02f, -2.09403541e-02f, 2.45986916e-02f, 1.10547058e-02f, -1.00318799e-02f,
  -6.56791823e-03f, -5.06326258e-02f, 2.67851409e-02f, -4.16443683e-02f, -7.50794122e-03f, 8.54971036e-02f, -1.99006349e-02f, -8.24282039e-03f, -1.13578238e-01f, -3.52603681e-02f,
  1.11031607e-01f, -5.23157194e-02f, 4.83963750e-02f, -5.02273999e-02f, -8.24408531e-02f, -2.11595837e-03f, -1.84633974e-02f, 1.21040400e-02f, -8.16561133e-02f, -1.01260982e-01f,
  -9.77953970e-02f, 4.11983654e-02f, 2.32140925e-02f, 4.23036469e-03f, 4.27567139e-02f, -4.66781594e-02f, 1.67227909e-02f, -5.33481874e-02f, 7.71698123e-03f, -3.96267604e-03f,
  -8.61055776e-03f, -6.74649468e-03f, -1.47462245e-02f, 1.38366334e-02f, -7.75859598e-03f, -1.05553314e-01f, 4.76962291e-02f, 1.10384241e-01f, -6.55390099e-02f, -2.32502930e-02f,
  2.48410031e-02f, 4.14981395e-02f, 5.24328239e-02f, 4.72640991e-03f, 3.33796330e-02f, 4.97971959e-02f, -6.84550926e-02f, 5.05559854e-02f, 1.56458840e-02f, 1.54639613e-02f,
  1.07658796e-01f, -3.95559110e-02f, -2.77694136e-01f, 5.01908250e-02f, 2.77420487e-02f, -8.88671651e-02f, -3.80142748e-01f, 8.27581435e-02f, -1.92415193e-01f, -5.44691607e-02f,
  1.15075499e-01f, -6.99296221e-02f, -1.61566570e-01f, 3.43773663e-01f, 2.21330762e-01f, -7.18131661e-02f, 2.60739714e-01f, 1.87895700e-01f, 3.10131628e-02f, 5.87269925e-02f,
  2.18498558e-01f, 3.74274611e-01f, 9.80865955e-02f, 3.03647578e-01f, 1.51266634e-01f, 1.34008363e-01f, 2.22875655e-01f, -1.24535181e-01f, 2.54661530e-01f, 9.53130648e-02f,
  2.11879667e-02f, 8.01298693e-02f, 2.18386203e-02f, -4.77725044e-02f, 1.07496185e-02f, -7.87206963e-02f, -2.96021998e-02f, 1.00578107e-01f, -1.43084750e-02f, -2.66917553e-02f,
  -3.35142985e-02f, 6.23043217e-02f, 8.33288059e-02f, 1.42241847e-02f, 4.29746620e-02f, -9.01106838e-03f, -4.72509786e-02f, -2.87501421e-02f, -1.00776628e-01f, -3.42282802e-02f,
  -1.19946331e-01f, 1.38388760e-02f, -4.39878702e-02f, -2.00405698e-02f, -1.49772644e-01f, -6.88382462e-02f, -5.69359660e-02f, -6.47644550e-02f, 2.14604009e-03f, 3.06964666e-02f,
  8.71978030e-02f, 6.53291028e-03f, -1.60015393e-02f, 5.11719845e-02f, -5.19229174e-02f, -1.14800222e-01f, 1.09670058e-01f, 6.48096157e-03f, -5.97707741e-03f, -4.85718735e-02f,
  -1.39216073e-02f, 6.09251484e-02f, 2.46454757e-02f, -2.67416704e-02f, 4.44773696e-02f, 1.01653732e-01f, -1.61579195e-02f, -4.71592089e-03f, -9.72106084e-02f, 2.41683554e-02f,
  2.59862337e-02f, 2.01783143e-02f, -1.68976542e-02f, 8.64424855e-02f, 7.17878044e-02f, -1.11163989e-01f, 2.24951655e-02f, -1.01447418e-01f, -1.05517484e-01f, 4.00908198e-03f,
  1.04610339e-01f, 1.13652021e-01f, -3.27603221e-02f, 1.71243437e-02f, -6.64744750e-02f, 2.53399275e-02f, -1.11264205e-02f, 8.21318403e-02f, 4.45681103e-02f, -3.65535356e-02f,
  -4.47326712e-03f, -3.08424304e-03f, 1.71345379e-02f, -2.76420563e-02f, 7.51647353e-02f, -8.86876956e-02f, 7.67902471e-03f, 4.45807092e-02f, -2.50064973e-02f, 1.14032961e-01f,
  -1.31090833e-02f, 1.45496093e-02f, 2.10348666e-02f, -1.20111048e-01f, 7.97878671e-03f, -6.02523535e-02f, 5.73821180e-02f, 1.41339274e-02f, 7.29952604e-02f, -8.71252455e-03f,
  -4.91371095e-01f, 2.19358951e-01f, -1.11936249e-01f, -2.73192972e-01f, 1.26761690e-01f, -2.71992415e-01f, -1.69019833e-01f, 8.18991363e-02f, 1.59491580e-02f, 7.39753172e-02f,
  5.95724303e-03f, 3.13193798e-02f, 1.35066643e-01f, 2.08433699e-02f, -2.91490048e-01f, 6.93522617e-02f, -2.83314615e-01f, -1.36468396e-01f, 4.77189757e-02f, -1.53214365e-01f,
  -9.85911861e-02f, -1.85494944e-02f, -1.25592843e-01f, 1.96354881e-01f, -1.52259134e-03f, -3.19820307e-02f, -1.94631979e-01f, 1.23033643e-01f, -1.00385576e-01f, 1.54659390e-01f,
  -1.74469247e-01f, 6.08445741e-02f, -1.41956419e-01f, -9.87562984e-02f, -2.16761142e-01f, -5.96608296e-02f, -7.98415989e-02f, -3.22836339e-02f, 1.31880892e-02f, -5.98401390e-02f,
  1.61434785e-02f, 4.77898009e-02f, 3.49818878e-02f, 5.98642863e-02f, 1.09712081e-02f, 3.30303982e-02f, 5.32638766e-02f, -1.06890187e-01f, -4.39414792e-02f, 5.89854382e-02f,
  2.32985783e-02f, -1.30711803e-02f, -1.30939856e-01f, -3.79590429e-02f, 8.81435722e-03f, -1.35099143e-02f, -5.04866540e-02f, -4.24884222e-02f, -4.35947180e-02f, -3.55970562e-02f,
  2.71094926e-02f, -1.00936353e-01f, 7.79314106e-03f, -9.14059579e-03f, 7.01017529e-02f, 9.54939350e-02f, 7.28861764e-02f, -1.00140879e-02f, -4.49942946e-02f, -4.40685228e-02f,
  -4.17888574e-02f, 8.10038894e-02f, -3.27306688e-02f, -1.43170282e-01f, 2.45349091e-02f, 6.88091805e-03f, -8.67716298e-02f, -3.92914079e-02f, 5.10965139e-02f, -5.67150712e-02f,
  -2.37140153e-02f, 1.71305817e-02f, 1.04450956e-01f, -2.14592312e-02f, -6.25880202e-03f, -4.65307795e-02f, -9.84570594e-04f, -6.62583262e-02f, -1.06382929e-01f, -6.29175454e-02f,
  -3.62188131e-01f, -1.95366427e-01f, -4.47571315e-02f, 6.46178871e-02f, -1.29527822e-02f, -7.83902109e-02f, -7.27918521e-02f, -7.98821747e-02f, -1.56539589e-01f, -2.40943767e-03f,
  -6.50790855e-02f, -5.58006242e-02f, -9.10839736e-02f, -2.99348831e-02f, 4.05958332e-02f, -7.79155344e-02f, -4.79800925e-02f, -3.44473799e-03f, -1.63791776e-01f, -1.39496578e-02f,
  -1.31982509e-02f, 4.98119816e-02f, 5.77447526e-02f, -3.87622751e-02f, -8.52675214e-02f, -1.03418440e-01f, 1.82118863e-02f, -1.60747636e-02f, -1.03290882e-02f, 5.74986264e-02f,
  1.01374030e-01f, -3.73435616e-01f, 8.77062008e-02f, 3.42583545e-02f, 7.78691843e-02f, 1.20648749e-01f, 2.37144217e-01f, -1.86132059e-01f, -3.55490178e-01f, -2.60863811e-01f,
  4.79992852e-02f, 1.45685211e-01f, -3.86554152e-02f, 3.78684103e-02f, 3.87122273e-01f, -1.07891276e-01f, -7.21650273e-02f, 1.57216176e-01f, -7.57508799e-02f, 3.51108462e-02f,
  3.48182097e-02f, 9.78876874e-02f, 1.31145760e-01f, -9.32907034e-03f, 1.44540668e-01f, -3.40475142e-02f, 2.21095383e-02f, 9.62299854e-02f, 1.31036088e-01f, 2.58143067e-01f,
  3.27377990e-02f, -1.21679999e-01f, 1.03844190e-03f, 2.05749013e-02f, -1.17706597e-01f, 5.94055057e-02f, 1.28675684e-01f, 1.65312082e-01f, 9.60276201e-02f, 2.71115042e-02f,
  3.73240933e-02f, 4.66347709e-02f, -4.19710837e-02f, 3.02070081e-02f, -9.92049575e-02f, -6.73110262e-02f, -2.17588805e-02f, -6.76096678e-02f, -5.16820550e-02f, 1.94072947e-02f,
  -6.96574971e-02f, -1.85537862e-03f, -7.94061795e-02f, 5.28043956e-02f, -4.56762016e-02f, -9.22142938e-02f, 4.19696905e-02f, 4.14090492e-02f, 1.19793341e-02f, 1.67537984e-02f,
  -2.09490228e-02f, 2.13083364e-02f, -4.11364250e-02f, -5.14037274e-02f, -2.84453146e-02f, -4.34090532e-02f, -4.76807505e-02f, -2.92423330e-02f, 4.82047684e-02f, -2.98238639e-02f,
  -4.28994074e-02f, 1.22805284e-02f, -3.57640535e-02f, -3.17976512e-02f, -1.62389409e-02f, -3.76437493e-02f, 5.34330532e-02f, 8.15012679e-02f, -5.77062517e-02f, 2.04556324e-02f,
  3.17495991e-03f, 4.60672677e-02f, -3.36048827e-02f, 4.26081009e-02f, -4.31166124e-03f, 4.17844281e-02f, 1.97436456e-02f, -4.27659322e-03f, -2.84693390e-02f, 8.84078741e-02f,
  -4.45569754e-02f, -2.37655833e-01f, -4.51767966e-02f, 3.03880479e-02f, 1.49328308e-02f, 1.29445386e-03f, 9.22868494e-03f, -3.83368731e-02f, -3.11555415e-02f, -5.51134758e-02f,
  2.13201959e-02f, 5.24244979e-02f, -7.85638094e-02f, 4.03413475e-02f, 6.15757033e-02f, -1.40560642e-01f, 1.45852445e-02f, 1.79044958e-02f, 5.05779423e-02f, -3.45468558e-02f,
  -1.18995802e-02f, -4.82132360e-02f, 5.18128313e-02f, -2.50122864e-02f, -1.65179297e-02f, 4.70080599e-02f, -7.81877786e-02f, -1.07595734e-02f, 4.50845584e-02f, 1.11447349e-02f,
  8.12533021e-01f, 1.81820437e-01f, 3.28815490e-01f, 5.12293696e-01f, 4.87823449e-02f, -3.20873767e-01f, -6.22018278e-02f, 1.58841714e-01f, 4.06263202e-01f, -1.06062993e-01f,
  -7.14095980e-02f, 1.92371503e-01f, -2.68212467e-01f, 2.17620865e-01f, -2.98855543e-01f, -3.26950461e-01f, 9.34525207e-02f, 6.84626028e-03f, 9.03181955e-02f, 1.15668915e-01f,
  2.00992286e-01f, -2.16345876e-01f, 8.72422829e-02f, -1.72507867e-01f, 3.51360679e-01f, 2.59043634e-01f, -1.42609835e-01f, -2.38214523e-01f, 8.32741782e-02f, -2.13017687e-01f,
  2.40062270e-02f, 1.56591788e-01f, 1.83997259e-01f, -2.04295926e-02f, 4.83555906e-02f, 3.61354351e-02f, -1.87167805e-02f, -1.05734691e-01f, 4.40384708e-02f, -3.33051831e-02f,
  -6.56594802e-03f, -2.33513825e-02f, 8.62079710e-02f, -6.06935211e-02f, 9.91216451e-02f, 1.00797556e-01f, 1.06161758e-01f, 2.00460181e-01f, 8.71455893e-02f, 9.46422517e-02f,
  9.37981978e-02f, 1.63663641e-01f, 7.74850696e-02f, -1.55489640e-02f, 8.98179486e-02f, 9.84983891e-02f, 3.52850109e-02f, -3.74051705e-02f, 4.09610942e-02f, 1.04699902e-01f,
  -9.01994854e-02f, -4.45439555e-02f, -1.69397164e-02f, 7.67718256e-02f, -2.61816885e-02f, 5.09738028e-02f, -2.02557184e-02f, -6.99443594e-02f, 7.53540138e-04f, -3.89998630e-02f,
  2.83965059e-02f, 9.75106731e-02f, -1.17416633e-02f, 8.10896531e-02f, 4.21468318e-02f, 1.30986065e-01f, -5.58406860e-02f, 1.12804035e-02f, 1.08976178e-01f, 7.03748614e-02f,
  -5.79362409e-03f, -2.62366273e-02f, -9.90584213e-03f, 2.67286822e-02f, -9.12848562e-02f, -4.56819981e-02f, 5.08978590e-02f, 1.00019924e-01f, 2.30428744e-02f, -7.87634030e-02f,
  -3.23346764e-01f, -3.47845703e-01f, -1.54598504e-02f, -3.74347274e-03f, -5.74152768e-02f, 1.07128536e-02f, -1.34207681e-02f, 1.06145076e-01f, -1.10784359e-01f, -1.71054192e-02f,
  5.49737504e-03f, 2.02586763e-02f, -4.11904156e-02f, 1.51322372e-02f, -5.47041222e-02f, -2.88826153e-02f, 9.83969681e-03f, -5.77543974e-02f, -4.97430190e-02f, -3.71482074e-02f,
  3.67549807e-02f, -1.39664799e-01f, 6.63124258e-03f, 1.15156785e-01f, 3.62029485e-02f, -3.52000333e-02f, 3.72389099e-03f, 3.24078687e-02f, -8.21422338e-02f, -6.61573112e-02f,
  -9.32047904e-01f, 1.77157581e-01f, 1.68084770e-01f, -1.10889696e-01f, -2.09264264e-01f, 1.44787744e-01f, 2.21271962e-01f, -7.73385912e-02f, -1.12081327e-01f, 2.77052164e-01f,
  2.67729372e-01f, -2.83746034e-01f, 2.50972658e-01f, 2.49765202e-01f, -1.96096405e-01f, 2.85664737e-01f, 1.03193179e-01f, 9.61359777e-03f, 5.28681129e-02f, -1.46910608e-01f,
  -8.04854631e-02f, 1.34361893e-01f, 2.30106771e-01f, 4.51844633e-02f, -3.70131657e-02f, -7.45187998e-02f, -4.08172496e-02f, 1.50370732e-01f, -2.84217112e-02f, -5.05921058e-02f,
  -1.99799702e-01f, -2.74470210e-01f, -4.42592502e-02f, -5.93315698e-02f, -7.71583840e-02f, -3.41126919e-02f, -6.98857382e-02f, 2.14924123e-02f, -8.55758712e-02f, 3.05187795e-03f,
  -9.79161263e-02f, -5.34397662e-02f, -2.94645801e-02f, -4.00351360e-02f, -1.45431668e-01f, -3.26638110e-02f, 4.19718809e-02f, 8.09471495e-03f, 9.22182724e-02f, 5.88730862e-03f,
  1.31696865e-01f, 5.13442904e-02f, 6.17376119e-02f, 6.24777935e-02f, -2.30596587e-02f, 6.55021071e-02f, 4.49624993e-02f, -4.33355756e-02f, -3.45894508e-02f, -7.38723353e-02f,
  -8.67801718e-03f, 1.36212828e-02f, 5.34950309e-02f, -3.83287072e-02f, 1.09590413e-02f, 3.80618647e-02f, 4.68777958e-03f, -6.49056137e-02f, 4.25841808e-02f, 5.72540201e-02f,
  -7.87938237e-02f, -5.16867824e-02f, -7.92602971e-02f, 2.52033677e-02f, -1.72041617e-02f, 3.73591785e-04f, 8.32375791e-03f, -4.36066464e-02f, 1.68649387e-03f, -1.87189749e-03f,
  -3.08303768e-03f, -5.31715760e-03f, 1.10118724e-02f, 1.41805466e-02f, -3.43526676e-02f, 2.87180431e-02f, -4.31244671e-02f, 3.78132276e-02f, 5.10099716e-02f, -6.79170862e-02f,
  -4.42930251e-01f, -3.53111953e-01f, -1.69429481e-02f, -1.27075016e-01f, 4.45529539e-03f, -3.98010910e-02f, 3.30745168e-02f, -2.98875235e-02f, -9.90463346e-02f, -8.56643245e-02f,
  -4.36264873e-02f, 1.35012278e-02f, -2.72898898e-02f, 1.25271299e-05f, 1.87034309e-02f, 5.28517514e-02f, -1.23627763e-02f, -5.67269996e-02f, -8.53566527e-02f, -5.85227348e-02f,
  6.67115394e-03f, -2.68804692e-02f, 3.91609594e-02f, 6.51907176e-02f, -1.84546635e-02f, -1.74186248e-02f, -1.42587885e-01f, 3.76815274e-02f, -9.84807834e-02f, 3.03477887e-02f,
  -1.83182865e-01f, 3.77760679e-01f, -3.60059232e-01f, 1.70076773e-01f, -8.74433890e-02f, 3.67949814e-01f, 3.88706267e-01f, 1.29000936e-02f, 1.27879366e-01f, 3.41749668e-01f,
  2.30808705e-01f, 6.68509975e-02f, 1.70529902e-01f, 4.78803486e-01f, -2.00024396e-02f, 3.17081362e-01f, 2.66847372e-01f, 2.53237754e-01f, -8.75298865e-03f, 1.00163072e-01f,
  -5.51330894e-02f, 3.14893663e-01f, -1.65875051e-02f, -6.28308281e-02f, 7.37219378e-02f, -2.31167197e-01f, -2.22285166e-02f, -1.94720238e-01f, 1.31885275e-01f, 5.69188930e-02f,
  1.04875363e-01f, 1.47281801e-02f, -9.92990360e-02f, -6.98817745e-02f, -5.85846752e-02f, -6.32239878e-02f, 1.11587625e-02f, -9.59879830e-02f, -5.23135737e-02f, 4.83643453e-05f,
  6.23511209e-04f, -4.85684164e-02f, 4.36453074e-02f, -7.74075976e-03f, -3.36396322e-03f, -8.27895477e-02f, 6.12868275e-03f, -5.61365671e-03f, 3.63380350e-02f, 2.03609839e-02f,
  -7.93588441e-03f, -2.30338126e-02f, 6.45547500e-03f, 6.71657771e-02f, -5.70618808e-02f, 7.31736124e-02f, 6.86205551e-02f, -1.74521562e-02f, -9.71587375e-03f, 2.10406333e-02f,
  4.14713845e-02f, 4.10150513e-02f, -1.21640861e-02f, -3.95133346e-02f, -7.25064799e-02f, -2.97490545e-02f, 3.10366061e-02f, 1.74156502e-02f, -6.68611601e-02f, 7.34046176e-02f,
  1.19905183e-02f, 1.71722788e-02f, 2.62412559e-02f, 2.80072000e-02f, 6.63055852e-02f, -1.32676698e-02f, -5.80237657e-02f, -1.64787285e-02f, -1.89534165e-02f, 1.88088827e-02f,
  -3.50087732e-02f, 2.62812208e-02f, -1.53359463e-02f, 8.51659849e-03f, 7.18946457e-02f, -3.76635492e-02f, 5.60937151e-02f, 1.29181091e-02f, 6.44426942e-02f, -3.78722027e-02f,
  1.93948418e-01f, 1.78434297e-01f, 4.10299748e-02f, 2.58894898e-02f, 4.55359183e-03f, -5.50033487e-02f, -4.95621469e-04f, -9.68874712e-03f, 2.51916759e-02f, 5.26877977e-02f,
  -7.98414201e-02f, 1.36800101e-02f, 6.69317227e-03f, 1.09585673e-02f, -6.86450452e-02f, 5.56306913e-02f, 3.43158320e-02f, 6.19286671e-03f, 4.82495030e-04f, -6.28563762e-02f,
  9.47921816e-03f, -3.62665057e-02f, -2.86279470e-02f, -4.89825718e-02f, 5.30429520e-02f, 9.92889982e-04f, 4.31680353e-03f, -9.91002098e-02f, -5.01723588e-02f, 2.14678328e-02f,
  -1.71847805e-01f, 2.70220697e-01f, -9.77593437e-02f, -2.63498072e-03f, 1.18970098e-02f, -3.24896067e-01f, -1.66496515e-01f, 3.13565508e-02f, -8.01204145e-02f, 3.62025023e-01f,
  7.22280964e-02f, 1.92197815e-01f, -1.01255752e-01f, -1.45296037e-01f, -6.55160069e-01f, -3.53059679e-01f, -2.60897130e-01f, 5.18955551e-02f, -1.16006233e-01f, 5.98287880e-02f,
  -1.37938276e-01f, -1.31873026e-01f, -2.64354199e-01f, 8.76505002e-02f, 1.26838148e-01f, 2.47789592e-01f, -6.31245226e-02f, 1.31991297e-01f, 9.50409546e-02f, -5.60111329e-02f,
  -4.02219174e-03f, 1.86294496e-01f, 1.02550909e-01f, -3.38365845e-02f, -5.02427556e-02f, 7.85007849e-02f, 2.99189426e-02f, 4.49494785e-03f, -6.40688613e-02f, 8.26894864e-03f,
  7.24949464e-02f, 6.51280489e-03f, 3.81664969e-02f, 2.40680706e-02f, 8.39807764e-02f, 5.26635237e-02f, 1.16446139e-02f, 6.65672347e-02f, 1.23129398e-01f, 2.04821955e-02f,
  -2.90148519e-02f, -1.57181490e-02f, 1.24884946e-02f, -2.94910278e-02f, -4.33358662e-02f, 8.15617573e-03f, -3.32723074e-02f, 5.64526673e-03f, 7.27168769e-02f, -5.09779043e-02f,
  -3.91256064e-02f, -3.74994539e-02f, -4.09423374e-02f, 5.24240732e-02f, -2.03703977e-02f, -3.79111543e-02f, 3.46848629e-02f, 2.33161841e-02f, 4.43628021e-02f, 3.53485085e-02f,
  3.81454229e-02f, 6.80396631e-02f, 8.42890963e-02f, 8.97340011e-03f, -5.83801093e-03f, 2.64238622e-02f, -5.82764037e-02f, 6.60742298e-02f, -5.75543977e-02f, 2.71962639e-02f,
  2.89477296e-02f, -2.81318873e-02f, 4.35447842e-02f, 3.60555239e-02f, -8.02635849e-02f, -3.21633630e-02f, 8.17767978e-02f, -8.40542912e-02f, -2.30657822e-03f, 3.26481573e-02f,
  -2.14273743e-02f, 4.34013158e-02f, 1.07818574e-01f, 7.09467828e-02f, 1.42089259e-02f, 4.46601771e-02f, -6.39475435e-02f, -6.97553810e-03f, -5.54022305e-02f, -3.99590693e-02f,
  1.85538512e-02f, 3.72891575e-02f, 1.46804797e-02f, 3.26335505e-02f, -4.71180119e-02f, -6.11970313e-02f, -1.77402198e-02f, 3.20501104e-02f, 1.31227134e-04f, 5.91402799e-02f,
  1.10792369e-01f, 6.59899712e-02f, 1.08070252e-02f, -5.24602830e-03f, 7.35809514e-03f, 4.07190557e-04f, 2.23863050e-02f, 4.91733998e-02f, 1.01483241e-02f, -3.00537292e-02f,
  -8.40367600e-02f, -1.19712844e-01f, 2.30230447e-02f, -3.55277300e-01f, -1.58837028e-02f, -3.22843753e-02f, -1.75685629e-01f, -9.30917338e-02f, -5.68216145e-02f, -2.52640367e-01f,
  -2.18398422e-01f, -1.39221633e-02f, 1.72982544e-01f, -2.06347272e-01f, 2.63584942e-01f, 1.83909535e-01f, -1.66230172e-01f, -1.07874721e-01f, 6.48550987e-02f, -1.80949226e-01f,
  -4.31421474e-02f, -2.31260493e-01f, 1.00533836e-01f, -1.75301775e-01f, -2.35043272e-01f, -1.39280289e-01f, 3.19946595e-02f, -8.54323804e-02f, -1.50604174e-01f, -6.53226897e-02f,
  8.38723704e-02f, -1.02509841e-01f, 9.04454663e-02f, 7.88414106e-02f, 9.84833296e-03f, 2.69980542e-02f, 4.53257114e-02f, 1.84042528e-02f, -5.29156663e-02f, -1.04915136e-02f,
  -1.03523908e-02f, 7.00981244e-02f, -7.01986849e-02f, -3.61957960e-02f, -9.04217064e-02f, -1.96976028e-02f, 1.28197540e-02f, 3.75901274e-02f, 5.07688038e-02f, 5.83712347e-02f,
  1.55064082e-02f, 7.31750578e-02f, -5.39416075e-02f, -4.09444943e-02f, -3.36666889e-02f, -7.13459104e-02f, 8.31821784e-02f, 6.93753287e-02f, -4.34503332e-02f, -5.32301962e-02f,
  -9.12687704e-02f, 1.12992479e-02f, 1.08004063e-02f, 6.61315769e-02f, 4.87504937e-02f, 2.10473835e-02f, -5.22520654e-02f, 4.45376560e-02f, -7.11355731e-02f, -7.11531471e-03f,
  2.65538543e-02f, -1.76606420e-02f, -3.94714624e-02f, -7.60428899e-04f, -4.28624153e-02f, 5.26721077e-03f, 9.18508768e-02f, -9.93193965e-03f, 1.83703341e-02f, 1.69433486e-02f,
  1.70861073e-02f, 6.77156076e-03f, -3.87196392e-02f, -3.81772146e-02f, 6.95463419e-02f, 4.29808684e-02f, 4.76364195e-02f, -3.77059332e-05f, -5.16614951e-02f, 4.95452143e-04f,
  6.15103394e-02f, -1.35977119e-01f, -4.47465666e-02f, 3.87064032e-02f, 5.78843020e-02f, 3.67100909e-02f, 2.04969905e-02f, -6.91732988e-02f, -2.85703912e-02f, -7.99893588e-02f,
  -8.02347511e-02f, -2.91341357e-02f, -5.48730232e-02f, -5.02974242e-02f, 4.81859595e-03f, 3.86968665e-02f, -3.45133021e-02f, 9.65109037e-04f, 4.18964401e-02f, 6.39291555e-02f,
  1.86208505e-02f, -5.37238196e-02f, 8.95434525e-03f, -5.84300235e-02f, -4.40971069e-02f, -4.79697920e-02f, 1.09255798e-02f, 7.95535743e-02f, -7.55245015e-02f, -2.73053870e-02f,
  1.78443462e-01f, -3.00505459e-01f, -2.80313641e-01f, -2.00406626e-01f, 1.61596522e-01f, 2.01181367e-01f, -1.46366060e-01f, -1.16509870e-01f, -3.02711219e-01f, -2.66586971e-02f,
  -6.29281905e-03f, -3.11926991e-01f, -3.63348514e-01f, -2.15502739e-01f, -1.23337157e-01f, -3.77785623e-01f, 1.00354224e-01f, -2.17182152e-02f, -1.40071779e-01f, 4.26409878e-02f,
  -3.99597101e-02f, 1.89838633e-01f, -1.81259453e-01f, 2.51005739e-01f, 1.40373692e-01f, 1.54386878e-01f, 3.03862870e-01f, -1.38647966e-02f, 1.91788048e-01f, 9.46619734e-02f,
  -7.36206770e-02f, -1.69610456e-01f, -1.11394130e-01f, -9.72101872e-04f, 7.31158778e-02f, 8.36968198e-02f, 8.37356523e-02f, -7.81652033e-02f, 4.19123936e-03f, -9.34469774e-02f,
  3.04498412e-02f, -4.60270047e-02f, 6.37026562e-04f, -3.30725610e-02f, 7.85768181e-02f, 3.70311365e-02f, -5.50953448e-02f, -7.80753233e-03f, -1.98240086e-01f, -1.06017478e-01f,
  -1.63169309e-01f, -6.46792650e-02f, 5.78478910e-02f, -9.27375164e-03f, -2.85868570e-02f, 2.91019212e-02f, 3.51359919e-02f, -6.71712831e-02f, 1.10725276e-01f, -1.54998545e-02f,
  3.76519710e-02f, 1.02597207e-01f, 1.95268597e-02f, 5.86130144e-03f, -3.04136537e-02f, 5.37780076e-02f, 9.22815651e-02f, -5.02245650e-02f, -2.35547218e-02f, -8.52471963e-02f,
  4.19000313e-02f, -6.20643422e-02f, 1.96201564e-03f, 5.42790964e-02f, 5.57098724e-02f, 1.37697365e-02f, 5.44366166e-02f, -4.65103518e-03f, -7.44502693e-02f, -8.61990005e-02f,
  -8.72012880e-03f, 1.03244796e-01f, -7.57520199e-02f, 7.73360729e-02f, 2.62441617e-02f, -4.35776934e-02f, 5.27891628e-02f, 1.14950119e-03f, 1.95920542e-02f, -1.00798784e-02f,
  3.46609615e-02f, 5.47880419e-02f, -1.07066579e-01f, 3.30539793e-02f, 4.17852635e-03f, 6.08094037e-02f, -4.38980535e-02f, -8.66313092e-03f, -6.98856660e-04f, 8.97940435e-03f,
  8.45002159e-02f, 6.42637163e-02f, 2.05892742e-01f, 4.41246778e-02f, 1.18387312e-01f, 7.41202757e-02f, 5.53294756e-02f, 5.30115366e-02f, 9.26149040e-02f, 2.09726617e-02f,
  9.80294943e-02f, 5.58775216e-02f, 2.32791174e-02f, 1.42770326e-02f, 7.43217617e-02f, 1.08068742e-01f, 9.48585346e-02f, 7.17703402e-02f, 2.57352814e-02f, -5.49936853e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 14)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 14;
const float L0_fan_Bp_bar_data[] = {
  3.05968821e-01f, 2.47285441e-01f, 2.25435868e-01f, 7.18008056e-02f, 1.72825664e-01f, 1.82497665e-01f, 1.47452340e-01f, 1.62581787e-01f, 3.63289773e-01f, 1.87132433e-01f,
  9.05010700e-02f, 2.40568817e-01f, 1.89035386e-01f, 2.20151111e-01f
};

// L1_fan_Wp (Shape: 25 x 64)
const int L1_fan_Wp_rows = 25;
const int L1_fan_Wp_cols = 64;
const float L1_fan_Wp_data[] = {
  -2.70398916e-04f, 9.20280535e-03f, 3.97398807e-02f, -5.92998415e-03f, -1.65103436e-01f, 1.13819219e-01f, 3.53441387e-02f, 6.63390309e-02f, 1.20585538e-01f, -1.75697461e-01f,
  8.01061392e-02f, -5.69007695e-02f, 1.31724015e-01f, 1.06375545e-01f, -1.12189814e-01f, 1.03677372e-02f, 7.25673288e-02f, 4.70672883e-02f, 1.34368569e-01f, 3.41674201e-02f,
  1.59165949e-01f, -8.41623694e-02f, 7.68197179e-02f, -7.73444623e-02f, 1.15143359e-02f, -9.54877585e-02f, -1.56751752e-01f, -2.52431005e-01f, -1.74793806e-02f, -1.70271978e-01f,
  -1.48283988e-01f, -1.05244152e-01f, 1.86125055e-01f, -4.66402099e-02f, 1.49648041e-01f, 4.19682749e-02f, -1.31728798e-01f, -2.02075597e-02f, 1.03504844e-01f, -1.65591165e-02f,
  -6.95124120e-02f, -7.97191262e-02f, -3.27262608e-03f, 9.21748430e-02f, -4.65748198e-02f, -1.79430962e-01f, -3.51265376e-03f, -1.16336733e-01f, 1.16740942e-01f, -5.82608730e-02f,
  -2.60887165e-02f, 2.33643323e-01f, -1.27407551e-01f, -2.33121485e-01f, -4.94468724e-03f, -1.97022781e-01f, -1.40377313e-01f, -1.98415488e-01f, 7.78825954e-02f, -1.31023034e-01f,
  2.39307418e-01f, 1.33700613e-02f, -1.82447836e-01f, 3.92325036e-02f, -1.45639554e-01f, 2.92793419e-02f, -9.61843692e-03f, -2.54320092e-02f, -5.34450673e-02f, -4.04663980e-02f,
  9.61569473e-02f, 6.10658862e-02f, 1.15276694e-01f, -1.21051386e-01f, 4.51093987e-02f, -7.64064118e-02f, 7.05258176e-02f, 2.15813760e-02f, -7.16182515e-02f, 4.56974991e-02f,
  -4.99201305e-02f, 3.70409787e-02f, 7.59894922e-02f, 4.39259363e-03f, 1.26888603e-01f, -1.72978744e-01f, 2.40225308e-02f, 4.98008765e-02f, 3.67391109e-02f, -1.63425878e-01f,
  -1.02711432e-01f, -1.76255003e-01f, -1.17085546e-01f, -1.38544440e-01f, -1.08288236e-01f, 1.31611330e-02f, 1.98526204e-01f, 5.11310548e-02f, -9.59180892e-02f, 1.25272661e-01f,
  -1.01246372e-01f, -4.10271809e-03f, 6.79365993e-02f, -8.33908916e-02f, -4.81376471e-03f, 1.01054288e-01f, -2.63714530e-02f, 1.36738062e-01f, -1.53275505e-02f, -9.05659795e-02f,
  -7.41865933e-02f, 7.25634098e-02f, 1.52796954e-01f, 8.39275569e-02f, -9.57486928e-02f, 1.63635746e-01f, -5.23879454e-02f, -1.09124854e-01f, -5.63536733e-02f, 7.24959150e-02f,
  -2.39582121e-01f, -6.73928484e-02f, -2.14155063e-01f, -8.37208480e-02f, 2.82392412e-01f, -1.79573908e-01f, -8.87250900e-02f, 2.05571890e-01f, 8.44348818e-02f, 4.48178276e-02f,
  3.72274891e-02f, -1.18899874e-01f, -5.42026199e-02f, 9.83105674e-02f, -3.98294888e-02f, -1.05538843e-02f, 2.48908680e-02f, -6.25484274e-04f, -5.10336794e-02f, 6.44951835e-02f,
  -1.49956224e-02f, -8.55722502e-02f, -1.07175149e-02f, -2.52754148e-02f, 5.97357526e-02f, 2.13088673e-02f, -8.18014070e-02f, -9.44867432e-02f, 9.29933134e-03f, 1.07261740e-01f,
  -1.21208124e-01f, -1.63158104e-01f, -3.51275876e-02f, 1.20103523e-01f, 6.84360601e-03f, 1.69335842e-01f, -8.41338411e-02f, 1.57010123e-01f, 2.24747714e-02f, 1.06018931e-02f,
  -5.93366735e-02f, -5.34512214e-02f, -1.03675025e-02f, 1.75429247e-02f, -7.15104118e-02f, 8.36876556e-02f, 8.81239399e-02f, 1.22138634e-01f, -1.18911870e-01f, -8.19504261e-02f,
  7.39159733e-02f, -1.46080926e-01f, -1.12770945e-01f, -8.07255879e-02f, 4.45204377e-02f, -4.66193855e-02f, -2.03621596e-01f, 6.54686838e-02f, -5.51415458e-02f, -1.37350202e-01f,
  -2.12730885e-01f, 9.88789126e-02f, 5.07270955e-02f, 1.08790267e-02f, 1.63337305e-01f, -9.90278125e-02f, 3.05574715e-01f, -8.82647336e-02f, -2.84778088e-01f, 1.83703542e-01f,
  -1.28995299e-01f, -1.08777642e-01f, -2.10057110e-01f, -1.90106535e-03f, -1.08124791e-02f, -1.99215606e-01f, -1.07509643e-01f, -1.18252859e-01f, 1.06276602e-01f, 4.70481701e-02f,
  5.32959700e-02f, -8.32324550e-02f, -1.90452896e-02f, -2.34712511e-02f, 1.32189086e-02f, 5.06910533e-02f, -2.97392998e-02f, 9.83218551e-02f, -3.81535664e-02f, -2.53591817e-02f,
  1.83854252e-02f, -1.05353817e-01f, 8.97907913e-02f, -1.48628568e-02f, -1.45931356e-02f, -9.90809575e-02f, -9.56325904e-02f, -5.65330423e-02f, -5.57223968e-02f, -5.86449318e-02f,
  -4.66997847e-02f, -5.34602813e-02f, -5.91761880e-02f, 1.41360953e-01f, -1.83571987e-02f, 1.34039566e-01f, -4.21307459e-02f, 1.09312885e-01f, -1.46957263e-01f, -6.14107028e-02f,
  -6.85389116e-02f, -1.16926223e-01f, 7.87598938e-02f, -2.11036764e-02f, 1.65889040e-01f, 1.08312540e-01f, -2.18817711e-01f, -1.25945747e-01f, 1.41905531e-01f, -8.53349045e-02f,
  -2.87705753e-02f, 1.82531606e-02f, 1.30447909e-01f, 2.01691657e-01f, -2.39034891e-02f, 1.10587157e-01f, 1.63006410e-01f, 2.40689386e-02f, -1.73479930e-01f, -1.61223322e-01f,
  2.57060200e-01f, -2.85666049e-01f, 9.22528803e-02f, -2.31515154e-01f, -2.05846783e-02f, 8.70096833e-02f, -1.26490489e-01f, -1.89629272e-02f, 3.52535732e-02f, 2.29000375e-02f,
  -9.04754773e-02f, -1.22891240e-01f, 3.35933012e-03f, 6.26178458e-02f, 6.74173310e-02f, -1.17037207e-01f, -2.73698792e-02f, -6.54462874e-02f, 1.17664352e-01f, 1.44788129e-02f,
  -1.98616218e-02f, -2.83722393e-02f, -2.62111258e-02f, 3.99364382e-02f, 8.64925012e-02f, 3.70714590e-02f, 1.38878688e-01f, -1.23124272e-01f, 7.69784525e-02f, 3.83448862e-02f,
  3.21353115e-02f, -5.08491881e-02f, -1.53998196e-01f, -2.64883846e-01f, -1.33837238e-01f, -6.58012480e-02f, -6.99085668e-02f, -2.09427588e-02f, 2.57780612e-01f, 1.29483137e-02f,
  -1.02187499e-01f, 6.47514835e-02f, -8.90624225e-02f, -5.18933497e-02f, 6.60519153e-02f, -1.74483389e-01f, -1.61188897e-02f, 1.17546499e-01f, 1.26343267e-02f, 1.63133189e-01f,
  3.15430127e-02f, -1.17666885e-01f, -2.07502767e-02f, 6.82388097e-02f, 1.33171767e-01f, -3.45628038e-02f, -1.21351592e-01f, 2.06631556e-01f, 5.56689799e-02f, -8.74079764e-02f,
  -8.73342063e-03f, -3.53813283e-02f, -2.43941411e-01f, -1.14155181e-01f, -1.33724496e-01f, -2.65474874e-03f, 2.96677679e-01f, -6.78816512e-02f, -8.33792612e-02f, 1.77187622e-01f,
  1.06101289e-01f, 1.66450255e-02f, 7.62309274e-03f, 2.41496246e-02f, -6.42161518e-02f, 2.38917470e-01f, -2.73792334e-02f, -1.74254086e-02f, 1.32776294e-02f, -1.02732042e-02f,
  3.51341814e-02f, 7.24694654e-02f, 1.28507048e-01f, 3.80847119e-02f, -8.65577459e-02f, 1.59199871e-02f, 9.47122574e-02f, 5.34023270e-02f, -2.69586332e-02f, -6.28807321e-02f,
  9.86730903e-02f, -8.84558484e-02f, -6.38249740e-02f, 4.96962406e-02f, 6.03100099e-02f, -9.87705514e-02f, -1.47845358e-01f, 1.40122930e-02f, 1.92668796e-01f, -1.74958985e-02f,
  1.05047040e-02f, -2.00918317e-01f, 1.81751116e-03f, -1.87980682e-01f, 3.02010387e-01f, 1.89229827e-02f, -8.88294950e-02f, 2.15813845e-01f, 1.38667598e-01f, 1.67539313e-01f,
  -1.90413460e-01f, -1.44216567e-01f, -4.20505367e-02f, -2.45151892e-02f, 7.91200921e-02f, -1.39251605e-01f, -9.13892314e-02f, 2.50930563e-02f, -1.04873754e-01f, 3.39356139e-02f,
  -6.90769851e-02f, 3.18962261e-02f, -9.38546360e-02f, 5.27214929e-02f, 1.82199180e-01f, -1.61381409e-01f, 1.80464819e-01f, -1.96526423e-01f, 2.10206345e-01f, -7.92956427e-02f,
  -9.15260836e-02f, -1.60816871e-02f, 1.31174671e-02f, -2.37261981e-01f, -1.24636903e-01f, -7.98593909e-02f, -3.64000648e-02f, 4.15214188e-02f, 4.01951559e-02f, -2.13600606e-01f,
  9.50689428e-04f, -3.03391251e-03f, -9.01977196e-02f, 3.86267863e-02f, -8.14163759e-02f, -1.22706853e-01f, -6.52673990e-02f, 1.03524644e-02f, 8.21673200e-02f, -9.97554734e-02f,
  -1.63351268e-01f, -5.85410483e-02f, -1.31710991e-01f, -2.15089582e-02f, -1.56543050e-02f, -4.83907722e-02f, 8.13277625e-03f, 9.62627493e-03f, 5.03033772e-03f, -4.97566462e-02f,
  1.39424829e-02f, -1.06987946e-01f, -1.26380354e-01f, 7.06963427e-03f, 5.21496721e-02f, 1.55430496e-01f, -1.17004625e-02f, 6.14679744e-03f, -1.19609810e-01f, 5.15768193e-02f,
  9.55786090e-03f, 2.26379689e-02f, -5.09742983e-02f, -2.11284071e-01f, 8.54563043e-02f, 9.32176262e-02f, 9.66000333e-02f, 1.14217736e-01f, 1.08464815e-01f, 6.84458539e-02f,
  1.24393456e-01f, 1.31227389e-01f, 2.06335053e-01f, -1.19773500e-01f, 6.25380501e-02f, 3.26458439e-02f, 9.44339335e-02f, 1.18147470e-01f, 1.32680804e-01f, 1.42324924e-01f,
  5.61630987e-02f, 1.70429438e-01f, -3.41318697e-01f, -2.00367365e-02f, 1.56987622e-01f, -1.45038739e-01f, 5.35012037e-02f, 2.38783453e-02f, -3.36343795e-02f, -9.58017781e-02f,
  -2.12389417e-03f, 5.10366298e-02f, -5.98485246e-02f, -1.60872623e-01f, -9.04110000e-02f, 2.87124030e-02f, -5.37436604e-02f, 6.66906685e-03f, -6.80056438e-02f, -1.43922761e-01f,
  4.37719859e-02f, 7.90034384e-02f, 1.06500976e-01f, 1.10696629e-02f, -1.06692716e-01f, -9.22199618e-03f, -2.94157024e-02f, 9.09125656e-02f, 3.65160815e-02f, -4.07726243e-02f,
  1.31013274e-01f, 1.26277640e-01f, 3.57594006e-02f, -7.59775043e-02f, -8.81836638e-02f, -2.44751140e-01f, -1.46544985e-02f, -1.17389552e-01f, 5.99633008e-02f, -4.96866331e-02f,
  1.04518048e-01f, -1.70947313e-01f, 9.38747004e-02f, 8.63144323e-02f, -3.44596393e-02f, 1.16086960e-01f, 1.61703661e-01f, -2.06428111e-01f, 3.97613235e-02f, -3.60924043e-02f,
  4.54475209e-02f, 9.06739384e-02f, 1.48331359e-01f, -7.70252151e-03f, 1.63541123e-01f, 1.00667909e-01f, 2.93896556e-01f, -2.89236367e-01f, 5.68434186e-02f, 7.02234283e-02f,
  1.82646111e-01f, 6.30480200e-02f, 2.08368704e-01f, 1.01267667e-02f, -8.30032527e-02f, 1.19572796e-01f, -2.86208600e-01f, -1.44066900e-01f, 1.24350384e-01f, -8.87426585e-02f,
  -9.82328132e-03f, -1.27247185e-01f, -6.19428270e-02f, 1.33605264e-02f, 3.17925634e-03f, -1.11013584e-01f, 4.00646441e-02f, -1.66922793e-01f, 1.24275371e-01f, -2.23105531e-02f,
  1.43120468e-01f, -2.67491788e-02f, -7.54643977e-02f, -1.41428271e-02f, -1.58034489e-01f, -1.56659093e-02f, -3.91864404e-02f, 1.97737291e-02f, -4.22325023e-02f, -5.25975525e-02f,
  -3.01528554e-02f, -1.69568747e-01f, 2.44016070e-02f, 2.31293077e-03f, -5.55192567e-02f, -5.57768792e-02f, 1.40375271e-02f, -1.67536750e-01f, 2.30080355e-02f, 2.48372238e-02f,
  6.78457273e-03f, -1.35760620e-01f, -6.39115423e-02f, -6.31886825e-04f, -5.04170172e-02f, 1.86316237e-01f, -4.58190255e-02f, 8.99319872e-02f, 1.51247755e-01f, -1.81267217e-01f,
  -1.60649955e-01f, -1.39770895e-01f, 1.55852169e-01f, 7.40382820e-02f, 1.32869661e-01f, 1.35666147e-01f, -1.54606640e-01f, 5.21182306e-02f, -1.03763975e-01f, -5.26060425e-02f,
  7.28275403e-02f, -6.02457635e-02f, 2.00861067e-01f, 6.67105764e-02f, 2.13533491e-02f, 1.67652667e-01f, -1.67438954e-01f, 1.54397205e-01f, -2.92844862e-01f, -1.13068474e-02f,
  1.83015585e-01f, -7.45550245e-02f, 1.64745539e-01f, -2.52387226e-01f, -6.64442778e-02f, 1.74839556e-01f, 1.15379870e-01f, 5.81965931e-02f, 1.70719847e-02f, -1.92789882e-02f,
  -1.05687223e-01f, 1.62506834e-01f, 1.11809345e-02f, -7.75585249e-02f, 2.94429362e-02f, -5.70067577e-02f, 9.32978988e-02f, 1.12191960e-01f, 2.46241260e-02f, 7.91639537e-02f,
  -2.60497313e-02f, 1.39298998e-02f, 2.29037870e-02f, 2.24117730e-02f, 6.79735467e-02f, 1.91108733e-02f, 1.14410687e-02f, 2.20708121e-02f, -6.05001114e-03f, 7.71898404e-03f,
  4.62900996e-02f, -1.20676756e-01f, -7.21794516e-02f, 8.07461366e-02f, 1.47869587e-01f, -1.64040819e-01f, 5.83392158e-02f, -2.34905735e-01f, -6.89733028e-02f, 1.36040244e-02f,
  2.13490725e-01f, 8.56372640e-02f, 3.44742648e-02f, 5.07220700e-02f, 3.68604660e-02f, 1.59059644e-01f, 3.35250199e-02f, -1.24393165e-01f, -9.49834213e-02f, -7.41273463e-02f,
  -7.40320608e-02f, -4.25121710e-02f, -9.36236640e-04f, -1.82911992e-01f, 1.66842818e-01f, -7.06812367e-02f, 1.13503255e-01f, 3.85277979e-02f, -2.37509049e-02f, -2.28075057e-01f,
  -5.46351299e-02f, -1.98366299e-01f, -8.61580148e-02f, -7.31023774e-02f, 2.76449621e-01f, -1.90201610e-01f, -1.56399235e-01f, -1.59345418e-01f, -3.92956808e-02f, -1.63377970e-01f,
  -6.45877346e-02f, -5.25887050e-02f, -1.46578588e-02f, -6.39121234e-02f, -1.52854264e-01f, 8.08751956e-02f, -3.59552866e-03f, -5.62259369e-03f, -2.10240316e-02f, -1.18436530e-01f,
  -5.01708826e-03f, -5.36987893e-02f, 7.50437900e-02f, 4.52437773e-02f, -8.82995799e-02f, 5.35053648e-02f, -6.68320898e-03f, 6.98586553e-02f, 9.95752662e-02f, 3.55389155e-02f,
  4.80277017e-02f, -1.33137092e-01f, 3.00518237e-02f, -1.37297571e-01f, -6.53927699e-02f, 5.88459373e-02f, -3.67708579e-02f, -1.72627628e-01f, -6.61990419e-03f, 1.08954152e-02f,
  -1.08877763e-01f, 1.00421652e-01f, 3.68606225e-02f, -1.28850222e-01f, 6.80888668e-02f, -1.06978804e-01f, -1.78147450e-01f, 6.38174191e-02f, 8.93911794e-02f, 1.14252716e-01f,
  -1.18863232e-01f, -1.59385696e-01f, 3.45458388e-02f, 2.94867605e-02f, 4.17263657e-02f, -1.23472154e-01f, 6.59038126e-02f, -5.26385829e-02f, -6.95872819e-03f, 1.68582752e-01f,
  -1.24904476e-01f, 8.29940364e-02f, -5.44473063e-03f, -1.68917194e-01f, 1.50103539e-01f, -1.97834834e-01f, 1.47096589e-01f, -2.66454428e-01f, -5.16525805e-02f, -1.07322641e-01f,
  5.26013747e-02f, 5.77760674e-02f, -1.03214912e-01f, -6.91108927e-02f, 1.01234518e-01f, -7.32677355e-02f, -2.92920824e-02f, 3.64538729e-02f, 1.73139665e-02f, 9.86739546e-02f,
  -1.19423099e-01f, -5.03045619e-02f, -1.44158497e-01f, 8.61770809e-02f, 1.17212459e-02f, 3.61480154e-02f, 8.01787153e-02f, 2.31495872e-02f, 8.05508867e-02f, -1.70639390e-03f,
  -2.75832750e-02f, -1.28953569e-02f, -4.78307419e-02f, 8.13335255e-02f, -2.96582114e-02f, -9.89696085e-02f, -5.13265803e-02f, -2.15203539e-02f, -3.99449915e-02f, 1.58032909e-01f,
  7.77413994e-02f, 2.98057273e-02f, -2.65287589e-02f, 1.43857911e-01f, 2.37904061e-02f, 6.50897920e-02f, 1.01810228e-02f, -1.89860612e-01f, 8.29072669e-02f, -1.45761997e-01f,
  -1.26276135e-01f, 1.34023041e-01f, 8.77128616e-02f, 8.57719481e-02f, -1.90669864e-01f, -4.61763777e-02f, -7.77518377e-02f, -1.61683947e-01f, 1.44604206e-01f, -4.78866957e-02f,
  6.67827204e-02f, 1.06663302e-01f, -1.11307226e-01f, 8.81322548e-02f, -2.77099013e-01f, -1.45521715e-01f, 3.43206339e-02f, 2.24435888e-02f, 1.58327863e-01f, -1.62502527e-01f,
  2.11042821e-01f, 2.78726011e-03f, -3.08485746e-01f, 3.25986147e-02f, -1.99495673e-01f, 1.99015349e-01f, 8.53208154e-02f, -1.40771642e-01f, 1.54936478e-01f, 7.38140494e-02f,
  5.41571863e-02f, -6.98905364e-02f, -2.58387346e-02f, 2.45100006e-01f, -2.90927049e-02f, 9.25901160e-02f, 7.98485279e-02f, 3.35019976e-02f, 8.69882181e-02f, 1.60802945e-01f,
  1.62680164e-01f, 1.70607008e-02f, -6.38509616e-02f, 2.49959063e-02f, 1.99212641e-01f, 1.44800059e-02f, 1.24346793e-01f, -9.43416506e-02f, 1.14216946e-01f, 3.42083164e-02f,
  4.90808450e-02f, -8.88307169e-02f, -4.23523113e-02f, 4.94172275e-02f, -1.49006933e-01f, -8.08624644e-03f, 1.07142003e-02f, 2.85648219e-02f, -3.77366580e-02f, -1.65409401e-01f,
  1.18482500e-01f, -1.03763752e-01f, 2.92860359e-01f, 4.97125275e-02f, -4.59604785e-02f, 1.24960564e-01f, 1.25824884e-01f, 1.10050753e-01f, -1.52439862e-01f, -1.03436895e-01f,
  -2.29311269e-02f, -3.60934203e-03f, -1.03955492e-02f, -1.29459307e-01f, -8.15548468e-03f, -6.25457615e-02f, -1.85997203e-01f, -2.68520205e-03f, -1.10549685e-02f, 1.02590345e-01f,
  -1.86288908e-01f, 8.32016841e-02f, -1.22579187e-02f, -1.02482311e-01f, 6.34437948e-02f, -2.11838931e-01f, 4.22470361e-01f, -4.16028313e-02f, -1.30509853e-01f, 2.32102230e-01f,
  -1.11061372e-01f, -1.33612603e-01f, -1.68198571e-02f, 1.44437561e-02f, 1.44238572e-03f, 1.32598802e-01f, 1.44257592e-02f, -5.33661172e-02f, 2.04241555e-02f, -1.15798684e-02f,
  -4.18058857e-02f, -3.89625952e-02f, -1.58459451e-02f, -3.13246846e-02f, -6.94182739e-02f, -8.57252069e-03f, -9.94554013e-02f, -4.92368378e-02f, 6.34592399e-02f, -4.57310155e-02f,
  -2.79163606e-02f, -1.91824837e-03f, -1.03750050e-01f, -1.24596944e-02f, 4.93981875e-03f, 8.36328268e-02f, 6.15324639e-02f, -1.16176844e-01f, 2.11928058e-02f, 6.78261369e-02f,
  1.29836768e-01f, -4.65207361e-02f, -6.74263239e-02f, -7.78245181e-02f, -2.89534945e-02f, 1.08375028e-01f, -7.19031021e-02f, -5.72523922e-02f, 1.52860492e-01f, -1.06815271e-01f,
  -1.75293952e-01f, 6.81325374e-03f, 1.19457878e-01f, 1.27198502e-01f, -1.64987996e-01f, 5.46890795e-02f, 6.68870807e-02f, 1.52068883e-01f, -2.23368838e-01f, 1.38646755e-02f,
  1.29534360e-02f, -1.02254916e-02f, 8.22113976e-02f, -1.19581111e-02f, 6.06380552e-02f, -1.77489653e-01f, -2.10859358e-01f, 4.30026017e-02f, -1.37614980e-02f, 7.47467354e-02f,
  -1.30340606e-01f, 2.26277992e-01f, 6.53275326e-02f, -1.71950698e-01f, 1.13579914e-01f, 6.59739459e-03f, 3.35970633e-02f, 1.41689256e-01f, -3.53557942e-03f, -7.59944767e-02f,
  7.77792232e-03f, 1.26913294e-01f, 1.04640186e-01f, 1.28135337e-02f, 2.53739059e-02f, 7.77266733e-03f, 1.21550560e-01f, 1.44156739e-01f, -1.39967471e-01f, 1.95383164e-03f,
  -2.55954210e-02f, 1.12961419e-01f, -1.31301591e-02f, 5.03766059e-04f, -5.36336005e-02f, -1.88658953e-01f, -1.00110240e-01f, 4.54172604e-02f, -9.57541540e-02f, -5.76702729e-02f,
  -3.60528678e-02f, -6.08854853e-02f, 1.54977590e-01f, 1.64147854e-01f, 1.45863041e-01f, -3.70090529e-02f, 2.45600101e-02f, 6.25740290e-02f, -1.67434454e-01f, 1.55797929e-01f,
  5.27165681e-02f, 1.26296729e-01f, 1.22382073e-02f, -3.21023054e-02f, -1.08703688e-01f, 1.00998871e-01f, 4.06502793e-03f, -1.50456242e-02f, 7.97346830e-02f, -1.45755289e-02f,
  -1.37070000e-01f, 3.85039300e-02f, -1.42031342e-01f, -7.86825567e-02f, -8.04246310e-03f, 1.98562160e-01f, 2.03262776e-01f, -1.12770788e-01f, -8.61101970e-02f, 2.09403396e-01f,
  -1.78710401e-01f, 1.09546691e-01f, -8.65727514e-02f, 4.33727652e-02f, -6.59353063e-02f, -4.01087068e-02f, -1.26333922e-01f, -2.51143605e-01f, 7.14051202e-02f, 8.05796981e-02f,
  1.45799831e-01f, 7.11118504e-02f, -5.79470843e-02f, -3.81959528e-02f, -8.75659578e-04f, 8.22987482e-02f, 3.04269101e-02f, -7.61398906e-03f, -8.65887664e-03f, 2.32882090e-02f,
  6.06907457e-02f, 6.97976127e-02f, -1.20725140e-01f, -4.81030047e-02f, -1.50722144e-02f, -5.77258617e-02f, 5.43352924e-02f, -2.80418620e-02f, -3.29946391e-02f, -1.28020927e-01f,
  -8.99038538e-02f, 1.47897467e-01f, -5.72235063e-02f, -1.08165005e-02f, -1.34187043e-02f, -2.36921292e-02f, 9.90740657e-02f, 2.75879890e-01f, 1.61443889e-01f, 5.35055809e-02f,
  2.66487859e-02f, -7.13446587e-02f, -1.37646988e-01f, 1.32874563e-01f, 1.19889095e-01f, 9.08121932e-03f, 1.57311916e-01f, -3.57611030e-02f, -8.87171626e-02f, 1.39985189e-01f,
  4.20576446e-02f, -2.14670766e-02f, -1.70026498e-03f, -1.51304424e-01f, -6.27059117e-02f, 8.23930278e-02f, -8.76461267e-02f, -5.38178720e-02f, -1.32612199e-01f, 2.60705967e-02f,
  5.90241812e-02f, -1.71359539e-01f, -1.26417547e-01f, 1.50067657e-01f, -2.28442326e-01f, 1.45548973e-02f, -7.14722797e-02f, 6.29355386e-02f, 2.74663538e-01f, 9.04242843e-02f,
  -2.51583457e-01f, -5.17557524e-02f, 1.56917628e-02f, -5.75912222e-02f, -1.05494648e-01f, -1.00934491e-01f, 2.62448676e-02f, 1.50773495e-01f, -2.53824852e-02f, -7.01008365e-02f,
  4.15822342e-02f, 6.76936880e-02f, -9.24966261e-02f, -5.34288026e-02f, -6.42501339e-02f, -1.29263595e-01f, 1.07044116e-01f, 7.37519115e-02f, -3.58791798e-02f, -9.94394571e-02f,
  2.50117984e-02f, -4.42515984e-02f, -5.74612466e-04f, 1.03107996e-01f, 6.72158450e-02f, -1.41874790e-01f, 5.26146032e-02f, 2.41777599e-02f, -2.71521751e-02f, -2.47588530e-02f,
  -3.70722003e-02f, -2.18969285e-01f, -1.23449281e-01f, 2.79098004e-02f, -5.05995564e-02f, 8.42334256e-02f, 1.04082815e-01f, -8.74403417e-02f, -7.21245259e-02f, -8.05987567e-02f,
  -9.70024467e-02f, 3.43273655e-02f, -4.16238420e-02f, -6.31538182e-02f, 2.60323789e-02f, 3.29969153e-02f, -1.14246145e-01f, 9.44622308e-02f, 1.99348316e-01f, -3.69047150e-02f,
  -1.13494238e-02f, 5.79619221e-02f, 3.92476059e-02f, 1.90145280e-02f, -1.14914387e-01f, 1.31122753e-01f, 6.44907355e-02f, -2.34549850e-01f, 8.58632922e-02f, -5.28503098e-02f,
  1.54838532e-01f, -4.44442686e-03f, -3.95936996e-01f, 2.12780476e-01f, 2.32125312e-01f, 2.56922692e-02f, 5.57937101e-02f, -1.86485462e-02f, 1.42757773e-01f, -2.61262320e-02f,
  4.69246693e-02f, 7.94104636e-02f, -8.92350674e-02f, 9.50691663e-03f, -1.36857359e-02f, 5.07382639e-02f, 1.34022115e-02f, 5.03634010e-03f, 1.88513696e-02f, 7.92775303e-03f,
  1.42723918e-01f, -4.52190042e-02f, -8.79005492e-02f, -3.84865887e-02f, 1.30950913e-01f, -7.50355702e-03f, 1.01719059e-01f, 9.01665241e-02f, 4.64853691e-03f, -7.15992674e-02f,
  7.36031383e-02f, 1.08601965e-01f, 7.36991242e-02f, -8.25486779e-02f, -1.52093858e-01f, -1.28198355e-01f, 2.19875704e-02f, -1.92796960e-02f, -3.08676232e-02f, -2.35156924e-01f,
  2.16751486e-01f, -1.08987749e-01f, 1.54095754e-01f, -3.37518491e-02f, 8.29810500e-02f, 5.47960065e-02f, 8.76680017e-02f, -3.47938798e-02f, -4.73017767e-02f, -1.27234673e-02f,
  -1.52470946e-01f, 2.07576379e-02f, 1.17054038e-01f, -2.93578953e-02f, -9.46474969e-02f, 1.82815120e-02f, 6.18624836e-02f, -2.29751632e-01f, -1.25704825e-01f, 6.85219392e-02f,
  2.29060017e-02f, -1.94797382e-01f, -8.24475437e-02f, -1.29671946e-01f, -1.14612564e-01f, -1.39388353e-01f, 4.02105786e-02f, 1.32414117e-01f, 2.08560035e-01f, 9.01705213e-03f,
  1.29053909e-02f, -1.47276431e-01f, 1.64440617e-01f, -1.30650457e-02f, 9.96105932e-03f, 1.07396767e-01f, 1.06121659e-01f, 2.05737259e-02f, -1.01759367e-01f, -4.96468768e-02f,
  -1.49637029e-01f, 8.40395167e-02f, -6.93890825e-03f, 6.43267184e-02f, 6.09963723e-02f, 2.94117089e-02f, 1.19875669e-01f, -1.11328356e-01f, 1.06263921e-01f, -3.15007716e-02f,
  2.33918913e-02f, 1.83337212e-01f, -6.51899725e-02f, 4.54004295e-02f, 9.73010287e-02f, 2.62179933e-02f, 1.02327326e-02f, 2.15416074e-01f, 6.29860833e-02f, 3.40213776e-02f,
  5.27357869e-02f, 1.18762866e-01f, 1.09358072e-01f, -8.65915716e-02f, -3.28419618e-02f, -9.14731026e-02f, 1.84259377e-02f, -1.99891374e-01f, 1.11255996e-01f, 1.83284190e-02f,
  8.09876621e-02f, 5.25235385e-02f, 3.26988928e-04f, -2.52901651e-02f, -1.39052227e-01f, -1.73262239e-01f, 1.26142070e-01f, 1.02200978e-01f, 1.43786976e-02f, 1.46532347e-02f,
  -3.05707157e-02f, -4.09964100e-02f, -1.22227162e-01f, -2.13942438e-01f, 1.14358291e-01f, -1.51138425e-01f, -6.15202636e-03f, -1.39255002e-01f, 2.03732997e-01f, 9.93954614e-02f,
  -1.28657192e-01f, 3.14413607e-01f, -1.34506121e-01f, 2.93745726e-01f, 7.51128718e-02f, -1.12469673e-01f, -1.25585869e-02f, -5.34798093e-02f, 1.27549991e-02f, 9.41041559e-02f,
  -3.30447555e-02f, 3.80351581e-02f, -4.22380343e-02f, 9.66854841e-02f, -1.09277787e-02f, -1.58483442e-02f, 9.64127947e-03f, -3.84306684e-02f, 8.95700678e-02f, -2.37745419e-02f,
  1.61606763e-02f, -8.16401318e-02f, 9.14438739e-02f, -3.51930670e-02f, 7.23295510e-02f, 8.31668526e-02f, 1.56005055e-01f, -2.47709695e-02f, 9.22817886e-02f, 3.22619267e-02f,
  5.41368462e-02f, 7.50514539e-03f, -1.77884325e-01f, -2.04368129e-01f, -1.65475979e-01f, 9.91544053e-02f, -4.66141887e-02f, -7.56243169e-02f, 2.31435776e-01f, -1.67926669e-01f,
  3.14021483e-02f, 3.60403731e-02f, -4.65338910e-03f, 9.63844508e-02f, 1.69468194e-01f, -1.13119163e-01f, -1.44363910e-01f, 8.52820799e-02f, -1.14022724e-01f, -2.54651196e-02f,
  1.10059530e-01f, -1.24380603e-01f, 2.00784057e-02f, 6.73071742e-02f, -6.73202276e-02f, -1.44772843e-01f, -1.62945613e-01f, 1.48137301e-01f, -1.23706058e-01f, -8.71404260e-02f,
  2.03831643e-02f, -5.16423658e-02f, 6.83107823e-02f, -5.71475849e-02f, -3.30477487e-03f, 1.59145996e-01f, 2.54694372e-01f, 2.03362003e-01f, -7.74796307e-02f, -2.53224447e-02f,
  2.25637201e-03f, 1.17463872e-01f, -2.12534405e-02f, -5.91440946e-02f, 1.13825791e-01f, 9.74385217e-02f, -6.18874375e-03f, -3.20236111e-04f, -1.20703783e-03f, 1.17220715e-01f,
  1.16732240e-01f, 1.16526239e-01f, -3.25677693e-02f, -9.18041170e-02f, 7.41043091e-02f, 9.51092765e-02f, -5.30211590e-02f, 1.27516948e-02f, -1.76234871e-01f, -2.39932761e-02f,
  -2.78721731e-02f, -4.82882708e-02f, -7.13207051e-02f, 1.12350009e-01f, 5.37106767e-03f, 3.80205996e-02f, 1.07843578e-01f, 1.47006840e-01f, 6.34352956e-03f, 4.75338567e-03f,
  1.49780557e-01f, -9.44666564e-03f, -5.73495552e-02f, 4.17363569e-02f, -1.87757034e-02f, 1.45892233e-01f, 4.47399057e-02f, 1.31507680e-01f, 1.05363600e-01f, 1.22183189e-01f,
  -6.43645972e-03f, 5.23800515e-02f, -3.89632545e-02f, -1.84140712e-01f, 2.50876583e-02f, -5.52622136e-03f, -7.89180920e-02f, 1.15483716e-01f, 2.05739252e-02f, 1.81165606e-01f,
  -1.32023752e-01f, -1.74580157e-01f, 3.15373316e-02f, 2.55586177e-01f, -5.23468666e-02f, 1.85211360e-01f, -2.08786335e-02f, 2.39882261e-01f, -3.65033060e-01f, -5.78912087e-02f,
  -1.53780431e-01f, -1.21085040e-01f, 1.49541527e-01f, 2.20601540e-03f, 1.24383681e-01f, 6.22768104e-02f, 8.28504562e-03f, -8.51027369e-02f, -8.26822668e-02f, 1.36328295e-01f,
  -4.93805707e-02f, -6.23509586e-02f, -1.44010335e-02f, -4.24230359e-02f, 3.05719115e-02f, -2.05276776e-02f, -4.41757217e-02f, 8.36907849e-02f, 2.81385742e-02f, 3.44209820e-02f,
  -4.22377028e-02f, -6.14462011e-02f, -5.07368818e-02f, -7.51148760e-02f, -7.74940029e-02f, -3.66982371e-02f, -3.93300392e-02f, -7.23457038e-02f, -8.56343955e-02f, 5.84183633e-02f,
  1.19729884e-01f, 3.31835039e-02f, 5.60914502e-02f, 3.68385650e-02f, 1.18280150e-01f, 3.98114249e-02f, -5.96799366e-02f, -6.00636788e-02f, 1.95772603e-01f, -2.07760297e-02f,
  -9.27364379e-02f, 7.80326650e-02f, 4.13299538e-02f, 9.93691385e-02f, -1.24948390e-01f, -2.14499891e-01f, 6.04331046e-02f, -6.25668690e-02f, 3.64994146e-02f, -2.22201869e-02f,
  1.13841914e-01f, -1.18791245e-01f, -1.22684613e-02f, 2.30615605e-02f, 1.25423655e-01f, -1.09902300e-01f, 6.68988377e-02f, 2.03792676e-01f, 1.48254931e-01f, -7.27091730e-02f,
  1.42147347e-01f, 8.90175626e-02f, -8.61490965e-02f, -1.25283673e-01f, -2.82636553e-01f, 1.44099183e-02f, 6.46521151e-02f, -9.08985808e-02f, -1.54594660e-01f, 2.11922801e-03f,
  -2.46986132e-02f, -8.38969201e-02f, -6.83560222e-02f, -9.92237702e-02f, 5.38685098e-02f, -3.41817103e-02f, 3.25951949e-02f, 5.53893186e-02f, -1.30049929e-01f, -6.14814535e-02f,
  -8.66871774e-02f, 1.53723489e-02f, -2.41012722e-02f, -8.56448989e-03f, -1.31767496e-01f, -5.44465752e-03f, -4.35583554e-02f, -9.42452922e-02f, -5.21208011e-02f, -7.72799328e-02f,
  -1.16969109e-01f, -3.24565023e-02f, -8.29748809e-02f, -8.71150643e-02f, 1.28136547e-02f, -6.80647511e-03f, -5.37194312e-02f, -7.30658844e-02f, -9.33489949e-02f, 1.67592928e-01f,
  -4.09684256e-02f, -1.54935373e-02f, -4.85372245e-02f, -1.54987079e-04f, -5.27202487e-02f, 1.75390132e-02f, -5.66534363e-02f, -7.98985437e-02f, 3.37810516e-02f, 1.60984024e-02f,
  1.83178917e-01f, 1.80090472e-01f, -5.10811917e-02f, 5.04573360e-02f, 4.90924381e-02f, 1.25824586e-01f, 3.86621915e-02f, 6.14457875e-02f, 1.13259040e-01f, 1.99180879e-02f,
  1.09856077e-01f, 1.95751905e-01f, 1.39184251e-01f, 1.78546965e-01f, 1.03792930e-02f, -4.87367958e-02f, -5.64153604e-02f, -2.15950876e-01f, 5.73758669e-02f, -2.06762269e-01f,
  2.84113083e-02f, 3.33740674e-02f, -4.12055440e-02f, -4.64450270e-02f, -2.05700342e-02f, -1.08102843e-01f, 5.03370631e-03f, -1.11786790e-01f, 1.04723526e-02f, -1.02506846e-01f,
  -2.50177737e-02f, 3.98215689e-02f, -1.23154417e-01f, 5.03671654e-02f, -1.16409168e-01f, -2.37832796e-02f, -3.25576290e-02f, 5.88220768e-02f, -1.15705125e-01f, -1.65008400e-02f,
  -1.53872907e-01f, -1.36787921e-01f, -1.14808567e-01f, -2.66342610e-03f, -1.42275557e-01f, -1.09585347e-02f, -8.21694508e-02f, -3.00647095e-02f, 3.10425255e-02f, 1.56727627e-01f,
  6.29408881e-02f, -3.63990525e-03f, 6.59815893e-02f, 6.87232912e-02f, -1.94439754e-01f, 3.35911140e-02f, -8.33956059e-03f, 1.82649400e-02f, -1.29030747e-02f, -3.57693657e-02f,
  -1.35888115e-01f, -1.22700213e-02f, 8.73570517e-02f, -6.55514095e-03f, 1.74002528e-01f, 7.41957128e-02f, -1.57280475e-01f, 4.97239716e-02f, 2.32242756e-02f, 6.29071444e-02f,
  -4.33232300e-02f, 2.43480653e-02f, 7.49854818e-02f, -7.70115405e-02f, 1.05625466e-02f, 2.57437259e-01f, 1.28567144e-01f, 8.76063630e-02f, -6.27514394e-03f, -1.76131297e-02f,
  2.15654224e-01f, -1.99246794e-01f, -1.71152219e-01f, -1.99800164e-01f, 6.05574921e-02f, -7.06785545e-02f, -2.03837268e-02f, 5.10301907e-03f, -5.12646772e-02f, 1.66398361e-02f,
  7.66522735e-02f, 5.09234425e-03f, -3.26648541e-02f, -3.51148807e-02f, -8.17664042e-02f, 1.17983274e-01f, -1.12466894e-01f, 2.65109260e-02f, -5.15366420e-02f, -4.97302078e-02f,
  1.67812780e-02f, 1.03795193e-02f, -9.18665603e-02f, -2.67581968e-03f, -1.80554807e-01f, -1.48327172e-01f, -3.07805873e-02f, -7.35815391e-02f, -1.97348371e-01f, 3.41115296e-02f,
  -4.72380556e-02f, 4.60522957e-02f, 4.85715941e-02f, 1.59744009e-01f, -3.18475254e-03f, 1.89798415e-01f, 3.10542639e-02f, 1.59271196e-01f, -1.09603517e-01f, -6.63653612e-02f,
  1.22021781e-02f, -5.00758663e-02f, -9.28186327e-02f, 1.27623335e-01f, -9.32875872e-02f, 5.59518933e-02f, -4.63404804e-02f, -1.57135888e-03f, 3.91087160e-02f, -4.09077096e-04f,
  1.18160658e-01f, -1.10020144e-02f, -6.90477863e-02f, 1.41962364e-01f, -1.71181872e-01f, 1.66263565e-01f, -2.32092202e-01f, -1.21904425e-01f, 3.74891758e-02f, 2.38534883e-01f,
  1.53277323e-01f, 1.45038262e-01f, 2.10261375e-01f, -1.42821576e-03f, -2.65127659e-01f, 1.10983998e-01f, -1.40065148e-01f, -6.83403993e-03f, 1.28522560e-01f, -1.80493623e-01f
};

// L1_fan_Wp_bar (Shape: 14 x 64)
const int L1_fan_Wp_bar_rows = 14;
const int L1_fan_Wp_bar_cols = 64;
const float L1_fan_Wp_bar_data[] = {
  1.44465774e-01f, -9.93219167e-02f, 4.52064164e-02f, 2.33576626e-01f, 1.01114698e-01f, -1.35942817e-01f, 3.89152691e-02f, 2.19429880e-02f, -2.56651789e-01f, 2.01240882e-01f,
  -1.14343017e-01f, -1.81877315e-01f, 4.02531810e-02f, 2.04074323e-01f, 2.10740477e-01f, -1.26306891e-01f, 2.21539307e-02f, 4.53109816e-02f, 6.93830922e-02f, 2.00517878e-01f,
  -1.73632339e-01f, 1.31209239e-01f, 1.95885614e-01f, -4.05897247e-03f, -5.38221002e-02f, 2.48806849e-01f, 1.84181482e-01f, -1.22612953e-01f, -2.07314007e-02f, 1.96545273e-01f,
  1.43377140e-01f, 1.15822949e-01f, -1.06243484e-01f, -1.44437551e-01f, -2.24042684e-02f, -3.99602324e-01f, 1.57955274e-01f, -3.73814479e-02f, -1.28094614e-01f, -2.46245399e-01f,
  2.87080854e-01f, -4.72257324e-02f, -1.10091120e-01f, -3.28576788e-02f, 3.45047325e-01f, 2.88376004e-01f, 2.82174289e-01f, -5.57379089e-02f, 1.03758119e-01f, -4.04545277e-01f,
  1.94054753e-01f, -8.66744388e-03f, 4.28952128e-01f, -1.93762839e-01f, 4.56746310e-01f, -1.33954599e-01f, 3.68475586e-01f, 3.61919969e-01f, -4.17152822e-01f, 5.05100071e-01f,
  1.41135171e-01f, 2.42203772e-01f, 2.64426678e-01f, -2.92469740e-01f, 6.68083578e-02f, -2.02705082e-03f, 2.13099316e-01f, 1.31775871e-01f, -1.03020072e-02f, 1.35698497e-01f,
  1.42495427e-02f, 9.75870788e-02f, -2.59443782e-02f, 1.40187308e-01f, 3.10076121e-02f, -6.58482984e-02f, 1.41604394e-01f, 5.87667190e-02f, 2.09475473e-01f, 7.55783021e-02f,
  4.34918180e-02f, 1.39798924e-01f, 2.16028206e-02f, 2.34884128e-01f, 1.80887654e-01f, 1.29029065e-01f, 1.51274800e-01f, -6.33272752e-02f, 2.27059424e-02f, 3.09635401e-01f,
  -2.19333500e-01f, -1.92326546e-01f, -3.18134934e-01f, 1.70153797e-01f, 1.71382993e-01f, 5.58183528e-02f, 2.51281857e-01f, -4.08695817e-01f, 6.12419210e-02f, 5.78661598e-02f,
  -1.47186786e-01f, 2.25435480e-01f, 2.97244549e-01f, -2.24354044e-01f, -2.45377183e-01f, -9.11912695e-02f, 2.15625212e-01f, 3.23690325e-02f, -5.87174436e-03f, -2.24654138e-01f,
  4.04147148e-01f, 1.79743674e-02f, -1.11558370e-01f, -2.79024631e-01f, -1.02824874e-01f, 6.62041977e-02f, -6.65973127e-02f, 2.40519792e-01f, 5.09977520e-01f, 9.81721506e-02f,
  2.57705152e-01f, 9.61252395e-03f, 3.87271404e-01f, -2.71398187e-01f, -3.83312404e-02f, 6.29705191e-01f, -1.11892387e-01f, -4.18682024e-02f, 1.79150939e-01f, 2.56091833e-01f,
  7.05059841e-02f, -3.91491652e-02f, 2.13417009e-01f, 4.01190072e-01f, 1.58727303e-01f, 1.01560555e-01f, 2.91032314e-01f, 1.04744080e-02f, 3.67456257e-01f, 3.46908271e-01f,
  4.19379361e-02f, 2.12752581e-01f, 1.58250883e-01f, 2.39237398e-01f, 1.57776892e-01f, 1.60396770e-01f, 2.69740313e-01f, 1.27853334e-01f, 9.73290801e-02f, 2.84150183e-01f,
  1.47156402e-01f, -2.16374416e-02f, 2.51676142e-01f, -9.87772644e-02f, 2.20240563e-01f, 2.50136793e-01f, 3.07202011e-01f, -2.95652926e-01f, -8.37751478e-02f, -2.09175617e-01f,
  -1.84940785e-01f, 2.79001206e-01f, 1.30339161e-01f, 9.28637385e-02f, 1.24391027e-01f, -1.91079125e-01f, 7.10863993e-02f, 3.04053962e-01f, -1.15369605e-02f, -8.93704742e-02f,
  -1.06519215e-01f, -2.39662766e-01f, -2.64460534e-01f, 9.56630409e-02f, -1.90380141e-01f, -2.75917679e-01f, 8.56249928e-02f, 3.58909994e-01f, 4.47569281e-01f, -6.61898702e-02f,
  -2.42565963e-02f, -6.31562471e-02f, -2.68839866e-01f, -8.78455639e-02f, -1.41089708e-01f, 2.57198125e-01f, 3.91783029e-01f, -1.82136104e-01f, -2.03222886e-01f, 7.14190230e-02f,
  5.61749563e-02f, 3.66449952e-01f, 1.86807528e-01f, 1.52063534e-01f, 3.71924303e-02f, 2.05415953e-02f, 1.66031241e-01f, 1.51707843e-01f, 1.41745090e-01f, -3.63208912e-02f,
  7.57034644e-02f, 1.85582072e-01f, 8.15866739e-02f, 1.00548744e-01f, -8.40842947e-02f, 1.38943195e-01f, 1.07641436e-01f, 1.19531766e-01f, 1.39366109e-02f, 1.10024132e-01f,
  1.24136835e-01f, 4.91475395e-04f, -8.60159323e-02f, 2.94271380e-01f, 1.24082498e-01f, 2.05897838e-02f, 1.16485372e-01f, 1.34476367e-02f, 2.67501146e-01f, 3.51380914e-01f,
  3.15747589e-01f, -2.13822052e-01f, 1.29098296e-01f, -1.21519677e-01f, -3.32976729e-01f, 1.36939943e-01f, 1.77151769e-01f, -4.49883230e-02f, 2.88837641e-01f, -1.87500373e-01f,
  -1.10846587e-01f, 1.95642427e-01f, 1.61465958e-01f, -1.34988129e-01f, 6.16072910e-03f, -1.18401296e-01f, -2.34357566e-01f, 2.26785645e-01f, 3.97662967e-02f, -1.91389397e-01f,
  1.82737634e-01f, -6.43495172e-02f, 5.10293901e-01f, -1.48541138e-01f, 3.30729276e-01f, 1.98456332e-01f, 7.33355731e-02f, 1.09019605e-02f, -4.94754985e-02f, 2.78417438e-01f,
  5.81792295e-01f, -1.41129926e-01f, -2.46549651e-01f, 2.65330262e-03f, 2.18288034e-01f, -5.45589626e-02f, -1.20853066e-01f, 1.24540985e-01f, 7.22500831e-02f, 1.54796749e-01f,
  -9.23565477e-02f, 6.17115833e-02f, 9.14126188e-02f, 1.09947637e-01f, 2.34445870e-01f, -9.01428536e-02f, 2.25439832e-01f, 7.94947594e-02f, 2.04682708e-01f, 2.51061618e-01f,
  2.09306832e-02f, 1.60491586e-01f, 1.68446168e-01f, 1.18122160e-01f, 2.21693665e-01f, 2.24352121e-01f, 2.08465233e-01f, 7.55688399e-02f, 2.66045451e-01f, 1.31326348e-01f,
  1.90786108e-01f, -2.70507067e-01f, -2.15859547e-01f, -2.74183482e-01f, 3.44547853e-02f, -3.81041408e-01f, -1.07777506e-01f, -1.90927163e-01f, 1.46454006e-01f, 9.81515869e-02f,
  -5.36290407e-02f, 2.83967525e-01f, -1.61873907e-01f, -5.82199283e-02f, 1.86183378e-01f, 4.95514981e-02f, 1.90525725e-02f, -4.31367122e-02f, -7.51493350e-02f, 6.38983473e-02f,
  -1.57696217e-01f, -2.44280994e-01f, -6.62513077e-02f, -1.54623285e-01f, 2.89347649e-01f, 4.45586490e-03f, 3.32233518e-01f, 3.70047420e-01f, -1.91570133e-01f, -4.34379548e-01f,
  2.39955783e-02f, -8.85430910e-03f, -2.10935459e-01f, 4.65052985e-02f, 3.92727643e-01f, -4.01266783e-01f, 2.41891265e-01f, 2.26045232e-02f, 7.41895214e-02f, 2.57125258e-01f,
  -1.88337523e-03f, 2.20051687e-02f, 1.03948541e-01f, 3.11130136e-01f, 1.82170659e-01f, -1.75369620e-01f, -1.41256839e-01f, 7.22383186e-02f, 4.77156192e-02f, 2.33247593e-01f,
  9.20460559e-03f, -4.11655679e-02f, 2.21498106e-02f, -1.76352054e-01f, 1.12428300e-01f, -5.87868653e-02f, -5.34427352e-02f, 3.47879119e-02f, -8.36531445e-02f, 1.11864746e-01f,
  2.44326722e-02f, 1.01020329e-01f, 4.41506431e-02f, 2.58200586e-01f, 1.94063798e-01f, -3.63688022e-02f, -2.22833544e-01f, 1.13652147e-01f, -2.01841727e-01f, 4.85420786e-02f,
  1.70853540e-01f, -2.27863207e-01f, 1.74796075e-01f, -8.96771252e-02f, -1.83815211e-01f, 2.23950088e-01f, 3.01066190e-01f, 1.01687551e-01f, 5.95876202e-02f, -1.77758619e-01f,
  8.04186091e-02f, 3.49593937e-01f, -7.87905753e-02f, -4.83637676e-02f, 6.28773198e-02f, 1.38675058e-02f, 4.11289074e-02f, 3.03219438e-01f, 6.00793660e-02f, -3.57052892e-01f,
  5.18717133e-02f, 2.53759902e-02f, -1.98206995e-02f, 9.85246524e-02f, -8.03397372e-02f, 4.12134647e-01f, -7.43853226e-02f, 4.12648141e-01f, 2.74457395e-01f, -1.74278417e-03f,
  2.06071377e-01f, 1.26028463e-01f, 2.55767629e-02f, 6.12891130e-02f, 2.28042025e-02f, 2.64788032e-01f, 7.65891466e-03f, -5.66506982e-02f, 1.81415334e-01f, 2.89843857e-01f,
  2.58603036e-01f, 2.62547404e-01f, 2.54760683e-01f, 3.78951728e-02f, 2.17650875e-01f, 2.28949860e-01f, 3.94826271e-02f, 5.31087182e-02f, 1.14490211e-01f, 2.00074583e-01f,
  2.15465680e-01f, 8.70608091e-02f, -1.24626644e-02f, -1.85324758e-01f, 1.66828692e-01f, 1.73497662e-01f, -1.29891217e-01f, -7.29608014e-02f, 2.33374685e-02f, 7.91193843e-02f,
  2.68008620e-01f, 1.33148655e-01f, -1.69758752e-01f, 2.59528905e-01f, -1.87456802e-01f, 3.44552726e-01f, -6.29112348e-02f, 2.57422447e-01f, -1.63894698e-01f, 1.21936731e-01f,
  -3.26841295e-01f, -3.82117331e-02f, -1.40654609e-01f, 2.06138462e-01f, -2.17996806e-01f, 3.19676399e-02f, 1.97097406e-01f, -1.63257234e-02f, -1.42713696e-01f, -1.38895884e-01f,
  -8.73838887e-02f, -9.17345211e-02f, -3.82322967e-01f, 5.32742381e-01f, -1.27463741e-02f, 5.71995266e-02f, -3.76757026e-01f, 5.21246254e-01f, -1.65082365e-01f, 4.35717195e-01f,
  1.69161871e-01f, 9.56158265e-02f, -1.46359801e-01f, 1.88251764e-01f, -1.85917899e-01f, 1.12806536e-01f, 5.76133840e-02f, 4.44473416e-01f, -3.02776277e-01f, 4.22176346e-02f,
  7.49360472e-02f, -4.72799838e-02f, 1.42557532e-01f, -1.99805900e-01f, 9.39389393e-02f, 1.46644518e-01f, 1.89102471e-01f, 2.83833854e-02f, 6.57389387e-02f, -1.02411948e-01f,
  -5.83159700e-02f, 8.16279575e-02f, 2.62089849e-01f, 1.69715688e-01f, -1.45408332e-01f, 1.40570536e-01f, -4.31065448e-02f, 1.00599431e-01f, 1.08865030e-01f, 6.52170032e-02f,
  5.13602681e-02f, -2.32511889e-02f, 5.58154695e-02f, 9.75837708e-02f, 2.20279664e-01f, -6.29666150e-02f, -1.88426688e-01f, -8.70269313e-02f, -4.92857322e-02f, 3.09257865e-01f,
  -1.11954741e-01f, 1.60061255e-01f, -4.60330844e-01f, -5.48408320e-03f, -1.58718020e-01f, -1.81174338e-01f, -1.02876837e-03f, -2.09088638e-01f, 1.48364231e-01f, 9.67298597e-02f,
  2.64139891e-01f, 7.90828839e-02f, -2.53259808e-01f, 7.06710070e-02f, 1.99000776e-01f, 1.86719466e-02f, 7.53286406e-02f, 3.11345935e-01f, 1.61561757e-01f, 5.65908290e-02f,
  3.16020697e-01f, 1.59501910e-01f, 4.04749393e-01f, 3.62580329e-01f, 1.16392691e-02f, 2.21219853e-01f, -1.58350289e-01f, -4.13435876e-01f, 7.37122744e-02f, 1.52427703e-01f,
  2.53141463e-01f, 6.05449498e-01f, 3.63918185e-01f, 1.31264523e-01f, 8.96959975e-02f, 3.15770030e-01f, 8.65556672e-02f, 2.90431291e-01f, 2.77087484e-02f, 3.55524756e-02f,
  -1.28494240e-02f, 1.36494577e-01f, 1.64695948e-01f, 5.40764928e-02f, 1.50743872e-01f, 1.74233213e-01f, 1.54771075e-01f, 4.91573364e-02f, 2.46442020e-01f, 1.64233223e-01f,
  1.48442030e-01f, 2.14362174e-01f, 3.45997885e-02f, 3.99784856e-02f, 2.66519576e-01f, 1.55187160e-01f, 7.80111551e-02f, 1.54000953e-01f, 7.59678334e-02f, -1.55601427e-01f,
  9.09486413e-02f, 1.53305426e-01f, 9.24407914e-02f, -1.54764578e-01f, 6.68993592e-02f, -2.34996065e-01f, 2.62710452e-01f, -2.78784961e-01f, 1.02709301e-01f, 2.05186129e-01f,
  1.93163350e-01f, 4.76965718e-02f, -7.53512383e-02f, -1.45063803e-01f, -3.07664245e-01f, -2.48340935e-01f, 3.67913187e-01f, 7.78837726e-02f, 3.17959525e-02f, -7.52130449e-02f,
  8.24358016e-02f, -1.33247972e-01f, 3.06630544e-02f, -4.30999175e-02f, 2.74435967e-01f, -1.36682093e-01f, 1.40764996e-01f, -1.35284796e-01f, 3.26105326e-01f, 1.79929703e-01f,
  -5.56760967e-01f, 5.16943991e-01f, 6.52657598e-02f, 3.26181054e-01f, 2.03664929e-01f, -2.18490064e-01f, -2.55017310e-01f, 1.24523975e-02f, 1.32169034e-02f, 2.36245409e-01f,
  2.32618451e-01f, -2.98738956e-01f, 1.21057555e-01f, 6.31092265e-02f, 2.73277890e-02f, 2.49327302e-01f, -1.52181163e-01f, 3.58999036e-02f, -7.70120844e-02f, -1.54819489e-01f,
  8.36655498e-02f, -7.14262249e-03f, -9.77478102e-02f, 2.35019028e-02f, -1.45673737e-01f, -9.12266374e-02f, -5.22871017e-02f, 8.42586011e-02f, -1.68185934e-01f, 2.08500102e-01f,
  1.12160452e-01f, -1.58875138e-01f, -5.10873422e-02f, 1.06212005e-01f, -1.33299232e-01f, 9.56795663e-02f, -2.52980664e-02f, 2.33188868e-01f, -1.09552287e-01f, 1.05257332e-01f,
  -4.36463088e-01f, 2.33541410e-02f, 1.10103481e-01f, -3.76830883e-02f, -3.51870656e-01f, -2.18242407e-01f, 1.89804420e-01f, 3.33951712e-01f, 1.18871622e-01f, 2.01090574e-01f,
  -1.07573252e-02f, 1.62271217e-01f, -9.58980843e-02f, 3.85712177e-01f, -7.06928298e-02f, 2.17390824e-02f, 3.47913429e-02f, 9.73987803e-02f, 1.95218727e-01f, 3.14381003e-01f,
  1.24153249e-01f, 5.29994190e-01f, 1.29811496e-01f, 1.80586427e-01f, -3.62886898e-02f, 3.73013467e-01f, 3.16590071e-01f, -2.15508789e-01f, 3.63497674e-01f, 2.11761847e-01f,
  2.14267239e-01f, 1.81542374e-02f, 7.25243762e-02f, 2.51276016e-01f, 6.69835880e-02f, 2.14961663e-01f, -4.00617048e-02f, 8.34957138e-02f, -3.32768373e-02f, 3.19150090e-01f,
  -8.73795301e-02f, 2.20534891e-01f, 2.18619034e-01f, -1.33267388e-01f, -3.61279137e-02f, -1.37678133e-02f, 2.79283702e-01f, 4.75206152e-02f, -7.35050589e-02f, -3.83092389e-02f,
  3.08354422e-02f, 1.34902909e-01f, -3.59331667e-02f, 2.33948961e-01f, 9.85700488e-02f, 2.59009078e-02f, -2.73585320e-01f, 2.29702994e-01f, 4.03804407e-02f, 3.85887831e-01f,
  1.04682818e-01f, -2.26003528e-01f, 1.19525582e-01f, -3.17798585e-01f, 2.03589916e-01f, -1.04563706e-01f, 6.53065443e-02f, 3.07294428e-01f, -6.27063811e-02f, 9.60585549e-02f,
  -1.45191371e-01f, 6.22842014e-02f, -1.96648762e-01f, -6.45862594e-02f, 3.41182828e-01f, -1.39991716e-01f, -2.22062543e-01f, 2.88933903e-01f, -3.72920811e-01f, -9.54597592e-02f,
  -3.79506379e-01f, -1.14431299e-01f, -4.80886996e-02f, 3.14124733e-01f, 1.58047974e-01f, 1.96703076e-01f, 4.72946048e-01f, -1.76186830e-01f, 4.42114800e-01f, 6.31862044e-01f,
  9.50871408e-02f, 2.49900341e-01f, 1.13963284e-01f, -4.23316211e-01f, 8.89456868e-02f, 6.08457290e-02f, 3.58992480e-02f, 7.22264349e-02f, -1.25174001e-01f, 7.93604925e-02f,
  2.43831843e-01f, 1.79173976e-01f, 2.02720299e-01f, -1.56011498e-02f, 6.70702383e-02f, 3.45878117e-02f, 1.70328826e-01f, 2.00722411e-01f, -4.85463291e-02f, 1.34058386e-01f,
  1.77295253e-01f, 3.06391157e-02f, 4.60596569e-02f, -1.35566339e-01f, 1.87389180e-01f, -8.78149942e-02f, 1.02510504e-01f, 2.60876287e-02f, 9.57860351e-02f, -2.90317774e-01f,
  -3.24276030e-01f, -3.07707578e-01f, 4.74748611e-02f, -2.09063858e-01f, -1.68657437e-01f, -1.06776524e-02f, 2.47363105e-01f, -1.23755410e-01f, 2.91229039e-01f, 2.37904906e-01f,
  -4.53800522e-02f, 1.17265075e-01f, -5.70651665e-02f, -2.32420877e-01f, 1.86913200e-02f, -1.05557598e-01f, 1.14868455e-01f, 3.79789531e-01f, -5.53702638e-02f, -2.73397774e-01f,
  -1.42083868e-01f, -6.11032732e-02f, 2.65068144e-01f, -3.09775770e-01f, 2.28998646e-01f, 4.67952043e-01f, -1.95978023e-02f, 2.85775930e-01f, 4.98115383e-02f, 1.11663669e-01f,
  -2.49688804e-01f, -1.35164618e-01f, 9.77802873e-02f, -8.12120885e-02f, 5.25774062e-01f, -2.77611285e-01f, -1.09861478e-01f, -1.10515617e-01f, 1.18324101e-01f, 7.31936283e-03f,
  1.12072587e-01f, 1.71894148e-01f, 9.62192565e-02f, 1.90607667e-01f, 1.73436806e-01f, 1.48258433e-01f, 1.41019702e-01f, 1.86608452e-02f, 1.26351655e-01f, 2.41647676e-01f,
  2.35854000e-01f, 1.94407672e-01f, -6.26268052e-03f, 2.55968392e-01f, 1.29481703e-01f, 4.51620109e-02f, 7.91418254e-02f, -7.48068392e-02f, 1.72277182e-01f, -7.16965795e-02f,
  1.09710079e-02f, 2.98984081e-01f, 1.76891282e-01f, -2.38353044e-01f, 1.17954602e-02f, -1.28135890e-01f, 3.13584745e-01f, -1.88626021e-01f, -7.72643909e-02f, -1.60148174e-01f,
  6.73454702e-02f, 4.93819918e-03f, 3.57854515e-01f, -8.82348791e-02f, -1.23426296e-01f, 2.76298642e-01f, -7.22163320e-02f, 1.95855618e-01f, 1.72192361e-02f, -1.32849604e-01f,
  -1.92406774e-01f, 7.76827186e-02f, 2.18574405e-01f, -2.64180563e-02f, -3.21634829e-01f, 1.10524390e-02f, 1.24492399e-01f, 2.03761265e-01f, -1.65590599e-01f, 2.55206108e-01f,
  2.48508856e-01f, 2.75666844e-02f, 2.60714322e-01f, -4.01982069e-02f, 2.43471652e-01f, -1.69057235e-01f, -3.45054239e-01f, 3.80463421e-01f, 2.87295938e-01f, -3.07778031e-01f,
  3.95917445e-01f, -1.17734797e-01f, 3.74360718e-02f, 9.54329316e-03f, 1.09100834e-01f, 4.79258224e-02f, 2.93700814e-01f, -1.46929198e-03f, 8.40989221e-03f, 4.67496105e-02f,
  4.89793681e-02f, 2.18787596e-01f, -7.30937719e-02f, 2.78477311e-01f, 8.00167173e-02f, -2.32939556e-01f, -4.58100624e-02f, 1.53006718e-01f, 2.07408071e-02f, -6.32654177e-03f,
  -1.62234560e-01f, -1.19362302e-01f, 1.06904671e-01f, 1.54743092e-02f, -1.08662531e-01f, 3.19555253e-01f, 1.64770335e-01f, -4.58926968e-02f, -1.72525361e-01f, 3.13107371e-01f,
  1.22361578e-01f, 1.24722064e-01f, 1.36682853e-01f, -1.03187814e-01f, 1.27470747e-01f, -4.44697142e-02f, 7.92845488e-02f, -5.24916016e-02f, 2.09044009e-01f, 2.51719594e-01f,
  -6.05380610e-02f, -3.20859700e-02f, 2.85268258e-02f, 1.97966382e-01f, -5.71064390e-02f, -1.27029244e-03f, 4.19837907e-02f, 9.36178025e-03f, -2.76386917e-01f, 3.94579679e-01f,
  -3.10504436e-01f, 5.40615385e-03f, -4.40884322e-01f, -1.38773695e-01f, 2.67670155e-01f, 4.20683742e-01f, 2.08433896e-01f, 2.62876004e-01f, 3.86238731e-02f, -1.40618667e-01f,
  3.62676352e-01f, 3.62361997e-01f, 6.24559447e-02f, -1.45285562e-01f, 3.95422786e-01f, -2.33626533e-02f
};

// L1_fan_Bp_bar (Shape: 1 x 14)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 14;
const float L1_fan_Bp_bar_data[] = {
  1.15692995e-01f, 1.67067528e-01f, 2.58209020e-01f, 1.39614657e-01f, 1.57357022e-01f, 1.16742522e-01f, 2.78859645e-01f, 1.73060253e-01f, 1.27715141e-01f, 1.43003687e-01f,
  1.59670562e-01f, 1.41173556e-01f, 1.39224946e-01f, 1.29848838e-01f
};

// L2_linear_W (Shape: 12 x 64)
const int L2_linear_W_rows = 12;
const int L2_linear_W_cols = 64;
const float L2_linear_W_data[] = {
  1.89659104e-01f, 4.25573997e-02f, -2.70919800e-01f, -2.29600240e-02f, -1.72963798e-01f, 1.40916526e-01f, 6.53504506e-02f, 1.65036559e-01f, 1.91579551e-01f, -1.42018691e-01f,
  4.82089445e-02f, -3.85255106e-02f, 1.43006846e-01f, -2.09121585e-01f, -1.49713218e-01f, 7.02468380e-02f, -2.60195464e-01f, -4.02499437e-01f, 6.81139901e-02f, -1.30355626e-01f,
  -1.48523539e-01f, -3.55336040e-01f, 8.86309817e-02f, -1.08861774e-01f, 1.33377194e-01f, 2.23481297e-01f, 1.54465541e-01f, -2.09105536e-02f, -3.11827987e-01f, 2.74201989e-01f,
  -3.58737200e-01f, 1.06328182e-01f, 1.06291480e-01f, 2.76172578e-01f, -3.00056130e-01f, -1.81855276e-01f, -2.38763094e-01f, -1.32408947e-01f, 2.54318774e-01f, -3.23794603e-01f,
  -1.35016978e-01f, 1.46943688e-01f, 1.22634381e-01f, 2.78187513e-01f, 3.49611863e-02f, -4.19637442e-01f, -5.18066958e-02f, -6.34981021e-02f, -4.15999256e-02f, -1.28211632e-01f,
  4.71590579e-01f, -4.52307552e-01f, -7.32289255e-01f, -3.61514777e-01f, -3.11216891e-01f, 8.92996043e-02f, -5.02310634e-01f, -5.27137578e-01f, 1.62569955e-01f, 3.38432312e-01f,
  3.07037562e-01f, 1.28747091e-01f, 2.36394629e-01f, 3.45292628e-01f, 9.58208516e-02f, -3.88096154e-01f, -1.96069643e-01f, -1.48887902e-01f, -2.96595871e-01f, -1.25354633e-01f,
  -1.32833987e-01f, -1.94159243e-02f, -1.08211331e-01f, 8.69961530e-02f, 4.50789332e-02f, -3.51164371e-01f, 1.75407141e-01f, 1.77383289e-01f, 1.86542884e-01f, -1.97539642e-01f,
  1.94698330e-02f, 1.64581880e-01f, -2.69736469e-01f, 1.86316788e-01f, 2.08672717e-01f, -3.95420820e-01f, 1.47649944e-01f, 2.21620336e-01f, -8.27131886e-03f, 2.95822114e-01f,
  1.74639910e-01f, -1.92097664e-01f, 3.23871464e-01f, 2.81641662e-01f, -3.84186059e-01f, 3.61954451e-01f, 3.08262557e-01f, 2.60213345e-01f, -2.57873297e-01f, -2.66810775e-01f,
  -8.40952694e-02f, -4.44675893e-01f, 1.80088922e-01f, -1.28089264e-01f, -3.38112056e-01f, 4.84686673e-01f, -4.84430185e-03f, -3.22362721e-01f, 3.17591429e-01f, -1.49546698e-01f,
  1.07014191e-03f, 2.51368403e-01f, -2.12027565e-01f, -2.73032129e-01f, -1.59019068e-01f, -1.22856483e-01f, -3.67997199e-01f, -5.28494895e-01f, 4.21253830e-01f, 3.40048820e-01f,
  -4.61514965e-02f, 3.41906875e-01f, -6.47189856e-01f, 3.77948970e-01f, -5.13321459e-01f, 2.47348219e-01f, -1.22368753e-01f, -2.55158722e-01f, -3.50636035e-01f, 7.25867227e-02f,
  1.06800675e-01f, -5.14290668e-03f, 1.27693638e-01f, -3.02341968e-01f, 4.65738140e-02f, -3.60977910e-02f, -2.56973296e-01f, -6.46641850e-02f, -1.85370713e-01f, -1.73644900e-01f,
  6.26337528e-02f, 4.69525233e-02f, -3.32136393e-01f, 1.47273773e-02f, -2.42651775e-01f, -2.81023413e-01f, -4.57459129e-02f, -1.33426026e-01f, -9.23596397e-02f, -3.91393974e-02f,
  -8.92686993e-02f, -3.86709045e-03f, 1.52397484e-01f, -2.45703921e-01f, 3.54102291e-02f, -6.20929748e-02f, -5.01729324e-02f, -2.26308748e-01f, -1.78601876e-01f, 2.13561878e-01f,
  -1.06237017e-01f, -5.51886931e-02f, -2.82508969e-01f, 1.15752272e-01f, 4.89917174e-02f, -3.18952113e-01f, 1.88649118e-01f, 6.64650351e-02f, 3.38247716e-01f, -2.41925746e-01f,
  -5.32543920e-02f, -2.17989311e-01f, -3.10806274e-01f, 2.58954972e-01f, -1.80165544e-02f, 3.30019981e-01f, 2.82754868e-01f, -4.83184643e-02f, -3.47873539e-01f, -4.09327894e-01f,
  1.70352831e-01f, 2.12325156e-01f, -2.92886287e-01f, 2.64769316e-01f, 2.54909992e-01f, 3.97102296e-01f, -3.49063337e-01f, 3.92983258e-01f, -4.74190533e-01f, -2.74648011e-01f,
  -4.26951170e-01f, -1.02324031e-01f, 1.25752673e-01f, -2.21733630e-01f, -1.40172318e-01f, -1.69494852e-01f, 1.18698515e-02f, -3.31212580e-02f, 1.42094612e-01f, 1.02023333e-01f,
  -2.82604605e-01f, -1.48154488e-02f, -9.13998410e-02f, -2.55282193e-01f, -9.07813832e-02f, -8.57242104e-03f, -1.61619768e-01f, -1.12742269e-02f, -1.19195811e-01f, 1.42700046e-01f,
  -1.18774593e-01f, -1.47440776e-01f, 3.39466147e-02f, -3.20464820e-02f, 4.23915498e-02f, -3.51927690e-02f, 2.34900359e-02f, -3.34565416e-02f, -2.33833656e-01f, 1.54357538e-01f,
  -2.15420842e-01f, -3.01145643e-01f, 2.37955540e-01f, -4.10311595e-02f, -9.29863453e-02f, 3.16562980e-01f, -2.24720478e-01f, 3.26503098e-01f, 9.37244371e-02f, 1.59572631e-01f,
  -2.34447554e-01f, -1.52263671e-01f, -1.38274789e-01f, 2.70460159e-01f, -1.28541276e-01f, 8.16508755e-02f, 1.79293603e-01f, -1.76222891e-01f, 3.37465286e-01f, -1.92256659e-01f,
  -8.00969824e-02f, 4.09720153e-01f, 5.36147773e-01f, 3.92864108e-01f, -5.72790921e-01f, -4.67868298e-01f, -4.95733380e-01f, -4.09732521e-01f, 9.16468948e-02f, -2.30041355e-01f,
  4.06485856e-01f, -3.00966293e-01f, 3.20303410e-01f, -2.97497094e-01f, -1.08707994e-01f, -4.68447477e-01f, 1.26405396e-02f, 1.33063316e-01f, 2.50144452e-01f, -2.11102828e-01f,
  5.74256219e-02f, -4.43746820e-02f, -7.11173117e-02f, -1.74475536e-01f, -4.60469536e-02f, 2.88602322e-01f, 1.91462249e-01f, 2.32367292e-01f, 1.15289994e-01f, 2.02433348e-01f,
  1.96226820e-01f, 1.34352341e-01f, 2.98079163e-01f, 2.28155419e-01f, -4.31991890e-02f, 1.54945880e-01f, -1.01662464e-01f, 7.76099339e-02f, -1.19132377e-01f, 2.33430229e-02f,
  1.29373163e-01f, -2.20623851e-01f, -2.05726445e-01f, -6.58696717e-06f, -1.84659153e-01f, -3.39141726e-01f, 2.18745708e-01f, -2.60494143e-01f, -4.60776359e-01f, -3.76642257e-01f,
  3.20780315e-02f, -1.90061331e-01f, 3.51437479e-01f, 1.86563075e-01f, 4.12573755e-01f, 4.08305228e-01f, 4.08140600e-01f, 9.72890183e-02f, 1.23352177e-01f, 2.15946764e-01f,
  -4.22082357e-02f, 4.86258686e-01f, -1.00348577e-01f, -5.25394529e-02f, -1.50089130e-01f, 4.77726519e-01f, -2.84657329e-01f, -7.23057210e-01f, 1.25449553e-01f, -1.85436368e-01f,
  -2.41797626e-01f, -2.10590661e-01f, 3.42120796e-01f, -4.97072279e-01f, 1.43315613e-01f, 1.10062487e-01f, 3.34095061e-01f, -4.54536647e-01f, 4.28323805e-01f, 3.94314647e-01f,
  -3.87622297e-01f, -1.98925845e-02f, -8.44450369e-02f, 1.69037655e-01f, 3.20861749e-02f, -1.25974521e-01f, 2.01883644e-01f, -3.68751660e-02f, 2.13436291e-01f, 4.14557615e-03f,
  1.38035342e-01f, 1.21263206e-01f, -1.31799906e-01f, 1.33818269e-01f, 8.72407109e-02f, 1.01583101e-01f, 1.72170028e-01f, -2.89713502e-01f, 1.76938593e-01f, 1.10258564e-01f,
  1.18488938e-01f, 2.32490420e-01f, 2.04345554e-01f, -1.56079501e-01f, -1.48935169e-01f, 1.23277508e-01f, 5.40843010e-01f, -4.06402022e-01f, -4.83865701e-02f, 5.02073586e-01f,
  5.20386934e-01f, -2.47914642e-01f, 4.85942006e-01f, 6.08508941e-03f, 4.92077678e-01f, 1.67999819e-01f, -2.90636659e-01f, 3.69415373e-01f, -6.18048571e-02f, -1.14725105e-01f,
  -4.06960577e-01f, 2.16473505e-01f, 1.69447392e-01f, -1.32908314e-01f, 3.44292402e-01f, -8.68393257e-02f, -2.66988277e-01f, -1.42222926e-01f, -2.48151958e-01f, -8.20456892e-02f,
  -2.07607642e-01f, 1.24597857e-02f, 4.91407476e-02f, -2.17498899e-01f, 3.63331854e-01f, -1.44371673e-01f, -5.26933908e-01f, -5.16943038e-01f, 2.71422416e-01f, -7.66365349e-01f,
  -2.57644355e-01f, 4.42763358e-01f, 4.54903841e-01f, -3.27163339e-01f, 2.68653095e-01f, 1.88494638e-01f, 2.57660329e-01f, -2.99997721e-02f, 1.84245124e-01f, 1.12628534e-01f,
  -2.44025514e-01f, -1.27161175e-01f, -2.15991348e-01f, -2.46198446e-01f, 1.79314226e-01f, -2.73735076e-01f, -2.19973326e-01f, 6.39524013e-02f, -2.12693006e-01f, -1.21703528e-01f,
  -2.64470965e-01f, 1.82975322e-01f, 1.46808401e-01f, 1.06744260e-01f, -3.94334160e-02f, 3.84085588e-02f, 1.67776689e-01f, 2.33143866e-01f, -2.22726747e-01f, 3.84854108e-01f,
  -2.20647827e-01f, 5.80645315e-02f, 5.23140669e-01f, -2.56976277e-01f, 2.50870943e-01f, -3.10136348e-01f, -4.08649325e-01f, 3.28783840e-01f, 1.75778702e-01f, -2.32100219e-01f,
  6.14274070e-02f, 3.85852277e-01f, 6.62501603e-02f, 2.68158436e-01f, 3.20737481e-01f, -2.27187946e-01f, -1.05615169e-01f, -3.71511310e-01f, -4.56269503e-01f, -4.50690776e-01f,
  -6.25340343e-02f, -7.01756477e-02f, 2.51542538e-01f, -3.99149209e-02f, -3.92242670e-01f, -3.75506312e-01f, 4.01160806e-01f, 4.09001827e-01f, 2.52473146e-01f, -4.55810994e-01f,
  7.20190629e-02f, -2.42798477e-01f, -6.18979931e-01f, -3.82932633e-01f, -3.03931564e-01f, 1.55404598e-01f, -7.58113489e-02f, -3.92159671e-01f, -8.31788257e-02f, -6.43765256e-02f,
  8.58881623e-02f, -5.79280406e-02f, 5.47685362e-02f, 7.19885454e-02f, -2.44648624e-02f, -1.08810410e-01f, 1.19793750e-02f, 5.55421673e-02f, 1.11107558e-01f, -5.82133885e-03f,
  4.70401999e-03f, 3.39742750e-02f, 6.38629049e-02f, -1.58443570e-01f, 6.68391064e-02f, -4.36566211e-02f, 9.98818353e-02f, 1.26091298e-02f, -4.83777467e-03f, -1.07659891e-01f,
  -1.56246275e-01f, -8.48326609e-02f, -1.85100943e-01f, -1.30573928e-01f, -1.25213295e-01f, -1.82156116e-01f, 2.18720675e-01f, -4.86003868e-02f, 1.62874132e-01f, 2.53108352e-01f,
  2.23115221e-01f, -2.26431847e-01f, -1.37093797e-01f, 2.03364789e-01f, 2.74827600e-01f, -2.58482277e-01f, -2.67449319e-01f, -1.55238941e-01f, -1.19352579e-01f, 5.48083931e-02f,
  -1.93364561e-01f, 1.72040060e-01f, -3.03009868e-01f, 9.94919613e-02f, 2.15544224e-01f, 3.40064913e-01f, 3.27865839e-01f, 2.13691115e-01f, 3.82417917e-01f, 5.56019768e-02f,
  -4.30396348e-01f, 1.51104107e-01f, -3.00071150e-01f, -2.55169541e-01f, -4.84670669e-01f, 4.41998273e-01f, -6.70642331e-02f, 2.74516910e-01f, -1.68566212e-01f, -3.56473535e-01f,
  2.56487399e-01f, 3.75392377e-01f, -5.14614247e-02f, 8.03945810e-02f, 9.95756537e-02f, -1.37594417e-01f, 1.57779053e-01f, 1.25958234e-01f, 1.25334561e-01f, 8.71944129e-02f,
  1.66940745e-02f, -3.10254842e-02f, -1.33905813e-01f, 1.65525630e-01f, -1.58027679e-01f, -1.78223893e-01f, 9.66757461e-02f, 8.48284066e-02f, -1.45513892e-01f, 6.61939308e-02f,
  -8.98109153e-02f, 1.38877302e-01f, -7.31092468e-02f, 5.59056103e-02f, 6.10949397e-02f, -1.82726644e-02f, -2.57509351e-02f, -2.52521366e-01f, -9.22903121e-02f, 3.33672076e-01f,
  2.75129020e-01f, 1.18001066e-02f, 1.67150363e-01f, 2.24144652e-01f, 1.44090608e-01f, 2.37069786e-01f, -8.24660063e-02f, -1.13682516e-01f, -1.25484735e-01f, 2.58706301e-01f,
  -2.48528972e-01f, 2.48502344e-01f, 1.19643375e-01f, -1.73146203e-01f, -1.06075630e-01f, -2.14420214e-01f, 1.54793337e-01f, 1.71889514e-01f, 1.54339388e-01f, 2.78106719e-01f,
  3.02843034e-01f, 3.01744133e-01f, -4.02956784e-01f, 3.25828165e-01f, -6.07403100e-01f, -2.05802858e-01f, -4.65127856e-01f, 2.60904700e-01f, 2.79519886e-01f, -1.77591577e-01f,
  -4.81242150e-01f, 1.21940129e-01f, 3.80132496e-01f, 2.96326101e-01f, -2.65998870e-01f, 4.24753726e-01f, -2.23763138e-02f, -7.50331879e-02f, -1.36606365e-01f, 2.97125597e-02f,
  -4.96460162e-02f, -9.74142924e-03f, 1.39539823e-01f, 4.88128364e-02f, 2.78370231e-01f, 8.83416608e-02f, -2.94189185e-01f, 2.16165766e-01f, 2.15178683e-01f, -9.13055148e-03f,
  -2.45188083e-02f, 4.36015651e-02f, 1.94623590e-01f, 2.13409111e-01f, -7.03673437e-02f, 5.77670187e-02f, 2.05247819e-01f, -1.30754570e-02f, -1.14088710e-02f, 5.47431298e-02f,
  -7.47000203e-02f, -3.64462316e-01f, -2.77077198e-01f, -2.04691991e-01f, -3.97192895e-01f, -1.74666569e-01f, -4.14318383e-01f, 1.62316129e-01f, 2.65865564e-01f, 1.22911505e-01f,
  3.23487431e-01f, -4.79531847e-02f, -2.80525774e-01f, -4.32529807e-01f, 2.15114966e-01f, 1.68926820e-01f, 3.04402530e-01f, -2.45750576e-01f, -4.37437790e-03f, 4.51243043e-01f,
  -2.64255404e-01f, 3.32455724e-01f, 8.46134573e-02f, -2.25885063e-01f, -7.71908090e-02f, -2.62516052e-01f, 6.71361983e-01f, -2.69217908e-01f, 1.74803644e-01f, 3.40496868e-01f,
  -1.17370963e-01f, 1.49180308e-01f, -5.31185031e-01f, -8.48599598e-02f, 4.13762003e-01f, -1.74002185e-01f, -5.98168969e-01f, -3.11764866e-01f, -1.18457846e-01f, -5.71748137e-01f,
  8.05734992e-02f, 8.26592296e-02f, 1.47013068e-01f, 1.50540009e-01f, 5.91844134e-02f, 1.45984227e-02f, 3.37341763e-02f, -6.63585067e-02f, 1.19947925e-01f, -9.89975780e-02f,
  1.67840958e-01f, 2.51078755e-01f, 6.85613453e-02f, -9.21552032e-02f, 1.84822917e-01f, 1.16657242e-01f, 2.25572675e-01f, 1.16709985e-01f, 2.90088952e-01f, 5.95640205e-02f,
  9.17187035e-02f, 5.29802293e-02f, 3.59380059e-02f, -2.01416314e-01f, 1.43369213e-01f, 2.56196231e-01f, 2.50117511e-01f, 1.81835875e-01f, 1.35625958e-01f, 3.04175168e-01f,
  -2.66032934e-01f, -2.32657358e-01f, -2.75174230e-01f, -2.83768058e-01f, -3.43384117e-01f, 2.40890041e-01f, 2.55549788e-01f, 2.46570289e-01f, -2.49162704e-01f, -8.84024426e-02f,
  -2.54845917e-01f, 2.84622870e-02f, -1.86876908e-01f, 1.88751057e-01f, 2.55441844e-01f, 6.22174814e-02f, -1.31844194e-03f, -1.94162413e-01f, -2.45002583e-01f, -2.27836296e-01f,
  -4.65496898e-01f, 1.68064579e-01f, 2.41788551e-01f, -4.40792680e-01f, 4.46869759e-03f, -4.42729890e-01f, 5.38776934e-01f, 4.86322373e-01f, -7.84663185e-02f, -4.07439619e-01f,
  -4.96720374e-01f, -2.76003838e-01f, -3.97984177e-01f, -3.81117016e-01f, 1.33207694e-01f, -9.76845995e-03f, -1.28059834e-01f, -1.16203586e-02f, 1.22937791e-01f, -1.43426105e-01f,
  -2.59327799e-01f, 9.51226577e-02f, -7.28755221e-02f, 4.00269590e-02f, 9.93456244e-02f, 1.36248186e-01f, -1.89676672e-01f, 3.16050686e-02f, -1.93101957e-01f, 8.16433281e-02f,
  -1.37909800e-01f, -9.29246619e-02f, -5.96027374e-02f, -1.64777026e-01f, 8.01516920e-02f, 9.80409533e-02f, -2.21585482e-01f, 3.77770737e-02f, -1.66218877e-01f, 1.09401740e-01f,
  -2.81481922e-01f, 2.85724401e-01f, -1.82938293e-01f, -3.28765437e-02f, 1.91209540e-01f, -6.07037470e-02f, -1.86640382e-01f, -2.59718239e-01f, 2.79353589e-01f, -1.48923665e-01f,
  1.65543165e-02f, -2.03200057e-01f, -2.85888582e-01f, -3.26757014e-01f, 1.26583576e-01f, -3.46496254e-01f, 2.45101780e-01f, 3.07624876e-01f, 2.18240514e-01f, -1.19334027e-01f,
  -2.48462677e-01f, -1.20320104e-01f, -1.83374301e-01f, -2.70221055e-01f, -3.38277847e-01f, 3.91593575e-01f, 8.41141045e-02f, 4.81191091e-02f, 1.41787887e-01f, 5.47944129e-01f,
  -5.80793440e-01f, -4.22818750e-01f, -4.49134409e-02f, -3.95126283e-01f, 3.80565822e-01f, -3.56630415e-01f, -4.13509309e-01f, 2.56682038e-01f
};

// L2_linear_B (Shape: 1 x 12)
const int L2_linear_B_rows = 1;
const int L2_linear_B_cols = 12;
const float L2_linear_B_data[] = {
  -9.49073955e-02f, 1.11422651e-01f, -1.32393181e-01f, 1.25833256e-02f, 7.67061189e-02f, -1.57908462e-02f, -6.18676506e-02f, 2.02944167e-02f, -9.82317850e-02f, -2.70359442e-02f,
  4.68676500e-02f, -7.37464353e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 25, 14
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        64, 25, 14
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_linear
    linear_forward_pgm(
        buffer1, x_out,
        L2_linear_W_data, L2_linear_B_data,
        64, 12
    );
    }
    