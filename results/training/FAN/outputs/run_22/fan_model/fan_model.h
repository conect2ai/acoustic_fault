/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 16 (x2)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 16;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    return (x > 0.0f) ? x : 0.0f;
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 6 x 120)
const int L0_fan_Wp_rows = 6;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  8.91596079e-01f, 4.95118648e-02f, -4.46259230e-02f, 1.82478026e-01f, 1.73510149e-01f, 2.85365462e-01f, 2.43458971e-01f, 5.24808727e-02f, 3.30179423e-01f, 3.55465300e-02f,
  5.22177480e-02f, 1.87290892e-01f, 9.64359045e-02f, 2.37355709e-01f, 2.11382926e-01f, 1.75572351e-01f, 1.02500208e-01f, 1.15732469e-01f, 1.69323638e-01f, 5.80143221e-02f,
  4.95922863e-02f, 2.46990174e-01f, -5.54511212e-02f, -8.69305134e-02f, -6.44019991e-02f, -1.22352555e-01f, -1.72695011e-01f, -1.10287324e-01f, -5.00643961e-02f, -3.08563448e-02f,
  -1.09296571e-02f, 2.43614390e-02f, -6.11377321e-03f, -3.19426395e-02f, 6.46040821e-03f, -3.10402885e-02f, -5.50163118e-03f, -3.33511382e-02f, 1.22498363e-01f, 4.00850289e-02f,
  6.40797764e-02f, 1.37160532e-02f, 8.48534033e-02f, 7.64851347e-02f, 8.17781836e-02f, -1.35140838e-02f, 7.01686516e-02f, -6.24534115e-02f, 5.68695515e-02f, 5.68871871e-02f,
  7.73533657e-02f, -1.20037489e-01f, 1.24082007e-02f, -3.56498025e-02f, -5.88873327e-02f, 4.43009473e-02f, -6.10917062e-03f, -8.61528814e-02f, 1.65123064e-02f, 6.66998625e-02f,
  1.47876563e-02f, 2.31941119e-02f, 2.38478798e-02f, -7.19816703e-03f, 3.83887291e-02f, -2.84173656e-02f, 6.60023019e-02f, -5.14314920e-02f, 7.75617063e-02f, 6.60461113e-02f,
  2.03322042e-02f, 8.57922286e-02f, 6.94156438e-02f, -3.11944485e-02f, 5.73223457e-02f, -1.35482196e-02f, 1.95462912e-04f, 2.30349251e-03f, -4.97448118e-03f, 6.69247583e-02f,
  3.86983231e-02f, -1.15860570e-02f, 8.17674585e-03f, -5.78144416e-02f, 1.64719801e-02f, -7.35820606e-02f, -1.58241112e-03f, 1.25521701e-02f, -2.45277993e-02f, -4.55324389e-02f,
  -5.07724062e-02f, -6.85099512e-02f, -3.94122154e-02f, 4.87361476e-02f, -3.91015671e-02f, -2.92835943e-03f, 2.11105291e-02f, 2.94590648e-02f, -9.92803574e-02f, -1.26083083e-02f,
  -9.13176239e-02f, -2.21849475e-02f, -7.21196234e-02f, -3.48865241e-02f, -7.21897259e-02f, 2.10620426e-02f, -1.09996535e-01f, 2.58288309e-02f, -5.62358126e-02f, -8.14402197e-03f,
  -6.32455423e-02f, 6.80486858e-02f, -9.66097601e-03f, -2.30171625e-02f, -2.01525334e-02f, -5.34982346e-02f, -8.74745622e-02f, 4.73292731e-02f, -6.09275214e-02f, -2.10755877e-02f,
  3.74249816e-02f, -7.32609630e-02f, 1.46461859e-01f, -3.86323035e-02f, -4.46651801e-02f, -3.77263755e-01f, 2.74669211e-02f, -4.58553918e-02f, 5.08644581e-02f, -2.82094866e-01f,
  -1.66636124e-01f, 3.41900706e-01f, -3.34329829e-02f, -5.72545864e-02f, 3.57116610e-01f, -1.18607663e-01f, -1.78072855e-01f, -6.81741256e-03f, 7.47098252e-02f, -4.44227420e-02f,
  -4.08858643e-04f, -7.90557787e-02f, -1.09958977e-01f, -1.00428455e-01f, -2.36154675e-01f, 9.10329297e-02f, -2.27308810e-01f, 2.11510956e-01f, -1.58576697e-01f, 1.04836181e-01f,
  -4.28887904e-02f, 3.66333462e-02f, 1.47665650e-01f, -1.52544826e-02f, -1.07393093e-01f, -2.02469490e-02f, -2.60651354e-02f, 1.46395460e-01f, 5.34923486e-02f, 1.22522861e-01f,
  4.23022471e-02f, 3.48756164e-02f, 3.20375450e-02f, 3.74304466e-02f, -1.22107724e-02f, 3.80053371e-02f, 4.95549925e-02f, -8.35426822e-02f, 1.05414972e-01f, 9.94830430e-02f,
  3.33469883e-02f, 9.96329542e-03f, -3.80061171e-03f, -5.53616807e-02f, 8.45031738e-02f, 7.19917193e-02f, -2.67050210e-02f, 6.08510636e-02f, -1.16623357e-01f, -2.39171516e-02f,
  9.77946371e-02f, 9.79850534e-03f, -4.70207334e-02f, -7.35308453e-02f, 2.63909344e-02f, -6.72140159e-03f, -3.39895859e-03f, 1.62947774e-02f, 3.87143977e-02f, -9.71800461e-02f,
  -1.37857661e-01f, 6.84119854e-03f, -4.63769585e-03f, -5.98727763e-02f, -8.87034461e-03f, 3.84392217e-02f, 1.02900220e-02f, -4.78933007e-03f, 7.91763589e-02f, 1.45271504e-02f,
  4.47471887e-02f, -6.40669838e-02f, -4.80871946e-02f, -7.29499981e-02f, -1.43149891e-03f, 9.85615104e-02f, 2.99379844e-02f, 1.07560232e-02f, 3.80136222e-02f, -4.15564142e-02f,
  -2.89896488e-01f, -3.75997633e-01f, -7.11170807e-02f, -7.08292872e-02f, -7.54312947e-02f, 4.18812707e-02f, 6.64175600e-02f, 6.51244447e-02f, -1.05277203e-01f, -9.07230526e-02f,
  -5.59404604e-02f, -2.84724981e-02f, -1.68243170e-01f, -3.23939025e-02f, 1.00170057e-02f, -1.20001063e-01f, -1.22766569e-01f, 5.60208736e-03f, -8.38561654e-02f, -1.09612428e-01f,
  -5.25591429e-03f, 7.43374834e-03f, 1.35409117e-01f, -9.28830877e-02f, -4.74686809e-02f, -6.36220127e-02f, -3.75559665e-02f, 6.25132397e-02f, 6.90669864e-02f, -6.27074670e-03f,
  4.91912842e-01f, 1.36793748e-01f, 8.85315761e-02f, 3.91424686e-01f, 3.60935926e-02f, 1.27533361e-01f, 2.79674113e-01f, 1.69613823e-01f, 3.83192822e-02f, 1.58697918e-01f,
  6.25187978e-02f, 1.15026906e-01f, 4.28784303e-02f, 4.79594707e-01f, 1.93783149e-01f, 3.20142627e-01f, 2.86986351e-01f, 2.29124099e-01f, 2.49580145e-02f, 5.71324266e-02f,
  1.34017020e-01f, 2.58384526e-01f, 2.61841476e-01f, -3.73033322e-02f, 8.37321579e-02f, -9.45708379e-02f, -5.31945787e-02f, -1.13477670e-01f, 6.81122020e-02f, 1.42998859e-01f,
  1.63681209e-01f, 1.28065760e-03f, -1.73364878e-02f, 3.59215029e-02f, -2.97982395e-02f, -5.15553802e-02f, -1.60136819e-02f, -2.18048040e-02f, -1.00855134e-01f, 8.67503881e-02f,
  -4.52128053e-02f, -4.60240059e-02f, 2.03855708e-01f, -7.02048168e-02f, -4.55236845e-02f, -3.66683230e-02f, 3.20795663e-02f, -3.26466300e-02f, -8.81949719e-03f, 1.18238054e-01f,
  2.32749768e-02f, 1.03963494e-01f, -2.76127700e-02f, 1.10700354e-02f, -4.80487719e-02f, 9.04148817e-03f, 2.56952941e-02f, -6.36959448e-02f, 1.12684229e-02f, 6.20036758e-03f,
  -5.16162403e-02f, -4.52995896e-02f, -4.01277170e-02f, -2.46331953e-02f, 2.09481977e-02f, 6.59828121e-03f, 5.85935004e-02f, 1.88752785e-02f, 7.73692504e-02f, -2.21507181e-03f,
  -2.24536583e-02f, 2.55939867e-02f, 1.55255850e-02f, 2.37217676e-02f, -8.92526377e-03f, 5.45267910e-02f, -1.93137843e-02f, -2.58843577e-03f, 4.50207368e-02f, 2.58243717e-02f,
  2.65420731e-02f, 1.79340374e-02f, 6.72277703e-04f, -3.54287624e-02f, -3.62555236e-02f, 1.59249436e-02f, 1.53356260e-02f, -7.27356924e-03f, -4.00070064e-02f, -2.22026687e-02f,
  -1.15577161e-01f, -1.20432481e-01f, 3.29364985e-02f, 4.52262908e-02f, -2.49875057e-03f, 3.47551592e-02f, 5.52569367e-02f, 1.33599686e-02f, 3.63507196e-02f, -7.41610602e-02f,
  -5.05092815e-02f, 7.63321994e-04f, -1.96141928e-01f, 4.45900336e-02f, 1.12291030e-03f, 3.92445959e-02f, 1.55446550e-03f, -2.86611561e-02f, 2.56390199e-02f, -1.12535255e-02f,
  4.07749601e-02f, -7.71619827e-02f, -2.73259990e-02f, 5.90315387e-02f, 8.18401277e-02f, 2.54543796e-02f, -9.80050582e-03f, 2.82437280e-02f, 5.82123995e-02f, 6.96370378e-02f,
  7.40221083e-01f, 2.32788041e-01f, 2.07466602e-01f, 1.60420194e-01f, 8.23989417e-03f, 3.40321124e-01f, 3.40345442e-01f, -4.90269624e-02f, 2.32905731e-01f, -7.33597055e-02f,
  -1.06863491e-01f, 2.24377304e-01f, -6.57705143e-02f, 8.10377672e-02f, 5.73740602e-02f, -1.26259536e-01f, 1.18820399e-01f, 7.39806890e-02f, 3.21943089e-02f, 8.11833963e-02f,
  6.71816990e-02f, -1.40833154e-01f, -1.06843546e-01f, -1.06924057e-01f, 7.33446330e-02f, 5.26787303e-02f, -1.79452673e-01f, -4.12864238e-02f, -1.73525855e-01f, 2.08743680e-02f,
  1.32117867e-01f, -4.71389703e-02f, -5.47528826e-02f, -4.72408831e-02f, -3.76171689e-03f, 8.33469629e-02f, 7.32640475e-02f, 9.65564102e-02f, -6.79195151e-02f, 6.22700565e-02f,
  5.06480411e-02f, -2.65764669e-02f, 1.50461448e-03f, 2.09120214e-02f, 8.14019889e-03f, -7.54488865e-03f, -9.16609727e-03f, -4.03845944e-02f, -2.17728037e-02f, -9.82526690e-03f,
  1.82084721e-02f, -7.89263099e-03f, 7.40115643e-02f, 1.73278376e-02f, 6.88644946e-02f, 2.07925215e-02f, 3.46407630e-02f, 4.21650037e-02f, 8.41743425e-02f, 9.39523503e-02f,
  9.12010819e-02f, -1.30407391e-02f, -9.33007598e-02f, -9.10204872e-02f, 2.87811179e-02f, -1.00372136e-01f, 2.39888486e-02f, -3.17631587e-02f, 2.73747426e-02f, -4.73009869e-02f,
  -1.28773656e-02f, 1.76656954e-02f, -3.50433812e-02f, 3.63797136e-02f, -2.69875284e-02f, 2.54064538e-02f, 5.84090315e-02f, -3.31950076e-02f, 2.72967536e-02f, -5.89503162e-02f,
  -3.58401723e-02f, 5.26273586e-02f, -5.47629893e-02f, 2.34951954e-02f, -5.85932769e-02f, 5.82112111e-02f, -1.93629768e-02f, 3.56734358e-02f, -2.05754992e-02f, 6.40122732e-03f,
  -3.83317992e-02f, 9.51080844e-02f, 4.98150475e-02f, 2.01123916e-02f, -2.57093124e-02f, -5.80338314e-02f, -2.53148172e-02f, -3.08097573e-03f, 5.34003749e-02f, 1.67715866e-02f,
  1.99957881e-02f, -1.52548030e-03f, 7.47172311e-02f, -6.86883330e-02f, 1.52833937e-02f, 3.23399273e-03f, 3.05499285e-02f, -1.30681153e-02f, 4.39161062e-02f, -3.73873748e-02f,
  8.84922873e-03f, 2.96932794e-02f, -8.51138774e-03f, 2.08600480e-02f, 3.56375985e-02f, 3.51267532e-02f, 1.25806794e-01f, -2.66242083e-02f, -5.71744516e-03f, -1.80735774e-02f,
  1.32386521e-01f, 1.99055612e-01f, 1.00425489e-01f, 1.42808929e-01f, 2.16629595e-01f, -6.02955557e-02f, -6.17920309e-02f, 3.71412367e-01f, -1.09570704e-01f, -1.26323834e-01f,
  -6.19836375e-02f, -4.25899997e-02f, -1.37584463e-01f, 4.19093929e-02f, -4.72783536e-01f, -5.13521433e-01f, -1.82703003e-01f, -1.26837298e-01f, -8.66946205e-03f, 5.64611591e-02f,
  -2.10407041e-02f, 1.16464518e-01f, -1.81663204e-02f, 3.07753026e-01f, 2.93005437e-01f, 3.12300295e-01f, 1.02823749e-01f, 1.91156864e-01f, 2.59753764e-01f, -4.91649918e-02f,
  -9.93527770e-02f, 4.11145240e-02f, 3.25867295e-01f, -1.27192382e-02f, -3.19365785e-02f, 7.83774722e-03f, 3.01345084e-02f, -4.26663570e-02f, -1.12717403e-02f, -6.20549507e-02f,
  8.19206145e-03f, -1.54695004e-01f, 1.88609995e-02f, 6.84147328e-02f, 4.51572314e-02f, 1.14559187e-02f, 8.06491729e-03f, 1.34096257e-02f, 9.47260484e-02f, -2.16901507e-02f,
  1.99091751e-02f, -4.74144518e-02f, 9.98914894e-03f, 1.57438237e-02f, 4.49310392e-02f, -4.11294075e-03f, -7.31689557e-02f, -7.83981010e-03f, -4.21431400e-02f, 8.38552639e-02f,
  9.90056805e-03f, 2.70192651e-03f, -3.67144383e-02f, -1.57567188e-02f, 7.75599703e-02f, 1.47497805e-03f, -3.74497958e-02f, 5.34378700e-02f, -2.60835849e-02f, 2.55946629e-02f,
  -2.86276862e-02f, 1.29788116e-01f, 7.80986762e-03f, 1.07689902e-01f, -2.87921820e-02f, 9.24800038e-02f, -9.34221819e-02f, -4.22013775e-02f, 1.01267390e-01f, -1.44780111e-02f,
  2.68875360e-02f, 1.95172075e-02f, 1.29886633e-02f, -5.69291739e-03f, -4.65540886e-02f, 7.26877451e-02f, -1.34742691e-03f, 6.25463948e-02f, -1.09139290e-02f, -4.24028141e-03f,
  -9.13385972e-02f, 4.50763255e-02f, -9.59906727e-03f, 3.70309539e-02f, -5.76319359e-02f, 3.82777750e-02f, -6.06180355e-02f, 1.17256846e-02f, -5.78190386e-02f, 3.64764407e-02f,
  4.90724780e-02f, 2.07959674e-02f, -6.09283987e-03f, -8.15766156e-02f, 2.37666555e-02f, -9.14450735e-03f, -8.58841985e-02f, 6.01774305e-02f, 9.01003927e-02f, 1.23947307e-01f,
  7.76767847e-04f, -6.17143959e-02f, -2.95887534e-02f, 5.58176152e-02f, 4.51436378e-02f, -1.16146751e-01f, 1.12620793e-01f, 1.44041711e-02f, -9.24823992e-03f, -2.64878273e-02f,
  -3.96431297e-01f, 6.48508251e-01f, 5.60282432e-02f, 2.39005044e-01f, -1.92250922e-01f, 1.57826126e-01f, 1.13749150e-02f, 1.67278051e-01f, -4.15239036e-02f, 2.71125227e-01f,
  -8.71191025e-02f, 1.17746130e-01f, -5.79307089e-03f, 2.18439564e-01f, -4.31831777e-01f, 1.53124496e-01f, -2.63472702e-02f, 9.72022191e-02f, -3.37948613e-02f, 1.24423720e-01f,
  1.36798359e-02f, 1.81245804e-01f, -9.07579809e-02f, 1.47595242e-01f, -6.06329404e-02f, 5.79294786e-02f, -1.49269685e-01f, -2.72398554e-02f, 3.59314978e-02f, 1.04602454e-02f,
  4.59365398e-02f, 1.54030845e-01f, 6.60721511e-02f, 6.79715723e-02f, -2.52611120e-03f, 5.05486093e-02f, -5.02343923e-02f, -5.70066795e-02f, -2.24238634e-03f, -3.78813334e-02f,
  -3.60873416e-02f, 3.25020589e-02f, 1.99791528e-02f, -7.72079872e-03f, 1.36894537e-02f, -5.61655723e-02f, -6.12454303e-02f, -5.69214933e-02f, 6.74163848e-02f, 3.99466492e-02f,
  3.89836058e-02f, -2.56636199e-02f, -2.24826322e-03f, 1.25919329e-02f, -3.99964191e-02f, 2.80455463e-02f, 3.61912809e-02f, 3.77282463e-02f, -1.93788018e-02f, -4.38352786e-02f,
  4.38958220e-02f, -7.20745176e-02f, -1.50771365e-02f, -7.82431364e-02f, 4.32272442e-02f, -6.44245418e-03f, -1.54902646e-02f, 2.99005993e-02f, -2.47161854e-02f, -3.68382744e-02f,
  -6.21987507e-02f, 6.43660575e-02f, -2.54276171e-02f, 3.12264450e-02f, -2.47361679e-02f, 2.25238185e-02f, 2.61429492e-02f, 7.36152846e-03f, -3.08095608e-02f, -3.89171876e-02f,
  1.23553062e-02f, -1.71168204e-02f, 2.38045193e-02f, -3.09781469e-02f, 4.30089906e-02f, -5.16324155e-02f, 1.88951790e-02f, 5.50264642e-02f, -4.17449214e-02f, -7.98901245e-02f,
  8.43256190e-02f, 1.80373952e-01f, 1.31596224e-02f, -3.49947512e-02f, 6.13965504e-02f, -7.09440634e-02f, -2.16129944e-02f, 5.20403609e-02f, 4.09572246e-03f, 6.31284341e-02f,
  4.24791453e-03f, -4.89164516e-02f, -5.07204421e-03f, 7.75780668e-03f, -1.69329364e-02f, 8.63640755e-02f, 1.74663961e-02f, -1.72210187e-02f, -9.87998769e-02f, -3.15505825e-02f,
  1.10870064e-03f, -6.72704875e-02f, -4.02474068e-02f, -9.84856710e-02f, -1.86136346e-02f, -6.19281977e-02f, -3.00246496e-02f, -1.43020442e-02f, -1.00908829e-02f, 8.30125157e-03f
};

// L0_fan_Wp_bar (Shape: 4 x 120)
const int L0_fan_Wp_bar_rows = 4;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  1.79727618e-02f, -1.42176241e-01f, 9.55428720e-01f, -2.27877181e-02f, 5.78817904e-01f, 8.37417483e-01f, 5.02174795e-01f, 1.80638164e-01f, 2.23459870e-01f, -6.19382918e-01f,
  -2.90679008e-01f, -8.26810375e-02f, -1.37039810e-01f, -2.20145747e-01f, 5.49233377e-01f, 2.02052042e-01f, 4.84000370e-02f, -2.27655321e-01f, 2.66523749e-01f, 9.94725991e-03f,
  3.17306757e-01f, 6.06519356e-02f, 3.45430285e-01f, 3.47320028e-02f, 2.78448492e-01f, -2.98984032e-02f, -2.71184176e-01f, 1.60061926e-01f, -1.99971348e-01f, 1.84495121e-01f,
  3.24481755e-01f, -2.45969042e-01f, -5.88368857e-03f, -2.38250056e-03f, 8.67044460e-03f, -3.96857113e-02f, -3.95766385e-02f, -1.23452814e-02f, 4.17797752e-02f, -1.96263678e-02f,
  -1.80973962e-01f, -2.30221432e-02f, -4.75928821e-02f, 3.14215049e-02f, -1.83459278e-02f, -3.14726457e-02f, 8.90554041e-02f, 8.03827494e-02f, 6.76719993e-02f, 1.85048014e-01f,
  1.13453217e-01f, 7.61343688e-02f, -5.28194346e-02f, -4.85585071e-02f, 3.32060941e-02f, -9.60736051e-02f, 8.46518129e-02f, 7.76711255e-02f, 4.81550470e-02f, -1.19894862e-01f,
  -7.37450048e-02f, 4.07181960e-03f, 6.98385155e-03f, -4.27783094e-02f, 7.20194578e-02f, 8.16247389e-02f, -9.47551057e-02f, -3.05877980e-02f, 7.47689083e-02f, -3.40278149e-02f,
  -9.57043320e-02f, -6.59295022e-02f, -7.48389438e-02f, 9.67212915e-02f, -1.66491315e-01f, -1.00309730e-01f, -5.60252145e-02f, -7.08321556e-02f, -5.22029251e-02f, 2.01742556e-02f,
  -2.14579906e-02f, 3.77934016e-02f, -9.59848538e-02f, -1.99604761e-02f, 4.03882097e-03f, 1.98490769e-02f, -6.38700426e-02f, 2.53402516e-02f, -3.97656113e-02f, 4.91212085e-02f,
  -1.18443169e-01f, -3.08629572e-01f, -2.82248128e-02f, -5.07005565e-02f, -1.72060616e-02f, -7.96568990e-02f, 1.26542691e-02f, 5.52871488e-02f, -3.62271257e-02f, -9.88064520e-03f,
  3.70785892e-02f, -7.48330280e-02f, 9.22047496e-02f, 6.99080601e-02f, -2.84476709e-02f, 3.85108106e-02f, -1.66355446e-02f, -1.44977570e-01f, -1.23161234e-01f, -5.14736399e-02f,
  1.65433914e-03f, -1.27009213e-01f, 8.73080119e-02f, -9.14669186e-02f, -1.29101068e-01f, -6.25302792e-02f, -2.76693348e-02f, 1.04245991e-01f, 3.51628289e-02f, 1.64199725e-01f,
  8.15961599e-01f, 3.05596799e-01f, 3.92654747e-01f, 9.09661114e-01f, 1.71135813e-01f, -3.73506010e-01f, -1.07819669e-01f, 5.43865025e-01f, 6.37633920e-01f, -2.47472495e-01f,
  1.76117122e-01f, -2.46542573e-01f, -7.74203166e-02f, 2.67528236e-01f, 4.05290365e-01f, -2.22036362e-01f, 5.93775034e-01f, -2.70902012e-02f, 4.51077402e-01f, 3.91651124e-01f,
  6.17925406e-01f, 3.34196627e-01f, 1.63450062e-01f, 8.93671811e-02f, 3.17899644e-01f, 3.75323176e-01f, 1.07042819e-01f, -1.10240258e-01f, -1.92847755e-02f, -2.21436456e-01f,
  -3.33984122e-02f, 8.70057195e-02f, 1.42300323e-01f, -1.53832585e-01f, 7.48530999e-02f, -9.38583165e-02f, -1.71908185e-01f, -3.02462518e-01f, -1.22003205e-01f, -4.66410973e-04f,
  -1.02666758e-01f, -3.87500077e-02f, -2.78748292e-02f, 7.40944296e-02f, -3.43826897e-02f, -5.67573532e-02f, 2.16537174e-02f, 5.45336530e-02f, -7.67603144e-02f, -3.89333436e-04f,
  9.46488231e-02f, 4.32438627e-02f, 2.10680306e-01f, -1.43944651e-01f, 1.12781085e-01f, 9.98240933e-02f, -3.01372875e-02f, -2.07782704e-02f, -5.46150506e-02f, 1.44163325e-01f,
  7.09241033e-02f, 5.12051806e-02f, -4.18194346e-02f, 3.59215401e-02f, 1.26862064e-01f, 6.70137107e-02f, 7.60346055e-02f, -6.84574023e-02f, 1.04422919e-01f, -6.72409311e-02f,
  8.94931108e-02f, -5.89203723e-02f, 1.19231723e-01f, -3.05034257e-02f, 5.01412489e-02f, 5.75667806e-02f, -3.87211256e-02f, 4.01862413e-02f, 1.00768283e-01f, 3.77860814e-02f,
  2.03605276e-02f, -1.23526640e-02f, 1.78158190e-02f, -4.04821485e-02f, 3.87653039e-04f, -1.22609185e-02f, 8.09007809e-02f, 5.39439581e-02f, -5.45640513e-02f, -5.69952046e-03f,
  5.12428209e-03f, 5.26702821e-01f, -2.17432273e-03f, -2.01771960e-01f, -5.40815666e-02f, 1.18064255e-01f, 2.62161382e-02f, 1.41073748e-01f, -4.45837267e-02f, 1.28693238e-01f,
  -5.12751415e-02f, 1.49316192e-02f, -3.40297110e-02f, -2.66949702e-02f, -6.70229970e-03f, 1.99444786e-01f, -3.11046056e-02f, 3.72628868e-02f, 5.18303029e-02f, 4.37411387e-03f,
  -7.78432339e-02f, -7.59148374e-02f, 3.16552967e-02f, 5.41604683e-03f, -5.81686161e-02f, -7.55065307e-02f, 2.99556106e-02f, 3.11704315e-02f, 6.60044402e-02f, -3.97431515e-02f,
  8.63180280e-01f, -3.18236537e-02f, 5.64787984e-01f, 8.19356263e-01f, 2.94228971e-01f, -7.02759743e-01f, -2.47961730e-01f, 1.18865579e-01f, 2.29234830e-01f, -4.02245075e-01f,
  -2.82588035e-01f, 4.60846514e-01f, -8.46327186e-01f, 4.94172186e-01f, -4.04658586e-01f, -4.62204546e-01f, -1.46868071e-02f, 2.03779206e-01f, 5.67943789e-02f, 2.18400313e-03f,
  2.96323627e-01f, -3.10305864e-01f, 1.22060463e-01f, -1.53122962e-01f, 6.18288338e-01f, 3.59285921e-01f, -1.11099981e-01f, -2.56610990e-01f, 2.45368451e-01f, 2.00377237e-02f,
  2.13167388e-02f, 2.27465093e-01f, 1.22919723e-01f, -5.21612819e-03f, -4.94925957e-03f, -1.67126253e-01f, 1.06347114e-01f, -9.54787210e-02f, 1.90049708e-01f, 5.77372611e-02f,
  -5.56428283e-02f, -6.83678985e-02f, 2.12160662e-01f, 9.74995550e-03f, 5.43173775e-02f, 1.49036184e-01f, 2.94820845e-01f, 2.17843473e-01f, 1.88489810e-01f, 2.66771793e-01f,
  6.42482415e-02f, 4.70611900e-02f, 3.32461223e-02f, -1.05553688e-02f, 6.82114437e-02f, 2.63982192e-02f, 5.43250330e-02f, 8.23569149e-02f, 5.96511923e-02f, 1.18822582e-01f,
  3.45939770e-02f, -1.84659287e-01f, 8.36438909e-02f, 3.80189866e-02f, 5.34778833e-02f, 1.07066862e-01f, 2.03126837e-02f, 3.86823304e-02f, 5.31940125e-02f, 2.16945969e-02f,
  -7.21443444e-02f, 2.49938723e-02f, 6.15049079e-02f, 6.46915939e-03f, 1.64388493e-02f, -6.59742132e-02f, 1.06009178e-01f, 8.48595724e-02f, 8.03397596e-02f, 1.59897387e-01f,
  4.82659368e-03f, -6.81505501e-02f, -4.80628908e-02f, 9.68416929e-02f, -1.18095621e-01f, -1.58452272e-01f, -5.76165281e-02f, 2.83933971e-02f, -1.84536189e-01f, -2.94643641e-02f,
  -8.77474904e-01f, -7.19934165e-01f, -1.96532518e-01f, 2.81119235e-02f, 1.28772864e-02f, 1.13331126e-02f, 6.10642061e-02f, 1.50288418e-01f, -1.84854627e-01f, -1.23681888e-01f,
  3.21318470e-02f, 9.44893286e-02f, -1.08153604e-01f, 8.67424905e-02f, -3.58440988e-02f, -5.16823456e-02f, -1.13388754e-01f, -7.86299109e-02f, -1.49243757e-01f, -1.16494760e-01f,
  -1.85400504e-03f, -2.12127358e-01f, -9.69238728e-02f, 6.95771948e-02f, 4.06812467e-02f, 3.16174813e-02f, 5.17114811e-02f, 6.14069402e-02f, -3.12876403e-02f, -2.26445585e-01f,
  3.31439614e-01f, -5.73388398e-01f, -6.70680940e-01f, 1.98808029e-01f, 5.28826892e-01f, 3.57890904e-01f, -1.36589289e-01f, 2.30900034e-01f, -3.32128972e-01f, -2.52634943e-01f,
  1.98419541e-01f, -3.66574645e-01f, -6.31482363e-01f, 3.24882001e-01f, 3.34988028e-01f, -8.93742859e-01f, 2.96395749e-01f, 4.10844535e-02f, -1.58424005e-01f, 2.97607780e-01f,
  2.28952438e-01f, 7.31861532e-01f, -2.81355828e-01f, 4.31839079e-01f, 2.23938808e-01f, 1.89277068e-01f, 4.84387994e-01f, -2.19670057e-01f, 5.65015316e-01f, 1.81340128e-01f,
  1.74539760e-02f, -1.00133240e-01f, 2.70636398e-02f, -1.83184192e-01f, 1.07175857e-01f, 2.27085993e-01f, 1.14992969e-01f, 1.55266898e-03f, -4.65706252e-02f, -3.98326144e-02f,
  -6.34632111e-02f, 1.85024276e-01f, 7.28917792e-02f, 1.21331260e-01f, 5.85511923e-02f, 1.29796960e-03f, 2.48131193e-02f, -1.80776030e-01f, -1.06986620e-01f, 6.53440226e-03f,
  -1.85392797e-01f, -1.15067624e-01f, 7.74426684e-02f, -2.99942270e-02f, 1.78979256e-03f, 5.51947169e-02f, -2.91525014e-02f, 4.07085903e-02f, -3.68171860e-03f, 3.37424278e-02f,
  1.35047972e-01f, -1.36012524e-01f, -9.24018398e-02f, -1.65181682e-02f, 2.81546079e-02f, -3.83949988e-02f, -3.16457562e-02f, 3.68404761e-02f, -3.77560146e-02f, -6.14418834e-02f,
  -9.09118727e-03f, 4.31527048e-02f, -3.91406938e-02f, 8.17162469e-02f, -1.67934503e-02f, -8.15912932e-02f, -4.25235704e-02f, 6.27671033e-02f, 1.40811866e-02f, -2.11660676e-02f,
  -8.80297273e-03f, 9.15464829e-04f, -2.44258624e-02f, 8.39978158e-02f, 3.72442938e-02f, -1.04222586e-03f, 1.09150954e-01f, 1.71294641e-02f, -1.31960213e-01f, -3.07625066e-02f,
  8.63381848e-02f, -1.15090525e-02f, -7.79548436e-02f, -2.24727206e-02f, -1.15300991e-01f, 1.08330756e-01f, -1.86934754e-01f, 2.19622012e-02f, -1.15211651e-01f, -8.21675956e-02f,
  2.53965765e-01f, -1.01242408e-01f, 4.55095991e-02f, -3.86852375e-03f, 9.53987092e-02f, 6.22805096e-02f, -1.00395292e-01f, -1.90184843e-02f, 6.92687035e-02f, 3.89164425e-02f,
  7.11216480e-02f, 6.65077893e-03f, -2.91178674e-02f, -6.41952157e-02f, 7.81348348e-02f, -3.78548615e-02f, 1.06982991e-01f, 1.71764139e-02f, 6.67229742e-02f, -1.49857894e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 4)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 4;
const float L0_fan_Bp_bar_data[] = {
  7.49931514e-01f, 3.43471825e-01f, 6.17054820e-01f, 5.59895277e-01f
};

// L1_fan_Wp (Shape: 6 x 16)
const int L1_fan_Wp_rows = 6;
const int L1_fan_Wp_cols = 16;
const float L1_fan_Wp_data[] = {
  4.46149498e-01f, 5.74489683e-02f, -1.91843733e-01f, -5.36032379e-01f, -3.09177279e-01f, -3.16426635e-01f, 3.82836550e-01f, -9.25555900e-02f, 4.13120061e-01f, 3.33588123e-01f,
  -2.04231128e-01f, 4.06465322e-01f, -2.02997252e-01f, -2.83141553e-01f, 1.09502740e-01f, -4.34322178e-01f, 1.48157477e-01f, -1.86521098e-01f, -4.45082754e-01f, 4.06905055e-01f,
  3.75083208e-01f, 3.21100354e-02f, -3.19572091e-01f, 1.67450950e-01f, -6.07719958e-01f, -4.23350960e-01f, -5.92328429e-01f, -3.08891714e-01f, 2.37213165e-01f, -3.49094808e-01f,
  -1.42172471e-01f, 3.40911388e-01f, -1.58570588e-01f, -8.92298147e-02f, 4.34511393e-01f, -1.01304576e-01f, -3.74592930e-01f, -3.67393017e-01f, 5.87740600e-01f, -5.31791076e-02f,
  3.17178726e-01f, 7.47720420e-01f, -2.41111517e-01f, -1.02005792e+00f, -5.30266762e-02f, 1.50724366e-01f, 2.35450581e-01f, -9.75289047e-02f, 5.29864132e-01f, 3.64303291e-02f,
  4.23618615e-01f, -1.19943954e-01f, -1.60981759e-01f, -3.66478980e-01f, 5.84698975e-01f, 5.13825193e-02f, 4.71036494e-01f, -1.11787535e-01f, -7.55282581e-01f, -6.47578180e-01f,
  4.27184969e-01f, -1.43909037e-01f, -1.53216213e-01f, -2.68501848e-01f, -6.68114796e-02f, 3.03289831e-01f, -2.89672643e-01f, 5.74140064e-02f, -2.60200560e-01f, -5.39491812e-05f,
  -4.98572916e-01f, 2.36551926e-01f, -5.50917149e-01f, -1.44754007e-01f, 7.79548764e-01f, -2.14738593e-01f, -1.53903157e-01f, 2.43178368e-01f, 4.38386172e-01f, -2.64529318e-01f,
  -1.09561853e-01f, 4.20261055e-01f, 2.72037923e-01f, -4.15774256e-01f, -1.90108925e-01f, 3.84793252e-01f, 1.29938647e-01f, -3.82591575e-01f, 5.12912393e-01f, 3.46740693e-01f,
  2.05098569e-01f, 1.02818573e+00f, -2.59227842e-01f, 3.37335378e-01f, -1.67265907e-01f, -1.83768719e-01f
};

// L1_fan_Wp_bar (Shape: 4 x 16)
const int L1_fan_Wp_bar_rows = 4;
const int L1_fan_Wp_bar_cols = 16;
const float L1_fan_Wp_bar_data[] = {
  1.17249906e+00f, -4.32554185e-02f, 1.72406256e-01f, 2.34670058e-01f, -5.88565230e-01f, -1.56864274e+00f, -9.61725041e-02f, 1.58340144e+00f, 5.12860179e-01f, 4.53819156e-01f,
  -2.62956262e-01f, -1.72896767e+00f, 2.39259616e-01f, -5.50752699e-01f, 1.53412032e+00f, 5.07827759e-01f, 1.66754317e+00f, 5.17480969e-01f, -5.38765974e-02f, -1.03130033e-02f,
  -2.77404547e-01f, -2.15126216e-01f, -1.16951859e+00f, 7.23854661e-01f, 7.32939899e-01f, -1.90072989e+00f, 3.75504047e-01f, 1.41653895e+00f, 3.33518125e-02f, 6.89979851e-01f,
  8.30001116e-01f, -6.88310862e-01f, -1.37924448e-01f, 7.00764358e-01f, 1.56562769e+00f, -3.40778947e-01f, 7.46424794e-01f, 5.84758759e-01f, 1.17933214e+00f, 5.35215616e-01f,
  1.08022027e-01f, 1.44878912e+00f, 6.61009178e-02f, 3.65858227e-01f, 1.77129781e+00f, 1.21024013e+00f, 9.25007701e-01f, 1.75388873e-01f, -5.16837418e-01f, -3.42558891e-01f,
  -3.55607361e-01f, 7.51872241e-01f, -1.13581538e-01f, 4.89013284e-01f, -3.56323905e-02f, -1.47076237e+00f, 9.61123168e-01f, -3.00689876e-01f, 5.85423373e-02f, -4.83946711e-01f,
  -2.52811044e-01f, 1.36053801e+00f, 1.88897789e-01f, 1.70535743e+00f
};

// L1_fan_Bp_bar (Shape: 1 x 4)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 4;
const float L1_fan_Bp_bar_data[] = {
  2.52878785e-01f, 1.15218270e+00f, 4.38631028e-01f, 4.08299863e-01f
};

// L2_linear_W (Shape: 12 x 16)
const int L2_linear_W_rows = 12;
const int L2_linear_W_cols = 16;
const float L2_linear_W_data[] = {
  8.62943530e-01f, 6.09665811e-01f, 8.59999239e-01f, 9.72867668e-01f, 4.54269141e-01f, -5.56661300e-02f, 1.08593988e+00f, -9.86535966e-01f, -9.08092022e-01f, 1.28744292e+00f,
  -1.76196027e+00f, 1.04926217e+00f, -9.14850891e-01f, 1.05252624e+00f, -1.28986418e+00f, 3.63765210e-01f, -6.15271151e-01f, 6.57337844e-01f, 7.31641591e-01f, 9.34280872e-01f,
  -1.45135331e+00f, 5.95939636e-01f, -7.46452034e-01f, 8.54093194e-01f, -1.32154301e-01f, -1.13030887e+00f, -1.29594576e+00f, 1.05771899e+00f, -1.12818539e+00f, -1.74678040e+00f,
  4.33756337e-02f, 8.60576212e-01f, -6.00144446e-01f, -6.38750255e-01f, 5.34183323e-01f, 3.33270192e-01f, 9.82619300e-02f, -1.02098393e+00f, 8.84088516e-01f, 5.92196226e-01f,
  4.60722893e-01f, -6.56318247e-01f, 3.28369945e-01f, -2.86559522e-01f, 5.57347000e-01f, -9.11341488e-01f, -1.89130723e-01f, 4.88822818e-01f, 8.98800850e-01f, 8.91246140e-01f,
  -1.14972556e+00f, -9.24852729e-01f, -4.98395026e-01f, 5.89167595e-01f, -6.47704601e-01f, 3.38924915e-01f, -3.70160937e-01f, -1.44959915e+00f, 1.52728438e+00f, 1.09860599e+00f,
  -9.92639780e-01f, 1.12311494e+00f, -1.05203509e+00f, -1.57981539e+00f, -1.04065847e+00f, -4.99836475e-01f, 2.30397582e-01f, 6.08735323e-01f, 1.00627792e+00f, 7.43804097e-01f,
  -9.15911436e-01f, 1.46916819e+00f, -1.40323603e+00f, 1.20044947e+00f, -4.05535907e-01f, -1.02221549e+00f, -1.00003648e+00f, 3.77261043e-01f, 7.27888465e-01f, -1.19855320e+00f,
  9.15627003e-01f, 1.23802379e-01f, 6.83190286e-01f, 4.20069873e-01f, -2.04696674e-02f, -3.68205816e-01f, 2.50896066e-01f, -1.63187051e+00f, 1.78482234e+00f, 1.28770399e+00f,
  -1.28333545e+00f, 1.31034970e+00f, -1.65671086e+00f, -8.32596421e-01f, 9.70886469e-01f, -5.78951836e-01f, -9.76964653e-01f, 4.10718739e-01f, -1.27021384e+00f, -3.32754344e-01f,
  -2.33409956e-01f, 3.68127346e-01f, 3.99639457e-02f, -1.88178170e+00f, -4.13881540e-02f, 9.78664696e-01f, 1.79143310e+00f, -9.46153224e-01f, -2.04080239e-01f, -1.10867739e+00f,
  7.16858208e-01f, -4.38881256e-02f, 1.03953958e+00f, -1.56859439e-02f, 6.43712997e-01f, 9.38492656e-01f, 7.18114614e-01f, -4.47056174e-01f, 5.68285942e-01f, 9.59936976e-01f,
  1.07451451e+00f, 1.01997638e+00f, 1.03510535e+00f, -1.25841129e+00f, 1.18504250e+00f, 4.44156408e-01f, -1.57618749e+00f, -4.82958436e-01f, -1.04559684e+00f, -3.38945985e-01f,
  -3.48693728e-01f, -2.64740199e-01f, -5.02387822e-01f, -1.15314007e+00f, 8.79289329e-01f, -1.63210797e+00f, -1.61613524e-01f, -5.09364963e-01f, 2.42128521e-01f, -8.12024921e-02f,
  -8.86579037e-01f, 5.03431737e-01f, -2.44498253e-01f, 6.97771609e-01f, 4.86778378e-01f, 4.64630902e-01f, -4.00083631e-01f, -1.03690445e+00f, -1.21234484e-01f, -4.33790624e-01f,
  -5.93372464e-01f, 1.39750183e+00f, 1.04809093e+00f, -4.44876313e-01f, -1.33932734e+00f, -5.27579188e-01f, 7.75558949e-01f, -1.74131477e+00f, 4.36212063e-01f, -1.08578312e+00f,
  -1.22893322e+00f, -5.42176843e-01f, -3.06919605e-01f, -1.21056736e+00f, 1.26606977e+00f, 8.10469329e-01f, -7.01050639e-01f, 1.34600496e+00f, -1.23389399e+00f, -8.49130630e-01f,
  1.57172084e+00f, -5.82411289e-01f, -9.68545675e-01f, -7.83262551e-01f, -1.62038052e+00f, 8.44598591e-01f, 6.28828287e-01f, -6.57927215e-01f, 5.38342774e-01f, 4.75352019e-01f,
  -5.66651344e-01f, 3.64099085e-01f, 9.47380543e-01f, -1.39805567e+00f, 5.28099120e-01f, -1.23079753e+00f, 7.86968648e-01f, 1.15618289e-01f, 3.55265588e-01f, 4.71045196e-01f,
  2.38528192e-01f, -1.20455277e+00f
};

// L2_linear_B (Shape: 1 x 12)
const int L2_linear_B_rows = 1;
const int L2_linear_B_cols = 12;
const float L2_linear_B_data[] = {
  1.36958510e-01f, -2.14864939e-01f, -7.67112434e-01f, 5.55450857e-01f, 2.48147830e-01f, 8.26607943e-02f, -7.77999759e-01f, 5.03481269e-01f, -4.55418259e-01f, 1.28036793e-02f,
  6.46660984e-01f, -6.40205026e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 6, 4
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        16, 6, 4
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_linear
    linear_forward_pgm(
        buffer1, x_out,
        L2_linear_W_data, L2_linear_B_data,
        16, 12
    );
    }
    