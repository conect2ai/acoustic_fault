/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 64 (x4)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 64;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    float x3 = x * x * x;
    return 0.5f * x * (1.0f + tanhf(0.79788456f * (x + 0.044715f * x3)));
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 19 x 120)
const int L0_fan_Wp_rows = 19;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  2.52177119e-01f, -5.70801012e-02f, 1.28086075e-01f, 5.52211255e-02f, -2.02095404e-01f, -1.19474225e-01f, -2.80845016e-01f, -1.87330656e-02f, -3.42219993e-02f, -1.03039876e-01f,
  8.30705557e-03f, 6.27210513e-02f, 1.49671718e-01f, -2.55909171e-02f, 1.36446074e-01f, -1.08317561e-01f, -3.07980239e-01f, 1.40093580e-01f, 2.28864253e-01f, -1.79811209e-01f,
  -1.59377471e-01f, -7.37431198e-02f, 2.77947355e-02f, -3.32475193e-02f, -2.87532687e-01f, -1.96209103e-01f, -2.67846286e-01f, -2.82203346e-01f, -2.53813833e-01f, -4.95600224e-01f,
  -9.91036296e-02f, 3.15885618e-02f, -1.38022661e-01f, -1.12055197e-01f, -1.18133076e-01f, -7.90235400e-02f, -5.98834641e-02f, -5.14279790e-02f, -1.17462233e-01f, -1.09844252e-01f,
  -8.35584179e-02f, -3.75703536e-02f, 1.26368343e-03f, 5.33851683e-02f, -3.26712392e-02f, -1.80301648e-02f, 3.83594423e-03f, 7.35175386e-02f, -9.01770443e-02f, -9.15186107e-02f,
  -1.88288793e-01f, -4.23225388e-02f, 6.26858398e-02f, -1.11278363e-01f, 1.81857403e-02f, -5.27679063e-02f, -1.03019103e-01f, -1.14946365e-01f, -9.29419994e-02f, -1.92320600e-01f,
  -4.78916429e-02f, 1.34680644e-01f, 6.33321404e-02f, -7.44942129e-02f, 7.85147250e-02f, -1.14138909e-02f, -5.70418127e-02f, -6.05997723e-03f, 4.84425388e-02f, 1.17219925e-01f,
  1.99828073e-02f, 1.24173937e-02f, -3.16489562e-02f, -4.72810119e-02f, 6.99545071e-02f, 2.00681798e-02f, 6.51817024e-02f, -5.61728841e-03f, 1.32115334e-02f, 2.94263903e-02f,
  2.84445509e-02f, -4.02236953e-02f, 1.81867909e-02f, -1.69809982e-02f, 6.29592538e-02f, 4.85315770e-02f, 9.15790573e-02f, 1.38561800e-01f, 1.48689762e-01f, 2.63396725e-02f,
  -6.21115752e-02f, -8.82903934e-02f, -5.44138476e-02f, -8.93858597e-02f, -1.26430094e-01f, -3.83588932e-02f, -6.58880621e-02f, -1.34940639e-01f, -8.08243733e-03f, -6.35762811e-02f,
  -1.78025346e-02f, -8.69654939e-02f, -5.55852577e-02f, -6.73134997e-02f, -1.56115100e-01f, -1.16410755e-01f, -1.11049578e-01f, -1.21315181e-01f, -1.73153147e-01f, -4.63793315e-02f,
  -7.14066029e-02f, -1.04127578e-01f, -8.27463865e-02f, -1.24824725e-01f, -9.47566330e-02f, -8.34917426e-02f, -1.37350082e-01f, -1.80100322e-01f, 4.31443043e-02f, -2.44063884e-01f,
  4.99363810e-01f, 6.96845502e-02f, 4.45505604e-02f, 3.69273514e-01f, 2.93876171e-01f, 5.28437905e-02f, 1.16651952e-02f, -5.68848923e-02f, 7.95368031e-02f, -1.10087758e-02f,
  3.39052640e-02f, 1.67227596e-01f, 2.69532744e-02f, -4.46169972e-02f, -8.86759162e-02f, -1.28984377e-01f, 5.15432283e-02f, 1.10614203e-01f, 1.27549358e-02f, 1.17260210e-01f,
  1.52524129e-01f, 3.11167389e-01f, 2.48020366e-01f, 4.73496541e-02f, 1.86422855e-01f, 4.26266789e-02f, -9.15356427e-02f, 1.17167138e-01f, -6.17868416e-02f, 2.23466903e-01f,
  6.33327290e-02f, 9.75212157e-02f, -3.08010001e-02f, 1.17543913e-01f, 9.10753980e-02f, 8.31068978e-02f, 3.49173248e-02f, 6.88431412e-02f, 5.92653602e-02f, 1.96705703e-02f,
  6.92958981e-02f, 6.27032369e-02f, 3.55427340e-02f, 4.49452624e-02f, 1.73074864e-02f, 7.63741136e-02f, -8.56419951e-02f, 2.27659903e-02f, -1.21038249e-02f, -3.67697924e-02f,
  2.83156689e-02f, 2.13606656e-02f, 3.82286198e-02f, -4.37740684e-02f, -2.59249844e-02f, 9.41682160e-02f, -1.24419726e-01f, 6.62991824e-03f, -1.17836125e-01f, 8.56566522e-03f,
  1.07438147e-01f, -4.39108871e-02f, -8.58632848e-02f, 6.61721360e-03f, -9.18867812e-02f, -9.56469402e-02f, -3.53571735e-02f, -7.42034428e-03f, -5.25212996e-02f, -6.30556569e-02f,
  -7.48055875e-02f, -3.67342122e-03f, 2.97185453e-03f, -6.90242574e-02f, -6.39396533e-02f, 4.24101911e-02f, -9.39395744e-03f, -2.13988088e-02f, -5.26214726e-02f, -2.44696941e-02f,
  9.65256393e-02f, 4.30181921e-02f, 1.32502064e-01f, -9.56820473e-02f, -9.39552113e-02f, 1.69092026e-02f, 3.82546037e-02f, 9.12369636e-04f, -3.27285863e-02f, 5.62786907e-02f,
  -3.87026817e-02f, -1.73033208e-01f, 6.75961748e-02f, -5.97413145e-02f, -4.06178571e-02f, -4.77097258e-02f, 6.50930498e-03f, -5.07484227e-02f, 1.77664384e-01f, 6.52286187e-02f,
  8.30989517e-03f, -6.09649979e-02f, -3.29259261e-02f, 1.64468959e-02f, -9.02516842e-02f, -3.11191212e-02f, 3.54890600e-02f, 5.09434082e-02f, -6.08753450e-02f, -1.11669721e-02f,
  -1.58854768e-01f, -9.63899940e-02f, -1.04076341e-01f, -7.89686665e-02f, -1.11491464e-01f, 9.51621234e-02f, 5.73893823e-03f, -1.24361008e-01f, -5.89285009e-02f, -1.22883692e-01f,
  -9.27473381e-02f, -2.80752691e-04f, -3.12099695e-01f, -1.91698506e-01f, -2.72770524e-01f, -2.71679938e-01f, -3.38670284e-01f, -1.91512972e-01f, -8.80462378e-02f, -1.08256780e-01f,
  -7.96103477e-03f, 7.57623045e-03f, 3.88791263e-02f, 5.23631275e-02f, -1.71584785e-01f, -3.69594067e-01f, -3.44756335e-01f, -3.16658288e-01f, -1.46893248e-01f, -4.90764566e-02f,
  1.53261665e-02f, -8.76103863e-02f, 8.31186473e-02f, 1.52045228e-02f, 1.36027798e-01f, 6.31246567e-02f, -7.00126812e-02f, -1.49520440e-02f, 1.12403251e-01f, 1.08301625e-01f,
  5.99171594e-02f, -7.23878741e-02f, 2.61246208e-02f, 1.89306382e-02f, -1.52599299e-02f, -9.20422673e-02f, -1.68051682e-02f, -7.05154389e-02f, 2.15987209e-02f, -8.15025941e-02f,
  -8.13536644e-02f, -7.22391382e-02f, -4.37802784e-02f, 1.00252599e-01f, 3.12490761e-02f, -4.03103977e-02f, -1.05069093e-01f, -1.70955673e-01f, -1.15532883e-01f, -1.09915785e-01f,
  -3.47151421e-02f, -6.55944124e-02f, -1.15090251e-01f, -8.68617743e-02f, -3.50438803e-02f, 5.22338226e-02f, 7.42322719e-03f, 5.70694245e-02f, 2.57295128e-02f, -2.20199060e-02f,
  6.79875142e-04f, -4.54255529e-02f, -7.86891207e-02f, -2.96420585e-02f, 2.69143097e-03f, 4.64528613e-03f, -6.79740384e-02f, -5.57253845e-02f, 3.15022655e-02f, -5.48696183e-02f,
  -7.90271237e-02f, -2.41130777e-02f, -6.96028247e-02f, -1.14475913e-01f, 3.61345857e-02f, -3.13532539e-03f, -5.29967956e-02f, 3.50579084e-03f, 2.05255337e-02f, -2.08948981e-02f,
  3.76992561e-02f, 5.86965419e-02f, -7.50300214e-02f, 1.48856482e-02f, -3.98179069e-02f, 2.50252448e-02f, 5.20570613e-02f, -4.96971048e-02f, 7.50735030e-02f, -1.24290111e-02f,
  9.03333575e-02f, -1.05649024e-01f, -5.48776351e-02f, -4.38364483e-02f, -1.50527865e-01f, -4.77420427e-02f, 5.90991117e-02f, -5.56128584e-02f, -6.01893924e-02f, 1.61592383e-04f,
  5.50155006e-02f, -6.20989054e-02f, 3.33005935e-02f, 8.12174007e-02f, 7.24813491e-02f, -1.51381753e-02f, -2.67223530e-02f, 6.51991665e-02f, 6.24090247e-02f, 1.15853935e-01f,
  6.99603260e-02f, -7.15184137e-02f, -8.78732204e-02f, 3.78685817e-02f, -2.35582031e-02f, -4.76115644e-02f, 1.02843009e-01f, -1.82832554e-02f, -1.66982338e-02f, -9.37804505e-02f,
  -9.29602757e-02f, -9.56198797e-02f, 1.07223719e-01f, 1.74195413e-02f, 5.33995777e-02f, -4.76212204e-02f, 4.19029854e-02f, -2.16725748e-02f, 3.18900384e-02f, 1.54752105e-01f,
  1.98126331e-01f, 8.99797976e-02f, 1.25582799e-01f, 2.30908260e-01f, 3.63556236e-01f, 2.85371184e-01f, 2.67031193e-01f, 3.21669757e-01f, 2.60766208e-01f, 1.24120615e-01f,
  -8.86466801e-02f, 8.28117952e-02f, 9.88039076e-02f, -1.05675183e-01f, -1.11471474e-01f, 4.92783189e-02f, -1.49135187e-04f, -3.91931310e-02f, 3.98058211e-03f, -4.63241674e-02f,
  2.46378466e-01f, -4.44540344e-02f, -4.83631082e-02f, -1.36108370e-02f, -1.22887217e-01f, -1.61983352e-03f, 1.70271955e-02f, -1.53200507e-01f, -1.22603439e-01f, 6.90143034e-02f,
  -2.25378666e-02f, 1.00538336e-01f, 6.09435001e-03f, -2.87956521e-02f, 9.26423296e-02f, 1.74643788e-02f, 3.11145489e-03f, 7.28039518e-02f, -7.81906769e-02f, -6.41709417e-02f,
  -4.53840643e-02f, 8.40167850e-02f, 1.07495390e-01f, -9.39323530e-02f, 3.34534459e-02f, -1.82639062e-02f, -1.76114440e-01f, -6.50664270e-02f, -8.38756189e-02f, -1.08090483e-01f,
  3.59668187e-03f, 1.18660694e-02f, -8.51098597e-02f, -4.11049314e-02f, 4.91165780e-02f, -5.86371906e-02f, 6.01956360e-02f, 3.15090120e-02f, -4.61063497e-02f, -1.25435339e-02f,
  -5.47888875e-02f, -6.84019625e-02f, -3.63363209e-03f, 2.39143316e-02f, -8.33921209e-02f, 3.30706313e-02f, 2.14485731e-02f, -7.05773011e-02f, -7.78255090e-02f, 5.14982908e-04f,
  6.51972741e-02f, 3.49684916e-02f, 5.17844036e-02f, -5.06272390e-02f, 6.79366738e-02f, 6.65753800e-03f, 7.47503117e-02f, 7.70978481e-02f, -7.30013289e-03f, 5.79235703e-02f,
  1.06559023e-01f, -4.62356806e-02f, 7.45655522e-02f, 6.09969720e-02f, 2.43779160e-02f, -1.06807247e-01f, -3.06787901e-02f, -3.87096070e-02f, 1.45060588e-02f, 3.27780880e-02f,
  7.67589957e-02f, 3.05017326e-02f, 1.31621584e-02f, -1.07421272e-01f, -7.38160044e-04f, 1.51720596e-02f, 1.45372506e-02f, 1.98639184e-02f, -9.03464109e-02f, -1.22386329e-01f,
  -8.54163337e-03f, 1.16491020e-01f, 4.98074479e-02f, 2.29076501e-02f, -5.41480407e-02f, 1.01280145e-01f, 4.32972461e-02f, 4.94583659e-02f, 1.25658855e-01f, -6.55416548e-02f,
  4.43467289e-01f, 1.35570541e-01f, -7.29346722e-02f, 1.40362531e-01f, 1.31441548e-01f, 1.81682426e-02f, 1.10499330e-01f, -5.87958731e-02f, -8.80864114e-02f, 3.99351977e-02f,
  -1.79541588e-01f, -2.74728328e-01f, -3.04221094e-01f, -2.88993686e-01f, -1.31087005e-01f, 2.17921734e-02f, -5.14762700e-02f, -5.47319278e-02f, -1.17851987e-01f, 3.03646363e-02f,
  2.87879445e-02f, 9.22497287e-02f, 8.98900107e-02f, -1.16992174e-02f, 8.16343725e-02f, -8.58935341e-02f, -1.25171229e-01f, 9.71162915e-02f, -9.91631821e-02f, 1.82476237e-01f,
  5.75639606e-02f, 6.46060556e-02f, -1.32145643e-01f, -7.73423463e-02f, 3.58718261e-02f, -2.55764113e-03f, 2.84277909e-02f, -8.86911824e-02f, -2.31686700e-02f, -1.36590339e-02f,
  -7.41480812e-02f, -9.10193622e-02f, -5.85747771e-02f, -3.03443335e-02f, 6.80722520e-02f, -4.67512757e-02f, -9.77497399e-02f, -1.55032247e-01f, -6.71172142e-02f, -1.06684975e-01f,
  -1.07128188e-01f, 1.17159583e-01f, 7.11656287e-02f, -2.42014173e-02f, -3.24709229e-02f, -6.00795038e-02f, -8.45569894e-02f, 6.82692900e-02f, -3.53612863e-02f, 2.44877283e-02f,
  -1.17131911e-01f, -3.70125249e-02f, 5.21302782e-02f, -8.31806287e-02f, -8.84748846e-02f, -9.10646543e-02f, 3.02369501e-02f, -4.94149551e-02f, -1.87066458e-02f, 4.95270863e-02f,
  -9.33298692e-02f, 9.43560675e-02f, 1.70886815e-02f, -5.07890321e-02f, 3.56148137e-03f, 4.09365185e-02f, 3.53757106e-02f, -7.20839351e-02f, -1.10503435e-01f, -7.65511468e-02f,
  -2.29200404e-02f, 1.13312870e-01f, -8.31928253e-02f, -8.43403414e-02f, 2.90909950e-02f, -1.32427237e-03f, 1.21304495e-02f, -1.03272237e-01f, 3.58625352e-02f, 6.08229376e-02f,
  -2.27190435e-01f, -1.82356074e-01f, -5.23955859e-02f, -2.24936046e-02f, 8.58467370e-02f, -4.14743647e-03f, -8.95203743e-03f, 3.70127223e-02f, -8.24973509e-02f, 5.49315363e-02f,
  5.65892234e-02f, 5.12753148e-03f, -6.65025115e-02f, -2.60905270e-02f, -6.71362225e-03f, -9.58626345e-03f, -1.26069129e-01f, -5.67740910e-02f, -3.56094576e-02f, 4.67372984e-02f,
  -5.68919629e-02f, -5.07117100e-02f, -3.01486813e-02f, -1.26199186e-01f, -1.03619341e-02f, -1.13060355e-01f, -5.20355105e-02f, -1.88117698e-02f, -1.48775727e-01f, -1.17300414e-01f,
  -2.01998919e-01f, -2.30354756e-01f, 8.62113163e-02f, -6.83747306e-02f, 1.44254550e-01f, 1.71090156e-01f, 2.25743935e-01f, 8.42709392e-02f, -3.23260613e-02f, -1.00737289e-01f,
  -1.53624684e-01f, -1.65205926e-01f, -3.19819376e-02f, -5.03619481e-03f, 1.08992390e-01f, 2.52941549e-01f, 3.00073564e-01f, 1.54017955e-01f, 2.89120674e-01f, 1.06353030e-01f,
  -1.69556588e-02f, -5.78662306e-02f, -2.36812577e-01f, -1.13792315e-01f, 6.46388903e-03f, -1.21305697e-02f, -1.24790870e-01f, -1.24355219e-03f, -6.02003885e-03f, 1.33660749e-01f,
  -9.15309340e-02f, -9.13907662e-02f, 2.28885889e-01f, 3.47522600e-03f, -7.16020241e-02f, 1.74249262e-02f, 1.18115000e-01f, 1.91054177e-02f, 2.36031804e-02f, -8.57201777e-03f,
  -3.69434580e-02f, 6.65651867e-03f, 9.57499221e-02f, -1.39990196e-01f, -6.86553940e-02f, 4.03398126e-02f, 3.63166444e-02f, -1.44253289e-02f, -1.02322251e-01f, -5.99774942e-02f,
  7.98113719e-02f, 1.23907566e-01f, 8.99286196e-02f, 9.72351339e-03f, 3.37179489e-02f, 1.18363455e-01f, 8.45241733e-03f, 1.75052471e-02f, -3.33058350e-02f, -2.82339193e-02f,
  -5.11001535e-02f, -8.06885436e-02f, -4.03182544e-02f, 2.87782727e-03f, 4.33519632e-02f, -3.32923420e-02f, -3.46430540e-02f, 3.47893983e-02f, 8.61564651e-02f, -5.60600720e-02f,
  -4.34513986e-02f, -7.45274173e-03f, -6.77725151e-02f, 6.89382106e-02f, -9.65889096e-02f, -2.47470234e-02f, 7.83722401e-02f, -4.33924654e-03f, -7.96717033e-02f, -3.86219448e-03f,
  2.11816803e-02f, 7.24431127e-02f, -2.52859183e-02f, 2.01506671e-02f, 1.00207552e-01f, 1.00258864e-01f, 9.87593383e-02f, 1.84147265e-02f, 3.75607535e-02f, 1.43367043e-02f,
  -5.04155159e-02f, 1.44626930e-01f, 1.78398311e-01f, -1.72796976e-02f, -1.34470058e-03f, -9.77394953e-02f, 2.23268438e-02f, 7.05149472e-02f, -8.11458915e-04f, 1.44558862e-01f,
  5.59972897e-02f, -4.85240258e-02f, -7.02932328e-02f, -2.90586501e-02f, 7.42679536e-02f, 5.93417622e-02f, -3.71734686e-02f, 6.64024577e-02f, -7.15839537e-03f, -4.09866199e-02f,
  -4.17272886e-03f, 4.10989411e-02f, 1.33504808e-01f, 1.10240489e-01f, 9.10808519e-02f, 1.47961274e-01f, 1.45024672e-01f, 1.24784887e-01f, 2.25150749e-01f, 5.00504002e-02f,
  -1.14015527e-02f, -1.82604164e-01f, -4.14781347e-02f, 2.10453793e-02f, 6.51124306e-03f, 6.76123947e-02f, 1.81031406e-01f, 4.51797247e-03f, 2.27353582e-03f, -2.35006474e-02f,
  -2.88994163e-02f, 1.34009505e-02f, 1.21088522e-02f, -3.12149581e-02f, 1.10808432e-01f, -1.15716737e-02f, -4.10215259e-02f, -3.17294300e-02f, 2.39347160e-01f, 2.97693834e-02f,
  2.96109784e-02f, -2.35224217e-02f, 2.11457983e-02f, -4.91581149e-02f, -1.15439035e-01f, 1.71445310e-02f, -1.32980555e-01f, -1.81560874e-01f, -9.51399282e-02f, -1.70939431e-01f,
  1.62732840e-01f, -2.09642321e-01f, 8.05947632e-02f, 3.12968455e-02f, -8.49501416e-03f, -1.13017976e-01f, -8.45446158e-03f, -1.84532274e-02f, 9.39256512e-03f, 1.72736663e-02f,
  -4.47162166e-02f, -1.11477617e-02f, 6.11541867e-02f, 7.01226352e-04f, 1.30241483e-01f, -3.65317725e-02f, 1.59891751e-02f, -9.77130532e-02f, 7.70417303e-02f, -7.48926625e-02f,
  -1.77085679e-02f, 4.61873189e-02f, 2.67240424e-02f, -7.18285004e-03f, 1.95420664e-02f, -1.86896864e-02f, -7.09815472e-02f, -7.80413747e-02f, 2.71305116e-03f, 2.75428724e-02f,
  1.04288146e-01f, -1.42771438e-01f, -4.08602543e-02f, -1.13362491e-01f, 7.53361657e-02f, 5.71413077e-02f, -5.92890428e-03f, 9.70140621e-02f, 1.68389138e-02f, -1.07684605e-01f,
  -7.70360678e-02f, 1.95785034e-02f, -1.41882701e-02f, -1.41452178e-02f, 3.65778469e-02f, -1.22941233e-01f, -1.69004891e-02f, -1.11332051e-01f, -2.78952364e-02f, 4.54905890e-02f,
  -1.46975303e-02f, 2.64251046e-02f, -8.14767089e-03f, 6.98552839e-03f, -1.69942066e-01f, -5.69622777e-02f, -9.54836085e-02f, -4.11328487e-02f, -6.34630471e-02f, -3.78115699e-02f,
  4.53042805e-01f, 8.46657064e-03f, 2.74278857e-02f, -6.51914859e-03f, 5.95522113e-02f, -7.52372434e-03f, 4.64841770e-03f, -5.60190380e-02f, -1.42899994e-02f, -1.40208087e-03f,
  1.08313346e-02f, -3.64372469e-02f, -2.51974370e-02f, -7.48169050e-03f, 1.48522377e-01f, 1.15718553e-02f, 6.69938549e-02f, 2.12022498e-01f, 9.83526707e-02f, 6.84135929e-02f,
  5.27068451e-02f, 2.52343178e-01f, 3.00950140e-01f, 1.57865360e-02f, 7.07053244e-02f, 1.69278517e-01f, 1.74706623e-01f, 8.59058574e-02f, 2.08344296e-01f, 1.82513237e-01f,
  3.20039779e-01f, 1.29180729e-01f, -2.05228049e-02f, 4.27446276e-01f, 2.26511329e-01f, 2.46184379e-01f, 1.52676061e-01f, 1.82287589e-01f, 2.86201276e-02f, 1.70119703e-01f,
  1.63526878e-01f, 3.30101289e-02f, 3.64649780e-02f, 1.91563200e-02f, 2.25890186e-02f, 1.61559373e-01f, 9.21099260e-03f, -5.98394163e-02f, -2.30991021e-02f, -4.45950329e-02f,
  2.66018566e-02f, -1.40387388e-02f, -2.01268438e-02f, -3.12289260e-02f, 3.84922028e-02f, -6.18959144e-02f, -7.81937316e-02f, 3.99166644e-02f, -8.99469778e-02f, -1.96291864e-01f,
  1.76194444e-01f, -2.53120717e-03f, -2.19325162e-02f, 5.68817258e-02f, 4.42818664e-02f, -1.17644735e-01f, 2.90904772e-02f, -1.68058515e-01f, -1.81371570e-02f, -1.20416023e-01f,
  8.50927234e-02f, -9.56913978e-02f, -5.52558415e-02f, -1.77835375e-01f, -1.18098287e-02f, -6.44028485e-02f, -4.93763648e-02f, -1.46322027e-01f, 6.43782085e-03f, -1.83779877e-02f,
  1.11766614e-01f, -9.09726769e-02f, 2.36273110e-02f, 6.11552186e-02f, 2.13344116e-02f, -6.47618324e-02f, -9.25687253e-02f, -1.60696387e-01f, -7.50195086e-02f, -1.66433468e-01f,
  -3.56520712e-02f, 7.04002082e-02f, -6.87142089e-02f, -5.73336631e-02f, 9.28636119e-02f, -2.47665327e-02f, -5.24542201e-03f, 6.81483597e-02f, 5.91312982e-02f, -8.00546706e-02f,
  -2.11306456e-02f, 8.31803679e-02f, 3.63829210e-02f, 1.67355254e-01f, 1.63832873e-01f, -2.45645680e-02f, 3.99283320e-02f, 1.86548457e-02f, -6.70470521e-02f, -2.97689624e-02f,
  -6.94490522e-02f, -6.08247779e-02f, -1.53200716e-01f, -1.70731276e-01f, -1.13459706e-01f, -8.31710547e-02f, -6.39794767e-02f, 1.87324733e-02f, -2.20070556e-02f, -1.11165576e-01f,
  2.46203154e-01f, -1.33649290e-01f, -6.92656785e-02f, 1.71993617e-02f, -2.72479709e-02f, -1.77025720e-01f, 1.64161533e-01f, 2.10452508e-02f, -1.08080041e-02f, -5.06443419e-02f,
  4.71739471e-02f, 1.40458047e-01f, -4.38389517e-02f, 1.73015278e-02f, 9.60730657e-04f, 6.83196113e-02f, -3.83972339e-02f, -1.88048519e-02f, 6.65650070e-02f, -2.79163178e-02f,
  4.84189503e-02f, 3.30814980e-02f, 3.80730443e-02f, 4.03378382e-02f, 2.83485614e-02f, 1.60175741e-01f, -2.61474513e-02f, 8.56391340e-02f, -6.93566576e-02f, 1.25048906e-02f,
  -4.82707620e-02f, -2.54588723e-01f, 1.99161261e-01f, -5.35325669e-02f, -6.17371984e-02f, 1.08864352e-01f, -6.89378008e-02f, 8.95255134e-02f, -2.58231233e-03f, -8.73862132e-02f,
  5.54691851e-02f, 1.65752441e-01f, 5.57468608e-02f, 1.54699907e-01f, 6.09342232e-02f, 8.06470774e-03f, -5.47666289e-02f, 1.27357736e-01f, 2.76046097e-01f, 2.73640841e-01f,
  4.35502864e-02f, 2.12027822e-02f, 1.32093564e-01f, 1.06378183e-01f, -1.43045366e-01f, 1.69341922e-01f, 3.67284194e-02f, -7.29708970e-02f, 1.29626552e-02f, -1.22975633e-01f,
  9.21699926e-02f, -1.15191638e-01f, -1.96747482e-03f, -9.33943838e-02f, 1.82151571e-02f, -1.69577509e-01f, -3.64051424e-02f, -8.11453760e-02f, -1.39884040e-01f, -1.04429901e-01f,
  -9.23806988e-03f, 5.78703498e-03f, -5.37914131e-03f, -1.64692886e-02f, -6.88057169e-02f, 5.49944583e-03f, -4.42960821e-02f, -2.17528157e-02f, 1.29476085e-01f, -2.31555998e-02f,
  -1.55124500e-01f, -1.28260329e-02f, 1.12168910e-02f, 6.77347928e-02f, 6.41762018e-02f, 3.58347036e-02f, 4.54071872e-02f, 2.42356528e-02f, 1.43845767e-01f, -6.50714338e-02f,
  5.62224984e-02f, 1.19731195e-01f, 1.75918534e-01f, 1.18452840e-01f, 7.22619984e-03f, 5.26417308e-02f, 3.31144524e-03f, 1.82965860e-01f, 1.35806352e-01f, -5.36122248e-02f,
  9.18879062e-02f, 3.33119892e-02f, 8.64447579e-02f, -2.92435866e-02f, -5.08343764e-02f, 8.57975930e-02f, 4.06621471e-02f, -4.99359369e-02f, -3.05294432e-02f, 5.13386875e-02f,
  8.66971761e-02f, 6.86608553e-02f, 3.77318226e-02f, -2.96260752e-02f, -4.19874750e-02f, 2.15557106e-02f, 5.39689250e-02f, 5.10538816e-02f, 6.37705401e-02f, 1.10905044e-01f,
  -3.04075927e-02f, -1.07925422e-02f, -1.20750405e-01f, -8.29492286e-02f, 3.82037461e-02f, -7.30938092e-02f, -8.13623145e-02f, -1.10696614e-01f, -1.27536908e-01f, -1.51637867e-01f,
  5.72770648e-03f, -1.20055467e-01f, -3.89805324e-02f, 1.11716934e-01f, -5.93599826e-02f, 4.07921057e-03f, -1.39302209e-01f, -5.10055609e-02f, -4.32036556e-02f, 1.03735346e-02f,
  -1.50180548e-01f, -2.82221427e-03f, 1.50581256e-01f, 3.11905891e-02f, 3.10333129e-02f, 1.58273056e-01f, 1.07801937e-01f, 2.17361748e-02f, 1.36415094e-01f, -5.44995889e-02f,
  -2.00566784e-01f, -5.21741882e-02f, -2.12998599e-01f, 1.12627499e-01f, 1.43215999e-01f, 4.52565309e-03f, -9.35444534e-02f, -3.48427035e-02f, 1.68108016e-01f, 1.50391385e-01f,
  2.10990846e-01f, 1.07903808e-01f, 6.05654642e-02f, 1.31920531e-01f, -4.14757878e-02f, -4.13696058e-02f, -4.63206833e-03f, -2.29911387e-01f, -2.29499549e-01f, 2.87478752e-02f,
  2.99281836e-01f, 5.74771985e-02f, -1.48467138e-01f, -8.51258822e-03f, 1.70600787e-01f, 1.27827466e-01f, 2.35585729e-03f, 1.71735302e-01f, 1.85545504e-01f, 1.10312022e-01f,
  -1.41034454e-01f, -1.79797426e-01f, -7.47398436e-02f, 5.75902425e-02f, -5.27915917e-03f, -7.06185699e-02f, 3.10027115e-02f, -5.06191812e-02f, -9.28151608e-02f, -1.28256306e-01f,
  1.19188540e-01f, -4.55557518e-02f, 7.21547902e-02f, 1.78618282e-02f, -1.25180855e-01f, 4.30914052e-02f, -7.59176090e-02f, -1.19585162e-02f, -1.32251695e-01f, -2.06787288e-02f,
  1.83725432e-01f, 1.37444019e-01f, -1.76536977e-01f, 6.78120181e-02f, -8.41935165e-03f, -6.62685558e-02f, 5.09042479e-02f, 8.24542493e-02f, -1.20525844e-01f, 1.05584070e-01f,
  -1.31429911e-01f, -3.11037172e-02f, -1.58490669e-02f, 3.00119678e-03f, 3.68246138e-02f, 1.77071001e-02f, -5.32871671e-02f, 2.88769472e-02f, 1.03012033e-01f, 1.35524487e-02f,
  -9.28981788e-03f, -7.75953159e-02f, -1.68395899e-02f, -2.47890409e-02f, 1.33110344e-01f, 7.54349157e-02f, 4.00251560e-02f, 1.12849869e-01f, 1.12850733e-01f, -1.97704993e-02f,
  5.32033257e-02f, 3.96402664e-02f, 3.73184383e-02f, -1.21878227e-02f, 7.65061453e-02f, 3.13032046e-02f, 5.56700081e-02f, 7.29986131e-02f, -2.65681967e-02f, -2.82201041e-02f,
  -9.54874530e-02f, -2.47212928e-02f, -8.97666365e-02f, -1.49810687e-01f, 2.80918404e-02f, 6.05794974e-03f, 1.32524803e-01f, 6.81837788e-03f, -4.16606814e-02f, -7.17183128e-02f,
  1.36012971e-01f, 1.04204051e-01f, 5.49382269e-02f, -5.02741784e-02f, -9.11417902e-02f, 5.44012822e-02f, 5.89700229e-02f, -4.93679605e-02f, -2.45535802e-02f, 6.74441981e-04f,
  6.21054210e-02f, -1.52574787e-02f, -3.61729972e-02f, -4.99228276e-02f, -1.14047574e-02f, -1.06050722e-01f, 5.88390566e-02f, 2.71897055e-02f, -1.33437455e-01f, 1.08915716e-01f,
  -1.05446637e-01f, 6.28854334e-02f, -1.32220045e-01f, -2.00733185e-01f, -9.14040208e-02f, 1.81832984e-02f, 1.45084843e-01f, 2.72745229e-02f, -4.34322879e-02f, -7.43182525e-02f,
  7.37059489e-02f, 1.00917473e-01f, 4.08473834e-02f, -8.41760486e-02f, -7.50917569e-02f, -1.38648674e-01f, -3.03126842e-01f, -1.56127363e-01f, 4.26038466e-02f, 8.44040290e-02f,
  -5.74075766e-02f, -5.12509756e-02f, -1.65269643e-01f, -6.38242811e-02f, -4.97930795e-02f, 8.30515176e-02f, -7.96929970e-02f, -5.14129102e-02f, 6.41395757e-03f, -2.39445895e-01f,
  2.16883700e-02f, -1.48423225e-01f, 4.50578295e-02f, -5.70591986e-02f, -2.70269252e-02f, 5.51526397e-02f, 4.41162195e-03f, -1.16670296e-01f, -5.49284630e-02f, -1.09646589e-01f,
  -9.79256704e-02f, -3.88704464e-02f, -5.31611070e-02f, -1.03472717e-01f, -9.99737829e-02f, -5.60665168e-02f, -1.93920597e-01f, -1.91418305e-01f, -5.75836077e-02f, -6.42091632e-02f,
  -2.17727169e-01f, -3.80462967e-02f, 1.00747580e-02f, -3.64748910e-02f, -5.25294691e-02f, -6.55770972e-02f, -8.09294805e-02f, -1.27324566e-01f, 1.83970910e-02f, -1.06395669e-02f,
  -1.34608671e-02f, 1.28358856e-01f, 3.17333043e-02f, -1.79890096e-02f, -1.30975889e-02f, -1.70016568e-02f, 7.47665390e-02f, 2.76513454e-02f, -4.14796770e-02f, -6.76869154e-02f,
  2.96360627e-02f, 1.02225114e-02f, -4.69774418e-02f, -1.18165977e-01f, 4.23235521e-02f, -1.67601481e-02f, -9.04287919e-02f, -2.26338003e-02f, -5.61433993e-02f, -6.52980581e-02f,
  3.55456099e-02f, 6.27056137e-03f, -4.77242991e-02f, -5.94332293e-02f, -6.92710429e-02f, 3.76090705e-02f, 1.70690492e-02f, 9.73710865e-02f, 4.49735336e-02f, -4.88795601e-02f,
  4.72661108e-02f, -1.47469640e-01f, 7.16742575e-02f, 4.31492366e-02f, 4.61616740e-02f, -2.36685034e-02f, 1.45011218e-02f, -1.48265734e-01f, -2.45725270e-02f, -3.00586261e-02f,
  -5.84218949e-02f, 2.62431130e-02f, -2.31657457e-02f, -7.25555792e-02f, 4.21271436e-02f, 1.49731599e-02f, -9.28624049e-02f, -1.11344129e-01f, 5.98506592e-02f, 1.51839033e-02f,
  -1.60945319e-02f, 1.57538764e-02f, 1.09748080e-01f, 9.32015777e-02f, 1.31958732e-02f, 8.73923451e-02f, 1.28262088e-01f, 4.17714827e-02f, 4.42371890e-02f, 1.34860620e-01f,
  -7.08469078e-02f, 3.54790121e-01f, 7.67802820e-02f, -6.95387796e-02f, 8.71943608e-02f, -1.02977961e-01f, 1.34582967e-01f, 1.66115724e-02f, -1.28586635e-01f, 1.98962525e-01f,
  2.37064231e-02f, -1.36332226e-03f, -1.20968916e-01f, 3.27917077e-02f, -2.47056363e-03f, 1.43863261e-01f, 2.13616937e-01f, 4.67811599e-02f, -2.39423588e-01f, -1.25243023e-01f,
  4.24956903e-03f, 3.62397209e-02f, -3.40805016e-02f, -7.52858073e-02f, -5.56098036e-02f, -1.84542879e-01f, 6.60683438e-02f, -3.96116376e-02f, -3.59546132e-02f, 2.65425056e-01f,
  -8.29167888e-02f, 4.55741491e-03f, -2.79320449e-01f, -9.36541557e-02f, 9.68746282e-03f, -1.08580835e-01f, -9.25823078e-02f, 7.06053600e-02f, 2.15861876e-03f, -3.40244472e-02f,
  1.15570851e-01f, 8.65904242e-03f, -1.39719591e-01f, -6.96769431e-02f, 2.57209744e-02f, -1.39408946e-01f, 6.50111167e-03f, -3.76392668e-03f, -1.18782513e-01f, -8.05340782e-02f,
  9.75823626e-02f, 8.42711255e-02f, -1.14402128e-02f, 3.43156643e-02f, -4.12659608e-02f, 2.37947069e-02f, -1.88732948e-02f, -1.50838420e-01f, -8.31090808e-02f, -3.89123755e-03f,
  6.54617921e-02f, 1.36548236e-01f, 8.44934396e-03f, 1.72679417e-03f, 4.59351912e-02f, 1.44942887e-02f, 7.73294121e-02f, 1.54782645e-02f, 9.80315953e-02f, 2.35861000e-02f,
  -2.22426876e-02f, -2.53153760e-02f, 9.83714238e-02f, 1.24321301e-02f, -2.56892778e-02f, 8.09797198e-02f, -6.64718002e-02f, -1.59733295e-02f, -1.44526025e-03f, -8.02934729e-03f,
  2.84953434e-02f, 6.61366060e-02f, 3.22409458e-02f, 3.45951356e-02f, 7.48714060e-02f, 6.83248043e-03f, -9.75446478e-02f, -1.17395946e-03f, -3.28405760e-02f, 5.31369001e-02f,
  -3.12911898e-01f, -2.11865567e-02f, -1.42293364e-01f, -9.76916105e-02f, 7.86867663e-02f, 7.06517920e-02f, 3.01430579e-02f, 9.80233997e-02f, 7.80924559e-02f, 6.47702515e-02f,
  -3.89658585e-02f, 3.21055464e-02f, -9.09426529e-03f, -2.60651857e-02f, 5.89508452e-02f, -1.09236315e-01f, 2.36786325e-02f, 1.82348136e-02f, -6.40732273e-02f, -3.82632129e-02f,
  -6.38795123e-02f, 3.21894027e-02f, -1.05287723e-01f, 7.79337585e-02f, -9.49045494e-02f, -1.13618262e-01f, -1.63979128e-01f, -3.55741121e-02f, -2.22951114e-01f, -9.91161019e-02f,
  -1.44413292e-01f, -1.63117796e-01f, -1.70545399e-01f, 1.78500071e-01f, 6.66458458e-02f, -8.82879049e-02f, -2.16560274e-01f, -1.11171581e-01f, 3.10706142e-02f, -1.14674635e-01f,
  1.08481543e-02f, 3.78625244e-02f, 6.27961010e-02f, -4.55501722e-03f, -1.54896542e-01f, -7.89976269e-02f, -3.03477533e-02f, -2.47358922e-02f, -1.04664810e-01f, 6.34095371e-02f,
  1.13213070e-01f, 9.66416225e-02f, -4.58167605e-02f, 9.01659951e-02f, 1.81905821e-01f, 4.54840586e-02f, -1.09900698e-01f, 6.27162531e-02f, 1.36254104e-02f, 1.26966000e-01f,
  -2.03326344e-01f, -1.58316702e-01f, -1.42673731e-01f, 9.45200119e-03f, 5.49847707e-02f, -4.05904949e-02f, -4.31943275e-02f, -1.32604808e-01f, -7.71520194e-03f, -5.67326583e-02f,
  -3.76833789e-02f, -3.05308774e-03f, -5.46820126e-02f, -1.09583735e-02f, -5.72271235e-02f, -1.87719166e-01f, -9.57516432e-02f, -9.53067467e-02f, -3.24578956e-02f, -1.67875424e-01f,
  -5.78613952e-02f, -7.94435516e-02f, -2.02017233e-01f, -1.95049822e-01f, -1.03782199e-01f, -3.51346843e-02f, -1.34095863e-01f, -5.33768982e-02f, -6.00810610e-02f, -7.80723542e-02f,
  -2.47553457e-03f, 1.59730539e-02f, 7.96427950e-02f, -2.85582542e-02f, 1.90727711e-02f, -3.01928520e-02f, 5.54747656e-02f, -4.82374243e-02f, 3.83250751e-02f, -6.86315820e-02f,
  -7.52576347e-03f, -8.47399235e-02f, -2.17040125e-02f, 8.70768726e-02f, 4.81383540e-02f, 1.22514635e-01f, 2.59768087e-02f, 1.07459381e-01f, -1.51664913e-02f, -4.19521704e-03f,
  2.32928805e-02f, 1.36401847e-01f, 1.33046120e-01f, 9.45852548e-02f, 1.02428518e-01f, 7.62385353e-02f, -4.58316877e-02f, 1.88037798e-01f, 9.99742746e-02f, 5.85405529e-02f,
  -4.92761470e-02f, -1.83371484e-01f, -1.40115574e-01f, -8.39763731e-02f, -6.91484660e-02f, -3.32263894e-02f, -1.51999225e-03f, -1.11383446e-01f, -5.76962009e-02f, -1.02108508e-01f,
  -1.15539804e-01f, -5.65714575e-02f, -1.33430853e-01f, -5.55904657e-02f, -9.24353674e-02f, -1.63494661e-01f, -4.88625020e-02f, -1.22745018e-02f, -1.13878176e-01f, -1.34690046e-01f,
  1.68586504e-02f, -1.10824905e-01f, -1.29817709e-01f, -1.73615187e-01f, -2.04903960e-01f, -9.73775685e-02f, -1.36440009e-01f, -4.88290153e-02f, -1.92662880e-01f, -2.36945838e-01f,
  -1.48619398e-01f, 2.11840555e-01f, 2.76281923e-01f, -1.23151161e-01f, 1.35591239e-01f, -1.71195522e-01f, -2.23674551e-01f, -2.21863940e-01f, -2.02631857e-02f, 4.84601371e-02f,
  9.94906351e-02f, -4.89299893e-02f, 3.93118970e-02f, 4.31868210e-02f, -8.55675936e-02f, 3.93626951e-02f, -2.47303713e-02f, -1.74263772e-03f, -1.85512468e-01f, -2.22024575e-01f,
  -1.02984242e-01f, 2.43710838e-02f, 2.37465594e-02f, 7.37026408e-02f, 2.08807793e-02f, 1.53286159e-01f, 1.58642247e-01f, 2.23704651e-01f, 2.33901009e-01f, 3.13928485e-01f,
  1.18842460e-01f, 9.72892120e-02f, -3.21178250e-02f, -6.94414377e-02f, 1.85385905e-02f, -8.23922083e-02f, 1.34443091e-02f, 1.51410131e-02f, -6.99850470e-02f, -7.15307370e-02f,
  5.22580892e-02f, 3.26869674e-02f, -1.96692795e-01f, -4.34484556e-02f, -7.49459192e-02f, -2.75895987e-02f, -8.60308707e-02f, -6.13795072e-02f, 2.19710008e-03f, -5.63111231e-02f,
  -5.91053069e-02f, 7.27342591e-02f, -3.17632556e-02f, -1.81811396e-02f, 6.44299993e-03f, 7.49064162e-02f, 1.21340714e-02f, -5.94312735e-02f, -4.16636989e-02f, -6.32175431e-02f,
  3.07128523e-02f, 6.79079667e-02f, 2.78856163e-03f, -4.68196673e-03f, -7.32481200e-03f, 2.17757863e-03f, 5.56729175e-02f, 1.01595700e-01f, 1.01894692e-01f, 1.53786140e-02f,
  6.05757050e-02f, 5.14355600e-02f, 1.36020541e-01f, 1.07515909e-01f, 1.43812940e-01f, 1.07562542e-01f, 2.28769314e-02f, 1.75257012e-01f, 8.60845521e-02f, 4.45142426e-02f,
  5.09907380e-02f, 1.80700853e-01f, 2.09576562e-01f, 5.67569118e-03f, 5.51503003e-02f, 1.56924412e-01f, 4.43523191e-02f, 4.93360646e-02f, 3.35527025e-02f, 6.62499145e-02f,
  -7.50727132e-02f, -8.83961283e-03f, -8.75784159e-02f, -2.40267231e-03f, -9.62372273e-02f, -3.95141393e-02f, 5.36043383e-02f, -5.04554664e-05f, 3.76395322e-02f, -7.88229331e-02f,
  4.19717096e-02f, -1.41201794e-01f, -4.66940813e-02f, -2.55435277e-02f, -1.00517720e-01f, -9.29087102e-02f, -9.51621681e-02f, -8.71502757e-02f, -1.11745827e-01f, -8.88142064e-02f,
  -7.22999498e-02f, -2.05181196e-01f, -2.41240531e-01f, -9.39291418e-02f, -4.42018062e-02f, -1.52171582e-01f, 2.35319640e-02f, -1.51646793e-01f, -2.42682144e-01f, -1.68529987e-01f,
  2.13679910e-01f, 1.03094287e-01f, -1.23001665e-01f, 2.92282969e-01f, 1.59354672e-01f, 3.77213908e-03f, 1.94685534e-02f, 7.23082125e-02f, 2.17382446e-01f, 1.72688827e-01f,
  1.87344760e-01f, 2.88913459e-01f, 1.28573075e-01f, 1.71607330e-01f, 2.00451445e-02f, 1.71504781e-01f, 2.00946406e-01f, -1.07181510e-02f, -1.08835340e-01f, 1.44976079e-01f,
  2.37572029e-01f, 2.30873346e-01f, 9.80711952e-02f, 5.44306040e-02f, 2.43577972e-01f, 1.27412230e-01f, -3.49748097e-02f, 2.39729080e-02f, 1.35171339e-01f, 3.54185373e-01f,
  2.99656361e-01f, 9.96460617e-02f, 1.38587594e-01f, 2.20674321e-01f, 1.48392782e-01f, 1.53257683e-01f, 1.78377479e-01f, 7.43005574e-02f, 1.31332412e-01f, 2.11962871e-02f,
  1.76459983e-01f, 1.12664320e-01f, 1.10342942e-01f, 2.35517696e-01f, 2.37750143e-01f, 1.81643888e-01f, 4.27442901e-02f, 4.91215624e-02f, -2.23731827e-02f, 7.69085065e-02f,
  1.59689754e-01f, 6.25297278e-02f, 1.29044279e-01f, 5.45824133e-02f, -2.32758205e-02f, 1.87204868e-01f, 5.54714389e-02f, 5.50146475e-02f, -7.15122297e-02f, 3.64452749e-02f,
  -3.89741622e-02f, -3.33780907e-02f, -5.12478612e-02f, -1.01174742e-01f, 1.01746805e-01f, -1.08823124e-02f, -2.36848071e-02f, 6.38416559e-02f, -1.16268329e-01f, 4.76733074e-02f,
  2.25095749e-02f, -4.53848355e-02f, -1.28126279e-01f, -8.90127271e-02f, -7.55559728e-02f, -7.41329277e-03f, -1.11333758e-01f, -2.38240659e-02f, -6.07549213e-02f, -2.81393677e-02f,
  -8.62094313e-02f, -1.13035858e-01f, -6.34099096e-02f, -7.42992759e-02f, 6.08505532e-02f, -3.46158259e-02f, 1.93268433e-02f, 1.30146078e-03f, -6.81621432e-02f, 9.86904353e-02f,
  3.18613261e-01f, 7.53700063e-02f, 2.94946015e-01f, 9.19819400e-02f, 6.63058385e-02f, 3.24886180e-02f, 7.68215954e-02f, 1.41858429e-01f, 1.74801156e-01f, 1.86678186e-01f,
  5.74851930e-02f, 4.25188318e-02f, 1.43830255e-01f, 7.48969689e-02f, 4.52087075e-02f, 1.59007683e-01f, 9.10985619e-02f, 1.36419192e-01f, 1.16654053e-01f, 3.54701653e-02f,
  9.47468355e-02f, 1.39680058e-01f, 2.02558458e-01f, 9.89090353e-02f, 2.74831406e-03f, 1.60651281e-01f, 2.02301666e-01f, 1.03112608e-01f, 6.26665205e-02f, 1.86042354e-01f,
  3.47508103e-01f, -2.60202259e-01f, 1.40412375e-01f, 2.22957328e-01f, -8.98538083e-02f, 9.75998268e-02f, 4.72541004e-02f, 7.20831752e-02f, 2.42678705e-03f, -8.37302282e-02f,
  -1.44791557e-02f, 2.39498228e-01f, 1.24289975e-01f, 9.42213312e-02f, 2.02549085e-01f, -1.48046175e-02f, -1.59676990e-03f, 2.19734475e-01f, 4.64035302e-01f, 2.95412362e-01f,
  4.94697914e-02f, 2.29119867e-01f, 1.60713077e-01f, 2.47872114e-01f, -7.46606067e-02f, 1.30776167e-01f, 4.97506931e-02f, 3.97713892e-02f, -9.92584899e-02f, -1.82976618e-01f,
  2.17425838e-01f, -9.37011372e-03f, 1.10658430e-01f, -8.08106512e-02f, 8.67153257e-02f, 1.56551287e-01f, 9.34067145e-02f, 7.79284835e-02f, 7.25637153e-02f, 1.34931624e-01f,
  4.80883792e-02f, 4.22159694e-02f, 1.87306389e-01f, 1.07781239e-01f, 6.98598698e-02f, 8.11472386e-02f, 3.07973232e-02f, 1.70823604e-01f, 8.77120644e-02f, -1.30162211e-02f,
  -1.78448192e-03f, -8.60218480e-02f, 1.72175243e-02f, 6.24233559e-02f, 9.07817483e-02f, 1.10420339e-01f, 4.35628109e-02f, 5.16765602e-02f, 1.61679253e-01f, 9.31873824e-03f,
  6.96871430e-02f, 1.11913020e-02f, -3.61227244e-02f, 1.30847644e-03f, -4.04961072e-02f, 3.78791206e-02f, -3.65003832e-02f, -5.54832921e-04f, -8.23549628e-02f, -7.71639124e-02f,
  -8.89014602e-02f, -9.17278826e-02f, -3.06448247e-02f, -3.05064172e-02f, -1.73268896e-02f, -4.97494861e-02f, -6.56766146e-02f, -9.50036272e-02f, 4.51967586e-03f, -1.58934429e-01f,
  -5.60378879e-02f, -1.10487729e-01f, -4.66689803e-02f, -6.71607107e-02f, -1.76516533e-01f, -7.06190541e-02f, -1.34714216e-01f, -1.33574098e-01f, 7.11284112e-03f, -3.54778767e-02f,
  2.60323018e-01f, 1.90611780e-02f, 1.50261834e-01f, -4.58849184e-02f, 3.68967913e-02f, 1.10955432e-01f, 1.46528587e-01f, -3.41414362e-02f, 5.04584908e-02f, 3.05967703e-02f,
  3.12898345e-02f, 5.44342399e-02f, 1.52226508e-01f, 6.17432874e-03f, 9.52509493e-02f, 6.38217106e-02f, 3.52994017e-02f, 1.23246819e-01f, 3.85820158e-02f, 1.00902915e-01f,
  -9.86297429e-02f, 1.47732511e-01f, 1.54231533e-01f, 1.43647566e-01f, 2.71428954e-02f, 1.48380429e-01f, 2.61905670e-01f, 1.28140256e-01f, 2.18360543e-01f, 2.09213272e-01f,
  1.52434930e-01f, -2.65013635e-01f, -3.33323509e-01f, 7.14350641e-02f, -9.00832638e-02f, -6.20702170e-02f, -2.22856566e-01f, -4.83578630e-02f, 1.65930599e-01f, -9.69961509e-02f,
  2.94950772e-02f, 2.51603335e-01f, 1.37867272e-01f, 1.17676221e-01f, 1.32691022e-02f, -1.55797213e-01f, -2.23442450e-01f, -5.33484705e-02f, 5.13224006e-02f, 1.09195553e-01f,
  5.02640717e-02f, -5.21782301e-02f, -1.84372179e-02f, -4.40194551e-03f, -4.76752501e-03f, 2.03428850e-01f, -1.50388494e-01f, -2.17096563e-02f, 8.66811648e-02f, -2.88656145e-01f,
  -9.23983455e-02f, -2.29501724e-01f, 1.70131817e-01f, -1.68681820e-03f, -6.75218180e-02f, -2.39348356e-02f, -4.32979800e-02f, -1.52326263e-02f, -5.57097942e-02f, 2.54976917e-02f,
  -9.84965730e-03f, 1.80273484e-02f, 2.73269117e-02f, 1.41245890e-02f, -5.67878410e-02f, -3.85182947e-02f, 3.39349429e-03f, -1.52696937e-01f, -1.08124055e-01f, -9.13658887e-02f,
  -1.36738187e-02f, -3.21930759e-02f, -2.36468110e-03f, 7.03877211e-02f, -8.59460160e-02f, 3.37162204e-02f, -5.91024831e-02f, -6.55161440e-02f, -7.82234222e-02f, -3.07812728e-02f,
  1.24464214e-01f, -7.69971758e-02f, 1.66043099e-02f, 9.47222412e-02f, 1.13728493e-01f, -3.86792608e-03f, -2.59693898e-02f, 2.85998024e-02f, 7.05920607e-02f, 4.96262833e-02f,
  -7.42088556e-02f, 1.99159905e-02f, 2.53546815e-02f, -1.62377805e-02f, 7.68681690e-02f, -6.57885596e-02f, -1.02194548e-01f, 6.89728186e-02f, 3.10349297e-02f, 7.64338300e-02f,
  1.89334415e-02f, 4.91985120e-02f, 7.83266425e-02f, 1.08615309e-01f, -1.22080564e-01f, -7.75580630e-02f, -6.44204468e-02f, -9.57227200e-02f, 1.88098088e-01f, -2.57712137e-02f,
  4.85878363e-02f, -3.04533485e-02f, 1.05108228e-03f, -5.60053699e-02f, -9.81019586e-02f, -3.71349752e-02f, -1.20572120e-01f, -4.39879894e-02f, 2.47083581e-03f, -1.64835975e-01f,
  1.26564741e-01f, -7.84313679e-02f, -1.02432467e-01f, 5.97666800e-02f, 6.14830106e-02f, 1.75705981e-02f, 8.92336741e-02f, 1.19338036e-02f, 1.72383077e-02f, -1.47490188e-01f,
  5.07130660e-02f, 6.45290762e-02f, 1.25708014e-01f, -2.14278828e-02f, -3.28540266e-03f, 8.22714865e-02f, -2.35854816e-02f, 1.02242768e-01f, 1.23513453e-01f, 7.47641176e-02f,
  -2.96588004e-01f, 9.69886631e-02f, -1.57258406e-01f, -2.15511359e-02f, 1.17622659e-01f, 4.11758162e-02f, -3.10933739e-02f, -2.28092298e-02f, 8.77244025e-02f, 5.10136671e-02f,
  1.66623041e-01f, 2.74792314e-01f, 1.68256104e-01f, 2.27100179e-01f, -3.03212684e-02f, 6.64160699e-02f, 1.75667167e-01f, 6.07127063e-02f, -3.11705004e-02f, 1.08906347e-02f,
  2.07153574e-01f, 6.05765097e-02f, 1.19476290e-02f, 1.04135059e-01f, 1.03199728e-01f, 1.96698621e-01f, 9.56474915e-02f, 1.01596788e-01f, 6.52901232e-02f, 3.17858666e-01f,
  2.40237992e-02f, -1.20454229e-01f, -6.85787573e-02f, 2.58231703e-02f, 7.80578107e-02f, 1.04560614e-01f, 5.19289635e-02f, -4.96938117e-02f, 1.58107251e-01f, 3.88843529e-02f,
  9.79504958e-02f, 1.79914877e-01f, 2.11911172e-01f, 1.48497403e-01f, 9.38254446e-02f, 3.33308950e-02f, 1.04312606e-01f, 1.04537830e-01f, -9.18602850e-03f, 3.34661119e-02f,
  2.53763765e-01f, 8.95251110e-02f, -1.26581462e-02f, 3.38333920e-02f, -7.41101801e-02f, 1.39044911e-01f, 4.60753925e-02f, 1.32005721e-01f, 4.33458481e-03f, 6.25043288e-02f,
  7.10852966e-02f, -1.05307445e-01f, -1.45033151e-01f, -3.03686429e-02f, -4.80869971e-02f, 3.49822044e-02f, -4.37162109e-02f, -6.86683431e-02f, -1.01676229e-02f, -9.71874222e-02f,
  -9.16002318e-02f, 4.79334742e-02f, -9.03847888e-02f, -9.69163850e-02f, 9.38166399e-03f, -1.03512987e-01f, -7.35889003e-03f, -1.62913594e-02f, -7.39472359e-02f, -1.13699190e-01f,
  -4.16997038e-02f, -1.14352755e-01f, -1.99647509e-02f, -1.05726995e-01f, -4.03761789e-02f, -4.63659726e-02f, -1.66828930e-01f, -8.49892050e-02f, -6.75179213e-02f, -1.00336045e-01f,
  9.57544222e-02f, 1.57269105e-01f, 1.04616031e-01f, 4.66809347e-02f, -2.36941036e-02f, 6.04452826e-02f, 4.40147966e-02f, 2.06236113e-02f, -4.33508679e-02f, -6.90099448e-02f,
  9.56114903e-02f, 9.27193239e-02f, 2.05507994e-01f, 1.07400961e-01f, 1.07887223e-01f, 3.24098393e-02f, 3.15551497e-02f, 4.10303734e-02f, 4.30969261e-02f, 9.63697881e-02f,
  3.00558768e-02f, 5.45276366e-02f, -7.24521801e-02f, -2.90762056e-02f, 2.45923735e-02f, 1.25561237e-01f, 1.89669579e-02f, 1.56170532e-01f, 5.50859272e-02f, -2.58695334e-02f,
  -5.20694777e-02f, -1.49110764e-01f, 8.02159458e-02f, -2.07599457e-02f, -1.48769662e-01f, -2.83399463e-01f, -4.08253044e-01f, -2.25465059e-01f, -8.75066072e-02f, -2.10363403e-01f,
  -2.62228101e-01f, 8.73331502e-02f, 1.15180291e-01f, 2.39118814e-01f, 3.47857475e-02f, -9.68892053e-02f, 1.10034771e-01f, 2.81394601e-01f, 2.32243329e-01f, 6.54978305e-02f,
  1.30105112e-02f, 1.79035142e-01f, 1.44488409e-01f, 1.42885521e-01f, 2.13192150e-01f, 2.02439800e-01f, -5.80342002e-02f, 1.35625824e-01f, 1.56580925e-01f, 5.14692903e-01f,
  1.47816956e-01f, -7.48129413e-02f, 5.52441319e-03f, 1.52800384e-03f, 3.82965989e-02f, 1.31744429e-01f, -7.20296130e-02f, -1.18054189e-02f, -5.70436157e-02f, -2.39424203e-02f,
  -2.18437146e-02f, -1.54510736e-02f, 8.50533247e-02f, 1.23762839e-01f, -2.66647600e-02f, -1.75521243e-02f, 8.63840133e-02f, 6.50215894e-02f, 7.88788944e-02f, 3.29295523e-03f,
  1.14631727e-01f, -3.89726274e-02f, -7.05315173e-02f, -4.26126495e-02f, -3.60290334e-02f, -3.81912738e-02f, -1.21807359e-01f, 1.11371361e-01f, -4.34016846e-02f, 1.09457172e-01f,
  -1.70146555e-01f, -4.60932683e-03f, 3.98243777e-03f, 5.92073649e-02f, 1.00594804e-01f, -2.42697392e-02f, -2.27677243e-04f, 3.94462384e-02f, 9.84001234e-02f, -8.66933609e-04f,
  5.18929772e-02f, -8.07668734e-03f, -4.09784019e-02f, -2.73750760e-02f, 2.21663667e-03f, 6.50840625e-02f, 2.22767610e-02f, -4.77029793e-02f, -4.47711721e-02f, 9.87214893e-02f,
  4.32431921e-02f, 4.03023772e-02f, -8.26702341e-02f, 1.41552776e-01f, -9.71312262e-03f, -4.04540449e-02f, 6.15248131e-03f, -2.93938816e-02f, 5.85974194e-02f, 1.82772353e-02f,
  -6.42771134e-03f, -1.95411444e-01f, -4.51431051e-02f, -2.11408399e-02f, -1.25006631e-01f, -8.69524702e-02f, 4.83322656e-03f, 1.29607320e-02f, -4.97426316e-02f, 2.72742216e-03f,
  -8.47088993e-02f, -2.57520452e-02f, -8.33765641e-02f, 6.69768155e-02f, 7.81505480e-02f, -8.54951814e-02f, -5.50457984e-02f, 7.64656290e-02f, -4.30340208e-02f, -2.02030391e-02f,
  -2.32836492e-02f, -1.72483981e-01f, -4.55689058e-02f, -2.09672507e-02f, -3.56967002e-02f, -2.49273162e-02f, -4.45084721e-02f, -1.11055620e-01f, -9.13233235e-02f, -1.90082222e-01f
};

// L0_fan_Wp_bar (Shape: 26 x 120)
const int L0_fan_Wp_bar_rows = 26;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -1.86125249e-01f, 5.61260223e-01f, -2.27058694e-01f, 2.10951626e-01f, 3.63787234e-01f, 1.42123327e-01f, 2.58576512e-01f, 1.90587133e-01f, -2.59256847e-02f, 7.90020004e-02f,
  2.09259674e-01f, -6.45468310e-02f, -1.45943925e-01f, -1.70886591e-01f, -6.13294281e-02f, -3.76824103e-02f, -1.29071608e-01f, -3.38664293e-01f, -4.84432518e-01f, -3.91587727e-02f,
  1.01556592e-01f, -1.65654838e-01f, -3.40722173e-01f, -1.47629693e-01f, 1.35036767e-01f, -4.47648577e-03f, 1.66072361e-02f, 1.52941301e-01f, 1.07340634e-01f, -5.06016202e-02f,
  -1.17907137e-01f, 2.87984759e-01f, -2.56211739e-02f, 1.60462558e-01f, 1.30042747e-01f, -6.99611083e-02f, -1.06796578e-01f, 8.51040930e-02f, 1.11443445e-01f, 2.06129141e-02f,
  -6.59752712e-02f, -1.62617173e-02f, -1.21916771e-01f, 1.07619287e-02f, -3.61494720e-02f, 3.39757688e-02f, 1.21954218e-01f, 1.03540458e-01f, 1.48054585e-01f, 1.67280473e-02f,
  1.38612002e-01f, 1.19223908e-01f, 1.11168467e-01f, 2.06054747e-01f, 9.56897438e-02f, 4.98543680e-02f, 1.12624429e-01f, 4.44199741e-02f, 1.08218297e-01f, -2.48514395e-02f,
  4.69072014e-02f, -4.83569615e-02f, 8.89580995e-02f, -1.00185126e-01f, 7.57586583e-02f, 2.68839616e-02f, 4.45371158e-02f, 1.15550764e-01f, -2.09793478e-01f, 9.57349141e-04f,
  1.79988563e-01f, 3.29338610e-02f, -1.61655713e-02f, 4.71798852e-02f, 2.01281868e-02f, 1.38988093e-01f, 2.84803510e-02f, 1.32988393e-01f, 1.34655967e-01f, 8.01503733e-02f,
  1.28944457e-01f, -1.88222617e-01f, -1.27929091e-01f, -1.09886201e-02f, 1.25083447e-01f, 2.36255210e-02f, 6.58173934e-02f, 1.75599247e-01f, -8.92895982e-02f, 6.69779256e-02f,
  7.13138133e-02f, 1.63157612e-01f, -1.18705258e-02f, 1.35592548e-02f, -3.63431722e-02f, 3.46517861e-02f, -4.89869639e-02f, 1.04636587e-01f, -1.68579668e-02f, 5.59805967e-02f,
  3.31323706e-02f, -2.68882900e-01f, -1.20207973e-01f, 8.08219239e-02f, -1.57452926e-01f, -9.21404585e-02f, 1.06875569e-01f, -5.89123853e-02f, -5.28713465e-02f, 6.32217973e-02f,
  5.25646135e-02f, 9.51268002e-02f, 8.93618092e-02f, 1.67905360e-01f, -2.05109827e-02f, -9.39407423e-02f, -3.84426005e-02f, -4.14830782e-02f, -6.07090816e-02f, -3.93551178e-02f,
  -8.69421139e-02f, -1.03929602e-01f, -1.69957936e-01f, 7.72773102e-02f, -2.54646987e-02f, -9.26674157e-02f, -2.17536524e-01f, -1.16030633e-01f, 1.43307313e-01f, 5.33562601e-02f,
  -2.69084778e-02f, 6.77989945e-02f, 8.35090354e-02f, 1.18343465e-01f, 5.37224300e-02f, 1.79301947e-01f, 1.81525409e-01f, 6.96716756e-02f, -5.46662994e-02f, -2.51914002e-02f,
  2.83168226e-01f, 2.66732741e-02f, 5.05084321e-02f, 9.81021672e-02f, 3.43726754e-01f, 3.23497295e-01f, 3.12926881e-02f, 9.83485281e-02f, 1.33417249e-01f, 4.56241637e-01f,
  -2.45420843e-01f, -1.64572448e-01f, -1.00782819e-01f, -1.48008347e-01f, -1.62461787e-01f, 2.65676565e-02f, -6.94198348e-03f, -9.71611813e-02f, -1.05464933e-02f, -1.79737762e-01f,
  -3.33696380e-02f, -1.92855939e-01f, 9.60800145e-03f, -6.43255003e-03f, -8.53466019e-02f, -6.86967075e-02f, -1.16898760e-01f, -1.68293998e-01f, -2.39699692e-01f, -2.31678456e-01f,
  1.25323698e-01f, -4.80204225e-02f, -2.31679767e-01f, -1.33454546e-01f, -7.94439912e-02f, 1.09483190e-02f, -4.65562157e-02f, 2.08951682e-01f, -1.17701344e-01f, 1.35080665e-01f,
  -1.12084754e-01f, -4.94184846e-04f, 5.05305491e-02f, -1.89609583e-02f, 1.28232464e-01f, -4.05815542e-02f, 2.96683307e-03f, -5.73154390e-02f, 6.38869330e-02f, 1.98581647e-02f,
  -4.04841779e-03f, -1.25998542e-01f, -1.78122416e-01f, -1.21569447e-01f, 5.85862510e-02f, 8.50988775e-02f, 5.28743789e-02f, -8.83311033e-03f, -1.23481296e-01f, -5.49597032e-02f,
  -4.85624634e-02f, 1.63003743e-01f, 6.42846897e-02f, 6.25286624e-02f, 1.63129762e-01f, -1.54953182e-01f, 1.15374684e-01f, 8.32721069e-02f, 4.59674448e-02f, 7.91364610e-02f,
  -2.66425312e-01f, -2.16007575e-01f, 8.02036673e-02f, -4.11435030e-02f, 1.56230051e-02f, 1.06312342e-01f, 5.89022338e-02f, -8.27609301e-02f, -6.89254180e-02f, -3.70945707e-02f,
  -8.03766623e-02f, 7.48984441e-02f, -8.40215534e-02f, 3.88335735e-02f, -1.72672402e-02f, 8.25999826e-02f, -3.83058767e-04f, -2.11271625e-02f, -1.19999960e-01f, -4.14344780e-02f,
  -2.77249273e-02f, -2.64415830e-01f, -1.76261723e-01f, -9.72113833e-02f, 1.16204791e-01f, -6.93838149e-02f, 8.95940065e-02f, 6.60472438e-02f, -1.38551906e-01f, -6.62843883e-02f,
  2.32508034e-01f, -2.31965333e-01f, 1.46445483e-01f, 2.26757005e-01f, -1.29438952e-01f, -1.78121150e-01f, -3.82509232e-01f, -1.74166247e-01f, 7.94603303e-02f, 4.13032547e-02f,
  1.74827933e-01f, 2.41187826e-01f, 3.03688973e-01f, 1.31199196e-01f, 1.82724908e-01f, -1.33093502e-02f, -4.55855057e-02f, 3.66423249e-01f, 1.82693705e-01f, 1.52981773e-01f,
  -7.05463141e-02f, -6.02422431e-02f, 2.05761954e-01f, 7.39649832e-02f, 5.77478856e-03f, 2.02487305e-01f, -1.03525713e-01f, -5.60961030e-02f, -5.61717078e-02f, 2.67829329e-01f,
  3.28601509e-01f, 1.39091745e-01f, 2.62561172e-01f, 1.70927003e-01f, -1.63487867e-02f, -1.87537111e-02f, 4.73693162e-02f, 1.51442915e-01f, 4.07089181e-02f, -6.21555597e-02f,
  -1.90078337e-02f, 3.93682607e-02f, -2.48257797e-02f, -1.29405200e-01f, -3.93207930e-02f, 2.25123074e-02f, 4.05784091e-03f, 6.49609650e-03f, -3.11428611e-03f, -3.10056880e-02f,
  -1.00235038e-01f, -2.28217151e-02f, -3.07377689e-02f, -6.58707917e-02f, -1.23457260e-01f, 1.54428333e-01f, -7.02391416e-02f, 6.54883310e-02f, -9.72232898e-04f, -8.53822455e-02f,
  1.14726253e-01f, 4.60400023e-02f, 1.69148855e-02f, 7.62664154e-02f, 6.16838261e-02f, -7.07977712e-02f, -5.14045097e-02f, 6.84104785e-02f, -1.65848941e-01f, -8.78739953e-02f,
  -1.73321646e-02f, -7.85919726e-02f, -6.10538535e-02f, 1.64384153e-02f, 1.45308420e-01f, 6.06002286e-02f, 3.86744179e-02f, 9.47063267e-02f, 1.16499096e-01f, -8.51834044e-02f,
  4.09654267e-02f, 6.20037224e-03f, -1.47410622e-02f, -1.02707729e-01f, 6.86059073e-02f, 1.61777690e-01f, 8.77627917e-03f, -3.17088068e-02f, -3.76961529e-02f, -9.66421068e-02f,
  -1.66389838e-01f, 2.92980552e-01f, 7.31895566e-02f, -4.78016585e-03f, 2.89282072e-02f, -7.23230168e-02f, 1.50682718e-01f, 1.42393559e-01f, 6.13019280e-02f, 9.92561057e-02f,
  -1.23520218e-01f, 1.66764125e-01f, -7.39376098e-02f, -1.52507335e-01f, -1.44266576e-01f, 1.82428360e-02f, -3.07791512e-02f, 7.34716654e-02f, 1.32518485e-01f, 6.77501038e-02f,
  -8.18549693e-02f, -2.78460439e-02f, 5.06482236e-02f, 9.51622650e-02f, -6.51209727e-02f, 6.99367672e-02f, 3.14084478e-02f, -1.16127551e-01f, 2.57986076e-02f, -1.81020811e-01f,
  5.61597161e-02f, -4.16133344e-01f, 6.84110597e-02f, 2.86800355e-01f, 2.66195945e-02f, -1.15891770e-01f, -5.05960047e-01f, 1.02617957e-01f, 2.19571725e-01f, -1.51972771e-01f,
  -3.69372852e-02f, 2.90561616e-01f, 2.14030311e-01f, 1.30742237e-01f, -8.40573758e-02f, -3.96674782e-01f, -1.57719210e-01f, -5.32764643e-02f, 3.33619833e-01f, 1.39672875e-01f,
  1.45629132e-02f, 2.05624569e-02f, 1.44953653e-01f, 1.57185465e-01f, -1.55561134e-01f, 1.95152089e-02f, -2.86786735e-01f, -1.26885250e-01f, -1.12745360e-01f, -3.59931499e-01f,
  -7.03696534e-02f, 5.60472682e-02f, 1.18051663e-01f, 1.36735708e-01f, -2.12038569e-02f, -1.01516768e-03f, -1.48046553e-01f, -6.99375272e-02f, -1.32328898e-01f, -4.49905209e-02f,
  1.41509905e-01f, 4.17882428e-02f, 9.92283151e-02f, -3.96120809e-02f, -6.12034313e-02f, 8.95716622e-02f, 6.13060892e-02f, 1.76884346e-02f, -4.90440093e-02f, 4.21325974e-02f,
  -8.80075842e-02f, 1.12282209e-01f, 3.47478539e-02f, -3.52257490e-02f, 6.22050837e-04f, 8.86517763e-02f, -8.18374753e-02f, -6.01597652e-02f, -3.62313129e-02f, -3.30751747e-01f,
  -6.63656220e-02f, -2.02109683e-02f, -4.07900773e-02f, 2.07782239e-02f, -2.43266951e-02f, 5.72647825e-02f, 1.76529922e-02f, -7.87844881e-02f, 6.72917301e-03f, 2.42090598e-02f,
  7.33367056e-02f, -2.66443156e-02f, -1.12686068e-01f, -2.52971016e-02f, -5.33937775e-02f, -3.44859585e-02f, 5.38959317e-02f, -7.07515255e-02f, 8.17995295e-02f, -2.45886017e-02f,
  1.21402718e-01f, 1.26790136e-01f, 2.80878283e-02f, 5.18918000e-02f, 7.59933144e-02f, -8.53205174e-02f, 7.28879571e-02f, -3.79745886e-02f, 1.03878297e-01f, 1.73991434e-02f,
  3.58465835e-02f, -6.86593279e-02f, -5.77283092e-02f, 4.87546362e-02f, 1.82419673e-01f, 8.66207927e-02f, -4.49413918e-02f, -7.99735710e-02f, 9.73179638e-02f, 6.56605884e-02f,
  1.16228439e-01f, 9.12622437e-02f, -6.39328286e-02f, -1.44910906e-02f, -7.58194327e-02f, 1.12222277e-01f, -4.81429510e-02f, -4.09640186e-03f, -8.23502466e-02f, -4.73513082e-02f,
  -1.27188653e-01f, -5.65513372e-02f, 1.47577450e-01f, 5.86356111e-02f, -4.45338041e-02f, 9.23666656e-02f, -2.06380084e-01f, -1.25813469e-01f, -6.82005808e-02f, -5.15853226e-01f,
  5.73237360e-01f, 2.03350022e-01f, 2.42663518e-01f, 1.82516873e-01f, 1.76213995e-01f, 1.56931639e-01f, 4.19649988e-01f, 2.00919420e-01f, -4.48705517e-02f, 6.98336363e-02f,
  6.58778697e-02f, -5.85735589e-02f, -8.05711076e-02f, -2.80208793e-02f, 7.35375732e-02f, -3.14386897e-02f, -7.82707259e-02f, 2.18493361e-02f, -3.25981295e-03f, 1.72637366e-02f,
  -5.99440262e-02f, 2.08972991e-01f, 2.85237312e-01f, 1.30499154e-01f, -6.86835498e-02f, -1.55616045e-01f, 1.10047169e-01f, 1.34736001e-01f, 8.88094530e-02f, -2.05325425e-01f,
  -1.50364980e-01f, 3.73918056e-01f, -9.35376137e-02f, 3.08722770e-03f, -1.99275929e-02f, 2.62661520e-02f, -1.19543523e-02f, -4.28140014e-02f, -7.71745145e-02f, -6.72016889e-02f,
  -1.13848314e-01f, 5.57590798e-02f, 2.31534746e-02f, -6.79849535e-02f, 1.52636632e-01f, 7.64212478e-03f, 4.51204814e-02f, 1.50027111e-01f, -3.18420120e-02f, -4.76764794e-03f,
  -1.54989511e-01f, 8.51215795e-03f, 2.19289884e-01f, 5.13509214e-02f, 8.14692378e-02f, -9.52062756e-02f, 1.40715405e-01f, 5.81187233e-02f, 1.22738957e-01f, -1.26766674e-02f,
  7.98564777e-02f, 1.15061946e-01f, 7.63477683e-02f, -1.10912494e-01f, -2.82623768e-02f, -7.29075596e-02f, -4.59681973e-02f, -2.84368396e-02f, 4.64226631e-03f, 9.92629603e-02f,
  -9.14498344e-02f, -1.73218697e-02f, -5.58505654e-02f, 5.16362898e-02f, -5.41449673e-02f, -1.66578330e-02f, -4.56504002e-02f, -1.75501928e-02f, 8.53198320e-02f, 7.52602369e-02f,
  7.32631832e-02f, 6.32695630e-02f, 5.33742737e-03f, -4.50719111e-02f, 3.44182998e-02f, 1.30840570e-01f, -1.20082751e-01f, -1.33964838e-02f, 5.19841425e-02f, 1.34170145e-01f,
  -4.25156057e-01f, 1.58143476e-01f, -2.07978517e-01f, -7.11210631e-03f, 9.52947214e-02f, -9.64887738e-02f, -1.39152380e-02f, -5.83317764e-02f, -9.03272256e-02f, -1.77922659e-02f,
  -6.62060305e-02f, -1.19956315e-01f, 4.83257473e-02f, -2.48927064e-02f, -1.19238988e-01f, -9.55673754e-02f, -1.33655250e-01f, -2.10550085e-01f, -2.33098015e-01f, -9.85614732e-02f,
  -1.96853369e-01f, -2.55646203e-02f, -1.74294394e-02f, 7.53656650e-06f, -9.92975011e-02f, -1.31540880e-01f, -4.73481677e-02f, -1.43040091e-01f, 1.14865258e-01f, 3.67725790e-02f,
  -4.31168765e-01f, 9.85933691e-02f, -2.49352790e-02f, 1.11999527e-01f, 1.37537241e-01f, 2.46619746e-01f, 2.49995515e-01f, 2.76156336e-01f, 1.89738080e-01f, 5.02364663e-03f,
  -1.30513348e-02f, 1.60651401e-01f, 1.31300271e-01f, 1.85720891e-01f, 2.05027089e-01f, 2.91436970e-01f, 2.95356095e-01f, 3.37746441e-02f, 2.12810896e-02f, 6.57560527e-02f,
  2.38557354e-01f, -3.52832414e-02f, -1.93971962e-01f, 3.29571180e-02f, 9.77365375e-02f, 2.46420894e-02f, 6.42811954e-02f, 1.59831598e-01f, 1.49257675e-01f, 1.85997307e-01f,
  3.10494024e-02f, -1.13404013e-01f, -6.12780638e-02f, -1.43422306e-01f, -1.13869011e-01f, -2.20683724e-01f, -5.10445936e-03f, -1.18705630e-01f, -7.52760023e-02f, -4.79447916e-02f,
  -5.80816232e-02f, -5.19128144e-02f, -6.51124716e-02f, -9.16835070e-02f, -2.86405031e-02f, -1.27694458e-01f, -4.88585345e-02f, 1.98913559e-01f, 1.40756279e-01f, -1.66872069e-02f,
  1.51106805e-01f, -2.34206859e-03f, -4.32903226e-03f, 7.03312829e-02f, 5.58546521e-02f, 3.43526644e-03f, 5.13202287e-02f, 5.63583300e-02f, 6.78849518e-02f, 2.48114821e-02f,
  2.51644790e-01f, 1.97799280e-01f, -3.00418139e-02f, 3.32065485e-02f, -7.35971332e-02f, 6.50832802e-03f, 5.65252975e-02f, 2.47001112e-01f, 1.67523786e-01f, 1.24358758e-02f,
  -6.29795250e-03f, 2.95483265e-02f, 1.52594477e-01f, -4.02175561e-02f, 3.83009319e-03f, -4.09582369e-02f, -4.95626368e-02f, -2.31229570e-02f, -2.54695207e-01f, -2.18356773e-01f,
  -6.75069094e-02f, -9.96548310e-02f, -1.24245815e-01f, -8.43461081e-02f, 7.36212358e-02f, 5.89119904e-02f, 1.82591360e-02f, -4.05675620e-02f, 4.78186533e-02f, -7.92701244e-02f,
  3.06964964e-01f, -1.30488306e-01f, 1.00620044e-02f, 6.60299808e-02f, -8.99162740e-02f, -1.76360220e-01f, -3.58282179e-02f, -1.78364396e-01f, -9.51777324e-02f, -2.46647093e-02f,
  -7.06280619e-02f, -1.48879185e-01f, -1.77825131e-02f, 1.50007550e-02f, -1.04666695e-01f, -8.32671300e-02f, 1.33876698e-02f, 1.65790468e-01f, 2.62614727e-01f, 1.49129242e-01f,
  3.43219042e-02f, 1.36763990e-01f, 1.38940066e-02f, 1.48090065e-01f, 2.00634181e-01f, 2.97509637e-02f, -6.35565296e-02f, 1.03500849e-02f, 6.05656169e-02f, 9.48600355e-05f,
  1.12674363e-01f, 3.41642499e-01f, 1.34685263e-01f, 2.33524311e-02f, 2.03039527e-01f, 2.53219694e-01f, 5.12681544e-01f, 1.77173659e-01f, -2.34569326e-01f, -1.10062268e-02f,
  -1.62095614e-02f, -2.70757794e-01f, -6.04984090e-02f, -1.10390276e-01f, 7.20292628e-02f, 6.34524822e-02f, -2.36470103e-02f, -1.13893330e-01f, -2.59431470e-02f, 3.78606245e-02f,
  2.63609346e-02f, 1.32840155e-02f, 5.43384962e-02f, 2.51528434e-02f, -4.64763530e-02f, -1.49498507e-01f, 1.23599805e-01f, 1.22873113e-01f, 8.57721642e-02f, -7.30461106e-02f,
  -2.94049352e-01f, 2.24235833e-01f, -1.34842053e-01f, -7.63895065e-02f, -3.18691656e-02f, -6.17761277e-02f, -6.50670901e-02f, 2.30901185e-02f, 1.09115858e-02f, -9.90525857e-02f,
  1.56786159e-01f, 3.16479020e-02f, 4.42626402e-02f, 5.69788441e-02f, -3.04049626e-02f, 3.37677151e-02f, -7.81932846e-02f, 8.80453214e-02f, -9.09513161e-02f, -2.11829804e-02f,
  -2.27440353e-02f, 4.21147421e-02f, 1.38526663e-01f, 8.81323218e-02f, 4.62393798e-02f, -1.29652902e-01f, 7.20113739e-02f, -7.86166266e-02f, -4.47864234e-02f, -7.46092945e-02f,
  -1.31918443e-03f, -4.97827455e-02f, 2.37979218e-02f, -3.74290906e-02f, 2.00702902e-02f, -1.23395972e-01f, -1.03315651e-01f, -1.10267634e-02f, -1.24920413e-01f, -1.08639039e-01f,
  -8.40704516e-02f, -1.13637023e-01f, -1.40330374e-01f, -1.40829414e-01f, -8.71230811e-02f, -1.30075533e-02f, -1.30319605e-02f, -5.69172353e-02f, 5.05176373e-02f, 8.29212889e-02f,
  1.36919869e-02f, -8.84130821e-02f, -3.22417542e-02f, -1.15134574e-01f, -6.40599206e-02f, 6.99689910e-02f, -1.75530195e-01f, 7.19697326e-02f, -7.26135299e-02f, 1.57008525e-02f,
  -3.30500335e-01f, 9.39199626e-02f, -2.60837376e-01f, -3.33191874e-03f, 4.06591594e-02f, -1.05067366e-03f, -8.72151479e-02f, -7.33708069e-02f, -1.42143369e-01f, -9.75636691e-02f,
  2.05367103e-01f, -1.27198905e-01f, -6.70535639e-02f, -5.43424934e-02f, -1.96414053e-01f, 5.32029895e-03f, -9.84442607e-02f, -1.32173806e-01f, -7.95678720e-02f, -1.32094786e-01f,
  -1.33013159e-01f, -1.19004495e-01f, -6.24451190e-02f, -4.01055760e-04f, -2.73164481e-01f, -2.88545877e-01f, -4.83214259e-02f, -9.51496884e-02f, 2.75016725e-02f, -5.29770777e-02f,
  -5.52387893e-01f, -1.99468940e-01f, -5.30852051e-03f, -4.14536119e-01f, 6.31284621e-03f, 2.53124952e-01f, -4.15162817e-02f, 1.29979879e-01f, -5.98103926e-02f, -3.32820177e-01f,
  -9.78552327e-02f, -1.29891396e-01f, -9.59824771e-02f, 1.06685638e-01f, 3.17407884e-02f, -2.77989477e-01f, -1.97080389e-01f, 9.74598378e-02f, 3.53640199e-01f, 3.76601189e-01f,
  1.32665887e-01f, -1.94419712e-01f, 1.93042923e-02f, 9.65845361e-02f, -2.73129046e-01f, -1.53027654e-01f, -2.79972523e-01f, -6.35724738e-02f, 4.21722755e-02f, -4.22610730e-01f,
  -1.92703187e-01f, -9.05426145e-02f, 2.94505745e-01f, 2.61299815e-02f, -1.85198054e-01f, 3.27274278e-02f, -5.45477942e-02f, 2.28719432e-02f, -8.74365345e-02f, -8.43090191e-03f,
  -2.15895072e-01f, 4.73794527e-02f, -9.71775502e-02f, -3.02887280e-02f, -2.00985566e-01f, -2.27545723e-02f, 3.30310985e-02f, 6.03646785e-02f, 8.84452686e-02f, -2.05771755e-02f,
  -4.58501577e-02f, -1.13486215e-01f, 1.02137923e-01f, 1.43506199e-01f, 1.33173600e-01f, -1.78795122e-02f, 2.19391257e-01f, 1.38460472e-01f, 1.71026468e-01f, -3.25599313e-01f,
  7.15920031e-02f, -4.21684571e-02f, 4.80085574e-02f, 1.79927181e-02f, -1.68412458e-02f, -1.18446806e-02f, -2.46419553e-02f, 2.23959889e-02f, 4.21251841e-02f, -5.51581942e-02f,
  8.37186724e-02f, -9.50256363e-02f, 1.10061336e-02f, -5.16340844e-02f, -5.16759977e-02f, 3.50301564e-02f, 7.27490559e-02f, 4.95907478e-02f, 5.20850681e-02f, -2.29347292e-02f,
  9.60174501e-02f, 1.47384241e-01f, -4.17120941e-02f, 2.96412203e-02f, 3.35453898e-02f, -5.87306358e-02f, -1.31929040e-01f, -2.55068112e-02f, -1.01030730e-01f, 7.63750374e-02f,
  -4.38826323e-01f, 3.65750909e-01f, -2.51090556e-01f, 7.77644962e-02f, -1.03810549e-01f, 4.82869800e-03f, -1.58257596e-02f, 1.11159183e-01f, -5.81438355e-02f, 9.86353755e-02f,
  1.63034931e-01f, -4.00214382e-02f, -1.48787111e-01f, 4.55287360e-02f, 2.60736477e-02f, 6.45403340e-02f, -1.89682338e-02f, -2.27595344e-02f, 1.09302126e-01f, 7.82339126e-02f,
  1.11651763e-01f, -1.63978767e-02f, -7.38930032e-02f, 3.82475778e-02f, 7.69723393e-03f, 8.04237053e-02f, -3.61399688e-02f, 6.99653104e-02f, 6.23061731e-02f, -3.24272543e-01f,
  5.56666136e-01f, -2.55506814e-01f, -4.95768964e-01f, 1.07008509e-01f, -1.10689513e-01f, -3.75957415e-02f, -2.13009402e-01f, 2.56235421e-01f, 2.19761446e-01f, -8.82858709e-02f,
  8.74310508e-02f, 2.53139764e-01f, 1.32878721e-01f, 1.61853999e-01f, 2.48010501e-01f, -2.07692370e-01f, -2.79189050e-01f, -4.48842496e-02f, 2.28162408e-01f, 2.77397215e-01f,
  1.24068394e-01f, 5.35553023e-02f, 2.23420277e-01f, 1.86189562e-01f, -2.23273411e-01f, 3.89786437e-02f, -3.25992763e-01f, -1.38875365e-01f, -1.31056637e-01f, -5.26686609e-01f,
  -2.77668625e-01f, 6.87375851e-03f, 3.77109759e-02f, 1.50705278e-01f, -2.34234318e-01f, -1.16230408e-02f, -5.32095619e-02f, -1.11090675e-01f, 4.30709273e-02f, -5.23238406e-02f,
  2.67247251e-05f, 2.71819364e-02f, -1.16159744e-03f, -7.40500018e-02f, -7.11594969e-02f, 9.18234661e-02f, 8.34044162e-03f, 5.78632753e-04f, -1.18234139e-02f, -8.98354501e-02f,
  -1.44253343e-01f, -1.16815366e-01f, -8.06526616e-02f, -1.51206568e-01f, 7.19820037e-02f, 1.02347039e-01f, -1.11158900e-01f, -1.87640265e-02f, -7.87822902e-02f, -3.34772438e-01f,
  -3.71556878e-02f, -3.43904532e-02f, -4.18388285e-02f, 2.44016554e-02f, 1.48231700e-01f, -9.24218968e-02f, -1.91604868e-02f, -9.07339975e-02f, 1.66083366e-01f, -4.38245274e-02f,
  -1.89554803e-02f, 6.48710702e-04f, -9.09436494e-02f, -6.01897687e-02f, -1.49066411e-02f, -9.22358222e-03f, 2.06800513e-02f, -8.60332325e-02f, 2.65987441e-02f, 4.36744317e-02f,
  6.79445565e-02f, -9.83699560e-02f, -1.64128728e-02f, 3.43597978e-02f, -3.73554672e-03f, -2.63103805e-02f, -5.04863486e-02f, -7.22282976e-02f, 1.20129637e-01f, 1.03925437e-01f,
  1.49929389e-01f, 1.22198470e-01f, 3.44830826e-02f, 1.21315733e-01f, -1.78578153e-01f, -5.78499585e-02f, 4.39248532e-02f, -1.97821651e-02f, 1.03296041e-02f, 4.89951074e-02f,
  6.87155128e-02f, 5.64606711e-02f, -2.99651898e-03f, -9.50507373e-02f, 3.39552052e-02f, 1.28860483e-02f, 7.32447533e-03f, -4.14519422e-02f, 1.31757095e-01f, -1.09056169e-02f,
  -3.79127800e-03f, 3.32276858e-02f, 8.56257379e-02f, 6.76569045e-02f, -2.47646645e-02f, 1.92853153e-01f, 1.79535113e-02f, -7.96844065e-02f, 9.84011665e-02f, 4.00478058e-02f,
  -1.01014867e-01f, 1.21540032e-01f, -4.53631505e-02f, 1.23726249e-01f, 2.73021311e-01f, 1.83571830e-01f, -6.79508671e-02f, 1.10621534e-01f, 2.13027120e-01f, 5.21553606e-02f,
  2.11559117e-01f, 2.27501556e-01f, -6.98741600e-02f, -4.16248254e-02f, -2.74138808e-01f, -1.71899378e-01f, -2.37874284e-01f, -2.01437235e-01f, -1.32450670e-01f, 1.31615987e-02f,
  -1.44229289e-02f, -1.25163072e-03f, -9.39206332e-02f, 8.30826070e-03f, -4.28892393e-03f, -2.49016568e-01f, -2.76387453e-01f, -2.02633545e-01f, -1.74327582e-01f, -2.88677663e-01f,
  -1.53880000e-01f, 8.59736949e-02f, 8.25436264e-02f, 7.98675120e-02f, -5.25702462e-02f, 2.42594093e-01f, 6.34617582e-02f, 8.60165525e-03f, 1.44222319e-01f, -1.66112985e-02f,
  -9.13219899e-02f, 1.61285967e-01f, -5.74054681e-02f, 5.58524067e-03f, -4.04999331e-02f, -1.24623790e-01f, 1.01905614e-02f, -1.29580855e-01f, -6.66704625e-02f, 2.83546094e-02f,
  7.51210749e-02f, -6.56505451e-02f, -1.66306868e-01f, 7.86762089e-02f, 4.84274402e-02f, -1.14976764e-01f, 6.46088347e-02f, 8.51729661e-02f, -1.43005267e-01f, -2.02868119e-01f,
  -2.54046656e-02f, -3.88569571e-02f, -8.61718878e-02f, 2.07618803e-01f, -5.39181419e-02f, -7.72750899e-02f, 1.98662058e-02f, -1.25065386e-01f, -1.10378094e-01f, 2.20100973e-02f,
  1.07716598e-01f, 4.51798784e-03f, 7.72045702e-02f, -9.68511924e-02f, -3.00028659e-02f, -6.89731613e-02f, -8.82776603e-02f, -2.69944400e-01f, -1.38870448e-01f, -3.62783447e-02f,
  -7.37202168e-02f, 2.49810703e-03f, -6.37195036e-02f, -8.81358013e-02f, -1.11562729e-01f, -4.37195338e-02f, -7.24839866e-02f, 8.79024565e-02f, 8.79022852e-02f, 1.73491072e-02f,
  2.21232399e-02f, 7.91396499e-02f, -1.00523785e-01f, -6.74927533e-02f, -1.76799834e-01f, 3.65419760e-02f, -1.87015329e-02f, -6.91031385e-03f, -9.97495949e-02f, 4.44077030e-02f,
  -1.26295030e-01f, -9.23885778e-02f, 3.17470841e-02f, -6.63836673e-02f, 7.54418746e-02f, -1.05765993e-02f, -1.30293176e-01f, -2.96875149e-01f, -9.05862376e-02f, 3.47131006e-02f,
  -6.43598065e-02f, -2.78566360e-01f, -1.72754601e-01f, -9.51336250e-02f, -1.69090182e-01f, -1.02783076e-01f, -1.16818778e-01f, -6.04858808e-02f, -2.76218235e-01f, -1.27741978e-01f,
  3.93525183e-01f, -1.10087015e-01f, -3.06336880e-01f, 6.08251728e-02f, -1.73395336e-01f, -1.30243227e-01f, -1.69790879e-01f, 1.38057873e-01f, 1.83117941e-01f, -1.75864056e-01f,
  2.96725985e-02f, 1.27576560e-01f, -1.67427883e-02f, -1.16221890e-01f, -1.71564631e-02f, -3.19046348e-01f, -2.67025203e-01f, -4.66208756e-02f, 1.24405622e-01f, 4.43824492e-02f,
  -2.83607021e-02f, -3.49140652e-02f, 1.01318739e-01f, -3.42003107e-02f, -2.78296530e-01f, -1.95987448e-01f, -3.92263323e-01f, -2.19114304e-01f, -3.12607199e-01f, -4.95527655e-01f,
  -3.38045835e-01f, 6.05793037e-02f, 6.89980714e-03f, 9.33341384e-02f, -6.67325929e-02f, 2.56121848e-02f, 7.42250383e-02f, 5.77866733e-02f, 1.84764862e-01f, -7.52616525e-02f,
  -4.01412770e-02f, 6.42431825e-02f, 1.40082240e-01f, -5.41496929e-03f, -1.61972083e-02f, 3.76729704e-02f, 2.58477265e-03f, 4.96449433e-02f, 1.30208358e-02f, -3.28203328e-02f,
  4.73949797e-02f, 2.93133799e-02f, 3.57288048e-02f, 6.30034432e-02f, 5.21527827e-02f, 6.96604401e-02f, -1.71527136e-02f, 5.52581884e-02f, -7.21688047e-02f, -1.08403608e-01f,
  7.73516148e-02f, 5.81802204e-02f, 2.71341633e-02f, 9.37848166e-02f, 1.29248872e-01f, 7.24706426e-02f, -4.18850081e-03f, 5.64324297e-02f, 2.10206900e-02f, -1.48668059e-03f,
  -2.23293472e-02f, -3.36769819e-02f, 2.91616768e-02f, -3.01686060e-02f, -3.78680229e-02f, -1.86335295e-02f, -1.15626985e-02f, 5.40042967e-02f, 9.34463069e-02f, -3.05950381e-02f,
  3.42627130e-02f, -5.60719669e-02f, -2.48207171e-02f, -1.14711501e-01f, -1.10223055e-01f, -6.30310997e-02f, -9.87156481e-02f, 2.26097815e-02f, 9.74664167e-02f, -8.70899484e-02f,
  1.67606652e-01f, -1.22166099e-02f, -2.00506836e-01f, -1.26143202e-01f, -6.90664351e-02f, 4.76350114e-02f, -1.27702028e-01f, -6.00312799e-02f, -6.98282942e-02f, -5.08313738e-02f,
  3.76377814e-02f, 5.33487387e-02f, 7.03991577e-02f, -7.77671440e-03f, 1.00430392e-01f, 4.69032340e-02f, 2.74206121e-02f, -1.08520025e-02f, -6.04947805e-02f, -1.76348761e-01f,
  -9.38682109e-02f, 4.55740765e-02f, 1.91605136e-01f, 2.67601293e-02f, 4.80545796e-02f, 6.07685037e-02f, -6.74178377e-02f, 2.85226456e-03f, 2.77062505e-03f, -1.31585542e-03f,
  -7.17003286e-01f, -1.32732227e-01f, -9.80995875e-03f, -4.25151080e-01f, -9.34503227e-02f, 2.35066190e-01f, 2.70968169e-01f, 5.57859279e-02f, -4.57208306e-02f, -3.70131172e-02f,
  -1.64746307e-02f, -3.32325846e-02f, -1.93243504e-01f, 6.07267357e-02f, 8.57917070e-02f, -3.92407440e-02f, -2.24898592e-01f, -2.29388162e-01f, 1.23500653e-01f, 2.68647373e-01f,
  1.05915383e-01f, -2.31128916e-01f, -2.59784758e-01f, -1.92337602e-01f, -1.71749949e-01f, -2.99535483e-01f, -2.83970267e-01f, -2.39271298e-01f, -5.57353999e-03f, -3.68695796e-01f,
  -8.57012868e-02f, -1.35718152e-01f, 1.36992009e-02f, -1.44509152e-01f, -8.87982920e-02f, 3.59763280e-02f, 1.81330349e-02f, -7.64348134e-02f, -2.02404149e-02f, 5.90194277e-02f,
  7.75004691e-03f, 1.03242680e-01f, -3.14727761e-02f, 3.63521874e-02f, -1.50793111e-02f, -5.47566311e-03f, 5.32245375e-02f, 5.12696728e-02f, -8.02360941e-03f, 1.21388137e-01f,
  9.58002955e-02f, -1.69295985e-02f, 1.70125198e-02f, 6.54645488e-02f, 1.89633206e-01f, -6.60233498e-02f, 1.94922034e-02f, 1.02461226e-01f, 4.23734672e-02f, -1.86784953e-01f,
  1.00604177e-01f, -7.24537764e-03f, 3.18255536e-02f, 2.15547774e-02f, -5.72164916e-02f, -3.45912762e-02f, -5.37098646e-02f, 2.22626291e-02f, 3.26628424e-02f, -6.13065921e-02f,
  4.64297235e-02f, -1.52738588e-02f, 5.31541184e-02f, -1.03976555e-01f, -7.38097280e-02f, -3.75954807e-03f, -1.90580580e-02f, 3.35527264e-04f, 4.67561372e-02f, -1.15703963e-01f,
  5.94695210e-02f, 2.61169653e-02f, -1.65200084e-01f, -4.47747037e-02f, 7.95408487e-02f, -8.20563436e-02f, 7.44705349e-02f, 1.92832515e-01f, 5.60082048e-02f, 1.07438385e-01f,
  -3.82053345e-01f, 1.09336764e-01f, -2.43860036e-01f, 3.81354839e-02f, -1.72534287e-01f, 3.26582901e-02f, -4.54906933e-02f, -7.91059956e-02f, -9.15661156e-02f, 9.91979092e-02f,
  1.63794711e-01f, 4.73103523e-02f, -3.42391841e-02f, 8.77869874e-02f, -3.01867221e-02f, 4.30224128e-02f, -2.10937802e-02f, -9.04274508e-02f, 6.13984019e-02f, 1.75887764e-01f,
  9.52701494e-02f, 2.16535293e-03f, -1.57208994e-01f, -6.35613948e-02f, 4.57534604e-02f, -1.32889347e-02f, -1.16080649e-01f, 2.26028748e-02f, -1.17292762e-01f, -2.45934054e-01f,
  -2.75078595e-01f, 3.26556116e-02f, -7.29200318e-02f, 9.32133347e-02f, 1.17877170e-01f, 2.58139186e-02f, 3.44978213e-01f, 6.64241016e-02f, -5.97061291e-02f, -1.25318244e-02f,
  -4.08875905e-02f, -1.70145527e-01f, 4.83083352e-02f, -5.04570045e-02f, 2.36069951e-02f, 2.61049122e-01f, 3.21303546e-01f, -1.00089155e-01f, -4.13727969e-01f, -8.45105574e-02f,
  9.23092756e-03f, -5.87220602e-02f, -4.02113289e-01f, -2.48565063e-01f, 5.92549704e-02f, -7.91750699e-02f, 8.86729658e-02f, 7.94836283e-02f, -3.91735025e-02f, 1.80430204e-01f,
  -1.83850989e-01f, -1.88423127e-01f, -3.38216946e-02f, -5.77069037e-02f, 2.09926292e-02f, -1.08405173e-01f, -5.11435419e-02f, -1.39865667e-01f, 6.70145154e-02f, -3.56337912e-02f,
  7.47185126e-02f, -7.00897863e-03f, 7.05588683e-02f, -8.79537836e-02f, -1.68481156e-01f, 6.93646669e-02f, 2.58521214e-02f, -1.16774373e-01f, -2.62995392e-01f, -1.21548004e-01f,
  1.67341575e-01f, -1.08660266e-01f, -1.42185718e-01f, 1.26109406e-01f, 3.01927179e-02f, -1.34488136e-01f, -1.78224653e-01f, -2.29973957e-01f, -2.40055829e-01f, -2.22487785e-02f,
  8.93609133e-03f, 6.20347373e-02f, -6.18698932e-02f, 1.23111531e-01f, 9.78840515e-02f, 2.81888768e-02f, 6.79445639e-02f, 7.89674744e-03f, -1.58003233e-02f, -7.47128651e-02f,
  -3.65081578e-02f, 3.61923762e-02f, 1.21657560e-02f, 7.80699030e-03f, 2.56793853e-02f, -7.08510727e-02f, -2.39918623e-02f, -2.72979606e-02f, -1.18187955e-02f, 2.03863457e-02f,
  -1.28124774e-01f, 1.11398119e-02f, 6.71226531e-03f, 5.28382920e-02f, 1.28012314e-01f, 3.51306908e-02f, 2.10838150e-02f, -2.93320864e-02f, -3.77430744e-03f, 6.04864918e-02f,
  -1.12524740e-01f, 1.28712848e-01f, 5.52785173e-02f, -3.61820348e-02f, -3.76941846e-03f, -5.38352504e-02f, -4.18193154e-02f, -2.86300201e-02f, -1.12675708e-02f, -4.31457572e-02f,
  1.02033289e-02f, 1.29859328e-01f, 1.37090549e-01f, 1.15395747e-01f, -1.46581113e-01f, -7.09936172e-02f, 1.29311308e-01f, -1.08953595e-01f, -1.66187912e-01f, -1.29912747e-03f,
  1.76276758e-01f, -1.22434057e-01f, -9.72212628e-02f, -5.13763912e-02f, 1.46399483e-01f, -6.31745681e-02f, -1.19667143e-01f, -4.12670672e-02f, -1.62350759e-01f, 2.36387253e-02f,
  -2.07115024e-01f, -2.04394728e-01f, -3.73377055e-01f, -1.35646174e-02f, 2.72077680e-01f, 1.48943827e-01f, -1.42210171e-01f, -1.34322107e-01f, 8.15048367e-02f, -3.15988921e-02f,
  9.63587612e-02f, 3.61898512e-01f, 8.60569775e-02f, 1.28530174e-01f, -1.93843201e-01f, -1.73598811e-01f, -1.39514282e-01f, -6.68934658e-02f, 9.37183108e-03f, 3.72962475e-01f,
  3.31371605e-01f, -3.49645242e-02f, -1.28252506e-02f, 5.31850476e-03f, 8.39643553e-02f, 4.72907275e-02f, -1.37622684e-01f, -4.11455445e-02f, 1.51693180e-01f, 1.14629976e-01f,
  -1.20912395e-01f, -9.79447737e-02f, 2.03483067e-02f, 1.75568268e-01f, 4.40627150e-02f, -1.49624035e-01f, 1.01350345e-01f, -2.29078904e-01f, -8.25024843e-02f, -1.03676103e-01f,
  2.00261939e-02f, 2.46294364e-02f, 9.54630375e-02f, 8.86396244e-02f, 1.34394303e-01f, 6.00861870e-02f, -1.59863323e-01f, -1.66412011e-01f, -2.58440286e-01f, -4.03223298e-02f,
  2.96164602e-01f, 2.04654500e-01f, -6.80059493e-02f, 1.36995250e-02f, -7.02442452e-02f, -1.31541505e-01f, -2.93674041e-02f, 1.50226057e-01f, -3.17087054e-01f, -2.73268819e-01f,
  -5.87411225e-02f, 6.47841617e-02f, -5.56114055e-02f, -1.19805686e-01f, 1.42642215e-01f, -1.26810288e-02f, 2.37787105e-02f, 4.97491881e-02f, 6.89281747e-02f, -1.48760909e-02f,
  4.28063534e-02f, 8.58449750e-03f, -1.10059017e-02f, -5.32247759e-02f, 4.96217944e-02f, -1.01158023e-01f, 3.65862437e-02f, -3.28224152e-02f, -5.65188713e-02f, -1.21188313e-02f,
  1.10956430e-01f, 9.61131826e-02f, -3.68338339e-02f, 7.93126598e-02f, 3.42049189e-02f, -1.05190642e-01f, -2.99441572e-02f, 1.28642702e-02f, -1.58464521e-01f, -4.46502566e-02f,
  -1.61207333e-01f, 7.58565292e-02f, 4.99919802e-02f, 8.79324749e-02f, 4.65968484e-03f, -1.01620108e-02f, 5.93109243e-02f, 7.04525635e-02f, 3.21148187e-02f, -3.87528352e-02f,
  8.73378217e-02f, -1.71465203e-01f, -5.57784066e-02f, 3.20216715e-02f, 5.76312840e-02f, 1.51531070e-01f, -6.72433851e-03f, -5.25053553e-02f, -7.54429176e-02f, 9.95911807e-02f,
  -3.70733999e-02f, 3.19488160e-02f, -1.65587813e-02f, -4.98797446e-02f, 8.31585675e-02f, -4.91790473e-03f, -7.14001879e-02f, -4.50267009e-02f, -2.99417436e-01f, -4.66367781e-01f,
  7.09891081e-01f, -3.57529104e-01f, 4.77616698e-01f, 5.82355447e-02f, -1.70837641e-01f, 2.62199212e-02f, -1.08779237e-01f, -2.35135537e-02f, 7.38518983e-02f, -2.14577429e-02f,
  -2.11570874e-01f, -1.46247549e-02f, 2.73168785e-03f, 4.25027758e-02f, 1.53162077e-01f, -6.96272450e-03f, 3.28028649e-02f, 4.55029100e-01f, 4.21214581e-01f, 2.02983245e-01f,
  -2.03182414e-01f, 1.31885603e-01f, 3.06890219e-01f, 2.66785741e-01f, -7.91997015e-02f, 5.06776422e-02f, 1.21160485e-02f, -6.04586937e-02f, -1.55012235e-01f, 8.87203589e-02f,
  1.67702101e-02f, 2.32783079e-01f, 6.12268634e-02f, 2.85551902e-02f, 1.38076628e-02f, 4.37264815e-02f, 5.30302599e-02f, 3.00911292e-02f, -3.61758322e-02f, -2.76893061e-02f,
  3.51037681e-02f, -5.76048121e-02f, -9.15715322e-02f, 1.92011625e-03f, 1.83797032e-02f, 9.16597769e-02f, 4.52146977e-02f, 1.81149662e-01f, 9.97430980e-02f, 1.96441393e-02f,
  -1.75344840e-01f, -9.24913213e-02f, -7.83442184e-02f, -9.67018306e-03f, 3.29100788e-02f, 3.46933715e-02f, -4.21148017e-02f, 1.11087278e-01f, 5.97448349e-02f, 8.51460397e-02f,
  -1.23581804e-01f, -2.88404692e-02f, -7.06341788e-02f, -2.54319794e-02f, 9.89757776e-02f, -5.56418821e-02f, -1.82307232e-02f, -4.23813276e-02f, 2.13693902e-02f, 7.50827342e-02f,
  -1.04008680e-02f, 5.99323101e-02f, -4.08706479e-02f, -6.97949603e-02f, -5.48262969e-02f, -6.46333967e-04f, 1.06252365e-01f, -2.77848784e-02f, -2.29176581e-01f, 4.66699116e-02f,
  5.42793311e-02f, 8.81937146e-02f, -4.06629667e-02f, 5.52461520e-02f, -9.49074477e-02f, 7.18732104e-02f, -7.48606995e-02f, -1.01905175e-01f, -1.18694551e-01f, 4.02483195e-02f,
  -4.94714737e-01f, 5.73722608e-02f, -7.10540339e-02f, 1.18571341e-01f, 5.14178164e-02f, -2.23375913e-02f, 4.03905008e-03f, 3.24496180e-02f, -9.27417353e-02f, -9.84399468e-02f,
  -4.99776751e-02f, 1.06862672e-01f, -1.31312490e-01f, 4.91102375e-02f, 1.56976774e-01f, -2.78767082e-03f, -1.62705570e-01f, 9.17340592e-02f, -5.01938723e-02f, -1.21300302e-01f,
  -1.55741259e-01f, -7.96618965e-03f, 3.54022048e-02f, -4.61384431e-02f, -2.46435422e-02f, -6.53526094e-03f, -1.24195918e-01f, -6.21628128e-02f, 4.30052280e-02f, -1.56901300e-01f,
  -6.15528345e-01f, -3.06285489e-02f, -8.55992511e-02f, -3.28048408e-01f, 8.46355185e-02f, 3.24642301e-01f, 3.17791790e-01f, -7.42806941e-02f, -1.15709931e-01f, 1.30520631e-02f,
  2.39863440e-01f, -3.89676914e-03f, 7.11809248e-02f, 8.02733600e-02f, 2.38543167e-03f, 9.90619138e-02f, -1.35626933e-02f, -1.04207106e-01f, -6.84918910e-02f, 8.44114944e-02f,
  1.42240807e-01f, -1.92682743e-01f, -3.90480459e-01f, -2.22563416e-01f, -4.65556830e-02f, -1.07345872e-01f, -1.61861748e-01f, -1.11922331e-01f, 1.82787687e-01f, -8.09561983e-02f,
  -3.33023630e-02f, -1.50207076e-02f, 1.62266433e-01f, -1.46391377e-01f, -8.19904788e-04f, -1.71838120e-01f, 3.21210921e-02f, -8.96882713e-02f, 4.98111024e-02f, -9.87927541e-02f,
  -1.71963662e-01f, 9.31114107e-02f, -1.67874545e-01f, -5.83384708e-02f, -2.57071078e-01f, -1.68535799e-01f, -2.79810913e-02f, -8.50902498e-02f, -6.55976012e-02f, 2.98857014e-03f,
  1.59930751e-01f, 1.53478771e-01f, -1.58771053e-01f, 6.91452250e-02f, 6.56509027e-02f, -8.55527595e-02f, 3.81946824e-02f, 4.06656712e-02f, 1.46544501e-01f, -1.63666561e-01f,
  3.48774046e-02f, 8.71295780e-02f, -2.61258222e-02f, 1.37733323e-02f, 1.11829676e-02f, 1.89539250e-02f, 4.59934399e-02f, 4.27255780e-02f, 4.09401469e-02f, -7.47872144e-02f,
  5.37632965e-03f, 1.47331730e-01f, 2.65878886e-02f, -1.33365570e-02f, 1.34271048e-02f, 9.57564935e-02f, -7.89413452e-02f, 9.51386094e-02f, -5.17950542e-02f, -9.17780958e-03f,
  -1.15225511e-02f, 1.53480917e-02f, -1.22794494e-01f, -6.97504357e-02f, -5.55517450e-02f, 9.27543566e-02f, 3.38809118e-02f, -1.47765661e-02f, -3.41149941e-02f, -3.01355384e-02f,
  -4.10226762e-01f, 1.67855993e-01f, -3.30766477e-02f, -9.30887610e-02f, 1.28956363e-01f, 4.16360274e-02f, 1.92791410e-02f, -1.24791779e-01f, -3.02206818e-02f, -1.51242197e-01f,
  -1.95280701e-01f, -1.25313193e-01f, -1.81713909e-01f, 2.62742508e-02f, -1.35766536e-01f, -1.12842299e-01f, -5.21140620e-02f, -9.57770944e-02f, 5.60781620e-02f, -6.73143938e-02f,
  -1.70497060e-01f, -3.86643410e-02f, -2.15252951e-01f, -7.51669332e-02f, 3.61042470e-02f, -1.07452877e-01f, -1.27544969e-01f, -1.15053914e-01f, -3.58472355e-02f, -3.05700153e-01f,
  7.51334667e-01f, -1.28164187e-01f, -5.17743230e-01f, 1.35775223e-01f, -3.48705649e-01f, -1.34062052e-01f, -3.31199527e-01f, -2.39179228e-02f, 1.46202177e-01f, -3.06159914e-01f,
  -1.27633467e-01f, 2.92045712e-01f, 5.36179692e-02f, 4.97890189e-02f, 7.95733556e-02f, -2.16038987e-01f, -2.12970704e-01f, -5.90878166e-02f, 1.65859491e-01f, 8.17878097e-02f,
  -7.16880895e-03f, 1.41491652e-01f, 2.36297563e-01f, 5.44549450e-02f, -1.15168542e-01f, 6.36545643e-02f, -3.07076454e-01f, -1.16038911e-01f, -3.23775932e-02f, -2.73715228e-01f,
  -3.07776272e-01f, -7.86827430e-02f, -1.60031784e-02f, 8.54333788e-02f, 5.83575182e-02f, -1.38012378e-03f, -6.51298165e-02f, -1.57492291e-02f, -6.14494877e-03f, -7.83747584e-02f,
  2.64020450e-02f, 5.03851995e-02f, 9.06341448e-02f, 6.40424192e-02f, -4.73274477e-02f, 1.05566055e-01f, 7.52121257e-03f, 1.80713590e-02f, -1.48860499e-01f, -6.91532642e-02f,
  -3.77361923e-02f, -1.16310250e-02f, -5.02488166e-02f, -7.35588893e-02f, -1.82688441e-02f, 3.20083015e-02f, -1.09655075e-01f, -9.44115594e-02f, -7.98681304e-02f, -1.33691013e-01f,
  -2.71863770e-02f, -1.07087299e-01f, 5.86924958e-04f, -3.88683192e-02f, -5.71946092e-02f, 1.66466329e-02f, -4.81983274e-02f, 6.41076118e-02f, 2.31807511e-02f, 9.58331376e-02f,
  -5.43152168e-02f, -2.07714625e-02f, 1.03846788e-01f, -6.83443015e-03f, -9.70347505e-03f, 6.47623986e-02f, 2.55417381e-03f, 6.71091606e-04f, 3.66853327e-02f, 2.53655203e-02f,
  3.73454764e-02f, 4.19620201e-02f, -9.99966785e-02f, 7.94436932e-02f, 2.49854997e-02f, 3.22469175e-02f, -7.00276531e-03f, -8.11901223e-03f, 3.97321470e-02f, 1.23750465e-02f,
  9.60043296e-02f, -7.83565119e-02f, -1.79306809e-02f, 1.29344612e-01f, 6.73334152e-02f, -5.17513677e-02f, -4.25896980e-02f, -3.52657586e-02f, 1.54487798e-02f, -6.80654943e-02f,
  -2.14210059e-02f, 7.33339712e-02f, -4.66508679e-02f, -2.92026289e-02f, 8.40369165e-02f, -5.11026904e-02f, -3.68497297e-02f, 6.82241768e-02f, 7.97790065e-02f, -4.54474352e-02f,
  7.28888735e-02f, -1.79168489e-02f, 2.07147121e-01f, 1.75234675e-02f, 2.80319471e-02f, 1.25730857e-01f, -4.66127731e-02f, 1.78557802e-02f, 9.83249098e-02f, 6.84950650e-02f,
  2.24443436e-01f, -3.63065898e-01f, -3.14483345e-01f, 3.18188161e-01f, 1.22054867e-01f, 2.33073637e-01f, 2.12400287e-01f, 2.74663955e-01f, 3.72595668e-01f, 3.94852869e-02f,
  -3.41195673e-01f, -2.94311196e-01f, -4.75648224e-01f, -3.80410194e-01f, -1.37265965e-01f, -1.39350876e-01f, -8.37396681e-02f, -7.45366439e-02f, 1.46097004e-01f, 3.47638816e-01f,
  2.43077993e-01f, 2.06704542e-01f, 2.40063399e-01f, 3.52137275e-02f, 1.27348840e-01f, 4.77578118e-02f, -1.25945777e-01f, -7.69541934e-02f, -1.90797791e-01f, -3.60921949e-01f,
  -2.67949879e-01f, -2.26452857e-01f, 3.37850414e-02f, -4.37040552e-02f, -7.42800534e-03f, 9.28610191e-02f, 3.48813534e-02f, -1.27054036e-01f, -1.55743048e-01f, -3.94194908e-02f,
  -1.99960366e-01f, -1.13368720e-01f, -2.17702180e-01f, -1.71650052e-02f, 1.43848896e-01f, 9.39122438e-02f, -1.83758795e-01f, -2.28021801e-01f, -2.86847621e-01f, -1.49888083e-01f,
  -1.47762939e-01f, -2.75440335e-01f, -2.74954677e-01f, -1.57224163e-01f, -2.11744666e-01f, -5.43336663e-03f, -1.63420469e-01f, -2.05031112e-01f, -1.51204571e-01f, -6.68765604e-02f,
  2.05163155e-02f, -9.06142518e-02f, 2.04656776e-02f, 1.18661188e-01f, -3.58638167e-02f, -9.19851959e-02f, -1.04877003e-01f, -6.08738996e-02f, -4.26754244e-02f, 8.97293538e-02f,
  -8.21667239e-02f, -3.35988477e-02f, -6.50890246e-02f, 1.13225751e-01f, -2.49372376e-03f, 6.47404268e-02f, 6.46419525e-02f, -1.12349642e-02f, 5.06530609e-03f, 8.02853554e-02f,
  1.77543871e-02f, 2.06437241e-02f, 5.02884760e-02f, -5.47156930e-02f, -3.63144688e-02f, -3.37619372e-02f, 8.84392299e-04f, -1.94305032e-02f, 4.32751514e-02f, 5.32582365e-02f,
  2.46556029e-01f, -2.56963551e-01f, -6.34583309e-02f, 6.75217307e-04f, -6.96605071e-02f, 2.19742302e-02f, -2.53391676e-02f, 4.77569774e-02f, -9.15556177e-02f, -1.41944895e-02f,
  -6.34346306e-02f, 1.02527410e-01f, -9.98637453e-02f, 2.76028737e-02f, 1.56956539e-01f, 9.05551985e-02f, 1.03953622e-01f, -1.52607923e-02f, 1.53147459e-01f, 1.78068742e-01f,
  2.31705103e-02f, 2.57423252e-01f, 1.43984392e-01f, 8.24631453e-02f, 1.13396019e-01f, 2.35804051e-01f, 9.97010171e-02f, 1.88054249e-01f, 1.28170084e-02f, 3.79861712e-01f,
  2.31798440e-01f, -3.93451601e-02f, -3.82178694e-01f, 2.05964252e-01f, -1.63589239e-01f, -1.31044924e-01f, -2.50159562e-01f, 2.09184125e-01f, 1.40367702e-01f, -3.12999845e-01f,
  -2.02278078e-01f, -3.78317423e-02f, -1.99010104e-01f, -2.37780839e-01f, -3.05946618e-01f, -4.07834768e-01f, -3.64862949e-01f, -2.78020591e-01f, -1.13418043e-01f, -1.00732081e-01f,
  -1.24008782e-01f, -1.06323890e-01f, -6.84448928e-02f, -8.23330656e-02f, 1.04119062e-01f, -3.84575054e-02f, -2.49463588e-01f, -6.63598031e-02f, -7.93338567e-02f, -2.86550343e-01f,
  -3.06769222e-01f, 2.03345552e-01f, 4.62407209e-02f, -3.32607441e-02f, -5.46136163e-02f, 7.68012777e-02f, 2.12318301e-02f, 1.29461475e-02f, 2.36257032e-01f, -1.67215746e-02f,
  2.60964166e-02f, -1.69316381e-02f, 3.06395609e-02f, 1.66261885e-02f, 2.12188065e-02f, -6.41684532e-02f, 1.57428652e-01f, 1.24720074e-01f, 1.02966182e-01f, 2.00197622e-02f,
  1.03638962e-01f, -5.14768474e-02f, 4.95542586e-02f, 1.98030427e-01f, 1.16279632e-01f, 6.58869222e-02f, 2.41260186e-01f, 2.85998404e-01f, 1.70343012e-01f, 1.95997074e-01f,
  2.90762959e-03f, -1.42023051e-02f, -3.81203666e-02f, 8.12784731e-02f, 1.22300591e-02f, 1.16355076e-01f, 2.37147622e-02f, 1.05503879e-01f, 1.35674784e-02f, -7.76045695e-02f,
  1.24018349e-01f, 1.00363821e-01f, 1.19328931e-01f, -9.33493823e-02f, -2.25863039e-01f, -7.94787779e-02f, -1.05059557e-01f, -9.43318456e-02f, 4.06354386e-03f, 4.20827419e-02f,
  4.82646190e-02f, 1.62042335e-01f, -8.31139609e-02f, -1.38525605e-01f, -7.19969645e-02f, 7.72678703e-02f, -3.83655094e-02f, -6.36583865e-02f, -5.41274808e-02f, 6.42330423e-02f,
  2.70010307e-02f, -1.64581820e-01f, 1.76750403e-02f, 9.72328428e-03f, 7.66758099e-02f, -5.93920313e-02f, -7.11959079e-02f, -1.57672744e-02f, 5.61804473e-02f, 2.84822378e-02f,
  -2.88593769e-02f, -9.10758600e-02f, -3.20914313e-02f, 9.85201001e-02f, -2.60068569e-02f, -1.18984424e-01f, -7.05732871e-03f, 9.90389958e-02f, -1.00768387e-01f, -5.75958043e-02f,
  -3.58672589e-02f, -3.80090922e-02f, -3.30952629e-02f, 1.13565847e-01f, 6.95123449e-02f, -1.35354608e-01f, 2.49488149e-02f, 1.12985633e-01f, -5.32143451e-02f, 9.35541168e-02f,
  -8.50775912e-02f, -4.06729847e-01f, 1.26780346e-01f, 3.06346826e-02f, 9.55577344e-02f, -7.26237819e-02f, -6.84403598e-01f, -3.54598224e-01f, 8.14383402e-02f, -2.60379434e-01f,
  -4.28822488e-02f, 2.40934521e-01f, 1.41457260e-01f, -4.61725146e-02f, -5.03601253e-01f, -4.94722068e-01f, -9.74572301e-02f, 5.75486384e-02f, 5.76300593e-03f, -1.74283013e-01f,
  2.05433667e-02f, 7.71284774e-02f, 7.10203722e-02f, 1.05891414e-02f, 1.35526121e-01f, 2.17340365e-01f, 4.28922847e-02f, 1.33578479e-01f, 8.69776495e-03f, 2.45728716e-01f,
  -7.69046098e-02f, -4.92858402e-02f, -3.53873298e-02f, 3.83189805e-02f, 6.69487342e-02f, 4.88049164e-02f, 6.26460612e-02f, -5.64157777e-02f, 1.01023607e-01f, -1.10904872e-02f,
  -7.35162804e-03f, 2.90627275e-02f, 2.56540209e-01f, 1.42250419e-01f, -8.60791579e-02f, -2.74375111e-01f, 7.17970431e-02f, 1.16384747e-02f, -1.52891293e-01f, -7.79587179e-02f,
  1.71625055e-02f, 1.08000701e-02f, -8.17344487e-02f, -9.53968912e-02f, -2.67835140e-01f, -5.29642915e-03f, -9.38900262e-02f, 9.78426635e-02f, -1.26183210e-02f, -1.66170776e-01f,
  -5.61005296e-03f, 6.70877919e-02f, -2.10242253e-02f, -1.72667444e-01f, 3.37840207e-02f, -1.12196896e-02f, -3.15478742e-02f, 1.55315483e-02f, -5.62408706e-03f, -4.25802097e-02f,
  2.62857657e-02f, 9.97880772e-02f, -4.62869853e-02f, -5.44671528e-02f, 2.17782721e-01f, 6.27976358e-02f, 8.78690258e-02f, -6.62662834e-02f, 8.47612172e-02f, -1.44214351e-02f,
  1.06178997e-02f, -4.32479866e-02f, -5.75819798e-02f, -2.57955436e-02f, -1.75594876e-03f, 6.65651681e-03f, 2.76631936e-02f, 3.81899290e-02f, -3.78729180e-02f, 1.33545309e-01f,
  -1.07206494e-01f, 1.42758369e-01f, -1.98518232e-01f, -7.62770250e-02f, -4.38084640e-02f, 8.11289027e-02f, 1.47160053e-01f, 5.90896681e-02f, -6.83613345e-02f, -1.03996165e-01f,
  5.46948425e-03f, -1.14678383e-01f, -1.20586017e-02f, 9.80435908e-02f, -8.07416365e-02f, -1.57550983e-02f, -1.91569164e-01f, 7.84899369e-02f, -9.47406292e-02f, 8.80442094e-03f,
  -1.49085462e-01f, -1.82660356e-01f, -2.90629536e-01f, -1.07560039e-01f, -1.78872868e-02f, -2.36590341e-01f, -9.81652513e-02f, 1.28408447e-02f, -2.98403859e-01f, -3.58031034e-01f,
  -5.08389056e-01f, 3.95985134e-02f, -6.97404221e-02f, 2.65492648e-01f, 3.73400092e-01f, 2.52678007e-01f, 4.22013044e-01f, 2.29306802e-01f, 1.05195530e-01f, -2.16850056e-03f,
  -1.14788510e-01f, -5.21762595e-02f, 6.06697798e-02f, 1.28222719e-01f, 1.97746396e-01f, 2.73692220e-01f, 2.39826918e-01f, 1.50136100e-02f, -1.75849423e-01f, -2.46648844e-02f,
  1.56330407e-01f, -7.57310539e-02f, -2.38475561e-01f, -5.67111745e-02f, 1.34885162e-01f, 1.23850904e-01f, 1.04986522e-02f, 2.39220411e-02f, 1.20220497e-01f, 6.14286475e-02f,
  -9.11126435e-02f, -7.12679923e-02f, 3.80162597e-02f, -1.27264500e-01f, -2.22367436e-01f, -1.90464631e-01f, -5.90796918e-02f, 1.24625135e-02f, -2.47388687e-02f, -2.81137992e-02f,
  -1.45230908e-02f, -6.45971224e-02f, 4.77423146e-02f, -8.76699686e-02f, -2.57745683e-02f, -4.45318632e-02f, -1.56052306e-01f, -2.56810281e-02f, 2.07158163e-01f, 7.46593848e-02f,
  -7.55946264e-02f, 1.35074817e-02f, 1.20205402e-01f, 4.28103358e-02f, 7.91089982e-02f, -5.98263592e-02f, 4.34598513e-02f, -6.21214621e-02f, -9.53451395e-02f, -3.51060368e-02f,
  -7.01046064e-02f, -6.69696033e-02f, -1.55341282e-01f, -1.38251632e-01f, -1.22022308e-01f, -8.05486590e-02f, 1.25363916e-01f, 1.30426392e-01f, 2.64001098e-02f, -3.74049097e-02f,
  1.60751760e-01f, 1.22578695e-01f, -4.66410033e-02f, 1.18361838e-01f, -5.68168983e-02f, -4.98963036e-02f, 1.19075514e-01f, -1.00823410e-01f, -9.09573510e-02f, -4.89186682e-02f,
  -2.11522989e-02f, 5.41665442e-02f, -9.42623839e-02f, -1.05495289e-01f, -1.02382302e-02f, -2.69524008e-02f, -6.22762442e-02f, -6.43834993e-02f, -1.06219016e-01f, 3.25619839e-02f,
  2.35058740e-01f, 8.40478241e-02f, -3.60972323e-02f, -2.89950129e-02f, -1.21751733e-01f, -1.92851990e-01f, -1.30511776e-01f, 6.89761266e-02f, 1.10415086e-01f, 2.86354832e-02f,
  -3.62889059e-02f, -9.43563879e-02f, 3.69097330e-02f, -1.40598835e-02f, 8.86050984e-03f, -6.75579626e-03f, -2.09050462e-01f, 1.10189505e-01f, 1.06386945e-01f, -6.27432950e-03f,
  4.10384163e-02f, 4.81971428e-02f, 9.22970623e-02f, 1.59974188e-01f, 1.12116039e-01f, 1.28383666e-01f, -6.19553477e-02f, 9.19187348e-03f, -6.21727444e-02f, -7.56794736e-02f,
  5.36523759e-01f, 1.36280775e-01f, 2.86578417e-01f, 1.81193396e-01f, 2.01994658e-01f, 2.85371214e-01f, 4.60995466e-01f, 3.04895431e-01f, -3.53525952e-02f, 9.94803831e-02f,
  3.48029025e-02f, -1.56935930e-01f, -2.15520665e-01f, -1.35128111e-01f, 7.28905434e-03f, 7.84287304e-02f, 3.04813627e-02f, 2.05951929e-02f, 8.60231519e-02f, 8.08668211e-02f,
  -1.15829557e-01f, 5.99059351e-02f, 1.43756405e-01f, -1.57725215e-02f, 9.12689883e-03f, -1.36292964e-01f, -2.16014348e-02f, 1.11672908e-01f, -5.27372863e-03f, -2.46306658e-01f,
  -1.29747450e-01f, 3.23834807e-01f, -1.65906519e-01f, -1.33932158e-01f, 3.42899300e-02f, 3.03935222e-02f, -2.91560125e-02f, 1.29692823e-01f, -1.10596567e-02f, -1.01102941e-01f,
  -8.15882087e-02f, 1.00937150e-01f, 4.09822278e-02f, 1.82527125e-01f, 1.51887253e-01f, -7.01763332e-02f, 7.46436119e-02f, 1.11910187e-01f, -5.18647172e-02f, -1.01309195e-01f,
  4.63362001e-02f, 2.00383887e-01f, 9.64662954e-02f, 6.98233172e-02f, 6.76777437e-02f, 3.69117483e-02f, 5.91337718e-02f, 3.62283997e-02f, 2.62176152e-02f, 5.50853126e-02f,
  -6.64816052e-02f, 1.26899987e-01f, 6.26444072e-02f, 1.10222079e-01f, 1.79596037e-01f, 1.04734175e-01f, 7.50644952e-02f, 1.07107170e-01f, 1.11912474e-01f, 1.46788299e-01f,
  -2.10927669e-02f, 1.42511815e-01f, 1.04881771e-01f, 1.35676693e-02f, -6.10280223e-02f, 1.19223937e-01f, 4.96675558e-02f, -7.28525640e-03f, -9.82690020e-04f, 1.37229055e-01f,
  1.32540688e-02f, 1.04654014e-01f, 4.57746834e-02f, 1.34278148e-01f, 5.79872951e-02f, 1.08238287e-01f, -1.54514998e-01f, 1.55761568e-02f, -1.05374458e-03f, -1.43491179e-01f,
  -8.36929753e-02f, 1.55993313e-01f, -8.72360691e-02f, -1.71289191e-01f, 7.68874735e-02f, -1.18137471e-01f, 4.07960974e-02f, -1.00989379e-01f, -1.53234303e-01f, -1.68047771e-01f,
  -1.12349257e-01f, -2.69413032e-02f, 9.72701535e-02f, 1.80045649e-01f, 8.07858780e-02f, -1.55278118e-02f, -6.07013628e-02f, 1.58375189e-01f, -1.03442065e-01f, -1.96981892e-01f,
  -3.04382630e-02f, -3.68093094e-03f, -6.76056594e-02f, 4.01244722e-02f, -3.26635502e-02f, -1.82564944e-01f, -3.78150214e-03f, 1.61881391e-02f, -1.15041975e-02f, 9.66093391e-02f,
  4.03898686e-01f, -4.34646636e-01f, 1.40269056e-01f, 2.32490823e-01f, 7.17544034e-02f, 1.85735017e-01f, -1.34297535e-01f, -3.33644859e-02f, -1.25891969e-01f, -6.48314059e-02f,
  -4.05707099e-02f, 4.14739288e-02f, 3.41981389e-02f, 7.14468211e-03f, -8.54283273e-02f, -2.33047977e-01f, -6.40181825e-02f, 7.67051503e-02f, 1.63872898e-01f, 5.57727404e-02f,
  -2.00191617e-01f, -1.15387850e-01f, -1.46632329e-01f, -1.42049357e-01f, -3.31252217e-01f, -9.84251127e-02f, -1.77386895e-01f, -2.39070579e-01f, -3.02182585e-01f, -3.84830743e-01f,
  4.96421866e-02f, 1.77545056e-01f, 2.34039485e-01f, 1.84693225e-02f, -2.15372555e-02f, 5.40692098e-02f, 1.21616431e-01f, -6.24216581e-03f, 9.60657075e-02f, 1.21207438e-01f,
  6.79122582e-02f, -7.80076236e-02f, -6.81166574e-02f, -7.75384977e-02f, -3.36188264e-02f, 7.62072578e-02f, -6.97217286e-02f, -9.43303704e-02f, -1.54247424e-02f, -8.56018811e-02f,
  -1.52163729e-01f, 1.39660835e-01f, 8.02480727e-02f, 1.25463726e-02f, -8.28316659e-02f, 1.50928751e-01f, -4.12848927e-02f, 3.14757787e-02f, 1.21779680e-01f, -1.51293203e-01f,
  -2.39302441e-02f, -9.98859107e-03f, -3.62713709e-02f, 1.06584551e-02f, -1.30759105e-01f, 6.46361262e-02f, 2.62558963e-02f, -8.02105293e-02f, 3.20044197e-02f, -1.61253065e-01f,
  -1.26332855e-02f, -1.12724684e-01f, -1.21667005e-01f, -7.38446182e-03f, -5.13189249e-02f, -5.10295555e-02f, 1.06828220e-01f, 6.42706081e-02f, -4.44212602e-03f, 1.84343699e-02f,
  9.33062471e-03f, -2.37733889e-02f, -6.52633384e-02f, -2.33693764e-01f, -3.40095423e-02f, -2.52072494e-02f, 3.90355773e-02f, -1.19955853e-01f, -1.61868632e-01f, -7.13286698e-02f,
  -1.31859276e-02f, 3.08989435e-01f, 7.34113902e-02f, -1.96399763e-02f, 1.02627814e-01f, -5.44890836e-02f, -5.21886088e-02f, 9.13211051e-03f, 1.89517457e-02f, 1.83704659e-01f,
  3.71615738e-02f, 9.03407261e-02f, -7.41619384e-03f, 1.95104466e-03f, 7.97729939e-02f, 1.40788510e-01f, -7.14538842e-02f, 4.99370769e-02f, 2.29666177e-02f, 1.36944465e-02f,
  -5.68697006e-02f, 1.34298995e-01f, 1.81698754e-01f, 1.73843250e-01f, 1.64838079e-02f, 1.44447014e-01f, 6.24480695e-02f, 7.82166570e-02f, 2.45855048e-01f, 1.01803839e-02f,
  1.83023736e-01f, -1.32267326e-01f, -4.22438920e-01f, 6.06403500e-02f, -2.55128533e-01f, 3.77235562e-02f, -1.66433141e-01f, 1.86416462e-01f, 1.62214503e-01f, -1.71607018e-01f,
  -1.42504632e-01f, 3.17357071e-02f, -1.99013110e-02f, -9.55141559e-02f, 1.34816080e-01f, -5.98297156e-02f, -2.79892117e-01f, -1.48580313e-01f, 7.98644200e-02f, 1.75983369e-01f,
  7.88534954e-02f, 3.59206721e-02f, 2.36092418e-01f, 1.98790595e-01f, 3.16831134e-02f, 3.73099595e-02f, -1.73152313e-01f, -2.69416273e-02f, 9.44393054e-02f, -3.22468430e-01f,
  -2.69434422e-01f, -8.16862211e-02f, 1.13352574e-01f, 4.21971455e-02f, -1.25451535e-01f, -7.81277716e-02f, -5.21455146e-02f, -3.35073732e-02f, -8.94030854e-02f, -1.18924491e-01f,
  -2.35706031e-01f, -1.74958348e-01f, -2.07375512e-01f, 2.07281653e-02f, 4.83722240e-02f, 7.58205587e-03f, -6.79077804e-02f, -2.78487299e-02f, -2.09573209e-02f, -1.20473884e-01f,
  -1.29828617e-01f, -2.03846008e-01f, -6.90510720e-02f, 4.92175296e-02f, -8.73645768e-02f, 3.83091532e-02f, 2.25217864e-02f, 7.72233009e-02f, 9.75670666e-02f, 2.39840522e-02f,
  3.06151994e-03f, 9.99930128e-02f, 8.85832757e-02f, 6.76022694e-02f, 1.02302693e-01f, -2.47225724e-02f, -2.70470791e-02f, 1.35976896e-01f, 2.42226832e-02f, -1.35929808e-02f,
  5.19225672e-02f, -2.69372091e-02f, 5.50111420e-02f, 3.19934115e-02f, -7.94390142e-02f, -1.54420640e-03f, 3.12862881e-02f, 3.83625515e-02f, 1.34355295e-02f, -3.53427194e-02f,
  -4.64686081e-02f, 5.58690950e-02f, 3.47308554e-02f, 8.93225148e-02f, -7.09204525e-02f, -3.18621472e-02f, -1.00535110e-01f, -2.29581352e-02f, 3.84248677e-03f, -1.31820962e-01f,
  1.83806822e-01f, 3.88142876e-02f, 2.41995975e-02f, 5.43383844e-02f, -7.45810866e-02f, -1.00821583e-02f, -1.20017670e-01f, 4.48818691e-02f, -8.87209773e-02f, -1.17300898e-01f,
  -6.22442588e-02f, -1.20528648e-02f, -1.37977526e-01f, -1.18337661e-01f, 7.44655654e-02f, -2.06582583e-02f, 3.04952972e-02f, 6.66353628e-02f, -2.51287594e-02f, -1.88772846e-02f,
  2.59453189e-02f, 2.74371896e-02f, 1.54624328e-01f, 1.07891522e-01f, 1.27390116e-01f, 3.29332519e-03f, -1.37384320e-02f, 4.65631299e-02f, 4.83555682e-02f, 1.57197580e-01f,
  6.71007574e-01f, -5.35724223e-01f, 2.82784730e-01f, 2.61946350e-01f, 1.84646979e-01f, 2.09662393e-01f, -8.53197724e-02f, -4.81828079e-02f, 1.74499393e-01f, -1.64167449e-01f,
  -1.36497676e-01f, 2.28818327e-01f, 1.15489610e-01f, 2.48663463e-02f, -3.08464058e-02f, 3.28010507e-02f, 1.61038905e-01f, 2.64387071e-01f, 3.62546414e-01f, 1.76497310e-01f,
  -1.88141033e-01f, -6.90210834e-02f, -5.06995879e-02f, 1.46251479e-02f, -2.61788189e-01f, 7.22449198e-02f, -1.21896118e-01f, -1.96514755e-01f, -2.94779956e-01f, -6.07715808e-02f,
  -9.72533450e-02f, -1.71481371e-01f, 2.58896828e-01f, -4.98571545e-02f, -1.87137499e-01f, -4.04801741e-02f, 5.90882935e-02f, -1.17813058e-01f, 4.49026115e-02f, -1.19153284e-01f,
  -3.40921618e-02f, -3.69281024e-02f, 1.41065307e-02f, -2.43138298e-02f, -1.10334791e-01f, -2.50956416e-02f, -1.41751170e-01f, 9.53336805e-03f, 2.47971863e-02f, -5.89897111e-02f,
  -9.06404629e-02f, -2.66812332e-02f, -6.94710389e-02f, -2.83149257e-02f, 8.85626376e-02f, 1.50101870e-01f, -1.42563134e-01f, -5.04930094e-02f, 5.29008210e-02f, -1.91301480e-02f,
  7.24353567e-02f, 4.54235487e-02f, 1.12652414e-01f, -3.12326308e-02f, 5.67030162e-03f, 6.01351187e-02f, 7.80587643e-02f, -8.27921778e-02f, 4.36342210e-02f, -2.45267302e-02f,
  2.61197519e-02f, 4.87753935e-02f, 7.25566894e-02f, 5.87717779e-02f, 6.14759848e-02f, -3.81785184e-02f, -2.49311328e-02f, -9.16787088e-02f, 3.78781483e-02f, -1.53627871e-02f,
  -7.79762194e-02f, -4.21918370e-02f, -6.74761310e-02f, -3.31622250e-02f, -7.07856342e-02f, -6.73907772e-02f, 6.54621124e-02f, -1.69310227e-01f, -6.83454499e-02f, 8.22974816e-02f,
  -4.21565115e-01f, 3.19062591e-01f, 8.39194059e-02f, -8.43679458e-02f, -8.17811489e-02f, -1.46458417e-01f, 6.20338060e-02f, -5.14005832e-02f, -3.73279564e-02f, -5.82274469e-03f,
  -1.21227756e-01f, -3.57910953e-02f, -3.78720835e-02f, -6.80866987e-02f, 8.99689123e-02f, -7.20635206e-02f, -1.15093060e-01f, 9.41046551e-02f, -3.92252505e-02f, -1.14681363e-01f,
  -1.13897100e-01f, 1.52564257e-01f, 1.54986560e-01f, 9.35600102e-02f, 9.11558867e-02f, 2.51768827e-01f, 6.31181300e-02f, 1.05635293e-01f, 1.96516380e-01f, -3.03169955e-02f,
  -4.58445966e-01f, -3.17092627e-01f, 4.26622391e-01f, -3.53979796e-01f, -2.43833750e-01f, -3.08827341e-01f, -3.04109424e-01f, -1.28577754e-01f, -1.93511233e-01f, -2.79364377e-01f,
  -1.18317880e-01f, 1.72367796e-01f, 3.58974904e-01f, 1.68960109e-01f, 1.80935428e-01f, -1.83731481e-01f, 5.19885719e-02f, 3.23034286e-01f, 3.70027125e-01f, -3.49282771e-01f,
  -4.77271497e-01f, -8.34971145e-02f, 1.58285759e-02f, 9.08803716e-02f, -2.20815942e-01f, 6.25203475e-02f, 2.89838314e-01f, -1.24636509e-01f, -1.43724084e-01f, -1.49231115e-02f,
  -3.64136323e-02f, -1.31710708e-01f, 1.84736863e-01f, -9.24358331e-03f, -1.15293264e-01f, 1.09690288e-03f, 6.45100847e-02f, 3.33761238e-02f, 3.07210274e-02f, 6.73007816e-02f,
  -3.16737369e-02f, 2.84960046e-02f, 8.02948773e-02f, -5.83500974e-03f, -7.95838833e-02f, -1.06075250e-01f, -6.13042666e-03f, 1.99037433e-01f, 1.51363537e-01f, -1.94035724e-01f,
  -2.63885736e-01f, -2.60281324e-01f, 1.01702079e-01f, 1.52031690e-01f, 8.07651877e-02f, 4.41424586e-02f, 1.16798438e-01f, -7.74925156e-03f, 1.66600600e-01f, -5.43799922e-02f,
  -9.25958753e-02f, 8.47114325e-02f, -2.35273764e-02f, -2.44568251e-02f, -1.22035597e-03f, -1.50988419e-02f, 9.33330730e-02f, 2.19636112e-02f, 6.10422045e-02f, -1.97770279e-02f,
  -8.16052184e-02f, -1.91205908e-02f, 1.40966371e-01f, -6.59698024e-02f, -3.07417978e-02f, -2.79406644e-02f, -8.46832916e-02f, -3.59165147e-02f, 8.13410506e-02f, 2.33474616e-02f,
  -5.55863045e-03f, -7.07417876e-02f, -2.24360880e-02f, 5.35557084e-02f, -8.00384209e-02f, 8.03627670e-02f, -1.32463828e-01f, 1.89716108e-02f, 5.82425781e-02f, -7.50624314e-02f,
  1.41904086e-01f, 1.29902288e-01f, -2.82672606e-02f, 1.41387001e-01f, -5.22592664e-02f, -6.55206991e-03f, 2.53811982e-02f, 6.11616634e-02f, 4.66222800e-02f, -2.01715361e-02f,
  -2.12737899e-02f, -1.65846899e-01f, 7.68892094e-02f, -7.73772299e-02f, -4.95057665e-02f, -1.79557186e-02f, -2.89610296e-01f, -6.66533634e-02f, -6.88995467e-04f, -2.49371365e-01f,
  -1.07905820e-01f, -8.21402669e-02f, -9.42691565e-02f, 1.06025338e-01f, -1.68726116e-01f, 5.35572916e-02f, 2.27983832e-01f, 1.66920424e-02f, 8.78239945e-02f, -8.82854313e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 26)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 26;
const float L0_fan_Bp_bar_data[] = {
  1.37493998e-01f, 1.41337076e-02f, 5.29641844e-02f, 1.88144401e-01f, 1.41030848e-01f, 3.89752276e-02f, 1.29253522e-01f, 1.02744386e-01f, 6.44020289e-02f, 8.11190605e-02f,
  -1.40420750e-01f, -9.93020386e-02f, 9.41632465e-02f, 1.72799349e-01f, 2.34536320e-01f, 4.66069616e-02f, 3.70686455e-03f, 1.96126491e-01f, -5.97222857e-02f, 9.88816544e-02f,
  -1.30469417e-02f, 4.31948341e-02f, -9.25649256e-02f, -3.99462245e-02f, 3.51014912e-01f, 2.47469410e-01f
};

// L1_fan_Wp (Shape: 19 x 64)
const int L1_fan_Wp_rows = 19;
const int L1_fan_Wp_cols = 64;
const float L1_fan_Wp_data[] = {
  -5.59089426e-03f, 1.63945317e-01f, -4.83886003e-02f, -5.78554943e-02f, 5.57746412e-03f, -1.25630662e-01f, -7.03618079e-02f, -1.51416332e-01f, -3.06546520e-02f, -6.73827529e-02f,
  1.23042352e-01f, 2.98209712e-02f, -8.28214921e-03f, -1.63940668e-01f, 8.04880038e-02f, -8.92630294e-02f, -4.13409108e-03f, -1.27029434e-01f, 4.71867174e-02f, 3.41115668e-02f,
  -9.58081707e-02f, -5.04394174e-02f, -1.47554368e-01f, 1.38098402e-02f, -2.12615095e-02f, -1.00826144e-01f, 3.14993015e-03f, -8.97064358e-02f, -1.24870256e-01f, -1.20004073e-01f,
  9.17312354e-02f, 1.11012600e-01f, 2.00722720e-02f, -1.36703566e-01f, 8.15760493e-02f, -3.35843302e-02f, -7.69018307e-02f, -1.27569616e-01f, -1.91474468e-01f, 1.75505996e-01f,
  -2.17219070e-02f, -6.12059757e-02f, 9.48105976e-02f, 6.30104616e-02f, -7.66730383e-02f, -3.32904756e-01f, -7.49662817e-02f, -9.97490287e-02f, -5.79174347e-02f, -4.66519296e-01f,
  1.50178552e-01f, -4.33183126e-02f, 2.63564795e-01f, -3.12031269e-01f, 2.51361042e-01f, 3.53126414e-02f, 3.90883684e-02f, 6.00645579e-02f, 1.52436718e-01f, -1.79812476e-01f,
  6.61199242e-02f, -1.98461875e-01f, 8.09331015e-02f, 7.33399689e-02f, -1.17435073e-03f, 9.86846760e-02f, 2.32608058e-02f, -7.88969845e-02f, 1.20571449e-01f, -1.28040478e-01f,
  -9.02692229e-02f, 8.03206861e-02f, 1.86988860e-02f, -6.38519600e-02f, 6.86555728e-02f, 7.08875358e-02f, 5.56519032e-02f, -6.44885842e-03f, 2.53613852e-02f, -3.80456410e-02f,
  -5.42805437e-03f, -7.02300891e-02f, 9.39401463e-02f, -2.07968876e-01f, 1.11843497e-01f, -1.49142027e-01f, -1.11129627e-01f, 1.35641828e-01f, -6.59990497e-03f, -2.69313008e-02f,
  1.26477778e-01f, -1.15015628e-02f, 1.49118481e-02f, -1.65378273e-01f, 1.00067884e-01f, 7.96818081e-03f, -4.72283624e-02f, 9.57808793e-02f, -1.89845428e-01f, -9.75640640e-02f,
  -1.44392878e-01f, -1.94870532e-01f, 2.16283485e-01f, 3.28768604e-02f, -8.50518718e-02f, 5.66990450e-02f, 1.70520663e-01f, 1.04655214e-01f, 5.85800707e-02f, -4.70084623e-02f,
  -5.35064526e-02f, 1.99369371e-01f, -1.41431108e-01f, 2.17611343e-01f, 1.41752377e-01f, 3.24628323e-01f, -1.19433440e-01f, 3.57543558e-01f, -6.79688379e-02f, 4.50837642e-01f,
  2.66156048e-02f, 8.36204737e-03f, 1.32390440e-01f, 3.15502957e-02f, -1.65275149e-02f, -3.49977538e-02f, 8.77217725e-02f, -2.27338687e-01f, -1.48929656e-01f, -1.19227670e-01f,
  -7.80468881e-02f, 7.90987462e-02f, -1.32641390e-01f, 5.87957492e-03f, 2.15834007e-02f, 4.77065109e-02f, 4.19495022e-03f, -8.67733434e-02f, -4.77143601e-02f, -6.10402226e-02f,
  -1.17980450e-01f, 5.10713235e-02f, -5.77202737e-02f, -1.03425793e-02f, 3.37879844e-02f, 4.19038869e-02f, -1.07562989e-01f, -8.09820890e-02f, 1.09784134e-01f, 7.74218068e-02f,
  -7.17121065e-02f, 8.72581452e-03f, -7.63554424e-02f, -1.61141217e-01f, -1.34947106e-01f, 6.57051951e-02f, 7.93632716e-02f, -1.14411354e-01f, 5.29534556e-02f, -9.17152613e-02f,
  -1.20741539e-02f, -6.46322742e-02f, 4.73716408e-02f, 5.19746309e-03f, -5.79730459e-02f, 7.38247037e-02f, 2.05687638e-02f, 1.50979474e-01f, 1.46573022e-01f, 8.84475373e-03f,
  -2.80850261e-01f, -7.04377294e-02f, -6.97812438e-02f, 1.29335403e-01f, -5.21126330e-01f, -1.17367417e-01f, -1.94356456e-01f, 8.95572081e-02f, 2.44991668e-03f, 3.28152180e-02f,
  2.46952311e-03f, 2.72545666e-01f, -9.90362391e-02f, -2.76116222e-01f, -1.47304550e-01f, 1.94087982e-01f, -2.71932259e-02f, -2.27546170e-01f, 1.32280616e-02f, -5.38599864e-02f,
  -2.04077736e-01f, 5.62319122e-02f, 1.09748885e-01f, 1.41579747e-01f, -7.34129734e-03f, 9.90039334e-02f, -9.67656448e-02f, -2.11895481e-02f, -1.37407303e-01f, 8.61176252e-02f,
  2.31225803e-01f, 1.42934263e-01f, -1.61535479e-02f, 1.96471401e-02f, 1.86678395e-01f, 1.34051265e-03f, 5.14412150e-02f, 3.94174531e-02f, -1.83924160e-03f, 1.10640287e-01f,
  7.50270784e-02f, -2.67117377e-02f, -1.78907678e-01f, -1.12235442e-01f, 8.83370489e-02f, 9.40280873e-03f, -1.31718367e-01f, -9.59702581e-03f, -1.21844858e-01f, -3.64271291e-02f,
  -1.37439534e-01f, -4.38912995e-02f, 1.14308827e-01f, -1.46745414e-01f, -3.18595022e-02f, 3.03518753e-02f, 6.50502592e-02f, -1.58885613e-01f, -1.63557574e-01f, -1.02695584e-01f,
  -1.10266946e-01f, -1.79102376e-01f, -8.58663246e-02f, -6.95678815e-02f, 2.39135161e-01f, 1.13381334e-01f, 5.60891405e-02f, -2.13741660e-01f, 1.97455790e-02f, -2.73820430e-01f,
  -5.17801428e-03f, -6.39272928e-02f, -1.28533214e-01f, -4.09507453e-01f, 2.40309954e-01f, -1.79194495e-01f, 5.37271611e-02f, 2.49350518e-01f, -2.13227272e-01f, -2.25375563e-01f,
  -2.98816338e-02f, 2.40202069e-01f, -1.11469626e-01f, 5.62207773e-02f, -1.65547311e-01f, 3.39091063e-01f, 2.99992580e-02f, -1.56464905e-01f, -1.02076931e-02f, 1.41014397e-01f,
  2.92420909e-02f, 6.92193732e-02f, -9.48549137e-02f, -1.74580753e-01f, -6.66427240e-02f, 9.05191973e-02f, -5.38917966e-02f, -3.03239636e-02f, 7.43319020e-02f, 1.75267354e-01f,
  -9.88092199e-02f, 8.54207352e-02f, -7.06015080e-02f, -4.59310934e-02f, -6.56523034e-02f, -6.15986586e-02f, -2.06814140e-01f, 6.44721761e-02f, -1.15299553e-01f, -1.67174503e-01f,
  1.72436591e-02f, 1.01763971e-01f, -1.27404615e-01f, 7.98506588e-02f, 3.06841955e-02f, 1.49702430e-02f, -1.44863293e-01f, -4.68889624e-02f, -6.89861327e-02f, -1.00360133e-01f,
  1.23251356e-01f, 2.72271365e-01f, 1.10987034e-02f, 1.13017336e-01f, -1.40668973e-01f, 1.16934441e-01f, -2.64115166e-02f, 1.51109397e-01f, -3.07601154e-01f, 4.90947254e-02f,
  -3.70514184e-01f, 1.67979017e-01f, 3.76358062e-01f, -1.65850550e-01f, 2.80932188e-01f, 1.04127109e-01f, -2.27045879e-01f, -7.48721510e-02f, -1.85194597e-01f, -3.86119867e-03f,
  3.14409196e-01f, 1.39518790e-02f, 1.11339681e-01f, 8.55411962e-02f, -1.90985873e-01f, -2.63112038e-01f, -7.65743107e-02f, 2.17650071e-01f, 4.55738157e-02f, 6.75551966e-02f,
  3.18314508e-02f, -8.07281733e-02f, 6.63235262e-02f, -8.40905234e-02f, -4.58758026e-02f, -4.76777330e-02f, 1.66464761e-01f, -8.20812806e-02f, -6.51870072e-02f, -6.18340261e-02f,
  4.66040820e-02f, -7.11444169e-02f, 2.32980438e-02f, 3.99565399e-02f, -9.08050016e-02f, -5.95315211e-02f, -2.61098109e-02f, 6.15109727e-02f, -1.88008294e-01f, 3.40205729e-02f,
  4.92021441e-02f, 4.46536094e-02f, 1.79638565e-01f, -3.81660648e-02f, -1.17109999e-01f, -9.49559137e-02f, -3.37129831e-02f, -5.80187999e-02f, 1.21240579e-02f, 4.80332319e-03f,
  7.43252262e-02f, -6.76456466e-02f, 1.20739654e-01f, 2.22440413e-03f, -4.37842272e-02f, -1.03851445e-01f, -9.22348425e-02f, 2.45395675e-02f, 1.20411746e-01f, 1.05448440e-01f,
  6.65773079e-02f, -1.36724830e-01f, -3.31954584e-02f, 3.69719490e-02f, -1.18370848e-02f, -1.01620629e-01f, -3.39391410e-01f, -8.36308226e-02f, -2.10150450e-01f, 8.86292383e-02f,
  -1.65690370e-02f, 2.49875188e-01f, 1.82474017e-01f, 1.47082329e-01f, -7.09778965e-02f, -4.88153964e-01f, -1.60788327e-01f, 7.55205005e-02f, -2.82704346e-02f, 8.38874727e-02f,
  -1.52843550e-01f, -1.05117917e-01f, -2.51319408e-01f, -1.76353127e-01f, 4.46848944e-02f, -4.71897945e-02f, -4.79514301e-02f, 3.55107412e-02f, 7.22181052e-02f, 3.24422345e-02f,
  1.80348694e-01f, -1.59935907e-01f, -6.25956357e-02f, -1.55788049e-01f, 8.51121917e-02f, 4.92789112e-02f, -1.30089492e-01f, 1.21540539e-01f, 1.01246219e-02f, 5.48481476e-03f,
  -1.78640429e-02f, 2.37935130e-02f, 4.97695468e-02f, 2.05119234e-02f, 6.70428202e-02f, 8.51351917e-02f, -4.19730647e-03f, 2.09460850e-03f, 7.93213099e-02f, 9.67173502e-02f,
  4.54476960e-02f, -1.36258930e-01f, 3.44232880e-02f, 1.51569724e-01f, 3.85849476e-02f, -2.49909442e-02f, -9.68534499e-02f, 1.03686817e-01f, -1.84333965e-01f, 2.24703804e-01f,
  8.98284167e-02f, 1.54069439e-01f, 1.04168110e-01f, 8.59981775e-02f, 1.57528400e-01f, 3.10987920e-01f, -2.44370982e-01f, 5.08034229e-02f, -1.34753108e-01f, -8.67985040e-02f,
  2.95091629e-01f, -3.20523269e-02f, 1.65246785e-01f, 3.06348056e-02f, -1.12801403e-01f, 3.15642655e-01f, -2.18048826e-01f, -8.78412947e-02f, 1.52515411e-01f, -3.37307215e-01f,
  -7.94190541e-02f, 1.20006248e-01f, 1.68839768e-02f, -5.69936484e-02f, -5.15368283e-02f, -6.77608103e-02f, 6.89096302e-02f, -1.12992421e-01f, -1.13389023e-01f, 2.57597547e-02f,
  2.20407192e-02f, -6.82643279e-02f, 1.97131172e-01f, -4.77979183e-02f, 1.09558798e-01f, -2.74628639e-01f, -1.41360730e-01f, -1.38079673e-01f, -7.67804235e-02f, 1.24094114e-01f,
  -5.72743528e-02f, -2.43936833e-02f, -1.57157928e-01f, -1.93617016e-03f, -1.58027515e-01f, -1.07691184e-01f, 4.96006906e-02f, -1.45189181e-01f, 2.53672987e-01f, -2.18013555e-01f,
  -2.03449696e-01f, 4.70649451e-02f, 1.47546500e-01f, 1.57136023e-02f, -4.37890068e-02f, -9.67017934e-02f, 3.64452484e-03f, 3.89916301e-02f, -7.91493878e-02f, 9.15185288e-02f,
  -1.43513769e-01f, -2.25565180e-01f, -1.24325871e-01f, 1.00421540e-01f, 2.72121187e-02f, -6.20758347e-02f, 9.27668288e-02f, 4.76535410e-02f, 5.68020577e-03f, 2.04755515e-01f,
  -9.06378105e-02f, -4.52835634e-02f, -1.42484576e-01f, 1.65572762e-01f, 2.28970572e-01f, 5.04650176e-02f, 6.54462129e-02f, -8.60111192e-02f, 4.12943549e-02f, 1.35795578e-01f,
  -1.15010239e-01f, -7.42557272e-02f, 1.37109205e-01f, 1.07586049e-02f, 9.10958089e-03f, 1.86034683e-02f, 1.81955889e-01f, -1.29729137e-01f, 1.27312124e-01f, -7.37646073e-02f,
  3.23031574e-01f, -2.57634908e-01f, 7.67415985e-02f, 1.76951312e-03f, 2.85021514e-02f, -1.94995627e-02f, 7.71042258e-02f, 9.54549462e-02f, 7.49455541e-02f, -9.69162881e-02f,
  -2.46472266e-02f, 7.78613240e-02f, 3.87410335e-02f, 1.01495661e-01f, 2.33573727e-02f, -1.13617023e-02f, -1.40747577e-01f, 1.96173579e-01f, 6.72638416e-03f, 1.40257567e-01f,
  9.73544642e-02f, 3.23319100e-02f, -5.84060512e-02f, 8.54152292e-02f, -1.56209897e-03f, -4.97399159e-02f, -5.59086259e-03f, -4.82870527e-02f, 8.36342946e-02f, -9.33432505e-02f,
  -2.36201081e-02f, -1.05934148e-03f, 3.52503620e-02f, 1.54694110e-01f, 3.31573450e-04f, 3.36592272e-02f, 1.76253855e-01f, 5.79160936e-02f, 1.05947167e-01f, 1.56735793e-01f,
  1.22539297e-01f, 2.98516285e-02f, 1.34912208e-01f, 2.30460584e-01f, -2.21047178e-02f, -2.47385547e-01f, -9.42977369e-02f, -5.92765510e-02f, 4.96668369e-01f, 1.43520743e-01f,
  4.85983416e-02f, -1.60325635e-02f, -1.86673865e-01f, 2.00640559e-01f, -2.70770229e-02f, -4.26672176e-02f, 3.39561969e-01f, -9.57384780e-02f, 8.37159902e-02f, 2.10913882e-01f,
  -1.18855864e-01f, -1.81434631e-01f, -3.48572470e-02f, 1.09124191e-01f, -4.97543737e-02f, 5.21286651e-02f, 1.24432862e-01f, 1.16406549e-02f, 6.15100712e-02f, 4.33468223e-02f,
  -1.06992170e-01f, 2.48016953e-03f, 1.03659788e-02f, -3.17004472e-02f, -7.24181682e-02f, 5.80513179e-02f, -1.01520747e-01f, 7.49279708e-02f, -7.50722140e-02f, 1.20461650e-01f,
  -5.39113954e-03f, 4.71649552e-03f, -7.44030401e-02f, 5.16354814e-02f, 3.26303393e-02f, 1.50665892e-02f, 1.01246394e-01f, 1.44894049e-01f, 1.11814156e-01f, 2.74640787e-02f,
  1.21625863e-01f, 3.02818209e-01f, 1.54937699e-01f, 1.10631965e-01f, -6.95129335e-02f, 5.15786484e-02f, -1.18747048e-01f, 6.48597404e-02f, -1.46977752e-01f, 1.72456712e-01f,
  9.63298231e-02f, 1.95276499e-01f, 1.59928709e-01f, -2.25179177e-02f, -4.57414016e-02f, -2.09630340e-01f, -6.82501867e-02f, -2.58778721e-01f, -1.72550663e-01f, 1.24541022e-01f,
  -1.05485171e-01f, -1.81401715e-01f, 2.40613386e-01f, -2.51220375e-01f, 1.54295743e-01f, -4.25972603e-02f, -2.44458728e-02f, -2.79123127e-01f, -7.53022209e-02f, -2.11275771e-01f,
  2.32642904e-01f, 6.77721351e-02f, 5.43857701e-02f, -3.90355259e-01f, 3.25180478e-02f, -5.41129448e-02f, 2.21384391e-01f, 1.08436765e-02f, 1.62230320e-02f, -6.76089972e-02f,
  8.61222893e-02f, -1.04786091e-01f, 2.87559368e-02f, 8.22281688e-02f, 7.83085525e-02f, 7.13547021e-02f, -4.10933718e-02f, 6.02616975e-03f, 1.24909945e-01f, -6.40748590e-02f,
  1.38738036e-01f, 9.79470555e-03f, -1.33487776e-01f, 7.29885548e-02f, -1.30674705e-01f, 1.10108629e-01f, -1.20263703e-01f, 8.14131498e-02f, 1.06387407e-01f, 1.93269551e-01f,
  8.95795673e-02f, -9.12410468e-02f, 8.00002441e-02f, -6.87791556e-02f, 3.70898917e-02f, 1.53328881e-01f, 3.13852839e-02f, 5.52984104e-02f, -2.03690186e-01f, -6.27740175e-02f,
  -1.44820228e-01f, -9.16389525e-02f, -8.86054784e-02f, -2.61367410e-02f, 1.78313926e-01f, -6.23380393e-03f, -2.41454667e-03f, -1.33224562e-01f, 1.76512748e-02f, -1.59413069e-01f,
  5.95052727e-02f, 1.06221639e-01f, 6.19313493e-02f, 8.04694463e-03f, -6.15532734e-02f, 1.46293387e-01f, 4.11554813e-01f, -3.70609090e-02f, 1.74346983e-01f, -1.91707119e-01f,
  7.13332975e-03f, -2.84653634e-01f, 1.89962149e-01f, -7.19186217e-02f, 3.00085008e-01f, -3.20964366e-01f, -1.28058419e-01f, -2.48870879e-01f, -1.33971304e-01f, 7.01467320e-02f,
  3.42550762e-02f, -1.35582089e-01f, 2.39666253e-01f, -9.46357399e-02f, 1.16297796e-01f, 7.04220086e-02f, 5.23031875e-02f, -9.83655378e-02f, -8.37244019e-02f, 6.49900511e-02f,
  7.77238905e-02f, 2.41027605e-02f, -1.17003202e-01f, -8.68399814e-03f, 1.17686659e-01f, -8.22874084e-02f, 2.40453915e-03f, 1.14832692e-01f, -3.09686586e-02f, -4.99029271e-02f,
  5.33517413e-02f, 5.28122857e-02f, -1.58814266e-02f, -4.20066267e-02f, -7.86696970e-02f, -9.68185514e-02f, 4.59598638e-02f, -1.87081233e-01f, 7.96767324e-02f, 7.93881044e-02f,
  -3.21715772e-02f, 9.41503793e-02f, -1.06095761e-01f, 1.91698357e-01f, -1.53743029e-01f, 3.51799577e-02f, -6.55591786e-02f, -2.10084058e-02f, 1.84091181e-01f, 3.27189639e-02f,
  -4.58277836e-02f, -4.22244631e-02f, 3.74005325e-02f, -2.05225810e-01f, 6.28449768e-02f, -2.00415794e-02f, 1.00949749e-01f, 8.17498416e-02f, -1.74899817e-01f, -1.47547722e-02f,
  3.54295254e-01f, -8.17540661e-02f, 1.23468183e-01f, -1.21564440e-01f, -1.77057713e-01f, -1.01432212e-01f, -2.14681625e-02f, -2.63935119e-01f, 2.29998067e-01f, 2.28899285e-01f,
  5.74941188e-02f, -8.76720473e-02f, 1.01308182e-01f, -1.73491135e-01f, -3.39055769e-02f, -1.34442775e-02f, 3.68184805e-01f, 2.63960045e-02f, 7.53988251e-02f, -1.64622511e-03f,
  2.97601819e-02f, -5.24903238e-02f, 1.84346825e-01f, 1.00906737e-01f, 9.32022482e-02f, 7.66963437e-02f, 9.79026705e-02f, 1.20926820e-01f, -8.09187442e-02f, 1.20162196e-01f,
  3.25073185e-03f, 7.05371425e-02f, 3.96472104e-02f, 9.25596505e-02f, 7.94093460e-02f, 5.33477478e-02f, -7.85300806e-02f, -2.16359109e-01f, 1.63626984e-01f, 3.48259211e-02f,
  -1.39985919e-01f, -1.43858775e-01f, 8.56838524e-02f, 1.67090654e-01f, -6.08796217e-02f, -1.42918766e-01f, 1.47605818e-02f, -8.22003856e-02f, 6.41936734e-02f, 1.77920312e-01f,
  -2.61329487e-02f, 1.69791840e-02f, -1.56145364e-01f, 8.74575600e-02f, 5.70778269e-03f, 2.39850700e-01f, -9.31767449e-02f, 2.13530466e-01f, 1.32675797e-01f, -1.63559258e-01f,
  -2.12801158e-01f, -3.20687741e-02f, -1.43513992e-01f, -6.67260075e-03f, -4.42507416e-01f, -1.98591560e-01f, -2.68430710e-01f, -9.71650109e-02f, -1.72491614e-02f, 1.29281595e-01f,
  4.86794747e-02f, -6.47696555e-02f, -2.45078906e-01f, 1.35568589e-01f, -3.16958904e-01f, 2.44419247e-01f, 1.04120515e-01f, 1.42855376e-01f, -3.90397497e-02f, -1.53281316e-01f,
  1.82202786e-01f, -5.54312300e-03f, 6.93054348e-02f, -1.01015018e-02f, 1.25578463e-01f, 1.21293925e-01f, -1.03102006e-01f, -9.90492329e-02f, 9.42472890e-02f, 2.24825457e-01f,
  4.98728529e-02f, 3.07300463e-02f, -7.73587227e-02f, 2.37151608e-01f, 4.86716852e-02f, -1.40523791e-01f, -1.61666498e-02f, -1.84160024e-02f, 9.67577994e-02f, -1.22715764e-01f,
  -6.94564134e-02f, -7.84755796e-02f, 5.47503605e-02f, 1.45823106e-01f, 2.46198364e-02f, 2.15357214e-01f, 9.50040594e-02f, -1.81417271e-01f, -3.97665538e-02f, -3.52265425e-02f,
  1.50078669e-01f, -1.11666985e-01f, 1.71830416e-01f, 3.26166451e-02f, 3.91585678e-02f, 1.25714108e-01f, -1.24839008e-01f, -5.28283864e-02f, 2.20473334e-01f, 1.39510080e-01f,
  1.85694899e-02f, 3.24123591e-01f, -1.03346437e-01f, -1.65039897e-01f, -1.45490199e-01f, 1.44763514e-01f, 1.09642819e-01f, -1.78629145e-01f, -4.91558611e-01f, -7.06201373e-03f,
  -6.49975464e-02f, -5.58738178e-03f, 2.16022819e-01f, -1.39415920e-01f, 3.39923911e-02f, 1.48277149e-01f, -1.42072946e-01f, -2.65305817e-01f, 9.67772305e-02f, 1.13821030e-01f,
  -1.29431292e-01f, -4.54377085e-02f, -2.36548737e-01f, -1.44424915e-01f, -2.70118713e-01f, 1.32384822e-01f, 1.76206335e-01f, -1.19620442e-01f, -1.15386072e-04f, -1.41962450e-02f,
  4.11952250e-02f, -1.29930347e-01f, 1.32532849e-04f, -1.17279232e-01f, -9.15584023e-05f, 5.86604476e-02f, 4.97270301e-02f, 2.33907565e-01f, 7.36457556e-02f, -1.02254219e-01f,
  -8.28715041e-02f, 8.26091021e-02f, 2.16049612e-01f, 6.14698837e-03f, 3.82424854e-02f, -1.26630455e-01f, 1.92305848e-01f, -6.36162534e-02f, 3.23511250e-02f, 1.03744656e-01f,
  3.34905311e-02f, -2.13951364e-01f, 1.92689449e-01f, -1.51519611e-01f, 8.39570537e-02f, -8.62257406e-02f, 1.06559128e-01f, 2.30182841e-01f, -1.02472782e-01f, 2.87660509e-01f,
  -5.08607645e-03f, -4.96767871e-02f, 1.30662799e-01f, 1.41011039e-02f, -6.26920257e-03f, 2.33130485e-01f, 8.66126940e-02f, -3.23715478e-01f, -1.74795836e-01f, -3.82168032e-02f,
  -1.09452151e-01f, -4.59853321e-01f, -2.91416824e-01f, 1.51113309e-02f, -2.49985084e-01f, -2.87353277e-01f, 1.82611629e-01f, 1.42913744e-01f, 4.27585170e-02f, -7.11733028e-02f,
  -4.68369015e-03f, -2.52117589e-02f, 4.93657924e-02f, 5.28666861e-02f, 8.10453594e-02f, -7.69346282e-02f, -1.04409248e-01f, -1.75265312e-01f, -7.50488639e-02f, -3.70605141e-01f,
  4.99298163e-02f, 9.81931165e-02f, 1.05145127e-01f, 7.01038539e-02f, -1.49644926e-01f, -1.45942792e-01f, -4.01774608e-02f, 1.02653064e-01f, 1.53510794e-01f, 7.59902038e-03f,
  9.67645422e-02f, 8.89818370e-03f, 5.24549931e-02f, -6.83651716e-02f, -5.70043065e-02f, -1.62802711e-02f, 5.37935495e-02f, -3.44346575e-02f, -3.16230744e-01f, 1.32707283e-01f,
  1.49554804e-01f, 2.39455998e-02f, -6.61609173e-02f, 9.74474773e-02f, 2.85074487e-02f, -3.43835875e-02f, -4.71606702e-02f, -5.65505102e-02f, -4.26711738e-02f, -3.16491239e-02f,
  1.00829683e-01f, -1.17657386e-01f, 1.10029943e-01f, -5.32685639e-03f, -1.39020503e-01f, -1.76224113e-01f, -5.66954687e-02f, -6.98588938e-02f, 5.42706288e-02f, -2.61728108e-01f,
  2.01174796e-01f, -1.75309867e-01f, 4.90203574e-02f, -5.46045601e-02f, 2.21157029e-01f, 1.26127899e-01f, -3.06299865e-01f, 9.15148333e-02f, -8.99416134e-02f, -5.36679775e-02f,
  1.04791477e-01f, 1.58810932e-02f, 2.19402790e-01f, -1.29454089e-02f, -1.37827352e-01f, -1.49639519e-02f, -2.38535717e-01f, 1.82198405e-01f, 4.82974090e-02f, 1.38321757e-01f,
  2.38707568e-02f, -2.06638306e-01f, 1.01166002e-01f, -1.00845933e-01f, -1.06880240e-01f, 2.05872446e-01f, -4.95427810e-02f, -6.84953481e-02f, -4.35366444e-02f, -1.49529269e-02f,
  -8.59458745e-03f, -2.35265251e-02f, -1.44035414e-01f, -1.28318304e-02f, 5.45143383e-03f, 1.20037142e-02f, -8.81863311e-02f, 9.24391523e-02f, 1.46174237e-01f, 1.98045652e-02f,
  -5.87961152e-02f, -3.91405039e-02f, 9.66199636e-02f, 8.96015540e-02f, 1.08875647e-01f, -1.11573942e-01f, 1.49262592e-01f, -4.02560756e-02f, -1.03233531e-01f, 1.78758174e-01f,
  2.08334580e-01f, -2.36203559e-02f, 7.16651157e-02f, 1.37349620e-01f, 2.75829202e-03f, 7.96960294e-03f, 6.47646142e-03f, -3.29445004e-02f, 1.59919169e-03f, 4.27550785e-02f,
  -1.05750911e-01f, -1.98015451e-01f, -5.59670515e-02f, -2.46519402e-01f, 4.38774303e-02f, 8.74362811e-02f, -2.11288240e-02f, -1.26534149e-01f, 1.07804269e-01f, -1.19027562e-01f,
  3.89355749e-01f, -1.59881175e-01f, 2.10070089e-01f, 5.16515225e-02f, -4.13610563e-02f, -8.37466791e-02f, 6.55660853e-02f, -5.29938340e-02f, 6.44968972e-02f, 2.38914609e-01f,
  6.91901892e-02f, -2.67368883e-01f, 7.71960542e-02f, -8.28364119e-02f, 2.51624584e-01f, 8.85540321e-02f, -2.51982678e-02f, -9.07605216e-02f, -1.38297662e-01f, 8.00877139e-02f,
  -6.48176223e-02f, 6.79933727e-02f, 1.15991868e-01f, -9.51324478e-02f, -1.58283859e-01f, 1.00078963e-01f, 4.10663486e-02f, -5.70864938e-02f, 8.98815785e-03f, 1.08992592e-01f,
  -9.31165442e-02f, -1.01803383e-02f, 9.97487754e-02f, -1.08245248e-03f, 5.83537295e-02f, -8.39290842e-02f, 6.77376380e-03f, 1.30092159e-01f, 1.15225956e-01f, -1.80308595e-01f,
  -1.74171999e-01f, -9.42157358e-02f, 1.65431589e-01f, -5.47405630e-02f, 5.62769780e-03f, -1.13011217e-02f, 1.35277668e-02f, -5.34744635e-02f, 3.58966296e-04f, 1.02368213e-01f,
  -6.60383403e-02f, -1.41132265e-01f, -7.89682195e-02f, -9.03391093e-02f, -3.22912447e-02f, -1.23428762e-01f, 2.26001129e-01f, -1.49979359e-02f, 2.11934999e-01f, -1.03774093e-01f,
  1.63012043e-01f, -1.94693264e-02f, 2.02487633e-01f, -4.37615663e-02f, -3.63346130e-01f, -1.62852313e-02f, 7.99714681e-03f, -1.23713426e-01f, 2.79385716e-01f, -2.84571111e-01f,
  3.11876535e-01f, 1.28077954e-01f, -1.87490642e-01f, -2.07657879e-03f, -9.74302515e-02f, 2.91208853e-03f, 2.82786041e-01f, 5.32596037e-02f, 1.03806145e-01f, -8.57664868e-02f,
  2.13926882e-01f, -4.07399572e-02f, 6.82087243e-02f, -5.41050434e-02f, 1.97590590e-01f, -8.51338282e-02f, 3.57026570e-02f, 2.86954224e-01f, -4.03675297e-03f, 1.21544674e-02f,
  2.24463530e-02f, 1.24430880e-01f, 2.11640354e-02f, 1.80967972e-02f, 8.16682130e-02f, 4.73918319e-02f, -3.88224795e-02f, -1.29450396e-01f, -1.16602547e-01f, -3.42876650e-02f,
  -1.34439081e-01f, 1.75318718e-01f, -2.20782712e-01f, 6.00565374e-02f, 4.51363483e-03f, -1.97082445e-01f, -5.77602647e-02f, 7.28392377e-02f, -3.70813087e-02f, -3.24103311e-02f,
  1.40975304e-02f, -2.67702974e-02f, -4.47686017e-02f, 1.72370840e-02f, -9.37507376e-02f, -6.49789497e-02f, -1.03259571e-01f, -5.03647625e-02f, -6.16804138e-03f, -1.07521854e-01f,
  2.40815934e-02f, -9.51057971e-02f, 7.27539659e-02f, -1.43523157e-01f, 2.73748904e-01f, 2.46387646e-02f, 2.99663007e-01f, 3.12817365e-01f, 7.69158304e-02f, 8.19610953e-02f,
  7.06964582e-02f, 4.56958711e-01f, -8.86692256e-02f, -1.56279773e-01f, -6.68536946e-02f, 3.22191864e-01f, -2.51766592e-01f, -2.52736926e-01f, -1.21442057e-01f, -6.74335361e-02f,
  -1.70104891e-01f, -2.69317515e-02f, -5.17426953e-02f, 1.97138600e-02f, -2.69259065e-01f, 3.11524212e-01f
};

// L1_fan_Wp_bar (Shape: 26 x 64)
const int L1_fan_Wp_bar_rows = 26;
const int L1_fan_Wp_bar_cols = 64;
const float L1_fan_Wp_bar_data[] = {
  1.79767698e-01f, -8.37436020e-02f, 1.44793078e-01f, 2.14305982e-01f, -5.56325801e-02f, 2.15754375e-01f, 2.34989822e-01f, 1.35571867e-01f, 1.69120803e-01f, 1.36857316e-01f,
  4.68002371e-02f, 4.06874977e-02f, 1.03049323e-01f, 2.56939292e-01f, 2.43178248e-01f, 1.32380337e-01f, 1.40615731e-01f, 9.16444063e-02f, 1.16316885e-01f, 4.97159828e-03f,
  -9.96900257e-03f, 1.19900987e-01f, -1.16725996e-01f, -3.26373689e-02f, -4.17790674e-02f, -1.78511843e-01f, -1.19402837e-02f, -1.40998304e-01f, 1.05521001e-01f, 1.24781718e-02f,
  2.39386976e-01f, -1.28742084e-01f, 1.96019486e-02f, 1.18760072e-01f, -1.95810750e-01f, -1.53216481e-01f, 1.50291279e-01f, -3.07210118e-01f, -2.83480175e-02f, -1.27698081e-02f,
  -2.99349368e-01f, -3.36325258e-01f, 2.41999596e-01f, 7.25561157e-02f, 3.41458619e-01f, -1.06378324e-01f, -1.94027810e-03f, 5.42957075e-02f, -5.97784296e-02f, 7.26614073e-02f,
  2.78645992e-01f, -6.99112937e-02f, -2.14147076e-01f, 2.12735444e-01f, 4.83007804e-02f, -2.57231556e-02f, -1.41981483e-01f, -2.90866673e-01f, 8.97728056e-02f, 7.16224015e-02f,
  -1.49186030e-01f, 8.43483135e-02f, -3.28881532e-01f, -1.88202813e-01f, 2.06370801e-01f, 1.17817730e-01f, 1.97483808e-01f, 8.83339122e-02f, 6.38408065e-02f, 1.70529023e-01f,
  2.22500018e-03f, 2.21314013e-01f, 1.75995249e-02f, 1.41431063e-01f, -6.56709149e-02f, 2.30715469e-01f, 1.69953972e-01f, 7.41555244e-02f, 9.10140947e-02f, 4.41138670e-02f,
  1.77455097e-01f, 1.78900808e-01f, -3.87200564e-02f, 2.61831403e-01f, -7.03430846e-02f, 1.41065925e-01f, 2.00255305e-01f, -6.68324828e-02f, -9.35015008e-02f, -1.48887197e-02f,
  -2.50100285e-01f, -1.20597303e-01f, -2.39215806e-01f, 1.15909912e-02f, -8.15096200e-02f, 4.52344529e-02f, -9.22003463e-02f, -1.06871188e-01f, 4.66892980e-02f, 8.44309852e-02f,
  -7.38320649e-02f, 1.45158067e-01f, -2.63532043e-01f, 1.06247246e-01f, 1.09897286e-01f, 1.71497895e-03f, 3.79701816e-02f, -6.74283281e-02f, 4.75733019e-02f, -3.61396261e-02f,
  4.10497077e-02f, -2.97318667e-01f, 3.11232433e-02f, -1.83113798e-01f, -1.41734079e-01f, -2.93942243e-01f, 3.54161829e-01f, -2.38667727e-01f, 1.53674781e-01f, -1.59646407e-01f,
  -2.40596272e-02f, -1.85129624e-02f, -3.92926931e-01f, -8.37976485e-03f, -1.01497144e-01f, -1.88635923e-02f, -2.71112453e-02f, 4.54413712e-01f, 2.48904098e-02f, 9.37337205e-02f,
  -1.23720646e-01f, 1.03418708e-01f, 6.31705225e-02f, -1.78272679e-01f, 1.22336492e-01f, -4.47671525e-02f, 6.96698278e-02f, -1.72327444e-01f, 2.20556721e-01f, -6.97202981e-02f,
  8.57165977e-02f, 1.25215519e-02f, 9.15664658e-02f, -1.25078103e-02f, 4.62881625e-02f, -8.45505744e-02f, 1.61792144e-01f, -1.56745449e-01f, 1.72770441e-01f, -1.44602597e-01f,
  8.03249851e-02f, 2.70591259e-01f, -5.11284992e-02f, 5.25392853e-02f, -1.72895655e-01f, -6.08957559e-02f, 9.83529016e-02f, -5.57758957e-02f, -4.38315198e-02f, 9.64901410e-03f,
  8.21869075e-02f, 5.93496896e-02f, -7.88124129e-02f, -1.35245323e-01f, 1.68303680e-02f, 1.03013173e-01f, 1.91418126e-01f, 2.16037370e-02f, -2.40887459e-02f, -2.23253816e-01f,
  -8.30881372e-02f, 3.13335568e-01f, 7.36300349e-02f, -1.05410079e-02f, -2.28936285e-01f, -1.78468987e-01f, -1.54834371e-02f, -1.43232927e-01f, 2.54997998e-01f, 1.23655945e-01f,
  3.02564986e-02f, 7.03382120e-02f, -6.74153939e-02f, 2.75577456e-01f, 3.47845703e-02f, -2.83791929e-01f, 4.80560213e-02f, 2.54928648e-01f, 1.01692364e-01f, -1.24218926e-01f,
  -2.49329433e-02f, -2.17214167e-01f, 1.86267108e-01f, -8.16829652e-02f, 2.78559655e-01f, 8.95534679e-02f, -6.11478835e-02f, 1.10666342e-01f, -1.00003600e-01f, -8.00881013e-02f,
  1.26034498e-01f, 1.41990945e-01f, -6.50543123e-02f, 9.12938640e-02f, 2.00536415e-01f, 1.02583133e-01f, 5.82509153e-02f, 1.27711862e-01f, 2.39340365e-02f, 1.72884315e-01f,
  1.14176013e-01f, 1.37538418e-01f, 1.08767666e-01f, -2.52817012e-02f, 4.34105217e-01f, -4.81847934e-02f, 2.21471135e-02f, 5.68602122e-02f, -1.44680187e-01f, 1.47889674e-01f,
  -4.31011356e-02f, -3.83371487e-02f, -2.58170724e-01f, -1.35739218e-03f, -1.56170651e-01f, 3.70378681e-02f, 1.91405505e-01f, 2.05946535e-01f, -7.09672645e-02f, 2.92845219e-01f,
  -3.13440353e-01f, 2.30565652e-01f, 6.78830370e-02f, 1.14883542e-01f, -6.43854439e-02f, 1.63148507e-01f, -3.75559106e-02f, 2.42726400e-01f, 1.32322147e-01f, -1.91265330e-01f,
  3.24437208e-02f, -2.06727147e-01f, -3.73964161e-01f, -2.01472476e-01f, 2.65631735e-01f, -2.69229949e-01f, -3.07732378e-03f, -1.07197754e-01f, -2.23298132e-01f, 2.38564927e-02f,
  -2.50618517e-01f, 3.10829170e-02f, 7.11583570e-02f, -2.69904304e-02f, 1.29631951e-01f, 4.77881968e-01f, 7.08871558e-02f, -6.21434338e-02f, 1.86849877e-01f, 7.49188140e-02f,
  -4.92618382e-02f, 1.88127458e-01f, -6.31130263e-02f, 6.71204701e-02f, 7.77252391e-02f, -4.64272983e-02f, -6.34508431e-02f, 6.02733865e-02f, 7.28756040e-02f, 2.09096655e-01f,
  5.37596382e-02f, 9.15861409e-03f, 5.69196902e-02f, 1.72520682e-01f, -4.69525196e-02f, 2.75765866e-01f, 3.56861716e-03f, 1.74236357e-01f, 8.06740150e-02f, -1.56427398e-01f,
  -6.73507899e-02f, -9.00773481e-02f, -1.30944669e-01f, 9.61957052e-02f, -1.13227986e-01f, 5.23618832e-02f, 1.30241945e-01f, -8.15651938e-02f, 1.50739014e-01f, -1.89116135e-01f,
  -5.72045818e-02f, -3.53951193e-03f, -8.31896737e-02f, 8.08311626e-02f, -1.18883774e-01f, -1.15939170e-01f, 1.08865604e-01f, -1.07656509e-01f, -1.84138030e-01f, 1.24948449e-01f,
  -1.01485290e-01f, 2.60502309e-01f, -3.61851484e-01f, -1.77859381e-01f, -1.34632453e-01f, 1.01285018e-01f, -1.31770149e-01f, -2.46654842e-02f, -2.26661209e-02f, 4.71190475e-02f,
  -1.31587997e-01f, -1.95288450e-01f, -1.79674104e-01f, 8.10627639e-02f, 8.04229155e-02f, -4.63277489e-01f, 1.13667704e-01f, -6.30090833e-02f, -6.98523410e-03f, 1.64793104e-01f,
  4.50432524e-02f, -1.41456071e-02f, 1.63338766e-01f, 2.99359765e-02f, 1.07690290e-01f, -6.27609491e-02f, 3.20055126e-03f, 6.16691411e-02f, 1.73010062e-02f, 3.44294235e-02f,
  6.43731058e-02f, 2.71017086e-02f, 1.93819866e-01f, -6.82694018e-02f, 7.42184371e-02f, -8.11344683e-02f, 1.52575865e-03f, 5.33791818e-02f, 1.92044720e-01f, 5.05807549e-02f,
  1.07335582e-01f, 4.92752083e-02f, -4.40394208e-02f, 6.14056550e-03f, 2.39008814e-02f, 2.70065665e-01f, -2.65758783e-02f, -3.76114957e-02f, -1.96542069e-02f, 3.49553004e-02f,
  -5.32267019e-02f, -6.50300011e-02f, -7.75293633e-03f, 2.85954699e-02f, 1.48089707e-01f, 7.00435191e-02f, 2.94227377e-02f, -2.78749168e-01f, 1.19212471e-01f, -1.22651920e-01f,
  7.46581703e-02f, 1.15782499e-01f, 3.23732942e-01f, 2.18959823e-02f, 5.79718351e-02f, -1.25502378e-01f, 2.37779185e-01f, -6.92951381e-02f, 1.22366048e-01f, -2.15384096e-01f,
  -9.88677219e-02f, -2.69829273e-01f, 7.09322765e-02f, -2.43782207e-01f, 1.30082563e-01f, -5.07971942e-02f, -4.23864648e-02f, -7.98632354e-02f, -6.14147866e-03f, 3.20706010e-01f,
  -1.60031527e-01f, 3.16342302e-02f, 4.26241122e-02f, 9.56413373e-02f, 1.69749007e-01f, -2.44757887e-02f, -2.51471326e-02f, -4.04465385e-02f, 4.18059826e-02f, -1.36596411e-01f,
  3.98793817e-02f, 3.17428224e-02f, -9.43099260e-02f, -3.50054279e-02f, 6.65720261e-04f, 6.26676530e-02f, -8.95972271e-03f, -6.21098951e-02f, 1.45760208e-01f, 5.42803071e-02f,
  -8.48730281e-02f, 1.51178181e-01f, -6.43788204e-02f, -4.46511842e-02f, 2.44031265e-01f, 8.94227177e-02f, 2.49818806e-02f, 2.25205839e-01f, 7.93835893e-02f, -2.88764775e-01f,
  -9.06735193e-03f, -9.93594751e-02f, 5.65665327e-02f, -1.09081440e-01f, -1.02470852e-01f, 1.21729471e-01f, -3.93447205e-02f, 8.40264782e-02f, -9.97039154e-02f, -1.11431241e-01f,
  -5.21432795e-03f, 1.36604652e-01f, -1.90413967e-02f, 1.84381112e-01f, 5.21371774e-02f, -3.07959970e-02f, -1.59467980e-01f, 1.50239795e-01f, 1.02450125e-01f, -2.34208331e-01f,
  -6.54921234e-02f, -1.02945464e-02f, -3.90176445e-01f, -2.30590269e-01f, 2.69130498e-01f, 1.88422084e-01f, -1.48775116e-01f, 9.25276577e-02f, 3.30083847e-01f, -1.21905208e-01f,
  -3.55063304e-02f, 8.59156996e-02f, 2.24731237e-01f, -1.66637659e-01f, -2.03921050e-01f, -2.47385055e-01f, 3.84775661e-02f, -4.18144852e-01f, 6.91953674e-02f, -1.06684957e-03f,
  1.90741476e-02f, 9.48240701e-03f, -6.50134832e-02f, 2.00292543e-01f, -4.30648103e-02f, -3.53691876e-02f, 6.41873702e-02f, 1.32783428e-01f, 7.37719461e-02f, 1.39871640e-02f,
  2.37080410e-01f, 1.68584734e-01f, 2.77175695e-01f, -8.82429183e-02f, 1.72959976e-02f, 6.47045746e-02f, -7.47545138e-02f, -1.38188498e-02f, -1.03740372e-01f, -1.13217533e-01f,
  1.88168123e-01f, 1.96171135e-01f, 7.52074122e-02f, -3.71598415e-02f, 5.31824715e-02f, 2.16128632e-01f, -1.08803332e-01f, -1.36155874e-01f, 1.31289676e-01f, -3.07432842e-02f,
  -1.72665883e-02f, 4.86221984e-02f, 1.02969073e-01f, -1.43380567e-01f, -1.32713661e-01f, -9.90710258e-02f, -5.47907129e-02f, -7.98659101e-02f, -2.25074127e-01f, -2.01407075e-01f,
  1.86926156e-01f, -2.15957344e-01f, 2.02046022e-01f, -6.67914450e-02f, -3.11430961e-01f, -3.43429744e-01f, -1.30313292e-01f, 1.52531624e-01f, -1.85376346e-01f, -7.33545795e-02f,
  1.90846860e-01f, -1.97487682e-01f, -4.52531934e-01f, 2.05076978e-01f, -1.25551701e-01f, -1.89398378e-01f, -6.36458397e-02f, 3.05692345e-01f, -2.09398307e-02f, 6.95111463e-04f,
  -4.79826517e-02f, 1.67837759e-04f, 5.50388657e-02f, -5.98074645e-02f, 8.50243196e-02f, -1.01792499e-01f, 8.96211863e-02f, 3.97441648e-02f, 1.12710241e-02f, 7.18252212e-02f,
  4.77733128e-02f, 2.61723120e-02f, 5.98083548e-02f, 1.13138579e-01f, 2.17993967e-02f, 8.99476409e-02f, 1.71880171e-01f, -5.44203185e-02f, 7.24533498e-02f, -2.21408177e-02f,
  6.66958243e-02f, 1.51806265e-01f, -3.17242950e-01f, -1.63800001e-01f, 3.43781747e-02f, -1.07149281e-01f, -1.52864894e-02f, -5.95172048e-02f, 9.47005749e-02f, 4.39027622e-02f,
  5.04619256e-02f, -9.41503420e-02f, 5.04448973e-02f, -1.17076278e-01f, -1.39819056e-01f, -1.76633075e-01f, 6.52707741e-02f, -2.64045864e-01f, -8.71217400e-02f, -9.08708051e-02f,
  1.99848726e-01f, -3.72442454e-02f, -1.37023076e-01f, 2.86377847e-01f, 1.32916927e-01f, -5.45096360e-02f, 9.08373445e-02f, 2.75060534e-01f, 3.77779193e-02f, 6.55518100e-02f,
  1.40227359e-02f, 2.65478462e-01f, 1.53089494e-01f, 5.45260310e-02f, -1.00106455e-01f, 3.06124002e-01f, -3.29951882e-01f, 4.05954905e-02f, 2.85375148e-01f, 2.43644312e-01f,
  -1.68440908e-01f, 1.94445928e-03f, 1.28833298e-02f, 7.31996298e-02f, -1.87519323e-02f, 1.70209303e-01f, 2.31788650e-01f, -1.76446617e-01f, -8.37291628e-02f, 1.99607342e-01f,
  2.28278920e-01f, 1.72494859e-01f, 2.69698024e-01f, -3.63759995e-02f, -3.19586061e-02f, 3.02682798e-02f, 1.02419205e-01f, 9.78064761e-02f, -1.48081735e-01f, -1.60824750e-02f,
  1.52579695e-01f, 1.30590484e-01f, 3.89468670e-02f, 1.58266500e-01f, 6.03217520e-02f, -1.97234198e-01f, 1.16112247e-01f, 3.35790925e-02f, -2.70452738e-01f, -2.41175983e-02f,
  7.63213411e-02f, -2.13036966e-02f, -9.47334897e-03f, -1.90130681e-01f, 1.97181210e-01f, 5.02836592e-02f, 8.11755210e-02f, 2.28845496e-02f, -1.25146881e-01f, 1.45175561e-01f,
  -1.37810916e-01f, 5.31724505e-02f, 1.05867319e-01f, -1.63973153e-01f, -1.33363884e-02f, 3.16121817e-01f, -3.65799457e-01f, -4.25097346e-02f, -1.89861685e-01f, 1.31828770e-01f,
  6.02827296e-02f, 2.32332930e-01f, 1.86569825e-01f, 7.89526105e-03f, 4.89332080e-02f, 3.11886787e-01f, 2.24587828e-01f, 3.20833892e-01f, -3.49244833e-01f, 2.12759435e-01f,
  2.05673948e-01f, 3.22249115e-01f, -7.27811679e-02f, -1.65369436e-01f, 2.25471616e-01f, 3.51152346e-02f, -1.83412880e-01f, -1.76478103e-02f, -7.02373236e-02f, -2.63824046e-01f,
  3.83937620e-02f, -1.90409228e-01f, 1.49106547e-01f, 7.23081306e-02f, 1.03547454e-01f, 8.59710947e-02f, 1.56115815e-02f, 1.79513693e-01f, 1.01918384e-01f, -5.54319508e-02f,
  -2.16303691e-01f, -1.34547129e-01f, 3.62068862e-02f, 4.53574536e-03f, -7.70923048e-02f, 3.69778164e-02f, 6.99807052e-03f, 1.80192843e-01f, 7.06879273e-02f, -1.69486851e-01f,
  -5.91603592e-02f, -8.85209441e-02f, 4.94741974e-03f, -2.04069078e-01f, 2.60775954e-01f, 1.06837459e-01f, -1.07271383e-02f, 2.29123518e-01f, -6.12665825e-02f, 8.35407302e-02f,
  -5.35982251e-02f, -2.47354191e-02f, -3.16525728e-01f, -5.14242388e-02f, -1.95915271e-02f, 1.88546479e-01f, 9.84212980e-02f, -3.95278167e-03f, 1.90621674e-01f, -1.45601064e-01f,
  -2.04085391e-02f, -3.14586341e-01f, -5.04954338e-01f, 3.14674288e-01f, -4.92538288e-02f, 2.38642201e-01f, -3.49574685e-01f, -6.65936321e-02f, -8.27127248e-02f, 3.15007448e-01f,
  1.56744540e-01f, 1.40514895e-01f, -2.99179673e-01f, 3.20802808e-01f, -5.44220269e-01f, 9.30756778e-02f, -7.55321467e-03f, -2.43121192e-01f, 3.53122413e-01f, -9.25520137e-02f,
  -9.62023288e-02f, 1.33615375e-01f, -1.43274575e-01f, 2.70708829e-01f, 5.38902022e-02f, -4.44408059e-02f, -4.94408347e-02f, 3.99582088e-02f, -1.32830232e-01f, 8.37635323e-02f,
  8.23732913e-02f, 3.55937704e-02f, -1.39951110e-02f, 2.30202556e-01f, -1.06635258e-01f, 4.45577838e-02f, 1.18426390e-01f, -1.62448231e-02f, -9.90180671e-02f, 3.07677649e-02f,
  1.25414982e-01f, 2.07383871e-01f, 3.31417114e-01f, 7.27941468e-02f, 3.82936671e-02f, 1.37476876e-01f, 7.41033778e-02f, -1.96514770e-01f, -2.00108081e-01f, 6.34396300e-02f,
  -1.13396332e-01f, -1.53947189e-01f, -8.52555335e-02f, 6.22289516e-02f, -2.78344229e-02f, -2.11779051e-03f, -1.04956739e-01f, 2.07642660e-01f, 2.44694725e-01f, 1.28744915e-01f,
  -8.55688974e-02f, 1.19672026e-02f, -5.31359725e-02f, 8.33126903e-02f, 7.85222948e-02f, 6.03146255e-02f, 8.55512097e-02f, 3.73123646e-01f, -1.08967073e-01f, -1.36063069e-01f,
  3.17724168e-01f, -9.67739820e-02f, -1.34515122e-01f, -1.13495067e-01f, -8.93360749e-02f, -1.54961541e-01f, 5.73468283e-02f, -1.73017442e-01f, 3.39579314e-01f, -3.49449217e-01f,
  -1.73943847e-01f, -2.34547824e-01f, 1.55983016e-01f, -5.85728958e-02f, -1.09914104e-02f, -7.24395737e-02f, 1.67156845e-01f, 5.03373146e-03f, 1.32806063e-01f, 8.67272392e-02f,
  1.26969159e-01f, 1.02884714e-02f, 6.50135009e-03f, 2.33335957e-01f, 2.25726534e-02f, 7.24603385e-02f, 2.99684610e-02f, 3.64942104e-02f, 1.03724472e-01f, 1.16818517e-01f,
  7.27469251e-02f, 1.10810474e-01f, 1.47834048e-01f, 1.84819669e-01f, -9.44114327e-02f, 3.65490839e-02f, 4.28419374e-03f, 4.31827940e-02f, 1.20887198e-02f, 4.34466638e-02f,
  -2.19405238e-02f, 9.22446549e-02f, -3.43345441e-02f, 1.63591370e-01f, 8.16859901e-02f, 4.62240838e-02f, -6.75546601e-02f, 1.13450557e-01f, -1.13329599e-02f, -9.60233882e-02f,
  2.41730586e-02f, 8.03999975e-02f, 2.78827138e-02f, -3.94890197e-02f, -2.19229400e-01f, -1.92207173e-01f, -4.43408117e-02f, -1.22243337e-01f, -9.16177034e-02f, -3.45037460e-01f,
  4.07389253e-01f, -4.76600304e-02f, 3.41385156e-01f, -3.32334727e-01f, 2.55558789e-01f, -4.21266654e-04f, 1.58428282e-01f, -2.00264484e-01f, 9.51454882e-03f, -3.55711192e-01f,
  1.64017156e-01f, -2.71348238e-01f, 2.07883731e-01f, 3.39050710e-01f, 1.91283196e-01f, -3.67313027e-01f, 6.39338885e-03f, 1.10513791e-01f, -7.66842961e-02f, 1.77557990e-01f,
  1.99507102e-01f, -2.81962425e-01f, 4.29754779e-02f, 8.96586105e-02f, -3.15690078e-02f, 1.79543510e-01f, 1.47846937e-01f, 1.24435209e-01f, 5.95912412e-02f, 1.33136055e-04f,
  -1.06267221e-01f, 6.84685931e-02f, -1.46705788e-02f, 1.29764065e-01f, 8.92433003e-02f, 4.54964638e-02f, -1.67705701e-03f, -9.97742265e-02f, 5.41525707e-02f, 5.26940525e-02f,
  2.98302546e-02f, 1.45833656e-01f, -2.59679928e-02f, -1.97747499e-01f, 7.49220401e-02f, -9.29074660e-02f, 1.00830987e-01f, -4.10136431e-02f, -9.37486347e-03f, -3.17410827e-02f,
  5.31876041e-03f, -2.16702208e-01f, -7.08594173e-02f, -4.96113766e-03f, -3.15645002e-02f, -2.26477325e-01f, 4.13042307e-02f, 7.51942173e-02f, 1.19136162e-02f, 7.45567530e-02f,
  5.43734711e-03f, 1.47238439e-02f, 1.02446288e-01f, 3.04376066e-01f, 1.81416571e-02f, -4.03712094e-02f, -6.01379052e-02f, -1.68168582e-02f, 9.47649330e-02f, -1.71843454e-01f,
  4.84953485e-02f, -1.81764513e-01f, -2.68141508e-01f, -2.27475822e-01f, 1.53063878e-01f, -3.19414496e-01f, -1.16128698e-01f, -3.54142696e-01f, 4.30788510e-02f, 3.33024234e-01f,
  -3.38692442e-02f, 1.83275878e-01f, 2.00995833e-01f, -5.46747595e-02f, 2.23633856e-01f, 3.32591891e-01f, 1.81486428e-01f, -6.39321804e-02f, -9.96005349e-03f, -1.71237309e-02f,
  1.64982900e-01f, 5.76641522e-02f, 1.97414547e-01f, 8.84328634e-02f, 1.78487882e-01f, -9.61352065e-02f, 1.83858365e-01f, -2.06879824e-02f, 1.13662459e-01f, 2.35238317e-02f,
  9.87597406e-02f, 1.03559867e-01f, 1.76527694e-01f, 1.50840819e-01f, 1.66951135e-01f, -4.80927415e-02f, -8.37553889e-02f, 5.04218638e-02f, -2.72082686e-01f, 9.62455273e-02f,
  -3.84146906e-02f, 1.64608881e-01f, -5.51436134e-02f, -7.67634138e-02f, 2.84598917e-01f, -2.42476794e-03f, 8.65913257e-02f, 1.15749307e-01f, -2.15328559e-02f, -9.23448280e-02f,
  -2.15806425e-01f, 3.89170758e-02f, -5.73180914e-02f, -4.26061824e-02f, 1.91422001e-01f, 1.15641445e-01f, -2.21634656e-01f, -3.51897180e-02f, -3.17356922e-02f, -1.94117337e-01f,
  1.80086806e-01f, 1.48875415e-01f, 1.95080593e-01f, 3.28476369e-01f, 1.52604505e-01f, 3.56332324e-02f, 5.02194278e-02f, 1.78561673e-01f, -3.14917386e-01f, 2.62164474e-01f,
  -1.23186879e-01f, 3.63448352e-01f, 3.53712231e-01f, 2.87557274e-01f, 1.46605894e-02f, -1.01978675e-01f, -3.99204679e-02f, -1.22971348e-02f, -9.48651284e-02f, -1.54469475e-01f,
  -9.08913091e-02f, -1.25611112e-01f, -9.30362102e-03f, -2.52368361e-01f, 3.32989804e-02f, 1.66760936e-01f, 7.48851001e-02f, -7.85107464e-02f, -1.13032907e-01f, -3.09078060e-02f,
  -7.38067999e-02f, 1.25220418e-01f, 1.13198638e-01f, -4.95588034e-02f, -1.57136265e-02f, -1.75308250e-02f, 4.17433120e-02f, 4.09120810e-04f, 9.82710347e-02f, 2.32108474e-01f,
  -1.82514459e-01f, 1.21935964e-01f, 1.28683420e-02f, -9.41409171e-03f, -3.11296806e-02f, 7.23389536e-02f, 2.09304504e-03f, 4.12053503e-02f, 1.51428193e-01f, 1.69634700e-01f,
  -2.24462375e-01f, -9.14547294e-02f, -5.61175980e-02f, -3.61557081e-02f, 1.24769108e-02f, 2.97846794e-02f, -1.83430631e-02f, 4.85736467e-02f, 6.76846206e-02f, 2.46347219e-01f,
  1.88708454e-01f, 4.27882284e-01f, 1.27154201e-01f, 1.45754397e-01f, -3.67025547e-02f, 2.89065033e-01f, 2.88757175e-01f, 7.11372942e-02f, 1.59438163e-01f, -4.47977632e-02f,
  -9.15086120e-02f, 3.12777638e-01f, 1.81056499e-01f, -1.94542795e-01f, 2.04281971e-01f, -1.20710708e-01f, 1.26087114e-01f, 9.50249508e-02f, 1.47915319e-01f, -1.43247366e-01f,
  1.71994179e-01f, 3.90592106e-02f, 1.41876861e-01f, -4.19688672e-02f, 7.59965703e-02f, 1.60546795e-01f, 1.42256215e-01f, 2.12989165e-03f, 1.81274429e-01f, -4.74476516e-02f,
  1.60506025e-01f, -1.24752466e-02f, 1.08790714e-02f, 1.14779964e-01f, 2.43981227e-01f, 2.51039386e-01f, 5.43878824e-02f, 4.94234599e-02f, -4.02993038e-02f, 7.91629702e-02f,
  3.94278020e-02f, 1.39391884e-01f, 1.06589071e-01f, 2.54701644e-01f, -5.48462495e-02f, 3.72305326e-02f, -1.64399639e-01f, -4.95416746e-02f, -3.01674664e-01f, 4.17817980e-02f,
  -2.38007563e-03f, -2.51475334e-01f, 1.12011768e-01f, -6.73328787e-02f, 4.87348028e-02f, 5.77653106e-03f, -4.43761386e-02f, -1.17174730e-01f, 9.25020128e-02f, 9.65072811e-02f,
  1.91778801e-02f, 9.84375775e-02f, -7.29433894e-02f, 8.95496532e-02f, 1.47113502e-01f, 2.97181010e-01f, 2.96419948e-01f, 1.47037476e-01f, 1.48211010e-02f, -1.43942758e-01f,
  5.39883792e-01f, 6.84543848e-02f, -1.21151075e-01f, -1.63021609e-01f, -7.20534474e-02f, 6.34542899e-03f, 1.67111978e-01f, -1.88785180e-01f, 1.71954811e-01f, -1.83336303e-01f,
  -3.85764651e-02f, 2.76537210e-01f, -1.27693266e-01f, -7.06651583e-02f, -2.05141947e-01f, 1.38975337e-01f, 3.48567426e-01f, 1.99014306e-01f, 8.95888805e-02f, 2.86850818e-02f,
  8.91648903e-02f, -1.08698718e-01f, 1.34957895e-01f, -9.93776880e-03f, 1.10736065e-01f, 2.51658615e-02f, 1.28738612e-01f, 7.67132193e-02f, -2.09424947e-03f, 1.91119701e-01f,
  4.90157455e-02f, 5.04445583e-02f, -1.64674763e-02f, 1.80961601e-02f, 9.05763432e-02f, 2.31104597e-01f, 1.35402009e-01f, -1.75070331e-01f, 9.93398130e-02f, 1.70449484e-02f,
  1.24183565e-01f, 1.53099112e-02f, -7.30601419e-03f, 3.45232487e-01f, 6.06675744e-02f, 8.66457820e-02f, -2.39522010e-02f, 2.15276197e-01f, -1.00406528e-01f, 3.99641730e-02f,
  -5.75711578e-02f, 4.16720808e-02f, 2.71786809e-01f, 2.73062170e-01f, -1.15132935e-01f, 4.75351624e-02f, -2.72369385e-01f, -1.59932878e-02f, -7.17625991e-02f, -1.21893428e-01f,
  -1.09852359e-01f, 2.47050449e-02f, -1.30436137e-01f, 4.25312929e-02f, 4.28907245e-01f, -1.70941111e-02f, 7.65624717e-02f, 3.54089849e-02f, 5.93714379e-02f, 1.12874329e-03f,
  -5.43237180e-02f, -5.24846911e-02f, 2.84396350e-01f, 5.35658300e-01f, -2.58195456e-02f, -2.06173062e-01f, -5.53083010e-02f, 8.63384381e-02f, -2.11804546e-02f, 2.12094128e-01f,
  3.02869439e-01f, -1.14882231e-01f, -2.13587396e-02f, 2.39123609e-02f, -4.62904684e-02f, -6.89433292e-02f, 1.61211833e-01f, -1.72557056e-01f, 2.57735047e-02f, 6.88921213e-02f,
  -8.60576481e-02f, -5.63448519e-02f, 7.22090947e-03f, 9.10815299e-02f, 4.59672883e-02f, -7.04862028e-02f, -9.08501223e-02f, -3.55602503e-02f, 1.69736519e-01f, -1.59901672e-03f,
  7.01690614e-02f, -5.70199676e-02f, 1.39972746e-01f, -1.28651738e-01f, 4.85631712e-02f, 1.69569120e-01f, 2.79479057e-01f, -4.45756093e-02f, -1.11519508e-01f, 8.03070739e-02f,
  -9.69617814e-02f, 1.37102515e-01f, 5.86100966e-02f, 8.16641469e-03f, 1.91147383e-02f, -1.53147650e-03f, 1.08665161e-01f, 4.69258241e-02f, -2.80323327e-01f, 1.26340300e-01f,
  -3.63089591e-01f, -9.94448829e-03f, -1.93320632e-01f, 1.55602708e-01f, -1.32942513e-01f, -1.67692021e-01f, -8.70131329e-02f, 3.32966089e-01f, -1.77904293e-01f, -3.57507735e-01f,
  4.86581400e-02f, -5.02045192e-02f, 3.22289132e-02f, 2.72416626e-03f, 2.82603621e-01f, 9.15926546e-02f, -8.70327204e-02f, 4.15677696e-01f, 1.21488504e-01f, 2.66535003e-02f,
  -5.23391878e-03f, -1.45343859e-02f, 1.54886395e-01f, -2.77284328e-02f, 4.82008040e-01f, -9.89452004e-02f, 1.74646690e-01f, 2.56359167e-02f, -1.61509439e-02f, 1.21343866e-01f,
  9.89575908e-02f, -5.56444167e-04f, 2.62260512e-02f, 1.73561379e-01f, 4.46181335e-02f, -5.46533726e-02f, 1.77500382e-01f, 1.04803324e-01f, -1.14122093e-01f, 2.86623370e-02f,
  -6.11278564e-02f, 9.86478627e-02f, -9.84698012e-02f, 7.66769797e-02f, 2.19284967e-01f, -1.72629133e-01f, -1.83342591e-01f, -8.62899870e-02f, -6.78323358e-02f, -1.84217263e-02f,
  5.90015687e-02f, 1.14257326e-02f, 1.45381376e-01f, -6.98324218e-02f, 3.39653343e-02f, 9.93200094e-02f, -1.35307804e-01f, 7.85141066e-02f, -1.82809889e-01f, 6.94007007e-03f,
  1.91332385e-01f, 2.21407339e-02f, -5.35508841e-02f, -1.20065354e-01f, 7.42635056e-02f, 7.96420574e-02f, -8.05175975e-02f, 4.21670452e-03f, -8.20637718e-02f, -1.53677568e-01f,
  -2.25162327e-01f, 4.50475290e-02f, 3.47218335e-01f, -1.14441156e-01f, 1.14517182e-01f, -2.62447316e-02f, -1.20030604e-02f, 3.51960175e-02f, -9.10786986e-02f, -1.06936157e-01f,
  2.43615270e-01f, 2.88821965e-01f, 2.50244558e-01f, -2.06243675e-02f, -1.79212674e-01f, 3.84615026e-02f, 7.22485259e-02f, 6.49488568e-02f, -3.87943648e-02f, -2.95092631e-03f,
  3.19012776e-02f, -7.12392107e-02f, 4.03202176e-02f, 1.98854223e-01f, -8.03838577e-03f, 1.09880574e-01f, 1.04534827e-01f, -2.56629139e-02f, 8.87414664e-02f, -3.10216006e-02f,
  8.08468089e-02f, -1.92761235e-02f, -8.60311314e-02f, 6.29422963e-02f, 7.07290918e-02f, 2.13634465e-02f, 1.60714388e-01f, 6.14105836e-02f, -1.30827278e-01f, -1.86604023e-01f,
  1.81970596e-01f, 1.19778015e-01f, -4.22173962e-02f, 3.78402531e-01f, -4.35073301e-02f, -9.30849761e-02f, -2.15517711e-02f, -2.68121213e-01f, 4.52149138e-02f, 9.66552738e-03f,
  1.65352881e-01f, -4.60241325e-02f, 1.07330784e-01f, 1.55106261e-01f, -1.51426241e-01f, -1.23362675e-01f, -2.86748800e-02f, 3.78491998e-01f, -4.24470529e-02f, 1.80941671e-01f,
  4.94810715e-02f, -1.01275593e-01f, -1.83932856e-02f, 1.22058773e-02f, 1.82905812e-02f, -3.50683898e-01f, -1.78123135e-02f, 6.11336194e-02f, 2.46121511e-02f, -3.08990449e-01f,
  1.99697744e-02f, 2.48987809e-01f, -1.11540547e-02f, -7.50607029e-02f, 3.19548726e-01f, -3.07161450e-01f, -8.71744379e-02f, 1.58371538e-01f, -1.46964863e-01f, 1.50190771e-01f,
  -3.33623916e-01f, -1.52802110e-01f, -1.10180229e-01f, -4.15455341e-01f, 2.80192167e-01f, -6.76195696e-02f, 1.11028358e-01f, 6.28148764e-02f, 3.68672535e-02f, 2.31508881e-01f,
  1.79746717e-01f, 1.96849436e-01f, -6.59191608e-02f, -9.67282150e-03f, 1.29603073e-01f, 1.82460591e-01f, 1.05933314e-02f, -1.69715434e-02f, -2.49475185e-02f, 7.18843341e-02f,
  6.71186149e-02f, 1.86820939e-01f, -2.82834649e-01f, -6.43390715e-02f, 2.46016771e-01f, 3.29610966e-02f, -1.16643377e-01f, -1.00564668e-02f, 1.16451144e-01f, -2.75583208e-01f,
  -3.51803631e-01f, 3.22747305e-02f, -3.50124650e-02f, -2.20316470e-01f, 2.72415847e-01f, 6.50926903e-02f, 3.59475724e-02f, -7.03455880e-02f, -1.83977097e-01f, -2.69074708e-01f,
  -2.59387065e-02f, 2.79358596e-01f, -2.47838199e-01f, 1.63517550e-01f, 1.96407884e-02f, -1.68713942e-01f, -1.13117747e-01f, -1.14451051e-01f, 1.18074238e-01f, 3.11921149e-01f,
  -1.55557454e-01f, -5.87814488e-02f, -2.52263486e-01f, 1.15557052e-01f, -3.68524455e-02f, 1.86925188e-01f, -7.09951445e-02f, 1.35678828e-01f, -2.40806141e-03f, -2.68229038e-01f,
  -1.11158937e-01f, 3.86513472e-02f, -1.93433221e-02f, -2.61061221e-01f, -3.19590777e-01f, -8.96187797e-02f, 5.47402874e-02f, -4.33293805e-02f, 7.82154053e-02f, 5.59496209e-02f,
  1.93605110e-01f, 1.65514797e-01f, 1.01044118e-01f, -4.28171195e-02f, 5.74520901e-02f, 1.47928908e-01f, -1.08451778e-02f, 1.57905445e-01f, 1.29930779e-01f, 1.25959858e-01f,
  7.27314204e-02f, -1.89741366e-02f, 8.65339413e-02f, 2.04091266e-01f, 4.54173721e-02f, 8.73904862e-03f, 9.42048579e-02f, 1.27503099e-02f, 4.50730361e-02f, 5.02640717e-02f,
  -7.65645579e-02f, 1.17036611e-01f, -1.56508595e-01f, 5.09982780e-02f, 1.67670101e-01f, -1.65029988e-01f, -5.77307604e-02f, 4.79723439e-02f, 3.84983942e-02f, 6.31845370e-03f,
  1.10083111e-02f, 1.10472076e-01f, -4.58350070e-02f, 1.48096666e-01f, -4.14222553e-02f, -4.49444383e-01f, 8.66709128e-02f, 4.90601212e-02f, -1.53340459e-01f, -5.66238463e-01f,
  2.57357001e-01f, -8.07840005e-02f, 1.36454642e-01f, -4.11560357e-01f, 6.42264709e-02f, -2.00838521e-01f, 1.33768514e-01f, -1.30484894e-01f, 1.03562593e-01f, -2.59395778e-01f,
  -2.83018462e-02f, -8.88963863e-02f, 1.86245576e-01f, 3.57458949e-01f, 1.58479378e-01f, -2.76470184e-01f, -3.66417617e-02f, 3.01976651e-01f, -1.57170311e-01f, 2.03289822e-01f,
  -8.39630216e-02f, -2.86032856e-01f, -2.87568159e-02f, 2.10190341e-01f, 1.15541361e-01f, 1.14475852e-02f, 4.65385765e-02f, -3.37147489e-02f, 2.60734335e-02f, 1.40075341e-01f,
  1.15724832e-01f, -1.19998515e-01f, 1.93218395e-01f, 1.55137733e-01f, 1.31100476e-01f, 1.68327823e-01f, -5.16087860e-02f, 1.78872272e-01f, 9.91070792e-02f, 1.87042758e-01f,
  -1.09296091e-01f, 2.39480019e-01f, 1.17519960e-01f, 2.74537839e-02f, -1.02969036e-01f, 2.67766744e-01f, -1.15214810e-01f, -3.26663435e-01f, -1.13429278e-01f, -4.65925671e-02f,
  -6.20969236e-02f, -2.01293394e-01f, 2.43302107e-01f, -1.10094242e-01f, 5.60865365e-02f, -1.60424814e-01f, -1.21298082e-01f, -2.41390735e-01f, -4.04166616e-02f, -1.28239337e-02f,
  1.82915106e-01f, 1.47986785e-01f, 7.42536336e-02f, 5.99536560e-02f, 6.61057532e-02f, -2.31529802e-01f, 3.81303616e-02f, -2.63743661e-02f, -2.59671479e-01f, 3.08223069e-02f,
  6.02565669e-02f, 2.58033015e-02f, -1.02989271e-01f, -2.39070747e-02f, 1.09147586e-01f, 7.55502284e-02f, -1.06023200e-01f, -3.45515043e-01f, -8.16420689e-02f, 1.88530877e-01f,
  -8.12115669e-02f, -4.64180857e-02f, 1.35231733e-01f, -1.27771899e-01f, -3.49309772e-01f, 1.63095549e-01f, 1.11043461e-01f, 9.62590426e-02f, 9.78345275e-02f, -5.35117649e-02f,
  1.07334562e-01f, 2.20116340e-02f, 1.67090178e-01f, 5.54107428e-02f, 2.54449025e-02f, 7.21905008e-02f, 2.23319679e-02f, 6.76124543e-02f, 1.75526470e-01f, 1.85643304e-02f,
  -2.71192542e-03f, 2.96848983e-01f, 1.37314305e-01f, -1.27086993e-02f, 1.11772776e-01f, -1.08589672e-01f, -2.38069326e-01f, 1.38113320e-01f, -1.55419633e-01f, -6.84166476e-02f,
  -1.09665513e-01f, 2.54929066e-03f, -1.15409512e-02f, -5.09084351e-02f, 3.28955874e-02f, -9.47167128e-02f, 4.26888391e-02f, -9.11676288e-02f, 7.21963644e-02f, -9.44247022e-02f,
  1.20477099e-02f, -5.16392961e-02f, 9.59929675e-02f, 5.31488061e-02f, 1.88263088e-01f, -8.49542841e-02f, 8.05431753e-02f, 1.24905527e-01f, -1.53536290e-01f, -2.13655919e-01f,
  -5.68370111e-02f, -8.55022669e-03f, 2.87412144e-02f, 2.69222885e-01f, 5.58599941e-02f, 7.81619921e-02f, 6.12046421e-02f, 2.23195329e-02f, -8.23750943e-02f, -3.80625725e-02f,
  2.05990132e-02f, 7.44073763e-02f, 4.10586864e-01f, 3.77873659e-01f, -8.92198682e-02f, -2.16168344e-01f, -4.47688252e-02f, 2.10096598e-01f, -1.63803801e-01f, 1.62090927e-01f,
  -4.48970944e-02f, 5.08318432e-02f, 1.09203197e-02f, -3.82080898e-02f, 3.39112692e-02f, 1.26822844e-01f, 8.12901929e-02f, 7.54526556e-02f, 1.42289653e-01f, -4.38890830e-02f,
  1.71426147e-01f, -9.53442305e-02f, -1.43046235e-03f, 1.48577243e-01f, 9.67383608e-02f, -8.31914693e-02f, -5.98081984e-02f, -6.26750812e-02f, 9.33319628e-02f, -1.45041440e-02f,
  1.34055808e-01f, 1.17273241e-01f, -8.00301880e-02f, -7.88011029e-02f, 5.37284277e-03f, -9.71527472e-02f, 1.27344787e-01f, 5.21583203e-03f, 1.83295861e-01f, -1.44287288e-01f,
  -3.13983038e-02f, -7.21634105e-02f, -2.06606783e-04f, 4.18859981e-02f, -1.04015023e-01f, 1.82979137e-01f, -1.92674249e-01f, -1.26125053e-01f, 6.82038367e-02f, 2.14158177e-01f,
  -1.16001196e-01f, -1.61440402e-01f, 3.40732574e-01f, -2.38090195e-02f, 2.41235286e-01f, -3.11595917e-01f, 4.44063656e-02f, -1.30380504e-02f, -6.81597143e-02f, -1.30189985e-01f,
  2.72566766e-01f, 1.91118255e-01f, -7.08760917e-02f, 1.12765573e-01f, 1.88827932e-01f, -4.89726394e-01f, -2.05895647e-01f, 2.87439432e-02f, 5.97358979e-02f, 1.72143072e-01f,
  -1.22072965e-01f, -1.08780622e-01f, 8.47882107e-02f, -4.71408993e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 26)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 26;
const float L1_fan_Bp_bar_data[] = {
  2.04122856e-01f, 5.09642698e-02f, -2.44090743e-02f, 5.56151159e-02f, -3.13249230e-02f, -1.08828530e-01f, -1.06703803e-01f, 1.50368109e-01f, 6.19834736e-02f, -8.36702734e-02f,
  1.93569168e-01f, 5.58568239e-02f, 1.14785641e-01f, 1.86080718e-03f, 6.71296800e-03f, -1.89258248e-01f, 3.48114669e-02f, 5.37573658e-02f, 1.20567024e-01f, -9.02225599e-02f,
  6.70284256e-02f, -5.22776656e-02f, 7.22881034e-02f, 9.32649747e-02f, 2.18046814e-01f, 1.96613207e-01f
};

// L2_fan_Wp (Shape: 19 x 64)
const int L2_fan_Wp_rows = 19;
const int L2_fan_Wp_cols = 64;
const float L2_fan_Wp_data[] = {
  -1.07527755e-01f, 8.22785869e-02f, 8.19743723e-02f, 4.13622521e-02f, 4.14525811e-03f, 4.38323840e-02f, -8.11646953e-02f, 4.94353920e-02f, -1.75013348e-01f, -2.92590959e-03f,
  4.13079411e-02f, -2.68079210e-02f, -1.95113923e-02f, 2.64509898e-02f, -8.96834508e-02f, -6.60515577e-02f, 2.49094486e-01f, -6.61089942e-02f, -1.07877091e-01f, 4.07576002e-02f,
  1.56486370e-02f, -1.38393253e-01f, 2.17119887e-01f, 1.04928007e-02f, 1.22733556e-01f, -1.26306579e-01f, -8.87038559e-02f, -2.08287254e-01f, -1.05857678e-01f, -3.73800732e-02f,
  -7.53488531e-03f, 1.04996763e-01f, -7.66592622e-02f, -1.19861096e-01f, 2.41957605e-01f, -1.00476202e-02f, 6.59331679e-02f, -4.38050047e-04f, 3.14041413e-02f, 1.26842201e-01f,
  2.18150437e-01f, 8.13859552e-02f, -5.32271340e-02f, 1.35884136e-01f, 2.94067822e-02f, 2.35382959e-01f, -5.62853739e-02f, -2.60382801e-01f, 6.67784810e-02f, 1.26168549e-01f,
  3.07671502e-02f, 6.46783337e-02f, -1.24843918e-01f, 8.86036605e-02f, 1.26954298e-02f, -1.30947717e-02f, -8.50111023e-02f, 8.83028656e-03f, -8.38584155e-02f, -3.08488235e-02f,
  5.79535551e-02f, 1.69519648e-01f, -5.74027523e-02f, 7.88908452e-03f, -1.60269693e-01f, -1.33412346e-01f, -6.07994981e-02f, -4.19277735e-02f, -5.35292365e-02f, -1.48015827e-01f,
  8.64906311e-02f, -3.76905538e-02f, 7.37265497e-02f, 2.79026926e-02f, 8.96875635e-02f, -3.11932061e-02f, -4.63250950e-02f, -9.20403004e-02f, -5.60997687e-02f, 1.11710452e-01f,
  7.51100928e-02f, -1.73920318e-01f, -8.53046998e-02f, -5.05793802e-02f, 2.63213128e-01f, -1.53451234e-01f, -2.04611629e-01f, 1.39019296e-01f, -1.12725236e-01f, 1.70828953e-01f,
  -5.20109721e-02f, 6.30038232e-02f, 4.74141426e-02f, -1.69090003e-01f, -9.19072852e-02f, -2.93317474e-02f, -3.90700623e-02f, 1.33953065e-01f, -1.27158120e-01f, 3.40738632e-02f,
  -1.46077216e-01f, -1.60223916e-01f, 1.25255942e-01f, -2.01509520e-01f, -3.51481624e-02f, -2.50344157e-01f, -1.47688285e-01f, -2.16321163e-02f, 7.30990171e-02f, -8.02395269e-02f,
  3.54711968e-03f, 1.82210982e-01f, 1.35072798e-01f, -1.43147290e-01f, 1.73788473e-01f, -5.27181327e-02f, 2.69760668e-01f, -1.64365336e-01f, -7.01707648e-03f, -3.45874205e-02f,
  6.39761537e-02f, 2.76909191e-02f, 1.10399783e-01f, -7.76552707e-02f, -5.93998609e-03f, -1.82048753e-01f, 9.43322778e-02f, 1.62903011e-01f, -1.05904818e-01f, -9.67978127e-03f,
  -8.15272629e-02f, 1.78114295e-01f, -1.76636949e-01f, 1.39192626e-01f, -1.02696903e-01f, -6.12930283e-02f, -5.07443175e-02f, 1.27522096e-01f, -3.35389525e-02f, 3.94358821e-02f,
  1.62208211e-02f, -7.13235736e-02f, -9.93871987e-02f, -2.15605214e-01f, -1.04644157e-01f, 1.85826659e-01f, 4.15653214e-02f, 1.25675216e-01f, -2.05022857e-01f, 1.27467558e-01f,
  2.33208105e-01f, 3.20890658e-02f, -3.31537500e-02f, -1.86372191e-01f, 1.44120425e-01f, -7.95382354e-03f, 1.40059948e-01f, 2.40757108e-01f, -1.22767091e-02f, 2.07328260e-01f,
  -5.52937528e-03f, 4.21824865e-02f, 1.94148198e-01f, -4.97535653e-02f, 3.32942367e-01f, -6.52821213e-02f, -2.57137924e-01f, 2.08057404e-01f, 6.11125976e-02f, 2.18900919e-01f,
  1.79687515e-01f, -8.90506245e-03f, -1.42865539e-01f, 6.59652054e-02f, 5.78413084e-02f, -2.96722144e-01f, 7.27574825e-02f, 5.25213927e-02f, -2.20227968e-02f, 1.73931956e-01f,
  -3.22345555e-01f, 2.51694247e-02f, -1.89847667e-02f, 1.22148231e-01f, 2.72850096e-01f, -8.43998976e-03f, -1.85534760e-01f, 1.70278087e-01f, 5.93767166e-02f, -1.78326257e-02f,
  -1.47589892e-01f, -2.11903453e-01f, 1.62442878e-01f, 3.38715240e-02f, -1.61570415e-03f, 1.09607592e-01f, 2.88803875e-01f, 9.84835029e-02f, 1.06843092e-01f, -1.22494020e-01f,
  -1.09646447e-01f, -2.75960919e-02f, -1.87468454e-02f, 5.24729304e-02f, 9.77246910e-02f, 1.75868854e-01f, -2.84934156e-02f, 1.36469945e-01f, 8.92977193e-02f, 3.80178951e-02f,
  3.76606621e-02f, 6.69457838e-02f, 8.29968229e-02f, -2.22161561e-02f, -3.60002704e-02f, -2.75862236e-02f, -5.78996725e-04f, -1.40244767e-01f, 2.62445211e-02f, -2.56570488e-01f,
  5.63702220e-03f, -1.06525935e-01f, 1.83726586e-02f, 8.70709047e-02f, 1.27147838e-01f, -2.77954936e-01f, 2.61767983e-01f, -1.05516762e-01f, 2.27256328e-01f, -4.46424745e-02f,
  8.61737132e-02f, 5.26756188e-03f, 2.35056028e-01f, 4.87392396e-03f, 9.94458236e-03f, 1.71394780e-01f, -3.06626856e-02f, 5.43353371e-02f, -1.40794680e-01f, 4.64470834e-02f,
  7.27493912e-02f, 2.84377299e-02f, 1.17273115e-01f, 7.35140294e-02f, -1.88516863e-02f, 9.04279500e-02f, 7.66777769e-02f, -1.64519206e-01f, -1.26153290e-01f, -9.88443792e-02f,
  -1.81543440e-01f, -9.83559340e-02f, 2.08370313e-01f, 1.19629495e-01f, -1.38450474e-01f, 4.81292233e-02f, -2.10573137e-01f, -1.18606895e-01f, 1.50363505e-01f, -8.61192718e-02f,
  -3.43413949e-02f, -1.75467208e-01f, 1.55890822e-01f, -4.89311330e-02f, 9.80808139e-02f, -1.39436247e-02f, -1.80328116e-02f, -1.67812034e-01f, -3.18269096e-02f, -2.85766512e-01f,
  -1.54169172e-01f, 2.00968981e-02f, -1.71445489e-01f, -5.13200462e-02f, -1.45559505e-01f, -4.27395254e-02f, 3.90137434e-02f, -2.43744925e-01f, -5.91014437e-02f, 1.39920134e-02f,
  -1.36585489e-01f, 4.85839806e-02f, -5.32650203e-02f, -1.61339473e-02f, -1.15022659e-01f, -2.57902294e-01f, 4.50273603e-02f, 2.24542096e-02f, -5.03550805e-02f, 1.79587036e-01f,
  4.33055945e-02f, -1.42002583e-01f, -3.19065422e-01f, -2.11102497e-02f, -1.03254691e-01f, -1.41776785e-01f, -6.99226409e-02f, -1.82540715e-01f, 2.35184166e-03f, -5.87422252e-02f,
  1.34362832e-01f, -1.76238641e-01f, 6.36174679e-02f, 3.10411185e-01f, 3.48472536e-01f, 2.87438706e-02f, 3.18240859e-02f, -1.71548516e-01f, 1.16626382e-01f, -5.19984681e-03f,
  -2.48082075e-03f, 2.11902276e-01f, -3.21576409e-02f, 6.47797659e-02f, -6.71538115e-02f, -1.23961397e-01f, -3.49061638e-02f, -2.59879649e-01f, 2.75752228e-02f, 1.24020234e-01f,
  1.52247429e-01f, 1.03622593e-01f, 4.37026881e-02f, 2.01712754e-02f, -8.93458873e-02f, 1.75515890e-01f, -3.24212164e-02f, -9.94880311e-03f, 2.28458848e-02f, 6.37802631e-02f,
  -9.30882767e-02f, -1.29677311e-01f, 2.39176303e-01f, 3.73830795e-02f, -9.90646556e-02f, 1.66055590e-01f, 3.08200158e-02f, 2.55970806e-01f, -1.32401381e-02f, -6.68269470e-02f,
  4.33865860e-02f, -7.93193951e-02f, 2.47828718e-02f, 1.17519259e-01f, 4.13601956e-04f, -1.77559614e-01f, -2.59616882e-01f, -4.61753970e-03f, 6.86059669e-02f, 9.01792720e-02f,
  8.18869025e-02f, 5.31687438e-02f, -2.61878744e-02f, -1.43828541e-01f, 1.50889121e-02f, -1.42645255e-01f, 9.52857956e-02f, -1.78737104e-01f, 1.40297949e-01f, 9.28917751e-02f,
  3.07869881e-01f, -1.05107218e-01f, 6.63343072e-02f, 2.47330070e-01f, 1.25278518e-01f, 2.27426831e-02f, -1.84839472e-01f, 2.41753999e-02f, -5.69856353e-02f, 2.24517316e-01f,
  2.09564805e-01f, 1.40906900e-01f, -3.62392180e-02f, 4.52021733e-02f, 2.98271514e-03f, -2.53958963e-02f, -1.93171814e-01f, 1.51474133e-01f, 1.68294936e-01f, -1.03271641e-01f,
  2.08757102e-01f, 6.07769042e-02f, -2.18273085e-02f, 5.37712947e-02f, -1.29499093e-01f, -2.21617639e-01f, -4.47293324e-03f, -1.13399975e-01f, -1.55509651e-01f, 2.75896937e-01f,
  -2.92319385e-03f, 7.77784809e-02f, 4.12394467e-04f, 1.33585855e-01f, -1.26422092e-01f, -1.30758598e-01f, -1.16086975e-01f, -6.61697611e-02f, -1.09993674e-01f, -9.25919414e-02f,
  -1.18528754e-02f, 3.80836315e-02f, 8.09742734e-02f, -1.50150791e-01f, 1.76197216e-01f, 2.29727596e-01f, -1.19691402e-01f, 1.03031673e-01f, 1.12334646e-01f, -1.13586903e-01f,
  1.62449703e-01f, -1.08001851e-01f, -4.94895466e-02f, -1.86142102e-01f, -1.30483076e-01f, 1.33348733e-01f, 3.73871140e-02f, 1.54832467e-01f, -1.64408371e-01f, 1.04804635e-01f,
  -8.05051997e-02f, -5.99110685e-02f, -2.13903654e-02f, -2.75085449e-01f, 2.08101049e-01f, 3.16988560e-03f, 1.65674254e-01f, -4.07772437e-02f, 5.61985150e-02f, -2.18425274e-01f,
  8.45352486e-02f, 2.46871740e-01f, 2.80157089e-01f, -1.42042441e-02f, -2.93676466e-01f, -4.38544117e-02f, -6.12634383e-02f, 2.25913785e-02f, -7.69319683e-02f, 3.56066488e-02f,
  -2.84072250e-01f, -6.33295774e-02f, 7.17203990e-02f, 2.41115406e-01f, -2.92684406e-01f, 6.10642768e-02f, -4.23530489e-02f, 7.25105777e-02f, -1.91887412e-02f, -3.87446769e-02f,
  2.58757919e-02f, -1.06846340e-01f, 1.10036619e-01f, -3.40977311e-02f, 1.54240308e-02f, -3.07517182e-02f, -1.02630518e-01f, 1.82206798e-02f, -1.02534093e-01f, -6.80033118e-02f,
  -1.08842991e-01f, -5.08878678e-02f, -1.32191375e-01f, 2.12950006e-01f, 9.06118006e-02f, 1.39367923e-01f, -1.60798222e-01f, 9.39319432e-02f, -1.67931207e-02f, 2.24691331e-01f,
  -5.31014651e-02f, -3.17516774e-01f, -2.14805141e-01f, 1.23227946e-01f, 5.68897463e-02f, 3.97866368e-02f, -4.83678132e-02f, -7.96486884e-02f, -6.73824996e-02f, -1.61353289e-03f,
  2.05612592e-02f, 2.09976211e-01f, 1.58660918e-01f, -2.83106625e-01f, 2.18868777e-01f, -1.30411431e-01f, -2.56077528e-01f, 3.47186327e-02f, 1.11517444e-01f, -8.49153381e-03f,
  2.39133254e-01f, 4.34982702e-02f, 1.74283367e-02f, 1.47338122e-01f, 2.33570769e-01f, -1.75859913e-01f, 9.72524360e-02f, -1.03671663e-01f, -1.44457653e-01f, 2.49020264e-01f,
  1.57098193e-02f, 9.04650167e-02f, -9.02818441e-02f, -3.77371944e-02f, 2.62830466e-01f, 1.12028532e-01f, 3.10790669e-02f, 1.57678589e-01f, -2.42420018e-01f, 1.22654118e-01f,
  1.68994024e-01f, -1.78297177e-01f, -1.39610609e-02f, 5.84830754e-02f, 3.01303953e-01f, 8.85967910e-02f, -1.85435526e-02f, -2.35911533e-01f, 6.79520220e-02f, 8.56012329e-02f,
  -9.94335264e-02f, 8.68384168e-02f, -9.53021049e-02f, 1.17173500e-01f, 8.75855312e-02f, -8.73835664e-03f, -2.67220046e-02f, -1.20726172e-02f, 5.27586751e-02f, 1.40646264e-01f,
  5.84259294e-02f, 2.99993362e-02f, -3.02366406e-01f, -2.04606071e-01f, 1.27466545e-01f, -1.49311140e-01f, 2.20528468e-02f, 1.62925094e-01f, -1.08475059e-01f, -2.83169031e-01f,
  1.17206238e-01f, 4.90106456e-02f, -3.12304357e-03f, 1.12582080e-01f, 1.84303701e-01f, -1.90234751e-01f, 1.71942353e-01f, 1.26555160e-01f, 1.35008327e-03f, -4.00645062e-02f,
  -1.70312613e-01f, 2.76673496e-01f, -1.15427673e-01f, 2.12872624e-01f, -8.49877074e-02f, 2.36538257e-02f, 6.89884797e-02f, 3.51858363e-02f, -1.34050637e-01f, -1.70578167e-01f,
  -1.05788767e-01f, 2.23115906e-02f, -5.72719313e-02f, 6.95210099e-02f, -2.49740049e-01f, -6.49671853e-02f, -1.17904670e-03f, 1.31529674e-01f, 3.54271770e-01f, -8.64607245e-02f,
  -5.57596199e-02f, 5.77766486e-02f, -9.16031972e-02f, -5.72547354e-02f, -3.42721702e-03f, -1.30921140e-01f, -2.68173307e-01f, 1.37239426e-01f, -1.03737555e-01f, -2.50481308e-01f,
  -8.20840001e-02f, 6.75670579e-02f, -1.36826292e-01f, 9.75084007e-02f, 5.25622480e-02f, -3.34136635e-02f, -3.98902521e-02f, -1.26926592e-02f, 7.42269456e-02f, -1.61280066e-01f,
  -8.66477787e-02f, 6.51247501e-02f, -1.36845440e-01f, -1.91667616e-01f, -1.01545341e-01f, 1.54930493e-02f, -9.75240320e-02f, 9.31732506e-02f, -2.76820213e-01f, -2.25659132e-01f,
  1.81084171e-01f, 1.45165384e-01f, 2.37850808e-02f, -4.33903039e-02f, 3.20781916e-02f, -9.15331170e-02f, -8.24788585e-02f, -3.76072992e-03f, -2.56641898e-02f, 3.10167819e-01f,
  1.89602390e-01f, -3.39834660e-01f, -3.20814922e-02f, -2.77598619e-01f, -6.58326149e-02f, -2.27572605e-01f, 9.71388817e-02f, 2.01734062e-02f, 1.30098879e-01f, -5.53237833e-02f,
  1.01810381e-01f, -2.08355814e-01f, -7.03778416e-02f, 1.11387298e-01f, 2.17636555e-01f, 1.40766829e-01f, -2.55506963e-01f, -8.80456716e-02f, 2.41111964e-02f, 1.15103550e-01f,
  -5.55049703e-02f, -6.42245784e-02f, 2.47887969e-01f, -8.91569257e-02f, 2.16087878e-01f, 2.68600196e-01f, -1.24088101e-01f, -6.91436827e-02f, -1.01773724e-01f, -4.08046395e-02f,
  1.01228304e-01f, 1.82510406e-01f, -1.29911438e-01f, 8.46258476e-02f, -1.07781209e-01f, -9.39606782e-03f, -1.83832303e-01f, -8.39860439e-02f, -7.28441179e-02f, -4.94846068e-02f,
  1.35310933e-01f, -1.86671287e-01f, -3.65846545e-01f, -9.74287391e-02f, -2.03950554e-01f, 6.93473518e-02f, 1.02173671e-01f, 1.08900979e-01f, -1.08849481e-01f, -1.41653225e-01f,
  -3.32120582e-02f, -2.25794390e-01f, 1.07089728e-02f, 6.72549009e-02f, -3.96339506e-01f, -1.02017529e-01f, 9.42002535e-02f, 2.73163557e-01f, 8.49432722e-02f, 2.40442194e-02f,
  1.50809854e-01f, -5.15807532e-02f, -6.37725368e-02f, 9.01926458e-02f, -3.47067893e-01f, 1.42167639e-02f, -6.06315881e-02f, 1.34616539e-01f, -1.38435200e-01f, 4.96821925e-02f,
  -5.98380603e-02f, 2.45864168e-01f, 1.33718342e-01f, 7.70676956e-02f, 1.08164931e-02f, -1.65003240e-01f, 7.91868344e-02f, -1.61955059e-01f, -7.09888712e-02f, 8.06507543e-02f,
  5.61454007e-03f, 7.20707104e-02f, 7.32106566e-02f, 1.24119833e-01f, 7.83429593e-02f, 1.66341767e-01f, -4.70553041e-02f, 1.44245610e-01f, -3.10637474e-01f, -1.91147059e-01f,
  -2.14980632e-01f, -5.38291447e-02f, 7.61603639e-02f, -8.45780820e-02f, 1.30278885e-01f, -1.59141377e-01f, -2.03847766e-01f, 8.42339247e-02f, 2.50436515e-01f, -1.17696993e-01f,
  -1.37829795e-01f, -9.69142169e-02f, -1.01206057e-01f, 1.24445595e-01f, -1.25618845e-01f, -1.02602296e-01f, -8.84272605e-02f, 7.56230503e-02f, -5.60419681e-03f, 1.21915750e-01f,
  -3.30584869e-02f, 2.65249722e-02f, 1.24059208e-01f, 1.49729937e-01f, -5.77104948e-02f, -1.35310456e-01f, 6.50243461e-02f, 1.40735105e-01f, -2.10119292e-01f, -1.62198946e-01f,
  -5.12955077e-02f, -2.07286719e-02f, 3.75068933e-01f, -1.84047401e-01f, 7.86558539e-02f, 1.33918926e-01f, -6.43644854e-02f, 1.57379806e-01f, -2.16116309e-01f, 3.51049006e-01f,
  8.70984122e-02f, 8.04960802e-02f, -1.45838320e-01f, 4.17200997e-02f, -1.13785237e-01f, 1.12728737e-02f, -8.22355375e-02f, 2.37028345e-01f, -9.71518084e-02f, -1.61222741e-01f,
  -1.20027371e-01f, -9.30170119e-02f, 1.88424764e-03f, 3.25593203e-02f, -1.26781523e-01f, -1.15882434e-01f, 3.45216803e-02f, -1.87676504e-01f, -4.46549430e-03f, 1.92742705e-01f,
  1.16844334e-01f, -5.28042540e-02f, -2.00627133e-01f, -1.43215090e-01f, 2.38962725e-01f, -2.12750316e-01f, -1.09105587e-01f, -9.79687180e-03f, -2.34219581e-01f, -2.89958976e-02f,
  7.55229816e-02f, 9.76431649e-03f, -4.49118726e-02f, 1.38475999e-01f, -1.66113153e-01f, -7.66957551e-02f, -1.12558581e-01f, -2.73055345e-01f, -9.10588577e-02f, -1.31421939e-01f,
  -1.20579280e-01f, 1.19114956e-02f, 5.61608225e-02f, -4.31172438e-02f, -1.10545412e-01f, -3.00343148e-02f, -1.56634804e-02f, -5.84198534e-02f, 1.40234768e-01f, 8.29691142e-02f,
  -1.89361036e-01f, -2.98784468e-02f, -3.38051543e-02f, 2.73128837e-01f, -4.68084663e-02f, 3.13456148e-01f, -2.10595936e-01f, -8.81316978e-03f, -1.34304315e-01f, 1.06209897e-01f,
  1.14721358e-01f, -7.38117024e-02f, 1.11613989e-01f, -3.42382520e-01f, -4.05742675e-02f, 3.06850020e-02f, -1.54444322e-01f, 3.39124002e-03f, -1.11789487e-01f, -1.63699463e-01f,
  9.06115323e-02f, -3.36392969e-02f, -7.44570717e-02f, -8.94373730e-02f, -3.64364162e-02f, -1.99655816e-01f, -2.82899261e-01f, -5.35949506e-02f, -2.36666262e-01f, 1.90387353e-01f,
  8.61312449e-02f, 1.61232904e-01f, 9.64587852e-02f, -2.11849600e-01f, 5.46743385e-02f, -2.56928932e-02f, 3.00487150e-02f, 3.34983207e-02f, -1.65431887e-01f, 6.49239123e-02f,
  1.09622590e-01f, 2.63771322e-02f, -5.86344264e-02f, -1.71842828e-01f, 2.71308701e-02f, 5.67596331e-02f, -8.64723697e-03f, 1.43141627e-01f, -1.06625572e-01f, 1.97121546e-01f,
  1.35248095e-01f, -5.21906130e-02f, -5.28097153e-02f, 1.77129582e-02f, 4.48916815e-02f, -4.17732894e-02f, -3.04686744e-02f, -3.82831097e-02f, -1.24956876e-01f, 1.95306003e-01f,
  7.39508122e-02f, -9.56764445e-02f, 6.63372576e-02f, -1.68029472e-01f, -3.72961424e-02f, 1.29022941e-01f, 9.64496925e-04f, 1.61479712e-01f, 7.02132285e-02f, -1.25437975e-01f,
  4.60283346e-02f, 3.53485234e-02f, 1.96961775e-01f, -3.35378721e-02f, -1.69565991e-01f, 1.88708045e-02f, -1.53179795e-01f, 1.49256855e-01f, -1.64799497e-01f, -3.87348905e-02f,
  -8.84630308e-02f, -8.93287659e-02f, -5.24818040e-02f, 1.08939961e-01f, -1.55554295e-01f, 1.50786102e-01f, 1.61782950e-02f, -2.63127405e-02f, -1.21256877e-02f, 9.23343599e-02f,
  2.52480596e-01f, 5.09568565e-02f, 1.11773454e-01f, -1.11027054e-01f, 4.45886403e-02f, -5.11658750e-02f, 3.91483977e-02f, 1.57497123e-01f, 1.28523618e-01f, -5.32827154e-02f,
  -2.67077148e-01f, -4.07278240e-01f, 1.03952840e-01f, -3.05239022e-01f, 3.17535289e-02f, 4.01878469e-02f, -6.72909915e-02f, -5.74532598e-02f, 1.08671725e-01f, -1.12588830e-01f,
  1.39571786e-01f, 1.11726254e-01f, 2.54467517e-01f, 1.44980699e-01f, 5.45831732e-02f, -2.42206343e-02f, 1.20169021e-01f, 8.40018019e-02f, 1.86532587e-01f, 4.48011905e-02f,
  -1.51937166e-02f, 1.02750666e-01f, -9.34355184e-02f, 2.08707660e-01f, -5.33624887e-02f, -5.50141670e-02f, 9.77109522e-02f, -2.83701643e-02f, 1.72464594e-01f, 1.04243658e-01f,
  9.85150114e-02f, -1.11123830e-01f, -1.56530350e-01f, -2.77784467e-01f, -2.23420128e-01f, -1.16350889e-01f, -2.00638726e-01f, 5.73916212e-02f, 8.60115513e-02f, -1.68802321e-01f,
  5.11851944e-02f, -1.16660252e-01f, 1.69902220e-01f, 8.81697237e-03f, 1.34007394e-01f, -6.97023759e-04f, 9.13072377e-02f, -8.99324287e-03f, -3.78787220e-02f, 2.25009155e-02f,
  -1.75868347e-01f, 2.98953533e-01f, 9.50569510e-02f, -5.35346791e-02f, 1.51851445e-01f, -1.99390739e-01f, 2.25485228e-02f, -1.93820067e-03f, 1.08228855e-01f, -2.18837589e-01f,
  -1.74747899e-01f, -2.11682543e-01f, 2.97219425e-01f, -1.59883916e-01f, 1.50391668e-01f, 3.78967494e-01f, 2.03778446e-01f, -8.39894637e-02f, -1.09175973e-01f, 9.08920169e-02f,
  -1.46621512e-02f, -2.04413190e-01f, -2.32668128e-03f, -6.47170022e-02f, -6.56996965e-02f, 1.20868169e-01f, -3.44018526e-02f, -3.99269089e-02f, -8.60997140e-02f, -6.84686080e-02f,
  -8.95445421e-02f, -6.25940263e-02f, 1.34554226e-02f, 1.46000385e-02f, -5.45389077e-04f, 1.85163263e-02f, -1.23398691e-01f, -1.97754070e-01f, 2.01803997e-01f, 3.07515194e-03f,
  -3.58790383e-02f, 1.18015721e-01f, -4.17223684e-02f, -9.88522768e-02f, 8.59382600e-02f, -9.50609222e-02f, -5.30660674e-02f, -5.87390102e-02f, -1.60032108e-01f, -1.70215666e-01f,
  -8.84697288e-02f, -9.69728604e-02f, -1.50018588e-01f, 6.53641298e-03f, 1.46772966e-01f, 8.03123936e-02f, 1.85640201e-01f, 2.17798233e-01f, 7.79399425e-02f, -8.83032382e-02f,
  9.52024832e-02f, -1.01418160e-01f, 1.06218152e-01f, 7.39130303e-02f, 5.27546331e-02f, -3.78170833e-02f, 7.90691897e-02f, 1.48737906e-02f, 2.66687945e-02f, -7.30727240e-02f,
  -2.22785637e-01f, 9.12874341e-02f, -1.32052988e-01f, -9.80817620e-03f, -5.38240969e-02f, -1.51021630e-01f, -4.34823424e-01f, -1.63670942e-01f, 1.06997401e-01f, -1.18298624e-02f,
  7.83381090e-02f, 2.27624789e-01f, 1.71918757e-02f, 2.12019578e-01f, -3.40806097e-02f, -1.13924436e-01f, -6.73378333e-02f, -9.64251533e-02f, -2.09457710e-01f, -2.56632477e-01f,
  3.26862894e-02f, -3.58889624e-02f, -8.63030031e-02f, 9.89214284e-04f, -9.49586183e-02f, -1.87616602e-01f, -2.23977283e-01f, -2.94055283e-01f, -1.75163373e-01f, -1.51771396e-01f,
  9.28849950e-02f, -3.06911439e-01f, -1.22112155e-01f, 1.28025919e-01f, -2.05217779e-01f, -4.93547507e-02f, 2.60004014e-01f, -1.84042752e-01f, -2.19222102e-02f, -1.95823386e-01f,
  1.27288386e-01f, -3.67940396e-01f, 7.76368519e-03f, 1.03485554e-01f, 4.60817479e-02f, 7.29934275e-02f, -2.42026642e-01f, 3.15792888e-01f, 9.22804326e-02f, 1.04388423e-01f,
  1.34128138e-01f, -4.11788076e-02f, -1.86351076e-01f, -1.36387900e-01f, 1.98966101e-01f, -1.02781625e-02f, -4.59031984e-02f, 3.99361067e-02f, 1.38868570e-01f, 7.32814744e-02f,
  9.83543098e-02f, 1.47980437e-01f, 1.51933795e-02f, -5.76058589e-03f, -1.05953865e-01f, 7.49160796e-02f, -8.06877762e-02f, 7.46108741e-02f, 4.13782783e-02f, 1.65543497e-01f,
  4.11328763e-01f, -1.48252686e-02f, -1.64175540e-01f, -1.41388714e-01f, -2.44492158e-01f, -2.93802544e-02f, -1.03268638e-01f, 1.94054917e-02f, 1.00687437e-01f, -1.79072350e-01f,
  -1.81836128e-01f, 1.00878298e-01f, -5.52021116e-02f, 2.97345612e-02f, -1.32560283e-01f, 1.05730720e-01f, -2.12508276e-01f, 2.42315099e-01f, -5.65601997e-02f, 4.83379066e-02f,
  1.80679059e-03f, -4.13582474e-02f, -6.78707734e-02f, -2.56093740e-01f, 3.30561474e-02f, -3.10373753e-02f, 9.27033871e-02f, -1.34181939e-02f, 9.16446596e-02f, -1.43139005e-01f,
  1.64028585e-01f, 5.69258668e-02f, 1.41820326e-01f, -2.25203261e-01f, 1.33988500e-01f, -2.23371133e-01f, 5.24531528e-02f, 1.42246053e-01f, 4.78887893e-02f, 9.20668393e-02f,
  -2.42128491e-01f, -2.22552624e-02f, -2.21364535e-02f, 4.00946081e-01f, 4.72030565e-02f, -1.47914276e-01f, 6.42947331e-02f, -7.68252313e-02f, -5.58135845e-02f, -1.70601889e-01f,
  -2.01573506e-01f, 2.01705441e-01f, -2.27172463e-03f, 5.76068908e-02f, -8.22789446e-02f, 2.32854709e-01f, -3.11907589e-01f, -1.40694097e-01f, 1.12803042e-01f, -1.05321109e-01f,
  -9.51835513e-02f, -1.44815773e-01f, 5.73081076e-02f, 2.10747197e-01f, -2.05868319e-01f, 2.08745245e-02f, 7.40558952e-02f, -4.43984829e-02f, 1.65042326e-01f, -2.44264945e-01f,
  -2.28573084e-01f, 9.14698020e-02f, 1.13317845e-02f, 2.45591909e-01f, 1.09292492e-02f, 2.73248285e-01f, 1.93719819e-01f, -1.01741232e-01f, -1.31305799e-01f, -9.13805813e-02f,
  -1.02104351e-01f, -1.08953044e-01f, -2.45270222e-01f, 2.53570303e-02f, -7.53495172e-02f, -1.25034168e-01f, -5.32801561e-02f, 5.67457564e-02f, 7.33634979e-02f, 1.19669907e-01f,
  4.71821986e-02f, -1.68233842e-01f, -1.67184293e-01f, 2.99778469e-02f, -6.53739199e-02f, -9.08474345e-03f, 1.66231498e-01f, 5.60277849e-02f, -1.01858914e-01f, 2.80829161e-01f,
  4.28442284e-02f, -8.24515745e-02f, -2.02945456e-01f, 6.74607307e-02f, 2.79705822e-01f, 2.04578176e-01f, -1.77398697e-01f, 6.55571371e-03f, 1.42748624e-01f, 1.87007636e-01f,
  -1.55092850e-01f, 1.02102369e-01f, 1.04523495e-01f, 3.05611759e-01f, -7.80755701e-03f, 1.22984275e-01f, -3.09288036e-02f, 7.51311518e-03f, -9.46986489e-03f, -2.93963313e-01f,
  -1.05193280e-01f, 2.34220698e-01f, -2.19499171e-01f, 1.76067024e-01f, -2.66319782e-01f, 3.57548445e-02f, 1.21927679e-01f, -8.82413983e-02f, -1.92893013e-01f, -1.07530216e-02f,
  9.03996229e-02f, 8.97085071e-02f, -2.14884117e-01f, 1.03635423e-01f, 7.69743770e-02f, -1.18060611e-01f
};

// L2_fan_Wp_bar (Shape: 26 x 64)
const int L2_fan_Wp_bar_rows = 26;
const int L2_fan_Wp_bar_cols = 64;
const float L2_fan_Wp_bar_data[] = {
  8.40490311e-02f, 2.64221549e-01f, 4.96870838e-02f, -3.30558233e-02f, -1.78591967e-01f, -2.63238791e-02f, -1.10383160e-01f, -7.23227262e-02f, -7.98657015e-02f, 9.33267251e-02f,
  4.59100418e-02f, 1.50064066e-01f, 4.29097228e-02f, 1.11752212e-01f, 5.43694161e-02f, 9.65929106e-02f, 1.32561639e-01f, -7.93792158e-02f, 3.33240815e-02f, 3.09363566e-02f,
  8.65459442e-02f, 7.14514405e-02f, -5.39821759e-02f, -2.68963456e-01f, 3.49162757e-01f, 2.81100601e-01f, -3.10080964e-03f, -1.62995905e-02f, -1.53211400e-01f, -2.01995775e-01f,
  -9.89160836e-02f, 3.52622658e-01f, 3.76544744e-01f, 4.21018660e-01f, 3.23378861e-01f, -2.70875841e-01f, -7.55173340e-02f, -3.49097222e-01f, 1.10924996e-01f, 1.19106010e-01f,
  -5.32911532e-02f, -1.06063113e-01f, -1.47105753e-01f, -1.50780633e-01f, 2.91926712e-01f, -2.05653086e-01f, -2.85466790e-01f, 2.03967959e-01f, -1.41913220e-01f, 1.84879024e-02f,
  -2.45567299e-02f, -1.98789582e-01f, 1.92539170e-02f, -3.39306220e-02f, -1.61613841e-02f, 1.65481389e-01f, 2.28564605e-01f, 1.06660798e-02f, 2.76113570e-01f, 9.31122378e-02f,
  1.66484714e-01f, -6.71959594e-02f, 4.67385575e-02f, 1.02000326e-01f, 2.12324560e-01f, 7.62991384e-02f, 1.59048736e-01f, 2.08720118e-02f, 2.88481414e-01f, 8.81748721e-02f,
  1.56983778e-01f, -2.87486762e-02f, 1.31270751e-01f, -4.95908596e-03f, 1.26019821e-01f, 2.22583130e-01f, 2.47228712e-01f, 2.96377301e-01f, 1.27686843e-01f, 2.18435496e-01f,
  9.80365835e-03f, 1.65881470e-01f, 9.58569646e-02f, -1.60258368e-01f, 3.69904600e-02f, 9.57697704e-02f, -2.49257945e-02f, 2.17835069e-01f, -2.00709060e-01f, -1.98268235e-01f,
  -9.51056108e-02f, 2.05205128e-01f, -1.03084877e-01f, -5.94814941e-02f, 1.12247922e-01f, -7.72043094e-02f, 3.70170884e-02f, -1.64415941e-01f, -1.83153719e-01f, -9.22877491e-02f,
  -1.67826235e-01f, 2.98439950e-01f, 1.40275955e-01f, 6.87752664e-02f, -2.08826825e-01f, 9.99675542e-02f, 8.31398815e-02f, -8.10615495e-02f, -2.03311160e-01f, -2.34689955e-02f,
  7.46663287e-02f, -3.94986160e-02f, 3.06190223e-01f, -2.52221432e-02f, -3.73586044e-02f, -1.65367678e-01f, 1.27811015e-01f, -1.61352009e-01f, 1.50102735e-01f, 6.18697368e-02f,
  -1.81339487e-01f, 8.97048935e-02f, -2.57055491e-01f, -3.14254500e-03f, -1.70770153e-01f, -4.99719679e-02f, 1.09843858e-01f, -1.79580361e-01f, -2.73044288e-01f, -7.75602534e-02f,
  2.08440691e-01f, 1.23287244e-02f, 9.12467390e-02f, 6.82613775e-02f, -7.06627145e-02f, 2.23068193e-01f, 3.93955037e-03f, 4.38051298e-02f, 6.84500709e-02f, -5.73853264e-03f,
  -7.53627568e-02f, -1.72983006e-01f, -7.32075647e-02f, 1.53340166e-02f, -1.61786139e-01f, -8.53139162e-02f, -7.80519396e-02f, 1.32579818e-01f, 7.33236000e-02f, 9.00943503e-02f,
  -2.63260126e-01f, -1.55740142e-01f, 7.63514638e-02f, 3.25250208e-01f, 9.80690494e-02f, -7.39889964e-02f, 5.06100431e-02f, -1.15905546e-01f, 1.14854231e-01f, 2.59307742e-01f,
  1.88513592e-01f, 4.02831197e-01f, 5.51565476e-02f, 2.03603022e-02f, -5.31907752e-02f, -4.19684678e-01f, 2.07356408e-01f, -1.71267807e-01f, -2.21368186e-02f, -2.66514003e-01f,
  1.76168308e-01f, -2.68511295e-01f, 3.46750498e-01f, -2.84933925e-01f, 6.31870180e-02f, 3.07609558e-01f, 3.37230086e-01f, 2.71030627e-02f, -3.11060995e-01f, -9.46747959e-02f,
  6.50875876e-03f, 2.89777443e-02f, 4.62445132e-02f, 2.60630972e-03f, -4.57595028e-02f, 2.73734909e-02f, 1.19602002e-01f, 1.88243300e-01f, -1.25767887e-01f, -6.21840311e-03f,
  7.68292248e-02f, 1.08547486e-01f, 7.65869543e-02f, 3.24172050e-01f, 8.48185718e-02f, 6.64061531e-02f, 9.00300369e-02f, 1.98404863e-01f, 2.97117382e-01f, 8.68158862e-02f,
  3.14791799e-01f, -1.10329986e-02f, 2.28135169e-01f, 2.59610921e-01f, 1.85911823e-02f, 4.27320749e-01f, 3.90027463e-02f, 2.74901807e-01f, 2.39206702e-01f, 2.43330240e-01f,
  9.84885171e-02f, -1.55199736e-01f, -1.96987838e-02f, 1.52610064e-01f, 8.36417377e-02f, 2.85556465e-01f, -1.00943804e-01f, -2.01382533e-01f, -2.54642248e-01f, -1.48179987e-02f,
  -9.30221751e-03f, -1.14199385e-01f, -1.38891935e-01f, 8.93054679e-02f, 1.84797511e-01f, -2.55367786e-01f, -1.10310629e-01f, -6.67528957e-02f, 1.32951155e-01f, 2.73331285e-01f,
  1.56913862e-01f, 3.24519753e-01f, -1.21388167e-01f, 2.56148726e-01f, 2.81410635e-01f, -2.58544147e-01f, -1.53838709e-01f, 1.42199889e-01f, 1.26044735e-01f, -8.72912854e-02f,
  1.53124958e-01f, -3.35936993e-02f, -1.99295461e-01f, 7.48485234e-03f, -1.55081600e-01f, -2.09454492e-01f, 1.21018164e-01f, -4.22477238e-02f, 5.88869676e-03f, 7.73010403e-02f,
  -7.40503371e-02f, 2.56088585e-01f, -7.57468343e-02f, 2.45324522e-02f, 1.54078037e-01f, -2.59471059e-01f, 9.11613181e-02f, 1.82173863e-01f, -7.11828098e-02f, -5.60533628e-02f,
  9.44450572e-02f, -1.70027539e-01f, 6.27778620e-02f, 2.16823503e-01f, -8.37817043e-03f, 3.62323187e-02f, 2.54362911e-01f, -1.02193072e-01f, -9.02521312e-02f, 3.07581007e-01f,
  1.15480654e-01f, 1.44323349e-01f, -4.93082032e-02f, -1.60717770e-01f, 4.73282970e-02f, 3.09716817e-02f, 1.61668092e-01f, -1.16345324e-01f, 3.47512588e-02f, 2.60823905e-01f,
  -3.10782492e-01f, -2.48131260e-01f, 1.84606481e-02f, -1.56426325e-01f, 1.02027640e-01f, 3.47169749e-02f, 1.44310892e-01f, 1.28203169e-01f, -1.00280114e-01f, -5.33493832e-02f,
  -1.37871742e-01f, 1.59806684e-01f, 1.64826512e-01f, -4.02875721e-01f, 8.73377696e-02f, -6.84075579e-02f, 1.23171993e-01f, -4.55585681e-02f, -3.35736126e-01f, -1.00243300e-01f,
  1.17514484e-01f, -1.18842451e-02f, -2.15540811e-01f, 1.25276759e-01f, -2.32772022e-01f, -1.32488668e-01f, 9.19861495e-02f, -2.60620177e-01f, 1.63139135e-01f, -3.03755790e-01f,
  -4.35892977e-02f, 1.56635493e-01f, 5.65714002e-01f, 4.63760868e-02f, 1.25255376e-01f, 1.24143638e-01f, 3.51007074e-01f, -4.75710630e-01f, -2.46067792e-02f, -2.20438495e-01f,
  -5.84231578e-02f, -5.27395941e-02f, -2.34896466e-02f, -2.09354106e-02f, -2.80880984e-02f, 1.19532593e-01f, 9.20753106e-02f, 6.49923831e-03f, 8.42029080e-02f, -1.68373913e-01f,
  2.09721848e-01f, -3.41586918e-02f, 3.10898453e-01f, 8.97522494e-02f, 2.12710258e-02f, -2.14722231e-01f, -3.43150757e-02f, 7.79752852e-03f, 1.27633214e-01f, -1.17522545e-01f,
  2.51331896e-01f, -1.55814588e-01f, 1.17686659e-01f, 2.17648864e-01f, -1.74156189e-01f, -1.08530186e-01f, -2.29603902e-01f, -8.67494941e-03f, -2.52606332e-01f, 4.73206490e-02f,
  -1.95397377e-01f, -5.17889082e-01f, -4.33468409e-02f, -3.41090918e-01f, -9.52321365e-02f, -1.02093190e-01f, 9.48481113e-02f, 3.84560943e-01f, 2.84589618e-01f, -2.30842099e-01f,
  -5.85568473e-02f, -2.83361733e-01f, -9.09339339e-02f, -6.24492429e-02f, -2.25376502e-01f, 1.10525750e-01f, 3.07414263e-01f, 1.22028716e-01f, -8.68736655e-02f, -2.53423929e-01f,
  2.00685725e-01f, -3.11120264e-02f, 2.63305992e-01f, -3.12141217e-02f, 7.10777938e-02f, -1.25744298e-01f, -5.19901514e-01f, 1.70226712e-02f, -2.25983158e-01f, -6.41690120e-02f,
  2.90363014e-01f, 1.48613945e-01f, 1.89050928e-01f, 1.11845024e-01f, -6.03343472e-02f, 3.35505962e-01f, 2.70804107e-01f, 4.15621176e-02f, -1.24296315e-01f, 1.35071263e-01f,
  1.85157806e-01f, -1.74945399e-01f, 1.64509326e-01f, 1.19779902e-02f, 2.99480289e-01f, 1.68235853e-01f, 2.16263026e-01f, 1.28414571e-01f, 2.17190549e-01f, -1.33341819e-01f,
  2.71819234e-01f, 4.25408483e-02f, 1.90942273e-01f, 5.84173296e-03f, -2.31891155e-01f, 4.71807178e-03f, 5.74270070e-01f, 1.31020704e-02f, 1.48229972e-01f, -4.37997282e-01f,
  -2.36881703e-01f, -3.42343986e-01f, -7.93874562e-02f, -7.71492571e-02f, -1.75471470e-01f, 1.31367832e-01f, 2.38068495e-02f, -1.50956079e-01f, 1.95818767e-01f, -2.48158965e-02f,
  1.66543335e-01f, 3.29991698e-01f, 2.14434549e-01f, 2.30921045e-01f, -9.16789547e-02f, 3.77120376e-01f, 2.10362226e-01f, -8.84201825e-02f, -1.45025581e-01f, 3.28877896e-01f,
  -1.46624729e-01f, -2.72926301e-01f, 1.31609589e-01f, -9.12626982e-02f, 1.50179118e-01f, -6.47196099e-02f, -4.73904401e-01f, -2.73805022e-01f, -1.35097966e-01f, -1.94262564e-02f,
  -2.92292237e-02f, -3.10790539e-01f, -3.16969189e-03f, 9.70613584e-03f, -6.97037354e-02f, 6.11008517e-02f, -5.53863235e-02f, 1.47779472e-02f, 1.76401101e-02f, 1.44510806e-01f,
  -3.68979946e-02f, 1.19138680e-01f, 6.97135553e-02f, -8.95284638e-02f, 7.56563619e-03f, 2.49104172e-01f, -1.25096172e-01f, 2.70974219e-01f, 2.42481777e-03f, 6.32029325e-02f,
  -1.91540539e-01f, 3.07690334e-02f, 1.31132856e-01f, 1.41680092e-01f, -8.18603039e-02f, -1.91045880e-01f, 2.31089354e-01f, 1.65006027e-01f, 3.63919809e-02f, 1.49225011e-01f,
  -1.20135076e-01f, -1.17434701e-02f, 3.05640310e-01f, 1.31100252e-01f, 1.48332361e-02f, 1.67695403e-01f, -1.37319416e-01f, 2.16833487e-01f, 3.76259461e-02f, 3.33035111e-01f,
  3.62133533e-02f, 1.28227338e-01f, 2.56402642e-01f, 7.92260990e-02f, 2.17801586e-01f, -1.06858097e-01f, -8.63928348e-02f, 2.81645983e-01f, -8.87982026e-02f, 1.38603240e-01f,
  2.13452399e-01f, 6.64323270e-02f, 2.04194076e-02f, -9.68395472e-02f, -2.37259716e-01f, 8.25379044e-02f, -3.49474460e-01f, 7.36081377e-02f, -2.66140580e-01f, 5.25847860e-02f,
  -5.55293187e-02f, -1.29869841e-02f, 1.47818640e-01f, -5.06635681e-02f, -4.23573069e-02f, -1.43909454e-01f, 5.67122214e-02f, 4.08026010e-01f, -1.37816861e-01f, 1.87094375e-01f,
  9.80701074e-02f, 6.99558705e-02f, 1.38581455e-01f, 2.45307118e-01f, 9.85001028e-03f, 1.76895633e-01f, 9.21496674e-02f, 1.98441893e-02f, -9.72762704e-02f, 1.61121681e-01f,
  -1.34363174e-01f, 2.80656070e-01f, -1.37604728e-01f, -7.25015476e-02f, -1.74150318e-01f, -1.68000415e-01f, 1.98100116e-02f, 1.17888570e-01f, -1.80242285e-02f, 4.86946739e-02f,
  2.69187599e-01f, 2.61969835e-01f, -2.07243979e-01f, 1.52576268e-01f, -6.54155463e-02f, -3.58480811e-01f, 3.37284327e-01f, 2.65522748e-01f, 6.70043156e-02f, 1.51290059e-01f,
  1.58531293e-02f, 1.60959080e-01f, -6.69769719e-02f, 4.48893487e-01f, 1.04833134e-01f, 3.07043999e-01f, 4.46784556e-01f, 9.64728817e-02f, 1.77985862e-01f, -3.36950958e-01f,
  -1.32490352e-01f, 2.48850301e-01f, -1.02125496e-01f, 4.70319510e-01f, 1.87690228e-01f, 7.15400130e-02f, 1.49867639e-01f, -1.06384590e-01f, -2.11504892e-01f, -1.72050059e-01f,
  -4.64108586e-01f, -1.98357403e-02f, 3.96989658e-02f, 1.38559908e-01f, -2.09455162e-01f, -5.82778566e-02f, 2.68127650e-01f, 1.20423101e-01f, 4.83501911e-01f, 1.45652024e-02f,
  3.68176401e-01f, 2.52639949e-01f, 1.07420571e-02f, 5.96481301e-02f, 3.33430655e-02f, 1.26564965e-01f, 2.41637766e-01f, -8.33261013e-02f, 8.78618360e-02f, -1.18134595e-01f,
  6.28250688e-02f, -1.13354623e-02f, 9.50324684e-02f, -8.26791823e-02f, 8.65590293e-03f, 1.03066027e-01f, -2.70630140e-03f, 7.00549111e-02f, 6.78658932e-02f, 2.40660310e-02f,
  9.83159691e-02f, 2.77143896e-01f, 2.39139780e-01f, -4.71930131e-02f, 1.33886887e-02f, 2.65928358e-01f, 7.60110691e-02f, -1.55830890e-01f, -4.65064310e-02f, -2.42774457e-01f,
  1.00117303e-01f, -2.15893209e-01f, -6.24273121e-02f, -3.74544859e-01f, -9.44912136e-02f, 6.61434084e-02f, -1.67659983e-01f, 2.90069282e-01f, -8.65780041e-02f, -1.11686021e-01f,
  1.26959592e-01f, 2.70516962e-01f, 6.29701689e-02f, -1.57866284e-01f, 4.24254164e-02f, -4.80017252e-02f, 1.36118323e-01f, -1.00517347e-01f, -3.30827795e-02f, 2.83057719e-01f,
  1.56589344e-01f, 2.19725698e-01f, -1.48748495e-02f, 1.84786960e-01f, 1.65053755e-01f, 1.30505681e-01f, -4.47661243e-02f, 1.21944688e-01f, -1.41954288e-01f, -1.24247484e-01f,
  6.00957349e-02f, 1.55941948e-01f, 1.58134118e-01f, -2.89838761e-01f, -5.51408045e-02f, -1.91806942e-01f, 1.01161778e-01f, -8.06794390e-02f, -4.67183590e-01f, 1.90411910e-01f,
  -9.51137468e-02f, 3.37649047e-01f, 1.46908835e-01f, -6.77304789e-02f, -1.46170586e-01f, 8.18538759e-03f, 1.43288031e-01f, 1.72662258e-01f, 1.33014694e-01f, 4.68708128e-02f,
  1.82173789e-01f, 1.16972819e-01f, 1.74474150e-01f, -6.07297421e-02f, 1.80765212e-01f, -9.56227705e-02f, -5.89828491e-02f, -6.79355562e-02f, 2.74424791e-01f, -1.55909872e-02f,
  2.14913376e-02f, 1.82230115e-01f, 1.76291928e-01f, -3.13311934e-01f, 4.40890014e-01f, 2.31414929e-01f, -2.41786286e-01f, -5.85432239e-02f, -4.93849628e-02f, -9.37111005e-02f,
  -1.47934780e-01f, 1.58079132e-01f, 7.06624314e-02f, 2.72658557e-01f, 3.12122405e-01f, 1.21122241e-01f, 4.72160392e-02f, -1.97480861e-02f, 1.76641613e-01f, 6.04476221e-02f,
  1.41727999e-01f, 4.24658917e-02f, -8.82028788e-02f, -1.06810248e-02f, 5.49110249e-02f, -1.30131738e-02f, -1.12854764e-01f, 6.19908236e-02f, -1.98480606e-01f, -1.10114522e-01f,
  1.03634737e-01f, -1.91362306e-01f, -1.02471121e-01f, -1.94114298e-01f, -8.59433785e-02f, 2.21836753e-02f, -5.96611239e-02f, -1.14072718e-01f, 1.71880469e-01f, -3.98467630e-02f,
  9.58079174e-02f, 1.48453370e-01f, -9.92889181e-02f, 1.84926093e-01f, 9.83739570e-02f, 4.47158068e-02f, 1.31970629e-01f, -8.02252293e-02f, 3.48402979e-03f, 2.30803385e-01f,
  9.07549858e-02f, 1.58840641e-01f, -8.68106559e-02f, 5.29777370e-02f, 4.11603972e-02f, 8.49195495e-02f, 1.87350139e-01f, 2.03366697e-01f, 1.35619462e-01f, 3.51412036e-02f,
  3.49800438e-02f, -2.64792377e-03f, 1.27857819e-01f, -7.27999955e-02f, 5.26117273e-02f, 6.69659600e-02f, 8.18281993e-02f, -5.20441271e-02f, 3.18264365e-01f, -1.55540764e-01f,
  -2.52818078e-01f, -3.30069326e-02f, -3.86298656e-01f, -1.48706079e-01f, -2.76084006e-01f, -6.05146438e-02f, -1.31902784e-01f, -1.71678752e-01f, 3.36252332e-01f, -4.17674854e-02f,
  7.91369453e-02f, 2.58291483e-01f, 1.82013080e-01f, 1.81802198e-01f, 2.62992848e-02f, 1.74271241e-01f, 1.04435280e-01f, 8.52914825e-02f, -3.53175378e-03f, 1.18727505e-01f,
  1.92505777e-01f, -2.53547847e-01f, -1.29604876e-01f, -2.39817917e-01f, -1.30016401e-01f, -1.38962567e-02f, 7.93503225e-02f, -1.41132161e-01f, 1.02571726e-01f, -3.25915307e-01f,
  -2.45436624e-01f, -1.75854981e-01f, 2.57760495e-01f, 9.58079919e-02f, 6.40495867e-02f, 1.82330906e-01f, 6.40237555e-02f, 6.29625767e-02f, -1.14366010e-01f, 1.36344388e-01f,
  -5.25024086e-02f, 7.45682931e-03f, -1.48681775e-01f, -4.50931340e-02f, -5.14694750e-02f, 1.56866983e-01f, -1.74119756e-01f, 1.06136210e-01f, -1.88353971e-01f, 6.74106851e-02f,
  -1.61961839e-01f, -1.60668120e-01f, -9.21527743e-02f, -1.68997586e-01f, 3.40288989e-02f, 1.01896510e-01f, 2.85340585e-02f, 4.93122861e-02f, 3.64327803e-02f, -1.61680788e-01f,
  8.24959651e-02f, -1.34913698e-01f, -2.16764674e-01f, 8.17035958e-02f, 7.01200143e-02f, 2.30385642e-02f, -9.51614231e-02f, -2.94950064e-02f, 1.15730889e-01f, -1.13465562e-01f,
  -3.65492254e-01f, 1.13290958e-01f, -4.78135459e-02f, 2.23536238e-01f, 2.34991163e-02f, 1.26949221e-01f, -1.86592117e-01f, 2.25797489e-01f, -7.57924691e-02f, 4.57765795e-02f,
  -3.69717717e-01f, 7.23602325e-02f, 8.47432613e-02f, -1.47791386e-01f, 1.76518530e-01f, -5.84807955e-02f, -4.80320543e-01f, -4.33638990e-02f, 1.92744061e-01f, 7.54881129e-02f,
  2.65837103e-01f, 1.20787852e-01f, 3.66332352e-01f, 1.27858698e-01f, -4.36893739e-02f, 2.62535840e-01f, -7.09565729e-02f, -1.74224213e-01f, 1.19896479e-01f, -2.99971346e-02f,
  2.11066738e-01f, 1.02538884e-01f, -1.69233441e-01f, -5.12190536e-02f, 2.04672366e-01f, 7.21555799e-02f, -9.58239138e-02f, -1.81362480e-01f, 2.71052159e-02f, 1.49455845e-01f,
  1.06304802e-01f, -1.10717982e-01f, 1.87836066e-01f, -1.22527063e-01f, -1.97217539e-02f, -1.59372985e-01f, 2.67127180e-03f, 1.89421177e-01f, -1.14113092e-01f, -4.09537822e-01f,
  -2.23701268e-01f, 2.58215755e-01f, -6.97208494e-02f, 2.91723143e-02f, -1.44949898e-01f, -2.51283348e-02f, -1.42996058e-01f, -2.50029042e-02f, 4.44809794e-02f, -3.03534091e-01f,
  9.05470625e-02f, 4.43871729e-02f, -5.57216592e-02f, 6.82579502e-02f, -1.36055961e-01f, 2.71068364e-01f, 9.51071382e-02f, -9.53667462e-02f, 1.31840631e-01f, -1.19377198e-02f,
  2.15449378e-01f, 8.32517911e-03f, 8.88851508e-02f, -2.71650076e-01f, 2.37259194e-02f, -3.79293710e-02f, 2.58254558e-01f, -7.28712557e-03f, -6.10526428e-02f, 2.57479399e-01f,
  3.49514335e-01f, 1.12504788e-01f, 1.30150169e-01f, -1.47754058e-01f, 7.15883821e-03f, 2.88434383e-02f, -5.75359687e-02f, 2.89168745e-01f, 3.95196497e-01f, -6.34347796e-02f,
  1.12453237e-01f, 1.62834957e-01f, -9.94334072e-02f, -1.02843372e-02f, 3.49228457e-02f, 4.87111807e-02f, 3.81562747e-02f, -3.32513154e-02f, 8.71596932e-02f, 6.05633967e-02f,
  -5.34940884e-02f, 9.84964892e-03f, 6.46821335e-02f, 9.53268334e-02f, 3.89633179e-02f, 8.88494328e-02f, 1.57870904e-01f, -3.26046022e-03f, 1.12378120e-01f, -1.29815206e-01f,
  -1.06131636e-01f, 1.86419964e-01f, 9.67928395e-02f, -4.44458514e-01f, -1.97452810e-02f, 2.01602653e-01f, 1.05317004e-01f, -6.06203638e-02f, 1.24053352e-01f, -9.17697400e-02f,
  2.93014036e-03f, -1.82533726e-01f, 5.77088520e-02f, -3.50013822e-01f, -1.25800878e-01f, 3.59437019e-01f, -5.96615896e-02f, -3.80376652e-02f, 5.37090050e-03f, -2.33678102e-01f,
  3.27531487e-01f, -4.91529666e-02f, 2.71695584e-01f, -1.66782573e-01f, 1.27319992e-01f, -4.73589599e-02f, 5.17682843e-02f, -1.59447014e-01f, -4.72447611e-02f, -1.35560572e-01f,
  3.03319842e-02f, 9.15692225e-02f, 6.26579225e-02f, 1.83284298e-01f, 1.19495906e-01f, -1.96309611e-01f, 6.57685101e-02f, 5.83103672e-02f, 1.15612350e-01f, -2.09199384e-01f,
  -1.49373665e-01f, -6.05974272e-02f, 3.65386188e-01f, 4.50763106e-02f, 9.22500193e-02f, 7.96287730e-02f, 2.14093819e-01f, 1.93576906e-02f, -2.55081713e-01f, -6.73656464e-02f,
  -1.60011768e-01f, 1.20665813e-02f, 1.01781204e-01f, 8.01852271e-02f, -4.95979935e-02f, 1.71067372e-01f, 3.85229029e-02f, 1.24447934e-01f, 2.64429092e-01f, 2.06269905e-01f,
  1.83179200e-01f, -1.31906822e-01f, -7.18985265e-03f, -1.94989324e-01f, 2.20696926e-01f, 4.43992317e-02f, -1.19668685e-01f, 2.16737692e-03f, 4.84685600e-02f, 2.97914803e-01f,
  -2.64213812e-02f, 2.91703910e-01f, -1.10797063e-01f, -6.76245615e-02f, 3.68070275e-01f, 1.99928209e-01f, 1.11059718e-01f, 2.60599945e-02f, 7.03879148e-02f, 9.96231958e-02f,
  -1.22471623e-01f, 1.52706593e-01f, -1.54731706e-01f, 2.98806041e-01f, 9.40955132e-02f, 4.30843495e-02f, 3.93878520e-02f, -1.28757477e-01f, 1.31310463e-01f, -5.05293123e-02f,
  2.46102251e-02f, -2.81836074e-02f, 2.24237457e-01f, -1.74776122e-01f, 3.63996595e-01f, -8.86124596e-02f, -9.79591906e-02f, 3.29211652e-01f, 1.11057527e-01f, 1.97082624e-01f,
  -7.47304633e-02f, -9.98206958e-02f, -6.10880204e-04f, 2.37904731e-02f, 1.17335968e-01f, -1.23235352e-01f, -2.23447591e-01f, -1.82919040e-01f, 4.44325283e-02f, 2.60074764e-01f,
  -1.30127370e-01f, 1.13627829e-01f, 1.55131683e-01f, 8.35177451e-02f, -9.13873017e-02f, 1.16520077e-02f, -6.31361604e-02f, 3.34533043e-02f, 2.48653889e-02f, 8.96122158e-02f,
  7.58274496e-02f, 1.38222083e-01f, 1.55591756e-01f, 2.18902066e-01f, 1.30221635e-01f, 8.32563341e-02f, 1.99137226e-01f, 1.69353962e-01f, -9.96601880e-02f, 2.33782008e-01f,
  1.05625346e-01f, 4.36065271e-02f, -7.26601332e-02f, 1.56972930e-01f, 2.29920924e-01f, 1.55363068e-01f, 2.37960517e-01f, 2.44781390e-01f, -2.37474382e-01f, -3.17203134e-01f,
  -1.12911962e-01f, -2.68177688e-01f, 2.17257589e-01f, -1.42326122e-02f, -2.25326605e-02f, 2.24697310e-03f, 1.17337368e-01f, -1.19346812e-01f, -5.52453054e-03f, 6.50500283e-02f,
  1.21245392e-01f, -2.74791777e-01f, 2.12684408e-01f, 3.85128008e-03f, 1.44517720e-01f, 2.67687961e-02f, -1.18366279e-01f, 3.48481419e-03f, 9.58001241e-02f, 1.88012362e-01f,
  2.18116567e-02f, 2.43837819e-01f, 4.31730062e-01f, -1.48683056e-01f, 9.35253650e-02f, -3.96281332e-02f, -1.22402132e-01f, -3.79948795e-01f, -2.06285372e-01f, 3.04457992e-01f,
  3.85360897e-01f, 7.33791739e-02f, 1.39328793e-01f, 8.20108280e-02f, 2.89058506e-01f, -2.67121613e-01f, -3.76318470e-02f, 1.31113768e-01f, 1.09163746e-01f, 3.73089425e-02f,
  -9.43343714e-02f, 2.30688408e-01f, 1.02385901e-01f, 8.24811384e-02f, 1.55646550e-02f, 2.39191771e-01f, -9.53777805e-02f, 7.79911503e-03f, -1.60889387e-01f, -5.69341779e-02f,
  -3.78386192e-02f, -1.74819753e-02f, 1.76765040e-01f, -7.47254938e-02f, 1.11271873e-01f, 3.08166802e-01f, 2.23954439e-01f, -2.32821941e-01f, 1.84809819e-01f, -1.29653826e-01f,
  -2.19402283e-01f, 8.56941268e-02f, -2.43428066e-01f, 2.65929073e-01f, 4.42931280e-02f, 3.45967919e-01f, -2.00302213e-01f, 2.59381090e-03f, 1.31650850e-01f, -1.68933929e-03f,
  7.19994307e-02f, 6.36416078e-02f, -3.90341692e-02f, -4.87660840e-02f, 9.82771590e-02f, 1.37971714e-01f, 9.97737199e-02f, -5.31214736e-02f, -7.64516294e-02f, -5.12135588e-02f,
  -3.82787734e-01f, 1.10978149e-01f, 2.00636938e-01f, -2.55113214e-01f, 8.12036097e-02f, 1.03418157e-01f, -5.32239974e-01f, -3.56168523e-02f, 2.12169681e-02f, -5.76527081e-02f,
  1.32867292e-01f, 1.09931432e-01f, 2.63538152e-01f, 1.07054569e-01f, -2.88390011e-01f, 1.42595276e-01f, -1.55200541e-01f, -1.16880290e-01f, 1.19284734e-01f, 3.13724764e-02f,
  2.51274198e-01f, 1.60249278e-01f, 9.14767087e-02f, 1.83403552e-01f, -9.22078453e-03f, 7.11298510e-02f, -8.87020603e-02f, 3.37886326e-02f, 8.43567327e-02f, -4.90923822e-02f,
  1.69166192e-01f, 2.09122241e-01f, 2.74057388e-01f, 2.35121712e-01f, 6.79420084e-02f, 1.50061503e-01f, 1.24728650e-01f, 4.57830131e-02f, 4.61540520e-02f, 3.79635468e-02f,
  1.81252599e-01f, 2.11751267e-01f, 1.96404010e-01f, -6.00131452e-02f, 4.51137394e-01f, 1.41643673e-01f, -2.10609548e-02f, -2.82263339e-01f, -1.80585951e-01f, -1.25523940e-01f,
  2.31057063e-01f, 5.91234341e-02f, 6.78220168e-02f, -1.03076622e-01f, -7.20595419e-02f, -3.60130340e-01f, -4.98945042e-02f, 3.27382594e-01f, -6.48438185e-02f, 6.03956692e-02f,
  1.96409374e-01f, 2.03100577e-01f, 6.34592921e-02f, 1.54921547e-01f, 1.46068502e-02f, 2.38878191e-01f, 3.12105380e-02f, 2.93131143e-01f, -5.10602258e-02f, 4.81292643e-02f,
  -6.04941733e-02f, 4.14603464e-02f, 1.90521598e-01f, -1.33065149e-01f, -5.86987473e-02f, -2.47538820e-01f, 6.42880350e-02f, 3.32862616e-01f, -6.54395372e-02f, 3.00630480e-02f,
  -6.10416755e-02f, -1.07413016e-01f, 4.44690794e-01f, 8.38922039e-02f, -1.03051588e-01f, 7.58579522e-02f, 2.89450318e-01f, 1.89233586e-01f, 2.19872475e-01f, 1.38776004e-01f,
  5.18076539e-01f, 5.95497154e-02f, 2.80680776e-01f, 2.65361875e-01f, 2.19110206e-01f, -1.21313415e-01f, -3.76922637e-02f, 3.85300368e-02f, 5.62483221e-02f, 2.20814332e-01f,
  1.41848192e-01f, 3.81118566e-01f, 3.36845666e-02f, 3.66744787e-01f, 8.46030712e-02f, -4.28501964e-01f, 1.75926894e-01f, 4.69184779e-02f, -2.58494258e-01f, 2.93456316e-01f,
  -2.05910653e-02f, -2.13610521e-03f, -2.05600500e-01f, 4.20127928e-01f, -1.12668656e-01f, -2.47144178e-01f, -4.81080897e-02f, -1.47948369e-01f, 2.23740846e-01f, -1.33972764e-01f,
  -3.94642726e-02f, -2.32014328e-01f, 1.39035895e-01f, 1.72588557e-01f, 9.56699625e-02f, 2.12598026e-01f, -1.83697402e-01f, 5.97390607e-02f, 4.52162996e-02f, -2.09801998e-02f,
  -1.04106531e-01f, -8.16733092e-02f, 1.51792273e-01f, -1.97523519e-01f, 3.59363742e-02f, -1.40832409e-01f, -1.13652930e-01f, 1.80245131e-01f, 3.86195071e-02f, -3.18387657e-01f,
  9.47680846e-02f, -6.81432560e-02f, -2.39239648e-01f, -5.08853681e-02f, -1.04394287e-01f, 6.33562729e-02f, -7.94006586e-02f, 7.21744373e-02f, 8.31549540e-02f, -1.02739632e-01f,
  2.13594615e-01f, 3.85332741e-02f, -2.55678535e-01f, 1.29808029e-02f, -3.43771994e-01f, -5.20680659e-02f, 1.89638138e-01f, 1.00677639e-01f, -7.25227296e-02f, 1.72864154e-01f,
  -1.14281416e-01f, -2.26624474e-01f, 7.21023791e-03f, -2.65324980e-01f, -4.49757129e-02f, -2.64146179e-01f, 6.59375116e-02f, 9.26231220e-02f, 1.21227488e-01f, -9.76137258e-03f,
  5.28726541e-02f, -1.83109701e-01f, -9.70751047e-02f, -6.48220181e-02f, -1.39133722e-01f, 8.61480907e-02f, 1.02363721e-01f, -7.34192599e-03f, 2.02178448e-01f, 6.60206303e-02f,
  2.74047881e-01f, -1.65044010e-01f, -3.80656719e-01f, 1.49838045e-01f, 9.29766893e-03f, 2.76559383e-01f, -3.79011221e-02f, -5.96768335e-02f, 4.61736694e-02f, 5.98470755e-02f,
  -2.66979374e-02f, -9.02366936e-02f, -3.04373324e-01f, 1.27675578e-01f, 2.06391215e-01f, -1.97288975e-01f, 1.36822313e-01f, 2.80716896e-01f, -3.62240165e-01f, 5.63318171e-02f,
  3.48976642e-01f, -3.70783769e-02f, 2.17436552e-01f, 1.29402980e-01f, 1.57185003e-01f, 2.88957983e-01f, 1.52003497e-01f, 2.42870167e-01f, -2.13530079e-01f, -1.80817023e-01f,
  6.32943064e-02f, -1.01024114e-01f, 1.82344735e-01f, 1.28567979e-01f, -1.66960910e-01f, -2.46226732e-02f, -1.34131938e-01f, -2.39951685e-02f, 4.65047956e-02f, 1.06959552e-01f,
  9.66032296e-02f, 2.46371165e-01f, 5.74550889e-02f, -1.91942155e-01f, -8.89487714e-02f, -1.96887940e-01f, 2.05110073e-01f, 4.65113372e-02f, 9.26245656e-03f, 1.90244496e-01f,
  -3.46079245e-02f, -1.21227607e-01f, -9.29370821e-02f, 8.70647803e-02f, 7.50376880e-02f, 3.76039371e-02f, -1.22412644e-01f, 1.91559434e-01f, 6.12048283e-02f, -3.35075706e-02f,
  6.31724373e-02f, 1.88691139e-01f, -2.08653197e-01f, 1.15015022e-01f, -8.36840868e-02f, -2.95941770e-01f, -4.14534844e-02f, -1.12289540e-01f, 4.31340560e-02f, 9.66795385e-02f,
  1.29457667e-01f, 9.92170200e-02f, 3.45550507e-01f, -8.03183764e-02f, 5.70450947e-02f, -4.03822333e-01f, -4.72685732e-02f, -2.82958560e-02f, 6.78100809e-02f, 5.13689183e-02f,
  2.31046215e-01f, 3.80582392e-01f, 4.00469035e-01f, -9.51181340e-04f, 6.48873895e-02f, -2.79419929e-01f, 1.95367992e-01f, -2.09074244e-01f, 8.32118168e-02f, -1.01237006e-01f,
  -3.56707960e-01f, -6.91397786e-02f, 2.66936962e-02f, 1.45594761e-01f, 2.82202184e-01f, 5.77938103e-04f, 1.14641093e-01f, -4.31082360e-02f, -9.33399983e-03f, -1.44169405e-01f,
  1.35356426e-01f, -9.94082913e-02f, 1.10454135e-01f, 3.55467558e-01f, 1.00522853e-01f, -6.93615945e-03f, -2.55418897e-01f, -4.99642976e-02f, -1.54015496e-01f, 1.18250713e-01f,
  -2.54320148e-02f, 2.08700269e-01f, -1.78834856e-01f, -1.40017435e-01f, 1.36300236e-01f, 1.21971279e-01f, 6.40909746e-02f, -2.84555376e-01f, 1.83485061e-01f, 1.24398157e-01f,
  -3.49952012e-01f, 6.83875335e-03f, -4.33910862e-02f, -5.36113940e-02f, -4.31916490e-02f, 1.47333995e-01f, -5.31466961e-01f, -2.21355408e-01f, -2.04711869e-01f, 3.72738689e-02f,
  1.26292944e-01f, -8.68508741e-02f, 7.41138160e-02f, -2.87049681e-01f, 2.13475153e-02f, 6.51778653e-02f, -1.22548575e-02f, -1.25447869e-01f, 5.36467060e-02f, -5.54314703e-02f,
  6.80793375e-02f, -2.41236508e-01f, -2.44981676e-01f, -4.32919376e-02f, 3.20016026e-01f, 5.62386177e-02f, -3.02514601e-02f, -1.09409906e-01f, -3.61688346e-01f, 8.87084976e-02f,
  1.54072732e-01f, 1.91718966e-01f, 1.74644575e-01f, -3.59169722e-01f, -9.61315259e-02f, 1.28668875e-01f, -7.03546852e-02f, 1.21534698e-01f, -3.90948027e-01f, 2.10930198e-01f,
  1.62592486e-01f, -1.98303536e-01f, -1.66644037e-01f, -4.55571935e-02f, 1.73721671e-01f, -9.12350486e-04f, 8.42930153e-02f, 4.00297493e-02f, -9.76051111e-03f, 2.81780779e-01f,
  -1.84631702e-02f, -8.63321275e-02f, 4.34224121e-02f, 1.54436812e-01f, 5.34012467e-02f, 1.03133898e-02f, -3.22870240e-02f, 2.72453241e-02f, 2.08676718e-02f, -3.97444442e-02f,
  9.20354202e-02f, 2.96356939e-02f, 5.71970195e-02f, 8.14209357e-02f, -3.29740018e-01f, -1.93580046e-01f, 2.40713179e-01f, 1.41625181e-01f, 1.98128045e-01f, -5.09192906e-02f,
  -2.13751718e-01f, -1.91111952e-01f, 6.63368497e-03f, 2.92310119e-01f, 2.30448455e-01f, 5.24225950e-01f, 1.54239446e-01f, -2.49408722e-01f, 1.04622200e-01f, -2.59175003e-01f,
  4.94863987e-02f, -7.28990436e-02f, -1.19090922e-01f, -1.53105557e-01f, -1.03129353e-02f, -1.22736178e-01f, 3.12428683e-01f, -2.37253740e-01f, 5.82192428e-02f, 1.75108954e-01f,
  1.98714703e-01f, -5.46054430e-02f, -1.06588587e-01f, -1.74724326e-01f, 1.54059380e-01f, -1.11180969e-01f, 9.40328166e-02f, 3.28868162e-03f, 4.40770835e-02f, -3.65594774e-02f,
  1.95463777e-01f, 2.66042024e-01f, -1.21327281e-01f, -9.37963575e-02f, 1.12288095e-01f, 1.29416153e-01f, -7.64607936e-02f, 2.38068588e-02f, 1.63081706e-01f, 8.26905742e-02f,
  -5.97922802e-02f, 7.03218766e-03f, 1.25269080e-02f, 3.70472483e-02f, 2.78946072e-01f, 1.10968508e-01f, -1.11723080e-01f, -7.39542991e-02f, 1.37662187e-01f, 1.35992409e-03f,
  8.86797011e-02f, -1.43418849e-01f, 9.50274169e-02f, -8.35991651e-02f, 1.80351183e-01f, 1.33375078e-01f, 1.38531312e-01f, 5.69724180e-02f, 1.25998408e-01f, -2.23116755e-01f,
  3.42427850e-01f, 2.68916879e-02f, -1.95812248e-02f, -6.06901646e-02f, 4.99858409e-02f, 7.68885985e-02f, -5.22997864e-02f, 1.49702519e-01f, -1.25075892e-01f, 6.46722168e-02f,
  1.42260054e-02f, 1.69839785e-01f, 2.56273538e-01f, 1.45052105e-01f, 1.54949650e-01f, 6.71900213e-02f, 2.27756768e-01f, 7.31610227e-03f, 1.72717884e-01f, 1.11369409e-01f,
  3.23391408e-01f, 2.47913569e-01f, -1.56052202e-01f, 1.24726869e-01f, 1.38660565e-01f, 1.28064498e-01f, 1.64948008e-03f, -1.09752953e-01f, -1.37690395e-01f, -1.56336427e-02f,
  1.91958994e-01f, -6.49976656e-02f, -3.57749790e-01f, -4.24473941e-01f, 5.77040128e-02f, -1.03572652e-01f, 2.11995333e-01f, -5.36617413e-02f, -1.73045084e-01f, 6.99887890e-03f,
  4.63734902e-02f, -6.15853928e-02f, 3.47843617e-02f, 9.22987014e-02f, -1.58325300e-01f, 2.48183031e-02f, -1.04402184e-01f, 6.26128763e-02f, -2.21903875e-01f, -1.02128629e-02f,
  -2.75779188e-01f, -1.89859420e-01f, 7.87742212e-02f, -2.34368712e-01f, -1.95588648e-01f, 8.00564811e-02f, -1.10259384e-01f, 3.52021545e-01f, 1.55019360e-02f, -2.17622921e-01f,
  -1.06441692e-01f, -2.00255305e-01f, -2.19726861e-02f, 8.52559283e-02f, 1.16811968e-01f, 2.65615493e-01f, 1.89388748e-02f, 5.10654859e-02f, 5.18343411e-03f, 1.38080135e-01f,
  -5.50378710e-02f, 1.77944303e-02f, -9.66160372e-02f, -4.03929241e-02f, -2.71197781e-02f, 1.33926451e-01f, -6.20468147e-02f, -5.96928224e-02f, -7.66648129e-02f, 2.12608472e-01f,
  1.95070982e-01f, 1.56749070e-01f, 1.12409443e-01f, 1.01851352e-01f, -1.29801538e-02f, 3.10888179e-02f, 8.64516944e-02f, -8.82729068e-02f, -3.30979228e-01f, 3.22611034e-01f,
  2.07696959e-01f, 1.98384151e-01f, -8.44790265e-02f, 2.48693570e-01f, 2.52770782e-01f, 2.08354555e-02f, -8.46927240e-02f, 5.70894964e-02f, -3.08587819e-01f, -2.71091521e-01f,
  5.50096668e-02f, -3.06219980e-02f, 2.50474759e-03f, 2.85435915e-01f
};

// L2_fan_Bp_bar (Shape: 1 x 26)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 26;
const float L2_fan_Bp_bar_data[] = {
  6.58963472e-02f, -1.76516827e-02f, 4.47532535e-02f, 1.83790386e-01f, -7.37073123e-02f, 7.24624144e-03f, 2.01563418e-01f, -4.17348035e-02f, 7.00264871e-02f, -1.57516766e-02f,
  1.77556217e-01f, 4.47315648e-02f, 6.23879917e-02f, 7.73844123e-02f, 2.99734771e-02f, 1.14593782e-01f, -5.31683490e-02f, 8.81076902e-02f, -1.14857899e-02f, 1.24247156e-01f,
  -5.88319264e-02f, 1.94373637e-01f, 7.93448929e-03f, 1.34705231e-01f, -5.44163911e-03f, 2.76055187e-02f
};

// L3_fan_Wp (Shape: 19 x 64)
const int L3_fan_Wp_rows = 19;
const int L3_fan_Wp_cols = 64;
const float L3_fan_Wp_data[] = {
  -1.19828463e-01f, -8.33905935e-02f, 6.58602342e-02f, 1.35235451e-02f, -3.13173197e-02f, -1.20810404e-01f, 1.80890024e-01f, 1.06633626e-01f, -2.14485660e-01f, 6.22392930e-02f,
  -2.15688795e-02f, 5.34024425e-02f, -2.42525525e-02f, 9.67206713e-03f, -3.12208082e-03f, 7.43873194e-02f, -1.15328528e-01f, 7.23254401e-03f, -2.23801993e-02f, -9.03971493e-03f,
  -1.81941554e-01f, 3.67728710e-01f, -5.63215353e-02f, 4.15157005e-02f, -1.39915168e-01f, -5.89002669e-02f, 6.90769032e-02f, 1.26587525e-01f, -5.02086222e-01f, 4.40575629e-02f,
  -5.99619821e-02f, 4.03257459e-03f, 3.16074342e-02f, -3.75762247e-02f, -9.16659757e-02f, 1.69062130e-02f, -1.42576963e-01f, 7.37787690e-03f, -1.44571468e-01f, -5.90570942e-02f,
  -2.30582535e-01f, 2.34564647e-01f, 1.58866793e-01f, -6.62422553e-02f, 1.79188803e-01f, -1.13254022e-02f, 6.07770681e-03f, 3.54217887e-02f, -1.60637587e-01f, -2.62976643e-02f,
  4.23265100e-02f, 1.19597897e-01f, 3.80259752e-02f, -1.31360099e-01f, -8.54128301e-02f, -5.20575903e-02f, -1.12514056e-01f, 1.42527297e-01f, -1.15485534e-01f, -1.73277438e-01f,
  2.09211141e-01f, -6.99925348e-02f, 6.42899200e-02f, 1.67249128e-01f, 3.16534370e-01f, 7.01001883e-02f, 2.65779160e-02f, 4.20822680e-01f, 1.17506795e-01f, 3.11459094e-01f,
  3.21933001e-01f, 5.51204272e-02f, 1.69442102e-01f, -1.89213939e-02f, -7.52218217e-02f, 2.24234596e-01f, 3.42478938e-02f, 1.23831749e-01f, 1.68268770e-01f, 4.66216505e-02f,
  -5.35711907e-02f, 6.77944720e-02f, 1.81357935e-01f, 1.05092444e-01f, -2.13413924e-01f, 1.52666077e-01f, 2.13319510e-02f, 1.06974393e-02f, 3.16671371e-01f, -2.56992131e-01f,
  -3.88375483e-02f, 1.78135991e-01f, -5.07102013e-02f, -4.27671522e-02f, -1.51643246e-01f, 2.81625683e-03f, -1.27540812e-01f, -5.20179160e-02f, -9.43470523e-02f, -3.13340724e-01f,
  -2.81505764e-01f, 1.78838953e-01f, 1.21264912e-01f, 2.47707330e-02f, -1.32661447e-01f, 2.83083022e-01f, 1.12062640e-01f, 6.06922619e-03f, 3.72898728e-02f, 9.83416475e-03f,
  8.38926062e-02f, 1.56797413e-02f, -4.01984574e-03f, 1.61657006e-01f, 3.34760942e-03f, -4.80790809e-02f, -6.13381295e-03f, -1.01489596e-01f, -1.36991814e-01f, 3.16605568e-02f,
  2.01211005e-01f, 2.21356958e-01f, -5.42966370e-03f, -1.51291907e-01f, -9.50305834e-02f, -2.08536386e-02f, 6.83284700e-02f, -2.43037865e-01f, -2.89148122e-01f, -2.75798976e-01f,
  -7.26792663e-02f, -2.49793470e-01f, -3.33408654e-01f, -2.53732830e-01f, 4.18510847e-02f, 9.92428586e-02f, -1.14368685e-02f, 2.20504671e-01f, -3.36271562e-02f, 4.63976264e-02f,
  -1.27705524e-03f, -1.33649677e-01f, -1.22970100e-02f, -8.67854953e-02f, -1.83922201e-02f, 2.29389027e-01f, -1.75131574e-01f, 1.12355486e-01f, -7.85143599e-02f, 1.27398774e-01f,
  1.51465148e-01f, 3.51272821e-02f, -3.11677843e-01f, 1.26565635e-01f, 4.16113958e-02f, 4.18745875e-02f, -1.42386049e-01f, 1.55884400e-01f, 6.90047145e-02f, -1.03280909e-01f,
  1.96488705e-02f, 4.69442457e-02f, -6.09382847e-03f, 2.69782275e-01f, -4.56299372e-02f, 5.79089448e-02f, 3.11749037e-02f, 6.55174553e-02f, -1.92470327e-02f, 8.37211385e-02f,
  2.15763673e-01f, 2.77025905e-02f, 6.68884218e-02f, 1.06897973e-01f, 2.10813448e-01f, -1.52501166e-01f, -3.12254895e-02f, -1.00024492e-01f, 1.02390975e-01f, 7.11326348e-03f,
  5.93650937e-02f, 3.29099665e-03f, 1.60844065e-02f, -2.23179255e-02f, -3.97539809e-02f, -1.71001539e-01f, 1.81360185e-01f, -3.03359002e-01f, 1.32256165e-01f, -9.63486508e-02f,
  -3.59302238e-02f, -8.88940990e-02f, -4.48338054e-02f, 6.48243502e-02f, 1.94855910e-02f, 9.93862562e-03f, -1.23423571e-02f, -1.76674113e-01f, 5.19093536e-02f, -4.27075885e-02f,
  8.23494643e-02f, -2.35439390e-01f, -1.67757958e-01f, -9.05483216e-02f, -2.40471452e-01f, -6.22072481e-02f, -1.41075581e-01f, 3.29085961e-02f, 1.79210842e-01f, -1.42436370e-01f,
  -9.52944085e-02f, 5.73301036e-03f, 1.69800565e-01f, -3.76324266e-01f, 6.70670345e-02f, -8.54178816e-02f, -1.00209878e-03f, -1.50287867e-01f, -4.96116042e-01f, -1.64897442e-01f,
  7.02406913e-02f, -2.82889903e-02f, 3.25353563e-01f, -1.67245433e-01f, -2.61880066e-02f, -8.11389610e-02f, 1.67527720e-01f, -6.15927614e-02f, 1.78713381e-01f, -2.19330072e-01f,
  -2.80937195e-01f, 1.64373919e-01f, 6.67863116e-02f, 1.05575258e-02f, -1.99210960e-02f, 2.24837631e-01f, 3.96083370e-02f, -9.48377699e-02f, -2.46360794e-01f, -1.99824885e-01f,
  -1.75212026e-01f, -2.56911684e-02f, -1.96479648e-01f, 1.17071919e-01f, -1.18881591e-01f, 1.28578290e-01f, 5.00973649e-02f, -1.07180804e-01f, 3.99436392e-02f, -1.88398976e-02f,
  4.52775732e-02f, 8.39265063e-02f, 1.15496628e-01f, -2.18450978e-01f, -1.91218462e-02f, -5.13867550e-02f, 1.22830682e-01f, 1.14085898e-02f, 7.34971464e-02f, -6.92183673e-02f,
  -1.58955544e-01f, -1.14243947e-01f, 7.06989914e-02f, -5.85539974e-02f, -5.54992408e-02f, 3.95670235e-01f, 1.29828649e-02f, 1.30617902e-01f, 6.22372478e-02f, 7.35325888e-02f,
  -2.46929079e-01f, -1.73695087e-01f, -8.69508758e-02f, -1.12258121e-01f, -8.93387794e-02f, -7.86733776e-02f, -6.75989762e-02f, 2.87493002e-02f, -1.72898531e-01f, 3.52927148e-02f,
  4.13613720e-03f, 1.54112563e-01f, -5.21582142e-02f, 1.10530116e-01f, 1.21391937e-01f, -1.73841894e-01f, -1.63126260e-01f, 3.96463610e-02f, 9.67621431e-02f, -5.96626513e-02f,
  1.66280597e-01f, 4.88443822e-02f, -1.40302092e-01f, -2.10060209e-01f, 1.91687733e-01f, 5.12878485e-02f, 1.68227330e-01f, -1.79403052e-01f, -2.72174746e-01f, -7.79730082e-02f,
  2.09414005e-01f, -3.53969745e-02f, -2.01068178e-01f, 1.79030299e-01f, 3.08389273e-02f, 1.14375027e-02f, -6.43581226e-02f, 8.58555064e-02f, -7.45245516e-02f, 9.82034877e-02f,
  -8.56136605e-02f, -4.94496450e-02f, -5.60361519e-02f, -1.54272527e-01f, -4.59299907e-02f, 1.02498382e-01f, -1.04544789e-01f, 6.60299212e-02f, 2.09235534e-01f, 1.03579268e-01f,
  7.65520185e-02f, 7.54711544e-03f, 8.38361681e-02f, 2.24934265e-01f, 2.40984216e-01f, 1.70332074e-01f, 2.18355190e-02f, 8.83484185e-02f, 1.95531890e-01f, 1.95196979e-02f,
  1.34178922e-01f, -2.54545379e-02f, -4.51330766e-02f, 4.88604372e-03f, 2.30336547e-01f, -3.73033360e-02f, 9.87699553e-02f, 1.47896437e-02f, 2.23573416e-01f, -1.67865828e-01f,
  -8.64929631e-02f, 7.25838989e-02f, -1.30917802e-01f, -1.48231342e-01f, 1.96995616e-01f, -8.27850029e-02f, 1.32855222e-01f, 3.64356823e-02f, 4.44097742e-02f, 2.72853673e-01f,
  8.60213414e-02f, 9.57772061e-02f, -3.43406014e-02f, 3.71164270e-02f, -8.05718973e-02f, -5.80157414e-02f, -1.21968038e-01f, 1.92323521e-01f, -1.05917662e-01f, 6.00772649e-02f,
  -2.90523320e-02f, 1.05329230e-01f, -2.06137866e-01f, -6.59832656e-02f, -1.49334043e-01f, -9.43413824e-02f, 7.26482198e-02f, -1.82687007e-02f, -4.67250384e-02f, -1.34203315e-01f,
  -1.00435920e-01f, -1.01054922e-01f, -2.78213900e-02f, 6.75542951e-02f, -6.16647452e-02f, 1.81197882e-01f, 8.75714198e-02f, 3.18503082e-01f, -2.36092210e-02f, -1.08242467e-01f,
  1.35391708e-02f, 4.64286879e-02f, 1.18113756e-01f, 1.85159191e-01f, -1.54486224e-01f, -3.22967768e-02f, 1.40541539e-01f, -1.53280601e-01f, -2.16924936e-01f, -9.44950730e-02f,
  9.55161229e-02f, -5.03470227e-02f, 2.29489710e-02f, -4.59900014e-02f, 9.79227498e-02f, -1.24673702e-01f, -9.09320340e-02f, -9.44073126e-02f, 6.58404231e-02f, 1.32570565e-01f,
  2.92367190e-01f, 9.05054361e-02f, 1.31622171e-02f, -7.59549960e-02f, 8.59251842e-02f, -7.16327280e-02f, -3.16050611e-02f, 2.30547220e-01f, -2.01431558e-01f, 1.98045760e-01f,
  -5.16244955e-02f, -3.51721570e-02f, 7.13192225e-02f, 1.21525586e-01f, -1.04129195e-01f, 1.81863233e-01f, -5.09251282e-02f, -1.46388188e-01f, 1.51363477e-01f, -1.46146357e-01f,
  -1.09489642e-01f, -8.85584503e-02f, -1.23772353e-01f, -1.61180105e-02f, 6.01205230e-02f, 4.90093138e-03f, 2.84784921e-02f, 2.18746036e-01f, -3.69401718e-03f, 1.07355371e-01f,
  6.65622130e-02f, -2.64278054e-01f, -1.10144811e-02f, 6.02414161e-02f, 1.34433001e-01f, -1.17996685e-01f, -2.63283122e-02f, 1.98688462e-01f, -9.46291685e-02f, 1.26857355e-01f,
  1.90129746e-02f, 1.63917318e-01f, 1.57600194e-02f, 1.40984058e-01f, 7.90653080e-02f, 9.81008857e-02f, 1.35055045e-02f, 8.02462325e-02f, -5.26533946e-02f, 8.58040079e-02f,
  9.02629495e-02f, 1.14415951e-01f, -9.52172428e-02f, 5.26797995e-02f, -1.61394849e-01f, -6.62343800e-02f, 4.89056446e-02f, 8.98400322e-02f, 4.08625044e-02f, -6.57285973e-02f,
  9.24775451e-02f, 2.67730895e-02f, -7.40930811e-02f, 1.08777218e-01f, -3.47249396e-02f, -6.05449192e-02f, 9.45195630e-02f, 1.79206192e-01f, -2.08092079e-01f, 6.19666092e-02f,
  1.59902871e-01f, -6.12093434e-02f, 4.22815949e-01f, -1.51774049e-01f, 1.24941356e-01f, 3.45870465e-01f, -6.56171367e-02f, -1.23020478e-01f, -5.68646453e-02f, -1.99914034e-02f,
  -2.68288761e-01f, 1.04069188e-01f, -1.95168003e-01f, 2.57348511e-02f, -1.22513972e-01f, 1.10482119e-01f, 1.66542694e-01f, -1.29700512e-01f, -2.53582112e-02f, 6.39428794e-02f,
  8.38641524e-02f, -1.59197956e-01f, 1.85129628e-01f, 3.24202282e-03f, 2.01047152e-01f, 2.40312386e-02f, 1.67446658e-01f, 9.03152749e-02f, -1.27457678e-01f, 1.54715162e-02f,
  1.49353281e-01f, 1.44361228e-01f, 9.69106629e-02f, -2.31637388e-01f, 6.35037348e-02f, -1.12247758e-01f, -5.09751067e-02f, -3.31305377e-02f, -1.36011779e-01f, -8.81678015e-02f,
  -6.76386207e-02f, -1.44293427e-01f, 7.74002150e-02f, 2.07484692e-01f, 1.01507947e-01f, 1.49413779e-01f, 2.23241672e-01f, 2.09655255e-01f, 1.11627050e-01f, -1.02153733e-01f,
  -3.49922925e-02f, 4.76056300e-02f, 1.70743428e-02f, 6.63818941e-02f, 4.50308099e-02f, -5.10450229e-02f, 2.62854099e-01f, 5.89903668e-02f, -4.02056761e-02f, -6.52382337e-03f,
  2.10539654e-01f, -6.56075776e-02f, 4.60379310e-02f, -1.23899266e-01f, 9.22282599e-03f, 4.81003448e-02f, -3.75824086e-02f, 8.10724348e-02f, 9.63721648e-02f, -2.01046690e-01f,
  8.19736347e-02f, 3.24145436e-01f, -3.34231444e-02f, 9.71633568e-02f, 3.58148068e-02f, -1.64537385e-01f, -1.56728685e-01f, -2.72004277e-01f, -2.28264153e-01f, 1.07023008e-01f,
  6.29844218e-02f, 1.64579600e-01f, -1.09553248e-01f, 4.22154926e-02f, 2.87774801e-01f, 2.74539944e-02f, -7.39796013e-02f, -1.98813140e-01f, -1.39862522e-01f, -8.80787298e-02f,
  -1.96065918e-01f, -5.32729626e-02f, 1.10095881e-01f, -6.19742572e-02f, 1.30446047e-01f, -2.16672704e-01f, -1.58825710e-01f, 1.03112184e-01f, -9.79528204e-02f, 2.43995041e-01f,
  -2.70864591e-02f, -4.90336865e-02f, 2.67719142e-02f, 7.69864470e-02f, -3.90285075e-01f, -2.42860258e-01f, -1.78659111e-02f, -1.92964777e-01f, -2.57758737e-01f, -1.19639210e-01f,
  -6.83717132e-02f, 7.44551495e-02f, -1.82902604e-01f, -1.33708060e-01f, 8.56169779e-03f, 1.28667057e-01f, -1.34391695e-01f, 7.32066408e-02f, 8.64924416e-02f, 1.50701210e-01f,
  -5.34698833e-03f, 3.99241187e-02f, -4.66225110e-02f, -1.68902472e-01f, 2.61452012e-02f, -4.21574637e-02f, -1.13978483e-01f, 3.44395012e-01f, -2.18119398e-01f, 9.40659642e-02f,
  -1.48523465e-01f, 1.37382895e-01f, 9.02144015e-02f, -5.75843453e-03f, 1.21167652e-01f, -8.60054716e-02f, -1.78464398e-01f, -1.01919770e-01f, -1.49151310e-01f, -3.31781022e-02f,
  1.48322850e-01f, 1.83773294e-01f, -8.73018801e-02f, -1.49488419e-01f, 6.87492117e-02f, 3.09266765e-02f, 4.59387749e-02f, -2.45297737e-02f, 7.26911798e-02f, -1.06780730e-01f,
  -6.41079992e-02f, 1.71621472e-01f, 8.86736214e-02f, 2.75058094e-02f, 2.03071907e-02f, -1.11286059e-01f, -1.96602061e-01f, 1.80633008e-01f, 1.30028844e-01f, 1.49371192e-01f,
  -1.53511949e-02f, -2.34280214e-01f, -9.86090526e-02f, -8.05137008e-02f, -7.33161643e-02f, -1.70428395e-01f, -1.95151031e-01f, 1.38209760e-01f, -6.40124604e-02f, 1.30243972e-01f,
  -1.72436535e-02f, 4.05541882e-02f, -6.76212925e-03f, 1.26258016e-01f, -1.07989050e-01f, 1.06719919e-01f, 2.16453537e-01f, -9.07455757e-02f, 2.42585931e-02f, 1.44748285e-01f,
  2.08660319e-01f, 1.90608948e-02f, 1.14435062e-01f, 3.97612676e-02f, 3.41494083e-01f, -1.49070062e-02f, -1.08184144e-01f, -2.45710649e-02f, 2.40548521e-01f, 9.34147462e-02f,
  3.84061150e-02f, 1.57738492e-01f, 1.47913203e-01f, -8.22421983e-02f, 5.53599074e-02f, 2.90341973e-02f, 2.51062751e-01f, 8.05264339e-02f, -8.43847543e-02f, 7.55838305e-03f,
  -2.33779684e-01f, 4.89642918e-02f, 6.89947531e-02f, 9.28507820e-02f, -2.95433570e-02f, -1.28854081e-01f, -2.52641529e-01f, 1.70317873e-01f, 2.71708429e-01f, -1.78522076e-02f,
  -4.77636047e-02f, -1.83056798e-02f, 3.32300514e-01f, 1.46698682e-02f, 2.14080498e-01f, -3.01884357e-02f, 1.11085735e-01f, -1.00050345e-01f, 1.11053042e-01f, 1.52885705e-01f,
  -1.20685939e-02f, -2.23450631e-01f, -1.88546740e-02f, -1.35805786e-01f, -1.96668524e-02f, -9.38994512e-02f, 3.65210534e-03f, 1.79780602e-01f, -1.86029777e-01f, -3.55137326e-02f,
  -6.72867196e-03f, 3.88766862e-02f, -2.47180000e-01f, -3.34283948e-01f, -1.27099574e-01f, -2.68565770e-02f, 5.12414686e-02f, -1.69729277e-01f, -6.51073977e-02f, -4.29528393e-02f,
  1.88280076e-01f, 3.00563909e-02f, 2.56194621e-01f, 1.92509562e-01f, 2.27491692e-01f, 3.01872134e-01f, 3.05720806e-01f, 1.64168388e-01f, -5.16981296e-02f, 1.71781510e-01f,
  2.27460772e-01f, 2.28242055e-02f, -5.06585985e-02f, 2.33994678e-01f, -2.69260108e-01f, 2.42029727e-01f, 1.37993142e-01f, -1.24621503e-01f, 4.38505188e-02f, -1.05627775e-01f,
  3.12080681e-01f, 3.36896837e-01f, -1.47346944e-01f, -2.56370425e-01f, -1.30863249e-01f, -2.87166685e-02f, -1.34309739e-01f, -5.90274408e-02f, 1.52325928e-01f, 1.75775960e-01f,
  -1.35246709e-01f, 1.03668042e-01f, 1.10052928e-01f, 1.81383938e-02f, -3.14103365e-02f, 1.05161324e-01f, -3.07855755e-01f, 1.15157537e-01f, 2.30349094e-01f, 9.39073861e-02f,
  2.10849717e-01f, -2.16245633e-02f, 1.43266112e-01f, -1.35163786e-02f, 1.25152305e-01f, -1.11189216e-01f, 3.11540440e-03f, -8.74379650e-02f, 2.12768205e-02f, -1.66378081e-01f,
  4.96756919e-02f, -1.97946787e-01f, 1.29049867e-01f, 1.07987728e-02f, -1.31586552e-01f, -3.96434106e-02f, 1.24043003e-01f, -5.84401935e-02f, -7.39950780e-03f, 2.18300760e-01f,
  1.26184151e-01f, 2.68423799e-02f, 2.18656376e-01f, 3.77466194e-02f, 1.00706279e-01f, 3.20908219e-01f, -2.90141478e-02f, -3.20331305e-02f, 1.87534302e-01f, -6.89137578e-02f,
  -1.48540568e-02f, -3.26408111e-02f, 1.68751732e-01f, -1.07625418e-03f, -2.41683200e-01f, -7.11465180e-02f, -4.43389453e-02f, -9.79128331e-02f, 3.15914191e-02f, -1.35273039e-01f,
  -9.72764194e-02f, 8.69281776e-03f, 8.25929940e-02f, -2.76175775e-02f, -1.11735137e-02f, -9.55090970e-02f, -2.38625616e-01f, 7.33593479e-02f, 7.42893666e-02f, 1.03923358e-01f,
  4.86199334e-02f, -2.44670399e-02f, -6.94192201e-02f, -2.43764669e-01f, 1.82844885e-02f, -1.01025747e-02f, 6.04000837e-02f, 1.76648833e-02f, -2.06707299e-01f, 2.00950820e-02f,
  7.55896047e-02f, 2.32092202e-01f, -1.19870596e-01f, -1.31244376e-01f, -4.79590930e-02f, 6.42510802e-02f, -1.19559085e-02f, -1.39785381e-02f, 5.73672056e-02f, -1.63749322e-01f,
  -5.94192781e-02f, -1.63887799e-01f, 5.66617548e-02f, 1.66425005e-01f, 9.29813012e-02f, 1.02580056e-01f, 1.78404644e-01f, 1.48389563e-01f, 1.15665399e-01f, -1.39700742e-02f,
  -1.59373298e-01f, -9.81334075e-02f, -2.13576153e-01f, -7.23189022e-03f, 1.60613462e-01f, -5.67385443e-02f, -2.20275953e-01f, -2.16077850e-03f, 8.49890858e-02f, 2.25012988e-01f,
  -1.06319048e-01f, 1.24097027e-01f, -6.90783635e-02f, 2.39440411e-01f, -1.44603299e-02f, -6.99559897e-02f, -1.27307981e-01f, -4.21133079e-02f, 1.78632215e-01f, 2.11973693e-02f,
  -1.09881856e-01f, 1.56730160e-01f, -7.88105652e-02f, 2.38183841e-01f, 3.21473181e-02f, 1.00722509e-02f, -1.54404148e-01f, 5.45916893e-02f, 1.87373295e-01f, -6.19569644e-02f,
  -1.41769350e-01f, -3.35126340e-01f, 1.10362329e-01f, -6.69095442e-02f, 6.60375431e-02f, -4.25970517e-02f, 2.56550670e-01f, 4.22561839e-02f, 1.61891133e-01f, 1.98689088e-01f,
  -2.22945064e-01f, -1.43967107e-01f, -4.14113700e-01f, -6.13802373e-02f, -1.45486251e-01f, 4.64406889e-03f, 6.62643649e-03f, 6.15022890e-02f, 1.65588126e-01f, 1.09610356e-01f,
  7.96455052e-03f, 2.31015280e-01f, -5.95074743e-02f, -2.43320063e-01f, 1.36192054e-01f, -2.63999160e-02f, -1.51170745e-01f, -6.12576753e-02f, -1.35502750e-02f, 3.01970001e-02f,
  1.01097465e-01f, -9.41484943e-02f, 1.05410196e-01f, -1.47357523e-01f, 6.67971075e-02f, 1.08105525e-01f, 2.31994763e-01f, 5.31224720e-02f, -1.04204208e-01f, 3.20134372e-01f,
  3.26107949e-01f, 1.41409650e-01f, 4.91016544e-02f, -6.78820461e-02f, 2.01947857e-02f, -1.98187791e-02f, 4.36734334e-02f, -1.50136529e-02f, 1.63160786e-02f, -7.00842813e-02f,
  1.83247328e-01f, -7.08396509e-02f, -2.58696377e-01f, 3.62911895e-02f, 2.13997617e-01f, -4.31200974e-02f, 6.57709017e-02f, -6.28604293e-02f, -2.27518333e-03f, -5.04825339e-02f,
  1.34315446e-03f, -8.60738903e-02f, -6.32666331e-03f, 9.34318006e-02f, -1.63884088e-01f, 4.57874052e-02f, 2.02170670e-01f, 1.98354825e-01f, 1.05640180e-01f, 8.20744336e-02f,
  -2.90580601e-01f, 2.55537760e-02f, 7.20986500e-02f, 2.80719310e-01f, -4.52989303e-02f, 1.07347496e-01f, -3.63805629e-02f, 1.30948955e-02f, -1.96086951e-02f, -1.03333011e-01f,
  -4.92295064e-02f, -2.49176815e-01f, -1.01086259e-01f, 1.48134977e-01f, -8.90560076e-02f, -1.90037742e-01f, -1.32373825e-01f, 1.55242365e-02f, -1.31921515e-01f, -1.56034321e-01f,
  7.37320185e-02f, -1.57190412e-01f, 4.84797284e-02f, 1.21933311e-01f, -9.95571017e-02f, -1.09008402e-01f, -9.04270113e-02f, -7.90212527e-02f, 6.51165424e-03f, -2.39789486e-02f,
  -1.10126503e-01f, -1.74705088e-01f, -7.84027949e-02f, 3.79790328e-02f, 1.31013263e-02f, 8.71791989e-02f, -9.59482864e-02f, -2.23500784e-02f, -1.57979861e-01f, 3.93727161e-02f,
  1.86858803e-01f, -9.72829238e-02f, 1.43103581e-02f, 2.23735839e-01f, 1.27775863e-01f, 1.23714656e-01f, -6.33075600e-03f, 6.80282488e-02f, 5.22912256e-02f, 2.16232717e-01f,
  -1.08553320e-01f, 1.42821327e-01f, 1.47525057e-01f, -1.30375609e-01f, 1.08382970e-01f, -3.02221149e-01f, -1.95755586e-02f, 2.88484275e-01f, -6.82522431e-02f, -8.86155590e-02f,
  -9.05270223e-03f, -1.86250675e-02f, -1.81630537e-01f, 1.35088846e-01f, -1.71416521e-01f, 7.44153857e-02f, -2.00169280e-01f, -3.80835757e-02f, -4.32370938e-02f, -9.55477282e-02f,
  5.90581913e-04f, 9.35242400e-02f, 9.87935215e-02f, 2.05645915e-02f, 1.28140286e-01f, 7.10043833e-02f, 7.24819377e-02f, 1.95658579e-01f, -1.34306606e-02f, 8.43477324e-02f,
  -8.76387879e-02f, -3.99065055e-02f, 1.78945944e-01f, -5.18964231e-02f, 7.82296956e-02f, -1.59389585e-01f, 1.23395890e-01f, 5.34913279e-02f, -1.42881483e-01f, 1.54188663e-01f,
  -6.24805763e-02f, 1.46182850e-01f, -2.46198084e-02f, -2.10275725e-01f, -2.63344944e-01f, 1.23081021e-01f, 1.00189932e-01f, -1.39011160e-01f, 2.30251715e-01f, -9.65656564e-02f,
  7.61529133e-02f, 1.13414499e-04f, 4.54396196e-02f, -2.25440953e-02f, 1.26767606e-01f, -7.84477070e-02f, -7.62606878e-03f, 6.19831271e-02f, 1.27291784e-01f, -1.67119727e-01f,
  -2.09743083e-01f, -1.11090124e-01f, 9.38270018e-02f, -2.07448322e-02f, 3.95926423e-02f, 5.87057360e-02f, 5.23211956e-02f, -2.25783229e-01f, -2.55092293e-01f, -9.49128941e-02f,
  8.57558772e-02f, -1.09220713e-01f, -8.99540959e-04f, 1.56203955e-01f, -5.60345501e-02f, 2.37479582e-01f, -6.37421533e-02f, -1.11645930e-01f, -1.10271625e-01f, 2.59943455e-01f,
  8.59385580e-02f, 6.82394281e-02f, -2.19378229e-02f, -1.04316669e-02f, -2.11069897e-01f, -1.23890467e-01f, -1.35994330e-01f, 7.13527873e-02f, -7.78693557e-02f, -2.18307689e-01f,
  -8.18813220e-04f, 2.26478249e-01f, -1.51019111e-01f, -2.66903695e-02f, 2.49534488e-01f, 4.07828726e-02f, 7.27803111e-02f, -7.95548260e-02f, -1.91256534e-02f, 1.15814440e-01f,
  2.38155923e-03f, -1.36932328e-01f, 4.13539372e-02f, -1.34989917e-02f, -4.10913453e-02f, -6.22876137e-02f, -4.64653189e-04f, 3.22395116e-02f, 1.87194213e-01f, -9.18613672e-02f,
  1.44349523e-02f, 1.88665792e-01f, -1.42790154e-01f, 4.72259261e-02f, 2.33433209e-02f, -2.32170105e-01f, 2.69109458e-01f, -1.32624735e-03f, -2.31723890e-01f, -1.16828196e-01f,
  1.59603730e-01f, -5.17767109e-02f, -1.90635502e-01f, -1.13632046e-02f, 1.33554772e-01f, -6.23117425e-02f, -5.34749180e-02f, 2.64345799e-02f, 1.00830562e-01f, 4.84964624e-02f,
  -5.52589558e-02f, -7.94275180e-02f, 2.58775562e-01f, -2.63107810e-02f, -1.53252333e-01f, -9.79433283e-02f, 3.94764334e-01f, -1.61722731e-02f, -1.47257149e-01f, -7.55406842e-02f,
  -1.03094347e-01f, -2.34407131e-02f, 3.28171760e-01f, -1.71647504e-01f, 1.02862092e-02f, -1.43837869e-01f, 1.69511624e-02f, -8.90546218e-02f, 1.55124301e-03f, -1.23472996e-01f,
  -1.67563930e-01f, -2.03810651e-02f, 1.95540916e-02f, 1.93646744e-01f, 1.77067906e-01f, 1.19582126e-02f, 1.73779309e-01f, 2.32615434e-02f, 1.23212427e-01f, -1.03670329e-01f,
  -8.69181156e-02f, 6.27452731e-02f, -1.68570727e-01f, 5.82474917e-02f, 2.39533298e-02f, -1.29241705e-01f, -3.58355194e-02f, -1.60723433e-01f, -2.23297223e-01f, 6.83882907e-02f,
  1.02605991e-01f, 1.30206540e-01f, -9.98137295e-02f, 1.03708714e-01f, 2.20305204e-01f, -2.49788743e-02f, 7.53064975e-02f, 8.34988058e-02f, 1.50810778e-01f, -2.99106061e-01f,
  -4.41288538e-02f, 7.75754303e-02f, 1.08779185e-02f, 2.12151214e-01f, 2.74066091e-01f, 1.69690758e-01f, 1.92990359e-02f, -2.87952553e-02f, 1.17328830e-01f, -8.16156343e-02f,
  -1.45086989e-01f, 1.21500835e-01f, -1.26707166e-01f, 2.14491427e-01f, -1.97086141e-01f, 2.03491017e-01f, -1.55311674e-01f, 8.08920264e-02f, 1.00730851e-01f, -2.58578241e-01f,
  -1.33913383e-01f, 8.96357670e-02f, -2.60511577e-01f, -1.46389186e-01f, 1.16576642e-01f, -1.53261989e-01f, 8.43087211e-02f, -2.63378173e-01f, -9.06556919e-02f, -8.95018578e-02f,
  -1.39240131e-01f, 1.33940071e-01f, -1.70396924e-01f, 1.16440197e-02f, -1.70006171e-01f, 2.03727305e-01f, 1.31131694e-01f, -1.23224750e-01f, -5.75065166e-02f, -3.64824943e-02f,
  -8.15635175e-02f, 7.80381262e-02f, 1.20426327e-01f, -1.60931982e-02f, -1.09496936e-01f, -4.60783429e-02f, -1.66323096e-01f, 2.47476757e-01f, 6.48537464e-03f, 1.27630264e-01f,
  1.31477579e-01f, -3.46424654e-02f, -6.85374215e-02f, -3.89734916e-02f, 1.69181809e-01f, 1.61254376e-01f
};

// L3_fan_Wp_bar (Shape: 26 x 64)
const int L3_fan_Wp_bar_rows = 26;
const int L3_fan_Wp_bar_cols = 64;
const float L3_fan_Wp_bar_data[] = {
  1.53879091e-01f, 1.57228276e-01f, -6.03156723e-02f, 3.72598350e-01f, 1.32499650e-01f, 2.22498804e-01f, -9.08016600e-03f, 7.07866997e-02f, 4.23000194e-02f, 6.53040037e-02f,
  1.71223804e-01f, 5.08566685e-02f, -2.10585240e-02f, -6.30993256e-03f, 8.66413862e-02f, 1.74020335e-01f, 3.91405635e-02f, -9.67279077e-02f, 1.71321362e-01f, -6.68386370e-02f,
  -3.05595137e-02f, 1.06701711e-02f, 1.02000915e-01f, 1.97292771e-02f, 6.52033910e-02f, -7.55170733e-03f, 3.83177310e-01f, -5.64426370e-02f, -8.90341923e-02f, -1.97372451e-01f,
  -1.92516878e-01f, 2.04483852e-01f, -1.12583861e-01f, 2.68458247e-01f, 1.23672456e-01f, -2.64963657e-01f, -2.77601719e-01f, 2.96771884e-01f, -3.18766795e-02f, 1.70393690e-01f,
  7.36499205e-03f, 1.45209789e-01f, -1.66888505e-01f, 9.45720896e-02f, 3.25646371e-01f, 1.82000801e-01f, 1.70982122e-01f, -7.04626292e-02f, 1.45026758e-01f, 4.38775003e-01f,
  -1.41390637e-01f, -1.16887711e-01f, 7.31506571e-02f, 1.70753196e-01f, -9.94774699e-02f, 5.20141348e-02f, 9.29381475e-02f, 3.88907969e-01f, -1.83266237e-01f, 5.29752709e-02f,
  1.89334288e-01f, 2.19019264e-01f, 7.08307698e-02f, -2.64727741e-01f, 6.12521805e-02f, 2.00133562e-01f, 1.40807122e-01f, 1.00628674e-01f, 2.86022514e-01f, 3.26383859e-02f,
  2.88527906e-02f, 3.89945388e-01f, 2.27333501e-01f, 3.46387416e-01f, 8.48971009e-02f, 8.95138383e-02f, 2.38731474e-01f, 1.75150305e-01f, 1.87194720e-01f, 2.39673242e-01f,
  4.81483154e-02f, 4.03320402e-01f, 3.78935337e-01f, 1.35983899e-01f, -1.22701339e-01f, -4.91200387e-02f, 6.18652999e-02f, -1.43924326e-01f, 1.20139062e-01f, -6.36613294e-02f,
  2.12558493e-01f, 4.50654794e-03f, 1.66580036e-01f, -3.92447889e-01f, -1.82456940e-01f, -9.37548503e-02f, -3.51420082e-02f, -4.50840183e-02f, 2.87453890e-01f, 1.06103137e-01f,
  -3.06448102e-01f, 3.37890595e-01f, 4.78966117e-01f, -1.57502204e-01f, 2.32752815e-01f, -5.34631573e-02f, -3.94440323e-01f, -1.81637943e-01f, 1.38249844e-01f, 9.24532395e-03f,
  2.68439144e-01f, 1.23405242e-02f, 4.03354883e-01f, 1.45055845e-01f, 5.87093942e-02f, 1.59178346e-01f, 3.96668129e-02f, 2.52776891e-01f, -1.22813135e-01f, -8.33794996e-02f,
  1.38786644e-01f, -1.31096274e-01f, -3.90138589e-02f, -9.24427435e-03f, -2.20803976e-01f, 1.23209648e-01f, 3.29636663e-01f, -1.45408243e-01f, 2.39588935e-02f, 2.16662049e-01f,
  1.17615268e-01f, 2.46835142e-01f, 1.26326755e-01f, -6.34030774e-02f, -2.54408360e-01f, -3.20225745e-01f, -9.95304063e-03f, -2.42757097e-01f, 9.94927213e-02f, -1.56309158e-01f,
  2.81944070e-02f, 1.02086529e-01f, 1.78674385e-01f, 9.05613750e-02f, -6.51563797e-03f, -3.20444077e-01f, 6.19858168e-02f, -6.60612881e-02f, 3.20732206e-01f, -4.96931404e-01f,
  6.46863356e-02f, 3.75413336e-03f, 9.47942659e-02f, -2.44052778e-03f, -2.09110543e-01f, -1.54577270e-01f, 2.23357663e-01f, -2.90212352e-02f, -4.79132459e-02f, -3.16433124e-02f,
  -4.68252487e-02f, -1.85352698e-01f, 3.94301926e-04f, -2.36032084e-01f, 2.16084719e-01f, -5.32009542e-01f, 1.24388561e-02f, 1.84274465e-01f, 7.58093745e-02f, 9.24629420e-02f,
  5.47885239e-01f, 1.12710245e-01f, -7.54571557e-02f, -2.27034185e-03f, -1.92466304e-01f, -1.08257912e-01f, -4.15459201e-02f, 2.14557350e-01f, -5.27739001e-04f, 6.98457211e-02f,
  2.67469019e-01f, -6.37234449e-02f, 8.99456367e-02f, 8.27100947e-02f, 2.05751881e-01f, 1.17108494e-01f, 9.04360786e-02f, 2.81974047e-01f, -9.90841314e-02f, 1.16105080e-01f,
  -4.43275757e-02f, -8.26545581e-02f, 5.60597032e-02f, 1.81097999e-01f, 2.34006777e-01f, 8.99023116e-02f, -3.28812748e-02f, -4.04433832e-02f, 1.05743803e-01f, 2.45719165e-01f,
  1.77580968e-01f, -1.05387419e-01f, 1.65841684e-01f, 1.62621126e-01f, 1.42973945e-01f, -2.66450588e-02f, 1.87232420e-02f, 1.26039803e-01f, 1.87983736e-01f, 1.43698752e-01f,
  2.45307431e-01f, 1.17586233e-01f, -1.49038494e-01f, 1.64088849e-02f, -1.34752998e-02f, -1.42967626e-02f, 2.99715191e-01f, -3.15408081e-01f, -3.01942289e-01f, 2.61167675e-01f,
  -2.98781157e-01f, -2.36413792e-01f, 1.55149102e-01f, -4.10659611e-01f, 2.25195840e-01f, -2.00687733e-04f, -1.81896716e-01f, -2.51795858e-01f, 1.15234613e-01f, 1.64147347e-01f,
  7.58207366e-02f, -6.44066706e-02f, -2.79613435e-01f, 7.94771761e-02f, -2.91597366e-01f, 1.34139508e-01f, 3.89907658e-01f, -4.21454422e-02f, 1.13767378e-01f, -4.07487303e-02f,
  2.18959272e-01f, 3.15824002e-02f, -2.02130917e-02f, -8.97508040e-02f, 3.45682167e-02f, 2.14162171e-02f, 2.01234207e-01f, -8.73328820e-02f, 4.35331404e-01f, 1.92460958e-02f,
  2.12948874e-01f, -1.08968101e-01f, -5.04939139e-01f, -2.49950513e-01f, 1.07866272e-01f, 3.71087268e-02f, -1.68150127e-01f, -1.04525968e-01f, -1.02402374e-01f, 2.10869592e-02f,
  -2.43626907e-01f, -2.95783859e-02f, 8.10735375e-02f, 1.00503199e-01f, -6.77127838e-02f, 2.03992635e-01f, 1.06832974e-01f, -1.26085311e-01f, -9.35439020e-03f, -1.82103783e-01f,
  -1.80936560e-01f, 2.55140573e-01f, 6.55345395e-02f, 2.96441644e-01f, 1.40382245e-01f, 1.66194797e-01f, -1.22545257e-01f, 2.48297676e-01f, 1.38613269e-01f, -5.61175980e-02f,
  2.56121419e-02f, -6.99907318e-02f, 3.35587621e-01f, 3.72810781e-01f, -2.00205117e-01f, -2.79996842e-01f, 2.56357700e-01f, 2.42769299e-03f, 2.01386176e-02f, 1.20599784e-01f,
  -9.36228484e-02f, 3.44231367e-01f, -8.57043043e-02f, 3.20592791e-01f, 5.26734926e-02f, -3.10604304e-01f, -2.07037792e-01f, -2.80646365e-02f, -1.34520426e-01f, -5.87163307e-02f,
  5.42981923e-02f, 2.37979352e-01f, 4.92083699e-01f, 5.47813028e-02f, 1.12069391e-01f, 8.52217823e-02f, 2.44232506e-01f, -5.37607521e-02f, 8.11195076e-02f, 4.00095358e-02f,
  4.90389578e-02f, 4.17069020e-03f, 2.07750320e-01f, -2.34789681e-02f, 9.27341208e-02f, -6.48328662e-02f, 2.86555678e-01f, -2.06709672e-02f, 1.07134894e-01f, 2.25513443e-01f,
  -6.13509081e-02f, -2.03566223e-01f, 1.05559871e-01f, -7.94871710e-03f, -4.09316182e-01f, -1.28056675e-01f, 1.00086175e-01f, -1.04184635e-01f, 2.68323738e-02f, 3.38092670e-02f,
  1.68634094e-02f, -2.59076953e-01f, -9.01931152e-03f, -1.00312479e-01f, -3.38690169e-02f, -2.97668409e-02f, 2.07462311e-01f, -3.10250297e-02f, 4.70353924e-02f, 1.50128320e-01f,
  5.17196730e-02f, 1.06179059e-01f, 9.57330912e-02f, -2.85478514e-02f, 7.57568851e-02f, 3.01716238e-01f, 1.60739094e-01f, -1.18047275e-01f, -1.12486847e-01f, -6.57211468e-02f,
  -2.20450282e-01f, 2.67121643e-01f, -3.53654981e-01f, 7.87102655e-02f, 1.98500440e-01f, -2.31062695e-01f, -2.58305699e-01f, 2.24500716e-01f, 6.70078695e-02f, 1.42786756e-01f,
  -5.30821383e-02f, 2.90408552e-01f, -9.37781930e-02f, 4.17614728e-02f, 1.23709086e-02f, 3.31396163e-01f, 3.48961473e-01f, -3.44590873e-01f, 1.88795820e-01f, 2.15230852e-01f,
  -5.53919226e-02f, -2.17238873e-01f, -9.40554664e-02f, -2.59384364e-02f, -7.60388076e-02f, 2.00148657e-01f, -1.76215544e-01f, 3.05478573e-01f, -1.53814897e-01f, -3.84027176e-02f,
  2.44312540e-01f, 1.69351995e-01f, -2.22919330e-01f, -1.54368812e-02f, 1.55098319e-01f, 3.59171987e-01f, -7.64083490e-02f, -8.79925210e-03f, 1.84506983e-01f, -5.33917211e-02f,
  -1.88327119e-01f, 2.02961326e-01f, 1.37183651e-01f, 1.50068358e-01f, 2.63148278e-01f, 1.20253988e-01f, 4.94852327e-02f, 2.04298213e-01f, 2.61031911e-02f, 5.91127798e-02f,
  -1.78310454e-01f, 9.98336747e-02f, 3.02161753e-01f, 1.25450820e-01f, -1.11963995e-01f, 1.01103470e-01f, 4.09148000e-02f, -1.44330785e-01f, 2.82065749e-01f, 8.86370055e-03f,
  4.89162773e-01f, 3.40298951e-01f, 2.76196506e-02f, -1.15959510e-01f, -9.81919235e-04f, -7.65603483e-02f, 1.47901744e-01f, 1.47292480e-01f, -2.00266883e-01f, 3.23762506e-01f,
  5.02633862e-03f, 3.46458048e-01f, 3.40419054e-01f, -3.08539659e-01f, 2.98526317e-01f, -2.10600361e-01f, 1.75210848e-01f, -3.89134526e-01f, -2.47261927e-01f, 7.75148049e-02f,
  3.24115634e-01f, 1.42593518e-01f, 2.25784187e-03f, -1.72462061e-01f, 4.70708385e-02f, 1.96034759e-01f, 5.46778999e-02f, 2.34781176e-01f, 2.03956515e-01f, 4.93910797e-02f,
  -3.61667424e-02f, 1.27847334e-02f, 1.10413380e-01f, 6.35673255e-02f, -3.91429104e-02f, 2.40292549e-01f, 6.77291723e-03f, 1.07960306e-01f, 2.64239055e-03f, -3.09126042e-02f,
  2.16807917e-01f, 2.99761537e-02f, -9.02833194e-02f, -1.37725338e-01f, 2.68648386e-01f, 7.25190639e-02f, -2.45268103e-02f, -7.27515817e-02f, -1.82753846e-01f, 1.15306780e-01f,
  -4.12706519e-03f, -4.83957976e-02f, -2.88880110e-01f, -8.63307808e-03f, 9.76154208e-02f, 4.87705581e-02f, 8.21462721e-02f, 2.19679460e-01f, -1.57520950e-01f, 2.30978087e-01f,
  -1.76438391e-02f, -2.44464919e-01f, 1.78514183e-01f, -8.31523389e-02f, -1.60844401e-01f, 8.18202272e-02f, 1.12360500e-01f, -1.38248980e-01f, -2.52025187e-01f, -4.35761720e-01f,
  3.97295086e-03f, 3.85727063e-02f, 5.00693679e-01f, -6.33397177e-02f, 1.44121766e-01f, -3.64020437e-01f, 1.14529245e-01f, -2.49486253e-01f, -6.60745353e-02f, 1.47472411e-01f,
  -3.38989317e-01f, 2.76978046e-01f, 3.98004711e-01f, -2.21302956e-02f, -3.39077041e-02f, 3.35912555e-01f, 1.87871724e-01f, 1.77357689e-01f, -3.98558266e-02f, -1.60819863e-03f,
  3.02999094e-02f, 1.06419891e-01f, 6.53343573e-02f, -1.21823013e-01f, 1.56208649e-01f, -1.95448607e-01f, -1.42299607e-01f, 1.68102533e-01f, -3.92355829e-01f, -9.33834314e-02f,
  2.55761594e-01f, -3.94024327e-02f, 1.11066498e-01f, 7.64390156e-02f, -3.84327769e-01f, -1.14091344e-01f, 1.25460923e-01f, -1.13793924e-01f, -2.10148469e-01f, -2.11118042e-01f,
  -1.34728760e-01f, -1.74045205e-01f, 3.35980095e-02f, 1.23473994e-01f, -1.08466014e-01f, 2.23034337e-01f, -2.48427451e-01f, -1.31913617e-01f, -1.01977527e-01f, -2.02290580e-01f,
  -1.56429838e-02f, 1.72935769e-01f, -1.12917230e-01f, 2.59980291e-01f, 1.40798926e-01f, 7.20064864e-02f, 8.47923383e-02f, -1.23214982e-01f, -2.21822709e-01f, 1.16285466e-01f,
  9.19563025e-02f, 5.60917594e-02f, -2.31803417e-01f, -1.56963453e-01f, 1.07285343e-02f, 6.57595024e-02f, 1.16600372e-01f, 2.11573869e-01f, 3.82971823e-01f, -3.57299328e-01f,
  8.58580619e-02f, -2.92539448e-01f, -8.07683729e-03f, -1.48602976e-02f, 4.10024017e-01f, -8.71956423e-02f, 1.63696855e-01f, 1.42537907e-01f, 2.97697559e-02f, 3.47676426e-01f,
  1.38836101e-01f, 1.38479890e-02f, -1.12812571e-01f, 3.95264655e-01f, 3.19791138e-01f, 1.11117817e-01f, 3.02984357e-01f, -3.29334527e-01f, 1.44490793e-01f, -2.92974055e-01f,
  1.12585686e-02f, 2.84516573e-01f, -2.69424170e-01f, 6.98205307e-02f, 2.45941743e-01f, -7.99704459e-04f, 7.37290606e-02f, 1.65510140e-02f, -1.46057859e-01f, -6.30972534e-02f,
  -2.63839308e-02f, 1.73032776e-01f, 1.38104841e-01f, 4.05461304e-02f, -7.99686611e-02f, 1.13534302e-01f, -6.11018157e-03f, 7.16792494e-02f, 1.24770559e-01f, 7.33842328e-02f,
  2.03179553e-01f, 7.27169961e-02f, -2.42263183e-01f, -1.03512339e-01f, -6.13604821e-02f, -2.46508777e-01f, 2.11037826e-02f, -3.99595946e-02f, -2.04239786e-01f, -1.12321293e-02f,
  -3.69742155e-01f, 2.90550679e-01f, 3.47604334e-01f, -2.71086842e-01f, -1.26838610e-01f, 5.47850542e-02f, -1.09819159e-01f, 4.02473390e-01f, 2.77771279e-02f, 9.90559012e-02f,
  6.98741525e-03f, -2.27519482e-01f, -2.94862717e-01f, -2.32766382e-02f, 9.08551663e-02f, 1.88493192e-01f, 1.42879233e-01f, 2.44762492e-03f, -3.55621010e-01f, 6.83947206e-02f,
  -2.15195075e-01f, -1.85887460e-02f, -3.23463529e-02f, -3.62169147e-01f, 3.59375477e-02f, 3.01962614e-01f, 8.29230919e-02f, -1.00504175e-01f, -4.33747703e-03f, -1.57899812e-01f,
  -1.42742559e-01f, 1.63036168e-01f, -2.86561131e-01f, 1.79907784e-01f, -1.34107657e-02f, 2.05098033e-01f, 2.27727860e-01f, 3.05192322e-01f, -2.18335167e-01f, -9.51690376e-02f,
  1.20913751e-01f, -1.64450645e-01f, -7.28472695e-02f, -5.47237210e-02f, -1.50234431e-01f, 1.04047187e-01f, 1.04051799e-01f, -2.71766394e-01f, -1.21583417e-01f, 4.17700633e-02f,
  1.31263450e-01f, -1.41242549e-01f, 1.54781230e-02f, 1.50465414e-01f, 1.55065525e-02f, 1.51123409e-03f, 9.12450179e-02f, 3.34364735e-02f, 6.17687851e-02f, -8.22158754e-02f,
  1.09281503e-01f, -1.90419987e-01f, 1.43139809e-01f, 9.70657989e-02f, -5.48607074e-02f, 2.89732330e-02f, -1.60002694e-01f, -3.15779932e-02f, -7.22294897e-02f, 2.89992750e-01f,
  -5.90793453e-02f, -1.28086537e-01f, 1.97169751e-01f, -3.35766561e-02f, -1.73394009e-01f, -4.94736843e-02f, -1.34673268e-01f, -4.06787157e-01f, -2.45089456e-01f, 2.13083997e-01f,
  -9.77151394e-02f, 3.70784491e-01f, 3.41845542e-01f, 1.07380122e-01f, 3.36581439e-01f, -8.75494555e-02f, 3.68813127e-02f, 3.53473499e-02f, -1.12864077e-01f, 3.10108941e-02f,
  1.74821559e-02f, 2.20773309e-01f, 3.41166347e-01f, -1.57081738e-01f, 3.63983721e-01f, -1.67437382e-02f, 1.63639486e-01f, 8.37880298e-02f, 1.19893014e-01f, 2.92752683e-01f,
  6.87203929e-02f, 6.75670356e-02f, -6.06184872e-03f, -1.96851552e-01f, 1.01312548e-01f, -9.51082679e-04f, 2.67513603e-01f, 3.77415359e-01f, 7.13911802e-02f, 2.47688130e-01f,
  2.98862010e-01f, -1.48506179e-01f, 1.82401184e-02f, -7.79344812e-02f, 1.80688649e-02f, 1.80661201e-01f, 1.97353825e-01f, 2.82935083e-01f, 1.29379556e-01f, 3.91150378e-02f,
  3.20870802e-02f, 1.10115968e-02f, 5.92991523e-02f, -4.25684564e-02f, 1.58427685e-01f, 1.42591372e-02f, 5.73353320e-02f, 5.56678735e-02f, -8.71252851e-04f, -1.70947358e-01f,
  -5.19891120e-02f, -1.22261405e-01f, -3.74849021e-01f, 2.43433043e-01f, -1.37080178e-01f, -9.52538662e-03f, 1.47343874e-01f, 1.96299195e-01f, -2.23070532e-01f, -5.62722266e-01f,
  -1.79729581e-01f, -1.35400414e-01f, -3.37590128e-01f, 4.11652178e-01f, -1.79687828e-01f, 4.32318747e-01f, -4.29400876e-02f, 2.03689426e-01f, 2.93653458e-01f, 6.37242049e-02f,
  -1.56294122e-01f, -6.95110410e-02f, -1.69257209e-01f, 2.63684541e-01f, -1.50192991e-01f, -1.74967647e-01f, 3.81544195e-02f, 5.96090294e-02f, 1.90948024e-01f, 9.15149692e-03f,
  3.23389947e-01f, 4.54975456e-01f, -9.83286500e-02f, 2.10638478e-01f, 1.36382729e-01f, -3.38450745e-02f, -1.19052723e-01f, -4.39815447e-02f, 1.20925546e-01f, 2.13254064e-01f,
  2.38150880e-01f, 3.39394659e-01f, 4.24494833e-01f, 3.57091099e-01f, 1.09140694e-01f, 1.60605162e-01f, 2.39898339e-01f, -1.56662658e-01f, -6.65944070e-02f, 1.65447399e-01f,
  6.79751486e-02f, 2.86111310e-02f, 1.33478716e-01f, 1.41452685e-01f, 3.38474363e-02f, -1.40360650e-02f, 1.59833148e-01f, -1.84348047e-01f, 1.27169818e-01f, 2.95432899e-02f,
  -1.90061763e-01f, 1.38134295e-02f, 2.26464838e-01f, -1.01480380e-01f, -3.17176767e-02f, -6.46479148e-03f, -1.12338118e-01f, 2.60770112e-01f, 6.48684204e-02f, -2.63367176e-01f,
  1.79395244e-01f, 1.38652146e-01f, -1.75228715e-01f, -4.26109016e-01f, -2.69844532e-01f, 2.84799993e-01f, -1.33012429e-01f, 2.34665498e-01f, -1.40154004e-01f, 3.32016706e-01f,
  -2.36743644e-01f, 1.08525604e-01f, 8.04914087e-02f, -2.32266247e-01f, -3.57614666e-01f, 2.68472470e-02f, -2.75655389e-01f, -1.04610339e-01f, -1.81153581e-01f, -5.62542956e-03f,
  -1.41105026e-01f, -2.73834523e-02f, 9.31349099e-02f, 3.94167081e-02f, -3.69396918e-02f, 3.87958169e-01f, -3.22881527e-02f, 9.18411016e-02f, -3.29630114e-02f, 4.31716144e-02f,
  -5.77683225e-02f, 3.68302278e-02f, 8.27448294e-02f, -3.50591950e-02f, 6.62520602e-02f, 2.23855358e-02f, -1.53055251e-01f, -1.49718955e-01f, -2.21424982e-01f, 2.44828090e-02f,
  1.10572398e-01f, 2.21806452e-01f, 1.87018439e-01f, -1.78587228e-01f, -7.41550773e-02f, 5.68514951e-02f, -1.77382737e-01f, 1.57037258e-01f, 3.48668188e-01f, -1.14879012e-01f,
  1.63342040e-02f, 2.51660794e-01f, -1.90765485e-01f, -4.33690287e-02f, 2.47480080e-01f, -1.21517345e-01f, 8.30474496e-02f, 1.08884670e-01f, 2.06044167e-01f, -9.36919004e-02f,
  1.01293556e-01f, -1.90756083e-01f, -2.40758255e-01f, 1.42760262e-01f, -2.51445651e-01f, 1.44864228e-02f, 1.90765694e-01f, -3.97613784e-03f, -3.03143948e-01f, 7.75564685e-02f,
  1.02091320e-01f, 4.94354591e-02f, 1.36260614e-01f, 1.74773455e-01f, 1.73984095e-01f, -8.93223062e-02f, 1.05304427e-01f, 2.47285590e-01f, 1.96679428e-01f, -5.45064919e-02f,
  1.63616434e-01f, 3.71589214e-02f, -7.95650855e-02f, -3.70165892e-02f, -8.03823695e-02f, 3.65027189e-01f, -3.88739221e-02f, 1.40126869e-01f, -1.55930430e-01f, 7.53195882e-02f,
  -1.18165784e-01f, 1.12764105e-01f, -6.26442879e-02f, 2.82187760e-01f, -7.32716918e-02f, -5.31980731e-02f, -8.95273909e-02f, -1.46149499e-02f, -3.28100398e-02f, 2.55224649e-02f,
  2.56830245e-01f, 1.38140425e-01f, -5.61019219e-02f, 2.37285629e-01f, 2.52613705e-02f, -1.56519011e-01f, 1.39481388e-02f, 9.77914110e-02f, 2.13655606e-01f, 1.69645976e-02f,
  7.36592039e-02f, -5.41203748e-03f, 1.82265624e-01f, 7.13896975e-02f, 6.26809895e-02f, -3.96622866e-01f, 1.79941565e-01f, -1.66354567e-01f, -2.60403603e-01f, 1.06710002e-01f,
  -1.53231621e-01f, 1.63627267e-01f, 1.03302367e-01f, -1.88234761e-01f, 8.81323814e-02f, 1.19780973e-01f, 2.94633806e-01f, 1.30134583e-01f, 4.31646146e-02f, -2.37715542e-01f,
  -5.74153215e-02f, 5.85044026e-02f, 3.31697732e-01f, 1.15198500e-01f, -1.52187258e-01f, 7.27820098e-02f, 2.35012025e-02f, -9.61726010e-02f, -1.59006506e-01f, 3.15813512e-01f,
  -4.20274258e-01f, -3.53008732e-02f, -1.77324072e-01f, 1.90873481e-02f, 3.57097089e-02f, 1.82662979e-02f, 4.40887481e-01f, -3.91053669e-02f, -1.53942689e-01f, 4.15266640e-02f,
  -1.81049824e-01f, 3.66447419e-01f, 8.86645764e-02f, -2.64650919e-02f, 3.58425409e-01f, 4.15460579e-02f, 4.04432863e-01f, 3.83158661e-02f, -7.69150956e-03f, 1.62255049e-01f,
  3.10143620e-01f, 2.24101990e-01f, 6.79192618e-02f, 2.32797995e-01f, 4.37583864e-01f, 2.01717652e-02f, -7.62118772e-03f, 2.91259527e-01f, 1.34807080e-01f, -2.35359654e-01f,
  1.44462347e-01f, 2.08368197e-01f, -9.06119794e-02f, -1.38759077e-01f, 5.40257730e-02f, -1.53491661e-01f, -8.63982923e-03f, 1.18401103e-01f, 2.94252366e-01f, -4.08028811e-02f,
  -2.22925632e-03f, 7.29630738e-02f, 5.72117716e-02f, 1.38437068e-02f, 3.76463443e-01f, -2.70709306e-01f, -1.67709902e-01f, 1.84182674e-01f, -3.30096096e-01f, 3.44167680e-01f,
  3.32338005e-01f, -2.80895144e-01f, 3.29328507e-01f, 2.14411274e-01f, -3.41961443e-01f, -4.46971059e-02f, 1.18293641e-02f, 2.69766729e-02f, 8.42948258e-02f, 1.23370238e-01f,
  7.52913207e-02f, 2.73902267e-01f, 4.23660815e-01f, -1.33859903e-01f, 3.60007919e-02f, -7.21358135e-02f, 3.27399443e-03f, -1.48311572e-03f, -1.58802286e-01f, -2.72127032e-01f,
  -1.17346391e-01f, -5.38544320e-02f, -8.65631923e-02f, -9.30005964e-03f, 3.01769733e-01f, 3.33069861e-02f, 2.36034811e-01f, 6.35763854e-02f, 2.43841842e-01f, -1.83236763e-01f,
  -3.97506952e-01f, -1.21318713e-01f, -1.02929659e-01f, -2.21837480e-02f, 3.43076140e-02f, 7.66694844e-02f, 2.24653557e-01f, 3.33889723e-02f, -1.34401515e-01f, 1.51538894e-01f,
  2.66537786e-01f, 1.76232144e-01f, 2.46025920e-01f, 8.40560049e-02f, -5.74761853e-02f, 8.10157731e-02f, 4.01092768e-02f, 4.45188023e-02f, 2.09876299e-01f, -6.78430647e-02f,
  1.64903820e-01f, 1.14415899e-01f, 2.64772754e-02f, -1.08332410e-01f, -1.94911167e-01f, 2.34038681e-01f, -2.97745951e-02f, 7.36840963e-02f, 5.46952561e-02f, -9.75505486e-02f,
  9.08856392e-02f, 6.50807023e-02f, -1.27795056e-01f, 3.40487957e-01f, -3.18518318e-02f, -6.89612105e-02f, 2.51269639e-01f, -2.43330076e-01f, -1.42915040e-01f, -1.08871743e-01f,
  -4.17266078e-02f, 2.35100880e-01f, -2.89314181e-01f, 2.79407769e-01f, -4.15238082e-01f, 1.73255503e-01f, -3.19936246e-01f, 4.49041501e-02f, 1.67159602e-01f, 2.83995215e-02f,
  5.84147545e-03f, 4.28131483e-02f, -1.20719686e-01f, -1.08605675e-01f, 4.71151739e-01f, -1.67919964e-01f, -2.91581661e-01f, -1.41485810e-01f, -4.22978913e-03f, 3.39545310e-01f,
  8.59920233e-02f, 9.93023291e-02f, 2.47860223e-01f, -1.24825269e-01f, 1.30418032e-01f, -1.46563694e-01f, -6.12252764e-02f, 8.37999955e-02f, 6.49502799e-02f, 1.44422337e-01f,
  2.76615359e-02f, 3.63124251e-01f, 3.26669484e-01f, 1.88536197e-01f, -5.81699796e-03f, -3.19108129e-01f, 2.29146495e-01f, -1.57821253e-01f, 1.60260409e-01f, -2.72253752e-02f,
  2.35349946e-02f, 2.62876451e-01f, 2.57391334e-01f, 2.39465192e-01f, 5.53651191e-02f, -1.55733526e-01f, -1.19506441e-01f, 1.00136034e-01f, 5.82193770e-02f, -1.06940001e-01f,
  7.46512562e-02f, -9.92699116e-02f, 2.15986714e-01f, -2.64299721e-01f, -1.72750801e-01f, 6.35450110e-02f, -1.38445750e-01f, 2.81660378e-01f, -1.20342575e-01f, 2.95738965e-01f,
  -1.04305990e-01f, 1.72405243e-02f, 1.63161010e-02f, 1.04337931e-02f, -7.42543265e-02f, 3.03484648e-01f, -2.10107073e-01f, 4.90112156e-02f, -1.72110304e-01f, 2.04462841e-01f,
  2.82850005e-02f, -9.96007468e-04f, -3.27993780e-01f, 2.61064708e-01f, 2.46153146e-01f, 2.08222330e-01f, -2.23200351e-01f, 1.48490757e-01f, 5.24118096e-02f, -1.25807345e-01f,
  5.80933057e-02f, 4.69289161e-02f, -1.44679353e-01f, 1.61657631e-01f, 1.06182240e-01f, 2.60730028e-01f, 1.90453291e-01f, -1.33642972e-01f, 4.38301228e-02f, -1.01104856e-01f,
  1.08621523e-01f, 2.49480069e-01f, -2.58381873e-01f, 3.38010676e-02f, 2.67985258e-02f, -3.91127080e-01f, 2.05817550e-01f, -3.37177277e-01f, -2.19593316e-01f, 1.13122657e-01f,
  -9.19824392e-02f, 1.03998840e-01f, -1.34554550e-01f, 2.88398385e-01f, 9.96725559e-02f, 3.97663936e-02f, 6.87498525e-02f, 1.36755541e-01f, 3.62455435e-02f, 2.38390803e-01f,
  2.95885652e-02f, 1.11104503e-01f, 9.08555910e-02f, -1.48264021e-01f, 8.14864263e-02f, 4.36260104e-02f, 5.85509874e-02f, -1.31131932e-01f, 6.58508241e-02f, -2.71685570e-02f,
  1.10572912e-01f, -8.14440381e-03f, 7.14188740e-02f, -1.50063768e-01f, 5.06653339e-02f, -3.43962014e-01f, 1.71155464e-02f, 3.70298177e-01f, 3.72481883e-01f, 6.59112707e-02f,
  3.88382971e-01f, -9.60334614e-02f, 2.49291748e-01f, -1.67171225e-01f, 1.23542592e-01f, 1.01307191e-01f, -4.02139455e-01f, 1.47122666e-01f, 1.12999231e-01f, 1.04562454e-01f,
  6.08261675e-02f, -9.79028568e-02f, 4.06422406e-01f, 2.48582199e-01f, -1.21888593e-01f, 1.43876314e-01f, 4.95564286e-03f, 1.92927346e-01f, 8.80090818e-02f, -2.70982087e-01f,
  4.04135823e-01f, -5.29739168e-03f, -2.92166434e-02f, 2.09129184e-01f, 1.99264050e-01f, 2.40982577e-01f, 1.75010160e-01f, 3.49296778e-01f, 1.35904536e-01f, -7.57693052e-02f,
  8.01577717e-02f, -2.15153039e-01f, 6.88033029e-02f, -9.12144408e-02f, -1.08310096e-01f, -1.48845106e-01f, 1.18979461e-01f, 3.45866755e-02f, -1.98108107e-01f, 4.05407138e-03f,
  -1.38295412e-01f, 3.60092893e-02f, -7.33864233e-02f, -1.90986484e-01f, 1.72410905e-01f, 2.60245413e-01f, 2.00747624e-02f, -3.09323072e-01f, 2.91535378e-01f, -1.37868866e-01f,
  2.10265994e-01f, -4.08157349e-01f, -1.79607436e-01f, 1.40397877e-01f, -8.38881209e-02f, -7.42097059e-03f, 2.06342936e-02f, -6.39219489e-03f, 1.51717931e-01f, 2.31124058e-01f,
  -1.03340507e-01f, 1.09407373e-01f, 2.65027642e-01f, -1.84320882e-01f, -1.81130812e-01f, -8.74593109e-02f, -3.58536601e-01f, -1.96616158e-01f, 3.10247332e-01f, 2.37202197e-01f,
  6.53143823e-02f, -1.93182752e-01f, -6.18649013e-02f, 1.08601220e-01f, 1.41822219e-01f, 2.25849319e-02f, 8.73091146e-02f, 1.41444042e-01f, 1.98150486e-01f, -2.78459877e-01f,
  2.19163090e-01f, -2.10552484e-01f, 1.51890591e-01f, -2.56694674e-01f, 8.52245316e-02f, 1.83528334e-01f, 4.21158001e-02f, -3.33623618e-01f, 2.58703623e-03f, -3.80537808e-02f,
  -4.64669317e-02f, 2.26126924e-01f, 2.33104303e-01f, -9.95449163e-03f, -2.84918398e-01f, -6.25668615e-02f, -2.67259330e-01f, 1.49252430e-01f, 1.61144435e-02f, -1.01762051e-02f,
  -1.06130108e-01f, 2.36976087e-01f, -7.01218545e-02f, -9.82849672e-02f, -4.77765292e-01f, -5.58317900e-02f, 1.03888795e-01f, 1.16350435e-01f, 2.99302232e-03f, 1.34410962e-01f,
  1.42090723e-01f, -2.27318972e-01f, 4.41720784e-02f, 5.81837483e-02f, 8.00920203e-02f, -9.99573693e-02f, 3.72620970e-02f, 5.28537808e-03f, 1.47494167e-01f, -4.73665386e-01f,
  -1.07997127e-01f, -1.45370260e-01f, 2.60520250e-01f, 6.96170703e-02f, 1.88002869e-01f, -2.09247276e-01f, 1.62104994e-01f, -4.49475318e-01f, 7.94345960e-02f, -5.34224175e-02f,
  3.46130311e-01f, -4.31642169e-03f, -3.85221988e-01f, 2.63408870e-01f, 5.56842573e-02f, -8.86218250e-02f, 1.17711939e-01f, 5.44716232e-02f, 6.25280961e-02f, 1.88740611e-01f,
  -3.35559368e-01f, 4.03705649e-02f, 1.41045332e-01f, 1.21570520e-01f, 2.26334810e-01f, -1.31191984e-01f, 8.08400139e-02f, -2.23017596e-02f, -1.64986163e-01f, 2.66901225e-01f,
  7.52685666e-02f, 8.94558150e-03f, 8.27261731e-02f, -2.09332764e-01f, 1.59442678e-01f, 2.07577854e-01f, 2.15317011e-02f, 1.04181252e-01f, 1.90659150e-01f, 3.17473710e-02f,
  -1.08683184e-01f, -1.11176170e-01f, 1.45989701e-01f, 8.85218382e-02f, -1.17321387e-01f, -2.19557017e-01f, 1.81648627e-01f, -3.29112560e-02f, 9.61898416e-02f, 1.64242238e-01f,
  -3.70221026e-02f, 4.70045656e-02f, 1.55886695e-01f, -2.45997339e-01f, -9.59170610e-03f, -2.67552108e-01f, -5.90877831e-02f, 2.31127460e-02f, -6.67212233e-02f, 2.38718569e-01f,
  -3.84759419e-02f, -2.51109421e-01f, 3.06631267e-01f, 1.95817307e-01f, -1.16931118e-01f, 1.72805279e-01f, -1.19922593e-01f, -2.22324535e-01f, 1.60933197e-01f, 1.57948762e-01f,
  1.69553105e-02f, -1.98555171e-01f, 1.97463170e-01f, 5.16367257e-02f, 4.28119153e-01f, -1.19486108e-01f, 6.34179041e-02f, 1.49619877e-01f, -3.02155763e-01f, 1.57417189e-02f,
  1.00474637e-02f, -1.50015920e-01f, 1.14260346e-01f, -1.33989677e-01f, 2.25864142e-01f, 2.03843832e-01f, 6.87783118e-03f, 2.51329303e-01f, -7.96796829e-02f, 2.03865305e-01f,
  -1.01103321e-01f, 1.17147051e-01f, 3.45145762e-01f, 9.19116959e-02f, 1.08810976e-01f, 1.78514525e-01f, 4.62625660e-02f, -7.54841119e-02f, -1.03731960e-01f, -2.61385560e-01f,
  8.63487832e-03f, -8.33294243e-02f, -2.87124336e-01f, -6.07166141e-02f, -2.92914063e-01f, 9.28528756e-02f, -4.81991544e-02f, 3.17942262e-01f, -1.09180421e-01f, 3.09215598e-02f,
  2.96578288e-01f, 1.29349589e-01f, -2.16673821e-01f, 2.83618748e-01f, 1.58614554e-02f, 1.07689023e-01f, -5.44443503e-02f, 2.42978800e-02f, -1.74202062e-02f, -9.12888646e-02f,
  1.11401752e-01f, 2.39571240e-02f, 2.49573499e-01f, 1.91364631e-01f, 1.48084328e-01f, 1.62748739e-01f, 2.22437024e-01f, -3.00128162e-01f, -2.61537522e-01f, -1.20209761e-01f,
  -1.66668251e-01f, -1.74882561e-01f, 4.38940665e-03f, 4.79886644e-02f, -2.59694338e-01f, -5.23969047e-02f, 3.38120133e-01f, -4.12596092e-02f, 1.71939179e-01f, 1.62523225e-01f,
  -3.06788627e-02f, -2.57383361e-02f, 9.64003950e-02f, 2.39353185e-03f, 5.72476052e-02f, -2.72064842e-02f, 7.94752687e-02f, -5.21437302e-02f, -4.09733564e-01f, 1.24990642e-01f,
  1.55048281e-01f, 2.57414907e-01f, 1.35226086e-01f, -9.37713757e-02f, -1.50121041e-02f, -5.16847670e-02f, -1.97601900e-01f, 2.32738271e-01f, -1.52832001e-01f, 2.71074206e-01f,
  1.45797715e-01f, -3.02991778e-01f, -6.26265556e-02f, 7.00440705e-02f, 3.42326909e-02f, 1.77381653e-02f, 2.56052613e-01f, 3.04182142e-01f, -3.36155891e-01f, 7.89502785e-02f,
  -8.59552901e-03f, 3.69947031e-02f, -2.91781109e-02f, 2.61117518e-01f, 4.29649830e-01f, 6.93359897e-02f, 6.87361807e-02f, 1.53410241e-01f, -7.32027590e-02f, 1.82168379e-01f,
  -1.22544933e-02f, -2.52355337e-01f, 6.22593425e-02f, 2.56714404e-01f, -4.15513903e-01f, 9.47572812e-02f, -1.62182525e-01f, 9.88879427e-02f, 3.86829644e-01f, -2.24628568e-01f,
  -4.69343625e-02f, -3.99730913e-02f, 8.39159116e-02f, -1.27089238e-02f, 1.57421038e-01f, -1.00002103e-01f, 8.24992731e-02f, 2.90969074e-01f, -2.55372617e-02f, 1.18982486e-01f,
  -3.10915649e-01f, -4.05283906e-02f, -2.13177390e-02f, -1.15932025e-01f, -4.65319633e-01f, 1.18942767e-01f, -2.48926088e-01f, 3.56278755e-03f, -1.12669870e-01f, 2.56222963e-01f,
  -1.15557984e-01f, -4.23655696e-02f, 2.20231622e-01f, 1.13226324e-01f, 4.02735285e-02f, -5.58742285e-02f, -2.53427029e-01f, 1.94399014e-01f, -1.33781001e-01f, 9.80560407e-02f,
  8.80795270e-02f, 1.91575155e-01f, 8.50836560e-02f, -5.32381907e-02f, 1.12277798e-01f, 2.75068462e-01f, 1.01544283e-01f, 7.04899281e-02f, 1.44950431e-02f, 2.28992030e-01f,
  -2.00511180e-02f, 8.24454874e-02f, 1.87187433e-01f, 4.01087463e-01f, 7.40848482e-02f, 2.61633098e-01f, 1.17761843e-01f, 2.04956964e-01f, 6.12254208e-03f, -1.41616791e-01f,
  -6.33850545e-02f, 8.04473609e-02f, 1.49676144e-01f, 2.91227192e-01f, 1.48139447e-01f, 1.41064197e-01f, -1.84156820e-01f, 3.90679955e-01f, 3.69990692e-02f, 1.90182782e-05f,
  1.56513944e-01f, -1.48013726e-01f, 4.73565578e-01f, 3.79760802e-01f, -2.10321203e-01f, -6.03485517e-02f, 1.54312581e-01f, -9.31280106e-02f, 2.40793258e-01f, 2.29424566e-01f,
  -4.35066849e-01f, 1.32655680e-01f, -2.57094175e-01f, 3.12645942e-01f, 1.36789724e-01f, 1.41464218e-01f, -2.41445825e-01f, 1.17492817e-01f, -2.75693208e-01f, -1.88186228e-01f,
  2.71797061e-01f, -7.39189312e-02f, 3.22654396e-01f, 9.31350365e-02f, 1.66973203e-01f, 1.34650216e-01f, 1.37470961e-01f, -2.84999721e-02f, -1.15483768e-01f, 5.36532179e-02f,
  9.34642926e-02f, -1.12026088e-01f, 1.36535019e-02f, 4.37529124e-02f, 7.95749500e-02f, -2.87627488e-01f, 4.77576628e-02f, 1.06759436e-01f, 9.08808708e-02f, 1.26535356e-01f,
  2.18213582e-03f, 4.88791503e-02f, -9.93060991e-02f, -1.55843511e-01f, 3.96970659e-02f, 1.45512670e-01f, 3.14493515e-02f, 9.33193341e-02f, 6.96519017e-02f, 2.24156544e-01f,
  9.66578797e-02f, 1.91542599e-02f, -6.69587357e-03f, -1.81589779e-02f, -4.68738116e-02f, 3.61038814e-03f, -1.63573906e-01f, 1.78279102e-01f, 3.33853741e-03f, -2.61778325e-01f,
  1.55340552e-01f, -2.19626665e-01f, -1.78827137e-01f, -6.15318865e-02f, -4.74372685e-01f, 3.88519704e-01f, 4.95592028e-01f, -2.50201672e-01f, -1.74567088e-01f, -4.39392123e-03f,
  -1.25779733e-01f, 2.35778466e-01f, 2.24818930e-01f, 1.40104339e-01f, -7.98787326e-02f, -8.78652409e-02f, -2.36569911e-01f, 8.40066299e-02f, 1.15714744e-01f, 8.92890021e-02f,
  2.84342915e-01f, 5.81065789e-02f, -2.66591698e-01f, 2.21163467e-01f, -8.82750303e-02f, -5.40218167e-02f, -1.88307688e-01f, -2.43870705e-01f, -2.91215279e-03f, 1.84859931e-01f,
  -1.01691838e-02f, -8.58732387e-02f, -1.21399395e-01f, -6.08969443e-02f, -1.70795843e-01f, 1.77655816e-01f, -4.01182204e-01f, 1.89997688e-01f, 4.97712903e-02f, 1.76402315e-01f,
  3.28472137e-01f, 2.28680044e-01f, -3.53244990e-02f, -3.06209147e-01f
};

// L3_fan_Bp_bar (Shape: 1 x 26)
const int L3_fan_Bp_bar_rows = 1;
const int L3_fan_Bp_bar_cols = 26;
const float L3_fan_Bp_bar_data[] = {
  1.34508133e-01f, 1.58314958e-01f, 1.06137030e-01f, 3.37878102e-03f, 1.15286693e-01f, 1.57915771e-01f, -1.96571164e-02f, 1.64099425e-01f, 1.76356643e-01f, -1.23980261e-01f,
  8.23223516e-02f, 1.96608037e-01f, 1.59506977e-01f, 6.05735742e-02f, 9.88830402e-02f, 2.09911587e-03f, 7.69346207e-02f, 1.53124377e-01f, -3.78561020e-02f, 1.64299812e-02f,
  1.10043779e-01f, 8.74116346e-02f, 4.70006615e-02f, 1.41772643e-01f, 9.06424746e-02f, 9.42130610e-02f
};

// L4_linear_W (Shape: 12 x 64)
const int L4_linear_W_rows = 12;
const int L4_linear_W_cols = 64;
const float L4_linear_W_data[] = {
  -9.73366052e-02f, -3.39856267e-01f, -9.58327949e-02f, -7.95906223e-03f, 2.21284345e-01f, 1.65278569e-01f, -9.86211374e-02f, -9.49319452e-02f, 1.15415156e-01f, -5.89171648e-02f,
  3.71029601e-02f, 2.37735882e-01f, -3.56721655e-02f, -2.48858050e-01f, -8.03021044e-02f, -8.03794637e-02f, -8.48372281e-02f, 1.26049191e-01f, -2.20562011e-01f, -1.13003850e-01f,
  -1.33547276e-01f, 3.88624072e-01f, -2.98655480e-01f, 2.25833669e-01f, -6.11213073e-02f, -6.35731034e-03f, 1.55850902e-01f, 4.39709574e-02f, -1.90990791e-01f, -1.57355875e-01f,
  6.41639158e-02f, 3.68381739e-01f, -8.36797953e-02f, 1.19137783e-02f, 7.97160938e-02f, 1.64292648e-01f, -6.98775947e-02f, 1.40783593e-01f, -2.82385141e-01f, -1.96979478e-01f,
  -1.76180288e-01f, -3.12817752e-01f, 1.29373325e-02f, -5.45130000e-02f, -1.38524577e-01f, -8.25011656e-02f, -6.37151361e-01f, 1.15892336e-01f, 1.43296689e-01f, -2.48554483e-01f,
  -2.79818654e-01f, -2.75974005e-01f, 1.93424329e-01f, -4.16698843e-01f, 9.27344933e-02f, -3.44300389e-01f, 1.77519485e-01f, -3.63216162e-01f, -2.53869444e-01f, 1.58098921e-01f,
  -1.26251742e-01f, 1.52493954e-01f, -5.01428451e-03f, 1.84589162e-01f, -1.27904536e-02f, 8.19213092e-02f, 1.65879369e-01f, -1.90190047e-01f, -1.79013480e-02f, -1.09895289e-01f,
  1.21563740e-01f, -7.72332624e-02f, -1.27638146e-01f, -5.89107350e-02f, -1.53785124e-01f, -1.89248547e-01f, -4.20745648e-02f, -7.60544613e-02f, 9.45820212e-02f, -4.43284884e-02f,
  4.34254557e-02f, 1.04764886e-01f, -2.35898420e-02f, 8.13947022e-02f, 2.30810344e-02f, -1.46825954e-01f, 4.54251170e-02f, 3.78282778e-02f, 1.70011297e-01f, 7.41236582e-02f,
  -2.74997830e-01f, -1.25100568e-01f, -1.20917881e-04f, -1.71363741e-01f, 6.68629110e-02f, 8.62648860e-02f, 1.94779441e-01f, 4.69073839e-02f, -1.38576001e-01f, 6.74824938e-02f,
  2.92512635e-03f, 5.11522591e-02f, -4.13038671e-01f, 1.27275109e-01f, -4.55288321e-01f, 2.05551043e-01f, 2.28594154e-01f, -3.30282271e-01f, 2.04458222e-01f, -1.01067252e-01f,
  -1.40494257e-01f, -2.54032075e-01f, -3.68067086e-01f, -2.64098138e-01f, 2.67086998e-02f, -1.94046170e-01f, 1.33735016e-01f, 1.39010906e-01f, 7.94690400e-02f, 1.30389199e-01f,
  1.62768647e-01f, -7.98588917e-02f, -1.12008587e-01f, -2.60250233e-02f, -2.74999470e-01f, 2.90735841e-01f, 3.06404203e-01f, -2.55843848e-01f, -5.77036031e-02f, 6.85360953e-02f,
  2.91437712e-02f, -6.96566403e-02f, -1.50942490e-01f, 4.67343666e-02f, -2.08693579e-01f, 1.99241638e-01f, 4.66439687e-02f, 1.98494598e-01f, -2.25093383e-02f, -1.14491573e-02f,
  2.67830610e-01f, 1.40759230e-01f, -1.09672144e-01f, 1.50076381e-03f, -8.40393752e-02f, 6.45504594e-02f, -2.00846940e-01f, 2.32073724e-01f, -1.50396183e-01f, 4.88325119e-01f,
  -2.50245482e-01f, -6.42189011e-02f, 1.59238189e-01f, -3.35404463e-02f, 1.40585769e-02f, -2.17448696e-01f, -1.16678692e-01f, -1.56788737e-01f, 2.09141180e-01f, -2.35721290e-01f,
  3.37945431e-01f, -1.21991076e-01f, -4.52685878e-02f, 3.28299366e-02f, 3.23662907e-01f, 1.72243834e-01f, 7.83668235e-02f, -6.03700280e-01f, -1.46926567e-01f, -2.92131841e-01f,
  1.93488151e-01f, 3.09468836e-01f, -2.20527232e-01f, -3.62759680e-01f, -6.46964848e-01f, 5.07156132e-03f, 1.09251939e-01f, 1.95938155e-01f, -2.35802799e-01f, 1.18697807e-01f,
  -2.08756164e-01f, -3.56958210e-01f, 1.25420555e-01f, 2.82988340e-01f, -1.65976807e-01f, 2.26681270e-02f, -7.02328756e-02f, -1.90415964e-01f, -3.46326739e-01f, -1.55276269e-01f,
  1.07540019e-01f, -1.31226420e-01f, -1.76326632e-01f, 1.37357593e-01f, -3.84090133e-02f, -1.28531799e-01f, 1.09872721e-01f, 6.54377043e-02f, -6.17064983e-02f, 2.81766444e-01f,
  -6.11167476e-02f, 9.89603773e-02f, 1.61786109e-01f, 2.82234885e-03f, 9.80057642e-02f, -1.98737592e-01f, -1.90739725e-02f, -2.60278042e-02f, -2.58365124e-01f, -1.84545085e-01f,
  2.11529583e-01f, -3.78373414e-02f, -2.64723271e-01f, -1.57395050e-01f, 2.43570358e-01f, 1.35177523e-01f, -1.00135125e-01f, 6.04300313e-02f, -2.43048564e-01f, 1.42285988e-01f,
  -1.99471831e-01f, -2.11504493e-02f, -1.34806380e-01f, 9.66381952e-02f, -1.24142796e-01f, -1.06960878e-01f, 8.46608207e-02f, -2.08452284e-01f, -2.39367142e-01f, 9.94799063e-02f,
  1.07978411e-01f, -4.88948286e-01f, 1.72251672e-01f, -2.76575387e-01f, -6.19460940e-01f, 4.15816754e-02f, -3.11856657e-01f, -1.94208324e-01f, 8.29491124e-04f, 4.92696054e-02f,
  1.40339360e-01f, 7.00609088e-02f, 4.98395897e-02f, 9.38177705e-02f, -1.00696899e-01f, -1.75359547e-01f, -2.37446949e-01f, -3.73139292e-01f, -4.68072504e-01f, -1.75981238e-01f,
  2.49234483e-01f, 7.64755309e-02f, 2.22721070e-01f, 2.12654639e-02f, -3.95376265e-01f, 1.18865982e-01f, -1.29997563e-02f, 1.85719147e-01f, -1.71015948e-01f, 2.21920118e-01f,
  -2.05286548e-01f, -3.03609610e-01f, 4.21493314e-02f, -4.11926694e-02f, -3.48267078e-01f, -2.26944089e-01f, -2.04903651e-02f, -4.13633883e-02f, -1.75132230e-01f, 5.89079000e-02f,
  1.85319632e-01f, -4.08585705e-02f, 1.43755168e-01f, -1.77395374e-01f, -1.14511512e-01f, 2.37676755e-01f, 1.31132556e-02f, -5.04024982e-01f, -1.97044626e-01f, -1.03978164e-01f,
  1.02164857e-01f, -1.56968549e-01f, -8.02476518e-03f, 5.36713861e-02f, 1.10123403e-01f, 4.10616755e-01f, -1.79376259e-01f, -1.33518055e-01f, -2.42344439e-01f, 1.66738316e-01f,
  -2.66229928e-01f, 8.27928334e-02f, -1.43456697e-01f, 1.18636176e-01f, 1.28105178e-01f, -7.70178810e-02f, -2.60353070e-02f, -3.60012650e-01f, -3.52716297e-01f, 8.68113562e-02f,
  -1.15518942e-01f, 1.00023337e-01f, 1.20174028e-01f, 1.91446006e-01f, 2.85307895e-02f, 1.93421170e-01f, 1.64846048e-01f, -1.64314061e-01f, 8.34013745e-02f, -2.59496421e-01f,
  8.23554248e-02f, 1.89259395e-01f, -1.67523637e-01f, -2.75049478e-01f, -2.89776027e-01f, 3.03652994e-02f, -4.50703710e-01f, 2.00257391e-01f, -1.37189344e-01f, 2.23007083e-01f,
  -8.06456804e-02f, 9.20217186e-02f, 2.36327723e-01f, 1.42557874e-01f, -6.20456273e-03f, 2.21090108e-01f, -8.54982901e-03f, -7.65181854e-02f, -1.39812315e-02f, -7.37623349e-02f,
  1.91355228e-01f, 1.63740918e-01f, -2.63401717e-01f, 5.90397976e-02f, 8.02015439e-02f, -7.96997324e-02f, 1.04000755e-01f, 2.10488230e-01f, 1.41898960e-01f, -7.00827837e-02f,
  1.79488093e-01f, -1.73692852e-01f, 3.45740676e-01f, 5.93519118e-03f, 1.69691607e-01f, 3.07639897e-01f, -6.78266138e-02f, 2.53564954e-01f, 1.24401949e-01f, -1.24053963e-01f,
  -3.13015580e-01f, -5.53640500e-02f, -3.16929430e-01f, -6.67727971e-03f, -2.94836074e-01f, 2.48101771e-01f, 6.87759072e-02f, 2.22310215e-01f, -2.78607965e-01f, -1.69084340e-01f,
  2.89078534e-01f, 1.31163195e-01f, -1.69329450e-01f, -1.11666389e-01f, -1.84676230e-01f, -4.15539086e-01f, -1.37122646e-01f, -2.46664390e-01f, 1.44698888e-01f, 9.54256952e-03f,
  2.66364720e-02f, -1.92810893e-02f, 1.08430818e-01f, 2.36402869e-01f, 2.34155189e-02f, 1.36498392e-01f, 1.74818024e-01f, 4.66899946e-03f, -4.02586520e-01f, 1.63002878e-01f,
  -1.26501799e-01f, 2.36706901e-02f, -3.80216300e-01f, -3.22002292e-01f, 1.23355031e-01f, -3.33277315e-01f, 1.00922614e-01f, -8.01562965e-02f, 2.42425084e-01f, 1.33134231e-01f,
  -9.18709189e-02f, -1.49406224e-01f, -1.32329151e-01f, -4.99703512e-02f, 8.63115129e-05f, 6.03756942e-02f, -1.97446436e-01f, -9.00476724e-02f, -1.76182479e-01f, -3.30553800e-01f,
  1.01210766e-01f, -6.61026239e-02f, 2.35293001e-01f, 1.73744798e-01f, 3.08252633e-01f, 3.72109234e-01f, 3.08776964e-02f, 7.69108981e-02f, -1.69251949e-01f, 7.89986178e-02f,
  -1.05386183e-01f, 1.65636733e-01f, 2.67542034e-01f, 2.87152678e-01f, -3.36135775e-01f, -2.38229752e-01f, 1.21365212e-01f, -1.16084525e-02f, -1.77368689e-02f, -2.69655585e-01f,
  1.80070892e-01f, -2.67747659e-02f, 1.09688960e-01f, 2.55518138e-01f, -3.46632808e-01f, 1.94551691e-01f, 2.21255347e-01f, 1.03390224e-01f, -1.73616797e-01f, 1.53129250e-01f,
  8.08665412e-04f, -3.26816827e-01f, -9.00381878e-02f, -4.46129553e-02f, -3.43029708e-01f, 2.32510231e-02f, -5.38062565e-02f, -8.07511955e-02f, -2.63163418e-01f, -1.13380797e-01f,
  -9.54003334e-02f, -8.15975294e-02f, -1.85149219e-02f, -2.08577827e-01f, 1.19840130e-01f, -1.90826267e-01f, 2.78662056e-01f, -3.67836237e-01f, -2.55219340e-01f, 8.20012838e-02f,
  5.98525852e-02f, -2.69177947e-02f, -1.63692236e-01f, -1.18470870e-01f, 4.07609083e-02f, 1.43105447e-01f, -1.51449397e-01f, -2.53107071e-01f, -1.57000706e-01f, -3.58462669e-02f,
  -1.93098158e-01f, -5.74651398e-02f, -1.44588262e-01f, 1.15542142e-02f, 5.18861935e-02f, -4.63442206e-02f, -2.96465307e-01f, -6.12899102e-02f, -2.21598297e-01f, -1.48590386e-01f,
  -1.99461624e-01f, -1.72990426e-01f, -1.95715353e-01f, -7.43856430e-02f, 5.10523431e-02f, -1.29848674e-01f, 1.26353621e-01f, -3.94772083e-01f, 1.59597665e-01f, -9.46641639e-02f,
  1.30730286e-01f, 1.41793862e-02f, -1.18785374e-01f, -2.55872328e-02f, 1.42050952e-01f, 2.07604319e-02f, -1.15485311e-01f, 1.40470058e-01f, -4.64895628e-02f, -2.66227156e-01f,
  -2.94548810e-01f, -2.20382169e-01f, 1.60069942e-01f, 1.24153867e-01f, 2.09827960e-01f, -1.84255883e-01f, -1.49962887e-01f, -5.30275643e-01f, -1.90567866e-01f, 2.13230513e-02f,
  -3.32356423e-01f, -2.49189675e-01f, -2.44582385e-01f, -5.76844327e-02f, 2.52459347e-01f, -2.09157541e-01f, 1.01527788e-01f, 7.32005090e-02f, 2.06975758e-01f, 4.18407954e-02f,
  -3.01168591e-01f, -1.85658738e-01f, 1.61731988e-01f, 2.06290796e-01f, -5.23332972e-03f, -9.41442400e-02f, -1.96445994e-02f, 1.28039764e-02f, -1.25473887e-01f, 1.71930082e-02f,
  3.55951011e-01f, 1.31931633e-01f, 2.26679593e-01f, 2.41670474e-01f, 1.17073674e-02f, 2.17315257e-01f, 7.61320442e-02f, 2.78592259e-02f, -2.15230629e-01f, 5.81804551e-02f,
  1.31256834e-01f, 1.30771726e-01f, 1.46695329e-02f, 1.38838619e-01f, -3.11137497e-01f, -3.18545014e-01f, -2.28392065e-01f, -4.74098951e-01f, 5.57231724e-01f, -1.56652346e-01f,
  2.15102643e-01f, -1.49505317e-01f, 1.85319051e-01f, 6.36671260e-02f, 6.45672381e-02f, 4.68728423e-01f, 3.89436185e-01f, 3.52392226e-01f, -1.57660425e-01f, -2.53617644e-01f,
  -2.73956001e-01f, -8.26158971e-02f, -4.66049463e-02f, -1.87952258e-02f, 1.55831188e-01f, -1.64627463e-01f, 3.34861815e-01f, -1.25522062e-01f, 2.77174562e-01f, -5.11170132e-03f,
  1.30310372e-01f, -3.26962233e-01f, -2.83314347e-01f, -2.74605542e-01f, -6.23640597e-01f, 2.27997541e-01f, -5.02195537e-01f, 4.62932996e-02f, 2.90108360e-02f, 2.81800926e-01f,
  -1.42571375e-01f, -3.61220300e-01f, -2.46851236e-01f, -2.17149690e-01f, 1.33840919e-01f, -8.31897464e-03f, 1.95445985e-01f, 1.28120720e-01f, 1.68769538e-01f, -1.60978422e-01f,
  1.25060827e-01f, -1.01279095e-01f, -9.12237316e-02f, -1.71563238e-01f, 4.84264791e-02f, 2.07980126e-02f, 2.01722071e-01f, -1.07214458e-01f, 1.34574752e-02f, -5.20129949e-02f,
  -3.50575075e-02f, 2.44178966e-01f, 3.54336686e-02f, -1.98827147e-01f, 3.51632126e-02f, -3.81815374e-01f, 2.57713705e-01f, -2.12005287e-01f, -2.43309021e-01f, 4.94238473e-02f,
  1.83084279e-01f, 2.26255044e-01f, 2.37190604e-01f, -2.35169679e-01f, -4.15901989e-02f, 3.29603881e-01f, 1.84791297e-01f, 7.42788985e-02f, -2.13097021e-01f, -1.47216856e-01f,
  2.13110358e-01f, -7.63126612e-02f, 2.01335877e-01f, -1.83658198e-01f, 1.89330488e-01f, 1.55496180e-01f, -3.86753748e-03f, -2.67427534e-01f, -6.75136894e-02f, 1.93958551e-01f,
  2.42285147e-01f, -9.63335335e-02f, -2.95860797e-01f, 1.65996626e-01f, -5.04619002e-01f, -1.54965833e-01f, -1.73141539e-01f, 2.09706962e-01f, -1.65492803e-01f, -2.04063013e-01f,
  -2.85439581e-01f, 4.83589508e-02f, -8.14024061e-02f, -1.27131522e-01f, 1.87528599e-02f, 2.38383308e-01f, -3.32706757e-02f, -4.49286759e-01f, 6.27742196e-03f, 1.57469600e-01f,
  -2.45904438e-02f, -1.53197035e-01f, 1.64902270e-01f, 4.31683697e-02f, -2.96412967e-03f, -1.50701344e-01f, 2.04701021e-01f, 1.44224733e-01f, 7.24959671e-02f, 6.02289177e-02f,
  -4.33147624e-02f, 1.07524961e-01f, 1.53378025e-01f, 6.11093529e-02f, -1.26386672e-01f, 5.66930957e-02f, 6.62982762e-02f, -1.35873079e-01f, 2.26157457e-01f, 1.34789243e-01f,
  1.71080634e-01f, -2.07504928e-01f, 2.09392682e-01f, -2.14715332e-01f, 1.79509774e-01f, -6.83421120e-02f, 1.11681059e-01f, 2.78497815e-01f, -1.90485373e-01f, 2.39693299e-01f,
  5.35357334e-02f, 1.75945610e-01f, -3.36688429e-01f, 3.97935748e-01f, 2.45748013e-01f, -2.33114302e-01f, -2.27856323e-01f, 1.09601960e-01f, 5.45374900e-02f, -1.13489971e-01f,
  -1.75391287e-01f, 1.84701145e-01f, -3.65052372e-01f, -2.38169968e-01f, -2.16853082e-01f, -8.11802130e-03f, -2.25107133e-01f, -2.62667477e-01f, 1.56190023e-01f, 2.46032313e-01f,
  3.86793554e-01f, -8.59930515e-02f, -4.05025214e-01f, 3.38757634e-01f, 8.02771151e-02f, -1.63716763e-01f, -4.38279301e-01f, -7.45819509e-02f, -3.69205065e-02f, -3.87188524e-01f,
  -6.95093423e-02f, -3.67967099e-01f, 2.96092778e-01f, -1.03905365e-01f, 1.46384118e-02f, 1.08136863e-01f, -6.45475984e-02f, 1.55967757e-01f, 2.06066996e-01f, -3.68593223e-02f,
  8.32628608e-02f, 1.56012714e-01f, -2.38162905e-01f, 9.96972024e-02f, 1.04589194e-01f, -2.84355819e-01f, 1.12386025e-01f, -3.77645977e-02f, -2.90112831e-02f, 4.43836488e-02f,
  -1.93690471e-02f, 6.62056133e-02f, -2.39925608e-01f, -2.98170388e-01f, 1.66247621e-01f, -3.94705534e-01f, 3.08958352e-01f, 1.73840001e-01f, -2.68384933e-01f, 9.46901292e-02f,
  1.97707340e-01f, 2.17600837e-02f, -2.38657430e-01f, -1.82941988e-01f, 7.58785680e-02f, 2.73454785e-01f, 1.92633182e-01f, -6.39511347e-02f, 2.36905903e-01f, 8.13877732e-02f,
  1.06003284e-01f, 1.18170910e-01f, -5.29688932e-02f, -4.80862744e-02f, 1.95985124e-01f, 2.24625796e-01f, -1.16802767e-01f, -2.93261021e-01f, -5.72400928e-01f, 2.52332211e-01f,
  7.49981552e-02f, -1.21267654e-01f, 9.47106183e-02f, 6.19181432e-02f, -2.13132113e-01f, -2.78439254e-01f, -1.48348644e-01f, -1.89394504e-01f, -1.64999962e-01f, -7.94164464e-02f,
  -6.50273785e-02f, 2.68340290e-01f, 2.33371556e-01f, -3.83146882e-01f, -1.73830181e-01f, -1.04460821e-01f, -2.72849321e-01f, -1.36387736e-01f
};

// L4_linear_B (Shape: 1 x 12)
const int L4_linear_B_rows = 1;
const int L4_linear_B_cols = 12;
const float L4_linear_B_data[] = {
  -1.05379120e-01f, 3.90790813e-02f, -7.72770494e-02f, -7.01508224e-02f, -2.03095600e-02f, 1.24236032e-01f, -8.75415429e-02f, 2.15986595e-02f, -1.91992186e-02f, -1.48304841e-02f,
  1.06375076e-01f, 2.84016281e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 19, 26
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        64, 19, 26
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        64, 19, 26
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L3_fan_Wp_data, L3_fan_Wp_bar_data, L3_fan_Bp_bar_data,
        64, 19, 26
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 4: L4_linear
    linear_forward_pgm(
        buffer1, x_out,
        L4_linear_W_data, L4_linear_B_data,
        64, 12
    );
    }
    