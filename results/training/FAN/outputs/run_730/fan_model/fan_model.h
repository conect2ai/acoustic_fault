/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 128 (x1)
    * Saída: 12
    * Buffer Máx: 128
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 128;
    const int FAN_MAX_BUFFER_SIZE = 128;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    return (x > 0.0f) ? x : 0.0f;
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 51 x 120)
const int L0_fan_Wp_rows = 51;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  1.22221652e-02f, 1.88956380e-01f, 1.43610895e-01f, 3.56082097e-02f, -2.97658946e-02f, 5.96261621e-02f, 2.51164854e-01f, 4.37339842e-02f, -2.92284638e-02f, 1.84497789e-01f,
  -9.50502753e-02f, -1.59150019e-01f, -9.58607197e-02f, -8.42454955e-02f, 3.88702378e-02f, 1.44226238e-01f, 2.12113827e-01f, -2.86566950e-02f, -8.82142689e-03f, -2.71173436e-02f,
  -5.61613068e-02f, -4.31541987e-02f, -8.53676721e-03f, -1.26403302e-01f, 2.22778209e-02f, -1.96486562e-01f, -3.10945082e-02f, -1.20665759e-01f, 2.17950027e-02f, -5.29616736e-02f,
  3.20999771e-02f, -8.14421922e-02f, -1.47670627e-01f, -1.13681324e-01f, -1.50710955e-01f, -2.37658229e-02f, -3.35916840e-02f, -1.55375570e-01f, -1.20547749e-01f, 1.12681836e-02f,
  -2.30636299e-01f, -1.63576603e-01f, -7.58160874e-02f, -2.21200138e-02f, -1.55458048e-01f, 4.59451601e-03f, 5.39806709e-02f, -1.21884808e-01f, -1.41277820e-01f, 2.28278786e-02f,
  -1.66426420e-01f, -5.65823615e-02f, -3.17608789e-02f, -5.23224846e-02f, -1.97835132e-01f, -1.29323199e-01f, -6.17321022e-02f, -1.47463351e-01f, -6.34875968e-02f, 2.99921203e-02f,
  5.60408980e-02f, 5.75399548e-02f, 1.30407121e-02f, 1.55110583e-01f, 1.24183141e-01f, 7.42741823e-02f, 8.05088058e-02f, 7.34038800e-02f, 4.32879142e-02f, 5.53293824e-02f,
  2.68706493e-02f, 6.65944442e-02f, 5.04989997e-02f, -2.32178476e-02f, 5.99117689e-02f, 8.28127265e-02f, -1.54253887e-02f, 1.11634985e-01f, 8.56311396e-02f, 6.22305693e-03f,
  4.71341126e-02f, -2.91045699e-02f, 3.30450833e-02f, -5.65808117e-02f, -3.77616957e-02f, 1.86122451e-02f, 1.51333120e-02f, -1.92364231e-02f, 6.37940541e-02f, -7.83374012e-02f,
  1.49566373e-02f, -2.24986494e-01f, -1.62507221e-01f, -7.21409470e-02f, -1.83582395e-01f, -1.45041436e-01f, -1.55647948e-01f, -1.35353372e-01f, -1.83038965e-01f, -1.02313995e-01f,
  -1.80790305e-01f, -1.06354877e-01f, -2.19476055e-02f, -8.70310813e-02f, -3.04412916e-02f, -9.12014171e-02f, -4.30576764e-02f, 1.52305583e-03f, -1.84737787e-01f, -1.03349589e-01f,
  4.14193161e-02f, 5.94278611e-02f, 1.12076730e-01f, -1.11082472e-01f, -2.31888473e-01f, -9.12606865e-02f, -1.45299971e-01f, -1.47285849e-01f, -3.20555195e-02f, -1.11545306e-02f,
  1.50490016e-01f, -1.27924560e-02f, 3.40447754e-01f, 2.97567993e-01f, 3.01519781e-01f, 1.77610859e-01f, -4.57504317e-02f, -1.40450038e-02f, 7.86405876e-02f, 1.54172122e-01f,
  8.67339224e-02f, 7.11029023e-03f, 1.50189951e-01f, -6.38260785e-03f, 5.33843674e-02f, 1.37348518e-01f, 1.05039246e-01f, 1.69072151e-01f, 2.11962283e-01f, 1.64724052e-01f,
  1.62119195e-01f, 2.17337996e-01f, 2.43806243e-01f, 8.53360221e-02f, 1.45286798e-01f, 9.22975391e-02f, 1.39787838e-01f, 2.24904865e-01f, 1.76838949e-01f, 2.84257680e-01f,
  4.05533761e-01f, -4.30064648e-03f, -2.38092076e-02f, -4.49708663e-02f, 9.06535462e-02f, -7.23286718e-02f, 9.35387090e-02f, -1.02718949e-01f, 1.24163285e-03f, 1.91677045e-02f,
  -2.60412376e-02f, 5.22824079e-02f, 3.26951779e-03f, 1.06817864e-01f, 4.03050482e-02f, 6.17041290e-02f, 2.94200275e-02f, 4.11527157e-02f, 5.73960915e-02f, 6.37156442e-02f,
  -5.26238009e-02f, -4.26996239e-02f, 4.09214273e-02f, 4.21195515e-02f, -7.92481750e-02f, 5.04273288e-02f, 4.74993624e-02f, -1.41619947e-02f, -4.52949107e-02f, -1.09511912e-01f,
  -9.96733606e-02f, 3.09124310e-02f, -3.12098600e-02f, -7.84754157e-02f, -9.62185115e-03f, 1.11018512e-02f, -7.89372064e-03f, 1.59152355e-02f, -3.44779678e-02f, -7.73769915e-02f,
  7.94192869e-03f, 1.11202292e-01f, -8.84417631e-03f, 1.80513654e-02f, 7.05244169e-02f, 9.89932418e-02f, -1.49079384e-02f, -1.42498054e-02f, -8.30484703e-02f, 5.33298636e-03f,
  1.20491013e-02f, -9.12627578e-02f, 8.31378922e-02f, 2.07824782e-02f, 3.07390559e-02f, 6.92577660e-02f, -5.80297932e-02f, -3.45735028e-02f, -8.54076371e-02f, 4.43353504e-02f,
  2.06298474e-02f, -2.51564793e-02f, -3.94112244e-02f, -1.27349481e-01f, -1.02045484e-01f, -1.38140544e-02f, 3.21808606e-02f, -9.23812911e-02f, 1.19038019e-02f, -2.50217486e-02f,
  1.70677844e-02f, 3.43565904e-02f, 9.39091388e-03f, -4.29610908e-02f, 2.94652060e-02f, -2.96506053e-03f, -2.55605951e-02f, -3.99624072e-02f, -7.16507584e-02f, -9.88580212e-02f,
  -1.07654065e-01f, -1.47324488e-01f, -2.17382908e-01f, -4.69754562e-02f, -8.91170558e-03f, -1.03128679e-01f, -8.40073451e-02f, -1.19497232e-01f, -1.23460270e-01f, -7.90678039e-02f,
  -4.46408123e-01f, 1.49125168e-02f, -2.53469020e-01f, -3.55576336e-01f, -2.52775967e-01f, -9.18853879e-02f, 7.74967894e-02f, -6.08614832e-02f, -1.27803117e-01f, -1.40300825e-01f,
  -2.31835265e-02f, 1.91859111e-01f, 4.28458303e-02f, 1.99511603e-01f, 1.84656903e-01f, -1.83991030e-01f, -3.21384251e-01f, -1.19561233e-01f, 9.31149721e-02f, 3.01963300e-01f,
  1.51180148e-01f, -1.61337614e-01f, -1.37820989e-01f, 7.31210113e-02f, -1.07481800e-01f, 7.30168670e-02f, -2.38710523e-01f, -1.53450891e-01f, 9.66759026e-02f, -2.29674414e-01f,
  2.23355785e-01f, -6.23579659e-02f, 8.71969089e-02f, 4.29412648e-02f, 7.68141821e-02f, 1.05061695e-01f, 6.80066571e-02f, 6.01748265e-02f, 4.62163519e-03f, 5.32470495e-02f,
  -3.26745994e-02f, 1.08214254e-02f, 7.28934184e-02f, 4.44282368e-02f, -3.15358257e-03f, 1.15207858e-01f, 3.67783755e-03f, -7.20972009e-03f, -5.84874414e-02f, 2.93523967e-02f,
  9.48251262e-02f, -8.14654902e-02f, 3.01820952e-02f, 1.23437949e-01f, 2.90754698e-02f, -6.48125587e-03f, 1.20299704e-01f, 1.27914846e-01f, 1.45268545e-01f, 1.27565647e-02f,
  2.57885549e-03f, -1.20593265e-01f, -1.95233300e-02f, 1.02810925e-02f, -7.06842542e-02f, -3.69086228e-02f, -1.57534659e-01f, -5.35631925e-02f, -4.28242274e-02f, -8.61500762e-03f,
  -1.19629372e-02f, -8.21945071e-02f, 2.38995105e-02f, -5.93562797e-02f, 1.49497371e-02f, -5.91425076e-02f, -7.73110837e-02f, 2.71896292e-02f, -4.58521284e-02f, -9.45853889e-02f,
  4.03935276e-02f, -3.89178321e-02f, -5.08442260e-02f, 1.77374799e-02f, 3.41542251e-02f, -2.24088095e-02f, 1.15912734e-02f, 5.27854152e-02f, -3.30040045e-02f, -1.65337637e-01f,
  -1.13648567e-02f, 9.15300660e-03f, 6.95145056e-02f, 5.36668450e-02f, -4.51391116e-02f, 9.34668034e-02f, 2.76351292e-02f, -4.93276911e-03f, -5.03444560e-02f, 5.30377217e-02f,
  5.79575151e-02f, 3.77018303e-02f, 2.98240241e-02f, 3.13480124e-02f, 1.42444260e-02f, 4.64562103e-02f, -2.47268908e-04f, 6.75234646e-02f, 5.95758334e-02f, 5.96938282e-02f,
  3.07763163e-02f, -1.53270243e-02f, -7.83428326e-02f, -3.75507809e-02f, -7.87870400e-03f, -4.91141388e-03f, 2.10934100e-04f, 1.08927906e-01f, 7.11094365e-02f, -2.67455000e-02f,
  -9.16453451e-02f, 2.50009805e-01f, 1.26854330e-01f, 5.23769110e-02f, 2.81161040e-01f, 2.31418073e-01f, 3.49565119e-01f, -3.32950614e-02f, -4.80960086e-02f, 1.50128126e-01f,
  1.66075155e-01f, 1.09359816e-01f, 1.08889528e-01f, -2.74407789e-02f, -1.17268357e-02f, 1.98643342e-01f, 2.08421409e-01f, -7.25738406e-02f, -4.75878306e-02f, 5.27281351e-02f,
  2.06811696e-01f, -7.21542211e-03f, -3.25344503e-01f, -1.55900121e-01f, 1.39879743e-02f, 9.28528011e-02f, 3.63465428e-04f, -1.76237877e-02f, 1.63004950e-01f, 2.40089476e-01f,
  3.23206484e-01f, -2.07555592e-01f, -1.34534568e-01f, 2.04002229e-03f, 7.51171410e-02f, -7.56144971e-02f, 2.03235596e-02f, -2.17901766e-01f, -3.14018577e-02f, -7.04462454e-02f,
  6.92795068e-02f, -3.51401754e-02f, -1.01407826e-01f, -3.99583913e-02f, -1.12237647e-01f, -1.08308874e-01f, -7.27239251e-02f, -1.79579377e-01f, -1.23432390e-01f, 6.52998639e-03f,
  1.42581075e-01f, 4.61907079e-03f, -4.50441567e-03f, -1.26194507e-01f, -2.16724221e-02f, -3.13555193e-03f, -1.81139410e-02f, -9.93295535e-02f, -1.46249369e-01f, 5.61765209e-03f,
  -6.85015023e-02f, 3.60503532e-02f, 3.70339863e-02f, -1.90002248e-02f, 6.07334040e-02f, 5.68888756e-03f, -8.16035196e-02f, 1.06062531e-03f, 5.96239278e-03f, -5.18140718e-02f,
  -3.81643996e-02f, 3.15578170e-02f, 1.59262866e-02f, -3.23099010e-02f, -4.72461805e-03f, -5.78838773e-02f, 1.02130979e-01f, -2.96730343e-02f, -9.59992334e-02f, -6.38303831e-02f,
  -6.79521542e-03f, -1.78537853e-02f, -3.90611850e-02f, -7.13278865e-03f, 2.40430329e-02f, -3.65863591e-02f, -2.74970215e-02f, -2.88760439e-02f, 3.93693075e-02f, -6.11710250e-02f,
  -5.23380898e-02f, -8.07636902e-02f, 5.24303056e-02f, -1.82560042e-01f, -2.89443112e-03f, -3.92481834e-02f, 1.46203833e-02f, -2.27706358e-02f, 6.03094846e-02f, -3.64857540e-02f,
  -5.58451414e-02f, 1.58721469e-02f, -8.35180841e-03f, -7.82549828e-02f, 4.70587751e-03f, -2.76959315e-02f, 4.23857234e-02f, 5.57712018e-02f, -6.61015660e-02f, 6.39149621e-02f,
  -6.85031414e-02f, 3.22558917e-02f, 5.65701053e-02f, -3.08320262e-02f, -7.54034817e-02f, 7.58027807e-02f, -2.93776281e-02f, -4.74239774e-02f, 4.14513275e-02f, 5.95325269e-02f,
  4.53044325e-02f, -6.48267847e-03f, -3.85880828e-01f, -1.12750344e-01f, -9.76321325e-02f, -2.62028933e-01f, -2.25465313e-01f, -2.30021909e-01f, -2.07288161e-01f, -1.07338741e-01f,
  1.29523680e-01f, 4.63722609e-02f, -2.03205734e-01f, -2.48242930e-01f, -2.41092324e-01f, -2.72788972e-01f, -4.59539235e-01f, -3.76744449e-01f, -2.65683085e-01f, -1.62539363e-01f,
  -2.12788835e-01f, -1.45855069e-01f, -2.05232531e-01f, -2.43391111e-01f, -1.07922688e-01f, -1.98894128e-01f, -2.83631086e-01f, -1.23129554e-01f, -1.79224327e-01f, -3.54387343e-01f,
  -7.81292096e-03f, -7.23696724e-02f, -1.72324464e-01f, -3.73789296e-02f, -1.56312108e-01f, -2.19285101e-01f, -1.19557776e-01f, -2.27491051e-01f, -1.41821682e-01f, -9.35550109e-02f,
  -1.63438797e-01f, -1.48710966e-01f, -1.03774667e-01f, -2.10092723e-01f, -1.87865257e-01f, -2.33500108e-01f, -2.57671416e-01f, -3.23528260e-01f, -2.37720177e-01f, -1.38079554e-01f,
  -1.60222352e-01f, -2.15828389e-01f, -1.70541346e-01f, -2.20734388e-01f, -2.32962415e-01f, -2.12031305e-01f, -1.08714744e-01f, -1.55663654e-01f, -2.74732441e-01f, -1.77293405e-01f,
  4.43016887e-02f, 4.46645916e-02f, 6.20639361e-02f, 1.06951162e-01f, 1.49157569e-01f, 7.63859823e-02f, 5.61568625e-02f, 7.47280493e-02f, 2.09155187e-04f, 4.69613709e-02f,
  -1.75924692e-02f, 3.24742682e-02f, 1.66681577e-02f, -2.25745104e-02f, -7.12129027e-02f, -6.66431412e-02f, 5.94285950e-02f, 2.90044360e-02f, -9.76653546e-02f, 5.50451223e-03f,
  -1.18937958e-02f, -3.47446837e-02f, 8.37365463e-02f, -6.96588159e-02f, -1.45037845e-03f, -7.34695196e-02f, -3.25656347e-02f, 7.34309703e-02f, 1.10942133e-01f, 2.94664241e-02f,
  1.28196627e-01f, -2.17408285e-01f, -1.68054581e-01f, -1.87406763e-01f, -1.32658154e-01f, -1.10166691e-01f, -7.52582699e-02f, -1.27024665e-01f, -1.52631178e-01f, -1.65221184e-01f,
  -6.59230947e-02f, -7.54486695e-02f, -1.44271374e-01f, -1.05520383e-01f, -1.44573450e-01f, -1.68305293e-01f, -1.25910282e-01f, -2.52385378e-01f, -1.69857457e-01f, -4.12755162e-02f,
  -1.99452654e-01f, -2.02350706e-01f, -1.43660039e-01f, -1.96672544e-01f, -7.54889250e-02f, -9.64780822e-02f, -1.41069695e-01f, -1.58313647e-01f, -1.41746685e-01f, -1.57883629e-01f,
  1.93506971e-01f, 1.65794402e-01f, 1.73790082e-01f, 2.45555937e-01f, 2.31055975e-01f, 1.96404472e-01f, 3.01806092e-01f, 2.17148736e-01f, 1.16337657e-01f, 2.12076113e-01f,
  1.27206862e-01f, 2.03896970e-01f, 2.18678921e-01f, 1.77725002e-01f, 2.90461153e-01f, 1.96352646e-01f, 2.23979175e-01f, 1.33082181e-01f, 2.22441792e-01f, 3.01792949e-01f,
  1.81596830e-01f, 1.57538459e-01f, 2.15644166e-01f, 1.65855050e-01f, 1.53269395e-01f, 1.15995921e-01f, 8.85397568e-02f, 8.31043571e-02f, 1.69530824e-01f, 2.31613368e-01f,
  2.52869070e-01f, 2.50355422e-01f, 3.93468840e-03f, -7.19560310e-03f, 7.77123123e-03f, 8.24690834e-02f, 9.58854258e-02f, -3.00964955e-02f, 7.94874579e-02f, 1.45832792e-01f,
  9.46531966e-02f, 5.83295822e-02f, 1.39619529e-01f, 7.97965974e-02f, 8.83698836e-02f, 1.31934613e-01f, 6.39507324e-02f, 1.52980149e-01f, 2.17779130e-02f, -1.03263399e-02f,
  4.63122651e-02f, 3.96150462e-02f, -3.66880521e-02f, -3.50135528e-02f, 1.18513301e-01f, 3.97615768e-02f, 3.44046839e-02f, 6.30854368e-02f, 1.56330261e-02f, 5.32585979e-02f,
  -9.25978497e-02f, -8.33798721e-02f, -3.00786849e-02f, 4.88130935e-02f, 4.76637259e-02f, -1.04970522e-01f, 3.22041065e-02f, 5.61205260e-02f, 1.43293720e-02f, -2.87750177e-02f,
  6.77208751e-02f, -2.99888216e-02f, 8.72204453e-02f, 8.05541575e-02f, 6.41273558e-02f, 1.86456777e-02f, -3.21781933e-02f, 2.30452493e-02f, 6.90603629e-03f, -1.12640642e-01f,
  -2.19242908e-02f, -3.74877378e-02f, 2.66233878e-03f, -2.74344273e-02f, -1.20084351e-02f, 2.99544223e-02f, 9.23304111e-02f, 9.81918350e-02f, 3.51879038e-02f, -3.51362005e-02f,
  1.36271924e-01f, -1.25798002e-01f, 1.19179100e-01f, 1.27237275e-01f, 6.28392352e-03f, -3.86733115e-02f, 4.79451492e-02f, 1.38551779e-02f, 5.03078848e-03f, 1.37074888e-01f,
  1.37433603e-01f, 8.54313299e-02f, 1.49302706e-01f, 5.97604141e-02f, 7.84324855e-02f, 1.19578674e-01f, -3.88191082e-03f, 9.92783830e-02f, 6.75211102e-02f, -6.12172447e-02f,
  -8.01001303e-03f, -5.96127436e-02f, -7.45573789e-02f, 2.93157268e-02f, 2.28396431e-02f, -1.21567352e-02f, 3.00851604e-03f, -6.72386289e-02f, 7.07243532e-02f, -8.18680786e-03f,
  6.05755746e-01f, 5.78088343e-01f, 5.99198341e-02f, 1.91150889e-01f, -9.58062038e-02f, 2.01287866e-01f, 2.76550800e-01f, 2.30389029e-01f, 1.55877292e-01f, 2.69390702e-01f,
  1.06903203e-01f, -1.08601367e-02f, 5.66278547e-02f, 8.71188417e-02f, 2.84584492e-01f, 2.76941657e-01f, 1.30406797e-01f, 1.29517376e-01f, -1.09270886e-01f, -5.34221195e-02f,
  1.76336244e-02f, 1.26505390e-01f, 2.80724525e-01f, 1.42542526e-01f, 4.41164002e-02f, -5.14145829e-02f, 8.44297260e-02f, 1.61357358e-01f, 1.06481731e-01f, 1.47453442e-01f,
  9.65655744e-02f, 3.60872567e-01f, -5.32485545e-02f, 8.42254534e-02f, 1.18432827e-01f, 1.55461401e-01f, 2.02764541e-01f, 1.57285556e-01f, 1.69784695e-01f, 1.50979728e-01f,
  1.23127379e-01f, 4.84969318e-02f, 1.02307960e-01f, 1.64019048e-01f, 1.89620391e-01f, 1.24201551e-01f, 8.34938958e-02f, 1.32373855e-01f, 1.69256374e-01f, 1.30890027e-01f,
  1.66135449e-02f, 2.06323490e-01f, 1.69214085e-01f, 2.28364080e-01f, 1.24019593e-01f, 1.17911562e-01f, 2.28220597e-01f, 1.64205655e-01f, 2.46108919e-01f, 1.25584573e-01f,
  -7.81304762e-02f, -1.24256231e-01f, -1.87238395e-01f, -1.68687239e-01f, -6.19319007e-02f, -1.24445453e-01f, -8.13084021e-02f, -1.17643535e-01f, -1.63669348e-01f, -1.29125625e-01f,
  -2.56372020e-02f, -1.17597356e-01f, -1.19306117e-01f, -6.08662814e-02f, -1.35203704e-01f, -2.69221924e-02f, -2.68310830e-02f, -8.27937201e-02f, -1.77920982e-03f, -1.04900841e-02f,
  -7.66887441e-02f, -3.39767560e-02f, -1.16173133e-01f, -9.27547216e-02f, -3.17178257e-02f, -5.03231734e-02f, -4.43929173e-02f, -5.52691109e-02f, -9.12318155e-02f, 5.91497980e-02f,
  3.42235565e-02f, 1.61225468e-01f, 1.01438008e-01f, 1.46395549e-01f, 1.79644436e-01f, 1.21471047e-01f, 9.59898457e-02f, 7.85158202e-02f, 6.58853948e-02f, 2.02901989e-01f,
  2.18800411e-01f, 1.70729965e-01f, 2.29734078e-01f, -6.78885262e-03f, 5.77471517e-02f, 5.99231906e-02f, 1.52559802e-01f, 1.35025308e-01f, 1.08479403e-01f, 1.17197454e-01f,
  1.15032762e-01f, 1.00446194e-01f, 2.37417638e-01f, 1.41437382e-01f, 9.34200138e-02f, 1.05308972e-01f, 7.85216168e-02f, 5.96114732e-02f, 1.59524724e-01f, 1.29352093e-01f,
  3.87811810e-02f, 5.30588984e-01f, 1.13024846e-01f, 1.55974384e-02f, -7.86259770e-03f, 8.14090669e-03f, 2.16795594e-01f, 2.62249149e-02f, 2.67206337e-02f, 2.39705667e-01f,
  2.28651613e-01f, 1.89813942e-01f, 2.14411110e-01f, 2.70559758e-01f, 1.71623126e-01f, 3.87158155e-01f, 1.78695038e-01f, 1.79361373e-01f, -1.87226851e-02f, -1.35456309e-01f,
  3.93074341e-02f, 1.82895705e-01f, 1.40038738e-02f, 8.39691088e-02f, -2.50199270e-02f, 1.47449851e-01f, 1.76899239e-01f, 1.54075101e-01f, 1.50791422e-01f, 2.22229585e-01f,
  3.08847427e-01f, -6.11527152e-02f, 1.15518652e-01f, 1.76744625e-01f, 1.60507560e-01f, 2.13251442e-01f, 2.06274182e-01f, 8.72890800e-02f, 1.00001924e-01f, 1.60345316e-01f,
  1.62272722e-01f, 1.14947014e-01f, 2.24217236e-01f, 5.81074096e-02f, 8.40170905e-02f, 1.02826580e-01f, 7.88353011e-02f, 1.58241600e-01f, 1.70299158e-01f, 1.89256608e-01f,
  1.10409170e-01f, 1.11562051e-02f, 1.89850837e-01f, 1.31113857e-01f, 7.41160810e-02f, 9.96800959e-02f, 6.72738999e-02f, 8.14450905e-03f, 1.33513466e-01f, 1.06395088e-01f,
  -2.09397264e-02f, -9.66487452e-02f, -1.19743697e-01f, -1.23668902e-01f, -7.55663887e-02f, -5.82063980e-02f, -4.93639968e-02f, -7.48798102e-02f, -8.01882520e-02f, -1.15316324e-01f,
  -3.21308225e-02f, -1.14954792e-01f, -7.63231441e-02f, -4.47774976e-02f, -1.25205696e-01f, -1.83538675e-01f, -7.76626915e-02f, -1.98632684e-02f, -6.91374317e-02f, -1.62279353e-01f,
  -1.38127849e-01f, -1.22624218e-01f, -8.46245438e-02f, -6.25722185e-02f, -1.32708862e-01f, -1.78099290e-01f, -1.42690882e-01f, -1.50148168e-01f, -1.59226432e-01f, -1.08183019e-01f,
  2.36141860e-01f, 1.02179378e-01f, 1.56150281e-01f, 1.28924936e-01f, 8.31153393e-02f, 5.92427328e-03f, 1.24315120e-01f, 6.74259290e-02f, 1.03742354e-01f, 3.49544659e-02f,
  1.26489386e-01f, 1.16856642e-01f, 1.36833489e-01f, 1.04515329e-01f, 4.13150666e-03f, 2.56823357e-02f, 1.85700908e-01f, 1.69301450e-01f, 1.53227001e-01f, 1.26038909e-01f,
  2.33147129e-01f, 6.43617585e-02f, 2.19383284e-01f, 1.28821701e-01f, 8.79896358e-02f, 1.06478117e-01f, 2.24699438e-01f, 1.49139479e-01f, 1.38391018e-01f, 2.89721370e-01f,
  -5.28050005e-01f, -2.83292413e-01f, -5.40885851e-02f, -2.95915931e-01f, -1.38298586e-01f, -2.21033152e-02f, 6.05475344e-02f, -5.41544054e-04f, -9.74583924e-02f, -2.40751103e-01f,
  -1.27730444e-01f, 8.11254680e-02f, 2.00764060e-01f, 2.85317987e-01f, 2.37452760e-01f, 6.94514513e-02f, 1.25327334e-02f, 1.95250601e-01f, 2.64620125e-01f, 1.80321917e-01f,
  1.39243707e-01f, -1.14904828e-01f, -1.56860396e-01f, 7.26333857e-02f, -2.61627194e-02f, 2.14327537e-02f, -9.83274207e-02f, -6.66442215e-02f, 3.59513573e-02f, -1.44764826e-01f,
  7.72625729e-02f, -2.39727005e-01f, 1.87737688e-01f, 4.67196293e-02f, -4.24505286e-02f, -4.10518125e-02f, -3.80284782e-03f, -9.53790620e-02f, -6.87085241e-02f, 1.69927254e-02f,
  2.71287207e-02f, 7.91670159e-02f, -3.35002057e-02f, 1.30391851e-01f, -5.09639643e-02f, 9.15972441e-02f, 1.80578120e-02f, 4.11547944e-02f, 1.01892672e-01f, 4.28280681e-02f,
  1.48251476e-02f, -5.52786235e-03f, -1.12840563e-01f, 1.12591155e-01f, 1.13227382e-01f, 1.36343196e-01f, 7.83341974e-02f, 1.76968779e-02f, 1.02914549e-01f, -7.18737468e-02f,
  7.18080252e-02f, 1.71248205e-02f, -5.97392917e-02f, -1.20726705e-01f, -5.20543829e-02f, -3.65083255e-02f, -4.65955846e-02f, 2.76270099e-02f, -8.01477674e-03f, -7.30426162e-02f,
  -6.22988213e-03f, -3.21503319e-02f, -1.07309900e-01f, -4.29914966e-02f, -2.29891147e-02f, -4.46883217e-02f, -7.68881012e-03f, -4.47596684e-02f, -2.50343736e-02f, -1.04087494e-01f,
  -1.11013763e-01f, -4.32800874e-02f, -7.88205117e-02f, 1.23454281e-03f, 1.61204971e-02f, 1.54631035e-02f, -7.43713453e-02f, -6.46218136e-02f, -2.27287263e-02f, -4.90265153e-02f,
  -3.60673331e-02f, 1.08834289e-01f, 6.52773678e-02f, 1.74482867e-01f, 3.09045035e-02f, 1.16905915e-02f, -8.10884964e-03f, -3.62556465e-02f, 1.02712596e-02f, -2.41528340e-02f,
  5.62474951e-02f, 8.66427720e-02f, 2.29688976e-02f, 1.12833371e-02f, 1.58682019e-02f, 7.09703565e-02f, -2.04984173e-02f, -1.29286069e-02f, 9.83012617e-02f, 2.87473481e-02f,
  -7.56378695e-02f, 1.10834455e-02f, 4.07702886e-02f, 1.76973622e-02f, -2.01372746e-02f, 4.74540181e-02f, 5.18049821e-02f, 4.62964848e-02f, 5.58226071e-02f, -5.78576662e-02f,
  1.85672436e-02f, -3.55327249e-01f, 5.00648260e-01f, 1.94693312e-01f, -1.51148975e-01f, -9.34422538e-02f, -3.85645032e-02f, -2.86496785e-02f, 1.06427915e-01f, -6.91827983e-02f,
  -9.49612856e-02f, 4.04672176e-02f, 2.14804769e-01f, 1.90791860e-01f, 2.34129354e-01f, 2.40365312e-01f, 4.20121163e-01f, 3.89003366e-01f, 3.68387759e-01f, 7.60330260e-03f,
  -1.18470371e-01f, 3.40872407e-02f, 1.99192226e-01f, 2.07184687e-01f, 1.12672359e-01f, 2.36131862e-01f, 1.84518874e-01f, 7.87812620e-02f, 5.44459075e-02f, 2.03789905e-01f,
  2.92311281e-01f, 5.12460582e-02f, 1.70431614e-01f, -2.66186465e-02f, -6.83792979e-02f, 1.05279326e-01f, -3.53840776e-02f, 1.72503203e-01f, 1.62888430e-02f, 9.08980146e-02f,
  -4.26420830e-02f, 4.94216010e-02f, 9.66800936e-03f, 2.48124711e-02f, 4.49492894e-02f, 9.49362386e-03f, 3.16670537e-02f, 1.88017249e-01f, 9.61510539e-02f, -1.18079437e-02f,
  -4.22154479e-02f, -6.43760860e-02f, 1.11040445e-02f, 8.68199095e-02f, 5.45693599e-02f, 6.55323863e-02f, 1.08690754e-01f, 1.64627850e-01f, 1.12929925e-01f, 1.41905442e-01f,
  -8.10235217e-02f, 7.34958914e-04f, -5.47379702e-02f, 2.42772829e-02f, 2.26888061e-02f, -1.99712981e-02f, -1.39163714e-02f, -4.68732640e-02f, 6.62952811e-02f, -3.65866050e-02f,
  5.87476529e-02f, -8.90624374e-02f, 4.01565693e-02f, 9.61494353e-03f, -6.19042218e-02f, 4.96599916e-03f, -5.83063550e-02f, -5.49241230e-02f, -7.72505775e-02f, -2.99745761e-02f,
  7.00867996e-02f, 1.73394009e-02f, -3.45070288e-02f, 6.79193512e-02f, -2.50890292e-02f, 9.95407924e-02f, 3.81398052e-02f, 2.04441138e-02f, 2.85251590e-04f, -1.54079618e-02f,
  5.25905751e-02f, -4.13099192e-02f, 1.08082563e-01f, 1.13984682e-01f, 1.40080661e-01f, 9.54042934e-03f, 5.60727939e-02f, 3.16615067e-02f, 9.79468748e-02f, 1.71004921e-01f,
  3.88285704e-02f, 1.43381968e-01f, 1.25510260e-01f, 5.17864265e-02f, 1.88668728e-01f, 1.47684455e-01f, 6.24365471e-02f, 7.28969276e-02f, 8.49645287e-02f, 2.59880386e-02f,
  3.41472849e-02f, 1.24233000e-01f, 4.05693427e-02f, 7.67530575e-02f, 6.84455037e-02f, 1.82706371e-01f, 1.84669092e-01f, 1.54612064e-01f, 2.33302981e-01f, 6.28743097e-02f,
  4.36379127e-02f, -7.10318089e-02f, -3.00246507e-01f, -1.12297602e-01f, -8.29087421e-02f, -1.27364576e-01f, -4.11092974e-02f, 1.20026588e-01f, -5.92912361e-02f, -9.90033075e-02f,
  -9.19599980e-02f, -6.20943978e-02f, -9.19815227e-02f, 3.84083465e-02f, -2.35475581e-02f, -1.67883515e-01f, -2.04587549e-01f, -1.35921255e-01f, 1.27697382e-02f, -3.90419699e-02f,
  -1.55821577e-01f, -3.57847176e-02f, -5.24154939e-02f, -7.34210089e-02f, -1.14823230e-01f, -2.83331387e-02f, -1.34657875e-01f, -1.64782166e-01f, -2.58100149e-03f, -1.62086219e-01f,
  -2.76737005e-01f, 1.96261838e-01f, 9.44560692e-02f, 3.57116051e-02f, -2.31411494e-02f, 5.24568334e-02f, 5.48624732e-02f, 3.97934616e-02f, 4.64120544e-02f, 9.03399065e-02f,
  1.48199927e-02f, 2.78359987e-02f, 1.35488987e-01f, 3.30839679e-02f, -1.63167287e-02f, -2.74570361e-02f, 1.75839681e-02f, -4.18280698e-02f, 3.31588984e-02f, 2.94185672e-02f,
  2.65324730e-02f, 7.14989975e-02f, 3.94674167e-02f, 2.02391505e-01f, 8.22417624e-03f, 1.12479873e-01f, 1.66613534e-01f, 1.85982995e-02f, 1.10676177e-01f, 8.94925892e-02f,
  -6.59246072e-02f, 1.06510453e-01f, 1.62296295e-02f, 5.44045419e-02f, 7.73779750e-02f, 1.17698744e-01f, 1.46011533e-02f, 9.22504514e-02f, 1.93416921e-03f, 8.28163996e-02f,
  1.58160515e-02f, -3.47401015e-02f, -1.34998355e-02f, 1.46486061e-02f, -7.19117001e-03f, 5.87590858e-02f, 1.62552837e-02f, -5.94299696e-02f, 9.27947760e-02f, 8.59792903e-02f,
  3.53090279e-02f, 6.25926033e-02f, -2.62009036e-02f, 2.77412552e-02f, -1.01844147e-01f, -5.72807901e-03f, -5.80047071e-02f, 1.02796510e-01f, -3.70570272e-02f, 8.92220438e-02f,
  1.85509980e-01f, 1.22040972e-01f, -3.11984904e-02f, 1.69373348e-01f, -1.71615873e-02f, 1.62345469e-01f, -1.64661836e-02f, 9.94976535e-02f, 9.37408134e-02f, -1.32149085e-02f,
  -3.12318299e-02f, 1.18540041e-01f, -2.09446829e-02f, 1.13134600e-01f, -1.61689259e-02f, 9.45265815e-02f, 4.76726480e-02f, 2.76952758e-02f, 1.51460676e-03f, -1.77894030e-02f,
  1.51667908e-01f, 1.28900483e-01f, 8.10462981e-02f, 1.91475332e-01f, 8.69072527e-02f, 6.06888533e-02f, 1.73111126e-01f, 9.51381847e-02f, 5.12421392e-02f, 1.50268152e-01f,
  6.57818913e-01f, -5.43791093e-02f, -1.86954647e-01f, 3.41752283e-02f, 1.75756037e-01f, 1.97853312e-01f, 2.85059303e-01f, 1.59146503e-01f, -2.15796381e-02f, 7.86529947e-03f,
  1.89560592e-01f, 6.39524907e-02f, -1.61668867e-01f, -8.74569491e-02f, 2.17474494e-02f, -1.60440922e-01f, -1.74648881e-01f, -1.91491723e-01f, 7.73703605e-02f, 1.18475899e-01f,
  9.90695087e-04f, -8.29405338e-03f, 3.76215950e-02f, -4.71183285e-03f, -1.82992354e-01f, -1.24829337e-01f, -1.99521825e-01f, -4.45544384e-02f, 1.37983654e-02f, -3.88762861e-01f,
  -2.17498705e-01f, 8.72920677e-02f, 2.63927393e-02f, -1.22542921e-02f, -6.31407499e-02f, -4.13081702e-03f, 3.03073670e-03f, -1.32261649e-01f, 5.01934625e-02f, -9.58984271e-02f,
  9.38288309e-03f, 5.01721948e-02f, -1.30312853e-02f, -4.70118932e-02f, 2.65818015e-02f, 9.15748253e-02f, -2.71478891e-02f, -1.93468649e-02f, -7.63907880e-02f, -6.79637492e-03f,
  -8.52797925e-02f, 7.92334527e-02f, 9.96669829e-02f, -2.81581953e-02f, 7.15074763e-02f, 2.42210981e-02f, 9.23411697e-02f, 3.50449607e-02f, 6.83835074e-02f, 1.31049529e-02f,
  -6.33476973e-02f, -5.08938096e-02f, -2.12657135e-02f, -1.91383697e-02f, 6.72630444e-02f, -4.26458195e-02f, -8.37908164e-02f, 2.43949238e-02f, 5.36279269e-02f, -2.48695314e-02f,
  1.03737637e-02f, -3.72897089e-02f, 7.97668993e-02f, 1.08677477e-01f, -1.23845497e-02f, 1.39555885e-02f, 5.56189707e-03f, -1.68610495e-02f, -7.02418247e-03f, 7.36364871e-02f,
  2.85316482e-02f, 1.94261502e-02f, -5.86970709e-02f, 1.24363704e-02f, -6.46445015e-03f, -9.77709368e-02f, 1.77799556e-02f, 2.27168947e-02f, 1.00169079e-02f, -3.62202674e-02f,
  -1.47037730e-01f, 1.29457399e-01f, -1.27167687e-01f, -1.76688582e-02f, -2.20663305e-02f, -5.41968718e-02f, 7.43925199e-03f, -6.06565699e-02f, -2.71296464e-02f, 1.94943566e-02f,
  -6.72651781e-03f, -6.30060211e-02f, 5.66481091e-02f, -3.89916152e-02f, -1.08807310e-02f, 9.66312364e-03f, 8.65753219e-02f, -1.82910077e-02f, 8.20529647e-03f, -2.16289088e-02f,
  -3.24146636e-02f, 2.42482824e-03f, 1.07046150e-01f, -5.56045249e-02f, -9.79927019e-04f, 3.40644307e-02f, -7.08811134e-02f, 6.64293906e-03f, 1.21619195e-01f, 4.31413278e-02f,
  -1.45669848e-01f, 7.79706985e-02f, 2.19715565e-01f, -8.31990689e-02f, -1.93614792e-02f, 1.84884191e-01f, 9.43049267e-02f, -1.44809822e-03f, 1.45422161e-01f, 1.25258848e-01f,
  1.89461768e-01f, 2.47467145e-01f, 2.53265232e-01f, 1.34473324e-01f, 1.74061418e-01f, 1.69861168e-01f, 8.38834420e-02f, 5.71283512e-03f, -2.19790842e-02f, 3.62778865e-02f,
  9.46173724e-03f, -1.26229212e-01f, -1.50955766e-01f, -4.23912145e-02f, 1.52143180e-01f, 8.21707472e-02f, 3.79354581e-02f, -9.68073215e-03f, 1.93341389e-01f, 7.55040348e-02f,
  4.05185819e-01f, 6.48226961e-03f, 1.92489013e-01f, 1.76324129e-01f, 2.05156624e-01f, 6.64470270e-02f, 2.11818397e-01f, 2.89405603e-02f, 1.84865251e-01f, 4.73363064e-02f,
  1.27193630e-01f, 1.16695017e-01f, 2.03818113e-01f, 1.53346837e-01f, 1.45085499e-01f, 3.87983359e-02f, 2.74404176e-02f, 1.41332569e-02f, 2.36122295e-01f, 1.23498701e-01f,
  1.19784050e-01f, 9.68254209e-02f, 3.11593916e-02f, 2.05689028e-01f, 1.33285582e-01f, 1.92817479e-01f, 1.43402994e-01f, 2.27094844e-01f, 2.67776042e-01f, 1.77467719e-01f,
  1.52800843e-01f, -6.67681023e-02f, -1.48198202e-01f, -1.80651173e-01f, -1.85006723e-01f, -9.54858139e-02f, -6.00552075e-02f, -2.26960018e-01f, -2.01305375e-01f, -9.04400274e-02f,
  -1.60563275e-01f, -3.81757319e-02f, -1.50993720e-01f, -1.11023724e-01f, -7.47319236e-02f, -1.59455508e-01f, -2.79869605e-02f, -2.15030774e-01f, -1.54987529e-01f, -9.10545290e-02f,
  -1.64093360e-01f, -5.48611209e-02f, -1.67911708e-01f, -1.89702690e-01f, -6.78174421e-02f, -1.16601869e-01f, -6.24794848e-02f, -2.02961445e-01f, -1.69663936e-01f, -5.70595823e-02f,
  2.37018168e-01f, 1.79933250e-01f, 2.53476143e-01f, -1.17269135e-03f, 1.80952623e-01f, 2.19621673e-01f, 2.02463657e-01f, 1.05654940e-01f, 1.52750298e-01f, 1.79841906e-01f,
  2.12478489e-01f, 1.67808414e-01f, 1.37192607e-01f, 2.52605528e-02f, 1.24885052e-01f, 1.40121594e-01f, -5.72663546e-02f, 1.60584390e-01f, 1.62416250e-01f, 1.88926950e-01f,
  2.57583726e-02f, -1.40773307e-03f, 1.00466736e-01f, 1.12149313e-01f, 1.19652092e-01f, 1.96338922e-01f, 2.18541890e-01f, 1.93337888e-01f, 1.33650109e-01f, -7.03141978e-03f,
  -4.16087002e-01f, -1.65847465e-01f, 3.08349431e-02f, -7.61782331e-03f, 2.77109623e-01f, 2.23522052e-01f, 2.47898951e-01f, -9.67963412e-02f, -1.75101921e-01f, 9.48966742e-02f,
  1.61822081e-01f, 3.24113369e-01f, 1.72069475e-01f, 1.77016944e-01f, 2.08264142e-02f, 6.50455989e-03f, 6.28110394e-02f, 1.00450911e-01f, 2.25131646e-01f, 2.99535871e-01f,
  3.93478155e-01f, 8.51387857e-04f, -2.18488257e-02f, -9.11346599e-02f, 1.09041803e-01f, 2.26595193e-01f, -9.45647247e-03f, 1.10429257e-01f, 1.76997125e-01f, 2.07984462e-01f,
  1.83828712e-01f, -2.26900131e-01f, 1.19270995e-01f, 7.64973611e-02f, 6.40703738e-03f, -8.10879245e-02f, 8.56399164e-02f, -1.06679909e-01f, 5.54338321e-02f, 2.64471881e-02f,
  1.35002777e-01f, 1.13505401e-01f, 8.75490308e-02f, 1.21966355e-01f, 8.92452430e-03f, 8.26538950e-02f, -7.80638084e-02f, 4.57458049e-02f, 3.36038545e-02f, -5.69396019e-02f,
  1.20239213e-01f, 1.69672102e-01f, 2.67442465e-02f, 8.69076252e-02f, -8.04902315e-02f, 1.73086822e-01f, 6.25405908e-02f, -5.51706441e-02f, -4.60826270e-02f, -2.22317055e-02f,
  -5.36032468e-02f, -1.28424559e-02f, -6.02220930e-02f, -1.40864495e-02f, -6.19196743e-02f, -6.89525008e-02f, -2.50093956e-02f, 3.69175822e-02f, 6.54997826e-02f, -9.07694027e-02f,
  -7.89175928e-02f, -2.03295033e-02f, -1.75496601e-02f, -2.41072625e-02f, 7.17198849e-02f, 3.25713144e-03f, 4.93184961e-02f, -6.49061725e-02f, -3.98527347e-02f, -8.98943171e-02f,
  1.45689072e-02f, -6.38842732e-02f, -1.30736660e-02f, -4.24247794e-02f, -4.57737446e-02f, -4.77487296e-02f, -1.60178952e-02f, 6.40090480e-02f, 7.50979688e-03f, -8.08544923e-03f,
  2.36476123e-01f, 7.20254332e-02f, 7.41407126e-02f, 1.41555583e-02f, 2.20286362e-02f, -3.67567949e-02f, 1.31260842e-01f, 6.85679615e-02f, 4.42799293e-02f, 1.12734459e-01f,
  3.53033096e-02f, 1.35642523e-02f, 1.18447833e-01f, 5.19310087e-02f, 1.34812281e-01f, 1.47558868e-01f, 8.76084566e-02f, 1.30510464e-01f, 1.65471956e-01f, -3.83041464e-02f,
  2.16573756e-02f, 1.36498556e-01f, 1.63201869e-01f, 8.94310027e-02f, 1.04839243e-01f, 2.65300423e-01f, 2.38136485e-01f, 8.88804197e-02f, 8.29937160e-02f, 2.99570467e-02f,
  1.41137084e-02f, 1.43651709e-01f, 4.93293852e-02f, 4.26898152e-02f, -1.50479957e-01f, -2.72338629e-01f, -1.70829475e-01f, -2.24427417e-01f, -2.01545060e-01f, -1.01970606e-01f,
  -2.97594249e-01f, -3.42774570e-01f, -1.26961306e-01f, -2.07909152e-01f, -1.00627281e-01f, 6.61185607e-02f, -1.70933474e-02f, 2.42177900e-02f, -1.49195716e-01f, -2.23741367e-01f,
  -2.12632149e-01f, -8.58640149e-02f, 8.66388716e-03f, -4.79947701e-02f, -1.33588418e-01f, -1.98223695e-01f, -1.14104878e-02f, -1.67975664e-01f, -1.26821995e-01f, -5.61016090e-02f,
  -2.48577416e-01f, -9.20219496e-02f, -2.42108941e-01f, -1.24967381e-01f, -1.76602885e-01f, -2.72496849e-01f, -1.43468693e-01f, -1.69002697e-01f, -1.86927333e-01f, -1.15646109e-01f,
  -1.35435417e-01f, -1.88810572e-01f, -9.89223197e-02f, -1.88351467e-01f, -1.92953229e-01f, -2.62234181e-01f, -1.45446569e-01f, -6.60170764e-02f, -1.78693935e-01f, -2.03674361e-01f,
  -1.63856536e-01f, -1.91491485e-01f, -2.14531928e-01f, -1.72832564e-01f, -1.46643832e-01f, -1.35280341e-01f, -1.86055988e-01f, -2.22038001e-01f, -1.38531461e-01f, -9.00053158e-02f,
  3.36402804e-02f, 2.18355179e-01f, 2.08709806e-01f, 1.90160647e-01f, 1.40992418e-01f, 1.69735774e-01f, 1.30198255e-01f, 1.91480249e-01f, 2.43487373e-01f, 1.37658209e-01f,
  2.39227280e-01f, 1.84388727e-01f, 1.59651637e-01f, 2.32230484e-01f, 2.45106727e-01f, 1.52003661e-01f, 4.31249514e-02f, 2.19092458e-01f, 1.56397462e-01f, 9.60678682e-02f,
  1.74019560e-01f, 2.03158319e-01f, 1.94375575e-01f, 2.27095276e-01f, 1.96385518e-01f, 2.33793601e-01f, 1.84828520e-01f, 1.40323088e-01f, 1.82176650e-01f, 2.05939978e-01f,
  -4.50459331e-01f, -1.50167078e-01f, -1.86820149e-01f, -2.36186296e-01f, -1.48069337e-01f, -2.17678979e-01f, -1.81529358e-01f, -1.65695906e-01f, -2.31460512e-01f, -2.39319742e-01f,
  -1.85429469e-01f, -1.69166312e-01f, -2.60074466e-01f, -2.05552429e-01f, -2.71231681e-01f, -2.76497841e-01f, -1.85678706e-01f, -2.18904838e-01f, -2.96780974e-01f, -2.34784305e-01f,
  -9.27796066e-02f, -3.41596991e-01f, -3.25640947e-01f, -2.23038852e-01f, -3.31204206e-01f, -3.90227318e-01f, -2.08757803e-01f, -3.37278962e-01f, -4.12372619e-01f, -2.81397283e-01f,
  -8.90885144e-02f, -3.65343809e-01f, -1.39984310e-01f, 1.89060897e-01f, 2.75662392e-01f, -1.37478277e-01f, -3.63953382e-01f, -2.96238273e-01f, 8.07391573e-03f, -4.55173329e-02f,
  -4.69689518e-02f, 4.97316420e-02f, -1.41141564e-01f, -2.52066880e-01f, -3.78912032e-01f, -2.31417358e-01f, -2.42640048e-01f, -1.78166077e-01f, -2.23233383e-02f, 1.45910501e-01f,
  3.57396454e-02f, 1.59922779e-01f, -4.28145118e-02f, -2.58675553e-02f, 5.32967970e-02f, 4.51844074e-02f, -1.29883081e-01f, 7.19674528e-02f, -1.55703038e-01f, -1.51342660e-01f,
  1.90087125e-01f, -2.69558251e-01f, 7.19934478e-02f, 3.31931189e-02f, -3.41105182e-03f, -1.52742982e-01f, -4.99125943e-02f, -9.11135226e-02f, 6.77986676e-03f, -4.45244759e-02f,
  2.41263155e-02f, -6.73376024e-02f, -6.02198355e-02f, -8.56584683e-02f, -1.02170818e-02f, -1.33936897e-01f, -1.71441585e-01f, -1.69515461e-01f, -2.36792490e-01f, -1.29703447e-01f,
  -4.05061394e-02f, 2.60754861e-02f, -3.83667275e-02f, -1.81026787e-01f, -2.11459488e-01f, -1.39200436e-02f, -1.67474478e-01f, -1.01291977e-01f, -2.30276302e-01f, -5.20261638e-02f,
  1.68768108e-01f, 1.22840427e-01f, 1.23375587e-01f, 1.34783849e-01f, 1.00533098e-01f, 5.01483008e-02f, 1.43776774e-01f, 1.72719777e-01f, 1.75798565e-01f, 5.33552915e-02f,
  9.12458301e-02f, 1.17757797e-01f, 1.04152910e-01f, 5.97998500e-02f, 1.49044290e-01f, 5.25641963e-02f, 9.58305672e-02f, 4.01792675e-02f, 1.75355211e-01f, 6.11124560e-02f,
  1.13148630e-01f, 7.95533229e-03f, 1.66935518e-01f, 9.06319264e-03f, -1.34359673e-02f, 1.61535814e-01f, 1.03112772e-01f, 6.31825849e-02f, 1.04843140e-01f, 6.03043064e-02f,
  2.43868187e-01f, -1.40969500e-01f, -9.16215125e-03f, -1.41235352e-01f, -1.73376109e-02f, -8.78865793e-02f, 2.34384816e-02f, -6.48625344e-02f, -3.62494811e-02f, -3.17128003e-02f,
  -1.12890974e-01f, -1.94825992e-01f, -1.11565448e-01f, -1.16093062e-01f, 8.65184963e-02f, -5.51841632e-02f, -1.23131108e-02f, -1.05426699e-01f, -1.59992784e-01f, -1.00930721e-01f,
  -2.21850395e-01f, -1.11685321e-02f, -2.77567026e-03f, -4.11708578e-02f, -1.45633593e-01f, -4.62620780e-02f, -2.39082742e-02f, -3.31371166e-02f, -1.31880954e-01f, 1.77415796e-02f,
  5.18398173e-02f, 3.44307929e-01f, -2.53103793e-01f, -1.23719729e-01f, -5.78286611e-02f, 1.05166333e-02f, 2.11384386e-01f, 2.41388142e-01f, 7.10935295e-02f, 1.50987357e-01f,
  5.69051653e-02f, 2.17077971e-01f, 2.37351641e-01f, 1.69014096e-01f, 4.02845681e-01f, 9.47151929e-02f, 7.49489367e-02f, -1.75588541e-02f, 3.09687816e-02f, 2.36650221e-02f,
  1.40664518e-01f, 1.77520230e-01f, 9.98362899e-02f, 1.56551883e-01f, -3.15974876e-02f, -8.36871006e-03f, -5.01696914e-02f, 9.04022623e-03f, 5.37348948e-02f, -2.00806051e-01f,
  -1.78013429e-01f, 3.54030021e-02f, 1.70003429e-01f, 2.18276322e-01f, -1.15797631e-02f, 5.42205758e-02f, 1.06129482e-01f, 6.22854941e-02f, 1.89322475e-02f, 1.21042117e-01f,
  -3.69893163e-02f, 5.03333062e-02f, 7.33968243e-02f, 8.14517513e-02f, 1.18677855e-01f, 4.80159111e-02f, 1.08592249e-01f, 8.98439586e-02f, 1.65090516e-01f, -1.87268276e-02f,
  7.89946839e-02f, -2.20274716e-03f, 9.99891683e-02f, 1.54064298e-01f, 9.42115635e-02f, 6.61783740e-02f, 1.39045089e-01f, 9.70747918e-02f, 2.15281010e-01f, 1.28982335e-01f,
  4.08597402e-02f, -1.57753736e-01f, -1.75428838e-01f, -9.84875783e-02f, -1.67954028e-01f, -1.53377965e-01f, -1.61499336e-01f, -4.65427972e-02f, -3.13535444e-02f, -6.47928491e-02f,
  -7.01202378e-02f, -3.14483643e-02f, -1.89854905e-01f, -9.23438445e-02f, -1.38895348e-01f, -7.79634863e-02f, -6.12320118e-02f, -3.99982631e-02f, -1.58673465e-01f, -8.95283744e-02f,
  -9.55604464e-02f, -1.83901548e-01f, -1.54805124e-01f, -1.06464066e-01f, -3.64011079e-02f, -1.12722553e-01f, -1.77230522e-01f, 8.95286328e-04f, -5.81901111e-02f, -1.10161044e-01f,
  3.04256856e-01f, 2.11909920e-01f, 5.06867245e-02f, 1.12784542e-02f, 1.51525838e-02f, 8.03407878e-02f, 8.38870853e-02f, -1.44086313e-02f, 9.05755386e-02f, 6.67844117e-02f,
  6.75264597e-02f, 9.11860764e-02f, 1.20201625e-01f, 6.61051497e-02f, 9.08989012e-02f, -3.52371577e-03f, 5.14101684e-02f, 4.69305404e-02f, 1.42644301e-01f, 1.15954109e-01f,
  1.21154077e-01f, 1.08367205e-01f, 8.17913115e-02f, 1.40013680e-01f, 6.37075156e-02f, 7.76815414e-02f, 4.04357240e-02f, 7.40214288e-02f, 1.42920956e-01f, 1.19223468e-01f,
  -5.47089912e-02f, 2.64317870e-01f, 1.59431204e-01f, 1.00576445e-01f, 7.86290094e-02f, 1.98636949e-01f, 3.36795717e-01f, 8.34166706e-02f, 2.24751402e-02f, 6.56305999e-02f,
  7.27349333e-03f, -2.07426950e-01f, -1.02852412e-01f, -1.47591516e-01f, -6.81967139e-02f, 1.21040083e-01f, 1.09860659e-01f, -8.69636014e-02f, -1.72372028e-01f, -3.08746751e-02f,
  -1.07357740e-01f, 3.37719023e-02f, -1.18093424e-01f, -6.15682863e-02f, -1.32129970e-03f, -8.78900290e-02f, -6.90454319e-02f, 3.23301852e-02f, -1.03201933e-01f, -1.15650855e-01f,
  -3.06848168e-01f, 6.41655773e-02f, 3.31662199e-03f, -1.06106050e-01f, -3.89867276e-02f, 2.36524269e-02f, 3.05505954e-02f, -1.99986100e-02f, -3.39098275e-02f, -5.06106354e-02f,
  -8.68227854e-02f, -1.18999057e-01f, -1.01957351e-01f, -7.68389134e-03f, -6.66155666e-02f, 3.73154022e-02f, 6.35294169e-02f, -5.98610267e-02f, -4.70602065e-02f, -1.00961000e-01f,
  1.41573176e-02f, -4.04146090e-02f, 1.42133385e-01f, 1.30440220e-01f, 5.83020858e-02f, -6.10633045e-02f, 6.11934252e-02f, -4.92767692e-02f, 1.53713236e-02f, 3.36984657e-02f,
  5.98352067e-02f, 1.02531090e-01f, 6.97950199e-02f, 9.62385982e-02f, -1.38263742e-03f, 3.36957239e-02f, 7.31165409e-02f, 1.52881313e-02f, -2.40510050e-02f, 6.19433969e-02f,
  4.00084965e-02f, 2.99930535e-02f, -3.44526693e-02f, 5.63298650e-02f, -7.98675641e-02f, 6.55329153e-02f, 1.39802962e-03f, 6.85925828e-03f, -4.45807762e-02f, 2.62000076e-02f,
  -1.54257752e-02f, 1.31270692e-01f, -2.64041834e-02f, 5.10780606e-03f, 7.22774193e-02f, 6.75963685e-02f, -1.60989631e-02f, 6.34822994e-02f, 5.71410842e-02f, 1.13744341e-01f,
  -1.55986652e-01f, -1.22744583e-01f, -1.74901754e-01f, -9.92896110e-02f, -8.01897347e-02f, -1.51066110e-01f, -1.24090292e-01f, -5.87983243e-02f, -1.03788868e-01f, -2.24871784e-02f,
  -5.21537103e-02f, 1.66992061e-02f, -2.41612215e-02f, 1.38592375e-02f, -6.52676523e-02f, -3.91009003e-02f, -3.40910405e-02f, -2.70453282e-02f, -9.30593088e-02f, -6.84002787e-03f,
  5.70429824e-02f, 7.56017631e-03f, -5.13022393e-02f, -3.93994600e-02f, -1.16643719e-02f, -1.61489636e-01f, -5.88375367e-02f, 5.20846024e-02f, 4.22883295e-02f, -1.74072236e-02f,
  -2.80224651e-01f, 4.03344065e-01f, 2.15602919e-01f, 1.79887250e-01f, 9.22487900e-02f, 1.21893547e-01f, 1.31817535e-01f, 9.24431756e-02f, 4.64464305e-03f, 2.24117637e-01f,
  2.26684272e-01f, 8.84292051e-02f, 1.19889885e-01f, 3.84676903e-02f, -1.35382444e-01f, 1.21424489e-01f, 5.57400845e-02f, -2.40930766e-01f, -2.70414442e-01f, -2.24428803e-01f,
  -2.22429018e-02f, -6.47399621e-03f, -2.24332049e-01f, -3.82051691e-02f, 4.11483608e-02f, -6.14787824e-02f, 1.11678258e-01f, 1.54435292e-01f, 1.53983578e-01f, 1.01262778e-01f,
  4.32085603e-01f, 1.98923022e-01f, 3.06512206e-03f, -8.08474084e-04f, 3.91688608e-02f, -8.05182159e-02f, 5.65790683e-02f, 2.82646567e-02f, 6.76685870e-02f, 6.22912832e-02f,
  3.74743342e-02f, -2.83077154e-02f, 3.48649616e-03f, -2.59538498e-02f, -2.87750587e-02f, -3.01163998e-02f, -2.36284006e-02f, -1.39159366e-01f, -1.08600426e-02f, 1.67136475e-01f,
  1.38234198e-01f, 4.66978438e-02f, 1.95247531e-01f, 1.73699521e-02f, -3.58170085e-02f, 2.50248089e-02f, 6.69241920e-02f, 7.28114322e-02f, -3.94657440e-02f, 1.42580897e-01f,
  -1.79289021e-02f, -4.37337644e-02f, -9.04186368e-02f, -1.23783708e-01f, -1.52600870e-01f, -1.00518771e-01f, -3.45538929e-02f, -9.36111733e-02f, -1.10341445e-01f, -9.26880315e-02f,
  -1.14194557e-01f, -7.70218372e-02f, -1.21815875e-01f, -1.12526111e-01f, -7.15793669e-02f, -5.48884235e-02f, -1.08935289e-01f, -7.51804411e-02f, 5.02720252e-02f, -1.82968110e-01f,
  -7.31582716e-02f, -9.06618163e-02f, -1.90083086e-02f, -1.32836282e-01f, -1.68821454e-01f, -4.00800258e-02f, -1.64217472e-01f, -1.16537765e-01f, -6.20896332e-02f, -1.28050029e-01f,
  7.27873445e-02f, 3.17213200e-02f, 1.16242088e-01f, -7.44293332e-02f, 1.14921361e-01f, 6.64386526e-03f, 1.28107890e-01f, -3.97561565e-02f, 5.14428644e-03f, 8.67075026e-02f,
  6.09814674e-02f, -3.35250571e-02f, 1.73370838e-01f, 9.82281193e-02f, -2.87631154e-03f, 3.75046507e-02f, 4.00724858e-02f, -1.20720919e-02f, -5.56446007e-03f, 4.95694950e-02f,
  1.90427661e-01f, -1.44386794e-02f, 9.02270526e-02f, 1.84454754e-01f, 6.89112321e-02f, -7.15735480e-02f, 1.20070666e-01f, 2.79920287e-02f, 6.20709918e-03f, 1.64900552e-02f,
  1.84541747e-01f, 3.21635008e-01f, -1.67025983e-01f, 2.26434439e-01f, -3.01676899e-01f, -3.75489503e-01f, -2.17794552e-01f, -2.50709169e-02f, 1.00711085e-01f, 1.54748186e-01f,
  -1.36072606e-01f, -5.13154343e-02f, 5.56725562e-02f, 1.18482495e-02f, -1.70696855e-01f, 5.22617921e-02f, 1.34606034e-01f, -3.71051356e-02f, -1.77082732e-01f, -1.36326894e-01f,
  7.54451677e-02f, 2.51827151e-01f, 1.22028977e-01f, 2.54977476e-02f, 1.71415374e-01f, 7.03578219e-02f, 2.14950278e-01f, 3.81684452e-02f, 6.37268424e-02f, 3.98516387e-01f,
  -4.66598868e-02f, -1.11622661e-01f, -2.08808258e-01f, -3.95014919e-02f, -3.47629115e-02f, 4.18908149e-02f, -7.08636865e-02f, 6.66566864e-02f, -4.09860313e-02f, 2.70974673e-02f,
  -6.89865872e-02f, 6.49966523e-02f, -8.05120990e-02f, -4.42333426e-03f, 7.12290555e-02f, -4.40738499e-02f, 5.76032251e-02f, 3.60913239e-02f, 4.08909097e-02f, 7.60718994e-03f,
  -1.87627226e-02f, -1.91472188e-01f, -1.75881073e-01f, -8.56472775e-02f, -1.28851235e-01f, -8.15602839e-02f, -1.13200083e-01f, -6.15530498e-02f, -8.29178169e-02f, 2.49495760e-01f,
  -4.15197387e-02f, -2.06816811e-02f, -3.78978699e-02f, 6.45261928e-02f, 5.77581562e-02f, 2.54394840e-02f, -1.02524702e-02f, 5.87198064e-02f, 3.01726777e-02f, -1.16533171e-02f,
  -2.59343740e-02f, 1.35698216e-02f, 7.63742775e-02f, 5.08518070e-02f, 5.97216636e-02f, 1.04400301e-02f, -2.19814274e-02f, 5.68255410e-02f, -4.57012057e-02f, 5.10325693e-02f,
  -2.01669279e-02f, -3.90708558e-02f, 1.24798678e-01f, 3.44331115e-02f, 3.07386387e-02f, 2.69626640e-02f, 3.23104970e-02f, -5.49116433e-02f, 2.05290392e-02f, -1.01583079e-01f,
  2.18709752e-01f, -2.12951928e-01f, 7.57370591e-02f, -4.65851128e-02f, 6.53248131e-02f, 4.45530377e-02f, -2.23019510e-03f, 3.92759331e-02f, 4.43028994e-02f, 3.76244001e-02f,
  -2.03693639e-02f, 1.91898104e-02f, 5.64121865e-02f, 1.44085241e-02f, -1.00695178e-01f, 7.67942593e-02f, 6.63633794e-02f, 4.50342372e-02f, -1.64243691e-02f, -2.93596722e-02f,
  1.03465945e-01f, 8.39928689e-04f, -1.66669767e-02f, 4.22750600e-02f, 2.02741250e-02f, -1.28410012e-01f, -6.25719428e-02f, -7.18414923e-03f, -1.86568767e-01f, 2.16922596e-01f,
  -4.80267704e-01f, 2.70483702e-01f, 2.92847574e-01f, -1.30865902e-01f, -3.83809693e-02f, -8.77583250e-02f, -4.46815044e-02f, -4.47863825e-02f, -1.45004407e-01f, 7.23890811e-02f,
  1.04284972e-01f, 5.98716587e-02f, -4.59762476e-02f, -3.00636832e-02f, 1.23375863e-01f, 1.23656057e-02f, -5.19178621e-02f, -3.28646526e-02f, -1.21156819e-01f, -1.79538682e-01f,
  -1.45668134e-01f, -2.03515515e-01f, -8.92481729e-02f, -1.33594468e-01f, -1.25293642e-01f, -8.18038583e-02f, -9.76571888e-02f, -1.81377381e-01f, -1.46935061e-01f, -2.07739174e-01f,
  1.52751446e-01f, 2.60820128e-02f, 6.87002912e-02f, -9.62888524e-02f, 9.41008851e-02f, -4.07567108e-03f, 1.17720619e-01f, 1.46347815e-02f, 3.29306312e-02f, 3.16428579e-02f,
  -2.91408096e-02f, 9.22525078e-02f, -1.86948944e-02f, 8.02242681e-02f, -2.60920301e-02f, 2.80072317e-02f, -2.36215885e-03f, 3.79160978e-02f, 8.17194358e-02f, 2.41160039e-02f,
  4.14178893e-02f, -7.93804526e-02f, -3.53320204e-02f, 1.14465818e-01f, -1.98582802e-02f, -6.45113960e-02f, -3.29121277e-02f, -1.13098912e-01f, -1.06902197e-01f, -1.07698575e-01f,
  6.68451414e-02f, -6.92911595e-02f, -1.43690892e-02f, 3.32449153e-02f, -5.87754995e-02f, 1.39591573e-02f, -6.05509132e-02f, -3.78680564e-02f, -2.38625072e-02f, -5.77556435e-03f,
  4.73902449e-02f, 7.02182716e-03f, 4.31850255e-02f, -6.81911260e-02f, -6.51008934e-02f, 1.27050914e-02f, -1.75850987e-01f, -1.57075026e-03f, 3.80518846e-02f, 1.29531194e-02f,
  -1.16820320e-01f, -9.93220834e-04f, -3.69395092e-02f, 2.80877333e-02f, -9.58847106e-02f, 7.32492581e-02f, 1.43081136e-02f, 1.42789800e-02f, -6.63231164e-02f, 9.10073891e-03f,
  2.04896912e-01f, 9.33878943e-02f, 1.08666988e-02f, -2.08354904e-03f, -4.37743999e-02f, 4.06212658e-02f, 6.01694770e-02f, 8.15594941e-02f, -3.34736183e-02f, 3.67946364e-03f,
  1.08922529e-03f, 1.13416635e-01f, 7.90299475e-02f, 6.77866191e-02f, -7.74663966e-03f, 1.08578146e-01f, 3.91300991e-02f, -8.42294097e-02f, 8.06596503e-02f, 7.10113198e-02f,
  1.10907018e-01f, -1.28527984e-01f, -3.06401737e-02f, 1.09578436e-02f, 2.98378553e-04f, -3.16086411e-02f, -2.49016900e-02f, -7.84274414e-02f, -2.92556789e-02f, -6.43776283e-02f,
  5.03165834e-02f, -2.39104614e-01f, -3.31410915e-02f, 1.12174042e-01f, 1.38158947e-01f, 1.13432378e-01f, -8.14247504e-02f, 1.31446257e-01f, -2.62638349e-02f, -5.28673530e-02f,
  -7.57452920e-02f, 1.06780030e-01f, 5.83999678e-02f, -9.69856232e-02f, 9.95027740e-03f, -1.29189983e-01f, -5.27807884e-02f, 9.06814709e-02f, 1.57535419e-01f, 1.90018997e-01f,
  4.04143073e-02f, 1.67967036e-01f, 8.34060311e-02f, 4.48508514e-03f, -1.18576795e-01f, 8.45098868e-03f, -1.59227341e-01f, -7.00101480e-02f, -1.94582045e-01f, -2.91577280e-01f,
  -2.01955721e-01f, -2.93748885e-01f, -1.91396996e-02f, -3.94992018e-03f, -6.76003173e-02f, -1.50464594e-01f, -1.24784738e-01f, -1.18292280e-01f, -2.29913723e-02f, -9.02378857e-02f,
  -7.23142549e-02f, -1.14257403e-01f, -1.65907100e-01f, -8.33515972e-02f, -7.37973005e-02f, -5.13914935e-02f, -1.22500896e-01f, -4.79438715e-03f, -6.45935684e-02f, -9.75221917e-02f,
  -6.02275208e-02f, 1.46646071e-02f, 7.98668861e-02f, 6.60492573e-03f, -9.62612554e-02f, 1.71968040e-05f, -6.99378774e-02f, -9.04117804e-03f, -9.62935686e-02f, -6.79635257e-02f,
  4.26179526e-04f, -9.97654814e-03f, -1.40933413e-02f, -1.10244118e-01f, 1.60745736e-02f, 7.19758356e-03f, -2.18226779e-02f, -8.64259526e-02f, 5.90495542e-02f, 7.18796684e-04f,
  2.80993450e-02f, 1.78276992e-03f, -1.11864852e-02f, -6.05163118e-03f, -2.40978803e-02f, 1.83406137e-02f, -3.81189806e-04f, -2.42424887e-02f, -1.64570622e-02f, -2.26065032e-02f,
  -6.16243668e-02f, 1.25146741e-02f, 1.77349783e-02f, -4.58720475e-02f, -8.36998373e-02f, 2.10860558e-02f, -6.54998496e-02f, -1.59845278e-02f, 7.42154047e-02f, -9.78949219e-02f,
  3.05730075e-01f, 3.43587734e-02f, -6.72985613e-02f, -1.28375515e-01f, -1.35904364e-02f, -7.40932077e-02f, 5.25908265e-03f, -7.21149519e-02f, -1.13401368e-01f, -3.05062421e-02f,
  -5.07878512e-02f, 1.48531878e-02f, -1.17913723e-01f, 4.05191928e-02f, 2.23157443e-02f, 1.77081842e-02f, 6.09793961e-02f, 6.19584098e-02f, 7.09814280e-02f, 6.05305322e-02f,
  6.67732507e-02f, 2.23760530e-01f, 1.47143528e-01f, 1.50503397e-01f, 2.33028103e-02f, 9.73450840e-02f, 7.07661211e-02f, 1.28318235e-01f, 7.10105300e-02f, 1.41702712e-01f,
  -6.21765912e-01f, -4.05228108e-01f, 4.13683243e-02f, -3.83113205e-01f, -5.24752997e-02f, 1.25205636e-01f, -2.23078169e-02f, 4.04784805e-04f, -1.04628772e-01f, -4.20226395e-01f,
  -2.92429268e-01f, -1.00222751e-01f, -4.52503338e-02f, 8.66512284e-02f, 1.03032567e-01f, -6.43097609e-02f, -9.99272894e-03f, 2.54874229e-01f, 2.74284452e-01f, 1.66513860e-01f,
  -2.83537805e-02f, -1.93971619e-01f, -1.75538898e-01f, -3.24501805e-02f, -1.14768349e-01f, -8.90518501e-02f, -1.89493656e-01f, -9.11617652e-02f, -1.65526137e-01f, -3.09253335e-01f,
  -6.06828928e-02f, -2.61784166e-01f, 1.15242817e-01f, -7.36158937e-02f, -1.00722477e-01f, -1.10787274e-02f, -1.13385767e-01f, -4.47679125e-02f, -4.61985692e-02f, -2.02684820e-01f,
  -7.54945204e-02f, -5.11972196e-02f, -1.00131817e-01f, -3.26284878e-02f, -1.48767844e-01f, -7.27862194e-02f, -4.08396125e-02f, 5.32405972e-02f, 2.01599076e-02f, -1.27927676e-01f,
  -9.41298530e-02f, -1.42305210e-01f, -3.45735066e-02f, 2.99987681e-02f, 4.89861034e-02f, 1.14755100e-02f, -6.39768615e-02f, -6.60365447e-02f, 4.94187102e-02f, -2.22173706e-01f,
  -2.11371407e-02f, 9.21779685e-03f, 6.94864020e-02f, 4.55017313e-02f, 2.62119863e-02f, 3.76831517e-02f, 7.93198720e-02f, 7.14197233e-02f, 5.53402826e-02f, 3.34895514e-02f,
  4.98949215e-02f, 5.92122562e-02f, 1.05244383e-01f, -2.07440052e-02f, 7.44037032e-02f, 4.75869477e-02f, 7.83173889e-02f, -2.30639633e-02f, 8.68789852e-02f, 1.21691711e-02f,
  2.30338257e-02f, 1.18899256e-01f, -4.26819250e-02f, 1.56723857e-01f, 5.61768226e-02f, 9.27933678e-03f, 7.19387531e-02f, -1.32579142e-02f, 1.01707831e-01f, -2.18524747e-02f,
  -8.85221139e-02f, 1.07225969e-01f, -5.09122871e-02f, -5.86099625e-02f, -6.27955496e-02f, -9.45398435e-02f, -1.02515139e-01f, -9.20652524e-02f, -8.12563896e-02f, -3.69438604e-02f,
  -3.01291030e-02f, -1.82516146e-02f, -8.23712647e-02f, -1.08430013e-02f, 5.65855578e-02f, -8.52250904e-02f, -1.89890847e-01f, -5.74501902e-02f, -2.70727929e-02f, -1.33581832e-01f,
  -1.74844950e-01f, -1.49661213e-01f, -5.10313222e-03f, 2.56728358e-03f, -2.18580365e-02f, -1.77382305e-02f, -7.01989830e-02f, 2.93248193e-03f, 3.30929160e-02f, -1.59418672e-01f,
  -3.79505962e-01f, 2.83146411e-01f, -3.85907553e-02f, -2.21050810e-02f, -8.66276994e-02f, -1.36984661e-01f, -9.28440019e-02f, -1.92423865e-01f, -1.65037885e-02f, 1.44301891e-01f,
  8.50461498e-02f, -5.90285584e-02f, 1.25288629e-04f, 1.33818254e-01f, -3.59491520e-02f, 4.68345769e-02f, 1.56249657e-01f, -4.32890430e-02f, -2.30972722e-01f, -1.75259681e-03f,
  1.09552220e-01f, -2.43820474e-02f, -7.86897093e-02f, 1.83955245e-02f, 2.11835995e-01f, 1.19547367e-01f, 1.52621686e-01f, 1.43689841e-01f, 1.04124635e-01f, 3.15471053e-01f,
  2.47358114e-01f, -2.36336105e-02f, -3.32494788e-02f, 1.21848062e-01f, 3.75520289e-02f, 6.58985674e-02f, 3.95131893e-02f, 1.27738297e-01f, -3.61069962e-02f, 6.43529668e-02f,
  7.81630352e-02f, 6.45476952e-02f, 8.64570811e-02f, 1.06373504e-01f, -1.10142464e-02f, -1.06676612e-02f, 7.22016841e-02f, -2.60927863e-02f, -3.16053480e-02f, 1.14589661e-01f,
  1.01862542e-01f, 7.09839761e-02f, -1.18183687e-01f, 3.53903249e-02f, -4.71013263e-02f, 4.40860279e-02f, -2.15985794e-02f, 7.21861720e-02f, -4.48874645e-02f, 5.35649471e-02f,
  -1.07555360e-01f, -7.39557445e-02f, -3.93680148e-02f, -3.33276507e-03f, 4.16969284e-02f, 1.44271087e-02f, 5.92094380e-03f, 1.99808367e-03f, 4.78655621e-02f, -1.06396331e-02f,
  -6.31859526e-02f, -4.43553030e-02f, -2.92428453e-02f, -8.88445377e-02f, 6.34581819e-02f, 4.85730693e-02f, -3.71595174e-02f, 2.28735860e-02f, -3.40625644e-03f, -3.04922573e-02f,
  -3.46923955e-02f, -9.38230008e-02f, -2.25497112e-02f, 1.07904188e-02f, 5.23802303e-02f, -7.88430870e-02f, 5.27137965e-02f, 1.53222075e-03f, -2.98940912e-02f, 3.06979287e-02f,
  -7.41757676e-02f, -1.08310834e-01f, 6.89755306e-02f, -3.73274013e-02f, -6.44632876e-02f, 2.76344419e-02f, -3.18911411e-02f, 6.94852024e-02f, 5.06415367e-02f, 3.57228913e-03f,
  -4.21426110e-02f, -9.03588906e-03f, 2.98221335e-02f, 4.82418872e-02f, 3.84434648e-02f, -1.60102267e-02f, 1.03656165e-01f, 5.52261770e-02f, 2.44985726e-02f, 1.02228457e-02f,
  6.30627573e-02f, -8.34579691e-02f, -1.85478374e-01f, -3.90362814e-02f, -5.87042943e-02f, -1.63865328e-01f, -1.23358436e-01f, -1.12670138e-01f, -2.31043413e-01f, -1.36418074e-01f,
  6.41767442e-01f, 3.92721504e-01f, 1.55426040e-01f, 3.07685167e-01f, 8.94943923e-02f, 5.36198281e-02f, 3.59842271e-01f, 1.92021921e-01f, 1.26735955e-01f, 2.07875729e-01f,
  -1.05351418e-01f, 3.59907858e-02f, 1.43296629e-01f, 1.53721422e-01f, 2.33034641e-01f, 3.18447500e-01f, 1.79020196e-01f, 1.78944543e-01f, 1.57315910e-01f, 9.93009359e-02f,
  1.74733415e-01f, 9.46172029e-02f, 2.35092372e-01f, 1.28877476e-01f, 2.17430964e-01f, 1.34638369e-01f, 3.99650447e-02f, 1.29631266e-01f, 1.40292406e-01f, 2.20727041e-01f,
  1.61498800e-01f, 3.41291606e-01f, 1.29176408e-01f, 1.60528421e-01f, 4.87208813e-02f, 1.63529381e-01f, 1.57993510e-01f, 2.36781701e-01f, 2.08446801e-01f, 2.01629594e-01f,
  2.98257433e-02f, 1.80571809e-01f, 2.05868661e-01f, 1.82170898e-01f, 1.89174980e-01f, 2.85911322e-01f, 2.48046026e-01f, 3.06542903e-01f, 1.72823042e-01f, 2.13770568e-01f,
  1.11445457e-01f, 2.66320467e-01f, 3.72089237e-01f, 2.60856241e-01f, 1.91413045e-01f, 9.61995870e-02f, 2.65863150e-01f, 2.49631256e-01f, 2.05233455e-01f, 3.19809407e-01f,
  -5.93440756e-02f, -1.53153256e-01f, -1.70094222e-01f, -1.37092829e-01f, -1.86308920e-01f, -1.21681690e-01f, -1.53469920e-01f, -2.20998719e-01f, -1.96159154e-01f, -3.70904170e-02f,
  -1.46337524e-01f, -4.33550999e-02f, -1.82806581e-01f, -2.68165842e-02f, -1.91773713e-01f, -2.53198091e-02f, -1.23617642e-01f, -3.74525599e-02f, -1.37061283e-01f, -3.69355716e-02f,
  -4.77477275e-02f, -1.52191922e-01f, -8.37869793e-02f, -1.19231269e-01f, -1.38430387e-01f, -6.31776452e-02f, -9.51994359e-02f, -2.35688761e-01f, -1.00930512e-01f, -1.14090435e-01f,
  4.59654517e-02f, 1.12268969e-01f, 3.12191457e-01f, 1.29572928e-01f, 1.34284496e-01f, 1.38637289e-01f, 2.10184857e-01f, 1.74270526e-01f, 1.58414766e-01f, 1.57667443e-01f,
  1.44805148e-01f, 9.67446864e-02f, 1.71578899e-01f, 1.11058697e-01f, 1.67534664e-01f, 1.26030147e-01f, 1.48557231e-01f, 1.49425864e-01f, 2.05626994e-01f, 1.24494575e-01f,
  1.50661871e-01f, 3.27051461e-01f, 2.82449573e-01f, 2.96534896e-01f, 2.18190491e-01f, 2.03352422e-01f, 1.95576906e-01f, 2.16235578e-01f, 2.12191343e-01f, 3.77157390e-01f,
  -1.67228077e-02f, 1.97796319e-02f, -4.77723747e-01f, -4.70056519e-04f, 1.06750548e-01f, -8.56119841e-02f, 1.33090422e-01f, 5.71174435e-02f, 3.41590159e-02f, -1.37173505e-02f,
  -4.28924672e-02f, -2.52617933e-02f, -1.09718360e-01f, -5.86443543e-02f, -1.98727190e-01f, -1.10017009e-01f, -1.21118426e-01f, -1.69949308e-01f, -1.21544590e-02f, 2.26007879e-01f,
  2.05062404e-01f, 1.80263028e-01f, -7.55756050e-02f, 5.08861803e-02f, 2.02461220e-02f, -1.40413672e-01f, -1.51233435e-01f, -6.41791662e-03f, -3.89731415e-02f, 2.60517858e-02f,
  -3.56040567e-01f, -2.06109866e-01f, -1.88057154e-01f, 2.21857037e-02f, -2.15920806e-01f, -1.90642715e-01f, -1.51436850e-01f, -1.65927976e-01f, -6.01905845e-02f, -1.18332855e-01f,
  -8.21994916e-02f, -1.26379296e-01f, -1.07921697e-01f, -1.92228705e-02f, -8.07067454e-02f, -1.30245492e-01f, -1.89055204e-01f, -2.71547884e-01f, -2.52168775e-01f, -1.37929395e-01f,
  -3.58340368e-02f, 4.51913849e-02f, -1.35166079e-01f, -1.33729249e-01f, -2.78200239e-01f, -1.76608816e-01f, -1.32047296e-01f, -2.00965971e-01f, -2.65146166e-01f, -2.13747293e-01f,
  1.38025716e-01f, 8.72764066e-02f, 4.10312489e-02f, 1.13665104e-01f, 1.55023724e-01f, 1.11406311e-01f, 7.21661448e-02f, 5.82847707e-02f, 1.29715756e-01f, 1.34411350e-01f,
  1.20948374e-01f, 6.46352321e-02f, 1.70470133e-01f, 7.42154345e-02f, 7.07780048e-02f, 1.18517667e-01f, 1.05109900e-01f, 1.05644085e-01f, 2.06343154e-03f, 6.63674250e-02f,
  7.87834004e-02f, 1.12736136e-01f, 2.41496898e-02f, -4.48979158e-03f, 3.35896537e-02f, 2.13759542e-02f, 1.34714350e-01f, 4.55560349e-02f, 3.92298810e-02f, 1.77845985e-01f,
  -2.15650931e-01f, -1.86387584e-01f, -5.45499846e-02f, -2.91386396e-02f, -1.92469895e-01f, -1.14075072e-01f, -6.19076639e-02f, -2.22900391e-01f, -6.00523166e-02f, -6.22198619e-02f,
  -1.83157828e-02f, -7.02800751e-02f, -1.55346766e-01f, -7.01822490e-02f, -8.32421258e-02f, -8.43187422e-02f, -4.96469848e-02f, -1.34076402e-01f, -6.13812990e-02f, -1.73244685e-01f,
  -1.58642545e-01f, -9.84039828e-02f, -2.23585501e-01f, -1.16516359e-01f, -1.74020305e-01f, -1.12765647e-01f, -2.70868838e-01f, -1.75724357e-01f, -1.76917195e-01f, -2.40325227e-01f,
  -2.24599570e-01f, -1.93411022e-01f, 4.98485826e-02f, -1.90621167e-01f, -1.47043109e-01f, -5.17714880e-02f, -1.81757256e-01f, -1.05070285e-01f, -1.37146935e-01f, -2.05624163e-01f,
  5.39678819e-02f, 9.02301297e-02f, 2.36872081e-02f, 4.35100272e-02f, 1.10973664e-01f, -9.61432531e-02f, -7.49940872e-02f, 6.78904913e-03f, -2.22932305e-02f, -3.52006257e-02f,
  -1.36292800e-01f, -1.41858444e-01f, -1.00983039e-01f, -6.39161617e-02f, -9.58093628e-02f, -8.57639778e-03f, 1.49190323e-02f, -3.80690880e-02f, -6.06426969e-02f, -2.49173343e-01f,
  4.71119583e-02f, -3.03009478e-03f, 1.06817678e-01f, -5.49981259e-02f, 2.30904110e-02f, 1.21558636e-01f, 3.42924483e-02f, 9.02228057e-02f, 9.99187753e-02f, 4.11439054e-02f,
  -4.27302346e-02f, 4.98515693e-03f, -4.07621153e-02f, 6.40684143e-02f, 2.85711121e-02f, 3.06283254e-02f, 2.43694019e-02f, 3.92590724e-02f, 1.05713613e-01f, 9.14569125e-02f,
  -1.08441956e-01f, -1.29801422e-01f, -4.18183804e-02f, 1.18753739e-01f, 2.16864407e-01f, -3.46309296e-03f, 1.30738214e-01f, 3.81922200e-02f, 1.86311081e-01f, 8.82752892e-03f,
  -2.07247958e-01f, 9.41777155e-02f, -5.46392091e-02f, -1.89816281e-02f, 1.61434840e-02f, 4.02427465e-02f, -6.30777106e-02f, 1.25824818e-02f, -8.68823528e-02f, 7.81064630e-02f,
  -2.33979523e-02f, 7.07488507e-02f, -1.94216259e-02f, 3.37814912e-02f, 2.60856864e-03f, -7.51649495e-03f, -2.07716711e-02f, -3.72229330e-02f, 9.76285040e-02f, 1.69210136e-02f,
  -1.76934097e-02f, 6.82934523e-02f, 9.44890603e-02f, 4.03667465e-02f, -1.17420591e-02f, -2.53093299e-02f, -3.83979008e-02f, -3.38813663e-02f, -3.06682102e-03f, -3.08314431e-03f,
  3.22893038e-02f, 1.66953221e-01f, -4.44036238e-02f, 1.24175385e-01f, -4.82377857e-02f, 2.46998910e-02f, 4.43487577e-02f, 3.97796072e-02f, 2.11267788e-02f, -4.50333394e-02f,
  1.19088948e-01f, -3.44860554e-02f, 4.26773028e-03f, -1.58351138e-02f, -9.10828914e-03f, 1.31738950e-02f, -1.59513783e-02f, -4.65898551e-02f, 1.01069480e-01f, 1.18156997e-02f,
  5.71723990e-02f, -8.27305466e-02f, -9.12576243e-02f, 2.36644298e-02f, 5.89543581e-03f, -6.07884256e-04f, 7.65520036e-02f, 6.27829507e-02f, 3.50268595e-02f, -1.32373899e-01f,
  -4.24382120e-01f, -2.15877950e-01f, -3.79728973e-01f, -2.08802707e-02f, 6.43758029e-02f, -5.34893423e-02f, 1.06793433e-01f, 1.09571613e-01f, 2.30405137e-01f, 7.65810302e-03f,
  -1.90519378e-01f, 2.42243502e-02f, -1.40992075e-01f, 3.98233049e-02f, -7.41090551e-02f, 2.58274619e-02f, 3.06391064e-02f, -1.99680552e-01f, -8.74831304e-02f, 6.03252575e-02f,
  2.34872863e-01f, -2.49764398e-02f, -1.21899031e-01f, -2.99088787e-02f, 9.39510539e-02f, -3.48071917e-03f, -5.45872860e-02f, -1.71791613e-01f, -7.29083344e-02f, -8.18788037e-02f,
  -3.67990613e-01f, -2.02392042e-01f, 6.76074624e-02f, 1.07734203e-01f, -4.77323122e-02f, 1.36248618e-01f, -1.07071176e-02f, 4.51238900e-02f, 1.16403673e-04f, 7.66578224e-03f,
  -7.43765980e-02f, 7.29280338e-02f, -6.82058707e-02f, -1.64332483e-02f, -5.61241247e-02f, -1.46370959e-02f, 4.39024456e-02f, -9.58368473e-04f, -4.89796698e-02f, -1.07001411e-02f,
  8.56193751e-02f, -2.21267287e-02f, -6.38886169e-02f, 7.82632232e-02f, 1.59165263e-02f, -8.02045539e-02f, -8.72681066e-02f, 4.48811473e-03f, 4.04973701e-02f, 1.72596231e-01f,
  3.21283266e-02f, -1.49318650e-01f, -5.28813377e-02f, -4.70671244e-03f, 4.14578430e-02f, -9.04281661e-02f, -4.38687019e-02f, -7.64581189e-02f, -3.17243896e-02f, 1.47899585e-02f,
  -8.77226517e-02f, 6.09741732e-03f, 1.58425812e-02f, -1.96580850e-02f, -6.59760088e-02f, -6.05033040e-02f, -7.31205568e-02f, -5.12554571e-02f, -3.13455090e-02f, -3.02349068e-02f,
  -1.02905139e-01f, -7.68528227e-03f, -1.52640730e-01f, -4.24583554e-02f, 7.80199692e-02f, -8.79929885e-02f, 6.15133019e-03f, 5.06323241e-02f, 4.83236313e-02f, -9.35785621e-02f,
  1.04862839e-01f, -1.96157143e-01f, -1.89176537e-02f, -4.81292978e-03f, -5.05218171e-02f, -1.08328294e-02f, -1.27970455e-02f, 2.89319791e-02f, -9.28199291e-02f, -1.62943378e-02f,
  -8.25825557e-02f, -4.84439805e-02f, -1.23450033e-01f, 3.10175605e-02f, 7.87604377e-02f, -4.01668344e-03f, 7.49958977e-02f, -7.33017474e-02f, -3.14344987e-02f, -3.10494006e-02f,
  1.01616807e-01f, -2.09962912e-02f, -8.48516971e-02f, 4.42049205e-02f, -2.75527239e-02f, -3.42306867e-02f, -1.09947264e-01f, 6.68701082e-02f, -5.75710200e-02f, 2.25687101e-01f,
  4.78596389e-01f, -5.22569157e-02f, -5.93795022e-03f, 9.28315595e-02f, -9.30436179e-02f, -1.40071675e-01f, -4.49016429e-02f, -5.74846752e-02f, 9.59246382e-02f, 6.40666485e-02f,
  -2.23265849e-02f, 1.59396559e-01f, 1.41126484e-01f, 4.29634377e-02f, 2.56551318e-02f, 2.89920121e-02f, -8.98984447e-03f, 2.50744611e-01f, 2.25869402e-01f, 2.14719102e-01f,
  1.54997438e-01f, 2.25357309e-01f, 2.87909418e-01f, 1.57780379e-01f, 1.53022945e-01f, 2.09090903e-01f, 9.66078043e-02f, 1.41602039e-01f, 1.87476248e-01f, 2.84142613e-01f,
  3.36433917e-01f, 2.24955514e-01f, 1.30313113e-01f, 1.38164431e-01f, -1.35611836e-03f, 1.46958441e-01f, 1.10658392e-01f, 4.43526432e-02f, 1.25395045e-01f, 1.04492337e-01f,
  1.59305125e-01f, 9.80554819e-02f, 1.59538954e-01f, 4.44204248e-02f, 1.72266841e-01f, 2.28188038e-01f, 5.74465021e-02f, 1.14365906e-01f, 1.81654066e-01f, 6.96157664e-02f,
  1.05803609e-01f, 8.08957368e-02f, 1.16079986e-01f, 1.69551045e-01f, 1.67249694e-01f, 1.45615309e-01f, 1.60552070e-01f, 2.13995486e-01f, 1.83995605e-01f, 2.44534060e-01f,
  8.19913819e-02f, -1.88273117e-01f, -1.24685340e-01f, -1.73887074e-01f, -2.11034149e-01f, -2.09073588e-01f, -1.44115791e-01f, -2.16216743e-01f, -6.04936182e-02f, -1.13439038e-01f,
  -2.25685671e-01f, -1.74127877e-01f, -1.05843365e-01f, -1.55996576e-01f, -9.77796093e-02f, -7.64760450e-02f, -1.79582208e-01f, -1.94308877e-01f, -8.55771378e-02f, -1.37131348e-01f,
  -1.44311666e-01f, -1.13504536e-01f, -1.20709851e-01f, -1.62113398e-01f, -1.51519045e-01f, -2.02488661e-01f, -1.75892726e-01f, -9.20007974e-02f, -1.36041895e-01f, -2.54945487e-01f,
  1.51553631e-01f, -1.71642646e-01f, 2.76078165e-01f, 2.27248624e-01f, 1.68288946e-01f, 1.56857699e-01f, 1.52864695e-01f, 1.09543294e-01f, 8.98872763e-02f, 1.17940858e-01f,
  9.17591974e-02f, 1.51784971e-01f, 1.10714592e-01f, 2.13176340e-01f, 1.74193710e-01f, 8.86912122e-02f, 1.30073547e-01f, 2.49199316e-01f, 1.47413075e-01f, 1.81058004e-01f,
  2.44941842e-02f, 2.00700432e-01f, 3.70200574e-01f, 2.34456062e-01f, 2.10513592e-01f, 3.05506229e-01f, 2.32855067e-01f, 2.52434641e-01f, 1.90033242e-01f, 3.12548906e-01f,
  4.92127687e-01f, -4.53324437e-01f, -1.60225511e-01f, 2.04663068e-01f, -1.05458170e-01f, -5.28937057e-02f, -1.41378239e-01f, 2.07761139e-01f, 1.80372298e-01f, -2.32185163e-02f,
  -1.98465049e-01f, 2.76014898e-02f, 6.33424148e-02f, 4.07956727e-02f, 1.61864862e-01f, 3.13864648e-02f, 9.11960006e-02f, 2.52252162e-01f, 2.62436301e-01f, 7.67671615e-02f,
  -1.52626596e-02f, 9.45533812e-02f, 1.63375810e-01f, 1.28382102e-01f, 6.04348397e-03f, 1.01722769e-01f, -7.58390054e-02f, -1.79516256e-01f, -2.33122543e-01f, -7.14940578e-02f,
  -1.44259676e-01f, -3.31521370e-02f, 2.40624145e-01f, 1.14815548e-01f, 1.18093018e-03f, 1.61018044e-01f, 1.00209653e-01f, 4.16572951e-02f, 5.44610247e-02f, 1.12907842e-01f,
  1.54915610e-02f, 1.15066588e-01f, 5.40116206e-02f, 1.61759201e-02f, 1.22428060e-01f, 6.41822070e-02f, 1.59797207e-01f, 7.06035495e-02f, 6.00239038e-02f, -6.02803826e-02f,
  -9.55446661e-02f, -1.60219684e-01f, -6.09688740e-03f, 9.15079117e-02f, 6.21258952e-02f, 1.40999138e-01f, -1.70358904e-02f, 8.42587501e-02f, 9.03607830e-02f, 4.47960123e-02f,
  -1.26837781e-02f, -2.06461146e-01f, -1.67276561e-01f, -1.18097074e-01f, -1.38008490e-01f, 2.93611232e-02f, -5.03212921e-02f, -1.33662075e-01f, -7.06442595e-02f, -1.03215672e-01f,
  -1.04323491e-01f, -5.24541698e-02f, -1.30559027e-01f, -4.07535248e-02f, -8.09138119e-02f, -1.49865016e-01f, -6.45126179e-02f, -1.67747200e-01f, -6.28554896e-02f, -1.26210362e-01f,
  3.10108252e-03f, -6.58232272e-02f, -8.64149705e-02f, 1.34815518e-02f, -2.42074430e-02f, -1.01011030e-01f, -6.35449290e-02f, -1.27991796e-01f, -1.74774304e-02f, -1.49327800e-01f,
  2.07428094e-02f, 7.11500868e-02f, 1.32687628e-01f, 2.03298837e-01f, 2.58946624e-02f, -1.62448697e-02f, -7.51381665e-02f, 6.61361814e-02f, 4.48909178e-02f, 6.63120747e-02f,
  -3.90342325e-02f, 9.05144811e-02f, 6.97034597e-02f, 3.61397155e-02f, 1.58682331e-01f, 1.78299531e-01f, 4.01432663e-02f, 1.28134787e-01f, 2.77577229e-02f, 2.90384144e-02f,
  6.68918863e-02f, 1.20171934e-01f, 4.99168187e-02f, 1.26695782e-01f, 9.66728702e-02f, 1.66512951e-01f, 6.49338588e-02f, 1.41890004e-01f, 9.47408453e-02f, 1.44463480e-01f,
  4.50509578e-01f, -1.10516027e-01f, 1.26274720e-01f, 7.10032955e-02f, -8.99214223e-02f, -6.71330094e-02f, -2.06270754e-01f, -9.08616558e-03f, 6.72647506e-02f, 1.77796539e-02f,
  -4.27195914e-02f, -5.94612770e-02f, 6.55778870e-02f, -1.28789529e-01f, -5.99366762e-02f, -5.68026528e-02f, -7.19086230e-02f, 4.78949351e-03f, 5.40460162e-02f, -9.36825201e-02f,
  -1.49615869e-01f, -5.74848242e-02f, 4.35153628e-03f, -6.80027902e-02f, 6.88090995e-02f, 1.40275225e-01f, -2.66706645e-02f, -1.30886096e-03f, -5.35238832e-02f, 1.42817780e-01f,
  2.50639051e-01f, 7.93573856e-02f, -8.10452029e-02f, -4.95815985e-02f, -1.66040778e-01f, 1.59788970e-02f, -3.67980227e-02f, 1.30990706e-03f, -1.28022417e-01f, -5.50380759e-02f,
  -1.07325986e-01f, -5.95486611e-02f, -4.27444726e-02f, -1.25060156e-01f, -4.20753583e-02f, -7.89626781e-03f, -1.31038055e-01f, -1.64660607e-02f, 3.93661344e-03f, -1.14292078e-01f,
  -1.43678993e-01f, -1.28298312e-01f, 4.43234481e-02f, -8.88456404e-02f, -1.52689097e-02f, -1.10208102e-01f, -6.66544065e-02f, -3.21605541e-02f, -2.94569191e-02f, 1.39774576e-01f,
  -1.68605894e-01f, -3.87532376e-02f, -9.99375731e-02f, 2.42494904e-02f, 2.67766342e-02f, 1.53432507e-02f, -4.47954610e-02f, -7.17342412e-03f, -4.70512584e-02f, -2.33012717e-03f,
  -2.44973954e-02f, 2.07145941e-02f, -6.54730201e-02f, 6.18034713e-02f, -5.61064668e-02f, -5.18347211e-02f, -9.95743498e-02f, 1.15873022e-02f, 5.26043586e-02f, -2.55172756e-02f,
  -5.78158116e-03f, -2.38392390e-02f, 1.05212936e-02f, -1.91058256e-02f, -5.67423366e-02f, -1.29070565e-01f, 3.20247822e-02f, 6.44848868e-02f, -2.99361106e-02f, 6.98322244e-03f,
  1.46122172e-01f, -2.97165662e-01f, 7.45540336e-02f, 3.46270911e-02f, -3.02924532e-02f, -3.39935794e-02f, -1.03591390e-01f, -4.51605096e-02f, 2.37901555e-03f, 6.49280176e-02f,
  -1.46299722e-02f, 5.10396063e-02f, -7.63174742e-02f, -7.90256727e-03f, -1.95855089e-02f, -1.81474891e-02f, -1.71623573e-01f, -4.47070263e-02f, -1.07430585e-01f, -1.58565417e-02f,
  -1.87464505e-01f, -2.89405175e-02f, 6.01482280e-02f, 3.14581282e-02f, -1.24668084e-01f, 5.73355588e-04f, 1.58129577e-02f, -3.99849676e-02f, 1.39804101e-02f, -9.11039952e-03f,
  1.82098970e-01f, -9.24523571e-04f, -1.89178392e-01f, 7.09589720e-02f, -8.65240768e-02f, -9.73777100e-02f, -2.94003859e-02f, 4.33035903e-02f, 1.01816826e-01f, -1.35291860e-01f,
  -1.11156605e-01f, -8.43481719e-02f, -1.22171231e-01f, -4.23524715e-02f, -1.21830786e-02f, -1.03509061e-01f, 5.00192381e-02f, -2.79193241e-02f, -1.57238156e-01f, 2.56694332e-02f,
  -9.25336108e-02f, 9.88263870e-04f, 8.40410516e-02f, 1.48845802e-03f, 4.93675172e-02f, -3.19305696e-02f, 3.62172835e-02f, 6.57423586e-02f, -7.89535269e-02f, 9.84522793e-03f,
  -3.04709941e-01f, 4.09071445e-02f, -1.41681761e-01f, -9.60720628e-02f, -1.04216687e-01f, 3.55016328e-02f, -1.05158016e-01f, 1.81139447e-02f, 5.41660823e-02f, -9.37824547e-02f,
  -3.12863290e-02f, -1.38448700e-01f, -1.84481982e-02f, -1.30390003e-02f, -9.95877013e-02f, 2.82704327e-02f, 3.31941321e-02f, 5.38791083e-02f, 7.46356649e-03f, -6.77367747e-02f,
  -6.85966313e-02f, -1.28846407e-01f, -1.40771180e-01f, 3.99434147e-03f, -1.95571836e-02f, -1.80913135e-01f, -6.59225583e-02f, -1.14721455e-01f, -4.36945148e-02f, 3.53145599e-02f,
  -1.48349956e-01f, 9.82758310e-03f, 1.01387128e-01f, 7.97723457e-02f, 2.95023769e-02f, -2.78662667e-02f, 1.87289584e-02f, 6.04732595e-02f, 6.01569451e-02f, -3.76481600e-02f,
  -3.33012342e-02f, -5.67162037e-02f, -2.64090132e-02f, 1.03848547e-01f, -4.64766473e-03f, -4.48270291e-02f, 1.40102254e-02f, -1.68863538e-04f, 7.92330280e-02f, 1.06613763e-01f,
  2.19275020e-02f, 1.09654739e-01f, 6.49078488e-02f, 7.03507140e-02f, 8.85682646e-03f, 8.09945390e-02f, -1.89680215e-02f, -8.40457231e-02f, 5.92634752e-02f, -6.37843013e-02f,
  -1.09637454e-01f, -1.41797587e-01f, -1.99107572e-01f, -6.51618186e-03f, -2.33588368e-02f, -7.05164075e-02f, -6.16176203e-02f, -6.81088790e-02f, -6.63690716e-02f, -6.64616376e-02f,
  -1.47667110e-01f, -4.30430435e-02f, -1.20402128e-01f, -2.29047313e-02f, -1.44748375e-01f, -2.31767204e-02f, -8.07339773e-02f, -1.46798432e-01f, -1.54455617e-01f, -1.62194967e-01f,
  -1.99601203e-02f, -1.88993081e-01f, -2.30413496e-01f, -1.74801961e-01f, -3.49575952e-02f, -1.47363812e-01f, -1.79294825e-01f, -1.91282809e-01f, -1.10199310e-01f, -1.23287410e-01f,
  -8.65442082e-02f, 4.46039885e-01f, -1.88036576e-01f, 1.11635499e-01f, -1.82356946e-02f, -2.30644077e-01f, -4.72536311e-02f, -4.60685827e-02f, 1.04255788e-01f, 2.32608676e-01f,
  1.74640968e-01f, 2.57594883e-01f, 2.62289017e-01f, 6.85593560e-02f, 8.58803373e-03f, 6.51021898e-02f, 1.06277458e-01f, -1.92781240e-01f, -3.80079597e-01f, -3.12087893e-01f,
  1.21246517e-01f, -1.16537154e-01f, -2.54123092e-01f, -1.76304549e-01f, 1.70947984e-01f, 1.11850798e-01f, 1.82130903e-01f, -2.71232985e-03f, 6.62171617e-02f, 2.49002069e-01f,
  1.15416154e-01f, -2.87324544e-02f, 4.30692174e-02f, 3.78766693e-02f, 7.02360943e-02f, 5.41676097e-02f, 1.40400976e-01f, 3.86150517e-02f, 3.75356451e-02f, 1.58279091e-01f,
  4.52266773e-03f, -3.69217619e-03f, 1.27311602e-01f, 8.37286375e-03f, -1.48015628e-02f, 2.94765946e-03f, 8.35504234e-02f, 8.05272236e-02f, 9.24507231e-02f, -2.43651345e-02f,
  1.17162928e-01f, 2.55852453e-02f, -1.12750113e-01f, 9.58865210e-02f, -4.50104550e-02f, 1.01948462e-01f, 4.16085161e-02f, -7.80986398e-02f, -8.87535661e-02f, 1.89248338e-01f,
  9.56459045e-02f, -4.07196395e-02f, -2.36182977e-02f, 1.17968414e-02f, -2.07321215e-02f, -7.31358528e-02f, 4.94896732e-02f, -2.84007285e-02f, -1.46382868e-01f, -5.19060381e-02f,
  -6.02198765e-02f, -5.44886664e-02f, 8.73812940e-03f, -8.93523842e-02f, 3.10061108e-02f, 3.32108606e-03f, -1.65577158e-01f, 2.31195632e-02f, -7.14715123e-02f, -2.99437903e-02f,
  -9.99543369e-02f, -1.00811526e-01f, -9.64385271e-02f, -1.00572966e-01f, 6.18921407e-03f, -3.41729410e-02f, -6.58105686e-02f, -2.91726552e-02f, -8.50602388e-02f, 3.02140634e-05f,
  3.42555434e-01f, -2.00015157e-01f, 1.26611143e-01f, 1.29652962e-01f, 6.88287914e-02f, -2.79271952e-03f, 1.05335377e-01f, 3.51755787e-03f, 6.20116033e-02f, 2.80530639e-02f,
  1.40415709e-02f, -5.27383909e-02f, 4.96176891e-02f, -5.51069994e-03f, -1.30882591e-01f, 2.64572334e-02f, 1.64487809e-01f, 1.81011651e-02f, -2.61614155e-02f, 2.38992032e-02f,
  1.25847548e-01f, -1.49833895e-02f, -4.11143266e-02f, 2.68780384e-02f, 5.66357262e-02f, 9.12762806e-02f, 2.62051951e-02f, -4.18749489e-02f, -1.04904570e-01f, 1.63207889e-01f,
  3.41251045e-01f, -2.81497866e-01f, -1.80508360e-01f, -5.54592237e-02f, -1.87398285e-01f, -1.68905199e-01f, -3.36107016e-01f, -4.51388508e-02f, 7.92089999e-02f, 1.25916325e-04f,
  1.73059758e-03f, 1.72086790e-01f, 3.04600954e-01f, 2.69745797e-01f, 1.22281820e-01f, -1.43417135e-01f, 6.40484616e-02f, 1.65319711e-01f, 1.75518543e-01f, -6.08843118e-02f,
  -1.09541684e-01f, 4.44057770e-02f, 2.40688652e-01f, 1.78993866e-01f, -7.94788897e-02f, 3.26829590e-02f, 6.34760875e-03f, -1.86269209e-01f, -1.31328478e-01f, -3.37218232e-02f,
  -1.13691995e-02f, 2.63839471e-03f, 9.36288610e-02f, 1.75563559e-01f, -5.90377860e-02f, 3.97498645e-02f, -1.01978295e-02f, 9.81253758e-02f, 7.19333515e-02f, -2.09509432e-02f,
  9.49056745e-02f, 9.48104337e-02f, 1.69521011e-02f, -4.81364466e-02f, -1.04916424e-01f, -4.17319201e-02f, 3.85564310e-03f, 1.38257772e-01f, 6.53815344e-02f, -1.58835799e-02f,
  -6.20557107e-02f, -1.33607119e-01f, -1.91662777e-02f, -8.21517557e-02f, 8.19289405e-03f, 3.13985087e-02f, -8.84061381e-02f, -1.02771059e-01f, -5.20475656e-02f, -1.32138357e-01f,
  4.28541899e-02f, -2.79640276e-02f, -2.85487361e-02f, -2.58482601e-02f, 5.87468676e-04f, 8.65615811e-03f, 2.64622550e-02f, -1.20317750e-01f, 4.02113274e-02f, -7.70190060e-02f,
  -4.06844132e-02f, -2.37458870e-02f, -8.18581879e-02f, 1.89094990e-02f, 2.39335783e-02f, -1.29141033e-01f, -5.52879982e-02f, 2.36582290e-02f, -6.89220428e-03f, -4.01630253e-02f,
  4.42787148e-02f, 3.35607976e-02f, -2.71933079e-02f, 5.03092855e-02f, 3.00273318e-02f, -1.76119413e-02f, 5.57546364e-03f, 3.15791927e-02f, 3.26867029e-02f, -1.16339281e-01f,
  1.48925902e-02f, 1.27888352e-01f, 9.85637009e-02f, 3.32830139e-02f, 5.59043176e-02f, 1.65139019e-01f, 5.70789613e-02f, 7.72836506e-02f, 1.57043472e-01f, 1.06865962e-04f,
  -1.65722705e-02f, 1.50244877e-01f, 9.39490944e-02f, -1.75957847e-03f, -1.27991391e-02f, -2.03372501e-02f, 9.78024676e-02f, 2.81363577e-02f, 9.99616459e-02f, -8.63405541e-02f,
  1.59013420e-02f, -1.64045375e-02f, -5.38490862e-02f, -2.54664244e-03f, -4.31106947e-02f, 8.03436190e-02f, 1.15010373e-01f, 6.97687780e-03f, 9.04808939e-02f, -3.31747998e-03f,
  5.39315641e-01f, -3.90767425e-01f, -3.29428762e-01f, 3.53280246e-01f, -4.84682396e-02f, -2.87569523e-01f, -3.40159804e-01f, -4.09651846e-02f, 1.87053829e-01f, -6.35284185e-02f,
  -3.60096186e-01f, -6.90212399e-02f, -7.19746351e-02f, -1.23967882e-04f, -4.68785241e-02f, -2.00335756e-01f, 1.03197239e-01f, 1.55220821e-01f, 5.46217859e-02f, 1.29884481e-02f,
  -1.82903763e-02f, 2.65706211e-01f, 2.69619048e-01f, 1.60115078e-01f, -2.63641328e-02f, 6.33233488e-02f, -5.88751808e-02f, -1.39523782e-02f, -2.71359235e-01f, -2.52579562e-02f,
  -4.14234012e-01f, -2.35545889e-01f, -3.55239697e-02f, -9.61443782e-02f, -1.02544017e-01f, -1.33550227e-01f, -1.64180070e-01f, -5.44765852e-02f, -6.18470609e-02f, -2.06752121e-02f,
  -9.61024538e-02f, -1.52545050e-01f, -8.58858898e-02f, -2.52167642e-01f, -7.13637918e-02f, -2.04916269e-01f, -4.99365665e-02f, -4.54271026e-02f, -1.79097980e-01f, -2.55293697e-01f,
  -2.44962245e-01f, -1.92352757e-01f, -2.18545645e-01f, -2.21456841e-01f, -1.73325390e-01f, -8.45180675e-02f, -3.16305876e-01f, -1.24327295e-01f, -2.06080467e-01f, -2.90354714e-02f,
  1.87084645e-01f, 2.08987951e-01f, 9.21252742e-02f, 2.15010524e-01f, 1.35704190e-01f, 1.68436974e-01f, 1.03344321e-01f, 1.51495874e-01f, 1.63484365e-01f, 1.62974045e-01f,
  1.05777472e-01f, 5.70894852e-02f, 1.63209513e-01f, 1.43021569e-01f, 1.32385179e-01f, 1.24595366e-01f, 8.64282772e-02f, 1.30170658e-01f, 6.59048557e-02f, 1.42236874e-01f,
  8.31921548e-02f, 1.74659982e-01f, 1.36069044e-01f, 9.69801098e-02f, 1.26063332e-01f, 1.55701429e-01f, 6.15582541e-02f, 1.44505128e-01f, 6.03621081e-02f, 1.11736357e-01f,
  6.62193522e-02f, -2.92990357e-01f, -5.12102880e-02f, -8.35590139e-02f, -1.71769902e-01f, -1.74646020e-01f, -1.49773836e-01f, -8.31939057e-02f, -1.25869319e-01f, -1.23736061e-01f,
  -2.23202109e-01f, -1.18958399e-01f, -9.58073288e-02f, -8.92795697e-02f, -6.18370995e-02f, -1.31934986e-01f, -1.08676754e-01f, -7.71971196e-02f, -3.58308516e-02f, -1.59434557e-01f,
  -5.97435161e-02f, -3.54485586e-02f, 1.78140681e-02f, -1.18630767e-01f, -1.55956715e-01f, 2.16570888e-02f, -1.28164351e-01f, -1.99024156e-01f, -1.12502396e-01f, -1.45797478e-02f,
  -2.21791744e-01f, 5.94994016e-02f, -2.09138289e-01f, -2.70605654e-01f, -1.81795120e-01f, -4.08048257e-02f, 1.29578888e-01f, -5.85234612e-02f, -6.39250278e-02f, -2.88015287e-02f,
  8.31277147e-02f, 1.04631573e-01f, 1.25321567e-01f, 1.92896947e-02f, -2.83911154e-02f, -9.25991759e-02f, -1.65945008e-01f, -1.33258805e-01f, -1.02799602e-01f, -3.41960974e-02f,
  -5.25828712e-02f, -1.15603149e-01f, -1.88278779e-01f, -2.48362884e-01f, -1.49383172e-01f, -1.39323294e-01f, -1.25531062e-01f, -2.26028383e-01f, -1.72736757e-02f, -2.29619354e-01f,
  1.17955871e-01f, -2.76964635e-01f, 9.45962686e-03f, -1.74046494e-02f, -8.78804773e-02f, -1.17155733e-02f, 6.18583448e-02f, -8.66600052e-02f, -8.98932293e-02f, -8.05341601e-02f,
  -4.98592034e-02f, -1.42914757e-01f, -2.78294478e-02f, -1.18914679e-01f, -1.66392908e-01f, -3.10714822e-02f, -4.89099100e-02f, -6.55757785e-02f, -3.49863060e-02f, 2.74902619e-02f,
  -4.81702015e-02f, -1.52148038e-01f, -8.77161026e-02f, -2.23777741e-02f, -1.25443071e-01f, -7.45229842e-03f, -5.53101189e-02f, -1.23915218e-01f, -6.23327158e-02f, -1.40505105e-01f,
  4.92128693e-02f, -1.64393950e-02f, -1.16992824e-01f, 1.10387176e-01f, 8.78886133e-02f, 2.77330317e-02f, -5.87993711e-02f, 3.87837589e-02f, 5.19531481e-02f, 8.24086294e-02f,
  9.41573530e-02f, 4.08548899e-02f, 1.48342485e-02f, 1.09898925e-01f, 4.20019515e-02f, 1.01860343e-02f, -4.08362001e-02f, 9.47270170e-02f, 1.46085963e-01f, -2.08697785e-02f,
  5.45432158e-02f, 3.12490463e-02f, 4.95313928e-02f, 4.50450368e-02f, 9.15278047e-02f, 2.60565523e-02f, -2.95090256e-03f, 9.17228684e-02f, 2.34710835e-02f, 6.01408333e-02f,
  2.86689162e-01f, 1.06524110e-01f, -6.03390932e-02f, 3.27330120e-02f, -4.63534929e-02f, -1.07421108e-01f, -5.55682704e-02f, -7.54307732e-02f, -6.01700023e-02f, -5.59930541e-02f,
  1.74044992e-03f, -5.87493330e-02f, 4.04191390e-03f, -5.93178123e-02f, -3.87961008e-02f, -1.02271341e-01f, 3.02411169e-02f, -1.17463924e-01f, -9.87132117e-02f, -1.33007839e-01f,
  7.46025238e-03f, -1.76876821e-02f, 1.78430110e-01f, 1.25259086e-01f, -7.56182224e-02f, -7.96633866e-03f, 9.39602926e-02f, -2.70699598e-02f, 1.29950568e-01f, 1.40743271e-01f,
  2.32250169e-01f, 4.22505699e-02f, 3.02071124e-01f, -4.49684486e-02f, -1.59671679e-01f, 1.37874648e-01f, 2.95111001e-01f, 7.21154734e-02f, -1.83554366e-01f, 3.04141454e-02f,
  -1.57178238e-01f, -3.46003532e-01f, -9.46624801e-02f, -1.15704082e-01f, 4.25671302e-02f, 1.71897769e-01f, 1.06793813e-01f, 2.79628247e-01f, 1.95339382e-01f, -9.42931976e-03f,
  -1.77061245e-01f, -9.19015780e-02f, 1.49924112e-02f, -9.40316729e-03f, -1.11195944e-01f, -6.28566667e-02f, 6.45449758e-02f, 1.46697268e-01f, 1.39170423e-01f, 1.69198826e-01f,
  1.32445812e-01f, 1.10617794e-01f, -1.21357396e-01f, -2.10810825e-01f, -1.94620099e-02f, -1.07295670e-01f, -2.58555841e-02f, 2.77845934e-03f, -8.35845098e-02f, -1.27520159e-01f,
  -1.30867660e-01f, -1.10443458e-01f, -1.77292768e-02f, -1.00125246e-01f, -1.97863206e-03f, 3.64766978e-02f, -9.34038311e-02f, 4.15767320e-02f, 7.16375746e-03f, -1.00696452e-01f,
  -1.35670170e-01f, -2.10325350e-03f, 4.88642938e-02f, -7.21815750e-02f, -4.72798981e-02f, 1.91340297e-02f, 1.65812951e-02f, -1.12604946e-02f, 1.53979018e-01f, 1.26105860e-01f,
  -2.68332586e-02f, 1.93105638e-02f, 6.73220307e-02f, 1.76468734e-02f, 3.93069675e-03f, -6.34341384e-04f, 2.99185584e-03f, -4.63357083e-02f, 3.81920971e-02f, 2.17059813e-02f,
  -2.33895630e-02f, 4.69871871e-02f, 4.87961359e-02f, -3.55240814e-02f, -7.82555714e-02f, 5.57818748e-02f, 8.80323797e-02f, -1.75692160e-02f, 2.15943567e-02f, -2.44938000e-03f,
  4.62872237e-02f, 8.57025981e-02f, -9.37333610e-03f, -3.81797776e-02f, -2.38420367e-02f, 6.89173024e-03f, -5.40449619e-02f, -3.77879925e-02f, -2.78779492e-02f, -3.78485508e-02f,
  -1.31184831e-01f, -5.68350554e-02f, -2.77960803e-02f, -5.12795784e-02f, -7.84196779e-02f, -1.01234481e-01f, -6.33248240e-02f, -1.31081387e-01f, -1.30752772e-01f, 2.60937493e-02f,
  -1.01636991e-01f, -7.40076080e-02f, -1.24501549e-01f, -1.02568576e-02f, 3.39209661e-02f, -9.63229164e-02f, -1.49077579e-01f, 4.42809686e-02f, -7.66083673e-02f, 1.19123477e-02f,
  -7.51488879e-02f, 1.33940637e-01f, 3.05738114e-02f, 2.81524993e-02f, 8.44084769e-02f, 2.30908673e-02f, 1.38602778e-01f, 1.65183172e-02f, 4.29053679e-02f, 9.61981490e-02f,
  6.46337792e-02f, 3.49227220e-01f, 2.20969990e-01f, 2.43460730e-01f, 9.00269765e-03f, -1.05098553e-01f, -1.94978014e-01f, -6.74675927e-02f, 8.41179863e-02f, -1.72196962e-02f,
  9.26251337e-02f, -1.40087213e-03f, 4.80262712e-02f, -3.25329117e-02f, -5.19051850e-02f, 9.80504006e-02f, 1.05000235e-01f, 3.24319229e-02f, -1.69904545e-01f, -2.51726538e-01f,
  -1.05606809e-01f, 1.42328396e-01f, 5.09674735e-02f, 7.53737614e-02f, 1.57565624e-01f, -1.31201092e-03f, 1.58292219e-01f, 2.40236327e-01f, 3.02789919e-02f, 2.36429513e-01f,
  1.29679859e-01f, 2.88885713e-01f, -1.50400713e-01f, -7.68406026e-04f, 1.30045503e-01f, -3.64678875e-02f, 4.62173820e-02f, 8.79464895e-02f, 7.69718066e-02f, 8.69178176e-02f,
  4.19179574e-02f, 3.05720679e-02f, 1.73884481e-01f, 1.41395912e-01f, 8.81622955e-02f, 2.99290325e-02f, 1.32362664e-01f, 1.67422757e-01f, 9.38143656e-02f, 1.53256029e-01f,
  4.57210578e-02f, 7.27915689e-02f, 4.63702762e-03f, 3.83679802e-03f, -6.67719264e-03f, 2.42329165e-02f, 1.44222796e-01f, 6.66956827e-02f, 8.34327340e-02f, 1.79964423e-01f,
  -1.25230089e-01f, -1.06230393e-01f, -6.52912259e-02f, -3.12452260e-02f, -5.05385920e-02f, -2.54044533e-02f, -2.45462842e-02f, -1.14204958e-02f, -1.28260747e-01f, 2.99040359e-02f,
  9.25476197e-03f, -8.13830364e-03f, -8.00415650e-02f, 1.15843713e-02f, -6.82045659e-03f, -4.60425280e-02f, 2.25132126e-02f, -3.15531977e-02f, -5.07181883e-02f, -5.90921054e-03f,
  -6.63360059e-02f, -7.28831813e-02f, 3.60935135e-03f, 6.38903752e-02f, -2.74068024e-02f, -4.43057530e-02f, -4.73119020e-02f, -1.02470227e-01f, -5.09644039e-02f, -2.08027028e-02f,
  -8.74108598e-02f, -9.21645388e-02f, 1.12093063e-02f, 8.33032951e-02f, 9.60253403e-02f, 1.08279392e-01f, 1.34903342e-01f, 3.85777615e-02f, 5.58357872e-02f, 3.44985537e-02f,
  3.66426073e-02f, 4.08480465e-02f, 1.12150922e-01f, 7.16288760e-02f, 2.99235098e-02f, -6.48166984e-02f, 6.38488159e-02f, -3.01501015e-03f, 3.96832870e-03f, 6.13128208e-02f,
  1.15636595e-01f, -1.45012736e-01f, -1.13105983e-01f, -7.00876266e-02f, -1.67117473e-02f, -1.45675033e-01f, -1.92963369e-02f, -2.22307164e-02f, -1.78838491e-01f, -3.58099043e-02f,
  -5.61632752e-01f, 5.93269384e-03f, -1.62726045e-02f, -1.85126990e-01f, -4.16188948e-02f, -1.06410451e-01f, -2.41986200e-01f, -1.63127646e-01f, -8.87638554e-02f, 1.66718774e-02f,
  1.33572921e-01f, 1.02401741e-01f, 1.69092104e-01f, 2.21892372e-01f, 1.62018016e-02f, 4.39076126e-02f, 6.09083474e-02f, -9.85963643e-03f, 2.35760701e-03f, -1.91712007e-02f,
  1.83885321e-01f, -1.09330285e-02f, -1.40760824e-01f, -5.28777801e-02f, 1.61589444e-01f, 1.71142861e-01f, 5.27717434e-02f, 3.43084671e-02f, 2.44972631e-01f, 2.43433267e-01f,
  2.82001138e-01f, -1.58272952e-01f, 8.86730757e-03f, 2.03604519e-01f, 1.51273489e-01f, -2.03761179e-02f, 8.31897035e-02f, 7.34557724e-03f, -2.13674009e-02f, -8.88251141e-03f,
  1.21180214e-01f, 3.84984016e-02f, 6.44555315e-02f, 4.93299589e-02f, -1.10363001e-02f, 7.62118101e-02f, -1.20175565e-02f, 9.10253450e-02f, 7.76883960e-02f, 1.56656817e-01f,
  2.28328437e-01f, 4.59806174e-02f, 5.35627548e-03f, -3.40904184e-02f, 6.31786138e-02f, 8.73601511e-02f, 1.46556690e-01f, 1.49818659e-01f, -1.95125323e-02f, 1.03006408e-01f,
  4.09777649e-02f, 4.42232983e-03f, -6.86083129e-03f, -1.35503635e-01f, -2.05848832e-02f, -9.57781356e-03f, -9.93473828e-03f, 1.18183037e-02f, 8.88523087e-03f, -7.74804205e-02f,
  1.94610115e-02f, -6.73672482e-02f, -7.28791580e-02f, -1.00051031e-01f, 1.17529342e-02f, 5.05875498e-02f, -5.27135395e-02f, 1.09640487e-01f, -3.06171775e-02f, 4.41117808e-02f,
  -1.14588765e-03f, 3.49491909e-02f, -6.41157627e-02f, -2.82763857e-02f, 1.01866938e-01f, -3.42559405e-02f, -4.16173302e-02f, 3.50593626e-02f, -4.59372662e-02f, -3.80286723e-02f,
  -1.97007552e-01f, -6.22230098e-02f, 8.43425617e-02f, 9.11696255e-02f, 1.57704595e-02f, 8.99200290e-02f, 9.39129516e-02f, 1.05023548e-01f, 8.33973438e-02f, -1.46974772e-02f,
  2.75509916e-02f, -3.14840712e-02f, -1.49644222e-02f, 1.01296693e-01f, 9.54272598e-03f, 2.65720813e-03f, 5.54481521e-02f, -2.98963096e-02f, 7.57920090e-03f, 1.47643998e-01f,
  5.95626347e-02f, -7.60698318e-02f, -1.20928079e-01f, -6.17556553e-03f, 3.56277265e-02f, -7.34765753e-02f, -1.79130994e-02f, 2.59748511e-02f, -3.53447087e-02f, -1.12582467e-01f,
  -5.23344517e-01f, 2.51787782e-01f, 5.33961058e-02f, -2.02586174e-01f, -1.35162905e-01f, 1.93970520e-02f, 9.31189954e-02f, -3.39178778e-02f, -4.17427272e-02f, 4.84816656e-02f,
  1.14073701e-01f, 1.65125340e-01f, 7.18052983e-02f, 2.49165148e-01f, 1.72348008e-01f, 2.77242899e-01f, 2.29996383e-01f, -7.51356110e-02f, -1.25658885e-01f, -1.06815338e-01f,
  7.33875409e-02f, -1.88047171e-01f, -1.70264944e-01f, -8.15642327e-02f, 4.27863859e-02f, -4.74498011e-02f, 4.24874946e-02f, -1.48227699e-02f, 1.01796351e-01f, 1.81453094e-01f,
  2.66003478e-02f, -9.57636535e-02f, -2.21453253e-02f, 5.43032773e-02f, 1.03220545e-01f, -4.79633436e-02f, -2.88116317e-02f, 2.76233442e-02f, -7.17566237e-02f, 9.56109837e-02f,
  -3.01740319e-02f, -4.42835614e-02f, 2.33562253e-02f, 1.22649536e-01f, -9.33184940e-03f, 2.25961395e-02f, -1.43363746e-02f, 9.83903334e-02f, 7.60706514e-02f, 7.46032894e-02f,
  1.48518115e-01f, -6.59645128e-04f, -5.64902313e-02f, 1.31137073e-01f, 1.10249430e-01f, -2.28791535e-02f, 1.02855168e-01f, 6.47439563e-04f, 1.57846119e-02f, -4.59293760e-02f,
  -1.32862091e-01f, 4.41588834e-02f, 1.02414221e-01f, -1.64186209e-02f, 1.09867513e-01f, 4.94793430e-02f, 9.46292430e-02f, 9.81920734e-02f, 1.95827279e-02f, 8.31974894e-02f,
  2.67441478e-02f, 3.79404426e-02f, -3.84929962e-03f, 4.32171896e-02f, 1.09977722e-01f, 7.62393605e-03f, 1.31185114e-01f, 8.87332335e-02f, 1.04459628e-01f, 4.91195582e-02f,
  5.99550903e-02f, 3.48717831e-02f, -2.59456672e-02f, 2.92158294e-02f, 1.09421059e-01f, -2.12635519e-03f, 7.35199675e-02f, 4.40815638e-04f, -4.33753617e-02f, -8.12263340e-02f,
  2.03277096e-02f, 7.37673268e-02f, 9.86215938e-03f, 2.25486550e-02f, -2.28353571e-02f, 7.95532912e-02f, 3.14502120e-02f, -7.17437593e-03f, 6.83486462e-02f, -5.43001667e-02f,
  6.34638593e-02f, -4.12469357e-02f, 7.01433718e-02f, 1.04290210e-01f, -5.06922007e-02f, 3.57391648e-02f, 1.09593101e-01f, -1.91983394e-02f, 4.27039936e-02f, 1.19257160e-01f,
  1.57080323e-01f, -5.38910702e-02f, -2.64684912e-02f, 6.06971607e-02f, 6.90934360e-02f, -1.04962945e-01f, -3.20516378e-02f, -8.04357752e-02f, -6.42098784e-02f, -5.48034981e-02f,
  3.75975043e-01f, -1.51121661e-01f, -6.87844232e-02f, -1.14401340e-01f, -2.37907723e-01f, -2.14961141e-01f, -2.10833013e-01f, 2.26237178e-02f, -5.51861823e-02f, -1.84057094e-02f,
  -5.45341969e-02f, 2.48157129e-01f, 1.47246629e-01f, 2.45523855e-01f, 2.52230674e-01f, -1.82974622e-01f, -2.90905505e-01f, 8.65569115e-02f, 2.77645022e-01f, -5.11226691e-02f,
  -1.57560945e-01f, 2.24182159e-02f, 7.79916495e-02f, -1.41543942e-02f, -2.47190103e-01f, 4.86477390e-02f, -9.87476110e-02f, -8.19012895e-02f, -2.30113015e-01f, -2.98906058e-01f,
  1.43659651e-01f, -2.12739799e-02f, 1.93357896e-02f, 6.30590767e-02f, -3.77685539e-02f, 7.62188807e-02f, 3.69794145e-02f, 2.90743373e-02f, 2.92291362e-02f, -1.02193974e-01f,
  -1.08696386e-01f, 2.75303274e-02f, 2.03652438e-02f, 7.88551196e-03f, 1.09478384e-02f, 3.08651756e-02f, -9.53937769e-02f, 5.85670471e-02f, 2.32007243e-02f, -1.37698725e-02f,
  -1.13439761e-01f, -8.28511864e-02f, 5.87382726e-02f, 7.34638199e-02f, 3.31849940e-02f, 2.34164950e-03f, 3.65618244e-02f, 1.49473185e-02f, 7.75161991e-03f, 7.39810662e-03f,
  -8.22798386e-02f, -2.66442858e-02f, -4.05398607e-02f, 3.34427394e-02f, -1.67756015e-03f, -1.13711908e-01f, 2.51584267e-03f, 7.83186406e-03f, 4.34235372e-02f, -2.08963398e-02f,
  2.40564533e-03f, 6.56839982e-02f, 5.82948364e-02f, 8.72014314e-02f, 4.10030670e-02f, 6.82514440e-03f, 4.91569303e-02f, -5.89979859e-03f, 7.37480372e-02f, 4.01231200e-02f,
  2.00888305e-03f, 5.98019585e-02f, 7.36400113e-02f, 1.10829964e-01f, -1.15220621e-02f, -3.61805176e-03f, 1.08680561e-01f, -7.70753773e-04f, -1.31865088e-02f, -1.37371160e-02f,
  2.46673793e-01f, 1.22567542e-01f, -5.14593534e-02f, 1.03858300e-01f, -6.13877028e-02f, 2.00010054e-02f, -1.88161619e-02f, 3.47868465e-02f, -9.31230187e-02f, 3.43596637e-02f,
  9.24690887e-02f, -1.36305531e-02f, 1.69997253e-02f, -5.04859649e-02f, 5.59229627e-02f, 3.35367769e-02f, -6.12749755e-02f, 4.57857316e-03f, 3.66126671e-02f, 5.72731579e-03f,
  -7.13808089e-02f, -6.17029704e-02f, 8.31457600e-02f, 3.14097181e-02f, -3.47554125e-02f, 1.41411960e-01f, -2.86266506e-02f, -4.64491732e-02f, 1.11847483e-01f, -3.73026878e-02f,
  3.44478190e-01f, 3.05044174e-01f, -3.26742977e-01f, 2.23923802e-01f, -2.44535163e-01f, -3.59473169e-01f, -1.96299896e-01f, -3.85883860e-02f, 1.33450374e-01f, 7.95785189e-02f,
  -2.53408346e-02f, -2.74962038e-02f, -1.89267546e-01f, -2.18182907e-01f, -1.93916529e-01f, -2.66381919e-01f, -1.83412492e-01f, -2.28849486e-01f, -1.98501021e-01f, -6.27685562e-02f,
  -5.31000318e-03f, 2.58727908e-01f, 1.70548558e-01f, 1.20109148e-01f, 1.36002406e-01f, -9.11948234e-02f, -3.71598974e-02f, 3.11840773e-02f, 2.90145399e-03f, 1.35425881e-01f,
  -1.97850198e-01f, 2.55612463e-01f, -1.41656175e-01f, 1.91767719e-02f, -7.16111660e-02f, -2.26279832e-02f, -5.33467010e-02f, -7.38026798e-02f, -7.07094222e-02f, -3.06959692e-02f,
  1.06237717e-01f, 1.14077854e-03f, -4.66806628e-02f, -8.85292739e-02f, 9.60301459e-02f, 4.11747731e-02f, 6.84816241e-02f, 6.34277686e-02f, -9.87370536e-02f, -3.50216813e-02f,
  -9.23162997e-02f, 4.66678757e-03f, -3.41872275e-02f, -7.91458860e-02f, -1.35339210e-02f, -1.47690699e-01f, 2.55773962e-02f, 3.21598612e-02f, -1.39109045e-01f, 1.69744119e-01f,
  7.42949033e-03f, -3.68585214e-02f, -1.41504668e-02f, 2.88946591e-02f, 8.56902450e-02f, -3.12333554e-02f, 2.86459308e-02f, 1.45706087e-01f, 4.59972844e-02f, 1.53623044e-01f,
  -6.95257355e-03f, 1.80801712e-02f, 4.59841639e-02f, 4.44440581e-02f, 3.41534093e-02f, 5.52138174e-03f, 8.51175040e-02f, 3.41118351e-02f, 1.28335088e-01f, 1.09024972e-01f,
  1.45575166e-01f, -1.28418836e-03f, 6.50243312e-02f, 2.57137809e-02f, 4.62925844e-02f, 7.96443373e-02f, 1.00273646e-01f, 2.88345404e-02f, 9.23887733e-03f, 3.99326272e-02f,
  7.46321306e-03f, -2.80087292e-01f, 2.34404393e-02f, -5.05088782e-03f, -2.32013352e-02f, 2.77430359e-02f, -5.28994650e-02f, -2.23337188e-02f, -1.20243721e-03f, -8.09189007e-02f,
  1.56366881e-02f, -2.82672103e-02f, 1.94802266e-02f, 3.95543277e-02f, -7.70005137e-02f, -7.89448321e-02f, -1.73106156e-02f, -4.67561856e-02f, -8.81433859e-02f, -3.65730040e-02f,
  -4.91287149e-02f, -1.07604034e-01f, -2.12666839e-01f, -1.67809561e-01f, -3.95172164e-02f, -2.78158545e-01f, -8.12602863e-02f, -1.25900492e-01f, -2.08393008e-01f, -9.89639107e-03f,
  1.27447188e-01f, 2.04803482e-01f, 4.21322472e-02f, 1.79450810e-01f, -4.22839038e-02f, -1.24066889e-01f, -3.99495438e-02f, -1.33297503e-01f, 9.33372900e-02f, 2.01433674e-01f,
  -3.74023728e-02f, -8.20635483e-02f, -1.03332378e-01f, -1.41278595e-01f, -1.62288576e-01f, 1.88083410e-01f, 1.26926601e-01f, -4.87555787e-02f, -1.92726523e-01f, 7.08954632e-02f,
  7.55069405e-02f, 1.28685504e-01f, 4.83410945e-03f, 1.50854871e-01f, 2.87163556e-01f, 1.90692395e-01f, 1.53151616e-01f, 1.81443542e-01f, 2.16401115e-01f, 3.86068404e-01f,
  3.00007164e-01f, 4.00984548e-02f, 1.91346742e-02f, 6.68407679e-02f, 4.05644178e-02f, 1.63704589e-01f, 1.58558428e-01f, 5.89404963e-02f, -5.69783757e-03f, 1.48322731e-01f,
  -1.29964706e-02f, 1.69760972e-01f, 1.63318403e-03f, 9.67876241e-02f, 9.92825851e-02f, 1.00853637e-01f, -6.92604333e-02f, 1.23084381e-01f, -1.29793640e-02f, 2.08441019e-02f,
  1.21714972e-01f, 1.51780933e-01f, 7.85873234e-02f, 9.20137465e-02f, 6.23343214e-02f, 8.91329721e-02f, 1.63531423e-01f, 1.73505008e-01f, 7.12331682e-02f, 3.43380153e-01f,
  1.06707141e-01f, -2.96690147e-02f, -1.23850882e-01f, 6.07179897e-03f, -9.26261917e-02f, -3.64926942e-02f, -7.51691312e-02f, -9.52936430e-03f, -5.27468994e-02f, -2.22289935e-02f,
  -8.00168142e-02f, -1.04408868e-01f, -9.77981612e-02f, 2.93831676e-02f, -5.62258475e-02f, -8.33406672e-02f, -1.28935233e-01f, -6.17602542e-02f, -9.20221880e-02f, -1.93761021e-01f,
  -5.03207594e-02f, 1.02093397e-02f, -1.31807506e-01f, -1.06768413e-02f, -5.31226546e-02f, -5.36270887e-02f, -1.05207957e-01f, -4.98538911e-02f, -1.20043777e-01f, -4.65213172e-02f,
  1.30342603e-01f, -3.17569971e-01f, 9.18530971e-02f, 1.02258779e-01f, 7.91850686e-02f, -5.43894060e-02f, -6.85702497e-03f, 3.55470106e-02f, -7.64546618e-02f, 1.17779866e-01f,
  6.09774850e-02f, -4.82453033e-02f, -1.30770439e-02f, 2.55386792e-02f, 2.51831375e-02f, -3.01679433e-03f, 1.07705197e-03f, 9.66621377e-03f, 1.28731340e-01f, 4.96352911e-02f,
  -8.49515200e-03f, 1.55937165e-01f, 2.15209156e-01f, 6.34995252e-02f, 7.64432102e-02f, 1.51439952e-02f, 1.33743435e-01f, 1.65870085e-01f, 1.58315077e-01f, 1.88266367e-01f,
  -4.12522294e-02f, -4.54393148e-01f, -5.29561713e-02f, -1.37276411e-01f, 4.87893187e-02f, 6.49215579e-02f, -2.40451604e-01f, -1.43702030e-01f, -4.46075611e-02f, -2.15872630e-01f,
  -5.15951775e-02f, 1.96426705e-01f, 8.38984326e-02f, 5.03545776e-02f, -2.54283212e-02f, -1.96177259e-01f, -1.32306725e-01f, 5.03103696e-02f, 3.51171762e-01f, 2.15060443e-01f,
  -5.51615991e-02f, -9.18240007e-03f, -4.51986194e-02f, -4.55837511e-02f, -1.06449701e-01f, 5.19619323e-02f, -1.95683450e-01f, -6.61767498e-02f, -7.13416189e-02f, -1.19902298e-01f,
  1.02581762e-01f, -1.55774951e-01f, 1.77700922e-01f, 7.96400979e-02f, -2.11149938e-02f, 6.91723377e-02f, 7.31273042e-03f, -2.44444292e-02f, -5.19155301e-02f, -8.19576681e-02f,
  1.45247594e-01f, -3.76103744e-02f, -2.58272570e-02f, 6.80453330e-02f, 4.13433537e-02f, 6.09291047e-02f, 1.06851803e-02f, 6.17302656e-02f, -4.51036775e-03f, 1.40561461e-02f,
  4.06665094e-02f, 1.94463823e-02f, 2.66148206e-02f, 7.29880407e-02f, 7.05467537e-02f, 1.48997590e-01f, -4.37791869e-02f, 9.10746828e-02f, -5.37955277e-02f, -4.62270230e-02f,
  1.54670706e-04f, -2.89902855e-02f, 5.98127022e-02f, -9.15936455e-02f, -5.17577380e-02f, 2.15181732e-03f, -5.53285442e-02f, 6.31228611e-02f, 1.97197292e-02f, -4.97052297e-02f,
  7.90468678e-02f, -1.84184033e-03f, 5.59051000e-02f, -9.05474424e-02f, 1.62383041e-03f, -8.42655264e-03f, -1.84509140e-02f, -3.65251191e-02f, 5.32997996e-02f, 2.95784455e-02f,
  4.89662476e-02f, -1.35148475e-02f, -4.37381044e-02f, -7.13723078e-02f, 2.09562965e-02f, 2.49932427e-02f, 1.15029737e-02f, 5.92718646e-02f, -5.04120179e-02f, -6.06755577e-02f,
  -1.05172619e-01f, 4.40546460e-02f, 1.10879816e-01f, 2.42202822e-02f, 1.47120617e-02f, 3.73896621e-02f, -1.06160073e-02f, 2.90620197e-02f, -1.94995198e-02f, -1.34910448e-02f,
  4.32860889e-02f, -6.70135543e-02f, -1.14436328e-01f, -3.77328917e-02f, 2.02006176e-02f, 1.46420840e-02f, -1.27957314e-01f, 1.97943728e-02f, 1.92857664e-02f, 3.68144922e-02f,
  -1.54771060e-02f, 5.67828529e-02f, 2.18256429e-01f, 4.77576442e-03f, 1.94318537e-02f, 1.42653495e-01f, 4.79460694e-02f, 1.19081259e-01f, 4.61037755e-02f, -7.73674203e-03f,
  1.32097155e-01f, 1.45788237e-01f, 4.05612111e-01f, -2.13454410e-01f, 3.48450281e-02f, 1.23492166e-01f, 2.07670957e-01f, -1.95398256e-02f, -1.16203576e-01f, 7.45361596e-02f,
  -1.02314204e-01f, -3.91019493e-01f, -3.25654268e-01f, -2.36797556e-01f, -8.22215974e-02f, 2.04910666e-01f, 1.75571322e-01f, -1.05974600e-01f, -9.51979533e-02f, -1.85479164e-01f,
  -2.67176181e-01f, -2.66210496e-01f, -1.57917649e-01f, -8.30121636e-02f, 3.61511819e-02f, -2.05976263e-01f, 1.95526183e-01f, 1.94836464e-02f, 9.21291932e-02f, 1.80950072e-02f,
  1.63575038e-01f, 3.43156099e-01f, -2.56409291e-02f, -9.84047577e-02f, -1.09338444e-02f, 6.92546591e-02f, -1.38259726e-02f, 7.55319893e-02f, -6.43482357e-02f, 3.77944075e-02f,
  -3.16967480e-02f, 7.44328089e-03f, -9.74058062e-02f, -9.06979069e-02f, 9.16790143e-02f, 7.41030723e-02f, 1.99679541e-03f, 4.40458655e-02f, 2.07634326e-02f, 1.56537712e-01f,
  -1.45815745e-01f, 2.51315478e-02f, 8.45629498e-02f, 1.89755540e-02f, 1.18050911e-01f, -7.36712990e-03f, 8.96391496e-02f, 1.62952632e-01f, 7.74966404e-02f, 4.54348437e-02f,
  -1.32468998e-01f, 3.74132060e-02f, 4.88520786e-02f, 4.26063947e-02f, -2.33554114e-02f, 6.99241553e-03f, 2.59612650e-02f, -3.44014131e-02f, -2.19800249e-02f, 9.82986577e-03f,
  -2.82097477e-02f, 7.93738663e-02f, 1.51665963e-03f, 1.30225942e-02f, -1.15166921e-02f, 4.23582494e-02f, 3.20886523e-02f, 2.50899643e-02f, 3.79425101e-02f, 6.94085658e-02f,
  -3.73229608e-02f, -2.68810429e-02f, -2.93526817e-02f, -9.89480969e-03f, 1.06656723e-01f, 1.06149800e-01f, 1.71249453e-02f, -5.59697747e-02f, 4.67076339e-02f, 2.65950616e-02f,
  -2.11888418e-01f, 8.51682350e-02f, 4.85799760e-02f, -1.00582927e-01f, 4.73647974e-02f, -1.95944607e-02f, -1.45918410e-02f, 8.53078347e-03f, -3.89500707e-03f, 1.54853798e-02f,
  5.40646315e-02f, 3.41657251e-02f, -6.78094290e-03f, 2.63650417e-02f, -5.30252885e-03f, -1.05162002e-01f, -7.81000871e-03f, -8.67362246e-02f, 6.15460835e-02f, 1.16681559e-02f,
  -8.81471038e-02f, -8.33477154e-02f, -7.06743002e-02f, 1.12009300e-02f, -9.47275013e-02f, -8.23537856e-02f, -5.83231337e-02f, -1.09871402e-01f, 1.67945717e-02f, -6.48523346e-02f,
  2.69942075e-01f, 4.03779805e-01f, 8.79839510e-02f, -1.48163438e-01f, 9.68944654e-02f, 1.99074522e-01f, 2.20955074e-01f, 1.71791956e-01f, 6.77169440e-03f, 2.23057732e-01f,
  2.49120310e-01f, 5.14887832e-02f, 7.98061490e-02f, -3.00861243e-02f, 3.71932536e-02f, 1.87387720e-01f, -7.86196962e-02f, -1.28001973e-01f, -1.82103902e-01f, -1.17961377e-01f,
  -2.81112380e-02f, -1.99321553e-01f, -5.79967760e-02f, -1.10402368e-01f, 5.03280647e-02f, 2.16661394e-02f, 1.58759251e-01f, 3.75876464e-02f, 7.55364746e-02f, 3.09477225e-02f,
  2.49950200e-01f, 3.01743060e-01f, -9.52324644e-02f, -2.13901531e-02f, 7.05237500e-03f, 1.14361607e-01f, 5.57304323e-02f, -3.06755323e-02f, 9.28490683e-02f, -2.71074064e-02f,
  1.34274870e-01f, 4.70779836e-02f, 5.31169139e-02f, 9.67119634e-02f, 6.83839694e-02f, 3.71950269e-02f, 3.92019264e-02f, 9.02396888e-02f, 1.04790635e-01f, 1.96196973e-01f,
  3.23577784e-02f, 2.19421893e-01f, 2.36045182e-01f, 1.25124037e-01f, 7.70698339e-02f, 6.34206980e-02f, 1.33010671e-01f, 1.59314334e-01f, 1.53639928e-01f, 1.51331812e-01f,
  -7.26986257e-03f, -1.63486656e-02f, -4.95760702e-02f, 8.89672339e-03f, -6.44894242e-02f, -2.46870145e-02f, -3.47989500e-02f, -1.26630778e-03f, -3.02645005e-02f, 3.54245445e-03f,
  5.45981526e-02f, -2.04896796e-02f, 6.55063689e-02f, 3.79113071e-02f, 3.51489931e-02f, 4.76517193e-02f, 5.23722619e-02f, -7.74691775e-02f, 4.83882166e-02f, 2.41524037e-02f,
  8.06010794e-03f, -1.63490344e-02f, 7.36431498e-03f, -2.84896903e-02f, 2.71909814e-02f, 2.37475224e-02f, -6.97066858e-02f, 6.48785830e-02f, 6.93664933e-03f, 8.45344551e-03f,
  -3.11972434e-03f, -1.92905334e-03f, 1.00684382e-01f, 9.56553128e-03f, 9.75516066e-02f, 8.75875726e-02f, 3.21966149e-02f, 1.68375671e-02f, 1.73593108e-02f, 5.38691655e-02f,
  3.16498987e-02f, 1.40276074e-01f, 9.39055607e-02f, 5.24762534e-02f, 6.68497756e-02f, 6.59086555e-02f, -3.39542255e-02f, 4.43308577e-02f, 3.31292301e-02f, 5.33984974e-02f,
  -6.75574914e-02f, 1.21505745e-01f, 1.71795428e-01f, 1.48087502e-01f, 1.03661485e-01f, 9.00900662e-02f, 4.07485180e-02f, 6.78579956e-02f, 1.12203747e-01f, 5.67337871e-02f,
  -4.98187304e-01f, 3.72452363e-02f, 1.01049788e-01f, -4.21486527e-01f, -1.12343937e-01f, 5.20552956e-02f, 6.64445311e-02f, -3.07563376e-02f, -1.92673415e-01f, -1.16798691e-01f,
  -7.63619021e-02f, -3.31284583e-01f, -2.33972788e-01f, -2.15625405e-01f, -8.29543695e-02f, -3.62269133e-02f, 8.90652314e-02f, -1.55498520e-01f, -3.12621564e-01f, -1.95983768e-01f,
  -1.90598860e-01f, -1.03926212e-01f, -2.40625724e-01f, -1.57701954e-01f, -1.07526183e-01f, -2.48758703e-01f, -5.38626350e-02f, -1.37210011e-01f, -5.76351210e-02f, -1.41035616e-01f,
  -9.07696113e-02f, -2.59194851e-01f, -1.64381936e-01f, -1.45899341e-01f, -4.21239026e-02f, -1.49748757e-01f, -2.15969637e-01f, -2.29221031e-01f, -1.79392904e-01f, -1.26616657e-01f,
  -1.51618645e-01f, -2.30380237e-01f, -1.01590790e-01f, -1.87860385e-01f, -2.17032492e-01f, -1.89128101e-01f, -4.69258539e-02f, -2.75513619e-01f, -1.76641256e-01f, -1.84247434e-01f,
  -1.64776057e-01f, -2.64399141e-01f, -1.73833027e-01f, -1.10511139e-01f, -1.23057775e-01f, -1.85237482e-01f, 8.28626379e-03f, -7.35906735e-02f, -1.64329171e-01f, -8.88758302e-02f,
  -2.79304441e-02f, 9.51800123e-02f, 1.30728766e-01f, 1.12994120e-01f, 2.17847690e-01f, 1.65884987e-01f, 1.61511943e-01f, 1.32226735e-01f, 1.31417111e-01f, 1.83171496e-01f,
  1.33334115e-01f, 1.17107011e-01f, 2.36701921e-01f, 1.11112393e-01f, 1.45092875e-01f, 1.80097938e-01f, 8.82619694e-02f, 1.77239090e-01f, 1.95303559e-01f, 1.24285370e-01f,
  1.53010353e-01f, 1.91395476e-01f, 2.29499131e-01f, 1.49973512e-01f, 1.37796849e-01f, 1.55753493e-01f, 6.51607737e-02f, 7.15294853e-02f, 1.02757290e-01f, 8.20664689e-02f,
  -9.22725424e-02f, -1.06185906e-01f, -2.60768294e-01f, -2.50737965e-01f, -1.53339118e-01f, -9.61111709e-02f, -1.68666288e-01f, -9.49076563e-02f, -1.33694127e-01f, -1.62048668e-01f,
  -1.46905065e-01f, -1.91777110e-01f, -1.27104804e-01f, -1.33021936e-01f, -1.10463753e-01f, -1.80886462e-01f, -6.30289912e-02f, -1.18688546e-01f, -1.23840787e-01f, -9.35604200e-02f,
  -9.83664319e-02f, -1.14540987e-01f, -2.35106930e-01f, -1.20890446e-01f, -1.57532901e-01f, -3.07981312e-01f, 9.34890937e-03f, -1.64544538e-01f, -1.27377480e-01f, 5.21575063e-02f,
  -1.75415292e-01f, -1.56685740e-01f, -7.85788428e-03f, 1.49233714e-01f, 2.31065243e-01f, 9.77855548e-02f, 1.58881381e-01f, 1.01121835e-01f, 1.91682756e-01f, 1.43092692e-01f,
  -5.26496544e-02f, -1.05852053e-01f, -1.40559897e-01f, -1.89758554e-01f, -1.56963736e-01f, 1.32351860e-01f, 6.69398531e-02f, -1.56002730e-01f, -2.16288999e-01f, -9.02995616e-02f,
  5.52261248e-02f, -2.29426790e-02f, -1.89752638e-01f, -9.79934335e-02f, 9.78614688e-02f, -1.72860883e-02f, 7.17813596e-02f, -1.07379451e-01f, -4.90274765e-02f, -8.99565220e-02f,
  -1.99531063e-01f, -2.40747452e-01f, -3.96142974e-02f, -1.33613914e-01f, -1.12279458e-02f, -8.51299390e-02f, 7.96203837e-02f, 6.06533885e-03f, -1.01792060e-01f, 1.50765572e-02f,
  2.68380437e-02f, -1.02742709e-01f, -7.88585246e-02f, -1.20684721e-01f, -7.61997774e-02f, 6.14483142e-03f, -1.27530560e-01f, -1.10501610e-01f, -1.21930562e-01f, -4.77733202e-02f,
  5.05883759e-03f, -2.92395372e-02f, -1.04091831e-01f, 1.28448557e-03f, -1.51447400e-01f, -3.62152085e-02f, -2.33779952e-01f, -1.22828014e-01f, -1.73578113e-01f, -5.22952352e-04f,
  8.95758942e-02f, -2.41762269e-02f, 5.19374348e-02f, 1.29244655e-01f, 1.45518556e-01f, 1.04796596e-01f, 2.12143689e-01f, -1.97166111e-02f, 3.78171578e-02f, 5.54421730e-02f,
  6.85269851e-03f, 1.57715514e-01f, 1.16989113e-01f, 6.86356872e-02f, 1.09937586e-01f, 1.47083998e-01f, 4.10349369e-02f, 5.59552461e-02f, 8.60776901e-02f, 1.08720109e-01f,
  7.78070986e-02f, -1.06975790e-02f, 1.76532999e-01f, 2.49059666e-02f, 5.64723648e-02f, 3.89823169e-02f, 1.45877287e-01f, 9.42571238e-02f, 5.03008664e-02f, 9.40453932e-02f,
  9.47610587e-02f, -1.05308779e-01f, 6.95248134e-03f, -8.27798992e-02f, 6.07485920e-02f, 5.15403822e-02f, 2.15682480e-02f, -3.16053559e-03f, -5.99932633e-02f, 1.05289686e-02f,
  -9.62724909e-02f, -7.35004619e-02f, -3.04799508e-02f, -2.33440790e-02f, 5.99353127e-02f, -7.93234445e-03f, 1.04196239e-02f, 3.49113531e-02f, 3.82321775e-02f, -6.99811131e-02f,
  6.53033331e-02f, 6.36977851e-02f, -6.08152486e-02f, 9.44845676e-02f, -3.42474952e-02f, 4.09299843e-02f, -4.61020332e-04f, 2.41842214e-02f, 8.51640850e-02f, 1.98784322e-01f,
  2.93278247e-01f, 1.63725633e-02f, -5.30779883e-02f, 1.08490013e-01f, 5.91951683e-02f, -2.28132054e-01f, -3.38364005e-01f, -1.07461184e-01f, 3.63944881e-02f, -2.92135887e-02f,
  1.17671661e-01f, 1.34830728e-01f, 1.52177280e-02f, -8.38087276e-02f, -1.86624631e-01f, -2.95912981e-01f, -2.98093230e-01f, -1.93330705e-01f, -1.21786565e-01f, -1.03578262e-01f,
  3.44551280e-02f, 1.70594886e-01f, 2.29107931e-01f, 1.26000643e-01f, 3.22584867e-01f, 1.09751321e-01f, 1.69053227e-01f, 1.43284351e-01f, 8.50270540e-02f, 2.44757354e-01f,
  1.52812019e-01f, 2.25271896e-01f, -1.16509676e-01f, 1.13558725e-01f, 1.72280088e-01f, 8.28630105e-02f, 2.21553333e-02f, 9.55504030e-02f, 6.43870309e-02f, -6.32056268e-03f,
  1.94641963e-01f, 4.17051315e-02f, 1.58584058e-01f, 1.37721717e-01f, 1.44158989e-01f, 1.38071314e-01f, 1.67030334e-01f, 7.08146915e-02f, 9.24737155e-02f, 1.69038862e-01f,
  3.08762472e-02f, 3.37801762e-02f, -2.04610452e-02f, -6.47104383e-02f, 1.82325616e-02f, 1.66174620e-02f, 2.74291635e-02f, 9.34895799e-02f, 3.23511809e-02f, 1.11971147e-01f,
  -3.96181121e-02f, -1.04326993e-01f, -7.52544254e-02f, -1.67798363e-02f, -7.36299530e-02f, -7.51502812e-02f, -2.35194154e-02f, -1.77959055e-01f, -7.40266815e-02f, -4.30363119e-02f,
  -6.68927431e-02f, -1.18881315e-01f, -2.82701626e-02f, -1.77789927e-01f, -3.58702280e-02f, -1.01000831e-01f, -1.36430666e-01f, -1.52082875e-01f, -8.51325840e-02f, -9.77394655e-02f,
  -8.45168307e-02f, -9.28942263e-02f, -4.05776612e-02f, -7.33106285e-02f, -7.31736869e-02f, -1.65337846e-01f, -1.84535831e-01f, -4.78518680e-02f, -6.41683564e-02f, -1.14842921e-01f,
  1.85042977e-01f, -6.07583933e-02f, -1.98940299e-02f, -7.46544171e-03f, 1.49194449e-01f, 1.01092674e-01f, 5.70523888e-02f, 5.91518804e-02f, 7.97234327e-02f, 5.77118136e-02f,
  7.74540156e-02f, -9.56718228e-04f, 2.61602644e-02f, 5.75560853e-02f, -1.06537854e-03f, -3.29547748e-02f, -1.49190081e-02f, -1.34552158e-02f, 1.09567656e-03f, 7.98927993e-02f,
  -3.08306683e-02f, -4.70690504e-02f, -8.70690644e-02f, -1.05193518e-01f, 5.19074649e-02f, -1.43722564e-01f, -7.15992600e-02f, -5.41566405e-03f, -2.12579623e-01f, -1.24377273e-01f,
  4.78298306e-01f, 3.09128016e-01f, -1.90020382e-01f, 2.80640453e-01f, 4.92491722e-02f, 9.42916125e-02f, 2.42744461e-01f, 2.21276268e-01f, 1.83231145e-01f, 1.74306735e-01f,
  -1.64828263e-02f, -9.92585048e-02f, 6.19741448e-04f, -7.83407092e-02f, -3.34929898e-02f, 1.56414583e-01f, 4.95303757e-02f, -1.80032432e-01f, -1.71494201e-01f, -7.84124807e-03f,
  2.59385798e-02f, -1.59727540e-02f, -1.23104289e-01f, -2.36903504e-02f, 1.53072819e-01f, 6.36974350e-02f, 5.51882386e-03f, -1.39443697e-02f, 1.28126610e-02f, 2.12039515e-01f,
  -3.96787673e-02f, 4.44871184e-05f, -3.99162769e-02f, -2.76704133e-02f, -6.96459487e-02f, -9.89312865e-03f, 1.97122563e-02f, 1.33861648e-02f, -5.93316406e-02f, 5.85085712e-02f,
  -7.85872787e-02f, 3.59982140e-02f, -2.20350530e-02f, 6.31652921e-02f, 1.14892103e-01f, -7.27582397e-03f, 6.25127181e-02f, -2.05918623e-04f, 8.76916423e-02f, 5.16736209e-02f,
  2.38842871e-02f, -8.42716638e-03f, -3.34444754e-02f, 4.32918407e-02f, 7.82165900e-02f, 3.00092977e-02f, 3.75119038e-02f, 4.58137915e-02f, 5.47825173e-02f, 2.50725359e-01f,
  3.64343375e-02f, -1.07951565e-02f, -1.02102138e-01f, -1.84619762e-02f, -4.04539146e-03f, -3.59010622e-02f, 7.52204750e-03f, -2.13863645e-02f, -7.15424865e-02f, 4.94407341e-02f,
  1.42071648e-02f, 7.28481961e-03f, -2.80257612e-02f, 2.79565360e-02f, -7.07319379e-02f, 3.52009162e-02f, -3.24381962e-02f, 5.88031150e-02f, -1.21308587e-01f, -9.38893929e-02f,
  -2.23877802e-02f, -4.70670611e-02f, 6.51714504e-02f, -5.34500591e-02f, -7.70356283e-02f, 1.96321364e-02f, -2.12599966e-03f, -2.38986369e-02f, 3.35821435e-02f, 7.53033459e-02f,
  4.52924222e-02f, -2.11959735e-01f, 1.27743796e-01f, 9.14199352e-02f, 8.70454162e-02f, 1.18367597e-02f, 9.03752670e-02f, -3.35817039e-02f, -1.80653259e-02f, -2.91104168e-02f,
  1.02718780e-02f, -1.40729621e-02f, 7.87161961e-02f, -7.16061667e-02f, 1.26901176e-02f, 6.31670561e-03f, 1.00992844e-01f, -7.14502204e-03f, 8.15801974e-03f, 4.60773557e-02f,
  7.98338056e-02f, 1.98943347e-01f, 1.68422818e-01f, 1.29917935e-01f, 5.92577346e-02f, 5.37781753e-02f, 5.60667776e-02f, 5.75189963e-02f, 8.72707739e-02f, 2.55056471e-01f,
  -3.87935042e-01f, -3.92659873e-01f, -1.63115487e-01f, -1.39357761e-01f, -1.51518494e-01f, -2.97526836e-01f, -4.27916199e-01f, -3.31520677e-01f, -1.75338089e-02f, -1.84781522e-01f,
  -6.08710311e-02f, 6.19708113e-02f, 4.62731235e-02f, -3.02870870e-02f, -2.98661709e-01f, -3.53088409e-01f, -2.89459020e-01f, -2.69987315e-01f, -8.81085172e-02f, -1.13102943e-01f,
  -7.07607195e-02f, -5.82921878e-03f, -7.15772435e-02f, -9.36723575e-02f, 2.77646794e-03f, -1.79932409e-04f, 2.72819977e-02f, -9.15265083e-02f, -3.35406773e-02f, -3.83855999e-02f,
  3.24924430e-03f, -1.79274216e-01f, 3.82200517e-02f, 2.84848511e-02f, 1.25987142e-01f, 6.27839938e-02f, 6.83380365e-02f, 1.59718245e-01f, 1.10229366e-01f, -1.83585659e-02f,
  6.64325291e-03f, 1.13636144e-02f, 7.68602043e-02f, 3.10354233e-02f, 7.51375733e-03f, -4.41037975e-02f, -3.50840352e-02f, -5.93431070e-02f, 6.53441101e-02f, 8.69059414e-02f,
  2.79478859e-02f, -5.77972010e-02f, -4.88700569e-02f, -6.71045408e-02f, 4.97185253e-02f, 2.90222745e-02f, -7.21907765e-02f, -5.44607677e-02f, 7.25017637e-02f, -8.27201158e-02f,
  -1.46906525e-01f, 7.58300349e-03f, -5.24093695e-02f, 1.66257489e-02f, 8.10676813e-02f, -3.07063032e-02f, -1.16963955e-02f, -8.92763436e-02f, 2.45394534e-03f, -4.19194251e-02f,
  -5.63763455e-02f, -1.59428678e-02f, -3.86024229e-02f, 3.95399332e-03f, 1.85110252e-02f, 7.86466338e-03f, -1.09619424e-01f, -7.06013814e-02f, -3.30866571e-03f, 3.45484316e-02f,
  -4.89285886e-02f, 1.52209764e-02f, 5.97307533e-02f, -5.20144962e-03f, -1.09984711e-01f, -2.68756393e-02f, 1.85294207e-02f, 9.18394476e-02f, -5.53477071e-02f, -1.31283551e-01f,
  1.07627928e-01f, 7.55543932e-02f, -1.12597175e-01f, -1.02655375e-02f, 3.20966244e-02f, -1.08649787e-02f, 2.39232276e-02f, -9.48074914e-04f, 3.11860424e-02f, -1.05939023e-02f,
  1.83916017e-02f, -7.13792350e-03f, -1.00884490e-01f, 1.72615256e-02f, -3.58173624e-02f, -9.97563172e-03f, 1.83886997e-02f, 4.82604206e-02f, 2.48021055e-02f, 1.69576402e-03f,
  -4.72755767e-02f, -1.43920809e-01f, -1.46049827e-01f, -1.13101907e-01f, -9.12809744e-02f, -4.22772858e-03f, -7.06436485e-02f, -1.20392377e-02f, -1.01230212e-01f, -1.62575841e-01f
};

// L0_fan_Wp_bar (Shape: 26 x 120)
const int L0_fan_Wp_bar_rows = 26;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -1.02721095e+00f, 4.74400818e-01f, 2.36573905e-01f, -3.62017602e-01f, 7.15422034e-01f, 4.24011856e-01f, 2.53795028e-01f, -1.05456389e-01f, -1.64488539e-01f, -9.67954993e-02f,
  5.13803363e-01f, 7.88457692e-02f, -1.37727380e-01f, -1.15236565e-01f, -4.12740201e-01f, -3.69586125e-02f, 2.13701464e-02f, -5.07377923e-01f, -3.95333529e-01f, -2.74350252e-02f,
  1.94639713e-01f, -3.02547991e-01f, -6.02526128e-01f, -3.72253537e-01f, -1.78353153e-02f, -1.16893582e-01f, 2.66384352e-02f, 2.73242872e-02f, 1.87725142e-01f, -3.41901965e-02f,
  -2.81285882e-01f, -6.75590187e-02f, 2.18905002e-01f, 6.26893416e-02f, 2.26390272e-01f, -3.08381379e-01f, -2.11677343e-01f, -9.07079652e-02f, 8.82043913e-02f, -1.44936502e-01f,
  2.36189023e-01f, 1.76657438e-01f, 1.59926727e-01f, -6.38156235e-02f, -2.29421958e-01f, -1.84182420e-01f, -3.26217890e-01f, -2.86384881e-01f, -3.56732041e-01f, -2.55877972e-01f,
  5.28928876e-01f, 3.92750084e-01f, -1.28578007e-01f, 5.23428656e-02f, -4.58214194e-01f, -2.28624493e-01f, -2.08940879e-01f, -3.15264761e-01f, -4.49502736e-01f, -7.56934106e-01f,
  -1.14433765e-01f, 2.51897126e-02f, -8.13433602e-02f, -1.42497852e-01f, -5.02968691e-02f, 3.19011994e-02f, -6.01223335e-02f, 3.87788080e-02f, -4.37451759e-03f, -4.65107895e-02f,
  8.45860913e-02f, 8.86725932e-02f, 1.04261180e-02f, 4.83348705e-02f, -1.47810832e-01f, 7.34228194e-02f, -6.80042356e-02f, -2.26374656e-01f, -1.29666135e-01f, -5.08146659e-02f,
  -3.03309429e-02f, 1.17350779e-02f, 6.24195971e-02f, -2.13765632e-02f, 7.69412294e-02f, -1.15237096e-02f, -9.70869660e-02f, 1.25974894e-01f, -1.56995654e-02f, -1.33713812e-01f,
  -3.40122402e-01f, 1.93887934e-01f, -3.37801754e-01f, -1.27383456e-01f, 4.25596908e-02f, 3.18328701e-02f, -6.20265864e-03f, 3.18134986e-02f, 1.01790324e-01f, -1.46576792e-01f,
  3.97288203e-02f, 5.07425070e-02f, -8.83655995e-02f, -3.22413142e-03f, -2.06956834e-01f, -6.98893666e-02f, -3.04508805e-01f, -9.95336100e-02f, 6.05080090e-02f, 7.52300099e-02f,
  -4.00476046e-02f, -4.02173370e-01f, -6.14498556e-01f, -2.61171401e-01f, -2.66300857e-01f, -4.72696185e-01f, -5.42249203e-01f, -3.09592307e-01f, -5.37167966e-01f, -1.06533885e+00f,
  -9.92310107e-01f, 3.89710695e-01f, -4.67985004e-01f, -8.45623136e-01f, -4.33523595e-01f, -2.24222820e-02f, 6.90578043e-01f, 1.98553100e-01f, -5.32856226e-01f, 1.69503108e-01f,
  2.86997080e-01f, -5.82329854e-02f, -2.31588513e-01f, 1.90106526e-01f, 3.10757309e-01f, 4.86325845e-02f, -5.30561924e-01f, -5.93088388e-01f, -5.35040870e-02f, 6.22703373e-01f,
  3.79220635e-01f, -1.92837074e-01f, -1.75377324e-01f, -1.37894183e-01f, -1.82601109e-01f, -2.95390904e-01f, -3.98440033e-01f, -2.95061767e-01f, 2.97050234e-02f, -4.69016701e-01f,
  3.44841510e-01f, -3.68799895e-01f, -4.52033095e-02f, -3.24801207e-01f, -4.42499109e-02f, -1.41599163e-01f, 1.14883073e-02f, -3.47070515e-01f, -1.00372456e-01f, -1.12811640e-01f,
  -3.11078578e-01f, -9.10008773e-02f, -1.52037635e-01f, 9.40940455e-02f, -4.97732684e-02f, -1.02953753e-02f, -1.25101224e-01f, -2.12786406e-01f, -2.94056267e-01f, 3.16390276e-01f,
  3.38069677e-01f, -7.41858333e-02f, -1.09497584e-01f, 6.45711049e-02f, 1.76061258e-01f, -8.62562358e-02f, 3.22069466e-01f, 1.16220964e-02f, -1.37314126e-01f, 1.11012973e-01f,
  2.13780180e-01f, 1.27797276e-01f, -1.57510899e-02f, 4.64128740e-02f, 1.59836467e-02f, -1.87355980e-01f, 9.91375186e-04f, 1.98845223e-01f, 1.21088274e-01f, 5.16221784e-02f,
  6.93714572e-03f, 1.25775293e-01f, 9.60389525e-02f, -3.86290736e-02f, 2.21180040e-02f, -1.24913447e-01f, -9.84812854e-04f, 2.21223935e-01f, -6.77792355e-03f, -5.32266907e-02f,
  -8.64219218e-02f, 4.48091701e-02f, -1.22960955e-01f, 1.23242013e-01f, 3.17575112e-02f, -1.47596821e-01f, -1.57560054e-02f, 1.39463946e-01f, 4.43871953e-02f, -1.54767811e-01f,
  1.31756470e-01f, -1.29762113e-01f, -6.39039371e-03f, -1.23178482e-01f, -7.54744112e-02f, -1.54489130e-01f, -5.10799997e-02f, 6.88401833e-02f, -1.55873045e-01f, 1.03109993e-01f,
  1.28212050e-01f, 1.27822787e-01f, 5.91243505e-02f, 1.07315488e-01f, -1.65006295e-01f, -3.81941348e-02f, 6.47731721e-02f, -7.05147907e-02f, -2.46480733e-01f, 5.71373254e-02f,
  1.75080284e-01f, 6.62957951e-02f, 2.07437843e-01f, 4.86440249e-02f, 1.76613182e-01f, -1.39953300e-01f, 2.06424221e-01f, 1.82811826e-01f, -1.68199539e-02f, 4.39317077e-01f,
  -8.34191561e-01f, -9.08254012e-02f, -3.06552567e-04f, 1.64094120e-01f, 4.14618939e-01f, 3.85714173e-01f, 3.02378207e-01f, 3.26770753e-01f, 1.66020572e-01f, 9.05608013e-02f,
  1.83129206e-01f, 1.66303307e-01f, 3.01572829e-01f, 2.69533873e-01f, 2.75078177e-01f, 4.44376707e-01f, 3.72141629e-01f, 1.12471441e-02f, 4.79744375e-02f, 1.53478757e-01f,
  3.73080194e-01f, 4.83924672e-02f, -8.40335116e-02f, 7.06349313e-02f, 9.04509947e-02f, 1.89645022e-01f, 2.66515076e-01f, 1.37260526e-01f, 2.31068909e-01f, 1.23999715e-01f,
  1.54773131e-01f, -3.72999281e-01f, 5.31048030e-02f, -4.82808128e-02f, -2.65100330e-01f, -2.32416779e-01f, -9.75509062e-02f, -9.25524905e-02f, -1.46584794e-01f, 1.26424506e-01f,
  -4.09289217e-03f, -1.24157503e-01f, -4.01067585e-02f, -5.09015247e-02f, -1.12323977e-01f, -2.30046231e-02f, -1.85132340e-01f, 1.15330614e-01f, 2.10657209e-01f, -1.46729471e-02f,
  2.04495806e-02f, 7.20955655e-02f, 8.09192434e-02f, 2.01425105e-01f, 5.39891608e-02f, -2.41918229e-02f, -1.07108261e-02f, -1.46107161e-02f, 2.27469485e-02f, -2.45682895e-02f,
  1.62110180e-01f, -8.17333981e-02f, -1.58481285e-01f, -5.80296777e-02f, -4.31107432e-02f, -1.65693045e-01f, 6.92500025e-02f, 2.03442097e-01f, 1.00773551e-01f, -4.74825501e-02f,
  1.12217620e-01f, 5.95941618e-02f, 6.90069934e-03f, 1.54368818e-01f, -5.28529771e-02f, -7.04634264e-02f, -5.94788380e-02f, -3.44434604e-02f, -7.75884837e-02f, -2.05039904e-01f,
  -9.87751707e-02f, 8.08322802e-03f, -1.23497017e-01f, -1.13639228e-01f, -4.87653054e-02f, 8.00746903e-02f, 1.36719197e-01f, 1.14803270e-01f, 2.30497643e-02f, 3.70931886e-02f,
  5.52504003e-01f, -8.74956697e-02f, -5.39972633e-02f, -7.82780647e-02f, -1.97522976e-02f, -2.84075469e-01f, -1.22602925e-01f, -1.16141345e-02f, -5.26640937e-02f, 5.52158579e-02f,
  -9.39981639e-02f, -2.63582021e-01f, -1.37317494e-01f, -3.23338807e-02f, -5.97846601e-03f, -6.13426082e-02f, -1.84423119e-01f, 1.19694144e-01f, 3.38668935e-02f, -5.98444678e-02f,
  -1.19616628e-01f, 1.48097247e-01f, 1.83791518e-01f, 9.24130380e-02f, 1.50230929e-01f, 1.66792497e-01f, -1.93547178e-02f, -3.43631804e-02f, 1.30149677e-01f, 1.04193196e-01f,
  1.01002681e+00f, -2.93764085e-01f, 5.72419465e-02f, 3.01615775e-01f, 3.85443538e-01f, 2.48639524e-01f, -7.68168271e-02f, -2.83773383e-03f, 2.15652436e-01f, 6.84169754e-02f,
  1.49158597e-01f, 2.80495971e-01f, 1.92629233e-01f, 4.32005972e-02f, -6.77662939e-02f, -1.38412282e-01f, -1.12632215e-01f, 1.44968495e-01f, 1.86918586e-01f, 2.39993453e-01f,
  1.05253473e-01f, 4.60235290e-02f, 2.73893941e-02f, 3.09840702e-02f, -4.79533337e-02f, 2.00330779e-01f, -7.43202195e-02f, -9.01075080e-02f, -5.38368616e-03f, -1.05727650e-02f,
  -3.13054651e-01f, 2.15897113e-02f, 1.45712703e-01f, -3.19478707e-03f, -7.38902390e-02f, -1.78467453e-01f, 4.36362997e-02f, -1.39790876e-02f, -1.32916361e-01f, -2.89885432e-01f,
  -1.53900564e-01f, -1.02610409e-01f, -1.08251069e-02f, -7.67235234e-02f, -6.89252466e-02f, 2.77700555e-03f, -6.63283691e-02f, -3.28817107e-02f, -1.46584272e-01f, -1.10866353e-01f,
  -1.23777182e-03f, 2.34749943e-01f, 1.83836336e-03f, 6.56272918e-02f, 1.25858009e-01f, 1.23806387e-01f, -4.89182770e-02f, 1.40250817e-01f, 9.43307281e-02f, 1.64088950e-01f,
  2.26148337e-01f, 2.37438217e-01f, 2.08454520e-01f, 1.78333655e-01f, 2.22421020e-01f, 1.22840784e-01f, -4.18366455e-02f, -1.01264134e-01f, 2.30944723e-01f, 1.32337704e-01f,
  -8.89210701e-02f, -3.07807364e-02f, 6.07968606e-02f, 4.07061800e-02f, 1.20200917e-01f, 8.35317820e-02f, 1.03789061e-01f, -1.10749707e-01f, 1.25733599e-01f, -6.21656552e-02f,
  6.03231154e-02f, -9.90692973e-02f, 1.97117962e-02f, -2.13829845e-01f, 8.88268929e-03f, 1.01554856e-01f, 2.09825084e-01f, -4.51984257e-02f, 5.78802824e-02f, 2.10966486e-02f,
  -5.63288510e-01f, 2.01815292e-01f, 5.77037446e-02f, -9.54702683e-03f, -1.47307822e-02f, -9.60837770e-03f, 2.28393793e-01f, -8.49973485e-02f, -2.45488673e-01f, -3.13896447e-01f,
  1.36727532e-02f, 3.06234583e-02f, -8.76419097e-02f, 6.24641925e-02f, 6.58921748e-02f, 4.40370329e-02f, 1.36138853e-02f, 2.23028194e-02f, -1.46300986e-01f, -1.93848789e-01f,
  2.29361211e-03f, 9.00432467e-02f, 1.54019549e-01f, 3.08609232e-02f, 5.20945750e-02f, 3.04644793e-01f, 1.40325144e-01f, 3.27668525e-02f, 1.48870125e-01f, 2.11815804e-01f,
  -1.42965078e-01f, 6.15069807e-01f, 2.69215554e-01f, -4.32736814e-01f, -6.46769479e-02f, 2.49228850e-01f, 5.10733128e-01f, -1.21590592e-01f, -3.73240203e-01f, 2.19247654e-01f,
  -1.13963932e-02f, -2.89480418e-01f, -2.49335468e-01f, 5.58690764e-02f, 2.53075004e-01f, 4.85620022e-01f, 4.03812766e-01f, 5.81253357e-02f, -5.62159121e-02f, 1.75551623e-01f,
  1.78747326e-01f, -9.25848857e-02f, -1.53363913e-01f, -6.52712286e-02f, -4.06636558e-02f, -2.12605476e-01f, -2.12041706e-01f, -2.06184536e-02f, 3.49748284e-01f, 4.22763288e-01f,
  2.98113376e-01f, 1.18935719e-01f, -1.43127605e-01f, -3.79794873e-02f, 8.79400000e-02f, 2.49867991e-01f, 2.35814855e-01f, -4.58216444e-02f, 2.98718326e-02f, 9.32650194e-02f,
  8.75399336e-02f, 9.80257466e-02f, 1.22741815e-02f, 8.76598656e-02f, -3.16322781e-02f, 3.03804933e-04f, 5.52493744e-02f, 1.64336756e-01f, -1.41395140e-03f, 1.62024274e-01f,
  1.50822371e-01f, -4.85963151e-02f, -2.44550824e-01f, -1.64429724e-01f, -2.51295846e-02f, -5.11771977e-01f, -1.83035538e-01f, -6.46942994e-03f, -2.12623402e-01f, 1.10836670e-01f,
  -3.12269300e-01f, 1.03673726e-01f, 1.43784627e-01f, 3.50779784e-03f, 1.13382123e-01f, -5.12129366e-02f, -1.06896786e-02f, 8.67390111e-02f, 5.15284091e-02f, 4.56654839e-02f,
  -7.62026533e-02f, -8.60197544e-02f, -8.32422227e-02f, -6.70589283e-02f, -9.06412378e-02f, -1.33729219e-01f, 1.97370544e-01f, 9.59617794e-02f, -2.03118995e-02f, -4.40276042e-02f,
  -1.75047889e-01f, 6.59207478e-02f, -1.65598840e-01f, 1.18057020e-01f, 1.62195042e-01f, -1.23255663e-01f, 1.62831955e-02f, -1.10592626e-01f, -1.88970298e-01f, 2.31123343e-02f,
  -4.52990949e-01f, 4.88218330e-02f, -4.08054627e-02f, 8.12581107e-02f, 1.60828814e-01f, 2.22081784e-02f, -8.60302076e-02f, 5.40662110e-02f, -6.13071285e-02f, 1.51297644e-01f,
  1.23378180e-01f, -3.21196131e-02f, -6.05875105e-02f, 1.09191522e-01f, -8.51336047e-02f, -5.17438352e-02f, 2.19296440e-01f, -8.32316186e-03f, 8.37036297e-02f, 2.71173101e-02f,
  -1.24134021e-02f, -1.00458972e-01f, -5.34573853e-01f, -2.39892989e-01f, -3.15795004e-01f, -4.98549521e-01f, -2.50367194e-01f, -7.92575777e-02f, -1.53802693e-01f, -1.50444254e-01f,
  4.92865741e-01f, 4.76550937e-01f, 1.34341359e-01f, 2.44837239e-01f, 2.44124651e-01f, 2.02133447e-01f, 2.43127018e-01f, -2.27469318e-02f, 3.90913039e-02f, 1.48313239e-01f,
  2.76968181e-01f, 1.56467319e-01f, 1.37152985e-01f, 9.31032225e-02f, 5.49752787e-02f, 6.50740564e-02f, -7.51930922e-02f, -8.10433552e-02f, -4.10084128e-02f, 1.67405475e-02f,
  1.41919076e-01f, 9.37958956e-02f, 3.05259358e-02f, 5.09805605e-02f, 1.45985633e-01f, 1.03893690e-01f, 8.26446563e-02f, 2.53137171e-01f, 2.09945261e-01f, 2.66648948e-01f,
  2.18238786e-01f, 2.27965578e-01f, -2.69166797e-01f, -6.40495196e-02f, -5.14020165e-03f, -2.88038522e-01f, -7.14914352e-02f, -1.65311709e-01f, -1.85648784e-01f, -1.55143827e-01f,
  5.06222621e-02f, -7.47001991e-02f, 1.01927951e-01f, 2.30673607e-02f, -1.40406098e-02f, -2.16554955e-01f, -9.43397731e-02f, -3.13181430e-02f, 4.25646156e-02f, 6.34061694e-02f,
  1.79349795e-01f, 1.71559975e-01f, 4.89902385e-02f, -1.33923799e-01f, 1.65628329e-01f, 1.15587324e-01f, 7.88638964e-02f, 2.57419925e-02f, 5.74567094e-02f, -3.23293395e-02f,
  1.85199618e-01f, 8.55347142e-02f, 2.23713949e-01f, -2.66925106e-03f, 1.15289213e-02f, 4.33531776e-02f, -4.50214483e-02f, -1.67259295e-02f, 3.35337892e-02f, -1.74633786e-02f,
  9.71307233e-03f, 1.08471416e-01f, -1.04663834e-01f, -1.62631780e-01f, -7.63505250e-02f, -2.20556520e-02f, 9.76343378e-02f, 1.71843916e-02f, 8.27782825e-02f, -1.11630140e-02f,
  -2.07948890e-02f, -1.37751430e-01f, -8.03605244e-02f, 5.21862246e-02f, -1.02261946e-01f, -5.21599352e-02f, -5.52030317e-02f, -8.51266086e-02f, -6.72658011e-02f, -6.00629002e-02f,
  -2.53175259e-01f, 3.29724699e-02f, 2.35718451e-02f, -6.68985164e-03f, 1.82643950e-01f, -9.13645327e-02f, 2.23305020e-02f, -3.37057188e-02f, -1.26328319e-01f, -2.66561389e-01f,
  -6.14479706e-02f, -1.95980202e-02f, 1.16775855e-01f, -1.73282679e-02f, -1.96299776e-01f, -2.08339304e-01f, -1.82831250e-02f, 8.37617218e-02f, -3.05038821e-02f, -8.93094484e-03f,
  -1.51165966e-02f, -1.94735751e-01f, -1.82390884e-01f, -2.30957761e-01f, -3.91853638e-02f, -1.61250710e-01f, -1.59299180e-01f, -3.99718694e-02f, -5.07677943e-02f, -1.83496103e-01f,
  5.25027514e-01f, 6.39507920e-02f, 1.89294755e-01f, 1.46783918e-01f, -2.04143375e-01f, -2.44418785e-01f, -3.99723262e-01f, -5.69181144e-02f, 9.38657001e-02f, 9.97696742e-02f,
  -7.04598278e-02f, 2.07628682e-01f, 2.10964277e-01f, 2.93078989e-01f, 2.25910112e-01f, 6.92379773e-02f, 1.46594554e-01f, 2.60310858e-01f, 8.21264461e-02f, -6.91137388e-02f,
  -5.59249893e-02f, 1.02343768e-01f, 3.48338664e-01f, 3.03600639e-01f, -1.49520650e-03f, 1.05808951e-01f, 1.40875369e-01f, -1.73037559e-01f, -2.51094364e-02f, 2.56313026e-01f,
  4.96911630e-02f, 1.93698734e-01f, 2.95415372e-01f, 1.71159729e-01f, 3.04088295e-01f, 2.66060084e-01f, 1.23463206e-01f, 5.83476536e-02f, -2.40603983e-02f, 1.34111300e-01f,
  1.83426976e-01f, 1.74660996e-01f, 1.07127048e-01f, -1.69195145e-01f, -9.78938267e-02f, 2.08565919e-03f, 9.72817913e-02f, 1.16356509e-02f, -1.00810570e-03f, 1.26207501e-01f,
  1.88688301e-02f, -1.43096924e-01f, -1.29104838e-01f, -1.11097589e-01f, 3.92338857e-02f, 1.27235815e-01f, 1.47349769e-02f, 5.58331460e-02f, 1.29123926e-02f, -1.60610657e-02f,
  7.50261396e-02f, -1.42939776e-01f, 7.70906880e-02f, -1.09182984e-01f, -1.07096940e-01f, -1.48033202e-01f, -2.63371766e-01f, -3.57984185e-01f, -1.26260281e-01f, -4.62633446e-02f,
  -2.21494853e-01f, -8.06935970e-03f, -7.05704316e-02f, -9.38555971e-02f, 4.62201126e-02f, -1.94129795e-01f, -2.25710601e-01f, -1.63520306e-01f, -4.50362042e-02f, 4.04652655e-02f,
  -5.13075776e-02f, -1.07634544e-01f, 2.40938462e-04f, -1.28555045e-01f, -1.39278904e-01f, -1.48946881e-01f, -1.61801428e-01f, -3.08567025e-02f, -1.67775378e-01f, -1.44645736e-01f,
  -2.42025554e-01f, 3.27662230e-01f, 1.35321945e-01f, 1.07309505e-01f, 4.54710089e-02f, 1.36540696e-01f, 1.23752855e-01f, -3.00034732e-02f, -1.10252924e-01f, 1.30323879e-02f,
  1.92785729e-02f, 1.07320718e-01f, 8.86335745e-02f, 1.92045849e-02f, -5.83296493e-02f, 2.35018339e-02f, 4.27042618e-02f, 8.24495032e-02f, 1.29814267e-01f, 1.76925734e-01f,
  -1.51298661e-02f, -1.51725084e-01f, -1.46602586e-01f, 6.25239611e-02f, -3.66044827e-02f, 1.97606813e-02f, 2.17596698e-03f, -4.83146831e-02f, -3.59098502e-02f, 3.96262854e-02f,
  -1.97269827e-01f, 2.80401528e-01f, -5.39384663e-01f, -5.92919648e-01f, -6.75358713e-01f, -2.32596248e-01f, -2.24945992e-01f, 1.39516249e-01f, 1.87471300e-01f, -2.66259089e-02f,
  -1.35404751e-01f, -3.72865289e-01f, -1.89636424e-01f, -1.63888961e-01f, 2.43325666e-01f, 1.42326429e-01f, 2.60022245e-02f, -3.42957050e-01f, -6.27491534e-01f, -6.53332651e-01f,
  -4.98870432e-01f, -6.28525496e-01f, -3.15665096e-01f, -1.40285060e-01f, -4.62239444e-01f, -3.96656036e-01f, -1.55611232e-01f, -2.01283827e-01f, 4.30319831e-02f, -2.64070958e-01f,
  -7.06579387e-01f, -1.61573902e-01f, -1.05415471e-01f, -1.12647496e-04f, -2.52593786e-01f, -3.92848551e-02f, -1.38803989e-01f, 2.00979367e-01f, 9.44475904e-02f, 7.48496950e-02f,
  -2.00595170e-01f, -1.68832213e-01f, -2.22903788e-01f, -1.96813360e-01f, -3.68247896e-01f, -1.08793303e-01f, 4.32524197e-02f, 6.62861466e-02f, 1.37460127e-01f, 2.20152825e-01f,
  1.41155720e-01f, 2.13189907e-02f, 1.60031412e-02f, 2.20241860e-01f, 3.49931628e-01f, 8.73949155e-02f, -9.15808417e-03f, -6.32795915e-02f, 2.38099903e-01f, 6.47017807e-02f,
  1.55960899e-02f, -5.17763337e-03f, -2.07201689e-02f, -1.13437325e-01f, 2.97002178e-02f, 1.83677927e-01f, 3.26490292e-04f, -5.43911643e-02f, 7.11783469e-02f, -1.25509217e-01f,
  2.34102942e-02f, 2.02384666e-01f, -6.30316436e-02f, 3.12636606e-02f, -1.06827013e-01f, 1.66924559e-02f, 1.50697082e-02f, 3.29784416e-02f, -8.60981829e-03f, -8.89941379e-02f,
  -9.57480669e-02f, 2.05147006e-02f, 2.62793563e-02f, -1.49634331e-01f, 9.28375218e-03f, 1.91351734e-02f, -8.92575830e-02f, 3.24339718e-02f, 3.21946926e-02f, 7.04883970e-03f,
  -4.37065512e-01f, 4.35065180e-01f, -1.25754908e-01f, -7.99196362e-02f, -6.74718618e-02f, 1.80185422e-01f, -1.24378584e-01f, 7.65158534e-02f, -3.51920873e-02f, -2.61570275e-01f,
  -2.20574483e-01f, -1.38048921e-02f, 5.53437434e-02f, 2.51891501e-02f, -1.92986503e-01f, -7.20832422e-02f, 1.47627458e-01f, -2.37826228e-01f, 1.46794975e-01f, 5.78833967e-02f,
  2.94756800e-01f, 1.12779856e-01f, -7.29767159e-02f, 1.77073628e-01f, 5.82562983e-02f, -1.76922873e-01f, -1.84980169e-01f, -6.30551055e-02f, 2.71124482e-01f, 1.85146645e-01f,
  -8.69028986e-01f, -6.76294491e-02f, 4.49869901e-01f, 8.66187438e-02f, -6.20994437e-03f, -1.64350227e-01f, -6.20704293e-01f, -1.90458283e-01f, 2.18627095e-01f, -6.41900348e-03f,
  -3.07226300e-01f, -2.55638987e-01f, 2.40844890e-01f, 1.00053743e-01f, -3.03092897e-01f, 1.60500243e-01f, 4.92643654e-01f, 1.68783382e-01f, -4.39131886e-01f, -7.50667691e-01f,
  -4.72934991e-01f, -3.85922015e-01f, -2.93684244e-01f, 1.85039453e-02f, 4.84595686e-01f, 1.50956884e-01f, 5.71615338e-01f, 2.01384261e-01f, 4.09438610e-02f, 7.31686532e-01f,
  -1.55172840e-01f, -4.56872322e-02f, -5.42899929e-02f, -2.01093107e-01f, 9.56975296e-02f, -1.51353721e-02f, -2.07419872e-01f, 1.35734141e-01f, -6.20810203e-02f, -1.99450320e-03f,
  -1.44264311e-01f, 4.07801531e-02f, -2.33280316e-01f, -4.23059650e-02f, -2.07058251e-01f, -2.27820233e-01f, 8.15159604e-02f, -7.99834654e-02f, -1.72297470e-02f, -7.59982914e-02f,
  -2.79354662e-01f, -5.01937449e-01f, -1.72183841e-01f, 7.95076974e-03f, 2.39161506e-01f, -2.77626991e-01f, -1.33665130e-02f, 5.47227748e-02f, 1.05149798e-01f, 2.25470349e-01f,
  7.41439685e-02f, 1.59311801e-01f, 1.86017230e-01f, 2.42822096e-01f, -1.69754624e-01f, 1.23425946e-01f, 2.73282409e-01f, -1.96259841e-03f, 1.13580465e-01f, -9.25589427e-02f,
  5.71707264e-02f, -1.28244147e-01f, -5.13702743e-02f, -7.21922144e-02f, 1.37759775e-01f, -5.26792258e-02f, -1.77966565e-01f, -6.18771091e-02f, 6.87123984e-02f, 1.22385167e-01f,
  -7.80171603e-02f, -3.54796872e-02f, 6.98056221e-02f, 5.13882488e-02f, 1.49132371e-01f, 2.62413353e-01f, -7.07787797e-02f, 1.68395955e-02f, -2.54187882e-02f, -1.37591869e-01f,
  -1.46735594e-01f, 1.48399010e-01f, -4.62779664e-02f, -1.10161573e-01f, -3.88437994e-02f, 1.66488871e-01f, 1.51531771e-01f, -8.36596787e-02f, -3.28741446e-02f, -2.78140962e-01f,
  -1.93514764e-01f, -6.59704432e-02f, 2.03560904e-01f, 2.52003223e-01f, -2.77967542e-01f, -2.70948093e-02f, -3.22207153e-01f, -1.37749985e-01f, -1.39456540e-01f, -6.10621609e-02f,
  1.46825582e-01f, -5.31875551e-01f, -6.18989885e-01f, -2.54834533e-01f, -1.50317103e-01f, -5.73988020e-01f, -9.12208781e-02f, -8.53456631e-02f, -2.16853216e-01f, -4.01697665e-01f,
  2.13417053e-01f, -2.83749789e-01f, -6.23862706e-02f, 5.50561175e-02f, -8.70203227e-02f, -9.75296795e-02f, 5.61783276e-02f, -3.32551412e-02f, 1.08432278e-01f, 1.07956432e-01f,
  -1.28337651e-01f, 1.92770567e-02f, 1.55756801e-01f, -9.90911722e-02f, -2.44194865e-01f, -4.36682217e-02f, -1.63409352e-01f, -5.87737598e-02f, 1.45784393e-01f, 3.92965600e-02f,
  -6.28904626e-02f, 7.13683739e-02f, -5.65459020e-02f, 1.04618249e-02f, 1.30412862e-01f, 2.60340143e-02f, -4.17060629e-02f, -1.15854219e-01f, -3.09761375e-01f, -2.69619435e-01f,
  2.30740607e-01f, -3.35957855e-01f, -4.59641032e-02f, -2.19047323e-01f, 3.37494053e-02f, -4.99408059e-02f, -4.04966660e-02f, -3.99487503e-02f, 1.36525333e-01f, 1.71486154e-01f,
  -5.62699400e-02f, -1.35751262e-01f, -2.20096316e-02f, 1.19111016e-01f, 2.38805428e-01f, 1.58796817e-01f, -3.84827405e-02f, -2.25177288e-01f, -1.24891229e-01f, -1.86724767e-01f,
  -1.41711742e-01f, -1.26617745e-01f, -1.27402425e-01f, -1.13249406e-01f, -1.15727022e-01f, -8.52201581e-02f, 1.75651927e-02f, -1.35730073e-01f, -9.05809775e-02f, 2.64766335e-01f,
  -2.70796329e-01f, -1.49536371e-01f, -2.07792118e-01f, -7.90508091e-02f, -8.12507123e-02f, 2.38450710e-02f, -5.98974936e-02f, 9.01190192e-02f, -6.78256601e-02f, -9.65125263e-02f,
  2.54874537e-03f, -3.03419709e-01f, -1.41549185e-01f, -4.05720547e-02f, -1.51763037e-01f, -1.05751783e-01f, -3.82357314e-02f, -1.41596556e-01f, -2.19686568e-01f, -1.71395823e-01f,
  -2.11832777e-01f, -6.33301362e-02f, -1.09362885e-01f, -5.65905049e-02f, -2.95293242e-01f, -1.58969015e-01f, -1.67672083e-01f, -2.41075009e-01f, 8.08202773e-02f, -6.29521385e-02f,
  1.46207526e-01f, -4.93409753e-01f, 1.15563028e-01f, -1.98661163e-01f, -1.72458105e-02f, -1.45570308e-01f, -9.82936621e-02f, -2.33966544e-01f, -8.50707944e-03f, 2.49622483e-02f,
  -2.49733984e-01f, 1.24753788e-01f, 5.04464395e-02f, 2.42379997e-02f, 2.20081359e-01f, 9.08619091e-02f, -1.41889051e-01f, -1.91605818e-02f, -1.78548589e-01f, -4.75477725e-02f,
  -9.81558114e-02f, -7.11371982e-03f, 8.16990584e-02f, 1.24697015e-01f, 7.98588395e-02f, 1.26140043e-01f, 2.22613439e-01f, 1.40863582e-01f, 1.29162952e-01f, 3.96033794e-01f,
  -2.45478749e-01f, -4.02868927e-01f, 1.62041381e-01f, 4.76283371e-01f, 2.77189940e-01f, 3.81982863e-01f, 1.36304736e-01f, 2.76129574e-01f, 4.43150312e-01f, 2.75886595e-01f,
  7.41464719e-02f, 3.44384730e-01f, 2.32773632e-01f, 1.58509597e-01f, 1.18272670e-01f, 3.34938705e-01f, 4.23052073e-01f, 1.31038964e-01f, 2.35418752e-01f, 2.78278410e-01f,
  2.78928369e-01f, -1.82875618e-02f, -2.09926739e-01f, 1.15638539e-01f, 2.05248311e-01f, 3.33426327e-01f, 1.69880807e-01f, -8.07932541e-02f, 7.60850236e-02f, 1.69556588e-01f,
  -4.51735184e-02f, -2.62390733e-01f, 1.62240252e-01f, -2.08179891e-01f, -1.88098162e-01f, -2.02097580e-01f, 1.23265143e-02f, -1.41350314e-01f, -2.13601440e-01f, -4.37519029e-02f,
  -1.37668028e-01f, -1.33843198e-01f, -1.41979232e-01f, -6.43985644e-02f, -2.05963776e-01f, -2.01292112e-01f, -1.35832444e-01f, 4.96298932e-02f, 1.33469105e-01f, 1.91420421e-03f,
  1.01427652e-01f, 1.95091739e-02f, 7.52106607e-02f, 1.04942009e-01f, 4.50028703e-02f, -1.35011249e-03f, -6.29843101e-02f, -3.57338041e-02f, -1.55913793e-02f, 4.03390639e-02f,
  2.68235147e-01f, 1.93107188e-01f, 5.07797077e-02f, 1.53287068e-01f, 5.85594662e-02f, 1.49259105e-01f, 1.03568576e-01f, 2.85079684e-02f, 6.78143874e-02f, 1.59500577e-02f,
  1.33449256e-01f, 1.48683026e-01f, 9.96585041e-02f, 1.49494722e-01f, 1.81692407e-01f, -8.85144342e-03f, -3.55651937e-02f, 4.73084711e-02f, -1.70563430e-01f, -9.34966877e-02f,
  -1.03628576e-01f, 3.88806872e-02f, -2.94742495e-01f, -1.29950032e-01f, 1.44247198e-02f, 4.27126922e-02f, 1.62171528e-01f, -2.65940689e-02f, -1.07440855e-02f, -2.46193688e-02f,
  2.22185627e-01f, 1.07709303e-01f, 1.74528614e-01f, -1.40903126e-02f, -1.96242645e-01f, -1.90134659e-01f, 1.40071407e-01f, -8.41292888e-02f, -2.68800884e-01f, -6.21828623e-02f,
  1.52505084e-03f, -1.48296311e-01f, -1.16434790e-01f, -5.43197133e-02f, 2.83858888e-02f, -4.26537730e-02f, -7.43563324e-02f, 2.15174422e-01f, 2.62964796e-02f, 5.74413314e-02f,
  -2.34624743e-02f, 1.95907101e-01f, 3.48550439e-01f, 2.67759830e-01f, 6.00244291e-02f, 1.82199553e-01f, -2.76674051e-02f, -6.03731312e-02f, 4.26367521e-02f, 1.02786943e-01f,
  8.79712760e-01f, 6.35631740e-01f, 4.46244568e-01f, 6.31247833e-02f, 1.91552654e-01f, 5.44429541e-01f, 8.16633344e-01f, 5.96902370e-01f, 1.50278941e-01f, 2.94082552e-01f,
  2.30240792e-01f, -2.51019329e-01f, -1.66103661e-01f, -1.97249591e-01f, 1.55544952e-01f, -2.72788145e-02f, -6.39547855e-02f, -8.01538210e-03f, 1.19896345e-01f, 4.05535027e-02f,
  -2.57575840e-01f, 5.85692450e-02f, 2.90516943e-01f, 7.84002151e-03f, -2.02895105e-01f, -3.88000071e-01f, -1.51812527e-02f, 1.59168839e-01f, 6.49176165e-02f, -5.75993478e-01f,
  -1.69772491e-01f, 2.70928174e-01f, -4.12601113e-01f, -1.95890546e-01f, 2.45914534e-02f, 9.45684612e-02f, 7.07087070e-02f, 1.42570883e-01f, 1.78691447e-01f, 2.82068420e-02f,
  -2.32716426e-02f, 5.06951213e-02f, 4.73224185e-02f, 1.04683615e-01f, 2.54748672e-01f, 1.53090894e-01f, 2.26479456e-01f, 1.78630173e-01f, 7.81576931e-02f, -6.07535467e-02f,
  -1.83461253e-02f, 2.50402451e-01f, 3.33862185e-01f, 1.72739983e-01f, 1.75712734e-01f, 4.00828272e-02f, 8.06585103e-02f, 1.43692151e-01f, 1.35574833e-01f, 1.24469742e-01f,
  6.83476478e-02f, 2.04676576e-02f, 1.57207642e-02f, 4.40370701e-02f, 3.58421877e-02f, 3.43225226e-02f, -7.13161826e-02f, 4.41408753e-02f, 3.79297212e-02f, 1.46696800e-02f,
  8.60998631e-02f, -1.07611403e-01f, 9.17193368e-02f, -1.24185778e-01f, -1.71476156e-01f, -4.76448946e-02f, 1.24622881e-01f, 4.63990495e-02f, -3.03274728e-02f, 4.06871475e-02f,
  -7.92230517e-02f, 9.11914036e-02f, -2.49553472e-02f, 8.66540670e-02f, 4.69050258e-02f, 2.78737936e-02f, -3.73903178e-02f, 1.04091794e-03f, 7.66668096e-02f, -4.01486307e-02f,
  -2.54683673e-01f, 5.11206090e-02f, -4.57148999e-01f, -1.65739715e-01f, 9.66760702e-03f, -9.44435783e-03f, -2.46299431e-01f, -1.67208210e-01f, -4.04646769e-02f, -2.73107048e-02f,
  4.46506962e-02f, 7.61106843e-03f, 1.35773420e-02f, 4.82253172e-02f, -6.90880045e-02f, 1.44468984e-02f, 7.30751678e-02f, -8.76834765e-02f, -9.19100419e-02f, -1.50680318e-01f,
  8.52854475e-02f, 1.07014049e-02f, 8.88859406e-02f, -1.05771497e-01f, -1.28617227e-01f, -2.42422193e-01f, -1.07057929e-01f, 2.32975204e-02f, -4.63596359e-02f, -8.68947133e-02f,
  -1.67963862e-01f, -9.91801679e-01f, -4.64380175e-01f, -3.34990948e-01f, -3.04287016e-01f, -8.21656957e-02f, -3.96279842e-01f, 2.74739191e-02f, -9.93499011e-02f, -7.86091864e-01f,
  -2.49767587e-01f, 1.95878744e-01f, -7.73158446e-02f, 2.01525524e-01f, 4.06681210e-01f, -7.67482460e-01f, -4.54684913e-01f, 3.27470601e-01f, 9.29554284e-01f, 6.30208492e-01f,
  1.36618733e-01f, 1.88908517e-01f, 4.73795712e-01f, 2.63260841e-01f, -5.42497337e-01f, 5.96752688e-02f, -5.03500164e-01f, -2.26561785e-01f, -2.59452999e-01f, -9.20068204e-01f,
  -6.02189720e-01f, -4.39777523e-01f, 3.89158428e-01f, 2.74129391e-01f, -7.08839446e-02f, 5.22844642e-02f, 8.78100842e-02f, -4.84816171e-02f, -4.45190594e-02f, -2.02082559e-01f,
  4.43396531e-02f, 1.99928552e-01f, 5.06911054e-02f, 3.26760709e-02f, -1.03655411e-02f, -8.38499516e-03f, 4.56642210e-02f, 1.03300266e-01f, -3.18822376e-02f, -1.90162227e-01f,
  -2.60452658e-01f, -2.86330342e-01f, -2.72543401e-01f, -1.43062517e-01f, 6.09256215e-02f, 2.05627292e-01f, 9.31338780e-03f, 1.75599739e-01f, 1.01477563e-01f, -7.01570392e-01f,
  1.22151244e-02f, -2.97896378e-02f, 2.72045452e-02f, 1.20885871e-01f, 3.49711552e-02f, -6.82684109e-02f, -9.28122029e-02f, -4.47826497e-02f, 1.62198827e-01f, -4.15964499e-02f,
  6.57816827e-02f, -9.30568874e-02f, 1.90690253e-02f, -1.79674298e-01f, -1.09701283e-01f, -9.95932221e-02f, -1.56267658e-01f, -2.47336831e-02f, -3.90125848e-02f, -6.84316084e-02f,
  1.43721834e-01f, -1.17551170e-01f, -1.51429549e-02f, 9.02635455e-02f, -7.97520950e-02f, 4.10006791e-02f, -8.39942619e-02f, 1.02961518e-01f, 9.46818367e-02f, -7.04567283e-02f,
  -2.15372980e-01f, 3.05750847e-01f, -3.86663318e-01f, 2.58976202e-02f, -8.65867883e-02f, 5.11175282e-02f, -2.45205045e-01f, 8.55608433e-02f, -7.20096007e-02f, -4.39708456e-02f,
  1.28483862e-01f, -1.93454027e-02f, -2.00912356e-01f, 8.73312950e-02f, 2.03899249e-01f, 4.36108969e-02f, 8.08775946e-02f, -7.10634515e-02f, 1.14333063e-01f, 3.03701428e-03f,
  -1.56190783e-01f, 1.23708823e-03f, -8.21139663e-03f, -6.58380538e-02f, -5.44623584e-02f, 2.40345404e-01f, -8.78846049e-02f, -5.59051782e-02f, 2.16207936e-01f, -6.19202673e-01f,
  3.92503858e-01f, 7.09309578e-02f, 2.00589404e-01f, 1.93686470e-01f, -9.60274115e-02f, -5.71848273e-01f, -8.11672747e-01f, -4.20889705e-01f, 4.59876657e-02f, -6.26532454e-03f,
  -1.02319106e-01f, 1.58495810e-02f, 1.40208393e-01f, -1.44407436e-01f, -4.82109398e-01f, -2.31081948e-01f, 6.90215733e-03f, -2.50867475e-02f, -1.88842684e-01f, -3.82053226e-01f,
  -1.41325369e-01f, 1.27666339e-01f, 6.05953261e-02f, 3.25761102e-02f, 5.41934490e-01f, 1.88445792e-01f, 2.92508602e-01f, 3.39261144e-01f, 3.10304686e-02f, 5.89161038e-01f,
  5.69174647e-01f, 4.16861743e-01f, -4.65069383e-01f, 1.92418367e-01f, 3.03631961e-01f, 6.06415458e-02f, -3.17439325e-02f, 2.51354873e-01f, -1.47396047e-02f, 1.65740540e-03f,
  1.55365944e-01f, 1.26418397e-01f, 6.74178004e-02f, -1.70354694e-02f, -1.02888718e-01f, -1.13042668e-01f, 7.64903962e-04f, 4.18203250e-02f, 2.33485550e-02f, 5.50297797e-02f,
  -1.16647638e-01f, -3.08152121e-02f, -5.11227585e-02f, -2.61872292e-01f, 4.06621359e-02f, 3.74098159e-02f, -5.81748523e-02f, 2.49114588e-01f, -1.57036811e-01f, 3.92093658e-01f,
  -6.36445582e-02f, 4.88035902e-02f, 3.53017859e-02f, -6.24024272e-02f, -3.82611863e-02f, -3.04205660e-02f, 2.41691861e-02f, -1.14986509e-01f, 2.79705003e-02f, -2.76179090e-02f,
  -1.29384488e-01f, -9.98899341e-02f, -3.23449150e-02f, 1.29546002e-02f, -2.51971409e-02f, 9.46891755e-02f, -1.16699778e-01f, -4.41130437e-02f, -4.61049080e-02f, 3.26948501e-02f,
  -4.59760353e-02f, 6.00630268e-02f, 2.77796596e-01f, -2.18356103e-02f, -4.25108103e-03f, -2.91961394e-02f, 8.01280141e-04f, -8.20060521e-02f, 1.54643118e-01f, 4.01272215e-02f,
  -1.02163382e-01f, -5.61423719e-01f, 3.50190662e-02f, 2.19775047e-02f, 8.12303945e-02f, 1.17294632e-01f, -8.63664970e-03f, -3.75456959e-02f, 1.67641208e-01f, -4.59772758e-02f,
  -4.17213142e-02f, -1.07452266e-01f, 1.41144544e-02f, 4.15474474e-02f, -1.87135637e-01f, -1.63573828e-02f, -1.52958050e-01f, -4.39437516e-02f, -1.96005210e-01f, 9.23361331e-02f,
  -1.81576043e-01f, -3.81896108e-01f, -3.27301979e-01f, -4.42066699e-01f, -7.94151276e-02f, -2.92027086e-01f, -1.46865830e-01f, -1.25603974e-01f, -4.01241809e-01f, -3.83271545e-01f,
  -5.87258101e-01f, -4.13884789e-01f, 2.61807591e-01f, -3.96560013e-01f, 1.18534997e-01f, 4.09539789e-01f, 4.78658676e-01f, -9.44975242e-02f, -3.10398221e-01f, 6.45595118e-02f,
  -3.33693266e-01f, -6.03967488e-01f, -5.04906952e-01f, -2.40413040e-01f, -4.94996272e-02f, 5.38972855e-01f, 3.69545609e-01f, 5.53397052e-02f, 2.31343731e-01f, 1.89207688e-01f,
  -6.30989820e-02f, -2.67945141e-01f, -3.57956946e-01f, -3.11397821e-01f, -2.51079261e-01f, -1.67531207e-01f, -1.92694589e-01f, -2.41591617e-01f, -8.98482651e-02f, -1.83202460e-01f,
  2.92252690e-01f, -4.08831239e-01f, 2.67160479e-02f, -2.33751506e-01f, -8.96844342e-02f, -2.03202397e-01f, 1.49727305e-02f, -1.13756172e-01f, -9.41048339e-02f, -1.07511282e-02f,
  -1.93222240e-01f, -6.77484646e-02f, -1.43743679e-01f, -6.73111528e-03f, 2.47647297e-02f, 1.43591896e-01f, -1.32570460e-01f, -2.21119314e-01f, -1.04406297e-01f, -1.11427031e-01f,
  -1.42188132e-01f, 4.09532636e-02f, 1.25171363e-01f, -2.41169650e-02f, -1.88599974e-01f, -5.74056879e-02f, -6.74242079e-02f, -1.27803519e-01f, -9.46707129e-02f, 1.45250857e-01f,
  2.84317136e-01f, 1.95419099e-02f, -1.08488880e-01f, -6.59917369e-02f, 5.96076585e-02f, 1.05424173e-01f, 7.23191649e-02f, 7.02544954e-03f, -1.14743836e-01f, -5.70529513e-02f,
  2.61200853e-02f, -1.10397935e-01f, -9.87393707e-02f, -6.11502565e-02f, -1.37658566e-01f, -3.17897618e-01f, -9.26560014e-02f, -9.21191350e-02f, -9.41743627e-02f, -7.86392987e-02f,
  -1.76088631e-01f, -1.07402310e-01f, -2.92674731e-02f, 1.65074691e-02f, 5.08112425e-04f, -5.23822829e-02f, -1.04161777e-01f, -6.66315407e-02f, -6.93271980e-02f, -1.52760476e-01f,
  -3.40560913e-01f, -1.20532128e-03f, 1.95090488e-01f, -2.84626603e-01f, -1.45182073e-01f, -9.70483720e-02f, -3.12676042e-01f, -4.84372070e-03f, -9.03542489e-02f, 7.62687773e-02f,
  -1.74475145e-02f, -1.50674395e-03f, 4.29378487e-02f, 5.98128960e-02f, 2.51559585e-01f, 6.44784942e-02f, -2.15305891e-02f, 7.95261040e-02f, -7.42188320e-02f, -2.30370611e-02f,
  4.53331433e-02f, 3.18604439e-01f, 2.46094733e-01f, 1.49960965e-01f, 3.05095538e-02f, 2.50327528e-01f, 2.66857266e-01f, 2.07466081e-01f, 3.29132080e-01f, 5.61680794e-01f,
  1.14971995e+00f, -4.49992537e-01f, -2.62708008e-01f, 2.69428100e-02f, -2.22779080e-01f, -7.01340288e-02f, -4.85896409e-01f, -7.58874463e-03f, 1.53788432e-01f, -3.27953607e-01f,
  4.84909445e-01f, 9.71947610e-01f, 6.60793424e-01f, 4.65034992e-01f, 4.99140292e-01f, -6.24611616e-01f, -7.04047501e-01f, 9.83992219e-02f, 3.40830147e-01f, 5.45627363e-02f,
  -2.18003854e-01f, -3.84612471e-01f, -1.61012001e-02f, -1.43529400e-01f, -7.11199820e-01f, 1.78051338e-01f, -7.09117055e-01f, -4.74995911e-01f, -2.58846879e-01f, -8.00995529e-01f,
  3.68331857e-02f, 1.68403864e-01f, 1.84176698e-01f, 3.42836291e-01f, -2.47045770e-01f, 3.79416607e-02f, -1.11425944e-01f, -3.63051742e-01f, 4.18193154e-02f, -1.25633612e-01f,
  8.23334903e-02f, 1.64254159e-01f, 9.22366083e-02f, -1.07786886e-01f, -3.06736559e-01f, -5.31827733e-02f, -2.17597604e-01f, 2.47114133e-02f, -7.78915826e-03f, -1.02585711e-01f,
  -1.40009165e-01f, -1.56396870e-02f, -8.10934007e-02f, -2.79313475e-01f, -9.18651596e-02f, 7.42451996e-02f, -6.14405274e-01f, -2.18858674e-01f, -2.53094491e-02f, -8.36498737e-01f,
  -4.15025428e-02f, 5.41022420e-02f, 1.82459764e-02f, -2.34812573e-01f, 1.03098258e-01f, 1.05743676e-01f, 1.16891414e-03f, 3.01265530e-02f, 2.91017741e-02f, -2.11359039e-01f,
  -1.39763327e-02f, -4.22171801e-02f, -9.47243869e-02f, -2.19408020e-01f, -9.25547630e-02f, -5.09943850e-02f, 4.39613126e-02f, -3.37655991e-02f, 4.04902175e-02f, 2.13849153e-02f,
  2.87725851e-02f, -7.67697543e-02f, -3.62751707e-02f, -3.77133377e-02f, 3.32147628e-02f, 1.04259029e-01f, 2.10298404e-01f, 3.23748626e-02f, 1.80873945e-02f, -2.01504584e-02f,
  5.37986979e-02f, 4.05161381e-01f, 8.25251788e-02f, 1.33059666e-01f, -1.78889874e-02f, -5.83055578e-02f, -1.58598408e-01f, -6.70705289e-02f, 9.93973836e-02f, 1.09078519e-01f,
  -4.75144535e-02f, 3.01827434e-02f, -3.47253345e-02f, -1.31525889e-01f, -1.01328425e-01f, 9.16353613e-02f, 1.76235065e-02f, 1.17315158e-01f, -1.78228095e-02f, -3.75883102e-01f,
  -2.75088370e-01f, -2.11860072e-02f, 9.81087238e-02f, 6.30899668e-02f, -1.42143607e-01f, 2.63379037e-01f, -2.98103213e-01f, -3.00875723e-01f, 2.90414572e-01f, -5.91461778e-01f,
  -6.09312475e-01f, 5.73356450e-01f, 3.45989585e-01f, -1.34307861e-01f, 6.86652660e-01f, 1.13907814e-01f, -1.87647541e-03f, -4.44478303e-01f, -1.16171218e-01f, 2.98341900e-01f,
  6.48885727e-01f, -6.73375726e-02f, 1.29281208e-01f, -1.31457284e-01f, -5.02188504e-01f, 1.44353941e-01f, 1.95075959e-01f, -3.09313834e-01f, -7.75171280e-01f, -3.82258445e-01f,
  5.26408404e-02f, -2.90258616e-01f, -5.95414460e-01f, -4.19139564e-01f, 3.39934409e-01f, 3.39154713e-02f, 4.54441756e-01f, 2.36974597e-01f, 2.99486369e-01f, 4.52099591e-01f,
  3.90776336e-01f, 2.17074171e-01f, -1.51734233e-01f, 2.72323430e-01f, 2.73653984e-01f, -3.39935720e-01f, -6.62940145e-02f, -7.82084465e-02f, 4.44166269e-03f, -8.76669362e-02f,
  1.98276803e-01f, -2.49212608e-02f, 1.90939903e-01f, -4.10264507e-02f, -1.17930196e-01f, -1.96573481e-01f, -9.73923951e-02f, -4.19850022e-01f, -4.35353965e-01f, -1.64101273e-01f,
  2.66815841e-01f, 3.59829813e-01f, 2.02814773e-01f, -8.07943642e-02f, -2.30882064e-01f, -9.12162215e-02f, -1.18742302e-01f, -2.86440372e-01f, -3.23233217e-01f, -2.50367522e-01f,
  2.66065123e-03f, 9.54355896e-02f, 1.57160193e-01f, 5.99032715e-02f, -1.46140635e-01f, -6.98868465e-03f, 6.53483300e-03f, 4.04210314e-02f, -1.06004708e-01f, -1.28850907e-01f,
  3.87572423e-02f, 7.05023184e-02f, -1.18637897e-01f, 1.29633591e-01f, -1.42441034e-01f, -1.35943536e-02f, 2.39111204e-02f, -6.59918040e-02f, 1.69958726e-01f, -7.11854547e-02f,
  -5.20858690e-02f, 4.45555113e-02f, 1.01740673e-01f, -2.18294024e-01f, 9.15083885e-02f, 4.16902080e-02f, 5.59437536e-02f, 7.00734695e-03f, -1.06778413e-01f, 2.32783984e-02f,
  -2.26471797e-01f, 3.30272829e-03f, -1.71183527e-01f, -3.62141803e-02f, 8.56691599e-02f, 1.21603385e-01f, 1.79520503e-01f, 1.31025920e-02f, 1.10707432e-01f, -5.15778512e-02f,
  -8.43600705e-02f, -4.63425145e-02f, 1.56092405e-01f, -5.79022951e-02f, -4.13098559e-02f, 1.76824585e-01f, 3.33405018e-01f, 1.11088470e-01f, -2.01581165e-01f, 2.59203389e-02f,
  -4.52717021e-02f, -2.58281410e-01f, -2.56760120e-01f, -1.67465322e-02f, 1.08459458e-01f, -1.17481299e-01f, -2.51870245e-01f, -2.00810403e-01f, -3.34104508e-01f, -5.05638063e-01f,
  1.03142738e+00f, 1.27192080e-01f, -7.19521284e-01f, 4.17123705e-01f, -9.15470421e-02f, -6.86397970e-01f, -8.83344173e-01f, -3.07785451e-01f, 3.31798613e-01f, -1.38817281e-01f,
  -7.81517327e-02f, 2.24899650e-01f, 3.46517384e-01f, -1.55997992e-01f, -5.43798625e-01f, -5.96185863e-01f, -5.16704738e-01f, -5.16527534e-01f, -6.02141857e-01f, -5.57771444e-01f,
  -8.86306539e-02f, 1.17735378e-01f, 4.08763513e-02f, -1.30164564e-01f, 2.27944255e-01f, 2.43545547e-01f, -6.94210455e-02f, 3.58158499e-02f, -2.93601513e-01f, 7.85108134e-02f,
  -2.18184367e-01f, -2.39222348e-01f, -1.43510044e-01f, 4.63328250e-02f, 1.74187124e-01f, 1.26350150e-01f, -8.65240693e-02f, 3.01047117e-02f, 2.13182047e-01f, 4.51282971e-02f,
  7.36491233e-02f, 2.84638721e-02f, -4.35709357e-02f, -5.20488918e-02f, -1.60344273e-01f, -9.10293013e-02f, -1.60536483e-01f, -2.28692114e-01f, -3.02742030e-02f, -1.09104561e-02f,
  2.44177766e-02f, -1.57646909e-02f, -1.57833979e-01f, -1.60400763e-01f, -2.82580644e-01f, 1.18935034e-01f, -8.20628554e-02f, -1.40097454e-01f, -1.94346100e-01f, 3.62865254e-02f,
  3.22572216e-02f, 2.25663424e-01f, 5.95234931e-02f, -3.78507772e-03f, 2.98506245e-02f, 1.82265759e-01f, 7.61578754e-02f, -8.92728940e-02f, -4.32827659e-02f, 1.80813745e-01f,
  -1.02916807e-02f, 6.29783347e-02f, -9.50811058e-02f, -2.77210437e-02f, 8.24487880e-02f, 8.40619430e-02f, 1.29846418e-02f, 4.23868559e-02f, -1.20398104e-01f, 9.30928811e-02f,
  2.16615908e-02f, 2.45037638e-02f, 1.43341169e-01f, 2.87378905e-03f, -9.91117060e-02f, -2.19145883e-02f, 7.68503025e-02f, 1.75797015e-01f, 3.23357470e-02f, -1.94248170e-01f,
  4.36531425e-01f, -1.69011489e-01f, 2.91942000e-01f, -1.49704859e-01f, 6.18604869e-02f, 1.78281851e-02f, 1.25176057e-01f, 1.22756727e-01f, 1.42848819e-01f, -1.04967423e-01f,
  -1.17230006e-01f, 1.28009737e-01f, 4.57407907e-02f, -5.97368218e-02f, -6.15261160e-02f, -9.49402750e-02f, 7.89063796e-02f, 5.81685416e-02f, -2.64517553e-02f, 1.13919877e-01f,
  1.24385767e-01f, 2.21573394e-02f, 1.00495420e-01f, 1.36101604e-01f, 5.65348379e-02f, 1.06942885e-01f, 1.26043767e-01f, 9.04947966e-02f, -1.03730679e-01f, 3.14285040e-01f,
  -1.65044516e-01f, -2.65489519e-02f, -7.87530959e-01f, -9.82784107e-02f, 7.64012933e-02f, -9.37576368e-02f, -1.87132210e-01f, -1.64583057e-01f, 1.21508636e-01f, 1.42600790e-01f,
  5.04010558e-01f, 3.80359888e-01f, -9.36319828e-02f, -8.37732106e-02f, -4.06397700e-01f, -3.19084316e-01f, -5.33614933e-01f, -4.87350225e-01f, -1.59412667e-01f, 3.78228188e-01f,
  5.35220981e-01f, 2.31526509e-01f, 2.45336667e-02f, 5.25334105e-02f, 1.93648353e-01f, 2.16755688e-01f, -9.78867635e-02f, -1.41518116e-01f, -4.29578386e-02f, -2.98661470e-01f,
  -2.67953068e-01f, -4.16150004e-01f, 1.02813706e-01f, 1.97038963e-01f, 1.17172144e-01f, 2.69921482e-01f, 2.30511010e-01f, -4.74803243e-03f, 2.10107848e-01f, 1.62584499e-01f,
  1.26097471e-01f, 3.33547384e-01f, 1.63124293e-01f, 1.49409309e-01f, 2.10814774e-01f, 3.91514264e-02f, -3.07511330e-01f, -3.05589586e-01f, -3.17291141e-01f, 1.56743992e-02f,
  2.78637499e-01f, -2.87217703e-02f, -7.33258545e-01f, -2.47261986e-01f, -3.34584624e-01f, -1.21231610e-02f, -8.65240172e-02f, 6.49647266e-02f, -3.10874909e-01f, -1.33510247e-01f,
  1.48106977e-01f, -3.76980864e-02f, -5.71301132e-02f, -9.51050073e-02f, 1.04221418e-01f, -2.05248781e-02f, -1.65964603e-01f, 4.27326337e-02f, 1.97284594e-02f, -1.18627831e-01f,
  -8.53578150e-02f, -1.10031776e-01f, 4.13460564e-03f, -8.93304273e-02f, 3.04884054e-02f, -6.00193031e-02f, -6.72070831e-02f, -7.94422254e-02f, -3.29038680e-01f, 8.77860188e-02f,
  -5.96722364e-02f, -1.19788036e-01f, 1.24076150e-01f, 6.15186170e-02f, 6.74037039e-02f, -6.32374659e-02f, -2.02881396e-02f, 2.67997831e-01f, 1.10317476e-01f, 1.36030167e-01f,
  2.45247155e-01f, -5.83767667e-02f, -4.55101430e-02f, -1.90836698e-01f, -1.04058526e-01f, 2.91835338e-01f, -3.19123175e-03f, 9.02340263e-02f, 1.62171596e-03f, 9.25552920e-02f,
  1.55598205e-02f, 4.69923466e-02f, 1.62062436e-01f, 4.45988178e-02f, 1.72507972e-01f, 6.05839118e-02f, -1.66821837e-01f, -2.70943463e-01f, -2.60106176e-01f, 2.16855153e-01f,
  -5.31278737e-02f, -2.49286428e-01f, -3.97320777e-01f, -3.99765164e-01f, -2.12770775e-01f, -7.44638667e-02f, -1.12558141e-01f, 4.42766249e-02f, -3.30620050e-01f, -4.76922318e-02f,
  -1.24228507e-01f, 4.52964902e-01f, -1.32530630e+00f, 4.08914894e-01f, -2.06446294e-02f, -1.52890533e-01f, 4.35117692e-01f, 4.63417232e-01f, 3.31607103e-01f, 4.28816639e-02f,
  -1.90228537e-01f, -3.04517031e-01f, -3.87775362e-01f, -1.49071053e-01f, -6.73730895e-02f, 1.74256906e-01f, 1.15911467e-02f, -6.40351713e-01f, -4.70250517e-01f, 3.54491562e-01f,
  7.25477517e-01f, 5.29650271e-01f, 9.83482227e-02f, -4.03254200e-03f, 9.87206548e-02f, -4.47564013e-02f, -9.98188332e-02f, -1.05935566e-01f, -8.13713595e-02f, -3.56253743e-01f,
  -9.58323479e-01f, -2.42684916e-01f, -2.64947385e-01f, -3.54209952e-02f, -1.95590213e-01f, -2.17645720e-01f, -7.54793081e-03f, -3.32162738e-01f, -2.22054780e-01f, -3.47839743e-02f,
  -2.12285221e-01f, -2.30023220e-01f, -2.91978657e-01f, -1.07222125e-01f, 3.08749788e-02f, -8.70252997e-02f, 4.46317606e-02f, -1.73872367e-01f, -2.60070533e-01f, -3.66604358e-01f,
  3.71507794e-01f, -3.46257269e-01f, -8.13059628e-01f, -8.22406337e-02f, -2.15650171e-01f, -3.85199070e-01f, -3.56074095e-01f, -2.95929521e-01f, -6.05781674e-01f, -1.96650863e-01f,
  1.51360348e-01f, -1.56874917e-02f, 1.18890889e-01f, 1.41911939e-01f, 2.68142700e-01f, -3.44407298e-02f, 5.77750616e-02f, 7.04115331e-02f, -8.04687385e-03f, 3.96989472e-02f,
  -1.23439535e-01f, -5.11989631e-02f, -1.74584568e-01f, -7.38412142e-02f, -1.03075400e-01f, -1.20557956e-01f, -2.29703993e-01f, 1.71658546e-01f, -5.98088130e-02f, 4.21150103e-02f,
  4.15523238e-02f, -2.00004220e-01f, 1.78488698e-02f, 1.19992541e-02f, -3.80125865e-02f, -2.67745536e-02f, 2.53390670e-02f, 5.24332412e-02f, -3.61414477e-02f, 4.81924042e-02f,
  3.56144160e-01f, -1.19141757e-01f, -2.56905276e-02f, 1.32477313e-01f, -2.21689753e-02f, 2.70213140e-03f, 2.84877401e-02f, -3.14595774e-02f, -9.54805538e-02f, -1.48242638e-01f,
  -1.49654478e-01f, -7.88702965e-02f, -7.86689073e-02f, 1.82122156e-01f, -1.53981283e-01f, -5.45547791e-02f, 3.66355538e-01f, -2.97853686e-02f, 9.88462120e-02f, -2.57945471e-02f,
  4.47110355e-01f, 2.76516408e-01f, -3.35380174e-02f, 6.33896440e-02f, 1.92236125e-01f, -9.88602191e-02f, -2.01556727e-01f, 7.77165685e-03f, -2.24747106e-01f, 6.86239958e-01f,
  -8.83404016e-01f, 3.50140943e-03f, 3.79548013e-01f, -2.47843638e-01f, 1.56631440e-01f, 2.43252397e-01f, 7.56055564e-02f, 1.39656350e-01f, -1.09451309e-01f, -4.51748259e-02f,
  7.57826045e-02f, -2.09206149e-01f, -2.81906962e-01f, -2.17347145e-01f, -5.00113547e-01f, -1.63834423e-01f, -3.86840165e-01f, -4.67804730e-01f, -2.69627839e-01f, 8.48293900e-02f,
  -2.78302014e-01f, -5.83100736e-01f, -5.45606911e-01f, -3.16607237e-01f, -2.99462318e-01f, -5.27171612e-01f, -2.36425564e-01f, -4.06292230e-01f, -1.47690505e-01f, -4.68157858e-01f,
  1.24979794e-01f, 4.38049644e-01f, 9.41967517e-02f, -2.65755266e-01f, -6.89980164e-02f, -4.26461063e-02f, -6.41737506e-02f, 1.08367512e-02f, -3.38061787e-02f, 6.96233884e-02f,
  1.18087254e-01f, 7.56009743e-02f, -1.17098287e-01f, 1.67692900e-01f, 1.82092041e-01f, 2.20848843e-01f, 2.97218710e-01f, 1.52244046e-01f, 1.18146934e-01f, 5.19657731e-01f,
  1.66061208e-01f, -6.58418052e-03f, 9.73798558e-02f, 2.81291902e-01f, 3.57671469e-01f, -1.88965484e-01f, 1.45874813e-01f, 9.59509239e-02f, 1.13540813e-01f, -2.31222034e-01f,
  -9.64364856e-02f, -6.60928190e-02f, 1.98580459e-01f, -1.54521354e-02f, -9.79305729e-02f, 1.04415283e-01f, -5.33295907e-02f, 6.47923211e-03f, -1.21034272e-01f, -1.22706980e-01f,
  1.93586349e-01f, 1.21182412e-01f, -2.99650747e-02f, -1.78556919e-01f, -1.15460001e-01f, -6.85521308e-03f, -9.50512588e-02f, -6.81004897e-02f, -1.01335514e-02f, -1.37271509e-01f,
  -1.05210207e-01f, 4.40366566e-03f, 9.69871879e-02f, -1.12707913e-01f, 6.61744550e-02f, -8.10451135e-02f, 1.65146694e-01f, 6.56576082e-02f, 8.20381865e-02f, 1.38447315e-01f,
  -3.52009326e-01f, 8.38440955e-02f, -2.69794196e-01f, -5.79064861e-02f, -3.28263193e-02f, 8.24595243e-02f, -1.37637649e-02f, -1.47802718e-02f, -4.03307229e-02f, 4.35741507e-02f,
  3.07043344e-01f, -1.22887142e-01f, -1.13324322e-01f, 2.04898655e-01f, -3.12128682e-02f, 1.76651597e-01f, -3.62462252e-02f, -1.30203456e-01f, 7.00966939e-02f, 3.26233387e-01f,
  3.75676304e-02f, -3.17502052e-01f, -3.44581723e-01f, -1.16222240e-01f, -8.00545067e-02f, -3.63405406e-01f, -2.64647692e-01f, -7.48325139e-02f, -3.24805409e-01f, -7.18924403e-01f,
  3.53710949e-01f, -3.90378803e-01f, -5.09530365e-01f, -1.43776059e-01f, -3.82592201e-01f, -3.55445951e-01f, -4.35011208e-01f, -1.69288903e-01f, 6.46280944e-02f, -1.96947336e-01f,
  -3.85103303e-05f, 3.05815905e-01f, 1.70642838e-01f, -2.02522464e-02f, -1.25167802e-01f, -4.67960685e-01f, -3.68513942e-01f, -3.48102182e-01f, -2.11361162e-02f, -1.73536643e-01f,
  -2.39760458e-01f, -2.15175077e-01f, -1.56390145e-01f, -1.37272567e-01f, -2.13756278e-01f, 3.56731042e-02f, -2.45284230e-01f, -1.43442541e-01f, -3.80585104e-01f, -3.78275424e-01f,
  -5.83942309e-02f, 6.37167096e-02f, 9.02579352e-02f, 1.05811439e-01f, 2.50695720e-02f, -3.34370881e-02f, 4.12633978e-02f, 7.00273216e-02f, 1.78704653e-02f, 1.07842416e-01f,
  -1.76087152e-02f, -8.18039551e-02f, 9.36203972e-02f, 7.33481646e-02f, -3.76603231e-02f, 3.25509869e-02f, 1.29893214e-01f, 8.42466727e-02f, -7.72134736e-02f, -1.19153649e-01f,
  -1.25510991e-01f, 7.21588060e-02f, 1.35959715e-01f, 1.33929998e-01f, 1.06533632e-01f, 1.22775219e-01f, 5.95183969e-02f, 1.42021507e-01f, 1.62868962e-01f, 1.58411056e-01f,
  -1.22776262e-01f, 1.58186615e-01f, 7.12528154e-02f, 2.54952073e-01f, 2.49761268e-01f, 2.50553116e-02f, 2.52877921e-02f, 1.80595517e-01f, 1.55215368e-01f, 5.79143837e-02f,
  -1.15287639e-02f, -7.68663436e-02f, 8.64358395e-02f, -9.17584002e-02f, -1.26756668e-01f, -1.56186402e-01f, -5.33555411e-02f, 1.43191144e-02f, 9.07889679e-02f, -6.47148862e-02f,
  -1.67801138e-02f, -9.13915783e-02f, -1.98764160e-01f, -9.76476893e-02f, -1.16395049e-01f, -7.80419931e-02f, -1.13232270e-01f, -7.34835416e-02f, -1.58842698e-01f, -1.61531642e-01f,
  3.36802244e-01f, -1.80301517e-01f, 1.76635513e-03f, 5.38826585e-02f, -1.26142710e-01f, -4.18613385e-03f, 8.77882615e-02f, -1.52488723e-02f, -1.65645286e-01f, 5.07056490e-02f,
  3.02106366e-02f, 7.09210802e-03f, 4.01619300e-02f, 1.27521068e-01f, 1.69235379e-01f, 6.02331720e-02f, 2.21555829e-01f, 6.39693812e-02f, -1.89622328e-01f, -4.29654457e-02f,
  -1.20964631e-01f, 7.84055293e-02f, 3.08454484e-01f, 1.98252916e-01f, 1.68417796e-01f, 5.17472625e-02f, 1.37686163e-01f, 2.11714562e-02f, -7.90860727e-02f, 2.95401454e-01f,
  -3.69399816e-01f, 2.80096322e-01f, -3.44797224e-01f, 1.10722065e-01f, -9.44212452e-02f, -4.20671403e-01f, -3.14423054e-01f, -1.70162469e-01f, 1.45238429e-01f, 6.40975386e-02f,
  8.71176571e-02f, -4.44785692e-02f, -6.73774108e-02f, -3.31619054e-01f, -5.80020368e-01f, -3.83639127e-01f, -5.12246013e-01f, -7.55268276e-01f, -6.85581446e-01f, -3.84159625e-01f,
  -2.74308681e-01f, -3.54689956e-01f, -4.09542203e-01f, -2.76636660e-01f, 1.94472492e-01f, -5.84366322e-02f, -1.51029482e-01f, -2.41393700e-01f, -3.52153182e-01f, -1.52834922e-01f,
  1.77767307e-01f, -1.27686951e-02f, -1.02603450e-01f, -1.18019111e-01f, 7.23572671e-02f, 9.13684815e-02f, -4.96229250e-03f, 1.14449590e-01f, 8.38456675e-02f, 1.74500346e-01f,
  1.42312646e-02f, 4.39213738e-02f, 1.15239792e-01f, 1.46017745e-01f, 8.15998912e-02f, 6.88399002e-02f, 1.52239189e-01f, -2.65698787e-02f, -4.99617271e-02f, 2.29166731e-01f,
  9.47209448e-02f, -1.42487511e-01f, 1.01546891e-01f, -1.49481213e-02f, 3.19522396e-02f, -1.19103111e-01f, 7.89865181e-02f, 6.91081062e-02f, -1.61382243e-01f, 1.94972500e-01f,
  -3.93539555e-02f, 2.47196093e-01f, 3.51826698e-02f, -5.26480563e-02f, -1.16337687e-02f, 1.73811261e-02f, 3.88513543e-02f, 9.19901058e-02f, -1.38165886e-02f, 1.77615806e-01f,
  2.02958241e-01f, 2.67879814e-02f, -2.58205663e-02f, 7.57228583e-02f, 1.17480187e-02f, -4.39887913e-03f, -1.05443992e-01f, 3.50520462e-02f, -4.09659632e-02f, 3.67308035e-03f,
  -5.26947640e-02f, -1.21417446e-02f, 1.78987011e-02f, -2.03994531e-02f, -1.26528814e-01f, 1.28176093e-01f, 4.86386158e-02f, 1.58152245e-02f, 4.05339338e-02f, 1.01004630e-01f,
  2.31020585e-01f, -5.68572521e-01f, 8.91551971e-02f, 1.23269297e-01f, 5.37109263e-02f, 1.36675000e-01f, 6.87778816e-02f, 5.17912768e-03f, -3.15789580e-02f, 4.72737141e-02f,
  -5.92899658e-02f, -4.97151725e-02f, 7.60192499e-02f, 5.40404133e-02f, -2.55283192e-02f, -1.50933355e-01f, 7.92851597e-02f, 8.88907313e-02f, -4.95061837e-02f, 3.01229864e-01f,
  2.20043510e-01f, -1.13984765e-02f, 2.43158787e-02f, 1.49325961e-02f, 8.76695141e-02f, -9.71116945e-02f, 5.29616997e-02f, 1.75336465e-01f, -9.87863094e-02f, 1.79514736e-01f,
  8.40641797e-01f, -4.43723202e-01f, 4.56365973e-01f, 2.27424055e-01f, -1.17837362e-01f, -4.40228641e-01f, -5.54131091e-01f, -2.80003875e-01f, -8.80422890e-02f, -1.39137805e-01f,
  -3.54912132e-02f, 3.69977891e-01f, 2.94680715e-01f, 2.92591840e-01f, 1.52750149e-01f, -1.70357615e-01f, 2.26699367e-01f, 6.10456705e-01f, 4.48203355e-01f, 1.87108606e-01f,
  9.61449966e-02f, 3.64851564e-01f, 5.42576075e-01f, 2.71581292e-01f, 1.44147053e-01f, 2.35882342e-01f, 1.27033412e-01f, 1.92519605e-01f, -5.84884696e-02f, 2.68986434e-01f,
  9.95025188e-02f, -2.29693487e-01f, 1.33215263e-01f, 1.38865948e-01f, 1.45777002e-01f, 8.85731913e-03f, 2.34500058e-02f, -6.76132971e-03f, -1.24213740e-01f, -1.50951460e-01f,
  6.94867522e-02f, 2.33699046e-02f, -1.11439608e-01f, 1.24292234e-02f, -9.20360386e-02f, -1.03707798e-01f, 1.06470212e-01f, 2.01893821e-01f, 1.14508890e-01f, -2.66880691e-02f,
  -9.02983546e-02f, -1.70488767e-02f, -1.04282908e-01f, -1.77965492e-01f, -4.27528890e-03f, 2.71489888e-01f, -7.88687766e-02f, 3.34392786e-02f, -3.12637608e-03f, -1.42336776e-02f,
  -1.58613902e-02f, 1.56003743e-01f, 2.83117712e-01f, 9.91870686e-02f, 1.92899972e-01f, 1.10024810e-01f, 6.87515959e-02f, -6.77629039e-02f, 9.61390436e-02f, 9.52143520e-02f,
  3.91844511e-02f, 2.16460034e-01f, 5.96115328e-02f, -4.75712791e-02f, 1.22178510e-01f, 4.33524400e-02f, -7.47264922e-03f, -1.28177851e-01f, 4.40660566e-02f, 6.55112490e-02f,
  7.79773742e-02f, 2.80830897e-02f, 1.99292526e-01f, 1.28299920e-02f, -4.81482260e-02f, 8.51558745e-02f, 1.33651495e-01f, 1.11282663e-02f, -1.03311703e-01f, 9.76560861e-02f,
  -5.53736269e-01f, 1.70807600e-01f, 1.86120898e-01f, -6.86610267e-02f, -9.76128578e-02f, -3.68609168e-02f, 4.28373516e-02f, 9.21964366e-03f, -9.94824246e-02f, -1.57107741e-01f,
  -1.09206289e-01f, -1.29870221e-01f, -1.24843024e-01f, -4.22017686e-02f, 4.43310887e-02f, -1.28291607e-01f, 6.44461289e-02f, -1.18445732e-01f, -1.03894658e-01f, -9.42839980e-02f,
  -1.16581656e-02f, -3.06161374e-01f, -2.05049977e-01f, -2.98530221e-01f, -7.43558183e-02f, 3.44994850e-02f, -1.35820091e-01f, -1.30315796e-01f, -1.34572029e-01f, -2.47850358e-01f,
  4.49665457e-01f, 2.53289849e-01f, 1.44516811e-01f, 9.28249955e-02f, 1.58442989e-01f, 2.68853068e-01f, 2.80334979e-01f, 1.56397879e-01f, 3.69504169e-02f, 1.46579862e-01f,
  1.95868999e-01f, 1.25009567e-01f, 1.68698832e-01f, 2.13471249e-01f, 2.38201037e-01f, 8.95713866e-02f, 1.19890384e-02f, -5.71774393e-02f, 3.60828750e-02f, 1.02107108e-01f,
  6.16166554e-02f, -1.95699371e-02f, -4.11423966e-02f, -7.21753538e-02f, 2.30166316e-02f, 1.02191731e-01f, -4.35671629e-03f, -2.05103103e-02f, 1.22955486e-01f, -1.52595609e-01f,
  -3.00585851e-02f, 1.20064266e-01f, -3.92740872e-03f, -4.48574014e-02f, 8.51248130e-02f, -1.03908882e-01f, -4.45774347e-02f, -2.20303804e-01f, -1.15055509e-01f, -1.72721475e-01f,
  -9.55482572e-02f, -7.32085630e-02f, 9.84251574e-02f, -7.37124085e-02f, -1.95459113e-01f, -1.39976054e-01f, -9.01345834e-02f, -7.71388113e-02f, 1.49564102e-01f, 4.01735529e-02f,
  6.91247657e-02f, -1.97168440e-02f, -1.19207956e-01f, 8.09201375e-02f, 1.19713999e-01f, 5.99611364e-02f, 1.43984914e-01f, 2.55076941e-02f, 5.43258861e-02f, -9.92210656e-02f,
  9.09551531e-02f, 2.38555044e-01f, 1.99731082e-01f, 2.67328061e-02f, 2.51265287e-01f, 7.00057670e-02f, -1.79939032e-01f, 7.32465461e-02f, 7.82344788e-02f, -4.11820039e-02f,
  -5.59314303e-02f, -6.22455813e-02f, -1.68277621e-02f, 7.70826340e-02f, 1.87134564e-01f, 7.48661458e-02f, -1.45630419e-01f, -1.03704389e-02f, 1.09646350e-01f, -6.16600104e-02f,
  1.08270779e-01f, -1.04458667e-01f, -1.84528321e-01f, -8.83378834e-02f, -2.36970693e-01f, 1.85130886e-03f, -5.00352420e-02f, -8.99750292e-02f, -1.71308070e-01f, -1.02179870e-01f,
  -7.33829081e-01f, 4.54310507e-01f, 1.89371109e-02f, 8.00057948e-02f, -2.80696712e-02f, -7.76965916e-03f, 1.91195548e-01f, -5.84349930e-02f, -8.47162008e-02f, -2.23060712e-01f,
  -5.83105162e-03f, -4.81655356e-04f, 3.15890014e-02f, -1.45313861e-02f, -1.24479398e-01f, -1.52566776e-01f, -9.16015450e-03f, 9.64753553e-02f, 5.70664741e-03f, -6.64239004e-02f,
  -4.48561087e-02f, -1.03261769e-01f, -2.43194640e-01f, 7.95573741e-02f, 1.50964811e-01f, -1.17211483e-01f, -9.99036729e-02f, -6.35962412e-02f, -2.75163446e-02f, -1.18669376e-01f,
  2.80921727e-01f, 4.72590446e-01f, 2.92048067e-01f, -3.09301257e-01f, -1.02133429e+00f, -5.38484335e-01f, -2.24225357e-01f, -1.54462680e-02f, -2.85156846e-01f, 1.00677903e-03f,
  -3.59621167e-01f, -2.73034394e-01f, 8.92353803e-02f, 2.02130631e-01f, 5.06015301e-01f, 3.46800655e-01f, 1.47973269e-01f, 4.29101944e-01f, 4.07808386e-02f, -4.46294665e-01f,
  -3.90033036e-01f, 4.98751439e-02f, 2.61115998e-01f, 2.16392666e-01f, -7.08582476e-02f, -1.56143054e-01f, 5.50587699e-02f, -2.26410285e-01f, -1.01504542e-01f, 2.93408036e-01f,
  2.26135045e-01f, -7.06591830e-02f, -1.74112692e-02f, -8.35881010e-03f, 3.24953459e-02f, 1.71849281e-01f, 7.09845796e-02f, 1.37788326e-01f, -6.00260384e-02f, -2.24696286e-02f,
  -1.01823144e-01f, -1.06582507e-01f, -2.39851311e-01f, -1.82999671e-02f, -2.12958321e-01f, -9.36334487e-03f, 4.35503479e-03f, 9.03393328e-02f, 1.17932320e-01f, 7.39952968e-03f,
  -1.69909582e-01f, -3.14152479e-01f, -1.00922853e-01f, -3.81369609e-03f, 9.30339992e-02f, -8.95894766e-02f, 1.40387444e-02f, -1.04763702e-01f, 1.15460530e-01f, 2.56868511e-01f,
  9.12047103e-02f, 7.48357251e-02f, -5.53613231e-02f, -4.46402729e-02f, -2.69292388e-02f, -7.11000711e-02f, -1.02641843e-01f, -2.61764023e-02f, -4.19010594e-02f, 4.13732789e-02f,
  2.12641302e-02f, 1.79186575e-02f, 2.61580087e-02f, 5.36696613e-02f, -1.10583184e-02f, 3.52141969e-02f, -4.10085209e-02f, -4.16147299e-02f, -6.54438809e-02f, -1.35161072e-01f,
  -2.41681352e-01f, -2.23735813e-02f, -6.71892166e-02f, 1.11211687e-02f, -3.27268541e-02f, 1.29204663e-03f, -5.26955910e-02f, -2.31704898e-02f, 1.28688654e-02f, -1.54223859e-01f,
  1.37591064e-01f, -2.66564041e-01f, 1.51408538e-01f, 2.34897301e-01f, 1.43865170e-02f, 3.07425223e-02f, 8.29051062e-03f, -2.74495706e-02f, -1.08464025e-01f, -4.04987158e-03f,
  -4.47539203e-02f, 1.24994487e-01f, 6.90040365e-02f, 5.89452460e-02f, -1.64709568e-01f, -1.38920546e-01f, -5.91921546e-02f, -1.06510691e-01f, -5.09629510e-02f, 1.17211090e-02f,
  3.21821496e-02f, -1.37254387e-01f, 5.93100628e-03f, -4.51239459e-02f, -5.03401347e-02f, -1.88290060e-01f, 1.14245027e-01f, -9.60265845e-02f, 9.41154659e-02f, 1.47454992e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 26)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 26;
const float L0_fan_Bp_bar_data[] = {
  5.32164812e-01f, 4.68270123e-01f, 3.53667140e-01f, 6.05329752e-01f, 6.92965031e-01f, 3.92036408e-01f, 1.58966377e-01f, 5.75402796e-01f, 6.60202265e-01f, 6.95707798e-01f,
  2.49798179e-01f, 5.14255345e-01f, 3.92875373e-01f, 7.51288176e-01f, 8.65331471e-01f, 5.05170286e-01f, 4.07339424e-01f, 6.48495018e-01f, 5.61051548e-01f, 4.58486259e-01f,
  1.06933028e-01f, -8.13414976e-02f, 4.92671013e-01f, 9.06392097e-01f, 4.69014257e-01f, 7.52553940e-01f
};

// L1_linear_W (Shape: 12 x 128)
const int L1_linear_W_rows = 12;
const int L1_linear_W_cols = 128;
const float L1_linear_W_data[] = {
  -2.24389136e-01f, -1.70368388e-01f, -2.14138493e-01f, -3.86001438e-01f, -5.52488491e-05f, 1.66873336e-01f, -3.77854370e-02f, -2.93124676e-01f, -1.64330631e-01f, -1.37393564e-01f,
  -1.62180647e-01f, -2.41834745e-01f, 7.34458640e-02f, -1.86344124e-02f, 1.57177802e-02f, 6.02953099e-02f, 1.26161158e-01f, -1.00988299e-01f, -2.99442679e-01f, -1.65106639e-01f,
  -3.24017857e-03f, -2.54792664e-02f, -1.37284771e-01f, 9.30354744e-02f, -5.69645222e-03f, -1.25998650e-02f, -5.34585118e-02f, -3.44340563e-01f, -8.39298889e-02f, -6.88296091e-03f,
  9.32118222e-02f, 8.55352581e-02f, -1.44994617e-01f, -1.16618156e-01f, 1.54011786e-01f, -7.01162368e-02f, -2.44424701e-01f, -6.31432310e-02f, -5.12253940e-02f, -4.37474856e-03f,
  -1.61833286e-01f, -2.41932063e-03f, -1.28497869e-01f, 1.14471078e-01f, -1.44294158e-01f, -4.98575121e-02f, 1.68278012e-02f, -1.68964460e-01f, -1.18809789e-01f, -2.89586931e-01f,
  -1.64223745e-01f, -2.02915937e-01f, 1.32719772e-02f, 1.65441394e-01f, -1.18840769e-01f, -3.00252922e-02f, -1.71109691e-01f, -2.28152484e-01f, -6.17404841e-02f, 1.72148138e-01f,
  -5.30484729e-02f, 2.05663517e-01f, 2.84630209e-01f, -1.42184407e-01f, -5.50660528e-02f, -1.20393880e-01f, 2.31974915e-01f, 9.74468589e-02f, -1.66924596e-02f, -2.33829692e-01f,
  -1.23909622e-01f, -8.48901458e-03f, 1.78423986e-01f, 2.03188077e-01f, -1.91600695e-01f, -6.90666959e-02f, 3.90782207e-02f, 1.03839763e-01f, 1.70109808e-01f, -6.75748438e-02f,
  1.55803204e-01f, -8.48493204e-02f, 8.04696381e-02f, -3.09112996e-01f, 1.06598735e-01f, 1.70511693e-01f, -1.41173884e-01f, -1.45838246e-01f, -1.94276765e-01f, 6.77129179e-02f,
  -1.95763558e-01f, 2.40680069e-01f, 2.34747574e-01f, 2.20904723e-02f, 3.09182912e-01f, -2.42723152e-01f, -1.05524361e-01f, -1.79867193e-01f, -1.78285897e-01f, 1.83733761e-01f,
  -1.93847165e-01f, -5.10209613e-02f, 1.55565754e-01f, 2.96649754e-01f, -5.35414040e-01f, -4.35569882e-01f, -8.97610664e-01f, -3.21350634e-01f, 1.46505507e-02f, -1.23496793e-01f,
  -7.58851230e-01f, -3.48726630e-01f, -5.16868234e-01f, 1.79094583e-01f, 9.95279729e-01f, -3.94012332e-01f, -8.83397818e-01f, 1.96414679e-01f, -9.17709768e-01f, -3.11513275e-01f,
  3.11414897e-01f, 4.96060431e-01f, 2.02215031e-01f, 3.08385521e-01f, -1.27327383e-01f, -2.40967646e-01f, -5.04602790e-01f, -5.25441945e-01f, -2.57291868e-02f, -2.18006954e-01f,
  -6.11070022e-02f, -1.41731903e-01f, -4.65195365e-02f, -2.32234284e-01f, -8.41115341e-02f, 1.12796269e-01f, -3.11144106e-02f, 3.09900772e-02f, -5.06362855e-01f, 2.66423430e-02f,
  1.04548447e-01f, 2.77204998e-02f, 3.15273702e-02f, 6.65429458e-02f, -6.45127222e-02f, 3.51839252e-02f, -1.11495368e-01f, -1.58505328e-02f, 1.20589562e-01f, 7.25030228e-02f,
  6.91861007e-03f, -2.19978675e-01f, 5.48152104e-02f, 2.05959287e-02f, -5.63115403e-02f, -7.90667683e-02f, 2.69059557e-02f, -4.15132083e-02f, -1.03012882e-01f, 5.31229898e-02f,
  5.93289733e-02f, -2.03335777e-01f, 1.61945578e-02f, -3.79840806e-02f, 6.11494519e-02f, -1.49299920e-01f, -1.21600017e-01f, -3.15805376e-02f, -2.46809646e-01f, 1.04193605e-01f,
  8.88962001e-02f, -1.15099408e-01f, -1.36440203e-01f, 7.76721090e-02f, -3.91566865e-02f, 1.66130558e-01f, -4.43667546e-02f, 1.64876014e-01f, -6.46240860e-02f, 2.48863176e-02f,
  -2.78084017e-02f, 4.62566949e-02f, -2.21348573e-02f, 7.93469995e-02f, 1.24704920e-01f, 5.58417365e-02f, 1.29156187e-02f, 8.59068409e-02f, -1.63806509e-02f, 4.66662049e-02f,
  2.59041309e-01f, 3.61120440e-02f, 3.24392617e-02f, 2.29494441e-02f, 6.89765587e-02f, 1.25051603e-01f, -1.71760723e-01f, -1.42227799e-01f, -2.68683344e-01f, 9.28351879e-02f,
  2.77905941e-01f, 8.67184624e-02f, -1.11077636e-01f, 7.67074302e-02f, -9.89489108e-02f, 2.05773771e-01f, -2.27651864e-01f, 8.06693584e-02f, 2.11679652e-01f, 5.56893386e-02f,
  -1.65556878e-01f, -4.83382195e-02f, 3.32351476e-01f, 6.37143031e-02f, 2.79025048e-01f, -8.13696086e-02f, 1.33379539e-02f, -1.67475268e-01f, -1.33167684e-01f, 2.18156442e-01f,
  -1.98092043e-01f, -2.11438000e-01f, 2.56822169e-01f, -3.05478454e-01f, 2.79189497e-02f, -1.74695849e-01f, -1.36558011e-01f, -4.46753055e-02f, -2.52829213e-02f, 2.92534363e-02f,
  -1.06104374e+00f, -5.91053307e-01f, -1.10073350e-01f, 2.83663034e-01f, -6.17355108e-01f, 1.95020482e-01f, 1.79756153e-02f, 3.79962474e-01f, -1.19241846e+00f, -1.89489108e-02f,
  8.34991857e-02f, -1.12446755e-01f, 5.79415739e-01f, -6.50274098e-01f, -5.70643902e-01f, 1.26142192e+00f, -4.10491496e-01f, 3.21542501e-01f, -4.25609261e-01f, -1.07287681e+00f,
  -6.43835068e-01f, 3.48035157e-01f, -4.35986817e-01f, 1.33348629e-01f, 4.10692364e-01f, 7.45958015e-02f, 2.28392839e-01f, 1.97075456e-01f, 1.84661761e-01f, 6.99923262e-02f,
  2.69712120e-01f, 2.79467583e-01f, 5.22386050e-03f, 1.77284628e-01f, 1.74011707e-01f, -1.92638617e-02f, 1.69282809e-01f, 2.41288301e-02f, 7.21559078e-02f, 9.08082947e-02f,
  2.95166168e-02f, -3.33587937e-02f, 7.17296004e-02f, 1.31246019e-02f, 1.25244437e-02f, 4.28438745e-02f, 1.25393525e-01f, 3.34484279e-01f, 8.80197883e-02f, 1.74617261e-01f,
  -8.92059281e-02f, 1.89413100e-01f, 2.48426214e-01f, 3.09728342e-03f, -7.48556405e-02f, -1.40831657e-02f, -2.26549655e-02f, 4.49767150e-02f, -1.47764519e-01f, -1.49977550e-01f,
  -8.23344290e-02f, 2.68043995e-01f, 2.67733842e-01f, 2.00001404e-01f, 1.22096941e-01f, -2.83349436e-02f, -3.10819093e-02f, 1.31845534e-01f, -9.29291472e-02f, -2.87568104e-02f,
  9.89351049e-02f, -2.09204167e-01f, -3.28740105e-02f, 5.16644791e-02f, 1.74307153e-01f, -2.20127448e-01f, 7.89438263e-02f, -1.79650411e-01f, 3.20025295e-01f, -4.69469391e-02f,
  -3.44671249e-01f, -2.27588207e-01f, -9.65272859e-02f, -1.54181257e-01f, -5.89762889e-02f, 2.73130089e-01f, 3.40126127e-01f, -1.00856677e-01f, -3.06685895e-01f, -1.04662113e-01f,
  4.30486649e-02f, 1.70879468e-01f, -1.01283357e-01f, 2.30230942e-01f, -1.50871634e-01f, -3.59034598e-01f, -4.91403081e-02f, 1.42481014e-01f, 1.91429839e-01f, 5.89337945e-01f,
  1.02531634e-01f, -1.32389411e-01f, -2.08681241e-01f, 3.20117980e-01f, -7.47038126e-02f, 5.85616678e-02f, 1.27352878e-01f, -4.82275859e-02f, 1.33640155e-01f, -5.15774369e-01f,
  3.85920078e-01f, 1.79845110e-01f, -2.70035654e-01f, -8.91191289e-02f, 1.39003962e-01f, 7.04900175e-02f, -3.23218778e-02f, 2.11217105e-01f, -1.06989130e-01f, -3.63872200e-01f,
  1.45901978e-01f, -9.75193977e-02f, -4.75699931e-01f, 1.12350382e-01f, -3.67586136e-01f, 5.64002693e-02f, -3.49897593e-01f, 2.85718799e-01f, -1.40615121e-01f, -7.25504458e-01f,
  -5.82045794e-01f, -1.53301105e-01f, -3.08670700e-01f, -5.75174630e-01f, 1.60256848e-01f, -2.97424532e-02f, 6.10122144e-01f, -2.30455875e-01f, -3.89127433e-01f, -3.37919965e-02f,
  8.55981052e-01f, -1.94605924e-02f, -1.02221677e-02f, -6.88580200e-02f, -6.41522527e-01f, -4.88459349e-01f, -4.61900085e-01f, -7.13920295e-01f, -2.07356006e-01f, -1.11422718e-01f,
  -6.32459581e-01f, 5.93526304e-01f, -3.08395565e-01f, 1.00559086e-01f, -1.46327168e-01f, -1.21902511e-01f, -2.21801773e-01f, 2.45729893e-01f, 1.41858429e-01f, -3.82150002e-02f,
  1.72923449e-02f, 2.95648277e-02f, 1.10899564e-02f, -1.03395870e-02f, 2.81643234e-02f, 1.44863427e-01f, -9.26160663e-02f, 2.50341356e-01f, 2.03847736e-02f, -3.57218347e-02f,
  -6.63925428e-03f, -8.65795314e-02f, -6.50662854e-02f, -3.93099666e-01f, -2.65763402e-01f, -2.08654493e-01f, -1.63020179e-01f, -1.38761941e-02f, -1.58840403e-01f, -3.69333522e-03f,
  -1.23142436e-01f, -1.07769035e-01f, -2.09421396e-01f, -2.88266912e-02f, 9.29803401e-02f, 1.11082189e-01f, -1.96821392e-01f, -2.19331607e-01f, -1.48088843e-01f, -8.84827301e-02f,
  -7.72748291e-02f, -7.87082314e-02f, -8.01877677e-02f, -1.76024567e-02f, 4.79961038e-02f, -9.96526927e-02f, -1.88101321e-01f, 1.92801915e-02f, 3.20860259e-02f, 4.61784974e-02f,
  -1.35735601e-01f, -3.63199860e-02f, 9.66047049e-02f, -3.00974160e-01f, 4.02505882e-02f, -8.64447355e-02f, 1.53087839e-01f, 3.26834381e-01f, 1.51308775e-01f, 5.30157518e-03f,
  -2.46583700e-01f, 4.68526818e-02f, -4.95024994e-02f, 3.43781322e-01f, -2.30171219e-01f, 1.79098681e-01f, -2.53958367e-02f, 1.79763049e-01f, -1.60806641e-01f, -9.51260179e-02f,
  -3.61401767e-01f, 1.49391755e-01f, -8.17660019e-02f, 5.02853170e-02f, -3.88713747e-01f, -1.20868839e-01f, -4.61597085e-01f, 2.04863042e-01f, 1.99603766e-01f, -7.25142732e-02f,
  -1.58501714e-01f, 2.31392428e-01f, 2.86962926e-01f, 4.07933667e-02f, -3.59483249e-02f, -4.96813238e-01f, 1.07471161e-01f, -3.64887826e-02f, -2.23844230e-01f, -2.57745445e-01f,
  9.26664397e-02f, 7.72251934e-03f, -2.25912258e-01f, 4.53786701e-01f, 6.60580397e-01f, -3.76822352e-01f, -3.79618019e-01f, 5.92251308e-02f, -1.94064379e-01f, 5.67936897e-01f,
  3.41838822e-02f, 1.21031083e-01f, -2.11958408e-01f, -3.58114421e-01f, -1.34510219e-01f, 3.06664199e-01f, 3.89679372e-01f, 5.63680708e-01f, -1.99607164e-01f, 2.61317026e-02f,
  8.18724334e-01f, -4.83149946e-01f, -5.98312497e-01f, 5.02808332e-01f, 1.20829254e-01f, -9.48532045e-01f, -2.42318228e-01f, -4.97863293e-01f, -4.25266236e-01f, -1.35088956e+00f,
  6.97831452e-01f, -1.58329308e-01f, 3.52229059e-01f, -1.27246177e+00f, -3.37860244e-03f, -3.46192211e-01f, 4.06974435e-01f, -5.11817336e-01f, -2.04832181e-01f, -5.11437237e-01f,
  6.26223460e-02f, -1.56243980e-01f, -1.27865463e-01f, 1.58497468e-01f, 2.57603496e-01f, -5.52451871e-02f, -8.19238946e-02f, -1.64575964e-01f, -5.39295673e-02f, -5.83905019e-02f,
  -1.93801019e-02f, 5.12611605e-02f, 1.38946280e-01f, -4.98795286e-02f, -7.64765218e-02f, -1.85271770e-01f, 1.17490485e-01f, -1.08360695e-02f, -1.01237886e-01f, -2.84791440e-01f,
  1.29552007e-01f, 1.67221189e-01f, -3.04636389e-01f, -6.30896818e-03f, 6.69592023e-02f, -2.01833230e-02f, -1.72743037e-01f, 8.18039328e-02f, -4.55027670e-02f, 2.90632583e-02f,
  -7.04177395e-02f, 9.10327490e-03f, -8.62853527e-02f, -3.21673639e-02f, 9.94118676e-02f, -4.40682430e-04f, 1.55908152e-01f, 1.41522005e-01f, -2.14336872e-01f, -1.13174170e-01f,
  -3.48813646e-02f, 4.04379144e-03f, 5.14638275e-02f, 1.11503318e-01f, -1.41914040e-01f, -8.44429061e-02f, 6.18389994e-02f, 3.73433866e-02f, 8.08433816e-03f, 8.02093819e-02f,
  -1.28506482e-01f, 2.56419778e-02f, -2.15288475e-01f, -1.18799686e-01f, -2.50734568e-01f, 6.06177263e-02f, -2.63897985e-01f, -1.74102280e-02f, 3.94847943e-03f, 1.12744227e-01f,
  -7.96974897e-02f, -1.13569982e-01f, -3.40757817e-02f, 1.90965027e-01f, -1.75302327e-01f, 5.82291372e-02f, -1.07509688e-01f, -8.02192315e-02f, 8.84916633e-02f, -1.48444548e-01f,
  -1.75590739e-02f, 1.78915009e-01f, 7.95932040e-02f, 1.26468673e-01f, -3.01746547e-01f, -1.44233420e-01f, 1.00127243e-01f, -7.86781684e-02f, -1.49079293e-01f, 1.25359610e-01f,
  1.76058516e-01f, -9.93616283e-02f, -8.30613300e-02f, 2.44390532e-01f, 1.48993218e-02f, 4.87786204e-01f, -9.63171273e-02f, -1.57410745e-02f, -8.16288963e-02f, -8.94988105e-02f,
  1.58641741e-01f, 1.38537258e-01f, -8.26945454e-02f, -1.48665220e-01f, 1.15927190e-01f, -2.56695449e-01f, -1.33839726e-01f, 1.78149641e-01f, 7.00158998e-02f, 6.92587644e-02f,
  -9.37361866e-02f, 2.43147418e-01f, -7.42728114e-02f, 1.25168160e-01f, 1.58944428e-01f, -4.32877064e-01f, 6.86584115e-02f, -2.34897584e-02f, -8.08407724e-01f, -1.40913606e-01f,
  -4.83205207e-02f, 1.76984996e-01f, 8.14603329e-01f, -1.32266596e-01f, 1.28554329e-01f, 9.22780707e-02f, -9.13668692e-01f, 4.65725690e-01f, -7.16195703e-01f, -1.52154744e-01f,
  4.18333590e-01f, 1.74636245e-01f, -1.71611980e-01f, -3.08133304e-01f, 2.97132671e-01f, -7.88971260e-02f, 4.92974043e-01f, -9.44040418e-01f, -1.48474142e-01f, -6.63562259e-03f,
  6.10821992e-02f, -1.96539313e-01f, 1.85890287e-01f, 9.94218439e-02f, 1.31733358e-01f, -9.73442420e-02f, 6.67935833e-02f, 8.92910138e-02f, 8.85146484e-02f, -4.50196564e-02f,
  -2.01493546e-01f, 8.02658573e-02f, -1.22632841e-02f, -1.87421888e-02f, 1.62418392e-02f, 9.15947407e-02f, -7.62444362e-02f, 7.40160942e-02f, 6.84749037e-02f, -8.32430050e-02f,
  1.10427730e-01f, 6.63420931e-03f, 5.95358834e-02f, 1.19327351e-01f, 1.53262421e-01f, 3.12492624e-02f, 1.92637086e-01f, 1.10575020e-01f, 8.35343748e-02f, 7.30810314e-02f,
  9.27463546e-02f, 2.99873445e-02f, -1.47541910e-01f, 1.71439707e-01f, -6.87867180e-02f, 8.81204978e-02f, 4.10180800e-02f, 2.37870857e-01f, 8.62108245e-02f, 3.66328768e-02f,
  2.05801368e-01f, 4.09339406e-02f, 1.89055026e-01f, 3.29897404e-01f, 1.30116582e-01f, 7.94899613e-02f, 4.95118164e-02f, -3.02911624e-02f, 9.23321471e-02f, 1.01357803e-01f,
  1.03616863e-01f, 1.65998176e-01f, -2.89175689e-01f, -2.04368562e-01f, -1.41444393e-02f, 1.92964718e-01f, -4.47610542e-02f, 1.35657713e-01f, 1.95157275e-01f, -3.21000695e-01f,
  -2.37559453e-01f, 1.72346070e-01f, 2.05784291e-01f, -1.32726520e-01f, -3.43168348e-01f, 9.82887596e-02f, 9.73548815e-02f, 2.27231026e-01f, 1.27065852e-02f, -4.39970791e-02f,
  5.33899009e-01f, 1.32233799e-01f, -5.27205095e-02f, -5.33287764e-01f, -1.53390318e-01f, 3.88628282e-02f, 1.44308299e-01f, -2.46291637e-01f, 3.17715228e-01f, -9.10601616e-02f,
  1.32205084e-01f, 5.81967384e-02f, 1.26866132e-01f, 3.82759392e-01f, 1.50607005e-01f, 3.06510329e-01f, 4.85094517e-01f, -2.09772378e-01f, -1.54390261e-01f, -2.92822957e-01f,
  4.23564278e-02f, 1.52866438e-01f, 3.75318408e-01f, 2.15343274e-02f, -3.38673234e-01f, -1.51075915e-01f, -3.17709148e-02f, 8.89546499e-02f, 4.33677375e-01f, -5.61958477e-02f,
  4.02710199e-01f, -1.63926810e-01f, -9.94374275e-01f, 2.70778034e-02f, 5.58426455e-02f, -3.84166092e-01f, -2.94702768e-01f, -2.31794149e-01f, -2.44322475e-02f, 1.64894238e-01f,
  -6.19610131e-01f, 1.45133525e-01f, -6.87813088e-02f, 6.72452524e-02f, -6.15369916e-01f, -6.68702602e-01f, -1.42668292e-01f, -2.91098595e-01f, -8.39324176e-01f, 6.31837428e-01f,
  5.49053073e-01f, 1.34213686e+00f, -7.09605336e-01f, -6.18412085e-02f, 2.31171012e-01f, -3.96282524e-01f, -2.55440831e-01f, 2.09878478e-02f, -3.16385031e-02f, -1.86895594e-01f,
  1.82951614e-02f, 1.02937676e-01f, -4.30454612e-02f, -1.85209423e-01f, 4.40832265e-02f, -7.77726099e-02f, -3.18282023e-02f, -7.73287714e-02f, -6.89624250e-02f, 1.66395918e-01f,
  -6.92892522e-02f, 2.59852093e-02f, -1.02915883e-01f, 2.66969323e-01f, -7.59206787e-02f, 1.76473394e-01f, 8.19110125e-02f, -3.34013283e-01f, 7.45345280e-03f, -2.98392981e-01f,
  -7.85061866e-02f, 7.71146594e-03f, 1.16419442e-01f, 1.69551775e-01f, 5.01964726e-02f, 4.68408875e-02f, 1.83047444e-01f, 3.83582450e-02f, -5.07721528e-02f, -2.34787017e-01f,
  6.19366765e-02f, 5.28267445e-03f, -7.29756951e-02f, -4.04544950e-01f, -1.22756340e-01f, -2.41548404e-01f, 1.33750513e-01f, 1.30425736e-01f, 1.25702560e-01f, -3.02749991e-01f,
  -1.87483653e-02f, -4.97521646e-03f, 2.98593342e-01f, 1.29689559e-01f, -9.14599597e-02f, -1.68829978e-01f, -3.97006012e-02f, 5.22674248e-02f, 3.02188359e-02f, 1.81084454e-01f,
  2.47576237e-01f, -1.53520867e-01f, -1.92258924e-01f, -2.51354873e-01f, 2.34355077e-01f, 2.05416426e-01f, 2.79800911e-02f, -2.57361531e-01f, 3.85372967e-01f, -2.07998157e-01f,
  -1.37786910e-01f, 2.86957864e-02f, -3.75653207e-01f, 1.02090620e-01f, -3.45555514e-01f, -1.77772850e-01f, 8.14350396e-02f, -1.61734775e-01f, 3.10517609e-01f, -2.58277118e-01f,
  -3.64427298e-01f, -3.10637355e-01f, 2.95859814e-01f, 1.37828365e-01f, 2.84103826e-02f, -3.50133479e-01f, -2.61497498e-01f, 2.15053216e-01f, -1.07328482e-02f, 2.66195595e-01f,
  2.57127315e-01f, -1.09766973e-02f, 8.95216763e-02f, 9.97396186e-02f, -1.55544072e-01f, 2.52871782e-01f, 2.42107108e-01f, -1.22724727e-01f, -6.04100972e-02f, -4.78390418e-02f,
  3.04260612e-01f, 2.01203331e-01f, -2.02437773e-01f, 4.55746591e-01f, 3.48451175e-02f, -4.58870567e-02f, -1.06712632e-01f, 2.94318676e-01f, 1.81356341e-01f, -5.01853526e-01f,
  -9.72018361e-01f, -1.62667811e-01f, -6.04328036e-01f, -3.39620203e-01f, 4.13298041e-01f, 5.28516918e-02f, 1.93325639e-01f, -5.24440110e-01f, 1.35492951e-01f, -2.49673426e-01f,
  -2.80309886e-01f, -1.75717860e-01f, -8.08369696e-01f, 5.06651521e-01f, -6.92050457e-01f, -5.89964390e-01f, -7.44589150e-01f, -6.93995178e-01f, -5.77029765e-01f, -5.39905608e-01f,
  -3.48034769e-01f, -5.03536999e-01f, -5.40383279e-01f, 5.29285371e-01f, -1.35491602e-02f, 8.88849616e-01f, -1.24662034e-01f, 1.11519713e-02f, 5.16896229e-03f, -8.18750709e-02f,
  -1.27482653e-01f, -1.82673514e-01f, -2.50004321e-01f, -2.10538998e-01f, -7.39212409e-02f, 2.39555221e-02f, -2.53879935e-01f, -3.17919105e-02f, 5.11441641e-02f, -5.64330928e-02f,
  -1.33521512e-01f, -8.31352025e-02f, 5.53885289e-02f, -1.33645937e-01f, -1.88360631e-01f, -5.42801358e-02f, 2.43537035e-02f, -3.58337723e-02f, -8.05061013e-02f, -1.08801417e-01f,
  7.57952183e-02f, -1.25402734e-01f, -1.24468967e-01f, -1.90889742e-02f, -1.58293411e-01f, -2.49899998e-02f, -1.52117312e-01f, -1.23417065e-01f, -2.22589657e-01f, -9.98163782e-03f,
  8.77740830e-02f, -1.37541056e-01f, 3.66662666e-02f, -2.83790976e-02f, 4.38517071e-02f, -1.22693144e-01f, -3.37928683e-01f, -8.87863412e-02f, -5.67946769e-02f, -2.24695623e-01f,
  -2.68043652e-02f, -2.75459290e-02f, 1.50557356e-02f, -5.75836450e-02f, -1.06141917e-01f, -1.86441001e-02f, 8.58128816e-03f, -2.28888448e-02f, 1.26171947e-01f, -4.61721718e-02f,
  7.85840973e-02f, -1.88956156e-01f, 2.20015407e-01f, -3.98039371e-02f, 1.46103114e-01f, 5.03921956e-02f, -2.93746889e-02f, -1.78259924e-01f, -3.63617152e-01f, -4.21569049e-02f,
  1.35584176e-01f, -1.31428197e-01f, -2.53335744e-01f, -1.54735586e-02f, 2.57606655e-01f, 1.99366603e-02f, 6.66459044e-03f, 6.52042963e-03f, -5.38871773e-02f, 1.80827469e-01f,
  9.02896151e-02f, 1.01364911e-01f, 2.28409320e-02f, -9.70177054e-02f, 3.65930766e-01f, -2.44438455e-01f, 1.19591586e-01f, -1.56685784e-01f, 1.26667887e-01f, 1.84690610e-01f,
  -4.41684909e-02f, 2.82512847e-02f, -2.52525002e-01f, -2.11301476e-01f, 6.25301525e-02f, 1.09057359e-01f, 2.80658811e-01f, -9.46069732e-02f, -1.61169156e-01f, -5.03703132e-02f,
  -1.42754346e-01f, -2.30015233e-01f, -7.62715489e-02f, 2.29603827e-01f, 3.20540965e-01f, -1.40785947e-01f, 5.80914170e-02f, -1.16451196e-01f, 7.12484539e-01f, -4.04511809e-01f,
  4.02455956e-01f, -3.80690366e-01f, 8.61436650e-02f, 9.85951070e-03f, -2.25507971e-02f, -6.49859667e-01f, 5.26070654e-01f, -4.44133222e-01f, 2.85185933e-01f, -2.36640871e-01f,
  -1.27035528e-01f, -7.31765866e-01f, -4.86422814e-02f, -8.59734595e-01f, 4.75486308e-01f, -1.42180264e-01f, -4.75233495e-01f, 7.77039170e-01f, -2.63809264e-01f, -5.18041313e-01f,
  -3.64707172e-01f, -8.38303864e-01f, -5.22417612e-02f, -2.53074020e-01f, 2.23477501e-02f, 1.21161200e-01f, 7.23569766e-02f, 2.00082138e-01f, -3.35462749e-01f, -7.22367838e-02f,
  -6.87049795e-03f, 5.82895465e-02f, 2.62711912e-01f, -2.29935184e-01f, 9.38873440e-02f, 1.56547278e-01f, 5.93099110e-02f, 3.61103229e-02f, 3.23114134e-02f, -9.06097665e-02f,
  1.82030778e-02f, -5.86200431e-02f, 2.11471897e-02f, 1.94146976e-01f, 6.61268532e-02f, 3.78346890e-02f, 2.74853587e-01f, -2.14536458e-01f, -6.47375882e-02f, 6.01267628e-02f,
  1.62716851e-01f, 4.46896732e-01f, -5.32768443e-02f, -8.37351233e-02f, 2.73780257e-01f, -1.06464736e-01f, 3.31494749e-01f, 2.77458191e-01f, 2.29916796e-01f, 2.07474768e-01f,
  -9.96339247e-02f, -1.14628755e-01f, -3.25824320e-02f, 1.97612643e-01f, 1.77498728e-01f, -1.82748996e-02f, -3.96312401e-03f, 1.51603580e-01f, 2.17092887e-01f, 7.11966008e-02f,
  -1.23608727e-02f, -8.45830888e-02f, -1.70949042e-01f, -1.18843094e-01f, -6.77807778e-02f, -1.76738352e-02f, 1.39468843e-02f, -3.66797209e-01f, 2.47588173e-01f, -1.35137349e-01f,
  2.45736111e-02f, -4.75118272e-02f, -1.14123881e-01f, -4.95437719e-02f, 3.58806103e-01f, 1.46982297e-01f, 3.62791866e-01f, -3.13886404e-02f, 3.31086338e-01f, -6.22272007e-02f,
  2.37282619e-01f, -1.60383224e-01f, 2.85616428e-01f, -8.85488018e-02f, -2.05442935e-01f, -4.93859380e-01f, 3.67650509e-01f, 2.19621956e-01f, -2.53912002e-01f, 1.89328939e-01f,
  -1.14793725e-01f, -3.33310366e-01f, -1.27856918e-02f, 1.11710884e-01f, 3.21945816e-01f, 2.59876978e-02f, -1.83211744e-01f, -5.30708671e-01f, -1.93275452e-01f, 1.19075038e-01f,
  -1.43969744e-01f, 4.74356294e-01f, -4.12348866e-01f, -4.84012604e-01f, -3.38361710e-01f, -1.84333399e-01f, -2.45720699e-01f, 3.56163412e-01f, 3.96125972e-01f, 3.80724758e-01f,
  1.16753280e-01f, -9.18784738e-02f, 2.57733107e-01f, -3.51673514e-01f, 3.30029964e-01f, -1.83700636e-01f, 1.19444830e-02f, -8.50869656e-01f, 5.21818437e-02f, 2.99633980e-01f,
  1.79818764e-01f, -3.91432554e-01f, -3.22539777e-01f, -5.24403393e-01f, -3.12722683e-01f, 4.03592855e-01f, 1.98427364e-01f, -7.52790123e-02f, 2.92703509e-01f, -5.85679889e-01f,
  8.02800953e-01f, -1.03647912e+00f, 5.60277514e-03f, -3.65132660e-01f, -4.32284534e-01f, -3.11230093e-01f, -4.82669294e-01f, -4.58476245e-02f, -5.52536130e-01f, -4.10895646e-02f,
  -5.43973386e-01f, -4.38916087e-01f, 4.40164953e-02f, 6.22091703e-02f, -1.69184376e-02f, -7.84173310e-02f, 5.26983440e-02f, 2.45807052e-01f, 8.02620426e-02f, 1.16839837e-02f,
  -1.37921944e-01f, -1.99075073e-01f, 2.95687597e-02f, -1.04315743e-01f, -9.53901857e-02f, 1.44751072e-01f, 2.03383356e-01f, -2.61228085e-01f, -1.58194572e-01f, 9.48801935e-02f,
  3.13369930e-02f, -6.44811755e-03f, -5.81330843e-02f, 2.37841904e-03f, -6.59190789e-02f, -4.22202826e-01f, -7.41469488e-02f, -5.78442439e-02f, 2.26000939e-02f, -1.18175745e-02f,
  5.24503104e-02f, -1.39837161e-01f, -3.02171223e-02f, 6.97912201e-02f, 8.84568691e-02f, 1.08945459e-01f, 5.57516776e-02f, 1.97652712e-01f, 5.72570711e-02f, -3.17475684e-02f,
  -1.86274007e-01f, 4.08775881e-02f, -7.12603107e-02f, -6.86890706e-02f, 1.59097001e-01f, 9.48107317e-02f, -6.91985190e-02f, 2.10290775e-02f, 2.70621981e-02f, -8.62675160e-02f,
  -2.77941972e-01f, 2.08580822e-01f, 1.88463777e-01f, -3.14896256e-01f, 1.80959836e-01f, -1.58962116e-01f, 4.17016774e-01f, 3.28171849e-01f, 2.90760342e-02f, -1.64047629e-01f,
  -6.38860390e-02f, -1.65686250e-01f, -3.78741235e-01f, -1.39585853e-01f, -2.09189460e-01f, -1.59073137e-02f, 4.01471615e-01f, 7.88131431e-02f, 5.40213943e-01f, -2.57445425e-01f,
  -3.21452677e-01f, 5.49714640e-02f, 4.77428108e-01f, -1.03595987e-01f, -2.09809750e-01f, -4.01989132e-01f, 2.09075063e-01f, -1.53313875e-01f, 2.40114927e-01f, -2.89846241e-01f,
  -2.35196486e-01f, 1.75028294e-01f, -1.98081717e-01f, 6.88373968e-02f, -1.16886564e-01f, 4.97739136e-01f, 3.03342212e-02f, -6.94307163e-02f, -2.43298292e-01f, -3.77506077e-01f,
  2.79139787e-01f, 3.58525187e-01f, 6.14760146e-02f, -2.29609028e-01f, 3.41429204e-01f, 3.14951479e-01f, 2.56339759e-02f, -4.09017354e-01f, -1.96484953e-01f, -3.46866578e-01f,
  -1.84633464e-01f, 2.77726382e-01f, -2.54241377e-01f, 3.30767214e-01f, 2.75217235e-01f, -5.03057241e-01f, -2.49169648e-01f, 2.98490793e-01f, -1.41863629e-01f, 1.87006846e-01f,
  2.31902823e-01f, -6.54847145e-01f, -1.46864742e-01f, -1.12033397e-01f, -2.75907308e-01f, -1.20120430e+00f, -6.86149716e-01f, 6.38126373e-01f, -4.83265311e-01f, -1.71070158e-01f,
  8.04087400e-01f, 7.26607621e-01f, 2.67239422e-01f, -4.81425554e-01f, -5.33845127e-01f, -1.63870856e-01f, -5.59623651e-02f, 3.41527075e-01f, -3.11295241e-01f, -1.01884305e+00f,
  1.43916860e-01f, 1.47683740e-01f, -2.30578303e-01f, 1.30452082e-01f, 8.11040103e-02f, 1.48028493e-01f, 1.26240239e-01f, 6.09360971e-02f, -4.41339128e-02f, 5.38700745e-02f,
  1.52287483e-01f, -1.69735730e-01f, -4.77983325e-04f, -1.21314332e-01f, -7.39132166e-02f, -1.95374936e-02f, 4.98249084e-02f, 7.70342946e-02f, 2.39919052e-02f, 1.07901953e-01f,
  -1.04978226e-01f, 1.19698770e-01f, -5.21140397e-02f, 3.17848831e-01f, 5.82804978e-02f, -4.55779117e-03f, -1.67969301e-01f, 1.86475843e-01f, -1.00788213e-02f, 2.59362180e-02f,
  6.20774142e-02f, -7.07123801e-02f, -1.41816156e-03f, 1.68137848e-01f, -3.24191786e-02f, -5.96680462e-01f, 3.89683992e-01f, -3.89734027e-03f, 8.28758031e-02f, 3.76270451e-02f,
  -9.44838598e-02f, -9.27869007e-02f, 1.46942168e-01f, 7.95349712e-04f, 7.68720806e-02f, 1.43710405e-01f, -1.47961736e-01f, 1.79267883e-01f, 9.28130299e-02f, 2.21676543e-01f,
  2.81523578e-02f, 2.13180125e-01f, -2.16123551e-01f, 4.00030285e-01f, 3.93067628e-01f, 1.39360502e-01f, -2.48135906e-02f, -9.43690389e-02f, 1.52254999e-01f, 3.03368449e-01f,
  3.21781993e-01f, 3.79389562e-02f, -8.07672262e-01f, 1.57521889e-01f, 4.90544558e-01f, -1.83928639e-01f, 1.28250703e-01f, -1.08068120e-02f, -1.45902321e-01f, 1.44188851e-01f,
  -2.93103252e-02f, 5.38974047e-01f, 1.94791943e-01f, 3.26837003e-01f, -4.35202904e-02f, 7.70964324e-02f, -2.21384570e-01f, 3.30718905e-01f, -9.39022452e-02f, 3.06848343e-02f,
  -2.49135047e-01f, 5.22462986e-02f, -1.94244698e-01f, 4.89821173e-02f, -2.46721864e-01f, -2.06242740e-01f, 1.58189118e-01f, -2.68001612e-02f, -1.96624592e-01f, 3.49080384e-01f,
  5.47850132e-01f, 3.20276231e-01f, -3.90652537e-01f, -1.76163465e-01f, 3.61345202e-01f, -2.74126112e-01f, 3.23884934e-02f, 2.09365636e-01f, 3.65377873e-01f, -3.07271212e-01f,
  -3.06582428e-03f, 1.33942604e-01f, -6.92962170e-01f, 8.52921247e-01f, 2.71460742e-01f, -5.89689791e-01f, 2.91425809e-02f, -8.90225638e-03f, -4.04744446e-01f, -9.50545728e-01f,
  -3.84401143e-01f, 3.33720356e-01f, -1.17048591e-01f, -9.42925274e-01f, -5.29676497e-01f, -1.89979881e-01f, 2.52066344e-01f, -4.60078806e-01f, -2.49709487e-01f, -1.26285911e-01f,
  -1.32925451e-01f, -5.82086921e-01f, -2.82367855e-01f, 9.60038975e-02f, 2.46094361e-01f, -2.79790789e-01f, -1.99601158e-01f, 6.14534557e-01f, -2.61418354e-02f, 2.05610663e-01f,
  1.00773044e-01f, -9.20431390e-02f, 1.78501770e-01f, 1.17204629e-01f, -8.18772316e-02f, 4.54727281e-03f, -9.30501372e-02f, 2.40135089e-01f, 2.35275984e-01f, -1.65839314e-01f,
  -5.25220111e-02f, 1.62503585e-01f, -1.42598003e-01f, 3.81673612e-02f, 6.39295503e-02f, -1.69985086e-01f, -2.08918571e-01f, 3.91473293e-01f, 1.24793708e-01f, 1.18058864e-02f,
  -1.95059553e-01f, 3.31597030e-01f, -1.62373669e-02f, -9.00311470e-02f, 7.83397108e-02f, -4.46722507e-01f, 1.02566034e-02f, -4.63115275e-02f, 9.73443966e-03f, 3.56989428e-02f,
  1.61724895e-01f, -5.46245743e-03f, -1.30019262e-01f, 7.49339759e-02f, 2.64146347e-02f, 5.88290356e-02f, -3.61399278e-02f, 1.68832898e-01f, 1.04337275e-01f, 1.02468356e-01f,
  1.74543530e-01f, -3.78517732e-02f, -4.19468731e-01f, -1.91572070e-01f, 9.92180109e-02f, -1.60486493e-02f, 1.17483877e-01f, -3.70579772e-02f, -5.28552011e-02f, -1.14473082e-01f,
  1.52742401e-01f, -2.48909995e-01f, 1.74155429e-01f, -5.28745688e-02f, 2.21014708e-01f, 3.02923709e-01f, 1.14495799e-01f, -1.48672923e-01f, -1.31768137e-02f, -1.22870192e-01f,
  8.00258875e-01f, -1.48859859e-01f, -1.19314782e-01f, 3.54757458e-02f, -2.29978487e-01f, -7.58783370e-02f, 1.93566099e-01f, 4.98055547e-01f, -5.13074756e-01f, 2.66297739e-02f,
  -3.48116666e-01f, -1.81079060e-01f, -3.62584114e-01f, 1.45559490e-01f, -3.23228240e-02f, -1.40753150e-01f, -4.48033601e-01f, -1.01746477e-01f, -2.12896124e-01f, -1.31799012e-01f,
  -8.04354921e-02f, -8.64241347e-02f, -3.38425815e-01f, -1.87275574e-01f, -2.04802707e-01f, 3.79981697e-01f, 2.24175066e-01f, -3.37974697e-01f, -1.88388780e-01f, -8.73378962e-02f,
  2.05712691e-01f, -1.53810814e-01f, -2.85126120e-01f, 2.91507125e-01f, 3.42179894e-01f, -5.43975011e-02f, -2.06303760e-01f, 3.32948007e-02f, 2.61666536e-01f, -7.94944018e-02f,
  4.60460097e-01f, 1.53494433e-01f, -2.46407688e-01f, -5.19595556e-02f, 3.92155886e-01f, 4.56010193e-01f, -3.53659153e-01f, -2.55120873e-01f, -6.63987696e-01f, -4.38316539e-03f,
  -7.74389803e-01f, 6.30582750e-01f, -2.63350487e-01f, -3.69651318e-02f, -5.16405284e-01f, -4.31641430e-01f, 6.39873028e-01f, -4.31786835e-01f, -7.78090417e-01f, -5.76649427e-01f,
  3.82732004e-01f, -4.48182881e-01f, -7.42433965e-02f, -4.60982770e-01f, 2.71660179e-01f, -3.64287823e-01f
};

// L1_linear_B (Shape: 1 x 12)
const int L1_linear_B_rows = 1;
const int L1_linear_B_cols = 12;
const float L1_linear_B_data[] = {
  -1.67148411e-01f, 1.10050671e-01f, 2.47725975e-02f, -6.93841800e-02f, -2.05343708e-01f, -4.90024723e-02f, -1.25171687e-03f, -2.87928283e-02f, 1.13487676e-01f, 1.46738872e-01f,
  -5.97090013e-02f, 1.55150935e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 51, 26
    );
    
    // Camada 1: L1_linear
    linear_forward_pgm(
        buffer1, x_out,
        L1_linear_W_data, L1_linear_B_data,
        128, 12
    );
    }
    