/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 16 (x3)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 16;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    float x3 = x * x * x;
    return 0.5f * x * (1.0f + tanhf(0.79788456f * (x + 0.044715f * x3)));
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 6 x 120)
const int L0_fan_Wp_rows = 6;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -1.44961983e-01f, -1.44180357e-01f, 2.10273743e-01f, -2.68124878e-01f, 1.28946647e-01f, 2.23164722e-01f, 3.30067247e-01f, -3.28652710e-02f, -2.56286357e-02f, 4.84642908e-02f,
  2.32304737e-01f, -2.74136156e-01f, 2.02391624e-01f, -7.12316409e-02f, 1.81642368e-01f, 1.42107904e-01f, 3.40347970e-03f, -1.00039557e-01f, -4.50557843e-03f, 1.00015597e-02f,
  6.77852556e-02f, 9.74655524e-02f, 1.29630730e-01f, 1.03265829e-01f, -4.96466234e-02f, -1.15694724e-01f, -9.69430581e-02f, 1.49670392e-01f, -6.82461783e-02f, -3.83458212e-02f,
  1.39966100e-01f, -6.68790862e-02f, -5.62482774e-02f, -1.24629624e-02f, 1.19029112e-01f, 4.52398174e-02f, -1.79606043e-02f, 6.57377718e-03f, 4.75209802e-02f, 9.16202925e-03f,
  -1.60714686e-02f, -2.81639933e-03f, -1.84492506e-02f, 6.77297171e-03f, -6.49079531e-02f, -9.88103170e-03f, -2.42271107e-02f, -2.19636783e-02f, -1.96745638e-02f, -3.38493474e-02f,
  -5.25375642e-03f, -5.49642090e-03f, 3.71890701e-02f, -8.47613662e-02f, 4.59726341e-02f, -8.46829452e-03f, -3.31021063e-02f, -2.26412225e-03f, -4.70278859e-02f, -7.45469257e-02f,
  -3.44872288e-02f, -4.16606218e-02f, 1.15074208e-02f, -1.26285711e-02f, 7.44344592e-02f, -7.71249738e-03f, -1.95726892e-03f, -1.40478453e-02f, -1.50127709e-02f, 1.98585503e-02f,
  3.71327661e-02f, -8.88870135e-02f, -5.74741326e-02f, -1.85420681e-02f, 4.16893419e-03f, -2.86954306e-02f, -1.00164199e-02f, -8.19171313e-03f, 2.71580555e-02f, -1.38379866e-02f,
  -1.20419846e-03f, 8.08457844e-03f, -2.57868972e-02f, 6.74149906e-03f, 1.59034189e-02f, 6.12755865e-03f, -2.58885045e-02f, -2.67716758e-02f, 4.70541529e-02f, 1.08168587e-01f,
  4.58940938e-02f, -2.91146003e-02f, 4.76069823e-02f, -2.09589861e-02f, -5.45265377e-02f, -4.71687131e-02f, 1.92032196e-02f, 4.27208766e-02f, 3.68890679e-03f, 1.96177904e-02f,
  3.64646502e-02f, 5.69535559e-03f, 1.78237185e-02f, 1.37582701e-02f, 5.93046211e-02f, 1.48069523e-02f, 4.49251048e-02f, -8.21581949e-03f, 2.41358895e-02f, -1.26272524e-02f,
  -1.44221634e-02f, 1.13303475e-02f, -2.39474941e-02f, 8.63106176e-03f, -5.47059588e-02f, 3.10410969e-02f, -3.71908732e-02f, 3.43226492e-02f, -1.31136598e-02f, 1.60007477e-02f,
  -6.38311088e-01f, -2.88860556e-02f, -3.49726319e-01f, -1.14163928e-01f, -7.79332919e-03f, -1.12456284e-01f, -1.01740420e-01f, 7.80080035e-02f, -2.65683681e-01f, 2.86014825e-01f,
  1.80065278e-02f, -1.35710776e-01f, -1.20930865e-01f, 1.30707711e-01f, -4.53066647e-01f, -1.28558844e-01f, 4.53870557e-02f, 3.58524881e-02f, -6.57456219e-02f, -2.10922002e-03f,
  -1.15778215e-01f, 1.73214763e-01f, -1.10391945e-01f, 1.83021933e-01f, 4.61999066e-02f, 2.42365990e-03f, 1.43547412e-02f, 1.41253015e-02f, 1.60523504e-01f, 8.57959315e-02f,
  2.53597442e-02f, -4.10983950e-04f, 6.35071099e-03f, -4.80081216e-02f, -1.06751703e-01f, -1.43146524e-02f, -1.83411930e-02f, -2.10204534e-02f, -3.51334736e-02f, 8.60217959e-03f,
  -6.36976808e-02f, -2.61480547e-03f, -1.95290092e-02f, 5.72916772e-03f, 1.76196434e-02f, -4.25516162e-03f, 2.05411948e-02f, -4.43149507e-02f, -2.11994015e-02f, -2.97843609e-02f,
  -4.97343689e-02f, -3.13468985e-02f, -4.63586152e-02f, -3.07787247e-02f, -3.48735191e-02f, 1.94762778e-02f, -4.68602739e-02f, -6.15407014e-03f, -1.47303110e-02f, -1.11255990e-02f,
  6.66087959e-03f, 2.76795984e-03f, 2.22949628e-02f, -2.89652264e-03f, -2.62499470e-02f, 3.73600610e-02f, -3.85805666e-02f, 3.64520550e-02f, -3.84648293e-02f, 1.97421219e-02f,
  -1.55402357e-02f, -5.13869077e-02f, -5.11807539e-02f, -7.48563185e-03f, -7.31643382e-03f, 2.90857926e-02f, -6.81104064e-02f, 2.87629738e-02f, -1.67315770e-02f, -2.34833229e-02f,
  -3.77195925e-02f, 4.18687379e-03f, 9.10391938e-03f, 1.02091841e-02f, 1.38329966e-02f, -5.63062988e-02f, -8.15504324e-03f, -1.31063908e-02f, -1.66902132e-02f, -2.52566319e-02f,
  -3.63324322e-02f, -8.38963017e-02f, -3.33911180e-02f, 5.34170158e-02f, 3.01052686e-02f, 3.50855403e-02f, -1.86619777e-02f, -6.88739400e-03f, 4.20918949e-02f, -1.85445007e-02f,
  5.88406585e-02f, 3.42191868e-02f, -4.01459411e-02f, -8.35134834e-03f, 4.79679601e-03f, -3.57021345e-03f, 5.98054053e-03f, 3.15295756e-02f, 4.24106270e-02f, -1.27169434e-02f,
  3.07434648e-02f, -3.20111727e-03f, 4.05573472e-03f, 4.87494245e-02f, 3.75529788e-02f, 1.15505820e-02f, 9.90689360e-03f, -1.77300721e-02f, -9.70749417e-04f, 2.77364370e-03f,
  2.57270008e-01f, -2.19955042e-01f, -8.63652378e-02f, 1.82401419e-01f, 8.19472820e-02f, 3.48684162e-01f, 7.96968564e-02f, -8.35406929e-02f, 1.00427948e-01f, -8.17409530e-02f,
  1.26173288e-01f, 9.94664803e-02f, -1.02557339e-01f, 3.11948061e-01f, 3.64863575e-01f, 3.94880734e-02f, 3.70534867e-01f, 1.48582265e-01f, 5.94206452e-02f, 3.59090939e-02f,
  1.20550774e-01f, 1.87167153e-01f, 6.51796982e-02f, 1.20181998e-03f, -5.71012385e-02f, -1.92472667e-01f, -1.38911247e-01f, -1.10665150e-01f, -2.09596716e-02f, 7.05498978e-02f,
  2.08468750e-01f, -3.68628837e-02f, -7.47572333e-02f, -5.05736796e-03f, -8.63394421e-03f, -2.57767644e-02f, 2.99806166e-02f, 1.55973816e-02f, 8.86736512e-02f, 7.29772123e-03f,
  -2.57461499e-02f, -8.56371783e-03f, 3.77677269e-02f, -6.46961778e-02f, 3.64844464e-02f, 1.33851487e-02f, 2.02551913e-02f, 1.65219009e-02f, 5.85177168e-03f, -1.97487772e-02f,
  3.09810266e-02f, 2.07968839e-02f, 4.74345759e-02f, 6.45674765e-02f, 2.63389666e-02f, 3.16264592e-02f, -1.18414620e-02f, -1.17575908e-02f, 2.33807396e-02f, -2.54441658e-03f,
  -2.88934968e-02f, -3.19147222e-02f, -1.75693110e-02f, 3.16473879e-02f, -2.23624334e-02f, 1.46805798e-03f, 1.28825912e-02f, -1.52427107e-02f, -5.92564838e-03f, 2.31757611e-02f,
  4.74960357e-02f, 8.14377703e-03f, -3.88498954e-03f, 6.58938335e-03f, -7.10611464e-04f, 2.14026384e-02f, 2.96179317e-02f, -2.33074669e-02f, -1.16117410e-02f, 6.48012459e-02f,
  -1.12563558e-02f, 2.01923642e-02f, 1.28575554e-03f, 2.40433216e-02f, 2.97550391e-02f, -8.62665325e-02f, -2.26822626e-02f, -5.92190661e-02f, -4.12009656e-02f, 1.05284071e-02f,
  -7.37514943e-02f, -1.66691437e-01f, -1.63491815e-02f, 5.42308092e-02f, 2.10127253e-02f, -6.31017378e-03f, 2.67481897e-02f, -2.76028481e-03f, -6.81980103e-02f, -5.91254160e-02f,
  7.05257244e-03f, 2.15366371e-02f, -2.47905608e-02f, 1.90126859e-02f, -9.44586657e-03f, -6.36357302e-03f, 1.36344032e-02f, -3.21114175e-02f, 1.34132747e-02f, 2.37194933e-02f,
  -7.85697773e-02f, 1.98511966e-02f, 2.98712943e-02f, -5.60877249e-02f, -1.23802004e-02f, -2.29814444e-02f, -4.13976522e-04f, -4.02042829e-02f, -2.58150473e-02f, 4.27566133e-02f,
  -5.39281905e-01f, -1.31667301e-01f, 2.10526615e-01f, -1.15514785e-01f, -1.61849916e-01f, -2.11960435e-01f, -1.36573985e-01f, -1.24665096e-01f, -2.02447891e-01f, -1.34141818e-01f,
  -1.34075686e-01f, 1.52764812e-01f, -6.49253204e-02f, -1.35179892e-01f, -1.03042133e-01f, -3.87386382e-02f, -1.83692858e-01f, -3.24608795e-02f, -7.08375350e-02f, -1.20536983e-01f,
  -2.90670153e-02f, -2.70344019e-01f, 1.23170950e-01f, -1.27645552e-01f, 2.47628726e-02f, 5.56255281e-02f, 4.29119729e-02f, 9.05260295e-02f, 8.41919705e-02f, 7.94908497e-03f,
  6.48720711e-02f, -9.61348489e-02f, -2.94461637e-03f, 5.17554209e-02f, -8.64310656e-03f, 3.39257270e-02f, 5.50302565e-02f, 1.28856655e-02f, 1.90447345e-02f, 1.84039176e-02f,
  1.24665610e-02f, 8.53738096e-03f, -3.50558572e-02f, 3.06045562e-02f, 1.11610694e-02f, 4.89436381e-04f, -9.54469945e-03f, 2.62773130e-02f, -2.24370230e-02f, 3.80414836e-02f,
  3.72510441e-02f, 3.47754844e-02f, 3.44493464e-02f, 8.21357965e-02f, -4.01493022e-03f, -8.93446431e-03f, 4.03848700e-02f, 7.39231929e-02f, 4.89235809e-03f, -3.64492051e-02f,
  -1.77689306e-02f, 3.36520448e-02f, 5.65773845e-02f, -2.61543021e-02f, -3.89699303e-02f, -1.66836493e-02f, -8.28594062e-03f, -3.17870788e-02f, 1.42586958e-02f, -3.92828297e-05f,
  -9.83741228e-03f, 2.67610252e-02f, -3.31504121e-02f, 3.79177742e-02f, -1.79050844e-02f, -1.99585110e-02f, -2.16919370e-02f, 3.86382714e-02f, 8.35078396e-03f, 2.80151311e-02f,
  -1.18001774e-02f, -2.75105704e-02f, 3.79589126e-02f, 1.71467606e-02f, -1.21397227e-02f, 6.14495128e-02f, 2.17311038e-03f, 5.57576679e-02f, -1.82048883e-02f, -1.77962822e-03f,
  -8.42552558e-02f, -1.63735256e-01f, -1.45809855e-02f, 1.90957787e-03f, 3.62674147e-03f, -3.75036448e-02f, -5.72527163e-02f, 1.47580421e-02f, -5.19746030e-03f, -6.05127290e-02f,
  2.74473298e-02f, 8.19902774e-03f, -2.30775066e-02f, -8.16158205e-03f, 1.50901955e-02f, -1.92125849e-02f, 3.06649506e-03f, -1.26906373e-02f, -2.66096201e-02f, 5.03948033e-02f,
  -3.76964192e-04f, -7.74394423e-02f, -1.68650895e-02f, -5.11266403e-02f, -1.23478975e-02f, 1.75465383e-02f, -3.70353535e-02f, -3.80657054e-02f, 2.01470237e-02f, 3.33018303e-02f,
  1.51061222e-01f, 3.30885708e-01f, 2.82379210e-01f, -7.37958550e-02f, 1.05533339e-01f, 2.33301982e-01f, -1.14236079e-01f, 1.78660959e-01f, 2.02118576e-01f, -7.65491873e-02f,
  4.04538028e-02f, -2.02131867e-01f, -1.26415521e-01f, 1.28995935e-02f, -1.91271186e-01f, 1.05438614e-02f, 1.56461284e-01f, -1.18892239e-02f, 2.05669254e-01f, 1.67297527e-01f,
  1.68562084e-01f, 1.69816703e-01f, 8.33101645e-02f, 3.49954993e-01f, 9.30794105e-02f, 3.46520655e-02f, -2.33079121e-01f, 2.62827519e-03f, 1.94555894e-02f, -2.06904225e-02f,
  -1.13189034e-01f, -5.79027683e-02f, 1.38723269e-01f, 7.02811107e-02f, -3.76352929e-02f, -2.14794856e-02f, -8.83004367e-02f, -1.02530465e-01f, -2.55359989e-02f, -3.51376086e-02f,
  -1.32587239e-01f, -1.98517777e-02f, 1.91012360e-02f, 4.67814915e-02f, 5.43029420e-02f, -1.61095839e-02f, 2.98220050e-02f, 3.06009352e-02f, 3.25330719e-02f, -5.06950654e-02f,
  1.30576044e-01f, 1.97939333e-02f, 6.32536337e-02f, 1.54242537e-03f, 3.05141639e-02f, 5.34269363e-02f, -1.27676213e-02f, -1.18156515e-01f, 1.00936458e-01f, 2.36489773e-02f,
  5.32284752e-03f, 7.65732080e-02f, -8.89116898e-03f, 3.30765508e-02f, -3.07381619e-02f, 4.11890820e-02f, -1.97949051e-03f, -3.16646993e-02f, -1.18009411e-02f, 9.37323458e-03f,
  -3.03982897e-03f, -4.83840965e-02f, -3.34725976e-02f, 6.37575462e-02f, -1.47512322e-02f, -1.24274772e-02f, -2.99647320e-02f, -3.47271301e-02f, 1.00107178e-01f, -2.76083313e-02f,
  -2.79909782e-02f, 6.35391623e-02f, 6.08017668e-02f, -2.46340875e-02f, 5.23339286e-02f, -4.61536609e-02f, 8.42040777e-03f, -3.85019146e-02f, 3.48532870e-02f, -7.59647936e-02f,
  3.32272872e-02f, 1.49411280e-02f, -2.09945291e-02f, -5.91633394e-02f, 1.53060013e-03f, -2.84773950e-03f, 1.19262427e-01f, 5.29784225e-02f, 5.19060344e-02f, 5.47363656e-03f,
  4.62228619e-02f, -9.19992477e-03f, 1.02278944e-02f, -2.25815773e-02f, -5.29221743e-02f, 4.35947813e-02f, -3.23611759e-02f, -1.47900162e-02f, 7.41773145e-03f, 4.92529236e-02f,
  -6.01071343e-02f, 3.55952568e-02f, -4.74926718e-02f, -8.32971185e-03f, -4.00097482e-02f, -3.73061374e-02f, 2.65778904e-03f, 4.07901406e-02f, -8.30637515e-02f, 4.07753512e-02f,
  -1.32396400e-01f, 7.04437345e-02f, 6.48190528e-02f, -3.11277341e-02f, -2.40191206e-01f, 2.57722437e-01f, 4.69518632e-01f, -1.28185168e-01f, 6.04714379e-02f, 3.15071404e-01f,
  9.20636579e-02f, 1.54733613e-01f, 3.20355654e-01f, 5.87327480e-02f, 3.19858402e-01f, 2.26108581e-01f, 1.60905048e-01f, 8.80784467e-02f, -1.86383091e-02f, -3.33349891e-02f,
  -9.88050327e-02f, 8.99152085e-02f, -9.33586434e-03f, -1.52808249e-01f, -1.15824178e-01f, -1.77378073e-01f, -1.77945849e-02f, 3.94064672e-02f, -8.53841379e-02f, 6.87572807e-02f,
  -6.97756186e-02f, -2.37205073e-01f, 2.37654857e-02f, -6.78566471e-02f, -4.20967713e-02f, 5.88123500e-02f, 5.05155185e-03f, 6.95860535e-02f, -5.26561402e-02f, -1.12179853e-02f,
  4.49195020e-02f, -2.50799507e-02f, -7.52121769e-03f, -1.49814086e-02f, -1.42409338e-03f, -1.82920024e-02f, -7.28336126e-02f, -4.57155779e-02f, -1.13152891e-01f, 1.79530531e-02f,
  5.80956750e-02f, -6.50921371e-03f, -1.38632916e-02f, 2.42603794e-02f, -6.75693387e-03f, 1.56476311e-02f, 3.48537676e-02f, 4.78643328e-02f, -1.83595326e-02f, -5.45437913e-03f,
  5.77736087e-02f, -1.45411240e-02f, -8.81572627e-03f, -6.25038445e-02f, 4.72136736e-02f, -2.43387558e-02f, -2.95723658e-02f, 2.17964426e-02f, -2.56827269e-02f, 7.20985532e-02f,
  -2.70330589e-02f, 2.90358602e-03f, -2.24628355e-02f, -9.34911706e-03f, -3.71906683e-02f, -6.85784519e-02f, -9.82880685e-03f, 2.41027791e-02f, -1.71025768e-02f, -3.54605876e-02f,
  -5.62481508e-02f, -9.60476813e-04f, 8.79751332e-03f, -3.99666615e-02f, 1.43285319e-02f, 5.34640625e-02f, -2.62369756e-02f, 3.11861895e-02f, -9.35434364e-03f, 2.64172610e-02f,
  1.29333377e-01f, 2.13379413e-01f, 3.70491445e-02f, 2.30712071e-03f, 4.52042855e-02f, 1.87420342e-02f, 3.77622768e-02f, -5.09567447e-02f, 7.59936124e-02f, 1.47446361e-03f,
  -6.86060265e-02f, -6.50212914e-02f, -1.24456352e-02f, 2.78756116e-02f, -2.65755709e-02f, 2.49538310e-02f, 2.66668163e-02f, 2.79926378e-02f, 7.98354819e-02f, -2.12854408e-02f,
  -6.23019040e-02f, -8.83514583e-02f, 3.58215421e-02f, -4.97169606e-02f, -2.03261916e-02f, 1.41698942e-02f, -3.80868874e-02f, -3.41803730e-02f, 5.20855784e-02f, 4.35822979e-02f
};

// L0_fan_Wp_bar (Shape: 4 x 120)
const int L0_fan_Wp_bar_rows = 4;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  1.74533755e-01f, -6.94400892e-02f, 2.85317659e-01f, 4.39973503e-01f, -1.57814994e-01f, -4.51638490e-01f, -1.87313437e-01f, 1.54457301e-01f, 1.95167214e-01f, -2.39869475e-01f,
  7.89542794e-02f, -6.47491142e-02f, 4.85329069e-02f, 1.19368427e-01f, 2.40239888e-01f, -1.41388895e-02f, 1.91050887e-01f, -1.11361682e-01f, 2.13385988e-02f, 2.18924358e-01f,
  2.67915040e-01f, 5.70413172e-02f, 2.94683993e-01f, -6.18173517e-02f, 2.63005868e-02f, 1.59126565e-01f, 2.37885728e-01f, -1.03241362e-01f, 1.12874500e-01f, -1.32152885e-01f,
  -1.49352387e-01f, 1.43488705e-01f, 5.38433306e-02f, -1.26171708e-01f, 6.51620403e-02f, -5.50992154e-02f, -3.99732925e-02f, -1.30524188e-01f, 6.66012103e-03f, -2.90421713e-02f,
  9.75169800e-03f, 6.31389692e-02f, -3.20659876e-02f, -3.91167738e-02f, -9.13108066e-02f, -8.22899118e-03f, 1.19754635e-01f, 4.16200161e-02f, -3.33559029e-02f, 8.94909576e-02f,
  7.01007247e-02f, -1.19317416e-02f, -6.77566801e-04f, 2.40349164e-03f, 6.65005073e-02f, 4.44852784e-02f, -3.99626531e-02f, 1.46522261e-02f, -1.60406120e-02f, -1.79460458e-02f,
  5.51096052e-02f, -1.01982549e-01f, -1.64107215e-02f, -1.85486935e-02f, 6.02786662e-03f, 4.06692736e-02f, -3.79160047e-02f, -7.32875541e-02f, 1.29921827e-02f, -1.74955204e-02f,
  4.63276319e-02f, 2.68194713e-02f, 2.05334201e-02f, -5.32414205e-02f, -1.38200726e-02f, -3.29218134e-02f, -7.73719186e-03f, -2.08582841e-02f, 8.01328942e-03f, 4.21560965e-02f,
  -1.50103932e-02f, -5.12216389e-02f, -3.99569981e-02f, -6.66181743e-02f, -3.73223200e-02f, 4.65799775e-03f, -2.61971704e-03f, -1.12856627e-02f, -2.18333527e-02f, 1.45498361e-03f,
  1.35371527e-02f, 1.38850480e-01f, 7.07358867e-02f, -4.19186912e-02f, 1.16042895e-02f, 5.50547801e-02f, -4.07011509e-02f, 7.21321777e-02f, -2.28904039e-02f, 1.23747233e-02f,
  3.94160040e-02f, -8.62953067e-02f, -3.43602225e-02f, 2.96929274e-02f, 5.84857278e-02f, 8.90701637e-02f, -4.09379713e-02f, 2.91148257e-02f, 3.46263982e-02f, 4.81654704e-02f,
  -1.02433665e-02f, -1.31457224e-01f, 1.22262659e-02f, 4.62887948e-03f, 5.54242693e-02f, -5.63446293e-03f, -7.61343688e-02f, -3.00283507e-02f, 6.80921227e-02f, -8.01197067e-03f,
  3.97864670e-01f, -9.77347791e-02f, 1.20143183e-01f, 3.08357090e-01f, 2.54642516e-01f, 1.67209104e-01f, 2.72469997e-01f, 1.00879982e-01f, 5.72392225e-01f, 8.07218160e-03f,
  -4.41488586e-02f, 6.50094151e-02f, 4.63488065e-02f, 1.59539422e-03f, 1.04768954e-01f, 2.88289376e-02f, 1.23022877e-01f, 1.32528730e-02f, 1.08361699e-01f, -4.01065536e-02f,
  -9.35084012e-04f, -1.89861745e-01f, -2.42869258e-01f, -2.92014986e-01f, -1.38468832e-01f, 6.95390552e-02f, -2.64507353e-01f, -8.74080881e-03f, -1.70213401e-01f, 8.93961340e-02f,
  1.80144478e-02f, 5.95275126e-02f, -1.29156232e-01f, 1.70600321e-02f, 1.58003264e-03f, -1.02708610e-02f, -9.55715403e-02f, 4.79975566e-02f, 6.95465729e-02f, 1.23976000e-01f,
  6.84144255e-03f, -7.09520504e-02f, -2.11309772e-02f, -4.51277643e-02f, 1.11769281e-01f, 6.07240433e-03f, 1.95156969e-02f, 1.97231560e-03f, 4.21786234e-02f, 1.74121112e-02f,
  -2.97894794e-02f, -1.45214703e-02f, -2.20303889e-02f, -4.23141494e-02f, 2.10410194e-03f, 3.56778689e-02f, 1.00937458e-02f, 5.24463654e-02f, -1.43596297e-02f, 8.11058283e-02f,
  -8.42323080e-02f, 8.46630931e-02f, 3.61398235e-02f, -2.06815377e-02f, -8.42199288e-03f, -2.57012937e-02f, -2.61943564e-02f, -4.71126512e-02f, -4.38082451e-03f, 5.16419951e-03f,
  3.58831845e-02f, -3.04349954e-03f, 6.72070403e-03f, 6.27186708e-03f, 2.14370787e-02f, 4.56933724e-03f, 2.91205514e-02f, -3.20293307e-02f, -3.31435278e-02f, -4.13887538e-02f,
  -5.03912941e-02f, -1.09136291e-02f, -4.18887706e-03f, 2.34756730e-02f, 2.39541624e-02f, 4.55821641e-02f, -4.79646139e-02f, 9.81235653e-02f, -1.48269134e-02f, -3.68515626e-02f,
  3.52002122e-02f, 5.20985387e-02f, 1.21572614e-02f, 2.39825863e-02f, -5.97715145e-03f, -3.01491003e-02f, 6.94416240e-02f, 8.40506237e-03f, 1.94021105e-03f, -2.28999741e-02f,
  8.93430319e-03f, 9.12011862e-02f, 9.06956103e-03f, -1.28490906e-02f, -6.90025324e-03f, 1.79538149e-02f, -2.53632460e-02f, -4.34815884e-03f, -1.52174383e-02f, -8.68604109e-02f,
  -8.00604001e-02f, 9.13108233e-03f, 8.27295929e-02f, 2.29042228e-02f, -1.00006923e-01f, -3.47310081e-02f, 5.85716479e-02f, -2.85122730e-02f, -5.77539243e-02f, -2.27719489e-02f,
  -5.84964633e-01f, -1.08254403e-01f, -2.84484714e-01f, -3.58385146e-01f, 9.53051746e-02f, -4.24911112e-01f, -4.93180037e-01f, -8.56034383e-02f, 1.00369938e-01f, -2.38833979e-01f,
  -1.04187548e-01f, -7.26576755e-03f, 2.22480614e-02f, -2.61511117e-01f, -5.89942094e-03f, 5.11824600e-02f, -3.27683628e-01f, -2.19594851e-01f, 7.66940862e-02f, -2.12350562e-01f,
  -1.36283981e-02f, -1.42200932e-01f, -1.69429481e-01f, 9.36604515e-02f, -2.10441530e-01f, 4.12577204e-03f, -5.09347096e-02f, -8.88940413e-03f, -1.03766359e-01f, 4.28171866e-02f,
  9.83816013e-02f, 2.50524700e-01f, -4.61058170e-02f, 7.21945101e-03f, -1.28686070e-01f, -9.63385627e-02f, -6.79542944e-02f, -2.75207516e-02f, -2.49731727e-03f, -6.20342270e-02f,
  -4.59013470e-02f, 7.42792711e-02f, -2.88214907e-02f, 4.13725786e-02f, -5.16337268e-02f, 9.23388079e-03f, 4.05297279e-02f, 1.56768169e-02f, 1.91690717e-02f, -8.37404653e-03f,
  -1.91671252e-02f, -2.18196549e-02f, -1.31907493e-01f, -4.91381362e-02f, -3.99560034e-02f, -1.41032059e-02f, -4.63141501e-02f, -4.26006876e-02f, -3.17997560e-02f, -6.46203905e-02f,
  -2.55001094e-02f, -1.01674092e-03f, 1.88932866e-02f, 2.78507499e-03f, -2.10612658e-02f, 3.20725553e-02f, -3.23528908e-02f, 2.26596985e-02f, 1.50383748e-02f, -5.07102199e-02f,
  -5.02762198e-02f, 3.07580009e-02f, -2.45095696e-02f, -3.76124382e-02f, -9.48118865e-02f, 4.59092995e-03f, 8.07395845e-04f, -1.86330378e-02f, -5.24012931e-02f, -2.08321903e-02f,
  -1.89513119e-03f, -1.73294842e-02f, -1.48731945e-02f, -3.44375037e-02f, 8.17169901e-03f, 2.00380571e-02f, -5.64183667e-03f, 1.86058078e-02f, -3.27997096e-02f, -6.95293024e-02f,
  -6.74335957e-02f, -2.56835431e-01f, 2.29413901e-02f, 6.41324092e-04f, 3.34353857e-02f, 1.06718047e-02f, 9.52563621e-03f, -2.60773320e-02f, -5.58943488e-02f, -4.93764924e-03f,
  -1.13068618e-01f, -6.12762496e-02f, 1.32724857e-02f, -1.29583264e-02f, 1.24891037e-02f, 1.33832684e-02f, -6.04766198e-02f, -5.93722649e-02f, -6.59302473e-02f, 6.22402132e-03f,
  2.69328654e-02f, 2.97775865e-02f, 8.27589259e-02f, 6.26871213e-02f, -5.02503440e-02f, -7.75191262e-02f, 1.27226673e-02f, 4.12220508e-02f, -2.63910485e-03f, 2.76933368e-02f,
  1.09726109e-01f, -2.05118358e-01f, -2.13754237e-01f, 7.91387483e-02f, 2.05726907e-01f, 2.22922400e-01f, -2.52463937e-01f, 6.06865622e-02f, -2.40738049e-01f, -1.20189495e-03f,
  5.86317442e-02f, 1.56726725e-02f, -3.82238746e-01f, 1.23050496e-01f, 1.88711986e-01f, -1.97532594e-01f, 1.32650718e-01f, 1.94955971e-02f, -1.94245696e-01f, -2.90891062e-02f,
  1.64768957e-02f, 3.99833620e-01f, -1.07141785e-01f, 3.10162157e-01f, 5.98253496e-02f, 3.29918973e-02f, 2.63072073e-01f, 1.95946079e-02f, 2.55579293e-01f, 1.29455373e-01f,
  3.27331424e-02f, -9.98549089e-02f, -6.18817322e-02f, -8.28670524e-03f, 1.91179086e-02f, 6.18970692e-02f, -8.40454537e-04f, -1.78584047e-02f, -9.58497729e-03f, -6.87005371e-02f,
  -6.26038685e-02f, 2.84848642e-02f, 3.46133746e-02f, 1.26460399e-02f, 5.23079373e-02f, -2.34886389e-02f, -3.96891125e-02f, -4.99044620e-02f, -1.18860237e-01f, -7.48047931e-03f,
  -7.54093975e-02f, -3.49118561e-02f, -1.06540229e-02f, 2.93096714e-02f, -7.61313960e-02f, 6.28717477e-03f, -9.00546461e-03f, -1.96788982e-02f, 1.86899137e-02f, -2.52070855e-02f,
  4.93976474e-02f, 2.82285139e-02f, -3.30910571e-02f, -1.40734585e-02f, 2.81367488e-02f, -1.77599639e-02f, -2.97892038e-02f, -1.09295417e-02f, -6.36578798e-02f, 1.29362978e-02f,
  -3.20790079e-03f, -3.47457789e-02f, -2.27510501e-02f, 4.19575684e-02f, 3.62758599e-02f, -4.59569842e-02f, -4.05360498e-02f, 5.30178957e-02f, 2.75120083e-02f, -5.51947169e-02f,
  -1.11662842e-01f, 6.00768402e-02f, 1.83993317e-02f, -1.27479313e-02f, 2.65789423e-02f, 5.22805676e-02f, 5.64069562e-02f, 3.37284505e-02f, -2.20180694e-02f, -1.21468380e-02f,
  7.65689313e-02f, 2.42290031e-02f, 5.46480948e-03f, 1.93960238e-02f, -4.03663050e-03f, 3.86370458e-02f, -1.89197976e-02f, 1.66698806e-02f, 5.88204302e-02f, 2.73341630e-02f,
  2.77965106e-02f, 1.42619507e-02f, 5.35811223e-02f, 1.94810927e-02f, 4.52861041e-02f, 8.09910297e-02f, -2.61113048e-02f, 3.41768959e-03f, 1.03485368e-01f, 2.95842532e-03f,
  6.00435361e-02f, -1.02754552e-02f, 1.06182527e-02f, -1.00572198e-03f, -1.56897679e-02f, -4.43106983e-03f, 2.41235364e-02f, -7.06325937e-03f, -6.31817896e-03f, -4.75695580e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 4)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 4;
const float L0_fan_Bp_bar_data[] = {
  -2.95854747e-01f, 1.12137347e-01f, 4.57151800e-01f, -1.25392629e-02f
};

// L1_fan_Wp (Shape: 6 x 16)
const int L1_fan_Wp_rows = 6;
const int L1_fan_Wp_cols = 16;
const float L1_fan_Wp_data[] = {
  -7.26625621e-02f, 3.11525881e-01f, 2.30057627e-01f, 3.92980784e-01f, 3.25580388e-01f, -3.38934809e-02f, -1.04190193e-01f, 4.44657266e-01f, -1.40444160e-01f, 4.28454518e-01f,
  1.37865067e-01f, -2.39396077e-02f, 2.59006530e-01f, -3.88283730e-01f, -3.71641219e-01f, -2.00950697e-01f, 4.66820300e-01f, -1.02684334e-01f, -3.44647914e-01f, -3.40628147e-01f,
  3.72819275e-01f, -5.20028733e-02f, 3.55297804e-01f, 6.04867637e-01f, -7.93716386e-02f, -6.50613189e-01f, -1.33874908e-01f, -1.56085908e-01f, 2.75472492e-01f, -2.74567276e-01f,
  -2.45176703e-01f, 3.62762243e-01f, -2.23759487e-01f, -1.06362894e-01f, -4.54504550e-01f, 6.42711669e-02f, 1.65842414e-01f, -2.40635931e-01f, -6.99954778e-02f, 4.36221242e-01f,
  -8.13995525e-02f, -1.92343086e-01f, -2.82182962e-01f, 1.87537938e-01f, 1.27995104e-01f, -6.43252790e-01f, 2.89323926e-01f, 4.21201676e-01f, -1.57817900e-01f, 9.61626172e-02f,
  5.34466147e-01f, 5.56843868e-03f, -4.41730350e-01f, 1.05831295e-01f, 5.26332617e-01f, -4.03562784e-01f, 5.48056841e-01f, 1.69431657e-01f, -1.42214581e-01f, 4.83442247e-01f,
  -1.50323018e-01f, -3.95448059e-02f, 3.85744750e-01f, -1.15497537e-01f, -9.88254398e-02f, -2.82532871e-01f, -7.93623552e-03f, 2.68055379e-01f, -3.31840575e-01f, -1.08935155e-01f,
  4.11084235e-01f, -9.07839760e-02f, 8.35966840e-02f, -1.32449120e-01f, 2.35257149e-01f, 4.69418019e-01f, -4.00625020e-01f, 1.43804312e-01f, 4.45149839e-01f, -4.11536127e-01f,
  1.04233749e-01f, -1.74754292e-01f, -4.46360588e-01f, -1.53381467e-01f, -5.54732159e-02f, 3.04999262e-01f, 9.08750594e-02f, 6.21190183e-02f, -5.03067672e-02f, -3.08016062e-01f,
  1.35828719e-01f, -5.95000803e-01f, 3.96271408e-01f, 1.17206886e-01f, 3.97035867e-01f, 3.81166786e-01f
};

// L1_fan_Wp_bar (Shape: 4 x 16)
const int L1_fan_Wp_bar_rows = 4;
const int L1_fan_Wp_bar_cols = 16;
const float L1_fan_Wp_bar_data[] = {
  6.34915531e-01f, 2.44546548e-01f, 3.46013993e-01f, -3.81034225e-01f, 2.57321417e-01f, -1.01776302e-01f, -2.04302222e-01f, -2.61297971e-01f, 8.15327585e-01f, -6.81582570e-01f,
  -1.86833590e-01f, 5.95746517e-01f, -2.21814767e-01f, 1.93095803e-01f, -5.93524873e-01f, 1.24693401e-01f, 4.13986415e-01f, 4.26784426e-01f, 5.12785256e-01f, 7.32107162e-02f,
  1.26844868e-01f, 2.69642293e-01f, -3.07293097e-03f, -3.07040364e-01f, -5.97106636e-01f, -3.16833735e-01f, 5.77663839e-01f, -3.77167761e-01f, 7.83992589e-01f, 6.42831028e-01f,
  -4.00676519e-01f, -2.72395283e-01f, 4.44397688e-01f, -3.74736249e-01f, -1.07738815e-01f, 6.15664542e-01f, -9.54857282e-03f, 1.84795648e-01f, 4.06078041e-01f, 6.05714023e-01f,
  -2.36244828e-01f, 1.12726398e-01f, -2.98064411e-01f, -7.29196519e-02f, 2.18912531e-02f, -4.23884951e-02f, 5.14786720e-01f, -2.57052064e-01f, -2.20934495e-01f, 4.19344932e-01f,
  2.05245256e-01f, 2.78599113e-01f, -1.48275048e-01f, 4.24891770e-01f, -3.66749942e-01f, -2.84969080e-02f, -3.86534065e-01f, 5.68175197e-01f, 4.74492554e-03f, -6.21475615e-02f,
  3.21976572e-01f, -2.65932716e-02f, 3.35095644e-01f, -5.31385951e-02f
};

// L1_fan_Bp_bar (Shape: 1 x 4)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 4;
const float L1_fan_Bp_bar_data[] = {
  3.74229848e-01f, 2.08079949e-01f, 4.20632213e-01f, 4.27179575e-01f
};

// L2_fan_Wp (Shape: 6 x 16)
const int L2_fan_Wp_rows = 6;
const int L2_fan_Wp_cols = 16;
const float L2_fan_Wp_data[] = {
  -2.34230548e-01f, -1.14890464e-01f, 4.03519839e-01f, 7.47084320e-02f, -1.69368103e-01f, 1.57954559e-01f, 2.21218273e-01f, 3.01634938e-01f, 5.68346143e-01f, -1.59981161e-01f,
  6.02660701e-02f, 2.00229570e-01f, -4.90414530e-01f, -3.82358730e-02f, 4.67543125e-01f, 3.50796372e-01f, -5.01385570e-01f, -2.77245343e-01f, -6.38107881e-02f, 5.80828607e-01f,
  -1.23679943e-01f, -1.37147561e-01f, 8.38796869e-02f, 8.72441590e-01f, 1.04092292e-01f, -7.07533598e-01f, -8.41413796e-01f, 4.10692483e-01f, -2.91737646e-01f, 4.06494349e-01f,
  -1.39128819e-01f, 1.05133958e-01f, 1.85379207e-01f, -1.33772537e-01f, -5.55685125e-02f, -1.58623055e-01f, 1.58633336e-01f, 1.82993591e-01f, 7.97687769e-02f, -6.33932710e-01f,
  -4.36210483e-02f, 4.11074236e-02f, 5.24657190e-01f, -7.94527605e-02f, -5.45216560e-01f, -5.43034375e-01f, 4.66178060e-01f, 1.67955637e-01f, -1.82865441e-01f, -2.71621853e-01f,
  -7.50327334e-02f, 2.48268694e-01f, -4.34590191e-01f, 2.12619938e-02f, 3.91919047e-01f, 6.98695362e-01f, 5.13806820e-01f, -6.75507545e-01f, -7.90641189e-01f, 1.35219932e-01f,
  1.18545517e-01f, -1.72959343e-01f, -2.82391250e-01f, 2.90228557e-02f, 9.54012722e-02f, -6.23994358e-02f, 2.74453580e-01f, 4.20468986e-01f, -1.99506700e-01f, 8.61866400e-02f,
  6.45380616e-01f, 7.75020599e-01f, 4.64851767e-01f, -6.81062460e-01f, -4.04504567e-01f, -1.36852011e-01f, -4.72192876e-02f, 1.83162495e-01f, 2.22843587e-01f, -2.01477453e-01f,
  -2.55170554e-01f, -9.36824679e-02f, 2.38779739e-01f, -5.31366289e-01f, 2.63246715e-01f, 2.66725123e-01f, -1.50403529e-02f, -5.96190155e-01f, 4.94816303e-02f, 1.82197556e-01f,
  -1.71065152e-01f, -6.78611398e-01f, -3.03014934e-01f, -4.50176328e-01f, 3.65563929e-01f, 2.78026670e-01f
};

// L2_fan_Wp_bar (Shape: 4 x 16)
const int L2_fan_Wp_bar_rows = 4;
const int L2_fan_Wp_bar_cols = 16;
const float L2_fan_Wp_bar_data[] = {
  -1.27805829e-01f, 5.22459447e-01f, -1.73029840e-01f, 3.15142781e-01f, -1.71972603e-01f, -3.63755673e-02f, 4.23063457e-01f, -2.78433114e-01f, -4.28888708e-01f, -4.91769202e-02f,
  -8.48045126e-02f, -4.48871255e-02f, -6.54481575e-02f, 1.40059924e+00f, -4.93198931e-01f, 6.21309698e-01f, 9.35499519e-02f, 4.15068120e-01f, 4.15495753e-01f, 4.77354765e-01f,
  6.10531271e-01f, 1.43402398e-01f, -1.81301147e-01f, 5.81493452e-02f, -2.15603486e-01f, 7.38186538e-01f, 3.33507210e-01f, -5.86265206e-01f, 1.38710284e+00f, -1.50683597e-01f,
  -3.66431564e-01f, -5.93689859e-01f, 1.42183393e-01f, 6.19810462e-01f, -1.89587444e-01f, 2.91200638e-01f, 4.50825632e-01f, -1.19272746e-01f, 7.89363054e-04f, 6.36666834e-01f,
  2.44944155e-01f, 9.61360186e-02f, 3.90729960e-03f, 4.81136143e-01f, -1.07928365e-01f, 5.12521386e-01f, 6.79337263e-01f, -3.70553672e-01f, 3.77821237e-01f, 5.48857987e-01f,
  3.74911547e-01f, -1.52590619e-02f, 5.68237364e-01f, 4.40845579e-01f, 6.95395529e-01f, -2.39217177e-01f, -3.39563340e-01f, 3.62651348e-01f, 5.49554408e-01f, -6.77311957e-01f,
  -2.32454628e-01f, 9.81509760e-02f, -8.43180995e-03f, -1.14097908e-01f
};

// L2_fan_Bp_bar (Shape: 1 x 4)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 4;
const float L2_fan_Bp_bar_data[] = {
  1.16908245e-01f, 1.90703422e-01f, -4.53945026e-02f, 3.62454802e-01f
};

// L3_linear_W (Shape: 12 x 16)
const int L3_linear_W_rows = 12;
const int L3_linear_W_cols = 16;
const float L3_linear_W_data[] = {
  5.19647777e-01f, 3.78069848e-01f, 4.52531368e-01f, 8.94023240e-01f, -1.16333872e-01f, 3.12985688e-01f, 2.55024463e-01f, -1.00267339e+00f, -1.34355292e-01f, -6.79361671e-02f,
  6.54793859e-01f, 4.50674742e-02f, -7.87138939e-01f, 7.40140200e-01f, 1.10487096e-01f, 6.52652562e-01f, 5.44846952e-01f, 6.37966037e-01f, -7.61599004e-01f, 5.40284991e-01f,
  1.57715842e-01f, -4.02278006e-01f, -5.40606260e-01f, 6.92666650e-01f, -5.69108427e-01f, 1.02381516e+00f, 2.99084604e-01f, -3.78123343e-01f, -6.21917665e-01f, 1.10150564e+00f,
  8.79450664e-02f, -6.11788154e-01f, 9.59623933e-01f, -2.97020823e-01f, -1.20396204e-01f, -1.19496679e+00f, -7.24208713e-01f, -4.56178188e-01f, 5.06180048e-01f, 9.47294474e-01f,
  -8.73724639e-01f, 9.42423224e-01f, 7.40949214e-01f, -8.90633225e-01f, -3.03671099e-02f, -5.19057095e-01f, 4.53315303e-02f, -4.74105716e-01f, -6.86884701e-01f, 1.02086234e+00f,
  -3.53931874e-01f, 7.15169311e-01f, 3.85009170e-01f, 3.60098749e-01f, 3.68128121e-01f, -1.21492073e-02f, 1.09109843e+00f, -7.71037579e-01f, 7.87383020e-01f, 2.46921524e-01f,
  -3.58280629e-01f, -4.98103589e-01f, 6.91404164e-01f, -3.10941607e-01f, 8.08390319e-01f, 1.92143574e-01f, 4.13604945e-01f, -6.71760798e-01f, 5.66393137e-01f, 4.57128465e-01f,
  7.39332139e-01f, -8.47681999e-01f, 7.08677113e-01f, -4.09467816e-01f, -5.79567909e-01f, 2.22125784e-01f, 2.54196912e-01f, -3.61136824e-01f, 1.51433542e-01f, 9.45555866e-01f,
  -7.12421298e-01f, -4.13461328e-01f, -2.63974011e-01f, -2.84142405e-01f, 3.22153986e-01f, -6.00802675e-02f, -4.53221709e-01f, -8.21988344e-01f, -3.76852721e-01f, -2.91729510e-01f,
  -3.00787598e-01f, -6.12183094e-01f, 1.24418847e-01f, 9.98786509e-01f, -2.02982292e-01f, -1.41175255e-01f, -2.83406000e-03f, 3.76382232e-01f, -3.65911990e-01f, 1.63987260e-02f,
  4.01760161e-01f, -1.10325146e+00f, -8.71690273e-01f, 5.24416029e-01f, -2.38868102e-01f, -7.94997275e-01f, -2.22241729e-01f, -2.65840739e-01f, 4.75115746e-01f, 7.15035424e-02f,
  7.34872639e-01f, -1.14160605e-01f, -8.34165335e-01f, 1.89604968e-01f, -7.10093260e-01f, -5.45912027e-01f, 5.87654188e-02f, -4.77962345e-01f, 6.50341094e-01f, -9.76606250e-01f,
  8.79832804e-01f, -8.03347945e-01f, -1.43791640e+00f, 1.06823552e+00f, -2.59350419e-01f, -2.91896939e-01f, -1.89465865e-01f, -4.53269213e-01f, -1.87334225e-01f, -7.66809583e-01f,
  -2.98547894e-01f, 3.56292248e-01f, -6.08832240e-01f, -2.20606193e-01f, 6.08525947e-02f, -4.45004761e-01f, -1.19794935e-01f, 7.80226350e-01f, 2.31374681e-01f, -2.09089950e-01f,
  8.94387960e-01f, -3.79275262e-01f, 7.05854818e-02f, -4.68021303e-01f, 1.36682436e-01f, -7.02711344e-01f, 6.31238878e-01f, -7.40507662e-01f, 4.44827415e-02f, 5.90075195e-01f,
  -9.64604259e-01f, -3.91160399e-02f, 2.88724959e-01f, -1.81535557e-01f, -9.76074815e-01f, 4.28384185e-01f, -5.81868172e-01f, 7.33508408e-01f, -4.11145240e-01f, 5.10584950e-01f,
  -4.63469088e-01f, -2.76568055e-01f, 9.21472192e-01f, 6.42175257e-01f, -9.31517243e-01f, 7.84094512e-01f, 3.75470281e-01f, 1.20677829e+00f, 5.04198074e-01f, 8.90317738e-01f,
  4.38144654e-01f, 4.15003300e-01f, -6.60930350e-02f, -7.24225819e-01f, 4.92891937e-01f, -1.06555171e-01f, 5.49503326e-01f, 3.52008969e-01f, 8.67506921e-01f, 6.54604673e-01f,
  5.43658555e-01f, 6.43936098e-01f, 2.65612185e-01f, 9.20223653e-01f, 2.31798477e-02f, 8.19676071e-02f, 4.62063253e-01f, -1.96758173e-02f, 8.92521203e-01f, -4.27943468e-01f,
  -8.26242149e-01f, 2.65590340e-01f
};

// L3_linear_B (Shape: 1 x 12)
const int L3_linear_B_rows = 1;
const int L3_linear_B_cols = 12;
const float L3_linear_B_data[] = {
  -3.61720264e-01f, -9.86104235e-02f, 2.98316509e-01f, 1.81988224e-01f, -1.38349056e-01f, -4.69130427e-01f, -1.92127377e-01f, 3.22232008e-01f, -2.61207730e-01f, -1.93458512e-01f,
  1.56826481e-01f, -1.76411010e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 6, 4
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        16, 6, 4
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        16, 6, 4
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_linear
    linear_forward_pgm(
        buffer1, x_out,
        L3_linear_W_data, L3_linear_B_data,
        16, 12
    );
    }
    