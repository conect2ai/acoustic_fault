/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 32 (x2)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 32;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    return (x > 0.0f) ? x : 0.0f;
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 12 x 120)
const int L0_fan_Wp_rows = 12;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -2.49983400e-01f, -1.75891921e-01f, 1.33205339e-01f, -1.84733361e-01f, -1.09191924e-01f, 7.54887909e-02f, -1.23013385e-01f, -1.01304732e-01f, -2.91077569e-02f, -1.10389315e-01f,
  1.62693992e-01f, 3.13596189e-01f, 2.41080865e-01f, 2.61234134e-01f, 1.24535777e-01f, -2.41541505e-01f, -3.71364027e-01f, -6.40606284e-02f, 3.66875648e-01f, 1.54199988e-01f,
  -1.93842349e-03f, -1.99813381e-01f, -2.34119743e-02f, -4.59462292e-02f, -2.97112882e-01f, -8.61119851e-02f, -2.66571015e-01f, -1.68287739e-01f, -5.77810826e-03f, -5.84216535e-01f,
  1.22847617e-01f, -1.13155261e-01f, 1.73120379e-01f, -3.29760499e-02f, -5.12531884e-02f, 6.86481372e-02f, 7.10050240e-02f, -7.36676296e-03f, -5.92351146e-02f, 8.52279924e-03f,
  -1.09937996e-01f, 7.79501721e-02f, -2.73999888e-02f, 5.14947139e-02f, -1.07032983e-02f, 6.52342662e-02f, -7.58863688e-02f, 5.33677787e-02f, 1.28724232e-01f, 5.17831258e-02f,
  -4.63967249e-02f, -9.55315828e-02f, -7.93038681e-02f, 6.03547394e-02f, 5.70061021e-02f, -2.97058672e-02f, 2.31064986e-02f, -1.42612085e-02f, 1.16511006e-02f, -3.61290425e-01f,
  -5.36202155e-02f, -1.80378016e-02f, 1.91128589e-02f, -7.71676302e-02f, -5.18582687e-02f, -8.33479967e-03f, -9.30375233e-02f, -3.01991720e-02f, 5.70198335e-02f, -1.31042451e-01f,
  5.11589684e-02f, 4.50359359e-02f, 2.39784811e-02f, -8.89990479e-03f, 7.84805268e-02f, -3.12733203e-02f, -3.97307836e-02f, 1.34811662e-02f, 9.60632861e-02f, -2.58362629e-02f,
  4.34530824e-02f, 5.63711636e-02f, -1.20632276e-02f, 6.73940554e-02f, 4.60637212e-02f, 3.87072079e-02f, -9.06637497e-03f, 1.28484175e-01f, 8.00502077e-02f, -5.06532975e-02f,
  8.81388609e-04f, 2.50956774e-01f, -7.12259635e-02f, 2.16234452e-03f, -8.12217593e-02f, 3.98251228e-02f, -1.07825197e-01f, 2.45275628e-02f, 2.43488606e-02f, 5.12137264e-02f,
  7.76562393e-02f, -7.54760392e-03f, 4.81594494e-03f, -1.17625156e-02f, 2.13291980e-02f, -1.05954614e-02f, -2.91178860e-02f, -1.39007932e-02f, -1.04982527e-02f, 6.36021048e-02f,
  -6.15606792e-02f, -3.10420580e-02f, -1.10509545e-02f, -1.70415528e-02f, -4.44833077e-02f, -4.41116318e-02f, -3.95282991e-02f, 3.52480933e-02f, 1.15923611e-02f, -1.39908761e-01f,
  3.21099907e-01f, -1.56205669e-01f, 4.79322553e-01f, -1.69658706e-01f, -3.10980886e-01f, 1.42177846e-03f, -1.73014197e-02f, -6.64959755e-03f, -1.09462343e-01f, -7.78736770e-02f,
  1.16678039e-02f, 5.94915301e-02f, 1.57240897e-01f, 2.16432407e-01f, 2.39054829e-01f, -4.59771827e-02f, -8.38452354e-02f, 3.42676759e-01f, 2.66001880e-01f, -1.75697625e-01f,
  -3.12890023e-01f, -1.25680715e-01f, 2.11252883e-01f, 8.97370800e-02f, -1.75743252e-01f, 8.54879990e-02f, 1.07647188e-01f, -1.54840216e-01f, 1.47907093e-01f, -1.99892774e-01f,
  1.73752770e-01f, -1.41426384e-01f, 1.15047947e-01f, 1.41653037e-02f, -4.33294401e-02f, 8.26700591e-03f, 7.03639686e-02f, -2.24013254e-02f, -2.31106915e-02f, -5.12753725e-02f,
  -5.09607643e-02f, -5.83072416e-02f, -1.07749343e-01f, -1.79598704e-02f, -6.76266328e-02f, 2.79741082e-02f, 8.46340880e-02f, 6.03099577e-02f, 1.31468564e-01f, 2.69918935e-03f,
  -2.41463467e-01f, -2.08021969e-01f, 1.20985853e-02f, 6.36935905e-02f, 2.73214765e-02f, 9.04483870e-02f, -1.42176375e-02f, -2.42854413e-02f, 2.14168102e-01f, 7.17003345e-02f,
  -2.07035034e-03f, 1.16877342e-02f, 3.69445868e-02f, -3.55415829e-02f, -7.29873851e-02f, -3.81527580e-02f, -4.67719771e-02f, -3.18652615e-02f, -2.83159148e-02f, 2.16412861e-02f,
  3.53724360e-02f, -5.59717417e-03f, 3.21802013e-02f, 7.02346712e-02f, 4.72033434e-02f, -2.83653047e-02f, -3.28962505e-02f, 8.48271847e-02f, 7.98306316e-02f, -4.71078530e-02f,
  4.32259403e-03f, -6.45865425e-02f, -2.09979601e-02f, -5.06513417e-02f, 5.42242713e-02f, 6.94612339e-02f, -4.29249518e-02f, 2.63743429e-03f, -2.17517489e-04f, -7.45976791e-02f,
  9.44251474e-03f, 2.99363643e-01f, 4.33476903e-02f, -2.82482617e-02f, 3.42915244e-02f, 5.43553643e-02f, 5.32528572e-02f, 9.43206903e-03f, -9.53287631e-02f, 2.87009124e-02f,
  -4.22725789e-02f, 1.05857179e-02f, 1.57350153e-02f, -2.37917807e-02f, -5.68366684e-02f, -8.40176642e-02f, 1.64390467e-02f, 5.99795617e-02f, 2.29866896e-02f, -9.33685005e-02f,
  -7.37710521e-02f, 3.96641828e-02f, 4.53930348e-02f, 7.96655267e-02f, -1.11926727e-01f, -4.01577493e-03f, 4.06164005e-02f, 4.10306528e-02f, 2.20515057e-01f, 2.05191925e-01f,
  -5.65381110e-01f, 3.92412022e-02f, -7.83554390e-02f, -1.43757030e-01f, 2.84816712e-01f, 1.05127819e-01f, 4.11503538e-02f, -1.04467645e-01f, -1.33854464e-01f, -1.46968842e-01f,
  1.46421999e-01f, 1.82880342e-01f, 2.01965161e-02f, 1.41100287e-01f, -1.88365616e-02f, -1.57558888e-01f, -2.19816435e-02f, 2.56116278e-02f, 1.86116784e-03f, 1.85967982e-01f,
  2.34675273e-01f, -1.32328272e-01f, -2.15200812e-01f, -6.60906285e-02f, -9.58234221e-02f, 6.01620488e-02f, -8.75082761e-02f, 1.00272514e-01f, 9.13547054e-02f, -9.76531208e-02f,
  -1.00683868e-01f, -8.95418078e-02f, 4.08862606e-02f, 7.83412755e-02f, -5.58572859e-02f, -2.66576529e-01f, -6.98889047e-02f, -1.10454537e-01f, -8.92664939e-02f, -1.19119257e-01f,
  9.12056118e-02f, -8.86657555e-03f, -2.45270990e-02f, -2.18033381e-02f, 5.83967427e-03f, -1.46039091e-02f, 1.71667207e-02f, -9.07974094e-02f, -8.40303302e-02f, -7.96938986e-02f,
  1.80677623e-01f, 1.39671445e-01f, -7.23844469e-02f, 4.40821648e-02f, -6.25081314e-03f, 6.70513287e-02f, -4.22471203e-02f, 7.63561577e-02f, 6.31103814e-02f, -2.58463264e-01f,
  4.76673730e-02f, -1.69086065e-02f, 4.20347936e-02f, -8.05558041e-02f, -4.75000888e-02f, 7.33986823e-03f, 5.85203990e-03f, 7.09200129e-02f, 2.76846942e-02f, 1.54200033e-03f,
  6.34673759e-02f, 5.38331196e-02f, -3.78625356e-02f, -5.01347110e-02f, -4.94000018e-02f, 5.84794804e-02f, 6.99362531e-02f, -7.91691896e-03f, 1.97448488e-02f, 3.89898836e-04f,
  1.37489038e-02f, 3.80150718e-03f, -4.00240906e-02f, 6.56037331e-02f, 1.09799124e-01f, 4.40391265e-02f, 2.72971895e-02f, 4.36697155e-02f, -1.85859967e-02f, -4.64265049e-02f,
  -2.62087226e-01f, 2.43089095e-01f, -1.59535527e-01f, -5.88102499e-04f, -1.45815507e-01f, -1.90074388e-02f, -4.86494638e-02f, -3.55848223e-02f, 1.39787523e-02f, -1.85826700e-02f,
  3.08328010e-02f, -1.04051687e-01f, -5.48568405e-02f, 7.93403853e-03f, -1.17169833e-02f, -3.27406824e-02f, -6.26229793e-02f, -2.36465763e-02f, -2.54959073e-02f, -5.60978940e-03f,
  -7.96171948e-02f, -5.16280979e-02f, -1.47368580e-01f, -1.41809061e-01f, -3.55105065e-02f, -8.44954327e-02f, -1.28004894e-01f, -2.07752854e-01f, -7.60417357e-02f, -4.07681286e-01f,
  -5.41348398e-01f, -4.31424119e-02f, 4.74788219e-01f, -4.30181175e-01f, 5.85802607e-02f, 3.13201517e-01f, 5.95848382e-01f, -3.29781286e-02f, -2.73075640e-01f, 7.49706104e-02f,
  4.01819358e-03f, -1.93358809e-01f, -2.03222051e-01f, -4.19821404e-02f, 1.34273112e-01f, 2.54831612e-01f, 1.82903439e-01f, 2.10868105e-01f, 2.20198572e-01f, 1.74722373e-01f,
  3.33385691e-02f, -2.44381562e-01f, -3.29570293e-01f, 1.85016934e-02f, -1.18931942e-01f, -4.97265421e-02f, -2.56544165e-02f, -1.25920802e-01f, 1.36759290e-02f, -1.95581809e-01f,
  6.50179237e-02f, -2.61383563e-01f, 7.93512166e-02f, -4.74059023e-02f, -5.74750565e-02f, -1.47111595e-01f, 1.16035878e-03f, -4.98548709e-02f, -3.71430032e-02f, 1.72596928e-02f,
  -6.47792816e-02f, -1.28086895e-01f, -7.74865523e-02f, -2.90332042e-04f, -4.48710434e-02f, -1.17385164e-02f, -1.50385395e-01f, -3.25822607e-02f, 3.29152085e-02f, 1.66885182e-02f,
  -1.26067102e-02f, 7.51568228e-02f, 6.06587157e-02f, 9.21112522e-02f, -2.09440310e-02f, -2.70875748e-02f, 1.85722951e-02f, -5.02305254e-02f, 9.61223543e-02f, -1.67226210e-01f,
  -1.89848498e-01f, -3.19044641e-03f, 2.82820240e-02f, -3.94112468e-02f, -2.94008870e-02f, -5.23329489e-02f, -1.38021940e-02f, 2.97067184e-02f, 3.92570384e-02f, 1.52460802e-02f,
  1.98792736e-03f, 5.67837954e-02f, -1.80385485e-02f, -4.21991609e-02f, 5.57798035e-02f, 3.12476512e-03f, 7.63653591e-02f, 4.51736413e-02f, 9.06286296e-03f, 1.32623827e-02f,
  1.50363967e-02f, 2.08618939e-02f, -5.33445366e-02f, 1.11502603e-01f, 4.44250591e-02f, 1.01209380e-01f, -2.97042858e-02f, -1.18640130e-02f, -3.54912654e-02f, -9.02080312e-02f,
  -1.26412213e-01f, 1.02841064e-01f, -8.82476345e-02f, -9.12131649e-03f, -1.27557032e-02f, -3.34921628e-02f, 5.96547276e-02f, -3.05978442e-03f, -1.37988636e-02f, 4.42236811e-02f,
  2.88434178e-02f, 2.86757443e-02f, -2.64849626e-02f, 7.32533112e-02f, 9.69723761e-02f, 1.06408998e-01f, -6.27595410e-02f, 6.65061697e-02f, 8.67250487e-02f, -2.43336409e-02f,
  -1.69212453e-03f, 8.03455710e-02f, 2.81931106e-02f, 9.21291113e-02f, 2.98081860e-02f, 4.34925258e-02f, 1.25783905e-01f, 7.57861286e-02f, 1.77047864e-01f, 8.73880982e-02f,
  -6.14345610e-01f, -5.86602278e-02f, 5.50225675e-01f, -2.14264333e-01f, 1.25150859e-01f, 4.99343351e-02f, 1.36378229e-01f, -1.17989160e-01f, -9.44758356e-02f, 1.29771531e-01f,
  -2.56963432e-01f, -1.90205768e-01f, -4.81800251e-02f, -1.16472794e-02f, -3.74805331e-02f, 2.57043660e-01f, 4.82141972e-01f, 3.09053063e-01f, -1.19496379e-02f, -1.19545348e-01f,
  -9.94472876e-02f, 4.51384261e-02f, -4.83008735e-02f, -4.24365960e-02f, 1.73630431e-01f, 9.30959955e-02f, 2.28602692e-01f, 1.62236333e-01f, 2.02572331e-01f, 3.38877708e-01f,
  2.28715837e-01f, -1.64965361e-01f, -5.31191304e-02f, -1.63316578e-01f, 2.99021602e-02f, -5.63133769e-02f, -7.88980499e-02f, -6.69685602e-02f, -4.26110700e-02f, -1.33083891e-02f,
  -1.63682718e-02f, -5.85799888e-02f, 2.59152986e-02f, -3.56086381e-02f, -5.33688255e-03f, -1.00413188e-01f, 1.86607223e-02f, 3.24947340e-03f, -3.78852859e-02f, -1.47204637e-03f,
  -2.15277448e-02f, 4.21756096e-02f, -2.12043636e-02f, -3.45309265e-02f, 3.22607197e-02f, -8.37020352e-02f, -4.35415655e-02f, 3.23315561e-02f, 5.96696585e-02f, 8.69327262e-02f,
  2.02049669e-02f, -2.67246943e-02f, -4.02276888e-02f, -1.01917004e-02f, -4.05706055e-02f, -4.91306745e-02f, 1.69231854e-02f, 6.12659752e-02f, -4.49546315e-02f, -4.65492196e-02f,
  -3.29907015e-02f, -1.27022816e-02f, 1.95240844e-02f, -4.47844155e-02f, 7.24790692e-02f, 7.94754922e-02f, 6.74563646e-03f, 6.26480654e-02f, 9.47988126e-03f, -2.41981801e-02f,
  -3.18052396e-02f, 4.30934578e-02f, -3.67109776e-02f, 2.30987668e-02f, 8.66430104e-02f, 4.85465564e-02f, 9.43362713e-02f, -5.14139719e-02f, -3.74255166e-03f, 9.95012838e-03f,
  -1.25244007e-01f, -1.85852628e-02f, -5.96028455e-02f, 4.83118147e-02f, 1.09950446e-01f, -8.52595083e-03f, -5.07313246e-03f, -2.32217321e-03f, -6.64017722e-02f, 1.86160225e-02f,
  3.09791490e-02f, 4.30753529e-02f, 5.84566742e-02f, 9.75123271e-02f, -3.57029252e-02f, -2.93805599e-02f, 4.91984114e-02f, 1.93066299e-02f, -1.07750800e-02f, 3.56633589e-02f,
  9.52897817e-02f, -1.81406084e-02f, -1.73525866e-02f, -4.66543436e-02f, 3.23296674e-02f, -4.94033098e-02f, 1.77610204e-01f, 5.37928306e-02f, -9.01717599e-03f, 6.08188510e-02f,
  1.28760204e-01f, -2.90825993e-01f, 3.95431548e-01f, 1.60544351e-01f, -1.33710578e-01f, -2.23412827e-01f, -5.70037961e-01f, -1.91833839e-01f, 3.78563032e-02f, 7.21053109e-02f,
  -4.62421775e-02f, 1.77921146e-01f, 9.65503454e-02f, 1.77605525e-01f, -1.23260736e-01f, -1.36258096e-01f, -2.80710142e-02f, 2.51768023e-01f, 7.17510134e-02f, -1.52323082e-01f,
  -1.96716473e-01f, -3.26929316e-02f, 1.33412406e-01f, -1.43192674e-03f, 5.19823283e-02f, 3.26264538e-02f, 1.85632005e-01f, 1.26114085e-01f, -1.04536362e-01f, 3.89809966e-01f,
  3.99478078e-01f, 2.53148694e-02f, 1.45805590e-02f, 1.11808497e-02f, 1.19453579e-01f, -2.06711683e-02f, -5.18710352e-02f, 1.25178739e-01f, 3.26613104e-03f, 2.93910839e-02f,
  1.04939319e-01f, 2.42881686e-03f, -3.18955374e-03f, 2.02569719e-02f, 1.21294782e-02f, 7.90612958e-03f, 1.31908968e-01f, 7.42289275e-02f, 3.70850377e-02f, 6.17555678e-02f,
  -3.42770591e-02f, 1.17970472e-02f, 2.52357945e-02f, 3.93091887e-02f, 8.95796791e-02f, 9.40847769e-02f, 7.68536404e-02f, 2.64427550e-02f, 1.16786145e-01f, 1.76727399e-01f,
  3.27028148e-02f, 1.30167827e-02f, 5.35662211e-02f, -1.53202573e-02f, -5.05112447e-02f, -1.23218412e-03f, 1.76256523e-02f, -4.59806388e-03f, -2.97327638e-02f, -1.94689967e-02f,
  4.05368358e-02f, 1.40580200e-02f, -3.80998105e-02f, -2.42132097e-02f, 6.25765533e-04f, -1.91172585e-02f, 1.11077894e-02f, -2.46693753e-03f, 8.47338047e-03f, -2.78975125e-02f,
  2.76203491e-02f, 1.53511222e-02f, 1.89492721e-02f, 6.17162772e-02f, 1.19126904e-04f, -8.59821588e-03f, -1.06261792e-02f, -5.96555742e-03f, -1.60551406e-02f, -3.32656130e-02f,
  -2.34272510e-01f, -3.96343954e-02f, 4.77288775e-02f, -2.50438470e-02f, -2.13405453e-02f, -2.77676508e-02f, 2.67262831e-02f, -2.97421031e-02f, -9.65998881e-03f, -1.99293476e-02f,
  -4.22197655e-02f, 3.52429636e-02f, 1.28593771e-02f, 7.61725334e-03f, -5.11736311e-02f, -3.61892693e-02f, -1.03022575e-01f, 1.84013862e-02f, -1.17666936e-02f, -4.36246321e-02f,
  -3.18375453e-02f, -1.23281442e-01f, -1.71246484e-01f, -1.62291408e-01f, 8.38682353e-02f, -1.43947780e-01f, -1.22641824e-01f, -3.44271399e-03f, -1.91094086e-01f, -3.07013482e-01f,
  -2.48107627e-01f, -2.30994239e-01f, -9.12695825e-02f, 1.88595906e-01f, 9.33206920e-03f, -2.37711102e-01f, -3.67399901e-01f, -2.11964592e-01f, 1.26563579e-01f, -7.80935809e-02f,
  1.15230149e-02f, 2.54139692e-01f, 2.77913272e-01f, 1.61798388e-01f, -2.29773641e-01f, -1.48505181e-01f, 6.50615543e-02f, -7.18515813e-02f, -5.34349754e-02f, -8.48911479e-02f,
  1.83533370e-01f, 1.28872886e-01f, 4.21088934e-03f, 1.46293640e-03f, 2.30446085e-01f, 3.09793323e-01f, 8.88921693e-02f, -2.40777861e-02f, -5.24139926e-02f, 2.84874290e-01f,
  8.20522830e-02f, -2.17049479e-01f, 4.71970066e-02f, 1.01994425e-02f, -2.94137727e-02f, -7.06211925e-02f, -1.30519727e-02f, -4.25364003e-02f, -6.16371669e-02f, -4.40470316e-03f,
  -3.20782065e-02f, -4.82994989e-02f, 2.05931552e-02f, 3.83375958e-02f, 1.09438021e-02f, -1.23238396e-02f, -6.62252828e-02f, -4.94489856e-02f, 1.85994077e-02f, -2.38688737e-02f,
  8.34553316e-02f, -4.59834263e-02f, -1.00235805e-01f, -2.35070363e-02f, -3.64516005e-02f, -4.50793505e-02f, -8.38767458e-03f, -4.22648713e-02f, -7.87872821e-02f, 1.57141108e-02f,
  -1.22622699e-01f, -9.05923080e-03f, 6.91528693e-02f, -3.75807807e-02f, 4.58444329e-03f, 2.76213931e-03f, -2.36701332e-02f, -1.02210827e-02f, 7.47618675e-02f, 1.01205222e-02f,
  1.74122173e-02f, 5.41470340e-03f, 4.39922065e-02f, -7.06642270e-02f, 7.75292814e-02f, -1.71797052e-02f, 1.94350723e-02f, 4.30563241e-02f, 1.71216782e-02f, -1.13611175e-02f,
  5.82021326e-02f, -8.17966182e-03f, 3.46236080e-02f, 6.54776692e-02f, -2.94577517e-02f, 3.67144905e-02f, 1.40890351e-03f, -3.38288844e-02f, 7.32984170e-02f, -6.66938424e-02f,
  3.82500857e-01f, -1.51817650e-01f, 1.25448480e-01f, 6.60730004e-02f, 3.75517420e-02f, -9.42449737e-03f, 7.85495862e-02f, 1.16246203e-02f, 1.41803334e-02f, 1.07834293e-02f,
  -6.99956641e-02f, -1.30462656e-02f, 4.54483777e-02f, 1.12112714e-02f, 4.38203439e-02f, -1.44638559e-02f, 4.26829755e-02f, 4.23994362e-02f, -6.47180453e-02f, 6.36339420e-03f,
  3.30155250e-03f, -2.75788326e-02f, -3.14081348e-02f, 8.20172485e-03f, 2.30605900e-02f, 8.83492604e-02f, 2.56433245e-02f, -2.42369529e-02f, -7.27484152e-02f, -1.04338720e-01f,
  2.84330994e-01f, -5.18846586e-02f, -5.88222802e-01f, 7.24688023e-02f, -1.39212608e-01f, -2.20604390e-01f, -1.62591264e-01f, -1.11136045e-02f, 1.65623993e-01f, 4.89451066e-02f,
  2.65875638e-01f, 3.57847184e-01f, 7.01696053e-02f, -5.02991490e-03f, -1.83587410e-02f, -3.27920884e-01f, -4.96083617e-01f, -4.34797972e-01f, -6.85526654e-02f, 4.96798754e-02f,
  2.30736405e-01f, 1.62210152e-01f, 1.01993389e-01f, -3.40537056e-02f, 6.73293881e-03f, 1.33190870e-01f, -1.14264891e-01f, -6.37040436e-02f, 2.90766619e-02f, -3.54513913e-01f,
  -1.18828133e-01f, -3.69984433e-02f, -6.43797358e-03f, 1.88146695e-01f, -4.27757017e-02f, -1.11576915e-01f, -2.74586491e-02f, -1.48495257e-01f, 3.56923975e-02f, -8.66557881e-02f,
  9.58596766e-02f, 2.35638842e-02f, -1.00444637e-01f, -6.29615560e-02f, 5.07691037e-03f, -3.47817875e-02f, -6.99151531e-02f, -1.27961591e-01f, -1.58127099e-01f, -5.87554872e-02f,
  1.94518007e-02f, 7.19176652e-03f, -9.90951285e-02f, -1.49084061e-01f, -8.16507861e-02f, -3.31321433e-02f, 2.37879492e-02f, 5.95940463e-02f, -1.37886424e-02f, 9.24015120e-02f,
  -6.49758428e-02f, -9.27094277e-03f, 8.62113014e-02f, -2.80054156e-02f, 1.56129107e-01f, -4.95854877e-02f, 6.67436980e-03f, 1.22046150e-01f, 3.08263469e-02f, 3.31453304e-03f,
  -8.38888530e-03f, 1.20468931e-02f, -1.16329649e-02f, -5.13089150e-02f, 7.07711652e-02f, -2.85945907e-02f, 1.45379016e-02f, 8.04186538e-02f, 2.02995725e-02f, 2.23017461e-03f,
  5.70160933e-02f, 7.25456476e-02f, -1.67061258e-02f, 7.83520266e-02f, 2.99174748e-02f, -6.96268156e-02f, 5.81445321e-02f, 6.29106387e-02f, 5.76047376e-02f, 3.60385887e-02f,
  3.65736604e-01f, -6.08665496e-02f, 3.80828828e-02f, 2.76110861e-02f, -2.63060518e-02f, 6.64147437e-02f, 2.67260764e-02f, -6.91552907e-02f, 4.49488945e-02f, 6.07251301e-02f,
  1.79123017e-03f, 1.62838474e-02f, 2.77811605e-02f, -5.51345898e-03f, 6.88239187e-02f, 3.30354124e-02f, 1.71600617e-02f, 7.34369271e-03f, 5.92725687e-02f, 3.78050208e-02f,
  3.26944925e-02f, 1.33520037e-01f, 1.03261150e-01f, 4.71563973e-02f, 1.41364947e-01f, 6.31245002e-02f, -1.11770201e-02f, 2.22866219e-02f, 1.91993862e-02f, 7.83108547e-02f,
  3.83207470e-01f, 7.64558092e-02f, 2.66737282e-01f, -2.15105750e-02f, -1.26388818e-01f, 7.48675037e-03f, 1.68178767e-01f, -1.07910909e-01f, -2.14169189e-01f, 1.33269817e-01f,
  -6.88891262e-02f, -1.67905465e-01f, -1.37831375e-01f, -2.13614553e-01f, -4.26879898e-02f, 1.02404933e-02f, 4.32987045e-03f, 3.59881558e-02f, -1.15407802e-01f, -5.98309971e-02f,
  -1.94554344e-01f, 8.67857113e-02f, 1.17973529e-01f, -1.83584075e-02f, -2.00473756e-01f, -1.93874225e-01f, 1.92369714e-01f, -2.18795910e-02f, 2.14836448e-02f, -1.58037245e-01f,
  1.31865472e-01f, 9.46658552e-02f, -2.63152719e-01f, -1.95027351e-01f, -1.30198568e-01f, -1.01013236e-01f, -5.09543307e-02f, -1.49753913e-01f, -1.01379827e-01f, -8.28497112e-02f,
  -7.19057992e-02f, -1.42967448e-01f, -1.20071866e-01f, -1.14198655e-01f, 7.86172003e-02f, -4.40829247e-02f, -7.89710879e-02f, -4.52605262e-02f, -2.64465194e-02f, -1.23496644e-01f,
  -1.98871300e-01f, -7.22863525e-02f, 1.55629478e-02f, -2.23840922e-02f, -4.55283783e-02f, -7.23646358e-02f, -2.13801768e-02f, -1.14387333e-01f, 6.70132488e-02f, 1.01281784e-01f,
  -6.40511960e-02f, 1.17324777e-02f, 4.98113967e-02f, 7.64157474e-02f, 5.55481054e-02f, 3.21194082e-02f, -8.29874445e-03f, 7.46347159e-02f, 2.61469604e-03f, 1.22091375e-01f,
  -4.66033034e-02f, 1.06693111e-01f, 3.53852920e-02f, 3.26323882e-02f, -1.52091235e-02f, 9.76898372e-02f, -2.64217495e-03f, 8.52987096e-02f, 3.45012620e-02f, 1.15851298e-01f,
  5.01464270e-02f, -2.15801261e-02f, 1.04570575e-02f, -2.24760789e-02f, 2.60192603e-02f, 4.86777350e-02f, 8.64472613e-02f, 3.49059701e-02f, 1.11431651e-01f, 1.81194797e-01f,
  -4.24941778e-02f, -1.57982871e-01f, -4.51065153e-02f, -1.15414046e-01f, -1.55120745e-01f, -1.47329435e-01f, -8.90824795e-02f, -1.12008847e-01f, -5.16125783e-02f, -2.45821737e-02f,
  -3.57099809e-02f, -4.22449671e-02f, 2.43938733e-02f, -5.00354506e-02f, -7.44938329e-02f, 2.80531533e-02f, -5.64259756e-03f, -4.77746204e-02f, -9.59685147e-02f, -2.68672016e-02f,
  -9.04180333e-02f, 2.85633113e-02f, 1.02271713e-01f, 1.68415289e-02f, -7.06054419e-02f, 3.87486927e-02f, -4.03352408e-03f, 1.56891197e-02f, 1.59538299e-01f, 2.45642588e-01f,
  -8.38049710e-01f, 4.42758769e-01f, -1.11001253e-01f, -2.77112514e-01f, 1.96175724e-01f, -1.46699566e-02f, 4.22942862e-02f, -1.28414094e-01f, -3.01752649e-02f, 4.93640527e-02f,
  1.79764494e-01f, 3.22686024e-02f, -1.15703389e-01f, 4.71164584e-02f, -2.32029602e-01f, 4.37825881e-02f, 2.00666711e-01f, -1.99596554e-01f, -2.62736350e-01f, -6.92187324e-02f,
  1.51831910e-01f, 1.67863872e-02f, -2.39136159e-01f, -1.76280886e-01f, 2.47512683e-01f, -1.09283645e-02f, 1.75144628e-01f, 7.35727325e-02f, 1.35649607e-01f, 3.55836689e-01f,
  -1.01302490e-01f, -4.44122329e-02f, 1.38536831e-02f, 6.68392554e-02f, 2.34228238e-01f, -1.33843794e-02f, 1.58400889e-02f, 2.16216017e-02f, 6.72715530e-02f, 7.65367448e-02f,
  1.49478167e-02f, 5.70260696e-02f, 6.52605072e-02f, 6.08692095e-02f, -3.09097990e-02f, -1.20637633e-01f, -1.18076630e-01f, -1.37832135e-01f, -9.44576487e-02f, -1.71085689e-02f,
  1.63149163e-01f, 1.32265031e-01f, -1.09931141e-01f, 2.72186678e-02f, -2.00799834e-02f, 3.85896824e-02f, 9.08418074e-02f, 9.20969844e-02f, -7.22780079e-02f, 5.95965749e-03f,
  5.82108200e-02f, 8.37459639e-02f, -6.89845383e-02f, -3.44256461e-02f, -4.10811007e-02f, 2.94970348e-02f, -1.32656535e-02f, -3.82805206e-02f, -1.53902723e-02f, -1.29630551e-01f,
  -1.65944372e-03f, -6.61547780e-02f, 1.75359603e-02f, -1.22815989e-01f, -9.86186564e-02f, -1.45922946e-02f, -2.27948483e-02f, -5.90445101e-02f, -1.22062087e-01f, -3.19707096e-02f,
  -7.70741403e-02f, 3.18148686e-03f, 3.95826250e-02f, -1.09286651e-01f, -9.70351472e-02f, -8.11585411e-02f, -5.73543124e-02f, 2.19329298e-02f, -7.65551329e-02f, -1.81159619e-02f,
  -1.08413808e-01f, 3.09538841e-02f, -1.19531788e-01f, -1.15620010e-01f, -1.94873253e-03f, 2.33987742e-03f, 1.17174899e-02f, 7.65904337e-02f, 3.34899090e-02f, -8.84645358e-02f,
  2.82883588e-02f, -1.15918040e-01f, 2.14478467e-02f, -5.39356023e-02f, -2.47860961e-02f, -8.66909027e-02f, -1.83529202e-02f, -1.04976013e-01f, 3.18830200e-02f, 1.10100336e-01f,
  2.00721920e-02f, -7.88766965e-02f, -2.53032625e-01f, -1.29463807e-01f, 4.05387878e-02f, -9.12557542e-02f, -1.38033032e-02f, -7.24407211e-02f, -9.93473381e-02f, -2.38218337e-01f,
  4.32394356e-01f, -2.78199732e-01f, 3.75767827e-01f, 1.53267920e-01f, -1.19073153e-01f, -2.03708813e-01f, -2.49483287e-01f, -3.59429419e-02f, 9.49890539e-02f, 8.80751237e-02f,
  -1.82686195e-01f, 8.99048150e-02f, 2.24997789e-01f, 7.68101066e-02f, 8.09437130e-03f, 1.80261582e-01f, 2.54473805e-01f, 4.09698635e-01f, 2.16284648e-01f, -1.47592142e-01f,
  -1.54752403e-01f, 2.84459684e-02f, 8.28353241e-02f, 4.50277179e-02f, 1.18222281e-01f, 9.07681435e-02f, 3.71273421e-02f, -1.58579703e-02f, -6.71869963e-02f, 4.17175651e-01f,
  2.64993548e-01f, -9.17903781e-02f, 1.25261039e-01f, 2.39499602e-02f, 1.31318159e-02f, 1.38416767e-01f, 1.32070705e-01f, 9.06505585e-02f, 5.56854941e-02f, 1.12307452e-01f,
  -7.09089488e-02f, 6.03437982e-02f, 9.10817832e-02f, 1.26594433e-03f, -1.23623991e-02f, 4.24013399e-02f, 5.42623326e-02f, 1.41859204e-01f, 2.11833715e-01f, 2.90315133e-03f,
  7.22256824e-02f, -1.85515713e-02f, 3.98849044e-03f, -6.38440102e-02f, 3.19298953e-02f, 6.38808236e-02f, -8.54818821e-02f, 2.65591815e-02f, 1.12164728e-01f, 2.17198342e-01f,
  -1.94696374e-02f, 1.14039600e-01f, -1.55653991e-02f, 1.86683219e-02f, 4.41176444e-02f, 6.74711913e-03f, 4.69270647e-02f, -1.76907890e-02f, 6.58205822e-02f, -2.43430515e-03f,
  2.46574674e-02f, 3.50716524e-02f, 1.45768207e-02f, 4.25713100e-02f, 4.53777611e-02f, 6.15294203e-02f, 3.39258723e-02f, 2.55046040e-02f, -5.74951693e-02f, 9.77457166e-02f,
  7.63497874e-02f, 5.26949344e-03f, -3.89871094e-03f, 6.88384324e-02f, -5.19885775e-03f, 7.48906806e-02f, 1.45979738e-02f, -3.43941487e-02f, -5.78089394e-02f, 1.20787667e-02f,
  1.20282315e-01f, 2.94986423e-02f, 2.44189963e-01f, 6.68124855e-02f, 1.55770574e-02f, 2.09468156e-02f, 7.11653531e-02f, 8.04878324e-02f, 5.33517152e-02f, 9.13249478e-02f,
  6.34039938e-02f, 4.93806452e-02f, 4.58741225e-02f, 1.37495771e-01f, 1.02279030e-01f, 9.28850397e-02f, -4.99025583e-02f, 2.36490324e-01f, 9.63784531e-02f, 4.55484204e-02f,
  2.74287537e-02f, 1.05822220e-01f, 1.44787043e-01f, 1.94162726e-01f, 5.50253578e-02f, 1.49910524e-01f, 1.64280921e-01f, 1.29319891e-01f, 1.33084238e-01f, 1.79403350e-01f,
  -2.14484975e-01f, 1.73623636e-01f, 7.58631825e-02f, 3.79079543e-02f, 1.31151408e-01f, 2.07810074e-01f, 4.02732849e-01f, 3.15419286e-02f, -1.80518538e-01f, -5.07975854e-02f,
  -1.96083322e-01f, -3.25416565e-01f, -3.05255085e-01f, -3.50215226e-01f, -1.57935843e-01f, 2.54568815e-01f, 2.14274779e-01f, -2.20289588e-01f, -2.73940772e-01f, -1.46131277e-01f,
  -3.59681547e-02f, -1.47620752e-01f, -3.43507320e-01f, -1.65045723e-01f, -7.95922652e-02f, -1.47603050e-01f, -5.73212132e-02f, 4.75838259e-02f, 1.12133719e-01f, 1.41449958e-01f,
  -1.84472665e-01f, -7.61870593e-02f, -1.71943560e-01f, -3.43021095e-01f, -2.39979640e-01f, -2.98714489e-01f, -2.21069872e-01f, -2.49657661e-01f, -1.98424891e-01f, -1.70863211e-01f,
  -2.03510210e-01f, -1.99556187e-01f, -1.86597645e-01f, -1.80400789e-01f, -1.33983165e-01f, -1.69302195e-01f, -1.04374617e-01f, -1.94093481e-01f, -2.88017869e-01f, -2.72547394e-01f,
  -1.08355798e-01f, -3.93829383e-02f, -1.48911476e-01f, -1.45108595e-01f, -1.28968388e-01f, -1.52737334e-01f, -2.33004704e-01f, -1.99081048e-01f, -2.20274627e-01f, -3.02698523e-01f,
  8.21051225e-02f, -2.03774776e-02f, 1.35891676e-01f, 9.69588608e-02f, 9.01860744e-02f, 5.98186590e-02f, 8.92248079e-02f, 1.30201086e-01f, 3.48693840e-02f, 3.88370007e-02f,
  5.65144941e-02f, 1.22480169e-01f, 2.89573949e-02f, 3.14527117e-02f, 1.49113368e-02f, 5.01697585e-02f, 1.58152074e-01f, 1.11530302e-03f, -3.98890004e-02f, 4.87301759e-02f,
  4.18481119e-02f, 2.87140496e-02f, 6.10985197e-02f, 7.74400085e-02f, 8.96071047e-02f, -3.10635776e-03f, 7.89149255e-02f, 8.50858465e-02f, -3.81306186e-02f, 1.00000180e-01f,
  -2.26669222e-01f, -1.23440333e-01f, -6.75449818e-02f, -1.84412956e-01f, -2.10582286e-01f, -1.83861196e-01f, -2.07046852e-01f, -2.23208666e-01f, -1.76854879e-01f, -1.29540712e-01f,
  -1.68328092e-01f, -1.92551166e-01f, -1.49604708e-01f, -1.32202536e-01f, -1.30421728e-01f, -8.96129608e-02f, -8.27226117e-02f, -4.31388579e-02f, -1.39256179e-01f, -1.45575047e-01f,
  -1.19248345e-01f, -4.15702201e-02f, -5.95328435e-02f, -5.05825393e-02f, -1.39677256e-01f, -1.17402464e-01f, -1.59748420e-01f, -1.48612484e-01f, -2.34382555e-01f, -2.03204960e-01f
};

// L0_fan_Wp_bar (Shape: 8 x 120)
const int L0_fan_Wp_bar_rows = 8;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  1.02118874e+00f, 6.73984349e-01f, -2.93769062e-01f, 1.86586842e-01f, -5.70275962e-01f, -3.68253171e-01f, 4.46367823e-02f, -7.98195153e-02f, -1.80902436e-01f, 2.19941691e-01f,
  -2.23636210e-01f, -4.29907948e-01f, -1.54642060e-01f, -2.99313217e-01f, 1.19627871e-01f, 7.94423819e-02f, -1.11302532e-01f, 3.34363617e-02f, -3.15033138e-01f, -2.47545153e-01f,
  -9.59947258e-02f, 2.55257845e-01f, 3.90638232e-01f, 5.38784601e-02f, 1.69913068e-01f, -3.03402394e-01f, -8.42305049e-02f, 1.10609159e-01f, -8.72489661e-02f, 4.23013002e-01f,
  2.65989006e-01f, 3.50922287e-01f, -2.52445757e-01f, -6.67111995e-03f, -9.80337802e-03f, 1.08984299e-01f, 4.00553606e-02f, 1.34101674e-01f, -3.13440077e-02f, -3.52229066e-02f,
  -3.03687062e-02f, -4.67374064e-02f, -1.40656158e-01f, -1.65358916e-01f, 9.63348243e-03f, 1.91724242e-03f, 7.30152652e-02f, 1.69650182e-01f, 9.84696224e-02f, 3.82555611e-02f,
  -1.83605507e-01f, 1.73414033e-02f, -2.96912845e-02f, -1.77726746e-01f, 9.91966669e-03f, -2.14730278e-01f, -3.72124277e-02f, 1.64354190e-01f, -6.95110485e-02f, 1.86467826e-01f,
  -1.70051217e-01f, 2.08571227e-03f, -8.45628604e-02f, -9.66563299e-02f, -4.57693152e-02f, -1.16438352e-01f, -5.24844453e-02f, -2.49816924e-02f, -9.12372991e-02f, -4.69513237e-02f,
  1.20635033e-02f, -5.71036413e-02f, -8.89700502e-02f, 1.05432635e-02f, -1.55269103e-02f, -2.88856477e-02f, 3.35011184e-02f, 6.28286973e-02f, 4.65073111e-03f, 6.67087268e-03f,
  -8.27441141e-02f, 4.67187027e-03f, 5.64152114e-02f, 1.34219863e-02f, 1.53510813e-02f, -1.48583483e-02f, -5.06528988e-02f, -1.16886839e-01f, 6.56401515e-02f, 1.36290103e-01f,
  -1.28001437e-01f, -4.82744217e-01f, 1.30089372e-01f, 1.07919373e-01f, 1.85175650e-02f, 8.20548311e-02f, 8.98903236e-03f, 5.20442054e-02f, 1.09357268e-01f, 9.61605757e-02f,
  -1.00256644e-01f, 2.03103758e-02f, 3.62928547e-02f, 3.09602208e-02f, -6.80881962e-02f, -5.24094366e-02f, 1.36880696e-01f, 4.47147749e-02f, 9.18298773e-03f, 1.84558466e-01f,
  4.18752879e-02f, -1.55938283e-01f, -5.70714287e-02f, 1.02085397e-01f, -3.06378193e-02f, -8.64016637e-02f, -1.46543965e-01f, -1.51002258e-02f, -1.63788110e-01f, 1.21688649e-01f,
  -3.68829876e-01f, -4.31622624e-01f, -4.72300462e-02f, -1.51485473e-01f, 8.73944238e-02f, -4.94221738e-03f, -8.57569993e-01f, -1.66882023e-01f, 3.83492798e-01f, -7.06307709e-01f,
  -2.96250373e-01f, 3.07082444e-01f, -1.06501766e-01f, -4.19429243e-02f, -5.53143442e-01f, -9.37649906e-01f, -4.46079552e-01f, -2.97607556e-02f, 1.16325594e-01f, -3.72138470e-02f,
  -9.67934057e-02f, 8.23249593e-02f, 2.57131457e-01f, 2.33385444e-01f, 8.46238993e-03f, 9.90935862e-02f, -8.13795105e-02f, 3.25585925e-03f, -2.81829357e-01f, -3.53711367e-01f,
  -4.21395659e-01f, -2.21428834e-02f, 1.18897453e-01f, -1.19520180e-01f, 1.17498711e-02f, -7.76040480e-02f, 1.84994619e-02f, 2.74985641e-01f, 1.96330294e-01f, 6.61701290e-03f,
  -8.19287300e-02f, -1.33697897e-01f, 1.11535542e-01f, -4.83646430e-02f, -1.27291709e-01f, -2.33283073e-01f, 2.58417189e-01f, 2.26380989e-01f, 4.71864566e-02f, -1.83881685e-01f,
  -1.30120143e-01f, -1.61652133e-01f, 6.43850043e-02f, -2.11046964e-01f, -1.56687170e-01f, 1.40662953e-01f, 2.00714007e-01f, 2.40880132e-01f, 2.16404095e-01f, -6.01807889e-03f,
  -9.65792984e-02f, -5.30070902e-05f, 3.77661698e-02f, 1.00461701e-02f, 2.03668270e-02f, 4.49590273e-02f, 4.04639207e-02f, -2.08441511e-01f, 4.97842357e-02f, -4.66532409e-02f,
  2.59109400e-02f, 8.17472953e-03f, -2.41712108e-02f, 4.40846868e-02f, 3.63119841e-02f, -6.84135407e-03f, -9.09938291e-02f, -9.63691846e-02f, 7.22410455e-02f, -3.76800038e-02f,
  4.19540666e-02f, 1.05014123e-01f, -7.64058763e-03f, 3.64910513e-02f, -2.20023602e-01f, -1.09206490e-01f, 9.41394642e-02f, -1.47197112e-01f, 7.93690458e-02f, 9.94672477e-02f,
  6.56489730e-02f, 2.08964452e-01f, -2.34420240e-01f, -2.53741723e-02f, 5.74938767e-03f, 5.35847992e-02f, 5.73478676e-02f, -8.03381875e-02f, 1.13967009e-01f, 8.03860202e-02f,
  7.96460658e-02f, -3.93564068e-02f, 5.41708507e-02f, 7.76829869e-02f, -1.19291611e-01f, -6.74719736e-02f, -2.54170418e-01f, -5.94621189e-02f, -9.54893511e-03f, 2.01451212e-01f,
  -9.61883664e-02f, -3.70864749e-01f, -2.56603837e-01f, -1.62590101e-01f, -3.28972377e-02f, -7.35793114e-02f, -1.03645965e-01f, -7.75386542e-02f, -3.53755921e-01f, -5.32974839e-01f,
  -3.02693993e-01f, 3.72527927e-01f, -1.73824653e-02f, -2.68264720e-03f, 2.46886000e-01f, 7.33285099e-02f, 1.11977473e-01f, 1.37895107e-01f, 8.36383402e-02f, 1.63050979e-01f,
  2.56264925e-01f, -2.79801309e-01f, -4.38751906e-01f, -4.18357968e-01f, -4.49704051e-01f, -3.65986496e-01f, -4.52079594e-01f, -7.87230253e-01f, -7.73436010e-01f, -1.53427005e-01f,
  -3.19477528e-01f, -3.57007384e-01f, -3.44907224e-01f, -2.11741254e-01f, 1.71062648e-01f, -2.73316443e-01f, -8.69730785e-02f, -3.78894471e-02f, 5.05536832e-02f, -1.44810557e-01f,
  -1.16467379e-01f, 3.30949008e-01f, -1.30511045e-01f, -1.71637431e-01f, 9.80964750e-02f, -1.45903789e-02f, -1.26015255e-02f, -1.79509316e-02f, 5.50201796e-02f, 4.25391681e-02f,
  1.41847625e-01f, 6.31300658e-02f, 6.85069636e-02f, -1.54557135e-02f, 6.66449070e-02f, 4.49739993e-02f, 1.24527276e-01f, 1.34801841e-03f, -1.03361286e-01f, 2.50170767e-01f,
  9.90426764e-02f, 1.80681080e-01f, 2.83718169e-01f, 2.31973290e-01f, 2.07033411e-01f, -4.88055348e-02f, 2.81418800e-01f, 3.40016246e-01f, 2.56972015e-01f, 1.19978629e-01f,
  -5.63737974e-02f, -2.09943429e-01f, -1.42884685e-03f, 8.66552666e-02f, -3.94787500e-03f, 1.65298209e-02f, -1.65038794e-01f, -1.23196021e-01f, -7.77617693e-02f, -6.76142611e-03f,
  8.39134529e-02f, 1.27565917e-02f, -1.24918148e-02f, -5.56124374e-02f, -2.14880612e-02f, 1.18490249e-01f, -2.33794525e-02f, 3.44616943e-03f, 6.89042360e-02f, 9.67007056e-02f,
  3.55817527e-02f, 1.25615507e-01f, -8.85096490e-02f, -4.55329902e-02f, 1.62588283e-01f, 1.14169128e-01f, 6.74620271e-03f, 2.58119800e-03f, 2.47504488e-02f, 2.13124007e-02f,
  -1.89481542e-01f, -1.11462981e-01f, -1.14300929e-01f, 7.17135146e-03f, -5.17370515e-02f, 1.49793729e-01f, 7.24099055e-02f, -6.40572160e-02f, -1.14854597e-01f, 2.98951585e-02f,
  9.02866423e-02f, -1.36464201e-02f, -7.29330555e-02f, -5.88575192e-03f, -8.66859406e-02f, 7.72724375e-02f, 1.70774639e-01f, -1.05178148e-01f, 7.92911798e-02f, 2.23931879e-01f,
  4.76802103e-02f, -3.83822322e-02f, -2.33674929e-01f, -9.44214314e-02f, 3.47153447e-03f, -3.19664240e-01f, -9.55518037e-02f, 2.78384592e-02f, -1.24619015e-01f, -1.14609160e-01f,
  2.94224828e-01f, -1.94735080e-01f, 4.61184233e-01f, 8.41084272e-02f, 2.19359040e-01f, 4.12058771e-01f, 2.48236775e-01f, 1.40052717e-02f, -2.52963640e-02f, 6.95929304e-02f,
  6.98955134e-02f, 8.34635198e-02f, -6.14464171e-02f, -1.15068033e-01f, -9.37229320e-02f, 3.19199525e-02f, -1.06136678e-02f, 6.65391013e-02f, 3.19483787e-01f, 2.31863707e-01f,
  -1.39789715e-01f, -3.00474036e-02f, -1.24697275e-01f, -2.01950385e-03f, -1.93347275e-01f, -3.21993306e-02f, -3.38678956e-02f, -2.68564850e-01f, -3.12304407e-01f, -2.70125538e-01f,
  4.67686146e-01f, 6.88838363e-02f, 2.58747131e-01f, -9.27235559e-02f, 4.09967676e-02f, 2.89619863e-02f, 9.33172777e-02f, 1.65592059e-01f, 7.36976117e-02f, 1.90954089e-01f,
  -8.54875594e-02f, 7.84896221e-03f, -6.08537421e-02f, 1.18522458e-02f, -4.60173301e-02f, -3.16088684e-02f, -1.11782119e-01f, -8.31159651e-02f, -4.42785397e-02f, 1.46393567e-01f,
  -1.02029674e-01f, 6.05157167e-02f, 1.05456434e-01f, 6.87766895e-02f, -1.13640185e-02f, 2.33512707e-02f, 7.40167350e-02f, -9.49757057e-04f, -3.82293724e-02f, 8.58558267e-02f,
  1.61584005e-01f, -4.55309860e-02f, -1.04989531e-02f, 1.15339078e-01f, 6.03454597e-02f, -6.94933832e-02f, -6.25990033e-02f, -3.07411663e-02f, -1.85644887e-02f, -1.03111453e-01f,
  -1.19227245e-01f, 4.20935377e-02f, 1.06156103e-01f, -1.25420503e-02f, 1.29918069e-01f, -4.01492268e-02f, -9.24441516e-02f, 7.66282156e-03f, 5.37665607e-03f, 1.24893766e-02f,
  3.09087639e-03f, 1.03674270e-02f, -4.04534079e-02f, -3.21323089e-02f, -1.21525131e-01f, -8.40408355e-02f, 4.97377515e-02f, -6.28056994e-04f, -1.45564258e-01f, -9.35904235e-02f,
  3.55565667e-01f, 1.29561245e-01f, 8.49215090e-02f, -6.81123361e-02f, 7.68945552e-03f, -2.18478948e-01f, 1.05831623e-01f, 1.43819883e-01f, -3.25235240e-02f, 1.26278758e-01f,
  -3.80714126e-02f, -1.84451528e-02f, -7.12790191e-02f, -1.21412359e-01f, 1.52015880e-01f, 3.70073095e-02f, -5.19887619e-02f, 1.01710916e-01f, 4.60005812e-02f, 2.10016638e-01f,
  1.44293811e-02f, 1.31176353e-01f, 3.05758655e-01f, 1.52284861e-01f, 4.20804210e-02f, 2.14679852e-01f, 1.30679801e-01f, 9.58036259e-02f, 2.43369848e-01f, 1.86315760e-01f,
  7.90426135e-01f, -7.84939885e-01f, -3.74191791e-01f, -2.53293186e-01f, -2.61940628e-01f, 7.04193562e-02f, -2.92793363e-01f, 6.31411150e-02f, 9.98557210e-02f, -5.79629838e-01f,
  -3.60314310e-01f, 2.30435044e-01f, -1.70860346e-02f, 1.93513781e-01f, 3.56999516e-01f, -4.62784380e-01f, -4.00444031e-01f, 2.69654602e-01f, 8.97890389e-01f, 3.84035110e-01f,
  2.07678564e-02f, 6.95715249e-02f, 4.39064085e-01f, 2.58994907e-01f, -5.16037703e-01f, 1.17008932e-01f, -4.52851385e-01f, -1.11639448e-01f, -1.61466107e-01f, -7.03441918e-01f,
  -2.67638862e-01f, -1.07795484e-01f, 1.62748098e-01f, 4.39475887e-02f, -1.82871968e-01f, 1.02795549e-01f, 8.08180124e-02f, -1.38515681e-01f, 1.28412032e-02f, -5.83173335e-02f,
  -5.69948331e-02f, 7.26184472e-02f, 5.36585376e-02f, 7.61129940e-03f, 8.83992612e-02f, 7.29899853e-02f, -3.17161642e-02f, -1.46221323e-02f, -4.55485098e-02f, -2.27920875e-01f,
  -2.33817309e-01f, 4.00067344e-02f, 1.37500867e-01f, 8.97190273e-02f, 1.69873938e-01f, 2.53309935e-01f, -4.88477014e-02f, 1.27431959e-01f, 2.95964777e-01f, -2.15674207e-01f,
  -9.30110216e-02f, -7.34039545e-02f, -1.22404927e-02f, 5.48723117e-02f, 1.33415852e-02f, -2.13856362e-02f, -3.31001244e-02f, -4.62816618e-02f, 6.55150861e-02f, -1.12169031e-02f,
  1.58043597e-02f, -8.28351974e-02f, 1.83555931e-02f, -7.43761584e-02f, -1.60250932e-01f, -1.06954865e-01f, 1.67538170e-02f, -1.87222645e-01f, 1.38710430e-02f, 1.41868135e-03f,
  1.35749593e-01f, 7.61548132e-02f, -5.49573898e-02f, 1.37747303e-02f, -4.83879410e-02f, -4.74703535e-02f, -2.77787708e-02f, 2.66475715e-02f, -8.47270526e-03f, 4.79185358e-02f,
  -1.18694395e-01f, 9.91218537e-03f, -1.65740117e-01f, 1.45610973e-01f, -6.19203709e-02f, -4.71356511e-02f, -2.01903343e-01f, -1.61363874e-02f, -7.35185593e-02f, -5.54261776e-03f,
  1.82421843e-03f, 1.41233757e-01f, -1.43054307e-01f, -7.97902793e-02f, 1.27402365e-01f, 6.52900115e-02f, 2.97974271e-04f, 9.51589867e-02f, 9.02955309e-02f, -1.33806601e-01f,
  -1.49157345e-01f, 1.22194521e-01f, 2.19853193e-01f, -1.81077793e-02f, 1.60455823e-01f, 2.45191947e-01f, -8.60148966e-02f, -2.11133529e-02f, 1.89333692e-01f, -2.00305283e-01f,
  4.61612642e-01f, 5.97485006e-01f, 1.32680640e-01f, 2.75499970e-01f, 2.29722992e-01f, 3.48861635e-01f, 6.69095635e-01f, 2.44822443e-01f, -1.94866061e-01f, 8.91371146e-02f,
  2.13025495e-01f, -6.90423250e-02f, 8.10146856e-04f, 4.92837988e-02f, 1.56328321e-01f, 1.99566111e-01f, -3.72818857e-02f, -1.01827830e-01f, -2.70706743e-01f, 1.98872145e-02f,
  -5.68455383e-02f, 1.17411263e-01f, 2.70053837e-02f, -1.34989500e-01f, 1.70293991e-02f, -2.24554181e-01f, 1.46939248e-01f, 2.51747012e-01f, 1.41589582e-01f, -2.06723049e-01f,
  3.14208627e-01f, 5.34154356e-01f, -2.94662476e-01f, -1.92320317e-01f, -9.14136022e-02f, -1.31016240e-01f, -9.55550298e-02f, -6.15174063e-02f, 4.03206497e-02f, -1.53268814e-01f,
  3.48389819e-02f, -7.57233649e-02f, 1.33098245e-01f, -9.22901407e-02f, -5.07463999e-02f, -1.04881175e-01f, -3.90287042e-02f, 1.13571018e-01f, 1.05724387e-01f, 4.63985130e-02f,
  -1.58432916e-01f, 2.28006262e-02f, 1.93654224e-01f, 9.67569575e-02f, 1.97917864e-01f, -9.51066762e-02f, 6.91201612e-02f, -6.71985075e-02f, 6.80772588e-02f, -7.35314935e-02f,
  -5.58445342e-02f, 4.36124243e-02f, 1.19571753e-01f, -3.55887264e-02f, -3.39018255e-02f, -3.64050232e-02f, -8.48489478e-02f, 6.61200881e-02f, 7.60577917e-02f, -9.83902067e-03f,
  -1.81537554e-01f, 4.64025997e-02f, -4.70607243e-02f, 1.72933172e-02f, -1.19527511e-01f, 7.83155560e-02f, -6.15340658e-02f, 7.93804899e-02f, 1.49331465e-01f, 1.46572515e-01f,
  1.35557413e-01f, 1.02813862e-01f, -1.16703175e-02f, -3.16370232e-03f, -1.27829209e-01f, -1.95790783e-01f, -2.27415800e-01f, -4.11560759e-03f, -7.02279434e-02f, 1.54912565e-02f,
  -1.17299385e-01f, 3.58969331e-01f, -7.96218812e-02f, 3.71297784e-02f, 6.61952719e-02f, -4.98568416e-02f, 1.55334339e-01f, 1.41086668e-01f, 4.61411737e-02f, 2.11414918e-02f,
  9.48214605e-02f, -7.19844252e-02f, 1.61508381e-01f, 3.71898040e-02f, -1.80913270e-01f, -9.55714881e-02f, -1.03646383e-01f, -3.60569963e-03f, 1.59798846e-01f, -1.94385406e-02f,
  -6.71937689e-02f, -2.46353209e-01f, -1.63177416e-01f, -2.32562229e-01f, -3.52265351e-02f, -1.66214824e-01f, -6.29013553e-02f, -1.86607182e-01f, -5.97352050e-02f, -2.84707934e-01f,
  -1.36570668e+00f, 3.03204685e-01f, -1.65245727e-01f, -1.03910911e+00f, -3.89269263e-01f, -4.19282377e-01f, -5.61102554e-02f, -1.47451311e-01f, -3.54701042e-01f, -1.73516437e-01f,
  -1.55762628e-01f, -2.78872758e-01f, -1.15306199e-01f, 8.52656364e-02f, -4.29871172e-01f, -2.44699791e-01f, -3.88038278e-01f, -6.75192177e-01f, -5.17805874e-01f, -3.34027380e-01f,
  -1.91182971e-01f, -6.91454709e-01f, -7.94330716e-01f, -8.76610950e-02f, -1.91970728e-02f, -8.28038007e-02f, -8.64491761e-02f, -3.85208100e-01f, 1.10827722e-02f, -2.17018992e-01f,
  1.77638620e-01f, -1.72458559e-01f, -2.02471375e-01f, -2.09510013e-01f, -1.71337858e-01f, -8.67883489e-02f, 1.26659041e-02f, -1.49455056e-01f, 7.77749941e-02f, 1.13920709e-02f,
  -2.74367690e-01f, -6.28207400e-02f, -1.50898159e-01f, -2.81540640e-02f, -1.58904672e-01f, -1.24816075e-01f, -7.09480494e-02f, -1.03768848e-01f, 1.65097006e-02f, 3.31745446e-01f,
  2.85323560e-01f, -1.14746369e-01f, 1.73517317e-02f, 1.82983980e-01f, 5.74358068e-02f, -1.69612065e-01f, 3.40318471e-01f, 2.10759595e-01f, 1.73256740e-01f, 2.04135552e-01f,
  -3.54647972e-02f, 8.61862600e-02f, -5.54584898e-03f, 8.13094303e-02f, -7.86420181e-02f, -6.21920303e-02f, -7.99593106e-02f, -8.79184753e-02f, -1.73123069e-02f, 1.82048231e-02f,
  2.86773853e-02f, -3.17682140e-02f, -6.88424706e-02f, -7.83085972e-02f, -5.10352142e-02f, -2.43589789e-01f, -6.80649132e-02f, 8.62447247e-02f, 5.34636267e-02f, -2.13262275e-01f,
  -8.09624642e-02f, 5.57761863e-02f, -3.83684970e-02f, 9.93895680e-02f, -1.10630050e-01f, -1.00538954e-01f, -9.23347548e-02f, 7.30756577e-03f, 5.73307797e-02f, -3.64165939e-02f,
  1.39883369e-01f, -3.10634494e-01f, -5.13059199e-02f, 7.67879859e-02f, -8.46524164e-03f, -4.94687334e-02f, -1.09749027e-02f, -1.20304562e-02f, -2.72629298e-02f, 7.11704120e-02f,
  -3.92121375e-02f, -1.66634377e-02f, 7.11525157e-02f, 7.93838575e-02f, -1.61364242e-01f, 2.43812334e-02f, 2.33621243e-02f, -5.24044856e-02f, 1.13060504e-01f, 8.54664594e-02f,
  8.51982757e-02f, 9.26422849e-02f, 5.06945215e-02f, 2.52431631e-01f, 2.44341791e-01f, -3.83234359e-02f, 2.24386618e-01f, 2.40286857e-01f, 1.10390924e-01f, 4.42427367e-01f,
  3.84397417e-01f, 7.44322017e-02f, 3.71421576e-01f, 4.50350195e-01f, 2.65075207e-01f, 3.48306924e-01f, 3.67872775e-01f, 2.40071580e-01f, 2.50497371e-01f, 1.45928219e-01f,
  -2.56968625e-02f, 7.77246207e-02f, 1.49338812e-01f, 1.61027834e-01f, 2.27337718e-01f, 3.01910341e-01f, 3.85361642e-01f, 1.67926416e-01f, 1.76198244e-01f, 2.48744071e-01f,
  2.52270728e-01f, -3.41577316e-03f, -5.32535575e-02f, 1.17089212e-01f, 1.20426096e-01f, 8.67010057e-02f, -1.51004139e-02f, -3.43329832e-02f, 8.99208896e-03f, 1.65426195e-01f,
  -1.29626781e-01f, 1.23069867e-01f, -6.94114715e-02f, -1.67511940e-01f, -2.43900597e-01f, -1.85325354e-01f, -2.52846777e-02f, -1.70359641e-01f, -1.26816183e-01f, -5.86008839e-02f,
  -2.01526299e-01f, -2.08511114e-01f, -4.97050285e-02f, -6.08365089e-02f, -4.66473475e-02f, -1.27782747e-01f, 3.04511953e-02f, 1.29403323e-01f, 4.93691601e-02f, -1.09436765e-01f,
  8.17268714e-02f, 9.59553793e-02f, -4.97494452e-02f, 8.73300508e-02f, 9.57458243e-02f, -3.77329416e-03f, 4.38017324e-02f, 7.53889456e-02f, -6.83158562e-02f, 1.81640789e-01f,
  1.91021502e-01f, 1.36277944e-01f, 1.10928610e-01f, 1.72358468e-01f, 4.63634804e-02f, 4.60249223e-02f, 2.78429128e-02f, 5.82329966e-02f, 2.96020895e-01f, 8.49961266e-02f,
  -3.88073325e-02f, -4.64090183e-02f, 1.15738630e-01f, -4.28088829e-02f, 8.03434029e-02f, 4.20884974e-02f, -3.57991830e-02f, -8.84551480e-02f, -8.52253810e-02f, -2.53792018e-01f,
  -9.02038291e-02f, 4.14898433e-02f, -5.65077439e-02f, 7.54294470e-02f, -5.78713417e-02f, 2.01777428e-01f, 5.46423206e-03f, -6.19085170e-02f, -3.47289070e-02f, -1.20201692e-01f,
  -5.23847282e-01f, -1.37431286e-02f, 2.27562971e-02f, -7.68584339e-03f, 2.24696882e-02f, -1.24802798e-01f, 1.05164818e-01f, -6.47701770e-02f, -1.95418119e-01f, -4.90481369e-02f,
  -1.89366668e-01f, -5.70416227e-02f, 2.74823345e-02f, 2.53857784e-02f, -4.39945236e-02f, -1.26488358e-02f, -3.26009877e-02f, 2.15334669e-01f, -4.14315611e-02f, -2.09197234e-02f,
  -5.07632457e-03f, 1.40630066e-01f, -3.45005654e-02f, 2.51561403e-01f, 1.67552784e-01f, 5.55536337e-02f, -6.06825389e-03f, 2.55832151e-02f, 1.83540080e-02f, -1.56069128e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 8)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 8;
const float L0_fan_Bp_bar_data[] = {
  6.85384929e-01f, 3.01380217e-01f, 6.62106216e-01f, 1.51408285e-01f, 3.33302885e-01f, 4.88324612e-01f, 1.01473260e+00f, 4.08765495e-01f
};

// L1_fan_Wp (Shape: 12 x 32)
const int L1_fan_Wp_rows = 12;
const int L1_fan_Wp_cols = 32;
const float L1_fan_Wp_data[] = {
  -2.47626722e-01f, -4.11448270e-01f, 2.08121806e-01f, 6.78351074e-02f, -7.91213289e-02f, -4.92424751e-03f, 2.52974331e-01f, -2.12078542e-02f, -1.79980099e-01f, 1.27590680e-02f,
  -1.04373425e-01f, -7.62126967e-02f, 5.53726435e-01f, 6.65321723e-02f, 7.41766542e-02f, -2.89789051e-01f, 8.05976987e-02f, 3.69504184e-01f, 1.77955180e-01f, 1.05133072e-01f,
  -2.38754645e-01f, -1.48476297e-02f, -4.43525100e-03f, -8.63554627e-02f, 2.22176701e-01f, 3.43409568e-01f, 4.87096384e-02f, -1.62376851e-01f, 1.91709742e-01f, -4.89307381e-02f,
  -1.37660682e-01f, 1.02065183e-01f, -1.83063030e-01f, 2.40850702e-01f, 5.71982302e-02f, -4.34867032e-02f, 1.61138743e-01f, 3.47964577e-02f, -1.16689965e-01f, -7.01563060e-02f,
  1.15220733e-01f, 5.59755377e-02f, 3.25350761e-02f, 4.28672954e-02f, 1.99200436e-02f, 9.63946618e-03f, -1.06696926e-01f, 4.96547259e-02f, -1.45285845e-01f, -2.97772914e-01f,
  -3.11582595e-01f, 1.22158557e-01f, 1.33741572e-01f, 3.45368013e-02f, -1.17940001e-01f, -2.66008116e-02f, 1.00103961e-02f, -2.67069370e-01f, 1.84549853e-01f, 1.53397426e-01f,
  -3.24005097e-01f, 2.43670523e-01f, 1.30301878e-01f, -2.59166062e-01f, -1.70003951e-01f, 1.50455400e-01f, 1.50491549e-02f, -1.00286104e-01f, -6.77196831e-02f, 7.80096352e-02f,
  7.17338249e-02f, 6.34122491e-02f, 9.05400887e-02f, 5.74908368e-02f, 3.17554250e-02f, 3.93434661e-03f, 1.21205494e-01f, 8.35256726e-02f, 6.50308654e-02f, 2.46739879e-01f,
  2.50212789e-01f, -3.77596229e-01f, -1.50175378e-01f, -1.06398009e-01f, -3.63013633e-02f, 4.91796769e-02f, 5.45442030e-02f, 3.49051319e-02f, -4.29847449e-01f, 1.76000610e-01f,
  -3.31533581e-01f, -1.09312115e-02f, 3.23361129e-01f, -4.17107254e-01f, 1.95582077e-01f, 3.70548256e-02f, -1.31049575e-02f, 1.01576500e-01f, 4.22210544e-02f, -2.71483243e-01f,
  -3.30805480e-02f, -2.13749558e-01f, 1.48135960e-01f, 1.93583831e-01f, 2.61952132e-02f, 8.02912861e-02f, -7.13737085e-02f, 9.76610333e-02f, -2.26961866e-01f, 5.15705310e-02f,
  -1.78220030e-02f, 2.24346757e-01f, 3.28793615e-01f, 1.86895251e-01f, 3.69647257e-02f, -3.39666218e-01f, 1.02533877e-01f, 1.74010303e-02f, 2.47315347e-01f, 5.92786632e-02f,
  3.21777500e-02f, 2.69271553e-01f, -3.87357235e-01f, 1.31360397e-01f, -6.91853464e-02f, -2.27932379e-01f, -6.12561069e-02f, -4.22898419e-02f, -2.12982576e-02f, 8.23750421e-02f,
  4.27914634e-02f, 2.00861432e-02f, 9.83784646e-02f, 1.77336648e-01f, 2.67350823e-01f, 1.34309232e-01f, 1.13787934e-01f, 5.89962397e-03f, -2.59993281e-02f, 1.74074899e-02f,
  -5.44735193e-02f, 2.07645163e-01f, -2.72329420e-01f, 1.73010185e-01f, 3.37586435e-03f, -8.25065747e-02f, -2.46606708e-01f, -2.20778465e-01f, 1.65712699e-01f, -3.40276748e-01f,
  -5.12432791e-02f, -1.74123757e-02f, 9.58357528e-02f, -4.81791347e-01f, -2.41173133e-02f, 2.87072539e-01f, 3.31886441e-01f, 3.24233547e-02f, 1.43556431e-01f, -1.35959476e-01f,
  -8.22360069e-02f, 1.54456034e-01f, -7.47201517e-02f, 1.89927667e-01f, -9.54714045e-02f, 1.76541731e-01f, -2.33625714e-02f, -3.91885713e-02f, 1.35482997e-01f, 5.06755672e-02f,
  2.21964374e-01f, 4.75850701e-02f, 3.61201823e-01f, 1.46374255e-01f, -8.34530802e-05f, 9.46167558e-02f, -7.75113180e-02f, -5.60482919e-01f, -2.88350731e-01f, 1.57461315e-01f,
  -1.94591433e-02f, -3.65041532e-02f, -1.57602429e-01f, 8.43333255e-04f, -3.84526551e-01f, 1.26500905e-01f, -7.14397803e-02f, 7.33202919e-02f, 4.25202668e-01f, -2.10808590e-01f,
  3.55385058e-02f, -9.09343883e-02f, 2.04161242e-01f, 4.22348678e-02f, 2.94851929e-01f, 2.33342454e-01f, -7.93135837e-02f, 3.56681608e-02f, 6.02223165e-02f, 5.16213924e-02f,
  1.12221457e-01f, -6.31191954e-02f, 3.39493267e-02f, -3.25398333e-02f, 4.11574662e-01f, 3.00367266e-01f, -2.79553026e-01f, -3.33157778e-01f, -2.20786050e-01f, 1.36921659e-01f,
  2.61832356e-01f, 2.80264318e-01f, -5.09249792e-02f, -2.01348022e-01f, 1.39557928e-01f, -4.23153713e-02f, -6.04656944e-03f, 1.03847168e-01f, -2.33266190e-01f, -9.72803533e-02f,
  -7.35525861e-02f, -1.80316672e-01f, 7.66430572e-02f, -1.71577603e-01f, 1.27385810e-01f, -9.80392098e-02f, 1.26522973e-01f, 7.03647360e-02f, -1.76475830e-02f, 3.99488630e-03f,
  1.98929563e-01f, -9.94451940e-02f, 4.78345975e-02f, 4.40500118e-02f, 5.60194813e-02f, 1.82194829e-01f, 4.26294319e-02f, 1.79482982e-01f, -2.50759244e-01f, -4.55031097e-01f,
  -2.08367929e-01f, 3.09437662e-01f, 1.49947107e-01f, 3.85261714e-01f, 1.00364462e-01f, -2.37578750e-01f, 9.13620144e-02f, -1.40770394e-02f, 2.37272844e-01f, 2.14249566e-01f,
  -3.54534894e-01f, 2.25173652e-01f, 2.87174210e-02f, 9.02784616e-02f, -7.62500763e-02f, -4.26879935e-02f, -5.70242144e-02f, -9.38343524e-04f, -2.83998042e-01f, -1.30521148e-01f,
  5.78087606e-02f, -1.10644415e-01f, 2.73217224e-02f, -2.79689461e-01f, -1.63486034e-01f, 7.12497458e-02f, 7.12947473e-02f, -3.94034423e-02f, -3.25219065e-01f, -1.24131709e-01f,
  -1.29116982e-01f, 2.29347348e-01f, 1.62321463e-01f, -8.92022699e-02f, -8.51423442e-02f, -2.99930394e-01f, -2.05053389e-03f, -5.15826643e-02f, -9.71790329e-02f, 4.89404835e-02f,
  9.60955173e-02f, -3.26425493e-01f, -9.26494151e-02f, 2.38857776e-01f, -1.32571176e-01f, 7.80198202e-02f, -5.25566041e-02f, 3.11644990e-02f, 1.01616099e-01f, 8.06214695e-04f,
  -1.13984138e-01f, -6.98201805e-02f, -3.70578952e-02f, -1.61634058e-01f, 1.15380868e-01f, -2.56721348e-01f, -4.63984199e-02f, 4.05129716e-02f, 1.92840055e-01f, -4.29472439e-02f,
  -1.18584149e-01f, -1.22266494e-01f, -2.53152519e-01f, -1.78374723e-01f, -1.82176545e-01f, -3.63853902e-01f, 2.22982779e-01f, 1.02774166e-01f, 1.43821105e-01f, -4.28312831e-02f,
  -5.24455048e-02f, 1.36169001e-01f, 4.96830672e-01f, -3.64083499e-01f, -2.31440797e-01f, -2.34761648e-02f, -1.31009191e-01f, 1.07253268e-01f, 5.79900891e-02f, 1.42637074e-01f,
  7.85005093e-03f, -4.61612791e-02f, 5.65576665e-02f, -8.25359523e-02f, -3.15379649e-02f, -1.33283824e-01f, -2.98772931e-01f, -4.20751013e-02f, 3.15026268e-02f, 3.73653919e-02f,
  6.93157911e-02f, -7.80385882e-02f, 9.54082459e-02f, -2.56363243e-01f, 3.86711329e-01f, -4.47279453e-01f, -1.50276542e-01f, 5.23114279e-02f, 2.39872903e-01f, 4.07765538e-01f,
  -6.51334599e-02f, 3.98106307e-01f, -1.33609428e-04f, -8.77645314e-02f, -2.56653726e-01f, 1.34089366e-01f, 6.99025840e-02f, 1.37948737e-01f, -5.31041980e-01f, -9.41044465e-02f,
  2.84742832e-01f, -1.59569159e-02f, 1.17308356e-01f, -6.45397156e-02f, -7.30717462e-03f, -9.60133821e-02f, 4.03994881e-02f, -2.34709665e-01f, 1.12634420e-01f, 1.87146872e-01f,
  3.56446058e-02f, 8.17920715e-02f, -9.65914205e-02f, -2.14130804e-03f, -2.13717490e-01f, -1.52116179e-01f, 6.09688424e-02f, -5.08762598e-02f, 1.17321409e-01f, 2.67796278e-01f,
  1.40623614e-01f, -1.51959658e-01f, -5.47878295e-02f, 8.61813873e-02f, 1.02947839e-01f, -3.57389823e-02f, 2.64622957e-01f, -3.81250903e-02f, -1.24242539e-02f, 7.07757398e-02f,
  -6.91632479e-02f, -2.18406036e-01f, -2.83716559e-01f, 1.87865525e-01f
};

// L1_fan_Wp_bar (Shape: 8 x 32)
const int L1_fan_Wp_bar_rows = 8;
const int L1_fan_Wp_bar_cols = 32;
const float L1_fan_Wp_bar_data[] = {
  -4.51021373e-01f, 1.07648343e-01f, 3.54835838e-01f, -1.62417199e-02f, 1.93104878e-01f, -7.89185520e-03f, -1.76412836e-01f, 1.52973548e-01f, 5.53416349e-02f, 1.36445463e-01f,
  3.14584106e-01f, -3.00209001e-02f, 6.00347281e-01f, 2.81355828e-01f, -4.33398813e-01f, 4.32241052e-01f, 6.73661947e-01f, 4.99006152e-01f, 1.22260642e+00f, 3.74325030e-02f,
  3.47097099e-01f, 1.51625434e-02f, 5.71886487e-02f, 6.50329143e-02f, -1.95863098e-01f, -4.80272591e-01f, -3.72261256e-01f, 2.61214674e-02f, -7.17501938e-01f, -5.53682268e-01f,
  4.79050815e-01f, -5.57759762e-01f, 4.15645540e-01f, 7.16924816e-02f, 1.68775931e-01f, 3.19174826e-01f, -1.09489799e-01f, 7.49083221e-01f, 4.62881207e-01f, 2.06027791e-01f,
  -2.15816364e-01f, -3.83580178e-01f, 4.89372909e-02f, -1.90889779e-02f, -1.66916668e-01f, -6.73220307e-02f, -1.75471231e-01f, 9.39059481e-02f, -9.79806632e-02f, -3.65754038e-01f,
  -4.47837532e-01f, -2.67892301e-01f, 1.67602673e-01f, -3.69234890e-01f, 8.96952078e-02f, 1.58209577e-01f, 3.86074454e-01f, -1.52320653e-01f, -4.21098508e-02f, -4.80043627e-02f,
  6.75648391e-01f, 6.32636845e-01f, -3.18804264e-01f, 6.02919936e-01f, 4.27568734e-01f, 1.89108759e-01f, 2.43626654e-01f, -9.17488337e-02f, 2.65270740e-01f, 5.22529483e-01f,
  2.77740270e-01f, 3.54791641e-01f, 3.33927691e-01f, -4.94955748e-01f, 3.46012503e-01f, 2.91717380e-01f, 2.98332602e-01f, 2.03654438e-01f, -5.68632424e-01f, 2.50776589e-01f,
  -1.18778378e-01f, -3.29483032e-01f, 1.33450106e-01f, 3.69527340e-01f, 1.26157016e-01f, -3.39331865e-01f, 4.18626130e-01f, 1.65505320e-01f, -4.97947931e-01f, -1.84226483e-01f,
  -2.52170205e-01f, 8.68172720e-02f, 3.88124466e-01f, -1.68061674e-01f, 1.02777219e+00f, 3.29288810e-01f, 6.37173712e-01f, 3.66856903e-01f, 1.87296137e-01f, 1.69082075e-01f,
  2.61449248e-01f, -4.33067352e-01f, 8.68552700e-02f, -3.56323808e-01f, 1.51585445e-01f, 7.96010971e-01f, 3.42717946e-01f, 5.77305377e-01f, -8.66961539e-01f, -7.95630440e-02f,
  -6.67902350e-01f, -9.33558285e-01f, -4.98099685e-01f, 2.91625440e-01f, -1.82410076e-01f, 6.47375226e-01f, 6.10717177e-01f, -9.82955098e-02f, -3.52698505e-01f, 2.23943084e-01f,
  9.38722312e-01f, -2.18292058e-01f, 5.11352718e-01f, -3.70827824e-01f, -1.14311266e+00f, 3.17822605e-01f, 9.88569483e-02f, -1.17140234e-01f, 2.65497357e-01f, 1.36100933e-01f,
  1.91747576e-01f, 1.51094019e-01f, 6.06957793e-01f, 1.69734638e-02f, 2.18762234e-01f, 6.84301734e-01f, 2.02950105e-01f, -2.39247277e-01f, -7.66093954e-02f, -7.28062838e-02f,
  4.75351870e-01f, 2.43104279e-01f, 4.96131897e-01f, -3.41924340e-01f, 4.31572795e-01f, 1.21045804e+00f, 3.75418633e-01f, -2.62637019e-01f, -4.31417674e-01f, 3.78958791e-01f,
  3.04784589e-02f, 2.17979535e-01f, 4.92348336e-02f, 6.99734330e-01f, 1.88408464e-01f, -1.19698994e-01f, -5.28884530e-01f, -3.45729947e-01f, 3.75750288e-02f, -2.86410779e-01f,
  9.32534337e-02f, -1.03741989e-01f, 2.30368510e-01f, -8.69028494e-02f, 4.58611608e-01f, 4.14809465e-01f, -1.23529270e-01f, 7.63990402e-01f, 2.20239863e-01f, -6.11093163e-01f,
  -1.02383994e-01f, -5.48886061e-02f, 4.31663334e-01f, -4.34561856e-02f, 3.65479827e-01f, 4.85896736e-01f, -1.36413291e-01f, -5.46842739e-02f, -3.29708606e-01f, 1.45322815e-01f,
  -1.16343662e-01f, 2.79685020e-01f, -3.68974537e-01f, 7.52300397e-02f, -4.90840942e-01f, -1.07601598e-01f, 2.52277672e-01f, -4.43377122e-02f, -1.19837737e+00f, 7.75766790e-01f,
  4.22320962e-01f, 3.55468154e-01f, -2.12066531e-01f, -1.65082872e-01f, 1.18174843e-01f, 6.55607358e-02f, -4.24259990e-01f, 4.74415660e-01f, -8.45426880e-03f, -3.22378606e-01f,
  -1.26067355e-01f, -1.34513140e-01f, 2.94250071e-01f, -1.06989555e-01f, -7.62297034e-01f, -1.41428542e+00f, 1.05438054e+00f, -4.77770977e-02f, -1.56871974e-01f, -7.60807395e-01f,
  1.08973610e+00f, 1.64576560e-01f, -1.07650566e+00f, 7.41671979e-01f, -5.00106573e-01f, 3.26671302e-01f, 6.52402546e-03f, 5.59292853e-01f, 5.52073359e-01f, -8.94580424e-01f,
  1.74943894e-01f, -1.58423875e-02f, 5.21025360e-01f, 1.14463434e-01f, 1.63233474e-01f, -1.02945395e-01f, -6.74475729e-02f, 1.39003605e-01f, -2.67819852e-01f, 5.18795289e-02f,
  9.91358235e-02f, -2.12423384e-01f, 3.46893705e-02f, -2.93642074e-01f, -3.10400338e-03f, 5.13768243e-03f, 5.07671058e-01f, -1.25707179e-01f, 3.90464477e-02f, -1.02274030e-01f,
  -1.89092666e-01f, -1.02093831e-01f, 1.37543306e-01f, 1.83631286e-01f, 1.07182607e-01f, -1.68841347e-01f, -2.68552363e-01f, 3.42808329e-02f, 1.66896269e-01f, -2.73775548e-01f,
  3.15481603e-01f, 4.54801261e-01f, -2.07924426e-01f, 2.58379698e-01f, -1.94178954e-01f, -1.76904261e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 8)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 8;
const float L1_fan_Bp_bar_data[] = {
  2.51153529e-01f, 6.13830268e-01f, 3.74074370e-01f, 4.85135764e-01f, 1.18214995e-01f, 3.01731378e-01f, 5.59832394e-01f, -2.30683625e-01f
};

// L2_linear_W (Shape: 12 x 32)
const int L2_linear_W_rows = 12;
const int L2_linear_W_cols = 32;
const float L2_linear_W_data[] = {
  -9.82521236e-01f, 5.71495950e-01f, -4.81583297e-01f, -1.79465637e-01f, -9.82305706e-02f, -9.21866894e-01f, 5.69749057e-01f, 9.23315436e-02f, -5.77947460e-02f, -5.60176969e-01f,
  -1.26914725e-01f, -5.15194178e-01f, 5.67999840e-01f, 8.48161578e-02f, 5.58790982e-01f, -3.50585743e-03f, -2.09037617e-01f, 3.23405296e-01f, -2.10248664e-01f, -3.59411508e-01f,
  -3.62193823e-01f, -3.50662023e-01f, 4.70847785e-01f, 6.16820455e-02f, -4.54567343e-01f, -4.21057492e-01f, -3.91137928e-01f, -6.48127496e-01f, -3.48214656e-01f, -1.34153247e+00f,
  9.00144517e-01f, 3.90812814e-01f, 5.02175927e-01f, 8.20253849e-01f, 1.83258981e-01f, 7.06042349e-03f, -4.87177700e-01f, -4.75491643e-01f, -5.14707506e-01f, -9.37514365e-01f,
  -8.78556371e-01f, 7.94124842e-01f, 4.58536983e-01f, -1.00876200e+00f, 7.71798372e-01f, -4.07171011e-01f, -1.27362143e-02f, -1.09589756e+00f, 7.34659433e-01f, 6.03159368e-02f,
  9.85959768e-01f, 8.51241231e-01f, -9.72914338e-01f, 1.61301225e-01f, -8.32339227e-01f, 1.94081768e-01f, -5.51694870e-01f, 3.15432221e-01f, 2.41022646e-01f, -1.01631153e+00f,
  -5.97779334e-01f, -9.55532026e-03f, -4.07885134e-01f, -1.23112321e-01f, -1.65881351e-01f, -7.19269335e-01f, 2.54046321e-01f, 1.80815887e-02f, 3.97574276e-01f, 3.59341383e-01f,
  -1.93261147e-01f, 1.79981068e-01f, 1.91292819e-02f, 9.71885398e-02f, 2.28917345e-01f, 5.49782932e-01f, 6.03401899e-01f, -1.01887846e+00f, 7.55723000e-01f, 9.98966992e-01f,
  -4.82920974e-01f, 4.32126105e-01f, 6.61583245e-01f, 1.35715902e-01f, -1.09541070e+00f, -8.18586946e-01f, -1.14278473e-01f, 4.59868610e-01f, -2.40207702e-01f, -3.58314604e-01f,
  -7.66518861e-02f, -6.88983321e-01f, 1.26441753e+00f, -6.54097915e-01f, -7.00443029e-01f, 2.08214536e-01f, 7.44230628e-01f, -5.88937521e-01f, -3.56526285e-01f, -1.53531045e-01f,
  3.24069172e-01f, -3.40948343e-01f, -2.44907965e-03f, -1.59829044e+00f, 4.93766993e-01f, -3.40123862e-01f, 6.10786751e-02f, -1.36308357e-01f, -8.20816278e-01f, 4.85297479e-02f,
  9.65842247e-01f, -1.03454977e-01f, 2.07046028e-02f, 7.41058171e-01f, -1.35892522e+00f, -1.38168797e-01f, -7.14032531e-01f, -5.20272136e-01f, 2.57846355e-01f, -2.23821908e-01f,
  -8.03835988e-01f, -7.48581767e-01f, 2.48644978e-01f, -7.48091161e-01f, -9.93815586e-02f, 7.75064468e-01f, -4.09831442e-02f, -1.03129554e+00f, -3.03690642e-01f, 7.90015236e-02f,
  4.07340944e-01f, -2.41215050e-01f, 7.47470558e-02f, 4.69378054e-01f, 2.36653894e-01f, 6.20721340e-01f, -4.01897937e-01f, -6.12409934e-02f, -4.84493285e-01f, 1.57323293e-03f,
  6.93692684e-01f, 3.72453541e-01f, -4.40222085e-01f, -1.04565443e-02f, -7.14447320e-01f, -2.36551955e-01f, 4.55763102e-01f, -6.26119673e-01f, 7.65434623e-01f, -3.68191957e-01f,
  -2.52514750e-01f, -6.18650079e-01f, 1.16128296e-01f, -2.46466175e-01f, -8.03864524e-02f, 2.36806840e-01f, 6.02167428e-01f, 2.92342305e-01f, -1.64678738e-01f, 7.80766979e-02f,
  2.14074150e-01f, -1.10215014e-02f, 7.97598541e-01f, -1.38809040e-01f, 2.34382123e-01f, 7.12533653e-01f, 4.06375557e-01f, 4.70693201e-01f, 2.95525134e-01f, -4.37698603e-01f,
  5.19068539e-01f, 8.92029256e-02f, -6.35129988e-01f, 9.23164308e-01f, -7.34480023e-01f, -8.40690911e-01f, 6.75768912e-01f, 8.84500563e-01f, 6.85296118e-01f, 8.96302342e-01f,
  1.19278401e-01f, 4.32724804e-01f, 3.54866743e-01f, -9.03487027e-01f, -6.40562117e-01f, -1.01608917e-01f, 4.62077558e-02f, 6.68580472e-01f, -9.82078791e-01f, -8.13306689e-01f,
  -1.93735391e-01f, 1.04655646e-01f, -2.93275621e-03f, 2.54614830e-01f, -5.75064659e-01f, -1.63503036e-01f, 2.82633662e-01f, -5.13538659e-01f, 1.43167645e-01f, -1.32553399e-01f,
  3.02137733e-01f, -8.09279263e-01f, -2.50205755e-01f, -6.83225334e-01f, 9.69846010e-01f, -7.39244521e-01f, -3.83720666e-01f, 9.78098214e-01f, 5.62785208e-01f, -2.22107768e-01f,
  -5.25049329e-01f, 7.62424529e-01f, 1.15047848e+00f, 5.36682069e-01f, -5.20364046e-01f, 7.94073999e-01f, 8.47090557e-02f, 2.77446270e-01f, -6.54260516e-01f, 5.81296265e-01f,
  -4.45765078e-01f, -9.22291160e-01f, -1.37886107e+00f, 6.86559901e-02f, -1.88618854e-01f, -1.69792369e-01f, 4.25108343e-01f, 4.62322049e-02f, -4.80436981e-02f, 5.06050467e-01f,
  -4.06617016e-01f, -5.29277027e-01f, 1.73075497e-01f, 5.81372529e-02f, 1.60934731e-01f, 5.47444582e-01f, -1.74513236e-01f, -4.07617897e-01f, -8.22424144e-02f, -2.59248316e-02f,
  -1.10359120e+00f, -4.17936265e-01f, -2.80832406e-02f, -6.83350265e-01f, 4.35542345e-01f, 4.60584164e-01f, 2.12452948e-01f, 4.30119753e-01f, -7.55775213e-01f, 2.04141662e-01f,
  -2.61423588e-01f, -1.63239241e+00f, -1.62402713e+00f, 1.01513386e-01f, 7.03252673e-01f, -1.60051938e-02f, -2.60398358e-01f, 4.69895065e-01f, 3.31013530e-01f, -2.36089434e-02f,
  -4.87946540e-01f, 2.60238461e-02f, 5.97362816e-02f, 3.19544733e-01f, 7.64384940e-02f, 2.87499875e-01f, -5.62441051e-01f, 8.42233002e-01f, -7.07935989e-01f, -7.65331089e-02f,
  1.07515574e+00f, 1.18732202e+00f, -1.65349096e-01f, 1.31076053e-01f, -1.15642917e+00f, -3.50998119e-02f, 9.80984330e-01f, -1.44947380e-01f, -3.09079438e-01f, 7.73507595e-01f,
  -5.94460845e-01f, 2.66118199e-01f, 4.03443396e-01f, -1.18908179e+00f, -9.61687326e-01f, -5.33956826e-01f, -1.06855345e+00f, -5.05234718e-01f, 4.03738946e-01f, 7.04299584e-02f,
  -5.25647044e-01f, 8.45046878e-01f, -2.49408875e-02f, -4.29582626e-01f, 4.47757244e-01f, 3.91447753e-01f, 2.50961393e-01f, 9.26472902e-01f, 8.88568342e-01f, 2.23106399e-01f,
  -2.41835684e-01f, -6.59301281e-01f, -7.58073270e-01f, 7.76255965e-01f, -1.43645108e+00f, -1.01152658e+00f, -7.36405626e-02f, 1.88480109e-01f, -6.77234769e-01f, 5.64794362e-01f,
  1.01246178e+00f, 1.06378508e+00f, -1.63145199e-01f, -3.83706093e-01f, -9.62464392e-01f, 3.37535411e-01f, 3.27531546e-01f, -3.48787904e-01f, 1.98044945e-02f, 2.79725324e-02f,
  4.97718342e-03f, -1.27112195e-01f, -1.76930130e-01f, 3.34074110e-01f, -3.61885309e-01f, 8.15906897e-02f, 1.00489467e-01f, 2.51159400e-01f, 5.19993782e-01f, 2.82085061e-01f,
  -4.52285483e-02f, -1.61112532e-01f, -5.53788602e-01f, 4.08871710e-01f, 6.33852839e-01f, 3.61590177e-01f, 4.92507637e-01f, 2.39737816e-02f, 5.30344546e-01f, -1.25298509e-02f,
  1.34162515e-01f, 1.51653171e-01f, 5.64510167e-01f, -5.06407261e-01f, 1.17194998e+00f, -1.25919819e+00f, 3.86650532e-01f, -6.56870306e-01f, -4.00503129e-01f, 7.73739740e-02f,
  -6.08249545e-01f, -9.06578600e-01f, 8.61836746e-02f, -9.52502191e-01f, -6.65154338e-01f, -4.89768386e-01f, -9.05427039e-02f, 1.60605162e-01f, -9.32706535e-01f, 4.84033525e-01f,
  2.85016596e-01f, 1.82797953e-01f, -6.92641914e-01f, 3.82383645e-01f, -6.65220976e-01f, 1.00692213e+00f, 8.81398395e-02f, -9.18505251e-01f, 6.73900962e-01f, -4.79548603e-01f,
  -3.41680378e-01f, -5.32725394e-01f, 6.78430021e-01f, -8.10588300e-02f, -3.68400365e-01f, -7.93528259e-01f, -6.79463685e-01f, 2.85623938e-01f, -1.12250149e+00f, 7.11257577e-01f,
  -9.33148801e-01f, 1.75208285e-01f, -5.75123310e-01f, -2.62554526e-01f
};

// L2_linear_B (Shape: 1 x 12)
const int L2_linear_B_rows = 1;
const int L2_linear_B_cols = 12;
const float L2_linear_B_data[] = {
  3.98551412e-02f, 2.12341458e-01f, 3.87820989e-01f, -1.56320147e-02f, -3.71529728e-01f, 1.67562664e-01f, 3.22961122e-01f, -4.12714392e-01f, -6.29106611e-02f, 2.62599349e-01f,
  -9.29458067e-02f, -2.45696947e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 12, 8
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        32, 12, 8
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_linear
    linear_forward_pgm(
        buffer1, x_out,
        L2_linear_W_data, L2_linear_B_data,
        32, 12
    );
    }
    