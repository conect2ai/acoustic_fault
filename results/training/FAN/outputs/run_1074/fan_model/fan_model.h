/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 64 (x2)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 64;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    float x3 = x * x * x;
    return 0.5f * x * (1.0f + tanhf(0.79788456f * (x + 0.044715f * x3)));
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 19 x 120)
const int L0_fan_Wp_rows = 19;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -4.24613953e-01f, 1.19940944e-01f, -1.32445708e-01f, 9.06397849e-02f, 6.27153441e-02f, -7.72772208e-02f, 2.49918606e-02f, -5.95369339e-02f, 5.67583591e-02f, 6.01091459e-02f,
  1.55954391e-01f, 9.50724483e-02f, -8.46025348e-02f, -1.35940164e-02f, -1.59801379e-01f, -1.43979505e-01f, -2.09156618e-01f, -2.85850376e-01f, -3.07583541e-01f, 3.94626856e-02f,
  4.14827950e-02f, 1.67794339e-02f, -8.13900530e-02f, -3.35446708e-02f, 1.96624339e-01f, 4.42922637e-02f, 7.59999081e-02f, 4.01910953e-02f, 6.18256480e-02f, -2.62381006e-02f,
  -1.08713992e-01f, 1.14906259e-01f, -2.04955712e-02f, 9.66584608e-02f, 1.17885739e-01f, -6.39553592e-02f, -4.66618203e-02f, -7.47330487e-03f, 9.91441533e-02f, 3.79125550e-02f,
  6.90396875e-02f, 1.66816767e-02f, 6.15346581e-02f, 9.09879953e-02f, 7.65659139e-02f, -1.22203613e-02f, 6.37177527e-02f, -7.97515586e-02f, 4.52178493e-02f, 8.62565413e-02f,
  3.10456008e-02f, 2.65730191e-02f, 1.36183025e-02f, 8.03677365e-02f, 5.72447255e-02f, 1.30920969e-02f, 1.18988909e-01f, 1.73926353e-02f, 3.10457684e-02f, 6.12694547e-02f,
  -1.29634030e-02f, -1.91759169e-02f, 3.44919227e-02f, -8.72858241e-02f, 3.70367728e-02f, 2.49800049e-02f, 2.63924226e-02f, -6.95527494e-02f, 3.70079242e-02f, 8.50615185e-03f,
  8.42767581e-02f, -9.05769467e-02f, -2.41527557e-02f, -1.27833392e-02f, -3.77126294e-03f, 2.16370225e-02f, -3.96207534e-03f, -6.14464320e-02f, 4.73367162e-02f, 1.38328746e-02f,
  7.13175535e-03f, -7.01528788e-03f, -2.55531929e-02f, 3.13248113e-02f, -5.95609732e-02f, 8.13588407e-03f, -4.20031734e-02f, 4.22008112e-02f, 7.22096562e-02f, -2.36702734e-03f,
  2.84555834e-02f, 2.89536901e-02f, -1.12079173e-01f, -3.04183923e-02f, 2.91250157e-03f, 4.03301790e-02f, 2.65300442e-02f, -2.32872441e-02f, 2.45003030e-02f, 4.71794643e-02f,
  1.10875806e-02f, 8.67302343e-03f, 2.97033861e-02f, -2.68360302e-02f, 6.72761649e-02f, -6.05034232e-02f, 5.34218885e-02f, -8.57706964e-02f, -2.53652371e-02f, 1.77461319e-02f,
  1.35116335e-02f, -1.19049206e-01f, -1.68828130e-01f, -5.98699413e-02f, -3.49352397e-02f, -1.56974122e-01f, -8.84998068e-02f, 2.26122420e-02f, -1.82108939e-01f, -6.13849461e-02f,
  2.27231327e-02f, -8.27903580e-03f, -2.19108328e-01f, -3.04205000e-01f, -1.48006722e-01f, -1.35975555e-01f, -8.29213262e-02f, -2.43655983e-02f, -8.53615925e-02f, -1.91318527e-01f,
  -3.74438874e-02f, 1.90073535e-01f, 2.31136717e-02f, 1.42659560e-01f, 7.55161867e-02f, -1.03998795e-01f, -2.25576863e-01f, -4.76609953e-02f, 1.52261615e-01f, 9.62094516e-02f,
  9.40501541e-02f, -1.20015955e-02f, 1.88407704e-01f, 9.36579630e-02f, -1.20931141e-01f, -1.53746605e-02f, -9.96435061e-02f, -7.59312063e-02f, 8.57183337e-02f, -1.84344336e-01f,
  -2.68098444e-01f, -9.13457852e-03f, 1.27119020e-01f, 1.51953548e-01f, -6.55982345e-02f, 1.63798317e-01f, 1.65137798e-02f, 1.00532725e-01f, 1.20194860e-01f, -8.37448519e-03f,
  6.57753497e-02f, 9.23968852e-02f, 7.91347772e-02f, 1.07404873e-01f, 2.67706718e-02f, 9.65106636e-02f, -1.63894594e-02f, 3.36577930e-02f, 2.89720669e-02f, 5.39067946e-02f,
  6.88048527e-02f, 9.62528661e-02f, 3.56334932e-02f, 9.62325409e-02f, 1.03408776e-01f, 6.92152530e-02f, 2.89668795e-02f, 1.11221366e-01f, 6.37873709e-02f, -4.99905720e-02f,
  -7.44939819e-02f, -1.21458843e-02f, -2.71502249e-02f, -4.99402471e-02f, 2.61905789e-02f, -3.76694091e-02f, -9.99596119e-02f, -1.31152526e-01f, 4.20771576e-02f, -5.71057126e-02f,
  -8.87741446e-02f, -1.24806367e-01f, -5.15032513e-03f, -3.23883668e-02f, -8.24476331e-02f, -1.26777589e-01f, -9.20629874e-02f, -3.22837420e-02f, -1.31187633e-01f, -7.50305653e-02f,
  -1.74586046e-02f, 1.51005283e-04f, -1.25116467e-01f, -3.55098508e-02f, 1.02838147e-02f, -4.40638438e-02f, -6.24301955e-02f, -2.65550520e-02f, -2.27795783e-02f, -5.49468882e-02f,
  -8.28545764e-02f, 1.03889287e-01f, -1.08051553e-01f, 1.21015742e-01f, -3.55089977e-02f, -2.83338055e-02f, -2.11641081e-02f, -1.28197409e-02f, 5.16883656e-02f, 6.29664212e-02f,
  9.84287187e-02f, 3.78724746e-02f, -7.30280019e-03f, -3.22608948e-02f, 2.86191422e-02f, 1.78759731e-02f, -7.63018150e-03f, -3.04726474e-02f, -1.07057206e-02f, 5.26298806e-02f,
  -3.59720886e-02f, 3.42748500e-02f, 1.50362886e-02f, -1.28150526e-02f, 4.53579165e-02f, 2.71245465e-02f, -2.98093576e-02f, -2.77399030e-02f, 5.13446033e-02f, -1.03284335e-02f,
  1.20576821e-01f, -1.79956034e-01f, -4.46989745e-01f, -1.90744966e-01f, -1.08900182e-01f, -1.17899757e-02f, -1.19473539e-01f, 1.43617615e-01f, -2.54059618e-04f, -1.95903197e-01f,
  -5.49180023e-02f, 8.81188661e-02f, -8.77534673e-02f, -3.88348475e-02f, -4.73775566e-02f, -1.47990093e-01f, -2.44403556e-01f, -1.66704193e-01f, 1.07464388e-01f, 1.29826769e-01f,
  -1.46025708e-02f, 8.76258407e-03f, 1.80713776e-02f, 5.19465581e-02f, -2.08383292e-01f, -8.81781280e-02f, -2.57845193e-01f, -6.00736141e-02f, -1.58564717e-01f, -2.47916475e-01f,
  -1.96971342e-01f, -1.69521883e-01f, 4.07479703e-02f, -1.63104199e-02f, -5.24520269e-03f, 8.06268677e-02f, 4.96045053e-02f, -4.62313890e-02f, 4.71870825e-02f, -3.67907970e-03f,
  -1.34793986e-02f, -1.61777101e-02f, 1.79284357e-03f, 4.70047370e-02f, 2.25137882e-02f, -3.44231687e-02f, 4.55901138e-02f, -6.55365661e-02f, -1.12255283e-01f, -3.15743759e-02f,
  -1.03381827e-01f, -1.50796682e-01f, -1.77988410e-01f, -7.19483048e-02f, -6.32043043e-03f, -2.63191829e-03f, -1.32888973e-01f, -5.93486317e-02f, -7.84542486e-02f, -7.14252070e-02f,
  5.40846065e-02f, 3.25645655e-02f, -2.07377039e-02f, 5.04430458e-02f, -1.03367195e-02f, 2.33742353e-02f, -3.76056763e-03f, -3.00874766e-02f, 8.40385705e-02f, 1.40804723e-02f,
  -1.49093159e-02f, -5.75048551e-02f, 9.31626838e-03f, -9.44232568e-02f, 1.47807142e-02f, -5.38169891e-02f, 4.23111878e-02f, 4.60962094e-02f, 6.99405698e-03f, 2.62240786e-02f,
  8.73813499e-03f, 6.85681179e-02f, 4.24828567e-02f, 2.61394456e-02f, 4.15681750e-02f, 2.50656460e-03f, -6.95859408e-03f, 9.38998535e-02f, 5.46318144e-02f, -9.14869551e-03f,
  1.58787936e-01f, 3.68947908e-02f, -5.65210134e-02f, 6.73673376e-02f, -1.49363335e-02f, 5.23370840e-02f, -1.18097760e-01f, -2.79944334e-02f, -6.98633268e-02f, -5.77805564e-02f,
  -2.57823262e-02f, 2.01078244e-02f, -4.87617180e-02f, -5.46546280e-02f, -3.99147086e-02f, 4.63012829e-02f, -1.95311429e-03f, -4.97375727e-02f, 8.93495232e-03f, -1.39029935e-01f,
  -4.17923294e-02f, 1.07919857e-01f, 3.69839109e-02f, 5.03580458e-02f, -7.78033659e-02f, 7.49780610e-02f, -8.18290338e-02f, -2.36022137e-02f, 5.01416661e-02f, 3.26406509e-02f,
  -3.73888612e-01f, 2.95268506e-01f, 3.71466100e-01f, -2.22251862e-01f, -9.32160765e-03f, 2.10442454e-01f, 2.10699871e-01f, 9.33074802e-02f, -2.20175013e-01f, 1.95192963e-01f,
  2.27392629e-01f, -8.86346102e-02f, 6.56821802e-02f, 8.14200118e-02f, 1.17255256e-01f, 1.32858574e-01f, 1.50308833e-01f, -7.39762932e-02f, -1.14392683e-01f, -2.03894496e-01f,
  -1.95800066e-01f, -2.10969448e-01f, -2.38155961e-01f, -8.90090391e-02f, -6.05410971e-02f, 2.96026729e-02f, 2.22693950e-01f, 6.03129566e-02f, 1.69691473e-01f, 1.31376181e-02f,
  1.17234245e-01f, 1.11924104e-01f, -1.20434098e-01f, -1.85638461e-02f, 6.56891391e-02f, 8.29497799e-02f, 7.91382641e-02f, 2.11081072e-03f, -3.85121210e-03f, 2.21176725e-02f,
  4.63539399e-02f, -3.43632922e-02f, 6.31604195e-02f, 3.52055090e-03f, -1.00818602e-02f, 5.94486184e-02f, -5.03087305e-02f, 1.31571680e-01f, 4.82990555e-02f, 1.15929134e-01f,
  1.54891172e-02f, 1.90827101e-02f, 1.48328677e-01f, 8.66962969e-02f, 1.08114958e-01f, -3.58367004e-02f, 2.13996306e-01f, 6.36002645e-02f, 1.01505093e-01f, 9.04047862e-02f,
  -8.87616724e-02f, 3.58358696e-02f, 1.85695216e-02f, -8.29843357e-02f, -3.52392606e-02f, -2.10896786e-02f, 9.22361854e-04f, -1.01015558e-02f, -8.75019282e-02f, -5.64598478e-02f,
  1.13390768e-02f, 7.63225257e-02f, 3.33472178e-03f, -6.17537424e-02f, -1.49728414e-02f, 1.31630516e-02f, -2.48600747e-02f, 2.67036855e-02f, -2.82867905e-02f, 9.72639397e-03f,
  -2.18155626e-02f, -6.91444501e-02f, -5.47860265e-02f, -3.18579711e-02f, 1.89040229e-02f, -2.51402287e-03f, -5.71683943e-02f, -8.80804495e-04f, -1.32681042e-01f, -9.55882072e-02f,
  5.10372482e-02f, 9.16001573e-02f, -1.46329822e-02f, 2.30700485e-02f, 5.98362535e-02f, 9.17923078e-03f, -1.52493129e-02f, 1.29860137e-02f, 1.10249154e-01f, -1.45605784e-02f,
  -1.65883712e-02f, -7.55187590e-03f, 4.72905189e-02f, -1.40551953e-02f, -3.53129096e-02f, -5.08201309e-04f, 2.78988704e-02f, -5.60441799e-02f, 7.23552555e-02f, 6.91527501e-02f,
  -8.14739615e-02f, -1.92434918e-02f, -2.98512038e-02f, 1.53265689e-02f, -6.43114448e-02f, -1.49847582e-01f, 1.00990392e-01f, 4.38674353e-02f, 8.05002823e-02f, -9.23847780e-02f,
  2.14616999e-01f, -9.72959585e-03f, 1.56627700e-01f, -2.37404659e-01f, -3.20038646e-01f, -4.36829627e-02f, -8.94505344e-03f, -3.84492390e-02f, -2.55092710e-01f, -4.80242558e-02f,
  -1.36765972e-01f, -9.69672129e-02f, 1.04647771e-01f, 1.32327825e-01f, 2.81677276e-01f, 5.79314344e-02f, -1.30025104e-01f, 1.58187732e-01f, 2.01872721e-01f, -9.31695029e-02f,
  -2.74578869e-01f, -8.70865881e-02f, 1.06296346e-01f, -1.99726205e-02f, -1.75878331e-01f, -2.12875724e-01f, -7.30273649e-02f, -2.41267451e-04f, -2.54624467e-02f, -1.64479598e-01f,
  1.14756525e-01f, 1.62848070e-01f, -5.20117171e-02f, -7.51251951e-02f, -2.35873550e-01f, -3.18975225e-02f, -1.06660925e-01f, 1.52844461e-02f, -1.21858522e-01f, -7.02642128e-02f,
  -9.25508216e-02f, -8.98042098e-02f, 3.71968076e-02f, -3.92582193e-02f, 1.56013120e-03f, -1.54719818e-02f, 6.54370859e-02f, 1.76425159e-01f, 1.31646931e-01f, -3.39809731e-02f,
  -1.54917523e-01f, -6.81037232e-02f, 5.72089218e-02f, 4.54226695e-02f, 8.05524960e-02f, -4.50690500e-02f, 5.39682098e-02f, -1.28218196e-02f, 1.13379940e-01f, -1.36493996e-01f,
  -1.16561636e-01f, 1.81637630e-02f, -2.18671071e-03f, 7.12150708e-02f, -3.75021547e-02f, 6.93237185e-02f, 3.26109342e-02f, 3.15159075e-02f, -2.46231873e-02f, 5.65052815e-02f,
  7.59107545e-02f, 5.95353991e-02f, 2.29860377e-02f, 6.71813935e-02f, -3.44795920e-02f, 1.26373231e-01f, 8.22147205e-02f, -1.08702369e-02f, 6.13274202e-02f, 9.79489833e-02f,
  5.70619814e-02f, 7.68455267e-02f, 1.49386628e-02f, -8.87292437e-03f, 1.08596273e-01f, 6.70783967e-02f, 2.24158317e-02f, 6.42693415e-02f, 1.23645619e-01f, 4.82827798e-02f,
  -1.07924938e-01f, 1.20023713e-01f, -6.97663426e-02f, -2.35558189e-02f, -9.67792943e-02f, -3.64498571e-02f, -5.58540486e-02f, -3.62931043e-02f, -4.53929566e-02f, 7.79651105e-03f,
  -9.77389514e-02f, -1.77688245e-02f, -3.10586579e-02f, 6.61270786e-03f, -1.39187247e-01f, -8.16790834e-02f, -1.77509516e-01f, -1.00255653e-01f, -9.30344760e-02f, -3.97670828e-02f,
  -6.31696582e-02f, -1.16515204e-01f, -5.94873615e-02f, -8.36863071e-02f, -4.01876494e-02f, -2.26215366e-02f, -3.12706567e-02f, -1.77654460e-01f, 4.66994336e-03f, -3.09916943e-01f,
  -3.11293483e-01f, 3.24276298e-01f, 1.94279268e-01f, -1.00343466e-01f, 2.55491752e-02f, 1.72073364e-01f, 2.07886100e-01f, 6.58343509e-02f, -4.48094495e-02f, 5.61999381e-02f,
  3.29894513e-01f, -1.08952019e-02f, 6.93943799e-02f, 1.00764088e-01f, -7.69999716e-03f, -1.36075746e-02f, -9.44891647e-02f, -9.52447876e-02f, -1.36967808e-01f, 2.02786904e-02f,
  -5.16029000e-02f, -1.83487743e-01f, -2.43060648e-01f, -9.72068831e-02f, 7.28574442e-03f, -6.03553802e-02f, 1.06121764e-01f, 7.77422339e-02f, 1.98778301e-01f, -3.44682165e-04f,
  2.06157565e-01f, 1.99087232e-01f, 6.21515028e-02f, -9.47652012e-02f, 5.43775745e-02f, 5.28319292e-02f, 8.52957144e-02f, -5.17857969e-02f, 4.56595719e-02f, 9.24619883e-02f,
  3.32996137e-02f, 5.13137765e-02f, -1.38111124e-02f, 8.83835778e-02f, 9.97929461e-03f, 6.02764115e-02f, 5.27376216e-03f, -3.57615612e-02f, -2.87790112e-02f, 5.07675521e-02f,
  7.30409548e-02f, 7.33156055e-02f, 9.50120389e-02f, 3.78282666e-02f, 2.06315234e-01f, -4.04544212e-02f, 1.72206536e-01f, 5.31730242e-02f, 1.95905522e-01f, -3.20229903e-02f,
  7.66758025e-02f, -1.94436554e-02f, -3.72068323e-02f, 8.54234099e-02f, -3.97656597e-02f, 3.67141068e-02f, 7.71796331e-03f, -2.08754912e-02f, -7.84451589e-02f, -4.80254441e-02f,
  2.46463660e-02f, 8.93111303e-02f, 9.28390585e-03f, 3.75253223e-02f, 3.14959101e-02f, 3.13033089e-02f, 7.67697860e-03f, 1.25220381e-02f, -2.31050830e-02f, -6.61785295e-03f,
  8.97936150e-02f, 3.25264037e-02f, 7.86505416e-02f, -5.76867722e-02f, 9.68900770e-02f, 4.37078625e-02f, 2.28598416e-02f, 3.67276520e-02f, 1.02509245e-01f, 2.30019968e-02f,
  -1.76044349e-02f, 1.04182646e-01f, 9.73569080e-02f, -3.21768820e-02f, -5.63508756e-02f, -2.56675910e-02f, 7.52751604e-02f, 6.34443387e-02f, 4.39015217e-02f, 7.69405812e-02f,
  1.67235270e-01f, 6.37151822e-02f, 3.10693569e-02f, 9.75114759e-03f, -2.52226479e-02f, -7.73254186e-02f, -4.64466140e-02f, -6.12406172e-02f, -1.76451523e-02f, -7.16636106e-02f,
  -2.40738485e-02f, -2.92423852e-02f, -1.99288372e-02f, 6.49311841e-02f, -9.26856883e-03f, -5.67429587e-02f, 4.24266607e-02f, -6.38500005e-02f, 5.58886230e-02f, -1.34802818e-01f,
  -4.20880876e-02f, 1.36169985e-01f, 2.07928836e-01f, 9.28058699e-02f, -3.38292792e-02f, 8.23180526e-02f, 8.39825571e-02f, 1.03576198e-01f, -5.09575419e-02f, 2.30682805e-01f,
  1.63908657e-02f, -2.16905668e-01f, -6.92492053e-02f, -1.26322672e-01f, -1.84860110e-01f, 1.33992910e-01f, 3.89672592e-02f, -1.19632326e-01f, -2.98405349e-01f, -2.19387829e-01f,
  -2.58762628e-01f, -2.16862142e-01f, -1.03641376e-01f, -1.59391657e-01f, 1.00706972e-01f, 7.65829394e-03f, 1.65580362e-01f, -9.18522999e-02f, -1.20493971e-01f, -4.04827371e-02f,
  1.42420679e-01f, 2.09770016e-02f, -1.05144959e-02f, -1.09833308e-01f, 6.40716553e-02f, 1.97508764e-02f, 8.21830183e-02f, 8.41868296e-02f, 6.41633049e-02f, 6.61090836e-02f,
  1.47193379e-03f, 4.66012210e-02f, -9.58687887e-02f, -6.73006568e-03f, 3.22853662e-02f, -2.29983646e-02f, -4.27603628e-03f, -5.00428490e-02f, 4.35951725e-02f, 4.98028845e-02f,
  4.52872366e-03f, -1.02905259e-01f, 1.51645601e-01f, 4.17605564e-02f, 3.34765129e-02f, 4.28558677e-04f, 9.87036154e-03f, 1.96412895e-02f, 4.69563305e-02f, 9.94543061e-02f,
  1.46743851e-02f, 1.70713738e-02f, 3.03426199e-02f, 1.17095947e-01f, -5.63517585e-02f, 1.50953745e-02f, 2.37729046e-02f, -7.51035213e-02f, -1.05284400e-01f, 4.33795750e-02f,
  -5.64332120e-02f, -2.99793258e-02f, -2.34468207e-02f, 6.04375452e-02f, -2.29504984e-02f, 5.67763001e-02f, -9.26175043e-02f, -7.17958063e-03f, 2.28377599e-02f, -1.09570384e-01f,
  -3.65515333e-03f, 3.02106328e-02f, -2.70627383e-02f, -8.53919238e-02f, 3.05682849e-02f, -3.43817100e-02f, 1.15743279e-02f, -2.75259316e-02f, 1.75609335e-03f, -2.17433926e-02f,
  1.92477807e-01f, -5.39999716e-02f, -2.41967733e-03f, 3.42162736e-02f, 1.08357824e-01f, 6.77378327e-02f, 3.00815757e-02f, -4.32475768e-02f, 9.22097862e-02f, 3.60432034e-03f,
  -3.91553305e-02f, -5.47463633e-02f, -1.43143255e-02f, -1.88708398e-02f, -6.02952242e-02f, 5.47369607e-02f, 5.82725033e-02f, -3.80054563e-02f, 6.73385635e-02f, 2.20073145e-02f,
  6.87470734e-02f, 1.11417621e-01f, 4.77823019e-02f, 8.86568949e-02f, 8.00933391e-02f, 1.17174044e-01f, 1.70289800e-01f, 1.29152089e-01f, 4.94710915e-02f, 2.53767580e-01f,
  -1.47175714e-01f, 8.98495913e-02f, -7.33415782e-02f, 4.70981523e-02f, -1.61881596e-01f, -1.27092823e-01f, -1.62876099e-01f, 4.36354354e-02f, 1.68909401e-01f, 1.12199202e-01f,
  -2.61633955e-02f, 1.35003105e-01f, 9.31955874e-02f, 1.02461234e-01f, -4.99443039e-02f, -3.99368294e-02f, -4.48576640e-03f, -4.69656549e-02f, -8.57391283e-02f, 7.40742907e-02f,
  -8.49453732e-03f, 3.55497301e-02f, -1.62527300e-02f, 7.01709017e-02f, 1.89765915e-01f, 5.56671098e-02f, 6.84823096e-02f, 3.66757587e-02f, 7.50321820e-02f, 1.86686367e-01f,
  -2.06039757e-01f, -4.78943922e-02f, 1.03887014e-01f, 1.76598534e-01f, 1.27853051e-01f, 1.88691378e-01f, 1.35267511e-01f, 9.15484428e-02f, 1.08384572e-01f, 1.68681532e-01f,
  1.25183642e-01f, 2.35547870e-01f, 9.87335145e-02f, 1.78791821e-01f, 7.77061284e-02f, 1.84195742e-01f, 2.03372449e-01f, 1.78813577e-01f, 1.70768678e-01f, 1.17780782e-01f,
  1.98717088e-01f, 5.53255826e-02f, -4.31027859e-02f, 3.54299210e-02f, 1.14463791e-01f, 1.80000570e-02f, 1.04449160e-01f, 4.94413264e-02f, 7.95675740e-02f, 1.20955043e-01f,
  -7.34945387e-02f, -3.63141783e-02f, -2.52968632e-02f, -1.55963404e-02f, -2.00443089e-01f, -1.00603804e-01f, -1.24371834e-01f, -1.74263179e-01f, -1.11909255e-01f, -5.78753352e-02f,
  -1.42365089e-02f, -5.30272797e-02f, -6.73048757e-03f, 4.12178300e-02f, -6.90534115e-02f, -4.72431295e-02f, -3.28183025e-02f, -4.33492959e-02f, -6.47097155e-02f, -8.16457272e-02f,
  -6.66174516e-02f, -9.34029296e-02f, 2.24586986e-02f, -6.84701353e-02f, -1.98773686e-02f, -2.67420094e-02f, -4.94070500e-02f, -1.34033769e-01f, -1.24542527e-01f, -1.30081862e-01f,
  3.69362906e-02f, 2.92992014e-02f, 1.80032045e-01f, 1.96281955e-01f, 1.24571964e-01f, 2.33567178e-01f, 1.31856591e-01f, 1.83865428e-01f, 1.49524778e-01f, 3.69004831e-02f,
  1.33336276e-01f, 1.02673732e-01f, 1.02337532e-01f, 1.84706777e-01f, 1.22504994e-01f, 4.88037430e-02f, 5.46926484e-02f, 8.71807486e-02f, 1.50152624e-01f, 1.53795898e-01f,
  1.24749571e-01f, 4.63537760e-02f, -1.50270183e-02f, 6.48183972e-02f, 1.44071773e-01f, 1.03363954e-01f, 4.40794714e-02f, 7.98036233e-02f, 7.19176605e-02f, 1.48743065e-02f,
  4.66003083e-02f, 3.88824642e-02f, -1.88829117e-02f, 1.30973846e-01f, -1.61378399e-01f, -2.45947003e-01f, -2.91462123e-01f, -8.14186335e-02f, 4.85605672e-02f, 2.17234623e-02f,
  -9.43439640e-03f, 1.45586893e-01f, 1.98371753e-01f, 2.21594587e-01f, 1.14169091e-01f, 6.46326393e-02f, 2.23788604e-01f, 2.05802545e-01f, 3.01713385e-02f, -5.93050346e-02f,
  8.10516179e-02f, 2.23818317e-01f, 2.81073570e-01f, 3.20718199e-01f, 1.98596746e-01f, 1.62323177e-01f, 2.39996865e-01f, 1.58102930e-01f, 1.32900864e-01f, 2.74937421e-01f,
  1.01770252e-01f, 1.02196574e-01f, 8.64061862e-02f, 2.06882656e-01f, 9.89150181e-02f, 1.56889528e-01f, 1.83134347e-01f, 2.19366625e-01f, 1.53710932e-01f, 2.31486410e-01f,
  1.88616365e-01f, 1.41302913e-01f, 1.51543379e-01f, 1.70620456e-01f, 1.99551851e-01f, 1.58966735e-01f, 2.77031273e-01f, 3.16657156e-01f, 2.75671393e-01f, 2.58413255e-01f,
  2.30422840e-01f, 1.76534876e-01f, 9.50893164e-02f, 1.42591327e-01f, 2.03468904e-01f, 1.45267919e-01f, 2.07952842e-01f, 2.33787850e-01f, 1.50918320e-01f, 2.75341600e-01f,
  -7.34582618e-02f, -1.98796421e-01f, -2.09367514e-01f, -1.28018662e-01f, -1.86540991e-01f, -1.37035847e-01f, -1.07815646e-01f, -8.92436057e-02f, -1.02449045e-01f, -6.06114119e-02f,
  -1.10789686e-01f, -1.70958728e-01f, -1.63449764e-01f, -1.09073237e-01f, -9.26680714e-02f, -7.74934441e-02f, -1.59493327e-01f, -1.59310982e-01f, -5.27410991e-02f, -1.36527032e-01f,
  -1.39873371e-01f, -1.60560817e-01f, -1.47977993e-01f, -1.35645624e-02f, -1.62697434e-01f, -1.02967501e-01f, -6.44232109e-02f, -1.63665652e-01f, -1.22851819e-01f, -1.41539231e-01f,
  3.78179960e-02f, 1.30341172e-01f, 1.77617177e-01f, 1.89537451e-01f, 2.10633472e-01f, 2.30825990e-01f, 1.92926019e-01f, 1.53616533e-01f, 2.07812607e-01f, 1.00963354e-01f,
  7.50595108e-02f, 1.74310088e-01f, 8.11125860e-02f, 1.48163110e-01f, 6.47333115e-02f, 1.87171593e-01f, 1.09932929e-01f, 1.73084125e-01f, 1.37391642e-01f, 8.61810148e-02f,
  1.64891347e-01f, 9.05959122e-03f, 1.27960756e-01f, 1.02210671e-01f, 8.94716233e-02f, 9.55518335e-02f, 3.86364758e-02f, 1.35309910e-02f, 1.19271129e-01f, 6.83519617e-02f,
  3.63888592e-01f, 1.42862529e-01f, 2.76777893e-01f, 4.47573960e-01f, 2.69334555e-01f, 2.51673192e-01f, 2.25523070e-01f, 1.99287415e-01f, 1.73434138e-01f, 2.20198944e-01f,
  2.17077490e-02f, -8.51173028e-02f, 4.62908112e-02f, -1.72480755e-02f, 8.24830383e-02f, 1.77878186e-01f, 1.76802382e-01f, 3.00613418e-02f, 6.32155016e-02f, 2.51942962e-01f,
  1.87304258e-01f, 2.03127667e-01f, 1.72900990e-01f, 2.08011121e-01f, 2.31137142e-01f, -1.76778026e-02f, 1.46590605e-01f, 2.45956242e-01f, -9.60846711e-03f, 1.50399417e-01f,
  1.06917210e-01f, 2.70696700e-01f, -7.40589425e-02f, -1.30062019e-02f, 4.18235436e-02f, 6.90110698e-02f, 3.92634422e-03f, 3.17099355e-02f, 2.58591231e-02f, 1.03882521e-01f,
  1.01467893e-01f, 5.77928089e-02f, -7.15377461e-03f, 8.28176588e-02f, 1.46184087e-01f, -8.73854849e-03f, -3.84074748e-02f, 2.89830100e-02f, -7.99476653e-02f, -3.87168713e-02f,
  1.25658363e-02f, 2.13289354e-02f, 1.04105622e-02f, -1.00515448e-01f, 1.03512891e-02f, 3.89615539e-03f, 1.35794003e-02f, -2.15664059e-02f, 3.91437151e-02f, 7.95692056e-02f,
  6.39415309e-02f, -6.26502857e-02f, -9.43342447e-02f, -8.51948038e-02f, -6.28049299e-02f, -1.90700233e-01f, -1.11512784e-02f, -1.38106318e-02f, -9.43469070e-03f, -9.48601291e-02f,
  -8.00274312e-02f, -6.04735799e-02f, -4.49416600e-02f, -6.58850819e-02f, -1.33436382e-01f, -5.16250953e-02f, 5.43836504e-03f, -7.90558979e-02f, -3.83390300e-02f, -8.88876095e-02f,
  -1.00215532e-01f, 4.37181257e-02f, -6.44988269e-02f, -1.25766411e-01f, 4.37338650e-02f, -1.03094671e-02f, -7.76088005e-03f, -4.92406078e-02f, -7.33590573e-02f, 4.76831645e-02f,
  -3.49293202e-02f, -1.05733186e-01f, 7.50833526e-02f, -3.08925044e-02f, -3.36268246e-02f, -9.80951265e-02f, -1.61638670e-02f, -5.57158329e-02f, -2.33020801e-02f, 1.23060875e-01f,
  -1.16556259e-02f, 1.07066162e-01f, 8.27222168e-02f, 3.83883715e-02f, 6.51455745e-02f, -1.60850864e-02f, -2.72844732e-02f, 3.44044194e-02f, -9.16762501e-02f, 7.50779882e-02f,
  3.89308259e-02f, -3.11883073e-02f, -1.07005954e-01f, -5.29701523e-02f, -3.26494686e-02f, -1.31481737e-01f, -5.81963807e-02f, -1.36639223e-01f, 1.66900195e-02f, -1.17309280e-02f,
  -4.12148058e-01f, 2.94031322e-01f, 1.77296177e-01f, -2.69805759e-01f, 2.88798045e-02f, 1.10536246e-02f, 1.14453472e-01f, -7.38966092e-02f, -2.67287701e-01f, 8.38649422e-02f,
  2.01318771e-01f, 3.52865271e-02f, 1.20763019e-01f, 1.26821473e-01f, -2.61665005e-02f, 9.48613044e-03f, -1.65849879e-01f, -8.80307555e-02f, -1.42741367e-01f, -8.45142975e-02f,
  -5.14595509e-02f, -8.28210637e-02f, -1.06799953e-01f, -1.08445510e-01f, -1.04405403e-01f, -4.33792919e-02f, 1.29525483e-01f, 4.68985625e-02f, 1.22957051e-01f, -3.47012803e-02f,
  1.58857793e-01f, -4.72447090e-02f, -7.93915167e-02f, -1.03507541e-01f, 5.82109764e-02f, -8.63984376e-02f, -7.49446228e-02f, -2.87356284e-02f, -1.62837822e-02f, 1.34467874e-02f,
  3.93958017e-02f, 1.29980696e-02f, -1.32625192e-01f, 6.17253855e-02f, -1.46767542e-01f, 4.65703867e-02f, -1.01841047e-01f, -4.97060977e-02f, 1.85900170e-03f, -1.10349348e-02f,
  -3.51879373e-02f, 1.92595390e-03f, -2.56407522e-02f, -7.14572007e-03f, -1.12366509e-02f, -4.83093448e-02f, 1.72284141e-01f, 9.49215610e-03f, 7.77975917e-02f, -7.70500302e-02f,
  2.36306433e-02f, -3.27648744e-02f, -4.86541614e-02f, -1.37321455e-02f, -2.13009529e-02f, -3.15384497e-03f, -3.04470751e-02f, -8.24189931e-03f, 2.44554169e-02f, -3.43231149e-02f,
  7.34148324e-02f, -5.14683574e-02f, 4.05742265e-02f, -5.28342053e-02f, -2.43272400e-03f, 3.66215594e-02f, 6.45097811e-03f, 7.56857470e-02f, 7.74235651e-02f, -6.08922914e-02f,
  -4.22845259e-02f, -5.04465699e-02f, -4.42611985e-02f, -2.79285666e-02f, 5.97918518e-02f, 3.26822102e-02f, 3.85085195e-02f, 1.00575751e-02f, -1.82988271e-02f, 8.13517999e-03f,
  2.63637267e-02f, 2.15630576e-01f, -7.82938078e-02f, -4.60028984e-02f, -1.10417753e-01f, 5.57342134e-02f, -4.94342893e-02f, -1.17779888e-01f, -5.35549708e-02f, -1.15542725e-01f,
  -1.41498810e-02f, -8.30868408e-02f, 2.46291403e-02f, 1.98186142e-03f, -5.81686050e-02f, -6.14276454e-02f, 2.22294894e-03f, -4.10583317e-02f, -8.97048786e-03f, 2.24868045e-03f,
  -9.92474612e-03f, -7.02914968e-02f, -1.38653651e-01f, 4.82626520e-02f, -1.53543167e-02f, -1.49108499e-01f, -3.42629962e-02f, 2.33187666e-03f, -4.46740165e-03f, -7.58726001e-02f,
  1.44603193e-01f, -1.20039031e-01f, 1.31829485e-01f, 1.66477457e-01f, -1.63428396e-01f, -1.29138887e-01f, -1.54438093e-01f, 4.81498614e-02f, 1.80005923e-01f, -5.31477369e-02f,
  -2.19037402e-02f, 2.02740878e-01f, 2.60583907e-01f, 2.08616987e-01f, 1.85440928e-01f, 6.64164275e-02f, 7.29085132e-02f, 3.22311223e-01f, 3.32078457e-01f, 7.36944079e-02f,
  2.81820111e-02f, -2.15674774e-03f, 1.94978088e-01f, 3.84007767e-02f, -5.24160936e-02f, 6.59188703e-02f, 5.66113703e-02f, -6.80903867e-02f, -1.39989376e-01f, -1.45300522e-01f,
  6.05326928e-02f, -2.23906577e-01f, 1.05358750e-01f, 9.04687156e-04f, -2.61843279e-02f, 9.00188908e-02f, 3.76926921e-03f, 8.63569528e-02f, -7.29737384e-03f, 1.14691397e-02f,
  -8.27597529e-02f, -5.66421486e-02f, 1.73422303e-02f, -1.17467359e-01f, -7.43355975e-02f, -7.03891888e-02f, -5.65055385e-02f, -2.92180888e-02f, 4.22879681e-02f, -5.38351573e-02f,
  -5.33582503e-03f, -1.30486265e-01f, 6.54351860e-02f, 9.04035941e-02f, -1.01102784e-01f, 1.25809118e-01f, -5.86514594e-03f, -1.05739273e-01f, 1.25791393e-02f, 9.31199566e-02f,
  4.04158458e-02f, 1.63516905e-02f, 4.81935367e-02f, -2.86076348e-02f, 3.42824906e-02f, 4.19583805e-02f, 5.10086082e-02f, 7.89009631e-02f, -1.20437760e-02f, -5.54542318e-02f,
  -1.14995670e-02f, -5.31361252e-02f, 6.16417639e-02f, 2.39318796e-02f, -1.91328432e-02f, -7.44605204e-03f, -8.39481317e-03f, 8.67436407e-04f, -5.22834472e-02f, -1.08578943e-01f,
  -9.30674747e-02f, -6.38929456e-02f, -3.39452475e-02f, 4.99768704e-02f, 9.02240630e-03f, 1.22004226e-01f, -1.22064454e-02f, -3.14865485e-02f, -3.04906964e-02f, -4.15230803e-02f,
  1.57328486e-01f, -1.01986930e-01f, -1.16343973e-02f, -3.55157442e-03f, -2.09027040e-03f, -2.42316648e-02f, 2.83686593e-02f, -4.46382631e-03f, 6.13078773e-02f, 5.99449612e-02f,
  -8.60817581e-02f, 1.23659305e-01f, 3.30276415e-02f, -9.65314582e-02f, 2.91364174e-02f, -3.23494971e-02f, 4.87213731e-02f, 1.30023688e-01f, -1.60578173e-02f, -2.21032044e-03f,
  1.65050337e-03f, 1.43058017e-01f, 1.72217146e-01f, 1.98153138e-01f, -4.49350588e-02f, 2.33956188e-01f, 1.02399953e-01f, 1.74052939e-02f, 1.33789316e-01f, 2.17536896e-01f,
  2.37667069e-01f, -3.41464639e-01f, -2.57860571e-01f, 1.23340428e-01f, -1.56805620e-01f, -1.37200698e-01f, -2.98811197e-01f, -4.42567505e-02f, 1.93122387e-01f, -1.33063242e-01f,
  4.62880619e-02f, 1.81026474e-01f, 1.84947476e-01f, 2.40190744e-01f, 1.38318211e-01f, -2.57157892e-01f, -1.25923321e-01f, 1.26777232e-01f, 2.62228549e-01f, 1.55861035e-01f,
  3.85300145e-02f, -6.75120740e-04f, 5.26735857e-02f, 1.22457668e-01f, -1.33810982e-01f, 1.01686167e-02f, -3.69676873e-02f, -1.34837151e-01f, -1.64174020e-01f, -2.14933991e-01f,
  6.16937131e-02f, 1.45218596e-02f, 1.33776426e-01f, 1.91544443e-02f, 1.86502859e-02f, 4.92580160e-02f, 3.75732444e-02f, 1.35830119e-01f, 1.34267300e-01f, -3.91843803e-02f,
  -1.51606398e-02f, 1.11962974e-01f, 1.13821454e-01f, 1.03649341e-01f, 1.58362202e-02f, 3.40269767e-02f, -2.26685982e-02f, 1.06313579e-01f, 8.94221440e-02f, -1.66000128e-02f,
  -1.33288026e-01f, -5.94852827e-02f, 7.15153199e-03f, -7.87571166e-03f, 3.18487585e-02f, 3.74145657e-02f, 3.74329044e-03f, 8.81065894e-03f, -1.90186054e-02f, 7.02088280e-03f,
  1.21979322e-02f, -5.47611937e-02f, -8.98210034e-02f, -6.56731874e-02f, -2.81658340e-02f, 1.41180633e-02f, -6.72855377e-02f, -1.81230456e-02f, 1.68495381e-03f, -6.43279701e-02f,
  -4.48589884e-02f, -7.76523575e-02f, 2.11906396e-02f, -5.90806119e-02f, -3.06244940e-02f, -4.03096015e-03f, 9.93378740e-03f, -5.57610346e-03f, 4.14431840e-02f, -9.23850536e-02f,
  -2.89633758e-02f, -7.58952051e-02f, 2.49844138e-02f, -3.47868241e-02f, -8.49352032e-02f, -1.13789283e-01f, -6.48344159e-02f, 2.16610599e-02f, -1.38810708e-03f, -2.03378156e-01f,
  2.72651434e-01f, 1.03597432e-01f, 3.39757949e-02f, 7.40888044e-02f, 7.81236158e-04f, 7.21354932e-02f, 2.38065030e-02f, 2.67945207e-03f, 3.69299427e-02f, 8.01336393e-02f,
  2.09566727e-02f, 1.28422156e-01f, 5.53203688e-04f, -4.21400107e-02f, -6.43332489e-03f, -1.78203396e-02f, -7.20102042e-02f, 8.80150571e-02f, -2.69948561e-02f, -1.33882342e-02f,
  -2.60896906e-02f, -4.73739281e-02f, 1.51741251e-01f, -8.24680272e-03f, 8.64489451e-02f, 5.15311100e-02f, 1.49450809e-01f, 1.49514750e-01f, 2.79985331e-02f, 1.95465237e-02f,
  2.69635528e-01f, 3.31532270e-01f, 1.42291375e-02f, 1.82068914e-01f, 2.73343883e-02f, 2.31300239e-02f, 2.37053797e-01f, 1.01643000e-02f, -1.78713985e-02f, 1.60278410e-01f,
  -8.18939582e-02f, -1.90694436e-01f, -1.08254373e-01f, -9.89421010e-02f, -1.17030621e-01f, 1.06184997e-01f, 1.82516024e-01f, -8.32662433e-02f, -2.68794715e-01f, -9.68346000e-02f,
  -6.61365502e-03f, 1.17569014e-01f, -8.31366107e-02f, 1.06266076e-02f, 2.83380479e-01f, -2.14930270e-02f, 7.81903714e-02f, 1.62102968e-01f, -1.75757632e-02f, 2.67279893e-01f,
  9.44272876e-02f, 1.07982665e-01f, -1.48757771e-01f, -2.96764299e-02f, -1.04814945e-02f, -3.03228796e-02f, 7.44896382e-02f, -4.81038131e-02f, -7.51556549e-03f, 1.16458692e-01f,
  1.51751358e-02f, -6.75595924e-02f, 8.80274922e-02f, 1.84050249e-03f, 1.86479948e-02f, -4.46245586e-03f, 1.04069322e-01f, 5.73172085e-02f, 2.37717014e-02f, 7.43888170e-02f,
  4.53926176e-02f, 5.69479428e-02f, 4.45247777e-02f, -1.49760321e-02f, 1.39643118e-01f, -2.79961508e-02f, 1.43069148e-01f, 1.10598646e-01f, 7.86916316e-02f, 2.30665386e-01f,
  7.05076102e-03f, -8.66933912e-02f, -1.70804709e-02f, -4.33690567e-03f, 1.38329447e-03f, 8.83770874e-04f, 1.15578109e-02f, -1.90854147e-02f, 3.98611575e-02f, -3.45105790e-02f,
  -7.57069662e-02f, 3.58388461e-02f, -3.46876159e-02f, 3.58178802e-02f, -4.09191614e-03f, -1.25059895e-02f, 3.02685145e-02f, -5.21209985e-02f, -2.22593546e-02f, -8.05833936e-02f,
  -3.28618996e-02f, 9.88472253e-03f, -4.28455472e-02f, 2.05059089e-02f, 5.86267598e-02f, -2.54666563e-02f, 1.15947137e-02f, -7.50317946e-02f, -1.58431958e-02f, -1.86328474e-03f,
  4.38153967e-02f, -2.69603699e-01f, 9.65004563e-02f, 7.72190932e-03f, 1.86279826e-02f, -4.23807055e-02f, 3.05152144e-02f, -8.22556168e-02f, 1.09297745e-02f, 7.62694608e-03f,
  -9.73405968e-03f, 7.69851953e-02f, 6.74606413e-02f, -4.05645370e-02f, -7.80177712e-02f, 4.99110520e-02f, -4.97092903e-02f, 8.81862044e-02f, 2.77281236e-02f, 6.95151761e-02f,
  1.43752813e-01f, 1.78045630e-02f, -6.36740029e-02f, 1.45551665e-02f, -1.52531629e-02f, -9.07727480e-02f, 3.76278348e-02f, -5.01328520e-03f, -2.49071196e-02f, 1.02737486e-01f,
  1.50527671e-01f, -1.42905787e-01f, 6.95047453e-02f, 4.53549735e-02f, -1.69313267e-01f, -7.96009004e-02f, -2.82329798e-01f, -2.65727460e-01f, -2.56149527e-02f, -1.74755175e-02f,
  -1.38445690e-01f, -7.48449489e-02f, -2.79848482e-02f, 3.97349671e-02f, 1.53606373e-03f, 9.79891196e-02f, 7.10815340e-02f, 1.11592278e-01f, 2.98078191e-02f, -1.47014171e-01f,
  -1.46464333e-01f, 1.17354222e-01f, 1.79321244e-01f, 1.45809194e-02f, -3.22559588e-02f, 8.23838860e-02f, 4.58364189e-02f, 1.48949429e-01f, 1.16758101e-01f, 1.73377648e-01f,
  8.09206739e-02f, -2.75555700e-02f, -3.69222909e-02f, -7.85676995e-04f, -7.51158446e-02f, 2.19049975e-02f, -6.70810416e-02f, 8.10749605e-02f, -1.13862008e-01f, 2.78207362e-02f,
  -6.04679957e-02f, 4.58655600e-03f, 6.65703714e-02f, 2.50286274e-02f, 4.87700850e-02f, -4.17370424e-02f, -6.00719862e-02f, -4.91451584e-02f, -1.00238003e-01f, -1.33429036e-01f,
  -2.58365157e-03f, -3.26523818e-02f, 3.29828821e-02f, -1.57520741e-01f, -1.05820462e-01f, 7.28424564e-02f, -1.21831462e-01f, 1.99727621e-02f, 4.58645448e-02f, 6.53361008e-02f,
  5.37394881e-02f, -6.33239970e-02f, -1.18697837e-01f, -3.97024564e-02f, -9.97136608e-02f, 3.69766653e-02f, -4.16962281e-02f, 1.60712246e-02f, 2.17426177e-02f, -8.50450993e-02f,
  -1.05765693e-01f, 1.06153255e-02f, 3.55700105e-02f, -3.38783339e-02f, 7.11104199e-02f, -1.86670870e-02f, 7.63791651e-02f, -8.97187144e-02f, 7.83527568e-02f, -3.10781579e-02f,
  8.17000307e-03f, -8.59390870e-02f, 6.74761534e-02f, -3.95336077e-02f, 5.03874868e-02f, -2.30075289e-02f, -2.16459166e-02f, -1.08745344e-01f, -1.66385248e-01f, -9.09380689e-02f,
  -3.74212414e-02f, 9.60886180e-02f, 5.38306423e-02f, 5.87730184e-02f, 9.09790322e-02f, -5.72212599e-02f, 2.81275399e-02f, -1.69215985e-02f, -4.54446115e-02f, -7.73620680e-02f,
  -6.26841635e-02f, -1.78241963e-03f, 2.12664548e-02f, -1.48109561e-02f, -3.68273258e-02f, -4.59104963e-02f, -4.45002839e-02f, 1.29592970e-01f, -4.56137918e-02f, -1.23240046e-01f,
  -9.03709307e-02f, 4.92804796e-02f, -5.06432541e-02f, -4.93821804e-04f, -9.76597294e-02f, -2.93770917e-02f, -2.90210973e-02f, 2.13791383e-03f, -1.40205743e-02f, -1.96244195e-02f,
  3.20545793e-01f, 2.32105896e-01f, -6.56106248e-02f, 4.56553102e-02f, -2.09463194e-01f, -8.71916711e-02f, 2.36975420e-02f, -1.12741411e-01f, -8.42362717e-02f, 6.13181219e-02f,
  5.35187032e-03f, -6.51937798e-02f, 1.56215276e-03f, -1.53351828e-01f, -5.12243845e-02f, 6.66056201e-02f, -1.19016627e-02f, -1.61301062e-01f, -7.97874182e-02f, -3.00111800e-01f,
  -1.34243459e-01f, 2.28539314e-02f, -2.36477591e-02f, -1.25606075e-01f, -1.17158771e-01f, 4.14811261e-03f, -3.47590819e-02f, -5.35795614e-02f, -4.76389304e-02f, -8.00993368e-02f,
  1.03661701e-01f, -9.94499773e-03f, -1.56058311e-01f, -9.34098847e-03f, 4.12937850e-02f, 2.15044823e-02f, -2.63740271e-02f, -1.04349867e-01f, -3.84754725e-02f, 2.98291259e-02f,
  -7.97660053e-02f, -1.28114402e-01f, -1.47735685e-01f, -8.86227340e-02f, -1.16394266e-01f, -1.43475682e-01f, -1.26361027e-01f, -3.02243158e-02f, -1.55615047e-01f, -1.00377694e-01f,
  -2.25833237e-01f, -1.69739023e-01f, 4.61183488e-03f, -1.57701984e-01f, -1.57614931e-01f, -1.72071442e-01f, -1.52751371e-01f, -8.03501233e-02f, -1.13002136e-01f, 1.93791892e-02f,
  2.05238461e-02f, 8.62877758e-04f, 1.16305538e-02f, 2.07695253e-02f, 4.37792353e-02f, 1.03679173e-01f, 3.14123258e-02f, 2.32706387e-02f, -6.62533343e-02f, 9.05220956e-02f,
  5.06396927e-02f, 1.90067329e-02f, 5.09073166e-03f, 3.23018506e-02f, 2.73539964e-02f, 6.12450354e-02f, 8.24072119e-03f, -4.28967178e-03f, 5.39118312e-02f, 6.61889687e-02f,
  -5.32971770e-02f, -9.03615821e-03f, 8.99690613e-02f, -8.74022841e-02f, -7.57312551e-02f, 1.83304846e-02f, -1.50005901e-02f, -7.41864219e-02f, 8.53568986e-02f, -3.63140926e-02f,
  2.74660915e-01f, -1.26890108e-01f, 7.47923777e-02f, -9.52428654e-02f, -1.33498579e-01f, -1.40373200e-01f, -5.42794131e-02f, -4.84425947e-02f, -1.96748734e-01f, -1.13270737e-01f,
  -1.32400125e-01f, 8.05542586e-05f, 1.45992087e-02f, -1.05112411e-01f, -1.07315578e-01f, -1.43756554e-01f, -3.64560145e-03f, -1.10826962e-01f, -9.63876843e-02f, -1.36746109e-01f,
  -1.65167153e-01f, -1.62616447e-01f, 3.58045697e-02f, 2.49753706e-04f, -4.78488766e-02f, -7.48521090e-02f, 5.17409518e-02f, -3.69147095e-03f, -1.14067085e-02f, 1.12367235e-01f,
  6.28217578e-01f, 2.53127187e-01f, -2.89054047e-02f, 2.34577313e-01f, -1.89626113e-01f, -1.43255472e-01f, 1.13767073e-01f, 7.25497976e-02f, 1.18956789e-01f, 1.75866455e-01f,
  1.68918166e-02f, -1.80912629e-01f, 1.12741319e-02f, -1.67848736e-01f, -3.07780094e-02f, 2.58677341e-02f, 7.15092719e-02f, -4.46543060e-02f, -2.20906019e-01f, -2.03135252e-01f,
  -1.80583313e-01f, 1.65857255e-01f, 1.25035495e-01f, -2.85888393e-03f, 9.43118334e-02f, -1.70329854e-01f, 1.55146539e-01f, 1.06179006e-01f, -1.05787821e-01f, 1.15951136e-01f,
  -2.69876979e-02f, 3.03834349e-01f, -1.45068362e-01f, -3.94122414e-02f, -6.41000569e-02f, 5.33855706e-02f, 3.61604587e-04f, -1.07550540e-03f, -1.08950455e-02f, 5.59270419e-02f,
  -3.69061567e-02f, 3.91044915e-02f, -3.80516909e-02f, 3.90852354e-02f, 6.47155419e-02f, -3.13922204e-02f, 1.05506532e-01f, 1.53368905e-01f, 5.32740764e-02f, 3.11317649e-02f,
  -7.86082074e-02f, 3.63738127e-02f, 1.04348250e-01f, -1.06188223e-01f, 1.37187494e-02f, -9.28951502e-02f, -4.68725525e-02f, -9.13456604e-02f, 5.91606200e-02f, 8.59604999e-02f,
  -3.90490294e-02f, -1.33760601e-01f, -6.80585206e-02f, 3.41100655e-02f, -1.45949330e-02f, -5.04147895e-02f, 1.88785363e-02f, -9.37215984e-03f, -3.61284688e-02f, 1.28926327e-02f,
  9.64406040e-03f, 1.72965098e-02f, -5.55677861e-02f, 5.70180081e-02f, 1.07400306e-02f, -3.28797773e-02f, -3.94229591e-03f, 1.34118721e-02f, -1.01384940e-02f, 5.99636231e-03f,
  -1.62863526e-02f, 1.70769487e-02f, -5.62406285e-03f, -3.19513343e-02f, 2.12311745e-02f, -3.86354737e-02f, -8.18039011e-03f, -5.52319810e-02f, -3.94347031e-03f, -3.01758368e-02f,
  9.22281146e-02f, -5.78500554e-02f, 1.15555786e-01f, 6.63192496e-02f, 5.42049631e-02f, -4.98884805e-02f, 2.92586256e-02f, -6.22004736e-03f, -2.75419317e-02f, 1.69483498e-02f,
  1.99893266e-02f, 7.50842988e-02f, 7.01015145e-02f, -5.46426959e-02f, -4.60816212e-02f, 1.94340367e-02f, -1.52514111e-02f, 5.73916035e-03f, 1.30523043e-02f, -1.00819673e-02f,
  -4.21935432e-02f, 7.00188102e-03f, 7.07642222e-03f, -5.01613878e-02f, -2.34669726e-02f, -1.01362534e-01f, -3.27393711e-02f, -5.99418813e-03f, 3.98743115e-02f, 1.08058237e-01f,
  4.66092408e-01f, 1.00288153e-01f, 7.10237697e-02f, 2.94967234e-01f, -1.97501421e-01f, -3.56688976e-01f, -3.37025970e-01f, -2.28793565e-02f, 1.46527722e-01f, 1.13139644e-01f,
  -8.37555751e-02f, -1.36717111e-01f, 4.60002832e-02f, -1.25764206e-01f, -5.64302281e-02f, 1.14709754e-02f, 6.37577698e-02f, -4.39166985e-02f, -1.93503127e-01f, -1.75791904e-01f,
  -1.70566186e-01f, 1.77943304e-01f, 1.72623217e-01f, 7.76439756e-02f, 6.10012980e-03f, -2.93788835e-02f, 8.91902074e-02f, 1.67754069e-02f, -1.11578085e-01f, 1.68262810e-01f,
  2.38464922e-02f, 1.54728755e-01f, -9.27957520e-02f, 2.05400195e-02f, 7.15110898e-02f, 3.60306650e-02f, 5.16303554e-02f, 6.92431629e-02f, 4.36196029e-02f, 8.49404112e-02f,
  4.17651841e-04f, 4.87876311e-02f, -2.33776141e-02f, 4.23191562e-02f, 6.18076175e-02f, 1.06957024e-02f, 1.78399161e-01f, 1.38921544e-01f, 6.01578802e-02f, -6.04781993e-02f,
  -7.52267316e-02f, 1.64434072e-02f, -2.45373845e-02f, -9.63124111e-02f, -2.69054566e-02f, -6.80659413e-02f, -2.05202196e-02f, 6.83646798e-02f, -1.55135812e-02f, 2.21954048e-01f,
  -6.14573210e-02f, -2.58426182e-02f, -1.36952475e-02f, -1.19899020e-01f, -2.00729445e-02f, -3.94110456e-02f, -3.58532481e-02f, -2.21322626e-02f, -8.86770412e-02f, 6.24263212e-02f,
  -8.02894533e-02f, -8.95546526e-02f, -1.11841343e-01f, 2.56014820e-02f, -4.49998826e-02f, -3.45613174e-02f, -4.28268686e-02f, 3.85911278e-02f, -2.32291389e-02f, 1.09352758e-02f,
  -3.21337953e-02f, -3.52545194e-02f, 2.25044843e-02f, -4.00486887e-02f, -7.64500499e-02f, -1.10323809e-03f, 2.62426361e-02f, -8.30377266e-02f, 7.69637823e-02f, -3.01670767e-02f,
  1.04427874e-01f, -1.59698144e-01f, 9.08799767e-02f, -2.02576742e-02f, 3.42663098e-03f, 1.38542429e-01f, -2.15186328e-02f, 1.35955885e-02f, 2.98215318e-02f, -3.74062508e-02f,
  -4.86783832e-02f, 2.78636012e-02f, 5.91434725e-02f, 4.76101339e-02f, -6.43823519e-02f, -1.02276076e-02f, 1.98419634e-02f, -7.39102960e-02f, -4.58373502e-02f, -1.57912206e-02f,
  7.86467865e-02f, 2.14098673e-02f, -3.77824642e-02f, 7.04035461e-02f, -2.82358658e-02f, -3.09987757e-02f, -4.73304242e-02f, -1.15854196e-01f, -6.85192049e-02f, 5.22219278e-02f,
  1.34285931e-02f, 4.07082923e-02f, -4.57641780e-01f, -1.10026576e-01f, -5.66402897e-02f, -1.87504292e-01f, -1.47710785e-01f, 2.06976961e-02f, 2.38044057e-02f, 1.55309290e-02f,
  1.99292704e-01f, 2.63380378e-01f, 5.73664643e-02f, 7.23321661e-02f, -1.04584500e-01f, -3.39877397e-01f, -3.58067304e-01f, -2.91538239e-01f, 2.84264460e-02f, 4.46010530e-02f,
  2.16598257e-01f, 2.09237449e-02f, 1.05109736e-01f, -3.33862305e-02f, 1.28812529e-02f, 4.00030576e-02f, -1.60711944e-01f, -1.01847626e-01f, 3.25883143e-02f, -1.44143894e-01f,
  -3.01785618e-02f, -3.22816707e-02f, 2.16108784e-02f, 1.53000250e-01f, 8.56503565e-03f, 2.85764597e-02f, 9.28654671e-02f, 1.06210718e-02f, -1.66842435e-02f, 1.94865558e-02f,
  8.82409364e-02f, 7.61291608e-02f, 5.96835371e-03f, 2.45898217e-02f, 2.03079637e-02f, 6.97723106e-02f, 6.27251342e-02f, -1.72407687e-01f, -3.93562019e-02f, -5.02371490e-02f,
  1.33855820e-01f, 3.77456360e-02f, -1.72001302e-01f, -5.14324866e-02f, -1.04100794e-01f, 5.31517118e-02f, -4.47189957e-02f, 3.71672288e-02f, -6.52751513e-03f, 7.97152221e-02f,
  6.93119019e-02f, -9.58321020e-02f, 8.21917690e-03f, 9.29732695e-02f, 4.48106043e-02f, -6.41629994e-02f, 1.51386382e-02f, 1.65911242e-02f, -5.58465570e-02f, 4.73703966e-02f,
  -7.08872005e-02f, -2.14480162e-02f, -5.80264702e-02f, -1.58632174e-02f, 4.09914926e-02f, -7.79750794e-02f, -4.26925533e-03f, -1.29562169e-02f, -7.41508901e-02f, 1.68856047e-02f,
  -2.81959660e-02f, -6.68062419e-02f, -4.28010002e-02f, 1.69096529e-04f, 1.01374732e-02f, -6.94887117e-02f, -4.78291176e-02f, 1.08485982e-01f, 1.12015745e-02f, 7.05161989e-02f,
  2.16239914e-01f, -8.87440294e-02f, 5.56738563e-02f, 8.92003532e-03f, 1.73905138e-02f, 1.75708719e-02f, 1.01818331e-01f, 2.71336883e-02f, 3.52394432e-02f, 4.94322106e-02f,
  -1.44151263e-02f, 1.57741997e-02f, -8.81539807e-02f, 1.26240393e-02f, -4.92850840e-02f, 5.79359382e-02f, 5.08039705e-02f, 7.27074873e-03f, 8.43741931e-03f, -7.15069799e-03f,
  -6.88797235e-02f, 3.17978524e-02f, 6.09778874e-02f, -7.07940832e-02f, 3.93846631e-02f, -8.64034891e-03f, 4.22133282e-02f, -8.48833248e-02f, 2.43370123e-02f, 1.66504236e-03f
};

// L0_fan_Wp_bar (Shape: 26 x 120)
const int L0_fan_Wp_bar_rows = 26;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -5.36030531e-01f, 9.19498280e-02f, 1.59733612e-02f, 2.67957985e-01f, 4.41269636e-01f, -3.29297557e-02f, 2.03438252e-02f, -3.17254663e-01f, -6.57616183e-03f, 1.00524843e-01f,
  6.01726919e-02f, 2.96546263e-03f, 1.56830505e-01f, 6.60071149e-02f, -1.75949916e-01f, 2.14600340e-01f, 3.15418124e-01f, -9.95726362e-02f, -3.70895207e-01f, -2.66400874e-01f,
  6.41222447e-02f, -1.10760845e-01f, -4.47055101e-01f, -1.15339138e-01f, 1.32219970e-01f, 5.60267381e-02f, 1.15806848e-01f, 8.31991360e-02f, 1.04415752e-01f, 4.23267186e-01f,
  -8.18143189e-02f, -2.65928686e-01f, 1.00140624e-01f, 2.27072179e-01f, 4.33673710e-02f, -3.23176086e-01f, -1.50775209e-01f, -1.03260353e-01f, 2.24960875e-02f, -8.67242441e-02f,
  2.06185132e-01f, -6.44983426e-02f, 3.25303495e-01f, 6.84612170e-02f, -1.15942910e-01f, -2.39776924e-01f, -1.66984662e-01f, -3.40793252e-01f, -2.58749932e-01f, -3.59606266e-01f,
  3.11491996e-01f, 1.95787802e-01f, -7.66710117e-02f, -8.16404894e-02f, -2.58043438e-01f, -1.05593011e-01f, -1.91757470e-01f, -3.60692739e-01f, -4.37470913e-01f, -4.17148411e-01f,
  2.50844993e-02f, 4.17799968e-03f, 5.32203019e-02f, 2.52657924e-02f, -6.98439628e-02f, 1.43216863e-01f, 2.03899771e-01f, -1.68208834e-02f, 1.82854570e-02f, -4.18797601e-03f,
  7.53372684e-02f, -1.14649847e-01f, -1.24378338e-01f, -1.02944449e-01f, 4.12313677e-02f, -6.64841384e-02f, 5.30076884e-02f, -8.64303336e-02f, -7.95986876e-02f, -6.23138025e-02f,
  -1.42702525e-02f, -9.21933800e-02f, -9.20591236e-04f, -1.55149505e-01f, 7.08857477e-02f, -9.46399868e-02f, 6.19218536e-02f, -5.93007281e-02f, -1.68509960e-01f, -6.67545125e-02f,
  -3.07436436e-02f, 4.99844626e-02f, -6.56343880e-04f, -6.53460473e-02f, 5.53467087e-02f, -6.04733229e-02f, -2.57332120e-02f, -6.76154718e-02f, 1.87903084e-02f, -1.52367830e-01f,
  -1.16138272e-01f, -1.28036231e-01f, 7.54440352e-02f, 4.78157140e-02f, -2.35059887e-01f, -3.55068371e-02f, 1.25456080e-01f, 1.12989821e-01f, -4.07609418e-02f, -2.89332084e-02f,
  8.55586827e-02f, -1.64715230e-01f, -1.77617162e-01f, -1.26289045e-02f, 1.65470988e-02f, -1.22649036e-01f, -1.46693364e-01f, -8.11387748e-02f, -2.65911728e-01f, -2.66148180e-01f,
  -1.27530038e-01f, 4.44388241e-02f, 5.73107004e-02f, 2.84993798e-01f, 1.32843584e-01f, 6.00892529e-02f, -8.34175292e-03f, 1.63140789e-01f, 2.67386109e-01f, 2.00080276e-01f,
  2.36459658e-01f, 3.53984594e-01f, 1.94001481e-01f, 1.82234764e-01f, 7.08421394e-02f, 2.32355133e-01f, 3.23968172e-01f, 2.13442311e-01f, 1.35887973e-02f, 1.56861529e-01f,
  2.49894902e-01f, 1.00226536e-01f, -5.28634489e-02f, 1.80184051e-01f, 2.49147817e-01f, 2.74399310e-01f, 1.77924916e-01f, 1.51988924e-01f, 2.49610782e-01f, 4.97450113e-01f,
  6.12025186e-02f, -2.97402721e-02f, 9.85263661e-02f, 1.86918210e-02f, -1.16339125e-01f, -1.67498782e-01f, -6.00846373e-02f, -1.40887663e-01f, -8.84251446e-02f, -4.46737297e-02f,
  4.15172894e-03f, -4.44863597e-03f, 2.11499929e-02f, -2.41824761e-02f, -1.47633865e-01f, -7.54614696e-02f, 6.19260482e-02f, 3.27159874e-02f, 1.95136238e-02f, 2.15132721e-02f,
  2.18089148e-01f, 1.05650229e-02f, -1.52022123e-01f, -6.53454885e-02f, 5.66740297e-02f, 9.79524329e-02f, 1.06885992e-02f, 6.08754009e-02f, -1.45333320e-01f, 7.40550235e-02f,
  1.40531644e-01f, 3.49422470e-02f, 1.65372148e-01f, 1.36565089e-01f, 1.35365799e-01f, 1.04683459e-01f, 1.09240614e-01f, 8.62709954e-02f, 1.19894638e-03f, -3.45280990e-02f,
  1.87292823e-03f, -1.32475886e-02f, -3.23063396e-02f, -3.22858058e-02f, 3.99461426e-02f, 8.54982808e-02f, -6.90405723e-03f, -6.74890652e-02f, -8.37933049e-02f, 5.85750416e-02f,
  -5.89906164e-02f, -3.08507569e-02f, -4.13243584e-02f, -4.46777493e-02f, 6.94944859e-02f, 6.31545186e-02f, -2.48358231e-02f, -3.37486230e-02f, -1.32230697e-02f, -4.64824103e-02f,
  -1.26837105e-01f, -1.18700609e-01f, 2.01403022e-01f, 2.73892414e-02f, -8.64321738e-02f, -5.16710505e-02f, 7.70511404e-02f, -1.91538464e-02f, -3.83753963e-02f, -4.14891057e-02f,
  -1.05082445e-01f, -5.13698310e-02f, -2.44981702e-02f, 3.22812162e-02f, -1.46787792e-01f, -1.02035627e-01f, 1.03990296e-02f, 3.88527066e-02f, -6.19476847e-02f, -1.14682056e-01f,
  -4.58869785e-02f, 1.52917458e-02f, -4.10840996e-02f, -2.73771212e-02f, -2.34208107e-02f, -1.94662735e-02f, -1.84692383e-01f, -1.24783732e-01f, -1.72954351e-01f, -1.38992861e-01f,
  3.31137687e-01f, -6.39604986e-01f, 3.64358604e-01f, 2.15605482e-01f, 4.17419910e-01f, 3.90117943e-01f, 7.84960762e-02f, -2.87117362e-02f, 1.25686839e-01f, -4.22496945e-02f,
  -3.25237274e-01f, -2.61110097e-01f, -2.96724558e-01f, -2.79225945e-01f, -1.80515721e-01f, 3.12644541e-02f, 1.63100109e-01f, 3.37341100e-01f, 3.94141167e-01f, 1.60742491e-01f,
  -1.48070427e-02f, -1.89027702e-03f, -1.87830366e-02f, -2.69045178e-02f, -1.49300575e-01f, 9.71184522e-02f, -4.17440943e-02f, 7.12415902e-03f, -1.91136703e-01f, 2.91218441e-02f,
  -5.30625433e-02f, -1.57926470e-01f, 2.12989524e-01f, -1.55849338e-01f, -9.95374024e-02f, 3.22438776e-02f, -4.45642173e-02f, -7.61655858e-03f, -4.08513956e-02f, -1.19101154e-02f,
  -4.79557216e-02f, -3.93096469e-02f, 2.20898706e-02f, 4.82177101e-02f, 1.60251796e-01f, 9.82196406e-02f, -8.33929405e-02f, -2.62240749e-02f, -1.46277800e-01f, -9.04580206e-02f,
  -1.37822494e-01f, -4.98081930e-02f, 6.09860718e-02f, -5.80470078e-02f, -3.22095416e-02f, 1.80926472e-02f, -3.20622586e-02f, 3.23569216e-02f, -5.63537627e-02f, 8.75840187e-02f,
  1.06472924e-01f, 4.30282392e-02f, 2.98001077e-02f, 1.00767821e-01f, -4.74600382e-02f, 9.15504619e-02f, 1.06909633e-01f, 7.62686431e-02f, 8.66735950e-02f, 7.20055327e-02f,
  -4.64418754e-02f, 2.90273707e-02f, 3.23720905e-03f, -3.25497016e-02f, -4.16753739e-02f, 1.91074423e-02f, 7.98647180e-02f, -7.36382753e-02f, -4.35175449e-02f, 5.15187606e-02f,
  -9.61986557e-03f, -7.25187510e-02f, -7.73145929e-02f, -4.28780057e-02f, -2.02284187e-01f, 9.60417688e-02f, 2.78872252e-02f, -9.08142179e-02f, -5.48094846e-02f, -1.79172847e-02f,
  -2.52740860e-01f, 1.16971567e-01f, 6.55660108e-02f, -1.05406001e-01f, 8.28776136e-02f, -7.36392140e-02f, 7.64420331e-02f, -4.03517708e-02f, -1.31184995e-01f, 8.71198028e-02f,
  5.05782440e-02f, 6.20146841e-02f, -1.39241412e-01f, -5.60323782e-02f, 2.56701887e-01f, 1.34222433e-01f, -1.45654187e-01f, -2.22129449e-02f, -1.15218284e-02f, -1.17032200e-01f,
  -1.56561494e-01f, 2.25863054e-01f, 6.84183985e-02f, 1.11558996e-01f, 6.07759878e-02f, 1.30148664e-01f, 1.85528751e-02f, 5.35989329e-02f, 1.60222635e-01f, 2.01846525e-01f,
  4.42806125e-01f, 1.26472890e-01f, 1.03795856e-01f, 2.13293493e-01f, 2.34320104e-01f, 1.51309133e-01f, 2.55712569e-01f, 7.05514699e-02f, 1.10198729e-01f, 1.84188560e-01f,
  2.16036379e-01f, 1.27283350e-01f, 1.04587160e-01f, 7.98961520e-02f, 1.84776574e-01f, -9.59814414e-02f, -1.69815853e-01f, 8.87287874e-03f, 5.99085260e-03f, 1.16855642e-02f,
  4.78863064e-03f, 9.10199657e-02f, 1.30770773e-01f, -7.29047731e-02f, -2.29740173e-01f, -8.10434669e-02f, -7.81077221e-02f, -6.02248423e-02f, -4.36118841e-02f, -4.16717142e-01f,
  -1.39791846e-01f, 2.84984946e-01f, 5.06690554e-02f, 8.38341936e-02f, 1.73408240e-02f, -4.19498757e-02f, -3.67610902e-02f, -6.00498393e-02f, 6.45019263e-02f, -1.16142236e-01f,
  -4.79583070e-02f, -1.28363585e-02f, -1.60498302e-02f, -6.88743144e-02f, -5.38664311e-02f, -2.76063867e-02f, -7.42289498e-02f, -1.14315331e-01f, -1.07850850e-01f, -1.10652752e-01f,
  -1.54880211e-01f, 1.03262901e-01f, 9.94119272e-02f, 8.72199307e-04f, -1.75760370e-02f, 8.04651007e-02f, 5.39426096e-02f, -1.75375685e-01f, -2.78885718e-02f, -6.07289895e-02f,
  -8.31008237e-03f, -5.68020009e-02f, 2.10764799e-02f, -1.77418049e-02f, 1.47054819e-02f, 4.22284380e-02f, 1.18664399e-01f, 3.72575523e-05f, 1.17144771e-01f, 6.81408346e-02f,
  8.86937305e-02f, -1.42763797e-02f, 8.97813365e-02f, 5.49455397e-02f, 1.56676956e-02f, 3.19028273e-03f, 1.11441594e-02f, 6.11034855e-02f, 7.73838684e-02f, 3.11730001e-02f,
  6.31801859e-02f, -1.62852239e-02f, -8.59867111e-02f, -4.10043746e-02f, -5.12116663e-02f, -6.92632571e-02f, 1.12937048e-01f, 5.51988110e-02f, -9.83197689e-02f, -5.93637861e-02f,
  1.56541869e-01f, 4.60126579e-01f, -7.46850274e-04f, -1.74707204e-01f, -1.59013242e-01f, -5.47347106e-02f, 8.60032588e-02f, 2.57946290e-02f, 6.11157622e-03f, 2.73233764e-02f,
  -4.32732590e-02f, 4.46229093e-02f, 6.99464828e-02f, -1.20764270e-01f, 3.92962694e-02f, 1.09259464e-01f, -8.04029480e-02f, 3.29374298e-02f, 8.84956773e-03f, 8.30117706e-03f,
  -2.38919519e-02f, 1.51521727e-01f, 1.36559770e-01f, 1.37452126e-01f, 1.13990441e-01f, 3.09805423e-01f, 1.66930556e-01f, 1.43333490e-03f, 2.07152352e-01f, 1.00666337e-01f,
  4.91237752e-02f, -2.32387260e-01f, -4.23062474e-01f, -3.28592397e-02f, -1.10817499e-01f, -2.32049316e-01f, -4.54100877e-01f, -5.27860299e-02f, 1.81860313e-01f, -4.65227455e-01f,
  -1.96540996e-01f, -3.00156213e-02f, -1.80371568e-01f, -2.24910155e-01f, -3.07259351e-01f, -5.30600667e-01f, -4.28181529e-01f, -1.84514895e-01f, 1.23965137e-01f, 1.23797670e-01f,
  -7.19633251e-02f, 6.23600855e-02f, 1.05799019e-01f, 8.61895680e-02f, -1.63134485e-01f, -1.75810695e-01f, -3.42921317e-01f, -1.86226457e-01f, -4.22904164e-01f, -4.55610335e-01f,
  -4.88612145e-01f, -1.43146202e-01f, -8.71951729e-02f, -4.13550474e-02f, -5.10205366e-02f, -3.27419527e-02f, -2.77691334e-02f, 7.97704831e-02f, 9.48588084e-03f, -2.29539618e-01f,
  -3.30699347e-02f, 1.97260633e-01f, 1.19848579e-01f, -6.67431131e-02f, 1.36089355e-01f, 1.10327832e-01f, 1.52620614e-01f, -1.49165811e-02f, -1.09827213e-01f, -5.65560423e-02f,
  -9.30790305e-02f, -1.56169206e-01f, -3.22829872e-01f, -1.03921600e-01f, -8.09304789e-02f, -1.47134677e-01f, -1.27149865e-01f, -1.34238660e-01f, -1.74364612e-01f, -4.25800115e-01f,
  1.28165245e-01f, -3.82348262e-02f, -5.23873679e-02f, 1.76408097e-01f, 7.64864087e-02f, 1.01746738e-01f, 8.07358772e-02f, -2.61882856e-03f, 5.16512245e-02f, 1.13941275e-01f,
  1.36942625e-01f, -1.10881468e-02f, 1.62975997e-01f, -1.12653568e-01f, -1.52691007e-01f, -5.81312478e-02f, -1.47134960e-01f, -1.29610047e-01f, -1.65261358e-01f, 2.77806595e-02f,
  1.97489560e-02f, 5.39636761e-02f, -6.27576485e-02f, 8.48584995e-03f, -2.07315370e-01f, -8.50643814e-02f, 9.74162668e-03f, -1.09233648e-01f, 1.03472434e-01f, -1.27790898e-01f,
  6.06926605e-02f, -6.27416223e-02f, -2.81108230e-01f, -8.29523578e-02f, -8.07603821e-03f, 1.50888756e-01f, -6.51800931e-02f, 1.58210680e-01f, 8.05869028e-02f, 4.21233755e-03f,
  -9.39431489e-02f, -2.59611364e-02f, -5.81497550e-02f, 2.77554393e-02f, 9.06720087e-02f, 1.58507545e-02f, -6.65896311e-02f, -1.96871720e-02f, 3.82724255e-02f, 9.08691138e-02f,
  3.03821005e-02f, -2.68317074e-01f, -2.16211408e-01f, -8.18919837e-02f, 1.77999344e-02f, -1.32947370e-01f, -1.99732259e-01f, -1.12210348e-01f, -2.80901313e-01f, -2.34832436e-01f,
  -2.30278373e-01f, 2.30734199e-02f, -2.64165044e-01f, 2.09990144e-01f, 1.53379068e-01f, -2.90553365e-02f, -7.04859048e-02f, 1.53526906e-02f, 1.40449837e-01f, 1.78660318e-01f,
  2.47286871e-01f, 2.86577284e-01f, 3.97681803e-01f, 2.52034128e-01f, 1.00397848e-01f, 4.29775901e-02f, 1.04356892e-02f, -4.16001752e-02f, 6.49739951e-02f, -5.45656234e-02f,
  1.01690501e-01f, -4.29872125e-02f, -1.22880533e-01f, -8.39610323e-02f, 1.01388641e-01f, 2.93675840e-01f, 1.15431212e-01f, -9.55950469e-03f, 1.40469849e-01f, -3.48238572e-02f,
  1.67797059e-01f, -3.11532050e-01f, 5.90343922e-02f, 7.09425658e-03f, -6.20101131e-02f, -2.21601456e-01f, -1.22165672e-01f, -2.19101787e-01f, -3.58137339e-02f, -6.20286949e-02f,
  -4.09335047e-02f, -1.40358999e-01f, 6.56836480e-03f, -1.02443293e-01f, -8.83226022e-02f, -1.45068511e-01f, -1.45763725e-01f, -1.62423730e-01f, -1.77936345e-01f, -1.35385245e-01f,
  1.15668647e-01f, -2.01548323e-01f, -1.48917615e-01f, -7.40419179e-02f, -1.15928493e-01f, 1.44525379e-01f, -2.33358387e-02f, -1.05787322e-01f, -2.98798326e-02f, -2.49880880e-01f,
  2.20491458e-02f, -1.82780847e-02f, 7.45728239e-02f, -1.23166077e-01f, 1.22035675e-01f, 8.75264555e-02f, -4.18847837e-02f, 3.18171494e-02f, -9.03821662e-02f, -2.55711470e-02f,
  -3.10840085e-02f, 3.51893678e-02f, -6.98061734e-02f, 8.53925496e-02f, 1.54823199e-01f, -1.58806928e-02f, 5.81778400e-02f, 1.03399351e-01f, -2.10720692e-02f, -2.99403612e-02f,
  1.92423880e-01f, -7.41709024e-02f, 2.57041007e-02f, 2.52852440e-02f, 1.13981245e-02f, 1.93017144e-02f, -1.46304723e-02f, 1.57519460e-01f, 7.18425587e-02f, -6.30256832e-02f,
  3.61282349e-01f, 4.71501425e-02f, 4.25036028e-02f, -7.88711533e-02f, -1.01878323e-01f, -1.95433088e-02f, 1.62516892e-01f, -6.54024258e-02f, -8.97495523e-02f, 2.56449264e-02f,
  2.58549806e-02f, 5.05669937e-02f, -2.75155511e-02f, -1.16071336e-01f, -3.73518355e-02f, 5.93274646e-02f, 6.63323328e-02f, -3.91520374e-02f, -1.38340490e-02f, -1.24639710e-02f,
  9.54830199e-02f, -4.91251573e-02f, -8.58612210e-02f, -1.05014984e-02f, -5.46973315e-05f, 1.82892382e-01f, 5.90970553e-03f, -5.82943112e-02f, -1.68756600e-02f, -7.39226397e-03f,
  6.73515260e-01f, -2.79143870e-01f, -4.79734838e-01f, 2.24255249e-01f, 2.16210797e-01f, 2.31444195e-01f, 2.13327348e-01f, 1.68639675e-01f, 1.76440507e-01f, 8.84833634e-02f,
  -8.11945796e-02f, -6.11880161e-02f, -1.15733407e-01f, -7.15046972e-02f, -4.58384641e-02f, -2.06066370e-01f, -1.59480825e-01f, -1.84863612e-01f, 1.84632957e-01f, 2.52800375e-01f,
  7.03846663e-02f, 1.77477762e-01f, 1.91177607e-01f, 4.11722474e-02f, -1.98076516e-01f, -1.08932108e-02f, -3.55659902e-01f, -2.96421289e-01f, -2.06045628e-01f, -4.70665127e-01f,
  -4.10347551e-01f, -1.88482240e-01f, 1.18120104e-01f, 5.29333875e-02f, -1.06310554e-01f, 4.67795171e-02f, 9.67435315e-02f, -3.51272933e-02f, 3.60099711e-02f, 8.96648914e-02f,
  -6.52008951e-02f, -9.21956003e-02f, -8.52120891e-02f, -7.30557069e-02f, 5.94209917e-02f, 9.16221812e-02f, -1.10234246e-01f, -2.98089031e-02f, -1.01502143e-01f, -1.22103654e-01f,
  -5.38424216e-02f, -3.70095298e-02f, -8.56754996e-05f, 2.28848048e-02f, -1.64151132e-01f, -5.54578751e-03f, -8.72854441e-02f, -1.85472697e-01f, -8.09567608e-03f, -9.37374458e-02f,
  -5.98309236e-03f, -8.76030549e-02f, -1.34457335e-01f, 2.20628921e-02f, 6.27370253e-02f, -5.84925301e-02f, 3.37896426e-03f, -4.66444567e-02f, -3.04975156e-02f, 7.17197806e-02f,
  3.17730606e-02f, -7.74425492e-02f, -7.42334872e-02f, -5.36624575e-03f, -1.20590404e-01f, -1.64112411e-02f, -1.43648423e-02f, -1.18591242e-01f, -3.62297893e-02f, 9.53789726e-02f,
  2.03624670e-03f, -1.34152919e-01f, -7.04617426e-02f, -8.05252045e-02f, -2.65075900e-02f, -5.96022159e-02f, 6.47248747e-03f, -3.39294001e-02f, 7.83166960e-02f, 1.41240969e-01f,
  2.24203721e-01f, -9.04161632e-02f, 1.21578671e-01f, -1.19422814e-02f, -8.27028006e-02f, -4.14542109e-02f, -2.35751167e-01f, -1.03988938e-01f, -4.80923131e-02f, -4.97489944e-02f,
  -1.04015969e-01f, -4.80558909e-02f, -3.97842154e-02f, 6.33106604e-02f, 1.98123708e-01f, -4.47153039e-02f, -6.31885778e-04f, -6.08184226e-02f, 2.99554970e-02f, 2.73523689e-03f,
  -6.11401945e-02f, 8.65298882e-02f, 2.04144686e-01f, 1.53460443e-01f, 3.80273536e-02f, 1.14267349e-01f, 3.75853814e-02f, 3.28303725e-02f, 1.56356290e-01f, 3.40401083e-01f,
  -3.49114835e-01f, -3.70921224e-01f, -2.31409416e-01f, -4.06179786e-01f, -4.20351207e-01f, -1.83724791e-01f, -1.08949207e-01f, 2.26652226e-03f, -2.36691609e-01f, -3.05291116e-01f,
  3.44369151e-02f, 4.85252202e-01f, 5.46159334e-02f, 1.77305728e-01f, 2.51579672e-01f, -4.08279568e-01f, -6.04858279e-01f, -5.00394683e-03f, 4.54856634e-01f, 3.29864144e-01f,
  1.20887019e-01f, -9.06609893e-02f, -1.77894413e-01f, -1.33484319e-01f, -4.13315535e-01f, 5.26196957e-02f, -5.03486812e-01f, -3.68279546e-01f, -2.75234103e-01f, -5.72751641e-01f,
  3.45896989e-01f, -2.49277771e-01f, 7.85342529e-02f, -5.43746399e-04f, -1.11019559e-01f, -2.24136431e-02f, -1.42888110e-02f, -9.38129351e-02f, -7.57622421e-02f, -1.24025039e-01f,
  -4.68813293e-02f, 6.18359186e-02f, 1.25194103e-01f, 9.22919884e-02f, 1.21375518e-02f, 4.80546728e-02f, -2.07608640e-01f, 2.12375540e-02f, -1.53218806e-01f, 1.48111442e-03f,
  4.97336537e-02f, -3.63504924e-02f, -7.63159990e-03f, -6.27889335e-02f, 1.26398038e-02f, 2.08676048e-02f, -4.77932170e-02f, -1.03118956e-01f, -2.72226445e-02f, -2.32210845e-01f,
  3.03822514e-02f, 8.41710344e-02f, -6.37921989e-02f, -7.96452165e-03f, -4.61421236e-02f, 4.52382378e-02f, 2.87914113e-03f, 2.69952249e-02f, 3.88872623e-02f, 8.66564661e-02f,
  5.94917387e-02f, -7.00927675e-02f, -1.64881106e-02f, -2.18509715e-02f, -5.56907505e-02f, -1.09204687e-01f, 5.55151217e-02f, 7.40394145e-02f, -7.00615942e-02f, -1.51447520e-01f,
  6.02344945e-02f, -9.77546647e-02f, -1.36058792e-01f, 1.90078933e-02f, -1.02956325e-01f, 1.88921317e-02f, -5.08645549e-02f, 1.11357853e-01f, -7.23218247e-02f, -9.74739641e-02f,
  4.00435805e-01f, -8.44240189e-02f, -9.68559608e-02f, 1.34927809e-01f, -1.13431521e-01f, -1.58086285e-01f, -1.62451640e-01f, -2.18972322e-02f, -6.00696169e-02f, 4.54238690e-02f,
  -9.78735927e-03f, 1.46873340e-01f, -9.63870157e-03f, 2.30521560e-02f, -4.26407624e-03f, 8.01330991e-03f, -1.22234831e-02f, 1.74467694e-02f, -6.40288666e-02f, -9.48459059e-02f,
  -8.81513432e-02f, -6.28610030e-02f, 1.65269211e-01f, 3.64585035e-02f, 2.48220116e-02f, 9.55065414e-02f, 3.52482647e-02f, 1.05467342e-01f, 2.27562338e-01f, 8.35176036e-02f,
  8.58746618e-02f, 4.45700854e-01f, 1.86135441e-01f, -4.62335767e-03f, 3.91208827e-02f, 1.46891847e-01f, 3.11814904e-01f, 1.03103623e-01f, 7.09883720e-02f, 8.27532820e-03f,
  -3.80254053e-02f, -1.64128780e-01f, -2.12226361e-02f, 1.85363069e-01f, 2.39355549e-01f, 2.91501671e-01f, 2.73620397e-01f, 9.44844782e-02f, 3.13404314e-02f, 1.54892966e-01f,
  6.63188919e-02f, 1.44170091e-01f, 9.87175331e-02f, 1.71888500e-01f, 2.67155111e-01f, 4.99778874e-02f, 1.21022813e-01f, 1.13455795e-01f, 1.69203773e-01f, 3.30961972e-01f,
  1.52830230e-02f, 6.20935997e-03f, -1.06282160e-01f, -8.75269845e-02f, -6.44393414e-02f, 3.70588638e-02f, -8.31905976e-02f, -1.16008848e-01f, -2.21878346e-02f, 3.82077545e-02f,
  -7.64877051e-02f, 5.14607765e-02f, 4.60767150e-02f, 1.49016986e-02f, -3.66632417e-02f, 1.38961971e-02f, 9.83571261e-02f, 1.14788803e-04f, -4.97438796e-02f, 5.31233847e-03f,
  6.90423176e-02f, -6.11313842e-02f, -2.67853528e-01f, -1.01551078e-01f, 4.90121394e-02f, -6.71351776e-02f, -1.06655739e-01f, 1.99659802e-02f, -1.56588197e-01f, -5.84582761e-02f,
  -2.72557169e-01f, 3.57204564e-02f, -2.78235134e-02f, 4.44414988e-02f, -6.33919204e-04f, -5.55570945e-02f, -7.62574524e-02f, -2.79107280e-02f, -2.53255479e-02f, -1.19252406e-01f,
  -1.98529020e-01f, -2.02360451e-01f, -4.14005965e-02f, -1.41424209e-01f, -1.49373785e-01f, -8.73169079e-02f, -1.71190798e-02f, 2.04038043e-02f, -1.04180321e-01f, -6.98970035e-02f,
  -9.96867474e-03f, -3.17522703e-04f, -1.61596492e-01f, 4.42051329e-02f, -3.58119830e-02f, -5.83573692e-02f, -7.24431053e-02f, -1.91533253e-01f, -1.24425359e-01f, -1.41352311e-01f,
  -1.08091481e-01f, -1.88315943e-01f, -7.87054971e-02f, 2.90712804e-01f, 1.00617036e-01f, 1.21890493e-01f, 2.29456127e-02f, 7.37648830e-02f, 5.12997210e-02f, 1.79679859e-02f,
  5.65359294e-02f, 1.23742633e-01f, 1.96860656e-02f, -1.77727304e-02f, -1.43076241e-01f, -1.81980014e-01f, -3.08758169e-02f, 3.09461188e-02f, -2.32404172e-02f, -9.52894613e-02f,
  -1.70668773e-02f, -2.76536584e-01f, -3.00607353e-01f, -9.03318897e-02f, -8.17783698e-02f, -3.70743632e-01f, -2.11014092e-01f, -4.01677750e-02f, -1.30029514e-01f, -2.04296052e-01f,
  4.76808816e-01f, -1.25584543e-01f, 2.06636623e-01f, 1.45846993e-01f, 2.95920640e-01f, 2.34851524e-01f, 2.12020516e-01f, 2.15389982e-01f, 7.94008598e-02f, 1.27678812e-01f,
  1.89186424e-01f, 4.28558141e-02f, 1.34492442e-01f, 3.74338925e-02f, 2.67992243e-02f, -4.94863652e-03f, -5.53050637e-02f, 1.75096765e-01f, 2.42598802e-01f, 1.61710620e-01f,
  -5.44625483e-02f, 7.02880546e-02f, 8.37820470e-02f, 6.53271601e-02f, -7.61829764e-02f, -3.20421457e-02f, 8.93799737e-02f, 3.78652960e-02f, 3.67318243e-02f, -1.77532345e-01f,
  -5.63343465e-02f, 4.72719409e-03f, 1.94142148e-01f, -5.42944968e-02f, -4.10279632e-02f, -1.21332034e-01f, -8.09503421e-02f, -8.54268223e-02f, -1.71621680e-01f, -3.46344821e-02f,
  -2.90147550e-02f, -4.39350270e-02f, 1.73893161e-02f, -1.35819390e-01f, -6.09354861e-02f, -7.21159391e-03f, -4.41251993e-02f, 1.22417100e-02f, -1.24276951e-01f, -4.79823127e-02f,
  -9.99937728e-02f, 2.47718440e-03f, 1.02731884e-01f, -8.15425590e-02f, 1.62982251e-02f, 5.34380004e-02f, 4.70403954e-02f, -1.48556894e-02f, 5.19120693e-02f, 3.64271998e-02f,
  6.65487796e-02f, 7.52880573e-02f, -5.56652341e-03f, -2.86056083e-02f, -6.35017827e-02f, 8.87688808e-03f, -1.17555693e-01f, 4.85712737e-02f, 3.74024287e-02f, 3.23067605e-02f,
  -1.20670423e-02f, -1.36157097e-02f, -4.21517268e-02f, 9.52369124e-02f, 1.23422869e-01f, 1.52617637e-02f, -1.30860899e-02f, -8.53696391e-02f, 1.12201147e-01f, 4.56439937e-03f,
  1.48239434e-01f, -8.22406169e-03f, 6.20074160e-02f, -1.20735236e-01f, 7.93802068e-02f, 6.46666214e-02f, 9.48414057e-02f, -3.40900160e-02f, 6.31833300e-02f, 2.52898354e-02f,
  -1.29415199e-01f, 8.67618397e-02f, 1.14772439e-01f, -1.69101730e-01f, -8.17794949e-02f, -6.01261780e-02f, -3.89712001e-03f, -1.50543330e-02f, -8.43193829e-02f, -4.38286662e-02f,
  -1.38072610e-01f, 2.67099664e-02f, -1.35365978e-01f, 1.03317490e-02f, 1.10160537e-01f, -3.12200026e-03f, -8.85616392e-02f, -1.18069679e-01f, -1.66922331e-01f, -8.26014504e-02f,
  -3.68952975e-02f, -2.07326245e-02f, 2.84428969e-02f, 6.82261437e-02f, 2.91256630e-03f, -3.30461115e-02f, -4.92547713e-02f, -4.63302992e-02f, 3.94942053e-02f, 4.12370376e-02f,
  -3.57520819e-01f, -3.61035794e-01f, 3.77655745e-01f, -2.49975964e-01f, 1.05047502e-01f, 1.13718919e-01f, 5.34578562e-02f, -6.86667040e-02f, -2.44665980e-01f, 7.28037627e-03f,
  -1.55608682e-02f, -6.70693889e-02f, -1.38898790e-01f, -1.88812669e-02f, -1.22072317e-01f, 2.66092457e-02f, 7.29784593e-02f, 9.04045627e-02f, 2.90287048e-01f, 2.29475886e-01f,
  8.35499838e-02f, 3.86846662e-02f, -1.67949975e-01f, -6.83807805e-02f, 1.40528098e-01f, 7.70657510e-02f, 1.35278687e-01f, 3.82332946e-03f, -4.17669080e-02f, 1.44977018e-01f,
  4.52422917e-01f, -2.74708509e-01f, 3.32635157e-02f, -2.59157121e-01f, -9.23085362e-02f, -6.05115406e-02f, -4.83100750e-02f, -4.04697023e-02f, -2.07544863e-01f, 6.50339276e-02f,
  -1.09348260e-01f, -3.71672958e-02f, -5.37683517e-02f, 8.15324113e-03f, 2.62813810e-02f, 5.78276627e-02f, -7.31230676e-02f, -1.04627408e-01f, -1.40461981e-01f, -3.90626118e-02f,
  -1.86609864e-01f, -1.71033800e-01f, 5.85879125e-02f, -1.92390103e-02f, -2.10915402e-01f, -1.13451861e-01f, -8.02255645e-02f, -5.95335774e-02f, -6.65040091e-02f, 2.59151515e-02f,
  -7.16836452e-02f, 2.14371886e-02f, -5.53383939e-02f, 2.68425234e-02f, -5.75496666e-02f, 1.87204464e-03f, 6.38455302e-02f, 1.58129260e-02f, -3.17861065e-02f, 7.92581588e-02f,
  -2.78605949e-02f, -3.38417105e-02f, -3.24146971e-02f, -3.93047230e-04f, -8.19772929e-02f, -1.04234263e-01f, -3.72542627e-02f, -7.65512958e-02f, -1.32709995e-01f, -1.04694404e-01f,
  -1.59467012e-01f, 1.16629163e-02f, 4.89473939e-02f, 5.92989661e-02f, -1.20969906e-01f, -1.65974006e-01f, -5.13368659e-02f, -9.01551545e-02f, -1.10933706e-01f, 2.89434120e-02f,
  1.25524908e-01f, -3.84272069e-01f, 2.51681864e-01f, -5.87159842e-02f, 3.16407569e-02f, -7.33493567e-02f, -5.05473614e-02f, -4.87399101e-02f, 1.31239714e-02f, 8.46911967e-02f,
  -5.82495779e-02f, 5.57164811e-02f, 8.11686087e-03f, 8.13738629e-02f, 1.36917278e-01f, 1.18231215e-01f, -1.28378764e-01f, 1.08799309e-01f, -4.75813895e-02f, 1.15724258e-01f,
  -6.83849528e-02f, 1.26513541e-01f, 9.19662267e-02f, 8.62381756e-02f, 8.84399042e-02f, 1.47814810e-01f, 3.11733335e-01f, 1.67533889e-01f, 1.21393055e-01f, 2.30531365e-01f,
  -3.48824590e-01f, 2.22034469e-01f, -2.58164883e-01f, -3.15213986e-02f, -3.06187779e-01f, -3.67183983e-01f, 2.00726151e-01f, -2.94169150e-02f, 5.56719750e-02f, 3.72113317e-01f,
  1.87653035e-01f, -1.18097097e-01f, 9.35489312e-02f, -3.00963670e-02f, -4.15563211e-02f, 3.18469942e-01f, -1.33417174e-01f, -2.72251457e-01f, -6.32705450e-01f, -4.82581615e-01f,
  -2.16171473e-01f, -1.48653597e-01f, -2.55152851e-01f, -2.14535609e-01f, 2.02286631e-01f, -2.10797787e-02f, 1.93149105e-01f, -1.19033895e-01f, -1.57776833e-01f, 8.84922966e-02f,
  2.01924294e-01f, -1.74280435e-01f, -2.52935559e-01f, -3.66531044e-01f, 1.09120049e-01f, -5.82025535e-02f, 3.04497406e-02f, -2.72955410e-02f, -1.08834133e-01f, 2.14156453e-02f,
  -2.78821111e-01f, -1.60474226e-01f, -2.25911215e-01f, -5.79134934e-02f, -9.10785496e-02f, -1.28864661e-01f, -1.07756004e-01f, -1.28948361e-01f, -5.92217892e-02f, -6.73726350e-02f,
  -2.33625080e-02f, -1.92994475e-01f, -1.73606738e-01f, 8.68177041e-02f, 9.47204903e-02f, -2.52173901e-01f, 9.41077024e-02f, -1.22024538e-02f, -7.29321837e-02f, 4.04390126e-01f,
  9.04137492e-02f, 1.17960587e-01f, 4.47120033e-02f, 6.29823059e-02f, 1.67076424e-01f, 1.05202399e-01f, -3.50490510e-02f, 2.03348219e-01f, -4.51761745e-02f, 1.27207309e-01f,
  4.03732136e-02f, 1.80347376e-02f, 1.07314162e-01f, 1.30911276e-01f, 1.37627432e-02f, -1.10502549e-01f, -2.14121677e-02f, 2.19612077e-01f, 2.02316809e-02f, 1.11657977e-02f,
  -8.44740942e-02f, -3.83097343e-02f, -7.63792312e-04f, 5.58426306e-02f, -1.53605059e-01f, -3.11648473e-02f, -1.53939113e-01f, 1.91853140e-02f, -1.09679647e-01f, -2.01820523e-01f,
  3.22984666e-01f, -2.66753823e-01f, 2.82579333e-01f, -4.10381556e-02f, 8.35436806e-02f, -2.84014866e-02f, 8.37990865e-02f, 5.91881163e-02f, -5.13820425e-02f, -8.92960876e-02f,
  -2.04259485e-01f, 1.36365771e-01f, 8.17423016e-02f, 2.78514493e-02f, 5.40459864e-02f, 3.33513469e-02f, 7.77977481e-02f, -5.58103509e-02f, -1.66393787e-01f, 5.42398961e-03f,
  6.92397403e-03f, 3.04340124e-02f, 1.76775575e-01f, 1.50131181e-01f, 2.02843174e-02f, -8.07122067e-02f, 2.12783486e-01f, 2.09297962e-03f, -6.40366748e-02f, 5.81830144e-01f,
  6.40965283e-01f, 2.28845000e-01f, 1.81925446e-01f, 1.04157791e-01f, 7.61640966e-02f, -1.70703065e-02f, 5.03683165e-02f, 7.95738026e-02f, -6.45925328e-02f, 1.57925084e-01f,
  2.21638605e-01f, 1.57450423e-01f, 1.91824317e-01f, 2.88647264e-02f, 1.20322563e-01f, -7.06346706e-02f, -6.29234910e-02f, 1.31990924e-01f, 1.53342426e-01f, 1.65186673e-01f,
  -2.41912995e-02f, 9.73394960e-02f, 1.62624791e-01f, 7.95375928e-03f, 5.66159375e-02f, -1.90816503e-02f, -3.99215743e-02f, 4.45644818e-02f, 1.54078886e-01f, -2.65101008e-02f,
  2.57155567e-01f, 4.87271667e-01f, -1.78508863e-01f, 9.49873924e-02f, 1.36272728e-01f, -7.10777566e-02f, 3.65343003e-04f, -6.20629229e-02f, -9.03800037e-03f, -1.31888270e-01f,
  3.34022269e-02f, 5.96567653e-02f, -2.25440804e-02f, -1.67535841e-02f, -1.32739432e-02f, 8.05477947e-02f, 5.49321845e-02f, -4.45321128e-02f, -9.50931571e-04f, 7.19564334e-02f,
  5.56707643e-02f, 6.56987429e-02f, 9.77819506e-03f, -1.20737582e-01f, 7.08574280e-02f, -4.61993180e-03f, 7.70977605e-03f, 1.47634640e-01f, 4.31245677e-02f, -7.15608057e-03f,
  1.95395425e-01f, 1.86590970e-01f, 1.50545731e-01f, 1.48534298e-01f, 6.36172742e-02f, 1.37847364e-01f, -7.74787553e-03f, 7.40599260e-02f, 5.04352860e-02f, 1.03660703e-01f,
  6.88957274e-02f, 7.15415878e-03f, -1.04591046e-02f, 2.75136754e-02f, 8.55154395e-02f, 6.62731454e-02f, 9.41069126e-02f, -2.49274094e-02f, 6.55142441e-02f, 8.27630423e-03f,
  5.34615293e-02f, -2.29433421e-02f, 9.95431244e-02f, 5.88979386e-02f, -6.30248636e-02f, 1.27388656e-01f, 6.20901920e-02f, 1.19998001e-01f, 1.11518115e-01f, 7.70284086e-02f,
  -3.98288459e-01f, 1.31211802e-02f, 4.14252616e-02f, 3.13544273e-02f, -5.09489439e-02f, -7.57714137e-02f, -2.26715393e-02f, -4.02764827e-02f, -3.45462151e-02f, -1.60992816e-01f,
  -6.56681731e-02f, -3.30277458e-02f, 1.20635927e-02f, -7.65972063e-02f, -1.18790850e-01f, -9.84509587e-02f, -1.19900178e-04f, 1.90482549e-02f, -6.37366921e-02f, -4.24861088e-02f,
  -1.45963401e-01f, -1.96315557e-01f, -1.35053098e-01f, -1.09870292e-01f, -5.37396148e-02f, -3.67491879e-02f, -6.96555227e-02f, -2.84455456e-02f, -4.06840295e-02f, -5.40143996e-02f,
  2.80554235e-01f, 1.59259841e-01f, 1.44410595e-01f, 1.47488892e-01f, -8.99318829e-02f, -4.74442095e-01f, -6.46502495e-01f, -3.71241063e-01f, 8.18142816e-02f, 1.36053443e-01f,
  1.66775316e-01f, 2.48741567e-01f, 1.92411378e-01f, -8.71111453e-02f, -2.26462498e-01f, -1.06705993e-01f, 1.44801559e-02f, -5.36978282e-02f, -2.66094178e-01f, -3.04593205e-01f,
  -1.21862456e-01f, -1.84950174e-03f, -9.39312652e-02f, -1.47075281e-01f, 2.83944309e-01f, 7.99104199e-02f, 1.54239252e-01f, 2.92113364e-01f, 1.71718031e-01f, 6.29709661e-01f,
  4.95180130e-01f, 8.13274905e-02f, -2.02512324e-01f, 2.22024899e-02f, 2.17606723e-01f, 4.77362722e-02f, 2.30038427e-02f, 1.80728406e-01f, 8.39557673e-04f, 9.74982902e-02f,
  2.02756226e-01f, 9.13137645e-02f, -1.83537733e-02f, -1.36202089e-02f, -7.11632371e-02f, -2.09803298e-01f, -7.35630319e-02f, -1.60257116e-01f, -2.35986784e-02f, 3.20742242e-02f,
  8.08678865e-02f, 5.11543527e-02f, -2.33600754e-02f, -1.96066752e-01f, 4.21307199e-02f, 1.17584176e-01f, -8.01678374e-02f, 3.65154743e-02f, -3.77993099e-02f, 1.99441314e-01f,
  1.49935028e-02f, 2.15682164e-02f, 5.44275567e-02f, 9.50215980e-02f, -6.54698163e-02f, 9.34357941e-02f, 7.30482936e-02f, -1.42200366e-02f, -3.63911986e-02f, 2.13765521e-02f,
  -2.64677498e-02f, 5.67025132e-02f, 1.30338045e-02f, 3.26886624e-02f, -5.11759939e-03f, 3.05580664e-02f, 1.44700194e-02f, -7.25710467e-02f, -1.71808321e-02f, -1.19581018e-02f,
  7.63325244e-02f, -2.80136485e-02f, 8.51423740e-02f, 6.45220652e-03f, 2.74150800e-02f, 2.88791023e-02f, 7.73972571e-02f, 4.10250500e-02f, -1.14133582e-02f, 1.31553084e-01f,
  -3.56164053e-02f, -3.71457368e-01f, 1.72210068e-01f, -6.92140982e-02f, 4.20962647e-02f, -2.73291394e-02f, 2.01308236e-01f, -7.45497793e-02f, 1.82386771e-01f, -3.98751460e-02f,
  -1.35469019e-01f, 7.49101043e-02f, 1.35785699e-01f, -9.23710242e-02f, -4.39083017e-02f, 1.73208173e-02f, -2.39759088e-02f, -5.42203672e-02f, -9.67826322e-02f, 7.40855187e-02f,
  -1.21625319e-01f, -4.43962336e-01f, -2.84549862e-01f, -2.10091546e-01f, -4.77117002e-02f, -1.78715885e-01f, -1.22049101e-01f, -1.45254806e-01f, -2.60556936e-01f, -2.90685117e-01f,
  4.48302962e-02f, -1.62867792e-02f, 5.22525609e-02f, 1.85541138e-01f, 1.93062603e-01f, -6.42291978e-02f, -3.57267708e-01f, -2.85971791e-01f, 1.91997170e-01f, 1.72808468e-02f,
  2.03577191e-01f, 3.87144014e-02f, -1.52946496e-02f, -2.27147385e-01f, -6.00457609e-01f, -3.69487047e-01f, -3.23642045e-01f, -5.01947343e-01f, -6.27623379e-01f, -3.63575548e-01f,
  -5.12473471e-02f, -2.31585205e-01f, -2.50621706e-01f, -3.03792059e-01f, 3.25136393e-01f, 9.66385528e-02f, 1.36542812e-01f, 4.05864865e-02f, 1.68759357e-02f, 1.77216530e-01f,
  7.59384856e-02f, 1.79081261e-01f, -8.05739462e-02f, 4.13378105e-02f, -2.24932786e-02f, -3.69824357e-02f, -1.12415768e-01f, 2.27691662e-02f, -8.73199478e-03f, -1.01522297e-01f,
  5.42973354e-02f, 2.77285036e-02f, 1.71188861e-02f, 2.11517680e-02f, -1.15866594e-01f, -1.24035090e-01f, -1.72174081e-01f, -3.41227472e-01f, -1.59724608e-01f, -5.37165105e-02f,
  9.37404633e-02f, 5.01119196e-02f, -1.40589088e-01f, -5.79914935e-02f, -2.08026052e-01f, -1.72769815e-01f, -7.70394802e-02f, 3.72900777e-02f, -2.47782573e-01f, -3.29538621e-02f,
  -9.76465791e-02f, -8.36526230e-02f, 5.18059246e-02f, 4.78762724e-02f, -1.02713302e-01f, 1.16197936e-01f, -7.85468444e-02f, -1.72991063e-02f, -1.14237554e-01f, -8.27073082e-02f,
  6.11207932e-02f, 6.65818229e-02f, -3.14158940e-04f, -4.35259081e-02f, 3.74024711e-03f, -5.67213632e-02f, 8.39007050e-02f, -1.20426573e-01f, -7.52411336e-02f, 2.01911964e-02f,
  -1.06644377e-01f, 4.32193913e-02f, 1.15949318e-01f, -1.41622424e-01f, -2.20784582e-02f, -1.30976588e-01f, 8.24880227e-02f, -1.11382820e-01f, -8.07151571e-02f, 1.89066138e-02f,
  -4.77536321e-02f, -1.80420309e-01f, 1.29652947e-01f, -2.43630365e-01f, -1.37837112e-01f, 1.25236765e-01f, 1.09542996e-01f, -7.89774582e-02f, 1.66210607e-01f, -1.49514586e-01f,
  -9.55435410e-02f, -6.45897686e-02f, 1.26705542e-01f, 3.46835703e-02f, -1.75214887e-01f, 2.41375621e-02f, -3.57226908e-01f, 5.00574373e-02f, -2.25170732e-01f, 7.19475225e-02f,
  -9.75048542e-02f, -2.82142758e-01f, -1.99291721e-01f, 1.96849275e-02f, -6.75053149e-02f, -1.78353891e-01f, -1.35845870e-01f, 2.38608196e-03f, -3.90037388e-01f, -2.42991894e-01f,
  -4.96301651e-01f, -3.61245900e-01f, 5.68404555e-01f, -3.73229027e-01f, -3.49152803e-01f, -2.94876516e-01f, -3.60473692e-01f, -7.96964541e-02f, -1.29220992e-01f, -1.41078010e-01f,
  -1.99545473e-01f, -1.99981064e-01f, -7.66817331e-02f, 1.77625358e-01f, 8.31048861e-02f, 9.87371951e-02f, 2.41552860e-01f, 5.08771837e-01f, 2.47703567e-01f, -2.22923517e-01f,
  -3.21808130e-01f, -5.13481610e-02f, 1.77365050e-01f, 2.72810787e-01f, -2.93681979e-01f, -1.43001765e-01f, 1.82886377e-01f, -1.43629462e-02f, 1.91603731e-02f, 2.32482553e-02f,
  -1.56070525e-02f, 1.79195348e-02f, 1.49227455e-01f, -2.95809489e-02f, -5.47417998e-03f, 1.36363786e-03f, 8.25381838e-04f, 1.35337532e-01f, -3.85361575e-02f, 1.74807951e-01f,
  -3.17666113e-01f, -7.20786164e-03f, -2.92556405e-01f, -1.45498708e-01f, -1.59948632e-01f, -1.46268278e-01f, 1.71791241e-01f, 3.87472957e-01f, 2.84159929e-01f, -2.28910167e-02f,
  -3.29476655e-01f, -4.02231604e-01f, -1.68730408e-01f, 2.32378114e-02f, 1.11639239e-01f, 8.60766470e-02f, 1.82311967e-01f, -2.18389574e-02f, 3.37736428e-01f, -1.71893239e-01f,
  2.61572078e-02f, -6.48184819e-03f, -8.17231685e-02f, 7.37402067e-02f, -6.38283417e-02f, 1.86503138e-02f, 5.00024445e-02f, -3.36880051e-02f, -3.91968153e-02f, 5.19816391e-02f,
  2.83614788e-02f, 1.01617090e-01f, 3.39133777e-02f, -1.06468610e-02f, 4.60926071e-03f, -8.47852975e-02f, -3.10853627e-02f, 6.47916496e-02f, 7.83899799e-02f, -2.02132408e-02f,
  -8.61300677e-02f, 5.74553311e-02f, 2.47355476e-02f, -2.12458661e-03f, -2.54662186e-02f, 1.27970263e-01f, -1.04925983e-01f, -8.95896778e-02f, -1.10562183e-01f, -3.38075534e-02f,
  -2.57854760e-01f, 4.01754647e-01f, -2.05620989e-01f, 1.28329545e-01f, -2.35252172e-01f, 1.05830766e-02f, 3.54009378e-03f, 4.67379540e-02f, -1.14294417e-01f, -1.22786298e-01f,
  -1.44690454e-01f, -2.99461163e-03f, 2.76911967e-02f, 1.50815740e-01f, -1.82655677e-01f, -1.45627469e-01f, -3.41754854e-01f, -1.43043652e-01f, -1.49935335e-01f, -1.63340926e-01f,
  4.89778779e-02f, -3.22272748e-01f, -5.99608243e-01f, -3.97301078e-01f, -3.48833561e-01f, -3.45745385e-01f, -2.24204615e-01f, -1.32298186e-01f, -1.85621694e-01f, -6.50004447e-01f,
  8.28465283e-01f, -2.12688357e-01f, -1.19596511e-01f, 5.71133457e-02f, -2.39792153e-01f, -1.71327114e-01f, -2.97688156e-01f, 7.63446763e-02f, 4.71681096e-02f, 5.77308722e-02f,
  2.30020404e-01f, 4.81737047e-01f, 3.46365720e-01f, 3.17609906e-01f, 2.14715749e-01f, -1.76246420e-01f, -2.65133053e-01f, 1.55916691e-01f, 2.29704916e-01f, -1.24329170e-02f,
  -8.19067210e-02f, -1.40215337e-01f, 2.27978036e-01f, 9.54154432e-02f, -2.44585916e-01f, 9.29795485e-03f, -2.16777027e-01f, -1.57332063e-01f, -1.23480067e-01f, -2.30400577e-01f,
  -2.00098917e-01f, 3.55551695e-03f, 1.12631969e-01f, 1.22086056e-01f, -4.30102944e-02f, 3.27492319e-02f, -3.24952267e-02f, -1.59820825e-01f, -1.32872894e-01f, -1.59584671e-01f,
  -9.18267947e-03f, 5.10960631e-02f, 3.77682634e-02f, -7.17389882e-02f, -1.49989739e-01f, -4.96947840e-02f, -1.19293287e-01f, -4.13855948e-02f, -2.29207929e-02f, -1.28508294e-02f,
  3.29515687e-03f, -9.19979960e-02f, -5.53649403e-02f, 3.15549672e-02f, 3.57312411e-02f, 1.63926363e-01f, -1.82788875e-02f, -5.34114279e-02f, 8.00619051e-02f, -1.50335357e-01f,
  1.43804580e-01f, -9.20878798e-02f, 9.86532718e-02f, -9.81828384e-03f, 9.24017206e-02f, -5.87282469e-03f, -2.99366773e-03f, 2.81798299e-02f, 1.01875462e-01f, -6.29290119e-02f,
  -5.98724522e-02f, 1.27374992e-01f, 1.00679681e-01f, -6.74392879e-02f, 1.09087393e-01f, -1.21375218e-01f, -4.14384417e-02f, -6.45036474e-02f, 8.13662335e-02f, -1.08553302e-02f,
  1.09319605e-01f, -1.01374879e-01f, -1.70876551e-02f, -1.42373303e-02f, -1.00312583e-01f, -3.68682034e-02f, -8.36597309e-02f, -2.92885154e-02f, -8.86218920e-02f, -4.23059682e-04f,
  -2.42174551e-01f, 3.51963580e-01f, 9.33219790e-02f, 8.33232775e-02f, -6.67738263e-03f, 3.55193317e-02f, 5.30994497e-02f, -5.96924089e-02f, -1.51774362e-02f, -9.60464552e-02f,
  -7.86310714e-03f, 6.36548325e-02f, -8.60836264e-03f, -8.53386447e-02f, 2.65218336e-02f, 7.69294724e-02f, 2.56850943e-02f, 2.57810261e-02f, 3.93244028e-02f, -1.40549719e-01f,
  -7.26074427e-02f, 5.22005707e-02f, 1.93162128e-01f, 3.70602198e-02f, 5.09935021e-02f, 1.94625050e-01f, -5.62007576e-02f, 6.75737485e-02f, 1.34629875e-01f, -5.03297783e-02f,
  -3.49722683e-01f, -3.53558242e-01f, -4.81084704e-01f, 2.53532112e-01f, 3.61251742e-01f, -1.98552102e-01f, -4.79087263e-01f, -4.33063924e-01f, 1.10157140e-01f, -2.09087968e-01f,
  1.88024998e-01f, 2.98910975e-01f, 2.23623887e-01f, 5.33895232e-02f, -2.43401125e-01f, -2.01745152e-01f, -7.82759339e-02f, -1.20065667e-01f, 3.74317132e-02f, 1.04362689e-01f,
  3.05534810e-01f, 2.38911226e-01f, 1.18999206e-01f, 5.02565205e-02f, 2.73895293e-01f, 2.30923176e-01f, 1.43300235e-01f, 1.94356024e-01f, 2.35237777e-02f, 1.72441214e-01f,
  -7.49592781e-02f, -3.24278772e-01f, 9.72308889e-02f, 1.71675667e-01f, 8.03279355e-02f, -1.61891907e-01f, -7.17006549e-02f, -7.61358812e-02f, 6.57075085e-03f, -5.20985089e-02f,
  1.92178622e-01f, -5.14651462e-03f, 1.87367618e-01f, 1.74398690e-01f, 8.46066326e-02f, -2.28887558e-01f, -1.23611040e-01f, -1.97674066e-01f, -2.13387102e-01f, -5.30894808e-02f,
  3.29269946e-01f, 1.40538037e-01f, -2.41139024e-01f, -1.80553913e-01f, -3.99897635e-01f, 1.15546264e-01f, -1.11258946e-01f, -4.84336242e-02f, -2.73056895e-01f, -3.44643474e-01f,
  -8.94648805e-02f, 1.67066529e-01f, -2.88747195e-02f, -1.50130138e-01f, -5.66883981e-02f, -4.69859137e-04f, -7.79699311e-02f, 8.64077881e-02f, 4.80505563e-02f, -1.58783793e-01f,
  -1.11487091e-01f, 3.12439408e-02f, -4.43092771e-02f, -8.22970197e-02f, 9.80917066e-02f, 4.09175083e-02f, -1.16127508e-03f, 1.42655060e-01f, 1.32787544e-02f, -6.93824589e-02f,
  -4.96389531e-02f, -4.68877554e-02f, 1.66973948e-01f, -3.87162752e-02f, -8.57493877e-02f, -6.38260171e-02f, 1.68441515e-02f, 1.89459622e-02f, -1.43443137e-01f, -2.94423662e-02f,
  2.39330649e-01f, 1.32709458e-01f, -3.17924432e-02f, 2.26568934e-02f, 8.19071606e-02f, -2.56723538e-02f, 7.79719055e-02f, -5.00992499e-02f, -1.36057194e-02f, -1.53215140e-01f,
  -1.03485636e-01f, -1.61983654e-01f, 1.50766507e-01f, 1.07914694e-01f, -1.18435100e-01f, -5.31519204e-02f, -1.28548861e-01f, -7.10076764e-02f, 6.07973896e-02f, 9.31603089e-02f,
  -1.71420295e-02f, -1.50982738e-01f, -1.80135071e-01f, -1.40348583e-01f, 7.64931291e-02f, -8.19207653e-02f, -4.36749496e-02f, 3.89692467e-03f, -2.87704319e-01f, -5.17632127e-01f,
  -6.98293149e-01f, 1.26322746e-01f, -2.45014921e-01f, -3.75231415e-01f, 1.67466119e-01f, 2.79750794e-01f, 4.39893216e-01f, 1.27763525e-01f, -1.55469641e-01f, 1.12243012e-01f,
  -1.31123722e-01f, -6.06315807e-02f, -7.56093338e-02f, 1.45782158e-01f, 1.49659351e-01f, 2.82832891e-01f, 3.22025210e-01f, -4.08483967e-02f, -8.09563696e-02f, 5.34800142e-02f,
  1.46952361e-01f, -2.55874604e-01f, -3.27069014e-01f, -1.69904977e-01f, -2.28964780e-02f, -1.29843757e-01f, -5.47020398e-02f, -1.22480653e-01f, 2.51399636e-01f, 1.76068380e-01f,
  -1.80381507e-01f, -4.48143840e-01f, 1.26301900e-01f, -8.03266540e-02f, -1.43259153e-01f, -1.13334753e-01f, 9.03002620e-02f, -1.92433760e-01f, -1.09535374e-01f, 6.39902875e-02f,
  -1.85627490e-01f, 2.26476928e-03f, -4.31225747e-02f, 1.85780525e-02f, -5.41946925e-02f, -1.01628691e-01f, -2.15535630e-02f, -1.78529620e-01f, -6.37525544e-02f, 5.52181043e-02f,
  4.80499089e-01f, -3.23788971e-02f, -2.09419340e-01f, 1.02361001e-01f, 1.00283064e-02f, -1.02393091e-01f, -3.78904492e-02f, -5.90187833e-02f, -1.04138277e-01f, -1.64947584e-01f,
  8.60434249e-02f, -5.24771772e-02f, 1.00352399e-01f, -5.41521795e-02f, -3.36694494e-02f, 6.63972972e-03f, 7.97897875e-02f, 5.53618893e-02f, 4.17949222e-02f, -1.15378164e-01f,
  2.83970274e-02f, -7.13347346e-02f, 4.57369313e-02f, -4.57740128e-02f, -1.05037857e-02f, -2.02564951e-02f, 5.38176410e-02f, 6.03790618e-02f, -6.38024658e-02f, -4.19707329e-04f,
  -1.05850041e-01f, -3.07922997e-03f, -2.32822653e-02f, 6.81730956e-02f, 1.85410120e-02f, -3.36305089e-02f, -1.08097441e-01f, -3.74017060e-02f, -9.03249756e-02f, 6.64474396e-03f,
  -2.89371133e-01f, 6.11723587e-02f, -8.56887028e-02f, -1.40603604e-02f, -1.84549704e-01f, -3.19056511e-02f, 1.02966288e-02f, -7.54255578e-02f, -6.19515702e-02f, -1.81212544e-01f,
  -3.88056338e-02f, -1.23660244e-01f, 2.92673968e-02f, 5.26687987e-02f, 4.30613346e-02f, 4.21818979e-02f, -3.41273174e-02f, -5.69979660e-02f, 1.30821824e-01f, 1.42327905e-01f,
  7.15028867e-02f, 6.90271631e-02f, -1.34780481e-01f, 9.37849656e-02f, -5.82744554e-02f, -9.43651572e-02f, -1.83289126e-01f, -1.61283508e-01f, -1.10796476e-02f, -2.07379892e-01f,
  -6.83375597e-01f, -3.83817732e-01f, -1.95473418e-01f, -5.13685763e-01f, -1.89572126e-01f, -3.96646149e-02f, -1.80798978e-01f, 6.50812835e-02f, -1.59184396e-01f, -4.26555991e-01f,
  -1.74048856e-01f, -6.28318191e-02f, -1.71586201e-01f, 5.20465039e-02f, -2.63950080e-01f, -5.44128478e-01f, -4.97518897e-01f, -2.19941422e-01f, 1.39629900e-01f, 1.26855254e-01f,
  -2.82515973e-01f, -3.79909694e-01f, -3.06058943e-01f, -9.01154876e-02f, -2.21764892e-01f, 2.67237565e-03f, -1.82360977e-01f, -1.13655485e-01f, 2.22673509e-04f, -3.31859559e-01f,
  -7.25572631e-02f, 4.59664389e-02f, 1.98932111e-01f, -5.63321710e-02f, -8.18766207e-02f, 4.41698767e-02f, 9.13012698e-02f, -3.16063315e-03f, 4.77892645e-02f, -1.93105582e-02f,
  -9.73025933e-02f, 1.16650462e-01f, -7.15232790e-02f, 9.13418159e-02f, -4.80490252e-02f, -7.56557435e-02f, -9.85944048e-02f, 4.67540845e-02f, 4.10380699e-02f, 1.73049033e-01f,
  -1.06701083e-01f, -1.49345458e-01f, 7.52141625e-02f, 1.74850509e-01f, 2.18361706e-01f, 1.28854617e-01f, 2.26275980e-01f, 3.77325386e-01f, 2.19244972e-01f, -3.59416264e-03f,
  -6.73669875e-02f, -3.81249823e-02f, 2.39957254e-02f, 1.11813033e-02f, -9.20450222e-03f, 1.30423661e-02f, -1.06913358e-01f, 2.88109202e-02f, 5.62787391e-02f, -7.59500936e-02f,
  -6.82514459e-02f, -1.28000965e-02f, 4.86858636e-02f, -1.59919202e-01f, -7.55759180e-02f, -1.83669224e-01f, -8.33977088e-02f, -1.69856444e-01f, -2.71556228e-02f, -5.24345152e-02f,
  3.14784646e-02f, 1.02090418e-01f, -8.34832340e-02f, 1.23813935e-01f, 3.08159869e-02f, -9.82026234e-02f, 3.11646499e-02f, 1.27242088e-01f, 3.84786390e-02f, -2.73755975e-02f,
  -1.95551410e-01f, -2.45673954e-02f, -1.47401482e-01f, 1.07854038e-01f, 3.23455967e-02f, -4.06143628e-02f, -2.90180948e-02f, -5.40014589e-03f, 1.39215767e-01f, 1.86409596e-02f,
  1.58459201e-01f, -3.56278382e-02f, -1.28531992e-01f, 4.10420746e-02f, -3.96655388e-02f, 6.75298087e-03f, -1.30202740e-01f, -9.99382064e-02f, 8.25935304e-02f, -1.33812934e-01f,
  -1.86554134e-01f, -1.69984683e-01f, -1.38311014e-01f, 1.37403741e-01f, 1.15520284e-01f, 5.28301932e-02f, 1.19104341e-01f, 1.78158924e-01f, 1.86454922e-01f, -2.33306140e-01f,
  -4.08693135e-01f, 5.59693836e-02f, 2.30723098e-01f, -5.46355322e-02f, 7.17541799e-02f, 8.01906884e-02f, 2.66528875e-01f, 1.09960482e-01f, -6.62857071e-02f, 5.00164330e-02f,
  -3.59752551e-02f, -1.24557927e-01f, -9.46963578e-02f, -6.14346080e-02f, 9.18411314e-02f, 1.91071317e-01f, 1.49821162e-01f, 9.84722450e-02f, 1.21317044e-01f, 1.80445775e-01f,
  3.49837169e-02f, 4.81326617e-02f, -1.31836519e-01f, -4.06755358e-02f, 4.10831161e-03f, 8.49351063e-02f, 8.80027860e-02f, 1.61592029e-02f, 1.11360461e-01f, -1.79348048e-02f,
  5.35567045e-01f, -5.75446859e-02f, -2.69630849e-02f, -9.11371559e-02f, -1.22018114e-01f, -4.12435494e-02f, -9.44226831e-02f, 4.74454090e-03f, -4.40728031e-02f, 8.91831443e-02f,
  -8.06439295e-02f, -1.31697029e-01f, -8.35249349e-02f, -1.28441855e-01f, 7.04458579e-02f, -9.68856514e-02f, -1.39286712e-01f, -5.97148575e-02f, 9.52181742e-02f, 9.23278183e-02f,
  -1.53769208e-02f, -1.51998848e-01f, 4.17518988e-02f, -5.36126420e-02f, -7.46429525e-03f, -6.53825402e-02f, -1.63286813e-02f, -9.67547968e-02f, -2.07451731e-02f, -1.94937319e-01f,
  1.51874021e-01f, 4.10385393e-02f, -1.08211927e-01f, -8.61388221e-02f, -5.69115169e-02f, -1.31376814e-02f, 5.12400605e-02f, 1.54988885e-01f, -6.74512535e-02f, 4.49538752e-02f,
  4.07648161e-02f, 1.20544001e-01f, 9.85924080e-02f, 9.66326818e-02f, -4.25071269e-02f, -6.23490289e-02f, 2.99803051e-03f, 9.91732106e-02f, -9.07448977e-02f, -9.88328606e-02f,
  1.27294630e-01f, 1.20944425e-01f, -2.65817195e-02f, -8.28945078e-03f, 1.12889812e-03f, -5.02673388e-02f, 5.85445203e-02f, 7.52068404e-03f, -5.16934283e-02f, 7.49804154e-02f,
  3.71554673e-01f, -1.21180369e-02f, 7.51580968e-02f, 6.98548183e-02f, 6.86696172e-02f, -1.07938237e-01f, 3.40595730e-02f, 5.59814163e-02f, 1.87268198e-01f, 2.36691296e-01f,
  8.66350085e-02f, -3.83964740e-02f, 6.75692260e-02f, 6.62215948e-02f, -6.09253421e-02f, 2.51381248e-02f, -3.39722671e-02f, 3.42420004e-02f, 2.20300958e-01f, 1.05011180e-01f,
  -1.75473001e-02f, -2.68807989e-02f, 8.55453163e-02f, 4.74927351e-02f, 7.06884079e-03f, 1.82244271e-01f, 1.94398463e-01f, 2.92102545e-02f, 1.20943010e-01f, 1.02375157e-01f,
  3.76593500e-01f, 2.31555462e-01f, 1.64050907e-01f, 1.74203277e-01f, 3.89934808e-01f, 2.79705346e-01f, 3.16171229e-01f, 1.91502437e-01f, -5.63006997e-02f, 7.50232711e-02f,
  1.01822339e-01f, -1.21852241e-01f, -1.58342138e-01f, -1.70543611e-01f, -1.28847227e-01f, 4.08375971e-02f, 4.03459035e-02f, 6.75918208e-03f, 3.50406058e-02f, 2.82520484e-02f,
  -1.23004861e-01f, 1.14787094e-01f, 8.33636746e-02f, -6.11644238e-02f, 8.31100643e-02f, -9.99344140e-02f, 1.35473832e-02f, 1.83820039e-01f, 9.01503414e-02f, -1.44910127e-01f,
  -7.14128986e-02f, 2.58923590e-01f, -1.91938072e-01f, -2.75166750e-01f, 1.60633773e-02f, -1.76713988e-01f, -6.62960485e-02f, -7.53486231e-02f, -5.05791046e-03f, -4.67114374e-02f,
  5.99229001e-02f, -7.44661316e-02f, -2.76847165e-02f, -2.89172661e-02f, -4.62232344e-02f, -7.69416019e-02f, -1.30811319e-01f, -4.30814214e-02f, -7.40472227e-04f, -1.98913310e-02f,
  -4.49670106e-03f, 1.73409209e-01f, 5.49734272e-02f, 6.42588958e-02f, -6.05058521e-02f, -1.49890231e-02f, 7.43643865e-02f, -4.16737944e-02f, 3.41059314e-03f, -4.75460850e-02f,
  -6.58724308e-02f, -8.99067242e-03f, 3.37795764e-02f, -4.58721258e-02f, 5.25918826e-02f, -4.26040627e-02f, 2.35335547e-02f, 6.95371255e-02f, 2.46264376e-02f, -8.17040876e-02f,
  -1.03293732e-01f, 1.69564486e-02f, -2.66595129e-02f, -7.60474522e-03f, -1.29755080e-01f, 2.58406308e-02f, 4.40579765e-02f, -9.11264569e-02f, 7.72376871e-03f, 6.02741353e-02f,
  -7.70719349e-02f, 7.89932068e-03f, -3.77829894e-02f, -3.19664590e-02f, -1.83126792e-01f, -1.13440149e-01f, -1.07249744e-01f, -7.69942030e-02f, 7.66938971e-03f, -1.53478049e-02f,
  -1.80549681e-01f, 1.08276561e-01f, -1.14654087e-01f, 1.37103605e-03f, 4.96013053e-02f, -1.43507764e-01f, 2.75176149e-02f, -1.22107426e-02f, 8.01427756e-03f, -3.17320190e-02f,
  8.12092945e-02f, -4.43732776e-02f, 3.18393335e-02f, -4.58742902e-02f, -8.40348937e-03f, -1.72575749e-02f, -1.96534861e-02f, 3.30545194e-02f, -4.22724746e-02f, -9.12474394e-02f,
  -4.67803469e-03f, -9.96062765e-04f, 1.19449764e-01f, -2.02494916e-02f, -1.42169297e-01f, -6.48757890e-02f, 8.10655579e-03f, -5.28271198e-02f, -1.11108869e-02f, -1.21358544e-01f,
  4.74633425e-01f, 8.44447091e-02f, 2.44034857e-01f, 1.71249866e-01f, -1.38516873e-01f, -8.81844833e-02f, -2.02134922e-02f, 6.23364151e-02f, 1.15074068e-02f, 1.37986958e-01f,
  -3.79836448e-02f, 9.25528258e-02f, 1.78265870e-01f, 1.34060204e-01f, 1.20742373e-01f, 1.08913809e-01f, -6.14975691e-02f, 1.10203691e-01f, 1.05832249e-01f, 6.83083087e-02f,
  -1.33302361e-01f, -1.04771130e-01f, 2.76326146e-02f, 1.30444378e-01f, 3.47394124e-02f, -3.85904289e-03f, -6.22845292e-02f, -1.83143243e-01f, -2.61127893e-02f, 4.85417210e-02f,
  2.85260528e-01f, 2.92115718e-01f, 1.97609991e-01f, 1.27867118e-01f, 8.33488107e-02f, 2.00885028e-01f, 8.97924080e-02f, 4.66726385e-02f, -7.46015236e-02f, -3.63755189e-02f,
  5.33335172e-02f, 1.85664557e-02f, -2.64921114e-02f, -9.33821574e-02f, -1.85360666e-02f, 1.98307820e-02f, 7.09160939e-02f, -3.39784585e-02f, -2.11295988e-02f, 3.79562601e-02f,
  6.15303516e-02f, -6.13793954e-02f, 4.78529930e-02f, 3.51185277e-02f, 4.59321029e-02f, -2.45977566e-02f, 2.64298227e-02f, 5.69951907e-02f, 7.80825317e-02f, 4.29454222e-02f,
  2.40352139e-01f, 8.50492194e-02f, 6.15561195e-02f, -6.56570494e-02f, -5.05750738e-02f, -1.03462644e-01f, -9.39493068e-04f, -2.90477797e-02f, -8.91548172e-02f, -4.09824103e-02f,
  -1.59723669e-01f, -4.37211469e-02f, -8.45113993e-02f, -1.19786941e-01f, 1.56836770e-02f, -8.01793635e-02f, -1.81275401e-02f, -1.12670241e-02f, -2.71579977e-02f, -4.96011265e-02f,
  -9.48389471e-02f, 5.26596094e-03f, -1.91510562e-02f, -1.63874909e-01f, 3.87657434e-02f, -8.38853717e-02f, -9.87721384e-02f, -1.61132857e-01f, -2.10621938e-01f, -1.22122988e-01f,
  -5.49666248e-02f, 1.12953901e-01f, 2.14118555e-01f, 1.28872365e-01f, 1.82547793e-02f, -2.96218935e-02f, 1.48750797e-01f, 7.87802562e-02f, 2.10679267e-02f, 1.29811451e-01f,
  4.07758094e-02f, 1.24409935e-02f, 4.31548841e-02f, -1.16099708e-01f, -4.17692885e-02f, -1.66208204e-02f, -5.31538054e-02f, 1.39565736e-01f, 2.61582602e-02f, 7.88460076e-02f,
  -4.89097014e-02f, 2.65016872e-02f, -3.16716805e-02f, 7.58707374e-02f, -1.08061403e-01f, 8.80678743e-02f, 1.70103945e-02f, -6.68646842e-02f, 5.82185909e-02f, 3.48789580e-02f,
  1.87939289e-03f, 2.29163408e-01f, -3.76486242e-01f, 1.71802998e-01f, 2.22925276e-01f, 1.50686726e-01f, 4.32087243e-01f, 3.67677420e-01f, 2.39982143e-01f, 2.19090164e-01f,
  3.73724066e-02f, -8.84228423e-02f, -9.67636332e-02f, -7.27637708e-02f, 1.65660456e-02f, 1.98169008e-01f, 2.42053568e-01f, -2.21322551e-01f, -2.16954201e-01f, 1.58043858e-02f,
  1.58451557e-01f, 1.61366269e-01f, -1.28707200e-01f, 2.05047633e-02f, -1.51950428e-02f, 4.36922582e-03f, 1.04738176e-01f, 2.66766699e-04f, -5.70225976e-02f, 9.70264003e-02f,
  -4.97262478e-01f, -3.34548533e-01f, -3.64259519e-02f, 3.17672752e-02f, -1.64183050e-01f, -3.12510654e-02f, 7.37990160e-03f, 5.71708567e-03f, 1.59958810e-01f, 1.22800246e-01f,
  1.57631598e-02f, -1.03855148e-01f, -7.66349956e-02f, 4.63552177e-02f, 1.19858697e-01f, -4.65529412e-02f, -7.48472139e-02f, 1.43318743e-01f, 5.13612852e-02f, -1.07076876e-01f,
  1.08314015e-01f, -3.15753929e-02f, 5.30098900e-02f, 5.12051918e-02f, -4.51481901e-02f, -8.96602347e-02f, -9.30772051e-02f, -6.08748347e-02f, 4.01809029e-02f, 1.49218932e-01f,
  7.47303665e-02f, 1.39597043e-01f, 1.90138873e-02f, 7.07884133e-03f, 1.18626282e-01f, 8.17204267e-02f, -6.32161573e-02f, 1.04447030e-01f, 6.36207759e-02f, 1.15706380e-02f,
  5.25987037e-02f, -3.87878343e-02f, 6.54952377e-02f, 6.19358011e-03f, -1.24269314e-01f, -6.71086758e-02f, -7.39619415e-03f, -5.50188981e-02f, -2.02000905e-02f, 7.18527585e-02f,
  4.62122299e-02f, 3.22589204e-02f, -3.71568277e-02f, -1.76040143e-01f, -7.97824711e-02f, 4.08747494e-02f, -8.10844228e-02f, -2.37997063e-02f, -2.62878593e-02f, 6.58489764e-02f,
  3.29924703e-01f, -2.41693780e-01f, -1.02746211e-01f, -7.12541044e-02f, -6.71906173e-02f, -8.71702656e-03f, -1.68784261e-01f, -7.52128810e-02f, 5.93813770e-02f, 2.37508360e-02f,
  -1.10001005e-01f, -1.00913376e-01f, -2.33638156e-02f, 6.81047291e-02f, 3.55189629e-02f, -7.41846710e-02f, 5.90848960e-02f, 1.04400687e-01f, 9.63214859e-02f, 4.15138789e-02f,
  1.02170311e-01f, 1.54214486e-01f, 2.12528527e-01f, 1.33876994e-01f, 9.57630426e-02f, -2.87162233e-02f, -2.40577571e-02f, 5.34817241e-02f, 4.37688120e-02f, 2.26875275e-01f,
  5.74548282e-02f, 4.46227640e-01f, -5.20885944e-01f, 2.64349550e-01f, -7.44734630e-02f, -3.08474123e-01f, 2.19467074e-01f, 2.89751887e-01f, 2.75358915e-01f, 3.13037902e-01f,
  6.37102127e-02f, -3.49539906e-01f, -2.03349411e-01f, -3.32117468e-01f, -4.98609334e-01f, -1.49744228e-01f, -1.70161158e-01f, -5.44691384e-01f, -5.87239385e-01f, -2.16466650e-01f,
  6.72748238e-02f, -3.02660577e-02f, -1.82255372e-01f, -9.84541103e-02f, 1.22584082e-01f, -1.95925295e-01f, 7.92826265e-02f, -1.28408566e-01f, -1.43925190e-01f, 6.33954257e-02f,
  -3.59747887e-01f, -4.90572974e-02f, -2.32952476e-01f, -1.84330111e-03f, 3.58665735e-02f, 2.39054691e-02f, -1.29531071e-01f, -8.37209970e-02f, 6.33059442e-02f, -1.08051620e-01f,
  -2.38654584e-01f, -1.03955446e-02f, -9.43609476e-02f, -8.28589052e-02f, -9.29472148e-02f, -9.97123793e-02f, 3.04013081e-02f, -2.21394181e-01f, -1.34086341e-01f, -6.63041100e-02f,
  -4.66919132e-02f, -4.02352065e-01f, -4.94478166e-01f, 3.09703592e-02f, -2.45776534e-01f, -2.71603525e-01f, -1.05703838e-01f, -2.05354542e-01f, -3.41264397e-01f, 4.13052529e-01f,
  1.62797958e-01f, -3.38213183e-02f, -4.26605158e-03f, 2.95299925e-02f, 1.19514115e-01f, 3.51597033e-02f, -2.53994833e-03f, 8.32522362e-02f, 4.41492386e-02f, -8.31753295e-03f,
  6.02011941e-02f, 5.85330874e-02f, -7.33048543e-02f, 4.85064425e-02f, -1.08059160e-01f, -1.25590414e-01f, -2.84943823e-02f, 1.23225480e-01f, -9.81544256e-02f, 3.80275548e-02f,
  -1.10858127e-01f, -1.46399111e-01f, -3.65609378e-02f, 3.72950584e-02f, -1.09657235e-01f, 4.44533397e-03f, 4.00031917e-02f, 3.68622765e-02f, 3.53419930e-02f, 2.11608056e-02f,
  1.60980597e-01f, -1.49196699e-01f, 4.91756536e-02f, -7.20516890e-02f, -5.40510900e-02f, -8.38454962e-02f, 1.50394052e-01f, 1.70866981e-01f, -2.29780283e-02f, 2.31943447e-02f,
  -1.18522033e-01f, 3.26752402e-02f, 1.23841353e-01f, 1.52505487e-02f, -8.83132294e-02f, -1.03081524e-01f, 1.52251706e-01f, -6.75888732e-02f, -1.20905861e-01f, 8.43811184e-02f,
  3.88078362e-01f, 1.47337243e-01f, -1.52764440e-01f, 1.66326806e-01f, 8.20441097e-02f, -1.76334366e-01f, -2.05948614e-02f, -9.98300593e-03f, -2.81172216e-01f, 5.88860512e-01f,
  -3.08699012e-01f, 5.44726729e-01f, 3.29971135e-01f, -3.33792299e-01f, 3.11808914e-01f, 4.96095955e-01f, 7.24616587e-01f, 1.89669505e-01f, -3.36284995e-01f, 3.03077221e-01f,
  3.51544440e-01f, -2.68885523e-01f, -1.92709386e-01f, -1.92323610e-01f, -1.60149649e-01f, 2.91373730e-01f, 1.97966084e-01f, -2.60775864e-01f, -2.75899500e-01f, -1.06554113e-01f,
  -1.74973183e-03f, -2.49534160e-01f, -2.98813909e-01f, -2.18240172e-01f, -2.08562419e-01f, -1.72000885e-01f, 1.62590772e-01f, 3.00165545e-02f, 1.71893418e-01f, -1.70615375e-01f,
  -7.09469914e-02f, 2.65350282e-01f, -1.71761513e-01f, -2.07811102e-01f, 1.65269554e-01f, -1.62258402e-01f, 4.14607897e-02f, -6.85459971e-02f, -2.10200809e-02f, -7.57762939e-02f,
  5.57186715e-02f, 7.69730732e-02f, 3.13942023e-02f, -8.50040987e-02f, 1.24061108e-02f, -9.80213061e-02f, -9.47897807e-02f, -1.52409926e-01f, -1.86120510e-01f, -7.57104084e-02f,
  1.18036672e-01f, 1.69047311e-01f, 1.40975341e-01f, 6.94183111e-02f, 3.72802801e-02f, -1.78980708e-01f, 2.14270115e-01f, -1.56195611e-01f, -3.67304683e-02f, -3.13462883e-01f,
  -8.01223156e-04f, 1.19440064e-01f, 6.57589734e-02f, 1.90379731e-02f, -2.55193934e-02f, 7.09020942e-02f, -7.89768174e-02f, 1.01136953e-01f, -4.89539914e-02f, -3.50553431e-02f,
  4.67978604e-02f, -5.70014305e-02f, -5.22887409e-02f, 6.85064122e-02f, -9.11868066e-02f, 4.26883698e-02f, -1.25142271e-02f, -3.41369770e-02f, -3.67874056e-02f, 1.56559478e-02f,
  -8.35064948e-02f, 3.31222862e-02f, -1.93853471e-02f, -1.06696099e-01f, 1.40670195e-01f, -5.26956171e-02f, -1.99336246e-01f, -1.63000301e-02f, -1.24044344e-02f, 1.70511901e-01f,
  -3.17720920e-01f, 1.77051872e-01f, -2.97890067e-01f, -4.13778722e-02f, 1.27292275e-01f, 2.84407567e-02f, 7.25443438e-02f, -2.12845821e-02f, 5.73321283e-02f, -3.29471417e-02f,
  1.34100839e-01f, -2.17994070e-03f, 1.10725276e-02f, -5.56772761e-02f, -5.81414700e-02f, 1.71660762e-02f, 1.27979785e-01f, -7.57024735e-02f, -6.28004670e-02f, -3.56784798e-02f,
  2.13679411e-02f, -8.74244571e-02f, -1.59081697e-01f, -3.49621773e-02f, -4.96789478e-02f, -2.46257335e-01f, -7.08246082e-02f, -1.77514642e-01f, -9.53134969e-02f, -1.84174508e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 26)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 26;
const float L0_fan_Bp_bar_data[] = {
  1.99187204e-01f, 1.50273025e-01f, 1.10482827e-01f, 2.55087912e-01f, 2.96722651e-01f, 3.29137683e-01f, 5.83859444e-01f, 6.16777122e-01f, 2.78794438e-01f, 1.38005689e-01f,
  2.90062577e-01f, 2.60612011e-01f, 1.79283500e-01f, 2.57229090e-01f, -4.91410308e-02f, 3.72845113e-01f, 2.35506490e-01f, 1.89385995e-01f, 3.22742052e-02f, 3.78588378e-01f,
  3.11171468e-02f, 1.15433402e-01f, 1.54184084e-02f, 4.79867071e-01f, 3.51880312e-01f, 2.03495488e-01f
};

// L1_fan_Wp (Shape: 19 x 64)
const int L1_fan_Wp_rows = 19;
const int L1_fan_Wp_cols = 64;
const float L1_fan_Wp_data[] = {
  5.73608875e-02f, 7.10711628e-02f, 2.22315133e-01f, 1.63977236e-01f, 4.16532764e-03f, 1.31674707e-02f, 1.76129222e-01f, 2.64313132e-01f, 1.23100430e-01f, 2.34822825e-01f,
  1.83952600e-01f, -1.65504217e-02f, 8.19350258e-02f, 3.14086415e-02f, 2.51619250e-01f, -7.98371583e-02f, 9.34576616e-02f, 1.29262865e-01f, 2.51341045e-01f, -1.12773322e-01f,
  -4.80652973e-02f, -1.10848531e-01f, 2.39537254e-01f, 2.28568643e-01f, -1.86966825e-03f, 6.12486564e-02f, -1.28407732e-01f, -1.27588332e-01f, -1.70748238e-03f, -7.85188228e-02f,
  7.39565939e-02f, -1.18669361e-01f, 1.21253341e-01f, 1.39799684e-01f, 1.24811210e-01f, 3.04631203e-01f, 1.46030948e-01f, -3.08542132e-01f, -2.83252262e-02f, -1.26869604e-01f,
  5.10631911e-02f, -2.00999379e-02f, -2.04762995e-01f, -1.33735031e-01f, 1.92525908e-01f, 3.17535624e-02f, 7.82716945e-02f, 1.87804345e-02f, -1.18148960e-01f, 3.22594166e-01f,
  -8.53821337e-02f, -9.96580869e-02f, -2.01135635e-01f, 3.36363047e-01f, -2.66037524e-01f, -1.58439949e-01f, -1.39904842e-01f, -1.14740871e-01f, -5.74718975e-03f, 1.77922230e-02f,
  1.01581253e-01f, 6.39574155e-02f, 1.31433904e-01f, 3.13734651e-01f, 6.58164769e-02f, 3.95123567e-03f, -1.22452062e-02f, 5.04653761e-03f, -1.37764579e-02f, 6.65388675e-03f,
  -1.18129645e-02f, -3.83138023e-02f, 9.15278196e-02f, 2.41443738e-02f, 3.37831564e-02f, 1.15687177e-01f, 1.77438512e-01f, 1.28708869e-01f, 1.70898750e-01f, -2.58069132e-02f,
  -7.89906234e-02f, 7.39279091e-02f, -1.02405742e-01f, -1.58723816e-01f, -8.10699984e-02f, 9.23277438e-02f, -1.44612670e-01f, -1.18231490e-01f, -2.21445933e-01f, -6.28269836e-02f,
  -1.07351668e-01f, 1.44602910e-01f, 1.40570208e-01f, -2.22464696e-01f, -2.25806683e-02f, -7.83123523e-02f, 9.22523290e-02f, 1.08981617e-01f, 5.71568049e-02f, -1.85952067e-01f,
  6.95584863e-02f, -4.44980189e-02f, 2.84781188e-01f, 1.11162737e-01f, 2.01080233e-01f, -1.05370872e-01f, -8.71905219e-03f, 5.87898679e-02f, 1.89484194e-01f, -1.85234264e-01f,
  -9.32084396e-02f, 6.41843081e-02f, 4.15552795e-01f, 2.48895567e-02f, -1.76759109e-01f, 2.68994451e-01f, 3.49594397e-03f, -2.49358848e-01f, -1.23032242e-01f, 7.15930164e-02f,
  1.97340474e-01f, -2.12132007e-01f, 1.38532594e-01f, -1.30904928e-01f, -1.22504504e-02f, 3.93665768e-02f, 1.21378824e-01f, -2.03554213e-01f, 8.43792483e-02f, -1.73195440e-03f,
  4.78782617e-02f, -1.31706774e-01f, 4.90628742e-03f, 6.60297275e-02f, 1.20174035e-01f, 2.62079071e-02f, -3.45852785e-02f, -7.06272572e-02f, 1.44297108e-02f, 1.17075637e-01f,
  5.80144301e-02f, -1.25938967e-01f, 3.26101407e-02f, -2.40725148e-02f, -2.17566505e-01f, -2.24827781e-01f, 8.45221952e-02f, -1.30369261e-01f, 1.57021824e-02f, -1.25773787e-01f,
  -9.87299755e-02f, 1.12745827e-02f, -1.77188560e-01f, -1.12082444e-01f, -9.16755274e-02f, 2.88980510e-02f, 1.44990832e-01f, -6.62131682e-02f, -1.20774014e-02f, 1.89178009e-02f,
  -6.83972463e-02f, 1.16492376e-01f, -4.64631356e-02f, 1.98577195e-02f, 1.63025245e-01f, -1.87121972e-01f, 5.32477312e-02f, 1.07103609e-01f, 2.60668732e-02f, -1.37508646e-01f,
  -1.57640159e-01f, -1.40812784e-01f, -1.60683349e-01f, -1.69528365e-01f, 2.22126156e-01f, -7.46767148e-02f, -1.31115645e-01f, -2.93710589e-01f, 1.78501397e-01f, 2.40811437e-01f,
  -2.07905322e-02f, 1.49972320e-01f, -1.11225188e-01f, -1.05348296e-01f, 2.07424104e-01f, -2.61656493e-02f, -2.34087303e-01f, 2.50713415e-02f, -2.60401487e-01f, 4.48421761e-02f,
  -2.42094815e-01f, -6.11264184e-02f, -3.99349108e-02f, -4.90630567e-02f, 1.13478094e-01f, -1.39606431e-01f, 3.67256999e-02f, 8.87477845e-02f, 3.59590864e-03f, -4.09493037e-02f,
  -4.01897728e-03f, -1.16258562e-01f, 2.69172899e-02f, -1.40012801e-02f, 7.47601092e-02f, 2.84582153e-02f, -8.61929953e-02f, -2.50157584e-02f, -9.72629786e-02f, -7.65770748e-02f,
  4.31125425e-03f, 3.88363563e-02f, 1.39886752e-01f, 2.32589375e-02f, 2.86649883e-01f, 7.93625042e-02f, 2.52378762e-01f, 1.32972583e-01f, 1.37383282e-01f, 1.21626526e-01f,
  1.75636925e-03f, 1.80496186e-01f, -6.22759424e-02f, 9.93735790e-02f, -1.37659460e-01f, -1.14862971e-01f, 6.01373985e-02f, -4.10044223e-01f, -3.19249451e-01f, -1.02078669e-01f,
  -7.65080377e-02f, -1.97379962e-01f, -9.40989926e-02f, 1.40531901e-02f, 7.32199997e-02f, -1.59327239e-02f, -3.94305289e-02f, 1.72609508e-01f, -1.64863586e-01f, -1.52000282e-02f,
  3.15038621e-01f, -1.93902794e-02f, -1.19521372e-01f, -1.64067864e-01f, -1.15582332e-01f, 2.08520859e-01f, 1.19222492e-01f, -3.73479314e-02f, -8.10075030e-02f, 1.87448904e-01f,
  9.16552991e-02f, 4.25893627e-02f, 1.02766015e-01f, 1.16217071e-02f, -1.07494161e-01f, 1.96486115e-01f, -2.11962104e-01f, 2.26566065e-02f, 1.22988626e-01f, 1.19416520e-01f,
  -1.29041523e-01f, -2.59144790e-02f, -5.30741699e-02f, -1.75432459e-01f, 4.53678444e-02f, -8.12504739e-02f, -1.58480272e-01f, 3.96545045e-02f, 3.96667607e-02f, -6.35548010e-02f,
  -3.01187932e-02f, 6.73800558e-02f, 1.30788371e-01f, 5.64987361e-02f, 1.12070195e-01f, 1.43743441e-01f, 2.92927828e-02f, 2.39526808e-01f, 1.37071699e-01f, -1.41242772e-01f,
  1.74539775e-01f, 4.23086345e-01f, 2.09289901e-02f, 1.96405519e-02f, 4.53108139e-02f, 1.33081377e-01f, -2.90714592e-01f, -8.24835226e-02f, -8.00970271e-02f, -7.98262134e-02f,
  -1.31266275e-02f, 4.78995293e-02f, 4.47535375e-03f, 9.00045559e-02f, 3.09355110e-01f, 6.90993518e-02f, -1.30826980e-01f, -1.92071833e-02f, -8.94848853e-02f, 5.04207760e-02f,
  1.17534630e-01f, -3.23375046e-01f, 3.44216153e-02f, -6.08534999e-02f, -1.96335122e-01f, 8.84531736e-02f, -1.03969812e-01f, -6.21366538e-02f, 1.86477348e-01f, -1.34251922e-01f,
  -9.65922698e-02f, 8.75710100e-02f, 1.50572523e-01f, 1.37514889e-01f, 2.78227702e-02f, -6.37556538e-02f, -4.88719903e-02f, 2.80556768e-01f, 1.19521320e-01f, 3.33545387e-01f,
  -1.74703240e-01f, -1.07334539e-01f, -5.60839847e-02f, -1.05472408e-01f, -1.05688475e-01f, -1.15208533e-02f, -1.15123123e-01f, 1.35478126e-02f, 7.78169883e-03f, 4.90544885e-02f,
  -1.32399142e-01f, -9.36520323e-02f, -6.55113682e-02f, -2.17568409e-03f, -6.63936436e-02f, 8.14977959e-02f, -7.69526139e-02f, 2.21169796e-02f, -6.86705932e-02f, 8.55583772e-02f,
  -3.25753540e-03f, -1.59609392e-02f, 1.47471637e-01f, -2.34307095e-01f, 1.01432763e-01f, 6.47208467e-02f, -1.74945891e-02f, 7.49917179e-02f, -1.71306461e-01f, 9.26650167e-02f,
  -1.43561125e-01f, -2.84543203e-04f, 3.47587168e-02f, -1.33677050e-01f, 4.22439836e-02f, -3.72618914e-01f, -1.17908679e-01f, 1.16312116e-01f, -2.63864338e-01f, 5.79369534e-03f,
  1.77994207e-01f, -2.10080653e-01f, 7.10177273e-02f, -3.41409445e-02f, -2.49595091e-01f, 1.41696110e-01f, 9.78731550e-03f, -4.10171598e-02f, 2.60425597e-01f, -2.01658010e-01f,
  9.04800221e-02f, 1.55270427e-01f, 2.89326191e-01f, -2.65423268e-01f, 8.02788511e-03f, 1.20524876e-01f, -1.34927258e-01f, 1.11919709e-01f, 4.70133778e-03f, -5.69419526e-02f,
  -7.97973201e-02f, -1.00466803e-01f, -1.69331044e-01f, 9.65860579e-03f, -1.80602238e-01f, 3.01455129e-02f, 1.62355125e-01f, 9.29374769e-02f, 4.93191257e-02f, 6.51209727e-02f,
  -1.79803222e-01f, -1.48242846e-01f, 8.07627067e-02f, 1.02450199e-01f, 1.81003045e-02f, -3.66817228e-03f, 1.12019032e-01f, 1.34399444e-01f, 1.08454354e-01f, 5.36211096e-02f,
  4.38249186e-02f, 1.27691612e-01f, 1.76082611e-01f, 9.64580029e-02f, -7.05497863e-04f, -1.49200007e-01f, 2.39839375e-01f, 9.94553268e-02f, 2.17651874e-01f, 2.29263201e-01f,
  -1.01021670e-01f, -7.75561482e-02f, -9.19746011e-02f, 3.77748604e-03f, -2.65546471e-01f, -1.60161689e-01f, 1.24691121e-01f, -9.18068066e-02f, 3.58665511e-02f, -1.54826090e-01f,
  2.76969355e-02f, -2.40878463e-01f, -1.65056735e-01f, -1.12765417e-01f, 5.55416867e-02f, -2.91273161e-03f, -1.57033429e-01f, -2.71708429e-01f, -4.46208604e-02f, -1.46971673e-01f,
  1.30663067e-02f, 1.28881812e-01f, 3.52145314e-01f, -2.65515316e-02f, 3.68746631e-02f, 1.36045203e-01f, 3.12153876e-01f, 1.66411787e-01f, -3.29897285e-01f, -9.66043621e-02f,
  -9.20849815e-02f, 3.12204678e-02f, 5.72000491e-03f, -2.09463015e-02f, -4.28274013e-02f, -1.34815380e-01f, 6.88540116e-02f, 3.68692875e-01f, 8.57588947e-02f, -1.01986878e-01f,
  -1.18981533e-01f, 4.76091057e-02f, 2.63091207e-01f, 2.52833702e-02f, -1.00377038e-01f, 3.57225761e-02f, -7.02337921e-02f, -2.89533157e-02f, 3.04807518e-02f, 2.65960097e-02f,
  -1.77353695e-02f, 9.30686295e-03f, 1.13084689e-01f, 3.06677632e-02f, 1.87411159e-02f, -4.39685993e-02f, -1.45235196e-01f, -1.99480161e-01f, -4.56727222e-02f, 6.38415888e-02f,
  -2.26141602e-01f, 4.08578366e-02f, -1.47885263e-01f, -2.11609662e-01f, -3.35117988e-02f, 1.04576305e-01f, 5.29201515e-02f, -2.24066794e-01f, 1.70581922e-01f, -5.22862300e-02f,
  -1.59599096e-01f, 1.47902325e-01f, 6.58777580e-02f, 1.76982712e-02f, 8.74418914e-02f, -2.08527014e-01f, -4.01500076e-01f, -1.85971275e-01f, 3.29813331e-01f, 1.08284660e-01f,
  2.75970817e-01f, 2.86860764e-03f, 3.59948218e-01f, 3.65977623e-02f, -4.74852539e-04f, 1.90030456e-01f, -1.84911758e-01f, -1.60268694e-01f, -8.24052766e-02f, -2.48289898e-01f,
  -3.19392234e-01f, 1.68944642e-01f, 2.57969350e-01f, 5.04385531e-02f, -1.87030211e-01f, -4.46893163e-02f, -1.76129624e-01f, 9.85006150e-03f, -9.99811478e-03f, 2.19535064e-02f,
  2.49935910e-02f, -3.71809006e-01f, -1.64629638e-01f, 1.56863108e-01f, -1.25229418e-01f, -1.87649563e-01f, -1.46022590e-03f, -6.93377852e-03f, -3.20530497e-02f, 4.02757004e-02f,
  9.48874503e-02f, 2.08650216e-01f, -3.80967371e-02f, 2.01240685e-02f, 5.62116504e-02f, -2.87008118e-02f, -1.44993439e-01f, 7.67753646e-02f, -1.39457449e-01f, 1.28901154e-01f,
  -1.02886006e-01f, 2.44425118e-01f, -2.19135601e-02f, 3.61103415e-02f, 1.88963681e-01f, -2.79430151e-01f, 9.72440690e-02f, 2.18454644e-01f, -1.59262165e-01f, -1.18450113e-01f,
  -2.05421105e-01f, 2.40717679e-01f, -2.51453757e-01f, -2.97176968e-02f, 1.42514378e-01f, -1.90168083e-01f, 1.29733056e-01f, -5.54442555e-02f, -2.84523159e-01f, 3.02856743e-01f,
  -5.08564487e-02f, -6.57896399e-02f, -2.11900175e-01f, 9.70972981e-03f, -5.52702025e-02f, 6.94939718e-02f, 9.56360996e-02f, -2.64342744e-02f, 5.81918769e-02f, 4.73001637e-02f,
  9.03420970e-02f, 1.72986984e-01f, 1.32077813e-01f, -2.41496131e-01f, 1.35010734e-01f, -1.39572278e-01f, -6.82303682e-02f, 7.97333941e-02f, -7.50421584e-02f, 8.74256045e-02f,
  -6.48503192e-03f, 8.37942883e-02f, -1.01392552e-01f, -6.84673563e-02f, 2.92518884e-01f, 3.13132882e-01f, 8.45454708e-02f, -2.95985141e-03f, -2.59462185e-02f, 1.94191858e-02f,
  8.35141838e-02f, -6.33689016e-02f, 2.08567139e-02f, -4.71116453e-02f, 1.31310984e-01f, -1.25114601e-02f, -4.53100540e-03f, -1.98383518e-02f, -5.07343598e-02f, 6.68438822e-02f,
  1.99203998e-01f, 8.88004154e-02f, 5.06959148e-02f, -1.00483475e-02f, 7.81123042e-02f, -2.17266396e-01f, -3.89853604e-02f, 1.22145616e-01f, 1.13799036e-01f, 7.47722834e-02f,
  -2.63653360e-02f, 4.24131215e-01f, -2.27452908e-02f, -3.99711616e-02f, 5.54141682e-03f, -6.06882833e-02f, -1.44774824e-01f, -1.39109612e-01f, -4.83708903e-02f, 1.08788669e-01f,
  1.52094722e-01f, 2.02261820e-01f, 4.12841029e-02f, -1.54891446e-01f, -5.03017530e-02f, -2.67412752e-01f, 6.58178329e-02f, 1.53502330e-01f, -1.99566796e-01f, -3.49865258e-02f,
  -9.98860458e-04f, 2.12388158e-01f, 4.83545884e-02f, 9.58073214e-02f, 1.62359759e-01f, 2.00616941e-01f, 5.24596535e-02f, -6.35360628e-02f, 3.30488905e-02f, -1.13288239e-02f,
  -1.48483813e-01f, -4.01747048e-01f, -1.66084304e-01f, -1.03688851e-01f, 1.68182239e-01f, 1.68288946e-01f, 6.42079264e-02f, 4.58313748e-02f, -1.08851634e-01f, 1.50820509e-01f,
  1.07241847e-01f, 5.33263832e-02f, 1.41057789e-01f, 7.14952797e-02f, 5.94774354e-03f, 3.64195630e-02f, 7.80311748e-02f, 1.16990298e-01f, 3.69224548e-02f, 3.58471945e-02f,
  7.09119663e-02f, -1.44930989e-01f, 7.45309750e-03f, -2.12398693e-02f, 2.38862425e-01f, 2.75505185e-02f, 5.29623069e-02f, -5.00304624e-02f, 1.03953175e-01f, -2.14808762e-01f,
  -1.71642929e-01f, -7.11537525e-02f, 1.57223418e-01f, 3.27752858e-01f, -1.08970188e-01f, 1.95004314e-01f, -9.86776315e-03f, 2.53333757e-03f, 1.94406584e-02f, -1.04968742e-01f,
  2.04761595e-01f, -2.44395845e-02f, 8.83738101e-02f, 1.46753132e-01f, 9.03686285e-02f, 2.68168300e-01f, 3.42043415e-02f, -3.52405906e-01f, -2.98054904e-01f, 7.50402212e-02f,
  3.00405860e-01f, -1.57585919e-01f, -1.26429394e-01f, -2.62583137e-01f, -4.11327891e-02f, 1.27295017e-01f, 1.84252456e-01f, 9.49692503e-02f, 1.65614352e-01f, 9.62216631e-02f,
  -1.10011950e-01f, -1.74227376e-02f, -1.74366921e-01f, 1.92704380e-01f, -4.93394472e-02f, -3.22815657e-01f, -1.30989447e-01f, -1.95922833e-02f, -1.03283636e-02f, 1.53712764e-01f,
  -8.99021253e-02f, -3.61743234e-02f, -1.86603338e-01f, 1.58778336e-02f, -9.08629447e-02f, -6.51883781e-02f, -2.95719206e-01f, -1.22428097e-01f, -1.07849829e-01f, -7.44052753e-02f,
  -9.00791511e-02f, -6.57260418e-02f, -9.23668686e-03f, -2.14385018e-01f, -4.94055897e-02f, 9.76914912e-03f, -1.51785970e-01f, -4.70250174e-02f, -3.07741091e-02f, -5.47269993e-02f,
  -1.03729352e-01f, 1.10650398e-01f, -3.84976655e-01f, -1.53737649e-01f, 4.30153832e-02f, 3.92001541e-03f, -2.79424369e-01f, -1.92155510e-01f, -1.74587727e-01f, -2.54849792e-01f,
  -7.52276033e-02f, 4.18234058e-02f, 4.63672541e-03f, -1.56712323e-01f, 1.87747538e-01f, 1.97766200e-01f, 9.01615322e-02f, -1.33303016e-01f, -4.76207882e-02f, -4.21459466e-01f,
  -3.54154795e-01f, -1.77731857e-01f, 1.56543672e-01f, -3.80929606e-03f, 2.68118590e-01f, 4.49740589e-02f, 1.46434065e-02f, 4.34278101e-02f, 9.48741734e-02f, 2.00351909e-01f,
  -8.25932026e-02f, -7.35889301e-02f, 2.18258053e-01f, -1.44219562e-01f, -2.56304592e-01f, -3.99657041e-01f, -2.25946829e-01f, -5.88167012e-02f, 6.53090477e-02f, 9.36686620e-03f,
  1.45703152e-01f, 1.19194664e-01f, 1.40233174e-01f, 4.58718315e-02f, 1.79665200e-02f, 1.03344709e-01f, -1.75077304e-01f, 7.30763376e-02f, -1.86596420e-02f, -1.22935558e-03f,
  2.04978600e-01f, -5.01264893e-02f, 2.06877738e-02f, -1.13318516e-02f, -5.69498464e-02f, 8.21558163e-02f, -1.04132080e-02f, 1.56480044e-01f, -1.64417952e-01f, 1.72683243e-02f,
  7.08737597e-02f, 3.71187665e-02f, -1.29547745e-01f, -6.51142597e-02f, 7.36558205e-03f, -1.15443543e-02f, 3.53726968e-02f, 1.84392259e-01f, 1.04531907e-01f, 2.29962245e-02f,
  1.33662567e-01f, -1.67613089e-01f, 5.99830113e-02f, -2.13005617e-01f, 1.18263856e-01f, -4.13327925e-02f, -9.94362161e-02f, 1.43971443e-01f, -3.69465351e-02f, 3.11530903e-02f,
  -5.56429615e-03f, 4.74214330e-02f, -5.36735840e-02f, -1.19552128e-01f, -7.77006447e-02f, 1.13955870e-01f, 1.03303358e-01f, 6.88658059e-02f, 2.58955844e-02f, -1.95312902e-01f,
  -1.18272148e-01f, 2.46747751e-02f, -1.71897754e-01f, -2.64051080e-01f, -6.98963925e-02f, -4.74540666e-02f, -7.87530281e-03f, 2.16371775e-01f, -8.32636654e-02f, 2.83858180e-01f,
  3.15520018e-01f, 8.11382011e-02f, -1.84610963e-01f, 3.56610656e-01f, 2.48340309e-01f, 1.48459613e-01f, -1.20015226e-01f, -8.74466822e-02f, -1.01196088e-01f, 8.33160132e-02f,
  4.26327944e-01f, -1.85059905e-01f, 8.91085491e-02f, 4.02259715e-02f, -1.16535991e-01f, -6.92682341e-02f, -3.24691087e-02f, 1.15467228e-01f, 2.61196084e-02f, -1.32593870e-01f,
  1.21475056e-01f, -1.50530845e-01f, 1.25625223e-01f, -2.90730782e-03f, -6.45711720e-02f, -5.74007817e-02f, -2.50215083e-02f, 1.17978707e-01f, -7.15989247e-02f, 1.56601086e-01f,
  7.09220991e-02f, -5.45978770e-02f, 1.12751462e-01f, 1.24078251e-01f, 2.65581924e-02f, 8.24666582e-03f, 3.36041190e-02f, -1.97615400e-01f, 9.94845852e-02f, 1.14225753e-01f,
  -9.78523567e-02f, 8.87933448e-02f, 2.21210178e-02f, 1.28893599e-01f, -9.23199132e-02f, -2.72241561e-03f, -5.63291647e-02f, -3.77846154e-04f, 1.27450764e-01f, 1.68843329e-01f,
  -2.12606147e-01f, -1.66972235e-01f, -2.17494592e-01f, -2.45432444e-02f, 2.85148948e-01f, 7.48230442e-02f, 8.22218135e-02f, -1.73053890e-02f, 7.23738223e-02f, -1.66582204e-02f,
  -5.34576178e-03f, -1.02827899e-01f, -4.74080704e-02f, 5.76293506e-02f, 2.19889358e-01f, 2.01894760e-01f, 1.17683604e-01f, 6.40477836e-02f, -2.74621993e-01f, 1.42747119e-01f,
  -3.26161683e-02f, -2.07840994e-01f, -1.83951408e-01f, -9.11590308e-02f, 6.89863414e-02f, 7.50725567e-02f, 2.32455313e-01f, -1.91681698e-01f, -6.50636181e-02f, -2.31463090e-01f,
  -3.46034169e-02f, -1.22715376e-01f, -4.08806689e-02f, -1.85844794e-01f, -3.91534120e-02f, -6.43266365e-02f, -6.77263141e-02f, 4.18911576e-02f, 1.03992224e-02f, -7.05443248e-02f,
  2.70142667e-02f, -7.80808404e-02f, -2.29391200e-03f, -1.01607047e-01f, 3.36500779e-02f, 8.82900730e-02f, 2.58476794e-01f, -2.38458030e-02f, -2.23762065e-01f, 1.38522327e-01f,
  2.24382663e-03f, -3.05288702e-01f, 1.73932806e-01f, 2.75262948e-02f, 1.45096600e-01f, 8.69521797e-02f, -7.65298456e-02f, -1.93221364e-02f, -4.34233844e-02f, 7.13724084e-03f,
  -1.03019126e-01f, -1.07368656e-01f, -1.16921790e-01f, 2.00985745e-02f, 1.92340270e-01f, 1.40686661e-01f, -2.84755737e-01f, 1.49771348e-01f, -3.29776783e-03f, 2.17297636e-02f,
  -1.11891992e-01f, -2.01840587e-02f, -1.64720900e-02f, -1.97821185e-01f, -1.49791136e-01f, -2.56815791e-01f, 8.57824925e-05f, -4.27862592e-02f, -1.22430407e-01f, -1.86656520e-01f,
  1.49794176e-01f, 6.96514100e-02f, 4.02196616e-01f, 6.75717443e-02f, 1.07789002e-01f, 5.37457429e-02f, -3.32516991e-02f, -7.61041865e-02f, 1.01892157e-02f, 1.64718822e-01f,
  -3.54468785e-02f, -5.16009815e-02f, 2.12932471e-02f, -6.14580847e-02f, -6.47477731e-02f, 2.35350318e-02f, -8.33211408e-04f, -4.38453257e-02f, 8.75995979e-02f, 8.42003748e-02f,
  7.04143494e-02f, -8.22837502e-02f, -6.83899820e-02f, -6.30280599e-02f, 1.12822175e-01f, -2.30059400e-02f, 3.07089705e-02f, 5.64398281e-02f, 1.21133827e-01f, 1.89756840e-01f,
  2.22967401e-01f, 1.81169108e-01f, -2.92498916e-02f, 4.92660031e-02f, 9.42071825e-02f, 7.72562623e-02f, 1.61646277e-01f, -1.31591752e-01f, -3.73978093e-02f, 1.16144411e-01f,
  -1.26500383e-01f, -9.79165584e-02f, -9.26562026e-02f, -9.20431688e-02f, -3.81545164e-02f, 2.04436541e-01f, 4.13645320e-02f, 3.03198516e-01f, 2.63666660e-01f, 2.32969094e-02f,
  -2.16939792e-01f, 2.28624910e-01f, 2.00774103e-01f, 1.16147667e-01f, 1.80520546e-02f, -1.18491851e-01f, 9.46303736e-03f, -1.49883524e-01f, -3.61657977e-01f, -6.90985844e-02f,
  2.91604027e-02f, -3.45650315e-01f, 2.85947531e-01f, -2.24064484e-01f, 3.36504467e-02f, 2.69051194e-01f, 1.45218834e-01f, 1.60849780e-01f, -6.47697374e-02f, 1.54922605e-01f,
  1.35978600e-02f, 1.55714273e-01f, 1.28794849e-01f, 1.67240769e-01f, 8.42453241e-02f, -7.25527555e-02f, -1.37971593e-02f, -1.87439665e-01f, 6.60564974e-02f, 6.05984107e-02f,
  -7.05534890e-02f, -3.15966904e-02f, 1.45802675e-02f, 6.42404407e-02f, 2.54377928e-02f, -5.55664673e-03f, -4.36249748e-02f, 3.53976712e-02f, -8.76700412e-03f, 1.01925423e-02f,
  -4.00657533e-03f, 3.21215019e-02f, -3.27609363e-03f, -1.17151342e-01f, -7.60863861e-03f, 1.24959074e-01f, -1.06957614e-01f, -4.27458435e-02f, -7.16774026e-03f, -2.77990196e-02f,
  -5.68549894e-02f, 7.10614175e-02f, -1.63806349e-01f, 1.14343059e-03f, 2.64407009e-01f, 1.80454180e-01f, -2.68059462e-01f, -7.62813538e-02f, 4.25586812e-02f, -4.06385541e-01f,
  -1.19866552e-02f, 1.94427758e-01f, 8.36294964e-02f, -1.84944436e-01f, -1.28127307e-01f, 1.15686819e-01f, 1.86408728e-01f, 1.94262251e-01f, 2.22461537e-01f, 3.42904299e-01f,
  -1.25855133e-01f, 2.48379424e-01f, 1.04304872e-01f, -9.36970562e-02f, 1.90358888e-02f, 9.74435657e-02f, -5.93519956e-02f, -3.58408056e-02f, 3.31975333e-02f, 2.10777476e-01f,
  -1.60246715e-01f, 2.59709619e-02f, -9.32123959e-02f, -2.54259795e-01f, -4.00573388e-02f, -3.25479716e-01f, -3.65262359e-01f, -2.93720156e-01f, 5.99822812e-02f, -1.68168738e-01f,
  8.95578638e-02f, 2.34418422e-01f, 1.67722851e-02f, 1.02796175e-01f, -7.22955614e-02f, -5.15308194e-02f, -2.35716049e-02f, 6.09723888e-02f, 1.41764909e-01f, -1.05302125e-01f,
  -1.57340467e-01f, -1.94260422e-02f, 6.23359829e-02f, 1.41096339e-01f, 1.03757912e-02f, 5.42087518e-02f, -6.22983575e-02f, -7.27664679e-02f, 9.77669433e-02f, -6.18951954e-03f,
  -5.30906804e-02f, 1.45286754e-01f, -9.75746848e-03f, 7.30217621e-03f, -1.99765190e-02f, -1.39259517e-01f, 1.33245766e-01f, -2.86607891e-01f, -1.36655360e-01f, 9.14023742e-02f,
  -1.12566255e-01f, 1.25006139e-01f, -1.78194970e-01f, -5.15117124e-02f, 1.84399206e-02f, -4.04295623e-01f, 7.65581504e-02f, -1.01417385e-01f, 1.55025929e-01f, 2.99140122e-02f,
  1.57825902e-01f, -2.59578258e-01f, 1.77650508e-02f, -1.77338555e-01f, 2.38629896e-02f, -5.43607660e-02f, -7.13656917e-02f, -3.41844976e-01f, -2.10450240e-03f, 1.82183295e-01f,
  5.09087071e-02f, 2.83393264e-01f, -1.64211065e-01f, -2.22736135e-01f, -1.90285712e-01f, -1.22936843e-02f, 1.98627710e-01f, 1.24198064e-01f, 6.19676709e-02f, -1.13697328e-01f,
  -2.41863102e-01f, 3.99647206e-01f, 8.20724219e-02f, 6.81988820e-02f, 1.54146239e-01f, -4.17276360e-02f, -3.34487893e-02f, 3.77753079e-02f, -9.86814573e-02f, 5.93196265e-02f,
  4.81198058e-02f, 1.94365799e-01f, 6.79775774e-02f, 1.08308055e-01f, 3.68927531e-02f, 3.61466333e-02f, -6.17557056e-02f, -8.17745775e-02f, -3.29480879e-02f, 1.55485403e-02f,
  2.82956269e-02f, 1.67562574e-01f, -7.82670155e-02f, -1.11736916e-01f, 1.10071152e-02f, -2.23624945e-01f, -9.83948186e-02f, -2.22945496e-01f, 1.35532007e-01f, 1.36769181e-02f,
  2.47879559e-03f, 1.43217996e-01f, 1.85081720e-01f, 1.42639531e-02f, 5.30604571e-02f, -3.81409302e-02f, -1.62771139e-02f, -1.30988419e-01f, 2.58722063e-02f, 2.65954465e-01f,
  1.96051240e-01f, 7.37192631e-02f, -8.99567921e-03f, -1.71682432e-01f, -4.66566421e-02f, 1.75704747e-01f, -2.68641591e-01f, -6.08646050e-02f, -4.15598750e-02f, -8.10409784e-02f,
  2.88717914e-02f, 2.24136889e-01f, -7.08337426e-02f, 2.05433801e-01f, -9.12152752e-02f, -8.99420679e-02f, 3.14640142e-02f, 3.83035749e-01f, 1.50264174e-01f, -1.16232783e-02f,
  -2.03362241e-01f, -6.01268820e-02f, -7.88799450e-02f, 8.51270705e-02f, 2.13685974e-01f, -2.82082826e-01f
};

// L1_fan_Wp_bar (Shape: 26 x 64)
const int L1_fan_Wp_bar_rows = 26;
const int L1_fan_Wp_bar_cols = 64;
const float L1_fan_Wp_bar_data[] = {
  4.01031375e-02f, -2.13164479e-01f, -1.21247947e-01f, 1.45137519e-01f, 4.37289430e-03f, 2.30402350e-02f, -4.45575714e-02f, 7.45956749e-02f, 1.31425425e-01f, 1.13044702e-01f,
  1.80902481e-01f, 1.06750160e-01f, 2.46366799e-01f, 1.48129120e-01f, 1.69018954e-01f, 2.46390119e-01f, 2.69960284e-01f, 2.65551209e-01f, 2.84083877e-02f, -5.34159988e-02f,
  -1.02180995e-01f, 1.39150485e-01f, -3.50229830e-01f, -4.08435822e-01f, -2.79607385e-01f, -1.24161214e-01f, -1.68779790e-02f, -2.95352973e-02f, -7.71682411e-02f, -3.09792459e-01f,
  2.04130225e-02f, 1.14234686e-01f, 2.17909738e-01f, -1.78719908e-02f, -1.95871741e-01f, 8.75900090e-02f, -3.65713239e-02f, 1.97046205e-01f, 3.99785340e-01f, 1.24746092e-01f,
  2.36982167e-01f, 1.00483492e-01f, 3.07298630e-01f, 2.24235803e-01f, 6.19669080e-01f, 1.14894807e-01f, -1.90922171e-01f, 1.43495813e-01f, -1.41725233e-02f, 5.85206710e-02f,
  -6.93379790e-02f, 2.34608948e-02f, 2.55899966e-01f, -4.70357597e-01f, -1.41936317e-02f, 4.23501909e-01f, -1.09917827e-01f, -7.24599138e-02f, 1.09076425e-02f, 5.75964600e-02f,
  8.41083452e-02f, 2.18528509e-01f, 2.82920748e-01f, -4.61433172e-01f, 2.83977747e-01f, -2.28461437e-02f, 7.59478658e-02f, -9.80336890e-02f, 1.17111646e-01f, 1.31909087e-01f,
  4.65624891e-02f, 1.09460585e-01f, 2.32622996e-01f, 9.93004739e-02f, 7.34634250e-02f, 3.36150490e-02f, 1.41339945e-02f, -2.11279932e-02f, 1.39112845e-01f, 1.53811947e-01f,
  4.42861691e-02f, -1.71324864e-01f, 2.64061689e-01f, -1.54409692e-01f, -9.28779021e-02f, -2.77881950e-01f, 3.41703326e-01f, 4.08329487e-01f, -1.14509754e-01f, -3.53108287e-01f,
  2.06524208e-01f, 1.40463844e-01f, 2.05316707e-01f, 9.53313336e-02f, -1.12811327e-02f, -3.11735064e-01f, -1.39041781e-01f, 1.53622299e-01f, -5.67795373e-02f, -3.34961236e-01f,
  -2.77030855e-01f, -4.53258663e-01f, 9.56569314e-02f, 1.27168790e-01f, -6.38315901e-02f, -1.85362741e-01f, -1.49800435e-01f, 1.11850938e-02f, -2.30790094e-01f, 2.11640194e-01f,
  2.37484619e-01f, -1.85639128e-01f, -6.84785321e-02f, 3.31674106e-02f, -2.62935579e-01f, -2.03619093e-01f, -2.15307474e-01f, 5.88061929e-01f, -2.36803055e-01f, -7.04822913e-02f,
  5.33072948e-01f, 8.25509131e-02f, 8.71968940e-02f, -5.47072999e-02f, 1.25667201e-02f, 9.65058655e-02f, -1.50998965e-01f, 5.02676010e-01f, 5.50942458e-02f, 3.35967660e-01f,
  3.27095836e-01f, 1.36112168e-01f, 1.53699368e-01f, 1.92503601e-01f, 9.16876793e-02f, 1.55763596e-01f, 1.48709370e-02f, 1.12227812e-01f, 3.54282826e-01f, 2.64949113e-01f,
  1.39070407e-01f, 2.53112078e-01f, 2.92691112e-01f, 1.24973327e-01f, 2.62077540e-01f, 2.06038967e-01f, 1.77998930e-01f, -1.00513160e-01f, -1.74330413e-01f, 1.48907423e-01f,
  -2.09169194e-01f, -1.06121577e-01f, -1.72895610e-01f, 3.16516966e-01f, -1.38065085e-01f, 1.44378901e-01f, -2.63492286e-01f, -1.55853719e-01f, 4.68705505e-01f, 1.39184684e-01f,
  -1.40073106e-01f, 4.31944542e-02f, 2.72978216e-01f, 3.73551548e-01f, 4.65126663e-01f, 2.70190984e-01f, 2.23617092e-01f, 1.34298131e-02f, -1.82307102e-02f, 5.55511452e-02f,
  1.92783564e-01f, 3.37070525e-01f, 4.20002848e-01f, -1.05244569e-01f, -6.93002939e-02f, 4.62244675e-02f, -5.88797443e-02f, 2.43517682e-01f, -1.50180042e-01f, 5.37808716e-01f,
  1.04037829e-01f, -1.72342777e-01f, 2.51598477e-01f, 2.28882924e-01f, -5.21587253e-01f, 5.79903312e-02f, -2.39178121e-01f, -1.95951387e-01f, 2.37439037e-03f, 4.55293655e-02f,
  2.66053289e-01f, -4.84485298e-01f, 5.03422245e-02f, 2.45769441e-01f, 3.26222658e-01f, 1.04170166e-01f, 1.21885762e-01f, 2.07977265e-01f, -1.20850429e-01f, -6.34349957e-02f,
  7.31493533e-02f, 2.72794724e-01f, 1.76463589e-01f, 1.17879577e-01f, 3.20628174e-02f, 4.49242303e-03f, -4.37946878e-02f, -2.36581327e-04f, 3.27353984e-01f, 7.81410336e-02f,
  6.61078393e-02f, 2.53037959e-01f, 5.57282306e-02f, 1.60291478e-01f, 1.15470894e-01f, -1.32460356e-01f, 6.17560856e-02f, -3.26062174e-04f, -1.71951558e-02f, 7.17773214e-02f,
  -2.54615605e-01f, 1.12568542e-01f, -4.59154695e-02f, 9.99250412e-02f, -2.62291074e-01f, -1.48011535e-01f, -2.26717591e-01f, -4.29937840e-02f, -1.03194825e-01f, 1.42753394e-02f,
  5.19051135e-01f, 1.97613463e-01f, -1.28290772e-01f, -2.52044350e-02f, 1.83390573e-01f, 3.29775333e-01f, -3.56044918e-02f, -5.48226386e-02f, -1.45103633e-01f, -1.02581359e-01f,
  -1.08559035e-01f, 5.56850851e-01f, -2.44848594e-01f, -1.52351305e-01f, 2.67060935e-01f, 3.09676647e-01f, -3.77299488e-01f, 5.17803013e-01f, 5.28132796e-01f, 3.21162462e-01f,
  -1.05917372e-01f, -1.48990527e-01f, 1.33400410e-01f, 1.85523719e-01f, 4.81660604e-01f, 9.65393111e-02f, -3.10664892e-01f, 8.96520019e-02f, 2.20333070e-01f, 2.94316590e-01f,
  1.46890312e-01f, 1.60081446e-01f, 1.89591989e-01f, 1.41630605e-01f, -1.54131725e-02f, 3.65277201e-01f, 1.11965336e-01f, 1.49608001e-01f, 4.18122023e-01f, 2.56827444e-01f,
  9.62226465e-02f, 2.09678382e-01f, 3.37169647e-01f, 3.78572851e-01f, 2.52424628e-01f, 1.14509210e-01f, -1.78591922e-01f, -1.02174230e-01f, -2.38962904e-01f, -3.63895088e-01f,
  -2.25876883e-01f, 4.27770764e-01f, -1.16095796e-01f, -3.27854790e-02f, -4.80656289e-02f, -2.78093994e-01f, -9.86635238e-02f, -1.39169827e-01f, 2.07334384e-01f, 5.57865910e-02f,
  -1.66507587e-01f, -9.02026804e-05f, 1.44619390e-01f, 7.30267465e-02f, 2.28228733e-01f, -8.75088423e-02f, 6.56332135e-01f, -1.83329910e-01f, 1.46876425e-01f, -2.45470926e-01f,
  2.58115172e-01f, -4.45978284e-01f, -1.63219795e-01f, 1.64510176e-01f, 4.89945114e-01f, 4.22205590e-02f, 8.24462101e-02f, 5.32853007e-01f, 3.82672369e-01f, -1.26416311e-01f,
  -4.22551066e-01f, 4.33069974e-01f, -3.92243892e-01f, 2.45440006e-02f, 1.18317828e-02f, 2.94795688e-02f, -8.00542906e-02f, 7.62097817e-03f, 3.47193986e-01f, -1.14477105e-01f,
  2.21539214e-01f, 2.07473218e-01f, 5.95995709e-02f, 2.71002918e-01f, 6.25142157e-02f, 2.81458855e-01f, 3.46189588e-01f, 1.50056155e-02f, 2.12522540e-02f, -2.36719027e-01f,
  4.25266214e-02f, 2.61703134e-01f, -1.88425593e-02f, 8.11251700e-02f, 1.32805735e-01f, 1.98416904e-01f, -8.16221833e-02f, 1.19965918e-01f, 1.30769268e-01f, -2.58599401e-01f,
  -2.22276095e-02f, -6.53689168e-03f, 1.05581423e-02f, 2.22998112e-01f, 7.09983069e-05f, -8.72112736e-02f, 4.63588350e-03f, -1.60510302e-01f, 1.37495875e-01f, -2.25348219e-01f,
  -3.01845521e-02f, -2.76899412e-02f, 2.56057501e-01f, 1.47441298e-01f, 2.14688212e-01f, 4.44456547e-01f, 8.66818279e-02f, -3.44026923e-01f, -1.73288099e-02f, 2.28900686e-01f,
  1.30943075e-01f, 1.41895428e-01f, -1.01631947e-01f, -1.84460863e-01f, 1.79232419e-01f, 2.04925328e-01f, 4.12205547e-01f, 3.25186878e-01f, -2.92318642e-01f, -3.18953663e-01f,
  6.82755783e-02f, -2.06436470e-01f, -4.01819050e-01f, -6.14017732e-02f, 3.21857095e-01f, -3.98493111e-01f, 7.97787867e-03f, 1.01534463e-01f, -4.80969995e-02f, 2.05966249e-01f,
  -1.70923509e-02f, 3.86447400e-01f, -4.48825181e-01f, 5.29366672e-01f, 1.12436950e-01f, 1.27904087e-01f, -1.93685472e-01f, -1.74056992e-01f, 1.18828334e-01f, 1.83155209e-01f,
  -3.10185738e-02f, 4.87771891e-02f, 1.45531803e-01f, 1.12611793e-01f, 4.06010091e-01f, 2.85439014e-01f, 1.77597225e-01f, -4.38147672e-02f, -1.23417899e-01f, -2.96665877e-02f,
  -1.20537095e-02f, 1.08654469e-01f, 8.93647783e-03f, 1.25869468e-01f, 8.21154341e-02f, 9.23116356e-02f, -4.59019601e-01f, -4.39279079e-02f, -1.88016042e-01f, -4.38571900e-01f,
  -1.90005377e-01f, 1.73815042e-01f, -1.76383644e-01f, -1.50137410e-01f, -1.51249334e-01f, 1.37216926e-01f, 6.27737716e-02f, 2.05525495e-02f, -5.32100685e-02f, 9.89100635e-02f,
  7.05048889e-02f, 1.72987849e-01f, -3.87389451e-01f, -8.54755268e-02f, -6.11329854e-01f, -3.35682966e-02f, 3.77298087e-01f, 1.12138964e-01f, 6.32546186e-01f, 2.27509990e-01f,
  9.60785821e-02f, 6.11240789e-02f, -2.66310722e-01f, 2.03392774e-01f, -1.56800270e-01f, -5.97985744e-01f, -1.63812354e-01f, 1.93039775e-01f, -6.15526214e-02f, 2.61706471e-01f,
  4.99848910e-02f, 1.71416044e-01f, -2.36774042e-01f, -6.62697405e-02f, -7.25140497e-02f, 4.47725922e-01f, 4.42334771e-01f, -1.50454909e-01f, 8.42812285e-02f, 6.97482750e-02f,
  3.54398638e-01f, 8.08441341e-02f, 7.69715384e-02f, 1.51658714e-01f, 3.57704610e-02f, 1.02794886e-01f, -2.38602725e-03f, -7.46963918e-02f, -1.35306583e-03f, -3.21370512e-02f,
  -7.61649087e-02f, 2.91108917e-02f, 2.56955057e-01f, 9.69604030e-02f, 1.27207428e-01f, 2.26713046e-01f, 3.94076496e-01f, 2.18399707e-02f, 2.29357585e-01f, -6.46738485e-02f,
  4.91709679e-01f, 8.14525038e-02f, 9.19260606e-02f, -2.06953824e-01f, 6.91563264e-03f, 1.43165037e-01f, -1.53299227e-01f, 1.64807722e-01f, 4.52755317e-02f, 3.85678653e-03f,
  -3.85502636e-01f, -1.53005555e-01f, -2.46110290e-01f, -6.10789478e-01f, -3.07916462e-01f, -2.41143405e-01f, 3.09596747e-01f, 6.32821992e-02f, 2.39732713e-01f, 3.22010338e-01f,
  2.22547159e-01f, 1.60225123e-01f, -1.23770706e-01f, 2.71527439e-01f, -1.77666303e-02f, -3.15952413e-02f, -5.80160171e-02f, -3.64040732e-01f, -2.29092717e-01f, -4.10252512e-01f,
  -6.40065074e-02f, 6.31390274e-01f, 3.76257569e-01f, -7.73617625e-02f, 5.05045593e-01f, 3.34590703e-01f, 8.60321000e-02f, -1.06098987e-01f, -1.03994131e-01f, -1.86811592e-02f,
  -1.45271853e-01f, 2.68797576e-01f, -1.62006155e-01f, -1.16084285e-01f, -1.30286679e-01f, 2.33422220e-01f, -2.56820191e-02f, -4.30292077e-02f, 1.37153253e-01f, -2.36703120e-02f,
  1.15256295e-01f, -3.48731428e-01f, 1.14786282e-01f, -1.14641026e-01f, -1.87236696e-01f, -2.11903706e-01f, 1.79176275e-02f, 7.92767294e-03f, -4.20966744e-02f, 1.94492370e-01f,
  -1.19092561e-01f, -7.20359087e-02f, 1.13865383e-01f, 5.14650382e-02f, -3.82757336e-01f, 5.50793782e-02f, -4.13500629e-02f, -1.49719864e-01f, -1.07785407e-03f, 2.04175953e-02f,
  8.62545222e-02f, 4.98730950e-02f, 1.44698530e-01f, 3.21835816e-01f, -1.46205306e-01f, -1.99100271e-01f, -1.42480269e-01f, 1.32847741e-01f, -1.44781647e-02f, 5.61522730e-02f,
  -2.46543154e-01f, 1.67780310e-01f, 4.37918631e-03f, -8.99602994e-02f, 4.85319763e-01f, 6.50338605e-02f, 1.77118212e-01f, 3.83155286e-01f, -1.41489292e-02f, 1.60446718e-01f,
  -3.71506363e-01f, -2.39413932e-01f, 2.04877302e-01f, -1.81063205e-01f, 2.22248554e-01f, -1.79251358e-01f, 1.75212458e-01f, 2.13963981e-03f, -2.85561204e-01f, 5.27393699e-01f,
  -2.08272964e-01f, 3.05267181e-02f, 7.18117654e-02f, -1.88517123e-01f, -5.35895340e-02f, -3.36277843e-01f, -7.84865543e-02f, 3.46841156e-01f, 2.71805286e-01f, 2.11597785e-01f,
  4.90126908e-02f, -2.43167114e-02f, 2.77075350e-01f, -1.17792590e-02f, 1.74309667e-02f, -1.77607778e-02f, 2.58872826e-02f, -2.10781302e-02f, 2.87408195e-02f, 1.13323666e-01f,
  -8.15619249e-03f, 6.41423538e-02f, -4.93345968e-03f, 1.10877074e-01f, 3.59872669e-01f, 3.85068327e-01f, -3.19919996e-02f, -9.57139730e-02f, 4.03316021e-01f, -1.41699478e-01f,
  3.90702337e-01f, 3.75753462e-01f, 1.54633135e-01f, -6.43452182e-02f, 1.28495589e-01f, 3.61201465e-01f, -5.07245481e-01f, -2.98969448e-01f, 2.45390870e-02f, -4.04095612e-02f,
  -1.21473029e-01f, 3.30099255e-01f, 3.27610672e-02f, 1.26297534e-01f, 5.01123488e-01f, 2.99375027e-01f, -1.87443897e-01f, -1.35700135e-02f, -1.01375952e-01f, -3.54259402e-01f,
  -7.45546401e-01f, -1.89189881e-01f, 2.06971258e-01f, -1.63907126e-01f, -3.00749749e-01f, 1.21615492e-01f, 2.49641076e-01f, 5.36452532e-01f, 4.41534907e-01f, 1.61689650e-02f,
  -1.58036396e-01f, -8.18391517e-02f, 2.14984909e-01f, 1.33860052e-01f, -8.39344189e-02f, 3.85651767e-01f, 8.95310566e-03f, 2.11010337e-01f, 1.06829569e-01f, 7.19910383e-01f,
  5.36427880e-03f, -1.25846773e-01f, 5.29272929e-02f, 1.88268237e-02f, 8.00147429e-02f, 3.35942917e-02f, -2.04801075e-02f, -1.36468232e-01f, 1.05400104e-02f, 7.08202422e-02f,
  -9.97240469e-03f, -1.17706573e-02f, 1.68779045e-01f, -2.92172078e-02f, -2.50763595e-01f, -5.50622679e-02f, 2.16314539e-01f, 1.18561529e-01f, 1.03172317e-01f, 3.68916690e-01f,
  2.74492741e-01f, -1.37825638e-01f, 2.07513408e-03f, -5.32798409e-01f, 2.14806676e-01f, -2.62112528e-01f, 1.15809381e-01f, 1.44383311e-01f, -7.39593208e-02f, 9.49142203e-02f,
  -5.53987205e-01f, -1.15595482e-01f, -1.63190871e-01f, -2.56348968e-01f, -3.77083033e-01f, -6.10923231e-01f, -5.06514430e-01f, 1.70222551e-01f, 5.45201778e-01f, 2.78110653e-01f,
  -4.11220007e-02f, -3.50630850e-01f, 3.41470748e-01f, 1.96661100e-01f, -1.88396618e-01f, 8.00941810e-02f, 1.52230084e-01f, -7.62107670e-02f, -3.10394228e-01f, -2.42703184e-01f,
  -1.83770925e-01f, 1.94624737e-01f, 3.68362725e-01f, 1.62405655e-01f, -2.55483687e-01f, 5.71567833e-01f, 4.69967097e-01f, 3.34462076e-01f, -4.16839272e-01f, -1.30347997e-01f,
  -3.93332392e-01f, -7.44163394e-02f, 1.04673065e-01f, 4.53351766e-01f, 2.85218269e-01f, -9.75882262e-02f, -4.98392507e-02f, 1.78638160e-01f, 3.16900499e-02f, 1.56081989e-01f,
  4.09208909e-02f, -1.70097817e-02f, 2.10344329e-01f, -1.31575122e-01f, 1.29990757e-01f, 6.88741133e-02f, 1.88815013e-01f, 2.25091204e-01f, 1.60667807e-01f, 1.79420799e-01f,
  -8.90730619e-02f, 1.74352840e-01f, 1.02459237e-01f, 9.53744277e-02f, -1.48370028e-01f, -4.25718993e-01f, -7.75515214e-02f, -3.10130984e-01f, -2.73097545e-01f, -1.54467106e-01f,
  -1.01645235e-02f, 4.44244705e-02f, 4.45425540e-01f, -1.68720171e-01f, -2.75817126e-01f, -1.16522878e-01f, 3.24398518e-01f, 1.09509647e-01f, 4.87565575e-03f, 3.29505950e-01f,
  2.28719160e-01f, -2.68747926e-01f, 5.08074343e-01f, 2.44803414e-01f, -3.60320449e-01f, -1.99091747e-01f, -3.26867133e-01f, 3.27333689e-01f, -4.58937049e-01f, -4.37654138e-01f,
  3.57142389e-01f, -1.82834417e-01f, 2.04800844e-01f, -5.63297272e-01f, 2.45552301e-01f, 7.73994923e-01f, 3.66049111e-01f, -1.18353866e-01f, -1.03506900e-01f, 2.69695848e-01f,
  3.81531388e-01f, -5.73244691e-01f, 1.33286817e-02f, 8.59716684e-02f, -1.47539992e-02f, -4.67058830e-02f, -7.42308795e-02f, 2.68105686e-01f, 7.90916681e-02f, 1.28684686e-02f,
  -6.82426170e-02f, -6.72684163e-02f, 1.46349028e-01f, -1.63405426e-02f, -2.23421045e-02f, 8.44806209e-02f, -1.18580852e-02f, -1.78467572e-01f, 5.36473421e-03f, -1.55597717e-01f,
  -2.67892212e-01f, -1.33072212e-01f, 2.02266276e-01f, 1.87595397e-01f, 2.03636736e-01f, 3.65937501e-02f, 5.76643832e-02f, -1.28664315e-01f, -1.24690346e-02f, -3.08791511e-02f,
  8.18165988e-02f, 3.27988639e-02f, 1.07518919e-01f, 4.51789191e-03f, 4.88091186e-02f, -1.02760777e-01f, 1.15639642e-01f, 7.85852298e-02f, 2.60103494e-01f, 2.82075644e-01f,
  -2.21757501e-01f, 6.84706792e-02f, -7.00267358e-03f, -4.61727440e-01f, -3.26023936e-01f, -1.88222751e-01f, -8.41357410e-02f, 2.44837523e-01f, 2.49608502e-01f, -6.46824837e-02f,
  8.83945376e-02f, 1.60222694e-01f, 9.42927226e-02f, 6.15764141e-01f, 4.37437668e-02f, 1.87443092e-01f, 2.62411207e-01f, -2.12614790e-01f, 1.43899053e-01f, -4.97600526e-01f,
  -3.14332068e-01f, -4.84504439e-02f, 2.91292518e-01f, -2.70432353e-01f, 3.90303195e-01f, 4.18065339e-01f, -1.33324519e-01f, -1.42697655e-02f, -8.29483718e-02f, -1.80188313e-01f,
  -2.66197979e-01f, 2.77485996e-01f, 4.59399000e-02f, 3.74824017e-01f, 3.89660388e-01f, 4.14102435e-01f, -1.57301024e-01f, 1.99342787e-01f, 2.00732067e-01f, 2.08577186e-01f,
  -1.37520134e-01f, 8.79890770e-02f, 2.27730840e-01f, 1.30518809e-01f, 1.44686446e-01f, 4.63059917e-02f, 8.13870654e-02f, 1.65317059e-01f, 1.76973209e-01f, 2.34581396e-01f,
  4.78179097e-01f, 1.51897609e-01f, -2.41588838e-02f, -3.73898864e-01f, 1.46781340e-01f, 1.79230481e-01f, 1.51586160e-01f, -1.62597835e-01f, 1.68726847e-01f, 2.73371816e-01f,
  1.15591511e-02f, 1.40671268e-01f, -5.32574095e-02f, -5.27038351e-02f, -1.26274610e-02f, 1.56036943e-01f, -3.08714986e-01f, 6.72536567e-02f, 5.14313638e-01f, -3.20721626e-01f,
  3.14868599e-01f, 2.67034471e-01f, -6.95978105e-02f, -5.00575423e-01f, 7.89161399e-02f, -7.63042942e-02f, -7.70057917e-01f, -2.48693213e-01f, 3.06143194e-01f, -2.67091393e-01f,
  2.61243075e-01f, -9.16241556e-02f, -2.57847402e-02f, 6.52681649e-01f, 2.30492339e-01f, 7.51740813e-01f, -3.16768497e-01f, 1.87213585e-01f, -3.17089893e-02f, 6.87064137e-03f,
  -2.76184112e-01f, -3.98552895e-01f, -6.74437061e-02f, -2.38117557e-02f, 4.15505059e-02f, -8.25969726e-02f, 2.59369552e-01f, 2.08862036e-01f, 2.08262727e-01f, -3.51802558e-02f,
  3.48790139e-01f, 7.27834925e-02f, 2.38328427e-01f, 1.54336736e-01f, -8.23822096e-02f, -1.08819000e-01f, 7.95343816e-02f, -8.91565308e-02f, -2.02140555e-01f, -9.24211927e-03f,
  2.72381574e-01f, 1.91037238e-01f, 1.76169828e-01f, 1.63594693e-01f, 4.50368434e-01f, 1.64948925e-02f, 1.77263990e-01f, 4.80045713e-02f, 3.93297434e-01f, 2.11720243e-01f,
  2.49080107e-01f, 1.26876980e-01f, 4.47701365e-02f, -7.94477686e-02f, 1.31919151e-02f, 3.21589708e-01f, 1.62676394e-01f, 1.52991086e-01f, -2.29265869e-01f, -1.21682905e-01f,
  -3.68260555e-02f, -4.15806532e-01f, -3.78828287e-01f, 9.35382023e-02f, -9.44250673e-02f, -1.98543802e-01f, -4.04348344e-01f, 1.49053410e-01f, 1.92060340e-02f, 1.41783670e-01f,
  -8.91437680e-02f, 5.76969445e-01f, 5.55413477e-02f, 5.88033386e-02f, 1.53213993e-01f, 9.12857354e-02f, 2.29798183e-01f, -3.54610234e-01f, -1.03267089e-01f, 2.90165305e-01f,
  5.46105146e-01f, -2.04099730e-01f, 1.54178262e-01f, 4.06272322e-01f, 1.03894196e-01f, 1.18101567e-01f, -2.22960413e-01f, -2.71272212e-01f, -3.48127335e-01f, 5.75726211e-01f,
  1.89540088e-01f, 1.02793217e-01f, -2.08428323e-01f, 1.53370380e-01f, 8.47779587e-02f, 1.81983620e-01f, 1.88237563e-01f, 1.82974949e-01f, 2.99437717e-02f, -4.68614623e-02f,
  4.30432498e-01f, 2.58934230e-01f, 1.04815461e-01f, -2.71506179e-02f, -1.06966205e-01f, 1.77030101e-01f, 2.35476822e-01f, 1.59387514e-02f, 4.87253778e-02f, -6.48782924e-02f,
  1.31327540e-01f, -1.66312322e-01f, -4.74692494e-01f, 2.58353621e-01f, -2.68982917e-01f, -6.31377399e-01f, 1.59870550e-01f, 5.06378375e-02f, 3.39628533e-02f, -2.39188001e-01f,
  8.31060931e-02f, 1.63835898e-01f, 2.54434854e-01f, 3.28052714e-02f, 1.37827788e-02f, 3.96734446e-01f, 3.19102317e-01f, 1.48822159e-01f, -5.84599257e-01f, -7.93141276e-02f,
  -2.11544156e-01f, -3.24980877e-02f, 3.10020894e-01f, 8.83416831e-02f, 1.19896121e-01f, 1.61533982e-01f, 3.06549549e-01f, 5.15828542e-02f, -2.99225301e-01f, 1.03134498e-01f,
  8.06118324e-02f, 1.55225024e-01f, -1.13840185e-01f, 4.91065919e-01f, 3.19407672e-01f, 1.79140598e-01f, -1.54960141e-01f, 1.22584254e-01f, -6.55601770e-02f, -2.57154834e-02f,
  3.43109071e-01f, 1.48007832e-02f, 3.40127349e-01f, -5.25678456e-01f, 2.62331575e-01f, 1.59928992e-01f, 4.27954942e-01f, -4.46945801e-02f, 2.95830220e-01f, 2.55795568e-02f,
  2.71166027e-01f, 1.00950971e-01f, 4.17073518e-02f, 2.91578859e-01f, 1.95606738e-01f, 2.56495010e-02f, 4.23583835e-02f, -6.47052974e-02f, 1.90698668e-01f, 1.17861696e-01f,
  -2.28817500e-02f, 2.67865688e-01f, 2.64489174e-01f, 1.09781981e-01f, 2.23578420e-02f, -1.94377616e-01f, 1.84080943e-01f, 1.35022476e-02f, 1.40272319e-01f, -1.80788308e-01f,
  -1.14056870e-01f, -1.69951230e-01f, 1.38645500e-01f, 3.35845411e-01f, -1.60425544e-01f, -1.65140450e-01f, -1.54979065e-01f, -7.25172088e-02f, -1.98267996e-01f, -2.53380924e-01f,
  -2.09553346e-01f, -3.02811503e-01f, 3.18650097e-01f, -1.76403850e-01f, -2.27550656e-01f, 2.39599049e-01f, -2.23954618e-01f, -6.02261834e-02f, -2.31188700e-01f, -2.44918708e-02f,
  2.46016681e-01f, 2.02016309e-02f, -1.01320632e-01f, -1.42142236e-01f, 1.61253810e-01f, -4.00047541e-01f, -2.15562239e-01f, 4.59543943e-01f, -3.54323328e-01f, -5.33837341e-02f,
  4.93295193e-01f, 1.44310907e-01f, -7.54155070e-02f, 1.50978506e-01f, -2.70337939e-01f, 5.65885752e-02f, -4.69261110e-02f, 7.62652457e-01f, -6.38917610e-02f, -2.18417104e-02f,
  1.39093965e-01f, 1.88133836e-01f, 7.30924830e-02f, 3.01233530e-02f, 1.77612826e-01f, 1.65629387e-01f, 1.68800056e-01f, -2.70440698e-01f, 8.78401250e-02f, -1.00813583e-02f,
  -1.54733673e-01f, -6.74618706e-02f, 8.92538428e-02f, 1.01419069e-01f, 2.22342595e-01f, 5.66474944e-02f, -5.34095522e-03f, -2.83801079e-01f, 6.27668053e-02f, 1.71065196e-01f,
  -2.71121323e-01f, 1.70973986e-02f, -2.22024471e-01f, -1.32178858e-01f, 2.28375066e-02f, 7.98647627e-02f, 1.46774262e-01f, -1.01861559e-01f, 4.29517299e-01f, 2.32267484e-01f,
  -1.88160166e-01f, 6.75738007e-02f, 8.39708894e-02f, -2.57037897e-02f, -5.73034063e-02f, -7.25873038e-02f, 1.11777730e-01f, 3.34108353e-01f, 3.19549382e-01f, 1.81440577e-01f,
  1.84886962e-01f, 3.68710645e-02f, -1.71607696e-02f, 6.52122200e-02f, -1.20207630e-01f, 1.38129383e-01f, -4.39103879e-02f, -4.91397768e-01f, -3.50461416e-02f, -6.26036711e-03f,
  -3.61215770e-01f, 5.49589455e-01f, 4.84461397e-01f, -3.32515895e-01f, 3.89990956e-02f, 2.57707179e-01f, -1.96097251e-02f, 1.31977096e-01f, 9.56333354e-02f, 6.36803880e-02f,
  -6.05425954e-01f, -5.16481400e-01f, 3.06179225e-01f, 2.54431784e-01f, 2.31409427e-02f, 1.92683503e-01f, 1.35805756e-01f, 1.89248264e-01f, 2.93270618e-01f, 1.72030240e-01f,
  -2.65709888e-02f, -1.32604554e-01f, 1.03120267e-01f, 1.89100772e-01f, 1.19355634e-01f, 1.98758125e-01f, 2.38310471e-01f, 1.74176648e-01f, 1.20598800e-01f, 2.34953895e-01f,
  3.34326684e-01f, -1.50336757e-01f, -2.62364689e-02f, -5.97172007e-02f, -1.68268919e-01f, 1.38954088e-01f, -2.82874964e-02f, -8.20420384e-02f, 6.16851114e-02f, 2.20972314e-01f,
  2.13987514e-01f, 1.83487102e-01f, 2.26294219e-01f, 1.88075721e-01f, -1.13695294e-01f, 2.54621059e-01f, 1.73074692e-01f, 2.76070267e-01f, 4.20876443e-01f, 2.85321534e-01f,
  -7.18506575e-02f, 2.31191844e-01f, -2.70622373e-01f, -1.47566438e-01f, -6.31313175e-02f, 2.54065305e-01f, -2.58584797e-01f, 3.52560252e-01f, 3.23900700e-01f, -2.28902102e-02f,
  2.30423868e-01f, 1.86315015e-01f, 3.21483672e-01f, 8.27183485e-01f, 1.78048223e-01f, 2.29604170e-01f, 4.64175820e-01f, 1.53229073e-01f, -3.66161883e-01f, 2.83944290e-02f,
  -5.01019098e-02f, -1.68011904e-01f, 8.76864865e-02f, -1.98284209e-01f, -1.48748845e-01f, -6.29236221e-01f, 8.12354758e-02f, 2.98235923e-01f, 2.52415776e-01f, 1.03091657e-01f,
  5.00677079e-02f, 1.90294519e-01f, -5.30301891e-02f, 6.40278161e-02f, 5.45407534e-02f, -1.09841853e-01f, -7.04319999e-02f, -4.95380051e-02f, 1.11579478e-01f, 1.54629216e-01f,
  7.62617812e-02f, 7.87884742e-02f, 3.99047807e-02f, -2.15139180e-01f, 2.29731545e-01f, 1.51241437e-01f, -5.67697473e-02f, 1.36770308e-01f, 3.62433851e-01f, -1.99790999e-01f,
  9.42518637e-02f, 3.94313812e-01f, 3.40615883e-02f, -1.03308111e-01f, -2.21043363e-01f, 2.51388758e-01f, 1.48331150e-01f, -1.70679376e-01f, -4.94052321e-02f, -1.88323557e-01f,
  1.65194005e-01f, -2.08895668e-01f, -8.62985775e-02f, 1.39630809e-01f, 3.57472956e-01f, 2.43518844e-01f, -3.56701285e-01f, -1.12954967e-01f, -7.56532103e-02f, 3.94419819e-01f,
  7.78135881e-02f, 1.36739552e-01f, 2.77237277e-02f, -1.58150747e-01f, 3.08106214e-01f, 7.59830594e-01f, -5.08883178e-01f, -1.66527078e-01f, 6.14554249e-02f, -4.32311445e-02f,
  -4.17988867e-01f, -7.35208988e-02f, 6.74319804e-01f, 1.20388642e-01f, 2.50450164e-01f, -1.72641650e-01f, -4.56031226e-02f, 4.65203285e-01f, 4.91369635e-01f, 2.15366334e-01f,
  -1.50649518e-01f, 2.79657990e-01f, 1.03441715e-01f, 2.22700149e-01f, -1.06648199e-01f, -2.38838047e-02f, 1.56992391e-01f, 2.01298639e-01f, -3.45676416e-03f, -7.97451194e-03f,
  -6.10832833e-02f, -2.74310191e-03f, -1.36571780e-01f, 1.05970599e-01f, -1.15161017e-01f, -6.33716583e-02f, 1.43953398e-01f, 1.83993489e-01f, 1.46395534e-01f, 2.86370188e-01f,
  -2.10402876e-01f, -1.57628171e-02f, 3.23699564e-01f, -2.70008117e-01f, 4.48438376e-01f, 5.39019525e-01f, 4.11091112e-02f, -2.18500152e-01f, -4.74132478e-01f, 2.57015765e-01f,
  -2.97010895e-02f, 2.70686150e-01f, -6.85762614e-02f, -3.86046141e-01f, -3.08590196e-02f, -2.38034308e-01f, -1.70301855e-01f, 3.84266704e-01f, 3.52419913e-02f, -1.99948892e-01f,
  -2.09655881e-01f, -2.80444741e-01f, 2.43079476e-02f, 8.05729553e-02f, -2.17069596e-01f, 1.68895185e-01f, -3.05370808e-01f, -2.13030696e-01f, 2.78586805e-01f, 3.09485883e-01f,
  -2.07130969e-01f, 1.98323905e-01f, 2.43134528e-01f, 1.40650705e-01f, -4.92877424e-01f, 1.48500398e-01f, -1.40709028e-01f, 4.16223973e-01f, 1.31778076e-01f, -1.60627916e-01f,
  -2.62255333e-02f, -1.57551780e-01f, 7.16026276e-02f, 6.08973689e-02f, 2.83525020e-01f, 4.74848896e-02f, 2.34133527e-01f, 1.69490039e-01f, 2.21640840e-01f, 8.28129873e-02f,
  1.39579609e-01f, 2.61305779e-01f, 1.08702458e-01f, 2.06531268e-02f, 1.76408395e-01f, 2.08382234e-01f, 6.18183278e-02f, 1.07816204e-01f, 1.21876091e-01f, 9.46833789e-02f,
  2.06114873e-01f, 2.37021953e-01f, 1.67121574e-01f, -2.97343522e-01f, 8.11317191e-02f, 3.59029114e-01f, 3.04872338e-02f, -5.69906924e-03f, -2.12237090e-01f, 1.28149107e-01f,
  -2.18863115e-02f, -4.61279973e-02f, -3.41428250e-01f, 4.25293408e-02f, 4.18988168e-01f, -1.59870312e-02f, -2.88260430e-01f, -3.94510813e-02f, 1.27063900e-01f, -3.57700810e-02f,
  -1.59775093e-01f, 8.27213749e-02f, -1.42067865e-01f, 2.17739455e-02f, 1.41636699e-01f, 1.55355960e-01f, 1.38676047e-01f, 2.37808973e-01f, 4.87590730e-01f, 4.48476583e-01f,
  5.14656678e-02f, 2.41682380e-01f, 1.53597638e-01f, 4.92776245e-01f, 7.10238367e-02f, -5.27016044e-01f, -2.58868098e-01f, -1.32249100e-02f, 1.31067678e-01f, -2.04066217e-01f,
  4.55101207e-02f, 2.24409983e-01f, -1.44291386e-01f, -5.84415998e-03f, -1.27507702e-01f, 1.86359793e-01f, 2.47927397e-01f, -3.22638363e-01f, 2.64609963e-01f, 1.64478675e-01f,
  -2.71976385e-02f, 1.03152715e-01f, 2.15665549e-01f, 5.90250478e-04f, 7.47970641e-02f, 8.85051489e-02f, 8.66656676e-02f, 2.01247722e-01f, 2.53867328e-01f, 1.52586728e-01f,
  2.40785748e-01f, 2.90283650e-01f, 2.46381998e-01f, 2.57459700e-01f, 1.79479346e-01f, 2.20636293e-01f, 1.14476129e-01f, -2.15410404e-02f, -2.78152198e-01f, 6.69009835e-02f,
  -1.66644990e-01f, -1.80678174e-01f, -1.87402084e-01f, 3.93761009e-01f, -2.62473941e-01f, -2.83594340e-01f, 1.80890523e-02f, -7.00730039e-03f, 6.41323328e-02f, -2.26204172e-01f,
  1.40209764e-01f, -1.70082405e-01f, 3.29877198e-01f, 3.85687709e-01f, 7.42788538e-02f, 1.74578354e-01f, 4.19458866e-01f, 4.17615026e-02f, 9.30633917e-02f, 2.38495231e-01f,
  -1.70601010e-01f, 3.70825559e-01f, 4.42607433e-01f, 2.31392205e-01f, 2.62831032e-01f, 2.41403937e-01f, 3.74113739e-01f, 4.44475502e-01f, 1.49866000e-01f, 3.02111544e-02f,
  4.15333807e-02f, -6.26068294e-01f, -3.89296897e-02f, 1.51950508e-01f, -1.37966186e-01f, -2.08688974e-01f, 2.95186881e-02f, 3.38826895e-01f, -1.33329645e-01f, 4.30078000e-01f,
  1.92254633e-01f, 4.19926554e-01f, -2.82037556e-01f, 3.42687033e-02f, -6.27005175e-02f, -1.72554016e-01f, -1.63571741e-02f, -1.46827593e-01f, -1.42444327e-01f, -2.28074007e-03f,
  -1.67069793e-01f, -7.18884170e-02f, -1.50687888e-01f, 5.23363538e-02f, -7.02317059e-02f, 7.69527927e-02f, -1.51549503e-01f, -9.93946120e-02f, -1.39266923e-01f, -6.09098300e-02f,
  2.72630081e-02f, -2.99416147e-02f, -2.10448250e-01f, 1.33542586e-02f, 9.87879117e-04f, -8.14045444e-02f, 1.12736188e-01f, -6.40476421e-02f, -1.42824113e-01f, 2.46328767e-02f,
  -2.09571153e-01f, 1.07510388e-01f, -7.13279173e-02f, -1.42082661e-01f, 5.67766167e-02f, -6.75100908e-02f, 2.69880537e-02f, -7.35066533e-02f, 3.49299684e-02f, 2.27534734e-02f,
  3.55402648e-01f, 7.75118619e-02f, 2.16188639e-01f, 5.96267916e-02f, 2.03268453e-01f, 2.65746862e-01f, 1.28070429e-01f, -1.61126509e-01f, -1.39284983e-01f, 2.04366103e-01f,
  -2.07925383e-02f, -2.87109107e-01f, 1.04118899e-01f, 1.19235560e-01f, -6.60949424e-02f, 7.94400498e-02f, 1.40960068e-01f, 1.04063340e-01f, 6.55739158e-02f, 2.16175288e-01f,
  -1.76705837e-01f, 1.13113962e-01f, 2.26203218e-01f, -4.45481315e-02f, 2.07328454e-01f, -4.88028616e-01f, -8.75882506e-02f, 3.29040289e-01f, 2.72396684e-01f, 6.02401793e-02f,
  6.65758969e-03f, 3.84446867e-02f, 4.25047092e-02f, 1.62706807e-01f, 7.16583580e-02f, 2.53809810e-01f, 7.23639876e-02f, 1.42210517e-02f, 6.93508163e-02f, 2.90304959e-01f,
  -2.53678802e-02f, 1.78689554e-01f, 2.95200557e-01f, 3.03615004e-01f, 1.95892662e-01f, 2.33344615e-01f, -3.14075127e-02f, -5.21105900e-02f, 2.35218719e-01f, -1.20972909e-01f,
  -2.50268459e-01f, 3.07575107e-01f, 7.95245394e-02f, 2.14212418e-01f, -5.20378053e-01f, 3.08505952e-01f, 3.19568723e-01f, -2.88026184e-02f, -4.45560396e-01f, -2.06243694e-02f,
  -8.55036378e-02f, -1.19847767e-01f, 4.09219414e-01f, 2.70153075e-01f, 1.23358056e-01f, -1.23495445e-01f, -4.01347131e-02f, 1.23838872e-01f, 6.22300282e-02f, 1.99878871e-01f,
  -5.21854997e-01f, -2.60408759e-01f, -1.20720007e-01f, 1.18030660e-01f, 2.86482535e-02f, 1.24292731e-01f, 4.92700711e-02f, 3.57358217e-01f, 1.93603471e-01f, 3.44576210e-01f,
  1.85057800e-02f, 2.40131870e-01f, -3.05272907e-01f, -6.35348668e-04f, -1.93597034e-01f, -7.57930949e-02f, 4.30050045e-02f, 2.13645380e-02f, 7.79731944e-02f, -6.76806644e-02f,
  -1.11556701e-01f, 3.30289416e-02f, 1.07182957e-01f, 1.96435288e-01f, 1.30553991e-01f, 2.02733502e-01f, -1.63967207e-01f, -2.84843077e-03f, 2.43045926e-01f, 5.39415479e-01f,
  2.40977377e-01f, 1.75873586e-03f, 1.84709206e-01f, 2.96308137e-02f, -7.90586770e-02f, -1.74260847e-02f, 1.76549777e-01f, 4.11585301e-01f, -8.30426216e-02f, 3.92193407e-01f,
  2.85661250e-01f, -9.17872041e-02f, -4.26961660e-01f, -2.24452108e-01f, -2.18180865e-01f, -2.92246759e-01f, 1.63007736e-01f, -6.86928071e-03f, -2.90845364e-01f, 5.50113507e-02f,
  -2.13977665e-01f, 2.14111716e-01f, -2.28775680e-01f, 9.61158127e-02f, -1.50485232e-01f, -4.39142615e-01f, 3.24973054e-02f, 2.06836551e-01f, 3.30591500e-02f, 1.13237903e-01f,
  -3.96734662e-02f, 1.21577801e-02f, 3.89526337e-01f, 2.20394611e-01f, 1.73092261e-01f, -8.06965977e-02f, -2.70074487e-01f, -9.31230336e-02f, -2.24374980e-01f, -1.30469680e-01f,
  1.27225131e-01f, 1.18202858e-01f, 2.05815241e-01f, 2.14452177e-01f, -2.42301315e-01f, 6.17096901e-01f, -4.89242822e-02f, 1.66766986e-01f, -2.26150647e-01f, -1.14573441e-01f,
  -3.62692833e-01f, -1.94483131e-01f, 9.91785377e-02f, -1.62638560e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 26)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 26;
const float L1_fan_Bp_bar_data[] = {
  5.84964268e-02f, 3.84065390e-01f, 1.10437110e-01f, 1.88279480e-01f, 3.75820935e-01f, 2.20913216e-01f, 3.15711617e-01f, 1.74502969e-01f, -9.33451802e-02f, 1.95484042e-01f,
  1.25630066e-01f, 1.55498356e-01f, 1.38703510e-01f, 3.75005335e-01f, 3.77230912e-01f, 2.05491155e-01f, 2.10688427e-01f, 1.02341361e-01f, 2.25544706e-01f, 1.55216411e-01f,
  1.08777158e-01f, 7.77321607e-02f, 2.01234296e-01f, 3.96837629e-02f, 9.34345052e-02f, 3.89948301e-02f
};

// L2_linear_W (Shape: 12 x 64)
const int L2_linear_W_rows = 12;
const int L2_linear_W_cols = 64;
const float L2_linear_W_data[] = {
  -3.11570197e-01f, 2.10508797e-02f, -5.53785525e-02f, -1.47497430e-01f, 1.64171979e-01f, -5.17259836e-02f, 4.28703390e-02f, 1.78962156e-01f, -1.98676348e-01f, -2.37231761e-01f,
  -3.56405377e-01f, 1.70374855e-01f, 2.47187674e-01f, 1.62743688e-01f, 1.25970811e-01f, -2.52795637e-01f, -3.37586850e-01f, -1.31219774e-01f, -4.51866165e-02f, -3.98830861e-01f,
  -2.59693772e-01f, 6.20187297e-02f, -8.22758600e-02f, -1.10016711e-01f, 5.05031884e-01f, -2.50848919e-01f, 3.74807656e-01f, 2.59763628e-01f, -3.26532453e-01f, -1.02816634e-01f,
  4.18187410e-01f, 3.30435514e-01f, 4.88987304e-02f, 2.26647556e-01f, 4.26314361e-02f, 7.59362876e-02f, -2.03937903e-01f, 5.78008369e-02f, 2.20668554e-01f, -1.69524193e-01f,
  -3.35858732e-01f, 1.60470635e-01f, -1.87616765e-01f, -9.64683145e-02f, 4.35564548e-01f, -4.77709733e-02f, 2.89202392e-01f, -4.41338003e-01f, 2.10020095e-01f, -1.92503080e-01f,
  1.87071279e-01f, -4.09888446e-01f, -1.58356689e-02f, 2.52189159e-01f, -4.65202034e-01f, -1.27732128e-01f, -4.31272745e-01f, -2.36343831e-01f, 4.26331982e-02f, -9.12648737e-02f,
  -6.87473714e-01f, 1.96868032e-02f, -1.64477319e-01f, 3.66896063e-01f, 2.24775702e-01f, 9.43859369e-02f, 2.01223031e-01f, 2.33361274e-01f, 1.15925305e-01f, -1.39134169e-01f,
  -4.53324199e-01f, -1.21349953e-01f, 1.01976238e-01f, 1.94941089e-01f, 1.32831693e-01f, 2.18425602e-01f, -5.37773848e-01f, -2.12617561e-01f, 1.82564527e-01f, -8.65650326e-02f,
  -4.19207215e-01f, 2.82063723e-01f, -1.87191907e-02f, -9.79473740e-02f, -1.35682985e-01f, -4.29024607e-01f, -3.88753377e-02f, -4.27277274e-02f, -3.03207368e-01f, -3.66678953e-01f,
  3.22147071e-01f, -3.07058990e-01f, 8.32107142e-02f, 2.18702644e-01f, 1.20816473e-02f, -3.40234727e-01f, 5.51389992e-01f, 1.10363938e-01f, 3.69366765e-01f, 1.49939179e-01f,
  -1.92617849e-01f, -4.58983302e-01f, 7.69561157e-02f, -5.21165431e-01f, 2.09188268e-01f, -2.60854572e-01f, -8.53042603e-01f, 1.56000122e-01f, -2.44819686e-01f, 7.47957081e-02f,
  4.12500411e-01f, 1.45927723e-02f, -5.77260375e-01f, 2.41338797e-02f, 3.10657352e-01f, -5.55060446e-01f, 3.40314567e-01f, -3.89720760e-02f, -5.33719897e-01f, 1.92209035e-01f,
  2.45353490e-01f, -3.68848860e-01f, -2.48028100e-01f, 2.33195469e-01f, 2.13001613e-02f, 1.23298742e-01f, -1.89584661e-02f, -2.83117592e-01f, 9.07882750e-02f, 8.83905068e-02f,
  1.37193114e-01f, 2.47529164e-01f, -1.24763459e-01f, -1.64770722e-01f, 4.59342934e-02f, -6.82907254e-02f, -1.83353201e-01f, -1.12256058e-01f, -6.19418472e-02f, 2.15545353e-02f,
  6.67267740e-02f, -8.33533928e-02f, 1.49698198e-01f, 3.28160882e-01f, 1.63885713e-01f, 5.98052740e-02f, -2.29046240e-01f, 3.49392563e-01f, 9.34392959e-02f, 4.10662174e-01f,
  1.15902610e-01f, -5.03221571e-01f, -3.42278689e-01f, -2.05979556e-01f, 4.71269786e-01f, -4.70748812e-01f, -2.10475177e-01f, -3.85806262e-02f, -2.08410338e-01f, 3.06339592e-01f,
  4.47260141e-01f, -1.23122334e-01f, -2.35884771e-01f, 2.80226618e-01f, 4.23584491e-01f, 1.65960655e-01f, -1.78979486e-01f, 2.83897012e-01f, 7.32043805e-03f, 2.72263810e-02f,
  -1.00894444e-01f, -2.80595779e-01f, -1.71339110e-01f, 3.20566416e-01f, -2.82290369e-01f, -4.37113971e-01f, -8.72916132e-02f, -3.67761642e-01f, -2.26692576e-02f, 3.74269783e-01f,
  4.53115031e-02f, 7.86069483e-02f, 3.34053367e-01f, 1.54333144e-01f, 3.34803835e-02f, -4.88077402e-01f, -3.02945942e-01f, -7.18688518e-02f, -5.29517531e-01f, 1.92113400e-01f,
  3.36792141e-01f, 2.77566880e-01f, 1.65396661e-01f, 2.23208163e-02f, 2.82805800e-01f, -2.71586120e-01f, -1.10475197e-01f, 2.19556630e-01f, -1.42699108e-01f, 6.61623552e-02f,
  -7.89050609e-02f, 2.62017995e-01f, -1.14169523e-01f, -6.65122345e-02f, -3.92653719e-02f, 2.69891083e-01f, 1.14547871e-01f, -9.45462435e-02f, 3.45355004e-01f, 1.01303734e-01f,
  3.10477287e-01f, -1.79517582e-01f, -6.64374009e-02f, -2.15353385e-01f, 3.39282036e-01f, 2.77996570e-01f, 2.49895781e-01f, 2.65688270e-01f, -1.36995777e-01f, -2.02737618e-02f,
  -4.57774550e-02f, -1.22150771e-01f, -2.54896045e-01f, 2.82837510e-01f, 3.27447355e-01f, 4.10679370e-01f, 8.50092396e-02f, -1.93600878e-01f, -1.33506507e-01f, 7.55332336e-02f,
  -6.96146905e-01f, 4.15611893e-01f, -7.18027294e-01f, 1.20111220e-01f, -3.17339331e-01f, -2.02173263e-01f, -5.10228984e-02f, 3.94760042e-01f, -3.12371671e-01f, 2.34636143e-01f,
  1.80103719e-01f, -7.69111812e-01f, 2.71261275e-01f, -1.69625521e-01f, 3.57601821e-01f, -3.25626642e-01f, 3.47892284e-01f, -6.92831427e-02f, -7.97321022e-01f, 2.72287101e-01f,
  3.19406874e-02f, 3.99716347e-02f, -4.68888015e-01f, -4.40240622e-01f, -1.39715552e-01f, -1.27957344e-01f, 1.56046361e-01f, 1.87200889e-01f, -2.42312059e-01f, 2.64120221e-01f,
  -2.08363652e-01f, 2.64427453e-01f, 2.63122469e-02f, -4.65953462e-02f, 7.81618729e-02f, 1.09750383e-01f, 6.35112002e-02f, -2.43545726e-01f, 1.11208655e-01f, -4.71786968e-02f,
  -1.68179423e-01f, 2.36949790e-02f, 2.46692777e-01f, 9.14832354e-02f, 4.28495891e-02f, 2.49509457e-02f, -1.74525380e-01f, -3.05742800e-01f, 3.87559772e-01f, 4.95341867e-01f,
  2.74383932e-01f, 4.00905162e-01f, -5.71752012e-01f, 2.96964377e-01f, -3.61837447e-02f, -1.66662440e-01f, -2.03971624e-01f, -5.92179820e-02f, -2.90950149e-01f, -2.75603533e-01f,
  -2.84298416e-02f, -8.20728540e-02f, -7.18210116e-02f, 9.39241275e-02f, -1.09767310e-01f, -4.30613756e-01f, 1.14682071e-01f, 2.00130954e-01f, 2.96124429e-01f, -1.00896265e-02f,
  -2.52044737e-01f, -1.34181738e-01f, 4.67494950e-02f, 4.26856995e-01f, 2.97978856e-02f, -5.90402842e-01f, -4.26157117e-01f, 3.21839154e-01f, -1.73191503e-01f, -7.81718642e-02f,
  -5.72634697e-01f, 1.56836942e-01f, -5.96941225e-02f, 1.36382386e-01f, 3.85356188e-01f, -1.76326901e-01f, -2.16914281e-01f, 2.17278451e-02f, 2.95297742e-01f, 5.71053512e-02f,
  -1.78246185e-01f, 6.30487874e-02f, -1.17825866e-01f, 1.51843816e-01f, 9.55881327e-02f, -2.21173942e-01f, 1.26078889e-01f, 1.52037486e-01f, 1.63810194e-01f, 2.58625597e-01f,
  1.67253181e-01f, 6.98751882e-02f, 3.45931292e-01f, 2.59680212e-01f, 1.79436952e-02f, 7.38787884e-03f, 2.14438364e-01f, -2.45763317e-01f, 1.48174345e-01f, 1.46387249e-01f,
  2.45359808e-01f, -5.89215606e-02f, -3.22981626e-01f, 3.81428421e-01f, -2.28743985e-01f, -3.75255257e-01f, 3.64918500e-01f, 3.50444019e-01f, 5.54111961e-04f, -1.75001040e-01f,
  -4.02266353e-01f, 1.51873946e-01f, 1.37039468e-01f, -1.39020979e-01f, 4.43095803e-01f, 1.07842907e-01f, -2.75401860e-01f, 3.32110375e-01f, 2.89783061e-01f, -2.31075391e-01f,
  3.83060396e-01f, 1.23339213e-01f, 2.24148463e-02f, -8.96384791e-02f, 5.02671480e-01f, -7.43384838e-01f, -2.37130165e-01f, -3.32276314e-01f, -3.13192755e-01f, -2.52395511e-01f,
  -5.75460792e-01f, -6.00433111e-01f, -4.56941962e-01f, 7.42219985e-02f, -1.17832147e-01f, -3.16926509e-01f, -1.20976873e-01f, 2.23090693e-01f, -1.84410304e-01f, 2.42962226e-01f,
  2.78450072e-01f, -3.55990157e-02f, -3.70596685e-02f, 3.60453203e-02f, -7.83764049e-02f, 2.06009641e-01f, -5.38109958e-01f, -1.20267630e-01f, 9.43327546e-02f, 1.22436963e-01f,
  -8.60966183e-03f, 1.54436246e-01f, -7.31236115e-02f, 2.37748906e-01f, -2.53884137e-01f, -2.10897297e-01f, 3.67685348e-01f, 2.41122156e-01f, 1.29800856e-01f, -5.25338426e-02f,
  -1.05789073e-01f, 1.10574946e-01f, 4.63936657e-01f, 3.19713235e-01f, 1.91647306e-01f, 1.81369528e-01f, -1.30657405e-01f, -4.66824979e-01f, 1.35949319e-02f, 2.74646640e-01f,
  -5.50171360e-02f, -3.12535793e-01f, -5.90650477e-02f, 4.76492673e-01f, -2.84878552e-01f, -2.13622451e-01f, -2.41319388e-01f, -5.72209209e-02f, -4.01536852e-01f, -3.23769987e-01f,
  1.35373056e-01f, 1.33955836e-01f, -3.95329416e-01f, 8.89533833e-02f, -1.04004860e-01f, -6.63803518e-01f, -3.33349332e-02f, 1.25067338e-01f, -2.87258029e-01f, -5.79269171e-01f,
  -1.65591866e-01f, 1.51513023e-02f, -2.28603810e-01f, 2.80330539e-01f, -2.89929032e-01f, 4.28377688e-01f, -5.75995982e-01f, 3.74346107e-01f, -1.41749546e-01f, 1.98203139e-02f,
  4.29592490e-01f, -4.51377332e-01f, -1.43753424e-01f, -3.94925654e-01f, -2.69719750e-01f, -1.73377290e-01f, -2.92389840e-01f, -3.48260850e-01f, 1.40444666e-01f, -3.22470725e-01f,
  -1.58196300e-01f, -3.53036493e-01f, -1.71652794e-01f, -3.00225496e-01f, 1.60401449e-01f, -2.11090520e-01f, -1.35459229e-01f, -1.23831294e-01f, 2.06995174e-01f, -1.17014505e-01f,
  -1.73575833e-01f, -2.80848563e-01f, -1.40903592e-01f, -6.82603866e-02f, -4.17373806e-01f, -1.91930123e-02f, -3.33777755e-01f, 1.74783155e-01f, 1.75649598e-01f, 1.11086749e-01f,
  1.19228870e-01f, 1.64224714e-01f, -2.99605802e-02f, -3.83455217e-01f, -9.02415905e-03f, -9.58082378e-02f, -3.23628753e-01f, -1.96720257e-01f, 3.78790200e-01f, -1.93938278e-02f,
  -2.05552489e-01f, 3.50865960e-01f, 1.30772531e-01f, -1.07987083e-01f, 5.46519421e-02f, 2.36098051e-01f, 4.31342833e-02f, 3.08600366e-01f, -4.22827423e-01f, 3.98689173e-02f,
  -5.12826979e-01f, 5.67513257e-02f, -4.80355591e-01f, 1.05563402e-01f, -1.08563386e-01f, 3.76106426e-02f, 2.94940025e-01f, 2.42798626e-01f, 1.10166771e-02f, 1.51034579e-01f,
  -3.19588155e-01f, -3.38915884e-01f, 2.40938097e-01f, 8.94441381e-02f, -2.05775052e-01f, 3.74293804e-01f, -4.13737923e-01f, -3.00483286e-01f, 2.43497943e-03f, -1.14377193e-01f,
  -5.33945799e-01f, -3.40129882e-01f, -2.58629452e-02f, -5.39311409e-01f, 1.26944378e-01f, 1.48476601e-01f, -1.16424099e-01f, 2.26215467e-01f, -2.71292794e-02f, -2.78413612e-02f,
  1.09074488e-01f, -2.85804063e-01f, -3.72894943e-01f, -1.40912876e-01f, -1.11579284e-01f, -1.82118908e-01f, -5.23145258e-01f, 9.17871147e-02f, 6.39857799e-02f, 9.45838019e-02f,
  7.08057508e-02f, 2.16253936e-01f, 2.38785937e-01f, -1.43724442e-01f, -1.97225854e-01f, -1.55390203e-01f, -3.44551057e-02f, 4.89411026e-01f, 4.09930438e-01f, -2.84676254e-01f,
  8.81071091e-02f, 3.00207734e-01f, 4.04834569e-01f, -1.76750064e-01f, -1.50477141e-01f, -3.44213724e-01f, -6.08334303e-01f, -3.69114578e-02f, 3.40196878e-01f, -3.52241695e-01f,
  2.96908021e-01f, -1.82418510e-01f, 7.89304897e-02f, -3.30766410e-01f, 8.60247254e-01f, 1.27329037e-01f, -6.95622981e-01f, -5.61680868e-02f, -1.82951093e-01f, -1.28644347e-01f,
  -1.51239648e-01f, -2.27112964e-01f, 1.90321520e-01f, -1.77145466e-01f, -4.61813480e-01f, -7.67388999e-01f, -1.01429313e-01f, 5.70507720e-02f, -4.00893867e-01f, -1.79185420e-01f,
  2.58322936e-02f, 2.78155267e-01f, 2.90179074e-01f, -1.35154843e-01f, -3.16431820e-01f, -2.79027373e-01f, 3.20156723e-01f, -2.92248815e-01f, 8.79205689e-02f, -3.75191718e-01f,
  2.45240375e-01f, 2.36826822e-01f, 1.15937404e-01f, -1.27703100e-01f, 2.43372545e-01f, -2.61215389e-01f, 2.78806210e-01f, -2.05205619e-01f, -3.07216823e-01f, -8.21710527e-02f,
  1.60795242e-01f, 1.00394897e-01f, 4.44229633e-01f, 1.81484282e-01f, -3.90285462e-01f, -3.19618464e-01f, 2.84824342e-01f, 4.06489640e-01f, -2.49031886e-01f, -5.99168789e-06f,
  1.71563074e-01f, 1.22845039e-01f, -4.01565969e-01f, -1.23351000e-01f, -2.02160761e-01f, -6.57217383e-01f, -2.20926409e-03f, 2.34154135e-01f, -2.16463313e-01f, 3.10074091e-01f,
  8.91162157e-02f, 1.96550235e-01f, 9.99550894e-02f, 1.30441308e-01f, 3.38511497e-01f, -4.88509268e-01f, 2.12457880e-01f, -1.35313675e-01f, 4.45666194e-01f, -6.22310877e-01f,
  -6.66477621e-01f, -4.63559240e-01f, -2.37411559e-01f, 1.09447077e-01f, 2.86575198e-01f, 2.33291939e-01f, -1.25958920e-01f, 1.14563040e-01f, -6.68200433e-01f, -7.78060928e-02f,
  -1.44527435e-01f, -1.64704606e-01f, 2.11552426e-01f, -5.28133392e-01f, -2.70623982e-01f, -5.90035558e-01f, 5.33368178e-02f, 5.65562360e-02f, 1.62873909e-01f, 3.43432963e-01f,
  8.05042014e-02f, -6.42907713e-03f, -2.12779537e-01f, -1.98695898e-01f, -1.46669578e-02f, 5.48839010e-03f, 1.01984002e-01f, -2.17569411e-01f, -1.19092152e-01f, -2.83799712e-02f,
  1.46555334e-01f, 1.22599684e-01f, 1.12823121e-01f, 1.01543352e-01f, -1.55546919e-01f, 3.69648300e-02f, -2.03159899e-01f, -3.21065038e-01f, 2.23143939e-02f, 2.73160562e-02f,
  1.69715658e-01f, -1.37251645e-01f, 1.31388396e-01f, -4.69160050e-01f, 4.21488494e-01f, 5.11127971e-02f, -3.33996058e-01f, 3.43456209e-01f, 1.86873719e-01f, 3.45632881e-01f,
  1.91940904e-01f, 8.01374111e-03f, -1.77473471e-01f, -1.35129213e-01f, -4.89209116e-01f, 2.88730443e-01f, -3.49372804e-01f, 3.43494356e-01f, -3.33110034e-01f, -5.28534465e-02f,
  -3.40533294e-02f, 1.87769905e-02f, -3.06569099e-01f, -4.75634098e-01f, -6.10939384e-01f, -1.66886210e-01f, -3.85312408e-01f, -5.23297548e-01f, -5.55510104e-01f, -2.65041530e-01f,
  3.94517779e-01f, -2.04602450e-01f, 5.12363791e-01f, -6.10885561e-01f, -2.30406836e-01f, -4.97538835e-01f, 2.55246967e-01f, 3.97511810e-01f, 4.65000331e-01f, 2.16166943e-01f,
  2.47495323e-01f, -3.71414959e-01f, 6.45542964e-02f, -4.91636395e-01f, -3.07408780e-01f, 1.56858489e-01f, 4.24142599e-01f, 3.10399681e-01f, 1.65276736e-01f, 1.16566136e-01f,
  -2.05518201e-01f, 1.34128422e-01f, 4.09875857e-03f, -2.04835176e-01f, 1.52640268e-02f, 1.68265611e-01f, -1.94874465e-01f, 1.69946671e-01f, 1.32811397e-01f, 7.92167336e-02f,
  -2.40372121e-01f, -7.18601122e-02f, -1.87465567e-02f, 1.27535388e-01f, -4.58831847e-01f, 1.63052425e-01f, -2.87785053e-01f, 3.20597559e-01f, -3.48392934e-01f, 3.54420066e-01f,
  -3.39089721e-01f, 4.84425217e-01f, 3.88816953e-01f, 3.02275926e-01f, -4.24559385e-01f, -3.58715862e-01f, -2.54881829e-01f, 9.57575887e-02f, 5.47945857e-01f, -1.08383961e-01f,
  3.08025807e-01f, -4.81974870e-01f, -4.30635422e-01f, 1.34647474e-01f, -4.48764980e-01f, -4.56757933e-01f, -9.65914428e-02f, 1.84478641e-01f, -1.36500999e-01f, -1.82329118e-01f,
  -1.50449142e-01f, 3.78515452e-01f, -2.02579960e-01f, 1.58458784e-01f, -6.82727396e-02f, -1.58524275e-01f, 3.66786957e-01f, -2.97039568e-01f, 5.32937288e-01f, -4.48798895e-01f,
  -1.13710843e-01f, -3.33474696e-01f, -3.51478517e-01f, -1.46767661e-01f, 3.74979854e-01f, -3.49154502e-01f, -1.78550467e-01f, -8.68280977e-02f
};

// L2_linear_B (Shape: 1 x 12)
const int L2_linear_B_rows = 1;
const int L2_linear_B_cols = 12;
const float L2_linear_B_data[] = {
  -3.26864347e-02f, -1.38708249e-01f, 1.13412902e-01f, 9.68883187e-03f, -1.07678771e-01f, -1.29211787e-02f, 7.47393519e-02f, -2.69182716e-02f, 9.74373370e-02f, 6.03311546e-02f,
  3.19576599e-02f, 1.65818304e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 19, 26
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        64, 19, 26
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_linear
    linear_forward_pgm(
        buffer1, x_out,
        L2_linear_W_data, L2_linear_B_data,
        64, 12
    );
    }
    