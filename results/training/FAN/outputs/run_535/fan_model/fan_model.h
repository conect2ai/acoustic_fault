/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 128 (x1)
    * Saída: 12
    * Buffer Máx: 128
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 128;
    const int FAN_MAX_BUFFER_SIZE = 128;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    return (x > 0.0f) ? x : 0.0f;
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 38 x 120)
const int L0_fan_Wp_rows = 38;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -1.13491034e-02f, -1.80784464e-01f, -9.81730670e-02f, -1.13093354e-01f, 4.09549326e-01f, -6.87747970e-02f, -5.21658123e-01f, 2.61509091e-01f, -1.69414014e-01f, -1.65893123e-01f,
  2.34201267e-01f, -4.19900745e-01f, -1.48287475e-01f, 5.48144802e-03f, 5.57522625e-02f, -5.10915220e-02f, -2.52768993e-02f, -1.85975358e-01f, -1.08855784e-01f, -3.98192145e-02f,
  4.28376384e-02f, 3.50111216e-01f, 8.12329128e-02f, 2.84959763e-01f, 1.67998880e-01f, 6.05733693e-03f, 1.51288092e-01f, -1.36344120e-01f, 1.90735459e-01f, 5.95982745e-02f,
  1.65004686e-01f, 3.93979624e-02f, -1.05355635e-01f, -3.26560065e-02f, 7.93753490e-02f, -5.72787747e-02f, -1.19857699e-01f, -1.39435813e-01f, -2.98878942e-02f, -1.46256294e-03f,
  -1.06986374e-01f, 1.47370622e-01f, -1.93812866e-02f, -1.17113590e-01f, 6.99505880e-02f, 5.90720810e-02f, 1.16171226e-01f, 6.41389415e-02f, -5.93342707e-02f, 1.30193993e-01f,
  -4.48476300e-02f, 2.86328755e-02f, -5.87386265e-02f, -7.04759583e-02f, 1.57564599e-02f, 1.95514224e-02f, -8.20289180e-02f, -6.80963099e-02f, 4.50915992e-02f, 3.43012065e-02f,
  -4.84344885e-02f, -1.28892735e-01f, -6.19594082e-02f, 8.07698295e-02f, -7.69504309e-02f, 1.26389891e-01f, -9.88042504e-02f, 3.04986201e-02f, -4.12613619e-03f, 8.09595957e-02f,
  1.33222610e-01f, -1.53795257e-02f, 1.56550799e-02f, -3.16411629e-02f, -5.21448329e-02f, -8.08578208e-02f, -2.15025675e-02f, 3.38340029e-02f, 6.33781925e-02f, 7.20881298e-02f,
  -3.10690328e-02f, 4.32565846e-02f, -3.94447297e-02f, 1.41636534e-02f, -7.71671087e-02f, -6.16672225e-02f, 6.70565069e-02f, 7.86010027e-02f, -5.61740948e-03f, 7.80176744e-02f,
  1.22095831e-01f, -1.32262498e-01f, -2.91710626e-02f, 8.33352655e-02f, 2.06021518e-02f, 9.91418287e-02f, -5.73845953e-02f, 1.18845195e-01f, -5.62306345e-02f, -9.97088477e-02f,
  7.44308531e-02f, 9.52236727e-03f, 3.15311528e-03f, 6.24821261e-02f, -2.52565984e-02f, -5.56007610e-04f, -1.73474848e-01f, -1.12547003e-01f, 3.10243685e-02f, 5.78164775e-03f,
  1.09070271e-01f, 5.19129373e-02f, -2.43564714e-02f, 1.25222921e-01f, 4.60995100e-02f, 6.70123845e-02f, -7.24078119e-02f, -6.28513321e-02f, 5.60829192e-02f, -3.27446684e-02f,
  7.69972242e-03f, 2.29862675e-01f, 1.84373289e-01f, 1.51024044e-01f, 9.15115923e-02f, -2.98115909e-02f, 3.10955420e-02f, 6.16679303e-02f, 6.31966665e-02f, 6.17123544e-02f,
  -2.57334024e-01f, 1.51269093e-01f, -2.19831601e-01f, -1.49334058e-01f, -3.95691633e-01f, -2.78659940e-01f, -4.60339375e-02f, -6.76414594e-02f, -8.48036110e-02f, 2.19720095e-01f,
  -9.25066322e-02f, -3.15112285e-02f, -8.77847895e-02f, 2.37121001e-01f, 2.29489356e-01f, 2.53470004e-01f, -3.90807167e-02f, 1.21151939e-01f, 1.32315770e-01f, -9.88186374e-02f,
  -9.77384225e-02f, -7.85810128e-02f, 1.13783121e-01f, -1.03873610e-02f, 4.67057340e-02f, 1.33394584e-01f, 3.58672962e-02f, -8.84196684e-02f, -4.73961830e-02f, 3.54866907e-02f,
  -1.91625822e-02f, -5.21022081e-02f, 6.64630756e-02f, -1.38690451e-03f, 1.33456960e-01f, 7.13703781e-03f, -3.47882062e-02f, -8.03347751e-02f, 6.62899688e-02f, -1.10495612e-01f,
  6.58278391e-02f, -7.97884911e-02f, 4.81216498e-02f, -5.26348837e-02f, -3.43322828e-02f, 5.34721464e-02f, 2.14097481e-02f, 2.96840537e-02f, -2.85876021e-02f, 5.60421636e-03f,
  6.25777692e-02f, 6.09376058e-02f, -4.74600941e-02f, -5.26145473e-03f, -7.53722787e-02f, 6.97852895e-02f, 1.01783751e-02f, -6.91829920e-02f, 3.89782488e-02f, 2.53373720e-02f,
  5.65037914e-02f, -1.09015312e-02f, -1.98058765e-02f, 3.55104022e-02f, -2.13327631e-02f, 7.60962218e-02f, -4.53688670e-03f, -8.06400273e-03f, 1.25384554e-01f, -1.06927529e-01f,
  -5.59458360e-02f, 1.09179756e-02f, 5.63109741e-02f, -6.38183905e-03f, -1.03819415e-01f, -4.50177602e-02f, 4.69550341e-02f, -1.03555946e-02f, 4.09558155e-02f, -8.01746268e-03f,
  7.27038383e-02f, 2.69106746e-01f, 1.67642813e-02f, 4.38957326e-02f, -3.97283509e-02f, -3.37888449e-02f, -6.08461313e-02f, 3.97823714e-02f, 3.86534594e-02f, 1.04204088e-03f,
  9.66061875e-02f, 1.10522546e-01f, 1.79160964e-02f, -1.14678452e-02f, -6.57057390e-02f, 2.70681903e-02f, 3.59714627e-02f, 2.41652895e-02f, 5.16690724e-02f, 5.48407473e-02f,
  4.97169718e-02f, 3.88831608e-02f, -5.26687875e-02f, 8.95372182e-02f, -6.54923869e-03f, -2.37847567e-02f, 2.35236343e-02f, 2.47777756e-02f, 8.32996424e-03f, -4.18213420e-02f,
  -1.08529761e-01f, 1.60072669e-01f, -3.31030823e-02f, -6.97595859e-03f, 1.64660379e-01f, -9.55891144e-03f, -1.81089699e-01f, 4.02044475e-01f, 3.52463394e-01f, -1.78437941e-02f,
  1.71459436e-01f, -3.15353692e-01f, 1.33385614e-01f, -1.19143926e-01f, -3.04591149e-01f, 8.20729602e-03f, -2.81768907e-02f, -1.67831630e-01f, 1.20751627e-01f, 5.03597669e-02f,
  1.01790324e-01f, -1.49409816e-01f, -1.09343901e-01f, 1.04527332e-01f, -2.63962224e-02f, 1.15298331e-01f, -1.89906269e-01f, -7.58628175e-03f, -2.79966295e-01f, -2.35060662e-01f,
  -7.73127526e-02f, 8.28977153e-02f, 4.65259589e-02f, -1.49676368e-01f, 2.26690978e-01f, -1.78511441e-03f, -1.50046349e-01f, -9.38561857e-02f, -9.14174765e-02f, -2.73476709e-02f,
  -1.22855261e-01f, -7.31925294e-02f, -2.73651406e-02f, -8.81213024e-02f, 4.83062230e-02f, 1.49211381e-02f, 1.20523702e-02f, 1.48938457e-02f, -1.06104566e-02f, 3.94179374e-02f,
  3.87998633e-02f, 1.08223744e-01f, 3.34424563e-02f, 6.90893037e-03f, -4.25647795e-02f, 1.46843567e-02f, -6.22395203e-02f, -3.66927274e-02f, -2.11495683e-02f, -8.97344784e-04f,
  3.90769206e-02f, 3.45515832e-02f, -3.33285481e-02f, -8.77327695e-02f, -3.50768752e-02f, 7.12094605e-02f, -5.30765355e-02f, -4.52189296e-02f, 2.23374404e-02f, -1.16859816e-01f,
  -3.58238593e-02f, -6.38163164e-02f, 9.94717777e-02f, 4.87432964e-02f, 3.30029689e-02f, -1.80224832e-02f, -6.40916303e-02f, -1.47124017e-02f, 7.99032301e-02f, 8.56763870e-02f,
  6.48952723e-02f, 3.81389037e-02f, -1.10444659e-02f, 3.15560475e-02f, 4.62812744e-03f, -5.61500974e-02f, 5.26793189e-02f, 8.24504718e-03f, 1.10118330e-01f, 6.58597331e-03f,
  1.36654764e-01f, 2.26989388e-02f, 5.30755185e-02f, -1.05768621e-01f, 2.32974067e-02f, 2.31301859e-02f, 1.04334084e-02f, 3.60858887e-02f, -8.74980260e-03f, 5.30206673e-02f,
  1.00397505e-04f, -5.26365414e-02f, 4.20600083e-03f, -5.68639971e-02f, -8.63545164e-02f, -1.30804116e-02f, -6.86256215e-02f, 2.99244281e-02f, -1.14406295e-01f, 6.37997091e-02f,
  -6.26774281e-02f, 1.98909920e-02f, -1.13678789e-02f, 1.30182713e-01f, -8.15759152e-02f, -8.58547632e-03f, -1.44442320e-02f, -4.63666953e-02f, -4.78687771e-02f, -7.58493366e-03f,
  2.11311817e-01f, 3.17509353e-01f, -1.83590576e-01f, 1.48399696e-01f, -1.94762982e-02f, -2.11787596e-01f, -2.43393794e-01f, 1.98859602e-01f, -1.61183789e-01f, 6.19153902e-02f,
  -1.61411285e-01f, -3.21863033e-02f, -2.23161548e-01f, 3.72488685e-02f, -2.20258147e-01f, -1.81955531e-01f, 1.77175447e-01f, 1.18907027e-01f, 1.79129362e-01f, 3.20229203e-01f,
  6.67109564e-02f, 2.19653562e-01f, 6.05860390e-02f, 2.15742737e-01f, 1.91890374e-01f, 2.28029519e-01f, 2.08980218e-01f, -3.53326425e-02f, 1.49484858e-01f, -1.28847763e-01f,
  -3.18555944e-02f, 1.49663582e-01f, -4.01571691e-02f, -6.06359988e-02f, 3.96365672e-02f, -6.35963231e-02f, 3.04011125e-02f, -6.42154142e-02f, 1.16595421e-02f, -4.36679348e-02f,
  3.09777446e-02f, 3.40323001e-02f, 6.36603832e-02f, -6.90160096e-02f, -2.04906594e-02f, -6.24727197e-02f, -1.34949451e-02f, 8.98741931e-02f, -7.46992901e-02f, -1.81698631e-02f,
  -8.27170461e-02f, 8.23289827e-02f, 3.18360925e-02f, 2.48942506e-02f, -1.15319900e-01f, -6.79104924e-02f, -1.24764321e-02f, -3.34392861e-02f, 5.16246296e-02f, -1.61195129e-01f,
  8.41425210e-02f, 6.49682358e-02f, -4.33011446e-03f, -1.20331673e-02f, -8.79598930e-02f, -1.12473644e-01f, 2.02720258e-02f, -1.00117058e-01f, -4.35067900e-02f, -5.48222698e-02f,
  -2.77929232e-02f, 6.99463710e-02f, -9.82136838e-03f, -6.64938707e-03f, 3.42086665e-02f, 5.47467247e-02f, 7.24190241e-03f, 6.22826256e-02f, -8.40579532e-03f, -7.47371316e-02f,
  5.37263881e-03f, -5.94475307e-03f, -1.93182100e-02f, 1.78146243e-01f, 3.86736877e-02f, -3.09600309e-02f, 5.15262708e-02f, -4.40568179e-02f, 4.74690571e-02f, 7.51851499e-03f,
  3.04222316e-01f, 3.69966328e-01f, -2.68278662e-02f, -6.71682954e-02f, -2.84156036e-02f, 5.29496977e-03f, 1.90504249e-02f, -9.11879912e-02f, -9.29931644e-03f, -6.43025413e-02f,
  3.66731100e-02f, 5.67323901e-02f, 1.61446169e-01f, -1.47984084e-02f, -1.12523371e-02f, -3.23226228e-02f, 4.98774042e-03f, -1.02043226e-01f, -7.72234239e-03f, 1.15688890e-01f,
  -8.59235320e-03f, 9.56714824e-02f, -1.43125365e-02f, -3.51202339e-02f, 1.04818814e-01f, 2.84395944e-02f, 1.50796682e-01f, 1.49264457e-02f, 5.21699041e-02f, -9.08768456e-03f,
  -1.67210922e-01f, -1.19935237e-01f, -2.92047113e-01f, 2.70895630e-01f, 6.37858883e-02f, 1.75342485e-01f, 3.10268313e-01f, -9.64085222e-04f, 3.33112627e-01f, 3.30163658e-01f,
  2.81149864e-01f, -4.65296246e-02f, -1.21118680e-01f, 2.33194083e-01f, 2.01938093e-01f, 3.15988213e-02f, 2.62269944e-01f, 1.40591636e-01f, -4.60215099e-02f, -1.15423381e-01f,
  2.67342478e-02f, 3.46089989e-01f, -1.91927657e-01f, 1.28686009e-02f, -1.07467137e-01f, -1.23327307e-01f, 1.84365660e-02f, -1.56414643e-01f, 5.94284758e-02f, -3.71491387e-02f,
  -1.72451675e-01f, -6.61911592e-02f, -4.61837687e-02f, -6.17091469e-02f, 4.78875227e-02f, 3.45083252e-02f, -1.63250789e-01f, -4.69633639e-02f, -6.66190237e-02f, -9.97870974e-03f,
  -8.80545527e-02f, 1.48276342e-02f, 1.31576940e-01f, 8.81201923e-02f, -2.05537360e-02f, 2.42352262e-02f, -3.71289551e-02f, 3.73046321e-04f, -5.36191985e-02f, -8.08730125e-02f,
  6.87635168e-02f, -4.76279519e-02f, -2.66936272e-02f, 7.89691508e-03f, -5.68691529e-02f, 7.90208280e-02f, -4.99307038e-03f, -6.82848915e-02f, -3.19127478e-02f, 1.43410802e-01f,
  7.98957869e-02f, 2.34917123e-02f, -8.50694347e-03f, 3.59272547e-02f, 4.85084876e-02f, -5.18230386e-02f, 2.83156876e-02f, -4.43936363e-02f, -2.10419577e-02f, -6.47863839e-03f,
  7.50532225e-02f, 2.45553367e-02f, 2.50699762e-02f, 2.94985473e-02f, 4.40999232e-02f, 8.61218292e-03f, -8.05100724e-02f, -9.93992295e-03f, 3.48842815e-02f, -7.85325915e-02f,
  3.88685986e-02f, 4.50225323e-02f, 4.33951579e-02f, -1.00214571e-01f, 4.97778179e-03f, 9.76964682e-02f, 6.77520782e-02f, -2.31537558e-02f, -1.51968319e-02f, -2.39439793e-02f,
  -6.69730827e-02f, 1.98447093e-01f, 1.01040758e-01f, -4.64779437e-02f, -1.93138868e-02f, 6.33534640e-02f, 2.10695751e-02f, 1.53743476e-02f, -2.41007153e-02f, 5.98984361e-02f,
  9.73690581e-03f, -5.57031482e-02f, -2.94551570e-02f, -1.85339823e-02f, 3.41916755e-02f, 8.59113634e-02f, -1.12244524e-02f, 5.93421161e-02f, 3.15605253e-02f, -3.50769758e-02f,
  -4.52054366e-02f, -5.37123624e-03f, 7.33669102e-03f, 4.38667350e-02f, -7.81993866e-02f, 7.93778300e-02f, 1.70324221e-02f, 1.17633650e-02f, 3.59073281e-02f, 3.24500389e-02f,
  2.53075302e-01f, -4.64282721e-01f, -4.03629750e-01f, -6.85648397e-02f, 3.47818375e-01f, -2.31195033e-01f, -2.01794386e-01f, -3.87832709e-02f, 1.83958426e-01f, -1.76067278e-01f,
  3.74865020e-03f, -2.54742354e-01f, -1.64597526e-01f, -1.73319206e-01f, -8.32398534e-02f, -1.45979628e-01f, -4.89741601e-02f, -1.63673118e-01f, 9.50079188e-02f, 7.71841640e-03f,
  5.32174036e-02f, 8.62471573e-03f, -2.83897281e-01f, 1.36577904e-01f, -2.72865891e-02f, -3.42722088e-02f, 5.19643687e-02f, -5.62928170e-02f, -1.10492393e-01f, -1.03659168e-01f,
  2.65102554e-02f, 1.31616995e-01f, -4.29321043e-02f, -2.61135008e-02f, -1.78888217e-02f, 7.08391443e-02f, -6.29548654e-02f, -5.76075688e-02f, -4.00001742e-02f, -4.99690957e-02f,
  2.40735170e-02f, 5.58627695e-02f, 3.58488075e-02f, 8.73729140e-02f, 1.50319129e-01f, 3.68425883e-02f, -3.74684855e-02f, 4.18032259e-02f, -6.40664920e-02f, -4.09151278e-02f,
  4.51969914e-02f, -4.86785779e-03f, 7.57639334e-02f, -1.29739374e-01f, 4.36391532e-02f, 7.82340541e-02f, -1.29335389e-01f, 1.96425989e-02f, -1.02292068e-01f, 6.86638951e-02f,
  3.73377688e-02f, -1.66027099e-02f, -9.02229548e-02f, 1.81529261e-02f, -6.09622709e-02f, 2.00024992e-02f, 4.07148078e-02f, -5.91744035e-02f, -3.21148671e-02f, -1.13024311e-02f,
  1.03093386e-01f, -8.98630638e-03f, 5.22510521e-02f, -3.93163078e-02f, 2.53204182e-02f, -2.37301588e-02f, -2.97809895e-02f, 1.76734421e-02f, 3.52381170e-02f, 1.07200481e-02f,
  1.08113633e-02f, 3.03751649e-03f, -7.03690350e-02f, 7.76215270e-02f, -5.20059206e-02f, 6.41629426e-03f, -7.15339407e-02f, 4.91130725e-02f, -6.42389432e-02f, -1.02274688e-02f,
  -1.57814994e-01f, -3.15811366e-01f, -8.89455061e-03f, -4.00484912e-02f, -9.79812145e-02f, 3.20980931e-03f, 6.66692108e-02f, 2.53015459e-02f, -3.54387164e-02f, 2.04223096e-02f,
  7.96364471e-02f, 4.65636235e-03f, -4.41536568e-02f, 2.87286751e-02f, -2.44264491e-02f, -4.26060110e-02f, -1.06123798e-01f, 3.11139394e-02f, -1.61387045e-02f, -7.02484325e-02f,
  -5.01065962e-02f, 3.87350768e-02f, -1.09384879e-02f, 1.17145762e-01f, 2.94910688e-02f, -1.76040195e-02f, 3.50562446e-02f, 6.91059753e-02f, 3.31675746e-02f, -2.25089025e-03f,
  -6.62483692e-01f, 4.52820659e-01f, -3.97758745e-02f, -3.25349689e-01f, 1.03540301e-01f, -1.08811997e-01f, -3.09603244e-01f, 2.31817439e-01f, -1.68066829e-01f, 3.54909807e-01f,
  1.46550655e-01f, -3.63925728e-03f, 1.04802117e-01f, 2.97887743e-01f, -2.68127322e-01f, 1.37956575e-01f, -7.64209107e-02f, -7.14553371e-02f, -6.46196911e-03f, 4.56595905e-02f,
  -9.23874229e-02f, 2.66137630e-01f, 1.09626718e-01f, 2.59667188e-01f, -4.51936722e-02f, -5.94657958e-02f, 1.63252607e-01f, -1.36167351e-02f, 1.68874875e-01f, 3.34257931e-02f,
  1.32926732e-01f, 5.97966788e-03f, -4.40813659e-04f, 4.22180966e-02f, -2.49138623e-02f, -5.74786328e-02f, -1.14522874e-01f, -6.16766065e-02f, -1.05694003e-01f, 3.22611071e-02f,
  -6.91711903e-02f, 1.15964212e-03f, -2.91645955e-02f, -2.01841397e-03f, -1.68610159e-02f, 1.66036524e-02f, -6.88528642e-03f, 3.67928110e-02f, 4.00738046e-02f, -3.98925245e-02f,
  -3.13208848e-02f, 1.96828675e-02f, -9.02659222e-02f, -1.75347496e-02f, -9.10074413e-02f, -5.04897907e-02f, -2.02246066e-02f, -1.72894560e-02f, -4.50997427e-02f, -2.19209725e-03f,
  -1.29354456e-02f, -7.38978609e-02f, -1.06304465e-02f, 5.70289381e-02f, -2.44808942e-02f, 2.80161686e-02f, 3.27510498e-02f, 2.31889281e-02f, -1.17077842e-01f, 6.99863359e-02f,
  -1.54282367e-02f, 1.51754683e-02f, 8.23959857e-02f, -2.58036144e-02f, -3.87868658e-02f, 1.80281047e-02f, -1.07355572e-01f, 2.81166378e-02f, -7.38822371e-02f, -2.25039106e-02f,
  3.35696936e-02f, 3.12341992e-02f, 1.42780803e-02f, 3.24827433e-02f, 7.08165541e-02f, 1.64564103e-02f, 6.21046498e-02f, 4.87910118e-03f, -4.48291823e-02f, -1.19551219e-01f,
  4.86869477e-02f, 2.39640161e-01f, 4.11405228e-02f, 2.73401523e-03f, 2.72804257e-02f, 5.86512610e-02f, 2.26271525e-03f, 5.16047217e-02f, -6.17335774e-02f, -2.10311031e-03f,
  -3.85584123e-02f, 1.89784169e-02f, 4.40036021e-02f, -6.39272258e-02f, -3.95671986e-02f, 7.34495670e-02f, -1.93757266e-02f, -5.39691187e-03f, -1.07393898e-01f, 9.96649265e-02f,
  1.48009043e-02f, -3.86394337e-02f, -3.38701867e-02f, -1.83151308e-02f, 9.12485644e-03f, -2.48589180e-02f, 1.98937003e-02f, 1.24228029e-02f, -2.58731171e-02f, 4.03490476e-02f,
  -8.18885565e-02f, -5.98814376e-02f, 1.24939770e-01f, 1.47440657e-01f, 1.10574991e-01f, -2.98999041e-01f, -2.30873331e-01f, 9.12151858e-02f, 2.53459215e-01f, -2.11732730e-01f,
  -4.84343395e-02f, -1.28744498e-01f, -6.70596585e-02f, -1.96793273e-01f, -2.01708853e-01f, -7.17487633e-02f, -2.69216985e-01f, -1.53028041e-01f, 2.15711102e-01f, -1.00644827e-01f,
  9.92154106e-02f, -2.73706138e-01f, 5.71109820e-03f, 4.02251538e-03f, -1.04898907e-01f, 1.73576891e-01f, -9.17769745e-02f, 1.44024864e-01f, -2.53774881e-01f, -7.45507106e-02f,
  2.89258845e-02f, -2.89435573e-02f, -2.99702920e-02f, 1.63436707e-04f, -7.80444145e-02f, -5.55470623e-02f, -9.23675112e-03f, 7.34182959e-03f, 9.48661044e-02f, 4.97242063e-02f,
  -6.45393133e-02f, 1.30157387e-02f, -1.66349299e-02f, 2.44126692e-02f, 5.64117320e-02f, 1.06251940e-01f, 8.80488083e-02f, 8.77085254e-02f, 3.40729915e-02f, 6.03266470e-02f,
  2.71514636e-02f, 1.52344350e-02f, 2.41312832e-02f, 3.42964232e-02f, 1.55025404e-02f, 2.78273094e-02f, -1.86816491e-02f, -6.85054958e-02f, -5.78058288e-02f, 2.82398146e-02f,
  -1.06937110e-01f, 2.13303156e-02f, 4.48205415e-03f, 5.81800304e-02f, -4.00764979e-02f, 6.05780184e-02f, 1.54587533e-02f, -1.82506721e-02f, 1.05377138e-01f, -1.16055915e-02f,
  -6.31398987e-03f, 5.66410683e-02f, 6.69827312e-02f, 1.41477212e-02f, -1.58755835e-02f, -3.80425565e-02f, -6.11096434e-02f, 4.21789335e-03f, 2.34613847e-02f, 2.17823293e-02f,
  4.56063412e-02f, 3.26002017e-02f, 1.98164817e-05f, 1.14509966e-02f, -7.36620603e-03f, 4.24508639e-02f, 1.47085190e-02f, 6.77737826e-03f, 1.35379434e-01f, 7.69369071e-04f,
  -1.32115990e-01f, -3.46491873e-01f, 3.83213419e-03f, 2.92981323e-02f, 5.11095859e-02f, -3.21974233e-02f, 5.25103472e-02f, 1.07076019e-02f, -9.72715840e-02f, -6.77120835e-02f,
  6.74317479e-02f, 2.52764896e-02f, -4.38693389e-02f, -1.45708248e-02f, 2.00439319e-02f, 2.08363663e-02f, -6.92512691e-02f, -6.99387640e-02f, -1.00928105e-01f, -6.96766749e-02f,
  1.59888398e-02f, 1.55850742e-02f, -3.03029772e-02f, -8.54906533e-03f, 1.39076076e-02f, -7.05345869e-02f, -3.41516063e-02f, 3.42299230e-02f, -1.61780398e-02f, -1.91407185e-02f,
  -5.04746020e-01f, 2.56819725e-01f, 7.94290602e-02f, -1.88561469e-01f, -6.89247251e-02f, -3.15564334e-01f, -3.73292118e-01f, -9.71146226e-02f, -1.27230883e-01f, 1.28887564e-01f,
  -1.07363276e-01f, 9.56431851e-02f, 1.58125877e-01f, -3.46182853e-01f, -2.63030589e-01f, 1.20875873e-01f, -3.14887226e-01f, -1.33763120e-01f, 2.79503372e-02f, -1.01134531e-01f,
  -1.23195417e-01f, -2.17284650e-01f, -4.37905267e-02f, 1.38694093e-01f, -1.82835266e-01f, 8.24416131e-02f, 1.94389790e-01f, 2.19339713e-01f, -1.32598549e-01f, -3.57154980e-02f,
  -7.45735317e-02f, 4.86477427e-02f, -1.59983858e-02f, 5.69834039e-02f, -1.20516516e-01f, -1.13575831e-02f, -1.10756541e-02f, 6.24603592e-03f, -8.50272831e-03f, 4.90505900e-03f,
  7.29727447e-02f, -3.49939093e-02f, -2.33251210e-02f, 5.29285111e-02f, -1.28971502e-01f, 3.40190269e-02f, -2.08019018e-02f, -4.95225415e-02f, -1.00215673e-02f, -6.37191460e-02f,
  2.70154737e-02f, -2.56890394e-02f, -5.23738265e-02f, 9.51346830e-02f, 6.32033870e-02f, -5.52130938e-02f, -4.41472250e-04f, 5.37058115e-02f, -3.02603338e-02f, 2.09873565e-03f,
  3.24374205e-03f, -6.81604585e-03f, -1.49684139e-02f, -4.04474810e-02f, -7.21956342e-02f, 1.03590135e-02f, -3.47629599e-02f, -4.95003955e-03f, 3.38886566e-02f, -2.53195129e-02f,
  -6.41933307e-02f, -9.71004739e-02f, -2.83982363e-02f, -7.07112551e-02f, -7.56511167e-02f, -8.88487920e-02f, 4.05237377e-02f, 2.92016864e-02f, -3.42162442e-03f, -1.76374856e-02f,
  2.55086794e-02f, -1.97060276e-02f, 4.64011319e-02f, -1.60788484e-02f, -2.52779555e-02f, 2.73008477e-02f, 3.89491804e-02f, 3.69726052e-03f, -6.18917961e-03f, -2.77413931e-02f,
  -1.26874691e-03f, 2.32328922e-01f, 6.71412200e-02f, -4.02259789e-02f, 1.27910674e-01f, 4.41687293e-02f, 1.81002226e-02f, 2.44621411e-02f, -3.79659049e-03f, -2.57761143e-02f,
  -3.14473547e-03f, -7.71956192e-03f, 4.61578891e-02f, 2.12747417e-02f, -4.36484721e-03f, -3.40871178e-02f, 4.16358188e-02f, 4.82080616e-02f, -1.06300041e-02f, 2.68395394e-02f,
  2.17908174e-02f, -9.77983885e-03f, 1.10740177e-02f, -4.77099530e-02f, -5.21215834e-02f, 6.78656399e-02f, -1.70372035e-02f, -4.36956696e-02f, 5.32774255e-02f, 2.25122105e-02f,
  3.88584256e-01f, -4.02583569e-01f, 2.81269759e-01f, 1.48759320e-01f, 1.62792429e-01f, -4.27640751e-02f, 8.62309784e-02f, 1.61126077e-01f, 1.08015470e-01f, -2.54830480e-01f,
  1.20149545e-01f, -1.71803966e-01f, -8.55570808e-02f, 2.60034502e-02f, 4.62729573e-01f, -9.02828947e-02f, 1.87529519e-01f, -6.96557537e-02f, -4.60937023e-02f, 1.92250848e-01f,
  1.47347033e-01f, 7.54377246e-02f, 2.26646140e-01f, 7.35594034e-02f, 6.13207668e-02f, 5.77463135e-02f, 1.77687138e-01f, 5.96630052e-02f, -8.91399384e-02f, -8.49921480e-02f,
  -1.07624874e-01f, 1.35157749e-01f, 3.83801945e-02f, 1.99682050e-04f, 1.27913356e-01f, 1.85315069e-02f, -5.35720810e-02f, -5.55446465e-03f, 8.55373815e-02f, -9.38983075e-03f,
  -8.19648951e-02f, -1.56774763e-02f, -5.58290593e-02f, 3.09004448e-02f, 9.25619826e-02f, 1.85129978e-02f, 4.95986007e-02f, -2.15680525e-02f, -3.14045921e-02f, -7.11873593e-03f,
  -1.12174824e-02f, -3.10719647e-02f, 8.27810243e-02f, -3.86297107e-02f, 3.67458574e-02f, 4.70301583e-02f, -4.47265990e-02f, -2.09605936e-02f, -7.34901950e-02f, 3.95551287e-02f,
  5.95738515e-02f, 1.14986293e-01f, 4.96610999e-02f, -1.61533710e-02f, 2.36110147e-02f, -7.32637756e-03f, 6.49127178e-03f, 2.02808268e-02f, -4.12981212e-03f, 4.91608270e-02f,
  2.75528748e-02f, 4.86335205e-03f, 5.51609658e-02f, 5.88423908e-02f, 1.28973955e-02f, 1.30397547e-02f, 6.07186109e-02f, -8.85461550e-03f, -6.16607033e-02f, 6.78270310e-02f,
  2.89618112e-02f, 6.19805306e-02f, -6.49220347e-02f, -5.84793985e-02f, 4.47416827e-02f, 2.81757899e-02f, -2.49915868e-02f, 1.63522325e-02f, 4.23678197e-02f, 8.00582990e-02f,
  -1.15640247e-02f, 3.25055689e-01f, 9.25022736e-02f, -6.87533319e-02f, -1.18583627e-02f, -1.30194677e-02f, 6.84661698e-03f, -1.16900457e-02f, 8.88612494e-02f, 6.70194402e-02f,
  4.67892736e-02f, -4.38550580e-03f, 7.20296800e-03f, -6.94711134e-02f, -4.33802493e-02f, -4.03307052e-03f, 1.22806644e-02f, 3.93876387e-03f, 1.68217704e-01f, -1.82477571e-02f,
  8.35225638e-03f, 5.63820638e-02f, 9.38787609e-02f, 5.38487658e-02f, 5.42774834e-02f, -2.23518051e-02f, 4.63442877e-02f, -8.04644600e-02f, 6.08773120e-02f, -7.15105683e-02f,
  7.29051381e-02f, 1.08698487e-01f, -2.32029334e-01f, -2.50330448e-01f, 1.65520068e-02f, 2.92455077e-01f, 2.48464957e-01f, 3.89768672e-03f, -1.29081681e-01f, 2.91481495e-01f,
  1.01086438e-01f, -1.98131949e-01f, 2.15142697e-01f, -2.86438614e-01f, -1.17123216e-01f, 3.56224924e-02f, 1.50594398e-01f, -5.98523729e-02f, -6.50941208e-02f, 1.26319319e-01f,
  -1.61193490e-01f, -1.11606782e-02f, -2.59243667e-01f, -9.58812539e-04f, -8.85080621e-02f, -2.20888942e-01f, 1.88014820e-01f, -1.24007970e-01f, 1.15114162e-02f, -6.01167865e-02f,
  4.99651395e-03f, -6.17181584e-02f, -6.45376518e-02f, -1.53289378e-01f, 1.46880865e-01f, 1.18922755e-01f, -1.24105383e-02f, -1.22834988e-01f, -1.72049016e-01f, -1.55420573e-02f,
  -4.92470190e-02f, -4.56809588e-02f, -1.22618310e-01f, 9.47829895e-03f, -5.08069657e-02f, -6.61615655e-02f, -1.03881143e-01f, -3.55323241e-03f, -9.67149287e-02f, -7.07092360e-02f,
  3.77391558e-03f, -8.94791707e-02f, 6.64045513e-02f, 4.30132188e-02f, 3.25116771e-03f, 8.68193619e-03f, -3.33210342e-02f, 7.80837685e-02f, 5.13100177e-02f, 5.38730957e-02f,
  1.36795685e-01f, 3.05185672e-02f, -7.38273039e-02f, -5.85292354e-02f, 7.35765323e-02f, -1.10094277e-02f, -2.29510814e-02f, -7.53325373e-02f, -1.47123644e-02f, 4.35005613e-02f,
  2.81648291e-03f, -1.23659114e-03f, -5.36109470e-02f, 4.07291055e-02f, 2.90601533e-02f, 5.26001817e-03f, -4.39222157e-02f, 6.53410107e-02f, 1.64149944e-02f, -2.85434462e-02f,
  -9.34627429e-02f, -6.68461546e-02f, 3.26753706e-02f, -7.33268335e-02f, 5.91160357e-02f, 5.88512160e-02f, -4.36573885e-02f, 1.14127561e-01f, -7.33801946e-02f, 5.96951097e-02f,
  1.57479525e-01f, 2.84949183e-01f, -2.91729569e-02f, -5.31103984e-02f, -3.70290056e-02f, 6.25937730e-02f, -1.17015742e-01f, 2.92122588e-02f, 9.45208147e-02f, 5.12228198e-02f,
  -3.20476480e-02f, -2.88040098e-02f, 1.80556402e-01f, 1.88909825e-02f, -6.34199530e-02f, 9.12129357e-02f, 4.65170331e-02f, -7.71693140e-03f, -2.88572498e-02f, 1.31727695e-01f,
  2.26437133e-02f, 3.68422121e-02f, 2.19735820e-02f, 1.55260591e-02f, -2.74589926e-04f, 2.69029401e-02f, 1.15685754e-01f, -3.11340895e-02f, 2.77433619e-02f, 1.51089946e-04f,
  -2.05372781e-01f, 4.05820847e-01f, 3.52667719e-02f, -6.34693541e-04f, -4.29325581e-01f, -2.36060441e-01f, -1.65738329e-01f, -2.32867524e-02f, 2.46764094e-01f, 2.93229848e-01f,
  -1.56742766e-01f, 1.25676498e-01f, 1.27768159e-01f, 1.02321662e-01f, -1.61336973e-01f, 3.71433258e-01f, 5.79089392e-03f, 1.24000892e-01f, 9.58019644e-02f, -1.13701709e-01f,
  -4.55907919e-02f, -8.05563107e-02f, -1.81975126e-01f, -2.60710102e-02f, -1.97620496e-01f, -1.22131333e-01f, -2.02179834e-01f, -8.72335061e-02f, -1.23732880e-01f, -1.30864307e-02f,
  -2.40233634e-03f, 9.42766443e-02f, -4.27726880e-02f, 1.24973744e-01f, -2.91456953e-02f, -8.27977583e-02f, 8.46271683e-03f, -3.06495633e-02f, -1.83713716e-03f, 3.98361534e-02f,
  -1.65797994e-02f, -3.28252874e-02f, 2.91387308e-02f, 5.32027148e-02f, 1.62061825e-02f, -3.24050561e-02f, -3.37916054e-02f, 4.18900549e-02f, 8.41757879e-02f, -1.92693342e-02f,
  -2.65406016e-02f, -3.78948450e-02f, -6.52778801e-03f, 3.44793499e-03f, -7.96741247e-02f, -1.14910281e-03f, -5.31708300e-02f, -1.46095067e-01f, 5.69559671e-02f, -1.21039644e-01f,
  -2.40708655e-03f, 2.59430390e-02f, -6.16212748e-02f, 5.42256497e-02f, -1.67808868e-02f, -2.18515489e-02f, 6.04285970e-02f, -1.43860129e-03f, 4.28189561e-02f, -1.90540925e-02f,
  -2.53619868e-02f, -6.04621582e-02f, 3.07614282e-02f, -8.48334953e-02f, -7.38775879e-02f, -1.19784884e-02f, -2.32223775e-02f, -6.43748716e-02f, -7.04805031e-02f, -4.42009158e-02f,
  1.32791949e-02f, 8.96381494e-03f, -1.19585181e-02f, -2.31029596e-02f, 8.07625800e-02f, -5.09720817e-02f, -4.90710419e-03f, 1.07449114e-01f, 3.16794962e-02f, -3.05674560e-02f,
  1.33075982e-01f, 1.84010297e-01f, -3.67987691e-03f, 1.83041934e-02f, 7.15469047e-02f, -1.98956728e-02f, 6.01355769e-02f, -9.08800925e-04f, 4.74345349e-02f, -2.03743316e-02f,
  -1.08373733e-02f, -7.96085894e-02f, 7.13149607e-02f, -6.92025274e-02f, 8.70578215e-02f, 1.01496819e-02f, 3.24496441e-02f, -1.45858806e-02f, -6.74388111e-02f, -1.28364712e-01f,
  -8.45044851e-02f, -7.03971833e-02f, -3.65125798e-02f, -4.04897071e-02f, -2.55399831e-02f, -6.82303216e-03f, -5.35473041e-02f, 3.30662425e-03f, -5.65641932e-02f, 9.89976153e-02f,
  -4.25465047e-01f, 3.13887298e-01f, 9.66818929e-02f, -1.40212059e-01f, 3.30711186e-01f, 3.39217447e-02f, -1.98877767e-01f, 2.26698503e-01f, -3.09067816e-01f, 2.28260264e-01f,
  -2.03666128e-02f, -2.88530827e-01f, -1.41487285e-01f, -1.23075314e-01f, -3.68537784e-01f, -2.02257708e-01f, -2.29318161e-02f, -8.31347425e-03f, -1.73547685e-01f, -4.44424264e-02f,
  -1.48076907e-01f, 7.38772154e-02f, -3.11606918e-02f, 3.02814960e-01f, 1.83699355e-01f, 1.17722899e-01f, 1.36604339e-01f, -3.28189246e-02f, 2.17926636e-01f, -1.00815125e-01f,
  -4.72021364e-02f, -1.79663792e-01f, -1.13004434e-03f, -5.96632585e-02f, -1.00578383e-01f, 8.87706503e-02f, -7.63509749e-03f, -4.16088440e-02f, -1.57855749e-02f, 1.59357395e-02f,
  3.68189625e-02f, 1.74698532e-02f, -9.36616212e-02f, -8.28381330e-02f, 1.76783264e-01f, 1.27535120e-01f, 7.11524561e-02f, 4.27669510e-02f, 9.20504108e-02f, -9.67097133e-02f,
  7.00853914e-02f, 6.09725676e-02f, 6.70236498e-02f, -3.97175141e-02f, 3.67622189e-02f, -9.00662616e-02f, 8.10286477e-02f, -6.55715540e-02f, 4.61995155e-02f, -8.60103406e-03f,
  8.94759316e-03f, -2.69458834e-02f, 7.54536688e-02f, 1.16997294e-01f, -4.58932333e-02f, 9.77999251e-03f, 1.68713052e-02f, 7.96878785e-02f, -1.00550331e-01f, -2.52491850e-02f,
  5.40486723e-02f, 9.36495606e-03f, 2.71212980e-02f, 5.33749349e-02f, -4.60266918e-02f, -2.38100588e-02f, 8.54517892e-02f, -8.70668516e-02f, -3.41351517e-02f, -2.11525615e-02f,
  -3.02500147e-02f, -4.69125509e-02f, -8.26736912e-02f, 2.74905004e-02f, -1.20193698e-03f, -3.60856317e-02f, 1.00078836e-01f, 4.56046723e-02f, -1.31774822e-03f, 6.37631193e-02f,
  -3.74690332e-02f, -9.98684615e-02f, 3.58791873e-02f, 7.06522316e-02f, -3.51569150e-04f, 1.01120569e-01f, -2.71392334e-02f, 8.14551786e-02f, 4.34312485e-02f, -1.51145548e-01f,
  1.05068557e-01f, 1.25969887e-01f, 2.16957461e-02f, -1.16329156e-01f, 2.76618171e-02f, 4.48841043e-02f, -5.13188802e-02f, -7.65569657e-02f, -1.70779657e-02f, 2.79431827e-02f,
  5.92318512e-02f, 8.59229174e-03f, 4.29481380e-02f, 1.44555286e-01f, 7.40316063e-02f, -3.14801708e-02f, -1.82188302e-02f, 4.09244141e-03f, -1.50220655e-02f, 8.99322629e-02f,
  -2.40972251e-01f, -3.20118338e-01f, -1.37516037e-01f, -2.14297161e-01f, -2.16337413e-01f, 4.30858582e-01f, 2.01645285e-01f, -1.33315071e-01f, -2.74260998e-01f, -3.52835353e-03f,
  9.84961167e-02f, -2.29530424e-01f, 1.05105579e-01f, 1.58142403e-01f, 4.18902010e-01f, 3.68032008e-01f, 8.18681121e-02f, 1.72883237e-03f, -9.79182646e-02f, -2.41008401e-01f,
  -2.86499262e-02f, -6.12635426e-02f, 6.80738240e-02f, -1.23939656e-01f, -1.71985000e-01f, -1.39045522e-01f, -1.28847733e-02f, -6.01736419e-02f, 1.26731664e-01f, 9.50461403e-02f,
  3.65087204e-02f, -2.55882263e-01f, -1.01381103e-02f, 8.72680619e-02f, -3.26947682e-02f, -8.82247183e-03f, 1.27940446e-01f, 1.55143574e-01f, 6.24390990e-02f, -9.60890874e-02f,
  -7.15345098e-03f, 1.93271954e-02f, -3.67876887e-03f, 3.21576968e-02f, -8.80800113e-02f, -8.80055726e-02f, -1.40155395e-02f, 7.09088966e-02f, -1.57257080e-01f, 4.38030623e-02f,
  -7.75835961e-02f, -5.86576238e-02f, -7.06634969e-02f, 5.83520047e-02f, -6.46827966e-02f, -4.12004143e-02f, 6.25011921e-02f, 3.71366777e-02f, 4.20286357e-02f, -1.52549461e-01f,
  4.27685566e-02f, -9.49012041e-02f, 3.48702297e-02f, -3.44549268e-02f, 5.60276210e-02f, -7.27379918e-02f, 4.18051928e-02f, 4.75736149e-02f, 2.86698006e-02f, -6.44495338e-02f,
  -1.33404313e-02f, 5.69123290e-02f, -1.31451366e-02f, 2.38034353e-02f, -1.79766696e-02f, -4.52605225e-02f, 9.70275402e-02f, -4.52168845e-02f, -1.10507034e-01f, 9.82342381e-03f,
  -1.81599259e-02f, 4.68396172e-02f, -3.20299156e-02f, 3.02012172e-02f, 7.07160980e-02f, 6.26730919e-03f, -7.01689115e-03f, 2.24466756e-04f, 3.59968059e-02f, 2.57439390e-02f,
  -9.38410759e-02f, -1.70049816e-01f, -7.19628558e-02f, -1.62951536e-02f, 2.87894532e-02f, 7.41336420e-02f, -2.12303344e-02f, -4.10414562e-02f, -2.62734015e-02f, 1.30245583e-02f,
  2.19461694e-02f, 3.18937786e-02f, -6.27531856e-02f, 4.84837890e-02f, 6.37203828e-02f, 2.98161898e-02f, -5.82494140e-02f, -1.98530518e-02f, 2.81644519e-02f, -2.22710297e-02f,
  -5.47277890e-02f, -2.50866525e-02f, -3.39243636e-02f, -1.41018838e-01f, 5.78269176e-02f, -3.12109990e-03f, -1.13459252e-01f, 1.12434711e-04f, -3.18507329e-02f, -8.92827986e-04f,
  -2.43408546e-01f, 2.93536305e-01f, 1.52634725e-01f, -2.38210753e-01f, 2.82774180e-01f, -6.51342748e-03f, -4.75400273e-04f, 1.89694986e-01f, -1.19430393e-01f, 5.83254583e-02f,
  -2.78996199e-01f, 1.90308001e-02f, -7.40392134e-02f, -3.85044158e-01f, -3.09352338e-01f, -3.16258311e-01f, -3.59384060e-01f, -2.93759197e-01f, -7.33120069e-02f, -1.22207806e-01f,
  -1.74637698e-02f, -5.28431833e-02f, 1.91122070e-01f, 4.10614282e-01f, 2.51898021e-01f, 2.98913062e-01f, -2.54780916e-03f, 2.01701224e-01f, -2.85617430e-02f, 8.47237781e-02f,
  -1.12901933e-01f, 2.66019385e-02f, 1.31369606e-01f, 3.73168066e-02f, -6.06619418e-02f, -4.71083224e-02f, -5.77995703e-02f, 1.00190453e-01f, -2.65347734e-02f, 4.01954763e-02f,
  9.62871499e-03f, 3.89318131e-02f, 5.25069088e-02f, 1.11544676e-01f, 1.18999220e-01f, 3.48243564e-02f, -1.71941854e-02f, 2.04377789e-02f, 9.11130607e-02f, -2.12370139e-02f,
  -2.98151765e-02f, -3.18082608e-02f, -7.10221827e-02f, -1.13756448e-01f, 3.98130231e-02f, -4.62095626e-02f, 1.85587090e-02f, 8.47819000e-02f, 1.23936497e-02f, -2.56599300e-02f,
  1.21768229e-01f, -6.93841949e-02f, -8.09974503e-03f, 6.72590360e-02f, -3.25931571e-02f, 8.20336938e-02f, -2.02007238e-02f, -2.79250480e-02f, 2.43134480e-02f, -2.53520515e-02f,
  -9.37531423e-03f, 2.85517983e-02f, -2.17755213e-02f, 2.66202074e-02f, -6.87976032e-02f, 9.50888321e-02f, -2.55554281e-02f, -4.37346771e-02f, -1.34946126e-02f, -5.85111529e-02f,
  9.02990624e-02f, -9.26499739e-02f, 2.38480214e-02f, 4.81538177e-02f, 2.27872701e-03f, 1.27919078e-01f, -3.37956101e-02f, 4.96127084e-02f, -1.47098005e-02f, -2.68670935e-02f,
  -3.09201300e-01f, -1.03453472e-01f, 3.35063338e-02f, 8.03011730e-02f, -3.98657331e-03f, -2.40660086e-02f, -8.96210596e-03f, -5.61900847e-02f, 8.59253556e-02f, -1.88395102e-02f,
  9.00435355e-03f, -1.02004290e-01f, 6.90843910e-03f, -6.20608665e-02f, -5.39811738e-02f, -4.45240065e-02f, -8.34910795e-02f, 3.06666996e-02f, 5.25601208e-02f, -5.72053529e-02f,
  -7.75811262e-03f, -4.85446071e-03f, 1.58226993e-02f, 1.56508401e-01f, -4.50723879e-02f, 3.02535836e-02f, -2.96096876e-02f, 1.03304096e-01f, -2.67985556e-02f, -2.08417568e-02f,
  1.52089313e-01f, 1.77692756e-01f, -3.48647892e-01f, -3.46975960e-03f, 4.51077558e-02f, -6.82482421e-02f, 1.58909589e-01f, 6.82142526e-02f, 3.18611830e-01f, 2.13951483e-01f,
  2.33096361e-01f, -1.05297759e-01f, 1.77443534e-01f, 1.03248106e-02f, -8.74334425e-02f, 1.90217808e-01f, 5.07872142e-02f, 1.14384510e-01f, -6.16558678e-02f, 4.86840941e-02f,
  -3.20860706e-02f, 2.01571673e-01f, -1.19664326e-01f, 3.29325460e-02f, -9.41406861e-02f, -9.05213431e-02f, 1.72754228e-01f, -8.28625038e-02f, -9.95717645e-02f, -1.17152467e-01f,
  2.79171113e-02f, 8.52218121e-02f, -6.48669451e-02f, 3.39957364e-02f, -8.20608065e-03f, -5.86448312e-02f, -3.47207673e-02f, -8.54263082e-03f, -2.58071199e-02f, -8.26769173e-02f,
  4.42139283e-02f, 2.58470755e-02f, -1.19628049e-01f, 1.72029026e-02f, 1.52572533e-02f, 1.22184800e-02f, -4.10724729e-02f, -8.32311884e-02f, -5.02883233e-02f, -5.12344055e-02f,
  -6.78439215e-02f, -1.24323234e-01f, -8.47837776e-02f, -3.41784246e-02f, -1.58409886e-02f, -3.95036973e-02f, -5.06977141e-02f, -7.89545029e-02f, 3.65397185e-02f, 8.52709338e-02f,
  -9.49146692e-03f, 6.38827775e-03f, -7.09996838e-03f, -4.75218631e-02f, 1.08975954e-01f, -1.01539917e-01f, 6.72402680e-02f, -1.83394784e-03f, -2.68386994e-02f, 1.12886131e-01f,
  -4.73794602e-02f, -4.82741697e-03f, -2.52816994e-02f, 8.80296901e-02f, 1.22466385e-01f, 1.08638946e-02f, -3.47209498e-02f, 6.77512437e-02f, -4.09749746e-02f, -4.23267968e-02f,
  1.73899438e-02f, 2.36593653e-02f, 1.18875068e-04f, 3.77324782e-02f, 6.29290491e-02f, 7.52480030e-02f, 1.46597736e-02f, -3.86648700e-02f, 1.66646335e-02f, 7.05948099e-03f,
  3.45030516e-01f, 3.78283352e-01f, 7.15140551e-02f, 1.30152190e-02f, -2.63702348e-02f, 2.13503581e-03f, -1.33270072e-02f, 2.22116918e-03f, 8.66282359e-02f, 1.12237878e-01f,
  -5.06578609e-02f, -2.49816012e-02f, -5.30310581e-06f, -1.49871316e-02f, -3.72208878e-02f, 2.54241116e-02f, 3.10423486e-02f, 1.01992995e-01f, 1.33282080e-01f, -1.00896638e-02f,
  7.27659985e-02f, 1.37997791e-01f, -7.07315356e-02f, -5.07660583e-03f, -1.74465887e-02f, 6.62993416e-02f, 5.28298039e-03f, 9.84456483e-03f, -4.33749566e-03f, -2.20382176e-02f,
  2.01914981e-01f, -2.12831348e-01f, 4.05812979e-01f, 2.36594543e-01f, -5.18605337e-02f, -2.06926510e-01f, -3.95255424e-02f, -6.95374012e-02f, -1.20059215e-01f, -3.06594282e-01f,
  -1.85789719e-01f, 1.47754923e-01f, 5.50801754e-02f, -2.30878606e-01f, 3.70181769e-01f, -3.69416587e-02f, 5.96573169e-04f, -1.35157049e-01f, -2.33900417e-02f, 8.81613865e-02f,
  1.41556188e-01f, -3.29201877e-01f, 2.63824105e-01f, -3.05016845e-01f, -4.28961143e-02f, 7.88647756e-02f, 1.88091725e-01f, 3.01250275e-02f, -4.44587693e-02f, 4.59112860e-02f,
  2.96545103e-02f, -1.07818119e-01f, -2.15340886e-04f, -8.64464939e-02f, -4.51055868e-03f, -2.54896805e-02f, 4.74691717e-03f, 5.81469052e-02f, 7.04655200e-02f, -2.92097274e-02f,
  -2.44359635e-02f, -6.81678625e-03f, -9.66951773e-02f, 1.81791782e-02f, -3.99233215e-02f, 3.77101265e-02f, 2.96935160e-02f, 5.13628572e-02f, -2.92312652e-02f, 1.01640962e-01f,
  4.71727997e-02f, 3.10606472e-02f, 6.29713312e-02f, 3.23170386e-02f, 1.00227296e-01f, 2.34949235e-02f, -2.04372425e-02f, 3.75177041e-02f, -1.06398026e-02f, -2.58682463e-02f,
  2.40927842e-02f, -7.25012049e-02f, -3.50018218e-03f, -3.65030393e-02f, -4.25173752e-02f, -2.90260185e-02f, -6.91253692e-02f, -2.15844158e-02f, 8.52442384e-02f, 2.70712539e-03f,
  7.59504363e-02f, 1.36073045e-02f, -1.06188051e-01f, 1.35727227e-02f, 7.10867252e-03f, -4.21520695e-02f, 5.33833914e-03f, -1.07172646e-01f, 2.10385565e-02f, 3.04942802e-02f,
  -1.97009612e-02f, -4.97855023e-02f, -6.05898537e-02f, -1.18975975e-02f, -1.03972636e-01f, 1.00742199e-01f, -8.40622112e-02f, 4.66433391e-02f, 6.12735003e-03f, 1.04933351e-01f,
  2.29296982e-02f, 2.08054204e-02f, -4.42564599e-02f, -1.11762434e-02f, -7.10594207e-02f, -2.43120473e-02f, -4.42509763e-02f, -1.65874008e-02f, 2.21536551e-02f, -7.75184110e-02f,
  -3.14037688e-02f, 4.53515770e-03f, 6.78790212e-02f, -4.83576208e-02f, 3.52505483e-02f, 5.71978539e-02f, -1.86130330e-02f, 3.85865010e-02f, 3.87036353e-02f, -6.83482736e-03f,
  3.66187841e-02f, -5.31777106e-02f, 1.83512606e-02f, -7.05683380e-02f, -2.24848045e-03f, 2.72822939e-02f, 7.89085105e-02f, 1.88653078e-02f, 2.35054456e-02f, -1.10236723e-02f,
  -2.37353384e-01f, -1.79443389e-01f, 8.99524465e-02f, 1.12737328e-01f, -1.82159111e-01f, -2.94460475e-01f, -2.93569081e-02f, -9.18801278e-02f, 3.07391919e-02f, 1.69461012e-01f,
  -9.07914340e-02f, -2.27801293e-01f, -5.70486560e-02f, 2.06409339e-02f, -5.40768325e-01f, -1.64097715e-02f, -1.21470816e-01f, -1.54880770e-02f, -1.31417168e-02f, -1.84899807e-01f,
  7.89107010e-03f, -3.22953522e-01f, 1.09200113e-01f, -7.44335055e-02f, -5.62313572e-02f, 1.81639373e-01f, 1.91507135e-02f, -3.16872969e-02f, 8.28144550e-02f, -7.33832046e-02f,
  -1.30266964e-01f, 1.20787080e-02f, 2.31226720e-02f, 6.88644126e-02f, -4.69948687e-02f, 8.58290866e-02f, 4.89086099e-02f, -8.77830237e-02f, -2.25658976e-02f, -2.14655735e-02f,
  2.49316171e-02f, -8.75068828e-02f, 6.73097558e-04f, 4.58161682e-02f, 3.69360521e-02f, 2.49563623e-02f, 4.87317368e-02f, 1.67829677e-01f, -5.77834398e-02f, -2.68400088e-02f,
  2.59434450e-02f, 6.37161359e-02f, 5.98873310e-02f, 9.42648128e-02f, 6.10762089e-03f, 4.63173687e-02f, 8.39743540e-02f, -4.34346078e-03f, -2.99326107e-02f, 1.62098452e-03f,
  -2.50798985e-02f, -2.73864903e-03f, -2.46595275e-02f, 1.94551088e-02f, -1.10778011e-01f, 5.86058982e-02f, -6.62123738e-03f, 5.80908880e-02f, 2.37578396e-02f, -1.46100279e-02f,
  -7.47680068e-02f, -9.54918563e-03f, 3.51026910e-03f, 7.00169150e-03f, 5.99053130e-02f, 1.88958738e-02f, 2.22548079e-02f, -6.13184646e-02f, -2.58076703e-03f, -2.86335051e-02f,
  -6.36111423e-02f, -4.63342965e-02f, -2.86082830e-02f, 5.80018014e-02f, -1.04610518e-01f, 1.73414685e-02f, 1.07605860e-01f, 5.82959950e-02f, 3.52713242e-02f, -5.86417913e-02f,
  -2.43119299e-01f, -2.98084557e-01f, -1.22788334e-02f, -3.61127295e-02f, -2.90242955e-02f, -7.91330934e-02f, -3.68515030e-02f, 1.24482000e-02f, -5.79957329e-02f, -7.79067799e-02f,
  6.20143488e-02f, 1.06875345e-01f, -7.77113426e-04f, 2.40231287e-02f, -8.30184072e-02f, -5.58610521e-02f, -5.54957893e-03f, -1.51385264e-02f, -3.60509120e-02f, -5.63525856e-02f,
  -3.78345437e-02f, -4.27806824e-02f, 4.03896309e-02f, -3.26108299e-02f, 6.94299191e-02f, -4.53321114e-02f, -9.20305029e-02f, 2.66510919e-02f, 2.97824517e-02f, -5.32157272e-02f,
  -4.46519375e-01f, 1.44504145e-01f, -2.46227235e-02f, -3.35632622e-01f, -5.58359176e-02f, 1.94114968e-01f, 2.11439859e-02f, -4.08125520e-02f, -1.98457137e-01f, 2.97445238e-01f,
  -2.95988079e-02f, -3.03615630e-01f, 2.79702812e-01f, -1.74399585e-01f, -4.04265672e-01f, 1.88567296e-01f, -1.15477107e-01f, -1.02482431e-01f, -4.71692048e-02f, -1.71872318e-01f,
  -1.54635131e-01f, -2.30112776e-01f, -1.33238863e-02f, 2.15225622e-01f, -1.27726138e-01f, 8.86353776e-02f, -1.51117751e-02f, 1.21349238e-01f, 3.95461768e-02f, -7.49885440e-02f,
  -1.17652617e-01f, -2.29177311e-01f, 3.02213039e-02f, -1.22341942e-02f, 2.39374880e-02f, 8.28416795e-02f, -6.62315637e-03f, 3.12866899e-03f, -9.87739116e-03f, -6.65910393e-02f,
  -3.64206880e-02f, -1.29550481e-02f, -5.49033051e-03f, 4.20003058e-03f, 3.35002542e-02f, 3.64994518e-02f, -7.89430365e-03f, 5.73589206e-02f, -1.67055149e-02f, -2.81928573e-02f,
  -5.01474040e-03f, 4.91849817e-02f, -1.64796337e-02f, 5.73426038e-02f, -1.19619668e-02f, -1.90257281e-02f, 3.28448117e-02f, 4.77853417e-02f, -6.27444908e-02f, -4.72386777e-02f,
  8.06766972e-02f, -4.40223925e-02f, 8.33023787e-02f, -7.33652562e-02f, -5.78058548e-02f, -5.97779080e-02f, 2.68371794e-02f, 1.55630736e-02f, 2.56873630e-02f, -2.43324488e-02f,
  -7.99281709e-03f, -4.33547385e-02f, -8.49726051e-02f, 6.08089082e-02f, -6.96321502e-02f, -2.56212847e-03f, 7.33606657e-03f, 2.63556316e-02f, -4.24887836e-02f, -4.72117439e-02f,
  5.95952086e-02f, -2.35189660e-03f, -9.61521417e-02f, 4.77805398e-02f, 5.53851426e-02f, 4.87825042e-03f, 5.33053419e-03f, 4.83878814e-02f, -2.50286479e-02f, -6.19455427e-02f,
  -1.16455577e-01f, -1.49071306e-01f, 3.57738622e-02f, 2.63504274e-02f, 1.49857225e-02f, 1.10903559e-02f, 1.58028714e-02f, 1.63422432e-02f, 5.37352040e-02f, -3.15421470e-03f,
  6.37165383e-02f, 2.11042725e-02f, 2.22417880e-02f, -4.02522832e-02f, -2.26786919e-02f, -3.48473117e-02f, -6.64319023e-02f, 4.85374406e-02f, -5.03720827e-02f, -2.99378317e-02f,
  3.66002172e-02f, -2.44634934e-02f, 7.85131156e-02f, -9.38030146e-03f, 1.49523765e-02f, 5.91087602e-02f, -1.38657913e-01f, 9.65702981e-02f, 7.38177672e-02f, 2.58441106e-03f,
  4.77804728e-02f, 1.18416674e-01f, 2.50525028e-01f, 1.21116728e-01f, -4.18309942e-02f, 3.03799272e-01f, -1.82985500e-01f, 5.25544696e-02f, -2.57862777e-01f, -4.46042567e-02f,
  -2.63540030e-01f, 1.10168613e-01f, -3.35381418e-01f, 2.08611280e-01f, 1.66272819e-01f, -1.70303509e-01f, 1.66379854e-01f, 1.28241703e-01f, -1.17531858e-01f, 9.51233208e-02f,
  7.43581653e-02f, 4.48905453e-02f, 1.07011177e-01f, 1.19607583e-01f, 5.21315113e-02f, 1.49196237e-01f, 6.81716949e-02f, -1.86646692e-02f, 2.46493533e-01f, 4.30121757e-02f,
  8.08189586e-02f, -2.11919621e-01f, -1.95779931e-02f, 4.19976898e-02f, 5.70481941e-02f, 7.10259005e-02f, 7.27718547e-02f, -1.03923470e-01f, -2.60000210e-02f, -3.10208667e-02f,
  1.74919479e-02f, 6.33900091e-02f, 5.79987876e-02f, -1.10820830e-01f, 6.89849723e-03f, 7.76276439e-02f, 6.02314109e-03f, 1.74734835e-02f, -1.28793633e-02f, 3.57594118e-02f,
  -4.64383550e-02f, 1.03703760e-01f, 2.49216743e-02f, 9.70661268e-02f, -4.49069366e-02f, 2.23201029e-02f, 8.35390203e-03f, 5.34654893e-02f, 3.62113714e-02f, 8.26134011e-02f,
  3.54337804e-02f, 5.91976801e-03f, 1.52419126e-02f, -2.66222730e-02f, -4.57371473e-02f, 1.14169260e-02f, -5.07415012e-02f, 1.38939088e-02f, 4.68216650e-02f, 5.94793307e-03f,
  6.87459251e-03f, 8.46661907e-03f, -7.78791234e-02f, 4.54808772e-02f, 2.89267302e-03f, -1.33117698e-02f, 3.57555449e-02f, -4.88445647e-02f, 3.49330902e-02f, 5.02118506e-02f,
  -1.11609384e-01f, 4.55316268e-02f, -5.88734709e-02f, -2.74414942e-02f, 5.07606789e-02f, -5.01191281e-02f, 7.16660172e-04f, -1.86771695e-02f, -4.17183852e-03f, -6.02175901e-03f,
  1.02533624e-01f, 8.14604461e-02f, -5.03643714e-02f, -4.82830852e-02f, 1.64890531e-02f, -1.90750845e-02f, 7.21043423e-02f, 1.03174359e-01f, 5.06806187e-03f, 1.96226127e-03f,
  7.46655688e-02f, 7.52053550e-03f, 2.62576025e-02f, 4.55734469e-02f, 6.21818379e-02f, -8.82395580e-02f, -2.22263653e-02f, 3.95505205e-02f, 2.06585042e-02f, 4.01526801e-02f,
  3.55028994e-02f, -6.61924705e-02f, 1.16041703e-02f, -1.99163854e-02f, 8.49722251e-02f, -5.02518788e-02f, 1.29253082e-02f, -3.44207659e-02f, 3.52989770e-02f, -6.41037663e-03f,
  -3.59239161e-01f, 5.16189374e-02f, -2.95209467e-01f, -2.35274304e-02f, -4.66654152e-02f, -3.71454097e-03f, 1.62016988e-01f, -7.68566551e-03f, -2.52606332e-01f, 1.69853717e-01f,
  2.99255282e-01f, -2.18686625e-01f, 4.29857783e-02f, 3.24985713e-01f, -1.25113562e-01f, 2.31859069e-02f, 1.98442802e-01f, 4.67183143e-02f, -1.45998657e-01f, -5.03305942e-02f,
  -1.54182240e-01f, 3.71881217e-01f, -1.67663512e-03f, 2.18178228e-01f, -3.45559418e-02f, -9.74531919e-02f, 3.09676379e-01f, 5.32605201e-02f, 2.63682246e-01f, 1.03510670e-01f,
  7.47169107e-02f, -1.18060514e-01f, -1.84856392e-02f, -8.09914097e-02f, 1.34330532e-02f, 8.95583332e-02f, 9.55688208e-02f, 5.14615737e-02f, -2.91023422e-02f, -5.32454811e-02f,
  -7.72853345e-02f, 5.91506474e-02f, 2.58056168e-02f, -3.64514813e-02f, -4.39329445e-02f, -2.64102630e-02f, -8.46424028e-02f, -8.10880661e-02f, 5.39946891e-02f, -8.24289396e-02f,
  -5.71079701e-02f, -1.08835306e-02f, -5.57069071e-02f, 7.61574656e-02f, -1.38035804e-01f, -5.62016480e-03f, 2.82816729e-03f, -1.04319341e-01f, -5.33101596e-02f, -7.00064301e-02f,
  3.19474749e-02f, -7.24710375e-02f, -9.19401995e-04f, 5.94469458e-02f, 9.04298946e-03f, 3.21363062e-02f, 7.50596868e-04f, 1.19109072e-01f, -8.32070559e-02f, -1.00913886e-02f,
  1.52258174e-02f, 1.86342309e-04f, 3.56429517e-02f, 3.24688219e-02f, -3.79190259e-02f, -2.85887579e-03f, -9.70969349e-02f, 3.63659449e-02f, -9.55232456e-02f, -3.87398992e-03f,
  8.11672360e-02f, -4.05827127e-02f, -4.36497703e-02f, 6.97505325e-02f, 3.86725180e-02f, -4.69360948e-02f, 8.16431865e-02f, -4.51336689e-02f, -1.74187683e-02f, 5.51355891e-02f,
  -2.45369300e-02f, 6.23044632e-02f, 3.32508422e-02f, 1.16257042e-01f, 3.40914428e-02f, -5.35438620e-02f, -2.58191545e-02f, -1.06201007e-03f, -1.57455262e-02f, -3.83509547e-02f,
  5.34601398e-02f, 4.33218777e-02f, -9.24666524e-02f, 4.61712256e-02f, 3.57125290e-02f, -3.59448083e-02f, 1.02754712e-01f, 3.91453356e-02f, -1.57496333e-03f, 4.30401191e-02f,
  1.80179179e-02f, 2.55601425e-02f, 3.63986380e-02f, -1.27238901e-02f, 7.10996389e-02f, 5.76047897e-02f, -8.74943212e-02f, 5.21062734e-03f, 2.73770522e-02f, 4.52718772e-02f,
  5.50926663e-02f, -2.36762062e-01f, 2.33038113e-01f, 2.00898409e-01f, -1.30996302e-01f, -1.97905093e-01f, -1.10508516e-01f, -8.02997798e-02f, 1.33320481e-01f, -2.95469791e-01f,
  -1.79537013e-01f, 9.68830213e-02f, -1.52889296e-01f, -8.51152241e-02f, 5.10784946e-02f, 1.16230555e-01f, -1.27617314e-01f, -9.99844819e-02f, 6.01422563e-02f, -1.53977841e-01f,
  1.67556494e-01f, -3.07991743e-01f, 2.53174424e-01f, -1.88683465e-01f, -1.81549545e-02f, 1.88770041e-01f, -1.58986911e-01f, 1.90286878e-02f, -1.20752893e-01f, -1.77282020e-02f,
  -1.54028401e-01f, -2.76104603e-02f, 7.32191354e-02f, 4.28860709e-02f, -5.11418842e-02f, -1.68682449e-02f, -1.07645206e-02f, 4.63482551e-02f, 1.00703560e-01f, 6.19703112e-03f,
  -4.86864112e-02f, 1.05270045e-02f, 7.88449273e-02f, -9.41405073e-03f, -1.65004854e-03f, 8.77424255e-02f, -2.86785066e-02f, 3.55833583e-02f, -2.49005612e-02f, 4.54152338e-02f,
  8.03948566e-02f, 3.30225229e-02f, 1.88749749e-03f, 3.84714976e-02f, 7.83830658e-02f, -8.64817412e-04f, 5.96835911e-02f, -2.03301143e-02f, 4.05943766e-03f, 1.73149686e-02f,
  4.13297564e-02f, -2.72485353e-02f, 1.43408757e-02f, -6.12250827e-02f, -5.24689369e-02f, 2.65721157e-02f, -6.42825216e-02f, -1.23440726e-02f, 1.42546576e-02f, -3.29890959e-02f,
  -5.00104614e-02f, 1.55664477e-02f, 5.11364918e-03f, -1.43647157e-02f, -8.56949091e-02f, 4.52086031e-02f, -4.25608270e-02f, -9.40611139e-02f, 2.95800641e-02f, 1.06771111e-01f,
  -9.57703963e-03f, -3.46555375e-02f, 1.48879318e-02f, 8.04661028e-03f, 9.18390974e-03f, -2.20351387e-02f, -5.07593155e-02f, 3.46277021e-02f, -2.18026899e-02f, -2.49426365e-02f,
  -3.30364525e-01f, -2.41920397e-01f, -4.42711934e-02f, -1.00531533e-01f, -4.26326059e-02f, 1.50379632e-02f, -6.24904688e-03f, -1.03297653e-02f, -1.17643476e-01f, -5.96992150e-02f,
  -3.90161909e-02f, -1.53346797e-02f, -1.73355341e-02f, 7.40937293e-02f, 1.71352848e-02f, -6.48026615e-02f, -3.29601876e-02f, -6.04895055e-02f, -9.64703634e-02f, -8.66224393e-02f,
  -8.28490853e-02f, 1.08284615e-02f, 8.11213404e-02f, 9.09063220e-03f, -6.12106360e-03f, -3.31264362e-02f, -9.49030966e-02f, 1.46680281e-01f, -7.95549061e-03f, -1.02201179e-01f,
  -3.29080254e-01f, -1.26165003e-02f, -2.28474215e-02f, -3.55658174e-01f, -6.98224604e-02f, 4.26714718e-01f, 6.24854378e-02f, -1.64545640e-01f, -4.51172054e-01f, 1.31302238e-01f,
  -1.31882608e-01f, -9.72078890e-02f, -1.91737667e-01f, 7.74724558e-02f, 3.34956907e-02f, -6.13947846e-02f, 1.64559335e-01f, 3.47370356e-02f, -2.36911029e-01f, -4.30130549e-02f,
  -5.25055975e-02f, -6.51596934e-02f, -7.34462263e-03f, -6.72735721e-02f, 1.11390054e-01f, 1.31279705e-02f, 8.60338956e-02f, -1.30839840e-01f, 3.26655924e-01f, 1.88613795e-02f,
  4.39790711e-02f, -2.32374445e-01f, 9.19370204e-02f, 8.33925232e-02f, 1.13597386e-01f, 1.65739924e-01f, 2.53019989e-01f, 5.70123196e-02f, -8.99032056e-02f, 1.38093624e-02f,
  8.11482370e-02f, -4.94737327e-02f, -3.14880274e-02f, -1.37899444e-01f, 3.98396961e-02f, -9.07404125e-02f, 1.34644052e-02f, 4.88693938e-02f, -1.19394675e-01f, -2.11325735e-02f,
  5.97863516e-04f, 1.05834350e-01f, 3.10992859e-02f, 1.50591627e-01f, 1.56881869e-01f, -8.49745348e-02f, 8.43898207e-02f, 1.64073154e-01f, 1.63205102e-01f, -3.56566161e-02f,
  -1.10230081e-01f, -2.02009752e-02f, -2.11917539e-03f, -9.58759040e-02f, -3.24736275e-02f, 2.64931154e-02f, 6.38354570e-02f, 1.71468146e-02f, 3.96380760e-02f, -5.45354784e-02f,
  -5.08156680e-02f, -3.63373272e-02f, -8.08730349e-02f, 8.04310068e-02f, -6.07818514e-02f, -1.92885045e-02f, -1.55483633e-02f, 4.07174379e-02f, 4.53711376e-02f, -9.36337337e-02f,
  -1.22714184e-01f, 5.03829634e-03f, -1.68751199e-02f, 1.23742998e-01f, -6.93372861e-02f, -6.15355819e-02f, -1.20409675e-01f, -3.67353037e-02f, -2.69137472e-02f, 2.28782929e-02f,
  1.97868511e-01f, -9.68792289e-02f, 1.28821265e-02f, 1.55502632e-01f, 5.33005111e-02f, 4.78989594e-02f, -7.12800547e-02f, 4.87459004e-02f, -1.21556297e-01f, -6.37753978e-02f,
  4.46646661e-02f, 1.28388166e-01f, 7.42720962e-02f, -9.89781767e-02f, 6.15352914e-02f, -1.48985097e-02f, -1.47529470e-03f, 2.78807990e-02f, -5.15696965e-02f, 6.21991931e-03f,
  2.62513086e-02f, 1.10026356e-02f, 1.52333453e-01f, -3.42774740e-03f, 1.33608058e-01f, 7.86397234e-02f, -1.21431798e-01f, 7.77177364e-02f, 1.44079760e-01f, -4.29751053e-02f,
  -3.79781611e-02f, -4.19134051e-01f, -1.56984389e-01f, -3.31512630e-01f, -5.75626828e-02f, 2.71054804e-01f, 4.52828377e-01f, -9.32272896e-02f, -3.16585563e-02f, 1.31953642e-01f,
  1.13263307e-02f, -1.30988397e-02f, 3.93167794e-01f, -3.08829576e-01f, 2.09231541e-01f, 1.05396718e-01f, -2.26678953e-01f, 1.12629810e-03f, -1.62667811e-01f, -9.78875011e-02f,
  -1.99153304e-01f, -1.67027593e-01f, -1.41889736e-01f, -2.55490094e-01f, -3.35535556e-02f, -1.01219818e-01f, 1.05959512e-01f, 1.33856073e-01f, -1.32926211e-01f, 9.38167498e-02f,
  -7.44696856e-02f, -3.17385420e-02f, -6.45135343e-02f, 1.86765846e-02f, -3.81463254e-03f, 1.70740545e-01f, 1.83236212e-01f, 1.72738031e-01f, 7.59061277e-02f, -5.43945702e-03f,
  8.83156359e-02f, -2.94511188e-02f, -8.77860337e-02f, 5.57921529e-02f, 6.11442886e-02f, -1.26256168e-01f, -8.39942917e-02f, -2.03928947e-02f, -5.13499789e-03f, 1.04936110e-02f,
  -9.31315571e-02f, -9.47489738e-02f, -2.81876675e-03f, -3.42246667e-02f, 2.65555475e-02f, 3.42464447e-02f, 9.76951793e-03f, 6.43820167e-02f, -5.88950850e-02f, -1.83729157e-01f,
  8.37524310e-02f, 8.59934539e-02f, -8.54245350e-02f, -6.15145080e-02f, -8.80380943e-02f, -2.85559446e-02f, 3.42555232e-02f, 4.70597260e-02f, -1.62942819e-02f, 5.16462922e-02f,
  -6.74284920e-02f, -1.31857559e-01f, 2.12465972e-02f, 5.13296276e-02f, 5.20750508e-02f, 2.66553145e-02f, 5.80474213e-02f, 3.22871357e-02f, -7.41059408e-02f, -3.56881618e-02f,
  9.10934433e-02f, -8.14437587e-03f, 5.39910682e-02f, 2.84814909e-02f, 3.04070096e-02f, 2.18247492e-02f, -7.69096240e-02f, -9.26860273e-02f, 5.81658445e-02f, 1.41060889e-01f,
  1.01021342e-01f, 4.93977033e-02f, 1.00779057e-01f, 1.42706204e-02f, -4.87030521e-02f, -4.89185285e-03f, -6.16717339e-02f, -8.52467120e-02f, 6.17041588e-02f, 2.22114641e-02f,
  2.02606320e-02f, 1.06251076e-01f, 2.66266335e-02f, -3.03403866e-02f, 1.59947239e-02f, 3.19517031e-02f, 8.35464597e-02f, 5.75776957e-02f, -7.16923922e-02f, -5.49147613e-02f,
  1.97819676e-02f, 6.64736852e-02f, 8.42756182e-02f, 5.07981107e-02f, 2.35809628e-02f, 5.44699142e-03f, 2.05008499e-02f, -4.16653752e-02f, 4.22099829e-02f, 4.80899867e-03f,
  1.54205665e-01f, 3.53214562e-01f, -4.78167161e-02f, 4.09029499e-02f, -2.25840718e-01f, -3.41447413e-01f, -1.83745757e-01f, -1.30715758e-01f, -6.11909032e-02f, 2.35708639e-01f,
  3.85852605e-02f, 1.58564523e-01f, 1.40328199e-01f, 1.40037537e-02f, -4.46330130e-01f, -1.26528665e-01f, -2.13281974e-01f, 1.94960330e-02f, 3.24620716e-02f, 5.01116589e-02f,
  -2.87708063e-02f, -5.23638576e-02f, -5.72401509e-02f, -3.86825837e-02f, -2.83497712e-03f, 1.96071640e-01f, -1.06138684e-01f, -8.15271065e-02f, 3.46283093e-02f, -5.79867549e-02f,
  1.24103323e-01f, 2.08392382e-01f, -4.02563401e-02f, 1.45940613e-02f, -1.00628108e-01f, 6.48410469e-02f, 1.01487748e-01f, -2.84809545e-02f, 1.59735251e-02f, -1.93440411e-02f,
  8.81777257e-02f, 1.78076904e-02f, -6.26845509e-02f, 9.78929643e-03f, 1.04322426e-01f, 8.00625831e-02f, -5.71663864e-02f, 4.29244479e-03f, 3.30062471e-02f, 9.99935064e-03f,
  -9.03337598e-02f, 1.43519491e-02f, 1.36806164e-02f, -1.13428140e-03f, -2.09774636e-02f, -2.37284321e-02f, 3.33440467e-03f, -1.05646960e-02f, 5.15361950e-02f, -4.12027352e-02f,
  -1.08303279e-02f, 1.46965764e-03f, -3.82860787e-02f, 4.78304364e-02f, -2.27195341e-02f, 3.09001952e-02f, 1.09485500e-01f, 7.87304938e-02f, 1.85277853e-02f, 7.11625442e-02f,
  -1.11923032e-02f, 1.08918371e-02f, 3.93588515e-03f, 1.13210976e-02f, 7.07322955e-02f, 7.15666264e-02f, 7.84066543e-02f, 5.51868938e-02f, -1.11093022e-01f, 9.28663369e-03f,
  3.54987755e-02f, -8.27424675e-02f, -6.52238354e-02f, 7.87528306e-02f, -6.91768527e-02f, -1.14324830e-01f, -1.51519210e-03f, 2.50850897e-02f, -1.13974130e-02f, -1.20812058e-02f,
  1.50994167e-01f, 7.28039891e-02f, 2.63759419e-02f, 1.03727065e-01f, 8.42346400e-02f, -1.29543260e-01f, 1.16256503e-02f, -1.18575841e-01f, 4.83119339e-02f, -3.71416472e-02f,
  -5.86583763e-02f, 4.98210900e-02f, -4.35268171e-02f, -5.44717163e-03f, 3.32721137e-03f, -1.98535547e-01f, 1.15600228e-01f, 4.93571311e-02f, 3.79353389e-02f, 7.12595209e-02f,
  2.16609500e-02f, 1.25922292e-01f, -1.42304683e-02f, -1.62597410e-02f, -6.30147830e-02f, -5.24211116e-03f, -4.30278629e-02f, -4.27808575e-02f, -2.86439545e-02f, -1.70142893e-02f,
  -4.02874470e-01f, 4.72757936e-01f, 4.26389873e-01f, 5.81285283e-02f, -4.32313651e-01f, 2.34686688e-01f, 1.52322322e-01f, 9.58272815e-03f, 2.38252152e-02f, 2.74122298e-01f,
  -1.32452786e-01f, 1.74167544e-01f, 1.01399310e-01f, 2.51440197e-01f, -5.87004423e-02f, 2.99523592e-01f, 2.44361952e-01f, 1.43961832e-01f, 5.86072274e-04f, -3.30320261e-02f,
  -1.93054019e-03f, -1.19878687e-01f, 2.16647714e-01f, -5.10216057e-02f, 1.84885354e-03f, 9.15151089e-03f, -3.00337642e-01f, -6.63035661e-02f, -5.32759838e-02f, -9.50006321e-02f,
  -3.03144976e-02f, -1.04557410e-01f, 9.26058888e-02f, 5.23741469e-02f, -1.24755362e-02f, -2.88775600e-02f, 3.98944737e-03f, -2.86470056e-02f, -3.71067040e-02f, 8.72180164e-02f,
  4.22445312e-02f, -1.17505349e-01f, -5.75935394e-02f, 4.60671037e-02f, 1.89087186e-02f, 5.53778410e-02f, 1.41592786e-01f, 1.71057180e-01f, 3.55071612e-02f, 6.29999563e-02f,
  1.37096629e-01f, 9.53449905e-02f, 6.20224252e-02f, 4.18102220e-02f, 6.24325313e-02f, 8.56618062e-02f, 3.84138450e-02f, -2.76307594e-02f, 2.53163418e-03f, -7.89704025e-02f,
  -3.83946672e-02f, -6.13655262e-02f, -4.77114646e-03f, -3.06258239e-02f, 2.90532336e-02f, -1.08427867e-01f, 8.87089521e-02f, -3.95763703e-02f, 7.52886385e-03f, -3.26410048e-02f,
  -9.17814746e-02f, -4.46313806e-02f, -6.57948926e-02f, 2.42476240e-02f, -6.47846162e-02f, -3.46489213e-02f, 8.91639888e-02f, -3.67487185e-02f, -1.15738930e-02f, -7.78886154e-02f,
  2.34624860e-03f, 3.15568522e-02f, 3.19143233e-04f, -5.34067303e-02f, 5.75617701e-02f, 5.08335605e-02f, 4.82527465e-02f, 5.44147119e-02f, 4.64149602e-02f, -1.20075643e-01f,
  -5.45363799e-02f, 8.32255185e-02f, -3.13201845e-02f, -3.26508954e-02f, 4.74084727e-02f, 1.38451136e-03f, 8.67158920e-02f, 3.69713386e-03f, 6.64260313e-02f, -9.64131355e-02f,
  -3.91822383e-02f, 1.59699675e-02f, -5.53125404e-02f, -2.64722556e-02f, 1.60986595e-02f, -7.32299266e-03f, -6.24570884e-02f, -1.73301231e-02f, -3.43058631e-02f, -4.84042540e-02f,
  -1.05404802e-01f, -6.01362921e-02f, -4.65576909e-02f, -3.91051061e-02f, -7.26191700e-02f, -7.72539377e-02f, -8.01841989e-02f, 2.42612343e-02f, -3.02432384e-02f, 8.50981176e-02f,
  4.84812945e-01f, -2.80227453e-01f, 5.62883131e-02f, -5.26829716e-03f, 2.41822749e-01f, 2.47755140e-01f, 2.85198420e-01f, 1.88764147e-02f, -1.11697149e-02f, -1.64110914e-01f,
  1.47395045e-01f, 1.46690970e-02f, -1.13729171e-01f, 1.10619783e-01f, 2.45513439e-01f, -2.16251522e-01f, 9.26205516e-02f, 1.05854891e-01f, -9.16549191e-02f, 8.26324821e-02f,
  4.78867209e-04f, 1.19657159e-01f, -5.04348241e-03f, -1.59751728e-01f, 2.60021359e-01f, -8.94764885e-02f, -1.17118210e-01f, -1.21844701e-01f, 9.67498124e-02f, 1.46862045e-01f,
  2.02213690e-01f, -4.13151868e-02f, 8.82806703e-02f, 3.84593271e-02f, 1.61636502e-01f, 7.18048587e-02f, 2.16071848e-02f, 8.69416725e-03f, 3.17994021e-02f, 8.61556679e-02f,
  3.03551331e-02f, 5.68801947e-02f, 1.86002497e-02f, -3.40881571e-02f, -7.56073231e-03f, -6.30481392e-02f, -1.09336907e-02f, 7.54625574e-02f, -4.15459182e-03f, 6.94543421e-02f,
  -2.70520318e-02f, 1.47577012e-02f, -4.56991754e-02f, -6.20969944e-02f, -2.40454394e-02f, 5.11511788e-02f, 2.81853583e-02f, 6.32857308e-02f, 2.48427037e-02f, -3.78616329e-04f,
  -5.03992103e-02f, -9.64825526e-02f, -5.38746938e-02f, -7.83986598e-03f, -7.26571977e-02f, 3.32273580e-02f, -4.71440181e-02f, 5.83308842e-03f, -7.39599243e-02f, -3.57881412e-02f,
  5.60047626e-02f, -1.11045158e-02f, -3.40555198e-02f, -6.23275824e-02f, -8.06636829e-03f, 2.60713119e-02f, 5.65272383e-02f, 1.40249426e-03f, 2.77778208e-02f, 7.91145787e-02f,
  -7.48347938e-02f, 2.26630573e-03f, -6.13595499e-03f, 5.59422523e-02f, -1.25690205e-02f, -1.49981342e-02f, -1.30039707e-01f, -6.88961744e-02f, 6.77299406e-03f, 4.12452333e-02f,
  1.35487929e-01f, -2.87278146e-01f, -5.85989654e-02f, 6.52456656e-02f, -5.41391075e-02f, -3.98300476e-02f, -6.54952675e-02f, -5.19267889e-03f, -1.00863859e-01f, -1.37390057e-02f,
  1.24848774e-02f, 1.99985621e-03f, -2.95896344e-02f, 2.48327386e-03f, -4.15171357e-03f, 3.16483788e-02f, 4.82389070e-02f, -2.85066571e-02f, 6.13607951e-02f, -7.57894898e-03f,
  -1.68088507e-02f, 3.12886247e-03f, -8.56861845e-02f, 3.61245088e-02f, 3.54472105e-03f, -3.36064696e-02f, 6.28310442e-02f, -7.40406569e-03f, -3.30088921e-02f, -5.76344803e-02f,
  -3.25762242e-01f, 6.32736906e-02f, -5.23885600e-02f, -2.50905991e-01f, -4.07879241e-02f, 1.17813215e-01f, 3.95876355e-02f, -1.15271881e-01f, -1.97234266e-02f, 9.73367989e-02f,
  4.38991562e-02f, 2.09898837e-02f, 1.54725090e-01f, 2.28226990e-01f, 1.90379232e-01f, 3.38595599e-01f, 4.01114635e-02f, 5.78103997e-02f, 1.25550196e-01f, -2.65104324e-01f,
  -1.99456081e-01f, 1.22382408e-02f, 4.71486785e-02f, -9.23711732e-02f, -1.71029240e-01f, -1.47479236e-01f, -1.88466743e-01f, -1.33882433e-01f, 3.80426347e-02f, 1.98929161e-01f,
  1.39334546e-02f, -2.61636585e-01f, -1.85465366e-02f, -1.19328010e-03f, -3.54472436e-02f, -3.30113769e-02f, 2.31486801e-02f, 7.37716258e-02f, 2.32359730e-02f, 4.04057372e-03f,
  2.69490927e-02f, -2.03425940e-02f, 3.94660793e-02f, 5.52075841e-02f, -2.50138752e-02f, 8.44781566e-03f, 1.25781789e-01f, 9.13168117e-02f, 2.26784386e-02f, -6.87203510e-03f,
  -6.93682358e-02f, 9.45891887e-02f, -2.99758390e-02f, -4.00641710e-02f, -6.68087676e-02f, -9.27976333e-03f, -1.17836125e-01f, -7.14043975e-02f, 1.08936347e-01f, -9.61950496e-02f,
  6.14445133e-04f, 3.77866114e-03f, 5.90122901e-02f, 3.72517370e-02f, 4.53893235e-03f, -9.57963914e-02f, 1.21930398e-01f, 7.17308596e-02f, 6.24314547e-02f, -2.52087694e-02f,
  -1.10135367e-02f, -4.02247049e-02f, 1.89611539e-02f, -2.37326883e-02f, 1.41850328e-02f, 4.83776722e-03f, 3.17836530e-03f, -6.60012886e-02f, -7.44236931e-02f, 9.96656343e-02f,
  5.05578564e-03f, 3.92067134e-02f, -2.05277219e-01f, 5.70913889e-02f, 9.48612317e-02f, 2.77650375e-02f, -5.55089638e-02f, -3.88789959e-02f, 6.08159788e-02f, 4.11713421e-02f,
  -1.67710111e-01f, -4.09158945e-01f, 5.56043796e-02f, -9.89160240e-02f, 1.43467396e-01f, 2.58787982e-02f, 1.33884490e-01f, -2.02469751e-02f, -1.60164028e-01f, 2.65440089e-03f,
  -8.13582093e-02f, -5.59037775e-02f, -7.35633597e-02f, 1.93716288e-02f, 2.17795968e-02f, -8.70826244e-02f, -9.98245776e-02f, -1.93487719e-01f, -3.48253883e-02f, -2.95607038e-02f,
  -1.50604412e-01f, -1.54033720e-01f, 1.13085084e-01f, -8.63256603e-02f, -8.78764316e-02f, -1.77110862e-02f, -1.33435145e-01f, -1.10000208e-01f, 2.73214672e-02f, -4.06412072e-02f,
  -3.95234287e-01f, -4.29996639e-01f, 3.71859483e-02f, 2.11819564e-03f, -1.82418093e-01f, 8.62055868e-02f, 2.24473685e-01f, -1.64992824e-01f, -4.90723640e-01f, -6.87659904e-02f,
  1.15106255e-01f, -1.21406302e-01f, 1.32103935e-01f, -1.05662599e-01f, 2.31709108e-01f, -1.30786106e-01f, 9.78400633e-02f, 1.15159318e-01f, -2.27694035e-01f, 2.01726913e-01f,
  -2.74396073e-02f, 1.09689966e-01f, 2.89280981e-01f, 3.74894999e-02f, 3.58293392e-02f, 8.03191066e-02f, 3.63259852e-01f, -3.94467339e-02f, 1.16118833e-01f, -2.27643311e-01f,
  -5.02056293e-02f, -2.01631233e-01f, 8.65218043e-02f, -4.24379222e-02f, 9.61356461e-02f, 3.15339230e-02f, 1.43680140e-01f, 2.69205719e-02f, -1.03972033e-01f, 1.01370499e-01f,
  9.27693024e-03f, -1.25721440e-01f, -5.46914153e-02f, -4.75118719e-02f, -1.08209789e-01f, -7.43853766e-03f, -9.05730352e-02f, 2.05377303e-02f, -1.76848415e-02f, -4.22750376e-02f,
  2.16730535e-02f, 4.40794863e-02f, 2.86881849e-02f, 4.49342765e-02f, 4.74855043e-02f, -2.48636249e-02f, 1.97253916e-02f, 1.21726342e-01f, -1.00138381e-01f, 4.33803797e-02f,
  3.02241836e-02f, -1.30225923e-02f, -4.32099439e-02f, -2.89187767e-02f, -2.86792312e-02f, -5.42084649e-02f, -1.17384091e-01f, -1.36794019e-02f, -9.61986259e-02f, 4.44523096e-02f,
  1.14567973e-01f, -7.64479041e-02f, -1.24114558e-01f, 5.59708066e-02f, 2.20298134e-02f, 1.47091681e-02f, 1.11085288e-01f, 1.62748992e-03f, 7.78423622e-02f, 4.57044542e-02f,
  -1.19418360e-01f, -3.19866999e-03f, -5.20328619e-03f, 5.56999668e-02f, -1.69132687e-02f, 9.46667939e-02f, -4.05798182e-02f, -2.41416879e-02f, 1.28518984e-01f, 6.72458485e-02f,
  1.24389783e-01f, -5.80485798e-02f, -5.91417355e-03f, 9.57228914e-02f, -7.95036834e-03f, 2.19680388e-02f, -6.72700182e-02f, -7.74159431e-02f, 1.12365536e-01f, 2.86428481e-02f,
  1.27803549e-01f, 1.34326383e-01f, 4.35889848e-02f, 2.74879783e-02f, 2.82686688e-02f, 6.36846945e-02f, 4.19816189e-02f, 4.28550951e-02f, 1.16866514e-01f, 1.10972926e-01f,
  1.31859303e-01f, 1.14853159e-01f, -1.25621229e-01f, 1.25307851e-02f, 3.91374342e-02f, 7.16896877e-02f, 2.37093046e-02f, -5.82913496e-02f, -4.03360799e-02f, -1.47850839e-02f,
  3.58690828e-01f, 1.78711265e-01f, -1.36930551e-02f, 2.41994008e-01f, 6.71691522e-02f, -7.76966102e-04f, -1.11639619e-01f, 3.07818323e-01f, 2.33833417e-01f, 2.50450950e-02f,
  1.13341838e-01f, 3.92860509e-02f, -1.67552546e-01f, 8.42863172e-02f, -5.69217876e-02f, -3.09908420e-01f, 1.96531773e-01f, 8.15883204e-02f, 5.05216643e-02f, 1.96034744e-01f,
  5.14623336e-02f, 3.24381702e-02f, 5.08905426e-02f, 3.71433310e-02f, 2.26760849e-01f, 2.17039600e-01f, 9.73732397e-02f, -1.32379904e-01f, 3.28994095e-02f, -8.65915194e-02f,
  7.26629794e-02f, 2.33554333e-01f, 1.79704368e-01f, 1.68487113e-02f, 1.31644651e-01f, -9.39114951e-03f, 5.15582636e-02f, -9.77136716e-02f, -6.83920011e-02f, -1.34627130e-02f,
  -6.18266687e-02f, 1.65724345e-02f, -5.44353761e-03f, -1.23404317e-01f, 8.57232958e-02f, 8.92296508e-02f, 7.90468752e-02f, 6.94746897e-02f, 3.54407988e-02f, -2.04153843e-02f,
  4.10178415e-02f, 8.39077309e-02f, 1.46305963e-01f, -8.10457952e-03f, 5.20768873e-02f, 2.51682959e-02f, -4.61876094e-02f, -1.39589626e-02f, 1.17724843e-01f, 1.04727462e-01f,
  1.70614254e-02f, -8.15486982e-02f, 1.06948704e-01f, -8.92552212e-02f, -2.62389798e-02f, -6.45841062e-02f, -8.59039277e-03f, -4.57285307e-02f, 6.65409863e-02f, 9.12447050e-02f,
  -3.84515524e-02f, 1.50269672e-01f, 8.93384293e-02f, 1.54666472e-02f, 5.86092249e-02f, 3.15661728e-02f, -1.75009202e-02f, -2.97324127e-03f, 3.99316801e-03f, 5.98176606e-02f,
  -1.65300500e-02f, 3.19856703e-02f, 3.45489639e-03f, 2.44281348e-02f, 6.73518553e-02f, -4.20183353e-02f, 2.09507719e-02f, 1.19357444e-01f, -2.32258923e-02f, -3.23940106e-02f,
  1.91391304e-01f, 2.06645221e-01f, 8.15399438e-02f, 1.05418295e-01f, 5.29436059e-02f, 6.65083379e-02f, -6.39962330e-02f, -5.04528359e-03f, 1.10002821e-02f, -2.57410221e-02f,
  4.27968763e-02f, 1.22994054e-02f, 7.38192350e-02f, -2.37325532e-03f, -5.04055098e-02f, 1.15988113e-01f, -2.29499978e-03f, -4.20866869e-02f, 6.60081580e-02f, 1.10842809e-01f,
  1.00444041e-01f, -7.87022561e-02f, -7.18038827e-02f, 1.06998302e-01f, 1.15245003e-02f, 1.40147492e-01f, -8.03010259e-03f, 2.92554777e-02f, -1.78898480e-02f, -4.54868414e-02f,
  2.48251110e-02f, 2.36934453e-01f, 2.93882042e-01f, 1.55820027e-01f, 1.59415230e-01f, -2.71927923e-01f, -7.18077719e-02f, 1.53320208e-01f, 7.06168860e-02f, -2.69634366e-01f,
  -4.23096977e-02f, 6.80959523e-02f, 1.12798043e-01f, -9.76189971e-02f, 5.09633683e-02f, -1.77037999e-01f, -7.73105621e-02f, -4.25284393e-02f, 1.80174246e-01f, 1.59982800e-01f,
  9.71195325e-02f, -2.76774466e-01f, 2.24936858e-01f, -9.95207131e-02f, 1.01239540e-01f, 1.01299703e-01f, -7.13872090e-02f, 1.89164519e-01f, -1.00638315e-01f, -8.13655704e-02f,
  9.37800482e-03f, 1.75749272e-01f, 1.31177530e-01f, -5.45251667e-02f, 1.13839649e-01f, -8.75627697e-02f, -4.22131643e-02f, 3.64506468e-02f, 2.74623297e-02f, 6.08949289e-02f,
  -5.55020161e-02f, -4.68440726e-02f, -9.21203867e-02f, -6.74129352e-02f, -3.25212963e-02f, 6.25110865e-02f, 9.30734351e-02f, 7.02132136e-02f, 1.60857309e-02f, 9.12282318e-02f,
  1.31395087e-01f, 6.37787953e-02f, 5.46608679e-02f, -9.71192718e-02f, 8.38459581e-02f, 4.56865616e-02f, -2.47430950e-02f, 1.34105235e-01f, 5.38854413e-02f, 4.04591039e-02f,
  3.33163375e-03f, -1.68629736e-02f, 8.82440507e-02f, 7.74621442e-02f, 1.52783785e-02f, -7.78756440e-02f, -3.76584791e-02f, -1.11965192e-02f, 1.15106096e-02f, 3.01737841e-02f,
  -7.51438960e-02f, 6.77056164e-02f, -8.30909461e-02f, -9.40164030e-02f, 5.68903275e-02f, -2.97695268e-02f, -3.52804437e-02f, 5.03012910e-02f, 5.36592305e-02f, 1.88205205e-03f,
  5.07162977e-03f, -5.84203601e-02f, 9.58828032e-02f, 9.85447690e-02f, -7.49124885e-02f, -5.10564074e-03f, -2.49909218e-02f, 4.73964699e-02f, 6.34330371e-03f, 1.65605508e-02f,
  7.13294372e-02f, 1.05731994e-01f, 2.46098433e-02f, -8.18649903e-02f, -3.76690738e-02f, -5.84563846e-03f, 3.74876745e-02f, 5.18476292e-02f, 4.62403446e-02f, -3.10057309e-02f,
  -1.95591263e-02f, -3.44543345e-02f, -1.34521751e-02f, -8.42260569e-02f, 3.40729952e-02f, 5.04290536e-02f, 4.45317142e-02f, -9.11062881e-02f, 2.45430712e-02f, 3.06822220e-03f,
  -6.32223263e-02f, -5.76399378e-02f, -1.01035507e-02f, -9.08677876e-02f, -9.92702097e-02f, -3.76166281e-04f, -1.09174117e-01f, -2.96853017e-02f, 1.05068401e-01f, -5.57245351e-02f,
  1.01730436e-01f, 1.62364051e-01f, -4.25184742e-02f, 3.57536852e-01f, -2.09345669e-01f, -3.43478054e-01f, -1.43758729e-01f, 5.29116653e-02f, 2.64071763e-01f, 2.02912420e-01f,
  1.72394127e-01f, -6.32884949e-02f, 1.64363667e-01f, 1.97033256e-01f, -1.74681798e-01f, 1.51722714e-01f, -1.13142943e-02f, 4.02041711e-02f, 3.59314159e-02f, 5.30372411e-02f,
  9.00933668e-02f, 1.46531075e-01f, 2.39054859e-02f, -8.55505317e-02f, -8.30091238e-02f, -5.01671582e-02f, 1.41170844e-01f, -1.34608224e-01f, -1.38970658e-01f, -1.66487366e-01f,
  -3.79133597e-02f, 2.38665745e-01f, -5.76846637e-02f, -9.29200724e-02f, 5.80609404e-02f, -6.79407194e-02f, -6.02548346e-02f, -1.55743644e-01f, -7.33336955e-02f, -1.50017701e-02f,
  -1.32861063e-02f, -1.02415703e-01f, 4.94666025e-02f, 6.17425814e-02f, -5.22502847e-02f, -8.85452405e-02f, -4.36220206e-02f, -3.41894329e-02f, -7.10851550e-02f, -2.15807036e-02f,
  1.16916420e-02f, -1.09864257e-01f, -1.72624532e-02f, 2.26752926e-02f, -6.94167390e-02f, -4.29619439e-02f, 1.59551650e-02f, -6.94651827e-02f, -2.22651102e-02f, -4.46309112e-02f,
  2.77109211e-03f, 5.47905825e-03f, 5.58532998e-02f, 2.54001375e-02f, 2.21084803e-02f, 1.32960686e-02f, -9.18638706e-02f, -6.35427907e-02f, 4.86031435e-02f, -1.95419453e-02f,
  -1.08989559e-01f, 6.46019131e-02f, 1.01914052e-02f, 2.58251326e-03f, -4.67564724e-03f, 4.35451232e-02f, -7.28295445e-02f, 3.31782736e-02f, 3.15686762e-02f, 2.11735312e-02f,
  -7.82629848e-03f, -1.54018570e-02f, 4.81549390e-02f, -1.14544526e-01f, -7.11419359e-02f, 3.44107598e-02f, 3.16819325e-02f, 6.28956035e-02f, 5.26161231e-02f, -7.43153021e-02f,
  3.13421078e-02f, 2.91003227e-01f, 7.76785016e-02f, 1.55803943e-02f, 7.14513063e-02f, -1.38720814e-02f, 2.29101833e-02f, 4.13694531e-02f, -1.94562729e-02f, -1.79971363e-02f,
  -3.68282534e-02f, -7.10214078e-02f, -3.45566235e-02f, -4.02363352e-02f, -3.88185047e-02f, 1.02852166e-01f, 8.17017555e-02f, 4.30042595e-02f, -2.02501062e-02f, -5.12713566e-04f,
  -6.11662772e-03f, 3.13150808e-02f, 6.28888756e-02f, 3.14727761e-02f, -1.53768389e-02f, 3.44278365e-02f, 1.07264109e-02f, -4.11738195e-02f, -3.23391147e-02f, -5.32246828e-02f,
  1.67019665e-01f, 1.66325405e-01f, 2.24824071e-01f, 1.49211720e-01f, -1.07973062e-01f, -1.30963609e-01f, 2.06244618e-01f, -3.81008722e-02f, 2.91015625e-01f, 8.60921368e-02f,
  -9.11620259e-02f, 3.32922608e-01f, -1.36759840e-02f, -1.16097052e-02f, -2.33622894e-01f, -2.50662901e-02f, -2.98375010e-01f, -1.09786302e-01f, -6.99943900e-02f, -2.05327749e-01f,
  -1.28108144e-01f, -4.04064834e-01f, -2.31692463e-01f, -3.42281848e-01f, -1.96675628e-01f, 5.35306986e-03f, -2.99170524e-01f, -5.16183721e-03f, -2.51477808e-01f, -1.32246688e-02f,
  9.74630471e-03f, 8.87199342e-02f, 1.57728046e-01f, 6.14583418e-02f, -1.82009220e-01f, 2.50222627e-02f, -1.35306314e-01f, 6.12158254e-02f, 7.38147050e-02f, 6.12711124e-02f,
  1.01098239e-01f, -4.46592309e-02f, -5.34101129e-02f, 9.18156058e-02f, 1.29586756e-01f, 4.90453541e-02f, 6.75058514e-02f, -1.20400183e-01f, 8.24655145e-02f, 4.57461104e-02f,
  2.90147774e-02f, 5.32957911e-02f, 6.17087148e-02f, -3.44876945e-03f, 1.29302740e-02f, 5.00798039e-02f, 6.65382892e-02f, 9.72978696e-02f, 3.47239859e-02f, 1.30117223e-01f,
  -5.04567996e-02f, -5.59464768e-02f, -1.28422096e-01f, 2.13052314e-02f, -2.04923507e-02f, 5.76437749e-02f, 2.78208754e-03f, -4.38458696e-02f, 4.27887663e-02f, -2.72523649e-02f,
  -5.32007664e-02f, 2.65470855e-02f, 4.37631421e-02f, -2.19824295e-02f, 2.90070269e-02f, 1.14747740e-01f, 1.41960839e-02f, -3.48469019e-02f, -2.14224905e-02f, -7.05530420e-02f,
  2.88473908e-02f, -2.42449827e-02f, -7.33124390e-02f, -7.46677397e-03f, 1.56573802e-02f, 5.61820455e-02f, -3.07491478e-02f, 4.09645773e-02f, 6.02731807e-03f, -1.40790150e-01f,
  -1.48689881e-01f, -1.95874855e-01f, 2.82374420e-03f, 1.26692327e-02f, -5.95389679e-03f, -3.50952819e-02f, -1.95291303e-02f, -6.14648163e-02f, -9.44048390e-02f, -1.00151107e-01f,
  -4.73352037e-02f, -4.17389534e-02f, -3.48222372e-03f, -3.47917080e-02f, -1.28165290e-01f, 6.39733523e-02f, -1.02202229e-01f, 1.42355356e-03f, -1.06992573e-01f, -5.11819683e-02f,
  -1.05709389e-01f, -1.02658235e-01f, 1.47917345e-02f, -9.01661962e-02f, -5.66416681e-02f, -3.03078555e-02f, -9.29757836e-04f, 5.76813035e-02f, -1.45695731e-01f, 1.58500355e-02f,
  -1.35231614e-01f, 2.66897529e-01f, 9.23006088e-02f, 2.09198341e-01f, -3.00358117e-01f, 5.17619774e-02f, -7.02757835e-02f, -1.50865763e-01f, 6.39026985e-02f, 1.77752435e-01f,
  -2.72842824e-01f, 1.86096042e-01f, -2.10003302e-01f, 3.27517599e-01f, -1.36767447e-01f, 1.62067354e-01f, 2.86450505e-01f, 1.47166118e-01f, 1.07092157e-01f, -4.36772630e-02f,
  5.01570702e-02f, -1.29063174e-01f, 1.43228412e-01f, -1.02359213e-01f, -8.64546522e-02f, 9.72456113e-02f, -1.47985235e-01f, -1.27121449e-01f, 1.48640677e-01f, -5.18202223e-02f,
  -1.27247855e-01f, 1.13853263e-02f, 1.09733287e-02f, -5.64963818e-02f, -1.15496688e-01f, -4.19138707e-02f, -4.40357067e-02f, -5.03376424e-02f, 3.16401874e-03f, 2.60717259e-03f,
  2.96607451e-03f, 6.29331693e-02f, 9.25165787e-02f, -3.65947708e-02f, -3.35214548e-02f, 5.02243219e-03f, 1.35346577e-01f, 7.19752982e-02f, 2.18792092e-02f, 7.59322494e-02f,
  7.19027519e-02f, 1.51705667e-01f, 1.26913890e-01f, 3.09183747e-02f, -6.26078397e-02f, 7.97675699e-02f, 6.58028573e-02f, -3.03357225e-02f, 4.20601107e-02f, 8.34382325e-03f,
  3.36329080e-03f, -5.89394346e-02f, 2.37549702e-03f, 2.43368000e-03f, -9.14971828e-02f, 3.12920399e-02f, 6.89112842e-02f, 4.19492871e-02f, -3.04460675e-02f, -5.17904237e-02f,
  -9.35309101e-03f, 5.62413745e-02f, -7.05887564e-03f, 4.70545217e-02f, 2.55435202e-02f, 1.19780920e-01f, -3.37786637e-02f, 1.11261550e-02f, -1.10668279e-02f, -1.23715233e-02f,
  -9.06169042e-03f, -1.10522914e-03f, -8.07038322e-02f, -2.47176234e-02f, -4.77847783e-03f, -1.62699714e-01f, 3.25152986e-02f, 2.98030004e-02f, -3.94404121e-02f, -3.76772843e-02f,
  -1.33603051e-01f, -3.46104242e-02f, 1.08455280e-02f, -4.02270816e-02f, 4.65352871e-02f, 3.44825238e-02f, 1.30836964e-01f, 5.79982065e-03f, -3.28579620e-02f, -6.68864101e-02f,
  1.71309169e-02f, -1.04930932e-02f, -3.32465507e-02f, 3.75376432e-03f, -4.19516154e-02f, -1.58257172e-01f, -3.99755612e-02f, -3.28060091e-02f, 4.22358699e-02f, -2.44502965e-02f,
  -7.61386082e-02f, -4.91975099e-02f, 1.81557667e-02f, -5.40713668e-02f, -4.06668521e-02f, -5.81858829e-02f, 7.90100731e-03f, 2.68757138e-02f, 2.16136687e-02f, 4.18463759e-02f,
  4.10331696e-01f, -1.90828457e-01f, -2.08730534e-01f, 1.08401798e-01f, 3.37699354e-01f, 3.59807342e-01f, 1.45257294e-01f, 4.61812392e-02f, 2.20576182e-01f, -2.48608500e-01f,
  -5.05097536e-03f, 4.22609709e-02f, -2.99254090e-01f, 1.55899627e-02f, 1.36369765e-01f, -1.89144582e-01f, -1.16033768e-02f, 1.47346511e-01f, 1.05670772e-01f, 1.12209298e-01f,
  6.08481392e-02f, 3.65296640e-02f, -1.66740894e-01f, -1.03697799e-01f, 2.37361252e-01f, 5.94574250e-02f, -2.07127124e-01f, -7.88140893e-02f, -2.10190397e-02f, 9.24857482e-02f,
  1.21085100e-01f, 6.81786565e-03f, -4.31372821e-02f, 9.15733539e-03f, 5.86624220e-02f, 1.20861400e-02f, 3.87006737e-02f, -7.86547083e-03f, 5.27527519e-02f, -1.06293419e-02f,
  -3.07656787e-02f, 7.92051703e-02f, 4.86996099e-02f, -6.78181499e-02f, 7.06404075e-02f, 2.28045904e-03f, 7.75032490e-02f, 7.77887776e-02f, -2.37879921e-02f, 7.93856308e-02f,
  1.96009148e-02f, -2.19956972e-02f, -5.73449284e-02f, 4.43842262e-03f, -1.40478099e-02f, 5.17599545e-02f, 6.21790364e-02f, 8.90553091e-03f, 3.40123065e-02f, 8.37427303e-02f,
  1.97288562e-02f, -9.10106748e-02f, -1.11814253e-01f, -1.78278349e-02f, -9.21303593e-03f, 4.39756326e-02f, -1.03231870e-01f, 4.04806659e-02f, -2.70038284e-02f, 6.95578530e-02f,
  4.14563157e-02f, -1.87009163e-02f, 6.99089793e-03f, 2.27627158e-03f, -3.49603333e-02f, 3.97351347e-02f, -5.61005548e-02f, 8.10428411e-02f, 2.53844447e-02f, -4.66542505e-02f,
  -4.17550243e-02f, 9.69474018e-02f, -6.77719787e-02f, 1.27392597e-02f, 5.91901466e-02f, -6.23768307e-02f, -9.95279104e-02f, 5.48074907e-03f, -2.76301410e-02f, -3.38550210e-02f,
  1.23217896e-01f, -5.77657111e-02f, -2.74721403e-02f, 1.00666352e-01f, -4.07459214e-02f, -1.81717146e-02f, -9.38874036e-02f, 1.11495052e-02f, 3.17661650e-02f, -2.25037825e-03f,
  1.78496577e-02f, 3.90555081e-03f, 4.62875441e-02f, 5.45812622e-02f, -1.22362310e-02f, -1.00729965e-01f, 5.36270887e-02f, -1.30880428e-02f, -1.27812913e-02f, -3.29770930e-02f,
  -7.92084448e-03f, 7.55734295e-02f, 4.05395366e-02f, 4.75643016e-02f, 7.00527430e-02f, 5.47426380e-02f, 2.08794810e-02f, 1.50843319e-02f, 3.88698420e-03f, -4.98853847e-02f,
  2.46439964e-01f, -4.12117630e-01f, -2.06311792e-01f, -5.68069294e-02f, 3.59824002e-02f, 7.01891631e-03f, -1.64699063e-01f, -1.40891448e-01f, -1.99452013e-01f, 3.25044394e-02f,
  -1.16088562e-01f, -5.31418361e-02f, -2.62189090e-01f, -1.83680624e-01f, 3.86562288e-01f, -3.16712677e-01f, 1.02158785e-01f, -1.27647668e-01f, -1.92951962e-01f, 7.52023384e-02f,
  9.44499448e-02f, 2.17357740e-01f, 7.82805774e-03f, 1.63330764e-01f, 4.71377037e-02f, 5.74553981e-02f, 2.69930124e-01f, -1.04180932e-01f, 2.10714936e-01f, -1.19281793e-02f,
  -8.06699246e-02f, -1.72795057e-01f, -9.34636071e-02f, -1.30426809e-02f, 4.74415086e-02f, 4.13109399e-02f, 1.70103848e-01f, -5.89950196e-02f, -1.79121885e-02f, -4.34145369e-02f,
  -3.27511393e-02f, 1.39573485e-01f, 3.19671491e-03f, -3.91258039e-02f, -7.36510009e-02f, 1.97517383e-03f, 1.12919463e-02f, 3.36842635e-03f, -1.41887337e-01f, -1.02651365e-01f,
  -3.03372554e-03f, -6.74100369e-02f, 1.06257536e-01f, 2.76496336e-02f, 8.36608857e-02f, -4.03397307e-02f, -1.75022110e-02f, -1.93121973e-02f, 2.74007898e-02f, 5.19725382e-02f,
  1.04131801e-02f, -9.03711990e-02f, 9.52616055e-03f, -7.77526125e-02f, 6.69418043e-03f, -2.00059917e-02f, 1.02845840e-01f, 8.27890188e-02f, 2.10160073e-02f, 2.51461379e-02f,
  6.59100711e-02f, -6.71936795e-02f, -2.52950657e-02f, -3.82814580e-03f, -5.07886559e-02f, -2.58353259e-03f, 6.95455074e-02f, -1.29363872e-02f, 3.60867865e-02f, 4.46796268e-02f,
  -4.84104715e-02f, 4.61636670e-02f, -1.00051083e-01f, 3.73096671e-03f, 7.57655129e-04f, 5.75663941e-03f, 4.02494594e-02f, -1.42637184e-02f, -1.05364792e-01f, 4.45500538e-02f,
  -3.17232423e-02f, 4.07702252e-02f, -3.11761275e-02f, -5.66872582e-02f, -4.57147323e-02f, 7.97984228e-02f, -2.40149088e-02f, 9.80774127e-03f, 8.02691728e-02f, -3.75485905e-02f,
  1.42383069e-01f, -4.39940393e-02f, 1.27734646e-01f, 2.85927802e-02f, 1.49470910e-01f, 8.36047605e-02f, 5.44007868e-02f, -4.10095835e-03f, 1.91322953e-01f, 2.11958829e-02f,
  3.43122147e-02f, 7.54856989e-02f, 1.94295924e-02f, 1.01284958e-01f, 5.02634011e-02f, 1.18751451e-01f, 7.34213814e-02f, -5.01072221e-02f, 5.29091731e-02f, -2.90471297e-02f,
  -1.73837885e-01f, 1.85409248e-01f, -1.06003776e-01f, 2.07430288e-01f, 4.85964715e-02f, -3.92883629e-01f, -2.69651413e-01f, 1.40167385e-01f, -2.52742410e-01f, 1.59328535e-01f,
  1.84046209e-01f, -1.66399121e-01f, -5.61249852e-02f, 1.72490805e-01f, -4.62454408e-01f, -3.60835165e-01f, -7.11775851e-03f, -8.42967927e-02f, -1.77724138e-01f, 4.24865149e-02f,
  -5.12944022e-03f, 9.60458890e-02f, 1.32959619e-01f, 1.34260878e-01f, 2.37605497e-01f, 1.56684548e-01f, 1.81469128e-01f, -2.16374025e-02f, 3.36870998e-01f, -3.62193212e-02f,
  -1.93613842e-02f, 6.63442761e-02f, 1.07520409e-01f, 4.90452312e-02f, 1.50039671e-02f, 1.74339805e-02f, -7.31644779e-02f, -1.28925398e-01f, -1.73749309e-03f, 1.41501212e-02f,
  -4.70979285e-04f, -3.10044270e-02f, 4.59481478e-02f, 8.20172504e-02f, -5.40370494e-02f, 8.85552168e-02f, -5.41514670e-03f, 7.62059465e-02f, 6.49527609e-02f, -2.30961535e-02f,
  2.61470396e-02f, 7.67593011e-02f, -2.61165984e-02f, 1.38340518e-02f, 7.20386952e-02f, -1.54289557e-02f, -1.72429532e-01f, -1.59611292e-02f, -5.52085228e-02f, -1.79475710e-01f,
  -2.07111947e-02f, -9.64385569e-02f, -2.01122724e-02f, -2.98930947e-02f, -1.00579783e-02f, 9.13311094e-02f, 2.03168485e-02f, 1.52795333e-02f, -1.62086348e-04f, 6.41733110e-02f,
  1.08885868e-02f, 9.38646942e-02f, 3.56249139e-02f, 3.35744433e-02f, -1.18431607e-02f, -2.87847836e-02f, -8.91735330e-02f, -3.79260108e-02f, -1.45008555e-02f, -3.89129221e-02f,
  2.40213163e-02f, -5.11368476e-02f, 1.01661123e-01f, -3.18208215e-04f, -6.14809468e-02f, 8.15660879e-03f, 4.11129147e-02f, -2.80645788e-02f, -8.51908028e-02f, 2.29239627e-03f,
  2.43936423e-02f, -2.89638676e-02f, 2.38744467e-02f, 6.12327736e-03f, -1.02523185e-01f, 1.18793789e-02f, -5.38408896e-03f, 9.69373155e-03f, -6.75838664e-02f, -1.70760546e-02f,
  1.37826458e-01f, 1.22151271e-01f, -7.61510357e-02f, -7.06424518e-03f, -1.66256931e-02f, -1.05025716e-01f, -3.80457826e-02f, 3.83304469e-02f, 2.82423999e-02f, 6.61372244e-02f,
  2.08721057e-01f, -4.41365130e-02f, -6.62931725e-02f, -4.80719917e-02f, 7.53212497e-02f, 5.06708100e-02f, -1.17664687e-01f, 5.20649999e-02f, -7.27666169e-03f, -8.17489903e-03f,
  -3.44300091e-01f, 3.26154441e-01f, 3.27216446e-01f, -9.25322771e-02f, -2.06294075e-01f, 4.05025601e-01f, 4.03286964e-02f, 4.87481506e-04f, -3.45938712e-01f, 8.51501822e-02f,
  -1.36629045e-01f, 7.65786693e-02f, 4.27038968e-02f, 1.07141711e-01f, 1.85561031e-01f, 2.17341427e-02f, 1.23643361e-01f, 8.79313946e-02f, -1.57158375e-01f, 4.60772589e-02f,
  -3.13907079e-02f, -1.89866722e-01f, 1.79487616e-01f, -5.30374795e-02f, 1.03956230e-01f, -3.73399667e-02f, -1.16647676e-01f, 4.36253622e-02f, 2.42116928e-01f, 1.32341767e-02f,
  4.06766459e-02f, -1.09359913e-01f, 7.72259906e-02f, 7.92777836e-02f, 8.39053765e-02f, -1.06167607e-02f, 1.25773519e-01f, -2.07039621e-02f, -9.23610330e-02f, 2.44800318e-02f,
  2.03300789e-02f, -4.65272069e-02f, -8.89756903e-02f, -9.44356024e-02f, -8.67517814e-02f, 2.94611081e-02f, 3.99945192e-02f, 1.00937791e-01f, -1.87960956e-02f, 1.03915036e-01f,
  8.05839747e-02f, 9.72988680e-02f, 2.85658613e-02f, 1.59260053e-02f, -2.23677158e-02f, -4.99000065e-02f, 1.38730302e-01f, 3.46167833e-02f, 1.23811409e-01f, -3.93904373e-02f,
  -3.64609547e-02f, -3.64704132e-02f, 1.03250533e-01f, -3.39836106e-02f, 7.54065625e-03f, -7.40599558e-02f, -8.04533064e-02f, 5.77797890e-02f, -9.40744802e-02f, 2.14235224e-02f,
  -1.13250479e-01f, 3.73664722e-02f, -4.00220677e-02f, -3.53909358e-02f, -9.76802688e-03f, -1.95353106e-02f, 8.03797692e-02f, -2.44252086e-02f, -5.97784221e-02f, 6.07926808e-02f,
  -5.72207645e-02f, 3.25093046e-02f, 7.27715995e-03f, -1.43351592e-02f, 4.13105674e-02f, 1.11916857e-02f, -5.36518283e-02f, 2.91578807e-02f, -2.81811263e-02f, 2.85392273e-02f,
  2.35121340e-01f, 1.34217083e-01f, -8.61635432e-02f, -8.03593174e-02f, -5.59522770e-02f, 1.34016901e-01f, 3.24594192e-02f, 7.47968554e-02f, 6.26125857e-02f, -5.52555285e-02f,
  8.06535557e-02f, -1.66853480e-02f, 7.63159171e-02f, 1.05000585e-02f, 3.55782732e-02f, 4.93968874e-02f, 7.40904408e-03f, -6.56906962e-02f, 2.61456165e-02f, -1.56753678e-02f,
  -6.02095947e-02f, -5.21676578e-02f, -2.29078885e-02f, -3.94903421e-02f, -2.07500346e-03f, -6.70223013e-02f, 4.99780476e-02f, -1.14447854e-01f, 2.98050810e-02f, -4.60817665e-03f
};

// L0_fan_Wp_bar (Shape: 52 x 120)
const int L0_fan_Wp_bar_rows = 52;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -8.40140581e-01f, 4.04584557e-01f, 1.37456832e-02f, -9.20480415e-02f, -1.10877909e-01f, 1.62518561e-01f, 1.29714638e-01f, 1.43947124e-01f, 1.60978004e-01f, 3.33578259e-01f,
  -3.35675552e-02f, -2.78420150e-01f, 3.56285661e-01f, 2.45069921e-01f, -2.96761364e-01f, 4.19572324e-01f, 6.25015125e-02f, -5.85318841e-02f, 1.73171550e-01f, 2.36249119e-02f,
  -8.01886469e-02f, -1.23982774e-02f, 2.65022337e-01f, 1.59632981e-01f, -2.64678210e-01f, -1.44387856e-01f, -2.40130603e-01f, 1.63789958e-01f, -2.23642752e-01f, -1.42631084e-01f,
  -1.08654037e-01f, -2.23516896e-01f, -6.66471794e-02f, -1.28826007e-01f, -2.06297457e-01f, -1.22656465e-01f, -1.60573572e-01f, -7.70670325e-02f, 6.54261932e-02f, 1.42875798e-02f,
  -4.09817211e-02f, -3.35495956e-02f, -3.86358276e-02f, 2.91005597e-02f, -5.93420267e-02f, 2.91044600e-02f, 1.29712269e-01f, 2.39102431e-02f, 2.83411499e-02f, 1.88132618e-02f,
  9.81213078e-02f, 5.96793778e-02f, 5.76671511e-02f, -7.52141550e-02f, -1.77290186e-01f, 5.43448590e-02f, 9.52170715e-02f, -1.01552218e-01f, -5.29550612e-02f, -3.95940021e-02f,
  -5.79117686e-02f, 1.72331557e-01f, 9.16156024e-02f, -1.15956482e-03f, 1.04930028e-02f, 1.63716264e-02f, 2.07702424e-02f, 1.21676363e-02f, 4.24266905e-02f, 8.00132975e-02f,
  -1.13662571e-01f, -5.16324081e-02f, -3.27035263e-02f, 2.81681195e-02f, 8.97644162e-02f, -1.01176284e-01f, -1.80145481e-03f, 2.08477005e-02f, 8.62952787e-03f, -5.15302718e-02f,
  -3.10690026e-03f, 1.05629228e-02f, -1.81322359e-02f, 9.18151736e-02f, 1.77335348e-02f, -8.88963044e-03f, -1.02800399e-01f, 6.48832470e-02f, -4.32696827e-02f, -4.58009765e-02f,
  -1.75046340e-01f, -2.74953932e-01f, 5.22082113e-02f, -1.39230818e-01f, -1.16039149e-01f, 3.62872183e-02f, 3.92199717e-02f, -9.49846730e-02f, -4.22103815e-02f, -9.47837755e-02f,
  -3.09220180e-02f, -4.00190055e-02f, -1.04277827e-01f, 3.47467177e-02f, 1.98054947e-02f, 7.06556365e-02f, 1.70599371e-02f, -1.71788037e-02f, -1.48189038e-01f, -1.07981175e-01f,
  3.91840599e-02f, 4.26407019e-03f, 3.00388853e-03f, 6.99374303e-02f, -8.31712931e-02f, -8.51258710e-02f, -2.12153867e-01f, -4.08583544e-02f, -1.95110470e-01f, 8.81972462e-02f,
  -2.16978565e-01f, 7.78944939e-02f, -3.82335365e-01f, -2.38857865e-01f, -1.03813164e-01f, 2.30387896e-01f, 3.20690006e-01f, -7.55724609e-02f, -2.22947076e-01f, 4.58729923e-01f,
  2.98731655e-01f, -3.71332258e-01f, 1.48487091e-01f, 1.27958998e-01f, -4.82671082e-01f, 1.40451685e-01f, 3.29610795e-01f, 2.41282448e-01f, -1.98843956e-01f, 1.46002397e-01f,
  -2.53841072e-01f, 3.53899807e-01f, -2.57529497e-01f, 1.29789934e-01f, 1.43096730e-01f, -6.08495101e-02f, 2.43161470e-01f, -2.18804628e-01f, 4.94873784e-02f, -1.10892020e-01f,
  -9.67089646e-03f, -6.08891733e-02f, -4.78959382e-02f, -4.95754443e-02f, 6.28410503e-02f, 1.42858982e-01f, 3.40169296e-02f, 4.58788546e-03f, -1.63618490e-01f, -5.05974703e-02f,
  8.01148862e-02f, -1.27066761e-01f, -2.49378867e-02f, -1.32781863e-01f, -7.20286602e-03f, -4.73726802e-02f, -7.08239526e-02f, 2.30225967e-03f, -1.41090557e-01f, -9.90108587e-03f,
  -8.33816007e-02f, 3.74282226e-02f, 1.76654294e-01f, -5.42854704e-02f, -9.91401076e-02f, -3.93260038e-03f, -3.92043814e-02f, -6.35874197e-02f, 3.64498980e-02f, -1.46207750e-01f,
  -3.91528085e-02f, 5.71084209e-02f, 6.68279380e-02f, -4.78480943e-02f, -1.22487798e-01f, 2.36484911e-02f, -3.39767374e-02f, 1.22435438e-02f, -1.40455261e-01f, 9.61592570e-02f,
  -3.08022425e-02f, -3.09706386e-02f, 4.25325334e-02f, 1.03189386e-01f, 6.92809299e-02f, 1.39764259e-02f, -1.50929131e-02f, 3.38554867e-02f, -4.19569649e-02f, -1.22158248e-02f,
  -2.56202221e-02f, 6.31899852e-03f, 2.70780437e-02f, 1.30073652e-01f, 6.34561330e-02f, -5.19590266e-02f, 3.00714858e-02f, -7.98391178e-02f, 6.66484907e-02f, 3.57797258e-02f,
  1.23796143e-01f, 1.39907345e-01f, -2.29305942e-02f, -6.43528327e-02f, -4.89241183e-02f, 8.35144222e-02f, 2.70695295e-02f, -5.89616634e-02f, -6.36106282e-02f, 3.95890884e-02f,
  9.57778320e-02f, 7.67179504e-02f, 1.92790344e-01f, -2.91171316e-02f, -9.95193888e-03f, 8.25397670e-02f, 4.69409972e-02f, -9.20077637e-02f, 5.45181930e-02f, -3.05354875e-02f,
  1.05697758e-01f, 3.88533808e-02f, 6.07982092e-02f, 3.08618452e-02f, 1.73837036e-01f, 1.07739732e-01f, 5.24057336e-02f, -5.95951490e-02f, -1.25234909e-02f, 2.41391603e-02f,
  -3.29875469e-01f, -2.04301532e-02f, -3.28477651e-01f, 2.20874190e-01f, 7.59083033e-02f, 1.56810507e-02f, -2.83893824e-01f, 2.46575966e-01f, -2.08590627e-01f, 1.00989498e-01f,
  2.91852653e-01f, -8.99403766e-02f, -1.13390647e-01f, 4.57767010e-01f, 3.71056318e-01f, 6.97757453e-02f, 4.55976665e-01f, 2.01271236e-01f, -7.03331875e-03f, 1.38234824e-01f,
  2.97729492e-01f, 4.35546339e-01f, 2.04411700e-01f, 2.26568922e-01f, 2.17392936e-01f, 6.36781529e-02f, 2.93270528e-01f, -1.73585385e-01f, 4.57045913e-01f, 8.04268867e-02f,
  5.13172075e-02f, -6.30345345e-02f, -1.23440502e-02f, -1.13465384e-01f, 5.66153489e-02f, -5.20665497e-02f, -8.63073096e-02f, -2.84781344e-02f, -5.84191829e-02f, 1.26781110e-02f,
  -1.51518002e-01f, 3.81386727e-02f, 1.30880043e-01f, 2.01103594e-02f, -1.17153481e-01f, 9.07966122e-03f, 4.49413760e-03f, -8.21999386e-02f, -7.40105882e-02f, 5.34536608e-04f,
  -3.00790612e-02f, 4.26299796e-02f, -2.45121922e-02f, 8.46698135e-02f, 2.49439199e-02f, -1.16745336e-02f, -2.20394470e-02f, -3.13586928e-02f, 1.43748119e-01f, 1.39408574e-01f,
  6.28930405e-02f, -5.63853197e-02f, 2.48228330e-02f, -1.84038989e-02f, -1.33092515e-02f, 1.06286362e-01f, 3.10578495e-02f, 1.92888808e-02f, -6.70328513e-02f, 9.40253362e-02f,
  9.17014331e-02f, 3.35427513e-03f, 8.79648253e-02f, -7.54624829e-02f, 9.35500339e-02f, 3.78859080e-02f, -3.42902951e-02f, 8.59290287e-02f, -6.48451746e-02f, 6.30832911e-02f,
  -9.81361568e-02f, -6.03856333e-03f, 3.58574763e-02f, -5.52518759e-04f, 3.37844802e-04f, 6.43464848e-02f, 8.93809348e-02f, 5.13932295e-03f, -9.97370388e-03f, -3.43983434e-02f,
  1.37507081e-01f, 1.67264372e-01f, -5.01148701e-02f, -4.79300804e-02f, 3.28457206e-02f, 9.03972536e-02f, -1.98723115e-02f, -2.62483489e-02f, -3.78423557e-02f, -8.08859318e-02f,
  -3.56442817e-02f, -7.41390511e-02f, 4.46064100e-02f, 3.75117697e-02f, 8.58206674e-02f, 9.49684605e-02f, -1.32867992e-02f, 1.67777855e-02f, 7.58476332e-02f, 1.83334649e-01f,
  -8.70069396e-03f, -9.83714126e-03f, 1.32796764e-01f, -3.10768839e-03f, 1.23763710e-01f, 1.92957055e-02f, 1.53650586e-02f, 6.01153169e-03f, 4.51672375e-02f, -3.60779203e-02f,
  -2.15788439e-01f, 1.46919880e-02f, -5.56454062e-01f, -3.99116397e-01f, 2.35097453e-01f, -5.28333709e-02f, -1.11736216e-01f, 8.98648798e-03f, -1.89522490e-01f, 3.29662263e-01f,
  3.61238301e-01f, -1.94635093e-01f, 3.11973691e-01f, -2.31335610e-01f, -4.22460645e-01f, -3.25264931e-02f, -4.22309488e-01f, -1.62437588e-01f, -1.01257801e-01f, -9.01883096e-02f,
  -1.74156919e-01f, 2.08345473e-01f, -4.46424246e-01f, 2.47780681e-01f, -1.39781341e-01f, -1.03030697e-01f, 3.02641422e-01f, 6.03474677e-02f, 7.07587600e-02f, 9.99973491e-02f,
  9.91145298e-02f, 2.00403661e-01f, 3.36499773e-02f, -1.15354240e-01f, 3.51671427e-02f, 1.39722943e-01f, -9.48105305e-02f, -8.70125275e-03f, -1.56911314e-01f, -1.02618150e-01f,
  8.02366063e-02f, -8.99014845e-02f, -8.32234547e-02f, 7.70599097e-02f, 8.60293433e-02f, 7.07691833e-02f, -2.68006008e-02f, -1.83323398e-01f, -7.01370463e-02f, -1.27230227e-01f,
  -1.20522738e-01f, -9.92255509e-02f, -8.89192149e-02f, -3.26499455e-02f, -4.02747914e-02f, 6.80904463e-02f, -9.96929705e-02f, 1.19052117e-03f, 2.22566985e-02f, 3.28918882e-02f,
  4.68791202e-02f, 1.43882772e-02f, 9.79969800e-02f, 1.89344641e-02f, 7.15945512e-02f, 9.52855423e-02f, 7.79574364e-02f, 5.55364937e-02f, -4.90326853e-03f, 1.82160482e-01f,
  -2.96345595e-02f, -3.04849278e-02f, 1.73355699e-01f, -9.32498947e-02f, -3.55255455e-02f, -7.18166977e-02f, -2.42445152e-02f, -5.30010909e-02f, -9.98102278e-02f, -2.91635618e-02f,
  7.30939284e-02f, -9.58281010e-03f, 7.05059320e-02f, 1.29105784e-02f, 6.90910742e-02f, -5.25469705e-02f, 7.83984438e-02f, -5.88238649e-02f, 6.01085201e-02f, -9.13652554e-02f,
  9.01053846e-03f, 7.71279037e-02f, -5.44066913e-02f, 4.03930014e-03f, 1.25248134e-01f, 1.36090592e-01f, -4.99237478e-02f, -1.44331515e-01f, 2.78275833e-02f, 1.08790681e-01f,
  -9.97699797e-02f, -2.73403674e-02f, 3.43337990e-02f, 2.98385657e-02f, -6.95065856e-02f, 2.35751584e-01f, 2.00765431e-01f, -1.16049245e-01f, -5.63225849e-03f, 7.31697306e-02f,
  8.13754350e-02f, 3.30141112e-02f, -1.49764553e-01f, 4.18965816e-02f, -8.68159980e-02f, 8.03967863e-02f, 1.52840421e-01f, 8.84130076e-02f, -1.17921764e-02f, -7.09755719e-02f,
  2.36527860e-01f, -4.87882286e-01f, -2.34575301e-01f, -1.85507104e-01f, -1.85442939e-01f, -1.75391987e-01f, 2.22495690e-01f, -4.40028667e-01f, -4.01464313e-01f, -1.60291016e-01f,
  -8.87898505e-02f, 2.00051293e-01f, 3.74299318e-01f, -3.35451871e-01f, 5.00813603e-01f, 3.08784753e-01f, -1.94123581e-01f, 1.29924640e-01f, -1.76988408e-01f, -1.27770603e-01f,
  3.24430107e-03f, -1.97306484e-01f, 1.42067373e-02f, -4.11396921e-01f, -2.24545076e-01f, -3.49492311e-01f, 1.14335060e-01f, 1.65548146e-01f, -2.38596335e-01f, 1.26941865e-02f,
  -1.25944600e-01f, -1.52498722e-01f, -7.11868107e-02f, 4.39008400e-02f, -1.54022336e-01f, 2.52847583e-03f, 1.33800417e-01f, 1.25378385e-01f, 7.33523071e-02f, -1.74660906e-02f,
  8.92299637e-02f, -5.34377946e-03f, -1.27193794e-01f, 9.09730867e-02f, -5.72635196e-02f, -9.21372473e-02f, -1.00422315e-01f, 7.25027025e-02f, -4.79095764e-02f, 5.88527396e-02f,
  6.19570017e-02f, 3.17766741e-02f, -8.68318826e-02f, 7.34169558e-02f, -4.84462604e-02f, -3.46344039e-02f, 9.58207995e-02f, 1.24864824e-01f, 6.39297962e-02f, -9.80378166e-02f,
  8.29483476e-03f, 1.36252671e-01f, 1.17423907e-01f, 2.25692708e-02f, -8.10255483e-02f, -5.13406172e-02f, 7.73003027e-02f, 2.45601106e-02f, -1.31337598e-01f, 1.46988900e-02f,
  -6.27556369e-02f, -4.74192202e-02f, -8.11288804e-02f, 1.04159107e-02f, 2.89551355e-03f, 1.10207200e-01f, 1.46218315e-01f, 8.12823474e-02f, -3.31394859e-02f, -6.77232817e-02f,
  6.45899996e-02f, 2.88149389e-03f, 1.50976982e-02f, -7.70992562e-02f, 1.64243784e-02f, 1.75279789e-02f, -5.23768142e-02f, -5.00703678e-02f, -1.03931345e-01f, 6.00121059e-02f,
  -7.77350813e-02f, -1.76060513e-01f, -1.12043321e-01f, 5.07889688e-03f, 4.57921661e-02f, 2.45736204e-02f, -4.72836941e-02f, -1.67272329e-01f, -1.92264188e-02f, -1.29042104e-01f,
  -3.87893580e-02f, 1.96088594e-03f, -5.95469847e-02f, 1.01613946e-01f, -4.06299718e-03f, -1.78070918e-01f, 1.39489785e-01f, 4.90923412e-02f, 8.41236040e-02f, -1.06428027e-01f,
  2.19917744e-02f, -4.46159020e-03f, 7.15610459e-02f, -1.09778062e-01f, -1.24051690e-01f, 1.62274361e-01f, -8.26047361e-02f, -3.09443772e-02f, 1.13122396e-01f, 3.40894647e-02f,
  1.20791696e-01f, -7.92785734e-02f, -3.71250600e-01f, -2.24853575e-01f, 1.08330525e-01f, -3.64294648e-01f, -2.74190545e-01f, -2.10226834e-01f, -1.27537861e-01f, 1.05461210e-01f,
  -2.36760080e-02f, 3.30553763e-02f, 1.58306807e-01f, -3.92383039e-01f, -4.59060788e-01f, -8.97068679e-02f, -4.41349149e-01f, -2.51798332e-01f, -6.87633753e-02f, -8.51618871e-02f,
  -2.23545000e-01f, -2.79766470e-01f, -3.00202817e-01f, 3.01321014e-03f, -1.44039005e-01f, 1.21793263e-01f, 3.70496750e-01f, 2.62635022e-01f, -1.62330106e-01f, -7.24402145e-02f,
  -3.05255771e-01f, -2.45465502e-01f, -7.14539513e-02f, -5.45096733e-02f, 2.10133623e-02f, 7.05795512e-02f, 3.02324630e-02f, -5.09536341e-02f, 2.55480316e-02f, -1.16654553e-01f,
  2.29750201e-01f, -3.96288335e-02f, -1.05345331e-01f, -1.94442668e-03f, 7.81820565e-02f, -1.43251821e-01f, -1.48173705e-01f, -6.49544597e-02f, -8.08715597e-02f, -3.60414083e-03f,
  -1.51008472e-01f, -7.07048029e-02f, -5.42021245e-02f, -4.15650383e-02f, 8.39293599e-02f, -1.54242903e-01f, 7.49327103e-03f, 1.50743023e-01f, 5.04709743e-02f, -1.62622750e-01f,
  -2.58481782e-03f, 8.96014720e-02f, 9.95654240e-03f, -3.00679244e-02f, -9.61117148e-02f, 7.90722854e-03f, -1.14850802e-02f, 4.41850573e-02f, 1.40877813e-01f, -4.45416272e-02f,
  -3.32403742e-02f, 5.44100106e-02f, -6.34677056e-03f, -7.77072161e-02f, 3.37968394e-02f, -1.87716391e-02f, 2.03575063e-02f, -2.63504069e-02f, -3.92404087e-02f, 5.42330965e-02f,
  -1.17316812e-01f, -4.07647043e-02f, -4.85333726e-02f, 1.17912740e-01f, -1.40348196e-01f, 6.16804808e-02f, -1.37552554e-02f, -1.19550824e-01f, 7.76610477e-03f, 2.80561764e-02f,
  -1.11421116e-01f, -1.54561520e-01f, -1.87608451e-02f, -1.73614956e-02f, 9.95953828e-02f, 5.78106232e-02f, 4.33166372e-03f, 4.53831218e-02f, -2.28961520e-02f, -2.46052584e-03f,
  1.06522709e-01f, 3.35283913e-02f, 2.51635276e-02f, 7.65244365e-02f, -4.61763423e-03f, -1.63420334e-01f, 1.37732640e-01f, 8.06506649e-02f, -3.83443423e-02f, 3.67663912e-02f,
  1.52371228e-01f, 6.97998516e-03f, -1.33439377e-02f, 4.81378287e-03f, 2.16412202e-01f, -4.28344011e-02f, 1.19056903e-01f, 1.58573642e-01f, 1.68879345e-01f, 7.75055140e-02f,
  -5.39033592e-01f, -5.10860920e-01f, 2.01728754e-03f, 2.10370630e-01f, 5.51468246e-02f, -2.49428213e-01f, 1.41947120e-01f, -3.09371203e-01f, -7.91799948e-02f, -2.30999395e-01f,
  2.75751978e-01f, -1.52417868e-01f, -1.22741252e-01f, 3.52427512e-01f, -7.37577900e-02f, 9.33989361e-02f, 2.68345531e-02f, 1.11027509e-01f, 1.20007368e-02f, -3.28495093e-02f,
  -7.14794919e-02f, 3.92225772e-01f, 2.90151369e-02f, 2.10219738e-03f, 8.57546479e-02f, -9.16138291e-02f, -6.37710169e-02f, -3.05998530e-02f, 1.32571533e-01f, 9.47121754e-02f,
  -2.73180962e-01f, -1.74333185e-01f, 6.00700602e-02f, -3.25842611e-02f, -1.47091046e-01f, -2.89370548e-02f, -4.32993770e-02f, 4.22266722e-02f, 3.58933024e-02f, -1.05469786e-01f,
  1.35533477e-03f, 3.09439506e-02f, 3.86287831e-02f, 2.15259753e-02f, -1.01088388e-02f, -9.51257255e-03f, -2.49431729e-02f, -2.17073709e-02f, 4.44134213e-02f, -6.41105697e-02f,
  9.99162495e-02f, -7.96094537e-02f, 8.95152092e-02f, 1.37390241e-01f, 6.24734536e-03f, 2.36798842e-02f, 1.60629362e-01f, -1.01265118e-01f, -1.72528431e-01f, -6.35258332e-02f,
  6.93428367e-02f, 1.47789106e-01f, 4.44535725e-02f, -5.95909432e-02f, 6.30226433e-02f, 4.17277627e-02f, 8.14563632e-02f, -5.43672917e-03f, -1.95522550e-02f, -2.54355073e-02f,
  -3.30249108e-02f, 9.19115916e-02f, 1.43570416e-02f, -7.38492841e-03f, -2.98659969e-02f, 1.43412696e-02f, 1.01415835e-01f, 3.24315280e-02f, -1.00405060e-01f, -1.17168911e-02f,
  5.67411855e-02f, -3.85999680e-02f, 4.13951911e-02f, 1.03657439e-01f, -4.32767570e-02f, -2.01774299e-01f, 2.67725959e-02f, -4.46139229e-03f, 1.24635864e-02f, 5.54748103e-02f,
  -6.51188910e-01f, -5.45922458e-01f, -1.90630974e-03f, 1.30250037e-03f, -7.69840628e-02f, -1.38827339e-01f, 9.86115560e-02f, -8.22358206e-02f, -1.31659463e-01f, -6.97836429e-02f,
  -1.14072047e-01f, 4.93751056e-02f, -4.94481884e-02f, 4.49712016e-02f, 5.96603490e-02f, 6.07754588e-02f, -1.10448338e-01f, -4.78857681e-02f, -9.39051583e-02f, -4.55651507e-02f,
  -7.40520880e-02f, 5.79323657e-02f, 1.36741534e-01f, 3.99398133e-02f, 2.41516586e-02f, -7.24680573e-02f, -1.00097671e-01f, -1.04560800e-01f, 1.29667930e-02f, 8.74054357e-02f,
  4.57653433e-01f, -2.82967746e-01f, -3.71221825e-02f, 9.30255279e-02f, 3.72703344e-01f, 4.56803411e-01f, 2.85244197e-01f, 1.06944025e-01f, 1.86912790e-01f, -3.39028507e-01f,
  1.48181114e-02f, -3.02577049e-01f, -1.06855951e-01f, 1.23557411e-01f, 3.49171489e-01f, 2.58884635e-02f, 2.89149702e-01f, 1.03850709e-02f, 1.42675474e-01f, 6.98254704e-02f,
  2.82807291e-01f, 1.79068923e-01f, -5.51226474e-02f, 3.10959807e-03f, 1.28339663e-01f, -2.03838751e-01f, -3.62208098e-01f, -2.45775372e-01f, -3.38301510e-01f, 8.03853571e-03f,
  3.86402234e-02f, 6.97581545e-02f, 1.00071974e-01f, 8.20036307e-02f, 5.80631830e-02f, -3.55054773e-02f, -7.93843791e-02f, 1.26016617e-01f, 7.04428181e-02f, 4.02719229e-02f,
  -6.24297373e-02f, 4.61942628e-02f, 6.75836504e-02f, 9.15679056e-03f, 1.86140016e-01f, 1.37967579e-02f, -1.71400160e-02f, -1.68813486e-02f, -1.43781826e-01f, 3.34598795e-02f,
  4.70995158e-02f, 2.35806825e-03f, -3.97361182e-02f, -1.41602769e-01f, -9.97190848e-02f, -4.21550125e-03f, -1.45999253e-01f, -2.19179079e-01f, -1.10093191e-01f, 3.10631339e-02f,
  1.46265449e-02f, -2.30201166e-02f, 1.22634090e-01f, 2.77163461e-02f, 1.96537867e-01f, 3.94719280e-02f, -2.37297080e-02f, 1.28632896e-02f, 7.61205107e-02f, 2.34444495e-02f,
  4.22250293e-02f, -5.23238406e-02f, 4.79927771e-02f, 9.26297829e-02f, 6.00953847e-02f, 1.08306356e-01f, 2.96338573e-02f, -1.26626998e-01f, -4.57667820e-02f, -2.76132673e-02f,
  -5.89594804e-02f, -4.09608558e-02f, 7.82013535e-02f, -6.50250912e-02f, 7.62998089e-02f, -1.82942413e-02f, -3.52838226e-02f, -2.86925714e-02f, 3.09459809e-02f, -1.34378113e-02f,
  1.10669859e-01f, -1.95028886e-01f, 7.69454539e-02f, 5.49083538e-02f, 3.80646177e-02f, 1.53504699e-01f, 7.83020332e-02f, 1.02851717e-02f, -6.41273484e-02f, 1.24854267e-01f,
  6.61247671e-02f, -2.79355724e-03f, 3.07990890e-02f, -1.47769466e-01f, -6.39892789e-03f, 1.44675404e-01f, -4.02000919e-02f, -4.38849181e-02f, -1.34846754e-02f, -1.56137515e-02f,
  -1.37575999e-01f, 1.61892220e-01f, -1.22519031e-01f, 3.50521207e-02f, -9.09991562e-02f, -1.78966120e-01f, 1.09774552e-01f, -2.57199347e-01f, -1.03188843e-01f, -8.35355371e-02f,
  2.69325823e-01f, 3.43436211e-01f, -7.98559040e-02f, -8.64826236e-03f, -1.71706900e-01f, -1.18171126e-01f, 3.63332257e-02f, -4.28579450e-02f, -4.08887625e-01f, 1.09321184e-01f,
  2.25298554e-01f, -6.54717162e-02f, 2.81424731e-01f, 5.13181567e-01f, -6.12701401e-02f, 1.90947205e-01f, 2.62794375e-01f, 2.13157162e-01f, 9.63478014e-02f, 2.16246784e-01f,
  1.21498525e-01f, 8.56779292e-02f, 2.63456523e-01f, 1.08684599e-01f, 4.82943565e-01f, 1.21535800e-01f, -7.73693551e-04f, 6.48859590e-02f, 1.52243644e-01f, 1.46699818e-02f,
  2.14498863e-01f, 1.28055140e-01f, 1.33895669e-02f, -3.33752409e-02f, -1.20638952e-01f, 1.42577719e-02f, 9.37164426e-02f, 9.76244211e-02f, -1.46348119e-01f, -6.07310198e-02f,
  -4.61022705e-02f, -1.43111840e-01f, -8.36360529e-02f, -1.21967241e-01f, 2.49758754e-02f, -7.01480359e-02f, -5.35265468e-02f, 5.24344221e-02f, 1.74293108e-02f, 1.96361169e-01f,
  3.37652192e-02f, 6.07658327e-02f, 6.13106601e-02f, 3.42233442e-02f, -1.02146700e-01f, -6.49170727e-02f, 3.03400704e-03f, 6.75571784e-02f, -7.93809071e-02f, -1.13221616e-01f,
  -5.69976983e-04f, -4.27206941e-02f, 1.24713387e-02f, 1.76875487e-01f, -5.08771762e-02f, 1.00462526e-01f, 8.26366246e-02f, 1.99937671e-01f, -2.78922487e-02f, 6.16845451e-02f,
  -1.82896275e-02f, -3.71879712e-02f, -1.44151449e-01f, -2.05722123e-01f, -4.52163927e-02f, 5.81921963e-03f, 4.50204350e-02f, 8.74686837e-02f, -7.31749907e-02f, 1.15836099e-01f,
  -8.25196728e-02f, 1.30567960e-02f, 2.78543998e-02f, 1.63434267e-01f, 3.10759228e-02f, -1.08686648e-01f, 6.25041947e-02f, 1.31160803e-02f, 5.11325002e-02f, -4.67484109e-02f,
  6.21378906e-02f, -1.92087561e-01f, -8.89532939e-02f, -1.74615294e-01f, 2.15358082e-02f, -2.97025461e-02f, 2.38230880e-02f, 1.45415366e-02f, -2.65399311e-02f, -9.83667001e-02f,
  -9.76695865e-02f, -1.10521965e-01f, -3.36273238e-02f, -9.37780142e-02f, -1.19982377e-01f, -8.70985165e-02f, 3.09764547e-03f, -1.77085474e-01f, -1.65491536e-01f, 1.21622376e-01f,
  -3.80340591e-02f, -1.02723189e-01f, -3.30810323e-02f, -7.38736168e-02f, -1.19165234e-01f, -6.55230060e-02f, -1.35560120e-02f, 6.00838326e-02f, 1.07749768e-01f, -5.55807687e-02f,
  4.02525038e-01f, 1.95534810e-01f, -1.32246315e-01f, -3.28822434e-01f, -3.12305689e-01f, -3.01912338e-01f, -4.01750714e-01f, -2.23270953e-01f, -3.70494932e-01f, -2.72772253e-01f,
  -2.89553642e-01f, -5.82481883e-02f, 1.46532506e-01f, -2.23935634e-01f, 2.26681560e-01f, 3.15250874e-01f, -2.71114130e-02f, -2.19116211e-01f, 7.96811283e-02f, 7.99861401e-02f,
  2.05674365e-01f, 1.09279700e-01f, 1.89291447e-01f, 2.75382340e-01f, -8.27547237e-02f, 3.15836780e-02f, 1.21939592e-01f, -1.11089036e-01f, -2.03363448e-01f, -9.17089507e-02f,
  -1.16419181e-01f, 5.17627895e-02f, -1.90789759e-01f, 2.67124530e-02f, -4.65826951e-02f, -1.43468156e-01f, -5.84736131e-02f, -4.38743010e-02f, -8.75303298e-02f, -1.17963508e-01f,
  5.18994443e-02f, 1.57596946e-01f, -3.36407945e-02f, 2.96767745e-02f, -1.61394347e-02f, -7.11347610e-02f, 1.13376200e-01f, -1.38492197e-01f, 2.19944976e-02f, 1.10908382e-01f,
  -2.07515936e-02f, 3.01513169e-02f, -6.80365711e-02f, 1.56432856e-02f, -1.40780527e-02f, -7.13649765e-02f, -6.57558963e-02f, -6.12455532e-02f, -1.89519878e-02f, -9.36190486e-02f,
  8.54411498e-02f, 1.45750046e-02f, 1.22741081e-01f, -7.76872262e-02f, 7.38220289e-02f, -9.99409519e-03f, -1.01023577e-01f, -7.61011839e-02f, 9.91705805e-03f, 2.51494050e-02f,
  -1.37209803e-01f, -1.19885951e-01f, -8.61691982e-02f, -3.52487415e-02f, 8.24185163e-02f, 6.55726879e-04f, 5.32836914e-02f, 2.52046380e-02f, -6.64798617e-02f, -1.25948027e-01f,
  -5.35966270e-02f, -2.71123480e-02f, -9.38947499e-02f, -6.50668144e-02f, -9.59430784e-02f, -8.37802887e-03f, 9.71444137e-03f, 3.55320089e-02f, 7.83954486e-02f, 7.37180859e-02f,
  -9.53109860e-02f, 2.00382739e-01f, -1.37287406e-02f, -1.79615170e-02f, 5.02578989e-02f, 1.66381802e-02f, -1.70270931e-02f, -5.39526865e-02f, 7.65356328e-03f, -3.59618329e-02f,
  2.03146487e-02f, -2.36403048e-02f, -8.41165036e-02f, -4.72647101e-02f, 1.61270704e-02f, -8.12349748e-03f, 8.40698630e-02f, -9.50843319e-02f, -1.13282554e-01f, -3.16861235e-02f,
  1.06146466e-03f, -7.65112601e-03f, 6.04459681e-02f, -9.78746042e-02f, -4.74988259e-02f, -1.24350615e-01f, 1.20131351e-01f, -6.76287487e-02f, 9.05983299e-02f, -1.95720613e-01f,
  1.52852997e-01f, 5.20901322e-01f, 3.10827106e-01f, 1.64007246e-01f, -3.62857997e-01f, -1.31488711e-01f, -2.83586353e-01f, 1.08006157e-01f, -1.09106759e-02f, -1.04815625e-02f,
  -3.13584536e-01f, 2.79465705e-01f, -9.15050432e-02f, 6.14532195e-02f, 3.01822990e-01f, 1.25401855e-01f, 3.18829864e-01f, 4.13860045e-02f, 7.44267106e-02f, 2.85013765e-01f,
  2.31919780e-01f, -5.98702729e-02f, 2.83014655e-01f, 1.63315699e-01f, 6.51462525e-02f, 1.92355394e-01f, -3.16533186e-02f, 6.05006479e-02f, 2.28071839e-01f, -4.88534495e-02f,
  5.69217019e-02f, 8.11924264e-02f, 5.63025884e-02f, -3.52283493e-02f, 5.79682142e-02f, -1.76048845e-01f, 6.38514161e-02f, -5.75531181e-03f, -5.79907447e-02f, 7.04488857e-03f,
  2.43329406e-02f, -3.72859687e-02f, 9.01453719e-02f, -2.07369514e-02f, -1.13221502e-03f, 6.69680675e-03f, 1.25529572e-01f, -2.46110316e-02f, 4.15109918e-02f, 1.77049823e-02f,
  2.04073086e-01f, -3.37290205e-02f, 1.83934963e-03f, -1.89822000e-02f, 1.23121880e-01f, 1.56121003e-02f, 6.27200305e-02f, -1.16124256e-02f, -5.46148513e-03f, 1.88742116e-01f,
  2.57353578e-02f, -1.32353127e-01f, -2.60009710e-02f, -9.12716761e-02f, 1.48876399e-01f, 6.41569495e-02f, 1.56532153e-01f, -7.66832009e-03f, -4.96727452e-02f, -1.34491818e-02f,
  1.23134349e-02f, -2.97959372e-02f, -6.41503334e-02f, -1.09641947e-01f, 5.36397733e-02f, -1.76270604e-02f, -9.71360132e-02f, -1.56708419e-01f, 1.46687731e-01f, 7.49843717e-02f,
  -1.35557905e-01f, -4.67760395e-03f, -6.17912039e-02f, -5.15129156e-02f, -1.17663525e-01f, -1.36699215e-01f, -4.08646837e-02f, 1.21643571e-02f, -5.92515431e-02f, 5.07817566e-02f,
  3.72158810e-02f, 3.51043195e-01f, 5.33994399e-02f, -1.28935901e-02f, 8.97484869e-02f, 1.23991698e-01f, 1.43525854e-01f, 1.56844035e-01f, 1.61761969e-01f, -4.29305732e-02f,
  6.55814782e-02f, -8.27835500e-02f, -3.07724960e-02f, -8.41995627e-02f, 1.12841703e-01f, 2.52120048e-01f, 4.22047116e-02f, -2.48417892e-02f, 7.68131092e-02f, 4.90042120e-02f,
  4.59611863e-02f, -4.11064290e-02f, 5.10927252e-02f, 8.09459016e-03f, 8.93260315e-02f, 2.74729123e-03f, 3.87885720e-02f, -2.60827579e-02f, 1.79531444e-02f, 1.08958721e-01f,
  -1.34706497e-01f, -2.36586973e-01f, -5.36153354e-02f, 5.19689500e-01f, -2.48178318e-01f, -1.25313297e-01f, 3.14564794e-01f, -3.40711027e-01f, 2.52872020e-01f, 6.17365865e-03f,
  4.85545486e-01f, -3.27361017e-01f, 2.72101581e-01f, 5.46824217e-01f, -2.05807999e-01f, 5.10007977e-01f, 2.12193355e-01f, 1.81780815e-01f, -2.37973467e-01f, -2.67434567e-02f,
  5.78219444e-02f, 1.16565086e-01f, 2.45906085e-01f, -5.31047463e-01f, -1.72237940e-02f, -2.41337657e-01f, -7.49252215e-02f, -1.39088050e-01f, -2.20713243e-01f, -3.17550302e-01f,
  1.37159884e-01f, 2.05622360e-01f, 1.34105727e-01f, -6.35538101e-02f, 1.28419995e-01f, 1.97538417e-02f, -2.21472699e-02f, -1.01960473e-01f, 1.16453148e-01f, 1.25763476e-01f,
  4.22703139e-02f, -1.26332104e-01f, -1.14512980e-01f, -7.04400316e-02f, -1.09556630e-01f, -1.38811022e-01f, 7.11490810e-02f, 1.09509557e-01f, -5.45579754e-02f, -5.44900708e-02f,
  1.49317861e-01f, 5.77779636e-02f, 2.05740750e-01f, -7.79950097e-02f, 1.80463959e-02f, 2.08395887e-02f, -1.89822260e-02f, -2.77125314e-02f, -8.84722397e-02f, -1.66375250e-01f,
  -2.09333882e-01f, -2.08443981e-02f, 5.82278296e-02f, 6.82642236e-02f, -6.71439916e-02f, 1.30685017e-01f, 2.62371148e-03f, -1.67753454e-02f, 2.10064296e-02f, -4.11135517e-02f,
  8.84013027e-02f, 2.01125275e-02f, -9.48188454e-02f, 1.45129235e-02f, 1.03549892e-02f, 3.09080631e-02f, -6.09405823e-02f, -1.25114933e-01f, 2.13037744e-01f, -8.91813561e-02f,
  -1.19808875e-02f, -3.49075086e-02f, 7.54743814e-02f, 2.25349888e-02f, 2.78866366e-02f, 4.21170238e-03f, 9.95320380e-02f, -7.05929250e-02f, 1.93413287e-01f, -8.06405321e-02f,
  -1.57972667e-02f, -4.03140306e-01f, 9.35045630e-03f, 3.52834836e-02f, -1.38471732e-02f, -1.47596255e-01f, -1.14706971e-01f, -8.86784792e-02f, -1.73380479e-01f, -7.22947568e-02f,
  -1.36790991e-01f, -1.43673746e-02f, -3.04556452e-02f, 2.19105147e-02f, 3.07094622e-02f, -1.38690565e-02f, 6.22397214e-02f, -8.71790722e-02f, 9.84148607e-02f, -2.93570995e-01f,
  -9.42370519e-02f, 8.19210894e-03f, -1.95270330e-02f, 6.83947206e-02f, -1.61587298e-02f, -1.41113503e-02f, -1.10388659e-01f, -1.96436886e-02f, 2.25221943e-02f, -2.45090909e-02f,
  -1.01086058e-01f, 3.01564932e-01f, 3.21388319e-02f, -1.68732882e-01f, -1.60184279e-01f, 7.75295543e-03f, -1.10262975e-01f, 1.08614907e-01f, 5.06849885e-01f, -2.24424779e-01f,
  -3.23185831e-01f, -8.57077911e-02f, -3.54323513e-03f, -4.02633190e-01f, 3.63240838e-01f, 3.87783676e-01f, 9.92827490e-02f, -9.92164575e-03f, 4.12788928e-01f, -2.07638904e-01f,
  1.30936339e-01f, -2.72936612e-01f, -2.17106000e-01f, -3.23516637e-01f, -2.81401217e-01f, -1.45453677e-01f, -3.89251053e-01f, 2.05916353e-02f, -3.65024209e-01f, 1.05465911e-01f,
  -3.72525565e-02f, 6.31898344e-02f, -2.26645440e-01f, 1.19245332e-02f, -3.21441852e-02f, -7.18883947e-02f, 5.51525988e-02f, -1.38294414e-01f, 7.45270178e-02f, 1.82657931e-02f,
  -5.17323948e-02f, -3.12355738e-02f, 1.79946925e-02f, 2.36492082e-02f, -1.19119108e-01f, -1.10656425e-01f, -1.85742546e-02f, -3.66091914e-02f, -1.17509842e-01f, -3.92964222e-02f,
  -5.02892993e-02f, 2.81879399e-02f, -4.49821390e-02f, 1.52324647e-01f, -8.33765883e-03f, 1.83394402e-02f, 2.92244926e-02f, 7.15675578e-02f, 3.21317241e-02f, 7.03064799e-02f,
  -3.74547802e-02f, 1.39099687e-01f, -6.32753596e-02f, -1.00547075e-01f, -4.89298031e-02f, 5.92358671e-02f, -6.34172410e-02f, 5.36825843e-02f, 2.21707970e-02f, -1.11697443e-01f,
  -9.89551377e-03f, 1.30755723e-01f, 1.47323415e-01f, 4.68699411e-02f, -5.52185513e-02f, 9.22194943e-02f, -1.05074197e-01f, 2.57545291e-03f, 2.19859127e-02f, 3.08779962e-02f,
  6.36812225e-02f, 7.56015852e-02f, -3.51494551e-02f, -1.15782350e-01f, -1.88770052e-02f, -1.47630612e-03f, 3.51777184e-03f, -3.91796678e-02f, -1.56461112e-02f, 8.41417536e-02f,
  1.38935357e-01f, 4.91056561e-01f, 6.00334853e-02f, -1.30077079e-01f, 1.25516713e-01f, -5.44860065e-02f, 3.25977728e-02f, -6.09358549e-02f, 2.05844864e-01f, -4.78875067e-04f,
  -3.74238454e-02f, -1.35330826e-01f, 3.75802778e-02f, 6.62334338e-02f, -3.11346888e-03f, 8.75511989e-02f, -9.15096235e-03f, 1.52680352e-01f, 1.80524185e-01f, 6.57001138e-02f,
  -2.67736286e-01f, 4.73174155e-02f, 3.35985012e-02f, 3.71870622e-02f, 3.82253826e-02f, -5.97606264e-02f, -9.36989486e-03f, 8.42485204e-02f, 8.81790519e-02f, 1.16779236e-03f,
  -2.10144788e-01f, -2.93501735e-01f, -2.55874932e-01f, 3.29613507e-01f, -2.69420631e-02f, -2.18067229e-01f, -4.57421660e-01f, 1.45676792e-01f, -3.00131232e-01f, -1.12017848e-01f,
  2.78790414e-01f, 4.04317267e-02f, -2.97036171e-01f, 5.40524244e-01f, 3.98482323e-01f, 1.03224665e-02f, 3.25596839e-01f, 2.17808768e-01f, 7.53688673e-03f, 1.17147438e-01f,
  1.92361310e-01f, 4.07520860e-01f, 3.37794840e-01f, 3.36731285e-01f, 2.54838496e-01f, 2.33575761e-01f, 3.19943160e-01f, 2.58767791e-02f, 4.25365418e-01f, 2.76691437e-01f,
  -1.74792647e-01f, 3.87984365e-02f, -1.32910624e-01f, -1.17926992e-01f, -1.12624262e-02f, -1.31177614e-02f, -6.57880977e-02f, 7.80028999e-02f, 1.05097406e-01f, 8.72286186e-02f,
  -1.07916743e-01f, 4.64135222e-02f, 8.09106082e-02f, 7.86837861e-02f, -1.65665582e-01f, -4.69904579e-02f, -1.40940025e-01f, 2.45678239e-04f, -1.13734186e-01f, -7.38073289e-02f,
  -1.11236043e-01f, 2.45271828e-02f, 5.17506711e-02f, 9.99496551e-04f, -4.07960936e-02f, 2.31270399e-02f, -3.62620801e-02f, -1.21088773e-01f, 4.69408743e-02f, -3.52759287e-02f,
  -8.20916668e-02f, 7.36247748e-02f, -9.39896628e-02f, 2.87225880e-02f, -6.08845688e-02f, 6.42999262e-02f, -1.63013935e-02f, 3.86438780e-02f, 5.22916093e-02f, -9.14125144e-02f,
  -3.61105017e-02f, -8.00135266e-03f, 5.13178445e-02f, -2.47869510e-02f, 6.74187616e-02f, -3.95289995e-02f, -4.20238934e-02f, 1.44794947e-02f, -1.28816679e-01f, 8.40005130e-02f,
  4.27764021e-02f, -1.01373591e-01f, -1.63185596e-02f, -9.70509723e-02f, 2.86386777e-02f, 1.39186218e-01f, 1.05846576e-01f, -1.81223288e-01f, 6.61558583e-02f, 2.82935575e-02f,
  -1.36426657e-01f, 6.70130849e-02f, -1.79788973e-02f, 3.10287848e-02f, 1.32308798e-02f, -6.28019264e-03f, 2.98654418e-02f, 8.16045478e-02f, 4.87341434e-02f, 3.90803143e-02f,
  1.06773049e-01f, 2.19971985e-02f, 2.58925278e-02f, 1.10086538e-02f, 1.49471968e-01f, -1.79046188e-02f, -6.82926103e-02f, -5.15947025e-03f, 3.66627388e-02f, 1.03575990e-01f,
  8.66613388e-02f, 4.04564217e-02f, 1.22144997e-01f, -9.39937681e-02f, 6.61649853e-02f, 1.90253593e-02f, -5.97711094e-03f, -5.46972789e-02f, 4.20666486e-02f, -2.04608254e-02f,
  -2.08045378e-01f, -4.25819218e-01f, 2.25515246e-01f, 4.07169223e-01f, -1.12529427e-01f, -2.11838871e-01f, 1.12662815e-01f, -4.14456964e-01f, -3.20783287e-01f, -2.77675271e-01f,
  -7.92701840e-02f, 1.90434724e-01f, -4.22788888e-01f, 2.16759875e-01f, 2.92419136e-01f, -4.27551925e-01f, -1.15363643e-01f, 3.27788591e-02f, -1.50554135e-01f, -5.38888723e-02f,
  -2.84125656e-02f, -6.62147673e-03f, 9.47269350e-02f, 1.09661497e-01f, 7.43723363e-02f, 4.61314470e-01f, 5.22961676e-01f, 3.43418181e-01f, 6.11436129e-01f, 4.07842308e-01f,
  -1.15138397e-01f, -1.73359513e-01f, 3.34521234e-02f, -6.95332885e-02f, 2.43417695e-02f, 7.41649494e-02f, 9.20867994e-02f, 2.27284148e-01f, 2.09874094e-01f, -9.45223961e-03f,
  5.36151975e-02f, 1.52276516e-01f, 6.29357472e-02f, 5.53210713e-02f, -4.35574464e-02f, 1.04956189e-02f, 1.25769135e-02f, -1.60278708e-01f, 1.81271974e-02f, -6.36765792e-04f,
  -1.04741924e-01f, -1.66496798e-01f, 3.74720171e-02f, 5.01163527e-02f, 1.26037031e-01f, -9.48511362e-02f, 4.62845452e-02f, 1.55431882e-01f, 9.73770693e-02f, 1.39166981e-01f,
  -1.20922148e-01f, -2.50889678e-02f, 1.38159860e-02f, -2.16495637e-02f, 5.08726239e-02f, 1.32890016e-01f, 1.46503234e-03f, -2.76019052e-02f, 1.53697222e-01f, -6.43669590e-02f,
  4.18382250e-02f, 4.75849956e-03f, 5.39083313e-03f, -5.16602769e-02f, -7.97679052e-02f, -1.39386788e-01f, 1.22260675e-01f, 7.29206279e-02f, -4.91699576e-02f, 1.70131475e-02f,
  -6.68029813e-03f, 1.26877531e-01f, 5.71918674e-02f, 5.30401915e-02f, -1.78548217e-01f, -6.65712636e-03f, 4.38803695e-02f, 1.49086453e-02f, -5.94407134e-02f, 1.62000611e-01f,
  -4.79241647e-02f, 5.00611775e-02f, -1.11374743e-02f, -9.45206210e-02f, 3.41448896e-02f, -5.01380414e-02f, -1.92700475e-02f, 9.92067531e-03f, 5.63996509e-02f, -1.65350467e-01f,
  -8.06563497e-02f, 1.27585173e-01f, -6.32952452e-02f, 5.37217148e-02f, 1.17967546e-01f, -4.34456207e-02f, 4.57627990e-04f, 3.38520147e-02f, -8.03436562e-02f, 1.23657636e-01f,
  -3.62149328e-02f, 7.41082802e-02f, 7.73676159e-03f, -9.14198682e-02f, -1.07540920e-01f, -5.25779277e-03f, 1.00522652e-01f, -1.62687786e-02f, 3.90138105e-02f, 1.02719478e-01f,
  -1.72064796e-01f, 3.65484774e-01f, -3.50979865e-01f, 1.04532354e-01f, 4.89189327e-02f, 4.34132069e-01f, 1.86473042e-01f, 1.39813155e-01f, -1.11228004e-01f, 3.26416910e-01f,
  2.38488570e-01f, 5.98822869e-02f, -2.13626251e-01f, 5.01800776e-01f, 1.73573837e-01f, 2.18755096e-01f, 3.81276667e-01f, 3.30269963e-01f, -1.15850396e-01f, 5.29069752e-02f,
  7.10536242e-02f, 4.26819324e-01f, -5.72414733e-02f, 2.20211923e-01f, 1.31826460e-01f, -2.19819754e-01f, 1.12856150e-01f, -1.96615458e-01f, 4.50124323e-01f, 2.88185567e-01f,
  1.23078920e-01f, -2.09429134e-02f, -9.32129771e-02f, -1.91682745e-02f, -2.36948691e-02f, -2.31834538e-02f, 8.34600627e-02f, 3.87045965e-02f, -1.26055896e-01f, 4.01677191e-02f,
  -4.94970866e-02f, 1.04907500e-02f, 4.38683666e-02f, -5.05166501e-02f, 4.68353219e-02f, -5.40735163e-02f, -8.38293955e-02f, -1.20688252e-01f, 8.10892284e-02f, -7.40928128e-02f,
  -1.85712919e-01f, -1.12136407e-03f, -9.45454389e-02f, 2.70345546e-02f, -1.10161923e-01f, 1.56753697e-02f, 5.81464171e-02f, -1.20237708e-01f, 5.61377816e-02f, 1.56226799e-01f,
  -2.90966611e-02f, 5.24959974e-02f, -2.64520459e-02f, -5.34195565e-02f, 1.33692194e-02f, 1.60800051e-02f, 8.62208679e-02f, 1.14170998e-01f, -9.50265899e-02f, 1.39638439e-01f,
  -1.82640727e-03f, -3.34728733e-02f, 1.48061551e-02f, 5.10166250e-02f, 1.03361242e-01f, 5.23190238e-02f, -1.47601426e-01f, 2.10336177e-03f, -9.24383178e-02f, -4.06319387e-02f,
  3.20970244e-03f, 5.99612556e-02f, -1.81670412e-02f, 2.50517204e-03f, 1.10899858e-01f, -6.79438785e-02f, 6.27223626e-02f, 8.17753188e-03f, -9.74993780e-02f, -1.02796927e-01f,
  2.38047138e-01f, 1.96820498e-01f, -1.20547608e-01f, 3.82203199e-02f, 6.44561201e-02f, -1.18149249e-02f, -4.73037828e-03f, 1.80204790e-02f, 8.86554271e-02f, -4.17355038e-02f,
  -1.27010047e-01f, -9.38338488e-02f, 2.81816982e-02f, 2.00940040e-03f, 7.21197650e-02f, 5.52431308e-02f, 3.50137614e-02f, -4.59302105e-02f, 4.00816761e-02f, -6.42661843e-03f,
  2.89459666e-03f, -9.26809311e-02f, 5.28679155e-02f, -6.62039146e-02f, 9.09466594e-02f, -3.01014017e-02f, 2.58869622e-02f, -2.06802376e-02f, -3.34064513e-02f, 1.41199574e-01f,
  -1.15499057e-01f, 1.83954075e-01f, 1.71007052e-01f, -3.00078750e-01f, -1.47106856e-01f, 1.77405383e-02f, -3.92973393e-01f, 9.13045034e-02f, 6.84980750e-02f, 3.73169005e-01f,
  -2.24646285e-01f, 3.27212065e-01f, -6.44821450e-02f, -2.45283902e-01f, -4.56494331e-01f, -4.54370350e-01f, -2.93339670e-01f, -2.28246942e-01f, -2.43484065e-01f, -2.05311939e-01f,
  -3.16968620e-01f, -4.96764570e-01f, -4.19482410e-01f, -1.46517307e-01f, -1.25134289e-01f, 2.61120558e-01f, -2.87267864e-02f, -2.05484331e-01f, 1.83890760e-01f, -1.75734401e-01f,
  -8.33116025e-02f, -4.55061086e-02f, 1.87581971e-01f, 2.57745415e-01f, 7.90156145e-03f, 9.90076438e-02f, 1.39819264e-01f, 1.08365290e-01f, -5.95374592e-02f, 5.41338883e-03f,
  1.53934911e-01f, 1.80481434e-01f, 1.21754766e-01f, -7.18726888e-02f, 1.36629596e-01f, 1.09242007e-01f, 1.51889130e-01f, 1.65328413e-01f, 3.01774442e-01f, -9.14653465e-02f,
  -8.61293357e-03f, 2.13176340e-01f, 1.09175131e-01f, 1.03480473e-01f, 1.21904299e-01f, -5.97323701e-02f, 9.99399126e-02f, 6.37911260e-02f, 1.68057799e-01f, 6.74941838e-02f,
  -8.59116092e-02f, -3.65204699e-02f, -8.42863843e-02f, -3.43830399e-02f, -1.44843087e-02f, 2.15015486e-02f, 4.35871771e-03f, -8.16168785e-02f, -3.26589942e-02f, 8.16946775e-02f,
  5.78181632e-02f, -9.30987000e-02f, -2.13738918e-01f, 7.81090632e-02f, -1.53644577e-01f, -4.38044630e-02f, 1.34641398e-02f, -2.56095063e-02f, -1.64991673e-02f, 7.28352740e-02f,
  -7.03530610e-02f, 1.11594729e-01f, -7.42788911e-02f, -4.44981568e-02f, -3.25571299e-02f, 9.53382850e-02f, 1.30253956e-01f, 1.47444591e-01f, -1.50789052e-01f, -6.51889965e-02f,
  1.01519711e-01f, -7.20533682e-03f, 5.92104308e-02f, 1.58646181e-01f, 9.50070389e-04f, 9.29150134e-02f, -3.80519815e-02f, 9.08975154e-02f, 1.01067312e-02f, -7.09086191e-03f,
  2.01775860e-02f, 5.68072964e-03f, 1.91126779e-01f, -3.26379538e-02f, -5.10838218e-02f, -1.35474160e-01f, -1.36548560e-02f, 1.10246219e-01f, 1.64179668e-01f, -8.50175600e-03f,
  8.23327303e-02f, 3.46992500e-02f, 4.10861662e-03f, -5.82124852e-02f, -3.48533085e-03f, 5.52243590e-02f, -7.49589205e-02f, 5.55112809e-02f, -1.34413943e-01f, 1.41094491e-01f,
  -7.50101149e-01f, 3.53883445e-01f, 2.49344006e-01f, -4.68579866e-02f, -7.87365735e-02f, 4.71220881e-01f, 3.99737149e-01f, 3.54458578e-02f, 2.22941980e-01f, 2.73721725e-01f,
  1.00337146e-02f, -1.20819665e-01f, 1.59840390e-01f, 2.30904654e-01f, 3.00884128e-01f, 3.76873106e-01f, 2.61567563e-01f, 1.81268170e-01f, 4.77934927e-02f, -2.34945640e-01f,
  4.06200625e-02f, 9.73982513e-02f, 1.27247334e-01f, -1.41949177e-01f, -4.17758003e-02f, -2.58727670e-01f, -1.62029162e-01f, 1.13357157e-01f, -4.06719558e-02f, 2.04111665e-01f,
  -2.04616815e-01f, -3.31613392e-01f, -3.84026378e-01f, -1.85571611e-02f, 4.91973087e-02f, 3.67950760e-02f, 5.52148893e-02f, -1.86954886e-02f, -1.05816856e-01f, 1.32092936e-02f,
  -8.54340941e-02f, -1.40801638e-01f, -7.09786415e-02f, -1.37801431e-02f, 1.47245731e-03f, -2.72056237e-02f, -3.86917926e-02f, 5.94693422e-03f, -5.08124381e-02f, 4.43119183e-02f,
  -4.43569571e-02f, 8.22087377e-02f, -4.34690602e-02f, 2.18114227e-01f, 8.41797218e-02f, -4.82973196e-02f, 1.59435179e-02f, -3.52505222e-02f, -1.14541668e-02f, -1.60226673e-02f,
  3.08744181e-02f, 1.12268403e-01f, -1.01547800e-01f, 3.90813574e-02f, -8.08362104e-03f, 6.84581399e-02f, -6.00376241e-02f, -2.94533023e-03f, 1.07794292e-01f, -2.79192850e-02f,
  -2.94718184e-02f, -1.14273190e-01f, -1.31975293e-01f, 1.31001864e-02f, -3.84974852e-02f, 1.19876219e-02f, -4.46884669e-02f, -7.12254345e-02f, 6.14166223e-02f, -7.42525700e-03f,
  8.87493044e-03f, 2.82486565e-02f, 6.68351352e-02f, -7.14280531e-02f, 2.48942822e-02f, -1.16471266e-02f, 8.25390816e-02f, 1.18986554e-01f, -2.62088440e-02f, 2.00594775e-04f,
  3.73537034e-01f, 2.25747097e-02f, -1.25614345e-01f, -6.53413609e-02f, 2.42038500e-02f, -8.82880241e-02f, 1.03495978e-01f, -7.22408518e-02f, 1.95093215e-01f, -4.45125951e-03f,
  -1.94873288e-02f, 3.46871503e-02f, -1.50385916e-01f, -3.30590061e-03f, 9.19142291e-02f, 8.22486952e-02f, 1.01675577e-01f, -5.78550436e-03f, 3.34363151e-03f, -1.06574744e-01f,
  -2.29517408e-02f, 1.91325098e-02f, -2.52496288e-03f, -1.63032617e-02f, -1.07060984e-01f, -1.69063490e-02f, -7.90702924e-02f, -7.08092451e-02f, 5.04079759e-02f, 5.61969355e-02f,
  3.84257048e-01f, 1.41468504e-03f, -6.85676187e-02f, 3.49139988e-01f, 3.78289908e-01f, 4.16553020e-01f, 2.24180520e-01f, 4.58332598e-01f, 4.27082598e-01f, -2.47538999e-01f,
  3.29121836e-02f, -2.78171539e-01f, -2.66633689e-01f, 2.93040067e-01f, 2.57248908e-01f, -1.28197417e-01f, 3.34315091e-01f, -8.13169107e-02f, 2.39618421e-01f, 1.30314574e-01f,
  1.76990435e-01f, 2.29771137e-01f, -1.68521896e-01f, 4.02049460e-02f, 2.00960487e-01f, -8.67292285e-02f, -3.67787123e-01f, -2.05038026e-01f, -1.83912158e-01f, -3.74378189e-02f,
  8.82328898e-02f, 1.34211943e-01f, -3.19128856e-02f, -9.83314589e-02f, -1.15799010e-02f, 7.79485935e-03f, -1.41952127e-01f, -1.94520503e-01f, 2.93725319e-02f, 4.13671397e-02f,
  -8.05055276e-02f, -1.90729573e-02f, 1.11809291e-01f, 3.79066914e-02f, 1.17958270e-01f, -1.17300926e-02f, -9.31542963e-02f, 1.45109911e-02f, -3.71722281e-02f, -3.46508548e-02f,
  -3.15722227e-02f, -3.86421382e-02f, 1.95893154e-01f, -6.70210868e-02f, 1.11961141e-01f, 9.00112651e-03f, -8.30408782e-02f, -4.79612052e-02f, -2.46945880e-02f, 3.24503519e-02f,
  5.60545474e-02f, 7.85453022e-02f, 5.95372356e-02f, 1.45561155e-02f, -7.35800993e-03f, 4.45747040e-02f, -1.34247676e-01f, -7.67095888e-04f, 2.06320900e-02f, 3.97509523e-02f,
  -2.90180370e-03f, -5.56132570e-03f, 1.31515756e-01f, -7.30459392e-02f, -2.18533073e-03f, 1.34724513e-01f, -1.30601798e-03f, -7.86654279e-02f, -2.57030427e-02f, 2.78917495e-02f,
  -5.66673540e-02f, 1.64282955e-02f, -4.56333198e-02f, -5.48765697e-02f, 7.11412984e-04f, 9.00864415e-03f, 1.71878096e-02f, 7.10269511e-02f, -5.25374487e-02f, -1.88472737e-02f,
  9.54817235e-02f, 1.42389074e-01f, -5.75757362e-02f, -1.36843219e-01f, -1.63305283e-01f, 5.05186506e-02f, 7.97079951e-02f, 1.36005908e-01f, -6.25602528e-02f, 3.60590480e-02f,
  1.09371440e-02f, -4.06165011e-02f, -5.49915098e-02f, -7.85717219e-02f, -5.50773107e-02f, 5.34805693e-02f, -2.29182705e-01f, 5.79405725e-02f, -1.29009709e-01f, 5.98747320e-02f,
  -6.32147118e-02f, 5.19805327e-02f, -3.55970711e-02f, 3.64532582e-02f, -4.89119627e-02f, -1.62138984e-01f, -7.12391958e-02f, 4.59151715e-02f, -1.01413094e-01f, 1.22945458e-02f,
  -4.84289974e-03f, 1.61737069e-01f, -1.89930603e-01f, 2.29946420e-01f, -2.49645755e-01f, 3.09413791e-01f, 5.59870064e-01f, -1.64701968e-01f, -1.87613130e-01f, 3.71206015e-01f,
  1.52615204e-01f, 2.34702259e-01f, 3.59513223e-01f, 5.11015356e-01f, -2.50412971e-02f, 2.93511719e-01f, 3.37063551e-01f, 2.18421921e-01f, -5.23914397e-02f, -2.72825323e-02f,
  -2.94079363e-01f, 3.70050371e-01f, 1.20447436e-03f, -1.87727973e-01f, 1.35764137e-01f, -1.78782254e-01f, 5.11830337e-02f, -3.06819938e-02f, 3.82703654e-02f, 1.08021051e-01f,
  9.64101963e-03f, 4.36033271e-02f, -1.21689282e-01f, -2.97977347e-02f, 7.22353980e-02f, -4.96625789e-02f, 1.25680670e-01f, 7.66121149e-02f, 8.88379663e-03f, 1.12128854e-01f,
  1.24915391e-01f, 2.31185947e-02f, 3.27221528e-02f, 3.84028852e-02f, -5.53447846e-03f, -1.51936069e-01f, -1.38149202e-01f, -4.93878461e-02f, -6.31958619e-02f, -1.38533145e-01f,
  -3.77714522e-02f, 5.95939578e-03f, -1.17963059e-02f, 2.71307863e-02f, -1.06574759e-01f, 8.21592584e-02f, 1.94461811e-02f, 1.35539070e-01f, 1.44013418e-02f, 3.99906635e-02f,
  -2.15362348e-02f, 7.13279173e-02f, 2.54571140e-02f, -6.97727799e-02f, 2.51710205e-03f, -1.11237196e-02f, 1.06033832e-01f, 5.10331281e-02f, -2.08380688e-02f, 4.83392216e-02f,
  -5.41765168e-02f, -1.28320277e-01f, 9.27615613e-02f, -4.03159671e-02f, 5.24684638e-02f, 7.56209344e-02f, -5.94504401e-02f, -2.08513662e-02f, -2.47484632e-02f, -9.38727930e-02f,
  1.59034077e-02f, 1.48726646e-02f, -1.74655300e-02f, 3.76014523e-02f, 8.59300867e-02f, -3.21717970e-02f, 1.43551722e-01f, 3.14101353e-02f, 3.48540135e-02f, 9.35486853e-02f,
  9.72038880e-02f, 3.99473220e-01f, 5.87809719e-02f, 5.22482097e-02f, 5.41012455e-03f, -1.07636437e-01f, 1.20673709e-01f, -4.16766241e-04f, 4.93366942e-02f, 7.03488961e-02f,
  5.80149777e-02f, -7.24116042e-02f, -7.14513510e-02f, 1.55963395e-02f, -5.52881509e-02f, 2.25634929e-02f, 6.53781667e-02f, 8.26223642e-02f, -1.04917475e-04f, -1.27106428e-01f,
  1.44592701e-02f, 1.70242473e-01f, -6.89647719e-02f, 9.88615751e-02f, -2.99621979e-03f, 3.69640291e-02f, -9.50057507e-02f, -1.85403842e-02f, 9.62339714e-02f, 9.48378723e-03f,
  4.09683615e-01f, -2.08817378e-01f, 2.09568158e-01f, -5.03922962e-02f, 6.91095889e-02f, 3.04721564e-01f, 4.56192762e-01f, -3.32306087e-01f, -3.67637247e-01f, -3.24236661e-01f,
  5.55341765e-02f, 2.10659966e-01f, 3.22991878e-01f, -1.37344062e-01f, 3.10904413e-01f, 4.94535230e-02f, -2.12188065e-01f, 3.13768862e-03f, -1.14568435e-01f, -1.29135475e-01f,
  -7.39920214e-02f, -5.80056682e-02f, 3.03321630e-01f, -3.68717939e-01f, 1.35611901e-02f, -2.19980478e-01f, -1.62477568e-01f, 1.46055236e-01f, -1.74831197e-01f, 8.53795707e-02f,
  3.23857106e-02f, -2.32711151e-01f, 1.84518442e-01f, -1.44939795e-02f, 9.94334444e-02f, 2.05364332e-01f, 2.06513032e-01f, 1.97377980e-01f, -5.11085503e-02f, 2.10862271e-02f,
  1.02168933e-01f, -8.64903927e-02f, -1.31080478e-01f, 1.23873666e-01f, -1.56499580e-01f, -9.05564353e-02f, -6.83205873e-02f, -6.15428872e-02f, -1.00343131e-01f, 1.58608869e-01f,
  1.01415344e-01f, -6.34189248e-02f, -1.10487312e-01f, -4.99366261e-02f, -1.09582476e-01f, -1.25737041e-01f, 3.66669185e-02f, 1.61889702e-01f, -1.52042344e-01f, -7.69444555e-03f,
  -5.35521694e-02f, 1.71979927e-02f, 1.41859412e-01f, -8.17587692e-03f, 3.69232823e-03f, -4.42281142e-02f, -1.06387682e-01f, -3.90984789e-02f, 1.38058171e-01f, 1.57300338e-01f,
  -8.05731118e-02f, -4.78656888e-02f, -6.83888281e-03f, 3.44577618e-02f, 2.56758314e-02f, -3.40867601e-02f, 3.35779488e-02f, -2.95958184e-02f, 1.64983496e-02f, -4.48575802e-02f,
  -1.04605695e-02f, -1.42910197e-01f, 2.74750963e-02f, -7.61192665e-02f, -1.24271862e-01f, 1.05801165e-01f, 4.52426076e-02f, 6.25359043e-02f, -1.05609046e-02f, 1.12144172e-01f,
  -9.08714831e-02f, -2.53946275e-01f, -4.27686311e-02f, -1.23438194e-01f, 1.71652958e-01f, 9.13082529e-03f, 9.02222246e-02f, -1.21858709e-01f, -3.84674631e-02f, -3.65761071e-02f,
  -1.14861235e-01f, -5.68893328e-02f, -1.39340684e-01f, -7.70164803e-02f, -9.00024921e-02f, -4.12160568e-02f, -3.59291174e-02f, -3.81400430e-04f, 2.84205098e-02f, -1.99846521e-01f,
  -2.99836285e-02f, -8.72212648e-02f, 6.09895075e-03f, -1.22846700e-01f, -1.30968839e-01f, 4.19659019e-02f, -1.08099639e-01f, 6.79018348e-02f, -1.22646153e-01f, -1.35298342e-01f,
  3.22011977e-01f, -1.45422757e-01f, -4.01151001e-01f, -9.82438177e-02f, 2.14087978e-01f, 2.10265830e-01f, -1.47747517e-01f, 3.01125040e-03f, -2.54397273e-01f, 1.14851661e-01f,
  2.33115539e-01f, -1.00653283e-02f, -1.69136241e-01f, 4.43646133e-01f, 3.91621679e-01f, 1.42157096e-02f, 2.29478583e-01f, 9.55193043e-02f, -1.69059724e-01f, 1.95985332e-01f,
  8.32780898e-02f, 4.60153610e-01f, 3.87847200e-02f, 1.57377124e-01f, 2.50217915e-01f, -2.16753423e-01f, 1.41834497e-01f, -9.35658142e-02f, 3.18547875e-01f, 3.62401575e-01f,
  5.19348122e-02f, 1.09083973e-01f, 2.07436481e-03f, 3.85881476e-02f, 9.18659195e-03f, 1.24909717e-03f, -9.88482982e-02f, 9.08710286e-02f, -6.35256544e-02f, -9.88765806e-02f,
  -1.15722353e-02f, 7.90082589e-02f, 6.93517849e-02f, 3.58177982e-02f, 4.89529669e-02f, -6.37714891e-03f, -8.51590037e-02f, 4.38325526e-03f, -1.77510053e-01f, 1.16561957e-01f,
  -1.29541188e-01f, -1.12963557e-01f, 4.22964543e-02f, 6.01175889e-05f, -1.12390546e-02f, -1.10422648e-01f, -6.19129054e-02f, -7.87911117e-02f, 7.17249466e-03f, 5.75443208e-02f,
  1.55654415e-01f, 6.28740042e-02f, 8.18331242e-02f, 1.14383608e-01f, -4.22822572e-02f, -1.29509550e-02f, 7.67383799e-02f, -5.37791438e-02f, -1.42558053e-01f, -5.73421121e-02f,
  -5.43645732e-02f, -2.08960101e-02f, 9.01886672e-02f, -2.57218815e-02f, -5.45577146e-04f, -7.18111917e-02f, -4.26734611e-02f, 2.36850954e-03f, -1.07483856e-01f, -1.69184029e-01f,
  3.31850648e-02f, -9.81865451e-02f, 6.45755157e-02f, 3.75383757e-02f, 3.47143002e-02f, -3.61087099e-02f, -1.84459686e-02f, 7.11085200e-02f, -6.70063794e-02f, -3.56092341e-02f,
  3.16055715e-02f, 1.07902661e-01f, -2.04933509e-02f, 2.33053956e-02f, -1.33355677e-01f, 1.69745490e-01f, 1.01438276e-01f, -3.32227610e-02f, 5.97545654e-02f, -1.21264746e-02f,
  1.08058758e-01f, -9.80288535e-02f, -1.28625345e-03f, 9.48049873e-02f, -6.58056214e-02f, 3.50802355e-02f, -2.53048167e-02f, -9.96092111e-02f, -1.81472108e-01f, 1.83483176e-02f,
  -4.40000407e-02f, 9.07250121e-03f, -8.96592438e-02f, -8.45781937e-02f, 5.26762456e-02f, -7.14143738e-02f, -1.55709442e-02f, 1.44656254e-02f, 7.16287717e-02f, -8.75527933e-02f,
  -3.39295924e-01f, -9.12823305e-02f, 1.20284490e-01f, 3.56050014e-01f, 1.51751526e-02f, -3.80470246e-01f, -1.31007522e-01f, 7.80045688e-02f, -2.70481408e-01f, 1.73139974e-01f,
  3.99079710e-01f, -6.64501563e-02f, 3.91372651e-01f, -1.65408313e-01f, -2.17168108e-01f, -1.14540063e-01f, -1.20895140e-01f, -2.39888534e-01f, 5.69532216e-02f, 2.08503261e-01f,
  -7.04520419e-02f, 7.11274296e-02f, 1.56319112e-01f, -1.49071133e-02f, -3.47888768e-02f, 3.52996498e-01f, 4.85978454e-01f, 3.16226125e-01f, 1.67122602e-01f, -6.74150810e-02f,
  -1.18752986e-01f, 3.34309228e-03f, -4.60689235e-03f, -2.28845417e-01f, 2.47998908e-02f, 1.56615693e-02f, 1.33233238e-02f, 1.37296095e-01f, 2.07104877e-01f, -9.43565145e-02f,
  -1.48372939e-02f, -1.74658727e-02f, -1.06097884e-01f, 2.20087916e-02f, -2.21855357e-01f, -5.39898872e-02f, -4.00423296e-02f, -3.11716814e-02f, 4.58225049e-03f, -7.25970194e-02f,
  3.04388162e-02f, 2.85788924e-02f, -7.39206374e-02f, 2.99535729e-02f, 6.17185496e-02f, 7.96025917e-02f, -4.04070504e-02f, 1.22227028e-01f, -1.51645154e-01f, 3.68751101e-02f,
  -9.83387157e-02f, 1.85528576e-01f, 1.04324117e-01f, -4.10632370e-03f, 1.33345470e-01f, -3.93136218e-02f, -1.34247005e-01f, 9.42008421e-02f, 4.09565605e-02f, 1.29672930e-01f,
  1.58554718e-01f, -1.09523378e-01f, -1.41513953e-02f, -1.97380036e-02f, 2.36950833e-02f, -1.07184589e-01f, 8.54267702e-02f, 4.48847972e-02f, 7.26701543e-02f, 2.27678232e-02f,
  1.90438002e-01f, -1.07348919e-01f, -1.07540734e-01f, 1.52058899e-02f, -9.79886651e-02f, 1.11470513e-01f, -6.72272891e-02f, -4.78946790e-02f, 1.88233405e-01f, 8.25119242e-02f,
  1.03353433e-01f, 5.49293518e-01f, 9.43829119e-02f, -1.90431058e-01f, -2.08628085e-03f, -4.36735749e-02f, -8.78395513e-02f, -1.39966339e-01f, 1.43177301e-01f, -1.57614395e-01f,
  1.45360101e-02f, -1.02927171e-01f, -8.10405686e-02f, -8.09059516e-02f, -4.94932709e-03f, 1.76054552e-01f, 7.04164505e-02f, 1.40020877e-01f, 1.24638729e-01f, 2.22245619e-01f,
  2.54070938e-01f, 1.98011339e-01f, 3.62601019e-02f, 9.59516969e-03f, -1.24885947e-01f, 1.16946839e-01f, -3.67067493e-02f, 2.18037665e-02f, -3.55902240e-02f, 1.11899242e-01f,
  6.14642382e-01f, 5.54478049e-01f, 5.14509082e-02f, 3.55221301e-01f, 1.60756446e-02f, 4.77613509e-01f, 2.37221777e-01f, 7.84225464e-02f, 2.53984779e-01f, 2.72012532e-01f,
  -1.49513349e-01f, 3.85900468e-01f, -3.93620223e-01f, 4.31932390e-01f, -2.35560313e-01f, -1.01494826e-01f, 2.88476288e-01f, 4.13755208e-01f, 3.11326180e-02f, 2.83860713e-01f,
  -7.32519180e-02f, -4.57591191e-02f, -3.80176544e-01f, -2.55503356e-01f, 2.75459021e-01f, 5.46856076e-02f, -5.75583994e-01f, -2.86219537e-01f, 2.42016762e-02f, -5.78529686e-02f,
  1.27004936e-01f, 5.26660644e-02f, 7.78978541e-02f, -2.14938149e-02f, -8.77106190e-03f, 2.45744009e-02f, -5.96627071e-02f, -5.33607006e-02f, -8.95797387e-02f, 6.94636405e-02f,
  9.73537564e-02f, -3.55533138e-02f, 1.12986103e-01f, -1.62681192e-01f, 1.31948739e-01f, 8.31348822e-03f, 4.48501483e-02f, 3.04798596e-02f, 1.08249627e-01f, 7.19343498e-02f,
  1.03852414e-01f, 8.80212113e-02f, 9.12847593e-02f, 1.42009063e-02f, -1.99233275e-03f, 1.32767871e-01f, 9.79575440e-02f, 5.10438569e-02f, 9.34472010e-02f, 9.59936827e-02f,
  3.33528817e-02f, 7.25841820e-02f, 2.63035707e-02f, -7.29816854e-02f, -7.16690067e-03f, 1.81044675e-02f, 1.38476370e-02f, -6.40784949e-02f, 5.65646403e-02f, 6.23533577e-02f,
  -1.96627006e-02f, -1.79622434e-02f, -8.86278227e-03f, 5.71126677e-02f, 7.04905689e-02f, 6.94214106e-02f, -1.62618570e-02f, 2.92595010e-02f, 1.04281165e-01f, -3.27005200e-02f,
  -1.68692037e-01f, -6.22666162e-03f, 1.14741400e-02f, -1.49482042e-01f, -1.11908205e-02f, -1.21364720e-01f, -4.06721085e-02f, 2.18480099e-02f, 1.42995389e-02f, -6.79702163e-02f,
  8.85043666e-02f, 1.53227344e-01f, -4.51719714e-03f, 2.70893946e-02f, -4.03917655e-02f, 4.92717698e-02f, 4.12336662e-02f, 1.59204453e-01f, -3.42686176e-02f, 5.00174761e-02f,
  8.81390050e-02f, 8.05053022e-03f, 8.91613439e-02f, 5.11540286e-02f, -5.81547059e-02f, 3.05759646e-02f, 2.23742295e-02f, -5.23054898e-02f, -7.18233781e-03f, -6.40456975e-02f,
  2.48149429e-02f, 1.85659558e-01f, 7.50526860e-02f, 4.29813042e-02f, 1.10579826e-01f, -7.81073719e-02f, 1.32610619e-01f, -5.23523986e-02f, -8.24773908e-02f, 4.18700911e-02f,
  -2.59056687e-01f, 1.36618037e-02f, 4.05722052e-01f, -4.02882397e-01f, 2.56157182e-02f, -1.70790534e-02f, -2.69387066e-01f, -1.15409009e-01f, -3.74705225e-01f, -3.40620816e-01f,
  -1.33076593e-01f, -1.07141644e-01f, 3.44553590e-01f, -3.49743873e-01f, 5.13520777e-01f, 3.59393567e-01f, -3.12771380e-01f, -3.35369200e-01f, 1.26305282e-01f, -1.20499894e-01f,
  -4.93876375e-02f, -3.03289920e-01f, 2.99667031e-01f, -1.50709614e-01f, -1.80434659e-01f, -2.02310905e-01f, -1.18821161e-02f, -2.12030741e-03f, -1.47130296e-01f, -4.69604172e-02f,
  -5.71054742e-02f, -7.60382339e-02f, 1.29323512e-01f, 9.04226527e-02f, 6.19192980e-02f, 3.08808889e-02f, -5.85744008e-02f, -3.40421610e-02f, -6.38593957e-02f, 1.97622273e-02f,
  -1.89471945e-01f, 4.58923578e-02f, -2.16265365e-01f, 1.41608834e-01f, -1.85707688e-01f, -3.43459435e-02f, -5.00166416e-02f, 4.66171876e-02f, -3.81421782e-02f, 7.97070414e-02f,
  6.90644905e-02f, 1.00798495e-02f, 2.73398273e-02f, -6.53223461e-03f, 6.69756234e-02f, -6.74495921e-02f, -2.47704908e-02f, 1.86148882e-01f, 3.13139334e-02f, 9.82230343e-03f,
  -5.17634265e-02f, 5.00623621e-02f, -3.43639404e-02f, 7.33577013e-02f, -1.18286446e-01f, -9.69861448e-02f, 1.80995860e-03f, -1.86076981e-03f, -1.12057701e-01f, -1.22700587e-01f,
  -6.49842322e-02f, 1.25016734e-01f, -2.58606207e-02f, -1.01799101e-01f, -1.88937739e-01f, -9.23495914e-04f, 5.83632477e-02f, 2.44227611e-02f, -1.16328418e-01f, -2.41106506e-02f,
  -1.32623106e-01f, -2.65944861e-02f, 4.85539762e-03f, 7.17380941e-02f, -2.88797310e-03f, 8.03015381e-02f, -1.15759462e-01f, 1.49890453e-01f, 1.66794196e-01f, 4.83867079e-02f,
  1.28080353e-01f, 8.99973139e-02f, -1.06561117e-01f, -7.23914653e-02f, -7.21199904e-04f, 1.59583271e-01f, -4.03862111e-02f, -7.04996288e-02f, -5.35166264e-02f, 5.96109889e-02f,
  -7.99227655e-02f, -1.48583101e-02f, -9.19585451e-02f, -3.52151133e-02f, 5.93954474e-02f, 3.58235314e-02f, -1.79010123e-01f, -2.28265241e-01f, 6.14201948e-02f, 9.68712196e-02f,
  -9.89345685e-02f, -1.92352936e-01f, 1.14479519e-01f, -1.65497363e-01f, 4.85560745e-02f, 7.55592585e-02f, 1.04289010e-01f, -1.21117540e-01f, -1.21064503e-02f, 6.45679310e-02f,
  -2.88031727e-01f, 3.39694619e-01f, -2.42660493e-01f, -3.54417413e-01f, 1.16720535e-02f, -2.13119194e-01f, -2.91946441e-01f, 1.17741503e-01f, 2.51732115e-02f, 1.90689173e-02f,
  -4.56401743e-02f, 1.69017799e-02f, 3.45305681e-01f, -2.09093556e-01f, -1.38454542e-01f, 1.92399681e-01f, -4.44594502e-01f, -3.30169797e-01f, 1.44630268e-01f, -1.95589080e-01f,
  -1.68746918e-01f, -1.13102749e-01f, -1.89322874e-01f, 1.57519415e-01f, -1.41553894e-01f, -8.24529380e-02f, -2.53628492e-01f, 1.82266608e-01f, -2.84291297e-01f, 9.01096985e-02f,
  -9.60054174e-02f, 1.43127382e-01f, -1.16020545e-01f, -2.24120147e-03f, -3.01423639e-01f, -1.44376263e-01f, -2.15937868e-01f, 3.74179035e-02f, 5.02142273e-02f, -5.33096539e-03f,
  7.11538419e-02f, 1.22198677e-02f, -1.51210397e-01f, 1.46257624e-01f, -1.42249940e-02f, -1.29810546e-03f, 1.01372316e-01f, -1.21909715e-01f, 5.25528006e-02f, 1.54460356e-01f,
  1.63040105e-02f, -7.08113424e-03f, -1.84613958e-01f, 3.55584896e-03f, 1.04854777e-02f, 1.21446095e-01f, -1.02316648e-01f, -1.20944932e-01f, -5.27575687e-02f, -4.81207557e-02f,
  -1.19691141e-01f, 8.21959600e-03f, 4.37026098e-02f, 1.74197033e-02f, 9.17594582e-02f, 6.75829947e-02f, 3.81898507e-02f, -3.63958962e-02f, -4.48432565e-02f, 1.51525680e-02f,
  -2.93306839e-02f, 1.72340591e-02f, 6.87738732e-02f, -2.42148340e-02f, -7.34779164e-02f, 5.42308167e-02f, -3.59497927e-02f, -2.01431308e-02f, -1.64024398e-01f, 4.74688113e-02f,
  8.36801603e-02f, -6.52752295e-02f, -2.52269059e-02f, 2.27281582e-02f, -2.71784049e-02f, 6.79018870e-02f, -7.54887564e-03f, 1.80019382e-02f, 5.39590977e-02f, -1.71035714e-02f,
  -8.36582556e-02f, -2.45551005e-01f, 4.03776057e-02f, 7.03614056e-02f, -5.70663996e-02f, -1.02069840e-01f, 4.16119508e-02f, -4.57405224e-02f, -3.16384882e-02f, -1.54510289e-01f,
  -2.17519671e-01f, -1.57708317e-01f, -2.66827166e-01f, 9.21155810e-02f, 7.50725940e-02f, -8.02213624e-02f, -9.00259539e-02f, -5.18913306e-02f, -1.63390577e-01f, -4.72804345e-02f,
  -2.19571382e-01f, -5.01155294e-02f, -2.86328252e-02f, -6.05761930e-02f, -1.37355596e-01f, -1.36499628e-01f, -8.49425122e-02f, 1.31362349e-01f, 4.58976105e-02f, -8.72962326e-02f,
  -5.38417578e-01f, 2.18969971e-01f, -3.49287093e-01f, -9.78528857e-02f, 1.22990169e-01f, -4.01243359e-01f, 6.07105494e-02f, 1.38079375e-01f, 3.53032827e-01f, 1.37168169e-01f,
  2.60942936e-01f, 9.03476998e-02f, 3.27643722e-01f, -6.08150139e-02f, -4.70117837e-01f, -1.87919796e-01f, -1.76779881e-01f, -1.02682479e-01f, 1.40736639e-01f, 1.84978262e-01f,
  -1.25693515e-01f, 2.13065803e-01f, -3.81323427e-01f, 3.51459324e-01f, -8.61901939e-02f, 7.58613786e-03f, 3.84979211e-02f, 2.70187020e-01f, -3.32694829e-01f, -7.03946920e-03f,
  -2.61239141e-01f, 1.91049397e-01f, -1.16805345e-01f, -1.07869551e-01f, -2.52327353e-01f, -6.96166828e-02f, -3.13719921e-02f, 2.13416517e-02f, -7.61251971e-02f, 4.91360649e-02f,
  -7.41016306e-03f, 9.49952528e-02f, 1.39281213e-01f, 1.23408325e-01f, 1.41476661e-01f, 1.89056788e-02f, -2.14705348e-01f, -1.73324123e-01f, 4.61488515e-02f, -1.54186502e-01f,
  -2.97969490e-01f, -2.16528401e-01f, -9.22164470e-02f, -9.79990885e-02f, -3.32478248e-02f, -2.13136990e-03f, -2.04608977e-01f, -1.77461982e-01f, -6.35813251e-02f, -1.62812844e-01f,
  6.65413365e-02f, 2.80270819e-02f, 8.44744146e-02f, 1.08936548e-01f, -9.20778289e-02f, -2.90297400e-02f, -1.77072156e-02f, -2.31816992e-02f, 9.49720219e-02f, -5.89492172e-02f,
  6.35644048e-02f, -1.83813497e-02f, 3.48220021e-02f, -2.66993642e-01f, -1.93055104e-02f, 1.80738851e-01f, 6.12608753e-02f, 5.25907017e-02f, -1.01809418e-02f, -8.76913890e-02f,
  1.47470817e-01f, -2.88979057e-02f, -1.42809339e-02f, -6.48621619e-02f, -7.15156570e-02f, -1.09359562e-01f, 7.05307424e-02f, -2.10620955e-01f, -1.66143328e-02f, 2.19971891e-02f,
  1.60678744e-01f, 4.06259984e-01f, 1.31915495e-01f, 6.52803853e-02f, 8.46582204e-02f, 6.20500781e-02f, 7.51058757e-02f, -2.64719427e-01f, 3.18652391e-02f, 1.77706346e-01f,
  8.24783221e-02f, 5.11891656e-02f, 1.29855787e-02f, -2.37880014e-02f, -1.25054726e-02f, -5.19644767e-02f, 9.07745287e-02f, 9.07503515e-02f, 1.01213213e-02f, -5.05922250e-02f,
  1.07934713e-01f, 8.88996422e-02f, -7.69969076e-03f, 6.22566650e-03f, 1.38270780e-01f, -2.12182011e-02f, 5.59706129e-02f, -1.40879110e-01f, -1.04793154e-01f, -6.66574538e-02f,
  1.08449683e-01f, 4.16226357e-01f, 1.98447615e-01f, 8.56995657e-02f, -8.31961259e-02f, -5.05501688e-01f, -5.40977865e-02f, 1.78616643e-01f, 2.86823630e-01f, 2.79511422e-01f,
  -1.89715445e-01f, 3.81452501e-01f, 9.56849381e-02f, -2.21183166e-01f, -3.14648271e-01f, -3.56535912e-01f, -2.71493018e-01f, -2.02801436e-01f, 5.52780479e-02f, 3.24958712e-02f,
  -1.71718821e-01f, -1.49711028e-01f, -1.59669876e-01f, 2.51863927e-01f, 1.31853193e-01f, 3.03387403e-01f, -1.99855924e-01f, 2.77762026e-01f, 3.14681120e-02f, -2.25957129e-02f,
  -4.12837900e-02f, 2.06321701e-01f, 1.68870270e-01f, 7.78577849e-02f, -6.24274090e-02f, -6.50119334e-02f, 4.77943309e-02f, -4.80733290e-02f, -3.70992757e-02f, 1.27701774e-01f,
  1.17868707e-01f, 9.88383144e-02f, 5.65746017e-02f, 1.01710573e-01f, 1.68415718e-02f, 1.72278389e-01f, 1.21906310e-01f, -4.13211323e-02f, 1.61507279e-01f, 8.94046128e-02f,
  6.25608712e-02f, 1.08734116e-01f, 5.19525595e-02f, 2.53783967e-02f, 9.23390016e-02f, -5.92076257e-02f, -6.51364550e-02f, 5.49125811e-03f, 2.32763658e-03f, 1.16989864e-02f,
  1.01444654e-01f, -6.75389543e-02f, 2.23247241e-02f, 1.64541125e-01f, 1.43924430e-02f, 1.15803722e-02f, 5.48717640e-02f, -1.49760786e-02f, -7.11720530e-03f, -3.96240540e-02f,
  -5.32836430e-02f, 1.66127220e-01f, -2.73523126e-02f, -2.34313793e-02f, -6.08171858e-02f, 5.70358969e-02f, 6.98709339e-02f, 1.37281135e-01f, -7.32524544e-02f, 4.75151986e-02f,
  9.95799303e-02f, -2.13086143e-01f, 1.12662144e-01f, -7.24376887e-02f, -1.00129351e-01f, -2.77730078e-02f, 1.22580998e-01f, 8.99773985e-02f, 2.27047689e-03f, -1.06145516e-01f,
  -2.40069836e-01f, -3.50028500e-02f, -6.27990216e-02f, 1.16483934e-01f, -5.04449792e-02f, -1.16687477e-01f, -3.89677621e-02f, 6.39705434e-02f, -9.34397131e-02f, 5.89354597e-02f,
  -2.49799993e-02f, 1.16301812e-02f, -1.45568565e-01f, -1.63178280e-04f, -1.28963977e-01f, -9.24836248e-02f, -1.37572200e-03f, 7.24451710e-03f, -1.16647534e-01f, -6.14758320e-02f,
  1.69419453e-01f, -8.48488510e-02f, 1.41101805e-02f, 2.09429837e-03f, -1.84240472e-02f, -6.14651330e-02f, 9.84979495e-02f, 3.50030065e-02f, 2.08316296e-02f, -2.53371391e-02f,
  6.05155110e-01f, -2.34139934e-01f, 5.76548100e-01f, 4.36662912e-01f, 1.49504051e-01f, 3.82383823e-01f, 5.12750387e-01f, 1.53299272e-01f, 5.92415452e-01f, -4.18716490e-01f,
  -4.94313300e-01f, 1.42820746e-01f, -3.32664661e-02f, -2.55329251e-01f, 1.84516802e-01f, 2.74305969e-01f, 1.68485120e-01f, 1.07075516e-02f, 7.84802958e-02f, -4.83205467e-02f,
  -8.59802663e-02f, -4.88343656e-01f, -1.80806831e-01f, -3.59475523e-01f, -3.09424996e-01f, -1.65028095e-01f, -4.40250188e-01f, -9.30523872e-03f, -3.80083859e-01f, -1.17820166e-01f,
  -3.16840619e-01f, 2.31486280e-02f, -7.84712955e-02f, -5.14386706e-02f, -6.89585581e-02f, 6.52502477e-02f, 1.06615730e-01f, 1.31862968e-01f, -2.84555349e-02f, -3.86321694e-02f,
  6.69835955e-02f, -6.20126426e-02f, -1.15225255e-01f, 3.39366980e-02f, 1.18359439e-01f, -8.26427131e-04f, 3.86730842e-02f, -9.18883532e-02f, -6.08637892e-02f, 2.17362434e-01f,
  2.66577676e-02f, 3.62033118e-03f, 2.50186585e-02f, -6.44601434e-02f, 1.38427183e-01f, -1.23190410e-01f, 1.88103095e-01f, 2.34979596e-02f, -4.03521247e-02f, 1.66588023e-01f,
  6.23963885e-02f, 1.86321348e-01f, -5.38459308e-02f, -1.28354486e-02f, -7.15130866e-02f, -1.15399502e-01f, -2.55801156e-02f, -8.11011810e-03f, 7.28071034e-02f, -2.64216476e-04f,
  5.65050989e-02f, -7.33105242e-02f, 1.60176232e-01f, 1.56627938e-01f, -7.20125586e-02f, -6.96856081e-02f, -1.07700616e-01f, 3.78503501e-02f, -1.11145891e-01f, 6.68929294e-02f,
  1.08519709e-02f, 4.82294373e-02f, -1.17000438e-01f, 5.61437570e-02f, -1.19355693e-01f, 3.12904455e-02f, -1.94328338e-01f, 2.50924863e-02f, 6.09049946e-02f, -1.24790169e-01f,
  -1.88686043e-01f, -1.44974515e-01f, -6.25946373e-02f, -2.10846126e-01f, 2.55369823e-02f, -2.19960675e-01f, 1.02818735e-01f, -3.15293781e-02f, 6.29522279e-02f, -3.59299146e-02f,
  -1.05252840e-01f, -6.88268542e-02f, -5.11500388e-02f, 8.76675248e-02f, -5.83333485e-02f, -1.36912644e-01f, -2.94230264e-02f, -7.38451853e-02f, 2.97062658e-02f, -1.14341274e-01f,
  -1.30610466e-01f, -4.24985215e-02f, -7.99330100e-02f, -1.28786191e-01f, -4.77976017e-02f, 3.14614400e-02f, 8.08370858e-02f, -4.53479849e-02f, 3.13293189e-02f, 4.34892140e-02f,
  3.28033894e-01f, -3.23535740e-01f, -3.31231743e-01f, -3.45045209e-01f, 1.04211219e-01f, -4.97755781e-02f, -2.61321366e-01f, -3.08462501e-01f, -4.24097896e-01f, 1.74623393e-02f,
  -2.03682974e-01f, -9.71771404e-02f, -1.58883333e-01f, -2.36947924e-01f, 3.38577889e-02f, -1.68108895e-01f, -1.38753414e-01f, 8.57152939e-02f, -2.31363513e-02f, -1.22519650e-01f,
  -8.90889168e-02f, -1.23222806e-01f, -1.73442662e-01f, -5.90417534e-02f, -8.81079957e-02f, 6.11852035e-02f, 2.01351643e-01f, -3.88114601e-02f, 7.15757832e-02f, -1.94892198e-01f,
  2.95982901e-02f, -9.07653943e-02f, -9.62209627e-02f, 1.77207254e-02f, 5.91155887e-02f, 1.93487212e-01f, 1.59992203e-01f, 2.91468594e-02f, -3.77189144e-02f, -9.16442648e-02f,
  1.12191424e-01f, -2.38625053e-03f, 6.43096939e-02f, -5.80612477e-03f, 5.58951013e-02f, -1.01640381e-01f, -2.84090135e-02f, 5.48069626e-02f, -1.51459202e-01f, 4.22133319e-02f,
  -1.91475183e-01f, 1.17512502e-01f, -5.15190884e-02f, -8.56909230e-02f, -9.83911902e-02f, -8.68213847e-02f, 7.10616633e-02f, 5.36316587e-03f, 6.96418136e-02f, -5.72950467e-02f,
  1.05264924e-01f, 9.70951393e-02f, 1.24429062e-01f, -6.50406480e-02f, -4.74424064e-02f, 4.54846807e-02f, 1.11277355e-02f, -4.50684242e-02f, -9.32001546e-02f, 6.01315275e-02f,
  1.02937901e-02f, -6.81224465e-02f, -8.55021253e-02f, -1.38485193e-01f, 1.37994990e-01f, -2.67060194e-02f, 7.37284720e-02f, 7.15238675e-02f, -3.14990431e-02f, 1.10558674e-01f,
  1.32950107e-02f, 3.86348329e-02f, -2.08617169e-02f, 6.86576171e-03f, -1.88283995e-02f, -8.35317001e-02f, -1.37724576e-03f, -7.07038566e-02f, 1.03042489e-02f, 1.19366646e-01f,
  1.03950933e-01f, 7.65217375e-03f, -3.14732306e-02f, -1.84975006e-02f, -9.69554931e-02f, 9.68892574e-02f, 3.38257402e-02f, -2.25933492e-02f, 6.42453646e-03f, -1.65247880e-02f,
  1.55140027e-01f, 2.84282900e-02f, 1.80517808e-01f, -3.30880210e-02f, -7.26316944e-02f, 1.51127419e-02f, 1.99126191e-02f, 8.68105292e-02f, 6.08600909e-04f, 6.10529594e-02f,
  4.38617496e-03f, 1.34254798e-01f, -3.35455053e-02f, -3.33955674e-03f, 2.88229641e-02f, 3.43381278e-02f, 1.47075325e-01f, -1.03251651e-01f, 7.72349983e-02f, -7.66560584e-02f,
  4.87985134e-01f, -5.73814929e-01f, 2.52587616e-01f, 4.85270709e-01f, 1.92158595e-01f, 1.31124437e-01f, 3.01684678e-01f, -1.16587348e-01f, 3.17161530e-01f, -2.95882672e-01f,
  -3.92621517e-01f, 1.09931640e-01f, -5.04530609e-01f, 2.28250742e-01f, 1.97769031e-01f, -2.30279446e-01f, 1.64463043e-01f, 2.75106639e-01f, 1.16531946e-01f, 2.95258183e-02f,
  1.11380778e-01f, 2.70196125e-02f, -1.32307410e-01f, -2.28849828e-01f, 6.81723794e-03f, 1.71015084e-01f, -2.08867133e-01f, -1.71165969e-02f, 2.32051030e-01f, 1.94893911e-01f,
  -1.87828049e-01f, 1.14757894e-02f, -1.32792001e-03f, -1.59189291e-02f, -6.10435195e-02f, -5.51590323e-02f, 6.82104602e-02f, 2.19416358e-02f, 7.31777921e-02f, 3.79052050e-02f,
  -1.47790099e-02f, -4.64226343e-02f, 2.01589957e-01f, 1.13831706e-01f, 6.21176288e-02f, 8.39685947e-02f, 1.47866637e-01f, -1.27144516e-01f, -2.33772844e-02f, -1.79421827e-02f,
  -8.80234390e-02f, 4.82436176e-03f, -8.52031410e-02f, 1.37017101e-01f, -2.23165452e-02f, 2.18514338e-01f, 1.01526484e-01f, 3.95546369e-02f, 7.23758489e-02f, 1.57844424e-01f,
  9.67196897e-02f, -7.24309012e-02f, -6.34153336e-02f, 2.12922189e-02f, -1.08420402e-02f, -4.32343781e-03f, -1.40391653e-02f, -1.81509014e-02f, -5.92471547e-02f, -4.45283353e-02f,
  5.32852933e-02f, 7.08199814e-02f, 3.24571021e-02f, 5.21512777e-02f, 7.04911426e-02f, 6.34847581e-02f, -1.73635092e-02f, 5.04785515e-02f, 3.14741991e-02f, -5.77721335e-02f,
  -9.41229314e-02f, 2.43361872e-02f, -7.43902922e-02f, -1.57453809e-02f, 5.19660115e-02f, -7.48989284e-02f, -1.00199215e-01f, 2.61328127e-02f, 6.30354509e-02f, -8.59737173e-02f,
  -5.16728818e-01f, -2.11308509e-01f, -1.34981737e-01f, 1.32668181e-03f, 9.03058797e-02f, -1.35587528e-01f, 5.40676787e-02f, 4.67890687e-03f, -1.02041505e-01f, -7.83701986e-02f,
  -5.57757951e-02f, -1.67933747e-03f, -2.15575136e-02f, 5.17456271e-02f, -8.02993402e-02f, -1.86879441e-01f, 7.01559633e-02f, -7.96514228e-02f, -2.00288650e-02f, -8.55199993e-02f,
  -5.72272800e-02f, -3.02013513e-02f, 6.16901517e-02f, 1.02505172e-02f, -3.59476544e-02f, 6.11498058e-02f, 1.65390354e-02f, 8.19265470e-03f, -1.27364630e-02f, 5.69817238e-02f,
  2.16144115e-01f, -4.09472495e-01f, -4.01281893e-01f, 7.25223795e-02f, 1.05008699e-01f, 1.14849051e-02f, 2.12178782e-01f, -1.26859069e-01f, -7.77105317e-02f, 8.48873705e-02f,
  5.74841142e-01f, -3.22656244e-01f, 1.70883819e-01f, 5.30972004e-01f, 7.93380961e-02f, 6.25936016e-02f, 2.37824932e-01f, 2.66414195e-01f, -6.27587065e-02f, 1.18602170e-02f,
  7.22364336e-03f, 2.06981972e-01f, 2.35893250e-01f, -2.81886786e-01f, 1.91993684e-01f, -3.56037885e-01f, 2.12611526e-01f, -1.54078826e-01f, 1.03590116e-01f, -6.87521622e-02f,
  2.02779382e-01f, 1.06878057e-01f, 1.26924589e-01f, -1.13760576e-01f, -1.14389658e-01f, 6.71831742e-02f, -1.15805706e-02f, 3.67232561e-02f, 5.90159111e-02f, 4.17794958e-02f,
  -9.49733704e-02f, -2.99564283e-02f, -8.37242529e-02f, -2.90723611e-02f, -2.32476406e-02f, -1.10203102e-01f, 2.36016873e-04f, 1.14271976e-01f, -6.43737242e-02f, 1.02067865e-01f,
  7.74656683e-02f, -1.15905412e-01f, 1.63395137e-01f, -8.79184306e-02f, 8.33554715e-02f, -6.38493821e-02f, 9.84001718e-03f, -4.42085639e-02f, -1.00390166e-01f, -1.39682248e-01f,
  -3.72534394e-02f, -7.90250972e-02f, 1.06091008e-01f, 8.83802772e-02f, 1.90514605e-03f, 1.00156434e-01f, 4.36783507e-02f, 9.39958021e-02f, -1.33153394e-01f, -1.99271757e-02f,
  2.70204842e-02f, -6.85527697e-02f, 4.63199764e-02f, 1.11799277e-01f, -8.21323786e-03f, -7.11283684e-02f, -3.93901691e-02f, -9.21023637e-02f, 8.19851160e-02f, 1.36860877e-01f,
  1.80536970e-01f, -1.33996323e-01f, 9.22311991e-02f, 1.07709154e-01f, -7.51775578e-02f, 5.01405187e-02f, 8.20143074e-02f, 9.85634774e-02f, -1.74659453e-02f, -4.00055535e-02f,
  -8.74002203e-02f, -3.34811121e-01f, -4.60311472e-02f, -8.14702585e-02f, -3.72610204e-02f, -7.19416589e-02f, -5.20628318e-02f, -1.44287929e-01f, 9.92248356e-02f, 6.59968413e-04f,
  -4.14032675e-02f, -6.53160438e-02f, 2.25800108e-02f, 1.27430081e-01f, -1.24018423e-01f, 3.52662825e-03f, -1.04677677e-01f, -4.99577587e-03f, -1.20272756e-01f, -2.02176556e-01f,
  -8.77592489e-02f, -9.47978571e-02f, -3.74494493e-02f, 5.18992618e-02f, -5.90217812e-03f, -5.31682037e-02f, -1.03859365e-01f, 7.12243840e-03f, -4.22461741e-02f, -1.02000184e-01f,
  4.80362624e-01f, -3.26104790e-01f, 1.42378861e-03f, 3.44421268e-01f, 4.16084796e-01f, 3.27952355e-01f, 2.03117117e-01f, 3.65274459e-01f, 4.22738105e-01f, -2.61149853e-01f,
  5.28014526e-02f, -1.91583991e-01f, -2.08148643e-01f, 1.49302036e-01f, 3.64447057e-01f, -9.92312208e-02f, 2.32000843e-01f, 2.00660229e-01f, 9.61020440e-02f, 1.49054289e-01f,
  2.02715993e-01f, 3.17166746e-01f, -1.24453492e-01f, -1.66948233e-02f, 1.44869775e-01f, -8.87313783e-02f, -9.18606594e-02f, -9.82104763e-02f, -3.90747525e-02f, 2.05481082e-01f,
  1.21193744e-01f, -7.28193671e-03f, 3.74709703e-02f, -1.49330959e-01f, -2.63990872e-02f, -4.15472500e-02f, -9.38305706e-02f, 9.20323730e-02f, 1.05574526e-01f, -1.08889155e-01f,
  -1.79836854e-01f, 5.32191135e-02f, -4.15809862e-02f, -2.72794310e-02f, 1.05595343e-01f, 5.52384220e-02f, -6.31159246e-02f, 1.59721915e-02f, 3.60145755e-02f, -7.97819793e-02f,
  1.32033434e-02f, -6.67790771e-02f, 1.00376718e-01f, -6.77402765e-02f, -4.92555685e-02f, -7.20806122e-02f, -1.77398205e-01f, 4.60712984e-02f, -2.06422769e-02f, 5.20760864e-02f,
  -2.30998397e-02f, -4.52798270e-02f, -3.68176624e-02f, 1.04595814e-02f, -5.77623071e-03f, -4.59879227e-02f, -5.72481193e-03f, -1.42727956e-01f, -2.43976433e-02f, 4.32769619e-02f,
  -7.96444656e-05f, 3.60759459e-02f, 1.13138556e-01f, -6.41956879e-03f, -1.56145049e-02f, -2.47033057e-03f, 2.80901906e-03f, -8.81512314e-02f, 2.70539429e-02f, -3.07201874e-02f,
  -2.72568762e-02f, 5.55264167e-02f, -7.19290301e-02f, -1.75202563e-01f, 4.82115988e-03f, 1.33093894e-01f, -1.80960298e-04f, -2.29639802e-02f, -9.23177451e-02f, 6.36313707e-02f,
  4.09370009e-03f, -5.53744398e-02f, -5.32857329e-02f, -2.36623287e-02f, -9.39042196e-02f, 1.19434502e-02f, 1.04172446e-01f, 6.20551258e-02f, 8.85884762e-02f, 2.62304060e-02f,
  -7.99812078e-02f, -1.10827781e-01f, -3.64345983e-02f, 5.24127763e-03f, -1.07908852e-01f, 3.38705406e-02f, -8.90456289e-02f, 2.79100593e-02f, 1.62664838e-02f, -7.11914152e-02f,
  -9.40690115e-02f, -1.33398131e-01f, 1.80136189e-02f, -1.80610307e-02f, 2.03467882e-03f, -1.36758968e-01f, -1.15761191e-01f, -3.51070543e-03f, -2.10794602e-02f, -3.37339453e-02f,
  2.68532127e-01f, 3.97389352e-01f, 1.60081282e-01f, 2.09005237e-01f, -1.10898755e-01f, -3.31410646e-01f, -3.08152795e-01f, -3.11851356e-04f, -1.70437783e-01f, 2.77649164e-01f,
  2.23120842e-02f, 1.43470809e-01f, -1.57516778e-01f, 1.07831180e-01f, -6.01163089e-01f, -3.70707393e-01f, -7.10331872e-02f, 1.92865785e-02f, -2.67255276e-01f, 2.53729194e-01f,
  -1.78015947e-01f, 5.87078705e-02f, 1.58164632e-02f, 2.71124989e-02f, 3.06698740e-01f, 1.79342091e-01f, 2.67971810e-02f, -4.03787903e-02f, 3.12918812e-01f, -4.72449027e-02f,
  3.70764807e-02f, 5.38818762e-02f, 7.02956244e-02f, -1.20537346e-02f, 7.00747669e-02f, 1.13372110e-01f, 4.12246920e-02f, -7.53930137e-02f, -2.23673936e-02f, 3.55508961e-02f,
  -2.74606440e-02f, 4.80198115e-02f, 5.05481400e-02f, 4.49721068e-02f, 1.10092320e-01f, 1.22229226e-01f, 1.07919730e-01f, 1.53323039e-01f, 3.54839452e-02f, 1.54758975e-01f,
  5.57784848e-02f, 9.53349322e-02f, 1.04734696e-01f, 5.85380457e-02f, -1.39033794e-01f, 7.13938549e-02f, 6.72068819e-02f, 2.35480089e-02f, 9.80906654e-03f, -3.16028260e-02f,
  1.77516937e-01f, -2.36198697e-02f, -6.90593421e-02f, -7.10593387e-02f, -4.70563173e-02f, 2.06526965e-02f, -1.17638953e-01f, -4.85204123e-02f, -4.43975767e-03f, -4.86644730e-02f,
  -1.25121744e-02f, 8.38229060e-02f, -3.38765085e-02f, 7.56796077e-02f, -1.53574273e-02f, 3.77368666e-02f, 7.11880112e-03f, -6.17247485e-02f, 9.36186165e-02f, -4.00601290e-02f,
  2.84846555e-02f, -8.00531134e-02f, 5.31239882e-02f, 1.85859781e-02f, -9.69921499e-02f, 1.54093906e-01f, 3.82499732e-02f, 6.14675060e-02f, -8.89845639e-02f, -2.93342192e-02f,
  -9.15362611e-02f, 8.79571736e-02f, -7.12068155e-02f, -1.51995532e-02f, 1.71498340e-02f, 3.13964561e-02f, -1.26820104e-02f, -4.68518548e-02f, 3.45292091e-02f, -3.92710716e-02f,
  3.24885696e-02f, -2.69930046e-02f, 4.63495404e-02f, 1.22720860e-01f, -2.70705931e-02f, -3.18551026e-02f, 5.16733192e-02f, 5.23581095e-02f, 8.85929391e-02f, 1.17087752e-01f,
  8.95040557e-02f, 3.11348476e-02f, -1.04937498e-02f, 2.23549753e-02f, -2.77331546e-02f, 3.97654846e-02f, 5.10252416e-02f, 3.01448274e-02f, 2.23548096e-02f, -1.30799875e-01f,
  -2.19531134e-01f, -9.99250710e-02f, 1.75780550e-01f, -1.22649953e-01f, 4.47948486e-01f, 5.06128669e-01f, 3.33321035e-01f, 1.67838350e-01f, -3.31427269e-02f, 6.49106205e-02f,
  3.48143041e-01f, 3.60470265e-02f, -3.14896437e-03f, -4.39400189e-02f, 2.43731350e-01f, 1.01124831e-01f, 6.48360476e-02f, 3.94833721e-02f, -3.34453940e-01f, -5.74367419e-02f,
  -2.20791653e-01f, -3.36128250e-02f, -2.47306004e-01f, -2.70832092e-01f, 1.32847860e-01f, -3.15583974e-01f, 3.98600362e-02f, 1.29785329e-01f, -5.59742786e-02f, 9.84335914e-02f,
  -5.91687411e-02f, -1.96006119e-01f, -1.97907239e-02f, 7.31193414e-03f, 1.04820147e-01f, -7.25215301e-03f, 6.02256274e-03f, -1.07364375e-02f, -7.53225163e-02f, 7.96376094e-02f,
  2.20053092e-01f, -1.40111327e-01f, -2.58651208e-02f, 1.77154914e-01f, -9.37803909e-02f, 7.71416798e-02f, 1.88161656e-02f, 1.35326073e-01f, 9.13223997e-02f, -8.44849274e-02f,
  8.26669484e-02f, 1.95992798e-01f, 1.46505311e-01f, 1.98892187e-02f, 5.75078949e-02f, -5.36182486e-02f, 5.99760078e-02f, 1.75210983e-01f, 1.67655334e-01f, 8.10274929e-02f,
  6.13391437e-02f, -5.06203175e-02f, -4.58354354e-02f, 3.19466530e-03f, -7.82501474e-02f, -1.20000886e-02f, 1.50964707e-01f, 8.89180601e-03f, -9.27856192e-02f, 1.25986338e-01f,
  2.65534967e-02f, 8.01762640e-02f, -1.02937266e-01f, 8.07244033e-02f, -3.32585792e-03f, 3.60008329e-02f, 1.22270256e-01f, -7.98631310e-02f, 2.18062717e-02f, 1.46700367e-01f,
  -4.49774638e-02f, 2.10639723e-02f, -3.89666632e-02f, -5.55390008e-02f, 9.71109942e-02f, -1.25386611e-01f, 1.36667872e-02f, 1.05693802e-01f, 2.89129037e-02f, 4.54334840e-02f,
  3.25455517e-01f, 1.14438459e-01f, -4.66161221e-02f, -1.35797411e-01f, -1.28072174e-02f, 1.19950652e-01f, -9.08154473e-02f, -2.35162936e-02f, 1.58855870e-01f, 1.22814320e-01f,
  1.26461655e-01f, -1.93569824e-01f, 1.77531749e-01f, -2.70125456e-02f, -6.28232807e-02f, 1.30200386e-01f, -4.63289730e-02f, 1.57616392e-01f, 2.05236524e-01f, 3.52350399e-02f,
  1.80661932e-01f, 5.35482429e-02f, -6.47609159e-02f, -2.43017264e-03f, -1.11312620e-01f, 1.83422521e-01f, -4.31641079e-02f, -9.06071961e-02f, 7.06309751e-02f, 1.20352313e-01f,
  -1.87552795e-01f, 1.95736736e-01f, 2.30681241e-01f, -5.97211707e-04f, -1.33035049e-01f, -5.00608265e-01f, -4.62589502e-01f, 1.90089494e-01f, -4.31662425e-02f, -5.82121909e-02f,
  9.95452851e-02f, 1.71570972e-01f, 2.78126508e-01f, 1.02788210e-01f, -6.32689074e-02f, 2.24484310e-01f, -1.89528182e-01f, -1.34502843e-01f, 1.04642585e-01f, 1.50817499e-01f,
  1.47329092e-01f, 7.25927949e-02f, 2.23591924e-01f, 2.66962171e-01f, 4.44930121e-02f, 5.44095300e-02f, 2.47627869e-01f, 2.81263232e-01f, -1.37154743e-01f, -8.24777484e-02f,
  -1.82031561e-02f, 2.43146911e-01f, 1.09740525e-01f, -3.55740674e-02f, 6.23226911e-02f, -6.95717558e-02f, -1.24775119e-01f, 1.07040599e-01f, -5.31855747e-02f, -1.78440399e-02f,
  -4.60012369e-02f, 7.84093514e-02f, 2.33317576e-02f, 3.38036418e-02f, 2.76311743e-03f, -4.93465699e-02f, 4.55449335e-02f, -3.25192101e-02f, 8.41427222e-02f, -4.20216806e-02f,
  1.43199965e-01f, 1.03087556e-02f, -4.41600271e-02f, -3.48385088e-02f, 4.59583066e-02f, -5.38929515e-02f, -5.82133830e-02f, -6.32637218e-02f, -9.73771065e-02f, -3.38591598e-02f,
  8.83995369e-02f, -8.93693790e-02f, -7.50634074e-02f, -7.44627342e-02f, -5.73330782e-02f, 9.97003987e-02f, 3.72142680e-02f, 3.95470522e-02f, 8.62471312e-02f, 6.35588989e-02f,
  -1.19491167e-01f, 4.10038196e-02f, 6.71702400e-02f, -5.82475252e-02f, 1.20218229e-02f, -2.38416921e-02f, -2.78961435e-02f, 8.81248266e-02f, -1.70477137e-01f, -4.91115488e-02f,
  8.19702893e-02f, -8.80071893e-02f, 6.38826191e-02f, -7.34486729e-02f, -1.67694718e-01f, 1.49991410e-03f, 6.51715547e-02f, 9.21655446e-03f, 9.37978849e-02f, -3.47272493e-02f,
  -1.78590734e-02f, 3.65735263e-01f, 5.89080229e-02f, 4.97961044e-02f, 1.33025229e-01f, 4.86702146e-03f, 7.25690648e-02f, 5.03448248e-02f, 5.13049960e-02f, 1.04760513e-01f,
  -1.12842964e-02f, -6.50166050e-02f, -1.20412886e-01f, -6.34965347e-03f, -5.64381555e-02f, 7.59781376e-02f, -4.67033386e-02f, 2.31283568e-02f, 2.30007228e-02f, 3.90239246e-02f,
  1.47911325e-01f, -6.68744743e-02f, 1.97111592e-02f, -6.24760240e-02f, -1.75457541e-02f, 1.55769102e-02f, 2.81909294e-02f, 6.22090362e-02f, 1.46095037e-01f, 3.87340933e-02f,
  5.14026165e-01f, -3.09672445e-01f, -1.76876709e-01f, 3.54028940e-01f, 3.41440171e-01f, -4.13994342e-02f, -4.38181758e-02f, 3.03985059e-01f, 1.09688811e-01f, -3.56986463e-01f,
  -1.73788816e-02f, -3.06352735e-01f, -3.91231060e-01f, 3.76045972e-01f, 3.60350966e-01f, -1.59615427e-01f, 4.19450939e-01f, 1.47193596e-01f, 2.35442713e-01f, 2.13029161e-01f,
  2.64481336e-01f, 4.77690816e-01f, 1.93403959e-01f, 2.75559753e-01f, 3.34582388e-01f, 2.07845330e-01f, 1.40813410e-01f, -1.49570510e-01f, 1.56340286e-01f, 8.47558433e-04f,
  -3.64887752e-02f, 6.82270676e-02f, 6.01345748e-02f, -3.22656743e-02f, 5.83792068e-02f, -1.39480531e-01f, -1.45245001e-01f, -1.25895843e-01f, 8.63423795e-02f, 9.08339489e-03f,
  -3.14581729e-02f, -5.48651675e-04f, 1.04296371e-01f, 3.59839648e-02f, 9.91991535e-02f, 9.15179476e-02f, 9.77783501e-02f, 4.39890772e-02f, -9.89324003e-02f, -6.82135224e-02f,
  1.19308531e-02f, -7.80949788e-03f, 3.80853228e-02f, 6.20327238e-03f, 5.73083237e-02f, 7.60522410e-02f, 8.79403725e-02f, -1.59391180e-01f, 4.14285436e-02f, 1.85155123e-02f,
  1.02495074e-01f, -9.73747894e-02f, -8.43968168e-02f, -1.41526610e-02f, -3.44178751e-02f, 2.20449418e-02f, 5.28623164e-02f, -8.20481479e-02f, 3.13870795e-02f, -7.65525326e-02f,
  3.03389668e-03f, 7.35130906e-02f, -9.06604901e-03f, -1.32877588e-01f, 1.17944077e-01f, -4.95359637e-02f, -2.35967766e-02f, -2.92603988e-02f, 3.18984911e-02f, -2.09119562e-02f,
  8.14564228e-02f, 1.21623063e-02f, -7.92254787e-03f, -4.85448763e-02f, -1.28454398e-02f, -7.83568621e-02f, -2.41846964e-03f, 5.99362589e-02f, 2.65209819e-03f, 2.13444494e-02f,
  3.99104171e-02f, 1.97473615e-02f, -1.44432662e-02f, -2.13072859e-02f, -7.47838020e-02f, 5.56076765e-02f, -4.36648866e-03f, 1.62680537e-01f, 5.61260954e-02f, 4.02153395e-02f,
  3.30492444e-02f, -7.60970488e-02f, -1.18695252e-01f, 2.98466370e-03f, -2.77520511e-02f, 2.61173174e-02f, -9.89721939e-02f, -6.72489405e-02f, 1.89590100e-02f, 9.51867849e-02f,
  2.11673845e-02f, -9.05666873e-02f, -7.24118501e-02f, 7.82260373e-02f, 4.53756982e-03f, -6.59032091e-02f, -2.51593045e-03f, -4.08643670e-02f, 6.93293335e-03f, -2.45085005e-02f,
  1.25229478e-01f, -1.87803641e-01f, 7.82098621e-02f, 4.12019849e-01f, -2.50744164e-01f, -4.58078861e-01f, -2.50093222e-01f, -1.23304926e-01f, 3.22136462e-01f, -7.40566477e-02f,
  3.59637439e-02f, 1.14540353e-01f, 3.94523628e-02f, -2.18497147e-03f, 1.50582150e-01f, 3.67322683e-01f, -1.87172927e-02f, 2.90525816e-02f, 1.35084182e-01f, -1.39010504e-01f,
  6.41209558e-02f, -1.02913767e-01f, 2.37490069e-02f, -2.74998724e-01f, -2.22289145e-01f, -1.36365414e-01f, 2.29718909e-01f, -2.81055421e-01f, -8.18959624e-02f, -1.56793177e-01f,
  -2.40113530e-02f, 4.63048778e-02f, -9.15944055e-02f, -1.12855159e-01f, -3.92819606e-02f, -1.10277282e-02f, 1.80043533e-01f, -6.68399781e-02f, -1.13958921e-02f, -3.82548496e-02f,
  -9.39583555e-02f, 1.11920759e-01f, -5.83785884e-02f, -1.15037382e-01f, -4.10394259e-02f, 1.70372546e-01f, 4.23598997e-02f, -1.60642229e-02f, -6.68647811e-02f, 7.45339468e-02f,
  1.24277793e-01f, 9.10951719e-02f, 8.65153819e-02f, 9.29024294e-02f, 9.75031033e-03f, -1.91809963e-02f, 1.00858897e-01f, -6.52839839e-02f, 5.13722971e-02f, 2.16267914e-01f,
  -7.22910762e-02f, -1.35227457e-01f, -4.41320762e-02f, 8.53580888e-03f, -2.84001250e-02f, 1.31279051e-01f, 1.69000834e-01f, 3.33041921e-02f, 5.05170152e-02f, -4.27720100e-02f,
  4.44339700e-02f, -1.62284687e-01f, -1.14673853e-01f, 6.30511716e-03f, 2.96523608e-03f, 2.21910879e-01f, 7.91992247e-02f, -2.42865342e-03f, 1.26128554e-01f, -4.33039060e-03f,
  5.42691816e-03f, 5.68662137e-02f, -7.49703944e-02f, -7.12679848e-02f, 6.77562058e-02f, 8.32937062e-02f, 4.31821831e-02f, 1.25201464e-01f, 3.55480760e-02f, -2.35941738e-01f,
  -1.32500693e-01f, -1.38253853e-01f, -1.50704503e-01f, -3.14180553e-02f, 6.88641444e-02f, -5.14400154e-02f, 2.39160791e-01f, 4.02246080e-02f, -3.11942715e-02f, 1.79654174e-02f,
  -7.85353631e-02f, 5.72175942e-02f, -3.84447612e-02f, 3.60667184e-02f, -6.35994151e-02f, 7.82712176e-02f, 1.32912487e-01f, 8.74293521e-02f, -2.40475491e-01f, -1.24899738e-01f,
  -8.58432353e-02f, -2.62378827e-02f, 6.04398325e-02f, 2.33214013e-02f, 1.08867651e-03f, -2.08093189e-02f, -5.68330549e-02f, 3.38869654e-02f, -4.53475863e-02f, 1.58803567e-01f,
  7.43975878e-01f, 2.39520505e-01f, 4.57532555e-01f, 6.11479402e-01f, -2.15894245e-02f, -3.82607609e-01f, 1.45100549e-01f, 1.18186310e-01f, 3.81793588e-01f, -2.32690558e-01f,
  -4.79016267e-02f, 1.84968770e-01f, -6.59011975e-02f, 1.63372710e-01f, -3.07963222e-01f, -1.87244952e-01f, 1.24713168e-01f, -6.80966005e-02f, 1.09195173e-01f, 1.29210576e-01f,
  2.81218737e-01f, -3.02597135e-01f, 2.60020763e-01f, -2.84302741e-01f, 3.88083577e-01f, 3.29391092e-01f, -2.12074935e-01f, -9.88015905e-02f, -7.13177323e-02f, -2.89294839e-01f,
  5.18413149e-02f, 2.84119099e-01f, 2.00498939e-01f, 2.51814052e-02f, 1.77436069e-01f, 4.19553593e-02f, -3.36715616e-02f, -1.33033156e-01f, 4.74427827e-02f, 5.79720661e-02f,
  4.93227132e-02f, -4.38875556e-02f, -3.68847065e-02f, -1.52056560e-01f, 1.77578792e-01f, 3.53824832e-02f, 1.27317026e-01f, 2.22231507e-01f, 1.11533418e-01f, 1.77847311e-01f,
  1.14205278e-01f, 1.74910188e-01f, 7.70698711e-02f, -1.09577142e-01f, 7.57341310e-02f, 5.23216166e-02f, -6.19752370e-02f, 5.25617525e-02f, 7.11270496e-02f, 1.00825049e-01f,
  -7.34908283e-02f, -4.11701314e-02f, -3.66854481e-02f, 1.12734087e-01f, -1.23657053e-02f, 1.34208292e-01f, -1.06997602e-01f, -8.61777589e-02f, -6.68417886e-02f, 9.33398772e-03f,
  1.68637279e-02f, 1.39574811e-01f, -5.66102453e-02f, -9.80890077e-03f, -3.14428061e-02f, 1.14015803e-01f, -2.51839831e-02f, -2.02632211e-02f, 1.41107002e-02f, 5.73993586e-02f,
  -5.85550293e-02f, -5.40261567e-02f, -3.30310091e-02f, -2.37749983e-02f, -4.38316278e-02f, -5.42997755e-03f, 1.87533684e-02f, 6.03865720e-02f, 1.21607529e-02f, -2.15192214e-02f,
  -1.34603173e-01f, -3.69573236e-01f, -3.79933342e-02f, -1.18177272e-01f, -1.68694966e-02f, 6.20227531e-02f, -5.36593013e-02f, 9.17624217e-03f, -8.42029452e-02f, -1.23374596e-01f,
  8.78748856e-03f, 1.12395711e-01f, -3.87370922e-02f, 1.88576989e-02f, -1.14388123e-01f, 3.58401835e-02f, -4.20021042e-02f, -9.33130160e-02f, -1.25010714e-01f, 2.28501707e-02f,
  -5.15894825e-03f, 5.17755896e-02f, -8.33667070e-02f, 3.19417417e-02f, -1.16694393e-02f, -2.35227458e-02f, -7.45323449e-02f, 2.98845638e-02f, -4.10410436e-03f, -9.10046697e-02f,
  3.48181725e-02f, 2.99734592e-01f, -3.48693371e-01f, 2.78109968e-01f, -3.05039048e-01f, 2.42556185e-01f, 2.94595987e-01f, -1.19147729e-02f, 3.10393989e-01f, 4.50229138e-01f,
  1.49979159e-01f, 1.33147508e-01f, 2.51766026e-01f, 2.86942869e-01f, 2.68057615e-01f, 3.88996869e-01f, 3.80997956e-01f, 2.67901003e-01f, 1.68275498e-02f, 2.26392999e-01f,
  1.20656267e-01f, 2.28174806e-01f, -2.30754256e-01f, 2.61662323e-02f, -1.27873659e-01f, -3.40333015e-01f, -4.56237234e-02f, -4.07948285e-01f, 2.71756928e-02f, -7.74269029e-02f,
  1.75965372e-02f, 8.56947601e-02f, -3.05517651e-02f, -6.28218427e-02f, -4.60418407e-03f, -2.43466888e-02f, -9.31385458e-02f, -7.42265582e-02f, -1.25584215e-01f, -4.15757671e-03f,
  1.52670443e-01f, 8.69714480e-04f, 1.18586235e-01f, -3.56927626e-02f, -7.16022328e-02f, -5.07443435e-02f, -1.59869362e-02f, -1.36243105e-01f, -7.29314685e-02f, -3.64354141e-02f,
  -1.81090888e-02f, -1.06836237e-01f, 1.91809945e-02f, 1.45294517e-01f, -3.46347094e-02f, 3.58620621e-02f, 3.07028256e-02f, -6.36103228e-02f, -3.42377485e-03f, 7.50750303e-02f,
  3.25038359e-02f, 1.26350462e-01f, 6.85754940e-02f, 4.75556105e-02f, 4.53320798e-03f, -1.21087275e-01f, 9.28647593e-02f, -7.55524933e-02f, 4.37747613e-02f, -3.33333760e-02f,
  -6.60756091e-03f, -7.55427256e-02f, -1.07830772e-02f, 6.60923198e-02f, 6.84772879e-02f, 1.18558249e-02f, -5.52610420e-02f, 1.41207352e-02f, 9.19240192e-02f, -5.44508547e-02f,
  -4.24161479e-02f, 1.16675265e-01f, -1.45955626e-02f, 1.77000333e-02f, 1.56242345e-02f, -2.99558248e-02f, 6.83043599e-02f, -6.81223571e-02f, -3.12222503e-02f, -1.36380550e-02f,
  1.19073190e-01f, 4.03627425e-01f, 7.79345855e-02f, 7.20890099e-03f, 2.32082810e-02f, -7.40638759e-04f, 5.28891385e-03f, 3.07161026e-02f, 6.47678450e-02f, 7.36109614e-02f,
  8.28025639e-02f, 1.51074052e-01f, 3.55296172e-02f, -5.62082231e-02f, -3.85584729e-03f, 2.00548813e-01f, 1.03480898e-01f, 1.99559480e-02f, 6.27676919e-02f, -8.10789391e-02f,
  -9.43944007e-02f, 1.28853947e-01f, 6.49487525e-02f, -2.23083198e-02f, 1.95822902e-02f, -2.13776696e-02f, 2.08509006e-02f, -1.12781990e-02f, -3.70165184e-02f, 3.21453214e-02f,
  -2.17304498e-01f, 1.91574588e-01f, -1.37984216e-01f, 4.22912449e-01f, -3.10744643e-01f, 2.90110379e-01f, 4.44062829e-01f, -4.50547934e-02f, 2.51308084e-01f, 4.71058160e-01f,
  1.82761148e-01f, 1.16994344e-01f, 2.12710306e-01f, 4.19675052e-01f, -2.77572602e-01f, 4.27571237e-01f, 4.01079059e-01f, 2.82625556e-01f, -9.35096517e-02f, 5.84595017e-02f,
  2.36710403e-02f, 1.69051722e-01f, -6.31204173e-02f, -1.76849917e-01f, -2.96504311e-02f, -1.56235114e-01f, -2.61377960e-01f, -3.96704227e-01f, 1.37451917e-01f, -1.79294124e-01f,
  -1.64667919e-01f, -1.97636724e-01f, 4.24295031e-02f, -1.53209716e-02f, 2.81883180e-02f, 4.71860915e-02f, -5.65094315e-02f, -1.72671020e-01f, -1.11483440e-01f, 9.20118466e-02f,
  3.46351862e-02f, -1.56981528e-01f, -3.45940739e-02f, -3.78502719e-03f, -2.35583488e-04f, -1.09853797e-01f, -5.53319938e-02f, 4.20897529e-02f, 5.05346470e-02f, -3.59481783e-03f,
  8.99682492e-02f, 1.40776755e-02f, 9.72790718e-02f, 1.49150595e-01f, 1.98975746e-02f, -3.83866355e-02f, 8.97311866e-02f, -1.01419108e-03f, 9.54537317e-02f, 2.10627317e-02f,
  3.75818554e-03f, -1.08240366e-01f, 2.85175741e-02f, -3.13615054e-02f, -3.52754369e-02f, 3.25250556e-03f, -4.98995222e-02f, -1.08600244e-01f, -9.09968391e-02f, 9.13456175e-03f,
  6.71858788e-02f, -1.20184431e-02f, -8.86597857e-02f, 4.81598936e-02f, 7.16565400e-02f, 1.20648712e-01f, -8.38730410e-02f, 4.44654375e-02f, -2.34031975e-02f, -4.98476699e-02f,
  9.07919407e-02f, -1.03248227e-02f, 4.27104160e-02f, -5.88443056e-02f, 3.43019553e-02f, -9.96108130e-02f, -6.10771105e-02f, 1.06591448e-01f, -3.24871833e-03f, -2.20645830e-01f,
  5.89553826e-02f, -1.38941973e-01f, 1.14485528e-02f, 4.33357991e-02f, 1.67334955e-02f, 3.12494878e-02f, -1.40153682e-02f, -3.74536216e-02f, -8.80147051e-03f, -6.30579330e-03f,
  -1.11634582e-01f, 1.06446445e-01f, -1.23694442e-01f, -5.17542735e-02f, -2.90539749e-02f, 9.29512829e-02f, 1.83387231e-02f, 5.94113246e-02f, -1.38026625e-01f, -1.04723744e-01f,
  2.26967521e-02f, -4.00526449e-02f, -2.56508663e-02f, 4.51193266e-02f, 1.76349312e-01f, 2.00931076e-02f, -1.08255342e-01f, -2.83218119e-02f, -1.35096252e-01f, 6.26490638e-02f,
  2.53567785e-01f, 3.84298027e-01f, 4.33804989e-02f, -1.15618389e-03f, 1.62647963e-02f, -5.72784364e-01f, -1.93193436e-01f, -3.37154865e-02f, 3.05180848e-01f, 1.40328631e-01f,
  -2.37390861e-01f, 4.69781399e-01f, 4.05694451e-03f, -1.55853719e-01f, -4.79305089e-01f, -2.56212801e-01f, -3.41763020e-01f, -7.96402171e-02f, 1.86168343e-01f, -1.18451416e-01f,
  -1.64249897e-01f, -2.16187581e-01f, -1.67522326e-01f, -4.57924865e-02f, -8.16561282e-03f, 2.86492467e-01f, -2.82474250e-01f, 9.16653201e-02f, -6.74879253e-02f, 6.81477934e-02f,
  -1.70051858e-01f, 2.38574222e-01f, 1.84065491e-01f, -2.81441770e-03f, -1.97983578e-01f, 4.76547256e-02f, -2.73108352e-02f, 4.83876653e-02f, -4.95946370e-02f, -4.96900938e-02f,
  9.01123732e-02f, -1.86729860e-02f, -3.52757610e-02f, 1.23745231e-02f, 6.33535609e-02f, 9.99696106e-02f, -2.24068556e-02f, 1.24391485e-02f, 2.29117703e-02f, -8.82469341e-02f,
  1.11034200e-01f, 8.36665481e-02f, -1.11193776e-01f, 2.14408915e-02f, -4.23755869e-02f, 4.07294696e-03f, -1.57783121e-01f, 5.14716133e-02f, -6.49363361e-03f, 5.36643565e-02f,
  1.09625449e-02f, -1.02748431e-01f, -4.08363752e-02f, 1.11145131e-01f, -3.40412296e-02f, -6.05940260e-02f, 2.17372086e-02f, 5.35373650e-02f, 1.93235390e-02f, -1.20193243e-01f,
  -1.48804605e-01f, 1.03660330e-01f, 8.75236914e-02f, -2.45179087e-02f, 2.05943007e-02f, 7.34464526e-02f, -7.76792020e-02f, -1.01091720e-01f, -8.37726295e-02f, -5.24567515e-02f,
  4.68154587e-02f, -1.65800974e-01f, 1.10069225e-02f, -2.02093199e-02f, -4.52196747e-02f, -2.10118219e-02f, -1.02611996e-01f, 4.48336639e-03f, 2.68223267e-02f, -9.87736881e-02f,
  -6.36011422e-01f, -4.29284036e-01f, 1.63109358e-02f, 8.85640830e-02f, 1.05712358e-02f, -1.35893688e-01f, -8.74568745e-02f, 4.58924808e-02f, -2.13913172e-02f, -7.98961446e-02f,
  -8.45258310e-03f, -5.54855019e-02f, -1.18392102e-01f, 5.65087870e-02f, -5.00910319e-02f, -1.09944806e-01f, -9.65384394e-02f, 7.72360479e-03f, -5.57142720e-02f, -4.65948656e-02f,
  3.77954356e-02f, -1.84726603e-02f, -6.06226316e-03f, 2.85141524e-02f, -5.52137941e-02f, 3.04484274e-02f, -6.25640601e-02f, 7.92871565e-02f, -1.28358841e-01f, -5.83224557e-02f,
  -5.81399024e-01f, 5.60359597e-01f, 3.86228144e-01f, -3.49312186e-01f, -3.94745097e-02f, 3.67052287e-01f, -1.84750304e-01f, 3.16389620e-01f, 2.89799660e-01f, 1.77004009e-01f,
  -2.50080734e-01f, 4.04396534e-01f, 1.22783601e-01f, -1.92688499e-02f, -3.59489828e-01f, 3.82696874e-02f, -1.76277518e-01f, -4.53043869e-03f, 1.49851903e-01f, -3.44144786e-03f,
  -1.68675661e-01f, -3.69569093e-01f, -2.09310547e-01f, 3.30053866e-02f, -5.04449606e-02f, -1.08264282e-03f, -3.90925884e-01f, -3.33566638e-03f, -1.44095942e-01f, -9.44198146e-02f,
  -4.16908622e-01f, -1.55808762e-01f, -8.44111070e-02f, 1.42842308e-01f, -3.98718640e-02f, 8.21337923e-02f, -1.27083391e-01f, -1.48336112e-01f, -2.44858433e-02f, 2.03172386e-01f,
  3.97260971e-02f, -3.61528285e-02f, -2.06620991e-03f, 7.72230029e-02f, 2.52028145e-02f, 1.30975321e-01f, 1.57846638e-03f, -3.92152928e-02f, 6.33258969e-02f, 1.11352719e-01f,
  1.98502749e-01f, 1.16233878e-01f, -4.94405366e-02f, -9.80617777e-02f, -3.49904969e-03f, 6.63896278e-02f, -1.04723826e-01f, -6.70168102e-02f, 4.46938984e-02f, -3.37482207e-02f,
  1.52738273e-01f, 2.25339551e-02f, 5.73255718e-02f, 4.60224599e-02f, -5.68750240e-02f, -1.77446812e-01f, -6.09391667e-02f, -2.32104108e-01f, 9.03858338e-03f, 5.81536628e-02f,
  -1.11967802e-01f, -1.77024994e-02f, -4.28530946e-03f, 1.92188472e-02f, -3.84840705e-02f, 9.00106356e-02f, -8.16541016e-02f, 9.65211540e-02f, -5.64574152e-02f, -6.38766736e-02f,
  4.48151305e-02f, -8.34671557e-02f, 5.45390993e-02f, -1.57294005e-01f, 3.88558470e-02f, -9.06571820e-02f, 5.48319854e-02f, 3.61737721e-02f, 9.58098157e-04f, -2.78003197e-02f,
  -1.13288485e-01f, -1.94044784e-01f, -3.99175566e-03f, -6.60374463e-02f, 1.05265133e-01f, 2.94993222e-02f, -3.72808352e-02f, -4.54543196e-02f, -8.55276361e-04f, 6.72868043e-02f,
  1.42240785e-02f, 2.15372834e-02f, -1.00422911e-02f, -9.88680422e-02f, 8.35023448e-02f, -1.10824659e-01f, -1.42318755e-01f, 2.67282072e-02f, -1.74058452e-01f, 1.28109932e-01f,
  9.27816853e-02f, -2.03766227e-02f, 2.10770257e-02f, -1.05045810e-02f, 6.37468137e-03f, -8.19933563e-02f, -4.88550439e-02f, 5.27425483e-02f, -7.28906840e-02f, -4.43256758e-02f,
  -6.21035159e-01f, 5.35568237e-01f, -1.99232385e-01f, -3.03524822e-01f, 2.43575051e-01f, 3.29873115e-01f, -6.73870817e-02f, 5.26199266e-02f, -4.32313263e-01f, 2.95297503e-01f,
  2.95618832e-01f, -3.17734689e-01f, 9.43905339e-02f, 2.42830828e-01f, -1.44855708e-01f, 1.63107172e-01f, 6.72917664e-02f, -5.19395024e-02f, -7.28137046e-02f, -1.63555413e-01f,
  -1.67171121e-01f, 4.44816291e-01f, -3.29927169e-02f, 3.42033058e-01f, 6.27146661e-02f, -2.50728607e-01f, 1.26402587e-01f, -2.08001141e-03f, 1.36123165e-01f, 1.65000930e-01f,
  -1.91785708e-01f, -3.93161654e-01f, -3.25309545e-01f, -1.71213329e-01f, -1.07263722e-01f, -1.89160049e-01f, -1.51532918e-01f, -2.78793518e-02f, -1.31718233e-01f, 3.69469635e-02f,
  -1.45178154e-01f, 5.60035463e-03f, 2.33134963e-02f, -4.39010821e-02f, -5.37566058e-02f, -3.99493240e-02f, 2.00701132e-01f, 3.80718485e-02f, 2.25898363e-02f, 3.93069312e-02f,
  7.47232139e-02f, 7.09220916e-02f, -6.19124509e-02f, 9.01406631e-02f, 1.20978273e-01f, 1.70729443e-01f, 2.18669605e-02f, 1.53948879e-02f, -2.46043429e-02f, -5.99048808e-02f,
  -5.18338755e-02f, -1.02483593e-01f, 7.78788850e-02f, -3.65438238e-02f, 3.54640558e-02f, 1.80827260e-01f, -2.50752196e-02f, 1.79610364e-02f, -5.71641289e-02f, 6.55084625e-02f,
  1.36163026e-01f, -5.41789159e-02f, 1.40831480e-02f, -7.82453418e-02f, -1.00625545e-01f, -1.02583148e-01f, -1.01087727e-02f, -2.03914158e-02f, 1.51435565e-02f, 2.81331968e-02f,
  -1.51789814e-01f, 2.53186412e-02f, 1.65802032e-01f, -3.67376506e-02f, 8.93665478e-02f, -5.44995666e-02f, -9.32898521e-02f, 8.99654105e-02f, 9.04700160e-02f, 9.15553942e-02f,
  -1.84577420e-01f, -2.99873114e-01f, -1.07207306e-01f, -3.21204290e-02f, -2.12825742e-02f, -9.14901588e-03f, -1.06971189e-01f, 5.33211492e-02f, 1.17123434e-02f, -1.76492445e-02f,
  1.35295307e-02f, -1.01117954e-01f, -4.25081374e-03f, -1.23777010e-01f, -1.57058120e-01f, 1.05445676e-01f, 4.35687080e-02f, -1.26821324e-01f, -6.93325102e-02f, 1.39142781e-01f,
  -1.02219760e-01f, 1.65028609e-02f, -4.69595119e-02f, 1.41580394e-02f, 2.74819545e-02f, 5.84080964e-02f, -7.24679306e-02f, 2.59750127e-03f, 1.25193313e-01f, 5.89811690e-02f,
  -1.06502108e-01f, 2.21993655e-01f, -1.68351959e-02f, -1.50282821e-02f, -3.35999936e-01f, -7.07600638e-02f, -1.43440425e-01f, 9.76831466e-02f, 2.78670579e-01f, -1.81048363e-01f,
  -1.81851834e-01f, -2.02824809e-02f, 1.34674057e-01f, -2.51932770e-01f, 4.29811358e-01f, 3.43886048e-01f, 1.97662249e-01f, -8.30507204e-02f, 2.66123831e-01f, -2.28821114e-01f,
  8.65732580e-02f, -3.08840215e-01f, 1.41430229e-01f, -1.27558514e-01f, -3.82565856e-01f, 8.52161497e-02f, -1.97558224e-01f, -6.14872463e-02f, -1.63725525e-01f, -1.63819253e-01f,
  5.99267371e-02f, -7.14985281e-02f, 6.28454238e-02f, 1.41692072e-01f, 6.37949705e-02f, -7.63285458e-02f, -8.58770311e-02f, -1.27105147e-01f, 9.07440782e-02f, 1.10659651e-01f,
  -1.56030273e-02f, 1.17715023e-01f, 1.11961579e-02f, -2.14562025e-02f, -7.90111795e-02f, -2.52128989e-02f, 5.53742088e-02f, 6.19649775e-02f, -6.60294518e-02f, -1.62828386e-01f,
  -1.18327299e-02f, 9.34799910e-02f, 1.98155604e-02f, 4.62019481e-02f, 5.98191209e-02f, 5.57041690e-02f, 7.58665502e-02f, -3.96698676e-02f, 7.26651074e-03f, 4.82527837e-02f,
  -2.14795828e-01f, -5.81822954e-02f, 3.81826572e-02f, 5.96438572e-02f, -4.19997908e-02f, -2.36214884e-03f, 8.83162543e-02f, -2.18402192e-01f, 6.31108060e-02f, -4.92321402e-02f,
  1.25103071e-01f, -6.28141779e-03f, 1.79532617e-02f, 3.36982124e-02f, -9.83463973e-02f, 9.30997822e-03f, -1.08949514e-02f, 3.54010798e-02f, 1.99509144e-01f, 8.85984376e-02f,
  -1.18371315e-01f, -1.51717380e-01f, -9.87566169e-03f, 6.00586012e-02f, 1.89353630e-01f, 1.79667748e-03f, -1.97750591e-02f, -5.65113313e-02f, 8.24596062e-02f, -9.19603929e-02f,
  1.03419781e-01f, 1.46032587e-01f, 1.65697932e-01f, 2.04189941e-01f, 1.57474414e-01f, -7.68738016e-02f, 2.39964644e-03f, 4.04939912e-02f, 4.76475284e-02f, 9.88373067e-03f,
  -7.00535178e-02f, 1.24586709e-01f, 6.72421884e-03f, -1.64172217e-01f, 1.37275591e-01f, 1.01026379e-01f, 9.53349844e-02f, 1.77642614e-01f, -5.33431172e-02f, -8.63517150e-02f,
  -1.80725306e-02f, -8.44569728e-02f, 9.65092853e-02f, 1.72709078e-01f, 9.29296538e-02f, -9.18033868e-02f, -1.46928299e-02f, 2.22895667e-01f, 3.99935851e-03f, 1.58194512e-01f,
  -2.18650531e-02f, -3.54756027e-01f, 4.49425995e-01f, -1.60087258e-01f, 5.57080135e-02f, 3.08533639e-01f, 2.44630709e-01f, -4.98515032e-02f, -1.47254720e-01f, -3.20204765e-01f,
  -1.71131313e-01f, -2.02850297e-01f, 2.70012349e-01f, -3.10716391e-01f, 3.95476520e-01f, 2.39369094e-01f, -1.37002155e-01f, 3.45793441e-02f, 3.42078619e-02f, -2.40947917e-01f,
  1.16934448e-01f, -2.55239874e-01f, 3.06685507e-01f, -2.54560083e-01f, -4.24935818e-02f, -2.71804601e-01f, -7.71170035e-02f, 1.52188301e-01f, -1.41241670e-01f, 1.60718307e-01f,
  -1.50813341e-01f, -2.61129975e-01f, -1.17122434e-01f, -1.35902256e-01f, -1.81083735e-02f, -3.43659297e-02f, 1.07834265e-02f, 7.59742558e-02f, -7.02176169e-02f, 1.01401903e-01f,
  -9.39122518e-04f, 1.01240873e-01f, -1.81218937e-01f, 2.86482666e-02f, -4.18182127e-02f, -4.67391908e-02f, 1.62914068e-01f, 8.58775675e-02f, 1.30266771e-02f, 1.26559138e-01f,
  1.07658371e-01f, 5.13060689e-02f, 5.49058355e-02f, -2.05540396e-02f, 1.27637491e-01f, 3.74632068e-02f, 8.31421092e-02f, 6.59651309e-02f, -6.37780949e-02f, -4.68704775e-02f,
  1.08565524e-01f, -9.35009867e-03f, 1.84580237e-02f, -1.81059204e-02f, -9.73904654e-02f, 4.89689559e-02f, -3.26725058e-02f, -4.28400189e-02f, -1.09497616e-02f, 6.44137561e-02f,
  1.87828597e-02f, -6.31923303e-02f, 3.84709723e-02f, 3.67074870e-02f, 4.49136347e-02f, -1.59811545e-02f, 1.02116633e-02f, 2.75599454e-02f, -1.38254371e-02f, -2.69986503e-02f,
  1.65878125e-02f, 1.02552101e-01f, 9.42577571e-02f, 5.97654693e-02f, -9.08312425e-02f, 6.25631362e-02f, -3.23453136e-02f, 1.22874849e-01f, -4.56716679e-02f, -1.13563740e-03f,
  -3.09219092e-01f, -4.51826692e-01f, -1.02935977e-01f, -1.90750897e-01f, -1.13377102e-01f, -1.45050526e-01f, 1.64712220e-03f, -1.75421461e-01f, -1.42891347e-01f, 5.33964019e-04f,
  -3.02813426e-02f, -5.46951033e-02f, 3.71910632e-03f, 4.67959559e-03f, -1.41848549e-01f, 5.95672056e-02f, -2.03753874e-01f, -1.56223074e-01f, -1.16932213e-01f, -1.31940544e-01f,
  -2.30485275e-02f, -5.48831141e-03f, 7.94556066e-02f, -1.35936299e-02f, -9.49722975e-02f, -7.74608478e-02f, -1.59115940e-01f, 8.37709382e-02f, -7.63100386e-03f, -2.28216220e-03f,
  -1.02284968e+00f, 4.23319876e-01f, 5.67396164e-01f, -4.20662880e-01f, -1.47356942e-01f, 2.80542046e-01f, 2.17135772e-01f, 3.66882235e-02f, -2.07637861e-01f, 3.40313315e-01f,
  7.26087540e-02f, -1.90304816e-01f, 3.19598675e-01f, 1.82014138e-01f, -2.12573573e-01f, 2.43818924e-01f, 1.50323734e-01f, -5.95566165e-03f, 3.80109660e-02f, -1.92567080e-01f,
  -1.66435167e-01f, -1.54587820e-01f, 2.27092177e-01f, 7.42103010e-02f, 3.92131135e-02f, -6.93943501e-02f, -1.71099111e-01f, 1.64599165e-01f, -8.08772221e-02f, 1.93110794e-01f,
  -3.76982421e-01f, -3.91390234e-01f, -8.78429040e-02f, 8.50660577e-02f, -8.58086273e-02f, -1.56485867e-02f, 9.07350564e-04f, -1.60924550e-02f, -5.69701008e-02f, -6.96706027e-02f,
  -6.00053109e-02f, -7.61998817e-03f, -7.85928741e-02f, -6.72828481e-02f, -6.07915260e-02f, -1.15990244e-01f, 1.02836214e-01f, 1.21823736e-01f, 4.61882688e-02f, 1.24121353e-01f,
  1.45539537e-01f, 1.76496476e-01f, -1.04995195e-06f, -3.19350548e-02f, -6.16844837e-03f, 1.05546564e-01f, 1.04145229e-01f, 6.63530380e-02f, -7.44929463e-02f, -4.80976105e-02f,
  1.03521943e-01f, -1.38768777e-01f, -1.14219934e-01f, 5.34852706e-02f, 6.86334744e-02f, 3.85601483e-02f, -6.41541779e-02f, 1.25378128e-02f, 7.45872967e-03f, 9.19046924e-02f,
  -1.70566216e-02f, -2.49501392e-02f, -6.78390563e-02f, 1.41023286e-03f, -3.50015461e-02f, 7.69095346e-02f, 2.41504684e-02f, -3.84319462e-02f, 1.57412812e-01f, 1.04448982e-01f,
  -9.12097842e-03f, -4.25993949e-02f, -5.93087031e-03f, -4.52567935e-02f, 8.80234838e-02f, 7.38949105e-02f, 1.34245362e-02f, 6.17743284e-02f, -1.83928274e-02f, -1.36543110e-01f,
  -6.48793221e-01f, -5.58044195e-01f, -1.16643682e-01f, -1.21446222e-01f, -2.70281434e-02f, 1.35193870e-03f, -1.88350845e-02f, -7.94281363e-02f, -1.12603933e-01f, -8.68335888e-02f,
  -9.49877128e-02f, -2.19730865e-02f, -1.38636932e-01f, 2.86515243e-02f, 4.43941467e-02f, -3.00504174e-02f, 3.16662597e-03f, -6.03053048e-02f, -9.43912640e-02f, 1.64946693e-03f,
  4.70242500e-02f, -1.19538382e-01f, -6.77615777e-02f, -1.40007123e-01f, -5.87696694e-02f, -5.18160574e-02f, -2.25996345e-01f, 2.03345995e-02f, -1.69549063e-01f, 7.78194293e-02f,
  -5.18438101e-01f, -8.48897249e-02f, -9.27702710e-02f, -3.29517424e-01f, 2.58930266e-01f, 2.03785539e-01f, -9.42337438e-02f, 3.51603866e-01f, -2.27412302e-02f, -5.80646619e-02f,
  -9.99139324e-02f, -5.87362349e-01f, 4.28914502e-02f, -4.75492120e-01f, -4.37401682e-01f, -6.16322309e-02f, -5.04973292e-01f, -4.42715496e-01f, 5.13134301e-02f, -2.14395076e-01f,
  -1.27065703e-01f, -6.83182105e-02f, -1.11754924e-01f, 3.73756528e-01f, 2.03195512e-02f, 1.55200079e-01f, 4.32827026e-02f, 3.80185276e-01f, -4.24089804e-02f, -8.76336098e-02f,
  -4.69411388e-02f, 3.21598761e-02f, 1.05242446e-01f, 1.33835599e-01f, 1.11223117e-01f, -1.33109409e-02f, -9.70960408e-02f, 2.95546912e-02f, -2.25833151e-02f, 5.04520461e-02f,
  -1.00785457e-01f, -1.32383868e-01f, -6.36134967e-02f, 1.76971033e-01f, 1.10711910e-01f, 4.12331484e-02f, -4.88839708e-02f, -2.84996862e-03f, -4.55772616e-02f, -1.25368476e-01f,
  -1.13204077e-01f, -2.63823606e-02f, -8.18540156e-02f, -2.09536597e-01f, -9.84030589e-02f, -1.32782885e-03f, 2.71881116e-03f, -1.15321934e-01f, -3.78430821e-03f, -1.19162157e-01f,
  -2.46773176e-02f, 1.70570798e-02f, 2.00349838e-02f, 9.82255042e-02f, -4.34378535e-02f, 1.58019170e-01f, 4.56350371e-02f, 5.01999967e-02f, 1.62586535e-03f, -4.58303504e-02f,
  2.92225368e-02f, -6.94880411e-02f, 4.09500003e-02f, 3.82437445e-02f, -8.39546174e-02f, 8.86968058e-03f, -1.20584063e-01f, 7.06532672e-02f, -4.34568450e-02f, -1.99360382e-02f,
  1.18989028e-01f, -6.58343434e-02f, -6.24925867e-02f, 7.29444101e-02f, -5.22456132e-02f, 8.11341181e-02f, 4.08712737e-02f, -1.12303317e-01f, -1.02128135e-02f, 3.02531533e-02f,
  -1.83011945e-02f, -6.11715429e-02f, 8.02795440e-02f, 1.07021756e-01f, -5.64278029e-02f, 7.67083978e-03f, 2.48690099e-02f, 3.65585983e-02f, 9.47338715e-03f, -3.49281654e-02f,
  -4.01299484e-02f, 2.74777487e-02f, -2.07501557e-02f, 2.71443259e-02f, -5.80598861e-02f, 9.80990604e-02f, -2.19588831e-01f, -4.25698459e-02f, -2.00434513e-02f, 3.72572504e-02f,
  -8.70787576e-02f, 5.21790124e-02f, 7.79055478e-03f, 4.97706188e-03f, -6.83344603e-02f, -8.89628008e-02f, 3.50229554e-02f, 2.05908269e-02f, -5.24177365e-02f, -8.32273997e-03f,
  -1.14422433e-01f, -1.92770094e-01f, -9.62185413e-02f, -3.81110400e-01f, 7.93224424e-02f, -2.23602459e-01f, -1.67292967e-01f, -3.46129030e-01f, 1.44790605e-01f, -1.71612263e-01f,
  -1.38247475e-01f, 1.16715893e-01f, 5.01982570e-01f, -4.46103901e-01f, 2.06509873e-01f, 3.24952066e-01f, -4.22230542e-01f, -2.03593910e-01f, -8.53684694e-02f, -1.47147834e-01f,
  -1.34450033e-01f, -7.43255690e-02f, -2.75762398e-02f, -2.32768491e-01f, -3.06895941e-01f, -2.64931172e-01f, 1.18226804e-01f, 7.77596757e-02f, -4.18394029e-01f, 7.56829083e-02f,
  -1.53025106e-01f, -2.96979278e-01f, -2.19684616e-02f, -1.98502630e-01f, -3.09523284e-01f, -7.27188913e-03f, -1.47937611e-01f, 1.34302035e-01f, -7.00753108e-02f, -1.33162856e-01f,
  1.25424951e-01f, 7.78893903e-02f, -3.72397043e-02f, 1.74194604e-01f, -1.35453448e-01f, -1.11250579e-01f, -5.66277131e-02f, -2.13937297e-01f, 1.20299749e-01f, 4.46887799e-02f,
  -5.66178970e-02f, -1.38581082e-01f, -7.35756382e-02f, -1.61386847e-01f, 6.36352226e-04f, -1.71683162e-01f, -1.04980897e-02f, 8.95200744e-02f, -1.52575314e-01f, -9.05001089e-02f,
  5.46145253e-02f, 9.36189219e-02f, -1.46720469e-01f, 6.66653514e-02f, 8.98193642e-02f, -5.96041977e-02f, -1.45807758e-01f, 4.46483679e-02f, -1.29092569e-02f, 4.80996966e-02f,
  -6.39394484e-03f, -3.92519571e-02f, -1.16863571e-01f, -1.58893108e-01f, -9.81716439e-02f, 5.76627553e-02f, 9.71072242e-02f, 1.39104232e-01f, 4.88820393e-03f, -1.17285624e-01f,
  -4.06585336e-02f, -4.14480940e-02f, -4.31273468e-02f, -7.50344470e-02f, 3.50696295e-02f, 2.05211908e-01f, -1.17451206e-01f, 3.52886580e-02f, -1.36610091e-01f, 1.22698262e-01f,
  -8.29315260e-02f, -4.58430439e-01f, 3.26777957e-02f, -1.67802379e-01f, 2.63800099e-02f, -4.02025916e-02f, 4.60988376e-03f, 3.06810457e-02f, -2.07571656e-01f, 3.03679034e-02f,
  -2.51144677e-01f, -4.20108698e-02f, -5.25359064e-02f, 8.61776341e-03f, 2.72150543e-02f, -1.45107791e-01f, 3.05462629e-02f, -1.48651361e-01f, -3.84057909e-02f, -4.86900955e-02f,
  3.23213153e-02f, 1.42268026e-02f, 2.09251374e-01f, -7.75307342e-02f, -1.23225220e-01f, 1.18065951e-02f, 9.44272503e-02f, -2.53816508e-02f, -1.41678706e-01f, -2.44494434e-02f,
  3.76022398e-01f, -3.51611644e-01f, -2.22451925e-01f, 6.24208851e-03f, -4.52200957e-02f, -3.75285864e-01f, -2.14035526e-01f, -1.71448708e-01f, 1.69311345e-01f, -3.04988325e-01f,
  2.41324157e-02f, 3.27412114e-02f, -5.45897372e-02f, -4.63683717e-02f, 2.89071351e-01f, 1.58873767e-01f, 5.08447923e-02f, -1.86279148e-01f, 1.99968114e-01f, -4.30015400e-02f,
  3.04108739e-01f, 4.69639674e-02f, 7.16742873e-02f, -1.71186626e-01f, -2.53522933e-01f, 8.11145231e-02f, 2.51108974e-01f, -2.82450795e-01f, -1.33949339e-01f, 4.11437340e-02f,
  -9.92646888e-02f, 6.07365966e-02f, -6.08648956e-02f, 5.00428258e-03f, 8.52265656e-02f, -1.25448406e-02f, -2.02314168e-01f, 1.74972024e-02f, 5.73665164e-02f, 1.61392391e-01f,
  8.63440633e-02f, 7.44935498e-02f, 1.84462909e-02f, 7.06772087e-04f, -7.44833723e-02f, 1.46167083e-02f, 1.65966928e-01f, -3.90196815e-02f, 2.09530606e-03f, 1.45463020e-01f,
  2.88009997e-02f, -1.78041048e-02f, -8.40596482e-02f, 9.78423208e-02f, 9.11100954e-02f, 1.77771803e-02f, -2.42509134e-02f, 4.15223576e-02f, -1.11290701e-01f, 7.41287470e-02f,
  7.98714757e-02f, 9.93615482e-03f, -1.43335566e-01f, 9.28552914e-03f, -3.32301520e-02f, 3.67490724e-02f, -1.01843916e-01f, -1.37964729e-02f, 2.21057646e-02f, -7.22086281e-02f,
  3.86529155e-02f, 1.09725378e-01f, 5.30478321e-02f, 2.74717789e-02f, -1.13687562e-02f, 5.70051745e-02f, -4.73666862e-02f, -4.86703739e-02f, 1.16143532e-01f, -6.62959144e-02f,
  4.64114249e-02f, 3.39999348e-02f, -3.12353708e-02f, -5.97716831e-02f, 6.45869076e-02f, -9.68828648e-02f, 1.41172528e-01f, -1.16241820e-01f, -5.02485707e-02f, -1.01164103e-01f,
  -5.70105948e-02f, 8.01614448e-02f, 3.00264172e-02f, -2.75506116e-02f, -4.10457850e-02f, -1.24530837e-01f, -1.49344727e-01f, -9.03434753e-02f, -1.25963300e-01f, 2.72671282e-02f,
  8.03241879e-02f, -4.56064679e-02f, -9.07743000e-04f, 5.22411987e-02f, -7.48200715e-02f, -5.34391850e-02f, 9.17316228e-02f, -9.60211754e-02f, 8.80320817e-02f, 1.86976820e-01f,
  -6.78396970e-02f, 1.06995115e-02f, 1.89771764e-02f, 1.47441290e-02f, -3.28867584e-02f, 8.76190737e-02f, -5.03318869e-02f, -4.24580164e-02f, 4.94489893e-02f, -6.80189487e-03f,
  -5.78104913e-01f, -8.97159800e-02f, 4.31208968e-01f, -5.11607707e-01f, 2.49217063e-01f, 2.94473797e-01f, 1.38476744e-01f, -7.18212277e-02f, -4.23376560e-01f, -3.09662759e-01f,
  -6.05848059e-02f, -6.42955750e-02f, 3.40692252e-01f, -2.61162877e-01f, 2.00548664e-01f, 1.34407848e-01f, -3.95466715e-01f, -1.26466095e-01f, 1.57732278e-01f, -2.90213060e-02f,
  -8.56150612e-02f, -6.88934028e-02f, 2.91905284e-01f, 1.17259786e-01f, -7.25552859e-03f, -8.93543884e-02f, -9.81155187e-02f, 4.47190225e-01f, -1.59966946e-01f, 3.00158590e-01f,
  -5.96595593e-02f, -1.74165621e-01f, 8.14875122e-03f, 1.48001872e-02f, 3.64134312e-02f, 8.19822475e-02f, 1.22932479e-01f, 2.30886638e-01f, -5.12061045e-02f, 2.69045588e-02f,
  1.24518871e-02f, 5.88960275e-02f, -5.32879569e-02f, 7.90001974e-02f, -4.36888263e-02f, -1.47354484e-01f, -7.50530437e-02f, -5.14732189e-02f, 5.51720187e-02f, 1.35986075e-01f,
  7.06227496e-02f, -9.01538320e-03f, 6.59247264e-02f, -1.20063581e-01f, 8.51077065e-02f, -3.49117666e-02f, -1.22612685e-01f, 7.95147382e-03f, -3.55317034e-02f, -1.81747396e-02f,
  9.22475532e-02f, 4.58797254e-02f, 2.07593441e-02f, 2.13112086e-02f, 5.15459664e-02f, 1.20446878e-02f, -1.83439802e-03f, 2.04318631e-02f, 1.09983189e-02f, 2.62640808e-02f,
  2.70718639e-03f, -3.55204940e-02f, -7.82242566e-02f, -5.87827526e-02f, -3.81429158e-02f, -1.73240840e-01f, 9.93934795e-02f, 1.30863059e-02f, -6.20463863e-02f, 8.13741982e-02f,
  -1.75756160e-02f, 1.18807154e-02f, 5.72886951e-02f, -3.84178967e-03f, -7.95777794e-03f, 3.97194922e-03f, 2.37751957e-02f, -6.53433427e-02f, -4.88876589e-02f, 1.17285393e-01f,
  -2.02844337e-01f, -2.97949076e-01f, 2.31801830e-02f, -7.01720268e-03f, 2.52913889e-02f, -8.53044912e-02f, -9.87197179e-03f, -1.00423433e-01f, -5.06074838e-02f, 2.05711816e-02f,
  -1.36517778e-01f, 1.34223541e-02f, 1.25896661e-02f, 1.36718629e-02f, 7.67759979e-02f, 5.52092865e-02f, -3.47890076e-03f, -3.24340016e-02f, -2.43959930e-02f, -8.56774077e-02f,
  6.65770620e-02f, -7.90868998e-02f, 5.90596907e-02f, 2.60965824e-02f, -8.95810425e-02f, -5.80797456e-02f, -8.56832340e-02f, 7.89776593e-02f, 1.25311734e-02f, 9.42714699e-03f,
  2.95034200e-01f, -5.06174743e-01f, -3.76161695e-01f, 5.33437990e-02f, 2.12369338e-01f, 1.54800013e-01f, -8.21072161e-02f, 2.16290787e-01f, -2.74502337e-01f, 4.29857243e-03f,
  9.60513055e-02f, -4.04908955e-01f, -4.75224257e-01f, -1.37253478e-01f, -6.16683625e-02f, -5.31096995e-01f, 2.65698433e-01f, -2.50500944e-02f, -2.02941090e-01f, 2.11595014e-01f,
  1.07445784e-01f, 1.85904667e-01f, 5.13502918e-02f, 3.66360992e-01f, 2.83796519e-01f, 2.47577578e-01f, 4.92028236e-01f, -3.80304438e-04f, 4.14177358e-01f, 1.84709921e-01f,
  -2.01671869e-02f, -1.07377373e-01f, 1.62352677e-02f, -2.00673230e-02f, 1.61620975e-01f, 3.02570879e-01f, 1.30161718e-01f, -1.57341018e-01f, -1.05339132e-01f, -5.92353493e-02f,
  2.73060016e-02f, -8.15777928e-02f, -6.04171716e-02f, -1.48040196e-02f, 1.00484639e-01f, 1.00353556e-02f, -1.71188653e-01f, 7.06811319e-04f, -5.61280474e-02f, -1.36721268e-01f,
  -1.88740388e-01f, -2.93354057e-02f, 1.33585617e-01f, -1.99530110e-01f, -1.89440012e-01f, -1.04272310e-02f, -2.82971398e-03f, -3.05590276e-02f, 8.23449194e-02f, 1.63203508e-01f,
  5.69146462e-02f, 8.41276124e-02f, -7.54776970e-02f, -6.82422817e-02f, -1.01793356e-01f, -2.15946566e-02f, -3.94939352e-03f, 5.62195703e-02f, 9.35273841e-02f, 2.37223413e-02f,
  3.04703228e-02f, -4.61457595e-02f, 3.49963233e-02f, -2.39402913e-02f, 3.03359367e-02f, -4.14807871e-02f, 5.61167486e-02f, 7.46109337e-02f, -2.04082206e-02f, -1.46764085e-01f,
  -1.10195152e-01f, -4.44348389e-03f, -6.62721395e-02f, 6.65527508e-02f, -9.66264233e-02f, -7.89847970e-02f, 4.05946113e-02f, -6.73909485e-02f, 8.16324428e-02f, 3.13684866e-02f,
  2.17045099e-02f, 7.31046405e-03f, -1.21602006e-01f, 1.35206860e-02f, -1.32489011e-01f, 8.19323510e-02f, 1.28524080e-02f, -1.35966584e-01f, -8.61077681e-02f, 2.60023195e-02f,
  2.29604453e-01f, 1.36878505e-01f, 9.46397260e-02f, -3.41764768e-03f, 1.74811333e-01f, 6.00948445e-02f, 1.03010744e-01f, 1.24415986e-01f, 2.84956545e-01f, -7.01135620e-02f,
  5.29003255e-02f, -5.14954440e-02f, 5.15840836e-02f, -3.08152363e-02f, 3.90709378e-02f, 6.33967072e-02f, -6.61642523e-03f, 5.91925941e-02f, 5.79569191e-02f, -1.33015975e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 52)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 52;
const float L0_fan_Bp_bar_data[] = {
  1.93858743e-01f, 3.47942710e-01f, 1.61465332e-01f, 4.69787568e-01f, 1.96291074e-01f, 2.94245422e-01f, 3.74483317e-01f, 4.40604061e-01f, 2.75609255e-01f, 2.08161071e-01f,
  3.75105172e-01f, 1.70576990e-01f, 2.57415473e-01f, 2.21938297e-01f, 4.47872341e-01f, 3.71086538e-01f, 4.20805126e-01f, 3.72551262e-01f, 3.56881112e-01f, 3.47817361e-01f,
  1.61985710e-01f, 1.48639372e-02f, 3.52686346e-01f, 4.69755530e-01f, 3.97099972e-01f, 2.76206136e-01f, 2.67923355e-01f, 4.42739278e-01f, 4.82036024e-01f, 3.68970692e-01f,
  4.51871783e-01f, 1.47236153e-01f, 3.93540293e-01f, 4.09042865e-01f, 3.79446983e-01f, 3.62900913e-01f, 3.61446351e-01f, 3.17275941e-01f, 4.10112411e-01f, 2.65773922e-01f,
  1.94825709e-01f, 2.47033790e-01f, 4.69167560e-01f, 4.37123716e-01f, 3.15364212e-01f, 2.97236711e-01f, 2.49532387e-01f, 6.12514496e-01f, 3.15701514e-01f, 3.73070121e-01f,
  3.12338024e-01f, 4.88193542e-01f
};

// L1_linear_W (Shape: 12 x 128)
const int L1_linear_W_rows = 12;
const int L1_linear_W_cols = 128;
const float L1_linear_W_data[] = {
  -1.12727687e-01f, -1.63547143e-01f, 1.07735202e-01f, -6.21371232e-02f, -2.90630281e-01f, -1.00920759e-01f, -2.41872370e-01f, 2.01771855e-02f, 7.78036891e-03f, -1.39468342e-01f,
  1.34804323e-02f, -1.35093972e-01f, -1.43639207e-01f, -2.84199893e-01f, -1.55167818e-01f, -2.35640686e-02f, -2.06838250e-01f, -6.18471131e-02f, -1.68503553e-01f, 3.36440466e-02f,
  -2.70840913e-01f, 6.62425160e-02f, -2.13716298e-01f, -1.00883171e-02f, 8.41182321e-02f, -3.14122438e-01f, -1.07323878e-01f, -2.22833991e-01f, -3.53113301e-02f, -2.71538664e-02f,
  -1.30501971e-01f, -3.97890583e-02f, 1.07409693e-01f, -1.86557993e-01f, -1.94044650e-01f, 5.84982596e-02f, 4.13315631e-02f, -9.96758565e-02f, -3.01591247e-01f, -1.35190845e-01f,
  -6.59793690e-02f, -2.79977649e-01f, 2.54303217e-01f, -2.46192083e-01f, 1.42154336e-01f, -2.58372039e-01f, 1.56383868e-02f, -3.12945426e-01f, -5.12388311e-02f, 2.75405824e-01f,
  8.93664584e-02f, 1.49802074e-01f, -9.45276022e-02f, 1.00873724e-01f, -2.07446188e-01f, 4.89370674e-01f, 3.68319213e-01f, -1.62524655e-01f, 3.12335014e-01f, -1.39126435e-01f,
  1.66892081e-01f, 5.07101156e-02f, 5.95459230e-02f, 1.01490214e-01f, -2.28818342e-01f, 2.47824326e-01f, 3.65847111e-01f, -3.01001310e-01f, -1.69516057e-01f, 3.21087360e-01f,
  -1.02829151e-01f, 2.68147379e-01f, -3.87127340e-01f, -3.43687177e-01f, 1.66374460e-01f, 1.05959810e-01f, 4.11629170e-01f, 3.78192753e-01f, 1.33869082e-01f, 1.10584162e-01f,
  5.29131144e-02f, -3.24000537e-01f, 3.03870946e-01f, -2.18502909e-01f, 2.07661405e-01f, -4.71443862e-01f, -2.37811089e-01f, 5.23896098e-01f, -4.14861709e-01f, -9.49543640e-02f,
  -1.63104787e-01f, 2.04635724e-01f, -3.97901297e-01f, 2.81337082e-01f, -4.61905539e-01f, 3.12060565e-01f, -8.08596537e-02f, -1.68567881e-01f, 9.27170068e-02f, -2.05430910e-01f,
  -2.61739701e-01f, -1.91087842e-01f, -6.36011511e-02f, -3.06158721e-01f, -3.87400359e-01f, -6.24639466e-02f, -2.22462565e-01f, 3.50675493e-01f, -5.47750354e-01f, -7.64933079e-02f,
  -1.19096488e-01f, -1.30598456e-01f, -4.68701452e-01f, 2.02058583e-01f, 3.95554341e-02f, 2.48037905e-01f, 4.40845013e-01f, -1.46097541e-01f, -2.10574478e-01f, 2.38823712e-01f,
  2.17402726e-02f, -8.79333690e-02f, 4.12516534e-01f, -3.39338541e-01f, -1.85618147e-01f, -2.25108609e-01f, -4.43037838e-01f, -2.33904362e-01f, 8.34368020e-02f, 4.54770587e-02f,
  4.41138335e-02f, -1.56057581e-01f, -3.16096574e-01f, -6.71203807e-02f, 1.08959109e-01f, -3.27727795e-01f, -2.43654311e-01f, 1.22852251e-01f, -1.60252734e-03f, 2.40353525e-01f,
  -9.76154730e-02f, 1.11954138e-01f, -1.23178810e-01f, -2.28333056e-01f, -1.84139004e-03f, -3.19388896e-01f, 8.74106809e-02f, 9.62442067e-03f, 1.06459539e-02f, -3.48383814e-01f,
  1.38009312e-02f, -3.24986726e-02f, -2.50598758e-01f, 9.83982235e-02f, -1.37427866e-01f, 1.22744612e-01f, 9.48286727e-02f, 1.04372881e-01f, 2.22174209e-02f, 6.52742162e-02f,
  -3.71921659e-02f, -1.32906526e-01f, 8.12777206e-02f, 1.15322664e-01f, 1.79347679e-01f, -4.92817201e-02f, 4.17702883e-01f, -1.92775771e-01f, -1.90175742e-01f, 1.92440554e-01f,
  -7.16328472e-02f, -6.20110705e-02f, 2.03989521e-01f, -2.15000480e-01f, -3.07581335e-01f, 2.01997726e-04f, 3.51707399e-01f, -1.08457930e-01f, 1.00794621e-01f, 1.98968321e-01f,
  -2.95218527e-01f, 3.89915794e-01f, -3.73417437e-01f, -3.29611868e-01f, -3.36648643e-01f, 5.58537431e-03f, 2.02711508e-01f, -3.98742050e-01f, 1.38998538e-01f, -2.84263995e-02f,
  1.43952444e-02f, -4.72097695e-02f, 3.72418106e-01f, 1.12197235e-01f, -7.50056058e-02f, 3.72874528e-01f, -3.10783982e-01f, 2.87703779e-02f, -3.29104334e-01f, -2.06656560e-01f,
  4.42004293e-01f, 2.24321231e-01f, -3.45828896e-03f, 7.41591677e-02f, -3.38320643e-01f, 2.46029243e-01f, 2.63115019e-01f, 1.51463240e-01f, 1.37560070e-01f, -6.97344318e-02f,
  -3.08840990e-01f, 2.32846752e-01f, 2.89293051e-01f, 2.83633739e-01f, -9.93376076e-02f, -2.10500270e-01f, -4.07366574e-01f, 1.92464665e-02f, -6.94691658e-01f, 3.76782119e-01f,
  -4.86937612e-01f, 7.61113018e-02f, 2.14518502e-01f, 2.59988517e-01f, 1.82555467e-01f, 3.87687981e-01f, -3.52190197e-01f, 2.90662885e-01f, -2.04370975e-01f, -6.81609809e-02f,
  -1.64237887e-01f, -2.78908551e-01f, -5.85372746e-01f, 1.78557336e-01f, -2.84368664e-01f, 2.65366286e-01f, 1.54380992e-01f, 2.41093896e-02f, 2.84533530e-01f, -1.25648931e-01f,
  1.25749856e-01f, -5.68061471e-01f, -9.75821763e-02f, 2.47013181e-01f, 1.41507789e-01f, -1.28031403e-01f, -5.15341640e-01f, 2.95857340e-01f, -5.64516783e-01f, -5.06295800e-01f,
  -5.31014502e-01f, -3.81701142e-01f, -1.64385155e-01f, 3.25022750e-02f, -2.69520611e-01f, 1.65715486e-01f, -2.06186831e-01f, 2.37334203e-02f, -2.14590728e-01f, 1.23810507e-01f,
  7.17117041e-02f, 5.32608218e-02f, 7.62335137e-02f, 1.23202063e-01f, -1.39269888e-01f, 2.12938171e-02f, -1.69939846e-01f, -2.52984822e-01f, 4.81277071e-02f, -6.44778535e-02f,
  -1.64903969e-01f, -1.69259429e-01f, 1.17459722e-01f, 2.62506064e-02f, -8.44990984e-02f, -3.15832704e-01f, -9.66607705e-02f, 1.05269872e-01f, -3.08419466e-02f, -5.31011485e-02f,
  -1.36901453e-01f, -2.10887581e-01f, -6.63766786e-02f, 2.60173846e-02f, -1.01547495e-01f, 7.61489645e-02f, 3.02343890e-02f, -4.27954122e-02f, -1.87855497e-01f, 5.92725873e-02f,
  -7.00366423e-02f, -3.20836902e-01f, -1.11886613e-01f, -5.12954500e-03f, 2.24754199e-01f, -3.94288860e-02f, -3.07297170e-01f, 2.00974733e-01f, 2.11212277e-01f, 2.42730811e-01f,
  -2.20945567e-01f, -1.12548545e-01f, -1.25132754e-01f, 2.72468686e-01f, -3.06950092e-01f, -1.41972661e-01f, -2.63780840e-02f, 2.71791846e-01f, 1.75902233e-01f, -4.01843905e-01f,
  4.01042365e-02f, 4.71026897e-02f, -9.10426751e-02f, 2.38498688e-01f, 3.19304705e-01f, 2.06359103e-01f, 2.39056706e-01f, -2.94060558e-01f, -2.07112223e-01f, -2.54050195e-01f,
  2.02404812e-01f, 9.79010165e-02f, 1.97787419e-01f, -1.30364314e-01f, -3.87087524e-01f, -3.98493469e-01f, -2.05256328e-01f, 2.27575019e-01f, 2.47061998e-01f, 1.91883400e-01f,
  1.88458487e-01f, -3.87647599e-02f, -2.92293251e-01f, -4.60111886e-01f, 2.94012904e-01f, -2.97075927e-01f, -1.78816523e-02f, -1.50568739e-01f, 4.21103507e-01f, 9.23223570e-02f,
  -1.47749707e-01f, -3.90268296e-01f, -1.53762579e-01f, -2.60616750e-01f, -2.01281816e-01f, 3.80683064e-01f, 4.70340848e-01f, 1.90829039e-01f, 8.85142684e-02f, -1.73288450e-01f,
  -1.35598378e-03f, -2.16593206e-01f, -3.05593163e-01f, 1.77684918e-01f, -3.35568339e-01f, -2.40096569e-01f, -3.01932096e-01f, -1.62028298e-01f, -2.59459525e-01f, -3.02213371e-01f,
  -4.71984237e-01f, 6.64320439e-02f, 3.93856168e-01f, 5.36410511e-02f, 2.12764621e-01f, -4.34008911e-02f, -3.40244412e-01f, -3.80197257e-01f, 3.28559279e-01f, -6.17700350e-03f,
  -3.96877259e-01f, -2.50881642e-01f, -3.17012280e-01f, -1.55221224e-01f, -2.60276765e-01f, -1.08645149e-01f, 2.79493164e-02f, -2.24116221e-01f, -1.34287968e-01f, -1.68630015e-02f,
  -1.56168893e-01f, 9.37354118e-02f, -1.72765911e-01f, 3.50633234e-01f, -1.28863528e-01f, -2.53447387e-02f, -3.49402893e-03f, 2.65524387e-01f, -6.32691681e-02f, 8.93807970e-03f,
  -2.24533930e-01f, -8.38385969e-02f, -2.70266622e-01f, -3.39186609e-01f, 8.69471803e-02f, 3.47456485e-02f, 1.11163789e-02f, -1.54353306e-01f, -2.23760843e-01f, -7.95627460e-02f,
  -2.59415329e-01f, -7.33444542e-02f, -5.46426624e-02f, -3.22685301e-01f, 6.93639517e-02f, 6.04893686e-03f, -4.09744047e-02f, -1.46902502e-01f, -1.43056482e-01f, 1.63888216e-01f,
  -2.02023029e-01f, 1.84665769e-01f, -2.72586793e-02f, -1.16308577e-01f, 8.01647231e-02f, -1.96794912e-01f, 7.65868351e-02f, 1.04668729e-01f, -1.21624969e-01f, -1.05147608e-01f,
  -4.73912200e-03f, -1.10173605e-01f, -1.15930766e-01f, 1.72367901e-01f, 1.88440770e-01f, -2.14556217e-01f, -4.35849726e-02f, 1.90613359e-01f, 2.72836119e-01f, 2.08666965e-01f,
  1.85852483e-01f, -3.21819484e-02f, -1.00814357e-01f, 2.33264208e-01f, 1.19257875e-01f, -3.14375818e-01f, 1.49229601e-01f, 5.83694912e-02f, -3.06178808e-01f, 5.41921370e-02f,
  6.52662143e-02f, -3.64827931e-01f, 2.20234513e-01f, -1.13535725e-01f, -4.54575300e-01f, -1.45943895e-01f, 2.26572216e-01f, -1.75371274e-01f, -2.64882028e-01f, 1.10751890e-01f,
  -4.28190500e-01f, -2.31004328e-01f, 8.15406591e-02f, 1.13308519e-01f, 4.24210548e-01f, -2.68174887e-01f, -2.21685529e-01f, -3.17940444e-01f, 2.42868945e-01f, -3.98195088e-01f,
  2.02867180e-01f, -4.18308862e-02f, -1.88283712e-01f, 3.90249103e-01f, -3.67932051e-01f, 1.42867431e-01f, 2.70872802e-01f, -3.41793686e-01f, -2.19409943e-01f, -4.22999300e-02f,
  -3.43033671e-01f, 9.35512409e-02f, -1.95782036e-01f, -1.79994449e-01f, -2.82613933e-01f, -3.49832267e-01f, 8.00897479e-02f, -3.39216202e-01f, -3.35655391e-01f, 5.90632446e-02f,
  -3.76603067e-01f, -3.09029631e-02f, 1.10273130e-01f, -3.17591429e-01f, -8.91647860e-02f, 3.92854214e-01f, 5.51672459e-01f, 3.51129800e-01f, -5.32751501e-01f, -3.08780760e-01f,
  -9.95119140e-02f, -1.44536033e-01f, -1.81910321e-01f, 3.87218110e-02f, -3.97453934e-01f, 2.90950835e-01f, -2.80541092e-01f, -1.77626103e-01f, -4.11730349e-01f, -1.69372007e-01f,
  -3.31586629e-01f, 4.56686676e-01f, 1.79538488e-01f, 2.60323405e-01f, -2.68245608e-01f, -4.46164608e-01f, 1.24672569e-01f, 2.93020457e-01f, 2.25506142e-01f, -3.67806256e-01f,
  2.08406523e-01f, -6.61650181e-01f, 1.18380181e-01f, 2.48620987e-01f, 8.36739317e-02f, -2.01816306e-01f, 7.95780197e-02f, 1.12043723e-01f, 2.90162653e-01f, 5.31207137e-02f,
  3.12995404e-01f, 4.78013791e-02f, 2.69137304e-02f, 1.18648164e-01f, 1.49308503e-01f, 2.16401219e-01f, 2.43794397e-01f, 2.24237709e-04f, 2.05257401e-01f, 1.12917244e-01f,
  -2.96431743e-02f, 8.23228210e-02f, 1.53506905e-01f, 9.82979313e-02f, 1.36225939e-01f, 1.59124941e-01f, -1.49078639e-02f, -3.29287760e-02f, 6.84786886e-02f, -8.65266249e-02f,
  -3.13852616e-02f, -1.26316592e-01f, 4.24597003e-02f, -3.71248201e-02f, -1.55106142e-01f, 1.41327888e-01f, 9.01421383e-02f, -6.84108585e-04f, 1.54805660e-01f, -3.64175364e-02f,
  2.44882286e-01f, -1.63940519e-01f, 2.24160254e-01f, -1.88180536e-01f, -1.08893007e-01f, -2.74497092e-01f, 4.68189627e-01f, 1.09103322e-01f, 3.78260970e-01f, -6.35494739e-02f,
  -1.75107226e-01f, 8.26986730e-02f, 3.98478836e-01f, 3.01916718e-01f, 5.56766152e-01f, -4.15580124e-01f, 2.18089204e-02f, -5.23238070e-02f, 4.08959538e-01f, 7.73642808e-02f,
  -9.13677141e-02f, 2.38332883e-01f, 2.77784854e-01f, -1.40199155e-01f, -3.90956163e-01f, 4.19461310e-01f, -2.03510538e-01f, 2.51909077e-01f, -9.15030017e-03f, -1.68366402e-01f,
  2.98527032e-01f, -3.26309800e-01f, -2.16577858e-01f, 1.05755396e-01f, -2.17919827e-01f, -2.08431259e-01f, -2.24124372e-01f, 4.53537881e-01f, 3.13414246e-01f, -2.98525512e-01f,
  -9.63170081e-02f, -8.26756880e-02f, -3.79655153e-01f, -4.75717872e-01f, -1.11767612e-02f, 7.77901113e-02f, 2.12900341e-01f, 1.71016172e-01f, 1.24935627e-01f, -3.57034385e-01f,
  7.83583820e-02f, -7.14727715e-02f, -4.13886756e-01f, -1.91545114e-01f, 1.57767087e-01f, 3.01672488e-01f, -1.53218940e-01f, -4.01370078e-01f, 3.55190597e-02f, -5.42896837e-02f,
  -2.05179587e-01f, -3.21831286e-01f, 4.06844974e-01f, 1.76965728e-01f, -3.92180532e-01f, -1.28278762e-01f, 3.67060378e-02f, 8.63758568e-03f, -3.89283299e-01f, -2.18460739e-01f,
  -2.55303532e-01f, -4.60997581e-01f, 2.04426840e-01f, 9.19038802e-02f, 1.15915565e-02f, -3.17084104e-01f, -2.15277806e-01f, -5.63056171e-01f, -2.24642977e-01f, -2.93891639e-01f,
  3.02196264e-01f, 3.89078200e-01f, 1.68419614e-01f, 3.26310188e-01f, 4.55084711e-01f, 2.17478573e-01f, -1.17351683e-02f, -2.94436961e-01f, 4.06294316e-01f, -1.70795709e-01f,
  -1.36984080e-01f, 1.86866522e-01f, -1.65083230e-01f, 2.91918367e-01f, -5.42427525e-02f, 6.14615194e-02f, 3.33878547e-01f, 7.99088478e-02f, 1.70033142e-01f, 1.60446271e-01f,
  1.32447869e-01f, -8.07424337e-02f, 1.91996098e-01f, 1.10522129e-01f, 9.75356102e-02f, 1.12665273e-01f, 1.10254012e-01f, 8.08282867e-02f, 2.37244144e-01f, 8.80740508e-02f,
  3.35625112e-01f, 1.60051167e-01f, -1.15493163e-02f, 4.21128199e-02f, 2.18661740e-01f, -7.50166643e-03f, 2.60848552e-01f, 9.52856466e-02f, 2.56926175e-02f, 1.40929490e-01f,
  -3.14636491e-02f, 4.72457670e-02f, 2.81664014e-01f, 3.52126099e-02f, 2.83365659e-02f, -1.38834655e-01f, -2.23948210e-01f, 1.05383709e-01f, -4.66985911e-01f, 1.87022150e-01f,
  -4.22794074e-02f, -1.02972634e-01f, 4.60275471e-01f, -3.54775637e-01f, -3.85102928e-01f, -2.65056074e-01f, -1.69340327e-01f, 3.90024185e-02f, 1.55644819e-01f, 3.87247175e-01f,
  -5.04829228e-01f, -1.17604643e-01f, -3.75639230e-01f, 4.32187676e-01f, -1.00408964e-01f, -4.13822770e-01f, -1.65162727e-01f, 4.48265821e-02f, -2.71126688e-01f, -1.90908790e-01f,
  -1.62679762e-01f, 1.12526312e-01f, -7.38882646e-02f, 3.06103081e-01f, -3.27135324e-02f, -1.97587714e-01f, -2.34890297e-01f, -4.04546363e-03f, -1.14729449e-01f, 1.55427337e-01f,
  2.55974829e-01f, 2.21465662e-01f, 1.52227238e-01f, -1.42909035e-01f, -3.53539467e-01f, 1.38183385e-01f, 1.35304824e-01f, -9.96835604e-02f, -3.40480417e-01f, -3.46680075e-01f,
  -4.05932814e-02f, -3.43769789e-01f, -4.35021460e-01f, 7.64838606e-02f, -4.66260105e-01f, 2.86323000e-02f, 2.81715155e-01f, -8.37118700e-02f, 5.26386857e-01f, -4.59085405e-01f,
  1.61321253e-01f, 4.90422025e-02f, -5.44344224e-02f, 3.23199362e-01f, 1.20868966e-01f, 1.81401923e-01f, -2.01984525e-01f, -3.30528408e-01f, -1.98996421e-02f, 3.41980249e-01f,
  -1.67733282e-01f, -1.01641871e-01f, 3.41694266e-01f, -2.41386592e-01f, 3.79134446e-01f, -9.60081741e-02f, 1.54475600e-01f, -6.31354868e-01f, 3.21930796e-02f, -1.91623256e-01f,
  4.02895026e-02f, -1.08057968e-01f, -7.81008080e-02f, -2.34869737e-02f, -2.20866501e-01f, 3.66742641e-01f, 2.00933650e-01f, -5.36546111e-01f, 2.58757114e-01f, -5.59717894e-01f,
  3.47933233e-01f, -3.84889275e-01f, -2.57601380e-01f, -2.79028893e-01f, 6.66361600e-02f, -1.98835075e-01f, -4.21001196e-01f, -4.70874161e-01f, 3.66200879e-02f, 9.43217129e-02f,
  1.26656160e-01f, 5.12361713e-02f, 1.02204747e-01f, -4.93668485e-03f, -2.64168203e-01f, -1.17091432e-01f, -3.00025165e-01f, -1.32985294e-01f, -2.89712083e-02f, -4.51269262e-02f,
  -1.94528904e-02f, 1.46064818e-01f, -2.16707110e-01f, 1.76189646e-01f, 9.59402174e-02f, -1.58844739e-02f, -1.69078216e-01f, 1.08470671e-01f, -8.21403489e-02f, -2.69540567e-02f,
  -1.18246488e-01f, 2.56314188e-01f, -4.80901599e-02f, 2.62619443e-02f, -7.74653777e-02f, 1.06691599e-01f, 1.23616479e-01f, 1.93398669e-01f, 5.48372082e-02f, 6.25794530e-02f,
  -2.15691198e-02f, -6.13409877e-02f, -2.13431090e-01f, 3.85015160e-02f, 1.18301839e-01f, -1.98306721e-02f, 2.89332509e-01f, 7.83825386e-03f, 3.42857242e-01f, -2.01767206e-01f,
  1.52271032e-01f, 5.40479302e-01f, -2.84450918e-01f, 3.24249625e-01f, -2.62463957e-01f, 3.49498808e-01f, -1.91460133e-01f, -1.53554156e-01f, 5.73261678e-02f, -2.79615641e-01f,
  2.23017082e-01f, -4.64539863e-02f, 2.53992051e-01f, 1.77820727e-01f, -9.84457284e-02f, -2.17376634e-01f, -2.91774541e-01f, 3.96193922e-01f, -4.28974688e-01f, -1.67427182e-01f,
  -1.86829969e-01f, -3.59565169e-01f, 3.06602448e-01f, -2.81696171e-01f, -2.38305792e-01f, 2.25170881e-01f, 3.00430417e-01f, 1.10976920e-01f, 1.51654974e-01f, -1.72006518e-01f,
  2.17264876e-01f, 2.64982004e-02f, -5.18851578e-02f, -4.20267314e-01f, -2.16105327e-01f, -2.21419215e-01f, -3.94659251e-01f, -1.60787106e-01f, -3.66105825e-01f, -2.57323027e-01f,
  8.04990232e-02f, 3.79364282e-01f, -2.39153475e-01f, -3.45917314e-01f, -1.49213925e-01f, 4.02322233e-01f, -2.88986024e-02f, -4.23226893e-01f, -3.46710950e-01f, -4.86408472e-01f,
  -4.79285866e-01f, -3.38678956e-01f, 4.33321565e-01f, -4.69480664e-01f, -8.73892903e-02f, -4.19705242e-01f, -3.78233463e-01f, 1.00685149e-01f, -3.93781424e-01f, -1.45729035e-01f,
  -2.19691560e-01f, 4.08809967e-02f, 3.69176000e-01f, -2.72876620e-01f, 3.65300238e-01f, 2.91793704e-01f, 3.54490906e-01f, -3.12005579e-01f, -1.44875795e-01f, -3.32324147e-01f,
  3.10507059e-01f, 3.27341914e-01f, 5.35466015e-01f, -9.01540071e-02f, 9.95695009e-04f, 8.85824934e-02f, -5.15023172e-01f, -2.93114781e-01f, 6.99352473e-02f, 1.07644223e-01f,
  -4.45022106e-01f, 2.99086064e-01f, -2.02036977e-01f, 2.03109026e-01f, -3.66782576e-01f, 1.93246454e-01f, -1.39439385e-02f, -2.24215597e-01f, -1.55539110e-01f, -7.68833086e-02f,
  -1.64185185e-02f, -8.50092992e-02f, -2.72926819e-02f, -1.81675613e-01f, -1.86254725e-01f, -5.56269847e-03f, -1.63753301e-01f, -1.04012109e-01f, 1.64891798e-02f, -5.45156421e-03f,
  9.26726237e-02f, 4.27062437e-02f, -8.88670161e-02f, -5.96949011e-02f, -1.04592770e-01f, -2.31487423e-01f, -1.84325740e-01f, -2.43205413e-01f, -6.05321154e-02f, -6.29457384e-02f,
  4.28146683e-03f, -4.39593978e-02f, -6.27544075e-02f, 1.86560303e-02f, -3.89192812e-02f, -6.34559840e-02f, -2.55559701e-02f, -1.11789636e-01f, -9.46531724e-03f, -5.77410497e-02f,
  -8.22830275e-02f, 5.92279248e-02f, -5.92567399e-02f, -4.76477221e-02f, 3.37995887e-02f, -2.68525034e-01f, -3.17110643e-02f, -2.85518542e-03f, -2.25384280e-01f, 2.93817848e-01f,
  -9.51950252e-02f, 1.86406896e-01f, 2.56824315e-01f, -2.66289175e-01f, -2.11990643e-02f, 2.46302560e-01f, -2.74276644e-01f, 4.81752865e-02f, -2.27697179e-01f, 7.00724199e-02f,
  3.13296407e-01f, 1.84312746e-01f, -6.99952915e-02f, -7.92454183e-02f, -2.52585411e-01f, 2.46833891e-01f, -1.28154501e-01f, -9.10496339e-02f, 7.10139945e-02f, -3.43259364e-01f,
  -2.24580809e-01f, 1.68052569e-01f, -1.39514804e-01f, -1.35985330e-01f, -6.13077022e-02f, 1.65462300e-01f, 1.15714349e-01f, -3.02681122e-02f, -1.33957744e-01f, 1.05642855e-01f,
  -1.62933126e-01f, -2.21597776e-01f, -1.97815195e-01f, -3.61088693e-01f, -5.57559989e-02f, 1.02533214e-01f, 3.67110521e-01f, 3.32537353e-01f, -2.22933084e-01f, -2.22762033e-01f,
  -1.95217833e-01f, 3.02337110e-01f, -1.32221520e-01f, -1.58150539e-01f, 3.03818405e-01f, 1.60385948e-02f, -1.74574688e-01f, -1.25689641e-01f, 1.67958900e-01f, -2.93638855e-01f,
  -2.53551483e-01f, -1.55649409e-01f, -2.25366086e-01f, -1.33278474e-01f, -1.69144779e-01f, -3.38124573e-01f, 2.95273095e-01f, 2.16590986e-01f, -2.54835188e-01f, -1.40319854e-01f,
  1.15907975e-01f, 2.29429185e-01f, -8.90236720e-02f, -1.17686056e-01f, -3.03458482e-01f, -3.13837349e-01f, -2.68292516e-01f, 9.45162848e-02f, -3.06875765e-01f, 3.92220110e-01f,
  -1.79246813e-01f, 5.08582639e-03f, -2.29242504e-01f, 2.13189393e-01f, -5.58668040e-02f, -1.92093924e-01f, 2.81699538e-01f, 1.65064424e-01f, -2.27792636e-01f, 6.65176064e-02f,
  3.97050053e-01f, 2.72316337e-01f, -1.57294989e-01f, -2.85467803e-01f, 5.55062704e-02f, -3.54607077e-03f, 3.48045565e-02f, -3.26852888e-01f, -2.71828696e-02f, -1.38784468e-01f,
  -7.84328431e-02f, 5.07266894e-02f, 5.01666851e-02f, -2.71806031e-01f, -4.83110324e-02f, 8.80650431e-02f, 1.09095760e-01f, -1.80100366e-01f, 1.99496117e-03f, 5.83812967e-02f,
  -2.25258663e-01f, -8.88115391e-02f, -1.90686956e-01f, -5.59374802e-02f, 3.21143195e-02f, -1.18003199e-02f, -1.67418510e-01f, -2.71613896e-01f, 1.37725025e-01f, 1.07518204e-01f,
  -1.03259757e-02f, -1.54540449e-01f, -1.71473045e-02f, -2.32068583e-01f, -1.82567835e-01f, -1.98451236e-01f, -2.18888819e-01f, 2.32781284e-02f, 2.13531163e-02f, -5.33392876e-02f,
  -2.73805469e-01f, 1.37820896e-02f, 4.68658842e-02f, 1.65102020e-01f, 5.84986769e-02f, 4.29007821e-02f, -9.02638063e-02f, -2.84036070e-01f, 1.46422148e-01f, -9.39464793e-02f,
  2.96794921e-01f, 2.54161477e-01f, -1.48682326e-01f, -4.52525094e-02f, -8.05277452e-02f, -2.94055670e-01f, -2.01857593e-02f, 1.62683278e-01f, 3.97864074e-01f, -1.03116415e-01f,
  -2.44773120e-01f, 1.91259161e-01f, 1.14792757e-01f, -8.42296705e-02f, -3.01445752e-01f, -2.85852492e-01f, 2.48539597e-01f, 5.53978682e-02f, -3.73846859e-01f, -3.12363267e-01f,
  2.11778030e-01f, 2.09029540e-01f, 3.13189536e-01f, 2.87447542e-01f, -1.81443855e-01f, 8.72568712e-02f, -3.72902632e-01f, 1.01047471e-01f, 2.19960734e-01f, 1.12040922e-01f,
  -4.99621369e-02f, -2.39141718e-01f, 3.06632370e-01f, -4.30175662e-01f, -3.57449979e-01f, -3.27855706e-01f, -1.32981300e-01f, -2.73477435e-01f, 1.00965165e-01f, 1.70275390e-01f,
  3.78794909e-01f, -9.95066538e-02f, -4.99567343e-03f, 3.33560795e-01f, 1.78886667e-01f, 5.50718792e-02f, -2.79402643e-01f, -3.17112684e-01f, -2.05478515e-03f, -2.71534622e-02f,
  -3.11073452e-01f, 7.19063506e-02f, 4.06895578e-01f, -2.85182476e-01f, 1.87379077e-01f, -2.90328205e-01f, 8.58900622e-02f, 6.43935502e-02f, -1.50387630e-01f, -2.51692623e-01f,
  -4.07768875e-01f, -1.91307694e-01f, -8.38165265e-03f, 1.99770540e-01f, -1.98374912e-01f, 4.13804352e-01f, 2.70365059e-01f, 2.16068074e-01f, 2.18412086e-01f, 1.17112920e-01f,
  -2.93120980e-01f, -4.94821072e-02f, -2.00759947e-01f, -2.52251059e-01f, 4.68015149e-02f, -1.75333858e-01f, -2.75280178e-01f, -3.35751086e-01f, -1.88126579e-01f, 1.72316134e-01f,
  -1.17876351e-01f, 6.77987561e-02f, -1.30402204e-03f, 5.06550185e-02f, -4.14718911e-02f, -2.66281605e-01f, 2.03423321e-01f, 5.89846075e-02f, -3.24423313e-01f, 1.66552901e-01f,
  6.77097067e-02f, 1.01874620e-01f, 2.37416774e-02f, -3.64191681e-02f, -1.16748415e-01f, -1.44948348e-01f, 1.91989958e-01f, 2.17133164e-02f, -1.91790372e-01f, 1.28742903e-01f,
  1.81978479e-01f, 1.69849336e-01f, 1.20373778e-01f, 5.06374612e-02f, 1.01280920e-01f, -2.45771140e-01f, -1.03768848e-01f, 9.54601262e-03f, -7.54979849e-02f, 2.31410526e-02f,
  -1.11593977e-01f, -1.74246747e-02f, -4.61290218e-02f, -4.24932800e-02f, 2.20584437e-01f, 1.45727918e-01f, 1.39604703e-01f, 1.97871253e-01f, -1.42851546e-01f, 7.80581310e-03f,
  -3.69997770e-01f, -3.44873309e-01f, -4.21862423e-01f, -3.15266520e-01f, -2.36339822e-01f, -2.13637650e-01f, -3.10470283e-01f, -1.78822860e-01f, -2.46314526e-01f, 2.82204300e-01f,
  -6.85184225e-02f, -3.21568131e-01f, -4.03466314e-01f, 3.45964760e-01f, -2.23765418e-01f, -2.35144794e-01f, 3.76681805e-01f, -1.58869907e-01f, -2.37587467e-01f, -1.56487197e-01f,
  -8.14012215e-02f, 2.09310681e-01f, 1.41962975e-01f, 4.35411960e-01f, -1.32889926e-01f, -1.47363111e-01f, 3.23963463e-01f, 9.26261172e-02f, 3.57908428e-01f, -3.63216251e-01f,
  7.50313699e-02f, -2.85785854e-01f, 1.49322510e-01f, -3.74594659e-01f, 1.19732589e-01f, 8.23602453e-02f, -2.07735673e-01f, 1.37686685e-01f, -3.07251543e-01f, -2.18347237e-01f,
  -4.63826001e-01f, -2.83489764e-01f, 5.62813222e-01f, 7.41415024e-02f, 1.82576388e-01f, 1.37802526e-01f, 7.34490895e-05f, -2.95250177e-01f, -4.06335175e-01f, 1.26504749e-01f,
  -1.42787039e-01f, -4.47590016e-02f, 3.55829716e-01f, -3.77191067e-01f, -4.86359984e-01f, 7.48669431e-02f, -3.63091171e-01f, 1.97718397e-01f, 4.65336710e-01f, -4.55343574e-02f,
  2.07081288e-01f, -5.40122390e-01f, 2.49317825e-01f, -2.26833522e-01f, -2.91555852e-01f, -3.43155116e-01f, 2.74594188e-01f, 4.39679287e-02f, 7.67358989e-02f, 1.29905000e-01f,
  -2.30826233e-02f, -3.04454297e-01f, 2.05744892e-01f, -1.51426673e-01f, -2.26774573e-01f, -1.30516529e-01f, -1.61754519e-01f, -4.45196807e-01f, -2.72245407e-01f, -3.07936013e-01f,
  -4.34883267e-01f, -4.90650594e-01f, -1.40119851e-01f, 3.92991543e-01f, 1.15513906e-01f, -5.25946558e-01f, 3.63548607e-01f, -2.77135167e-02f, 3.79762262e-01f, -2.63210952e-01f,
  1.02430783e-01f, -1.19436957e-01f, 5.10534868e-02f, -1.48019567e-02f, 1.37229994e-01f, 6.16865046e-03f, 1.27401143e-01f, 2.20639139e-01f, 5.38011342e-02f, 2.39769101e-01f,
  -1.18701622e-01f, 9.80956703e-02f, -1.74463138e-01f, 5.70959970e-02f, 1.28179610e-01f, 2.03228414e-01f, 9.80669111e-02f, 8.80647525e-02f, 8.23271573e-02f, 2.88309574e-01f,
  3.76522355e-02f, -4.34317105e-02f, 2.39626952e-02f, 1.16463676e-01f, 1.58050478e-01f, -6.84212223e-02f, 2.40017116e-01f, -2.33749777e-01f, -3.68793905e-02f, 1.95955575e-01f,
  9.98691916e-02f, 1.12162374e-01f, 2.20077887e-01f, -8.28299001e-02f, 8.18644091e-02f, 9.23210904e-02f, 9.36735794e-03f, 1.94045022e-01f, 3.61401170e-01f, 2.17233837e-01f,
  2.45316610e-01f, 2.93350905e-01f, -2.72167325e-01f, 1.61024898e-01f, 8.04080740e-02f, -2.98240664e-03f, 3.31347048e-01f, -7.70817846e-02f, 4.14315552e-01f, -3.93052876e-01f,
  3.19802791e-01f, -1.22522913e-01f, 2.98055768e-01f, 2.39220604e-01f, -1.46250442e-01f, 1.63549751e-01f, 3.89263183e-01f, -9.31337127e-04f, 1.75923392e-01f, -3.61168206e-01f,
  3.68582666e-01f, 3.43244374e-01f, 2.35154435e-01f, -3.76826882e-01f, -1.47548914e-01f, -3.93001437e-01f, 4.51532781e-01f, 3.05117577e-01f, -8.19744617e-02f, -1.34904176e-01f,
  -3.55749309e-01f, -2.68970430e-01f, 3.46891657e-02f, 3.87855142e-01f, 2.28199735e-01f, -1.54207079e-02f, -4.17294472e-01f, 4.04272765e-01f, -1.43275008e-01f, 3.27752411e-01f,
  -4.73389961e-02f, 3.20270389e-01f, -3.97440881e-01f, -3.82230908e-01f, -3.75895709e-01f, -2.12651446e-01f, -3.55983645e-01f, -3.18549126e-01f, -1.78795099e-01f, -1.34100392e-01f,
  1.64541379e-01f, 2.87018213e-02f, 2.93863267e-01f, -1.43889144e-01f, -3.13802749e-01f, -1.11890040e-01f, -2.14080393e-01f, -3.13453585e-01f, 3.57153654e-01f, -1.21002622e-01f,
  -1.41929582e-01f, -3.14140677e-01f, 1.61575764e-01f, -7.65390918e-02f, -3.35157603e-01f, 3.66321653e-01f, -2.93504298e-01f, -8.46595317e-02f, -2.56875843e-01f, 1.18615456e-01f,
  2.22561300e-01f, -1.10485047e-01f, -3.55457813e-01f, -2.55330384e-01f, -3.14850718e-01f, -2.05571443e-01f, -3.26052636e-01f, -3.29584897e-01f, -2.31206104e-01f, 7.18684345e-02f,
  -2.08260283e-01f, -1.95598379e-01f, -4.86449093e-01f, 3.13412070e-01f, -1.96648061e-01f, -1.34360909e-01f, -1.08060716e-02f, 4.93451923e-01f, 6.91191256e-02f, -9.40410048e-02f,
  1.08143976e-02f, 1.42122701e-01f, 2.10633725e-02f, 1.05765790e-01f, 8.04669857e-02f, 8.35736319e-02f, 5.81875034e-02f, 1.24457031e-01f, -3.70001979e-02f, -2.81452797e-02f,
  1.61237925e-01f, -1.28052384e-01f, 6.38440698e-02f, -6.01089746e-02f, 1.04183638e-02f, 8.74247178e-02f, 1.01380870e-01f, 8.23107585e-02f, -3.93436253e-02f, 7.22785220e-02f,
  1.94351897e-02f, 9.04617608e-02f, -1.17700092e-01f, -2.55624298e-02f, 1.45862609e-01f, 1.18535690e-01f, 5.05633466e-02f, 1.99573729e-02f, 3.47224576e-03f, 1.36136487e-01f,
  -1.91755757e-01f, -4.70872857e-02f, 8.38514417e-02f, 4.40046191e-02f, 9.51147377e-02f, 1.05963933e-04f, -3.72499466e-01f, 3.25894207e-01f, -1.82256158e-02f, 2.06760153e-01f,
  -3.68495524e-01f, -3.05437356e-01f, -8.89490917e-02f, 6.02738410e-02f, 5.20353019e-02f, -3.50792319e-01f, -1.54934704e-01f, 5.41359745e-02f, 1.67384163e-01f, -2.37798735e-01f,
  2.49827147e-01f, -3.38752091e-01f, 1.55437842e-01f, 3.26713413e-01f, -4.28849831e-02f, 2.41523266e-01f, -2.38072976e-01f, 3.42175186e-01f, 1.75238937e-01f, -3.49193484e-01f,
  3.69787484e-01f, 1.94572747e-01f, 1.56635657e-01f, -1.59200743e-01f, -1.26133516e-01f, 2.49275163e-01f, 2.81734973e-01f, -8.50086361e-02f, 3.45274210e-01f, 3.69463950e-01f,
  5.03866002e-02f, -3.14541698e-01f, 2.80816019e-01f, 2.66615868e-01f, -2.78087318e-01f, -2.06565171e-01f, -3.40532154e-01f, -3.42062354e-01f, -1.18514918e-01f, 8.48475769e-02f,
  -8.68907869e-02f, -3.56232405e-01f, 2.78466612e-01f, -2.64490724e-01f, 2.08519310e-01f, -1.57116517e-01f, -3.51012975e-01f, -3.00759822e-01f, 8.48380029e-02f, -2.39084691e-01f,
  3.58953685e-01f, -4.08582598e-01f, -2.55187809e-01f, -8.99166986e-02f, -3.65909077e-02f, -2.74480522e-01f, -3.19501191e-01f, 5.24410963e-01f, -1.34941354e-01f, -1.24091983e-01f,
  -2.40500420e-01f, 3.87556195e-01f, 2.00181484e-01f, -8.52454454e-03f, 1.36768520e-01f, -4.87125814e-02f, -3.48906994e-01f, 3.46953422e-01f, -9.01004896e-02f, -1.22326734e-02f,
  -2.99723804e-01f, 6.58990741e-02f, 5.43594778e-01f, -3.77847701e-01f, 1.44008443e-01f, 4.32778180e-01f, 2.93106824e-01f, -3.16761255e-01f, -8.13436955e-02f, -1.55151233e-01f,
  -2.42167413e-02f, -3.76634091e-01f, -3.89454663e-01f, -2.95988858e-01f, -3.86088759e-01f, -1.42780319e-01f
};

// L1_linear_B (Shape: 1 x 12)
const int L1_linear_B_rows = 1;
const int L1_linear_B_cols = 12;
const float L1_linear_B_data[] = {
  3.00045148e-03f, -7.45998994e-02f, -2.98100859e-02f, -9.79225785e-02f, -3.48723494e-02f, 1.26214623e-01f, 5.88514470e-02f, -1.14829458e-01f, -5.38435876e-02f, -2.59386450e-02f,
  7.75944814e-02f, -4.44159731e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 38, 52
    );
    
    // Camada 1: L1_linear
    linear_forward_pgm(
        buffer1, x_out,
        L1_linear_W_data, L1_linear_B_data,
        128, 12
    );
    }
    