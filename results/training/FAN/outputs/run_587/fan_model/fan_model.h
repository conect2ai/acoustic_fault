/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 16 (x1)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 16;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    static inline float fan_activation(float x) { return x; }

    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 6 x 120)
const int L0_fan_Wp_rows = 6;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  4.40123528e-01f, -3.80376279e-01f, -3.77862424e-01f, 2.48529807e-01f, -9.77597311e-02f, -1.59392372e-01f, -7.12819397e-01f, -9.11755264e-02f, 3.02036881e-01f, -2.44728759e-01f,
  5.18420599e-02f, 3.85525316e-01f, 2.92028129e-01f, 2.49677345e-01f, -1.21592889e-02f, -4.83170867e-01f, -3.63352597e-01f, -2.97556967e-02f, 2.01113701e-01f, 9.09160972e-02f,
  1.18646339e-01f, -2.17247322e-01f, 2.74762869e-01f, 1.71940342e-01f, -1.96136713e-01f, 6.73834458e-02f, -3.58686388e-01f, -1.40201962e-02f, 4.40947562e-02f, -1.49502724e-01f,
  -1.62765272e-02f, -1.18880821e-02f, 2.95304731e-02f, 1.35125637e-01f, -5.06283268e-02f, -5.01873232e-02f, -1.82996318e-02f, -2.92294640e-02f, 5.16745436e-04f, -3.13067846e-02f,
  1.41086830e-02f, 9.92603227e-02f, 2.01704837e-02f, -4.29044850e-02f, -4.59679738e-02f, -2.58875322e-02f, -2.94711511e-03f, 5.38503975e-02f, -7.18860328e-02f, -3.82151012e-03f,
  -6.78139031e-02f, -3.59173417e-02f, -1.29637673e-01f, -7.30745196e-02f, -4.91224322e-03f, 1.63335010e-01f, -5.36937527e-02f, 6.02424182e-02f, 4.74884640e-03f, -7.05966204e-02f,
  4.84816656e-02f, -5.20588607e-02f, -6.64590811e-03f, 1.32140173e-02f, 1.66259836e-02f, -3.86662968e-02f, 1.60281491e-02f, -9.89093184e-02f, 2.82083582e-02f, -7.29291588e-02f,
  -1.63405156e-03f, -5.63220941e-02f, -7.60247279e-03f, -7.86246732e-02f, 3.52592804e-02f, -5.37174568e-02f, -7.31258988e-02f, -2.26671249e-02f, 8.22880492e-02f, 1.20157038e-03f,
  -1.38839446e-02f, 1.54901773e-03f, -1.76577643e-02f, -1.80832427e-02f, 1.05422456e-02f, -1.28615471e-02f, -1.35519831e-02f, 1.55364592e-02f, 1.10788206e-02f, 4.54387628e-02f,
  3.23515981e-02f, 1.17114648e-01f, -2.71472987e-02f, 5.99830896e-02f, -6.71463683e-02f, 3.09896749e-02f, -4.05234657e-02f, 5.38193174e-02f, 4.79912013e-02f, -5.89642935e-02f,
  6.77189231e-02f, 1.16322632e-03f, -1.76088270e-02f, 2.29510982e-02f, -1.00868233e-02f, -2.46311934e-03f, -1.34315602e-02f, -7.05231074e-03f, 5.69691276e-03f, -2.86971480e-02f,
  -4.16469673e-04f, -8.47626328e-02f, 1.10808632e-03f, -1.69636235e-02f, -4.84182313e-02f, -3.72177958e-02f, -1.52301013e-01f, -1.15804963e-01f, -6.24457598e-02f, -3.50630164e-01f,
  3.10812652e-01f, 3.60022306e-01f, -8.82151306e-01f, 6.67021334e-01f, -2.31482804e-01f, -4.85815972e-01f, -1.48073778e-01f, 1.27271444e-01f, 2.58043408e-01f, 1.04029827e-01f,
  4.90549654e-02f, -2.59638578e-03f, -8.25928152e-02f, -4.57054675e-02f, 5.24988770e-03f, -9.36877355e-02f, -6.47090748e-02f, -1.69854552e-01f, -4.00512069e-01f, 1.01693302e-01f,
  4.69821513e-01f, 4.08639729e-01f, 3.41545373e-01f, 1.29168630e-02f, 2.19492570e-01f, -3.24676126e-01f, -3.53871733e-01f, -2.43766122e-02f, -1.13339797e-01f, 6.01707697e-01f,
  -1.23597734e-01f, 1.89365283e-01f, -9.14653614e-02f, 1.08730972e-01f, -4.15087305e-02f, 6.88466132e-02f, -8.57092068e-03f, 2.81937537e-03f, 7.39161950e-03f, -1.91091523e-02f,
  6.56820163e-02f, 2.61407476e-02f, -2.66538858e-02f, 4.99309860e-02f, 2.38100402e-02f, 4.45710681e-02f, 7.42841959e-02f, 6.56439736e-02f, -4.91725244e-02f, -1.37068015e-02f,
  1.56507656e-01f, 5.22403121e-02f, -2.17053980e-01f, -1.13460153e-01f, -4.81557958e-02f, -1.29531836e-02f, 9.20727998e-02f, 8.14707652e-02f, -1.04282662e-01f, 1.61517784e-01f,
  3.60814966e-02f, -8.17240253e-02f, -2.15599835e-02f, 3.51541117e-02f, -3.69464979e-02f, -4.26382907e-02f, -9.19737946e-03f, -5.43553708e-03f, 3.60832224e-03f, -1.96371134e-02f,
  1.53638320e-02f, -1.82430726e-02f, -5.44815557e-03f, 7.81288091e-03f, 2.86829118e-02f, 5.32093719e-02f, -3.82137783e-02f, 5.75132482e-02f, -2.27255598e-02f, 1.02061607e-01f,
  1.19507343e-01f, -2.02098154e-02f, -3.24278586e-02f, 4.11237739e-02f, 3.61481719e-02f, -2.97557563e-03f, 3.66706327e-02f, -5.70085011e-02f, -9.86251906e-02f, -2.20653694e-02f,
  3.94038893e-02f, -2.05424532e-01f, 4.45985124e-02f, 1.28631927e-02f, -3.04992236e-02f, -8.28078389e-03f, 2.19121035e-02f, -1.61643755e-02f, 2.90844161e-02f, 6.38969019e-02f,
  -4.94608581e-02f, -7.49715790e-02f, -5.41300699e-03f, 4.15500812e-03f, -3.69364507e-02f, 4.49352479e-03f, 4.24691616e-03f, -8.67130309e-02f, 1.17863184e-02f, 7.21868277e-02f,
  1.05682217e-01f, -8.94627869e-02f, -1.11634098e-01f, -5.39822392e-02f, 9.56081897e-02f, -1.61197752e-01f, -1.81280985e-01f, -5.08904420e-02f, -2.59428531e-01f, 8.95637572e-02f,
  -8.19138169e-01f, 3.09975326e-01f, -5.07141769e-01f, -2.52132326e-01f, 1.41533256e-01f, 8.50322377e-03f, -1.09517435e-03f, -9.40623053e-04f, -2.67931130e-02f, -7.23537579e-02f,
  3.12805235e-01f, 3.08031946e-01f, 2.03145176e-01f, 2.07407162e-01f, -1.07182704e-01f, -1.53150395e-01f, -4.67627019e-01f, -3.92029941e-01f, -1.78650722e-01f, 1.40073106e-01f,
  2.88357794e-01f, -1.97983041e-01f, -2.66923130e-01f, -1.01692818e-01f, 3.30969552e-03f, 2.64015883e-01f, -2.84783058e-02f, -1.10826328e-01f, 1.29057303e-01f, -4.71195698e-01f,
  -1.39322534e-01f, -1.08463943e-01f, 7.80699700e-02f, 1.14881471e-01f, 1.42742498e-02f, -6.01754263e-02f, 2.44533177e-02f, -1.27502874e-01f, 6.37484342e-02f, -7.15494826e-02f,
  5.77013418e-02f, 6.87462911e-02f, 1.14571434e-02f, 5.17025702e-02f, -4.25298363e-02f, -5.96188158e-02f, -9.03807357e-02f, -2.16098428e-01f, -1.13895401e-01f, -2.48437654e-02f,
  2.27924645e-01f, 6.03009872e-02f, -1.27264932e-01f, 1.00459710e-01f, -1.37191424e-02f, -4.83293198e-02f, 1.07456014e-01f, -2.33894512e-02f, -1.71138048e-02f, -7.02094510e-02f,
  6.15749834e-03f, 8.55909847e-03f, 2.40649916e-02f, -1.76484641e-02f, 2.06797682e-02f, 1.14864921e-02f, 9.69657594e-06f, 4.36075293e-02f, -2.95455530e-02f, -2.14973539e-02f,
  -2.23883186e-02f, -1.86176517e-03f, 6.44233674e-02f, -4.23831120e-03f, 2.70616673e-02f, -3.91732305e-02f, -6.81294948e-02f, -1.10061551e-02f, 5.30691594e-02f, -4.85675558e-02f,
  1.97771122e-03f, 2.88929604e-02f, -2.34997422e-02f, 6.75978838e-03f, -3.81598063e-02f, -4.17402387e-02f, 1.01430351e-02f, 4.95481752e-02f, 6.47614822e-02f, -3.55630107e-02f,
  1.62973523e-01f, 1.59391955e-01f, -8.60269591e-02f, -2.01427899e-02f, -5.56916296e-02f, 2.01094635e-02f, -2.36741379e-02f, 1.76228993e-02f, -1.35822566e-02f, -1.04592415e-02f,
  1.78191774e-02f, -8.10812861e-02f, 5.33954166e-02f, -4.99069691e-02f, 4.25820276e-02f, 6.84899315e-02f, 1.91990286e-02f, 3.35258543e-02f, -1.05603635e-02f, -7.39532337e-03f,
  -1.45725375e-02f, -2.56908983e-02f, 1.61981378e-02f, 3.69135216e-02f, 1.08446606e-01f, 6.20313771e-02f, 1.45502687e-02f, 4.08304445e-02f, 7.09789013e-03f, 6.13541305e-02f,
  -7.88661480e-01f, -1.31243706e-01f, 5.20598173e-01f, -2.33600706e-01f, 2.31542408e-01f, 1.56076908e-01f, -4.37944442e-01f, -3.53017658e-01f, -9.01343226e-02f, -2.41852645e-02f,
  2.05844596e-01f, 1.33395702e-01f, 5.02539426e-02f, 3.42837796e-02f, -4.07639891e-01f, -1.41135707e-01f, -3.14045623e-02f, -1.33949772e-01f, 1.23576475e-02f, 8.35854262e-02f,
  7.60185579e-03f, -2.21984416e-01f, -2.81031698e-01f, -1.63233072e-01f, -1.28940299e-01f, -1.70753270e-01f, 6.43402562e-02f, -1.90298945e-01f, -6.93241432e-02f, -2.61923790e-01f,
  -3.65298465e-02f, 4.81545413e-03f, 6.89902455e-02f, -2.48174760e-02f, 4.01425883e-02f, -7.01260120e-02f, -6.17782865e-03f, -7.71684796e-02f, -8.76383409e-02f, -1.73306409e-02f,
  7.56801516e-02f, 4.53961641e-02f, -9.25687179e-02f, 6.48388565e-02f, 6.98825624e-03f, 3.90599631e-02f, -4.81076688e-02f, -8.25883672e-02f, -3.37526575e-02f, 1.30988881e-01f,
  2.81154905e-02f, 1.00998417e-01f, 1.28182799e-01f, 3.02435439e-02f, 1.43104019e-02f, 1.14119075e-01f, 1.12351608e-02f, -2.30646674e-02f, -6.10449314e-02f, -2.95485586e-01f,
  -2.74949018e-02f, -6.31370693e-02f, 6.11318722e-02f, -1.66607387e-02f, 4.82844003e-02f, 3.37027870e-02f, 9.86772403e-02f, -5.32042123e-02f, 1.45068821e-02f, -1.22007683e-01f,
  3.50554362e-02f, 5.46557717e-02f, 9.15668160e-02f, -6.45976048e-03f, 3.12594809e-02f, 1.01693906e-01f, 4.40041758e-02f, -1.46883307e-02f, 8.52804929e-02f, -2.21190602e-02f,
  -5.25518730e-02f, 5.28832301e-02f, -1.07894437e-02f, -6.73746914e-02f, 3.48464958e-02f, 5.83183281e-02f, 4.66582626e-02f, 4.72539403e-02f, -2.61409804e-02f, 4.16308120e-02f,
  -1.28890127e-01f, 1.38857380e-01f, -1.09157167e-01f, -1.15757040e-03f, 5.72065264e-03f, 2.00238526e-02f, 2.96835024e-02f, 1.18495673e-02f, 1.15633104e-02f, -8.26286003e-02f,
  5.50333411e-03f, -1.20562747e-01f, -4.42974735e-03f, -5.80415577e-02f, -1.49679873e-02f, 2.44687628e-02f, -7.91244805e-02f, -7.97642171e-02f, 4.10724953e-02f, 1.99104790e-02f,
  -9.93390158e-02f, -1.30981445e-01f, -1.49319828e-01f, -6.36897460e-02f, -4.05182540e-02f, -4.14103866e-02f, 1.01001766e-02f, 9.84315667e-03f, -1.43377468e-01f, -3.31230670e-01f,
  -4.66607004e-01f, 2.04647198e-01f, 7.20564902e-01f, 2.51377553e-01f, 1.92701593e-01f, -4.76301201e-02f, 1.89661145e-01f, -7.25930706e-02f, -1.52370989e-01f, 2.31789425e-01f,
  1.70089483e-01f, -8.70752558e-02f, 1.38781294e-01f, 6.99479654e-02f, 4.37882952e-02f, 3.06223601e-01f, 5.26565254e-01f, 1.87775835e-01f, 3.73963645e-04f, -1.53622687e-01f,
  -1.36274666e-01f, -1.33681577e-02f, 8.46349052e-04f, -6.28956035e-02f, -2.68765576e-02f, -6.35645166e-02f, 4.04360116e-01f, -6.81509897e-02f, -1.01064742e-01f, 2.97249883e-01f,
  2.21983120e-01f, 1.54483393e-01f, 1.10857576e-01f, 1.11845218e-01f, 1.55912444e-01f, -3.18589881e-02f, 4.92524914e-02f, 1.36611372e-01f, 9.02299955e-03f, 1.47237435e-01f,
  2.17809379e-01f, 3.67558785e-02f, 1.75602943e-01f, 3.74697931e-02f, 9.54587758e-02f, 7.10426867e-02f, 1.11887872e-01f, 1.93097204e-01f, 2.32868433e-01f, 4.35402170e-02f,
  1.36919543e-01f, 6.24064915e-02f, 3.90986465e-02f, 1.85674965e-01f, 1.53102964e-01f, 1.16652608e-01f, 4.15908359e-02f, 7.55428821e-02f, 1.84762895e-01f, -9.13664326e-02f,
  4.42476291e-03f, -1.03683107e-01f, -1.58594310e-01f, -9.91113782e-02f, -1.85919002e-01f, -1.01836406e-01f, 2.67132018e-02f, -7.67144635e-02f, -1.01033367e-01f, -9.43321735e-02f,
  -8.82520713e-03f, 2.60644481e-02f, -4.84834835e-02f, 4.58521508e-02f, -5.08843362e-02f, -9.28934440e-02f, -9.15113166e-02f, 1.28682246e-02f, -2.29916032e-02f, -6.42784014e-02f,
  -8.37283134e-02f, -1.47465423e-01f, -5.75588867e-02f, -1.47178143e-01f, 2.29292531e-02f, 2.91677322e-02f, -1.08768344e-01f, -4.85670045e-02f, -9.71917883e-02f, -4.84692380e-02f,
  -2.40244180e-01f, 1.72987312e-01f, -2.78473459e-02f, 8.14694911e-02f, 1.72450822e-02f, 8.04018229e-02f, 1.20826423e-01f, 5.85174672e-02f, 7.02725798e-02f, -2.91782655e-02f,
  7.94413611e-02f, 4.75106901e-03f, 1.22331455e-01f, 4.17057946e-02f, -9.71355243e-04f, 3.59699763e-02f, 6.51712641e-02f, 5.32336794e-02f, 7.40148649e-02f, -4.25514393e-02f,
  9.24848542e-02f, -9.15407687e-02f, -1.53446868e-01f, -5.01834489e-02f, -1.69685613e-02f, -4.07975502e-02f, -2.54680719e-02f, -1.19085133e-03f, 4.73850295e-02f, -2.55736232e-01f,
  5.51771402e-01f, 4.48320545e-02f, -1.35394908e-03f, -3.04701418e-01f, -3.07939202e-01f, 2.68646032e-01f, 5.11614740e-01f, 1.68668166e-01f, -1.40191972e-01f, -2.24749669e-02f,
  -3.22576473e-03f, -1.71392605e-01f, -6.92814291e-02f, -7.02379420e-02f, 3.29035074e-01f, 1.22508310e-01f, -1.43045723e-01f, 1.32174054e-02f, 2.05594748e-01f, 7.52201080e-02f,
  -1.61443964e-01f, -9.16628614e-02f, 5.68788387e-02f, -3.93515900e-02f, -2.84422189e-01f, -8.27325135e-02f, -1.50703760e-02f, -4.08679321e-02f, 1.25444904e-01f, -5.41917920e-01f,
  -6.62498847e-02f, 1.43316701e-01f, -1.44335851e-01f, -1.31852388e-01f, -1.91396743e-01f, 4.51770760e-02f, 4.79769334e-02f, -9.09793973e-02f, -3.49646695e-02f, -1.06197983e-01f,
  -1.10386364e-01f, -1.13253556e-01f, -1.41092405e-01f, -4.22523543e-02f, 4.69281338e-02f, 1.42905846e-01f, -1.71933621e-02f, -3.01410127e-02f, 1.10097751e-02f, 8.96133259e-02f,
  -7.67720267e-02f, -6.81417435e-02f, 1.04837649e-01f, 7.68748894e-02f, 1.52378261e-01f, -1.01403005e-01f, 6.36235811e-03f, 5.20437695e-02f, 1.13007270e-01f, -1.46464393e-01f,
  -7.31494427e-02f, -3.19452770e-02f, 5.26483916e-02f, 4.61469963e-02f, -2.10354812e-02f, -1.59490071e-02f, -2.92406660e-02f, -1.85072590e-02f, -5.81001937e-02f, -1.06233510e-03f,
  -2.02112682e-02f, -4.41751909e-03f, -4.88915332e-02f, 9.16309506e-02f, -8.51337239e-02f, 5.77263273e-02f, 6.05936088e-02f, 3.61233205e-03f, -5.55975027e-02f, 8.59467965e-03f,
  -4.27835025e-02f, 1.73472818e-02f, 2.25961395e-02f, -8.86122510e-02f, -7.14954734e-03f, -5.23669161e-02f, -8.34116829e-04f, 2.57252809e-02f, 2.78249793e-02f, -5.36672259e-03f,
  -4.42605317e-02f, 1.52686983e-01f, -1.09799244e-01f, -7.19032213e-02f, 5.97523525e-02f, -7.32694417e-02f, -1.11676909e-01f, -4.78520244e-02f, -5.98879233e-02f, 1.23783657e-02f,
  5.78503218e-03f, 5.01442403e-02f, 2.44645551e-02f, 2.03057937e-02f, -4.38717082e-02f, -5.23625426e-02f, 5.29003330e-02f, 1.44478614e-02f, 2.84036249e-02f, -4.45392542e-02f,
  -2.06625164e-02f, 7.52051249e-02f, 1.07921086e-01f, -3.29398289e-02f, 1.59732327e-02f, 2.87251454e-02f, 2.05853488e-02f, -1.80584472e-02f, 2.50633866e-01f, 1.18281655e-01f
};

// L0_fan_Wp_bar (Shape: 4 x 120)
const int L0_fan_Wp_bar_rows = 4;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -1.70946550e+00f, -1.93019882e-01f, -8.10165331e-02f, -7.56410301e-01f, 1.34039372e-01f, 4.81024712e-01f, 2.49880522e-01f, 1.61886781e-01f, -1.86744422e-01f, -5.09523451e-01f,
  -5.22334278e-01f, -3.03036392e-01f, -4.09632087e-01f, 9.84328762e-02f, 1.65760666e-01f, 2.30551884e-01f, 5.05963802e-01f, 1.75266296e-01f, 2.85071075e-01f, 4.09361303e-01f,
  5.58103740e-01f, -1.12203479e-01f, -4.08244699e-01f, 2.32259646e-01f, -2.18050525e-01f, 1.67324975e-01f, -6.73452839e-02f, -2.50113994e-01f, 2.13377759e-01f, 1.49517462e-01f,
  -1.02522171e+00f, -4.96590406e-01f, 3.03938657e-01f, 7.80241638e-02f, 4.72248383e-02f, -3.48340183e-01f, -1.60334766e-01f, -1.81056008e-01f, -4.52329777e-02f, -1.32838652e-01f,
  -1.73822299e-01f, -6.87317252e-02f, -2.05542862e-01f, 1.73951209e-01f, -3.17299925e-02f, 1.65053576e-01f, 2.29284540e-01f, 1.25262439e-01f, -1.86889872e-01f, 6.39523715e-02f,
  3.43004912e-01f, -5.98964319e-02f, -3.38044524e-01f, 5.24111927e-01f, 3.80546898e-01f, 2.56597310e-01f, -1.60077259e-01f, 8.62296447e-02f, 3.27185877e-02f, -7.62392581e-01f,
  5.47346063e-02f, -7.09552027e-04f, 1.28414586e-01f, -9.32089686e-02f, 6.19369559e-02f, -6.32325485e-02f, 1.81382634e-02f, -6.81992322e-02f, 8.56711939e-02f, -1.35174260e-01f,
  2.73691267e-01f, -1.07649311e-01f, 9.70533490e-02f, -2.47456729e-01f, -3.13372761e-02f, 1.43616721e-01f, 1.54135659e-01f, -1.23894796e-01f, -4.10655513e-02f, -1.28441881e-02f,
  4.50938120e-02f, -5.37794270e-02f, 2.09013462e-01f, 2.58871317e-01f, 1.28919974e-01f, -2.76079495e-02f, -1.09943166e-01f, -1.06267318e-01f, -2.45707005e-01f, -9.89782363e-02f,
  -5.94913065e-01f, 7.35743344e-01f, -6.93165600e-01f, -1.02059364e-01f, -1.25887379e-01f, 1.16743855e-01f, -2.16899052e-01f, 1.61953002e-01f, -1.36520669e-01f, -8.29290152e-02f,
  2.62092710e-01f, -1.45431742e-01f, -1.22085452e-01f, 2.14509010e-01f, -1.01361901e-01f, -2.10571498e-01f, 2.11298298e-02f, -3.35939586e-01f, 2.08718047e-01f, 9.60139781e-02f,
  -1.64531060e-02f, -1.18320212e-01f, -6.28370404e-01f, -2.26655021e-01f, -7.12083653e-02f, -3.37748617e-01f, -6.90529525e-01f, -2.51283139e-01f, -5.68418503e-01f, -1.16969979e+00f,
  1.01231933e+00f, 4.39694166e-01f, 9.67485964e-01f, 4.19763356e-01f, -1.07320556e-02f, -4.18579370e-01f, -6.36900663e-01f, -4.79075104e-01f, 9.73318592e-02f, 1.81712583e-01f,
  2.60328948e-01f, -2.33851030e-01f, 7.39806145e-02f, -3.24914604e-01f, -3.33508968e-01f, 2.78186593e-02f, 2.72661686e-01f, 3.77223566e-02f, -7.69017398e-01f, -8.91783118e-01f,
  -8.52503002e-01f, -3.73214134e-03f, 1.92221120e-01f, -1.04400143e-01f, 5.73885739e-01f, -2.99749792e-01f, 7.11293161e-01f, 7.20064938e-01f, 2.12071776e-01f, 8.91973555e-01f,
  7.20378995e-01f, 8.63016367e-01f, -7.27486730e-01f, -3.16478424e-02f, 4.93984103e-01f, -4.65057120e-02f, -1.67321637e-01f, 3.74402076e-01f, 9.23685543e-03f, 5.08479960e-02f,
  2.22056895e-01f, -4.33066003e-02f, 1.79017365e-01f, -2.12505553e-03f, -1.16467729e-01f, -2.42992744e-01f, 1.01432987e-01f, -1.90705375e-03f, 1.00063920e-01f, 1.50449961e-01f,
  -3.22142363e-01f, 1.48823768e-01f, 4.18468356e-01f, -1.60553664e-01f, 3.76691148e-02f, -2.21198931e-01f, 1.35154575e-01f, 7.86801279e-02f, -1.18197210e-01f, 4.39444780e-01f,
  -1.75385445e-01f, 2.46101350e-01f, 8.91236290e-02f, -8.63555744e-02f, -1.56663075e-01f, 1.30484670e-01f, 5.35849808e-03f, -1.08923309e-01f, -1.03724144e-01f, 2.29768641e-02f,
  -1.04030758e-01f, -8.99639446e-03f, -1.65866241e-01f, -2.50856504e-02f, 7.19504207e-02f, 1.46301389e-01f, 6.66924864e-02f, -1.34731233e-01f, -4.78836522e-02f, -2.32970230e-02f,
  -5.96732982e-02f, 7.13977441e-02f, 2.33932465e-01f, -3.67558859e-02f, -4.83442191e-03f, 9.29770619e-02f, -1.23127503e-02f, -2.92779468e-02f, -1.12564430e-01f, 4.09574397e-02f,
  -4.51997638e-01f, -3.19704205e-01f, 1.87541604e-01f, -8.75026286e-02f, 2.28318289e-01f, 2.01696351e-01f, 2.23003462e-01f, -8.20366889e-02f, 1.27672017e-01f, -5.89986667e-02f,
  -5.57607226e-02f, -5.60502112e-02f, 2.14500412e-01f, -1.03069961e-01f, -2.73355603e-01f, 1.72761865e-02f, -1.93612590e-01f, -1.35979593e-01f, -2.17622638e-01f, 6.52572662e-02f,
  1.57634486e-02f, -7.57626772e-01f, -8.58318508e-01f, -2.97153413e-01f, -7.31099024e-02f, -6.00292742e-01f, -3.18205178e-01f, -3.60994905e-01f, -4.48812664e-01f, -8.69732797e-01f,
  -2.52936512e-01f, 3.95990878e-01f, -3.17420572e-01f, 5.44481993e-01f, 1.02818704e+00f, 7.08184600e-01f, 6.92712367e-01f, 6.37185108e-03f, -2.99183037e-02f, 3.30514401e-01f,
  6.62240326e-01f, 2.31211230e-01f, 6.25303090e-02f, -7.89151490e-02f, -2.31243685e-01f, 5.46853170e-02f, 5.37504815e-02f, -4.96591896e-01f, -3.81494373e-01f, 2.08209410e-01f,
  5.12233973e-01f, -2.15682574e-02f, -4.43877488e-01f, -2.70490110e-01f, 1.79853231e-01f, 8.12303722e-02f, 9.99702737e-02f, 4.68794495e-01f, 4.83622640e-01f, 2.68544018e-01f,
  3.21481004e-02f, 1.39118373e-01f, -1.46034554e-01f, 1.83506027e-01f, 3.09902765e-02f, -5.05229712e-01f, -2.07843572e-01f, -3.46059442e-01f, -1.37793021e-02f, -3.45852710e-02f,
  1.32410362e-01f, 2.49189772e-02f, 2.34183103e-01f, -2.53609531e-02f, -5.62550388e-02f, -3.21409740e-02f, -3.21041971e-01f, -2.73006201e-01f, -6.37910664e-02f, -6.23595975e-02f,
  4.31720078e-01f, 4.56681192e-01f, 1.49453774e-01f, 8.65449682e-02f, 1.49773896e-01f, 7.02139884e-02f, -2.26864684e-03f, -1.60556622e-02f, -1.51953459e-01f, -3.61889273e-01f,
  3.11178650e-04f, 1.46154091e-01f, 1.97621778e-01f, -2.33507499e-01f, 1.61615044e-01f, -1.83475122e-01f, -7.70471022e-02f, 1.66220561e-01f, 1.50222838e-01f, -2.00560048e-01f,
  -1.39995664e-01f, 4.41018678e-02f, -3.19391519e-01f, -2.13545278e-01f, 6.06628843e-02f, 2.23059813e-03f, 3.83336134e-02f, -1.14644341e-01f, 1.45337820e-01f, -1.08362287e-02f,
  1.20276190e-01f, -6.28824607e-02f, -1.14860579e-01f, -2.13882253e-01f, -3.05470638e-02f, -1.43221375e-02f, 1.61050081e-01f, -4.65460308e-02f, 1.75608285e-02f, 1.17822602e-01f,
  -5.83298743e-01f, 3.35633069e-01f, -1.03572801e-01f, -1.74568802e-01f, 8.56757984e-02f, -9.79238376e-02f, 3.06517482e-01f, 2.70573776e-02f, 1.44359335e-01f, -1.18244402e-01f,
  8.56261477e-02f, -1.96703270e-01f, 9.88550559e-02f, -1.76600322e-01f, -1.11679979e-01f, -9.75980684e-02f, 4.91844788e-02f, -4.34323363e-02f, -1.52175426e-01f, -3.13605398e-01f,
  -8.84132385e-02f, -1.18496127e-01f, -2.10417032e-01f, -1.92988470e-01f, 8.80898312e-02f, -4.48071351e-03f, -2.28967577e-01f, -2.67367870e-01f, -2.50366747e-01f, -5.05435705e-01f,
  1.60091746e+00f, -1.26447666e+00f, 3.19575697e-01f, 2.38720223e-01f, -2.33397335e-01f, -1.79029241e-01f, -7.82725930e-01f, -1.14019699e-01f, 1.86909288e-01f, -2.37261087e-01f,
  -3.39382291e-01f, 2.82329559e-01f, 3.45741302e-01f, 3.40399474e-01f, 4.32429463e-01f, -1.13418274e-01f, 6.80010393e-02f, 8.83317530e-01f, 8.73748660e-01f, -1.60416532e-02f,
  -1.37111887e-01f, -7.99355134e-02f, 3.10688168e-01f, 1.75716028e-01f, -3.81050527e-01f, 1.52945012e-01f, -3.85898799e-02f, -4.71921146e-01f, -3.93672585e-01f, -3.31521519e-02f,
  -2.77447551e-01f, -1.67513803e-01f, 3.92565697e-01f, -1.42691715e-03f, -7.80328810e-02f, 1.71397835e-01f, 9.12247449e-02f, -7.40580410e-02f, -9.40278843e-02f, -1.35252520e-01f,
  -6.86546937e-02f, -3.85010205e-02f, 8.31646472e-02f, -1.96117144e-02f, -1.82609469e-01f, -9.17700157e-02f, 9.96199995e-02f, 1.49283573e-01f, 1.01665080e-01f, -1.69757739e-01f,
  -2.28083357e-01f, -1.67973116e-01f, -1.08457118e-01f, -5.46435863e-02f, 1.57642335e-01f, 1.23263508e-01f, -1.67878106e-01f, 2.42911652e-02f, 2.03056842e-01f, -7.95953814e-03f,
  -7.16267480e-03f, 1.02165543e-01f, -4.78750281e-03f, -5.91829345e-02f, 2.25243904e-03f, -4.25643064e-02f, 4.26816046e-02f, -4.87488471e-02f, 1.56241924e-01f, 3.59143168e-02f,
  -1.18582673e-01f, 1.30599126e-01f, -2.02757362e-02f, -3.46552730e-02f, 6.81761131e-02f, 3.35197784e-02f, 6.35658437e-03f, -1.41117945e-01f, 5.41146733e-02f, -6.22434169e-02f,
  2.35288158e-01f, 4.95685153e-02f, -2.02184450e-02f, -6.74588159e-02f, -1.75447151e-01f, 6.91217557e-02f, 1.43452585e-01f, -2.34143231e-02f, -4.64574173e-02f, -1.13771506e-01f,
  -3.89225215e-01f, 5.06857634e-01f, 8.27043131e-02f, 1.17256552e-01f, -2.85703912e-02f, -1.50456384e-01f, 3.97192314e-02f, -4.11713608e-02f, -2.43790716e-01f, -8.31752643e-02f,
  -9.59044322e-02f, 1.51525825e-01f, -7.14928582e-02f, -3.86198983e-02f, 1.14714898e-01f, 6.40976243e-04f, -3.97643670e-02f, 9.64972302e-02f, -4.06513214e-02f, -2.27935284e-01f,
  -1.80301994e-01f, 1.14666790e-01f, 6.46424806e-03f, 1.41802058e-01f, 1.01449221e-01f, 3.63108367e-01f, -1.36594653e-01f, -1.38013139e-01f, 1.26134276e-01f, -1.47568524e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 4)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 4;
const float L0_fan_Bp_bar_data[] = {
  9.17305350e-01f, 1.15756428e+00f, 1.02374196e+00f, 1.31600368e+00f
};

// L1_linear_W (Shape: 12 x 16)
const int L1_linear_W_rows = 12;
const int L1_linear_W_cols = 16;
const float L1_linear_W_data[] = {
  -1.59418881e+00f, 8.24097157e-01f, -9.27791536e-01f, -3.27754766e-01f, -1.21413863e+00f, 1.29148319e-01f, 5.91477275e-01f, 8.18956375e-01f, 2.62290239e-01f, 1.09008765e+00f,
  5.07596254e-01f, -2.28275701e-01f, 9.95470524e-01f, -2.17739463e+00f, -1.90595388e+00f, -2.37025872e-01f, -8.77877772e-01f, 4.35581237e-01f, 5.83833516e-01f, 4.38778639e-01f,
  -4.51868773e-01f, -3.59559178e-01f, 1.69101799e+00f, -5.72086334e-01f, 4.85096067e-01f, 2.30340198e-01f, -2.76110377e-02f, 3.46279770e-01f, -2.14765906e+00f, -7.55583942e-01f,
  4.67692196e-01f, 1.19928074e+00f, 1.78967729e-01f, 3.07994317e-02f, 5.16629696e-01f, 6.63812280e-01f, 7.71392047e-01f, -3.62292469e-01f, 8.68708491e-01f, -2.50012726e-01f,
  -1.18828082e+00f, 6.77855670e-01f, 1.21334517e+00f, -1.07875073e+00f, 6.50487602e-01f, -2.11030349e-01f, -1.52623105e+00f, 5.52701950e-01f, 1.10999835e+00f, -2.59703964e-01f,
  -7.15022266e-01f, -1.35920393e+00f, 1.48038423e+00f, 2.08178580e-01f, -6.83051288e-01f, -1.69201326e+00f, -1.08687975e-01f, 1.34877533e-01f, -5.55615962e-01f, 1.26356089e+00f,
  1.11548924e+00f, -1.12856889e+00f, -5.09195566e-01f, -2.47837567e+00f, 2.39877999e-02f, 1.07278287e+00f, 1.95099771e-01f, -1.46658468e+00f, 9.39048231e-02f, -2.65396178e-01f,
  7.99621820e-01f, 5.85080460e-02f, 1.45721400e+00f, 7.68399715e-01f, -9.64515090e-01f, -6.59280658e-01f, -2.67006934e-01f, 8.91260087e-01f, -1.01495492e+00f, -9.60484445e-01f,
  1.62618673e+00f, 9.20740724e-01f, 1.18273556e+00f, 5.70025265e-01f, -7.47829497e-01f, 6.64533854e-01f, 5.60830653e-01f, 2.67757368e+00f, 8.91882420e-01f, -1.62470913e+00f,
  -5.98506451e-01f, 9.55037951e-01f, -8.47355783e-01f, -1.07926083e+00f, 5.63970441e-03f, -6.48255527e-01f, 4.57660198e-01f, -1.23376691e+00f, -1.76758504e+00f, -8.64334643e-01f,
  -1.37845427e-01f, 3.91472220e-01f, -2.55814850e-01f, 7.09988177e-01f, -1.94581762e-01f, -1.09963703e+00f, 1.03836775e+00f, -3.88077497e-01f, -9.68834341e-01f, 9.25870955e-01f,
  -1.06118393e+00f, 2.58978993e-01f, -8.03852797e-01f, -3.94945681e-01f, 8.90038729e-01f, 3.16010684e-01f, -1.04975998e+00f, -8.68836403e-01f, -6.46568894e-01f, 1.97576210e-01f,
  3.82392071e-02f, -2.27997676e-01f, 3.22649091e-01f, -9.38894153e-01f, 6.33028209e-01f, -1.00088680e+00f, 6.54673576e-01f, -6.20560348e-01f, -4.95430559e-01f, -7.84639537e-01f,
  -4.84787226e-02f, 9.70230758e-01f, 7.26833820e-01f, 1.02670915e-01f, -1.62231946e+00f, -1.65903401e+00f, -1.75265276e+00f, -1.16227007e+00f, -8.96578729e-02f, 7.90549278e-01f,
  -5.30332983e-01f, -8.79388750e-01f, -6.11276217e-02f, 5.20463586e-01f, 6.29118681e-02f, -1.24783969e+00f, 1.18369818e+00f, 1.15584123e+00f, 1.50755629e-01f, -1.94368231e+00f,
  1.54048300e+00f, 9.60580587e-01f, -8.96885931e-01f, 1.42039642e-01f, -2.49385640e-01f, -1.49666631e+00f, -7.43315518e-01f, 6.31527722e-01f, 1.63344219e-01f, -4.21948135e-01f,
  8.84631813e-01f, -1.66254580e+00f, -6.03375673e-01f, 1.25727606e+00f, 4.98864889e-01f, 1.46482635e+00f, -1.70531619e+00f, -1.38567126e+00f, 1.51814497e+00f, 1.12989879e+00f,
  -1.00815523e+00f, 2.18608543e-01f, -1.81584513e+00f, -1.31185246e+00f, -1.04432142e+00f, -2.06292725e+00f, -9.09106135e-01f, 1.08110929e+00f, -9.00920704e-02f, 1.31947130e-01f,
  -1.77927479e-01f, -2.18520164e-02f, -9.89167929e-01f, -2.94527411e-01f, -7.76205063e-01f, -9.85230133e-02f, 5.60896039e-01f, 2.35342789e+00f, -1.27376664e+00f, 6.53094947e-01f,
  5.64499676e-01f, -1.81365478e+00f
};

// L1_linear_B (Shape: 1 x 12)
const int L1_linear_B_rows = 1;
const int L1_linear_B_cols = 12;
const float L1_linear_B_data[] = {
  5.87184548e-01f, -6.47439480e-01f, -7.05992222e-01f, -3.57342839e-01f, 5.50223649e-01f, 1.00737691e+00f, -5.94889641e-01f, -2.35050358e-02f, -2.56354958e-01f, -6.12085521e-01f,
  6.34572327e-01f, -4.11318123e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 6, 4
    );
    
    // Camada 1: L1_linear
    linear_forward_pgm(
        buffer1, x_out,
        L1_linear_W_data, L1_linear_B_data,
        16, 12
    );
    }
    