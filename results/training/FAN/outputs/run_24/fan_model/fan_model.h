/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 16 (x3)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 16;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    float x3 = x * x * x;
    return 0.5f * x * (1.0f + tanhf(0.79788456f * (x + 0.044715f * x3)));
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 1 x 120)
const int L0_fan_Wp_rows = 1;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -1.40449367e-02f, 2.51443475e-01f, 8.60046688e-03f, 3.91225964e-01f, -1.11676276e-01f, 2.58807182e-01f, 3.53364408e-01f, 3.77446413e-02f, 2.94719636e-01f, 2.40250096e-01f,
  1.97449829e-02f, 2.91765958e-01f, -4.58204001e-02f, 2.71543801e-01f, -1.42652750e-01f, -1.07346527e-01f, 1.12376653e-01f, 9.35637951e-02f, -8.74620378e-02f, -6.70469627e-02f,
  -2.19135433e-02f, -2.54972521e-02f, -9.32665542e-02f, -1.07661314e-01f, -1.04686338e-02f, 3.87288928e-02f, -1.06127530e-01f, 2.47807633e-02f, 8.48687366e-02f, 9.83320102e-02f,
  -1.54130394e-02f, -1.08768135e-01f, -1.13681098e-02f, -2.82408409e-02f, -8.06541964e-02f, 9.05898307e-03f, -3.99895050e-02f, -2.28262860e-02f, -2.06040032e-02f, -3.22485901e-03f,
  6.57716533e-03f, -5.38617596e-02f, 8.00260529e-03f, 5.94810396e-02f, 6.93034381e-02f, 1.16502056e-02f, 3.52817327e-02f, 1.72543731e-02f, 7.19611719e-02f, -9.73179936e-02f,
  7.79653266e-02f, -3.52794379e-02f, -3.49189192e-02f, -2.82616112e-02f, -4.02001329e-02f, 2.39171516e-02f, -1.25403022e-02f, 2.35480554e-02f, -6.04499243e-02f, 1.33197708e-02f,
  -6.48714527e-02f, -6.67710453e-02f, 2.94286199e-03f, -6.19865023e-03f, -2.44128685e-02f, -1.20719656e-01f, 2.54455078e-02f, -5.37423193e-02f, 4.57917601e-02f, -7.52670690e-02f,
  4.79748584e-02f, -2.85967551e-02f, -2.40510162e-02f, 6.88615302e-03f, 6.41947845e-03f, -2.46998183e-02f, -1.29159754e-02f, -2.03752657e-03f, 8.26109275e-02f, -6.85258443e-03f,
  -5.24332710e-02f, 2.16336828e-02f, -9.33628716e-03f, -2.76405681e-02f, -8.27634931e-02f, 5.10647409e-02f, 8.23808014e-02f, 3.03559937e-02f, 6.08403003e-03f, -4.99031553e-03f,
  1.52941654e-02f, -1.43883526e-02f, 9.17635218e-04f, 4.15437333e-02f, -6.62030885e-03f, 4.01230380e-02f, -4.61689830e-02f, -3.31643373e-02f, 9.12317336e-02f, -2.22462267e-02f,
  -6.77616745e-02f, 5.19034965e-03f, -7.97837898e-02f, 6.14151023e-02f, 3.10057402e-02f, 2.16673166e-02f, -3.00195049e-02f, 1.17421538e-01f, -5.38230827e-03f, -4.31838930e-02f,
  -8.16152617e-02f, -8.96212831e-02f, -7.32977763e-02f, -2.80489922e-02f, -9.02643204e-02f, -1.34004280e-02f, 8.88340268e-03f, -4.98307310e-02f, -5.64955026e-02f, -9.24189463e-02f
};

// L0_fan_Wp_bar (Shape: 14 x 120)
const int L0_fan_Wp_bar_rows = 14;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  4.18519497e-01f, 5.27529240e-01f, 4.54669446e-01f, 4.96478796e-01f, -3.81302714e-01f, -4.50993836e-01f, -1.98567197e-01f, 1.76525891e-01f, -1.48267094e-02f, 8.03317949e-02f,
  -1.30809203e-01f, 4.66653079e-01f, -1.39987782e-01f, 2.63389766e-01f, -6.21658266e-02f, -2.33744055e-01f, 8.84412229e-02f, -5.69472946e-02f, -9.93025079e-02f, 2.53742933e-01f,
  1.71033055e-01f, -7.73279518e-02f, 1.67067587e-01f, -1.29108923e-02f, 2.02771440e-01f, 3.19021106e-01f, 2.11583413e-02f, -1.48592696e-01f, 2.57789314e-01f, -2.19615743e-01f,
  -3.56532186e-02f, 1.28646955e-01f, 1.73172504e-01f, 5.98344021e-02f, 1.06579654e-01f, -8.77718106e-02f, 2.03689653e-02f, -4.29874659e-02f, -1.00291982e-01f, 2.23573707e-02f,
  1.52343631e-01f, -3.93289514e-02f, 9.31918025e-02f, -3.00134756e-02f, -1.68534946e-02f, 3.73937599e-02f, 1.03232861e-01f, 2.67474595e-02f, 2.54787728e-02f, 1.28846169e-01f,
  1.11315690e-01f, 1.32881194e-01f, 7.28131011e-02f, -2.80360635e-02f, 1.96791321e-01f, 1.25941848e-02f, 2.65163984e-02f, -3.07728420e-03f, 1.34351151e-02f, 1.55276626e-01f,
  5.74663356e-02f, -3.92175540e-02f, -1.22277983e-01f, -9.94980633e-02f, -8.54420650e-04f, -1.89731084e-02f, -6.87179416e-02f, -1.99669655e-02f, -6.35362864e-02f, -2.87911948e-02f,
  -9.08911675e-02f, 3.56570594e-02f, -1.32132277e-01f, -7.39522055e-02f, 8.56384449e-03f, -8.44759122e-02f, -1.34219916e-03f, -1.42975375e-01f, 2.64380649e-02f, 3.47495973e-02f,
  6.34465041e-03f, -2.23362315e-02f, 7.01211169e-02f, -1.02115378e-01f, -1.21199161e-01f, 3.57292034e-02f, 2.45000292e-02f, 4.59977724e-02f, -3.10312100e-02f, 7.66097531e-02f,
  -5.07717431e-02f, 2.80068666e-01f, 9.78856087e-02f, -6.33821636e-02f, 2.50582695e-02f, 4.34078984e-02f, -7.50471205e-02f, 1.67703182e-01f, 7.43838549e-02f, -5.12672625e-02f,
  8.94994289e-02f, -7.84681514e-02f, -2.82361526e-02f, -1.53947517e-01f, -9.83671322e-02f, 9.65416282e-02f, 1.51302621e-01f, 1.73777826e-02f, 9.49501842e-02f, 8.42785388e-02f,
  1.49899751e-01f, -7.07558617e-02f, 8.07194039e-02f, 1.04926161e-01f, 1.07937500e-01f, 4.21056263e-02f, -1.63504400e-03f, 6.39735535e-02f, 8.96280408e-02f, 7.78683499e-02f,
  -2.47503176e-01f, 5.20612776e-01f, -2.73369253e-01f, 3.18898022e-01f, -2.32875228e-01f, 5.37397921e-01f, 5.27342081e-01f, -2.55314410e-01f, 2.41135702e-01f, 4.32187259e-01f,
  1.41422048e-01f, 1.04728699e-01f, 2.73476511e-01f, 4.97684896e-01f, 4.35591564e-02f, 4.94176120e-01f, 3.55406374e-01f, 2.88387209e-01f, -2.39367466e-02f, 1.90671235e-01f,
  -1.02229707e-01f, 4.33604985e-01f, -8.28788579e-02f, -1.12940349e-01f, -3.06887943e-02f, -3.26685309e-01f, -6.13461733e-02f, -1.70806974e-01f, -7.00200647e-02f, 5.86425997e-02f,
  9.35415477e-02f, 4.13316302e-02f, -1.04598813e-01f, -9.10819992e-02f, 7.90371299e-02f, -6.73058350e-03f, 2.12402474e-02f, -6.19881302e-02f, -1.42393738e-01f, -1.33622577e-02f,
  1.32117942e-01f, -7.64844567e-02f, 3.88932452e-02f, 4.72055301e-02f, -1.19808093e-01f, -1.59816772e-01f, -4.95629758e-02f, -7.26990402e-02f, -8.73363316e-02f, -1.01696728e-02f,
  -1.23550510e-02f, -5.03191948e-02f, 5.24266362e-02f, 4.13410701e-02f, -8.79089460e-02f, 1.42374068e-01f, 2.20567778e-01f, -3.37864384e-02f, 5.68140205e-03f, 1.45187482e-01f,
  2.99423989e-02f, 9.76751372e-02f, -3.95798124e-02f, -1.48358390e-01f, -1.51408138e-02f, -7.41342409e-03f, -2.74949428e-02f, -4.93954234e-02f, -6.86336756e-02f, 3.05503290e-02f,
  -5.23684435e-02f, -3.99432667e-02f, -3.93253891e-03f, 9.29758325e-03f, 8.56296122e-02f, 6.01782799e-02f, -9.88464877e-02f, -4.77998145e-02f, -4.02847752e-02f, -4.45538163e-02f,
  4.22740020e-02f, 1.54907294e-02f, 2.26493198e-02f, 4.74036224e-02f, -1.73445686e-03f, -7.53205791e-02f, 4.14107963e-02f, -7.48084262e-02f, -4.36519133e-03f, 4.44705449e-02f,
  3.12068045e-01f, 3.08237970e-01f, 5.04276389e-03f, -3.29503939e-02f, 3.24655324e-02f, -7.87664503e-02f, 9.34778154e-02f, -3.24514258e-04f, 1.66739076e-01f, 6.18944131e-02f,
  9.24013034e-02f, 5.88115938e-02f, -2.95724738e-02f, -6.30979091e-02f, -1.56058241e-02f, 1.13309219e-01f, 1.57642215e-01f, 5.03434949e-02f, 8.96331817e-02f, -7.45640323e-02f,
  -6.55320892e-03f, 7.79341534e-02f, 5.67704141e-02f, 2.50548515e-02f, 6.40161783e-02f, 8.94523039e-03f, 3.33626270e-02f, -6.60207644e-02f, -5.39351664e-02f, 4.72660325e-02f,
  5.72009206e-01f, -1.95438743e-01f, -1.72780842e-01f, 3.56262416e-01f, 4.50244755e-01f, 5.16513944e-01f, 4.00934815e-01f, 4.00519222e-01f, 4.45625752e-01f, -1.06810682e-01f,
  1.80595174e-01f, -2.35135451e-01f, -3.92291337e-01f, 4.07870531e-01f, 3.81868601e-01f, -1.37178168e-01f, 4.26331073e-01f, 1.83069631e-01f, 1.62350237e-01f, 1.17727250e-01f,
  2.51961380e-01f, 3.12958241e-01f, -2.82567948e-01f, -3.43649201e-02f, 7.88465068e-02f, -1.39914766e-01f, -2.38662586e-01f, -3.01780045e-01f, -3.82948332e-02f, 1.75065652e-04f,
  1.38120139e-02f, 8.61913040e-02f, -7.20625669e-02f, -1.78359903e-03f, 2.57360078e-02f, -4.36236896e-02f, -1.04940370e-01f, -6.54430985e-02f, -6.17268607e-02f, -4.21248041e-02f,
  -8.38965401e-02f, -4.99248356e-02f, 4.36021052e-02f, 1.48664566e-03f, 1.36121333e-01f, -1.96896773e-02f, 2.96966694e-02f, 3.92768830e-02f, -6.52477192e-03f, 6.02049381e-03f,
  -4.52296101e-02f, -5.94947636e-02f, 5.23964800e-02f, 3.08491457e-02f, 3.24614570e-02f, 2.33722962e-02f, -5.36643267e-02f, -1.04591735e-01f, 4.54385281e-02f, 6.96982518e-02f,
  3.90370190e-02f, -7.80559853e-02f, -9.80747044e-02f, -7.44192302e-03f, 8.81398767e-02f, -5.28497901e-03f, 6.16652556e-02f, -1.04889214e-01f, 1.03367992e-01f, -1.95024032e-02f,
  3.04742400e-02f, 7.53040612e-02f, 1.06486537e-01f, -3.84472273e-02f, 3.20032611e-02f, 3.69174965e-02f, -2.14150734e-02f, 7.22210929e-02f, 6.03228025e-02f, 1.23485558e-01f,
  -8.14451352e-02f, 3.30069996e-02f, -1.14800863e-01f, -6.79955855e-02f, 3.45643200e-02f, -2.76286956e-02f, -1.04042865e-01f, 7.92650040e-03f, 2.93163061e-02f, -2.61262581e-02f,
  7.80844986e-02f, -4.13980223e-02f, -4.32974733e-02f, -8.16735998e-02f, -1.98920481e-02f, 1.70484781e-02f, 7.07080662e-02f, 4.87029590e-02f, -3.87726426e-02f, -3.18504125e-02f,
  -4.71484363e-02f, 1.64018292e-02f, 2.72737183e-02f, 8.01086426e-02f, 1.03289885e-02f, -1.71668380e-02f, -1.57530040e-01f, 8.27851519e-02f, 8.14754292e-02f, -6.70479760e-02f,
  -9.17602479e-02f, 2.63018869e-02f, -7.89249898e-04f, 1.86769851e-02f, 4.76052277e-02f, -1.03206597e-01f, 9.07764509e-02f, 1.55462127e-03f, -1.16852731e-01f, 4.16057482e-02f,
  4.47934002e-01f, -6.30854905e-01f, 3.35956395e-01f, 5.35914421e-01f, 7.97023326e-02f, 7.69224241e-02f, 5.07509172e-01f, -3.25323105e-01f, -1.19200461e-01f, -5.30375779e-01f,
  -1.16013950e-02f, 1.66608065e-01f, -3.83033603e-02f, -1.08981477e-02f, 3.78461987e-01f, -8.81092623e-02f, 7.77731463e-02f, 2.46258453e-01f, -6.47659004e-02f, 1.73478976e-01f,
  1.65208057e-01f, -9.82753038e-02f, 2.69844562e-01f, -3.95348251e-01f, 1.30315781e-01f, -1.12728238e-01f, -5.39975129e-02f, 2.19926555e-02f, -7.72463605e-02f, 6.24115579e-02f,
  -1.02068476e-01f, 3.13007943e-02f, -1.36726741e-02f, -1.58837393e-01f, -6.23622313e-02f, 4.97508757e-02f, 4.21576314e-02f, 1.36396363e-01f, 1.62249640e-01f, -6.77401721e-02f,
  8.74269828e-02f, -4.32238057e-02f, 1.90572124e-02f, 9.03090984e-02f, -5.85938990e-02f, -2.87519656e-02f, 5.22488281e-02f, -7.36499950e-03f, -3.40586044e-02f, 8.24081823e-02f,
  6.56853393e-02f, -7.88898095e-02f, 7.41019398e-02f, -6.35372624e-02f, 2.43835170e-02f, 4.12413925e-02f, 1.05451420e-01f, 1.14731207e-01f, -5.43455668e-02f, -1.11174758e-03f,
  -1.60562582e-02f, 1.92809235e-02f, -7.26941004e-02f, -6.15339726e-02f, -2.05784347e-02f, -6.23631477e-02f, -2.12934203e-02f, 1.62100103e-02f, -1.90131441e-02f, -3.80564183e-02f,
  6.77391589e-02f, -2.91113425e-02f, 6.51899651e-02f, 9.71871614e-02f, 5.82353696e-02f, 4.38347384e-02f, 1.24590218e-01f, 1.45896124e-02f, 6.70050383e-02f, -3.15309763e-02f,
  1.18901199e-02f, 4.64855693e-04f, 2.69377772e-02f, 5.82249239e-02f, -2.19857953e-02f, 3.98389809e-03f, -1.12514375e-02f, -1.96600128e-02f, 9.31005031e-02f, 6.26927242e-02f,
  -3.27156425e-01f, -1.91531599e-01f, -8.91012028e-02f, -9.68093276e-02f, -7.70982131e-02f, -6.86479509e-02f, 3.77368592e-02f, -6.97915405e-02f, -6.58309758e-02f, -3.63008422e-03f,
  -1.62070673e-02f, 2.14976240e-02f, -1.20184936e-01f, 4.52029258e-02f, -1.94203341e-03f, 2.80498471e-02f, -4.61496413e-02f, -1.36599898e-01f, -2.20962148e-02f, -2.49543842e-02f,
  -3.61710936e-02f, 5.29314242e-02f, 4.44269553e-02f, -5.79400882e-02f, -8.01885128e-02f, 5.66640720e-02f, 4.63341773e-02f, -7.15205371e-02f, 3.50151770e-02f, -1.19060144e-01f,
  3.52911353e-01f, 1.63588847e-03f, -1.38329372e-01f, 3.75556350e-02f, 2.49002770e-01f, -3.64415497e-01f, 1.87654257e-01f, 1.81974798e-01f, 2.99906075e-01f, 1.04968503e-01f,
  -8.47703367e-02f, -1.98548391e-01f, -7.25342631e-02f, -2.03846246e-01f, -5.92883468e-01f, -3.56378138e-01f, -1.31214157e-01f, -1.69248208e-01f, -2.80213058e-02f, -1.54209062e-02f,
  6.41020015e-03f, 4.80485708e-02f, -1.98524725e-02f, 3.24699163e-01f, 3.70131075e-01f, 2.43246183e-01f, 9.71835554e-02f, 1.25526160e-01f, -9.99940857e-02f, -1.24732420e-01f,
  2.76895575e-02f, -7.70632699e-02f, 6.15638569e-02f, -7.03622550e-02f, 2.35722866e-02f, 1.24903478e-01f, -4.60473932e-02f, -5.92348399e-04f, -4.26755473e-02f, -3.93621661e-02f,
  -9.87891629e-02f, 1.01498224e-01f, -1.13399670e-01f, 2.11880300e-02f, 1.58285886e-01f, 8.84516016e-02f, -1.09792568e-01f, -2.29070783e-02f, 8.21322054e-02f, -1.14887118e-01f,
  -5.91553822e-02f, -2.54939217e-02f, -2.04297937e-02f, -8.55218172e-02f, -4.28224765e-02f, -8.20628181e-02f, -1.38740361e-01f, -3.87649611e-02f, -4.96662743e-02f, 4.86784130e-02f,
  -2.84455325e-02f, 4.86262813e-02f, 6.48672367e-03f, 5.30456342e-02f, -4.25625779e-02f, 1.17122740e-01f, -1.13591656e-01f, -5.78884035e-02f, 5.07618636e-02f, -2.96693761e-02f,
  1.75544973e-02f, -1.43830720e-02f, -6.72777891e-02f, 1.26705155e-01f, 2.80804187e-02f, 1.61237922e-02f, 1.47599103e-02f, -1.46249682e-02f, 5.35398014e-02f, 5.08336648e-02f,
  9.30849537e-02f, -3.97310369e-02f, 2.83853207e-02f, 6.02958165e-02f, -4.95982096e-02f, 6.97682351e-02f, 4.16331552e-02f, 3.87162790e-02f, -2.99576353e-02f, -4.16655540e-02f,
  -1.72607332e-01f, -2.77263463e-01f, 4.04309705e-02f, 1.15294904e-01f, -8.20975229e-02f, -7.54863918e-02f, -1.00898266e-01f, -3.97515856e-02f, -6.16942160e-02f, -4.79236953e-02f,
  1.78366929e-01f, 7.30265230e-02f, -5.52334711e-02f, -7.54543543e-02f, 5.92614375e-02f, -5.00908159e-02f, -1.50213633e-02f, 1.12794943e-01f, 2.14320282e-03f, -6.02148250e-02f,
  3.08240950e-02f, -8.11625943e-02f, 6.11764006e-02f, 1.23499118e-01f, 1.76969752e-01f, -1.11076877e-01f, -5.49698584e-02f, 1.66234076e-02f, -3.79216969e-02f, -2.55636591e-02f,
  3.56204599e-01f, -2.10011482e-01f, -2.18680039e-01f, 1.41822085e-01f, 4.08448795e-05f, 1.67551845e-01f, -4.73870300e-02f, 3.06235421e-02f, -2.06347838e-01f, 6.44608811e-02f,
  1.09022327e-01f, -9.50799957e-02f, -3.44510913e-01f, 3.05718571e-01f, 2.97781199e-01f, -2.09905460e-01f, 1.64244637e-01f, 1.70704871e-02f, -1.01195708e-01f, 1.11196853e-01f,
  1.31943882e-01f, 5.26227951e-01f, 5.88986911e-02f, 2.52683818e-01f, 2.22047150e-01f, -6.60740957e-02f, 9.52570438e-02f, -7.09446222e-02f, 2.23998010e-01f, 1.36485949e-01f,
  1.01004861e-01f, -1.75466901e-03f, -7.70988455e-03f, 1.01816386e-01f, -7.83138648e-02f, -9.53505095e-03f, -3.94042470e-02f, -7.82910455e-03f, 1.95554900e-03f, -6.08383827e-02f,
  -1.83538403e-02f, 7.50010163e-02f, 9.59788114e-02f, -9.21567902e-03f, -2.57803919e-03f, -1.33951306e-01f, -3.56758647e-02f, -8.48179907e-02f, -1.93841770e-01f, 1.11966103e-01f,
  -1.25459269e-01f, -6.28089160e-02f, 2.94088870e-02f, -1.39628306e-01f, -2.28691474e-02f, 2.49626506e-02f, -4.88247275e-02f, -1.35422377e-02f, -5.38221858e-02f, 8.21742862e-02f,
  9.38400030e-02f, -2.58996077e-02f, 9.70262140e-02f, 2.58257519e-02f, -2.76782271e-02f, -5.02193384e-02f, -8.79659951e-02f, -2.29440436e-01f, -1.02759011e-01f, -1.19280122e-01f,
  -2.00993586e-02f, 1.98699180e-02f, -1.67076234e-02f, 6.40069097e-02f, 1.21921629e-01f, 2.12394148e-02f, -5.88345304e-02f, -8.14906433e-02f, -5.27304970e-02f, -5.69163598e-02f,
  2.50325818e-03f, 9.77988634e-03f, 1.21126533e-01f, -1.20585293e-01f, 5.86787984e-02f, -5.54250000e-05f, 1.11899599e-01f, 9.06734392e-02f, -7.58095607e-02f, 3.09710614e-02f,
  -9.66968909e-02f, -6.51776269e-02f, 1.09026609e-02f, 2.16431580e-02f, -1.65589705e-01f, 6.53420016e-02f, 5.26540056e-02f, 6.37648255e-02f, 6.62534162e-02f, 1.57446670e-03f,
  6.74465811e-03f, -3.58216465e-02f, 4.35028151e-02f, 6.46933494e-03f, 1.63981691e-02f, 6.11231998e-02f, 1.80121269e-02f, 3.03627476e-02f, 1.99043495e-03f, 2.73459274e-02f,
  1.13452829e-01f, -6.98782504e-02f, 3.41277905e-02f, -6.17730506e-02f, 5.53236529e-02f, -2.14575715e-02f, -3.60671990e-02f, 8.87340903e-02f, -5.95931187e-02f, -9.05081183e-02f,
  -4.31094080e-01f, 2.38507651e-02f, -2.54783034e-01f, -2.85621256e-01f, 2.04489633e-01f, -1.06889546e-01f, -3.17374170e-02f, -1.64086387e-01f, -6.80110529e-02f, 7.94181377e-02f,
  2.76979923e-01f, -1.02902330e-01f, 2.96533376e-01f, -4.03944641e-01f, -5.70722818e-01f, -2.22314894e-01f, -5.01505196e-01f, -1.13797896e-01f, 7.60671943e-02f, 2.54603270e-02f,
  -2.47708693e-01f, 7.45557249e-03f, -3.28423083e-01f, 1.91513255e-01f, 1.10569103e-02f, 5.36560193e-02f, -5.40172569e-02f, 4.44348156e-01f, -2.30958477e-01f, -4.59724925e-02f,
  4.65004444e-02f, 4.27565351e-02f, 9.95999854e-03f, -5.81123158e-02f, -1.13905370e-01f, -1.29848151e-02f, -1.12498343e-01f, -2.85336506e-02f, -1.67927388e-02f, -1.89658478e-02f,
  4.35350239e-02f, -4.02137265e-02f, -4.53768708e-02f, 1.01546213e-01f, 1.46827698e-02f, -1.34699211e-01f, -9.42060947e-02f, -7.72723779e-02f, -1.37233138e-02f, -8.92540589e-02f,
  -7.72563890e-02f, 3.43055800e-02f, -2.95420010e-02f, -1.83647517e-02f, -1.41407579e-01f, 6.37870282e-02f, 1.47048160e-02f, 7.32463002e-02f, 5.59058646e-03f, 2.56173983e-02f,
  -8.26809555e-03f, -5.70979342e-02f, 7.51827806e-02f, -3.48683745e-02f, 2.36307587e-02f, -3.98208722e-02f, -6.40225559e-02f, -1.44664273e-02f, 5.24318442e-02f, -2.98921019e-02f,
  -3.16808410e-02f, -1.01934811e-02f, 6.31457716e-02f, -1.07642189e-01f, 8.85571539e-02f, -3.25850956e-02f, -5.86280935e-02f, 5.38036004e-02f, -1.14059888e-01f, 2.44340077e-02f,
  -2.15531588e-02f, -7.22099692e-02f, 9.03704539e-02f, -4.54294458e-02f, 8.99133533e-02f, 5.30887097e-02f, -4.13703211e-02f, 1.41905211e-02f, -2.94394442e-03f, 4.14669998e-02f,
  6.41899183e-02f, 1.73697427e-01f, 1.22010402e-01f, 1.56961828e-01f, 2.38527022e-02f, 5.46709336e-02f, -3.62543426e-02f, 1.53277572e-02f, 8.67998321e-03f, -6.78800568e-02f,
  -5.14496714e-02f, -9.89317074e-02f, 8.06850493e-02f, 3.09532452e-02f, 3.39090377e-02f, 1.38168372e-02f, 9.32365842e-03f, 9.80471261e-03f, 9.38240588e-02f, 5.23052849e-02f,
  3.90963592e-02f, 6.04448020e-02f, 1.89988967e-02f, 1.00968584e-01f, 1.46690244e-02f, 1.03074387e-01f, 7.08353221e-02f, 2.39365976e-02f, 3.65467556e-02f, -9.43642259e-02f,
  -5.69488071e-02f, 1.39165476e-01f, -3.52756649e-01f, 2.13814005e-02f, -8.86095017e-02f, 2.57759154e-01f, 1.57264650e-01f, 2.42027976e-02f, -4.51067805e-01f, 2.52040803e-01f,
  1.89111337e-01f, -2.06388701e-02f, 5.29329702e-02f, 4.86672819e-01f, 1.63477167e-01f, 2.71636486e-01f, 1.80727720e-01f, 2.88375448e-02f, 9.99657623e-03f, 1.80030376e-01f,
  1.03980504e-01f, 4.85314965e-01f, 2.53847301e-01f, 2.40591452e-01f, 2.38738701e-01f, 3.35349794e-03f, 3.50819007e-02f, -7.24252388e-02f, 2.30436340e-01f, -6.49580583e-02f,
  1.86411202e-01f, 2.73731221e-02f, 2.70842724e-02f, -9.40144360e-02f, 7.25892885e-03f, -6.10587783e-02f, -2.18746781e-01f, 7.04628006e-02f, -1.38626218e-01f, -4.05294299e-02f,
  4.27835658e-02f, -7.05285743e-02f, -1.53637547e-02f, -8.30735266e-02f, -8.19498077e-02f, -2.33235322e-02f, 1.98862236e-02f, -5.14939846e-03f, 6.69577271e-02f, 9.98580158e-02f,
  -2.17888393e-02f, -3.11609376e-02f, -6.21353276e-03f, 2.60114521e-02f, -9.79404822e-02f, -4.34634686e-02f, -5.91197722e-02f, -1.12702928e-01f, 1.67871900e-02f, -6.17616437e-02f,
  2.11886149e-02f, -9.64549035e-02f, -1.53188407e-02f, 3.86982337e-02f, 1.03461951e-01f, 1.06237158e-01f, 2.73941969e-03f, 1.35662690e-01f, -1.55998021e-01f, 1.23535000e-01f,
  2.43804213e-02f, -6.60999939e-02f, -2.55403351e-02f, -8.01426843e-02f, -5.11711612e-02f, 7.42485151e-02f, 8.37661922e-02f, 9.14418474e-02f, -1.17313102e-01f, 9.58193019e-02f,
  2.13846602e-02f, -6.67124838e-02f, -1.74255576e-02f, 1.07561417e-01f, 4.95471247e-02f, 7.16223419e-02f, -9.41666309e-03f, -6.82134703e-02f, 3.49792168e-02f, -1.00389205e-01f,
  4.86443937e-02f, -5.67052439e-02f, 2.97760554e-02f, -3.14147994e-02f, 6.01878278e-02f, 4.84610908e-02f, 2.90321782e-02f, 5.01966886e-02f, -4.04669605e-02f, 2.34360676e-02f,
  -7.61845857e-02f, -1.58484846e-01f, 7.48263951e-03f, 2.20362786e-02f, -1.25096619e-01f, 4.75067757e-02f, 3.86550725e-02f, -7.82574043e-02f, 1.15586154e-01f, 4.19826545e-02f,
  3.75252292e-02f, 3.08270641e-02f, 1.30452998e-02f, -2.19266154e-02f, -1.27747860e-02f, 1.50925247e-02f, 1.16539756e-02f, -7.30827525e-02f, 2.00428553e-02f, -1.23275034e-01f,
  -6.66402876e-01f, 3.93830806e-01f, -6.46863580e-02f, -4.25630093e-01f, 1.01910755e-01f, 4.32499126e-02f, -5.35498321e-01f, 2.75766730e-01f, -8.39371830e-02f, 1.32679656e-01f,
  -2.18211755e-01f, -1.49789900e-02f, 9.31506325e-03f, -1.29770055e-01f, 5.29631861e-02f, 2.15403914e-01f, -2.39925936e-01f, -1.12210818e-01f, 1.21972516e-01f, -2.42844567e-01f,
  -1.46800261e-02f, -1.39158681e-01f, 9.42628458e-03f, 1.63311660e-01f, -2.30341211e-01f, -9.77708697e-02f, -2.22964391e-01f, -6.02674372e-02f, -1.92588404e-01f, -8.70311819e-03f,
  -3.28442484e-01f, -1.77171692e-01f, -3.24379891e-01f, -6.35098442e-02f, -8.54624957e-02f, -8.96467268e-02f, -1.83437109e-01f, 3.85353789e-02f, -3.63955908e-02f, 2.40855366e-02f,
  4.74360073e-03f, 1.29933715e-01f, 8.62166956e-02f, 1.03267610e-01f, 3.31040062e-02f, -4.52745482e-02f, 8.74127224e-02f, -1.08511068e-01f, 1.58626921e-02f, 2.10097343e-01f,
  9.20241848e-02f, -5.86003549e-02f, -1.44005284e-01f, -5.83177358e-02f, -2.05827896e-02f, -5.54917492e-02f, -3.59195918e-02f, 3.64930853e-02f, -1.66402329e-02f, 5.60066104e-02f,
  1.87446375e-03f, 2.20503267e-02f, -3.21199037e-02f, -1.10474423e-01f, -1.70256402e-02f, 1.64928082e-02f, 2.86403075e-02f, -5.47215454e-02f, -6.63756160e-03f, -5.74032329e-02f,
  4.40010661e-03f, 6.79146545e-03f, -4.65938263e-02f, -2.85040233e-02f, -3.69544104e-02f, -1.16334423e-01f, -1.13485120e-01f, -3.72663364e-02f, -3.59497331e-02f, -1.28058404e-01f,
  8.18183925e-03f, 8.18138942e-02f, 1.42726945e-02f, 3.15332487e-02f, -8.72198772e-03f, 2.84756697e-03f, 6.23431578e-02f, -2.06491575e-02f, -1.63484942e-02f, -1.55229773e-02f,
  -3.88725638e-01f, -3.34051013e-01f, -1.68717548e-01f, -6.26418516e-02f, -3.15288901e-02f, -4.92874570e-02f, -1.65069997e-02f, -1.00265272e-01f, -1.06864914e-01f, -1.88073199e-02f,
  1.89887505e-04f, -5.90128172e-03f, -9.26125199e-02f, -8.49995092e-02f, 1.43692747e-01f, 2.42701340e-02f, -1.06359109e-01f, -5.44000790e-02f, -9.93755311e-02f, -5.86395711e-02f,
  -6.14294820e-02f, 5.26238494e-02f, 7.68154263e-02f, 3.61783206e-02f, 6.05457462e-02f, -2.22132295e-01f, 5.79961874e-02f, -3.98519337e-02f, -6.43982291e-02f, 6.98336288e-02f,
  -9.70076248e-02f, -1.26757577e-01f, -5.04602432e-01f, -3.31679314e-01f, 2.83315390e-01f, 1.61789060e-01f, -3.65763426e-01f, 3.50545757e-02f, -4.37219679e-01f, 1.19586676e-01f,
  3.85400616e-02f, -3.16446900e-01f, -2.40136981e-01f, -1.76109061e-01f, -3.16316821e-02f, -5.06421864e-01f, 1.25806943e-01f, -2.69407071e-02f, -1.50161937e-01f, 2.01344341e-02f,
  -1.14489138e-01f, 3.10186774e-01f, -2.60162205e-01f, 3.39275867e-01f, -7.15304762e-02f, 1.70163810e-02f, 3.91155601e-01f, -2.72845495e-02f, 2.70264715e-01f, 7.84546286e-02f,
  -1.17556885e-01f, -1.43997744e-01f, -1.92570955e-01f, -1.08996421e-01f, 2.58208793e-02f, 1.39208660e-01f, 8.04854035e-02f, -6.79318309e-02f, -4.53446992e-02f, -6.24902733e-02f,
  3.19623128e-02f, -2.42176745e-02f, 1.37431761e-02f, -6.68158457e-02f, 1.37060419e-01f, -2.33687181e-03f, -5.32587096e-02f, -1.04480192e-01f, -9.02874246e-02f, -1.14735484e-01f,
  -1.04895525e-01f, -1.14167761e-02f, 5.54208755e-02f, 1.58738496e-03f, -1.22804858e-01f, 3.00210621e-02f, 1.63874999e-02f, -7.84818381e-02f, 9.94376168e-02f, 4.27428596e-02f,
  4.30276729e-02f, 1.32378072e-01f, -4.01782840e-02f, -1.20059624e-01f, -5.59195061e-04f, -7.24669173e-02f, 2.10245717e-02f, -9.77080708e-05f, -5.14739417e-02f, 1.82518326e-02f,
  5.90687767e-02f, -1.01405099e-01f, -6.65935641e-03f, -5.20471344e-03f, 3.58718932e-02f, -2.99606938e-02f, 2.32936312e-02f, 3.33931879e-03f, -2.08509061e-02f, -3.39945965e-02f,
  -1.01422697e-01f, 7.74365216e-02f, -7.86827803e-02f, 1.19959742e-01f, -1.81376990e-02f, -1.08541533e-01f, 3.95501778e-02f, -6.87114745e-02f, -2.77618691e-02f, 5.98905906e-02f,
  7.68411681e-02f, 1.31376758e-01f, -6.15598783e-02f, 3.82306688e-02f, 2.55549867e-02f, 1.39002636e-01f, -7.46867880e-02f, 2.58956174e-03f, 3.79857682e-02f, 5.77715412e-02f,
  1.95516869e-01f, 4.53418121e-02f, 1.30180925e-01f, 1.41013861e-02f, 2.49933805e-02f, 6.85342178e-02f, 8.78903195e-02f, 1.02271689e-02f, 1.04378402e-01f, 6.86340705e-02f,
  1.51388198e-01f, 9.14723575e-02f, -4.91572507e-02f, 1.09199300e-01f, 1.25427872e-01f, 9.09259990e-02f, 1.74695522e-01f, -6.69024838e-03f, 1.56569257e-01f, -6.45567328e-02f,
  -8.39607477e-01f, -4.90697831e-01f, -2.87189841e-01f, -5.32051362e-02f, 5.53457364e-02f, 1.62381306e-01f, 1.75153613e-01f, -2.13658988e-01f, -1.78348407e-01f, 1.70091122e-01f,
  2.90394753e-01f, -1.52682319e-01f, -8.68080854e-02f, 3.01382303e-01f, -1.11336149e-02f, 5.59785478e-02f, 1.30505413e-01f, -2.95885783e-02f, -2.50168025e-01f, -3.60358059e-01f,
  -1.89561188e-01f, 2.25324720e-01f, 2.71985754e-02f, 8.09147581e-02f, -3.66242342e-02f, -1.21388629e-01f, 2.13315651e-01f, 9.45778266e-02f, 2.17440665e-01f, 2.25536540e-01f,
  -1.63404241e-01f, -3.91619772e-01f, 1.63737088e-02f, -1.11492619e-01f, 3.78598203e-03f, -5.38414232e-02f, 3.00770290e-02f, 4.16201875e-02f, -2.23311745e-02f, -4.68961224e-02f,
  6.52614608e-02f, -8.03169459e-02f, -2.27902457e-02f, 6.04298040e-02f, -1.73441112e-01f, 1.39876707e-02f, 6.17671944e-02f, -4.36313124e-03f, -4.61737104e-02f, -5.99147305e-02f,
  -6.12869672e-02f, -2.84838229e-02f, 3.48216807e-03f, 2.38595605e-02f, 1.50478994e-02f, -8.82421657e-02f, 7.05886558e-02f, 3.81146744e-02f, -1.00551687e-01f, 5.39077632e-02f,
  -6.56391531e-02f, -3.16629596e-02f, -7.15195462e-02f, 8.40790011e-03f, -4.43338230e-02f, 8.49567913e-03f, 6.34557977e-02f, 1.13195367e-02f, 4.32649367e-02f, 4.52374853e-02f,
  -1.44044206e-01f, -1.10645974e-02f, 2.45503429e-02f, -1.90251470e-02f, 8.77095386e-03f, -4.00308371e-02f, 1.14858116e-03f, -1.12037798e-02f, -3.59475762e-02f, 9.64902937e-02f,
  -6.83037043e-02f, -1.62102543e-02f, 6.65009068e-03f, -2.70617455e-02f, -4.19725813e-02f, 2.19680406e-02f, 4.36365269e-02f, -4.65037785e-02f, 6.05870523e-02f, 6.27370924e-02f,
  -3.96476597e-01f, -4.69273925e-01f, 3.74422967e-02f, 4.70593348e-02f, 2.97241453e-02f, 3.82031724e-02f, -1.17041707e-01f, 6.93237176e-03f, -3.22305001e-02f, -7.27348402e-02f,
  1.12279244e-02f, 3.36207747e-02f, -5.34410067e-02f, 2.33590603e-02f, 9.31428596e-02f, -2.18304656e-02f, -7.55999535e-02f, 1.43925309e-01f, 8.84741545e-02f, -6.89477175e-02f,
  -2.98048053e-02f, -1.07931361e-01f, -4.10352694e-03f, 3.09873093e-02f, 1.18686207e-01f, 4.17964570e-02f, -1.87807217e-01f, -4.73771654e-02f, 7.57560357e-02f, 9.83684659e-02f,
  -7.91210890e-01f, 1.30611196e-01f, 3.03198069e-01f, -3.34845185e-01f, -1.91065609e-01f, 5.11803269e-01f, 1.98741332e-01f, 1.35311455e-01f, -2.96914220e-01f, -6.93408493e-03f,
  -1.96790487e-01f, -2.41526410e-01f, 2.07622930e-01f, 9.78800841e-03f, 1.44597948e-01f, 2.49909922e-01f, 1.05086513e-01f, -1.36143133e-01f, 6.65074438e-02f, -9.54630896e-02f,
  1.24297640e-03f, -1.94830507e-01f, 1.05917126e-01f, 6.88158646e-02f, -2.01033220e-01f, -1.95378110e-01f, -1.60703659e-01f, -1.06501281e-01f, -8.06196705e-02f, -2.89772917e-02f,
  -2.74048239e-01f, -1.27132535e-01f, 7.33958110e-02f, 5.36402725e-02f, 2.68444698e-02f, 3.15685533e-02f, 6.07246347e-02f, -2.34819949e-02f, -1.61550984e-01f, 3.06629892e-02f,
  -1.03147604e-01f, -2.30766572e-02f, -1.15021460e-01f, -4.08780538e-02f, -5.28813899e-02f, -4.14278880e-02f, -8.73300806e-02f, 4.12438484e-03f, -4.99316379e-02f, 1.19850211e-01f,
  1.46757022e-01f, 8.24546814e-02f, 9.38143879e-02f, 5.21331318e-02f, 1.30239660e-02f, 6.28471747e-02f, 1.01284310e-01f, 4.90783192e-02f, 1.73667371e-01f, -9.61790532e-02f,
  6.42137304e-02f, 8.97952542e-02f, 7.51429237e-03f, -4.28965688e-02f, 2.74804831e-02f, -1.14833526e-01f, 6.25585467e-02f, -1.65756479e-01f, 6.41771629e-02f, -4.27480787e-02f,
  -1.16153851e-01f, -2.54382938e-02f, -8.95813107e-02f, 1.13497287e-01f, -3.58274877e-02f, 7.17694312e-03f, 2.22846419e-02f, -4.56513166e-02f, 1.13411240e-01f, 9.05331783e-03f,
  -4.30590995e-02f, 4.15946692e-02f, 7.75378272e-02f, 6.69758916e-02f, 1.95363522e-01f, -3.22303176e-02f, -1.07078053e-01f, 1.76419616e-01f, 6.40244707e-02f, 3.78962196e-02f,
  -2.99214095e-01f, -2.52372772e-01f, -1.25332728e-01f, 1.95834250e-03f, -7.89881274e-02f, 6.00911900e-02f, 1.20052006e-02f, 2.99853422e-02f, -6.04694188e-02f, 1.61605924e-02f,
  3.74436937e-02f, 7.51900077e-02f, -4.43672352e-02f, 2.44325716e-02f, 1.49022549e-01f, 4.12456207e-02f, -1.05599254e-01f, -4.05804962e-02f, -2.24774238e-02f, -3.39966118e-02f,
  -9.16373134e-02f, -9.80839431e-02f, -1.51928831e-02f, -7.85965938e-03f, 6.62281662e-02f, -8.46824348e-02f, -1.84157982e-01f, 7.52212256e-02f, -1.04182012e-01f, 5.61152063e-02f,
  2.41620615e-01f, -1.75238878e-01f, -3.91405940e-01f, -2.82063127e-01f, -3.24632257e-01f, -5.22637188e-01f, -4.53408659e-01f, -3.29744697e-01f, 1.48717999e-01f, 9.76588279e-02f,
  -1.07691623e-02f, 1.76999673e-01f, 3.77248049e-01f, -4.52627689e-01f, -8.49536993e-03f, 1.94574907e-01f, -5.15013695e-01f, -2.59849817e-01f, 9.80889276e-02f, -2.87656844e-01f,
  5.29159978e-03f, -2.80171394e-01f, -2.94550598e-01f, 5.25608696e-02f, -5.01399279e-01f, -4.63489704e-02f, 9.79954675e-02f, -1.15633436e-01f, -2.43531659e-01f, -1.26013815e-01f,
  -1.76281199e-01f, 7.24463463e-02f, -1.22454092e-01f, 8.77448618e-02f, -1.81763306e-01f, -1.75871849e-02f, -1.57371193e-01f, -6.27564918e-03f, 1.51012158e-02f, 6.91573247e-02f,
  -2.17765756e-03f, 3.93772349e-02f, 7.18414336e-02f, 1.52682766e-01f, 4.44109086e-03f, -3.52047049e-02f, 2.98591796e-03f, -1.26502231e-01f, -3.56277898e-02f, -1.26983881e-01f,
  -1.19088560e-01f, -3.51643302e-02f, -1.24051429e-01f, -7.29618536e-04f, -2.08040718e-02f, -6.65328056e-02f, -2.23238356e-02f, -6.30821511e-02f, -6.50915876e-02f, 1.60641484e-02f,
  4.71051484e-02f, 7.95234218e-02f, -2.90552620e-02f, -2.18480472e-02f, -1.32458761e-01f, -6.01222217e-02f, 5.68286516e-03f, -2.58875750e-02f, 5.63568957e-02f, -1.16966374e-01f,
  -6.53123334e-02f, -1.40072301e-01f, 1.28192157e-02f, 3.95463407e-03f, -1.36051401e-01f, -8.10439885e-02f, 1.15983570e-02f, 4.31774780e-02f, -4.74215820e-02f, -3.29796709e-02f,
  -2.16112453e-02f, -1.84999686e-02f, 8.11909065e-02f, 1.49239525e-02f, -1.16598636e-01f, 1.69130582e-02f, 7.20696151e-02f, 5.10029420e-02f, -4.87824529e-02f, -2.12326907e-02f,
  -2.18685418e-01f, 1.73145384e-02f, 8.52297843e-02f, 6.61792234e-02f, -1.05542943e-01f, 2.70193014e-02f, -3.87877375e-02f, 4.95137684e-02f, -2.38596313e-02f, 1.58531815e-02f,
  5.31395376e-02f, 2.01839507e-02f, -5.24477754e-03f, 2.43664384e-02f, -2.40178243e-03f, -1.10903397e-01f, -1.55341979e-02f, 3.56457420e-02f, -9.81651619e-02f, -7.23941922e-02f,
  -5.80209587e-03f, 5.31291552e-02f, 8.10047090e-02f, -7.09013268e-02f, 2.50113755e-02f, 3.07902638e-02f, -3.76379974e-02f, 7.70171592e-03f, 5.68933673e-02f, -5.60057051e-02f,
  -1.11174263e-01f, -1.36095315e-01f, 7.24075884e-02f, 1.08061694e-01f, -8.49125385e-02f, -3.77564847e-01f, -2.53971964e-01f, 1.64091453e-01f, -3.56643707e-01f, -5.47937118e-02f,
  1.54077142e-01f, -6.19110204e-02f, -3.69130373e-02f, 4.31711301e-02f, 4.19393271e-01f, -8.01596344e-02f, 2.01137379e-01f, 5.27820475e-02f, 2.01901928e-01f, 2.76474744e-01f,
  4.05663669e-01f, 1.93821192e-01f, 3.79826754e-01f, 2.94214159e-01f, 1.27482399e-01f, 2.88036197e-01f, 4.95575488e-01f, 1.92958131e-01f, 4.25031185e-01f, 1.09802149e-01f,
  -8.73110443e-02f, 2.03697495e-02f, 6.95060343e-02f, -5.44795431e-02f, 2.28640288e-01f, 4.10434082e-02f, 6.81262538e-02f, -4.99719474e-03f, -7.90697262e-02f, 5.87611608e-02f,
  -1.34730726e-01f, 4.95568551e-02f, -1.43858995e-02f, 6.19138703e-02f, -1.25984341e-01f, 5.18940063e-03f, -1.02192322e-02f, -1.76416226e-02f, -1.00945204e-01f, -7.40724131e-02f,
  2.67503150e-02f, -9.58849788e-02f, -1.17955491e-01f, 1.94389187e-02f, -4.52452637e-02f, -1.52851865e-01f, -7.33422562e-02f, -3.56518999e-02f, -1.91803858e-01f, 1.36100337e-01f,
  5.25555089e-02f, -2.33323816e-02f, -1.47879630e-01f, -5.42884991e-02f, -2.58063842e-02f, -2.99635790e-02f, -2.28747167e-02f, -1.40989259e-01f, 8.66953135e-02f, -2.89347563e-02f,
  -7.65694352e-03f, 1.02034554e-01f, -2.14216132e-02f, -3.36516760e-02f, 3.75389233e-02f, -1.02212690e-01f, -1.47999581e-02f, 3.24385650e-02f, -1.17394499e-01f, -3.67213935e-02f,
  4.99453731e-02f, 9.63052548e-03f, -3.24267484e-02f, -3.58742215e-02f, -1.81851059e-01f, 1.16150521e-01f, -5.61796362e-03f, 2.58379383e-03f, -2.22838391e-02f, 3.91245335e-02f,
  1.55761749e-01f, 4.75389808e-01f, -6.73572347e-02f, -1.45066485e-01f, 2.53648683e-02f, -3.91190015e-02f, 6.15061866e-03f, 4.06527929e-02f, 1.24605566e-01f, -3.24949436e-02f,
  8.24629590e-02f, -3.55410837e-02f, 5.35194091e-02f, -4.42582853e-02f, 5.73965609e-02f, 1.21519424e-01f, 6.98243082e-02f, 4.59855050e-02f, 2.94632372e-02f, 2.44495392e-01f,
  -2.33256593e-02f, 5.70706732e-04f, 1.14446497e-02f, -1.23036817e-01f, -9.42062773e-03f, -7.33223036e-02f, -2.32166294e-02f, 4.71906960e-02f, 9.89538953e-02f, -1.17161972e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 14)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 14;
const float L0_fan_Bp_bar_data[] = {
  4.22601908e-01f, 2.30236486e-01f, 3.38370442e-01f, 5.85346818e-01f, 4.27711397e-01f, 6.58373758e-02f, 6.00167096e-01f, 2.62298435e-01f, 3.35194647e-01f, 3.38130146e-01f,
  6.17672384e-01f, 3.26246321e-01f, -6.94181696e-02f, 4.83084619e-01f
};

// L1_fan_Wp (Shape: 1 x 16)
const int L1_fan_Wp_rows = 1;
const int L1_fan_Wp_cols = 16;
const float L1_fan_Wp_data[] = {
  -3.68517458e-01f, 4.22464669e-01f, 3.19822401e-01f, 4.74752545e-01f, -1.40319556e-01f, -4.54270393e-01f, -2.17169002e-01f, -1.89165816e-01f, -3.09455425e-01f, 3.54347885e-01f,
  1.48486227e-01f, -2.06585713e-02f, -6.51024580e-02f, 1.52700365e-01f, -4.09857333e-01f, -1.18116133e-01f
};

// L1_fan_Wp_bar (Shape: 14 x 16)
const int L1_fan_Wp_bar_rows = 14;
const int L1_fan_Wp_bar_cols = 16;
const float L1_fan_Wp_bar_data[] = {
  -2.95369804e-01f, 5.96561193e-01f, -2.76469678e-01f, 8.20354223e-01f, 1.60347790e-01f, 9.49903578e-02f, -1.25511006e-01f, 2.87822217e-01f, -2.02891499e-01f, 5.50245762e-01f,
  2.05694631e-01f, -2.79310010e-02f, 3.71249378e-01f, 3.87501597e-01f, 7.07913861e-02f, 7.65140653e-02f, 1.97777033e-01f, -4.58444744e-01f, 3.40757281e-01f, 1.04829557e-01f,
  1.88629881e-01f, 1.39840379e-01f, 1.32018477e-01f, 5.50259292e-01f, -2.06780627e-01f, 5.40902078e-01f, -2.74257243e-01f, 6.57298803e-01f, 4.12974358e-01f, -1.52336150e-01f,
  -5.72693907e-02f, 5.13246477e-01f, 3.75862062e-01f, 7.06815720e-01f, 5.95282555e-01f, -2.70537168e-01f, 2.34789401e-01f, 6.98747873e-01f, 7.25474536e-01f, -3.22347492e-01f,
  2.29232550e-01f, -1.31151542e-01f, 1.76584661e-01f, -3.50730926e-01f, -2.23044921e-02f, 2.12142304e-01f, -2.20805872e-02f, -6.64893866e-01f, 5.78863204e-01f, -8.06849897e-02f,
  1.73785537e-01f, 1.10317834e-01f, 3.50990534e-01f, 6.56555235e-01f, 4.88531768e-01f, -3.00910920e-01f, 6.53458536e-01f, -4.43352938e-01f, -2.75109876e-02f, 4.62702632e-01f,
  1.33509904e-01f, -1.90133914e-01f, -1.75731689e-01f, 1.70659676e-01f, 3.54355425e-01f, -2.65183598e-01f, -2.05353901e-01f, 3.58368546e-01f, 8.45800757e-01f, 4.64917630e-01f,
  5.06330550e-01f, 6.31130397e-01f, 3.41442078e-02f, 2.28309229e-01f, -1.73752025e-01f, 6.76897705e-01f, 4.10091162e-01f, -2.90345430e-01f, -8.01244378e-02f, -5.68801165e-02f,
  3.59580666e-01f, -5.29744387e-01f, -1.43145382e-01f, 3.02308917e-01f, -4.12262321e-01f, 7.13058293e-01f, -4.61163431e-01f, 6.83714747e-02f, 8.62576589e-02f, 4.26688850e-01f,
  -8.77293497e-02f, 2.16560010e-02f, 5.19601583e-01f, 6.07112110e-01f, -4.91759151e-01f, 6.59454525e-01f, -2.19511986e-01f, 2.51975268e-01f, 1.05893813e-01f, 2.80751079e-01f,
  1.25839591e-01f, -1.92946419e-01f, -1.98372379e-01f, 1.19415022e-01f, 2.63341427e-01f, 4.98366021e-02f, 6.24594510e-01f, 1.96192116e-01f, -5.06261051e-01f, 3.42594206e-01f,
  9.11700547e-01f, 2.84906924e-01f, 5.00659168e-01f, 4.79902923e-01f, 9.62818742e-01f, 4.79994178e-01f, 4.54160839e-01f, 6.59696519e-01f, 3.02253842e-01f, -2.17254445e-01f,
  -9.66019463e-03f, -3.07002753e-01f, -1.90948144e-01f, -4.57530320e-01f, -8.52051437e-01f, 3.41547653e-02f, -1.16855375e-01f, 3.02681059e-01f, 4.60933954e-01f, -5.13152838e-01f,
  9.79884565e-02f, -5.42466223e-01f, -3.28885585e-01f, 2.77663141e-01f, 1.36409709e-02f, -2.29183644e-01f, 1.06411111e+00f, 5.20623587e-02f, 7.75521696e-01f, 4.64632928e-01f,
  3.60064477e-01f, 3.24833155e-01f, 5.53402044e-02f, 6.50808990e-01f, -2.14711696e-01f, 2.96781421e-01f, 5.57724118e-01f, 5.81079245e-01f, 1.52565166e-01f, -2.43470162e-01f,
  -3.89224559e-01f, 2.96257377e-01f, -5.29228635e-02f, 4.48507011e-01f, 4.56664145e-01f, -2.86488216e-02f, -2.33507797e-01f, 4.55534518e-01f, -7.03690425e-02f, 5.49948335e-01f,
  1.42484188e-01f, 3.58104825e-01f, 2.81790227e-01f, 5.73382914e-01f, 1.38791263e-01f, 7.11287618e-01f, -9.88246053e-02f, 2.99195677e-01f, -1.23477513e-02f, 2.97142982e-01f,
  3.22039455e-01f, -4.15930927e-01f, 4.86993909e-01f, 4.46703404e-01f, -4.25553441e-01f, 2.15396695e-02f, 5.58776021e-01f, -2.98643291e-01f, 2.14471504e-01f, 6.07308820e-02f,
  7.05373406e-01f, 2.09232852e-01f, 4.80160296e-01f, 5.32692790e-01f, -4.42473814e-02f, -5.83751649e-02f, -4.88823503e-01f, 5.97239733e-01f, -8.37439895e-02f, -3.15475643e-01f,
  -2.35127553e-01f, 3.70438695e-01f, -8.94235894e-02f, 3.91267955e-01f, -1.75753579e-01f, 8.64490271e-01f, 7.02097297e-01f, -4.97914702e-02f, -9.65363309e-02f, 3.57728481e-01f,
  -3.98382545e-03f, 2.56306350e-01f, 4.94089238e-02f, 3.40643197e-01f, 7.24391118e-02f, -9.86349285e-02f, 7.55468726e-01f, -1.29611373e-01f, -8.41234177e-02f, 1.92555726e-01f,
  3.08619277e-03f, 2.01427013e-01f, -5.23228943e-01f, 2.72652030e-01f, 3.64389527e-03f, -2.13604569e-01f, 3.78919005e-01f, 2.01104537e-01f, 6.00451946e-01f, -4.45017248e-01f,
  5.46124637e-01f, 5.46482742e-01f, 2.12279074e-02f, -9.90670323e-02f
};

// L1_fan_Bp_bar (Shape: 1 x 14)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 14;
const float L1_fan_Bp_bar_data[] = {
  4.09940243e-01f, -7.80867189e-02f, 5.26151001e-01f, 4.15327042e-01f, 3.93364504e-02f, 4.70009804e-01f, 2.64717042e-01f, 5.25817513e-01f, 3.40529531e-01f, 5.18698931e-01f,
  6.74672782e-01f, -3.73872928e-02f, -9.62543488e-02f, 4.40514088e-01f
};

// L2_fan_Wp (Shape: 1 x 16)
const int L2_fan_Wp_rows = 1;
const int L2_fan_Wp_cols = 16;
const float L2_fan_Wp_data[] = {
  1.83417350e-01f, 3.75194401e-01f, 1.11152358e-01f, 1.08458869e-01f, -2.18474776e-01f, -4.04229105e-01f, -1.20244086e-01f, 7.61802047e-02f, 2.54389018e-01f, -3.29259597e-02f,
  -4.37205285e-02f, 1.73743844e-01f, 2.06982091e-01f, -6.05560280e-02f, 5.63012995e-02f, -7.47975856e-02f
};

// L2_fan_Wp_bar (Shape: 14 x 16)
const int L2_fan_Wp_bar_rows = 14;
const int L2_fan_Wp_bar_cols = 16;
const float L2_fan_Wp_bar_data[] = {
  -1.22565567e-01f, -7.23675847e-01f, -4.07294035e-01f, -8.64575803e-02f, 8.54894996e-01f, 7.21740484e-01f, 2.12734446e-01f, 1.54726967e-01f, -2.96472251e-01f, 7.41106272e-01f,
  5.24705887e-01f, -1.42606094e-01f, 2.40064844e-01f, 2.92687386e-01f, -3.68210822e-01f, 8.09869841e-02f, 5.39213538e-01f, 3.72172475e-01f, 5.53394437e-01f, -5.37232220e-01f,
  4.93182272e-01f, 2.82124370e-01f, -2.91129172e-01f, 3.92297536e-01f, -4.85972464e-02f, 8.96841213e-02f, 1.82044759e-01f, 2.77241051e-01f, 5.79812586e-01f, -5.22886038e-01f,
  -1.33068368e-01f, 6.60162926e-01f, -2.07968205e-01f, 1.91126004e-01f, 7.14073241e-01f, 2.63865709e-01f, 4.77381349e-02f, -2.73816526e-01f, 2.90385455e-01f, 5.95852852e-01f,
  9.91880223e-02f, -4.95649546e-01f, -3.46007526e-01f, 1.92231044e-01f, 6.65454626e-01f, 6.07097521e-02f, 3.57109338e-01f, 2.01088622e-01f, -2.26058930e-01f, -2.45020479e-01f,
  3.96663308e-01f, 2.84770364e-03f, -5.58406748e-02f, 6.22586846e-01f, 7.05967784e-01f, -3.07433695e-01f, 4.06914502e-01f, -3.87121409e-01f, 4.24273580e-01f, -1.63096949e-01f,
  -2.79941231e-01f, 3.57056588e-01f, 7.59969234e-01f, 2.26941854e-02f, -3.21719557e-01f, 3.46701503e-01f, 6.30404711e-01f, 1.54993340e-01f, -9.85283777e-02f, -8.24666321e-02f,
  5.47349811e-01f, 1.28043503e-01f, -1.28949821e-01f, 4.85938579e-01f, -7.80506968e-01f, 3.18368435e-01f, 5.46117187e-01f, 3.33145708e-01f, 6.91118717e-01f, -1.52660742e-01f,
  1.77048460e-01f, 2.04954833e-01f, 3.06098431e-01f, 5.65056622e-01f, -3.23543191e-01f, -7.68843964e-02f, -3.62241976e-02f, 8.80721927e-01f, -4.15670455e-01f, 2.64630392e-02f,
  4.69450563e-01f, 4.27690566e-01f, 3.67958426e-01f, 6.78761452e-02f, -4.97493654e-01f, 2.13323291e-02f, 2.50575572e-01f, -2.95603782e-01f, -8.97611976e-02f, 9.48909000e-02f,
  -3.99102956e-01f, 3.10902655e-01f, -3.52982134e-01f, 5.91078222e-01f, 7.41098702e-01f, 1.91583872e-01f, 7.77766228e-01f, 4.23121303e-01f, -6.95972741e-02f, 3.13616768e-02f,
  7.69685581e-02f, 2.30813354e-01f, 7.34087169e-01f, 6.11647367e-01f, -5.20493574e-02f, -3.32582504e-01f, 4.98479426e-01f, 2.86319196e-01f, -2.65976071e-01f, -3.22104007e-01f,
  2.99698025e-01f, 8.57761919e-01f, -1.21509112e-01f, 4.32662964e-01f, 3.48656982e-01f, 3.02713007e-01f, -3.51271152e-01f, -1.52448621e-02f, 5.53358257e-01f, 2.74639636e-01f,
  4.21270728e-01f, -1.46151602e-01f, 6.18097305e-01f, -1.72941118e-01f, -4.50259268e-01f, 2.90527195e-02f, 5.03368616e-01f, 2.56038997e-02f, 4.98924255e-01f, 5.88564098e-01f,
  2.18548343e-01f, -6.52140915e-01f, 5.29467408e-03f, 8.69045675e-01f, -6.33969247e-01f, -4.09531206e-01f, -8.60264152e-02f, 2.34402865e-01f, -1.45505473e-01f, 2.33220264e-01f,
  4.58174109e-01f, 6.44938469e-01f, -5.09237766e-01f, -4.23792124e-01f, 4.89010483e-01f, -1.87473875e-02f, 3.89867008e-01f, 2.11598709e-01f, -1.25538573e-01f, 3.84967506e-01f,
  -8.73230174e-02f, 2.84405917e-01f, 4.94051188e-01f, -3.27727795e-01f, 2.08903819e-01f, 4.56338465e-01f, -2.29671359e-01f, 3.35418433e-01f, -1.46735743e-01f, 6.05059445e-01f,
  -5.97486675e-01f, 2.24431172e-01f, 2.82199830e-01f, -1.56840384e-01f, 2.71214217e-01f, 2.84759670e-01f, -3.73400122e-01f, -5.75468361e-01f, -3.51785332e-01f, -3.11646909e-02f,
  8.84822667e-01f, 5.19620061e-01f, 3.16265404e-01f, 2.60879666e-01f, -1.36956021e-01f, 5.94576061e-01f, 1.21041104e-01f, -4.34428722e-01f, 2.57278323e-01f, 3.86139333e-01f,
  -3.32038462e-01f, -2.88327724e-01f, -1.57575741e-01f, -1.08439781e-01f, -2.98402533e-02f, 6.60795152e-01f, -2.82432467e-01f, 2.79898137e-01f, 6.79500043e-01f, 2.53986031e-01f,
  -2.17028260e-01f, 1.43233627e-01f, 1.28288478e-01f, 2.10975304e-01f, -3.77599627e-01f, 8.04119229e-01f, 1.89037189e-01f, -8.93309772e-01f, 2.28369161e-01f, 7.22389936e-01f,
  9.65965316e-02f, 2.25759059e-01f, 2.79188827e-02f, -2.96271592e-01f, 3.37068826e-01f, -4.11868393e-01f, 7.04240441e-01f, 7.84612119e-01f, -3.19863379e-01f, 5.64559758e-01f,
  1.57583445e-01f, 3.87336582e-01f, 6.31034672e-01f, -3.89074236e-01f
};

// L2_fan_Bp_bar (Shape: 1 x 14)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 14;
const float L2_fan_Bp_bar_data[] = {
  4.07589167e-01f, 4.81628358e-01f, 9.76772532e-02f, 3.30623269e-01f, 5.36760874e-02f, 4.41001281e-02f, 1.31452918e-01f, 2.29653701e-01f, 2.72351295e-01f, -1.18638694e-01f,
  1.33425876e-01f, 5.85770532e-02f, -1.33123100e-01f, 8.07206035e-02f
};

// L3_linear_W (Shape: 12 x 16)
const int L3_linear_W_rows = 12;
const int L3_linear_W_cols = 16;
const float L3_linear_W_data[] = {
  -9.35770273e-02f, -2.31442511e-01f, -9.68990266e-01f, 1.06334321e-01f, 5.62025011e-01f, -2.35158741e-01f, 3.20463270e-01f, 1.43786728e-01f, -3.38409245e-01f, -8.74562502e-01f,
  2.90983051e-01f, 2.48581693e-01f, 4.81700182e-01f, -4.42341655e-01f, -4.54659611e-01f, -3.54666531e-01f, -3.85489821e-01f, 2.33007073e-01f, -9.17148352e-01f, -3.64619166e-01f,
  4.65683132e-01f, 2.57989436e-01f, 4.37826365e-01f, 9.42695513e-02f, -1.76232278e-01f, -3.75589788e-01f, -5.38150370e-01f, -1.70162126e-01f, -2.60662824e-01f, -1.03405523e+00f,
  2.50135392e-01f, 3.54750693e-01f, 5.00049405e-02f, 4.28454652e-02f, -1.99004129e-01f, -8.12162101e-01f, 1.50154084e-01f, 2.80399323e-01f, 2.48032063e-01f, 2.45342523e-01f,
  -4.72023427e-01f, -4.48558897e-01f, -6.62453473e-01f, 4.83806580e-01f, -7.61856973e-01f, 1.13160439e-01f, 2.70649374e-01f, -1.99650526e-01f, -5.73971495e-02f, -5.54482877e-01f,
  4.72506702e-01f, 2.52178639e-01f, -6.21374786e-01f, 4.28005487e-01f, -4.19947684e-01f, -6.48229063e-01f, 1.54645205e-01f, -1.72196105e-01f, 2.10019603e-01f, 1.24569938e-01f,
  -5.71024537e-01f, -7.18403384e-02f, -7.73380578e-01f, -7.50336826e-01f, 3.21448773e-01f, 4.58338350e-01f, -2.97222793e-01f, 5.22569418e-01f, 1.36443689e-01f, -5.15399396e-01f,
  -5.43564558e-01f, 4.76628512e-01f, 2.14788228e-01f, 3.49781871e-01f, 4.23095286e-01f, 3.14567350e-02f, -3.11458349e-01f, -6.09076977e-01f, -1.71223700e-01f, -4.98740643e-01f,
  7.56953135e-02f, 1.60618663e-01f, -4.96859789e-01f, 3.83199245e-01f, -3.88114043e-02f, -2.23404299e-02f, 4.13965970e-01f, -1.92082435e-01f, -2.36240342e-01f, 5.80003738e-01f,
  -1.67599365e-01f, -8.94473791e-01f, 4.74261314e-01f, -3.64029557e-01f, -3.14206183e-01f, 3.34542572e-01f, -2.14596856e-02f, -2.32783020e-01f, 4.44097161e-01f, -4.89191204e-01f,
  -3.81904691e-01f, -3.48351002e-02f, 1.88200608e-01f, -6.79226995e-01f, -5.64217508e-01f, 1.51140019e-01f, -9.21072245e-01f, -1.63949028e-01f, 7.24528357e-02f, 5.34065247e-01f,
  3.02130580e-01f, 3.46377566e-02f, -7.59255439e-02f, 5.44168651e-01f, -6.45322621e-01f, -2.08064973e-01f, -2.60375023e-01f, 4.74690288e-01f, -5.29699147e-01f, -4.85781521e-01f,
  3.92583013e-01f, -1.14487976e-01f, 4.11619544e-01f, -4.54570979e-01f, -2.35260472e-01f, -3.50913614e-01f, -4.11333919e-01f, 3.25598061e-01f, -3.18340927e-01f, 3.40746760e-01f,
  2.75879391e-02f, -4.94520277e-01f, -4.14492190e-01f, -7.81753302e-01f, 4.63449918e-02f, 4.81841266e-01f, 4.91466105e-01f, 4.16253746e-01f, -4.14909959e-01f, 3.83011587e-02f,
  5.96968131e-03f, -2.06227109e-01f, 3.21739852e-01f, 1.00648165e-01f, 6.70405254e-02f, -5.40384233e-01f, 3.35196614e-01f, 2.59134084e-01f, 2.46364415e-01f, -5.10813475e-01f,
  -4.59536351e-02f, 2.38602757e-01f, 1.11991130e-01f, -3.48751247e-01f, -5.56937516e-01f, 3.01000714e-01f, 2.97052413e-01f, 4.60664421e-01f, -4.32874948e-01f, -8.22941720e-01f,
  -1.80066764e-01f, -2.76994079e-01f, 3.46771210e-01f, -6.37765050e-01f, -6.75195336e-01f, 5.98078072e-01f, -8.84269118e-01f, 8.85161906e-02f, 1.38102993e-01f, -2.75895774e-01f,
  -7.95840979e-01f, 3.60408634e-01f, -2.62689829e-01f, 7.04051778e-02f, 4.15073276e-01f, -6.89572752e-01f, 3.86195689e-01f, -3.04737985e-01f, 3.74165624e-01f, 2.12917849e-01f,
  -8.31188619e-01f, -8.94074917e-01f, -2.05027655e-01f, -2.60875106e-01f, -4.99605983e-01f, 7.25426555e-01f, 3.26171577e-01f, -5.93734622e-01f, 2.49103069e-01f, 3.07217479e-01f,
  -6.18834913e-01f, 1.25051960e-01f
};

// L3_linear_B (Shape: 1 x 12)
const int L3_linear_B_rows = 1;
const int L3_linear_B_cols = 12;
const float L3_linear_B_data[] = {
  -2.04632759e-01f, 8.36995896e-03f, -6.49130419e-02f, 2.97088146e-01f, 4.11531292e-02f, 1.17262758e-01f, 5.79035059e-02f, -8.37679952e-02f, -1.66281521e-01f, 1.54896215e-01f,
  -6.09251782e-02f, -3.00481524e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 1, 14
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        16, 1, 14
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        16, 1, 14
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_linear
    linear_forward_pgm(
        buffer1, x_out,
        L3_linear_W_data, L3_linear_B_data,
        16, 12
    );
    }
    