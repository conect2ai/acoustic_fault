/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 64 (x4)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 64;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    float x3 = x * x * x;
    return 0.5f * x * (1.0f + tanhf(0.79788456f * (x + 0.044715f * x3)));
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 6 x 120)
const int L0_fan_Wp_rows = 6;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -8.93592611e-02f, -9.55587178e-02f, 1.50088370e-01f, 6.83510751e-02f, -5.77015504e-02f, -1.19466543e-01f, -5.94433881e-02f, -6.52088448e-02f, -5.93227148e-02f, -1.35580733e-01f,
  -7.39601478e-02f, 1.61293969e-01f, -1.98275503e-02f, -9.20943692e-02f, -7.52359554e-02f, 6.59063905e-02f, -1.20315425e-01f, 1.20167751e-02f, -3.84649611e-03f, -5.71625642e-02f,
  -9.37978923e-03f, -3.82271148e-02f, 1.64166063e-01f, 6.17704391e-02f, -7.57324994e-02f, 1.06257737e-01f, -3.95066477e-02f, 5.06916828e-03f, 8.44758898e-02f, -9.62376036e-03f,
  -9.87480432e-02f, -8.78677592e-02f, 4.92543215e-03f, -3.68021950e-02f, -8.33218358e-03f, -2.78918203e-02f, -2.95972060e-02f, 1.03808433e-01f, -1.69125497e-02f, 4.83382009e-02f,
  -4.20151688e-02f, 2.67052855e-02f, -6.29734322e-02f, -7.27771036e-03f, -1.46112274e-02f, 1.00494437e-01f, 1.85911804e-02f, 1.85528223e-03f, 1.90881006e-02f, 6.66865557e-02f,
  7.90451020e-02f, -1.24445613e-02f, -2.59038433e-02f, 2.15831231e-02f, 1.21632982e-02f, 5.31075038e-02f, 6.93097338e-02f, 2.83954367e-02f, 8.47443640e-02f, 5.79580106e-02f,
  2.43507903e-02f, 3.72609496e-02f, -1.86491404e-02f, -4.13281135e-02f, -7.37053948e-03f, 2.89297011e-02f, -1.72508284e-02f, 4.46530171e-02f, 3.94694805e-02f, -3.80667597e-02f,
  2.61257077e-03f, 9.09963343e-03f, -5.37795573e-02f, 4.60107885e-02f, -3.89617383e-02f, 1.46364011e-02f, 5.04726171e-02f, -4.93834056e-02f, -1.91083718e-02f, 8.34565237e-03f,
  -5.26244305e-02f, -1.37526356e-02f, -2.15478241e-02f, 3.06975339e-02f, 3.43640558e-02f, -2.62768194e-02f, -1.35557242e-02f, 2.14686505e-02f, 2.28802930e-03f, 5.31884283e-02f,
  -1.92522824e-01f, -6.24977835e-02f, -7.16854166e-03f, -3.79711837e-02f, -1.44727230e-02f, -1.38522880e-02f, -8.31109378e-03f, -3.99955437e-02f, -4.24624942e-02f, 6.73541892e-03f,
  4.12710123e-02f, -3.09919603e-02f, 1.70978662e-02f, -8.48932657e-03f, -3.30146328e-02f, -1.77750643e-02f, -4.19320911e-02f, -7.74945021e-02f, -8.71031061e-02f, -2.53155101e-02f,
  4.77535166e-02f, -7.32935667e-02f, 3.70195322e-02f, -5.48131950e-02f, -2.10648682e-02f, -1.34792831e-02f, -4.54617664e-02f, 5.49734980e-02f, -1.84272416e-02f, -1.24435937e-02f,
  -1.77792162e-01f, 1.58385262e-01f, 1.67807668e-01f, -5.23523614e-02f, -7.43781254e-02f, 5.05081862e-02f, -9.13999695e-03f, -1.00476136e-02f, 9.45498496e-02f, 9.37281549e-03f,
  6.51263893e-02f, -6.68168589e-02f, 2.09734240e-03f, 4.68515158e-02f, -3.20751481e-02f, 1.61832079e-01f, 1.61096528e-02f, -1.54884765e-02f, -3.48170064e-02f, -1.43156676e-02f,
  -1.35200219e-02f, -1.79311447e-03f, 7.48452172e-02f, 1.25576943e-01f, -6.03664964e-02f, 1.35386661e-01f, -1.91965267e-01f, 8.55640322e-02f, -1.16497111e-02f, -6.24211766e-02f,
  4.92286347e-02f, -5.38481586e-02f, 5.48137091e-02f, 5.89023829e-02f, 1.44866602e-02f, 4.99750189e-02f, 3.99040617e-02f, 3.19172218e-02f, -3.32155302e-02f, 5.87439314e-02f,
  7.80479088e-02f, 7.31490478e-02f, 5.96709512e-02f, -3.56578780e-03f, -1.25670957e-03f, -5.19992644e-03f, 1.26957567e-02f, 4.96718399e-02f, 5.14571788e-03f, -5.02528623e-03f,
  5.86373731e-02f, 5.15031554e-02f, -1.02064170e-01f, -4.47245799e-02f, -5.26743867e-02f, -5.27815595e-02f, 6.53627366e-02f, 7.92522207e-02f, 1.40341735e-02f, -6.59815827e-03f,
  -2.29163337e-02f, 3.00726909e-02f, -7.43996352e-02f, 2.69569829e-02f, -2.00584140e-02f, 2.21985411e-02f, 7.15160221e-02f, -4.74290811e-02f, -6.02602363e-02f, 2.85156239e-02f,
  -1.82731804e-02f, -6.31036013e-02f, 1.55701609e-02f, -3.66288573e-02f, -7.77714700e-02f, -8.50904062e-02f, -2.98530832e-02f, 2.03007050e-02f, 5.16914669e-03f, 6.13430366e-02f,
  3.54873873e-02f, 1.44952685e-02f, 9.62471068e-02f, -1.78937856e-02f, -3.40761617e-02f, 2.92677572e-03f, -4.52352129e-02f, 5.89869544e-02f, 6.56473413e-02f, -3.67243476e-02f,
  7.36782374e-03f, -1.32350652e-02f, -5.10094687e-02f, -1.80826876e-02f, -4.39996235e-02f, 1.91913303e-02f, -6.17171004e-02f, -2.70213466e-02f, 2.75578387e-02f, -3.67893279e-02f,
  -7.87323937e-02f, -5.34627587e-02f, 4.36257347e-02f, 2.41157450e-02f, 5.80545478e-02f, -2.31741779e-02f, -4.75208238e-02f, -3.78662497e-02f, -5.34654222e-02f, 8.37398507e-03f,
  7.36589357e-03f, -4.98819351e-02f, -2.93876007e-02f, -8.20917860e-02f, 3.19122477e-03f, -8.59632865e-02f, -2.13867594e-02f, 1.98081825e-02f, 4.14426886e-02f, 6.77771820e-03f,
  -2.11998641e-01f, 6.69381171e-02f, -1.82801604e-01f, 1.49586245e-01f, 1.46581426e-01f, 1.20115913e-01f, -8.67806822e-02f, 8.27305391e-02f, -9.17395353e-02f, 1.15162447e-01f,
  1.13303021e-01f, -1.20569564e-01f, -7.01889955e-03f, 2.89707333e-02f, 7.31883869e-02f, -1.27048925e-01f, 6.95311576e-02f, -4.10183966e-02f, -1.31921679e-01f, 1.17623709e-01f,
  1.11447060e-02f, 2.04131752e-01f, 6.76000342e-02f, 2.95192152e-01f, 1.65095869e-02f, -3.00313774e-02f, 3.12963247e-01f, 7.27331564e-02f, 2.13804707e-01f, 1.16569147e-01f,
  -5.89711480e-02f, -3.26181240e-02f, -1.09653929e-02f, -9.02300030e-02f, 7.11459294e-02f, -1.03190105e-04f, -9.02677700e-03f, -2.48419326e-02f, -5.75393252e-02f, -2.75287591e-02f,
  -4.19913940e-02f, -5.77527983e-03f, 3.36631425e-02f, 1.68608669e-02f, -3.02898064e-02f, -6.60697818e-02f, -3.70239727e-02f, 1.23304566e-02f, -1.86970141e-02f, -2.43603606e-02f,
  -4.94684167e-02f, -6.09211326e-02f, 4.40627895e-03f, 6.53327405e-02f, -5.15398309e-02f, 1.08117191e-02f, 3.69084887e-02f, -5.29340915e-02f, 2.38779392e-02f, -1.86112430e-02f,
  -2.85004321e-02f, 6.36536349e-03f, -1.49083994e-02f, -1.49593754e-02f, 9.72481668e-02f, -4.33735363e-02f, 1.34950853e-03f, 3.50613669e-02f, -1.01167984e-01f, 1.28909387e-02f,
  6.01015165e-02f, 3.66415307e-02f, -1.26191480e-02f, 3.51830311e-02f, 1.60837062e-02f, 5.20716608e-03f, 3.55738513e-02f, -9.54547664e-04f, -2.28158832e-02f, -6.32077530e-02f,
  1.05766645e-02f, 2.16618180e-02f, -2.94156242e-02f, -2.01463904e-02f, 2.16896590e-02f, 1.54703129e-02f, 1.43038295e-03f, -1.47668738e-02f, 6.45938423e-03f, 1.54896546e-03f,
  9.33407322e-02f, 8.67793486e-02f, 1.38370600e-03f, 1.72080025e-02f, -8.16085469e-03f, 8.70226175e-02f, -1.46762263e-02f, 2.94802971e-02f, -2.72554532e-02f, 5.28645627e-02f,
  1.12291209e-01f, 1.25935152e-02f, -6.41057342e-02f, 1.21002384e-02f, 2.11810395e-02f, 6.36054426e-02f, 3.08737555e-03f, 5.44117391e-03f, 7.54494816e-02f, 3.19358110e-02f,
  8.11118707e-02f, 2.87691727e-02f, 6.16785623e-02f, -1.54664265e-02f, -2.63559486e-04f, -4.00008745e-02f, 3.84892374e-02f, 2.08497588e-02f, -3.41651402e-02f, -2.26034895e-02f,
  2.19387367e-01f, -1.97164282e-01f, -8.72181430e-02f, -7.71180540e-02f, -5.59409000e-02f, 2.30360940e-01f, 1.46119937e-01f, -6.21618740e-02f, 6.76597059e-02f, -4.07280922e-02f,
  1.25433141e-02f, -7.44305179e-02f, -6.67763576e-02f, 9.95403249e-03f, 1.83661088e-01f, 5.50701544e-02f, 1.96047455e-01f, -6.77230880e-02f, 5.88594191e-03f, -7.13215247e-02f,
  3.26760523e-02f, -5.46506047e-02f, -8.91325548e-02f, -8.30343142e-02f, -5.55771105e-02f, -3.24632525e-02f, -1.45941023e-02f, -4.98070307e-02f, -8.15851688e-02f, 6.77356645e-02f,
  3.43615003e-02f, 1.61505472e-02f, -7.05390200e-02f, 1.31908571e-02f, 2.01777685e-02f, 4.61648926e-02f, -1.29548348e-02f, 1.15690470e-01f, -6.08193651e-02f, 8.44589842e-04f,
  3.32709365e-02f, 3.51394154e-03f, -3.55854048e-03f, 1.61738507e-02f, -8.41150340e-03f, -2.97450200e-02f, -4.28933837e-02f, -8.63413385e-04f, -7.44542927e-02f, 4.64003673e-03f,
  -4.69967425e-02f, -3.01797334e-02f, -1.69076219e-01f, -2.91106217e-02f, -4.07475159e-02f, -7.62797333e-03f, -4.61238669e-03f, -2.02409308e-02f, -3.56498994e-02f, -5.45661990e-03f,
  8.75471812e-03f, 4.67629880e-02f, -6.67621344e-02f, 2.06951667e-02f, -2.88598966e-02f, 4.59073633e-02f, -8.82932693e-02f, 2.19741836e-02f, -2.60498747e-02f, 1.04726050e-02f,
  1.59694087e-02f, 1.24710547e-02f, -5.54011427e-02f, 4.23420779e-02f, -3.05377580e-02f, -4.02691737e-02f, -4.52772900e-02f, -7.04082623e-02f, 7.43571436e-03f, 3.23536247e-02f,
  -1.73469726e-02f, -6.11205436e-02f, -2.41062604e-03f, 3.33209103e-03f, -1.69138163e-02f, -4.18399274e-02f, 7.70372245e-03f, -7.91737214e-02f, -4.24818248e-02f, 2.08725538e-02f,
  -5.17096855e-02f, -1.11984238e-01f, 1.49067044e-02f, 2.99235377e-02f, 3.18211988e-02f, -8.74276385e-02f, -1.72336567e-02f, -4.70977789e-03f, -5.80007322e-02f, 2.86985151e-02f,
  -7.52644092e-02f, -1.39832357e-02f, -4.07669693e-03f, -2.95043178e-02f, 6.50922302e-03f, 8.15115497e-02f, -1.20741893e-02f, 2.22754525e-03f, 1.00688748e-02f, -4.11438271e-02f,
  -9.53320041e-02f, -5.09962402e-02f, 1.37904687e-02f, 1.25775002e-02f, -1.19549828e-02f, -5.43273278e-02f, 3.36499363e-02f, -5.02389893e-02f, 9.40675661e-03f, 4.51491959e-02f,
  9.47712585e-02f, -1.44053856e-02f, 1.13097981e-01f, -3.21496185e-03f, 5.42777069e-02f, 3.01673752e-03f, -9.57764536e-02f, 1.22985095e-02f, -1.55198693e-01f, 2.95233373e-02f,
  1.07701451e-01f, -6.26715571e-02f, 2.49465853e-02f, 1.47200581e-02f, -6.64222911e-02f, -3.11510712e-02f, -8.58728141e-02f, -2.19557174e-02f, -1.98278185e-02f, -2.22028866e-02f,
  3.35722677e-02f, -2.93740965e-02f, 7.74359554e-02f, 1.20756477e-01f, 7.03925192e-02f, 5.99045046e-02f, 6.32960275e-02f, 4.51125428e-02f, 8.28789771e-02f, -4.87902015e-02f,
  2.75648572e-03f, -1.31357647e-02f, 6.82927296e-02f, 4.15405519e-02f, 5.29618263e-02f, 4.84344587e-02f, 6.73164055e-02f, 4.32149731e-02f, -1.16142305e-02f, 1.42730922e-02f,
  4.53776047e-02f, 4.28567939e-02f, 7.80240120e-03f, -1.44587485e-02f, -9.49262306e-02f, -6.65900186e-02f, 7.24430457e-02f, 1.59900840e-02f, 3.10276393e-02f, 4.15594317e-02f,
  -2.24873442e-02f, 4.94450368e-02f, 8.64706263e-02f, 1.06357448e-02f, -7.67717957e-02f, -5.65576507e-03f, 4.10307059e-03f, 4.86067049e-02f, 2.56723072e-02f, -1.00107200e-01f,
  1.53036024e-02f, 3.05636674e-02f, -2.87485756e-02f, 8.31041932e-02f, -2.04346515e-02f, 4.42299992e-02f, 3.48178409e-02f, 5.37424535e-02f, 4.04738002e-02f, -2.06647310e-02f,
  3.41957621e-02f, -1.45228887e-02f, -5.81878349e-02f, -6.38781637e-02f, -1.70311779e-02f, -4.09384556e-02f, -4.11062911e-02f, 6.31076172e-02f, -1.36250686e-02f, 4.57959920e-02f,
  1.06147220e-02f, -1.27918217e-02f, 2.62376685e-02f, 5.73053956e-02f, -2.77593685e-03f, 8.17579741e-04f, -4.59455512e-02f, 2.27477634e-03f, -6.86756596e-02f, 4.17958684e-02f,
  -2.85478793e-02f, 7.37104118e-02f, 6.97251260e-02f, 2.90944874e-02f, -4.78817746e-02f, 1.12971757e-02f, -4.17095944e-02f, -9.55371708e-02f, -7.27866497e-03f, -4.85980548e-02f,
  4.92525920e-02f, 4.16338816e-02f, -7.36529604e-02f, 2.73740366e-02f, 5.07020112e-03f, 5.03768809e-02f, 3.41809765e-02f, -4.29747216e-02f, 7.03622624e-02f, 3.98307741e-02f,
  2.05065552e-02f, 9.84845590e-03f, -1.48488758e-02f, -2.69511119e-02f, 4.02799211e-02f, 7.52610853e-03f, 5.65466434e-02f, 4.29180712e-02f, 3.62465493e-02f, 4.22256403e-02f,
  2.59151578e-01f, -1.76426563e-02f, -7.33949840e-02f, -6.40814658e-03f, -4.72996458e-02f, -1.83226213e-01f, -8.78680274e-02f, -5.82177378e-02f, -1.21757001e-01f, -1.07765011e-01f,
  5.31963259e-02f, -4.62760106e-02f, -6.82635605e-02f, -4.06307094e-02f, -2.28724163e-03f, -8.97211358e-02f, -6.73905201e-03f, -2.38775043e-03f, -1.14952028e-01f, 7.90951401e-02f,
  9.69500933e-03f, -8.26625302e-02f, 2.47035436e-02f, -3.86190601e-02f, 6.08379059e-02f, 1.17521197e-01f, -2.24349182e-02f, 7.25595802e-02f, 1.03801861e-01f, -7.04810172e-02f,
  7.57586434e-02f, 9.68189612e-02f, -1.52918426e-02f, 5.92581332e-02f, 9.88396583e-04f, -6.29031239e-03f, 2.17791293e-02f, 2.60217860e-02f, -2.58116070e-02f, 3.65887508e-02f,
  -1.41104246e-02f, -1.22760376e-02f, 4.68715057e-02f, -3.39577310e-02f, -9.93148759e-02f, -6.47566095e-02f, -4.15023714e-02f, -4.49359836e-03f, 5.23822987e-03f, 4.10587899e-02f,
  -3.41953561e-02f, 9.15240124e-03f, -4.03902158e-02f, -5.33131957e-02f, -5.21573424e-02f, 2.14531142e-02f, -9.26099047e-02f, -3.73352244e-02f, 5.53417169e-02f, -4.11738046e-02f,
  -8.26815423e-03f, -1.67075805e-02f, 4.65763919e-02f, -2.43035182e-02f, 3.26968282e-02f, -4.42049233e-03f, -9.01530311e-02f, -6.13039397e-02f, -3.54571044e-02f, 3.36531512e-02f,
  1.62501149e-02f, -5.83426394e-02f, -2.00284123e-02f, -1.31014641e-02f, -4.87724356e-02f, -5.11385770e-05f, -5.61675662e-03f, -3.61805074e-02f, -4.90100868e-02f, -6.84423298e-02f,
  -5.21740429e-02f, -5.36256563e-03f, 1.24005424e-02f, 9.21230912e-02f, -1.54892169e-02f, 2.02124398e-02f, -4.09802496e-02f, 3.58083807e-02f, -5.37382662e-02f, -3.34538296e-02f,
  3.71261649e-02f, 9.14588124e-02f, -2.70554405e-02f, -4.46225842e-03f, -7.21867681e-02f, 5.46061285e-02f, -3.45708430e-02f, 5.69196418e-02f, -7.40419887e-03f, -3.72967049e-02f,
  -4.32284735e-02f, 3.70295183e-03f, -5.22036143e-02f, 4.52823751e-02f, 2.62122508e-02f, 5.59533872e-02f, 2.70035565e-02f, -1.76212583e-02f, 6.05361594e-04f, 3.32197659e-02f,
  4.99512888e-02f, 2.74544731e-02f, 2.55475491e-02f, 5.83103709e-02f, 6.32288605e-02f, 1.18766958e-02f, 7.84161687e-02f, -3.26954201e-02f, 9.52539779e-03f, -4.26488295e-02f
};

// L0_fan_Wp_bar (Shape: 52 x 120)
const int L0_fan_Wp_bar_rows = 52;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -7.02115055e-03f, -1.15374461e-01f, -4.30071587e-03f, -9.78246853e-02f, 2.31043957e-02f, -1.33316711e-01f, -1.41714916e-01f, -1.87332466e-01f, -8.02089199e-02f, -1.23723321e-01f,
  -1.05541989e-01f, 1.03265598e-01f, 1.06921658e-01f, -1.15350597e-01f, 2.49676704e-01f, 9.57145691e-02f, -9.31691080e-02f, -4.75152917e-02f, -7.69233285e-03f, -1.20569728e-01f,
  3.94214466e-02f, -7.47715756e-02f, -3.68871093e-02f, -1.33657381e-01f, -8.54131207e-02f, -1.28329366e-01f, -9.52959899e-03f, 6.91727269e-03f, -1.52362779e-01f, 7.32946098e-02f,
  -3.60547565e-02f, -1.20860755e-01f, 8.08822829e-03f, -1.65427420e-02f, -4.74925749e-02f, -5.25551140e-02f, 6.38820902e-02f, 2.17203051e-02f, -2.34868173e-02f, 6.84124231e-02f,
  4.37787436e-02f, 5.89399226e-02f, -8.22750703e-02f, 5.74463643e-02f, -4.18796428e-02f, -4.33600023e-02f, -9.13039315e-03f, 7.27371946e-02f, 5.26110083e-03f, -6.47856817e-02f,
  -8.69365931e-02f, 2.35408489e-02f, 2.06419230e-02f, 1.04675628e-03f, -2.37035006e-02f, -5.95551021e-02f, 6.64932951e-02f, 1.03659600e-01f, -6.27943650e-02f, 4.41866219e-02f,
  3.36057022e-02f, -3.78011130e-02f, 2.97804270e-02f, -3.69527563e-02f, 4.98452112e-02f, -7.90398717e-02f, 2.17410885e-02f, 7.21611232e-02f, 6.01413194e-04f, -1.21273203e-02f,
  2.99651772e-02f, 3.15359258e-03f, 5.09903766e-02f, -6.81867599e-02f, -1.78302843e-02f, -8.14660266e-02f, 7.37442672e-02f, 5.22583835e-02f, -1.98016386e-03f, 3.40386741e-02f,
  8.29418004e-02f, -4.47830744e-02f, 6.45171180e-02f, 5.96725456e-02f, -7.50889182e-02f, 1.87025722e-02f, -4.36064824e-02f, -4.74615097e-02f, 7.44637698e-02f, -2.06372105e-02f,
  -1.41740143e-01f, -1.63672775e-01f, -8.94329995e-02f, 1.59779601e-02f, -4.23749164e-02f, -3.90078276e-02f, 2.84550078e-02f, 1.21541945e-02f, -9.93780792e-02f, -6.78482577e-02f,
  -3.52761373e-02f, -7.52891763e-04f, 4.61584851e-02f, 3.61690521e-02f, 5.84283052e-03f, -5.56979477e-02f, -4.22146730e-02f, -1.20990807e-02f, 6.73583429e-03f, 4.10977267e-02f,
  7.77260354e-03f, -3.76446284e-02f, -3.22293229e-02f, -6.86913356e-02f, 4.10038903e-02f, 5.04847430e-02f, 1.08857751e-02f, 4.31963466e-02f, 3.21092457e-02f, -7.06538558e-02f,
  -2.14934811e-01f, 7.49117211e-02f, 7.03170300e-02f, -1.35571092e-01f, 2.41331719e-02f, 7.60200694e-02f, -1.77849960e-02f, 6.17950410e-02f, 9.04225707e-02f, 1.78414926e-01f,
  7.15016127e-02f, 2.90058702e-02f, 8.33275095e-02f, 2.36796513e-02f, -5.46687096e-02f, 3.36146094e-02f, 6.19001240e-02f, -3.07145156e-02f, 5.60530908e-02f, -1.15030631e-01f,
  -4.37144935e-02f, 4.14514840e-02f, -1.86866075e-02f, 5.82377287e-03f, -7.61031732e-02f, 2.80937981e-02f, -3.20203081e-02f, -1.68155953e-02f, 3.96112949e-02f, 5.62623329e-02f,
  -1.03252769e-01f, -1.40661076e-02f, -1.54503696e-02f, 6.50969241e-03f, -7.06052706e-02f, -5.39187193e-02f, 2.26423517e-02f, -5.42750806e-02f, 5.50049134e-02f, -3.13205905e-02f,
  -2.21569445e-02f, -7.81338587e-02f, 7.56235123e-02f, -8.18561241e-02f, 8.53050798e-02f, 7.91472122e-02f, 5.21503091e-02f, 8.32167938e-02f, 4.44777384e-02f, 6.42576590e-02f,
  5.10545932e-02f, 6.98678717e-02f, -7.99741521e-02f, 6.16309941e-02f, 8.17557722e-02f, 6.32053316e-02f, 1.68204289e-02f, -5.41492812e-02f, 4.33181562e-02f, -2.88356375e-02f,
  3.10459249e-02f, -7.12714717e-02f, 7.98683837e-02f, -8.75322744e-02f, -2.84201205e-02f, -7.84125775e-02f, 4.49585058e-02f, -2.54967529e-02f, -4.80882265e-02f, 2.39671264e-02f,
  -1.43118855e-02f, -3.93067561e-02f, -5.28689250e-02f, -4.77178283e-02f, 5.51173910e-02f, -2.07488388e-02f, 7.18582422e-02f, -9.00319740e-02f, -8.25167075e-03f, -5.82322031e-02f,
  6.57779276e-02f, -5.35924099e-02f, -5.82229607e-02f, -2.76758000e-02f, 1.69802662e-02f, 8.96640792e-02f, -4.85242624e-03f, -1.96047220e-02f, 7.73637816e-02f, 3.72395404e-02f,
  -1.50955185e-01f, -8.49142820e-02f, -1.88098650e-03f, 6.88290410e-03f, -6.86712638e-02f, 2.81494074e-02f, -3.02776340e-02f, 5.23087233e-02f, -4.20173183e-02f, 6.62515983e-02f,
  5.12370206e-02f, 1.64706483e-02f, -7.75644779e-02f, -5.07811941e-02f, -2.11110134e-02f, -5.74991340e-03f, -6.58079162e-02f, 9.07888487e-02f, -7.12706596e-02f, 3.99898961e-02f,
  -9.67228599e-03f, -6.31116703e-02f, -3.06061506e-02f, 4.52266335e-02f, -2.64618117e-02f, -8.10599923e-02f, -1.03812590e-02f, -1.46997264e-02f, 8.57880991e-03f, 6.92412630e-02f,
  -2.87648857e-01f, 1.45677730e-01f, -5.32810986e-02f, -1.23634771e-01f, -2.29558796e-02f, 7.93159381e-03f, -9.40422863e-02f, 1.68640316e-02f, -1.14985183e-01f, 1.18234962e-01f,
  1.47835712e-03f, -1.03131257e-01f, 1.22542188e-01f, 2.91269971e-03f, -1.49363607e-01f, 9.02381688e-02f, -1.14143454e-01f, -9.72114131e-02f, 2.22149622e-02f, -3.42643745e-02f,
  -3.94124463e-02f, 1.78714380e-01f, 2.84688435e-02f, 1.46476656e-01f, -5.77300824e-02f, -7.96986148e-02f, 1.01650923e-01f, 1.54797077e-01f, -1.39307017e-02f, -3.26158851e-02f,
  -7.82271847e-02f, -2.39645336e-02f, -1.29570410e-01f, -7.93616846e-02f, -9.44449753e-02f, -9.71291661e-02f, 6.45945892e-02f, 1.95610411e-02f, 1.79544967e-02f, -2.21420843e-02f,
  3.29137780e-02f, 1.35995047e-02f, -5.42176068e-02f, 1.12958988e-02f, 6.16651587e-02f, -5.06062172e-02f, -1.80834774e-02f, 2.29637548e-02f, 4.44077253e-02f, -6.24372885e-02f,
  2.45390292e-02f, -1.14234639e-02f, -5.60269430e-02f, -1.05451746e-02f, 1.81973465e-02f, 1.61657352e-02f, -7.48400465e-02f, -4.85622473e-02f, 3.38255949e-02f, -3.70416157e-02f,
  4.78910580e-02f, -7.01540038e-02f, -1.03573443e-03f, -3.47542912e-02f, 4.81567867e-02f, 1.89646129e-02f, 6.00764574e-03f, -6.66748732e-02f, 6.17138222e-02f, -8.51654187e-02f,
  -9.82005522e-02f, 5.69610484e-02f, 8.88642222e-02f, 2.36407667e-03f, 5.36978319e-02f, -5.21115400e-02f, -6.22414984e-02f, 4.27262075e-02f, -7.79116303e-02f, -8.31453204e-02f,
  2.68103387e-02f, -8.68927389e-02f, -3.30458991e-02f, -7.41533861e-02f, 8.65458176e-02f, -5.77778444e-02f, -3.84110399e-02f, -1.33688441e-02f, -4.66520377e-02f, 4.42508049e-02f,
  -5.51748201e-02f, 3.41091044e-02f, -1.02011289e-03f, 1.14751250e-01f, -8.10559690e-02f, 6.71388507e-02f, -7.85039440e-02f, -1.18547320e-01f, -3.94063070e-02f, 2.37189755e-02f,
  -5.30728213e-02f, 8.06187093e-02f, -1.57182000e-03f, -6.00238480e-02f, 4.06358764e-02f, 2.47316658e-02f, -3.71042895e-03f, -4.98578437e-02f, 3.47900204e-03f, 6.55816048e-02f,
  -4.83619608e-02f, 8.44969973e-02f, -2.45684218e-02f, 8.52110144e-03f, -5.35366461e-02f, -3.97629514e-02f, -8.17133188e-02f, -4.24970388e-02f, 1.70085521e-03f, 1.74152385e-02f,
  2.33972277e-02f, 1.12304483e-02f, 6.29707873e-02f, 2.09358796e-01f, -5.76926731e-02f, -1.62965655e-01f, -1.06065646e-01f, 2.07575839e-02f, -1.01578057e-01f, -3.64043489e-02f,
  2.94107124e-02f, -9.19388235e-02f, -5.37001267e-02f, 3.21300104e-02f, 7.92587027e-02f, -2.03126937e-01f, -2.06569005e-02f, -2.94091813e-02f, -4.37207967e-02f, 8.25984851e-02f,
  4.66983132e-02f, 1.40136167e-01f, 2.41311461e-01f, 9.03671533e-02f, 1.72406301e-01f, 2.90842414e-01f, 1.72674730e-01f, 1.12116322e-01f, 1.97300479e-01f, -6.07949980e-02f,
  -1.31155372e-01f, -4.83926386e-02f, 7.69422157e-03f, -9.16189700e-02f, 1.75284240e-02f, 4.80449311e-02f, 2.20437068e-02f, 4.72948439e-02f, -3.48514356e-02f, -5.21229729e-02f,
  -1.16899852e-02f, -3.54219638e-02f, -1.44081321e-02f, -6.93097338e-02f, -3.12070046e-02f, 4.97696884e-02f, -9.76289902e-03f, 2.66219284e-02f, -3.94592248e-02f, 7.32313991e-02f,
  8.75612199e-02f, 2.06485204e-02f, -6.22700714e-02f, 3.46536525e-02f, 3.61897461e-02f, 1.83085003e-03f, 2.33779419e-02f, 3.50888111e-02f, -3.34200053e-03f, -4.89376951e-03f,
  -8.62312689e-02f, 6.15069047e-02f, -2.09866427e-02f, -1.96163543e-02f, -1.09293573e-02f, -4.85171564e-02f, 1.56518891e-02f, 1.61624458e-02f, -4.39687120e-03f, 8.70877935e-04f,
  9.86676663e-02f, -1.74235553e-02f, -1.70067400e-02f, -7.44151101e-02f, 5.88909686e-02f, -1.15153398e-02f, 7.33944252e-02f, -8.61869752e-02f, 8.32550004e-02f, -2.40650568e-02f,
  1.58595329e-03f, 8.08228403e-02f, 4.08705585e-02f, -7.31490850e-02f, 3.85657996e-02f, 2.68254448e-02f, -3.42013151e-03f, 4.41744328e-02f, 4.76424210e-02f, 4.19216929e-03f,
  -5.29491492e-02f, 1.15333095e-01f, -4.90838811e-02f, -7.20231619e-04f, 4.78158072e-02f, -6.76605059e-03f, -1.84087865e-02f, -6.69620484e-02f, 5.28773330e-02f, 2.31827796e-02f,
  7.22288340e-02f, -3.04146111e-02f, 3.04262508e-02f, 4.19039056e-02f, -6.94013536e-02f, -2.71031056e-02f, 3.00080664e-02f, -4.40695621e-02f, -3.51280044e-03f, -1.42466687e-02f,
  9.51793864e-02f, -2.81487163e-02f, -1.24168291e-04f, -6.99312761e-02f, 1.16960578e-01f, -6.51070615e-03f, -3.10739651e-02f, 4.42064553e-03f, -1.39778024e-02f, -7.12537915e-02f,
  -1.90585464e-01f, 9.22866687e-02f, 5.87202003e-03f, -2.02411965e-01f, 2.60115284e-02f, -1.13637157e-01f, -1.04607157e-01f, 4.00943719e-02f, 4.10683081e-02f, 1.85930170e-02f,
  -2.01763008e-02f, -7.95635134e-02f, 8.70016068e-02f, 8.61586854e-02f, -1.10217586e-01f, 6.85670227e-02f, -4.76382412e-02f, -2.20613834e-02f, 4.59949262e-02f, 4.69076075e-02f,
  -7.27308095e-02f, -2.88647283e-02f, -4.23744321e-03f, 6.63877353e-02f, -3.30228321e-02f, -2.14242795e-03f, -6.75628940e-03f, -3.16486806e-02f, -5.79159744e-02f, -1.94386560e-02f,
  -1.38058439e-01f, -1.52017295e-01f, -7.50517771e-02f, 2.41155550e-02f, -9.69146192e-02f, 3.75555716e-02f, -5.28046973e-02f, -3.31448130e-02f, -1.18662946e-01f, 7.69234225e-02f,
  -8.00285190e-02f, -1.17355632e-03f, 5.31280600e-02f, 1.03374340e-01f, -8.50479752e-02f, -1.27171902e-02f, -5.42127586e-04f, -8.04178268e-02f, -6.95842803e-02f, -3.90696116e-02f,
  -1.39395641e-02f, 3.40042599e-02f, -8.72589573e-02f, -3.10583841e-02f, 1.84076894e-02f, -6.82758912e-02f, -9.23588574e-02f, -5.51211983e-02f, 2.33329404e-02f, 2.14587357e-02f,
  6.67757988e-02f, -3.12235635e-02f, 5.29500190e-03f, -3.29685137e-02f, -5.37380017e-03f, 3.81203964e-02f, 2.31976267e-02f, -2.02554557e-03f, -1.66854542e-02f, -4.32276092e-02f,
  1.79208610e-02f, -4.57870439e-02f, -2.70491987e-02f, -8.23942870e-02f, 9.26850066e-02f, -7.66293658e-03f, -2.52929367e-02f, -1.08031761e-02f, 7.73224086e-02f, -5.70263974e-02f,
  -5.81923649e-02f, 6.36606067e-02f, 7.58465007e-02f, -4.29997500e-03f, 8.14948380e-02f, 4.15694155e-02f, 7.76952133e-02f, -3.12426384e-03f, 3.98664996e-02f, 2.98043564e-02f,
  -1.32510781e-01f, -8.82873908e-02f, -1.27726361e-01f, 7.76105968e-04f, -7.82828256e-02f, 1.98307983e-03f, -6.50537834e-02f, 4.15380448e-02f, 1.05454298e-02f, -1.22857131e-02f,
  -2.94966213e-02f, -6.63397135e-03f, -7.05395192e-02f, -5.17052598e-02f, -1.42273037e-02f, -7.39873648e-02f, -5.56592159e-02f, 6.14275299e-02f, -2.21327040e-02f, -3.41317616e-02f,
  4.80647162e-02f, -3.57185937e-02f, 9.47937965e-02f, -3.84332426e-02f, -1.04938090e-01f, -2.28922293e-02f, -5.98603375e-02f, -5.01280986e-02f, -8.11982378e-02f, -7.46499598e-02f,
  -7.00708805e-03f, -8.13619196e-02f, -4.58778888e-02f, 7.79059753e-02f, 9.41782817e-02f, 5.77460006e-02f, -7.40000159e-02f, -5.67213632e-02f, 5.66228703e-02f, -6.92048017e-03f,
  -3.41824330e-02f, 6.92671165e-02f, -6.89521506e-02f, 7.09757283e-02f, 8.72843340e-02f, 4.02768754e-04f, -3.14068645e-02f, -1.39049767e-02f, 2.01330110e-02f, -3.79671529e-02f,
  2.78378488e-03f, 4.80070012e-03f, -4.84432504e-02f, 1.95079371e-02f, 6.83450997e-02f, -2.75718533e-02f, 4.09450158e-02f, -4.08130139e-02f, -6.99390620e-02f, 5.04251271e-02f,
  -6.05619773e-02f, -1.75614264e-02f, -6.69557080e-02f, 6.97595179e-02f, 4.51809987e-02f, -2.84797661e-02f, 3.70466784e-02f, 8.12749863e-02f, 3.07307262e-02f, 6.66598678e-02f,
  -8.74313936e-02f, 8.24179053e-02f, -4.27694693e-02f, -5.19973561e-02f, 7.22893775e-02f, 5.36956750e-02f, -3.30164544e-02f, -5.31822667e-02f, -2.89850477e-02f, -4.61376179e-03f,
  1.07523287e-03f, -4.07144055e-02f, -6.88670427e-02f, -6.34979382e-02f, 3.67151834e-02f, -2.09076740e-02f, 2.56807320e-02f, -4.93524596e-02f, -7.92985708e-02f, 8.37231278e-02f,
  -6.71798736e-02f, 2.12915502e-02f, -4.49471030e-04f, 5.76668303e-04f, -6.68017492e-02f, 4.17763777e-02f, 6.06585778e-02f, 4.78798710e-02f, 7.64546916e-02f, -5.58787165e-03f,
  -6.80316687e-02f, 8.70484039e-02f, -6.97733611e-02f, -7.25888386e-02f, -7.75573775e-02f, 1.57755986e-02f, -1.43139604e-02f, -7.70326778e-02f, -5.66559918e-02f, -6.57695010e-02f,
  5.06881885e-02f, -2.88037341e-02f, -1.22187324e-02f, -2.23066360e-02f, -2.86152773e-02f, 2.51967683e-02f, 2.72331089e-02f, 7.03005493e-02f, -3.84958088e-02f, 4.59071733e-02f,
  -2.80690510e-02f, 4.28312309e-02f, 4.96563055e-02f, -2.24115476e-02f, -2.27011312e-02f, -7.31627718e-02f, 4.41539213e-02f, -5.84085751e-03f, 1.53234589e-03f, 8.34665913e-03f,
  -6.79151937e-02f, 1.50409769e-02f, 2.22058762e-02f, 2.74000615e-02f, -5.76358568e-03f, 4.66411980e-03f, 1.85488220e-02f, 8.06500018e-02f, 4.65258397e-03f, 8.09265077e-02f,
  -9.35324356e-02f, -5.81379980e-02f, -3.14043462e-03f, 2.53742486e-02f, 6.35028332e-02f, -7.40496740e-02f, -7.53141716e-02f, 2.81196423e-02f, -5.86693026e-02f, 2.08742451e-02f,
  -6.24225326e-02f, 1.66564658e-01f, 9.41845030e-02f, 1.21261582e-01f, -5.62764592e-02f, -5.30525409e-02f, -7.76407076e-03f, 6.72085136e-02f, 1.64131373e-01f, -1.28936516e-02f,
  1.11698266e-02f, 1.32422090e-01f, -1.25760743e-02f, 1.34942094e-02f, 6.68919459e-02f, -1.85751282e-02f, -1.35061285e-02f, -3.72439320e-03f, 1.09981574e-01f, 5.26704639e-02f,
  5.31508438e-02f, -1.27852987e-02f, -3.35681550e-02f, -2.10044812e-02f, 2.96638198e-02f, 1.11752674e-02f, -8.72386619e-02f, 2.46928055e-02f, 5.93321435e-02f, -6.57022074e-02f,
  -1.43078072e-02f, 1.25672281e-01f, -6.78380951e-02f, 3.86551246e-02f, 5.05608544e-02f, -9.40523893e-02f, 1.86299514e-02f, -7.69664645e-02f, -4.99769449e-02f, 3.37290764e-02f,
  -5.40332571e-02f, -4.23038602e-02f, 5.17004840e-02f, -2.97034681e-02f, -2.63255630e-02f, 3.16919805e-03f, -6.89948397e-03f, -4.16297130e-02f, 5.98344505e-02f, 3.64501439e-02f,
  9.33969859e-03f, 6.51302189e-02f, -5.43270633e-02f, 6.21175319e-02f, -8.24710634e-03f, 5.36326668e-04f, -1.58799998e-02f, 8.96533299e-03f, -4.55492288e-02f, 7.17065558e-02f,
  -3.13325040e-02f, 5.98332733e-02f, 7.37237409e-02f, 6.63364455e-02f, -1.15298862e-02f, 9.71612558e-02f, 6.00869730e-02f, -7.62461573e-02f, 6.45394772e-02f, 1.72707383e-02f,
  -4.16497849e-02f, 6.86593354e-02f, -6.28241375e-02f, 1.42176226e-02f, 7.84511119e-02f, -3.08823469e-03f, 5.97236827e-02f, 4.82213758e-02f, -1.07310154e-02f, 7.23239873e-03f,
  4.22102697e-02f, -5.73735461e-02f, -7.10629895e-02f, 3.92827615e-02f, -1.36923417e-02f, 5.18951826e-02f, 4.43815859e-03f, -6.51064366e-02f, 5.14833443e-02f, 1.77270658e-02f,
  8.08274224e-02f, 1.16451010e-01f, 4.07135375e-02f, -6.34893849e-02f, 6.43450692e-02f, -8.22703093e-02f, -3.16320620e-02f, 2.13407609e-03f, 8.57877433e-02f, 3.62821557e-02f,
  -2.18712296e-02f, -7.02345297e-02f, -8.89660046e-02f, 2.41668504e-02f, -4.48999815e-02f, 2.92454958e-02f, 1.07833326e-01f, -4.20798510e-02f, 3.52162831e-02f, 8.08878466e-02f,
  5.90920001e-02f, 2.67793685e-02f, -3.47629488e-02f, 7.06908479e-02f, -8.32062773e-03f, 4.88674417e-02f, 6.01066090e-02f, -5.22935251e-03f, 3.28936502e-02f, 6.66028261e-02f,
  -1.21090814e-01f, 1.02449693e-01f, 3.42756249e-02f, 9.68374684e-02f, -2.26732194e-02f, 3.22136246e-02f, 1.02969117e-01f, -3.26490700e-02f, 1.59109458e-01f, -7.38159427e-03f,
  5.51879182e-02f, 7.86237866e-02f, 2.49988493e-02f, 7.94028193e-02f, 6.63030818e-02f, 3.97229940e-02f, 7.97680914e-02f, -7.52348006e-02f, -1.59102362e-02f, 2.38538627e-03f,
  -9.21358839e-02f, -1.15600349e-02f, -9.10457224e-02f, -4.31496352e-02f, 8.77130870e-03f, -9.54870582e-02f, -6.91620633e-02f, -4.31396179e-02f, 1.39937655e-03f, 7.51383081e-02f,
  6.94909170e-02f, 7.28325024e-02f, -9.24717188e-02f, 2.43313015e-02f, -7.48974159e-02f, -9.72715393e-02f, 6.72947764e-02f, -1.01567566e-01f, -4.51563373e-02f, 3.22822854e-03f,
  -1.54734766e-02f, -7.81817362e-02f, -8.46182853e-02f, 5.68281598e-02f, -4.07927946e-05f, -2.93852556e-02f, 6.31028488e-02f, -5.92155382e-02f, 1.26043074e-02f, 5.59215173e-02f,
  -4.25164737e-02f, -7.23644048e-02f, -3.08269206e-02f, -1.90309398e-02f, -3.14252973e-02f, 8.03168193e-02f, 9.92024466e-02f, -5.55052198e-02f, 5.66412956e-02f, -3.59188095e-02f,
  -3.17545831e-02f, -4.42944989e-02f, 8.34853426e-02f, 1.64639764e-02f, -1.48774423e-02f, -2.63318345e-02f, -6.24321625e-02f, 6.36885092e-02f, 8.48110095e-02f, 4.91040759e-02f,
  2.32149139e-02f, -5.24495877e-02f, -7.35262781e-03f, 5.02621122e-02f, 4.74481545e-02f, 5.83841018e-02f, -6.78536072e-02f, -5.14332280e-02f, 3.69678512e-02f, 6.11684173e-02f,
  2.59520137e-03f, 3.64361256e-02f, 6.44186214e-02f, 8.32636207e-02f, -6.86192885e-02f, -6.32508919e-02f, 3.35663185e-02f, -1.96799207e-02f, -8.12838450e-02f, 8.41209292e-02f,
  -5.50577082e-02f, 5.96255027e-02f, -6.48503825e-02f, 2.12111454e-02f, -5.93586005e-02f, 7.72532299e-02f, -9.07677971e-03f, 3.84710990e-02f, 7.44817704e-02f, 8.66168886e-02f,
  6.63733482e-02f, -5.50388321e-02f, -3.48231196e-02f, 1.32288877e-02f, -2.98840441e-02f, 2.55067996e-03f, -6.19014204e-02f, 8.63965787e-03f, 6.15101829e-02f, -1.90357510e-02f,
  3.45667754e-03f, -6.39762580e-02f, 5.18348813e-02f, 5.75284213e-02f, 7.83862472e-02f, 2.81693898e-02f, -8.31496045e-02f, -6.49508834e-03f, -8.98085833e-02f, 9.80243608e-02f,
  -7.36822560e-02f, 9.22758356e-02f, 5.06130373e-03f, 8.11448544e-02f, -7.09099099e-02f, 1.21254295e-01f, 7.17559233e-02f, -1.45816123e-02f, -9.89060551e-02f, 6.51343260e-04f,
  -2.86827199e-02f, -4.37650792e-02f, 7.58634061e-02f, 1.16486281e-01f, 5.97653016e-02f, 1.45633370e-01f, 2.65849126e-03f, 6.92487061e-02f, 1.41095801e-03f, -4.81095687e-02f,
  -1.03920221e-01f, 2.40374519e-03f, 7.98146948e-02f, 7.33414814e-02f, 1.06062600e-02f, -1.32646054e-01f, 2.04920284e-02f, -5.31243253e-03f, 6.16196059e-02f, 9.32796150e-02f,
  -6.32353947e-02f, -1.41996741e-01f, 6.11907281e-02f, -6.23306744e-02f, -7.06567541e-02f, -7.40373954e-02f, 1.03477322e-01f, -7.00605065e-02f, -2.46789642e-02f, -1.86631698e-02f,
  6.80759326e-02f, -7.34895021e-02f, 1.13190366e-02f, -7.10380822e-02f, -1.30008131e-01f, -3.97123434e-02f, -7.93807581e-02f, 4.79858108e-02f, 3.43717560e-02f, -9.65169370e-02f,
  -2.98354328e-02f, -5.94331063e-02f, 6.74331039e-02f, -8.20552409e-02f, -4.73496281e-02f, -8.91795009e-03f, -8.97370279e-03f, 8.45425427e-02f, 2.92570367e-02f, 6.58056214e-02f,
  -4.66879904e-02f, -1.30539704e-02f, -2.50384603e-02f, 1.78864338e-02f, -1.51445391e-02f, -4.42779101e-02f, -2.33097505e-02f, 8.38968903e-02f, 7.70702446e-03f, 9.25664902e-02f,
  -3.18137296e-02f, -4.75362763e-02f, 1.12779755e-02f, 1.45972595e-02f, -1.14882560e-02f, 5.79897054e-02f, -3.02487127e-02f, -3.19469683e-02f, 8.90303031e-02f, -6.33566827e-02f,
  -1.42462160e-02f, 3.62770036e-02f, -6.17131107e-02f, -2.97327479e-03f, -8.66113305e-02f, 8.04949850e-02f, 1.67232789e-02f, 6.78260326e-02f, -4.42975461e-02f, 2.10739728e-02f,
  4.98626642e-02f, -3.59699465e-02f, 3.78609858e-02f, 6.44782633e-02f, -8.77263471e-02f, 3.17819342e-02f, -4.88672480e-02f, 6.65900782e-02f, -5.77215217e-02f, -7.62566328e-02f,
  -6.28488585e-02f, 7.33300224e-02f, -1.10829867e-01f, -5.58613706e-03f, -4.02264437e-03f, 3.37496139e-02f, 5.90228997e-02f, 3.33104357e-02f, -4.40299623e-02f, -3.19517367e-02f,
  6.47889972e-02f, 6.03724681e-02f, -2.87345033e-02f, 3.97029854e-02f, -5.03284745e-02f, 6.34629652e-02f, -8.90216753e-02f, 8.81777033e-02f, -1.12336405e-01f, 1.86801106e-02f,
  -7.26255402e-02f, -7.55183995e-02f, 1.58566892e-01f, 8.37853104e-02f, 1.28111139e-01f, 1.66424047e-02f, 1.54507965e-01f, 6.50515258e-02f, 1.04306638e-01f, 4.28442545e-02f,
  -7.43339360e-02f, -6.16689697e-02f, 3.48811597e-02f, 3.59310061e-02f, 9.22718272e-02f, -5.48288710e-02f, 1.26176432e-01f, -8.72840546e-03f, 8.60248730e-02f, -2.27571232e-03f,
  8.87603089e-02f, -7.45248795e-02f, -9.09734219e-02f, -1.24327138e-01f, 2.16130428e-02f, -7.90719315e-02f, -1.24732167e-01f, 3.60119008e-02f, -1.14064857e-01f, 1.86282173e-02f,
  4.93602008e-02f, 9.08329785e-02f, -8.12315345e-02f, 1.90369338e-02f, 5.73268682e-02f, 4.06517982e-02f, -5.85028417e-02f, -3.96367200e-02f, 7.33608603e-02f, -7.50106946e-02f,
  -1.06995534e-02f, -6.10852055e-02f, 3.26611623e-02f, 4.75554317e-02f, -8.65045842e-03f, 1.56251844e-02f, 5.24715111e-02f, -5.72218746e-02f, -7.56559297e-02f, 4.00910750e-02f,
  -9.81598422e-02f, -4.00798209e-02f, 1.10709686e-02f, 7.70733953e-02f, 2.07264852e-02f, -2.51872260e-02f, -3.50766443e-02f, 7.82139748e-02f, 4.65347283e-02f, 3.84601504e-02f,
  -8.38757306e-02f, -2.82151569e-02f, 3.60405296e-02f, -5.04989699e-02f, 3.23987752e-02f, -6.62349612e-02f, -9.10650101e-03f, -7.75971338e-02f, 3.92848253e-02f, 1.32293692e-02f,
  -3.20070013e-02f, 1.31367706e-02f, -8.48539546e-02f, 3.20036411e-02f, 5.51854670e-02f, -3.44155058e-02f, -2.00251024e-02f, 3.87449600e-02f, 6.12683855e-02f, 3.54669057e-02f,
  9.62107256e-02f, 8.88896063e-02f, 4.49788384e-02f, -6.26592198e-03f, 5.37236854e-02f, -9.32824798e-03f, -5.31031974e-02f, 2.28538420e-02f, -6.35375306e-02f, 1.76226851e-02f,
  -4.24812408e-03f, 4.66920175e-02f, 2.72332560e-02f, -1.25533408e-02f, 3.92312966e-02f, -6.41058087e-02f, -2.62715351e-02f, 5.28474897e-02f, 1.54044265e-02f, 2.59346720e-02f,
  -5.43278940e-02f, 3.74333151e-02f, 6.76082224e-02f, -5.15652671e-02f, -1.00442413e-02f, -9.92638990e-02f, 1.03293154e-02f, -7.23831877e-02f, 7.96553046e-02f, 3.04987356e-02f,
  3.14329341e-02f, 4.31798175e-02f, 7.95420632e-02f, 7.72738010e-02f, 1.00118686e-02f, 9.63232946e-03f, 6.46897480e-02f, 1.56280156e-02f, -8.33905116e-02f, 6.24148399e-02f,
  2.67133676e-02f, -3.35730582e-01f, 9.58907381e-02f, 9.67229158e-02f, 1.83000773e-01f, 1.36510044e-01f, 1.09680556e-01f, -3.04101706e-02f, -2.04581410e-01f, -1.70797169e-01f,
  7.66351223e-02f, -6.62596943e-03f, -2.57426463e-02f, -7.10165873e-02f, 3.18337530e-01f, -1.18160605e-01f, -9.05247256e-02f, -6.69918023e-03f, -7.22429380e-02f, 4.03919443e-02f,
  9.66609493e-02f, 3.45948245e-03f, 1.23587161e-01f, -1.24814967e-02f, -5.72076701e-02f, -7.67082721e-02f, 7.88017288e-02f, 2.90918108e-02f, 1.24132387e-01f, 1.59217685e-01f,
  -7.83350915e-02f, -9.86076891e-02f, 8.03122595e-02f, -1.04027145e-01f, -4.65451591e-02f, -7.13104159e-02f, -6.16090372e-04f, 6.49378169e-03f, -4.08190489e-02f, -8.99213832e-03f,
  -2.60910811e-03f, -2.28527579e-02f, 2.08852859e-03f, 1.56297032e-02f, 8.62104446e-03f, -8.69694725e-02f, -1.62551608e-02f, 3.11968406e-03f, 6.66419417e-02f, 1.71430297e-02f,
  -7.78584331e-02f, 5.96437454e-02f, -1.13762602e-01f, 6.37400374e-02f, 7.50380903e-02f, -6.19781837e-02f, 2.04143580e-02f, 7.14450777e-02f, 5.91599941e-02f, 3.49058062e-02f,
  8.81528780e-02f, 6.93245884e-03f, -7.01824110e-03f, -8.74150470e-02f, -3.94651806e-03f, 1.13189435e-02f, 8.06361437e-02f, -1.95256975e-02f, -2.45062495e-03f, 6.59625307e-02f,
  7.54157677e-02f, -2.50344328e-03f, -8.92225876e-02f, 1.07063372e-02f, 1.55277802e-02f, -6.78541586e-02f, 1.08046802e-02f, -1.39023066e-02f, -6.01879209e-02f, -3.08883619e-02f,
  9.15511921e-02f, 4.16232310e-02f, 6.15968928e-03f, 3.34911421e-02f, -3.18959430e-02f, 4.13287729e-02f, 3.18492241e-02f, -3.82101201e-02f, -4.55616027e-05f, 8.44274163e-02f,
  -2.13177502e-01f, -1.88963756e-01f, -3.22766341e-02f, 2.91534122e-02f, 2.84852535e-02f, -3.53147089e-02f, -1.07433125e-02f, -8.58668685e-02f, -5.90497479e-02f, 5.23175560e-02f,
  -6.35376349e-02f, -3.19553316e-02f, 5.05257063e-02f, -3.03577650e-02f, -5.44699393e-02f, 7.60452868e-03f, 8.13771933e-02f, -3.83454226e-02f, -2.01697107e-02f, -1.00962289e-01f,
  -4.94512655e-02f, 5.25016673e-02f, 8.24993625e-02f, -8.65767896e-02f, 3.97133343e-02f, 6.31630197e-02f, -2.96146180e-02f, 6.14824817e-02f, -4.52438891e-02f, -3.08141802e-02f,
  1.31291509e-01f, -7.35861287e-02f, -2.49113538e-03f, -3.40195820e-02f, -7.59954005e-02f, 9.66746286e-02f, 4.51879762e-02f, 1.86908878e-02f, -3.26147256e-03f, -1.10070646e-01f,
  4.53334115e-02f, 1.65678021e-02f, -1.47116939e-02f, -4.58523445e-02f, 7.34976158e-02f, 4.57365289e-02f, 9.66684595e-02f, 2.55887210e-02f, -7.34405071e-02f, 4.31926958e-02f,
  1.20022679e-02f, 1.03633814e-01f, -2.39783116e-02f, 4.15837625e-03f, 5.72589487e-02f, 8.59475881e-02f, -2.36579124e-02f, 8.93086642e-02f, -1.02938786e-02f, 4.79145274e-02f,
  6.91876933e-02f, 5.07415533e-02f, -3.02354880e-02f, -3.99225876e-02f, -3.12520051e-03f, -7.83573687e-02f, 7.13195745e-03f, 8.57019052e-02f, -3.85491587e-02f, 6.24386333e-02f,
  -8.66659544e-03f, 4.83067892e-02f, -3.55440453e-02f, 3.35640833e-02f, 4.60652001e-02f, -1.80541370e-02f, -4.37595695e-02f, 6.13112608e-03f, 7.08030239e-02f, -2.12079827e-02f,
  -4.27939482e-02f, -5.31261563e-02f, -9.28730592e-02f, -6.65019150e-04f, 1.39898655e-03f, -2.31692474e-02f, 7.27868080e-02f, -5.07742912e-02f, -7.15020299e-02f, -6.00322187e-02f,
  1.06503680e-01f, -2.65190508e-02f, 3.75846848e-02f, -2.53788941e-02f, -8.09709132e-02f, 8.44903514e-02f, -6.97204471e-02f, -1.00744830e-03f, 6.67422712e-02f, -5.54031879e-02f,
  -4.67859507e-02f, 1.02965944e-01f, 4.05561477e-02f, -3.90413627e-02f, -4.16450240e-02f, -2.04170775e-02f, 8.75941515e-02f, -3.53976712e-02f, 7.45708793e-02f, 6.98976815e-02f,
  -1.02534048e-01f, 3.78549956e-02f, -2.66505294e-02f, -6.08003326e-02f, 1.02726994e-02f, 8.00241828e-02f, 2.70767733e-02f, -2.53471415e-02f, -6.83510229e-02f, 7.36702234e-02f,
  -6.06904738e-02f, -1.03996463e-01f, -3.40957046e-02f, 1.91848893e-02f, -5.17832860e-02f, -2.34328583e-03f, 1.45330122e-02f, 1.24252448e-02f, 3.87580357e-02f, -4.37386557e-02f,
  -9.46488790e-03f, -3.48982005e-03f, 7.83777386e-02f, -9.68628284e-03f, -3.89399454e-02f, -7.39975572e-02f, 5.68857081e-02f, -5.97829558e-02f, 7.57238641e-02f, -8.02147686e-02f,
  2.53091175e-02f, 7.21964166e-02f, 5.21459058e-02f, 1.11837229e-02f, 6.45006895e-02f, 4.75294963e-02f, -4.92938654e-03f, 5.51349074e-02f, 9.24088657e-02f, -8.74285623e-02f,
  5.91090247e-02f, -9.82306749e-02f, -5.39327674e-02f, -9.43633467e-02f, -8.60439390e-02f, 2.52358969e-02f, 4.04885113e-02f, -2.64105555e-02f, -1.22712322e-01f, 9.48968083e-02f,
  -7.01417495e-03f, -1.12580143e-01f, 5.02011627e-02f, 4.19913456e-02f, 8.21982548e-02f, -8.18028953e-03f, 1.45731270e-01f, 1.01933904e-01f, -5.61646186e-03f, -8.20464864e-02f,
  -3.16077024e-02f, 9.12592635e-02f, -2.82866564e-02f, -6.42842501e-02f, -6.33692741e-02f, -2.50789616e-02f, -2.65898053e-02f, -8.18437040e-02f, -8.80192593e-02f, 4.32127081e-02f,
  -1.21792899e-02f, -3.48616540e-02f, 7.01033995e-02f, 7.07633495e-02f, 6.26282990e-02f, 6.88850507e-02f, -8.25868025e-02f, -8.44178051e-02f, 2.81018876e-02f, -4.27895039e-02f,
  3.92815806e-02f, -1.74177272e-04f, 1.57793090e-02f, 7.56163895e-02f, -5.01062497e-02f, 1.45617928e-02f, 5.34188524e-02f, 9.17022396e-03f, 2.07317919e-02f, -5.15122190e-02f,
  5.96044771e-02f, -7.14468434e-02f, 3.10166683e-02f, -8.06314424e-02f, -5.52674681e-02f, 3.90253402e-02f, 5.55099221e-03f, -8.48381296e-02f, -7.32576549e-02f, -8.11918825e-02f,
  -1.12033628e-01f, -4.01665494e-02f, 2.70741563e-02f, -7.02934191e-02f, 2.01620832e-02f, 2.89907469e-03f, 4.87903133e-02f, -3.91166173e-02f, -2.35591754e-02f, -1.35506624e-02f,
  2.63672527e-02f, 4.74318005e-02f, 6.26721233e-02f, 8.80424008e-02f, 7.76772201e-02f, 9.77304019e-03f, 4.33593616e-02f, -6.55099982e-03f, 3.98465171e-02f, 5.40817948e-03f,
  7.29951635e-02f, -9.26235318e-02f, -5.91583550e-02f, -2.72140373e-02f, 3.15785259e-02f, -6.78089857e-02f, -1.52343744e-03f, -3.06895897e-02f, 9.00685266e-02f, -5.17784171e-02f,
  -5.38913347e-03f, -2.92970203e-02f, -2.58928295e-02f, -1.30921649e-02f, -4.18821722e-03f, -7.89242089e-02f, 7.78565332e-02f, 5.56724407e-02f, 8.13226849e-02f, -4.64781793e-03f,
  8.09403323e-03f, -6.24057166e-02f, -3.63914147e-02f, 9.09112860e-03f, -8.36593807e-02f, -3.55473130e-05f, 5.98688498e-02f, 6.50911331e-02f, -8.08418542e-02f, -9.71684232e-02f,
  1.24601023e-02f, 3.92513573e-02f, -1.79222878e-02f, -1.27831995e-02f, 8.87571797e-02f, 1.01126410e-01f, -5.89180440e-02f, -3.88371833e-02f, -1.96003616e-02f, -7.92747438e-02f,
  1.85620204e-01f, 1.74295139e-02f, -4.42449711e-02f, -8.95494297e-02f, -5.78699633e-02f, 1.04041407e-02f, -9.93747264e-02f, -2.77157817e-02f, -1.95089176e-01f, -3.56185064e-02f,
  1.19452082e-01f, -1.08632155e-01f, -6.03992790e-02f, 2.21536420e-02f, -4.18900475e-02f, -1.07330099e-01f, 9.35258120e-02f, -1.17288008e-02f, 4.82701361e-02f, -5.33233173e-02f,
  2.80881356e-02f, 9.93176848e-02f, -2.68644001e-03f, 8.50881785e-02f, -2.14304682e-02f, -6.65257499e-02f, 8.21364745e-02f, 9.64832027e-03f, 8.79202858e-02f, -4.02537435e-02f,
  -7.76022160e-03f, 5.08143194e-02f, 4.81671132e-02f, 1.41126215e-02f, 6.35330603e-02f, 7.86502361e-02f, -1.94931682e-02f, -3.81341800e-02f, -1.18272539e-04f, 5.65827899e-02f,
  -2.99573466e-02f, -2.97510438e-02f, -3.00016776e-02f, 4.73894216e-02f, -1.14740081e-01f, -2.10527778e-02f, -6.13852218e-02f, -5.34202950e-03f, -6.37393631e-03f, -4.75630797e-02f,
  -1.08092785e-01f, -1.07378282e-01f, -5.87902367e-02f, 4.84327041e-02f, -3.77670750e-02f, -1.89606901e-02f, 9.32196388e-04f, -7.04535330e-03f, -4.00447287e-03f, -2.50818282e-02f,
  -1.92267485e-02f, -3.29729021e-02f, 2.18304731e-02f, 5.15463762e-02f, 5.16423620e-02f, 5.69965318e-02f, -4.59040850e-02f, -1.32053327e-02f, 1.33351786e-02f, 2.28301585e-02f,
  1.30280685e-02f, 8.98670033e-02f, -2.08038595e-02f, -7.91689381e-03f, 8.55033547e-02f, 4.08356041e-02f, -8.15282091e-02f, 6.10986874e-02f, 3.36844623e-02f, -4.45784144e-02f,
  -5.32118278e-03f, 1.05465084e-01f, 7.27364570e-02f, 1.54007468e-02f, -4.58377413e-02f, 4.67097014e-02f, -6.92992359e-02f, 4.57796305e-02f, 1.42359408e-02f, 6.30075485e-02f,
  6.87750056e-02f, 8.04206133e-02f, -6.05385341e-02f, -1.15157194e-01f, 5.64904325e-02f, 1.50472159e-02f, 6.62855059e-02f, 6.67217970e-02f, -4.71601486e-02f, -4.75305319e-02f,
  9.16147009e-02f, -8.26369599e-03f, -2.24605817e-02f, 1.28785511e-02f, -4.83858138e-02f, -5.90764917e-03f, -4.75673191e-02f, -5.76173712e-04f, -5.63226119e-02f, 1.63852125e-02f,
  8.00063759e-02f, -2.51752641e-02f, -2.80082766e-02f, 3.89945023e-02f, -3.27849090e-02f, 5.67638204e-02f, 2.29296228e-03f, -7.93911591e-02f, 2.11788360e-02f, -4.12226543e-02f,
  -2.24580452e-01f, 2.22593565e-02f, -1.28862783e-01f, -1.99627876e-01f, -1.92807447e-02f, -1.10079974e-01f, -3.05240024e-02f, 1.23466045e-01f, -7.39440173e-02f, 9.55019444e-02f,
  1.42900720e-01f, -1.36015490e-01f, 1.09250341e-02f, -4.58583459e-02f, -2.56055951e-01f, -7.79002905e-02f, -2.68254727e-01f, -1.66499391e-01f, -8.29054490e-02f, -1.08196400e-01f,
  -1.70821354e-01f, -3.63468640e-02f, -1.46516368e-01f, 2.79231928e-02f, -1.88766420e-02f, -8.97134375e-03f, 9.85744670e-02f, 8.66360664e-02f, -5.35188131e-02f, 6.68757334e-02f,
  -7.09574372e-02f, 1.73811778e-01f, 9.26514640e-02f, -1.98607650e-02f, 2.28288658e-02f, 2.68623158e-02f, 1.75712388e-02f, 5.53042591e-02f, 2.43248418e-02f, -2.86788009e-02f,
  1.38590327e-02f, 6.88875765e-02f, 3.54500152e-02f, 1.44049572e-02f, -6.90869335e-03f, -2.22599171e-02f, -5.33946697e-03f, -4.54337001e-02f, -6.95415214e-02f, -7.94836208e-02f,
  -1.51181789e-02f, -7.87762105e-02f, 4.98824799e-03f, -3.99998650e-02f, 1.64743047e-02f, 6.22668378e-02f, -2.80729849e-02f, -6.70443401e-02f, -7.14221075e-02f, -1.56048182e-02f,
  -2.46450808e-02f, -1.58172660e-02f, -4.99118753e-02f, 1.13086715e-01f, -5.38808219e-02f, 4.95310649e-02f, -9.45393518e-02f, 3.10073625e-02f, -3.30969766e-02f, 4.66733277e-02f,
  6.36040866e-02f, 6.87506720e-02f, -5.06860726e-02f, -7.00335354e-02f, -2.76457146e-02f, -2.83652414e-02f, -4.05734777e-02f, 2.83590965e-02f, -9.50979441e-02f, 4.95603960e-03f,
  2.91680265e-02f, -1.79070104e-02f, 2.05377396e-02f, 4.22043987e-02f, -3.16576734e-02f, -3.73634743e-03f, 2.03338619e-02f, -3.17117050e-02f, 8.38500336e-02f, -5.19447364e-02f,
  4.14618067e-02f, 2.90089641e-02f, -4.67663370e-02f, -4.16177884e-03f, 5.73740192e-02f, -3.96036217e-03f, -5.37613556e-02f, 2.50486787e-02f, -2.30803397e-02f, -2.15433966e-02f,
  2.68506389e-02f, -2.21086200e-02f, -2.93595418e-02f, -4.45794128e-02f, -1.58013087e-02f, 1.28002092e-02f, -1.14408813e-01f, 9.20507237e-02f, 3.67536652e-03f, 9.38195363e-02f,
  4.82907929e-02f, 4.49079312e-02f, 3.13078091e-02f, -6.66215271e-02f, 2.06071939e-02f, -2.30224505e-02f, 6.26687258e-02f, 1.98781602e-02f, -4.47571576e-02f, -3.50930467e-02f,
  2.21501989e-03f, 6.29391894e-02f, -4.66686785e-02f, -1.14338093e-01f, -4.32070643e-02f, -1.60801336e-01f, -1.33868948e-01f, -7.49669224e-02f, -5.67254871e-02f, 1.02115989e-01f,
  -1.57647431e-01f, -2.13470776e-02f, 3.42262201e-02f, -2.07572669e-01f, -7.84520060e-02f, -1.14964873e-01f, -2.10015699e-01f, -5.87766506e-02f, -1.91275962e-02f, 5.27143525e-03f,
  -1.32928565e-01f, -1.22229382e-01f, -2.93148980e-02f, 8.92595912e-04f, -5.89908287e-02f, 1.17121443e-01f, 1.62781864e-01f, 3.86701375e-02f, 1.79088283e-02f, -9.73111987e-02f,
  -9.39716324e-02f, -1.01247668e-01f, 4.34466638e-02f, -9.80294794e-02f, 4.54049036e-02f, -4.22673710e-02f, -3.00841480e-02f, -7.85886869e-03f, -7.22888410e-02f, -3.60321589e-02f,
  4.77704480e-02f, -4.65456322e-02f, -1.39787933e-02f, 5.98998219e-02f, 4.79952851e-03f, -6.17276644e-04f, 3.77994962e-02f, -4.69330512e-02f, -8.02882388e-02f, 2.24908404e-02f,
  6.69244975e-02f, 7.24157840e-02f, 3.82855050e-02f, 7.64549375e-02f, 4.97565791e-02f, -1.46428663e-02f, -4.68975790e-02f, 1.94309672e-04f, -3.30415629e-02f, -8.60831980e-03f,
  5.79059869e-02f, -6.93915337e-02f, -6.56296015e-02f, 3.75272110e-02f, -7.48144835e-02f, 3.78428004e-03f, 6.29561990e-02f, -7.49310330e-02f, 8.88112281e-03f, -1.67510728e-03f,
  2.32224558e-02f, 7.59528950e-02f, -4.89234691e-03f, -1.21698435e-02f, -2.70550624e-02f, 7.08327815e-02f, 7.30794272e-04f, 4.39075008e-02f, 6.23447075e-03f, 3.14958543e-02f,
  1.22288382e-02f, -3.21125682e-03f, 5.89792468e-02f, 9.87198725e-02f, -4.49481793e-02f, 3.97395007e-02f, -3.49303999e-04f, -4.47523557e-02f, -3.42622101e-02f, -2.55188514e-02f,
  1.15607522e-01f, 1.18902037e-02f, -2.90898550e-02f, 4.24894653e-02f, -3.03476509e-02f, -2.12826785e-02f, -1.01166464e-01f, 2.82552205e-02f, -2.96072010e-02f, -6.93458691e-02f,
  -2.20001563e-02f, -4.12391014e-02f, 1.50296288e-02f, 7.61531666e-02f, 1.14465831e-02f, -7.85456039e-03f, 4.89139408e-02f, 5.24027832e-02f, 7.62299225e-02f, -9.33411904e-03f,
  -6.94997329e-03f, 6.29508719e-02f, -9.28164739e-03f, 7.18644187e-02f, -3.42258625e-02f, 1.07578821e-01f, -6.71597663e-03f, 9.51299742e-02f, -1.54386386e-02f, 2.10845545e-02f,
  -1.06605016e-01f, 7.58972540e-02f, -1.16401510e-02f, 1.91427365e-01f, -5.49586266e-02f, 1.79904897e-03f, -4.74868808e-03f, 1.00590698e-01f, -2.83366311e-02f, 2.94366907e-02f,
  4.82776426e-02f, -4.45570834e-02f, 5.93309030e-02f, 1.49190992e-01f, 4.74987403e-02f, 1.16752721e-01f, 1.46766350e-01f, 2.27946993e-02f, 3.59470025e-02f, -5.60545688e-03f,
  5.78236803e-02f, 4.71126735e-02f, -9.75292996e-02f, -4.03515138e-02f, -3.27702835e-02f, -6.89912885e-02f, -6.62811100e-02f, -8.27290416e-02f, 8.19387287e-02f, 6.92908764e-02f,
  -1.64341014e-02f, 5.78039996e-02f, -9.49036777e-02f, 1.57981012e-02f, -3.68129015e-02f, -4.91823927e-02f, 9.58274864e-03f, -6.28524348e-02f, -7.50109926e-02f, 1.06038466e-01f,
  -2.75983289e-02f, -1.50191328e-02f, 6.39158636e-02f, -4.68246453e-02f, 3.37041654e-02f, -1.69211673e-03f, 2.88754664e-02f, 8.53892602e-03f, 8.15773979e-02f, 2.89627202e-02f,
  4.71253619e-02f, 5.26226796e-02f, 3.35509069e-02f, -5.38195781e-02f, -2.79773697e-02f, -5.10302000e-02f, -1.13344956e-02f, 1.21288728e-02f, 8.40201005e-02f, -7.64040351e-02f,
  3.06524113e-02f, 1.93971582e-02f, -7.06749707e-02f, -6.63601980e-02f, -7.86101520e-02f, -8.73633325e-02f, 4.60619330e-02f, 1.98241994e-02f, 2.65851449e-02f, -6.59377575e-02f,
  -8.00833851e-02f, 4.48860079e-02f, 3.81785654e-03f, 5.67743834e-03f, 4.89393547e-02f, -1.77652892e-02f, 5.44863567e-02f, 6.93238750e-02f, 7.36395791e-02f, 8.04630369e-02f,
  -2.26340326e-03f, 5.85112981e-02f, -2.15893798e-02f, 5.41728958e-02f, -1.27656739e-02f, -6.24679811e-02f, 9.45527852e-02f, -5.18355407e-02f, -6.76578879e-02f, 8.18333700e-02f,
  1.33725718e-01f, 9.92147103e-02f, 5.96470088e-02f, -7.11202621e-02f, 4.90964092e-02f, -7.44687691e-02f, -1.27198547e-02f, 3.03357858e-02f, -1.79958306e-02f, 5.88510558e-02f,
  -9.28775221e-02f, -7.19524175e-02f, -1.04064466e-02f, -4.38263826e-03f, -4.74884063e-02f, -6.64600134e-02f, 4.10572253e-02f, -3.66707407e-02f, 7.90921226e-02f, 5.12867719e-02f,
  -1.49819106e-02f, 3.10274754e-02f, -9.94303916e-03f, 5.86438142e-02f, 9.38055217e-02f, 6.84520006e-02f, -6.89067245e-02f, 4.54795174e-02f, -1.73490983e-03f, 1.00945882e-01f,
  6.14706147e-03f, -4.92864549e-02f, -7.08572716e-02f, -1.06153926e-02f, -6.20277636e-02f, -4.58262712e-02f, 9.80777889e-02f, -3.50439362e-02f, -2.85167247e-02f, 6.47089779e-02f,
  -2.64555048e-02f, -7.62626668e-03f, -1.75692327e-02f, 5.79234995e-02f, 8.47704187e-02f, 2.35263221e-02f, 4.81167659e-02f, 3.83764841e-02f, 4.78884391e-02f, 7.68932551e-02f,
  3.39487717e-02f, -3.58167626e-02f, 7.35666826e-02f, 5.71315810e-02f, 2.60509029e-02f, 1.14411609e-02f, -5.99024557e-02f, 2.38797870e-02f, 4.53118607e-02f, -6.05180562e-02f,
  2.95805782e-02f, 4.04626764e-02f, 2.34394819e-02f, 5.69204614e-02f, -7.04316571e-02f, -7.33649060e-02f, 5.50504308e-03f, 7.09626675e-02f, -1.58890877e-02f, -1.34195872e-02f,
  4.50425260e-02f, -6.74244687e-02f, -8.03439543e-02f, -7.60952607e-02f, -2.93826163e-02f, 4.63643223e-02f, -4.58457060e-02f, -9.50992331e-02f, -6.09270781e-02f, -5.45059405e-02f,
  5.76891787e-02f, 8.45625177e-02f, -3.76112736e-03f, -3.01119704e-02f, 9.28614812e-04f, 2.51505338e-02f, 6.67607225e-03f, -6.73052818e-02f, 4.82120141e-02f, -1.33356769e-02f,
  7.35126883e-02f, -4.14258502e-02f, 3.10941972e-02f, 4.89859618e-02f, 3.77135258e-03f, 8.82741511e-02f, -6.04591519e-02f, -6.48370609e-02f, -5.67660779e-02f, 4.90525849e-02f,
  -5.51593713e-02f, -7.85627514e-02f, 8.12925622e-02f, 7.08842278e-02f, 8.18598196e-02f, 8.43751337e-03f, -4.25465964e-02f, 8.70252028e-02f, 8.78706947e-02f, -3.35827433e-02f,
  -2.77933702e-02f, -1.77016053e-02f, 5.05702896e-03f, 3.05345678e-03f, -4.63532731e-02f, -5.12010045e-02f, -3.52641046e-02f, 2.49319077e-02f, 5.51557876e-02f, -3.54711339e-02f,
  -6.51931018e-02f, 1.05757840e-01f, -8.28666240e-02f, 5.20618744e-02f, -8.58712196e-02f, 4.61338423e-02f, 5.77132106e-02f, 2.04619300e-02f, -5.69621138e-02f, -7.74998516e-02f,
  -5.08367680e-02f, -1.55806858e-02f, -3.73778827e-02f, 9.14147720e-02f, 1.78512037e-02f, -7.91332498e-02f, 7.20394105e-02f, -5.42804599e-03f, -6.36576265e-02f, -4.51469384e-02f,
  1.03918267e-02f, 4.07644734e-02f, 7.96670988e-02f, 4.11597565e-02f, 9.34284925e-03f, -5.48899919e-02f, -4.54319827e-02f, -2.67047957e-02f, 4.94952127e-02f, 4.17344719e-02f,
  -1.21490821e-01f, 1.79302976e-01f, 4.71843183e-02f, -1.15041450e-01f, 2.15879437e-02f, 8.10406450e-03f, -5.84934792e-03f, -1.12132646e-01f, 1.56369731e-02f, 9.62737575e-02f,
  5.05618826e-02f, -5.54337166e-02f, 4.70734052e-02f, 5.71664870e-02f, -1.31119654e-01f, 1.27234787e-01f, 9.86318365e-02f, 1.37970932e-02f, 2.13627517e-02f, -9.78206620e-02f,
  -4.50174846e-02f, 6.61069676e-02f, 7.53338337e-02f, 5.91288991e-02f, 2.01022439e-02f, -8.56641978e-02f, -6.97250366e-02f, 1.09103560e-01f, 8.97593349e-02f, 1.01171046e-01f,
  -7.33533129e-02f, -3.67237739e-02f, -1.09098539e-01f, 5.68832159e-02f, 3.87612311e-03f, -1.09724306e-01f, -7.71358311e-02f, 8.22971854e-03f, -2.62908936e-02f, 4.92770411e-03f,
  -1.34516796e-02f, 1.47242788e-02f, -1.04476452e-01f, -5.68607962e-03f, -8.02336857e-02f, 5.95495291e-02f, 2.36984044e-02f, 2.99759265e-02f, -8.86502489e-02f, -8.33584182e-03f,
  3.83542366e-02f, -4.78933044e-02f, -3.80794555e-02f, 1.31468633e-02f, 1.81490034e-02f, -1.57935098e-02f, 8.49544927e-02f, -4.01972197e-02f, 9.53412522e-03f, 4.49472666e-02f,
  2.45931000e-02f, 2.51258966e-02f, 5.70404790e-02f, 1.27868215e-02f, 1.24910451e-03f, 8.66601542e-02f, -4.28294726e-02f, 1.31995149e-03f, 6.70226291e-02f, 5.13944700e-02f,
  -8.32400005e-03f, 3.49314958e-02f, -4.02524658e-02f, -2.49471646e-02f, -8.09810087e-02f, 5.83223030e-02f, -4.53452654e-02f, 7.39059076e-02f, 4.06275950e-02f, 1.56319551e-02f,
  -9.25233588e-02f, -5.52449189e-02f, 4.13766503e-02f, 7.45867193e-02f, -6.74656853e-02f, 1.44629218e-02f, -1.56540629e-02f, -6.56708777e-02f, -4.83309031e-02f, 3.50526534e-02f,
  -5.16814645e-03f, -2.08215974e-02f, -7.11059049e-02f, -7.40830824e-02f, 7.44809285e-02f, 1.89893749e-02f, -3.21757123e-02f, -9.93982181e-02f, -2.23323405e-02f, 1.99803673e-02f,
  -1.57322772e-02f, -9.22714919e-02f, -2.36463975e-02f, 5.60684539e-02f, -7.29650334e-02f, -7.59646343e-03f, -8.67354125e-02f, 6.20571300e-02f, -5.29531315e-02f, 1.04857842e-02f,
  3.61666568e-02f, 1.36561682e-02f, -8.08434784e-02f, 7.67713115e-02f, 5.46220988e-02f, -3.13932151e-02f, 7.29276836e-02f, 1.58785656e-02f, 4.18557078e-02f, 1.01765909e-03f,
  -1.81323573e-01f, 8.22909623e-02f, -2.53267825e-01f, 5.25551885e-02f, -8.47138986e-02f, 1.39882088e-01f, 2.27897987e-01f, -8.48308504e-02f, 6.70355931e-02f, 1.51812941e-01f,
  1.41409338e-01f, 3.23735029e-02f, 1.38918206e-01f, 2.33984396e-01f, 8.45807791e-02f, 1.87551677e-01f, 1.70035690e-01f, 1.96237385e-01f, -4.77160178e-02f, 6.33009374e-02f,
  3.06511130e-02f, 1.57308236e-01f, -3.35298777e-02f, -1.29287526e-01f, 1.47658251e-02f, -1.70236856e-01f, 9.39606037e-03f, -1.41416565e-01f, 1.78275928e-02f, -8.67995098e-02f,
  4.34585214e-02f, -2.89323535e-02f, 6.21068068e-02f, 9.21423733e-03f, -3.25046740e-02f, 5.38074374e-02f, -4.20453437e-02f, -4.44598384e-02f, -1.41063426e-02f, 1.27882687e-02f,
  1.37412678e-02f, 3.08953021e-02f, -5.50949201e-02f, -6.05397709e-02f, 5.57484925e-02f, 1.71792395e-02f, 3.79724056e-02f, -4.61717322e-02f, -2.28138082e-02f, 7.12185428e-02f,
  2.04054862e-02f, 8.19200724e-02f, -7.12756813e-02f, 6.60680681e-02f, -1.97959859e-02f, 7.11307526e-02f, 1.65365599e-02f, -5.23425788e-02f, 3.87675986e-02f, -1.56494826e-02f,
  -2.50042826e-02f, -2.26579085e-02f, 2.49902103e-02f, 8.06327909e-02f, 1.70865271e-04f, 7.24195465e-02f, 8.87883604e-02f, -1.99604314e-02f, 2.13826448e-02f, 3.11318389e-03f,
  -2.62583587e-02f, 4.55214158e-02f, -2.76659094e-02f, -8.18499774e-02f, -5.79569042e-02f, -3.74312489e-03f, -5.45599610e-02f, 4.19201069e-02f, -2.35050693e-02f, 5.06370179e-02f,
  3.55549492e-02f, -1.11574186e-02f, -1.33518567e-02f, 1.02564007e-01f, 4.49860580e-02f, -4.17791307e-03f, 6.22725338e-02f, -7.17569739e-02f, 3.32824439e-02f, -6.67711645e-02f,
  7.91714713e-02f, -7.14144334e-02f, -4.03724648e-02f, -3.26830782e-02f, -5.52672520e-03f, 2.50985809e-02f, -1.89223455e-03f, -3.34519185e-02f, 4.41700704e-02f, -1.00169554e-01f,
  -3.10967653e-03f, 2.89925188e-02f, 2.13150848e-02f, -2.78160572e-02f, -5.24956547e-02f, 3.08724307e-02f, 6.84062093e-02f, -2.17852779e-02f, 7.18649337e-03f, -2.14344147e-03f,
  -7.47498637e-03f, -6.29094196e-04f, 6.42671064e-02f, -6.67327642e-02f, 8.27996209e-02f, -1.97233781e-02f, -4.96399328e-02f, -1.01818375e-01f, 2.77959760e-02f, -2.64806719e-03f,
  7.71819577e-02f, 4.26739268e-02f, 1.62064210e-01f, -8.40748698e-02f, -3.75259407e-02f, 2.09909547e-02f, 1.56565383e-01f, 4.69863676e-02f, 7.51074404e-02f, -1.36424929e-01f,
  -6.60604239e-02f, 1.28453523e-01f, 3.80813926e-02f, 8.37679394e-03f, 2.86777485e-02f, 5.59727177e-02f, -2.46176240e-03f, 4.28881571e-02f, 6.86406046e-02f, -5.93647100e-02f,
  -6.54885406e-03f, -1.46620452e-01f, 4.19864990e-02f, 6.55110925e-02f, 6.82414547e-02f, 1.28013920e-02f, -7.22275600e-02f, 7.34693035e-02f, -4.35666330e-02f, -5.07656448e-02f,
  1.02989145e-01f, 8.65424052e-02f, 5.43431155e-02f, 2.15767417e-02f, 1.02964863e-01f, 3.40701342e-02f, 1.40894264e-01f, 1.48733288e-01f, -5.16656255e-05f, 4.74919602e-02f,
  9.79888160e-03f, 6.17355965e-02f, 1.13999413e-03f, 7.61048228e-04f, 7.17087984e-02f, 4.60668355e-02f, -3.31899337e-02f, -1.93535984e-02f, -4.54824418e-03f, -5.64256357e-03f,
  9.71106999e-03f, 1.11363463e-01f, 3.24583687e-02f, 8.17407444e-02f, 7.14408830e-02f, 1.10555947e-01f, -2.63397023e-02f, -2.12395564e-02f, 3.50657701e-02f, -9.96828154e-02f,
  2.41464525e-02f, 4.84353863e-03f, 1.35059161e-02f, 8.62295330e-02f, 7.73206502e-02f, 1.54429814e-02f, -1.75570715e-02f, 5.49657606e-02f, -1.57207325e-02f, 5.46137504e-02f,
  2.85390150e-02f, -2.04115175e-02f, -1.18442737e-02f, -1.41659984e-02f, -5.23661412e-02f, -3.26060653e-02f, 7.66912624e-02f, 4.09396216e-02f, 3.46208327e-02f, -3.02229961e-03f,
  -2.80977413e-02f, 3.83889973e-02f, 4.25248109e-02f, 3.38032842e-02f, 8.09351653e-02f, 4.51611392e-02f, -2.44000237e-02f, 8.17986131e-02f, -1.64906513e-02f, 7.31772324e-03f,
  -2.45605838e-02f, -7.87881911e-02f, 9.97649953e-02f, 4.22712369e-03f, 1.77362319e-02f, -2.02246141e-02f, -6.40185550e-02f, -4.21017148e-02f, 2.62555163e-02f, -4.51031253e-02f,
  -8.51657763e-02f, 2.43178643e-02f, -6.05090661e-03f, 4.30282298e-03f, -6.63731098e-02f, 6.44860882e-03f, 4.88729589e-02f, 4.91714068e-02f, 1.64114553e-02f, 5.15140872e-03f,
  -4.33818772e-02f, 2.81847846e-02f, 1.02247804e-01f, 5.93324043e-02f, -9.64402407e-03f, 2.05716887e-03f, -7.40434453e-02f, 3.33200358e-02f, 4.82068434e-02f, 1.19244251e-02f,
  -7.88220838e-02f, -1.73069984e-01f, 7.82193914e-02f, -1.80149693e-02f, 1.52221933e-01f, 1.46182030e-01f, 2.49712914e-01f, -1.64670318e-01f, -1.95020229e-01f, -1.09604843e-01f,
  -2.54279226e-02f, -6.94631413e-02f, 1.56834841e-01f, 1.81365889e-02f, 2.01511219e-01f, 2.00623274e-01f, 7.93486089e-02f, -9.48131680e-02f, -1.15912914e-01f, -1.49783358e-01f,
  1.58275068e-02f, 1.43579058e-02f, 1.43870682e-01f, -1.22480653e-01f, 7.31085241e-03f, -7.71812648e-02f, 1.01603501e-01f, 1.61672369e-01f, 5.44429906e-02f, 2.08989263e-01f,
  -1.16167620e-01f, -1.64635256e-01f, -9.25583392e-02f, -9.74457934e-02f, 2.82879751e-02f, 4.74040508e-02f, -4.39457409e-03f, 1.89058587e-01f, 6.09814450e-02f, 4.53107897e-03f,
  -2.51286719e-02f, 1.65248429e-03f, -1.82462372e-02f, -2.31519248e-02f, -1.04569476e-02f, 1.85833368e-02f, -1.07971333e-01f, -7.26762787e-02f, -7.99214393e-02f, 3.64950560e-02f,
  -6.31021038e-02f, 4.55783010e-02f, 1.52080907e-02f, -3.77178155e-02f, -3.84209454e-02f, 1.63687374e-02f, 3.27989757e-02f, 1.12300768e-01f, -4.20168340e-02f, -2.68716388e-03f,
  -3.95770371e-02f, 3.59689295e-02f, -2.10094508e-02f, -7.60310655e-03f, 5.00424281e-02f, -4.68067527e-02f, -4.87637334e-02f, 5.02172634e-02f, 3.34136784e-02f, -7.63710635e-03f,
  4.04505245e-02f, -2.08989680e-02f, -2.21606568e-02f, -3.84964831e-02f, -1.94706302e-02f, 2.64180619e-02f, -1.99701777e-03f, 3.32587957e-02f, -4.77107689e-02f, -1.39117008e-02f,
  5.68283945e-02f, -1.97226387e-02f, 2.90072206e-02f, -2.62081885e-04f, 7.81423822e-02f, -2.00376194e-02f, 1.40072042e-02f, -2.68563908e-03f, -2.23840438e-02f, 1.12990901e-01f,
  -1.77576870e-01f, -2.06401795e-01f, -1.53790237e-02f, -1.28331259e-01f, -5.04769199e-02f, -1.38848647e-03f, 6.14590868e-02f, -4.68488298e-02f, 9.94025543e-02f, 3.33367591e-03f,
  -2.39258371e-02f, -1.46671338e-02f, -6.07761145e-02f, 2.72348505e-02f, 4.49705943e-02f, -6.69957548e-02f, -4.33830591e-03f, 8.63030627e-02f, -5.89467622e-02f, 2.99623366e-02f,
  -8.22026562e-03f, -3.74734178e-02f, 3.82352062e-02f, -7.33217970e-02f, -4.95458627e-03f, 6.53740987e-02f, -6.61563948e-02f, -9.77940410e-02f, 4.31477018e-02f, 2.76767537e-02f,
  -1.19095407e-01f, -5.82738891e-02f, 2.46123806e-01f, -1.92231536e-01f, -9.38366279e-02f, 8.50532204e-02f, 7.15926290e-02f, -5.06665707e-02f, -1.60682112e-01f, -2.53182743e-02f,
  -6.66927174e-03f, -3.69618833e-02f, 9.41865891e-02f, -7.19092563e-02f, 1.70138329e-01f, 1.46887265e-02f, -1.15311205e-01f, 8.34836587e-02f, 2.85859630e-02f, -8.19080696e-02f,
  -6.69179186e-02f, -1.71917751e-01f, 8.26346800e-02f, -6.97019920e-02f, 1.53554482e-02f, -1.33999318e-01f, 6.48317486e-02f, 7.42467791e-02f, -1.06014967e-01f, 6.38196617e-02f,
  -4.89160940e-02f, 1.32523035e-03f, 9.05742422e-02f, -1.48624200e-02f, -3.02578378e-02f, 2.72943825e-02f, -1.41904913e-02f, 2.81798709e-02f, -7.85454363e-02f, 4.68417108e-02f,
  1.36023164e-02f, 2.01177988e-02f, -1.54276326e-01f, 5.98934852e-03f, -1.95345022e-02f, -7.65349194e-02f, 5.43734292e-03f, -8.25502798e-02f, 4.33348045e-02f, 1.37024403e-01f,
  1.13208406e-01f, 7.21937045e-02f, 3.52300555e-02f, -6.08150028e-02f, 6.68719858e-02f, -1.25259836e-03f, -2.35840902e-02f, -4.03068075e-03f, -5.85627370e-02f, -4.93405536e-02f,
  8.22645649e-02f, -1.72465853e-02f, 1.03000790e-01f, -6.82066455e-02f, -3.25649157e-02f, 1.35253854e-02f, -2.24940237e-02f, -3.21085658e-03f, -4.52570356e-02f, 2.43875775e-02f,
  1.90833583e-02f, 3.12086605e-02f, 6.28117546e-02f, -4.25415151e-02f, 4.44018804e-02f, 4.24758904e-03f, -3.75129022e-02f, -1.44585790e-02f, 3.28644216e-02f, -2.55913157e-02f,
  2.36912072e-02f, 1.04621165e-01f, 1.97512610e-03f, -3.30788339e-03f, 5.55489287e-02f, 3.99472155e-02f, -1.99961569e-02f, 2.19452288e-02f, -6.29701018e-02f, 8.89823493e-03f,
  -8.26542154e-02f, -1.12166911e-01f, -1.32874232e-02f, 7.32517913e-02f, 1.04101129e-01f, 1.79506652e-02f, 1.13814212e-01f, 2.33306829e-02f, -7.94620588e-02f, -6.84008449e-02f,
  -2.85301525e-02f, -1.41267655e-02f, 5.39745539e-02f, 4.26477753e-02f, 7.76609033e-02f, -5.71032651e-02f, -5.77309169e-02f, -7.81590044e-02f, -2.71086767e-02f, 7.96132833e-02f,
  -3.33722867e-02f, -4.99257594e-02f, 1.40527608e-02f, 6.34162650e-02f, 3.22880596e-02f, -1.99265089e-02f, -4.97797728e-02f, 7.19558522e-02f, 8.45352709e-02f, 4.90842685e-02f,
  -1.53616905e-01f, -9.66527238e-02f, -4.02926877e-02f, -2.68280916e-02f, -1.30051523e-01f, 1.69502482e-01f, 2.11338729e-01f, -6.72571138e-02f, -1.80057019e-01f, 1.75259665e-01f,
  1.90302953e-01f, -3.58610786e-02f, 1.80590943e-01f, 2.15155810e-01f, 1.58627763e-01f, 2.16821969e-01f, 7.41803572e-02f, 9.00120586e-02f, -1.12440981e-01f, -1.33561000e-01f,
  -8.53285789e-02f, 8.91441107e-02f, 1.42849416e-01f, -1.07973456e-01f, 1.60591619e-03f, -7.96437040e-02f, 5.39855585e-02f, 5.52105419e-02f, 9.84806642e-02f, 1.38627782e-01f,
  -6.58940151e-02f, -5.56396209e-02f, -5.83279915e-02f, -6.08930998e-02f, -9.81729403e-02f, 3.90466005e-02f, 6.61737323e-02f, 8.56102481e-02f, 3.78866494e-02f, -7.50845000e-02f,
  -4.63495124e-03f, -5.68944849e-02f, 1.44382156e-02f, -5.54432496e-02f, -1.11420490e-01f, 5.64882644e-02f, 1.60077810e-02f, 6.15009628e-02f, 2.15771385e-02f, -9.18160528e-02f,
  -2.78122053e-02f, -6.33678660e-02f, -4.52381261e-02f, 3.25019397e-02f, 8.79073739e-02f, 5.30776083e-02f, -5.08130714e-02f, 1.69982258e-02f, -5.40810777e-03f, 7.51667889e-03f,
  2.31228070e-03f, 3.87965702e-02f, -7.72010386e-02f, 3.62108834e-02f, -4.63768281e-02f, 4.27090600e-02f, 3.88321131e-02f, 6.84369132e-02f, 1.80363599e-02f, 4.84741814e-02f,
  -8.23922306e-02f, -2.56284308e-02f, -6.01049438e-02f, 3.64111885e-02f, -4.16725054e-02f, -5.18769138e-02f, -6.57292549e-04f, 5.27707599e-02f, -1.75380651e-02f, -7.44127408e-02f,
  -2.18683109e-02f, 3.62195782e-02f, 1.49519578e-01f, 1.11027062e-01f, -8.67493376e-02f, 5.49969971e-02f, -7.36813173e-02f, -8.41679499e-02f, -3.12489811e-02f, -1.27158668e-02f,
  -1.38757601e-01f, -1.59539983e-01f, -4.89236116e-02f, -2.95711961e-02f, 5.00133745e-02f, -4.46711518e-02f, -1.07824475e-01f, -1.17081543e-02f, 1.23523818e-02f, -2.79333852e-02f,
  5.86049221e-02f, 2.20267884e-02f, -1.24033369e-01f, -4.79542911e-02f, 1.47338370e-02f, -2.44299378e-02f, -5.67526743e-02f, 3.54089253e-02f, 1.16778262e-01f, 2.66472381e-02f,
  -7.93863845e-04f, -2.56043412e-02f, 7.36776590e-02f, 6.68198094e-02f, 8.06993991e-02f, -3.42402011e-02f, -5.12964167e-02f, -3.82651724e-02f, 6.45150896e-03f, 5.89134060e-02f,
  -9.02497172e-02f, 9.64195505e-02f, -1.15003094e-01f, -3.43447626e-02f, -1.75153129e-02f, -3.25994901e-02f, 4.76828282e-04f, -2.41715424e-02f, -2.68250108e-02f, 6.43671155e-02f,
  3.46380100e-02f, -5.10740606e-03f, 5.11419103e-02f, -8.46374109e-02f, -9.38831046e-02f, 2.32857186e-02f, -1.02272071e-01f, -2.19888296e-02f, -7.97583014e-02f, 2.11376995e-02f,
  8.71614181e-03f, -3.35910358e-02f, -4.24849391e-02f, 4.03892016e-03f, -2.64551267e-02f, 2.25378759e-02f, 7.68142939e-02f, 1.05271794e-01f, -3.21201682e-02f, 9.90022197e-02f,
  4.82358858e-02f, -1.73456464e-02f, -7.37456605e-02f, 2.00296398e-02f, -1.70262028e-02f, -2.71649864e-02f, -5.15902005e-02f, 4.98444401e-03f, -8.40326548e-02f, -5.75368255e-02f,
  4.25905026e-02f, 1.77812241e-02f, -1.02932826e-01f, -5.43313958e-02f, -3.22038680e-02f, 7.36925304e-02f, -8.25146958e-02f, 2.59059574e-02f, -2.93130055e-02f, -6.32345900e-02f,
  6.22837581e-02f, -4.39312197e-02f, 7.65158609e-02f, 1.90432146e-02f, -6.59005269e-02f, -7.83371702e-02f, 5.35522699e-02f, 7.54710212e-02f, 8.44826028e-02f, -6.00271113e-02f,
  -5.15441000e-02f, -1.00720763e-01f, 4.08746339e-02f, -2.92991381e-03f, 9.89530236e-02f, 4.70661409e-02f, -5.07750437e-02f, 5.20835370e-02f, -2.58542821e-02f, -8.31024125e-02f,
  -6.42766282e-02f, 4.32857797e-02f, -2.07664184e-02f, 5.84553927e-02f, -7.66807869e-02f, 1.08335947e-03f, -2.90422775e-02f, -2.46867295e-02f, -2.03790031e-02f, -2.33215207e-04f,
  8.17392692e-02f, -5.64008728e-02f, -6.19822182e-02f, 2.05169674e-02f, -1.33117121e-02f, 2.26770714e-02f, -1.69155113e-02f, 8.53718743e-02f, -3.35505158e-02f, 3.16214338e-02f,
  1.10974349e-02f, 8.00165832e-02f, -4.67885919e-02f, -6.68077692e-02f, 3.87456641e-02f, 2.60537281e-03f, -6.67495131e-02f, 2.42248308e-02f, -1.29390750e-02f, -1.32636633e-03f,
  6.20223731e-02f, -4.65985723e-02f, -2.71011353e-03f, -7.44622499e-02f, -1.48997474e-02f, -3.50607038e-02f, 6.80262595e-02f, -7.51775801e-02f, 3.18000540e-02f, 2.82119270e-02f,
  4.83419299e-02f, -2.99657620e-02f, -5.49323894e-02f, 1.69901941e-02f, 6.15203641e-02f, -3.20963115e-02f, -8.20947438e-03f, 1.06409956e-02f, 6.97784051e-02f, -9.57998540e-03f,
  2.05493927e-01f, -1.73359603e-01f, -3.41505604e-03f, 1.63308576e-01f, 1.00199081e-01f, 1.20910130e-01f, 1.90436691e-01f, 1.00255536e-03f, 2.98482738e-02f, -4.81958464e-02f,
  -2.07471056e-03f, -1.40924051e-01f, -5.77860177e-02f, -7.75811896e-02f, 4.71652821e-02f, -1.74528360e-02f, 8.44747424e-02f, -5.31576015e-02f, 9.16434266e-03f, -1.02444984e-01f,
  9.27660912e-02f, 5.87055683e-02f, 5.76562025e-02f, -3.87011021e-02f, 5.25175259e-02f, -6.94144592e-02f, -2.62829736e-02f, -5.78969307e-02f, -1.65353063e-02f, 2.00048219e-02f,
  1.30844871e-02f, -8.80286694e-02f, -1.33700098e-03f, -1.91342421e-02f, -4.52761576e-02f, 4.54924367e-02f, -2.03604493e-02f, 8.28343257e-03f, 7.05210865e-02f, 4.78334837e-02f,
  -1.76017396e-02f, -1.88138317e-02f, 3.40905413e-03f, -2.73129400e-02f, -1.15723098e-02f, -3.82351168e-02f, 2.42293160e-02f, -4.23633829e-02f, -1.98999159e-02f, -9.28198844e-02f,
  -2.84556150e-02f, 3.26882228e-02f, 1.59676317e-02f, -8.78484994e-02f, -6.56752288e-02f, -6.40747026e-02f, -3.13757360e-02f, -3.37810814e-03f, 1.69603119e-03f, 4.60442565e-02f,
  2.52862591e-02f, 3.52357924e-02f, 2.45338469e-03f, 9.64217708e-02f, -2.40129940e-02f, 7.01938272e-02f, -2.04079170e-02f, 7.58806244e-02f, -6.18869476e-02f, -8.39397386e-02f,
  -4.87299729e-03f, -1.58777628e-02f, 8.94298702e-02f, 9.66394693e-02f, 3.75315137e-02f, -4.58402149e-02f, 9.11332760e-03f, -9.40518156e-02f, 3.93302329e-02f, 3.79584916e-02f,
  -7.50647336e-02f, 7.52594247e-02f, -8.10737461e-02f, -4.36633900e-02f, -8.28959271e-02f, 4.66034152e-02f, 4.98819388e-02f, 3.51517671e-03f, -5.30649442e-03f, 6.69717416e-02f,
  3.52673121e-02f, -3.39339152e-02f, 5.75963855e-02f, 8.65327790e-02f, 4.38048795e-04f, -2.60035023e-02f, -6.36534095e-02f, -5.20735458e-02f, 6.95010424e-02f, 8.84669125e-02f,
  5.05430587e-02f, 3.48095596e-03f, -6.56631663e-02f, 4.88823801e-02f, -4.61536944e-02f, -1.98982507e-02f, 1.02190198e-02f, -7.64448345e-02f, -2.64713094e-02f, -3.63345630e-02f,
  -1.39803393e-02f, 2.39647599e-03f, -2.83415783e-02f, -7.94152357e-03f, -5.52956425e-02f, 2.81242225e-02f, 3.29341739e-02f, 7.33437657e-04f, 1.97386444e-02f, -4.80549559e-02f,
  -8.25049505e-02f, 4.09391597e-02f, -5.19597083e-02f, -2.86926497e-02f, 1.30272526e-02f, -2.43615843e-02f, -3.65361534e-02f, 2.28755344e-02f, 1.59989700e-01f, 1.15435449e-02f,
  -9.67411697e-02f, -1.19869709e-01f, 2.12521460e-02f, -1.25585034e-01f, -1.19852804e-01f, -4.68881242e-02f, -1.01193942e-01f, -1.08561181e-01f, 8.86724144e-02f, -1.29789591e-01f,
  1.89797562e-02f, -4.60814014e-02f, 5.42106107e-03f, 3.41141149e-02f, 5.42867631e-02f, -5.73945045e-02f, -1.02514707e-01f, 5.82996532e-02f, -1.28922299e-01f, 7.06818700e-02f,
  -1.10220112e-01f, 4.81236652e-02f, 9.66228843e-02f, -7.22161829e-02f, -1.17159970e-01f, 1.10889841e-02f, -1.43247247e-01f, 4.16288003e-02f, 1.08465299e-01f, 1.18788192e-02f,
  3.59311625e-02f, -3.79527994e-02f, -3.37467939e-02f, 2.51496676e-02f, 8.79017413e-02f, -2.06858534e-02f, -8.97079632e-02f, -3.16835269e-02f, -1.36173293e-02f, 1.09699130e-01f,
  1.46069722e-02f, -3.02437451e-02f, 7.21339509e-02f, -2.24110484e-02f, -5.32425158e-02f, 1.28917946e-02f, -9.34459046e-02f, -4.98153046e-02f, -6.64449334e-02f, -7.05328286e-02f,
  3.37510519e-02f, -3.55177224e-02f, 6.74157217e-02f, 6.21706024e-02f, -4.46176529e-02f, -3.65941636e-02f, -1.22951819e-02f, -1.76609438e-02f, 8.09435919e-03f, 8.80279392e-02f,
  3.66166718e-02f, -9.57485009e-03f, 1.71019009e-03f, -7.15301279e-03f, 1.41461166e-02f, -4.38754708e-02f, 6.06842525e-02f, 4.18804623e-02f, 2.41814665e-02f, -3.70962098e-02f,
  -7.76453763e-02f, -5.67437746e-02f, 7.96277672e-02f, 1.81485172e-02f, 7.68683553e-02f, 1.62167326e-02f, -6.24691658e-02f, 2.25502681e-02f, -5.58889238e-03f, 4.54136841e-02f,
  -7.19071180e-02f, -1.29792079e-01f, 9.25716609e-02f, -3.19076906e-04f, 6.19063824e-02f, 3.61392414e-03f, -3.13817449e-02f, 2.33014114e-02f, 1.24048311e-02f, 2.60604429e-03f,
  3.72072197e-02f, -4.50727306e-02f, -1.02078579e-01f, 7.40309358e-02f, 2.29235291e-02f, -9.40029621e-02f, 1.24609973e-02f, -1.21294461e-01f, 8.39285925e-03f, -2.86231888e-03f,
  -7.93086961e-02f, -6.98483735e-02f, -1.44013008e-02f, 5.09012267e-02f, 9.27343890e-02f, -3.25357057e-02f, -1.64565910e-02f, 4.53579967e-04f, -5.43015227e-02f, -2.42173076e-02f,
  7.25527331e-02f, -1.82377383e-01f, -1.28391132e-01f, -1.82664338e-02f, 9.23982561e-02f, 6.47890791e-02f, -7.21424296e-02f, 3.12981084e-02f, -7.23103760e-03f, -2.97796298e-02f,
  -3.16421292e-03f, 4.45954204e-02f, -1.43461585e-01f, 4.94681410e-02f, 3.33664753e-02f, -8.72302428e-02f, 5.36083691e-02f, 6.09628223e-02f, 2.36822926e-02f, -1.35258660e-01f,
  -4.04900722e-02f, 1.55629724e-01f, 1.02095522e-01f, 9.84464213e-02f, 6.54896349e-02f, 1.14796959e-01f, 2.51241233e-02f, -1.77026857e-04f, 6.71209693e-02f, 1.34649396e-01f,
  7.78318197e-02f, -2.04796847e-02f, -3.20796929e-02f, -8.43782630e-03f, -1.84670649e-02f, -2.52024550e-02f, 5.85916638e-02f, -6.29947856e-02f, -5.99501692e-02f, 6.90428317e-02f,
  5.65224327e-02f, -7.74246175e-03f, 6.14332147e-02f, -5.52142411e-03f, 3.60061601e-02f, 5.82115166e-03f, 5.93576245e-02f, 2.01193728e-02f, -9.00699105e-03f, 1.20068772e-03f,
  4.29815091e-02f, -7.66447112e-02f, -1.40434857e-02f, -3.10608540e-02f, -2.36990284e-02f, -1.60455462e-02f, 5.77550381e-02f, -1.21798329e-02f, 7.40042776e-02f, 1.28952339e-01f,
  6.05596341e-02f, -2.99734604e-02f, -6.85330853e-02f, 3.72620858e-02f, -8.30692872e-02f, -9.37335640e-02f, -5.24951220e-02f, -2.19543595e-02f, 3.14056431e-03f, -5.89723438e-02f,
  -7.18527436e-02f, -2.02879533e-02f, 4.04601991e-02f, 7.77996331e-02f, 1.02639524e-02f, 1.35886120e-02f, -7.71487504e-02f, -8.29449520e-02f, 2.87580285e-02f, 3.83731462e-02f,
  -7.99877644e-02f, -1.63662825e-02f, -5.22036180e-02f, -2.50005852e-02f, -9.48071852e-02f, 4.45678225e-03f, -3.00650299e-02f, 8.19933563e-02f, 8.64445344e-02f, -1.34788668e-02f,
  -8.14286247e-03f, 1.40593657e-02f, 7.13507384e-02f, -4.61645611e-02f, 7.96347931e-02f, 4.06786129e-02f, -1.86784621e-02f, 6.78186491e-03f, -3.03589180e-02f, -6.91842437e-02f,
  -1.53753264e-02f, 9.09502879e-02f, 4.84356843e-02f, -2.89801247e-02f, 9.31766182e-02f, -5.90454601e-02f, 3.92683484e-02f, -2.67417915e-02f, -6.65848106e-02f, -7.91881233e-02f,
  6.12079203e-02f, -5.94622567e-02f, 8.57074931e-02f, 9.03592780e-02f, 3.54571231e-02f, -4.55634743e-02f, 5.71683869e-02f, 8.46933499e-02f, -5.19248471e-02f, 7.57683888e-02f,
  -2.00228229e-01f, 1.33161500e-01f, -1.23919845e-01f, -1.08893916e-01f, 8.84334147e-02f, 2.58952789e-02f, -1.53294858e-03f, 5.65512255e-02f, -1.23436838e-01f, -4.90977094e-02f,
  -6.84415828e-03f, -6.11205725e-03f, 1.22816287e-01f, -4.86292578e-02f, -7.23655373e-02f, -5.02807349e-02f, 3.65490913e-02f, -1.15817182e-01f, -4.15032869e-03f, 5.95483184e-02f,
  3.77275087e-02f, -6.31010830e-02f, -2.24752482e-02f, 1.42516389e-01f, -1.12541933e-02f, 8.10443535e-02f, -3.09801158e-02f, 1.21949852e-01f, -5.06927595e-02f, 9.26537588e-02f,
  1.10889263e-01f, 1.15911394e-01f, -5.06827161e-02f, -5.79438470e-02f, -9.33755934e-02f, -6.43551499e-02f, -4.06783670e-02f, 7.05473498e-02f, 7.43597671e-02f, -5.79104275e-02f,
  -8.14548060e-02f, -7.90932477e-02f, -6.64007068e-02f, -7.46440375e-03f, -1.00840420e-01f, 4.95200083e-02f, 7.08705485e-02f, 2.43198406e-02f, 2.97392197e-02f, 3.66300754e-02f,
  -1.04823664e-01f, -3.91025692e-02f, -7.08945021e-02f, -1.62408594e-02f, -8.04144815e-02f, -6.08188733e-02f, 1.65889915e-02f, -8.14429075e-02f, -3.89707498e-02f, -6.89263269e-02f,
  -8.51024613e-02f, 8.62526074e-02f, 3.13200168e-02f, 7.94953406e-02f, -5.99394925e-02f, 1.50808264e-02f, -9.98063236e-02f, 4.46384959e-02f, 2.28203833e-02f, 4.03886102e-02f,
  5.66979051e-02f, -2.34148633e-02f, -7.76222115e-03f, -6.77192658e-02f, 2.74139214e-02f, -4.63428861e-03f, -5.61924130e-02f, 7.98370596e-03f, -9.10248160e-02f, 3.83362211e-02f,
  -6.48903698e-02f, 6.09704256e-02f, -6.96893930e-02f, 4.29514945e-02f, -3.02037466e-02f, -7.31896088e-02f, -9.60408822e-02f, -1.21487882e-02f, -3.63285504e-02f, -6.23155897e-03f,
  7.65238181e-02f, 6.00039586e-02f, 1.01170696e-01f, -7.79050738e-02f, 1.08539335e-01f, 2.06794459e-02f, 5.79878837e-02f, -6.74908087e-02f, -1.13390367e-02f, 1.21337397e-03f,
  3.05898599e-02f, -7.03924224e-02f, 1.75876101e-03f, 3.45554389e-02f, -4.93717194e-02f, 4.06364119e-03f, 1.01345759e-02f, -5.87977991e-02f, 1.86748914e-02f, -2.06692144e-03f,
  -2.80453470e-02f, 1.48476884e-02f, -6.83122948e-02f, 4.71627153e-02f, -1.36782387e-02f, 1.95834320e-02f, -5.39064929e-02f, -2.75944378e-02f, 6.08340986e-02f, -5.88036049e-03f,
  4.89931181e-02f, 4.50613648e-02f, -5.00472635e-02f, -5.06074913e-03f, -1.21767074e-01f, -1.30556703e-01f, -9.24038589e-02f, -2.28214124e-03f, -6.80198446e-02f, -6.97694197e-02f,
  1.96619332e-02f, 1.87180322e-02f, -4.30286899e-02f, -5.09766005e-02f, 7.42119970e-03f, 8.39776993e-02f, -8.46254081e-02f, 1.28940884e-02f, 1.23262577e-01f, 7.66643211e-02f,
  9.86728743e-02f, 1.09366765e-02f, 1.62316933e-01f, 3.87511700e-02f, 5.36136813e-02f, -8.40109959e-03f, 1.53383911e-01f, 7.32568279e-02f, -4.18002196e-02f, 7.03617930e-02f,
  -4.97396775e-02f, 5.67417173e-03f, -7.56262168e-02f, 7.80121014e-02f, 1.07181408e-01f, -5.02609015e-02f, -3.99967469e-02f, -6.83885589e-02f, 7.25193769e-02f, -3.01539712e-02f,
  9.03213955e-03f, -4.24875021e-02f, 3.29437964e-02f, -5.28497323e-02f, -7.07928389e-02f, -1.37766674e-02f, 2.65906565e-02f, -9.68833640e-03f, -3.03518884e-02f, 8.04424006e-03f,
  -6.44223168e-02f, -7.94502050e-02f, 4.11130562e-02f, -4.98060286e-02f, 5.98452948e-02f, -4.03815210e-02f, 6.98325858e-02f, 2.37137452e-02f, -7.34418407e-02f, 6.65954798e-02f,
  -3.58303562e-02f, 7.33576342e-02f, 5.18798679e-02f, 3.61527279e-02f, 8.17892477e-02f, 3.00125256e-02f, 6.68856800e-02f, 6.38426393e-02f, -7.64938956e-03f, 6.16906723e-03f,
  7.52898827e-02f, -1.95755921e-02f, -2.60473620e-02f, -3.33838500e-02f, 1.51063371e-02f, -1.82154104e-02f, -6.12232536e-02f, 1.24556981e-02f, 3.77468094e-02f, 3.30589153e-02f,
  4.32320312e-02f, 1.46161783e-02f, 4.51741107e-02f, 1.06470548e-02f, -8.25051218e-02f, -5.18096983e-02f, 2.81543527e-02f, 2.07861550e-02f, -4.64409478e-02f, 2.30322257e-02f,
  -4.16806564e-02f, 5.08379452e-02f, -8.30965415e-02f, 4.51578852e-03f, -1.39787365e-02f, -1.98940355e-02f, -3.66289206e-02f, 1.50032211e-02f, 2.55188849e-02f, 6.46307915e-02f,
  6.62333593e-02f, -7.46586621e-02f, 7.18157440e-02f, -1.66913383e-02f, 2.33785473e-02f, -5.74840046e-02f, 3.34949344e-02f, -1.60282496e-02f, 5.15632741e-02f, -9.58241615e-03f,
  -2.18465906e-02f, -7.33001158e-02f, -7.53931981e-03f, -6.03697821e-02f, 6.90416945e-03f, 1.38628785e-03f, 2.30128802e-02f, 7.30345100e-02f, -1.78735275e-02f, 3.21428478e-03f,
  3.06718022e-01f, 4.66473430e-04f, -1.13405816e-01f, -3.02647613e-02f, -5.57477064e-02f, -9.18127000e-02f, -4.20756936e-02f, 5.08699678e-02f, -2.78108954e-01f, 9.13939178e-02f,
  1.27048403e-01f, -1.26469761e-01f, -8.54113325e-02f, 7.17695728e-02f, 6.39748275e-02f, -3.60609703e-02f, 8.49651173e-02f, -2.81458404e-02f, -9.92760062e-02f, 1.81609467e-01f,
  -2.83639994e-03f, 3.13350946e-01f, -3.39414813e-02f, 1.17187768e-01f, 1.40511051e-01f, 4.13005538e-02f, 1.76642284e-01f, -2.01895051e-02f, 1.03799850e-01f, 1.09943934e-01f,
  8.63737389e-02f, -7.28904381e-02f, -7.24064708e-02f, -3.70366983e-02f, 6.97328299e-02f, 9.10809636e-02f, -2.43893638e-02f, -4.12639268e-02f, -5.32384124e-03f, -2.71513909e-02f,
  -8.89105052e-02f, -1.93866976e-02f, 2.55948938e-02f, 1.77059844e-02f, 1.19235029e-03f, -1.30505547e-01f, -4.49822808e-04f, -1.21591844e-01f, -3.54411714e-02f, 3.98691893e-02f,
  -9.18615460e-02f, 4.29339595e-02f, -1.03835769e-01f, -7.56659731e-02f, -3.15229961e-04f, -1.88168678e-02f, -6.34594262e-02f, 9.96534154e-03f, 5.98955341e-02f, 1.44338628e-04f,
  5.43293990e-02f, 2.92262603e-02f, 1.03003442e-01f, -2.22575404e-02f, 3.77730764e-02f, 6.75401976e-03f, -6.06914200e-02f, -4.67762761e-02f, -2.24319547e-02f, -1.67814549e-02f,
  -9.10622813e-03f, -2.02203579e-02f, -8.65793899e-02f, 1.02797180e-01f, -1.11084199e-02f, 1.74941532e-02f, 9.24346503e-03f, 1.07634127e-01f, -3.20890918e-02f, -8.09204951e-03f,
  -3.20432335e-02f, -3.24912295e-02f, 6.11185692e-02f, -5.20825721e-02f, 1.13022327e-02f, -3.56932618e-02f, 1.21980995e-01f, -7.45911524e-02f, -3.32988761e-02f, 4.57508378e-02f,
  7.58029297e-02f, 2.26803854e-01f, -2.79262960e-02f, 4.70296219e-02f, -3.50430980e-03f, -2.74132788e-02f, -3.59003358e-02f, 4.66683554e-03f, 1.26961663e-01f, 1.21150263e-01f,
  -6.20462149e-02f, 1.50454603e-02f, 1.47523498e-02f, -7.34593421e-02f, 7.99986050e-02f, 5.88262342e-02f, 3.22134122e-02f, 3.56239416e-02f, -6.19619079e-02f, 9.34391841e-02f,
  4.59295772e-02f, 3.76915606e-03f, 7.83419423e-03f, 3.52660241e-03f, -6.92115072e-03f, 8.65523145e-03f, -3.26103792e-02f, -4.98982426e-03f, 6.42438680e-02f, -9.68038812e-02f,
  5.01872413e-02f, 2.57515311e-02f, -1.14388131e-01f, -6.48031360e-04f, -5.80548644e-02f, -7.76416063e-02f, -1.92773730e-01f, -1.60915166e-01f, 3.02930623e-02f, 1.43569201e-01f,
  -1.00522242e-01f, 1.86451524e-02f, -4.65944372e-02f, -1.99637279e-01f, -3.65767777e-02f, -5.21149971e-02f, 1.93383964e-03f, 1.98851619e-02f, 9.93521959e-02f, -2.82530859e-02f,
  -1.21144600e-01f, -5.99881336e-02f, -1.39397830e-01f, 3.11983027e-03f, -7.08978325e-02f, 6.02370352e-02f, 9.60648656e-02f, -9.60442275e-02f, -9.33678448e-02f, -4.67092805e-02f,
  -8.38251188e-02f, -3.52547280e-02f, 9.24046412e-02f, -7.04289004e-02f, -2.38715522e-02f, 8.10064226e-02f, 2.13640351e-02f, -6.23049438e-02f, 5.04968464e-02f, -7.13384375e-02f,
  5.61729968e-02f, -4.91108596e-02f, -9.08041298e-02f, -6.95281848e-02f, -1.05337523e-01f, -6.37620240e-02f, 3.66513766e-02f, -5.82933873e-02f, 7.04973564e-02f, -7.78724402e-02f,
  1.03601702e-02f, -6.25973567e-02f, -8.11066255e-02f, 6.09530918e-02f, 2.45585246e-03f, -7.52461553e-02f, -3.23697366e-02f, 9.86594707e-03f, 6.05098195e-02f, 8.75639021e-02f,
  -5.03925309e-02f, 5.38207404e-02f, -2.04830337e-03f, 2.30934583e-02f, -6.39384091e-02f, -1.16204452e-02f, 6.27688318e-02f, 8.95035267e-02f, 4.55669546e-03f, -6.32092580e-02f,
  3.12263723e-02f, 2.24676412e-02f, -4.06500809e-02f, -2.29942910e-02f, 5.30895442e-02f, 7.25187659e-02f, -2.67945267e-02f, -5.55464551e-02f, 1.45520456e-02f, 4.26029451e-02f,
  4.06355858e-02f, 5.66818118e-02f, -2.70502865e-02f, -6.29696101e-02f, -3.53383236e-02f, -5.13560651e-03f, 7.66539946e-02f, -6.77169040e-02f, -7.40262344e-02f, -5.50948717e-02f,
  -1.43099325e-02f, -4.19938983e-03f, -1.11160679e-02f, 8.74993205e-02f, -4.99272011e-02f, 2.15300992e-02f, 5.56093045e-02f, -2.83878595e-02f, 4.72238176e-02f, 1.38710747e-02f,
  -5.72335646e-02f, -6.67295977e-02f, 6.45716041e-02f, -7.22474977e-02f, -2.56273132e-02f, 8.35698172e-02f, -2.02765837e-02f, -1.22854719e-02f, 7.52758756e-02f, 7.82558620e-02f,
  -1.93857066e-02f, -1.53280636e-02f, -2.99236681e-02f, 4.78267111e-02f, 5.25056385e-02f, -3.61951552e-02f, -1.57349929e-02f, 1.56248379e-02f, 5.07293902e-02f, 6.96891397e-02f,
  -3.04376096e-01f, -2.20584627e-02f, -3.03693442e-03f, -2.66358525e-01f, 6.10703602e-02f, 1.74729042e-02f, -3.43786739e-02f, 8.18395708e-03f, -7.26087019e-02f, 7.83220083e-02f,
  1.05075963e-01f, -1.06667049e-01f, 1.43920302e-01f, -1.30997106e-01f, -2.00953871e-01f, -6.57529756e-02f, -1.44470349e-01f, 2.13782340e-02f, 2.87153814e-02f, 4.18233499e-02f,
  -1.37735635e-01f, 1.20237912e-03f, -1.13289751e-01f, 1.28662243e-01f, 9.78818312e-02f, 1.38689905e-01f, -4.46761437e-02f, 5.99394292e-02f, -2.04177368e-02f, 7.68011063e-02f,
  -3.22965831e-02f, 9.15204212e-02f, -3.95943364e-03f, -3.71019430e-02f, 1.76513363e-02f, -3.89984772e-02f, 1.78543869e-02f, 2.94813216e-02f, -2.85374876e-02f, -2.27498151e-02f,
  -2.17144042e-02f, 7.76819605e-03f, -1.44743370e-02f, 7.29703456e-02f, 5.36845252e-02f, 4.08492312e-02f, 4.77139791e-03f, 1.32907019e-03f, 1.61074717e-02f, -5.35092093e-02f,
  -4.07068543e-02f, 1.74561720e-02f, -8.30480531e-02f, -5.32388501e-02f, -1.06373774e-02f, 2.05256958e-02f, -8.21528584e-02f, -2.96159144e-02f, -1.04197185e-03f, -5.48362285e-02f,
  5.86218238e-02f, 2.54568253e-02f, 6.33973768e-03f, 1.55020244e-02f, 5.28852977e-02f, 5.76110408e-02f, -3.62761356e-02f, -7.24591836e-02f, 8.50574113e-03f, -2.15014745e-03f,
  -5.68223745e-02f, -5.65872826e-02f, -1.86359696e-02f, 3.27531360e-02f, -8.44600648e-02f, -5.78981563e-02f, -2.30502971e-02f, -2.68282648e-02f, 4.42965468e-03f, -6.18696585e-02f,
  -1.10382317e-02f, -3.49573381e-02f, -2.04535909e-02f, -7.52628818e-02f, -4.97801509e-03f, -2.05603596e-02f, 1.44505361e-02f, -1.93867758e-02f, -6.68477565e-02f, 3.39307860e-02f,
  4.14542593e-02f, 9.23775434e-02f, 8.28395113e-02f, 1.09290212e-01f, 2.94755884e-02f, -3.60096917e-02f, 1.19148362e-02f, 2.92673353e-02f, -1.60999727e-02f, 2.09152363e-02f,
  -8.06738511e-02f, 1.31312339e-02f, 4.83958778e-04f, 9.97629575e-03f, 8.71085934e-03f, 4.02342752e-02f, 2.75736786e-02f, -4.95305061e-02f, -8.80993307e-02f, -2.78409626e-02f,
  8.39899257e-02f, 6.14926293e-02f, -3.04837618e-03f, 4.14736830e-02f, 2.60638557e-02f, -1.97001770e-02f, 3.19340676e-02f, -3.96761810e-03f, 8.46204627e-03f, 3.53480945e-03f,
  8.78513306e-02f, 8.27695280e-02f, 1.61851987e-01f, 7.05642328e-02f, -7.53945857e-02f, -1.30534291e-01f, -9.74014476e-02f, 9.85906050e-02f, 1.02763258e-01f, -1.27739668e-01f,
  7.77311325e-02f, 1.26201585e-01f, -3.56584303e-02f, 1.16126165e-01f, 2.33695414e-02f, -7.49138743e-03f, 1.06824592e-01f, 1.11685768e-01f, 1.30644485e-01f, 1.88779160e-02f,
  1.61462892e-02f, 4.60496657e-02f, -3.77408415e-02f, 5.90516180e-02f, 5.82676120e-02f, 9.39273164e-02f, -3.22303101e-02f, 5.33343218e-02f, 1.42115410e-02f, -2.25303229e-02f,
  -5.60869239e-02f, 9.62272212e-02f, -9.87318531e-02f, -1.14639878e-01f, 3.08744311e-02f, -1.25433169e-02f, -2.13179663e-02f, -3.91008519e-02f, -3.59212868e-02f, 7.02202991e-02f,
  5.58821373e-02f, -9.96063799e-02f, -4.17384543e-02f, 5.55224791e-02f, 8.69176760e-02f, 9.37318727e-02f, -2.22806223e-02f, 1.22762144e-01f, -2.41875593e-02f, -7.61323720e-02f,
  7.86003564e-03f, -1.08582247e-02f, -2.91864183e-02f, -2.81409919e-02f, 1.01920441e-02f, 6.07726239e-02f, 2.80768666e-02f, 4.56502438e-02f, 5.32265147e-03f, 5.82443625e-02f,
  -1.46085173e-02f, 5.84575050e-02f, 6.45879135e-02f, -1.73758771e-02f, 9.98158939e-03f, 1.11241518e-02f, -8.07334669e-03f, 2.14389693e-02f, -5.27574308e-02f, 9.20988321e-02f,
  7.13400543e-02f, -3.84392999e-02f, 5.90348840e-02f, 1.81179978e-02f, 4.95972000e-02f, -4.32944708e-02f, 3.32042240e-02f, 4.97153141e-02f, -7.12963566e-02f, -3.34779546e-02f,
  -3.74864042e-02f, -4.46382351e-03f, 8.44477862e-03f, 1.79110281e-02f, 2.02538315e-02f, -3.77872139e-02f, 5.14018536e-02f, 4.16634642e-02f, -6.86384812e-02f, -7.56099820e-02f,
  8.63561258e-02f, 1.49246767e-01f, -1.36145148e-02f, -5.06346747e-02f, 1.06458680e-03f, 2.50072796e-02f, 4.20777276e-02f, 5.70880994e-02f, 4.16776016e-02f, -3.75707485e-02f,
  -4.91556823e-02f, -4.82240804e-02f, -8.69574547e-02f, -8.61855149e-02f, -3.82204093e-02f, 2.80461125e-02f, -3.30062136e-02f, 3.78530696e-02f, 2.85888882e-03f, 4.17291149e-02f,
  9.51030180e-02f, -1.64592285e-02f, -1.33950636e-02f, -1.44233601e-02f, -1.51703525e-02f, 8.46393928e-02f, 6.73959851e-02f, 7.38634542e-02f, -3.76809686e-02f, 6.34953380e-03f,
  8.54373500e-02f, -1.70179501e-01f, 9.40917879e-02f, -3.42688747e-02f, 1.99632719e-02f, -4.68410216e-02f, 7.48072343e-04f, -5.71139678e-02f, -8.31391662e-03f, -2.03307435e-01f,
  -2.76419725e-02f, 1.03325598e-01f, 1.21294096e-01f, -4.63665575e-02f, 5.59992418e-02f, 8.48567858e-02f, -4.34077345e-02f, -1.54999178e-02f, 2.10823100e-02f, -5.68843149e-02f,
  3.18226814e-02f, -9.47541147e-02f, 1.07001193e-01f, -1.95384830e-01f, 4.03797850e-02f, -1.29341066e-01f, -7.26575926e-02f, 4.93727401e-02f, -1.51759898e-02f, -9.28753708e-03f,
  1.79680914e-01f, -7.49692470e-02f, -4.11240337e-03f, 4.36011218e-02f, -3.06102410e-02f, 4.45134975e-02f, -7.95895047e-03f, -6.05007587e-03f, 1.38287649e-01f, -2.20039263e-02f,
  5.57042360e-02f, 7.83463866e-02f, -3.55807357e-02f, 2.70694625e-02f, -2.56971363e-02f, 7.34650940e-02f, 9.98604074e-02f, 2.60335375e-02f, -5.77136949e-02f, -5.07029630e-02f,
  6.54160902e-02f, 5.95309138e-02f, 1.13447392e-02f, 1.88893992e-02f, 3.55318747e-02f, -2.97703743e-02f, -5.04078194e-02f, 6.88367784e-02f, 6.03372678e-02f, -8.53737667e-02f,
  -2.49075174e-01f, -6.63247928e-02f, 7.26628825e-02f, 7.70008266e-02f, -2.27834471e-02f, 1.13175527e-04f, 4.69323769e-02f, 2.19995938e-02f, 1.15891330e-01f, -1.67288538e-02f,
  1.37296664e-02f, -5.03493100e-02f, -6.81976601e-02f, 4.53363135e-02f, 4.86873724e-02f, 1.52515415e-02f, 6.70637563e-03f, 3.59838717e-02f, -6.69508055e-02f, -8.99423808e-02f,
  -5.31088300e-02f, -5.29629253e-02f, -5.38104512e-02f, 6.85999319e-02f, 5.87073639e-02f, 4.11406532e-02f, 4.34645563e-02f, -2.76928004e-02f, 4.48951460e-02f, -2.91698761e-02f,
  -1.17727518e-02f, -2.55526572e-01f, 1.63814761e-02f, 4.88914400e-02f, 1.16545610e-01f, -1.64481979e-02f, -1.52906701e-02f, -4.57497537e-02f, -1.85396820e-02f, 4.31055389e-02f,
  6.36175051e-02f, 1.98321119e-02f, -5.00339717e-02f, 7.10543012e-03f, -8.44147652e-02f, 2.00491026e-02f, -3.38935591e-02f, -5.40546365e-02f, 5.10179698e-02f, -1.00080028e-01f,
  1.14053916e-02f, 3.59348506e-02f, 1.14295468e-01f, 4.20762189e-02f, -2.89776493e-02f, -3.79004143e-02f, 1.31753627e-02f, 2.57453714e-02f, -5.51465666e-03f, 3.76699418e-02f,
  5.00876047e-02f, -3.27801332e-02f, 9.83997509e-02f, -4.55354638e-02f, 1.50230536e-02f, 1.18489176e-01f, 1.10183633e-03f, 7.61383250e-02f, -8.47766325e-02f, -8.07329565e-02f,
  -4.05252054e-02f, -8.58075917e-02f, -6.69782013e-02f, 1.22015998e-02f, 1.12228923e-01f, -4.87979408e-03f, -2.78164390e-02f, -3.29635032e-02f, 1.58265568e-02f, 5.21642007e-02f,
  7.72107095e-02f, -1.77331008e-02f, -4.66219895e-02f, 8.33718688e-04f, -6.18028529e-02f, -6.92272186e-02f, 2.61093173e-02f, 4.20500040e-02f, 4.65402231e-02f, -5.67328297e-02f,
  -6.08669296e-02f, -6.15703091e-02f, -1.05445711e-02f, -7.90768191e-02f, -1.72879770e-02f, 5.66970482e-02f, 1.00435972e-01f, -8.63144249e-02f, 2.99721453e-02f, -3.81071828e-02f,
  -3.44737358e-02f, 3.54625173e-02f, -1.15448618e-02f, 7.94299915e-02f, -9.55280140e-02f, 5.64496927e-02f, -3.49502228e-02f, -9.49404612e-02f, -6.91695586e-02f, -9.24354717e-02f,
  -1.26441056e-02f, -2.05535516e-02f, 8.68677720e-02f, 6.92128539e-02f, -4.01606224e-02f, -2.22761817e-02f, -6.70105292e-05f, -7.49404952e-02f, -7.72252977e-02f, -2.77633406e-02f,
  -5.26526570e-02f, 2.66254544e-02f, -3.21165919e-02f, 5.70335165e-02f, 9.34893787e-02f, 5.63631468e-02f, 6.32140934e-02f, -8.06472152e-02f, -2.43771691e-02f, -8.15949123e-03f,
  8.49218294e-02f, -8.92079473e-02f, 7.59592727e-02f, 5.99835478e-02f, 3.58769447e-02f, -3.85256000e-02f, -3.19420137e-02f, 7.95651674e-02f, 2.27429532e-03f, 5.08429036e-02f,
  -8.50483254e-02f, 6.09830357e-02f, -4.69150115e-03f, 3.49906310e-02f, -8.47082138e-02f, -3.93475592e-02f, 6.24932125e-02f, -2.48364750e-02f, -8.04531872e-02f, -1.71644241e-02f,
  4.43205163e-02f, -8.92060697e-02f, 7.96014965e-02f, -5.11068478e-02f, -8.12404081e-02f, -3.43314968e-02f, -7.64868110e-02f, -7.60752484e-02f, -7.59488791e-02f, 6.60641417e-02f,
  -8.81907269e-02f, 5.18126041e-02f, -7.32483938e-02f, 7.86295440e-03f, -3.90214548e-02f, 2.29556542e-02f, -4.15686443e-02f, -9.54304188e-02f, 5.77437654e-02f, 6.13751970e-02f,
  5.55917062e-02f, -2.72102226e-02f, 9.97291878e-02f, 4.41640355e-02f, 5.07752337e-02f, 8.96053761e-02f, -3.79934646e-02f, 2.05272790e-02f, 2.87526269e-02f, 8.27660635e-02f,
  -3.69935900e-01f, 1.96520746e-01f, -1.39018372e-01f, -6.69273967e-03f, -6.14505559e-02f, 1.09287582e-01f, 1.20218463e-01f, 3.91233899e-02f, 5.22775613e-02f, 3.38443220e-01f,
  1.35882765e-01f, -7.04516172e-02f, 1.32010460e-01f, 1.89952716e-01f, -4.47385311e-02f, 9.60684270e-02f, 1.04321770e-01f, 5.97513504e-02f, -4.06550765e-02f, -5.19881696e-02f,
  -9.21678096e-02f, 1.90152258e-01f, -6.15208223e-02f, 8.80165100e-02f, -2.17655655e-02f, -9.83644947e-02f, 6.29907995e-02f, -8.33169445e-02f, 6.20975439e-03f, -1.91771742e-02f,
  -1.06738135e-01f, -6.05704188e-02f, -9.07979533e-02f, -1.31971091e-01f, -1.26956686e-01f, -2.78363675e-02f, -8.26888159e-02f, -8.39346368e-03f, -4.44820598e-02f, 4.68054637e-02f,
  2.55718380e-02f, 2.26174109e-02f, -3.53798382e-02f, 9.53619182e-02f, -2.64297556e-02f, -6.19200543e-02f, 6.85418956e-03f, -5.48376255e-02f, 8.08325503e-03f, 2.81397104e-02f,
  8.24048370e-02f, -9.06529054e-02f, 5.36722876e-02f, 7.83830509e-02f, 7.49497255e-03f, 3.42820622e-02f, 1.09285846e-01f, 4.19713231e-03f, -8.28916505e-02f, 5.37421145e-02f,
  4.28982191e-02f, 7.37944804e-03f, 1.17016569e-01f, -2.98692677e-02f, -8.26971792e-03f, -5.47629558e-02f, 9.34468135e-02f, 5.30589782e-02f, -1.50328213e-02f, 1.21914148e-01f,
  7.50388131e-02f, -4.58375439e-02f, 3.99000198e-02f, 1.13017112e-01f, 6.48625046e-02f, 6.21224195e-02f, 8.32601159e-04f, -1.55903492e-02f, -5.92808872e-02f, 5.71223497e-02f,
  6.08655624e-02f, -3.59677663e-03f, -1.79539230e-02f, 3.06754019e-02f, -1.30317397e-02f, 4.38940190e-02f, 4.03940454e-02f, 8.94050002e-02f, -4.20232005e-02f, -3.04284971e-02f,
  -2.18544006e-02f, -5.38459569e-02f, 4.97945361e-02f, 6.09238371e-02f, 2.75526494e-02f, -3.60423513e-02f, 3.44305262e-02f, 2.71309428e-02f, -7.33926594e-02f, -7.90973287e-03f,
  -6.22303337e-02f, 4.22947519e-02f, 5.15158921e-02f, 8.68393015e-03f, -9.41867416e-04f, -1.60151627e-02f, 9.78745222e-02f, -7.94580653e-02f, -1.56713035e-02f, -7.68425167e-02f,
  3.50161530e-02f, 1.54741965e-02f, 5.53809814e-02f, -6.95621818e-02f, -4.63778116e-02f, 3.41975465e-02f, 1.32747274e-02f, 7.06884041e-02f, -9.60989099e-04f, -1.20655317e-02f,
  4.49525602e-02f, -1.29917534e-02f, -6.72717392e-03f, 5.61546795e-02f, -1.04959225e-02f, -3.55068967e-02f, -6.95386855e-03f, 6.83054551e-02f, 2.08509378e-02f, -8.58255029e-02f,
  -4.67401706e-02f, -2.47254279e-02f, -1.20262176e-01f, 5.63330539e-02f, 9.47243944e-02f, -8.09758604e-02f, 5.74114099e-02f, 6.98129162e-02f, -4.08327160e-03f, 2.97262259e-02f,
  -5.70849776e-02f, 6.99712038e-02f, -5.63962199e-02f, -1.10626556e-01f, -1.72445197e-02f, -8.27378482e-02f, -4.29532044e-02f, -4.45416346e-02f, -8.52071419e-02f, -4.04030681e-02f,
  -8.29184651e-02f, -2.17184648e-02f, -3.48418131e-02f, -2.27139257e-02f, 6.21118024e-02f, 6.77607432e-02f, 6.76887110e-02f, -5.11382483e-02f, 3.62952128e-02f, -2.94836555e-02f,
  -6.86170384e-02f, -3.61824073e-02f, -7.13315383e-02f, -1.60127673e-02f, -3.25701898e-03f, 1.74365304e-02f, 1.96390022e-02f, -8.14044699e-02f, -2.07478050e-02f, 2.90453751e-02f,
  -2.16420125e-02f, 1.59753561e-02f, -3.36526632e-02f, 2.66562812e-02f, -4.56857607e-02f, 3.95864435e-02f, -9.82836038e-02f, -3.45801152e-02f, 9.09341425e-02f, 2.14879829e-02f,
  4.70147245e-02f, 4.14345786e-02f, -5.86939342e-02f, 2.31819302e-02f, 6.26096129e-02f, 9.75134894e-02f, -3.49515863e-02f, -4.47595632e-03f, 3.80593427e-02f, -7.08901659e-02f,
  5.66264428e-03f, -8.56417343e-02f, 3.51968594e-02f, 4.43597250e-02f, -6.29717261e-02f, -1.70958042e-02f, 1.23137189e-02f, 2.68570725e-02f, -5.06296270e-02f, -2.92629004e-03f,
  -7.01983273e-02f, -8.55394751e-02f, 6.97468221e-02f, -6.69984221e-02f, 5.00795245e-02f, 6.12089708e-02f, -9.02159587e-02f, 3.89760546e-03f, 7.35129416e-02f, 8.58530328e-02f,
  -7.61749744e-02f, 2.70869769e-02f, 5.49253747e-02f, -1.61212273e-02f, -4.94416058e-02f, 1.76433455e-02f, -3.95095199e-02f, 8.35963935e-02f, -8.29568952e-02f, -1.98308937e-02f,
  2.43282039e-02f, -4.41157930e-02f, -8.80910363e-03f, 4.90678810e-02f, 6.37209788e-02f, 8.71507102e-04f, -6.98113665e-02f, 1.20221376e-02f, -6.16859533e-02f, -2.25112261e-03f,
  5.33640422e-02f, -2.17877142e-02f, -7.30590522e-02f, 5.99531941e-02f, 2.67993603e-02f, -4.60809357e-02f, -7.01311827e-02f, 6.52505923e-03f, -8.02381895e-03f, 5.48526458e-02f,
  -6.94629773e-02f, 6.97548687e-02f, -1.19941793e-01f, -1.15354927e-02f, 7.35942051e-02f, -7.44994283e-02f, 7.81751350e-02f, 1.05542159e-02f, -1.19524889e-01f, 1.15887694e-01f,
  -1.20580159e-02f, 2.27859635e-02f, 7.73235187e-02f, -6.44309595e-02f, -7.02098683e-02f, -5.28005362e-02f, -7.77585804e-02f, -1.72209330e-02f, -9.72595960e-02f, -2.10361052e-02f,
  5.48759587e-02f, -3.84464003e-02f, 2.35702135e-02f, 8.45674500e-02f, 3.25225964e-02f, 5.55936880e-02f, -5.44787459e-02f, -2.92813759e-02f, -5.34746312e-02f, 4.66534235e-02f,
  -2.37980522e-02f, 5.15278131e-02f, -2.06762627e-02f, -4.88586463e-02f, 8.25942159e-02f, 5.76623231e-02f, -1.73465088e-02f, -1.87326185e-02f, -8.74374732e-02f, 9.13941339e-02f,
  6.72841668e-02f, -6.85404241e-02f, 7.43082166e-02f, -5.73268272e-02f, -6.15815632e-03f, 3.40081677e-02f, -6.89584389e-02f, 7.13421926e-02f, 6.26696944e-02f, -1.08681940e-01f,
  -9.30411443e-02f, -7.64997229e-02f, -7.13940039e-02f, -1.13874264e-02f, -5.76143898e-02f, -2.86471806e-02f, -7.47078881e-02f, -7.54991025e-02f, -3.40909101e-02f, 2.61960290e-02f,
  -1.25805894e-02f, 6.47292808e-02f, 4.90786545e-02f, -7.34128198e-03f, 4.98834141e-02f, 2.91963834e-02f, 8.90948996e-02f, 8.93212333e-02f, 5.11713400e-02f, -2.24761497e-02f,
  -4.77902927e-02f, -2.94076558e-02f, 5.51308915e-02f, -9.28214267e-02f, -1.69692021e-02f, -6.47432264e-03f, 3.06707760e-03f, 7.93526415e-03f, 1.95216443e-02f, 6.65907338e-02f,
  2.78782472e-03f, -7.28310421e-02f, -5.97495474e-02f, 6.47490099e-02f, 6.14605546e-02f, -3.31969722e-03f, -8.16997662e-02f, 8.75601694e-02f, 1.18601779e-02f, 5.67812547e-02f,
  4.64129485e-02f, 1.09708585e-01f, 7.00500533e-02f, 5.24805747e-02f, 8.40533972e-02f, -4.23509516e-02f, -1.26685025e-02f, 7.67632481e-03f, 6.69551417e-02f, 8.10249448e-02f,
  -4.31471728e-02f, 6.36656061e-02f, -5.21316240e-03f, -1.46965561e-02f, 2.79343370e-02f, -8.96769166e-02f, -6.73204139e-02f, -2.57097813e-03f, 1.60580017e-02f, -4.76404205e-02f,
  -4.70692776e-02f, 6.12392537e-02f, 1.06587775e-01f, 1.15177326e-03f, 4.99170125e-02f, 1.70998890e-02f, -4.96976227e-02f, -6.28865883e-02f, 3.63125876e-02f, 4.73159850e-02f,
  1.80089157e-02f, -2.05322541e-03f, 1.38806835e-01f, 2.47658640e-02f, -4.54130732e-02f, 2.34013833e-02f, 8.11924189e-02f, 7.91359693e-02f, 6.06478378e-02f, -1.35003831e-02f,
  1.61558185e-02f, -7.52372891e-02f, -1.20235093e-01f, -2.17714012e-02f, 5.83779737e-02f, -6.76833764e-02f, -4.81294133e-02f, -7.68064186e-02f, 8.24765712e-02f, 6.87836930e-02f,
  -5.12046404e-02f, -5.21343620e-03f, 4.41934839e-02f, 2.89162043e-02f, 1.19820125e-02f, 5.92508493e-03f, -5.42765670e-03f, 8.62553939e-02f, 1.27160549e-02f, -4.07276936e-02f,
  5.89679666e-02f, -3.86068150e-02f, -4.66599129e-02f, -8.43628347e-02f, -6.25010207e-02f, -4.98944893e-02f, 3.49787949e-03f, 5.19436132e-03f, -2.51295138e-02f, 3.12531553e-02f,
  1.62981357e-02f, -7.73417130e-02f, 9.40707922e-02f, 5.93387149e-02f, 3.06164492e-02f, 2.92101745e-02f, 1.08297253e-02f, -7.58259445e-02f, 7.04861730e-02f, 3.96162048e-02f,
  9.37278122e-02f, 6.27470315e-02f, -1.00612625e-01f, -3.77134793e-02f, 2.13059597e-02f, 7.11874887e-02f, 3.62750776e-02f, -7.50139654e-02f, 2.34445333e-02f, -1.05428202e-02f,
  1.21204266e-02f, -5.84470965e-02f, -8.40225294e-02f, 5.01608523e-03f, 7.14032650e-02f, -9.45191905e-02f, 8.59840065e-02f, 3.43384445e-02f, 9.18507427e-02f, -2.17994675e-02f,
  -4.39858958e-02f, 4.16230857e-02f, 8.59999433e-02f, -2.68868599e-02f, 4.64526676e-02f, -5.63287251e-02f, 1.04564158e-02f, -6.40929565e-02f, 3.64002734e-02f, -5.59662916e-02f,
  1.98410265e-02f, -6.78468496e-02f, -6.51162770e-03f, -9.30025578e-02f, 7.07822219e-02f, 3.99718881e-02f, -1.32661602e-02f, 4.73425677e-03f, -7.04784766e-02f, 9.04115587e-02f,
  -1.29606843e-01f, -5.06788306e-02f, -8.06750283e-02f, 9.20136087e-03f, 2.39242669e-02f, 7.38359168e-02f, 5.07257916e-02f, 7.22320527e-02f, 2.63367984e-02f, 4.37111408e-02f,
  -2.68868115e-02f, 6.57756254e-02f, -1.23737557e-02f, 2.34704223e-02f, -4.77311872e-02f, 2.70412937e-02f, 8.61067921e-02f, 2.98989034e-04f, -6.24390803e-02f, -5.35028093e-02f,
  -3.61318290e-02f, 2.94416714e-02f, 8.72820430e-03f, 6.42685592e-02f, 6.67718127e-02f, -7.53543228e-02f, -5.10411672e-02f, -4.35367376e-02f, 3.57394181e-02f, -6.58084229e-02f,
  -1.59012750e-01f, -3.03389109e-03f, -1.76749453e-01f, 8.79043117e-02f, 4.67496254e-02f, 7.85287395e-02f, 2.15058438e-02f, 8.30081105e-02f, 2.46766508e-02f, 7.94947892e-02f,
  6.41339496e-02f, 2.68241623e-03f, 1.74723156e-02f, 1.89586490e-01f, -4.31067823e-03f, 6.56281635e-02f, 1.05639406e-01f, 6.81344271e-02f, 9.57574602e-03f, 7.40348548e-02f,
  -7.02892393e-02f, 1.62125602e-01f, -8.40422884e-02f, 8.41527283e-02f, 6.76432475e-02f, -5.03566191e-02f, 1.23810247e-01f, 2.22240575e-02f, -1.84312072e-02f, 6.43355548e-02f,
  -4.62588891e-02f, -3.40970084e-02f, 2.05448437e-02f, -6.66751564e-02f, -1.17065152e-02f, 6.57814601e-03f, -4.34715860e-02f, 1.27524119e-02f, 9.76192951e-03f, -6.51111454e-02f,
  -3.55629176e-02f, -2.78251264e-02f, -3.08045885e-03f, 7.29851425e-02f, -3.94806638e-02f, 5.39210923e-02f, 2.12590788e-02f, 8.03328231e-02f, -7.79675245e-02f, -2.98960302e-02f,
  -3.13949808e-02f, 8.00619423e-02f, 6.52030557e-02f, -1.46251414e-02f, 7.80006722e-02f, 2.71109622e-02f, -2.49081999e-02f, -2.68692840e-02f, -9.31978971e-02f, 7.22039416e-02f,
  -1.53812449e-02f, -8.25319588e-02f, 1.43023059e-02f, 4.47334647e-02f, 1.99349392e-02f, 2.33667064e-02f, -5.84305823e-03f, 5.48206270e-02f, 5.13331778e-03f, 9.21258032e-02f,
  6.44937437e-03f, -1.78975575e-02f, -4.70091589e-02f, -9.67692211e-02f, -8.07192922e-02f, -7.84703940e-02f, 2.22903546e-02f, -3.34982425e-02f, 2.57137790e-03f, -7.03822225e-02f,
  -2.73393299e-02f, -7.41287172e-02f, -2.65182946e-02f, -5.11230156e-02f, 7.31658936e-02f, -2.54566725e-02f, -2.77683027e-02f, 5.86637817e-02f, 5.12084961e-02f, -4.84500974e-02f,
  6.27329871e-02f, 8.26516449e-02f, -3.28136086e-02f, -2.44086478e-02f, -1.70933511e-02f, -5.04459962e-02f, -3.72463204e-02f, 1.17400931e-02f, -7.74144679e-02f, 3.41705792e-02f,
  3.34819257e-02f, 4.04632129e-02f, 1.97659303e-02f, 4.59229806e-03f, -7.01144859e-02f, 9.85364616e-02f, -5.04198261e-02f, 7.35612214e-02f, 8.51739720e-02f, -5.83845936e-02f,
  -3.49938795e-02f, -2.00815927e-02f, -4.93746698e-02f, -2.83489190e-02f, 9.51413065e-02f, 6.25895895e-03f, -2.95623615e-02f, -3.30917351e-02f, 5.71209639e-02f, 5.99464476e-02f,
  3.13255452e-02f, -5.36378287e-02f, -2.04032630e-01f, -1.42927229e-01f, -2.34101534e-01f, 1.60306558e-01f, 1.94235027e-01f, -2.25285873e-01f, -3.65467191e-01f, 5.26747294e-03f,
  8.73726308e-02f, -6.73285872e-02f, 1.42228320e-01f, 1.49847388e-01f, 5.99548519e-02f, 2.80110717e-01f, 1.57848567e-01f, 1.13133311e-01f, 8.66329949e-03f, -3.34709734e-02f,
  -1.16328850e-01f, 7.39110783e-02f, 1.92620471e-01f, -4.71025333e-02f, -4.51580733e-02f, -1.59585595e-01f, -2.85366438e-02f, 1.85051952e-02f, -5.05290702e-02f, -1.18708782e-01f,
  1.79348633e-01f, 5.54883741e-02f, 3.12883081e-03f, 3.25866155e-02f, 6.32074624e-02f, -3.12903039e-02f, 8.90089422e-02f, 8.65625441e-02f, -8.12469721e-02f, -2.28468645e-02f,
  7.26888925e-02f, -1.07560389e-01f, -2.56670144e-04f, -1.00180255e-02f, -1.10158019e-01f, -7.14835599e-02f, -9.30347368e-02f, -8.85494500e-02f, -2.81980634e-02f, 6.37917370e-02f,
  -4.00914699e-02f, -2.63078623e-02f, 3.55672720e-03f, 2.28392072e-02f, -1.15332708e-01f, -9.49439481e-02f, 4.67789248e-02f, 2.30262242e-03f, 5.88966757e-02f, -2.10934412e-02f,
  -8.56041312e-02f, 1.24554271e-02f, -8.00380204e-03f, -3.82930040e-02f, -9.02165174e-02f, 1.04721166e-01f, -3.41383815e-02f, 2.41716262e-02f, -1.12291940e-01f, 2.65059005e-02f,
  -1.68139786e-02f, -5.48658930e-02f, -3.42739895e-02f, 5.49299223e-03f, -8.45936835e-02f, 1.14111379e-02f, -4.69873250e-02f, 1.67885851e-02f, -6.89349603e-03f, 5.44605218e-02f,
  -7.22585246e-02f, -7.34697953e-02f, 8.03583302e-03f, 2.54903417e-02f, 4.37067449e-02f, -7.17046037e-02f, -7.05836527e-03f, 8.63685608e-02f, 5.79257123e-02f, 1.15985777e-02f,
  3.71856615e-02f, -8.05496946e-02f, 5.74482195e-02f, 7.12264795e-03f, 7.70115033e-02f, 8.02100003e-02f, -7.95347989e-02f, -4.43028323e-02f, -2.71871667e-02f, -1.98104624e-02f,
  -3.62773724e-02f, -6.03269599e-02f, -6.84499517e-02f, -5.70593998e-02f, -1.28267314e-02f, 5.05065471e-02f, 8.97281319e-02f, -3.55842300e-02f, 2.07830500e-03f, -3.95199135e-02f,
  1.88089106e-02f, -2.08782405e-02f, -1.00431755e-01f, 2.89704651e-02f, -4.16225791e-02f, -2.75820959e-02f, -2.25091390e-02f, 4.75795791e-02f, 1.96037889e-02f, -6.19280264e-02f,
  -8.80945846e-02f, -6.58368245e-02f, -1.19042940e-01f, -1.96211249e-01f, -1.36879338e-02f, 1.92372743e-02f, -4.14832756e-02f, 5.32486439e-02f, -1.46941897e-02f, 1.33695945e-01f,
  -4.56592999e-02f, 1.50971273e-02f, 5.55882417e-02f, -2.54311040e-02f, -4.93821725e-02f, 5.76056242e-02f, -9.55084562e-02f, 1.26519836e-02f, -1.17987052e-01f, -2.35105753e-02f,
  -3.64273973e-02f, -7.70529208e-04f, -6.70087636e-02f, -2.31540613e-02f, -8.85181576e-02f, -6.30634055e-02f, 5.75718880e-02f, -5.19800112e-02f, -5.99885322e-02f, -2.18692943e-02f,
  -4.76515368e-02f, 5.87851852e-02f, 6.89327940e-02f, 8.76053423e-02f, 7.56306946e-02f, -5.89329787e-02f, -1.43581927e-02f, -7.57718682e-02f, -4.08024713e-02f, -1.02472270e-03f,
  -9.26391333e-02f, -1.95739735e-02f, 1.40618607e-02f, -1.78705901e-02f, -4.62372191e-02f, 8.38112161e-02f, -6.83355257e-02f, -4.73872051e-02f, 2.95555983e-02f, -6.18767664e-02f,
  -1.12478286e-02f, 1.13580655e-02f, -4.65805903e-02f, 6.22105710e-02f, -7.79617354e-02f, -8.44681859e-02f, 1.87264439e-02f, 3.42746899e-02f, 2.22022515e-02f, 5.32310717e-02f,
  -1.14537396e-01f, -6.71901368e-03f, -3.60749252e-02f, 4.78979424e-02f, 2.22996604e-02f, -1.94384847e-02f, -1.73847768e-02f, 1.83150787e-02f, -1.60012878e-02f, -2.25349348e-02f,
  6.84412718e-02f, 1.48411943e-02f, 5.73897138e-02f, 1.23635000e-02f, -1.88621152e-02f, 4.31513414e-02f, -4.90166713e-03f, -3.08850240e-02f, -8.89012665e-02f, -2.56415661e-02f,
  6.59526736e-02f, 7.90221468e-02f, 8.40801075e-02f, 3.17105316e-02f, 2.17814147e-02f, 3.57107795e-03f, 2.46344451e-02f, -7.65807868e-04f, 1.92399193e-02f, -4.65841405e-02f,
  8.39144960e-02f, -4.00117859e-02f, 9.09352824e-02f, -3.39783020e-02f, 8.33417103e-02f, 2.81569585e-02f, 5.29029742e-02f, -8.99304301e-02f, -5.14485389e-02f, 4.54849005e-02f,
  7.00524002e-02f, 4.29883339e-02f, -6.77770842e-03f, 3.04406621e-02f, 3.78156938e-02f, 8.29119086e-02f, 5.50192967e-02f, -8.80559906e-02f, 1.20124929e-02f, -6.98799118e-02f,
  4.36792448e-02f, -5.47948927e-02f, 6.20095655e-02f, -6.23442158e-02f, 3.16641629e-02f, 1.03932671e-01f, -9.04928241e-03f, -7.24124387e-02f, -9.22047421e-02f, -6.59542978e-02f,
  1.61243126e-01f, -3.20400536e-01f, -1.32867664e-01f, 1.25459999e-01f, 2.40163088e-01f, 1.88968387e-02f, 5.35904802e-02f, 7.89840647e-04f, 3.32345031e-02f, -1.50321156e-01f,
  3.28156017e-02f, -2.96671805e-03f, -1.85090646e-01f, 8.27496201e-02f, 1.96856081e-01f, -1.39030457e-01f, 4.18730341e-02f, 2.28431280e-04f, -2.79828925e-02f, -5.69825098e-02f,
  7.49593005e-02f, 2.13886768e-01f, 1.13821059e-01f, 1.05623059e-01f, 2.15715006e-01f, -3.36858816e-02f, 1.28043637e-01f, 4.46390025e-02f, 1.96807012e-01f, 1.09612994e-01f,
  4.14915122e-02f, 3.09202317e-02f, -3.70397717e-02f, -6.15567341e-03f, -3.60715538e-02f, -2.45272294e-02f, -2.35867035e-02f, 9.53281447e-02f, 3.39009389e-02f, -2.09372640e-02f,
  -3.72774079e-02f, 1.04035065e-01f, 6.82306811e-02f, 7.44659081e-02f, 5.15973680e-02f, 6.51183575e-02f, -3.17758671e-03f, -5.75849004e-02f, -2.88124289e-02f, -7.22689182e-02f,
  -1.38857082e-01f, -3.52657139e-02f, 6.93393201e-02f, 6.79989159e-02f, -1.10319301e-01f, -4.46310006e-02f, -7.83464983e-02f, -3.67047964e-03f, -1.89634170e-02f, -7.93425888e-02f,
  2.49822217e-04f, -3.66535187e-02f, -7.55926520e-02f, 6.82431683e-02f, 2.49639228e-02f, 4.89582680e-02f, 5.59976064e-02f, -9.59363431e-02f, 2.20823344e-02f, 3.54104526e-02f,
  -4.35411446e-02f, 2.09895186e-02f, -2.10706405e-02f, -9.53257307e-02f, 4.87324223e-02f, -6.64441213e-02f, 1.09069878e-02f, -5.97530976e-02f, -4.57405187e-02f, 3.97284739e-02f,
  5.24027199e-02f, -2.27203406e-02f, -4.51766737e-02f, 8.97103101e-02f, 2.81085279e-02f, 2.80244164e-02f, 1.13506643e-02f, -6.25518560e-02f, 3.31994668e-02f, -5.93564399e-02f,
  1.87285971e-02f, -1.54113352e-01f, 2.70412844e-02f, -1.34250643e-02f, -9.95388925e-02f, -4.02953997e-02f, 1.07025178e-02f, 5.36894687e-02f, -5.13684079e-02f, -9.77104008e-02f,
  -1.70701426e-02f, -7.54907448e-03f, -3.22950408e-02f, 4.55487408e-02f, 8.58534649e-02f, -5.11191376e-02f, 3.27794143e-04f, 7.37514049e-02f, 7.43340030e-02f, -1.77112129e-02f,
  -1.81258786e-02f, -4.47762087e-02f, -2.48712711e-02f, -4.04406227e-02f, 2.87676658e-02f, -1.09402174e-02f, -4.36462462e-03f, -1.08624876e-01f, -8.88762325e-02f, -1.64099410e-02f,
  -7.32695237e-02f, -1.07847035e-01f, -1.57522038e-01f, -1.51812807e-01f, 9.28023160e-02f, -8.42478871e-02f, -1.61276057e-01f, -4.86167744e-02f, -9.88526046e-02f, 9.07428563e-02f,
  1.41364231e-04f, -6.90808743e-02f, -3.46525498e-02f, -9.05582085e-02f, -2.75741634e-03f, -6.52065650e-02f, -3.84456366e-02f, -4.42931615e-02f, -6.48339912e-02f, -4.58683297e-02f,
  7.64094070e-02f, -1.27605006e-01f, -2.77891401e-02f, -3.60146351e-02f, -1.35402441e-01f, -4.11493406e-02f, 1.05225593e-01f, 5.44310138e-02f, -4.95434441e-02f, -7.51194805e-02f,
  -7.57378116e-02f, -6.95904121e-02f, 1.15205254e-02f, -3.56400870e-02f, -5.07805906e-02f, 7.15849251e-02f, -4.40505296e-02f, -2.61797067e-02f, 3.36831249e-02f, -7.35817701e-02f,
  -5.85145429e-02f, -1.05070844e-02f, -1.70648098e-02f, 4.42618206e-02f, -2.70721279e-02f, 6.01142794e-02f, -7.25282505e-02f, -4.44230139e-02f, 4.12193546e-03f, 2.20379308e-02f,
  1.15025239e-02f, -1.51168406e-02f, 7.50261098e-02f, -4.65589762e-02f, -1.99322589e-02f, 1.29431242e-03f, 5.26543669e-02f, 9.45859179e-02f, -6.07045256e-02f, -2.53104186e-03f,
  6.06110203e-04f, 5.82810789e-02f, -2.79028416e-02f, -8.10826197e-02f, -1.75753180e-02f, 1.76476277e-02f, 1.12609798e-02f, 3.28059564e-03f, 3.69784534e-02f, 5.83890975e-02f,
  2.91948840e-02f, -3.59003209e-02f, 4.20577154e-02f, -7.01866150e-02f, -6.55935565e-03f, -7.36975819e-02f, -4.30454090e-02f, -7.00476244e-02f, -4.52176891e-02f, 8.05609953e-03f,
  -6.21144883e-02f, -7.00436458e-02f, -4.47967201e-02f, -4.11444493e-02f, -6.76054955e-02f, -7.29116565e-03f, 3.79684344e-02f, 2.35694507e-03f, -1.65361464e-02f, -3.91448513e-02f,
  4.07119514e-03f, -7.18366308e-03f, -5.74366674e-02f, -5.44402488e-02f, -5.50862513e-02f, 3.98086905e-02f, -6.62042648e-02f, 1.36770615e-02f, 6.78005815e-02f, -8.78567025e-02f,
  8.30342621e-02f, -6.60022488e-03f, -3.64013948e-03f, -6.03445172e-02f, -8.93851295e-02f, -5.34184575e-02f, 3.21607366e-02f, -4.42644469e-02f, -5.38961254e-02f, -1.48828896e-02f,
  -3.24728787e-02f, -2.25707982e-02f, -8.73134956e-02f, 6.99436292e-02f, 8.79632831e-02f, 2.73992550e-02f, 9.26023647e-02f, 4.54133609e-03f, 3.48806232e-02f, 7.45801851e-02f,
  -5.31211160e-02f, 1.33943811e-01f, -1.36921636e-03f, 1.00471206e-01f, 1.17323138e-01f, 1.34531036e-01f, 1.31168067e-01f, 6.70654029e-02f, 2.34860852e-02f, 1.32863939e-01f,
  2.40290221e-02f, 1.76936830e-03f, 2.39101686e-02f, 1.45232171e-01f, 8.22909996e-02f, 3.49167623e-02f, 1.51603013e-01f, 3.68699394e-02f, -7.82202277e-03f, -2.85093132e-02f,
  3.38604711e-02f, 1.00482769e-01f, -1.47368899e-02f, -1.38116349e-02f, -4.62869145e-02f, -1.61007434e-01f, -7.07446085e-03f, -6.54097572e-02f, -1.31276427e-02f, -2.36363132e-02f,
  1.08077573e-02f, -8.37306231e-02f, -4.23271880e-02f, 3.94069217e-02f, 5.59219792e-02f, -8.21475908e-02f, -4.46069725e-02f, 6.82557523e-02f, 1.11107118e-02f, 1.94791090e-02f,
  -7.28840008e-02f, -3.62831764e-02f, 7.73642287e-02f, -5.01201861e-02f, -7.41357170e-03f, -1.37565294e-02f, -6.42832965e-02f, -7.74614438e-02f, -6.08998127e-02f, -6.22709617e-02f,
  4.08623293e-02f, 3.40534444e-03f, 1.06778126e-02f, 3.76264714e-02f, -4.17995714e-02f, -1.12425825e-02f, 2.40155961e-03f, -2.04927451e-03f, 5.57460524e-02f, 4.36785398e-03f,
  -6.06358843e-03f, 5.77184260e-02f, -6.73238840e-03f, 4.21090983e-02f, -4.38443720e-02f, -3.82594429e-02f, 7.38598639e-03f, -8.90596882e-02f, -2.74483133e-02f, 3.70174982e-02f,
  6.99005872e-02f, -9.67400731e-04f, 1.43096421e-03f, -8.21276680e-02f, 4.84290570e-02f, 9.94192213e-02f, 2.54036654e-02f, -5.42470813e-02f, -9.81375854e-03f, -1.60448216e-02f,
  4.41513136e-02f, -7.06633180e-02f, -3.40357311e-02f, 2.63236985e-02f, 1.80383530e-02f, -5.50762825e-02f, 6.58592060e-02f, -2.37365235e-02f, -6.54851422e-02f, 4.93402071e-02f,
  1.26657084e-01f, 6.30124286e-02f, 2.74634194e-02f, 5.46681210e-02f, -1.89875048e-02f, 5.04306331e-02f, 8.28299299e-02f, 2.20033005e-02f, -4.42082807e-02f, -6.99382052e-02f,
  -3.71031053e-02f, 4.49287519e-02f, 7.18498826e-02f, 4.51524518e-02f, -1.24366051e-02f, 3.48162837e-02f, -9.67659503e-02f, -2.80026980e-02f, 3.33488993e-02f, 3.80627019e-03f,
  -6.27666265e-02f, 4.17269580e-02f, 3.94500932e-03f, 3.50703718e-03f, 4.97454889e-02f, -4.17105900e-03f, -5.59648760e-02f, -9.93330851e-02f, -2.06026789e-02f, -5.15240617e-02f,
  -3.14440876e-02f, -5.23177441e-03f, 9.10654739e-02f, 1.53834261e-02f, 6.34712800e-02f, 1.01213485e-01f, 9.20191407e-02f, 3.37495580e-02f, 1.01786278e-01f, -8.91336650e-02f,
  -1.04008824e-01f, 3.66665386e-02f, -1.84131379e-04f, 9.65026394e-03f, -8.30880925e-02f, -1.47300120e-02f, 7.71162519e-03f, -9.19375718e-02f, 1.17324442e-01f, 4.01188619e-02f,
  -3.62566784e-02f, -2.28469595e-02f, 2.14924919e-03f, -8.24039131e-02f, 8.09457526e-03f, 6.57163635e-02f, -1.27466604e-01f, 1.03787825e-01f, -6.53092936e-02f, -3.81113328e-02f,
  -2.75345817e-02f, 1.38987541e-01f, -3.38871926e-02f, -8.75651895e-04f, 4.66334559e-02f, 2.54622046e-02f, -3.50347757e-02f, 5.59586473e-02f, -2.40224935e-02f, -8.34058002e-02f,
  -2.45593619e-02f, -9.82417986e-02f, 4.80938815e-02f, -3.19709303e-03f, 1.11700714e-01f, 5.36220409e-02f, 7.79493302e-02f, 7.53755793e-02f, 9.27251950e-02f, 3.63026559e-02f,
  2.32659485e-02f, -1.94297675e-02f, 3.37145850e-02f, -1.25451293e-02f, 1.46883614e-02f, 2.57725306e-02f, 3.40262055e-02f, -8.34029913e-02f, -1.26961432e-02f, 4.61362563e-02f,
  7.39905015e-02f, 1.07679833e-02f, -4.25415970e-02f, 8.31079260e-02f, 1.40842991e-02f, -1.08242594e-01f, -7.75145814e-02f, -6.39271457e-03f, -8.58099312e-02f, -2.50214934e-02f,
  4.62535545e-02f, 4.73794676e-02f, 4.34047431e-02f, -7.41307735e-02f, 2.30026506e-02f, -7.11730197e-02f, -2.60731783e-02f, 2.90123653e-02f, -4.99112606e-02f, -1.31784845e-02f,
  9.00897011e-02f, -3.89011875e-02f, -6.34507975e-03f, -2.00855155e-02f, -6.43453225e-02f, 4.25338447e-02f, -4.77356911e-02f, -5.56806326e-02f, 6.13547936e-02f, 1.06182015e-02f,
  -6.16947897e-02f, -4.58092839e-02f, 4.21382152e-02f, 2.88578998e-02f, -6.62070736e-02f, -6.40102997e-02f, 6.95744157e-02f, -4.37875539e-02f, -2.55385339e-02f, -4.91763055e-02f,
  -1.32661119e-01f, 1.67991072e-02f, -6.36250339e-03f, -1.71381999e-02f, -1.01261027e-01f, 5.56663200e-02f, -4.34197187e-02f, -5.76586183e-03f, 1.24686835e-02f, -1.00781042e-02f,
  -4.11081351e-02f, 4.66172658e-02f, -2.02167239e-02f, -1.09139338e-01f, 8.10327474e-03f, -7.46921776e-03f, -8.30830187e-02f, 7.37123936e-02f, -2.17705518e-02f, 9.61603504e-03f,
  2.16757089e-01f, -1.49543181e-01f, 1.39636751e-02f, 7.76647627e-02f, 9.00762975e-02f, 1.45909209e-02f, -6.00220934e-02f, 2.02028989e-03f, 1.44597918e-01f, -1.96544275e-01f,
  -1.74078234e-02f, -6.33322150e-02f, -6.56179786e-02f, -1.19361065e-01f, 2.08384454e-01f, -1.12223681e-02f, -1.17402017e-01f, -9.53098908e-02f, 8.25855061e-02f, -6.25206381e-02f,
  7.29792863e-02f, -1.62560213e-02f, -9.82792974e-02f, -1.14855096e-01f, -9.89599675e-02f, 1.20310336e-02f, -8.01017582e-02f, -1.55790165e-01f, -1.98751971e-01f, -3.90064828e-02f,
  4.49409895e-02f, -2.80588437e-02f, 4.52464931e-02f, -1.13640897e-01f, -3.58519256e-02f, 4.46309848e-03f, -9.13234428e-02f, -5.50571829e-02f, -8.18647146e-02f, 1.04497112e-02f,
  1.96918547e-02f, -9.01341215e-02f, 8.99110455e-03f, 1.13688456e-02f, -1.21620810e-02f, 4.37166393e-02f, 1.41386567e-02f, 6.15921803e-02f, -9.53457281e-02f, 6.09411001e-02f,
  5.19724451e-02f, -3.11194807e-02f, 7.20802993e-02f, -1.10394605e-01f, 3.89571041e-02f, -1.52817294e-02f, 8.09300169e-02f, 5.88329174e-02f, 6.60558045e-02f, 4.76318933e-02f,
  -1.03429921e-01f, 7.81383365e-02f, -1.55501831e-02f, 3.58308665e-02f, -4.45025181e-03f, 2.07640305e-02f, -7.37384558e-02f, -1.68407001e-02f, 2.89506428e-02f, -8.47612135e-03f,
  1.71364713e-02f, -1.84369739e-02f, -6.12219609e-03f, 3.50681916e-02f, 7.09452406e-02f, 7.87421167e-02f, -3.58804315e-02f, 2.50856695e-03f, -5.07012978e-02f, 3.65305506e-02f,
  2.51355898e-02f, 3.58975045e-02f, -7.22289607e-02f, 4.71295090e-03f, 4.81399447e-02f, -4.99319546e-02f, -7.25734308e-02f, 4.58240919e-02f, 4.40891013e-02f, 1.28513901e-02f,
  -1.27635626e-02f, -1.54454648e-01f, -1.21705517e-01f, -5.00683077e-02f, -8.05660114e-02f, 2.88493875e-02f, -4.61396836e-02f, -1.32597601e-02f, -1.00483738e-01f, -1.05224989e-01f,
  -4.53971140e-02f, 1.10431965e-02f, -8.04366171e-02f, -7.02115744e-02f, 4.08579260e-02f, -7.41613135e-02f, -7.91734159e-02f, -7.66908079e-02f, 2.91431230e-02f, -9.19804126e-02f,
  2.07362995e-02f, -5.44003844e-02f, 2.27291137e-02f, 4.58688326e-02f, -6.01753518e-02f, -2.45303158e-02f, 6.92271218e-02f, -7.75964232e-03f, -2.16547046e-02f, -6.60695061e-02f,
  -4.62834865e-01f, 2.15410754e-01f, 9.62293968e-02f, -9.08561125e-02f, 1.56426709e-02f, 8.17132592e-02f, 3.02194208e-02f, -1.05573274e-01f, -1.50032401e-01f, -2.33650487e-02f,
  1.69140268e-02f, -1.44765705e-01f, 7.32974038e-02f, -1.35965869e-02f, -3.49515229e-02f, 1.93436772e-01f, -4.24477868e-02f, -1.11833110e-01f, 1.47624597e-01f, -5.94216622e-02f,
  -1.22344000e-02f, 1.14885420e-01f, 9.97436792e-02f, 1.04449466e-01f, -3.29102129e-02f, -1.59298748e-01f, -1.84800141e-02f, 1.17767170e-01f, -2.97285095e-02f, 3.38571854e-02f,
  -2.17775945e-02f, -1.25114769e-01f, -1.82563126e-01f, -8.02265704e-02f, -9.83775035e-02f, -3.29426527e-02f, -1.35529339e-01f, 6.48655172e-04f, -2.68848371e-02f, -2.07130462e-02f,
  -7.48554468e-02f, -6.27873186e-03f, -3.26528251e-02f, -3.54589848e-03f, -3.35076898e-02f, -8.48684087e-03f, 9.54511538e-02f, 1.67720690e-02f, 1.84994973e-02f, 7.99560174e-02f,
  6.22163750e-02f, -2.40093675e-02f, -4.78393547e-02f, 6.80816174e-03f, 3.74989696e-02f, 3.63989547e-02f, 2.99484860e-02f, 4.92804013e-02f, -5.47796823e-02f, -8.35937858e-02f,
  -1.25303091e-02f, 7.15521872e-02f, -1.90748051e-02f, -2.78058182e-02f, 7.24285468e-02f, -3.12811472e-02f, 3.56721692e-02f, -9.36356708e-02f, 4.90139425e-02f, -4.73102443e-02f,
  -2.70200241e-02f, -1.22837694e-02f, -1.15471356e-01f, 4.09263931e-02f, 8.78150575e-03f, 3.13585475e-02f, 4.84264493e-02f, -7.49015361e-02f, -1.48517443e-02f, 2.78663281e-02f,
  2.99296472e-02f, -1.14110680e-02f, -5.63076064e-02f, 2.76345368e-02f, -8.95774066e-02f, 5.92002925e-03f, 1.96491778e-02f, -4.75677587e-02f, -3.34887058e-02f, -4.05601561e-02f,
  -2.39729762e-01f, -1.38790414e-01f, 1.62333008e-02f, -5.91527261e-02f, 2.84104645e-02f, -4.04738300e-02f, -2.48931162e-02f, 1.40775936e-02f, -1.40636247e-02f, -3.05579808e-02f,
  -1.64259691e-02f, -4.47194017e-02f, 1.27535965e-02f, -5.18097216e-03f, 1.50519414e-02f, -4.42117862e-02f, 4.47930694e-02f, 3.62525843e-02f, -2.89616846e-02f, -8.97040740e-02f,
  -1.09960638e-01f, -7.66624743e-03f, 5.09184356e-05f, -4.85588834e-02f, -4.72986931e-03f, -1.85793415e-02f, -3.34139690e-02f, -1.41874840e-02f, -6.82959259e-02f, 6.01069778e-02f,
  -1.39142334e-01f, 1.12491526e-01f, -1.15368329e-01f, 5.20393858e-03f, 1.81582600e-01f, 1.01723351e-01f, 1.56076834e-01f, -4.88467375e-03f, 9.80094150e-02f, 1.02921106e-01f,
  7.82022923e-02f, -4.29938994e-02f, -5.94950952e-02f, -1.16695892e-02f, -7.37484172e-02f, -3.79066989e-02f, 1.19469084e-01f, 4.79728691e-02f, 3.13127078e-02f, -2.42517702e-02f,
  -4.43708003e-02f, -4.08781469e-02f, -1.25418708e-01f, -1.08127013e-01f, -5.29079102e-02f, 5.52630052e-02f, -3.50403488e-02f, 2.83466615e-02f, -4.46488298e-02f, -3.57335992e-02f,
  4.15640175e-02f, 6.02937117e-02f, -7.55219981e-02f, -1.48196882e-02f, 2.63072010e-02f, -3.78093235e-02f, 1.05753373e-02f, -2.44902112e-02f, -2.10383944e-02f, 9.54357758e-02f,
  -2.52650939e-02f, -6.13390766e-02f, -4.05487232e-02f, -5.77465072e-02f, 5.30889519e-02f, 3.27396169e-02f, 7.76638556e-03f, 4.61476743e-02f, -8.53560343e-02f, -3.91508788e-02f,
  3.11954618e-02f, 8.68586451e-02f, 3.90742393e-03f, 7.56538510e-02f, -6.78387880e-02f, 5.07795066e-02f, -3.61650735e-02f, 1.69631205e-02f, 5.97358532e-02f, 1.04749463e-01f,
  7.01268986e-02f, 9.27215293e-02f, -9.38488171e-02f, -1.06030637e-02f, 3.63102891e-02f, 8.97226948e-03f, 1.39348526e-02f, 8.86508077e-02f, 7.14636073e-02f, -5.27770668e-02f,
  -2.76236124e-02f, 4.69122753e-02f, -3.76116559e-02f, 3.33488062e-02f, 7.85235539e-02f, -3.38705182e-02f, -3.43343578e-02f, -5.28473035e-02f, 3.68563943e-02f, -4.53664847e-02f,
  -3.19432132e-02f, -3.17863822e-02f, 6.18371665e-02f, 5.93907237e-02f, 6.06497936e-02f, 1.58424098e-02f, 9.18716341e-02f, 6.80384040e-02f, -8.15630332e-02f, 4.10142504e-02f,
  7.30483904e-02f, 1.68321863e-01f, -3.37534398e-02f, 6.63914112e-03f, -5.59508950e-02f, -3.52729000e-02f, 7.54404515e-02f, -2.70819627e-02f, 3.79284695e-02f, 3.17514874e-02f,
  6.42560720e-02f, 1.50300572e-02f, 1.04133496e-02f, -3.23225670e-02f, -6.27446324e-02f, 1.34456931e-02f, 3.91074568e-02f, -5.38598001e-02f, 3.70458812e-02f, -8.27283263e-02f,
  -5.19373417e-02f, -1.35350320e-02f, 3.82767320e-02f, 5.08225476e-03f, 1.35307079e-02f, -3.41588259e-02f, 2.58092936e-02f, 4.39900942e-02f, 4.33169007e-02f, -9.89876129e-03f,
  3.90410833e-02f, 5.43690138e-02f, 1.28370365e-02f, 7.14423433e-02f, -2.06631906e-02f, -1.60539553e-01f, -6.52099028e-02f, 7.82645047e-02f, -6.00576075e-03f, -1.37285531e-01f,
  1.31981401e-02f, -1.89950727e-02f, -7.38662854e-02f, 5.85475285e-03f, 5.96779734e-02f, -1.56473108e-02f, 1.32602200e-01f, 6.49570823e-02f, 1.66104902e-02f, 1.33711398e-01f,
  1.83416590e-01f, -2.36301450e-03f, 1.79097697e-01f, 4.95606549e-02f, 6.53721541e-02f, 1.57442465e-01f, 1.89626738e-01f, -8.18716213e-02f, 1.48204282e-01f, 1.70888975e-02f,
  -1.18044475e-02f, 4.06520627e-02f, -4.55589630e-02f, -6.23065382e-02f, -1.24242054e-02f, 2.40784641e-02f, -1.02610797e-01f, 1.81625541e-02f, 5.57673648e-02f, -5.94437048e-02f,
  -9.85800400e-02f, -2.62187514e-02f, -2.74816081e-02f, -3.00112013e-02f, 5.31281382e-02f, 3.59726744e-03f, 8.62978026e-02f, 5.96636981e-02f, 3.93318497e-02f, -2.30651554e-02f,
  -2.68122479e-02f, -4.20859009e-02f, -2.80400980e-02f, 3.21191810e-02f, 1.10749401e-01f, 3.63751389e-02f, 1.17032807e-02f, 1.55243855e-02f, -1.32795339e-02f, 7.10460022e-02f,
  -5.92250726e-04f, -6.95314184e-02f, -3.90296541e-02f, 7.31104845e-03f, 6.62477016e-02f, 1.19201429e-01f, 7.60588795e-02f, -2.13348158e-02f, 2.73289792e-02f, 4.29086573e-02f,
  2.23663077e-02f, -6.16056891e-03f, 6.48734495e-02f, -1.25765935e-01f, 7.59255812e-02f, -1.00936092e-01f, -8.17871913e-02f, -1.87747553e-02f, -1.65064447e-02f, -6.62918985e-02f,
  1.24621298e-02f, 3.33108678e-02f, 9.17585939e-02f, 1.68966334e-02f, -8.75159353e-02f, 6.64465502e-02f, -1.43115167e-02f, -4.93656360e-02f, 6.91708252e-02f, 5.52585088e-02f,
  7.74774030e-02f, 1.46457598e-01f, 4.27246615e-02f, 1.14301704e-02f, 8.52433741e-02f, -4.46312316e-03f, -5.81978671e-02f, 4.51703966e-02f, 5.54394536e-02f, -4.00991589e-02f,
  -2.99953017e-02f, -7.18163177e-02f, -1.85605586e-02f, 1.03117339e-01f, -5.62151372e-02f, -9.38015617e-03f, 1.42156286e-02f, 6.32715076e-02f, 6.74567372e-02f, 2.30551008e-02f,
  -1.05011687e-02f, -7.93541744e-02f, -6.49856478e-02f, 1.89703349e-02f, -3.71321999e-02f, -9.56534222e-02f, -3.84890102e-02f, 6.10371009e-02f, 1.34211937e-02f, 9.67881233e-02f,
  -7.93887228e-02f, -1.55364752e-01f, -3.37743849e-01f, -1.78526029e-01f, 7.07573891e-02f, -2.27837279e-01f, -1.70538485e-01f, -7.96939153e-03f, -1.31761238e-01f, 1.02961898e-01f,
  -3.90102528e-02f, -7.66408667e-02f, 7.95772895e-02f, -3.01039606e-01f, -1.85553074e-01f, -7.33317733e-02f, -1.84717253e-01f, -1.25120748e-02f, -1.15808479e-01f, -1.61581337e-01f,
  -2.51794420e-02f, -5.10396212e-02f, -2.68890828e-01f, 8.24107602e-03f, -2.11083546e-01f, -2.93740239e-02f, 1.91117361e-01f, 1.57414861e-02f, 3.43282730e-03f, -6.26769289e-02f,
  -7.75571689e-02f, -1.05202779e-01f, -2.71326862e-02f, -1.82141997e-02f, 1.44115584e-02f, 6.68391213e-02f, 7.44073763e-02f, -6.62522465e-02f, 5.24896272e-02f, 6.55031949e-02f,
  -1.97194964e-02f, 4.87390198e-02f, -6.59530908e-02f, -1.79072917e-02f, 3.89679745e-02f, 1.54005354e-02f, -9.95802879e-02f, 8.96397326e-03f, -1.24929897e-01f, -7.50267655e-02f,
  -1.46611542e-01f, 2.37542111e-02f, -8.11762176e-03f, 6.20334744e-02f, -1.24758981e-01f, -5.80374226e-02f, 4.26035263e-02f, -2.52271555e-02f, -3.00622322e-02f, 9.63229965e-03f,
  5.06387427e-02f, 6.79689422e-02f, -1.81078948e-02f, -1.50792431e-02f, -7.02707469e-02f, -3.95053588e-02f, -4.60750423e-02f, 3.00422478e-02f, 6.32874575e-03f, 9.85819846e-02f,
  -3.93072143e-02f, -6.02992587e-02f, -1.24705238e-02f, 3.77412587e-02f, 2.21394282e-03f, -5.68450205e-02f, 4.43807021e-02f, 7.21085668e-02f, -3.23442183e-02f, 5.72134331e-02f,
  -3.27274464e-02f, 6.27070367e-02f, -1.09863617e-02f, 3.31589323e-03f, -2.80972607e-02f, 5.40543944e-02f, 6.48791417e-02f, -5.76110091e-03f, 1.55461151e-02f, 7.79262185e-03f,
  9.78592113e-02f, 5.41448360e-03f, 3.56568843e-02f, 4.16551121e-02f, 1.04143851e-01f, 6.46643667e-03f, -6.89416938e-03f, -5.73987402e-02f, -4.03445438e-02f, -8.06576833e-02f,
  1.10825956e-01f, 8.94520208e-02f, 4.45739105e-02f, 6.95733875e-02f, 1.84597727e-02f, 2.89285323e-03f, 2.79831234e-02f, 1.30338939e-02f, 2.81821266e-02f, -3.66821070e-03f,
  -2.99091358e-02f, 1.30315553e-02f, 7.26965815e-02f, -5.11505129e-03f, -2.56480556e-03f, 8.33883211e-02f, -3.48297954e-02f, 1.88302025e-02f, 2.51014419e-02f, -7.02241585e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 52)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 52;
const float L0_fan_Bp_bar_data[] = {
  1.47204041e-01f, 4.27497365e-02f, 1.03281900e-01f, 1.35076806e-01f, 9.72317830e-02f, -8.38848725e-02f, 1.05040953e-01f, 4.97213490e-02f, -4.18528691e-02f, 2.02527251e-02f,
  8.32664967e-03f, -2.16665235e-03f, -7.28341425e-03f, 4.53231391e-03f, 2.09910739e-02f, 1.07951403e-01f, -4.96055335e-02f, -2.35693553e-03f, 2.76381453e-03f, 6.04701601e-02f,
  9.38295349e-02f, 1.38418615e-01f, -2.00291425e-02f, 1.34661466e-01f, -3.43550667e-02f, -1.39026381e-02f, 7.19493851e-02f, 6.52363431e-03f, 5.93300760e-02f, 8.64215791e-02f,
  1.38976842e-01f, 4.83579449e-02f, 1.21844508e-01f, 8.75492916e-02f, 6.92134798e-02f, -1.50423823e-02f, 2.16305107e-01f, 1.04023255e-01f, -6.98318705e-02f, 9.40949190e-03f,
  1.27811104e-01f, 1.47002578e-01f, 7.70266429e-02f, 3.58503312e-02f, 1.15719892e-01f, 1.70448311e-02f, 6.54628873e-02f, 1.40541777e-01f, 1.27655566e-01f, 8.41724426e-02f,
  9.68394428e-02f, 3.04434113e-02f
};

// L1_fan_Wp (Shape: 6 x 64)
const int L1_fan_Wp_rows = 6;
const int L1_fan_Wp_cols = 64;
const float L1_fan_Wp_data[] = {
  -4.13168073e-02f, 1.53600040e-03f, 1.46326154e-01f, -2.59803869e-02f, 1.40651733e-01f, 8.44468996e-02f, 1.30900264e-01f, -5.40672392e-02f, -2.78704256e-01f, 1.02759428e-01f,
  -4.65654992e-02f, 1.22408062e-01f, 1.14278547e-01f, 8.48146230e-02f, -1.05789423e-01f, -9.21978801e-02f, 1.49107262e-01f, -8.01223516e-03f, 5.06368168e-02f, 6.55916408e-02f,
  -1.54808462e-01f, -5.17881550e-02f, -3.39327641e-02f, 1.01347687e-02f, -7.84613118e-02f, -1.85967937e-01f, -1.52049631e-01f, 6.53512627e-02f, -1.61415339e-01f, 6.42919317e-02f,
  -7.76657909e-02f, -1.47512451e-01f, 1.89832970e-01f, 1.35272250e-01f, 1.93868160e-01f, -1.21368825e-01f, -8.85375813e-02f, -1.47915715e-02f, 6.73482120e-02f, -2.47527454e-02f,
  -8.32297355e-02f, -8.94253477e-02f, -3.07925999e-01f, -1.54182324e-02f, -2.54268087e-02f, 2.12845523e-02f, 2.58412987e-01f, 5.17190397e-02f, -1.78241074e-01f, -1.46692861e-02f,
  1.11935874e-02f, 5.68908975e-02f, -1.80226445e-01f, -1.60262004e-01f, -7.61702433e-02f, -1.38402998e-03f, 8.50308314e-02f, -6.03219531e-02f, 6.68310076e-02f, 5.20972870e-02f,
  1.36246294e-01f, -1.50171056e-01f, 4.58360696e-03f, 1.01848066e-01f, -1.63654193e-01f, 4.66532707e-02f, -1.04554683e-01f, -1.52667567e-01f, -3.23742107e-02f, -3.81015316e-02f,
  -4.30528484e-02f, -6.14114292e-02f, 6.31655753e-02f, 1.02432601e-01f, -5.05796075e-03f, -1.20832577e-01f, -7.23023787e-02f, -5.87710552e-02f, 6.96584284e-02f, 1.47633463e-01f,
  -6.27731979e-02f, 3.65554616e-02f, 9.24722776e-02f, 9.86831356e-03f, 1.02144413e-01f, -8.16757753e-02f, 6.78298324e-02f, -5.31731732e-02f, -3.71011253e-03f, 2.00414345e-01f,
  -6.63898215e-02f, -1.19296089e-01f, 1.78045824e-01f, -9.47070047e-02f, -1.25212431e-01f, 1.24586001e-01f, -6.49862066e-02f, 3.03068459e-02f, -1.52226657e-01f, 1.72347620e-01f,
  -5.07874452e-02f, -8.63199234e-02f, -2.02058226e-01f, -1.70706436e-02f, 2.45260671e-02f, -1.26930326e-02f, 3.10722262e-01f, -1.03230618e-01f, -1.13790385e-01f, 4.35030907e-02f,
  -2.10548311e-01f, -4.14475948e-02f, 1.39572859e-01f, -6.26109540e-02f, 1.37546942e-01f, -3.64194461e-03f, 1.04208730e-01f, 7.68544897e-02f, 4.41958420e-02f, 7.36149624e-02f,
  -1.70477003e-01f, 1.98114634e-01f, -1.80746645e-01f, -1.70866758e-01f, -1.63476080e-01f, -9.31612328e-02f, 2.16283351e-01f, -1.85490981e-01f, 1.28567100e-01f, 9.62198302e-02f,
  1.26315892e-01f, 2.14569848e-02f, -1.10355616e-01f, 1.42227843e-01f, -3.70456018e-02f, -6.42189011e-02f, 8.64784345e-02f, 6.19987026e-03f, -8.39164704e-02f, -1.00509298e-03f,
  -1.82310157e-02f, -5.00754314e-03f, -9.23797786e-02f, -5.36157154e-02f, -7.01658279e-02f, -4.33638245e-02f, 1.00240402e-01f, 8.94845203e-02f, 5.55707887e-02f, 1.49678543e-01f,
  -2.18260586e-01f, 1.02246933e-01f, -4.20018546e-02f, 6.81606829e-02f, 1.26918554e-01f, 8.90082493e-02f, 1.61763728e-01f, 2.59165373e-02f, 5.01910364e-03f, -2.88109127e-02f,
  -8.64995122e-02f, -2.46427491e-01f, -2.16529623e-01f, -1.98176458e-01f, -3.30410972e-02f, 1.04932420e-01f, 4.20803018e-02f, -7.73961172e-02f, -1.05282500e-01f, -9.21379104e-02f,
  6.56392872e-02f, -3.63812968e-02f, 5.49044013e-02f, 1.76536292e-01f, -1.24384873e-01f, -8.95549953e-02f, 4.58436236e-02f, -6.18268969e-03f, 1.01956286e-01f, 7.95893297e-02f,
  3.21304575e-02f, -2.46673137e-01f, -5.31017072e-02f, -5.56202494e-02f, 3.14679928e-02f, 4.74941134e-02f, 1.64551482e-01f, -1.75595507e-02f, -1.72943607e-01f, 1.05958730e-01f,
  1.45561755e-01f, 5.08067720e-02f, 4.79063429e-02f, -6.03819303e-02f, 1.77171960e-01f, -1.06058516e-01f, 2.12139525e-02f, -6.07566647e-02f, 1.01946689e-01f, 1.84453040e-01f,
  -1.20335363e-01f, -5.78931794e-02f, 1.03141434e-01f, 8.72314908e-03f, 7.23378286e-02f, 1.90265104e-01f, 1.10258669e-01f, -1.86890721e-01f, 1.74776211e-01f, -1.23041913e-01f,
  1.14341162e-01f, 3.06974296e-02f, 1.02214254e-01f, 9.39801801e-03f, 6.06865063e-03f, -3.98083143e-02f, 6.68794885e-02f, -1.22081049e-01f, 8.94246846e-02f, -9.46201533e-02f,
  3.45342490e-03f, 1.55620491e-02f, 3.63704190e-02f, -1.70007080e-01f, 9.08662900e-02f, 2.15875298e-01f, 9.44187865e-02f, 9.42465886e-02f, 2.14844700e-02f, -7.84642994e-04f,
  1.30831182e-01f, -8.81712586e-02f, 1.44051239e-01f, -1.09235272e-01f, -1.85641974e-01f, -5.25821149e-02f, 1.25529304e-01f, -4.06999104e-02f, 1.11657038e-01f, -8.89638364e-02f,
  1.36694774e-01f, -1.82729334e-01f, 8.39011967e-02f, -1.42845055e-02f, -4.54777889e-02f, 1.19187534e-01f, 6.60121664e-02f, -2.25326657e-01f, -8.33630636e-02f, -1.21401429e-01f,
  9.57477093e-02f, -1.64147511e-01f, 2.75904030e-01f, 7.87260309e-02f, -5.78866750e-02f, -1.76857069e-01f, -3.31574231e-02f, 1.09881312e-01f, 7.26146698e-02f, -7.85475597e-02f,
  -8.42937268e-03f, -1.48184359e-01f, -1.02651052e-01f, 5.36513217e-02f, 6.80126026e-02f, 1.49068251e-01f, -4.32403050e-02f, -3.86479013e-02f, -7.37204477e-02f, 2.82295723e-03f,
  -1.30712375e-01f, -2.56377999e-02f, 2.99778376e-02f, -4.33125868e-02f, -5.12899831e-02f, -1.46450964e-03f, 4.10230234e-02f, 8.03763419e-02f, 1.94572642e-01f, 9.50073004e-02f,
  2.69534383e-02f, 1.27397850e-01f, -1.57484427e-01f, -1.02586322e-01f, -8.39669257e-02f, -4.56448421e-02f, 1.33350864e-01f, 1.37647346e-01f, 3.79779339e-02f, 2.11274937e-01f,
  1.41714305e-01f, 1.82535574e-01f, -1.36425465e-01f, 1.39447317e-01f, -1.08526260e-01f, -1.13689108e-02f, -3.81676815e-02f, -8.76027122e-02f, 4.62164283e-02f, -1.53037742e-01f,
  -7.08718747e-02f, -1.58141851e-01f, 3.66446227e-02f, -1.11482777e-02f, 1.73108652e-01f, 3.15333605e-02f, -1.21132322e-01f, 5.27481697e-02f, 5.97262289e-03f, 1.14859380e-01f,
  -5.91804422e-02f, 1.28833711e-01f, 2.83785313e-02f, 1.11042947e-01f, -1.29745156e-01f, -7.12479725e-02f, -8.58775061e-03f, -9.29121971e-02f, -1.78544462e-01f, -2.58935839e-01f,
  2.58378815e-02f, -9.44080651e-02f, -1.03824642e-02f, -8.98576006e-02f, 8.43769908e-02f, 3.20189707e-02f, -1.17734648e-01f, -4.48588980e-03f, 1.55097693e-01f, -6.61464781e-02f,
  -2.26767603e-02f, -1.52410537e-01f, -1.44183666e-01f, -3.51512469e-02f, 1.12707444e-01f, 1.29772350e-03f, 1.66624442e-01f, -1.57724402e-03f, -8.10072049e-02f, 4.55218814e-02f,
  -4.54409868e-02f, -5.40226251e-02f, -1.45728528e-01f, -5.56716870e-04f, -1.33007765e-01f, -9.23297927e-02f, 5.72053045e-02f, -1.10905141e-01f, 5.04365340e-02f, 8.31733942e-02f,
  6.61467984e-02f, -9.24943089e-02f, -3.32450774e-03f, -1.77839920e-01f, -1.38628617e-01f, -1.40150502e-01f, 5.09303398e-02f, -6.79820701e-02f, 1.03166007e-01f, -9.02172085e-03f,
  1.04758732e-01f, 9.34758559e-02f, 9.04081017e-02f, 2.79561318e-02f, 1.60210133e-01f, 1.42661810e-01f, -1.71582639e-01f, 4.69726557e-03f, 1.78464144e-01f, -2.68775392e-02f,
  -3.98095995e-02f, 1.07667953e-01f, 1.35022163e-01f, -9.02159736e-02f, -1.81318298e-02f, -1.43828183e-01f, -2.66977679e-02f, 2.15405435e-03f, 6.49559796e-02f, -6.11517504e-02f,
  1.34151474e-01f, 4.24021948e-03f, 6.15012497e-02f, 2.47143544e-02f
};

// L1_fan_Wp_bar (Shape: 52 x 64)
const int L1_fan_Wp_bar_rows = 52;
const int L1_fan_Wp_bar_cols = 64;
const float L1_fan_Wp_bar_data[] = {
  6.16821013e-02f, 2.08237380e-01f, 1.13553263e-01f, 1.96651071e-01f, -1.47117244e-04f, 5.40549159e-02f, 6.60122484e-02f, -1.23803392e-01f, 1.41087100e-01f, -2.44034946e-01f,
  3.00375782e-02f, -3.19660851e-03f, -7.75902420e-02f, -8.11344013e-02f, 2.82829851e-01f, -4.04248806e-03f, 2.04268619e-01f, -8.32881555e-02f, -2.77605373e-02f, -2.63482612e-02f,
  -4.27596346e-02f, -6.84675649e-02f, -1.30028084e-01f, -1.17425129e-01f, -6.81617111e-02f, 8.35588276e-02f, 3.03674817e-01f, 1.72864720e-01f, -4.15849648e-02f, -8.83319005e-02f,
  8.61468837e-02f, 4.09545638e-02f, -1.41012430e-01f, 7.59565178e-03f, -1.07292578e-01f, 4.46077809e-02f, 1.25601277e-01f, -1.52031928e-01f, 4.45122086e-02f, -3.88647197e-03f,
  2.02997029e-01f, 1.80608612e-02f, 2.21091993e-02f, 5.72555885e-02f, 2.62661576e-01f, -8.85109697e-03f, 1.24513451e-03f, -5.82906592e-04f, 3.62472609e-02f, 1.97979361e-02f,
  1.84331492e-01f, -3.46003734e-02f, 6.11231439e-02f, 8.76787677e-02f, 1.32847160e-01f, -1.54014826e-01f, 1.63565725e-01f, -7.22521842e-02f, -1.10786909e-03f, -7.23438561e-02f,
  1.88073650e-01f, -3.23802605e-02f, 9.66715515e-02f, 2.83892363e-01f, -8.96055177e-02f, -8.65054354e-02f, 1.25810117e-01f, 9.14767161e-02f, -1.01622768e-01f, 1.43494070e-01f,
  6.47596866e-02f, 3.78589220e-02f, -7.12752938e-02f, 6.41577244e-02f, 1.05081461e-01f, -4.12182547e-02f, -1.96115281e-02f, 8.60900432e-02f, -1.06731027e-01f, -6.47625253e-02f,
  1.15572989e-01f, 1.19151250e-02f, -5.07604219e-02f, -1.00007519e-01f, -2.44952608e-02f, 2.74326243e-02f, -2.38111848e-03f, 1.65713811e-03f, -6.48292527e-02f, 1.12575330e-02f,
  5.89346178e-02f, 1.28413394e-01f, 3.07996292e-02f, 9.55980197e-02f, 2.33389717e-02f, -1.12290442e-01f, -5.97497001e-02f, -1.15093984e-01f, 1.82359926e-02f, -1.29046157e-01f,
  9.02114734e-02f, 3.89157832e-02f, -2.59995628e-02f, 5.81774041e-02f, 7.19392374e-02f, -3.06171812e-02f, 7.91205019e-02f, 2.05064118e-02f, 9.08080116e-02f, -1.02362119e-01f,
  1.16787903e-01f, 1.14539668e-01f, -8.95611197e-02f, 4.93272543e-02f, 5.52657321e-02f, -6.27370626e-02f, -3.80654410e-02f, -2.55624484e-02f, 1.00569263e-01f, 6.86722714e-03f,
  7.92703629e-02f, -4.89780232e-02f, 1.01775542e-01f, -7.60205975e-03f, -9.65148509e-02f, 1.03483438e-01f, 1.07982986e-01f, 8.86254609e-02f, 2.79206574e-01f, 2.09876359e-01f,
  5.72816357e-02f, 3.27364206e-01f, 2.58440197e-01f, 2.26509094e-01f, 1.49696290e-01f, -1.37773827e-01f, -1.74986288e-01f, 1.75996646e-01f, -1.08560495e-01f, 3.88915800e-02f,
  1.16476081e-01f, 4.05266769e-02f, -1.28633782e-01f, 1.26476109e-01f, 1.63709313e-01f, -6.01322651e-02f, -3.29746082e-02f, 4.23474796e-02f, -1.53668761e-01f, 2.29941346e-02f,
  4.85168919e-02f, -9.39293206e-02f, 1.07031250e-02f, -6.83687627e-02f, -3.36758047e-02f, 1.96632788e-01f, -5.16982898e-02f, -7.40205571e-02f, -7.91890100e-02f, -7.44299311e-03f,
  -4.31790240e-02f, -6.34026676e-02f, -6.49550036e-02f, -1.41777573e-02f, -6.29455596e-02f, 3.11900321e-02f, 1.51432157e-01f, 1.58318132e-01f, 1.47717535e-01f, 9.07713994e-02f,
  -3.64987180e-02f, 2.22343311e-01f, 6.32493943e-02f, 1.40099362e-01f, 2.12829545e-01f, 1.07166879e-01f, -1.03154548e-01f, 1.68578818e-01f, 2.94863508e-04f, 9.25758630e-02f,
  -7.81115890e-02f, 2.52579227e-02f, 1.55578956e-01f, 2.37434849e-01f, 9.69819538e-03f, -6.11007102e-02f, 8.77011046e-02f, 3.23197871e-01f, -8.76212195e-02f, -4.03072760e-02f,
  2.02553675e-01f, 3.34750563e-01f, -9.33355168e-02f, -7.73923844e-02f, -5.04065007e-02f, 1.47891670e-01f, 1.31151021e-01f, 4.90072854e-02f, -6.71030506e-02f, 3.45069282e-02f,
  1.33021653e-01f, -2.47718431e-02f, -3.49605922e-03f, -1.71978343e-02f, 8.41526091e-02f, 7.72401392e-02f, 6.14230633e-02f, 6.61484078e-02f, -8.05517063e-02f, 7.33952448e-02f,
  -6.25286624e-02f, 2.91087683e-02f, -1.16116824e-02f, 1.91130526e-02f, -1.08806014e-01f, 1.07144229e-01f, 1.13395080e-01f, 1.15006417e-01f, 1.17076756e-02f, 7.37991557e-02f,
  -1.83961913e-02f, 4.46016379e-02f, -1.37142818e-02f, 1.52411401e-01f, -1.22699790e-01f, -1.57268830e-02f, -1.43727995e-02f, 4.87468056e-02f, -2.30331216e-02f, 6.33916184e-02f,
  -9.62419063e-03f, 5.29713631e-02f, 4.57259789e-02f, 4.37367745e-02f, 1.77237019e-01f, 5.56523614e-02f, 1.72822680e-02f, -9.24578309e-02f, -5.14535457e-02f, 3.08655128e-02f,
  -5.07946908e-02f, -2.01809332e-02f, 2.23656427e-02f, 2.27429047e-02f, -1.03006465e-02f, 1.64688244e-01f, 1.05599955e-01f, -8.10348988e-03f, -7.39501789e-02f, -6.27028421e-02f,
  -9.62812174e-03f, -1.37181235e-02f, -7.28459731e-02f, -1.33140339e-02f, 1.81371838e-01f, 1.33554749e-02f, -5.41037321e-03f, 8.16500783e-02f, -9.77680534e-02f, -1.56126991e-02f,
  -6.69191703e-02f, 1.05810143e-01f, 3.46298739e-02f, -1.01922981e-01f, -4.75263409e-03f, -1.96011979e-02f, -1.24477828e-02f, -1.47217866e-02f, -1.01640478e-01f, 2.95222159e-02f,
  -1.18912876e-01f, -2.11264770e-02f, 7.79744834e-02f, -1.36608686e-02f, -7.76924714e-02f, -5.23950197e-02f, -9.02746767e-02f, 1.57950446e-02f, -1.12980399e-02f, 8.59266222e-02f,
  8.02809894e-02f, 8.51009414e-02f, 2.01576408e-02f, -1.33185416e-01f, 3.92001197e-02f, -1.10600721e-02f, 3.38079892e-02f, -1.06985770e-01f, 1.08052939e-01f, -3.81285362e-02f,
  8.68394673e-02f, 1.25801191e-01f, -1.20875932e-01f, -3.90200131e-02f, 4.50122096e-02f, -7.46656358e-02f, 8.16692831e-04f, -9.09211040e-02f, -2.25824527e-02f, -6.03038222e-02f,
  -7.28334412e-02f, -1.31181285e-01f, -1.53152542e-02f, 8.96096677e-02f, -9.09964368e-03f, -1.02727741e-01f, -8.40608850e-02f, -9.62822214e-02f, -1.11696042e-01f, -1.00246467e-01f,
  -1.07263088e-01f, 4.99448255e-02f, -8.33878890e-02f, 2.82565653e-02f, 1.22719906e-01f, 6.02413379e-02f, 3.01453806e-02f, -3.65487821e-02f, -9.75725055e-02f, 4.75901179e-02f,
  7.45338947e-02f, 2.19840601e-01f, 2.07080796e-01f, 1.27826616e-01f, 8.74861181e-02f, 5.41799888e-02f, -1.67438820e-01f, 9.03371796e-02f, 3.74054126e-02f, 2.08060503e-01f,
  -1.08188659e-01f, -1.99567989e-01f, -1.00789763e-01f, 1.81921214e-01f, -1.13504780e-02f, -1.03334330e-01f, 8.37780237e-02f, 8.38546604e-02f, -4.22570202e-03f, 6.17193766e-02f,
  1.00648984e-01f, 1.37998059e-01f, -5.77806495e-02f, 3.65834981e-02f, 1.81634888e-01f, 6.92013949e-02f, -8.00451636e-02f, -1.41708627e-01f, 2.39205603e-02f, 1.62946165e-01f,
  1.79350287e-01f, 2.76096135e-01f, -5.54729402e-02f, 2.11634547e-01f, 1.50411144e-01f, 2.84364462e-01f, -8.57199132e-02f, 9.47513282e-02f, -3.68452705e-02f, 1.03639275e-01f,
  -5.24040894e-04f, -1.69999618e-02f, -4.07201750e-03f, 8.64990726e-02f, -9.44434181e-02f, 5.41740991e-02f, 3.46093881e-03f, 1.25313327e-01f, 3.04917663e-01f, 9.82680768e-02f,
  -1.42404303e-01f, 3.44083458e-02f, 1.01742089e-01f, 3.27709019e-01f, 9.66141745e-03f, 5.24178818e-02f, -9.64404494e-02f, 1.46162435e-01f, 1.08675592e-01f, 9.45545137e-02f,
  1.53716877e-01f, 6.40169904e-02f, 5.69953248e-02f, -3.06406040e-02f, 6.24432825e-02f, 1.84197903e-01f, 1.79760292e-01f, 6.31836951e-02f, -2.05451101e-02f, 8.37363079e-02f,
  9.13093686e-02f, 1.28600359e-01f, 4.63444553e-02f, 4.01438810e-02f, 3.16062570e-02f, -1.51557758e-01f, 9.26661398e-03f, -6.48060590e-02f, 7.24272653e-02f, -1.20544389e-01f,
  -3.52364965e-02f, -1.22193903e-01f, -4.65977825e-02f, 5.11608608e-02f, 5.38223190e-03f, 1.26314551e-01f, 1.01465344e-01f, 2.63934825e-02f, 1.23707868e-01f, -1.15420356e-01f,
  -1.55871093e-01f, -1.37483299e-01f, -5.39343059e-03f, 1.70838088e-02f, 1.04046352e-01f, -1.54766347e-02f, 1.03298739e-01f, 5.38751148e-02f, 1.72196209e-01f, 1.23030089e-01f,
  8.01743567e-02f, 5.17469384e-02f, -3.75344791e-02f, 3.87655161e-02f, 1.42912105e-01f, 8.83635785e-03f, -8.18245187e-02f, -1.37836531e-01f, 8.86702258e-03f, -7.29545727e-02f,
  1.60246640e-01f, 1.58284321e-01f, -3.87575030e-02f, 4.85855527e-02f, -9.23395976e-02f, 2.37543657e-02f, -7.27881724e-03f, 1.46274135e-01f, -6.39953837e-02f, -6.44279048e-02f,
  3.07490360e-02f, -3.80090028e-02f, 1.10581145e-01f, 1.26742691e-01f, 1.16847627e-01f, 1.08293258e-01f, 1.36696259e-02f, -1.02163985e-01f, -6.86018690e-02f, -6.52456656e-02f,
  5.26194088e-02f, 7.33495504e-02f, -1.01370282e-01f, -5.76126277e-02f, 1.49160614e-02f, 7.17667416e-02f, -1.34821415e-01f, -7.50335455e-02f, 9.25272107e-02f, 1.12533584e-01f,
  5.84489144e-02f, -8.16542469e-03f, 4.00272757e-02f, -1.12393163e-01f, 7.78479800e-02f, -5.68765029e-03f, -4.85899486e-02f, 8.71972293e-02f, -1.46092037e-02f, -1.17032640e-01f,
  -2.60445755e-02f, -1.17450744e-01f, 4.22167480e-02f, 5.41830398e-02f, 1.06331408e-01f, 2.54865270e-02f, -2.36496013e-02f, -4.97088840e-05f, 5.83073720e-02f, -8.06698427e-02f,
  -9.62547213e-02f, 6.68267086e-02f, -9.44607183e-02f, 1.09686844e-01f, 2.88276542e-02f, -1.17577001e-01f, -8.29024892e-03f, 1.21714786e-01f, -1.00779615e-01f, 7.65070468e-02f,
  -7.55629689e-02f, -2.54224017e-02f, 7.78034478e-02f, -9.51910317e-02f, 6.86389431e-02f, -4.55123149e-02f, -1.13722987e-01f, 5.04393615e-02f, 1.23289309e-01f, 1.18210793e-01f,
  -2.31820848e-02f, 8.74888673e-02f, 6.93614706e-02f, 1.68098379e-02f, 6.00103475e-02f, -7.26260915e-02f, 5.84457964e-02f, -2.55175848e-02f, -7.80862272e-02f, -1.09434597e-01f,
  -9.87245440e-02f, -7.05642253e-02f, 1.31914034e-01f, 1.25449806e-01f, 8.74236301e-02f, 1.63862389e-02f, 1.24080911e-01f, 1.27748534e-01f, 1.60003863e-02f, -1.19303696e-01f,
  8.20645317e-02f, 1.11985847e-01f, 6.78506717e-02f, 1.12516418e-01f, 1.54502377e-01f, 5.45813795e-03f, 1.07312217e-01f, 1.24023827e-02f, -1.03580348e-01f, 6.94181696e-02f,
  -1.70490324e-01f, -3.48275863e-02f, 8.66209716e-02f, 2.04892503e-03f, -7.57924840e-02f, -7.39224674e-03f, -7.45271519e-02f, 1.13296576e-01f, 6.22081123e-02f, 1.24668591e-01f,
  1.26356026e-02f, 5.82746742e-03f, -2.43909322e-02f, 1.00501608e-02f, -4.91402037e-02f, -2.59666461e-02f, -6.19183257e-02f, -4.27419916e-02f, -6.09000698e-02f, 4.67518717e-02f,
  1.06935211e-01f, -5.98635525e-02f, 8.81535262e-02f, -1.15596429e-01f, 1.32824346e-01f, -2.25144774e-02f, 6.25846758e-02f, -9.57524627e-02f, -3.80372144e-02f, 9.14828926e-02f,
  6.12465329e-02f, -9.92490631e-03f, -2.34097615e-02f, -1.05745360e-01f, 8.33642334e-02f, 5.76965092e-03f, 1.15031488e-01f, 1.54199705e-01f, 1.62008032e-01f, 8.65169168e-02f,
  -1.45591840e-01f, 5.10714427e-02f, -9.37996432e-02f, 4.41314355e-02f, -7.69417286e-02f, 1.69682860e-01f, -5.72035648e-02f, -4.40853275e-02f, -7.52614960e-02f, -1.15577690e-02f,
  2.49302518e-02f, 1.23830833e-01f, -2.70795673e-02f, -1.54768407e-01f, -2.77566947e-02f, 1.41846642e-01f, -1.02139972e-01f, 1.31356940e-01f, 1.19791441e-01f, 6.11194037e-02f,
  1.66320417e-03f, -7.29798451e-02f, 3.56108360e-02f, -7.81433657e-02f, -2.95716599e-02f, -7.53538311e-02f, -2.98352796e-03f, -9.59483683e-02f, 1.08134836e-01f, 6.41854340e-03f,
  1.19803712e-01f, 5.23825847e-02f, 1.20502971e-01f, 3.22199091e-02f, -5.01180580e-03f, 4.19871137e-02f, 1.98098458e-02f, -6.82959184e-02f, -9.37584341e-02f, 1.02771372e-01f,
  6.81251436e-02f, 4.49877232e-02f, 1.02591142e-01f, 2.89552677e-02f, -7.21850842e-02f, 8.92118812e-02f, -3.56741212e-02f, -1.13272229e-02f, -1.88641213e-02f, -2.49504521e-02f,
  -1.27894595e-01f, 1.09828494e-01f, 2.88181659e-02f, -8.90987292e-02f, -1.57047048e-01f, 7.57506909e-03f, 3.35371159e-02f, -5.83105162e-02f, 1.17750339e-01f, -1.96614973e-02f,
  5.87998480e-02f, 3.97059284e-02f, -4.07223729e-03f, 9.10017937e-02f, -1.36435661e-03f, 1.11111969e-01f, -6.90334588e-02f, -1.23698547e-01f, -1.38102344e-03f, 1.00337505e-01f,
  -3.61657254e-02f, 3.86602171e-02f, 1.78421304e-01f, 9.37347338e-02f, 1.17254980e-01f, 1.08050548e-01f, 4.15732153e-02f, 1.39216930e-01f, -1.20210692e-01f, -1.21079214e-01f,
  -1.00355715e-01f, -8.12009200e-02f, 1.18430503e-01f, 2.45823748e-02f, 5.35510071e-02f, -3.10616270e-02f, 1.92183211e-01f, -1.77710708e-02f, -7.33745694e-02f, -6.24283962e-02f,
  2.02893130e-02f, 1.04771912e-01f, 4.69126441e-02f, 7.71510378e-02f, 1.27480607e-02f, 5.26723862e-02f, 1.27172023e-01f, -4.51298356e-02f, -7.05904216e-02f, -3.71080786e-02f,
  -1.90234482e-02f, -6.02310710e-02f, 3.70145664e-02f, 1.21420175e-01f, -7.10722953e-02f, 5.36914766e-02f, -5.28888628e-02f, -6.55901060e-02f, 1.73386976e-01f, -9.14159790e-02f,
  1.41206577e-01f, 8.43646452e-02f, -6.89137429e-02f, 5.29925674e-02f, 1.79573134e-01f, -1.03337795e-01f, 4.57428917e-02f, 7.24911690e-02f, 1.42694831e-01f, 2.69009657e-02f,
  1.30115286e-01f, 6.25183508e-02f, 3.23265083e-02f, 4.53044381e-03f, 1.10782504e-01f, -8.93023089e-02f, 3.32642831e-02f, -1.13661237e-01f, 9.66194719e-02f, -5.21191321e-02f,
  9.48845223e-02f, -4.64569218e-02f, 8.45271870e-02f, 1.01023074e-02f, 1.03837334e-01f, -6.69636205e-02f, 4.11223285e-02f, 1.56520516e-01f, 1.50496662e-01f, 7.66935050e-02f,
  -5.01141734e-02f, 7.33323768e-02f, -8.98245648e-02f, -1.56249627e-01f, 1.39816508e-01f, 1.18220173e-01f, -1.30355909e-01f, -6.28241524e-02f, -2.84206849e-02f, 7.25845546e-02f,
  -8.26044306e-02f, -3.28339101e-03f, 1.33201033e-01f, -1.07559554e-01f, -6.68328181e-02f, -3.79409082e-02f, 3.75125953e-03f, -9.83562991e-02f, -1.04828626e-01f, -4.96013053e-02f,
  -7.80685479e-03f, 9.57061350e-02f, -7.68871829e-02f, 5.85169643e-02f, 6.07386185e-03f, 1.09082162e-01f, 8.84004012e-02f, -1.33718625e-01f, 6.66509718e-02f, -7.37115070e-02f,
  9.82200429e-02f, -1.20566748e-01f, -4.71811108e-02f, 5.57961278e-02f, 1.05965048e-01f, -3.53321712e-03f, 9.89325345e-02f, 1.15279861e-01f, -1.82429515e-02f, 4.10873815e-02f,
  9.64918658e-02f, 4.15059701e-02f, -7.22149014e-03f, 1.05289929e-01f, -1.04757167e-01f, -1.21479735e-01f, -8.89344886e-02f, -1.71281084e-01f, -8.85790139e-02f, -5.66239432e-02f,
  -3.05833649e-02f, -1.24058440e-01f, -9.47380364e-02f, 2.83396766e-02f, 2.72945017e-02f, -4.76856716e-02f, 6.68219570e-03f, 1.42142847e-01f, 1.06327526e-01f, 1.64770603e-01f,
  5.72446734e-02f, 4.30760719e-02f, 1.43329009e-01f, -4.58930731e-02f, -4.44033667e-02f, 1.09232239e-01f, -1.32918013e-02f, -7.94317573e-02f, -1.34452790e-01f, -1.11258566e-01f,
  -4.49690185e-02f, -1.34439683e-02f, -8.48064870e-02f, -8.38342905e-02f, 1.15396082e-01f, 3.28214280e-02f, 1.24104120e-01f, 9.70591009e-02f, 2.41325367e-02f, -1.29292188e-02f,
  -1.46614283e-01f, -6.45825490e-02f, 1.18214175e-01f, 3.06240749e-02f, 6.26707897e-02f, -6.13814816e-02f, 8.09748918e-02f, 1.20003536e-01f, -5.70482276e-02f, 1.11297585e-01f,
  1.20255195e-01f, -5.00026830e-02f, 4.28289082e-03f, -3.93214226e-02f, 9.72584710e-02f, -4.71289642e-02f, 1.02076672e-01f, 8.49798769e-02f, -2.94351391e-02f, 4.07928368e-03f,
  -4.61353399e-02f, -5.95055036e-02f, -5.23972772e-02f, -2.09567416e-02f, -1.17603377e-01f, 5.38286157e-02f, 1.47791535e-01f, -1.14889471e-02f, -2.32360903e-02f, -1.03287138e-01f,
  1.48008212e-01f, -6.05288707e-02f, -5.55512588e-03f, -1.24808200e-01f, -1.02257788e-01f, 1.65535688e-01f, -1.04101971e-01f, 2.15717778e-02f, 4.39788513e-02f, 1.43880114e-01f,
  9.17891711e-02f, -4.34961654e-02f, -7.46456683e-02f, -1.62706599e-02f, -1.13259032e-01f, -1.84478834e-02f, 6.58623278e-02f, 1.13763260e-02f, -3.63303833e-02f, 6.58876672e-02f,
  -3.70724648e-02f, 5.70374392e-02f, 5.13739437e-02f, -9.77659151e-02f, 3.48038077e-02f, -7.93609023e-02f, -2.47915909e-02f, -1.20020077e-01f, 5.94784319e-03f, 7.83273056e-02f,
  -7.17175454e-02f, 8.13765079e-02f, 4.08154950e-02f, 7.66041428e-02f, 5.19063957e-02f, -1.84105374e-02f, -1.18913695e-01f, 2.17727646e-02f, 3.05493586e-02f, 3.42198126e-02f,
  5.02391160e-02f, -4.24668118e-02f, 7.00329170e-02f, -1.24350049e-01f, -1.05047770e-01f, 1.13954537e-01f, -4.02543359e-02f, 8.34242925e-02f, 5.24005666e-02f, -9.52281281e-02f,
  2.90726870e-02f, -2.42715962e-02f, -8.31671730e-02f, 2.06305441e-02f, -1.13280259e-01f, -6.87840283e-02f, -7.55021796e-02f, 1.01271406e-01f, -7.92608261e-02f, 6.62180111e-02f,
  -3.06954999e-02f, 9.03795362e-02f, -1.83960702e-02f, 1.19346268e-02f, -1.29370257e-01f, -8.58227760e-02f, -1.73373315e-02f, 3.36461030e-02f, 4.30983268e-02f, 8.20696354e-02f,
  -2.67745480e-02f, -4.84680496e-02f, -5.85126355e-02f, 9.24767479e-02f, 8.55396092e-02f, 8.67433567e-03f, 1.54299378e-01f, 1.01348616e-01f, 6.48560235e-03f, 8.48534182e-02f,
  2.53852099e-01f, 2.12703049e-01f, 2.14674771e-01f, -1.15186840e-01f, -2.48402819e-01f, 1.13047183e-01f, -1.07100755e-01f, 1.41446352e-01f, 3.56307834e-01f, -1.08968392e-01f,
  -1.95463598e-02f, 2.47549191e-02f, 8.42088759e-02f, 9.50009525e-02f, -1.61626339e-01f, -1.25008747e-01f, 1.14910282e-01f, -1.25900179e-01f, 1.50750324e-01f, 1.61746129e-01f,
  -7.57744461e-02f, -7.36062750e-02f, -1.76183227e-02f, 1.48755550e-01f, -7.16109723e-02f, -1.14817426e-01f, -5.27618974e-02f, -6.84823543e-02f, -1.49515346e-02f, 1.97705850e-01f,
  4.54146378e-02f, 6.64354786e-02f, -5.76346787e-03f, 1.23061232e-01f, 1.04027964e-01f, 1.47399709e-01f, -1.42306954e-01f, 9.05951336e-02f, -1.98638260e-01f, 1.83625549e-01f,
  -9.81391147e-02f, -1.30554438e-01f, 2.12152645e-01f, 1.57412857e-01f, -1.65944368e-01f, -1.58226117e-02f, -1.22123554e-01f, 9.41540152e-02f, -1.24403730e-01f, -3.78915295e-02f,
  -7.62645528e-02f, 2.23706841e-01f, 1.93792522e-01f, -5.40452003e-02f, -9.62924620e-04f, 2.38646194e-01f, 3.59033942e-02f, -1.68548584e-01f, 9.89883393e-03f, 6.28959294e-03f,
  1.47661613e-02f, 1.18785791e-01f, 1.41173720e-01f, 7.30302744e-03f, 1.47692502e-01f, 2.48586684e-02f, 4.65749837e-02f, -1.08094938e-01f, 5.59399948e-02f, 2.06708759e-01f,
  6.31129220e-02f, -1.11535266e-02f, 1.34426758e-01f, -8.78014714e-02f, -1.65825143e-01f, 1.70311034e-01f, -7.26643354e-02f, 1.34999696e-02f, 2.16758735e-02f, 4.62241434e-02f,
  -1.33637525e-02f, 1.42470628e-01f, 2.85735488e-01f, 1.13001630e-01f, -5.65848649e-02f, -1.30971782e-02f, -9.00408849e-02f, -7.94712231e-02f, -1.54666007e-01f, 1.01730730e-02f,
  -8.80213603e-02f, 8.46346915e-02f, 7.91908875e-02f, 2.52680302e-01f, -5.50777167e-02f, 6.21874109e-02f, -9.24284458e-02f, 1.18904896e-01f, 1.18904278e-01f, 4.12306823e-02f,
  -5.67644425e-02f, -5.17814979e-02f, 3.57179008e-02f, -1.17015399e-01f, -1.12107620e-01f, 7.10776299e-02f, 2.12387592e-01f, 2.22725663e-02f, -1.24681674e-01f, 2.73508765e-02f,
  2.13702433e-02f, 1.02778323e-01f, 9.24737155e-02f, 2.92439666e-02f, -1.62409395e-01f, 3.05226177e-01f, -1.43176049e-01f, 2.10590810e-02f, 1.18069015e-01f, 6.03920221e-02f,
  -4.95686904e-02f, -3.03248484e-02f, 3.48058678e-02f, -2.01617062e-01f, 1.06909245e-01f, 1.36306183e-02f, -6.72697183e-03f, -7.40625411e-02f, 3.17115113e-02f, 1.66692093e-01f,
  3.98305990e-02f, 5.86287118e-02f, 6.26893044e-02f, -1.77609041e-01f, 5.81973307e-02f, 9.74890888e-02f, 7.58092180e-02f, 9.93073136e-02f, -6.72418326e-02f, 2.10318387e-01f,
  -1.39710099e-01f, -8.75176638e-02f, 1.33737147e-01f, -4.02355567e-02f, -4.72550616e-02f, 6.47861976e-03f, -1.29782200e-01f, -6.45503253e-02f, -3.70699167e-02f, -8.62917528e-02f,
  -1.33448124e-01f, 6.06474578e-02f, 3.81680727e-02f, -9.82896909e-02f, 5.07057793e-02f, 1.48060381e-01f, 1.13461807e-01f, -1.33734673e-01f, 4.72155064e-02f, -1.40602708e-01f,
  8.61383006e-02f, -1.19762070e-01f, -1.00983456e-01f, 8.17168206e-02f, 2.33207345e-02f, 3.20130922e-02f, 1.70063555e-01f, 5.85346594e-02f, -4.09290269e-02f, 2.22457841e-01f,
  1.18642012e-02f, 4.44323895e-03f, 5.83463907e-02f, 6.85991570e-02f, -9.15668458e-02f, -7.86052048e-02f, 7.23789260e-02f, -2.84016840e-02f, -1.45153955e-01f, -1.05365023e-01f,
  2.74139252e-02f, -1.03867576e-01f, 7.54503459e-02f, 8.73426646e-02f, -8.43385458e-02f, -5.02785146e-02f, 6.97772428e-02f, -9.61486176e-02f, 1.79090854e-02f, 1.22022770e-01f,
  1.09318294e-01f, -9.04346332e-02f, 8.25912282e-02f, -2.86660045e-02f, 1.11148469e-01f, -2.26786900e-02f, 4.54451554e-02f, -1.44353390e-01f, 7.41729289e-02f, 7.97400251e-02f,
  8.56102556e-02f, -8.53926167e-02f, -3.64872925e-02f, 1.52267218e-01f, 3.20744477e-02f, 1.10496883e-03f, 1.34255379e-01f, 1.87084563e-02f, -2.67261900e-02f, 4.16247733e-02f,
  -5.37497513e-02f, -6.67119399e-02f, -9.71549451e-02f, -5.45231365e-02f, 6.31785914e-02f, 3.66985090e-02f, -2.24636067e-02f, -1.02255188e-01f, 1.01886779e-01f, -5.99949472e-02f,
  -1.34183178e-02f, 8.69199187e-02f, -2.63562165e-02f, -9.98998061e-02f, -1.10006325e-01f, -4.90646586e-02f, 5.16965725e-02f, -1.03239864e-01f, -9.79794115e-02f, 1.43353483e-02f,
  -1.05705909e-01f, 1.29190460e-01f, 1.55967474e-02f, 1.48044959e-01f, -8.10216293e-02f, -7.64966086e-02f, 9.42824185e-02f, -1.11926235e-01f, -3.47030722e-02f, 1.24687925e-01f,
  -1.31789163e-01f, -9.35449004e-02f, 1.90173276e-02f, -2.85953656e-02f, 1.88249134e-04f, 2.61924397e-02f, -1.41452095e-02f, -4.01914269e-02f, -3.23171243e-02f, 5.90262264e-02f,
  1.54934436e-01f, -2.45717284e-03f, 1.22168213e-02f, 7.29396418e-02f, 1.68147266e-01f, -1.32559212e-02f, -1.63472239e-02f, 5.38204238e-02f, -1.02890186e-01f, 1.04207605e-01f,
  4.38973010e-02f, -1.35471269e-01f, -9.65822190e-02f, -9.01148692e-02f, -4.94019082e-03f, 2.28501372e-02f, 1.88059345e-01f, -9.17590857e-02f, -1.00813825e-02f, 1.00216545e-01f,
  1.13152236e-01f, -1.94318257e-02f, -6.40152767e-02f, 1.27642319e-01f, -3.20239514e-02f, 1.51867205e-02f, 1.04877822e-01f, 1.72148906e-02f, -4.71505523e-02f, -5.03871888e-02f,
  2.79149562e-02f, -9.88025665e-02f, 1.00167640e-01f, 4.11976986e-02f, 2.73241866e-02f, -1.08908094e-01f, -2.21716762e-02f, 1.30425040e-02f, 1.24389447e-01f, -3.01748067e-02f,
  6.26525953e-02f, 6.68137372e-02f, 1.17085621e-01f, -1.01927951e-01f, -2.48559061e-02f, -8.53800476e-02f, 6.26434460e-02f, 1.92611832e-02f, 3.35223600e-02f, -6.24428242e-02f,
  -1.92818488e-03f, -1.52826998e-02f, -3.25581874e-03f, 9.36450958e-02f, 1.10808805e-01f, 1.04530662e-01f, 9.34792906e-02f, -1.14336565e-01f, -9.82055534e-03f, 8.56170207e-02f,
  -3.76285575e-02f, -1.42402187e-01f, 8.01765621e-02f, 6.24692291e-02f, -2.73624808e-02f, 7.55835474e-02f, 5.68705648e-02f, -5.80512770e-02f, -9.56638455e-02f, -1.21401392e-01f,
  1.57430652e-03f, 1.01047173e-01f, -1.06560975e-01f, -3.22728306e-02f, -4.49125990e-02f, 6.73731342e-02f, -3.99711952e-02f, -1.26310334e-01f, -1.72196259e-03f, -9.20139719e-03f,
  9.54287350e-02f, 1.90021805e-02f, -5.26458770e-03f, 5.08732758e-02f, -7.46234953e-02f, 3.96283157e-02f, 6.87350053e-03f, 8.19870830e-03f, 4.24270369e-02f, -6.18968867e-02f,
  -8.11644793e-02f, -1.80794783e-02f, 9.58928093e-03f, -1.20760538e-02f, -3.62129994e-02f, -1.12032242e-01f, 4.19086032e-02f, -6.35752454e-02f, -8.61750767e-02f, -9.12529156e-02f,
  -4.96870428e-02f, -2.79949829e-02f, 1.30310327e-01f, -6.88273683e-02f, 1.06081463e-01f, -7.78120533e-02f, 1.08369514e-01f, -5.93497120e-02f, -1.15420833e-01f, 5.35879731e-02f,
  9.92614180e-02f, -1.09961323e-01f, 1.33807072e-02f, 6.25745356e-02f, -3.64914574e-02f, -1.75058600e-02f, -1.38808480e-02f, 1.22780770e-01f, 4.03038003e-02f, -1.14453122e-01f,
  7.61946067e-02f, -2.48065963e-02f, -5.27444407e-02f, 7.87310228e-02f, -4.37843911e-02f, -7.42496476e-02f, 3.55906575e-03f, 3.77654321e-02f, -3.13684642e-02f, 6.94096833e-02f,
  -9.00689811e-02f, -3.99752380e-03f, -7.93001279e-02f, 1.08101247e-02f, -9.09580961e-02f, 3.15041803e-02f, 5.71024269e-02f, 6.95163682e-02f, 1.00085117e-01f, 6.43573850e-02f,
  -7.37054050e-02f, 1.00301199e-01f, -1.01143360e-01f, -4.18469049e-02f, -8.81412849e-02f, 1.03864737e-01f, -6.50279298e-02f, -4.72109066e-03f, 1.11145236e-01f, -2.55189687e-02f,
  1.09126806e-01f, 1.30996391e-01f, 2.20744330e-02f, -8.52534175e-02f, -7.72291422e-02f, -1.12468943e-01f, -8.65977556e-02f, -4.21498008e-02f, 9.05691832e-02f, -2.03211745e-03f,
  -5.99898957e-02f, 9.39884484e-02f, 1.23502716e-01f, 1.00883663e-01f, -4.76537086e-02f, -2.68558897e-02f, 3.89806591e-02f, -9.61445868e-02f, -9.83690843e-02f, 9.66946706e-02f,
  5.44386096e-02f, 3.65417227e-02f, 1.07826054e-01f, 7.58301392e-02f, -6.93315864e-02f, 7.14182705e-02f, -6.63156062e-02f, -9.45199579e-02f, 1.19644962e-01f, 6.72036503e-03f,
  -4.17049639e-02f, -8.75956342e-02f, 1.33629637e-02f, 2.35465821e-02f, -3.85517515e-02f, 1.37184635e-02f, -5.15506193e-02f, 1.78307891e-02f, 1.21989876e-01f, 3.57723772e-03f,
  -4.11165953e-02f, -2.65887752e-02f, -2.08616070e-02f, -8.71832594e-02f, 2.04259634e-01f, 1.82338133e-01f, -8.01427886e-02f, 2.98974570e-02f, 1.83478892e-01f, 6.34567738e-02f,
  -1.07841328e-01f, -9.65488330e-02f, 2.80930489e-01f, -7.49694034e-02f, 1.65501237e-01f, 1.57623947e-01f, -1.10206313e-01f, -9.71245393e-02f, -6.77645728e-02f, 1.93365008e-01f,
  6.80246502e-02f, -1.06941596e-01f, 1.82467178e-02f, -1.24632102e-02f, -8.78422484e-02f, -2.79095247e-02f, 1.93662550e-02f, 7.38701522e-02f, 2.59534568e-02f, 8.76496062e-02f,
  2.00282633e-02f, 1.55000603e-02f, 9.15643424e-02f, -6.40321001e-02f, 5.97169250e-02f, -2.06544530e-02f, -1.55226856e-01f, -1.01930067e-01f, -1.11808077e-01f, -1.79253072e-02f,
  -3.99848036e-02f, 1.78845804e-02f, -2.15308298e-03f, 1.38981463e-02f, -6.79999143e-02f, 1.26540348e-01f, 1.98771179e-01f, -8.66213907e-03f, 1.09319694e-01f, 1.99338645e-02f,
  -8.05863738e-02f, 5.33804707e-02f, 2.59806346e-02f, -6.37698025e-02f, 7.12752109e-03f, -9.03266594e-02f, 1.62934229e-01f, -1.59193203e-02f, 8.28894749e-02f, 1.09306857e-01f,
  1.11911036e-01f, 6.55862689e-02f, -1.06460273e-01f, 3.64920907e-02f, -1.19240835e-01f, 4.41620611e-02f, 1.72921851e-01f, 1.51522592e-01f, 1.46520898e-01f, 2.18176618e-01f,
  3.24559063e-01f, 1.64342165e-01f, 2.59793669e-01f, 2.28107333e-01f, 1.60694644e-01f, 1.87808871e-01f, -2.26755768e-01f, 1.79378137e-01f, -1.63831308e-01f, -1.84250847e-01f,
  1.89797748e-02f, 1.33904502e-01f, 7.46750161e-02f, -9.18518379e-02f, 7.22731128e-02f, -5.20238653e-02f, 1.54140517e-01f, 1.17603848e-02f, 4.62864079e-02f, 1.75559446e-01f,
  2.27706552e-01f, 3.86366621e-02f, -1.17631499e-02f, -8.12402219e-02f, 7.94929340e-02f, -9.33748409e-02f, -1.18210547e-01f, -6.35880455e-02f, -6.89329579e-02f, -8.56644064e-02f,
  1.36689559e-01f, 2.69990206e-01f, 1.25380546e-01f, 2.71349568e-02f, 4.17905375e-02f, 2.79697143e-02f, 1.30923614e-01f, -1.46649823e-01f, 6.58437163e-02f, -8.53621811e-02f,
  -2.90848464e-02f, -3.67750861e-02f, 1.30420569e-02f, -1.02130055e-01f, 1.54750705e-01f, 8.54883641e-02f, 1.25929773e-01f, -1.01369657e-01f, 4.53089699e-02f, 1.32284120e-01f,
  -1.38670057e-01f, 1.38007119e-01f, 9.58920568e-02f, 5.01941592e-02f, -3.28486525e-02f, -6.51998296e-02f, 1.37267902e-01f, 1.60705626e-01f, 1.98933363e-01f, -6.27948344e-02f,
  5.37280180e-02f, -8.88958126e-02f, -8.74388218e-02f, -8.66230577e-02f, 1.14516452e-01f, -1.06589183e-01f, -1.01849847e-02f, -1.18267931e-01f, 1.02052435e-01f, -9.43837613e-02f,
  8.59532356e-02f, 1.53191820e-01f, 1.03032164e-01f, -7.89395124e-02f, 1.04218442e-02f, -5.08922003e-02f, -4.73904759e-02f, -5.03990054e-02f, -4.34793718e-02f, -1.02266446e-02f,
  -3.14059369e-02f, -4.60057855e-02f, -5.49736805e-02f, 2.77220160e-02f, -7.75517672e-02f, 1.85417458e-02f, 1.14741713e-01f, 8.57199579e-02f, -8.65588486e-02f, -5.55247702e-02f,
  -5.62113449e-02f, 1.04962572e-01f, 1.20617412e-01f, 3.18554752e-02f, -3.42027433e-02f, -4.13151383e-02f, 1.14159130e-01f, 1.84220299e-02f, 4.94937673e-02f, 1.24745123e-01f,
  4.90602180e-02f, 4.18180935e-02f, -6.79122731e-02f, 3.61714438e-02f, 1.42701611e-01f, 2.88466401e-02f, -5.25934659e-02f, -8.80723521e-02f, -1.77830458e-02f, -3.58806178e-03f,
  1.05058819e-01f, 6.08211197e-02f, -9.05258581e-02f, -9.23694596e-02f, 1.58733148e-02f, -4.57753413e-05f, 9.84466597e-02f, 1.12211317e-01f, -5.93205728e-02f, -5.27237542e-02f,
  -7.28763789e-02f, 9.86379460e-02f, 1.09244935e-01f, -1.32025480e-01f, -1.08727276e-01f, 1.38032243e-01f, -5.31255752e-02f, 1.69575408e-01f, -2.08338466e-03f, -6.63353642e-03f,
  -7.67447501e-02f, 6.37926608e-02f, 4.12812876e-03f, -1.06355757e-01f, 1.94147844e-02f, -1.05917610e-01f, 6.47082031e-02f, -5.62925823e-02f, -3.81636829e-03f, -1.81761142e-02f,
  -2.46153940e-02f, 1.57586206e-02f, -3.08811683e-02f, 1.17982805e-01f, 9.05677825e-02f, -3.16778049e-02f, -8.11431482e-02f, -2.69835461e-02f, 1.37443677e-01f, -1.89099330e-02f,
  -6.36055246e-02f, -1.19930372e-01f, -9.60219130e-02f, 1.32992297e-01f, -4.85304371e-02f, -5.33314086e-02f, -8.83043162e-04f, 6.66362569e-02f, 3.27128246e-02f, 4.58558463e-03f,
  -1.01865664e-01f, -1.23013638e-01f, -2.57636625e-02f, 1.14932090e-01f, 1.98018476e-02f, 9.41722766e-02f, -1.15275033e-01f, 1.02866404e-01f, -1.23568185e-01f, -5.78576140e-02f,
  -3.52376290e-02f, -5.32728098e-02f, -1.29724592e-02f, 1.25138834e-01f, -4.14207764e-02f, 2.96355318e-02f, 8.72722641e-02f, 1.03355825e-01f, 6.32145032e-02f, 9.39519256e-02f,
  -1.01872444e-01f, 5.09280302e-02f, -8.67971629e-02f, -2.35984400e-02f, 1.33280247e-01f, 1.14037529e-01f, 5.51259592e-02f, -1.07582644e-01f, -8.86083990e-02f, -1.04325458e-01f,
  -4.15256470e-02f, -2.49610078e-02f, 5.69348596e-02f, -7.75329471e-02f, -1.20184779e-01f, -5.97580262e-02f, -6.32687937e-03f, -6.19488284e-02f, -6.02303818e-02f, -8.51483420e-02f,
  3.73178087e-02f, -3.16543430e-02f, -4.49829884e-02f, 2.02249475e-02f, -5.06454036e-02f, -5.08883819e-02f, 8.49921033e-02f, -1.63522102e-02f, -1.47109805e-02f, 9.37627703e-02f,
  -9.29581746e-02f, 1.00539871e-01f, 3.45577449e-02f, -1.00583635e-01f, -7.40461722e-02f, -2.28220988e-02f, 1.12690739e-01f, -1.65069122e-02f, -2.20198948e-02f, 9.40837190e-02f,
  1.19013816e-01f, -1.11314550e-01f, 1.53833320e-02f, 1.12825066e-01f, 6.71657994e-02f, -1.12549856e-01f, 5.22214640e-03f, 2.64414847e-02f, -9.21512023e-02f, -5.24794050e-02f,
  1.22170180e-01f, -1.90979522e-02f, 1.01051256e-01f, -1.18176797e-02f, 6.00483641e-02f, -5.09942416e-03f, 1.06352698e-02f, -1.20131122e-02f, 3.98516282e-03f, 5.64476810e-02f,
  -4.94650975e-02f, 5.99505231e-02f, -1.06871374e-01f, 1.01160705e-01f, -2.76982263e-02f, 3.46006937e-02f, 9.38645750e-02f, -1.15123853e-01f, -1.70862488e-02f, -6.01565503e-02f,
  9.10563171e-02f, -7.13263964e-03f, -1.20421864e-01f, -1.69506930e-02f, -1.19420856e-01f, -8.69437158e-02f, -9.99868736e-02f, 6.03496060e-02f, -1.00761294e-01f, 7.76430741e-02f,
  -6.47097081e-02f, 1.20670475e-01f, -1.72954164e-02f, -1.46357184e-02f, -6.82022795e-03f, -3.02618369e-02f, 1.06543303e-01f, 4.20833826e-02f, 2.34774295e-02f, -7.40912333e-02f,
  7.17584789e-02f, -9.44101661e-02f, 5.43512963e-02f, 6.68385923e-02f, -3.58608998e-02f, -1.23448476e-01f, 1.07569620e-01f, -8.80959854e-02f, 2.65803430e-02f, 1.14696838e-01f,
  -5.88989444e-02f, 1.49489278e-02f, -1.28075201e-02f, -2.23531462e-02f, -9.20668542e-02f, -8.87515172e-02f, 3.88106778e-02f, -1.59857664e-02f, 4.63324115e-02f, 6.52234629e-02f,
  -2.26348136e-02f, 2.09727995e-02f, -2.72213165e-02f, -1.17446883e-02f, 2.61546820e-02f, -7.47157633e-02f, -1.19043542e-02f, -4.58629057e-02f, 1.37780011e-02f, -4.45146710e-02f,
  2.79408935e-02f, 9.01174396e-02f, -1.66089330e-02f, -1.20810606e-01f, -6.41537234e-02f, -1.18073672e-01f, -5.09690121e-02f, -1.62229519e-02f, 3.37183513e-02f, -2.17334349e-02f,
  -8.50544050e-02f, -2.52682380e-02f, -6.70780465e-02f, 1.05397105e-01f, -7.96362013e-02f, -1.03437960e-01f, -3.74578834e-02f, 4.64121960e-02f, -3.32569256e-02f, 1.04338050e-01f,
  -1.12341642e-01f, -7.14835748e-02f, -9.06961337e-02f, -9.86690074e-02f, 1.00347489e-01f, -2.30948012e-02f, -1.05157733e-01f, -5.65137668e-03f, 3.98948565e-02f, -5.65711074e-02f,
  -6.57463074e-02f, 2.74111573e-02f, 1.02128431e-01f, 7.40539432e-02f, -1.89610440e-02f, -1.01447478e-01f, 7.73040811e-03f, -7.00817853e-02f, 6.84883446e-02f, -1.54585773e-02f,
  -2.41712611e-02f, -7.83187300e-02f, 8.39977562e-02f, -2.06074771e-02f, -3.42204571e-02f, -1.32074906e-02f, -3.21933404e-02f, 2.68099047e-02f, 8.92383829e-02f, 8.26633908e-03f,
  1.43439084e-01f, 9.48711932e-02f, 4.57558557e-02f, -7.20768496e-02f, -1.85735710e-03f, -1.00410447e-01f, -4.47629578e-02f, -8.81055836e-03f, -4.86652963e-02f, 3.54012549e-02f,
  -8.14593136e-02f, 9.70868673e-03f, 6.24566674e-02f, 7.52866566e-02f, -9.40687060e-02f, 9.08313170e-02f, -6.45325854e-02f, 1.09152593e-01f, -1.18222021e-01f, -1.97301083e-03f,
  -7.14670345e-02f, -3.64316329e-02f, 1.35910576e-02f, 8.50758031e-02f, -9.22178775e-02f, -1.20451115e-01f, -1.53372623e-02f, -1.03627695e-02f, -6.60399646e-02f, 7.93096647e-02f,
  8.69861096e-02f, -9.57783088e-02f, -5.84280770e-03f, -8.98798034e-02f, -8.01511779e-02f, 3.63324434e-02f, 7.02774972e-02f, -3.29742245e-02f, 1.43679664e-01f, -5.36777228e-02f,
  -9.90648661e-03f, -7.98464473e-03f, -2.17519756e-02f, -7.90495053e-02f, 1.74379021e-01f, -1.21469073e-01f, -8.76898021e-02f, 7.01653734e-02f, -5.18668517e-02f, 8.65150318e-02f,
  -1.15103640e-01f, 4.02601669e-03f, 1.09053984e-01f, 1.16266429e-01f, 8.27446356e-02f, 2.18549035e-02f, 4.13316861e-02f, 3.70561890e-02f, 5.98897748e-02f, -9.12759304e-02f,
  -1.33186698e-01f, 9.78725031e-02f, 1.61949228e-02f, -4.92815822e-02f, 1.23987580e-02f, 1.22756772e-01f, 1.12913243e-01f, 7.20340833e-02f, -1.15765370e-01f, -6.73623458e-02f,
  -7.60877952e-02f, 1.67988986e-02f, 1.08145006e-01f, 7.28152394e-02f, 1.13304965e-01f, 6.88015074e-02f, -1.90375559e-02f, -2.13051792e-02f, 9.93472897e-03f, -2.17511377e-04f,
  -6.05667830e-02f, -6.63362592e-02f, 3.93752605e-02f, -9.39302072e-02f, -5.73622882e-02f, -7.68209528e-03f, 1.59859080e-02f, 9.53467749e-03f, -8.18502009e-02f, -2.72234771e-02f,
  4.88880351e-02f, 1.42713517e-01f, -1.18416637e-01f, -1.34615332e-01f, 4.58832644e-03f, 2.78471373e-02f, -3.73257883e-02f, -9.92797017e-02f, 1.10772930e-01f, 4.79579605e-02f,
  -1.85230449e-02f, -3.00727915e-02f, 2.52800900e-02f, 1.09046236e-01f, -1.27343506e-01f, 8.92614350e-02f, 1.89813357e-02f, -1.37017071e-02f, 2.94357277e-02f, 1.24249898e-01f,
  1.24664530e-01f, -2.44553220e-02f, 3.42788808e-02f, 6.74896464e-02f, -1.16470411e-01f, 7.52881393e-02f, -1.60188712e-02f, 2.56068911e-02f, 2.14662589e-02f, 1.05197899e-01f,
  -9.43021029e-02f, -7.44833797e-03f, 1.23256177e-01f, 8.60526189e-02f, -3.36028263e-03f, -9.12110135e-02f, 7.21115023e-02f, 2.63168551e-02f, -6.98079988e-02f, -4.72569698e-03f,
  -7.58546889e-02f, -8.94015059e-02f, -1.14850223e-01f, 3.99816260e-02f, -9.29498821e-02f, 8.96508805e-03f, -7.78466836e-02f, 1.09322526e-01f, -1.33694828e-01f, -9.74810272e-02f,
  -3.68892029e-02f, -2.91547477e-02f, 1.16768293e-01f, -3.11970543e-02f, 4.97311689e-02f, 1.11880057e-01f, -3.16848867e-02f, 1.78306177e-02f, 6.14283271e-02f, -7.18737626e-03f,
  -3.67429517e-02f, -3.81927378e-03f, 3.85731459e-02f, -6.12114072e-02f, -9.53529030e-02f, -1.78598857e-03f, -7.32082501e-02f, -2.13565258e-03f, -1.09969616e-01f, 3.27700041e-02f,
  1.43405735e-01f, 1.28345266e-01f, -3.72102521e-02f, -2.54848935e-02f, 3.60846855e-02f, 4.31049764e-02f, 1.43445179e-01f, 1.31664991e-01f, -1.11497752e-01f, -1.98330089e-01f,
  1.12282567e-01f, -9.10711586e-02f, -5.64919971e-02f, -4.10947204e-02f, 1.27606332e-01f, -1.06210642e-01f, -1.34230498e-02f, -9.62114632e-02f, 4.56488132e-02f, 2.68381033e-02f,
  1.33856982e-01f, 4.91828546e-02f, 4.69097123e-02f, -5.18171899e-02f, -1.03351220e-01f, -7.37853199e-02f, 1.46621764e-01f, -8.51798579e-02f, -3.52620110e-02f, 1.12675495e-01f,
  1.61302596e-01f, -1.14790291e-01f, 1.49148479e-01f, -6.10859133e-02f, 8.57415870e-02f, 3.13961916e-02f, 1.49270343e-02f, -6.89954758e-02f, 4.94109094e-02f, -1.24306671e-01f,
  -9.67336297e-02f, -7.93795958e-02f, 4.53708228e-03f, -8.27590227e-02f, 1.28124624e-01f, 7.50056505e-02f, 7.33118802e-02f, 9.45409015e-02f, 1.50004104e-01f, -3.42819653e-02f,
  -9.97628570e-02f, 9.01239552e-03f, 6.84175491e-02f, -9.20411125e-02f, -9.45140198e-02f, -7.80920833e-02f, -9.67373475e-02f, 3.05179842e-02f, 1.08102150e-01f, -7.92317539e-02f,
  1.55447394e-01f, -7.43840337e-02f, 3.95285822e-02f, -1.44045660e-02f, 9.04817507e-02f, -1.98923573e-02f, 6.86421692e-02f, 1.41719565e-01f, 1.34884715e-01f, 2.59734550e-03f,
  1.19141638e-02f, -6.31942078e-02f, 4.74515222e-02f, -6.07639961e-02f, 2.90620290e-02f, -3.99328694e-02f, 1.02258809e-01f, -2.79448088e-02f, 1.56803206e-01f, -3.35685839e-03f,
  2.81322114e-02f, -6.89492375e-02f, 4.85426448e-02f, 8.88843909e-02f, -1.49589792e-01f, -7.65828416e-02f, -9.63923484e-02f, 9.50944796e-02f, 2.40059178e-02f, -5.19293025e-02f,
  1.39064446e-01f, 4.39311452e-02f, -1.32260934e-01f, 8.27523246e-02f, 7.46750683e-02f, -1.28496468e-01f, -1.33467242e-01f, 5.91931604e-02f, -1.28094152e-01f, -1.26376674e-01f,
  1.07986756e-01f, -1.13295555e-01f, 7.24418536e-02f, 4.19231430e-02f, -5.90399839e-02f, -7.19819888e-02f, -6.41557351e-02f, 1.84888408e-01f, -5.20901456e-02f, -2.90340185e-02f,
  -1.13266475e-01f, 1.21816210e-02f, -2.43480187e-02f, -8.00749734e-02f, -8.38104822e-03f, -5.94885498e-02f, -8.04531202e-02f, -1.43454209e-01f, -7.56912753e-02f, -5.14726760e-03f,
  1.20364845e-01f, -4.62341495e-02f, -1.19124822e-01f, 1.81301758e-02f, 5.98840378e-02f, 1.31659687e-01f, 7.03185331e-03f, 2.57299274e-01f, 1.93298861e-01f, 2.29510933e-01f,
  1.47901662e-02f, 4.79284339e-02f, 1.98066369e-01f, 1.73711628e-01f, -1.31720275e-01f, -8.91654268e-02f, 1.69669345e-01f, 1.69437468e-01f, 1.43799270e-02f, 6.03337325e-02f,
  5.01450747e-02f, 7.83378929e-02f, 4.76992428e-02f, -5.93634434e-02f, -1.07291408e-01f, -1.21727563e-01f, -1.20641284e-01f, -1.82573907e-02f, 9.53653976e-02f, -7.63584599e-02f,
  9.60176140e-02f, -6.68107942e-02f, 6.72649071e-02f, 1.82846154e-03f, -1.69180706e-01f, -1.22372285e-01f, -3.42751145e-02f, 5.87670878e-02f, 5.96003942e-02f, 2.52270013e-01f,
  -3.67115438e-02f, 1.88239068e-01f, -2.97526382e-02f, 2.16731146e-01f, 1.36291888e-02f, 7.11521953e-02f, -8.60782564e-02f, 9.50823948e-02f, -1.62939932e-02f, 1.09572180e-01f,
  2.72052020e-01f, 5.56711964e-02f, -5.30389957e-02f, 4.88477796e-02f, 3.09503488e-02f, 3.99796143e-02f, 1.97562963e-01f, -2.27834657e-02f, 5.71896024e-02f, -1.31626148e-02f,
  1.76166892e-01f, 2.77585447e-01f, 4.27127406e-02f, -1.05661256e-02f, -1.03566885e-01f, -5.47178537e-02f, -4.67799790e-02f, 1.46851510e-01f, 9.22019631e-02f, 9.48672146e-02f,
  2.10158471e-02f, -7.54138529e-02f, 1.34314492e-01f, 6.51183128e-02f, 5.19378856e-02f, 1.77202374e-01f, 1.22949995e-01f, 1.85248405e-01f, -1.42340451e-01f, -1.74911208e-02f,
  -1.05247132e-01f, 4.13109623e-02f, -9.29184631e-02f, -1.19266734e-01f, -1.07683003e-01f, 1.38807833e-01f, 8.70213211e-02f, 2.04475280e-02f, 7.17009753e-02f, -1.06909707e-01f,
  -8.54189098e-02f, 1.45543560e-01f, 1.40970007e-01f, 8.57258402e-03f, 4.03033867e-02f, -1.43882055e-02f, -3.16480249e-02f, -1.08409494e-01f, -1.40127301e-01f, -9.20073316e-02f,
  -1.66814681e-02f, 1.12872645e-01f, -4.40218337e-02f, 1.86285540e-01f, -1.84640624e-02f, 2.51782723e-02f, -9.08252001e-02f, 1.75094470e-01f, 1.06255874e-01f, 1.23010278e-01f,
  6.94627687e-03f, 6.71154559e-02f, -6.61614686e-02f, -8.92430171e-02f, 1.65561020e-01f, -5.19405818e-03f, -1.26069084e-01f, 5.84351271e-02f, -8.98276716e-02f, 2.99944244e-02f,
  1.71213314e-01f, 2.43392270e-02f, -9.69660133e-02f, -4.52959817e-03f, 1.55619428e-01f, 1.82026505e-01f, 8.76870081e-02f, 7.31082410e-02f, -9.99269560e-02f, 5.08137718e-02f,
  8.41405764e-02f, -4.04245853e-02f, -3.99891138e-02f, 1.87290877e-01f, -1.48520678e-01f, -1.17907166e-01f, 1.71748355e-01f, 1.89949721e-01f, -3.65383476e-02f, 3.50017995e-02f,
  1.89110845e-01f, 1.13183847e-02f, -1.71886683e-01f, -1.17103502e-01f, -9.27608684e-02f, 1.94672361e-01f, -9.77399051e-02f, -1.35573730e-01f, 4.31856923e-02f, 3.14284191e-02f,
  -1.37771204e-01f, 1.10626161e-01f, 2.05566045e-02f, 1.05128037e-02f, 9.17905718e-02f, 1.66275516e-01f, -9.99614075e-02f, 1.18898757e-01f, -1.79288946e-02f, -7.04919621e-02f,
  5.10157458e-02f, -7.34301880e-02f, -6.24744929e-02f, -1.20939128e-01f, -7.22954869e-02f, -5.42013235e-02f, -1.09626293e-01f, 2.87800748e-02f, 4.80581298e-02f, 1.65685955e-02f,
  -1.14285378e-02f, 5.03021479e-03f, -1.26501441e-01f, 1.69531479e-01f, 9.88066792e-02f, -6.75406829e-02f, 4.41560037e-02f, -1.33825809e-01f, 1.13627136e-01f, 9.71874893e-02f,
  3.55967358e-02f, -2.67582722e-02f, 6.97381273e-02f, -9.23511684e-02f, 7.70166740e-02f, 4.12717126e-02f, 8.58859196e-02f, 7.39624426e-02f, 8.72762278e-02f, -1.35558695e-01f,
  -3.07881068e-02f, 1.52303159e-01f, -2.65056342e-02f, 2.16345247e-02f, 1.10548697e-01f, 9.82068405e-02f, -3.64545472e-02f, 1.71605185e-01f, 1.01793269e-02f, 8.82092044e-02f,
  8.47890750e-02f, -3.45066525e-02f, 1.23704456e-01f, 5.82261980e-02f, 1.28839538e-01f, 6.28224537e-02f, 4.92701083e-02f, 1.57429025e-01f, 4.40430455e-02f, 8.48719031e-02f,
  3.89610715e-02f, -1.19887680e-01f, -1.31448181e-02f, 6.76599666e-02f, 1.35830343e-01f, -7.76563734e-02f, 4.95047234e-02f, -1.37676178e-02f, -9.14526954e-02f, 1.19629458e-01f,
  -5.43469191e-02f, -9.13004652e-02f, -1.01040646e-01f, 1.09932989e-01f, 1.08341590e-01f, -1.53507674e-02f, -3.37037705e-02f, -1.99619913e-03f, 9.27828848e-02f, 4.88319546e-02f,
  -6.08757213e-02f, 1.59565508e-01f, -4.14804295e-02f, 6.17832877e-02f, -6.90766275e-02f, 1.84064850e-01f, -7.67797679e-02f, -3.27985026e-02f, 4.67654355e-02f, 8.39718208e-02f,
  -8.29721838e-02f, 4.26939130e-02f, -7.94523731e-02f, -9.63717550e-02f, -1.17825463e-01f, 6.90442398e-02f, 2.58660484e-02f, 8.09412915e-03f, 1.95292100e-01f, 1.90417003e-02f,
  -4.13528504e-03f, -1.07907869e-01f, -8.98521915e-02f, 1.73447743e-01f, 6.28344640e-02f, 2.31459960e-02f, 2.25895233e-02f, 8.71648937e-02f, -5.06307464e-03f, -1.35775849e-01f,
  8.81387815e-02f, 7.35618696e-02f, 5.90406870e-03f, -1.24220643e-02f, -3.80633287e-02f, 5.32782972e-02f, -1.04276881e-01f, 7.86341950e-02f, 1.22394338e-01f, -7.91021883e-02f,
  -4.83967848e-02f, -6.87087849e-02f, -9.11022052e-02f, 3.24414074e-02f, 4.44216989e-02f, -8.25897083e-02f, 2.64332406e-02f, -9.77607965e-02f, -9.39276963e-02f, 1.39544204e-01f,
  -1.44243352e-02f, 9.28743556e-02f, 6.52874336e-02f, -7.23426268e-02f, 8.16332251e-02f, -6.83672801e-02f, -4.57821302e-02f, 4.98612709e-02f, -1.17902793e-01f, -1.27505735e-01f,
  -2.70085596e-02f, -7.19841719e-02f, 1.11294121e-01f, -7.14388043e-02f, -1.11285798e-01f, 1.36071742e-02f, -9.18609872e-02f, 1.07938848e-01f, -3.55474725e-02f, -3.80830057e-02f,
  1.01199843e-01f, 2.87994165e-02f, -2.59924829e-02f, 1.15094461e-01f, -6.84755296e-02f, 6.84547378e-03f, -1.78312231e-02f, 2.96956743e-03f, -1.25562213e-02f, 1.16011158e-01f,
  -9.90482569e-02f, -1.22048914e-01f, 4.34455182e-03f, 1.24210835e-01f, -3.11189275e-02f, 1.26516193e-01f, -5.77039160e-02f, 7.64068291e-02f, -5.05288802e-02f, 8.26564282e-02f,
  -3.82265337e-02f, -1.13872550e-01f, -2.36114096e-02f, -3.26097831e-02f, 8.63587186e-02f, -7.94462413e-02f, 2.38271505e-02f, -1.36831149e-01f, 8.25736448e-02f, 1.60429016e-01f,
  6.37464272e-03f, -3.90483253e-02f, -2.27837618e-02f, 1.74194537e-02f, -4.91393469e-02f, -5.24601899e-02f, 1.51217298e-03f, 1.10241190e-01f, 6.38914108e-02f, 1.04069272e-02f,
  -3.81946051e-03f, 1.11903623e-01f, -8.24869499e-02f, -5.03744371e-02f, -1.11396722e-01f, 1.14637934e-01f, -7.98367411e-02f, 1.31867602e-02f, 8.28475803e-02f, 3.65743898e-02f,
  1.72176018e-01f, 7.01774359e-02f, -5.14236838e-03f, 6.16785772e-02f, -8.25080425e-02f, 1.04752034e-01f, -1.74457151e-02f, 2.55232938e-02f, -1.31529346e-01f, -8.54561571e-03f,
  3.31881791e-02f, 2.93327980e-02f, 5.40675893e-02f, 1.02013443e-02f, -7.35034421e-02f, 3.66203417e-03f, -1.07652172e-01f, 1.61679208e-01f, -4.38484177e-02f, -5.43629490e-02f,
  1.46800354e-01f, -1.04451843e-01f, -5.71048409e-02f, -1.77204702e-02f, -8.15880224e-02f, -3.66469286e-02f, 3.39020565e-02f, 7.23015442e-02f, -2.27634497e-02f, 1.33484542e-01f,
  3.24419253e-02f, 6.17886670e-02f, -1.13426544e-01f, -2.30413135e-02f, -4.74170502e-03f, 3.63221280e-02f, -5.01742512e-02f, -8.54818821e-02f, 2.50576250e-02f, -7.45369270e-02f,
  1.38251945e-01f, -7.70238340e-02f, -7.17818215e-02f, -1.19320184e-01f, -4.67084954e-03f, 9.25262198e-02f, 7.59576038e-02f, -4.97712232e-02f, -1.70265455e-02f, -8.98555070e-02f,
  6.77150562e-02f, -1.19358763e-01f, -8.07059258e-02f, 1.97047647e-02f, -1.01282112e-01f, -1.02963438e-03f, -5.79411276e-02f, -1.08146379e-02f, 1.16942590e-02f, 1.02680679e-02f,
  -7.88038298e-02f, 6.48332462e-02f, 1.18611127e-01f, -1.06511898e-01f, -1.18269816e-01f, 4.96228449e-02f, 3.63390297e-02f, -1.02998346e-01f, 8.57554227e-02f, -1.37191908e-02f,
  1.34471059e-01f, 1.17042065e-01f, 1.33442566e-01f, 1.39304951e-01f, 5.44180833e-02f, -3.16024870e-02f, 5.97575121e-02f, -4.89075631e-02f, -1.07729875e-01f, 3.78514500e-03f,
  1.23530570e-02f, 4.69686389e-02f, 1.04268275e-01f, -3.92073728e-02f, -4.38252464e-02f, -7.72887617e-02f, -1.31102726e-01f, -6.18307069e-02f, -4.76164632e-02f, 1.08726420e-01f,
  -2.00040266e-02f, -3.17525193e-02f, 4.81242575e-02f, -2.66654999e-03f, 4.85057458e-02f, 7.99517855e-02f, 1.96792092e-02f, 3.03963739e-02f, 6.53186291e-02f, -6.30103052e-02f,
  -1.19704209e-01f, -1.10219531e-01f, 7.93219730e-02f, -5.27861044e-02f, -9.52842161e-02f, -2.52586287e-02f, -1.30390510e-01f, -3.20558734e-02f, -1.15477823e-01f, -7.00100586e-02f,
  -1.09349534e-01f, -1.28385395e-01f, 9.48643386e-02f, -6.48638457e-02f, 6.40212791e-03f, -2.46714707e-02f, 6.38336018e-02f, -2.92497911e-02f, -1.04577526e-01f, 1.04534231e-01f,
  -1.23991229e-01f, 4.46764193e-03f, 9.64722037e-03f, 5.93794063e-02f, 2.01971289e-02f, 6.42964318e-02f, -1.32903187e-02f, 1.29498854e-01f, 3.94277237e-02f, 8.74465406e-02f,
  -7.40596652e-02f, -7.47373626e-02f, -1.33752853e-01f, -9.94298309e-02f, 1.23210482e-01f, -6.47877604e-02f, -5.42533584e-02f, 4.41314392e-02f, -1.08944237e-01f, 4.89703976e-02f,
  8.80332813e-02f, -7.35714510e-02f, 1.07085323e-02f, -9.07926112e-02f, -1.41072916e-02f, 3.59167927e-03f, -8.78856052e-03f, -7.73458928e-03f, 2.54820604e-02f, 9.86924395e-02f,
  1.05693236e-01f, -1.24950685e-01f, -5.24042994e-02f, 1.39658395e-02f, 4.39348184e-02f, 1.11918710e-01f, 1.66524537e-02f, -8.53544250e-02f, -1.17944703e-01f, -5.85660972e-02f,
  6.31848499e-02f, 1.26042277e-01f, -4.50685583e-02f, 7.29924068e-02f, -5.95721230e-03f, 5.33796027e-02f, -6.83249487e-03f, 8.95230845e-02f, 7.33021721e-02f, 1.60761084e-02f,
  4.24102694e-02f, -1.00275949e-01f, -2.60621067e-02f, -9.77431759e-02f, -3.49957217e-03f, 4.43953276e-02f, -2.66109090e-02f, 9.99196544e-02f, -4.21940088e-02f, 9.10092294e-02f,
  -7.98881352e-02f, -7.59315267e-02f, -7.90594369e-02f, 1.08513646e-01f, -9.48294848e-02f, 1.58541352e-02f, -4.92029786e-02f, -9.54556093e-02f, -1.42135229e-02f, -1.64493229e-02f,
  -3.36337015e-02f, 8.37784633e-03f, -6.57238513e-02f, 8.22349116e-02f, -3.52226401e-04f, -4.81785610e-02f, -1.45438462e-01f, 6.82851858e-03f, -4.62601855e-02f, 1.99226364e-02f,
  -1.16642639e-01f, 1.23393200e-01f, -4.62890416e-02f, 8.23120400e-02f, 1.19386040e-01f, 1.94366854e-02f, 3.53215337e-02f, -4.89094593e-02f, 1.47864698e-02f, -5.57869561e-02f,
  5.24534807e-02f, -2.71102358e-02f, 5.70116751e-02f, -7.50141367e-02f, 9.51376036e-02f, -1.27339527e-01f, -8.63234978e-03f, 2.16367748e-02f, -4.82241586e-02f, 7.22047985e-02f,
  -7.79838562e-02f, 2.03448534e-02f, -1.03163816e-01f, 1.68148847e-03f, 2.66086347e-02f, -6.58982471e-02f, -2.92743519e-02f, -1.39461039e-02f, 1.20872341e-01f, -1.90686397e-02f,
  -5.15010953e-02f, 3.30142006e-02f, 9.33593437e-02f, 2.88610682e-02f, 9.73686352e-02f, -3.77030224e-02f, 1.89524572e-02f, 4.59069572e-02f, 7.41288662e-02f, -7.80248716e-02f,
  -8.33914243e-03f, -2.35758740e-02f, 6.74692960e-03f, 8.56687352e-02f, 9.47828814e-02f, -2.85767559e-02f, 1.40430257e-01f, 1.02494746e-01f, -7.02040493e-02f, -8.73484761e-02f,
  8.90010595e-02f, -3.61956768e-02f, -6.36303797e-02f, 3.76987532e-02f, -8.65084082e-02f, -1.41512871e-01f, 1.64564505e-01f, -3.66864912e-02f, 1.90661717e-02f, 1.62211191e-02f,
  -1.27697829e-02f, -6.42974302e-02f, -1.22108266e-01f, 3.53702381e-02f, 1.01949595e-01f, 1.28376544e-01f, 1.08569726e-01f, 6.10483065e-02f, 9.53319147e-02f, 1.79525822e-01f,
  9.15281922e-02f, 2.07713097e-02f, -1.25871941e-01f, 7.07251625e-03f, 2.53877491e-02f, 1.29770309e-01f, -4.39898297e-02f, -4.65810001e-02f, 2.31321584e-02f, -1.17007822e-01f,
  -5.82157262e-02f, -7.99411684e-02f, 1.24153383e-01f, -3.76113970e-03f, -7.45626241e-02f, -9.87693444e-02f, 1.24348350e-01f, 2.16045499e-01f, -4.79547493e-02f, 1.83805376e-01f,
  1.24086261e-01f, -4.68623713e-02f, -7.44596645e-02f, 3.04839183e-02f, 7.99039602e-02f, -1.25146210e-01f, -1.03428096e-01f, -8.99341106e-02f, 1.35499686e-01f, 1.21973902e-02f,
  1.37622729e-01f, 1.21370303e-02f, 1.43800408e-01f, 6.28480241e-02f, -7.09049553e-02f, -3.50722997e-03f, 1.57670200e-01f, -9.06182267e-03f, 1.02774411e-01f, -1.16350450e-01f,
  5.78969307e-02f, 1.45777687e-01f, 1.04992263e-01f, -5.68987876e-02f, -6.12725616e-02f, 2.77526677e-02f, -3.01020537e-02f, -4.57034111e-02f, -8.18815827e-03f, 6.71310276e-02f,
  7.02872947e-02f, 1.80987678e-02f, 1.65112352e-03f, -5.37196398e-02f, 1.10162780e-01f, 2.76849084e-02f, -3.98207903e-02f, 7.05449581e-02f, 1.09076858e-01f, 7.68830180e-02f,
  4.98673357e-02f, 6.34374171e-02f, 1.05718434e-01f, 5.06281741e-02f, 1.03058413e-01f, 4.28130999e-02f, -1.07696004e-01f, 6.41051680e-03f, 1.06738813e-01f, -4.04810123e-02f,
  -8.47611278e-02f, -7.18343705e-02f, 4.40971181e-02f, -6.17340915e-02f, -5.01619168e-02f, 1.15077049e-01f, 1.62167251e-01f, 3.19203623e-02f, -6.71570236e-03f, -6.77523389e-02f,
  8.80497172e-02f, 1.67694449e-01f, 3.65010574e-02f, 1.28438979e-01f, 1.96923967e-02f, -2.68130228e-02f, -3.74014005e-02f, -1.00560285e-01f, 7.36202532e-03f, 8.02244172e-02f,
  -4.47194129e-02f, -4.17330023e-03f, 1.13898642e-01f, 2.19610278e-02f, 5.92530891e-02f, -5.63793443e-02f, 9.10061300e-02f, -5.42912558e-02f, -1.01935372e-01f, 9.00252312e-02f,
  1.14955850e-01f, -1.20219178e-01f, -3.00752111e-02f, -6.82927221e-02f, -2.40592435e-02f, 1.22876823e-01f, -1.04586713e-01f, 1.33305416e-01f, 1.04373612e-01f, 9.69249308e-02f,
  1.53329611e-01f, 5.18425182e-02f, -3.60372737e-02f, 1.44662306e-01f, -1.48156798e-02f, -3.60383913e-02f, 1.07669860e-01f, -5.81041873e-02f, -8.65181759e-02f, 4.98748049e-02f,
  1.41857520e-01f, -5.42896912e-02f, -6.66470081e-02f, 1.78001121e-01f, 1.29630759e-01f, 9.64759961e-02f, -1.08508147e-01f, 2.44097393e-02f, 6.05358519e-02f, 1.26876131e-01f,
  5.71384281e-02f, -1.05768174e-01f, 7.37739354e-02f, 7.69707114e-02f, -9.26974565e-02f, -6.83808252e-02f, -9.22154412e-02f, 1.17543088e-02f, -1.96550917e-02f, -1.05936393e-01f,
  1.53381437e-01f, 5.74034154e-02f, 1.10660680e-01f, 4.46783267e-02f, -8.07168707e-02f, 6.90133125e-02f, 6.85261562e-02f, 8.06651935e-02f, 2.76824348e-02f, 1.31401613e-01f,
  1.22204021e-01f, 2.80408170e-02f, -8.32955167e-02f, 5.84068857e-02f, 1.65509824e-02f, 8.94220080e-03f, -6.29921556e-02f, -2.25181244e-02f, -1.00374846e-02f, -6.50129020e-02f,
  -4.62950813e-03f, 8.65355879e-02f, -1.70217335e-01f, -4.59542722e-02f, 1.73524395e-01f, -6.81602061e-02f, -1.59644466e-02f, -5.67404926e-02f, -1.10641561e-01f, 3.50164622e-02f,
  -1.64755844e-02f, 5.87817933e-03f, 6.26655966e-02f, -1.33560911e-01f, 3.89557295e-02f, 1.03826843e-01f, 9.86515880e-02f, -5.43026738e-02f, -1.28237292e-01f, 1.15715213e-01f,
  3.04354839e-02f, 3.54719423e-02f, 3.91784795e-02f, -4.27356027e-02f, 9.44223478e-02f, -2.33226288e-02f, 3.11798397e-02f, 1.79768622e-01f, -6.64846599e-02f, 9.09084678e-02f,
  -5.78754842e-02f, 6.56458959e-02f, -1.44820856e-02f, 3.79642169e-03f, -1.14252053e-01f, 1.16958870e-02f, 1.34777296e-02f, -1.63523760e-02f, 1.88913688e-01f, 2.89541278e-02f,
  1.05693519e-01f, -4.57232930e-02f, -4.78705987e-02f, -1.16995974e-02f, 2.23529980e-01f, 1.21594302e-03f, 1.08945064e-01f, -7.61621818e-02f, -1.58244884e-03f, 2.27479786e-01f,
  -8.74347985e-02f, 9.15652066e-02f, 8.46158192e-02f, 7.79946521e-02f, -5.98830320e-02f, 4.44799140e-02f, 9.55324024e-02f, -9.74815935e-02f, 4.49740551e-02f, -2.36898847e-02f,
  1.98835671e-01f, -4.84669842e-02f, 2.65846640e-01f, 1.95210829e-01f, -3.70893511e-03f, 1.41588017e-01f, 8.83018002e-02f, 7.53626078e-02f, -2.45887749e-02f, -5.55259697e-02f,
  -2.21957415e-02f, -6.82302192e-02f, 2.37998478e-02f, 1.93005919e-01f, 1.26776129e-01f, -1.16359212e-01f, 5.75004034e-02f, -2.21954845e-02f, -1.09113961e-01f, 1.08748963e-02f,
  1.34738818e-01f, -1.45957574e-01f, 4.35687900e-02f, -1.07542180e-01f, -5.96337430e-02f, -3.72607559e-02f, 2.52186805e-01f, -4.67429012e-02f, -1.24422483e-01f, -5.06388769e-02f,
  2.10931003e-01f, -3.84017713e-02f, -1.78055873e-03f, 1.76680118e-01f, 2.13309646e-01f, 5.06761745e-02f, 1.23914734e-01f, -1.55102685e-01f, 1.66883469e-01f, -4.89257313e-02f,
  1.09202392e-01f, 6.87419474e-02f, 2.49619409e-02f, 1.31854743e-01f, 1.97141916e-01f, -3.21545191e-02f, 1.15170822e-01f, 1.02495011e-02f, 2.25039795e-01f, -8.22858438e-02f,
  -9.74024013e-02f, 2.11227648e-02f, 5.65833338e-02f, 1.93773746e-01f, 1.34017607e-02f, -1.62875101e-01f, 8.24077055e-02f, -1.12524584e-01f, 4.27852683e-02f, -5.62027246e-02f,
  3.21439207e-01f, -1.15990199e-01f, -1.00976855e-01f, -6.76755533e-02f, 1.76932663e-01f, 5.47440797e-02f, 1.43987616e-03f, 3.65692005e-02f, 1.10791465e-02f, 8.16076100e-02f,
  6.83514103e-02f, -2.39896681e-02f, -1.17706053e-01f, -1.22359591e-02f, -4.73252609e-02f, -1.20026894e-01f, 1.87859684e-01f, 1.18591726e-01f, -7.09203258e-02f, 1.25917286e-01f,
  -5.07732015e-03f, -8.16611946e-02f, 7.83254206e-03f, 2.78268885e-02f, 5.52430786e-02f, 1.61083788e-02f, 1.05226256e-01f, 1.03131235e-01f, 1.33624077e-01f, -9.48054269e-02f,
  1.08111560e-01f, -8.38235170e-02f, -1.05484746e-01f, 7.50331357e-02f, 9.27856863e-02f, -6.49615303e-02f, 2.72675101e-02f, 2.19701469e-01f, 1.90423951e-01f, 2.56347507e-01f,
  7.43144527e-02f, 1.20162163e-02f, -8.94863456e-02f, -1.12227851e-03f, 5.91790527e-02f, -1.10986739e-01f, -1.16729900e-01f, -7.70234466e-02f, -5.21696098e-02f, -1.04136765e-01f,
  -6.45090193e-02f, -2.71455143e-02f, 1.09893985e-01f, 9.17476416e-02f, -1.85520370e-02f, 4.11612913e-02f, -1.22038089e-01f, 6.30346034e-03f, 8.27741399e-02f, 1.21183973e-02f,
  -5.79588786e-02f, 4.41080704e-02f, 6.55062869e-02f, -1.61164284e-01f, 1.77759573e-01f, -1.01513207e-01f, -2.95886267e-02f, -1.54743344e-01f, 1.16636313e-01f, 8.13474879e-02f,
  1.96145654e-01f, 2.82214135e-02f, 1.12924598e-01f, 1.80732831e-02f, -5.16911000e-02f, -8.40131566e-03f, 2.52689216e-02f, -2.14718983e-01f, 9.11934450e-02f, 8.13033879e-02f,
  -4.87391464e-02f, -1.23377442e-02f, 1.90561414e-01f, 1.87667757e-01f, 1.20000914e-01f, 1.34927295e-02f, 1.63765982e-01f, 1.15476092e-02f, 8.38006362e-02f, -1.13863274e-01f,
  -1.19433515e-01f, 7.08755180e-02f, -1.69261962e-01f, -5.13990894e-02f, 1.29721299e-01f, 1.56384557e-01f, -4.72005978e-02f, 1.30545035e-01f, 1.54414415e-01f, -7.52794882e-03f,
  -1.23952337e-01f, 5.79740517e-02f, -1.29495889e-01f, 3.86209264e-02f, 2.06285808e-02f, -1.05101220e-01f, -4.11361009e-02f, -1.07645161e-01f, 2.02867314e-01f, 4.44418518e-03f,
  -4.94252034e-02f, -4.79403995e-02f, 2.43730411e-01f, 3.58543471e-02f, -8.96447822e-02f, -6.05027564e-02f, 8.72415081e-02f, -7.39700571e-02f, 9.84894633e-02f, -1.24379166e-03f,
  -2.44168080e-02f, -8.81944224e-02f, 5.12319282e-02f, -2.02576797e-02f, 5.96107095e-02f, 8.26827660e-02f, 8.81035328e-02f, 2.36975849e-02f, 1.57906160e-01f, 1.16759554e-01f,
  -5.26912184e-03f, 4.18460108e-02f, 3.65019813e-02f, 2.90125217e-02f, 1.03941284e-01f, 1.03518352e-01f, -8.13323110e-02f, 4.37689014e-02f, 4.97494824e-02f, -7.39615187e-02f,
  -4.37363014e-02f, -1.77973837e-01f, 1.02996230e-01f, -7.35401660e-02f, -1.93702001e-02f, 7.48630539e-02f, -2.67520472e-02f, 1.19664140e-01f, -5.95721416e-02f, 9.55491960e-02f,
  -4.90149818e-02f, 9.47468877e-02f, -6.36963844e-02f, -5.47902584e-02f, 2.80688237e-02f, 8.71027708e-02f, -8.54755044e-02f, 5.50973229e-02f, 1.32626534e-01f, 1.05495751e-01f,
  7.07566217e-02f, 1.00226529e-01f, 2.51062438e-02f, 6.28229827e-02f, -9.25947502e-02f, -1.51600568e-02f, -9.74716023e-02f, 3.22775617e-02f, 1.20181292e-01f, 7.84522444e-02f,
  9.37300473e-02f, -1.20503128e-01f, -6.36653453e-02f, -5.47048040e-02f, 3.16858925e-02f, 5.39798476e-02f, 1.14616185e-01f, 1.49021884e-02f, 7.90982693e-03f, -2.13693008e-02f,
  2.53053997e-02f, -1.02105327e-01f, 5.21061160e-02f, 2.63680965e-02f, -8.37258175e-02f, -1.26502976e-01f, 3.39409783e-02f, -1.26791894e-01f, 3.49384658e-02f, 7.32584894e-02f,
  4.25196625e-02f, -1.04488045e-01f, -1.12028144e-01f, -1.76034197e-02f, -4.49222513e-02f, 3.43288705e-02f, 2.13211760e-01f, 1.79000109e-01f, 5.17359562e-03f, 2.07195461e-01f,
  1.76188767e-01f, 2.20662281e-01f, 4.83228043e-02f, -1.19227052e-01f, 1.99436545e-01f, 9.02939364e-02f, 1.74720123e-01f, 6.67620078e-02f, -1.46180727e-02f, -8.56629089e-02f,
  3.61585058e-02f, 2.45374382e-01f, -1.21071689e-01f, 8.05643052e-02f, 5.21592647e-02f, 4.10212986e-02f, 1.97996907e-02f, -4.94316444e-02f, 2.57567346e-01f, 1.66499346e-01f,
  -3.18373665e-02f, 2.08878871e-02f, -1.96592566e-02f, 4.98933420e-02f, 9.91639495e-02f, 1.41020074e-01f, -3.80414142e-03f, 6.92709163e-02f, 6.33048415e-02f, 4.66560386e-02f,
  -2.26533897e-02f, -3.50914150e-02f, -1.54161409e-01f, 1.16129220e-01f, -1.66379824e-01f, 1.34264022e-01f, -3.90107706e-02f, 1.23740584e-01f, 1.33783489e-01f, -1.31648704e-01f,
  -1.17878512e-01f, 1.28405333e-01f, 1.03735462e-01f, 6.72135800e-02f, 6.44682720e-02f, 1.16397336e-01f, 1.10564105e-01f, 3.92614864e-02f, 1.93548933e-01f, -1.07455291e-01f,
  -1.89437315e-01f, 3.29616904e-01f, -5.60598262e-03f, 1.17901005e-01f, -7.00140893e-02f, 1.16510585e-01f, -2.15749636e-01f, -1.93475783e-01f, 2.19028413e-01f, -1.69051975e-01f,
  -1.12036712e-01f, 1.90604068e-02f, -4.14647050e-02f, 1.19190872e-01f, 1.06204879e-02f, -2.51212474e-02f, 4.79801893e-02f, -1.28936023e-01f, -4.89788912e-02f, 1.18445590e-01f,
  -1.24814533e-01f, -6.71306923e-02f, 9.86967608e-02f, 3.27388011e-02f, -9.18505061e-03f, 6.82997555e-02f, -3.08685005e-02f, -8.31352249e-02f, -9.86812562e-02f, -7.84686357e-02f,
  8.86036605e-02f, -5.84977157e-02f, -1.21712029e-01f, 1.20318374e-02f, -3.14594917e-02f, 1.15951553e-01f, 9.16027352e-02f, 9.14568007e-02f, -8.00388679e-02f, -1.35881174e-02f,
  8.09720159e-03f, -1.20156229e-01f, -4.31432687e-02f, -6.07646555e-02f, 7.31362328e-02f, 5.79182319e-02f, -3.97682935e-02f, 9.53392610e-02f, 9.75085795e-02f, -4.62727472e-02f,
  1.06094271e-01f, 1.17162131e-01f, 9.17986110e-02f, 9.98065248e-03f, -6.64433241e-02f, 8.53489116e-02f, 1.10819861e-01f, -6.02417253e-02f, 1.01769872e-01f, 2.40172911e-03f,
  2.42128279e-02f, 7.36678913e-02f, 4.04367223e-03f, -6.46342710e-02f, -4.66799550e-03f, 1.17212303e-01f, 1.37500957e-01f, -1.15258053e-01f, -9.99118537e-02f, -1.59794781e-02f,
  -7.42248446e-02f, -2.13514864e-02f, -1.15095213e-01f, 2.16658235e-01f, -1.67140774e-02f, -5.82995974e-02f, 3.93918119e-02f, 4.05196622e-02f, -1.75738465e-02f, -6.16511367e-02f,
  -7.09831566e-02f, 7.23057613e-02f, -2.57953275e-02f, 1.05421193e-01f, -9.71928760e-02f, -2.12413864e-03f, -3.20894085e-02f, -4.24435176e-02f, 3.21439765e-02f, 1.77169628e-02f,
  -1.25600770e-01f, -2.08211737e-03f, -1.39131218e-01f, -1.13115333e-01f, 3.81968990e-02f, -1.02010138e-01f, 4.02346104e-02f, 7.77206793e-02f, 4.20065708e-02f, -1.85909178e-02f,
  -1.09671347e-01f, -2.26167738e-02f, -4.45019230e-02f, -2.54854113e-02f, -9.64949280e-02f, -1.11538045e-01f, -2.13177446e-02f, -2.91964244e-02f, -4.36354615e-03f, 2.03858856e-02f,
  -8.20647553e-02f, -9.23928842e-02f, 2.64432821e-02f, 7.22473115e-02f, -1.22772977e-01f, -3.87792252e-02f, -1.12301566e-01f, -4.34049256e-02f, -1.03356145e-01f, 4.33616452e-02f,
  -9.52319726e-02f, 5.97428791e-02f, 7.26691112e-02f, 7.07921397e-04f, 5.23414947e-02f, -8.82085487e-02f, 4.55296151e-02f, 1.11390561e-01f, -1.30992223e-04f, 1.16034918e-01f,
  9.00616944e-02f, -9.30114314e-02f, 9.92514566e-03f, -6.12868369e-02f, 1.01014011e-01f, -9.25148129e-02f, 7.30233788e-02f, 1.28517272e-02f
};

// L1_fan_Bp_bar (Shape: 1 x 52)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 52;
const float L1_fan_Bp_bar_data[] = {
  2.29252592e-01f, 2.41146013e-02f, 2.77401417e-01f, -5.85665517e-02f, -1.69241093e-02f, 2.47273847e-01f, 1.67902023e-01f, 3.53413820e-02f, -5.43027148e-02f, 6.76972494e-02f,
  -2.04324462e-02f, -5.43859005e-02f, 1.84471277e-03f, -1.02609880e-01f, 1.50860891e-01f, 1.81961715e-01f, 1.15353711e-01f, 9.85398442e-02f, 2.69515738e-02f, 2.21208856e-02f,
  -5.12971058e-02f, 4.39271070e-02f, 2.58799165e-01f, -8.47027358e-03f, -3.51367481e-02f, -1.12361558e-01f, -7.35459030e-02f, 1.30280554e-01f, -2.73613539e-02f, -1.39008224e-01f,
  1.18946970e-01f, 4.09022681e-02f, 1.66988134e-01f, 6.40990585e-02f, 1.38313204e-01f, 5.02679721e-02f, 6.61625266e-02f, 3.56972893e-03f, -1.16747431e-01f, 1.14449590e-01f,
  -2.70882792e-05f, -3.58663425e-02f, -5.04007563e-02f, 1.81727871e-01f, 4.57430892e-02f, 6.02948107e-02f, 6.16367050e-02f, 1.93246111e-01f, -9.75271761e-02f, 2.63690561e-01f,
  6.06506914e-02f, 8.43595937e-02f
};

// L2_fan_Wp (Shape: 6 x 64)
const int L2_fan_Wp_rows = 6;
const int L2_fan_Wp_cols = 64;
const float L2_fan_Wp_data[] = {
  6.39595324e-04f, 5.67480549e-02f, 3.27069266e-03f, -4.03275788e-02f, -1.14270546e-01f, -6.24947362e-02f, 2.10373536e-01f, -4.72666472e-02f, -1.18570462e-01f, -2.44080693e-01f,
  -1.04473323e-01f, -5.74935563e-02f, -8.72172490e-02f, 4.48361859e-02f, 1.59824461e-01f, -8.87921154e-02f, 2.91376635e-02f, -2.06767052e-01f, -6.31058663e-02f, -5.68657219e-02f,
  8.11757371e-02f, 1.08209260e-01f, -1.50690852e-02f, 1.24315359e-01f, -2.07256585e-01f, 3.11754104e-02f, 3.46732199e-01f, 2.71716118e-01f, 1.10482648e-01f, -2.57396186e-03f,
  -1.98184803e-01f, -1.35767564e-01f, -6.25141785e-02f, 4.91443276e-02f, -2.55020056e-03f, -6.35331050e-02f, 6.63876608e-02f, 8.46369192e-03f, 1.21796817e-01f, -7.48169124e-02f,
  1.28822595e-01f, 9.21165273e-02f, -3.20421197e-02f, 9.36291460e-03f, -7.58560598e-02f, 1.20804012e-02f, -2.80280542e-02f, -1.02735296e-01f, -1.06590642e-02f, 3.40582244e-02f,
  -5.83643056e-02f, -9.22119468e-02f, 1.28969708e-02f, 1.56884104e-01f, -5.42172231e-02f, 2.69099865e-02f, -8.53423998e-02f, -8.72966945e-02f, 8.71012136e-02f, -1.90160438e-01f,
  -6.51112199e-02f, 1.94537178e-01f, -4.30165678e-02f, 1.07294716e-01f, -1.27479360e-01f, 5.84459491e-02f, 9.90866795e-02f, 1.45394027e-01f, -9.41731851e-04f, -5.57398871e-02f,
  -1.94526203e-02f, -7.74518773e-02f, -5.73079288e-03f, 1.20446876e-01f, 2.47817531e-01f, -6.61242977e-02f, -1.74851060e-01f, -3.75578441e-02f, -2.47578695e-02f, 9.39216465e-02f,
  1.24356478e-01f, 2.31689379e-01f, 4.97210072e-04f, -5.12191616e-02f, -3.38692181e-02f, 6.49846531e-03f, -8.05234388e-02f, 8.23915750e-02f, 1.04162237e-02f, 3.07441112e-02f,
  5.25640734e-02f, 9.47991759e-02f, 3.52090858e-02f, -1.66454732e-01f, 6.28404915e-02f, 6.69866502e-02f, 2.76570804e-02f, -8.69106427e-02f, 3.79298031e-02f, 1.20783836e-01f,
  4.36111493e-03f, -1.24290980e-01f, 1.03623740e-01f, -6.01275750e-02f, 1.01535700e-01f, 3.31842341e-02f, 6.56215176e-02f, -1.02126218e-01f, 2.18113855e-01f, 9.73535553e-02f,
  -6.35672966e-03f, 1.36775643e-01f, -2.65380461e-02f, 7.33798519e-02f, -5.51385581e-02f, 1.02642916e-01f, -6.85422346e-02f, -3.01520731e-02f, 4.13379893e-02f, 1.39750792e-02f,
  6.46307468e-02f, -5.41905640e-03f, -5.49967550e-02f, -1.38186529e-01f, -7.47609138e-02f, 3.43470499e-02f, 4.87515517e-02f, 1.35894001e-01f, 4.74152490e-02f, 6.75107017e-02f,
  -3.03613693e-02f, -4.99700271e-02f, 4.20695692e-02f, -1.10448830e-01f, 1.51062772e-01f, -1.49432421e-01f, -1.35028496e-01f, -9.72803384e-02f, 2.67873146e-02f, -2.62772501e-01f,
  -2.49475732e-01f, -9.64006335e-02f, 1.96984157e-01f, -1.48574293e-01f, 8.89810454e-03f, -1.16287485e-01f, 6.26499504e-02f, 6.84180250e-03f, 1.20120563e-01f, 1.30347610e-01f,
  -3.29587273e-02f, -4.90372516e-02f, 1.06347529e-02f, -1.05669610e-01f, 3.11774731e-01f, 2.24885806e-01f, 5.30586531e-03f, -8.20185244e-02f, -5.14665544e-02f, 2.44328417e-02f,
  -6.33904040e-02f, -1.36833653e-01f, 8.91586244e-02f, -9.28916223e-03f, 7.55912662e-02f, -6.63223863e-02f, 7.39525110e-02f, -2.89579593e-02f, 7.61410967e-02f, -6.66659549e-02f,
  -1.18503772e-01f, -4.86719795e-02f, -1.15376256e-01f, -7.70851150e-02f, 1.53736845e-01f, -8.41491818e-02f, 2.00472977e-02f, 9.81520414e-02f, -1.17705874e-01f, 6.79599494e-02f,
  1.06782362e-01f, 5.33169769e-02f, -9.16529223e-02f, -1.46243259e-01f, -2.12238416e-01f, -6.43684790e-02f, 1.62247106e-01f, -1.86923623e-01f, -1.38533309e-01f, 3.36507373e-02f,
  1.37966231e-01f, -1.95667725e-02f, 1.57764807e-01f, -8.30117092e-02f, 1.88034098e-03f, -8.54635015e-02f, -6.14340045e-02f, -1.58275709e-01f, 2.22289667e-01f, -2.00191624e-02f,
  2.60204840e-02f, -5.85189834e-02f, -2.14844033e-01f, 6.94627389e-02f, -2.02119630e-02f, 1.30176216e-01f, 1.11078143e-01f, -1.01205148e-01f, -1.08331881e-01f, -1.74827456e-01f,
  -1.21007003e-01f, 9.03039332e-03f, 1.12626530e-01f, -8.20339024e-02f, 1.28936782e-01f, 3.17999832e-02f, 8.90246928e-02f, 3.17865796e-02f, 2.29638934e-01f, -5.50983325e-02f,
  1.00711495e-01f, -1.62778120e-03f, -4.17893790e-02f, 1.32062063e-02f, -7.64207542e-02f, -7.15975314e-02f, -1.63079530e-03f, -2.88257208e-02f, 5.92048392e-02f, 5.32803684e-03f,
  1.03522442e-01f, -8.50718617e-02f, -5.21761216e-02f, 4.18075267e-03f, -9.28412005e-02f, 1.13897972e-01f, -1.21765263e-01f, -1.19025856e-01f, -1.18832560e-02f, -7.03319088e-02f,
  -4.26799469e-02f, -4.82534058e-02f, -9.51040760e-02f, -5.07098138e-02f, -6.22662306e-02f, -1.22560859e-02f, 3.27670388e-02f, 1.69237554e-02f, -1.40857145e-01f, -1.01875504e-02f,
  -1.66057870e-02f, 1.26950651e-01f, -1.03216186e-01f, 6.62659258e-02f, -5.30402437e-02f, 6.98750168e-02f, 1.48017019e-01f, -2.30957549e-02f, 1.02476329e-01f, 1.15651332e-01f,
  -3.04830167e-02f, 2.18620971e-02f, 2.02896476e-01f, -3.71539265e-01f, 1.01168789e-01f, 1.14412412e-01f, -1.36862755e-01f, 6.79406226e-02f, 5.93256652e-02f, 1.26376539e-01f,
  2.19291672e-01f, -1.03766188e-01f, -1.14200048e-01f, -1.40964836e-01f, -8.29450265e-02f, 7.45734721e-02f, 1.33435383e-01f, 4.35820706e-02f, 7.97169749e-03f, -7.38829523e-02f,
  -1.18506536e-01f, -1.22086033e-01f, 5.45826219e-02f, -1.38386354e-01f, -9.21837538e-02f, -2.02350412e-02f, 9.27389190e-02f, 5.12575954e-02f, 3.73834260e-02f, -1.09265722e-01f,
  1.78564593e-01f, -8.21304247e-02f, 2.64829285e-02f, -9.72675309e-02f, 9.78622288e-02f, -1.74163431e-02f, 1.05709012e-03f, 5.72172925e-02f, -1.20373026e-01f, 2.24898085e-01f,
  -5.86840324e-02f, -1.50080070e-01f, -3.73251475e-02f, -3.32780704e-02f, -1.05156519e-01f, -3.64665352e-02f, -1.20939113e-01f, -1.36823265e-03f, -5.86144114e-03f, -1.21924639e-01f,
  -5.87184988e-02f, -1.75262298e-02f, 4.99195419e-02f, 1.70602188e-01f, -1.34640649e-01f, -5.06431684e-02f, -2.60170605e-02f, -2.69836128e-01f, 1.05486386e-01f, -7.81690981e-03f,
  9.36438441e-02f, 2.56506335e-02f, -1.82128195e-02f, -9.88241583e-02f, -2.83975806e-02f, 6.14246428e-02f, 5.98899908e-02f, 2.02886522e-01f, -2.39108615e-02f, -1.55761745e-02f,
  1.85992241e-01f, -5.22460118e-02f, -2.39883378e-01f, -4.37731631e-02f, 8.56550131e-03f, 1.26208737e-01f, -3.68579179e-02f, 1.70575064e-02f, 3.20922770e-02f, -1.02845311e-01f,
  -4.56282794e-02f, 2.31046807e-02f, -1.26271188e-01f, -5.76014593e-02f, -9.70390067e-02f, 2.46308185e-02f, 1.03787132e-01f, 4.11917344e-02f, 9.62216705e-02f, -6.08318448e-02f,
  -7.70804137e-02f, 5.26625253e-02f, 8.48987699e-03f, -7.34086558e-02f, -6.65201470e-02f, -3.00379773e-03f, 1.09150186e-01f, 1.06686816e-01f, 2.57607084e-03f, 9.43792388e-02f,
  1.39526814e-01f, 2.70497091e-02f, -1.01682171e-01f, 3.94660011e-02f, 1.25618830e-01f, -2.44391188e-02f, 1.34858534e-01f, 1.34356655e-02f, 7.61474520e-02f, 7.29677975e-02f,
  -1.20402463e-01f, 1.26325876e-01f, 7.20764548e-02f, 1.94180496e-02f, 5.01621738e-02f, -6.08540140e-02f, 3.15843858e-02f, -1.61548421e-01f, 1.12495512e-01f, -5.65661043e-02f,
  -1.38635505e-02f, 1.16006777e-01f, -3.54396366e-02f, 3.34692821e-02f
};

// L2_fan_Wp_bar (Shape: 52 x 64)
const int L2_fan_Wp_bar_rows = 52;
const int L2_fan_Wp_bar_cols = 64;
const float L2_fan_Wp_bar_data[] = {
  1.31049687e-02f, 6.79577142e-02f, -7.59959146e-02f, -6.42264858e-02f, -1.08451523e-01f, -1.13321580e-01f, -6.77030161e-02f, 1.25615433e-01f, -1.43682808e-01f, -3.60534191e-02f,
  3.00680250e-02f, -1.16020469e-02f, 9.06880796e-02f, -1.29976310e-03f, -5.63536845e-02f, -4.03333306e-02f, -1.09976225e-01f, 1.59804244e-02f, -4.45631482e-02f, -1.19117066e-01f,
  5.81576712e-02f, 2.18363907e-02f, 8.85099247e-02f, -1.49067994e-02f, 4.56378125e-02f, 1.16869822e-01f, 1.67945296e-01f, 1.12981871e-01f, -1.74640864e-02f, 7.33778402e-02f,
  -5.98960705e-02f, 1.43084358e-02f, -1.11571811e-01f, -1.02022611e-01f, 1.46612003e-01f, 9.46377963e-02f, 2.88967490e-02f, 4.41736355e-02f, -7.02822134e-02f, -3.31744961e-02f,
  -1.13505987e-03f, 7.38900080e-02f, -6.07404374e-02f, 1.54189123e-02f, -7.25662187e-02f, 5.51492795e-02f, -6.01110235e-02f, -6.36491133e-03f, -1.00895651e-01f, 8.54673684e-02f,
  -1.05520822e-01f, -6.08712137e-02f, -1.54303676e-02f, 7.21085146e-02f, -5.44240624e-02f, -5.48781082e-02f, -6.02037385e-02f, -5.53298295e-02f, 5.80535121e-02f, 1.08598933e-01f,
  -1.04246758e-01f, -7.52127990e-02f, -6.32337183e-02f, 4.21344377e-02f, 4.79814075e-02f, 7.13918507e-02f, 1.87105268e-01f, 2.26575390e-01f, 1.08359151e-01f, 1.94049194e-01f,
  3.02092224e-01f, -2.19450980e-01f, -1.91207796e-01f, 2.30319649e-01f, 5.09994626e-02f, -2.37892821e-01f, -9.08592194e-02f, 2.58627664e-02f, 3.43279272e-01f, 9.14246663e-02f,
  8.12426768e-03f, 6.24566153e-02f, 5.25636859e-02f, 1.01718508e-01f, -1.30592182e-01f, -1.62137169e-02f, -3.99416909e-02f, -1.00587323e-01f, -1.29831314e-01f, -1.07464202e-01f,
  3.86729896e-01f, 8.50921124e-02f, -7.80924931e-02f, -8.48396122e-03f, -1.19667441e-01f, -2.17257757e-02f, -1.92014500e-03f, -1.04730755e-01f, 2.51308858e-01f, 2.93601695e-02f,
  1.19495526e-01f, 4.11331356e-02f, 1.03940733e-01f, 3.60185429e-02f, 7.19395429e-02f, 1.08142095e-02f, 9.80270654e-02f, -9.24477875e-02f, 2.37197056e-02f, -3.55148502e-02f,
  -1.52799170e-02f, 1.37053743e-01f, 1.20666936e-01f, 9.86360162e-02f, -7.28149340e-02f, -1.06737159e-01f, 8.35006591e-03f, -3.36581119e-03f, -3.17451172e-02f, -1.55955413e-02f,
  -1.25781903e-02f, 4.28666696e-02f, 1.92529172e-01f, -1.49195582e-01f, -3.30930017e-02f, 2.02869877e-01f, 1.25917584e-01f, -2.49376390e-02f, 5.91618894e-03f, 1.82930619e-01f,
  1.58172846e-01f, -3.63441929e-02f, 6.66142851e-02f, 1.45790741e-01f, -2.53269728e-02f, -1.74639031e-01f, -1.88954577e-01f, 4.34953682e-02f, 1.76449597e-01f, -9.07998756e-02f,
  -1.99088097e-01f, 4.76529151e-02f, 1.70239940e-01f, 4.29779813e-02f, 1.27845258e-01f, -2.79699303e-02f, 1.85561836e-01f, -7.02649727e-02f, -3.03860847e-02f, 5.61432354e-03f,
  1.35092825e-01f, -1.23323217e-01f, -1.60083190e-01f, -3.08055021e-02f, 2.36023009e-01f, 2.33847439e-01f, -3.10950838e-02f, -1.17597327e-01f, -1.24455437e-01f, 8.04427564e-02f,
  -7.69723728e-02f, -1.36663258e-01f, 2.78627604e-01f, 1.97119080e-02f, 1.29340753e-01f, -2.82047335e-02f, 6.85781660e-03f, 8.67010057e-02f, -8.92790779e-02f, 1.23818060e-02f,
  5.50854802e-02f, -1.20946959e-01f, 6.70976043e-02f, -2.35878732e-02f, -4.11105864e-02f, -6.36224300e-02f, 1.45308087e-02f, 6.13494329e-02f, -1.29279479e-01f, -1.19669639e-01f,
  -9.78214890e-02f, -7.63614550e-02f, 7.10777491e-02f, -8.57281536e-02f, 2.86878888e-02f, 7.66824232e-03f, 1.06213585e-01f, 8.75384882e-02f, -4.00032755e-03f, 1.44513369e-01f,
  -4.08771373e-02f, 3.54703516e-02f, -1.28226966e-01f, 3.87665480e-02f, 1.40048489e-01f, -2.11243723e-02f, -2.82199215e-03f, -1.02810591e-01f, -9.39614698e-02f, 4.26352546e-02f,
  -2.08912909e-01f, 1.10634387e-01f, 1.42459020e-01f, 5.60542829e-02f, -8.41668900e-03f, -2.45336406e-02f, 8.46129004e-03f, 3.57575156e-02f, 8.45494941e-02f, 2.40769118e-01f,
  1.65508822e-01f, -3.74415182e-02f, 3.27731445e-02f, 9.45599824e-02f, 1.06268801e-01f, -2.62913276e-02f, -2.57814932e-03f, -1.06548108e-01f, 1.85895681e-01f, 1.49311572e-02f,
  -1.67604640e-01f, -9.40241367e-02f, 2.11078823e-02f, 8.90870690e-02f, -1.14724398e-01f, 6.55410439e-02f, 1.02995560e-01f, 9.96286646e-02f, -6.70268089e-02f, 9.42425281e-02f,
  3.99149656e-02f, 4.99469414e-02f, 1.41377538e-01f, 9.17371269e-03f, -6.94076344e-02f, -1.05979871e-02f, 2.82789499e-01f, -2.55331080e-02f, -6.72496855e-02f, -2.83041894e-02f,
  2.34164223e-02f, -7.03555122e-02f, -5.81241027e-02f, 4.32283208e-02f, 1.07278518e-01f, 2.04043120e-01f, 1.08997472e-01f, 1.00032061e-01f, 1.89012289e-01f, 4.42803055e-02f,
  1.79739684e-01f, 2.36053243e-02f, -1.18502863e-01f, 1.54016599e-01f, 2.74558403e-02f, 5.26587293e-02f, -9.84387398e-02f, 6.15485683e-02f, -4.68654372e-02f, -5.76506704e-02f,
  -1.40168935e-01f, -5.55645041e-02f, -5.60047925e-02f, 7.75164962e-02f, -9.43440422e-02f, 9.47329774e-02f, 1.13341786e-01f, -1.17878988e-01f, 9.07782167e-02f, -5.24971448e-02f,
  8.13806430e-03f, 2.88114212e-02f, -8.15260336e-02f, 2.07926407e-01f, -3.92765142e-02f, 2.45111603e-02f, 9.01843607e-02f, -2.85584722e-02f, 5.68096451e-02f, 4.72883135e-03f,
  1.00310601e-01f, 3.26468144e-03f, 1.22007430e-01f, 1.25287324e-01f, -1.25319183e-01f, 5.52527271e-02f, -8.33885893e-02f, 5.39537109e-02f, -1.59650855e-02f, 9.10394453e-03f,
  1.49780408e-01f, 1.46022871e-01f, -1.01738423e-01f, -8.16494972e-02f, 1.17746219e-01f, 8.55849981e-02f, 1.14820868e-01f, -1.15672484e-01f, -2.60536559e-02f, -4.59729284e-02f,
  1.98845938e-01f, 1.47963390e-01f, -9.90394223e-03f, 7.56817162e-02f, -1.00459330e-01f, 5.57975098e-02f, 3.90291400e-02f, -5.21582402e-02f, -4.56141867e-02f, 1.22585125e-01f,
  -5.61257862e-02f, 1.41488919e-02f, -6.62717149e-02f, 2.09873632e-01f, -4.89930389e-03f, -7.09521119e-03f, -1.02764033e-02f, -5.59627302e-02f, 4.26774472e-02f, -3.69826406e-02f,
  3.81930098e-02f, 1.13049008e-01f, 1.44472674e-01f, -6.74570650e-02f, -4.85122353e-02f, 9.22383815e-02f, -1.69500336e-02f, -1.09921336e-01f, 1.70521840e-01f, 7.89551158e-03f,
  -1.34446109e-02f, 8.96853134e-02f, 2.92126238e-01f, -7.49789998e-02f, -4.39378917e-02f, 7.44020790e-02f, 3.34915295e-02f, -1.73690617e-02f, 5.67115359e-02f, 5.34822792e-02f,
  1.75556421e-01f, -4.25011367e-02f, 4.31351922e-02f, 1.48694471e-01f, -8.82083997e-02f, 1.10490816e-02f, 1.48538351e-02f, -4.35746275e-02f, -8.99939891e-03f, -1.02035455e-01f,
  -2.04537809e-02f, -7.75036141e-02f, -1.11833327e-01f, 1.74502686e-01f, 1.40669057e-02f, -1.02926813e-01f, 8.68941844e-02f, -3.81267592e-02f, -6.35609552e-02f, -7.97888041e-02f,
  -1.16355978e-01f, -5.10450918e-03f, 9.82049629e-02f, 1.24037854e-01f, -3.12894396e-02f, 8.24457109e-02f, 3.96726541e-02f, -8.84000584e-02f, -1.13388211e-01f, 7.04671890e-02f,
  -3.73827033e-02f, -1.17155507e-01f, -2.29531266e-02f, -9.45746750e-02f, 1.27851814e-01f, -6.63158819e-02f, 1.25605300e-01f, 6.50443360e-02f, 7.94925392e-02f, 7.10830912e-02f,
  1.39930397e-01f, -9.52671245e-02f, 7.08996207e-02f, -9.17472914e-02f, -4.49689813e-02f, 6.97626323e-02f, -4.02433611e-02f, -1.29372567e-01f, 3.84764262e-02f, -1.20692603e-01f,
  1.08177193e-01f, 4.82701175e-02f, 6.74229860e-02f, 3.02809123e-02f, 1.84440538e-02f, 1.45448865e-02f, 3.74036580e-02f, 2.32043304e-02f, 9.16772038e-02f, -1.34861823e-02f,
  1.06871026e-02f, -4.08606827e-02f, -5.34421252e-03f, -8.54695663e-02f, 2.25932710e-02f, 1.24730803e-01f, -1.10618465e-01f, -4.44018841e-02f, -7.27889463e-02f, 3.69650759e-02f,
  1.16428815e-01f, 8.79197121e-02f, 1.02586918e-01f, 1.02034137e-01f, 1.14898831e-01f, 8.48806724e-02f, -6.19818121e-02f, -8.39472711e-02f, -7.60245547e-02f, -3.85809690e-02f,
  3.23235840e-02f, 2.04536580e-02f, -9.52106491e-02f, -1.06720954e-01f, -5.36230095e-02f, 4.70766984e-03f, -1.31654188e-01f, -4.07792479e-02f, -1.76107734e-02f, -7.87063166e-02f,
  1.26702830e-01f, -3.94820981e-02f, 9.16953310e-02f, -1.16192862e-01f, 8.24241489e-02f, -6.67279735e-02f, -4.10497151e-02f, -6.75188303e-02f, 4.11787741e-02f, 9.50211734e-02f,
  -8.72154310e-02f, 3.65263000e-02f, -1.11653350e-01f, -8.69509354e-02f, 1.15053244e-01f, 2.00759377e-02f, -1.63712017e-02f, 6.85639679e-02f, 5.36973849e-02f, 3.15200798e-02f,
  1.47558227e-01f, -2.75109317e-02f, 1.10703111e-01f, -2.04059985e-02f, 1.30504519e-01f, -1.49991199e-01f, -8.65755007e-02f, 1.20288029e-01f, 5.41016599e-03f, 1.26018524e-01f,
  5.16106077e-02f, -1.00751251e-01f, -5.09755723e-02f, 4.71619219e-02f, -9.96003523e-02f, -1.77234709e-02f, 9.53082442e-02f, -1.05917834e-01f, -4.19314578e-02f, -6.33249506e-02f,
  1.42256737e-01f, -8.56289789e-02f, 7.49272779e-02f, 1.00976221e-01f, -1.10451048e-02f, 1.06260099e-01f, -1.13060243e-01f, 1.44458920e-01f, 5.78492135e-02f, 9.07051265e-02f,
  -4.67991494e-02f, -1.37260050e-01f, 2.63489842e-01f, -1.13930374e-01f, 1.19180121e-02f, 9.17390659e-02f, -8.74264259e-03f, 2.47495482e-03f, 3.49339843e-02f, 9.52283144e-02f,
  -3.19108069e-02f, 4.06451337e-02f, 4.83858399e-02f, 6.62483498e-02f, 3.20741571e-02f, -3.51850800e-02f, 1.62777938e-02f, 6.19527027e-02f, -6.96575046e-02f, 1.09543584e-01f,
  2.80400049e-02f, -1.49140628e-02f, 1.51454151e-04f, 1.02202475e-01f, 4.10797335e-02f, 6.44377396e-02f, -2.54901294e-02f, 1.11250252e-01f, -7.79721588e-02f, 3.41090001e-02f,
  3.17585617e-02f, 2.94597950e-02f, -2.53316853e-02f, -1.60387326e-02f, 1.88918859e-01f, 2.62569655e-02f, 9.00891945e-02f, 9.56769064e-02f, 5.84959984e-03f, -1.82564072e-02f,
  1.23538621e-01f, 1.31875545e-01f, -1.41834289e-01f, 1.20663293e-01f, 1.68942079e-01f, -5.24960794e-02f, 1.22047827e-01f, 1.02755383e-01f, -9.90884975e-02f, -5.24218418e-02f,
  -6.02874570e-02f, 1.19286589e-01f, 1.61215395e-03f, -1.37721747e-01f, 9.21090245e-02f, 8.73610303e-02f, -6.83498681e-02f, 3.18907052e-02f, -8.73175338e-02f, -5.16538695e-03f,
  -1.37424271e-03f, -4.42126878e-02f, -3.34222764e-02f, 1.03898324e-01f, -5.58365844e-02f, 6.77949861e-02f, -4.33515012e-02f, -7.63331130e-02f, -6.12933561e-02f, -4.38892879e-02f,
  -7.22615495e-02f, -1.16438128e-01f, -2.70410459e-02f, -4.85775433e-02f, 1.02197267e-01f, -6.59044832e-02f, 2.52048858e-02f, -9.95865688e-02f, -6.65940046e-02f, -1.28395651e-02f,
  -1.21096753e-01f, -9.51980725e-02f, -6.27650172e-02f, -5.37730567e-02f, 1.10166073e-01f, -1.13939092e-01f, 1.09347321e-01f, 9.02179256e-02f, 1.22343950e-01f, 1.03747420e-01f,
  -9.31060687e-02f, 1.94175199e-01f, 1.49010286e-01f, 6.26892447e-02f, -7.93321058e-02f, -1.73415784e-02f, 6.34035915e-02f, -7.28735104e-02f, 7.88033977e-02f, -1.08264729e-01f,
  2.77024694e-02f, -1.07666872e-01f, -9.03004035e-02f, 5.28074242e-02f, -8.08432028e-02f, -1.20982356e-01f, 4.12364155e-02f, 2.26867814e-02f, -9.45147425e-02f, 1.11635879e-01f,
  -7.36571625e-02f, 8.35615471e-02f, -1.06125221e-01f, 4.58087598e-04f, 7.90365860e-02f, 2.56328401e-03f, -8.34236741e-02f, -7.25032240e-02f, -4.22905423e-02f, -3.03255338e-02f,
  4.10009846e-02f, -3.58988158e-02f, -1.18413068e-01f, 5.07066138e-02f, -5.10283522e-02f, -7.51098543e-02f, 6.97929487e-02f, 5.37416041e-02f, -4.89353985e-02f, 3.30450125e-02f,
  -8.25249106e-02f, -7.10026398e-02f, 1.01295836e-01f, 5.45410030e-02f, 1.23702958e-01f, 4.36022058e-02f, 5.56493141e-02f, -8.06118250e-02f, -7.49717802e-02f, 2.49684397e-02f,
  8.89240801e-02f, 8.98889974e-02f, 1.26347572e-01f, -8.33921600e-03f, 6.34354027e-03f, -2.14338098e-02f, -6.68363124e-02f, -1.42117888e-02f, 3.38880606e-02f, 1.16520226e-01f,
  -3.89180742e-02f, 1.14432149e-01f, 8.95256922e-02f, -7.53334314e-02f, 5.64747415e-02f, -6.67432919e-02f, -1.12323508e-01f, -7.34592229e-02f, -9.05074552e-03f, 3.24179083e-02f,
  2.22249702e-01f, 1.63113177e-01f, 2.13717356e-01f, 2.34478056e-01f, 1.42797723e-01f, 2.38054916e-01f, -3.67951006e-01f, 4.46524352e-01f, 1.59254685e-01f, -2.52367169e-01f,
  2.91054219e-01f, -4.20826301e-02f, -2.57493675e-01f, -5.81380874e-02f, 8.95875916e-02f, -1.79865751e-02f, -1.09460779e-01f, 4.22708213e-01f, 6.37621805e-02f, -1.96160674e-01f,
  7.05639720e-02f, -1.06836960e-01f, -1.01965576e-01f, -9.88490134e-02f, 1.52260214e-01f, -8.40203464e-02f, -2.34395742e-01f, 3.13161850e-01f, 1.49326682e-01f, -7.31240511e-02f,
  2.91942451e-02f, 1.41820656e-02f, 3.89677994e-02f, 1.70595616e-01f, 9.06062797e-02f, 8.49768668e-02f, -3.83373648e-02f, -1.01768360e-01f, -8.65038112e-02f, -8.38643461e-02f,
  9.85364318e-02f, -1.90407839e-02f, -4.48081978e-02f, -1.12747222e-01f, 3.88260812e-01f, 3.13566655e-01f, 5.13111800e-02f, 1.68598607e-01f, -2.84439847e-02f, 1.45536646e-01f,
  9.78114456e-02f, 2.75275148e-02f, -1.84339117e-02f, -3.24998051e-02f, 5.59699163e-02f, 2.00182989e-01f, 2.16560304e-01f, -1.81790173e-01f, 2.00036801e-02f, -8.93039405e-02f,
  1.99580751e-02f, 3.39114875e-01f, 7.73961917e-02f, -5.91941178e-02f, 6.54833987e-02f, -2.24129595e-02f, -7.29926005e-02f, 4.58957292e-02f, 8.33774507e-02f, 1.20857745e-01f,
  -1.13665663e-01f, 1.01654992e-01f, -9.71539766e-02f, 1.01736426e-01f, -1.48614757e-02f, 4.47189733e-02f, -9.89507884e-02f, 1.94426812e-02f, 1.04880780e-01f, 4.96466123e-02f,
  4.05023135e-02f, -7.83179626e-02f, 8.75056256e-03f, -9.12882164e-02f, 3.54823726e-03f, 7.60996481e-03f, -7.19118267e-02f, 1.24338362e-03f, -2.44529042e-02f, 1.75725352e-02f,
  -1.19097330e-01f, -1.26667589e-01f, 1.89752597e-02f, -1.23591319e-01f, 5.81287332e-02f, 9.25090984e-02f, -1.10269487e-01f, 5.57888160e-03f, -7.34788924e-02f, -8.53933394e-02f,
  -1.05289683e-01f, 2.06078216e-02f, 2.30223332e-02f, 9.82328132e-02f, -7.73720816e-02f, -1.91496611e-02f, 1.46242911e-02f, -1.35005325e-01f, 6.61585853e-02f, -9.12383199e-02f,
  7.40953460e-02f, -4.99079600e-02f, -7.87443146e-02f, -7.66275376e-02f, -6.73642009e-02f, -1.00776732e-01f, -6.73902631e-02f, -2.82610115e-02f, 6.76304996e-02f, -5.72408661e-02f,
  -1.04059771e-01f, -1.54814674e-02f, -4.14921762e-03f, -6.35417923e-02f, 1.79010145e-02f, 1.06368195e-02f, 2.36430299e-02f, 5.98289184e-02f, 8.05211812e-02f, 1.48320705e-01f,
  4.30569462e-02f, 2.80896902e-01f, 2.15357333e-01f, 1.41839132e-01f, -2.88297664e-02f, 1.63323939e-01f, 2.98892289e-01f, -2.61423707e-01f, -1.56832248e-01f, 1.04670703e-01f,
  1.05680123e-01f, 5.88143207e-02f, 2.98849851e-01f, 5.32868225e-03f, -3.98113094e-02f, 8.43092576e-02f, -1.35155261e-01f, -1.28540099e-02f, -3.54294740e-02f, 2.97287051e-02f,
  -7.43041933e-02f, 9.69669521e-02f, 1.26951128e-01f, -2.92853117e-02f, 3.11225317e-02f, -1.78378411e-02f, 1.10350341e-01f, -7.10462928e-02f, -1.12600334e-01f, -3.40158902e-02f,
  1.30894005e-01f, 1.50989145e-01f, 4.56703492e-02f, -8.49050134e-02f, 7.77534321e-02f, 7.44216959e-04f, -1.43836468e-01f, 5.36546074e-02f, 7.94349052e-03f, -9.55908671e-02f,
  -7.14882696e-03f, 9.01149660e-02f, -7.03935549e-02f, 8.37274194e-02f, 1.75193280e-01f, -6.98647797e-02f, 5.59161268e-02f, 6.67725727e-02f, 3.56200174e-03f, 5.92383109e-02f,
  2.45689787e-02f, -2.01046407e-01f, -1.53461844e-01f, 1.55196488e-01f, -8.65219608e-02f, -2.54388511e-01f, -9.92221832e-02f, 6.05781451e-02f, -9.48742107e-02f, 2.48681232e-01f,
  -6.88124262e-03f, 4.75407057e-02f, -9.92773771e-02f, -1.10755637e-01f, 6.57567456e-02f, 7.77653232e-02f, -8.43743905e-02f, 7.64623955e-02f, -1.00095727e-01f, 1.66088864e-02f,
  -1.13321513e-01f, 9.91884917e-02f, -3.27668898e-02f, -1.01589501e-01f, 5.23635112e-02f, 8.88630301e-02f, 1.38762876e-01f, 1.25396729e-01f, -8.78782421e-02f, 6.01939075e-02f,
  -9.89374816e-02f, 1.52368173e-02f, 5.06212898e-02f, -4.64286916e-02f, 4.58746701e-02f, 1.16451234e-01f, 4.71434519e-02f, -6.02706522e-03f, 6.52062297e-02f, -1.23672023e-01f,
  -4.30098176e-02f, -5.85909709e-02f, 7.53318220e-02f, -4.71320450e-02f, -9.73322541e-02f, 2.49900203e-02f, -1.00109108e-01f, -6.30744770e-02f, -9.90610868e-02f, 2.12987252e-02f,
  3.06481831e-02f, 2.25981623e-02f, -1.55600568e-03f, -1.21075317e-01f, -3.82987000e-02f, 1.12064213e-01f, 1.83214303e-02f, 1.39115706e-01f, -9.06648040e-02f, 1.20357044e-01f,
  3.38974930e-02f, 6.09498732e-02f, -5.97950183e-02f, -6.20884821e-03f, 1.31367650e-02f, 5.42742498e-02f, 1.74491052e-02f, 1.02912314e-01f, -1.36442287e-02f, 1.39668971e-01f,
  7.96222501e-03f, 1.22772843e-01f, 1.72370113e-02f, -3.39580094e-03f, 6.87619001e-02f, 6.15850091e-02f, -1.18890777e-02f, 5.57657704e-02f, 3.17960382e-02f, -4.68676090e-02f,
  -5.49175479e-02f, -4.25648838e-02f, -1.32824600e-01f, 6.01886399e-02f, 4.32929844e-02f, -6.16778471e-02f, 6.60145422e-04f, 6.72551105e-03f, -2.12295651e-02f, -1.65828373e-02f,
  -1.33916661e-01f, 3.68321985e-02f, -6.44186959e-02f, 6.08054623e-02f, 7.21286759e-02f, 1.16993889e-01f, 8.65545049e-02f, 6.44130260e-02f, 9.92140267e-03f, 1.96650587e-02f,
  1.28640637e-01f, -9.86747965e-02f, -6.83326945e-02f, 4.89715263e-02f, 3.86072136e-02f, 3.07133719e-02f, -1.18955057e-02f, 8.11518282e-02f, 5.76496720e-02f, 6.72708312e-03f,
  -1.06622115e-01f, -3.92583720e-02f, -4.07407358e-02f, -1.44281387e-02f, -2.31040288e-02f, -4.92419153e-02f, -1.27156149e-03f, -7.61960223e-02f, -1.93158220e-02f, -1.29961580e-01f,
  1.69269219e-01f, 1.23297675e-02f, -1.81682594e-02f, -1.70447014e-03f, 8.56792778e-02f, 3.24315466e-02f, 1.02102458e-01f, 8.80635381e-02f, 5.71937263e-02f, 1.04146488e-02f,
  1.33338034e-01f, -8.18438455e-02f, -7.21698031e-02f, 1.40618468e-02f, 5.36117405e-02f, 1.01342373e-01f, -2.00983533e-03f, -8.30976665e-03f, -5.27373068e-02f, -8.24174359e-02f,
  2.21298789e-04f, -7.95927495e-02f, -4.00428623e-02f, -3.54617424e-02f, 2.55267471e-02f, 9.61185545e-02f, -2.10891180e-02f, 4.80352528e-02f, -2.07111537e-02f, -1.09437548e-01f,
  5.90172857e-02f, -5.01255393e-02f, -6.45629838e-02f, -7.46951550e-02f, -1.12600394e-01f, -1.54615063e-02f, -7.69991800e-02f, 1.36295274e-01f, 8.31437111e-02f, -8.68588686e-02f,
  -7.52129704e-02f, 1.03562862e-01f, -1.17713131e-01f, 9.22657549e-02f, 6.78212382e-03f, -5.81403077e-02f, -2.61405250e-03f, 6.38015643e-02f, -9.78819355e-02f, -9.22705606e-02f,
  1.12865105e-01f, 9.82242972e-02f, 4.51481491e-02f, 8.64510834e-02f, -1.00522920e-01f, 2.41999589e-02f, -6.30860701e-02f, 3.95100527e-02f, -2.52152234e-02f, -3.62005010e-02f,
  -3.77438739e-02f, 7.29435906e-02f, 8.01671669e-02f, -9.96528342e-02f, -6.32490814e-02f, -1.04743257e-01f, -3.31765652e-04f, -1.04298994e-01f, 3.96582261e-02f, -6.50411518e-03f,
  -3.08604091e-02f, -2.69045085e-02f, -1.16171747e-01f, -4.79877554e-02f, 3.65116708e-02f, 5.57255223e-02f, 6.28933311e-03f, -7.95135051e-02f, -2.43919231e-02f, -2.49302704e-02f,
  -1.46546960e-02f, -2.62414105e-02f, 9.28297564e-02f, -5.18135540e-02f, 1.80390805e-01f, 1.59039184e-01f, 1.31350636e-01f, 5.41431941e-02f, -5.25756888e-02f, 1.32003993e-01f,
  -1.44794673e-01f, 6.12706356e-02f, 2.97518633e-02f, -2.28997812e-01f, 5.99950887e-02f, 1.18173175e-01f, 1.16168410e-01f, 5.10511249e-02f, 1.34954557e-01f, 1.49502456e-01f,
  1.79133490e-02f, -2.76888888e-02f, -6.43843859e-02f, -5.24841063e-03f, 3.56785990e-02f, -3.24575067e-03f, -3.40805575e-02f, 1.31611064e-01f, -2.82785129e-02f, -2.60880981e-02f,
  1.94919612e-02f, 1.10101320e-01f, 5.65578640e-02f, 1.60329476e-01f, -1.35167152e-01f, -8.87312591e-02f, 1.81270558e-02f, 1.35423526e-01f, -1.46520495e-01f, -1.18486784e-01f,
  -6.38000518e-02f, 7.47859254e-02f, -8.99062455e-02f, 5.71282357e-02f, -1.01252362e-01f, -1.36256650e-01f, -1.23218350e-01f, 4.84404676e-02f, 1.43408179e-01f, 6.65473416e-02f,
  1.59890845e-01f, 2.56986544e-02f, 2.08697636e-02f, 1.19037837e-01f, -1.17084928e-01f, -1.15365975e-01f, -1.07221067e-01f, -7.38468766e-02f, -9.47001576e-02f, 1.07389085e-01f,
  -1.54367844e-02f, -1.92050457e-01f, -1.45534635e-01f, 4.34528328e-02f, -5.97499013e-02f, 3.25943381e-01f, -1.05215395e-02f, 6.06675223e-02f, 1.16187446e-01f, 1.41643763e-01f,
  1.57972760e-02f, -1.06331028e-01f, -6.92071319e-02f, -4.62021679e-02f, 4.33420353e-02f, -9.36055183e-02f, -2.49817483e-02f, 4.42678109e-02f, -1.12177812e-01f, 1.42375991e-01f,
  4.54967208e-02f, 9.44571644e-02f, 2.08740085e-02f, 9.24850255e-02f, -5.63317351e-02f, -6.51097819e-02f, 2.55887993e-02f, -7.57901594e-02f, -5.37457503e-02f, -8.58684182e-02f,
  1.40803054e-01f, 1.62245911e-02f, 1.69603061e-02f, 1.60738863e-02f, -5.23870140e-02f, -1.13616288e-01f, 1.76337976e-02f, -3.92198451e-02f, 3.37561243e-03f, 8.12346488e-02f,
  -8.16093907e-02f, -8.02513137e-02f, -2.86732651e-02f, 8.31334740e-02f, -8.97640958e-02f, 7.82186282e-04f, 1.00730591e-01f, 5.25799580e-02f, 1.04199946e-01f, 7.57822841e-02f,
  1.12644203e-01f, 8.84439126e-02f, -6.21309951e-02f, -7.12443590e-02f, 1.23311915e-01f, 5.30458540e-02f, -9.62575078e-02f, 2.63761356e-03f, 8.74775276e-02f, -8.45485479e-02f,
  -4.73647378e-02f, -4.83773239e-02f, 4.07068171e-02f, -1.00381680e-01f, 5.80823533e-02f, 2.37903949e-02f, 8.57068524e-02f, 7.15012997e-02f, 4.41018343e-02f, 4.37655337e-02f,
  3.58342715e-02f, 5.50898463e-02f, 7.48925433e-02f, 1.08667992e-01f, 6.32412359e-02f, 1.62082016e-01f, 6.64873123e-02f, 9.93807614e-02f, 8.76766443e-02f, -2.16001824e-01f,
  1.83301091e-01f, 8.79677609e-02f, -7.52107650e-02f, -2.94297170e-02f, -5.94662428e-02f, 2.08039954e-03f, 1.40098497e-01f, -1.12335175e-01f, 3.95796299e-02f, 2.14002132e-01f,
  1.78473011e-01f, -6.58295229e-02f, -1.08081400e-02f, -1.37231722e-01f, 1.52359158e-01f, -5.87036088e-02f, 7.05966279e-02f, -7.76592791e-02f, -1.43830463e-01f, -7.78110698e-02f,
  -7.25205466e-02f, 1.79690926e-03f, 1.40004039e-01f, -8.38599950e-02f, -1.26361847e-01f, -3.62316445e-02f, 7.59747699e-02f, 4.46110331e-02f, 9.09272954e-02f, 1.01403370e-01f,
  -5.49368607e-03f, 8.19603428e-02f, -8.15339461e-02f, 1.25958771e-02f, -7.92646855e-02f, 7.09726810e-02f, 7.01464489e-02f, 1.31922990e-01f, 2.06783935e-01f, -1.98663417e-02f,
  8.86967522e-04f, -6.74907342e-02f, -1.86817069e-02f, -3.85979302e-02f, 2.49991845e-02f, -6.99921176e-02f, 4.60600331e-02f, 1.19381979e-01f, -1.32347569e-01f, 6.30668029e-02f,
  -7.51302578e-03f, -2.10417658e-02f, 1.72158219e-02f, 7.67741492e-03f, -1.19649269e-01f, -8.19176957e-02f, 4.03439514e-02f, -1.51000533e-03f, -6.54525757e-02f, 3.23461145e-02f,
  1.16723232e-01f, 8.60329643e-02f, -1.88700378e-01f, 1.21715732e-01f, -3.71081755e-02f, 2.28715092e-01f, 1.35459751e-01f, 6.84225932e-02f, 1.13706090e-01f, 3.59216258e-02f,
  -6.24318831e-02f, -6.92321807e-02f, -5.69910593e-02f, 2.96070844e-01f, -1.50757404e-02f, 8.19588974e-02f, -3.40511254e-03f, -1.45359971e-02f, 8.08486193e-02f, -1.07355781e-01f,
  -5.14982529e-02f, 8.98054689e-02f, 5.01641445e-02f, -1.92144156e-01f, 4.94541265e-02f, -9.02673677e-02f, 1.11687876e-01f, -1.67186409e-02f, -2.50622891e-02f, -1.77189391e-02f,
  3.78906764e-02f, 2.28333697e-02f, -1.30497040e-02f, 1.16798751e-01f, -2.72870474e-02f, 1.77607927e-02f, -9.23030749e-02f, 1.11215049e-02f, -3.52555327e-02f, -9.97298583e-02f,
  2.94472665e-01f, 2.21384346e-01f, -1.33544102e-01f, 1.83281556e-01f, 5.61540946e-02f, -5.30255847e-02f, 3.10283676e-02f, -6.06163628e-02f, 1.12248980e-01f, 1.75623432e-01f,
  9.18851718e-02f, -6.00678322e-04f, 1.32113904e-01f, 2.73107439e-01f, 1.73116624e-01f, 1.13089560e-02f, -1.09966304e-02f, 7.10444013e-03f, -8.15398321e-02f, 1.96909495e-02f,
  2.04182670e-01f, 1.31678358e-01f, 1.76321045e-01f, 2.93876883e-02f, 1.73767284e-01f, -1.50572881e-03f, -1.16580188e-01f, 1.20696016e-01f, -7.32162669e-02f, 7.63467047e-03f,
  2.83438474e-01f, -6.55632019e-02f, -1.94991663e-01f, -5.54504357e-02f, 1.24472573e-01f, 1.24003096e-02f, 1.10192731e-01f, 2.53222466e-01f, 1.81854162e-02f, 7.14619383e-02f,
  2.73622088e-02f, -1.57172009e-02f, 9.29892510e-02f, 4.54619341e-02f, -3.08870804e-02f, 5.72626069e-02f, 1.64107993e-01f, 3.52574229e-01f, -5.86999804e-02f, 1.24131865e-03f,
  -9.49076563e-02f, -1.41423985e-01f, 5.67006767e-02f, -3.43689993e-02f, 2.18763709e-01f, -1.13182575e-01f, 4.98068109e-02f, -6.86451346e-02f, 3.20285335e-02f, 9.17711258e-02f,
  -8.24972019e-02f, 5.47801219e-02f, -1.43598378e-01f, -5.23775928e-02f, 4.22364241e-03f, 1.94498524e-01f, 1.75129414e-01f, 1.40043627e-02f, 9.93890539e-02f, 3.97367515e-02f,
  6.28572106e-02f, -3.52797993e-02f, 3.36838737e-02f, 1.00713618e-01f, 1.10996999e-01f, 9.06298533e-02f, -1.08155292e-02f, -1.02705300e-01f, 1.06533714e-01f, -1.79086417e-01f,
  5.44146597e-02f, 1.00076638e-01f, -1.32357910e-01f, 5.99489734e-02f, 2.34921560e-01f, 6.22624978e-02f, 6.59845918e-02f, -5.51264994e-02f, 1.55260310e-01f, 1.00092791e-01f,
  2.10078597e-01f, -1.41424283e-01f, 4.56237085e-02f, 2.11046532e-01f, 6.55687600e-02f, 6.33974522e-02f, -1.17549459e-02f, -3.86862271e-02f, 4.51249704e-02f, 5.07531911e-02f,
  -1.07910886e-01f, 4.38619927e-02f, 1.50611624e-01f, -2.87435949e-02f, -1.47911370e-01f, 1.02756754e-01f, 1.54794753e-01f, -9.22200754e-02f, 1.59521684e-01f, 1.75895672e-02f,
  -6.07435144e-02f, 1.41038492e-01f, 5.02588041e-02f, 8.53108093e-02f, 3.38267758e-02f, -1.11347720e-01f, -6.14547962e-03f, -5.91947027e-02f, 1.79249525e-01f, 9.00998414e-02f,
  1.26171067e-01f, 2.13059857e-02f, -1.21888131e-01f, -1.04273275e-01f, 8.15521367e-03f, 5.85796759e-02f, 1.61619321e-01f, -8.49753767e-02f, -3.09031853e-03f, 7.95932561e-02f,
  1.99669693e-02f, 1.59607142e-01f, 7.65842944e-02f, -1.16382204e-01f, 4.05641533e-02f, 5.09401485e-02f, -1.08419046e-01f, -8.35120231e-02f, -1.01044476e-01f, 5.18936440e-02f,
  -7.11776912e-02f, 2.10057378e-01f, 1.29744083e-01f, -5.35120629e-03f, -1.62677513e-03f, -9.26982313e-02f, 4.07183282e-02f, -1.04657121e-01f, 2.44337380e-01f, 1.42678186e-01f,
  1.84084296e-01f, 8.13450515e-02f, 2.35804409e-01f, 3.41307312e-01f, 1.59997419e-01f, -3.11208665e-01f, 1.31327912e-01f, 1.97871819e-01f, -9.95461568e-02f, 8.22889209e-02f,
  1.36138529e-01f, 1.33399636e-01f, 7.70359859e-02f, -1.57015875e-03f, 1.14054081e-03f, 2.08669752e-01f, 1.48415506e-01f, 8.80217254e-02f, 9.46522579e-02f, -1.68636411e-01f,
  1.60533965e-01f, 1.07323974e-01f, 1.30650774e-01f, 5.04139960e-02f, -6.25758171e-02f, -1.69350896e-02f, 3.94325331e-02f, -3.40927392e-02f, 2.02444881e-01f, 7.35477358e-02f,
  -4.50573117e-02f, -1.07157156e-01f, 3.70243520e-01f, -9.56774056e-02f, 7.18394816e-02f, 1.00609407e-01f, -6.68620244e-02f, -6.90522939e-02f, -1.31113797e-01f, -8.81517529e-02f,
  9.94538814e-02f, 1.60999075e-01f, -9.75492522e-02f, 1.35085389e-01f, 1.71956852e-01f, -4.58609685e-02f, -1.35335729e-01f, -1.26925632e-01f, -2.98832376e-02f, -9.50513221e-03f,
  -7.66174197e-02f, -1.78368226e-01f, 7.61026219e-02f, 1.27596006e-01f, -7.04374090e-02f, 2.21961647e-01f, -6.41110400e-03f, 1.48427591e-01f, 1.99812651e-02f, -1.69336095e-01f,
  -1.53518841e-01f, -1.16253041e-01f, -5.14106527e-02f, 5.60760126e-03f, 2.36592907e-02f, 9.22571272e-02f, -1.00088276e-01f, 4.09781672e-02f, -1.70030668e-01f, 1.19166739e-01f,
  -4.01826622e-03f, -1.46509305e-01f, -3.73910517e-02f, -2.75954437e-02f, 9.73098725e-02f, 3.11317258e-02f, -1.26772851e-01f, -3.19120400e-02f, -1.78180598e-02f, 1.31723866e-01f,
  1.04342595e-01f, 1.11825377e-01f, -5.31866997e-02f, -1.12889551e-01f, 3.12072807e-03f, 1.13564897e-02f, -7.76448324e-02f, -3.87078226e-02f, -1.07544437e-01f, 2.97562554e-02f,
  6.20488301e-02f, -1.01494372e-01f, -8.28599259e-02f, 1.02181472e-01f, 3.80006693e-02f, 2.04107668e-02f, -6.29883070e-05f, -5.70302121e-02f, 9.10271949e-04f, 7.88125917e-02f,
  3.78328878e-05f, -6.04561567e-02f, -1.14744864e-01f, -1.79134272e-02f, 4.35237922e-02f, 1.66968834e-02f, 1.18608370e-01f, -8.28403607e-02f, -6.21327534e-02f, -8.56988207e-02f,
  2.00697430e-03f, -1.11094303e-01f, -1.17377557e-01f, 8.80574584e-02f, 3.40821035e-02f, -9.02437866e-02f, 8.92971382e-02f, 1.16284877e-01f, -2.69308686e-03f, -9.10842940e-02f,
  -1.81193510e-03f, 7.16354400e-02f, 1.07973635e-01f, -4.28513438e-02f, 4.89020683e-02f, -5.57079054e-02f, -4.36265096e-02f, -1.43061563e-01f, 1.60073419e-03f, -5.64417504e-02f,
  1.12343896e-02f, 5.35544679e-02f, -1.74232591e-02f, -9.60047469e-02f, -3.83197442e-02f, 1.03798583e-02f, -3.34849097e-02f, 7.43970498e-02f, 1.41705215e-01f, -7.56236911e-02f,
  1.14816964e-01f, 2.44490635e-02f, -1.02477372e-01f, -2.48045474e-02f, 7.60541484e-02f, 5.27710794e-03f, -8.14004466e-02f, -6.33944124e-02f, 3.53633240e-02f, -1.07258074e-01f,
  8.26685727e-02f, 2.10107788e-02f, -3.15216966e-02f, 8.37739464e-03f, -1.08556867e-01f, -1.07958555e-01f, 5.64810596e-02f, -4.24757637e-02f, 3.49155888e-02f, -4.46881093e-02f,
  -7.84773454e-02f, 4.21245024e-02f, 4.78698276e-02f, 6.67931587e-02f, -7.48862848e-02f, -5.11524901e-02f, 1.10147975e-01f, -7.13780671e-02f, 3.55669037e-02f, 4.49311063e-02f,
  4.57465015e-02f, 1.53071061e-02f, -3.73951579e-03f, 1.28692053e-02f, -5.36678396e-02f, 1.09486483e-01f, 6.44862326e-03f, -6.91335797e-02f, -1.17753744e-01f, -2.77391579e-02f,
  3.26350182e-02f, 9.00842920e-02f, 1.28732622e-01f, -2.96830689e-03f, -7.53883943e-02f, -3.23602892e-02f, 1.18458204e-01f, -1.27362266e-01f, 8.51405635e-02f, -8.01484138e-02f,
  -7.79600888e-02f, 7.56832287e-02f, -1.01773581e-02f, -4.12364975e-02f, -8.83233547e-02f, -3.98220941e-02f, -6.39998987e-02f, 3.54339071e-02f, -6.32669106e-02f, 9.17974934e-02f,
  1.65524762e-02f, 1.29813612e-01f, 1.40658543e-01f, -6.50119856e-02f, 5.07820137e-02f, -7.49853924e-02f, -2.77594980e-02f, -1.05972439e-01f, 1.19477464e-02f, -1.01141132e-01f,
  1.01517193e-01f, -1.10797480e-01f, -1.03151433e-01f, -3.97067517e-02f, 5.39806746e-02f, 1.15855813e-01f, 1.33684084e-01f, -9.79799852e-02f, -3.40683991e-03f, 1.26727715e-01f,
  -4.86140326e-02f, 1.11903206e-01f, 8.47071856e-02f, 6.91101328e-02f, 8.82022381e-02f, 1.07889056e-01f, -7.90984556e-03f, -6.56468496e-02f, 9.42100119e-03f, -2.47009052e-03f,
  2.46428195e-02f, -1.93579812e-02f, 1.75711401e-02f, -5.32490574e-02f, 5.81908599e-03f, -5.80754578e-02f, -2.87911538e-02f, -8.54253024e-02f, 4.59210463e-02f, 7.04990253e-02f,
  -7.43768886e-02f, 2.08868608e-02f, -5.08507751e-02f, -8.13442841e-02f, -5.46440892e-02f, -1.23709822e-02f, -1.13094645e-02f, -8.32718685e-02f, -8.32730308e-02f, 1.08918779e-01f,
  -6.69360459e-02f, -4.53363769e-02f, 6.12337627e-02f, -2.16543302e-02f, 1.05574138e-01f, 2.01480359e-01f, 2.31286421e-01f, 2.52360493e-01f, 9.53948721e-02f, 2.12081119e-01f,
  2.25047152e-02f, 6.44457489e-02f, 1.29363745e-01f, -1.08284675e-01f, -1.69860274e-01f, -3.39597017e-02f, 1.93150595e-01f, 7.03478158e-02f, 2.56523311e-01f, -4.64491844e-02f,
  -1.28111750e-01f, 2.69014481e-02f, -1.56296730e-01f, 7.51569308e-03f, -3.21877636e-02f, 6.65230229e-02f, 1.73425432e-02f, 1.07936248e-01f, -2.75404714e-02f, -4.08656448e-02f,
  8.84247422e-02f, -1.03374355e-01f, 2.13342518e-01f, 5.54908812e-02f, -8.42126384e-02f, 4.55005318e-02f, -1.19475290e-01f, 2.28141531e-01f, -1.42015561e-01f, -1.16036676e-01f,
  2.47896463e-02f, -1.13071986e-01f, -6.92076236e-02f, -3.89755294e-02f, 3.50673534e-02f, -1.86871104e-02f, 9.10406560e-02f, 1.42710835e-01f, 3.75780240e-02f, -8.36340114e-02f,
  -1.93209685e-02f, -6.31783232e-02f, -2.74818707e-02f, -1.99629925e-02f, 1.53893689e-02f, -4.44270633e-02f, 1.24197984e-02f, -1.39557734e-01f, 2.47033760e-02f, 8.35360028e-03f,
  4.84040231e-02f, -6.38199747e-02f, -1.80040166e-01f, 4.93442006e-02f, 6.86745495e-02f, 6.95877373e-02f, -6.57100305e-02f, -1.37765288e-01f, 2.58361027e-02f, -1.04279168e-01f,
  -6.12707771e-02f, 3.55668813e-02f, 1.19007543e-01f, -1.94867179e-02f, -8.20868835e-02f, -4.86103445e-02f, -2.04859897e-02f, -1.10621043e-01f, 1.09708339e-01f, -9.44903269e-02f,
  -5.99863827e-02f, -1.00025378e-01f, 1.65476263e-01f, 4.75326851e-02f, 8.79520401e-02f, -1.06839314e-01f, 1.28844664e-01f, -1.01237111e-01f, 5.14747500e-02f, -1.07792579e-01f,
  -9.91147235e-02f, -8.44234228e-02f, 7.25802928e-02f, 1.14543319e-01f, 1.16786594e-02f, -5.24132997e-02f, 7.85132311e-03f, -1.01912767e-01f, -7.26523474e-02f, -1.38602490e-02f,
  1.00200966e-01f, -8.31763595e-02f, 3.12938057e-02f, 1.06724940e-01f, 3.45043093e-02f, 8.34112912e-02f, -1.46593219e-02f, 3.93767953e-02f, -7.96743333e-02f, 1.22075565e-01f,
  -1.06913961e-01f, -2.01002881e-02f, -1.16641894e-01f, -9.88597870e-02f, 1.06644988e-01f, -9.08031315e-02f, -4.44064587e-02f, 9.55457333e-03f, 3.49044544e-03f, -8.40340555e-02f,
  8.52922946e-02f, -4.45605479e-02f, -3.26642133e-02f, 7.80531839e-02f, -8.53611305e-02f, 1.11999489e-01f, -4.14385200e-02f, 6.02472350e-02f, 5.51273338e-02f, 4.39947769e-02f,
  4.85853814e-02f, -6.88871890e-02f, -1.80039927e-02f, -8.98997858e-02f, 5.93714863e-02f, -5.72094172e-02f, -4.74155992e-02f, 8.59255940e-02f, 1.52194649e-01f, -5.35047352e-02f,
  -2.22270489e-02f, -2.33955793e-02f, -1.43730909e-01f, -6.24391772e-02f, 1.12662226e-01f, -7.05802366e-02f, 2.31795058e-01f, 1.87599566e-04f, 7.18043149e-02f, 2.17255540e-02f,
  -4.22229245e-03f, 6.43276274e-02f, -5.90190254e-02f, 5.76301105e-02f, 3.79050523e-02f, -9.80039537e-02f, 3.67605197e-03f, 9.17949826e-02f, 1.46667942e-01f, -1.18066631e-01f,
  -1.10340938e-01f, -1.50152389e-02f, -7.44179189e-02f, 1.83354504e-02f, -1.34466633e-01f, 6.76732585e-02f, 7.38571445e-03f, 7.00422823e-02f, -1.22260034e-01f, -1.18273169e-01f,
  2.35854089e-03f, 1.49180414e-02f, 1.82545336e-03f, 6.23482801e-02f, -1.34717524e-01f, 5.24507323e-03f, 7.25887343e-02f, -7.68429041e-02f, -1.64475478e-02f, 3.07785161e-02f,
  -1.11015789e-01f, 8.83018970e-02f, 4.91712280e-02f, -1.09164670e-01f, -1.02519818e-01f, -6.03049770e-02f, -1.39514608e-02f, 4.14998010e-02f, -1.74802879e-03f, -7.97425285e-02f,
  -1.06591612e-01f, -7.56058469e-02f, -1.00540988e-01f, -7.67283589e-02f, 3.25334743e-02f, -1.03580497e-01f, -2.56101936e-02f, 7.16323406e-02f, 1.34646013e-01f, 1.41780242e-01f,
  1.02580674e-01f, 9.53149423e-02f, -1.14212386e-01f, -6.94787353e-02f, -5.23923226e-02f, -2.06160188e-01f, 9.02234241e-02f, -1.54178098e-01f, -3.65027003e-02f, 2.39154175e-02f,
  2.27742985e-01f, 1.34442955e-01f, -1.12251975e-01f, 2.71704458e-02f, 2.48365048e-02f, 6.50151819e-02f, 1.85525060e-01f, 6.31006360e-02f, 6.10158406e-02f, -1.35350108e-01f,
  4.28462103e-02f, 2.92186085e-02f, 1.90476850e-01f, 3.84667404e-02f, -1.51633471e-01f, -1.29311621e-01f, -7.45498464e-02f, 1.26971573e-01f, -4.16528769e-02f, 5.84856682e-02f,
  1.72334477e-01f, 3.50752333e-03f, -1.50546217e-02f, -1.11449897e-01f, -1.13949053e-01f, -1.26938209e-01f, 1.40287861e-01f, 2.96644960e-02f, -8.63422081e-02f, -2.22746339e-02f,
  2.13008955e-01f, -3.02889012e-02f, 1.40963212e-01f, -2.13488676e-02f, 4.84899171e-02f, -5.71981352e-03f, -1.27515927e-01f, -9.36020762e-02f, -1.08938053e-01f, -9.40044373e-02f,
  5.34181111e-02f, -1.23564631e-01f, -5.78111224e-02f, 1.07086800e-01f, 8.61778203e-03f, -8.46358761e-02f, -5.51136546e-02f, 3.24585452e-03f, 1.49389327e-01f, -9.63651314e-02f,
  2.04237521e-01f, 1.33669795e-02f, 1.32482246e-01f, 7.93377608e-02f, 7.21704736e-02f, 2.41121560e-01f, -4.07992341e-02f, 1.37593597e-01f, 2.29773089e-01f, -2.69712150e-01f,
  -2.65961498e-01f, -5.47096953e-02f, 1.25634372e-01f, -1.76628754e-02f, 3.05208415e-01f, 3.83688733e-02f, 4.14491966e-02f, -9.60829575e-03f, 3.23290266e-02f, -7.90848210e-02f,
  1.41023234e-01f, 1.24768466e-01f, -1.14133634e-01f, 1.74706727e-01f, -7.75472522e-02f, -8.02870616e-02f, 1.72009654e-02f, 2.17671450e-02f, -2.97306962e-02f, 1.32242903e-01f,
  -7.00939223e-02f, -1.97727811e-02f, -1.10107198e-01f, 2.24049076e-01f, -4.14783545e-02f, 3.65981087e-02f, -5.02404897e-03f, -8.69746879e-02f, -1.09111937e-02f, 9.42660309e-03f,
  5.01532219e-02f, -3.64642888e-02f, -3.65338922e-02f, 1.82064787e-01f, 4.12783064e-02f, -3.39228548e-02f, -8.07459727e-02f, 6.54284507e-02f, 6.05277643e-02f, 9.00242329e-02f,
  -1.01209283e-01f, -8.42879340e-03f, -9.16614681e-02f, 3.63960601e-02f, -5.68998568e-02f, -7.65025392e-02f, -1.31096691e-01f, -7.70510733e-02f, -1.29985390e-02f, 1.06208399e-01f,
  1.27290890e-01f, 3.31898689e-01f, 1.33157179e-01f, -7.32291862e-02f, -7.51618296e-02f, 1.19837351e-01f, -6.98693767e-02f, -1.05403416e-01f, -6.38109744e-02f, -5.94901629e-02f,
  -3.12068742e-02f, 2.63846219e-02f, -8.79620388e-02f, -7.00693354e-02f, 5.14837168e-02f, -2.93667186e-02f, 5.78411631e-02f, 2.62474059e-03f, -1.22155339e-01f, 8.19009691e-02f,
  -1.15171239e-01f, 2.38348003e-02f, 1.09884031e-01f, -1.90935712e-02f, 8.31060037e-02f, 7.73344338e-02f, -2.35276278e-02f, -9.32471901e-02f, -8.63913745e-02f, 6.38474673e-02f,
  5.06280586e-02f, 1.17884293e-01f, 3.04455552e-02f, 1.14064552e-01f, -8.91691521e-02f, 9.01559815e-02f, -2.61899568e-02f, 5.61496988e-02f, 3.65983993e-02f, 2.01996174e-02f,
  6.79135695e-02f, -1.08664542e-01f, 3.33196670e-02f, -8.02646950e-02f, -5.48507646e-02f, -9.52085778e-02f, 2.10088119e-02f, -7.44002238e-02f, 1.20115705e-01f, 1.18429773e-01f,
  2.87707541e-02f, -7.04304501e-02f, -1.03923522e-01f, -9.79118198e-02f, -5.42413704e-02f, -5.92913255e-02f, 1.84437279e-02f, 1.14121661e-01f, 1.18272461e-01f, -9.21781287e-02f,
  7.23245516e-02f, 2.60180887e-02f, 7.83845410e-02f, -4.55469005e-02f, 2.95048095e-02f, -8.92718583e-02f, -1.99773647e-02f, -1.07563421e-01f, -5.89385293e-02f, 6.64295331e-02f,
  6.68363124e-02f, -8.45835730e-02f, 8.13328698e-02f, 1.58363029e-01f, -2.21316978e-01f, 2.62524664e-01f, 2.94712987e-02f, -2.17799351e-01f, 2.84171309e-02f, 1.78590089e-01f,
  -4.15587192e-03f, -5.90875298e-02f, -9.13554803e-03f, 1.67573869e-01f, -1.41500626e-02f, -5.81126399e-02f, -9.54663530e-02f, -7.39051625e-02f, 3.72523814e-02f, 1.10670095e-02f,
  2.09320057e-02f, -9.22295749e-02f, -2.77913548e-03f, -1.18631400e-01f, -1.52104989e-01f, 4.85664292e-04f, 1.29933655e-01f, -6.48932979e-02f, 4.67572957e-02f, -1.07268408e-01f,
  1.36961162e-01f, 2.24423006e-01f, 3.25779766e-02f, -5.43287955e-02f, 6.22333027e-02f, -1.13313481e-01f, -7.72823095e-02f, 8.16619098e-02f, -5.04233912e-02f, -2.49579474e-02f,
  -4.29536887e-02f, -1.09318875e-01f, -1.72942635e-02f, -7.10809380e-02f, 4.43047024e-02f, 4.20219973e-02f, 1.42335534e-01f, 9.19179916e-02f, -7.11305365e-02f, -2.73770504e-02f,
  -7.90590197e-02f, -6.57170117e-02f, 9.43925306e-02f, 3.49226361e-03f, -5.35909273e-03f, -7.88562596e-02f, 3.87741229e-03f, 1.40130237e-01f, -5.95481806e-02f, 2.41914928e-01f,
  -1.91053748e-02f, -8.24200436e-02f, -5.72137609e-02f, 1.31637424e-01f, 1.03217028e-01f, 8.06751102e-02f, 5.97476102e-02f, 6.94632903e-02f, -5.76744266e-02f, 3.53358090e-02f,
  1.51065797e-01f, -7.91601539e-02f, -1.02298252e-01f, -1.29285708e-01f, -5.22667496e-03f, -9.32142511e-02f, 1.29227154e-02f, 1.13162398e-01f, -5.30898459e-02f, -1.34705575e-02f,
  1.27125636e-01f, -1.46449655e-01f, -7.65428916e-02f, -1.30340636e-01f, 9.30891465e-03f, 1.36371590e-02f, 8.90305713e-02f, -3.90486494e-02f, -6.22869506e-02f, 2.69316062e-02f,
  6.01123311e-02f, -9.23242643e-02f, 1.07253917e-01f, 4.26395573e-02f, 5.07923018e-04f, 1.73197493e-01f, -1.03960946e-01f, 1.97212808e-02f, 3.93901132e-02f, -2.71621123e-02f,
  -6.63547963e-02f, -8.61948654e-02f, 9.45942011e-03f, 2.71828473e-03f, -1.31043345e-01f, -5.38262874e-02f, 6.36379570e-02f, 1.61907837e-01f, 1.85455263e-01f, 9.64203030e-02f,
  6.18625022e-02f, -6.63140938e-02f, -2.47008875e-02f, 1.51354019e-02f, 4.74943705e-02f, -9.47123915e-02f, -2.57252809e-02f, 1.63861364e-01f, -5.26820049e-02f, -1.70570649e-02f,
  -1.18744291e-01f, 6.32987767e-02f, -1.10493310e-01f, 2.44004384e-01f, 7.38878399e-02f, -7.91854933e-02f, -6.84852526e-02f, -1.00115165e-01f, -9.61728320e-02f, 6.42715693e-02f,
  -1.08740881e-01f, 1.29852310e-01f, -1.70585558e-01f, 5.42563237e-02f, -1.31304525e-02f, -4.21246588e-02f, 1.21906988e-01f, 7.11908415e-02f, 7.31766829e-03f, -4.97883856e-02f,
  1.21174335e-01f, 1.55049235e-01f, 1.11205712e-01f, 6.84569706e-04f, 3.16191614e-02f, 9.41918492e-02f, 7.86332488e-02f, 1.10418133e-01f, 8.72162357e-02f, 1.05561644e-01f,
  6.67128190e-02f, 4.58487011e-02f, -5.35126068e-02f, -2.42083445e-02f, 6.48038909e-02f, -8.21203217e-02f, 6.33739978e-02f, -4.73473482e-02f, -3.24048102e-02f, 1.36720046e-01f,
  -1.03812709e-01f, 8.22206512e-02f, 8.69142711e-02f, 1.06560618e-01f, 8.60521644e-02f, 1.68525372e-02f, -5.86349256e-02f, -8.72800350e-02f, 3.99211943e-02f, 1.05863184e-01f,
  8.60637203e-02f, 5.89387044e-02f, 5.04007824e-02f, 1.13715664e-01f, -5.20296618e-02f, 2.60198358e-02f, -1.20098948e-01f, 3.97656560e-02f, -7.65883997e-02f, -1.00340992e-01f,
  -3.58334854e-02f, 9.93255824e-02f, 1.61293507e-01f, -4.03858237e-02f, 1.07248038e-01f, -6.72256649e-02f, 8.20982270e-04f, -6.22163042e-02f, 1.46996513e-01f, 6.06802106e-02f,
  -6.36495426e-02f, -1.05339937e-01f, 1.04031600e-01f, 1.38218492e-01f, -5.98907284e-02f, 1.73350602e-01f, -1.42029524e-02f, -6.75997287e-02f, -1.86709166e-02f, 1.04702590e-02f,
  -1.80318594e-01f, 6.07209690e-02f, 2.37387732e-01f, -5.59381358e-02f, 1.68740541e-01f, -3.69126815e-03f, 6.82694167e-02f, 7.09694326e-02f, -1.16468340e-01f, -8.94960016e-02f,
  1.07239805e-01f, 9.21930373e-02f, 1.46841869e-01f, -5.02854884e-02f, 6.29567057e-02f, -4.04098295e-02f, 1.56167254e-01f, -2.84654871e-02f, 9.06507596e-02f, -1.77552123e-02f,
  1.17991723e-01f, 4.47688475e-02f, 6.86229095e-02f, -2.67550200e-02f, -8.02252889e-02f, -4.77050208e-02f, -3.45110036e-02f, -5.71344458e-02f, 2.36313399e-02f, 1.88531689e-02f,
  3.10508739e-02f, 8.41988623e-02f, -1.11521110e-01f, 9.09257401e-03f, -6.31751195e-02f, 5.51163889e-02f, 4.11495827e-02f, 6.56315982e-02f, -6.63516298e-02f, -2.39454899e-02f,
  5.93562163e-02f, -8.34746361e-02f, -1.05698250e-01f, -2.75437590e-02f, 2.36157514e-02f, -9.95939448e-02f, -2.43150070e-02f, 5.65762445e-02f, -7.92162344e-02f, 1.20184757e-01f,
  -2.62729786e-02f, -1.36540771e-01f, 9.78696626e-03f, 6.76138029e-02f, 4.54445072e-02f, 8.42719600e-02f, 1.51291922e-01f, 1.38641924e-01f, 3.91296335e-02f, 1.71302050e-01f,
  -2.25182489e-01f, 9.17486027e-02f, -5.81549890e-02f, -3.41642345e-03f, 2.25506321e-01f, -1.69923201e-01f, 4.38343994e-02f, -3.33579704e-02f, 1.65223312e-02f, -5.72096221e-02f,
  -5.61630465e-02f, 2.52394944e-01f, 1.67508602e-01f, 7.54070953e-02f, 4.33823206e-02f, 1.03359513e-01f, -4.61841337e-02f, -1.67831644e-01f, 4.88605238e-02f, -1.10235326e-01f,
  -1.23418950e-01f, 8.22534040e-02f, -1.37125731e-01f, 3.39213014e-02f, 4.59022410e-02f, -2.93704378e-03f, 1.22440964e-01f, -4.52106632e-02f, 1.47233710e-01f, 1.76454000e-02f,
  7.76076093e-02f, 1.31005747e-02f, -7.92691186e-02f, -1.33657530e-01f, 5.66847771e-02f, 6.84949663e-03f, 3.06281541e-02f, 4.18293700e-02f, 4.43014577e-02f, 1.38728410e-01f,
  8.69245678e-02f, 1.58920273e-01f, -7.72626698e-02f, 9.19307768e-03f, 1.40357893e-02f, -7.26130605e-03f, -3.72108780e-02f, 8.45909119e-02f, 2.36950852e-02f, -7.92107265e-03f,
  1.46946669e-01f, 1.59456670e-01f, 1.51760101e-01f, -8.60316604e-02f, -1.52896807e-01f, 1.05280578e-01f, -3.67020778e-02f, 4.19121683e-02f, -8.29004589e-03f, -7.13677406e-02f,
  1.58971220e-01f, 3.47069427e-02f, -3.93511690e-02f, 7.91731197e-03f, -2.39976868e-02f, 1.25778884e-01f, -5.64665347e-02f, -1.24426849e-01f, -1.45903200e-01f, -5.48283430e-03f,
  9.37231183e-02f, -3.98259461e-02f, 2.47253761e-01f, 1.15626134e-01f, -9.12163109e-02f, 1.08769285e-02f, -2.77042892e-02f, 8.71006027e-02f, 1.80869326e-01f, 2.29789224e-02f,
  7.53648505e-02f, -1.11087978e-01f, -1.13916568e-01f, -5.24243787e-02f, 9.57457349e-02f, 1.40235290e-01f, -1.37752369e-01f, 6.21899664e-02f, 1.07813284e-01f, -9.90886539e-02f,
  4.29496877e-02f, -4.94263768e-02f, -1.36196956e-01f, 5.11810780e-02f, 1.15342863e-01f, 9.93005410e-02f, 1.07063301e-01f, 3.03985346e-02f, 5.34100942e-02f, -8.80576298e-02f,
  -1.50981024e-01f, 5.35196662e-02f, 7.63993785e-02f, -9.53838304e-02f, 1.70797572e-01f, -1.17978208e-01f, -8.72018468e-03f, 5.71400747e-02f, -7.49082118e-02f, 9.13977101e-02f,
  -1.18884265e-01f, 1.05704881e-01f, 1.43097127e-02f, -1.18398786e-01f, -2.98732799e-03f, 7.86420554e-02f, -7.21036717e-02f, -9.02282223e-02f, 5.57130724e-02f, 8.49571731e-03f,
  1.14871480e-01f, 1.16510876e-01f, 3.31417806e-02f, 4.36834395e-02f, 1.64830044e-01f, 1.95598409e-01f, 1.03582449e-01f, 2.54796773e-01f, -2.27788329e-01f, 1.72084108e-01f,
  1.49654895e-01f, -1.01477310e-01f, -8.45106989e-02f, -3.74484807e-02f, 1.39380957e-03f, 9.94898677e-02f, 1.20342985e-01f, 7.89074674e-02f, 9.39043984e-02f, 4.19680662e-02f,
  -1.26558304e-01f, -8.89637545e-02f, 8.83463621e-02f, 1.04639731e-01f, -7.82872662e-02f, -3.72557715e-02f, 7.06921220e-02f, 4.56065014e-02f, -1.20478474e-01f, -6.95412792e-03f,
  4.23801877e-02f, 5.69028817e-02f, -5.99138774e-02f, -4.79055606e-02f, -1.04935482e-01f, 1.08828731e-01f, 2.27211248e-02f, 1.07872285e-01f, 4.11354341e-02f, -1.26431063e-01f,
  -1.14145659e-01f, -1.24031618e-01f, -1.14364035e-01f, 6.31352654e-03f, -1.54032230e-01f, 5.31783476e-02f, 1.61210120e-01f, 3.81876267e-02f, 4.85136434e-02f, 6.98139612e-03f,
  -3.81585620e-02f, 1.14410691e-01f, -1.07093334e-01f, 6.46458641e-02f, 6.54642433e-02f, -1.12493716e-01f, 1.24746747e-01f, 1.18072286e-01f, 1.18263386e-01f, -1.75026894e-01f,
  -1.39439762e-01f, 4.08477038e-02f, 1.48518593e-03f, 3.04176033e-01f, -7.21982718e-02f, -2.14270912e-02f, 5.69660068e-02f, -6.59427606e-03f, 1.90132901e-01f, 1.86402753e-01f,
  1.03243381e-01f, -6.60991948e-03f, -1.83239937e-01f, 7.76387460e-04f, 1.62481785e-01f, -6.35795742e-02f, 9.44737643e-02f, 4.98381741e-02f, 2.71859579e-02f, -5.94800152e-02f,
  -2.33044568e-03f, 1.36085488e-02f, -3.08427680e-02f, 6.21256828e-02f, -7.69184083e-02f, 8.73678327e-02f, -3.88844032e-03f, -5.82419261e-02f, -4.31724172e-03f, 1.08530372e-01f,
  9.36326683e-02f, 2.20406037e-02f, -1.47689372e-01f, -1.38914466e-01f, -2.18767263e-02f, -2.70527378e-02f, 1.70694981e-02f, 1.22148946e-01f, 4.71638329e-02f, 7.89222717e-02f,
  7.77331144e-02f, 1.04866721e-01f, 3.79402675e-02f, 1.46903200e-02f, -9.33698639e-02f, -1.07495971e-01f, -1.37973964e-01f, -6.03597797e-02f, -1.16844229e-01f, -5.27582020e-02f,
  9.31142829e-03f, 9.54863578e-02f, 1.67892531e-01f, 1.26603305e-01f, -3.36855724e-02f, -7.41066486e-02f, 5.56019694e-02f, -1.16176568e-01f, 1.18790738e-01f, 5.72005436e-02f,
  8.56827646e-02f, 5.49456254e-02f, 1.21695444e-01f, -2.43180413e-02f, 4.22624201e-02f, -5.86886331e-03f, -6.14580922e-02f, -1.04851693e-01f, 9.73799080e-02f, 2.90150866e-02f,
  -8.74577761e-02f, -8.29604222e-04f, 1.71748456e-02f, 3.34693268e-02f, 1.37133166e-01f, 1.63377952e-02f, 4.08685841e-02f, 2.60864086e-02f, -7.35339290e-03f, -2.07188223e-02f,
  -4.18886207e-02f, -6.37100860e-02f, 7.64825717e-02f, -2.20795698e-03f, -7.58424550e-02f, -2.15214994e-02f, -4.42077406e-04f, -4.90311049e-02f, 5.04539348e-02f, 1.10629469e-01f,
  4.90910038e-02f, -1.14583589e-01f, 6.83985204e-02f, 1.17947511e-01f, 6.08742088e-02f, -1.91283524e-02f, -1.99429952e-02f, 3.71937342e-02f, -3.50107886e-02f, 4.49527688e-02f,
  5.51256128e-02f, 1.81330442e-02f, 6.85722753e-02f, -5.07348366e-02f, 1.06727324e-01f, -4.32639159e-02f, 1.00613408e-01f, -1.12260245e-01f, 7.01772645e-02f, -2.86210943e-02f,
  -3.22113298e-02f, -4.28902321e-02f, -1.83313563e-02f, 8.62249509e-02f, -9.24709961e-02f, 5.98064736e-02f, -2.72338316e-02f, 6.51634410e-02f, -9.20694843e-02f, -7.02990144e-02f,
  7.37454277e-03f, 8.60730559e-02f, 8.07422772e-02f, -5.02171740e-03f, 2.86711734e-02f, -5.67505322e-02f, -1.26965135e-01f, -1.20677829e-01f, -1.16044596e-01f, -1.08678013e-01f,
  -7.39636272e-02f, -4.92309965e-02f, -6.31458387e-02f, -3.87277380e-02f, 3.37102786e-02f, -7.57242367e-02f, 1.56705469e-01f, 1.95829600e-01f, -4.57136743e-02f, 3.34925875e-02f,
  2.23593146e-01f, 4.25651558e-02f, -8.48241299e-02f, -7.13152904e-03f, -4.98989671e-02f, -1.12937734e-01f, -5.71929030e-02f, -6.22157531e-04f, 3.09263378e-01f, 5.87520376e-02f,
  -8.59375894e-02f, -6.82871863e-02f, 1.25959545e-01f, 3.04919574e-03f, -2.95805093e-02f, 1.39467910e-01f, 1.32111624e-01f, 3.17511708e-02f, 3.58474068e-03f, -5.90294525e-02f,
  2.83212900e-01f, 2.14296892e-01f, -7.31984228e-02f, 1.22909486e-01f, -1.76141858e-02f, -8.19134563e-02f, -1.63448639e-02f, 1.10144161e-01f, 2.45378271e-01f, 8.40424076e-02f,
  -7.51649067e-02f, 6.49724379e-02f, -8.49572271e-02f, 9.57400575e-02f, -5.61465733e-02f, 1.92423202e-02f, 7.21668685e-03f, 7.32011199e-02f, -2.43281722e-02f, -1.33994982e-01f,
  -2.65165847e-02f, -1.22983485e-01f, -9.62748379e-02f, 6.34214878e-02f, -3.53964381e-02f, 5.95957376e-02f, 9.49436873e-02f, 5.56107052e-02f, 6.37980700e-02f, -2.71081720e-02f,
  -5.18492460e-02f, 8.36057365e-02f, -9.22507122e-02f, -1.35575771e-01f, -9.15380046e-02f, 1.98310181e-01f, -1.04320850e-02f, 5.16593978e-02f, 1.17435344e-01f, 9.31573138e-02f,
  -2.34319805e-03f, 4.27364325e-03f, 7.08800331e-02f, 8.28940570e-02f, 4.83085103e-02f, -1.17938034e-01f, 2.00897127e-01f, -1.17165789e-01f, 4.61631007e-02f, -8.26964453e-02f,
  4.35774177e-02f, 1.14642657e-01f, 2.48351712e-02f, 1.16290458e-01f, -1.01989619e-01f, -5.60128540e-02f, -1.60607714e-02f, -9.65798795e-02f, -8.70741978e-02f, 4.01923470e-02f,
  1.36722684e-01f, 4.27115895e-02f, 6.05409732e-03f, -2.08351072e-02f, 1.80840716e-01f, -1.43578937e-02f, 6.62002563e-02f, 4.80992049e-02f, -5.69441989e-02f, 1.92322284e-02f,
  1.96145698e-02f, -1.39563065e-02f, 1.26888201e-01f, 1.09345809e-01f, 6.50819167e-02f, -8.16312656e-02f, -1.32399261e-01f, -3.14959064e-02f, 1.06313072e-01f, -4.02414501e-02f,
  -1.55466041e-02f, -4.25286926e-02f, -3.22563015e-02f, -4.24863063e-02f, 8.19915831e-02f, -4.02091667e-02f, 3.45108695e-02f, -1.18936539e-01f, -9.75572020e-02f, 6.50331229e-02f,
  -9.60978270e-02f, -5.72833531e-02f, -9.15549695e-02f, 1.18505448e-01f, -4.87007089e-02f, -4.36373726e-02f, -1.37700737e-01f, -2.09995173e-02f, 8.26463923e-02f, -1.41227050e-02f,
  8.37514400e-02f, -8.24830383e-02f, 1.29041433e-01f, 6.74414337e-02f, -4.98260446e-02f, -8.20529088e-02f, -2.52735727e-02f, -4.31511439e-02f, 2.27192836e-03f, -1.10062860e-01f,
  -9.80128795e-02f, -9.46564823e-02f, -1.40929604e-02f, -6.29102737e-02f, 1.16803914e-01f, -5.20119183e-02f, -2.59078555e-02f, 3.95273753e-02f, -8.58995244e-02f, -9.97269154e-02f,
  -8.21939036e-02f, 4.88144299e-03f, -3.34524959e-02f, -5.92537969e-02f, -1.65669201e-03f, 3.10024340e-02f, 2.77117193e-02f, 1.17370486e-01f, -6.23424947e-02f, 1.01682581e-01f,
  1.30416453e-01f, 1.06288955e-01f, 6.88719973e-02f, 9.46482345e-02f, -7.18142465e-02f, -9.37826857e-02f, -8.43138695e-02f, -1.32909358e-01f, 3.62415984e-02f, 2.90722605e-02f,
  6.25625998e-02f, -4.54518870e-02f, -7.41385994e-03f, -1.18163913e-01f, 1.10719740e-01f, -5.95788509e-02f, -5.54909091e-03f, -3.27418111e-02f, -1.18922949e-01f, 7.28978664e-02f,
  -3.74156907e-02f, -2.55762041e-02f, -3.38813588e-02f, 3.14944200e-02f, 2.13890728e-02f, -1.25297561e-01f, 1.21852040e-01f, -4.11803052e-02f, 5.01435772e-02f, -6.51706085e-02f,
  1.31176621e-01f, 1.23016849e-01f, 8.14207494e-02f, 4.98033054e-02f, 9.64442790e-02f, 2.02093031e-02f, 2.11858645e-01f, 1.56719297e-01f, 2.45971829e-01f, 2.01872557e-01f,
  2.67571986e-01f, 1.74789473e-01f, 1.01484857e-01f, 5.35161532e-02f, 4.04521711e-02f, 1.65873379e-01f, 2.28008032e-01f, -2.67909229e-01f, -2.42180526e-01f, -3.81508507e-02f,
  -4.59620133e-02f, -1.12920143e-01f, -2.02566758e-02f, 2.60588050e-01f, 2.37595886e-01f, 7.99815580e-02f, -1.31420225e-01f, -1.22285262e-01f, 2.48649064e-02f, 5.86472712e-02f,
  -1.80995115e-03f, 7.46656135e-02f, 3.60728800e-03f, 1.88945696e-01f, 5.98922260e-02f, -5.57752810e-02f, -1.34496437e-02f, -6.72738701e-02f, 1.05034895e-01f, -1.40767753e-01f,
  3.03324461e-01f, -3.10533633e-03f, 8.23689550e-02f, -1.40773788e-01f, -1.31722942e-01f, 1.18238017e-01f, 8.41516703e-02f, -1.16148412e-01f, 7.98723325e-02f, -1.61309674e-01f,
  2.00801015e-01f, 1.83735907e-01f, 1.57426834e-01f, 2.01495904e-02f, 2.47366931e-02f, 1.38282835e-01f, 9.27215219e-02f, -1.00450695e-01f, 7.89454579e-02f, -1.90700479e-02f,
  1.07971445e-01f, 9.23867822e-02f, -1.88237391e-02f, 7.97547624e-02f, 4.26905509e-03f, 1.43816322e-03f, -6.74444363e-02f, 1.15042046e-01f, -1.38194010e-01f, -4.42473218e-02f,
  1.71424896e-01f, 2.08133072e-01f, 3.47438157e-02f, 9.31166206e-03f, 1.64124995e-01f, 1.59571886e-01f, 7.13803172e-02f, -2.42795289e-01f, -1.28320483e-02f, 3.88814658e-01f,
  3.84381972e-02f, 1.46590993e-01f, 3.25774819e-01f, -7.64873922e-02f, 3.59343179e-02f, -4.11978252e-02f, 1.19002014e-01f, 1.36680827e-01f, 1.26620471e-01f, -3.98882851e-02f,
  1.60382520e-02f, -1.00945853e-01f, 1.02082230e-01f, -1.01496525e-01f, -9.53631382e-03f, 3.97341922e-02f, 6.75307959e-02f, -1.76292047e-01f, -1.69173643e-01f, -4.27992921e-03f,
  7.21694529e-02f, 4.69427072e-02f, -1.66904539e-01f, -1.46747813e-01f, 4.14361149e-01f, -1.44317880e-01f, -1.19917858e-02f, 3.52866459e-03f, 1.98220480e-02f, -6.83392957e-02f,
  -1.95508394e-02f, 1.03108361e-01f, 1.92647219e-01f, -1.85930710e-02f, 8.98870528e-02f, -2.26605944e-02f, -7.37689361e-02f, 1.90449297e-01f, -1.59382112e-02f, 7.52613097e-02f,
  -3.60067412e-02f, -1.15688607e-01f, 2.05849539e-02f, 1.56870991e-01f, 8.00719261e-02f, 6.95458576e-02f, -5.77633306e-02f, 4.48043257e-01f, 1.49926037e-01f, 2.97601044e-01f,
  1.11561216e-01f, -1.32186428e-01f, 3.11408136e-02f, -2.26002336e-02f, -4.10836097e-03f, 5.12035526e-02f, -1.49630348e-03f, 3.27601805e-02f, -5.31129502e-02f, 1.57083690e-01f,
  -7.38177896e-02f, 8.22467804e-02f, 8.28043818e-02f, 1.00381851e-01f, -9.56173092e-02f, -1.39452815e-02f, 4.27835174e-02f, 9.36797634e-02f, 1.75729617e-01f, -6.34331480e-02f,
  -5.66440113e-02f, -1.09546959e-01f, 3.23252729e-03f, -8.40192437e-02f, -8.99370760e-02f, -1.03344694e-01f, 1.67918131e-02f, -7.87132047e-03f, 8.88028927e-03f, 4.22343612e-02f,
  -1.14881024e-01f, 1.28917724e-01f, 1.35386348e-01f, 1.20085552e-01f, 2.45844368e-02f, 4.03364748e-02f, 7.17924312e-02f, 1.22868448e-01f, -4.80564386e-02f, -3.59766521e-02f,
  6.97498992e-02f, -7.60110319e-02f, 1.36036845e-02f, 1.23977497e-01f, -8.37092176e-02f, 2.28955392e-02f, 1.35267526e-01f, -7.38238767e-02f, 1.02028005e-01f, 7.45280385e-02f,
  1.35181183e-02f, -1.91761293e-02f, 5.92007823e-02f, 5.49828969e-02f, 4.10098284e-02f, -2.40051113e-02f, -3.41248773e-02f, -1.48115799e-01f, -1.44726336e-01f, -9.02072061e-03f,
  -5.25407754e-02f, -1.16071843e-01f, 5.31662516e-02f, 4.18319181e-02f, 2.32962389e-02f, -2.95248330e-02f, -9.70232114e-02f, -1.11823559e-01f, 1.53221950e-01f, 1.37419179e-01f,
  -7.23026274e-03f, 9.76883806e-03f, 1.60204321e-01f, 3.99306789e-02f, -1.77818298e-01f, 8.89495462e-02f, 1.37054306e-02f, 4.50101532e-02f, -3.45987976e-02f, 1.11226685e-01f,
  9.74330828e-02f, 9.17338803e-02f, -1.22628855e-02f, -9.32121798e-02f, -1.30751267e-01f, 1.38678551e-01f, 4.65577096e-02f, -1.04821697e-01f, 1.63481832e-01f, -2.36764718e-02f,
  3.61433923e-02f, -7.22198412e-02f, 1.30889356e-01f, -5.69077842e-02f, -9.63256732e-02f, -1.07358098e-01f, -1.08349606e-01f, -1.31452650e-01f, -6.92822039e-02f, 3.20308772e-03f,
  -4.14789245e-02f, 1.27280951e-01f, -7.23238066e-02f, 2.29966082e-03f, -9.88800228e-02f, 9.95366275e-02f, -2.52003223e-02f, -2.91836653e-02f, -2.41582338e-02f, -1.21262774e-01f,
  -1.61424708e-02f, -6.37913644e-02f, 7.23482668e-02f, 1.66338742e-01f, -1.96755212e-02f, 3.39681692e-02f, -1.23846300e-01f, 3.20157632e-02f, -6.78954422e-02f, 1.01580016e-01f,
  -1.08156011e-01f, -5.75358458e-02f, 9.56734121e-02f, -1.09851137e-01f, -7.85361305e-02f, -1.96138863e-02f, 2.13943254e-02f, 1.59162939e-01f, 3.86808887e-02f, -8.29794481e-02f,
  -6.21004440e-02f, 1.00106336e-02f, 1.04142008e-02f, 6.18111379e-02f, -6.51307404e-02f, -7.53983334e-02f, -8.78771842e-02f, -3.41013037e-02f, -3.63990143e-02f, -5.76059371e-02f,
  -7.72773400e-02f, 9.48438887e-03f, -5.70460595e-03f, -3.63506526e-02f, -1.30302697e-01f, -2.59510987e-02f, -5.60176596e-02f, 7.45005300e-03f, -3.54967937e-02f, -9.90243182e-02f,
  -1.05127446e-01f, -1.19395077e-01f, 1.71614401e-02f, 3.69724743e-02f, 1.13912374e-01f, -4.33925129e-02f, -2.81412178e-03f, 5.06572239e-02f, 2.88475528e-02f, 3.67000811e-02f,
  -1.04357816e-01f, -9.84809026e-02f, 7.32220709e-02f, 4.59509492e-02f, -4.10254560e-02f, 1.08169183e-01f, -8.38141441e-02f, -6.15775511e-02f, -2.08329074e-02f, 8.43484625e-02f,
  -9.39382426e-03f, 1.14098504e-01f, 6.73228204e-02f, 4.38761674e-02f, 1.13773830e-02f, -9.44800749e-02f, 2.22645402e-02f, -7.91722164e-03f, 2.40722559e-02f, 2.79287379e-02f,
  5.47537059e-02f, -7.57971704e-02f, -8.00293684e-02f, 1.43373590e-02f, 1.11935653e-01f, -6.10370189e-03f, 8.28817785e-02f, -1.10439524e-01f, -1.06999055e-01f, 1.83718204e-02f,
  1.21528804e-01f, -4.41236310e-02f, -1.16773240e-01f, 7.71973468e-03f, 1.27107576e-02f, -6.48209155e-02f, 1.05837129e-01f, 1.45461425e-01f, 6.95593432e-02f, 1.08267993e-01f,
  1.55811980e-01f, 1.30084798e-01f, 9.88768507e-03f, -1.22778311e-01f, 1.58732846e-01f, -1.56203331e-02f, 1.25946803e-02f, -4.71802913e-02f, 8.91639739e-02f, -9.89905372e-03f,
  -9.73740499e-03f, -6.41371086e-02f, 1.09572545e-01f, 4.55579124e-02f, -5.60294352e-02f, -8.88588876e-02f, -8.19728673e-02f, 3.73634584e-02f, 1.33828714e-01f, 1.99246462e-02f,
  8.81330594e-02f, 2.78016496e-02f, 2.41336934e-02f, 1.17859252e-01f, -9.35709774e-02f, 1.63766965e-01f, -3.50149460e-02f, 7.67262504e-02f, -8.03269818e-02f, 3.49255055e-02f,
  5.66659309e-02f, -1.31661877e-01f, -7.09415153e-02f, -5.09041250e-02f, 6.56632334e-02f, 1.09566748e-01f, -9.31349844e-02f, -1.02160357e-01f, -4.16104458e-02f, 2.22370718e-02f,
  3.12839225e-02f, 8.33556652e-02f, 3.70385163e-02f, -7.64285848e-02f, 3.00046038e-02f, -7.16603994e-02f, -1.01796813e-01f, -1.10961132e-01f, 7.46604381e-03f, 1.28972605e-02f,
  -1.06934555e-01f, 2.52693780e-02f, -1.16823547e-01f, 9.67296585e-02f, -3.36020812e-02f, 1.70676425e-01f, -7.71229640e-02f, -6.69549685e-03f, 1.10119730e-01f, 4.03453298e-02f,
  1.63714096e-01f, 1.81870908e-02f, 2.90047348e-01f, 1.45729184e-01f, 1.97230220e-01f, 3.65792990e-01f, 1.90364003e-01f, -2.18793213e-01f, 2.94923365e-01f, -1.47612333e-01f,
  -2.69628137e-01f, 2.68747527e-02f, 5.17735630e-02f, 1.29990831e-01f, 2.85885692e-01f, -4.07854170e-02f, 5.27536124e-02f, 2.61985529e-02f, -2.31722407e-02f, 7.62365758e-02f,
  3.61227873e-03f, -3.71238999e-02f, -4.71704528e-02f, 1.16137788e-01f, -3.54636600e-03f, 2.50701830e-02f, 7.49389976e-02f, -9.79655460e-02f, 1.84153259e-01f, 2.67480966e-02f,
  -5.04403897e-02f, -7.15592057e-02f, 1.05758421e-02f, 8.81545711e-03f, 6.34222524e-03f, -1.43205360e-01f, 7.49844033e-03f, -9.89818722e-02f, 6.62146658e-02f, 9.78129432e-02f,
  2.53034998e-02f, -4.41635512e-02f, -1.09009676e-01f, 1.11345015e-01f, -8.50542039e-02f, 4.34991606e-02f, 9.86744165e-02f, -9.04612839e-02f, 2.51084138e-02f, -2.19258107e-02f,
  -1.32381245e-01f, -7.71176666e-02f, 5.74928150e-02f, 1.77346300e-02f, -6.61169440e-02f, 4.66196053e-02f, -5.29841240e-03f, 4.25267108e-02f, -1.70608595e-01f, 1.27724394e-01f,
  3.07833012e-02f, 6.19054697e-02f, 6.08287519e-03f, -1.21125653e-01f, -1.39087155e-01f, -1.45426199e-01f, -1.14269100e-01f, 1.07358970e-01f, -3.05394623e-02f, 1.49621861e-02f,
  1.23216458e-01f, 7.34935030e-02f, -8.86992216e-02f, 8.01163092e-02f, -1.07556544e-01f, -5.70535585e-02f, 1.99983437e-02f, 1.11736350e-01f, -1.42544108e-02f, 1.27577171e-01f,
  -1.13935329e-01f, 1.26408264e-01f, -9.98960957e-02f, 6.78069666e-02f, 1.36503279e-01f, 3.36899832e-02f, 1.42825752e-01f, 3.12968594e-04f, 1.10761710e-01f, 6.11703955e-02f,
  1.20371789e-01f, 4.48975153e-02f, 3.96473333e-02f, -1.05047889e-01f, 1.24519080e-01f, 8.57817158e-02f, -9.31533352e-02f, 1.07198097e-01f, -4.34109606e-02f, 6.19953610e-02f,
  1.26996282e-02f, 3.31807472e-02f, -6.66701868e-02f, -1.27807334e-01f, -9.72877145e-02f, -3.62768695e-02f, 2.84038819e-02f, -3.54331657e-02f, -1.99551042e-02f, -5.26609831e-03f,
  -9.31291804e-02f, 1.11186415e-01f, -8.52580890e-02f, 8.90037790e-02f, -4.04061936e-02f, -1.05489731e-01f, 9.07555521e-02f, 1.28132850e-01f, 8.49668160e-02f, -8.81140530e-02f,
  9.52418819e-02f, 1.41601980e-01f, 6.12321720e-02f, 9.22754034e-03f, -4.57232706e-02f, -1.32246614e-01f, 7.22025707e-02f, -1.02470204e-01f
};

// L2_fan_Bp_bar (Shape: 1 x 52)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 52;
const float L2_fan_Bp_bar_data[] = {
  -4.36445735e-02f, 1.61314249e-01f, 1.03682093e-02f, 2.70717144e-02f, -1.05473720e-01f, 4.22984622e-02f, -4.23424505e-02f, 1.71024188e-01f, 2.16108263e-01f, 4.91787642e-02f,
  2.96303183e-01f, -8.48928094e-02f, 2.48439580e-01f, -8.06793049e-02f, -6.86907172e-02f, -8.20025578e-02f, 4.15692963e-02f, -4.77054194e-02f, 6.30501881e-02f, 8.94859955e-02f,
  1.97418198e-01f, 8.75165462e-02f, 2.18974620e-01f, 2.02525407e-03f, 1.04564421e-01f, -7.53026903e-02f, 2.65104234e-01f, -1.01986349e-01f, -3.47056389e-02f, 9.81590897e-02f,
  2.06977442e-01f, -1.44705707e-02f, 1.72606200e-01f, 5.76457717e-02f, 1.00131467e-01f, -7.34350272e-03f, 1.43794179e-01f, 3.86819951e-02f, 2.13154312e-03f, 1.42345056e-01f,
  5.03586978e-02f, 4.31435890e-02f, 7.53523186e-02f, -2.12260820e-02f, 5.54619394e-02f, 1.69522613e-01f, 1.37644589e-01f, 5.89856133e-02f, 5.03733680e-02f, -4.24168520e-02f,
  2.67804772e-01f, 8.99036601e-02f
};

// L3_fan_Wp (Shape: 6 x 64)
const int L3_fan_Wp_rows = 6;
const int L3_fan_Wp_cols = 64;
const float L3_fan_Wp_data[] = {
  4.54177707e-02f, 9.23520848e-02f, 6.51360676e-02f, 5.03951497e-02f, 1.68322727e-01f, -1.10335246e-01f, -3.86986732e-01f, -1.14155032e-01f, -3.72626573e-01f, -3.67506444e-02f,
  -1.00080736e-01f, -1.63675070e-01f, -5.41689210e-02f, -2.68205516e-02f, -1.71759978e-01f, -1.54638514e-01f, -8.86628032e-02f, -1.09901488e-01f, -9.20372456e-02f, 6.01624772e-02f,
  1.17134996e-01f, -4.52766605e-02f, 1.44810259e-01f, 9.57895964e-02f, 3.72349434e-02f, -3.23322676e-02f, -9.49684530e-02f, 4.50978242e-03f, 3.04825641e-02f, 9.30976346e-02f,
  -7.10827950e-03f, 4.55656946e-02f, -2.02122286e-01f, 1.65150732e-01f, 1.91619918e-01f, -4.57700342e-02f, -3.78586501e-02f, 1.05520837e-01f, 4.02049273e-02f, -1.38320014e-01f,
  2.57358365e-02f, -1.36501282e-01f, -1.33023877e-02f, -5.62829040e-02f, -2.29515322e-02f, 5.27298078e-02f, -1.26176625e-01f, 1.66324973e-02f, -2.63124164e-02f, -1.11096345e-01f,
  -7.23029301e-02f, -2.95503661e-02f, -7.10321814e-02f, -2.18410060e-01f, -1.30368903e-01f, -1.48338927e-02f, 1.01660945e-01f, 2.38459915e-01f, 1.55200124e-01f, 9.19297710e-02f,
  -6.39854074e-02f, -1.05385132e-01f, -1.13849780e-02f, -7.28993714e-02f, -6.72286600e-02f, 7.03130141e-02f, -2.91701425e-02f, 1.10770680e-01f, 6.72353134e-02f, 6.16018288e-02f,
  4.31896597e-01f, -3.77187913e-04f, 2.12808162e-01f, 1.69177979e-01f, 1.87996045e-01f, -6.95260540e-02f, 1.04788937e-01f, 1.79765284e-01f, 5.64914905e-02f, 2.05359180e-02f,
  -3.48080061e-02f, 1.61050435e-03f, -5.70061011e-03f, -1.14494771e-01f, -1.46869972e-01f, 6.98648691e-02f, 6.56884629e-03f, 1.52568910e-02f, -6.74723685e-02f, 8.65220875e-02f,
  -6.22724034e-02f, -4.40749526e-02f, -5.99375330e-02f, -9.22786668e-02f, -1.14416946e-02f, -2.33348489e-01f, 7.55401850e-02f, -3.73903982e-04f, -1.00805052e-01f, 8.25465377e-03f,
  -1.21116497e-01f, 7.85863772e-02f, -9.26450267e-02f, 1.32111937e-01f, 1.33531839e-01f, 2.58588612e-01f, -5.22514023e-02f, -1.14225700e-01f, -1.12215802e-01f, 2.39220764e-02f,
  -1.42228872e-01f, -4.96745929e-02f, -9.31959450e-02f, 1.32811889e-01f, -1.45046398e-01f, -1.52684882e-01f, 1.10487729e-01f, 1.05746448e-01f, 2.21003201e-02f, 6.64932979e-03f,
  -1.04079945e-02f, 1.53940991e-02f, -4.61091287e-02f, -1.14055872e-02f, 6.67791814e-02f, -3.45566869e-02f, -1.69666205e-02f, -1.96762905e-02f, -3.53108421e-02f, 5.77412546e-02f,
  -2.03945413e-01f, 4.13443297e-02f, -1.38817551e-02f, 6.77743256e-02f, 1.21684216e-01f, 8.42309371e-02f, 3.22163701e-01f, 4.74632569e-02f, 4.01466228e-02f, 8.91251191e-02f,
  1.75571907e-02f, 1.28652006e-01f, 2.18367055e-01f, -4.37292866e-02f, -3.93814221e-02f, 1.54020460e-02f, -4.76564988e-02f, -3.85157950e-02f, -2.00345833e-02f, 3.47323455e-02f,
  -1.34384766e-01f, -1.23609670e-01f, -4.53906693e-03f, -3.59965861e-02f, -5.13369702e-02f, 4.03524283e-03f, -8.14912394e-02f, -6.27277642e-02f, 2.75130421e-02f, -1.34325817e-01f,
  2.14317590e-01f, 1.04431380e-02f, -1.02188602e-01f, -1.46804154e-01f, -2.10805563e-03f, 8.00528228e-02f, -1.21880993e-01f, 1.15381852e-01f, 3.71787436e-02f, 6.56461567e-02f,
  6.66957572e-02f, 4.93198521e-02f, -1.30748421e-01f, -1.40410200e-01f, 3.17172706e-02f, -7.26669431e-02f, 5.33222370e-02f, 7.84823522e-02f, -1.57152206e-01f, -1.64001063e-01f,
  -9.08580571e-02f, 2.09167808e-01f, -4.51104566e-02f, 4.57675308e-02f, 2.90972218e-02f, 1.65517345e-01f, -1.98611170e-02f, -1.29781142e-01f, 1.48660885e-02f, -3.98607031e-02f,
  -1.49145812e-01f, -3.06993388e-02f, -2.97478419e-02f, -4.88988757e-02f, -1.50165200e-01f, -4.28981818e-02f, -3.56030352e-02f, 6.31749704e-02f, 1.24170475e-01f, 6.69304421e-03f,
  -5.39896153e-02f, 6.68530678e-03f, -1.82304457e-01f, 1.46946266e-01f, 7.35116079e-02f, 1.26047388e-01f, -8.17115977e-02f, -6.37201546e-03f, 1.19132899e-01f, 4.41691242e-02f,
  2.61141136e-02f, -1.24650441e-01f, 7.44541660e-02f, 3.42725664e-02f, 1.67618811e-01f, 6.79869205e-02f, 8.79627690e-02f, 1.11173026e-01f, 4.09195945e-02f, 5.22344597e-02f,
  1.20933965e-01f, -8.98646787e-02f, -2.00834095e-01f, -5.95266744e-03f, 9.16277338e-03f, -1.16250001e-01f, -2.76004910e-01f, 1.26070395e-01f, -6.57061264e-02f, -1.07948435e-03f,
  1.14656664e-01f, -2.22375547e-03f, 4.38701212e-02f, 8.19472014e-04f, 7.69288763e-02f, 3.37558202e-02f, -5.10618612e-02f, 9.71326679e-02f, -1.77850891e-02f, 6.22957684e-02f,
  9.00405794e-02f, 1.12803921e-01f, -1.13913929e-02f, -8.08011070e-02f, -2.00833343e-02f, 1.06085584e-01f, -8.03487375e-02f, -6.74140379e-02f, -1.19733401e-01f, -1.91765741e-01f,
  -2.86535136e-02f, -1.19647585e-01f, 4.27087434e-02f, -6.10851608e-02f, 1.19322181e-01f, -1.76711809e-02f, 1.39092833e-01f, -7.69662857e-02f, -1.08065128e-01f, 7.28997141e-02f,
  1.76970914e-01f, 1.06152751e-01f, 1.02532066e-01f, 1.04085743e-01f, -7.35757127e-02f, -7.20972419e-02f, -1.71019271e-01f, 1.22359559e-01f, -7.30462223e-02f, -9.47181433e-02f,
  8.52058157e-02f, 3.71707305e-02f, -5.39417416e-02f, 3.82451825e-02f, -4.75531407e-02f, -7.83357620e-02f, 7.95465410e-02f, -1.07433528e-01f, 2.05356151e-01f, 1.03719801e-01f,
  1.13383166e-01f, -3.94927114e-02f, 4.93089370e-02f, -4.18823808e-02f, 1.13067657e-01f, 2.34019607e-02f, -2.35262066e-02f, 6.45923242e-02f, 1.18167058e-01f, -1.12131141e-01f,
  2.13427674e-02f, 6.46698475e-02f, -5.53144002e-03f, -5.18524274e-02f, 5.94913103e-02f, 4.77179028e-02f, -3.27741653e-02f, -9.74022970e-02f, -1.50699709e-02f, -2.94633862e-02f,
  1.33756235e-01f, 4.18456830e-02f, 1.07687809e-01f, -1.62267804e-01f, -7.44491667e-02f, 2.34268624e-02f, 9.54821035e-02f, 4.69493419e-02f, 4.15461743e-03f, -1.56798456e-02f,
  1.19561546e-01f, -3.66592668e-02f, 1.14777945e-01f, -1.28230020e-01f, 1.42615214e-01f, -1.85913406e-02f, 2.14977115e-02f, -9.49772596e-02f, -9.46993902e-02f, -5.65292723e-02f,
  -1.00275269e-02f, 1.62690923e-01f, -1.37734294e-01f, 1.92152753e-01f, -2.95459572e-03f, -2.07111612e-02f, 3.76214713e-01f, 3.79314013e-02f, 3.18184137e-01f, 1.36676669e-01f,
  -1.05894268e-01f, 3.85456197e-02f, -2.39203461e-02f, 1.78047448e-01f, 2.30056241e-01f, 3.69854877e-03f, -1.15331181e-03f, -7.22281262e-02f, 2.85331365e-02f, -9.53922570e-02f,
  -5.01542818e-03f, 5.16542420e-02f, -1.59921497e-01f, -1.25928715e-01f, 8.90657082e-02f, -1.33451834e-01f, 6.73691854e-02f, 1.19080342e-01f, -6.81714434e-03f, 5.84425442e-02f,
  -1.12916142e-01f, -1.11615881e-01f, 3.52671407e-02f, 8.75361711e-02f, -6.15801290e-02f, -1.13364086e-02f, 1.34114809e-02f, -1.14673963e-02f, -1.05474405e-01f, 6.82417899e-02f,
  -5.07496409e-02f, -3.41210887e-02f, 1.03059903e-01f, -3.79167870e-02f, -1.07683495e-01f, 1.03206977e-01f, -1.49182945e-01f, -1.29587963e-01f, 6.88942820e-02f, 1.28390312e-01f,
  -8.40241164e-02f, -1.66271821e-01f, 1.01460174e-01f, 1.79746494e-01f, 2.48854849e-02f, 9.39563438e-02f, 7.92586058e-02f, -1.05048306e-02f, -1.38250709e-01f, -1.96499556e-01f,
  -2.35259589e-02f, -2.58400794e-02f, -2.37244269e-04f, 2.17694901e-02f
};

// L3_fan_Wp_bar (Shape: 52 x 64)
const int L3_fan_Wp_bar_rows = 52;
const int L3_fan_Wp_bar_cols = 64;
const float L3_fan_Wp_bar_data[] = {
  2.88785566e-02f, 1.64120317e-01f, -7.13111535e-02f, -3.91072184e-02f, 6.91290572e-02f, -6.65996447e-02f, 5.19398274e-03f, -1.14413522e-01f, -2.73925141e-02f, 1.58230603e-01f,
  -4.86029312e-02f, -4.55170535e-02f, 8.83080438e-02f, 1.42027065e-01f, -1.00697339e-01f, -1.16891116e-01f, -6.30163178e-02f, 4.68725897e-02f, 5.86837390e-03f, 6.37334138e-02f,
  1.13487728e-01f, 4.81433123e-02f, -9.28542763e-02f, -2.23962720e-02f, 9.78706256e-02f, 4.11408544e-02f, 1.97168160e-02f, 3.30053717e-02f, -8.05605203e-02f, 6.37857914e-02f,
  -6.86450675e-02f, -8.02568346e-02f, 1.57651608e-03f, -3.51253487e-02f, -4.83200550e-02f, -1.09419174e-01f, 4.91052940e-02f, 6.78280741e-02f, -3.61654386e-02f, -5.32618873e-02f,
  -7.25992247e-02f, 1.51785597e-01f, 7.14571476e-02f, -1.23697348e-01f, 1.30801544e-01f, -5.72963059e-02f, 6.04973547e-02f, 1.15687720e-01f, -1.21269248e-01f, -5.69621697e-02f,
  5.43991337e-03f, -1.09930575e-01f, 1.17145568e-01f, 6.86680749e-02f, -8.90870467e-02f, -3.64164300e-02f, -1.08070791e-01f, -3.62784825e-02f, 8.09443593e-02f, -7.31898472e-03f,
  1.13139987e-01f, -4.74293046e-02f, 1.33295804e-01f, -2.69238595e-02f, -1.70254558e-02f, -1.31966481e-02f, -9.73994732e-02f, -7.46176243e-02f, 5.01787029e-02f, -6.86654747e-02f,
  -2.15475317e-02f, -1.07912309e-02f, 4.44280393e-02f, 4.46341932e-02f, 7.22983629e-02f, 2.67537031e-02f, 9.97462273e-02f, -7.05301687e-02f, -3.38689163e-02f, -5.19672409e-02f,
  8.54325891e-02f, 5.37183275e-03f, 8.38747025e-02f, -3.28487121e-02f, -6.81490526e-02f, 7.80656710e-02f, 4.29047272e-02f, 1.03173561e-01f, -2.24455558e-02f, 2.64071990e-02f,
  1.84424547e-03f, -7.10963234e-02f, -2.67013833e-02f, 1.11987665e-01f, -8.98797344e-03f, -7.46282786e-02f, 8.26195478e-02f, 2.29192469e-02f, -1.17454678e-01f, -1.20799504e-01f,
  4.05512936e-02f, 8.51632804e-02f, -5.55285886e-02f, 1.04205877e-01f, 1.08451575e-01f, -7.39702955e-02f, 1.47780301e-02f, 1.98459066e-02f, 9.93771702e-02f, 6.33101240e-02f,
  7.14051053e-02f, 1.03313901e-01f, -1.37121268e-02f, 3.74578387e-02f, 6.57302886e-02f, -2.00992189e-02f, -9.07848924e-02f, 1.29784212e-01f, -2.50280406e-02f, -4.43903506e-02f,
  -1.19570225e-01f, 1.12620771e-01f, -1.09708078e-01f, -2.30603851e-02f, -8.57419223e-02f, 1.06157042e-01f, -2.27174144e-02f, 1.18418977e-01f, 9.93249267e-02f, 7.34439865e-02f,
  4.60388511e-02f, 7.02140033e-02f, 1.09531535e-02f, -7.05313012e-02f, -1.27244994e-01f, 9.69910175e-02f, 1.15170799e-01f, 5.08583114e-02f, 3.28544937e-02f, 1.09719574e-01f,
  -1.04462607e-02f, 1.08142488e-01f, 2.82098278e-02f, -1.10099226e-01f, -1.28758445e-01f, -1.54768245e-03f, 8.54805782e-02f, 1.52136460e-01f, -1.55933350e-02f, -3.02411672e-02f,
  -6.16730936e-02f, -7.77511522e-02f, 1.01715788e-01f, -2.26636566e-02f, 1.06777631e-01f, 2.71991063e-02f, -6.33348897e-02f, -3.16770226e-02f, 1.40843987e-01f, -2.68930048e-02f,
  1.38038903e-01f, 1.29135743e-01f, 4.86339703e-02f, -6.10551760e-02f, -9.79233459e-02f, -7.93176964e-02f, -7.21122846e-02f, -7.23379478e-02f, -1.31567463e-01f, 4.72426899e-02f,
  -1.26533613e-01f, -1.31734878e-01f, 1.20204449e-01f, 1.13503687e-01f, -7.77878314e-02f, 8.66795108e-02f, 7.14361668e-02f, -8.34628642e-02f, 7.46282861e-02f, 2.64416225e-02f,
  8.01143199e-02f, 5.52656390e-02f, 3.05921417e-02f, -1.44225666e-02f, -5.96921407e-02f, 1.66608959e-01f, 1.15936927e-01f, -1.83575694e-02f, -4.66604456e-02f, 7.93063864e-02f,
  -8.35605189e-02f, -1.13049887e-01f, 2.01839637e-02f, 1.00776345e-01f, -8.31152797e-02f, -5.28770499e-02f, -1.42993033e-01f, -3.75914574e-02f, -4.90330905e-03f, -5.50935008e-02f,
  1.50748059e-01f, -7.59179518e-03f, 1.22908890e-01f, -7.51934648e-02f, 4.03130613e-02f, 5.87619171e-02f, -5.24015203e-02f, 2.00624159e-03f, 1.05719000e-01f, 8.85026976e-02f,
  9.63059217e-02f, -4.06653211e-02f, 6.84067681e-02f, -2.12428290e-02f, 4.33330797e-02f, -3.06552835e-02f, -6.07430353e-04f, 1.02505378e-01f, 1.22894545e-03f, -6.42617494e-02f,
  2.92685255e-02f, -6.25795126e-02f, 8.74972790e-02f, 2.43795719e-02f, -1.54634183e-02f, -3.08526177e-02f, -3.97367552e-02f, 9.43122730e-02f, 8.26717690e-02f, 8.85200575e-02f,
  1.66785736e-02f, -1.18282065e-03f, 1.22422136e-01f, 1.38971031e-01f, -2.31068041e-02f, 2.39901766e-02f, 8.82676765e-02f, 8.29159543e-02f, 9.23208799e-03f, -1.18270435e-03f,
  1.34092838e-01f, 2.15739314e-03f, -1.39704603e-03f, -3.97510827e-02f, -6.72960505e-02f, 1.64003447e-02f, 6.31571338e-02f, 7.43886605e-02f, -8.88497084e-02f, 3.63826007e-03f,
  7.58483261e-02f, 8.70806258e-03f, 1.19487651e-01f, -5.60142770e-02f, 1.20719895e-01f, 1.03365369e-01f, 7.08878860e-02f, 1.39604390e-01f, -1.88077688e-02f, -7.19615771e-03f,
  7.59125426e-02f, -1.45221567e-02f, 1.30738243e-01f, -8.38667452e-02f, -9.70108286e-02f, 1.37388870e-01f, 9.76886302e-02f, -1.54791579e-01f, 9.31894407e-02f, -9.21840444e-02f,
  -2.41631605e-02f, -1.26354098e-01f, -8.79977793e-02f, 1.99764997e-01f, -1.14591666e-01f, 3.85324657e-02f, 1.86712235e-01f, -1.13613553e-01f, -6.09417148e-02f, -4.22844961e-02f,
  1.71080962e-01f, 4.73080538e-02f, -6.40143901e-02f, -3.10485009e-02f, 6.51067868e-02f, 3.76641639e-02f, -1.29641118e-02f, -3.57903577e-02f, -1.75996214e-01f, -2.84446813e-02f,
  -2.05825642e-03f, -6.68137893e-02f, 9.73530579e-03f, -8.46152902e-02f, 1.46758240e-02f, -1.20178707e-01f, -9.83686093e-03f, 1.54061273e-01f, 2.24238247e-01f, -7.83387572e-02f,
  1.02343939e-01f, 7.43870661e-02f, 1.20922171e-01f, -2.88241543e-02f, -1.21610567e-01f, -1.31546357e-03f, 6.11113086e-02f, 6.63369521e-02f, -2.86404304e-02f, -6.01511188e-02f,
  1.19214885e-01f, 5.53240739e-02f, -2.26885483e-01f, 1.18592545e-01f, -8.64365548e-02f, 1.59697324e-01f, 1.62376780e-02f, -7.33199567e-02f, 1.08404472e-01f, -7.87800252e-02f,
  7.47783482e-02f, 9.52279009e-03f, 1.62179172e-01f, 8.76980498e-02f, 3.47435498e-03f, 1.34195164e-01f, 1.85581580e-01f, -1.64118052e-01f, 5.79218715e-02f, 2.06643194e-01f,
  1.58043340e-01f, -1.47484779e-01f, 1.09044477e-01f, -9.70610790e-03f, -8.69788751e-02f, 8.23063478e-02f, 7.71024823e-02f, 5.70030510e-02f, -9.49976742e-02f, 5.83642069e-03f,
  -4.72348034e-02f, -4.95912619e-02f, -2.19525769e-01f, -7.72141144e-02f, 6.85967738e-03f, 1.01663694e-01f, -1.17316544e-01f, 4.15656380e-02f, 7.92571232e-02f, 7.47458711e-02f,
  -8.93027931e-02f, 2.23393403e-02f, -1.44194171e-01f, 5.08147962e-02f, 1.70718983e-01f, 8.29724669e-02f, 3.55780125e-02f, 1.72525179e-02f, 2.10864857e-01f, 3.85267586e-02f,
  1.55877590e-01f, -2.93317400e-02f, -1.14631709e-02f, -7.48997405e-02f, 5.27633727e-03f, -2.54351124e-02f, -1.19625814e-01f, 1.07820176e-01f, 3.41090932e-02f, 2.24641040e-02f,
  9.87515971e-02f, 9.44262221e-02f, -6.29475042e-02f, -7.67508000e-02f, 1.39847562e-01f, -7.63531476e-02f, -7.81512409e-02f, 7.00113773e-02f, 7.66013935e-02f, -3.57109085e-02f,
  -4.68797013e-02f, 6.18741959e-02f, 1.61588669e-01f, 4.80563156e-02f, -1.24758095e-01f, 1.19865806e-04f, -2.00016275e-01f, 8.00210834e-02f, -1.14543796e-01f, -1.55725991e-02f,
  8.14819336e-02f, 9.49501395e-02f, -8.95412415e-02f, 1.11823501e-02f, 1.68192446e-01f, 2.73665935e-02f, -5.95164262e-02f, 9.64403152e-02f, 7.76448427e-03f, 8.78359005e-02f,
  1.02368623e-01f, -5.13807945e-02f, 6.36436045e-02f, 9.19637606e-02f, -7.14377388e-02f, -1.30749092e-01f, -1.27953365e-01f, -6.46739677e-02f, 2.63368338e-02f, 1.61149129e-01f,
  2.46163178e-02f, 2.12949794e-02f, -5.21827787e-02f, -9.22803432e-02f, 1.01610713e-01f, 1.39877170e-01f, -5.65787554e-02f, 1.12651952e-01f, 1.13870271e-01f, -8.77542272e-02f,
  -1.06386573e-03f, 2.05878355e-03f, 1.51569163e-03f, 9.67999920e-03f, 8.12713876e-02f, 1.44049600e-01f, 1.00458167e-01f, 1.38548119e-02f, -1.15163147e-01f, -1.06185384e-01f,
  8.92241374e-02f, 1.70377821e-01f, -1.58407725e-02f, 8.05936083e-02f, 6.98895454e-02f, 1.14410713e-01f, -1.11309908e-01f, 5.12970053e-02f, 1.34244457e-01f, -2.21441723e-02f,
  4.28990163e-02f, 9.80110839e-02f, -1.15826458e-01f, 7.97479004e-02f, -4.12397413e-03f, -6.13745749e-02f, 7.31377583e-03f, 1.61424757e-03f, -1.92947611e-02f, 6.76370934e-02f,
  -3.84324007e-02f, -4.62728785e-03f, 9.54459757e-02f, -6.03905469e-02f, 6.53060805e-03f, 1.16672352e-01f, 2.97475513e-02f, 9.11924709e-03f, 1.35453448e-01f, 6.24029487e-02f,
  -3.83217726e-03f, -4.37278822e-02f, 1.26708254e-01f, -1.44526005e-01f, -5.18406369e-02f, 1.32079935e-02f, -5.91141544e-02f, 1.36056423e-01f, -3.09822727e-02f, -1.12312317e-01f,
  5.97987808e-02f, -7.89542273e-02f, -8.99623781e-02f, 8.01479146e-02f, -1.07651660e-02f, 1.46429660e-02f, -2.18564756e-02f, -6.67337775e-02f, 1.61651552e-01f, -6.62924675e-03f,
  9.91923586e-02f, -9.66059491e-02f, 7.67007619e-02f, -4.86228950e-02f, -1.17613688e-01f, -5.44325821e-02f, -1.08365543e-01f, -9.50371474e-02f, 9.92200971e-02f, -5.45021854e-02f,
  7.65756762e-04f, -4.31231223e-02f, -6.48207366e-02f, 2.22345218e-02f, -1.18827492e-01f, 5.18550761e-02f, 8.64927936e-03f, -6.23675622e-02f, -3.87037583e-02f, 6.19730204e-02f,
  -8.45313519e-02f, 5.49071319e-02f, 1.11479528e-01f, -3.71905640e-02f, 1.27967581e-01f, 1.97301079e-02f, 1.22109301e-01f, -4.95969281e-02f, -2.19199955e-02f, 1.44960597e-01f,
  8.82713497e-02f, -3.80577818e-02f, -4.10364494e-02f, 1.75946823e-03f, 1.65215537e-01f, 1.23851381e-01f, 9.56929848e-02f, -2.24203672e-02f, 3.80756170e-03f, 1.76576719e-01f,
  1.68826893e-01f, -8.70216414e-02f, -1.15973637e-01f, 1.84942827e-01f, 3.50517780e-02f, 1.26919404e-01f, -6.73105940e-02f, 1.05522968e-01f, -8.96823332e-02f, -1.05104849e-01f,
  -6.08205274e-02f, -1.13223784e-01f, 6.53076768e-02f, 1.21884502e-01f, 4.12539542e-01f, 9.44342166e-02f, 2.10123956e-02f, 4.57140896e-03f, -6.02009743e-02f, 1.19202726e-01f,
  -1.02215642e-02f, -1.52321294e-01f, -9.48004574e-02f, 1.10834740e-01f, 2.18022883e-01f, -1.14707991e-01f, 6.49041161e-02f, 3.77749689e-02f, 6.10849857e-02f, -1.44477621e-01f,
  -9.18543786e-02f, -7.10613653e-02f, -6.57336786e-02f, 1.06061019e-01f, 1.02088325e-01f, 1.12141758e-01f, -1.84048191e-02f, 1.49045259e-01f, 9.45072174e-02f, 4.85404022e-02f,
  2.09374323e-01f, -1.20847873e-01f, 1.33232132e-01f, 9.52367187e-02f, -1.15053028e-01f, -6.32743835e-02f, -3.61891985e-02f, 1.68933943e-02f, 2.44525090e-01f, 2.05072500e-02f,
  1.03318550e-01f, -5.40274978e-02f, 3.49010527e-02f, -7.59617016e-02f, 5.21253981e-02f, -7.87427947e-02f, -1.88506711e-02f, 6.28144890e-02f, 1.73525080e-01f, 1.54086396e-01f,
  1.20994546e-01f, -2.23113317e-02f, 1.33710867e-02f, 4.80069630e-02f, -1.66679814e-01f, 1.56424105e-01f, -5.34687890e-03f, 2.05343589e-02f, 2.23725196e-02f, -2.21655462e-02f,
  -8.58911201e-02f, 2.54907329e-02f, -1.55483097e-01f, 8.34974274e-02f, 2.43412852e-02f, -5.31575903e-02f, 1.28960744e-01f, -1.30040556e-01f, 9.16721895e-02f, -6.85292110e-02f,
  1.21398039e-01f, 5.23994304e-02f, -5.68547957e-02f, -1.35763377e-01f, 1.96552873e-01f, -1.09708928e-01f, 2.18279511e-02f, 2.97243111e-02f, -2.94407420e-02f, 9.54698026e-02f,
  5.08404430e-03f, 7.78073072e-02f, -1.25331789e-01f, 1.72357727e-02f, 1.83220118e-01f, 1.00928992e-01f, -4.08973657e-02f, -5.90696931e-02f, 1.95746109e-01f, -2.36177519e-02f,
  1.06656082e-01f, 1.41645717e-02f, -3.25478762e-02f, -1.74670089e-02f, -5.83880991e-02f, 5.13640977e-02f, 1.85823426e-01f, 1.22355796e-01f, 9.68905836e-02f, 1.08899347e-01f,
  1.37987342e-02f, 2.99684368e-02f, -1.07666001e-01f, -2.14557890e-02f, 1.52567029e-01f, -9.34824571e-02f, -1.28055334e-01f, 1.68712214e-01f, 2.02309862e-01f, -5.89474943e-03f,
  -6.32390333e-03f, -3.95265482e-02f, 8.28433111e-02f, -1.25636151e-02f, 2.14678258e-01f, 2.17270479e-01f, 8.22879523e-02f, 5.95070480e-04f, 1.48052752e-01f, -9.44822654e-02f,
  8.31708685e-02f, -9.14838463e-02f, 3.09966458e-03f, 9.67010111e-02f, 1.64288059e-01f, -3.37559544e-02f, 5.54290228e-03f, -5.86062623e-03f, 1.39741180e-02f, 3.48558016e-02f,
  9.57018882e-02f, -5.11283614e-02f, -3.44754383e-02f, 1.74945090e-02f, -5.09678163e-02f, 9.37330425e-02f, -2.48069745e-02f, -5.55410236e-02f, -1.31508959e-02f, -7.18325609e-04f,
  1.48248926e-01f, 7.26119354e-02f, -1.38530647e-02f, -2.92765312e-02f, 1.37358904e-01f, 2.40452755e-02f, -6.80632442e-02f, -6.88945428e-02f, 1.02136843e-01f, -8.37311894e-02f,
  -6.41975319e-03f, 8.68519545e-02f, -4.47194874e-02f, 2.93868650e-02f, -8.00831690e-02f, -1.88885182e-02f, -1.21521659e-01f, 7.41991997e-02f, 2.74494290e-02f, -2.63963770e-02f,
  -1.11929715e-01f, 1.13638699e-01f, 4.97604646e-02f, -3.12134274e-03f, 6.23906218e-02f, 6.82245046e-02f, 1.93121843e-02f, 1.76976815e-01f, 3.43890823e-02f, -1.14352454e-03f,
  2.99530178e-02f, 7.38569722e-02f, 1.79369643e-01f, 3.44607010e-02f, 6.74175546e-02f, 9.94375944e-02f, 2.13959485e-01f, 7.36205056e-02f, -5.81400804e-02f, 8.97243768e-02f,
  6.69932142e-02f, -2.23962404e-02f, -9.45838392e-02f, -6.16970174e-02f, 5.40395752e-02f, 8.37391317e-02f, 6.27860352e-02f, -7.42400214e-02f, -1.26231052e-02f, -1.35815606e-01f,
  -1.21773504e-01f, -1.53908217e-02f, -9.80255893e-04f, -3.41402590e-02f, -9.06408504e-02f, 1.33826494e-01f, 3.11210781e-01f, 7.66332671e-02f, 2.74370819e-01f, 9.22055468e-02f,
  -7.62831196e-02f, -2.67729652e-03f, 2.33357593e-01f, -2.95443237e-02f, 7.49222487e-02f, -1.87935159e-01f, 1.49750099e-01f, 6.77108020e-02f, 4.16066963e-03f, 2.14534737e-02f,
  1.11594759e-01f, -1.80388633e-02f, 8.24323818e-02f, 2.43476108e-02f, 1.02037303e-01f, 8.80171210e-02f, 2.06521824e-01f, 3.03362515e-02f, 5.41496314e-02f, 1.00247048e-01f,
  1.25396699e-01f, -1.10702135e-01f, -3.75818973e-03f, 4.12378907e-02f, 2.31192306e-01f, -8.50443989e-02f, 9.94951651e-02f, -4.68234755e-02f, -5.82733862e-02f, -2.82270517e-02f,
  -2.37491783e-02f, -9.03897509e-02f, -3.94784249e-02f, 2.27535293e-02f, -1.92356557e-02f, 2.76476424e-02f, 8.57233480e-02f, -8.58781263e-02f, 4.11901885e-04f, 1.20367501e-02f,
  3.01044546e-02f, -6.62225038e-02f, 1.05778640e-02f, 1.92022875e-01f, 1.39096066e-01f, 7.08885565e-02f, 2.37316675e-02f, 4.91006039e-02f, 1.69753805e-01f, -1.40626937e-01f,
  5.80349900e-02f, 7.35502839e-02f, -1.02730550e-01f, -6.42769709e-02f, -1.12302341e-02f, -1.81606431e-02f, -5.67853861e-02f, -7.87389092e-03f, 1.59776554e-01f, 1.05204128e-01f,
  -1.34390891e-01f, -8.73973444e-02f, 1.18258305e-01f, 5.44239916e-02f, -7.73241520e-02f, 1.00044824e-01f, -9.90222543e-02f, 6.79664686e-02f, 1.17828930e-02f, 1.39354065e-03f,
  4.89622168e-02f, 1.74120236e-02f, 1.20211929e-01f, -6.29409254e-02f, 2.01865658e-02f, 2.26743184e-02f, 1.92094073e-01f, -4.31878902e-02f, 8.33944082e-02f, 1.48883581e-01f,
  1.74331982e-02f, -8.51120055e-02f, 8.95286575e-02f, -1.65130999e-02f, 3.50165851e-02f, 1.04501754e-01f, -3.36445011e-02f, 4.40788344e-02f, 2.59439386e-02f, 1.05011076e-01f,
  5.00858501e-02f, 1.02569997e-01f, 1.31391674e-01f, -1.27548710e-01f, -7.64943585e-02f, 1.11203946e-01f, 1.16252832e-01f, -1.22128576e-01f, -1.05861485e-01f, -3.28896679e-02f,
  1.48158595e-02f, 8.86823423e-03f, -1.15565518e-02f, 1.11842953e-01f, -2.47007962e-02f, -9.21679214e-02f, 2.04682667e-02f, 1.93144586e-02f, -2.25979020e-03f, 1.29773617e-01f,
  -8.27324018e-02f, -1.65918916e-01f, -1.13603190e-01f, -2.25704070e-02f, -1.64794661e-02f, 1.72728553e-01f, 1.42035216e-01f, 2.57221788e-01f, 8.87043700e-02f, 1.00936681e-01f,
  -9.31106731e-02f, 4.80251806e-03f, -3.83577170e-03f, -1.08314946e-01f, 1.17825218e-01f, 5.53017594e-02f, -2.11136445e-01f, 4.02746871e-02f, 1.45816766e-02f, 8.64751488e-02f,
  -1.36686206e-01f, 5.46877179e-03f, -5.49914734e-03f, 2.05735445e-01f, -4.21264768e-02f, 7.73190930e-02f, 9.41635892e-02f, 2.55634431e-02f, -7.71132410e-02f, -4.42024022e-02f,
  -9.68719348e-02f, 4.87520359e-02f, 6.14501275e-02f, -2.08160765e-02f, -1.63530216e-01f, 1.42783627e-01f, -1.24195091e-01f, 4.38331328e-02f, -1.14290239e-02f, -2.55029649e-02f,
  9.04279575e-02f, -1.13405101e-01f, -8.49783644e-02f, -8.47464576e-02f, 1.12622745e-01f, -1.04987308e-01f, -1.29281417e-01f, -5.21427207e-02f, 2.07792476e-01f, 3.14746261e-01f,
  -1.21634267e-01f, -3.35592218e-02f, 7.81262442e-02f, 1.40674040e-01f, -3.30875181e-02f, -8.27393681e-02f, 3.59463841e-02f, 1.83469996e-01f, 7.33712390e-02f, 3.13155651e-01f,
  3.13601762e-01f, 1.86579436e-01f, 3.47082317e-01f, 9.54336226e-02f, 1.02047235e-01f, 1.40770033e-01f, 2.29922205e-01f, -1.28687277e-01f, -1.42558783e-01f, 2.58333087e-01f,
  1.78382516e-01f, -6.08293079e-02f, -1.21199578e-01f, -8.46969895e-03f, 1.24504119e-01f, -5.75455762e-02f, 9.64211375e-02f, -1.42360076e-01f, -7.51929358e-02f, 7.96493739e-02f,
  2.50705540e-01f, -1.14898495e-01f, -5.89682236e-02f, 3.78533825e-02f, 9.72846672e-02f, -9.55821127e-02f, 9.33633000e-02f, -1.40135467e-01f, 1.74558416e-01f, 9.21479543e-04f,
  2.04817310e-01f, -1.33745164e-01f, -1.13613322e-01f, -7.41208792e-02f, 2.13833213e-01f, -1.21062562e-01f, 9.91432294e-02f, 2.10303646e-02f, 2.79817253e-01f, 7.82736838e-02f,
  -1.35807604e-01f, -5.10137044e-02f, 1.40191074e-02f, -1.48070212e-02f, -6.92266598e-02f, 3.37306075e-02f, 5.63354567e-02f, 3.70583944e-02f, -3.54215764e-02f, 2.65011400e-01f,
  6.76127076e-02f, -2.01076809e-02f, 1.66431054e-01f, -8.48228484e-02f, -7.55053759e-02f, 1.46595733e-02f, -9.47215259e-02f, 1.41691327e-01f, 3.02002013e-01f, -3.61081660e-02f,
  1.97994784e-01f, 1.34722024e-01f, 6.67586848e-02f, 3.15419108e-01f, 2.76977539e-01f, 2.21878365e-01f, 1.24422006e-01f, 1.33292615e-01f, 2.84083694e-01f, -7.13449791e-02f,
  1.86111741e-02f, 1.40518144e-01f, 5.51042445e-02f, 2.61768937e-01f, 2.77570724e-01f, -3.84632647e-02f, 2.15665456e-02f, -1.56029731e-01f, -1.06969893e-01f, 1.54467523e-01f,
  -2.47817636e-02f, -6.49404973e-02f, 8.63111243e-02f, 4.27788161e-02f, 1.14394605e-01f, -1.17887832e-01f, -1.59683272e-01f, 1.98502038e-02f, -1.23952933e-01f, -1.46060273e-01f,
  1.20869070e-01f, -2.63440371e-01f, 2.01048747e-01f, 1.64575219e-01f, 1.68788791e-01f, -1.13432080e-01f, -8.56684893e-02f, -8.03970620e-02f, -1.60453245e-01f, 9.64526683e-02f,
  -1.12031765e-01f, 2.02102941e-02f, -1.39607219e-02f, -3.33337486e-02f, -8.62998590e-02f, 1.02346027e-02f, -6.06576540e-02f, -1.75615653e-01f, -3.86232249e-02f, -1.48106933e-01f,
  -4.03109714e-02f, -1.25215933e-01f, 8.61032754e-02f, 2.61578739e-01f, -2.87912581e-02f, -4.52190787e-02f, 3.08588654e-01f, 2.99813855e-03f, 9.21197906e-02f, -7.00092539e-02f,
  3.74039523e-02f, 7.49398023e-03f, 7.79911429e-02f, -8.59206170e-02f, -1.02752775e-01f, -7.78894424e-02f, -8.26605633e-02f, 1.61154363e-02f, -9.43890885e-02f, -7.35492185e-02f,
  -1.35693058e-01f, 7.42593631e-02f, 3.21410596e-02f, 4.68446724e-02f, 1.05463721e-01f, -9.21763405e-02f, -1.13623701e-01f, 1.03598433e-02f, 1.04782484e-01f, -6.60997927e-02f,
  -2.95905527e-02f, -1.25270545e-01f, 6.05564229e-02f, 8.61246660e-02f, -5.75985871e-02f, 8.16719532e-02f, -2.46105436e-02f, -3.17450352e-02f, 7.71420076e-02f, 4.08392325e-02f,
  5.08568808e-02f, 5.28557487e-02f, -5.22556789e-02f, 1.14584655e-01f, -1.26549706e-01f, 3.89569346e-03f, 4.89336923e-02f, 1.18089221e-01f, -7.63749033e-02f, 4.39515822e-02f,
  -1.84990279e-02f, -1.22957062e-02f, 4.79233041e-02f, 6.38298020e-02f, 6.82235435e-02f, -5.41927433e-03f, 6.82827979e-02f, 9.23243091e-02f, -6.49172887e-02f, -2.40215715e-02f,
  -4.10159025e-03f, 4.84584644e-02f, -1.24515086e-01f, 9.80072394e-02f, 6.32037297e-02f, -5.03880605e-02f, -4.58182162e-03f, -1.25031337e-01f, 3.81370895e-02f, 1.24009727e-02f,
  1.10169105e-01f, 1.94923172e-03f, -2.29287948e-02f, 9.31586102e-02f, -3.40645686e-02f, -1.76525079e-02f, 1.92913581e-02f, -9.40754116e-02f, 1.72948334e-02f, -8.46728086e-02f,
  -7.58578777e-02f, 1.80555835e-01f, -7.71073699e-02f, -3.83712836e-02f, 1.41503051e-01f, 3.79391573e-02f, 8.20427090e-02f, 1.85869180e-03f, -9.40676406e-02f, 2.93815862e-02f,
  -9.66883451e-02f, -4.94571822e-03f, 1.64674193e-01f, -2.36934628e-02f, -8.19172934e-02f, -1.03058361e-01f, 5.40012270e-02f, 8.43728557e-02f, -3.13505381e-02f, 7.10505014e-03f,
  1.45618141e-01f, 7.46758431e-02f, -3.00822090e-02f, -1.42542943e-01f, 2.26486344e-02f, 5.99895045e-02f, 1.27100408e-01f, -1.30180582e-01f, -9.22164507e-03f, -1.45507351e-01f,
  9.25992578e-02f, -3.60776335e-02f, -1.05782576e-01f, -3.73187363e-02f, -9.62842777e-02f, -7.16875643e-02f, 3.68462503e-02f, 6.73273727e-02f, 2.96665933e-02f, 4.22062501e-02f,
  1.64661571e-01f, -2.33176630e-02f, -9.11812186e-02f, -6.38290197e-02f, -1.14343964e-01f, -5.06823398e-02f, 1.56646483e-02f, 4.03199233e-02f, -6.00954443e-02f, 9.69259813e-02f,
  -3.47058438e-02f, 3.64464074e-02f, -9.46134850e-02f, -3.43038305e-03f, 1.70983985e-01f, -2.51455996e-02f, 2.02410705e-02f, 9.27714780e-02f, -1.03486381e-01f, 1.64448861e-02f,
  1.62820742e-02f, -7.43829459e-02f, 2.19418108e-01f, 2.07351089e-01f, 5.07488735e-02f, 1.89079210e-01f, 2.91353706e-02f, 3.43359001e-02f, -1.60764098e-01f, 1.02071486e-01f,
  -9.32588652e-02f, 9.01014581e-02f, 1.61080360e-01f, -5.86019456e-03f, 3.93548273e-02f, 3.17463502e-02f, -2.10676473e-02f, 7.77482940e-03f, -4.37800251e-02f, 1.56918675e-01f,
  -4.80251387e-02f, 5.74126020e-02f, 2.29992159e-02f, 1.79547928e-02f, -1.04907475e-01f, 5.95264472e-02f, -5.35064610e-04f, -7.36460537e-02f, -2.15892661e-02f, -1.08770244e-01f,
  -1.33263648e-01f, 1.25458419e-01f, 7.30491010e-03f, -7.23039508e-02f, -2.53175702e-02f, 5.01369759e-02f, 2.77894557e-01f, -1.29085094e-01f, -2.16710707e-03f, 4.27040830e-02f,
  5.89742139e-02f, 1.02129243e-01f, 1.22652978e-01f, 1.80378988e-01f, 1.45173386e-01f, -1.41274199e-01f, -1.57439649e-01f, -1.42139435e-01f, -1.14499994e-01f, 1.67306303e-03f,
  1.96958818e-02f, 1.36700412e-03f, -6.02692328e-02f, 6.72300830e-02f, -5.59755489e-02f, 1.48583010e-01f, 8.39910656e-03f, -8.75059292e-02f, -8.24013427e-02f, 3.32404435e-01f,
  1.87389627e-02f, 6.28953204e-02f, -4.56346944e-02f, -4.01959978e-02f, 3.69059108e-02f, -7.89034739e-02f, 1.27758130e-01f, -8.63956884e-02f, 1.07474245e-01f, 1.59546912e-01f,
  -8.33907351e-03f, -5.14025129e-02f, -8.66108760e-02f, 5.36070392e-02f, 9.96401682e-02f, -1.15749426e-01f, 7.59731559e-03f, -1.46991268e-01f, 6.95316792e-02f, 9.46175978e-02f,
  -5.60405292e-02f, 1.31596595e-01f, 1.74340606e-02f, 1.03240110e-01f, -3.75685468e-02f, 3.29664685e-02f, 6.76591247e-02f, -6.13380224e-02f, 5.09017408e-02f, 5.12618236e-02f,
  -3.47339585e-02f, 4.16272841e-02f, 2.89071351e-02f, -6.04200512e-02f, -5.04400618e-02f, -1.06175296e-01f, 1.19980276e-02f, 9.58201289e-02f, 9.45253223e-02f, 2.04654813e-01f,
  2.20614284e-01f, -6.47170618e-02f, -2.71035545e-02f, -2.26651970e-02f, -3.23857777e-02f, -2.76762843e-02f, 8.39762017e-02f, -1.10162824e-01f, -1.83538422e-01f, 3.34886685e-02f,
  -1.26080170e-01f, -6.10270798e-02f, -1.10191859e-01f, -9.80506986e-02f, 1.53188393e-01f, -2.15294566e-02f, -1.60499573e-01f, -9.12819728e-02f, 1.00293428e-01f, 8.09470599e-04f,
  -2.79035675e-03f, -1.02323912e-01f, 2.76052337e-02f, 2.87407994e-01f, 6.20530359e-03f, -6.13148101e-02f, 1.81987267e-02f, 1.60776705e-01f, -4.98790406e-02f, -4.91139516e-02f,
  2.39165202e-01f, 1.35071099e-01f, 1.97422475e-01f, 1.39222428e-01f, 2.01116204e-02f, 2.16217205e-01f, -2.06238940e-01f, -1.57139972e-02f, -7.11481348e-02f, -1.09649152e-01f,
  2.14341149e-01f, -1.66619137e-01f, 4.20215018e-02f, -1.62377395e-02f, -7.09992722e-02f, -1.63225144e-01f, 1.25968587e-02f, 1.56343326e-01f, -1.11646667e-01f, 8.89403149e-02f,
  1.43632874e-01f, -6.21601455e-02f, 2.07998026e-02f, 6.63277805e-02f, 4.63981964e-02f, 5.36150634e-02f, -1.25927836e-01f, 1.06062457e-01f, -8.95926207e-02f, 1.26431793e-01f,
  1.07827581e-01f, 1.29254669e-01f, 7.78646488e-03f, 5.70099987e-02f, 1.45690635e-01f, -1.67031325e-02f, -3.01312953e-02f, -9.85390693e-02f, 1.40724285e-02f, -1.50601208e-01f,
  -1.06475577e-01f, -6.68464005e-02f, 1.09810241e-01f, -2.77217268e-03f, 1.04566082e-01f, 9.59870815e-02f, 8.60524625e-02f, 8.99196863e-02f, 4.20542881e-02f, -7.55567625e-02f,
  -5.19232601e-02f, 2.13215631e-02f, 5.83278500e-02f, -1.63689092e-01f, 9.09934714e-02f, -5.00269467e-03f, -2.97607705e-02f, 1.19059645e-01f, -5.68684265e-02f, 1.16099216e-01f,
  -3.80541687e-03f, -5.55372201e-02f, 2.01208889e-01f, -1.16230614e-01f, 2.81151701e-02f, 9.36372280e-02f, 1.89861268e-01f, 1.58289641e-01f, 8.45269635e-02f, 1.60504684e-01f,
  8.72019678e-02f, -1.44475335e-02f, 1.11139610e-01f, -4.62082960e-02f, -8.02728683e-02f, 1.10198826e-01f, -1.09358110e-01f, 4.35655937e-02f, -2.79304646e-02f, 1.42531451e-02f,
  -4.19220701e-02f, -1.28037676e-01f, -5.62076718e-02f, -1.46073952e-01f, -8.38937759e-02f, -3.12424842e-02f, 1.94679216e-01f, -4.90791090e-02f, 3.01005036e-01f, 8.13937262e-02f,
  8.10300186e-02f, -6.82900399e-02f, 2.72481143e-01f, -6.52176887e-02f, 1.16725199e-01f, -1.63024738e-01f, -4.42015305e-02f, -1.50588721e-01f, 8.94623101e-02f, -6.21973723e-03f,
  -5.00728488e-02f, -6.48045987e-02f, 2.50495076e-01f, -1.12731149e-02f, -4.77619842e-02f, 5.49662150e-02f, 1.82385623e-01f, -1.42487630e-01f, 1.09753318e-01f, 1.58137888e-01f,
  1.18331760e-01f, 1.37136906e-01f, 6.49400949e-02f, 6.05463162e-02f, 1.86720997e-01f, 1.53610691e-01f, 7.17775896e-02f, 6.45736530e-02f, 4.54209857e-02f, -7.40121007e-02f,
  -5.28156015e-05f, -2.53485292e-01f, 1.20681398e-01f, 9.40005668e-03f, -1.12028293e-01f, 1.00669272e-01f, 2.56366014e-01f, -5.57962433e-02f, 1.00872673e-01f, 1.69788435e-01f,
  1.46087140e-01f, 2.52205700e-01f, 2.11766332e-01f, 7.67887458e-02f, -6.91963534e-04f, -1.52645633e-01f, -1.93040609e-01f, 1.40402496e-01f, 2.32665449e-01f, -1.24033861e-01f,
  -7.10687935e-02f, -1.33967310e-01f, -1.64088402e-02f, -1.84797481e-01f, -6.35762513e-02f, 1.86368108e-01f, -8.60542282e-02f, -6.18405603e-02f, 4.38836142e-02f, 5.05233109e-02f,
  -4.64615300e-02f, 7.67297903e-03f, 8.92356932e-02f, -4.69291657e-02f, 7.44384155e-02f, 9.37218666e-02f, 1.80804450e-02f, 4.10711057e-02f, 1.27348024e-02f, 4.89595644e-02f,
  -2.49383636e-02f, -1.12943649e-01f, 2.20428035e-01f, -1.27183867e-03f, -1.20802306e-01f, 5.98702729e-02f, 2.86013514e-01f, 1.99368112e-02f, -1.38688982e-01f, -1.05514005e-01f,
  2.27609873e-01f, 7.91682154e-02f, -7.22327530e-02f, -8.57853219e-02f, -1.04033835e-01f, 8.05721432e-02f, -4.68647629e-02f, -1.27560332e-01f, 1.03682332e-01f, 5.77450581e-02f,
  9.82398391e-02f, -2.37836353e-02f, -9.82893258e-02f, 1.25224039e-01f, -4.67363484e-02f, 8.40706006e-02f, 3.74995992e-02f, -2.18142606e-02f, -1.53925717e-02f, 1.16307043e-01f,
  1.02624871e-01f, -6.26396313e-02f, 7.98215270e-02f, -5.18956743e-02f, -8.82570967e-02f, -6.90270811e-02f, -1.15178607e-03f, -8.07545260e-02f, 9.55550149e-02f, -9.50742364e-02f,
  -3.42502980e-03f, 3.19580622e-02f, 2.65836511e-02f, -3.56041342e-02f, 3.40953879e-02f, -4.28553252e-03f, 3.82298641e-02f, 9.60087851e-02f, -5.84855564e-02f, -2.24463362e-02f,
  -6.60465052e-03f, -4.59693745e-02f, 5.52913956e-02f, 7.91269168e-02f, -1.08015627e-01f, -6.66244477e-02f, 8.13531280e-02f, 1.07657887e-01f, -4.64619957e-02f, -1.24839343e-01f,
  1.25056103e-01f, -3.71031836e-02f, -1.07085861e-01f, -1.16504364e-01f, -7.01298416e-02f, 6.99315518e-02f, 6.72222599e-02f, -9.59328860e-02f, -3.11304219e-02f, -8.74783918e-02f,
  1.52590871e-01f, -3.62354331e-03f, -2.90545654e-02f, -3.76147516e-02f, 8.39209780e-02f, 1.15567066e-01f, -3.64856981e-02f, 1.36082813e-01f, 6.85260072e-02f, -9.15361717e-02f,
  4.13643792e-02f, 4.56849448e-02f, 2.21984256e-02f, -4.73034792e-02f, 2.66349223e-02f, 7.09855929e-02f, 1.33290235e-02f, 2.93289181e-02f, 2.52256189e-02f, 4.73345816e-03f,
  -1.22514307e-01f, -2.37255488e-02f, 1.18599012e-01f, -8.34847838e-02f, 3.61827128e-02f, 1.10847279e-01f, 3.45463562e-03f, 1.07609376e-01f, 1.00452676e-01f, 8.17239434e-02f,
  -4.04090770e-02f, 1.17703527e-01f, 3.18162113e-01f, -6.94353282e-02f, -1.23133520e-02f, 1.28859030e-02f, 8.26310888e-02f, -7.74930194e-02f, -1.03328429e-01f, 1.85989499e-01f,
  4.14047688e-02f, -3.55866924e-02f, -1.10972144e-01f, -6.29975135e-03f, 1.26537502e-01f, -4.17786613e-02f, -6.72206357e-02f, -2.73727365e-02f, 2.49163359e-02f, -8.72078240e-02f,
  2.84262747e-01f, 5.48249185e-02f, -5.40366676e-03f, 9.94043648e-02f, 1.86176404e-01f, -6.99863881e-02f, -1.27616644e-01f, -1.14248656e-01f, 9.11031738e-02f, 3.42860958e-03f,
  7.25922808e-02f, 1.93294864e-02f, -2.49942075e-02f, 5.09323999e-02f, 1.59596890e-01f, 1.21535463e-02f, 1.77948639e-01f, 1.38518885e-01f, 1.19858988e-01f, -8.52319449e-02f,
  1.41268224e-01f, 3.90231349e-02f, -5.75619601e-02f, 8.30348656e-02f, -4.96111214e-02f, 1.92521468e-01f, 9.71005782e-02f, -1.21665291e-01f, 3.80392782e-02f, 6.97578937e-02f,
  1.73620105e-01f, -2.73109358e-02f, -1.78884909e-01f, -1.69667661e-01f, 1.25504330e-01f, -1.48366868e-01f, 3.72166708e-02f, -1.64787415e-02f, 2.02988252e-01f, 5.54820523e-02f,
  -7.55467732e-03f, 1.61007315e-01f, 1.76278353e-01f, 7.00551495e-02f, 1.20776623e-01f, 1.27249911e-01f, 1.44267157e-01f, 6.74669296e-02f, 6.65320083e-02f, 6.36948571e-02f,
  6.34030551e-02f, -2.00058855e-02f, 7.24041685e-02f, 1.50122553e-01f, 5.18770553e-02f, -1.21411812e-02f, -1.07245229e-01f, -1.27638847e-01f, -7.86705390e-02f, 1.09505475e-01f,
  6.32897541e-02f, -8.67063701e-02f, -2.39879161e-01f, -9.14862007e-02f, 4.99212241e-04f, -4.22434509e-02f, 6.37146272e-03f, -1.10694431e-01f, 6.97678030e-02f, 1.11951241e-02f,
  1.70477797e-05f, 9.58404839e-02f, -3.75326611e-02f, 1.79890037e-01f, 1.64049387e-01f, -1.27261281e-01f, 9.60266888e-02f, -2.65873484e-02f, 1.00920992e-02f, -6.81072026e-02f,
  1.32725716e-01f, -6.17890395e-02f, 4.97460105e-02f, 8.47753510e-02f, 6.52069598e-02f, -9.68515500e-02f, 2.33967118e-02f, 1.12602845e-01f, -7.83363208e-02f, -6.64911866e-02f,
  -4.08790037e-02f, -1.29505917e-01f, 8.05049762e-03f, 2.10064068e-01f, -7.46211857e-02f, 3.74718420e-02f, 9.07348320e-02f, 2.20045492e-01f, 5.28600924e-02f, -1.81837514e-01f,
  1.07291870e-01f, 7.69561455e-02f, -2.15836409e-02f, -5.91744669e-02f, 5.30139543e-02f, 2.15970069e-01f, 2.90299684e-01f, 9.17646568e-03f, 2.00007707e-01f, 1.45596430e-01f,
  -1.76500648e-01f, 6.85433159e-03f, 5.62762693e-02f, -1.63562268e-01f, 1.33964866e-01f, -1.82343442e-02f, -1.14298865e-01f, -9.45926607e-02f, -5.73102832e-02f, -2.35649884e-01f,
  -1.78418949e-01f, 1.12132229e-01f, 8.56846869e-02f, 6.44149706e-02f, -6.74933866e-02f, 8.92271325e-02f, 1.79509204e-02f, 2.92255431e-02f, 1.32910877e-01f, -5.28894030e-02f,
  -4.26448658e-02f, -1.11687742e-01f, -4.26009111e-02f, -8.67155269e-02f, 2.33738199e-01f, -7.18080103e-02f, 8.39350745e-02f, 1.55430213e-01f, 2.88114339e-01f, 2.98581850e-02f,
  6.08308315e-02f, 5.39315268e-02f, 8.10583383e-02f, 3.32921483e-02f, -1.16773114e-01f, 2.20233072e-02f, -9.31341946e-03f, -3.98852816e-03f, -1.33054465e-01f, 1.46205693e-01f,
  3.50499002e-04f, 3.03606223e-02f, 2.38304306e-02f, 1.14344805e-02f, 6.47242814e-02f, 9.01167467e-02f, 2.73911674e-02f, -1.58590913e-01f, 1.02587163e-01f, -8.30481052e-02f,
  1.97732806e-01f, 5.83296118e-04f, 4.54296023e-02f, -8.86093974e-02f, 8.20802301e-02f, 1.77614823e-01f, 1.74313515e-01f, -1.71980724e-01f, -7.71234483e-02f, -9.74446088e-02f,
  -1.61057822e-02f, 1.19398616e-03f, -8.54076296e-02f, 5.16269505e-02f, 1.25629157e-02f, -1.10283948e-01f, -1.03413783e-01f, -5.01217172e-02f, -6.20785914e-02f, -4.59116139e-02f,
  -6.34726956e-02f, -5.04072420e-02f, 4.42962982e-02f, 9.74683929e-03f, -3.09638530e-02f, 7.01354817e-02f, 9.39285383e-02f, 1.19169869e-01f, -9.15259495e-02f, -6.65282980e-02f,
  -9.64497626e-02f, -1.06392190e-01f, 2.62390152e-02f, -3.67242768e-02f, 9.60443318e-02f, 5.44583201e-02f, 9.28186327e-02f, -2.37094276e-02f, 4.81492952e-02f, -5.27095457e-04f,
  -9.14502963e-02f, -9.64712352e-02f, 8.87529477e-02f, 1.02213144e-01f, -1.19244084e-01f, 7.45144188e-02f, 7.12325349e-02f, 1.18295841e-01f, -3.35132219e-02f, 3.23680788e-02f,
  -7.23262653e-02f, -9.06650424e-02f, 1.46798924e-01f, 3.93482856e-02f, -1.12200290e-01f, 1.06104344e-01f, 6.67987913e-02f, -1.78649761e-02f, 9.10765603e-02f, -5.40904468e-03f,
  1.73681360e-02f, 9.07781273e-02f, 2.40811482e-02f, -1.10837057e-01f, -7.99146388e-03f, 6.65245056e-02f, -7.96492249e-02f, 4.91495803e-02f, 6.36087731e-02f, -5.49079180e-02f,
  -8.86213705e-02f, 7.98649620e-03f, 2.68496946e-02f, -9.70793217e-02f, -1.58000514e-01f, 6.04617335e-02f, -1.40843764e-01f, 4.16046344e-02f, -1.87361270e-01f, -7.47607183e-03f,
  -1.03885852e-01f, 4.90821712e-02f, 7.86131695e-02f, -1.25979796e-01f, -2.90905125e-02f, -4.54983255e-03f, 1.54130116e-01f, 1.71699420e-01f, 3.54622826e-02f, 8.56032223e-02f,
  2.85128299e-02f, 1.31056026e-01f, 4.63135988e-02f, 3.90168428e-02f, 7.15997517e-02f, 7.35695660e-02f, -1.66347757e-01f, -4.15375689e-04f, -4.25311513e-02f, 5.06527685e-02f,
  7.38262832e-02f, -1.22693434e-01f, -3.41964909e-03f, -1.41942687e-02f, 1.19883463e-01f, -6.27950504e-02f, 1.47655308e-02f, 1.17422350e-01f, 1.96477305e-02f, -1.31928781e-02f,
  -2.67542731e-02f, -3.71400663e-03f, -3.68881226e-02f, 9.71420258e-02f, 1.35447094e-02f, 1.00446336e-01f, -5.29457144e-02f, 2.72209346e-02f, 2.24459954e-02f, 1.28649622e-01f,
  4.08225730e-02f, -7.23271305e-03f, -1.05493190e-02f, -5.90164140e-02f, -5.48063889e-02f, 8.68956670e-02f, 1.43028912e-03f, -1.01636767e-01f, 5.28360680e-02f, 1.28435865e-01f,
  -7.02062026e-02f, 7.95753524e-02f, 2.59608980e-02f, -6.93450272e-02f, 6.33182079e-02f, 2.78698318e-02f, 4.98337951e-03f, -6.48597032e-02f, 4.12245095e-02f, -4.30498496e-02f,
  6.81658555e-03f, -7.49003664e-02f, 3.41973379e-02f, -6.87503293e-02f, -2.83682626e-03f, -4.13318314e-02f, -1.73271403e-01f, 3.19683813e-02f, 1.44716138e-02f, -2.72370912e-02f,
  2.84248255e-02f, 2.16970574e-02f, 4.89009470e-02f, -7.69522563e-02f, -1.38257060e-03f, 6.59187734e-02f, 5.11405207e-02f, -6.63892105e-02f, 2.21164286e-01f, -1.41163878e-02f,
  -4.95606102e-02f, 4.47499529e-02f, -1.18025593e-01f, -6.98667094e-02f, 1.92639381e-01f, -6.78568110e-02f, -1.03885867e-01f, -1.19939104e-01f, -2.49992386e-02f, -1.13226548e-02f,
  1.49530238e-02f, -2.29814630e-02f, 2.11050231e-02f, 7.52705336e-02f, 1.27947971e-01f, -1.14466853e-01f, -2.44857855e-02f, -8.28823298e-02f, 1.75576642e-01f, -5.73194623e-02f,
  5.73571920e-02f, 7.47510493e-02f, -1.25186533e-01f, -8.12417269e-02f, 3.06069441e-02f, -1.24197183e-02f, -3.06220092e-02f, -3.18536498e-02f, -8.24071467e-02f, -6.76203519e-02f,
  4.15756851e-02f, 4.93107885e-02f, -5.16968481e-02f, -8.47185552e-02f, 9.43564326e-02f, -5.23016229e-02f, 4.34813984e-02f, 6.10910840e-02f, -9.55806952e-03f, -2.83606630e-02f,
  -2.82811690e-02f, 1.23947434e-01f, 1.28454939e-01f, 8.48025903e-02f, -6.56543970e-02f, -1.06370814e-01f, 7.08994567e-02f, 5.95207065e-02f, -3.29739824e-02f, -4.47109118e-02f,
  -5.43708131e-02f, -1.11052044e-01f, 8.83793272e-03f, -9.24091414e-02f, -6.51273280e-02f, -7.45280609e-02f, -6.29018024e-02f, -1.02680162e-01f, 1.02698676e-01f, 1.28609119e-02f,
  -9.50837955e-02f, -7.39140809e-02f, -1.34764582e-01f, 1.16297588e-01f, -8.18428546e-02f, -1.46500552e-02f, 9.80324596e-02f, -1.10815883e-01f, -9.86910537e-02f, 5.46748973e-02f,
  6.55930042e-02f, -9.18753669e-02f, 3.09896506e-02f, 4.77153063e-03f, -4.14518155e-02f, 1.12639524e-01f, -3.27969491e-02f, -1.01449564e-01f, 1.34534970e-01f, 1.19693048e-01f,
  2.79576685e-02f, 1.91108976e-02f, -9.32635367e-02f, 9.32882540e-03f, 3.22095864e-02f, 1.12060815e-01f, 5.51197119e-02f, -7.57773966e-02f, 1.20308287e-02f, -1.16506115e-01f,
  -1.22897111e-01f, -1.12704679e-01f, 1.76391769e-02f, 1.35370763e-02f, -6.27549319e-03f, 1.07750252e-01f, 9.61642191e-02f, -3.21262069e-02f, 3.70040610e-02f, 5.49767427e-02f,
  9.61408913e-02f, -6.84416154e-03f, -9.36408862e-02f, -5.56929521e-02f, 8.27282369e-02f, 7.40735903e-02f, 9.25034061e-02f, 1.55943409e-01f, 7.39159957e-02f, -8.14632624e-02f,
  4.15402316e-02f, -9.87014547e-02f, 6.72746226e-02f, 2.31743604e-02f, 1.76816747e-01f, 4.79770787e-02f, 4.77949381e-02f, 9.10291001e-02f, 6.37285337e-02f, -5.57506867e-02f,
  4.79200017e-03f, 1.24931663e-01f, -1.22282952e-02f, -5.76743521e-02f, -9.19914991e-02f, -8.90601203e-02f, -3.77308615e-02f, -1.00700267e-01f, 1.87677234e-01f, 4.59910333e-02f,
  2.78858505e-02f, -8.00556839e-02f, 5.60909286e-02f, 1.29243195e-01f, -7.78341144e-02f, -9.78789553e-02f, -3.66239510e-02f, -3.41935735e-03f, 2.64235772e-03f, 1.03722759e-01f,
  1.03231572e-01f, 1.19696483e-01f, 1.01622157e-01f, -5.62443398e-02f, -5.22242486e-02f, -1.55696245e-02f, 2.57502645e-02f, 5.39090969e-02f, -5.96875101e-02f, 1.31056249e-01f,
  1.03256457e-01f, 3.73004414e-02f, -3.37070762e-03f, 8.82268995e-02f, 2.51563434e-02f, -7.83420503e-02f, -3.02763246e-02f, 1.28539979e-01f, 1.51288971e-01f, -1.28736377e-01f,
  -1.49027213e-01f, 2.32427102e-02f, 7.27653354e-02f, -4.82115969e-02f, -8.89442861e-02f, 6.71621598e-03f, 1.59644157e-01f, -1.17283117e-03f, -1.05055943e-01f, -3.70808765e-02f,
  6.42366484e-02f, -2.66064946e-02f, 7.84367919e-02f, -8.96013901e-03f, -4.61929515e-02f, 1.10091724e-01f, 6.30298033e-02f, -1.02263324e-01f, -7.58619979e-02f, 9.98544171e-02f,
  -5.55626974e-02f, 3.11273690e-02f, -9.41479430e-02f, -1.74764786e-02f, -1.14471838e-01f, -6.25146702e-02f, -5.96677326e-02f, 1.04850799e-01f, 9.94294584e-02f, -7.86801130e-02f,
  1.45289660e-01f, -9.82983857e-02f, 7.78243393e-02f, -7.37669095e-02f, -9.08842534e-02f, 9.37566832e-02f, -7.14705959e-02f, 8.70204903e-03f, -4.21311799e-03f, -7.14552179e-02f,
  -6.31483272e-02f, 1.01347394e-01f, 1.22290216e-01f, 6.82406081e-03f, 1.01693109e-01f, -9.98889729e-02f, 4.52102460e-02f, 1.04385443e-01f, -1.30417990e-02f, -2.79052593e-02f,
  1.47061706e-01f, -8.83439332e-02f, -9.66710448e-02f, -5.34954332e-02f, 2.17195898e-02f, -3.26935053e-02f, 7.40154311e-02f, 1.02938265e-01f, -6.10211603e-02f, 2.50888430e-02f,
  1.25477225e-01f, 5.58268055e-02f, -6.24604858e-02f, -6.43645376e-02f, -1.06615126e-01f, 1.59233604e-02f, 9.46830213e-03f, -8.94377306e-02f, 3.32201011e-02f, 3.74374129e-02f,
  1.04896992e-01f, -9.98018123e-03f, -5.90119436e-02f, 3.43914367e-02f, 1.52662635e-01f, 7.32479393e-02f, 6.12732172e-02f, -7.22435713e-02f, 3.83957475e-02f, 5.11374418e-03f,
  -1.84637666e-01f, 3.90025042e-02f, -8.42526034e-02f, 3.46955168e-03f, -5.31745888e-03f, -1.48082373e-03f, -1.44104066e-03f, 3.83231565e-02f, 1.34021670e-01f, 1.14299580e-01f,
  -5.75021431e-02f, -1.33964449e-01f, 8.38842764e-02f, 1.40538678e-01f, 1.90317288e-01f, -3.21261887e-03f, 5.51389009e-02f, 1.00391604e-01f, 1.21585131e-01f, 1.31344870e-01f,
  1.48663055e-02f, -3.14543694e-02f, -3.79730873e-02f, -1.68848857e-02f, -9.08089876e-02f, -7.81104565e-02f, -1.42079547e-01f, 1.42088354e-01f, -5.32041900e-02f, 3.91569920e-02f,
  1.03376672e-01f, -1.29956827e-01f, -9.77879986e-02f, -9.50574130e-02f, -6.59098998e-02f, 8.44164118e-02f, 1.22126982e-01f, 1.18031204e-01f, 1.65789694e-01f, 4.23447974e-03f,
  1.55114293e-01f, 1.31512165e-01f, 1.56886771e-01f, 8.50823149e-02f, -3.55241448e-02f, 2.55602356e-02f, 9.16332379e-02f, -9.16114226e-02f, 4.95411865e-02f, -1.71110541e-01f,
  2.05771104e-02f, 8.06215331e-02f, -1.03378110e-01f, -1.47471100e-03f, -2.33587082e-02f, 3.76211829e-03f, 8.37083533e-02f, -4.11352776e-02f, 5.29361777e-02f, 1.21043779e-01f,
  1.25520483e-01f, 2.08351508e-01f, 1.18937321e-01f, 1.02982834e-01f, 5.52449003e-02f, -7.58633837e-02f, -1.83051899e-01f, -7.72801042e-02f, -1.17545001e-01f, -4.45620716e-02f,
  -6.69286624e-02f, -2.06584688e-02f, -1.32311285e-01f, 4.20828024e-03f, -6.87845647e-02f, 2.13724896e-02f, 3.46088642e-03f, 4.26182114e-02f, 4.49609041e-01f, 7.43802488e-02f,
  1.26199499e-01f, -1.42514244e-01f, -2.90710926e-02f, 9.45507735e-02f, 1.93336353e-01f, -2.29550879e-02f, 3.45351361e-02f, -1.30875289e-01f, 1.59798097e-02f, -5.47689646e-02f,
  -9.97256711e-02f, -6.30254298e-02f, -1.00999385e-01f, -2.69852802e-02f, 1.20137297e-01f, 3.30179706e-02f, -9.34154987e-02f, 9.70588773e-02f, 1.63167536e-01f, -5.05028106e-02f,
  3.76245417e-02f, 1.76710170e-02f, 1.16306484e-01f, -6.68774843e-02f, 1.70255214e-01f, -3.88421081e-02f, 2.05505893e-01f, -4.06767353e-02f, 4.84547252e-03f, -3.92556228e-02f,
  2.75598373e-02f, 1.16624303e-01f, -3.85494670e-03f, -8.32004473e-02f, 7.49989599e-02f, 5.07052010e-03f, 9.39469039e-02f, -1.44690946e-02f, -2.32219212e-02f, -5.16900606e-02f,
  -1.67034730e-01f, -1.02083698e-01f, -4.21833806e-02f, 1.46613456e-03f, -4.63644266e-02f, -1.19136376e-02f, 1.25048995e-01f, 7.11306334e-02f, 9.33065861e-02f, -1.31361693e-01f,
  -2.08557174e-01f, 9.40172672e-02f, -4.12127264e-02f, 1.98324218e-01f, 1.83239967e-01f, 1.08581260e-01f, 1.21755332e-01f, -3.39974500e-02f, -7.37202466e-02f, 1.17319390e-01f,
  6.18156530e-02f, 2.94432845e-02f, 1.88762128e-01f, 6.40435591e-02f, -7.86033720e-02f, 2.38332637e-02f, 6.07375987e-02f, -1.19252063e-01f, -3.14762071e-02f, 3.45219225e-02f,
  -4.79546338e-02f, 1.59798563e-02f, 1.18447326e-01f, 1.29276708e-01f, -2.57203858e-02f, -1.22374311e-01f, -1.20728418e-01f, -3.17384750e-02f, 1.33193135e-02f, -1.06520198e-01f,
  -2.99295839e-02f, 3.85719612e-02f, 8.84267315e-02f, -5.49494438e-02f, 9.82627273e-02f, -1.15705147e-01f, -3.98575217e-02f, -2.91991886e-02f, 4.20793965e-02f, -7.87905902e-02f,
  8.87361690e-02f, 4.17657122e-02f, -1.09252699e-01f, -2.43051853e-02f, -1.35869995e-01f, -6.92088977e-02f, 1.96991295e-01f, 3.94189209e-02f, -1.19299844e-01f, 1.12742241e-02f,
  5.20965643e-02f, 1.00582495e-01f, 4.28430513e-02f, -9.75775272e-02f, -9.28396285e-02f, 1.23168595e-01f, -7.27795959e-02f, 1.96202949e-01f, -7.99177438e-02f, 2.45517655e-03f,
  1.87962934e-01f, 4.36229296e-02f, 2.28435323e-01f, 1.17912807e-01f, -1.24021761e-01f, -1.83947813e-02f, -1.04423344e-01f, 2.29519665e-01f, -1.29207242e-02f, -1.02883674e-01f,
  -1.49600670e-01f, -1.17987849e-01f, -1.70335677e-02f, 8.58179014e-03f, -2.27930900e-02f, -1.11868702e-01f, 9.45239440e-02f, 3.01392693e-02f, 2.04598427e-01f, -8.34323242e-02f,
  -1.11089528e-01f, 1.05415195e-01f, -5.82148880e-02f, -1.21048994e-01f, 8.70004892e-02f, -3.68777364e-02f, 1.96802750e-01f, 1.04241975e-01f, -1.12931035e-01f, 4.34792861e-02f,
  -4.12012041e-02f, 4.49207192e-03f, 1.44639891e-02f, -4.98816837e-03f, -3.73387933e-02f, -1.10300630e-02f, 1.86820731e-01f, 6.10097498e-02f, -1.97592340e-02f, 8.09574202e-02f,
  2.68554147e-02f, 4.69183736e-02f, 9.96001065e-02f, 3.45603824e-02f, -3.73052135e-02f, -1.64324611e-01f, 8.43198299e-02f, 3.37202661e-02f, 1.22721277e-01f, 1.62428003e-02f,
  1.32526010e-01f, -1.56595916e-01f, 7.64524415e-02f, -1.52373672e-01f, -1.01823777e-01f, 7.10968301e-02f, 1.29071429e-01f, 1.77253876e-02f, 7.81945959e-02f, 1.77542105e-01f,
  -4.74054813e-02f, 1.92249596e-01f, 1.76771238e-01f, 8.77124630e-03f, 1.13752978e-02f, 3.32041532e-02f, -1.39949406e-02f, 6.20615929e-02f, 2.55801022e-01f, 2.72282772e-02f,
  -8.38425308e-02f, 1.76030338e-01f, 1.62066370e-01f, 3.11557148e-02f, 1.31750837e-01f, 1.26861170e-01f, 2.92064832e-03f, 1.56451523e-01f, 9.04552415e-02f, -8.04379284e-02f,
  -2.09161788e-01f, 8.12697317e-03f, -8.32908675e-02f, -6.36888221e-02f, -5.15374281e-02f, 1.83757376e-02f, -5.21882251e-03f, 1.54582411e-01f, 1.17137849e-01f, -2.26666816e-02f,
  -3.42432782e-02f, 1.90125346e-01f, 1.96028918e-01f, -8.75945911e-02f, 5.57848718e-03f, 8.87161493e-02f, 9.20722038e-02f, -8.03063437e-03f, -6.83305189e-02f, 6.39172196e-02f,
  -4.83391695e-02f, 8.99628848e-02f, -7.05289468e-03f, -1.71919018e-01f, -9.64330509e-02f, 5.29365987e-02f, -5.62250838e-02f, -8.63510445e-02f, -1.63297907e-01f, 5.61415106e-02f,
  -8.16996396e-02f, 5.37779070e-02f, -2.63981577e-02f, 1.24212906e-01f, 8.26210082e-02f, 3.60944629e-01f, -3.84448618e-02f, -6.30451813e-02f, -9.12051424e-02f, -5.08345552e-02f,
  1.27258062e-01f, 5.81126995e-02f, 2.80130267e-01f, 5.18252142e-02f, 2.20266163e-01f, 2.43975550e-01f, 2.90399730e-01f, 2.21921086e-01f, 4.26786989e-02f, 6.31023049e-02f,
  1.36001274e-01f, -7.82318190e-02f, 2.10045148e-02f, 3.66093144e-02f, -1.16141133e-01f, 2.66681641e-01f, 1.11102261e-01f, -1.71464026e-01f, -1.35290474e-01f, -3.73111814e-02f,
  -7.65743703e-02f, 1.19663060e-01f, -5.22486940e-02f, 1.65372156e-02f, 1.07696190e-01f, -3.17266546e-02f, -1.48970205e-02f, 5.24755858e-04f, -1.31179556e-01f, 8.48884434e-02f,
  7.13246614e-02f, -1.50032071e-02f, 3.57512012e-02f, -1.77951470e-01f, 8.33502226e-03f, 2.08682165e-01f, 7.68193752e-02f, 1.97097007e-02f, -1.37203947e-01f, -8.78601223e-02f,
  2.63694450e-02f, 1.30523434e-02f, -1.57905966e-01f, -1.01642810e-01f, -1.21963248e-01f, -8.59416276e-03f, -1.55001655e-01f, 1.11721538e-01f, -9.16621089e-02f, -1.95209682e-01f,
  -2.77380627e-02f, -1.44986942e-01f, -1.06417671e-01f, -9.54845250e-02f, -4.94879612e-04f, -5.23181893e-02f, 1.45373151e-01f, 4.45332043e-02f, 3.07402074e-01f, -1.11707281e-02f,
  5.67995105e-03f, 4.45412360e-02f, -1.14877477e-01f, 5.72686754e-02f, 2.21172228e-01f, -7.04638846e-03f, -1.92263812e-01f, -2.70418590e-03f, -5.19988537e-02f, -1.65253252e-01f,
  -2.59803124e-02f, 7.38886520e-02f, 8.04954488e-03f, 2.57105738e-01f, 1.45562872e-01f, -1.53681636e-01f, -3.14915031e-01f, 1.57728076e-01f, 1.34581178e-01f, 1.72458410e-01f,
  1.53592378e-01f, 3.47239435e-01f, 2.38333493e-01f, -1.73100475e-02f, 2.13301517e-02f, 5.20592034e-02f, -2.05095887e-01f, -5.69339469e-02f, 4.12560642e-01f, 1.06464371e-01f,
  -9.57665294e-02f, 1.33198006e-02f, 7.91367218e-02f, 4.62792665e-02f, -1.16975345e-01f, -8.70221332e-02f, 4.74630408e-02f, 2.47989684e-01f, 3.51272702e-01f, -2.29735821e-02f,
  -4.37674783e-02f, -4.59880270e-02f, -1.09961465e-01f, -9.20342281e-02f, -1.51104152e-01f, -3.21644060e-02f, -7.74053782e-02f, 2.49746576e-01f, -1.24947466e-01f, 6.94028586e-02f,
  -7.52431154e-02f, 6.60041198e-02f, -6.06637821e-02f, -7.33275786e-02f, 3.79973382e-01f, 1.13977082e-01f, 7.20767677e-02f, 1.12633862e-01f, -3.63927670e-02f, 1.70224328e-02f,
  -7.53416419e-02f, -4.36928347e-02f, 2.96378613e-01f, 1.52878299e-01f, -1.78743139e-01f, 5.22374548e-02f, 9.97702032e-02f, 1.23541532e-02f, -3.44202310e-01f, 1.25309840e-01f,
  -6.05547503e-02f, -9.98489708e-02f, -7.19242394e-02f, 3.45363468e-02f, 8.06737468e-02f, -1.11045033e-01f, -1.07664160e-01f, 3.32501121e-02f, -5.44138104e-02f, 6.34971187e-02f,
  4.97856177e-02f, -7.14462027e-02f, 6.69782758e-02f, 9.34403092e-02f, -1.04414411e-01f, -1.17055409e-01f, -4.09641452e-02f, -1.43270902e-02f, 4.15450670e-02f, -5.95136695e-02f,
  2.77921446e-02f, -1.80531014e-02f, -7.20923543e-02f, 6.76124915e-02f, 6.25649393e-02f, -8.58286470e-02f, 3.64399776e-02f, -3.07674371e-02f, -8.18131194e-02f, 1.02059431e-02f,
  -1.00298889e-01f, 3.04431375e-02f, 3.26296780e-03f, -1.13780834e-01f, 2.31579561e-02f, 3.17657888e-02f, -2.44670603e-02f, 5.57636768e-02f, 3.56256180e-02f, -1.19387962e-01f,
  2.89977703e-04f, 9.06236321e-02f, 3.56739238e-02f, -3.40388045e-02f, 1.80160126e-03f, 9.65548977e-02f, -1.20243356e-01f, -8.70739594e-02f, -1.24894820e-01f, 6.21378645e-02f,
  -6.89072311e-02f, 3.05392705e-02f, 5.99149838e-02f, -5.51883429e-02f, -5.58883213e-02f, 1.90857910e-02f, -6.43139035e-02f, -2.78626643e-02f, 2.01281067e-02f, -6.93971738e-02f,
  1.09121345e-01f, -2.10166350e-02f, 1.72312837e-02f, -4.44105826e-02f, 2.91266982e-02f, -4.06284779e-02f, 1.33394271e-01f, 1.33923143e-01f, 5.47124632e-02f, 1.68741137e-01f,
  -2.40865156e-01f, 2.61580557e-01f, 2.78614461e-01f, -2.08170697e-01f, -2.42203325e-01f, -4.87658381e-03f, -1.92675143e-02f, 1.89167127e-01f, 1.89289793e-01f, 7.85560384e-02f,
  1.44680426e-01f, -1.32136837e-01f, -7.33388066e-02f, 7.59616271e-02f, -1.74236834e-01f, 9.56831798e-02f, 5.14126301e-01f, -7.72408321e-02f, -1.88077793e-01f, 2.12416425e-02f,
  -8.41300585e-04f, -5.73330484e-02f, 6.95809051e-02f, 6.89557940e-02f, 1.12246931e-01f, 2.35542417e-01f, 3.45694274e-01f, -9.37604532e-03f, 5.62722683e-02f, -1.13026194e-01f,
  -1.28079327e-02f, 8.75943452e-02f, -1.03371985e-01f, -6.23085909e-02f, 3.95128876e-02f, 1.27481863e-01f, -1.69647560e-01f, 9.70163718e-02f, 2.98024975e-02f, -8.58950615e-02f,
  4.17915285e-02f, 7.95203634e-03f, 3.07145894e-01f, -1.41037581e-02f, 9.89293531e-02f, 1.24182142e-01f, -1.04828238e-01f, -3.08002718e-02f, -8.48219767e-02f, -8.31985027e-02f,
  3.37799132e-01f, 1.88813452e-02f, -1.44477919e-01f, 1.50792226e-01f, -5.33401361e-03f, -1.10025056e-01f, -2.02775940e-01f, -1.06068529e-01f, 2.20443130e-01f, -1.33174276e-02f,
  2.14813724e-01f, 6.25597835e-02f, -5.98144531e-03f, 3.57987359e-02f, 1.15445688e-01f, -1.08890332e-01f, -1.76809132e-01f, -9.62513089e-02f, -2.63491005e-01f, 1.25785321e-01f,
  -1.28375247e-01f, -1.94836423e-01f, -1.16428882e-01f, 4.41882201e-02f, -1.22055218e-01f, 6.40925691e-02f, -5.57333324e-03f, -5.36008738e-02f, 1.28253937e-01f, -8.04705173e-02f,
  5.07577360e-01f, 9.96198505e-02f, 3.78492326e-01f, -8.86650831e-02f, 4.91747409e-02f, -4.63434048e-02f, 2.47327566e-01f, 8.58917758e-02f, 1.91589817e-02f, 6.21975213e-02f,
  6.92324042e-02f, -2.25343734e-01f, -1.92805588e-01f, 8.23744833e-02f, -9.11732391e-02f, 8.89955685e-02f, 2.05825135e-01f, 4.87670936e-02f, 4.08640504e-02f, 1.74944922e-01f,
  2.82399446e-01f, 5.04793972e-02f, 3.18208426e-01f, 2.54703641e-01f, -8.30654874e-02f, 8.76854360e-02f, 1.91425104e-02f, 7.89743140e-02f, 3.64204258e-01f, 9.49704275e-02f,
  -9.63644683e-02f, -4.06073779e-02f, -4.78970669e-02f, -1.10764578e-01f, 6.20171241e-02f, -1.79747403e-01f, -6.87397942e-02f, 1.36147574e-01f, -1.20468736e-01f, -4.94411290e-02f,
  1.77519307e-01f, -8.97632018e-02f, -2.43424755e-02f, 1.36230290e-01f, 6.59649596e-02f, 3.60422991e-02f, -4.69380878e-02f, 4.53002714e-02f, -1.96706951e-01f, 7.61614367e-02f,
  -1.73793942e-01f, 3.38434465e-02f, -1.38140664e-01f, 2.48448811e-02f, -1.21029250e-01f, 1.14572060e-03f, 7.12662041e-02f, -1.12248631e-02f, -9.01819915e-02f, -4.08066111e-03f,
  -2.41836123e-02f, -7.71868974e-02f, -7.90477619e-02f, -7.35237002e-02f, 1.87068492e-01f, 3.13569643e-02f, 2.21018940e-02f, 1.47190794e-01f, -3.06088515e-02f, 7.37797096e-02f,
  -9.22755431e-03f, -8.33962187e-02f, 3.67798880e-02f, 8.70114043e-02f, -1.17125891e-01f, 1.22943766e-01f, 2.02421576e-01f, 8.59865844e-02f, 1.93137340e-02f, -6.85654134e-02f,
  -6.05781414e-02f, -3.62824909e-02f, 4.88071255e-02f, -3.41881886e-02f, -5.17303906e-02f, -1.10544428e-01f, 7.98653904e-03f, 5.92414625e-02f, 3.86612564e-02f, -2.88152918e-02f,
  1.90198451e-01f, 3.55309434e-02f, -9.59385633e-02f, 8.98518860e-02f, -1.19879343e-01f, -7.41118789e-02f, -9.79311066e-04f, -1.37420008e-02f, -6.37863427e-02f, 6.82721734e-02f,
  8.55140984e-02f, -1.83571801e-02f, -2.88754459e-02f, 1.04460537e-01f, -7.05490932e-02f, 1.33915886e-01f, 6.91200271e-02f, -7.66137755e-03f, -1.31987426e-02f, 3.91347297e-02f,
  1.18118145e-01f, 1.09303132e-01f, -8.84848908e-02f, 9.78010669e-02f, 1.00401975e-01f, 7.06994981e-02f, -1.33116925e-02f, 2.21911930e-02f, 7.10966066e-03f, 2.18486816e-01f,
  -4.17242460e-02f, 1.18446507e-01f, -3.53640877e-02f, -7.14200269e-03f, 7.60959685e-02f, 6.96496516e-02f, 2.37128846e-02f, 9.53388140e-02f, -3.33919749e-02f, -1.27762511e-01f,
  -1.65250152e-01f, 1.28987953e-01f, -8.34174156e-02f, -1.36814356e-01f, 5.23254834e-02f, 1.34179713e-02f, 7.93557316e-02f, 1.88087076e-01f, 6.98129996e-04f, 4.97615933e-02f,
  4.03458737e-02f, 3.16095352e-02f, 9.52564254e-02f, 4.50632572e-02f, -1.29049078e-01f, -1.12536423e-01f, 4.45608869e-02f, 1.32551774e-01f, 2.95412238e-03f, -1.87549293e-02f,
  -3.18475291e-02f, 3.30895819e-02f, 4.89895865e-02f, 9.71029177e-02f, 8.33271742e-02f, -1.02939829e-01f, 6.55211583e-02f, -1.28868803e-01f, 8.23661610e-02f, 9.25334692e-02f,
  -2.51816008e-02f, -6.53126091e-02f, 2.79185399e-02f, 1.41339153e-01f, -9.48490351e-02f, -9.29721445e-02f, -1.10075325e-01f, -8.47287998e-02f, -7.18845353e-02f, 7.77458847e-02f,
  -6.97112381e-02f, -4.03196849e-02f, 1.56897381e-01f, 1.22413039e-01f, 1.92033052e-02f, -3.38955149e-02f, 1.56861752e-01f, 1.22553661e-01f, 1.77946433e-01f, -5.83945438e-02f,
  2.68559903e-02f, 1.00121118e-01f, -1.09458677e-01f, 1.86692268e-01f, 1.74893439e-02f, 7.00742379e-02f, 1.26651496e-01f, -8.63396451e-02f, -3.00520360e-02f, 5.04334718e-02f,
  -1.51052028e-01f, 1.10446224e-02f, -3.75266820e-02f, 9.60217267e-02f, -4.46036570e-02f, 9.23233330e-02f, -6.39516264e-02f, 7.51939565e-02f, 6.48536012e-02f, 2.64928825e-02f,
  -2.16726288e-02f, 5.83305880e-02f, 4.42077629e-02f, 8.71831849e-02f, 4.50144932e-02f, -1.37985662e-01f, -2.29187924e-02f, -1.16135813e-01f, 1.57753423e-01f, 6.19516037e-02f,
  1.17163636e-01f, 1.62908301e-01f, 1.45238385e-01f, -1.17388502e-01f, -1.32744908e-01f, -6.21182397e-02f, 5.04028574e-02f, 1.46735758e-01f, -3.98217961e-02f, 4.64394242e-02f,
  -2.62647402e-03f, 5.22868112e-02f, 6.00189939e-02f, 2.56583374e-02f, 1.31203383e-01f, -1.29649773e-01f, -1.13106392e-01f, -1.15975626e-01f, -1.32911563e-01f, -1.33840501e-01f,
  -5.31533845e-02f, -6.12087362e-02f, 1.70974135e-01f, 5.25407903e-02f, 4.61870618e-02f, -1.19376369e-01f, 3.83425578e-02f, -9.37501863e-02f, -8.17670301e-02f, 6.55415878e-02f,
  -2.00197369e-01f, -1.54438568e-02f, -3.50157544e-02f, -1.83895215e-01f, -1.80105418e-02f, 1.26020044e-01f, 7.54941180e-02f, -1.82830319e-01f, -5.51073961e-02f, 5.21339178e-02f,
  -3.18148034e-03f, -3.73150818e-02f, 7.12999925e-02f, 2.13218760e-02f, 6.10674806e-02f, 1.12741813e-01f, 2.44375989e-01f, 9.49799418e-02f, 1.15238689e-01f, -2.44150963e-02f,
  1.03202298e-01f, 1.90132838e-02f, 1.89462435e-02f, -6.59860522e-02f, 7.54250288e-02f, 1.75161123e-01f, 1.56555742e-01f, 8.28213990e-02f, -4.13545445e-02f, -7.58817494e-02f,
  2.85151415e-02f, 2.11951714e-02f, -6.49238378e-02f, 8.09511319e-02f, -5.15450798e-02f, 2.76284833e-02f, -1.12567142e-01f, 2.82085054e-02f, 3.68998237e-02f, 6.34506857e-03f,
  1.07996523e-01f, -1.48503827e-02f, 3.90406512e-02f, 2.11696997e-02f, -1.37967626e-02f, 1.20807245e-01f, 8.97627100e-02f, -9.33122709e-02f, -1.00326873e-01f, 1.09767050e-01f,
  -6.21373300e-03f, 1.79858729e-01f, -3.72351445e-02f, -5.37911197e-03f, -1.09924510e-01f, 9.15284157e-02f, -7.17251096e-03f, 7.82132372e-02f, 2.69118428e-01f, 3.10766339e-01f,
  2.30209440e-01f, 1.73507601e-01f, 2.08821625e-01f, 2.45138511e-01f, 5.03711514e-02f, -6.17658198e-02f, -1.40883714e-01f, 5.37101105e-02f, 3.76832992e-01f, -2.19104543e-01f,
  -1.27236873e-01f, 2.07022458e-01f, 3.94478701e-02f, 2.67038792e-02f, -3.25633697e-02f, 1.79692134e-01f, -7.01826811e-02f, 1.60692811e-01f, 2.43553042e-01f, 3.44798155e-02f,
  -3.55512410e-01f, 5.43367006e-02f, -6.95987269e-02f, 1.07710570e-01f, -1.52023971e-01f, -8.33559707e-02f, -5.71167096e-03f, 2.35842820e-02f, 1.60694927e-01f, -1.79013722e-02f,
  -1.74652413e-01f, -2.10405011e-02f, 4.74526495e-01f, -1.17875174e-01f, 1.24749303e-01f, 1.14782080e-01f, 1.63419262e-01f, -1.09096225e-02f, 1.11262962e-01f, 1.04926683e-01f,
  1.40417427e-01f, -7.42271245e-02f, -2.07269594e-01f, -9.19520929e-02f, -3.95553634e-02f, 2.00013876e-01f, 9.95975062e-02f, 1.22284196e-01f, 4.35119346e-02f, 6.17712215e-02f,
  -7.07620010e-03f, 1.12468928e-01f, 9.81144309e-02f, 9.42018852e-02f, -1.49134859e-01f, 4.24785972e-01f, -8.44424218e-02f, 1.20571002e-01f, -7.92983100e-02f, 2.07313955e-01f,
  2.49454558e-01f, 9.59032997e-02f, 9.32969898e-02f, -4.94022742e-02f, 6.63063675e-02f, 6.78906888e-02f, 1.99797854e-01f, 1.46177828e-01f, -1.94970533e-01f, -4.25289012e-02f,
  1.07209571e-01f, -5.74878640e-02f, -9.40867700e-03f, -6.35931864e-02f, -6.03370741e-02f, 1.06725529e-01f, 1.15449883e-01f, 1.19204149e-01f, -7.27441236e-02f, -5.71921654e-02f,
  -9.42828879e-02f, 1.25969663e-01f, 7.69736618e-02f, -8.33884755e-04f, -2.95426883e-02f, -1.28065392e-01f, 5.34384660e-02f, -4.60526608e-02f, 4.66895476e-02f, -2.34123562e-02f,
  -2.01842546e-01f, -1.12502319e-04f, 2.24795625e-01f, 1.13313906e-01f, 7.49451667e-02f, 1.34496346e-01f, 3.58499169e-01f, -3.19543295e-02f, -3.26112993e-02f, -6.36438653e-02f,
  -8.35556630e-03f, -3.41421254e-02f, -2.59882305e-02f, -1.22241817e-01f, -1.03801697e-01f, -9.56531763e-02f, -8.44982713e-02f, 4.63994779e-02f, -2.07211319e-02f, -3.28256807e-04f,
  1.41767889e-01f, -1.89848498e-01f, -7.66990408e-02f, 1.13364890e-01f, 1.13133714e-01f, -1.44576132e-01f, 8.12612250e-02f, -9.46972817e-02f, 2.58539617e-01f, 1.70188993e-01f,
  -8.31451416e-02f, 1.38182148e-01f, 3.14826928e-02f, 2.34731752e-02f, -7.63011426e-02f, -1.20170200e-02f, -5.08789234e-02f, 7.19630793e-02f, -2.93457918e-02f, -7.03742728e-02f,
  1.08159006e-01f, -7.24543957e-03f, 8.07313994e-02f, -4.21972983e-02f, 1.69769198e-01f, -6.82934225e-02f, 5.37165813e-02f, -9.72928181e-02f, 2.53588557e-02f, 1.80806309e-01f,
  1.24775186e-01f, -2.48044776e-03f, 5.83128594e-02f, -8.97355676e-02f, -8.55889097e-02f, 2.37817951e-02f, -4.52905782e-02f, -6.81246519e-02f, 5.18937968e-02f, -3.39383557e-02f,
  1.35116890e-01f, -6.80020675e-02f, -9.99343675e-03f, -1.16078965e-01f, -1.36834875e-01f, -6.38510883e-02f, -1.35522382e-02f, -5.21247573e-02f, 1.57182276e-01f, -5.08200265e-02f,
  2.82198992e-02f, -6.95297644e-02f, -1.08958147e-01f, -2.85462141e-02f, 1.25831097e-01f, 1.20759927e-01f, -2.01599207e-02f, -5.13243377e-02f, -1.11133359e-01f, 9.03982446e-02f,
  7.95737356e-02f, -4.42560390e-02f, -4.60589230e-02f, -1.08780466e-01f, 1.19921237e-01f, -1.09641425e-01f, -1.70483422e-02f, 1.39456047e-02f, -1.08324669e-01f, 9.98588651e-02f,
  5.45515083e-02f, 2.30824780e-02f, 1.15393354e-02f, 4.00998294e-02f, 6.58857524e-02f, -1.32207155e-01f, 7.55054057e-02f, 4.83075567e-02f, 1.57657221e-01f, -1.08072296e-01f,
  2.98355576e-02f, -1.11871026e-01f, 2.69325078e-02f, -1.14423424e-01f, 1.17987037e-01f, 8.56343508e-02f, -1.81719065e-01f, 7.14293048e-02f, 1.12334918e-02f, 1.74656902e-02f,
  -1.36473477e-02f, 1.07431725e-01f, 6.46898448e-02f, -4.60024923e-02f, -6.44835606e-02f, 1.87081366e-03f, 8.08418542e-02f, 3.86475027e-03f, 6.52668253e-02f, -1.31278606e-02f,
  -5.97480573e-02f, 2.30429582e-02f, 1.57339916e-01f, 6.51694238e-02f, 1.19878136e-01f, 4.65270653e-02f, -2.73335278e-02f, 2.95069069e-02f, 2.08066944e-02f, -7.13679790e-02f,
  1.74715310e-01f, -1.02392338e-01f, 2.92060319e-02f, 1.33755594e-01f, 1.24437474e-01f, 1.27129242e-01f, -8.04012716e-02f, 7.51984259e-03f, -3.07236072e-02f, 3.81961018e-02f,
  9.70190018e-02f, 9.90066528e-02f, -1.60123721e-01f, -6.17830083e-02f, -1.26506224e-01f, -5.26872948e-02f, 1.33853823e-01f, 1.61802601e-02f, -2.51515675e-02f, 1.06263131e-01f,
  1.07009403e-01f, 1.32972881e-01f, -5.01169416e-04f, 5.55363391e-03f, 5.30228131e-02f, -1.37107342e-01f, 1.16000116e-01f, -7.57587478e-02f, -1.43331680e-02f, 4.43076827e-02f,
  4.76325043e-02f, 8.27566683e-02f, 8.29751510e-03f, 4.77976687e-02f, 1.27924934e-01f, 3.32115740e-02f, 2.46475134e-02f, 9.91518050e-02f, 9.33668986e-02f, -3.33591774e-02f,
  -1.13994619e-02f, 2.06820387e-02f, -8.81893262e-02f, -5.68582192e-02f, 1.03439555e-01f, -1.05696663e-01f, 9.24632791e-03f, 1.05046943e-01f, -5.53210340e-02f, 1.07890032e-01f,
  -1.22621514e-01f, -4.70933728e-02f, 2.87234820e-02f, 7.48834386e-03f, 6.83083385e-02f, -2.92903315e-02f, -1.04676552e-01f, -3.03246547e-04f, 1.13225639e-01f, -1.10212408e-01f,
  -6.68341294e-02f, 9.11466628e-02f, -1.24127373e-01f, 7.68405497e-02f, 9.82042700e-02f, 1.25144213e-01f, 1.31422207e-01f, 7.83754438e-02f, 1.71980888e-01f, -2.91938595e-02f,
  -8.68473649e-02f, -1.05988756e-01f, 1.99700333e-02f, -1.09949209e-01f, -1.18281148e-01f, -4.20473777e-02f, 5.06293401e-02f, -8.91637355e-02f, -8.81569088e-02f, -4.29735333e-02f,
  -9.97507796e-02f, 6.68683555e-03f, 5.68592884e-02f, -2.46150717e-02f, -2.56526843e-02f, 7.84411132e-02f, 1.03720367e-01f, -9.15861130e-02f, -1.03501230e-01f, -6.81164861e-02f,
  3.60366143e-02f, 2.07318798e-01f, -8.94751102e-02f, -9.55524296e-02f, 1.07437931e-01f, -4.06602919e-02f, 6.18847683e-02f, -7.24692494e-02f
};

// L3_fan_Bp_bar (Shape: 1 x 52)
const int L3_fan_Bp_bar_rows = 1;
const int L3_fan_Bp_bar_cols = 52;
const float L3_fan_Bp_bar_data[] = {
  6.85271844e-02f, 3.59512456e-02f, 1.39532909e-01f, -8.60585868e-02f, 4.18091528e-02f, -5.53523190e-02f, 9.40200165e-02f, -1.02266684e-01f, 2.78708339e-02f, 1.66327342e-01f,
  -3.24506685e-02f, -4.00290638e-02f, 2.01285586e-01f, 1.10894099e-01f, 7.25180283e-02f, 9.05077606e-02f, 5.37607931e-02f, 9.97805223e-02f, 1.77387565e-01f, -3.00488397e-02f,
  2.20294580e-01f, 2.67190300e-02f, -2.24359930e-04f, -8.83727893e-02f, 1.13456979e-01f, 1.86489969e-01f, -1.70979500e-02f, -8.31744894e-02f, -9.39646214e-02f, 9.78552848e-02f,
  4.59210984e-02f, 1.06828183e-01f, -3.18844393e-02f, 2.30497364e-02f, 3.41697820e-02f, 8.51011127e-02f, 1.51155412e-01f, 1.02934942e-01f, 9.65701044e-02f, 5.27349636e-02f,
  1.15993381e-01f, 1.90552235e-01f, -2.60036942e-02f, -9.17026252e-02f, -9.75160748e-02f, 2.09104400e-02f, -4.65240935e-03f, 2.29409784e-01f, -2.51320899e-02f, -4.60047498e-02f,
  1.29563555e-01f, 2.59516034e-02f
};

// L4_linear_W (Shape: 12 x 64)
const int L4_linear_W_rows = 12;
const int L4_linear_W_cols = 64;
const float L4_linear_W_data[] = {
  -6.29493743e-02f, -4.50774610e-01f, 5.00106812e-02f, 9.23191532e-02f, -1.07073762e-01f, -2.59426445e-01f, 2.61629224e-01f, -1.81724340e-01f, -3.56626324e-02f, 2.41325237e-02f,
  -6.92838430e-02f, -3.04304510e-01f, -1.18867606e-01f, 1.25925869e-01f, -4.35443968e-02f, -2.59343386e-02f, -7.36961439e-02f, -1.84050798e-01f, 1.10291228e-01f, -8.34133178e-02f,
  1.95881337e-01f, -4.34391312e-02f, 9.17346552e-02f, -2.25721583e-01f, -1.70382828e-01f, 3.70636046e-01f, -5.09132266e-01f, -2.69577414e-01f, -7.79756904e-02f, -9.94329825e-02f,
  -2.57595450e-01f, 2.42857084e-01f, -9.58240852e-02f, -2.60167241e-01f, -1.46893516e-01f, 4.91275871e-03f, -1.46084785e-01f, -2.81173140e-01f, -4.99669798e-02f, -8.20331797e-02f,
  1.16528772e-01f, -1.15343861e-01f, 8.98317471e-02f, -2.96122562e-02f, -7.14571178e-02f, -6.84168041e-02f, -1.19986422e-01f, 1.92555696e-01f, -1.80850700e-01f, -1.41852275e-01f,
  -1.42567664e-01f, 5.11388063e-01f, -4.32788543e-02f, 3.60065997e-01f, -2.12144375e-01f, 1.92005798e-01f, 2.14099720e-01f, -5.20762727e-02f, 2.57487446e-01f, -3.72870535e-01f,
  2.62097627e-01f, 3.10196057e-02f, 8.64842981e-02f, -5.73667465e-03f, 1.93015084e-01f, -2.27295756e-01f, -4.37686918e-04f, -1.07346959e-01f, -1.70598969e-01f, -3.45580950e-02f,
  -1.08699001e-01f, -2.10056752e-01f, -3.10674250e-01f, 4.03664529e-01f, -5.15261665e-02f, -3.68484735e-01f, 6.11886047e-02f, 1.10343471e-01f, -1.42471105e-01f, 1.38148889e-01f,
  4.28515933e-02f, -1.01480395e-01f, -1.20578602e-01f, -2.12570969e-02f, 3.41806442e-01f, -1.25467241e-01f, -2.35329151e-01f, 1.51716992e-01f, -5.39138727e-02f, 7.90815055e-02f,
  -4.46646810e-01f, -2.76363105e-01f, 9.83252153e-02f, 2.22334675e-02f, -1.33075014e-01f, -1.48224324e-01f, 4.46962155e-02f, 1.06918193e-01f, -8.97138938e-02f, 1.88302323e-02f,
  -2.10398033e-01f, -2.01958075e-01f, -1.17872790e-01f, 7.86866471e-02f, 6.10146262e-02f, 8.71310383e-02f, -4.77162600e-02f, -1.70546696e-01f, -3.33981449e-03f, 2.77744591e-01f,
  3.26847523e-01f, -1.06841261e-02f, -2.20894054e-01f, -2.35893577e-01f, -1.13628797e-01f, 2.93021291e-01f, 4.33981093e-03f, 4.01921034e-01f, 5.09588420e-01f, 5.57084419e-02f,
  -1.22299165e-01f, 9.95709002e-03f, 2.80303895e-01f, -2.89639711e-01f, -1.93981603e-01f, -1.07084125e-01f, 1.00236826e-01f, -7.00591579e-02f, -3.82037461e-01f, 7.92210698e-02f,
  1.77248985e-01f, -3.21434051e-01f, 2.78813714e-05f, -9.21193734e-02f, -3.50017279e-01f, 9.30628628e-02f, 3.19181621e-01f, 1.60614610e-01f, -5.08223139e-02f, 4.40377295e-01f,
  -2.18245346e-04f, 1.07217543e-01f, -3.68636250e-02f, 8.91782157e-03f, -1.07586168e-01f, 3.12677100e-02f, -1.68666363e-01f, -1.03686698e-01f, 2.50902206e-01f, 9.38470215e-02f,
  -2.01629803e-01f, 1.81233987e-01f, -1.91707551e-01f, -1.25081673e-01f, -6.37520058e-03f, 9.70438495e-02f, 8.33197236e-02f, 2.00213030e-01f, -2.63373733e-01f, -1.75729066e-01f,
  -3.48650485e-01f, 7.41567612e-02f, -2.06013784e-01f, 3.02265249e-02f, 1.38590351e-01f, -7.37688765e-02f, -1.89989671e-01f, -2.87811887e-02f, -8.22023302e-02f, 1.93840712e-01f,
  -2.53862794e-02f, -1.52978313e-03f, 9.26246960e-03f, -3.83733958e-02f, 2.19350040e-01f, 3.00633252e-01f, 3.06467742e-01f, -3.13005239e-01f, -8.79655480e-02f, 3.46484154e-01f,
  -2.35257614e-02f, 2.43904635e-01f, 2.54128695e-01f, -5.49650788e-02f, 8.90213158e-03f, 1.43014029e-01f, 1.15025099e-02f, -5.21963358e-01f, -2.37089485e-01f, -2.36625466e-02f,
  -1.60728231e-01f, -2.11543366e-01f, -2.54846692e-01f, -8.74291137e-02f, 9.30083916e-02f, -8.35923254e-02f, -4.88756113e-02f, 1.16177194e-01f, 2.16781318e-01f, -1.28102198e-01f,
  -3.10070012e-02f, -3.60976905e-01f, -2.20836461e-01f, -3.42245460e-01f, 2.49672439e-02f, 2.60747969e-02f, 1.02470428e-01f, 6.93193972e-02f, 1.36492401e-01f, 1.56529203e-01f,
  1.66534200e-01f, 6.34079650e-02f, -3.45207036e-01f, 7.69025683e-02f, 1.66199971e-02f, -1.24982171e-01f, 9.69611406e-02f, 1.15531020e-01f, -1.09358907e-01f, -3.94421339e-01f,
  5.88886626e-02f, -1.02466390e-01f, 3.56748492e-01f, 2.01898396e-01f, 2.58448690e-01f, -3.70590568e-01f, 1.82151645e-01f, -2.78253686e-02f, -1.38720974e-01f, 2.19620556e-01f,
  -1.18588451e-02f, -4.95886318e-02f, 7.20872730e-03f, 5.65976202e-02f, 1.12931602e-01f, 9.63826664e-03f, -4.33547311e-02f, -1.62124351e-01f, -2.14281201e-01f, -6.51016310e-02f,
  -1.79326504e-01f, 4.05990124e-01f, -2.88164347e-01f, -3.12850326e-01f, 3.20110843e-02f, -5.04706621e-01f, -3.74740899e-01f, 8.98105949e-02f, -3.46007794e-02f, -1.40884951e-01f,
  1.17911518e-01f, 5.64649880e-01f, 1.51250422e-01f, -1.97246656e-01f, -1.94574967e-02f, 1.30160928e-01f, 1.94184542e-01f, 1.44694149e-01f, -8.09116755e-03f, -1.82216570e-01f,
  1.03246659e-01f, 2.14722931e-01f, 2.37887174e-01f, -1.06928110e-01f, 2.89183408e-01f, -2.15863019e-01f, -1.15795210e-01f, 1.27521828e-01f, -8.86341184e-02f, -5.68199018e-03f,
  7.11306781e-02f, -2.29837447e-02f, -1.60662904e-01f, -1.43540114e-01f, -6.63488824e-03f, 2.77107079e-02f, -4.37576957e-02f, -2.27374285e-01f, 1.26326159e-01f, -2.40098193e-01f,
  -5.27741574e-02f, 3.18670243e-01f, -1.19479120e-01f, 2.19262078e-01f, -1.30574219e-02f, -8.00646245e-02f, 2.67883360e-01f, 2.93581545e-01f, 2.01006427e-01f, -3.27837259e-01f,
  -2.12024208e-02f, -9.25482064e-02f, -1.58807963e-01f, 2.53742605e-01f, 4.42649536e-02f, 7.27051720e-02f, 1.37017831e-01f, 7.75709469e-03f, 1.12188095e-02f, -1.70288071e-01f,
  -3.28665078e-02f, -1.00644700e-01f, -2.98342764e-01f, 6.83711916e-02f, -1.71068445e-01f, 1.89236805e-01f, 1.05346642e-01f, -2.78490912e-02f, -4.42911312e-02f, 2.25622073e-01f,
  -1.84623569e-01f, 1.24341264e-01f, 1.91224575e-01f, -6.74813539e-02f, -9.73308086e-02f, 3.88972759e-01f, 2.32927158e-01f, -3.50086428e-02f, -9.95035768e-02f, 2.26884663e-01f,
  -4.06722054e-02f, 8.88601393e-02f, 2.12846890e-01f, 1.77732706e-01f, 6.60521314e-02f, 2.47877285e-01f, 3.97283137e-01f, -5.25250971e-01f, -2.25349411e-01f, -2.86619097e-01f,
  1.26483396e-01f, -3.72486740e-01f, -1.28331572e-01f, 6.72851969e-03f, 1.69145659e-01f, -1.38625000e-02f, -1.81564718e-01f, -1.99992180e-01f, -1.66401982e-01f, 8.38881657e-02f,
  1.68860510e-01f, 7.61865899e-02f, -5.07228309e-04f, 2.07856879e-01f, -2.76852492e-02f, -4.96985242e-02f, -1.13756387e-02f, 2.05954075e-01f, -2.55100075e-02f, -6.90876544e-02f,
  4.61765304e-02f, 9.46478471e-02f, 2.92036742e-01f, 9.13251415e-02f, -3.62723693e-02f, -5.03564589e-02f, -1.84588596e-01f, -1.09470434e-01f, 4.49951768e-01f, -4.46856990e-02f,
  -1.54328078e-01f, -4.39577401e-02f, 7.09710494e-02f, -1.65952012e-01f, 1.24049895e-01f, -8.14746022e-02f, 9.93656814e-02f, -8.63618683e-03f, -2.96948617e-03f, -1.89060912e-01f,
  1.97530419e-01f, 9.21173245e-02f, 5.76090403e-02f, 3.56738716e-01f, 2.81367395e-02f, 1.81335837e-01f, -6.94218054e-02f, -3.97255570e-02f, 1.82952181e-01f, -1.41232550e-01f,
  3.24743539e-01f, -3.56747247e-02f, 2.61651874e-01f, 1.51948109e-01f, -7.01271296e-02f, 2.21982226e-01f, -1.95000738e-01f, 2.90418565e-01f, -1.27408192e-01f, -1.04398802e-01f,
  -4.43348348e-01f, 1.58423245e-01f, 4.69363093e-01f, 7.97459856e-03f, 1.57658815e-01f, 2.94883817e-01f, -1.30871341e-01f, 4.02581617e-02f, 1.51836842e-01f, 5.37672564e-02f,
  -1.72097355e-01f, -1.70287058e-01f, 5.74860424e-02f, 2.30806887e-01f, 1.64870784e-01f, -1.73719751e-03f, 1.62120491e-01f, 1.23365745e-01f, -2.00035013e-02f, 4.97554662e-03f,
  3.05096567e-01f, 3.98493111e-01f, -1.15555421e-01f, 2.03820914e-01f, -1.07236393e-01f, 4.79294918e-02f, -2.41392419e-01f, 1.56379715e-01f, -2.14957654e-01f, 6.50646985e-02f,
  2.13769764e-01f, -7.99779743e-02f, 2.38689423e-01f, -1.13347895e-01f, -3.92972156e-02f, 5.65625448e-03f, 7.48514831e-02f, 6.39226064e-02f, 3.29760611e-02f, -2.19905883e-01f,
  1.11524820e-01f, -1.43676875e-02f, 1.86862454e-01f, -9.00658891e-02f, 2.71275192e-01f, -7.16376379e-02f, -1.11767292e-01f, 1.12624161e-01f, -2.80256700e-02f, -1.71787754e-01f,
  -2.16114670e-02f, 3.31513621e-02f, -1.36992306e-01f, -1.66860893e-01f, 1.10559426e-01f, 1.26583055e-01f, 1.71291307e-01f, -3.24505903e-02f, 6.34441227e-02f, -1.75162688e-01f,
  -3.87866199e-02f, 1.29852638e-01f, -2.74712630e-02f, -1.76434383e-01f, -3.72701287e-01f, 4.74373788e-01f, 3.19962986e-02f, 1.75161675e-01f, -2.72586226e-01f, 1.76669285e-01f,
  1.66002870e-01f, 1.61723569e-01f, -1.39125541e-01f, 2.06387773e-01f, 9.12327096e-02f, 1.98888943e-01f, 2.58337945e-01f, -9.38656628e-02f, -1.87203795e-01f, 5.43542318e-02f,
  8.84684250e-02f, 2.96537578e-02f, 3.11540633e-01f, -2.27299765e-01f, 3.67584258e-01f, -2.32267737e-01f, -5.57868779e-02f, -8.22315365e-02f, 1.75732851e-01f, -1.63309515e-01f,
  1.31838145e-02f, 2.08681896e-01f, -7.25898221e-02f, 2.79854592e-02f, 4.41835344e-01f, 1.86373442e-01f, -1.98582649e-01f, -1.06176756e-01f, -3.10242064e-02f, -7.24410936e-02f,
  -2.39738319e-02f, 1.85186401e-01f, 1.11092702e-01f, 6.18857779e-02f, -1.34142905e-01f, -9.41593125e-02f, 1.36885241e-01f, -4.82663736e-02f, -3.50242108e-01f, -2.53517628e-01f,
  8.21993798e-02f, -2.66590536e-01f, -1.16647124e-01f, -1.51585266e-02f, 6.68503344e-02f, 3.69711876e-01f, -9.31870774e-04f, 2.99560100e-01f, -2.71564066e-01f, 5.49156442e-02f,
  5.67114390e-02f, -4.35391590e-02f, 2.07096133e-02f, -5.26737049e-02f, -7.82139674e-02f, -1.36571318e-01f, -1.25780940e-01f, 1.19087800e-01f, 2.54194140e-01f, -2.66948014e-01f,
  -3.57422650e-01f, 3.51244211e-01f, 1.06067508e-01f, 1.25354081e-01f, 8.41537490e-02f, 5.86272664e-02f, 3.50639597e-02f, -6.16542809e-02f, 1.40554816e-01f, -9.14226547e-02f,
  -1.63434342e-01f, -1.14684500e-01f, 2.21265797e-02f, 3.37464154e-01f, -2.01735646e-01f, 2.12292835e-01f, 1.66270919e-02f, -2.02801123e-01f, 8.44104290e-02f, -1.17011413e-01f,
  -1.17532738e-01f, 1.09775089e-01f, -1.99013919e-01f, -1.08779967e-01f, 6.24075867e-02f, 3.28541964e-01f, 1.59607291e-01f, -2.72275452e-02f, 2.82018065e-01f, 4.63728122e-02f,
  -1.66708127e-01f, 6.69422969e-02f, -7.58994222e-02f, 2.85704136e-01f, -1.05734706e-01f, -5.05486652e-02f, -7.00853616e-02f, 1.71226442e-01f, 2.72392422e-01f, 6.83379695e-02f,
  1.00694254e-01f, -2.66222715e-01f, -3.92209701e-02f, -4.15168405e-01f, -5.02976328e-02f, -3.02324653e-01f, 5.46252012e-01f, 6.06802590e-02f, -1.84487268e-01f, -1.93211868e-01f,
  -2.76922453e-02f, -3.52184623e-01f, -2.50690758e-01f, -3.72695774e-02f, -7.76521936e-02f, -1.85915872e-01f, -1.50785536e-01f, 1.19540235e-02f, -3.91281873e-01f, 1.55804664e-01f,
  -3.90027128e-02f, -7.27001727e-02f, -4.21739668e-01f, 3.23163390e-01f, 1.94193736e-01f, 6.02368973e-02f, -9.28135775e-03f, 3.09298247e-01f, -1.16666943e-01f, -1.48616899e-02f,
  4.22972254e-02f, 8.08255225e-02f, -1.22086920e-01f, -1.67874575e-01f, 1.49521247e-01f, 2.55180914e-02f, 8.43895897e-02f, -2.67249137e-01f, -5.59700793e-03f, -3.33977222e-01f,
  -1.21609531e-01f, 3.01816136e-01f, 8.10749605e-02f, 4.03996319e-01f, 1.10387832e-01f, 1.97824195e-01f, -5.99801131e-02f, 1.10374764e-01f, -1.19424537e-01f, -2.58648634e-01f,
  -9.52608734e-02f, -7.32810423e-02f, -1.78625882e-01f, 6.03025369e-02f, -3.47589135e-01f, 9.97540131e-02f, 1.22699022e-01f, -9.59603414e-02f, -2.05543526e-02f, -7.24007338e-02f,
  -1.42855152e-01f, -1.57862812e-01f, -1.79411456e-01f, 2.53181249e-01f, 4.82888483e-02f, 1.09598465e-01f, 7.31017292e-02f, 4.91704017e-01f, 4.31397110e-02f, 2.83741444e-01f,
  -4.66087401e-01f, -1.91536903e-01f, 1.34770736e-01f, 3.71551812e-02f, -6.52264282e-02f, -2.63919711e-01f, -6.54469943e-04f, 1.02865733e-01f, -4.57628183e-02f, 6.09047040e-02f,
  1.16938561e-01f, 6.59664795e-02f, -5.23146279e-02f, 3.55101705e-01f, 2.40914270e-01f, 2.66369209e-02f, 2.37837926e-01f, -6.31614253e-02f, -3.37981701e-01f, 2.12635845e-02f,
  1.49429858e-01f, -1.22602090e-01f, -3.36014330e-02f, -3.44138145e-02f, -8.58209133e-02f, 9.45835840e-03f, 3.59030336e-01f, 1.92974404e-01f, -3.13216299e-02f, -6.90669008e-03f,
  -1.84682041e-01f, 2.51436234e-01f, 4.17041257e-02f, 4.66541499e-02f, 5.77073246e-02f, -1.36662573e-01f, 2.70097554e-01f, -3.66608828e-01f, 1.01381727e-02f, 4.53404970e-02f,
  1.23828195e-01f, -9.57461670e-02f, 2.60922104e-01f, 1.52577952e-01f, 5.05637228e-01f, 1.42282456e-01f, 1.28734156e-01f, -1.31023273e-01f, 1.60220042e-01f, 2.56750118e-02f,
  -5.74408546e-02f, -6.44762740e-02f, 1.15567699e-01f, 1.99996963e-01f, -2.88698985e-03f, -9.85830352e-02f, -5.92100881e-02f, -2.14434534e-01f, -1.63396478e-01f, -9.27168503e-02f,
  -2.25340858e-01f, -3.17080081e-01f, -5.01343869e-02f, -3.74706984e-01f, 2.63791203e-01f, -8.37639123e-02f, -8.95005241e-02f, -8.74992386e-02f, -9.81171727e-02f, 4.09605652e-01f,
  -2.11978197e-01f, -2.08269283e-01f, -9.55213010e-02f, 8.67467374e-02f, 2.51587033e-01f, 2.45273829e-01f, 2.23991409e-01f, 3.56555432e-01f, 1.51755378e-01f, 2.71353275e-01f,
  1.61320686e-01f, 1.37743384e-01f, -4.42595631e-02f, -1.43546820e-01f, 4.73212041e-02f, 1.45797446e-01f, -2.27228552e-02f, -2.91501898e-02f, 6.68071734e-04f, -1.06350593e-01f,
  -1.30929202e-01f, 6.49832711e-02f, -1.33455962e-01f, -9.03619174e-03f, -2.14766469e-02f, 1.67681396e-01f, 1.72224477e-01f, -1.06028663e-02f, 1.34686098e-01f, -1.38486117e-01f,
  4.37697113e-01f, 2.97227502e-01f, 8.63866881e-02f, -1.96283422e-02f, 4.51404899e-02f, -1.75503213e-02f, 2.27374539e-01f, 4.08414826e-02f, 2.94215262e-01f, -7.64767975e-02f,
  9.40562412e-02f, 2.96582133e-01f, 2.90456563e-01f, -1.57020867e-01f, -2.43060961e-01f, 6.36517853e-02f, 1.31512150e-01f, 4.35375720e-02f, -1.11113116e-01f, -5.73227704e-02f,
  -1.68139711e-02f, -8.40115100e-02f, 1.18025512e-01f, 2.39654809e-01f, 4.92308527e-01f, -5.13637066e-01f, 1.15073128e-02f, -2.57399857e-01f, -3.08544248e-01f, -7.84466416e-02f,
  2.93109063e-02f, 1.06454305e-01f, -1.78422242e-01f, 2.34229505e-01f, 4.02689241e-02f, 1.40294060e-01f, -1.34243637e-01f, 1.19991958e-01f
};

// L4_linear_B (Shape: 1 x 12)
const int L4_linear_B_rows = 1;
const int L4_linear_B_cols = 12;
const float L4_linear_B_data[] = {
  -1.88450351e-01f, -1.65665448e-01f, -9.21878442e-02f, 1.57485664e-01f, 7.09129870e-02f, -7.32909441e-02f, -1.15652889e-01f, 9.27208588e-02f, 4.27480154e-02f, 3.97863612e-02f,
  5.87669536e-02f, 1.76867127e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 6, 52
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        64, 6, 52
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        64, 6, 52
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L3_fan_Wp_data, L3_fan_Wp_bar_data, L3_fan_Bp_bar_data,
        64, 6, 52
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 4: L4_linear
    linear_forward_pgm(
        buffer1, x_out,
        L4_linear_W_data, L4_linear_B_data,
        64, 12
    );
    }
    