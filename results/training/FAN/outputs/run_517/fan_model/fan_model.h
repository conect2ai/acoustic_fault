/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 64 (x4)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 64;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    return (x > 0.0f) ? x : 0.0f;
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 6 x 120)
const int L0_fan_Wp_rows = 6;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  6.61786040e-03f, 1.23259380e-01f, -1.75738961e-01f, -1.56894594e-01f, 1.46651983e-01f, -5.01521723e-03f, -1.56363711e-01f, 1.20352335e-01f, -5.76199815e-02f, -1.79456137e-02f,
  5.69854155e-02f, -6.36318401e-02f, -6.25496134e-02f, -1.46212112e-02f, -1.63331375e-01f, -3.46372388e-02f, -1.01485185e-01f, -7.99085647e-02f, 4.36434746e-02f, 2.94513293e-02f,
  -1.71478149e-02f, -1.62405930e-02f, -1.69198573e-01f, 1.51624128e-01f, -4.19212915e-02f, 1.10786790e-02f, -4.54774499e-02f, -3.86371370e-03f, 6.70381170e-03f, 5.33558019e-02f,
  -4.63312194e-02f, 9.69144180e-02f, -1.74797997e-02f, 9.53799263e-02f, -6.07526898e-02f, 7.47825997e-03f, -7.98798725e-02f, -1.55241331e-02f, -1.81700010e-02f, 4.38678190e-02f,
  3.40151936e-02f, 2.38334499e-02f, 7.10393712e-02f, 1.18400110e-02f, -1.08972173e-02f, 2.63894126e-02f, 6.63386881e-02f, -2.82854289e-02f, -3.34970132e-02f, -4.75254767e-02f,
  3.63503508e-02f, 1.25952093e-02f, -9.50637609e-02f, 5.81260212e-02f, 5.24539016e-02f, -5.73243834e-02f, -7.15456456e-02f, -2.31064875e-02f, 2.27393731e-02f, 7.00922385e-02f,
  -1.14597636e-03f, -9.68041737e-03f, -6.48399116e-03f, 2.06026752e-02f, 1.80214494e-02f, -2.83678938e-02f, 3.88722867e-02f, -1.92586835e-02f, -3.07030249e-02f, -1.75066572e-02f,
  2.56953891e-02f, -1.85756367e-02f, 6.09785207e-02f, -6.95291981e-02f, 1.94808263e-02f, -7.57314116e-02f, -6.78082407e-02f, 2.48034876e-02f, 4.38744947e-02f, -6.00502603e-02f,
  -4.07793745e-02f, 1.80715956e-02f, -2.14343425e-02f, 2.69416533e-02f, 1.58973616e-02f, -5.43386750e-02f, -2.85596084e-02f, -5.77559434e-02f, -8.76220688e-02f, -8.09733793e-02f,
  1.13388471e-01f, 7.35378787e-02f, 3.76705825e-02f, 9.99490619e-02f, -5.16011342e-02f, -4.43401039e-02f, -7.08935931e-02f, 4.13272455e-02f, 5.44057079e-02f, 6.07398450e-02f,
  1.99422203e-02f, 3.29528525e-02f, 2.07488332e-03f, -1.39657035e-02f, -6.00378215e-02f, 3.33169475e-02f, -7.43252272e-03f, 1.50888264e-02f, -1.33351805e-02f, -2.02824902e-02f,
  -3.05486564e-03f, 1.12630561e-01f, 7.16755688e-02f, 7.10098594e-02f, -7.00113177e-03f, 6.26406744e-02f, -1.31077962e-02f, -9.84321628e-03f, 9.37394351e-02f, -6.33492470e-02f,
  -1.90946519e-01f, -1.33110330e-01f, 1.09116472e-01f, -9.57255512e-02f, -5.61379567e-02f, -1.61263064e-01f, 2.91406382e-02f, -5.32077514e-02f, -5.76012880e-02f, -1.24169402e-01f,
  -5.21425866e-02f, 5.23570292e-02f, 1.55547917e-01f, -6.01625852e-02f, 6.86249435e-02f, 1.18744098e-01f, -1.18779607e-01f, -9.18105543e-02f, 2.60381736e-02f, 2.80104391e-03f,
  -3.28730084e-02f, -4.07748707e-02f, 8.51207897e-02f, 2.86966152e-02f, -1.40446723e-01f, -4.91658151e-02f, -8.26491192e-02f, 6.42617568e-02f, -8.12917128e-02f, 9.75489616e-02f,
  -1.36856794e-01f, 1.45353307e-03f, 1.66612118e-02f, -1.78729501e-02f, 1.74128152e-02f, -3.45594287e-02f, -2.56933291e-02f, 1.57767072e-01f, 4.55088057e-02f, -4.41340804e-02f,
  4.17472944e-02f, -4.47228812e-02f, 1.02068149e-01f, 9.34204310e-02f, -3.46533470e-02f, 4.74115424e-02f, -1.23074781e-02f, 1.14377029e-02f, 4.06500436e-02f, 4.54058945e-02f,
  -3.79572762e-03f, 8.51456672e-02f, -5.75663373e-02f, 2.03704350e-02f, -3.66230756e-02f, 5.99045902e-02f, 2.68886499e-02f, 7.04745576e-02f, -1.64431985e-02f, 5.43573778e-03f,
  1.19697668e-01f, -2.80118287e-02f, -1.63768679e-02f, 1.00614801e-02f, -7.98872337e-02f, 9.42095220e-02f, -5.34610171e-03f, 4.62340601e-02f, -8.24974254e-02f, -1.40712500e-01f,
  -4.16457886e-03f, -1.09894527e-02f, 2.49819459e-05f, -9.35568064e-02f, -1.02244787e-01f, -6.17557112e-03f, 9.93353948e-02f, 1.23306317e-02f, 4.21585478e-02f, -9.82402861e-02f,
  4.65137837e-03f, 9.28562731e-05f, -5.58860414e-02f, -7.08260238e-02f, -5.67783974e-02f, -1.25255287e-02f, -5.00769690e-02f, 5.99345490e-02f, 5.38433669e-03f, 5.64963631e-02f,
  -1.15285128e-01f, -1.92175671e-01f, -2.86288969e-02f, -4.98588122e-02f, -3.03590745e-02f, -7.83966631e-02f, 1.84526332e-02f, 5.26192673e-02f, -1.07512645e-01f, 7.97038525e-02f,
  4.95270500e-03f, -4.36944142e-02f, 1.29179452e-02f, -5.54193370e-02f, 5.24428152e-02f, -5.64765334e-02f, -9.73035172e-02f, 3.99898924e-02f, -9.45771039e-02f, -5.44482395e-02f,
  8.20536315e-02f, 7.53864944e-02f, 4.08798717e-02f, -8.94420147e-02f, 7.98011646e-02f, -5.90995438e-02f, -1.17664633e-03f, 9.70264897e-04f, -2.92425249e-02f, 1.51282665e-03f,
  -1.08992517e-01f, 1.77308366e-01f, -1.99940279e-01f, -3.13558131e-02f, -2.33510837e-01f, -5.08671775e-02f, -4.35061418e-02f, 9.56216455e-03f, -7.15755820e-02f, 2.06665426e-01f,
  6.74160421e-02f, -9.20227095e-02f, 1.44580647e-01f, 1.04745708e-01f, 1.77073386e-03f, 1.70890465e-01f, 6.98719844e-02f, -1.06830411e-02f, 4.31258790e-02f, 1.22181475e-01f,
  -2.97129918e-02f, 9.51201916e-02f, -2.55157575e-02f, 5.77940419e-02f, -1.07254118e-01f, -5.79285156e-03f, 5.14952280e-02f, -1.36121824e-01f, -1.50727537e-02f, -5.54527827e-02f,
  -8.51180181e-02f, 6.77476823e-02f, 2.51273364e-02f, 6.80919588e-02f, 4.31873687e-02f, -3.96705791e-02f, -1.76834166e-02f, -7.90209249e-02f, -5.77820390e-02f, 4.09504436e-02f,
  -1.99538493e-03f, -1.50379501e-02f, 1.08047938e-02f, 2.10273266e-02f, -3.73318233e-02f, -2.67588738e-02f, 2.58402079e-02f, -2.68633496e-02f, -7.01373965e-02f, -8.64719376e-02f,
  5.34582362e-02f, -6.32080948e-03f, -1.70674291e-03f, -2.04886775e-02f, -4.23130654e-02f, -7.06814369e-03f, -1.29758297e-02f, 5.87431807e-03f, 1.52965693e-03f, -5.36988489e-02f,
  5.25173731e-02f, 1.41560743e-02f, -2.39671040e-02f, -5.75181097e-02f, 2.44294591e-02f, -2.55244896e-02f, 5.17425463e-02f, -1.49146970e-02f, -3.15712541e-02f, 1.16751129e-02f,
  -6.06944114e-02f, 2.86436547e-02f, -1.98580977e-03f, 1.85326505e-02f, 5.33689596e-02f, -1.19411796e-02f, -6.74040839e-02f, -2.88299080e-02f, -4.82277721e-02f, 1.78954955e-02f,
  5.55962790e-03f, -5.88874556e-02f, -1.65352877e-03f, -1.15316659e-01f, -2.65462492e-02f, 5.92514500e-02f, 6.93999827e-02f, -3.07870228e-02f, 3.04501206e-02f, 1.65436249e-02f,
  9.93201137e-02f, 2.11055711e-01f, -1.24857398e-02f, -2.00754236e-02f, -3.15311626e-02f, -1.65280141e-02f, 5.26273362e-02f, 1.19738821e-02f, -1.19796896e-03f, -1.31614348e-02f,
  -1.86104346e-02f, -3.14058103e-02f, 5.27571514e-02f, -5.74137904e-02f, 5.42488433e-02f, 6.08410574e-02f, 5.88094778e-02f, 8.94121602e-02f, 8.73770565e-02f, 2.94441059e-02f,
  8.33113678e-03f, 6.96581602e-02f, -3.94730307e-02f, 6.46535084e-02f, -4.43552621e-02f, -6.08874187e-02f, 1.34372106e-02f, -7.04144239e-02f, -6.42545754e-04f, 1.82623826e-02f,
  1.64623097e-01f, -4.04287986e-02f, 1.24778047e-01f, -1.51971862e-01f, -7.47081190e-02f, 6.17118515e-02f, 1.05249576e-01f, -4.46567945e-02f, 6.46552145e-02f, -1.21018790e-01f,
  -9.73550379e-02f, 2.41144463e-01f, -1.10565228e-02f, -2.01302737e-01f, 1.99646428e-01f, -4.05646674e-02f, -1.28680423e-01f, -2.61874609e-02f, 7.89387822e-02f, -4.99955676e-02f,
  -2.23823879e-02f, -2.34390900e-01f, -1.28746286e-01f, -1.31851390e-01f, 3.74098606e-02f, 1.67583991e-02f, -9.23894793e-02f, -3.38640390e-03f, -1.38732135e-01f, 7.46367425e-02f,
  -1.98510066e-02f, -8.83456543e-02f, 1.50745332e-01f, 5.03587944e-04f, 1.65696032e-02f, -1.07114110e-02f, 1.12659276e-01f, 6.10706657e-02f, 3.68032791e-02f, -1.64556000e-02f,
  1.01021029e-01f, 2.38000639e-02f, 5.84705360e-02f, -7.50758797e-02f, 4.47117686e-02f, 2.94610914e-02f, 8.42937157e-02f, -9.27564967e-03f, -5.26328832e-02f, 9.77455750e-02f,
  -6.39128983e-02f, -3.65082882e-02f, -1.46999238e-02f, -2.82033556e-03f, -2.94680968e-02f, -4.57158871e-02f, 7.51115605e-02f, 1.06570154e-01f, -3.80509086e-02f, -2.64862962e-02f,
  2.29386277e-02f, 5.72932549e-02f, -1.00465558e-01f, 5.42695187e-02f, 1.10314209e-02f, 1.74461305e-02f, 4.17165905e-02f, -5.05720861e-02f, 1.02998212e-01f, -1.66011490e-02f,
  -2.44143009e-02f, 2.82924324e-02f, -5.04697636e-02f, -7.54179573e-03f, 5.34999445e-02f, 2.64589712e-02f, 1.89201012e-02f, -5.93518391e-02f, 1.42981699e-02f, 4.01335023e-02f,
  7.34314509e-03f, -3.58741358e-02f, -3.41860056e-02f, -2.90927850e-03f, 3.99267711e-02f, 6.80917725e-02f, -1.64620485e-02f, -2.62613483e-02f, 5.85992709e-02f, -5.04730903e-02f,
  -1.11445069e-01f, -1.38086110e-01f, 1.92372175e-03f, -3.13210636e-02f, 1.43283065e-02f, 5.16950823e-02f, 7.39949420e-02f, 8.81300401e-03f, 8.52281693e-03f, -2.77423132e-02f,
  -2.19000895e-02f, -3.45152169e-02f, 7.49617955e-03f, -5.19789830e-02f, 3.39217260e-02f, -3.68122496e-02f, -1.37859043e-02f, 8.86932835e-02f, -1.01046022e-02f, 1.33933993e-02f,
  -7.09119067e-03f, -4.72650304e-03f, 2.51283757e-02f, -4.77245194e-04f, -7.95776695e-02f, 5.01290560e-02f, 8.87541287e-03f, 8.14737752e-03f, -6.55642664e-03f, 4.11297311e-04f,
  -3.16880882e-01f, 3.65190655e-01f, -8.84757563e-02f, -1.81785207e-02f, 6.16754554e-02f, 8.10311213e-02f, -1.41508460e-01f, 2.28180781e-01f, 5.14531462e-03f, 1.72188371e-01f,
  8.32608640e-02f, 7.49536231e-02f, 5.13465777e-02f, 1.23626471e-01f, -1.38710499e-01f, -7.42336810e-02f, 6.48231953e-02f, 5.39569221e-02f, -9.22737569e-02f, 1.05449572e-01f,
  -2.16709450e-02f, 3.28041017e-02f, -6.35255873e-03f, 4.68542017e-02f, 8.63616616e-02f, 2.13449281e-02f, 1.72554664e-02f, -6.51291832e-02f, 3.33035775e-02f, -1.52556668e-03f,
  -5.30134216e-02f, -5.06155081e-02f, 5.73501773e-02f, -3.30948904e-02f, 7.52329528e-02f, -1.45412507e-02f, 2.75928136e-02f, -1.36977628e-01f, -2.79140193e-03f, -3.00075971e-02f,
  -5.33726960e-02f, 4.10229042e-02f, -8.23725238e-02f, -7.91916400e-02f, 3.52380350e-02f, 4.96502593e-02f, -7.49677196e-02f, 7.95804430e-03f, 2.82857195e-02f, 2.14610510e-02f,
  -3.10661364e-02f, 4.97001633e-02f, 9.42181982e-03f, 4.95078601e-02f, 3.96804214e-02f, 5.44823855e-02f, 2.61678975e-02f, 8.11637379e-03f, 3.05061862e-02f, 8.83828476e-02f,
  -4.49081138e-02f, 1.89639423e-02f, -2.45728139e-02f, 8.98283124e-02f, 6.82456568e-02f, 7.29020536e-02f, 9.65653546e-03f, 2.77061798e-02f, -5.56539819e-02f, 5.91865778e-02f,
  6.08750270e-04f, 7.50145540e-02f, 2.26734430e-02f, -1.71555637e-03f, -1.34645710e-02f, 5.68256862e-02f, -2.31881216e-02f, -4.19577695e-02f, -3.79603319e-02f, 2.03260388e-02f,
  -3.83624621e-02f, -1.65803879e-02f, -3.49293835e-02f, -1.01685794e-02f, 9.61398985e-03f, -4.79393415e-02f, -2.78488621e-02f, -7.35486345e-03f, -2.41105799e-02f, 7.42857950e-03f,
  9.83574316e-02f, 1.38514131e-01f, -7.98355266e-02f, -5.62644936e-02f, 3.33634834e-03f, -1.59693155e-02f, -9.88542140e-02f, -3.87221836e-02f, -4.93623130e-02f, -4.50370386e-02f,
  6.38570040e-02f, 3.14832591e-02f, 6.48754835e-02f, -6.18757419e-02f, -2.09764428e-02f, 3.91330160e-02f, 4.07319218e-02f, 5.87050393e-02f, -1.61153395e-02f, 4.59507331e-02f,
  6.48702458e-02f, -4.43312600e-02f, 2.25068089e-02f, 1.94690898e-02f, -1.99824963e-02f, 1.64124072e-02f, 2.54590064e-02f, 1.21376663e-02f, -6.27460331e-02f, 1.81110203e-02f,
  1.47657081e-01f, -4.34079338e-05f, 1.92913547e-01f, 1.16445638e-01f, 1.04328871e-01f, -2.19043449e-01f, -2.56947756e-01f, 5.99751286e-02f, 5.40978946e-02f, -1.70180857e-01f,
  -3.75184119e-02f, 2.17504445e-02f, -1.41726807e-01f, -1.36465793e-02f, -4.27166075e-02f, -1.61893368e-01f, -1.35294914e-01f, -2.66790036e-02f, 1.03697643e-01f, 3.39272283e-02f,
  8.19827169e-02f, -1.76592439e-01f, 9.61137637e-02f, -3.19939852e-02f, -3.56173702e-02f, 9.62128639e-02f, -4.15935926e-02f, 9.74121392e-02f, 3.44101451e-02f, -3.48164514e-02f,
  1.10141980e-02f, -1.57951638e-02f, 1.20475337e-01f, 5.22982329e-02f, 6.62696287e-02f, -3.90068144e-02f, -2.72764303e-02f, -5.83872944e-02f, 2.45844275e-02f, 8.14996436e-02f,
  -8.63455907e-02f, -4.94423285e-02f, -7.36476155e-04f, -1.99998338e-02f, 1.54103339e-03f, -1.36898980e-02f, 2.05585361e-02f, 2.49920152e-02f, 6.35390356e-02f, 2.62316559e-02f,
  2.73068473e-02f, 4.32479829e-02f, -7.08704256e-03f, -6.83951452e-02f, -8.89648497e-03f, 2.11398955e-02f, 2.81085894e-02f, 1.19852889e-02f, 4.13918570e-02f, -6.87112361e-02f,
  -3.24026756e-02f, -1.71886273e-02f, -5.72223440e-02f, -2.48293877e-02f, -4.25663702e-02f, -1.59439631e-02f, -5.91964051e-02f, -6.76526278e-02f, -5.53868152e-03f, -9.05351788e-02f,
  -3.87980565e-02f, -8.40393081e-03f, -4.76169884e-02f, -6.55121580e-02f, -3.88054140e-02f, -5.00083230e-02f, -1.04225188e-01f, -5.85613698e-02f, 3.92029397e-02f, 9.53285173e-02f,
  -8.72938335e-03f, 2.57829344e-03f, -4.66951765e-02f, -2.73811575e-02f, -4.65788366e-03f, 1.93685479e-03f, -1.77132245e-02f, -1.28482692e-02f, 1.57476054e-03f, -1.18191345e-02f,
  -6.98625669e-02f, -1.61484405e-01f, -2.12420747e-02f, 5.66606857e-02f, -2.93945447e-02f, -7.79914036e-02f, -1.61964465e-02f, 2.86951829e-02f, 2.58798078e-02f, -8.17313641e-02f,
  -3.94469593e-03f, 4.10477072e-02f, 1.72594767e-02f, 2.38153916e-02f, 1.90696772e-02f, -1.00720808e-01f, -1.01668663e-01f, 2.02787183e-02f, -7.40586668e-02f, 1.55810220e-02f,
  -4.96062897e-02f, -4.01205719e-02f, 9.73655097e-03f, 2.60563605e-02f, -1.11930618e-04f, 3.86339091e-02f, 3.17265205e-02f, 4.62808572e-02f, -7.39724636e-02f, 1.43368477e-02f
};

// L0_fan_Wp_bar (Shape: 52 x 120)
const int L0_fan_Wp_bar_rows = 52;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -3.15648437e-01f, -8.58954899e-03f, -9.87577960e-02f, -2.05548003e-01f, -1.01717360e-01f, -1.53524175e-01f, 4.22616601e-02f, -3.89793254e-02f, 2.26784293e-02f, 3.76738012e-02f,
  2.27357242e-02f, 8.39016400e-03f, 1.18540309e-01f, 6.51427731e-03f, 2.03922987e-02f, 1.19821616e-01f, -1.09725550e-01f, 9.23864245e-02f, 7.64482692e-02f, -1.75219461e-01f,
  -2.96717938e-02f, -1.01702340e-01f, -3.10219191e-02f, -2.38216430e-01f, -1.24913931e-01f, -5.30838631e-02f, 1.24750426e-03f, 1.46707390e-02f, -1.29198879e-01f, 8.22130069e-02f,
  -2.77341545e-01f, -1.54337659e-01f, -1.33491799e-01f, -2.84090303e-02f, -8.62138495e-02f, 4.03901450e-02f, 5.27764969e-02f, -3.87594029e-02f, -9.22789797e-02f, 9.42474827e-02f,
  -4.99867601e-03f, 6.97294548e-02f, -1.22622237e-01f, -2.91973669e-02f, -1.07994825e-01f, 8.82680435e-03f, 3.27868722e-02f, -4.36819009e-02f, -7.34343603e-02f, -1.57059240e-03f,
  9.71184224e-02f, -9.00490284e-02f, -1.22543005e-02f, 1.97389294e-04f, 4.92400192e-02f, -7.53002465e-02f, -5.93307503e-02f, 1.18806856e-02f, -7.07759187e-02f, 3.44034769e-02f,
  -2.23536640e-02f, 7.76565298e-02f, 1.40329123e-01f, -6.85101002e-02f, 5.79609536e-02f, -9.92075726e-02f, 1.88819133e-02f, 3.25744376e-02f, 8.99544731e-02f, 2.06837822e-02f,
  -6.13264292e-02f, -3.86623479e-02f, -3.60561162e-02f, 5.01633286e-02f, 4.26399671e-02f, -4.25245762e-02f, -9.58217084e-02f, -1.92067418e-02f, -1.31078297e-02f, -7.77688920e-02f,
  1.94338206e-02f, -4.22853865e-02f, -6.86433837e-02f, 1.40436844e-03f, 1.98209267e-02f, 5.69174401e-02f, -5.23806475e-02f, -8.29616487e-02f, -4.61013988e-02f, -6.09581359e-02f,
  -3.84546101e-01f, -1.48863211e-01f, 5.33733033e-02f, -1.05420321e-01f, 6.25504702e-02f, -1.63486246e-02f, -9.94447153e-03f, -2.85512619e-02f, 7.42530599e-02f, 1.28590479e-03f,
  9.48584639e-03f, 9.87715926e-03f, -7.85021111e-02f, 1.00839458e-01f, 3.94014046e-02f, -2.76548751e-02f, -3.48974913e-02f, -1.07494881e-02f, -3.56149487e-02f, 8.50754604e-02f,
  -1.72894523e-02f, 4.45133150e-02f, 6.48142546e-02f, 1.24162473e-02f, -1.88866388e-02f, -5.92485117e-03f, -9.99462605e-02f, -2.26616729e-02f, 9.05485749e-02f, 1.85254421e-02f,
  -1.04587749e-01f, 1.09943099e-01f, -1.06210664e-01f, -1.96840335e-02f, -2.11873315e-02f, -1.50223404e-01f, -1.61869764e-01f, 7.45697841e-02f, 9.81980041e-02f, 1.20894052e-01f,
  -1.15631320e-01f, 5.62787615e-02f, 8.52346048e-02f, -7.84884468e-02f, -2.46374398e-01f, -5.65770641e-02f, -1.76970556e-01f, -2.10309073e-01f, -2.18723360e-02f, -2.64460351e-02f,
  -1.90246835e-01f, -2.35273823e-01f, -2.68839628e-01f, -5.34933805e-02f, -4.46596779e-02f, 1.50987348e-02f, 4.64288443e-02f, 8.91277120e-02f, -1.41063213e-01f, -5.44941425e-02f,
  -6.17182665e-02f, 1.15260452e-01f, -3.53070046e-03f, -2.05840003e-02f, -3.87979299e-02f, -6.10121004e-02f, -9.77033079e-02f, -3.21533009e-02f, -6.71746209e-02f, -3.42172123e-02f,
  2.28341687e-02f, -8.60638265e-03f, 4.29825485e-03f, 6.29212484e-02f, 1.05959903e-02f, -3.80893387e-02f, 8.68279207e-03f, 6.84079304e-02f, -8.26622471e-02f, -2.37689428e-02f,
  -1.53643470e-02f, -2.56153475e-02f, -4.07095477e-02f, 3.27633210e-02f, 1.67138968e-02f, 5.69091458e-03f, -6.23108298e-02f, -2.43471917e-02f, 1.47485351e-02f, 1.56132914e-02f,
  -7.47272233e-03f, 3.33668627e-02f, -7.84476623e-02f, -7.73386238e-03f, 7.62702152e-02f, 6.91739619e-02f, -4.88661379e-02f, -3.74708064e-02f, -3.00002769e-02f, -1.61010846e-02f,
  1.82111817e-03f, 5.74206747e-02f, -3.73463705e-03f, -2.29068212e-02f, -2.00259760e-02f, 7.21617192e-02f, -1.38882875e-01f, 6.38403837e-03f, -6.06743693e-02f, 6.26476407e-02f,
  1.01270631e-01f, 2.74577178e-02f, 4.21052538e-02f, -6.06624857e-02f, 3.48475464e-02f, -1.00277280e-02f, 4.27917652e-02f, 1.11698657e-02f, 5.42042665e-02f, -4.07075398e-02f,
  -4.91213202e-02f, 8.32575783e-02f, 2.35726871e-02f, 6.25978038e-02f, -3.60148703e-03f, -7.02180807e-03f, 7.42722973e-02f, -9.73272398e-02f, 5.43564744e-02f, -2.87379213e-02f,
  -7.52631500e-02f, 4.48121913e-02f, 3.91781107e-02f, -4.20444645e-02f, 4.63896915e-02f, 2.89196596e-02f, 6.43374696e-02f, -1.96483098e-02f, -1.20703243e-01f, 5.69953583e-04f,
  -2.27629766e-02f, -3.63828763e-02f, 4.05887254e-02f, 3.71225141e-02f, 2.82198470e-02f, -3.61507349e-02f, -6.42276183e-02f, 1.57021396e-02f, -5.94457202e-02f, -3.27471569e-02f,
  1.26355097e-01f, 1.74989522e-01f, 4.27910239e-02f, 5.15917689e-03f, 1.08367018e-01f, -9.35683250e-02f, 3.43251904e-03f, 6.05488457e-02f, 1.35343634e-02f, 2.30364874e-01f,
  -3.78802009e-02f, 1.09818906e-01f, -7.91034698e-02f, -2.08166078e-01f, -2.73668170e-01f, -1.93451539e-01f, -1.42449230e-01f, 1.09132158e-03f, -1.46747470e-01f, -1.73841901e-02f,
  -1.95122540e-01f, -2.60700226e-01f, -1.58388346e-01f, 5.93929254e-02f, 2.15997174e-01f, 1.26871064e-01f, -1.68591589e-02f, 3.94135490e-02f, 1.48927301e-01f, -1.00879431e-01f,
  4.11382206e-02f, -3.28196250e-02f, 1.29358783e-01f, 9.21031237e-02f, 4.93411627e-03f, 1.75084069e-01f, 1.31277278e-01f, 8.83418880e-03f, -2.89713666e-02f, 2.50207912e-02f,
  4.46981303e-02f, 5.37661510e-03f, -5.46999872e-02f, -1.94886159e-02f, -4.44168039e-03f, 5.88172860e-02f, -8.42040405e-03f, 7.12986141e-02f, -1.20271780e-02f, 1.04748160e-02f,
  5.21487296e-02f, 2.20633857e-02f, 4.77997437e-02f, 6.63532764e-02f, -3.32984067e-02f, -3.25524211e-02f, -1.15646049e-01f, 5.28097115e-02f, 1.27736377e-02f, 1.96759608e-02f,
  4.69433516e-02f, 6.42482862e-02f, -3.67062129e-02f, -7.56489933e-02f, -8.67619291e-02f, 2.66028903e-02f, -1.19186871e-01f, 6.45757541e-02f, 3.79918814e-02f, 2.52553094e-02f,
  4.09379080e-02f, -2.85445759e-03f, -7.38131180e-02f, 1.07782304e-01f, -3.48401777e-02f, -7.49688968e-02f, 1.33469030e-01f, 4.57043201e-02f, 1.52026711e-03f, -3.88569608e-02f,
  -3.54616642e-02f, 2.87021697e-03f, 6.49945885e-02f, 6.31258786e-02f, -8.88085738e-03f, 1.38583444e-02f, -2.74898037e-02f, -7.36807659e-03f, 3.91601920e-02f, -4.60303053e-02f,
  -8.49138871e-02f, -2.59514395e-02f, -2.52340222e-03f, 2.78499140e-03f, -2.58763810e-03f, 3.80163975e-02f, 4.69225310e-02f, 1.00264437e-01f, -1.15815997e-02f, 4.67596315e-02f,
  1.43317893e-01f, 7.32744262e-02f, 9.28546190e-02f, -2.17958260e-02f, 5.34696020e-02f, -9.26452950e-02f, -6.47297734e-03f, 8.09629485e-02f, -3.05664204e-02f, 3.92955467e-02f,
  -2.40580253e-02f, -5.75436056e-02f, -3.25689279e-03f, 3.87433469e-02f, 2.25472189e-02f, 4.83815372e-02f, 8.22668374e-02f, 7.74493515e-02f, -3.26336026e-02f, -9.79906842e-02f,
  -3.45253646e-01f, 2.27537885e-01f, -6.62678108e-02f, -1.33871838e-01f, 9.15383846e-02f, -1.20737389e-01f, 6.96349815e-02f, -7.70723373e-02f, 5.20510152e-02f, 8.87747779e-02f,
  -1.10405639e-01f, -4.62206407e-03f, 1.17368467e-01f, 6.18618540e-02f, -1.89522296e-01f, 8.29598382e-02f, -7.94930384e-02f, -1.44293189e-01f, 6.53729811e-02f, 1.58777907e-02f,
  -2.02353355e-02f, -4.69224826e-02f, -1.52595013e-01f, 1.37908101e-01f, -3.16252038e-02f, -9.77561995e-02f, -2.71006338e-02f, 5.53501546e-02f, -9.18832049e-02f, -4.15846221e-02f,
  -2.04043865e-01f, -1.09186649e-01f, -6.52713850e-02f, -4.35343105e-03f, -8.60705748e-02f, -3.95856127e-02f, -1.07235625e-01f, -4.91288863e-02f, -5.62782511e-02f, -6.35603964e-02f,
  1.31296944e-02f, -4.55403365e-02f, -8.66432767e-03f, 6.82304129e-02f, -4.86867353e-02f, 3.72427665e-02f, 1.41682355e-02f, 5.17809242e-02f, -1.42853856e-01f, -2.75965296e-02f,
  -5.10959104e-02f, -2.90949084e-02f, -2.63290815e-02f, 4.73414548e-02f, 4.65532653e-02f, -3.31451185e-02f, -8.51960629e-02f, 5.90246394e-02f, -3.41540165e-02f, -6.90632463e-02f,
  5.24219610e-02f, -7.38189071e-02f, 8.55416507e-02f, 3.66326161e-02f, -5.44337183e-02f, 2.35450547e-02f, 7.23547488e-02f, -1.99624598e-02f, 2.68238429e-02f, -1.26439566e-02f,
  7.44979829e-02f, 3.73542979e-02f, 5.34567283e-03f, -6.03972003e-02f, -9.24477167e-03f, 9.29448847e-03f, 6.09601550e-02f, 2.36711372e-02f, -5.43118790e-02f, 8.58914629e-02f,
  1.79574912e-04f, 1.10873580e-01f, 8.37404430e-02f, 8.96726400e-02f, 2.03444622e-02f, -4.32770886e-02f, 2.13818252e-02f, -1.53255146e-02f, 1.43734645e-03f, -4.72608246e-02f,
  -5.59624806e-02f, -7.31196329e-02f, -9.19606835e-02f, -3.80260944e-02f, -6.42822534e-02f, -1.23781405e-01f, -6.00799993e-02f, 8.00557658e-02f, 4.93516251e-02f, -4.71770577e-02f,
  -7.18947574e-02f, 1.09313298e-02f, -4.26555574e-02f, 2.03562975e-02f, 6.75539374e-02f, -1.29587397e-01f, -4.09914143e-02f, -1.01631985e-03f, -6.00343049e-02f, -1.23241387e-01f,
  -6.39070272e-02f, -1.66133756e-03f, -1.10424694e-03f, 3.79771926e-02f, 3.39726321e-02f, -8.22581947e-02f, 1.44317662e-02f, -5.19386344e-02f, 6.13391437e-02f, -6.39614090e-02f,
  -7.88570493e-02f, -1.22560568e-01f, -7.31905848e-02f, 1.18310399e-01f, 1.31442055e-01f, -7.70133138e-02f, -3.13447118e-01f, 7.38917217e-02f, -1.39304474e-01f, -1.84825018e-01f,
  -4.57483009e-02f, 1.55303031e-01f, -3.09203625e-01f, 1.41526446e-01f, 1.94336370e-01f, -6.83205426e-02f, 2.15472192e-01f, 1.29847340e-02f, 6.62075430e-02f, 7.08358288e-02f,
  2.21545830e-01f, 3.00967336e-01f, 4.00032103e-02f, 1.17001414e-01f, 1.08197510e-01f, 7.18576014e-02f, 1.68001652e-01f, -1.72911540e-01f, 1.92806512e-01f, 5.90048917e-02f,
  -1.02699427e-02f, 1.13830082e-01f, 4.00357507e-03f, 2.61656102e-02f, -6.34036362e-02f, 3.26042771e-02f, 2.24047601e-02f, -3.99276055e-02f, -2.79184729e-02f, -1.27891824e-01f,
  6.25183582e-02f, 1.05055250e-01f, 6.22342490e-02f, 9.09918919e-02f, -2.10012705e-03f, 7.47030005e-02f, 4.40167859e-02f, -7.96572194e-02f, -2.35571004e-02f, -4.19276878e-02f,
  -1.75849535e-02f, -5.50236255e-02f, -7.82362223e-02f, -5.76917529e-02f, 4.33841012e-02f, -1.86236165e-02f, -2.60657780e-02f, 4.46418859e-02f, 8.58583003e-02f, -4.94216196e-03f,
  3.59621532e-02f, 6.74188361e-02f, -7.59418979e-02f, -2.48771103e-04f, -7.37071559e-02f, 6.06106110e-02f, -3.10225990e-02f, 9.33265127e-03f, -3.77213135e-02f, -1.80521626e-02f,
  -2.28916444e-02f, 6.35950360e-04f, -4.50740196e-02f, -3.66700515e-02f, 5.98111674e-02f, -4.50580455e-02f, 6.83271140e-02f, 4.57514003e-02f, 8.72862786e-02f, -4.07535695e-02f,
  2.18130834e-02f, -6.23441376e-02f, -5.08639775e-02f, -7.81276263e-03f, -8.91503170e-02f, -4.03021276e-02f, 3.12297996e-02f, -4.82478105e-02f, -7.24992529e-02f, -9.68268234e-03f,
  1.33765033e-02f, 4.03173305e-02f, -9.86136943e-02f, -2.50779092e-02f, 1.94213726e-02f, 6.25879876e-03f, 1.68451872e-02f, 3.01433913e-02f, 4.35287394e-02f, 7.29361735e-03f,
  -1.96273923e-02f, 3.03206015e-02f, 1.63984280e-02f, 4.42252122e-02f, 1.19104758e-01f, -6.69824108e-02f, -1.23619325e-02f, 7.97756538e-02f, 5.67339398e-02f, -9.75742121e-04f,
  2.76970193e-02f, -6.27896637e-02f, 9.93421599e-02f, -1.05518334e-01f, 6.76282123e-02f, -6.14649951e-02f, -5.40813338e-03f, 9.74576455e-03f, 4.21197563e-02f, -2.49971505e-02f,
  -2.71476060e-02f, -6.75795376e-02f, -1.60764679e-01f, -7.68822730e-02f, -6.06984980e-02f, 2.51991041e-02f, -1.25505805e-01f, -1.86964139e-01f, -1.47849739e-01f, 3.51415388e-02f,
  -1.25896737e-01f, -9.88783836e-02f, 2.71325130e-02f, -1.11636911e-02f, 1.12200014e-01f, 1.50025979e-01f, -5.67420572e-02f, -5.36038056e-02f, 4.07879837e-02f, -4.11919206e-02f,
  3.09037790e-02f, 9.16379765e-02f, 1.32573307e-01f, 8.72882232e-02f, -9.84583795e-02f, -4.51562367e-02f, 2.69043050e-03f, -1.83897708e-02f, -6.70225546e-02f, -1.19653605e-01f,
  -8.85098800e-02f, -9.46652293e-02f, -3.79121415e-02f, 2.16809139e-02f, -3.90259959e-02f, -5.53830378e-02f, -5.48657924e-02f, -4.21423726e-02f, 5.64912222e-02f, 1.73097905e-02f,
  -6.96041584e-02f, -9.66273099e-02f, -6.36637881e-02f, 5.65160699e-02f, 1.13738701e-02f, 1.45743461e-02f, 6.31554723e-02f, -8.95007625e-02f, -8.04029219e-03f, 3.11047304e-02f,
  -2.05085203e-02f, 1.32295629e-02f, 2.56741215e-02f, 3.46660800e-02f, -7.84619153e-02f, -6.35358468e-02f, -2.60884184e-02f, -1.23884253e-01f, 3.75312753e-02f, -6.11396059e-02f,
  9.18828100e-02f, -1.13139063e-01f, -1.44916428e-02f, -7.85424840e-03f, -1.54776759e-02f, 7.07393810e-02f, -4.24462147e-02f, -4.28136513e-02f, 1.34000614e-01f, 8.84762853e-02f,
  1.08593985e-01f, -6.31057918e-02f, -1.18987635e-01f, -3.19426209e-02f, 1.26155496e-01f, 2.93267630e-02f, 4.55603302e-02f, 3.90100628e-02f, 6.14184327e-02f, -3.18635181e-02f,
  -1.24700619e-02f, -4.60726582e-03f, -2.07844097e-02f, -6.77578673e-02f, -7.95362741e-02f, 1.05099387e-01f, -4.87949550e-02f, -1.64622199e-02f, 5.09618409e-02f, -7.16817454e-02f,
  -5.78509830e-02f, -1.05167799e-01f, -9.29408297e-02f, -9.57883149e-02f, 4.75905240e-02f, -7.51914680e-02f, 4.70045023e-02f, -4.33852933e-02f, -4.75795232e-02f, -2.16754694e-02f,
  -1.17690235e-01f, -6.36170991e-03f, 3.73587832e-02f, 8.03541467e-02f, 7.21715987e-02f, -7.30997846e-02f, 9.61329043e-03f, -4.89167906e-02f, 2.21108105e-02f, -7.24122599e-02f,
  -5.89544587e-02f, 5.60160652e-02f, 6.95403740e-02f, -8.07089210e-02f, 6.70906752e-02f, -2.31445804e-02f, -1.37231082e-01f, 6.85456544e-02f, 2.70539448e-02f, -1.36927078e-02f,
  -7.99571276e-02f, 3.03322040e-02f, 4.03318554e-02f, 4.47620600e-02f, -4.98017855e-02f, -2.73759693e-01f, -1.91758871e-01f, 1.24439098e-01f, -7.27650672e-02f, 3.25575285e-02f,
  3.19868810e-02f, -1.08580738e-02f, 5.83656244e-02f, 5.77525869e-02f, 6.31586835e-02f, -5.04079238e-02f, 4.00542840e-02f, 4.01527761e-03f, 5.37626445e-02f, 2.54639369e-02f,
  1.05538286e-01f, -1.00878589e-02f, 6.30089194e-02f, 4.21918444e-02f, 1.16564650e-02f, 1.16367154e-01f, 1.79784134e-01f, 7.95343369e-02f, -1.02606777e-03f, 5.59098162e-02f,
  -1.21021785e-01f, 1.50702536e-01f, 5.44058494e-02f, -1.01553343e-01f, 7.85180628e-02f, -8.78992025e-03f, -7.01706484e-02f, -1.54554155e-02f, -3.13098952e-02f, 4.80035469e-02f,
  -1.10767204e-02f, 2.69152923e-03f, 2.29521133e-02f, -8.32255632e-02f, -5.73527776e-02f, 7.11014569e-02f, 3.29276286e-02f, 2.07991675e-02f, -1.67690683e-02f, 3.39203551e-02f,
  4.03118022e-02f, 1.03412382e-01f, 6.46831915e-02f, 4.04561982e-02f, 6.00974541e-03f, 3.15986127e-02f, 1.23577667e-02f, -5.64518608e-02f, 3.30606066e-02f, -1.59457121e-02f,
  5.82004897e-02f, 1.76357832e-02f, -1.39260450e-02f, 3.96696925e-02f, -6.23107143e-02f, 7.66590908e-02f, -1.78893760e-03f, 3.23549360e-02f, -3.59146157e-03f, 3.23228687e-02f,
  -2.87063187e-04f, 3.05229332e-02f, 2.63840221e-02f, 3.97514664e-02f, 7.12130666e-02f, 7.25933909e-02f, -5.89671396e-02f, 4.79603782e-02f, -1.16068311e-01f, -8.94846320e-02f,
  4.28208970e-02f, 1.80920772e-02f, -4.02973332e-02f, -4.33061905e-02f, 7.77336359e-02f, 6.72475770e-02f, -4.39279713e-02f, -2.78391689e-02f, 2.80862506e-02f, 1.37542551e-02f,
  8.88906941e-02f, 2.42507994e-01f, -8.45131371e-03f, -1.97574757e-02f, 1.44393565e-02f, -6.35139123e-02f, -6.58570183e-03f, 6.72421455e-02f, 6.36745840e-02f, -6.07240153e-03f,
  9.74957794e-02f, -7.00720549e-02f, -1.05150938e-01f, -8.97729248e-02f, 5.90368398e-02f, 2.13295016e-02f, 2.69360282e-02f, -1.03201799e-01f, -6.89273551e-02f, 4.65264283e-02f,
  2.61049327e-02f, -7.47330859e-02f, 6.01647533e-02f, -1.35991856e-01f, -8.20877552e-02f, -5.02348281e-02f, 4.59860228e-02f, -8.56860653e-02f, 1.11835606e-01f, 9.19151306e-02f,
  1.80639178e-01f, -2.49948606e-01f, 7.21603408e-02f, 1.98092058e-01f, 2.04978779e-01f, 8.08069929e-02f, 1.96148485e-01f, 7.60909766e-02f, 1.73864186e-01f, -1.03367351e-01f,
  -5.22440635e-02f, -1.14261232e-01f, -7.53102526e-02f, -1.95120201e-02f, 1.59205452e-01f, -7.62417614e-02f, 2.58881208e-02f, -1.20077871e-01f, 7.28109553e-02f, -1.13779902e-02f,
  -6.14439957e-02f, -6.20915294e-02f, 4.86470796e-02f, -3.22350711e-02f, 1.03456207e-01f, 4.29413132e-02f, -1.57743603e-01f, 5.14093824e-02f, -7.86285996e-02f, -1.24970861e-01f,
  -7.56318644e-02f, -2.91497875e-02f, -1.64739251e-01f, -1.21845752e-01f, -5.17654698e-03f, -1.02648273e-01f, -2.57873014e-02f, -3.36049423e-02f, 1.25893474e-01f, -9.67417844e-03f,
  -1.12648886e-02f, 4.44632247e-02f, 4.55483459e-02f, -8.65647644e-02f, -1.33506125e-02f, -1.05466945e-02f, 6.63169548e-02f, 3.64560336e-02f, -4.50902656e-02f, -6.68022409e-02f,
  -4.48314436e-02f, -7.86596462e-02f, -5.98477498e-02f, -1.45662606e-01f, -3.11757857e-03f, 1.07827850e-01f, -5.27134128e-02f, -1.02235377e-01f, -2.75537539e-02f, -1.14256896e-01f,
  -8.98477882e-02f, 4.56324033e-03f, 1.64850634e-02f, 2.95034647e-02f, 9.55274478e-02f, 3.84388566e-02f, 8.10570121e-02f, 2.56034452e-03f, -2.26874407e-02f, -5.87979108e-02f,
  6.02048412e-02f, 7.87604675e-02f, -1.96984243e-02f, 2.31883004e-02f, 3.38060558e-02f, -3.13465297e-03f, -1.10759676e-01f, 3.04647125e-02f, -1.28799397e-02f, 5.95377982e-02f,
  8.33489746e-02f, 7.63228675e-03f, 7.35324025e-02f, 1.25277013e-01f, -1.15476601e-01f, 5.39078452e-02f, -6.52800575e-02f, -4.56142090e-02f, -5.41608743e-02f, 4.87933531e-02f,
  8.82605463e-03f, -1.09621443e-01f, -4.97970395e-02f, -5.20708747e-02f, 1.22293187e-02f, 1.77237783e-02f, 2.39691101e-02f, 1.41762504e-02f, 4.25710492e-02f, 2.25197822e-02f,
  -1.33460267e-02f, 2.25516744e-02f, 9.99032240e-03f, 6.91287890e-02f, -4.67065200e-02f, 5.83606511e-02f, 6.16563149e-02f, 1.08441925e-02f, 2.92258151e-03f, -9.27986018e-03f,
  9.48587433e-02f, 9.63466018e-02f, -1.47964247e-02f, -6.82001412e-02f, -6.57687560e-02f, 2.19013265e-04f, -2.89548468e-03f, -7.79601140e-03f, -1.27226517e-01f, 6.85203299e-02f,
  1.50916070e-01f, 3.16840738e-01f, 8.31796750e-02f, 1.29443258e-01f, 5.53119481e-02f, 1.29354373e-01f, 2.23527461e-01f, 1.10720456e-01f, 2.60996044e-01f, -1.94960572e-02f,
  -9.37940329e-02f, -1.97915994e-02f, 4.43927906e-02f, 1.76409222e-02f, 7.94162601e-03f, 3.26083079e-02f, 2.21699983e-01f, 1.09803416e-02f, 2.33338829e-02f, -8.77674576e-03f,
  -3.09452321e-02f, 2.61689574e-02f, -7.22845718e-02f, 2.53803153e-02f, -1.72771085e-02f, 6.80751428e-02f, 1.92410406e-02f, -7.08790869e-02f, -1.45672649e-01f, 3.27673107e-02f,
  -3.47448252e-02f, 3.43197174e-02f, -1.29483610e-01f, -5.05030304e-02f, 5.21491608e-03f, 1.47849480e-02f, -5.47702126e-02f, 4.54354919e-02f, -1.30950846e-02f, -2.23251469e-02f,
  -7.35518858e-02f, 9.87321045e-03f, -1.12374546e-02f, -7.24938959e-02f, 1.13847643e-01f, 8.16935599e-02f, -3.28951180e-02f, -5.91843762e-02f, -1.89010091e-02f, 2.51451880e-03f,
  8.73815268e-02f, -1.39348265e-02f, 2.47678980e-02f, 9.45385545e-02f, 3.84342484e-02f, 1.05024584e-01f, 8.47846866e-02f, -1.62390564e-02f, -6.37341812e-02f, 9.01350677e-02f,
  1.40252709e-03f, 8.12235177e-02f, 5.80292791e-02f, 7.87577555e-02f, -9.17828232e-02f, -5.41903637e-02f, -5.68104303e-03f, -1.11603491e-01f, 1.24002928e-02f, 7.65345469e-02f,
  -1.17791116e-01f, 1.07403599e-01f, 3.00439410e-02f, -4.20960486e-02f, -6.19153343e-02f, -4.09375392e-02f, 2.02140510e-02f, 9.33451131e-02f, 5.77250347e-02f, -2.34836200e-03f,
  -6.89330697e-02f, -8.07303041e-02f, -3.15664895e-02f, 4.39807847e-02f, 7.70776048e-02f, -1.17515558e-02f, -5.38988225e-02f, -3.14515047e-02f, -3.29361041e-03f, -8.06981996e-02f,
  1.04852207e-01f, 2.53447354e-01f, 1.08092446e-02f, 1.93305425e-02f, 6.20010011e-02f, -3.00035123e-02f, -2.80798543e-02f, 7.66987652e-02f, 1.34343401e-01f, -4.31545032e-03f,
  1.03780910e-01f, 4.72304784e-02f, 1.17157228e-01f, 5.41714616e-02f, 3.15533206e-02f, 5.84579632e-02f, 1.20188855e-01f, -6.06011488e-02f, 7.09305331e-02f, -9.16124955e-02f,
  -3.87405269e-02f, -4.15351056e-02f, 3.35749015e-02f, 8.26259106e-02f, 5.73372561e-03f, -9.40716937e-02f, -1.70415379e-02f, 1.08409293e-01f, 5.74570447e-02f, 5.15858456e-03f,
  1.29826114e-01f, 2.12713573e-02f, -8.85338262e-02f, -9.21180546e-02f, -2.06715599e-01f, 1.74939454e-01f, 2.25057587e-01f, -1.03815287e-01f, 1.56819355e-02f, 1.96990166e-02f,
  6.30639568e-02f, -8.23402777e-03f, 9.88629088e-02f, 1.58045217e-01f, 3.81755158e-02f, 2.48300031e-01f, 4.87932861e-02f, 1.00614741e-01f, 2.12980490e-02f, 6.43763095e-02f,
  -5.68013154e-02f, 7.79724419e-02f, 5.66339381e-02f, -1.15484655e-01f, 7.99487308e-02f, -1.53289184e-01f, -1.66742295e-01f, 7.16017708e-02f, -1.65615082e-01f, -9.44010019e-02f,
  -2.38630679e-02f, 7.37036243e-02f, 2.46310756e-02f, 4.06944714e-02f, 3.54526006e-02f, 3.23817618e-02f, 2.07384210e-02f, -3.47961299e-02f, -3.91096696e-02f, 1.39387161e-03f,
  5.60024194e-02f, 4.00580391e-02f, 2.87610572e-02f, -7.82853663e-02f, -5.04952148e-02f, -2.51639578e-02f, -5.63503355e-02f, 5.84128611e-02f, -6.51231706e-02f, -5.01396209e-02f,
  -4.41247523e-02f, 9.49438959e-02f, 1.32663295e-01f, -8.69697519e-03f, -6.52957410e-02f, -7.97523782e-02f, 4.10896651e-02f, -9.23990831e-03f, -2.05737893e-02f, 8.35668109e-03f,
  6.96859211e-02f, 4.91941758e-02f, 4.08911929e-02f, 7.90857524e-03f, 5.81239797e-02f, -1.24084065e-02f, -5.02157472e-02f, -1.72814075e-02f, -3.19649801e-02f, 6.22433797e-03f,
  4.66944091e-02f, -8.30674395e-02f, 3.94215919e-02f, -7.34476522e-02f, 4.43231799e-02f, -3.56239378e-02f, 7.81208603e-03f, -1.31167676e-02f, 3.44195068e-02f, 7.16738552e-02f,
  -4.90819439e-02f, -1.84445246e-03f, 4.56817076e-03f, -1.13633238e-01f, -5.89517169e-02f, -1.34822475e-02f, 7.06851808e-03f, 2.05011182e-02f, -2.89511215e-02f, 5.80083616e-02f,
  1.39035424e-02f, 1.04359485e-01f, 1.14686623e-01f, 6.91804439e-02f, 9.77441762e-03f, -7.45878965e-02f, 4.44740653e-02f, 6.62777051e-02f, -1.97767261e-02f, 1.32063806e-01f,
  -7.52086043e-02f, 3.08588501e-02f, -8.83014947e-02f, -5.76243289e-02f, -9.43125784e-02f, -1.37035638e-01f, -1.95664633e-02f, 1.31878927e-02f, 1.06910029e-02f, 1.00627048e-02f,
  -3.73889618e-02f, 1.68028828e-02f, 2.80287787e-02f, -4.84378636e-02f, -1.42115075e-02f, 7.56563917e-02f, 4.79530394e-02f, 8.14467296e-02f, -1.12811804e-01f, 8.31406862e-02f,
  -2.11926401e-01f, -2.37086594e-01f, -5.75279258e-02f, -1.24087922e-01f, 2.10605651e-01f, 1.25566766e-01f, 1.42623603e-01f, -2.93678306e-02f, -1.87530056e-01f, 8.45935270e-02f,
  1.57446876e-01f, -1.60454080e-01f, 2.34292311e-04f, -2.50204802e-01f, -2.47632369e-01f, -2.06214339e-01f, -9.01148841e-02f, -1.15471117e-01f, -1.16421603e-01f, 9.62630808e-02f,
  -8.54960158e-02f, -7.61129409e-02f, -1.78444311e-01f, 4.34507914e-02f, 9.65983123e-02f, 4.42966819e-02f, 2.10307553e-01f, 7.36255571e-02f, 1.06288753e-01f, -1.10273197e-01f,
  1.22770006e-02f, 9.27981436e-02f, -2.82157063e-02f, -8.41987785e-03f, 7.93049634e-02f, 7.22887516e-02f, 5.18608727e-02f, 2.74196900e-02f, 1.97853968e-02f, 4.08852212e-02f,
  1.87082887e-01f, 3.41813825e-02f, 2.20827814e-02f, -9.04753506e-02f, 8.19572620e-03f, -6.78392947e-02f, -3.48416828e-02f, 4.48581763e-02f, 5.37596047e-02f, -5.90842217e-02f,
  4.89174463e-02f, 6.65184632e-02f, -6.16600253e-02f, -1.33233637e-01f, -1.01641737e-01f, -5.67950346e-02f, -3.82805541e-02f, 9.17309895e-02f, 1.31078973e-01f, -1.88605059e-02f,
  -3.84455584e-02f, 1.28371879e-01f, -2.01528016e-02f, -2.34988555e-02f, -5.81058227e-02f, 6.47699926e-04f, 4.06064801e-02f, -6.95420727e-02f, -1.75489429e-02f, -1.87367275e-02f,
  6.39039725e-02f, -8.03023800e-02f, -3.00616045e-02f, -4.47367541e-02f, -1.27216965e-01f, -2.65415236e-02f, 3.84531394e-02f, 7.03708678e-02f, 6.27068952e-02f, 2.63684895e-02f,
  2.41285823e-02f, -4.20132615e-02f, -2.67542079e-02f, 3.10253259e-02f, 1.73339620e-01f, -3.83239649e-02f, 8.70947819e-03f, -8.13560039e-02f, -6.70561641e-02f, 9.30063799e-02f,
  -1.43829035e-02f, 7.15082362e-02f, -3.59074138e-02f, 1.91987082e-02f, 4.64044400e-02f, 5.75121939e-02f, 2.64009200e-02f, -2.52362471e-02f, -2.08554324e-02f, -3.29175591e-02f,
  3.89820896e-02f, -7.23546743e-02f, 1.23341620e-01f, -1.14087872e-01f, 8.67302641e-02f, 6.14131019e-02f, 3.67854461e-02f, -1.30167063e-02f, -1.83586255e-02f, 8.40781778e-02f,
  3.27920243e-02f, 9.74491984e-02f, -8.56005847e-02f, 4.72506620e-02f, 4.94854860e-02f, 3.75741497e-02f, -4.43144925e-02f, 1.97710488e-02f, 5.82951754e-02f, -3.73044722e-02f,
  -3.47230494e-01f, -3.70014110e-03f, -1.21758066e-01f, -1.54913530e-01f, 1.45323984e-02f, -7.74979889e-02f, 5.20206019e-02f, -2.74335742e-02f, 2.37165652e-02f, 1.37750015e-01f,
  1.39033154e-01f, -2.08834216e-01f, 6.41697347e-02f, -2.77171470e-02f, -1.84840187e-01f, -1.01429880e-01f, -1.67410001e-01f, 2.51460019e-02f, -1.33399054e-01f, -1.33946672e-01f,
  -1.84519619e-01f, -6.32204935e-02f, -1.51060894e-01f, -1.20403618e-02f, 1.83896832e-02f, -6.45852387e-02f, 4.65912037e-02f, 3.81479450e-02f, -8.32211375e-02f, -6.74144402e-02f,
  -1.30386710e-01f, -8.41850713e-02f, -2.04070844e-02f, -1.00423239e-01f, 5.81888994e-03f, 3.46027361e-03f, 3.18180025e-02f, 6.81889728e-02f, -7.69272968e-02f, -3.06257010e-02f,
  -6.08900823e-02f, -1.21321715e-02f, -2.51950300e-03f, -2.94854827e-02f, -9.74717364e-03f, 1.00339063e-01f, -5.83878309e-02f, 9.53743979e-03f, -1.10802129e-02f, -3.46726365e-02f,
  -2.06560269e-02f, -8.68509561e-02f, 4.07070555e-02f, 1.66060235e-02f, 4.14677933e-02f, 9.93292481e-02f, 9.23125539e-03f, -1.91013496e-02f, -8.74744430e-02f, -2.05767937e-02f,
  -5.42385019e-02f, 5.79306819e-02f, 5.85477275e-04f, 4.86489274e-02f, 6.76416308e-02f, 2.95538679e-02f, 2.07338277e-02f, -6.31634286e-03f, -2.38212775e-02f, 4.25054170e-02f,
  -7.16525540e-02f, -4.13731150e-02f, 6.36419579e-02f, 3.29135396e-02f, 8.69329125e-02f, 4.96922359e-02f, 3.83717753e-02f, 5.78793623e-02f, 2.11559199e-02f, 5.01059592e-02f,
  5.24974167e-02f, 2.02015135e-02f, 2.09713001e-02f, 3.99972647e-02f, 1.06560681e-02f, -1.49768377e-02f, -2.60782242e-02f, 8.67791399e-02f, 7.72435497e-03f, 4.43404447e-03f,
  -2.88854353e-02f, 2.56092325e-02f, 6.04874082e-02f, 7.04016462e-02f, 4.36082147e-02f, 2.54145246e-02f, -2.95532066e-02f, -5.52513935e-02f, 3.57136130e-03f, 5.66275679e-02f,
  5.57667203e-02f, 2.99867243e-02f, -1.02827661e-01f, -9.50035825e-02f, 5.28376475e-02f, 7.67076015e-02f, 5.96346706e-02f, -7.45199397e-02f, 1.29085435e-02f, -1.96347944e-03f,
  8.57847407e-02f, -8.08647182e-03f, -6.96121082e-02f, -4.21373770e-02f, -5.82374558e-02f, 7.70459175e-02f, -2.13274360e-02f, 2.40652319e-02f, -1.01064540e-01f, -1.00200623e-02f,
  1.95424467e-01f, 1.13759041e-01f, 6.96907192e-02f, 2.13124931e-01f, -3.03083789e-02f, 1.26649916e-01f, 1.62184015e-02f, -2.45350990e-02f, 1.78135738e-01f, -1.04317265e-02f,
  -3.00056133e-02f, 9.64207351e-02f, -5.33066280e-02f, 1.31765500e-01f, -8.06777328e-02f, -1.82639025e-02f, 9.58049074e-02f, -2.28244551e-02f, 2.96221841e-02f, 2.20039859e-01f,
  5.55986576e-02f, -2.95785069e-02f, -8.55237171e-02f, 5.49996458e-03f, -1.17413793e-02f, 1.07723497e-01f, -2.06255153e-01f, -2.28638932e-01f, -1.21160127e-01f, -8.60617459e-02f,
  -5.38445003e-02f, 6.82541355e-02f, 1.13102968e-03f, 7.30410516e-02f, 1.60598122e-02f, 4.96477224e-02f, -1.25690401e-01f, -7.31988475e-02f, -6.08065836e-02f, 6.12619892e-02f,
  1.02740377e-01f, 5.54472432e-02f, 1.40879363e-01f, -1.54685872e-02f, 1.75467134e-02f, 2.80038435e-02f, 6.52713478e-02f, -2.93890424e-02f, 1.59232935e-03f, -2.81901546e-02f,
  3.78430858e-02f, 2.95547284e-02f, 1.03901461e-01f, -6.39005229e-02f, 8.32688361e-02f, -2.08329130e-03f, 1.67619679e-02f, -1.04224965e-01f, -1.87838580e-02f, -2.98053212e-02f,
  -8.58448520e-02f, 2.21413858e-02f, -3.02299000e-02f, -4.48938273e-02f, 2.93609798e-02f, -6.16101138e-02f, 7.80856535e-02f, 7.55135268e-02f, 1.12060318e-02f, 4.98401187e-03f,
  -1.72242650e-03f, -1.07587092e-01f, 4.60650250e-02f, 5.89939989e-02f, 9.84965116e-02f, 3.22782919e-02f, 3.19203846e-02f, 5.59475198e-02f, -6.78390414e-02f, -6.71866611e-02f,
  -1.79595314e-02f, 3.95235419e-02f, 4.07834314e-02f, -1.52990390e-02f, 3.17078084e-02f, 7.83264413e-02f, -3.38733010e-02f, 3.34293172e-02f, 4.71709557e-02f, -9.36777703e-03f,
  -3.70076299e-02f, 2.97004767e-02f, -2.47511528e-02f, 4.27504778e-02f, 6.38332888e-02f, -1.75444447e-02f, -3.78126353e-02f, 1.10236943e-01f, -5.51257692e-02f, 8.33895504e-02f,
  1.15882568e-02f, 9.04267468e-03f, 6.32730573e-02f, -7.33422413e-02f, -9.88411903e-03f, 6.01852164e-02f, -8.61493573e-02f, 3.93240061e-03f, -1.09925076e-01f, 4.99775261e-02f,
  -8.15046430e-02f, 5.54806106e-02f, -6.88401684e-02f, 2.24272627e-02f, 1.86356492e-02f, -1.24761209e-01f, 1.27400488e-01f, -6.83253780e-02f, -4.52750968e-03f, 2.60191821e-02f,
  -2.69692093e-01f, 7.21941516e-02f, 1.82243079e-01f, -1.69323027e-01f, -1.66987665e-02f, -1.77658513e-01f, -1.95618302e-01f, 1.49751380e-01f, 1.02991134e-01f, 8.77959430e-02f,
  5.69658317e-02f, -3.73899080e-02f, 1.22756645e-01f, -1.42109707e-01f, -1.90140203e-01f, -5.29119596e-02f, -1.74634069e-01f, -1.45751953e-01f, -4.85715568e-02f, -6.32039458e-02f,
  -9.13776308e-02f, -8.75749961e-02f, -2.75822263e-02f, 1.09816216e-01f, -5.19460812e-02f, 4.49892953e-02f, -1.10440329e-01f, 1.26531243e-01f, -2.87288893e-02f, 5.48044182e-02f,
  5.43222912e-02f, 1.58361271e-01f, 4.57842695e-03f, 3.95127460e-02f, 7.08681066e-03f, -9.33078378e-02f, -1.01140305e-01f, -4.28685471e-02f, -4.52137180e-02f, 3.04910950e-02f,
  -3.54687311e-02f, -1.47217112e-02f, -2.88594123e-02f, -2.46070307e-02f, 5.11356145e-02f, 8.85446593e-02f, 2.03579776e-02f, 1.24479709e-02f, -2.22507715e-02f, 4.22307439e-02f,
  1.35048047e-01f, -6.73574582e-02f, -6.35381863e-02f, -9.90760028e-02f, -2.35650931e-02f, 4.12227996e-02f, -1.12253405e-01f, -2.20955033e-02f, -9.61692706e-02f, 2.60333084e-02f,
  4.60738735e-03f, 1.76948053e-03f, 7.76083544e-02f, 1.00519501e-01f, -1.29582454e-02f, 2.00269977e-03f, 2.41021849e-02f, 3.87839973e-02f, -8.47925339e-03f, 5.39458133e-02f,
  -7.93466195e-02f, -6.95159584e-02f, -3.24398801e-02f, -1.08843938e-01f, 2.08678823e-02f, 4.55100052e-02f, -1.42594531e-01f, -4.39875238e-02f, -1.45505294e-01f, -2.61963215e-02f,
  7.89699927e-02f, -7.37952143e-02f, 2.45413035e-02f, -2.72687804e-02f, 3.38281058e-02f, -1.02321450e-02f, -9.42741800e-03f, -5.04654385e-02f, 3.71656120e-02f, 4.70966883e-02f,
  6.00152984e-02f, 2.16955934e-02f, 1.20470710e-01f, -4.88645909e-03f, 1.19620331e-01f, -1.15536721e-02f, -2.75347359e-03f, -8.55562836e-03f, 4.42776978e-02f, 5.80845587e-02f,
  1.61621366e-02f, -9.70208123e-02f, -7.52803683e-02f, -4.28873254e-03f, -7.12185502e-02f, 1.17556788e-02f, 1.51116150e-02f, -8.91312808e-02f, -2.96100862e-02f, 9.61957127e-02f,
  -3.03753521e-02f, -6.06849976e-02f, -3.31725925e-02f, -7.36698450e-04f, -1.10965166e-02f, 3.23079415e-02f, -5.33549711e-02f, -2.00639050e-02f, -9.41220447e-02f, -8.53118822e-02f,
  9.99451652e-02f, -3.85425650e-02f, 1.18748084e-01f, 2.08722446e-02f, 1.45820960e-01f, 7.30861574e-02f, 2.42718562e-01f, -1.87234566e-01f, 6.23665489e-02f, -1.61341637e-01f,
  1.55384233e-02f, 2.87441723e-02f, 1.80736974e-01f, -1.45930439e-01f, 1.66063726e-01f, 1.48764506e-01f, -6.51695803e-02f, 2.48835739e-02f, -4.00103927e-02f, -3.49060958e-03f,
  4.11835052e-02f, -1.93218425e-01f, -3.75740938e-02f, -2.54816204e-01f, -6.82231486e-02f, -9.33075845e-02f, -6.01761751e-02f, 1.76822878e-02f, -7.53808394e-02f, 8.10536593e-02f,
  7.27770701e-02f, -1.49997910e-02f, -3.21013853e-02f, 3.63880917e-02f, 8.18441901e-03f, -9.28502679e-02f, 2.10284665e-02f, 7.57240504e-02f, -8.82150233e-03f, -3.38017792e-02f,
  4.75975014e-02f, 5.54414690e-02f, -4.12924625e-02f, -3.33059393e-02f, 1.77511142e-03f, -9.39588100e-02f, 7.51626566e-02f, 2.77968105e-02f, -5.29989824e-02f, 6.66615963e-02f,
  1.02111427e-02f, 7.67244771e-02f, 1.93924159e-02f, 5.76328428e-04f, 6.84001073e-02f, -1.07000060e-02f, 3.03909611e-02f, 2.91335769e-02f, 4.01134118e-02f, 1.97194889e-02f,
  -9.13190022e-02f, 7.07153007e-02f, -3.94098759e-02f, 4.37285230e-02f, -3.39263752e-02f, -5.26938289e-02f, 2.71431915e-02f, 4.19174917e-02f, 7.72803556e-03f, 4.53059794e-03f,
  2.69001294e-02f, -7.30675682e-02f, 6.14210218e-03f, 3.79575267e-02f, -3.13684978e-02f, 5.53783178e-02f, -5.52932173e-02f, 3.93593013e-02f, -7.29155093e-02f, 6.25648424e-02f,
  -1.00048132e-01f, 7.53418282e-02f, -1.89943090e-02f, -3.95960286e-02f, -1.25025557e-02f, 8.42957478e-03f, -3.65036279e-02f, -7.18540400e-02f, -5.62724832e-04f, 3.69590409e-02f,
  7.39625320e-02f, 6.23240657e-02f, 5.56783155e-02f, 3.48461568e-02f, 5.22622690e-02f, 3.51626729e-03f, 4.79254760e-02f, -4.73706126e-02f, 5.60135990e-02f, -5.36277927e-02f,
  -3.39430869e-02f, -1.45204170e-02f, -2.50791926e-02f, 1.22360419e-02f, -2.07422078e-02f, -1.25044614e-01f, 1.02228098e-01f, 4.82244566e-02f, 7.31605142e-02f, -6.60551265e-02f,
  -3.09552159e-02f, 3.83335017e-02f, 2.65558921e-02f, -1.09394327e-01f, 1.58567298e-02f, -1.72016192e-02f, 5.57265468e-02f, 7.50110671e-02f, -8.18114355e-02f, -6.00548135e-03f,
  -1.17719844e-01f, 3.73962253e-01f, 1.58311985e-02f, 1.99616313e-01f, -1.08443469e-01f, 2.04015866e-01f, 2.59072781e-01f, 2.43696272e-02f, 1.85437933e-01f, 2.27964789e-01f,
  3.91410366e-02f, 2.88592372e-02f, 9.02321413e-02f, 1.09502308e-01f, 5.43093458e-02f, 2.36132503e-01f, 2.07787350e-01f, 1.08714379e-01f, 5.95755577e-02f, 1.17430568e-01f,
  6.59728646e-02f, 5.13884462e-02f, 7.86751434e-02f, 5.76955229e-02f, -7.47337788e-02f, -1.32456928e-01f, -5.16553558e-02f, -9.42512006e-02f, -3.65454108e-02f, -5.47636487e-03f,
  9.66282096e-03f, 1.43927876e-02f, -6.23598769e-02f, -5.09495400e-02f, 9.20035038e-03f, -7.37482309e-02f, 4.48395722e-02f, -2.17817090e-02f, 2.24490534e-03f, -2.13036966e-02f,
  -1.13724373e-01f, -6.08660169e-02f, 4.77802157e-02f, 2.16243360e-02f, 6.28404468e-02f, 7.31216930e-03f, 1.25675043e-02f, -5.96089177e-02f, 4.88172695e-02f, -1.78073794e-02f,
  1.95674896e-02f, -5.65495603e-02f, -3.93860899e-02f, 1.03255607e-01f, -1.16564274e-01f, 2.41096374e-02f, 9.98313203e-02f, -5.49301058e-02f, -6.06567115e-02f, -2.72462536e-02f,
  1.45346038e-02f, -8.83348212e-02f, 1.14409486e-02f, -3.17586660e-02f, 7.74120390e-02f, 1.39854820e-02f, 5.89016899e-02f, -3.68224941e-02f, -8.89765918e-02f, 7.28321075e-02f,
  -6.19022697e-02f, -4.04865630e-02f, -4.07880805e-02f, 1.31747108e-02f, 1.22417659e-02f, 5.93766645e-02f, -3.52012850e-02f, 2.00189650e-02f, 4.70708087e-02f, -5.82826175e-02f,
  1.19849980e-01f, 9.86782834e-02f, -4.50083353e-02f, 1.09577641e-01f, 2.49588117e-02f, -4.50375974e-02f, 7.17799813e-02f, -7.17872456e-02f, 2.00931542e-02f, -1.18625641e-01f,
  1.15542218e-01f, 2.72163093e-01f, -6.78509995e-02f, -1.97370071e-02f, 1.04391664e-01f, -2.67406683e-02f, 5.44218346e-02f, -4.36436012e-02f, 1.05482340e-01f, 4.27416898e-02f,
  -8.49931017e-02f, 1.13700246e-02f, 2.33600941e-03f, -1.00308113e-01f, 1.09924003e-01f, 8.02088305e-02f, 6.32826313e-02f, 5.41809388e-02f, 7.90788094e-04f, -4.43580411e-02f,
  -8.17463547e-02f, 7.01185316e-02f, 2.36438750e-03f, -2.16210950e-02f, 3.46236788e-02f, -5.52851819e-02f, 9.78145972e-02f, -5.68482699e-03f, 4.27883305e-03f, 2.33274624e-02f,
  2.27821246e-01f, 1.36645973e-01f, 2.29462326e-01f, 1.44406542e-01f, -1.83495763e-03f, -4.47005443e-02f, -2.01660618e-01f, 6.25819340e-02f, 2.72406548e-01f, 4.62334193e-02f,
  5.00610135e-02f, 7.00732097e-02f, -8.23604986e-02f, 7.40752369e-02f, -2.12367043e-01f, -1.68828338e-01f, -9.79174897e-02f, -4.82494617e-03f, 6.25925735e-02f, -4.34633112e-04f,
  -1.22756273e-01f, -3.15599293e-01f, -1.95692912e-01f, -7.22650439e-02f, 1.68872029e-01f, -2.19917912e-02f, -2.83811122e-01f, -1.39166415e-01f, -5.18931933e-02f, -1.25733927e-01f,
  -2.37714760e-02f, 7.03041255e-02f, 8.72661099e-02f, 5.17380163e-02f, -4.19981815e-02f, -2.26061940e-02f, 1.32459858e-02f, -1.07503891e-01f, -4.35817130e-02f, -4.53189053e-02f,
  -1.17788084e-01f, 1.57709431e-03f, 9.36249569e-02f, 6.69572689e-03f, 1.44387092e-02f, 3.44396159e-02f, 9.23174471e-02f, 9.66394320e-02f, -2.57680584e-02f, -5.78170046e-02f,
  1.49341494e-01f, -3.14489454e-02f, 9.16267782e-02f, -7.69001171e-02f, 3.36268055e-03f, 1.34623408e-01f, 4.54488909e-03f, -1.37529634e-02f, -5.37126558e-03f, 7.43050547e-03f,
  -7.29980171e-02f, -6.38777018e-02f, 7.01539516e-02f, -3.25316526e-02f, 6.33114204e-02f, 3.87777910e-02f, 6.05833493e-02f, -8.63365643e-03f, 4.72145807e-03f, 2.04231665e-02f,
  7.66327307e-02f, 3.72291282e-02f, 1.91375483e-02f, 5.13103306e-02f, 4.56407443e-02f, 9.35430452e-02f, 2.72066183e-02f, 4.90605012e-02f, -7.30618238e-02f, 9.32343155e-02f,
  8.16349015e-02f, -1.37963500e-02f, 1.03871420e-01f, 3.91865559e-02f, 9.11896955e-03f, 7.66729936e-03f, 7.34907687e-02f, 8.45725685e-02f, 6.19039983e-02f, -7.64752179e-02f,
  2.96482723e-02f, -2.10778385e-01f, -1.74915306e-02f, 3.95953134e-02f, 5.21043614e-02f, 1.13132723e-01f, 5.65654226e-02f, 1.06097698e-01f, -1.13895610e-01f, -4.40265387e-02f,
  4.47866246e-02f, -6.36593178e-02f, 7.69515336e-02f, 8.75068828e-02f, 1.04569336e-02f, 2.93996138e-03f, -1.92570597e-01f, -9.99022871e-02f, 1.10315147e-03f, 3.99362221e-02f,
  -8.52739736e-02f, 7.03085512e-02f, -2.76831109e-02f, -1.16953842e-01f, 2.05936097e-02f, -1.01933599e-01f, -7.38655683e-03f, 5.04326448e-03f, -6.11123219e-02f, -5.43563738e-02f,
  2.48390391e-01f, -2.26098746e-02f, -1.16209546e-02f, 1.88214034e-01f, 7.50622991e-03f, 2.46659089e-02f, 1.73821881e-01f, 6.88557252e-02f, 2.43415803e-01f, -4.72551547e-02f,
  -1.25371953e-02f, 4.31663590e-03f, -9.47900712e-02f, 1.77849755e-02f, 6.48008958e-02f, -6.09688051e-02f, 1.72056183e-02f, -1.04136601e-01f, 1.07146159e-01f, -4.81176516e-03f,
  1.27805173e-01f, 6.04878925e-03f, -1.09036386e-01f, -5.46458177e-03f, 9.93023515e-02f, 5.52574657e-02f, -1.71125814e-01f, -4.50773500e-02f, -1.81788236e-01f, 1.64856052e-03f,
  6.92206398e-02f, 6.25495166e-02f, 9.27860737e-02f, -2.87839044e-02f, -5.34257591e-02f, 7.59997219e-03f, -1.14980265e-01f, -1.11204185e-01f, 5.57489544e-02f, 2.20704116e-02f,
  -4.03587148e-02f, 3.20183150e-02f, 7.23706977e-03f, -3.90233062e-02f, 1.58778548e-01f, 1.36432499e-02f, 2.19073929e-02f, -2.73861624e-02f, -2.05714181e-02f, 2.36426797e-02f,
  -9.35889333e-02f, -1.12646006e-01f, 8.81354064e-02f, -8.81090984e-02f, 9.37730372e-02f, -5.22902980e-02f, 2.56746542e-02f, -5.22331111e-02f, -3.33774951e-03f, -2.26376448e-02f,
  7.28465393e-02f, -6.76689763e-03f, 7.39353970e-02f, 2.15984918e-02f, 2.78148800e-02f, 6.17298996e-03f, -3.45437005e-02f, -8.06724802e-02f, 1.50061538e-02f, -6.42504916e-02f,
  -1.99660822e-03f, 9.58445668e-03f, -5.65611608e-02f, -1.12706356e-01f, 5.58707565e-02f, 5.66700995e-02f, -4.08783741e-02f, -6.16230220e-02f, -2.62683537e-02f, 8.64873547e-03f,
  7.10143521e-02f, 3.96310389e-02f, -7.76757821e-02f, 1.91996768e-02f, -5.16072661e-02f, -4.51172292e-02f, -7.66112506e-02f, -9.27676260e-02f, -8.83866772e-02f, -3.82156782e-02f,
  5.98749444e-02f, 1.96843711e-03f, -7.13814422e-02f, 1.15963016e-02f, -6.58654720e-02f, 4.00974900e-02f, 4.59922440e-02f, -7.95582235e-02f, 2.02533789e-02f, -2.00927742e-02f,
  4.29636054e-02f, -1.12151206e-02f, -4.98214699e-02f, 7.94029385e-02f, 8.09170380e-02f, 6.43810257e-02f, 7.93089420e-02f, 1.10666733e-03f, 2.52952073e-02f, 3.00644580e-02f,
  -6.19011410e-02f, -4.61052731e-03f, -1.61530264e-02f, -4.21289541e-02f, 8.47462285e-03f, -1.09415926e-01f, -4.46291007e-02f, 1.03772646e-02f, 3.91745195e-02f, -9.77952629e-02f,
  1.62782565e-01f, -3.93194519e-02f, 1.04252473e-01f, 1.19998075e-01f, 1.02308668e-01f, 3.83304209e-02f, 1.80863485e-01f, 2.26319637e-02f, 2.50772566e-01f, 2.82087666e-03f,
  -9.91767868e-02f, 1.05545506e-01f, 9.60301235e-02f, 8.77352282e-02f, 6.89757466e-02f, -5.11766784e-02f, 5.35965636e-02f, 6.55032843e-02f, 5.33534251e-02f, 8.20830911e-02f,
  5.24784662e-02f, 1.12819774e-02f, -1.04500316e-01f, -1.15849249e-01f, 9.23212692e-02f, -6.81190416e-02f, -6.98765740e-02f, -8.46448168e-02f, -1.86828524e-02f, -9.38369781e-02f,
  7.68026412e-02f, -2.76810653e-03f, 8.48841108e-03f, -2.87166168e-03f, 3.32382955e-02f, 2.07574014e-02f, -2.56058816e-02f, -1.52890766e-02f, -6.35415018e-02f, 1.02911361e-01f,
  4.94252592e-02f, -3.65067497e-02f, 7.72153139e-02f, 5.05061001e-02f, -2.69803591e-02f, 1.72649175e-02f, 6.92939758e-02f, 4.78609316e-02f, 5.04305810e-02f, -5.45217209e-02f,
  3.74029726e-02f, -4.05896977e-02f, 2.44622063e-02f, -1.84597857e-02f, -5.23941740e-02f, -1.17167924e-02f, 4.22750376e-02f, 3.83797549e-02f, 9.22470018e-02f, 4.36326414e-02f,
  4.49055471e-02f, 5.00053167e-02f, 1.74457319e-02f, 2.20345752e-03f, 9.90633201e-03f, 3.48654285e-04f, 5.43676764e-02f, 3.32845449e-02f, -6.47956580e-02f, 3.93118598e-02f,
  -3.27970944e-02f, 7.03122392e-02f, 5.82876243e-03f, 9.97108668e-02f, 5.89839369e-02f, -4.57187928e-02f, -2.85536367e-02f, 3.42412069e-02f, 2.07040310e-02f, 1.44993300e-02f,
  2.43094824e-02f, 7.27561116e-02f, -2.67966045e-03f, 1.05341367e-01f, 4.24428508e-02f, 6.33542687e-02f, 4.59810859e-03f, 1.03530206e-01f, -5.96481338e-02f, 8.16832259e-02f,
  3.40208499e-04f, -3.05026677e-02f, 1.13560811e-01f, -3.06089269e-03f, 8.39678198e-03f, -7.64550790e-02f, 1.32016046e-02f, -9.49103758e-03f, -3.82063887e-03f, 8.18428397e-02f,
  -9.75020975e-03f, 6.77205548e-02f, -3.93354595e-02f, -5.18103205e-02f, -5.18020913e-02f, -1.57076046e-02f, 1.07161338e-02f, -7.68668577e-02f, -5.31100631e-02f, -1.71238780e-02f,
  3.29450406e-02f, 1.00902915e-01f, 8.24199468e-02f, -4.42403518e-02f, -1.31601673e-02f, 4.13930453e-02f, -3.34633403e-02f, -6.78285435e-02f, -8.42564565e-04f, 6.20931294e-03f,
  1.15604907e-01f, 1.04188338e-01f, -1.41830936e-01f, 7.58344308e-02f, -8.47191643e-03f, -1.25620067e-01f, -5.18350415e-02f, 1.22168154e-01f, -1.76514000e-01f, 8.35715383e-02f,
  1.69567131e-02f, -1.64645035e-02f, -6.30445704e-02f, 1.16998345e-01f, -2.33308896e-02f, 4.70857602e-03f, 2.15541795e-01f, 1.05573668e-03f, 5.72197028e-02f, 2.34740853e-01f,
  9.22355205e-02f, 1.20712191e-01f, -1.27880320e-01f, 1.77050620e-01f, 1.71682075e-01f, -6.40347078e-02f, 1.89530775e-01f, 3.86275910e-02f, 1.33851364e-01f, 1.16374172e-01f,
  6.49543405e-02f, 9.02739391e-02f, 1.31535968e-02f, -1.62034612e-02f, -1.09711736e-02f, 2.76379827e-02f, 5.36185987e-02f, 1.15253292e-02f, -1.27280280e-02f, -5.58858924e-02f,
  -7.24073425e-02f, -4.73536886e-02f, -1.15575589e-01f, -9.27547514e-02f, 3.73623818e-02f, -1.39914617e-01f, -3.22577097e-02f, -2.63282992e-02f, 1.19003735e-03f, 4.23785374e-02f,
  2.09330674e-03f, -2.24410947e-02f, 4.05808426e-02f, -5.08168302e-02f, -2.24265680e-02f, -6.81606084e-02f, -9.07450542e-02f, -9.14635286e-02f, -2.56643444e-02f, -2.38297712e-02f,
  -4.18409668e-02f, 3.31343152e-02f, -1.61183104e-02f, -6.35605678e-02f, 5.64346053e-02f, 7.53990747e-03f, 5.72917610e-02f, -3.99357006e-02f, -8.68283957e-03f, 1.32208532e-02f,
  6.36199042e-02f, -7.38314167e-02f, -6.80306405e-02f, -1.40823601e-02f, -4.41203788e-02f, -6.95709744e-03f, -1.09886201e-02f, 7.31829628e-02f, 7.76193244e-03f, 4.12764251e-02f,
  1.09307133e-02f, 2.49733571e-02f, 1.17323510e-01f, 7.16538131e-02f, -1.12087823e-01f, -1.28902607e-02f, 1.29819751e-01f, 2.64554862e-02f, -8.44513103e-02f, 3.70387621e-02f,
  1.45604953e-01f, 1.46168068e-01f, -3.76585424e-02f, -3.59920114e-02f, -2.55597588e-02f, 1.28140360e-01f, 2.84976419e-02f, 1.03736766e-01f, 4.44031172e-02f, 9.06405598e-02f,
  -4.73066904e-02f, -6.44402355e-02f, -3.78019139e-02f, -7.81117938e-03f, 7.00326264e-02f, -1.29363900e-02f, -7.00248824e-03f, -7.46283680e-02f, 1.21388752e-02f, -3.59804593e-02f,
  -2.94379536e-02f, -1.03398502e-01f, -1.11906148e-01f, -4.97832745e-02f, -9.14897770e-02f, -2.54664756e-02f, 1.39223933e-02f, 8.77657980e-02f, -4.18201014e-02f, 4.82741632e-02f,
  -1.66070797e-02f, 4.47906479e-02f, -1.16129093e-01f, -1.24865942e-01f, 3.66591965e-03f, -5.32822162e-02f, -2.95191328e-03f, 1.31515160e-01f, 1.77652672e-01f, -4.18709964e-03f,
  -3.26900817e-02f, 3.09044309e-02f, 1.79718703e-01f, -1.40478939e-01f, 1.59709126e-01f, 9.71955508e-02f, -9.26011503e-02f, -1.87813416e-01f, 1.68061167e-01f, -1.43960461e-01f,
  -1.65980041e-01f, -1.86033234e-01f, -1.19099915e-01f, -3.90514284e-02f, -1.35813504e-01f, -4.50371467e-02f, -7.49006271e-02f, -8.88764933e-02f, -2.15426639e-01f, -1.20213509e-01f,
  9.97302607e-02f, 4.65850867e-02f, 5.08752726e-02f, -6.27332425e-04f, 4.04054411e-02f, -1.86367184e-02f, 2.90755765e-03f, -1.90101508e-02f, 8.76001194e-02f, 1.01006739e-02f,
  -5.03366850e-02f, -1.25144646e-01f, -6.59106001e-02f, -2.57881153e-02f, -7.18446970e-02f, 8.53993893e-02f, 1.27749490e-02f, 1.19405754e-01f, 9.50310659e-03f, 5.06900102e-02f,
  6.99172094e-02f, -1.61118619e-02f, 2.38050986e-03f, -2.63246987e-02f, 1.36692319e-02f, 5.18270284e-02f, -9.52865556e-03f, -1.36182467e-02f, -1.32947583e-02f, -2.40621231e-02f,
  7.61319697e-02f, 2.39397399e-02f, 5.82762919e-02f, 1.75138470e-02f, 1.15152068e-01f, -1.45714581e-02f, -2.52555925e-02f, -5.27025349e-02f, -8.90683755e-03f, -6.59187585e-02f,
  -4.84027388e-03f, -4.01009573e-03f, 5.69678061e-02f, 1.87946409e-02f, -1.34713337e-01f, 5.31487726e-03f, 1.60762444e-02f, -3.07012647e-02f, -4.23793793e-02f, -1.76621489e-02f,
  -7.15014860e-02f, -3.79601307e-02f, -6.07853830e-02f, -9.66022909e-02f, 8.07278380e-02f, 1.14744931e-01f, -7.07825422e-02f, -1.19456388e-01f, -3.77165782e-03f, 1.11252265e-02f,
  -4.38337736e-02f, 5.69780357e-03f, 7.61900321e-02f, 4.66672294e-02f, 2.24785060e-02f, 8.06087162e-03f, -4.79825251e-02f, -1.11312129e-01f, 1.42468689e-02f, 6.04451895e-02f,
  -1.32474229e-01f, -8.01256672e-02f, -5.83889224e-02f, 3.65165621e-02f, -1.08959340e-02f, 9.48367566e-02f, -6.60063624e-02f, 3.70528176e-02f, -5.07812761e-02f, -7.37355882e-03f,
  -9.46727693e-02f, -1.63357370e-02f, 5.52926771e-02f, -4.28352989e-02f, 6.07395321e-02f, -5.48178442e-02f, 2.48998012e-02f, 6.74383193e-02f, -1.31597016e-02f, 2.09019147e-02f,
  -3.15973014e-01f, -5.94142042e-02f, -1.63342893e-01f, -6.18911423e-02f, 5.51242977e-02f, 9.19339582e-02f, -8.84284750e-02f, 6.62577748e-02f, -2.04520017e-01f, 1.22422583e-01f,
  6.86951503e-02f, -2.92507738e-01f, 7.89686944e-03f, 1.46166608e-02f, -2.09181488e-01f, -1.66337448e-03f, 2.19960809e-02f, 9.52056795e-03f, -5.73509261e-02f, -3.05154342e-02f,
  -8.54604915e-02f, 1.81037918e-01f, 1.83289144e-02f, -8.76368396e-03f, -6.14177138e-02f, 1.15927406e-01f, 2.11702377e-01f, 1.19774276e-02f, 5.01005352e-02f, -6.52205497e-02f,
  -9.38115045e-02f, -1.14937946e-01f, -4.54267599e-02f, -9.09722596e-02f, 6.38851672e-02f, 6.39718994e-02f, 8.79132897e-02f, -5.48615530e-02f, 6.41080886e-02f, -2.84617376e-02f,
  -3.49937975e-02f, 2.12434009e-02f, 2.52277851e-02f, 2.54237186e-02f, -6.19075373e-02f, 1.43705765e-02f, -1.26151629e-02f, 5.13326265e-02f, -3.18087637e-03f, -1.60000511e-02f,
  -4.93828245e-02f, 7.37255961e-02f, 1.20618023e-01f, 8.94191340e-02f, -5.30567355e-02f, -1.90225188e-02f, 1.03340410e-01f, -9.92028862e-02f, -6.62658438e-02f, -9.39734951e-02f,
  2.29509193e-02f, -1.37060890e-02f, -5.00240587e-02f, -1.03477865e-01f, -5.74805215e-02f, 4.16172016e-03f, 1.39242169e-02f, -8.34433287e-02f, 4.41405131e-03f, -2.75698230e-02f,
  -3.92728001e-02f, -4.18156805e-03f, 1.78299807e-02f, 9.06057507e-02f, 1.44446805e-01f, 2.35371739e-02f, -8.94668102e-02f, -6.26566410e-02f, -8.22241753e-02f, -4.38643247e-02f,
  5.06100282e-02f, -5.39231859e-02f, 8.54169130e-02f, -3.53706032e-02f, 5.73502518e-02f, 1.02091674e-02f, -5.93398362e-02f, -1.35643020e-01f, -7.43534714e-02f, -7.88772255e-02f,
  1.15698442e-01f, 7.17727169e-02f, 4.16406430e-03f, -8.19098279e-02f, 2.59363838e-02f, 8.54001846e-03f, -8.86149704e-02f, -6.20431416e-02f, 1.95389949e-02f, 2.10367646e-02f,
  1.58391148e-01f, 1.01109318e-01f, 4.31364253e-02f, 7.51217157e-02f, -3.79110985e-02f, 1.37420809e-02f, 3.45657766e-02f, 5.84278367e-02f, -9.21981595e-03f, 7.14448467e-02f,
  -1.47328600e-02f, 8.52484182e-02f, 4.67547178e-02f, 1.59277078e-02f, 1.67919528e-02f, 5.44232540e-02f, 1.06825814e-01f, 8.96517485e-02f, -6.42239451e-02f, -6.14270288e-03f,
  2.91974187e-01f, 1.46362126e-01f, 1.89892724e-01f, 2.11567372e-01f, -6.96413517e-02f, -1.96623445e-01f, 5.04410379e-02f, 8.16025659e-02f, 2.79368043e-01f, -8.45741481e-02f,
  -1.04788758e-01f, 1.47451073e-01f, -1.28036961e-01f, 1.45255297e-01f, -1.32793695e-01f, -1.44521192e-01f, -2.30558105e-02f, 5.50080091e-02f, 6.62690103e-02f, 9.22354236e-02f,
  9.58357453e-02f, -1.07515231e-01f, -7.85660744e-03f, -2.00852513e-01f, 5.99461235e-02f, 1.98323622e-01f, -2.09206641e-01f, -1.03880592e-01f, 1.17704645e-01f, -2.38587499e-01f,
  6.71807677e-02f, 9.22416970e-02f, 6.85545653e-02f, -4.32436764e-02f, -5.50852120e-02f, -3.85188013e-02f, -5.93693778e-02f, -1.32461831e-01f, 1.74134411e-02f, -1.47140017e-02f,
  6.70874640e-02f, 5.64254541e-03f, 2.63687763e-02f, -4.25224751e-02f, 3.49592343e-02f, 9.91483927e-02f, 8.74039009e-02f, 1.19042926e-01f, -1.50501300e-02f, 5.56072779e-02f,
  1.34101808e-01f, 4.17100079e-02f, -2.89655551e-02f, -5.72519265e-02f, 3.21272649e-02f, 8.56967643e-02f, -6.80637062e-02f, 5.89113161e-02f, 4.58560325e-02f, -4.01037000e-02f,
  -3.93571593e-02f, -7.31387958e-02f, -7.84853920e-02f, -2.79358868e-02f, -4.43369336e-02f, 7.02864453e-02f, -8.90265927e-02f, -1.61569025e-02f, -2.65835179e-03f, 2.26678103e-02f,
  -1.67458244e-02f, 1.73617639e-02f, -2.28070077e-02f, 6.17136806e-02f, 3.27151865e-02f, 3.38660516e-02f, -6.17502667e-02f, -4.67318036e-02f, 3.72438505e-02f, 4.40545268e-02f,
  -2.94686649e-02f, -3.54634784e-03f, -5.98728023e-02f, -9.38847959e-02f, -1.65590886e-02f, -4.72897518e-04f, 4.91713881e-02f, 6.18469268e-02f, -3.93233262e-02f, -1.97698940e-02f,
  -6.26470521e-02f, 3.44660915e-02f, 2.50675734e-02f, -7.90943876e-02f, -1.24180159e-02f, -2.77434494e-02f, 4.37308997e-02f, 3.88599597e-02f, 1.67737361e-02f, -4.32747044e-02f,
  7.10671768e-02f, -1.12813130e-01f, -1.18785456e-01f, 8.80458020e-03f, -5.39200902e-02f, 1.56723913e-02f, 1.55098306e-03f, 2.50497255e-02f, 2.05781162e-02f, 1.23268925e-02f,
  8.51663761e-03f, 6.87128399e-03f, -2.55520288e-02f, 9.25080702e-02f, 7.55475312e-02f, -4.67213504e-02f, 1.33825485e-02f, 4.58465293e-02f, -2.65652500e-02f, 4.65399399e-02f,
  -7.19205514e-02f, 2.75591075e-01f, -1.53104544e-01f, 1.43817030e-02f, 5.26550710e-02f, 2.26341993e-01f, 1.44935891e-01f, -2.29469128e-02f, 1.63638413e-01f, 1.20675772e-01f,
  1.36993229e-01f, 7.97506794e-02f, -2.86514945e-02f, 2.08464861e-01f, 2.76887994e-02f, 9.69812945e-02f, 2.81812787e-01f, 1.14561178e-01f, 6.83497563e-02f, 4.53791171e-02f,
  2.69631147e-02f, 1.73090652e-01f, -2.18780965e-01f, -1.01044253e-01f, 5.48838191e-02f, -1.68623239e-01f, -1.18019447e-01f, -1.53938696e-01f, -1.15054518e-01f, 1.68310367e-02f,
  2.52422299e-02f, -2.36162916e-02f, -6.16048574e-02f, 5.96564077e-02f, -3.46296541e-02f, -4.14883206e-03f, -8.52874368e-02f, -9.74030346e-02f, -5.93432365e-03f, -3.24731059e-02f,
  -9.52708535e-03f, 3.20817828e-02f, 4.43731584e-02f, 6.86036870e-02f, -4.12064046e-02f, -2.14711633e-02f, -7.04691038e-02f, -3.73555496e-02f, -8.80300254e-02f, 1.91785563e-02f,
  -3.55400820e-03f, -2.91741025e-02f, 3.04263029e-02f, -3.92903388e-02f, 3.06647848e-02f, 4.63184863e-02f, -5.00385324e-03f, -9.12513398e-03f, 7.51335919e-02f, 7.63786882e-02f,
  -2.27875449e-02f, 8.11338350e-02f, -4.19945419e-02f, -5.20309061e-02f, -6.18319847e-02f, -3.42515670e-02f, 2.83284392e-03f, 4.93684150e-02f, -1.48201697e-02f, -2.94002071e-02f,
  5.27739152e-02f, -3.91362906e-02f, 3.65410037e-02f, -2.06421390e-02f, 6.33438006e-02f, 5.28148971e-02f, -8.17360282e-02f, 1.03222847e-01f, -7.25723291e-03f, -5.58456443e-02f,
  -4.32017706e-02f, 5.79141714e-02f, 4.00351237e-05f, -5.20619564e-02f, -4.32142578e-02f, -9.06830505e-02f, -6.15546815e-02f, 4.62006144e-02f, -6.54661208e-02f, 1.58346370e-02f,
  1.24325655e-01f, 1.61981463e-01f, -2.35571675e-02f, 5.86824529e-02f, -5.10656126e-02f, 5.27179018e-02f, 6.09360002e-02f, 8.78986642e-02f, 4.29829732e-02f, 1.01187835e-02f,
  -5.89499325e-02f, -1.72161416e-03f, 8.74435082e-02f, -6.29207939e-02f, -4.99086175e-03f, 1.72210839e-02f, 9.21959132e-02f, 3.91731970e-02f, 3.12274918e-02f, -2.12083310e-02f,
  -3.17173451e-02f, 1.89471059e-02f, 5.77793010e-02f, -6.79143220e-02f, 5.11168353e-02f, 6.35490268e-02f, -5.43641374e-02f, -3.14597785e-02f, -8.66626855e-03f, 5.21036237e-03f,
  -1.83784202e-01f, -3.76723632e-02f, -1.90314099e-01f, -3.52274030e-02f, -2.08976362e-02f, -2.34330565e-01f, -2.46632308e-01f, -8.36794078e-02f, 1.53345913e-01f, -1.58043243e-02f,
  -2.77993716e-02f, -1.31715015e-02f, 1.81332648e-01f, -1.50079265e-01f, -1.58482328e-01f, 1.13090247e-01f, -1.07050583e-01f, -7.94464201e-02f, 1.47696540e-01f, -4.33394574e-02f,
  -6.59841746e-02f, -8.18438083e-02f, -2.36452650e-02f, 1.88820027e-02f, -9.10928473e-02f, -3.68733406e-02f, -5.95365539e-02f, -9.47035402e-02f, -1.12964265e-01f, -9.07429755e-02f,
  -4.81926762e-02f, 1.42092004e-01f, 4.33938242e-02f, 8.16536099e-02f, -1.34225413e-01f, -8.83028284e-02f, 1.10531626e-02f, 4.19531167e-02f, 6.54925257e-02f, -6.15500845e-02f,
  1.10901155e-01f, 7.49418065e-02f, -1.82893500e-02f, 1.75033342e-02f, 3.11231222e-02f, 5.83460853e-02f, -3.41607481e-02f, -3.25355232e-02f, 3.30131548e-03f, 5.89336269e-02f,
  -6.29915483e-03f, 3.86189669e-02f, -1.18654212e-02f, 6.82325214e-02f, -2.87798438e-02f, 4.18753214e-02f, -6.61848783e-02f, 2.15595309e-02f, -2.78218184e-02f, -1.90261956e-02f,
  -7.75344893e-02f, -1.22533264e-02f, 3.52037139e-02f, -7.11209625e-02f, 1.35332672e-02f, -8.71597882e-03f, 2.96287443e-02f, 8.55368897e-02f, -5.96261136e-02f, 1.01413149e-02f,
  5.30391335e-02f, 3.94022949e-02f, 2.42064265e-03f, -3.36286537e-02f, -3.02636232e-02f, -2.52381060e-02f, 6.39981702e-02f, -3.16952355e-02f, 3.41723636e-02f, 3.37134264e-02f,
  1.07085690e-01f, 2.90568192e-02f, 5.49643859e-02f, 6.59017637e-02f, 6.22678138e-02f, -2.59188414e-02f, 6.58819079e-02f, -1.30532524e-02f, -1.07968496e-02f, -1.01368852e-01f,
  7.70133510e-02f, 3.39502431e-02f, 4.44238782e-02f, 2.92067472e-02f, -2.52813976e-02f, -7.17259794e-02f, 7.36649111e-02f, -3.30238976e-02f, -7.07751364e-02f, -4.47559841e-02f,
  -5.94527237e-02f, -7.42961565e-05f, -3.78649384e-02f, 1.39604406e-02f, 8.64376407e-03f, -4.18408290e-02f, 4.82732467e-02f, -8.70619901e-03f, -4.73286174e-02f, 1.17919985e-02f,
  -1.45535711e-02f, 4.54232804e-02f, 1.37776285e-02f, 9.89768207e-02f, -1.37256300e-02f, -9.53388214e-02f, 7.09758326e-02f, 3.36712189e-02f, 3.65015119e-02f, -2.54484592e-03f,
  -2.58114710e-02f, 6.51996285e-02f, 3.72154638e-02f, 1.96724966e-01f, -3.87287363e-02f, -1.29152551e-01f, -1.72045231e-01f, 7.94728175e-02f, 3.66609283e-02f, -1.00150287e-01f,
  -3.06819919e-02f, 9.63004008e-02f, -1.27199546e-01f, 2.50469327e-01f, 5.25186509e-02f, -2.05769956e-01f, 3.04582685e-01f, 1.59573890e-02f, 1.10290244e-01f, 1.25906408e-01f,
  8.02537799e-02f, 6.38235435e-02f, -4.40105386e-02f, -3.28451544e-02f, 1.07186653e-01f, 5.79159893e-02f, 1.09960839e-01f, -1.82145178e-01f, 1.76173851e-01f, 7.55084977e-02f,
  2.13774946e-02f, 5.76729812e-02f, 4.68794256e-02f, -8.02075639e-02f, -3.84538509e-02f, 5.42221740e-02f, 7.97383487e-03f, -2.61631459e-02f, 5.61962686e-02f, 1.93298627e-02f,
  4.91699837e-02f, -1.61078796e-02f, -2.50567291e-02f, -3.64392623e-02f, 3.56806479e-02f, 8.03615376e-02f, -5.38711660e-02f, 6.06740043e-02f, 5.29848710e-02f, 7.47075006e-02f,
  1.77113116e-02f, 1.52026005e-02f, 1.31930232e-01f, 1.01828882e-02f, -3.01727862e-03f, -1.90481246e-02f, 3.83222513e-02f, 4.67558280e-02f, 1.35779371e-02f, 1.14312693e-01f,
  -1.61770061e-02f, -9.85818580e-02f, -8.78780559e-02f, 4.86547053e-02f, -6.10354841e-02f, -4.07031886e-02f, -6.07019998e-02f, 2.42450293e-02f, 1.01549774e-02f, -6.57964349e-02f,
  1.19870212e-02f, 5.38012050e-02f, -6.68625906e-02f, -2.56735999e-02f, -7.17587257e-03f, -4.80935210e-03f, -6.29158467e-02f, -2.38557607e-02f, 1.54214697e-02f, 6.80790981e-03f,
  1.81548372e-02f, 4.76134531e-02f, -6.30914792e-02f, -1.66161582e-02f, 1.47052268e-02f, -1.12430798e-03f, -4.37580235e-02f, 5.67713045e-02f, 4.73644175e-02f, 3.12791206e-02f,
  6.25350401e-02f, 5.88541739e-02f, -7.26487488e-02f, 1.54138505e-02f, -6.08280934e-02f, -2.57371161e-02f, 1.30916268e-01f, 5.85189164e-02f, 5.92634827e-02f, -1.07472472e-01f,
  -7.54406443e-04f, 5.17610945e-02f, -2.37168279e-02f, -2.19839718e-03f, 4.77853604e-02f, -4.81069414e-03f, -3.87820080e-02f, -3.41500267e-02f, 1.40286535e-01f, 5.23177460e-02f,
  -5.26116341e-02f, -1.52253499e-02f, 8.04967508e-02f, -2.77404636e-02f, -2.15747650e-03f, -4.29084860e-02f, 4.68025655e-02f, -6.35994002e-02f, 1.33678749e-01f, -7.31636807e-02f,
  -2.52741158e-01f, 2.00226679e-01f, 3.31888422e-02f, -1.01093397e-01f, -2.52605192e-02f, -9.66927484e-02f, 6.68852106e-02f, 6.23753481e-02f, -9.41846892e-02f, 1.26620650e-01f,
  -7.49632046e-02f, 7.06218109e-02f, 5.25816195e-02f, -8.82466976e-03f, -2.74912953e-01f, -1.28025934e-01f, -3.89852040e-02f, -1.79827306e-03f, 2.49912608e-02f, 1.45677954e-01f,
  -8.81039947e-02f, -1.63559720e-01f, 3.94546278e-02f, 3.12741064e-02f, 2.96914764e-02f, 4.06879596e-02f, 9.56039876e-02f, 4.83368225e-02f, 1.67715792e-02f, 6.61569238e-02f,
  1.22982070e-01f, -2.50626858e-02f, 5.92143536e-02f, 9.39652771e-02f, 5.39679527e-02f, -4.77048382e-02f, -3.48663665e-02f, 2.93112360e-02f, -4.54537570e-02f, 7.35035613e-02f,
  9.31837782e-02f, -6.04462111e-03f, -7.30386889e-03f, -7.21082538e-02f, -4.37303353e-03f, 4.75306250e-02f, -1.30063575e-02f, -5.57404906e-02f, 4.49677929e-02f, -1.37191370e-01f,
  5.89410700e-02f, 3.41748856e-02f, -8.66871029e-02f, -9.47609246e-02f, -6.55065104e-02f, 6.48109093e-02f, 5.77517301e-02f, -1.90816671e-02f, 2.27869507e-02f, -6.53709322e-02f,
  3.79385166e-02f, -3.62155400e-03f, -3.67651023e-02f, 2.63644587e-02f, 2.59083021e-03f, 1.26714045e-02f, -2.07572877e-02f, 1.17125027e-02f, -2.31475886e-02f, 6.51148856e-02f,
  -2.89144441e-02f, -2.44278125e-02f, 6.44046590e-02f, 3.51780802e-02f, -4.60719988e-02f, 4.89363680e-03f, 5.30982055e-02f, 8.17790255e-02f, 2.86029316e-02f, 2.60847956e-02f,
  -7.02660829e-02f, 7.08058244e-03f, -4.21953276e-02f, 6.78622350e-02f, -5.73938005e-02f, -1.17364176e-01f, -5.52269677e-03f, -7.82631636e-02f, 6.93766028e-02f, -7.07794279e-02f,
  2.69815233e-02f, -4.04765271e-02f, -5.02502488e-04f, 5.70385531e-02f, 5.83086424e-02f, -3.75272031e-03f, 3.68673801e-02f, 9.85992998e-02f, 2.00388092e-03f, 2.17920681e-03f,
  -9.42044556e-02f, 6.73145428e-03f, -1.37157589e-01f, 4.28774729e-02f, 2.44011432e-02f, 2.87646987e-02f, 2.18301918e-02f, -5.58909364e-02f, -9.56087559e-02f, -4.40897569e-02f,
  -1.79837942e-02f, -3.70376594e-02f, -3.02737746e-02f, -2.86534522e-02f, 3.60786989e-02f, 2.75547337e-02f, -2.37805527e-02f, -2.74510384e-02f, 4.76016328e-02f, 8.17594025e-03f,
  -3.08415741e-01f, 2.29769230e-01f, 7.57891499e-03f, -1.52016133e-01f, 9.95525047e-02f, 5.76168559e-02f, -2.07404117e-03f, 2.80025192e-02f, -1.64134204e-01f, -6.26438111e-02f,
  -6.56800568e-02f, -1.11242406e-01f, 1.49455573e-02f, -1.04533173e-01f, -2.80277014e-01f, -8.27271491e-02f, -1.55797482e-01f, -9.49282348e-02f, 1.45839723e-02f, 3.80374976e-02f,
  -1.98905114e-02f, -1.29834160e-01f, 1.31832585e-02f, 1.84990987e-01f, -6.32244302e-03f, 8.30965042e-02f, -8.15418735e-02f, 1.70731917e-01f, 5.18393219e-02f, 2.31313631e-02f,
  -1.44156083e-01f, 7.06075653e-02f, -9.65604093e-03f, 4.98202704e-02f, -9.11810696e-02f, 5.12632355e-03f, 3.63340564e-02f, 4.79776785e-02f, 5.61805628e-02f, 5.24317957e-02f,
  -5.48541658e-02f, 3.91097888e-02f, -8.64239261e-02f, 7.33828619e-02f, 8.66720229e-02f, 5.16726449e-03f, 3.22125219e-02f, -5.68221547e-02f, 7.12972432e-02f, 5.28172106e-02f,
  6.34059906e-02f, 2.46621482e-02f, -1.26048587e-02f, -1.24472730e-01f, -1.26243876e-02f, 1.28178289e-02f, 5.48877753e-02f, -1.03174999e-01f, 1.12748910e-02f, -3.41496691e-02f,
  -3.67323272e-02f, -3.07189561e-02f, 3.30361314e-02f, -8.93922821e-02f, -1.56710241e-02f, 3.63496654e-02f, 1.42808433e-03f, 3.59786563e-02f, 6.20843507e-02f, 3.20389792e-02f,
  -1.04960360e-01f, -4.36788015e-02f, -3.38099450e-02f, -4.11283365e-03f, -2.66060652e-03f, 2.99285185e-02f, -5.23294508e-02f, 5.16759008e-02f, 4.57474478e-02f, 1.83596667e-02f,
  -1.08099788e-01f, 2.14942289e-03f, 6.28126785e-02f, -6.70684278e-02f, -7.06501817e-03f, 9.69972834e-02f, 2.56845411e-02f, 2.35151183e-02f, 3.07171699e-02f, 2.36700792e-02f,
  -1.42145053e-01f, -6.94227219e-02f, -1.70851722e-02f, -6.13328815e-02f, 3.58273126e-02f, -2.66677253e-02f, 6.74277768e-02f, -5.36584482e-02f, -4.00910489e-02f, -2.11907681e-02f,
  -5.71692549e-02f, 4.69597504e-02f, -9.91794765e-02f, -1.05138116e-01f, -8.93235020e-03f, -6.59068227e-02f, 2.33662166e-02f, -2.02624761e-02f, 4.01374958e-02f, 5.92303798e-02f,
  -1.91391930e-02f, 3.22141647e-02f, -3.65928225e-02f, -7.95088895e-03f, 2.14682836e-02f, -1.11456640e-01f, -4.15618997e-03f, 2.64255572e-02f, 8.09867382e-02f, 1.70166977e-02f,
  -1.73120797e-01f, 9.92381200e-02f, 6.96653500e-02f, -6.34251535e-03f, -5.34663796e-02f, -1.93005413e-01f, -1.31035089e-01f, 2.02533752e-01f, 5.43179810e-02f, -1.58310365e-02f,
  3.91857885e-02f, -7.43277296e-02f, 1.56746238e-01f, -1.50518358e-01f, -2.05431029e-01f, -3.05442736e-02f, -2.81778187e-01f, -9.98856053e-02f, -2.82672178e-02f, 8.51265267e-02f,
  -9.79861394e-02f, 4.17207042e-03f, -1.66464653e-02f, 1.26886010e-01f, 5.31965271e-02f, 1.68739110e-01f, 1.86358780e-01f, 1.47636995e-01f, 5.53688817e-02f, -1.03109919e-01f,
  -1.54759526e-01f, 6.23074397e-02f, -3.37852538e-03f, 2.96892896e-02f, -4.46544867e-03f, 4.87881117e-02f, 2.00656429e-02f, -1.60464551e-02f, 2.58761924e-02f, -7.02228844e-02f,
  -5.14350720e-02f, 1.44893667e-02f, -3.32389846e-02f, 3.10323318e-03f, -4.60960418e-02f, 5.71606942e-02f, 7.23226322e-03f, -7.67172948e-02f, -2.96925157e-02f, -9.68857557e-02f,
  -5.31725697e-02f, -5.24182580e-02f, 6.66812807e-02f, 4.62330319e-03f, 2.25929730e-03f, 8.55822191e-02f, -3.22653167e-02f, 2.98918108e-03f, 4.27666632e-03f, -2.21477095e-02f,
  -6.54360559e-03f, -2.95021711e-03f, 4.78120483e-02f, 3.35472114e-02f, -2.11811275e-03f, 1.03115536e-01f, -3.83069515e-02f, 1.44103207e-02f, -3.92236263e-02f, -8.98729311e-04f,
  5.52596338e-02f, 5.44088297e-02f, 2.42406949e-02f, 1.85863208e-02f, -3.99979297e-03f, -5.16429078e-03f, 7.70600811e-02f, 3.40474844e-02f, -6.11855313e-02f, -8.00235868e-02f,
  1.17999882e-01f, -1.78736281e-02f, -9.17020664e-02f, 2.72753071e-02f, 3.45427543e-02f, 4.64508273e-02f, 6.07348047e-02f, 3.81261595e-02f, 1.26035567e-02f, -2.38405131e-02f,
  -2.06960905e-02f, 1.76843509e-01f, 4.74814437e-02f, -5.94169497e-02f, -1.05247786e-02f, -3.25147994e-02f, -3.51531915e-02f, 1.17983564e-03f, 8.18063542e-02f, -3.19979824e-02f,
  1.49871573e-01f, 2.45415866e-02f, 1.02313468e-03f, -3.60462861e-03f, -6.17803587e-03f, -9.40595493e-02f, 1.10138692e-01f, 1.44720733e-01f, -5.00114309e-03f, 6.75362572e-02f,
  6.86079860e-02f, -3.32348682e-02f, -5.03595360e-02f, -1.82290673e-02f, 8.02088156e-03f, -2.49914080e-02f, -3.63862701e-02f, 1.37264049e-02f, -1.11487256e-02f, 5.01297154e-02f,
  -9.94843394e-02f, 8.81369859e-02f, -7.27581307e-02f, -1.68194741e-01f, 6.22188263e-02f, -1.12265281e-01f, -1.10780708e-01f, -2.81045977e-02f, 2.78906580e-02f, -4.10529599e-02f,
  5.28397330e-04f, -2.58240532e-02f, 3.31916064e-02f, -4.79058363e-02f, -1.03775509e-01f, 5.86747006e-02f, -9.70906466e-02f, -1.68286294e-01f, 1.12893447e-01f, -7.83405378e-02f,
  -1.41918182e-01f, -3.51794064e-02f, -5.38299605e-02f, 1.21143989e-01f, -1.73437353e-02f, 7.32311308e-02f, -3.22193243e-02f, 1.28192052e-01f, -6.56165108e-02f, 7.10088611e-02f,
  -1.74012795e-01f, -6.68688118e-02f, -5.51585369e-02f, -1.09865271e-01f, -7.39235058e-02f, -8.87492895e-02f, -4.20120545e-02f, -1.96187533e-02f, 1.36765074e-02f, -4.98367324e-02f,
  -1.87528157e-03f, 3.00650373e-02f, 1.03056125e-01f, 7.30180182e-03f, 5.09430431e-02f, -8.87694135e-02f, 5.04268520e-02f, -2.71651242e-02f, -6.71657249e-02f, -6.87237531e-02f,
  4.96546626e-02f, 1.01211756e-01f, -6.12741988e-03f, 2.01685298e-02f, 3.09155174e-02f, 4.03296612e-02f, 1.03806313e-02f, 3.95656265e-02f, -4.73559499e-02f, -7.79451281e-02f,
  7.98422098e-02f, 7.34704956e-02f, 9.38058570e-02f, -3.64710204e-02f, 4.54338193e-02f, 1.31899759e-01f, -9.96802822e-02f, -1.20054437e-02f, -3.23138908e-02f, -2.14532800e-02f,
  2.60110628e-02f, 3.59430686e-02f, -6.59080455e-03f, -8.20878819e-02f, -4.43660244e-02f, 4.25790995e-02f, 2.62591755e-03f, -3.38436775e-02f, 9.40351337e-02f, 4.17213328e-02f,
  -4.88015562e-02f, 5.55317476e-02f, -3.96728292e-02f, -1.72654465e-02f, 4.84359525e-02f, -6.33030459e-02f, 2.34157294e-02f, 1.14112437e-01f, -4.71862406e-02f, 4.09527458e-02f,
  -2.99505770e-01f, -3.02501153e-02f, -1.25533074e-01f, 9.91273951e-03f, -5.66838123e-02f, -1.31382030e-02f, 5.55823222e-02f, -6.05936209e-03f, -1.70956198e-02f, 1.70654675e-03f,
  6.43766066e-03f, -3.44300121e-02f, -4.09634076e-02f, -6.83998019e-02f, 6.56576008e-02f, 1.01174116e-01f, 4.59184125e-02f, -1.00439087e-01f, 1.11217769e-02f, 5.14457189e-02f,
  -3.85196768e-02f, -1.49661284e-02f, -1.60752889e-02f, 9.70318541e-02f, -1.03454515e-01f, -1.64692961e-02f, -8.42607617e-02f, 3.39502282e-02f, 4.60011661e-02f, 5.06081656e-02f,
  2.26553217e-01f, -7.42555559e-02f, 7.28402566e-03f, 1.18213996e-01f, 1.45584494e-01f, 9.30215418e-02f, 1.73838481e-01f, 1.79288730e-01f, 1.99053317e-01f, -1.53845698e-01f,
  -1.44567803e-01f, -1.37541935e-01f, -1.36942640e-01f, -4.47677560e-02f, 1.10532247e-01f, -5.39548732e-02f, 1.22790247e-01f, 5.21457463e-04f, 8.76968354e-02f, -1.45092476e-02f,
  -3.61822024e-02f, 1.55000873e-02f, -1.29379723e-02f, -6.79229423e-02f, 1.27335126e-02f, 2.41907174e-03f, 1.40007744e-02f, -7.76546123e-03f, -1.04991160e-01f, 5.19333929e-02f,
  -9.83017161e-02f, 1.15878612e-01f, -5.59075316e-03f, -9.79774594e-02f, 5.47561375e-03f, 4.09156568e-02f, 8.27882588e-02f, -6.50858600e-03f, 7.50356317e-02f, -7.12008327e-02f,
  -6.53373301e-02f, -1.13662317e-01f, 3.22129391e-02f, 3.17653380e-02f, 7.93453231e-02f, 3.08703128e-02f, 1.76521596e-02f, -2.08048164e-04f, 2.38877609e-02f, 4.51328196e-02f,
  -6.12192489e-02f, 4.68806438e-02f, -1.20185940e-02f, -1.66362729e-02f, 1.20319854e-02f, 6.14059828e-02f, -3.31615470e-02f, -8.15875456e-02f, -8.13453421e-02f, 7.06112459e-02f,
  7.87769109e-02f, 8.30666721e-02f, -1.19012527e-01f, -4.68439013e-02f, 3.18894275e-02f, 2.84586102e-02f, 3.76235656e-02f, -9.95059460e-02f, -4.89772670e-02f, -8.75456110e-02f,
  -4.78512049e-02f, -2.06114668e-02f, 3.47855389e-02f, 8.18652939e-03f, -4.10381297e-04f, 5.09221032e-02f, 3.62678319e-02f, -4.26100828e-02f, 3.05325985e-02f, 5.96742406e-02f,
  -2.38965196e-03f, 4.71074432e-02f, -7.64789805e-02f, -9.91943777e-02f, 3.56611609e-02f, 2.01481152e-02f, -2.46525593e-02f, -1.36003539e-01f, 2.95937788e-02f, -2.95653008e-02f,
  -1.79507196e-01f, 1.10357739e-01f, -1.12859987e-01f, -7.06617236e-02f, -1.63010657e-02f, -5.75556830e-02f, 6.60511032e-02f, 3.48157389e-03f, -5.57195731e-02f, -9.02893916e-02f,
  -1.16770463e-02f, -6.96461499e-02f, -3.82674970e-02f, 2.80049909e-02f, -7.96410162e-03f, -1.64785594e-01f, 1.64081864e-02f, 3.92303579e-02f, 3.64349000e-02f, -7.94430450e-02f,
  -1.30805634e-02f, -4.18422408e-02f, -1.17302528e-02f, -1.43231023e-02f, 5.06914556e-02f, -3.97666246e-02f, 3.64427380e-02f, -2.18504649e-02f, -9.64963734e-02f, 5.37159778e-02f,
  -1.34357125e-01f, 2.72473931e-01f, 2.24155542e-02f, -2.39659518e-01f, 6.81824312e-02f, -8.59565884e-02f, -1.42924413e-01f, 8.37568045e-02f, -7.40546510e-02f, -1.29462779e-01f,
  -9.14154798e-02f, -9.10506472e-02f, 1.03460848e-01f, -1.41404435e-01f, -6.09367713e-02f, 1.62901524e-02f, -8.51786137e-02f, -2.00773433e-01f, 1.29284695e-01f, -2.84000747e-02f,
  -4.46960218e-02f, -1.94476880e-02f, -2.94964208e-04f, 1.57699451e-01f, -2.91507561e-02f, -4.81899902e-02f, -1.75726280e-01f, 2.24488750e-01f, -8.57568681e-02f, -1.34120919e-02f,
  1.66105255e-02f, 1.33143319e-02f, -1.06544703e-01f, -5.04877865e-02f, -1.13797761e-01f, -3.16663682e-02f, -1.00175500e-01f, 4.77836132e-02f, 3.21489177e-03f, 2.91597620e-02f,
  -4.85078245e-02f, 3.33710201e-02f, 6.27064481e-02f, 5.67367710e-02f, -7.11277872e-02f, -2.60529388e-02f, 4.29793075e-02f, 3.84237505e-02f, 3.78994010e-02f, 4.70773391e-02f,
  1.32672727e-01f, 2.73529696e-03f, -3.92707810e-02f, -1.44805685e-01f, 6.43580630e-02f, -1.39569156e-02f, 8.91207531e-02f, -8.73966888e-02f, -5.11709563e-02f, -1.96552705e-02f,
  -2.81345099e-02f, -8.94194767e-02f, -3.30823846e-02f, -7.32314307e-03f, 9.16937832e-03f, -7.12843239e-02f, 1.61688644e-02f, -3.09839807e-02f, -1.96839813e-02f, 6.94079623e-02f,
  -4.07092981e-02f, -7.58244283e-03f, 2.56832782e-02f, 3.30622904e-02f, -8.96865055e-02f, -1.38376653e-03f, -5.28578712e-05f, 5.16203716e-02f, 9.81694385e-02f, 2.19412129e-02f,
  4.02780920e-02f, 1.71368830e-02f, -1.01136014e-01f, 5.97366691e-02f, -1.36139646e-01f, -3.18507999e-02f, 2.13236194e-02f, 2.31844652e-02f, -8.82519931e-02f, 6.85466081e-02f,
  -6.79931194e-02f, -1.81971058e-01f, 5.24453409e-02f, 5.82097769e-02f, -8.93130898e-03f, -5.09231538e-02f, 7.24290162e-02f, 5.82063682e-02f, -9.90628004e-02f, -5.71626984e-02f,
  -5.67386448e-02f, -8.42876211e-02f, -3.40659730e-02f, -3.84526290e-02f, -5.21111488e-02f, -3.16810086e-02f, -4.28454615e-02f, 3.10144108e-02f, 2.81143095e-02f, -4.54978049e-02f,
  -8.77587683e-03f, 2.15167291e-02f, 4.46879230e-02f, -3.45887952e-02f, -1.13590486e-01f, -3.44634950e-02f, -4.91194166e-02f, -3.75091992e-02f, 4.38501164e-02f, -6.18617050e-03f,
  2.37080269e-02f, 1.42703325e-01f, 2.72587001e-01f, -1.35593265e-01f, 1.94392353e-01f, 2.84232795e-01f, 1.11049235e-01f, 9.99500751e-02f, 3.35813612e-02f, -7.58768991e-02f,
  -9.58393514e-02f, 5.00226356e-02f, -8.02937243e-03f, -1.24980688e-01f, -1.10233642e-01f, 1.43477684e-02f, 3.83077636e-02f, 1.54273706e-02f, 1.28156394e-01f, 2.25848742e-02f,
  9.31944400e-02f, -9.76992399e-02f, 1.08749010e-01f, 1.14672510e-02f, 8.26679245e-02f, -4.60552461e-02f, -2.45646223e-01f, 1.04854330e-01f, -1.67328998e-01f, -2.11399943e-02f,
  2.78237816e-02f, -7.95447901e-02f, -2.80888993e-02f, -6.14275597e-02f, 5.86743169e-02f, 1.04503902e-02f, -1.79070551e-02f, -1.09160572e-01f, 9.53485668e-02f, -7.54363928e-03f,
  3.97326648e-02f, 1.08644448e-01f, -1.74704837e-04f, 1.97192356e-02f, 8.26926082e-02f, 5.17466031e-02f, 7.28966296e-02f, -8.18049349e-03f, 7.73884496e-03f, 6.13202825e-02f,
  2.11741909e-01f, 1.69046789e-01f, 6.65354207e-02f, 8.15178752e-02f, -5.07776923e-02f, -4.31291685e-02f, -2.22066622e-02f, 1.01975165e-02f, 5.89994676e-02f, 4.86777537e-02f,
  4.58366424e-02f, -9.00649950e-02f, -2.27741115e-02f, 7.67800063e-02f, 1.34546921e-01f, 7.28737116e-02f, -5.46993315e-02f, -6.46770895e-02f, 3.57871479e-03f, -1.08327596e-02f,
  2.11749934e-02f, -1.02471180e-01f, 9.69502404e-02f, -1.73257235e-02f, -5.27185351e-02f, 3.10552679e-02f, 6.04406334e-02f, 3.37296352e-02f, 7.11096674e-02f, 1.08997338e-02f,
  -2.73748450e-02f, -7.55823851e-02f, 2.72296462e-02f, 5.73922470e-02f, 6.52740225e-02f, 1.13840088e-01f, -1.18488453e-01f, 1.00184709e-01f, -2.11558528e-02f, -4.04452579e-03f,
  -2.31268495e-01f, -2.17272699e-01f, -8.60978439e-02f, -7.41397291e-02f, -6.41425997e-02f, -4.14112285e-02f, -4.61190082e-02f, -6.64486885e-02f, 5.53760305e-02f, -8.07464682e-03f,
  4.69576754e-02f, 3.67386825e-02f, -1.09507307e-01f, -1.63400359e-02f, 1.29069882e-02f, 6.39556646e-02f, 1.74195785e-02f, -2.26858370e-02f, -1.82652427e-03f, -1.25985993e-02f,
  3.88369858e-02f, 1.43713811e-02f, 9.02148560e-02f, 9.71852764e-02f, -1.11407913e-01f, -1.48526400e-01f, -2.78979298e-02f, 3.48445289e-02f, 1.16137806e-02f, 1.02995401e-02f,
  1.07342094e-01f, -2.83508033e-01f, 1.20643690e-01f, 2.42362589e-01f, 1.05903059e-01f, -1.77089870e-02f, 1.50594354e-01f, -2.79335678e-02f, 3.48737842e-04f, -2.05125257e-01f,
  -1.22038871e-01f, -3.12993415e-02f, -2.78911024e-01f, 7.13737234e-02f, 9.51769724e-02f, -2.20307529e-01f, 8.26275572e-02f, -1.60111919e-01f, -4.40646820e-02f, 9.72973555e-02f,
  1.07905976e-01f, 1.94893345e-01f, 5.42146377e-02f, 9.20723081e-02f, 1.69974402e-01f, 1.12363175e-01f, 2.03388482e-01f, 7.74425864e-02f, 4.41190340e-02f, 5.53023927e-02f,
  -8.39197338e-02f, 1.02519147e-01f, 7.12016448e-02f, -3.82290147e-02f, -2.66361376e-03f, -6.27050996e-02f, -1.34695685e-02f, -3.88418846e-02f, 1.30687103e-01f, 1.99477542e-02f,
  -6.32052049e-02f, 6.41688891e-03f, 6.33588284e-02f, 3.79746035e-02f, 8.94359648e-02f, 9.40363631e-02f, -3.79594602e-02f, -8.21529552e-02f, 1.74778085e-02f, 6.33137440e-03f,
  -4.27386947e-02f, -1.33094355e-01f, 9.66266915e-02f, -8.88158754e-03f, 1.58182129e-01f, 2.56251497e-03f, 4.78784181e-02f, 8.20672810e-02f, 3.13826539e-02f, -1.02793938e-02f,
  -9.98507217e-02f, 2.17640074e-03f, -1.19802551e-02f, 1.03707500e-01f, -2.36135144e-02f, -6.91696396e-03f, 1.83365121e-02f, 4.05237339e-02f, -2.19455697e-02f, 2.64947806e-02f,
  4.66302931e-02f, 1.02130780e-02f, -4.79841344e-02f, 8.44954178e-02f, 3.28257531e-02f, 6.05287142e-02f, 4.67431918e-02f, -1.23223821e-02f, -2.04575416e-02f, -6.33548340e-03f,
  1.56439375e-02f, 7.02682277e-03f, 1.26557751e-03f, 7.62425885e-02f, -1.25098154e-02f, -5.23146205e-02f, 3.74681875e-02f, -2.24148924e-03f, -4.46835235e-02f, -3.20106149e-02f,
  -1.76534370e-01f, -8.89222547e-02f, -9.97822825e-03f, 9.35199391e-03f, -2.29258500e-02f, -8.48313048e-02f, -5.72159290e-02f, -3.44235674e-02f, -1.99748613e-02f, -5.90099916e-02f,
  -1.17660491e-02f, -1.82077568e-02f, -8.72071460e-02f, -6.95527717e-02f, -4.72045727e-02f, -1.12141585e-02f, 6.89681917e-02f, -5.39127626e-02f, 6.64087385e-02f, -9.00601745e-02f,
  7.86080491e-03f, -8.56606662e-02f, 7.99953416e-02f, 1.00235574e-01f, -3.45218815e-02f, 2.00480614e-02f, 8.94919410e-02f, -3.86799574e-02f, -8.17165002e-02f, 6.14138646e-03f,
  -1.01735055e-01f, 9.22556370e-02f, 2.26897523e-01f, 5.63811064e-02f, -6.57637119e-02f, 2.57100463e-01f, 3.97840366e-02f, 1.27414718e-01f, 2.87289441e-01f, 5.84754013e-02f,
  -8.94901305e-02f, 7.28225559e-02f, 3.40058059e-02f, 3.45773250e-02f, 3.95995416e-02f, 1.04378797e-01f, 1.78751752e-01f, -6.00917377e-02f, 8.34498405e-02f, 1.54039320e-02f,
  -8.28968808e-02f, -6.55466244e-02f, -6.45562187e-02f, 8.29511136e-03f, -1.44015595e-01f, -1.33717209e-01f, -1.44334882e-01f, -2.24810317e-02f, -1.41346142e-01f, -2.64174193e-02f,
  -3.50817526e-03f, 2.89648678e-02f, 4.05547284e-02f, 1.87048651e-02f, 1.07967071e-01f, -2.45346762e-02f, -5.36939576e-02f, -4.65697981e-02f, 1.20767895e-02f, -2.16540676e-02f,
  -1.45510202e-02f, -3.13726813e-02f, -6.53223544e-02f, -2.14658994e-02f, 7.45741948e-02f, 2.96144411e-02f, 6.45529926e-02f, 3.27325575e-02f, 1.25614434e-01f, 6.61236420e-02f,
  1.71363816e-01f, 3.08136232e-02f, 3.32039893e-02f, -1.26703635e-01f, 1.93388085e-03f, 5.07031456e-02f, 6.83172867e-02f, -6.05565682e-02f, 3.65756005e-02f, 1.66907281e-01f,
  7.20446482e-02f, -1.83435474e-02f, 7.54852733e-03f, -8.46172944e-02f, -5.44358045e-02f, -1.90807302e-02f, 6.49823248e-02f, -3.21045443e-02f, 6.40188009e-02f, -2.32922751e-02f,
  -1.09439865e-01f, 6.42150342e-02f, 9.27272215e-02f, 1.21060058e-01f, 3.80423814e-02f, -8.99982527e-02f, -1.45514328e-02f, -8.37509930e-02f, -1.10255843e-02f, -6.55908957e-02f,
  -7.73855299e-02f, 2.49690209e-02f, -3.44974138e-02f, -3.72518077e-02f, 1.09189942e-01f, -7.65579119e-02f, -7.06876591e-02f, 8.96907076e-02f, -1.45638376e-01f, -1.38433680e-01f,
  5.70116714e-02f, 6.00989424e-02f, 6.19681105e-02f, -6.07374795e-02f, -7.64611885e-02f, -8.44058171e-02f, -3.34818824e-03f, 3.63954157e-02f, 3.11326738e-02f, -9.83922109e-02f,
  6.19630106e-02f, 1.70404930e-02f, -6.48580939e-02f, 1.47230485e-02f, 2.07370315e-02f, -7.18147233e-02f, 8.88944790e-02f, 6.19255938e-02f, -1.45136314e-02f, 3.34808566e-02f,
  1.73827738e-01f, 9.10285786e-02f, -5.33363074e-02f, 5.76217361e-02f, -5.02384501e-03f, 6.13160543e-02f, 7.28254244e-02f, 5.81150539e-02f, 2.40579862e-02f, 8.05351287e-02f,
  1.50226086e-01f, -2.21164133e-02f, -1.26740977e-03f, -7.67166317e-02f, -1.60805315e-01f, -7.32699633e-02f, -1.05657607e-01f, -3.43109854e-02f, -2.54443377e-01f, 7.88857564e-02f,
  1.23298457e-02f, -4.29480895e-02f, 1.95550561e-01f, -2.93802377e-02f, -7.22614154e-02f, 4.47385721e-02f, 3.32625397e-02f, -6.21012077e-02f, -2.30952241e-02f, 2.68306136e-01f,
  3.80275287e-02f, 1.14711188e-01f, 1.55907020e-01f, 8.81185606e-02f, -5.63321821e-02f, 1.76603854e-01f, 1.73742875e-01f, 1.58960998e-01f, 1.17843404e-01f, -1.49902195e-01f,
  8.03906620e-02f, 1.17185675e-01f, -1.04166148e-02f, 1.14499535e-02f, 1.04959317e-01f, 4.10773791e-02f, -2.17533056e-02f, -1.10656448e-01f, 7.53848329e-02f, 6.07245490e-02f,
  -4.32993807e-02f, 9.52529013e-02f, -4.19780575e-02f, -2.80262884e-02f, 1.74076241e-02f, -8.03530589e-02f, -6.58784509e-02f, -7.48685747e-02f, -4.57844175e-02f, 9.40830931e-02f,
  -6.01705201e-02f, -1.43390626e-01f, -6.43268079e-02f, 1.21513102e-02f, 5.40536456e-02f, -6.13448070e-03f, -4.16304767e-02f, -5.21287806e-02f, -3.72921899e-02f, 6.42932905e-03f,
  5.92047945e-02f, 8.31867978e-02f, -2.44143903e-02f, -5.02751805e-02f, 2.55320594e-02f, 5.31724561e-03f, -1.59640294e-02f, -4.82863076e-02f, 5.16982377e-03f, 2.35627107e-02f,
  -1.15688413e-01f, -6.48295507e-02f, 7.31562302e-02f, 7.37953261e-02f, -5.21097258e-02f, -4.72878251e-04f, -1.08252399e-01f, -1.41738646e-03f, -5.53074889e-02f, -7.13478103e-02f,
  -8.63981713e-03f, -1.11944340e-02f, 3.39358859e-02f, -1.71061419e-02f, -6.00331090e-02f, 1.67185031e-02f, 9.24456120e-02f, 4.78559285e-02f, -3.07755731e-02f, -5.02316691e-02f,
  5.57179824e-02f, 1.96119994e-01f, -3.75460796e-02f, -7.52008408e-02f, 4.39070612e-02f, -3.57794128e-02f, -4.67360877e-02f, 1.66076589e-02f, -2.51058210e-02f, -2.68846918e-02f,
  5.33740781e-02f, -7.17212185e-02f, 8.05902407e-02f, 2.39558890e-02f, -1.40288651e-01f, 8.58207345e-02f, -4.97704255e-04f, -1.37675226e-01f, -3.20390873e-02f, 5.98181486e-02f,
  4.59127836e-02f, -4.90069576e-02f, -7.27066249e-02f, -1.28086731e-01f, -9.96679068e-03f, 4.09597903e-02f, -7.42435530e-02f, -6.85855700e-03f, -1.02485023e-01f, -1.14301264e-01f,
  2.22087339e-01f, 1.59811191e-02f, 1.09405234e-01f, 8.28182995e-02f, -1.70465019e-02f, 6.77828267e-02f, 8.21855515e-02f, -1.79362856e-02f, 1.92100242e-01f, -4.24051508e-02f,
  5.84782809e-02f, 9.92814526e-02f, 6.34251982e-02f, 3.41533939e-03f, 1.19765118e-01f, 1.26653798e-02f, -2.57867239e-02f, 6.02669008e-02f, 7.19766393e-02f, 6.41700299e-03f,
  -2.23377738e-02f, -1.62617803e-01f, -7.88571090e-02f, -2.13328764e-01f, 3.71790752e-02f, -1.84708089e-02f, -3.89301218e-02f, 2.72097886e-02f, -1.23419352e-01f, -1.87783130e-02f,
  6.15244024e-02f, 3.75170968e-02f, 1.10128652e-02f, -8.46318156e-03f, -2.44447067e-02f, -4.82068509e-02f, -2.83817276e-02f, -7.48805180e-02f, 6.97729513e-02f, -8.81026778e-03f,
  -9.97438468e-03f, -3.07931174e-02f, -1.82510465e-02f, 2.72965133e-02f, 9.92719159e-02f, 7.15955198e-02f, -2.04016026e-02f, -7.10105672e-02f, -2.22683828e-02f, -5.55108562e-02f,
  5.99826202e-02f, -1.21815940e-02f, 1.47112831e-02f, -7.09523708e-02f, -5.94944600e-03f, -2.77934168e-02f, -9.29311067e-02f, -4.89675291e-02f, 4.85387929e-02f, 3.93893616e-03f,
  -1.88718662e-02f, -6.74736723e-02f, -4.06476520e-02f, -7.03121349e-02f, 2.98017636e-02f, 5.20384461e-02f, 3.02496105e-02f, -7.42206201e-02f, 7.25442916e-02f, 7.82485157e-02f,
  6.29453734e-02f, 1.41734630e-02f, -1.29705118e-02f, 9.65046883e-02f, -3.94778848e-02f, -6.34542629e-02f, 7.94276223e-02f, 1.34428032e-02f, -4.87867408e-02f, -4.02972177e-02f,
  2.74403617e-02f, -8.57821926e-02f, -7.76047334e-02f, -1.17358156e-01f, 3.72763239e-02f, 1.66241117e-02f, -8.41755643e-02f, -2.21983977e-02f, 2.53279079e-02f, -1.25792446e-02f,
  -4.31091078e-02f, 1.31224599e-02f, -2.59216540e-02f, 2.21251138e-02f, -1.19859884e-02f, -7.16140447e-03f, -1.01332076e-01f, 3.42335813e-02f, 1.07882269e-01f, -9.78213735e-03f,
  2.10610069e-02f, 9.50117633e-02f, -1.62886139e-02f, -5.83189614e-02f, 8.14941674e-02f, 9.11845565e-02f, -1.49681363e-02f, 5.86626753e-02f, 5.52581400e-02f, 5.66745587e-02f,
  -4.16005205e-04f, -4.55370732e-02f, 5.25841750e-02f, 6.42532529e-03f, 8.92504603e-02f, 3.48557346e-02f, -9.06906277e-02f, 4.20936309e-02f, -1.87740903e-02f, -1.97639447e-02f,
  7.40647167e-02f, 2.26258725e-01f, 1.56789780e-01f, 1.69366933e-02f, 9.65922996e-02f, -4.23878804e-02f, -5.95237538e-02f, 4.24802117e-02f, 8.32020640e-02f, 6.88267127e-02f,
  -1.02404416e-01f, 2.00602397e-01f, -8.87117311e-02f, -1.41138583e-01f, -3.17874700e-01f, -2.28662714e-01f, -1.26053914e-01f, -1.08953230e-01f, -8.62748623e-02f, 7.45295733e-02f,
  -8.99145827e-02f, -2.49324903e-01f, -1.56894043e-01f, -3.35174948e-02f, 1.74766004e-01f, 2.80957017e-02f, -1.10743612e-01f, 4.35405485e-02f, 4.35526930e-02f, -3.43236737e-02f,
  -2.26611551e-02f, -2.29895338e-02f, 1.25332445e-01f, -1.38745410e-02f, 1.32246446e-02f, 3.65103856e-02f, 3.10105495e-02f, -6.06668517e-02f, -3.51086520e-02f, 4.18600999e-02f,
  9.62168574e-02f, -1.24743141e-01f, 4.63683046e-02f, -8.08006376e-02f, 9.64171737e-02f, 1.00926846e-01f, 1.27071619e-01f, 1.69783041e-01f, 3.05315778e-02f, -9.41981189e-03f,
  2.70880666e-02f, -3.85853387e-02f, -1.52540021e-03f, 4.55712825e-02f, 7.06498846e-02f, -3.19197848e-02f, -5.90845419e-04f, 9.10259709e-02f, 1.03908114e-01f, -1.69403313e-04f,
  -8.15164298e-02f, -1.87537819e-02f, 3.75545993e-02f, 4.70672734e-02f, 1.08183786e-01f, -3.90976444e-02f, -3.32754781e-03f, -5.28857717e-03f, 5.32217845e-02f, -2.20102947e-02f,
  1.14293071e-02f, -7.38735544e-03f, 1.40280547e-02f, -8.03673640e-03f, -5.79061210e-02f, -6.89254925e-02f, -2.20144372e-02f, 4.14762460e-03f, 1.46198552e-02f, 6.39436245e-02f,
  -6.04112027e-03f, -1.44311367e-02f, -2.12781485e-02f, -6.69410750e-02f, -7.23071173e-02f, 3.00715994e-02f, -3.07605881e-02f, 3.31942178e-02f, 1.35626681e-02f, -6.05900511e-02f,
  4.21354100e-02f, -1.85922027e-01f, -5.50579578e-02f, 1.36130191e-02f, 3.71135063e-02f, 5.90576343e-02f, -3.71358544e-02f, 3.33981663e-02f, 9.28479247e-03f, -6.51606470e-02f,
  -4.53793183e-02f, -3.16264816e-02f, -3.80573459e-02f, 1.08648412e-01f, -2.53748726e-02f, 2.01796624e-03f, -6.14982955e-02f, -4.04521935e-02f, 7.29336441e-02f, -9.53974575e-03f,
  1.25806302e-01f, 2.62626372e-02f, 5.75483963e-02f, 1.15746982e-01f, 8.92611744e-04f, 5.20847850e-02f, 2.87204683e-02f, -5.11138923e-02f, -6.70657456e-02f, 4.98478897e-02f,
  -6.39363006e-03f, 2.13344350e-01f, 1.97390974e-01f, 2.57613093e-01f, -1.08212717e-01f, -2.90237337e-01f, -1.37484804e-01f, 7.76364058e-02f, -5.19033894e-02f, 6.60551265e-02f,
  3.50064561e-02f, 1.17464967e-01f, 6.61705201e-03f, 1.47070677e-03f, -3.27454507e-02f, -1.02291942e-01f, -1.20545462e-01f, -7.69532472e-02f, 4.39055227e-02f, 1.77105740e-01f,
  7.96107426e-02f, -2.77607068e-02f, 7.58722425e-02f, 5.17374612e-02f, 1.42093822e-01f, 1.73844054e-01f, 7.72073716e-02f, 6.84340224e-02f, -1.07235638e-02f, -1.14640810e-01f,
  -7.12818727e-02f, 1.03239879e-01f, 3.59484889e-02f, -4.17295285e-02f, -1.99335720e-02f, 2.99146213e-02f, 1.47062698e-02f, -1.62216604e-01f, 8.04241598e-02f, 2.87068114e-02f,
  -5.98667711e-02f, 2.89135426e-02f, -7.75710866e-02f, -6.05982728e-03f, 5.36137521e-02f, 1.73125714e-02f, 9.86333266e-02f, -2.66126934e-02f, 8.25758576e-02f, 8.85871500e-02f,
  3.89474183e-02f, 8.01741481e-02f, 6.46397769e-02f, -2.63101421e-02f, 2.13773772e-02f, -3.98709662e-02f, 4.68537398e-02f, 6.88486025e-02f, -7.38591887e-03f, 3.12444847e-02f,
  1.03779286e-01f, -2.44577173e-02f, 5.18762395e-02f, -8.55360255e-02f, 1.17086647e-02f, -6.74802884e-02f, 1.66335460e-02f, -5.84382527e-02f, 3.96368727e-02f, -1.20131774e-02f,
  -3.44277844e-02f, 4.66168001e-02f, -4.98944148e-02f, 2.87333410e-03f, -1.55441393e-03f, 5.04908040e-02f, -1.82278659e-02f, 4.29629581e-03f, 3.81709225e-02f, -2.13662349e-02f,
  -3.36717675e-03f, -3.19630206e-02f, 7.52376020e-02f, -2.29807775e-02f, -5.23895398e-02f, -3.87594476e-02f, 2.70564891e-02f, -3.95175852e-02f, 4.82973494e-02f, -7.38158301e-02f,
  8.74551088e-02f, 1.32012218e-01f, -5.07028922e-02f, -4.65656258e-02f, 2.61627790e-02f, -4.02676240e-02f, -3.63861397e-02f, 1.68012735e-02f, -1.50737446e-02f, 7.76783982e-03f,
  -2.18079099e-03f, -9.72771123e-02f, 4.62089479e-02f, -1.83965303e-02f, -1.49124889e-02f, -6.55143782e-02f, 5.75699098e-03f, -6.54824311e-03f, 2.41674650e-02f, 5.29322438e-02f,
  1.87082797e-01f, -8.21305737e-02f, -1.69670128e-03f, 2.70358985e-03f, 8.47539213e-03f, 3.25224071e-04f, -7.42456019e-02f, 6.54316097e-02f, 1.25137612e-01f, -5.79393320e-02f,
  -2.14849040e-01f, -2.82076392e-02f, -1.16443083e-01f, -1.26080036e-01f, -9.55109745e-02f, -2.03656703e-01f, -1.69848576e-01f, -1.78424761e-01f, 4.08715867e-02f, 1.54587656e-01f,
  -4.99725416e-02f, -6.73353821e-02f, 1.42441079e-01f, -1.31374940e-01f, -6.34999573e-02f, 2.15428665e-01f, 7.25303730e-03f, -9.82176047e-03f, -4.59612794e-02f, -1.85202241e-01f,
  -4.95067090e-02f, -7.42035881e-02f, 8.94917324e-02f, -7.67099783e-02f, -1.41296223e-01f, -8.52669552e-02f, -4.49991077e-02f, -2.17279837e-01f, -1.79312274e-01f, -1.03268355e-01f,
  2.89221783e-03f, -6.32897019e-02f, -3.79447266e-02f, -3.63271646e-02f, -1.13965310e-01f, 2.82073813e-03f, -4.97352891e-02f, 3.33168823e-03f, 5.18375412e-02f, -5.91533743e-02f,
  1.22838849e-02f, 2.28358097e-02f, -3.05650830e-02f, 4.78916653e-02f, -3.86965871e-02f, -5.35915568e-02f, -5.10981418e-02f, -7.36641930e-03f, -1.67724434e-02f, 6.45081922e-02f,
  -3.38401571e-02f, 1.51507193e-02f, 6.25951495e-03f, -9.32756811e-04f, -4.12133336e-02f, -5.72912656e-02f, 2.59778518e-02f, 6.58729486e-03f, 1.94966141e-02f, -1.23203108e-02f,
  -2.60322206e-02f, -9.04182494e-02f, -4.23650183e-02f, 7.72847384e-02f, 6.23350963e-03f, 7.66439885e-02f, -3.10572218e-02f, 2.89485678e-02f, -4.44700383e-03f, -1.28721176e-02f,
  -6.69637173e-02f, 6.34569898e-02f, 4.91967872e-02f, 1.26742097e-02f, -4.79980595e-02f, 4.67402264e-02f, -3.53328995e-02f, 2.74797026e-02f, -5.51957311e-03f, 4.42102365e-02f,
  2.72270292e-02f, -4.55917455e-02f, 1.17984220e-01f, -4.92970124e-02f, -2.49700826e-02f, -3.53870518e-03f, 1.04122655e-02f, 7.24665970e-02f, -1.43136308e-02f, -1.15386114e-01f,
  -5.59187196e-02f, -7.46679753e-02f, -1.02506310e-01f, 5.62273003e-02f, -3.84753011e-02f, -2.65756324e-02f, 3.42207542e-03f, 7.56993517e-03f, -1.01466551e-01f, -2.86110379e-02f,
  1.17185432e-02f, 3.12895179e-02f, 1.23538403e-02f, -8.40570554e-02f, 3.51318344e-02f, 8.88197199e-02f, 1.67405717e-02f, 2.17815302e-02f, 6.93948269e-02f, 8.73707701e-03f,
  -5.39618172e-02f, -5.20959198e-02f, 6.66429847e-02f, 8.80380496e-02f, -1.77007746e-02f, 1.30784353e-02f, 2.96635143e-02f, 5.12845218e-02f, -7.00880215e-02f, -7.96107017e-03f,
  -1.26886100e-01f, 1.97416067e-01f, 1.33218318e-02f, 6.02498725e-02f, 1.55287031e-02f, 3.51887614e-01f, 1.24478519e-01f, 2.41066575e-01f, 2.28277028e-01f, 8.27150792e-02f,
  -8.13823491e-02f, -2.12587416e-02f, -1.03486598e-01f, 1.44095734e-01f, 7.96025768e-02f, 8.58316645e-02f, 1.53192908e-01f, 1.14211656e-01f, 1.38738036e-01f, -1.27858549e-01f,
  -6.54944777e-02f, 2.58445945e-02f, -8.63029659e-02f, 6.15594164e-03f, -1.91869587e-02f, -7.00350180e-02f, -2.50923008e-01f, -6.99939728e-02f, -1.14708522e-03f, 5.65495668e-03f,
  -2.88008749e-02f, -8.96150060e-03f, -7.39893466e-02f, -9.64183584e-02f, 8.15003354e-04f, -1.11855872e-01f, 1.47397174e-02f, -6.40221015e-02f, -5.01914322e-02f, 2.83641815e-02f,
  -1.43013457e-02f, -9.85180363e-02f, 9.87890735e-02f, -3.44453775e-03f, 1.09508231e-01f, -5.29757142e-02f, -1.09082222e-01f, 2.79193395e-03f, 5.56091666e-02f, 2.08601989e-02f,
  -1.03118077e-01f, 2.70414613e-02f, -6.46275207e-02f, 8.19944367e-02f, -4.33183461e-02f, -5.90083003e-02f, -2.42713112e-02f, -9.90837812e-02f, 2.87674312e-02f, 8.31076801e-02f,
  -1.71768796e-02f, -1.91833321e-02f, 1.87202450e-02f, -3.43495235e-02f, -3.33978385e-02f, -3.24119367e-02f, -9.99858044e-03f, -1.94552867e-03f, -1.58286095e-02f, -3.62869278e-02f,
  2.86861584e-02f, 2.24426351e-02f, 5.77511787e-02f, -1.10580567e-02f, 5.56611754e-02f, -6.53724149e-02f, -3.11133638e-02f, 3.19922306e-02f, -3.96393836e-02f, -4.44602743e-02f,
  6.91801906e-02f, -1.22221652e-03f, -6.04043417e-02f, 8.38003382e-02f, -2.02360079e-02f, 7.60708610e-03f, -1.62899937e-03f, 8.66539851e-02f, -2.01143026e-02f, 2.87707467e-02f,
  1.52026281e-01f, 1.24520153e-01f, 5.80694117e-02f, -7.60266185e-02f, -7.39191696e-02f, -6.06431924e-02f, 1.70567632e-02f, 8.55209082e-02f, -4.91907336e-02f, 7.38308802e-02f,
  5.56005025e-03f, 3.27222166e-03f, -2.40357500e-02f, -7.36667123e-03f, -4.22476381e-02f, -1.67338103e-02f, -1.97507158e-01f, 3.03615592e-02f, 1.62050035e-02f, -2.16931710e-03f,
  -5.60992882e-02f, -2.45682560e-02f, 2.79110186e-02f, -4.66488414e-02f, 8.78156126e-02f, -5.46554253e-02f, 2.19099279e-02f, 4.77190479e-04f, 4.64983750e-03f, 4.12035733e-02f,
  2.12902814e-01f, -2.52111312e-02f, 1.37067437e-01f, 2.27597028e-01f, 5.92168979e-02f, -1.21313436e-02f, 1.65351555e-02f, 4.38053608e-02f, 1.04225703e-01f, 9.07073263e-03f,
  -6.10184260e-02f, 8.83478299e-02f, -1.85281321e-01f, -1.79109871e-02f, 2.15725973e-02f, -1.31613597e-01f, 2.81429179e-02f, 5.04558999e-03f, -1.09083369e-01f, 9.51894745e-02f,
  1.42103106e-01f, -4.10920382e-02f, -2.25645471e-02f, -5.84580787e-02f, 5.83547130e-02f, 1.67668119e-01f, 4.68115620e-02f, -4.08519730e-02f, 8.38189945e-02f, -6.75464608e-03f,
  -1.89059973e-02f, 3.87357362e-02f, -1.06561333e-02f, -1.90485660e-02f, 2.86969468e-02f, -8.20482448e-02f, 7.95836523e-02f, -1.03750983e-02f, -2.55127493e-02f, -3.98316346e-02f,
  -6.85308278e-02f, -1.06510520e-03f, 2.17119697e-02f, 5.55921122e-02f, -7.41527304e-02f, 6.06312230e-02f, 9.39997062e-02f, 9.55154002e-02f, 6.17375970e-03f, 1.11109102e-02f,
  -1.74806900e-02f, -6.20896090e-03f, 1.01501107e-01f, 1.32144213e-01f, -8.31976533e-02f, 4.26403433e-02f, -4.70258370e-02f, 5.41262217e-02f, 2.57067778e-03f, 1.95950624e-02f,
  4.03008163e-02f, -5.25733158e-02f, 1.72027703e-02f, -4.20788862e-02f, 4.52210661e-03f, -8.84394441e-03f, -3.47103849e-02f, 8.07732269e-02f, -1.72104929e-02f, 4.50978167e-02f,
  -3.68178375e-02f, 1.23093538e-01f, 4.15363945e-02f, -9.40645039e-02f, 4.00712267e-02f, -1.91281810e-02f, 1.09961443e-01f, -4.58104390e-04f, 8.21470842e-02f, -6.96484223e-02f,
  4.84859720e-02f, -1.09803773e-01f, -6.80233762e-02f, 5.28411344e-02f, 1.97833683e-02f, -4.97438163e-02f, -1.81739435e-01f, -3.56013179e-02f, -3.54776531e-02f, -4.61345240e-02f,
  -7.96375871e-02f, -4.85781990e-02f, -2.64005624e-02f, 2.01283544e-02f, -3.65696959e-02f, 2.63283253e-02f, -7.97344223e-02f, 4.45179008e-02f, -8.75697061e-02f, -6.37938157e-02f,
  5.34615442e-02f, -3.11097298e-02f, 6.11173101e-02f, 3.08509991e-02f, 7.67094130e-03f, -6.21350715e-03f, 8.34712479e-03f, 2.08181106e-02f, -6.45253882e-02f, -6.15090989e-02f,
  6.85373647e-03f, 1.39948307e-02f, 2.03563981e-02f, 2.95845419e-02f, -1.42939100e-02f, 1.58593178e-01f, 1.08431287e-01f, 4.70545590e-02f, 2.45654061e-02f, -4.54462022e-02f,
  2.11049318e-02f, 1.15403704e-01f, 6.86331838e-02f, 3.11055690e-01f, -6.15537651e-02f, -3.38281125e-01f, -2.15680405e-01f, 5.13177626e-02f, 5.02072461e-02f, -1.32699966e-01f,
  -8.18344951e-02f, 7.60616595e-03f, -1.43694803e-01f, 1.29285559e-01f, 2.92146087e-01f, -8.10448173e-03f, 1.14269517e-01f, -3.25302556e-02f, 1.69807166e-01f, 2.01398462e-01f,
  1.45570487e-01f, 1.07859045e-01f, 2.43425801e-01f, 1.33868754e-01f, 3.09063047e-02f, 1.44767255e-01f, 2.04829335e-01f, -1.72053985e-02f, 2.35202789e-01f, 9.93431732e-02f,
  3.50061757e-03f, 1.75846331e-02f, 2.68115252e-02f, -2.37581767e-02f, -5.08630164e-02f, -1.82065174e-01f, -9.64203700e-02f, 9.44840442e-03f, 6.78337514e-02f, 4.20930050e-02f,
  -6.09703586e-02f, 2.07083113e-03f, 1.33656859e-01f, -6.71169907e-02f, -1.13356099e-01f, -4.06429656e-02f, -4.46901731e-02f, -8.77207518e-03f, 4.13930081e-02f, -6.61268085e-02f,
  2.97861435e-02f, -6.31030723e-02f, -3.26600224e-02f, 1.12534925e-01f, 1.76078051e-01f, -2.34152954e-02f, -7.17108026e-02f, 4.90377247e-02f, 4.67352681e-02f, 4.71132845e-02f,
  -4.30549569e-02f, 3.65690961e-02f, 3.85372862e-02f, -9.79094952e-03f, 6.25767782e-02f, -4.26324643e-02f, -8.74974132e-02f, -6.17532767e-02f, 8.06907043e-02f, -5.03678285e-02f,
  6.85384572e-02f, 6.89789206e-02f, -5.07290736e-02f, 6.44276962e-02f, 2.51532216e-02f, 5.26664965e-02f, -1.73217198e-03f, -6.89620385e-04f, 6.62108138e-03f, 1.05623558e-01f,
  3.52318995e-02f, 6.32129014e-02f, 2.34510023e-02f, -1.05313361e-01f, 7.75421271e-03f, 5.59814647e-02f, -4.71818708e-02f, -2.70743929e-02f, 1.43652996e-02f, 2.06635781e-02f,
  -1.08282916e-01f, 2.12248355e-01f, -6.92921728e-02f, 3.10560782e-02f, 1.23936512e-01f, 4.03259322e-02f, 3.09058391e-02f, 4.51910309e-02f, 6.50776401e-02f, -2.50163469e-02f,
  1.08399034e-01f, -5.07764425e-03f, -9.64962319e-02f, 4.85231578e-02f, -7.08126947e-02f, 6.63758293e-02f, 8.24320540e-02f, -4.70768102e-02f, -1.51299685e-02f, 1.05195135e-01f,
  1.84806623e-02f, -4.59386595e-02f, 6.46441206e-02f, 7.64195621e-02f, -2.70307735e-02f, 3.84798720e-02f, -1.24860322e-02f, -3.21922526e-02f, 2.97890753e-02f, 4.42209169e-02f,
  1.09568745e-01f, 5.45864850e-02f, 1.77607954e-01f, 3.20264310e-01f, 2.01085415e-02f, -1.71705261e-01f, -2.17870444e-01f, 1.39557183e-01f, 1.29706636e-01f, -1.42778516e-01f,
  -6.02998137e-02f, 2.63139233e-02f, -1.45961285e-01f, 1.50483027e-01f, -7.68796504e-02f, -5.57060428e-02f, 1.24517232e-01f, -3.83300744e-02f, 4.70134914e-02f, 7.84639642e-02f,
  1.52097374e-01f, 7.23674819e-02f, 1.37422532e-01f, 4.04295102e-02f, 1.90764278e-01f, 8.54282156e-02f, 6.13130443e-02f, 5.33621153e-03f, 6.18940257e-02f, -6.64287433e-02f,
  -4.95466180e-02f, 5.19383512e-02f, -1.85099598e-02f, -1.64582506e-02f, 6.62199929e-02f, -7.86762759e-02f, -7.58621143e-04f, -1.02018625e-01f, 3.64273302e-02f, -6.23990931e-02f,
  -1.15295695e-02f, 1.17058521e-02f, 4.41385992e-02f, -3.61887328e-02f, 3.26461457e-02f, 7.24180117e-02f, 8.43393803e-02f, -1.45272594e-02f, 1.15114506e-02f, 6.76380321e-02f,
  2.48073861e-02f, 1.93051994e-02f, 9.41241309e-02f, 7.23213851e-02f, 8.33988935e-02f, 1.30648939e-02f, 2.59485487e-02f, -3.97874452e-02f, -5.79924993e-02f, 1.11893490e-01f,
  2.11441442e-02f, 1.66407358e-02f, 4.99014221e-02f, -5.79804822e-04f, 5.33934273e-02f, -3.50277848e-03f, 1.20251626e-02f, -4.19556759e-02f, 6.35891184e-02f, -9.44734886e-02f,
  -2.53879763e-02f, 4.60555553e-02f, 2.49676071e-02f, 2.78732367e-02f, 5.37265129e-02f, -6.49989322e-02f, -2.55895238e-02f, 7.35088512e-02f, 5.20914532e-02f, 6.37624562e-02f,
  -2.55438089e-02f, -4.47082594e-02f, 1.11042403e-01f, 3.58282402e-02f, -1.52571010e-03f, -6.79770112e-02f, 4.92849760e-02f, 6.37882724e-02f, 2.44279895e-02f, 9.82794166e-03f,
  -7.46916384e-02f, 3.75438407e-02f, 3.50079276e-02f, -2.30722204e-02f, 3.83321615e-03f, 1.28126238e-03f, -6.88613653e-02f, 2.01924564e-03f, -3.93545255e-02f, 6.39078766e-02f,
  -4.51767035e-02f, -8.17322060e-02f, -6.03215434e-02f, 4.45990637e-02f, -2.71949377e-02f, -2.09585708e-02f, 2.64211651e-02f, -8.19007214e-03f, -9.87308100e-02f, -4.02638800e-02f,
  4.67566960e-03f, -7.37814233e-02f, 2.99264435e-02f, -1.40811540e-02f, 2.39871093e-03f, -9.62380320e-02f, 1.96095556e-02f, 4.51437272e-02f, 9.36374515e-02f, 1.70055646e-02f,
  -4.05348986e-01f, 1.00336254e-01f, -1.21271901e-01f, 2.26838216e-02f, -2.18243599e-02f, 5.26078120e-02f, 4.41743471e-02f, -5.65524735e-02f, 2.09392011e-02f, 2.47430742e-01f,
  2.14691386e-01f, -2.05418333e-01f, 1.13887466e-01f, 8.61192420e-02f, -1.68224037e-01f, -1.26457578e-02f, 1.30897716e-01f, 2.56618597e-02f, -1.56187089e-02f, -1.24418363e-01f,
  -4.07529362e-02f, 3.55625786e-02f, -9.10478309e-02f, 4.79673930e-02f, -7.72261992e-02f, -1.01935491e-01f, 1.66059539e-01f, -1.43528625e-03f, 4.99851070e-02f, 1.60764772e-02f,
  -1.06281057e-01f, -1.13924794e-01f, -3.79502326e-02f, -4.57132794e-02f, -1.19547315e-01f, -2.57502776e-02f, 5.51221631e-02f, -3.68282720e-02f, -1.07253036e-02f, -2.79768985e-02f,
  7.75118067e-04f, -1.11311026e-01f, 1.04568563e-02f, 1.56237287e-02f, 4.43392470e-02f, -3.88694443e-02f, -1.33624850e-02f, -3.94639000e-02f, -1.72184128e-02f, -7.39240944e-02f,
  -2.02948786e-03f, -6.01661615e-02f, 9.80563685e-02f, -9.50211380e-03f, 1.49746984e-02f, 5.77614382e-02f, 3.98235470e-02f, -5.66612408e-02f, 6.49687722e-02f, -1.12553298e-01f,
  7.40208104e-02f, -1.46819964e-01f, -1.08702742e-02f, 2.08036024e-02f, 4.71935645e-02f, 6.50649592e-02f, -1.49377128e-02f, -1.01011246e-01f, 2.30588727e-02f, -5.40755242e-02f,
  -2.92187799e-02f, -4.37305197e-02f, -2.61705145e-02f, -1.50419343e-02f, 6.62849918e-02f, -4.34026122e-02f, -4.89351824e-02f, -3.18273692e-03f, 4.93348129e-02f, 1.42451236e-02f,
  3.63150313e-02f, -7.76709169e-02f, 7.74108712e-03f, 9.72584486e-02f, 6.22351989e-02f, 6.84635490e-02f, -2.50178706e-02f, -9.58225057e-02f, -3.07123605e-02f, -8.29729587e-02f,
  8.65022093e-02f, -3.32780788e-03f, 8.70006606e-02f, 1.11738537e-02f, -5.62211405e-03f, 2.14394778e-02f, 8.42926577e-02f, -1.98974647e-02f, 3.19214463e-02f, -3.24841477e-02f,
  7.47088157e-03f, -7.92507231e-02f, -2.82082800e-02f, 7.71717280e-02f, -4.16584313e-02f, 3.13617056e-03f, 7.21734986e-02f, 5.78374937e-02f, 1.21406084e-02f, -5.68455160e-02f,
  -3.45665775e-02f, 1.23221884e-02f, 3.36339958e-02f, 1.08788228e-02f, 4.93647642e-02f, 7.26416931e-02f, 3.40974028e-03f, 4.35264632e-02f, 7.85740912e-02f, -7.50865340e-02f,
  -9.17799696e-02f, -2.85524428e-01f, -1.11111272e-02f, 1.98257193e-01f, 1.06469370e-01f, -2.19258040e-01f, -2.19733104e-01f, -1.27382249e-01f, -1.97510019e-01f, -2.69263953e-01f,
  -3.39458999e-03f, -4.47164662e-02f, -3.58722031e-01f, 2.26362899e-01f, 2.34516278e-01f, -1.49221420e-01f, 6.48799688e-02f, 1.17059313e-02f, -7.25425482e-02f, 2.90905144e-02f,
  1.51405901e-01f, 1.17277503e-01f, 2.43912697e-01f, 4.72686552e-02f, 1.03218660e-01f, 1.24042988e-01f, 2.38069341e-01f, -5.40879034e-02f, 1.93213791e-01f, 5.13346903e-02f,
  -7.40228966e-02f, 2.00088825e-02f, 3.16244215e-02f, 6.47198707e-02f, 2.49588527e-02f, -3.53310741e-02f, 1.72367226e-02f, -9.20056924e-03f, 2.67893411e-02f, -3.57331410e-02f,
  -3.10954433e-02f, 2.36197691e-02f, 1.01059966e-01f, -7.31611997e-02f, -4.81372215e-02f, 3.91812297e-03f, -1.18680857e-02f, -8.17297772e-02f, 2.76825894e-02f, -9.47673023e-02f,
  -6.92416802e-02f, -4.99776453e-02f, -3.02416719e-02f, 6.74497560e-02f, 1.02523558e-01f, 1.14467908e-02f, 2.69409567e-02f, 2.88316682e-02f, -3.79806794e-02f, 9.95842889e-02f,
  5.45440353e-02f, -3.67199518e-02f, -1.01268716e-01f, -5.98770715e-02f, -1.16666190e-01f, -9.92461517e-02f, -5.76245040e-02f, 5.26639400e-03f, 4.96635325e-02f, 5.07128835e-02f,
  1.38764037e-02f, -2.71862615e-02f, 7.20551386e-02f, 4.94654551e-02f, 1.40582202e-02f, -4.23329175e-02f, -7.41013438e-02f, 2.55615041e-02f, -3.42080817e-02f, 4.87578288e-02f,
  1.35999564e-02f, 2.90529616e-02f, -2.79817786e-02f, -1.09652048e-02f, -3.52927260e-02f, -1.71309300e-02f, 1.27859823e-02f, -9.54876989e-02f, -4.32074629e-02f, 2.78384630e-02f,
  8.28955472e-02f, 3.87237258e-02f, -3.45720202e-02f, 2.53567230e-02f, -1.81768350e-02f, -5.66568226e-02f, 5.85612543e-02f, 4.28858995e-02f, -1.14896903e-02f, 2.85991672e-02f,
  8.59452132e-03f, 7.72016197e-02f, 1.23246815e-02f, 2.83863395e-03f, 7.28167593e-02f, -3.48234102e-02f, 5.86716570e-02f, 1.01774603e-01f, 8.27713832e-02f, 1.64995994e-02f,
  -7.51913711e-02f, -1.11992106e-01f, 5.62655069e-02f, 1.22416699e-02f, -5.70777571e-04f, -1.45507008e-02f, 8.76575708e-02f, -7.36178234e-02f, 1.01376481e-01f, -4.37951460e-02f,
  -3.03601414e-01f, 1.47385463e-01f, -2.00596545e-02f, -1.63645029e-01f, 9.29207876e-02f, -4.25141631e-03f, -1.12815641e-01f, 7.21077323e-02f, -6.34684637e-02f, -3.72108705e-02f,
  3.44066732e-02f, -1.17855363e-01f, 4.76485938e-02f, -1.43515259e-01f, -1.37441278e-01f, 1.32237390e-01f, -1.48825943e-01f, 7.59038888e-03f, 5.30458763e-02f, -4.37121429e-02f,
  -3.83092137e-03f, -3.21024731e-02f, -5.63536175e-02f, 3.22147831e-02f, -8.59507397e-02f, -2.30925363e-02f, -1.65085703e-01f, 3.72431278e-02f, -4.46993411e-02f, -8.21690261e-02f,
  -1.33024491e-02f, 1.28336981e-01f, -1.82997752e-02f, 9.39615909e-03f, 7.02953860e-02f, 3.16343717e-02f, -2.34140996e-02f, 2.58284938e-02f, -2.43681986e-02f, 4.20185812e-02f,
  -6.77738935e-02f, 5.39787412e-02f, -6.58342987e-02f, 3.14996280e-02f, -2.70748772e-02f, -4.46864851e-02f, -6.89967582e-03f, 1.03060782e-01f, 1.08184449e-01f, -5.68321124e-02f,
  2.37527005e-02f, -5.32005429e-02f, -1.40738547e-01f, 1.78372394e-02f, -5.40783964e-02f, -2.47085337e-02f, 8.39132741e-02f, -6.05873913e-02f, 2.00173426e-02f, 2.02782881e-02f,
  -1.16757251e-01f, 7.26140887e-02f, -8.89074709e-03f, -7.34433457e-02f, -2.75549553e-02f, -7.53224315e-03f, -1.31535947e-01f, -3.71837318e-02f, -1.24093659e-01f, -4.91981879e-02f,
  -5.46043590e-02f, -3.96437831e-02f, 4.50778827e-02f, 1.43237533e-02f, -1.83098670e-02f, -9.47383884e-03f, 5.06645590e-02f, 1.94919277e-02f, -1.29207328e-01f, -5.10146990e-02f,
  4.19789962e-02f, -3.97066474e-02f, -4.64103222e-02f, -1.11482944e-02f, 2.52069943e-02f, -7.31461048e-02f, -3.00027225e-02f, 7.05808029e-02f, -6.11677431e-02f, -2.10152399e-02f,
  -7.82485306e-02f, 1.18619472e-01f, 1.17368095e-01f, -5.39452694e-02f, 1.26340970e-01f, 6.99089654e-03f, -6.20452799e-02f, 3.92474458e-02f, 6.45604059e-02f, -5.46849007e-03f,
  -1.18509173e-01f, 4.57760096e-02f, 2.49126758e-02f, -1.49490181e-02f, -1.01021849e-01f, -7.41361603e-02f, -6.26320243e-02f, -4.36377572e-03f, 3.01386844e-02f, -1.56037016e-02f,
  -3.64408903e-02f, 7.79542625e-02f, -4.10326682e-02f, -9.69075263e-02f, -1.03223957e-01f, -1.02503330e-01f, 5.81839494e-03f, -6.73083961e-02f, -2.85930615e-02f, -3.06998566e-02f,
  2.09051624e-01f, 2.25856267e-02f, 1.93819523e-01f, 1.71901256e-01f, 1.37412906e-01f, 5.97653575e-02f, 2.42937446e-01f, 1.17145412e-01f, 2.89184391e-01f, -9.98406261e-02f,
  -9.95549038e-02f, -1.58206820e-01f, -8.76632407e-02f, -6.58292398e-02f, 3.41648497e-02f, -7.12010637e-02f, 2.34971866e-02f, -1.73813209e-01f, 7.08239153e-02f, -2.60297004e-02f,
  1.13972947e-01f, -8.73261392e-02f, 3.53711937e-03f, -1.54023051e-01f, -5.18009476e-02f, 7.12175891e-02f, -1.04276739e-01f, -9.83621087e-03f, -8.28123242e-02f, -2.31874045e-02f,
  -6.45040795e-02f, 8.79709348e-02f, -8.49308744e-02f, -2.21070014e-02f, -2.03135014e-02f, 6.79703578e-02f, 7.18054250e-02f, 2.81688310e-02f, -5.06397933e-02f, 1.77181233e-03f,
  -1.19498491e-01f, -1.23270471e-02f, -3.15106362e-02f, 8.64777938e-02f, -5.16628437e-02f, -2.71875858e-02f, -3.66657693e-03f, -2.74668243e-02f, -5.44823967e-02f, -4.66200802e-03f,
  3.80144417e-02f, -1.11724824e-01f, -9.19230059e-02f, 2.37124469e-02f, 6.65739328e-02f, 8.62707719e-02f, 5.96346594e-02f, 5.67907607e-03f, 6.94775209e-02f, 1.81427971e-02f,
  -1.21918976e-01f, -9.81920492e-03f, 3.85183170e-02f, -2.12783106e-02f, -8.23265240e-02f, 3.54329459e-02f, -4.98006269e-02f, -3.44504714e-02f, 1.01402372e-01f, 3.51444669e-02f,
  6.53278604e-02f, 4.67682965e-02f, -5.90018928e-02f, 3.46179493e-02f, -7.21005872e-02f, -7.43016507e-03f, 4.04267050e-02f, -2.75705066e-02f, 2.36225817e-02f, -7.80507401e-02f,
  1.15058757e-01f, -1.24281654e-02f, -9.86801684e-02f, -3.57318893e-02f, 8.00096989e-02f, 5.10673523e-02f, 5.70607036e-02f, -5.43292053e-02f, 4.74209897e-03f, 1.94779504e-02f,
  -1.57216206e-01f, -4.23480980e-02f, -5.08276485e-02f, -8.36820081e-02f, 7.00290920e-03f, -6.37527630e-02f, 4.00134809e-02f, -5.83088100e-02f, 2.52219550e-02f, 6.80956692e-02f,
  2.56685205e-02f, 3.64643633e-02f, -6.76986426e-02f, -7.93544576e-03f, -1.36608230e-02f, -1.82463415e-02f, -8.42235014e-02f, -5.90123907e-02f, 1.86556652e-02f, -5.99840023e-02f,
  -5.46968356e-02f, 1.45155378e-02f, -3.02647855e-02f, 4.75141853e-02f, -8.14970285e-02f, -9.48820934e-02f, -5.73610142e-03f, -4.16742340e-02f, 3.59399691e-02f, -3.01305261e-02f,
  -3.27536277e-02f, 5.41426167e-02f, 5.23269512e-02f, -9.56918299e-02f, -1.20605968e-01f, -3.38066101e-01f, -2.34697729e-01f, 9.20943394e-02f, 1.65650919e-01f, 6.34338334e-02f,
  -5.50629944e-02f, 1.46006048e-01f, 1.50613323e-01f, -1.65332839e-01f, 8.33722297e-03f, 7.06301555e-02f, -2.34954253e-01f, -1.38455108e-01f, 3.69578004e-02f, -1.15816087e-01f,
  -7.59854866e-03f, -1.17105275e-01f, -3.16726565e-02f, -3.71559076e-02f, -1.84290484e-01f, 1.12234682e-01f, 1.33034915e-01f, -3.40227149e-02f, -2.81013101e-02f, 2.84315366e-02f,
  -1.05519302e-01f, 2.03819871e-01f, 9.45189223e-02f, 6.27582446e-02f, -4.68633734e-02f, -1.21587059e-02f, -7.52462596e-02f, -5.72619103e-02f, -1.68929826e-02f, 8.87137605e-04f,
  4.15133163e-02f, 7.54962713e-02f, 2.93963198e-02f, -4.53629158e-02f, -3.56371589e-02f, 3.88923101e-03f, 1.40995413e-01f, 7.30422288e-02f, -2.92528663e-02f, -9.36133936e-02f,
  2.88242828e-02f, 1.75966546e-02f, -8.64310786e-02f, 3.94451655e-02f, 5.62111475e-02f, 6.09614290e-02f, -1.01497039e-01f, 9.01510380e-03f, -3.61398682e-02f, 6.13812879e-02f,
  -3.52409780e-02f, -1.43514588e-01f, -6.96446225e-02f, -1.86992576e-03f, -8.48020613e-02f, 2.00597569e-03f, 2.94426102e-02f, 4.01505493e-02f, -3.83457765e-02f, 4.81189638e-02f,
  -3.56616862e-02f, -1.22656412e-02f, -6.03112504e-02f, 1.83201872e-03f, -3.80139425e-02f, 8.77672732e-02f, -8.27550143e-02f, -1.80312134e-02f, -1.27457641e-02f, -3.15789059e-02f,
  2.50031911e-02f, -1.59597039e-01f, 7.27561563e-02f, 3.35106812e-02f, 3.50951068e-02f, 3.89818475e-02f, -9.95413586e-03f, 2.03863136e-03f, 3.96167822e-02f, 4.56062797e-03f,
  4.88207564e-02f, 1.27544522e-01f, -5.83128221e-02f, -1.95923541e-02f, -4.94245142e-02f, -3.16248573e-02f, -7.75910020e-02f, 4.73568439e-02f, -5.08929836e-03f, 5.61010055e-02f,
  -1.80124945e-03f, -5.99420518e-02f, -1.98649112e-02f, 6.40389323e-02f, 7.17863739e-02f, -4.94940355e-02f, -4.09340821e-02f, 4.31983098e-02f, 6.32590875e-02f, 1.27871765e-03f,
  3.54052335e-02f, -5.68537414e-02f, -2.88210232e-02f, -6.78641349e-02f, -6.06151782e-02f, -2.11656895e-02f, -7.54083022e-02f, 1.65949378e-03f, 4.22862284e-02f, 6.16169581e-03f,
  8.72737020e-02f, -1.78005733e-02f, 1.80335894e-01f, 2.99324691e-02f, 9.23336372e-02f, 2.54090577e-01f, 1.80681914e-01f, 2.29466945e-01f, 5.96206412e-02f, -1.36454493e-01f,
  -1.73469007e-01f, -9.09220353e-02f, 1.22272223e-01f, -1.97424248e-01f, 6.06082641e-02f, 8.43749493e-02f, 8.79701898e-02f, -1.14779197e-01f, 1.70781299e-01f, -2.75876187e-02f,
  8.56879205e-02f, -4.84710839e-03f, 4.45488356e-02f, 8.24299082e-02f, 2.33784155e-03f, -1.08710006e-01f, -1.64112553e-01f, 7.63753504e-02f, -1.41021743e-01f, -1.60236228e-02f,
  2.17387639e-02f, -2.45281681e-02f, -1.23549076e-02f, 4.19899411e-02f, 7.46638107e-04f, -1.46259993e-01f, -4.74636406e-02f, -1.21834032e-01f, -1.29503205e-01f, -4.13729101e-02f,
  5.20982295e-02f, -4.94419262e-02f, -1.11056929e-02f, 1.79510713e-02f, -1.72695369e-02f, -2.46582944e-02f, -7.14910254e-02f, 8.30607414e-02f, 6.29807413e-02f, 5.03417440e-02f,
  8.47374871e-02f, 8.54183175e-03f, -3.45266014e-02f, -2.13393904e-02f, -4.23015207e-02f, 3.75124440e-02f, -1.97792631e-02f, -1.29136860e-01f, -2.44300757e-02f, 9.06177890e-03f,
  5.50117046e-02f, -2.90077664e-02f, -1.12967826e-02f, -3.10154539e-02f, -3.65282074e-02f, -1.48554116e-01f, -8.88594240e-02f, 3.73576991e-02f, -1.51423598e-02f, 6.74948022e-02f,
  -6.07146062e-02f, -2.31247041e-02f, 5.29297255e-02f, -1.28853664e-01f, 1.63190998e-02f, 5.16803488e-02f, -3.37349810e-02f, 5.15247695e-02f, -1.96811464e-03f, 3.76421749e-03f,
  9.27157328e-02f, 1.71957761e-02f, 3.41976387e-03f, 7.31246127e-03f, -1.59545355e-02f, -5.29710837e-02f, -8.12613890e-02f, 5.03371172e-02f, 8.88804495e-02f, -1.99373439e-03f,
  -1.55753896e-01f, 9.45738554e-02f, -4.76065762e-02f, -2.80741006e-02f, -4.02601585e-02f, -4.60658781e-03f, -2.59425398e-02f, -9.02327523e-02f, -5.34621719e-03f, 2.44352245e-03f,
  -4.37722243e-02f, -8.77900049e-02f, 2.50505023e-02f, 5.35384230e-02f, -3.96309346e-02f, 5.77160716e-02f, -3.37230638e-02f, -3.85140739e-02f, -6.49688244e-02f, -3.70218791e-02f,
  -6.31738976e-02f, -2.68148053e-02f, -6.38078749e-02f, 5.99110276e-02f, -4.95553575e-02f, -6.74803108e-02f, -6.17833175e-02f, 6.07088618e-02f, -3.40506844e-02f, -3.95933315e-02f,
  -4.03583288e-01f, 1.20747238e-01f, 4.12023552e-02f, -2.57792681e-01f, -1.04044288e-01f, -5.94014563e-02f, -1.26117433e-03f, -9.71267149e-02f, 4.35160324e-02f, -8.27448294e-02f,
  -7.44572729e-02f, 5.87843806e-02f, 2.57289797e-01f, -4.79213446e-02f, 4.00656015e-02f, 1.14237092e-01f, -2.79663131e-02f, -3.76125053e-02f, 1.42952144e-01f, -3.83060463e-02f,
  3.27888094e-02f, -3.92910242e-02f, -1.88316852e-02f, -1.79767217e-02f, -1.32719755e-01f, -3.40147465e-02f, -1.12801686e-01f, 1.16352074e-01f, -8.44535679e-02f, 4.43715416e-02f,
  -3.07857543e-01f, -1.07704267e-01f, -1.39132291e-01f, -2.68453546e-02f, -1.26497447e-01f, 6.51227534e-02f, -1.30793750e-01f, 6.50739670e-03f, -5.37437424e-02f, -6.72598276e-03f,
  3.14934291e-02f, -1.87310390e-02f, -1.76777411e-02f, -1.61560364e-02f, -6.26927882e-04f, 1.17260730e-02f, -4.47818115e-02f, -9.03945789e-02f, 1.99322030e-02f, 5.48601225e-02f,
  7.74860382e-03f, -3.86361815e-02f, -8.78551230e-02f, 5.45519181e-02f, 3.23654674e-02f, -4.99204807e-02f, -6.23803288e-02f, -2.79543805e-03f, 6.06884481e-03f, -5.27508371e-03f,
  -2.62920819e-02f, 1.44756213e-01f, -4.74616140e-02f, -4.55802307e-03f, -4.35870513e-02f, -2.40626279e-02f, -2.60209609e-02f, 8.70148931e-03f, -7.13512823e-02f, 1.57788172e-02f,
  -3.27459238e-02f, -5.90183511e-02f, -5.26565313e-02f, 5.61647005e-02f, 3.32301930e-02f, -8.47515911e-02f, 3.55771445e-02f, -8.76966491e-03f, 5.51704951e-02f, -7.13541359e-02f,
  -3.00020296e-02f, 5.59825972e-02f, 6.54652715e-02f, 8.65256786e-03f, 6.18865900e-03f, -7.33460253e-03f, -3.85147110e-02f, 3.66566516e-02f, -2.37893895e-03f, 3.72735523e-02f,
  -1.90316424e-01f, -1.18369170e-01f, -1.09140709e-01f, -1.20751403e-01f, -2.90274099e-02f, 2.44722283e-03f, 3.97301018e-02f, -6.81976154e-02f, -1.56302936e-02f, 3.52176628e-03f,
  -7.18065500e-02f, -1.26664728e-01f, 4.74694520e-02f, 3.31291482e-02f, -6.28823489e-02f, -5.58949299e-02f, 1.51195126e-02f, 9.23489109e-02f, -1.02926813e-01f, 7.93048069e-02f,
  -4.41670120e-02f, 4.54684198e-02f, 8.74686763e-02f, -8.36435184e-02f, -2.15710327e-02f, -4.31282260e-02f, 7.08622560e-02f, 3.48461047e-02f, -2.87905112e-02f, 1.14193164e-01f,
  9.46014300e-02f, -4.17998396e-02f, 2.83864960e-02f, -7.55225495e-02f, -3.69369052e-02f, 1.78833395e-01f, 2.41632715e-01f, -1.83059379e-01f, 8.15270748e-03f, 1.69002593e-01f,
  1.76313773e-01f, 1.03496477e-01f, 2.74274141e-01f, -3.62929031e-02f, 1.19945608e-01f, 1.77527100e-01f, 7.22853467e-02f, 1.27581313e-01f, -6.94424883e-02f, 4.38655652e-02f,
  -2.21737358e-03f, -7.65483920e-03f, 1.29765093e-01f, -7.52010420e-02f, -2.92131696e-02f, -1.57277435e-01f, -6.40896037e-02f, 9.27751288e-02f, -1.30365431e-01f, 4.85627260e-03f,
  1.18723296e-01f, 7.96352103e-02f, 6.15809597e-02f, 1.20202832e-01f, -6.73373276e-03f, 9.30717681e-03f, 2.91278847e-02f, 7.80860661e-03f, 6.39539585e-02f, 3.39641944e-02f,
  2.70510428e-02f, 6.95804730e-02f, -6.40789792e-02f, 1.31310355e-02f, -9.75782871e-02f, -7.20044151e-02f, -7.61360908e-03f, -3.65649946e-02f, -6.91759810e-02f, 1.36202564e-02f,
  3.52368988e-02f, -6.45905659e-02f, 4.94580157e-02f, 3.22168507e-02f, -4.54489095e-03f, 2.70391908e-02f, 1.12275362e-01f, 4.03867327e-02f, -1.13719404e-02f, -7.65479356e-02f,
  4.66443822e-02f, 4.85299006e-02f, 3.04058921e-02f, 3.18564512e-02f, -2.94122100e-03f, -1.15362536e-02f, 1.21640239e-03f, 2.25289054e-02f, -7.31974933e-03f, -1.90204326e-02f,
  -6.08152114e-02f, 1.35103276e-03f, 2.15001386e-02f, 4.90239561e-02f, -3.09720021e-02f, 2.56678388e-02f, 6.72175214e-02f, -3.16393636e-02f, 5.66859618e-02f, 3.64953838e-02f,
  5.33476993e-02f, 1.21043637e-01f, 1.01297107e-02f, 6.25410974e-02f, 7.55307153e-02f, 1.33501487e-02f, -5.20022549e-02f, -1.60357673e-02f, -1.68681387e-02f, 4.69575301e-02f,
  6.58442602e-02f, 7.22803399e-02f, -7.72835761e-02f, -1.58989674e-03f, -3.61372046e-02f, 6.02800064e-02f, 3.37712541e-02f, -1.27641276e-01f, -4.89113443e-02f, 1.68186948e-02f,
  8.49835500e-02f, -7.11937845e-02f, 3.83214504e-02f, 2.65120175e-02f, -7.93397427e-02f, -1.04522742e-01f, 9.97383446e-02f, -6.62994683e-02f, -6.67280108e-02f, 9.24997311e-03f,
  -1.43491253e-02f, 1.03053808e-01f, 7.83360749e-03f, 3.09655312e-02f, -1.04073631e-02f, 5.69884107e-02f, 2.34530829e-02f, -4.99716960e-02f, 4.10273336e-02f, -1.16729243e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 52)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 52;
const float L0_fan_Bp_bar_data[] = {
  2.05058321e-01f, -3.08081545e-02f, 7.34602213e-02f, 5.40348329e-02f, 9.89490747e-02f, 2.07731336e-01f, -4.70979251e-02f, 1.70134768e-01f, 1.82919219e-01f, 1.17386073e-01f,
  7.14332908e-02f, 7.27427080e-02f, 6.84084520e-02f, 2.25673877e-02f, 6.02610372e-02f, 1.42165467e-01f, 9.25890878e-02f, 8.51041526e-02f, 1.12899721e-01f, 2.53183365e-01f,
  5.30421026e-02f, 1.27738491e-01f, 3.93699445e-02f, 7.79532865e-02f, 2.91224346e-02f, 1.94968179e-01f, 1.88302711e-01f, 2.71605462e-01f, 7.89383799e-02f, 5.01642413e-02f,
  9.89354551e-02f, 1.18694315e-02f, 2.72701144e-01f, 1.19531237e-01f, 6.50454313e-02f, -4.91905808e-02f, 1.27647698e-01f, 3.82873602e-02f, -2.14777663e-02f, 8.01415443e-02f,
  5.32614440e-02f, 7.39901438e-02f, 9.95982066e-02f, 2.13412523e-01f, 1.71956450e-01f, 1.34498522e-01f, 1.53081223e-01f, 2.96359211e-02f, 2.89190747e-02f, 1.38853610e-01f,
  2.42305845e-01f, 1.93186015e-01f
};

// L1_fan_Wp (Shape: 6 x 64)
const int L1_fan_Wp_rows = 6;
const int L1_fan_Wp_cols = 64;
const float L1_fan_Wp_data[] = {
  5.95481321e-02f, -2.77724263e-04f, 2.12649032e-02f, -5.90352416e-02f, -8.40280056e-02f, -1.33884937e-01f, -8.07872936e-02f, 5.81216328e-02f, 1.18169822e-01f, -1.57201409e-01f,
  1.04229264e-01f, -2.00116679e-01f, 4.73680161e-02f, -4.05022496e-04f, -1.00146286e-01f, -1.03014648e-01f, 1.14140473e-01f, 1.23999342e-01f, 1.15641549e-01f, -8.71422440e-02f,
  6.09416738e-02f, 8.78415555e-02f, 1.76566690e-01f, 1.42628714e-01f, -1.53416589e-01f, -1.98929518e-01f, 3.04688923e-02f, 1.00001199e-02f, -2.09594935e-01f, -9.68750790e-02f,
  -6.26368076e-02f, -2.96880044e-02f, -1.91852510e-01f, 1.44250602e-01f, -2.48701319e-01f, 7.79336244e-02f, 8.72140154e-02f, 1.54533014e-01f, -5.49023114e-02f, -1.46175459e-01f,
  3.50801535e-02f, -1.63687766e-01f, 4.41665798e-02f, -1.82861447e-01f, -2.13403761e-01f, 8.87668207e-02f, -1.61848679e-01f, -6.03817543e-03f, -4.20609154e-02f, -9.95589122e-02f,
  -1.02824233e-01f, 5.42975925e-02f, -9.32958946e-02f, -1.03998724e-02f, 1.88555717e-01f, -4.65909764e-02f, 8.61903653e-02f, 2.60080487e-01f, -8.13488811e-02f, -1.19743794e-01f,
  9.21505094e-02f, -1.63457260e-01f, -1.72237396e-01f, 9.48854387e-02f, 4.68097590e-02f, -7.09423125e-02f, 1.11496903e-01f, -9.36260521e-02f, 6.00011386e-02f, 1.05135806e-01f,
  1.22332238e-01f, -5.27278287e-03f, -8.51844028e-02f, 6.83173165e-02f, -1.90869793e-02f, -1.76641177e-02f, 1.58758998e-01f, 1.28158912e-01f, 8.19412693e-02f, 9.89504084e-02f,
  2.03870520e-01f, 1.21744707e-01f, 9.14828386e-03f, -2.32265983e-02f, -9.38953161e-02f, -2.06993029e-01f, 8.52078944e-02f, 9.19534490e-02f, -4.51600924e-02f, 1.35448307e-01f,
  -5.46131916e-02f, -1.19792946e-01f, -7.89517313e-02f, -1.98093578e-01f, -1.52679369e-01f, 4.56758104e-02f, -4.89422008e-02f, 1.93794459e-01f, -2.51034826e-01f, -9.24228132e-02f,
  8.82506222e-02f, 8.50353464e-02f, -8.30748528e-02f, 7.01680332e-02f, 2.57976763e-02f, 1.00572526e-01f, 7.19549209e-02f, 3.76549922e-02f, 2.63104700e-02f, -7.43212029e-02f,
  -1.16173252e-01f, -1.98367953e-01f, -1.19188882e-01f, 3.65644544e-02f, -1.62393495e-01f, 1.52715653e-01f, 6.00746572e-02f, -4.66225483e-02f, -7.58254481e-03f, -9.44436938e-02f,
  3.98741364e-02f, 1.74624920e-01f, 1.20830446e-01f, -1.45863920e-01f, -8.91569108e-02f, -1.21434018e-01f, 7.43039772e-02f, -1.32106125e-01f, -1.23854868e-01f, 4.19960320e-02f,
  1.02008298e-01f, 6.59221224e-03f, 6.35940880e-02f, -5.71523979e-02f, -1.73278749e-02f, -5.38352169e-02f, 1.88245386e-01f, -1.94246739e-01f, 2.18142733e-01f, -1.43879890e-01f,
  -1.09319292e-01f, -2.09644720e-01f, -4.52921391e-02f, -5.82178235e-02f, -1.17285848e-01f, 1.06274165e-01f, -7.61555135e-02f, -1.04021929e-01f, 6.38590753e-02f, 1.21398479e-01f,
  2.00678095e-01f, 2.14643627e-02f, 9.54824239e-02f, -1.46853372e-01f, -3.43276607e-03f, 1.20966509e-01f, -1.95791975e-01f, 8.14768970e-02f, -8.26845765e-02f, 1.65458515e-01f,
  -7.06452727e-02f, 4.10508998e-02f, 2.28296202e-02f, 2.50115603e-01f, -1.56215921e-01f, 1.59290507e-02f, -3.70964259e-02f, -1.35009602e-01f, -4.54580188e-02f, -1.42517969e-01f,
  -8.18708688e-02f, -1.43448606e-01f, -1.48235232e-01f, -4.09347303e-02f, 1.24854177e-01f, 2.07384065e-01f, -9.82132182e-02f, -7.11042881e-02f, -4.33710814e-02f, 1.00774333e-01f,
  2.34972969e-01f, -1.25464663e-01f, -1.18976370e-01f, -1.28252849e-01f, 1.46041930e-01f, -1.08675268e-02f, 4.05524373e-02f, 1.35251835e-01f, -1.69839472e-01f, 9.20303762e-02f,
  -1.08588867e-01f, -3.00386716e-02f, -9.34552997e-02f, -4.32498679e-02f, -1.04361333e-01f, 3.85548361e-02f, 3.09034102e-02f, -5.13980649e-02f, -2.85656266e-02f, -1.35722429e-01f,
  2.39318728e-01f, -3.54863331e-02f, 2.65202165e-01f, -1.19236954e-01f, -8.46566260e-02f, 6.32250533e-02f, 1.54466376e-01f, 7.42570311e-02f, -2.11509377e-01f, 7.80931190e-02f,
  7.90719166e-02f, -1.48134917e-01f, 9.35611427e-02f, 6.11024909e-02f, 7.32569769e-02f, 2.00567022e-02f, 1.38235828e-02f, -8.95994250e-03f, -4.36096266e-02f, 2.68355429e-01f,
  8.92046243e-02f, -1.88635234e-02f, 1.48552552e-01f, 1.47337019e-01f, -1.50071815e-01f, 1.31917119e-01f, 1.34051427e-01f, 1.95417032e-01f, -1.48643732e-01f, 1.11946128e-01f,
  1.63872521e-02f, 1.36171281e-02f, 2.21419081e-01f, -4.70301956e-02f, 6.88037127e-02f, 1.52238645e-03f, 1.89205110e-02f, -1.78403169e-01f, 3.75590101e-02f, 1.45444989e-01f,
  3.41690588e-03f, 7.87037462e-02f, 2.86295861e-01f, -2.70848535e-02f, 9.03718770e-02f, 7.21945539e-02f, 7.36106336e-02f, 1.76844582e-01f, -4.23035696e-02f, -1.38327554e-01f,
  3.46454121e-02f, 3.69169973e-02f, 4.40403856e-02f, 1.57181472e-01f, -1.12166382e-01f, -3.47587951e-02f, -1.37050524e-01f, 4.46520075e-02f, -1.73381910e-01f, -1.33146733e-01f,
  -1.88929230e-01f, 2.59675719e-02f, 1.61420833e-02f, 1.01730287e-01f, -9.69661996e-02f, 6.06955662e-02f, -1.64703488e-01f, 9.82883424e-02f, 4.97274799e-03f, 1.43985212e-01f,
  -1.72020674e-01f, -1.74824223e-01f, 1.65273502e-01f, 7.96915293e-02f, 2.24796802e-01f, 4.21252176e-02f, 1.62785482e-02f, -1.25910774e-01f, -1.74774364e-01f, -3.53787616e-02f,
  -1.31396614e-02f, -7.73533061e-02f, 6.37777150e-02f, -3.55785415e-02f, 6.86335564e-02f, 1.19166769e-01f, 3.25878747e-02f, 4.42453176e-02f, 2.40247279e-01f, -1.46936655e-01f,
  1.07469499e-01f, -1.83952644e-01f, 1.14897974e-01f, 6.82836175e-02f, -7.48838037e-02f, -2.00026244e-01f, -3.14226374e-03f, -3.22660878e-02f, 1.82782561e-01f, 4.65854257e-03f,
  -2.27635488e-01f, 1.74884915e-01f, -5.95101491e-02f, -8.95600393e-02f, 3.69125940e-02f, -1.65308952e-01f, 1.80235565e-01f, 5.42459190e-02f, -1.05238467e-01f, -3.37497965e-02f,
  1.17650613e-01f, 1.80795133e-01f, -1.21622227e-01f, 1.59762844e-01f, -5.75645268e-02f, 1.60793453e-01f, 2.27357939e-01f, 2.78555024e-02f, 6.48990879e-03f, -1.28235698e-01f,
  -1.73586577e-01f, -9.38752815e-02f, 5.35942614e-02f, -9.65047181e-02f, -7.99126923e-02f, 3.55278477e-02f, -1.30881499e-02f, -2.69659199e-02f, 2.51812991e-02f, 2.32787039e-02f,
  -1.03593677e-01f, -6.16316684e-02f, 5.97709455e-02f, 1.39138848e-01f, -2.69456226e-02f, -4.11346778e-02f, -1.47452042e-01f, 1.09117970e-01f, -3.66115049e-02f, 3.19909751e-02f,
  -3.36726457e-02f, 1.03160396e-01f, 9.99024287e-02f, 1.91319838e-01f, -1.98435664e-01f, 1.21147648e-01f, 9.57940239e-03f, 2.19400562e-02f, -1.26873761e-01f, -7.62496218e-02f,
  -6.66138763e-03f, 3.01271607e-03f, 1.90841891e-02f, -2.66798530e-02f, -2.12578148e-01f, 4.36836760e-03f, 8.74932632e-02f, -1.48698628e-01f, -4.43649776e-02f, 6.50212541e-02f,
  6.54233471e-02f, 8.18963274e-02f, -3.38424668e-02f, 5.33041470e-02f, -7.13508502e-02f, -6.62933365e-02f, -1.50523037e-01f, 3.21111791e-02f, -1.11639284e-01f, -3.86682972e-02f,
  -1.76047340e-01f, 1.07895192e-02f, -7.68969804e-02f, -1.66865103e-02f, -8.70853812e-02f, -1.58022657e-01f, 1.93971530e-01f, -7.90379271e-02f, 1.61758274e-01f, -1.76538274e-01f,
  8.72405767e-02f, 1.74566302e-02f, -7.17622638e-02f, -2.63037179e-02f
};

// L1_fan_Wp_bar (Shape: 52 x 64)
const int L1_fan_Wp_bar_rows = 52;
const int L1_fan_Wp_bar_cols = 64;
const float L1_fan_Wp_bar_data[] = {
  -1.75720137e-02f, -5.52199632e-02f, 1.73654914e-01f, 9.08811316e-02f, -1.44116566e-01f, -1.79445576e-02f, 2.01577485e-01f, -1.77593797e-01f, 1.57306120e-01f, -1.83673903e-01f,
  1.59880072e-02f, -2.15515047e-01f, -2.81355709e-01f, -1.07409202e-01f, 8.88595134e-02f, -9.47816223e-02f, 2.62439132e-01f, 1.32563308e-01f, -1.46647934e-02f, 6.07790425e-02f,
  -7.44844079e-02f, 2.01754048e-01f, -3.26126218e-02f, 9.14687961e-02f, -3.24486569e-02f, -9.07331407e-02f, -1.58400536e-01f, 5.42001314e-02f, 1.81769989e-02f, 3.29395905e-02f,
  5.66819757e-02f, 1.95390135e-01f, 6.37479648e-02f, 1.16379723e-01f, -1.97308451e-01f, 1.00576825e-01f, -1.12058729e-01f, -2.32991460e-03f, -7.07238819e-03f, -1.44192591e-01f,
  -9.77656394e-02f, -6.50775805e-02f, 2.38156063e-03f, 2.86286529e-02f, -1.01458840e-01f, -1.50259733e-01f, -1.31327450e-01f, 1.94328800e-01f, 5.85792921e-02f, -2.93615442e-02f,
  -1.61516830e-01f, -1.97075874e-01f, 2.83305291e-02f, 7.99364597e-02f, -1.11291118e-01f, -1.34526014e-01f, 7.60823712e-02f, -2.31888238e-03f, -1.49626359e-01f, -1.17311452e-03f,
  -1.04368165e-01f, -8.62957537e-03f, -1.65324390e-01f, 1.23339184e-02f, 7.72426501e-02f, 5.57423197e-02f, 1.24388985e-01f, 1.34328008e-02f, 1.32653832e-01f, 1.27653942e-01f,
  3.34568210e-02f, 7.93653876e-02f, -4.02828753e-02f, -3.14113870e-02f, 1.62222609e-01f, -9.40007940e-02f, 1.02624282e-01f, 4.37046960e-02f, 3.77499200e-02f, 7.86243677e-02f,
  2.28458285e-01f, 1.21221565e-01f, 1.22543007e-01f, -1.28233671e-01f, -6.92730322e-02f, -1.46564141e-01f, 8.65406319e-02f, 2.00757518e-01f, -1.77990928e-01f, 1.14391871e-01f,
  -9.91794765e-02f, -8.23135301e-03f, 1.25107080e-01f, 6.71158582e-02f, -1.09341517e-01f, 8.14594850e-02f, 9.71268266e-02f, 2.64655799e-01f, -7.35814348e-02f, -2.64924634e-02f,
  1.84350148e-01f, 2.05765039e-01f, 9.24081430e-02f, 1.38972744e-01f, 8.46903399e-02f, 1.88897952e-01f, -1.44824773e-01f, 1.43328637e-01f, -9.43700969e-02f, 8.38043261e-03f,
  -1.81192346e-02f, 6.04483560e-02f, -1.48819923e-01f, 9.96092036e-02f, 3.52824703e-02f, 4.06270958e-02f, 1.44906133e-01f, -1.09882377e-01f, 8.97296742e-02f, 9.03520659e-02f,
  1.04769170e-01f, 2.07341641e-01f, 8.05688277e-02f, -1.21316515e-01f, 1.07336923e-01f, -7.31316507e-02f, 4.26041484e-02f, 2.50589140e-02f, 9.71342772e-02f, -4.21845242e-02f,
  -7.04428554e-03f, 1.17189668e-01f, -7.38934129e-02f, 4.66009639e-02f, 1.79878190e-01f, -1.66216180e-01f, -8.11994001e-02f, -1.54427826e-01f, 1.06543273e-01f, 1.29886657e-01f,
  -1.99781358e-01f, 1.32415602e-02f, 1.40292823e-01f, -1.26980081e-01f, 1.70183420e-01f, -1.64863374e-02f, 9.55549330e-02f, 9.28671062e-02f, 3.12768519e-02f, 1.17864124e-01f,
  -1.77748844e-01f, -2.27559164e-01f, 1.42955437e-01f, -1.30085602e-01f, 7.70114809e-02f, 2.00181287e-02f, 1.18561916e-01f, 4.30993848e-02f, 7.93337729e-03f, 1.13266155e-01f,
  4.19232175e-02f, -8.32866803e-02f, 3.31262976e-01f, 1.49345160e-01f, -7.82310441e-02f, -2.41840500e-02f, -8.83836672e-03f, 5.73856384e-02f, 1.49428904e-01f, -1.46601170e-01f,
  8.78355205e-02f, 6.79071918e-02f, 1.34221930e-02f, -1.00459985e-01f, 9.70656797e-03f, 1.70084700e-01f, 1.36007428e-01f, 1.84189126e-01f, 1.11131296e-01f, 1.00887548e-02f,
  6.24637417e-02f, 3.19001824e-02f, 9.00638551e-02f, 2.72980519e-02f, 2.28068084e-02f, -3.04091945e-02f, -6.67219460e-02f, 3.11530046e-02f, -7.09706396e-02f, 4.28224318e-02f,
  -1.25294164e-01f, 6.56127334e-02f, 2.56681830e-01f, 8.05659071e-02f, 2.45593637e-01f, 1.53620183e-01f, 7.04497173e-02f, 3.22228782e-02f, 1.89348206e-01f, -1.43340649e-02f,
  -6.78610653e-02f, 1.95533887e-01f, 2.26271182e-01f, 1.30285501e-01f, -5.07425182e-02f, -8.92789960e-02f, 2.60151803e-01f, 4.78167720e-02f, 3.70676629e-02f, -1.07839718e-01f,
  -1.61736440e-02f, 6.95602149e-02f, 2.08279174e-02f, 1.89149696e-02f, -1.35018583e-02f, 1.84403770e-02f, 3.52816395e-02f, -6.45361375e-03f, -2.66420767e-02f, -1.21234991e-01f,
  2.87678212e-01f, 1.95013583e-01f, 1.72220424e-01f, 1.88114986e-01f, -3.82641447e-03f, 1.85270727e-01f, 2.27153271e-01f, 8.05238560e-02f, -4.88712415e-02f, 1.35425597e-01f,
  1.77277505e-01f, 1.80085599e-01f, -5.59869371e-02f, 1.03601180e-01f, 1.38680831e-01f, 2.22171485e-01f, 2.90350944e-01f, -1.06308438e-01f, 5.21886833e-02f, -5.41233905e-02f,
  4.62665856e-02f, 3.03238481e-01f, 1.63689375e-01f, -8.01217407e-02f, 1.97617993e-01f, 3.10476180e-02f, -2.39735782e-01f, -3.66861895e-02f, -1.18059129e-01f, -2.72351533e-01f,
  -1.63159464e-02f, 6.73855692e-02f, -6.58859387e-02f, 5.47146425e-02f, -3.46518904e-02f, -6.19371012e-02f, 3.12228315e-02f, 1.86737791e-01f, -4.19308059e-02f, -1.93662830e-02f,
  3.62309217e-02f, 1.69359297e-01f, 5.03936037e-02f, -1.31521113e-02f, 2.04427302e-01f, 1.34000570e-01f, -9.06233490e-02f, -1.80679485e-01f, 3.10902655e-01f, 9.24814045e-02f,
  -1.05317615e-01f, 2.84436997e-02f, 7.53813088e-02f, 1.68203756e-01f, 1.69776782e-01f, -6.13279901e-02f, 1.50020540e-01f, 1.00491293e-01f, -1.96095794e-01f, -7.58839622e-02f,
  6.96777999e-02f, 1.84908107e-01f, 9.29341316e-02f, 2.68477827e-01f, -1.10592777e-02f, -4.76352274e-02f, -6.27757981e-02f, -5.55817503e-03f, 1.73127994e-01f, -2.09104121e-01f,
  -6.28860295e-02f, 5.45136146e-02f, 2.29833186e-01f, -8.45974311e-02f, 5.48014008e-02f, -7.81264622e-03f, -2.43557002e-02f, 6.11004978e-02f, -3.93104479e-02f, 1.82372227e-01f,
  3.35682333e-02f, -1.62209287e-01f, 2.14880094e-01f, 1.51464790e-01f, 6.22944161e-02f, -1.88083425e-01f, 1.39908819e-02f, 3.05750102e-01f, 1.86245114e-01f, 6.18856307e-03f,
  4.56320643e-02f, 6.67212456e-02f, 5.54543175e-02f, -1.05892539e-01f, 2.48248532e-01f, 1.05957119e-02f, 1.61905229e-01f, 8.61103907e-02f, 2.59772509e-01f, 8.18303525e-02f,
  4.83137220e-02f, 1.23980269e-02f, 1.13146111e-01f, 1.05746813e-01f, 2.19367370e-01f, -7.07502440e-02f, 4.00873013e-02f, -2.39888877e-01f, 1.77839205e-01f, -6.08527735e-02f,
  1.67089269e-01f, -1.53842747e-01f, 1.00609638e-01f, 5.64532727e-02f, 3.11883613e-02f, 6.21367916e-02f, -9.19534639e-02f, 1.97261378e-01f, -4.35820818e-02f, -1.47382542e-01f,
  1.69555202e-01f, 1.02638677e-02f, 2.21747681e-01f, 1.70957550e-01f, -2.45388430e-02f, -7.76522458e-02f, -7.73071721e-02f, 2.84592807e-01f, -2.12658092e-01f, -8.76480117e-02f,
  1.92671180e-01f, 1.58185989e-01f, -7.20709786e-02f, 2.93479592e-01f, -1.29304871e-01f, 1.29873753e-01f, 5.26115596e-02f, -3.13894972e-02f, 4.17899825e-02f, 8.34937580e-03f,
  8.11317489e-02f, -1.32955253e-01f, 6.74493611e-02f, 4.77038212e-02f, -7.44164139e-02f, -9.02433917e-02f, 6.83701709e-02f, 1.84954181e-01f, 5.60934916e-02f, -4.01933230e-02f,
  -1.10411994e-01f, 1.19945548e-01f, 2.88161784e-01f, -1.67174879e-02f, -6.05704039e-02f, -2.18610108e-01f, 2.98515201e-01f, -8.75575319e-02f, -3.11297718e-02f, -1.52094886e-02f,
  -3.19361210e-01f, 1.01990193e-01f, 4.10680398e-02f, 5.07709272e-02f, 2.39534527e-01f, -1.16781471e-02f, -5.83620593e-02f, 9.64987874e-02f, -5.07981190e-03f, 1.48689479e-01f,
  -1.51121421e-02f, 2.25991771e-01f, -8.05291608e-02f, 6.91052079e-02f, -2.42372930e-01f, -7.13351145e-02f, 2.71868289e-01f, -4.42737900e-02f, -1.00295365e-01f, 9.26250145e-02f,
  3.34836692e-02f, 1.29979268e-01f, -7.00440630e-02f, 1.64383501e-01f, 1.68227673e-01f, 2.26277754e-01f, -5.35124913e-02f, -1.05846832e-02f, 2.09257007e-01f, 1.88713267e-01f,
  1.27208933e-01f, 2.59596884e-01f, 3.14339134e-03f, 3.76369245e-02f, 1.70073479e-01f, 3.30863856e-02f, 2.13367507e-01f, 3.82835120e-02f, -5.07529862e-02f, 1.24554560e-01f,
  1.67739466e-01f, -1.13504929e-02f, -1.79806724e-02f, -2.47073895e-03f, -7.04393163e-02f, -3.27398069e-02f, 2.01621071e-01f, 7.75970845e-03f, 1.95605636e-01f, 2.14905411e-01f,
  1.03607081e-01f, 1.29460339e-02f, 9.33829248e-02f, -1.62584484e-01f, -1.34718508e-01f, 7.88563788e-02f, 3.71334627e-02f, 8.78128931e-02f, 5.24417385e-02f, 7.04737529e-02f,
  -2.46408321e-02f, 4.67565954e-02f, -1.33658713e-02f, 1.47186741e-01f, 1.61091641e-01f, 2.68856019e-01f, 1.80484548e-01f, -1.21595031e-02f, 2.21966207e-02f, 1.12942100e-01f,
  1.86050730e-03f, 4.70098183e-02f, 7.57043213e-02f, 2.12422639e-01f, 5.47223426e-02f, 8.91648903e-02f, -8.72076452e-02f, 4.32927608e-02f, -3.30467105e-01f, 1.66917503e-01f,
  7.00701699e-02f, 7.56750926e-02f, -1.25846758e-01f, -4.57227156e-02f, 1.99210569e-01f, 1.26325816e-01f, -2.50583626e-02f, 1.47174075e-01f, 1.25705153e-01f, 2.78269742e-02f,
  -3.06541640e-02f, -6.79089036e-03f, -3.93367559e-02f, -1.02609992e-02f, 1.03059769e-01f, -4.88945991e-02f, -8.71152803e-03f, 5.81570156e-02f, -4.36764099e-02f, 4.93353754e-02f,
  2.53227443e-01f, -1.58393472e-01f, -1.43254444e-01f, -1.41227171e-01f, -1.58025399e-02f, -2.11153701e-02f, -6.28092661e-02f, -1.54697597e-02f, -1.47187129e-01f, 1.79867193e-01f,
  7.05889985e-02f, 1.26795992e-01f, 1.23052532e-02f, 9.03897882e-02f, 1.76178992e-01f, -6.46876320e-02f, 4.64000367e-02f, -1.50215656e-01f, -1.78049147e-01f, 1.14382118e-01f,
  -3.83672230e-02f, -1.49706646e-03f, 2.78155953e-02f, 1.32128209e-01f, -5.55640161e-02f, 1.69234335e-01f, 1.16220139e-01f, 1.99771628e-01f, 5.18016368e-02f, 3.88089530e-02f,
  2.13844553e-01f, 1.91580400e-01f, 9.13912281e-02f, 4.12611030e-02f, 8.79293904e-02f, 1.38686877e-02f, 1.08730726e-01f, 4.06432571e-03f, -8.96142572e-02f, 1.19274206e-01f,
  2.21823707e-01f, -2.96708960e-02f, 1.28214628e-01f, -2.49457523e-01f, 1.61680847e-01f, 6.94047958e-02f, -3.89686972e-02f, 1.56920508e-01f, -1.01634748e-01f, 2.15720609e-01f,
  -6.16670214e-02f, 3.71639803e-02f, 4.64176647e-02f, 1.37581542e-01f, -1.15328766e-01f, 1.38657600e-01f, 8.54436215e-03f, 6.59392104e-02f, -8.63132775e-02f, 2.77640969e-01f,
  1.07381670e-02f, -8.65572244e-02f, -5.24662063e-02f, -1.08789816e-01f, 1.35493636e-01f, 4.69677038e-02f, -9.64230746e-02f, 1.62652910e-01f, 1.82038784e-01f, 3.26195434e-02f,
  2.29791161e-02f, 7.89985955e-02f, -2.42957715e-02f, 5.44967167e-02f, 7.17358068e-02f, 1.13017239e-01f, 1.93612706e-02f, -1.13680303e-01f, 3.03514618e-02f, -9.58519429e-02f,
  -1.15184374e-01f, -1.33054838e-01f, 1.01868436e-02f, 1.85629979e-01f, 2.08735779e-01f, -7.39768744e-02f, 7.36380965e-02f, -6.72315806e-03f, 2.80280679e-01f, -3.99114862e-02f,
  1.35423958e-01f, 4.25237492e-02f, -7.76372179e-02f, 6.17661029e-02f, 2.17503592e-01f, -3.24810781e-02f, 1.30088910e-01f, 1.43916667e-01f, 7.51112327e-02f, 4.14807051e-02f,
  9.77187231e-02f, 1.66946843e-01f, -1.81204081e-02f, -1.12890579e-01f, 2.13387400e-01f, -8.00884236e-03f, 1.38911501e-01f, -2.43349239e-01f, -2.10448597e-02f, -1.00420251e-01f,
  3.17112124e-03f, 1.40117973e-01f, -9.11584571e-02f, 6.61298409e-02f, -2.03092247e-02f, 1.46799847e-01f, 1.96189523e-01f, 2.22170278e-01f, 1.23757847e-01f, 1.48878723e-01f,
  1.68413043e-01f, -8.06657597e-02f, 2.63496395e-02f, 2.30275363e-01f, -5.73452078e-02f, 8.84107407e-03f, 1.99724570e-01f, 1.85242847e-01f, 8.39592591e-02f, 1.68430120e-01f,
  -1.24997705e-01f, 2.35148445e-01f, -9.22368374e-03f, -6.96209222e-02f, -8.42715949e-02f, 1.09615587e-01f, -2.63020750e-02f, -1.10403426e-01f, 1.26594499e-01f, -1.01823024e-01f,
  1.53658241e-01f, -1.21358901e-01f, 2.06546023e-01f, 1.22823395e-01f, 1.19863562e-01f, -7.58628398e-02f, -7.00610727e-02f, 1.29829407e-01f, 2.61289537e-01f, 5.26565835e-02f,
  1.05854094e-01f, -5.91635294e-02f, 1.05667263e-01f, -1.64813489e-01f, 1.19205981e-01f, 1.97612777e-01f, -3.07430532e-02f, 2.84248069e-02f, 1.67676270e-01f, 2.19145417e-01f,
  1.15206152e-01f, 2.10015371e-01f, 1.04626380e-01f, 3.62277217e-02f, 1.74521714e-01f, 1.53138071e-01f, -2.40922589e-02f, -1.33895800e-01f, 9.49795470e-02f, -1.83720291e-01f,
  1.37049645e-01f, 2.87378561e-02f, -8.31238180e-02f, 1.04017043e-02f, -6.81294575e-02f, 2.54038483e-01f, -5.14047481e-02f, -3.55878770e-02f, 2.17584580e-01f, 7.83370063e-02f,
  2.51222640e-01f, 2.21871939e-02f, -8.23303536e-02f, 1.00544959e-01f, 5.08283749e-02f, 1.10242993e-01f, -1.56942517e-01f, 3.11904013e-01f, -2.27376577e-02f, -1.24924793e-03f,
  -8.17369148e-02f, 1.96449950e-01f, -6.79877624e-02f, 1.61698610e-01f, 1.37983233e-01f, 2.19431296e-01f, -1.73990816e-01f, 2.08892763e-01f, 1.24603413e-01f, 1.55055165e-01f,
  2.68400788e-01f, 1.32746041e-01f, -5.98097481e-02f, 1.20075077e-01f, 1.66302130e-01f, -8.14797580e-02f, 1.56529993e-01f, 6.44807816e-02f, -1.30811289e-01f, 1.10786423e-01f,
  2.23432839e-01f, -1.68764979e-01f, 1.24561951e-01f, -2.70987395e-02f, 1.75225854e-01f, 1.88330054e-01f, 2.37393931e-01f, -2.65614372e-02f, 1.73729777e-01f, 1.41053140e-01f,
  -7.15479031e-02f, 1.92618862e-01f, 8.86464790e-02f, -1.20226748e-01f, 2.89628655e-01f, 3.15435201e-01f, 4.19506021e-02f, 1.31592035e-01f, 1.76950231e-01f, 1.93896115e-01f,
  -1.32474765e-01f, -1.06079213e-01f, -1.28270328e-01f, -2.55193710e-02f, 1.13085911e-01f, -1.76886365e-01f, 8.17748010e-02f, -1.84441447e-01f, 2.13669389e-01f, 4.43762094e-02f,
  -8.20452049e-02f, 7.90053308e-02f, -1.97172716e-01f, 1.65821746e-01f, 9.14182290e-02f, 2.59559274e-01f, 1.27477080e-01f, 1.30548939e-01f, 6.59762025e-02f, -1.51834190e-01f,
  1.41441613e-01f, 1.46343634e-01f, 4.33786027e-02f, 1.71683133e-01f, -2.47909781e-02f, -8.96861181e-02f, -1.18666537e-01f, 2.20789716e-01f, 1.52436402e-02f, 7.89203718e-02f,
  -1.59360498e-01f, -1.11141466e-01f, -4.53384370e-02f, 1.42244354e-01f, 4.77976203e-02f, 9.91823450e-02f, 5.76562695e-02f, 1.48884524e-02f, 2.78465688e-01f, 1.85686529e-01f,
  1.86359644e-01f, -3.24999504e-02f, -5.62768728e-02f, 1.07785776e-01f, -1.26548916e-01f, 1.20055474e-01f, 3.40362675e-02f, 2.36468345e-01f, -1.41666353e-01f, 3.38435397e-02f,
  9.49714035e-02f, -2.26251613e-02f, -7.26463795e-02f, 2.60821313e-01f, -1.41832158e-01f, 2.01298028e-01f, 3.96797545e-02f, 5.35620227e-02f, 1.94640040e-01f, 7.00516254e-02f,
  -7.93026760e-02f, 1.67173922e-01f, 1.65238194e-02f, 9.26931426e-02f, -8.50659087e-02f, -5.20738810e-02f, -1.02427274e-01f, -8.81352872e-02f, -6.15877584e-02f, 1.90076262e-01f,
  -1.50260434e-01f, -1.24789573e-01f, 2.05459118e-01f, -1.01102024e-01f, 1.70561060e-01f, -4.02763039e-02f, 1.38092414e-01f, 2.20314130e-01f, 2.23813206e-02f, -1.18839212e-01f,
  1.11639053e-01f, -1.39756843e-01f, 1.07570291e-01f, 8.36392641e-02f, -9.13014412e-02f, 2.09117457e-02f, 3.21146585e-02f, 2.13544041e-01f, -3.74069661e-02f, 1.14216074e-01f,
  -1.10482804e-01f, 1.90972328e-01f, 2.39941493e-01f, 1.66117456e-02f, -6.25161678e-02f, 2.58778870e-01f, -2.34875213e-02f, -1.33967632e-02f, 1.35994196e-01f, 1.39531344e-01f,
  1.97448045e-01f, -8.05968419e-02f, -1.11552507e-01f, 2.65355855e-01f, -5.77361248e-02f, -1.24059962e-02f, 6.04483709e-02f, 1.85468674e-01f, 1.88750461e-01f, -1.25158176e-01f,
  -5.63240647e-02f, 2.18456641e-01f, 2.77812153e-01f, 2.38871127e-01f, 6.06365385e-04f, 2.55205959e-01f, 3.45767546e-03f, 1.70799434e-01f, 1.36407092e-01f, -5.54194348e-03f,
  -2.01255679e-01f, -6.84798285e-02f, 1.06180027e-01f, 1.27884559e-02f, 4.33131009e-02f, 1.29916668e-01f, 1.28137037e-01f, 1.85880139e-01f, -5.82056381e-02f, 1.58943176e-01f,
  -3.12986851e-01f, 1.92890599e-01f, -2.93439001e-01f, 1.91918120e-01f, 1.38399020e-01f, 1.85343355e-01f, 1.24238312e-01f, 3.17237675e-02f, 2.43277192e-01f, 1.32462442e-01f,
  -5.18244244e-02f, 1.97841197e-01f, -1.92723081e-01f, -1.07082099e-01f, 1.75104871e-01f, 1.28213570e-01f, -7.55140558e-02f, 8.87125283e-02f, 3.86684686e-02f, -2.14406729e-01f,
  1.72782205e-02f, -7.37470090e-02f, -4.93508391e-02f, 5.36353998e-02f, 5.83320521e-02f, 1.23354986e-01f, -2.18494073e-01f, -1.70402959e-01f, 5.17674796e-02f, 1.46452442e-01f,
  7.28941038e-02f, 2.01612949e-01f, -8.05962160e-02f, 1.00672379e-01f, 1.01302654e-01f, 7.19464645e-02f, 3.67236286e-02f, 1.54965252e-01f, -4.61986773e-02f, -1.12981357e-01f,
  1.19297758e-01f, 1.51563108e-01f, -2.15907931e-01f, -1.02925440e-02f, -1.80647463e-01f, -1.04522854e-02f, 8.87235105e-02f, 4.07212302e-02f, 1.14761680e-01f, 2.29417250e-01f,
  8.79100412e-02f, -3.30830924e-02f, -1.84433125e-02f, 5.17034195e-02f, 1.59154370e-01f, -4.89551537e-02f, 6.51303902e-02f, 7.20874891e-02f, 1.89495340e-01f, 2.77588129e-01f,
  1.67292655e-01f, 1.23495504e-01f, 1.34843692e-01f, 2.57396936e-01f, -5.67835346e-02f, 1.85373828e-01f, 8.14046413e-02f, 7.55708897e-03f, 1.15491383e-01f, -2.60432996e-02f,
  7.89473504e-02f, 1.31807253e-01f, -1.53833926e-01f, 1.75392091e-01f, -1.00158811e-01f, 6.77424669e-02f, 2.33513236e-01f, 9.71117094e-02f, 1.20002531e-01f, 4.68390770e-02f,
  1.39596000e-01f, 2.64047086e-01f, 1.42509409e-03f, 2.32422173e-01f, 1.86256096e-01f, -7.19438195e-02f, 4.90749925e-02f, 6.38213903e-02f, 2.63471007e-02f, -7.08375126e-02f,
  1.76359668e-01f, 1.80663407e-01f, 1.79987028e-02f, -1.03693843e-01f, 2.75505185e-01f, 2.52070546e-01f, -5.63661344e-02f, 1.92289859e-01f, 1.38648927e-01f, 3.04328978e-01f,
  2.41377071e-01f, -2.60252766e-02f, 2.74323195e-01f, 1.27003163e-01f, -6.83370754e-02f, 1.64538026e-01f, -7.73521960e-02f, 6.03205971e-02f, 2.59977102e-01f, -2.96858754e-02f,
  -6.12329803e-02f, -6.78922283e-03f, 1.59856319e-01f, -1.28391460e-01f, 1.64007828e-01f, 8.10432062e-02f, -1.40146479e-01f, 1.90623403e-01f, 2.39614353e-01f, 1.62169978e-01f,
  3.08919419e-02f, 1.44826531e-01f, 3.00326310e-02f, 1.03024863e-01f, 1.04395822e-02f, 1.77000314e-01f, -1.54031992e-01f, 9.55333561e-02f, -5.00705801e-02f, 1.32017314e-01f,
  -2.36615941e-01f, -1.20291337e-02f, 2.48734221e-01f, 1.87000483e-02f, -8.32486302e-02f, 7.31279375e-03f, -1.67875633e-01f, -4.10324484e-02f, 1.25870192e-02f, 5.95599599e-02f,
  1.15069143e-01f, 1.55435801e-01f, 2.19006948e-02f, 8.84490982e-02f, -2.32076552e-02f, 6.91353679e-02f, 1.89462662e-01f, 1.33481815e-01f, 8.20158720e-02f, 1.23662189e-01f,
  6.85766935e-02f, -1.15266919e-01f, 8.21464602e-03f, -9.34843272e-02f, -1.51883781e-01f, -1.02604643e-01f, 5.19655459e-02f, -1.09446362e-01f, -4.97825444e-02f, -1.03261314e-01f,
  -4.93762270e-02f, -1.16150230e-01f, -4.03275937e-02f, -1.08014628e-01f, 1.05827330e-02f, 9.59490314e-02f, 1.35945082e-01f, -1.06997378e-01f, 5.03180735e-02f, -1.85494676e-01f,
  -1.27927186e-02f, 2.50875145e-01f, -4.92262170e-02f, 4.50748242e-02f, 5.12780659e-02f, 1.12135276e-01f, 6.91377595e-02f, -1.21935070e-01f, 8.61885622e-02f, 1.76122919e-01f,
  2.18397036e-01f, -1.77651295e-03f, 1.02131680e-01f, 1.51923478e-01f, -3.90652716e-02f, 9.47220549e-02f, 5.42128570e-02f, 7.23820627e-02f, 1.60038069e-01f, -1.48633540e-01f,
  -1.28269747e-01f, -1.21732309e-01f, 3.28713804e-01f, -1.04374662e-01f, 1.68310136e-01f, -7.62044117e-02f, 2.23482354e-03f, -1.90762952e-01f, -2.21910745e-01f, -2.36637075e-03f,
  1.61088586e-01f, 9.72691998e-02f, 1.18042845e-02f, -4.72488627e-02f, 9.82704684e-02f, 1.62839890e-01f, -1.26278102e-01f, 4.45463732e-02f, -3.75284739e-02f, -8.34963992e-02f,
  -3.01508307e-02f, 2.96230733e-01f, -2.18503758e-01f, -4.64883307e-03f, 5.35205007e-02f, 9.73447189e-02f, -3.29595432e-02f, 5.94987758e-02f, -1.09693445e-01f, 2.00077921e-01f,
  -5.49376868e-02f, 1.82543129e-01f, 6.36502281e-02f, -1.58269498e-02f, 1.75897241e-01f, -1.83919087e-01f, -1.87046286e-02f, -1.54810280e-01f, -9.68335569e-02f, -8.07293579e-02f,
  1.25615075e-01f, 2.09174100e-02f, -1.71236452e-02f, -7.10373446e-02f, 1.93293124e-01f, 1.55879587e-01f, 1.07525103e-01f, -1.07541293e-01f, 1.97725728e-01f, 1.49264246e-01f,
  1.59309745e-01f, 1.31371826e-01f, -1.25253618e-01f, 9.77477524e-03f, 8.22333712e-03f, 2.67668534e-02f, -2.55685057e-02f, 1.45514488e-01f, 3.58521193e-02f, 1.13636397e-01f,
  1.16019227e-01f, 2.43554618e-02f, 1.48815036e-01f, 1.57680467e-01f, 3.76017727e-02f, 1.85807794e-01f, -6.47383034e-02f, 2.45270692e-02f, 1.11893132e-01f, 1.94714144e-01f,
  1.09116761e-02f, 2.47807622e-01f, 2.03700606e-02f, 2.08035797e-01f, 1.69160426e-01f, -4.19040360e-02f, 2.11839825e-01f, -1.22449495e-01f, -1.13183007e-01f, -2.57331461e-01f,
  -5.62797813e-03f, 5.03483005e-02f, -1.12325981e-01f, 2.24828690e-01f, -9.45655257e-02f, -1.43521234e-01f, 2.25237876e-01f, -1.33418992e-01f, 1.06485002e-02f, 1.19747750e-01f,
  5.77794127e-02f, 2.24741742e-01f, 1.29825443e-01f, -1.55743659e-01f, 2.11314932e-01f, 5.70466593e-02f, 8.99172798e-02f, 2.44248107e-01f, 2.76817501e-01f, 2.09951743e-01f,
  3.18951625e-03f, 1.97974205e-01f, 5.59858605e-02f, 1.57889500e-01f, -1.01470165e-01f, 3.97707261e-02f, -1.73937567e-02f, 1.92650914e-01f, 1.97644487e-01f, 2.61576362e-02f,
  -1.44067764e-01f, -6.32182434e-02f, 4.93039861e-02f, 9.63857770e-02f, -3.14914063e-02f, 1.90236941e-01f, 1.72167003e-01f, -6.02287576e-02f, 1.72164008e-01f, 3.15220281e-02f,
  1.49330333e-01f, -2.06588894e-01f, 1.73561871e-01f, 4.73762909e-03f, 6.66505247e-02f, -5.81887225e-03f, -5.05830050e-02f, 9.83291641e-02f, 1.37023062e-01f, -9.76772383e-02f,
  -3.29506516e-01f, 6.93714991e-02f, -3.77948791e-01f, -1.10060014e-01f, 1.55492052e-01f, 2.94740461e-02f, -1.20539859e-01f, -2.57745862e-01f, 2.52560735e-01f, 1.15979604e-01f,
  -1.25528835e-02f, 2.29803473e-01f, -1.49665415e-01f, 8.17059074e-03f, 7.09900558e-02f, 3.15002650e-02f, -2.36096382e-02f, -1.28052115e-01f, 1.68510079e-01f, -3.47564250e-01f,
  -5.54796867e-02f, -3.81822363e-02f, 1.00077562e-01f, 3.11134011e-03f, 1.22610688e-01f, 5.76336384e-02f, -2.14142084e-01f, -1.55700728e-01f, 1.10782713e-01f, 1.09682798e-01f,
  -2.76482940e-01f, -9.06778798e-02f, -2.00661659e-01f, 1.05060905e-01f, 1.78402528e-01f, -6.80301562e-02f, 2.15699300e-01f, 2.80025005e-01f, -8.34767595e-02f, -1.24451973e-01f,
  1.49664566e-01f, -1.92405030e-01f, -1.69467762e-01f, 2.46486664e-01f, -1.22047462e-01f, 1.09122157e-01f, -1.56272888e-01f, 8.03409070e-02f, -1.63686931e-01f, 1.23794064e-01f,
  -7.86821246e-02f, 7.85427988e-02f, 1.26002476e-01f, 7.88040161e-02f, -1.14339581e-02f, 1.62487462e-01f, 1.19075835e-01f, 4.02179100e-02f, 1.17050812e-01f, 8.65527838e-02f,
  2.09623836e-02f, 6.61230162e-02f, 1.08681075e-01f, -1.46932811e-01f, 2.17896208e-01f, -2.14744210e-01f, 2.69480139e-01f, -1.20084628e-01f, -1.54629573e-01f, 8.78405757e-03f,
  1.04284108e-01f, 1.45976052e-01f, 1.67416200e-01f, 1.88345447e-01f, 2.01192260e-01f, 1.57016128e-01f, 4.24727648e-02f, 8.65955725e-02f, 4.49470282e-02f, 5.56018353e-02f,
  -7.57280691e-03f, 1.05257221e-01f, -8.45971927e-02f, 1.28664240e-01f, -2.75032874e-02f, 1.55498192e-01f, 7.54563063e-02f, 1.55392572e-01f, 4.88256179e-02f, 1.21444032e-01f,
  3.04809604e-02f, 1.94289714e-01f, 4.75253873e-02f, 1.92290738e-01f, 1.06227938e-02f, 1.36210799e-01f, 1.97613463e-01f, 3.76195051e-02f, 3.42881717e-02f, 7.52843693e-02f,
  5.45898117e-02f, 2.19350569e-02f, 1.39510050e-01f, 2.25885630e-01f, 2.78269239e-02f, 1.79197505e-01f, 2.36794561e-01f, -1.08028628e-01f, 1.37049794e-01f, 1.05804518e-01f,
  2.71272361e-01f, 1.20478466e-01f, 1.17291264e-01f, 1.81251559e-02f, 7.41397813e-02f, -4.50515300e-02f, 1.43517941e-01f, 3.34617193e-03f, 7.34453425e-02f, -1.92444189e-03f,
  1.04461491e-01f, 4.18722630e-02f, 1.53876439e-01f, 1.39617920e-01f, 6.35834858e-02f, 5.32969758e-02f, -3.83394510e-02f, -6.80971295e-02f, -1.98529840e-01f, 4.43578102e-02f,
  -1.28219411e-01f, 1.76582962e-01f, 2.84429267e-02f, -1.16898544e-01f, 1.73488691e-01f, -9.94108543e-02f, -6.33056089e-02f, -1.89962033e-02f, -1.43267170e-01f, 2.69936532e-01f,
  2.11825341e-01f, 2.10968331e-01f, -1.43107533e-01f, -2.01339409e-01f, 1.02620378e-01f, -8.22600164e-03f, 6.50109425e-02f, 8.29328001e-02f, 2.52081752e-01f, 1.08804062e-01f,
  1.86343461e-01f, -2.69764233e-02f, 1.23112172e-01f, -1.58766001e-01f, 1.43063009e-01f, -3.51176299e-02f, -7.37168714e-02f, 1.26757279e-01f, -1.57630001e-03f, 1.51367322e-01f,
  -1.99028879e-01f, -4.27659079e-02f, 6.30749315e-02f, 5.32849543e-02f, 2.64163256e-01f, 1.23315163e-01f, 1.81503400e-01f, -7.98385143e-02f, 1.22377440e-01f, 1.81502938e-01f,
  -2.88199503e-02f, -2.77530253e-02f, -1.92900542e-02f, 3.68362740e-02f, 1.50209278e-01f, 2.12112710e-01f, -1.96665391e-01f, -5.42028844e-02f, 7.26644555e-03f, 1.89520910e-01f,
  4.47156392e-02f, 2.58313775e-01f, 1.24146223e-01f, -2.84512136e-02f, 2.43362099e-01f, 2.14793250e-01f, 1.49618357e-01f, 2.34015752e-02f, 2.03106388e-01f, 3.87956090e-02f,
  2.39833426e-02f, -2.85946816e-01f, 1.50116175e-01f, -6.93840161e-02f, 2.40787625e-01f, -7.39242509e-02f, -1.21427014e-01f, 9.01012421e-02f, 8.51490051e-02f, -1.16366278e-02f,
  1.94678977e-01f, 1.12047859e-01f, 2.03286633e-01f, 2.00135618e-01f, 1.48720250e-01f, 1.83377098e-02f, 7.61636198e-02f, -9.60955843e-02f, 2.62295771e-06f, 6.63802475e-02f,
  -1.06432043e-01f, 1.98926535e-02f, 2.25613579e-01f, 1.18335076e-01f, 1.05120301e-01f, 1.64914757e-01f, -6.97507113e-02f, 1.94993019e-01f, 2.85354018e-01f, 1.55783460e-01f,
  -6.17821403e-02f, 1.15238309e-01f, -6.74279407e-02f, 1.01316199e-01f, 4.07096632e-02f, 8.11793655e-03f, 3.12345568e-02f, 8.48982334e-02f, 7.90908840e-03f, 3.29564549e-02f,
  6.12004995e-02f, 2.02819958e-01f, 1.38579726e-01f, 1.21712998e-01f, 8.72785524e-02f, -2.05783039e-01f, 9.39545706e-02f, 1.26329467e-01f, 1.28577247e-01f, 2.70680010e-01f,
  -1.26466807e-02f, 1.85131535e-01f, 5.24921976e-02f, -5.17412350e-02f, -2.60488857e-02f, 9.67272446e-02f, -1.17942356e-01f, -9.37060686e-04f, -1.45893237e-02f, 9.42535028e-02f,
  9.58491787e-02f, -5.15970699e-02f, -8.22483376e-02f, 2.93105282e-03f, -8.47035721e-02f, -1.20895766e-01f, 4.62200493e-02f, 1.33223787e-01f, 1.96803540e-01f, 2.66458809e-01f,
  -7.60098845e-02f, 1.47196308e-01f, 1.67274445e-01f, -2.73868218e-02f, -1.32324249e-01f, -1.07571110e-01f, 1.42269596e-01f, 5.67070693e-02f, -5.78285456e-02f, 2.37937961e-02f,
  -2.32664555e-01f, -7.49102756e-02f, 1.10797957e-01f, 1.04562625e-01f, -7.70259649e-02f, -1.56094566e-01f, 2.99774081e-01f, -5.85982716e-03f, 3.79211530e-02f, -6.26685470e-02f,
  -7.39356279e-02f, 1.68769283e-03f, 3.22987318e-01f, 8.31919760e-02f, -7.84202516e-02f, 1.39162123e-01f, 1.93214417e-01f, -7.00920001e-02f, 1.24855965e-01f, 2.28253845e-02f,
  1.09343998e-01f, -6.14803173e-02f, 1.14884868e-01f, 4.17893454e-02f, 6.36319146e-02f, -8.19900781e-02f, 1.34896606e-01f, 2.29740068e-01f, 5.78982793e-02f, -7.05072470e-03f,
  -1.08435757e-01f, 2.44809359e-01f, 5.44763654e-02f, 2.04919249e-01f, -4.09912206e-02f, -1.06596328e-01f, -1.47722930e-01f, 2.24206112e-02f, 6.43860027e-02f, 1.27457872e-01f,
  -1.02636188e-01f, -9.96475741e-02f, -1.71911176e-02f, -6.19964600e-02f, -5.69641255e-02f, 3.12040001e-02f, -9.35311094e-02f, -1.28305137e-01f, 1.58193819e-02f, 5.69587015e-02f,
  -1.21229803e-02f, 3.90547141e-02f, 2.32100654e-02f, -9.77957845e-02f, -3.24398950e-02f, -6.37272298e-02f, -1.05186298e-01f, -4.35006917e-02f, 6.55597970e-02f, 9.62074921e-02f,
  -6.69675767e-02f, 3.39778960e-02f, 5.51844276e-02f, -1.02433786e-01f, 3.54434252e-02f, -6.32784218e-02f, -2.67915856e-02f, -1.00920424e-01f, 1.05508968e-01f, 3.25398659e-03f,
  -8.51728171e-02f, -8.39555562e-02f, 8.29120353e-03f, -1.27277568e-01f, -1.00688115e-02f, -2.67739743e-02f, 3.15353237e-02f, 2.00074054e-02f, -3.56271700e-03f, -1.36861056e-02f,
  8.36573541e-02f, -1.20028719e-01f, 7.10594133e-02f, 9.60089359e-03f, -2.54790913e-02f, 5.51196635e-02f, -8.46204460e-02f, -5.42231761e-02f, -9.65587795e-02f, -1.13790259e-01f,
  -7.44474605e-02f, -7.42101669e-02f, -5.96131245e-03f, 6.37473762e-02f, 6.75095171e-02f, 4.20072004e-02f, -7.10940510e-02f, 6.58970326e-02f, -1.28451586e-01f, -1.13578580e-01f,
  -1.05884239e-01f, 3.22523341e-02f, -7.01250285e-02f, 3.64587791e-02f, -3.86620201e-02f, -9.12737027e-02f, 1.53157845e-01f, 4.91279550e-02f, 1.35999754e-01f, -3.33267637e-02f,
  9.65112373e-02f, 1.06202178e-01f, 6.06741607e-02f, 1.28805071e-01f, 1.39982492e-01f, -1.64579213e-01f, 2.00308815e-01f, 1.58255994e-01f, 8.64276662e-02f, 1.97087124e-01f,
  5.68855740e-02f, 6.78696930e-02f, 5.18557355e-02f, 8.81631598e-02f, 2.18635574e-01f, -1.38207421e-01f, 1.16669387e-01f, -6.50213510e-02f, 1.13525882e-01f, 5.23431152e-02f,
  -6.58921618e-03f, 2.87267536e-01f, -1.69739202e-01f, 7.63831735e-02f, 3.12577225e-02f, -6.11751564e-02f, 3.55182886e-02f, 5.31060956e-02f, 8.28182250e-02f, 1.27002165e-01f,
  1.65247023e-01f, 5.48011698e-02f, 3.64926606e-02f, 7.87789449e-02f, 1.84393048e-01f, 2.11237267e-01f, 1.62483931e-01f, 5.63677587e-03f, 6.85323998e-02f, 2.31141344e-01f,
  1.56394035e-01f, 5.57570495e-02f, 2.73968596e-02f, 1.13356560e-01f, -7.61062205e-02f, 1.21800102e-01f, 8.04197416e-02f, -3.72552909e-02f, 1.86970368e-01f, -7.63513893e-02f,
  7.28466436e-02f, 1.18455989e-02f, 1.39897227e-01f, 1.00452669e-01f, 1.90060064e-01f, -9.23896804e-02f, 2.14502066e-02f, 2.20239684e-02f, 1.43003628e-01f, -1.47604451e-01f,
  5.59342988e-02f, 2.62564775e-02f, 2.41861060e-01f, 4.10408154e-02f, 1.63032353e-01f, 2.25885864e-02f, 7.14245141e-02f, -2.21924484e-01f, 1.83999866e-01f, -1.52637258e-01f,
  2.43561640e-01f, -1.07076615e-01f, -1.67105883e-01f, -1.00711875e-01f, -1.09226935e-01f, 4.90881465e-02f, 1.98763147e-01f, 1.31238803e-01f, 1.75769001e-01f, 1.15040727e-02f,
  2.96957523e-01f, 1.30786046e-01f, -9.04054493e-02f, 9.69029516e-02f, 2.12624922e-01f, -1.52202278e-01f, 9.90404189e-03f, 3.17567348e-01f, 5.16032018e-02f, 1.08526327e-01f,
  1.24574661e-01f, 2.30848566e-01f, -7.87048340e-02f, 9.56888422e-02f, 3.32469866e-02f, 2.61300832e-01f, 7.54902959e-02f, 1.70970321e-01f, 3.96828093e-02f, -8.22041556e-02f,
  8.04641098e-02f, -1.15926407e-01f, 8.40198342e-03f, -3.77904549e-02f, -4.76886779e-02f, -1.59354694e-02f, 1.47880986e-01f, 2.56925523e-02f, 7.79256076e-02f, -1.58930868e-02f,
  8.78710300e-02f, -6.93432614e-03f, 2.76764721e-01f, 6.80006742e-02f, 2.36007646e-01f, 1.20617345e-01f, 1.89925224e-01f, -9.27196294e-02f, -8.74176249e-02f, 5.90209439e-02f,
  8.13823044e-02f, 5.06397374e-02f, -1.30492017e-01f, 3.25179510e-02f, 2.05293633e-02f, 1.29008964e-01f, 1.63646892e-01f, 1.16361901e-01f, 2.22893991e-03f, 1.31533235e-01f,
  -1.97061956e-01f, 5.06860949e-02f, -2.24996075e-01f, 2.50426233e-01f, -3.19086134e-01f, 4.47683819e-02f, 1.54600680e-01f, -9.66359079e-02f, -1.36864126e-01f, -1.10111780e-01f,
  -6.38899654e-02f, 5.24918437e-02f, 1.83690842e-02f, 7.71706849e-02f, -1.67727415e-02f, 3.95532278e-03f, -2.52510142e-03f, 7.36357272e-02f, -8.71376991e-02f, -8.75111017e-03f,
  2.50707269e-01f, 9.57955122e-02f, -1.34848103e-01f, -9.93980467e-03f, 1.37385547e-01f, -1.86375275e-01f, -7.36084729e-02f, 4.58352007e-02f, -1.62076861e-01f, -1.11142784e-01f,
  -1.24753416e-01f, -3.98103781e-02f, -1.29434571e-01f, 9.59034711e-02f, -2.20461056e-01f, 7.62947574e-02f, 4.00002450e-02f, 1.01224139e-01f, 2.10366637e-01f, 1.15920268e-01f,
  1.72774777e-01f, -1.52473496e-02f, 1.14209652e-01f, -1.41372606e-01f, -1.74889237e-01f, 5.26929535e-02f, 2.33564582e-02f, 1.90292999e-01f, 6.58921450e-02f, -4.90910597e-02f,
  -7.20081404e-02f, 1.22419469e-01f, 1.15220323e-02f, 2.02542141e-01f, -1.06703937e-01f, 2.48003498e-01f, 1.85044542e-01f, 1.02760814e-01f, 6.30986691e-02f, -8.66629463e-03f,
  1.35642484e-01f, 5.29282633e-03f, -5.53470254e-02f, 1.63092259e-02f, -1.03495240e-01f, 2.35164747e-01f, -1.83145657e-01f, 1.70160994e-01f, -7.02486783e-02f, 1.28587753e-01f,
  4.59900970e-04f, 1.67673379e-01f, 5.33948466e-02f, 1.13861144e-01f, 1.24484502e-01f, -5.99358454e-02f, 7.56212100e-02f, 6.17028959e-03f, -9.21351165e-02f, -1.88407619e-02f,
  -8.50553066e-02f, 1.29438311e-01f, -2.94946171e-02f, 1.25463270e-02f, 6.59769326e-02f, -1.73238620e-01f, 7.63470903e-02f, -3.47523317e-02f, -4.65969704e-02f, 9.41906720e-02f,
  1.63909554e-01f, -1.86352924e-01f, -2.28654847e-01f, -1.33182123e-01f, 2.28829801e-01f, 2.88501326e-02f, -1.56447627e-02f, 2.86545865e-02f, 1.55999914e-01f, 1.89563438e-01f,
  4.20100614e-02f, 1.54733643e-01f, -2.38894746e-02f, 6.14617057e-02f, -1.14695035e-01f, 9.62062180e-03f, 7.67114460e-02f, -8.30032900e-02f, -5.27054407e-02f, 1.04615673e-01f,
  -8.64892676e-02f, -9.88008175e-03f, 1.51261702e-01f, 1.09392114e-01f, 6.47237673e-02f, 2.40383118e-01f, 2.12372571e-01f, -1.46569878e-01f, 6.50283471e-02f, -1.25691056e-01f,
  1.98568165e-01f, 3.89504842e-02f, 2.15125516e-01f, 1.61430955e-01f, 1.00681938e-01f, 2.01640785e-01f, 2.03757301e-01f, -8.99902731e-02f, -4.24086191e-02f, 5.15611358e-02f,
  -1.02788351e-01f, 1.12430658e-02f, 4.09785584e-02f, 4.02894802e-02f, 2.44829780e-03f, -1.23145014e-01f, -5.06236851e-02f, -8.00694004e-02f, -3.93180549e-03f, -2.00667661e-02f,
  -1.81797311e-01f, 8.00575316e-02f, 2.34176978e-01f, 1.53168589e-01f, -1.75631925e-01f, 6.25905441e-03f, 1.86366871e-01f, 1.13846466e-01f, 7.49294311e-02f, 1.25829786e-01f,
  8.00556242e-02f, 8.21915716e-02f, 1.26862422e-01f, -1.78679489e-02f, 1.17259815e-01f, -1.56520426e-01f, 2.79492378e-01f, 2.13724181e-01f, -6.28883466e-02f, -8.27436596e-02f,
  5.04747704e-02f, -1.35054544e-01f, -1.94976076e-01f, -9.48004276e-02f, 1.82621911e-01f, -7.81149417e-03f, 1.32632270e-01f, 4.26583402e-02f, 1.58684447e-01f, -1.49925008e-01f,
  1.60709500e-01f, 8.56762379e-02f, -1.11133702e-01f, -9.11346525e-02f, 1.99504599e-01f, -4.33591232e-02f, 1.58265885e-02f, 1.94870271e-02f, 5.53709492e-02f, -6.36092350e-02f,
  2.06398442e-02f, 2.52724022e-01f, -1.98580146e-01f, 1.91477209e-01f, 1.41220883e-01f, -4.97126132e-02f, 5.92673309e-02f, 1.13909736e-01f, 1.59416452e-01f, 8.20877105e-02f,
  1.93492547e-02f, 9.26063210e-02f, 1.50424942e-01f, -2.36311018e-01f, -1.40045762e-01f, 8.43521953e-02f, 1.38311964e-02f, -1.84757620e-01f, 7.77281523e-02f, -1.23957999e-01f,
  -2.87121441e-02f, -2.36054044e-02f, -1.99966822e-02f, 1.47881359e-01f, 4.65606712e-02f, 3.03060859e-02f, -1.80138610e-02f, 1.98677525e-01f, 2.88882196e-01f, 1.12299114e-01f,
  5.91047853e-02f, -1.74817204e-01f, 1.92991167e-01f, 2.27398425e-02f, -2.42349207e-01f, 1.12914033e-01f, 1.42792389e-01f, 1.41553536e-01f, -1.27286330e-01f, 1.45600632e-01f,
  -8.21473971e-02f, 2.36456931e-01f, -2.12283991e-02f, 2.33764499e-02f, 3.50685678e-02f, -7.45715797e-02f, -1.07565805e-01f, 4.68335748e-02f, 8.31887946e-02f, -1.86803192e-02f,
  1.28760099e-01f, 8.95297974e-02f, -4.34191301e-02f, -1.32228285e-02f, -2.13152580e-02f, -8.88719782e-02f, -1.89001467e-02f, -1.08622238e-01f, -2.47993693e-02f, -9.57235508e-03f,
  -4.32260558e-02f, -1.38327688e-01f, 2.96059716e-02f, 4.34443913e-02f, 2.77793799e-02f, -7.29482174e-02f, -9.56661850e-02f, 2.22395554e-01f, 4.42307852e-02f, 2.27395266e-01f,
  1.32821798e-01f, 1.67307779e-01f, -1.98776368e-02f, 1.30309984e-01f, 1.81216866e-01f, 1.69512391e-01f, -2.75733452e-02f, -1.02441320e-02f, 2.38047373e-02f, 1.20030113e-01f,
  -5.75591177e-02f, 1.42882496e-01f, -8.94374039e-04f, 5.05768843e-02f, -4.61019501e-02f, -3.58922742e-02f, 5.19190393e-02f, -1.09186783e-01f, -4.14542258e-02f, 2.74414439e-02f,
  1.49784267e-01f, 3.35575417e-02f, 6.26783893e-02f, -9.66229066e-02f, 1.84079736e-01f, -6.24547601e-02f, 1.19452931e-01f, 9.78957862e-02f, 7.40480497e-02f, 1.22802965e-01f,
  1.19408593e-01f, -9.34135914e-02f, -4.17832509e-02f, -8.46012030e-04f, 2.07367465e-01f, 1.40156969e-02f, -3.50713544e-02f, 3.70387919e-02f, 1.49679231e-02f, 9.63336453e-02f,
  5.55601669e-03f, 1.01069454e-02f, 1.35721684e-01f, 6.28818898e-03f, 5.80154918e-02f, 2.61410713e-01f, 6.13485612e-02f, -3.62818688e-02f, 2.35588685e-01f, -5.78940101e-02f,
  -3.96927483e-02f, -7.47468248e-02f, 1.43819362e-01f, 1.08275026e-01f, 5.10067903e-02f, 1.45566761e-01f, -8.18302780e-02f, 2.54406542e-01f, -1.24444097e-01f, 2.35768065e-01f,
  1.99819189e-02f, 1.75510213e-01f, -5.69422506e-02f, -7.83071518e-02f, 1.94462508e-01f, -4.64259200e-02f, 9.21959206e-02f, 2.27660760e-02f, 1.21680617e-01f, 3.56900655e-02f,
  -1.59417361e-01f, 9.92056355e-02f, -6.30824268e-02f, 2.25253880e-01f, -1.34375617e-01f, 4.83868383e-02f, 1.15033716e-01f, -8.07724372e-02f, 6.50213379e-03f, -5.93125299e-02f,
  -1.78244039e-01f, 1.37169674e-01f, -1.44630268e-01f, 1.75597608e-01f, 1.44456789e-01f, 1.56836376e-01f, -6.62124455e-02f, -1.07962891e-01f, 1.49295434e-01f, -5.87343946e-02f,
  3.84501554e-02f, 1.11193657e-01f, -3.10961362e-02f, 6.01673312e-02f, 9.05699283e-02f, 7.42281154e-02f, 1.06861979e-01f, -1.83190480e-01f, 1.07334845e-01f, 1.42942071e-01f,
  4.03442681e-02f, -1.04647838e-01f, -6.41100407e-02f, 1.09681174e-01f, -5.23647331e-02f, 1.79532412e-02f, 1.81094036e-01f, -3.30669545e-02f, 1.32387012e-01f, 1.55696854e-01f,
  1.65653110e-01f, -5.19963279e-02f, 1.77621052e-01f, -3.82496044e-02f, -1.32502183e-01f, 1.02763467e-01f, -6.84741214e-02f, 9.87947211e-02f, 1.69911259e-03f, 1.33069605e-01f,
  -5.84410876e-02f, -9.29092616e-02f, 1.08103298e-01f, 2.24909201e-01f, -1.03459619e-01f, 2.10819736e-01f, 1.53934836e-01f, 4.38055433e-02f, 5.49445078e-02f, 7.33078793e-02f,
  -9.79918800e-03f, 1.48591682e-01f, -4.05747332e-02f, -1.05391353e-01f, 5.20591773e-02f, -1.97638497e-01f, 1.21864907e-01f, -2.86445506e-02f, 3.53719182e-02f, 1.05252147e-01f,
  -2.11080849e-01f, 8.35833848e-02f, 7.10112378e-02f, -1.59489408e-01f, -2.42762808e-02f, 5.04578799e-02f, -1.88793279e-02f, 8.75747204e-02f, 1.56564116e-01f, 7.74910450e-02f,
  -2.76622593e-01f, -8.05976540e-02f, 1.91538990e-01f, 5.23763448e-02f, -5.87195624e-03f, 1.70145422e-01f, 1.86268449e-01f, 9.64729413e-02f, 1.23960584e-01f, 1.25330642e-01f,
  9.74250808e-02f, -1.55930808e-02f, 2.66906410e-01f, 5.94294704e-02f, -1.40646756e-01f, 1.63094103e-01f, -1.48144811e-02f, -1.97832227e-01f, -3.48871164e-02f, -1.09620623e-01f,
  2.36017585e-01f, -5.21973409e-02f, -1.04826756e-01f, 8.84894431e-02f, 1.59367517e-01f, -1.27930818e-02f, 5.46918362e-02f, -4.22621099e-03f, 2.11124808e-01f, -1.71364397e-01f,
  1.31126717e-01f, 1.39947563e-01f, 2.68486321e-01f, 1.33251786e-01f, -1.51599780e-01f, 2.92899776e-02f, -8.17982033e-02f, 3.15068625e-02f, 5.71662299e-02f, 1.04766443e-01f,
  -9.51346308e-02f, -7.85406604e-02f, 5.05733825e-02f, 3.09134535e-02f, 1.99228510e-01f, 1.28636450e-01f, 1.66368410e-01f, 3.85236628e-02f, 5.63515835e-02f, 1.11404965e-02f,
  6.87689893e-03f, -1.64317086e-01f, 2.25613490e-01f, -6.91846609e-02f, -8.82660747e-02f, 1.48334786e-01f, 2.72574604e-01f, 2.25245744e-01f, 9.39528048e-02f, 7.74711967e-02f,
  -8.48140717e-02f, -9.79357660e-02f, 3.90193872e-02f, -1.09644271e-01f, 3.21797401e-01f, 2.44682789e-01f, -5.22504263e-02f, 3.04621346e-02f, -1.78233966e-01f, 1.16836661e-02f,
  1.63075164e-01f, -1.40926212e-01f, -1.28540751e-02f, 1.16309039e-01f, 1.56176938e-02f, 2.50349760e-01f, -7.79303759e-02f, 1.57450676e-01f, 3.92123312e-02f, 1.55923948e-01f,
  2.07142159e-01f, 2.54842043e-01f, 2.36157373e-01f, 1.06126128e-03f, -1.20157830e-01f, -4.40849140e-02f, 1.23369329e-01f, -1.02046430e-01f, 3.05115636e-02f, 1.36556581e-01f,
  -1.08006999e-01f, 1.43369302e-01f, 1.50610968e-01f, 8.99377186e-03f, 1.00984387e-01f, 1.38683259e-01f, -1.26655951e-01f, 8.61025229e-02f, 2.00428948e-01f, -6.60362840e-02f,
  8.47431943e-02f, -9.99610052e-02f, -4.42549437e-02f, -7.23337457e-02f, -1.17545249e-02f, 9.30796284e-03f, 2.79525165e-02f, 1.45526752e-01f, -3.18686664e-02f, 4.07852046e-02f,
  -5.46543524e-02f, 6.90041706e-02f, -8.53915960e-02f, 1.33730888e-01f, -1.82703529e-02f, 1.91827536e-01f, -1.29421890e-01f, -1.60091538e-02f, 2.47477606e-01f, 1.02717899e-01f,
  -1.02654040e-01f, -6.15515523e-02f, -6.73085004e-02f, -1.72436051e-02f, 4.13920432e-02f, 4.30328660e-02f, 1.22253083e-01f, 6.59601837e-02f, -2.09054369e-02f, 1.37358785e-01f,
  -7.52320364e-02f, 1.19176231e-01f, 1.50107414e-01f, 1.58187374e-01f, 1.21145219e-01f, -3.61580998e-02f, -3.54971886e-02f, -1.12304986e-02f, 1.00058459e-01f, -1.39054269e-01f,
  -5.66390827e-02f, -1.78316589e-02f, 1.96574703e-01f, -1.13028996e-01f, 7.65591115e-02f, -1.02605313e-01f, -1.42690688e-01f, 1.28199235e-01f, 4.07514498e-02f, -9.98195484e-02f,
  -6.11836389e-02f, -1.21228635e-01f, 3.62149738e-02f, 5.59353717e-02f, 1.03773989e-01f, -1.73284397e-01f, 9.88068506e-02f, 1.49472833e-01f, -1.14621721e-01f, -1.06379159e-01f,
  7.97949210e-02f, -1.92324042e-01f, 6.96755350e-02f, 3.82927852e-03f, -2.81647649e-02f, 8.02148283e-02f, 2.31516778e-01f, -2.41608662e-03f, 1.61789715e-01f, 6.40233010e-02f,
  2.28483006e-01f, -5.26844077e-02f, 9.02190879e-02f, 1.04237534e-01f, 2.17592083e-02f, 2.29016263e-02f, -3.20977196e-02f, 1.44319355e-01f, -1.38822630e-01f, 4.60380968e-03f,
  -8.86401534e-02f, 1.84204623e-01f, 1.23052232e-01f, -9.88899693e-02f, 8.34789351e-02f, 6.55468404e-02f, 1.20732285e-01f, 1.30961612e-01f, 1.33290917e-01f, 5.56894355e-02f,
  1.87108502e-01f, -3.79329063e-02f, -2.36260787e-01f, -2.14576900e-01f, 2.87772954e-01f, -1.21147465e-02f, -2.09414717e-02f, 7.20689222e-02f, 2.57479697e-02f, 4.67258319e-02f,
  4.19626758e-02f, 5.11608049e-02f, 2.30193973e-01f, -1.28770798e-01f, 1.63370654e-01f, 1.22107029e-01f, 3.67911309e-02f, 1.53208807e-01f, -3.76834460e-02f, 5.13915494e-02f,
  -8.96996446e-03f, 5.60675859e-02f, 3.11431944e-01f, 1.70278236e-01f, 9.03711170e-02f, 8.38699043e-02f, 1.01166785e-01f, -4.16132882e-02f, 1.91004410e-01f, -1.05008312e-01f,
  2.68273473e-01f, -3.58745046e-02f, 2.49857567e-02f, 1.07233636e-01f, 3.74636590e-01f, 3.21840733e-01f, 8.01097881e-03f, 2.04837188e-01f, 8.33345354e-02f, 1.83035374e-01f,
  1.63712680e-01f, 1.89543888e-01f, 1.07444927e-01f, -1.82940979e-02f, 5.77770770e-02f, -7.39604756e-02f, 1.68645591e-01f, 5.91749251e-02f, 1.68211758e-02f, 1.70017511e-01f,
  -1.15999496e-02f, -4.61723767e-02f, 6.41382625e-03f, -1.64606720e-01f, 1.92273915e-01f, 1.70151874e-01f, 1.91383585e-02f, 2.66228542e-02f, -1.09063806e-02f, 9.11508650e-02f,
  -9.99410055e-04f, 7.60566294e-02f, 4.13514338e-02f, -8.46796781e-02f, 6.85062725e-03f, 3.90885323e-02f, -2.60322154e-01f, -4.23050001e-02f, -3.17290379e-03f, 1.68547437e-01f,
  -4.18237671e-02f, 7.44094700e-02f, 1.01562068e-02f, -1.50379762e-02f, -1.56118926e-02f, 5.36359847e-02f, -8.96469131e-02f, -3.43414508e-02f, 8.72875154e-02f, -1.19684778e-01f,
  4.76045236e-02f, 1.59323871e-01f, 1.22311436e-01f, 1.86588645e-01f, 3.30327302e-02f, 2.06501633e-01f, 2.27345191e-02f, 2.67351240e-01f, 1.30767718e-01f, 6.77869022e-02f,
  3.23156938e-02f, 9.62550268e-02f, 1.06748445e-02f, 3.51736173e-02f, 1.30379155e-01f, -1.53685540e-01f, 8.53865594e-02f, -7.61802495e-02f, 4.62469533e-02f, 2.38241240e-01f,
  -5.37234508e-02f, 6.54458702e-02f, 8.29821173e-03f, 4.89987060e-02f, 2.10756242e-01f, 1.04448147e-01f, 1.29371090e-02f, 1.79606713e-02f, -4.47316691e-02f, -6.99644759e-02f,
  1.26173764e-01f, 1.05675474e-01f, 1.69479921e-01f, 2.41332874e-02f, 1.07949659e-01f, 2.17806906e-01f, -3.12858894e-02f, 6.46946803e-02f, 3.66565920e-02f, 6.93900958e-02f,
  1.26430333e-01f, 2.83668339e-01f, 2.24976569e-01f, 1.49983093e-01f, 2.41997652e-02f, -4.46527973e-02f, 9.98404995e-02f, -1.12141192e-01f, -5.68249337e-02f, -1.57146916e-01f,
  1.58427849e-01f, 1.64713725e-01f, -1.84936393e-02f, 2.83871621e-01f, -7.94473141e-02f, -1.80636778e-01f, 1.68366402e-01f, -1.47889286e-01f, -1.56459183e-01f, -9.32430197e-03f,
  -3.39334011e-02f, 1.28991500e-01f, 1.28780082e-01f, -1.51358008e-01f, 5.53533435e-03f, 8.14278871e-02f, 1.13587052e-01f, 2.31503248e-01f, 1.94398209e-01f, 1.86051443e-01f,
  -1.65388197e-01f, 5.55939339e-02f, 1.09417334e-01f, -1.20137259e-01f, 8.15320686e-02f, 1.19635627e-01f, 8.06415640e-03f, 2.00133726e-01f, 3.48022096e-02f, 1.45634264e-01f,
  -8.07747170e-02f, -1.61314625e-02f, 2.33547669e-03f, -1.90066022e-03f, 1.89712301e-01f, -1.85016379e-01f, 2.18943089e-01f, -1.07845873e-01f, 2.32572481e-01f, 2.18801852e-02f,
  1.65726647e-01f, -1.64219975e-01f, 1.75786436e-01f, 1.17466254e-02f, 1.73650861e-01f, -8.00253171e-03f, 6.26545697e-02f, 1.69887826e-01f, 8.96689817e-02f, -1.37892872e-01f,
  -8.93793479e-02f, -1.21414870e-01f, 9.85823795e-02f, 6.56915680e-02f, -1.53031126e-01f, 5.83737679e-02f, 1.57060698e-01f, 5.82052246e-02f, 2.77902056e-02f, 2.37834956e-02f,
  1.13749787e-01f, -5.33979796e-02f, 1.07324354e-01f, 2.42602676e-02f, 1.04099207e-01f, 1.60841733e-01f, 1.26190796e-01f, 1.04772374e-01f, -9.75655913e-02f, -1.23282924e-01f,
  3.84286083e-02f, 3.64525989e-02f, -2.55197566e-02f, 1.90829247e-01f, 2.21825838e-02f, 2.79086173e-01f, 1.62849605e-01f, -3.69884260e-02f, -1.28771752e-01f, 2.18864143e-01f,
  1.03542812e-01f, 2.07534999e-01f, 2.17556268e-01f, 6.20293580e-02f, -8.37316550e-03f, 3.16757038e-02f, 2.79844366e-02f, -4.44869548e-02f, -1.01822063e-01f, 1.32256761e-01f,
  -1.04637004e-01f, 2.72214890e-01f, 2.24728584e-01f, -2.01044753e-01f, 4.39947583e-02f, 1.65014878e-01f, 1.44083217e-01f, 1.60819516e-02f, 5.99150956e-02f, 1.23894595e-01f,
  -4.55215648e-02f, -8.13095197e-02f, 1.32173479e-01f, 9.13508330e-03f, -1.84918251e-02f, -4.19158349e-03f, 7.94247985e-02f, 1.60390005e-01f, 7.20788538e-02f, 5.45417517e-02f,
  1.09317414e-01f, 1.73431873e-01f, -1.24394305e-01f, 6.22019209e-02f, -6.38229027e-02f, 2.00770020e-01f, -1.99201241e-01f, 2.19468683e-01f, 1.58014707e-02f, -1.33603483e-01f,
  1.17487283e-02f, -1.26661479e-01f, -1.18650675e-01f, -6.61141276e-02f, -2.22379774e-01f, 8.03716928e-02f, 1.36138350e-01f, 1.68447286e-01f, 5.94016761e-02f, -1.44348338e-01f,
  1.37836441e-01f, 8.84803608e-02f, 6.48541898e-02f, -4.91103567e-02f, 1.51293099e-01f, 1.82168230e-01f, 7.26884902e-02f, -3.42111476e-02f, 2.16796890e-01f, 2.23247055e-02f,
  5.96586876e-02f, -6.52004927e-02f, -1.39245927e-01f, 7.96618685e-02f, -5.88412248e-02f, -4.69405651e-02f, -4.22768779e-02f, 1.54861182e-01f, 4.07682806e-02f, 1.58725664e-01f,
  2.32972607e-01f, 1.88182995e-01f, -1.61771700e-02f, -2.08385736e-01f, 1.68723226e-01f, 1.29472315e-01f, -1.44201547e-01f, 6.09316342e-02f, -4.74931337e-02f, 1.28304943e-01f,
  -9.69634801e-02f, 1.14843354e-01f, -2.24847466e-01f, 4.15656492e-02f, -1.24385595e-01f, 2.31135830e-01f, -4.43089642e-02f, 2.26710305e-01f, 1.05236903e-01f, 4.78638560e-02f,
  6.99331388e-02f, -3.11197974e-02f, 5.63665368e-02f, -1.15434133e-01f, 1.39735416e-01f, 1.07614554e-01f, -4.37133163e-02f, 1.60757020e-01f, 1.83648825e-01f, -1.96908325e-01f,
  3.15768495e-02f, 4.54558805e-02f, 2.26473555e-01f, 1.89091995e-01f, 6.94821104e-02f, 2.46357113e-01f, 4.27698530e-02f, 1.22685358e-01f, 1.62954226e-01f, -5.55417128e-03f,
  5.13315275e-02f, -6.40333444e-02f, 3.14227752e-02f, 1.66676164e-01f, 2.39170305e-02f, 2.08108544e-01f, -8.71064812e-02f, 1.68524422e-02f, -8.38303640e-02f, -1.40494127e-02f,
  -1.07599050e-01f, -3.44563425e-02f, 1.51211210e-02f, 1.62561476e-01f, -1.34858221e-01f, -7.57820085e-02f, 2.73961663e-01f, -9.53302812e-03f, 1.41647816e-01f, 1.49860486e-01f,
  2.02359706e-01f, 1.67533472e-01f, -6.52815402e-02f, 1.13927700e-01f, -8.04395080e-02f, 8.97161067e-02f, 2.78596841e-02f, 5.04018702e-02f, 2.86284201e-02f, 5.02366796e-02f,
  9.98999774e-02f, 2.19158769e-01f, 3.05342823e-02f, -1.26291901e-01f, 2.08201155e-01f, 3.69444117e-02f, 1.19491108e-01f, 4.86337915e-02f, 9.32892784e-02f, -6.74422979e-02f,
  2.79839337e-01f, -5.11594601e-02f, 2.13107094e-01f, -1.23715244e-01f, 6.36949390e-02f, -2.39291582e-02f, 2.81852931e-02f, 4.63376492e-02f, 9.63360444e-02f, 7.10299611e-02f,
  -4.02217545e-02f, 1.64071172e-01f, 4.79897484e-02f, 4.68339473e-02f, -2.04810038e-01f, 1.41652957e-01f, 2.43107200e-01f, 1.02282185e-02f, 3.72183579e-03f, 9.42145661e-02f,
  2.49216720e-01f, 2.35401057e-02f, -3.78707275e-02f, 1.78753451e-01f, -4.65275869e-02f, 3.47280204e-02f, -7.50972256e-02f, 8.99643824e-03f, -9.15365517e-02f, 1.72870204e-01f,
  6.21560179e-02f, -5.51074278e-03f, 1.44022822e-01f, -6.91749603e-02f, -1.03707984e-01f, -4.51891050e-02f, 1.02036692e-01f, 7.69955572e-03f, 8.33936930e-02f, -1.48978695e-01f,
  2.12112010e-01f, 1.18210636e-01f, 8.25778618e-02f, 2.07046360e-01f, 4.74378504e-02f, 1.43527225e-01f, -3.00247874e-03f, 1.97328046e-01f, 2.39625320e-01f, 6.77842796e-02f,
  1.74541488e-01f, -1.24142759e-01f, 3.37489508e-02f, -4.12131809e-02f, -7.77839124e-02f, 2.07884446e-01f, -3.03032827e-02f, 2.88008656e-02f, 1.24432310e-01f, 9.54798013e-02f,
  -4.30337414e-02f, 2.74203271e-01f, -2.07811948e-02f, 2.07391586e-02f, 1.21368431e-01f, 1.79456994e-01f, 2.23482609e-01f, 7.56712398e-03f, 7.58723170e-03f, 1.26432315e-01f,
  2.84817647e-02f, 1.75528049e-01f, 1.46231651e-01f, 2.75987666e-02f, -1.39300182e-01f, 5.54353707e-02f, -1.02399863e-01f, 1.97938122e-02f, -2.07608536e-01f, 1.22099996e-01f,
  2.17483137e-02f, 9.15319994e-02f, -4.27989587e-02f, -4.59589958e-02f, 2.61147976e-01f, -5.89765748e-03f, 1.02619015e-01f, 7.50044659e-02f, -8.83619264e-02f, -4.48625199e-02f,
  -4.34317589e-02f, 3.36909257e-02f, 7.42935389e-02f, 1.58250272e-01f, 5.29218838e-02f, -2.14750931e-01f, -1.12922350e-03f, 1.45243332e-01f, 4.50300314e-02f, 1.33988962e-01f,
  1.39896959e-01f, 1.78160131e-01f, 1.44954160e-01f, -9.86905992e-02f, 9.46290419e-02f, 6.70519285e-03f, 1.05333872e-01f, 2.41111256e-02f, -1.40037179e-01f, 1.17482305e-01f,
  2.29474008e-01f, -5.32373302e-02f, 1.70343667e-01f, 1.59124658e-01f, -4.60824743e-02f, -2.34216005e-02f, 4.18885201e-02f, -7.09216744e-02f, -6.54237494e-02f, 1.19775999e-02f,
  -3.84013727e-02f, 2.15110287e-01f, 1.94348156e-01f, 1.84190452e-01f, -1.55262962e-01f, 2.46954039e-01f, -1.12006038e-01f, 1.99341148e-01f, 1.02022896e-02f, 6.97704852e-02f,
  1.34379163e-01f, -5.24617881e-02f, 1.42476737e-01f, 8.47327039e-02f, 6.94481581e-02f, -3.38722840e-02f, 1.72160137e-02f, 1.08173572e-01f, -1.03230283e-01f, 2.25359872e-01f,
  -1.05131403e-01f, 2.12283835e-01f, -1.48698717e-01f, 8.41786433e-03f, 9.35546458e-02f, 1.35182455e-01f, -9.50624645e-02f, 6.29689777e-03f, 9.12501067e-02f, 5.34069575e-02f,
  -8.36697780e-03f, 8.78031552e-02f, -9.31697711e-03f, 1.48718953e-02f, -6.97323754e-02f, 5.85930143e-03f, 3.89000848e-02f, 1.60705298e-01f, 2.41795897e-01f, -5.04451357e-02f,
  8.84175524e-02f, -7.80935436e-02f, 7.32480437e-02f, 4.07128856e-02f, 2.29215339e-01f, -7.73536190e-02f, 4.09953929e-02f, 9.36461706e-03f, 2.25882396e-01f, -3.26317325e-02f,
  1.63759161e-02f, 3.14870030e-02f, -1.51366711e-01f, -9.70793702e-03f, 1.42632723e-01f, 1.01112753e-01f, 2.00751051e-02f, 1.67619228e-01f, 5.27574830e-02f, -8.94415844e-03f,
  3.61379124e-02f, -1.40383661e-01f, 3.95761617e-02f, 7.91319385e-02f, -1.48060665e-01f, 1.28185049e-01f, 4.51011807e-02f, 9.73337367e-02f, -1.03319950e-01f, 1.17114738e-01f,
  2.02342704e-01f, 3.15329991e-02f, 1.47543833e-01f, -7.06202758e-04f, 3.82030159e-02f, 1.13955326e-01f, 6.57363236e-02f, 1.21667378e-01f, 1.46616116e-01f, 1.52463436e-01f,
  7.51052946e-02f, 1.63254421e-02f, -6.00046888e-02f, 1.46785364e-01f, 1.58989474e-01f, 3.13673504e-02f, -1.34921208e-01f, -2.39350080e-01f, 1.96963310e-01f, -8.80085006e-02f,
  -1.82967678e-01f, 1.72233269e-01f, -2.73623858e-02f, 1.09976783e-01f, -4.24831621e-02f, 1.40155092e-01f, 2.14209437e-01f, 7.22033828e-02f, 9.54392478e-02f, 1.97528660e-01f,
  -7.26266056e-02f, 1.46925911e-01f, 3.53726819e-02f, 2.82451153e-01f, -2.18136445e-01f, 1.02165006e-01f, 1.87163860e-01f, -9.24189091e-02f, 9.37469378e-02f, 2.99726762e-02f,
  -1.73165426e-01f, 6.48868158e-02f, 1.93533629e-01f, 2.59090252e-02f, 9.12973657e-02f, 9.73618478e-02f, 8.57753213e-04f, 1.51260570e-02f, 1.91595331e-01f, -7.55701512e-02f,
  -2.89081223e-02f, 1.90434247e-01f, 9.88770872e-02f, -1.37206122e-01f, 1.06526211e-01f, -5.79659082e-03f, -1.40613196e-02f, 1.64528787e-01f, 1.51101679e-01f, 4.31724973e-02f,
  -3.90499085e-02f, 7.20860288e-02f, 1.84215277e-01f, 1.23681590e-01f, 1.40395939e-01f, 1.33247629e-01f, -2.80584041e-02f, -1.32550560e-02f, 1.54598683e-01f, 2.12891191e-01f,
  8.11081007e-02f, -4.25665379e-02f, 7.25353956e-02f, -2.65595187e-02f, -5.59501946e-02f, 5.91681059e-03f, -1.23702297e-02f, 1.44481167e-01f, 1.62269235e-01f, -1.70163676e-01f,
  -1.03956304e-01f, -8.37245584e-02f, 2.40740255e-01f, 7.63928443e-02f, -2.78148632e-02f, 1.99352264e-01f, 1.92803636e-01f, 2.25316584e-02f, 1.77352652e-01f, 5.47412261e-02f,
  -5.53751364e-02f, 8.67558867e-02f, 1.13120914e-01f, 1.64427057e-01f, 6.37596473e-02f, 5.23732491e-02f, 5.54404445e-02f, 9.61916894e-02f, -1.57969147e-01f, -1.20230556e-01f,
  -9.36174616e-02f, 1.33118689e-01f, -4.02331501e-02f, 1.71192184e-01f, -2.91418899e-02f, 9.35132895e-03f, 1.96613401e-01f, 4.46613580e-02f, 8.18584859e-02f, 5.18742949e-02f,
  1.55171603e-01f, 2.00627744e-01f, -9.11389068e-02f, 1.68900505e-01f, -1.28656060e-01f, 1.45623893e-01f, -7.36224875e-02f, 7.14185461e-02f, -1.04351476e-01f, -6.34099841e-02f,
  1.66033447e-01f, 2.21425250e-01f, -1.01210792e-02f, -9.39044356e-02f, 8.61815885e-02f, 1.59266397e-01f, 1.50722221e-01f, 1.89994752e-01f, 1.00475028e-01f, -3.88135202e-02f,
  6.49488717e-02f, 5.67462184e-02f, 2.30201468e-01f, -7.28275403e-02f, -8.38494375e-02f, -4.52846028e-02f, 1.29956841e-01f, -3.99422646e-03f, -1.22039743e-01f, 4.47542816e-02f,
  4.76725623e-02f, 1.23738855e-01f, 2.64424942e-02f, 9.16066691e-02f, -3.09255153e-01f, 3.09593938e-02f, 1.32031620e-01f, 2.64667589e-02f, 8.27698261e-02f, -2.06678599e-01f,
  -9.81810465e-02f, -2.41339058e-02f, 1.15857907e-01f, 7.70712867e-02f, 2.79143807e-02f, 2.03927398e-01f, -1.05752572e-02f, 1.76664740e-02f, -2.92228237e-02f, -2.31769625e-02f,
  2.17879996e-01f, -2.40013421e-01f, -1.48889437e-01f, 6.53617159e-02f, -2.94013508e-02f, 1.64980561e-01f, 1.13527425e-01f, -2.50600070e-01f, 7.66310319e-02f, 4.50556492e-03f,
  1.06993817e-01f, -1.05263281e-03f, -2.08766237e-01f, 1.26327910e-02f, 2.59898137e-02f, -2.89733429e-02f, 2.77306698e-02f, 3.25447954e-02f, 1.21788837e-01f, 6.34066910e-02f,
  -1.31674275e-01f, -1.45869404e-02f, 1.74581185e-01f, 8.50712135e-03f, -9.17670354e-02f, 8.97828266e-02f, -1.57102093e-01f, 4.74696159e-02f, -3.41834985e-02f, -1.56070828e-01f,
  -1.55868828e-01f, 4.48364625e-03f, -1.32986978e-01f, -3.55485044e-02f, 6.86751604e-02f, 1.39326990e-01f, -5.44504002e-02f, 2.45710641e-01f, 1.09346882e-01f, -4.03942689e-02f,
  1.18884034e-01f, 4.88444604e-02f, 1.39542818e-02f, 6.55454770e-02f, 1.19637489e-01f, 1.50898442e-01f, -7.44218454e-02f, -3.34830321e-02f, 2.04162851e-01f, 5.45665808e-02f,
  1.54552430e-01f, 2.31372163e-01f, 5.38101457e-02f, 1.32207707e-01f, -2.78511047e-02f, 7.80650321e-03f, 1.44305214e-01f, -2.51548942e-02f, -5.30174784e-02f, 3.08077745e-02f,
  1.96023867e-01f, 2.22786710e-01f, -3.23715657e-02f, 2.37401858e-01f, -1.21523269e-01f, 1.47943228e-01f, 1.10047132e-01f, 6.18691593e-02f, -1.56762488e-02f, -8.61007255e-03f,
  1.28450513e-01f, 2.04629183e-01f, 1.87740047e-02f, 1.35411650e-01f, 1.19741626e-01f, 1.82466000e-01f, 1.70355484e-01f, 2.27178723e-01f, 5.16822860e-02f, 1.82679266e-01f,
  -1.37925386e-01f, 2.66373634e-01f, 1.67081840e-02f, -5.92876859e-02f, 1.56546816e-01f, -1.08762020e-02f, -1.30062252e-01f, 1.57501161e-01f, 7.94846341e-02f, 4.94120382e-02f,
  1.09688379e-02f, -7.76928803e-03f, -7.33969957e-02f, -8.20748694e-03f, 2.39312887e-01f, -1.86125070e-01f, 3.02936196e-01f, -1.09035626e-01f, 1.90272316e-01f, 1.13159820e-01f,
  1.32557586e-01f, -6.80720210e-02f, -4.57399562e-02f, 1.45442575e-01f, -9.08714905e-02f, -7.68232122e-02f, -2.05668937e-02f, 1.79140151e-01f, -1.47276387e-01f, 1.73924431e-01f,
  4.79715243e-02f, -4.64745751e-03f, -5.57640977e-02f, -8.65186006e-03f, 2.17996284e-01f, 1.22276731e-01f, -1.85301136e-02f, 3.79508212e-02f, 7.20825866e-02f, 1.21071987e-01f,
  9.94420843e-04f, 6.26684204e-02f, -1.21037282e-01f, 1.26184821e-01f, 1.70645416e-01f, 2.69376993e-01f, -7.61399567e-02f, 1.78432092e-01f, 9.99378860e-02f, -3.79442275e-02f,
  -1.28289163e-01f, -1.42261777e-02f, 6.87298924e-02f, -6.34550899e-02f, 1.30331919e-01f, 1.62607580e-01f, -1.61848485e-01f, -4.69020382e-03f, 1.72208801e-01f, -6.32498488e-02f,
  2.18266070e-01f, 1.26546934e-01f, 1.26284957e-01f, 3.28073017e-02f, -8.99491310e-02f, 1.72362685e-01f, 8.23505744e-02f, -3.72642316e-02f, -5.90912849e-02f, -1.37924373e-01f,
  -1.10761322e-01f, 1.67341396e-01f, 5.70800294e-05f, 2.03996971e-01f, -1.53517202e-01f, -1.61084030e-02f, -1.60595223e-01f, -1.59012839e-01f, 2.33837754e-01f, -8.58080611e-02f,
  1.84506208e-01f, -5.25135845e-02f, 1.40283674e-01f, 4.32685576e-02f, 1.92712262e-01f, 1.29524559e-01f, 2.98863873e-02f, 7.27040751e-05f, 4.49210182e-02f, 1.59538761e-01f,
  -3.13062519e-02f, 1.75606936e-01f, -2.09313691e-01f, 2.08492935e-01f, 1.09250871e-02f, 2.30490923e-01f, -2.75563419e-01f, 6.05740957e-02f, 2.60174185e-01f, -1.21084051e-02f,
  -1.37546852e-01f, 5.02028354e-02f, 5.32509983e-02f, 2.69657299e-02f, -1.50819309e-02f, 8.57778713e-02f, 1.19545870e-01f, 1.92768797e-02f, 9.12722498e-02f, 5.02091013e-02f,
  2.03736406e-02f, -1.12725474e-01f, 2.69996256e-01f, 9.06023234e-02f, -1.74741670e-01f, 9.52793285e-02f, 6.16343431e-02f, -6.14733249e-02f, 1.12831797e-02f, -1.03076361e-01f,
  -2.02388372e-02f, 9.64560136e-02f, 1.51247621e-01f, 1.97498072e-02f, 3.28829102e-02f, -5.62837794e-02f, -2.44185239e-01f, 9.84279737e-02f, 1.78129315e-01f, 7.69014135e-02f,
  8.04106295e-02f, 2.06955910e-01f, 1.93151519e-01f, -1.08731352e-01f, 1.92092136e-01f, -1.88816234e-01f, -2.08869189e-01f, 1.79140687e-01f, 3.27429958e-02f, 1.29464015e-01f,
  1.28389016e-01f, -6.76140934e-02f, -5.92729710e-02f, 1.87912732e-01f, 1.18668033e-02f, 1.00117795e-01f, 1.56699985e-01f, 1.03764199e-01f, 2.63758034e-01f, 1.71449468e-01f,
  -1.58703513e-02f, 9.87815903e-04f, 1.94469497e-01f, 1.19508587e-01f, 6.80316566e-03f, 8.42468068e-02f, 4.68992889e-02f, -1.85899526e-01f, 1.09101273e-02f, -1.23953342e-01f,
  2.50682801e-01f, 1.46863893e-01f, -3.07666868e-01f, 8.18925723e-02f, 2.10218459e-01f, -8.01668763e-02f, 2.64412582e-01f, 7.38958642e-02f, 6.02185261e-03f, 9.48835909e-03f,
  1.29595160e-01f, -1.47302359e-01f, 8.02215636e-02f, 1.79744847e-02f, 1.35860637e-01f, 1.01423319e-02f, -4.92100157e-02f, -2.97554228e-02f, 1.32421087e-02f, 1.65929034e-01f,
  9.03737769e-02f, 1.99429497e-01f, -5.70561960e-02f, 6.56067133e-02f, 2.66987711e-01f, 1.90626517e-01f, 2.66618486e-02f, 1.27667144e-01f, -8.04606378e-02f, -3.88861410e-02f,
  1.81124926e-01f, 7.85548314e-02f, 1.50841445e-01f, -1.09115854e-01f, -1.04286328e-01f, 1.27349079e-01f, 2.57321186e-02f, 1.30432069e-01f, -8.32362399e-02f, 7.61345252e-02f,
  2.03272358e-01f, -9.97473225e-02f, -1.92708578e-02f, 1.68769509e-01f, 1.71686023e-01f, 1.32312834e-01f, -6.87895268e-02f, 2.03899041e-01f, -1.37239784e-01f, -5.35223521e-02f,
  -5.09929694e-02f, -5.55418804e-02f, -3.30026805e-01f, -4.47308598e-03f, 8.46038535e-02f, 9.94476825e-02f, -2.84743775e-02f, 2.16702670e-01f, 1.34350747e-01f, 3.53627615e-02f,
  2.07804605e-01f, -4.30450216e-02f, -3.09250467e-02f, -1.61109250e-02f, -1.60284609e-01f, -9.60169658e-02f, -1.07013984e-02f, 3.92857455e-02f, -6.90884516e-02f, -9.30552632e-02f,
  -1.29796900e-02f, 1.01668835e-01f, -1.03713848e-01f, 2.60401014e-02f, 1.25616193e-01f, 2.25609288e-01f, -7.20207840e-02f, -5.89305442e-03f, 1.51997119e-01f, 6.73549995e-03f,
  1.37570336e-01f, 4.05119620e-02f, 9.40850228e-02f, 7.71248639e-02f, 4.81518768e-02f, 1.47232354e-01f, 9.30325240e-02f, 1.43075101e-02f, 1.03350803e-01f, 1.52030364e-01f,
  -1.33859605e-01f, 1.67981498e-02f, 3.49314734e-02f, 3.61044891e-03f, 1.08265504e-02f, 8.35502148e-02f, -3.25690508e-02f, -6.12834916e-02f, 1.40854299e-01f, 2.22802423e-02f,
  1.38942122e-01f, -2.79676970e-02f, 1.59842685e-01f, -1.86942369e-01f, -4.47031595e-02f, -2.22254563e-02f, 9.15565714e-02f, -4.10751775e-02f, -3.49921547e-02f, -1.09815240e-01f,
  -1.09452754e-02f, -2.35413145e-02f, 7.69511834e-02f, 2.47428760e-01f, -2.04272196e-01f, 1.70708448e-01f, -8.30960553e-03f, 1.05772438e-02f
};

// L1_fan_Bp_bar (Shape: 1 x 52)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 52;
const float L1_fan_Bp_bar_data[] = {
  1.72316194e-01f, 1.52878210e-01f, 1.15358554e-01f, 1.05604962e-01f, 1.43036067e-01f, 1.29815474e-01f, -1.31262410e-02f, 1.63217187e-01f, 4.38754819e-03f, 1.85740486e-01f,
  1.09242901e-01f, 2.25417465e-01f, 1.66572735e-01f, 3.39112096e-02f, 1.48215413e-01f, -2.22822838e-02f, 8.13873410e-02f, 2.44533699e-02f, 1.57560423e-01f, 1.12022862e-01f,
  1.20074749e-02f, 1.57097936e-01f, -8.81825089e-02f, -1.41111881e-01f, 1.91504613e-01f, 9.65210944e-02f, 1.70346320e-01f, 2.27190722e-02f, 8.44277292e-02f, 7.44832456e-02f,
  7.00110495e-02f, 9.39053670e-02f, 1.24894202e-01f, 1.04674116e-01f, -7.02145370e-03f, 6.50483295e-02f, 3.84107754e-02f, 1.31033301e-01f, 4.25116345e-02f, 2.03202642e-03f,
  -9.20719355e-02f, -3.12398071e-03f, -3.26713547e-02f, -5.15407771e-02f, 9.26952995e-03f, -6.03429088e-03f, 1.61538526e-01f, 4.26225178e-03f, 2.63687838e-02f, -3.20464163e-03f,
  1.76961958e-01f, 7.89453164e-02f
};

// L2_fan_Wp (Shape: 6 x 64)
const int L2_fan_Wp_rows = 6;
const int L2_fan_Wp_cols = 64;
const float L2_fan_Wp_data[] = {
  3.02701406e-02f, 1.50485197e-02f, 1.02292031e-01f, 1.01903155e-01f, 5.10316156e-02f, -6.87333522e-03f, -2.00357974e-01f, -4.61104289e-02f, -1.94547415e-01f, -1.16570957e-01f,
  1.29461855e-01f, -8.91109109e-02f, -4.21791114e-02f, 1.07816784e-02f, -6.57261349e-03f, 7.58756474e-02f, 1.28249675e-01f, -1.47666693e-01f, 1.10420465e-01f, 9.43273306e-02f,
  -1.05945900e-01f, -1.51532218e-01f, -6.02130182e-02f, -5.38755506e-02f, 1.01188868e-01f, 9.69393402e-02f, 5.46672419e-02f, 1.25504091e-01f, -1.43708795e-01f, 1.05899006e-01f,
  -1.24575153e-01f, -9.57482755e-02f, 1.14917025e-01f, -2.63307076e-02f, 5.17461263e-02f, -1.50193542e-03f, -3.54275405e-02f, -4.17846255e-02f, -5.22112101e-02f, 6.97731897e-02f,
  2.44566165e-02f, -7.39258751e-02f, 1.02385759e-01f, 1.20175086e-01f, -5.13047017e-02f, -1.02449611e-01f, 5.54972626e-02f, 9.87864062e-02f, 2.94841155e-02f, 3.17452773e-02f,
  -6.11243024e-02f, 1.67709261e-01f, 9.17403847e-02f, 2.22992927e-01f, 7.52320066e-02f, 1.27687931e-01f, -1.41152948e-01f, 9.82292965e-02f, -7.03970864e-02f, 3.72142829e-02f,
  -1.07778981e-01f, -1.43587950e-03f, 4.47943015e-03f, 1.25288367e-01f, 4.09558937e-02f, 1.74511857e-02f, 5.07936813e-02f, -1.86943114e-01f, -1.15557291e-01f, -1.07971393e-01f,
  1.54068336e-01f, 5.33805043e-02f, -6.95437267e-02f, -1.03384696e-01f, 2.27186367e-01f, -6.89860387e-03f, -3.64793278e-02f, 1.20911591e-01f, 1.21752471e-02f, -5.67022637e-02f,
  4.88637798e-02f, -1.87065274e-01f, -4.47513536e-02f, 7.86557794e-02f, -4.39506583e-02f, -1.02449983e-01f, 1.81100313e-02f, -1.97236583e-01f, -2.28270218e-02f, 6.94734529e-02f,
  -7.33716041e-02f, 1.18226469e-01f, 6.19833730e-02f, 1.09832630e-01f, -1.87877845e-02f, 1.15474477e-01f, 2.18733326e-02f, -3.41195911e-02f, -2.72714850e-02f, 4.75720465e-02f,
  6.56373948e-02f, -9.24736261e-02f, 1.32777184e-01f, 1.34435683e-01f, -1.58665568e-01f, 1.79431643e-02f, 2.18848488e-03f, -8.84755626e-02f, -1.81542516e-01f, -6.44040033e-02f,
  -7.18434229e-02f, 1.57469846e-02f, 1.08912982e-01f, 1.30506039e-01f, 7.02967644e-02f, -9.22847018e-02f, 1.41482381e-02f, 1.46963388e-01f, 3.46953012e-02f, 5.95189780e-02f,
  5.00397459e-02f, 5.35056405e-02f, 1.60226583e-01f, -1.90737490e-02f, -8.74091238e-02f, 8.62788118e-04f, 1.46881221e-02f, -5.35150468e-02f, -1.16397582e-01f, -7.73707479e-02f,
  1.08196430e-01f, -1.45482033e-01f, -1.15338184e-01f, -8.07954893e-02f, -1.12733692e-01f, -3.59898806e-02f, -1.62260175e-01f, 5.68864197e-02f, 1.30749017e-01f, 1.53803853e-02f,
  -5.01001701e-02f, -1.57894939e-03f, 1.26795858e-01f, -4.81888056e-02f, -7.31291920e-02f, -1.67721376e-01f, -7.97395855e-02f, 9.50992331e-02f, -4.55585942e-02f, -1.17406048e-01f,
  6.08591959e-02f, -1.88884791e-02f, 1.39801323e-01f, 1.36697786e-02f, 4.76935878e-02f, -1.51155770e-01f, -5.61280847e-02f, -5.15368432e-02f, -2.04660714e-01f, -6.92925453e-02f,
  6.56354204e-02f, 7.77854472e-02f, 1.33518264e-01f, 5.31287789e-02f, 2.70422399e-02f, 3.14927436e-02f, -4.91469167e-02f, -2.54376773e-02f, 7.79557601e-02f, -2.23150458e-02f,
  1.29184738e-01f, 9.69750509e-02f, 1.51869759e-01f, -6.76411763e-02f, -1.17720991e-01f, 4.59316000e-02f, 1.21086314e-01f, 1.10565193e-01f, 1.24971651e-01f, 1.39142737e-01f,
  -8.13906938e-02f, -1.42238522e-02f, 6.60197213e-02f, -8.98721721e-03f, -4.22893353e-02f, -7.27303997e-02f, -1.45986006e-01f, -5.68802841e-02f, 3.82587425e-02f, -1.16067618e-01f,
  1.19662851e-01f, -1.25959106e-02f, 1.20330798e-02f, -7.34642297e-02f, 1.73016101e-01f, 6.08321093e-02f, 7.43025467e-02f, 1.44778237e-01f, -1.54777050e-01f, -1.34401798e-01f,
  1.02870733e-01f, 2.29279194e-02f, -2.23827332e-01f, -8.91434327e-02f, -3.37693654e-02f, -1.11758351e-01f, 1.32917717e-01f, 1.19295813e-01f, 8.89468193e-02f, 1.09154530e-01f,
  1.14494830e-01f, 1.20472554e-02f, -4.86180261e-02f, 5.28074950e-02f, 7.01571554e-02f, 1.07394204e-01f, 4.15314473e-02f, -1.40044764e-01f, 1.15398072e-01f, -4.46705557e-02f,
  -9.25750881e-02f, -1.76756695e-01f, 7.85884336e-02f, -3.16914879e-02f, 1.66944191e-01f, 2.78708655e-02f, 1.53040931e-01f, -1.10136136e-01f, -1.35847166e-01f, 9.05761421e-02f,
  8.98514912e-02f, -1.80788621e-01f, -3.20669226e-02f, 1.49327680e-01f, -6.10037483e-02f, 1.01467781e-01f, -3.47097106e-02f, 4.36589569e-02f, 1.12852259e-02f, -9.87643935e-03f,
  -5.89054413e-02f, 7.27374107e-02f, -4.48798202e-02f, 2.09937215e-01f, -1.19821571e-01f, -4.55810763e-02f, -1.61753476e-01f, 3.43982689e-02f, 9.11345705e-02f, -1.82612941e-01f,
  5.30270003e-02f, -1.42640755e-01f, -4.26412746e-02f, -4.95518744e-03f, -1.47058025e-01f, 1.81966573e-01f, 8.95065144e-02f, 3.13298926e-02f, 9.57507342e-02f, 3.14805582e-02f,
  -7.43284151e-02f, -3.80382827e-03f, -1.81799427e-01f, -2.23868489e-01f, -3.50225531e-02f, -4.59604822e-02f, 8.85281190e-02f, -8.18091705e-02f, -1.70180544e-01f, -2.22537518e-02f,
  -1.10868163e-01f, -6.95716217e-02f, 1.72970057e-01f, -1.39457867e-01f, 1.78517029e-01f, 2.89115049e-02f, -1.77661367e-02f, 1.14481471e-01f, -1.14336438e-01f, 6.31403774e-02f,
  2.80584227e-02f, -7.93922916e-02f, -1.07745454e-01f, 1.23677656e-01f, -4.53132205e-02f, -2.33131181e-02f, -2.45966613e-02f, -7.90425241e-02f, 2.76980735e-02f, -4.01009470e-02f,
  1.02221578e-01f, 8.40082243e-02f, -9.88588110e-02f, -6.18321784e-02f, 2.34140959e-02f, -7.53376633e-02f, 9.83736143e-02f, 3.18204314e-02f, 1.83059543e-01f, 2.02315941e-01f,
  -1.25422418e-01f, -9.21261981e-02f, 1.04065388e-01f, 3.67737236e-03f, -1.04432166e-01f, -6.17973469e-02f, -1.85492590e-01f, -2.64175199e-02f, 5.34148514e-02f, -4.99541648e-02f,
  -6.60450608e-02f, 5.04042841e-02f, 1.36468992e-01f, 9.00564492e-02f, 4.95853461e-02f, 1.07883789e-01f, 6.12970814e-02f, 2.05473185e-01f, -1.48252398e-01f, 1.19200110e-01f,
  -8.19595009e-02f, 8.50726217e-02f, 2.00757936e-01f, 2.42926404e-02f, -9.67195034e-02f, 2.68727802e-02f, -1.99191377e-01f, 1.80022623e-02f, 3.48667651e-02f, 9.22050998e-02f,
  1.02769002e-01f, -2.00592801e-01f, -2.41950643e-03f, -8.72969553e-02f, 2.80559398e-02f, 5.14051206e-02f, -7.26564089e-03f, -2.07045600e-02f, -8.38429574e-03f, 6.53494149e-02f,
  -5.45603372e-02f, 1.47255231e-02f, -1.09147653e-01f, 4.53591868e-02f, 4.65611592e-02f, 1.73332226e-02f, -4.07212190e-02f, -8.86118039e-02f, 1.95348915e-02f, -9.44753438e-02f,
  -3.57463330e-01f, 3.66266556e-02f, 3.70289199e-03f, 2.18213294e-02f, 1.36349022e-01f, 5.69783784e-02f, 3.73652242e-02f, -7.13384748e-02f, -3.81732769e-02f, -5.92641495e-02f,
  1.41783327e-01f, -5.20291403e-02f, 1.55678749e-01f, 1.55168116e-01f, 1.91720143e-01f, -8.77306163e-02f, 7.98266754e-02f, 1.51776701e-01f, 9.57879424e-02f, -3.32561359e-02f,
  1.68036655e-01f, 1.44858703e-01f, -4.26197462e-02f, -6.65713847e-02f, -4.79871295e-02f, -2.06204262e-02f, -2.89097186e-02f, -4.59591113e-02f, -5.76062128e-02f, -5.81214987e-02f,
  -8.56294334e-02f, 4.77932729e-02f, 5.80408983e-02f, 7.73496479e-02f
};

// L2_fan_Wp_bar (Shape: 52 x 64)
const int L2_fan_Wp_bar_rows = 52;
const int L2_fan_Wp_bar_cols = 64;
const float L2_fan_Wp_bar_data[] = {
  1.11763500e-01f, 1.65634230e-02f, 1.56106539e-02f, -4.63400781e-02f, -5.99925332e-02f, 1.21464103e-01f, 7.17506632e-02f, 2.57136881e-01f, -1.40117854e-01f, -8.21993202e-02f,
  5.86109981e-02f, 1.18978716e-01f, -3.85932401e-02f, 9.65198576e-02f, -1.16530374e-01f, 5.07617444e-02f, 3.00916079e-02f, 1.04917072e-01f, -5.00254706e-03f, 5.77435493e-02f,
  5.10016866e-02f, 7.19914287e-02f, -4.29049022e-02f, 7.02159032e-02f, 1.88482720e-02f, 1.70997649e-01f, 1.93703342e-02f, 6.16531856e-02f, -1.45514652e-01f, 2.29825795e-01f,
  2.34621763e-01f, 1.31739393e-01f, -1.53246760e-01f, 5.10885157e-02f, -1.19899213e-02f, -7.99738467e-02f, 9.58430991e-02f, -8.89532864e-02f, -9.91392881e-02f, 2.72508353e-01f,
  -2.13325560e-01f, 1.16952635e-01f, -8.24945047e-02f, -6.46780059e-02f, -6.91381767e-02f, 3.59847285e-02f, -2.45386660e-02f, 6.23642392e-02f, -2.45152451e-02f, 2.00439960e-01f,
  1.76047400e-01f, -7.87951890e-03f, 2.25279093e-01f, 2.97961142e-02f, 3.62951905e-02f, 1.24767302e-02f, 1.47625893e-01f, 2.54311442e-01f, 1.45398855e-01f, 2.36535251e-01f,
  6.55034557e-02f, -4.12626043e-02f, 1.60979167e-01f, -1.45796716e-01f, 1.30416065e-01f, 5.58409914e-02f, -5.94143309e-02f, -8.99447873e-03f, -3.07758395e-02f, 8.72713402e-02f,
  2.92418599e-01f, 1.93166971e-01f, 6.38357028e-02f, 3.55539396e-02f, 3.18055786e-02f, 1.71014994e-01f, 2.55308837e-01f, 2.61014104e-01f, 1.00999080e-01f, -1.07050546e-01f,
  1.19448222e-01f, 1.40105233e-01f, -3.99040990e-02f, -8.95027164e-03f, 3.21325473e-02f, 1.06827602e-01f, -1.02458987e-02f, -1.47257969e-01f, 4.44604084e-02f, 9.67350602e-02f,
  -6.73054084e-02f, -1.40683785e-01f, 1.69403359e-01f, 2.38087177e-01f, -4.38744854e-03f, 2.41501242e-01f, -2.82920115e-02f, 1.33837640e-01f, -3.16334739e-02f, -6.29374087e-02f,
  1.51537672e-01f, 1.96919695e-01f, -2.02104226e-01f, 1.98403880e-01f, -9.51290578e-02f, 1.52190134e-01f, -3.53695937e-02f, -1.20692834e-01f, 1.32099345e-01f, 2.70728618e-01f,
  -1.20301679e-01f, 2.17403937e-02f, 8.20073634e-02f, 5.60859852e-02f, 2.50479043e-01f, -1.69468775e-01f, 1.17369406e-01f, 1.05161734e-01f, 1.93541571e-02f, 3.41802835e-02f,
  -1.31513772e-03f, 2.57044464e-01f, -9.13898274e-02f, -4.87317704e-03f, 8.09201375e-02f, -1.31996408e-01f, 2.73544908e-01f, 2.74241879e-03f, -2.05389962e-01f, 5.82692549e-02f,
  -5.19398926e-03f, 1.01045646e-01f, -6.65571243e-02f, -1.10552222e-01f, -2.67189860e-01f, -1.39726326e-01f, -5.75583708e-03f, 1.00839734e-01f, 1.87787339e-01f, -1.39372095e-01f,
  1.42089024e-01f, 1.74813941e-02f, 2.74164379e-01f, 3.08448106e-01f, -3.39389183e-02f, -2.14298114e-01f, 1.34653434e-01f, 4.83039999e-03f, -4.00943607e-02f, 6.84163123e-02f,
  1.38789088e-01f, 2.13454925e-02f, 1.80262581e-01f, -6.73925206e-02f, 7.65932277e-02f, -8.95937346e-03f, -7.05482364e-02f, 1.62175670e-01f, -2.52093703e-01f, 5.26930504e-02f,
  2.74599582e-01f, 1.97558925e-01f, 2.96919525e-01f, 2.78227367e-02f, 1.61811829e-01f, 2.00283974e-01f, -1.32808998e-01f, -1.57153040e-01f, 3.86401676e-02f, -4.33393605e-02f,
  1.90972283e-01f, -6.82586164e-04f, 3.03868920e-01f, -3.08790728e-02f, -1.43314123e-01f, 2.70185262e-01f, 2.43878335e-01f, 1.36547193e-01f, 2.29249626e-01f, 2.25982349e-03f,
  3.51637900e-02f, 9.26928446e-02f, 2.11987063e-01f, 1.23290069e-01f, -8.09070393e-02f, -1.33232087e-01f, -6.03763126e-02f, 2.69680396e-02f, -1.83044314e-01f, 6.56764284e-02f,
  1.50813863e-01f, -1.52029900e-03f, -7.61504322e-02f, 3.55556495e-02f, 1.91997230e-01f, 1.88035905e-01f, 1.05046652e-01f, -7.22160637e-02f, -3.03212315e-01f, -4.28935289e-02f,
  9.84171331e-02f, 1.49327159e-01f, 2.71323416e-02f, -2.78682709e-01f, 4.93359417e-02f, 1.65821269e-01f, 2.64248461e-01f, 3.29692930e-01f, 9.30144936e-02f, -5.41983247e-02f,
  5.06572984e-02f, 1.69707656e-01f, -1.30236402e-01f, 8.71836096e-02f, -2.35859603e-02f, 1.16040155e-01f, 2.51443624e-01f, 1.08811982e-01f, 1.18117839e-01f, -2.13082612e-01f,
  -2.19843879e-01f, 4.63529676e-02f, 9.87756774e-02f, 9.78376493e-02f, 2.96645582e-01f, 1.70877576e-01f, 1.69885874e-01f, -3.68828420e-03f, -6.68050349e-02f, 6.65567592e-02f,
  8.97491798e-02f, -4.07911837e-03f, 2.37790629e-01f, 1.71533048e-01f, 1.29330084e-01f, 1.30144522e-01f, 1.45407081e-01f, 4.20066230e-02f, -5.31161539e-02f, 1.78074569e-01f,
  7.38358404e-03f, -2.36609839e-02f, 1.14117870e-02f, 2.57275611e-01f, -1.95042670e-01f, 9.57597941e-02f, 1.39304698e-01f, -3.44371311e-02f, -6.44948259e-02f, -1.88858271e-01f,
  -1.04469806e-02f, 9.22839567e-02f, -1.85625389e-01f, 1.57293212e-02f, 5.32602556e-02f, 9.73964855e-02f, 2.92238649e-02f, 2.54114151e-01f, -2.63829902e-02f, 9.75929797e-02f,
  7.76120275e-02f, 2.83773810e-01f, -1.23331241e-01f, -5.20219281e-02f, 2.88499985e-03f, 1.20680556e-01f, -3.37242454e-01f, 1.21760279e-01f, 2.08707720e-01f, 1.76174477e-01f,
  8.06331560e-02f, 1.83937371e-01f, 1.37403369e-01f, 2.21668720e-01f, 1.66308600e-02f, 4.00510356e-02f, 2.61872560e-01f, 2.56558806e-01f, 2.42251262e-01f, 2.58235067e-01f,
  -1.94209859e-01f, 7.38926372e-03f, 2.89576888e-01f, 1.63971807e-03f, -3.09435483e-02f, 4.82186750e-02f, -2.47450829e-01f, 1.58323959e-01f, -9.18510184e-02f, -5.04936278e-02f,
  5.33583798e-02f, -7.14490488e-02f, 6.03512824e-02f, 8.61891955e-02f, 1.20946869e-01f, -5.20539023e-02f, 5.67131005e-02f, 1.44892365e-01f, -1.52955338e-01f, -3.95215042e-02f,
  -9.67775807e-02f, 2.00177386e-01f, -1.04814962e-01f, 1.59668308e-02f, -7.18219429e-02f, 2.30793640e-01f, 1.51623011e-01f, 2.60646511e-02f, -5.69662303e-02f, -2.60995608e-02f,
  -1.67441726e-01f, -1.37537882e-01f, 3.78607772e-02f, 8.35473090e-02f, 6.55413941e-02f, 2.70140141e-01f, 2.37041891e-01f, -9.24083441e-02f, -5.92071377e-03f, 6.50460124e-02f,
  -1.73307985e-01f, 4.60395915e-03f, -2.96458695e-02f, 5.86993620e-02f, 1.52114838e-01f, 7.83781111e-02f, -2.50671506e-01f, -1.03014624e-02f, 9.39971805e-02f, 2.45168284e-01f,
  -3.68864924e-01f, -1.04063094e-01f, -1.45447731e-01f, 9.39415693e-02f, 3.93475145e-02f, 3.15832913e-01f, -4.84004840e-02f, 1.67953297e-01f, -1.28184944e-01f, -1.42685562e-01f,
  -2.83562429e-02f, 7.78024122e-02f, 2.90207654e-01f, 1.81545436e-01f, 8.05498958e-02f, -1.20848045e-01f, 2.31426015e-01f, 6.99807657e-03f, -1.72123849e-01f, 1.43775895e-01f,
  -2.38278449e-01f, 1.87251583e-01f, 9.01283696e-02f, 1.67435186e-03f, 1.52481377e-01f, 1.30356848e-01f, 2.48996690e-01f, -3.20265926e-02f, 5.41902035e-02f, -1.35100886e-01f,
  1.77440152e-01f, -1.36110321e-01f, 3.02024633e-02f, 4.01986064e-03f, 4.95881774e-03f, 2.59293944e-01f, -1.61128297e-01f, -3.12843658e-02f, 1.06299676e-01f, 2.42510930e-01f,
  2.62211174e-01f, -1.65872071e-02f, 7.71767274e-02f, 4.68537677e-03f, -6.40747100e-02f, -1.42966835e-02f, -3.41480039e-02f, -4.98371273e-02f, -1.52301684e-01f, 2.34553248e-01f,
  7.97805283e-03f, -1.64512038e-01f, 1.03605770e-01f, 2.32066326e-02f, 6.41351789e-02f, 1.50764287e-01f, 1.36500642e-01f, -8.38135704e-02f, 1.43169174e-02f, 1.37700625e-02f,
  -4.70549893e-03f, -3.29990178e-01f, 2.69090891e-01f, 1.25264907e-02f, 3.38788927e-02f, 3.48829105e-02f, 1.16644278e-01f, -1.93587691e-01f, 1.50538802e-01f, -7.20976293e-02f,
  1.42835498e-01f, 1.56309396e-01f, -1.23973880e-02f, 9.37039554e-02f, 7.86355808e-02f, 1.41383275e-01f, -8.30861777e-02f, 1.13228597e-01f, 6.31627813e-02f, -2.67841786e-01f,
  6.61840439e-02f, 2.16371696e-02f, 1.04282297e-01f, -2.73306787e-01f, 3.16267908e-02f, 7.65021369e-02f, 1.07033014e-01f, 1.15082949e-01f, -1.77279726e-01f, -3.02644540e-02f,
  -9.78815481e-02f, 1.06644437e-01f, 5.95462210e-02f, -1.63823888e-01f, 1.12197213e-01f, 2.14777738e-01f, -6.62748609e-03f, 1.30870342e-01f, 2.04777375e-01f, -1.06302887e-01f,
  1.00355767e-01f, 5.35664149e-02f, -1.04840226e-01f, -3.29110950e-01f, 5.50607927e-02f, 8.32211748e-02f, -1.31014541e-01f, -6.12671152e-02f, -5.62410951e-02f, -9.76327658e-02f,
  2.18212724e-01f, -3.62175927e-02f, 1.43140465e-01f, -6.36093412e-03f, -1.21776864e-01f, 1.19953297e-01f, 9.16334465e-02f, 1.51836753e-01f, -9.79382694e-02f, -9.28275883e-02f,
  3.48148942e-02f, -8.85754600e-02f, -8.72071087e-02f, -1.55838458e-02f, -8.43218789e-02f, 3.66421118e-02f, -1.10001735e-01f, 3.31421047e-02f, -4.86085080e-02f, -1.20742932e-01f,
  -1.38235599e-01f, -1.05734557e-01f, -1.27360255e-01f, 2.63503063e-02f, 3.48117426e-02f, -1.42136188e-02f, 3.96874510e-02f, -9.86426510e-03f, -2.72291973e-02f, -3.77397686e-02f,
  4.29602489e-02f, -5.32858670e-02f, -1.44054234e-01f, -5.37385866e-02f, -1.02912784e-01f, -5.72679332e-03f, 3.73100350e-03f, -5.37826307e-02f, -5.40674217e-02f, 7.81313106e-02f,
  8.43771175e-02f, 8.87087882e-02f, -2.14469209e-02f, 1.16415650e-01f, -4.09543104e-02f, 3.04561928e-02f, -7.50903934e-02f, -9.58942994e-02f, 5.08840121e-02f, -8.00514780e-03f,
  -3.94374914e-02f, 2.74921693e-02f, -1.20550901e-01f, -1.48247257e-01f, 1.76684931e-02f, -1.20779701e-01f, 4.68959846e-02f, -5.38923666e-02f, -1.12952426e-01f, -1.23106264e-01f,
  -1.32233858e-01f, 8.70449021e-02f, 4.23603617e-02f, 9.39362794e-02f, -3.27011198e-02f, 8.12295377e-02f, 1.04234196e-01f, -7.36901909e-02f, 7.86899924e-02f, -5.75338565e-02f,
  8.93884972e-02f, -5.23271300e-02f, -1.16799949e-02f, -9.42018554e-02f, 1.35327667e-01f, 5.45769706e-02f, 7.03755096e-02f, -1.44257978e-01f, -1.29605010e-01f, 1.06400885e-01f,
  -2.39062637e-01f, -1.44585613e-02f, 2.86852010e-02f, 6.55388907e-02f, -2.02007875e-01f, 6.61409646e-02f, -1.38903325e-02f, 1.93241566e-01f, -8.64913166e-02f, 2.76622772e-02f,
  -1.75507944e-02f, -1.24457315e-01f, 4.81789447e-02f, -1.60110489e-01f, 2.32225806e-01f, -3.70260514e-02f, 1.76148668e-01f, 1.31008640e-01f, 1.56352103e-01f, -1.08690709e-01f,
  -4.44539031e-03f, 2.39505216e-01f, -1.17823750e-01f, 1.48450746e-03f, -1.02381967e-02f, 1.36242226e-01f, 3.28165561e-01f, -2.58630817e-03f, 2.19692841e-01f, 3.30654047e-02f,
  -6.44879937e-02f, 1.62830189e-01f, -7.47210383e-02f, -1.87959120e-01f, -5.34681231e-02f, 5.51611111e-02f, 1.78667828e-01f, 7.98055083e-02f, -1.60869315e-01f, 2.10604697e-01f,
  2.30193827e-02f, 2.21205831e-01f, 8.08514953e-02f, 6.29709614e-03f, 6.94497824e-02f, 2.41682276e-01f, -2.75708716e-02f, -6.50169179e-02f, -1.09432250e-01f, 6.93844035e-02f,
  -2.15046778e-01f, 9.49068442e-02f, 1.33194029e-01f, -1.05964087e-01f, 6.56551644e-02f, -1.78179383e-01f, 9.34048891e-02f, 4.07506526e-02f, 1.96609378e-01f, 1.51016757e-01f,
  6.54440746e-02f, 5.96938618e-02f, -6.05231151e-02f, 2.13859364e-01f, -3.33397388e-02f, -3.10538292e-01f, -4.83258627e-02f, -3.93184088e-02f, 5.07676266e-02f, 8.94731879e-02f,
  -1.47240028e-01f, -4.45864275e-02f, 6.92009255e-02f, -6.99582323e-02f, 2.31318220e-01f, 1.59331962e-01f, 1.65481955e-01f, -6.94232509e-02f, -6.12261631e-02f, 1.68597803e-01f,
  -6.77048936e-02f, 1.72009856e-01f, 1.34202436e-01f, 1.66164011e-01f, -1.54069945e-01f, 2.71283723e-02f, 3.32271576e-01f, -3.92485084e-03f, 1.29578441e-01f, -8.24420899e-02f,
  -1.65860936e-01f, 1.83266085e-02f, 1.51025578e-01f, -9.98604298e-02f, 2.33168036e-01f, 1.85846742e-02f, 4.15879525e-02f, 9.55540463e-02f, -5.70807196e-02f, -2.62436047e-02f,
  -1.94701925e-01f, 6.43632859e-02f, 1.77084371e-01f, 5.71720302e-02f, -8.24889690e-02f, 1.51373282e-01f, -1.94281265e-02f, 2.04967916e-01f, 3.71006913e-02f, 2.45872453e-01f,
  1.35436282e-01f, 1.86205477e-01f, 1.11317746e-01f, 1.00151218e-01f, 1.24608688e-02f, 4.62174602e-02f, 2.04964891e-01f, 1.75333709e-01f, -6.17567301e-02f, -6.16920739e-02f,
  9.75701883e-02f, 7.98121914e-02f, 1.08805299e-01f, 1.02255002e-01f, 1.69159681e-01f, -9.13029313e-02f, -1.11936055e-01f, -2.18894392e-01f, -1.36821136e-01f, -8.30499362e-03f,
  2.59925574e-01f, -9.13723409e-02f, -3.09350938e-02f, -2.99793947e-02f, 5.25606237e-02f, 2.14354396e-02f, 7.00657740e-02f, -1.52490631e-01f, 2.71292180e-01f, 1.71407327e-01f,
  -5.76612577e-02f, 1.01159319e-01f, 6.15733210e-03f, 4.94581722e-02f, 2.12661073e-01f, 9.63219032e-02f, -6.58622459e-02f, 2.17998892e-01f, 9.54375193e-02f, -8.98795128e-02f,
  5.34689963e-01f, -5.25198728e-02f, 2.66289622e-01f, 1.57266796e-01f, 1.60018485e-02f, 7.97137097e-02f, -2.70573515e-02f, 7.30411485e-02f, 3.08126986e-01f, 1.30923301e-01f,
  1.00749582e-01f, 1.55741736e-01f, 1.80386513e-01f, 2.22534284e-01f, 1.44647092e-01f, -1.34658337e-01f, 1.30742818e-01f, 2.70537555e-01f, 1.95967451e-01f, -1.07599847e-01f,
  -4.02543098e-02f, 4.90721837e-02f, -1.44063383e-01f, 1.80414751e-01f, 1.53564513e-01f, 8.19613189e-02f, 2.96218060e-02f, 9.84937623e-02f, 2.06141725e-01f, -1.13432005e-01f,
  -7.67934555e-03f, 1.30226105e-01f, -5.20595349e-03f, 1.69438850e-02f, 2.50731587e-01f, 9.26754475e-02f, -4.98980470e-02f, -1.17198676e-02f, -5.05118184e-02f, 1.30523235e-01f,
  3.98856044e-01f, 1.01506501e-01f, 7.85106346e-02f, 7.41017014e-02f, -1.54280826e-01f, 1.33772731e-01f, 2.75233507e-01f, 1.64286450e-01f, -3.23957705e-04f, 2.61042155e-02f,
  -6.57566190e-02f, 2.09823370e-01f, -3.63145620e-02f, -1.53954551e-01f, 1.32894710e-01f, 1.42884888e-02f, 1.03256039e-01f, 1.17056511e-01f, 1.95228755e-02f, 4.25439700e-02f,
  2.63897814e-02f, -1.08991221e-01f, 1.87158749e-01f, 2.01695096e-02f, 9.95893627e-02f, 7.14941174e-02f, -2.45486513e-01f, 3.76957096e-02f, -1.14657149e-01f, -6.47687167e-02f,
  -2.39091739e-02f, -4.27289214e-03f, -1.34301320e-01f, -1.37053624e-01f, -4.93905507e-02f, 2.16417000e-01f, -1.19198062e-01f, -6.39735982e-02f, -1.11060254e-01f, 1.92443326e-01f,
  -6.43455237e-02f, -2.32167900e-01f, -7.73322210e-02f, -4.49709259e-02f, 1.59410104e-01f, -2.70622671e-01f, -7.57022873e-02f, -1.94974080e-01f, -1.67842120e-01f, -2.22067550e-01f,
  6.02526031e-02f, -1.38137024e-02f, 1.76397309e-01f, 1.48966447e-01f, 3.76227498e-02f, 3.07811555e-02f, 3.38985547e-02f, 1.50181010e-01f, -2.41818838e-02f, -2.13825591e-02f,
  -3.83395925e-02f, 5.73495887e-02f, 9.44972411e-02f, -1.26266941e-01f, -7.79969990e-02f, 8.04353878e-02f, -1.42414108e-01f, -1.34943023e-01f, 2.96529919e-01f, 1.73661396e-01f,
  -1.27250448e-01f, 4.29332396e-03f, -3.26232612e-02f, -1.71196505e-01f, 2.39747569e-01f, -1.04225419e-01f, -3.16293910e-02f, 1.32963285e-01f, 1.39624000e-01f, -2.70323809e-02f,
  -2.19514011e-03f, -2.63566136e-01f, 3.48539092e-02f, -2.07540276e-03f, 3.18968520e-02f, 1.53145809e-02f, -3.51711102e-02f, 2.48261333e-01f, -5.21540679e-02f, 6.34965971e-02f,
  -2.04448715e-01f, 1.30665600e-01f, 6.65643588e-02f, -1.18583739e-01f, 1.57656938e-01f, 1.07185535e-01f, -9.53330547e-02f, 1.50872141e-01f, -1.14270806e-01f, -1.43317908e-01f,
  -1.41425118e-01f, -5.89247271e-02f, 5.44418618e-02f, 2.63838228e-02f, 9.23599899e-02f, 6.50733635e-02f, 4.28711660e-02f, 1.98469207e-01f, 1.65654555e-01f, -1.28515750e-01f,
  2.29439542e-01f, 8.76532793e-02f, 6.44963309e-02f, 9.13846493e-02f, -4.31042090e-02f, 8.22062567e-02f, 7.19324723e-02f, -1.00774029e-02f, 5.03486656e-02f, 4.09978814e-02f,
  2.23091412e-02f, -2.52769720e-02f, 7.48334602e-02f, 9.78964642e-02f, -4.28396314e-02f, 4.44525145e-02f, -7.91560858e-02f, -2.44273972e-02f, -1.99401639e-02f, -7.34492019e-02f,
  -6.77721351e-02f, 7.46942312e-02f, 7.31195658e-02f, -8.07137862e-02f, -5.32772066e-03f, -4.12058458e-03f, -9.74427164e-02f, -3.65062281e-02f, -2.58512478e-02f, -8.32544938e-02f,
  -9.38197970e-02f, 3.34301256e-02f, 7.23139420e-02f, -6.89837933e-02f, -1.25593707e-01f, -1.71746388e-02f, -8.46128166e-02f, -9.53209586e-03f, -7.89635777e-02f, -2.28920616e-02f,
  1.01945341e-01f, -5.88577464e-02f, 1.00801252e-01f, 1.16400905e-01f, 9.37843546e-02f, 6.13472387e-02f, 4.65010852e-02f, 1.23806193e-01f, -1.16020806e-01f, -4.62993607e-02f,
  -9.22987610e-02f, 9.66657177e-02f, 3.23930904e-02f, -8.87187794e-02f, -1.15373068e-01f, 1.06470697e-01f, -1.00419722e-01f, -8.23637396e-02f, -6.81603551e-02f, 1.23888105e-02f,
  -1.02729738e-01f, 4.55642305e-02f, 4.13001440e-02f, -4.10573110e-02f, 4.71609384e-02f, 3.32216769e-02f, -9.17079225e-02f, 1.07941024e-01f, 2.27096770e-03f, -8.77135992e-03f,
  3.44294943e-02f, -9.85922217e-02f, -1.76487435e-02f, -8.30887407e-02f, 1.70813091e-02f, -6.76280558e-02f, 1.28902659e-01f, 2.02114031e-01f, 1.69458419e-01f, 1.11571811e-01f,
  1.79252788e-01f, 3.63401063e-02f, -1.21735632e-01f, -1.93054080e-01f, 1.13932557e-01f, -1.07675426e-01f, 1.26227885e-01f, -2.44568318e-01f, -1.65417850e-01f, -3.68545949e-02f,
  1.07421540e-01f, -1.76259041e-01f, 2.69739956e-01f, 1.60147130e-01f, 2.75008619e-01f, 2.82091111e-01f, 1.87113285e-01f, 2.23038733e-01f, 2.14852989e-02f, 7.98885897e-02f,
  4.74782027e-02f, -4.14178073e-02f, 1.86426565e-01f, 3.35340917e-01f, 4.39199470e-02f, -1.53863698e-01f, 4.67355698e-01f, 3.52818891e-02f, 5.90022095e-02f, -7.56671876e-02f,
  -7.90970698e-02f, -5.30575812e-02f, -1.12933941e-01f, 1.22957811e-01f, 2.17685282e-01f, 5.17876260e-02f, 1.51442289e-01f, 5.18927053e-02f, 2.43342742e-01f, 2.96222359e-01f,
  1.53029338e-01f, -1.69878677e-01f, 2.63630390e-01f, 2.40021423e-01f, -9.62945297e-02f, -2.67192334e-01f, -1.44995391e-01f, 1.25764325e-01f, -4.76866737e-02f, 5.93505315e-02f,
  1.77975431e-01f, 2.31255278e-01f, 1.27234250e-01f, 1.16246298e-01f, 9.61914808e-02f, -1.55446231e-01f, 7.37406462e-02f, 3.23341489e-01f, -6.97966516e-02f, 1.70068190e-01f,
  1.72796667e-01f, 8.53178427e-02f, 2.07679141e-02f, 1.97109789e-01f, 1.43494174e-01f, 1.54611737e-01f, -1.01068258e-01f, 8.50890875e-02f, -1.09206781e-01f, -2.89855987e-01f,
  1.59300461e-01f, -1.41075030e-01f, -6.38554469e-02f, -4.59691323e-02f, 8.38496685e-02f, -6.86681420e-02f, 2.42486838e-02f, 3.25224400e-02f, 1.50364414e-01f, 1.80405721e-01f,
  -1.47254780e-01f, -2.24061329e-02f, -1.27460919e-02f, 1.93987831e-01f, 2.34730300e-02f, 1.81408584e-01f, -4.92435172e-02f, 1.14797734e-01f, -1.49263874e-01f, 3.17323655e-02f,
  6.16025627e-01f, -1.81569576e-01f, 3.01544983e-02f, -1.07029773e-01f, -1.21507324e-01f, 7.53636062e-02f, -8.38488564e-02f, -8.51147808e-03f, 3.15456152e-01f, -1.71900559e-02f,
  8.26969966e-02f, -7.93008506e-03f, 6.98013157e-02f, 2.34059125e-01f, 3.78151089e-02f, -1.65750831e-01f, 3.04856688e-01f, -3.31425667e-03f, -1.13650588e-02f, -1.31278917e-01f,
  -1.20328981e-02f, 2.68744886e-01f, -5.94903156e-02f, 8.85134190e-02f, 1.36660025e-01f, 2.54845232e-01f, 1.50579467e-01f, -4.26778495e-02f, 1.32850572e-01f, 9.16009396e-03f,
  2.67426521e-02f, 2.97738075e-01f, -9.11741778e-02f, 8.78495127e-02f, -2.55872067e-02f, 5.63200079e-02f, -2.21528545e-01f, -1.09345026e-01f, -1.83460370e-01f, -3.19121182e-02f,
  2.29782686e-01f, 9.06253681e-02f, 8.70557874e-03f, 1.29511118e-01f, 6.49166927e-02f, 1.92467034e-01f, 2.74192654e-02f, 4.87496965e-02f, 5.60731180e-02f, -2.11580753e-01f,
  8.24468583e-02f, 6.35068417e-02f, -4.15302776e-02f, -5.51466122e-02f, 1.39811799e-01f, 6.35023117e-02f, -1.53318495e-01f, 8.22426402e-04f, -1.67153135e-01f, 1.01722274e-02f,
  -3.48457880e-02f, 4.11002599e-02f, 1.74896076e-01f, -1.33070990e-01f, 2.13608131e-01f, 1.12290740e-01f, -1.99860781e-01f, 1.28963724e-01f, 1.10801077e-02f, 6.11672550e-02f,
  -9.01364237e-02f, 9.27086994e-02f, -2.16902673e-01f, 9.99990106e-02f, -3.85916270e-02f, 1.53448256e-02f, -1.13160767e-01f, 7.01254010e-02f, -1.04876935e-01f, 3.20782103e-02f,
  1.84673414e-01f, -1.52170628e-01f, 1.09118901e-01f, -1.89932417e-02f, 5.33761568e-02f, -2.49576531e-02f, 1.79236770e-01f, 1.01368085e-01f, -1.20876329e-02f, 1.17610730e-02f,
  1.33960722e-02f, -3.34061347e-02f, 1.03887759e-01f, -8.41598865e-03f, 1.75009146e-01f, 9.08212066e-02f, 2.00333428e-02f, 1.14993900e-01f, -2.01208275e-02f, -3.65999178e-03f,
  1.49634659e-01f, 1.03494540e-01f, 5.78701757e-02f, -1.34899821e-02f, -1.37776732e-01f, 8.41974169e-02f, -2.41799623e-01f, -1.82324901e-01f, 2.55370200e-01f, -4.07806318e-03f,
  -2.59898938e-02f, 1.42735705e-01f, 8.28559622e-02f, 8.11282918e-02f, -6.70264363e-02f, -1.82921261e-01f, 3.26209851e-02f, 5.29309772e-02f, -1.44299597e-01f, 2.06200127e-02f,
  1.78524718e-01f, -1.03039369e-01f, 2.65135825e-01f, 2.31122389e-01f, -1.26813114e-01f, -1.37086108e-01f, 3.92306559e-02f, 2.43873373e-01f, 2.28811055e-01f, 1.27623543e-01f,
  9.14902017e-02f, 1.43528149e-01f, 1.95479110e-01f, -4.83219996e-02f, 1.41666621e-01f, 1.35419771e-01f, 4.79471385e-02f, 1.96620360e-01f, -9.44524407e-02f, -1.51416019e-01f,
  -3.29819024e-02f, -1.05195887e-01f, 1.32394701e-01f, 8.00728947e-02f, 1.61876693e-01f, 1.81437045e-01f, 2.59024590e-01f, 1.59069136e-01f, 1.86210275e-01f, -1.34455888e-02f,
  1.22705974e-01f, 1.75897554e-01f, 1.66548908e-01f, 2.46824563e-01f, -1.64707527e-01f, 1.32699087e-01f, 7.25403577e-02f, 1.83485746e-02f, -7.05967546e-02f, -3.09111259e-04f,
  2.43293434e-01f, 5.03747957e-03f, 1.51569456e-01f, 1.64567038e-01f, 2.13032454e-01f, 5.21745495e-02f, 1.13167010e-01f, 8.41231421e-02f, -7.27107674e-02f, 1.05246671e-01f,
  -7.29145631e-02f, -5.78048527e-02f, 1.29997609e-02f, -1.81856453e-01f, 7.29540959e-02f, -7.21188784e-02f, 4.78635877e-02f, 2.73052663e-01f, -2.54724354e-01f, -1.02612168e-01f,
  8.29635859e-02f, 1.65416554e-01f, -5.38492277e-02f, 8.58547315e-02f, -9.49952006e-02f, 2.56340563e-01f, 2.36064717e-01f, 2.20665634e-01f, 3.89917195e-02f, 6.87741786e-02f,
  -3.37881930e-02f, 2.80231074e-03f, 5.13743639e-01f, -1.08869061e-01f, 1.58004433e-01f, 2.06962764e-01f, 2.38570303e-01f, -7.79951736e-02f, 6.90108985e-02f, -1.24968095e-02f,
  7.94381127e-02f, -1.07941180e-01f, -9.43508744e-03f, 4.87225242e-02f, 1.62083164e-01f, 1.24381945e-01f, 7.04703061e-03f, 9.09186974e-02f, -1.13096356e-01f, 9.45765153e-02f,
  2.08367016e-02f, -2.24263277e-02f, 2.34705582e-01f, 1.63547903e-01f, -1.57187492e-01f, 3.36094238e-02f, 1.90858036e-01f, 1.17137939e-01f, 7.57351667e-02f, -1.60520524e-01f,
  1.66359425e-01f, -3.52273099e-02f, -5.12697324e-02f, 5.53315654e-02f, 1.51781708e-01f, 2.47467309e-02f, -2.87657045e-02f, -6.94661066e-02f, -6.57450914e-01f, 3.52826086e-03f,
  -2.55374074e-01f, -2.23174870e-01f, 3.08363914e-01f, -3.26342404e-01f, 4.42148186e-03f, 4.53267023e-02f, 3.05336624e-01f, 2.70002216e-01f, -3.85771573e-01f, 8.17819610e-02f,
  -3.75602216e-01f, -3.61476898e-01f, 3.58066559e-01f, 5.85038215e-02f, 1.01037949e-01f, -7.61397034e-02f, 3.35133821e-01f, 1.23568565e-01f, -9.39418562e-03f, 3.86561975e-02f,
  -3.39551032e-01f, -1.14231862e-01f, 7.42447376e-02f, 6.98531687e-01f, 5.32141089e-01f, 5.99806048e-02f, 1.70863345e-01f, -7.91829303e-02f, -9.10405666e-02f, -2.17367843e-01f,
  4.78742778e-01f, 7.84204602e-02f, 8.74479711e-02f, 1.28320034e-03f, -5.11954069e-01f, 3.23074311e-01f, -2.24265940e-02f, -2.73506165e-01f, -3.18286836e-01f, -6.80120438e-02f,
  -3.39328170e-01f, 3.14773768e-02f, 6.62760854e-01f, -5.47419265e-02f, 3.38226669e-02f, 9.22762901e-02f, -3.08532864e-01f, -4.99635935e-01f, 3.76869619e-01f, 3.84154350e-01f,
  -1.58610940e-01f, 3.43313992e-01f, 1.94487140e-01f, 2.82694787e-01f, 1.66358680e-01f, 3.06605041e-01f, 3.74192953e-01f, 3.00166726e-01f, -6.02794409e-01f, -1.77255273e-01f,
  -1.08881094e-01f, 1.47842597e-02f, 1.59970835e-01f, 7.20222220e-02f, 8.18049759e-02f, 9.82648581e-02f, -2.48954907e-01f, -1.06813414e-02f, -5.75469099e-02f, -1.67224705e-01f,
  2.26950943e-01f, -1.56446680e-01f, 9.83246788e-02f, -5.88802099e-02f, 7.87011981e-02f, -1.10022333e-02f, 1.08072743e-01f, -1.76291361e-01f, 2.36247763e-01f, 1.21105693e-01f,
  -3.28524038e-02f, -1.36594698e-01f, -5.90669475e-02f, 4.90840748e-02f, -3.47345844e-02f, 1.78130403e-01f, 1.18490256e-01f, 1.91344544e-01f, -1.14220493e-01f, 1.48849785e-01f,
  3.84339809e-01f, -2.43046321e-02f, 2.05336899e-01f, -8.80477056e-02f, -7.60874990e-03f, 5.37316725e-02f, 8.11109766e-02f, -1.99563831e-01f, 2.64409006e-01f, 4.69840690e-02f,
  9.21808183e-03f, 4.95569333e-02f, 1.75623875e-02f, 2.14104727e-01f, 1.30163759e-01f, -6.26215860e-02f, 5.80175184e-02f, 1.85639650e-01f, 1.40973240e-01f, 1.30892143e-01f,
  -1.69930652e-01f, 2.01128796e-01f, 2.10216790e-02f, 2.79196411e-01f, 2.03375980e-01f, 8.07537511e-02f, 1.72558594e-02f, -5.93981259e-02f, 1.91238180e-01f, 1.15240358e-01f,
  7.10997656e-02f, 1.56107083e-01f, -1.12863660e-01f, 1.93020970e-01f, 1.93648525e-02f, -1.11185342e-01f, -8.12104568e-02f, 5.38680218e-02f, 3.57721820e-02f, -1.03415839e-01f,
  -1.47331983e-01f, 5.46292439e-02f, 8.22270736e-02f, 9.56624895e-02f, 1.33141160e-01f, -8.23531002e-02f, 6.55732229e-02f, -6.36856630e-02f, 1.41167909e-01f, 3.33562523e-01f,
  6.47366121e-02f, -1.62110329e-01f, 1.28621146e-01f, -9.95294526e-02f, -4.87204850e-01f, 2.79761590e-02f, -1.10876098e-01f, 1.98494978e-02f, 3.68866674e-03f, -1.55668169e-01f,
  7.60927126e-02f, -1.37322266e-02f, -1.09723270e-01f, -6.53163493e-02f, 5.09848911e-03f, -8.46830010e-02f, 1.48528010e-01f, 1.41285267e-02f, 1.09580028e+00f, -6.66025728e-02f,
  -3.71591225e-02f, -1.06647111e-01f, -2.52450675e-01f, 4.00934257e-02f, 1.19731344e-01f, -1.38218448e-01f, 4.65458594e-02f, 9.88981221e-04f, 4.93898578e-02f, -1.05473578e-01f,
  7.82033727e-02f, 6.53427746e-03f, -1.09845459e-01f, 7.35647306e-02f, 3.37276235e-02f, 1.03695333e-01f, -2.76173162e-03f, -9.67421010e-02f, 9.30775329e-02f, 8.10268298e-02f,
  -1.50350705e-01f, 7.72622302e-02f, 6.52760863e-02f, -7.58016407e-02f, -1.83596388e-01f, 3.73036116e-02f, 9.98156052e-03f, 8.11589211e-02f, -4.30066139e-03f, -2.19117284e-01f,
  -7.72777721e-02f, -7.84947649e-02f, -6.43756688e-02f, -1.83298618e-01f, -2.97376305e-01f, 7.00087324e-02f, -1.44754976e-01f, -2.09679343e-02f, 1.99195221e-01f, 1.18785791e-01f,
  7.48443007e-02f, 7.44452477e-02f, 8.09390023e-02f, 2.43365377e-01f, 1.94107369e-02f, -1.65384486e-01f, 7.32045546e-02f, -2.73764525e-02f, 6.16438985e-02f, -6.46393374e-02f,
  -2.51951143e-02f, -1.60249755e-01f, 1.60343722e-02f, -2.36039422e-02f, 1.80856869e-01f, 2.56499331e-02f, -1.41952578e-02f, 2.82954752e-01f, -1.19961008e-01f, 4.66456488e-02f,
  -2.22294126e-02f, 5.01254797e-02f, 3.70563507e-01f, -3.84121686e-02f, 9.15611759e-02f, -4.37172838e-02f, -1.11025162e-01f, 2.35572323e-01f, -4.01320904e-02f, -2.02321738e-01f,
  1.09746516e-01f, -2.25507524e-02f, 1.13587029e-01f, 1.37381360e-01f, 2.08648741e-01f, 9.09514129e-02f, 8.78708810e-02f, 2.79997915e-01f, 1.70744911e-01f, -1.34047605e-02f,
  1.62375178e-02f, 9.63453427e-02f, -3.53910215e-02f, 7.67799690e-02f, -8.03010613e-02f, 2.14376319e-02f, -6.16863854e-02f, 2.00995266e-01f, 1.58615008e-01f, 7.21442848e-02f,
  -7.12495856e-03f, -1.24378920e-01f, 5.16825728e-02f, 1.56171262e-01f, -8.85520428e-02f, 1.37132049e-01f, 5.30786105e-02f, 1.91059604e-01f, -4.01413441e-02f, 7.73746520e-02f,
  3.28768864e-02f, 2.69663513e-01f, -3.50701451e-01f, -7.14116823e-03f, -1.19628549e-01f, 4.28291596e-02f, -1.29243303e-02f, 5.87420203e-02f, -5.31417131e-02f, 1.52429253e-01f,
  9.79885459e-02f, -1.84738830e-01f, 2.30099395e-01f, 1.34306485e-02f, 3.12309116e-01f, 1.95157379e-01f, 9.63801593e-02f, 4.26224209e-02f, 2.41081834e-01f, -1.01696305e-01f,
  5.25321811e-02f, 1.38014436e-01f, -2.98472106e-01f, 1.28532290e-01f, -3.00043840e-02f, 7.15057775e-02f, 6.23194128e-02f, 1.13308311e-01f, 2.66699731e-01f, 7.96748996e-02f,
  5.11936136e-02f, -2.15532016e-02f, -9.92405321e-03f, 6.91913590e-02f, -8.15335438e-02f, 3.31926811e-03f, -2.73251701e-02f, 8.06861222e-02f, -2.67715186e-01f, -3.47994007e-02f,
  1.61766261e-01f, 1.77646011e-01f, 1.56163424e-01f, -1.69902489e-01f, 2.14221120e-01f, 7.89633244e-02f, -1.06400840e-01f, -2.26400882e-01f, 1.62373513e-01f, -1.40320985e-02f,
  -2.65802830e-01f, 2.40543857e-01f, 4.04781885e-02f, -1.01508863e-01f, -7.75209516e-02f, 8.38453099e-02f, 1.91075355e-01f, 8.08476955e-02f, -4.07651775e-02f, -3.46407481e-02f,
  3.23043764e-02f, 5.66990823e-02f, 6.56052232e-02f, -1.01795875e-01f, 2.30335847e-01f, 8.41133520e-02f, -1.97242778e-02f, 7.48376921e-02f, 2.76255339e-01f, 7.98263475e-02f,
  1.68241814e-01f, 1.00267053e-01f, 6.16026372e-02f, 1.73735559e-01f, 6.49223179e-02f, 9.33675095e-02f, -9.58741605e-02f, 8.51354972e-02f, 1.81727082e-01f, -6.68493286e-02f,
  1.60827205e-01f, -1.59989938e-01f, 1.65881291e-02f, -8.25645328e-02f, 1.78971097e-01f, -1.19907156e-01f, -2.45090917e-01f, 2.16486737e-01f, -6.24839738e-02f, 3.31711620e-02f,
  -4.21463326e-02f, -1.11704711e-02f, 1.21270679e-01f, 2.49107331e-01f, -1.94866613e-01f, -4.62322794e-02f, -8.28790888e-02f, 7.82864466e-02f, -9.36733484e-02f, -3.55291255e-02f,
  1.83440566e-01f, 3.09740589e-03f, -1.55615211e-01f, -1.46873191e-03f, 1.27785638e-01f, -5.56401350e-02f, 1.04545720e-01f, -1.99213848e-01f, 8.45997557e-02f, -1.93427607e-01f,
  -5.62982373e-02f, -1.04667366e-01f, -1.46960989e-01f, 2.05316464e-03f, -7.69466758e-02f, -1.68869510e-01f, -1.34429917e-01f, 5.94577715e-02f, 2.86982600e-02f, 5.27061559e-02f,
  4.76057641e-02f, 1.73219323e-01f, 1.05787806e-01f, -5.27301878e-02f, 1.04184985e-01f, -2.38066483e-02f, 8.22844505e-02f, -7.98085853e-02f, 3.42690378e-01f, 2.89882272e-01f,
  -2.36940607e-01f, -7.48862401e-02f, 8.81879628e-02f, 7.39743114e-02f, 1.72791407e-01f, -1.18707900e-03f, 2.02246115e-01f, 3.32120180e-01f, -2.41427496e-02f, 4.77887280e-02f,
  1.28103837e-01f, 1.70305893e-01f, 3.38481516e-01f, 1.04251197e-02f, 3.50407735e-02f, -1.44467384e-01f, 7.45661706e-02f, 1.40509270e-02f, 2.54387796e-01f, -4.03866135e-02f,
  -3.72494727e-01f, 2.74622917e-01f, 7.99573660e-02f, 2.64753610e-01f, 5.29857539e-02f, -3.58958170e-02f, 2.44882628e-01f, 3.42092693e-01f, -1.24032393e-01f, -1.00282669e-01f,
  5.65378927e-02f, -1.29809463e-02f, 5.22906110e-02f, -6.00125827e-02f, 2.51294106e-01f, 9.05778408e-02f, -1.10885650e-01f, 1.47095427e-01f, 2.57861137e-01f, -9.37906653e-03f,
  -6.01317501e-04f, -1.34107415e-02f, 1.60686061e-01f, 3.49810496e-02f, -1.14491627e-01f, -3.11040692e-02f, 7.44913369e-02f, 1.12183332e-01f, -1.31385341e-01f, 1.12430073e-01f,
  -1.37768298e-01f, -6.83724880e-03f, 2.54271269e-01f, 1.43477857e-01f, -3.54947336e-02f, 2.67547578e-01f, -3.12600937e-03f, 1.07000517e-02f, 1.72662586e-01f, 3.21916156e-02f,
  -2.07006127e-01f, 8.54673013e-02f, 6.35672733e-02f, 7.41236359e-02f, -2.94923365e-01f, 9.99758914e-02f, 1.25985086e-01f, 2.67867744e-02f, -3.63690518e-02f, 2.36478001e-01f,
  2.56652951e-01f, 2.42700562e-01f, 1.74116790e-01f, 3.86698134e-02f, 2.25211218e-01f, 1.80862099e-01f, 1.24270253e-01f, 1.32932752e-01f, -1.81953102e-01f, -1.06103756e-02f,
  3.12071621e-01f, -9.61160138e-02f, 6.51061982e-02f, -1.99195966e-02f, -2.69315362e-01f, -8.16538930e-02f, 3.19634303e-02f, -6.51782937e-03f, 8.63432437e-02f, 1.16417378e-01f,
  1.92471713e-01f, 4.71471287e-02f, 1.30981982e-01f, -3.59684639e-02f, 7.71070793e-02f, -5.91016114e-02f, -1.03828222e-01f, 1.53843328e-01f, 7.51223266e-02f, 2.46635064e-01f,
  4.57528941e-02f, -9.50164720e-02f, 1.17522456e-01f, 2.30870530e-01f, -3.69190052e-02f, 3.79936741e-04f, -4.89755832e-02f, 6.77703992e-02f, 2.03875155e-04f, -7.21960664e-02f,
  8.44098777e-02f, -7.71783516e-02f, -5.62642515e-02f, 1.24134228e-01f, 2.41088003e-01f, 2.74399184e-02f, -1.75521284e-01f, 1.73596799e-01f, 1.18307270e-01f, -1.32183207e-03f,
  -5.14461324e-02f, 1.25361666e-01f, 1.51543394e-01f, -1.17347939e-02f, -7.40716010e-02f, 2.02651501e-01f, -9.12836269e-02f, -1.75376430e-01f, -1.71570808e-01f, 2.25400314e-01f,
  1.45832328e-02f, 3.71101201e-02f, -1.00240549e-02f, 7.64990076e-02f, 1.78822819e-02f, 2.38096222e-01f, 1.21179461e-01f, 2.17130572e-01f, 1.89327806e-01f, 1.46641135e-01f,
  -1.54027818e-02f, 3.16024795e-02f, -1.19392008e-01f, 8.68800655e-02f, 1.27558723e-01f, 1.02607377e-01f, -1.49752460e-02f, 1.96213782e-01f, -8.32556337e-02f, -1.39414622e-02f,
  -1.52153760e-01f, -9.67600644e-02f, -1.24647886e-01f, -8.83877277e-02f, 7.05141202e-02f, 8.97592977e-02f, 1.48418054e-01f, 2.19317406e-01f, -9.50424969e-02f, 8.07233006e-02f,
  -6.50807545e-02f, 5.53483106e-02f, -1.33407369e-01f, 1.10413797e-01f, -4.57377769e-02f, -1.10338040e-01f, 5.09165227e-02f, 2.25283146e-01f, -6.24773419e-03f, -6.72883391e-02f,
  2.17478007e-01f, 2.40146160e-01f, -2.65948847e-03f, 4.23934162e-02f, 2.18711391e-01f, 2.23036841e-01f, -1.03245482e-01f, 1.25114784e-01f, 1.32966399e-01f, -5.65704599e-04f,
  -7.06436038e-02f, -5.98041108e-03f, -1.21200107e-01f, -2.21362770e-01f, -1.25758991e-01f, 7.49508664e-02f, -5.06626926e-02f, -1.40075058e-01f, -4.22246642e-02f, 4.74691652e-02f,
  -2.28094637e-01f, 2.98869535e-02f, 1.43550441e-01f, -1.22606307e-02f, -1.36600100e-02f, 1.55691087e-01f, 6.84073269e-02f, 2.71338135e-01f, -1.23519450e-03f, -8.38068649e-02f,
  -9.50495303e-02f, 2.95129586e-02f, 4.71274853e-02f, -1.27015397e-01f, -1.36121497e-01f, 4.26441021e-02f, 4.76351008e-02f, 1.46243095e-01f, 1.60670206e-01f, -1.66855995e-02f,
  -4.74701673e-02f, 7.09805414e-02f, 3.50095719e-01f, -5.88206947e-02f, 3.19360234e-02f, 2.77517363e-02f, 3.53389889e-01f, 1.01145431e-01f, 1.37153685e-01f, -1.20708257e-01f,
  -1.36944294e-01f, 3.64172235e-02f, 6.17142133e-02f, -2.59959072e-01f, 1.67146638e-01f, -9.91643518e-02f, -8.65785182e-02f, -6.62910491e-02f, 1.48791373e-01f, 7.05913380e-02f,
  1.10512845e-01f, 1.68711245e-01f, 1.71590596e-01f, 1.60786197e-01f, 1.73601717e-01f, 1.79963455e-01f, 1.88075691e-01f, 2.06227437e-01f, -1.22147456e-01f, 1.53337225e-01f,
  -5.34077287e-02f, 1.78704411e-01f, -1.56645887e-02f, -5.08273311e-04f, 5.83500713e-02f, -1.46925092e-01f, 1.12305600e-02f, 1.55524030e-01f, 1.34355083e-01f, -5.41086532e-02f,
  4.85469438e-02f, 1.43324032e-01f, -6.92959875e-02f, -6.43406361e-02f, 2.34343216e-01f, 1.60303265e-01f, -1.96594968e-01f, 1.07912514e-02f, 9.65089574e-02f, 3.53029072e-02f,
  -5.56798056e-02f, -7.79454932e-02f, 1.44502565e-01f, 1.65466025e-01f, 1.62938908e-01f, 5.77445738e-02f, 8.86351094e-02f, 6.95964992e-02f, 9.72716510e-02f, 6.66836873e-02f,
  -1.72441646e-01f, -9.53809470e-02f, 2.41283968e-01f, 4.28217575e-02f, 2.67305560e-02f, -2.03909457e-01f, -1.71832085e-01f, 6.54905736e-02f, -3.66174169e-02f, 1.40273064e-01f,
  4.56087990e-03f, 8.33849907e-02f, -4.13170420e-02f, 2.07392812e-01f, 2.86237150e-02f, -4.34150174e-02f, 2.11919799e-01f, 1.93119481e-01f, 6.01601005e-02f, 1.54253572e-01f,
  5.70259169e-02f, -7.94306397e-02f, -5.18165380e-02f, 4.58690012e-03f, -7.79842809e-02f, 1.32004106e-02f, -5.53860143e-02f, 1.09369367e-01f, -1.03346884e-01f, -5.14610298e-02f,
  -1.02015302e-01f, -4.79566492e-02f, 7.31460154e-02f, 8.46887380e-02f, -5.20214811e-02f, -2.48088734e-03f, -5.94001152e-02f, -1.30301164e-02f, -7.23931491e-02f, 1.76161483e-01f,
  1.65800527e-01f, -8.09175000e-02f, 4.23890837e-02f, -9.65712368e-02f, -5.89792021e-02f, -6.35969862e-02f, 1.61588743e-01f, 2.69214571e-01f, -1.08682260e-01f, -2.75449246e-01f,
  1.31059930e-01f, 2.10706033e-02f, -8.43345895e-02f, 2.07938641e-01f, -2.12493867e-01f, -1.89877331e-01f, 1.81860402e-02f, 6.36755154e-02f, 1.30724430e-01f, 1.85529470e-01f,
  1.05530620e-01f, 4.83417585e-02f, -5.62765040e-02f, 7.39644691e-02f, 1.49093136e-01f, 2.70259142e-01f, 2.91225500e-03f, 1.44556373e-01f, -1.84904244e-02f, 1.97115228e-01f,
  2.18819737e-01f, 2.08276194e-02f, -7.20426515e-02f, -8.44113678e-02f, -1.70168608e-01f, 2.56524365e-02f, 1.24488071e-01f, 5.50865382e-03f, -6.36355132e-02f, 1.28593162e-01f,
  -1.18714990e-02f, -1.57834619e-01f, 1.16999552e-01f, 1.06295003e-02f, 5.13556488e-02f, -7.37428218e-02f, 2.30464116e-01f, 1.08356692e-01f, -3.56351286e-02f, 1.14630468e-01f,
  5.19601777e-02f, -7.41250664e-02f, 2.15484202e-01f, 1.88685805e-01f, 6.30719736e-02f, 9.34545398e-02f, 6.16743192e-02f, 2.55164444e-01f, -8.06014985e-02f, 1.77698269e-01f,
  2.56163925e-01f, 1.16868109e-01f, -1.58423543e-01f, -7.92680159e-02f, -4.36340533e-02f, 1.89828798e-01f, -1.25470906e-01f, 8.09578151e-02f, 8.37237686e-02f, 1.50399283e-01f,
  -7.65076727e-02f, -7.54008815e-02f, -2.67782897e-01f, -1.29239440e-01f, 2.50311848e-02f, 2.01438531e-01f, -9.17971805e-02f, 3.08016296e-02f, -1.35072991e-01f, -2.22947076e-01f,
  2.26705715e-01f, -5.37801646e-02f, 1.02563597e-01f, 6.25350401e-02f, 8.18860233e-02f, 1.12141706e-01f, -1.35946989e-01f, -5.29183866e-03f, -1.19328707e-01f, 6.39733449e-02f,
  1.80288479e-01f, 1.62453294e-01f, 1.61364645e-01f, 7.77834281e-02f, 3.07075590e-01f, -6.15623966e-02f, 2.29917523e-02f, -2.27516353e-01f, -9.87918079e-02f, 1.54049667e-02f,
  -7.24721104e-02f, 1.51782548e-02f, 1.58059105e-01f, 1.35405846e-02f, -1.12390727e-01f, -6.30999655e-02f, -9.91691872e-02f, 1.12158187e-01f, -2.36247450e-01f, 4.91555482e-02f,
  3.61889839e-01f, -1.57743152e-02f, -2.79101799e-03f, 1.28815591e-01f, -2.03247666e-01f, -1.19944721e-01f, 2.03622505e-01f, 2.60321259e-01f, -1.52691483e-01f, 1.52036041e-01f,
  2.44273946e-01f, 1.37923583e-01f, 8.32684636e-02f, -3.68321035e-03f, 3.08879107e-01f, 1.51313394e-01f, -3.02671313e-01f, -1.30535468e-01f, 1.53206959e-01f, 1.73559412e-01f,
  1.82533070e-01f, 2.22534999e-01f, -1.24926693e-04f, 1.15779400e-01f, 8.71086121e-02f, -5.88369630e-02f, 9.61279720e-02f, -1.59511551e-01f, 1.54415211e-02f, -2.45588627e-02f,
  -1.29165471e-01f, -1.49896536e-02f, -1.48420185e-01f, -7.41268024e-02f, 9.21682790e-02f, 7.74825141e-02f, 2.88081825e-01f, 2.33958051e-01f, 1.17044546e-01f, -4.59402129e-02f,
  -9.54384357e-02f, 1.39520541e-01f, 1.36495575e-01f, 1.78759515e-01f, 7.40421042e-02f, 3.68257910e-01f, 6.32920414e-02f, 2.22097803e-02f, 4.87640977e-01f, 2.00243294e-02f,
  2.15276599e-01f, 7.02827349e-02f, -7.28683546e-02f, -6.60827458e-02f, -8.02083239e-02f, -2.07796693e-02f, 3.30044597e-01f, 2.26485860e-02f, 1.60623729e-01f, 2.52301276e-01f,
  1.66223779e-01f, 2.39282116e-01f, 7.88098276e-02f, -2.42583036e-01f, 1.24966837e-01f, 9.98422876e-02f, 3.62933166e-02f, -2.48457566e-01f, 2.27402803e-02f, 1.22393213e-01f,
  -4.99488711e-02f, 7.56216496e-02f, 3.06686461e-01f, 1.31655678e-01f, 2.31902957e-01f, -7.80034298e-03f, 1.51572730e-02f, -2.52423704e-01f, 1.68706663e-02f, 2.51028270e-01f,
  6.28056601e-02f, 1.44779518e-01f, 7.47450516e-02f, -1.90933608e-02f, -7.30035007e-02f, 3.41084786e-02f, 1.06755368e-01f, 2.17861794e-02f, -2.48830587e-01f, 5.36101721e-02f,
  -2.39151642e-01f, -2.29657009e-01f, -5.19314827e-03f, -9.86017846e-03f, -1.10845558e-01f, -5.64734377e-02f, -1.06772460e-01f, 8.73341039e-02f, 3.16827834e-01f, -1.26217172e-01f,
  1.73010916e-01f, 1.83390573e-01f, 1.23451583e-01f, 6.01995364e-03f, -4.52254191e-02f, -1.08063594e-01f, -1.41465321e-01f, 1.16481930e-01f, 1.83287680e-01f, 1.40698090e-01f,
  -1.48958474e-01f, -4.19811495e-02f, 1.01409949e-01f, -2.65669096e-02f, 7.25412145e-02f, -9.45363864e-02f, -7.09646419e-02f, 5.17318435e-02f, 1.36691451e-01f, -1.04162484e-01f,
  2.18262330e-01f, 2.08668455e-01f, 1.01541117e-01f, -8.74940604e-02f, 1.61572341e-02f, 2.35663995e-01f, -4.85970313e-03f, -8.10293853e-02f, 1.78844854e-01f, 1.14527866e-01f,
  4.26640026e-02f, 6.89036474e-02f, -1.35348111e-01f, 1.33014172e-01f, 1.52529910e-01f, 6.19851612e-02f, 4.78608273e-02f, 2.37881646e-01f, 1.72428980e-01f, 3.50588337e-02f,
  5.04022911e-02f, 1.79074496e-01f, 1.74684618e-02f, 1.95458472e-01f, -1.92830339e-01f, -6.30761236e-02f, 1.56098112e-01f, 2.59077907e-01f, 6.76527768e-02f, 1.05725899e-01f,
  1.01571262e-01f, 1.66989237e-01f, 8.41477811e-02f, 1.89168036e-01f, 2.36639202e-01f, 1.14216782e-01f, -3.96065354e-01f, -2.02353746e-02f, 1.56344324e-01f, 1.16393164e-01f,
  -1.80483442e-02f, -1.17843494e-01f, -1.66963428e-01f, 2.10012838e-01f, -1.05240770e-01f, 4.40137908e-02f, -3.98182645e-02f, 1.05612978e-01f, -3.42944004e-02f, 1.55453354e-01f,
  2.47108787e-02f, 9.50792953e-02f, 7.02668428e-02f, -1.01908170e-01f, 1.51825190e-01f, 9.74051282e-02f, 2.97661364e-01f, 9.13632512e-02f, -1.15477145e-01f, 9.03596506e-02f,
  -3.03764611e-01f, -9.40952748e-02f, 3.93499210e-02f, -4.82784547e-02f, 3.33607674e-01f, -2.48108264e-02f, -8.68141726e-02f, 2.17268959e-01f, 1.53814703e-01f, 6.33438758e-04f,
  -2.12086737e-01f, 1.61874279e-01f, 9.98909026e-03f, -1.85603157e-01f, 6.59004599e-02f, 1.15280069e-01f, 1.03661172e-01f, 8.93512666e-02f, -1.37022033e-01f, 3.06610707e-02f,
  9.17187259e-02f, -7.32403100e-02f, 1.18756197e-01f, 1.52729318e-01f, 4.17987294e-02f, -9.99829620e-02f, -7.26090802e-05f, 1.09604843e-01f, -1.46725178e-02f, 5.45242019e-02f,
  1.49831891e-01f, 1.73617199e-01f, 5.75164519e-02f, -1.32328970e-02f, 5.38070053e-02f, 1.05642863e-01f, 9.76822451e-02f, 2.78574884e-01f, -6.19455390e-02f, -1.34338602e-01f,
  -1.53701663e-01f, 2.78082453e-02f, -5.26737459e-02f, 2.17726380e-01f, -1.91741794e-01f, 5.12724482e-02f, 2.13862583e-01f, 2.02219844e-01f, -1.68108232e-02f, 1.52737632e-01f,
  1.44784108e-01f, -1.19232491e-01f, 6.23713881e-02f, 9.83536690e-02f, -1.33681610e-01f, 2.06286639e-01f, 1.27080217e-01f, 1.28873408e-01f, -5.38730621e-02f, 4.51502874e-02f,
  1.40244186e-01f, 5.05491979e-02f, -9.96260047e-02f, -3.81053425e-02f, -6.51229173e-02f, -1.04988694e-01f, 1.33482277e-01f, -1.69558421e-01f, 8.09358880e-02f, 8.62238333e-02f,
  2.19206046e-02f, 8.43667611e-02f, -1.37126923e-01f, -6.20911382e-02f, -5.04266322e-02f, 8.04569200e-02f, 2.04285551e-02f, -3.51069868e-02f, 5.35612516e-02f, 2.43983060e-01f,
  9.26790088e-02f, -2.71591954e-02f, 1.54702947e-01f, 4.77549508e-02f, 1.16278101e-02f, 1.68639004e-01f, 3.38614024e-02f, 2.33532622e-01f, 1.20818548e-01f, 6.68168440e-02f,
  3.07364017e-01f, 1.20943256e-01f, -7.68319443e-02f, -2.39148866e-02f, -3.93486358e-02f, 1.36762843e-01f, 7.39127919e-02f, 1.01861805e-01f, 1.63056508e-01f, 5.23532704e-02f,
  -1.37281448e-01f, -1.68593943e-01f, -9.63832289e-02f, 6.04855157e-02f, -1.80679876e-02f, -2.52718687e-01f, 7.50544900e-03f, -1.04923472e-02f, 1.41629204e-01f, 1.43267795e-01f,
  -1.85800016e-01f, -5.02148867e-02f, 7.66208619e-02f, 4.33401763e-02f, -1.84855163e-01f, -6.95668757e-02f, 2.20342815e-01f, 1.38051882e-01f, 1.82154521e-01f, 9.40637887e-02f,
  1.42630516e-03f, 1.38370935e-02f, 1.13508895e-01f, 1.98086932e-01f, 8.46268609e-02f, 2.50714511e-01f, 1.37033001e-01f, 2.40390733e-01f, 2.70647496e-01f, -3.49774845e-02f,
  6.05485626e-02f, 7.31894746e-02f, 6.43680617e-02f, 1.09106533e-01f, 4.50259447e-02f, 8.27128366e-02f, 2.02224702e-02f, 1.49706185e-01f, 3.15640539e-01f, -6.29045591e-02f,
  2.43841726e-02f, 1.49061874e-01f, 1.96943823e-02f, -6.08251616e-02f, 2.02902779e-01f, 5.90978377e-02f, -1.80481952e-02f, -5.51712699e-02f, 1.38646781e-01f, -4.91279177e-02f,
  -1.12951100e-01f, 7.59024173e-02f, 8.64616334e-02f, -1.11748159e-01f, -2.38882646e-01f, -9.34005603e-02f, 2.20848769e-01f, 1.07649893e-01f, -1.03636473e-01f, -1.18749917e-01f,
  -1.28282949e-01f, -1.34939447e-01f, -1.30465394e-02f, 3.59351635e-02f, -5.97795136e-02f, 8.56545120e-02f, -8.95955935e-02f, 5.14512733e-02f, -4.21879664e-02f, -5.13854772e-02f,
  4.76136841e-02f, -4.34498191e-02f, 5.27854115e-02f, -1.00952178e-01f, 5.92009015e-02f, -4.66950834e-02f, -1.32687679e-02f, -6.57339469e-02f, 6.99418113e-02f, 1.76265519e-02f,
  7.97253661e-03f, -1.35440886e-01f, -2.82878913e-02f, 5.02164215e-02f, -8.87020454e-02f, -7.85050541e-02f, -6.19079024e-02f, 1.54392356e-02f, -2.15143133e-02f, -9.81648266e-02f,
  -1.11657478e-01f, 1.00354083e-01f, 8.35795850e-02f, -6.05193675e-02f, 4.17141132e-02f, -7.19663277e-02f, -6.06195331e-02f, -1.20556980e-01f, 1.76196992e-02f, -1.10625960e-01f,
  -2.08580978e-02f, -2.96901707e-02f, 1.91834532e-02f, -4.52453643e-02f, 6.19727944e-04f, -7.68355131e-02f, 4.60439511e-02f, -7.98265561e-02f, -5.29183932e-02f, -1.09473400e-01f,
  3.36512066e-02f, -6.22319281e-02f, 1.08199134e-01f, -5.08525707e-02f, 6.39967397e-02f, -1.17614888e-01f, -9.61102843e-02f, -1.29719991e-02f, 7.61834234e-02f, 7.33241960e-02f,
  -6.93989247e-02f, 2.57299077e-02f, 8.60051587e-02f, 3.76001038e-02f, -9.40151699e-03f, 1.09450735e-01f, 3.96344141e-04f, 6.13773614e-02f, -7.75793195e-02f, -7.17660710e-02f,
  1.52415603e-01f, 3.01217198e-01f, -2.75856614e-01f, 2.55205873e-02f, -2.73336917e-02f, 1.01826571e-01f, 1.33782119e-01f, 2.52903789e-01f, -1.68294430e-01f, 1.66922465e-01f,
  -9.41952914e-02f, -1.48213003e-02f, -3.18306535e-02f, 3.56979184e-02f, 1.31900907e-01f, 2.45719124e-02f, 2.00257540e-01f, 5.90990996e-04f, 9.66068134e-02f, -2.98205074e-02f,
  1.26091205e-03f, 1.99808866e-01f, -2.57693350e-01f, 1.84903026e-01f, 9.96876284e-02f, 2.51879394e-01f, 2.30617166e-01f, 5.07845543e-03f, 1.54930338e-01f, 2.02796131e-01f,
  -1.88716561e-01f, -4.39484231e-02f, 1.26470372e-01f, -9.29411128e-02f, 2.13616490e-01f, -1.24026410e-01f, 1.22061640e-01f, 2.46455923e-01f, -1.28537655e-01f, -3.62747349e-02f,
  1.62788123e-01f, 1.60009474e-01f, 1.17089786e-01f, 5.10017201e-03f, 4.54903618e-02f, 5.74630052e-02f, 4.22537923e-02f, -3.89698260e-02f, 6.38335720e-02f, -4.68151607e-02f,
  -1.19817154e-02f, 1.41533583e-01f, -4.60659824e-02f, -1.14891455e-01f, 2.14245543e-01f, 5.55886142e-02f, -8.48013759e-02f, -1.71011269e-01f, 2.17814911e-02f, -9.92812142e-02f,
  -9.12503600e-02f, 5.67889214e-02f, -1.99740186e-01f, 1.72387227e-01f, -1.52119547e-01f, -1.72361255e-01f, 1.23932339e-01f, -1.24582360e-02f, -8.74847099e-02f, 6.42064363e-02f,
  -1.30278189e-02f, -1.99155472e-02f, 1.65554687e-01f, 4.15639952e-02f, 6.95278868e-02f, 1.48254618e-01f, 1.91398278e-01f, 8.51249471e-02f, 9.99746695e-02f, -4.18411158e-02f,
  -1.85256526e-01f, 1.09363146e-01f, 1.32686257e-01f, 7.15539698e-03f, -2.11576909e-01f, 1.92798138e-01f, -1.88076809e-01f, 1.02185950e-01f, -1.00143291e-01f, -2.36024652e-02f,
  7.93567374e-02f, 1.11269742e-01f, 1.31893635e-01f, -9.31645632e-02f, 9.46365669e-02f, 1.07686847e-01f, 2.32014693e-02f, 1.07972845e-02f, -1.32761642e-01f, 3.43176126e-02f,
  -1.61548883e-01f, 6.20420203e-02f, -9.31996293e-03f, 1.12508712e-02f, 2.10306227e-01f, 4.48651016e-02f, -1.03054401e-02f, -1.02555133e-01f, 5.59133105e-02f, 1.80868998e-01f,
  -3.45769431e-03f, -1.54778152e-03f, -3.30176614e-02f, 1.85861409e-01f, -4.92424630e-02f, 2.23076686e-01f, 7.18025789e-02f, 5.32268099e-02f, -1.02928482e-01f, -6.19810261e-02f,
  1.93293154e-01f, -3.31037156e-02f, 2.37191722e-01f, 1.41652167e-01f, 1.09952327e-03f, 1.93587393e-01f, -8.48436356e-03f, -2.16761410e-01f, 7.57570118e-02f, 7.49907419e-02f,
  -1.98341176e-01f, -4.15344490e-03f, 4.98259142e-02f, -1.13136023e-01f, -5.84354438e-03f, 1.56971246e-01f, -1.26997441e-01f, 5.46928719e-02f, 6.68261200e-02f, 3.06007043e-02f,
  -2.42035817e-02f, 1.94916651e-01f, 7.13033378e-02f, 1.91792309e-01f, 8.86126235e-02f, 2.20410172e-02f, 1.67866722e-01f, 1.23738147e-01f, -1.30020589e-01f, -6.75641224e-02f,
  1.38941631e-01f, 6.68291608e-03f, 1.99551672e-01f, 2.02161059e-01f, 1.71878317e-03f, 5.27224466e-02f, -6.93022907e-02f, 1.49753526e-01f, 1.23779282e-01f, -3.70289721e-02f,
  2.25287154e-01f, 1.29042909e-01f, 1.58520728e-01f, 2.66949445e-01f, 1.69140413e-01f, -1.64454486e-02f, 4.78451848e-02f, 9.46187451e-02f, -1.04719112e-02f, -1.21078148e-01f,
  -2.20841146e-03f, 1.08192310e-01f, 1.22436229e-03f, 7.49958679e-03f, -1.76666118e-02f, 2.95600072e-02f, -3.72674577e-02f, -1.73725203e-01f, -3.58923562e-02f, -4.70517389e-02f,
  -1.39325410e-01f, 1.18555255e-01f, 1.39162675e-01f, 1.67907804e-01f, 1.59984887e-01f, -8.10201764e-02f, -2.11013444e-02f, -9.73763352e-04f, -5.60685396e-02f, 4.78881150e-02f,
  1.58752501e-01f, 1.25034809e-01f, 1.03293389e-01f, 2.63590980e-02f, 2.01835543e-01f, -6.18963595e-03f, -2.67541468e-01f, 1.51023552e-01f, -1.67010367e-01f, -2.72706181e-01f,
  2.32559949e-01f, 1.37871476e-02f, 1.96136609e-01f, 9.00472626e-02f, 1.84827805e-01f, 1.19108871e-01f, 2.15361819e-01f, -7.80349150e-02f, 1.55775845e-01f, -1.36761352e-01f,
  1.75982434e-02f, 6.08915053e-02f, 2.72229344e-01f, 4.16906029e-02f, -3.03616613e-01f, 9.37253311e-02f, -1.21451830e-02f, 6.46230429e-02f, -2.13933319e-01f, 2.24759057e-02f,
  8.30624029e-02f, 1.50011152e-01f, -5.64818606e-02f, -6.11354783e-03f, 5.55975437e-02f, -1.63782328e-01f, 3.39494757e-02f, -3.10985018e-02f, 4.28992882e-02f, -2.71566492e-02f,
  1.24072261e-01f, 2.43741229e-01f, 7.73670599e-02f, 7.61015294e-03f, 3.82905640e-03f, -2.49228761e-01f, 2.60556996e-01f, 2.07782030e-01f, 1.18296973e-01f, 6.92852139e-02f,
  1.80743828e-01f, 9.58817005e-02f, -2.17755824e-01f, 2.27357224e-01f, 9.71252173e-02f, 1.29212961e-01f, -1.09769955e-01f, 5.02264965e-03f, -1.87907778e-02f, -9.66561399e-03f,
  6.30812794e-02f, 2.09793504e-02f, -9.30832252e-02f, 1.03680678e-01f, 1.46673933e-01f, 3.19314688e-01f, -1.98976606e-01f, -3.12548816e-01f, 2.98176765e-01f, 4.53115031e-02f,
  6.12887181e-02f, 2.25941241e-01f, 5.72398007e-02f, -1.86008915e-01f, 9.10141990e-02f, -9.52839851e-02f, 2.53059790e-02f, 5.75111136e-02f, 5.72521091e-02f, 3.17305885e-02f,
  -1.59633040e-01f, -6.01981319e-02f, 6.26131073e-02f, 2.17338383e-01f, 5.23470864e-02f, -4.82208543e-02f, -7.01688975e-02f, 1.48384184e-01f, 4.13758993e-01f, 7.25172237e-02f,
  7.58787198e-03f, 1.73301194e-02f, -1.21981129e-01f, 4.38857786e-02f, 1.34124219e-01f, -2.05686428e-02f, -5.87852038e-02f, 1.65276408e-01f, -2.04655528e-01f, 7.79554248e-02f,
  -2.24788189e-02f, -1.52494013e-01f, -1.65884122e-01f, -2.57152002e-02f, 2.20513761e-01f, -1.16867833e-02f, -1.24010285e-02f, 9.94165614e-02f, 1.50305517e-02f, 1.52863730e-02f,
  1.50305659e-01f, 2.18684018e-01f, -3.64932790e-03f, 2.66278889e-02f, 1.05913609e-01f, 1.62597448e-01f, 6.63219541e-02f, 8.63012001e-02f, 1.21924534e-01f, 1.77270859e-01f,
  1.70809031e-01f, -7.93617666e-02f, 1.57003313e-01f, 1.91124603e-02f, 6.68255389e-02f, 1.01896122e-01f, -1.28357252e-02f, 7.98139647e-02f, 2.73204982e-01f, -1.32828489e-01f,
  2.49526799e-01f, 3.09746981e-01f, -2.18923371e-02f, -3.67339961e-02f, 1.69667616e-01f, 1.05250835e-01f, 8.02416131e-02f, -1.31295487e-01f, 2.29521215e-01f, 2.26267383e-01f,
  8.95639285e-02f, -6.67507797e-02f, 1.35251939e-01f, 1.44318417e-01f, 1.70533121e-01f, -7.67826587e-02f, -6.11983277e-02f, -2.11139098e-01f, -1.02915287e-01f, -7.96940550e-02f,
  2.72179544e-01f, 8.11136365e-02f, -1.31104052e-01f, 2.12092385e-01f, -2.32899264e-01f, 2.20351115e-01f, -2.16751739e-01f, 8.82794708e-02f, 1.04413830e-01f, 2.29902804e-01f,
  -1.96233317e-01f, -3.03161591e-02f, -6.64470196e-02f, 1.26349002e-01f, 2.92898137e-02f, 6.35773391e-02f, -3.57411169e-02f, 9.14110057e-03f, -4.86332960e-02f, 1.21730998e-01f,
  1.24419324e-01f, 3.55089121e-02f, 5.74665740e-02f, -2.31443733e-01f, 1.50399446e-01f, -1.61049455e-01f, -1.70622304e-01f, -5.47731742e-02f, 1.80805609e-01f, 2.54726410e-01f,
  -6.27162829e-02f, 1.18389800e-01f, 1.12994164e-02f, -1.30538478e-01f, 1.45086512e-01f, -1.05820306e-01f, 2.82610059e-01f, 1.20431624e-01f, 1.75817348e-02f, 1.22312471e-01f,
  1.68614373e-01f, 3.11142445e-01f, 4.14622016e-02f, -1.20651936e-02f, 3.06038618e-01f, 2.72512436e-01f, -2.80271202e-01f, -5.01837619e-02f, 8.66263434e-02f, -6.06413372e-02f,
  -7.88695142e-02f, 7.27653801e-02f, 1.04016654e-01f, 1.94177732e-01f, 1.82045817e-01f, 4.13836539e-02f, 1.37345701e-01f, 1.61025271e-01f, -4.95713763e-02f, 2.44331896e-01f,
  -1.59591511e-01f, 4.26359661e-02f, 7.42218718e-02f, 1.81056023e-01f, 2.36070558e-01f, -1.90295860e-01f, 1.02858976e-01f, -7.19235167e-02f, 2.38624518e-03f, 8.33243877e-03f,
  -1.26230851e-01f, -4.68935408e-02f, 6.86835721e-02f, 1.51021957e-01f, 1.33923873e-01f, -3.45349424e-02f, 1.25685006e-01f, 2.15913251e-01f, 3.67435664e-02f, 3.45267355e-02f,
  5.50831147e-02f, -5.08791506e-02f, 2.99064349e-02f, -1.27919406e-01f, 4.92676198e-02f, -9.80355963e-02f, 2.06015445e-02f, 4.72730063e-02f, -5.71980998e-02f, -1.10580452e-01f,
  -1.38261005e-01f, -3.32079455e-02f, 8.43330026e-02f, -5.37029356e-02f, 1.48896769e-01f, 4.79806587e-02f, -7.49438033e-02f, 1.13942772e-01f, 3.49416696e-02f, 2.70384047e-02f,
  -2.86726486e-02f, -1.49839595e-02f, -4.84213494e-02f, 2.19861314e-01f, 4.60972153e-02f, 1.28764167e-01f, -1.70019090e-01f, -9.81353596e-02f, -3.48662555e-01f, -2.18895242e-01f,
  1.98269039e-02f, 4.03762460e-02f, 2.32803211e-01f, -6.41418397e-02f, 1.14757694e-01f, 4.15356308e-02f, -2.94084777e-03f, -1.37771398e-01f, 1.17784306e-01f, 7.40540624e-02f,
  -1.32616907e-01f, 2.64365133e-02f, -1.15845531e-01f, -3.30180600e-02f, 7.71278590e-02f, 1.72017157e-01f, 5.98693453e-02f, 1.41087338e-01f, -2.47876629e-01f, 2.39597782e-02f,
  5.53360701e-01f, 1.82266142e-02f, 2.25698143e-01f, 1.04774199e-02f, 2.53611982e-01f, 7.48017654e-02f, 9.04103145e-02f, -1.71659335e-01f, 4.12251055e-02f, 2.20700845e-01f,
  -2.28721350e-02f, 1.33566847e-02f, 4.50437143e-02f, 1.28149748e-01f, -6.20779060e-02f, -1.68603972e-01f, 2.12549642e-01f, -3.99071351e-02f, 8.28521624e-02f, 8.94969553e-02f,
  -3.38984653e-02f, 2.37642437e-01f, -4.33964990e-02f, 2.69156158e-01f, 2.07785621e-01f, 2.06684321e-01f, 3.71745378e-02f, -1.50006975e-03f, 2.93273777e-01f, 4.36936319e-02f,
  8.13975260e-02f, 1.06265068e-01f, -2.91800182e-02f, 3.58626172e-02f, 1.10649869e-01f, 1.02176175e-01f, 2.00801224e-01f, 2.15584621e-01f, 1.18473312e-02f, 1.60658494e-01f,
  -2.32231654e-02f, 2.29155600e-01f, 2.81896114e-01f, 4.78053205e-02f, -1.28549427e-01f, -1.13256685e-02f, -1.51373655e-01f, 3.20848748e-02f, -1.75315347e-02f, -1.98194191e-01f,
  -1.68543644e-02f, 5.85544407e-02f, 1.69585600e-01f, 1.51741564e-01f, 1.97973460e-01f, 1.46245763e-01f, 2.94504136e-01f, 1.48111820e-01f, 2.13627622e-01f, 1.35408297e-01f,
  5.42629473e-02f, 3.44059393e-02f, 2.79088914e-01f, 1.83339477e-01f, 8.52077454e-02f, 8.13400652e-03f, 4.06643488e-02f, 1.76597714e-01f, -1.92475095e-01f, 1.74759366e-02f,
  1.73990309e-01f, 6.15958162e-02f, 2.79669017e-01f, 1.36166781e-01f, 1.60980493e-01f, 2.20885444e-02f, 2.47534305e-01f, 2.53935140e-02f, 3.32069546e-02f, 1.94791839e-01f,
  -1.60105657e-02f, 2.61617750e-01f, -3.87794971e-02f, -5.20917550e-02f, -4.44502831e-02f, 1.09668568e-01f, 1.37307227e-01f, 1.46870002e-01f, 2.65300006e-01f, -2.50282418e-02f,
  2.95924425e-01f, 2.82901287e-01f, -1.53081864e-01f, -1.79196317e-02f, 3.88697870e-02f, 1.24912255e-01f, -2.34402381e-02f, 8.73284191e-02f, 2.15187997e-01f, 4.46487926e-02f,
  -8.56371969e-02f, 5.70856109e-02f, 1.26936883e-01f, 1.30090863e-01f, 1.17870279e-01f, 1.61254674e-01f, -7.82076716e-02f, -2.29471266e-01f, 1.23513341e-01f, 2.29225501e-01f,
  -1.14254773e-01f, 1.53989375e-01f, -6.03788197e-02f, -1.47315010e-01f, -4.19536084e-02f, 1.22769207e-01f, 9.01592374e-02f, 6.69981167e-02f, -1.50035862e-02f, 7.41936266e-02f,
  -1.43000975e-01f, 5.97952865e-02f, -4.02785018e-02f, 3.11790258e-01f, -7.56424963e-02f, 1.54820174e-01f, -9.56785828e-02f, 2.25041155e-02f, 3.76069397e-01f, -6.60981685e-02f,
  -1.40397057e-01f, -1.13091074e-01f, -1.25534087e-01f, -8.21824968e-02f, 4.15174067e-02f, -4.62925285e-02f, 1.32242337e-01f, 2.60704309e-01f, -5.98843470e-02f, 1.05447620e-01f,
  6.61190152e-02f, -1.25836372e-01f, -2.05590978e-01f, 1.73239976e-01f, 4.39889133e-02f, -3.09441928e-02f, -2.59498600e-02f, 2.69297212e-01f, 7.09980875e-02f, -7.75957182e-02f,
  2.36081377e-01f, 1.88126147e-01f, -1.25880959e-02f, 1.54621542e-01f, -1.01616802e-02f, 1.88835591e-01f, 1.93209559e-01f, 1.37646571e-01f, 2.89582103e-01f, 1.88224301e-01f,
  -7.04991147e-02f, -1.68629140e-01f, 6.62455633e-02f, 1.03009425e-01f, 6.41088337e-02f, 3.88432927e-02f, 4.53218371e-02f, 5.58806509e-02f, 1.08963996e-01f, 3.25114340e-01f,
  1.01215549e-01f, 8.09155405e-02f, -2.09974721e-01f, -1.15107179e-01f, 7.58530870e-02f, 1.49552718e-01f, 9.66365263e-02f, 1.59320086e-01f, -1.61530003e-01f, 3.05976737e-02f,
  -8.52407329e-03f, -3.93297477e-03f, -8.07143301e-02f, -7.52169341e-02f, 2.35105887e-01f, 7.35208839e-02f, 1.90105662e-01f, 1.38593361e-01f, 2.29071267e-02f, -1.67953432e-01f,
  -1.96197014e-02f, 2.15330690e-01f, -3.50276828e-02f, 8.50048587e-02f, -3.82337086e-02f, 2.48057440e-01f, 1.79877207e-01f, 5.79867251e-02f, 3.94165479e-02f, 9.59529877e-02f,
  -1.69137344e-01f, 2.86533069e-02f, -7.79376701e-02f, 8.15984532e-02f, 7.65218139e-02f, -1.42613828e-01f, 3.54156718e-02f, 2.86577165e-01f, -2.29943812e-01f, 6.63624257e-02f,
  5.12435362e-02f, 1.59198746e-01f, 1.23122677e-01f, -1.41914979e-01f, 5.76614328e-02f, -1.27142474e-01f, 1.78733706e-01f, -1.28532812e-01f, -8.00563861e-03f, 1.02170847e-01f,
  -1.79329842e-01f, 9.22956541e-02f, 1.08596399e-01f, -1.79833978e-01f, 1.67812601e-01f, -1.16601422e-01f, 5.51067181e-02f, 5.25376275e-02f, -1.16208550e-02f, -6.96416572e-02f,
  6.42071804e-03f, -1.93949938e-02f, 6.61461651e-02f, -1.90689147e-01f, 3.78541291e-01f, 3.24333131e-01f, -7.14801177e-02f, -1.89893514e-01f, -4.66965735e-02f, -2.39276588e-02f,
  1.94310457e-01f, 1.39028817e-01f, 1.09293088e-01f, 2.54676580e-01f, -1.45392877e-03f, -1.49525702e-01f, 7.69166946e-02f, 2.21333534e-01f, 2.33217761e-01f, 1.54604286e-01f,
  1.27198160e-01f, -2.10714132e-01f, 2.81516686e-02f, 5.95146865e-02f, 2.64316142e-01f, 7.70318210e-02f, -3.65465581e-01f, 1.43670887e-01f, 1.04624756e-01f, 2.15973735e-01f,
  2.23356724e-01f, -1.03671648e-01f, 1.67211041e-01f, 1.74432382e-01f, -1.29384384e-01f, -1.64468572e-01f, 1.49584845e-01f, -5.17397299e-02f, 1.41629398e-01f, 1.31440267e-01f,
  2.43953615e-01f, 8.07459354e-02f, -1.10619299e-01f, -8.52905773e-03f, -6.35119602e-02f, 9.10253897e-02f, 9.52489004e-02f, -4.78112698e-02f, 8.85995477e-03f, -1.13066927e-01f,
  -7.98587280e-04f, -1.17680386e-01f, 1.09442510e-01f, 1.06918350e-01f, -7.84777850e-02f, 9.27614868e-02f, -9.17439386e-02f, -8.63913354e-03f, 1.00826338e-01f, -1.98993832e-02f,
  -1.32425306e-02f, 1.98217139e-01f, 8.10866132e-02f, -3.99627425e-02f, 1.04280345e-01f, 3.97634469e-02f, -8.52183849e-02f, -2.15771735e-01f, 2.63923645e-01f, 3.26616824e-01f,
  -1.37416795e-01f, -1.41280830e-01f, -1.53308474e-02f, -2.65663881e-02f, 2.54194979e-02f, 1.42468929e-01f, 1.85849756e-01f, 8.54098648e-02f, 1.26394674e-01f, -1.34564102e-01f,
  3.02906066e-01f, 1.02462113e-01f, 3.00318956e-01f, 1.22343772e-03f, -5.02948016e-02f, -2.40059048e-01f, 1.11273557e-01f, -4.37472435e-03f, 2.14037582e-01f, 5.75010777e-02f,
  -4.32353020e-01f, 9.71097574e-02f, 1.16601668e-01f, 1.18231557e-01f, 4.99066478e-03f, 1.86427089e-03f, 1.79112732e-01f, 8.93018097e-02f, -1.30788758e-01f, -4.63561621e-03f,
  1.63598865e-01f, 3.56712267e-02f, -9.04839858e-03f, 6.63615465e-02f, 1.14981405e-01f, 8.51431340e-02f, -9.00687203e-02f, 9.50565711e-02f, -2.05154996e-02f, 7.11119547e-02f,
  -1.90839488e-02f, -1.40114889e-01f, 1.75466724e-02f, -9.79283527e-02f, -1.84636787e-01f, -1.40765503e-01f, 3.44199315e-02f, 2.16061082e-02f, -2.41598234e-01f, 6.92989491e-03f,
  5.71754202e-02f, 8.11907351e-02f, 6.28823712e-02f, -1.69891515e-03f, -1.73362102e-02f, 3.77363563e-02f, 8.71461853e-02f, -2.74671391e-02f, 1.14666440e-01f, -3.74372825e-02f,
  -2.40802705e-01f, -2.62537628e-01f, 5.38122132e-02f, -5.73618896e-02f, 2.37974644e-01f, -2.33755544e-01f, -1.74717128e-01f, 1.44047029e-02f, 1.95586279e-01f, -1.93978343e-02f,
  5.52129559e-02f, -6.33291304e-02f, 2.42913201e-01f, 1.43934831e-01f, -2.17025424e-03f, 6.80170283e-02f, 1.39352009e-01f, 7.88936689e-02f, 2.15899665e-03f, -3.68484668e-02f,
  1.00740597e-01f, 2.26526469e-01f, -2.65854448e-02f, -3.71179692e-02f, -9.73166078e-02f, 1.89624682e-01f, 2.35775813e-01f, -5.66067100e-02f, 1.08448610e-01f, -9.72810686e-02f,
  -7.42767751e-02f, 5.22529893e-02f, 1.76039308e-01f, -1.27795739e-02f, 2.03102797e-01f, -1.06428757e-01f, 1.11183107e-01f, 7.41724223e-02f, 2.03893960e-01f, -1.98124573e-01f,
  3.75691392e-02f, 2.17913389e-01f, 2.00818196e-01f, -1.96726978e-01f, 1.02888912e-01f, 2.06476495e-01f, -5.39036132e-02f, 1.45653099e-01f, 1.48782611e-01f, 2.04569817e-01f,
  1.02854066e-01f, 9.43529233e-02f, 9.03035775e-02f, -1.46625498e-02f, -1.89680248e-01f, 1.70247272e-01f, 1.14068247e-01f, 5.29475994e-02f
};

// L2_fan_Bp_bar (Shape: 1 x 52)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 52;
const float L2_fan_Bp_bar_data[] = {
  -2.65091490e-02f, -3.15716639e-02f, 9.97813269e-02f, 1.86149448e-01f, 2.20302045e-01f, 1.74908623e-01f, 8.75914693e-02f, 6.04857281e-02f, 4.85896505e-02f, -2.61196010e-02f,
  5.78140728e-02f, 8.92468616e-02f, -1.19048782e-01f, -1.21475451e-01f, -3.68007869e-02f, 1.46175355e-01f, -7.32619166e-02f, -7.67828822e-02f, 1.56803727e-02f, 9.90208089e-02f,
  3.13914493e-02f, 7.80811980e-02f, -6.62688538e-02f, 2.89119259e-02f, 1.84199773e-02f, 3.33533734e-02f, 8.08213279e-02f, 7.79668093e-02f, -4.93265688e-02f, 4.91818152e-02f,
  -8.23661871e-03f, 1.51647285e-01f, 1.91221759e-01f, 1.25899687e-01f, 2.16956317e-01f, 1.04885064e-01f, 7.00482056e-02f, -2.48482842e-02f, -6.50229631e-03f, -7.49985427e-02f,
  1.56896770e-01f, 3.87333073e-02f, -6.79258481e-02f, 9.14373174e-02f, 9.76596144e-04f, 8.49984884e-02f, 7.58037344e-02f, 9.94228274e-02f, 1.09216318e-01f, -3.26290191e-03f,
  1.49431363e-01f, 1.01841860e-01f
};

// L3_fan_Wp (Shape: 6 x 64)
const int L3_fan_Wp_rows = 6;
const int L3_fan_Wp_cols = 64;
const float L3_fan_Wp_data[] = {
  -1.81931034e-01f, -1.48638058e-02f, -1.30069279e-03f, -9.81394202e-02f, -7.88235888e-02f, 3.22856978e-02f, -1.42417625e-01f, 1.03661492e-01f, 1.88433584e-02f, -1.71042106e-03f,
  5.22165410e-02f, -6.76302835e-02f, 2.92842072e-02f, 1.24527395e-01f, 1.47659786e-03f, -1.30842119e-01f, -7.16308951e-02f, 7.41519732e-03f, 4.05858420e-02f, 7.50122294e-02f,
  2.49586180e-02f, 1.47002742e-01f, -7.98832476e-02f, 1.40861580e-02f, 6.24104664e-02f, 3.33234891e-02f, -3.92773305e-04f, -1.49259521e-02f, 4.05263714e-02f, 1.51064806e-02f,
  -1.12316266e-01f, -4.47775200e-02f, -1.02698095e-01f, -4.81353439e-02f, 7.71276504e-02f, 3.65381613e-02f, 1.41008869e-02f, -1.10208698e-01f, -7.19457790e-02f, 1.31932974e-01f,
  9.35311764e-02f, -9.13435370e-02f, -4.64221872e-02f, -6.58152848e-02f, -1.38768356e-03f, 1.21575668e-02f, 9.78680179e-02f, -5.20816967e-02f, -1.21891769e-02f, -1.45181185e-02f,
  -6.24290816e-02f, -7.83560872e-02f, 4.92351539e-02f, 8.85105059e-02f, 9.12640318e-02f, 8.70240852e-02f, 6.73666224e-02f, 1.70239015e-03f, 6.24782667e-02f, 1.63359612e-01f,
  1.60171598e-01f, -1.51120543e-01f, -1.53477877e-01f, -4.29437496e-03f, 3.95260677e-02f, 8.06662366e-02f, 5.14293052e-02f, 2.12873053e-02f, -3.25659588e-02f, 8.90541170e-03f,
  1.76193938e-01f, 3.23893093e-02f, 7.97249228e-02f, -1.85610458e-01f, 2.05649361e-02f, 7.90116787e-02f, -1.34762488e-02f, -9.48510841e-02f, 1.12723537e-01f, -1.62032545e-02f,
  -2.77268747e-03f, -2.45832596e-02f, -1.31820187e-01f, -8.12045066e-04f, 1.44630194e-01f, 1.09283485e-01f, -6.51893690e-02f, -8.50253627e-02f, 1.04947075e-01f, 1.03903838e-01f,
  1.05351448e-01f, -6.08910695e-02f, -1.55537099e-01f, -2.00998355e-02f, 4.96543609e-02f, -8.28506202e-02f, 1.12054050e-01f, 5.58806323e-02f, 2.60233171e-02f, 1.48472175e-01f,
  -2.55240616e-03f, -4.53266501e-02f, 5.79263717e-02f, 2.40727165e-03f, -1.40501723e-01f, -1.30794659e-01f, 1.27534509e-01f, -4.81283702e-02f, -3.28154340e-02f, 5.90762720e-02f,
  3.61599922e-02f, 1.06446944e-01f, -2.55059078e-02f, 5.35903536e-02f, -1.37334084e-02f, -6.09451570e-02f, -1.33360445e-01f, -9.19796005e-02f, -1.07520819e-02f, -5.25668599e-02f,
  -5.98525815e-02f, 3.52835581e-02f, 9.19772759e-02f, -9.28268060e-02f, 1.93040222e-01f, -8.21289867e-02f, -7.29670972e-02f, -8.95658210e-02f, -7.90719092e-02f, -6.90473765e-02f,
  3.08395978e-02f, 1.12870239e-01f, 1.90816578e-02f, 8.09510350e-02f, -2.37932190e-01f, 5.16100526e-02f, -1.95251375e-01f, 3.70915979e-02f, 6.42846152e-02f, -7.79662132e-02f,
  -1.23362681e-02f, 3.53844017e-02f, -1.06212907e-01f, -3.61192524e-02f, -6.10037521e-03f, -3.64639014e-02f, 2.15906948e-01f, 1.15914568e-02f, -1.25151426e-01f, -2.32493249e-03f,
  7.69019276e-02f, 1.45931408e-01f, 6.44839033e-02f, -8.20210855e-03f, 5.36824726e-02f, 1.03528481e-02f, 6.76280856e-02f, -1.05748981e-01f, -5.31102382e-02f, 3.66506986e-02f,
  3.26548070e-02f, -1.13205373e-01f, 3.56381349e-02f, -6.22215308e-02f, -5.96789904e-02f, 7.03004524e-02f, -2.61007026e-02f, -6.82601938e-03f, 1.13556296e-01f, 2.59579159e-02f,
  -8.67779478e-02f, 1.75173301e-02f, 1.08248545e-02f, 5.22999093e-02f, 1.73236400e-01f, -1.02019146e-01f, -1.51873872e-01f, -3.42086405e-02f, 8.38448033e-02f, -3.46157439e-02f,
  1.67315722e-01f, -9.46011171e-02f, 8.33018869e-02f, 1.60278171e-01f, -1.02794953e-02f, 1.93324871e-02f, -9.62601304e-02f, -4.68879864e-02f, -7.14301839e-02f, 5.44583909e-02f,
  -1.10832065e-01f, -5.82677498e-03f, 1.01888411e-01f, -1.00722045e-01f, 1.09851427e-01f, 6.88806474e-02f, -4.21944186e-02f, -1.82170665e-03f, -2.17710033e-01f, -1.81841031e-01f,
  -2.09528372e-01f, 1.41607717e-01f, -8.56613442e-02f, -7.19287321e-02f, -1.14216231e-01f, 4.99468967e-02f, -1.44004196e-01f, -1.82353199e-01f, -1.77400261e-02f, -1.47399763e-02f,
  3.35515253e-02f, -1.56034427e-02f, 3.91159719e-03f, -8.95381048e-02f, -1.93331428e-02f, -1.35634363e-01f, -7.54817277e-02f, -5.72688803e-02f, -2.80398466e-02f, 1.67394858e-02f,
  -9.09686834e-02f, 2.42022648e-02f, -5.23735099e-02f, -2.28550971e-01f, -1.32667124e-01f, -4.23747413e-02f, -1.29694879e-01f, 1.22500665e-01f, 1.05157040e-01f, 1.89796947e-02f,
  -1.28454473e-02f, -7.54251033e-02f, 1.06134698e-01f, 6.70239404e-02f, -8.55457596e-03f, 1.01033688e-01f, 1.45085752e-01f, 8.03991109e-02f, 1.34810254e-01f, 1.95016321e-02f,
  -5.88082895e-02f, -1.14960358e-01f, 1.37075901e-01f, 1.15136532e-02f, 4.94113341e-02f, 8.42000451e-03f, -1.10131614e-01f, 8.21298137e-02f, 7.00580850e-02f, -1.15456700e-01f,
  8.98128226e-02f, 1.33632585e-01f, 1.01178586e-01f, 8.00359026e-02f, -4.77028862e-02f, -2.49472819e-02f, 3.49027552e-02f, 7.06548765e-02f, -5.50534995e-03f, -6.77238312e-03f,
  -1.03075199e-01f, 3.60756665e-02f, 8.44319016e-02f, 4.40128893e-02f, 2.27446258e-01f, -1.46165937e-02f, 1.22277156e-01f, 9.99655575e-02f, 8.45330879e-02f, -1.24873705e-02f,
  -7.50318244e-02f, 1.92234844e-01f, -7.01038763e-02f, -4.19746116e-02f, 8.10676347e-03f, -6.48757443e-02f, -2.44016876e-03f, -6.20696135e-02f, 3.35101373e-02f, -1.52669981e-01f,
  -1.20463893e-01f, 6.93720430e-02f, 5.35338670e-02f, 1.69689745e-01f, 1.37172118e-02f, -3.02622467e-02f, 1.64743334e-01f, -3.02802189e-03f, -3.80788781e-02f, -7.00008646e-02f,
  -3.53674428e-03f, -5.44708557e-02f, -1.95377842e-01f, -1.35050118e-01f, 1.13525815e-01f, -1.23580337e-01f, 7.00834543e-02f, 1.43335000e-01f, 2.96735428e-02f, 3.33109163e-02f,
  3.93937007e-02f, -6.71833977e-02f, 9.82073098e-02f, -1.80397425e-02f, -3.45606916e-02f, -1.26982868e-01f, -1.53268995e-02f, 2.62084361e-02f, 9.27513689e-02f, 4.61930595e-02f,
  -1.76370405e-02f, -4.61521000e-02f, 5.59747592e-02f, -1.34302750e-01f, -1.06222508e-02f, 1.45544812e-01f, -5.31874597e-02f, 1.25718722e-02f, -3.83611247e-02f, -2.16879454e-02f,
  1.79893702e-01f, -5.98349608e-03f, -4.77925204e-02f, -2.55493657e-03f, 1.36938795e-01f, -1.98505749e-03f, 5.45074530e-02f, -1.44997418e-01f, 2.05903903e-01f, -9.56295058e-03f,
  -3.95965166e-02f, -3.07946298e-02f, -1.11214273e-01f, -1.85725763e-01f, -5.71607724e-02f, 1.63614944e-01f, -2.73778997e-02f, 1.36401147e-01f, 9.88191590e-02f, 1.50019664e-03f,
  -8.28790367e-02f, 8.02497286e-03f, 3.91495526e-02f, -1.17394008e-01f, 7.15453550e-02f, 5.16035259e-02f, -1.25126451e-01f, -1.42020226e-01f, -4.37958203e-02f, 8.45892504e-02f,
  1.21321559e-01f, 1.20465122e-01f, 9.44466591e-02f, -9.19410363e-02f, 8.25978722e-03f, -5.08766994e-02f, 4.59486432e-02f, 7.57142380e-02f, 5.92411384e-02f, 8.27776734e-03f,
  2.76976917e-02f, 5.43174073e-02f, -5.92198446e-02f, -7.33751506e-02f, -4.49190289e-02f, 5.41649498e-02f, 6.31483346e-02f, -1.41825229e-01f, 9.53634977e-02f, 9.94088203e-02f,
  -6.78739548e-02f, 6.04423787e-03f, 3.81278209e-02f, -3.34645808e-02f, -2.15016380e-02f, -5.49751371e-02f, -1.77212823e-02f, -1.49055138e-01f, 2.78619248e-02f, -1.08980909e-01f,
  -4.87444699e-02f, -4.33677994e-02f, 1.92667991e-02f, 1.43565625e-01f
};

// L3_fan_Wp_bar (Shape: 52 x 64)
const int L3_fan_Wp_bar_rows = 52;
const int L3_fan_Wp_bar_cols = 64;
const float L3_fan_Wp_bar_data[] = {
  1.13663070e-01f, -3.43186893e-02f, 1.45048782e-01f, -5.55505343e-02f, 6.83815684e-03f, -1.39585018e-01f, 3.31088901e-01f, 2.17777357e-01f, -6.30714223e-02f, -1.50664195e-01f,
  1.63858935e-01f, -5.22315316e-03f, 9.87430140e-02f, 1.76866740e-01f, -1.07067503e-01f, -7.92030096e-02f, -5.55208735e-02f, -2.11739019e-01f, -5.07726450e-04f, -5.14921099e-02f,
  9.66426879e-02f, 1.57984853e-01f, 1.51526600e-01f, -3.21454197e-01f, 1.65016815e-01f, 8.36016685e-02f, 2.36988604e-01f, 2.02801879e-02f, -4.33648899e-02f, 8.83680731e-02f,
  -7.19326138e-02f, 1.01000810e+00f, 1.95615947e-01f, -2.27964014e-01f, 1.07580528e-01f, -5.19946851e-02f, 4.23498824e-02f, 8.56724679e-02f, 3.18744853e-02f, 9.19397846e-02f,
  -5.16811125e-02f, -1.24749886e-02f, 3.14278871e-01f, 1.58721045e-01f, 2.26186082e-01f, 2.71323442e-01f, -6.28765253e-03f, 2.60534920e-02f, -9.07992721e-02f, 2.70311460e-02f,
  -2.70983540e-02f, 1.21930659e-01f, -7.02961087e-02f, 2.54817277e-01f, 2.74306804e-01f, -4.40441743e-02f, 1.28161117e-01f, -5.04125468e-02f, 1.97791040e-01f, 6.77279532e-02f,
  -2.72912141e-02f, -1.15580998e-01f, -9.98268947e-02f, 1.11211047e-01f, 3.84144485e-02f, 1.37118369e-01f, 7.96086937e-02f, 1.42930597e-01f, 2.05519244e-01f, 1.02735274e-01f,
  -1.13814943e-01f, 1.45305917e-01f, -1.75268948e-02f, -3.96793373e-02f, -1.96437642e-01f, 7.70439133e-02f, 6.78439513e-02f, 1.83123901e-01f, 2.19525367e-01f, 1.17689081e-01f,
  1.89397037e-01f, 8.24338794e-02f, -8.86327252e-02f, 1.17754363e-01f, 1.93283096e-01f, -2.66970638e-02f, 4.28500362e-02f, 1.22590877e-01f, 7.05873296e-02f, 1.06248282e-01f,
  -1.59443378e-01f, -1.01354189e-01f, -1.00012131e-01f, 2.36697465e-01f, 1.08227789e-01f, -3.57075840e-01f, -1.43674433e-01f, 3.37480195e-02f, 5.06719649e-02f, 1.70458466e-01f,
  6.25646412e-02f, 1.54507771e-01f, 6.69604838e-02f, 1.44040864e-02f, 3.79574709e-02f, 9.63978246e-02f, -3.31568383e-02f, -8.45712274e-02f, -7.92879164e-02f, -1.24163441e-01f,
  2.79956788e-01f, -9.38832946e-03f, 2.41599694e-01f, -5.67502230e-02f, 6.55199885e-02f, 5.50876483e-02f, -4.76263501e-02f, 1.34921327e-01f, -1.99142527e-02f, 9.24937427e-02f,
  -6.67066351e-02f, -1.25807673e-01f, 1.81527525e-01f, -5.83899533e-03f, 2.42302909e-01f, -3.07327253e-03f, 1.80157889e-02f, -8.35311562e-02f, -2.25444306e-02f, 1.51254356e-01f,
  8.11032206e-02f, 2.02802196e-02f, -2.94398125e-02f, -1.77320503e-02f, -1.66288927e-01f, -2.79521197e-01f, 1.38229933e-02f, 1.51838809e-01f, 2.55660146e-01f, -6.62590787e-02f,
  -4.34344336e-02f, -1.07373387e-01f, 4.66887057e-02f, 6.20514266e-02f, 1.02833010e-01f, -3.21797095e-02f, 1.77336514e-01f, -8.91729817e-02f, -1.95309743e-01f, 1.03207596e-01f,
  1.45833939e-01f, 1.33497894e-01f, -2.61272434e-02f, -8.14360529e-02f, 2.25988165e-01f, 1.51971221e-01f, -3.51871201e-03f, -1.83729097e-01f, -9.74022821e-02f, 1.84779242e-01f,
  1.91072956e-01f, 1.78001404e-01f, -6.06767312e-02f, 6.96113184e-02f, 1.00324832e-01f, -1.59016903e-02f, 8.99990425e-02f, 3.62706296e-02f, -5.78907318e-02f, 2.76269168e-01f,
  -6.04711361e-02f, 1.91962570e-01f, 6.59650564e-02f, 1.80189729e-01f, -1.06397280e-02f, -7.15963449e-03f, 8.90011191e-02f, -1.04610942e-01f, -1.10432096e-01f, 1.00805960e-03f,
  2.07148030e-01f, -3.46551761e-02f, -7.94340819e-02f, -4.89069987e-03f, 2.13939101e-01f, 1.00077748e-01f, 4.03006300e-02f, -4.52371091e-02f, -2.25145862e-01f, 1.26517728e-01f,
  -2.87903268e-02f, 2.16539606e-01f, -8.97403248e-03f, 2.27993932e-02f, 1.61588699e-01f, 4.83941510e-02f, -3.59541252e-02f, -5.28522730e-02f, -5.71363121e-02f, -1.61237299e-01f,
  7.68426359e-02f, 2.20488861e-01f, -1.15218244e-01f, 2.79053543e-02f, -5.15937991e-02f, 3.66268046e-02f, 1.41785331e-02f, 1.26229361e-01f, -4.31099422e-02f, -1.91156685e-01f,
  2.10296616e-01f, 7.08418489e-02f, -1.57290578e-01f, 4.01474610e-02f, 1.07855208e-01f, 1.49569094e-01f, -1.62942275e-01f, 2.95749605e-02f, 1.80606276e-01f, 2.24605992e-01f,
  -8.56846496e-02f, -6.96715340e-02f, 1.37852073e-01f, -3.62904578e-01f, 3.88536341e-02f, 9.81808547e-03f, -2.35845968e-01f, -5.89479553e-03f, 1.13860846e-01f, 5.80658615e-02f,
  7.60679021e-02f, -8.17212909e-02f, -2.95964420e-01f, 9.38207805e-02f, -1.85565323e-01f, -6.42674863e-02f, 1.43945947e-01f, -2.57335380e-02f, 1.12088747e-01f, -2.14498103e-01f,
  1.44382492e-01f, 9.66688022e-02f, 9.73658636e-02f, -2.88477272e-01f, 2.24471882e-01f, -1.15135431e-01f, -2.96237506e-02f, 4.58464138e-02f, 5.91561459e-02f, 7.28481263e-03f,
  9.83430296e-02f, -2.49369498e-02f, -7.03243092e-02f, 1.59618691e-01f, -8.26861113e-02f, -2.08606627e-02f, -8.89620557e-02f, -6.37929887e-02f, -2.87395030e-01f, -2.50933692e-03f,
  1.40934833e-03f, -3.11437637e-01f, 2.27614433e-01f, -1.86380688e-02f, 2.38273114e-01f, -2.51884937e-01f, 8.55537504e-02f, 8.63149762e-02f, -1.44046664e-01f, -1.54938474e-01f,
  2.54520178e-01f, 4.84625660e-02f, -6.70951828e-02f, -4.59013209e-02f, 4.23410982e-02f, -7.38643855e-02f, 1.32031098e-01f, 1.29852578e-01f, 8.35126713e-02f, -3.56464624e-01f,
  3.04516442e-02f, -5.31857908e-02f, 3.10871489e-02f, 1.65303931e-01f, -1.13783404e-01f, 6.76794127e-02f, 8.95783585e-03f, 5.30033767e-01f, 1.37268573e-01f, 1.24413304e-01f,
  1.55225053e-01f, 4.70786244e-02f, 4.16727960e-02f, 1.06302854e-02f, 1.09999245e-02f, 5.38652181e-04f, 1.83740959e-01f, -6.29831478e-02f, -8.36633146e-03f, -1.06065914e-01f,
  1.50709480e-01f, -8.34186673e-02f, -2.06224635e-01f, -1.65410712e-01f, 1.65699974e-01f, 9.96569246e-02f, 3.61358263e-02f, 6.55396804e-02f, -5.37103647e-03f, 4.89794202e-02f,
  -1.30869240e-01f, -7.50051439e-02f, -1.03382275e-01f, 1.24495551e-01f, 7.31659159e-02f, -1.52794272e-01f, 4.46921922e-02f, 1.10250510e-01f, -6.85664117e-02f, 9.87693965e-02f,
  1.79858446e-01f, 1.86614305e-01f, 2.42830291e-01f, 1.95432194e-02f, 8.24517980e-02f, 1.90207347e-01f, 7.83635080e-02f, 1.10643012e-02f, -1.37607038e-01f, 2.55458087e-01f,
  1.05908655e-01f, 1.11695498e-01f, -9.33571234e-02f, 6.09927103e-02f, -1.66456196e-02f, 3.78620042e-03f, 2.80229956e-01f, 3.59485820e-02f, 9.46638733e-02f, 9.40816998e-02f,
  -1.55381477e-02f, -9.45916865e-03f, 1.09694123e-01f, -1.37536675e-01f, -1.25962228e-01f, 8.03253129e-02f, -8.09306055e-02f, -3.62861492e-02f, -1.89655796e-01f, -1.11820139e-02f,
  -9.04814377e-02f, -3.17241430e-01f, 1.31408527e-01f, -1.09300137e-01f, 4.54929434e-02f, 1.16413176e-01f, -3.01815365e-02f, -3.40600982e-02f, 2.84259200e-01f, 1.12669833e-01f,
  3.07511799e-02f, 7.12446272e-02f, 4.00330126e-02f, 2.27649167e-01f, 3.55929509e-02f, 9.45901573e-02f, 1.64167672e-01f, 1.55291632e-01f, -2.76741832e-02f, -1.21401704e-03f,
  -2.22866051e-02f, 1.25052214e-01f, -4.79590073e-02f, -3.90872210e-02f, -1.60370857e-01f, -9.06993896e-02f, 1.95390776e-01f, -7.63757676e-02f, -9.26603600e-02f, -6.00344166e-02f,
  7.40073025e-02f, 1.02106266e-01f, 8.64631683e-02f, 1.30635956e-02f, -5.70450090e-02f, -1.24393001e-01f, 1.57049432e-01f, -6.19409010e-02f, 2.15022694e-02f, 2.77323034e-02f,
  1.93926767e-01f, 2.10758939e-01f, -4.27526236e-02f, -2.42458075e-01f, -3.84067856e-02f, 9.61013213e-02f, 1.68164209e-01f, 2.21186697e-01f, -2.82356013e-02f, 4.23985682e-02f,
  -1.30836785e-01f, -1.86505802e-02f, -2.06386015e-01f, -7.96692853e-04f, 5.60230315e-02f, 1.83996618e-01f, 5.93814999e-02f, -1.44820020e-01f, 2.26403698e-01f, -7.80949071e-02f,
  -1.01944171e-01f, 8.92866850e-02f, 8.21574330e-02f, 2.76677877e-01f, -7.50692636e-02f, 3.56298268e-01f, 2.60171317e-03f, 1.04302389e-03f, 3.71261351e-02f, 5.12215756e-02f,
  -4.95762452e-02f, -8.12322423e-02f, -1.07815184e-01f, 1.47627547e-01f, 2.78502017e-01f, -2.28532732e-01f, 2.16028020e-01f, 2.21135631e-01f, 1.36297047e-02f, 2.07215115e-01f,
  3.86102162e-02f, 1.40784487e-01f, 1.66361734e-01f, 1.17207449e-02f, 1.11111619e-01f, 2.32098311e-01f, -1.81735873e-01f, 1.80497050e-01f, 1.76883042e-01f, 2.46395636e-02f,
  -2.24804357e-01f, 6.85451552e-02f, -2.20043920e-02f, 1.89740494e-01f, 2.08727613e-01f, -5.36516681e-02f, -4.89436202e-02f, 6.27725050e-02f, -1.05949938e-02f, 1.74345747e-01f,
  -6.97111040e-02f, 8.50572363e-02f, 1.12831943e-01f, -2.75036488e-02f, -1.49481863e-01f, -1.71307713e-01f, -1.91122219e-01f, 1.03566356e-01f, -6.37532324e-02f, -1.46646038e-01f,
  1.28454626e-01f, 1.29849225e-01f, -5.55901043e-02f, -5.32376245e-02f, 3.07273176e-02f, 1.67882174e-01f, -4.36864533e-02f, 9.60556641e-02f, 2.19668403e-01f, -1.06862970e-01f,
  -7.72939250e-02f, 2.61388063e-01f, 4.57627289e-02f, -5.81774674e-03f, -5.84067106e-02f, -1.76840931e-01f, 8.84055123e-02f, -1.01346441e-01f, 7.68461451e-02f, 3.73494178e-01f,
  -2.06272185e-01f, -5.48030026e-02f, 1.27757713e-01f, 2.70254195e-01f, -3.45957465e-02f, 1.95370883e-01f, 5.79279363e-02f, -3.03871352e-02f, -5.61070209e-03f, 1.52054369e-01f,
  9.15201604e-02f, 6.37990162e-02f, -1.33069158e-01f, -5.96720651e-02f, 9.41130072e-02f, 1.65473744e-01f, 6.73426688e-02f, -3.57652851e-03f, 2.07534060e-01f, 1.27255879e-02f,
  7.14377388e-02f, 8.99370387e-03f, -1.07526310e-01f, 1.34316117e-01f, 5.88406064e-03f, -2.05309629e-01f, 9.12074745e-02f, 1.11727737e-01f, 2.69826859e-01f, 2.63913810e-01f,
  1.88349172e-01f, -7.22058490e-02f, -5.75968698e-02f, -4.31506149e-02f, -7.72128180e-02f, -5.50211407e-02f, -1.32930920e-01f, 6.71141371e-02f, -1.20123193e-01f, -5.33689111e-02f,
  2.03903522e-02f, 1.09568484e-01f, 4.58895415e-02f, 8.58896002e-02f, 8.44016969e-02f, -1.45139337e-01f, -1.58653073e-02f, -4.16130573e-02f, -9.04624239e-02f, 6.95873722e-02f,
  -6.75957873e-02f, -8.96546543e-02f, -5.88584878e-02f, -1.73927117e-02f, -1.27569407e-01f, 4.10217158e-02f, 2.15194747e-02f, -7.36406744e-02f, -1.11837633e-01f, -1.50604201e-02f,
  1.85939819e-02f, 7.44536519e-02f, 9.48491914e-04f, -7.28882700e-02f, 3.45389955e-02f, -1.16488338e-02f, 8.77142996e-02f, 5.67549877e-02f, -1.28785878e-01f, 7.98862949e-02f,
  -1.29657358e-01f, 3.30175795e-02f, -7.03275353e-02f, 6.16026074e-02f, -4.01767194e-02f, -9.00229067e-02f, -1.04820810e-01f, -2.60422640e-02f, -2.13067457e-02f, -1.02130502e-01f,
  5.18643558e-02f, 1.01085052e-01f, 7.49034435e-02f, 6.95847794e-02f, 5.40229753e-02f, 6.21840693e-02f, -4.98679467e-02f, 4.24884260e-02f, 5.70636839e-02f, -7.86136985e-02f,
  -1.09321088e-01f, -9.76336077e-02f, 4.42143120e-02f, -6.97754100e-02f, -1.47053972e-01f, -1.29626274e-01f, -2.88255900e-01f, 1.16705820e-01f, -3.06761444e-01f, 1.52523862e-02f,
  -1.16405062e-01f, -2.57960111e-01f, -9.28460583e-02f, -9.64148864e-02f, -1.34236626e-02f, 1.47083744e-01f, 2.93653190e-01f, -2.93130074e-02f, -9.79026631e-02f, -1.22668654e-01f,
  1.70939580e-01f, 1.90002784e-01f, 9.91993919e-02f, 1.35527551e-01f, -1.46385238e-01f, 4.58628088e-02f, 4.58602980e-02f, 9.04275402e-02f, 8.96904692e-02f, -3.21359187e-01f,
  -1.35973364e-01f, 9.28531587e-03f, -1.32392779e-01f, 9.76938829e-02f, -1.50417894e-01f, -3.35337818e-02f, 9.65149999e-02f, 2.63149351e-01f, 1.19698755e-02f, 3.13631356e-01f,
  2.61028409e-01f, 7.98657835e-02f, -1.32399008e-01f, 1.15380444e-01f, 7.64575303e-02f, 1.10265939e-02f, 3.09442520e-01f, 4.82461527e-02f, -1.98258013e-01f, 1.08674578e-02f,
  5.63525222e-02f, 2.06197411e-01f, -2.31322959e-01f, 3.29914615e-02f, 1.64401323e-01f, -5.65066189e-02f, 1.26055643e-01f, 1.38037011e-01f, 1.20628335e-01f, -9.07327011e-02f,
  -2.28143141e-01f, -3.01812798e-01f, -4.63511609e-02f, 1.87726513e-01f, -1.56591803e-01f, -2.14540616e-01f, 6.92746937e-02f, 3.23662199e-02f, 6.14783214e-03f, 3.17821503e-02f,
  1.86739713e-01f, -5.62336808e-03f, 1.82878107e-01f, -1.06969737e-01f, -3.62845957e-02f, -4.24219556e-02f, 7.17093144e-03f, 1.63219333e-01f, -2.70505156e-02f, -1.05165347e-01f,
  9.29303616e-02f, -1.37462214e-01f, 2.00828165e-01f, 1.78883299e-01f, 5.62534593e-02f, -4.67803665e-02f, 1.22471519e-01f, 1.84923396e-01f, -2.09516332e-01f, -1.17896155e-01f,
  1.39314801e-01f, 3.10392808e-02f, -1.50527924e-01f, -2.02199087e-01f, 1.44888267e-01f, -7.24313408e-03f, -8.85310024e-02f, -1.18913561e-01f, -1.00294590e-01f, 1.41658619e-01f,
  -1.21317700e-01f, 3.71713452e-02f, 1.22918323e-01f, -7.79840648e-02f, 2.78206736e-01f, 9.20388848e-02f, 4.95177284e-02f, 1.38998091e-01f, -8.68411362e-03f, -2.92418036e-03f,
  1.18512936e-01f, 8.92445296e-02f, 2.49284469e-02f, 8.50077271e-02f, -4.20875661e-02f, 2.32698023e-01f, -9.59707424e-02f, 4.23815697e-02f, -9.82639641e-02f, 1.01635503e-02f,
  2.77142040e-02f, 2.42755443e-01f, -3.26896529e-03f, 1.16911598e-01f, 2.71471702e-02f, 1.16999961e-01f, -1.97852746e-01f, 4.29815426e-02f, 9.43212956e-02f, 1.45557448e-01f,
  8.91116261e-02f, -5.52419387e-02f, 7.41081461e-02f, 8.26200247e-02f, -1.19838715e-01f, 1.83948472e-01f, 5.31953871e-02f, 2.05622301e-01f, -2.27359515e-02f, 1.51214510e-01f,
  2.16446832e-01f, 2.37133671e-02f, -2.26215273e-02f, 1.80555761e-01f, 7.11597428e-02f, 1.49618626e-01f, -6.10853955e-02f, -6.17435910e-02f, 6.22882210e-02f, 1.78522572e-01f,
  -2.45629381e-02f, -1.52575999e-01f, 1.43579403e-02f, -3.17056701e-02f, -1.28651768e-01f, 9.50325876e-02f, 2.53719568e-01f, -9.91919562e-02f, -4.28278707e-02f, 6.51947334e-02f,
  2.96495110e-01f, 1.21665031e-01f, 2.17352852e-01f, -1.60860568e-02f, 9.36886594e-02f, -6.02203533e-02f, 2.78163999e-01f, 6.17820434e-02f, -2.79005785e-02f, -1.51565790e-01f,
  -5.49425408e-02f, 7.17682019e-02f, 1.90923199e-01f, 3.76901007e-03f, -6.05967455e-02f, 5.78977689e-02f, 1.05504662e-01f, 1.51974171e-01f, 2.18208537e-01f, 1.05017193e-01f,
  1.20823361e-01f, 1.28336817e-01f, 2.19339970e-03f, 2.40967721e-02f, -1.42745107e-01f, -4.98969257e-02f, 6.01687469e-02f, 1.01937577e-01f, 3.02422821e-04f, -5.98861724e-02f,
  4.97826077e-02f, 1.90359056e-01f, 1.26317397e-01f, 6.33558556e-02f, -1.97817832e-01f, 7.37333894e-02f, -2.50721481e-02f, 2.57512927e-01f, 1.81307793e-01f, 1.56967994e-02f,
  1.25976309e-01f, -2.50529200e-02f, 1.25969602e-02f, 1.61327496e-01f, -5.64080663e-02f, -7.83975646e-02f, -1.74326196e-01f, 9.16487128e-02f, -1.17087439e-01f, -6.09121062e-02f,
  1.72579885e-01f, 1.14369832e-01f, 1.52825549e-01f, 8.29117447e-02f, 2.46131599e-01f, 2.09530249e-01f, -2.88426802e-02f, 1.22161143e-01f, 9.45943668e-02f, -7.36023486e-02f,
  -5.64270429e-02f, 1.20357797e-01f, 2.12743610e-01f, -7.22426269e-03f, -1.11175152e-02f, -1.09828867e-01f, -3.36520076e-02f, 8.61843973e-02f, -1.80490226e-01f, -4.90195937e-02f,
  1.94101520e-02f, -1.00415193e-01f, 2.83960104e-01f, 1.21270522e-01f, 2.55566180e-01f, 1.96092799e-01f, 1.45015329e-01f, 1.26504093e-01f, 3.60779129e-02f, 1.91448301e-01f,
  -1.41883612e-01f, -5.39464690e-02f, -1.79503560e-01f, 5.63781485e-02f, -1.47048309e-01f, -2.86376700e-02f, -1.23341389e-01f, 4.96279560e-02f, -1.54987408e-03f, 1.64302498e-01f,
  2.64499485e-02f, 1.21519685e-01f, 4.44779582e-02f, 9.61455107e-02f, -5.23283519e-02f, 3.44599411e-02f, 2.93861106e-02f, 1.51962265e-01f, -5.52476384e-02f, 9.36349034e-02f,
  7.85306767e-02f, -1.16758384e-01f, 1.16350763e-01f, 6.82843700e-02f, -1.06917776e-01f, 1.07482985e-01f, -4.70082723e-02f, 8.37707240e-03f, 7.68962726e-02f, -2.64346749e-01f,
  -2.79512666e-02f, 2.02252939e-01f, 6.71256185e-02f, -2.90784333e-02f, -4.40090746e-02f, -1.08782232e-01f, 1.38665318e-01f, 5.44102527e-02f, 1.68417647e-01f, 3.20798755e-01f,
  -1.30187228e-01f, -8.41023624e-02f, 1.14615873e-01f, 1.27215192e-01f, -7.50825852e-02f, 3.47378105e-02f, -1.46605164e-01f, 9.77834165e-02f, 1.64659619e-02f, -1.14306763e-01f,
  -9.07718986e-02f, 7.62085170e-02f, -6.44677058e-02f, 1.42505392e-02f, -1.35632589e-01f, 1.71633407e-01f, -3.97573188e-02f, 1.80802584e-01f, 7.33458400e-02f, 2.41181716e-01f,
  1.56478435e-01f, 1.17907546e-01f, 6.16599955e-02f, 3.58562171e-02f, 3.76639627e-02f, -5.38279004e-02f, -7.47507811e-02f, -7.34011754e-02f, 2.52148025e-02f, 1.17301373e-02f,
  1.51276067e-01f, 2.37757489e-02f, 2.09709302e-01f, -5.54160699e-02f, 7.67936707e-02f, 1.58242762e-01f, -1.06965609e-01f, 3.97220720e-03f, 1.37426078e-01f, -9.41095501e-02f,
  6.90243673e-03f, -1.27117872e-01f, 5.69600658e-03f, 1.84126437e-01f, 2.49920025e-01f, 1.38659388e-01f, 9.08498690e-02f, 1.76594071e-02f, -3.53835970e-02f, -2.43112985e-02f,
  -7.93125778e-02f, -4.68169227e-02f, 8.09028670e-02f, 4.00042422e-02f, -1.09410100e-01f, -1.06130309e-01f, -1.18615329e-01f, 2.49075238e-03f, 1.22945994e-01f, -9.21029299e-02f,
  -3.54094021e-02f, -1.02673516e-01f, 7.41290376e-02f, -9.71162617e-02f, -1.09034054e-01f, -1.12538993e-01f, 1.92200318e-02f, 4.00949419e-02f, -1.09756738e-01f, -1.13543123e-02f,
  9.69117731e-02f, 4.30244952e-02f, -3.24682854e-02f, -5.85791767e-02f, -9.97703373e-02f, -6.04748428e-02f, 8.53563834e-04f, 3.83335203e-02f, -1.09761268e-01f, 5.34867048e-02f,
  7.00623989e-02f, -1.62336212e-02f, -6.21044487e-02f, -8.68836939e-02f, 1.08624563e-01f, -6.10791817e-02f, 3.44961882e-03f, -1.29204877e-02f, -4.97360267e-02f, -7.67964050e-02f,
  -7.45038465e-02f, 1.01842910e-01f, 1.10671759e-01f, 4.10211869e-02f, -9.46044028e-02f, -5.07363230e-02f, 1.48120821e-02f, 6.91934079e-02f, -9.24136490e-02f, -9.38229859e-02f,
  -2.82801297e-02f, -1.00356005e-01f, 6.20113760e-02f, 3.66742648e-02f, -1.30151600e-01f, -3.36824246e-02f, -6.55626552e-03f, -5.12810200e-02f, -1.21522807e-01f, -7.20058680e-02f,
  -7.38106072e-02f, -7.92987645e-02f, -1.03502586e-01f, 4.95809019e-02f, -9.15509760e-02f, 4.22241688e-02f, 4.61424589e-02f, 5.71985692e-02f, 2.46599317e-04f, -9.77260172e-02f,
  -2.61814147e-02f, 6.56698793e-02f, -6.52051270e-02f, -2.58405060e-02f, -6.87081218e-02f, -8.06756318e-02f, -4.50020880e-02f, -6.72011524e-02f, 2.62791961e-02f, -6.04552031e-03f,
  -9.38470066e-02f, -1.01484850e-01f, -7.57367909e-03f, 2.26481408e-02f, -8.98398459e-03f, 1.79749131e-02f, 2.76732147e-02f, 1.07716575e-01f, 7.50644505e-03f, 3.21947038e-03f,
  -3.89605761e-02f, 1.02997780e-01f, -7.17962086e-02f, 4.38179523e-02f, 9.24522430e-02f, 9.55304652e-02f, 6.54350221e-03f, 2.08968818e-02f, -9.97476429e-02f, -6.33593500e-02f,
  9.32559967e-02f, 8.81606042e-02f, 7.01991022e-02f, -3.08787376e-02f, -1.07390314e-01f, -6.62936270e-03f, -6.60142154e-02f, 5.54669797e-02f, -4.70780581e-02f, 7.44032860e-02f,
  -4.24762815e-02f, 4.40855622e-02f, -3.96821797e-02f, -8.30070674e-03f, 8.20878446e-02f, -3.56369019e-02f, 4.39340174e-02f, 3.07784081e-02f, -9.27912593e-02f, -1.16096973e-01f,
  -1.20464385e-01f, 3.58051956e-02f, -7.31518120e-02f, 4.95135039e-02f, 1.03458017e-01f, 2.34151959e-01f, 6.29336312e-02f, 1.55173138e-01f, -2.94251535e-02f, 1.14973836e-01f,
  -2.36324947e-02f, -2.38675520e-01f, -1.26233235e-01f, 3.30226570e-01f, 1.15875207e-01f, 1.54284671e-01f, -1.10122904e-01f, -3.51065397e-02f, 7.29055330e-02f, 2.10015982e-01f,
  1.72058508e-01f, 1.49475127e-01f, 1.15598887e-01f, 8.62300843e-02f, -1.01359285e-01f, 1.28385887e-01f, 5.01666625e-04f, 2.43018437e-02f, -7.93657079e-02f, -5.58124036e-02f,
  1.82248548e-01f, 1.79284979e-02f, -5.99116273e-02f, -4.80033979e-02f, 4.27444614e-02f, -3.56744826e-01f, -7.75885731e-02f, 9.37876999e-02f, -1.76086158e-01f, 7.32797608e-02f,
  1.39097303e-01f, 5.91867715e-02f, 1.51922449e-01f, 1.11620203e-01f, -1.29937762e-02f, 1.78448796e-01f, -5.03150225e-02f, -1.30187646e-01f, -1.40044056e-02f, 6.53488412e-02f,
  1.00129046e-01f, 3.05081066e-02f, 5.91684366e-03f, -1.20410711e-01f, 1.13377303e-01f, 7.32835680e-02f, 2.36956906e-02f, -1.45068541e-01f, -1.32738486e-01f, -1.09436400e-01f,
  2.78538823e-01f, 1.24187581e-02f, -1.95082463e-02f, -6.16294704e-02f, 5.57089113e-02f, 4.03068848e-02f, -2.35034861e-02f, -1.07978638e-02f, 1.05474517e-01f, -1.54419616e-01f,
  -4.48079966e-02f, -1.23059571e-01f, -1.67732015e-01f, -4.00305428e-02f, 9.59927514e-02f, -3.45637500e-02f, 1.98198691e-01f, -1.18687578e-01f, 1.95018917e-01f, 6.22591786e-02f,
  -3.46821509e-02f, -6.27758577e-02f, 2.04158977e-01f, 1.02205649e-01f, -6.92613497e-02f, -3.20131257e-02f, 1.53838068e-01f, 1.80730671e-02f, 6.92373291e-02f, -1.41250372e-01f,
  1.66489378e-01f, -3.13449562e-01f, 9.98346135e-02f, -8.83402750e-02f, 1.89648196e-01f, 2.10051555e-02f, -1.27838939e-01f, 1.40951455e-01f, 1.03645287e-01f, -4.53242920e-02f,
  9.48164389e-02f, -3.91177386e-02f, 1.58730701e-01f, 2.82511190e-02f, 1.51736066e-01f, 1.17051139e-01f, -1.37046605e-01f, -1.09183826e-01f, -4.87331972e-02f, 4.56027575e-02f,
  3.70888561e-02f, 8.28374829e-03f, 5.72811216e-02f, 2.43312463e-01f, -1.80750951e-01f, -7.99840987e-02f, 1.58040658e-01f, -7.52363470e-04f, 1.29495785e-01f, -6.40043393e-02f,
  4.67531681e-02f, 1.25791267e-01f, -1.31229863e-01f, -6.23543672e-02f, -4.48473729e-03f, 1.03225075e-01f, 4.50902134e-02f, -1.66906536e-01f, -8.47085267e-02f, 4.76931408e-02f,
  1.64905675e-02f, 1.86430991e-01f, 6.56275749e-02f, 8.46024230e-02f, 2.30622575e-01f, 1.05010733e-01f, 2.44042780e-02f, 2.76552886e-01f, -2.27790833e-01f, 2.88037304e-02f,
  -1.01783797e-01f, 5.59081286e-02f, -2.43754044e-01f, 5.35057299e-02f, 1.43452846e-02f, 2.04524755e-01f, -2.35362668e-02f, -4.75613255e-04f, 1.24247536e-01f, 5.51561117e-02f,
  1.11350164e-01f, -8.71045608e-03f, -2.61421017e-02f, -1.99615598e-01f, -3.70177464e-03f, 1.46212995e-01f, 6.08526096e-02f, -1.06054410e-01f, -5.11437245e-02f, -1.50733069e-01f,
  -5.04955370e-03f, -3.82255167e-02f, -8.50729458e-03f, -5.32152295e-01f, -1.03052475e-01f, -7.75782838e-02f, -2.19009057e-01f, -4.52834964e-02f, 2.66347259e-01f, 2.75054723e-01f,
  -4.14169729e-02f, 7.52590001e-02f, -1.80908054e-01f, 6.74177520e-03f, -7.26915374e-02f, -1.54996201e-01f, 5.25622070e-02f, -3.76923144e-01f, 1.62463292e-01f, -3.22103426e-02f,
  2.36876339e-01f, 9.05096158e-03f, 8.51297602e-02f, -1.49244666e-01f, -4.49091494e-02f, -9.71533079e-03f, 4.24860492e-02f, 2.78486252e-01f, 1.98065713e-01f, -6.57579452e-02f,
  1.01931095e-01f, -1.06923252e-01f, 1.73591822e-01f, 1.66436553e-01f, 1.02531135e-01f, -6.40247390e-02f, 1.90992028e-01f, 1.45988241e-01f, 2.69175589e-01f, 3.51287425e-02f,
  1.64551642e-02f, 2.50808895e-01f, 1.37993246e-01f, -9.63197425e-02f, -8.60420540e-02f, 3.41085315e-01f, -3.30808982e-02f, 2.93059498e-01f, 3.89296971e-02f, 8.57789163e-03f,
  4.58682813e-02f, 1.71982393e-01f, 1.98521063e-01f, 2.33691148e-02f, -1.04291625e-02f, -8.61623436e-02f, -1.30642623e-01f, 3.60842124e-02f, -2.84557175e-02f, -8.68247077e-03f,
  -1.89114884e-01f, 6.03491105e-02f, 1.64691955e-01f, 1.22565009e-01f, -9.87049118e-02f, -6.63249791e-02f, 1.59244269e-01f, -4.13380831e-01f, 8.44660178e-02f, -4.76400293e-02f,
  -3.53518836e-02f, 1.22286513e-01f, 1.06877536e-01f, -1.33471098e-02f, 4.65527810e-02f, 9.29928496e-02f, -1.40644431e-01f, 1.60232589e-01f, -1.85362846e-01f, -3.69572788e-02f,
  1.89444512e-01f, 9.40720364e-03f, 3.09097558e-01f, -1.43045578e-02f, 8.30322057e-02f, -4.74848114e-02f, -5.20467497e-02f, -8.70635435e-02f, 2.06703752e-01f, -1.21044651e-01f,
  2.95412075e-02f, 4.30553630e-02f, 2.96624571e-01f, 8.26977789e-02f, 9.91563424e-02f, -5.46516068e-02f, 2.78374981e-02f, 8.72741919e-03f, 8.35007280e-02f, 9.69493203e-03f,
  1.08349599e-01f, -6.63021356e-02f, -6.39490634e-02f, -9.63807330e-02f, -1.01697616e-01f, 1.26079237e-02f, -6.73983097e-02f, 6.47323057e-02f, 6.85564131e-02f, -8.35489184e-02f,
  -7.62502328e-02f, 2.71002129e-02f, 4.77218330e-02f, -1.17090829e-01f, -7.48034492e-02f, 3.06512527e-02f, -4.21538167e-02f, -5.15344739e-02f, 4.72710617e-02f, 1.72435194e-02f,
  -6.86156973e-02f, -1.20891631e-01f, -1.27736643e-01f, -8.63034278e-02f, -2.11988408e-02f, 1.11506432e-01f, -9.36098117e-03f, -1.58513784e-02f, -2.49193609e-03f, 7.15196729e-02f,
  9.93451774e-02f, -4.66287732e-02f, 2.60092895e-02f, -6.20087832e-02f, -1.17265940e-01f, -5.01990169e-02f, -7.63125047e-02f, 9.05172452e-02f, -7.78787956e-02f, -9.41782445e-02f,
  5.34672141e-02f, 2.00914890e-02f, 2.72160266e-02f, -9.61048901e-03f, -4.27983552e-02f, -1.00336120e-01f, 4.53793146e-02f, 9.74598303e-02f, -5.56070432e-02f, -3.49353105e-02f,
  -2.79856622e-02f, 3.73799503e-02f, 1.16519900e-02f, 6.73481971e-02f, -7.18834475e-02f, 1.57306939e-02f, -1.17802501e-01f, -4.02961224e-02f, -1.36258110e-01f, -2.39477456e-02f,
  1.24777518e-02f, 5.57667762e-02f, -1.37474433e-01f, 1.08127460e-01f, -2.37903297e-02f, 1.29935712e-01f, -2.10223198e-02f, 1.55618191e-01f, 8.93748030e-02f, 1.94214568e-01f,
  7.03129843e-02f, 3.98127697e-02f, -1.86009929e-01f, 1.04691811e-01f, 1.92533195e-01f, -1.04451165e-01f, 6.92619830e-02f, 1.67347148e-01f, -1.41116410e-01f, -5.87500967e-02f,
  1.16066411e-01f, -1.36534989e-01f, -9.30286795e-02f, -8.47830698e-02f, 3.57976221e-02f, 2.08238840e-01f, 1.59131661e-01f, 6.20659888e-02f, 1.89556897e-01f, -1.85441282e-02f,
  2.82665081e-02f, 1.99452817e-01f, 2.00456128e-01f, 1.56483665e-01f, 1.10255055e-01f, 9.06912804e-01f, 1.32047176e-01f, -5.69273531e-02f, 4.50875610e-02f, -3.79526205e-02f,
  1.33337542e-01f, -1.50651649e-01f, 1.01983942e-01f, 2.06407726e-01f, 7.51213282e-02f, -1.60086597e-03f, 6.14888407e-02f, 1.38566896e-01f, 1.46714181e-01f, 1.82620659e-01f,
  7.41310194e-02f, 1.84458733e-01f, -1.28096253e-01f, 2.28576246e-03f, -1.07282452e-01f, 5.21428883e-02f, -1.44954041e-01f, -4.31189723e-02f, 1.88434064e-01f, -1.52238673e-02f,
  -4.19051200e-03f, 1.26673952e-01f, 1.27020821e-01f, 2.98702270e-01f, -1.01140156e-01f, -2.10360721e-01f, -1.76510707e-01f, -2.63094343e-02f, 1.38180301e-01f, -7.48802256e-03f,
  6.41791746e-02f, -1.37891546e-01f, -1.76830366e-01f, -1.16599031e-01f, 1.16578586e-01f, 6.82153329e-02f, 3.40287723e-02f, 1.56358927e-01f, 2.04032734e-02f, 2.42291987e-01f,
  -9.97765660e-02f, 4.15536091e-02f, -9.25848633e-03f, 1.21291103e-02f, 4.85938117e-02f, 5.46699539e-02f, 1.52371734e-01f, 2.00730879e-02f, -1.25600980e-03f, -1.11055955e-01f,
  1.78365454e-01f, -2.54839182e-01f, 1.35012241e-02f, -5.67561388e-03f, 8.05558462e-04f, 7.75507987e-02f, -6.40125349e-02f, 3.21469568e-02f, -4.28845100e-02f, -3.32052320e-01f,
  -2.43036244e-02f, -1.49939544e-02f, 4.16700020e-02f, -2.40160041e-02f, 8.62862468e-02f, 4.67354804e-02f, -4.58939038e-02f, -8.10496733e-02f, -2.04595014e-01f, -4.26097028e-02f,
  -1.93317413e-01f, 3.26770055e-03f, 6.19733445e-02f, 1.99386477e-01f, -3.82312089e-02f, 9.26579721e-03f, 1.53124034e-01f, -3.24925855e-02f, 4.37856093e-02f, -1.29442886e-01f,
  1.14749119e-01f, 8.27291142e-03f, -1.69614464e-01f, 1.54855192e-01f, 1.47564672e-02f, -4.24968749e-02f, -1.02065966e-01f, -1.36113120e-02f, -4.50750776e-02f, 1.69153214e-01f,
  1.36698872e-01f, 1.91122532e-01f, 1.21088624e-02f, -1.01218075e-01f, -4.99986336e-02f, 2.90688425e-02f, 7.57419392e-02f, -3.83018665e-02f, 1.04723327e-01f, 1.23990610e-01f,
  3.44126895e-02f, -1.75778061e-01f, -4.28823987e-03f, -1.81709960e-01f, 1.99403733e-01f, -4.97601442e-02f, 3.18230204e-02f, -6.94124997e-02f, -5.03321476e-02f, -7.68966079e-02f,
  -4.88473326e-02f, -7.00342953e-02f, 1.23909004e-01f, -8.32766816e-02f, -6.77924678e-02f, -1.98880017e-01f, 2.37482712e-01f, -9.41858888e-02f, -1.07215278e-01f, -1.29926726e-01f,
  -9.46596414e-02f, 1.32690206e-01f, -2.28893071e-01f, 4.58606631e-01f, 1.43490851e-01f, 9.55826193e-02f, 3.12538236e-01f, -1.03202447e-01f, -3.98315713e-02f, -8.31081867e-02f,
  9.03639793e-02f, 1.32830054e-01f, 1.17813632e-01f, 3.67625034e-03f, -4.24450748e-02f, 1.35075953e-02f, -1.01790847e-02f, 1.02064438e-01f, -2.26153567e-01f, 7.62209147e-02f,
  -7.24406540e-02f, -4.04120870e-02f, 4.93572466e-02f, 2.53998607e-01f, -1.89590156e-01f, 1.47868181e-02f, 6.15801625e-02f, 9.19364989e-02f, -1.19905442e-01f, 1.45190343e-01f,
  4.74330448e-02f, 1.11728646e-01f, -5.80363087e-02f, 4.21076454e-02f, -6.08889498e-02f, 7.07920045e-02f, 1.52007851e-03f, 1.39768288e-01f, 1.42502971e-02f, 1.75391823e-01f,
  -6.12698123e-02f, 1.84726622e-02f, 1.13100491e-01f, -2.15903819e-01f, 3.84333245e-02f, 2.49141440e-01f, -2.24311352e-01f, 1.95531115e-01f, -1.15163244e-01f, 5.37972301e-02f,
  8.24823231e-02f, 2.08340377e-01f, 5.86137995e-02f, 2.96073835e-02f, 2.12722182e-01f, -9.77587234e-03f, -8.82597789e-02f, -9.27597508e-02f, 9.34536234e-02f, 2.16133296e-01f,
  -1.24318950e-01f, -6.17749728e-02f, 1.62613884e-01f, 1.31784286e-02f, -5.07152826e-03f, 7.25517645e-02f, 2.40167454e-01f, -6.03120089e-01f, 1.80794541e-02f, 1.29689975e-02f,
  5.89247942e-02f, -7.31638521e-02f, 1.08815350e-01f, -7.47200325e-02f, -2.74560209e-02f, -1.96770519e-01f, 1.89510822e-01f, -3.39375101e-02f, -2.00028852e-01f, -1.14299931e-01f,
  1.23500369e-01f, -6.46262020e-02f, 6.93981349e-02f, 4.29309867e-02f, 2.57232010e-01f, -3.94009799e-02f, 2.05969229e-01f, -2.82429606e-01f, 2.19059214e-01f, -1.63116634e-01f,
  -1.11189276e-01f, 4.56725806e-02f, 1.48953468e-01f, 1.47187114e-01f, 6.09348528e-03f, 3.53083611e-02f, 6.54910281e-02f, -2.73412522e-02f, -8.30418095e-02f, 4.57054563e-02f,
  -2.31680088e-02f, -5.28714284e-02f, -2.12528799e-02f, 1.42843366e-01f, 1.31214857e-01f, 1.46048874e-01f, -5.26383035e-02f, 7.82204419e-02f, 1.66570693e-01f, -9.29163769e-02f,
  -2.05575645e-01f, 7.30852634e-02f, 5.53377159e-03f, 2.55419761e-01f, 2.25371912e-01f, 1.15249842e-01f, 9.11287665e-02f, 8.24972615e-02f, 1.08044282e-01f, -3.56624238e-02f,
  2.06547752e-01f, -1.48013681e-01f, -4.76418696e-02f, -2.21284665e-02f, 1.37674704e-01f, -4.28934395e-03f, -4.15993817e-02f, -1.57312766e-01f, -1.12717107e-01f, 1.98377281e-01f,
  2.38107026e-01f, -8.41296613e-01f, -5.65428250e-02f, 1.57585546e-01f, 2.25126266e-01f, 4.96138483e-02f, 2.00704336e-01f, 2.36996368e-01f, -1.17094226e-01f, -2.10841615e-02f,
  2.44113848e-01f, -1.14306226e-01f, -8.94489884e-02f, -2.40411505e-01f, -4.92660962e-02f, -2.23068669e-01f, -2.46918015e-03f, -7.64001906e-02f, 2.53170311e-01f, 8.48660097e-02f,
  1.88259304e-01f, -1.43242434e-01f, 1.27135932e-01f, -1.01052508e-01f, 1.28417313e-01f, 1.93588093e-01f, -8.30790401e-02f, 1.14625171e-01f, -7.02634230e-02f, -1.19750768e-01f,
  3.39486063e-01f, 1.36559770e-01f, -3.33958752e-02f, 1.54118985e-01f, -5.07745370e-02f, 1.09524556e-01f, 3.96119952e-02f, 8.98173153e-02f, 1.21229598e-02f, 7.49412328e-02f,
  9.64682028e-02f, -1.72913462e-01f, 2.02283517e-01f, -5.04484326e-02f, -1.54446706e-01f, 1.22827671e-01f, -1.35631666e-01f, 9.08898637e-02f, 2.76637703e-01f, 2.90217608e-01f,
  -3.74648944e-02f, 5.45129320e-03f, 2.02443246e-02f, -1.00552380e-01f, 5.50110489e-02f, -5.66463284e-02f, 1.01182289e-01f, -1.19918257e-01f, -1.07072219e-01f, 1.19406199e-02f,
  1.20953172e-01f, 6.82570320e-03f, 7.27406591e-02f, 6.50941953e-02f, 1.23822339e-01f, -3.21673304e-01f, 7.81504065e-02f, 1.83004260e-01f, -8.99467804e-03f, -3.03837676e-02f,
  3.03891543e-02f, 1.81548804e-01f, -2.53435802e-02f, -1.10238776e-01f, 1.27445221e-01f, 1.14871390e-01f, -1.48045212e-01f, -2.42735386e-01f, 5.42143956e-02f, -2.07667470e-01f,
  -8.17314684e-02f, 2.08583567e-02f, 1.10578246e-01f, -7.81325251e-02f, 2.50739574e-01f, -2.06219018e-01f, 7.87519738e-02f, 5.89590296e-02f, -1.05450585e-01f, 1.57049373e-01f,
  2.09070686e-02f, -1.59945562e-02f, 8.65010619e-02f, -1.60659298e-01f, 4.67753075e-02f, 2.78895140e-01f, 7.10165501e-02f, 2.17877790e-01f, 2.70910077e-02f, -1.93793401e-02f,
  2.45471634e-02f, -6.98938966e-02f, -3.89887355e-02f, -9.45890695e-02f, 1.97126597e-01f, 7.48620480e-02f, 2.49313265e-01f, 3.29582468e-02f, 2.89496601e-01f, 1.30584434e-01f,
  -1.45503372e-01f, -1.40703306e-01f, 1.91685572e-01f, 6.15427606e-02f, 4.18977886e-02f, 3.64177227e-02f, -2.42025852e-02f, 7.23101795e-02f, 1.58874556e-01f, -5.07266968e-02f,
  2.23339632e-01f, -2.01567650e-01f, 1.77038852e-02f, 2.17646416e-02f, 2.18131080e-01f, 1.34213641e-01f, -2.57854193e-01f, 8.47720876e-02f, 5.64770326e-02f, -3.30105461e-02f,
  2.75107265e-01f, 4.39607427e-02f, -8.84082019e-02f, 7.07160756e-02f, -3.65861915e-02f, 7.51420110e-02f, -2.39999257e-02f, -1.24212794e-01f, -1.18631788e-01f, 3.96003276e-02f,
  -2.42064949e-02f, 5.01818471e-02f, 1.88425258e-01f, 2.94261184e-02f, 8.38344172e-02f, -1.06909215e-01f, 1.31289452e-01f, -3.58294919e-02f, -3.26056518e-02f, 2.57293954e-02f,
  1.85160249e-01f, 7.84272775e-02f, -1.15440667e-01f, -1.05398737e-01f, 9.07012224e-02f, 1.29122585e-01f, 1.96354836e-01f, -1.00749791e-01f, -1.26972422e-01f, -7.06063956e-02f,
  1.00123063e-01f, 2.44162649e-01f, -9.72164273e-02f, 5.27612828e-02f, -1.08072862e-01f, -1.76602136e-02f, -1.18076866e-02f, -5.64313941e-02f, -6.44080415e-02f, -6.21269196e-02f,
  -1.00542046e-01f, -6.56181201e-02f, -9.10886563e-03f, -7.95787200e-02f, -1.22913107e-01f, 8.70234296e-02f, -1.11829743e-01f, -5.36182858e-02f, 4.33156192e-02f, 1.04028508e-02f,
  2.20216382e-02f, 2.04854608e-02f, 2.19236538e-02f, 1.09535575e-01f, -1.09254748e-01f, 8.81091058e-02f, -6.00820556e-02f, -1.66501701e-02f, 6.13754168e-02f, 1.06127381e-01f,
  1.18968241e-01f, 1.96605530e-02f, 9.81847271e-02f, 8.46231580e-02f, -1.27717823e-01f, -7.36524910e-02f, 3.06221191e-04f, -1.37231015e-02f, 2.63652466e-02f, 2.04139156e-03f,
  -7.61140808e-02f, -4.01124805e-02f, 1.05919376e-01f, 1.51215401e-02f, -1.30383242e-02f, 7.77726108e-03f, -7.57213384e-02f, -6.11778088e-02f, -9.16069448e-02f, -9.88151655e-02f,
  -8.84158686e-02f, 5.90722710e-02f, -9.12951902e-02f, -3.54109854e-02f, -7.06165284e-02f, 1.00986190e-01f, 1.74053293e-02f, -1.21922165e-01f, -1.15492612e-01f, -5.67178130e-02f,
  -5.97450919e-02f, -7.26715997e-02f, 6.28378987e-02f, 8.04413110e-02f, 7.28934482e-02f, 5.94039969e-02f, -7.02067316e-02f, 1.01756148e-01f, -3.35402712e-02f, 6.79057389e-02f,
  -9.37411264e-02f, 4.92881425e-02f, 2.51509203e-03f, 5.17711043e-02f, -6.95774555e-02f, -5.91752306e-02f, 3.68250092e-03f, 3.31706703e-02f, -1.45396739e-02f, 5.49967252e-02f,
  3.62680182e-02f, 9.75640640e-02f, 5.45084998e-02f, -1.02985695e-01f, -9.58139300e-02f, 2.10877657e-02f, -8.44901800e-02f, 5.09251282e-02f, 4.63286154e-02f, 4.26409692e-02f,
  9.55955237e-02f, 4.22844514e-02f, -8.56411457e-02f, -8.08743387e-02f, -2.56578606e-02f, 3.04289861e-03f, -2.12392304e-02f, 9.32860672e-02f, 3.78751382e-02f, -8.44562426e-02f,
  9.33553055e-02f, -1.10069595e-01f, -2.40290165e-02f, -1.13455243e-01f, 3.77497822e-02f, 5.32264486e-02f, 1.05810389e-01f, 9.00665745e-02f, -1.17120966e-01f, 6.47319704e-02f,
  -1.27060965e-01f, 3.76344682e-03f, -5.48642650e-02f, -3.57617694e-03f, -1.13599896e-01f, -1.05725989e-01f, -1.03723578e-01f, -1.05086058e-01f, -1.26273051e-01f, -1.05216898e-01f,
  6.59631267e-02f, -6.71180934e-02f, 1.08919933e-01f, 5.53211197e-02f, -3.18704173e-03f, -1.23813666e-01f, 1.06658973e-01f, -3.15069407e-02f, 1.54835582e-02f, -1.27477407e-01f,
  -9.13184416e-03f, 4.99338806e-02f, 1.56545620e-02f, -1.38095170e-01f, 1.31664380e-01f, 2.54586022e-02f, 2.79881656e-01f, 5.59196509e-02f, -1.03313278e-03f, -2.13736385e-01f,
  -9.71201584e-02f, -1.90404281e-02f, -8.80299658e-02f, 1.34516761e-01f, 1.11770190e-01f, 1.52083233e-01f, -9.18117538e-02f, -2.31302828e-02f, -1.47192879e-02f, 2.38655973e-02f,
  8.26389343e-02f, 9.24586356e-02f, 9.87777859e-02f, -2.95382977e-01f, 4.22405219e-03f, 1.19640706e-02f, 2.50719916e-02f, 1.74022540e-02f, -1.02446452e-01f, 3.49290483e-03f,
  -1.54575005e-01f, -1.09791674e-01f, 4.65682754e-03f, 9.04601663e-02f, 1.92326054e-01f, 1.09090209e-01f, 1.75854400e-01f, 1.34276897e-01f, 8.94769188e-03f, 1.22739121e-01f,
  1.50353834e-01f, -8.01837444e-02f, 3.01317349e-02f, -1.04021579e-01f, -1.58583343e-01f, 1.64416358e-01f, -1.11032285e-01f, -1.31081501e-02f, 8.53873342e-02f, 1.51783153e-02f,
  -5.55750653e-02f, 1.50643215e-01f, -5.33647761e-02f, 1.31921440e-01f, 8.30507874e-02f, -6.31100684e-02f, -3.47577669e-02f, -1.50726736e-01f, 9.92538687e-03f, -1.07300438e-01f,
  2.75850445e-02f, -2.09126789e-02f, 1.20338358e-01f, 1.14407599e-01f, 2.41569411e-02f, -7.20357746e-02f, 7.37259537e-02f, 1.48264483e-01f, 1.52514935e-01f, 1.44451514e-01f,
  -2.84973502e-01f, 2.84830444e-02f, -1.87868103e-01f, -1.71912551e-01f, 4.34584022e-02f, -3.04072052e-01f, 2.85625517e-01f, 2.70124584e-01f, -8.86913761e-02f, -2.64078349e-01f,
  2.37180635e-01f, -9.80368629e-02f, -1.06787555e-01f, -3.14841792e-02f, 3.15289833e-02f, 2.05494300e-01f, -1.90697014e-01f, 1.01773709e-01f, 1.27418578e-01f, -4.71575372e-02f,
  -1.08800763e-02f, -6.80278838e-02f, 2.40649283e-01f, -7.81524107e-02f, -2.34683603e-01f, 7.04427361e-01f, -4.14990913e-03f, -1.45425454e-01f, 7.99390823e-02f, 2.18537137e-01f,
  3.77169177e-02f, 1.75795734e-01f, 1.38815343e-01f, 2.01398090e-01f, 1.73197672e-01f, 1.40586949e-03f, 2.37212688e-01f, 2.71947891e-01f, -7.65275806e-02f, 2.49361601e-02f,
  1.83355473e-02f, 1.47855729e-01f, -1.42730534e-01f, 9.58879814e-02f, 8.22288096e-02f, 2.23229490e-02f, -1.41414151e-01f, 2.25735068e-01f, 2.29416654e-01f, 2.31559440e-01f,
  9.63965654e-02f, -1.79175973e-01f, 1.78428382e-01f, 1.48162603e-01f, 1.03155084e-01f, 9.46838930e-02f, -8.62726867e-02f, -1.11998931e-01f, 4.51032631e-02f, 1.23449318e-01f,
  1.27592906e-01f, 1.61800608e-01f, 2.27687180e-01f, 1.25066295e-01f, -8.05830508e-02f, -4.09155786e-02f, -3.90323400e-02f, 1.74085915e-01f, -2.45439842e-01f, 2.45931577e-02f,
  1.66470170e-01f, 1.02838054e-01f, 6.96627945e-02f, 1.28610969e-01f, 1.84632003e-01f, 2.11987227e-01f, -8.96432102e-02f, 1.12007260e-01f, 1.79991364e-01f, 8.47205520e-02f,
  1.48760621e-03f, 2.24282756e-01f, -1.60876680e-02f, -1.05387881e-01f, -1.95761144e-01f, -1.57776296e-01f, -2.81890389e-02f, -6.25717593e-03f, 5.94680272e-02f, -2.78007895e-01f,
  1.34750098e-01f, 6.87162112e-03f, 3.52082290e-02f, 1.53129131e-01f, 5.88166900e-02f, 3.22020203e-02f, 1.28543600e-01f, 3.20994994e-03f, 1.13572165e-01f, -1.19793512e-01f,
  -3.72953638e-02f, -2.07246304e-01f, 1.27883861e-02f, -1.28123581e-01f, 2.34741703e-01f, 1.18240854e-02f, 4.10127677e-02f, -8.21543634e-02f, 2.27984443e-01f, -7.85142481e-02f,
  -9.60754754e-04f, 1.22060999e-02f, -8.81448984e-02f, 1.33008631e-02f, 5.16057648e-02f, 3.50892544e-02f, 1.54522851e-01f, -5.14820963e-02f, 6.54480532e-02f, 7.20397085e-02f,
  2.20992938e-02f, -6.93549290e-02f, 2.00451076e-01f, 6.01877784e-03f, 2.95409560e-03f, 4.52821935e-03f, 2.96428185e-02f, 1.29341558e-01f, 1.83771133e-01f, -1.33873105e-01f,
  1.19075850e-01f, 4.63116765e-02f, 2.89497614e-01f, 1.30741477e-01f, -1.27067134e-01f, -1.00514807e-01f, -9.74016562e-02f, 1.49466112e-01f, -1.54505828e-02f, -2.27625035e-02f,
  5.56720980e-02f, -1.34821266e-01f, -1.13731302e-01f, 1.46957278e-01f, 4.62362207e-02f, -2.54305959e-01f, -1.20364139e-02f, -4.95427810e-02f, 3.03734899e-01f, 2.62435824e-01f,
  -7.00847879e-02f, -1.46931037e-01f, 1.96189545e-02f, 3.11562240e-01f, 5.57198077e-02f, -1.68325976e-01f, -1.67829424e-01f, 1.62904039e-01f, -3.58332433e-02f, 1.95071489e-01f,
  5.01971059e-02f, 1.47526726e-01f, -1.30801544e-01f, 4.55145203e-02f, 1.31326243e-01f, 9.22747180e-02f, 9.06756222e-02f, 1.42645314e-01f, -9.13485978e-03f, 6.12930320e-02f,
  -3.35944742e-02f, -7.33710304e-02f, -1.25511605e-02f, 7.63336197e-02f, 7.84309134e-02f, 1.24028221e-01f, -1.39156371e-01f, 7.41750747e-02f, 3.22032012e-02f, 3.09633892e-02f,
  9.36229900e-02f, -9.37248692e-02f, -2.01224521e-01f, -2.60350318e-03f, 1.21188574e-01f, 1.84455290e-01f, 1.03623502e-01f, 1.18712515e-01f, 1.50080293e-01f, -1.85409170e-02f,
  -1.24267330e-02f, 1.62252173e-01f, -2.36101579e-02f, 7.67068192e-02f, 2.19816610e-01f, -2.57268637e-01f, -2.50775993e-01f, -7.39437714e-03f, 1.22643881e-01f, 2.23223269e-02f,
  2.41861474e-02f, 1.45865321e-01f, -1.15170337e-01f, -3.89957130e-02f, -1.10827655e-01f, -4.74057645e-02f, -5.17237149e-02f, -7.05412179e-02f, 3.89642380e-02f, 1.39994979e-01f,
  -7.55619034e-02f, -4.55882885e-02f, -1.02473453e-01f, -3.47147733e-02f, -7.38304779e-02f, 2.17249915e-01f, 1.53294519e-01f, -7.18276441e-01f, -4.05076221e-02f, -8.68136808e-02f,
  -5.43758795e-02f, -1.52430367e-02f, 1.67386442e-01f, 4.32523303e-02f, -1.92593470e-01f, 6.43362179e-02f, -5.11951894e-02f, -1.17845431e-01f, 4.37074415e-02f, -2.85341114e-01f,
  1.63132533e-01f, -2.72989124e-01f, 2.15932533e-01f, 9.02547389e-02f, 2.91432161e-02f, -2.81504095e-02f, 9.96615663e-02f, -1.28391251e-01f, 1.47436827e-01f, 1.06664546e-01f,
  1.03701085e-01f, -6.81840777e-02f, -8.63429382e-02f, -1.22008368e-01f, 1.79233953e-01f, 1.23645090e-01f, 2.25997403e-01f, 1.87245488e-01f, -2.01043729e-02f, -4.48779203e-02f,
  -1.19314224e-01f, 5.49358167e-02f, 2.40678281e-01f, 5.15686683e-02f, -8.82439166e-02f, -3.62581871e-02f, 1.39893174e-01f, 3.47521067e-01f, 1.82782039e-01f, -2.49574892e-02f,
  1.81055576e-01f, 6.26616850e-02f, 1.06223047e-01f, -4.91230227e-02f, 5.71352057e-03f, 1.10372074e-01f, 5.76068014e-02f, -1.90287352e-01f, -2.74623539e-02f, -2.95276865e-02f,
  1.65752366e-01f, 2.31856674e-01f, 1.08172879e-01f, -5.82136437e-02f, 1.36348054e-01f, 8.98734629e-02f, 9.58171114e-02f, 1.40905738e-01f, -9.76314098e-02f, 2.24579990e-01f,
  1.51874304e-01f, 2.65352935e-01f, 2.54981667e-01f, -1.04773827e-01f, 2.40147673e-02f, -5.89550771e-02f, -1.75302848e-01f, -2.05265209e-01f, -3.25496495e-02f, 8.30123797e-02f,
  2.16387555e-01f, -1.57554299e-01f, 2.59900987e-01f, 2.34667346e-01f, 2.14942247e-01f, 1.78485632e-01f, 8.20438340e-02f, 2.29559138e-01f, 2.17557829e-02f, 5.42608351e-02f,
  -7.38681182e-02f, 6.04331605e-02f, 1.22576989e-01f, -8.53198767e-02f, 2.98033416e-01f, -1.11340709e-01f, -5.84031753e-02f, 2.51692146e-01f, -1.08721398e-03f, 1.89115047e-01f,
  2.15649903e-02f, -2.71315515e-01f, -3.20874661e-01f, -3.17724161e-02f, 8.26951023e-03f, 2.39291728e-01f, 6.23779409e-02f, 1.98840216e-01f, 1.64764732e-01f, -9.59206969e-02f,
  5.90708628e-02f, -2.70649731e-01f, 9.34708565e-02f, 1.25146508e-01f, -1.22433797e-01f, -9.62058380e-02f, 9.93225053e-02f, 2.10480131e-02f, 9.77505818e-02f, 2.14828074e-01f,
  8.23248476e-02f, 3.19912553e-01f, -1.79260358e-01f, 9.40002874e-02f, 1.00895524e-01f, 6.06348030e-02f, -3.89550067e-02f, 1.36127993e-01f, -1.47327021e-01f, -2.15915609e-02f,
  -1.65622100e-01f, -7.37697855e-02f, -6.38141260e-02f, 1.52603853e-02f, 2.03642815e-01f, -1.42120510e-01f, 1.39989510e-01f, 2.22347096e-01f, 5.06782643e-02f, 7.83877671e-02f,
  -2.45488822e-01f, -7.32131228e-02f, 1.44384548e-01f, 3.43895480e-02f, -1.78794507e-02f, -7.65419081e-02f, -5.92806526e-02f, -1.38903549e-02f, 6.21420937e-03f, -6.88694417e-02f,
  8.05482501e-04f, 5.61449789e-02f, 1.86272375e-02f, -5.64803816e-02f, 2.37626448e-01f, 8.77733305e-02f, -6.63287472e-03f, -1.81880280e-01f, 1.52188204e-02f, -1.76069245e-01f,
  -1.14953957e-01f, -5.82202859e-02f, 3.67596745e-02f, 6.90231621e-02f, 2.54357845e-01f, 5.65539859e-02f, -1.89172868e-02f, -3.62151936e-02f, 2.40730524e-01f, -1.63484104e-02f,
  -9.15838107e-02f, -1.54973492e-01f, -4.98227142e-02f, 2.72316206e-02f, -1.69807598e-01f, -1.64110094e-01f, -3.75051424e-02f, -1.54984921e-01f, 9.07686912e-03f, -9.23030674e-02f,
  -1.92093570e-02f, 1.85457528e-01f, -3.13972346e-02f, -9.22309682e-02f, 7.41249397e-02f, -2.31356621e-02f, 1.78171381e-01f, 9.79738217e-03f, 1.17313620e-02f, -3.25607210e-02f,
  -1.92139503e-02f, 4.20175754e-02f, 1.06589742e-01f, 3.74729373e-02f, 1.65667996e-01f, -1.41139209e-01f, 1.83464736e-01f, -1.40512347e-01f, -9.75077003e-02f, 9.25578833e-01f,
  -2.22809445e-02f, -1.76251680e-01f, 1.02961540e-01f, 1.24083661e-01f, 2.04093963e-01f, 1.41021520e-01f, 1.27623811e-01f, 5.93067333e-02f, -1.17265977e-01f, 8.83679688e-02f,
  9.79301333e-02f, 2.03115895e-01f, -2.71502067e-03f, 1.39454633e-01f, -4.63839360e-02f, 1.49371549e-01f, -1.36530384e-01f, 1.33135259e-01f, -1.33896405e-02f, 1.61814481e-01f,
  2.08499189e-02f, 2.43690997e-01f, 1.35361329e-01f, 3.10007483e-01f, 3.43696550e-02f, -2.54863262e-01f, -1.35758556e-02f, 1.00287370e-01f, 2.04920769e-03f, 1.78295568e-01f,
  2.80150175e-01f, -4.04006392e-02f, -1.34411260e-01f, -1.16734728e-01f, 1.95103996e-02f, -4.06354740e-02f, -1.42097935e-01f, -4.45135757e-02f, -1.01652555e-01f, -5.65676112e-03f,
  1.08584896e-01f, -1.33895352e-02f, -2.47500073e-02f, -2.36815456e-02f, -8.13730732e-02f, -1.11975320e-01f, -2.59527173e-02f, -5.95136955e-02f, 2.51645744e-02f, 3.28296944e-02f,
  3.98527719e-02f, -5.26754707e-02f, 8.88680443e-02f, -1.00009836e-01f, -1.23256385e-01f, 6.49711043e-02f, -3.45399939e-02f, 1.04206949e-01f, 1.72201935e-02f, 3.94436829e-02f,
  -7.05368370e-02f, -7.68133551e-02f, -2.96340697e-02f, 1.04873277e-01f, 7.83055425e-02f, -3.63622606e-03f, 2.67599500e-03f, 9.77700502e-02f, 4.56764251e-02f, 2.97785681e-02f,
  5.36901467e-02f, 9.82393026e-02f, -1.20825037e-01f, -3.41787152e-02f, 3.72361317e-02f, -1.21564880e-01f, 4.87529263e-02f, 7.28548393e-02f, -7.96739310e-02f, 6.75824424e-03f,
  6.56317621e-02f, 6.91705644e-02f, -1.64776575e-02f, -1.42935425e-01f, -6.75280839e-02f, 8.90568793e-02f, 4.70073149e-02f, 1.00830197e-01f, -1.22621298e-01f, -2.45187171e-02f,
  -1.30350709e-01f, -1.01737708e-01f, -9.72824544e-03f, -1.77565217e-02f, -1.24110430e-01f, 6.54946864e-02f, -1.29678592e-01f, 2.15945318e-02f, -1.86425790e-01f, -1.86743110e-01f,
  -4.92785349e-02f, -1.70053497e-01f, 4.48964387e-02f, 1.91997826e-01f, 1.74184963e-01f, -2.06946760e-01f, 3.94740254e-02f, 1.52346224e-01f, 9.13703367e-02f, 1.59943029e-01f,
  1.30230635e-01f, 4.87684198e-02f, -2.15611026e-01f, -1.23225667e-01f, 2.18780711e-01f, 7.39310905e-02f, 8.86697844e-02f, 6.72826692e-02f, 1.56487018e-01f, 1.74209569e-02f,
  -2.78437342e-02f, 6.88768476e-02f, 1.08387366e-01f, 1.20576909e-02f, 1.42896056e-01f, 2.26585362e-02f, 1.43435121e-01f, 3.41557324e-01f, -1.94550566e-02f, -2.39406805e-02f,
  -5.50960600e-02f, -1.67569160e-01f, -8.40356108e-03f, 9.74365473e-02f, -1.53903201e-01f, -1.34086102e-01f, 1.25253737e-01f, 3.11879609e-02f, 1.67604357e-01f, -2.09594816e-02f,
  1.41860813e-01f, 6.80483952e-02f, -1.20162487e-01f, -1.34261400e-01f, 7.34664649e-02f, 5.55407442e-02f, -5.15047647e-03f, -1.13053121e-01f, 7.38407373e-02f, 6.70738220e-02f,
  6.58746436e-02f, -1.97745506e-02f, -6.18092604e-02f, -3.98064451e-03f, 5.50927706e-02f, 8.47333577e-03f, 1.79085255e-01f, 5.10085560e-03f, -1.11684009e-01f, 2.11561218e-01f,
  7.09051788e-02f, -1.36744240e-02f, 2.17750613e-02f, 1.39263235e-02f, 2.74264663e-02f, -4.23638374e-02f, 8.09441209e-02f, 1.58450320e-01f, 1.22074552e-01f, -2.64393687e-01f,
  -6.94390014e-02f, -1.02165148e-01f, -1.03922719e-02f, 1.81694955e-01f, 3.21491569e-01f, 2.37251475e-01f, -5.98606393e-02f, 2.99898863e-01f, 4.75964658e-02f, 3.14067006e-02f,
  2.38522351e-01f, -7.40997866e-02f, -2.85432562e-02f, -6.93270415e-02f, 1.86524913e-01f, -1.50963487e-02f, -2.47684475e-02f, -4.33304645e-02f, -5.41137345e-02f, 2.12312996e-01f,
  5.53668030e-02f, -9.14420858e-02f, 4.81370650e-02f, 3.30576718e-01f, 2.99284339e-01f, 1.55382395e-01f, 9.15620998e-02f, 6.62296340e-02f, 8.30996111e-02f, 5.42543940e-02f,
  2.05448493e-01f, -7.87772238e-02f, 9.61311609e-02f, -9.44766700e-02f, -1.63839623e-01f, 3.28236781e-02f, -1.58977598e-01f, -5.50149754e-02f, 1.94885284e-01f, 1.29269725e-02f,
  2.28283778e-01f, 1.40531793e-01f, 5.02650451e-04f, -8.80170241e-02f, 1.54185206e-01f, -2.80723330e-02f, -2.25887626e-01f, -1.08200451e-02f, -3.68726104e-02f, -1.94019347e-01f,
  2.80855536e-01f, 9.03341472e-02f, -5.68451844e-02f, 5.64884432e-02f, 1.85550272e-01f, -9.75325704e-02f, 2.86038537e-02f, -1.40702017e-02f, -1.03532178e-02f, 3.04738525e-02f,
  -1.72251478e-01f, -4.53615151e-02f, -2.18973085e-01f, -3.83002795e-02f, 9.22553167e-02f, -2.45828390e-01f, -3.04409042e-02f, -1.55342743e-02f, -1.66914627e-01f, -7.15957880e-02f,
  2.37669513e-01f, 1.96859181e-01f, 1.46543384e-01f, 6.02167770e-02f, -5.57280332e-02f, 1.42888501e-01f, -1.39452726e-01f, 1.35951340e-01f, 2.76833475e-02f, 6.81986734e-02f,
  5.83128780e-02f, -1.72875017e-01f, 3.91725339e-02f, -1.83683679e-01f, -4.28873412e-02f, 7.66484618e-01f, -1.31794348e-01f, -2.22897738e-01f, -3.83735076e-02f, 1.19505242e-01f,
  -4.59875949e-02f, 9.93024558e-02f, 1.36628047e-01f, 1.94771722e-01f, -1.49229005e-01f, 7.25457817e-02f, 1.45340726e-01f, -1.75223947e-02f, 9.92725268e-02f, -1.35405228e-01f,
  8.24782252e-02f, 1.68734074e-01f, -1.02746978e-01f, 5.03651751e-03f, 1.17616959e-01f, 1.07783161e-01f, -3.93887796e-02f, 1.29015520e-01f, -1.91710331e-02f, 1.35572284e-01f,
  1.07114941e-01f, -1.19844496e-01f, 1.92339033e-01f, 1.08501285e-01f, 3.02024242e-02f, 1.60368472e-01f, 1.41221657e-01f, 6.93106055e-02f, 3.44588831e-02f, -1.77957267e-01f,
  -7.12288404e-03f, -4.36853059e-02f, -7.48532787e-02f, -1.86929241e-01f, 1.53802902e-01f, 3.98701206e-02f, 1.03983521e-01f, -4.47204970e-02f, -8.35628733e-02f, -9.11335275e-02f,
  -5.02748694e-03f, 3.75828817e-02f, 1.32945269e-01f, 9.39387605e-02f, -1.19072333e-01f, -6.01858227e-03f, 2.41309851e-02f, -5.55617958e-02f, 5.40206879e-02f, -2.52938777e-01f,
  1.48472376e-02f, -3.42477053e-01f, 8.29365328e-02f, -1.00408897e-01f, -1.11747697e-01f, -1.92761049e-01f, -2.00562194e-01f, -7.13518262e-02f, 4.95247990e-02f, 5.31281292e-01f,
  7.22641945e-02f, -1.81918249e-01f, 1.00639261e-01f, -2.60092504e-02f, 3.42409313e-02f, 1.09296717e-01f, -3.47967744e-02f, -2.30657961e-02f, 1.96375903e-02f, 1.63421314e-02f,
  2.54507363e-02f, -2.46472415e-02f, -1.34156710e-02f, 1.09320618e-01f, -1.14351511e-02f, -1.27115622e-01f, 5.46148121e-02f, -7.91562200e-02f, 1.54551074e-01f, -1.14703989e-02f,
  -1.10663027e-01f, -5.19245006e-02f, -4.26188894e-02f, 5.82464784e-02f, 1.19982183e-03f, -6.82691708e-02f, 7.97822699e-02f, -2.21985325e-01f, -3.99905331e-02f, 1.67930812e-01f,
  9.41990092e-02f, 8.42150301e-03f, 1.68258771e-01f, 1.79233421e-02f, -1.20098218e-01f, 6.72246367e-02f, 2.29006130e-02f, 7.47633874e-02f, 4.02928367e-02f, -2.50696331e-01f,
  6.44501001e-02f, -8.46883208e-02f, 2.44452022e-02f, 1.07375577e-01f, -9.35490504e-02f, 2.59818044e-02f, 6.16476359e-03f, 7.64699653e-02f, -7.68582895e-02f, 2.35195346e-02f,
  1.51102496e-02f, -1.41365334e-01f, 9.91801992e-02f, -2.61832122e-02f, 5.08683361e-02f, 5.51471580e-03f, -1.92860529e-01f, 5.15310429e-02f, 9.60162207e-02f, 2.90627759e-02f,
  -1.17197685e-01f, 6.70113564e-02f, 1.54290736e-01f, -8.50376487e-02f, -1.53106734e-01f, -8.19072593e-03f, 1.56985205e-02f, 1.17685681e-03f, -8.24123546e-02f, 1.54092804e-01f,
  5.89277260e-02f, -1.74619094e-03f, -1.39208645e-01f, -6.14357442e-02f, -3.08749583e-02f, 9.31843594e-02f, 1.59169346e-01f, -2.13448238e-02f, 1.48882747e-01f, -8.20827261e-02f,
  8.61356109e-02f, 9.97959003e-02f, 2.04787463e-01f, -1.65730283e-01f, 2.31101856e-01f, 1.14500076e-01f, -9.63873789e-02f, -2.05876697e-02f, 4.38852273e-02f, -1.97910026e-01f,
  1.89744264e-01f, -1.11746378e-01f, 9.73837152e-02f, 2.25733265e-01f, 9.79668275e-02f, 3.88054475e-02f, 1.18780568e-01f, -6.70682453e-03f, 6.07972629e-02f, 1.26564264e-01f,
  2.11537018e-01f, 8.60088598e-03f, -1.25014275e-01f, -2.72756875e-01f, -7.42068291e-02f, 1.57968402e-01f, 2.53859609e-01f, 1.03178196e-01f, -1.31557360e-01f, -1.24605723e-01f,
  -1.28894495e-02f, 3.56001258e-02f, 8.28324929e-02f, -3.54658440e-02f, 2.86843807e-01f, 8.66643190e-02f, -3.96071747e-02f, -6.23598918e-02f, -6.61643222e-03f, 4.69023623e-02f,
  -1.57501847e-01f, 3.72374095e-02f, 2.18568191e-01f, 1.20311333e-02f, -2.72117611e-02f, -1.74181774e-01f, -5.88483512e-02f, 2.03724116e-01f, 5.48332334e-02f, 8.08529109e-02f,
  -1.64537951e-01f, -5.46262264e-02f, 2.01532319e-02f, 1.03204362e-02f, 1.98795915e-01f, 1.14590548e-01f, -2.45677665e-01f, 2.98716486e-01f, -1.01230651e-01f, 1.07475623e-01f,
  1.79395601e-01f, 7.03071356e-02f, 6.29870454e-03f, -5.10464795e-02f, -9.82152149e-02f, -2.41980515e-02f, -6.90255612e-02f, -7.15938359e-02f, 1.23981990e-01f, 1.69125363e-01f,
  -8.50576535e-03f, 1.49792641e-01f, 3.01089823e-01f, -1.12342171e-01f, 1.70208231e-01f, -1.02049828e-01f, -3.73890512e-02f, 1.07505403e-01f, 2.48386651e-01f, 1.50160238e-01f,
  -8.87282752e-03f, 2.22019479e-01f, 1.20526612e-01f, 1.70579404e-01f, 2.13184372e-01f, 1.56913266e-01f, -2.54577309e-01f, -6.95412979e-02f, -1.62519366e-01f, 1.92062050e-01f,
  -1.91077650e-01f, 5.56300357e-02f, 7.25994259e-02f, 1.78856432e-01f, -4.08873260e-02f, 1.50185544e-02f, 1.07652254e-01f, 8.57035145e-02f, -9.31518748e-02f, 4.01893770e-03f,
  1.17801555e-01f, -5.39096296e-02f, -8.32466334e-02f, 3.47742200e-01f, -8.74657556e-03f, -2.41149087e-02f, -9.27231237e-02f, -5.42733073e-02f, 3.33097689e-02f, -5.61543107e-02f,
  4.68868949e-03f, -3.41065198e-01f, -1.68233678e-01f, 6.78784549e-02f, 4.12159748e-02f, 2.52942622e-01f, 2.41510063e-01f, 1.96247771e-01f, 7.93614462e-02f, 9.14139021e-03f,
  1.04529008e-01f, 1.80330709e-01f, -6.35465309e-02f, -2.27882676e-02f, 2.38381745e-03f, -1.91223800e-01f, 1.26879945e-01f, -8.34833179e-03f, -5.57686761e-03f, 1.51824877e-02f,
  6.80845976e-02f, 4.61756624e-02f, 1.13858923e-01f, 5.63517921e-02f, 6.95052445e-02f, 1.45441234e-01f, 1.93172053e-01f, 2.02481132e-02f, -5.90061620e-02f, 8.84756446e-02f,
  2.40113810e-01f, 6.04931172e-03f, 1.55938134e-01f, -1.10257469e-01f, -9.88558158e-02f, -9.90642160e-02f, -6.40155077e-02f, 3.72336954e-02f, 1.02209553e-01f, -2.99297720e-02f,
  -5.51393442e-03f, -4.68317680e-02f, 1.04654625e-01f, -4.53247726e-02f, 5.03770076e-02f, -1.98242478e-02f, -6.39304742e-02f, -1.08372316e-01f, -6.13499247e-02f, -1.28291056e-01f,
  9.71854925e-02f, 8.17806125e-02f, -1.21864997e-01f, 4.72311452e-02f, -6.05846941e-02f, -9.25460756e-02f, 1.93623919e-02f, -8.98558125e-02f, -1.11375391e-01f, -5.26402891e-03f,
  9.58461687e-02f, 9.70679820e-02f, -4.21337485e-02f, 2.94670300e-03f, 3.80637497e-02f, -1.17912591e-01f, -1.27304137e-01f, -3.15683857e-02f, 1.00083813e-01f, -9.62545350e-03f,
  -3.09772938e-02f, 9.09390524e-02f, -7.58097395e-02f, -1.91021268e-03f, -3.16687897e-02f, 4.37851399e-02f, 5.69766611e-02f, -8.54863450e-02f, -6.17939606e-02f, -1.04576275e-01f,
  8.97393301e-02f, -9.54257324e-02f, -8.72749314e-02f, -1.15680844e-02f, -9.65703875e-02f, 7.57446140e-02f, 7.98327178e-02f, 1.36692310e-02f, -2.56922152e-02f, -5.73631451e-02f,
  -2.62636412e-02f, 3.53246927e-02f, -9.19149071e-03f, 2.02813894e-02f, -3.47977579e-02f, -5.44504300e-02f, 6.20947145e-02f, -1.04905419e-01f, 4.55708802e-02f, -2.12031230e-01f,
  -1.41697049e-01f, -1.90815195e-01f, 3.23629528e-02f, -5.64796403e-02f, -1.90891579e-01f, -5.08788079e-02f, -9.07732248e-02f, 3.86509113e-04f, 1.98827222e-01f, -8.43391791e-02f,
  -6.92815185e-02f, 1.35025144e-01f, 4.81405780e-02f, -4.91850190e-02f, 4.51786034e-02f, -1.19972214e-01f, 3.17181647e-01f, 1.13373153e-01f, -1.88580051e-01f, -7.55158737e-02f,
  1.82207733e-01f, -2.44792458e-02f, 1.64324231e-02f, -1.69360787e-02f, 2.22176760e-01f, -3.21197882e-02f, 4.21394221e-02f, 1.13498837e-01f, -1.09679468e-01f, 5.92445433e-01f,
  -1.10650234e-01f, -5.69954291e-02f, -1.48396522e-01f, 7.93963671e-02f, 2.43566558e-01f, 2.05223784e-01f, -9.54518467e-02f, -1.57643378e-01f, -7.09599033e-02f, 4.91620265e-02f,
  -3.50565128e-02f, 6.88551553e-03f, 1.75333649e-01f, -1.39993891e-01f, -1.17873721e-01f, -6.59581423e-02f, 3.67290415e-02f, 1.23488888e-01f, -1.85200125e-02f, -4.72224392e-02f,
  -6.83428487e-03f, 1.24806240e-01f, -1.31507143e-01f, 2.64831901e-01f, 1.13809556e-01f, -1.87414542e-01f, 1.77641734e-02f, -1.56196937e-01f, -2.70531550e-02f, 2.16708601e-01f,
  2.67501809e-02f, 8.19948837e-02f, 9.30920988e-02f, -4.68522012e-02f, -4.69817221e-02f, 2.44445656e-03f, 4.60153073e-02f, -9.18165296e-02f, 1.07014008e-01f, 3.23285870e-02f,
  -1.80921294e-02f, -4.86014970e-02f, -3.78281362e-02f, 6.72723446e-03f, 8.18461329e-02f, -9.00146514e-02f, -2.71007605e-03f, 8.77768397e-02f, -5.22609651e-02f, -8.41177851e-02f,
  8.45711976e-02f, 1.03576779e-01f, 1.08175486e-01f, -1.06321700e-01f, -1.11844599e-01f, 3.14427167e-02f, 3.36158350e-02f, -4.30812836e-02f, 2.87085772e-02f, -5.64525127e-02f,
  -1.01048827e-01f, -1.10995822e-01f, 1.03716105e-01f, 1.02738097e-01f, -3.23143899e-02f, 7.96768516e-02f, -8.72748494e-02f, -4.78642695e-02f, 6.51192516e-02f, -1.14300802e-01f,
  -1.14807069e-01f, 1.10195816e-01f, -1.01100981e-01f, 4.54999506e-03f, -7.44053870e-02f, 5.18142106e-03f, 1.98164340e-02f, 5.39177656e-03f, 3.77372988e-02f, -1.86149441e-02f,
  5.75058348e-02f, 6.60899580e-02f, 5.73515557e-02f, 7.62206763e-02f, -1.05451539e-01f, -1.29432485e-01f, 5.82657158e-02f, 9.17948931e-02f, -1.14963293e-01f, -5.77977858e-02f,
  -7.60495067e-02f, -2.56246924e-02f, -1.16353869e-01f, -4.20182943e-03f, 5.08726686e-02f, 1.92775689e-02f, -1.01788148e-01f, 6.11231364e-02f, -2.88731188e-01f, -1.34412944e-01f,
  -1.11861907e-01f, -2.76938796e-01f, 1.43850178e-01f, -7.64597431e-02f, 6.61268160e-02f, -7.43519887e-02f, 9.25042778e-02f, 8.80277343e-03f, -4.13443409e-02f, -1.27976865e-01f,
  2.66378403e-01f, 1.46613121e-01f, -4.01394628e-02f, 3.06369420e-02f, 1.23330347e-01f, 3.19433473e-02f, -5.63521981e-02f, 8.75819027e-02f, 7.13282749e-02f, -2.29501948e-01f,
  3.11492905e-02f, 2.29913741e-02f, 4.84616775e-03f, 4.01335023e-02f, 4.71171066e-02f, 3.75403417e-03f, 9.96921584e-03f, -5.57883680e-02f, 2.29691491e-01f, 1.12887867e-01f,
  1.20226227e-01f, -3.07771154e-02f, -2.27920622e-01f, -5.55196702e-02f, -6.56559169e-02f, 7.96363801e-02f, 8.59816000e-02f, 1.41164497e-01f, 9.59277451e-02f, -4.01633456e-02f,
  1.87415212e-01f, 2.40609571e-01f, -2.19393015e-01f, -1.14572197e-01f, 1.19067542e-01f, 5.44685423e-02f, -1.06732287e-01f, -4.62805741e-02f, 8.58486593e-02f, 1.02182806e-01f,
  4.62759845e-02f, -1.75753534e-01f, -9.77926925e-02f, 1.76512748e-01f, 1.69508785e-01f, -1.56828687e-01f, -1.70007616e-01f, 6.78553358e-02f, -3.74474712e-02f, 2.18886107e-01f,
  -4.56923917e-02f, 1.13409147e-01f, -3.50953154e-02f, -8.55836198e-02f, 1.71603426e-01f, 9.48316827e-02f, -1.90931797e-01f, -4.22628969e-02f, -2.29940802e-01f, -7.04838112e-02f,
  -4.90869135e-02f, -1.99121103e-01f, 1.61341578e-01f, 2.15937719e-01f, 7.56038800e-02f, -2.00830415e-01f, -5.37907844e-03f, 1.93652824e-01f, 2.16622092e-02f, 4.75480221e-03f,
  5.02006896e-02f, -1.45732269e-01f, -1.22118041e-01f, 1.59577236e-01f, 2.37636134e-01f, 6.87774569e-02f, -1.61845446e-01f, -2.10255593e-01f, 2.83133201e-02f, 1.54017314e-01f,
  -1.24314643e-01f, 5.90294480e-01f, -1.62666515e-01f, -8.03240165e-02f, 1.04468040e-01f, 1.91462979e-01f, 4.89553474e-02f, 2.97343098e-02f, 8.51634294e-02f, 1.64890945e-01f,
  2.38968208e-02f, -3.67075615e-02f, 3.76716964e-02f, -1.28851244e-02f, -1.74700081e-01f, -4.22362424e-02f, 1.00970693e-01f, 1.28098100e-01f, -7.81969056e-02f, -1.00630470e-01f,
  1.19871691e-01f, 9.95527133e-02f, -9.56965834e-02f, 1.25096589e-01f, 2.58433335e-02f, 2.08470121e-01f, -1.63208872e-01f, -1.52973905e-01f, 1.21322699e-01f, 9.25064145e-04f,
  2.01676086e-01f, 1.81609228e-01f, 9.33659971e-02f, -4.61534299e-02f, -9.27866846e-02f, 1.36200354e-01f, 2.82955673e-02f, 5.14341779e-02f, 4.81634475e-02f, 2.03184098e-01f,
  3.96001674e-02f, 1.26788005e-01f, -2.35796142e-02f, -3.58215608e-02f, 1.07021540e-01f, 6.91525415e-02f, 1.70362934e-01f, -1.01755902e-01f, -8.40057731e-02f, 1.48866817e-01f,
  -2.08283612e-03f, -1.31716043e-01f, -8.36130604e-02f, 5.92698306e-02f, -5.96425869e-02f, 2.16348290e-01f, -1.76388286e-02f, -8.55072925e-04f, -2.58351900e-02f, -1.80462897e-02f,
  2.28209019e-01f, 2.65880853e-01f, -8.55680928e-02f, -7.70974979e-02f, 2.49799401e-01f, -3.73943523e-02f, 1.81624994e-01f, 1.29250716e-02f, 2.29156036e-02f, -7.39618763e-02f,
  -1.41574338e-01f, -5.61374389e-02f, 6.65810630e-02f, 2.03413799e-01f, -8.19263235e-02f, -3.54602933e-02f, 1.15681954e-01f, 7.93697834e-02f, 1.24210604e-01f, 1.89316928e-01f,
  1.66746140e-01f, 1.99177310e-01f, 3.98949049e-02f, 1.94547828e-02f, 1.86972693e-02f, 8.41745213e-02f, 6.61729500e-02f, 8.94734263e-02f, 5.92380092e-02f, -9.13514569e-02f,
  6.03990443e-02f, 1.28095582e-01f, 1.16129160e-01f, 7.62804672e-02f, 1.08109631e-01f, -1.89450383e-01f, -1.43659458e-01f, 4.00587395e-02f
};

// L3_fan_Bp_bar (Shape: 1 x 52)
const int L3_fan_Bp_bar_rows = 1;
const int L3_fan_Bp_bar_cols = 52;
const float L3_fan_Bp_bar_data[] = {
  -1.22167014e-01f, 8.70255977e-02f, 4.86486368e-02f, 1.50558853e-03f, -1.41475592e-02f, -4.53334861e-02f, 6.13892190e-02f, 1.36859924e-01f, -5.65023161e-02f, 7.74614066e-02f,
  6.28446713e-02f, 3.30391526e-02f, -5.41614071e-02f, 4.12867293e-02f, 6.66830242e-02f, -9.82390791e-02f, 5.05761690e-02f, -5.52362055e-02f, 1.55562788e-01f, 5.74361607e-02f,
  -9.88991037e-02f, 1.53833151e-01f, -8.84414241e-02f, -1.74363330e-03f, 8.25072974e-02f, 1.01617482e-02f, 1.41021997e-01f, -7.97537044e-02f, -9.23877284e-02f, -7.42885023e-02f,
  4.48207278e-03f, -1.94572064e-03f, -3.38794477e-02f, 1.13131560e-01f, 9.05081034e-02f, -4.82138566e-04f, 4.16796841e-02f, -3.98316160e-02f, -3.15456688e-02f, 5.81424534e-02f,
  -8.53574052e-02f, -1.47851910e-02f, -1.47254961e-02f, 7.59164989e-02f, 4.93287258e-02f, 1.52520940e-01f, 7.92850628e-02f, -7.56479613e-03f, -7.99908265e-02f, 1.95661690e-02f,
  -8.86368752e-02f, 1.35335624e-01f
};

// L4_linear_W (Shape: 12 x 64)
const int L4_linear_W_rows = 12;
const int L4_linear_W_cols = 64;
const float L4_linear_W_data[] = {
  1.58044770e-01f, -6.31532893e-02f, 1.81845278e-02f, -1.29498586e-01f, 8.92388895e-02f, -5.43536153e-03f, 8.48036781e-02f, -1.32960349e-01f, 1.92614883e-01f, 1.03653364e-01f,
  -7.11690933e-02f, -1.73590213e-01f, -3.96742970e-02f, -9.76166651e-02f, 1.03310488e-01f, -2.45168030e-01f, -1.41561642e-01f, -7.87017681e-03f, -1.79269001e-01f, 2.05348477e-01f,
  7.49353543e-02f, -3.36368024e-01f, -9.09677446e-02f, 2.75058486e-03f, -2.97957249e-02f, 1.30689308e-01f, -1.00211494e-01f, 9.32150632e-02f, -2.28495654e-02f, -3.05915862e-01f,
  5.87932095e-02f, -4.84689027e-02f, 2.62085907e-02f, 9.87822637e-02f, -2.56100655e-01f, -1.50314003e-01f, -1.10104606e-01f, -3.31406504e-01f, -1.05317339e-01f, -1.44206613e-01f,
  -7.02198669e-02f, 5.72010353e-02f, -1.75346375e-01f, 2.25854605e-01f, -1.00412332e-01f, 5.11035621e-02f, -2.89848626e-01f, -2.80049562e-01f, -8.58301669e-02f, 1.49823308e-01f,
  -4.72107977e-02f, -1.44504473e-01f, -2.27910891e-01f, 2.53454983e-01f, -3.27053368e-02f, 4.02728058e-02f, 1.33015588e-01f, 1.03020526e-01f, 5.67923337e-02f, 1.44743904e-01f,
  -1.23960972e-01f, -3.07836741e-01f, 9.30506736e-02f, -4.65160534e-02f, 2.95069031e-02f, -8.70369747e-02f, -3.65406438e-03f, -1.36598900e-01f, 8.00649077e-02f, 1.64562374e-01f,
  -1.79809272e-01f, -1.85785994e-01f, 2.52245575e-01f, -1.45056089e-02f, -1.99491456e-01f, 1.96480468e-01f, -1.51976511e-01f, 4.28852327e-02f, 4.22685780e-02f, 1.46198094e-01f,
  -4.54315841e-01f, 7.92994350e-02f, -1.30220413e-01f, 5.54297492e-02f, -8.67722034e-02f, -3.77507746e-01f, -7.31731281e-02f, -3.30109671e-02f, 7.87295774e-02f, -5.15564494e-02f,
  -1.08182214e-01f, 4.82150167e-02f, 1.44121751e-01f, -9.94250551e-02f, 2.78966963e-01f, 1.39893889e-01f, 7.69127533e-02f, -1.17605925e-01f, 6.84438944e-02f, 6.87550828e-02f,
  1.57328591e-01f, 1.30677029e-01f, 1.38164669e-01f, -1.46081403e-01f, -4.82900366e-02f, -8.93742293e-02f, 2.14923788e-02f, -6.80170208e-02f, 1.55594453e-01f, -3.34022418e-02f,
  -1.13599729e-02f, -2.30677843e-01f, -1.31877184e-01f, 3.03354282e-02f, -3.61468494e-02f, -5.27439304e-02f, -1.53521737e-02f, -1.66310053e-02f, -7.87308812e-02f, -7.29441941e-02f,
  1.07447602e-01f, 1.81393221e-01f, -7.79417455e-02f, 6.66525662e-02f, -3.66384983e-02f, -3.13450605e-01f, -9.69129894e-03f, -2.51089573e-01f, 1.90018982e-01f, -8.86822268e-02f,
  -7.09186634e-03f, 4.06140741e-03f, 1.05238058e-01f, 2.94652674e-02f, 6.39599040e-02f, 1.47023290e-01f, -1.83481008e-01f, -1.93528175e-01f, 1.28963411e-01f, 3.75153311e-02f,
  1.68062821e-01f, 2.86530927e-02f, -2.14135975e-01f, -1.07662030e-01f, 1.21548951e-01f, -1.96758643e-01f, 2.04352468e-01f, -1.05404072e-01f, -9.07484666e-02f, -3.12721372e-01f,
  -1.19881205e-01f, 7.66681507e-02f, -2.86695898e-01f, -1.66006833e-01f, 9.67415869e-02f, -9.90561843e-02f, -2.25351974e-01f, -3.12403999e-02f, 2.69050673e-02f, -5.66915981e-02f,
  -1.09182492e-01f, 5.63816093e-02f, -2.19098270e-01f, -1.48275122e-01f, 6.95691928e-02f, 6.55456185e-02f, 1.61724761e-01f, 1.43066999e-02f, -8.41019899e-02f, 1.63361651e-03f,
  7.98872858e-02f, -1.77084804e-01f, 1.11820614e-02f, -3.96485068e-02f, 2.70492226e-01f, 1.56786218e-01f, 3.42747234e-02f, -2.80517906e-01f, 3.13218161e-02f, 1.92907989e-01f,
  1.40058354e-01f, -2.30918944e-01f, -2.52985001e-01f, 8.44533667e-02f, -7.20954016e-02f, -1.02153882e-01f, 4.46151532e-02f, -6.99799433e-02f, -5.40096266e-03f, 3.11534368e-02f,
  -1.64671317e-01f, 8.09773803e-03f, -1.38552442e-01f, -1.58460423e-01f, -8.18940848e-02f, -1.31636765e-02f, -2.19794482e-01f, -8.04156996e-03f, 4.20239083e-02f, -6.52455986e-02f,
  -4.27054428e-02f, 3.98016348e-02f, -1.12989031e-01f, -6.65101558e-02f, 6.25265464e-02f, 4.95895790e-03f, -2.79396385e-01f, 1.53802661e-02f, -1.62292436e-01f, 4.13576216e-02f,
  1.80485964e-01f, 1.53507233e-01f, -6.29717018e-03f, -8.52495804e-02f, 1.47595435e-01f, -2.46900663e-01f, 7.31437802e-02f, -1.43826708e-01f, -8.75581503e-02f, -2.77134478e-02f,
  -2.48492703e-01f, -8.95363167e-02f, -1.93016186e-01f, -3.20285052e-01f, -4.10243310e-02f, 1.01451315e-01f, 1.60821937e-02f, 2.07164004e-01f, -1.18256934e-01f, -1.64084160e-03f,
  -3.05247903e-01f, -2.01431245e-01f, -4.50550728e-02f, 3.97592485e-02f, 9.89066213e-02f, 1.89624637e-01f, 7.76288807e-02f, -8.94477367e-02f, -2.45140970e-01f, 8.74875113e-02f,
  -7.78131466e-03f, 1.82787720e-02f, -1.04664072e-01f, -2.11944163e-01f, 1.49111241e-01f, 8.43040869e-02f, -1.44536689e-01f, -2.81884521e-01f, -1.27365619e-01f, -8.26104730e-03f,
  1.20541058e-01f, -1.96437791e-01f, 5.43427095e-02f, -2.57110536e-01f, 1.48802117e-01f, -1.23633184e-01f, 1.80384636e-01f, -1.70512926e-02f, 4.68754061e-02f, 1.15477905e-01f,
  -3.05753294e-03f, 1.44467399e-01f, -1.23115927e-02f, 2.07755089e-01f, -6.78814203e-02f, 9.25353467e-02f, -7.89230540e-02f, -5.52944057e-02f, 5.58610372e-02f, 5.59147857e-02f,
  1.18727930e-01f, -3.97466123e-01f, -5.09926528e-02f, 8.77847373e-02f, 1.54328803e-02f, -2.80947760e-02f, 2.74385139e-02f, 1.04944773e-01f, 1.51790887e-01f, 1.58748135e-01f,
  6.76066801e-02f, 7.94218853e-02f, -8.66326019e-02f, -5.54557592e-02f, 2.73784939e-02f, -9.78772417e-02f, -1.41756043e-01f, 8.76401961e-02f, -6.10004365e-02f, 1.05803244e-01f,
  -2.04849035e-01f, 1.91503093e-02f, -2.02849969e-01f, -1.30257711e-01f, -1.31237609e-02f, 6.55745715e-02f, -4.19775881e-02f, 8.02963227e-02f, 1.41957849e-01f, -7.93203060e-03f,
  1.45300224e-01f, 1.23222180e-01f, -1.88792214e-01f, -3.22753936e-02f, 4.63828333e-02f, -6.25414178e-02f, -3.40241753e-02f, -2.36160621e-01f, 4.49371561e-02f, -5.07991649e-02f,
  -2.35677063e-01f, -1.37613624e-01f, 2.36350838e-02f, 4.37565446e-02f, -6.35664985e-02f, -2.51435727e-01f, -8.96604285e-02f, 6.76299166e-03f, -2.20552646e-02f, 1.17634684e-01f,
  -1.82423681e-01f, 9.30335298e-02f, 9.60315093e-02f, 5.47210462e-02f, -3.50614195e-03f, -1.08342774e-01f, 1.24279097e-01f, -2.60623515e-01f, 1.65683776e-01f, 2.20890775e-01f,
  2.63244301e-01f, -6.42552972e-02f, 1.25402033e-01f, -1.85153425e-01f, 1.13345429e-01f, 1.11213122e-02f, 2.21506301e-02f, 9.66544226e-02f, -3.22807431e-01f, -7.84575641e-02f,
  9.43236947e-02f, -1.26920134e-01f, -3.61825675e-02f, -9.03169159e-03f, -1.60947908e-02f, 1.03675313e-01f, 4.75475937e-02f, -1.43203586e-02f, 1.20474778e-01f, 1.12598024e-01f,
  -4.51430976e-02f, 1.05775975e-01f, 5.29631302e-02f, -1.85186476e-01f, 1.90630302e-01f, -1.84236094e-02f, -5.70500488e-05f, -1.55040249e-01f, 1.28644839e-01f, 7.86755607e-02f,
  -2.67635030e-03f, -2.09200680e-02f, 1.02742277e-01f, -1.85254544e-01f, -1.75379664e-01f, 1.73956692e-01f, -4.08667251e-02f, -2.99005151e-01f, -1.60814464e-01f, 1.41042486e-01f,
  5.81060015e-02f, -1.37690012e-03f, -3.46253961e-02f, 1.37769520e-01f, 1.37140229e-01f, 9.98024419e-02f, 1.41924039e-01f, -1.37275398e-01f, -1.03662573e-01f, 9.70595181e-02f,
  1.48392944e-02f, 9.03331488e-02f, -3.05238128e-01f, -1.15886204e-01f, -1.53063700e-01f, 1.02970965e-01f, 3.73973437e-02f, -3.02606244e-02f, 9.74346921e-02f, -1.46318167e-01f,
  -3.20093669e-02f, -1.67919815e-01f, 9.72185805e-02f, -2.42861748e-01f, 3.88438860e-03f, 4.96415310e-02f, -1.18786551e-01f, -1.99437410e-01f, 1.35631964e-01f, 1.19073324e-01f,
  2.05137745e-01f, -1.97012261e-01f, -3.35887939e-01f, -3.66420478e-01f, -8.48396271e-02f, 1.70918897e-01f, -2.41103798e-01f, 9.37046334e-02f, -2.88167894e-01f, -7.12448210e-02f,
  -8.09585303e-03f, 3.80786955e-02f, 1.39472866e-02f, 1.89513609e-01f, -2.91649878e-01f, -2.27634031e-02f, 8.56399611e-02f, -1.41621530e-01f, 6.88565336e-03f, -9.40103531e-02f,
  1.61980227e-01f, 1.60652790e-02f, 1.62266538e-01f, 1.64273128e-01f, 9.00600180e-02f, -4.21801805e-02f, -2.45966315e-02f, -2.38531068e-01f, -8.70936811e-02f, 5.50597273e-02f,
  1.96559844e-03f, -6.08264729e-02f, 8.94851610e-02f, -3.20794970e-01f, -1.49232280e-02f, 1.30790800e-01f, 6.92910254e-02f, -1.97527170e-01f, -2.06601888e-01f, -3.46801393e-02f,
  -2.52807513e-02f, -3.18358928e-01f, -9.75306556e-02f, 6.01617321e-02f, 7.10052922e-02f, 2.29706153e-01f, -1.71822786e-01f, -3.68572734e-02f, 1.53893884e-02f, -1.55553773e-01f,
  -2.47362610e-02f, 9.09763798e-02f, 5.43805137e-02f, -9.53670517e-02f, 1.23091549e-01f, 1.17325246e-01f, 6.51161000e-02f, -1.43720523e-01f, -9.46919806e-03f, -4.36084606e-02f,
  1.17135838e-01f, -2.26377174e-01f, 5.05995974e-02f, -8.85501131e-02f, -1.28433928e-01f, -8.29716474e-02f, 1.88090026e-01f, -2.02470839e-01f, 9.21261609e-02f, -2.17443317e-01f,
  6.00711331e-02f, 1.19238712e-01f, 8.04033205e-02f, -2.95728981e-01f, -1.10589035e-01f, -6.72580451e-02f, -2.46725649e-01f, -9.13363602e-03f, -7.58311599e-02f, -1.84890106e-01f,
  8.68892670e-02f, 2.00715005e-01f, 6.00632504e-02f, 1.95485145e-01f, -2.28962183e-01f, -3.03139351e-02f, -9.79947671e-02f, -1.88720062e-01f, -1.08939655e-01f, 3.62224579e-02f,
  7.01952130e-02f, 1.81480065e-01f, -2.76713669e-01f, -1.00253262e-01f, -2.36307345e-02f, 1.07213333e-01f, -3.40140998e-01f, 1.55017152e-01f, -1.21543765e-01f, 1.08010814e-01f,
  -1.64366905e-02f, -8.75248685e-02f, 4.71177213e-02f, -2.67566830e-01f, -1.50994450e-01f, -6.14665151e-02f, -1.70888137e-02f, 1.16103543e-02f, -1.05550550e-01f, 1.23622894e-01f,
  -4.45619076e-02f, 5.18074743e-02f, 8.96819532e-02f, -1.57820694e-02f, -1.11294180e-01f, -4.56523560e-02f, -6.78729564e-02f, 6.53543025e-02f, 2.18121067e-01f, 6.77985623e-02f,
  7.45694265e-02f, 1.60739034e-01f, -1.74771532e-01f, 5.04443236e-02f, 1.95907541e-02f, 1.22580595e-01f, -1.32836640e-01f, -1.72992602e-01f, 2.41101887e-02f, -2.28045821e-01f,
  1.00629285e-01f, 6.59189150e-02f, -4.91639078e-02f, -2.20553294e-01f, 5.97668700e-02f, -2.05215380e-01f, -2.96931341e-02f, 1.11491404e-01f, 8.50473270e-02f, 1.24100730e-01f,
  -2.96379536e-01f, 1.99112162e-01f, 8.70665908e-02f, -1.22351184e-01f, -7.45263547e-02f, -2.16363966e-01f, 1.73496693e-01f, 7.15057552e-02f, -4.68517430e-02f, 1.31265193e-01f,
  2.98848581e-02f, 9.61896777e-02f, -1.02877907e-01f, -9.63242874e-02f, 8.51762816e-02f, -1.07619621e-01f, -4.71256934e-02f, -1.66187689e-01f, 5.72060496e-02f, -1.45713538e-01f,
  -1.44628868e-01f, 4.36233394e-02f, -7.73130208e-02f, 9.96965989e-02f, 1.10041015e-01f, -1.26733318e-01f, 1.44221663e-01f, 4.07756455e-02f, -2.36564934e-01f, -5.21606989e-02f,
  8.62432364e-03f, 1.63588196e-01f, -3.92860286e-02f, -1.25829771e-01f, 1.71185136e-01f, -2.34754518e-01f, 1.78525940e-01f, 1.61558867e-01f, 1.23917304e-01f, 1.02930605e-01f,
  4.50192764e-02f, 1.77008495e-01f, -3.74669842e-02f, 6.05011061e-02f, 2.03461930e-01f, -1.00024402e-01f, 1.55597910e-01f, 5.90043329e-02f, 8.85440782e-02f, -3.30316961e-01f,
  1.24024659e-01f, 9.90944058e-02f, -8.88680145e-02f, 7.77247846e-02f, -6.25612140e-02f, -7.04805627e-02f, -2.05431655e-02f, -1.48970231e-01f, -1.67030036e-01f, 1.28713191e-01f,
  -2.67368346e-01f, -3.21323603e-01f, 1.12220317e-01f, -4.06534374e-02f, 8.48958492e-02f, 6.82035089e-02f, -1.41673893e-01f, 2.18368039e-01f, 7.75835738e-02f, 2.51410276e-01f,
  9.58063900e-02f, -5.08492254e-02f, 1.69171587e-01f, -3.49579215e-01f, -9.13230702e-02f, 1.15369789e-01f, 9.37966034e-02f, 1.09033629e-01f, -1.57317951e-01f, -1.92813382e-01f,
  -3.14576447e-01f, 1.15809627e-01f, -1.32732794e-01f, 2.79933721e-01f, -1.76181659e-01f, -2.44555950e-01f, -7.23361000e-02f, 4.91126664e-02f, -3.40441138e-01f, -1.90271154e-01f,
  -1.49327233e-01f, -9.12645906e-02f, 2.09158007e-02f, -1.84740573e-01f, 7.47867599e-02f, -1.19342797e-01f, -1.27376094e-02f, -1.90953340e-03f, -8.58270675e-02f, 1.45287305e-01f,
  7.02412741e-04f, 1.55256083e-02f, 6.66586980e-02f, -1.59037709e-01f, 1.33643538e-01f, -6.87999837e-03f, 2.65160084e-01f, 2.41750419e-01f, -3.85723077e-02f, 2.14330763e-01f,
  -1.37118250e-01f, 1.63618766e-03f, -1.62872761e-01f, 7.24255219e-02f, -2.43405342e-01f, -4.62966859e-01f, -1.92250758e-01f, -2.16509365e-02f, -6.91899285e-02f, 1.82318509e-01f,
  4.13494334e-02f, -1.38345882e-01f, 3.29201557e-02f, -3.05211872e-01f, 4.56752144e-02f, 9.66791287e-02f, -3.08974963e-02f, -7.00408518e-02f, 7.23826587e-02f, -2.98959196e-01f,
  1.48166269e-01f, 4.30574827e-02f, 8.47223848e-02f, -3.58264148e-02f, -2.11531028e-01f, -4.60847020e-02f, 2.42858194e-03f, 1.17086582e-01f, -1.27806857e-01f, -2.73438931e-01f,
  -1.14324898e-01f, -5.88809885e-02f, -7.11950436e-02f, 1.62778005e-01f, 1.93400696e-01f, -2.13192016e-01f, 2.51720816e-01f, -1.69921264e-01f, 1.92964554e-01f, -2.72985850e-03f,
  -5.28909601e-02f, -2.64745772e-01f, 4.55403998e-02f, 1.48168176e-01f, -2.18933150e-01f, 4.35636099e-03f, -2.53183305e-01f, 1.21918112e-01f, -5.72429523e-02f, -2.39666775e-01f,
  -1.22433618e-01f, -2.04902768e-01f, 9.91625264e-02f, -7.06880214e-03f, -1.56678602e-01f, -9.06475857e-02f, -1.45643413e-01f, -1.06760480e-01f, 1.34927884e-01f, -4.00018580e-02f,
  -1.89292923e-01f, 8.00353140e-02f, 5.20137511e-02f, -2.30153576e-01f, -1.61578119e-01f, 1.45779431e-01f, -3.29858720e-01f, 3.44440644e-03f, -1.74676865e-01f, -2.31656075e-01f,
  5.31957187e-02f, 5.46724387e-02f, -3.02012414e-02f, 7.42015317e-02f, -6.42518178e-02f, 3.32062781e-01f, -9.48609039e-02f, -2.91926637e-02f, 5.59684820e-02f, 1.75848842e-01f,
  -8.61306563e-02f, 8.75599682e-02f, 1.78148318e-02f, -1.80828180e-02f, -9.45497975e-02f, 1.05569558e-02f, -9.71116796e-02f, -9.71111059e-02f, 6.88102990e-02f, 3.65360714e-02f,
  1.62415683e-01f, 1.36866227e-01f, 9.03090909e-02f, -2.74486300e-02f, 4.22391389e-03f, -1.03661694e-01f, -1.00231813e-02f, -2.78358191e-01f, 1.68361723e-01f, -2.64196813e-01f,
  -8.91302228e-02f, -8.11337382e-02f, 2.55361974e-01f, -2.13225320e-01f, -3.50535065e-02f, -1.19569656e-02f, 1.68357357e-01f, -2.94729382e-01f, 2.29762737e-02f, 4.68228422e-02f,
  -1.29836053e-01f, 3.52997482e-02f, -1.06207371e-01f, -3.05438697e-01f, -9.81278047e-02f, 2.90455166e-02f, -8.43161866e-02f, -1.70116946e-01f
};

// L4_linear_B (Shape: 1 x 12)
const int L4_linear_B_rows = 1;
const int L4_linear_B_cols = 12;
const float L4_linear_B_data[] = {
  1.16287343e-01f, -7.57031366e-02f, -4.23133820e-02f, -6.59308955e-02f, -1.01624675e-01f, -2.11734902e-02f, -4.17291038e-02f, -1.35100484e-01f, -1.67946428e-01f, 3.27856317e-02f,
  7.64579251e-02f, 7.47860745e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 6, 52
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        64, 6, 52
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        64, 6, 52
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L3_fan_Wp_data, L3_fan_Wp_bar_data, L3_fan_Bp_bar_data,
        64, 6, 52
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 4: L4_linear
    linear_forward_pgm(
        buffer1, x_out,
        L4_linear_W_data, L4_linear_B_data,
        64, 12
    );
    }
    