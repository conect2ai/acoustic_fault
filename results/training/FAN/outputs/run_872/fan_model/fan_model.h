/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 64 (x1)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 64;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    static inline float fan_activation(float x) { return x; }

    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 19 x 120)
const int L0_fan_Wp_rows = 19;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -2.57869959e-01f, 1.11124270e-01f, -4.34466004e-01f, 4.82808426e-02f, -9.83856712e-03f, -1.82873681e-01f, -1.34361088e-01f, 3.86873372e-02f, 3.39773558e-02f, 5.09165190e-02f,
  1.91198796e-01f, 2.36693233e-01f, 9.17376429e-02f, -2.25435141e-02f, -2.31914297e-01f, -1.90421388e-01f, -3.09448153e-01f, -3.54046255e-01f, -2.52633721e-01f, 4.05396633e-02f,
  2.93989982e-02f, -3.45220640e-02f, -2.68665612e-01f, -1.31263942e-01f, 2.44410127e-01f, 6.76504895e-02f, 6.65484220e-02f, -6.65423423e-02f, 8.65694806e-02f, 1.27955645e-01f,
  3.88717726e-02f, -1.10854685e-01f, -3.01702321e-02f, 7.45734423e-02f, -4.90408763e-02f, -5.49667254e-02f, -1.06437318e-01f, -6.28655702e-02f, -3.56838927e-02f, -4.18329574e-02f,
  1.41024990e-02f, 1.10243205e-02f, -4.73649725e-02f, 8.39095563e-02f, -5.05703986e-02f, -8.26585814e-02f, -9.35478061e-02f, -2.19853356e-01f, -1.47966638e-01f, 3.91936302e-02f,
  1.52444974e-01f, 1.36537077e-02f, -2.87370503e-01f, -4.17329557e-02f, -8.67333114e-02f, -9.66996327e-02f, 7.83727765e-02f, -1.37625085e-02f, -5.05086817e-02f, 1.02357619e-01f,
  -5.65659739e-02f, 1.34189306e-02f, 1.26418052e-02f, 8.72276071e-03f, -1.05281931e-03f, 1.05255870e-02f, 4.16043252e-02f, -2.15313490e-02f, 4.05935496e-02f, -5.12638614e-02f,
  -1.06172273e-02f, -1.49305677e-02f, 2.85332627e-03f, -1.08862676e-01f, 5.25758453e-02f, -5.13279289e-02f, -2.16595177e-02f, 2.63310559e-02f, -5.04664853e-02f, 4.40124534e-02f,
  1.20988917e-02f, 4.63441759e-02f, -4.65460196e-02f, 7.46868402e-02f, 2.90584173e-02f, 2.12753713e-02f, -7.74386376e-02f, 3.86805870e-02f, -8.43711942e-02f, 8.31643958e-03f,
  1.40420839e-01f, -1.38963431e-01f, 2.44560745e-02f, -5.09938598e-02f, -4.12488043e-05f, -1.21021885e-02f, 1.02660067e-01f, -6.09994978e-02f, 2.60122046e-02f, -1.98475271e-02f,
  -2.74408702e-02f, -3.53477262e-02f, 2.16937400e-02f, 7.51344934e-02f, 1.93975922e-02f, 7.20301783e-03f, -1.09184990e-02f, 5.90507723e-02f, 4.63037342e-02f, -1.82464849e-02f,
  -6.46190299e-03f, -1.09693058e-01f, -5.69525398e-02f, -4.14202027e-02f, 9.12252162e-03f, -7.46321380e-02f, -7.13570639e-02f, -1.43368496e-02f, -2.21556872e-01f, -3.55699100e-02f,
  1.62446678e-01f, 3.12098086e-01f, -3.16711336e-01f, 1.58247754e-01f, 1.25020474e-01f, 1.98107719e-01f, 2.18426555e-01f, 8.99648517e-02f, 1.81844726e-01f, 2.15580225e-01f,
  1.61491022e-01f, 5.85796647e-02f, -8.70693326e-02f, -1.27726674e-01f, -1.11207381e-01f, 5.37652820e-02f, -3.45130526e-02f, -1.98457554e-01f, -2.45792061e-01f, -3.19615602e-02f,
  1.68369845e-01f, 1.33634984e-01f, -1.24531619e-01f, -8.49050805e-02f, 6.39918298e-02f, -6.30040318e-02f, 4.04015258e-02f, 1.26820048e-02f, -8.68370011e-02f, 2.65861228e-02f,
  -2.96511531e-01f, 4.01885062e-02f, -6.19269051e-02f, 1.30822837e-01f, -3.42075229e-02f, -5.79472408e-02f, -2.83712056e-02f, -2.60223001e-02f, -1.00994599e-03f, 2.62208935e-02f,
  4.38491488e-03f, -1.35484999e-02f, -1.78369042e-02f, -6.63663447e-02f, 1.05533391e-01f, 3.73862982e-02f, -4.85602990e-02f, -2.09190071e-01f, -1.94106642e-02f, 1.99998077e-02f,
  4.57714945e-02f, 1.53661624e-01f, -4.62850556e-02f, -3.09082661e-02f, -1.07872799e-01f, -5.67404926e-02f, 7.38068484e-04f, -1.06358618e-01f, -1.23175919e-01f, 1.21363863e-01f,
  3.40437107e-02f, -6.76462278e-02f, 4.44957847e-03f, 3.36034596e-02f, 3.71094346e-02f, 3.05935852e-02f, -1.29165389e-02f, -2.53071729e-02f, 1.44599648e-02f, -2.77908538e-02f,
  -3.51380408e-02f, -1.68475173e-02f, 5.01491912e-02f, 4.54077497e-04f, -3.22427042e-02f, 2.28201225e-02f, 5.60596166e-03f, -4.73899068e-04f, 1.15689440e-02f, -2.67787669e-02f,
  -5.48053831e-02f, -3.98021415e-02f, 1.79338269e-02f, 1.72643866e-02f, -1.01529034e-02f, -3.87868360e-02f, 2.50222459e-02f, -6.48996159e-02f, 3.03293541e-02f, 2.33725607e-02f,
  6.64588287e-02f, -1.09756775e-01f, 1.03252292e-01f, -5.71608096e-02f, 4.98608314e-02f, 4.44263294e-02f, 5.48542216e-02f, -1.30398385e-02f, 3.26407216e-02f, -3.26754525e-02f,
  -1.76975213e-03f, 1.17635787e-01f, -1.41643290e-03f, 2.49305069e-02f, -6.05682284e-02f, 3.83110829e-02f, 1.12952307e-01f, 4.50892299e-02f, 4.55400161e-02f, 4.50751670e-02f,
  1.19248472e-01f, 5.44171222e-02f, -2.12935335e-03f, -6.75386861e-02f, 1.20979451e-01f, -1.12133741e-01f, -7.53747076e-02f, 3.28960246e-04f, -1.79809332e-02f, 1.99613497e-01f,
  2.19461486e-01f, 2.21295580e-01f, -4.27459896e-01f, 3.74427587e-02f, -3.27185616e-02f, 7.24244788e-02f, -6.56126859e-03f, 9.43225473e-02f, -3.49604408e-03f, -5.49332388e-02f,
  2.41837725e-01f, 2.19481178e-02f, -1.09834233e-02f, -8.41030478e-02f, -6.91318884e-02f, -1.79106146e-01f, -3.21231246e-01f, -2.68352747e-01f, -8.78644437e-02f, -2.10376340e-03f,
  7.12417662e-02f, -1.30449897e-02f, 1.04137503e-01f, -4.92424108e-02f, -5.04437275e-02f, -1.54988647e-01f, -7.37695768e-02f, -9.92022380e-02f, -3.59788388e-02f, -1.78930193e-01f,
  -3.84784311e-01f, 1.98750973e-01f, -1.65265024e-01f, 4.28620428e-02f, 1.35175223e-02f, 3.13501582e-02f, -4.91045043e-03f, -1.53555619e-02f, 9.86783504e-02f, -4.18151403e-03f,
  -4.70585823e-02f, 1.06847383e-01f, -7.77529702e-02f, -6.80581704e-02f, -1.00425696e-02f, 6.17010742e-02f, -2.22976375e-02f, 1.83531567e-02f, -1.11108370e-01f, -3.00606154e-02f,
  7.46498927e-02f, 5.29376138e-03f, -4.00403738e-02f, 7.30688572e-02f, 5.12242839e-02f, -1.12261862e-01f, -4.09826934e-02f, -2.96560675e-02f, 5.00505231e-02f, -1.25694364e-01f,
  9.00436658e-03f, -3.04888445e-03f, 1.20576881e-02f, -2.64135636e-02f, 3.38361822e-02f, -2.88247988e-02f, -3.11408238e-03f, 5.62912188e-02f, -2.42420267e-02f, 3.10128834e-02f,
  4.96164076e-02f, -4.74908128e-02f, -1.44436685e-02f, 5.33712300e-05f, 4.09279810e-03f, 2.84807105e-02f, -2.37563811e-02f, 4.20372039e-02f, -6.58304393e-02f, 2.62004063e-02f,
  -4.91112471e-02f, -2.86112428e-02f, -1.12815769e-02f, 5.44467904e-02f, 4.79570106e-02f, -4.15184535e-02f, -5.45518212e-02f, 4.87623364e-02f, 7.83990473e-02f, 6.18034322e-03f,
  -7.61095760e-03f, 1.25377133e-01f, -1.51282936e-01f, -4.03029379e-03f, -2.87284050e-02f, 1.16150212e-02f, -1.94934718e-02f, -1.09267458e-02f, -1.44411123e-03f, 1.07407868e-02f,
  4.39078808e-02f, -2.25257780e-02f, -1.49313090e-02f, 1.08062707e-01f, 4.06730436e-02f, -2.16331420e-04f, 1.08365037e-01f, -2.12816373e-02f, 1.30822686e-02f, 4.91275825e-02f,
  -2.84708831e-02f, -1.18394208e-03f, -3.78377698e-02f, -5.54371849e-02f, -2.16739681e-02f, -1.02545120e-01f, -1.80676877e-01f, -1.10739589e-01f, -1.39482155e-01f, -1.47579536e-01f,
  -4.50148076e-01f, -1.83319390e-01f, 1.26926675e-01f, -2.11782664e-01f, 1.46485820e-01f, 2.97650367e-01f, 3.87713581e-01f, 1.16656728e-01f, -5.69939092e-02f, -1.23796880e-01f,
  -3.48065514e-04f, 5.34189306e-02f, 4.09631953e-02f, 8.14316794e-03f, 1.64289609e-01f, 1.24872170e-01f, 1.38586730e-01f, 1.10466234e-01f, 3.37885082e-01f, 2.72193819e-01f,
  1.18125223e-01f, 8.56693648e-03f, -5.95040694e-02f, 2.51647029e-02f, -9.41203535e-02f, -6.00264035e-02f, -2.01691583e-01f, -1.00109458e-01f, -2.18991861e-02f, -1.72663152e-01f,
  9.42217186e-02f, -3.05882722e-01f, 1.42601117e-01f, -1.48746148e-02f, 1.70870405e-02f, -9.57543924e-02f, 1.13159925e-01f, -7.13965222e-02f, 4.87487540e-02f, 5.96117303e-02f,
  6.37046695e-02f, 4.07252945e-02f, -4.40726280e-02f, 8.65139440e-02f, -1.65578518e-02f, 3.10356244e-02f, -4.95912731e-02f, -1.39621114e-02f, 1.96204614e-03f, -4.52231616e-02f,
  7.97551572e-02f, 2.14968938e-02f, 8.63747075e-02f, 7.73715079e-02f, -6.65554777e-02f, -2.03810632e-02f, -6.75038323e-02f, -7.87572190e-02f, 5.24815433e-02f, -8.71648863e-02f,
  1.76188033e-02f, -2.23895404e-02f, 2.02596020e-02f, 3.41659524e-02f, 2.49914057e-03f, -2.82674544e-02f, -2.37350725e-02f, 1.46303341e-01f, -3.62157734e-04f, 3.41626108e-02f,
  6.54823100e-03f, 1.90776326e-02f, 1.43339927e-03f, 1.84152685e-02f, -2.72372947e-03f, 7.65093416e-02f, 7.75353089e-02f, 5.96283078e-02f, -1.67213529e-02f, 6.31587207e-03f,
  -1.89014450e-02f, 5.15409373e-03f, -8.63065943e-02f, 3.35328504e-02f, -3.11888885e-02f, 4.98824604e-02f, 3.46975867e-03f, 2.35146601e-02f, 1.03794718e-02f, -5.77870756e-02f,
  -8.08945000e-02f, -1.77542511e-02f, -3.46886963e-02f, 2.06675027e-02f, -6.26833513e-02f, -2.80597527e-02f, -6.66002706e-02f, -9.04281214e-02f, -5.84790483e-02f, -1.06441900e-02f,
  1.30366413e-02f, 2.00126227e-02f, -8.83156285e-02f, 1.47164026e-02f, 1.12405643e-01f, 6.22581504e-03f, 4.24104743e-02f, 2.32834704e-02f, 4.84577082e-02f, 5.08237518e-02f,
  -1.74952298e-02f, 1.95389092e-01f, 2.05531344e-01f, 4.74854298e-02f, 3.43681537e-02f, 9.10098255e-02f, 1.21437892e-01f, 1.12544678e-01f, 1.25861198e-01f, 5.45617379e-02f,
  4.54257131e-01f, 1.48682311e-01f, -1.41974250e-02f, 2.59697139e-01f, -5.29763438e-02f, -1.27238780e-01f, -8.03968310e-03f, 1.66565612e-01f, 6.49489136e-03f, 6.50642589e-02f,
  -1.60006598e-01f, -2.42501035e-01f, -8.01326632e-02f, -3.61912847e-02f, -8.71217474e-02f, 2.07209468e-01f, 2.01014131e-01f, 8.81433785e-02f, -1.59746423e-01f, -2.10433099e-02f,
  -8.06326568e-02f, 1.30309001e-01f, 9.33102593e-02f, 1.74268290e-01f, 1.26002625e-01f, 1.35018140e-01f, 1.74582586e-01f, 1.33264372e-02f, 2.97264289e-02f, 2.25623220e-01f,
  -1.67490512e-01f, 1.03850760e-01f, -8.67677554e-02f, 3.35566811e-02f, -4.87103425e-02f, 3.72427255e-02f, 2.59387959e-02f, 9.23755169e-02f, -4.39286195e-02f, 3.77954580e-02f,
  -5.63594475e-02f, -2.08401289e-02f, -1.44157419e-02f, -1.48525955e-02f, 1.71800354e-03f, 3.18831601e-03f, 1.44854248e-01f, 7.46595263e-02f, 6.65417165e-02f, -2.88767666e-02f,
  -8.83619189e-02f, -4.12989631e-02f, -8.50592833e-03f, 2.78263856e-02f, 7.90816993e-02f, -5.06410934e-03f, -9.83355660e-03f, 1.47269741e-01f, 9.24957693e-02f, 3.91250312e-01f,
  3.50356065e-02f, -4.70169783e-02f, 4.05158103e-03f, 3.62345390e-02f, 4.29111794e-02f, -3.01330816e-02f, -3.46789807e-02f, 4.79046553e-02f, 3.95031646e-03f, 3.08790188e-02f,
  2.10183281e-02f, -2.01203953e-02f, -2.21782755e-02f, 3.27902101e-02f, 4.06084629e-03f, 3.79212759e-02f, -4.45163324e-02f, 6.03438951e-02f, -4.48225923e-02f, 5.73242037e-03f,
  -5.08521870e-02f, -5.73629327e-02f, -7.13050272e-03f, -3.14918905e-02f, 1.27400858e-02f, -1.69163663e-03f, -3.15987468e-02f, -4.43536006e-02f, -3.09699290e-02f, -3.39420848e-02f,
  9.45722163e-02f, -2.10801229e-01f, 7.73138180e-02f, 1.28626853e-01f, 1.47540215e-02f, -2.89657153e-02f, -5.91801032e-02f, 2.95128324e-03f, -5.22987172e-03f, -5.13506494e-03f,
  -1.02511421e-01f, 4.29102778e-02f, -1.33957705e-02f, 1.13499640e-02f, -6.12769350e-02f, -2.51610987e-02f, 3.96891534e-02f, -4.01254334e-02f, -4.27382207e-03f, 6.98366091e-02f,
  4.28896025e-02f, -3.45304422e-03f, 8.37019533e-02f, 2.31307074e-02f, -7.42879743e-03f, 2.65181139e-02f, -2.54440997e-02f, 7.54017895e-03f, 1.53439954e-01f, 3.55294704e-01f,
  -2.91224718e-01f, -1.60289541e-01f, -4.22932774e-01f, -5.70991598e-02f, -2.18946338e-01f, -2.32287124e-01f, -1.82490289e-01f, 1.29325330e-01f, 9.81506184e-02f, -9.97713059e-02f,
  9.24830362e-02f, 3.41258973e-01f, 2.94907689e-01f, 2.03966737e-01f, 2.56565195e-02f, -2.76719302e-01f, -2.28886485e-01f, -1.97215140e-01f, 7.85844848e-02f, 5.38502038e-02f,
  2.92653870e-02f, 1.16252145e-02f, -8.84030014e-02f, 2.11957637e-02f, -2.45025046e-02f, 4.04790379e-02f, -1.45602778e-01f, -3.86780649e-02f, -1.53453127e-01f, -3.43824834e-01f,
  -6.73185214e-02f, -5.59906363e-02f, 6.30196258e-02f, 7.36331940e-02f, 3.61000299e-02f, 2.70716101e-02f, 4.80671935e-02f, 4.72436100e-02f, 7.34929517e-02f, -5.20675220e-02f,
  3.04018729e-03f, 1.06523879e-01f, 8.05231482e-02f, -1.17359357e-02f, 1.11187436e-02f, 6.65876865e-02f, -2.77641695e-03f, -6.16706721e-02f, -3.47786136e-02f, 1.15371861e-01f,
  1.97515320e-02f, -1.89740434e-01f, -1.94399416e-01f, 3.11972797e-02f, 1.76119469e-02f, 5.00378236e-02f, -2.96505857e-02f, -2.69311480e-02f, -7.62269422e-02f, -2.19015047e-01f,
  3.35250981e-02f, -7.95202926e-02f, -1.91794839e-02f, -3.75782587e-02f, 5.47612607e-02f, 1.41336583e-02f, -6.45181090e-02f, -1.36631746e-02f, 1.84686650e-02f, -3.74061838e-02f,
  4.40317690e-02f, 1.25185167e-02f, 1.25663206e-02f, 3.47016677e-02f, 7.76598416e-03f, -8.16700235e-02f, -5.18984608e-02f, 5.22257127e-02f, 9.10537019e-02f, -2.45831273e-02f,
  3.50409038e-02f, -2.23179162e-02f, 3.49100083e-02f, -1.86956264e-02f, 5.41763566e-03f, 2.50917673e-02f, -2.28735409e-03f, 1.74162332e-02f, 1.14080841e-02f, -5.81182167e-02f,
  2.43315727e-01f, 3.74999568e-02f, -3.10698268e-03f, 7.64023960e-02f, -1.39940724e-01f, 9.45439115e-02f, -4.72169891e-02f, -2.33010072e-02f, 2.80892644e-02f, -2.89644324e-03f,
  3.72129083e-02f, -1.90532375e-02f, 2.02217586e-02f, 1.76448785e-02f, -5.66990254e-03f, 6.01310395e-02f, 3.14308628e-02f, -1.13840707e-01f, 6.21243939e-02f, 8.81046280e-02f,
  9.83779132e-03f, -2.48334687e-02f, 3.94964926e-02f, -1.07296742e-02f, 5.11460528e-02f, 2.22191792e-02f, -7.29685202e-02f, -3.78339142e-02f, -9.35553908e-02f, -1.42793894e-01f,
  6.91619962e-02f, 3.95183891e-01f, 7.78682530e-02f, 8.78526866e-02f, 7.01785535e-02f, -7.45133013e-02f, 1.13259396e-03f, -1.44147888e-01f, 8.06716830e-03f, 1.69399366e-01f,
  1.75374061e-01f, -6.26241043e-02f, -3.06424610e-02f, -2.35301554e-01f, -3.40728551e-01f, -3.90970819e-02f, -1.59814134e-01f, -2.94624507e-01f, -3.71323287e-01f, -1.64994031e-01f,
  5.27789779e-02f, -2.54962016e-02f, -9.05414894e-02f, -7.71706328e-02f, 6.30673021e-02f, -2.67065335e-02f, 1.58989131e-01f, 6.44477904e-02f, 6.18925914e-02f, 1.47376031e-01f,
  3.94752026e-01f, 2.15704769e-01f, -1.23634011e-01f, 3.42234634e-02f, 1.22143842e-01f, -9.76758823e-03f, 8.91352296e-02f, 2.01008450e-02f, -5.70196919e-02f, 2.54575834e-02f,
  1.32908314e-01f, 1.19358199e-02f, 4.21824008e-02f, 1.40894661e-02f, 7.95655847e-02f, 1.04812160e-02f, -6.18916564e-02f, -1.23434484e-01f, -5.10327592e-02f, 4.47169431e-02f,
  1.02963150e-01f, -1.60283269e-03f, 5.49477041e-02f, -3.78604606e-02f, -1.36411577e-01f, -1.35326028e-01f, 1.06174670e-01f, -3.63426320e-02f, -7.20896721e-02f, 1.55779079e-01f,
  -5.28758131e-02f, -5.75808510e-02f, -4.46038879e-02f, 7.03743324e-02f, 3.95880230e-02f, 1.05462791e-02f, -3.47092077e-02f, 5.84289320e-02f, -2.52454095e-02f, 7.83787146e-02f,
  -4.47699502e-02f, -1.82405319e-02f, -4.48990501e-02f, 1.15392301e-02f, -1.80291887e-02f, 2.17182301e-02f, -2.44354107e-03f, -5.17543033e-03f, 4.12652344e-02f, 1.68866068e-02f,
  1.68375578e-02f, 3.88536416e-02f, 7.90240020e-02f, -4.59798239e-03f, 1.77609939e-02f, -6.51923940e-02f, -4.50123511e-02f, 4.84832078e-02f, -2.67369952e-02f, 5.93000762e-02f,
  2.27438182e-01f, -2.11671516e-01f, 4.16031517e-02f, -6.05033413e-02f, 5.18570282e-02f, 1.83194727e-02f, 3.58130261e-02f, -5.57362400e-02f, 5.32458164e-02f, 2.27234662e-02f,
  -3.14604379e-02f, -5.96800111e-02f, 8.54305401e-02f, -4.65943292e-03f, -5.46916835e-02f, 2.11702138e-02f, 2.87979189e-02f, -8.06474909e-02f, -7.29494691e-02f, 1.77653700e-01f,
  1.89445075e-02f, 2.34022532e-02f, 8.71286727e-03f, 1.14918435e-02f, -2.48575788e-02f, 4.08731541e-03f, 1.85231473e-02f, 1.21150492e-02f, -9.36048031e-02f, 1.05300933e-01f,
  1.53533369e-01f, 2.18357071e-01f, 7.64745921e-02f, -4.01217341e-02f, -1.80506855e-02f, 2.01585725e-01f, 3.61360610e-01f, 2.78797209e-01f, -7.94789474e-03f, -5.55689894e-02f,
  -8.12891871e-02f, -1.77176729e-01f, -4.17101718e-02f, -4.13208604e-02f, 1.59211069e-01f, 1.79537103e-01f, 1.55058112e-02f, -3.94940889e-03f, 3.28986347e-02f, 7.81539381e-02f,
  -6.35764152e-02f, -5.55919148e-02f, -8.06791559e-02f, -4.53238562e-02f, -2.57829785e-01f, -2.20435470e-01f, -1.42872274e-01f, -1.37615740e-01f, -4.19187061e-02f, -3.29189032e-01f,
  4.78422046e-02f, 1.63137361e-01f, 1.83214415e-02f, -1.32770464e-01f, -1.71098337e-01f, 7.06377774e-02f, -1.37535725e-02f, -6.55941740e-02f, 5.56013435e-02f, 1.17094487e-01f,
  -7.51259103e-02f, 2.97029596e-02f, 1.18783035e-03f, -8.99393577e-03f, 8.89110789e-02f, 4.58070077e-02f, 6.85185939e-02f, 2.17296816e-02f, -5.63249215e-02f, -2.01128032e-02f,
  -3.75920422e-02f, 6.09021215e-03f, 7.09300637e-02f, 4.42389771e-02f, 1.24639228e-01f, -1.37039721e-01f, 1.07831948e-01f, 2.37029102e-02f, 1.15891106e-01f, 1.71205699e-01f,
  -1.73647217e-02f, 2.45499723e-02f, -9.10527185e-02f, 6.35406971e-02f, 1.88076328e-02f, 1.27171278e-02f, -6.40358999e-02f, 4.77970056e-02f, 1.58255082e-03f, 3.61524150e-02f,
  6.18040860e-02f, -2.24085413e-02f, -1.17582763e-02f, 8.97205621e-02f, -6.40813783e-02f, 1.53237218e-02f, -5.62468469e-02f, 6.86854571e-02f, -5.30162826e-03f, -1.22818174e-02f,
  5.22771291e-02f, -1.08010387e-02f, -9.46840048e-02f, 1.56692080e-02f, -6.59273341e-02f, 4.95404601e-02f, -4.90756370e-02f, 4.05052863e-03f, 1.95084151e-03f, -2.23247334e-02f,
  -3.57593060e-03f, -1.47035569e-01f, 2.55896486e-02f, 1.04974527e-02f, -1.71618350e-02f, -8.45761523e-02f, -3.94126810e-02f, 2.17233095e-02f, -1.06345057e-01f, 9.68343765e-02f,
  -2.57933065e-02f, 6.20483086e-02f, 1.83711760e-02f, -3.03175133e-02f, 5.41370064e-02f, 1.13175713e-01f, -2.12689191e-02f, -5.45485392e-02f, 6.45620003e-02f, 7.79207703e-03f,
  7.71296546e-02f, 1.48647517e-01f, 1.68764755e-01f, 2.13100195e-01f, 1.28882062e-02f, -2.00420339e-03f, 8.07291567e-02f, 5.78746572e-02f, 1.00426614e-01f, 2.04621777e-01f,
  -4.67386633e-01f, 7.81938154e-03f, -1.22908903e-02f, -2.64879525e-01f, 4.92393924e-03f, 1.16501994e-01f, 5.15785534e-03f, -9.95906740e-02f, -1.87985286e-01f, -1.07926533e-01f,
  6.29651472e-02f, 2.62533948e-02f, 6.79192925e-03f, -3.78485136e-02f, -1.55865431e-01f, -1.57039165e-01f, -2.81719536e-01f, -1.60624683e-01f, -3.77986133e-02f, -1.13225006e-01f,
  -1.94772795e-01f, -1.35578126e-01f, -2.69865036e-01f, -1.71497121e-01f, -1.66186050e-01f, -8.51965696e-02f, -6.60534203e-02f, 3.13802548e-02f, -1.33964391e-02f, -3.00224781e-01f,
  -8.55628103e-02f, 7.51204267e-02f, 4.00020033e-02f, 3.23335603e-02f, 1.20281018e-01f, 5.91045991e-02f, -3.44178788e-02f, 3.56734395e-02f, 4.87032384e-02f, 3.53301279e-02f,
  1.00545570e-01f, 9.02447924e-02f, 4.13652211e-02f, -1.45411985e-02f, -7.24972039e-02f, -1.03820525e-02f, -5.07864282e-02f, -2.93094851e-02f, 2.33346950e-02f, 4.46899049e-02f,
  1.66112557e-02f, 1.88067136e-03f, 5.36244549e-02f, 1.11967057e-01f, 6.10033982e-02f, 1.55104101e-01f, 1.90197453e-01f, 1.74314141e-01f, 4.73680571e-02f, -1.17658876e-01f,
  -2.31869686e-02f, 1.55040920e-02f, 7.08211064e-02f, 3.38294208e-02f, -4.53227572e-02f, 5.13750315e-02f, -1.21797118e-02f, -1.80513095e-02f, -5.04582450e-02f, -1.24783709e-03f,
  7.04151988e-02f, 4.69909869e-02f, -2.13928446e-02f, -1.21845931e-01f, -2.99383551e-02f, -4.71362509e-02f, 1.76339876e-02f, -2.37879027e-02f, -9.47457626e-02f, 2.49688327e-02f,
  -4.45837863e-02f, 2.89172661e-02f, -1.89333700e-03f, 1.56193580e-02f, -4.10453454e-02f, -4.56026606e-02f, 6.64293533e-03f, 1.04491830e-01f, 4.53692898e-02f, 1.30304378e-02f,
  6.98723714e-04f, 2.48067021e-01f, -6.67289719e-02f, -1.62141889e-01f, -6.69828728e-02f, -1.76593307e-02f, 1.05902866e-01f, -4.71713506e-02f, 5.91490231e-02f, -4.35016118e-02f,
  5.73367439e-02f, -8.75471458e-02f, 4.60367743e-03f, 2.13191677e-02f, -1.23752663e-02f, -4.19841744e-02f, -6.69205263e-02f, -1.24430820e-01f, -3.40897180e-02f, 2.41472218e-02f,
  -3.89524251e-02f, -1.07337765e-01f, -9.10096243e-03f, 5.96627630e-02f, 1.76463518e-02f, -1.02303706e-01f, 1.55513762e-02f, -4.62499000e-02f, 6.16276860e-02f, -1.10307164e-01f,
  -5.84430508e-02f, 2.15109199e-01f, 2.40495652e-01f, 1.32875964e-01f, -2.77299900e-03f, -1.71842948e-01f, -1.98889300e-01f, 1.72120780e-02f, -8.07927325e-02f, 7.13309795e-02f,
  -5.08413978e-05f, -9.93382335e-02f, 2.23206840e-02f, 1.81893818e-02f, -1.10328585e-01f, 1.13647468e-02f, 8.90920833e-02f, -1.02383614e-01f, -8.66630003e-02f, -2.25546032e-01f,
  -1.57740489e-01f, 1.14740178e-01f, 7.78414309e-02f, 1.07051000e-01f, -5.45853004e-02f, -1.90264687e-01f, 4.37310897e-02f, -5.18809780e-02f, -4.86669093e-02f, -6.68499395e-02f,
  -1.08773127e-01f, 2.08296105e-01f, -8.21832567e-02f, -9.21058431e-02f, 1.21202171e-01f, -1.43995751e-02f, 1.81419123e-02f, 1.76964607e-02f, 3.91073972e-02f, 5.54554574e-02f,
  -1.48315172e-04f, 6.15049601e-02f, -4.88037150e-03f, 5.77808432e-02f, 5.35235219e-02f, -9.52857882e-02f, 7.02321082e-02f, 1.10245042e-01f, 2.86457427e-02f, 4.02917303e-02f,
  -3.95548306e-02f, -7.29081482e-02f, -3.21823619e-02f, -5.33058820e-03f, -9.70522873e-03f, -1.38712198e-01f, -7.79167041e-02f, -2.84231510e-02f, -1.76246032e-01f, -4.62372676e-02f,
  -1.21594936e-01f, 4.52671908e-02f, -3.96990292e-02f, 9.02065039e-02f, -6.10795729e-02f, 2.25102459e-03f, 2.52145175e-02f, 1.68050602e-02f, -1.17032044e-02f, -9.72946989e-04f,
  2.72928495e-02f, -7.71343522e-03f, 8.24305266e-02f, 4.65821028e-02f, 5.94659522e-03f, 2.95663569e-02f, 1.69420782e-02f, 3.51748765e-02f, 1.72673967e-02f, 4.52461131e-02f,
  -1.05502214e-02f, -7.64633939e-02f, 4.36972566e-02f, -4.41210642e-02f, -3.99191864e-02f, 6.91955388e-02f, -5.93962194e-03f, -2.55619511e-02f, 2.21985914e-02f, 8.72306973e-02f,
  -3.77453640e-02f, 1.28475726e-01f, -1.39331445e-01f, -1.20772779e-01f, 3.27865034e-02f, -2.30236314e-02f, 9.70150158e-02f, 6.38796911e-02f, 1.29932851e-01f, -3.71224731e-02f,
  -2.96414504e-03f, 2.62999106e-02f, 3.98676060e-02f, 1.19209513e-02f, -8.77618715e-02f, -8.20764750e-02f, -1.04847290e-02f, -2.75863949e-02f, -8.30001161e-02f, 9.36006755e-02f,
  8.05620366e-05f, -2.87127256e-01f, -2.80609727e-01f, -1.70381442e-01f, -9.58294719e-02f, -2.25588262e-01f, -1.31899521e-01f, -1.99065775e-01f, -1.96273774e-01f, -2.38244057e-01f,
  5.93108237e-01f, -3.81997645e-01f, 2.55362958e-01f, -8.34875554e-02f, -2.06090480e-01f, -4.55633253e-02f, -2.22772792e-01f, -2.01490964e-03f, 2.87072849e-03f, -2.16956958e-01f,
  -9.15585533e-02f, 4.51989397e-02f, 1.27653137e-01f, 2.05048665e-01f, 3.39491904e-01f, -1.98699102e-01f, -1.79164857e-01f, 2.32236430e-01f, 5.30589700e-01f, 1.71972454e-01f,
  -2.74855614e-01f, 3.61590721e-02f, 1.86037511e-01f, 2.78366581e-02f, -2.99581707e-01f, -8.09187889e-02f, -1.37518317e-01f, -5.38281016e-02f, -1.96560562e-01f, -4.80666965e-01f,
  8.57860744e-02f, 3.73302102e-02f, 1.03635900e-01f, -2.04706527e-02f, 4.39315243e-03f, 9.70101431e-02f, 5.15669882e-02f, 2.33222488e-02f, 4.27527316e-02f, -7.78378323e-02f,
  -6.61501810e-02f, 5.69264777e-03f, 5.23919798e-03f, -3.86197232e-02f, 3.77732478e-02f, 1.00249164e-02f, -1.89311318e-02f, 1.33365929e-01f, 2.25385517e-01f, 1.12082027e-02f,
  -2.80965507e-01f, -1.76204190e-01f, 1.08634964e-01f, -4.08781990e-02f, 8.29110220e-02f, 1.01469301e-01f, -4.43088822e-02f, 9.82815549e-02f, 2.64348328e-01f, -1.20379351e-01f,
  -4.49161418e-02f, -2.49595158e-02f, -3.59502807e-02f, 7.21417181e-03f, -3.77439596e-02f, -2.60959426e-03f, 2.67526433e-02f, -3.25201973e-02f, -5.47190988e-03f, -3.29049192e-02f,
  6.59831911e-02f, -1.19356792e-02f, 4.14186344e-02f, 5.39740501e-03f, -1.43397124e-02f, -2.43321378e-02f, 2.63725854e-02f, -6.20863140e-02f, 7.45018050e-02f, -3.83592956e-02f,
  3.61235440e-02f, 5.97200766e-02f, -5.12968972e-02f, 2.89902128e-02f, -4.22930792e-02f, 1.54427141e-02f, 1.35113922e-04f, -2.48459019e-02f, 1.83046851e-02f, -4.13509011e-02f,
  7.34730288e-02f, 2.53212363e-01f, -1.89757254e-02f, 6.01415671e-02f, 2.40566172e-02f, 6.42443029e-03f, -6.14805100e-03f, -2.42730863e-02f, -5.07843755e-02f, 4.84361639e-03f,
  7.65826851e-02f, 9.95834842e-02f, 8.76849424e-03f, 7.56739033e-03f, 1.72583424e-02f, -2.65898574e-02f, -1.39166906e-01f, 6.68460429e-02f, 4.87952773e-03f, -2.90933736e-02f,
  -1.09944053e-01f, 3.23677696e-02f, 6.60762414e-02f, 4.06527147e-02f, -5.76062594e-03f, 1.48736790e-01f, 4.34331298e-02f, -5.58860935e-02f, 1.94398537e-01f, -1.46857664e-01f,
  8.05964291e-01f, 1.84085101e-01f, -1.63005307e-01f, 2.24968046e-02f, -1.58098683e-01f, -2.75707096e-01f, -1.82896957e-01f, 8.70004520e-02f, 5.23585156e-02f, 7.58244842e-02f,
  -1.55466214e-01f, 9.32842866e-02f, 9.25075412e-02f, 4.46823575e-02f, -1.40038216e-02f, -1.37233153e-01f, -2.10529909e-01f, 2.13456135e-02f, 7.51747489e-02f, 7.45190084e-02f,
  -1.17462300e-01f, 3.79125401e-02f, 2.26637661e-01f, 1.46896988e-01f, 1.41305281e-02f, 2.39786692e-02f, 4.37894799e-02f, -1.41083831e-02f, 9.29187611e-03f, 2.19562411e-01f,
  2.03576490e-01f, 2.80938447e-01f, -4.08140972e-04f, -3.51082608e-02f, -1.44659892e-01f, 1.53958693e-01f, 9.46246739e-03f, 1.97769329e-02f, -2.86178235e-02f, 2.20768945e-03f,
  4.65983786e-02f, 5.39277913e-03f, 2.62744110e-02f, 4.07764502e-02f, 9.96659249e-02f, -1.25476625e-02f, -1.60276964e-02f, 2.70682424e-02f, -2.64450274e-02f, 6.46922812e-02f,
  -1.70232490e-01f, -3.02223787e-02f, 1.93856973e-02f, 2.31586806e-02f, -4.13559889e-03f, -1.02162331e-01f, 4.33308557e-02f, 1.34717613e-01f, 8.87582079e-02f, 2.60782152e-01f,
  1.01752821e-02f, 2.24789921e-02f, 2.03771461e-02f, 7.01751933e-02f, 1.43706314e-02f, 3.69661413e-02f, -5.33374539e-03f, -5.29386438e-02f, 3.72705385e-02f, -6.64406223e-03f,
  6.27745129e-03f, -9.44000110e-03f, 7.13806674e-02f, 8.81508663e-02f, -1.00843824e-01f, 2.75937113e-04f, 4.05785181e-02f, -4.93627824e-02f, -3.24735865e-02f, 5.67240976e-02f,
  6.05352037e-02f, 5.16854152e-02f, -6.54406622e-02f, 4.49352153e-02f, 3.20348702e-03f, -1.29093677e-02f, 2.25457810e-02f, 3.87650952e-02f, -7.26267844e-02f, 2.47410312e-02f,
  7.87171870e-02f, -1.97831526e-01f, 1.92413554e-01f, 1.26091734e-01f, -3.82523201e-02f, -7.81775266e-02f, -6.73892945e-02f, 2.42704637e-02f, 6.71534427e-03f, 1.16233490e-01f,
  1.10315038e-02f, 3.60376202e-02f, -4.06560190e-02f, -1.15297576e-02f, -4.52971533e-02f, -1.37808388e-02f, -1.16787665e-01f, -1.66771235e-03f, -1.02832876e-01f, -1.68571278e-01f,
  -1.18534215e-01f, 6.23793043e-02f, 9.75576490e-02f, -2.76786312e-02f, 9.87663567e-02f, 1.10672608e-01f, 3.70897502e-02f, 1.38869688e-01f, 6.28343523e-02f, 1.92835748e-01f,
  -3.58042866e-01f, -2.85745651e-01f, -3.35220575e-01f, -1.07439116e-01f, -6.97448403e-02f, -4.33533117e-02f, 6.06057607e-02f, 2.04236761e-01f, 1.21276148e-01f, -1.26579776e-01f,
  1.18997142e-01f, 1.55223280e-01f, 2.13663384e-01f, 1.52528718e-01f, 1.44776292e-02f, -1.77246526e-01f, -2.64034003e-01f, -6.97834790e-02f, 1.88778922e-01f, 1.91151336e-01f,
  1.48820775e-02f, -8.25286359e-02f, -7.81695172e-02f, 3.77733111e-02f, -9.26855803e-02f, 9.94975585e-03f, -1.62280798e-01f, -1.49376422e-01f, -1.44219100e-01f, -2.91900456e-01f,
  -1.22909606e-01f, -2.33760402e-01f, 2.08401695e-01f, -1.05926329e-02f, -6.94262460e-02f, -9.29948967e-03f, 7.23870657e-03f, 9.85753536e-03f, 5.78433974e-03f, -1.34082213e-01f,
  -5.12681715e-02f, -2.82068853e-03f, -5.43492138e-02f, 3.22595090e-02f, 2.84855813e-02f, -4.75029973e-03f, 1.43595440e-02f, -1.37021065e-01f, -6.15961775e-02f, 6.82612509e-02f,
  2.55293045e-02f, -1.82069406e-01f, -1.17548123e-01f, -4.82270727e-03f, -3.91847193e-02f, 3.81281935e-02f, -6.70671612e-02f, -1.90514959e-02f, -3.51666212e-02f, -1.40113711e-01f,
  2.50298977e-02f, -5.34261987e-02f, 2.46171694e-04f, 6.48269197e-03f, 4.87334281e-02f, 2.23547108e-02f, -3.69871743e-02f, -2.37411875e-02f, 6.01519551e-03f, -2.27736682e-02f,
  -5.71637899e-02f, 2.68122237e-02f, 4.63583395e-02f, -6.86733611e-03f, -1.31504936e-02f, -3.34052593e-02f, -5.07346354e-02f, -1.61224063e-02f, 7.03194141e-02f, 2.28505656e-02f,
  -3.47479470e-02f, -5.02236784e-02f, -6.15733936e-02f, 9.34146997e-03f, 1.38639063e-02f, -7.34893531e-02f, -2.53215758e-03f, 4.71305028e-02f, 2.23986898e-02f, 6.53698109e-03f,
  3.57845008e-01f, 1.60216257e-01f, -3.39605771e-02f, 1.03873625e-01f, -2.52167806e-02f, -1.46621689e-02f, 7.57838041e-03f, 3.59496847e-02f, -4.36818264e-02f, 5.82657494e-02f,
  -3.66596575e-03f, 1.53729869e-02f, 2.04131403e-03f, -4.53398423e-03f, -1.66044775e-02f, 8.56485888e-02f, 1.06020330e-03f, -1.63207948e-02f, 1.46047741e-01f, -2.77782045e-02f,
  -9.52841900e-03f, 2.78967321e-02f, 1.13220215e-01f, 7.16327429e-02f, 5.49736395e-02f, 1.72907263e-01f, 1.73382223e-01f, 2.04572365e-01f, 1.12326533e-01f, 1.16818808e-01f,
  -8.68935436e-02f, 1.90842152e-01f, 2.95980275e-01f, 9.07603651e-02f, 1.31913215e-01f, 4.67693657e-02f, 9.39011872e-02f, -3.19469720e-02f, -5.67681901e-02f, 1.08894490e-01f,
  -9.46480408e-03f, 7.92126358e-03f, -5.44042066e-02f, 8.39666347e-04f, -4.22814488e-03f, 1.26630947e-01f, 5.12633100e-02f, 8.15096051e-02f, -5.52691482e-02f, -9.12603736e-03f,
  6.04068227e-02f, 1.44725099e-01f, 7.93366060e-02f, 2.54017450e-02f, 1.03561906e-02f, 3.65418941e-02f, 1.42223671e-01f, 7.87998736e-02f, 1.02524966e-01f, 8.55342746e-02f,
  -8.99324194e-02f, 1.66974142e-01f, -1.45976812e-01f, -1.39928097e-02f, -9.92817618e-03f, -1.64840028e-01f, -6.38716444e-02f, -1.14377275e-01f, -6.33624718e-02f, 4.18892726e-02f,
  4.52481732e-02f, -8.17142874e-02f, 5.18467873e-02f, 2.22846214e-02f, 5.50643504e-02f, -1.37294652e-02f, -8.37081298e-03f, 1.43574789e-01f, 8.29464719e-02f, 6.66649714e-02f,
  1.89165294e-01f, 9.86109525e-02f, 1.05416723e-01f, 2.85751023e-03f, 9.80779827e-02f, -4.28767800e-02f, 1.04475997e-01f, 3.54990438e-02f, 9.52944756e-02f, -5.94502920e-03f,
  -8.74973740e-03f, -5.44080697e-02f, -8.11990350e-02f, 1.91517193e-02f, 1.26916794e-02f, -4.70768027e-02f, -7.40508921e-03f, -1.31364325e-02f, -7.52567798e-02f, -2.72780322e-02f,
  2.90558022e-02f, 9.48224440e-02f, 1.03088714e-01f, 2.10153554e-02f, -5.25931828e-02f, 2.60456093e-02f, 1.16511378e-02f, 4.73697111e-02f, -9.36391428e-02f, -6.60483353e-03f,
  -7.44052883e-03f, -1.44162504e-02f, 2.34866422e-02f, -5.54669313e-02f, 8.17417130e-02f, 5.39139882e-02f, -8.25844929e-02f, -1.86083596e-02f, 3.15408483e-02f, -1.29880132e-02f,
  -1.57286033e-01f, 1.01507440e-01f, -4.93995175e-02f, -1.35490047e-02f, -5.91888539e-02f, 2.46395189e-02f, 7.61067122e-02f, 2.34277509e-02f, -1.67022347e-02f, -3.51870134e-02f,
  3.87957618e-02f, -2.68877037e-02f, 2.30243634e-02f, -3.81028466e-02f, -1.20815217e-01f, 1.65491551e-02f, -3.07361241e-02f, 5.46061508e-02f, -3.61774452e-02f, 1.02335282e-01f,
  4.04571034e-02f, -4.78850938e-02f, -2.47111768e-01f, -1.44052327e-01f, 6.16637096e-02f, -8.04668665e-02f, -1.43066809e-01f, -1.41491428e-01f, -1.14573307e-01f, -2.72113740e-01f,
  -3.02316904e-01f, -1.17724307e-01f, 6.62347898e-02f, -1.44756446e-02f, 1.22896791e-01f, 2.74159256e-02f, 1.24034785e-01f, -3.10167633e-02f, -9.82880890e-02f, -2.16004401e-01f,
  5.54930903e-02f, -9.91465375e-02f, -1.19312555e-01f, 2.53693443e-02f, 1.25697134e-02f, -2.68450342e-02f, 1.02628462e-01f, 3.47500443e-02f, 1.40879422e-01f, 2.57659368e-02f,
  1.02985024e-01f, 2.19803378e-02f, 1.07528511e-02f, 4.38974611e-02f, -6.09165691e-02f, 4.69608903e-02f, -8.82380456e-02f, 8.05640072e-02f, 9.51256379e-02f, 1.97344683e-02f,
  -1.80512786e-01f, 1.01231955e-01f, 2.08729114e-02f, 8.27670470e-02f, 1.63608347e-05f, -9.18807983e-02f, 4.22860570e-02f, -3.34260277e-02f, 9.14896745e-03f, -8.42211246e-02f,
  9.60911810e-02f, 5.90227507e-02f, 6.03852123e-02f, 4.21222374e-02f, 3.64270248e-02f, 7.28156045e-02f, 8.84191506e-03f, -4.45820242e-02f, 4.61070500e-02f, -1.42978616e-02f,
  7.34461918e-02f, 1.91728875e-01f, 9.45041031e-02f, -4.29833084e-02f, -8.49092379e-03f, 1.63731605e-01f, -5.78772463e-02f, 9.87718776e-02f, -5.95267266e-02f, -1.51109859e-01f,
  -4.13743481e-02f, 2.02383138e-02f, -9.22727492e-03f, -2.95040058e-03f, -2.37703659e-02f, 9.21801664e-03f, 1.96901932e-02f, -6.61364617e-03f, 7.81672820e-03f, -3.44860996e-03f,
  -7.32430862e-03f, -1.08844109e-01f, 1.92903336e-02f, -5.92055023e-02f, -3.46340425e-02f, 5.36053441e-02f, 8.41800719e-02f, -8.31070691e-02f, 3.86481322e-02f, -2.02028137e-02f,
  1.19461566e-02f, 4.36861850e-02f, -4.43429267e-03f, -4.46340302e-04f, 3.23619768e-02f, 2.82621160e-02f, 5.48098385e-02f, -1.27430819e-02f, -6.97366223e-02f, -8.52433033e-04f,
  -4.34803456e-01f, 2.14288950e-01f, -1.34722799e-01f, 4.24899161e-02f, 2.99029611e-02f, 1.49103440e-02f, -7.70377591e-02f, 1.11396881e-02f, 4.70983051e-02f, -7.27826878e-02f,
  3.85443047e-02f, -8.77293050e-02f, -5.58163133e-03f, -1.20465206e-02f, -2.27849721e-03f, -6.71469867e-02f, -3.28037329e-02f, -3.81011367e-02f, 1.66088939e-02f, -7.60427583e-03f,
  -9.00581293e-03f, -1.29367739e-01f, -1.77054197e-01f, -1.17042087e-01f, 8.37284401e-02f, -9.00471061e-02f, -1.35679021e-01f, -1.13334671e-01f, -1.24571010e-01f, -4.47713256e-01f,
  6.03004061e-02f, 2.85420567e-01f, -5.35085537e-02f, 1.81685448e-01f, -1.79041162e-01f, -4.83356565e-01f, -2.47010589e-01f, -1.78096250e-01f, 2.16485970e-02f, -4.99001183e-02f,
  -6.42824993e-02f, 5.80601469e-02f, 1.63048252e-01f, 2.64718966e-03f, 4.45896126e-02f, -2.50575636e-02f, 1.82140112e-01f, 9.69656780e-02f, -4.49084900e-02f, -1.59166753e-01f,
  1.02036878e-01f, 1.61073416e-01f, 8.90013278e-02f, 1.23410247e-01f, 1.19774438e-01f, 8.80873576e-02f, 4.40558083e-02f, 5.17575182e-02f, 5.89191578e-02f, 4.50149477e-01f,
  3.02693814e-01f, 8.02364200e-03f, -4.80820462e-02f, 7.34167472e-02f, -2.44858600e-02f, 3.08139771e-02f, -2.06520017e-02f, 4.14967090e-02f, 1.31723722e-02f, -3.04464530e-03f,
  -2.70799547e-02f, 2.90935542e-02f, 6.30206894e-03f, 3.21334116e-02f, 1.00533280e-03f, -3.27399783e-02f, 6.66132793e-02f, 1.19267553e-01f, 1.93605535e-02f, 1.05320193e-01f,
  1.34905711e-01f, -1.32585526e-01f, -7.69478902e-02f, -1.68575823e-01f, -9.77944881e-02f, -5.63463382e-02f, -1.56615470e-02f, -9.38640609e-02f, -1.56853452e-01f, 2.56113000e-02f,
  -1.83034018e-02f, -3.72931585e-02f, -1.00404568e-01f, 4.43813130e-02f, -1.10925492e-02f, -1.86340939e-02f, 5.18838875e-02f, 2.72411737e-03f, -2.58376431e-02f, 2.57880483e-02f,
  -1.13995075e-02f, 2.01836857e-03f, -2.39522406e-03f, 4.39540967e-02f, 4.00402285e-02f, -4.50792117e-03f, -3.60455848e-02f, 4.14310619e-02f, 2.91043874e-02f, -3.18391249e-02f,
  2.56838538e-02f, -5.68407886e-02f, -4.75138128e-02f, 6.07164949e-02f, 1.18791182e-02f, 6.73227571e-03f, 1.20163092e-03f, -2.09291354e-02f, -2.13403944e-02f, 1.47907455e-02f,
  7.39926025e-02f, -2.91090518e-01f, 1.67403325e-01f, 4.08664756e-02f, 2.44079307e-02f, 5.96568473e-02f, 4.77590077e-02f, 5.85857891e-02f, -2.50073876e-02f, 4.16495353e-02f,
  -9.37476940e-03f, 6.65835738e-02f, 5.37497923e-02f, -2.36577675e-04f, -1.09538428e-01f, -8.55099708e-02f, -1.18138315e-02f, 6.15931451e-02f, -6.95804283e-02f, 1.09575847e-02f,
  6.14225827e-02f, -1.43071979e-01f, -7.31317978e-03f, -8.93021747e-02f, -6.59816042e-02f, -5.26208393e-02f, 3.55390869e-02f, 2.56952792e-02f, -1.45682544e-01f, -2.68497821e-02f,
  -4.86543834e-01f, 2.70267069e-01f, 2.00945213e-01f, -2.53718942e-01f, -7.87242055e-02f, 1.72641575e-01f, 2.85661012e-01f, -8.94781947e-02f, -2.37725198e-01f, 9.33939591e-02f,
  1.17237829e-01f, -9.38626751e-02f, -1.11176923e-01f, -5.42729115e-03f, 8.99437070e-02f, 1.61618590e-01f, 8.20896924e-02f, -1.00609355e-01f, -4.34941575e-02f, -1.01196647e-01f,
  -7.90043082e-03f, -1.57340258e-01f, -2.00773943e-02f, -4.13209982e-02f, 2.87332293e-02f, -1.33508118e-03f, 1.78172022e-01f, 1.49501517e-01f, 1.30218506e-01f, 7.63394535e-02f,
  1.67861655e-01f, -7.34288245e-02f, -7.42494091e-02f, -1.47303969e-01f, 8.69430900e-02f, -6.86573684e-02f, -6.93584513e-03f, -2.94594094e-02f, -3.35449688e-02f, -1.37439631e-02f,
  -6.28969446e-02f, -6.99565709e-02f, -4.30477001e-02f, 6.73900396e-02f, -5.89382388e-02f, 4.17807363e-02f, 8.49282146e-02f, -3.93226556e-02f, 8.13204348e-02f, -8.82949644e-06f,
  -4.34416048e-02f, -3.99322510e-02f, 4.73449752e-02f, 1.68937564e-01f, 9.27634463e-02f, -4.93647791e-02f, 5.67606352e-02f, 1.08150803e-01f, 1.69227630e-01f, 1.66161300e-03f,
  -4.85702157e-02f, -2.44039614e-02f, 1.90923940e-02f, -6.21330440e-02f, 1.98574439e-02f, 5.97110428e-02f, -6.26769364e-02f, 9.25401971e-02f, 5.36571369e-02f, 1.11488355e-02f,
  6.60793064e-03f, -2.93581542e-02f, -3.35658453e-02f, 3.49540217e-03f, -5.54403625e-02f, 4.62142788e-02f, 6.63386611e-03f, -3.76728084e-03f, 6.06976002e-02f, -6.64241165e-02f,
  -3.23851854e-02f, 8.93900264e-03f, -1.01118214e-01f, 3.18904184e-02f, -9.80737712e-03f, 1.81873366e-02f, 2.34083878e-03f, -9.86532657e-04f, 3.94883659e-03f, 3.35615017e-02f,
  2.24740128e-03f, 4.90321033e-02f, -8.36178139e-02f, -6.87724352e-02f, -7.10233599e-02f, 5.19697778e-02f, -3.34790461e-02f, -5.99599583e-03f, -1.14873081e-01f, 4.03401405e-02f,
  -2.13549919e-02f, 4.04161103e-02f, 8.46263915e-02f, 1.72005761e-02f, 4.67913635e-02f, -9.72431377e-02f, 9.30854455e-02f, -4.74519134e-02f, 2.96022724e-02f, -5.62437810e-02f,
  6.06983900e-02f, 6.91510784e-03f, 4.31009866e-02f, -1.75608024e-02f, -3.38731110e-02f, -1.08445160e-01f, 1.97406530e-01f, 5.67638911e-02f, -4.79202601e-04f, 5.29433377e-02f,
  7.77310133e-03f, -3.65392156e-02f, -3.74705672e-01f, -2.04664692e-01f, -2.61748254e-01f, -2.55334854e-01f, -1.27958078e-02f, 4.60181572e-03f, -7.89908990e-02f, -2.00338215e-01f,
  -7.32578859e-02f, -9.91558097e-03f, 1.97539367e-02f, 7.31870905e-02f, -5.58799654e-02f, -1.01998642e-01f, -1.93306163e-01f, -1.13229848e-01f, -1.95103541e-01f, -1.60504729e-01f,
  -2.87720021e-02f, -1.99201226e-01f, -8.03846344e-02f, -3.38792615e-02f, -7.32073486e-02f, -1.25712767e-01f, -1.88967198e-01f, -1.64264634e-01f, -1.60951149e-02f, -6.67661577e-02f,
  -3.21955800e-01f, 9.65743288e-02f, 5.87603189e-02f, 8.72294903e-02f, -2.43125446e-02f, -4.56597097e-02f, -4.00301665e-02f, 1.27747310e-02f, 6.96452111e-02f, -1.59790870e-02f,
  -9.78466570e-02f, -5.39553352e-02f, -2.25465633e-02f, -6.89699799e-02f, -1.06373236e-01f, 1.43029550e-02f, -7.02478439e-02f, 6.04975689e-03f, -7.10587427e-02f, -9.54227801e-03f,
  3.14347050e-03f, -9.42718759e-02f, -2.72006951e-02f, -1.19839050e-02f, 1.04627691e-01f, -1.94858070e-02f, 5.80138005e-02f, 4.73501049e-02f, -5.10702096e-02f, 1.07999586e-01f,
  -4.03148159e-02f, -4.80293036e-02f, -3.59271653e-02f, 8.67306292e-02f, 1.22525673e-02f, -6.16735965e-03f, -7.11659575e-03f, 4.72905347e-04f, 5.13913520e-02f, 7.89923817e-02f,
  -1.72317326e-02f, -4.62891757e-02f, 4.93752919e-02f, 2.10420396e-02f, -1.64118055e-02f, 8.90791789e-03f, 4.42557558e-02f, 3.34285758e-02f, -4.98770224e-03f, -6.21508770e-02f,
  8.02668482e-02f, 2.95595583e-02f, -7.69543722e-02f, 9.75314826e-02f, -7.07854629e-02f, -7.14858770e-02f, -1.54637154e-02f, -1.41239837e-02f, -7.62287667e-03f, 5.65229403e-03f,
  1.72463655e-01f, -2.67006531e-02f, -1.91713143e-02f, 1.43526182e-01f, -8.04579630e-02f, -1.21916765e-02f, 4.00884002e-02f, 1.22459382e-01f, -2.37168185e-02f, 2.11199163e-03f,
  6.33667707e-02f, -8.83608963e-03f, 2.57129278e-02f, -4.11941372e-02f, 5.88753540e-03f, -6.62081391e-02f, 2.96679828e-02f, -4.98111993e-02f, 7.16312230e-02f, 2.59850100e-02f,
  1.85877401e-02f, -1.17068645e-02f, 1.32306471e-01f, 1.24739103e-01f, 1.92739663e-03f, 5.12787402e-02f, 7.88280815e-02f, 1.01971380e-01f, -1.75527092e-02f, 3.88165005e-02f,
  -1.77016910e-02f, -2.04356045e-01f, -4.25997853e-01f, 8.81506130e-04f, -3.24345201e-01f, -2.16889814e-01f, -3.63773733e-01f, -4.59466688e-02f, 1.83784351e-01f, -8.48827586e-02f,
  -1.24113418e-01f, -3.33723314e-02f, -5.24708442e-02f, 8.96225870e-02f, -1.64005663e-02f, -6.25492334e-02f, -1.34895861e-01f, 1.85484923e-02f, -4.07441100e-03f, 7.92741030e-02f,
  5.79529479e-02f, -7.35610276e-02f, -5.23841335e-03f, 9.78541374e-03f, 9.35076401e-02f, 1.16226953e-02f, -1.06650151e-01f, -4.46269959e-02f, 4.73329090e-02f, 4.12449315e-02f,
  -1.53033793e-01f, -2.26297110e-01f, -1.40570374e-02f, 5.42532355e-02f, 6.25692774e-03f, 8.01750943e-02f, -2.45776703e-03f, -2.78617386e-02f, -5.99342994e-02f, 8.92515108e-03f,
  1.80818047e-02f, 4.29996289e-03f, -1.27494797e-01f, 9.98326093e-02f, -7.46046156e-02f, -2.28315275e-02f, 1.32260308e-01f, 1.05096921e-01f, 2.80187726e-02f, -1.53370667e-02f,
  3.18574272e-02f, -1.05222166e-01f, -2.32559443e-01f, -6.88009011e-03f, 2.98480075e-02f, -2.87910528e-03f, -1.17929891e-01f, 8.87997672e-02f, -1.96103398e-02f, 8.91787857e-02f,
  1.14872465e-02f, 2.98829172e-02f, -1.48726357e-02f, 1.56017300e-02f, 1.52933775e-02f, 3.93816829e-02f, -4.09116857e-02f, 1.24354046e-02f, -3.45252939e-02f, 8.77417028e-02f,
  -1.61986821e-03f, -8.70840624e-03f, -1.25178648e-02f, -2.42200997e-02f, -6.23086244e-02f, -2.54306216e-02f, 1.47283245e-02f, 3.01681925e-02f, -2.24768091e-02f, 9.56272334e-03f,
  2.98854392e-02f, 7.27440184e-03f, 5.67677245e-02f, 9.62714292e-03f, -9.49369557e-03f, 5.77912889e-02f, 2.52267346e-02f, -3.91232595e-02f, -1.16431154e-02f, -8.94365832e-02f,
  5.77583797e-02f, -1.97675020e-01f, 6.01971038e-02f, 7.20686167e-02f, 1.14002153e-02f, 1.03627734e-01f, -3.56276259e-02f, 4.53103445e-02f, 1.96176413e-02f, -4.01961282e-02f,
  -8.21273997e-02f, 5.84365018e-02f, -8.20357054e-02f, -2.42178049e-02f, -2.66045220e-02f, 6.98169693e-02f, 1.70750618e-02f, 2.02239701e-03f, 7.03484938e-02f, 1.30965203e-01f,
  4.54128124e-02f, 4.79169702e-03f, -8.51479620e-02f, -1.06500834e-02f, 8.18869919e-02f, -4.55147624e-02f, -1.18328184e-01f, 6.16943883e-03f, -3.88218910e-02f, 1.64952591e-01f
};

// L0_fan_Wp_bar (Shape: 26 x 120)
const int L0_fan_Wp_bar_rows = 26;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  2.14485496e-01f, -2.33384579e-01f, -3.35108966e-01f, 2.70061428e-03f, -9.57731679e-02f, -1.96949676e-01f, -3.17119628e-01f, -1.29848763e-01f, 1.08158402e-01f, -4.08445597e-02f,
  6.48370907e-02f, 8.26081261e-02f, -1.34591488e-02f, 1.34140968e-01f, -8.11104998e-02f, -2.22902939e-01f, -2.36217692e-01f, -4.40550782e-02f, 1.39555976e-01f, 1.71299383e-01f,
  1.25799552e-01f, 1.35068610e-01f, 5.76421134e-02f, 5.60315698e-02f, -1.32966693e-02f, 4.51832600e-02f, 5.55339037e-03f, -3.08038238e-02f, -9.17316079e-02f, -1.62726432e-01f,
  -1.59134120e-01f, -3.94031256e-02f, 9.81409103e-03f, 1.38057068e-01f, -7.62689337e-02f, 3.91705334e-02f, -4.82332595e-02f, -3.34779806e-02f, -7.63635784e-02f, 2.55923904e-02f,
  -2.20639594e-02f, 8.24243501e-02f, -5.32500967e-02f, -6.92902431e-02f, -3.69752431e-03f, -5.55351228e-02f, -3.74804772e-02f, 3.84624712e-02f, -3.21232192e-02f, -9.97578800e-02f,
  3.98161449e-03f, -5.76062351e-02f, 2.94289514e-02f, -1.10509627e-01f, -1.00788623e-01f, 8.04091394e-02f, -1.53335229e-01f, -9.12409574e-02f, -1.28928840e-01f, -9.22305137e-02f,
  -9.17686448e-02f, -5.36593907e-02f, 2.74581499e-02f, -2.73660328e-02f, 1.13528557e-01f, -2.82573830e-02f, 4.55170125e-02f, -1.69911503e-03f, -4.37077694e-02f, 1.61406826e-02f,
  -5.56447357e-02f, -5.32556921e-02f, 2.30396446e-03f, 3.30993906e-02f, -9.09526180e-03f, 1.00831343e-02f, 6.63159490e-02f, -7.30637163e-02f, 8.16448927e-02f, 6.99383467e-02f,
  2.26675346e-02f, -3.79070528e-02f, -6.42728657e-02f, -2.20744293e-02f, 3.28068063e-02f, -4.97098640e-02f, -4.31916453e-02f, -3.19359377e-02f, 7.92570263e-02f, 6.21742522e-03f,
  8.24724585e-02f, 1.72533412e-02f, 2.63497904e-02f, -1.21693388e-02f, -2.20392235e-02f, -6.11543879e-02f, 2.38769483e-02f, -5.03055640e-02f, 8.02999139e-02f, -4.75941673e-02f,
  5.31894378e-02f, -2.84088962e-03f, -7.49549344e-02f, 4.06486392e-02f, 7.92123303e-02f, 2.46929564e-02f, 5.88350603e-03f, -5.89398406e-02f, -1.10404547e-02f, -1.00031987e-01f,
  -7.50115067e-02f, -1.15587443e-01f, -6.16864339e-02f, -8.74920189e-02f, -5.40964156e-02f, 9.73579437e-02f, -1.45777866e-01f, -1.16834059e-01f, -6.53008884e-03f, -1.43099248e-01f,
  1.19172446e-01f, 7.95977488e-02f, -1.88934147e-01f, 1.80545688e-01f, 4.86403517e-02f, -1.43393651e-01f, -1.13424279e-01f, 1.35529917e-02f, 2.24986952e-03f, 1.83934122e-01f,
  9.89070460e-02f, 1.66920453e-01f, 1.56826392e-01f, -1.27312038e-02f, 2.69785244e-02f, 8.46963152e-02f, 1.80801246e-02f, 2.16974281e-02f, -7.73528218e-03f, -1.95098780e-02f,
  1.93886742e-01f, 8.07913169e-02f, -3.06103714e-02f, -2.95486804e-02f, 1.06879003e-01f, 1.64344206e-01f, 5.82308620e-02f, 4.78830002e-02f, -2.59342082e-02f, 1.43561825e-01f,
  2.69855894e-02f, -1.97668493e-01f, -5.68793938e-02f, 1.56153589e-01f, 6.55956045e-02f, 2.08167322e-02f, -2.24683201e-03f, 9.35074594e-03f, 6.12765998e-02f, -1.80598535e-02f,
  -1.35026779e-02f, -2.59101707e-02f, -1.82055291e-02f, -3.48466001e-02f, -1.10169547e-02f, -8.74954835e-03f, -9.67827737e-02f, 2.59768567e-04f, -8.92348588e-03f, -5.67547567e-02f,
  5.85425161e-02f, 4.01777141e-02f, -9.88206938e-02f, -1.37174144e-01f, -2.75667827e-03f, -7.74300098e-02f, -1.22435980e-01f, -5.15132137e-02f, -4.17406149e-02f, -2.88614929e-02f,
  -8.83083604e-03f, -7.60697797e-02f, -5.68315424e-02f, 8.70207883e-03f, -6.65117428e-02f, 7.80421868e-02f, -3.45789604e-02f, 7.86846131e-02f, -3.43726687e-02f, 7.09789768e-02f,
  -1.67278163e-02f, -8.53435472e-02f, 1.95622537e-02f, 6.83485791e-02f, 6.19888194e-02f, -8.81014764e-02f, -6.98380545e-02f, -2.62823682e-02f, -1.04795836e-01f, -2.01922450e-02f,
  4.30610403e-03f, 1.04710339e-02f, -3.85156348e-02f, -9.61519331e-02f, -5.37664071e-02f, -1.52028445e-02f, -1.01116613e-01f, -6.05479702e-02f, 3.77219170e-02f, -5.94549701e-02f,
  2.61124283e-01f, -1.17331631e-01f, 4.39500436e-02f, -1.37613369e-02f, -8.78562685e-03f, -7.55673796e-02f, -7.15976860e-03f, -9.77736712e-03f, 2.10134387e-02f, 2.14719400e-02f,
  -1.22091524e-01f, -8.77995491e-02f, 1.16026081e-01f, -7.11552128e-02f, -6.59231916e-02f, 4.82984744e-02f, 6.23516776e-02f, -1.42677650e-02f, -5.04273809e-02f, -1.78462815e-05f,
  8.94428417e-02f, -1.31756356e-02f, 1.26535356e-01f, 1.02542505e-01f, -5.44219278e-02f, 1.30259514e-01f, -5.75621165e-02f, 1.55408829e-02f, -7.50430003e-02f, 2.17010435e-02f,
  1.86412796e-01f, 1.27273247e-01f, 4.79429886e-02f, -2.93387733e-02f, -2.26702332e-01f, -1.94498152e-01f, -1.44601554e-01f, 1.24201057e-02f, -5.71655370e-02f, 1.17642796e-02f,
  -9.79704335e-02f, -4.98786829e-02f, -1.37564152e-01f, 7.06049055e-02f, 1.09517537e-01f, 2.27762219e-02f, 2.31221393e-02f, 9.42202210e-02f, 1.56959936e-01f, 9.53843221e-02f,
  4.54602987e-02f, 1.12550914e-01f, 1.54454768e-01f, 8.66951942e-02f, 1.41268447e-01f, -8.39520898e-03f, 9.63584110e-02f, -1.34038199e-02f, 1.18939467e-01f, 1.34535015e-01f,
  3.09792645e-02f, 1.12336256e-01f, -4.27473150e-02f, -8.92471746e-02f, -1.08850248e-01f, 4.40778062e-02f, -2.71148002e-03f, 2.15927660e-02f, 7.03568012e-03f, -2.16120407e-02f,
  -5.89716174e-02f, 3.75302769e-02f, -5.94353043e-02f, 7.75989238e-03f, 4.62187156e-02f, -4.36077677e-02f, 1.26724303e-01f, 8.44959542e-02f, -8.84297842e-05f, 1.06205590e-01f,
  -2.29831319e-02f, -2.03707684e-02f, -9.21713710e-02f, -2.37277336e-02f, 5.35026267e-02f, -1.22469872e-01f, -6.60154521e-02f, 1.74341816e-03f, -5.63961044e-02f, 1.22938842e-01f,
  -3.94274220e-02f, 6.88906712e-03f, -3.04508787e-02f, 3.08373589e-02f, 4.86149006e-02f, -1.83425229e-02f, 8.74196365e-02f, -5.49657382e-02f, -8.21947679e-02f, 1.10673998e-02f,
  4.39231358e-02f, -3.95910516e-02f, -1.59192104e-02f, 2.67741159e-02f, 5.23118898e-02f, 6.97208419e-02f, 1.63152479e-02f, 2.76011974e-02f, 3.76103744e-02f, -8.04528035e-03f,
  -2.11593546e-02f, -2.70653982e-02f, -1.30055482e-02f, 1.65606267e-03f, -2.91161574e-02f, 5.44239432e-02f, 4.29043472e-02f, 3.90471555e-02f, 3.68933491e-02f, -7.08963946e-02f,
  -5.60598187e-02f, -2.02798069e-01f, 7.82227982e-03f, -5.65618835e-02f, -1.99826248e-02f, -4.07959931e-02f, -1.25346497e-01f, -5.01945466e-02f, -2.80422866e-02f, 4.90987077e-02f,
  -1.18838124e-01f, -4.37257215e-02f, -1.30237639e-01f, -7.27639571e-02f, -6.23877011e-02f, -6.74486905e-02f, -1.17289610e-01f, -6.37773201e-02f, 2.35415213e-02f, 5.35872802e-02f,
  -8.91828611e-02f, -9.13559180e-03f, -1.59334555e-01f, -1.19260758e-01f, 4.07130457e-03f, -1.25708848e-01f, -3.80278728e-03f, 9.31055285e-03f, -9.28492174e-02f, -9.40653160e-02f,
  -3.02322209e-01f, 5.64341024e-02f, -3.61697488e-02f, -1.48196161e-01f, 1.10639133e-01f, 2.53615286e-02f, 2.91310456e-02f, -9.88836810e-02f, 2.83950730e-03f, -3.11094876e-02f,
  1.86571270e-01f, 8.71684626e-02f, 4.77730148e-02f, -1.37508279e-02f, -1.65388230e-02f, 3.67222168e-02f, 6.74893185e-02f, -7.15948045e-02f, -1.53728276e-01f, -5.81876375e-02f,
  7.74386674e-02f, -1.25531927e-01f, -1.59241915e-01f, -1.16163194e-01f, 4.24612239e-02f, -9.27096605e-03f, 4.53388430e-02f, 3.57376784e-02f, 3.60901840e-02f, -1.70078725e-02f,
  2.39473283e-01f, 3.35907191e-02f, -1.00339368e-01f, 8.72188285e-02f, -2.86500491e-02f, -9.06397253e-02f, -8.47636070e-03f, -8.11222419e-02f, 6.71563670e-02f, -9.12396312e-02f,
  6.07147291e-02f, -1.18674347e-02f, -9.00127813e-02f, 2.81979013e-02f, -9.11427587e-02f, -1.96751673e-02f, -1.20552868e-01f, -8.98792967e-02f, -1.37957603e-01f, 7.71055669e-02f,
  -1.59441587e-02f, 4.90391366e-02f, -1.12265788e-01f, 3.55318002e-03f, -6.36815578e-02f, -5.31581864e-02f, -7.91685730e-02f, -3.52955312e-02f, -6.41243458e-02f, -1.27991050e-01f,
  5.70201054e-02f, 5.14742844e-02f, 3.14622261e-02f, 3.10714096e-02f, -1.64810894e-03f, -2.06318498e-03f, -3.00991000e-03f, 4.66045588e-02f, 3.24115418e-02f, -6.36848882e-02f,
  3.39686982e-02f, -2.47757044e-02f, 2.18901373e-02f, -5.61657175e-02f, 3.52253206e-02f, 2.63916962e-02f, 2.07874011e-02f, 5.27094081e-02f, -3.67338955e-02f, 1.36068864e-02f,
  -1.17956307e-02f, 2.44082268e-02f, -5.42267710e-02f, 1.95583273e-02f, 6.56919703e-02f, -1.07154265e-01f, 1.80841591e-02f, 6.08164556e-02f, -4.96043861e-02f, -9.47876275e-02f,
  -3.97159271e-02f, 6.80627897e-02f, 9.92594585e-02f, -1.28246054e-01f, 6.29603118e-02f, 3.90932336e-02f, 1.94428675e-02f, -8.03907141e-02f, -4.54111546e-02f, 6.18477911e-02f,
  -5.24042957e-02f, -8.36403891e-02f, -1.59235187e-02f, -4.58840467e-02f, -6.50192201e-02f, -3.70029360e-02f, -4.51315157e-02f, -9.29477275e-04f, -6.59093186e-02f, 1.17530050e-02f,
  -9.54984054e-02f, 3.64981331e-02f, -8.62227753e-02f, -3.10588479e-02f, 3.96759100e-02f, 4.73107621e-02f, -4.69889119e-03f, -3.34405378e-02f, -1.16890818e-01f, -3.03827412e-02f,
  1.41207753e-02f, -1.25706131e-02f, 1.62998468e-01f, 1.13577165e-01f, -1.08558433e-02f, 5.46886399e-02f, 1.03511296e-01f, 1.91597447e-01f, 6.29741326e-02f, -5.81243448e-03f,
  -7.07288682e-02f, -6.83446974e-02f, 4.27374542e-02f, 8.46422017e-02f, 1.32533476e-01f, 1.89996064e-01f, 1.82856232e-01f, 2.20615938e-01f, 3.69245224e-02f, 6.86058998e-02f,
  1.35743842e-01f, -4.07793792e-03f, 4.37474065e-03f, 1.59398347e-01f, 4.63266484e-02f, -1.43751390e-02f, 8.39900449e-02f, -2.68324334e-02f, 7.94349834e-02f, 2.35336944e-01f,
  -1.03374764e-01f, -1.05728410e-01f, 5.71726151e-02f, 4.55073155e-02f, -1.40350297e-01f, 6.30116314e-02f, -3.84428948e-02f, -5.64838424e-02f, -8.91410634e-02f, 1.05525769e-01f,
  -7.18266517e-02f, -5.12610143e-03f, 4.75287847e-02f, -2.40318608e-02f, 1.96751077e-02f, 2.24185511e-02f, 3.11329644e-02f, 2.99234204e-02f, 1.03723109e-01f, -9.18296352e-02f,
  -4.96302731e-03f, -1.50389463e-01f, -4.85996157e-02f, 4.86360304e-02f, 6.05842918e-02f, -1.07079931e-01f, -1.03231920e-02f, 6.43643737e-02f, 7.88601488e-02f, 6.39064014e-02f,
  1.36325415e-02f, 9.23828967e-03f, 5.05354591e-02f, 6.96461871e-02f, 6.46506399e-02f, -2.38629952e-02f, 7.60644954e-03f, 8.12331127e-05f, 3.62846442e-03f, -5.07587232e-02f,
  -3.27434987e-02f, -1.14219688e-01f, 4.33060713e-02f, -1.04052223e-01f, 2.26369407e-02f, 2.98488960e-02f, -1.54418908e-02f, 9.08163637e-02f, -1.07978359e-01f, 2.11268477e-03f,
  -2.21025702e-02f, 5.47083728e-02f, -2.24154778e-02f, -2.98586637e-02f, -6.99884668e-02f, -1.07668974e-02f, 4.96026091e-02f, -1.07801221e-02f, -1.63290035e-02f, -3.44587415e-02f,
  2.57461164e-02f, -1.42389879e-01f, 1.22653618e-01f, 7.39086932e-03f, -2.40369830e-02f, -1.02718985e-02f, 7.44991284e-03f, -3.65426093e-02f, -1.02474451e-01f, 1.38844416e-01f,
  -1.31141350e-01f, 2.13061944e-02f, 5.38808592e-02f, 2.07317658e-02f, 3.64175774e-02f, -1.38712404e-02f, 9.16817319e-03f, 1.17657036e-01f, 1.23806313e-01f, 7.67211542e-02f,
  1.80142988e-02f, 7.71609023e-02f, -7.91430920e-02f, -6.17048070e-02f, -6.82811961e-02f, 1.54058635e-02f, 7.12179067e-03f, -8.25369582e-02f, 2.24952549e-02f, 5.81095181e-02f,
  6.13043308e-02f, -2.34649032e-01f, 1.38760298e-01f, 1.30357314e-02f, 1.47923455e-02f, 1.78459942e-01f, 1.34026445e-03f, 1.22693539e-01f, 1.30585492e-01f, -6.78231940e-02f,
  -1.78954676e-01f, -4.75155041e-02f, 4.85964008e-02f, 3.75135690e-02f, 4.34154347e-02f, -1.57191157e-02f, 5.81743903e-02f, 1.01783894e-01f, 1.66549191e-01f, 9.13279355e-02f,
  3.85410488e-02f, -6.84092194e-02f, -5.84237948e-02f, 6.59702122e-02f, -4.01181802e-02f, 6.76861852e-02f, -9.37827490e-03f, -6.39085285e-03f, 5.00231888e-03f, -1.63969733e-02f,
  2.38145590e-02f, -2.83419713e-02f, 1.25154734e-01f, -1.73231602e-01f, -9.58665684e-02f, -8.13568607e-02f, -5.22959568e-02f, -9.28105116e-02f, 1.72461420e-02f, 1.27265025e-02f,
  -1.22179456e-01f, -1.21753745e-01f, -1.18458882e-01f, -6.77367970e-02f, -4.25938033e-02f, 8.00683275e-02f, -4.48099636e-02f, -7.10327178e-02f, -8.56001154e-02f, -4.10751626e-02f,
  -9.22258794e-02f, -1.14917733e-01f, 7.74464682e-02f, 6.70748502e-02f, -1.21591918e-01f, -5.35759665e-02f, 2.46358458e-02f, -5.54477684e-02f, 6.17440268e-02f, 5.59550747e-02f,
  -5.82662113e-02f, 8.50653946e-02f, -1.74032748e-02f, -5.29249161e-02f, -8.21894128e-03f, 3.53177600e-02f, 9.69992876e-02f, 4.54457439e-02f, 3.58140990e-02f, 3.43583301e-02f,
  -8.33296869e-03f, 4.81669270e-02f, -4.25823592e-02f, 1.00660868e-01f, 5.92547469e-03f, -2.49799318e-03f, -5.16661964e-02f, -7.62992306e-03f, 4.94320784e-03f, -4.36353311e-02f,
  -5.25311269e-02f, 6.27158256e-03f, 1.55772232e-02f, -1.04965173e-01f, 1.57679394e-02f, -1.08479718e-02f, -6.42940030e-02f, 1.72856096e-02f, 7.62278447e-03f, -7.24421591e-02f,
  4.67032753e-02f, 1.16179390e-02f, 7.12906495e-02f, 6.65606111e-02f, -1.60303861e-02f, -5.30931540e-02f, -3.08230799e-02f, -9.11009088e-02f, -1.32224545e-01f, 8.59240964e-02f,
  -1.03489578e-01f, 1.11939991e-02f, -1.39594926e-02f, 9.14216507e-03f, 1.24269120e-01f, -2.79880408e-02f, -1.99031755e-02f, 8.94738510e-02f, 5.26647642e-03f, -8.69163722e-02f,
  -8.67773518e-02f, 2.28534818e-01f, 2.64017284e-01f, 1.26056671e-01f, 9.30451974e-02f, 1.71484947e-01f, 1.44742101e-01f, 1.05516709e-01f, 7.89732859e-02f, 6.92945346e-02f,
  -4.18546587e-01f, -2.10827246e-01f, -1.29179016e-01f, -4.00224090e-01f, -1.41709372e-01f, 1.83170773e-02f, 2.43916214e-02f, -1.03855982e-01f, -1.49717957e-01f, -2.59094894e-01f,
  -1.54692173e-01f, -9.88499448e-02f, -8.13301727e-02f, 9.49962139e-02f, 6.31705970e-02f, -5.52300140e-02f, -9.38106179e-02f, 1.66304484e-02f, 2.87893683e-01f, 1.96256340e-01f,
  6.20541871e-02f, -1.09013796e-01f, 3.41703780e-02f, 5.04973903e-02f, -1.69010967e-01f, -2.71632522e-02f, -1.77731082e-01f, -8.02701041e-02f, -4.18183859e-03f, -1.88151151e-01f,
  -1.36194736e-01f, 3.72192776e-03f, 1.82054400e-01f, 1.18626002e-02f, -1.40204970e-02f, -1.34994136e-02f, 1.41459182e-02f, -8.34409371e-02f, -6.29266798e-02f, -1.07707918e-01f,
  -3.77092957e-02f, 8.02813917e-02f, -1.37991339e-01f, -2.07473245e-03f, -7.41363019e-02f, 6.62661437e-03f, 3.81306820e-02f, 1.35053620e-01f, 1.15027823e-01f, 1.54951766e-01f,
  1.02675995e-02f, -3.24152932e-02f, -8.32981765e-02f, 5.51363267e-02f, 2.32220162e-02f, 2.47261170e-02f, 8.35576281e-02f, 8.57814327e-02f, 1.59357563e-01f, -1.62665308e-01f,
  4.34010699e-02f, -5.84675670e-02f, 6.63384497e-02f, 5.40447310e-02f, -1.65854990e-02f, -9.10954848e-02f, 3.56722251e-02f, 3.14682652e-03f, 5.81504777e-02f, -1.01893455e-01f,
  3.44329253e-02f, 4.05898169e-02f, -6.03206344e-02f, -9.04757455e-02f, 3.72735485e-02f, -2.53486098e-03f, -3.99737284e-02f, 2.78582256e-02f, 4.99678142e-02f, 3.79281910e-03f,
  -2.46507162e-03f, 2.36205775e-02f, -1.21198893e-02f, 2.95977183e-02f, 1.46904916e-01f, 1.36071434e-02f, -6.11175667e-04f, 8.04551616e-02f, -2.61313692e-02f, -2.12575402e-03f,
  -3.48764181e-01f, 3.00431788e-01f, -1.92307800e-01f, 1.72696505e-02f, -1.64700225e-01f, -6.96035568e-03f, -1.48639351e-01f, 4.73768376e-02f, -4.13558483e-02f, 5.41967936e-02f,
  1.43420145e-01f, -1.87653471e-02f, -6.54880553e-02f, 9.96693894e-02f, -2.05114465e-02f, 6.84360489e-02f, 7.54203126e-02f, -9.84781012e-02f, 8.26717690e-02f, 4.42501381e-02f,
  5.72725683e-02f, -7.86128342e-02f, -1.10546805e-01f, -1.48130849e-01f, -7.29927793e-02f, -7.60997236e-02f, -7.07335100e-02f, -2.60911649e-03f, -2.92654112e-02f, -1.81929514e-01f,
  3.66374761e-01f, 3.00502002e-01f, 7.98509642e-02f, 1.41145557e-01f, -1.09826541e-02f, 7.79860094e-02f, 5.27245514e-02f, -5.79666607e-02f, -4.86816615e-02f, 1.86003685e-01f,
  2.72348881e-01f, 1.60473794e-01f, 1.17706701e-01f, 1.02028385e-01f, 6.80168420e-02f, -4.57965545e-02f, -5.77397421e-02f, -1.35247916e-01f, 1.05779050e-02f, -6.00695871e-02f,
  -7.57870004e-02f, -4.78795953e-02f, 3.77579294e-02f, 5.40016182e-02f, 1.16638735e-01f, 5.68079092e-02f, 7.80351758e-02f, 9.39225182e-02f, 3.58367376e-02f, 1.15494698e-01f,
  2.48438254e-01f, 2.59401083e-01f, -2.19004706e-01f, -6.56096488e-02f, 6.85206279e-02f, 7.22826421e-02f, 2.43942905e-02f, -7.10043777e-03f, -2.75643039e-02f, -4.46720794e-02f,
  -3.84283401e-02f, 5.37980199e-02f, 2.12442856e-02f, -8.35922360e-02f, 7.10331723e-02f, -3.50484364e-02f, -1.21567240e-02f, -1.05384067e-01f, -9.35889259e-02f, 1.27160192e-01f,
  -1.44198798e-02f, 1.49020985e-01f, 1.09151304e-01f, -1.65230811e-01f, -3.34860161e-02f, -3.97030823e-03f, 1.17490351e-01f, 1.15468927e-01f, 5.11760004e-02f, 1.01202004e-01f,
  1.03272989e-01f, 6.70474917e-02f, 1.37919679e-01f, 5.25952317e-02f, 9.26517472e-02f, -1.78944692e-02f, 6.41716551e-03f, 7.19919503e-02f, -9.46286693e-02f, -2.60542352e-02f,
  8.84968340e-02f, 1.00965537e-02f, -2.43014172e-02f, 2.27318355e-03f, 4.34143506e-02f, 9.88741443e-02f, 9.18980166e-02f, 5.59242405e-02f, 8.59937817e-02f, -2.68645361e-02f,
  -5.05881719e-02f, 3.13992724e-02f, -8.03574547e-03f, -1.03220865e-01f, -5.05318306e-02f, -7.65766669e-03f, 7.32029453e-02f, 7.25838095e-02f, -3.69232595e-02f, -5.23166619e-02f,
  -5.61285019e-02f, 5.52583002e-02f, -1.52782789e-02f, -8.41398910e-02f, 1.05299756e-01f, -1.07788276e-02f, 4.06843908e-02f, -7.32149556e-02f, 6.00809827e-02f, -1.28640058e-02f,
  -3.25232781e-02f, 3.00975237e-02f, 3.69615778e-02f, -5.98064028e-02f, -1.11522026e-01f, -1.69378683e-01f, 6.32793382e-02f, -7.59777501e-02f, -2.92868242e-02f, 8.69595818e-03f,
  -1.31008729e-01f, -1.50169298e-01f, -8.39927122e-02f, -1.76524252e-01f, -5.78317270e-02f, -1.64102502e-02f, -7.45324045e-02f, -1.45297408e-01f, -1.11585401e-01f, -1.41552821e-01f,
  -7.02663779e-01f, 1.33942828e-01f, -1.63397919e-02f, -1.55157551e-01f, 8.29900801e-02f, 8.53488743e-02f, 2.74574697e-01f, 1.14309646e-01f, 8.44715014e-02f, 1.17815316e-01f,
  -3.79596129e-02f, -8.34450275e-02f, 6.08495139e-02f, 7.87510425e-02f, 3.20524424e-02f, 2.63427645e-01f, 1.48632437e-01f, -2.30079237e-02f, -1.59953088e-01f, -8.54400173e-02f,
  5.61139137e-02f, -1.91237524e-01f, -2.86195576e-01f, -1.44540116e-01f, 3.53147872e-02f, 1.65916048e-02f, -5.28097190e-02f, -2.98859570e-02f, -3.45458165e-02f, 1.17932096e-01f,
  -1.19540468e-01f, -3.12858671e-01f, 4.61833589e-02f, -1.31135017e-01f, 1.10901538e-02f, 1.29714739e-02f, -4.65485826e-02f, -7.39843547e-02f, -5.54189123e-02f, -7.33655691e-02f,
  -1.03198111e-01f, -9.60622057e-02f, -5.07393815e-02f, -1.06562153e-01f, -9.55114439e-02f, -8.52298290e-02f, 1.73128340e-02f, -1.36548430e-01f, -2.95391772e-02f, -8.79038405e-03f,
  -1.72420666e-02f, -1.73693582e-01f, -1.72160327e-01f, -5.47292121e-02f, 3.31439041e-02f, -1.09841317e-01f, -1.54840097e-01f, -6.28083646e-02f, -8.15084428e-02f, -1.72747821e-01f,
  4.32306863e-02f, -7.51026124e-02f, 5.38089760e-02f, -2.77096014e-02f, 8.04156512e-02f, 1.01032495e-01f, 7.66757280e-02f, 1.74458604e-02f, -6.96888715e-02f, 9.70351603e-03f,
  -2.72894800e-02f, 4.18563373e-02f, 2.04100590e-02f, 6.72920793e-03f, 4.32175174e-02f, 6.00063466e-02f, 3.21633704e-02f, 2.56687719e-02f, -5.50268218e-02f, -9.18517914e-03f,
  -4.44451496e-02f, 3.16555947e-02f, -8.68904442e-02f, 1.05491459e-01f, -4.42790091e-02f, 4.98159640e-02f, -7.37899095e-02f, 4.65435088e-02f, -5.49895801e-02f, 9.13495757e-03f,
  -5.70771843e-02f, 4.49051708e-02f, -1.35027496e-02f, 1.52695309e-02f, -7.13994587e-03f, -4.11403365e-02f, -8.23467877e-03f, -9.00700837e-02f, -3.11940797e-02f, -4.82883640e-02f,
  -2.50218213e-02f, -1.16406746e-01f, 3.61761451e-02f, -4.56774309e-02f, -7.88237080e-02f, 3.70306172e-03f, -6.81354478e-02f, -1.28038853e-01f, -9.57675502e-02f, -1.26278490e-01f,
  5.56467772e-02f, -5.25412783e-02f, -2.45945945e-01f, -2.51705367e-02f, -9.30338167e-03f, -1.14469983e-01f, -3.97376940e-02f, -8.07564408e-02f, -1.05262972e-01f, -1.48761272e-01f,
  1.91132516e-01f, 1.55635551e-01f, 1.95066825e-01f, 1.12968288e-01f, 2.26091936e-01f, 2.67032266e-01f, 3.23805898e-01f, 1.19383641e-01f, 1.85211599e-01f, 1.83717921e-01f,
  -7.28674605e-03f, -1.26390651e-01f, -3.88816185e-02f, -2.67233141e-02f, -7.08083361e-02f, 1.27862588e-01f, 1.03484891e-01f, 5.62863201e-02f, -1.84484683e-02f, 6.15617782e-02f,
  1.17251864e-02f, 4.16198140e-03f, 5.63749112e-02f, -4.96955514e-02f, -5.24920002e-02f, -4.96252142e-02f, -6.71278406e-03f, -1.17490534e-02f, 1.00164518e-01f, -4.24664356e-02f,
  -1.55384153e-01f, 1.67265445e-01f, -1.15973324e-01f, -1.32207260e-01f, -4.25053462e-02f, 2.45880103e-03f, -9.26446691e-02f, -1.04877345e-01f, 6.56692088e-02f, 5.40897958e-02f,
  4.49871738e-03f, -1.24387622e-01f, 5.96778281e-02f, -5.53073697e-02f, 9.12637264e-03f, -2.07962934e-02f, -1.59032531e-02f, 3.93674634e-02f, -1.00586101e-01f, -4.92179357e-02f,
  1.47022884e-02f, 4.88982946e-02f, 6.48102611e-02f, -3.67059670e-02f, -7.25405104e-03f, -2.70478483e-02f, 6.08489923e-02f, 1.34116979e-02f, 5.32184429e-02f, 2.90211737e-02f,
  -4.78498489e-02f, 5.31788021e-02f, -4.04522531e-02f, 4.50242609e-02f, -7.74195343e-02f, 5.61262518e-02f, -4.89106588e-02f, -5.10015376e-02f, -3.51511985e-02f, 1.48558663e-02f,
  6.17461726e-02f, -5.23094125e-02f, -1.70408208e-02f, -2.14613248e-02f, -1.07953288e-01f, -4.55206968e-02f, 4.17470671e-02f, 5.44449203e-02f, 7.34373629e-02f, 1.27551267e-02f,
  -2.61444245e-02f, 4.02857959e-02f, 8.06408003e-02f, 5.94715625e-02f, -8.07134584e-02f, 6.92649707e-02f, 6.10008985e-02f, -3.37197632e-02f, 1.26108617e-01f, 9.92621407e-02f,
  -2.72938162e-02f, 1.12661004e-01f, -2.05609843e-01f, -5.66145107e-02f, 6.20814338e-02f, 4.74026101e-03f, 3.86424214e-02f, -3.44738029e-02f, 7.87055716e-02f, -1.85666289e-02f,
  -9.37498920e-03f, 8.63463676e-04f, -1.68820899e-02f, 6.47414997e-02f, -5.96745126e-02f, 9.47447345e-02f, 3.70405838e-02f, -1.03437398e-02f, -7.93062523e-02f, -2.04096474e-02f,
  3.80477160e-02f, 6.56814426e-02f, 1.02975577e-01f, 9.07736178e-03f, 2.92698406e-02f, -7.11846799e-02f, -4.90608327e-02f, -3.82512100e-02f, -2.91306544e-02f, 4.20549400e-02f,
  8.97851288e-02f, 2.71547377e-01f, 1.37093484e-01f, 5.03978916e-02f, 3.93753313e-02f, 2.56770998e-01f, 3.53616834e-01f, 1.90435931e-01f, 7.16503710e-03f, -1.92379614e-03f,
  1.29681095e-01f, -9.30897221e-02f, 8.67873728e-02f, 6.03407137e-02f, 2.89038755e-02f, 2.68607680e-02f, 6.15896331e-03f, 7.14713708e-02f, 2.89713200e-02f, -3.92432045e-03f,
  -1.00196861e-01f, -1.73877906e-02f, -4.05285843e-02f, 7.54498467e-02f, 3.48469019e-02f, -8.88033584e-02f, 7.06418380e-02f, 4.26694155e-02f, 4.88962932e-03f, -3.23204324e-02f,
  -9.12931710e-02f, 1.62708193e-01f, -6.09357394e-02f, -1.51349425e-01f, -6.35653660e-02f, -1.00173600e-01f, 1.07500236e-02f, -3.55659276e-02f, 2.86943819e-02f, 1.00883311e-02f,
  -3.29971313e-03f, -8.05647895e-02f, 1.14490334e-02f, 2.77879220e-02f, -4.34320094e-03f, 4.38108370e-02f, -9.34753045e-02f, 1.75271574e-02f, 1.18345939e-01f, 5.12414053e-02f,
  -6.53740689e-02f, -4.64554504e-02f, 1.48331985e-01f, 3.40903215e-02f, 5.96049316e-02f, 3.68886180e-02f, -6.74597919e-04f, 8.36005434e-02f, 9.08483192e-02f, -7.16400966e-02f,
  -2.87500769e-02f, 7.44516328e-02f, 5.41596822e-02f, -5.43345474e-02f, -4.21388596e-02f, 7.04514459e-02f, 2.18027867e-02f, 4.47801128e-02f, 1.63377915e-02f, -3.33896354e-02f,
  2.73766667e-02f, -2.50400379e-02f, 4.46582325e-02f, -5.23080677e-02f, 3.71823646e-02f, -3.58057432e-02f, -4.28334847e-02f, 1.35665098e-02f, -6.55821413e-02f, 6.12610318e-02f,
  4.21941243e-02f, 3.62345539e-02f, 3.37252859e-03f, 5.17969355e-02f, -1.01987580e-02f, -4.35683690e-02f, -2.26313621e-03f, -7.09623843e-02f, -9.65885818e-02f, -1.07909933e-01f,
  -2.53565669e-01f, 1.39891312e-01f, -4.67571206e-02f, 4.51678224e-02f, 5.27635217e-02f, -4.44063097e-02f, 4.09779623e-02f, -2.20737327e-02f, -1.55768311e-02f, 3.70021276e-02f,
  1.33096511e-02f, -3.83931696e-02f, 2.49873307e-02f, -1.11746646e-01f, -5.35295949e-05f, -8.26165378e-02f, -5.72405104e-03f, 3.05899829e-02f, -8.33280161e-02f, -9.23544392e-02f,
  -8.69595185e-02f, -1.81197543e-02f, -7.70609304e-02f, 1.98635440e-02f, -9.84326676e-02f, -9.24688652e-02f, -1.00467302e-01f, 2.65186019e-02f, -1.21433323e-03f, -1.58979475e-01f,
  -3.96244407e-01f, 3.27953398e-02f, 6.77535981e-02f, -2.75404483e-01f, -3.81993479e-03f, 2.27936711e-02f, 1.24756023e-01f, 3.01924214e-04f, -1.30708486e-01f, 8.68950933e-02f,
  8.59468617e-03f, 6.24764070e-04f, -6.13302477e-02f, 1.96486246e-02f, -9.82137546e-02f, 7.94336498e-02f, 4.20570821e-02f, -1.34167820e-01f, -8.90967548e-02f, -5.63068241e-02f,
  -8.83615986e-02f, -9.87600461e-02f, -1.95465341e-01f, -1.26852110e-01f, -8.53015110e-02f, -5.82214519e-02f, -1.61457509e-02f, -1.07419930e-01f, -3.12361661e-02f, -3.94803956e-02f,
  4.21048135e-01f, -1.51916414e-01f, 2.37512123e-02f, -1.21220037e-01f, -5.37378713e-02f, -9.48289931e-02f, -5.98415397e-02f, -6.88827708e-02f, -8.67572799e-02f, -4.63206992e-02f,
  5.06917723e-02f, 2.48385444e-02f, -8.77030417e-02f, 6.57003522e-02f, -5.19197620e-02f, -4.23303358e-02f, -1.16049200e-01f, -2.40070168e-02f, 1.57677997e-02f, 4.39449213e-02f,
  -8.31152499e-03f, 9.59979743e-02f, 9.02766921e-03f, 1.08639099e-01f, 4.52340059e-02f, 4.04692180e-02f, 1.28009282e-02f, 1.52173871e-02f, -1.27550466e-02f, -6.46257587e-03f,
  3.15500220e-04f, 8.16026405e-02f, 1.64406113e-02f, -8.10305104e-02f, -3.75888012e-02f, 4.28154916e-02f, 1.65720508e-02f, 3.61763611e-02f, -9.07912329e-02f, -9.02464688e-02f,
  3.61591987e-02f, 2.59148106e-02f, -3.11784726e-02f, 5.62358089e-02f, 3.70042166e-04f, -5.51077835e-02f, -4.18947637e-02f, 3.88824604e-02f, 2.19476465e-02f, -1.09717734e-01f,
  -5.74444160e-02f, 3.45615894e-02f, -8.90505165e-02f, 8.10307711e-02f, 2.86562685e-02f, -9.37954485e-02f, -5.83129078e-02f, -8.56417194e-02f, 1.57428626e-03f, 2.21545454e-02f,
  5.41510880e-02f, 2.16606036e-02f, -2.21411581e-03f, -8.23791251e-02f, -9.42652598e-02f, -8.26842114e-02f, 5.99797480e-02f, -2.24351883e-02f, -7.87299573e-02f, 9.35534611e-02f,
  9.82884020e-02f, -8.34378898e-02f, 2.86167711e-02f, 6.04918413e-02f, -3.22543681e-02f, 2.75919791e-02f, -8.77585039e-02f, -8.61016810e-02f, -4.52380553e-02f, 3.16433199e-02f,
  -1.97782442e-02f, 4.89608608e-02f, 2.14304551e-02f, 1.18398979e-01f, 8.93217996e-02f, 6.69064820e-02f, 1.50951058e-01f, 1.39997795e-01f, 1.27583727e-01f, 6.63063005e-02f,
  2.13508263e-01f, -1.92594424e-01f, -5.72894551e-02f, 2.24375576e-01f, 1.49763525e-01f, -3.51271778e-02f, -1.75797436e-02f, -2.95483321e-02f, 1.16784729e-01f, 1.46790892e-01f,
  1.07430458e-01f, 2.53671914e-01f, 2.06673160e-01f, 6.57752827e-02f, -1.14015844e-02f, -3.56090106e-02f, -4.39156033e-02f, -4.69416659e-03f, 1.29779592e-01f, 1.94570199e-01f,
  1.86232731e-01f, 1.04978517e-01f, 4.73821238e-02f, 9.96738952e-03f, 2.24122852e-02f, 6.60098642e-02f, 2.08819676e-02f, 1.31009817e-01f, -1.61247253e-02f, 1.71482414e-01f,
  1.89319268e-01f, -1.40746698e-01f, 3.15964222e-02f, 7.51364455e-02f, 1.29619926e-01f, -1.06071196e-01f, -6.83757663e-02f, 9.58590955e-03f, 4.29138131e-02f, -8.39499608e-02f,
  1.19581044e-01f, -6.65341988e-02f, 9.33105499e-03f, -4.19400297e-02f, -4.89739887e-02f, 4.66810763e-02f, -6.35489300e-02f, -1.11082226e-01f, -1.02574877e-01f, -7.95265939e-03f,
  6.84603602e-02f, 7.47964531e-02f, -1.76616982e-02f, -6.65275455e-02f, -5.45376949e-02f, 5.49438260e-02f, -8.07188973e-02f, -4.45820130e-02f, -6.41841367e-02f, -9.34539139e-02f,
  5.88746406e-02f, 3.28851081e-02f, -2.41042729e-02f, 4.82710078e-04f, 1.11569859e-01f, 4.17309925e-02f, 5.38588613e-02f, 9.21682641e-02f, 8.16315338e-02f, -6.01142719e-02f,
  6.63274452e-02f, 2.95741623e-03f, -3.59798074e-02f, 1.04915917e-01f, 1.08360916e-01f, 3.29714306e-02f, -5.89791425e-02f, -4.10642363e-02f, -1.40046934e-02f, -3.63490246e-02f,
  1.04869843e-01f, 2.90167937e-03f, 6.86484724e-02f, -4.49089967e-02f, -6.05362840e-02f, 1.12871572e-01f, 9.60385203e-02f, 8.70572776e-02f, 4.49641123e-02f, 7.08125234e-02f,
  -2.98761204e-03f, -1.46663291e-02f, 1.20251864e-01f, 5.12193926e-02f, 1.74468127e-03f, -1.10305049e-01f, 1.23120956e-01f, -3.46637815e-02f, -9.87843424e-03f, 1.84379742e-02f,
  4.51424494e-02f, -2.69896407e-02f, -7.09596053e-02f, -4.77092005e-02f, -1.95546243e-02f, -9.06756297e-02f, 1.85752083e-02f, 7.91308805e-02f, -1.09904841e-01f, -2.51461826e-02f,
  -1.21797495e-01f, -3.36412080e-02f, -6.04516938e-02f, 7.82702770e-03f, -2.36365814e-02f, 3.24618705e-02f, -8.39779377e-02f, -6.43012077e-02f, -6.38208985e-02f, -2.07205769e-02f,
  -1.13959983e-01f, -4.07844365e-01f, -5.91043830e-02f, 7.42722452e-02f, -1.44385323e-01f, -3.24213356e-01f, -5.35361528e-01f, -1.55520827e-01f, 9.39898789e-02f, -2.74881482e-01f,
  -3.46749909e-02f, 9.16041732e-02f, 9.72541347e-02f, -5.08470833e-02f, -2.27929339e-01f, -4.01525021e-01f, -2.57511914e-01f, -6.20917417e-02f, 1.09669521e-01f, -4.67117466e-02f,
  -1.42806992e-01f, -4.00863849e-02f, 1.58245936e-01f, 8.09270740e-02f, 2.42290311e-02f, 1.30560756e-01f, -1.07059777e-02f, 6.04526326e-02f, -3.22351642e-02f, -1.32591039e-01f,
  2.37796884e-02f, 7.05603212e-02f, 8.42314959e-02f, 1.13119930e-02f, 4.75113727e-02f, -4.98601981e-02f, -1.86529085e-02f, 1.33641094e-01f, 7.09960237e-03f, -5.78934141e-03f,
  1.07779510e-01f, 7.73745775e-02f, 2.81481147e-02f, -5.78340739e-02f, -5.02888821e-02f, -1.00665212e-01f, 3.17745619e-02f, 8.47967416e-02f, 2.76205055e-02f, -1.36665463e-01f,
  -1.77965596e-01f, -5.69943562e-02f, 2.54728626e-02f, 5.68999127e-02f, -4.96336445e-03f, 1.16123818e-01f, 1.06199412e-02f, 4.94531989e-02f, 1.01304851e-01f, 6.90218285e-02f,
  -7.27252737e-02f, 5.68260737e-02f, 7.73177668e-02f, 1.90152568e-04f, -1.25724049e-02f, 1.00543328e-01f, -5.63555546e-02f, -3.20529565e-02f, -3.74427587e-02f, 1.11207832e-02f,
  7.09083900e-02f, 1.41374404e-02f, 8.49569496e-03f, 1.47989644e-02f, 8.27555805e-02f, 7.82367960e-02f, -1.00358360e-01f, -5.75305410e-02f, -1.13326125e-01f, -2.12970152e-02f,
  2.94621568e-02f, -1.33390296e-02f, 5.20280078e-02f, 8.11934993e-02f, -1.09377831e-01f, -9.54295695e-02f, 4.74326089e-02f, 4.85416129e-02f, 3.74992453e-02f, 3.68450843e-02f,
  2.30627477e-01f, 3.60271335e-02f, -9.36032012e-02f, 8.10760856e-02f, -4.37965952e-02f, -3.69794108e-02f, -3.54901403e-02f, 2.39433963e-02f, 2.30454858e-02f, -5.87365106e-02f,
  3.19180684e-03f, 1.03172660e-02f, 1.69826914e-02f, -2.41233855e-02f, -8.10807571e-02f, -1.74265858e-02f, -2.35767141e-01f, -6.31602108e-02f, -4.91470732e-02f, -8.63922760e-02f,
  -6.14734292e-02f, -1.83844164e-01f, -1.33955896e-01f, -4.77370732e-02f, 9.12924334e-02f, 2.26675700e-02f, -4.01962437e-02f, -9.79967788e-03f, -2.39454675e-02f, -2.31418073e-01f,
  -1.74152628e-01f, 1.21865183e-01f, 4.20671068e-02f, 3.01548000e-02f, 1.27692223e-01f, -1.22482143e-02f, 4.35359031e-02f, 3.93984132e-02f, 9.26777273e-02f, -8.27392489e-02f,
  -1.15018897e-02f, -2.75943745e-02f, 9.26898867e-02f, 3.83548550e-02f, 3.34719382e-02f, 1.65389534e-02f, 1.74679220e-01f, 6.73166588e-02f, -9.02497172e-02f, -5.98147162e-04f,
  -4.17211987e-02f, 3.61560732e-02f, -1.88683234e-02f, 1.22196607e-01f, 4.06551510e-02f, 6.51983097e-02f, 1.42284513e-01f, 7.27009624e-02f, 7.21719041e-02f, 1.33888200e-01f,
  -2.26081640e-01f, -1.30006194e-01f, -1.67269744e-02f, -7.12094009e-02f, 9.70473289e-02f, -1.15394175e-01f, -8.98077488e-02f, -7.59918541e-02f, -6.87848255e-02f, -3.68872061e-02f,
  -2.12913025e-02f, -4.64560837e-02f, 4.93529923e-02f, -4.30423729e-02f, -9.30454955e-02f, -3.75571474e-02f, -2.87808198e-02f, -4.57580611e-02f, 6.68183044e-02f, -5.53746475e-03f,
  4.69465815e-02f, 1.73526686e-02f, -1.23866417e-01f, 2.01956909e-02f, -7.05498308e-02f, 1.10075390e-02f, -1.09441273e-01f, 1.63470686e-03f, -7.45478645e-02f, -7.61236204e-03f,
  5.34281023e-02f, 3.81900929e-02f, 3.71733457e-02f, 1.49048027e-02f, 8.33140314e-02f, -4.04979102e-02f, -5.37970755e-03f, -1.16930623e-03f, 6.41428605e-02f, -2.15822943e-02f,
  1.24724275e-02f, 5.88682154e-03f, -2.20263321e-02f, -6.70574680e-02f, 7.81251788e-02f, 2.89282445e-02f, -8.71345773e-02f, 7.40698129e-02f, 3.88685353e-02f, 6.27383664e-02f,
  -8.89408067e-02f, 7.71299228e-02f, -3.10038589e-03f, 5.38172834e-02f, 2.55213194e-02f, 7.49238729e-02f, -1.13013536e-01f, -2.71118898e-02f, 5.87020814e-03f, -9.49314982e-02f,
  -2.76861694e-02f, -5.27599007e-02f, -1.31452501e-01f, -5.25776707e-02f, -4.49790321e-02f, 4.48119547e-03f, -2.35536005e-02f, -6.83399290e-02f, -1.23469420e-02f, -2.06386135e-03f,
  -5.20164445e-02f, -4.42886278e-02f, -5.82804531e-02f, 4.82718647e-02f, -2.20721085e-02f, -1.07659929e-01f, -8.29070508e-02f, 4.40961458e-02f, -1.14608873e-02f, -7.81244338e-02f,
  -1.62290921e-03f, -1.17845781e-01f, -1.43959343e-01f, -8.79906639e-02f, -9.60921030e-03f, -7.95708448e-02f, -9.42227095e-02f, -1.48755074e-01f, -1.76563740e-01f, -2.15227172e-01f,
  -2.42518649e-01f, -1.06539547e-01f, -2.15887442e-01f, 1.91282406e-02f, 2.31086556e-02f, -7.16963559e-02f, 4.63898368e-02f, 5.90291508e-02f, 5.04369885e-02f, -1.95982344e-02f,
  -5.76823838e-02f, 9.85064730e-02f, -1.20942052e-02f, 4.84683737e-02f, 1.46645764e-02f, -3.68747562e-02f, -6.02033883e-02f, -2.63597537e-02f, 1.13967527e-03f, 1.53185174e-01f,
  8.22153836e-02f, 7.73842558e-02f, 5.72982989e-02f, 1.00470856e-01f, 1.04219131e-01f, 5.54779619e-02f, -1.37280986e-01f, -1.12351719e-02f, -4.49143499e-02f, 1.32611720e-02f,
  -1.40991792e-01f, -1.61405742e-01f, 5.02137840e-02f, -1.39625249e-02f, -2.81712599e-02f, -5.78508675e-02f, -6.01662546e-02f, -3.74273360e-02f, -2.14824807e-02f, -5.70296049e-02f,
  -2.74905786e-02f, -1.74345598e-02f, -1.11064510e-02f, 1.12750731e-01f, -4.91419286e-02f, -3.15933637e-02f, 6.67426363e-02f, -8.27293098e-02f, -2.37669926e-02f, 7.05391020e-02f,
  -2.53182296e-02f, -4.03938033e-02f, -9.78479460e-02f, -5.06788120e-02f, 2.15923954e-02f, -4.31974493e-02f, -1.26791457e-02f, -8.57859701e-02f, -5.27677648e-02f, -1.53449476e-01f,
  -3.17770173e-03f, -2.08480861e-02f, -4.64905761e-02f, -1.17279477e-02f, 1.28462287e-02f, -5.35500981e-02f, -4.78738695e-02f, 7.75137469e-02f, 9.32106227e-02f, 3.97646539e-02f,
  5.79719245e-02f, -7.20463544e-02f, 8.53286125e-03f, -8.66198167e-02f, -3.84505391e-02f, -6.94340318e-02f, -3.79071711e-03f, -9.44230985e-03f, 6.78377450e-02f, 1.03837363e-02f,
  -7.55390748e-02f, -5.53619824e-02f, 3.52565112e-04f, 5.80912270e-02f, 7.27033764e-02f, -7.15289041e-02f, 6.00884333e-02f, 7.00715631e-02f, -8.84240508e-05f, -7.65158907e-02f,
  -5.97630553e-02f, -1.58079024e-02f, -9.50860307e-02f, 7.43357539e-02f, 1.46442223e-02f, -3.61954384e-02f, -8.21812898e-02f, 2.51441058e-02f, -2.44588908e-02f, 6.55531138e-02f,
  -3.04395538e-02f, 6.37743920e-02f, -4.89314413e-03f, -1.91488564e-02f, -1.24909421e-02f, -2.98405578e-03f, -5.66579998e-02f, -4.24855128e-02f, -5.29735088e-02f, 7.36895949e-02f,
  5.50431162e-02f, -7.92031288e-02f, 2.95317324e-04f, -9.44194943e-02f, 8.92661810e-02f, -1.03614189e-01f, -1.18283711e-01f, -3.59785855e-02f, -6.99748546e-02f, -1.27362102e-01f,
  2.42378503e-01f, 3.34346220e-02f, -1.15160100e-01f, 7.60258287e-02f, -5.06058224e-02f, -1.37417708e-02f, -9.09207016e-03f, 1.46098658e-01f, -3.39082778e-02f, -1.05759263e-01f,
  -1.83004346e-02f, -1.05821460e-01f, -1.01564243e-01f, -1.12583853e-01f, -2.42485702e-02f, -1.75361447e-02f, -5.60102016e-02f, 4.46711481e-02f, 8.53019133e-02f, -5.87436333e-02f,
  4.98324782e-02f, -1.24485847e-02f, 1.99299958e-02f, -7.06496611e-02f, -9.65379402e-02f, -1.19048558e-01f, -1.61381721e-01f, -4.77879643e-02f, -3.41059342e-02f, -1.22825801e-01f,
  -2.60608315e-01f, 4.04582843e-02f, 6.77928776e-02f, 2.76552495e-02f, -9.42184553e-02f, 8.77695754e-02f, 4.72975187e-02f, 9.22543705e-02f, 7.36404210e-03f, 5.46445660e-02f,
  -5.88669861e-03f, 8.12956784e-03f, 1.78962648e-02f, 2.37245187e-02f, 8.91947150e-02f, 5.20326309e-02f, 9.28172469e-02f, -1.49033160e-03f, -8.61071348e-02f, -1.26150832e-01f,
  -1.25524119e-01f, 6.81391209e-02f, -4.33793701e-02f, 6.82983324e-02f, 6.03853874e-02f, -8.27436224e-02f, -2.24314630e-02f, -2.77683605e-02f, -3.60260755e-02f, -2.35452666e-03f,
  1.29213724e-02f, -1.25343008e-02f, -9.61416811e-02f, 6.45355955e-02f, -6.45619407e-02f, 6.66520149e-02f, -6.17729910e-02f, 2.19388064e-02f, 7.41690472e-02f, 4.46326472e-02f,
  6.70403838e-02f, 5.60820140e-02f, 5.25886007e-02f, 6.67914674e-02f, -9.38728824e-02f, -1.72161143e-02f, 5.18677197e-02f, -6.94207568e-03f, 2.72061490e-02f, -9.76662785e-02f,
  3.45471688e-02f, -7.20827207e-02f, -2.05015903e-03f, -5.70554845e-02f, -6.54615760e-02f, -5.20130992e-02f, -8.76286030e-02f, -7.85329752e-03f, 4.85452078e-02f, -4.27785795e-03f,
  -1.40831411e-01f, -1.08270191e-01f, -6.05711527e-03f, 3.21130492e-02f, -9.54938233e-02f, -4.91096117e-02f, -7.44707733e-02f, 2.93129981e-02f, -9.48800296e-02f, -9.22925863e-03f,
  -4.63376082e-02f, -6.77293837e-02f, -7.24966601e-02f, 1.40795624e-02f, 9.58846435e-02f, -4.30782512e-02f, 1.84131283e-02f, -7.83321038e-02f, 4.74600121e-02f, 5.48769049e-02f,
  6.64197728e-02f, 1.55961081e-01f, 6.93260431e-02f, 1.42768696e-01f, 5.34383953e-03f, 1.24804571e-01f, 2.48334706e-02f, 1.21159293e-01f, 1.15234656e-02f, 2.24714667e-01f,
  -5.36434948e-02f, -1.62753969e-01f, -1.63078800e-01f, -6.38857782e-02f, 8.69140998e-02f, -3.02662496e-02f, -8.78007710e-02f, -9.76072326e-02f, -1.20744117e-01f, 2.66395975e-02f,
  -3.89805436e-02f, 6.01947904e-02f, -6.36994243e-02f, -1.28881246e-01f, -1.89841211e-01f, -8.66120383e-02f, -2.15992555e-01f, -1.95366099e-01f, -7.96136353e-03f, 2.52876673e-02f,
  1.07075810e-01f, -1.19558774e-01f, -2.45702509e-02f, -9.53976288e-02f, 1.04608774e-01f, -4.20777574e-02f, -8.39930102e-02f, 5.17455563e-02f, -3.97224445e-03f, 8.92229527e-02f,
  1.58961248e-02f, 7.14157149e-02f, 6.34995177e-02f, 1.19133912e-01f, -1.08451750e-02f, 2.47764979e-02f, 8.61825123e-02f, -1.41144007e-01f, 7.56000727e-02f, -1.80914011e-02f,
  5.68224490e-02f, 8.75350460e-02f, -4.05307077e-02f, 6.67022243e-02f, -8.20892006e-02f, 1.87907983e-02f, -8.69016126e-02f, -1.13685533e-01f, -1.29204497e-01f, 8.10109973e-02f,
  8.69390666e-02f, 8.18448141e-02f, 2.95413043e-02f, -9.17383581e-02f, 9.66866314e-02f, 9.98474509e-02f, 8.24378505e-02f, 9.80314016e-02f, -3.09708863e-02f, -1.03148043e-01f,
  1.39016453e-02f, 4.34801094e-02f, 1.44152381e-02f, 1.58663820e-02f, 3.13872807e-02f, 8.24664161e-03f, -9.47104171e-02f, -4.62694764e-02f, -3.15790959e-02f, -9.00898054e-02f,
  -9.14504305e-02f, -7.36555979e-02f, -4.61034961e-02f, -2.26873644e-02f, -1.06502779e-01f, -7.03244731e-02f, -4.38257940e-02f, -6.25600442e-02f, 5.67961857e-03f, -2.79777534e-02f,
  -2.16437187e-02f, 7.03922287e-02f, -7.67439827e-02f, -3.00036669e-02f, -2.33437456e-02f, -3.65499929e-02f, 3.07690799e-02f, 5.28189577e-02f, 2.80139353e-02f, -4.44060750e-02f,
  -1.76136389e-01f, -8.53689015e-03f, 2.62481906e-02f, 5.15057035e-02f, 3.60909477e-02f, 6.50358871e-02f, 5.25249839e-02f, -5.48207536e-02f, 2.81278193e-02f, 2.36963276e-02f,
  2.17966679e-02f, 4.24962789e-02f, -6.36245357e-04f, -2.11748388e-02f, -3.36912759e-02f, 4.39113611e-03f, -1.17348969e-01f, -1.21400803e-01f, -1.28456261e-02f, -4.94750589e-02f,
  -8.73363689e-02f, -1.51535437e-01f, -8.86180624e-02f, -1.42130464e-01f, 3.44658569e-02f, -7.12073455e-03f, -1.22033373e-01f, -2.20959634e-02f, -1.02402948e-01f, -1.68572679e-01f,
  1.57802016e-01f, -4.27942071e-03f, -1.53217912e-02f, 5.56448847e-02f, 4.20226343e-02f, 7.74038583e-03f, 2.42803190e-02f, -9.25178081e-03f, -5.15936464e-02f, 1.61972009e-02f,
  3.46637145e-02f, 1.59680307e-01f, 4.08934429e-02f, 7.80620053e-02f, 5.01088686e-02f, -1.21817812e-01f, -9.40150097e-02f, 8.20128620e-02f, 4.86543514e-02f, 5.07003665e-02f,
  1.37170935e-02f, 5.82232848e-02f, 9.24827605e-02f, 9.17453021e-02f, -1.53287677e-02f, -3.78397033e-02f, -2.10497100e-02f, -3.70973125e-02f, -9.47530344e-02f, -1.11781232e-01f,
  -8.52886513e-02f, 2.10467562e-01f, 2.55918410e-02f, -1.22119179e-02f, 2.06433386e-02f, 1.13322400e-01f, 1.61315799e-02f, -4.38610576e-02f, -3.75056779e-03f, 2.25472655e-02f,
  -4.46557142e-02f, 1.50922388e-02f, 1.15557142e-01f, 1.19268447e-02f, 6.66808411e-02f, 9.49362069e-02f, 6.30551204e-02f, 1.18028559e-01f, -5.88723272e-02f, -2.28368100e-02f,
  -4.02611233e-02f, 2.26019733e-02f, -5.51419519e-03f, 6.80536702e-02f, -3.32097374e-02f, 2.48473138e-02f, 8.76940936e-02f, 4.96278964e-02f, 7.48737007e-02f, 4.41581272e-02f,
  -1.03575200e-01f, -6.03501685e-02f, -1.50530403e-02f, 3.80306244e-02f, 4.11933996e-02f, -3.93472388e-02f, 3.47546972e-02f, -6.05996437e-02f, 7.71370605e-02f, 4.02359106e-02f,
  -2.22361907e-02f, 8.04200582e-03f, 3.04591786e-02f, -4.53836285e-03f, -5.30823804e-02f, 3.27543914e-03f, -6.44260738e-03f, -8.18765024e-04f, -5.96050266e-03f, -9.00831148e-02f,
  4.63957563e-02f, 6.79902080e-03f, -9.55691040e-02f, -2.89994497e-02f, -1.10945731e-01f, 5.18559888e-02f, -1.58077031e-02f, 7.10841967e-03f, -8.43676701e-02f, 1.86475404e-02f,
  -8.31530765e-02f, 7.71356225e-02f, -7.39747332e-03f, 1.01450071e-01f, -1.92129146e-02f, 1.31331356e-02f, 7.61575997e-02f, -2.79831234e-02f, 8.29465017e-02f, -8.52958634e-02f,
  -4.80092578e-02f, 7.45924115e-02f, 1.11106128e-01f, -9.35278181e-03f, 6.34699315e-02f, -5.36416769e-02f, -4.39538620e-02f, 7.67077953e-02f, 5.78329898e-02f, -5.12032397e-02f,
  -6.26764074e-02f, -1.67798605e-02f, -8.48214403e-02f, -1.31542981e-01f, -3.01971752e-02f, -8.52302834e-02f, -1.76907256e-02f, 1.81041602e-02f, -1.97855122e-02f, -9.04814675e-02f,
  -2.99235612e-01f, -5.33480346e-02f, -1.47172242e-01f, -1.60943922e-02f, 7.65028521e-02f, 1.84005365e-01f, 2.05860138e-01f, -5.15561253e-02f, -3.73011641e-02f, -4.15028408e-02f,
  1.18558407e-02f, 5.14910668e-02f, -1.33199826e-01f, -3.73442955e-02f, -4.19835933e-02f, -2.63058823e-02f, -1.30922168e-01f, -1.28389731e-01f, -4.16666195e-02f, 1.80910885e-01f,
  1.71759561e-01f, -9.52416733e-02f, -7.96751454e-02f, -5.96096367e-02f, -7.57534476e-03f, 5.73630817e-02f, -1.67717829e-01f, -2.87889577e-02f, -6.62797503e-03f, -9.82660651e-02f,
  -3.22190602e-03f, 2.77223662e-02f, -5.34240529e-02f, 6.53242767e-02f, 4.06893604e-02f, -8.37930515e-02f, -8.10778737e-02f, -2.40944717e-02f, 2.45903190e-02f, -7.38405734e-02f,
  -1.01565644e-02f, 8.25598091e-02f, 6.05257712e-02f, -1.83942635e-02f, -8.12538564e-02f, 2.25214823e-03f, -1.27656817e-01f, -6.03079088e-02f, -1.24100912e-02f, 1.10598402e-02f,
  1.31444829e-02f, -2.58930866e-02f, -3.04027330e-02f, 2.51278877e-02f, -3.55432853e-02f, -1.31931528e-01f, -7.68533871e-02f, -2.62982142e-03f, -2.16494370e-02f, -3.98109779e-02f,
  5.26372751e-04f, -8.30426738e-02f, -3.67329456e-02f, -1.93520188e-02f, 2.13848688e-02f, 1.84540786e-02f, -7.92996027e-03f, -1.07005136e-02f, 4.83205244e-02f, 3.99238132e-02f,
  -1.81825515e-02f, 1.18600382e-02f, 1.25687700e-02f, -8.56944546e-03f, -1.09647423e-01f, -4.52402234e-03f, 6.40150085e-02f, -1.21529065e-02f, -4.99575995e-02f, 5.88393994e-02f,
  2.07273457e-02f, -2.46175956e-02f, -1.14050567e-01f, -5.28925024e-02f, -7.82578513e-02f, -5.10777310e-02f, 4.00178395e-02f, -6.12423941e-02f, -2.03695446e-02f, 6.29217103e-02f,
  -1.90062538e-01f, 3.14255506e-02f, -6.01052567e-02f, -4.85610962e-02f, -3.64953466e-02f, -8.65941495e-02f, -8.82642120e-02f, -6.86583146e-02f, -9.35090855e-02f, -5.51448688e-02f,
  -5.82702784e-03f, -1.07889064e-01f, -1.15021050e-01f, -6.44039139e-02f, 2.85072103e-02f, -5.79309464e-02f, -1.24671921e-01f, -7.05666095e-02f, -1.12208553e-01f, -7.96070416e-03f,
  -8.86696801e-02f, -9.36708748e-02f, -1.10253774e-01f, -1.45240963e-01f, -3.56017798e-02f, -1.65604204e-01f, -1.18538432e-01f, -5.61943911e-02f, -8.80441517e-02f, -2.70613194e-01f,
  -5.43687977e-02f, -1.15098275e-01f, -2.16629297e-01f, -3.24172117e-02f, -2.15631902e-01f, -9.40733701e-02f, -2.26167187e-01f, -2.65485235e-02f, -5.79718724e-02f, 3.52334939e-02f,
  9.90348235e-02f, 1.37705982e-01f, 6.54367879e-02f, 6.40964508e-02f, -1.57470986e-01f, -6.37926981e-02f, -1.90395236e-01f, -8.50411654e-02f, -4.01826501e-02f, -7.80954584e-02f,
  5.86748570e-02f, 1.69546194e-02f, -1.24292709e-01f, -9.43224058e-02f, 5.80767132e-02f, 6.19350933e-02f, -6.33947179e-02f, -3.37742232e-02f, 6.02450920e-03f, -5.53339571e-02f,
  3.33893567e-01f, -2.14922786e-01f, -2.83079036e-02f, -3.31315510e-02f, -2.44645122e-02f, -4.68513146e-02f, 2.69409847e-02f, -7.84504507e-03f, -2.36664917e-02f, 5.05546667e-02f,
  6.67054430e-02f, 3.14944349e-02f, -3.03437244e-02f, 2.07309425e-02f, -7.30370078e-03f, 7.35171288e-02f, -9.99751594e-03f, -1.17652901e-01f, -8.75160098e-04f, -3.00531462e-02f,
  -4.21658047e-02f, -1.02397121e-01f, 4.07171901e-03f, -5.10125756e-02f, -3.28372270e-02f, -7.03911260e-02f, -4.13063020e-02f, -6.68454915e-02f, -1.38462022e-01f, 8.52120072e-02f,
  6.68579936e-02f, 4.87673692e-02f, 5.17585576e-02f, -2.50532031e-02f, 4.94916141e-02f, 5.60801327e-02f, -2.58015171e-02f, 9.33556929e-02f, 7.19308928e-02f, 1.20320125e-03f,
  4.51644734e-02f, -2.80203088e-03f, 4.10736315e-02f, 6.11716881e-02f, -7.84273911e-03f, 6.13504164e-02f, -6.87442347e-02f, 2.64152978e-02f, -8.85903463e-03f, -5.00222258e-02f,
  -5.02458960e-02f, -1.22528821e-02f, 5.47390878e-02f, -3.47122736e-02f, -1.16475053e-01f, -5.00838719e-02f, 3.09332591e-02f, 6.16431572e-02f, 5.37463240e-02f, -1.09815255e-01f,
  3.48297596e-01f, -2.32641280e-01f, -2.30757017e-02f, 2.19275523e-02f, -1.10760823e-01f, 1.55576570e-02f, 2.45320313e-02f, 1.60867302e-03f, 5.27643673e-02f, 8.75794217e-02f,
  3.19435447e-02f, 1.02201633e-01f, -3.83913927e-02f, -6.78454787e-02f, 9.97840911e-02f, 2.24367436e-02f, 1.47793889e-02f, -8.92600045e-02f, 7.89871067e-03f, 9.18370858e-02f,
  -2.59086862e-02f, 4.39563505e-02f, 2.46641207e-02f, -4.84339055e-03f, 8.05847347e-02f, -1.36950854e-02f, 6.87085465e-02f, -1.96954273e-02f, -4.74137738e-02f, 1.86542541e-01f,
  6.44376576e-02f, 6.44545034e-02f, -1.06490195e-01f, -4.90027703e-02f, 9.16699097e-02f, 8.84383097e-02f, -3.60306073e-03f, 6.47149757e-02f, 1.58332780e-01f, 4.04722691e-02f,
  1.77352533e-01f, 1.69716716e-01f, 2.13119879e-01f, 1.45622611e-01f, 1.50820270e-01f, 3.90993692e-02f, -3.09813451e-02f, 4.88414392e-02f, 3.20922397e-02f, 1.44854654e-02f,
  -4.09226725e-03f, -5.38765639e-02f, -1.11692011e-01f, 6.55979887e-02f, -1.18909352e-01f, -2.64684930e-02f, -1.13542885e-01f, -8.04280564e-02f, -9.52193141e-02f, -1.26634598e-01f,
  -1.13883935e-01f, -5.45976199e-02f, 1.18308291e-01f, 4.12181579e-02f, -1.01521417e-01f, -7.45143294e-02f, -9.76309180e-03f, -1.55025706e-01f, -1.20963184e-02f, -6.83830976e-02f,
  -4.50114952e-03f, 1.48887932e-02f, -9.52404737e-02f, -8.58252570e-02f, -6.61932752e-02f, -8.58751778e-03f, 1.23172496e-02f, 2.28426214e-02f, 1.07202105e-01f, 2.80708000e-02f,
  -5.35820611e-02f, 4.33428995e-02f, 3.42599973e-02f, 1.09624572e-01f, 1.25233203e-01f, 1.16923034e-01f, -4.42212448e-02f, 4.94235717e-02f, -1.65373669e-03f, -5.38526438e-02f,
  -4.87256516e-03f, 3.32497619e-02f, 1.40662109e-02f, -1.38043733e-02f, 4.24132720e-02f, 4.20896783e-02f, -8.94284397e-02f, 1.44036468e-02f, 8.06697980e-02f, -1.12235419e-01f,
  3.01412251e-02f, 9.57923159e-02f, 6.81321695e-02f, 3.48062888e-02f, 1.64403971e-02f, -5.80201298e-02f, -8.61848425e-03f, 2.09347270e-02f, 9.02938750e-03f, -7.41436034e-02f,
  8.12598616e-02f, 4.24209097e-03f, -6.19342923e-02f, -1.08136728e-01f, 5.34553416e-02f, 8.36137384e-02f, -4.23582606e-02f, 1.88212935e-02f, -6.28924444e-02f, 7.90983513e-02f,
  -7.94170424e-02f, 1.98283032e-01f, 6.77416772e-02f, -4.70184721e-02f, -9.41488072e-02f, -4.02436107e-02f, -5.77636361e-02f, -7.02696573e-03f, -6.91759139e-02f, -1.04469573e-02f,
  -3.93283479e-02f, -7.13164881e-02f, -8.58664662e-02f, -3.88267450e-02f, -2.54007466e-02f, -3.67571563e-02f, -9.69129279e-02f, 4.44074050e-02f, -3.39521132e-02f, 4.32451740e-02f,
  4.38113399e-02f, -6.44672313e-04f, 1.19542971e-01f, 9.26074162e-02f, 9.39011127e-02f, 4.72870581e-02f, 4.65984568e-02f, -1.96015500e-02f, 1.19134441e-01f, 6.06004894e-02f,
  -1.82528481e-01f, 3.55619639e-02f, -1.49795845e-01f, -1.57879740e-02f, 2.19948709e-01f, 2.50844657e-01f, 2.51439631e-01f, 1.70468017e-01f, 7.05325752e-02f, 5.30414172e-02f,
  -6.03802614e-02f, -7.24167153e-02f, -1.07337184e-01f, 2.28334516e-02f, 9.92806330e-02f, 5.91492699e-03f, 9.92661193e-02f, -7.86687881e-02f, -1.00412451e-01f, 9.29546505e-02f,
  1.16977267e-01f, -2.57572401e-02f, -1.15125135e-01f, -2.19988078e-02f, -7.28019029e-02f, -2.71195807e-02f, -5.55528328e-02f, -5.03612682e-02f, 4.11790460e-02f, -1.13647528e-01f,
  -2.05216140e-01f, 5.95232891e-03f, 2.89491341e-02f, 4.95115630e-02f, -1.01639435e-01f, -7.95309916e-02f, -6.83554932e-02f, 9.41823516e-03f, -7.33709335e-02f, -4.57161628e-02f,
  -1.11398257e-01f, 1.96052901e-02f, 1.06192715e-02f, 1.24203842e-02f, -1.20666316e-02f, -5.88400140e-02f, 4.40464076e-03f, -6.61367550e-02f, -8.33439901e-02f, -9.12868306e-02f,
  1.18288971e-01f, -3.84538025e-02f, 1.33010261e-02f, -5.90739027e-02f, -3.10814730e-03f, -1.00704990e-01f, 4.35978770e-02f, -2.46612797e-03f, -6.79125413e-02f, -8.02288502e-02f,
  5.55590913e-02f, -6.54873103e-02f, 6.42842427e-02f, 4.05403264e-02f, 5.45305312e-02f, -8.09266642e-02f, -9.58867930e-03f, -1.70406736e-02f, -5.20747006e-02f, -9.73836146e-03f,
  -2.01200023e-02f, -5.89662716e-02f, -9.07700416e-03f, -6.52595311e-02f, 2.77875848e-02f, 5.58483601e-02f, 3.38991433e-02f, -5.53448871e-02f, -3.68763767e-02f, -7.58541077e-02f,
  3.68984342e-02f, -5.00685610e-02f, -2.16483679e-02f, 3.70232090e-02f, 7.66388029e-02f, -8.81597474e-02f, -4.10828665e-02f, 7.21313655e-02f, -6.30230755e-02f, 2.33056508e-02f,
  -2.62701493e-02f, 1.07227989e-01f, -6.30448982e-02f, 4.08589393e-02f, -1.25857085e-01f, 2.69691609e-02f, -5.65434992e-02f, -1.08592026e-01f, -5.76009117e-02f, 6.16992936e-02f,
  9.41908509e-02f, 8.06468073e-03f, -7.46505260e-02f, -3.98797635e-03f, -5.17086722e-02f, 4.00313586e-02f, 9.52351317e-02f, 4.45022658e-02f, -4.36679460e-02f, -7.27755278e-02f,
  9.40806642e-02f, -1.75961398e-03f, 1.02048956e-01f, 1.00087509e-01f, 4.05552313e-02f, -8.09086189e-02f, -2.20202133e-02f, -2.14663018e-02f, 9.14782137e-02f, 9.17271972e-02f,
  3.75276953e-01f, -9.91171896e-02f, -1.63159788e-01f, 6.18350692e-02f, -1.47575259e-01f, -1.97852179e-02f, -5.25995791e-02f, 1.47483781e-01f, 4.38894965e-02f, 5.20455465e-02f,
  5.66647835e-02f, 2.38937229e-01f, 2.30952576e-01f, 1.24586910e-01f, 1.60385191e-01f, -8.54188576e-02f, -1.35795265e-01f, 9.03345868e-02f, 1.93827778e-01f, 1.94573193e-03f,
  -1.35627493e-01f, -3.53081920e-03f, 9.75318700e-02f, 6.68614283e-02f, -1.69631526e-01f, -9.42950249e-02f, -6.29700273e-02f, -1.55136675e-01f, -1.57584921e-01f, -8.60490203e-02f,
  -4.42197658e-02f, 2.20536478e-02f, 1.63232461e-01f, -2.51780823e-02f, -1.17078535e-01f, -1.13727897e-03f, 4.57059294e-02f, -7.00275972e-02f, -8.65933076e-02f, -1.42139107e-01f,
  -1.27119452e-01f, 6.41210601e-02f, 6.92542084e-03f, -6.65502101e-02f, -1.10714741e-01f, 1.00252694e-02f, -1.35578904e-02f, 8.88028741e-02f, 6.49239076e-03f, 9.47802421e-03f,
  -1.50522649e-01f, -1.00149758e-01f, 3.71280573e-02f, 3.68879586e-02f, 6.62019998e-02f, 6.14273250e-02f, 1.85753256e-02f, 5.29648475e-02f, 1.17154315e-01f, -1.33505136e-01f,
  -5.20421267e-02f, 3.58202569e-02f, -1.90108584e-03f, 8.92517865e-02f, 3.17500234e-02f, -3.01066432e-02f, 7.07954764e-02f, -8.38609412e-02f, 9.03110132e-02f, 4.20450792e-02f,
  -9.77922902e-02f, 2.63087433e-02f, -7.44841769e-02f, -5.67627735e-02f, 7.75966570e-02f, -6.79746568e-02f, -2.23430004e-02f, 3.50810736e-02f, -3.00883316e-03f, 5.33597618e-02f,
  6.39507249e-02f, 5.79597838e-02f, 1.78875607e-02f, 2.61092950e-02f, -6.62144795e-02f, -5.80323376e-02f, -6.95765764e-02f, -2.98783500e-02f, 2.74246186e-02f, 2.25319285e-02f,
  -1.92280486e-01f, 2.69547194e-01f, 7.74616823e-02f, 3.14745754e-02f, -6.67471662e-02f, -6.13043532e-02f, 8.88757259e-02f, -3.62977944e-02f, -3.82392444e-02f, -5.19760065e-02f,
  2.99568903e-02f, 4.70004752e-02f, 2.58413292e-02f, -9.75842308e-03f, -7.44257271e-02f, 2.93265413e-02f, 2.42994577e-02f, 1.07100926e-01f, -7.58173876e-03f, -5.80321588e-02f,
  -9.54592898e-02f, 2.75282301e-02f, 8.66224766e-02f, 1.10502949e-03f, -1.59177836e-03f, 1.74233004e-01f, 2.78803464e-02f, -1.46165036e-03f, 1.63161591e-01f, -9.64070782e-02f,
  4.55361456e-01f, -2.25855753e-01f, -3.40427220e-01f, 6.58307374e-02f, -1.54735267e-01f, -3.09847206e-01f, -3.83348882e-01f, -1.19515568e-01f, -9.57607105e-03f, -1.50951624e-01f,
  -2.11708754e-01f, -4.07499336e-02f, 3.78073975e-02f, 4.01425399e-02f, -8.30184761e-03f, -1.92531914e-01f, -1.58078402e-01f, -2.84778904e-02f, -1.46592380e-02f, -3.84305865e-02f,
  -1.95651054e-01f, -8.02880004e-02f, 1.39047444e-01f, 9.58177522e-02f, -1.30240947e-01f, -1.66223123e-04f, -5.67252003e-02f, -5.13874665e-02f, -2.02000841e-01f, -2.09196031e-01f,
  -3.27301025e-01f, 1.37709573e-01f, -3.57323000e-03f, 2.65853424e-02f, -3.29632051e-02f, 7.51904994e-02f, -1.34418998e-02f, 1.83856103e-03f, 1.32878206e-03f, 4.82606888e-02f,
  -5.03075086e-02f, 5.28207459e-02f, 6.68473765e-02f, 5.62874973e-02f, -6.36091605e-02f, 6.61307573e-02f, -2.40682941e-02f, 1.33883983e-01f, 7.51863420e-02f, -1.49680793e-01f,
  -1.58946022e-01f, -6.34894148e-02f, 5.46421781e-02f, -2.57123727e-02f, 6.13480806e-02f, 7.30100870e-02f, -1.57784104e-01f, 4.37416658e-02f, -7.83258453e-02f, 3.12941559e-02f,
  -1.20157242e-01f, 2.08067941e-03f, -6.65270165e-02f, -4.32923902e-03f, -1.99444741e-02f, 1.66928768e-02f, -6.74351677e-02f, 7.12915212e-02f, -7.48778880e-02f, 9.87087656e-03f,
  -5.79056591e-02f, -9.40559581e-02f, -6.25066385e-02f, 8.35995097e-03f, -3.83394137e-02f, 3.47092599e-02f, 4.60404567e-02f, -2.20578518e-02f, -4.51661311e-02f, 8.85474831e-02f,
  8.02706741e-03f, -3.32738683e-02f, 2.99798232e-02f, -8.68567079e-02f, -6.41143844e-02f, 5.26211224e-02f, -3.07141580e-02f, 1.15872761e-02f, 5.24097644e-02f, -2.72931010e-02f,
  1.47151008e-01f, -4.27747369e-02f, 9.59732905e-02f, 1.91063866e-01f, -4.38024513e-02f, 1.98332984e-02f, -6.41324520e-02f, 8.60604346e-02f, 9.06757265e-02f, -6.30614683e-02f,
  -8.99766684e-02f, -6.61507547e-02f, 1.52236959e-02f, -5.69359027e-02f, -8.08069631e-02f, 4.71586315e-03f, 6.57750070e-02f, -4.57441323e-02f, -4.39483672e-02f, -1.73680503e-02f,
  -7.62820169e-02f, 1.07727639e-01f, 1.46226272e-01f, 2.33175494e-02f, -1.38660287e-02f, 8.54198411e-02f, -5.99619895e-02f, 7.22002750e-03f, 5.74858822e-02f, 3.30159441e-02f,
  -2.17957914e-01f, 1.02042235e-01f, 2.67326564e-01f, -9.21992213e-02f, -1.32501289e-01f, -7.77481049e-02f, -5.70470728e-02f, 4.38688397e-02f, -1.14249013e-01f, -1.29999697e-01f,
  -8.95621404e-02f, -1.18239075e-01f, -4.45827171e-02f, 4.94475067e-02f, -2.00849045e-02f, 1.08213127e-01f, -3.97379547e-02f, -2.15723049e-02f, -1.01457164e-01f, -1.84530243e-01f,
  -1.44983679e-01f, -1.52692392e-01f, -1.29716337e-01f, -1.38847372e-02f, -1.69047657e-02f, -1.18120372e-01f, 7.44671002e-02f, 3.77756637e-03f, -4.09174599e-02f, -9.94925667e-03f,
  1.53114259e-01f, 1.59948260e-01f, -1.13760017e-01f, -1.36165231e-01f, 3.76550592e-02f, -9.17488057e-03f, 4.21457179e-02f, 1.37717471e-01f, 7.43618757e-02f, 1.11336589e-01f,
  -4.44514491e-02f, 7.37462146e-03f, -1.86068155e-02f, -3.00268512e-02f, -3.28445435e-02f, -4.36296239e-02f, 7.83264786e-02f, 7.02893436e-02f, 1.32442653e-01f, 5.60860150e-02f,
  -1.12858899e-01f, -1.77800342e-01f, -3.29169482e-02f, 2.19388846e-02f, 6.47656992e-02f, -8.69729966e-02f, 7.70421848e-02f, 5.05884402e-02f, 5.46981730e-02f, -2.35135071e-02f,
  -5.04503101e-02f, 1.87438540e-02f, -2.95817591e-02f, 3.64718437e-02f, -1.95823945e-02f, 9.93327647e-02f, -1.09626921e-02f, -1.08880967e-01f, -5.62813729e-02f, -2.85904612e-02f,
  -3.17343697e-02f, 2.04085112e-02f, 3.19851190e-02f, -6.63427413e-02f, 2.19734479e-02f, 4.01339866e-02f, -5.22548938e-03f, -2.40967665e-02f, -1.66644603e-02f, 2.31911484e-02f,
  2.19543390e-02f, 4.39433642e-02f, -3.93874720e-02f, 8.03969149e-03f, 7.60811046e-02f, 3.33750211e-02f, 6.40846267e-02f, -6.76470697e-02f, -6.62170425e-02f, 2.06766985e-02f,
  -1.32419616e-01f, 4.97952849e-02f, -1.99947748e-02f, -6.44918904e-02f, -1.39387185e-02f, -5.11890836e-02f, -6.28517866e-02f, 5.18276617e-02f, 8.25036541e-02f, -5.65012768e-02f,
  -5.45522720e-02f, 2.46974695e-02f, -1.17704377e-01f, 1.28778322e-02f, -2.09591966e-02f, -9.94947031e-02f, -1.07187346e-01f, -1.27161831e-01f, -1.13051059e-02f, 3.63413654e-02f,
  -1.50020510e-01f, -1.93434328e-01f, -2.25968361e-01f, -1.13995887e-01f, 3.40447389e-02f, -1.22922555e-01f, -4.91635576e-02f, -1.98910255e-02f, -1.35671988e-01f, -2.41056979e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 26)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 26;
const float L0_fan_Bp_bar_data[] = {
  1.50325745e-01f, 1.48985267e-01f, 1.13677971e-01f, 1.19741470e-01f, 9.87710804e-02f, 2.28033245e-01f, 2.22463533e-01f, 1.38697147e-01f, 2.24927291e-01f, 1.79786935e-01f,
  9.53281969e-02f, 1.60805672e-01f, 4.50839400e-02f, 2.64375776e-01f, 1.25923440e-01f, 5.83485849e-02f, 9.82600227e-02f, 1.02493443e-01f, 1.66667253e-01f, 3.63793932e-02f,
  1.64545953e-01f, 1.86934710e-01f, 2.02145055e-01f, 1.93491071e-01f, 1.27881765e-01f, 1.25466585e-01f
};

// L1_linear_W (Shape: 12 x 64)
const int L1_linear_W_rows = 12;
const int L1_linear_W_cols = 64;
const float L1_linear_W_data[] = {
  -3.51022720e-01f, 7.77999759e-02f, -4.97432768e-01f, 1.41176507e-01f, -3.96822333e-01f, -6.15728974e-01f, -1.35173246e-01f, -4.90084141e-02f, -3.06160748e-01f, 2.02566478e-02f,
  -1.80460259e-01f, 2.59604566e-02f, -4.78193372e-01f, -1.00956813e-01f, 1.55284768e-02f, -2.83612788e-01f, -1.92703217e-01f, -3.25122565e-01f, -4.14465219e-01f, 1.52323052e-01f,
  -1.18590586e-01f, 1.01988301e-01f, -1.40174717e-01f, -1.41138256e-01f, 3.56014110e-02f, -3.67114782e-01f, 6.33524135e-02f, 9.53291804e-02f, 2.33090222e-02f, 3.18649888e-01f,
  -7.24010244e-02f, 1.95016548e-01f, -1.53810591e-01f, 1.57706246e-01f, -3.19206566e-01f, -3.67089927e-01f, 3.40358987e-02f, 2.21657097e-01f, 4.97753799e-01f, -2.10724786e-01f,
  3.03825643e-02f, -1.37671366e-01f, 9.21328831e-03f, -6.87006339e-02f, 4.94366556e-01f, -2.44903550e-01f, -2.23046139e-01f, -2.11871967e-01f, -1.34921782e-02f, -2.33213320e-01f,
  -3.44179897e-03f, 4.99029189e-01f, -1.29819721e-01f, 3.46347123e-01f, 1.57546952e-01f, 2.98695534e-01f, 1.77691489e-01f, 3.64137471e-01f, 1.83793411e-01f, 7.88108818e-03f,
  1.45282194e-01f, 9.02491435e-02f, 2.41756395e-01f, -6.98557869e-02f, 3.54799181e-01f, -1.34968638e-01f, 2.01948240e-01f, 5.81685314e-03f, 2.58416593e-01f, 1.05754621e-01f,
  1.07741103e-01f, 3.62007797e-01f, -1.60815567e-01f, 4.05249707e-02f, -7.07890809e-01f, -1.67110451e-02f, -4.47941795e-02f, -2.70259589e-01f, 2.25057691e-01f, -1.31486237e-01f,
  -4.36472287e-03f, -3.98403674e-01f, -4.91546541e-02f, -2.19168529e-01f, -8.57807621e-02f, 1.58250272e-01f, 4.09283750e-02f, -1.10983580e-01f, 4.46138769e-01f, -4.40503746e-01f,
  9.31603834e-02f, 1.58767223e-01f, -4.99881685e-01f, 7.83990860e-01f, 4.03513253e-01f, 2.25300178e-01f, -2.00216964e-01f, -4.00736243e-01f, -1.65996447e-01f, -4.53501731e-01f,
  1.08189754e-01f, 2.12332904e-02f, 2.34406710e-01f, 3.09061706e-02f, -2.61019200e-01f, -1.86491180e-02f, -6.46378025e-02f, 1.54936746e-01f, -1.06300637e-01f, 3.01402390e-01f,
  -3.79846334e-01f, 7.64569119e-02f, 2.67160386e-01f, -1.80860147e-01f, 3.62022012e-01f, 2.39554510e-01f, -1.20688841e-01f, -1.37259424e-01f, 1.33964652e-02f, -9.86204017e-03f,
  1.53636381e-01f, -2.44398758e-01f, -6.85850158e-02f, 4.69017059e-01f, -6.49142340e-02f, 7.32760251e-01f, 6.02788687e-01f, -1.04890347e-01f, 1.73194885e-01f, -1.95288107e-01f,
  1.38786003e-01f, 2.20718980e-01f, 1.09635502e-01f, 4.24876928e-01f, -1.22645624e-01f, -8.84838104e-02f, 5.14275253e-01f, -1.65419877e-01f, -8.66628140e-02f, 2.24880800e-01f,
  4.47873473e-01f, 2.40529820e-01f, -4.59236838e-02f, 1.89545885e-01f, 7.35809654e-02f, 2.48322219e-01f, 9.17740837e-02f, -3.54831308e-01f, -6.02832258e-01f, -1.11547552e-01f,
  -1.57328129e-01f, -2.46742174e-01f, 9.76822972e-02f, -5.74330509e-01f, -4.63422745e-01f, 9.69027076e-03f, 3.47850531e-01f, 6.31192029e-01f, -4.69303548e-01f, -1.49187475e-01f,
  3.63692224e-01f, 2.39452139e-01f, 1.52203068e-01f, 9.58239064e-02f, -1.50612488e-01f, 1.50129631e-01f, 1.63827389e-01f, -9.02047306e-02f, 6.68843910e-02f, -2.22839937e-01f,
  9.91076455e-02f, -1.58637986e-01f, 4.34335649e-01f, -3.32826763e-01f, -6.45577982e-02f, -1.87332392e-01f, -1.52256757e-01f, -2.78941065e-01f, -1.85689643e-01f, 3.95696461e-01f,
  1.97630107e-01f, 3.19226459e-02f, -1.08414762e-01f, -2.78696209e-01f, 1.03968546e-01f, -2.07556367e-01f, -1.89250097e-01f, -1.92405805e-02f, -1.26312003e-01f, 5.95564879e-02f,
  5.53558916e-02f, 1.86413154e-01f, -1.26467764e-01f, 1.14773221e-01f, 7.09240139e-03f, 1.99801683e-01f, -5.29644787e-01f, 1.61481649e-01f, 2.31262103e-01f, 5.17587960e-02f,
  -2.68184155e-01f, -1.44203484e-01f, 6.37224093e-02f, -5.21926641e-01f, 1.14414804e-01f, 2.87335724e-01f, 4.79628928e-02f, -2.77384728e-01f, -1.04139820e-02f, 1.15537859e-01f,
  1.77063227e-01f, 2.10206434e-01f, -1.63450018e-01f, 1.66854858e-01f, 2.07820848e-01f, -1.25897244e-01f, 2.44127899e-01f, -1.21438377e-01f, 1.04269318e-01f, 7.69407228e-02f,
  1.37568012e-01f, -3.58232498e-01f, -4.18331951e-01f, 2.57664651e-01f, -1.80034116e-01f, 2.62485713e-01f, -4.89916921e-01f, 3.64472598e-01f, 1.75914034e-01f, 2.69464403e-01f,
  -3.16937178e-01f, -2.80435324e-01f, -4.44257855e-02f, 3.35724175e-01f, -1.66615799e-01f, -2.26845760e-02f, 6.98142052e-01f, -5.62106706e-02f, 4.95493978e-01f, -2.84423996e-02f,
  -1.95831563e-02f, 4.42207903e-01f, -1.75309777e-01f, -4.90159690e-01f, -1.61665231e-01f, -3.04561220e-02f, -1.61095578e-02f, 1.81007937e-01f, -2.55334526e-01f, 3.20062160e-01f,
  -2.39914522e-01f, 2.05109671e-01f, 2.25510791e-01f, -6.25719205e-02f, -5.72572410e-01f, 3.48997772e-01f, -4.12336767e-01f, 2.79444344e-02f, 9.05397460e-02f, -7.16216862e-01f,
  -2.70982713e-01f, -1.28736079e-01f, -2.61894196e-01f, 7.13469880e-03f, -4.46819007e-01f, -5.46348214e-01f, 1.02184877e-01f, -1.82288051e-01f, 3.79799813e-01f, 2.69652605e-01f,
  3.30526710e-01f, 4.89539117e-01f, 1.72008574e-02f, 1.34589979e-02f, 6.95104003e-02f, 2.52861828e-01f, -7.88273811e-02f, 7.61457533e-02f, -5.23169219e-01f, -3.41029048e-01f,
  4.21701282e-01f, 6.50539637e-01f, -4.40857768e-01f, 4.68578190e-01f, 3.34511906e-01f, -3.82430196e-01f, -4.04873490e-01f, 1.22504190e-01f, -2.69537181e-01f, -2.22820804e-01f,
  -8.05700943e-02f, -5.17552458e-02f, 3.59188497e-01f, 4.66494828e-01f, -9.58908051e-02f, -1.93207432e-02f, 1.52825685e-02f, 1.22996666e-01f, 1.05868243e-01f, -9.47224647e-02f,
  -3.75651717e-01f, 1.47384584e-01f, 1.23076394e-01f, 1.38552055e-01f, -5.49301542e-02f, 2.15993654e-02f, -2.68602502e-02f, 5.30602157e-01f, 8.55142698e-02f, -1.30698413e-01f,
  -1.82362363e-01f, 1.27563357e-01f, -8.49065706e-02f, -3.88238765e-02f, 1.08170137e-01f, -2.86205416e-03f, -2.39318088e-01f, -1.60807922e-01f, 7.06761181e-02f, 5.26799023e-01f,
  1.28324628e-01f, 8.66146609e-02f, 1.66553631e-01f, 2.38682464e-01f, 3.39978524e-02f, 2.04935670e-01f, 1.65757179e-01f, 6.48105070e-02f, 2.95159191e-01f, 5.35102129e-01f,
  6.52808487e-01f, 1.19886659e-01f, 3.79221022e-01f, -1.10438526e-01f, -1.79857925e-01f, 3.48729044e-01f, 2.85407275e-01f, -2.46383563e-01f, -1.61376476e-01f, 3.20961893e-01f,
  6.77152276e-01f, 4.87974584e-01f, -3.70502472e-01f, 4.26179618e-01f, 1.80316538e-01f, 3.42921138e-01f, 2.25965008e-01f, -4.54284586e-02f, -1.56875968e-01f, -2.62444407e-01f,
  1.78177610e-01f, 5.11918306e-01f, -3.93858314e-01f, -6.51163876e-01f, -3.55585441e-02f, -2.59617686e-01f, 5.84446192e-01f, 2.32476711e-01f, 9.36480612e-02f, 3.94862711e-01f,
  -2.26693042e-02f, -8.18519816e-02f, 5.00489445e-03f, -6.36058375e-02f, -3.40419024e-01f, -8.32067803e-02f, -1.07638892e-02f, 1.54655978e-01f, -2.52114534e-01f, -1.75154135e-01f,
  -3.42889242e-02f, -2.73860782e-01f, -1.18894614e-01f, -2.11626012e-02f, 3.39614660e-01f, -3.01684737e-01f, -1.09867655e-01f, -2.26672441e-01f, 2.67043859e-01f, 8.76837000e-02f,
  2.22646028e-01f, -1.11155398e-01f, 3.05678070e-01f, -3.03706855e-01f, 2.32919067e-01f, 7.32895285e-02f, 1.67744085e-02f, 4.62776236e-03f, -3.17879349e-01f, -1.58270702e-01f,
  2.06713483e-01f, 1.51315823e-01f, -4.97235239e-01f, -2.62582786e-02f, 2.95904130e-01f, -4.33652282e-01f, -4.72958297e-01f, -1.95723362e-02f, 1.24123320e-01f, -5.45560539e-01f,
  1.98691398e-01f, 8.01694021e-02f, 4.61098760e-01f, -3.52113128e-01f, -1.67080879e-01f, -7.26391226e-02f, -3.55330229e-01f, 5.15333295e-01f, -4.15840894e-01f, -7.98381418e-02f,
  5.46460375e-02f, -5.49380124e-01f, 2.25990355e-01f, 5.96826449e-02f, 6.08240485e-01f, -3.86917949e-01f, 4.51167583e-01f, 9.69611108e-02f, 6.81253016e-01f, -1.11675523e-01f,
  -2.04006568e-01f, 3.49131003e-02f, -1.41652688e-01f, -6.60730079e-02f, 5.57260096e-01f, -3.05477798e-01f, 2.64181703e-01f, -8.92192647e-02f, 4.91337553e-02f, 1.52899966e-01f,
  -2.87914604e-01f, -7.93816149e-02f, 2.93428265e-02f, -8.51914808e-02f, -2.45439410e-01f, -2.79650837e-01f, 4.71464678e-04f, -1.03350885e-01f, -7.73832900e-03f, -1.56547815e-01f,
  5.21353446e-02f, -1.84803322e-01f, -2.44277015e-01f, -2.52458245e-01f, -2.91263968e-01f, -3.69642712e-02f, 1.27336815e-01f, 2.29612797e-01f, 8.18943530e-02f, -2.88558602e-01f,
  1.39164612e-01f, -2.89068609e-01f, 5.22339484e-03f, -8.07901919e-02f, -2.42157429e-01f, -7.43667260e-02f, -2.03143239e-01f, 5.34051284e-02f, -8.41759980e-01f, -1.62037626e-01f,
  8.12799037e-02f, -2.16832906e-01f, -4.17384505e-01f, -7.14029185e-03f, -5.86662777e-02f, -3.32245603e-02f, 5.22105210e-02f, 1.16537131e-01f, 2.91890293e-01f, -1.37780190e-01f,
  3.34358484e-01f, 3.43790390e-02f, -9.86635014e-02f, -3.01126003e-01f, -4.96612526e-02f, -1.43105581e-01f, -4.97969016e-02f, -3.02771628e-01f, -2.52118587e-01f, -1.55824527e-01f,
  2.28682429e-01f, 2.53768384e-01f, 2.96540856e-01f, 1.26505002e-01f, -1.21509090e-01f, -2.91220516e-01f, -8.87823626e-02f, 9.83603820e-02f, -1.57095283e-01f, 1.33056641e-01f,
  3.39597851e-01f, -1.94179860e-03f, 7.38062849e-03f, -2.84932077e-01f, 7.51761079e-01f, 1.65907532e-01f, 1.95975944e-01f, 8.51332024e-02f, -6.59012645e-02f, -1.57096207e-01f,
  5.15597403e-01f, 2.71067560e-01f, -1.90984741e-01f, -3.07145342e-02f, -1.67373702e-01f, 2.60056883e-01f, -1.58685684e-01f, 1.49506211e-01f, 3.54884863e-01f, -1.10707022e-01f,
  -1.42946318e-01f, -7.34811202e-02f, -2.76815265e-01f, 9.71140899e-03f, -5.25364429e-02f, -2.42930293e-01f, -2.80938353e-02f, -4.00138259e-01f, 3.40760611e-02f, 4.98588569e-03f,
  6.06485792e-02f, -1.95316926e-01f, 6.61816671e-02f, 1.48827955e-01f, 2.08291829e-01f, 1.85464963e-01f, 1.72135815e-01f, -1.99520499e-01f, 2.82260805e-01f, 1.68407634e-01f,
  3.70728895e-02f, -5.32283723e-01f, -3.62139307e-02f, -5.51509798e-01f, 6.27243578e-01f, 4.51141119e-01f, -7.00576901e-01f, -1.47320598e-01f, 2.47337863e-01f, -3.81273627e-01f,
  -4.23533231e-01f, 2.67533273e-01f, 1.20288752e-01f, -5.99858314e-02f, -4.69843656e-01f, -2.34867901e-01f, -5.33722401e-01f, -8.29589292e-02f, -3.87935847e-01f, -2.89294571e-01f,
  -2.84293920e-01f, -1.45222917e-01f, -2.40060892e-02f, -1.42187208e-01f, 1.09445982e-01f, 5.59798479e-01f, -1.00583933e-01f, -4.00843531e-01f, -1.48095042e-01f, 3.05143803e-01f,
  2.72383157e-04f, 6.59114644e-02f, 7.11462125e-02f, -2.04375625e-01f, -1.91729978e-01f, -1.25987679e-01f, 1.80596635e-01f, -1.35714531e-01f, -1.62128717e-01f, -6.47439659e-02f,
  -2.13594660e-01f, -9.90494266e-02f, 1.48177862e-01f, -2.27982327e-02f, 4.77335900e-02f, -1.34315044e-01f, -3.86406668e-02f, 2.68796772e-01f, -2.19049174e-02f, -7.39411861e-02f,
  3.63156080e-01f, 2.81591237e-01f, -6.58496097e-02f, -5.93660891e-01f, 1.88843787e-01f, 9.56590846e-02f, -3.35840322e-02f, 3.00018847e-01f, 5.15467636e-02f, 1.77227572e-01f,
  -1.36940731e-02f, -3.60536337e-01f, 5.00668809e-02f, 7.18406588e-02f, 2.23993838e-01f, 6.46837175e-01f, 2.06261888e-01f, 1.05177909e-01f, -1.76421583e-01f, -7.08934441e-02f,
  -1.02887779e-01f, 4.66312021e-01f, -5.44292033e-01f, -2.03226864e-01f, 1.17822289e-01f, -7.44278073e-01f, 2.32837349e-01f, -5.93942106e-01f, 2.89542377e-01f, 2.62472808e-01f,
  5.42470753e-01f, -2.94725955e-01f, -9.49097127e-02f, 7.23410845e-02f, 2.70979643e-01f, 3.59874099e-01f, 1.30867818e-02f, 1.94425911e-01f, -2.57575989e-01f, -2.94523388e-01f,
  -1.17749251e-01f, 3.81810188e-01f, -2.23842233e-01f, -2.21140489e-01f, -3.45773965e-01f, -4.44019437e-02f, 4.94323999e-01f, 1.19892918e-02f, 8.07439312e-02f, 4.85657677e-02f,
  -1.87033594e-01f, 3.23097765e-01f, -1.48864323e-02f, 1.67124182e-01f, 1.09596431e-01f, -2.04512089e-01f, -1.24105036e-01f, -2.43648782e-01f, -1.43327162e-01f, -3.01904231e-01f,
  2.89458275e-01f, -1.18663833e-01f, -2.25829348e-01f, -4.64316495e-02f, -2.98577989e-03f, 1.83707893e-01f, -2.10094407e-01f, 1.11131839e-01f, 1.20617844e-01f, -6.03201874e-02f,
  2.08196223e-01f, 1.64827779e-01f, -2.72183180e-01f, -2.14863136e-01f, -3.04793984e-01f, 6.99094981e-02f, -2.22915500e-01f, 2.10212737e-01f, 2.85748124e-01f, 1.57760233e-01f,
  -3.44278842e-01f, -6.20898843e-01f, 6.37885034e-01f, -2.39209443e-01f, 3.03477466e-01f, 3.16563874e-01f, 2.25413188e-01f, 3.42210978e-01f, -4.60980177e-01f, 1.06789395e-01f,
  3.27220798e-04f, 3.01758051e-01f, -2.85505921e-01f, -4.80960548e-01f, 1.67573124e-01f, 5.53361297e-01f, 1.56834170e-01f, -3.91491726e-02f, -2.17745110e-01f, 5.44232242e-02f,
  -5.98993003e-02f, 1.65237606e-01f, -1.15902759e-01f, 1.99546903e-01f, -1.91838607e-01f, 3.55288088e-02f, 7.10807517e-02f, -2.98214614e-01f, -1.30442783e-01f, 5.20359337e-01f,
  -1.15741961e-01f, 1.27088204e-01f, -2.00627834e-01f, -3.63996578e-03f, -3.32656741e-01f, -2.09758475e-01f, -1.93125799e-01f, -1.15118556e-01f, 5.08080840e-01f, -4.91994098e-02f,
  -4.21567596e-02f, -1.22467652e-01f, -3.78593951e-01f, 5.78418300e-02f, -2.59498190e-02f, -5.89315556e-02f, 1.96969941e-01f, 2.71085262e-01f, 2.80620381e-02f, -3.04611564e-01f,
  1.70057908e-01f, 1.71870723e-01f, 3.00683409e-01f, 1.90584250e-02f, 2.83807933e-01f, 1.90550148e-01f, -2.59223372e-01f, -2.97531605e-01f, -2.49452400e-03f, 4.12249982e-01f,
  8.56997445e-02f, 2.95164715e-02f, -6.23133242e-01f, -3.02601367e-01f, 2.07099825e-01f, 3.96276206e-01f, 4.75293621e-02f, -5.41507341e-02f, -4.24209177e-01f, 3.60675544e-01f,
  4.88270044e-01f, 2.13965289e-02f, 2.73427844e-01f, -5.86210340e-02f, 1.40066324e-02f, -3.33965778e-01f, 4.38491642e-01f, 3.73979360e-01f, -3.53826702e-01f, 2.99100250e-01f,
  -1.83566540e-01f, -5.30255914e-01f, -1.77485079e-01f, -2.51346022e-01f, -1.91228956e-01f, -6.29646033e-02f, -3.20960224e-01f, -2.95113802e-01f, -1.69319343e-02f, 4.23810780e-01f,
  -2.40888312e-01f, 4.80094284e-01f, 4.70942587e-01f, 2.95356829e-02f, -2.57560879e-01f, -2.72028536e-01f, 5.13891829e-03f, -1.65372640e-01f, 9.92313493e-03f, -2.13373639e-02f,
  1.34096205e-01f, 1.33259282e-01f, -2.66450405e-01f, -9.46150944e-02f, 1.59082353e-01f, -2.60601752e-02f, -2.93676287e-01f, 1.35230258e-01f
};

// L1_linear_B (Shape: 1 x 12)
const int L1_linear_B_rows = 1;
const int L1_linear_B_cols = 12;
const float L1_linear_B_data[] = {
  -3.52991410e-02f, 1.50362868e-02f, -7.02002570e-02f, 3.30834016e-02f, 2.71966159e-02f, 1.19061142e-01f, -1.61636576e-01f, -2.87570171e-02f, 3.38703282e-02f, -3.49194780e-02f,
  6.28874823e-02f, -6.55215755e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 19, 26
    );
    
    // Camada 1: L1_linear
    linear_forward_pgm(
        buffer1, x_out,
        L1_linear_W_data, L1_linear_B_data,
        64, 12
    );
    }
    