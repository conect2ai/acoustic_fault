/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 64 (x4)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 64;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    static inline float fan_activation(float x) { return x; }

    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 25 x 120)
const int L0_fan_Wp_rows = 25;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  9.53913033e-02f, -4.92916465e-01f, 1.64352104e-01f, -3.31131183e-02f, -1.94161963e-02f, -3.40028703e-02f, -9.91326794e-02f, -1.43168047e-01f, -6.93489388e-02f, -1.82748973e-01f,
  -3.03394139e-01f, -2.42745861e-01f, -1.38828903e-01f, -1.31586596e-01f, -5.34434197e-03f, 2.80463547e-02f, 7.18492493e-02f, 2.24399179e-01f, 3.46582025e-01f, -8.62143040e-02f,
  -2.60800391e-01f, -6.03160970e-02f, 1.67767525e-01f, -3.84982154e-02f, -7.43040219e-02f, -8.67652334e-03f, 5.82958572e-03f, -1.51627421e-01f, -2.08317295e-01f, -1.34180397e-01f,
  1.67103171e-01f, -2.91989058e-01f, 6.86051250e-02f, -2.27703035e-01f, -1.77075863e-01f, -2.70894598e-02f, -1.17276952e-01f, 1.27008120e-02f, -4.68221940e-02f, -8.27850103e-02f,
  -1.54789507e-01f, -2.07296044e-01f, -5.25790267e-02f, -7.88230523e-02f, 6.26556901e-03f, 1.53911170e-02f, -7.11534470e-02f, 3.49247605e-02f, -4.42847945e-02f, -1.93142533e-01f,
  -2.74502218e-01f, -1.89426780e-01f, 1.19795594e-02f, -1.38921157e-01f, -2.79708058e-02f, -5.00192903e-02f, -7.98785165e-02f, -1.19089849e-01f, -1.22077227e-01f, -1.82493970e-01f,
  2.99211573e-02f, 1.76332235e-01f, 1.71509877e-01f, 1.04484171e-01f, 1.43556148e-01f, 1.47986393e-02f, 3.99324857e-02f, 1.01277404e-01f, 4.99632731e-02f, 1.31168276e-01f,
  4.42822389e-02f, 9.69236344e-02f, 8.12899247e-02f, -4.54277061e-02f, -3.98585573e-02f, 5.06841838e-02f, 6.83378354e-02f, 1.12217247e-01f, 1.24469481e-01f, 7.14187175e-02f,
  1.05427727e-01f, 1.10919565e-01f, 2.04642013e-01f, 4.35154475e-02f, 3.89743410e-03f, 8.72392431e-02f, 4.95755896e-02f, 4.21638340e-02f, 3.79924290e-02f, 8.31272453e-02f,
  -8.31555948e-02f, -4.22611237e-02f, -1.48608275e-02f, -2.02487811e-01f, -1.57541275e-01f, -1.21704221e-01f, -5.67400008e-02f, -1.13893941e-01f, -1.98331714e-01f, -1.97178692e-01f,
  -1.71171784e-01f, 1.97991431e-02f, -9.88287106e-03f, 5.49739189e-02f, -7.69569678e-03f, -8.26466233e-02f, -1.41952842e-01f, -8.57395232e-02f, -1.31718904e-01f, -1.10018879e-01f,
  -7.89098814e-02f, -6.71669394e-02f, 1.76013540e-02f, -1.18344547e-02f, -7.20292032e-02f, -4.91367355e-02f, 3.13579999e-02f, -2.55631395e-02f, -3.00249103e-02f, 3.54850031e-02f,
  4.30994391e-01f, -1.23752244e-02f, 1.42382443e-01f, 3.03162336e-01f, 2.34507143e-01f, 2.65095800e-01f, 3.49950820e-01f, 2.40713939e-01f, 2.03961462e-01f, 1.94663286e-01f,
  -1.49584264e-01f, -2.51235813e-01f, -1.93309933e-01f, -1.05758555e-01f, 1.04090333e-01f, 1.17659368e-01f, 1.72204643e-01f, 4.96799983e-02f, 1.38073817e-01f, 2.15968505e-01f,
  1.09674565e-01f, 3.14152837e-02f, -1.71964883e-03f, 3.51900905e-02f, 7.04826042e-02f, -8.14516470e-03f, -5.24755791e-02f, 6.50739949e-03f, -4.39040177e-03f, -2.16703117e-02f,
  -9.02689770e-02f, 8.24933350e-02f, -8.91228952e-03f, -6.03973381e-02f, -1.42194211e-01f, -3.25555094e-02f, 3.61453258e-02f, -7.11442903e-02f, -6.59704134e-02f, -2.06995029e-02f,
  -3.33319232e-02f, -7.56359324e-02f, 7.14837387e-02f, 3.54306698e-02f, 4.99263406e-02f, 1.28700733e-02f, 5.19979782e-02f, 4.89611253e-02f, 4.02847640e-02f, 5.04724681e-02f,
  2.11759079e-02f, 4.19484340e-02f, 1.16343729e-01f, -6.84574544e-02f, -4.50997390e-02f, 1.16697093e-02f, -7.10855275e-02f, -1.07057169e-02f, -3.14851329e-02f, 8.79288167e-02f,
  8.42056572e-02f, -4.91978377e-02f, -1.16512045e-01f, -3.92188355e-02f, -1.05107695e-01f, -8.28686059e-02f, -1.38705492e-01f, -7.75379092e-02f, 6.40698150e-03f, -6.04974851e-02f,
  -1.06240422e-01f, -4.46263663e-02f, -2.09220089e-02f, 7.07528964e-02f, -8.96926895e-02f, 1.04446925e-01f, 1.53049501e-02f, -6.45717829e-02f, -1.09547190e-01f, -7.08409026e-02f,
  3.96377407e-02f, 3.32679774e-05f, -6.47453815e-02f, 5.21982089e-02f, -3.08319721e-02f, 1.00638390e-01f, -5.08742221e-03f, -5.34621030e-02f, 5.23660565e-03f, -1.57600060e-01f,
  3.48806940e-02f, -1.15381882e-01f, -1.60429962e-02f, 2.88407113e-02f, -1.09521300e-01f, -1.42247930e-01f, -2.36539729e-02f, -2.11511999e-02f, -7.25001097e-02f, -4.36208174e-02f,
  2.83526592e-02f, -1.06910160e-02f, -2.17207596e-02f, -9.29249525e-02f, 6.98111579e-02f, 4.59664986e-02f, -1.76724941e-02f, 2.23223176e-02f, 4.92580645e-02f, 4.16943468e-02f,
  9.23960358e-02f, 2.24201024e-01f, 1.15517266e-01f, 5.55765741e-02f, -1.65310856e-02f, 6.98604882e-02f, -3.92107181e-02f, 5.90148196e-02f, 4.05358747e-02f, 9.69563723e-02f,
  -6.15118369e-02f, 4.30378854e-01f, -2.40036920e-01f, 2.67881546e-02f, 9.87112671e-02f, 3.64298038e-02f, 1.53963760e-01f, 9.31018312e-03f, -5.71221970e-02f, 1.30432725e-01f,
  2.75211543e-01f, 7.59888217e-02f, -6.47912994e-02f, -6.73822910e-02f, -2.21027657e-01f, 4.26295660e-02f, -2.33589374e-02f, -3.77063096e-01f, -3.92678142e-01f, 5.52068278e-02f,
  5.94403744e-02f, 7.55004352e-03f, -1.49517253e-01f, -5.14399745e-02f, 1.23323165e-01f, -2.26288289e-02f, 4.02644165e-02f, 7.30940327e-02f, 3.21666300e-02f, 8.50709453e-02f,
  1.24610022e-01f, 1.27461150e-01f, -1.03580363e-01f, -4.32080415e-04f, 1.23863459e-01f, -5.02722189e-02f, -1.26262933e-01f, -1.39706552e-01f, -1.81592777e-02f, 4.83307131e-02f,
  1.31982446e-01f, 2.45701410e-02f, 3.30723040e-02f, -1.01019204e-01f, 3.36401574e-02f, -5.66915236e-02f, -9.47165862e-02f, -8.01506191e-02f, -8.45642015e-02f, -1.03861699e-02f,
  2.53655128e-02f, 1.56260774e-01f, 1.06758848e-01f, -6.84430823e-02f, -7.79526532e-02f, -1.31583869e-01f, -1.03339814e-02f, -2.89112441e-02f, 1.13427581e-03f, 7.74888024e-02f,
  -8.14957470e-02f, 1.28345499e-02f, -2.61792745e-02f, -1.53509406e-02f, -1.11535437e-01f, -5.37448004e-02f, 2.54396424e-02f, -3.96762416e-02f, -2.29819063e-02f, -6.24440089e-02f,
  -7.89738148e-02f, -7.92225972e-02f, -9.48214829e-02f, -2.15581767e-02f, -9.37719923e-03f, -1.40637541e-02f, -2.04261132e-02f, 5.73268682e-02f, -2.34051012e-02f, 8.12423900e-02f,
  -1.04657657e-01f, 3.67657766e-02f, -8.37024581e-03f, -2.71356050e-02f, 1.17703783e-03f, -7.18176290e-02f, -4.58673276e-02f, -1.33614773e-02f, -9.22262296e-02f, -9.68023762e-03f,
  -1.19656876e-01f, -7.01551363e-02f, -9.17281806e-02f, -7.00234175e-02f, 7.59465760e-03f, -2.14306116e-02f, -7.45583326e-03f, 4.32459787e-02f, -1.35820266e-02f, -1.24613196e-02f,
  5.90469651e-02f, 7.25331083e-02f, -5.96659034e-02f, -1.30310655e-01f, 3.42725851e-02f, -1.71003684e-01f, 1.81665514e-02f, 3.21353860e-02f, 3.04277595e-02f, 9.82431769e-02f,
  9.27049387e-03f, -5.88669889e-02f, -1.00708470e-01f, -1.76859070e-02f, 3.29749137e-02f, -9.14529115e-02f, -1.11505143e-01f, 1.78996772e-02f, -2.19071046e-01f, -2.01278508e-01f,
  2.03783423e-01f, -7.74686337e-02f, 1.48469940e-01f, -9.70558003e-02f, 9.32515860e-02f, 2.51435220e-01f, 4.04371142e-01f, 7.59832114e-02f, -1.87873438e-01f, -1.61100794e-02f,
  1.50132567e-01f, -1.71328753e-01f, 6.62756199e-03f, -1.17059192e-02f, 3.76583412e-02f, 1.25849620e-01f, 4.62583527e-02f, -4.31205407e-02f, -8.55846033e-02f, -1.78592205e-01f,
  -1.88111335e-01f, -1.38457224e-01f, -7.23753348e-02f, -1.99460998e-01f, -1.49316370e-01f, -6.35766089e-02f, 2.58234758e-02f, -8.30856785e-02f, 4.25991677e-02f, -1.92081273e-01f,
  2.93223977e-01f, 1.78987518e-01f, -6.53084591e-02f, -5.94171844e-02f, 1.26352217e-02f, -2.88490914e-02f, -6.87532350e-02f, -6.33734884e-03f, -2.92506218e-02f, -9.76911839e-03f,
  2.58305166e-02f, 2.53413059e-02f, -4.75729369e-02f, 1.26057779e-02f, 8.07825662e-03f, -8.06304514e-02f, 4.08928804e-02f, -1.37956431e-02f, 5.23248054e-02f, 9.52695161e-02f,
  -1.03736728e-01f, 2.75856741e-02f, 1.62060037e-01f, 1.03356913e-01f, 1.31257519e-01f, 1.49440710e-02f, 5.73006943e-02f, -5.39963730e-02f, 1.64326280e-01f, -6.50953948e-02f,
  -1.91849917e-02f, 4.49162573e-02f, 3.75415236e-02f, -6.58671632e-02f, -1.07809119e-01f, 1.67001523e-02f, 6.87006414e-02f, 4.52414975e-02f, -7.46220946e-02f, -7.32023716e-02f,
  2.17745844e-02f, -5.01919203e-02f, -1.09330157e-03f, -4.67735007e-02f, -1.01276664e-02f, 3.69208045e-02f, 1.95121497e-03f, -2.94184834e-02f, 8.32010992e-03f, 1.34285484e-02f,
  1.63810346e-02f, 3.85216214e-02f, -2.46583531e-03f, -1.05437204e-01f, -9.62265357e-02f, -1.87542941e-02f, -7.56909996e-02f, 5.79646118e-02f, 6.40909001e-02f, -2.96043828e-02f,
  -5.10191470e-02f, 1.34959430e-01f, 5.28861061e-02f, -9.11263973e-02f, -2.90158903e-04f, 6.92688301e-02f, 2.08665803e-02f, 2.91840732e-02f, 5.84348105e-03f, -4.67865504e-02f,
  2.54907627e-02f, 8.28913525e-02f, 3.80308703e-02f, 3.70459259e-02f, 9.52439662e-03f, -4.35588555e-03f, -2.09388323e-02f, -4.05752659e-02f, 2.20954493e-02f, 2.40139011e-02f,
  -1.33190677e-01f, 1.29699454e-01f, 2.72982597e-01f, 1.45565003e-01f, 8.36092010e-02f, 6.48684949e-02f, 1.69025168e-01f, 9.96974707e-02f, 1.33961603e-01f, 2.44623512e-01f,
  -1.74831316e-01f, -1.73796505e-01f, -2.95521289e-01f, 1.11063607e-02f, 7.68073723e-02f, -4.40673064e-03f, -3.00464034e-01f, -9.59261209e-02f, 1.19274035e-01f, -1.61239251e-01f,
  -1.89212691e-02f, 2.44493455e-01f, 1.51165515e-01f, 1.94500998e-01f, -4.76120301e-02f, -1.42878458e-01f, -1.78748909e-02f, 1.54939182e-02f, 9.78406221e-02f, 1.61937013e-01f,
  2.02813730e-01f, 3.76860909e-02f, -2.08644643e-02f, 1.04129583e-01f, -4.70219664e-02f, 1.05420999e-01f, -1.16665177e-01f, 4.61437739e-03f, 3.26822512e-02f, -1.03519786e-04f,
  -2.14762196e-01f, -9.76919234e-02f, 8.99175256e-02f, 1.48320347e-01f, -2.60313284e-02f, -5.43001853e-02f, 2.17190711e-03f, -5.68903871e-02f, 5.93466498e-02f, -4.19733003e-02f,
  -3.42393480e-02f, 6.53404668e-02f, -3.53253148e-02f, 4.00419012e-02f, -1.79166421e-01f, -7.51331747e-02f, 1.26403673e-02f, 2.09170487e-02f, -3.54850129e-03f, -3.79628278e-02f,
  2.14891225e-01f, 4.63761799e-02f, -1.40388831e-01f, 2.74382364e-02f, -7.64701664e-02f, 1.49877192e-02f, -9.89481509e-02f, -1.31155699e-01f, -1.68663099e-01f, -1.51177421e-01f,
  -1.10615306e-01f, 4.32226956e-02f, -6.27078637e-02f, -1.13691926e-01f, -5.78561462e-02f, 5.43085337e-02f, 8.36368576e-02f, 3.71206440e-02f, 2.12040842e-02f, -5.64476475e-02f,
  2.80751307e-02f, -3.85200754e-02f, -3.63835730e-02f, -7.58158192e-02f, -2.86035836e-02f, 1.88183226e-02f, -1.15829803e-01f, -7.60811567e-02f, 1.20915929e-02f, -7.91389495e-02f,
  3.33426967e-02f, -6.04631864e-02f, 5.38301282e-02f, -5.94074130e-02f, -1.95429977e-02f, -9.31726247e-02f, -1.13963462e-01f, -4.38720472e-02f, -8.98851976e-02f, -1.06098346e-01f,
  -2.13929918e-02f, 1.33589804e-01f, 1.11444429e-01f, 5.25004677e-02f, -1.00892894e-02f, 8.23138282e-02f, 9.05866921e-02f, 1.00543007e-01f, -6.46470562e-02f, 2.80196480e-02f,
  -1.18094012e-02f, -1.13726899e-01f, -2.52746642e-02f, -3.75639126e-02f, 2.74997018e-03f, -1.67483538e-02f, 7.05390498e-02f, 1.48867443e-01f, 6.39964789e-02f, 2.39421558e-02f,
  2.53575407e-02f, 9.17190462e-02f, -9.34778899e-03f, 1.03344657e-01f, 1.94096267e-02f, 2.27334555e-02f, -7.51180053e-02f, -9.13432464e-02f, 1.34765438e-03f, -1.88888654e-01f,
  9.33439672e-01f, -2.06130996e-01f, -3.16340216e-02f, -2.06813179e-02f, -1.87802225e-01f, -1.11628421e-01f, -1.84024915e-01f, -1.05097905e-01f, -1.17111631e-01f, -9.65611860e-02f,
  1.55820876e-01f, 1.65493965e-01f, 1.69458881e-01f, 7.97692910e-02f, 2.94633687e-01f, -1.35742605e-01f, -8.69769379e-02f, 2.94439048e-01f, 2.12030753e-01f, 8.83331373e-02f,
  -1.55740768e-01f, 1.07937090e-01f, 3.38463426e-01f, 3.39474641e-02f, -2.94649988e-01f, -9.31657478e-03f, -1.56110451e-01f, -2.79159099e-02f, -1.50952414e-01f, -3.06406468e-01f,
  1.02564380e-01f, 7.37867653e-02f, -3.07413284e-02f, 3.96989696e-02f, -1.93892747e-01f, -5.82217053e-02f, -4.49828990e-02f, -4.82430793e-02f, -1.05564274e-01f, -6.32337928e-02f,
  -4.77824956e-02f, -9.13618878e-02f, -4.22497243e-02f, -1.74827855e-02f, -6.76982179e-02f, -5.91156147e-02f, -1.19839944e-02f, 6.57163635e-02f, 2.66629867e-02f, -2.47157607e-02f,
  -8.12790617e-02f, 3.07433102e-02f, 5.49160223e-03f, -1.07643895e-01f, -3.59113008e-04f, -2.69176606e-02f, -8.96984413e-02f, -1.92437768e-01f, 6.62804320e-02f, -2.19014451e-01f,
  -1.19392343e-01f, -6.96468949e-02f, -4.99737598e-02f, 5.02501018e-02f, 5.49862580e-03f, -4.70318682e-02f, 8.51981863e-02f, 6.90616667e-02f, 5.04334494e-02f, -4.03413810e-02f,
  1.59359090e-02f, -9.40458700e-02f, -1.63429342e-02f, -4.98367846e-02f, -7.21932761e-03f, -7.62336627e-02f, 9.36925188e-02f, -3.07455994e-02f, -9.78573337e-02f, -6.37658238e-02f,
  5.72490022e-02f, -4.54749428e-02f, -2.38941759e-02f, -2.25866940e-02f, -3.28448303e-02f, 5.59352664e-03f, -4.08042111e-02f, 6.50587957e-04f, -4.03914154e-02f, -1.11898994e-02f,
  6.04587197e-02f, 1.33601740e-01f, -1.62535682e-02f, -1.09251685e-01f, -2.62371618e-02f, -4.14365008e-02f, -1.73841603e-02f, -5.44520766e-02f, 3.00717894e-02f, -5.32787070e-02f,
  -8.42869878e-02f, 2.63204258e-02f, 4.64355536e-02f, -7.56894648e-02f, -3.66038121e-02f, -2.71092057e-02f, -1.57910713e-03f, 1.92388929e-02f, -4.86584529e-02f, -1.10678628e-01f,
  -7.20022470e-02f, -8.73441696e-02f, 4.15786430e-02f, -3.27574532e-03f, -9.31573212e-02f, 2.26134315e-01f, -9.72399488e-02f, -5.07415123e-02f, 1.90812081e-01f, -7.94382617e-02f,
  -6.05165325e-02f, 1.74383596e-01f, -1.32819816e-01f, -1.47497833e-01f, 4.00838368e-02f, 9.09020454e-02f, 3.83468360e-01f, 1.74268648e-01f, 1.00735836e-01f, 1.92939267e-01f,
  1.02830827e-01f, 1.61573112e-01f, 7.06933439e-02f, 1.60589144e-01f, 8.17156211e-02f, -3.61086801e-02f, -1.63529083e-01f, -2.36617655e-01f, -6.73928857e-02f, -5.32314181e-04f,
  6.85880613e-03f, -1.22091517e-01f, -2.99725562e-01f, -3.77331562e-02f, -1.83188990e-01f, 8.13702960e-03f, -1.67642057e-01f, -1.85034901e-01f, 9.53816175e-02f, -1.63188055e-01f,
  5.71848042e-02f, -3.04468442e-03f, 1.79539040e-01f, 9.30160955e-02f, 2.73450818e-02f, -1.46441329e-02f, 6.01951741e-02f, -6.71065524e-02f, -5.77927474e-03f, 4.26508151e-02f,
  5.79605959e-02f, -5.13714626e-02f, -1.65116265e-02f, 3.35908532e-02f, 2.04422921e-02f, 7.22173974e-02f, 1.24114640e-02f, -1.31661460e-01f, -1.12277046e-02f, 9.95397344e-02f,
  1.47946432e-01f, -2.50555463e-02f, -1.39421178e-03f, 2.13163793e-02f, 2.83642113e-03f, -9.53496620e-02f, 6.53847530e-02f, 2.27472372e-02f, 9.44053903e-02f, 1.08111016e-01f,
  -5.95585555e-02f, -8.93899128e-02f, -7.82401562e-02f, 9.90721658e-02f, -7.40887970e-02f, 9.13749561e-02f, 1.73716352e-03f, -6.58368990e-02f, 1.19821496e-01f, 5.46210781e-02f,
  1.73510253e-01f, 7.70084560e-02f, 3.46160159e-02f, 5.21059632e-02f, -7.18613118e-02f, -3.02253701e-02f, -2.64402032e-02f, 1.05855311e-03f, -6.46351576e-02f, -3.91492844e-02f,
  8.66911262e-02f, -2.79075857e-02f, -7.56160170e-02f, -7.54833966e-02f, -6.37718439e-02f, -3.34443897e-02f, -3.04174740e-02f, -3.71353813e-02f, -2.74261665e-02f, -9.66393203e-03f,
  3.57813984e-01f, 5.28216809e-02f, 1.66775301e-01f, 1.30518273e-01f, -4.43383213e-03f, 3.29498909e-02f, 1.30812928e-01f, -8.68882518e-03f, 9.44397971e-02f, 2.88401470e-02f,
  4.49002795e-02f, 6.32727817e-02f, 2.93669440e-02f, 1.26998737e-01f, 2.04613984e-01f, 6.48182333e-02f, 3.54499891e-02f, 1.08129986e-01f, 8.95778984e-02f, 9.87642705e-02f,
  1.87548205e-01f, 1.64268121e-01f, 1.38625905e-01f, 2.53126860e-01f, 6.04138821e-02f, 2.22358301e-01f, 1.72766551e-01f, 2.45298490e-01f, 3.00713480e-01f, 3.45904499e-01f,
  2.85557121e-01f, 1.30075455e-01f, 2.88348138e-01f, 2.37297058e-01f, 4.81238626e-02f, 4.43479009e-02f, 2.46637896e-01f, 2.22482339e-01f, 9.81689841e-02f, 1.88207731e-01f,
  6.67431056e-02f, 5.44627523e-03f, 6.53235614e-03f, 8.69290978e-02f, 2.56809741e-01f, 2.61656284e-01f, 2.72333145e-01f, 2.65397668e-01f, 2.27987558e-01f, 1.34325013e-01f,
  -1.53862331e-02f, 1.55400351e-01f, 2.13613868e-01f, 1.16277494e-01f, 1.33602858e-01f, -3.06217056e-02f, 1.67266503e-01f, 2.27889735e-02f, 1.77040830e-01f, 1.82935208e-01f,
  4.17857878e-02f, 2.20792100e-01f, 9.09851044e-02f, 1.54662833e-01f, 1.05386134e-02f, -2.58923904e-03f, 1.18614137e-01f, 8.60336646e-02f, 8.69028494e-02f, 5.40003367e-02f,
  -2.00107861e-02f, 6.76558390e-02f, -3.61198783e-02f, 6.26225993e-02f, 1.55563995e-01f, 4.63788919e-02f, 1.29375860e-01f, 2.34893449e-02f, 1.41066447e-01f, 1.56940892e-02f,
  4.23282497e-02f, 4.21062745e-02f, 1.28623813e-01f, 7.12704211e-02f, 1.01585872e-02f, 8.10628980e-02f, 1.61516786e-01f, 1.06685750e-01f, 9.79772955e-02f, 2.45157629e-01f,
  -5.29368222e-02f, -1.77021235e-01f, -2.74114497e-02f, 5.46109937e-02f, 1.63654964e-02f, -9.69486013e-02f, 3.85549013e-03f, 7.44779110e-02f, -8.63890257e-03f, -5.42064346e-02f,
  -5.27998023e-02f, -7.43913502e-02f, 1.08514270e-02f, -1.78108609e-03f, -6.42611412e-03f, 4.20488678e-02f, 3.40913199e-02f, -3.67507674e-02f, 4.87188436e-02f, -7.83589110e-02f,
  2.88028363e-03f, -7.96982050e-02f, -1.43065229e-01f, -3.50880250e-02f, 2.41299178e-02f, 7.57915974e-02f, 3.08487881e-02f, 6.06197119e-02f, -9.47034210e-02f, 8.07186812e-02f,
  -8.77067298e-02f, -2.23576296e-02f, 1.67132273e-01f, 1.14786796e-01f, 4.75583263e-02f, 3.89203592e-03f, -1.44528262e-02f, 1.64363421e-02f, 1.13446228e-01f, 1.61869735e-01f,
  1.25981614e-01f, 3.15388441e-02f, 2.61660162e-02f, 1.33565128e-01f, 1.61232769e-01f, 1.24635845e-01f, 1.68976858e-01f, 2.06490681e-01f, 1.89274624e-01f, 1.96425542e-02f,
  9.58183780e-03f, 1.32110238e-01f, 3.14889997e-02f, 1.33890539e-01f, -2.00409945e-02f, 2.12620080e-01f, 1.16192773e-01f, 8.99028331e-02f, 1.94705427e-01f, 2.09942833e-01f,
  3.47250402e-01f, 1.59363106e-01f, 9.40777063e-02f, -2.43234113e-01f, -2.87849993e-01f, -1.18785903e-01f, 2.92897910e-01f, 1.82902068e-02f, -1.19920224e-01f, -2.22746972e-02f,
  -2.36138672e-01f, -3.74517143e-01f, -1.66298673e-01f, -8.81464705e-02f, 1.82040498e-01f, 2.04332933e-01f, -3.87603114e-03f, 1.81926444e-01f, -2.59815566e-02f, -5.58531377e-04f,
  -1.41515449e-01f, -1.23186214e-02f, 1.25905573e-01f, 7.54460273e-03f, -7.89847076e-02f, -1.04370601e-01f, -3.67536545e-02f, 4.34624851e-02f, 3.35084535e-02f, -8.43139887e-02f,
  -1.80194154e-01f, 1.09944157e-01f, -1.16378717e-01f, -1.13361686e-01f, -1.41166598e-01f, 1.27659023e-01f, -6.38731197e-02f, -7.99665004e-02f, -1.20608382e-01f, -1.20152339e-01f,
  -2.37516850e-01f, -1.03173861e-02f, -9.11847204e-02f, 1.87339801e-02f, -7.49103427e-02f, 9.52286869e-02f, 1.09992586e-01f, 9.96018499e-02f, 9.23997238e-02f, -2.97597349e-02f,
  -1.70513958e-01f, -7.74921626e-02f, 1.14942864e-01f, 1.26624376e-01f, -1.67052001e-02f, 4.69284318e-02f, 9.14759189e-02f, -3.21214460e-02f, 1.92176253e-01f, 4.13282625e-02f,
  -7.29923099e-02f, -5.67277595e-02f, 3.35035175e-02f, 1.36315031e-03f, 4.77253608e-02f, -1.11069798e-01f, -8.40473473e-02f, -6.62546279e-03f, 2.94934269e-02f, 1.08643621e-01f,
  -1.22476801e-01f, 6.27425388e-02f, -6.58834055e-02f, 2.90682483e-02f, 2.25912081e-03f, 1.96179729e-02f, -6.59442320e-02f, 9.26540941e-02f, 2.94497889e-02f, -1.77548807e-02f,
  -5.75613566e-02f, 5.42752184e-02f, 1.55785689e-02f, -5.13650626e-02f, 1.07754484e-01f, -1.23779224e-02f, 1.10710394e-02f, 2.78513972e-02f, 9.14012268e-02f, -1.19038830e-02f,
  -2.07856193e-01f, -6.06043600e-02f, -6.39577433e-02f, 5.86485304e-02f, -8.37152451e-02f, -4.34117131e-02f, 2.27994025e-02f, 9.95858759e-03f, 2.31741071e-02f, 2.12362632e-02f,
  -2.63896864e-02f, -2.41804011e-02f, -1.33383553e-02f, -5.11000119e-02f, -1.47143221e-02f, -3.09237335e-02f, -1.52850552e-02f, -6.31833002e-02f, -1.14532765e-02f, -2.94111366e-03f,
  1.08528137e-01f, 1.99998811e-01f, 1.47453498e-03f, -1.37332082e-02f, -7.40951747e-02f, 5.15016448e-03f, 7.92310834e-02f, 2.64899805e-02f, 1.50901422e-01f, 3.54552120e-01f,
  -4.44163829e-01f, -1.00950368e-01f, -1.33281201e-01f, -2.64019042e-01f, -2.97428906e-01f, -5.87853938e-02f, -1.91244669e-02f, 1.33243829e-01f, -2.12266743e-02f, -3.17894407e-02f,
  -1.56033011e-02f, -4.04311158e-02f, -1.31718330e-02f, -1.51003711e-02f, 1.45533383e-01f, 1.08000122e-01f, 3.48819373e-03f, 5.11819832e-02f, -1.58738256e-01f, -1.99521437e-01f,
  -2.14596286e-01f, -3.47677618e-01f, -9.97963026e-02f, 8.74388777e-03f, -7.11460933e-02f, -1.30090073e-01f, -8.34147353e-03f, -3.62240933e-02f, -3.81301455e-02f, -9.48435515e-02f,
  -7.16481879e-02f, -9.84147713e-02f, 1.28012478e-01f, 1.23048842e-01f, -3.41917016e-02f, 1.20729618e-01f, 5.81626184e-02f, 1.26624867e-01f, 3.89736444e-02f, 1.38488621e-01f,
  -5.08210957e-02f, -3.07421610e-02f, 1.88890491e-02f, -8.04543421e-02f, -7.88814016e-03f, -2.35625487e-02f, 1.51001826e-01f, 2.99967732e-02f, -1.20709427e-02f, 8.83284956e-02f,
  -5.46830660e-03f, -1.04033001e-01f, 3.69776711e-02f, 1.29439905e-01f, 1.02848150e-01f, -1.02867559e-02f, 7.61572123e-02f, 1.21111438e-01f, 1.67209461e-01f, 7.80707300e-02f,
  1.51601033e-02f, -3.59706543e-02f, 7.08403531e-03f, 8.51110928e-03f, -2.40640417e-02f, 1.02029704e-01f, -5.29285632e-02f, -4.01220694e-02f, 1.95473973e-02f, -6.71975762e-02f,
  1.95506886e-02f, -1.83965471e-02f, 5.17735817e-02f, -1.88715681e-02f, 9.47424546e-02f, -5.73358685e-02f, 2.09345738e-03f, -3.95148136e-02f, 8.86468813e-02f, 7.13173896e-02f,
  -3.86625640e-02f, -3.23331356e-02f, -6.47406429e-02f, 4.10471186e-02f, 3.08711585e-02f, 8.73357407e-04f, 3.17998119e-02f, 3.60347889e-02f, -7.15645775e-02f, 8.32262821e-03f,
  8.61651823e-03f, 1.18888371e-01f, 8.33077803e-02f, 6.01955131e-02f, -2.33140290e-02f, 1.88363746e-01f, 1.07143878e-03f, 1.69425175e-01f, -2.97628585e-02f, -8.32530186e-02f,
  -1.05926944e-02f, 7.71388188e-02f, -6.08833283e-02f, 1.08713798e-01f, -7.27932528e-02f, -2.54238211e-02f, 1.93859637e-02f, -1.86682884e-02f, 2.86373869e-02f, 1.03236707e-02f,
  1.09074377e-01f, 1.33607313e-01f, 1.05540201e-01f, 1.04597263e-01f, 3.97046143e-03f, -1.21639095e-01f, 1.74878202e-02f, 1.10017948e-01f, 7.38600716e-02f, 1.31634071e-01f,
  1.38573095e-01f, -1.50613204e-01f, -2.61262596e-01f, -4.03125063e-02f, -1.61315277e-01f, -4.70983014e-02f, -2.12602690e-01f, 4.19052653e-02f, 8.26937258e-02f, -1.42387465e-01f,
  7.79512301e-02f, 3.13181043e-01f, 2.31642753e-01f, 2.84820616e-01f, 1.78604588e-01f, -2.05924496e-01f, -3.46407861e-01f, -3.62416729e-02f, 2.59810984e-01f, 2.17901260e-01f,
  1.05321489e-01f, 1.75982956e-02f, 8.22853744e-02f, 1.29648969e-01f, -1.74493462e-01f, 1.26791105e-01f, -2.95239627e-01f, -1.52018771e-01f, 9.91588086e-02f, -4.13351119e-01f,
  -6.15807436e-02f, -7.46151879e-02f, 9.59585533e-02f, 2.03564167e-01f, -6.65841773e-02f, -2.71460079e-02f, -7.10723475e-02f, -9.36001018e-02f, -7.16152135e-03f, -8.32817331e-02f,
  -3.03454641e-02f, -1.14794798e-01f, 7.01471195e-02f, -1.36517584e-01f, -9.40213725e-02f, -4.05013412e-02f, -1.99662998e-01f, 4.99201603e-02f, -5.22010103e-02f, 2.32967455e-02f,
  3.29816416e-02f, -3.81011739e-02f, -3.21088880e-02f, 1.57495514e-02f, 9.15994868e-02f, 3.89247611e-02f, -4.96731838e-03f, -4.41397317e-02f, 4.50756811e-02f, -2.43075803e-01f,
  9.77835953e-02f, -8.17491189e-02f, -4.60385270e-02f, -8.02102387e-02f, 2.62011103e-02f, -8.34648386e-02f, -1.66431628e-02f, -8.63715485e-02f, 7.67766079e-03f, 3.01088206e-02f,
  1.97047070e-02f, -4.36579250e-02f, 2.17332467e-02f, 4.82281968e-02f, 1.26366904e-02f, -9.21994373e-02f, -3.90655138e-02f, -3.33715081e-02f, 1.32134079e-03f, -4.22276892e-02f,
  1.91687979e-02f, -1.66524865e-03f, -1.45667493e-02f, 5.89308934e-03f, -5.43132164e-02f, 3.07290573e-02f, -1.86040029e-02f, -2.44686306e-02f, -3.65694650e-02f, 5.02431318e-02f,
  1.32187888e-01f, 2.17650890e-01f, -2.45911106e-02f, 1.37561098e-01f, 2.61739753e-02f, 8.01571310e-02f, -8.97975452e-03f, 4.40810956e-02f, 6.65272847e-02f, -3.01893731e-03f,
  9.06134993e-02f, 7.51308128e-02f, -1.91643853e-02f, 2.26007234e-02f, 8.62675533e-02f, -3.82010601e-02f, 2.89665535e-02f, -9.84427612e-03f, 9.74425748e-02f, -7.08386227e-02f,
  -2.15555560e-02f, 5.57393171e-02f, 1.10897534e-01f, -4.22698185e-02f, 1.96516365e-02f, 1.79742739e-01f, -6.18101507e-02f, 5.38536757e-02f, 6.36543408e-02f, -7.34041706e-02f,
  1.27700970e-01f, 1.05176225e-01f, 2.79815704e-01f, 5.59292287e-02f, 1.29826441e-01f, 1.89005374e-03f, 1.45150080e-01f, -2.43948959e-02f, -1.17921025e-01f, 4.63923626e-03f,
  1.28029525e-01f, -2.06786782e-01f, -2.29081765e-01f, -1.23382315e-01f, -6.06052242e-02f, -3.38171236e-02f, 1.29120156e-01f, 1.60773098e-02f, -7.68451020e-02f, 1.92977879e-02f,
  -1.68408640e-02f, 4.92885187e-02f, 6.88413456e-02f, 1.94502771e-02f, 4.95049320e-02f, -2.13189453e-01f, 1.83126777e-01f, 1.61244735e-01f, 1.44618317e-01f, -6.84051728e-03f,
  -1.92912012e-01f, 3.88121665e-01f, -9.64953974e-02f, -2.29126941e-02f, -1.78155880e-02f, -7.77613223e-02f, -8.86915252e-02f, -2.40212753e-02f, -1.11355288e-02f, -2.24460438e-02f,
  1.21632539e-01f, -3.39191733e-03f, 4.15924983e-03f, 4.96426187e-02f, 5.19687776e-03f, 8.10073782e-03f, 4.43654396e-02f, -3.95427272e-02f, 6.94017112e-02f, 6.50095940e-02f,
  -3.26391472e-03f, 1.43922269e-01f, 9.50948149e-02f, -7.57442275e-03f, -1.02466000e-02f, -4.92606610e-02f, -2.35334598e-03f, 1.20751373e-01f, -3.84082235e-02f, -1.31509811e-01f,
  -1.62123665e-01f, -1.77627802e-02f, 5.45331985e-02f, 3.02256681e-02f, -2.81632170e-02f, -4.21153717e-02f, -4.09738198e-02f, -4.97957692e-02f, 9.29720234e-03f, -5.69900731e-03f,
  7.10201683e-03f, -1.34534175e-02f, -3.77301052e-02f, 1.19815566e-01f, -7.35734077e-03f, -1.01605114e-02f, -2.79793516e-02f, 1.79653186e-02f, 1.37339115e-01f, 1.49110239e-02f,
  -8.96333978e-02f, 8.18767175e-02f, 1.49379879e-01f, -9.33970436e-02f, 1.20447867e-01f, 1.96495857e-02f, 3.69879194e-02f, 2.84634512e-02f, 7.40040839e-02f, 7.77978674e-02f,
  -3.28894973e-01f, 2.05361381e-01f, -2.11542875e-01f, -1.57388210e-01f, -8.61206427e-02f, -3.20003629e-02f, 5.93432114e-02f, 4.69030477e-02f, 9.08989385e-02f, -2.14154739e-02f,
  -1.52137689e-02f, -6.20402582e-02f, -3.88359018e-02f, 8.75310600e-02f, -1.29220203e-01f, 6.29294217e-02f, -4.43619629e-03f, -9.26174074e-02f, -8.61783102e-02f, 1.55548742e-02f,
  -9.67974663e-02f, -6.64247274e-02f, -7.59977326e-02f, -1.62823319e-01f, -1.54395401e-01f, -3.32180381e-01f, -1.56337872e-01f, -1.72172397e-01f, -1.21552184e-01f, -3.10061842e-01f,
  -5.78226335e-02f, 3.81247640e-01f, 1.72961846e-01f, -2.92885751e-01f, -5.72651848e-02f, 2.42639154e-01f, 4.75070536e-01f, 3.37285176e-02f, -2.01060340e-01f, 3.65146957e-02f,
  3.58953536e-01f, 1.11342825e-01f, 9.89288464e-02f, 1.58892825e-01f, 1.68808222e-01f, -6.31782338e-02f, -6.78469911e-02f, -1.61293417e-01f, 1.12982489e-01f, 1.60440728e-01f,
  7.12136924e-02f, -1.05735801e-01f, -9.24982876e-02f, -9.72590595e-02f, -2.24812850e-01f, 2.10825689e-02f, -1.47998007e-02f, 4.82409485e-02f, 1.41082883e-01f, -1.81490555e-01f,
  1.98688075e-01f, -1.72438454e-02f, -1.84075043e-01f, -1.13695078e-01f, 2.86829621e-02f, 1.18255503e-01f, 1.04630105e-01f, 3.42950188e-02f, 2.29849126e-02f, 5.12832664e-02f,
  1.13423258e-01f, 4.36737239e-02f, 1.08610079e-01f, -3.06085870e-02f, 3.44295017e-02f, -9.43612307e-02f, -1.17378511e-01f, 5.41982567e-03f, -1.23913831e-03f, 1.67614937e-01f,
  7.60003552e-02f, 6.22184426e-02f, 1.49855867e-01f, 2.37158760e-02f, -1.93963032e-02f, -1.42963201e-01f, 2.30050720e-02f, -1.18733346e-01f, -2.08081733e-02f, 1.84619974e-04f,
  -1.45542964e-01f, -7.02700093e-02f, -6.05353303e-02f, 2.59013586e-02f, 8.97399895e-03f, 3.71579640e-02f, 3.76569992e-03f, -9.07435641e-02f, -3.07430644e-02f, -8.05199221e-02f,
  2.96178162e-02f, -8.56838822e-02f, 6.86746836e-02f, 4.36018184e-02f, -7.13374689e-02f, -1.00389007e-03f, 1.44586526e-03f, -3.81745175e-02f, -8.45453069e-02f, -1.24347851e-01f,
  -5.33942431e-02f, -2.47302558e-02f, 3.74065414e-02f, 1.69890493e-01f, 6.46615727e-03f, 2.27689426e-02f, -1.26463786e-01f, -3.23908380e-03f, -7.78270811e-02f, -3.76150757e-02f,
  1.16196953e-01f, 1.46614956e-02f, -6.47007152e-02f, -1.05529875e-01f, -1.70407251e-01f, 4.18494642e-02f, 6.57602549e-02f, -5.57345562e-02f, -9.89364386e-02f, 2.10902188e-02f,
  3.31179053e-02f, 6.18321523e-02f, 9.28165689e-02f, 5.11897616e-02f, -6.07416742e-02f, -7.76500255e-02f, 4.72621992e-02f, 3.33492346e-02f, 5.27069531e-02f, -1.80713888e-02f,
  -9.23699588e-02f, -7.92384446e-02f, -7.88165033e-02f, 8.43215659e-02f, -8.32864121e-02f, -6.18939213e-02f, -7.57382736e-02f, -5.08619286e-03f, 3.77871804e-02f, 3.27618308e-02f,
  -1.19506359e-01f, 3.27425674e-02f, -1.71226218e-01f, -1.88845769e-02f, -1.02371030e-01f, 1.64971143e-01f, 1.00782119e-01f, 6.61962926e-02f, -3.19032334e-02f, 3.39360572e-02f,
  3.34608667e-02f, 1.16967879e-01f, 9.31517109e-02f, 1.79032266e-01f, 4.72517982e-02f, -6.81619439e-03f, 2.29702815e-02f, -1.04879580e-01f, 1.31513551e-02f, 1.16293423e-01f,
  1.46349678e-02f, -9.10179839e-02f, -1.22536533e-01f, -5.17068955e-04f, -1.00934312e-01f, 1.23827204e-01f, 3.42715867e-02f, -8.54134485e-02f, 8.74054804e-02f, -2.51213640e-01f,
  -1.69574559e-01f, -2.45317355e-01f, -4.44492474e-02f, -4.66261022e-02f, -1.27851173e-01f, -1.10187493e-01f, -1.21026086e-02f, -1.02758750e-01f, -2.44597159e-02f, -1.41635746e-01f,
  -6.70307428e-02f, -6.36047451e-03f, -5.50063141e-02f, -1.24735758e-01f, -8.88498873e-02f, -7.26561025e-02f, -4.17619944e-03f, -6.82168454e-02f, 4.19398490e-03f, -9.52924117e-02f,
  1.49161406e-02f, -8.18960592e-02f, -1.13792963e-01f, 2.90383101e-02f, -1.32419929e-01f, -4.63410579e-02f, -1.24048926e-01f, -1.97547585e-01f, 5.19505925e-02f, -5.41671440e-02f,
  6.71109036e-02f, -5.11658341e-02f, -5.63114602e-03f, 3.35834697e-02f, -4.34519071e-03f, 1.07707048e-03f, 8.09605643e-02f, 8.01411197e-02f, 8.53190050e-02f, -5.63423410e-02f,
  7.37703368e-02f, -7.83488154e-03f, 1.34403616e-01f, -5.77086918e-02f, 5.64856976e-02f, 3.96085577e-03f, 1.09639429e-02f, 1.31921485e-01f, -6.45224517e-03f, 3.00677661e-02f,
  4.47194465e-02f, 2.73660403e-02f, 1.51457056e-01f, 5.64615764e-02f, -2.46401709e-02f, 3.60362157e-02f, 1.13678239e-01f, 1.18579924e-01f, -2.89878231e-02f, 8.37438181e-02f,
  1.52962431e-01f, 1.71677083e-01f, -3.55174541e-02f, 2.53280085e-02f, 3.20007056e-02f, 2.80278046e-02f, -3.64737287e-02f, 1.18349887e-01f, -6.78796172e-02f, -7.42871454e-03f,
  -5.74079975e-02f, 5.51150627e-02f, 4.99182492e-02f, -1.05734980e-02f, 4.32755612e-02f, 3.34312394e-02f, 9.94633213e-02f, 7.61357397e-02f, 2.46250331e-02f, -1.33528411e-02f,
  -1.06093276e-03f, 2.77083635e-01f, 1.04229465e-01f, 8.09501410e-02f, -7.24271908e-02f, 1.59134254e-01f, 8.79124850e-02f, 5.55337742e-02f, 2.02524185e-01f, 2.19142213e-01f,
  2.89214939e-01f, -2.70966887e-01f, -6.38943464e-02f, 1.30213097e-01f, 6.28343150e-02f, 1.77052692e-01f, 9.53343231e-03f, 9.61135253e-02f, -7.49781430e-02f, -1.51172072e-01f,
  -1.11175992e-01f, 1.19050015e-02f, -3.85492630e-02f, -1.23575762e-01f, -6.22045770e-02f, -2.42360421e-02f, -2.73904670e-02f, 1.44315809e-01f, 3.30451131e-01f, 6.79945126e-02f,
  -4.38451916e-02f, 2.43836660e-02f, 1.66543245e-01f, 9.03329924e-02f, -2.31027931e-01f, 4.54579443e-02f, -1.98396459e-01f, -9.81340185e-02f, 4.18840442e-03f, -3.36488038e-01f,
  -4.17245589e-02f, -1.80331245e-03f, 1.89048439e-01f, 8.74891281e-02f, 5.83455414e-02f, 9.80100706e-02f, 6.74168468e-02f, -1.86406430e-02f, -7.25559890e-03f, -6.12377524e-02f,
  -9.26207192e-03f, -4.75921035e-02f, 6.19166419e-02f, 6.74423575e-03f, 7.79966936e-02f, 2.11236868e-02f, -3.28386799e-02f, 8.14381391e-02f, -4.16362248e-02f, -7.53521249e-02f,
  -1.48509666e-01f, 4.05143015e-02f, 2.14254215e-01f, -5.82702048e-02f, 4.38638963e-02f, 1.43414006e-01f, 3.57914940e-02f, -4.98350449e-02f, 3.42058018e-02f, -7.39603788e-02f,
  1.13228016e-01f, 7.74730835e-03f, -9.49698463e-02f, 9.69340373e-03f, 6.09586313e-02f, -8.37414116e-02f, -9.37339757e-03f, -1.11705065e-01f, -3.22103240e-02f, -2.80141197e-02f,
  -1.45743452e-02f, 2.14599445e-02f, -8.18912610e-02f, -3.12010124e-02f, 5.77190251e-04f, -1.07206807e-01f, -4.25181612e-02f, -5.91182150e-02f, 3.62856500e-02f, -3.21018025e-02f,
  3.11644096e-02f, -6.74097314e-02f, 1.46286665e-02f, 1.46176724e-03f, -5.13960188e-03f, 1.60586070e-02f, -3.81881595e-02f, -1.07592726e-02f, -8.47526714e-02f, 5.51948324e-02f,
  1.10097401e-01f, -1.55174345e-01f, -7.39662796e-02f, 2.41677985e-02f, 1.84474394e-01f, 4.96214181e-02f, -1.35924919e-02f, 6.32878914e-02f, -5.44691365e-03f, -6.01631440e-02f,
  1.61784329e-02f, 5.35599254e-02f, -1.30920827e-01f, 4.96926568e-02f, 9.77752581e-02f, 6.91124052e-02f, -1.55133149e-02f, 7.43782520e-02f, 6.43486157e-03f, -5.33094853e-02f,
  -2.31189337e-02f, 3.75209861e-02f, 1.88306615e-01f, 2.57485285e-02f, 1.02830119e-01f, 1.18301585e-01f, 4.79459390e-02f, 1.36717081e-01f, 9.18702856e-02f, 2.12630749e-01f,
  -2.29573235e-01f, -4.14887862e-03f, 2.21046522e-01f, 3.30233201e-02f, -2.55555622e-02f, -3.22550058e-01f, -3.95336896e-01f, -9.34157297e-02f, 1.56970266e-02f, 7.67305791e-02f,
  -8.38623568e-02f, -1.10840477e-01f, -1.19076490e-01f, -1.02943622e-01f, -1.50186419e-01f, 4.96987738e-02f, 3.96008305e-02f, -9.06924158e-02f, -1.53301165e-01f, -9.71340686e-02f,
  -1.35440938e-02f, 6.98667765e-02f, 9.34772380e-03f, 7.33611593e-03f, 2.84118146e-01f, -3.23270336e-02f, 2.04794019e-01f, 1.60461038e-01f, -2.76590418e-02f, 4.14765000e-01f,
  2.37245932e-01f, 1.00599833e-01f, 7.28536248e-02f, -3.31493430e-02f, 1.40999287e-01f, -7.84222260e-02f, 1.70424599e-02f, 1.28818080e-01f, -2.94989310e-02f, 1.41431347e-01f,
  1.01184152e-01f, 5.75174652e-02f, 9.83662829e-02f, 1.20865606e-01f, 6.46658912e-02f, 1.09898625e-02f, -5.94209228e-03f, 2.28902437e-02f, 1.62853852e-01f, 4.68225330e-02f,
  5.07322550e-02f, -6.21502772e-02f, -5.22990525e-03f, -1.23100812e-02f, -5.88334585e-03f, 2.93088201e-02f, 1.16339527e-01f, 1.75960790e-02f, 1.33621162e-02f, 4.66842055e-02f,
  -5.10117114e-02f, 1.86717678e-02f, 4.69514020e-02f, -6.69286102e-02f, -9.61170793e-02f, -3.27542089e-02f, -3.34113985e-02f, -8.45732465e-02f, -1.52004227e-01f, -5.29743135e-02f,
  -6.93534836e-02f, 5.30737452e-02f, -6.54876903e-02f, -5.26411124e-02f, -4.72960062e-02f, -2.26006992e-02f, -2.13404372e-02f, -5.56169711e-02f, -2.42639221e-02f, 3.98504324e-02f,
  -2.36761961e-02f, 3.92801389e-02f, 4.49514464e-02f, 6.94046915e-02f, -3.05065904e-02f, -5.37032038e-02f, -1.72284544e-02f, 2.79053841e-02f, -6.23708889e-02f, -1.21521521e-02f,
  6.06569424e-02f, 4.60831262e-02f, 1.17437094e-01f, 6.58924459e-03f, -1.04875546e-02f, 7.91691430e-03f, 8.03839341e-02f, -6.73723444e-02f, 6.20167069e-02f, 1.44182313e-02f,
  -8.83822143e-03f, 5.59477694e-02f, 4.25932109e-02f, 1.26746669e-02f, -3.42388190e-02f, -4.75256406e-02f, 3.29601578e-02f, 6.94416985e-02f, 5.73689751e-02f, -2.16631573e-02f,
  2.61983890e-02f, -1.05270401e-01f, -2.08859578e-01f, -6.29235059e-02f, 2.82871723e-02f, -1.59884989e-01f, -5.54367453e-02f, 2.70833448e-02f, -9.59013849e-02f, -1.59981892e-01f,
  -1.19720228e-01f, -2.22992286e-01f, 2.66392857e-01f, -1.19252034e-01f, -1.35445982e-01f, 1.08345591e-01f, 1.98795408e-01f, 1.36504486e-01f, 7.91473463e-02f, -1.38758728e-02f,
  -9.51558053e-02f, -6.47593616e-03f, 5.16011193e-02f, -4.14832524e-04f, 1.96736410e-01f, 7.20569417e-02f, -1.53708342e-03f, 2.45494559e-01f, 3.31687868e-01f, 1.55971989e-01f,
  -4.48556393e-02f, -4.07335460e-02f, 1.87823564e-01f, 1.48782998e-01f, -2.41145313e-01f, 5.31704798e-02f, -1.13583110e-01f, -6.49772435e-02f, 2.66647562e-02f, -3.71190339e-01f,
  -9.76674855e-02f, -4.35850769e-03f, 1.75614744e-01f, 2.70853913e-03f, -5.89520223e-02f, 5.01117557e-02f, 7.93307349e-02f, 1.27879068e-01f, 4.04558778e-02f, -3.84458564e-02f,
  8.66995007e-02f, 5.09453043e-02f, 2.55220588e-02f, -3.87100801e-02f, -7.86543563e-02f, 1.14621446e-01f, 4.35489789e-02f, 4.03496698e-02f, 1.50681108e-01f, 8.47193375e-02f,
  -2.31492333e-03f, -8.65561143e-02f, 5.79197370e-02f, 8.14875886e-02f, 6.65998757e-02f, 3.63520458e-02f, -5.24259433e-02f, 5.04351407e-02f, 8.95104334e-02f, -1.18300773e-01f,
  2.31005773e-02f, -1.14646882e-01f, -1.42072504e-02f, -1.07347079e-01f, -7.56994188e-02f, -3.55983824e-02f, -4.74200919e-02f, -1.00504190e-01f, 5.91227133e-03f, -4.42049408e-04f,
  -2.23280606e-03f, -7.40000829e-02f, 5.18722162e-02f, 5.30260557e-04f, -9.16620567e-02f, -1.39746100e-01f, -8.28807652e-02f, -1.64712314e-02f, 7.79449418e-02f, -5.92172472e-03f,
  -2.77563520e-02f, 5.36530577e-02f, -7.89265409e-02f, 3.76365632e-02f, -8.20060074e-03f, 6.79220483e-02f, 2.30077635e-02f, -9.59253684e-03f, -1.76017638e-02f, -4.01980132e-02f,
  -2.40708981e-02f, 1.98072270e-01f, -1.18333623e-01f, -3.00910231e-02f, 4.66347784e-02f, 7.53454268e-02f, -1.40611790e-02f, 9.75346044e-02f, -1.15339704e-01f, 9.99397319e-03f,
  4.90028448e-02f, 9.99844819e-03f, 1.03774190e-01f, -1.55804004e-03f, 6.93857968e-02f, 1.35645732e-01f, 8.11482444e-02f, -9.74171422e-03f, 1.29623875e-01f, -4.58437465e-02f,
  1.17172904e-01f, 6.95297346e-02f, 1.63188443e-01f, 5.09394296e-02f, -2.15568151e-02f, 8.69723111e-02f, 1.14757225e-01f, 5.18756248e-02f, 8.92478749e-02f, 9.78197679e-02f,
  -3.70238781e-01f, 2.68942326e-01f, -2.00384215e-01f, 1.05236821e-01f, -5.70200011e-02f, -6.92595094e-02f, -1.47505784e-02f, -3.36160623e-02f, 1.59083903e-01f, 2.07081988e-01f,
  1.36583999e-01f, 4.66539562e-02f, 1.40198305e-01f, 1.15647297e-02f, -9.13360268e-02f, -1.24347238e-02f, -1.00998068e-02f, -2.88416624e-01f, -2.95482934e-01f, -6.64926544e-02f,
  2.32544467e-01f, 1.02481574e-01f, 5.12185059e-02f, -7.36919940e-02f, 2.19823658e-01f, 1.07734263e-01f, 1.12357795e-01f, 5.42454049e-03f, -2.38524247e-02f, 2.68801451e-01f,
  -9.29807201e-02f, -9.37598273e-02f, 1.91606639e-03f, 8.73630643e-02f, 5.20548690e-03f, 6.68973057e-03f, 1.22590701e-03f, -7.42104501e-02f, 5.61892353e-02f, 1.08908758e-01f,
  1.31086633e-01f, 4.21655364e-02f, -4.99166511e-02f, 1.09243482e-01f, -3.49000953e-02f, -1.67785138e-02f, 1.27255514e-01f, 1.23979077e-02f, -9.44999680e-02f, 4.89227511e-02f,
  1.92928255e-01f, -5.40443100e-02f, -1.99186336e-02f, -3.64917070e-02f, 3.27503867e-02f, 3.43577079e-02f, 1.51491806e-01f, -1.08069293e-02f, 5.13599906e-03f, 1.78062439e-01f,
  6.26426935e-02f, -3.58570851e-02f, -1.11015238e-01f, 1.44367088e-02f, -7.92259648e-02f, -1.10157952e-01f, -8.91330391e-02f, -5.04742526e-02f, 1.49489352e-02f, -5.55098653e-02f,
  -3.49714272e-02f, -3.51045206e-02f, -1.69842355e-02f, -4.24245335e-02f, 3.64376865e-02f, -1.02586955e-01f, -2.70167645e-02f, -6.60488009e-02f, -3.26502547e-02f, -1.48673169e-02f,
  -1.13217004e-01f, -9.37910900e-02f, -1.16074145e-01f, -1.52439270e-02f, -7.38146603e-02f, -8.76191780e-02f, -8.13008919e-02f, -9.67480168e-02f, 4.96965796e-02f, -4.42234613e-02f,
  1.77800328e-01f, -7.71038011e-02f, 1.29731139e-02f, 6.45403787e-02f, 8.42034072e-02f, 1.36979118e-01f, 1.01086810e-01f, 6.77797049e-02f, 1.10272408e-01f, 1.17882572e-01f,
  1.37742400e-01f, 1.05615007e-02f, -2.63964199e-02f, 5.78236319e-02f, 3.12172603e-02f, -1.40799293e-02f, 7.09667876e-02f, -6.26670429e-03f, 8.92160758e-02f, 1.45757213e-01f,
  1.90355286e-01f, 9.66082662e-02f, 1.35917701e-02f, 3.87158096e-02f, 4.40337993e-02f, 3.24591324e-02f, 2.27336753e-02f, 9.67306122e-02f, -1.20385006e-01f, 1.31867707e-01f,
  -6.68458998e-01f, 3.14047257e-03f, 3.00482035e-01f, -2.91673914e-02f, 2.70397633e-01f, 3.28747660e-01f, 3.56812626e-01f, 1.34859988e-02f, -1.12362459e-01f, 1.20994203e-01f,
  1.58473194e-01f, -1.73683971e-01f, 1.91528094e-03f, 1.25801295e-01f, 2.49723569e-01f, 5.08066416e-01f, 3.25176805e-01f, 1.00133404e-01f, 3.31457034e-02f, -1.63108855e-02f,
  2.25077905e-02f, -1.89527377e-01f, -1.90018117e-01f, -6.42225370e-02f, 1.78778116e-02f, 5.11826649e-02f, 1.95471555e-01f, 9.89681855e-02f, 3.80792581e-02f, 7.26413056e-02f,
  4.34401721e-01f, 8.43201280e-02f, 1.61815926e-01f, 1.17000103e-01f, 1.81264505e-01f, -9.51353982e-02f, 2.05018707e-02f, -1.21227773e-02f, -1.00380540e-01f, 5.42328060e-02f,
  8.10740590e-02f, 4.86074761e-02f, 1.15372781e-02f, 5.63680455e-02f, 6.00438118e-02f, -3.09118652e-03f, 3.74943651e-02f, 3.28246765e-02f, 1.47880897e-01f, 1.11983612e-01f,
  9.55915898e-02f, -2.48217639e-02f, -7.35575845e-03f, 7.22198561e-02f, 2.17175901e-01f, -4.54310793e-03f, 1.05796941e-01f, 1.08289912e-01f, 1.34985447e-01f, 6.26436174e-02f,
  -4.62138541e-02f, 3.15719433e-02f, -6.68566898e-02f, -5.98061457e-02f, -1.10560276e-01f, -1.51493892e-01f, -3.78481261e-02f, 8.11720490e-02f, 1.90435406e-02f, -1.08443551e-01f,
  -2.67075542e-02f, 2.60423198e-02f, -1.11826658e-01f, -6.21456280e-02f, -6.68180035e-03f, -8.44756439e-02f, -2.79931538e-02f, -4.05084994e-03f, -7.75886849e-02f, -3.89656909e-02f,
  -5.60064353e-02f, -1.52318142e-02f, -5.39808832e-02f, 9.23801810e-02f, 4.72955033e-02f, -3.31643894e-02f, 4.92275693e-03f, 1.14596514e-02f, -8.89312774e-02f, -1.49827683e-02f,
  4.08753566e-02f, 1.14680201e-01f, 3.18345726e-02f, 1.33817315e-01f, 6.63498640e-02f, 7.84276351e-02f, -4.41602385e-03f, 1.07811138e-01f, 8.40979293e-02f, 4.39505384e-04f,
  9.04537067e-02f, -1.00739505e-02f, -3.15197110e-02f, 5.92124648e-02f, 6.85972571e-02f, 7.59560093e-02f, 1.03675969e-01f, 1.12784825e-01f, 5.72758801e-02f, 3.29940468e-02f,
  5.30832037e-02f, 7.12141991e-02f, -4.07528924e-03f, 8.31118897e-02f, 1.09359182e-01f, -6.36351435e-03f, 4.53120656e-02f, 1.05809972e-01f, 3.50899845e-02f, 3.10384426e-02f,
  -4.11488973e-02f, -2.22248584e-01f, 2.69798428e-01f, -2.35162020e-01f, -1.23086516e-02f, 2.27852002e-01f, 1.77514464e-01f, -2.83625759e-02f, 2.76705949e-03f, -1.14912204e-02f,
  -7.29964748e-02f, -5.59094511e-02f, 8.80727470e-02f, 1.61058486e-01f, 3.65419656e-01f, 2.01983303e-01f, 1.81199819e-01f, 3.74778390e-01f, 3.58269542e-01f, 7.60252774e-02f,
  -1.47925168e-01f, -6.80211931e-02f, 9.02428478e-02f, 3.31243910e-02f, -1.64848313e-01f, -5.85155115e-02f, -7.40286261e-02f, -5.00223227e-02f, -2.38656555e-03f, -1.64354160e-01f,
  -1.37119994e-01f, -7.38412961e-02f, 1.91995099e-01f, -1.50456339e-01f, 1.60209239e-02f, 1.05083473e-01f, 1.72148049e-01f, 5.10209333e-03f, -4.42122370e-02f, 2.36280840e-02f,
  -1.11205608e-01f, 1.62057858e-02f, -1.16330013e-02f, -1.08230107e-01f, -1.92036122e-01f, -7.16222301e-02f, -1.11564316e-01f, 1.13617338e-01f, 7.57930875e-02f, -2.30366923e-02f,
  -1.37497678e-01f, 9.15074348e-02f, 9.21543315e-02f, 9.64757113e-04f, 7.75322840e-02f, 6.80446252e-02f, -7.70673230e-02f, 3.97337377e-02f, 6.82195649e-02f, -2.47100979e-01f,
  3.08242533e-02f, 1.92816816e-02f, -4.21605892e-02f, -6.53191581e-02f, -1.16623519e-02f, -1.22850100e-02f, -2.67271344e-02f, -5.67374192e-02f, -6.93183905e-03f, -5.55565022e-02f,
  3.48460041e-02f, 3.48214656e-02f, 1.55915758e-02f, 2.37320084e-02f, 3.72427516e-02f, 4.23866063e-02f, 1.96512416e-02f, -2.96903979e-02f, -2.77972855e-02f, -2.21984498e-02f,
  3.61028612e-02f, -6.81478977e-02f, -9.27211493e-02f, -1.01691946e-01f, -4.18885890e-03f, 3.09468042e-02f, 1.05114216e-02f, -1.48873059e-02f, 3.64793576e-02f, 1.13790616e-01f,
  -2.74831086e-01f, 1.96126878e-01f, -1.29482687e-01f, -3.34940217e-02f, -6.23297915e-02f, -1.02259874e-01f, -1.42957032e-01f, -1.18662706e-02f, -7.55802840e-02f, -8.77185315e-02f,
  -1.46027198e-02f, -4.21668552e-02f, -1.10675938e-01f, -1.04489066e-01f, 3.07880864e-02f, -7.45855570e-02f, -2.05181707e-02f, 3.37677188e-02f, 7.53540918e-02f, -1.48212150e-01f,
  -1.37828439e-01f, -1.69215742e-02f, -4.27213535e-02f, 1.55541785e-02f, -7.50515610e-02f, 1.49261817e-01f, 1.40015669e-02f, -4.81779613e-02f, 1.40796661e-01f, -2.62249894e-02f,
  1.22709297e-01f, -3.25470924e-01f, 2.94013888e-01f, -1.10212989e-01f, 6.74697459e-02f, 6.80191815e-02f, -2.01827548e-02f, -1.44124940e-01f, -5.67574427e-02f, -1.05407052e-01f,
  -1.92151010e-01f, -1.10590436e-01f, 7.79414875e-03f, -2.80918414e-03f, 1.98326290e-01f, 8.69883150e-02f, 2.20471859e-01f, 4.61328387e-01f, 3.39855164e-01f, 4.24244441e-02f,
  -1.44766316e-01f, 4.61494811e-02f, 1.85250387e-01f, 1.27323329e-01f, -1.61032796e-01f, -4.72638346e-02f, 9.08534303e-02f, 2.67906841e-02f, 1.05910562e-01f, 6.12395257e-02f,
  7.26309270e-02f, -1.82651818e-01f, 5.62323444e-02f, 2.19812095e-02f, -1.42132238e-01f, -7.09193796e-02f, -1.46327078e-01f, 2.82188790e-04f, -9.92878005e-02f, 7.22930655e-02f,
  -2.29227189e-02f, -3.77671011e-02f, -1.43508404e-01f, -1.82272494e-02f, -1.74849909e-02f, -9.68143623e-03f, -2.59844307e-02f, -5.26110791e-02f, 3.27835865e-02f, -5.96287064e-02f,
  -9.72390398e-02f, 1.84697676e-02f, 8.40899721e-02f, -5.57827652e-02f, -6.53842911e-02f, -1.97460074e-02f, -9.78575796e-02f, -5.79794943e-02f, 7.14075565e-02f, -9.74304676e-02f,
  4.75601740e-02f, -1.27009764e-01f, -1.09046996e-01f, 2.71480391e-03f, 1.04197465e-01f, 2.28485242e-02f, 7.17457756e-02f, -7.68010551e-03f, 3.91443111e-02f, -3.04516032e-02f,
  -5.84543087e-02f, 4.75691594e-02f, 7.03256875e-02f, -1.03636660e-01f, 3.94591503e-02f, 5.37220985e-02f, 1.08406674e-02f, -3.91786844e-02f, 3.18957940e-02f, 1.56020924e-01f,
  1.42236754e-01f, 5.30685186e-02f, -4.49398533e-02f, 3.76599729e-02f, -1.53506743e-02f, -3.13348719e-04f, 8.30835402e-02f, 3.73359881e-02f, 1.17024407e-01f, -5.20501472e-02f,
  -1.48677394e-01f, 4.38105948e-02f, -5.41675054e-02f, -6.49201404e-03f, -8.68292376e-02f, -2.39298306e-02f, -5.19316681e-02f, -8.75683427e-02f, -1.32831708e-01f, -5.31669334e-02f,
  -4.90080975e-02f, 5.09454757e-02f, -1.52412698e-01f, -7.74843767e-02f, -2.39262227e-02f, -6.61714450e-02f, -1.34832457e-01f, -7.79419765e-02f, -2.23023072e-02f, -4.47792858e-02f,
  -3.12455893e-02f, 1.75248757e-02f, -7.57604605e-03f, 4.61118482e-02f, -6.95804786e-03f, 1.03649862e-01f, 7.53038703e-03f, -1.03798293e-01f, -1.13685858e-02f, -1.90885186e-01f,
  -3.30658376e-01f, -6.08355582e-01f, 3.94579589e-01f, -3.52593400e-02f, 1.04405969e-01f, 2.97325980e-02f, -1.41682938e-01f, -6.52205497e-02f, 1.14660859e-01f, -5.94098382e-02f,
  -1.82732925e-01f, -9.68721807e-02f, -1.11578353e-01f, -6.00336939e-02f, -3.89733203e-02f, -2.66403910e-02f, 2.35483423e-01f, 3.29293996e-01f, 1.86230853e-01f, -5.31991683e-02f,
  -1.35709971e-01f, 2.03838646e-01f, 8.40113088e-02f, 3.02094743e-02f, 5.57298958e-02f, 8.12336877e-02f, 1.98182300e-01f, 1.13314658e-01f, -4.14734259e-02f, 3.73642415e-01f,
  3.68311107e-01f, -1.78832635e-01f, 1.09109320e-01f, 2.94070374e-02f, 1.12905107e-01f, -5.65515039e-03f, 3.71124246e-03f, 1.87597707e-01f, -4.78411652e-02f, 7.77411982e-02f,
  7.88649544e-02f, 9.08070356e-02f, 1.73417348e-02f, 3.76476720e-02f, 1.87401175e-02f, 5.66108664e-03f, -2.81990282e-02f, 1.66744236e-02f, 5.95509149e-02f, -1.36286676e-01f,
  -2.91311517e-02f, 4.76760678e-02f, 3.82526591e-02f, -1.04400935e-02f, -4.05116566e-02f, 1.05673775e-01f, -4.97882068e-02f, 1.54343411e-01f, -1.49912219e-02f, 1.34908020e-01f,
  9.04009938e-02f, -2.72076204e-03f, -8.63365233e-02f, -2.36423258e-02f, -8.83268565e-02f, -5.76285832e-03f, 1.53330183e-02f, 5.25265038e-02f, -4.41786041e-03f, 1.36127934e-01f,
  -3.82438228e-02f, -2.87692584e-02f, 7.58987069e-02f, -6.17326237e-02f, -4.32345606e-02f, 3.04125212e-02f, -7.65879313e-03f, -3.46155837e-02f, 7.16479197e-02f, -5.67762665e-02f,
  7.46826157e-02f, 4.59961258e-02f, 6.69947267e-03f, 1.12414114e-01f, -1.31411515e-02f, 3.65811773e-02f, 5.38996868e-02f, -1.24497712e-02f, -7.18514696e-02f, -3.37000042e-02f,
  6.11955449e-02f, -9.14510041e-02f, 3.58248837e-02f, 7.60349408e-02f, 1.96611434e-01f, 2.25912165e-02f, -3.26099922e-04f, 3.48666240e-03f, -8.95677209e-02f, 1.91141106e-02f,
  7.03471377e-02f, 2.09347866e-02f, 5.85646145e-02f, 5.54014333e-02f, 7.94068128e-02f, 2.04836987e-02f, -7.80729484e-03f, 9.85850990e-02f, 1.70188770e-03f, 8.64517763e-02f,
  -3.79688628e-02f, 4.05194517e-03f, 1.13450669e-01f, 2.67520845e-02f, 3.54229733e-02f, -4.61638942e-02f, 2.27283426e-02f, 1.36321858e-01f, 5.24710631e-03f, -1.07657552e-01f,
  1.78736538e-01f, -5.71712852e-03f, 8.99280384e-02f, -7.61590227e-02f, 2.09182471e-01f, 2.10727558e-01f, 4.21160489e-01f, 7.11742938e-02f, -1.02217972e-01f, 4.59876843e-02f,
  -2.84619369e-02f, -3.93907994e-01f, -2.28272229e-01f, -1.96472943e-01f, 7.15078712e-02f, 1.11876033e-01f, 8.69985893e-02f, -5.81539124e-02f, -1.04542308e-01f, -1.05486467e-01f,
  -7.42135867e-02f, -6.08144961e-02f, -8.81165415e-02f, -1.09848566e-01f, -7.33521208e-02f, -2.54993588e-01f, 8.87197033e-02f, 8.13767537e-02f, -5.11498787e-02f, -3.51244844e-02f,
  -6.77647591e-02f, 1.54659882e-01f, -2.18224470e-02f, -1.36728987e-01f, -1.46244988e-01f, -5.53695410e-02f, -5.18350527e-02f, -2.68717855e-02f, -2.72126906e-02f, -2.85365842e-02f,
  -1.01284049e-01f, -8.27045273e-03f, -7.39153475e-02f, -9.08265114e-02f, 1.31885454e-01f, 1.02335274e-01f, -8.59649181e-02f, 7.76656298e-03f, -2.38322001e-02f, -3.70396264e-02f,
  -4.15876098e-02f, 8.66620541e-02f, 9.85333696e-02f, 4.05533575e-02f, 7.96974823e-02f, -1.35429084e-01f, 4.84395362e-02f, -2.49848589e-02f, 2.79145059e-03f, -1.32404312e-01f,
  -9.55262482e-02f, -9.51608585e-04f, 2.43447982e-02f, 1.97856203e-02f, -5.56798279e-02f, 7.23414570e-02f, 5.16975590e-04f, -1.32821789e-02f, 4.82841209e-02f, -1.53754242e-02f,
  4.63998206e-02f, 5.26529364e-02f, -1.10957436e-02f, 3.22208367e-02f, -8.42274800e-02f, -1.11612733e-02f, -4.67983373e-02f, -3.82906720e-02f, 1.09809801e-01f, -1.32615922e-03f,
  -9.87623408e-02f, 1.20183125e-01f, -7.68656433e-02f, -9.13479403e-02f, 6.69260696e-02f, -1.35024771e-01f, -7.59386718e-02f, -1.65468771e-02f, -2.69787330e-02f, 5.71073778e-02f,
  -2.50966966e-01f, 8.72465074e-02f, 1.19582871e-02f, -2.68208757e-02f, 2.20579747e-02f, -1.36980459e-01f, -9.44113508e-02f, -1.61021769e-01f, -1.39393419e-01f, -9.75225121e-02f,
  -8.76285657e-02f, -1.18067935e-02f, 9.27653760e-02f, 9.52017587e-03f, 1.93191692e-02f, 5.29148430e-02f, -7.97548369e-02f, -2.12837104e-02f, 5.00445440e-02f, -4.66644838e-02f,
  -9.53089260e-03f, 4.82040308e-02f, 5.20616286e-02f, -1.46393310e-02f, -1.18008889e-01f, -1.41790807e-01f, -6.00794777e-02f, -7.60064870e-02f, 6.00402169e-02f, -4.00966816e-02f,
  8.52087364e-02f, 2.13944271e-01f, 3.78514603e-02f, 2.36216664e-01f, 7.17632249e-02f, -2.58073932e-03f, 2.61378109e-01f, 1.16435617e-01f, 1.22934803e-02f, 2.70176172e-01f,
  1.46705985e-01f, -3.83765139e-02f, -2.83812489e-02f, -1.35085527e-02f, 1.26925409e-02f, 3.40667903e-01f, 2.41356432e-01f, 6.47839755e-02f, -1.40264824e-01f, 7.95217231e-02f,
  1.18273512e-01f, 3.96013893e-02f, -8.23196396e-02f, 3.25621441e-02f, -1.75473038e-02f, -1.28162727e-01f, -9.98621657e-02f, -1.25047177e-01f, -1.01045765e-01f, 1.12185754e-01f,
  -6.18956201e-02f, 3.07522360e-02f, -1.99918747e-02f, -2.30604801e-02f, -9.20854881e-02f, -1.16300806e-01f, -6.38078675e-02f, -6.25481457e-03f, -4.48393822e-02f, 6.54465258e-02f,
  -1.90663151e-02f, -7.10022077e-02f, -9.90700424e-02f, -5.91506511e-02f, 1.57579370e-02f, -5.40645011e-02f, 2.09411681e-02f, -3.58588584e-02f, -7.00426921e-02f, -6.85951784e-02f,
  4.38525565e-02f, 1.33360222e-01f, -5.72923012e-02f, 8.41047615e-02f, -1.50624458e-02f, -1.39036149e-01f, -2.14713402e-02f, -1.13137580e-01f, -6.63017631e-02f, -5.04956879e-02f,
  1.12028746e-02f, -1.68306045e-02f, -1.03320420e-01f, -1.38239592e-01f, 5.30530140e-02f, -5.23942336e-02f, -1.88396238e-02f, 8.13602284e-02f, -9.02154595e-02f, -1.63356662e-02f,
  4.85017449e-02f, -3.33339013e-02f, 4.06238101e-02f, -2.74544470e-02f, 1.46311015e-01f, 5.51362056e-03f, 4.88381041e-03f, 6.52952567e-02f, 3.24356034e-02f, 2.43310798e-02f,
  -1.77414052e-03f, -1.09540991e-01f, 3.46756764e-02f, -2.92898491e-02f, 1.14629805e-01f, 1.25240207e-01f, 5.20693325e-02f, 5.43021820e-02f, -2.53766719e-02f, -3.67994197e-02f,
  -1.18950583e-01f, -1.46776482e-01f, 3.17075290e-02f, 1.66555434e-01f, -6.06494062e-02f, -5.70175275e-02f, -4.66894284e-02f, 5.84874786e-02f, -4.29276414e-02f, 8.45669955e-02f,
  4.10703719e-02f, 1.07048683e-01f, -1.69534326e-01f, -1.26090869e-01f, -7.06661940e-02f, -3.90913151e-03f, 3.25014554e-02f, 7.13941976e-02f, -1.40210584e-01f, 3.44204605e-02f,
  7.34633878e-02f, 1.33459851e-01f, 1.63299456e-01f, -1.33891162e-02f, 2.91623380e-02f, 5.59189580e-02f, -8.35006982e-02f, -1.13474406e-01f, -5.87535501e-02f, 9.81127545e-02f,
  4.62337077e-01f, 1.40205815e-01f, 1.57653302e-01f, 1.10760676e-02f, -3.10589880e-01f, -4.35090847e-02f, 2.77909070e-01f, 2.27229133e-01f, 4.32872958e-02f, 1.29211202e-01f,
  -2.12288901e-01f, -2.62164444e-01f, -6.54993132e-02f, 2.20619123e-02f, 1.30971640e-01f, 8.51758868e-02f, 9.86930728e-02f, 1.69512287e-01f, 1.38678446e-01f, -1.41878963e-01f,
  -4.61795367e-02f, 1.98237672e-01f, 3.42077702e-01f, 5.79043888e-02f, -1.14362417e-02f, -1.79665580e-01f, -7.17044109e-03f, 5.17492369e-02f, -4.23407331e-02f, -7.53794611e-02f,
  -6.32196441e-02f, -7.17468932e-02f, -1.46513909e-01f, -7.44113093e-03f, -1.11760013e-01f, 1.83563039e-03f, 6.66470872e-03f, 4.97858599e-03f, -3.40070315e-02f, 1.56527907e-02f,
  -1.76430836e-01f, 1.20822387e-02f, -8.72216970e-02f, 4.91990037e-02f, 8.36547241e-02f, 3.15310359e-02f, 1.07129380e-01f, 1.74472094e-01f, 2.09896713e-02f, -6.10797554e-02f,
  -1.27032861e-01f, -2.11498793e-02f, 8.13943967e-02f, 5.60548156e-02f, -6.50259182e-02f, -5.16058365e-03f, -9.44875255e-02f, -1.01583935e-01f, 4.82729971e-02f, 1.87357098e-01f,
  3.87952616e-03f, 2.69775651e-02f, -5.15193045e-02f, 1.06996551e-01f, 1.66290343e-01f, -3.16064544e-02f, 9.52769741e-02f, 5.47418408e-02f, 3.21186706e-02f, 2.35291868e-02f,
  4.43523526e-02f, -2.50611380e-02f, 1.19028702e-01f, -2.94147842e-02f, -5.85960709e-02f, -1.42290547e-01f, 1.35471085e-02f, -4.09430154e-02f, -8.64010006e-02f, 3.16593684e-02f,
  -1.37325358e-02f, 3.55543755e-02f, -1.53942434e-02f, 4.85290997e-02f, -5.29994480e-02f, -1.09258331e-02f, 8.88929795e-03f, 6.67060167e-03f, -6.59495965e-02f, -9.50422809e-02f,
  2.17061892e-01f, -8.06152299e-02f, 9.69064981e-02f, -9.31651145e-03f, 1.72398072e-02f, -5.64957270e-03f, -7.22698495e-02f, 2.53389310e-02f, -1.20961398e-01f, 1.01053655e-01f,
  7.01044453e-03f, 1.42051056e-01f, -2.42569931e-02f, 1.44285439e-02f, -1.00868207e-03f, 5.86718135e-02f, -2.99333632e-02f, -3.31853633e-03f, 5.11087924e-02f, 7.82762244e-02f,
  4.70115431e-02f, 4.74403389e-02f, 4.24335524e-02f, 6.99254349e-02f, 5.81148490e-02f, -9.62960906e-03f, 2.78448705e-02f, 8.91148970e-02f, 1.93564102e-01f, 3.73160154e-01f
};

// L0_fan_Wp_bar (Shape: 14 x 120)
const int L0_fan_Wp_bar_rows = 14;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -4.38314408e-01f, -1.52627155e-01f, -1.16037250e-01f, -6.44161254e-02f, 1.99765880e-02f, 1.14654817e-01f, -2.13543877e-01f, 5.88691160e-02f, 2.56544687e-02f, -1.87467888e-01f,
  -2.11408406e-01f, -2.46282130e-01f, -2.79017061e-01f, -1.95999041e-01f, -2.95367956e-01f, -3.94221246e-01f, -3.52536917e-01f, -2.70474702e-01f, 2.42867898e-02f, 1.30100682e-01f,
  -8.23340565e-02f, -1.93533793e-01f, -1.54066876e-01f, -9.37415008e-03f, 5.17244488e-02f, -3.34479809e-02f, -3.21011767e-02f, 6.68961853e-02f, 2.55231168e-02f, -8.36298540e-02f,
  -4.41422462e-02f, -5.96053004e-02f, 1.57435331e-02f, -6.90042675e-02f, 6.95879236e-02f, -4.19135317e-02f, -1.16643436e-01f, 5.46164345e-03f, 6.55733645e-02f, -1.60967514e-01f,
  -8.73910934e-02f, -4.06859405e-02f, 3.89985219e-02f, -3.72341760e-02f, -1.14013113e-01f, -7.86903948e-02f, -5.64228045e-03f, 7.49421269e-02f, 1.39986351e-02f, 1.41779661e-01f,
  -6.80017397e-02f, -6.75026700e-02f, -2.32297648e-02f, -1.98177807e-03f, 3.05549260e-02f, -3.26808468e-02f, 1.30591854e-01f, 1.49658605e-01f, 1.41863510e-01f, 6.59700036e-02f,
  -3.60657088e-02f, -1.49150391e-03f, -3.01109045e-03f, -9.11420211e-02f, -2.25732937e-01f, -1.11338468e-02f, -5.43686487e-02f, -1.15336873e-01f, -4.55323756e-02f, 1.25437472e-02f,
  8.44325125e-02f, 3.71864177e-02f, -6.43669069e-02f, -2.60638241e-02f, 2.48020585e-03f, 4.75372337e-02f, -3.90881822e-02f, 5.70533462e-02f, 3.51062827e-02f, -1.77242085e-02f,
  -1.37512699e-01f, 2.54107088e-01f, 1.06570516e-02f, -5.60277142e-03f, -1.18959509e-01f, 9.14116576e-02f, 1.70681602e-03f, -6.03862889e-02f, 7.95405507e-02f, -6.38218522e-02f,
  -6.90533519e-02f, 8.56502578e-02f, -2.45946407e-01f, -6.71948120e-02f, -8.46443698e-02f, 3.30018415e-03f, -9.74650532e-02f, -5.52661568e-02f, 3.92562803e-03f, -1.02080472e-01f,
  -6.89007565e-02f, 5.95807889e-03f, -3.23925004e-03f, 7.34852999e-02f, -1.47907302e-01f, -1.90160230e-01f, -2.73282051e-01f, -1.01863459e-01f, -6.39241263e-02f, 7.55808651e-02f,
  -7.25827292e-02f, -1.29442409e-01f, -2.57065147e-01f, -4.16342616e-02f, 1.76015962e-02f, -1.70886263e-01f, -1.16518557e-01f, 1.96005672e-01f, 2.20275223e-02f, -1.49089873e-01f,
  1.29663795e-02f, -5.93301700e-03f, -3.38023044e-02f, 1.63966760e-01f, 2.10703775e-01f, 2.17727736e-01f, 8.61966312e-02f, -2.47806832e-02f, -2.27688719e-03f, 5.44117577e-03f,
  1.91912025e-01f, 1.33806780e-01f, 2.12299690e-01f, 8.89476165e-02f, 1.07511848e-01f, 1.05152316e-01f, 3.43034118e-02f, -9.88815352e-02f, 5.91924265e-02f, 1.26900390e-01f,
  -2.73813773e-02f, -2.29615122e-01f, -1.99522927e-01f, -1.00532703e-01f, 5.11371084e-02f, -4.50563431e-02f, -4.77340631e-02f, -1.64036080e-02f, -3.66220763e-03f, -1.11029394e-01f,
  4.86622065e-01f, 1.56233028e-01f, 6.37716874e-02f, 1.64049685e-01f, -4.17110622e-02f, -1.76987946e-01f, 7.93802291e-02f, -1.28572872e-02f, -2.98391227e-02f, 4.38475087e-02f,
  1.87589042e-02f, -1.03101552e-01f, -8.02401304e-02f, -8.32505748e-02f, -1.32005692e-01f, -5.43052182e-02f, -1.60658598e-01f, 7.68048083e-03f, 1.51301861e-01f, 1.68076858e-01f,
  8.05330947e-02f, 2.28101406e-02f, 1.38829008e-01f, 5.36534144e-03f, 1.32976487e-01f, 2.45674122e-02f, -9.05410852e-03f, 5.66170886e-02f, 1.33755192e-01f, -6.72925040e-02f,
  -1.27259240e-01f, -4.49482501e-02f, -9.68582556e-02f, -7.87524059e-02f, -8.45960081e-02f, -1.00621721e-02f, -1.03710584e-01f, -2.55571445e-03f, -1.36980593e-01f, -3.17499727e-01f,
  -8.23633149e-02f, 1.66082636e-01f, 8.91524106e-02f, -1.16287224e-01f, 9.00233537e-02f, 2.12553907e-02f, -4.86084074e-02f, 8.89010429e-02f, 4.92975814e-03f, -7.07290843e-02f,
  2.22489741e-02f, 1.41265884e-01f, -1.15045443e-01f, -4.71598916e-02f, 5.21498686e-03f, 4.91527189e-03f, -3.26387361e-02f, -5.94404042e-02f, -1.67121813e-01f, -8.27899128e-02f,
  3.00904363e-01f, 2.36802593e-01f, 6.86067864e-02f, 1.12199694e-01f, -1.19408950e-01f, 4.20057662e-02f, 1.21519729e-01f, 1.32279962e-01f, 1.67671651e-01f, 1.57824725e-01f,
  1.31412014e-01f, 3.70652117e-02f, -6.08089101e-03f, 2.55548824e-02f, 6.21169545e-02f, 1.31129446e-02f, -1.87788475e-02f, 1.47182256e-01f, 1.70318589e-01f, 2.55542815e-01f,
  5.29254340e-02f, -2.81296275e-03f, 1.95639133e-01f, 1.74361885e-01f, 8.83512106e-03f, 5.50825596e-02f, 4.86611873e-02f, 3.98846306e-02f, 9.63332579e-02f, -3.74218002e-02f,
  -1.24263294e-01f, -4.62026410e-02f, -2.15339944e-01f, -1.50353881e-02f, 2.14384589e-02f, 7.80089647e-02f, -1.83311984e-01f, 2.92981211e-02f, 1.27311006e-01f, -2.37276644e-01f,
  4.96460088e-02f, 1.91859022e-01f, -9.95739251e-02f, -9.17520653e-03f, -1.54177353e-01f, -2.68218040e-01f, -2.41333961e-01f, -1.92310587e-01f, 1.43197536e-01f, 4.09809619e-01f,
  1.94840223e-01f, -1.39693454e-01f, -5.60410358e-02f, 1.39926806e-01f, 2.14903802e-02f, -9.28919688e-02f, -3.21841002e-01f, -2.01238301e-02f, -7.59642199e-02f, -2.56866723e-01f,
  -2.20608383e-01f, 1.49991930e-01f, 1.36233926e-01f, 3.83020937e-02f, -8.91740993e-02f, -8.17951784e-02f, -6.70318529e-02f, -9.41924825e-02f, -7.10114539e-02f, -7.17572048e-02f,
  8.41032937e-02f, 1.29999474e-01f, -1.28228277e-01f, -6.35886416e-02f, 4.60786186e-02f, 1.18806012e-01f, 4.11912762e-02f, -7.47089535e-02f, -2.34953333e-02f, 8.10841173e-02f,
  1.10377878e-01f, 1.55551791e-01f, 4.95612137e-02f, 1.18289944e-02f, -7.30524883e-02f, -4.42692451e-02f, -6.52922466e-02f, 8.33450109e-02f, -5.73241971e-02f, -1.46977931e-01f,
  1.12079293e-01f, 4.55651693e-02f, 1.40952423e-01f, 1.01575084e-01f, 7.40779191e-02f, -7.02044740e-02f, 2.63702758e-02f, -1.64692551e-02f, 9.06086639e-02f, -3.28832082e-02f,
  3.95927159e-03f, 5.32637574e-02f, 5.33712655e-03f, 4.41712365e-02f, 1.24911129e-01f, 9.53413248e-02f, 9.57224369e-02f, 2.14469265e-02f, 8.29231739e-02f, 2.97798757e-02f,
  -1.24694910e-02f, -4.79132272e-02f, -1.28433937e-02f, 3.10575385e-02f, -2.52121631e-02f, -8.35901871e-02f, 4.33976799e-02f, 6.27170578e-02f, 5.53294979e-02f, 6.84479764e-03f,
  -3.88318539e-01f, 3.84279597e-03f, -9.06277969e-02f, 1.26429662e-01f, -6.72158077e-02f, -1.42233251e-02f, -4.63851057e-02f, -6.48161247e-02f, 2.52036704e-03f, 3.80428433e-02f,
  1.83568895e-01f, -5.86666986e-02f, -1.31120548e-01f, 5.93801253e-02f, 2.79418435e-02f, 7.39455670e-02f, -2.47112638e-03f, 1.24163821e-01f, 6.51306957e-02f, 2.68076479e-01f,
  -1.02917366e-01f, 1.47376331e-02f, -3.10310512e-03f, -1.53303057e-01f, 1.50378505e-02f, 3.78938206e-02f, -1.32560208e-01f, 2.43702717e-02f, -1.19913399e-01f, -3.03689539e-01f,
  -2.02699564e-02f, -4.10754025e-01f, -2.29787782e-01f, -2.80303478e-01f, -1.94430828e-01f, -3.78856957e-02f, -1.85219646e-01f, 1.67220399e-01f, -6.38217330e-02f, -3.67786884e-01f,
  -2.62228400e-02f, 2.96941996e-01f, -3.84090748e-03f, 1.54224455e-01f, 1.32369593e-01f, -3.99903089e-01f, -3.42602670e-01f, 6.36314675e-02f, 3.74729455e-01f, 3.28079313e-01f,
  4.46252115e-02f, -7.68758655e-02f, 7.67224580e-02f, 1.41959026e-01f, -2.34809577e-01f, 1.58096254e-01f, -3.43712509e-01f, -1.43071860e-01f, 7.86112063e-03f, -3.79636317e-01f,
  -3.71994041e-02f, -5.50291352e-02f, 1.08002439e-01f, -1.96572579e-02f, -1.67754337e-01f, -6.51116520e-02f, -5.71726747e-02f, -1.41946105e-02f, 1.75723098e-02f, -5.21938540e-02f,
  -1.06310517e-01f, 2.45465524e-02f, 7.39952549e-02f, 6.40539452e-02f, -6.05708025e-02f, 1.09104194e-01f, -4.23516259e-02f, 5.85760735e-02f, -2.67816819e-02f, -9.02516916e-02f,
  -3.55162211e-02f, 6.70638904e-02f, 4.95196730e-02f, -9.95257795e-02f, 8.83198529e-02f, 2.01157518e-02f, -1.01031819e-02f, 1.06045492e-01f, 1.59910187e-01f, -1.27857432e-01f,
  -6.07457422e-02f, 7.23515004e-02f, 5.85190505e-02f, -3.16989645e-02f, 2.48990543e-02f, -2.19298936e-02f, -2.27353796e-02f, 5.42456657e-02f, 8.91207457e-02f, -6.27700984e-02f,
  3.42777520e-02f, 2.32372992e-02f, 2.14927886e-02f, -1.38613343e-01f, 6.05774065e-03f, -3.59094553e-02f, 7.34426007e-02f, -3.97548079e-02f, -3.71431597e-02f, -6.10483103e-02f,
  1.56049272e-02f, 8.17207545e-02f, -8.60627145e-02f, 5.87382689e-02f, -7.89280012e-02f, -1.22894838e-01f, 3.80698740e-02f, 1.00744635e-01f, -1.34513546e-02f, -1.76344030e-02f,
  -1.04917884e-01f, 2.81888489e-02f, -2.06872165e-01f, 2.23370224e-01f, 3.28535214e-02f, -4.91920635e-02f, 1.21613583e-02f, -9.22539830e-02f, -7.65499994e-02f, -6.27562106e-02f,
  2.29257978e-02f, -4.70652469e-02f, -2.63380557e-02f, 7.03041032e-02f, 5.49524426e-02f, 1.99502960e-01f, -6.22409172e-02f, 1.15992159e-01f, 7.59828836e-02f, -6.54101744e-02f,
  -4.32780758e-02f, 6.13932591e-03f, 3.54542136e-02f, -1.35765178e-02f, 4.65477593e-02f, 7.51010478e-02f, 4.41492982e-02f, 1.44871324e-01f, 2.47912675e-01f, -3.25667351e-01f,
  -6.14207029e-01f, -1.35427102e-01f, -3.84738654e-01f, -1.28514558e-01f, 1.95681438e-01f, 8.01167414e-02f, 1.56546608e-02f, -7.02705160e-02f, 1.79576233e-01f, 1.58364743e-01f,
  5.47346063e-02f, 3.52917984e-02f, 7.47205317e-02f, 6.26236126e-02f, -2.14947052e-02f, 2.60692447e-01f, 2.52667159e-01f, -1.83948547e-01f, -2.90753812e-01f, -9.18456819e-03f,
  2.20808670e-01f, -1.17440984e-01f, -2.50669837e-01f, 4.73608188e-02f, 2.23966002e-01f, 2.35060081e-01f, 1.55036435e-01f, 1.67682856e-01f, 1.47147879e-01f, 1.41637579e-01f,
  -1.60273761e-01f, -3.10269058e-01f, -6.24327771e-02f, -2.18805689e-02f, -6.03741556e-02f, -2.05840155e-01f, -1.08596712e-01f, -3.17144364e-01f, -2.25820005e-01f, -1.26774549e-01f,
  6.57448662e-04f, -1.46852974e-02f, -8.47339183e-02f, -7.50759095e-02f, -1.83900446e-01f, -3.46659720e-02f, 6.95547760e-02f, -9.57589969e-02f, 6.79975823e-02f, 6.61206618e-02f,
  2.17301145e-01f, 1.86867699e-01f, -4.43641748e-03f, 1.29924089e-01f, 1.37140706e-01f, 1.13081723e-01f, 5.36967516e-02f, 1.44461617e-01f, 2.75368094e-02f, 1.34136707e-01f,
  1.87442482e-01f, 2.18125224e-01f, 2.63405386e-02f, 9.71754864e-02f, 1.49722531e-01f, -2.26233085e-03f, 2.08643507e-02f, 8.61091018e-02f, 8.69866274e-03f, 8.71691778e-02f,
  5.83479404e-02f, 4.51603197e-02f, 3.47566828e-02f, -1.44464225e-01f, 5.36072515e-02f, 2.41779294e-02f, 7.17618167e-02f, 8.83436128e-02f, 9.01030898e-02f, 1.12383530e-01f,
  9.43195149e-02f, 9.89799201e-03f, -6.87391758e-02f, -1.82654068e-01f, 4.95769158e-02f, 6.60802424e-02f, 1.03279121e-01f, 7.28913620e-02f, 7.27424100e-02f, -2.01114360e-02f,
  1.37764543e-01f, 1.07770666e-01f, 1.03029422e-01f, 1.09260201e-01f, -1.85027383e-02f, 2.65822411e-02f, 1.05136469e-01f, -3.32891010e-02f, -2.02186868e-01f, -6.85493201e-02f,
  3.61322835e-02f, -8.23231488e-02f, -4.08354029e-02f, 1.71175823e-02f, 1.14567829e-02f, 1.98965985e-02f, 1.34487048e-01f, -7.67997513e-03f, 1.14452749e-01f, 5.21986522e-02f,
  2.42245480e-01f, 1.28499508e-01f, -1.06624722e-01f, 9.77362916e-02f, 1.43036336e-01f, 1.13152012e-01f, -7.13990778e-02f, 5.16969003e-02f, -5.22268265e-02f, -5.52976131e-02f,
  -6.44542694e-01f, 2.08244056e-01f, -5.77123538e-02f, -6.02136135e-01f, -4.76685166e-01f, -1.96816921e-01f, 2.64899671e-01f, -2.56952107e-01f, -3.62652063e-01f, 6.89788349e-03f,
  6.26705959e-02f, 7.21953958e-02f, 1.34677619e-01f, 2.04088375e-01f, 3.40657890e-01f, 2.44223461e-01f, -1.18468732e-01f, 1.67123005e-02f, 1.02893777e-01f, -3.40800099e-02f,
  -9.72306728e-03f, -1.31166115e-01f, -2.57628918e-01f, -1.38141975e-01f, -1.72633454e-01f, -1.50695480e-02f, -4.18988988e-02f, -1.82252556e-01f, -2.31240485e-02f, -8.10077116e-02f,
  3.67317289e-01f, -4.10822123e-01f, -1.47591233e-01f, -1.44962996e-01f, -1.42165525e-02f, -1.18472219e-01f, 2.00925320e-02f, -2.28316724e-01f, 1.51609452e-02f, 1.31765613e-02f,
  -1.79216251e-01f, 1.10887932e-02f, -7.25250542e-02f, -1.67697407e-02f, 6.81190118e-02f, 2.64678709e-03f, -7.32243359e-02f, -2.74910163e-02f, 2.24802084e-02f, 2.01953396e-01f,
  8.75264853e-02f, 1.71750467e-02f, -2.07334440e-02f, -5.53867146e-02f, 2.08516624e-02f, 3.28958221e-02f, 5.90117574e-02f, 1.07709439e-02f, -1.54071217e-02f, 1.63628802e-01f,
  1.06634982e-01f, 2.44719386e-02f, -3.77377011e-02f, -7.76096620e-03f, 7.59327738e-03f, 2.74114013e-02f, 2.48818137e-02f, 3.30757424e-02f, 1.25754029e-01f, 1.10976674e-01f,
  -8.03342760e-02f, -1.98987536e-02f, -1.12205207e-01f, -9.35061574e-02f, 9.60400477e-02f, -3.57449464e-02f, 5.46400063e-02f, 7.08940700e-02f, -1.31008223e-01f, 3.64726186e-02f,
  4.18407395e-02f, -4.49215472e-02f, -2.91058491e-03f, 6.97657615e-02f, -8.31193849e-02f, 2.88543524e-03f, -1.39083609e-01f, 1.48266293e-02f, 4.41226400e-02f, -3.67719941e-02f,
  3.36379379e-01f, -2.04597518e-01f, 1.81247368e-01f, 1.46083832e-01f, -1.80047557e-01f, -1.62507128e-02f, -2.57825274e-02f, -2.24087700e-01f, -1.34438917e-01f, -2.45169410e-03f,
  -6.20817505e-02f, 1.46356940e-01f, 4.64164317e-02f, 4.90254210e-03f, -3.43236630e-03f, -2.59620976e-02f, 4.03902307e-02f, -1.17637224e-01f, -1.12474628e-01f, 7.58875459e-02f,
  1.04899347e-01f, 1.93604119e-02f, 1.72857150e-01f, 6.67077675e-03f, 7.08373860e-02f, 5.26937358e-02f, 2.23438486e-01f, 1.23266988e-01f, 4.69177216e-02f, 2.21470729e-01f,
  3.23564708e-01f, 3.71478647e-01f, -4.01451476e-02f, 2.48768821e-01f, 2.35790163e-01f, 1.31348327e-01f, 2.48251349e-01f, 2.53334105e-01f, 7.53324553e-02f, 1.87165648e-01f,
  2.46028408e-01f, 2.78360993e-01f, 2.13355675e-01f, 1.10667191e-01f, 1.18710697e-01f, 3.44691165e-02f, 3.57454866e-02f, 3.44330706e-02f, 2.05018488e-03f, 1.09926455e-01f,
  8.15688297e-02f, -3.40010561e-02f, 4.01444584e-02f, -7.51930289e-03f, 7.48521090e-02f, 2.29614135e-02f, 5.83594367e-02f, 2.15043370e-02f, -1.77923013e-02f, -3.22044790e-02f,
  -7.67536014e-02f, 8.26336369e-02f, -1.15466304e-01f, 3.10445298e-03f, 1.14107795e-01f, -7.22317770e-02f, 8.91411006e-02f, 3.47037911e-02f, -5.02325855e-02f, -1.42601386e-01f,
  4.68871146e-02f, 1.29892603e-01f, 1.57791406e-01f, 8.49347338e-02f, 3.07095386e-02f, -5.64384758e-02f, 3.17207910e-02f, 2.09268540e-01f, 2.96550859e-02f, 5.59641644e-02f,
  1.29985258e-01f, 1.64333120e-01f, 1.77271485e-01f, 1.91164970e-01f, 2.30628878e-01f, 1.29786596e-01f, 7.26583507e-03f, 3.75292860e-02f, 1.90952830e-02f, -3.45678031e-02f,
  2.24839926e-01f, 4.80485708e-02f, 6.59802333e-02f, 2.40713745e-01f, 2.79515646e-02f, 1.28708676e-01f, 8.66362154e-02f, 1.41865134e-01f, 1.41828358e-01f, 2.59921886e-02f,
  -6.14582971e-02f, 1.09947138e-01f, 5.43402731e-02f, 1.10757194e-01f, -3.65425809e-03f, 1.24631323e-01f, 1.52687728e-01f, 5.88134639e-02f, 1.13637662e-02f, 3.04433536e-02f,
  1.06325857e-01f, -3.08532529e-02f, -1.25918850e-01f, 7.03525022e-02f, -6.76206723e-02f, 3.72271650e-02f, -1.88435800e-02f, 2.81117540e-02f, -9.37306229e-03f, -5.72307073e-02f,
  -2.35489801e-01f, 9.01218727e-02f, -3.15583609e-02f, -8.77216980e-02f, -8.84616300e-02f, -4.85976376e-02f, -3.48810367e-02f, -1.48825005e-01f, -1.39023557e-01f, -2.67720610e-01f,
  -7.52746910e-02f, 6.58904836e-02f, 1.87211439e-01f, 7.56413564e-02f, -1.55400351e-01f, -1.09626241e-01f, -2.75145308e-03f, 2.27406055e-01f, 6.34183437e-02f, -3.63385677e-02f,
  -4.54623625e-02f, -4.22835909e-03f, -1.27515391e-01f, -3.27683017e-02f, 3.29882391e-02f, -1.89318806e-02f, -3.50944320e-04f, -5.75523488e-02f, -1.11153029e-01f, -1.15848675e-01f,
  2.21264541e-01f, 3.21162641e-01f, -1.33401379e-01f, 1.29195079e-01f, -3.08371037e-01f, -4.08503681e-01f, -4.92701441e-01f, -2.98265100e-01f, 4.69909534e-02f, 1.10660531e-02f,
  -1.42835319e-01f, 1.40605529e-03f, 6.20556027e-02f, -5.31031415e-02f, -2.18977749e-01f, 6.48199618e-02f, 3.26478295e-02f, 1.53986188e-02f, -2.09636763e-01f, -1.25307128e-01f,
  1.56113341e-01f, 2.71177977e-01f, 2.25797758e-01f, 6.36402816e-02f, 2.25778267e-01f, 1.18012831e-01f, 4.85157669e-02f, 1.34719387e-01f, 3.77430432e-02f, 4.28331584e-01f,
  1.95980161e-01f, -5.23226149e-02f, -2.70866841e-01f, 6.81063086e-02f, -3.51675637e-02f, -6.46909252e-02f, 1.00129116e-02f, 9.29604247e-02f, -1.28382221e-01f, -1.86724996e-03f,
  -7.83875808e-02f, 5.41861169e-02f, -4.31623124e-02f, 5.72022004e-03f, -1.09310575e-01f, -1.72023177e-01f, -3.75555307e-02f, 1.74300652e-02f, 3.97026427e-02f, -4.36579250e-02f,
  -8.75457600e-02f, 7.91171789e-02f, -1.37371123e-01f, -3.13379884e-01f, -2.05608577e-01f, -3.03960405e-02f, -2.53189772e-01f, 2.25523617e-02f, -1.48722500e-01f, 2.49047682e-01f,
  -4.60695438e-02f, -5.72442301e-02f, -7.29080886e-02f, 6.02595657e-02f, 1.60721801e-02f, -3.65232378e-02f, 3.75273861e-02f, -3.59484591e-02f, -9.05206203e-02f, -7.09647387e-02f,
  -5.12633882e-02f, -1.19683575e-02f, -2.14466080e-02f, 2.14657793e-03f, -8.88418332e-02f, 1.38151586e-01f, -9.65968221e-02f, 3.14355865e-02f, 1.92155633e-02f, -8.18702430e-02f,
  -7.02259839e-02f, -3.48994997e-03f, 1.25525489e-01f, 7.60357501e-03f, 2.31248233e-02f, 1.73853133e-02f, 6.50740564e-02f, 6.21611029e-02f, 1.75912783e-01f, 1.24505758e-01f,
  7.30753615e-02f, -3.05879623e-01f, 1.08818665e-01f, 1.18131392e-01f, -3.15922638e-03f, -1.36355562e-02f, 4.51801270e-02f, -1.14611439e-01f, -9.42365751e-02f, -1.77284375e-01f,
  -2.01826826e-01f, -1.10224880e-01f, 3.43229547e-02f, -1.50688905e-02f, -1.20115757e-01f, -9.22550634e-03f, -9.35723186e-02f, -2.36909077e-01f, -7.59988278e-02f, 1.15849949e-01f,
  -1.07040554e-01f, 4.79338914e-02f, -2.15295047e-01f, -2.10921839e-01f, -2.28193915e-03f, -2.05555946e-01f, -1.69345424e-01f, -6.70522600e-02f, -2.49105424e-01f, -1.45542130e-01f,
  -6.08399332e-01f, 1.80238336e-01f, 4.13173512e-02f, -6.39807582e-02f, 2.84567714e-01f, 1.41895041e-01f, 2.66778588e-01f, -1.16344228e-01f, -8.94194096e-02f, 9.58175436e-02f,
  8.24895948e-02f, -5.08454815e-02f, -2.59532295e-02f, 1.06658481e-01f, -8.93383548e-02f, 1.88457459e-01f, 3.66430491e-01f, -1.13160484e-01f, -2.42097199e-01f, 3.49373855e-02f,
  2.05088794e-01f, -1.05699264e-01f, -4.11820829e-01f, -8.88087526e-02f, -1.86709326e-03f, 1.31284306e-02f, 5.33981342e-03f, 1.22152977e-01f, 2.72350699e-01f, 2.47026503e-01f,
  5.87739386e-02f, -1.85534805e-01f, -1.06205590e-01f, -6.32028803e-02f, -1.50897717e-02f, -1.96519822e-01f, 1.75524093e-02f, -3.28967571e-02f, -2.98967771e-02f, -1.22253180e-01f,
  1.11577503e-01f, -8.24898630e-02f, -4.99953143e-02f, 1.72536988e-02f, -6.64483979e-02f, -1.77767575e-01f, -6.78411871e-02f, -1.66295275e-01f, -2.79841095e-01f, -1.70449167e-01f,
  1.85742110e-01f, -6.76489249e-02f, -2.24244878e-01f, 4.30456810e-02f, -5.61281033e-02f, -1.95037901e-01f, -5.06916940e-02f, -8.40083063e-02f, -3.57630789e-01f, -3.30843747e-01f,
  1.17775902e-01f, -1.11310780e-01f, -6.40426353e-02f, 2.80303527e-02f, 2.49006152e-02f, 9.97185335e-02f, 1.28410533e-01f, 2.21872181e-02f, 9.12921354e-02f, -2.22616456e-02f,
  1.57272313e-02f, -1.02868170e-01f, -6.81030154e-02f, 1.77076329e-02f, -6.13058992e-02f, 9.28203017e-03f, 8.26535299e-02f, -2.04824358e-02f, -4.77141552e-02f, 7.08477013e-03f,
  -3.46645303e-02f, -5.84039977e-03f, -1.56223564e-03f, -2.58753393e-02f, 5.85638545e-02f, 7.05186427e-02f, 2.37038508e-02f, -5.03553487e-02f, -8.95135999e-02f, 4.77629378e-02f,
  5.62567590e-03f, 2.65854821e-02f, -1.63186103e-01f, -6.71263114e-02f, 2.54718233e-02f, 3.26456428e-02f, 5.95757216e-02f, 4.72991355e-02f, 2.39760131e-02f, -3.96942496e-02f,
  -1.00022376e-01f, -7.13320971e-02f, 1.04791939e-01f, 2.87488084e-02f, -1.14418581e-01f, -1.20452873e-01f, 6.15907647e-02f, 3.91199865e-06f, 1.27476687e-02f, -9.80178490e-02f,
  -3.13674100e-02f, -3.04535121e-01f, -2.72311717e-01f, 4.59264405e-03f, -2.97158901e-02f, -2.60961145e-01f, -9.06209201e-02f, -9.94340777e-02f, -1.86704814e-01f, -2.27153853e-01f,
  2.42257848e-01f, 6.41852617e-01f, 6.48896545e-02f, -2.19762102e-01f, 2.18608789e-02f, 1.68962386e-02f, 3.07697773e-01f, -5.08564338e-02f, -2.94917941e-01f, 1.21512294e-01f,
  1.30163124e-02f, -2.71360189e-01f, -7.86146671e-02f, -9.87939090e-02f, -2.48891730e-02f, 5.16073406e-02f, 2.10590586e-02f, 2.15460034e-03f, -1.76831290e-01f, -1.51940539e-01f,
  3.54354978e-02f, 9.97778550e-02f, -6.69014752e-02f, 2.53767557e-02f, 1.85124949e-01f, -2.98378587e-01f, 2.02992111e-02f, 1.77918255e-01f, 1.77663207e-01f, 2.23900527e-01f,
  3.47757968e-03f, 2.50541002e-01f, -4.28183138e-01f, 1.50477648e-01f, 6.63399100e-02f, 3.31658423e-02f, -4.62873932e-03f, -1.33187724e-02f, -2.50326581e-02f, -6.44571036e-02f,
  1.36132061e-01f, 3.81245464e-02f, 1.20052293e-01f, 1.16475914e-02f, 1.08975202e-01f, 2.26114318e-02f, -3.45979221e-02f, 8.05433765e-02f, -1.74176935e-02f, 4.78379130e-02f,
  5.48800901e-02f, 1.04968384e-01f, -2.26324275e-02f, -6.51214868e-02f, -4.58336137e-02f, -2.31153876e-01f, -1.98432747e-02f, 1.00213334e-01f, -1.91128865e-01f, -7.37655610e-02f,
  -1.52268961e-01f, 1.06262878e-01f, 1.13937542e-01f, -4.68011387e-02f, -3.30138318e-02f, -8.90991092e-02f, -4.55568694e-02f, -4.07784879e-02f, 5.48395775e-02f, 8.15968663e-02f,
  -1.44905061e-01f, -4.44514900e-02f, -4.36591357e-02f, -1.74673468e-01f, -8.43199193e-02f, 4.46219556e-02f, -3.58929858e-02f, 3.45158279e-02f, -9.16164517e-02f, -2.06835493e-02f,
  -1.99833345e-02f, 8.67248029e-02f, -2.58938298e-02f, 4.39359695e-02f, -2.19739880e-02f, -4.67287749e-02f, -4.49733585e-02f, -1.78451583e-01f, 8.58379714e-03f, 5.12200501e-03f,
  -3.68932843e-01f, -1.49092197e-01f, -1.04807019e-01f, 1.55606464e-01f, 1.76537842e-01f, 1.47526830e-01f, 1.38230145e-01f, 9.23330635e-02f, 1.82581525e-02f, 8.21428001e-02f,
  1.34459719e-01f, -2.26435047e-02f, 1.06588952e-01f, 2.82422714e-02f, -1.59545332e-01f, -5.81433326e-02f, 7.92897418e-02f, 1.61132030e-02f, 1.54349469e-02f, -1.19269326e-01f,
  3.72342137e-03f, -1.46516517e-01f, -2.33168721e-01f, -2.05686927e-01f, -7.43696392e-02f, -3.39636683e-01f, -1.42376900e-01f, -5.10899164e-02f, -8.90967101e-02f, -3.13122123e-01f,
  -1.17592797e-01f, -6.53754249e-02f, -2.68023759e-01f, -4.49911922e-01f, -2.06884488e-01f, 9.56535414e-02f, -1.80709615e-01f, -5.05405385e-03f, -1.79722786e-01f, -3.28018814e-01f,
  -1.60613418e-01f, -1.73448235e-01f, -5.53364679e-02f, -8.26009214e-02f, -1.12366483e-01f, -2.35388726e-01f, -3.88849497e-01f, -1.09701075e-01f, 1.41325772e-01f, 5.28778397e-02f,
  -1.80197880e-01f, -4.45345938e-01f, -2.44466871e-01f, -2.96608452e-02f, -2.93073058e-01f, -1.74929649e-01f, -5.05178750e-01f, -2.98609138e-01f, 5.99351861e-02f, -3.51440102e-01f,
  -1.77579463e-01f, 2.65145361e-01f, 1.58770844e-01f, 2.44069815e-01f, 7.48099610e-02f, 4.28313427e-02f, 1.80271864e-02f, -1.35988310e-01f, 1.45355910e-01f, 5.24595380e-02f,
  4.01068432e-03f, 2.53085345e-02f, 1.16825281e-02f, -5.56190461e-02f, -1.91715285e-02f, 5.00093699e-02f, 2.70766951e-02f, -6.80708364e-02f, 3.92647423e-02f, 2.47249566e-02f,
  1.01039171e-01f, -3.29097803e-03f, 8.99412930e-02f, 1.14130780e-01f, 2.37936094e-01f, 1.21888347e-01f, 1.87755421e-01f, 2.67580867e-01f, 1.69207975e-01f, 6.35840520e-02f,
  -1.05560333e-01f, 4.10774052e-02f, -2.03222353e-02f, -8.50468781e-03f, -2.25048717e-02f, 1.00852877e-01f, -5.54249734e-02f, -1.24980144e-01f, 6.15221821e-03f, -7.17717931e-02f,
  -1.04838358e-02f, -9.05282199e-02f, -4.52575795e-02f, -1.19362660e-01f, -1.33839384e-01f, -2.99975998e-03f, 6.27241954e-02f, -8.64911750e-02f, 6.08153939e-02f, 1.57974049e-01f,
  8.86909217e-02f, 5.40954173e-02f, -8.91396105e-02f, -3.60065177e-02f, -8.31413418e-02f, -4.58103381e-02f, -5.07408343e-02f, 3.68278031e-03f, -2.19182670e-02f, 7.22764060e-02f,
  -3.62334430e-01f, 1.94670811e-01f, 5.63487820e-02f, 1.70462519e-01f, 3.84180225e-03f, 1.91086289e-02f, 1.87475886e-02f, -1.74928129e-01f, -5.18642999e-02f, -8.41657352e-03f,
  1.19073957e-01f, 1.43162743e-03f, -7.81311393e-02f, 7.87491575e-02f, 3.59257348e-02f, -2.63022259e-02f, -3.05232275e-02f, -1.21755548e-01f, 2.65023541e-02f, -1.99493822e-02f,
  -2.45375447e-02f, 4.02861014e-02f, 7.77668729e-02f, 1.16810314e-01f, 9.47545171e-02f, 7.91178420e-02f, 6.23760652e-03f, -1.90221462e-02f, -5.84309250e-02f, -1.32888928e-01f,
  -2.54581459e-02f, -1.75653309e-01f, -1.77666336e-01f, 1.79420024e-01f, -1.11613728e-01f, -1.22445533e-02f, -1.67799249e-01f, 1.74545988e-01f, 2.15314671e-01f, -9.96649712e-02f,
  3.86490882e-03f, 1.35758281e-01f, 7.05799013e-02f, -6.18987568e-02f, -1.14086822e-01f, -2.71626443e-01f, -2.90038586e-01f, -1.76679179e-01f, 1.61187381e-01f, 2.09940821e-01f,
  3.77341509e-02f, 1.27731651e-01f, 2.34644432e-02f, 1.00257836e-01f, -1.75236259e-02f, -1.59132704e-01f, -3.31265122e-01f, -2.05687732e-01f, -3.55566710e-01f, -4.97706771e-01f,
  -2.99679309e-01f, -2.20110431e-01f, 1.40948713e-01f, -3.78276147e-02f, 1.29518300e-01f, 1.50208026e-01f, 5.40588535e-02f, 7.79057816e-02f, 2.44691238e-01f, 2.18286574e-01f,
  1.13730438e-01f, 1.59305140e-01f, 6.13612942e-02f, 2.14788783e-02f, 1.88410189e-02f, 4.62156534e-02f, 1.63870543e-01f, 1.01213120e-01f, -3.95115986e-02f, 1.60923079e-02f,
  4.56315884e-03f, -6.23183660e-02f, -4.69565056e-02f, -1.35669827e-01f, -4.38545123e-02f, -9.44364443e-03f, -4.60877940e-02f, -1.89940426e-02f, -1.31983414e-01f, -1.04137033e-01f,
  5.48111387e-02f, -3.77874225e-02f, -1.56291686e-02f, 7.60734603e-02f, -6.02374785e-02f, 6.98084533e-02f, -1.54359370e-01f, -1.43229231e-01f, 1.51381884e-02f, 2.60988809e-02f,
  8.93882737e-02f, -9.74564254e-03f, 3.75567377e-02f, -8.42050090e-02f, -6.79859892e-02f, -1.51538685e-01f, -1.81489393e-01f, -1.66204020e-01f, -1.31902233e-01f, 3.31541561e-02f,
  7.34955296e-02f, 1.09357457e-03f, 1.76740792e-02f, -8.23872462e-02f, -1.54931501e-01f, -6.37890175e-02f, 1.66954976e-02f, 5.48329614e-02f, 1.69759914e-01f, 1.29122302e-01f,
  1.39402002e-01f, -2.17029870e-01f, -8.39231238e-02f, 8.56570601e-02f, -1.11358806e-01f, 1.34398624e-01f, -7.70545974e-02f, 5.57516739e-02f, -3.00473534e-02f, 4.70301695e-02f,
  3.68682072e-02f, -1.26290798e-01f, -4.24012020e-02f, 3.78056504e-02f, 1.12679049e-01f, -6.66783750e-02f, 3.26804817e-02f, -1.71329722e-01f, -8.39227960e-02f, 1.01325519e-01f,
  1.17902949e-01f, -2.51647439e-02f, -1.48636643e-02f, -1.56164005e-01f, 3.17068212e-02f, -1.89300522e-01f, -1.39764309e-01f, -1.63600743e-01f, -2.97317296e-01f, -1.58669800e-01f,
  -6.61173284e-01f, -4.48001288e-02f, -5.04090786e-02f, -3.13238770e-01f, 3.27990919e-01f, 3.66720229e-01f, 3.10602665e-01f, 1.47151142e-01f, -9.30076316e-02f, 1.51421249e-01f,
  1.69772059e-01f, 3.34753990e-02f, 6.98302463e-02f, 1.22242376e-01f, 8.45524669e-02f, 2.42903084e-01f, 2.25865290e-01f, -1.08831368e-01f, 4.44379188e-02f, 2.18413040e-01f,
  1.60559639e-01f, -3.40924233e-01f, -4.16877568e-01f, -1.28328711e-01f, -4.61282618e-02f, -2.03954186e-02f, -2.21716657e-01f, -9.12469849e-02f, 6.47482052e-02f, -8.22976604e-02f,
  -1.23481564e-01f, -1.98196396e-01f, 2.35205173e-01f, -9.33290198e-02f, -1.36448711e-01f, -2.10687444e-02f, -2.05384359e-01f, -2.64613450e-01f, -4.01419438e-02f, -1.98334321e-01f,
  -1.53814048e-01f, 5.14464453e-02f, -2.65953671e-02f, 2.89191250e-02f, -1.35776326e-01f, 2.41385084e-02f, 7.51621276e-02f, -4.45850268e-02f, 2.16048211e-02f, 1.06079146e-01f,
  2.13023454e-01f, 5.50840832e-02f, -1.00403875e-01f, 9.46864262e-02f, 6.20766915e-02f, -2.12833926e-01f, -1.35960042e-01f, -1.13326043e-01f, -2.27472559e-01f, -3.77022713e-01f,
  -1.69149563e-02f, -4.74278592e-02f, -3.24655958e-02f, 4.78089787e-02f, 6.97612539e-02f, -4.97345030e-02f, -7.60499090e-02f, 1.73877209e-01f, 1.63793545e-02f, -1.34869725e-01f,
  -1.84327504e-03f, 1.58200130e-01f, 1.80360302e-02f, 7.29382969e-03f, 8.66525434e-03f, -6.59909248e-02f, 2.81638056e-02f, -5.75427264e-02f, -1.53312599e-02f, -1.00336857e-01f,
  -8.36458057e-03f, -4.17911038e-02f, -4.15824279e-02f, 1.16412282e-01f, 7.43395165e-02f, -8.16000253e-03f, -1.23326965e-02f, 1.00435778e-01f, 3.95697914e-02f, -9.62460227e-03f,
  -2.62097508e-01f, -3.93327065e-02f, -5.07554114e-02f, 8.21499303e-02f, -5.03242090e-02f, -8.58551413e-02f, -1.04573593e-01f, 7.69433826e-02f, -4.84383032e-02f, 1.51253477e-01f,
  -4.05017212e-02f, -6.30755424e-02f, -1.01753227e-01f, -1.62651099e-03f, -1.39518483e-02f, 1.09183371e-01f, 3.53647470e-02f, 1.78198934e-01f, 7.16545060e-02f, 1.22822998e-02f,
  5.72638437e-02f, 1.80119332e-02f, -1.39417797e-01f, -3.62427644e-02f, -6.42774850e-02f, -1.90710768e-01f, -1.67395204e-01f, -3.33574042e-02f, -2.79975116e-01f, -2.60484576e-01f,
  2.75589507e-02f, -3.04245740e-01f, -3.52020204e-01f, -8.60669091e-02f, -6.52308902e-03f, 2.58462243e-02f, -1.30713731e-01f, 1.63133249e-01f, 1.07425913e-01f, -1.92599922e-01f,
  -1.66313037e-01f, 1.60447195e-01f, -1.09943822e-01f, -1.04247732e-02f, -3.96265015e-02f, -3.51456672e-01f, -4.07287747e-01f, -1.19936958e-01f, 2.21911654e-01f, 3.28664929e-01f,
  1.95116296e-01f, 2.41677668e-02f, 2.11538836e-01f, 1.14056319e-01f, 2.51744501e-02f, 1.57333642e-01f, -1.11471280e-01f, 6.21101223e-02f, 5.35390154e-02f, -3.02290589e-01f,
  -3.12227219e-01f, -9.55213755e-02f, -3.61432880e-02f, 8.77807438e-02f, -1.27448112e-01f, 2.97145396e-02f, -1.45323038e-01f, -9.85212624e-02f, -2.11922582e-02f, -4.61647399e-02f,
  -5.94275407e-02f, 1.06698453e-01f, 1.61298171e-01f, -3.18122562e-03f, 7.30241537e-02f, 1.57048851e-01f, 1.88600663e-02f, 6.18634112e-02f, -1.62567303e-01f, -1.78940371e-01f,
  -1.83955878e-01f, -1.33800030e-01f, -1.11497112e-01f, -2.00278517e-02f, -7.87913334e-03f, -9.42650624e-03f, 7.66093731e-02f, 5.81015199e-02f, 1.94916893e-02f, -1.00320645e-01f,
  -5.90190180e-02f, -2.49654893e-03f, 4.68492433e-02f, 6.98162839e-02f, 2.01956593e-02f, -4.03796881e-03f, -3.63856950e-03f, 7.95700029e-02f, 1.01912275e-01f, -2.56326552e-02f,
  -8.39983821e-02f, 7.56078884e-02f, 2.35105362e-02f, -1.27651796e-01f, 4.85956781e-02f, 1.70351062e-02f, 2.07423978e-02f, 2.84382422e-02f, 2.61784177e-02f, 5.39775081e-02f,
  8.57892707e-02f, 4.69446778e-02f, 2.88766585e-02f, 1.18995786e-01f, -1.16050512e-01f, -7.55842701e-02f, -9.95910317e-02f, 5.51809557e-02f, -6.56351447e-02f, 6.46803179e-04f,
  1.41862988e-01f, -6.58253133e-02f, -2.55969375e-01f, 1.33896396e-01f, -7.79274255e-02f, -1.84627324e-01f, -7.39682913e-02f, -3.35174538e-02f, -3.80344167e-02f, -1.30827352e-02f,
  -2.18608100e-02f, -1.97967310e-02f, 2.88811717e-02f, 5.96591923e-03f, 4.57144156e-02f, 1.37114972e-01f, -2.38394574e-03f, 1.19268810e-02f, -1.74569767e-02f, -2.33715605e-02f,
  -9.07428935e-02f, -2.91652232e-02f, 2.99152602e-02f, -4.00037766e-02f, -5.93581796e-03f, 6.65830448e-02f, -3.88410613e-02f, -4.92036939e-02f, -9.39297602e-02f, -8.69039819e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 14)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 14;
const float L0_fan_Bp_bar_data[] = {
  9.38639324e-03f, -3.93325649e-02f, -5.83068542e-02f, 1.62911206e-01f, 9.72057208e-02f, -5.88401891e-02f, -8.93831775e-02f, 2.18618080e-01f, -3.67254913e-02f, 2.00072870e-01f,
  9.41556972e-03f, 5.06192222e-02f, 4.58085723e-02f, 8.27465653e-02f
};

// L1_fan_Wp (Shape: 25 x 64)
const int L1_fan_Wp_rows = 25;
const int L1_fan_Wp_cols = 64;
const float L1_fan_Wp_data[] = {
  -1.85428157e-01f, 1.81381300e-01f, 4.83161682e-04f, -1.46248400e-01f, -2.29174271e-02f, 6.34606928e-04f, -8.32667761e-03f, 6.41743541e-02f, -6.80960566e-02f, 1.40732095e-01f,
  2.23669633e-02f, 2.44151309e-01f, -3.84798869e-02f, -2.00702734e-02f, -5.63206710e-02f, 2.29817722e-02f, 3.20426337e-02f, -8.01053867e-02f, -1.00816771e-01f, -8.79992694e-02f,
  -1.41312718e-01f, 6.80574998e-02f, 2.32357606e-01f, 4.40594405e-02f, 2.01390125e-02f, -6.98615611e-02f, 4.39190380e-02f, -1.25324115e-01f, -3.35080177e-02f, 6.51396513e-02f,
  3.55941743e-01f, -1.17515668e-01f, -6.34884834e-02f, -7.63900727e-02f, -9.07391608e-02f, 2.20345065e-01f, -1.30457446e-01f, -2.21383885e-01f, 1.55706018e-01f, 8.07447657e-02f,
  9.16319527e-03f, -6.21555522e-02f, 3.80484983e-02f, -3.05206835e-01f, 9.60862562e-02f, 9.70503017e-02f, 1.05779953e-01f, -2.78730728e-02f, -3.68970148e-02f, 1.49298951e-01f,
  -2.86677871e-02f, 5.63518032e-02f, 7.46662170e-02f, 2.28936188e-02f, -6.80446997e-02f, -3.53093475e-01f, 1.19930416e-01f, 6.09671362e-02f, -3.65302190e-02f, -1.15650162e-01f,
  1.19261339e-01f, -6.21475726e-02f, -6.58635572e-02f, 3.86776440e-02f, -1.00713007e-01f, -5.37371524e-02f, -1.31216660e-01f, 4.91566397e-02f, -1.07197665e-01f, -2.24471875e-02f,
  5.54287322e-02f, 4.72035911e-03f, 3.21930908e-02f, -6.86478540e-02f, -9.42963064e-02f, -3.24024744e-02f, -4.21067849e-02f, -5.02312481e-02f, 1.00520737e-01f, 7.21714348e-02f,
  -6.39981255e-02f, 9.58254468e-03f, 1.93142474e-01f, -4.59844321e-02f, -3.37789729e-02f, -1.00830168e-01f, -4.67225397e-03f, -1.25141636e-01f, -8.27454329e-02f, -1.96184605e-01f,
  -6.12833388e-02f, 2.13872060e-01f, 4.96209897e-02f, -4.02723588e-02f, -1.76058322e-01f, -3.14397998e-02f, -8.47801715e-02f, -4.05497476e-02f, -4.62866239e-02f, -1.03466764e-01f,
  9.74936932e-02f, 8.29270780e-02f, -9.50918347e-02f, -2.15165257e-01f, 2.64953822e-01f, -2.15731878e-02f, -7.50196585e-03f, 2.44095493e-02f, -1.97991878e-01f, -1.85175255e-01f,
  2.27777231e-02f, 1.43829122e-01f, -1.59727558e-01f, -1.52782068e-01f, 2.35792518e-01f, -1.29570082e-01f, 1.95733175e-01f, 6.20591491e-02f, 1.58143595e-01f, -1.66124344e-01f,
  -5.56082390e-02f, -2.48795783e-04f, 1.98534206e-01f, 2.38613442e-01f, 1.48250461e-01f, 6.86140060e-02f, 2.02736080e-01f, 5.57979383e-02f, 9.53240246e-02f, 1.34627312e-01f,
  1.07608633e-02f, 1.01309709e-01f, -1.04874805e-01f, 2.37613365e-01f, -1.30734086e-01f, 1.45487385e-04f, -6.37012273e-02f, 4.51234356e-02f, 1.36987474e-02f, -2.14186013e-01f,
  -1.26276925e-01f, -5.15897498e-02f, 2.46711552e-01f, 2.37908890e-03f, 8.09980035e-02f, -2.24509351e-02f, -9.81195793e-02f, -1.57899603e-01f, 6.83201626e-02f, -1.63857087e-01f,
  -1.59708977e-01f, 1.03492461e-01f, -6.41568527e-02f, -1.14168957e-01f, -6.61635771e-02f, 1.91801518e-01f, -2.71492936e-02f, 6.45139515e-02f, -6.78631738e-02f, 7.26260915e-02f,
  -2.76672281e-02f, -6.79344982e-02f, 1.35998294e-01f, 5.93469143e-02f, 1.23895116e-01f, 9.54483896e-02f, 7.74004832e-02f, -6.66739568e-02f, -1.18750900e-01f, -4.49934788e-02f,
  1.37643889e-01f, -7.33334720e-02f, -4.44954365e-01f, -2.27465138e-01f, -1.82817489e-01f, -1.84521377e-02f, 9.84600782e-02f, 4.15128209e-02f, -9.04167369e-02f, 1.42620057e-01f,
  -6.31501898e-02f, -1.61509961e-01f, -3.29580531e-02f, 3.36242855e-01f, 1.16093419e-01f, 2.87629843e-01f, -6.92685694e-02f, -4.33130786e-02f, -3.15065771e-01f, 6.19314127e-02f,
  -3.40159297e-01f, -4.65861671e-02f, 4.27248850e-02f, 7.95490816e-02f, -1.07462615e-01f, -4.00278904e-02f, -1.11300744e-01f, -2.47757718e-01f, 1.40974447e-02f, -1.28181145e-01f,
  -6.09658798e-03f, 3.73523757e-02f, -2.69929320e-01f, 7.96618536e-02f, -1.60571158e-01f, 6.75715506e-02f, 7.67677352e-02f, -2.15358213e-02f, -1.77919120e-03f, -1.54087231e-01f,
  -7.65292719e-02f, 1.78655551e-03f, 1.34983614e-01f, 1.46747515e-01f, -1.21728387e-02f, -1.30082622e-01f, 1.07363425e-01f, -1.21352695e-01f, -3.15157101e-02f, 4.16792370e-02f,
  8.41950998e-02f, -3.88251245e-02f, 2.49441579e-01f, 1.43858448e-01f, -1.73880160e-01f, -1.24697685e-01f, -2.05041245e-01f, 4.01474595e-01f, -1.70123160e-01f, 1.49124086e-01f,
  -3.59533615e-02f, 2.76364863e-01f, -1.36497721e-01f, 1.33643880e-01f, -1.17286325e-01f, 1.30605802e-01f, 1.12095028e-01f, 2.80597508e-02f, -2.33530730e-01f, 6.20433539e-02f,
  -1.17687814e-01f, -1.43999130e-01f, -1.43586239e-03f, -4.48875409e-03f, 6.81059137e-02f, 1.73334002e-01f, -2.37071276e-01f, -8.15649480e-02f, 1.45303458e-01f, -3.27944219e-01f,
  -8.79488699e-03f, 2.29870260e-01f, 1.95121258e-01f, 8.86580199e-02f, 2.07468137e-01f, 1.75868794e-01f, 7.92768449e-02f, -5.03488481e-02f, 4.25052047e-02f, 6.89080656e-02f,
  -6.13846183e-02f, 3.55140306e-02f, 8.36987142e-03f, 1.43229023e-01f, 1.27342403e-01f, -6.60504214e-03f, -1.35735348e-01f, -9.85002145e-02f, 1.19594239e-01f, -1.32288843e-01f,
  2.71033477e-02f, 1.61994860e-01f, 1.07790694e-01f, -1.40139703e-02f, 2.19146699e-01f, 1.76265001e-01f, 1.38402641e-01f, -4.98355925e-03f, 3.84559929e-02f, -5.10719903e-02f,
  1.17433570e-01f, -3.74519005e-02f, 5.36602139e-02f, 1.49192866e-02f, 1.17999345e-01f, 5.39515838e-02f, -2.80368507e-01f, 9.93890613e-02f, -2.86090858e-02f, 3.85295451e-02f,
  -7.22317770e-02f, -5.61487824e-02f, 5.03623334e-04f, 3.01095247e-01f, 2.63270661e-02f, 8.90102386e-02f, -7.84476027e-02f, 1.14542320e-01f, -4.96036001e-03f, 6.93570226e-02f,
  4.84196395e-01f, 7.00470954e-02f, 5.46517782e-02f, 7.05867261e-02f, 9.06987023e-03f, 2.80017368e-02f, -9.68772266e-03f, 8.37392136e-02f, -2.34241351e-01f, -1.72651410e-01f,
  6.31192550e-02f, 1.89969644e-01f, 3.71299498e-02f, -3.26907456e-01f, 1.55770510e-01f, -8.58039111e-02f, 1.73069164e-01f, -1.20072737e-01f, 3.38387370e-01f, -2.60885149e-01f,
  -1.92130636e-02f, 2.19603911e-01f, 1.28481969e-01f, 1.52776977e-02f, 4.93623614e-02f, -8.37898534e-03f, -1.06697567e-01f, -7.07625151e-02f, 2.59767585e-02f, -4.63358052e-02f,
  -2.33529191e-02f, 1.02536969e-01f, 3.44121195e-02f, 7.11496770e-02f, 2.54367650e-01f, 4.50547971e-03f, 4.78534698e-02f, 4.71183322e-02f, -1.50588393e-01f, -2.00547829e-01f,
  -1.23641886e-01f, -8.26793090e-02f, 1.16233103e-01f, -2.50487984e-03f, -2.69751139e-02f, -1.46142617e-01f, 6.16074773e-03f, 1.40649110e-01f, -1.96765661e-01f, 9.36959386e-02f,
  1.33122504e-01f, -8.53119344e-02f, 8.08105916e-02f, 5.18584736e-02f, -2.45563891e-02f, 8.28560293e-02f, -7.36271963e-02f, -3.29775572e-01f, 1.46991059e-01f, -1.77552123e-02f,
  -6.44117445e-02f, -9.46183428e-02f, 1.37050688e-01f, -1.40745074e-01f, -2.90691257e-01f, -3.81069863e-03f, -1.50494754e-01f, -1.28850684e-01f, 1.44007960e-02f, 5.42568229e-03f,
  7.56900162e-02f, 1.20758027e-01f, 2.18865976e-01f, -6.85848072e-02f, 4.45986055e-02f, -2.03518346e-01f, -2.77351006e-03f, 2.11094737e-01f, 8.31464007e-02f, -1.32969484e-01f,
  1.86893255e-01f, 2.05306470e-01f, 1.04656957e-01f, 2.54622579e-01f, -3.13210115e-02f, -5.01027405e-02f, -9.53744650e-02f, 1.57107666e-01f, 7.59163871e-02f, -1.22690804e-01f,
  -2.27588855e-04f, -9.05683488e-02f, 1.06363513e-01f, 1.04614176e-01f, 7.42066428e-02f, 8.59159604e-02f, 1.05404928e-01f, 6.31684214e-02f, 8.77685621e-02f, -9.76412147e-02f,
  5.95597886e-02f, -1.02060527e-01f, 3.13074253e-02f, 1.19948559e-01f, 1.03954552e-02f, 3.68541433e-03f, 6.10261112e-02f, -8.82021859e-02f, 1.52011916e-01f, 1.63866412e-02f,
  -1.86570957e-01f, -2.92289704e-01f, -6.89182505e-02f, 1.22149475e-01f, 1.61860302e-01f, -5.75964525e-02f, -7.55893588e-02f, 1.53975695e-01f, 2.64213651e-01f, 2.82938242e-01f,
  -5.35421260e-02f, -1.00161374e-01f, 9.16956887e-02f, 7.89243802e-02f, -7.62518793e-02f, 2.30076596e-01f, -1.30262315e-01f, 8.35619941e-02f, 7.69242868e-02f, 1.22554251e-03f,
  9.89452526e-02f, -4.36320789e-02f, -1.72269881e-01f, 1.46440521e-01f, 1.90081030e-01f, -1.79842457e-01f, 8.75310972e-02f, 2.52755433e-01f, -4.32268009e-02f, 1.66413754e-01f,
  -1.29988566e-01f, -1.73510909e-01f, -1.09218009e-01f, -2.39330605e-01f, 1.53211057e-01f, 1.67223647e-01f, -2.35554017e-02f, 3.26689035e-01f, -3.95474099e-02f, -1.82172343e-01f,
  -3.87644544e-02f, -6.18535280e-02f, 2.58429572e-02f, 2.74419989e-02f, 6.16168715e-02f, 1.66440196e-02f, 8.30250159e-02f, 4.91327308e-02f, 1.34517908e-01f, 1.72607917e-02f,
  -8.78065005e-02f, 4.69512157e-02f, -1.11298203e-01f, -7.02765808e-02f, 9.70973540e-03f, -3.00017018e-02f, 8.35100561e-02f, 2.49596387e-01f, 6.57833889e-02f, 1.10835455e-01f,
  -9.53112766e-02f, 2.12077517e-02f, -1.01746045e-01f, 1.79082036e-01f, 2.19319086e-03f, -1.50787026e-01f, 2.13843887e-03f, -4.50164303e-02f, 1.31806657e-01f, -9.51826945e-02f,
  1.78932156e-02f, 1.18984640e-01f, -1.30579537e-02f, -1.62324592e-01f, 4.49990183e-02f, -8.05366486e-02f, -1.07123248e-01f, -1.45707816e-01f, 1.84926227e-01f, 1.31253749e-01f,
  -1.50214702e-01f, 1.59940302e-01f, 2.90805370e-01f, 2.26943150e-01f, 2.18655497e-01f, 7.28143826e-02f, -1.28349094e-02f, 8.33826214e-02f, -4.28126603e-02f, -1.91556513e-01f,
  -2.47583017e-01f, 5.97048327e-02f, -7.07453415e-02f, 8.24862644e-02f, 1.50661871e-01f, 1.61470160e-01f, -1.44065812e-01f, -1.54261691e-02f, -1.80765092e-01f, -5.88880219e-02f,
  -2.09488735e-01f, -2.12445185e-01f, -3.61342318e-02f, 1.27548218e-01f, 1.55080110e-01f, 4.81808484e-02f, 6.12642579e-02f, -1.97554424e-01f, 2.19259173e-01f, 6.94784448e-02f,
  -8.65262300e-02f, -1.01447977e-01f, -1.71779245e-01f, 1.38913035e-01f, -6.12910129e-02f, -9.42702517e-02f, -7.22676963e-02f, 8.71034861e-02f, -5.52502386e-02f, -4.69803810e-02f,
  -1.87151805e-01f, 2.48239636e-01f, 1.08560741e-01f, 2.37758681e-01f, -1.48707777e-02f, -1.76739432e-02f, 2.80621331e-02f, -2.34750867e-01f, 1.01314746e-01f, 5.36783934e-02f,
  1.67345464e-01f, 2.45296378e-02f, 1.46859646e-01f, 7.55831301e-02f, 1.92220941e-01f, 1.79671794e-01f, 4.51092096e-03f, 1.99483916e-01f, 7.79860765e-02f, 5.18583953e-02f,
  -8.42663720e-02f, -2.47370154e-02f, -1.20475322e-01f, -7.37606809e-02f, 5.20210117e-02f, -1.25498950e-01f, -2.04350613e-02f, -9.33579654e-02f, -2.55917549e-01f, 1.23722568e-01f,
  6.85699657e-02f, -3.00486553e-02f, 1.71875395e-02f, 1.28145903e-01f, 2.63122797e-01f, 1.23558708e-01f, -7.86512494e-02f, -3.48231941e-01f, 1.57504797e-01f, -6.94145933e-02f,
  1.75646320e-01f, 2.34641694e-02f, 1.79440007e-01f, -3.52634549e-01f, 3.69599879e-01f, -1.32413919e-03f, -7.75938556e-02f, 1.20207898e-01f, -3.80811319e-02f, -1.82569817e-01f,
  -8.78014192e-02f, -7.25515261e-02f, -7.74418861e-02f, 9.79320407e-02f, -6.33474886e-02f, 4.91002314e-02f, -7.87153989e-02f, 7.74604604e-02f, 8.98494124e-02f, 2.25120466e-02f,
  1.73592232e-02f, -5.25337234e-02f, -1.42679259e-01f, -2.15634480e-02f, -7.55554214e-02f, -5.66848256e-02f, 1.93640284e-04f, -8.55414942e-02f, -2.06576101e-03f, -5.18251862e-03f,
  -1.47890806e-01f, -1.67985618e-01f, -1.23697028e-01f, -3.03055197e-02f, 4.12805490e-02f, 2.19220176e-01f, -7.81107461e-04f, -8.25666487e-02f, -2.35962436e-01f, -2.07284063e-01f,
  -5.57275303e-02f, 4.48735543e-02f, 2.15569213e-01f, -7.39046186e-02f, 1.16109299e-02f, 2.57042842e-03f, 1.09281324e-01f, 5.38075948e-03f, -5.04389293e-02f, -3.84618081e-02f,
  1.05037883e-01f, 7.95112327e-02f, 1.81225222e-02f, -7.89456591e-02f, 7.66046047e-02f, -1.94710717e-01f, 2.09161788e-01f, -5.96306510e-02f, 2.23673075e-01f, 5.83089180e-02f,
  3.34209859e-01f, -9.60035175e-02f, -2.45110497e-01f, 1.38144553e-01f, 3.86257023e-01f, -5.43103851e-02f, 3.77584784e-03f, 1.42141998e-01f, 4.25895870e-01f, 1.45466894e-01f,
  4.04203311e-02f, -1.05536766e-02f, -1.06158040e-01f, 3.97330523e-02f, 1.28433436e-01f, -7.89922550e-02f, -7.44101927e-02f, -1.38892964e-01f, 7.18449131e-02f, -1.24471933e-01f,
  -2.76752621e-01f, 2.45964509e-02f, 1.56772718e-01f, -1.18219003e-01f, -5.12797646e-02f, 2.38059927e-03f, -3.06634028e-02f, -1.45806978e-02f, 2.73818169e-02f, -1.24217533e-01f,
  -3.00188839e-01f, -8.32640305e-02f, 1.72139297e-03f, -1.87533647e-01f, -4.77687605e-02f, -1.49214026e-02f, 9.02855992e-02f, 4.10016216e-02f, -8.80829897e-03f, -3.12097110e-02f,
  5.51148094e-02f, 3.96260619e-02f, 3.52694769e-03f, 2.11356893e-01f, 1.93530247e-01f, 1.41316369e-01f, -6.31866232e-02f, -1.19899027e-01f, -4.50733267e-02f, 2.77320184e-02f,
  -8.90690386e-02f, 1.76626374e-03f, -4.65040728e-02f, -1.48559257e-01f, 1.22806899e-01f, 3.17242891e-02f, -1.31115049e-01f, 7.19711334e-02f, -2.06819139e-02f, 1.18206693e-02f,
  2.57745236e-01f, -3.10568810e-02f, 2.71830708e-01f, -1.08417556e-01f, 2.59029835e-01f, 3.04670148e-02f, -5.15835546e-02f, -9.82504189e-02f, -9.77348816e-03f, -3.43048096e-01f,
  -1.40630007e-01f, 2.65401930e-01f, 1.30005896e-01f, 2.22422153e-01f, -5.91623001e-02f, -5.02057374e-02f, -4.93183173e-02f, -2.73442585e-02f, -7.10715875e-02f, -4.21498381e-02f,
  -9.82994810e-02f, 3.01700309e-02f, 1.01433046e-01f, 3.18738259e-02f, -8.27952921e-02f, 2.26140171e-02f, -9.45098475e-02f, 1.39944842e-02f, -1.61630090e-03f, -3.95146310e-02f,
  8.17314610e-02f, 1.42119005e-01f, -2.46842623e-01f, -7.45321484e-03f, 9.13812146e-02f, 5.82982134e-03f, -7.76343718e-02f, 3.25679183e-02f, 1.27366841e-01f, 8.62476751e-02f,
  5.19196130e-02f, -5.69100119e-02f, 2.21403632e-02f, -8.29787403e-02f, 2.86159724e-01f, -1.22161638e-02f, -8.28990189e-04f, 7.59115443e-03f, -6.08944967e-02f, 2.50237137e-01f,
  -1.20253190e-01f, -5.69251925e-02f, -6.30056486e-02f, 2.79511690e-01f, -1.78463176e-01f, 1.59780666e-01f, 3.23483646e-02f, 1.81329429e-01f, 1.70554265e-01f, 7.40834624e-02f,
  6.03266656e-02f, -1.47124484e-01f, 1.07471095e-02f, 1.22315869e-01f, -1.81473866e-01f, -1.36724681e-01f, -1.31834313e-01f, 8.57719928e-02f, -3.59873086e-01f, 3.90533805e-02f,
  5.82196824e-02f, -4.79275025e-02f, -3.58635962e-01f, 1.76940653e-02f, -2.45496184e-01f, 4.94480655e-02f, -4.24925566e-01f, 8.31759050e-02f, 1.12711126e-02f, -1.29552513e-01f,
  -3.15795243e-02f, 5.93403578e-02f, 5.15596196e-02f, 2.57365227e-01f, -3.71506959e-02f, 9.42124128e-02f, -4.34706137e-02f, 3.34164081e-03f, 7.94797465e-02f, -2.93393042e-02f,
  4.64840718e-02f, -1.59686077e-02f, 3.60769243e-03f, 8.48230273e-02f, 9.03637558e-02f, 3.95592041e-02f, 1.89867660e-01f, -7.27484822e-02f, -6.39040172e-02f, -8.23407024e-02f,
  -4.60440479e-03f, -9.57516488e-03f, -1.23844728e-01f, 6.48460984e-02f, 3.59036662e-02f, 3.17715481e-02f, -8.00299942e-02f, -1.48879275e-01f, -2.70524442e-01f, 5.74534982e-02f,
  -8.94033443e-03f, 5.79193681e-02f, 1.35927677e-01f, -1.50163665e-01f, -5.20502031e-02f, -3.82659733e-02f, 2.85335854e-02f, -6.91908523e-02f, 2.30543315e-02f, -1.03086039e-01f,
  1.23172708e-01f, 9.94501412e-02f, 1.18628070e-01f, 2.12705191e-02f, 1.46309316e-01f, 2.53369212e-02f, -1.04040094e-02f, -1.18392728e-01f, 8.63921642e-02f, 1.70678198e-01f,
  -1.53478220e-01f, -5.35125583e-02f, 5.69871068e-02f, 4.60670739e-01f, -4.92059253e-02f, -8.30258534e-04f, 7.97320604e-02f, -3.42626363e-01f, -5.65008260e-02f, 2.75187492e-02f,
  5.41373752e-02f, -2.86029782e-02f, -1.56435333e-02f, -3.10717449e-02f, 4.24845852e-02f, 6.45372719e-02f, -4.97311205e-02f, 2.97935773e-02f, 2.49084383e-02f, -2.17754152e-02f,
  1.31187856e-01f, -3.51347886e-02f, -5.01200603e-03f, -6.92010596e-02f, 1.36869829e-02f, 1.14726737e-01f, -7.19653070e-02f, 7.23176971e-02f, 4.72010672e-03f, 1.13140717e-01f,
  1.38532192e-01f, 7.50952214e-02f, 8.54976773e-02f, 1.27206385e-01f, 2.04656236e-02f, 7.39952996e-02f, -3.58094485e-03f, 8.71640220e-02f, -4.57261652e-02f, -1.34698778e-01f,
  -2.78113335e-02f, 7.86818564e-03f, 9.40220878e-02f, -4.59392592e-02f, 5.49813099e-02f, 1.62224948e-01f, 9.16049704e-02f, 6.14566356e-02f, 1.05667822e-02f, -1.01107210e-01f,
  -1.24496199e-01f, 1.00532882e-02f, -8.63788575e-02f, 2.21517757e-01f, -7.44552091e-02f, 3.71382460e-02f, 5.06757379e-01f, 2.34071165e-01f, 6.88206851e-02f, 1.20021671e-01f,
  -9.41484272e-02f, 2.42187381e-01f, -1.73173621e-01f, -1.05159566e-01f, -2.78817564e-01f, 8.01084265e-02f, -1.80403009e-01f, 1.47941485e-01f, -1.70332551e-01f, -1.54926460e-02f,
  -8.17438364e-02f, -5.10503165e-02f, -2.17503205e-01f, -3.47397178e-02f, -1.49497941e-01f, 4.32155170e-02f, 8.11920017e-02f, -1.23620711e-01f, -9.65046976e-03f, -5.01988977e-02f,
  -1.44067153e-01f, -1.62332103e-01f, -9.97430086e-03f, -1.55972019e-02f, -4.47952794e-03f, 4.82171476e-02f, -6.72436282e-02f, -8.15822333e-02f, 1.64219677e-01f, 8.55379850e-02f,
  -7.90975764e-02f, 1.84316099e-01f, 1.04067139e-01f, -2.07435712e-02f, -2.32054340e-03f, 3.80120762e-02f, -1.29422888e-01f, -1.68012202e-01f, -9.01232287e-02f, -7.70533755e-02f,
  1.77300021e-01f, 8.62633288e-02f, -7.19052777e-02f, -1.44435480e-01f, -3.92775722e-02f, -2.52500847e-02f, -9.79107339e-03f, 1.23777792e-01f, 7.07355663e-02f, -1.99322701e-01f,
  -3.17168422e-02f, 1.52387440e-01f, 3.90912686e-03f, 2.64580436e-02f, -1.04788534e-01f, 1.42320275e-01f, -1.29234657e-01f, 1.18671589e-01f, -2.58572757e-01f, 1.19639002e-01f,
  4.34542149e-01f, 1.19959727e-01f, 2.52319306e-01f, -7.84244165e-02f, 1.63155310e-02f, -1.94765642e-01f, 3.19374613e-02f, 1.41022995e-01f, 7.41859376e-02f, 3.23358446e-01f,
  1.70819521e-01f, 2.50854995e-02f, -1.85903370e-01f, -4.47175592e-01f, -2.21305802e-01f, -2.13190466e-01f, 6.69160038e-02f, -5.66675030e-02f, 1.83863088e-01f, 2.19309002e-01f,
  -1.09381564e-01f, 9.32771638e-02f, -1.54225770e-02f, 3.12999003e-02f, 3.55896191e-04f, 6.06009364e-02f, -4.83326279e-02f, -3.27356979e-02f, 2.05770805e-01f, 1.09366126e-01f,
  1.26374558e-01f, 4.28150855e-02f, -1.36560485e-01f, -1.27885625e-01f, 6.65275902e-02f, 8.06735978e-02f, 8.10578763e-02f, 2.69012451e-02f, 2.62145931e-03f, 1.66385129e-01f,
  1.22225180e-01f, 2.40984242e-02f, -1.09033316e-01f, 4.11629165e-03f, 1.21484436e-01f, -7.36867189e-02f, 5.10057854e-03f, -4.51439852e-03f, 4.56226133e-02f, -5.32310782e-03f,
  2.33532563e-01f, 6.67608622e-03f, 9.70680150e-04f, 6.82390407e-02f, 7.82380998e-03f, 9.41378400e-02f, -1.19737640e-01f, 1.79738402e-01f, 3.51108215e-03f, 1.59838259e-01f,
  -5.91020584e-02f, -4.92076576e-02f, -7.72777796e-02f, 1.94314290e-02f, -1.67189956e-01f, 1.45554483e-01f, -5.69292158e-02f, -7.31555969e-02f, -9.34337601e-02f, 1.81483030e-01f,
  -2.23362431e-01f, -5.77052124e-02f, -1.64213151e-01f, 2.36170292e-01f, -3.53054106e-01f, -3.83730121e-02f, -1.97749823e-01f, -6.94932267e-02f, -2.40067661e-01f, 3.50964874e-01f,
  5.43649718e-02f, 8.18419009e-02f, -4.65318114e-01f, 1.39605757e-02f, -8.88327658e-02f, 9.60185304e-02f, -5.46118207e-02f, -3.93089503e-02f, -9.00197104e-02f, -1.38641104e-01f,
  -2.24130936e-02f, 1.37620747e-01f, -2.91904714e-02f, -9.96480659e-02f, -7.83624873e-02f, 1.72142442e-02f, 1.90271527e-01f, 2.98876949e-02f, 1.30553067e-01f, 1.69941857e-01f,
  -4.58144350e-03f, -1.94568168e-02f, -1.38968632e-01f, -5.00759892e-02f, 1.08735487e-01f, 6.87666684e-02f, 4.34058122e-02f, 9.04801339e-02f, 4.01074253e-02f, -9.86581296e-02f,
  -1.14678331e-01f, 3.41549963e-02f, -9.73377004e-02f, 1.78136364e-01f, 1.94116198e-02f, -7.55316541e-02f, -8.77861604e-02f, -1.40103042e-01f, 1.42571330e-01f, 3.11598033e-01f,
  -8.91708061e-02f, 3.83992717e-02f, 1.07609354e-01f, 3.10189370e-02f, -1.32711381e-01f, -6.89207017e-02f, 1.87955841e-01f, -9.51451659e-02f, -1.82911023e-01f, -2.56125093e-01f,
  -2.01687470e-01f, -1.05453327e-01f, -9.85779837e-02f, -2.48445615e-01f, 1.41830638e-01f, -1.08555391e-01f, 7.53663853e-02f, 8.99969693e-03f, 1.02873713e-01f, -7.40063563e-02f,
  1.06418453e-01f, -2.97679212e-02f, 6.22345172e-02f, -2.55243421e-01f, -8.61617699e-02f, 1.67507648e-01f, -1.29134983e-01f, 2.36269146e-01f, 6.66534454e-02f, 2.29293015e-03f,
  4.71618585e-02f, -4.15315032e-02f, 2.47483235e-02f, 1.05709068e-01f, 6.23500347e-02f, -9.85017270e-02f, -5.62259667e-02f, 4.57385108e-02f, -3.39680873e-02f, 5.21382391e-02f,
  -1.95149016e-02f, -1.07459530e-01f, 5.96873313e-02f, -2.01915801e-01f, -3.42767034e-03f, 7.49468580e-02f, -5.38123138e-02f, -5.63940145e-02f, -1.28808782e-01f, 5.36993183e-02f,
  1.28219444e-02f, -1.37374476e-01f, -3.74901411e-03f, -4.38443720e-02f, 3.76467220e-02f, 2.24976428e-03f, -2.54459113e-01f, 5.03074415e-02f, -1.38785064e-01f, -3.01986724e-01f,
  -7.05547258e-02f, -1.88744232e-01f, -2.80801002e-02f, -1.73937052e-01f, 1.70967672e-02f, -2.37492576e-01f, -2.25186795e-01f, -9.19665620e-02f, 2.41992995e-01f, -1.27654031e-01f,
  9.91581529e-02f, -2.39477068e-01f, 8.39449242e-02f, 9.31351781e-02f, 2.12833241e-01f, -2.79411942e-01f, -1.61563858e-01f, -7.69031346e-02f, 2.08107457e-01f, -2.03001842e-01f,
  -6.53867982e-03f, -7.13306665e-02f, 1.66053563e-01f, -2.10908517e-01f, 3.14290039e-02f, 3.88526410e-01f, -1.24672674e-01f, -2.41111711e-01f, 3.57170850e-02f, 1.89011157e-01f,
  -1.95130810e-01f, 2.41002534e-02f, -8.42682179e-03f, 1.25202714e-02f, 4.68786508e-02f, -3.59388930e-03f, 2.02495411e-01f, -2.21615598e-01f, 5.51025718e-02f, 2.35363599e-02f,
  1.28583431e-01f, -2.84318719e-03f, 5.88817000e-02f, 1.32350519e-01f, -7.10516423e-02f, 1.35973096e-02f, -1.09208472e-01f, -4.99857739e-02f, 7.94473663e-02f, 1.49595693e-01f,
  -3.26069921e-01f, -7.45917410e-02f, 2.34868098e-02f, -2.44491119e-02f, 1.30447984e-01f, 4.19526920e-03f, -2.15060189e-02f, 1.08183846e-01f, -9.02982503e-02f, -1.94953263e-01f,
  -3.53895165e-02f, 1.28486007e-01f, 2.31174633e-01f, 1.89044233e-02f, -4.10346240e-02f, -1.52831497e-02f, -2.99263336e-02f, 3.65838498e-01f, -7.03509077e-02f, 1.36586810e-02f,
  -6.18024915e-02f, 2.57987291e-01f, -2.88091540e-01f, 1.03609562e-01f, -1.72115993e-02f, -2.43657567e-02f, 2.28913903e-01f, 7.75327310e-02f, 1.00643426e-01f, -1.95190385e-01f,
  -6.82418421e-02f, 1.82664871e-01f, -5.10572121e-02f, -5.91596104e-02f, -1.26052320e-01f, 1.45564422e-01f, -8.17243457e-02f, 1.12026513e-01f, -6.68766424e-02f, -2.46586189e-01f,
  -2.81578332e-01f, -3.02340001e-01f, -2.47153744e-01f, -1.39880599e-02f, -1.67610064e-01f, 2.12772861e-01f, 7.94335529e-02f, -1.49461940e-01f, 8.18992630e-02f, -5.74647821e-02f,
  -5.93768507e-02f, -1.72478572e-01f, 1.33145735e-01f, 1.38958529e-01f, -1.27354125e-02f, 6.59001991e-02f, -5.29320240e-02f, -2.05010310e-01f, 2.07639840e-02f, 7.91946873e-02f,
  -4.97885160e-02f, 1.00447156e-01f, 4.58648354e-02f, -8.00099131e-03f, -3.17963213e-02f, 1.44347146e-01f, 2.96937227e-01f, 1.07829437e-01f, -1.56764597e-01f, 1.43718496e-01f,
  2.13319762e-03f, -5.35936318e-02f, 8.61871988e-02f, 9.59293321e-02f, 1.01674564e-01f, -1.60319939e-01f, -1.93866551e-01f, 3.18665579e-02f, 8.64230990e-02f, -2.89228503e-02f,
  -3.83247174e-02f, 4.09855694e-02f, 7.04350844e-02f, 2.25951210e-01f, 7.24757463e-02f, 1.75042283e-02f, -1.05032563e-01f, 1.14295118e-01f, -7.35171661e-02f, 1.47060916e-01f,
  1.48116693e-01f, 7.91507494e-03f, -1.32200748e-01f, 1.66156083e-01f, 9.25834700e-02f, -1.34573445e-01f, -1.16255216e-01f, -3.47334184e-02f, -1.08223654e-01f, 1.59503922e-01f,
  -4.83950339e-02f, 2.40825400e-01f, -4.53573242e-02f, -2.01745436e-01f, 1.79498896e-01f, -1.44148409e-01f, 1.79345578e-01f, -1.33832455e-01f, 1.90336779e-01f, 3.65780629e-02f,
  7.69400820e-02f, 1.73631590e-02f, -6.94765151e-03f, -6.27154484e-02f, -9.70769208e-03f, -1.44336313e-01f, -5.35539016e-02f, 1.29442304e-01f, -1.35301620e-01f, 3.80362198e-02f,
  3.65920626e-02f, 6.48719370e-02f, -5.75469546e-02f, 1.32376868e-02f, 7.01105455e-03f, -7.26948259e-03f, -1.73538581e-01f, -1.26070378e-03f, -2.05083117e-01f, -3.25054005e-02f,
  -2.08412871e-01f, 1.38223944e-02f, -4.69205752e-02f, -2.01972082e-01f, -1.24565952e-01f, -6.52235746e-02f, -7.66750425e-04f, 1.50345162e-01f, -6.51152506e-02f, 1.84782922e-01f,
  -1.94975212e-01f, 9.49029252e-02f, -3.06018200e-02f, -3.04523379e-01f, -2.06014633e-01f, -9.05851796e-02f, 1.01143025e-01f, 6.90070987e-02f, 8.34777777e-04f, -1.69787437e-01f,
  1.42758906e-01f, -2.58054942e-01f, 8.33586138e-03f, -9.62122083e-02f, -2.72456884e-01f, -1.25372976e-01f, -6.20476063e-03f, -3.05702060e-01f, 7.43499324e-02f, -2.39766330e-01f,
  1.66177332e-01f, 8.85228962e-02f, 9.04833432e-03f, -3.62115353e-02f, -4.74964529e-02f, -5.72108179e-02f, -5.14780022e-02f, 8.54905173e-02f, 3.25459242e-01f, -1.34629145e-01f,
  -2.63368279e-01f, -1.72436506e-01f, 1.81482747e-01f, 2.08495557e-01f, -3.38655934e-02f, 1.94112822e-01f, 1.29755393e-01f, 2.69318148e-02f, 7.02753142e-02f, -1.87538117e-01f,
  -4.59697470e-02f, 1.32631706e-02f, -1.38714379e-02f, -3.73580828e-02f, -2.22809240e-01f, 2.06005067e-01f, 5.23348413e-02f, 7.50875995e-02f, 1.73965216e-01f, 6.21111915e-02f,
  -2.66872011e-02f, -2.76543462e-04f, -1.74299940e-01f, 5.27665168e-02f, 2.28564963e-01f, 1.06496543e-01f, 9.16414112e-02f, 5.59457056e-02f, -5.61639629e-02f, 1.36304066e-01f,
  -1.88176185e-01f, -1.60745174e-01f, -2.03579038e-01f, 2.37307802e-01f, 1.76075950e-01f, -4.00958583e-02f, 1.11272810e-02f, -2.18814880e-01f, -9.67531092e-03f, 3.92286181e-01f,
  -1.99014563e-02f, 2.92997975e-02f, 6.10918999e-02f, 7.59761482e-02f, -1.61201119e-01f, 6.88352734e-02f, -1.13608595e-02f, -2.95155216e-02f, -4.09885310e-02f, -6.62342012e-02f,
  -1.62947372e-01f, -1.99189365e-01f, -7.09360838e-02f, -5.68448119e-02f, -2.91664619e-02f, -1.49145663e-01f, 2.83068538e-01f, 2.02033624e-01f, -3.05102188e-02f, -1.74031809e-01f,
  8.35090578e-02f, -5.53629920e-02f, -1.57580778e-01f, -1.49967670e-01f, 2.33756244e-01f, 2.34433576e-01f, -4.45243157e-02f, 2.86191851e-01f, 1.04316138e-01f, -3.91244106e-02f,
  1.07018039e-01f, 8.67558047e-02f, 4.83207963e-02f, -5.74148223e-02f, -1.11495676e-02f, 3.02365869e-02f, 1.64824992e-01f, 3.68015319e-02f, -5.59010580e-02f, 2.25144513e-02f,
  8.36263821e-02f, 4.90085632e-02f, 1.41923398e-01f, 3.10106296e-02f, 1.62844285e-01f, -3.10004428e-02f, 8.12750533e-02f, -1.43389422e-02f, -4.71993275e-02f, 2.42578715e-01f,
  -4.18067956e-03f, 8.62533078e-02f, 1.75473392e-01f, 6.65544793e-02f, -1.76049158e-01f, -2.35141426e-01f, -2.50866532e-01f, 7.40669072e-02f, 1.57933727e-01f, -2.17442047e-02f,
  2.69114692e-02f, -7.15756491e-02f, 1.74436718e-01f, 3.67442757e-01f, 1.87939610e-02f, 1.02930963e-01f, 5.55622764e-02f, 5.11777885e-02f, -5.84701262e-02f, 1.78388916e-02f,
  3.24991681e-02f, 2.39949860e-02f, 3.48925948e-01f, 3.25313136e-02f, 3.93674634e-02f, -1.88010186e-01f, -1.26686066e-01f, -7.66101331e-02f, 2.01572955e-01f, 9.92533341e-02f,
  1.16391413e-01f, 3.13102454e-01f, -4.13289741e-02f, 8.47528502e-02f, 7.20587820e-02f, -2.63147086e-01f, 6.93517029e-02f, -3.98057163e-01f, 6.52619079e-02f, 2.26919144e-01f,
  1.06041931e-01f, 2.43206397e-01f, -1.23874389e-01f, 1.24701122e-02f, 3.72687392e-02f, 1.87803134e-02f, 7.82668218e-02f, 6.14177957e-02f, -9.41917207e-03f, 9.18407738e-02f,
  1.90762505e-02f, -3.45480889e-02f, 1.58917412e-01f, 1.07142799e-01f, 2.12160442e-02f, -5.93001507e-02f, -6.21455833e-02f, 4.64031361e-02f, 2.43480559e-02f, -6.94642588e-02f,
  -1.43558621e-01f, -1.18827142e-01f, -2.34506447e-02f, -5.82998246e-02f, 9.14172530e-02f, 9.16519389e-03f, 5.95895313e-02f, 6.48245662e-02f, 8.39071274e-02f, -1.00736953e-01f,
  -9.48097482e-02f, 1.46583557e-01f, -1.27223462e-01f, -6.34913817e-02f, -3.95460203e-02f, -1.97733399e-02f, 1.60777383e-02f, -1.32707447e-01f, 3.64495777e-02f, -2.36460075e-01f,
  1.87784601e-02f, 8.38906839e-02f, 1.11042403e-01f, -8.73388052e-02f, 4.93352488e-03f, -2.18516048e-02f, -2.18313932e-01f, -7.91734736e-03f, 8.88695270e-02f, 5.03919944e-02f,
  3.55464108e-02f, -9.82685760e-02f, -1.39097854e-01f, -1.96677640e-01f, -3.72204818e-02f, -5.58964722e-02f, 2.36753654e-02f, -1.70942262e-01f, 1.19627602e-01f, 2.34766170e-01f,
  2.80630916e-01f, 2.99701677e-03f, -1.34202853e-01f, 1.13852685e-02f, -7.09292144e-02f, -2.28324831e-01f, 6.40860721e-02f, -6.64352551e-02f, -5.06196134e-02f, -8.49843174e-02f,
  -1.15482546e-01f, 1.00155979e-01f, -1.00368418e-01f, -1.73380435e-01f, -4.06662188e-02f, 1.60620883e-01f, -2.62088911e-03f, -3.01521625e-02f, 5.66185489e-02f, -4.25805748e-02f,
  -1.62491873e-01f, -3.64991389e-02f, 1.02656089e-01f, 4.96554039e-02f, 1.05550736e-01f, 4.83109653e-02f, -3.64088789e-02f, 9.15937778e-03f, 3.19886468e-02f, -7.27648735e-02f,
  -1.34812728e-01f, 8.61889571e-02f, -2.60821860e-02f, -6.78673759e-02f, 8.77800658e-02f, -1.36829495e-01f, 2.34411746e-01f, -6.00457285e-03f, -2.70804092e-02f, 1.46043852e-01f,
  1.09015241e-01f, -1.26436800e-01f, 7.31505156e-02f, -2.03626171e-01f, -1.22977242e-01f, -8.72235000e-02f, 7.43494108e-02f, 4.19869535e-02f, -1.48672253e-01f, -1.48754925e-01f,
  1.26189753e-01f, 5.35983518e-02f, 8.40242580e-02f, -4.79380041e-03f, 3.28586251e-02f, 4.24296223e-02f, -1.48649782e-01f, 1.48246169e-01f, -1.11696094e-01f, -1.50589168e-01f,
  -1.06390871e-01f, -3.23619068e-01f, 9.09462422e-02f, -4.08507651e-03f, -2.70385087e-01f, -4.17496599e-02f, -2.79955328e-01f, -2.01603383e-01f, -1.54979587e-01f, -2.12791875e-01f
};

// L1_fan_Wp_bar (Shape: 14 x 64)
const int L1_fan_Wp_bar_rows = 14;
const int L1_fan_Wp_bar_cols = 64;
const float L1_fan_Wp_bar_data[] = {
  1.33447334e-01f, 2.03935608e-01f, 7.45434314e-02f, 1.42880425e-01f, -4.53951284e-02f, -1.73748925e-01f, 1.14069730e-01f, -5.21244183e-02f, 3.52282785e-02f, -1.69450700e-01f,
  -4.91329059e-02f, 1.38981491e-01f, 3.82831739e-03f, 2.02214405e-01f, -1.37657933e-02f, 1.32124841e-01f, 1.11919396e-01f, 1.27240613e-01f, -2.06202921e-02f, 3.21008980e-01f,
  9.01290402e-02f, 6.64205849e-02f, 5.13254143e-02f, 1.77232716e-02f, 1.18247578e-02f, -7.40090981e-02f, 2.96750981e-02f, 1.91392414e-02f, 1.21362709e-01f, 2.95604998e-03f,
  -1.39594272e-01f, 2.01685615e-02f, -6.12114929e-02f, -9.97449830e-02f, -1.83283210e-01f, 1.03163116e-01f, 3.67663875e-02f, 3.18899453e-01f, 8.57527256e-02f, 8.50178972e-02f,
  -1.53369963e-01f, 2.82419622e-02f, -4.95062955e-02f, 6.81911856e-02f, 5.41258216e-01f, 9.46722999e-02f, -1.30913883e-01f, 2.08211914e-02f, 3.56135853e-02f, -1.36338070e-01f,
  2.69094054e-02f, 1.40724018e-01f, 8.48204643e-02f, 1.24087289e-01f, 1.29430011e-01f, -2.08221320e-02f, 2.51045763e-01f, -4.72209692e-01f, 1.97858587e-01f, 3.78252715e-02f,
  -1.18821319e-02f, -1.54259533e-01f, 5.32160878e-01f, -1.91686451e-01f, -1.30713228e-02f, -4.43601655e-03f, 1.11285761e-01f, -4.33631763e-02f, -1.40738577e-01f, -9.56651196e-03f,
  1.98425576e-02f, 3.21653076e-02f, 4.75547686e-02f, 6.81812242e-02f, -2.35597081e-02f, 3.08530722e-02f, -2.26119496e-02f, 1.93001270e-01f, 1.38675213e-01f, 6.71827197e-02f,
  2.28294358e-02f, 4.93187271e-02f, -2.66827792e-01f, -1.68549910e-01f, -1.25807431e-02f, -1.58626791e-02f, -9.77098197e-02f, -2.38393545e-02f, 1.14850722e-01f, -4.58102114e-02f,
  -2.06045583e-01f, -4.60063890e-02f, -1.50487155e-01f, 6.60512298e-02f, 1.55796543e-01f, -1.09761469e-01f, 4.77914512e-02f, -1.64473325e-01f, 9.28403884e-02f, 3.73188347e-01f,
  -5.40890582e-02f, -2.10934982e-01f, -1.62034780e-01f, 6.73761740e-02f, 1.99734978e-02f, 1.30020559e-01f, -4.76094894e-02f, -5.68149276e-02f, 1.47305569e-02f, 3.79802100e-02f,
  1.38300464e-01f, -3.62740876e-03f, -6.56367391e-02f, -5.94650395e-02f, 1.94373634e-02f, 2.01633066e-01f, 2.24610731e-01f, 2.65035182e-01f, -4.28353101e-01f, -1.76940247e-01f,
  -2.07914591e-01f, 1.35303080e-01f, -2.72818148e-01f, 1.61059983e-02f, 2.24047810e-01f, 1.81085750e-01f, 5.14128730e-02f, 3.24431866e-01f, 2.49634758e-01f, -2.65499167e-02f,
  1.66891456e-01f, 1.16086617e-01f, 1.48872837e-01f, -3.85854021e-02f, 9.93097201e-02f, -4.33796225e-03f, 1.13347940e-01f, -1.39559582e-01f, 1.46016013e-02f, 9.65696350e-02f,
  -6.67404160e-02f, 2.29146779e-01f, 1.27757728e-01f, 9.27866548e-02f, 9.04506817e-02f, 1.44711025e-02f, -7.32756853e-02f, -4.07389514e-02f, 1.39217645e-01f, 2.62049288e-02f,
  -7.18228072e-02f, 1.92530766e-01f, 2.68160738e-02f, 5.43530807e-02f, -4.66878489e-02f, -1.27967536e-01f, 1.07475206e-01f, 9.60588008e-02f, 2.27024883e-01f, 4.27354462e-02f,
  9.69100669e-02f, 8.57416019e-02f, 1.76247701e-01f, 3.05980146e-01f, -5.73953316e-02f, 2.44103014e-01f, 8.64504185e-03f, 1.73758671e-01f, -2.27405474e-01f, 8.12187791e-02f,
  1.42309353e-01f, -6.47624210e-02f, 1.14848308e-01f, -3.11613083e-02f, -1.93448409e-01f, -2.43065119e-01f, -1.75364286e-01f, 1.53440177e-01f, -8.40592310e-02f, 1.75662003e-02f,
  7.27100531e-03f, 1.38508663e-01f, 5.97274816e-03f, 3.52380693e-01f, 1.71525553e-01f, -3.12898755e-01f, -1.48926497e-01f, -1.45182058e-01f, 2.43763298e-01f, 1.60381645e-01f,
  -3.15796435e-02f, 7.70966113e-02f, 7.22304657e-02f, 2.26869032e-01f, 1.00690024e-02f, 1.14077376e-02f, 5.77692874e-02f, 9.58796293e-02f, 4.16389928e-04f, 1.17414765e-01f,
  -1.68342646e-02f, 8.13883021e-02f, 6.57869726e-02f, 9.14645493e-02f, -1.32355869e-01f, 1.34919465e-01f, 3.01376998e-01f, 4.92400974e-02f, 9.96045917e-02f, 6.51985183e-02f,
  1.47716925e-01f, -5.91178872e-02f, 7.37869516e-02f, 1.03771478e-01f, 5.37977368e-02f, 1.09765967e-02f, -2.61184216e-01f, -2.53789067e-01f, 2.53869921e-01f, 1.84902057e-01f,
  2.38944814e-01f, -2.41065338e-01f, 1.30250946e-01f, 1.78110793e-01f, 1.59098804e-01f, 2.88358718e-01f, -1.44779667e-01f, -1.35983050e-01f, 1.18461447e-02f, -2.46331692e-02f,
  -1.05066665e-01f, -1.12143800e-01f, -1.43036470e-01f, -9.83714685e-03f, 4.36994173e-02f, -2.17786700e-01f, -3.00504297e-01f, -1.75327361e-01f, -3.57581049e-01f, 3.10404569e-01f,
  1.09505497e-01f, 3.06827098e-01f, -1.75904065e-01f, -2.13064805e-01f, 7.40170106e-02f, -2.49191359e-01f, -3.76458690e-02f, 3.85379903e-02f, 1.49262309e-01f, 1.23457253e-01f,
  -1.92859471e-01f, 3.30058962e-01f, -1.02063395e-01f, 1.06418550e-01f, -2.94850051e-01f, 7.26380721e-02f, -4.97170314e-02f, 1.84728913e-02f, -7.27470294e-02f, 2.24291876e-01f,
  9.55106840e-02f, 2.69493699e-01f, 7.15073571e-02f, -5.27783521e-02f, -3.57356332e-02f, 1.99877575e-01f, 1.26575798e-01f, 8.89723077e-02f, 2.54453123e-01f, -2.76866704e-02f,
  -7.98026249e-02f, 9.74497385e-03f, -1.14864267e-01f, -7.51677603e-02f, -5.86361252e-02f, -2.02654332e-01f, -1.74354956e-01f, 6.40191287e-02f, 5.91062009e-02f, -1.69739476e-04f,
  -8.06725472e-02f, -1.87825456e-01f, 6.56395704e-02f, 1.66329175e-01f, 1.23862639e-01f, -3.85745838e-02f, -2.53111511e-01f, -8.35534260e-02f, -8.26124568e-03f, 8.52191970e-02f,
  2.36008704e-01f, -5.92910238e-02f, -1.89000607e-01f, -1.30678460e-01f, -1.88629813e-02f, -1.29494175e-01f, -1.33902924e-02f, 1.37124598e-01f, -7.85463601e-02f, -3.90144140e-02f,
  -4.59665731e-02f, 1.85950529e-02f, -8.61062109e-02f, 1.28167734e-01f, 1.69695497e-01f, 9.86462906e-02f, 2.97404289e-01f, -1.42464221e-01f, 1.95721257e-02f, 4.68167327e-02f,
  3.92888971e-02f, -8.98110643e-02f, -1.16244197e-01f, 1.21126436e-02f, -8.49579722e-02f, -1.83712766e-01f, 4.48118970e-02f, 3.54091942e-01f, -1.33384410e-02f, 2.08674833e-01f,
  -1.07201710e-02f, 3.24244313e-02f, -5.00382148e-02f, 1.86093107e-01f, 1.42042205e-01f, 6.44816235e-02f, 3.81306484e-02f, -1.91082601e-02f, 1.15393735e-01f, 1.54144719e-01f,
  1.04698867e-01f, -1.47939250e-02f, 1.55708417e-01f, 6.11365698e-02f, -4.88645993e-02f, 1.06422573e-01f, -5.06566577e-02f, 8.07683393e-02f, 3.11240196e-01f, 9.68037546e-02f,
  -2.13081529e-03f, 1.80597231e-01f, 1.56346262e-01f, -9.48214307e-02f, 1.37626017e-02f, -1.05279796e-01f, -1.62758008e-01f, 1.38770357e-01f, -7.99272582e-02f, 1.29580572e-02f,
  -1.82145506e-01f, -1.15491107e-01f, -1.67508006e-01f, -3.11892360e-01f, -6.28442131e-03f, -9.43166390e-02f, 2.01715410e-01f, -3.40383202e-02f, -4.11441177e-02f, -2.20509976e-01f,
  4.01317894e-01f, 3.00051346e-02f, -8.94243736e-03f, -8.97886325e-03f, 3.54765318e-02f, -3.85971293e-02f, 1.70134574e-01f, 1.53425345e-02f, -1.99938625e-01f, -4.83030468e-01f,
  4.00444657e-01f, 4.65973802e-02f, 5.66692837e-02f, 9.62936878e-02f, 2.13091046e-01f, -9.14357603e-02f, -2.36072898e-01f, 2.84764115e-02f, 2.23863646e-01f, 9.81678367e-02f,
  1.02128461e-01f, -3.83805260e-02f, 3.44124794e-01f, -1.23038381e-01f, -6.05492108e-03f, 6.64617270e-02f, -1.13397971e-01f, 8.71573985e-02f, -3.16504352e-02f, 3.13420594e-02f,
  1.36579492e-03f, -1.14832230e-01f, 8.45210329e-02f, 1.17548279e-01f, -6.48823604e-02f, 7.95579422e-03f, 1.42118171e-01f, -1.12661690e-01f, 8.36292878e-02f, 4.77957986e-02f,
  -4.88247648e-02f, 5.97697534e-02f, -1.37088588e-02f, -6.15859479e-02f, -1.57254618e-02f, -2.38656122e-02f, 1.82056248e-01f, -8.90082270e-02f, 1.12720624e-01f, -1.59448430e-01f,
  -1.53535362e-02f, 2.11511061e-01f, -5.39072379e-02f, -1.61031961e-01f, -2.41376787e-01f, 8.49427432e-02f, -1.11910589e-01f, -1.61934987e-01f, 6.96051642e-02f, -2.53276639e-02f,
  -1.64598912e-01f, 3.06826700e-02f, -6.01990186e-02f, -2.59955078e-01f, 6.09751511e-03f, -1.37578249e-01f, 5.25329709e-02f, -1.05338715e-01f, -3.10622882e-02f, -1.12124465e-01f,
  1.40218198e-01f, -7.94201065e-03f, -6.76029474e-02f, -1.75466359e-01f, 1.40768975e-01f, -1.54014593e-02f, 1.52970359e-01f, 1.66962594e-01f, 2.19227195e-01f, -1.49139799e-02f,
  -2.19893292e-01f, 1.17133684e-01f, -2.53595203e-01f, -2.15887874e-01f, -1.36154920e-01f, 2.14575157e-01f, -9.90199447e-02f, 2.51405329e-01f, 3.25798467e-02f, -6.55842992e-03f,
  4.49789204e-02f, -5.43328337e-02f, -8.39244500e-02f, 6.98515922e-02f, 6.75813332e-02f, -7.25502381e-03f, 4.48635705e-02f, 6.69052452e-02f, 3.16951075e-03f, 2.54043788e-02f,
  -1.55741468e-01f, 2.45037512e-03f, 1.73097149e-01f, 1.23005159e-01f, -6.09517954e-02f, -4.41585556e-02f, 2.70634405e-02f, 1.29177839e-01f, 1.66640982e-01f, 1.26726404e-01f,
  -8.78270268e-02f, -2.96442676e-02f, 1.58783436e-01f, -6.86142072e-02f, 1.11012608e-01f, 2.14480683e-01f, -6.68480108e-03f, -4.70611490e-02f, -5.61055169e-02f, -3.74334008e-02f,
  1.79826036e-01f, -1.42103825e-02f, -2.60147661e-01f, -3.19842175e-02f, 2.50886362e-02f, -5.86617664e-02f, -1.46579340e-01f, -8.12251493e-02f, 5.34216166e-02f, -6.00125752e-02f,
  -1.85968354e-02f, 4.54339311e-02f, -1.71879351e-01f, -3.57870273e-02f, 1.24564022e-01f, 1.54470593e-01f, 7.40498528e-02f, 7.92406052e-02f, -3.51472646e-01f, -5.75704277e-02f,
  8.11640024e-02f, -9.85122174e-02f, 3.25547040e-01f, -3.79701197e-01f, 1.58353224e-01f, 2.01098919e-01f, 2.53799617e-01f, 3.83718669e-01f, -4.10354912e-01f, -3.75024259e-01f,
  1.25551922e-02f, -6.34626523e-02f, 1.10226080e-01f, 9.60739478e-02f, 4.53807153e-02f, -1.33258924e-01f, -3.37791517e-02f, 4.71496135e-01f, 6.94118366e-02f, -6.52025342e-02f,
  -9.79209542e-02f, 1.33855954e-01f, 3.26395690e-01f, 5.99649772e-02f, 1.43230625e-03f, 1.25299603e-01f, 2.33395696e-01f, -6.29992262e-02f, 1.31681934e-01f, 2.56056428e-01f,
  1.16303518e-01f, -6.10729307e-02f, 8.15409943e-02f, -7.77124539e-02f, 2.07168937e-01f, 1.31536141e-01f, -1.07103765e-01f, 2.18376279e-01f, 2.75365770e-01f, -2.43628010e-01f,
  -2.83208281e-01f, -4.93217707e-02f, -6.29071565e-03f, -4.16415818e-02f, 3.10514700e-02f, 3.58426452e-01f, 1.03565782e-01f, -1.85348228e-01f, -8.33031759e-02f, -4.71490204e-01f,
  7.55971894e-02f, -3.02322619e-02f, -9.15916860e-02f, 2.12392479e-01f, 1.03725262e-01f, -1.13250598e-01f, 6.25037104e-02f, 1.38081521e-01f, 1.43130854e-01f, 1.46507531e-01f,
  1.99793056e-01f, 4.85006273e-01f, -8.92136097e-02f, -4.90501933e-02f, -9.14069265e-02f, -1.66965444e-02f, -1.93031117e-01f, -5.46134934e-02f, -5.17062135e-02f, 3.81592125e-01f,
  -3.31110835e-01f, -3.08821406e-02f, -1.13743626e-01f, 1.73003331e-01f, -1.36993587e-01f, 2.77601153e-01f, 2.33050101e-02f, 1.15359269e-01f, 2.17452630e-01f, 2.95102239e-01f,
  9.79095250e-02f, 1.88505441e-01f, 2.19724581e-01f, 8.04476365e-02f, -8.11527073e-02f, -2.91098684e-01f, 1.44032389e-01f, 1.08064115e-01f, 2.01245606e-01f, 1.04478955e-01f,
  8.39404315e-02f, 3.39092016e-02f, 2.14402691e-01f, 5.55095039e-02f, -6.27367795e-02f, 6.28166944e-02f, 1.45917922e-01f, 2.79159006e-02f, 2.09234819e-01f, 1.69707850e-01f,
  3.62447314e-02f, -3.48494053e-01f, 8.16501528e-02f, 8.54311809e-02f, 1.78575099e-01f, -6.02832176e-02f, 1.77388206e-01f, 2.29890645e-01f, -7.33226463e-02f, 1.88235655e-01f,
  2.12778404e-01f, 7.02604055e-02f, -2.08708689e-01f, -6.88418970e-02f, 2.50607342e-01f, 7.46220425e-02f, -3.63508075e-01f, 5.39380778e-03f, 1.98437810e-01f, -2.16126174e-01f,
  -3.40144932e-01f, -5.12056828e-01f, -6.73895657e-01f, 6.20066114e-02f, 5.19071631e-02f, 2.41120830e-01f, 2.33010262e-01f, -3.36368501e-01f, 7.82381743e-02f, -9.22084600e-02f,
  6.34023696e-02f, 1.33014828e-01f, -1.83131129e-01f, -7.91625455e-02f, 2.10538641e-01f, -6.07142337e-02f, 2.59612530e-01f, 1.38790131e-01f, 5.30542657e-02f, 6.45708665e-02f,
  -6.53986558e-02f, 1.34627566e-01f, 1.06817804e-01f, 8.17433372e-03f, 1.28140301e-01f, 3.35461974e-01f, -4.06198390e-02f, 2.18358114e-02f, -1.31543502e-01f, 8.33628476e-02f,
  1.09117694e-01f, 1.68621764e-01f, 1.65383458e-01f, 2.18129233e-02f, 1.34741500e-01f, 7.54422843e-02f, 4.55490276e-02f, 8.23312327e-02f, -9.82578006e-03f, -4.70038690e-03f,
  -1.12248734e-01f, 7.75838345e-02f, 1.79225847e-01f, 5.01249917e-02f, -1.32464990e-01f, -3.31469588e-02f, -1.16943873e-01f, 9.62590501e-02f, -3.14656287e-01f, -1.86104774e-02f,
  1.94199264e-01f, -1.78690881e-01f, 1.33267492e-01f, -1.45317301e-01f, -2.54703276e-02f, 5.26947640e-02f, 1.85340196e-01f, -3.44254076e-01f, -1.17122047e-01f, -2.03575213e-02f,
  3.06834131e-01f, -2.77298272e-01f, 2.36187071e-01f, -3.72108936e-01f, -2.55053401e-01f, -2.76936330e-02f, 2.79960543e-01f, -3.15707237e-01f, -7.30477925e-03f, -6.92741573e-02f,
  1.97156817e-01f, -3.38707924e-01f, 9.86375064e-02f, -4.05037180e-02f, -1.20331720e-01f, -2.18110323e-01f, -5.21280989e-02f, 4.06242937e-01f, -1.99502289e-01f, -6.86775222e-02f,
  -1.56792924e-01f, -5.66915097e-03f, -2.33385637e-01f, 1.08184665e-01f, 6.10495619e-02f, -3.49231482e-01f, -1.15372054e-01f, -3.50766792e-03f, -3.21085490e-02f, 3.19631159e-01f,
  2.33213320e-01f, -1.66400865e-01f, 8.45718011e-03f, 1.85625136e-01f, 3.30757320e-01f, -1.77234337e-02f, 2.43266486e-02f, -5.44098876e-02f, -2.35220283e-01f, -5.81001975e-02f,
  9.92377251e-02f, -6.02805130e-02f, -1.45163894e-01f, -1.35072963e-02f, 1.77169610e-02f, -1.90326884e-01f, 2.65152175e-02f, 3.25751714e-02f, -1.44774303e-01f, 7.54620582e-02f,
  2.07897335e-01f, 4.14807722e-03f, 3.04041449e-02f, -3.21574509e-02f, -2.33639047e-01f, -2.50300076e-02f, 1.75770059e-01f, 1.30459011e-01f, 2.19455082e-03f, -3.18497866e-01f,
  -5.87677956e-02f, -9.55858603e-02f, -2.41132025e-02f, -6.00475334e-02f, -2.36759350e-01f, 2.05840155e-01f, -1.91367462e-01f, 3.77913445e-01f, 1.22970924e-01f, 4.18565094e-01f,
  3.40777189e-01f, 2.96911776e-01f, 1.57519206e-01f, 1.20083228e-01f, -3.99066210e-01f, -5.84963933e-02f, -3.24154228e-01f, 2.63650641e-02f, -1.00895651e-01f, -1.59754202e-01f,
  -5.08731008e-02f, 2.58415733e-02f, -2.13609263e-01f, -1.73569217e-01f, 2.06462398e-01f, -3.72163624e-01f, 2.02392954e-02f, -1.26239628e-01f, 2.05884501e-02f, 1.23041660e-01f,
  1.03999838e-01f, 1.08802497e-01f, 7.47480569e-03f, 4.46547084e-02f, 1.27600580e-01f, 6.87422752e-02f, 8.74373317e-02f, -1.57523543e-01f, 1.68886539e-02f, 1.59633644e-02f,
  1.13158822e-01f, 6.94695115e-02f, 3.07217948e-02f, 1.35841757e-01f, -4.25278805e-02f, 5.71151190e-02f, -1.18357493e-02f, -1.57729417e-01f, -4.38898243e-02f, 5.82346171e-02f,
  5.17066866e-02f, 1.19863652e-01f, 1.96625754e-01f, -4.83104065e-02f, 1.05394600e-02f, 5.51296659e-02f, -3.54544856e-02f, -9.82921049e-02f, -3.83210331e-02f, 1.85962602e-01f,
  4.18628603e-02f, -1.45269379e-01f, 2.31662244e-02f, 2.65118420e-01f, -2.20236063e-01f, 2.67293781e-01f, 1.43507481e-01f, 6.83023110e-02f, -2.55456924e-01f, -2.32037604e-01f,
  2.42174804e-01f, 1.12976566e-01f, 2.76213363e-02f, -2.77063996e-01f, -1.64359406e-01f, -1.94896966e-01f, 9.63454843e-02f, 4.75771651e-02f, 1.81883991e-01f, -6.33601174e-02f,
  -1.48150576e-02f, 7.60605261e-02f, 1.34470463e-01f, 3.46429735e-01f, -7.68841952e-02f, 1.07874528e-01f, 9.01887752e-03f, -7.35649541e-02f, 2.53673643e-01f, 3.27744097e-01f,
  6.06862679e-02f, 1.14493206e-01f, 4.61047925e-02f, 6.41317144e-02f, -5.18581569e-02f, -5.37025332e-02f, 8.58425871e-02f, 2.61899233e-02f, 1.48223549e-01f, 1.53131083e-01f,
  -1.22704789e-01f, 1.57949962e-02f, -4.06671874e-02f, 1.10466316e-01f, 2.47488096e-02f, 1.14753582e-01f, 4.11078706e-02f, -1.19363546e-01f, -3.74020450e-02f, 1.19141629e-03f,
  -8.93326197e-03f, 3.50341536e-02f, 1.24525195e-02f, -3.01266182e-02f, -2.99319602e-03f, 6.45123497e-02f, 6.26155660e-02f, -7.13104755e-02f, 4.54791114e-02f, 9.45104565e-03f,
  -2.09491119e-01f, 1.82407573e-01f, -7.61069059e-02f, 2.23638602e-02f, 1.69209898e-01f, -4.66852635e-02f, -2.62421995e-01f, -3.33824232e-02f, -1.16049126e-01f, -7.21585518e-03f,
  -2.46147793e-02f, -5.05936369e-02f, 1.29005983e-01f, -1.02482274e-01f, -9.61100906e-02f, -1.18789554e-01f, -2.50178367e-01f, 1.56239178e-02f, 3.50959308e-04f, -1.73429936e-01f,
  8.38112608e-02f, 3.11422553e-02f, -3.08425963e-01f, 1.44557551e-01f, 2.52542235e-02f, -1.87147439e-01f, -1.88344382e-02f, -3.26638907e-01f, -1.31402716e-01f, 9.37634557e-02f,
  1.72662243e-01f, 1.96623817e-01f, -3.82238477e-01f, -3.34513754e-01f, 2.66679287e-01f, -1.56916440e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 14)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 14;
const float L1_fan_Bp_bar_data[] = {
  -9.08213779e-02f, 1.31631056e-02f, 4.89052339e-03f, 1.49164096e-01f, 1.88423201e-01f, 6.62915558e-02f, 6.20638579e-02f, 7.48674795e-02f, 4.43092622e-02f, 9.35683958e-03f,
  1.10219240e-01f, -3.20325531e-02f, 5.59815578e-02f, 1.40794143e-01f
};

// L2_fan_Wp (Shape: 25 x 64)
const int L2_fan_Wp_rows = 25;
const int L2_fan_Wp_cols = 64;
const float L2_fan_Wp_data[] = {
  -1.31465182e-01f, -1.21035449e-01f, -5.18568903e-02f, 1.25885746e-02f, -8.84743929e-02f, 9.93679930e-03f, 6.15814626e-02f, -1.49790093e-01f, 2.59945661e-01f, -4.48914664e-03f,
  -1.52371258e-01f, -9.83365402e-02f, -2.74770409e-02f, 1.02037013e-01f, -1.07782193e-01f, -6.06478564e-02f, -8.89629796e-02f, -1.00877970e-01f, -6.28637001e-02f, -4.66274954e-02f,
  1.52714670e-01f, -4.61208485e-02f, 1.48613647e-01f, 8.47999472e-03f, -8.52535963e-02f, 1.11442991e-02f, -4.74488828e-03f, 2.42823243e-01f, -7.42902756e-02f, 4.33303192e-02f,
  -1.82329699e-01f, -1.25146016e-01f, 1.56436816e-01f, 8.27757716e-02f, -5.68188205e-02f, -1.98415313e-02f, 4.67604995e-02f, -7.08399266e-02f, -1.95444271e-01f, -1.27086207e-01f,
  9.11480263e-02f, -5.48134595e-02f, 2.74591502e-02f, -1.63322151e-01f, -1.92807391e-01f, 2.74783134e-01f, 8.62248242e-02f, -2.37539485e-01f, 3.78407389e-01f, 2.46349141e-01f,
  3.15074116e-01f, -2.43301094e-01f, -1.08102284e-01f, 2.27512732e-01f, -1.82751045e-01f, -8.61663371e-02f, -1.15565591e-01f, 1.42718107e-01f, -8.33251998e-02f, -2.03999922e-01f,
  -1.97057705e-03f, -7.27831125e-02f, -1.10940225e-01f, 3.73767555e-01f, -3.49815726e-01f, 1.53158093e-02f, -2.05824226e-01f, -1.48066923e-01f, -3.32713849e-03f, 7.38339648e-02f,
  1.65965762e-02f, 3.51777792e-01f, -2.02875003e-01f, -7.37028569e-03f, -8.77626315e-02f, 1.57785013e-01f, 2.35253405e-02f, 3.23322594e-01f, -7.20862241e-04f, 1.13273943e-02f,
  1.71593294e-01f, 9.19947997e-02f, -1.19219065e-01f, -1.57301411e-01f, 1.19175404e-01f, 6.72643259e-02f, -2.44070843e-01f, 2.50475675e-01f, -2.28773817e-01f, -1.78520396e-01f,
  -5.79797663e-02f, 1.22853413e-01f, 1.88944384e-01f, 8.05127844e-02f, -1.02413811e-01f, -9.25129503e-02f, 5.05225509e-02f, 1.00175053e-01f, 1.28811151e-02f, -2.79378921e-01f,
  -5.27342483e-02f, -4.94554751e-02f, 4.60456051e-02f, -3.67052518e-02f, 1.47484034e-01f, 2.85474043e-02f, -2.12309152e-01f, 2.14897454e-01f, 3.90487239e-02f, 1.97680481e-02f,
  -1.77387506e-01f, -7.68532977e-02f, -2.82704502e-01f, 1.16804488e-01f, -3.78132202e-02f, -5.27895987e-03f, 6.27167150e-02f, -1.33382797e-01f, -2.30624855e-01f, 7.42402747e-02f,
  -8.73806849e-02f, -1.01465449e-01f, -3.21879864e-01f, -1.31312788e-01f, -2.72980899e-01f, -6.25261292e-02f, -1.32300436e-01f, -1.36828125e-01f, -1.39623508e-01f, 1.58061951e-01f,
  -1.50121853e-01f, 1.62467450e-01f, 6.14390373e-02f, 8.37334841e-02f, -1.14215136e-01f, 7.13664480e-03f, -8.52784287e-05f, -5.03303483e-02f, 6.58117831e-02f, 3.80004272e-02f,
  -4.35452089e-02f, -5.76457679e-02f, 1.09668441e-01f, 2.45711301e-02f, 1.08542114e-01f, -1.39667884e-01f, -1.26430690e-01f, 7.52652735e-02f, 2.07873881e-01f, 5.29264137e-02f,
  -1.45681009e-01f, -2.72090803e-03f, -5.08250110e-02f, 5.51142655e-02f, -8.64185020e-02f, 1.75852880e-01f, -6.79618642e-02f, 1.56603515e-01f, -2.99412441e-02f, 2.82240748e-01f,
  -5.56314699e-02f, -1.91197634e-01f, -1.25269786e-01f, -2.36836761e-01f, -9.94339436e-02f, 1.94471180e-01f, 2.88761854e-01f, 3.27291340e-02f, 9.60739926e-02f, -1.19357005e-01f,
  1.53916087e-02f, 1.38963461e-02f, 1.55761719e-01f, -6.37511238e-02f, -1.99833706e-01f, -2.85178293e-02f, -6.44990355e-02f, 2.19744042e-01f, -4.79531065e-02f, -2.78711319e-01f,
  -6.45227358e-02f, -2.22367491e-03f, -2.72485346e-01f, -1.42909922e-02f, -1.15659080e-01f, 1.93718091e-01f, 2.21607029e-01f, -2.79989898e-01f, -6.66765645e-02f, 1.36921154e-02f,
  -1.29658327e-01f, -2.22260252e-01f, 4.15284373e-03f, -1.59606948e-01f, -1.54138565e-01f, 2.62896329e-01f, 6.12213053e-02f, 8.56923461e-02f, -1.37758255e-01f, -7.12803528e-02f,
  -3.19061168e-02f, 1.27634907e-03f, -1.47110283e-01f, -3.85868363e-02f, -1.23701796e-01f, -1.45225879e-02f, 3.14974785e-02f, 1.45490076e-02f, -6.90102875e-02f, -1.67656198e-01f,
  2.49200374e-01f, 1.45456374e-01f, 2.11193338e-01f, 1.21953912e-01f, 1.28464714e-01f, 1.83929905e-01f, -2.13181362e-01f, -1.61374703e-01f, -1.48338035e-01f, 3.64540130e-01f,
  -3.97013754e-01f, -1.27475053e-01f, 1.66306287e-01f, 3.29684228e-01f, -3.81455384e-02f, -4.64549035e-01f, 1.15293181e-02f, 9.17987302e-02f, -8.45713392e-02f, -3.75026860e-03f,
  -1.25292689e-01f, -2.70075440e-01f, -1.49546042e-01f, 3.22377861e-01f, 1.66686475e-01f, -1.40494436e-01f, -2.29325965e-01f, 9.51863825e-02f, 2.71541208e-01f, 8.99290890e-02f,
  1.05278946e-01f, 2.25053221e-01f, -5.98152950e-02f, -6.75552040e-02f, -2.92582251e-02f, 1.08470179e-01f, 4.90565524e-02f, 5.38621396e-02f, 2.03293130e-01f, -1.09860741e-01f,
  1.05939694e-01f, 6.50327727e-02f, 2.38103509e-01f, -5.45692705e-02f, -1.14635250e-03f, -2.56270985e-03f, 2.69755542e-01f, -1.94734991e-01f, 1.96535051e-01f, -7.40098348e-03f,
  1.47575110e-01f, 4.08477336e-02f, -2.37354077e-02f, -2.16475770e-01f, 1.13304742e-01f, 3.02524716e-02f, 7.40829632e-02f, -3.05187196e-01f, 1.65222824e-01f, -8.08023363e-02f,
  -5.09951171e-03f, -6.74385801e-02f, 2.70623595e-01f, 6.06337637e-02f, -1.86329320e-01f, 2.84576625e-01f, -1.42464504e-01f, 1.52769700e-01f, 2.19662771e-01f, -2.05726922e-01f,
  -4.42408770e-02f, 1.17308803e-01f, -4.58531231e-02f, -3.54093492e-01f, -1.18022434e-01f, 6.26157075e-02f, 2.49077082e-01f, 3.42671812e-01f, 2.33068660e-01f, 8.32209960e-02f,
  2.25100681e-01f, 1.70747004e-02f, -7.42824599e-02f, 9.15632173e-02f, -1.48804471e-01f, 4.72086808e-03f, 1.02125436e-01f, -1.06531322e-01f, 2.34799370e-01f, 1.34135196e-02f,
  1.55465156e-02f, -2.16282122e-02f, -2.31019616e-01f, 6.35934770e-02f, 1.48613974e-01f, 3.60212207e-01f, -4.35292274e-02f, 7.42937922e-02f, -8.49512294e-02f, 2.09570210e-02f,
  2.30980620e-01f, 4.08066034e-01f, 1.91963509e-01f, -1.85271218e-01f, 1.51871834e-02f, -6.48341700e-02f, 1.45002007e-01f, 3.49084109e-01f, -4.72146571e-02f, -1.53926956e-02f,
  -1.15990989e-01f, 2.08212897e-01f, 1.46826610e-01f, 7.04156468e-03f, 1.34821370e-01f, -7.47047290e-02f, -1.18923679e-01f, 1.45860597e-01f, -1.95318565e-01f, 1.67784169e-01f,
  -3.37390900e-02f, 9.63200554e-02f, -3.75415720e-02f, 6.23542070e-02f, 8.73808414e-02f, 3.71477723e-01f, 3.76103222e-02f, -8.33166912e-02f, -6.24366403e-02f, 5.19665442e-02f,
  1.48021728e-01f, 5.69663532e-02f, -1.58089563e-01f, 1.97183713e-01f, -2.92635802e-02f, 1.00831129e-02f, 1.23340724e-04f, 1.10533461e-01f, 1.91671699e-02f, -3.88094224e-02f,
  -3.72908674e-02f, 3.65723595e-02f, -9.18470249e-02f, -9.78430435e-02f, -2.81874806e-01f, -1.77637830e-01f, -1.43098578e-01f, 2.02000961e-02f, 3.47796142e-01f, 6.36724532e-02f,
  1.63947135e-01f, -1.53181523e-01f, -2.73484103e-02f, -9.50909555e-02f, 2.27454871e-01f, -9.18422714e-02f, -1.36657774e-01f, 1.63447767e-01f, 4.93036844e-02f, -5.79077266e-02f,
  -7.28897229e-02f, -1.71201125e-01f, 1.13528028e-01f, 4.20549996e-02f, -1.07708335e-01f, 2.86026411e-02f, -3.37297358e-02f, 1.54216439e-01f, -6.64298162e-02f, -1.41969591e-01f,
  -1.49871737e-01f, 8.77739415e-02f, -6.45581260e-02f, -1.79060683e-01f, 2.75396667e-02f, 7.03577772e-02f, 8.04714710e-02f, 6.36936650e-02f, -3.86887155e-02f, 3.01523030e-01f,
  -9.13283154e-02f, 4.08380814e-02f, 1.48535907e-01f, -1.72862142e-01f, 8.41564536e-02f, 2.89081991e-01f, -4.83580902e-02f, 2.59494096e-01f, 1.07113212e-01f, -4.87769991e-02f,
  2.19176352e-01f, 9.32869390e-02f, -8.64033997e-02f, 4.68082018e-02f, 5.01679033e-02f, 1.84563473e-01f, -1.37339339e-01f, 3.35828155e-01f, 7.16635957e-02f, -5.40595278e-02f,
  -2.92323440e-01f, -2.32287981e-02f, -5.10836691e-02f, 1.44125462e-01f, -3.14353071e-02f, 3.99289429e-01f, 1.71409398e-01f, -1.80107087e-01f, -2.46719629e-01f, -7.58906966e-03f,
  3.96913141e-02f, 9.83389691e-02f, 3.12825650e-01f, -1.69530019e-01f, 5.27190678e-02f, 1.33363083e-01f, -6.83742836e-02f, 3.04945737e-01f, 1.58307806e-01f, -3.82065820e-03f,
  3.84512767e-02f, 1.93455085e-01f, -2.39700481e-01f, 2.95582503e-01f, 1.45106360e-01f, -4.29413766e-02f, 2.27072969e-01f, 7.47054443e-02f, -7.27534816e-02f, -1.85950175e-02f,
  -1.49622157e-01f, -1.10472828e-01f, 2.67246187e-01f, -3.00199296e-02f, -8.15819651e-02f, 1.60447729e-03f, -3.99693511e-02f, -1.13021463e-01f, 1.17661990e-01f, 6.44378038e-03f,
  7.18980208e-02f, 1.63413763e-01f, 1.78260684e-01f, 9.83878598e-02f, -4.67543080e-02f, 3.64351943e-02f, -1.64969582e-02f, 3.83349136e-02f, -3.71274389e-02f, 1.60315707e-01f,
  2.25675434e-01f, 6.83031976e-03f, -2.12817952e-01f, -4.68273498e-02f, 2.56318189e-02f, -6.87940717e-02f, -1.62950009e-02f, 1.64580390e-01f, -1.69188872e-01f, 5.10233976e-02f,
  3.76555249e-02f, 2.88159470e-03f, -7.24861100e-02f, -1.02276243e-02f, 4.81762625e-02f, -2.67377533e-02f, 2.08767876e-01f, -1.61637157e-01f, 2.18405277e-01f, -2.26923063e-01f,
  -2.44173378e-01f, 4.05571938e-01f, -8.72401595e-02f, 7.60063753e-02f, -3.56795937e-02f, -1.10185347e-01f, -2.77282417e-01f, -2.39453420e-01f, 1.68673396e-01f, 1.49678767e-01f,
  6.42114282e-02f, -2.64355093e-01f, -1.92964435e-01f, 1.25430107e-01f, 3.05608451e-01f, -4.20331694e-02f, -8.90696719e-02f, -6.34193122e-02f, 1.66923955e-01f, 9.30736493e-03f,
  3.12986635e-02f, 7.41846040e-02f, 1.29981562e-01f, -1.92958266e-01f, -1.48314059e-01f, 2.15001509e-01f, 1.21059738e-01f, 1.41871199e-01f, 1.12035908e-01f, -1.44670635e-01f,
  1.31228104e-01f, 1.17803559e-01f, 2.14748636e-01f, 1.30347073e-01f, -1.60274059e-02f, -5.87247275e-02f, 1.73591837e-01f, -6.65935408e-03f, -1.53153134e-03f, 2.73739733e-02f,
  6.62917048e-02f, -5.44827506e-02f, 1.12148754e-01f, 4.39576469e-02f, 2.55094469e-01f, 7.11955875e-02f, 1.31779760e-01f, 1.80210724e-01f, -7.05377609e-02f, 2.79422700e-01f,
  -7.14209229e-02f, 5.62283071e-03f, 6.38169646e-02f, -6.78849518e-02f, 7.05356076e-02f, 1.34276971e-01f, -5.90958036e-02f, 2.55590469e-01f, 1.42058343e-01f, -1.62734408e-02f,
  2.36659884e-01f, -6.85602948e-02f, 1.96714357e-01f, -1.47003159e-01f, 6.97814301e-02f, 4.28863376e-01f, -2.71438211e-01f, -8.39516968e-02f, -4.08844948e-02f, -1.24471828e-01f,
  -3.59269343e-02f, -6.59714416e-02f, 2.24124238e-01f, -1.96958687e-02f, -1.01638064e-01f, -8.92150328e-02f, -1.20073795e-01f, 7.93614611e-02f, 1.15107417e-01f, -8.81706551e-02f,
  1.14724757e-02f, 1.43939421e-01f, 2.16263115e-01f, -5.25162704e-02f, 6.03119954e-02f, 2.33686313e-01f, 3.07750180e-02f, -3.37691098e-01f, -1.57205433e-01f, 7.52227157e-02f,
  2.00607106e-01f, 1.92544788e-01f, -1.61676303e-01f, -1.70615703e-01f, -1.10244639e-01f, 3.05872917e-01f, 5.57501614e-02f, -1.13428764e-01f, -1.42641082e-01f, -1.52112078e-03f,
  -4.32137623e-02f, 1.04338191e-01f, 8.66709724e-02f, 1.44584645e-02f, 4.48882319e-02f, -8.66394639e-02f, 4.72073592e-02f, -2.26953149e-01f, 1.33731246e-01f, -7.81507790e-02f,
  -7.53602684e-02f, 5.84254321e-03f, -4.84674610e-02f, -8.29043612e-03f, -1.69348404e-01f, 1.24466017e-01f, -3.64586078e-02f, 1.88748464e-01f, 2.20147774e-01f, 1.63653083e-02f,
  -2.81448752e-01f, 1.69104099e-01f, -1.42354295e-01f, -2.46958271e-01f, -7.00867772e-02f, 1.12503879e-01f, 3.50664794e-01f, 2.62910545e-01f, 4.31153402e-02f, 3.19325067e-02f,
  1.70614004e-01f, 1.82732925e-01f, 2.05379695e-01f, 1.88690588e-01f, -1.08443946e-01f, -1.76340360e-02f, -1.55379385e-01f, 8.03273097e-02f, 1.53819211e-02f, -1.44379772e-02f,
  -1.36085182e-01f, -2.30407137e-02f, 1.38799772e-01f, 3.12304229e-01f, 1.50618508e-01f, -3.34887542e-02f, -1.98195666e-01f, -2.04372495e-01f, -1.47340462e-01f, -8.25554654e-02f,
  1.82340488e-01f, 2.26316616e-01f, -1.03692867e-01f, -1.26294389e-01f, 1.39151081e-01f, 3.03621627e-02f, 6.37635216e-02f, 1.59658968e-01f, -1.18973456e-01f, 2.77971085e-02f,
  2.30125353e-01f, 2.24639457e-02f, -8.38963166e-02f, -2.84673739e-02f, 1.20125823e-01f, -3.89281362e-02f, 1.22252747e-01f, -2.38341801e-02f, 5.27673736e-02f, -8.68988931e-02f,
  -1.96564689e-01f, -1.47900686e-01f, 1.55034468e-01f, -1.12591863e-01f, 1.57360584e-01f, 9.92390364e-02f, -5.56601956e-02f, 5.96760400e-02f, -1.41135186e-01f, 5.09242751e-02f,
  -1.76609650e-01f, 2.75358081e-01f, 2.86519021e-01f, 1.31617233e-01f, -1.34132564e-01f, 4.14596498e-02f, 2.22431228e-01f, -1.76172674e-01f, -2.53161311e-01f, -1.69312671e-01f,
  2.50856102e-01f, 1.03618950e-02f, -2.03981429e-01f, -9.31380615e-02f, 4.52890284e-02f, 1.85337156e-01f, 7.36274244e-03f, 2.53073156e-01f, -1.78472146e-01f, -1.79229409e-01f,
  -9.38302428e-02f, 2.90589958e-01f, 2.73758501e-01f, -9.58188996e-02f, -2.84279734e-01f, 1.86946113e-02f, 1.36815682e-01f, 2.67206971e-02f, 9.21009257e-02f, -2.17186287e-01f,
  -1.04043685e-01f, -2.14196429e-01f, -1.32284805e-01f, 1.83280736e-01f, 2.08203904e-02f, 7.30820745e-02f, 5.97971976e-02f, -1.58808324e-02f, -9.40858293e-03f, 2.12062314e-01f,
  1.82159469e-01f, -3.18413004e-02f, 3.11533138e-02f, 1.03420958e-01f, -4.40848395e-02f, -2.06652328e-01f, -1.41782641e-01f, 4.69200127e-02f, -1.54980728e-02f, -8.77933949e-03f,
  -2.14795698e-03f, 1.57086045e-01f, -1.26589641e-01f, 1.02021940e-01f, 1.89011618e-01f, 3.96511238e-03f, -1.70368060e-01f, -8.38785246e-02f, -1.65652148e-02f, 4.53706495e-02f,
  2.86194682e-01f, 1.26061708e-01f, -1.36764973e-01f, 4.65214588e-02f, 2.14522660e-01f, -1.49133205e-02f, -9.21319649e-02f, 7.95394406e-02f, -4.90163751e-02f, -4.84788306e-02f,
  -1.76238552e-01f, 6.46663308e-02f, -1.02989323e-01f, 1.08963296e-01f, 3.91100675e-01f, 2.76241064e-01f, -1.52793467e-01f, -7.11620003e-02f, 2.63022613e-02f, 2.01307349e-02f,
  -5.94021976e-02f, -6.30233660e-02f, -6.70625921e-03f, -2.64222145e-01f, -2.44137961e-02f, 5.45102358e-03f, -1.02990694e-01f, 6.12151735e-02f, 6.53369799e-02f, 1.31934732e-01f,
  -3.78696844e-02f, 1.48684144e-01f, -1.12650387e-01f, -1.32406890e-01f, -7.21840784e-02f, -2.45330617e-01f, 1.40497116e-02f, 1.42181039e-01f, -6.61861226e-02f, 3.55137736e-02f,
  6.17486499e-02f, 3.30283269e-02f, -7.98518658e-02f, 2.62855440e-01f, -1.31630763e-01f, -2.32938528e-01f, 6.37826920e-02f, 6.35445938e-02f, 2.16266453e-01f, 1.11221738e-01f,
  4.08963375e-02f, 2.90014241e-02f, 6.70979843e-02f, -6.61296099e-02f, -1.24873511e-01f, -2.82431215e-01f, 7.85283744e-02f, 1.40110701e-01f, -1.45609722e-01f, -3.64007466e-02f,
  1.60866603e-01f, -2.00551286e-01f, 1.15793236e-01f, 2.70594716e-01f, -1.23670429e-01f, -9.38539580e-02f, 5.80929480e-02f, -4.28861417e-02f, 8.77687111e-02f, 4.87595424e-02f,
  1.91873267e-01f, -7.40184784e-02f, 1.29693672e-01f, -1.65371913e-02f, 1.20380603e-01f, 9.36326683e-02f, 1.41531089e-02f, -2.24479046e-02f, -2.28966340e-01f, -1.43402321e-02f,
  5.05230166e-02f, -1.63833156e-01f, -1.12844348e-01f, -2.08090991e-02f, -2.14612588e-01f, 2.99783200e-02f, -5.72648942e-02f, -1.08058050e-01f, 2.10957050e-01f, -3.36402506e-01f,
  -9.51623661e-04f, -8.16188380e-02f, -1.35336174e-02f, -1.19483016e-01f, -2.62811601e-01f, -7.83245340e-02f, 4.18098830e-03f, 2.05035344e-01f, -1.98070779e-01f, 1.07642770e-01f,
  -2.00177148e-01f, 2.02732995e-01f, 5.59367053e-02f, 2.74577048e-02f, 1.32609934e-01f, 1.11697223e-02f, 2.26185247e-01f, -7.94912651e-02f, -6.92467093e-02f, 2.38621205e-01f,
  -5.62006794e-02f, -2.35338621e-02f, -1.08797468e-01f, -1.62519708e-01f, 1.15465233e-02f, -6.25722557e-02f, -9.79682337e-03f, 3.94442976e-02f, -2.82748789e-02f, 1.19328156e-01f,
  3.83715518e-02f, -1.48622856e-01f, -3.35053243e-02f, 1.41555682e-01f, -1.54254451e-01f, 2.18703240e-01f, 1.01663113e-01f, -1.53166339e-01f, 6.98533356e-02f, 1.37486219e-01f,
  1.38090238e-01f, -3.18740867e-02f, 5.12927249e-02f, -1.82025731e-01f, -1.21410422e-01f, -4.99426387e-02f, -1.95232973e-01f, -1.70527652e-01f, -9.63335857e-02f, 1.64865106e-02f,
  1.35627359e-01f, 1.16574012e-01f, -1.99277505e-01f, -8.92355815e-02f, -8.05948302e-02f, -3.00181676e-02f, -3.11037172e-02f, 7.88341686e-02f, 2.77319457e-02f, -4.31904234e-02f,
  -1.62975937e-01f, 1.50238797e-01f, -1.97160006e-01f, 5.16388193e-02f, -1.48592114e-01f, 1.98576804e-02f, 1.08521953e-01f, -1.16999000e-01f, -3.19116533e-01f, 1.08846454e-02f,
  -2.51237243e-01f, 9.75249335e-02f, 2.23994642e-01f, 7.90643543e-02f, 1.57575190e-01f, -7.66157135e-02f, 4.80456883e-03f, -7.44138332e-03f, 1.61201194e-01f, -4.82977405e-02f,
  -4.87748422e-02f, 2.59029180e-01f, -2.34912112e-01f, 6.89192023e-03f, 1.75401062e-01f, -1.62468299e-01f, 1.60316333e-01f, -3.06484044e-01f, -9.59654078e-02f, -7.48866200e-02f,
  -1.70854792e-01f, -1.05720550e-01f, 2.93245405e-01f, -3.20621394e-02f, -8.96278843e-02f, -8.68960395e-02f, 1.36490002e-01f, -2.06184372e-01f, -2.42221765e-02f, -1.61469981e-01f,
  -1.60152406e-01f, -1.55044943e-01f, 3.46457511e-02f, 3.86814475e-02f, -1.33177459e-01f, -5.56481853e-02f, -3.21790129e-02f, 2.42199935e-03f, 3.21160592e-02f, -2.01627821e-01f,
  -3.59660417e-01f, 1.35497466e-01f, -1.24227833e-02f, -2.49515906e-01f, 1.25208527e-01f, 9.94005129e-02f, 2.55722612e-01f, 5.11128567e-02f, -2.63422400e-01f, 3.38877499e-01f,
  2.39077196e-01f, 1.28387541e-01f, 1.55822068e-01f, 5.86424693e-02f, -3.27298999e-01f, 8.18342641e-02f, -2.11893007e-01f, -3.87072191e-02f, -1.34778181e-02f, 7.83996284e-02f,
  -2.71863937e-01f, 9.98571068e-02f, 1.67775497e-01f, 1.24264702e-01f, -1.11852705e-01f, -1.42501205e-01f, 1.16049983e-01f, -1.06252685e-01f, 8.30164999e-02f, -6.30458519e-02f,
  1.05110832e-01f, -7.88365453e-02f, -2.61222050e-02f, -2.14675933e-01f, -6.67028502e-02f, -2.15698685e-02f, -1.22847274e-01f, -6.78868666e-02f, -1.19768910e-01f, 1.19764350e-01f,
  2.63848677e-02f, -7.91595802e-02f, -9.44587588e-02f, 1.35037795e-01f, 5.64665385e-02f, -4.88260984e-02f, -2.65611291e-01f, 1.06437601e-01f, -1.68907464e-01f, -1.40069813e-01f,
  1.79545403e-01f, -1.02014355e-01f, 3.96113321e-02f, 6.11846261e-02f, 5.74526377e-02f, -3.54146063e-01f, 1.61677718e-01f, -2.58774385e-02f, -1.33924216e-01f, -7.49733299e-02f,
  -2.66619325e-02f, -1.05847716e-01f, -1.49790481e-01f, -3.12654264e-02f, -5.74287474e-02f, 2.11979479e-01f, -1.65030003e-01f, 3.00557315e-02f, 9.83129516e-02f, 3.95861547e-03f,
  3.58459413e-01f, 2.42063142e-02f, -2.39933684e-01f, 3.14829022e-01f, -6.39276728e-02f, 2.21520513e-01f, 7.75870904e-02f, -3.86350900e-02f, -7.50216190e-03f, -2.58427709e-01f,
  -7.41804466e-02f, 8.77710283e-02f, -9.24361050e-02f, -1.61724668e-02f, -1.03466421e-01f, -5.03210165e-03f, 7.23314434e-02f, 2.77304888e-01f, -2.92159244e-02f, 3.08740258e-01f,
  1.07869230e-01f, -3.00097138e-01f, 9.00369212e-02f, 4.26896960e-02f, 6.11628816e-02f, -1.00332424e-01f, -1.04009748e-01f, 1.87087163e-01f, -2.63776252e-04f, 2.45176420e-01f,
  -1.50257632e-01f, -1.92944556e-01f, -6.10721037e-02f, 1.55536653e-02f, -2.91397065e-01f, -1.53247034e-02f, -1.61370352e-01f, 2.65263822e-02f, -2.69853354e-01f, -1.01537853e-01f,
  1.49611607e-01f, 1.57871217e-01f, -5.14800064e-02f, -2.73643613e-01f, -2.08261222e-01f, 1.90655366e-01f, -9.24206376e-02f, 3.17043215e-01f, -2.36022249e-02f, -2.21333966e-01f,
  -1.08974501e-01f, 2.25002885e-01f, 7.95918424e-03f, -2.98423376e-02f, 9.15583447e-02f, -8.15884769e-03f, 9.15129781e-02f, 7.12167248e-02f, -2.68596947e-01f, -1.40525624e-01f,
  -2.59961128e-01f, 2.48893514e-01f, 6.09200560e-02f, 2.27665901e-01f, -1.42212316e-01f, 9.63483229e-02f, -3.12436484e-02f, -7.05799973e-03f, -2.32699841e-01f, 5.06765209e-02f,
  8.14068988e-02f, 2.87600070e-01f, 1.54484704e-01f, -1.37576431e-01f, -3.23913753e-01f, -8.19940586e-03f, -2.62991786e-01f, 5.85830249e-02f, 1.89652875e-01f, -7.75490701e-02f,
  -1.06398180e-01f, -6.77616000e-02f, -1.46630824e-01f, 9.81203243e-02f, 4.02597189e-02f, 5.61162010e-02f, 1.09881848e-01f, 1.43320963e-01f, 9.16310400e-02f, -1.85931534e-01f,
  -9.77495387e-02f, -1.75205231e-01f, 4.20612544e-02f, 2.72775024e-01f, -4.92765233e-02f, 1.03780285e-01f, 1.42238513e-01f, 1.27270222e-01f, -8.30692947e-02f, 7.16589615e-02f,
  -6.62000850e-02f, 2.28495449e-01f, 1.45969287e-01f, 1.01681866e-01f, 3.05028819e-02f, 1.90863788e-01f, 5.26053132e-03f, -8.30821916e-02f, -1.13897286e-01f, -2.33251024e-02f,
  2.07762390e-01f, 3.84860188e-02f, 2.57886082e-01f, -9.03739110e-02f, 2.43301794e-01f, 6.54920489e-02f, -2.29937598e-01f, 1.63158495e-02f, 3.36772874e-02f, 3.22290003e-01f,
  -5.45523129e-02f, 1.33861229e-01f, 3.86050306e-02f, -1.00089863e-01f, -1.26561290e-02f, 8.86731073e-02f, -2.34085053e-01f, 6.00451492e-02f, 1.00873619e-01f, 3.46437156e-01f,
  1.14927709e-01f, -1.75569400e-01f, 3.79524268e-02f, 1.50000170e-01f, -1.51731759e-01f, -9.30515379e-02f, -4.13531214e-02f, -3.60353768e-01f, 1.05496630e-01f, 2.60895759e-01f,
  1.08061425e-01f, -1.74371377e-01f, 1.18792597e-02f, 6.42570555e-02f, 1.62835494e-01f, 7.32853711e-02f, -1.56097757e-02f, -1.61936641e-01f, -9.17432457e-02f, -3.24147016e-01f,
  -2.55668253e-01f, 8.86935219e-02f, 4.34256233e-02f, 2.63424337e-01f, -3.48324105e-02f, 1.13050282e-01f, 1.53158437e-02f, 1.19903781e-01f, 6.58584163e-02f, -1.42641425e-01f,
  -7.38434866e-02f, -9.40985531e-02f, 8.06122199e-02f, -9.48465466e-02f, 5.92631288e-02f, -1.57293975e-01f, 1.20441079e-01f, -5.81293032e-02f, -5.54505922e-02f, -2.35301748e-01f,
  -2.63771531e-03f, -2.71103948e-01f, 1.15145333e-02f, -8.35528299e-02f, 6.03284128e-03f, -8.88644531e-02f, -1.06960706e-01f, -1.73661515e-01f, -5.46217039e-02f, -1.62742853e-01f,
  8.04372411e-03f, 3.42803411e-02f, -2.59643458e-02f, -6.94884285e-02f, -1.02870286e-01f, -1.92348272e-01f, 1.37045979e-01f, 2.44136438e-01f, -8.41272622e-02f, -1.40322849e-01f,
  7.01755211e-02f, -2.50435978e-01f, -8.28192160e-02f, 2.36105602e-02f, 1.92606419e-01f, -1.52457505e-01f, 2.68923566e-02f, -2.15264603e-01f, 1.09360963e-01f, -6.35939091e-02f,
  1.80052131e-01f, 1.68879822e-01f, -1.57270998e-01f, -9.02670473e-02f, 3.10941726e-01f, -9.05330926e-02f, -3.00904363e-01f, 9.73325446e-02f, 4.90136929e-02f, -1.15673520e-01f,
  2.33177543e-01f, 2.87589073e-01f, -5.27922362e-02f, 1.82861239e-01f, -4.31629270e-02f, -1.52385488e-01f, -8.22792873e-02f, -1.46264711e-03f, -1.05615392e-01f, -1.08669989e-01f,
  1.42379448e-01f, -1.34259179e-01f, 3.20020944e-01f, -8.97592679e-02f, -2.00445101e-01f, 1.10347860e-01f, -5.73714226e-02f, -2.14746833e-01f, -2.05501035e-01f, 9.43513438e-02f,
  -8.83245617e-02f, -1.35203069e-02f, -1.75408721e-02f, -2.37770140e-01f, 8.56852382e-02f, 2.70280633e-02f, 1.05375379e-01f, -1.59730628e-01f, -9.48533565e-02f, -1.20572984e-01f,
  -6.56041279e-02f, -2.01969504e-01f, -1.40588796e-02f, -1.36791080e-01f, -4.50250283e-02f, -1.64516702e-01f, -6.88397214e-02f, -1.52077377e-02f, -3.54483835e-02f, -4.65214133e-01f,
  -1.84346452e-01f, -1.29441485e-01f, 9.13245529e-02f, -1.49869159e-01f, -1.75860554e-01f, 1.31995529e-01f, 4.66440134e-02f, 1.81224912e-01f, -5.96679971e-02f, -3.18036437e-01f,
  2.39624813e-01f, 2.39309564e-01f, 8.00062120e-02f, -2.35807393e-02f, -1.53095648e-01f, 6.71486333e-02f, -2.61761904e-01f, -1.56530201e-01f, 6.11657612e-02f, -2.82232668e-02f,
  -1.05326563e-01f, 8.70672287e-04f, -3.29988003e-02f, -1.33901751e-02f, -2.21534893e-02f, 3.05373184e-02f, 4.15108837e-02f, -2.06592366e-01f, -1.14897095e-01f, -1.58930853e-01f,
  6.19965568e-02f, 2.11860329e-01f, 1.75125953e-02f, -8.05561766e-02f, 2.89134365e-02f, -5.22841290e-02f, 9.91225988e-02f, -1.47902191e-01f, 2.69279145e-02f, 4.45598215e-02f,
  7.56136030e-02f, 1.61206916e-01f, -4.71400395e-02f, -9.39268842e-02f, -3.64172682e-02f, -5.34772612e-02f, -1.34199169e-02f, 2.24599540e-02f, 6.03748346e-03f, 1.19305223e-01f,
  9.41801146e-02f, 2.07258359e-01f, 3.98800336e-02f, 6.28586784e-02f, 8.02793503e-02f, 1.10010423e-01f, -8.10375065e-03f, 1.87449858e-01f, -5.03588207e-02f, -2.62091067e-02f,
  8.51031989e-02f, -9.18818042e-02f, -1.26462296e-01f, 1.53603181e-01f, 2.91750968e-01f, -2.39114161e-05f, -1.10281698e-01f, -2.35808805e-01f, -3.74515392e-02f, -1.30474836e-01f,
  -2.76862234e-02f, 2.73882031e-01f, -2.67960608e-01f, -1.27646536e-01f, 9.74589307e-03f, 2.19420552e-01f, 8.40282291e-02f, 1.07800081e-01f, 1.82760075e-01f, 1.32886112e-01f,
  -1.45434082e-01f, 1.76147316e-02f, -6.12370521e-02f, 3.33207697e-01f, 2.31561840e-01f, -1.09161615e-01f, 1.43213347e-01f, 1.91947699e-01f, -1.53190643e-01f, -1.52176186e-01f,
  -1.19280286e-01f, 1.65483577e-03f, 1.52921662e-01f, -1.03993773e-01f, 1.20188013e-01f, -5.67427054e-02f, 6.38957247e-02f, -2.31151730e-01f, 8.37788284e-02f, 9.36883166e-02f,
  -4.68644500e-02f, 6.10159449e-02f, 8.80594552e-02f, -1.91593453e-01f, 9.74478051e-02f, 5.61534762e-02f, 6.73225150e-02f, 1.18765280e-01f, -1.45095745e-02f, -1.33348182e-01f,
  -1.67913899e-01f, -1.99366227e-01f, -1.00807577e-01f, 1.95648801e-02f, 3.77008356e-02f, -1.48420081e-01f, -9.79132280e-02f, -1.70439228e-01f, -3.27691212e-02f, -6.79264739e-02f,
  -3.72512601e-02f, -2.66893595e-01f, -1.16129123e-01f, -7.68775865e-02f, -1.38842553e-01f, 6.77078916e-03f, 1.14616178e-01f, -1.12258054e-01f, 2.39465937e-01f, 6.52202815e-02f,
  1.74773000e-02f, 9.95523483e-02f, 6.95118457e-02f, -7.44426697e-02f, 9.31436848e-03f, -2.21149474e-01f, -1.58606749e-02f, 2.29047641e-01f, -1.56433120e-01f, -2.99723949e-02f,
  1.23530179e-02f, -1.96658581e-01f, 5.16871847e-02f, -1.26847938e-01f, -8.73212591e-02f, -1.54104531e-01f, -1.33052006e-01f, -3.53189230e-01f, 1.23362914e-02f, 9.56461579e-03f,
  1.48263022e-01f, -2.60735691e-01f, 3.01165015e-01f, 9.21608582e-02f, -5.34911938e-02f, -1.45032093e-01f, -1.47407949e-01f, 1.50205448e-01f, -1.44001797e-01f, 1.64771035e-01f,
  -9.26672965e-02f, 1.71608254e-01f, 7.63461739e-02f, -3.65646183e-02f, -1.62508711e-01f, 3.27583253e-02f, -1.40411839e-01f, 1.54736489e-01f, 1.84961166e-02f, 1.10548228e-01f,
  1.10152394e-01f, -1.64787576e-01f, -7.76881576e-02f, -1.56021535e-01f, -1.11724794e-01f, 1.06484152e-01f, 1.06398173e-01f, 8.80334303e-02f, -5.16495183e-02f, 2.34468523e-02f,
  1.30269110e-01f, 1.23971425e-01f, 1.09655559e-01f, 3.56531329e-02f, -9.15017501e-02f, 1.05602741e-01f, 7.73690864e-02f, 7.64251351e-02f, -7.40804374e-02f, -5.57161793e-02f,
  -1.31298006e-01f, 1.94383204e-01f, -2.88630519e-02f, -1.16196007e-01f, 1.17290923e-02f, -9.93206427e-02f, 5.10304868e-02f, -2.26754680e-01f, -5.05097546e-02f, 1.40364677e-01f,
  -1.98267862e-01f, -1.24706872e-01f, 2.48452559e-01f, 1.18956380e-01f, -1.42420530e-02f, -1.69413254e-01f, -2.04137921e-01f, -6.02581948e-02f, 4.55445237e-02f, 3.68109137e-01f,
  2.04157740e-01f, 2.04238296e-01f, -1.38508882e-02f, 3.70606892e-02f, 2.10294232e-01f, 2.09638074e-01f, -1.62608147e-01f, -4.91197467e-01f, -1.77353069e-01f, 2.55403996e-01f,
  1.64186329e-01f, -1.46816298e-01f, 1.33435205e-01f, 3.94957997e-02f, 1.89043447e-01f, -1.28358439e-01f, -8.12287033e-02f, 2.70155579e-01f, 2.74743021e-01f, -9.49118137e-02f,
  1.33398771e-01f, -1.11636549e-01f, 2.24143397e-02f, -5.52131943e-02f, -7.48257563e-02f, -6.60623610e-02f, 7.32627511e-02f, -6.11708649e-02f, -6.11280724e-02f, -1.92545176e-01f,
  5.87349460e-02f, 1.63738523e-02f, -1.62562504e-01f, -2.06486508e-02f, -1.69452026e-01f, 2.17997599e-02f, -2.09431946e-01f, 1.32098958e-01f, -1.24683015e-01f, -9.70655084e-02f,
  2.73625106e-01f, 1.36779830e-01f, -4.31347042e-02f, 4.49545532e-02f, 1.81448460e-01f, -1.41824052e-01f, 1.60534203e-01f, 3.37189361e-02f, -1.14686564e-01f, -1.83249339e-01f,
  -2.03760624e-01f, -2.03146175e-01f, -1.97633371e-01f, -1.63811326e-01f, 1.41482741e-01f, -2.35756502e-01f, 2.42366102e-02f, -5.17000034e-02f, 4.19246443e-02f, -1.10969551e-01f,
  2.44301543e-01f, 1.56340614e-01f, -1.64689705e-01f, -1.19551443e-01f, 1.72596708e-01f, 1.66230187e-01f, 4.33522128e-02f, 1.26077071e-01f, 4.61545587e-02f, -1.89184174e-01f,
  2.01786652e-01f, 1.52471974e-01f, -3.54662612e-02f, 1.98790044e-01f, -1.17406333e-02f, -2.24446058e-01f, 5.86231612e-02f, 3.66644710e-02f, 6.61872029e-02f, 1.41832707e-02f,
  3.15094471e-01f, -2.32973620e-01f, 2.95268297e-01f, 1.20676540e-01f, -2.66245306e-02f, 7.53711835e-02f, -3.49785596e-01f, -1.51029542e-01f, -2.40996405e-01f, -3.18735242e-02f,
  -1.92156032e-01f, 1.21342000e-02f, 1.22746736e-01f, -1.62094068e-02f, -5.71026467e-02f, -9.52357501e-02f, 6.34617731e-02f, -1.33161202e-01f, -1.98583886e-01f, 9.91084129e-02f,
  6.02231659e-02f, -2.86659420e-01f, -3.03895641e-02f, 1.89517089e-03f, -1.77323729e-01f, -3.20508145e-02f, -1.63345844e-01f, 9.53921601e-02f, -2.06531957e-01f, -3.58116806e-01f,
  -1.39414355e-01f, -1.58670127e-01f, 1.55614344e-02f, -2.05364332e-01f, 3.18975225e-02f, 4.38652217e-01f, -2.26663560e-01f, -4.98005375e-02f, 9.42040756e-02f, 8.34663138e-02f,
  3.12731066e-03f, -2.16596693e-01f, 3.21994811e-01f, -3.76267053e-05f, 2.62540549e-01f, 3.52511048e-01f, 1.87245473e-01f, -1.83599576e-01f, -4.52001244e-01f, 1.83290169e-01f,
  2.86452234e-01f, -1.70368478e-01f, -1.90802991e-01f, -4.37794551e-02f, 1.24791346e-01f, -4.48475406e-02f, 1.49537802e-01f, -1.50285199e-01f, 1.73156753e-01f, -2.97883570e-01f,
  -1.07591830e-01f, -3.16977762e-02f, -1.26464769e-01f, -1.88501850e-02f, -1.65002748e-01f, -1.87818687e-02f, -2.21997991e-01f, 1.23370111e-01f, -4.00246903e-02f, -5.51431775e-02f
};

// L2_fan_Wp_bar (Shape: 14 x 64)
const int L2_fan_Wp_bar_rows = 14;
const int L2_fan_Wp_bar_cols = 64;
const float L2_fan_Wp_bar_data[] = {
  3.45307976e-01f, -1.43433943e-01f, 2.73993500e-02f, -4.93846498e-02f, 1.32560730e-01f, 1.17013112e-01f, -5.75140342e-02f, -2.44872496e-02f, 5.93018830e-02f, 7.18008354e-02f,
  -1.85555834e-02f, -1.86121821e-01f, 2.02388301e-01f, 1.02533586e-01f, 9.16084554e-03f, -1.78202450e-01f, -3.14447880e-02f, 1.88013986e-01f, 1.48524940e-01f, -2.15260312e-02f,
  -1.10061347e-01f, 7.04096630e-02f, -3.29248123e-02f, 2.45206840e-02f, 1.10147316e-02f, -2.83317994e-02f, 1.85969830e-01f, -3.87009472e-01f, -4.93281484e-02f, -3.15904990e-02f,
  1.36989623e-01f, 3.17262276e-03f, -3.45267475e-01f, 4.63392168e-01f, 2.47720465e-01f, 6.36255369e-02f, -4.25569192e-02f, 6.80928975e-02f, -1.25497252e-01f, 3.24154824e-01f,
  5.59512749e-02f, -9.48053151e-02f, -1.77970678e-01f, -8.54026899e-02f, 2.86406815e-01f, 1.98652357e-01f, -1.52926967e-01f, -5.26598431e-02f, -2.95322478e-01f, -2.66162843e-01f,
  3.10495675e-01f, -5.39221950e-02f, 2.63254702e-01f, -6.26636446e-02f, 2.46288687e-01f, 1.66607454e-01f, 1.04088455e-01f, 1.96009383e-01f, -1.36408165e-01f, 2.31578991e-01f,
  -5.95909245e-02f, -4.44271863e-02f, 3.56965989e-01f, -7.60817230e-02f, 2.74467409e-01f, 2.15517119e-01f, 2.08608344e-01f, -1.95186526e-01f, 1.67756692e-01f, 6.11031204e-02f,
  -2.84114033e-01f, -3.22596788e-01f, 1.40416607e-01f, -2.23059595e-01f, -3.50711703e-01f, 1.29028231e-01f, 1.16953716e-01f, 8.99876133e-02f, -6.29572049e-02f, 6.27369657e-02f,
  -1.84793144e-01f, -4.42152023e-02f, 2.10745156e-01f, 7.29847758e-04f, 1.24441214e-01f, -1.26549855e-01f, 5.28646223e-02f, 1.40921578e-01f, -1.93391033e-02f, -4.45641130e-02f,
  -1.11793682e-01f, 4.26775441e-02f, 1.37433276e-01f, -3.25103134e-01f, -8.20846036e-02f, -2.84470469e-01f, -6.72675446e-02f, 1.15310363e-01f, -3.00522029e-01f, -6.40233159e-02f,
  -2.41861373e-01f, -1.12555563e-01f, 5.47226518e-02f, 4.43489067e-02f, 1.12410136e-01f, -2.72589684e-01f, 5.13634868e-02f, -4.29830924e-02f, 1.12542130e-01f, -2.37292305e-01f,
  -3.03573996e-01f, -2.97457516e-01f, -3.43006581e-01f, 5.95549226e-01f, -4.94290181e-02f, 3.09395343e-01f, -6.39740229e-02f, 9.40542147e-02f, 4.80387472e-02f, -2.60219704e-02f,
  1.43717945e-01f, 1.01169690e-01f, 2.03469798e-01f, 7.17585310e-02f, 9.59024355e-02f, 3.60303313e-01f, -7.91387036e-02f, 2.37543676e-02f, 8.57442021e-02f, -4.00257200e-01f,
  1.02583673e-02f, 7.86500052e-02f, 4.69775088e-02f, -8.69373605e-02f, -1.69988219e-02f, -1.41487882e-01f, -7.52805313e-03f, -2.21593469e-01f, -9.63550583e-02f, -6.24309257e-02f,
  6.85950965e-02f, 6.74394444e-02f, -1.68242097e-01f, -2.72582471e-02f, 8.93763378e-02f, 8.93314853e-02f, 8.22953060e-02f, 4.92855273e-02f, -6.10270202e-02f, -1.32067120e-02f,
  7.09054396e-02f, -8.76977388e-03f, -1.30104944e-01f, -1.13876998e-01f, 1.69171095e-01f, 3.46230231e-02f, 1.14038780e-01f, -1.51040494e-01f, 7.10145757e-02f, 4.81866475e-04f,
  -1.26425505e-01f, 6.37305677e-02f, 8.67613181e-02f, 2.84705400e-01f, -2.14703456e-01f, 1.18241817e-01f, -1.37756795e-01f, 2.32675865e-01f, -1.71446264e-01f, -8.01133215e-02f,
  -2.55715642e-02f, -1.53443189e-02f, -9.10136849e-02f, 4.44274284e-02f, 7.07594529e-02f, -1.61298037e-01f, -1.05890669e-01f, 1.58318564e-01f, -1.86987624e-01f, 2.40766034e-01f,
  -3.03406864e-02f, 1.35157391e-01f, 2.09545478e-01f, 4.24773358e-02f, 2.29590997e-01f, -3.56976390e-02f, -8.96371752e-02f, 1.96190581e-01f, 8.74443278e-02f, -5.82166612e-02f,
  6.25501797e-02f, -8.31584260e-02f, 2.19940603e-01f, 2.04436690e-01f, 6.49655908e-02f, -3.59077118e-02f, 1.71997830e-01f, 7.79524818e-02f, -2.32610390e-01f, -2.31251970e-01f,
  1.43130213e-01f, 1.87881112e-01f, -1.85155105e-02f, 3.22686851e-01f, 2.99544871e-01f, 2.85564568e-02f, 2.89517403e-01f, 3.18869978e-01f, -1.46875039e-01f, -6.53713644e-02f,
  1.14317320e-03f, 1.43826485e-01f, 2.48106420e-01f, -3.19114216e-02f, -1.06835142e-01f, 1.46973670e-01f, 2.51171827e-01f, 1.60355255e-01f, 2.22244766e-02f, 3.59403975e-02f,
  3.04600418e-01f, 3.22976373e-02f, 1.29640743e-01f, -7.54976794e-02f, -1.41543532e-02f, 1.15756422e-01f, -3.05865854e-01f, -1.48030013e-01f, -8.79945084e-02f, 1.68871712e-02f,
  3.72644335e-01f, -2.24670023e-01f, 3.16567928e-01f, -8.59082043e-02f, 2.00311225e-02f, 1.28402561e-01f, 2.90063303e-02f, -2.31741205e-01f, 7.28446707e-07f, -1.79551676e-01f,
  -2.48698555e-02f, 3.33482444e-01f, -1.70517385e-01f, 1.53389230e-01f, 9.07681733e-02f, 2.78719008e-01f, 9.78911528e-04f, -2.11332496e-02f, -4.73647937e-02f, 4.84606139e-02f,
  3.60733896e-01f, -4.69962992e-02f, 2.31314525e-01f, 6.36078883e-03f, -1.65718481e-01f, 5.19643612e-02f, 5.26127703e-02f, -2.04637036e-01f, 1.15128368e-01f, 2.10831910e-01f,
  7.69972578e-02f, 9.32638571e-02f, 8.34730044e-02f, 2.67373621e-01f, 1.14998907e-01f, 6.26950413e-02f, -2.91253161e-02f, -3.77041437e-02f, -4.26393487e-02f, 4.70517501e-02f,
  -1.48099866e-02f, 9.67367142e-02f, 1.69481769e-01f, 3.61957937e-03f, -8.37205909e-03f, -3.80868502e-02f, 2.41635069e-01f, 3.96397591e-01f, 2.54583180e-01f, 1.60585463e-01f,
  -1.22038154e-02f, -4.85761970e-01f, 1.43518597e-01f, 3.31923723e-01f, -1.88325107e-01f, -7.25752413e-02f, 1.39724672e-01f, 4.30361569e-01f, -1.72119021e-01f, -2.65004545e-01f,
  1.60578445e-01f, 8.66996497e-02f, -1.81612536e-01f, 1.63241267e-01f, -1.23332135e-01f, -2.88392037e-01f, -4.26744312e-01f, 1.28772646e-01f, 1.01014219e-01f, -4.16668579e-02f,
  1.95153937e-01f, 3.21733356e-02f, 2.44782493e-01f, 1.37112409e-01f, -1.48763642e-01f, -3.37106407e-01f, -1.24539256e-01f, -2.33119980e-01f, 9.70466509e-02f, 7.47319832e-02f,
  2.11809009e-01f, 2.65889853e-01f, 6.47867098e-02f, -9.61037949e-02f, -5.52802160e-03f, 1.73525795e-01f, 1.52019620e-01f, -1.11590140e-01f, 1.47045493e-01f, -1.75705999e-01f,
  4.33819145e-02f, 1.03273794e-01f, 2.08631098e-01f, 3.47260311e-02f, 1.76295191e-01f, -5.11642620e-02f, 1.72941715e-01f, -1.47316158e-01f, 3.10748909e-02f, 9.38037783e-02f,
  -1.13735221e-01f, 1.02478795e-01f, -4.42910604e-02f, 7.79775158e-02f, -1.22948125e-01f, 2.56876737e-01f, -4.92163301e-02f, 1.20532744e-01f, 7.81358406e-02f, -7.49389902e-02f,
  1.35597348e-01f, 7.17053488e-02f, 2.80808687e-01f, 1.71472043e-01f, 2.23841846e-01f, -2.33351380e-01f, -1.52301937e-01f, -2.28826925e-01f, -8.57404694e-02f, 8.50154534e-02f,
  -2.46272355e-01f, -2.50349075e-01f, 2.69832730e-01f, 1.43103898e-01f, -4.19787914e-01f, -2.28474438e-01f, 9.00063515e-02f, 8.11443105e-02f, 4.33217824e-01f, 1.67137221e-01f,
  1.65441670e-02f, -4.17217702e-01f, -2.52998769e-01f, -2.37654373e-01f, 3.14829260e-01f, -1.72678173e-01f, -4.08240557e-01f, -1.44587353e-01f, 1.55978706e-02f, 3.08471322e-01f,
  2.69876625e-02f, -2.29359120e-01f, -1.13666631e-01f, 1.94863975e-01f, -9.65950191e-02f, -2.21213713e-01f, -1.78783298e-01f, 1.18208930e-01f, 2.06267238e-01f, -4.64671671e-01f,
  -4.80635576e-02f, 4.92156744e-01f, -3.45168829e-01f, -5.17297201e-02f, 2.24655986e-01f, -1.73573017e-01f, 2.84763813e-01f, -1.17776934e-02f, 3.05797994e-01f, 2.37842044e-03f,
  -3.12339589e-02f, -3.26903611e-01f, 1.01278044e-01f, -1.60356879e-01f, -1.13090292e-01f, 3.72048095e-02f, 1.06071070e-01f, 3.65053378e-02f, 3.93183529e-02f, 1.28125651e-02f,
  -1.17447801e-01f, 1.79529354e-01f, 9.75980908e-02f, 2.77114511e-01f, 2.67602168e-02f, -1.03697740e-01f, 1.56389400e-01f, -6.93162829e-02f, 2.85152551e-02f, 1.59670278e-01f,
  1.49314646e-02f, 3.75548638e-02f, 8.07252228e-02f, 1.16471341e-02f, -7.30973780e-02f, 1.82994887e-01f, -1.07446604e-03f, 1.19022079e-01f, -4.18651616e-03f, 1.85449962e-02f,
  -9.09994468e-02f, 5.55688329e-02f, -1.50164545e-01f, 3.05391133e-01f, -4.06917557e-02f, -9.13946852e-02f, 9.82810557e-02f, 1.02665678e-01f, -1.05621502e-01f, -1.03181675e-01f,
  3.36814225e-02f, -1.20025009e-01f, -7.93049037e-02f, 3.24923426e-01f, -1.27160802e-01f, 3.27754885e-01f, 1.55706719e-01f, 1.11231143e-02f, 2.19117433e-01f, 7.93171208e-03f,
  1.06606603e-01f, -1.41923770e-01f, 3.49678606e-01f, 2.85530556e-03f, 1.94348738e-01f, 2.72700101e-01f, 5.85276857e-02f, 4.93622571e-02f, 2.85157531e-01f, 2.43952438e-01f,
  1.89359784e-01f, -5.50137796e-02f, 2.52636731e-01f, -4.61983941e-02f, 2.34285101e-01f, -5.18226949e-03f, 1.00826904e-01f, 6.98599145e-02f, -9.99878719e-02f, 3.97229716e-02f,
  3.73125076e-01f, 9.30711776e-02f, -5.04385401e-03f, 2.56080747e-01f, 1.81262288e-02f, -1.43719435e-01f, 1.43257946e-01f, 5.27860299e-02f, -1.13946773e-01f, 5.46572767e-02f,
  2.12736085e-01f, -2.67254505e-02f, 3.03603470e-01f, 2.73739219e-01f, 3.72175053e-02f, 3.91017377e-01f, 3.31756868e-03f, -3.63253266e-01f, 2.18056917e-01f, -2.93024510e-01f,
  -4.59390283e-02f, 2.22112536e-01f, -2.28169098e-01f, -6.61839321e-02f, -1.28174886e-01f, -3.00640706e-02f, -2.36278102e-01f, -4.95978236e-01f, 1.77185431e-01f, 2.03960538e-01f,
  7.23524988e-02f, -1.26908675e-01f, -2.41974637e-01f, -1.34763718e-02f, 3.46004784e-01f, -1.24789990e-01f, 2.93055385e-01f, 7.88697526e-02f, -1.97238788e-01f, -1.24028213e-01f,
  5.32827005e-02f, 2.84610450e-01f, 3.82681154e-02f, -1.28896371e-01f, 6.15611672e-02f, 2.30209321e-01f, 2.87623823e-01f, 2.47646332e-01f, 2.20182762e-01f, -1.81013480e-01f,
  8.19563344e-02f, 1.54113621e-01f, 4.53477167e-02f, 2.60392576e-01f, 4.67758477e-02f, 6.67948797e-02f, 2.93830901e-01f, -2.10000679e-01f, -6.59924792e-03f, -3.57711352e-02f,
  1.38978541e-01f, 1.36099849e-02f, -9.74827632e-02f, 2.01558560e-01f, 2.87698388e-01f, 1.68288440e-01f, -4.74521630e-02f, 2.90270716e-01f, -1.83337659e-03f, 7.71953091e-02f,
  1.12512387e-01f, 9.34780613e-02f, 1.80666462e-01f, 2.29622588e-01f, 1.95692509e-01f, 9.94029120e-02f, 3.17022204e-01f, -3.07639353e-02f, 5.09029105e-02f, 5.69361448e-01f,
  -2.85968125e-01f, -1.57572433e-01f, 6.59336671e-02f, 2.58648008e-01f, 2.11498160e-02f, -6.26046211e-02f, -1.41623005e-01f, -2.67407764e-02f, -1.00319959e-01f, 2.12898180e-02f,
  -1.05272204e-01f, -7.14049041e-01f, 1.54429287e-01f, 1.81081295e-01f, 1.45605713e-01f, -9.50092673e-02f, -1.54298246e-01f, -7.06550777e-02f, 3.14215839e-01f, 1.96431011e-01f,
  2.32760131e-01f, 2.04100505e-01f, -2.68045157e-01f, -1.71338618e-01f, 1.31553439e-02f, 4.18093055e-01f, 1.15869522e-01f, -1.63232669e-01f, -2.91038472e-02f, 2.30073959e-01f,
  3.12819809e-01f, 2.39766002e-01f, 2.57208407e-01f, -3.29036079e-02f, -6.16542064e-02f, 7.64760375e-03f, -2.95058787e-01f, 3.05961162e-01f, -8.39971527e-02f, 1.55168381e-02f,
  -2.82462724e-02f, 1.59429684e-02f, 1.41670182e-01f, 2.95812637e-02f, 1.09062828e-01f, 1.18034370e-01f, 6.98182732e-02f, 1.87831804e-01f, -1.54460445e-01f, 1.78673387e-01f,
  -6.29235245e-03f, 1.70360968e-01f, 3.45513001e-02f, 4.83063310e-02f, 2.24279627e-01f, -1.35355338e-01f, 2.15279907e-01f, -5.76894768e-02f, -7.71219656e-02f, -1.08406246e-01f,
  -1.18397541e-01f, -2.10146800e-01f, -1.69797733e-01f, 5.39789677e-01f, -1.35921419e-01f, 3.27875242e-02f, -6.86786398e-02f, 3.41330022e-01f, -1.16071990e-03f, -4.26486522e-01f,
  -8.66660252e-02f, -1.27304941e-01f, -1.64495260e-01f, 1.52190268e-01f, 9.20633674e-02f, -8.37401152e-02f, 1.72046527e-01f, -7.65878037e-02f, -2.10960284e-02f, 2.11558118e-01f,
  2.86576390e-01f, -3.69072445e-02f, -2.72622164e-02f, 1.34451777e-01f, -1.28750280e-01f, -1.42215744e-01f, -2.26251975e-01f, -1.91185430e-01f, 2.10907355e-01f, 1.30020827e-01f,
  -2.43185423e-02f, -8.72261152e-02f, 7.21158609e-02f, 6.08934946e-02f, 1.09452523e-01f, -1.31088719e-02f, -1.02412306e-01f, -1.10995367e-01f, 1.05032600e-01f, -2.12586299e-01f,
  -1.25684932e-01f, 1.27356648e-01f, -1.46137431e-01f, 1.03507400e-01f, 7.76079148e-02f, -2.47159109e-01f, 1.22061618e-01f, 2.24960253e-01f, -4.93708416e-04f, 2.38351300e-01f,
  1.13437943e-01f, 2.04395205e-01f, -1.01115033e-01f, 1.35783300e-01f, 1.32290408e-01f, 1.21787123e-01f, 5.79017848e-02f, 3.27878930e-02f, 2.35392511e-01f, -9.62822437e-02f,
  1.44839631e-02f, 2.00993955e-01f, 2.73000628e-01f, 7.60304229e-03f, 8.38245153e-02f, -2.45298818e-01f, -2.22831339e-01f, 6.52552545e-01f, -2.78671682e-01f, 8.67192540e-03f,
  -8.33976269e-03f, 1.68410391e-01f, -2.45734543e-01f, -1.57880381e-01f, -1.10746488e-01f, 4.40922044e-02f, -1.61001712e-01f, 3.01520079e-01f, -4.18833867e-02f, -2.44673878e-01f,
  -1.27906844e-01f, 1.42675146e-01f, -2.21109226e-01f, 1.43407285e-01f, 1.06878445e-01f, -3.18950154e-02f, 6.82083741e-02f, 1.09574702e-02f, -1.91917077e-01f, -3.21834117e-01f,
  -2.48175576e-01f, -2.21054792e-01f, 5.98253123e-02f, 1.06003292e-01f, 1.34014055e-01f, -3.17248911e-01f, 2.35731862e-02f, -5.18264621e-02f, 1.78113446e-01f, 1.25572428e-01f,
  -1.08730063e-01f, -6.29148036e-02f, 1.71156064e-01f, -1.56276487e-02f, 2.49864027e-01f, -2.94843346e-01f, 1.21456020e-01f, 3.27438563e-02f, 1.88273668e-01f, 1.03882387e-01f,
  -4.85473201e-02f, -2.21517676e-05f, 1.17124327e-01f, -1.98762119e-01f, -1.33393586e-01f, -2.55229414e-01f, 1.11294255e-01f, 9.74188000e-03f, -2.45382652e-01f, -1.88974380e-01f,
  -6.46673813e-02f, -1.60042852e-01f, 9.76578966e-02f, -5.83923422e-03f, -7.23728165e-02f, 1.61522523e-01f, 3.24715763e-01f, -5.59838824e-02f, 9.58036408e-02f, 1.24096267e-01f,
  8.35193396e-02f, 6.56697676e-02f, -2.18721226e-01f, -1.51341930e-01f, 2.11680576e-01f, -1.50538877e-01f, -2.26348504e-01f, 1.03635676e-01f, 9.61354747e-02f, 1.58917561e-01f,
  -3.74399066e-01f, -6.83327913e-02f, -4.53248084e-01f, 1.07115351e-01f, -1.83215246e-01f, -4.30037864e-02f, 1.05510913e-01f, -2.70842969e-01f, -2.12330014e-01f, 1.74029097e-01f,
  -9.48637053e-02f, -2.14782164e-01f, -9.64752361e-02f, 1.40082479e-01f, 1.42264995e-03f, 1.93320736e-01f, -7.74690695e-03f, 4.71497588e-02f, 8.32895562e-02f, 1.60332501e-01f,
  1.99490398e-01f, -8.65898952e-02f, -1.07040241e-01f, 1.46228850e-01f, 1.97411492e-01f, 7.89879542e-03f, 1.14598744e-01f, -8.65437090e-02f, -3.64615470e-02f, 2.02739030e-01f,
  -1.46429852e-01f, -2.45957002e-01f, 4.20186147e-02f, 2.09778666e-01f, -7.84204453e-02f, 2.92599618e-01f, -1.18220203e-01f, -7.54862130e-02f, -1.03318468e-02f, 3.14111143e-01f,
  2.65211493e-01f, 1.95411831e-01f, 4.12254445e-02f, 9.64221507e-02f, 1.90863132e-01f, 1.67564079e-01f, 1.89494222e-01f, -1.27256900e-01f, 1.11500986e-01f, -1.18054887e-02f,
  -7.46287480e-02f, 4.98790205e-01f, -4.62967530e-02f, 1.26314061e-02f, -3.50589722e-01f, 3.59013528e-02f, 1.56454459e-01f, 9.09077153e-02f, 2.72381961e-01f, 2.10756823e-01f,
  -7.86165446e-02f, 2.08781689e-01f, -1.15404889e-01f, 3.19033898e-02f, -1.92711805e-03f, 2.93175757e-01f, 1.07405834e-01f, -1.67332992e-01f, 2.99977720e-01f, 1.01547167e-01f,
  -1.62637711e-01f, 2.19459891e-01f, -1.79851845e-01f, -1.43525198e-01f, 3.78975039e-03f, 3.14273566e-01f, -3.20757151e-01f, 2.69146442e-01f, 8.58324543e-02f, 7.67417401e-02f,
  2.45310172e-01f, 5.14077954e-02f, -9.25103277e-02f, -6.91814348e-02f, -1.20269641e-01f, 1.09812759e-01f, 5.03645316e-02f, 1.99854881e-01f, -3.68803814e-02f, -3.27179581e-02f,
  1.06699802e-01f, -3.09250236e-01f, 5.30558825e-02f, -7.48516470e-02f, 2.41792630e-02f, 2.09213823e-01f, 2.73960769e-01f, -1.59749866e-01f, 3.20049107e-01f, 1.32733181e-01f,
  2.19482481e-01f, 2.18702927e-01f, 2.19593212e-01f, 2.00989470e-02f, 2.09001750e-02f, -1.64003506e-01f, 2.15620846e-01f, 4.50054348e-01f, -5.83125651e-02f, 2.27558509e-01f,
  8.82517770e-02f, 1.54397666e-01f, 2.72879541e-01f, 3.46535087e-01f, 2.00868905e-01f, 1.85961053e-01f, -1.81287974e-02f, -1.19043164e-01f, -3.24965343e-02f, 1.13927282e-01f,
  -2.92954445e-01f, -2.28946097e-02f, -1.59187689e-01f, 3.08074862e-01f, 9.38743502e-02f, -3.81683677e-01f, 1.04693649e-03f, 5.67017086e-02f, -7.58231282e-02f, 3.63453925e-01f,
  2.34766081e-01f, 2.77751356e-01f, -4.62060310e-02f, -1.36692896e-01f, -1.72844548e-02f, 2.09050015e-01f, 2.87596852e-01f, -6.54969513e-02f, -6.98638186e-02f, 2.16743648e-01f,
  -1.02859452e-01f, -1.22779042e-01f, -3.28211665e-01f, 1.17978677e-01f, -4.41045165e-02f, -6.30727187e-02f, 2.89541095e-01f, -8.50690082e-02f, 1.99339762e-01f, -3.09800208e-01f,
  3.26357991e-01f, 3.44032012e-02f, -5.25267213e-04f, 3.89854044e-01f, 1.04417704e-01f, -3.19923103e-01f
};

// L2_fan_Bp_bar (Shape: 1 x 14)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 14;
const float L2_fan_Bp_bar_data[] = {
  -5.26886769e-02f, -1.68560296e-02f, -9.39256325e-02f, 8.35504532e-02f, 1.22755729e-01f, 2.34889425e-02f, 8.75709355e-02f, 4.32420932e-02f, 1.77826256e-01f, -7.37833325e-04f,
  1.52023733e-01f, 8.90095830e-02f, 1.44800708e-01f, 1.96321309e-01f
};

// L3_fan_Wp (Shape: 25 x 64)
const int L3_fan_Wp_rows = 25;
const int L3_fan_Wp_cols = 64;
const float L3_fan_Wp_data[] = {
  1.68416962e-01f, 4.65578921e-02f, -6.74211383e-02f, 2.54208595e-01f, -4.75007249e-03f, -1.34249285e-01f, -2.81124085e-01f, -8.02029222e-02f, 8.11396390e-02f, 5.66901304e-02f,
  8.51960108e-02f, -7.93061331e-02f, 1.04223937e-01f, -2.98170328e-01f, -9.56073776e-02f, 1.27363235e-01f, -1.55308336e-01f, -1.46402508e-01f, -1.97222367e-01f, 2.16283537e-02f,
  1.39618218e-01f, -6.62906393e-02f, 1.98966607e-01f, -1.43753737e-01f, -3.82223018e-02f, -1.25323758e-01f, -1.36723235e-01f, 1.48964138e-03f, 1.44190341e-01f, 2.50199467e-01f,
  -1.36146937e-02f, 1.58666074e-01f, -1.28004625e-01f, -1.87153652e-01f, 1.29408851e-01f, 2.68616050e-01f, -1.93408057e-01f, -2.84534460e-03f, -3.18257749e-01f, -1.15057766e-01f,
  -1.29332423e-01f, -5.72286770e-02f, -6.31055934e-03f, 2.47830585e-01f, 9.36147496e-02f, 1.26732707e-01f, -5.74817471e-02f, 2.46427178e-01f, 3.41192275e-01f, -5.98940067e-02f,
  6.61219135e-02f, 2.06612885e-01f, 6.14712760e-02f, 2.57123783e-02f, 7.72416890e-02f, -1.53871356e-02f, 6.30675256e-02f, -1.70007110e-01f, -2.09851936e-02f, -1.27684399e-01f,
  -7.52286464e-02f, -1.50234863e-01f, 2.06027348e-02f, 3.85045037e-02f, 4.03637104e-02f, -1.53902262e-01f, 1.16103970e-01f, -2.90099055e-01f, -2.12304369e-01f, -1.53042987e-01f,
  1.52511761e-01f, -2.38678411e-01f, -1.39632791e-01f, 5.97150512e-02f, -8.72878283e-02f, -1.03203706e-01f, 8.04239586e-02f, 1.71023890e-01f, -1.61282629e-01f, -1.24869175e-05f,
  3.27680856e-01f, -7.09233955e-02f, 1.37720019e-01f, -2.30660185e-01f, -1.13062814e-01f, -1.29495874e-01f, -1.28980622e-01f, 8.80140364e-02f, -1.77257936e-02f, 6.93466812e-02f,
  -1.13917693e-01f, -3.40927998e-03f, -2.19705522e-01f, 1.90724321e-02f, 7.06687942e-03f, -3.94982427e-01f, -2.16552213e-01f, -1.07297406e-01f, 6.60757199e-02f, -2.37472743e-01f,
  -2.85794623e-02f, 3.71754497e-01f, -1.98164433e-01f, -1.24775499e-01f, -2.90973019e-02f, -3.09102029e-01f, 7.25745112e-02f, 3.40798404e-03f, 2.71051556e-01f, -4.27879356e-02f,
  3.46628934e-01f, -4.16495681e-01f, -7.31708407e-02f, 2.57819984e-02f, 1.78602915e-02f, -5.85121065e-02f, -3.92613783e-02f, -1.80650260e-02f, -7.22349212e-02f, 2.46485800e-01f,
  -1.68617100e-01f, 2.29179976e-03f, -1.18405633e-02f, -6.84098946e-03f, -1.60018280e-01f, -8.91763717e-02f, -1.19359300e-01f, -2.91428287e-02f, 8.34103450e-02f, 1.18827755e-02f,
  -2.38152310e-01f, 9.87366810e-02f, 1.16125150e-02f, -1.40280217e-01f, -1.07188515e-01f, 1.45896291e-02f, -7.09541589e-02f, -8.88479725e-02f, 1.82306811e-01f, -1.72264159e-01f,
  -1.59399211e-01f, -7.98262432e-02f, -1.82913765e-01f, -1.41602725e-01f, -5.48864640e-02f, 4.99369726e-02f, -1.34812355e-01f, -1.59453660e-01f, 1.59355059e-01f, -5.76216765e-02f,
  -1.68118596e-01f, -1.27067566e-01f, 3.04119885e-01f, -1.84306666e-01f, 2.52607375e-01f, 7.34893233e-02f, -3.70590799e-02f, -2.48923913e-01f, -8.74896795e-02f, 8.58627707e-02f,
  6.38297498e-02f, -2.17596814e-01f, -2.36516148e-02f, 1.48226516e-02f, 2.35877082e-01f, -1.90593183e-01f, 1.01244438e-03f, 5.41752726e-02f, 1.44454511e-03f, 3.13510418e-01f,
  4.12285961e-02f, -2.33053029e-01f, -3.12980972e-02f, 2.31669798e-01f, -1.64246395e-01f, 3.79315346e-01f, -1.41027629e-01f, 2.74212867e-01f, 2.09852587e-02f, -1.14128977e-01f,
  1.01034835e-01f, -1.32248402e-01f, 5.31258099e-02f, -4.26913202e-02f, -1.57544389e-01f, -1.25486538e-01f, -1.28618643e-01f, 3.32058966e-02f, 1.63953781e-01f, -1.17858529e-01f,
  1.04305446e-02f, -3.01737897e-02f, -1.00977562e-01f, -9.69059020e-02f, -9.63273421e-02f, -1.22986823e-01f, -3.71594680e-03f, -1.15953237e-01f, 3.63315865e-02f, -3.88825722e-02f,
  -1.10831037e-01f, -4.19697650e-02f, -5.53187989e-02f, -1.23915195e-01f, 1.09662205e-01f, 5.15127964e-02f, 1.52348399e-01f, 6.63512051e-02f, -1.44846350e-01f, -9.86396819e-02f,
  -2.16817437e-03f, -1.12682842e-02f, 1.17706634e-01f, 1.07245967e-01f, 3.57082859e-02f, 4.47046570e-02f, -2.62445331e-01f, 1.29433528e-01f, -9.81308743e-02f, 8.56220499e-02f,
  2.95913517e-01f, -9.03142169e-02f, -1.79113314e-01f, 1.28713539e-02f, 2.13284597e-01f, 1.12470210e-01f, 1.41653061e-01f, 1.59226999e-01f, 7.80300125e-02f, -3.40083838e-02f,
  -2.87776086e-02f, 2.74390983e-03f, 1.54491767e-01f, -5.80701698e-03f, -1.01531826e-01f, 1.81115538e-01f, 3.82030010e-02f, -3.53502929e-02f, -1.28837630e-01f, 2.07646877e-01f,
  6.61032572e-02f, -2.77848411e-02f, -1.35313615e-01f, -1.92551851e-01f, 1.26067907e-01f, -9.31770131e-02f, 1.26372889e-01f, -1.05451323e-01f, 5.52821197e-02f, 1.29280373e-01f,
  2.38384083e-01f, -1.59542724e-01f, 8.88253003e-02f, 6.34617656e-02f, -1.70898512e-01f, -1.48615941e-01f, -1.74758378e-02f, -1.44112185e-01f, 7.45220855e-02f, 1.75302207e-01f,
  5.19572049e-02f, 2.39186347e-01f, -5.11502959e-02f, -2.10562926e-02f, 4.04265299e-02f, -4.29653982e-03f, -1.99836388e-01f, -3.55114974e-02f, 2.02823088e-01f, 1.37406617e-01f,
  3.49278860e-02f, 1.39954314e-01f, 1.58313699e-02f, 6.38719499e-02f, 1.34341940e-02f, 8.93178210e-02f, -1.48171932e-01f, 1.25876904e-01f, -5.63102029e-02f, 1.52566046e-01f,
  -1.03908047e-01f, 1.00278750e-01f, -8.03331379e-03f, 4.37030122e-02f, 2.99974322e-01f, -1.58390403e-01f, 1.20574802e-01f, -1.48861334e-01f, 4.84187379e-02f, 8.90675709e-02f,
  8.17908198e-02f, 1.61143720e-01f, 2.28386238e-01f, -3.07474524e-01f, 1.30894363e-01f, -1.73357844e-01f, 2.75490671e-01f, 1.83273032e-01f, 7.85896555e-02f, -6.73063323e-02f,
  -1.20973997e-02f, 7.01486841e-02f, 4.03636694e-02f, -1.44112274e-01f, -2.44673327e-01f, -8.01006556e-02f, -9.35717821e-02f, 5.45562692e-02f, 1.84715420e-01f, -1.50251985e-01f,
  2.40227163e-01f, -1.87684625e-01f, -1.12382071e-02f, 1.13335259e-01f, 1.36308506e-01f, 1.20144054e-01f, 1.71822086e-01f, 2.80646890e-01f, 2.31652811e-01f, 7.81004280e-02f,
  2.18738973e-01f, 8.69029835e-02f, 5.99987507e-02f, 2.61874646e-01f, -1.95350096e-01f, -4.04061005e-02f, -9.92846489e-02f, 2.08495930e-01f, 2.86502182e-01f, 1.58255726e-01f,
  4.15741019e-02f, 3.09838094e-02f, -1.28781438e-01f, -2.20896378e-01f, -1.76816687e-01f, 1.36002913e-01f, -2.48826310e-01f, -3.28022987e-02f, -2.00833976e-01f, -1.95137151e-02f,
  -5.27321100e-02f, -1.44670516e-01f, 4.35350984e-02f, -1.71153247e-01f, 2.11179480e-01f, 2.11209562e-02f, -8.87882039e-02f, -3.54201347e-02f, 2.79028773e-01f, 2.43834659e-01f,
  -1.16025940e-01f, 4.75688241e-02f, -1.47500381e-01f, -2.65118122e-01f, 5.59879243e-02f, 2.47296840e-01f, -1.88595176e-01f, 5.74243292e-02f, -2.47489139e-01f, -2.24072605e-01f,
  -5.13730571e-03f, -1.48099409e-02f, 1.12624541e-01f, 2.37369373e-01f, 2.52757341e-01f, -1.30878881e-01f, 8.22081417e-02f, 1.46942064e-01f, 6.77368566e-02f, -1.01946965e-01f,
  -7.10763037e-02f, 1.05093412e-01f, -8.24955180e-02f, -1.10065058e-01f, 1.51412589e-02f, -1.04782432e-01f, -1.77297294e-01f, -1.27556711e-01f, 1.51282430e-01f, 6.57284865e-03f,
  -1.15716770e-01f, 9.18742865e-02f, 1.18586700e-02f, -1.78919554e-01f, 5.30172139e-02f, 5.62177151e-02f, 1.64749965e-01f, 4.81975079e-02f, -2.21407022e-02f, -9.36765298e-02f,
  -1.11739516e-01f, 1.97976932e-01f, 4.71971259e-02f, 2.41473280e-02f, 2.31011748e-01f, -4.38862890e-02f, -2.22478300e-01f, -1.81732640e-01f, -1.25735506e-01f, 6.12707436e-02f,
  -2.11487278e-01f, 9.97222811e-02f, -2.68786103e-02f, 7.17064291e-02f, 1.37680084e-01f, -1.03708789e-01f, -2.78322827e-02f, -8.30209404e-02f, 2.02407733e-01f, 2.20901474e-01f,
  1.68557480e-01f, -1.89775042e-02f, 4.22383547e-02f, -6.66378858e-03f, 1.30459145e-02f, 3.41370165e-01f, 2.24509418e-01f, 1.33082345e-01f, -1.29037082e-01f, 8.74032676e-02f,
  -6.34705648e-02f, 7.06215110e-03f, 4.49877344e-02f, 2.45710984e-02f, 6.54260814e-02f, -8.57219100e-02f, -1.32072136e-01f, 2.51988739e-01f, -6.20996654e-02f, -8.06426778e-02f,
  -2.51632035e-01f, 1.97020486e-01f, -1.16916023e-01f, -1.98825285e-01f, -1.25032142e-01f, 1.77754149e-01f, 8.19867775e-02f, 2.00076252e-01f, -1.08195469e-01f, -1.54948473e-01f,
  4.23676707e-03f, 1.00039110e-01f, 7.94080198e-02f, -1.06441572e-01f, -3.02320689e-01f, -3.04689538e-02f, 1.73235059e-01f, -2.94691175e-01f, -2.69126505e-01f, -1.14348330e-01f,
  1.68105438e-01f, 4.01633568e-02f, 5.11209853e-03f, -3.60045731e-02f, -2.02435642e-01f, -3.78407612e-02f, -5.96096329e-02f, -2.07626179e-01f, 6.37361333e-02f, 7.23426342e-02f,
  2.28833124e-01f, -8.34793299e-02f, -6.75700381e-02f, -6.49703816e-02f, 1.50628418e-01f, 7.68436491e-02f, 7.58313015e-02f, -1.02139600e-01f, -9.53129306e-02f, -8.26314762e-02f,
  9.55852121e-03f, 1.14873154e-02f, 2.82557830e-02f, -1.97722301e-01f, 1.97703704e-01f, 1.47174478e-01f, 1.51714245e-02f, -1.00492515e-01f, 1.83906749e-01f, 2.35801399e-01f,
  4.81076576e-02f, -6.64112717e-03f, 1.35247082e-01f, -1.47396969e-02f, 5.79146147e-02f, 4.95218970e-02f, -3.99878547e-02f, -1.44564420e-01f, -1.31149236e-02f, -1.53426334e-01f,
  2.70336438e-02f, -8.12592730e-02f, -1.00132599e-01f, -3.90368663e-02f, -6.29475042e-02f, 1.26355514e-02f, -1.94215730e-01f, -9.26263109e-02f, -1.28110126e-01f, 1.61771178e-01f,
  -1.15806458e-03f, 4.02634516e-02f, -1.75358467e-02f, 8.06648433e-02f, -2.80893240e-02f, 2.82517582e-01f, 3.03494096e-01f, 6.02601171e-02f, 2.18374506e-01f, -1.52519569e-02f,
  8.76615271e-02f, 2.21035182e-01f, -7.38092586e-02f, -3.83433625e-02f, 1.86211482e-01f, 1.30715609e-01f, -3.52434926e-02f, -4.42302637e-02f, -5.05023301e-02f, -1.47196621e-01f,
  1.48486689e-01f, 5.54802790e-02f, -1.54007316e-01f, 3.67397591e-02f, 2.12923288e-02f, 1.10861622e-01f, -5.05850576e-02f, 5.58780096e-02f, 3.29907127e-02f, 1.98066980e-02f,
  -2.47491263e-02f, -1.14448871e-02f, -6.27577603e-02f, -1.62737489e-01f, 2.41446719e-02f, -1.21133372e-01f, -1.17553182e-01f, 2.14710280e-01f, -1.03163302e-01f, -6.07979372e-02f,
  4.08283062e-03f, 1.91421602e-02f, 1.50616154e-01f, -1.63212568e-01f, -1.75898597e-01f, -1.03047699e-01f, -9.27737057e-02f, -1.26678580e-02f, -1.56111419e-01f, 9.11121443e-02f,
  2.00119559e-02f, -1.14787996e-01f, -2.40916252e-01f, -2.20613867e-01f, 1.27103791e-01f, 5.43519929e-02f, -2.76137982e-02f, -2.44605586e-01f, 1.95182487e-01f, -3.27254266e-01f,
  5.41625358e-02f, -6.62881583e-02f, -1.86181843e-01f, 8.72571096e-02f, -6.08274639e-02f, 1.62130654e-01f, -7.55163729e-02f, 1.21405810e-01f, -2.90524159e-02f, 2.25484774e-01f,
  1.66402385e-02f, -1.10524535e-01f, -7.10637122e-02f, -8.71397257e-02f, -8.27106535e-02f, 3.28166820e-02f, 5.61252749e-03f, 4.50374782e-02f, 1.34824321e-01f, 1.23996869e-01f,
  -5.87380193e-02f, 7.04662725e-02f, -2.46866122e-02f, 8.07798356e-02f, 2.30624869e-01f, 3.01927805e-01f, -5.83090149e-02f, 8.89076144e-02f, 1.00307755e-01f, -3.98159772e-02f,
  1.98900953e-01f, 1.42023802e-01f, -3.02097917e-01f, -8.36455077e-03f, -1.98162422e-01f, 1.75122410e-01f, -3.08972187e-02f, -4.46317811e-03f, 2.49711126e-01f, 1.26558051e-01f,
  -1.66452542e-01f, -1.40461437e-02f, -1.24162041e-01f, 2.64959456e-03f, 1.75994799e-01f, -6.39939727e-03f, -3.16937268e-02f, -4.07824805e-03f, -1.09157108e-01f, 8.86193737e-02f,
  -2.43393257e-01f, 2.19905585e-01f, -1.62413210e-01f, 1.94806203e-01f, -2.00382695e-01f, -2.51336724e-01f, -2.15939045e-01f, 1.52806878e-01f, -1.68245643e-01f, 1.95811167e-01f,
  -2.77640313e-01f, -4.92611974e-02f, -1.40414327e-01f, 2.29851648e-01f, 3.38238508e-01f, -1.04992958e-02f, -7.29899183e-02f, 2.77160648e-02f, 9.54714566e-02f, -3.91344130e-02f,
  -1.14359461e-01f, -6.22805245e-02f, 1.20177314e-01f, -9.27813537e-03f, 5.91542162e-02f, 1.58692494e-01f, 1.41412765e-01f, -1.17685802e-01f, -2.08485667e-02f, 1.63560361e-01f,
  1.21164165e-01f, -9.02242120e-03f, 6.57970682e-02f, 9.33031961e-02f, -2.99146809e-02f, 9.51441526e-02f, -2.29570568e-01f, 1.91015378e-01f, 4.96201729e-03f, 1.28268197e-01f,
  4.01368625e-02f, -6.07923651e-03f, -1.05430968e-02f, -2.45999441e-01f, 4.05963995e-02f, -6.18402623e-02f, -2.46706709e-01f, -5.15976697e-02f, 3.45640886e-03f, 5.27160540e-02f,
  1.66739061e-01f, 1.66017845e-01f, -7.17855245e-02f, 6.06500991e-02f, 2.68032290e-02f, -1.98450550e-01f, -4.86366786e-02f, -1.32236434e-02f, -9.76991374e-04f, 1.85105428e-01f,
  -8.45134929e-02f, -9.02124774e-03f, 1.03255123e-01f, -1.55163314e-02f, 3.10173333e-01f, 6.49541393e-02f, 1.11133732e-01f, -1.40623987e-01f, 2.79477295e-02f, 1.08661838e-01f,
  2.65084565e-01f, -5.44465408e-02f, -3.36956829e-01f, -7.00166523e-02f, 1.42970204e-01f, -1.33490330e-02f, -1.73657954e-01f, -2.75931731e-02f, 4.48214775e-03f, -1.47550657e-01f,
  2.87368566e-01f, 4.30307314e-02f, 2.93527879e-02f, -8.72170851e-02f, 9.94021520e-02f, -1.63994297e-01f, 1.05839722e-01f, -1.46903321e-01f, -1.19232081e-01f, -2.27576531e-02f,
  -2.28250131e-01f, -1.19817853e-02f, 1.79044843e-01f, -6.07358925e-02f, -5.85563704e-02f, 1.36897996e-01f, 2.68544436e-01f, 1.14415281e-01f, -2.78203338e-01f, 2.94803013e-03f,
  -9.72217843e-02f, 5.04568592e-02f, 1.56772494e-01f, 8.41625631e-02f, -5.47893345e-02f, 1.24814048e-01f, -2.20811162e-02f, 1.80347741e-01f, -1.66964188e-01f, 1.28774554e-01f,
  1.97549374e-03f, -9.09423828e-02f, -5.49631715e-02f, 1.31612793e-01f, 9.55869351e-03f, -7.40630180e-03f, 1.04547709e-01f, 1.15618251e-01f, 4.68406938e-02f, -4.08134004e-03f,
  -6.75700307e-02f, -4.14718920e-03f, -1.69246942e-01f, 6.91496879e-02f, -2.97988881e-03f, 1.84501529e-01f, -3.94649267e-01f, -1.52264968e-01f, 6.03286400e-02f, -5.40643595e-02f,
  1.79896787e-01f, -7.03210160e-02f, -1.51642427e-01f, -5.62867261e-02f, 3.29737179e-02f, -2.22130567e-01f, 6.15539588e-02f, -4.53655720e-02f, 5.51293381e-02f, 5.51396143e-03f,
  1.74469221e-02f, -2.52806127e-01f, -4.49880324e-02f, 5.08736968e-02f, 1.30250990e-01f, -1.14800550e-01f, -2.40645126e-01f, 5.57362027e-02f, 5.83474152e-02f, 2.57622123e-01f,
  -2.22503960e-01f, -1.01298384e-01f, -4.65182064e-04f, 2.34733611e-01f, -5.33200726e-02f, -1.70412093e-01f, -1.85608074e-01f, 2.01182500e-01f, 6.83386028e-02f, 2.98732221e-02f,
  9.87546816e-02f, 1.14898691e-02f, 8.12354237e-02f, -1.34060711e-01f, -8.94471854e-02f, 4.63294517e-03f, -2.56955117e-01f, -2.05032408e-01f, -1.65344253e-02f, -1.34639695e-01f,
  -7.70774782e-02f, 2.17684984e-01f, 4.67914194e-02f, -1.51795834e-01f, -1.79655284e-01f, 4.78477404e-02f, -1.65976420e-01f, -3.65980864e-01f, 1.01105273e-01f, -1.47412509e-01f,
  -9.42182913e-02f, -3.51702422e-02f, 1.42180964e-01f, -1.40831158e-01f, 2.32714504e-01f, 2.67600268e-01f, -6.28325865e-02f, -2.92045742e-01f, 2.67003626e-02f, 1.29828066e-01f,
  -6.71341717e-02f, -6.16704114e-02f, -4.98457663e-02f, -1.30381584e-01f, 2.29886830e-01f, 1.01809055e-02f, -7.46370479e-02f, -1.01323687e-02f, -8.81762430e-02f, 1.34944841e-01f,
  1.73749104e-01f, -2.20281139e-01f, -4.10751328e-02f, -3.86656895e-02f, 1.60087630e-01f, 1.92853808e-01f, -3.26058388e-01f, -3.27842608e-02f, -2.12952524e-01f, 8.11772719e-02f,
  -1.16288051e-01f, 6.11849092e-02f, -4.87848073e-02f, -8.52955952e-02f, -1.45052999e-01f, 2.51146294e-02f, 9.88552347e-02f, 1.83423832e-01f, 1.22345231e-01f, -1.12955511e-01f,
  1.21337041e-01f, -1.43242985e-01f, 3.78283225e-02f, -4.40406688e-02f, -1.66548878e-01f, -1.28992304e-01f, -2.60598928e-01f, -3.12555522e-01f, -2.27482349e-01f, 5.07202232e-03f,
  -1.03026628e-01f, -2.94778556e-01f, -1.82471842e-01f, 7.77421370e-02f, -1.87941670e-01f, 1.11977793e-01f, 1.69502765e-01f, -1.73273757e-02f, 5.85012473e-02f, -1.16093628e-01f,
  1.95382610e-02f, -7.41101503e-02f, 3.01968813e-01f, 9.30000320e-02f, 3.38204391e-02f, 4.42393590e-03f, 7.67936260e-02f, -1.70823112e-02f, 2.51894265e-01f, -1.42563665e-02f,
  -1.99724600e-01f, -9.62549895e-02f, -3.85486931e-02f, 2.29106233e-01f, -2.96347797e-01f, -2.09010825e-01f, 8.39644969e-02f, -2.54640430e-01f, -2.37596318e-01f, 8.49272087e-02f,
  2.19068334e-01f, -3.29395644e-02f, -3.40477586e-01f, 1.21344358e-01f, -1.34262770e-01f, 2.69175172e-01f, -1.06378987e-01f, 8.56248811e-02f, -3.45645249e-01f, 1.40080452e-01f,
  3.53012770e-01f, 1.15931213e-01f, 7.02365264e-02f, -3.67968976e-02f, 4.89977524e-02f, -6.32380396e-02f, 3.88032105e-03f, 7.63039812e-02f, 1.15842916e-01f, -2.30090424e-01f,
  -1.69773117e-01f, -1.32585749e-01f, -1.10421821e-01f, -1.86135378e-02f, 6.61216527e-02f, 1.13559239e-01f, -5.99714220e-02f, -1.72778859e-03f, -5.52802123e-02f, -5.14692254e-02f,
  1.48928717e-01f, -2.38594189e-01f, 1.68120474e-01f, -7.33570158e-02f, -4.43239808e-02f, -2.55164444e-01f, 1.83559760e-01f, -8.56118947e-02f, -6.32425919e-02f, 7.14999065e-02f,
  -1.69271797e-01f, -3.37122902e-02f, 6.40410036e-02f, 1.99318662e-01f, 5.09817638e-02f, -1.66951880e-01f, -6.58196881e-02f, -9.67132822e-02f, -8.84733573e-02f, 3.30541730e-02f,
  6.12782761e-02f, -1.09532841e-01f, 2.19597623e-01f, 2.77872205e-01f, -2.91971322e-02f, -2.60368794e-01f, 1.51617885e-01f, 3.51850808e-01f, -1.24019407e-01f, -6.57757372e-02f,
  -4.93418090e-02f, 1.98859237e-02f, 7.98477456e-02f, -3.84855382e-02f, 8.33099410e-02f, 8.27361569e-02f, 3.13521884e-02f, 1.85658574e-01f, -7.72325695e-02f, -1.28672868e-01f,
  -5.86497539e-04f, 9.28970799e-02f, -9.48846526e-03f, 2.02880129e-01f, -1.93902686e-01f, 2.30356716e-02f, -1.79870203e-01f, 3.41031440e-02f, -1.08089544e-01f, 2.57601757e-02f,
  1.74434721e-01f, 1.24158576e-01f, -6.26075342e-02f, -1.55733943e-01f, 1.38371848e-02f, 1.29744768e-01f, 2.81002879e-01f, 3.12853674e-03f, 1.63547575e-01f, 7.99445137e-02f,
  -1.63491577e-01f, -2.64698826e-02f, -1.28895864e-01f, -7.59588256e-02f, -5.25264814e-02f, -1.98905692e-01f, 1.15574058e-02f, -1.35725081e-01f, 9.14650708e-02f, -1.53213769e-01f,
  -1.31618693e-01f, -1.00127622e-01f, -2.83070300e-02f, 1.98140070e-01f, -5.90125285e-02f, -9.17668417e-02f, -1.60420835e-02f, -7.65331089e-02f, -1.71764404e-01f, -1.64059669e-01f,
  -1.17785126e-01f, -8.09639618e-02f, 4.81920689e-02f, -5.25101833e-02f, -1.47528529e-01f, -1.89642176e-01f, 4.26129773e-02f, 8.10130388e-02f, -3.24356034e-02f, -8.58135521e-02f,
  1.01800114e-01f, 7.27165118e-03f, -1.78713620e-01f, -2.19368637e-01f, 1.21870570e-01f, -1.20583743e-01f, 2.10639045e-01f, -2.70342737e-01f, -5.06148152e-02f, 3.11679281e-02f,
  -4.26511690e-02f, 2.08821386e-01f, 3.45869735e-02f, -3.00810933e-01f, 1.75801769e-01f, 2.08127826e-01f, -1.08666010e-01f, 6.25095740e-02f, -1.16758905e-01f, 7.85153657e-02f,
  -6.12006895e-02f, -1.67129621e-01f, 7.14782551e-02f, -6.88989460e-02f, 2.87548423e-01f, 9.62388068e-02f, -3.93083878e-02f, -1.01560526e-01f, -1.63756013e-02f, 1.76688105e-01f,
  2.50816077e-01f, 2.75780857e-02f, -1.51183262e-01f, 1.53004423e-01f, 7.09210634e-02f, -8.85650516e-02f, -3.10495734e-01f, 2.19241321e-01f, 1.48729300e-02f, -1.88985243e-01f,
  -2.01810449e-01f, -2.43976146e-01f, 1.34252412e-02f, 6.52683079e-02f, 1.42700315e-01f, 1.07564731e-02f, -1.94129795e-01f, 2.62278747e-02f, -4.26337793e-02f, 9.05092359e-02f,
  -1.48919178e-02f, 9.02994573e-02f, -1.69662341e-01f, 8.72588754e-02f, -1.05948053e-01f, -9.93197262e-02f, -3.22009847e-02f, -1.05271064e-01f, 1.44329742e-01f, 4.05275047e-01f,
  -1.46874338e-01f, 1.75021574e-01f, 2.19969809e-01f, 1.48738148e-02f, -2.18262300e-01f, -3.33889574e-01f, 3.58687460e-01f, 3.28662902e-01f, 1.25456341e-02f, -6.26555085e-02f,
  -1.24460578e-01f, 6.66974708e-02f, -1.82507604e-01f, 1.37683317e-01f, -5.27989632e-03f, -9.26588997e-02f, -3.91774029e-01f, 2.60695130e-01f, 3.22734229e-02f, -2.26940870e-01f,
  -5.61648458e-02f, 1.37714550e-01f, 1.23081163e-01f, 1.75244614e-01f, -9.84505042e-02f, 1.26177058e-01f, 1.09312035e-01f, 1.49209332e-02f, -1.52469352e-01f, -9.41732004e-02f,
  8.44229013e-02f, 1.40937254e-01f, -1.38160512e-01f, -6.47469908e-02f, -1.44430131e-01f, 1.51520237e-01f, -1.66041747e-01f, -2.01292440e-01f, 1.10359050e-01f, -3.26056592e-02f,
  2.45156772e-02f, 1.96749330e-01f, 1.16341479e-01f, -8.01789090e-02f, -1.42161295e-01f, -6.89873472e-02f, -2.29258254e-01f, 2.15451077e-01f, 1.93558782e-01f, -7.86040276e-02f,
  -1.69721395e-01f, -1.33623466e-01f, 1.11091681e-01f, -1.14857182e-01f, -8.34440291e-02f, 2.48540893e-01f, -1.98414624e-01f, -1.05288394e-01f, -1.18924350e-01f, -8.01253840e-02f,
  -2.62520075e-01f, -1.69450343e-01f, 3.22202921e-01f, 1.86391830e-01f, -8.86981748e-03f, 2.10608635e-03f, 7.47297406e-02f, 2.09867716e-01f, 8.53786319e-02f, 6.62455261e-02f,
  8.36386010e-02f, -2.28619054e-02f, -1.23457514e-01f, 2.70516366e-01f, 4.50149812e-02f, 3.58158574e-02f, -1.34981513e-01f, 3.28021087e-02f, 2.82439858e-01f, -5.89525290e-02f,
  -1.41713858e-01f, -1.61585793e-01f, 9.20395739e-03f, -7.27252439e-02f, 1.54133633e-01f, 1.29396059e-02f, -6.26379326e-02f, -1.16296731e-01f, 8.62526670e-02f, 2.39196733e-01f,
  6.86923936e-02f, -1.59024354e-02f, -1.57991409e-01f, -3.62224318e-02f, 7.38620088e-02f, 7.06869811e-02f, 2.33267751e-02f, -1.65913850e-01f, -2.38155633e-01f, 1.15815401e-02f,
  2.16732144e-01f, -1.74999610e-01f, 8.38841423e-02f, -1.13629669e-01f, -4.01174486e-01f, -1.91411868e-01f, -1.46835716e-02f, 2.54392829e-02f, 8.11594799e-02f, -2.82699198e-01f,
  -1.15037046e-01f, 9.42581296e-02f, -2.12980449e-01f, -1.14197619e-02f, -8.66496861e-02f, 4.23922352e-02f, 1.32787481e-01f, 1.71576053e-01f, 1.72372833e-01f, -1.58067122e-01f,
  2.47475386e-01f, 3.83415259e-02f, -3.58759165e-02f, 2.27805562e-02f, 2.64734980e-02f, -6.81168959e-02f, -2.43254825e-01f, -1.59516767e-01f, -1.69958428e-01f, 5.38828131e-03f,
  2.01106176e-01f, 3.10071111e-01f, -3.31314169e-02f, -2.17905238e-01f, -7.86973909e-02f, -1.22690253e-01f, 2.77353019e-01f, -2.43861750e-01f, -2.89276212e-01f, 2.27851093e-01f,
  1.60295933e-01f, 1.90277509e-02f, -1.90858424e-01f, -1.52543157e-01f, 1.18155368e-01f, 1.44315124e-01f, -6.99603558e-02f, 6.47386909e-02f, -1.22580212e-02f, 1.49301469e-01f,
  3.16354990e-01f, 2.03675970e-01f, -2.78114248e-03f, 1.30951703e-01f, 3.42965301e-04f, -1.89213917e-01f, -4.37704921e-02f, 6.22843169e-02f, 4.82397377e-02f, -3.26466784e-02f,
  -1.59686774e-01f, 2.23197527e-02f, -3.42135094e-02f, 1.79823846e-01f, -2.26651415e-01f, 1.14575908e-01f, -8.82942900e-02f, 1.38413519e-01f, -1.08601056e-01f, 1.49342164e-01f,
  -1.01606525e-01f, -1.99227571e-01f, -7.01274499e-02f, 1.38828352e-01f, 1.81465730e-01f, -8.13620761e-02f, -3.87087055e-02f, 6.27493486e-02f, -4.25168537e-02f, -3.27351503e-02f,
  3.49322930e-02f, -2.00007260e-01f, -1.14066333e-01f, -1.13195805e-02f, -1.22012980e-01f, -1.93941605e-03f, 8.02893639e-02f, -9.14443135e-02f, 8.91123246e-03f, 8.75505358e-02f,
  1.02281198e-01f, -2.28964254e-01f, 1.08224943e-01f, 1.48382718e-02f, -7.76050761e-02f, 4.51970473e-02f, -9.63925943e-02f, 2.99814820e-01f, -3.05950865e-02f, 9.09547284e-02f,
  1.50231142e-02f, -7.57691264e-02f, 1.55552432e-01f, 4.95919995e-02f, -2.65852846e-02f, 1.46495029e-01f, -2.05381021e-01f, 2.50795752e-01f, 1.44343734e-01f, -1.65083438e-01f,
  -1.45751655e-01f, 1.85357660e-01f, 3.68275903e-02f, 2.50792354e-01f, 1.12433262e-01f, 3.44399512e-01f, 1.45693853e-01f, -1.31749868e-01f, 7.55094318e-03f, -6.57505170e-02f,
  2.30562046e-01f, -7.44434865e-03f, -1.81607142e-01f, -2.11206377e-01f, -1.12529941e-01f, 2.80528851e-02f, 5.94002195e-02f, -1.49953559e-01f, -1.32797927e-01f, 2.78368384e-01f,
  -7.83789232e-02f, 1.45789301e-02f, -1.55565247e-01f, -6.40870482e-02f, 1.37571156e-01f, -1.90078065e-01f, 3.40886682e-01f, 2.21802041e-01f, -3.05721555e-02f, -3.44139457e-01f,
  1.23082273e-01f, -7.19382092e-02f, -7.00398833e-02f, 1.37496650e-01f, -1.88900307e-01f, -4.30800114e-03f, 3.09842341e-02f, -8.92092362e-02f, -3.55670191e-02f, 2.00357661e-02f,
  9.36609581e-02f, 4.18469012e-02f, 4.11508307e-02f, 1.41027197e-01f, -3.23472135e-02f, -2.29336202e-01f, 8.50400999e-02f, -1.68145020e-02f, 2.30122376e-02f, -8.10036808e-02f,
  -5.24409227e-02f, 3.73612940e-01f, -6.89220950e-02f, -2.45905831e-01f, 4.76560593e-02f, -9.67724621e-02f, -7.19416142e-02f, -5.49215637e-02f, -2.71321856e-03f, 1.63204968e-01f,
  -9.88109559e-02f, 3.30592208e-02f, 3.38944554e-01f, -1.06115174e-02f, 1.15993634e-01f, 7.94207901e-02f, -1.50926355e-02f, 3.47372025e-01f, -1.13434128e-01f, -3.04469485e-02f,
  -9.38835591e-02f, -2.95436624e-02f, 1.13996200e-01f, 7.14895055e-02f, 1.58341497e-01f, 6.35155365e-02f, 5.50423600e-02f, -1.16423883e-01f, 2.15178773e-01f, 2.13009357e-01f,
  9.09325853e-02f, -1.55060917e-01f, 1.59162618e-02f, 1.66943818e-01f, -1.06004931e-01f, -1.41184375e-01f, -6.10156804e-02f, -1.74415961e-01f, 2.60622259e-02f, -2.66793579e-01f,
  6.26086369e-02f, 6.55969456e-02f, -1.13445863e-01f, -2.09725946e-01f, -2.64039729e-02f, 9.68255177e-02f, -4.00172621e-02f, 1.06067821e-01f, -1.54873058e-01f, 7.77198151e-02f,
  9.87529978e-02f, 4.81751896e-02f, -9.62690786e-02f, -1.74780235e-01f, -6.97473586e-02f, -1.05286181e-01f, -7.02582896e-02f, 9.67527647e-03f, 4.50929850e-02f, 6.89815059e-02f,
  2.55619794e-01f, 7.60776326e-02f, -1.11282907e-01f, -3.95053774e-01f, 1.26510337e-01f, 9.01652649e-02f, -7.15493336e-02f, -3.05442810e-01f, -2.37382144e-01f, -3.29972178e-01f,
  1.32025540e-01f, 1.36086658e-01f, 2.31206492e-01f, -3.86041701e-02f, -1.32228835e-02f, -4.63656196e-03f, 1.26850232e-01f, -1.37118295e-01f, -1.53762057e-01f, -3.20872338e-03f,
  3.74260135e-02f, 1.48045532e-02f, -9.84816179e-02f, 1.67925403e-01f, -1.34751633e-01f, -2.60455217e-02f, -1.32699043e-01f, -9.06407312e-02f, -4.70923539e-03f, 1.80719763e-01f,
  -5.08356877e-02f, 9.38101113e-02f, 1.29161671e-01f, 1.66839600e-01f, 1.16301835e-01f, -1.66429356e-01f, -2.76140198e-02f, 6.14975542e-02f, -5.31157553e-02f, -1.01942368e-01f,
  -3.76355760e-02f, 1.55987084e-01f, 4.68205437e-02f, -4.78268862e-02f, -1.20511852e-01f, -8.85720402e-02f, -6.12866096e-02f, -9.64348670e-03f, 2.10373402e-01f, -2.33783983e-02f,
  -1.08845592e-01f, -2.25113168e-01f, 7.95185715e-02f, 1.88410282e-01f, -6.15643822e-02f, 2.61329889e-01f, -3.98583412e-02f, 7.63384774e-02f, 1.09301738e-01f, -1.30253285e-01f,
  -3.07397125e-03f, 7.19567761e-02f, -9.87838507e-02f, 3.64057254e-03f, 2.05554679e-01f, 2.70803928e-01f, 1.00473233e-01f, -1.99786112e-01f, -5.94856292e-02f, 1.98390514e-01f,
  -7.23997951e-02f, 1.44532606e-01f, -2.34111920e-01f, 1.15322143e-01f, -4.04983237e-02f, 4.88299876e-03f, -7.45693669e-02f, -7.11477324e-02f, -1.89784110e-01f, 2.19147965e-01f,
  -2.48365939e-01f, 1.07532494e-01f, -1.87037155e-01f, 2.03263909e-01f, -7.48826638e-02f, -6.17307574e-02f, -1.00986481e-01f, -5.00300489e-02f, -1.53758243e-01f, 1.84452087e-01f,
  -4.36701588e-02f, 1.62398607e-01f, -9.18121189e-02f, -9.10715386e-03f, 1.41429514e-01f, -1.37924433e-01f, -1.53683890e-02f, 2.24779293e-01f, 1.52412862e-01f, 6.13087080e-02f,
  8.95592272e-02f, 2.35610947e-01f, 1.02945780e-02f, -9.43984315e-02f, -1.33623913e-01f, -1.71179309e-01f, 8.74173120e-02f, -2.36649677e-01f, 1.88943177e-01f, 6.77948594e-02f,
  2.40714937e-01f, 6.69280859e-03f, 1.57903373e-01f, -3.69830318e-02f, 1.80649117e-01f, 5.64017929e-02f, 8.64977241e-02f, -7.04561025e-02f, 4.30200137e-02f, 2.86388844e-02f,
  -8.38007182e-02f, 1.79666594e-01f, -3.97813655e-02f, 6.85764998e-02f, 2.95774132e-01f, 4.52093733e-03f, -1.69427559e-01f, -2.11983919e-02f, -4.31982242e-02f, 7.06629232e-02f,
  1.00625157e-01f, 1.55663222e-01f, -3.97454984e-02f, 1.60444006e-01f, -1.26949877e-01f, -4.84935977e-02f, -1.68705091e-01f, 1.90058090e-02f, 4.75145578e-02f, 6.59355707e-03f,
  5.07216938e-02f, -1.93463400e-01f, -1.96367487e-01f, 4.08049151e-02f, -1.96117342e-01f, -5.84472716e-02f, -5.55350520e-02f, 1.97092175e-01f, -4.90147248e-02f, 2.49475628e-01f,
  6.05340339e-02f, 1.63595125e-01f, -1.44805610e-01f, -1.73540398e-01f, 2.03116283e-01f, -9.25628319e-02f, 1.90221399e-01f, 1.40501317e-02f, 1.13234423e-01f, 5.43544628e-03f,
  3.77897248e-02f, 8.38735253e-02f, 1.80752888e-01f, 7.81635121e-02f, -1.18920654e-01f, 2.92925328e-01f, 2.06266060e-01f, -1.54719830e-01f, -1.39188422e-02f, 7.49557018e-02f,
  -6.28790911e-03f, -1.61469564e-01f, 2.84004603e-02f, -7.76309147e-02f, 1.85631037e-01f, -1.65722087e-01f, -2.36009330e-01f, -1.12728499e-01f, -3.93386185e-02f, 1.50326759e-01f,
  -6.07763380e-02f, -2.04525907e-02f, -5.39306626e-02f, 6.79460391e-02f, -2.17517510e-01f, -2.91151166e-01f, -6.00218549e-02f, -6.82564005e-02f, -1.90579459e-01f, -4.96967360e-02f,
  -1.13763817e-01f, -1.04487568e-01f, -6.64016381e-02f, -5.09381555e-02f, 1.88505620e-01f, 1.61164716e-01f, -1.03351437e-02f, -1.25814065e-01f, -2.05524176e-01f, -2.35243335e-01f,
  1.84957311e-01f, 1.90666065e-01f, 2.29076385e-01f, -1.05270386e-01f, -1.40833482e-01f, -2.18183577e-01f, 7.60621652e-02f, 1.04665861e-01f, 1.79188818e-01f, -2.81708062e-01f,
  2.44219452e-01f, 1.35854363e-01f, -4.36106324e-03f, 1.50771812e-02f, -2.56872445e-01f, -4.01941873e-02f, -2.04713922e-02f, -7.97764957e-02f, 1.20476604e-01f, -1.84895694e-01f,
  1.78681955e-01f, 7.52005205e-02f, -2.47321371e-02f, -1.52854532e-01f, 7.52663389e-02f, -6.27035126e-02f, 9.88202840e-02f, 6.81167021e-02f, -2.60696951e-02f, 1.06865406e-01f
};

// L3_fan_Wp_bar (Shape: 14 x 64)
const int L3_fan_Wp_bar_rows = 14;
const int L3_fan_Wp_bar_cols = 64;
const float L3_fan_Wp_bar_data[] = {
  9.24177691e-02f, 1.54551908e-01f, -1.37364358e-01f, 9.16220322e-02f, 2.12675229e-01f, -3.30232717e-02f, -2.30556220e-01f, -8.11598301e-02f, 2.96955079e-01f, 2.94178694e-01f,
  3.29537652e-02f, -7.33487541e-03f, 9.53361765e-02f, -3.22933197e-01f, 3.48589644e-02f, -3.45140815e-01f, -3.91034305e-01f, 5.18722460e-02f, -6.17218688e-02f, -1.57564238e-01f,
  -1.41650215e-01f, 1.44523874e-01f, 1.07738279e-01f, -2.91923255e-01f, 1.80282488e-01f, -8.91391933e-02f, -1.66196376e-01f, -2.31796280e-01f, 1.96498528e-01f, 4.10734527e-02f,
  -2.40602747e-01f, -3.71111259e-02f, 1.00490928e-01f, 2.68664420e-01f, 4.72867936e-02f, 3.72707874e-01f, -3.98581056e-03f, -1.71293169e-01f, -1.63956851e-01f, -2.95052081e-01f,
  2.31588826e-01f, 2.55830288e-01f, 1.43425867e-01f, 9.01983157e-02f, -2.02484950e-02f, 1.38499439e-01f, -5.92892207e-02f, 4.52710867e-01f, -4.39614020e-02f, -1.16267540e-01f,
  9.67838168e-02f, 7.11147785e-02f, 1.56378716e-01f, 1.41124263e-01f, 8.63971934e-02f, -4.76497799e-01f, 1.26207978e-01f, 2.74498641e-01f, 3.13292593e-02f, -1.27134562e-01f,
  -1.27237961e-02f, 1.60074458e-01f, 1.55074701e-01f, 5.63108549e-02f, 1.72594115e-02f, -1.30014002e-01f, 9.16048978e-03f, 6.81144968e-02f, -8.02237615e-02f, 1.97641738e-02f,
  -2.03670263e-01f, 1.61455646e-01f, 1.87594458e-01f, 2.65544862e-01f, 1.63962215e-01f, -1.16117030e-01f, 2.21646026e-01f, 2.18983330e-02f, 8.32108259e-02f, 2.16729656e-01f,
  1.11329012e-01f, 1.90211877e-01f, -4.45750430e-02f, -7.91922659e-02f, 2.76179105e-01f, -3.66467983e-02f, 1.61428656e-02f, 1.78252175e-01f, 4.19926792e-02f, -5.65080762e-01f,
  3.85900736e-02f, 1.96688741e-01f, 9.50154215e-02f, 1.34005561e-01f, 2.09184423e-01f, -1.02608368e-01f, -2.53932983e-01f, -1.01310626e-01f, 4.33293320e-02f, -1.00125797e-01f,
  1.36253491e-01f, -1.75251752e-01f, 4.13691364e-02f, -2.42574096e-01f, -1.76491529e-01f, 1.74457729e-01f, -7.43027851e-02f, -1.65710244e-02f, -2.23041505e-01f, 5.07794082e-01f,
  -3.73764664e-01f, 1.44045547e-01f, -1.64504312e-02f, 1.96815848e-01f, 1.99146926e-01f, -4.91082519e-02f, 2.11692825e-01f, 1.35925725e-01f, 4.06683236e-01f, 1.78029522e-01f,
  3.82119358e-01f, -2.81441927e-01f, -1.73966795e-01f, 2.84085542e-01f, 2.23066598e-01f, 3.58730495e-01f, 2.26216152e-01f, 5.26364923e-01f, -6.05069436e-02f, 1.77103251e-01f,
  -1.10712294e-02f, 1.73273653e-01f, 3.60797822e-01f, -7.62483925e-02f, -2.58871347e-01f, 6.74777329e-02f, -2.11857989e-01f, 1.21109903e-01f, 1.39685974e-01f, -3.74579690e-02f,
  1.00886643e-01f, 2.05871001e-01f, -2.92760902e-03f, -1.45303026e-01f, 1.99371681e-01f, 2.85572022e-01f, 1.77888125e-02f, -2.80894011e-01f, -1.03560932e-01f, -3.10991071e-02f,
  1.55524671e-01f, 8.79297629e-02f, 9.04932022e-02f, 4.93223779e-02f, 4.17502880e-01f, 2.17036709e-01f, -1.73669323e-01f, -4.21676159e-01f, 3.92872155e-01f, 3.10435355e-01f,
  -5.42704053e-02f, -5.92120998e-02f, -1.67200983e-01f, -2.34835014e-01f, 9.01882797e-02f, 1.35349827e-02f, 1.05440468e-01f, -2.32308164e-01f, 1.50000304e-01f, 2.39589214e-01f,
  -5.72056212e-02f, -1.37243837e-01f, -3.19628745e-01f, 1.44052684e-01f, -6.26559183e-02f, -5.66692501e-02f, -8.22874606e-02f, 1.45722136e-01f, 8.23813155e-02f, 6.44795597e-02f,
  -2.27608815e-01f, 1.82574615e-01f, -3.79013531e-02f, 2.74258256e-01f, 1.90405603e-02f, 6.80139661e-02f, 2.76980221e-01f, 3.53232682e-01f, 3.61487299e-01f, -1.88874289e-01f,
  4.87082809e-01f, 2.97869623e-01f, 1.65341213e-01f, 5.54178283e-02f, -5.74542917e-02f, 5.19934967e-02f, 1.93734229e-01f, 3.32641184e-01f, 1.12669401e-01f, 1.27652988e-01f,
  1.50023863e-01f, 2.84230798e-01f, -1.39532596e-01f, 8.51701349e-02f, 1.01333456e-02f, 4.69880886e-02f, 6.53062984e-02f, 1.23247385e-01f, -2.83039380e-02f, -7.93846101e-02f,
  2.52800107e-01f, 3.44609976e-01f, 1.15843818e-01f, 1.45112261e-01f, 2.17118934e-01f, 8.42953101e-02f, -3.21412951e-01f, -1.07938796e-01f, -4.16856289e-01f, -1.08572491e-01f,
  7.86291808e-02f, 2.39019588e-01f, 5.49284108e-02f, -5.34662642e-02f, 1.13996319e-01f, 2.67074853e-01f, 1.37772840e-02f, 2.51247913e-01f, -3.34895372e-01f, 1.88789621e-01f,
  -6.91296682e-02f, -7.92337209e-02f, -2.35126078e-01f, -3.44177991e-01f, -1.43852748e-03f, 5.19056559e-01f, -3.83706838e-01f, 2.16136143e-01f, -2.32224703e-01f, 1.57117546e-01f,
  3.75047117e-01f, -9.47859585e-02f, -1.66226774e-01f, 2.63273627e-01f, 1.91435754e-01f, 1.72242269e-01f, 4.41480987e-02f, -5.91007546e-02f, 4.60741490e-01f, 1.92490056e-01f,
  3.45878303e-01f, 7.02165440e-02f, 1.07463360e-01f, 1.30978487e-02f, 3.62361744e-02f, 3.14687788e-01f, 2.11300537e-01f, 3.11512761e-02f, 2.42725402e-01f, 2.46293515e-01f,
  2.44074672e-01f, 3.30854028e-01f, -8.63766000e-02f, 1.06158026e-01f, 1.61444619e-01f, 3.69428486e-01f, -1.70608470e-03f, 1.59456417e-01f, 9.18507203e-02f, -5.06601781e-02f,
  -1.12268198e-02f, 1.29688278e-01f, -2.34127957e-02f, 2.26396576e-01f, -4.39979099e-02f, 1.41719624e-01f, 3.42843980e-02f, 8.17589387e-02f, 3.14965248e-01f, -1.22403406e-01f,
  -9.58098397e-02f, -2.17188932e-02f, -3.78822982e-01f, 9.05436743e-03f, 7.34237805e-02f, 3.13245356e-01f, 2.26923659e-01f, 8.74174461e-02f, -3.46151069e-02f, 2.18617246e-01f,
  5.83444163e-02f, 2.93104053e-01f, -2.20749304e-01f, 2.48758733e-01f, -3.35909247e-01f, -2.46547997e-01f, 3.51013131e-02f, -7.55038410e-02f, 2.59464711e-01f, 3.72149140e-01f,
  -2.52884477e-01f, 6.21888526e-02f, 9.50831547e-02f, -1.96031168e-01f, 2.96746522e-01f, -2.13841319e-01f, -1.73703983e-01f, 3.10694128e-01f, -2.55068541e-02f, 4.62336451e-01f,
  -1.28964156e-01f, 1.48978069e-01f, 1.78092331e-01f, 3.06274712e-01f, 3.90824467e-01f, 3.46720926e-02f, -3.08277886e-02f, -3.30791995e-02f, 1.63768828e-01f, 1.40601128e-01f,
  2.01218233e-01f, 1.26469269e-01f, 6.19303212e-02f, 3.15094233e-01f, 2.00223234e-02f, -1.05338674e-02f, -2.04870567e-01f, 3.12556960e-02f, 2.87348647e-02f, 1.93451136e-01f,
  4.83367324e-01f, 2.12967545e-02f, -2.41063789e-01f, -4.18701917e-01f, 6.52281344e-02f, -9.52516275e-04f, -8.14608335e-02f, 3.68275493e-01f, -9.96314660e-02f, 4.06328142e-02f,
  -9.82606667e-04f, -7.77250752e-02f, -7.06709251e-02f, -1.37536868e-01f, 5.36711931e-01f, -1.96871068e-02f, 1.44723564e-01f, 3.45653862e-01f, 1.85097784e-01f, 1.84364319e-02f,
  -2.19149347e-02f, -8.72756820e-03f, 3.48449908e-02f, -1.63645908e-01f, -1.68393642e-01f, -1.00610875e-01f, 3.34883451e-01f, -2.36302897e-01f, 4.18608710e-02f, -2.19983533e-02f,
  1.41323358e-01f, 3.66697073e-01f, -4.09471482e-01f, -2.62058079e-01f, -2.43131034e-02f, 2.03577459e-01f, -2.04076752e-01f, 3.27253193e-01f, -2.87438720e-01f, -1.66218773e-01f,
  2.93969482e-01f, 2.48007670e-01f, 1.95149377e-01f, 9.50052682e-03f, 3.66754383e-02f, -3.42199765e-02f, 2.32982889e-01f, -4.10002023e-01f, -4.22919780e-01f, 1.69930428e-01f,
  7.39419162e-02f, 1.97995141e-01f, 2.85658807e-01f, 5.59134148e-02f, -2.64238685e-01f, 9.18114632e-02f, 1.16936482e-01f, 2.07372248e-01f, 3.62494797e-01f, -5.61636090e-02f,
  2.17905074e-01f, -1.33498639e-01f, -2.91065007e-01f, -8.79066139e-02f, 9.57144722e-02f, 1.45372048e-01f, -5.91353886e-02f, 2.07752064e-01f, 3.70265245e-02f, -4.82329130e-02f,
  3.70304212e-02f, 1.56443834e-01f, 1.09817155e-01f, -2.79501438e-01f, -1.59893423e-01f, -6.15492761e-02f, -1.11965239e-01f, 1.24046609e-01f, 2.13908315e-01f, 3.86125416e-01f,
  3.05992812e-01f, 1.36349216e-01f, -2.36318052e-01f, -5.59318960e-01f, 3.03549975e-01f, 3.68955106e-01f, 3.21201503e-01f, 1.09367162e-01f, -3.51704895e-01f, -7.62636214e-02f,
  6.06693029e-02f, 1.64041027e-01f, 1.07856825e-01f, 2.23295223e-02f, 3.75981301e-01f, 1.69075310e-01f, 1.35805994e-01f, -1.94029495e-01f, -2.21999720e-01f, -2.24503711e-01f,
  5.56292199e-02f, -2.04822421e-01f, -3.91312182e-01f, -1.48704767e-01f, -3.98746058e-02f, 3.28941494e-02f, -1.30836561e-01f, 3.17899317e-01f, -7.00108558e-02f, 1.27170011e-01f,
  4.33824137e-02f, 3.34604532e-01f, 3.41081858e-01f, 1.28846899e-01f, 1.04191415e-01f, -1.95286810e-01f, 3.59717250e-01f, -4.20493037e-02f, -1.80364385e-01f, 2.55486965e-02f,
  3.51064086e-01f, 2.55233943e-01f, 2.29334742e-01f, 1.07626460e-01f, 2.73288995e-01f, -3.21018368e-01f, -9.48780105e-02f, 2.00916111e-01f, 8.37878361e-02f, 2.18461558e-01f,
  3.17294240e-01f, 1.38973162e-01f, -3.00597772e-02f, 4.34252471e-02f, 4.90449965e-02f, 3.95379961e-01f, -9.62083861e-02f, 6.30672649e-02f, -4.35936034e-01f, -1.78015962e-01f,
  2.30605900e-01f, -2.55661178e-02f, 1.64940611e-01f, 5.52112639e-01f, -3.62305939e-01f, -1.72288924e-01f, 1.95810780e-01f, 2.68311828e-01f, 3.71333323e-02f, -3.73021811e-01f,
  3.82861674e-01f, 2.99939126e-01f, -3.26704443e-01f, 5.21643698e-01f, 1.01089226e-02f, 2.25107938e-01f, -1.64306566e-01f, -6.24163821e-02f, 1.73478186e-01f, -1.66131362e-01f,
  3.81330907e-01f, -1.73473001e-01f, 4.89444174e-02f, -3.61655265e-01f, 6.11264348e-01f, -1.35115057e-01f, -2.12464288e-01f, -1.75289392e-01f, 3.81398462e-02f, 3.38150620e-01f,
  7.58069754e-02f, 3.56089205e-01f, -1.28267348e-01f, 8.02978724e-02f, -1.49052590e-01f, 5.28138757e-01f, 3.23515713e-01f, 2.57246047e-01f, 1.73348352e-01f, 2.75875330e-01f,
  -2.04217300e-01f, -2.04171687e-01f, 1.43963192e-02f, -3.41066014e-04f, -2.13214517e-01f, -2.19279423e-01f, -3.91100459e-02f, 4.32177745e-02f, -2.92606074e-02f, 4.41525225e-03f,
  1.20372616e-01f, -7.14900419e-02f, -1.13519020e-01f, 4.97259870e-02f, 1.06277451e-01f, 5.79146966e-02f, 5.68532310e-02f, 6.65415898e-02f, -2.22226940e-02f, -2.63190661e-02f,
  1.13111526e-01f, 9.05513763e-02f, 2.16254622e-01f, -1.36203498e-01f, -1.23036183e-01f, 1.13544554e-01f, -3.42570871e-01f, -3.76113325e-01f, -3.33877772e-01f, -4.20470908e-03f,
  2.33504936e-01f, 1.72839746e-01f, -2.22180724e-01f, -3.47142994e-01f, 2.59942770e-01f, 6.66450486e-02f, 2.29892775e-01f, 1.87685966e-01f, -3.64776701e-03f, -6.94478899e-02f,
  5.74057028e-02f, -6.08343482e-02f, 3.73912454e-02f, -2.92979204e-03f, 6.32682517e-02f, 2.28432491e-02f, 7.03526288e-02f, 2.59272575e-01f, -1.20761218e-02f, 1.20200768e-01f,
  1.52257383e-01f, 1.73338745e-02f, 9.67441648e-02f, 1.00167088e-01f, 3.06808978e-01f, 5.76616339e-02f, 2.61735171e-01f, -4.02787387e-01f, 2.92774767e-01f, 1.17248565e-01f,
  4.24375497e-02f, -6.90985173e-02f, -6.05497584e-02f, 2.31497452e-01f, -9.20682400e-02f, 1.79794788e-01f, 2.31185630e-01f, 6.19358122e-02f, -2.83472896e-01f, -2.90734898e-02f,
  -2.57363301e-02f, -1.59298882e-01f, 9.66998190e-02f, 1.10978164e-01f, -1.91830337e-01f, 2.28933468e-01f, -1.87146533e-02f, 1.97174832e-01f, -7.72127835e-03f, 1.14871427e-01f,
  1.72819972e-01f, 2.26131737e-01f, 2.87392437e-01f, 1.02438703e-01f, 2.97944754e-01f, -2.19026074e-01f, 3.11598957e-01f, -9.94302630e-02f, 9.16038752e-02f, 1.24517374e-01f,
  -1.53834000e-02f, -1.96542107e-02f, -8.03844333e-02f, 1.40775591e-01f, -1.52850315e-01f, 1.22149505e-01f, 3.78795788e-02f, -5.54060221e-01f, 2.06862256e-01f, 2.45710477e-01f,
  -1.61360368e-01f, -9.88559723e-02f, -2.29471341e-01f, 3.48260611e-01f, 1.16746977e-01f, -2.42529642e-02f, -2.26145625e-01f, -2.01918021e-01f, -2.39050090e-01f, 3.67710553e-02f,
  -1.89284801e-01f, -7.91171193e-02f, 1.86681494e-01f, -3.22692156e-01f, 1.36031285e-01f, -2.57645287e-02f, 1.94185197e-01f, 3.91048849e-01f, 2.57810205e-01f, 1.45459613e-02f,
  6.24386035e-02f, 5.99852443e-01f, 2.41862699e-01f, 9.73825827e-02f, 3.45503315e-02f, -2.06583843e-01f, -7.55981505e-02f, 2.70824552e-01f, -4.86453585e-02f, 2.06172064e-01f,
  1.30920246e-01f, 1.50215060e-01f, 1.18096672e-01f, 1.22871168e-01f, -7.65138045e-02f, 3.43351394e-01f, 1.79075852e-01f, -1.44888416e-01f, 1.89663842e-01f, 3.30176115e-01f,
  -1.04429528e-01f, 2.08079085e-01f, 1.02618240e-01f, 1.58691555e-01f, 2.25913987e-01f, -2.85683811e-01f, 3.07227284e-01f, 9.19460207e-02f, 1.67326078e-01f, 1.54491618e-01f,
  -1.58762500e-01f, 2.31767207e-01f, -9.16232094e-02f, 4.47384156e-02f, 2.71227747e-01f, 2.70349920e-01f, -2.88379759e-01f, -4.16281283e-01f, -1.73547164e-01f, 1.87157989e-01f,
  -1.33932725e-01f, -2.50235081e-01f, 3.07114840e-01f, 3.03884536e-01f, 2.80645907e-01f, 1.12206392e-01f, 3.54908556e-01f, -1.31134510e-01f, 1.60813197e-01f, 2.76403874e-01f,
  3.77141178e-01f, 9.18850768e-03f, 1.06307134e-01f, -2.67999291e-01f, 1.79428652e-01f, -2.05278367e-01f, 7.19717667e-02f, -1.25270188e-01f, -1.87583774e-01f, 1.01434410e-01f,
  3.04895043e-01f, -3.39527637e-01f, -1.03808083e-01f, -7.11516440e-02f, 1.57620028e-01f, -1.01569317e-01f, 1.02242734e-02f, 1.73955545e-01f, 6.85249418e-02f, -1.92141801e-01f,
  1.03089556e-01f, 1.72383413e-01f, 9.13101360e-02f, -1.49891183e-01f, -2.13632703e-01f, 9.05693769e-02f, -3.24991524e-01f, -1.58368930e-01f, 1.19956449e-01f, 1.89590439e-01f,
  2.52985626e-01f, 1.01697959e-01f, -1.67910770e-01f, -6.02141619e-02f, -1.12774841e-01f, -2.29700416e-01f, -1.96556717e-01f, 4.26275522e-01f, 2.23697707e-01f, -3.26502383e-01f,
  1.60487294e-01f, 8.68606269e-02f, -1.40632968e-02f, -7.59512857e-02f, 1.77079335e-01f, 3.00062299e-01f, 5.35938255e-02f, 2.07484856e-01f, 1.64972946e-01f, -3.24555546e-01f,
  -4.18378294e-01f, -4.48122114e-01f, -8.30606837e-03f, 2.40553573e-01f, -2.72967935e-01f, 2.18858927e-01f, 1.97162583e-01f, 2.48436883e-01f, 3.62325102e-01f, 1.71784550e-01f,
  -3.41674499e-02f, -1.87202901e-01f, 1.19391702e-01f, 3.09239149e-01f, 4.09300178e-01f, 3.15865248e-01f, 5.13451584e-02f, -1.39078498e-01f, 1.88930780e-01f, 2.11406291e-01f,
  -7.78899863e-02f, 6.14796542e-02f, -2.22760201e-01f, 2.06634209e-01f, 2.09167227e-01f, -3.88241231e-01f, 4.35673222e-02f, -2.90301293e-02f, 1.62127852e-01f, 9.97248441e-02f,
  5.84053881e-02f, 5.63004240e-02f, 1.39692426e-01f, 7.14875478e-03f, 2.33937785e-01f, 2.65555531e-02f, 1.38685659e-01f, 1.56266406e-01f, -1.48945570e-01f, 2.48415321e-02f,
  5.11986427e-02f, -2.56891876e-01f, -3.54556173e-01f, 2.44581163e-01f, 7.29809105e-02f, -5.23892827e-02f, 2.23697871e-01f, 7.94858932e-02f, -1.94267586e-01f, 1.12999402e-01f,
  3.27939391e-01f, 4.24407944e-02f, -2.62311916e-03f, 3.25687647e-01f, -1.57230347e-01f, -3.70925754e-01f, 3.30066174e-01f, 3.90745282e-01f, 1.07969292e-01f, 1.67624965e-01f,
  4.53714505e-02f, 2.94883192e-01f, -4.25702572e-01f, -3.61035943e-01f, -2.49820054e-01f, -1.23291261e-01f, 2.81335264e-01f, 3.12133431e-02f, -9.03112367e-02f, -3.15997511e-01f,
  1.54408053e-01f, -1.75382182e-01f, 2.39621788e-01f, -1.77133661e-02f, 1.40467957e-01f, -1.69283941e-01f, -2.06162795e-01f, -3.60959843e-02f, 2.04370022e-01f, -3.85572106e-01f,
  4.26997125e-01f, 1.30182907e-01f, -6.27047345e-02f, 9.17650536e-02f, -9.10546929e-02f, 3.63438755e-01f, -4.83813602e-03f, 2.62309220e-02f, 8.08202103e-03f, -4.99341160e-01f,
  4.15993109e-02f, -4.09718119e-02f, 3.69302988e-01f, -5.97118497e-01f, -8.45094025e-02f, 1.64450750e-01f, 3.60084653e-01f, 1.86030999e-01f, 2.28676632e-01f, 2.26500645e-01f,
  -5.45695573e-02f, 2.33617991e-01f, 6.43483996e-02f, 1.62882417e-01f, 4.77742404e-02f, -6.67121261e-02f, 6.16309941e-02f, -1.64282531e-01f, -3.12517673e-01f, 2.85929620e-01f,
  -9.68185589e-02f, 1.86799332e-01f, 2.48632729e-01f, 7.33934343e-02f, -3.27818207e-02f, 3.28045100e-01f, -2.28079572e-01f, 1.04198493e-01f, 2.06175163e-01f, 1.94098473e-01f,
  -1.27196133e-01f, -2.18544334e-01f, 5.48011139e-02f, 5.02987914e-02f, -7.30970949e-02f, 1.63184121e-01f, 9.23589021e-02f, -3.14882010e-01f, -3.46139558e-02f, 2.12785453e-01f,
  -1.25705883e-01f, 4.08329904e-01f, 2.60079801e-01f, 1.94913313e-01f, -2.78962851e-01f, 8.07587281e-02f, 2.00537771e-01f, -6.00737110e-02f, -1.38336435e-01f, 5.07925868e-01f,
  -5.34781277e-01f, -2.52265215e-01f, -2.71822840e-01f, -1.18857943e-01f, 5.75575680e-02f, 5.29315472e-02f, -4.30971086e-02f, 1.21729128e-01f, 2.98996121e-01f, -1.33526489e-01f,
  1.60036922e-01f, -8.60809013e-02f, -1.41950119e-02f, 2.33352095e-01f, -2.33846933e-01f, 3.60272735e-01f, -1.82071283e-01f, 4.36209708e-01f, 4.76575121e-02f, 8.46881326e-03f,
  8.39755759e-02f, -8.52432325e-02f, -9.69885513e-02f, -2.58856446e-01f, 1.40672565e-01f, 2.58392751e-01f
};

// L3_fan_Bp_bar (Shape: 1 x 14)
const int L3_fan_Bp_bar_rows = 1;
const int L3_fan_Bp_bar_cols = 14;
const float L3_fan_Bp_bar_data[] = {
  5.27807698e-02f, 3.95385958e-02f, 1.24152072e-01f, 2.18479782e-01f, 9.45673957e-02f, 2.12163255e-01f, 1.35940939e-01f, 8.99782702e-02f, 4.21957783e-02f, 5.94405197e-02f,
  3.45999628e-01f, 1.17063992e-01f, 1.62349954e-01f, -2.28240974e-02f
};

// L4_linear_W (Shape: 12 x 64)
const int L4_linear_W_rows = 12;
const int L4_linear_W_cols = 64;
const float L4_linear_W_data[] = {
  -2.91796267e-01f, -1.63026109e-01f, 2.68295985e-02f, 6.03550486e-02f, -8.70601684e-02f, -1.73596069e-01f, -3.39442119e-03f, 1.53507397e-01f, 3.42294723e-02f, -7.70731494e-02f,
  -1.86891958e-01f, -4.27316129e-01f, -4.99453619e-02f, -1.24897078e-01f, -1.92809969e-01f, -1.51967639e-02f, 9.29324403e-02f, -9.11969841e-02f, 2.77668927e-02f, 6.92797005e-02f,
  4.85925078e-02f, -3.53180438e-01f, -1.33667156e-01f, -1.58683375e-01f, 1.80069119e-01f, 1.78712338e-01f, 2.51420308e-02f, 3.78809273e-02f, 1.57635622e-02f, 1.72337741e-01f,
  8.51448923e-02f, -1.91153765e-01f, -1.52910417e-02f, -1.90520957e-01f, 1.89224496e-01f, 1.47581488e-01f, -1.03082724e-01f, 3.24289888e-01f, -7.88100250e-03f, -5.97289242e-02f,
  -2.19131932e-02f, 3.43754590e-01f, 3.23364496e-01f, 4.63722050e-02f, -9.59117711e-02f, -3.77803862e-01f, -1.37571722e-01f, 3.87422323e-01f, 4.44281176e-02f, 1.71740159e-01f,
  1.39246136e-01f, 1.57058433e-01f, -2.57994920e-01f, 6.24286123e-02f, -8.09484497e-02f, 2.34008983e-01f, -2.46776626e-01f, -3.50217260e-02f, 1.88130811e-01f, 3.24569404e-01f,
  -2.36562222e-01f, -1.87783465e-01f, -1.74077988e-01f, -2.25382969e-01f, -2.17181727e-01f, 1.13322232e-02f, 9.93415266e-02f, -5.00204116e-02f, -5.60571323e-04f, -2.18197510e-01f,
  2.25568235e-01f, 2.12815300e-01f, 2.25653991e-01f, 2.47852951e-02f, -2.73838285e-02f, 1.48402289e-01f, 4.42758799e-02f, 2.19131187e-01f, 2.54579157e-01f, 5.51070236e-02f,
  7.60930032e-02f, 2.80388314e-02f, -2.11332679e-01f, 2.89378166e-01f, 5.78915179e-02f, 9.72277448e-02f, 3.07037801e-01f, 4.93883854e-03f, 1.17554367e-02f, -1.01714186e-01f,
  -4.20669079e-01f, 1.09183595e-01f, -3.50965232e-01f, 3.52322936e-01f, 3.67994457e-02f, 3.00346285e-01f, 3.62699896e-01f, -2.65304655e-01f, -5.34618735e-01f, 3.58420938e-01f,
  -1.55228183e-01f, 2.14029402e-01f, -5.38203865e-02f, 2.11377382e-01f, -4.84391637e-02f, -2.53093779e-01f, 5.98143637e-02f, 1.00357205e-01f, -1.07685208e-01f, -3.66631418e-01f,
  4.00204472e-02f, 1.39239952e-01f, -3.08828682e-01f, -2.81970978e-01f, 1.41374609e-02f, -1.81177929e-02f, 2.26549044e-01f, -3.00325841e-01f, -1.03559956e-01f, 1.42631590e-01f,
  2.40861580e-01f, -2.40703225e-01f, -3.14644247e-01f, -4.81595397e-02f, 1.04643859e-01f, -2.25004740e-02f, -3.45509410e-01f, -2.84849137e-01f, -4.37641084e-01f, -2.48221889e-01f,
  -8.39905217e-02f, 1.15433456e-02f, 3.88008624e-01f, 2.78675407e-01f, -5.17784841e-02f, -1.21261500e-01f, 2.30424985e-01f, -2.45644510e-01f, 1.95771456e-01f, 1.26881510e-01f,
  8.92049596e-02f, 1.45364359e-01f, 1.48662120e-01f, 3.18526030e-02f, 4.03697431e-01f, 7.88149387e-02f, 1.79198936e-01f, 3.30042511e-01f, 4.79116663e-02f, 1.10955246e-01f,
  3.76454964e-02f, 5.11579290e-02f, 4.76647504e-02f, 3.77411216e-01f, -2.19354376e-01f, -2.77696520e-01f, 1.30399719e-01f, 1.25639141e-01f, 5.56663036e-01f, 5.01250744e-01f,
  1.75077647e-01f, 2.03188360e-01f, 6.13785014e-02f, 2.77372867e-01f, 1.36857986e-01f, -1.91785797e-01f, -4.43053097e-02f, -2.33988285e-01f, -2.15735421e-01f, -4.07915950e-01f,
  -1.04230933e-01f, -3.74510050e-01f, -1.05438054e-01f, 1.46865502e-01f, -2.32818529e-01f, 3.28495026e-01f, -3.37692015e-02f, -2.54825622e-01f, 6.02661371e-02f, 3.74772623e-02f,
  -3.78733762e-02f, 2.77747542e-01f, 2.60260969e-01f, -1.83773801e-01f, -1.12143114e-01f, -2.93685108e-01f, -4.44148667e-02f, -6.37971699e-01f, -5.57271779e-01f, -5.96457005e-01f,
  2.23173231e-01f, 1.49532586e-01f, -6.79292008e-02f, -2.88229108e-01f, -5.48060000e-01f, 2.89570570e-01f, -7.15267956e-02f, 2.07425222e-01f, 1.96377233e-01f, -1.20588407e-01f,
  -3.44200075e-01f, -1.58396810e-01f, -3.10678899e-01f, 9.75423157e-02f, -6.87973127e-02f, 2.19664648e-01f, 1.51246607e-01f, -1.34568840e-01f, -7.71342963e-02f, 8.00998211e-02f,
  5.55658340e-02f, -3.63706559e-01f, -3.21321636e-02f, -1.58799887e-01f, -6.50540413e-03f, 2.77242482e-01f, -2.16552258e-01f, 3.48844349e-01f, 1.88344210e-01f, 2.34482095e-01f,
  6.35531694e-02f, 2.80907989e-01f, 3.42858255e-01f, -4.79484834e-02f, -2.58597553e-01f, 3.32778990e-01f, -1.76963910e-01f, -2.63738811e-01f, -9.24614817e-02f, -2.21102640e-01f,
  -3.52098234e-02f, 1.76525503e-01f, 3.29756409e-01f, -1.56466588e-01f, 9.19141099e-02f, -1.41873702e-01f, 5.38796186e-02f, 2.96347380e-01f, -2.00539872e-01f, -2.10328460e-01f,
  2.43560970e-01f, 3.32330197e-01f, 2.40559921e-01f, 1.47865698e-01f, -2.61609942e-01f, -6.77739263e-01f, -2.34736219e-01f, 3.46353799e-01f, -4.54806119e-01f, -5.37710130e-01f,
  -1.97338522e-03f, -2.74778992e-01f, 1.33280769e-01f, 3.32719654e-01f, -4.53930125e-02f, -5.47249839e-02f, 1.64827317e-01f, 9.52923521e-02f, 2.93990731e-01f, -2.56735384e-01f,
  -1.75686628e-01f, -2.22159460e-01f, -2.03932181e-01f, 1.64960355e-01f, 1.06650263e-01f, -6.84860647e-02f, 8.84082019e-02f, -1.23993319e-03f, -2.79377520e-01f, 1.60667270e-01f,
  -6.88140541e-02f, -1.95394203e-01f, 1.49489880e-01f, -5.53625375e-02f, -7.19444379e-02f, 1.28728360e-01f, 1.00591637e-01f, 1.77834839e-01f, -9.59699601e-02f, -7.43859038e-02f,
  -2.64478385e-01f, -1.65500283e-01f, -1.80420652e-01f, -9.12651271e-02f, -8.78796875e-02f, -3.47649276e-01f, -3.28978926e-01f, -1.24751896e-01f, -1.68909505e-01f, -2.17876270e-01f,
  -3.33968192e-01f, 3.19634348e-01f, -3.95844169e-02f, -7.03687966e-02f, 1.87881380e-01f, -1.65058658e-01f, 1.08060986e-01f, -2.39502653e-01f, -3.57956737e-01f, 4.69349056e-01f,
  1.57082513e-01f, 2.32747123e-01f, -2.05909327e-01f, -3.83405596e-01f, 1.09533645e-01f, 1.58256628e-02f, -1.47379011e-01f, 1.54911414e-01f, -3.55533272e-01f, 4.66721170e-02f,
  -3.23671579e-01f, -2.96865195e-01f, -3.81281406e-01f, -3.96836579e-01f, 2.05480471e-01f, 1.40843555e-01f, 8.91050026e-02f, 2.09975466e-01f, 3.46968710e-01f, -2.15739638e-01f,
  2.78204292e-01f, -2.40589365e-01f, 2.87364662e-01f, 2.43321195e-01f, 4.35964763e-02f, -1.12146489e-01f, 9.23686549e-02f, 8.45642090e-02f, 2.19008058e-01f, 9.23511535e-02f,
  1.59367427e-01f, 3.31501924e-02f, 2.03538854e-02f, -4.09907490e-01f, 1.45907521e-01f, -1.74853727e-02f, -3.26734990e-01f, 1.03932060e-01f, -1.27598241e-01f, 1.19102143e-01f,
  7.81981871e-02f, 1.77368760e-01f, 1.36372030e-01f, 8.01884159e-02f, -3.36132273e-02f, -9.72890928e-02f, -1.36291992e-03f, 2.91327778e-02f, 3.06497246e-01f, -3.11478883e-01f,
  -3.22818071e-01f, -8.68690833e-02f, -2.19045892e-01f, -1.92636460e-01f, 4.89921331e-01f, -1.09651901e-01f, -3.87294501e-01f, 2.56557530e-03f, 7.16192499e-02f, 1.97163522e-01f,
  1.81087419e-01f, 1.83853388e-01f, -2.12239251e-01f, 1.72011361e-01f, 2.42282555e-01f, 3.17864954e-01f, 1.69862702e-01f, 9.11627561e-02f, 3.63875151e-01f, 5.02213202e-02f,
  1.98505580e-01f, -2.85332426e-02f, 1.68413758e-01f, 1.42369866e-01f, 5.84752113e-02f, -3.11819971e-01f, 1.74622253e-01f, 6.89997077e-02f, -7.22246766e-02f, -2.85590529e-01f,
  -1.50204182e-01f, 2.47379631e-01f, 1.11077242e-02f, -2.78418094e-01f, -3.58046368e-02f, 4.92710546e-02f, -1.36462197e-01f, 2.59811521e-01f, 5.55020683e-02f, 8.69361013e-02f,
  -3.34765255e-01f, 1.94628850e-01f, 8.12961832e-02f, 2.94643492e-01f, 1.06003113e-01f, 1.41371012e-01f, 3.04048955e-01f, -1.61112040e-01f, 1.39399230e-01f, -3.25744599e-01f,
  1.26608789e-01f, -4.95896209e-03f, 2.47669414e-01f, -2.58058131e-01f, 2.15445980e-02f, 1.48111328e-01f, -7.80009525e-03f, 1.75309200e-02f, -4.02230114e-01f, -6.21012002e-02f,
  2.26084873e-01f, 3.87682557e-01f, 6.06281012e-02f, -2.33300790e-01f, 1.63159758e-01f, 1.64922029e-01f, -6.81547746e-02f, -1.69820309e-01f, 2.97773838e-01f, 2.77965572e-02f,
  -4.55811173e-01f, 1.14387721e-01f, -1.56111553e-01f, -1.79047123e-01f, 3.04009449e-02f, 4.77822959e-01f, 9.04758126e-02f, -1.25918373e-01f, 1.67403311e-01f, -8.78090560e-02f,
  2.89413124e-01f, 2.87415206e-01f, -1.67499527e-01f, -1.85558703e-02f, -3.58142048e-01f, -5.07955551e-01f, -8.29314440e-02f, 2.65900493e-01f, 2.34785646e-01f, -4.76743728e-02f,
  1.01205669e-01f, 2.39440352e-01f, -3.45816135e-01f, 2.98794448e-01f, -2.70357251e-01f, -2.28864416e-01f, -4.33944046e-01f, 4.47332673e-02f, -2.54194606e-02f, 2.89801061e-01f,
  1.82359666e-01f, 9.88486335e-02f, 7.11051561e-03f, 1.59706756e-01f, 6.49039000e-02f, 1.56501979e-01f, 1.48071229e-01f, -1.00575373e-01f, 1.79680273e-01f, 5.77409333e-03f,
  -1.01100206e-01f, -1.88008159e-01f, -1.11598745e-02f, 2.08459929e-01f, 2.84373313e-01f, -3.55846956e-02f, 6.54430836e-02f, 1.86909869e-01f, -9.16450098e-02f, 5.19061759e-02f,
  -8.16292465e-02f, -1.17552411e-02f, 8.03751498e-02f, -2.08251193e-01f, 1.89972505e-01f, -1.91026211e-01f, -2.26012930e-01f, 1.39392450e-01f, -3.19924235e-01f, -3.96153897e-01f,
  -2.76231289e-01f, 4.45135124e-02f, -3.02230000e-01f, 3.04754406e-01f, 3.83815318e-01f, -2.75494456e-01f, -1.43137366e-01f, -1.89923704e-01f, -7.03840926e-02f, 5.15531972e-02f,
  1.30686924e-01f, -1.19353957e-01f, 9.61997062e-02f, -2.85825759e-01f, -1.91528663e-01f, -2.16127336e-01f, -2.48974413e-01f, -8.95688012e-02f, -1.62935317e-01f, -4.09540176e-01f,
  -3.47840518e-01f, -3.53271157e-01f, -3.73447239e-01f, -2.67355561e-01f, -1.66592717e-01f, 2.46529654e-01f, -2.04005748e-01f, -2.02468902e-01f, 3.71345758e-01f, 2.00076103e-01f,
  -8.25861469e-02f, -3.40013236e-01f, 8.28980729e-02f, 3.22089404e-01f, 1.34213403e-01f, -3.61770272e-01f, -4.10830416e-03f, 2.94750207e-03f, -3.02862898e-02f, -9.91381183e-02f,
  -1.57776296e-01f, 1.34617031e-01f, -1.09006636e-01f, -2.15205327e-01f, 1.54060647e-01f, 6.29157806e-03f, -1.27954215e-01f, 1.10295718e-03f, -2.02588871e-01f, -2.12019771e-01f,
  8.76658410e-02f, -5.61802201e-02f, -1.97299272e-01f, 3.89086194e-02f, -2.73608625e-01f, -1.96777672e-01f, 7.35480189e-02f, 1.69635937e-01f, 3.64442468e-01f, -2.60783851e-01f,
  -1.27596617e-01f, -2.25280404e-01f, -1.20503314e-01f, -3.87653708e-01f, -1.50853246e-01f, 2.23548979e-01f, 3.24108303e-01f, -4.46041048e-01f, 3.44055384e-01f, -4.21481282e-02f,
  3.04089427e-01f, -3.29028256e-02f, 7.13757202e-02f, -2.51650661e-01f, -1.03003561e-01f, 1.55287907e-01f, 2.79909045e-01f, -9.66297388e-02f, 1.13394544e-01f, -1.25784054e-01f,
  2.85494030e-01f, 7.34618492e-03f, -5.58248401e-01f, 2.53904432e-01f, 1.55411765e-01f, 1.57490462e-01f, 1.89499244e-01f, -1.27818987e-01f, -1.59308970e-01f, -3.96994710e-01f,
  -4.47355002e-01f, 2.85565168e-01f, -1.58564502e-03f, -2.03860775e-02f, -6.58734262e-01f, 3.29383880e-01f, 2.11784229e-01f, 1.41587228e-01f, -2.82506615e-01f, -2.24649355e-01f,
  -6.79579601e-02f, -5.73473088e-02f, 1.44879088e-01f, -4.37404215e-02f, -2.66494900e-01f, -8.54433402e-02f, 9.09527168e-02f, -9.17598382e-02f, -1.71351433e-01f, -6.83910176e-02f,
  -3.72577965e-01f, -1.53952107e-01f, -7.97816962e-02f, 2.16878802e-01f, 3.58047187e-02f, -1.47828445e-01f, -5.50428443e-02f, 8.18780214e-02f, -7.54164904e-02f, 2.54418403e-01f,
  2.43593063e-02f, 8.11555609e-02f, -8.03141482e-03f, 4.45957966e-02f, 2.02847019e-01f, 2.22466648e-01f, 4.25035685e-01f, -4.47413698e-02f, 1.95980027e-01f, 3.16839397e-01f,
  4.24789369e-01f, -1.79317385e-01f, -1.44148514e-01f, -1.72525689e-01f, 5.74148893e-02f, 1.74537655e-02f, -1.65285915e-01f, 2.35766858e-01f, 2.55139265e-02f, 2.49656305e-01f,
  -3.66641998e-01f, -3.48709315e-01f, -2.66214401e-01f, -4.44135517e-01f, 1.51468962e-01f, -1.13321498e-01f, 2.23224953e-01f, -4.70826596e-01f, -3.83740544e-01f, 1.20504424e-01f,
  1.50995985e-01f, -4.19490278e-01f, -9.28835347e-02f, 2.58976638e-01f, -6.35410845e-02f, -2.39082500e-02f, 2.08015040e-01f, -4.16215479e-01f, 2.85275698e-01f, -4.24938411e-01f,
  8.46633911e-02f, -2.30146080e-01f, -3.33029151e-01f, 2.58138981e-02f, -3.45037699e-01f, -3.12165935e-02f, -1.48735017e-01f, -2.99187601e-01f, -1.00159980e-01f, -1.41798615e-01f,
  2.35580787e-01f, 1.12872265e-01f, -2.43340462e-01f, 1.88606799e-01f, -1.84222579e-01f, -3.79383087e-01f, -1.67450249e-01f, -3.42669487e-01f, -7.33844265e-02f, -2.85397261e-01f,
  -1.08873665e-01f, -2.61026621e-01f, -4.12618160e-01f, -1.42923713e-01f, 1.18009537e-01f, -9.33044404e-02f, -7.94116408e-02f, 1.10158563e-01f, -1.14337660e-01f, -1.35625094e-01f,
  -7.42747113e-02f, -3.49711835e-01f, 1.32310629e-01f, -2.07786113e-01f, 4.30143327e-01f, -1.05810411e-01f, 3.84110123e-01f, 2.81717449e-01f, -1.85316175e-01f, -1.65703043e-01f,
  1.46607563e-01f, -4.34687920e-03f, -3.38859707e-02f, -1.98546246e-01f, 1.41330063e-01f, 1.50420815e-01f, 1.39812216e-01f, 2.01730039e-02f, 2.48136550e-01f, 1.96457788e-01f,
  -1.40889868e-01f, 3.48187774e-01f, 2.00052828e-01f, -2.72209913e-01f, -5.16778469e-01f, 3.02162766e-01f, -6.02452792e-02f, -5.45796692e-01f, -3.37658048e-01f, -4.33370531e-01f,
  -5.95950544e-01f, -2.55184650e-01f, 1.32981926e-01f, -4.04492199e-01f, -1.69234812e-01f, -2.12061197e-01f, -1.47364158e-02f, -4.21996191e-02f, -1.13396086e-01f, 8.07641074e-03f,
  9.80460197e-02f, -4.00236696e-01f, -2.67396808e-01f, -1.83562055e-01f, -2.82864451e-01f, -4.87381779e-02f, -3.19309860e-01f, 4.23154086e-02f, -2.01616749e-01f, 3.10099006e-01f,
  -1.00453431e-02f, 2.03034833e-01f, -3.91054124e-01f, 6.46632165e-02f, -4.67574922e-03f, -4.40801442e-01f, 1.35272861e-01f, 3.04681826e-02f, 2.24010617e-01f, -2.60772526e-01f,
  3.22151870e-01f, -4.45151001e-01f, -1.23686165e-01f, -1.45433053e-01f, -1.05537049e-01f, 2.09863096e-01f, -9.43535268e-02f, 3.38099837e-01f, -3.58378440e-01f, -1.54221222e-01f,
  1.77432165e-01f, 1.73088610e-01f, -1.11231253e-01f, 1.37609601e-01f, -1.22379802e-01f, -2.66118258e-01f, 2.74106085e-01f, 1.08033054e-01f, -3.54662687e-01f, 3.11649829e-01f,
  7.48822615e-02f, -3.57673876e-02f, -2.30658546e-01f, -1.67104736e-01f, -3.55237097e-01f, -5.18526018e-01f, 1.42649472e-01f, -3.46934170e-01f, 1.96602046e-02f, -6.00333333e-01f,
  2.98887312e-01f, 1.91772148e-01f, -2.67761707e-01f, 1.05509475e-01f, -2.89555162e-01f, -2.92743415e-01f, -1.60779923e-01f, 1.49847403e-01f
};

// L4_linear_B (Shape: 1 x 12)
const int L4_linear_B_rows = 1;
const int L4_linear_B_cols = 12;
const float L4_linear_B_data[] = {
  -7.11147115e-02f, -3.70398648e-02f, 6.08961731e-02f, -5.76731786e-02f, 8.19416791e-02f, -1.00203946e-01f, -8.54693428e-02f, 1.33984655e-01f, -2.63236798e-02f, -2.87455078e-02f,
  5.16853342e-03f, -2.11507250e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 25, 14
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        64, 25, 14
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        64, 25, 14
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L3_fan_Wp_data, L3_fan_Wp_bar_data, L3_fan_Bp_bar_data,
        64, 25, 14
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 4: L4_linear
    linear_forward_pgm(
        buffer1, x_out,
        L4_linear_W_data, L4_linear_B_data,
        64, 12
    );
    }
    