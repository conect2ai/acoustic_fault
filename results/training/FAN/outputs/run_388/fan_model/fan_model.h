/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 16 (x1)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 16;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    return (x > 0.0f) ? x : 0.0f;
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 3 x 120)
const int L0_fan_Wp_rows = 3;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -1.07736778e+00f, -6.90317973e-02f, -3.85768771e-01f, -3.56024563e-01f, -1.58177063e-01f, -3.41866791e-01f, -1.90934241e-01f, -9.29439962e-02f, -3.12288195e-01f, 2.55180031e-01f,
  2.21683010e-01f, -2.70336926e-01f, 2.07584396e-01f, -7.74527481e-03f, -6.26300037e-01f, 1.69346735e-01f, -2.88037717e-01f, -5.53947315e-02f, -2.78411843e-02f, -1.19708396e-01f,
  -1.14404030e-01f, -1.00078844e-02f, -3.69434431e-02f, -3.63850221e-02f, -1.39172062e-01f, -9.07638669e-02f, 1.17719263e-01f, -2.39436962e-02f, 5.76353408e-02f, -4.60252166e-02f,
  1.30461007e-01f, 2.62361497e-01f, 6.43513426e-02f, 3.58929150e-02f, -3.50059010e-02f, 8.95188227e-02f, -7.91649669e-02f, 8.29787254e-02f, -5.24214134e-02f, 9.88947973e-03f,
  -7.94195309e-02f, -3.32148420e-03f, 6.29447848e-02f, 1.09898821e-02f, -1.35713607e-01f, -1.75425082e-01f, -1.05463369e-02f, 5.67154214e-02f, 4.87939045e-02f, -9.58624482e-02f,
  -2.49752197e-02f, -9.26504750e-03f, -1.03528805e-01f, 9.19880271e-02f, -1.64794967e-01f, -9.62325837e-03f, 8.31254050e-02f, -4.71218443e-03f, 2.92094075e-03f, -1.22003242e-01f,
  2.10183226e-02f, -2.25505140e-02f, -1.44321704e-02f, 4.94912341e-02f, -8.29790458e-02f, 1.31886408e-01f, -8.92780423e-02f, 6.67751953e-02f, -1.51544333e-01f, -2.09842976e-02f,
  -3.56249027e-02f, 3.50718945e-02f, -5.42656425e-03f, -4.60773483e-02f, 2.14229692e-02f, 3.50086614e-02f, -3.22103351e-02f, -3.48827951e-02f, 3.80913354e-02f, -6.65312633e-03f,
  4.51911502e-02f, -5.48752062e-02f, 4.15012799e-02f, 3.52086574e-02f, 4.66194823e-02f, -5.51104620e-02f, 4.66688946e-02f, -7.03916997e-02f, -1.05655361e-02f, -8.66645575e-02f,
  -7.20317736e-02f, -6.17116466e-02f, 3.70351337e-02f, -6.16275240e-03f, -6.20007776e-02f, -8.75871032e-02f, -6.39022067e-02f, -1.66667119e-01f, 2.66597830e-02f, -3.03337835e-02f,
  -6.14159158e-04f, 1.27750169e-02f, 3.03920638e-03f, -2.19880454e-02f, 9.21753943e-02f, 1.24439850e-01f, 7.40358382e-02f, -4.00751606e-02f, -8.24209675e-02f, 2.42312867e-02f,
  1.27632217e-03f, 1.72594152e-02f, 1.96442194e-03f, 4.39358205e-02f, 6.05617501e-02f, 3.49604264e-02f, -1.48280367e-01f, 3.36649641e-02f, -2.48920321e-02f, 6.20091287e-03f,
  4.41216230e-01f, -2.59103268e-01f, -2.42029607e-01f, 3.51066470e-01f, -4.02861126e-02f, 4.52273823e-02f, 3.69967930e-02f, -4.15890813e-02f, -1.36949882e-01f, 2.62950540e-01f,
  8.92392620e-02f, 1.55446753e-01f, -2.22518459e-01f, 4.82619196e-01f, -8.45622420e-02f, -2.25993112e-01f, 3.47636402e-01f, 2.23586887e-01f, -2.78805345e-01f, 1.84404731e-01f,
  -1.71115361e-02f, 3.05792391e-01f, 1.48925900e-01f, -1.25136718e-01f, 2.83473998e-01f, -2.30073273e-01f, 3.56825799e-01f, -2.99282759e-01f, 2.43603185e-01f, 1.96853583e-03f,
  3.72099690e-02f, 3.02269328e-02f, -2.22458467e-02f, -1.03493566e-02f, -3.16413082e-02f, 4.34469655e-02f, -1.44926691e-02f, -5.33443280e-02f, -1.27182513e-01f, 3.52329165e-02f,
  -7.41151050e-02f, 9.53826234e-02f, -6.83940873e-02f, -1.26616031e-01f, 2.79505372e-01f, 5.60237234e-03f, 4.59732935e-02f, 8.97032544e-02f, 2.39635911e-02f, 1.11482635e-01f,
  -1.55485813e-02f, 2.30925139e-02f, 1.14353552e-01f, 7.56825209e-02f, -3.93746905e-02f, -1.01012714e-01f, -5.40118478e-02f, -7.33583272e-02f, 7.30680116e-03f, 2.18739677e-02f,
  7.50144795e-02f, -3.49458903e-02f, -7.36450925e-02f, 9.20355096e-02f, -2.42565423e-02f, -2.81752441e-02f, 8.62121731e-02f, 7.23450035e-02f, -9.42367092e-02f, 8.15797672e-02f,
  -9.17052198e-03f, -4.24649194e-02f, 8.99580121e-02f, -2.51821452e-03f, 6.16325140e-02f, 8.43272433e-02f, 1.54458079e-02f, -1.03046015e-01f, 1.14695681e-02f, 3.75944264e-02f,
  7.57075055e-03f, -3.31638604e-02f, -7.36185834e-02f, 4.52672541e-02f, -8.61896388e-03f, -4.86569926e-02f, 6.50408864e-02f, -2.11175531e-03f, -7.93975871e-03f, -7.50375539e-02f,
  8.33936632e-02f, -2.00689748e-01f, -1.07317492e-01f, -1.59707554e-02f, -4.41681333e-02f, -6.99728057e-02f, -2.62969974e-02f, 3.02428138e-02f, 2.00989936e-02f, -4.37845811e-02f,
  -3.52827925e-03f, -4.72828001e-02f, 9.93035510e-02f, 1.81030005e-01f, -1.69874474e-01f, 2.66222954e-02f, -9.52522736e-03f, -6.51234388e-02f, 1.15140729e-01f, -5.80037432e-03f,
  5.27249388e-02f, -3.10228206e-02f, -5.24059720e-02f, -5.99408988e-03f, 3.06629706e-02f, 1.91360842e-02f, 8.33593905e-02f, -1.23569384e-01f, -3.56945097e-02f, 8.60722438e-02f,
  1.81608811e-01f, -1.64053943e-02f, -3.71771604e-01f, 4.71906364e-02f, 4.40451622e-01f, -1.22177549e-01f, -7.79078528e-02f, 2.89488316e-01f, -4.84608300e-02f, 7.16417506e-02f,
  2.13273764e-01f, -3.38204801e-01f, 4.05623950e-02f, 4.53274138e-02f, 1.99307315e-02f, -3.93354565e-01f, 2.70236079e-02f, -1.68799922e-01f, 8.86036176e-03f, 1.42049462e-01f,
  -1.92264356e-02f, 6.39288783e-01f, -1.70864791e-01f, 3.84991765e-01f, 1.37118921e-01f, -1.38724923e-01f, 3.99685651e-01f, -6.82387054e-02f, 1.82591140e-01f, -6.39875932e-03f,
  -2.66311057e-02f, -4.66046929e-02f, 3.20441253e-03f, -4.25813235e-02f, 7.91811347e-02f, -1.67762465e-03f, 8.13837424e-02f, -9.65895653e-02f, -2.61055343e-02f, -7.80776441e-02f,
  1.47948076e-03f, -9.92727205e-02f, 3.67734656e-02f, -2.53805686e-02f, 3.62756178e-02f, -2.18864437e-02f, -8.07330459e-02f, 2.49118935e-02f, 6.13576397e-02f, -3.14882509e-02f,
  -1.53061911e-01f, -2.07458854e-01f, -7.44300336e-02f, 4.37359437e-02f, -8.29913616e-02f, -4.17962261e-02f, -1.13230437e-01f, -3.85643877e-02f, 1.00295674e-02f, 9.36870202e-02f,
  -5.48545569e-02f, 9.63248238e-02f, -7.60306716e-02f, -7.35262502e-03f, 2.57280152e-02f, 7.01149702e-02f, 1.19614573e-02f, 5.34660257e-02f, -1.07027657e-01f, 9.43901911e-02f,
  6.55241385e-02f, 4.34987359e-02f, -1.71175282e-02f, -4.91289273e-02f, 1.70882035e-03f, -1.55821638e-02f, 2.34046988e-02f, -9.16208848e-02f, 2.29118261e-02f, 1.87894087e-02f,
  -4.35636081e-02f, 1.26815811e-01f, -3.95265743e-02f, 4.22823764e-02f, -1.32225469e-01f, -1.12101063e-01f, -6.15863279e-02f, -9.36659724e-02f, -2.80113220e-02f, 1.02899462e-01f,
  2.34111771e-01f, 3.50914925e-01f, -2.38608811e-02f, 2.41888501e-02f, 1.49092212e-01f, 2.80651245e-02f, 2.99943425e-02f, -2.27652751e-02f, 5.10796495e-02f, 8.70529264e-02f,
  -6.63018599e-02f, 5.51356114e-02f, 2.17249081e-03f, 3.29566561e-03f, -6.55159280e-02f, 1.86846517e-02f, 9.71350819e-03f, -1.37170348e-02f, 1.03666678e-01f, 2.74074879e-02f,
  8.39952677e-02f, 3.29626128e-02f, 4.68251035e-02f, 6.41658604e-02f, 4.11476120e-02f, -1.68049836e-03f, 5.84431887e-02f, -4.81495373e-02f, 8.70793834e-02f, 9.24535915e-02f
};

// L0_fan_Wp_bar (Shape: 10 x 120)
const int L0_fan_Wp_bar_rows = 10;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -1.52425158e+00f, 4.45230871e-01f, -2.84634009e-02f, -1.29653960e-01f, -3.66474390e-01f, 1.41460812e+00f, 1.64219093e+00f, -4.12229151e-01f, -6.69791773e-02f, 7.27768302e-01f,
  4.36312377e-01f, 1.60598591e-01f, 8.16926062e-01f, 8.41449678e-01f, 5.63761294e-01f, 7.72509456e-01f, 6.18878663e-01f, 6.64252460e-01f, -2.28768855e-01f, -1.31708428e-01f,
  -2.72288114e-01f, 5.41272581e-01f, 3.82952958e-01f, -4.45892781e-01f, 9.28865448e-02f, -7.05581784e-01f, -1.78401023e-01f, -5.36265969e-02f, 1.36409611e-01f, -1.33675262e-02f,
  -4.39514995e-01f, -1.04741395e+00f, -1.03775091e-01f, -1.07478529e-01f, -1.05296388e-01f, -2.09879526e-03f, 6.01634532e-02f, 1.98396042e-01f, -2.04141274e-01f, 5.78451417e-02f,
  1.20764218e-01f, -1.83574647e-01f, -1.02821492e-01f, 6.04740046e-02f, -9.87525210e-02f, -2.41273776e-01f, -1.87751681e-01f, -2.18789857e-02f, -9.03465077e-02f, 3.43346149e-02f,
  1.41788274e-01f, 3.00648510e-02f, -4.44886554e-03f, 1.19386412e-01f, -8.03746954e-02f, -1.38966739e-01f, 1.18454605e-01f, 1.51806697e-01f, 1.66149616e-01f, -1.19884625e-01f,
  1.71946622e-02f, 8.77337158e-02f, 1.09591454e-01f, -1.19129986e-01f, 2.15167180e-02f, -9.49401334e-02f, 3.46704163e-02f, -1.12647325e-01f, -8.06495994e-02f, 7.75670782e-02f,
  -1.01105303e-01f, -1.22082546e-01f, -1.28057718e-01f, 2.05054834e-01f, -1.20118253e-01f, -5.83276935e-02f, 7.61646554e-02f, -1.62867978e-01f, 2.92582642e-02f, 2.78102551e-02f,
  -1.07624263e-01f, -9.14930925e-03f, 1.26192674e-01f, -7.97878727e-02f, -7.45298862e-02f, 4.71665524e-02f, -1.01279013e-01f, -7.17836022e-02f, -1.19647115e-01f, 2.19353348e-01f,
  2.40708977e-01f, -1.24336302e-01f, 3.33549380e-02f, -8.00662935e-02f, 1.63393393e-01f, 1.17832474e-01f, -2.03349870e-02f, -1.06690615e-01f, 1.86928555e-01f, 3.86879034e-02f,
  -1.16446964e-01f, 5.68860993e-02f, -1.64058894e-01f, -1.49324924e-01f, -5.51393442e-03f, 1.79049671e-01f, 5.75134419e-02f, -9.34934020e-02f, 5.69178835e-02f, -1.99165568e-01f,
  -1.24024510e-01f, 8.19820091e-02f, 9.02981088e-02f, -2.13818662e-02f, 3.68533209e-02f, 9.11255330e-02f, -2.58355826e-01f, -1.64400414e-01f, -8.40915889e-02f, 2.20264181e-01f,
  -7.75154233e-01f, -3.95840742e-02f, 6.50887966e-01f, 2.43943855e-01f, 5.95201254e-01f, 1.09683299e+00f, 1.71963438e-01f, 8.74113142e-01f, 6.88654065e-01f, -3.93484443e-01f,
  -3.88626337e-01f, -6.54107332e-01f, -4.22183186e-01f, 2.75994658e-01f, 5.66770136e-01f, 2.98879147e-01f, 6.94939852e-01f, -1.38469651e-01f, 3.90308678e-01f, 6.81464672e-02f,
  1.70263022e-01f, -7.87474513e-02f, 2.33850703e-01f, 6.77169412e-02f, -1.10911250e-01f, -1.70187384e-01f, -3.66213232e-01f, -4.46757190e-02f, -6.57012761e-02f, 2.65582174e-01f,
  -7.53801316e-02f, -2.46786982e-01f, -2.94945240e-01f, -8.49822164e-02f, 1.29639342e-01f, -1.02899536e-01f, -1.92191511e-01f, -8.76675770e-02f, 7.68952221e-02f, -1.49336853e-03f,
  -4.16192412e-01f, 7.53201321e-02f, 5.98816993e-03f, -1.17127545e-01f, 1.24946877e-01f, 7.18826130e-02f, 2.11165652e-01f, 5.23075759e-02f, 1.87982306e-01f, 2.14523375e-01f,
  5.59004322e-02f, 4.03472632e-01f, 5.75365871e-02f, 1.60038680e-01f, 2.55541746e-02f, -6.99756574e-03f, 1.27519190e-01f, -2.70924568e-02f, -3.76411118e-02f, 3.43144953e-01f,
  2.06662327e-01f, 1.03943177e-01f, -1.78564683e-01f, -6.52164295e-02f, -2.58813277e-02f, 6.03270642e-02f, 7.58075044e-02f, -1.56124756e-01f, -5.16395224e-03f, -2.08677813e-01f,
  9.66300815e-02f, -1.72288895e-01f, 4.65457290e-02f, 1.84314519e-01f, -2.58068800e-01f, 5.01169153e-02f, -1.67777807e-01f, -6.26431555e-02f, 8.15281495e-02f, 8.42554271e-02f,
  -6.80726990e-02f, 1.60206735e-01f, -1.55342668e-01f, 1.14226630e-02f, 1.97514072e-01f, 5.45024946e-02f, -3.96497250e-02f, 1.39758945e-01f, 3.14645618e-02f, -2.03418866e-01f,
  -6.39587283e-01f, -4.53872442e-01f, -1.12812124e-01f, 2.67750882e-02f, 5.96639439e-02f, 9.15704574e-03f, 1.23273879e-01f, 5.32187000e-02f, 1.37431085e-01f, 5.29685766e-02f,
  -7.79519975e-02f, -1.03288531e-01f, -9.48336795e-02f, 4.60721664e-02f, -8.16559568e-02f, 7.01810867e-02f, -1.65595457e-01f, 1.01276011e-04f, -4.77317907e-03f, -9.10210609e-02f,
  -2.40078807e-01f, -8.25629458e-02f, 4.93621230e-02f, 3.22309062e-02f, 5.13986647e-02f, -5.71140759e-02f, -2.29262173e-01f, 1.16539344e-01f, -6.12978265e-02f, 1.53984338e-01f,
  -7.11702779e-02f, -1.01447439e+00f, -9.86310720e-01f, -4.26471174e-01f, 9.09241259e-01f, 9.75284636e-01f, -3.37402731e-01f, 1.25596657e-01f, -1.24193978e+00f, -2.92285323e-01f,
  1.19641244e-01f, -4.24461275e-01f, -7.88576961e-01f, -6.25599250e-02f, 5.07252574e-01f, -8.82515430e-01f, 5.22359192e-01f, 1.59705371e-01f, -4.86076027e-01f, 4.13617730e-01f,
  -4.67934236e-02f, 7.93272078e-01f, -3.85084003e-01f, 5.43136477e-01f, 3.99171352e-01f, 2.16744527e-01f, 8.32310736e-01f, 1.71299294e-01f, 8.10756207e-01f, 3.95299435e-01f,
  -9.72700492e-02f, -4.37538683e-01f, -1.77794799e-01f, -2.31364265e-01f, 2.17969045e-01f, 3.03804100e-01f, 3.45900059e-01f, 1.42242134e-01f, -1.64267719e-01f, -1.29822046e-01f,
  6.73649758e-02f, 6.45304024e-02f, 1.16790935e-01f, -4.34405841e-02f, -5.23068346e-02f, -3.83709520e-02f, -1.81690734e-02f, -1.31502926e-01f, -2.99210578e-01f, -1.21653460e-01f,
  -1.82873040e-01f, -7.27883279e-02f, 7.45490789e-02f, 7.20672961e-03f, -3.95583585e-02f, -6.04378134e-02f, -1.43184617e-01f, 2.40193546e-01f, -1.67678911e-02f, 8.15382600e-02f,
  2.55264282e-01f, 1.35888597e-02f, 6.24000803e-02f, -2.70707756e-01f, -2.29479130e-02f, 4.04672883e-02f, -7.23062083e-02f, 2.15573460e-02f, -8.75149518e-02f, -5.54910898e-02f,
  9.15625505e-03f, -2.31592078e-02f, -1.11726344e-01f, 1.97404344e-02f, 1.49480775e-01f, -2.52083957e-01f, 1.49818584e-01f, 1.46468952e-01f, 5.53664491e-02f, 5.19229546e-02f,
  -2.43120208e-01f, 8.68231505e-02f, 6.43439889e-02f, 1.01905234e-01f, -7.34314770e-02f, 1.12307236e-01f, 1.85965061e-01f, -1.47335440e-01f, 2.71933209e-02f, 1.91660866e-01f,
  1.39304534e-01f, 4.18418378e-01f, -1.77496821e-01f, -4.69409823e-02f, -2.45989021e-02f, 3.27926278e-01f, -2.24208489e-01f, 1.61992624e-01f, 8.92843008e-02f, -4.79225777e-02f,
  3.80329877e-01f, 8.81349072e-02f, 2.76725609e-02f, -1.71258226e-02f, -4.19022702e-02f, 1.41524777e-01f, 1.25885233e-01f, 1.29644647e-01f, 2.59217948e-01f, 2.76009560e-01f,
  2.65996724e-01f, 2.74527162e-01f, -8.51536989e-02f, 1.59466818e-01f, 1.17943414e-01f, 4.49665114e-02f, 2.96238124e-01f, -5.71782850e-02f, 1.76484644e-01f, -2.19507828e-01f,
  9.17486489e-01f, 6.60537302e-01f, 9.84515429e-01f, 1.07075787e+00f, 3.07155047e-02f, -8.20439339e-01f, 1.35873258e-01f, -1.84836143e-04f, 3.60693187e-01f, -4.22920436e-02f,
  -3.85691375e-01f, 6.34197116e-01f, -2.15043604e-01f, -2.19696194e-01f, -3.40235144e-01f, -7.02556372e-01f, 3.13827962e-01f, 6.71618208e-02f, -9.57570523e-02f, 5.26638210e-01f,
  4.42669690e-01f, -7.58651197e-01f, 5.10065496e-01f, -3.28256011e-01f, 5.86037755e-01f, 9.82394457e-01f, 2.04517558e-01f, 2.19818518e-01f, 6.71091616e-01f, -6.08269989e-01f,
  -2.95232803e-01f, -1.15063734e-01f, 2.54367322e-01f, -1.83046624e-01f, 2.46857435e-01f, 1.72213539e-01f, 1.54991105e-01f, -1.53570294e-01f, -1.02304332e-01f, 6.01384602e-02f,
  3.79032083e-02f, -1.33318648e-01f, 3.90827842e-02f, -8.41686055e-02f, -5.31680398e-02f, 5.82707673e-02f, 6.78494722e-02f, 2.16433451e-01f, 9.45698097e-02f, 2.22540453e-01f,
  3.51617306e-01f, 1.78362221e-01f, 1.52978107e-01f, 2.03751981e-01f, 2.57565379e-01f, 7.86628127e-02f, 1.24524258e-01f, 1.51883438e-01f, 2.40707904e-01f, 1.95453152e-01f,
  -1.81766897e-02f, -7.10733607e-03f, -1.26384258e-01f, -6.15722034e-03f, -3.76503589e-03f, -5.93302883e-02f, -1.06277252e-02f, -1.44394636e-01f, 5.76108433e-02f, -4.72068787e-02f,
  1.00697264e-01f, -1.03826888e-01f, -2.25899696e-01f, 9.13214013e-02f, 3.51999812e-02f, -5.80566488e-02f, -3.28235403e-02f, -6.56181425e-02f, 1.64258286e-01f, 4.51603495e-02f,
  -1.49749577e-01f, -4.67805564e-02f, 1.64880320e-01f, -6.56260997e-02f, -3.37639451e-01f, -1.16911381e-02f, -3.59874917e-04f, 5.92449903e-02f, 1.99669152e-02f, 3.80677357e-02f,
  -1.03743840e-02f, 5.26421428e-01f, 1.34233549e-01f, -7.86023140e-02f, 1.94019359e-02f, 1.02286533e-01f, -2.52923101e-01f, 1.68252975e-01f, 1.98970765e-01f, -7.62958080e-02f,
  1.19875796e-01f, 2.20124096e-01f, -3.21309716e-02f, -4.58553620e-02f, -1.60439149e-01f, 3.10447395e-01f, -9.08006281e-02f, 4.46656905e-02f, 1.55377328e-01f, 1.29979014e-01f,
  1.23055592e-01f, -1.22646399e-01f, -3.64805944e-02f, 4.89049330e-02f, -6.51130006e-02f, -3.05496585e-02f, 1.28304467e-01f, 2.75556743e-01f, 1.56104267e-01f, 6.49710000e-02f,
  -1.95393220e-01f, -3.43619019e-01f, 3.75876784e-01f, 2.53763795e-01f, -3.89490575e-01f, -4.53638434e-01f, 1.31267682e-01f, -3.33432466e-01f, -4.00092937e-02f, -6.22679651e-01f,
  -5.66832125e-01f, 4.79117602e-01f, 1.08009204e-01f, -6.02669716e-01f, 1.37035108e+00f, 2.19727710e-01f, -8.34326074e-03f, 7.90520310e-02f, 4.73220162e-02f, 7.96764642e-02f,
  -6.93940297e-02f, -3.77556711e-01f, 2.12014154e-01f, -3.18025053e-01f, -6.48339450e-01f, -1.90610245e-01f, 1.22566335e-01f, 1.14361160e-01f, -4.34701920e-01f, 2.68281121e-02f,
  -3.58901799e-01f, -1.08055800e-01f, -1.80062369e-01f, 1.05126671e-01f, -1.78582504e-01f, -9.06048715e-02f, 1.68276206e-01f, 1.59290418e-01f, 8.70166272e-02f, 3.66177522e-02f,
  7.00865462e-02f, 1.36547908e-01f, -1.45340398e-01f, 2.17517875e-02f, -1.68594852e-01f, -5.25223762e-02f, -4.36387816e-03f, -1.79690704e-01f, -1.06560662e-02f, -1.75756663e-01f,
  1.85914878e-02f, -2.70793766e-01f, -1.50909558e-01f, 1.87312588e-01f, 5.94817363e-02f, -1.36851296e-01f, 1.30471930e-01f, 8.93942490e-02f, -7.39144236e-02f, 2.25478113e-02f,
  7.62564242e-02f, -4.46662270e-02f, -1.77343398e-01f, -1.57032639e-01f, -2.13775232e-01f, -1.50386676e-01f, 5.96659817e-02f, -1.12835139e-01f, -5.26660793e-02f, -9.71539170e-02f,
  -8.88831988e-02f, -7.55262598e-02f, -1.33107573e-01f, -1.46787822e-01f, -1.30759463e-01f, -1.47747144e-01f, 1.92468777e-01f, -1.39007017e-01f, -8.69553164e-03f, -1.19434908e-01f,
  -3.59177478e-02f, 1.99203053e-03f, -9.62500200e-02f, -3.40454211e-03f, -1.74436674e-01f, -7.35313725e-03f, -2.36125156e-01f, -1.78172618e-01f, -2.17398331e-01f, -9.95103121e-02f,
  1.97493345e-01f, 5.39347649e-01f, -1.10687174e-01f, -4.06809663e-03f, 3.61032225e-02f, -1.01967238e-01f, -3.50401644e-03f, 2.36968845e-02f, 2.19681531e-01f, -3.91541682e-02f,
  -9.33780968e-02f, 2.28066705e-02f, 1.55231863e-01f, 1.54994488e-01f, 1.99920446e-01f, -4.12416868e-02f, 1.76817343e-01f, 1.16262481e-01f, 1.80103198e-01f, 7.22967014e-02f,
  -7.40066692e-02f, 9.16632414e-02f, 1.87035069e-01f, -9.56131816e-02f, 1.78155694e-02f, 4.37086597e-02f, -5.01541793e-02f, 1.12508304e-01f, 9.26449820e-02f, 1.83971152e-01f,
  5.16889274e-01f, -1.19418776e+00f, 5.39738178e-01f, 5.56021214e-01f, 9.16493952e-01f, 3.11262637e-01f, 7.04409480e-01f, 4.66445461e-02f, -2.49176517e-01f, -1.42825818e+00f,
  -6.98463097e-02f, -3.18368733e-01f, -1.85270458e-01f, -1.07353032e-01f, 7.29466498e-01f, -2.89229929e-01f, -2.33240351e-02f, -3.50456744e-01f, 2.77914107e-01f, 2.36914441e-01f,
  5.51709294e-01f, 1.20783888e-01f, 7.35067248e-01f, -1.61707640e-01f, 6.13984764e-01f, 4.19691876e-02f, -2.30526388e-01f, 2.21839875e-01f, -1.28823116e-01f, 9.01596919e-02f,
  3.03882323e-02f, 1.01491567e-02f, 3.35700214e-01f, -6.57605305e-02f, 8.50965381e-02f, 2.76425034e-02f, 4.07944508e-02f, 2.05625042e-01f, 3.69840413e-01f, -2.12180957e-01f,
  4.69004214e-02f, 7.84685835e-02f, 8.74355212e-02f, 7.07952455e-02f, 1.38311628e-02f, -1.08979763e-02f, 1.23781525e-01f, 1.89098075e-01f, -9.85871702e-02f, 1.78752884e-01f,
  2.32992172e-01f, 2.19759159e-02f, 2.37606451e-01f, -1.63080961e-01f, 1.72158211e-01f, 1.00745179e-01f, -6.81043416e-02f, 6.78896308e-02f, -2.12410521e-02f, -6.53591678e-02f,
  -1.24006175e-01f, 2.89653447e-02f, 1.09868363e-01f, 9.18271672e-03f, 7.10866554e-03f, 2.96306927e-02f, -3.55040170e-02f, -1.32697672e-01f, -7.62325479e-03f, -2.21366867e-01f,
  -8.25137869e-02f, 4.58119065e-02f, -4.69006971e-02f, -7.57729933e-02f, 5.19977883e-03f, -1.54057220e-01f, 6.21743128e-02f, -8.87231082e-02f, 1.46385580e-01f, 1.71310261e-01f,
  -1.95636198e-01f, 7.76809081e-03f, -2.28207763e-02f, 1.44553289e-01f, -1.35015115e-01f, -7.94067904e-02f, -3.16587612e-02f, -1.74209356e-01f, 1.42237917e-01f, 2.40604535e-01f,
  -7.73280621e-01f, -1.44829142e+00f, -1.18825659e-01f, -2.93736532e-03f, -2.91408628e-01f, -1.18523225e-01f, 2.68588103e-02f, -2.08304748e-01f, -2.57729828e-01f, 1.09923318e-01f,
  -6.56867325e-02f, 8.73847902e-02f, -1.96376488e-01f, 1.14439614e-02f, -2.96049509e-02f, 3.90755013e-02f, -1.37990609e-01f, -4.29425418e-01f, -3.64095345e-02f, -2.08484173e-01f,
  -1.89995207e-02f, 3.05740889e-02f, 1.85983136e-01f, 2.93141425e-01f, 1.27507765e-02f, -1.56197637e-01f, -1.69903077e-02f, -2.09236927e-02f, -2.60995943e-02f, -3.36276814e-02f,
  5.22618592e-01f, 6.71398759e-01f, 3.86512540e-02f, 1.47348896e-01f, -4.57800269e-01f, -6.93813443e-01f, -9.17544544e-01f, 7.79405236e-02f, -4.28442657e-01f, -3.45782697e-01f,
  -2.09807023e-01f, -1.31528541e-01f, 2.28771940e-01f, 1.01300761e-01f, 7.48039663e-01f, 7.56455421e-01f, 3.56585741e-01f, -1.81746364e-01f, 4.52380240e-01f, 4.19576585e-01f,
  5.94676375e-01f, 6.28526986e-01f, 8.77228975e-01f, 4.45088089e-01f, 3.14272195e-01f, 2.23467201e-01f, 4.88402903e-01f, -1.05779529e-01f, -7.70349875e-02f, -2.42029518e-01f,
  -1.99368581e-01f, 3.25519502e-01f, -1.90780032e-03f, -1.09354243e-01f, 2.38894820e-01f, -1.73731729e-01f, -1.75648913e-01f, -1.94535077e-01f, -1.19753189e-01f, -3.20287347e-01f,
  5.70006259e-02f, 1.37716562e-01f, 8.93565416e-02f, -2.75439937e-02f, -3.19048524e-01f, -1.25438869e-01f, 2.09540322e-01f, -1.79290652e-01f, -1.61442190e-01f, 3.95277500e-01f,
  9.01067406e-02f, -7.91597515e-02f, -4.39915620e-02f, 1.01395108e-01f, -1.73573598e-01f, -3.31430882e-03f, -2.44278520e-01f, -1.67734593e-01f, -8.38424712e-02f, -1.53915891e-02f,
  1.97753355e-01f, -1.20523833e-01f, 1.46402612e-01f, -5.08814231e-02f, 7.99254477e-02f, 1.72121208e-02f, 6.53242841e-02f, -4.60833348e-02f, -1.18508451e-02f, 1.56539708e-01f,
  -1.13330513e-01f, 1.32613495e-01f, -4.63875309e-02f, -1.29337341e-01f, 8.84428173e-02f, 6.70691282e-02f, -1.99133288e-02f, 1.43369049e-01f, -2.30490640e-01f, 6.36309683e-02f,
  -1.85296685e-01f, -3.41026708e-02f, -4.77394834e-02f, 6.01014830e-02f, -1.67153701e-01f, -8.13075602e-02f, 2.13766247e-01f, 7.87070468e-02f, 1.11700855e-01f, 1.45931125e-01f,
  1.27516642e-01f, 6.44340932e-01f, -1.26058862e-01f, -1.01643108e-01f, -1.26644662e-02f, 2.88614277e-02f, 1.66004464e-01f, 1.67402864e-01f, 1.43198475e-01f, 1.82221383e-01f,
  3.86303775e-02f, -3.87166411e-01f, 1.04985841e-01f, -1.54201314e-01f, -9.84501243e-02f, 9.67486203e-02f, 8.07676241e-02f, -1.68325633e-01f, -8.26988518e-02f, 1.45176187e-01f,
  1.58737481e-01f, 3.95436659e-02f, 1.56815037e-01f, -1.93585038e-01f, -4.76100519e-02f, -1.70339480e-01f, 4.29463759e-02f, 2.03729793e-02f, 3.21174473e-01f, 3.29098813e-02f,
  -1.53779185e+00f, 9.78267908e-01f, 3.92252445e-01f, -1.04927576e+00f, 1.97687030e-01f, -2.81938612e-01f, -9.13344443e-01f, 4.65574741e-01f, 5.49733080e-03f, 4.19973701e-01f,
  -4.85471934e-01f, 5.46213150e-01f, 4.31645006e-01f, -6.48847580e-01f, -1.28755116e+00f, -4.14513201e-01f, -1.19473743e+00f, -2.57196724e-01f, 8.10837746e-03f, -1.40183628e-01f,
  -5.45648813e-01f, -5.48157215e-01f, -4.39627409e-01f, 6.15302026e-01f, 6.42761216e-02f, 2.70621449e-01f, -8.52016747e-01f, 5.34725487e-01f, -3.78377557e-01f, 1.49796173e-01f,
  -6.23342991e-01f, 1.88992947e-01f, -1.20248832e-01f, 5.41213527e-02f, -1.61939278e-01f, 2.08524484e-02f, -1.59601122e-01f, -9.77161974e-02f, -1.53884530e-01f, 9.74684879e-02f,
  1.01796128e-01f, 2.36970901e-01f, -1.05115987e-01f, 1.23039365e-01f, 1.70694396e-01f, 2.31239080e-01f, 1.80368930e-01f, -1.55606523e-01f, 2.04067409e-01f, 2.94695079e-01f,
  1.55353308e-01f, 8.73587430e-02f, 1.34272929e-02f, 2.70114485e-02f, 6.51702806e-02f, -1.76252055e-04f, -1.25494778e-01f, 1.74361598e-02f, -9.14353877e-02f, -8.51335302e-02f,
  2.08061159e-01f, -9.64083970e-02f, 7.71977380e-02f, -2.40035336e-02f, -1.18964806e-01f, -1.25541743e-02f, -2.05942448e-02f, -1.85712397e-01f, 1.51045183e-02f, -2.67922521e-01f,
  -1.34168297e-01f, 1.90776885e-02f, 3.68798673e-02f, -2.37382799e-01f, -5.35098650e-02f, -8.56385827e-02f, -1.44565970e-01f, -2.21419754e-03f, -4.88448068e-02f, -1.36679798e-01f,
  -5.58599867e-02f, -1.04138896e-01f, 1.34283885e-01f, -2.19146833e-01f, -5.62960692e-02f, 1.59376234e-01f, 4.37817276e-02f, 1.42560769e-02f, -1.58485949e-01f, -1.41349837e-01f,
  -7.74727404e-01f, -3.05892795e-01f, 4.15321849e-02f, 6.31654039e-02f, -2.66305786e-02f, -1.21288389e-01f, -1.82052344e-01f, 2.63610594e-02f, -3.84713262e-02f, -6.05486669e-02f,
  9.88340825e-02f, -6.48647621e-02f, -2.77396768e-01f, 1.38996765e-01f, -3.49338725e-02f, -2.56184250e-01f, -2.65384793e-01f, -2.67025977e-01f, -2.14883849e-01f, 5.18596023e-02f,
  1.69315994e-01f, 6.32138550e-02f, -4.03574817e-02f, -7.92068429e-03f, -7.31596500e-02f, -2.16137350e-01f, -5.08031659e-02f, 8.19125846e-02f, -6.08191788e-02f, 3.21707241e-02f,
  6.49036705e-01f, -9.21353459e-01f, 3.24472785e-02f, -5.71529150e-01f, 3.76432925e-01f, -2.43137151e-01f, -6.48787916e-02f, -6.90360606e-01f, -5.19100949e-02f, -8.60014617e-01f,
  -4.26497161e-01f, 5.70991188e-02f, 4.93644208e-01f, -8.21902633e-01f, 1.00838757e+00f, 7.43936673e-02f, -6.54756188e-01f, -4.13705975e-01f, 1.08400792e-01f, -6.17389143e-01f,
  7.23369122e-02f, -1.05137885e+00f, -6.95111006e-02f, -8.54571104e-01f, -3.26532841e-01f, -4.93374020e-01f, 5.04401177e-02f, 3.43961656e-01f, -7.71477222e-01f, 7.82913342e-02f,
  -1.64077491e-01f, -1.07691251e-01f, -2.49452189e-01f, 3.50409909e-03f, 2.25406542e-01f, 3.15567255e-01f, 1.15032911e-01f, 2.82098234e-01f, 1.52153715e-01f, 1.00273505e-01f,
  1.66611165e-01f, 8.59264582e-02f, -2.40977496e-01f, 2.15182289e-01f, -3.61609794e-02f, -5.61548173e-02f, 2.92017348e-02f, -1.78135950e-02f, -1.19652003e-01f, 3.55712742e-01f,
  1.56067401e-01f, 2.51968443e-01f, 4.42995802e-02f, -9.64021236e-02f, 1.75471947e-01f, -1.18768886e-01f, -2.11133696e-02f, 1.96457952e-01f, -1.61383599e-01f, -5.81775717e-02f,
  -1.57336503e-01f, 1.97328001e-01f, 5.38463704e-02f, -2.26384029e-01f, 7.63095031e-03f, -5.52129112e-02f, -1.08506560e-01f, -1.27019569e-01f, 1.56028226e-01f, 1.46266026e-02f,
  2.40819603e-02f, 1.80568919e-02f, -2.01124713e-01f, 4.34062518e-02f, -7.68171474e-02f, -2.65660454e-02f, 1.30849898e-01f, -3.05923782e-02f, 1.54139563e-01f, -7.52252638e-02f,
  1.17891476e-01f, -9.23606530e-02f, -8.18977654e-02f, 4.01195548e-02f, -1.47905657e-02f, 1.89873829e-01f, -1.45010754e-01f, 2.22183794e-01f, -9.35004205e-02f, 2.12146137e-02f,
  -1.74559325e-01f, -4.64169025e-01f, -2.56753534e-01f, -1.95448026e-01f, -9.03635696e-02f, 1.21328585e-01f, -1.78860530e-01f, -3.65122616e-01f, -1.05005778e-01f, -4.48133647e-02f,
  -1.10468693e-01f, 1.21864481e-02f, 1.32731304e-01f, -8.13638195e-02f, -2.23632023e-01f, -2.49922261e-01f, -2.34358847e-01f, -8.90568197e-02f, -1.17841158e-02f, -7.72435740e-02f,
  -1.94337919e-01f, -5.56264706e-02f, -7.30115995e-02f, -3.52066644e-02f, -3.18042397e-01f, 1.26254141e-01f, -2.01541986e-02f, 1.38210431e-01f, 2.68693298e-01f, -1.31102040e-01f,
  1.27214527e+00f, 3.17135274e-01f, -2.56943047e-01f, 6.48462951e-01f, 3.12155426e-01f, 7.56399751e-01f, 6.82451546e-01f, 3.03312033e-01f, 9.36648488e-01f, 1.27603009e-01f,
  -6.87788650e-02f, 1.84728146e-01f, -4.50456768e-01f, 3.73888433e-01f, -5.29319681e-02f, -1.04384325e-01f, 4.55966175e-01f, 3.55441988e-01f, 3.73621106e-01f, 4.30664867e-01f,
  2.98978001e-01f, 2.26686895e-01f, -1.07949829e+00f, -3.32163841e-01f, 2.21331432e-01f, -6.63802177e-02f, -8.54280889e-01f, -3.67801309e-01f, -4.67413068e-01f, -5.65817282e-02f,
  1.99138168e-02f, 1.92046076e-01f, -6.33789822e-02f, 6.30483869e-03f, 7.84970000e-02f, -3.77098694e-02f, -1.15517676e-01f, -3.20937783e-01f, -2.49368716e-02f, 9.28039029e-02f,
  1.86654657e-01f, -1.05230510e-01f, 2.17609853e-01f, -1.15438439e-01f, 3.56450170e-01f, -3.05955787e-03f, -3.44515406e-02f, 9.41938162e-03f, -1.78988039e-01f, -8.92832875e-02f,
  7.76758119e-02f, -1.82148442e-02f, 1.22267619e-01f, -2.57602502e-02f, 6.24104217e-03f, 1.13549933e-01f, -7.64701664e-02f, -3.21636871e-02f, -9.49324816e-02f, 1.08155966e-01f,
  1.76041409e-01f, 2.51241744e-01f, 7.32947513e-02f, -1.27178490e-01f, 6.42656758e-02f, -2.88837925e-02f, -3.75165790e-02f, -2.20896676e-01f, 1.38348475e-01f, -1.16705902e-01f,
  -7.25301206e-02f, 1.11374319e-01f, 1.64517969e-01f, 2.90278774e-02f, 9.97926891e-02f, 1.03765175e-01f, -1.06838867e-01f, -5.01929298e-02f, 1.92304656e-01f, -1.19768664e-01f,
  -1.05592333e-01f, 6.66547418e-02f, -8.79850313e-02f, -1.99166343e-01f, -1.00591086e-01f, -6.15844578e-02f, 1.54101968e-01f, 5.90218082e-02f, -4.28455546e-02f, 7.32347788e-03f,
  4.28315960e-02f, 3.48842263e-01f, -2.79808193e-02f, -7.83582404e-02f, -9.84839126e-02f, 1.55964702e-01f, 8.00578669e-02f, 2.54162014e-01f, -1.07628249e-01f, 1.94061741e-01f,
  5.41514866e-02f, 1.27938032e-01f, 1.51071399e-01f, -1.31082565e-01f, -1.46077096e-01f, 2.44429819e-02f, 3.63005660e-02f, -6.10168800e-02f, 7.62762353e-02f, -1.97155103e-01f,
  -3.40471044e-02f, 2.33701661e-01f, 8.83585066e-02f, 1.62273526e-01f, 1.83173656e-01f, -9.22346935e-02f, 2.61941612e-01f, -2.18822762e-01f, -1.48036182e-01f, 3.33868414e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 10)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 10;
const float L0_fan_Bp_bar_data[] = {
  1.11804986e+00f, 7.53258169e-01f, 1.31702816e+00f, 1.04324651e+00f, 8.49047959e-01f, 9.82373178e-01f, 1.41327843e-01f, 1.62591231e+00f, 8.07625949e-01f, 1.02699733e+00f
};

// L1_linear_W (Shape: 12 x 16)
const int L1_linear_W_rows = 12;
const int L1_linear_W_cols = 16;
const float L1_linear_W_data[] = {
  -1.21811795e+00f, 4.61707205e-01f, 6.94003880e-01f, 1.69610703e+00f, 1.50393438e+00f, -1.03024960e+00f, 1.34598434e+00f, 8.23044255e-02f, -1.19957805e+00f, -8.82108212e-01f,
  -1.02233040e+00f, -7.26582587e-01f, 3.47134233e-01f, -9.64623272e-01f, -1.67446029e+00f, -6.90396965e-01f, 1.29894769e+00f, -1.31158757e+00f, -9.14910495e-01f, -1.15083528e+00f,
  9.78987515e-01f, 1.49379754e+00f, 5.97517252e-01f, -5.49003147e-02f, 6.36653602e-01f, -1.46124470e+00f, -1.83477092e+00f, -1.12382066e+00f, 4.90902156e-01f, -1.89477253e+00f,
  1.57481804e-01f, 5.64344406e-01f, -3.68533820e-01f, -9.89682317e-01f, -1.25719756e-01f, -1.38775480e+00f, 5.88508725e-01f, 6.12460449e-02f, -8.23184431e-01f, 3.74408364e-01f,
  1.05655980e+00f, -9.87419844e-01f, 5.37619233e-01f, 5.97795784e-01f, -8.02909195e-01f, -1.38446355e+00f, -1.57684791e+00f, -1.01786733e+00f, -1.32767236e+00f, -3.14797938e-01f,
  8.71680140e-01f, 8.08017477e-02f, -8.48081768e-01f, 8.62674952e-01f, -8.31791282e-01f, -1.23485601e+00f, -1.32238913e+00f, -1.02299654e+00f, -3.53047252e-01f, -9.93651867e-01f,
  -3.24857682e-02f, 1.41677797e+00f, -8.06553185e-01f, -8.85980844e-01f, 1.40079832e+00f, -6.51450455e-01f, 4.42093797e-02f, 1.21212626e+00f, -1.54940999e+00f, -1.40123308e+00f,
  8.79653245e-02f, 9.33518469e-01f, -2.43062422e-01f, -9.97514248e-01f, -8.28768671e-01f, 2.75223643e-01f, 4.88132983e-01f, 4.24458921e-01f, -9.97814722e-03f, -1.35774541e+00f,
  3.19617122e-01f, 8.83001864e-01f, 6.38685048e-01f, -1.33792174e+00f, -1.25101411e+00f, -7.72017241e-01f, 3.19583327e-01f, 3.81941319e-01f, -1.37334406e+00f, 8.98240209e-02f,
  8.13048244e-01f, -1.51251686e+00f, -1.29802540e-01f, -8.08701634e-01f, -8.68991673e-01f, 1.05893636e+00f, -6.87673986e-01f, 3.16654384e-01f, -3.28236431e-01f, -1.44233510e-01f,
  3.34535778e-01f, 6.68131173e-01f, -1.55408609e+00f, 6.49596214e-01f, -1.12074876e+00f, 2.26325348e-01f, -9.89008546e-01f, 9.47540402e-01f, -7.70424724e-01f, -1.31069386e+00f,
  2.43487239e-01f, 9.53438342e-01f, -4.11463469e-01f, 1.28276438e-01f, -2.55768806e-01f, 6.82239011e-02f, -3.68969850e-02f, -3.36056590e-01f, -1.14433825e+00f, -8.75390470e-01f,
  -1.28163660e+00f, -9.66285527e-01f, 1.00651717e+00f, -1.37621582e+00f, 1.62409097e-01f, 3.83090675e-02f, 9.19618309e-01f, -4.76427704e-01f, 1.56681180e-01f, -1.37189806e-01f,
  -3.60011399e-01f, -8.41281235e-01f, 8.80218744e-02f, 5.53736985e-01f, -1.08896124e+00f, -5.80920756e-01f, -1.83827624e-01f, 1.00195575e+00f, 6.17879391e-01f, -4.40397978e-01f,
  6.46768749e-01f, -9.44346726e-01f, -1.16061032e+00f, -7.70688295e-01f, -1.51275426e-01f, 5.86767316e-01f, -6.96299016e-01f, -8.32346857e-01f, -5.69482803e-01f, -7.03238249e-01f,
  3.67380530e-01f, -5.96901357e-01f, -2.81874686e-01f, -4.74913836e-01f, 5.79628527e-01f, 9.11779284e-01f, -1.36161971e+00f, -1.43578160e+00f, 7.93084681e-01f, -1.15140927e+00f,
  -9.86320972e-02f, 1.09012711e+00f, -2.50126719e-01f, 1.49471974e+00f, 2.19043940e-01f, 1.32557619e+00f, -1.24393415e+00f, -1.07101059e+00f, 1.16820717e+00f, 2.73690104e-01f,
  -2.80220538e-01f, -1.37735820e+00f, -1.33247602e+00f, 3.05029124e-01f, -2.86122680e-01f, 8.42940211e-02f, 6.95749342e-01f, 2.77752906e-01f, -4.30110633e-01f, -1.30571008e+00f,
  8.09504390e-01f, -1.52460825e+00f, -1.25486064e+00f, -8.89841855e-01f, -1.13320434e+00f, 1.42633331e+00f, -6.14461005e-01f, -3.52906436e-01f, -1.17353451e+00f, 4.09018993e-01f,
  -5.17103016e-01f, 5.07791162e-01f
};

// L1_linear_B (Shape: 1 x 12)
const int L1_linear_B_rows = 1;
const int L1_linear_B_cols = 12;
const float L1_linear_B_data[] = {
  3.86559010e-01f, -1.03096738e-01f, -4.48539630e-02f, 1.15151078e-01f, -1.39382467e-01f, 1.97022527e-01f, -1.49112463e-01f, -4.71779317e-01f, -7.02701747e-01f, -5.17917693e-01f,
  4.76716548e-01f, -2.48741135e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 3, 10
    );
    
    // Camada 1: L1_linear
    linear_forward_pgm(
        buffer1, x_out,
        L1_linear_W_data, L1_linear_B_data,
        16, 12
    );
    }
    