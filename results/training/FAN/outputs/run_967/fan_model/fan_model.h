/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 16 (x1)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 16;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    return (x > 0.0f) ? x : 0.0f;
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 4 x 120)
const int L0_fan_Wp_rows = 4;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  7.15679884e-01f, -6.10714555e-01f, 2.34601051e-02f, -4.94337678e-02f, 2.03321278e-01f, 2.43242964e-01f, -8.61869454e-02f, 3.54654938e-02f, -1.73733681e-02f, -2.27987155e-01f,
  -3.79260965e-02f, 6.18249476e-02f, -4.12470512e-02f, 1.07777053e-02f, 2.75767654e-01f, -3.42010796e-01f, -3.35401297e-01f, 2.99288750e-01f, 6.16579413e-01f, 2.67054230e-01f,
  -8.52565020e-02f, -1.86672956e-01f, 2.13463873e-01f, 5.22347949e-02f, -3.96343708e-01f, -1.71474963e-02f, -2.21230268e-01f, -1.66069821e-01f, 1.08400308e-01f, -6.61571324e-01f,
  -9.93800163e-02f, -7.33999759e-02f, 1.44103646e-01f, 1.05950743e-01f, -9.85334143e-02f, 5.73187247e-02f, 4.16540802e-02f, -3.58100533e-02f, 3.23983394e-02f, -9.48258042e-02f,
  4.26415447e-03f, 1.17058773e-02f, 1.25236688e-02f, -9.26152170e-02f, -5.45720250e-05f, -1.72786880e-02f, -4.12479825e-02f, 5.36842868e-02f, -2.65926924e-02f, -4.90548201e-02f,
  -9.65955257e-02f, 6.21859431e-02f, 5.58255352e-02f, 1.58198357e-01f, 2.72871852e-01f, 1.51583895e-01f, -9.16045252e-03f, 4.75102291e-02f, 2.53536105e-01f, -1.46686465e-01f,
  7.50244304e-04f, -3.60391277e-04f, 6.36223406e-02f, -7.59077147e-02f, -4.52888608e-02f, -1.45559721e-02f, -6.88417628e-02f, -8.91759433e-03f, 3.10159922e-02f, -1.68473106e-02f,
  -6.73738644e-02f, -2.71355975e-02f, 2.06951443e-02f, 3.13087460e-03f, -8.74685943e-02f, -1.72575377e-02f, -1.73913562e-04f, -8.89058188e-02f, 7.43834302e-03f, -1.48736045e-01f,
  3.21125500e-02f, -2.43225396e-02f, -6.83557317e-02f, -3.41691524e-02f, -5.71264476e-02f, -4.51492891e-02f, -2.80270483e-02f, -3.98643455e-03f, -7.49714971e-02f, -1.75487511e-02f,
  -1.22203164e-01f, 3.12862962e-01f, -1.51695177e-01f, -1.25707742e-02f, 1.00145191e-01f, -3.64864655e-02f, 1.60170812e-02f, 2.20082179e-02f, -3.25145014e-02f, -8.38033576e-03f,
  1.10460959e-01f, 8.35803673e-02f, -3.01695392e-02f, 5.01043834e-02f, 9.08645838e-02f, 8.22728053e-02f, 1.59386322e-02f, -9.79768345e-04f, -9.07904468e-03f, -1.32768229e-01f,
  -1.10457689e-01f, 4.85267974e-02f, 4.46674488e-02f, 2.93079950e-02f, -6.83316542e-03f, 1.58220589e-01f, -6.14914447e-02f, -7.95714837e-03f, 1.73225507e-01f, -1.45612180e-01f,
  -3.67563605e-01f, -2.04022512e-01f, -9.89319742e-01f, 7.50855729e-02f, 7.24466592e-02f, 3.84094119e-02f, -2.16998711e-01f, -2.52758563e-02f, 2.52212703e-01f, -8.41834471e-02f,
  3.30363482e-01f, 3.67746860e-01f, 5.00424467e-02f, 1.32087350e-01f, -1.55930787e-01f, -2.90508151e-01f, -4.25194472e-01f, -3.69081289e-01f, -4.57351618e-02f, 3.47145230e-01f,
  4.99189079e-01f, 1.37213662e-01f, -3.65774632e-02f, -4.30987179e-02f, 1.80808887e-01f, 1.55132994e-01f, -1.69597998e-01f, 5.23204207e-02f, -5.83929429e-03f, -2.09366605e-01f,
  -3.68524462e-01f, -3.56078058e-01f, -8.99330452e-02f, 8.42838138e-02f, -2.52295099e-02f, -1.05727002e-01f, -9.95707139e-02f, -1.92160249e-01f, -2.99917860e-03f, -1.32232398e-01f,
  1.23618077e-02f, -6.73805457e-03f, 5.26125021e-02f, 3.26631665e-02f, -3.68749797e-02f, -7.93053135e-02f, -1.41315803e-01f, -2.28075445e-01f, -1.55884117e-01f, 5.09750359e-02f,
  2.13704765e-01f, 1.38337091e-01f, -1.34021729e-01f, -1.28614172e-01f, -8.45525190e-02f, -1.30110562e-01f, -1.60529271e-01f, -1.31936684e-01f, -2.12823272e-01f, -2.71589071e-01f,
  6.69581592e-02f, 4.26806435e-02f, 2.21171901e-02f, -7.37194866e-02f, 4.67594266e-02f, 2.78392173e-02f, -3.53405182e-03f, 9.30817798e-02f, 4.68366630e-02f, -6.42374232e-02f,
  -2.59058941e-02f, -4.93355058e-02f, -4.59375698e-03f, -4.44697551e-02f, 5.88536449e-02f, -2.77273287e-03f, 5.42702042e-02f, 5.51793911e-02f, 7.20365420e-02f, -6.27046004e-02f,
  -3.76654007e-02f, -7.70939663e-02f, 3.52999456e-02f, 5.09164445e-02f, -7.79266506e-02f, -1.43393993e-01f, -9.09842700e-02f, 2.75291782e-02f, -3.70750241e-02f, -5.93138812e-03f,
  -3.02314802e-05f, -5.15884012e-02f, -3.45111862e-02f, -1.19174607e-01f, -9.27577447e-03f, 6.19611181e-02f, 5.90831898e-02f, 2.23147925e-02f, -3.45255211e-02f, -1.52778372e-01f,
  -6.85395254e-03f, 6.70353696e-02f, -4.37529758e-02f, 4.86019105e-02f, -4.41044010e-02f, -7.12026432e-02f, 1.06937215e-01f, -6.44513080e-03f, 6.49249330e-02f, 8.48047733e-02f,
  4.69198972e-02f, 6.80379346e-02f, 1.88753530e-02f, -7.89188817e-02f, -3.40622999e-02f, 3.46852541e-02f, -1.68657601e-01f, -1.24247209e-03f, -1.81400150e-01f, -2.11754352e-01f,
  -1.64123401e-01f, -3.83337140e-01f, 9.78266522e-02f, -1.97038502e-01f, -6.61963457e-03f, 8.12162906e-02f, -2.02194110e-01f, 7.79721364e-02f, 1.00053504e-01f, -6.26989007e-02f,
  1.45208970e-01f, 2.77273208e-01f, 3.71458113e-01f, 3.25149745e-01f, 9.82383862e-02f, -3.28520358e-01f, -3.09708655e-01f, -3.11873686e-02f, 1.99643001e-01f, 2.51193885e-02f,
  -1.44527912e-01f, -5.35383597e-02f, -6.08115941e-02f, -2.20880106e-01f, -3.50023627e-01f, -6.13692813e-02f, -2.22504765e-01f, -6.26706332e-02f, -5.44953011e-02f, -6.38661742e-01f,
  -6.91582412e-02f, 8.64393115e-02f, 1.98396295e-01f, 4.80206795e-02f, -2.07340997e-02f, 2.25292146e-02f, -8.76726732e-02f, -2.60127634e-02f, 1.13350607e-01f, 2.89802309e-02f,
  8.55615139e-02f, 1.22783430e-01f, 6.54676408e-02f, 4.39732149e-02f, 8.12995210e-02f, 8.48686993e-02f, 5.61036244e-02f, -3.91238593e-02f, 2.51238439e-02f, 7.14683011e-02f,
  -9.90927666e-02f, -1.70799702e-01f, -4.50265454e-03f, 6.99773207e-02f, 9.80713591e-02f, 1.00418277e-01f, 3.42164934e-02f, -8.32873285e-02f, 3.83970402e-02f, -2.70207912e-01f,
  -4.55844775e-03f, -6.86270967e-02f, -2.57717837e-02f, -2.98071373e-02f, -5.80830015e-02f, 9.65072680e-03f, -4.74078469e-02f, 9.85367689e-03f, -1.04050217e-02f, -3.73149663e-02f,
  -2.78923530e-02f, -2.11617351e-02f, 4.95337229e-03f, -1.05813481e-01f, -1.33688286e-01f, -2.54006572e-02f, -9.98429805e-02f, -3.75797115e-02f, -7.59761373e-04f, 5.11557013e-02f,
  -1.61773153e-02f, 5.28878234e-02f, -3.85865867e-02f, -5.66144995e-02f, -2.09583975e-02f, -7.04773143e-02f, 5.19832820e-02f, -6.43151253e-03f, 9.59307924e-02f, -3.60957384e-02f,
  9.87815633e-02f, 2.32509270e-01f, -1.57748953e-01f, 4.60497402e-02f, 4.42894027e-02f, 7.75754079e-02f, 1.63153317e-02f, 4.06188369e-02f, 9.26624462e-02f, 1.30361822e-02f,
  1.20097838e-01f, 5.84515557e-02f, 6.68808743e-02f, -7.39890784e-02f, 2.72746421e-02f, 3.23323868e-02f, -1.05222883e-02f, -1.41385114e-02f, 6.15592189e-02f, 3.49298120e-02f,
  -5.43650202e-02f, -6.17219843e-02f, 8.15242082e-02f, 6.35741800e-02f, 7.08638206e-02f, -5.03974110e-02f, -5.75050972e-02f, -7.20621347e-02f, 8.27547014e-02f, -2.97358572e-01f,
  -2.90335864e-01f, 5.11466444e-01f, 1.40797600e-01f, 2.82231450e-01f, 2.38324642e-01f, 8.09011310e-02f, 3.27252537e-01f, -4.15639989e-02f, -3.41972917e-01f, 3.29730451e-01f,
  1.90731511e-01f, 5.81806451e-02f, 1.63844731e-02f, -2.07489990e-02f, -6.40963092e-02f, 4.22880083e-01f, 2.54733324e-01f, -1.96258873e-01f, -2.17724055e-01f, 3.42954881e-02f,
  1.93065792e-01f, 1.12957440e-01f, -1.71049967e-01f, -2.28658691e-01f, 1.85829058e-01f, -5.97308949e-02f, 3.78479026e-02f, 1.63996033e-02f, -6.88718259e-02f, 3.32377195e-01f,
  2.78010845e-01f, -4.81047444e-02f, -1.63079560e-01f, 5.08061834e-02f, 6.50397837e-02f, -3.52290682e-02f, 4.27823849e-02f, -1.13555640e-01f, -1.00884736e-01f, 5.19056320e-02f,
  3.57775874e-02f, 6.98304623e-02f, -7.79073387e-02f, 7.77696744e-02f, 2.61364970e-02f, 6.51345626e-02f, -7.07667023e-02f, -6.71473369e-02f, -8.19283053e-02f, 2.07445510e-02f,
  2.02053532e-01f, 8.36419091e-02f, -5.02111539e-02f, -1.62810728e-01f, -1.08975396e-01f, -2.41526678e-01f, -4.53057028e-02f, -3.59123200e-02f, -2.03503102e-01f, -1.95377204e-03f,
  5.70821613e-02f, -1.19270869e-01f, -8.93832445e-02f, -3.37137207e-02f, -2.82544047e-02f, -1.53468907e-01f, -2.82300524e-02f, -3.95227894e-02f, -6.51883930e-02f, -1.25950083e-01f,
  4.41402011e-02f, 4.84218299e-02f, 2.30568442e-02f, -1.08603016e-02f, 7.53343701e-02f, -4.09310870e-02f, -3.56051885e-02f, 1.16825201e-01f, -1.02839537e-01f, -1.07626416e-01f,
  1.81316286e-02f, -2.05819026e-01f, -2.74215396e-02f, -2.04904154e-02f, 5.86750656e-02f, 1.03938878e-01f, -3.03885117e-02f, -1.05030416e-02f, -5.05143069e-02f, -4.43387702e-02f,
  -1.06977925e-01f, -2.09952578e-01f, 2.47448497e-03f, -9.61449668e-02f, -8.72064456e-02f, -1.10905431e-01f, -6.04809076e-02f, -8.69607478e-02f, -6.12567812e-02f, 5.77835627e-02f,
  -9.98010784e-02f, 2.15749014e-02f, -9.36085079e-03f, -3.73345837e-02f, -6.99673872e-03f, -4.10179533e-02f, 3.56088132e-02f, 4.57063913e-02f, -1.60400912e-01f, -6.73158392e-02f,
  -9.54486206e-02f, -9.30244997e-02f, -1.11053720e-01f, -5.78624345e-02f, -1.92406639e-01f, -7.33571425e-02f, -1.57539219e-01f, -1.82173505e-01f, -1.21211506e-01f, 1.09763190e-01f
};

// L0_fan_Wp_bar (Shape: 8 x 120)
const int L0_fan_Wp_bar_rows = 8;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  1.53899837e+00f, 3.61891210e-01f, -2.07383752e+00f, -4.76129875e-02f, -1.33811116e+00f, -1.25964952e+00f, -7.11122930e-01f, -3.25561389e-02f, 1.79913625e-01f, -5.11897445e-01f,
  -9.57425684e-02f, 7.45537698e-01f, 3.99560720e-01f, -2.19688907e-01f, 1.12368599e-01f, -9.03769493e-01f, -1.29320931e+00f, -6.52393162e-01f, -6.51244223e-01f, -5.21842957e-01f,
  -2.55143940e-01f, 3.73355001e-02f, 2.70016551e-01f, -2.44264957e-03f, -3.49333614e-01f, 1.32661313e-01f, -6.83595479e-01f, -6.74393415e-01f, -4.87079650e-01f, -7.06630766e-01f,
  -6.39128387e-01f, -5.61521649e-01f, -2.35965714e-01f, 1.23672612e-01f, -2.05777600e-01f, 9.84515548e-02f, 1.18165284e-01f, 8.94952342e-02f, 1.27541974e-01f, 1.11116156e-01f,
  5.69335045e-03f, 1.85128257e-01f, 3.79662775e-02f, -3.13648373e-01f, -3.15107226e-01f, -1.15642183e-01f, -6.24264851e-02f, -1.66364208e-01f, -3.72618884e-02f, -1.70554593e-01f,
  -2.14692682e-01f, -3.53894889e-01f, -9.24260542e-02f, -1.73539236e-01f, -2.51637310e-01f, -2.19724819e-01f, -3.06626439e-01f, -3.90242875e-01f, -1.95682421e-01f, 1.90090463e-01f,
  -1.67606071e-01f, 2.73536947e-02f, -4.88812141e-02f, 1.59200504e-01f, 2.83178180e-01f, 1.27695620e-01f, 1.98974609e-02f, 4.17279676e-02f, -4.42523323e-03f, -3.92734539e-03f,
  -1.76009163e-01f, -8.11611414e-02f, -4.19735909e-04f, 2.64062166e-01f, -3.80050130e-02f, -2.08744958e-01f, -4.52126786e-02f, -3.37366387e-02f, 1.11999370e-01f, 4.97518331e-02f,
  -8.78106579e-02f, -2.14502551e-02f, 1.13891013e-01f, -1.14741012e-01f, -3.23532403e-01f, -7.27861300e-02f, 5.60347773e-02f, 6.27490878e-02f, 2.16610178e-01f, -2.89041586e-02f,
  1.13013828e+00f, -4.27161694e-01f, 4.33090687e-01f, 1.04851700e-01f, -1.72417969e-01f, -6.77269250e-02f, 3.51761989e-02f, 4.14938480e-02f, 1.51942089e-01f, 2.02673987e-01f,
  -1.82733670e-01f, 2.26413935e-01f, -6.52050823e-02f, -1.70629472e-01f, -1.43567443e-01f, 7.06570819e-02f, 1.06505387e-01f, -8.11749548e-02f, -4.97556711e-03f, -3.70170832e-01f,
  -1.40147224e-01f, 2.01286182e-01f, 6.11882329e-01f, 3.53495419e-01f, 5.96596636e-02f, 2.39166349e-01f, 2.31045827e-01f, 1.44595951e-01f, 4.36814636e-01f, 9.20423388e-01f,
  7.63285279e-01f, -4.55837786e-01f, 4.24596548e-01f, 4.49716926e-01f, -4.38757867e-01f, -7.62213111e-01f, -9.62532401e-01f, -3.90234083e-01f, -4.96556796e-02f, -3.08110118e-01f,
  -3.13353330e-01f, 4.53034282e-01f, 5.10850489e-01f, 6.74674511e-01f, 5.19459188e-01f, -7.03898519e-02f, 5.73863387e-01f, 1.02565312e+00f, 7.43857324e-01f, 7.25063831e-02f,
  1.12972986e-02f, 2.04318553e-01f, 4.35201198e-01f, 2.61499137e-01f, -4.25647534e-02f, 2.86532015e-01f, 2.62190867e-02f, -5.22788465e-02f, -2.99055185e-02f, 6.01874232e-01f,
  -1.73853084e-01f, -9.17445049e-02f, 2.31508225e-01f, 8.62149298e-02f, -5.26059745e-03f, 5.69738969e-02f, -1.34923458e-01f, -7.49215707e-02f, -1.67286113e-01f, -4.58095707e-02f,
  -1.27102181e-01f, 2.97540420e-04f, 1.10726424e-01f, -1.08769752e-01f, -1.85283020e-01f, -1.15588486e-01f, 1.54828861e-01f, 5.07220447e-01f, 3.09471577e-01f, -1.64990291e-01f,
  7.51735866e-02f, -2.92113304e-01f, -3.19914073e-01f, -2.16408789e-01f, 6.95028082e-02f, 4.32016104e-01f, -2.73106962e-01f, -1.15531281e-01f, -1.09291553e-01f, -3.96402739e-02f,
  3.86866070e-02f, 1.19437158e-01f, 6.27099127e-02f, 1.29149541e-01f, 2.29610190e-01f, -5.52429184e-02f, 1.32437259e-01f, 2.30245944e-02f, 1.79361656e-01f, -1.43784538e-01f,
  1.28652349e-01f, 3.59942131e-02f, 2.99942624e-02f, -4.93723303e-02f, 1.70681790e-01f, -1.67542696e-01f, -1.92772090e-01f, 3.54850963e-02f, -3.36864479e-02f, -4.80436608e-02f,
  2.82354265e-01f, 1.04702204e-01f, -1.35502964e-01f, 1.56391263e-01f, -3.16100791e-02f, 1.95945159e-01f, 1.54235780e-01f, -2.42603764e-01f, -1.36261478e-01f, -6.41076937e-02f,
  -8.39973211e-01f, 4.54430640e-01f, 1.64879516e-01f, 2.74822563e-01f, -9.10424516e-02f, -1.79071695e-01f, 9.93548855e-02f, 7.32965618e-02f, 1.97214056e-02f, -1.63264677e-01f,
  -3.23707879e-01f, 5.06864265e-02f, -8.90433192e-02f, 6.61630705e-02f, -7.93800354e-02f, -3.31272751e-01f, -1.56173080e-01f, 2.44010076e-01f, 3.85151990e-02f, -1.93970770e-01f,
  -4.19868529e-02f, -3.08418244e-01f, -1.03835896e-01f, -8.11129510e-02f, -2.09226206e-01f, 2.10498035e-01f, -2.33944207e-01f, -3.53569567e-01f, -2.54147112e-01f, -4.49592978e-01f,
  -1.09303975e+00f, 8.58061731e-01f, 7.16435313e-01f, 2.00474635e-01f, 7.13850856e-01f, 1.16562441e-01f, 1.47701308e-01f, -3.74677837e-01f, -2.69063145e-01f, 2.89290190e-01f,
  7.01214969e-01f, -4.53787565e-01f, 7.24395066e-02f, -3.63325626e-01f, -8.13402951e-01f, 4.89165992e-01f, 5.08157790e-01f, -6.55164897e-01f, -1.48588145e+00f, -1.07689083e+00f,
  -5.48927128e-01f, -4.56241906e-01f, -7.20041335e-01f, -3.10522884e-01f, 7.25905240e-01f, -1.83674708e-01f, 9.20770466e-01f, 6.47930562e-01f, 7.17710555e-01f, 1.01059651e+00f,
  2.19065681e-01f, 4.71447915e-01f, -5.00517488e-01f, -4.13595773e-02f, 3.25613588e-01f, -5.40998399e-01f, -3.89206886e-01f, -2.26061046e-02f, 2.02262521e-01f, 1.45041168e-01f,
  2.54205674e-01f, -1.57540455e-01f, 1.80356205e-01f, 7.67289549e-02f, -3.19478124e-01f, -3.87204975e-01f, -2.04646230e-01f, -4.79068458e-01f, -1.63469091e-01f, -1.50301367e-01f,
  3.91075283e-01f, 1.26478434e-01f, 2.50652581e-01f, -4.49793413e-02f, 1.31285340e-01f, -2.44770661e-01f, 3.08995426e-01f, -6.99352473e-02f, 1.12382799e-01f, 1.35039568e-01f,
  -1.78281158e-01f, 1.26321241e-01f, 5.82904927e-02f, 1.63972571e-01f, -1.51078971e-02f, 5.61872497e-02f, 2.09991217e-01f, -2.92108692e-02f, -6.99213445e-02f, -2.68226147e-01f,
  5.75812273e-02f, -3.74100171e-02f, 1.01431767e-02f, -7.60434493e-02f, -8.54823142e-02f, 6.45493045e-02f, 4.69723949e-03f, -1.98313355e-01f, 2.15013269e-02f, -1.35598034e-01f,
  -1.26670524e-02f, 1.99500367e-01f, 8.87589082e-02f, -2.13214085e-01f, 9.13086534e-02f, 1.34254441e-01f, -3.64872590e-02f, -1.57604679e-01f, -1.36844575e-01f, 1.63070321e-01f,
  -5.61808944e-01f, 7.99464062e-02f, -1.50819629e-01f, -3.60468656e-01f, 2.38944039e-01f, 2.05691874e-01f, 2.38121986e-01f, 8.42182860e-02f, 3.30271840e-01f, -3.46500784e-01f,
  -1.32601127e-01f, -6.20249771e-02f, 2.99325913e-01f, 6.95821494e-02f, -4.67270225e-01f, -3.04943975e-02f, 9.04156361e-03f, 1.40714690e-01f, -2.68247694e-01f, 6.39923289e-02f,
  1.47578031e-01f, -6.96451545e-01f, -1.04234946e+00f, -3.21127772e-01f, -3.21974009e-01f, -7.10865796e-01f, -5.75434387e-01f, -6.20235324e-01f, -4.61551577e-01f, -1.02389598e+00f,
  5.73408425e-01f, -4.72943634e-01f, -7.22782373e-01f, 8.48049164e-01f, -1.21902481e-01f, -1.04604244e+00f, -1.70939028e+00f, -6.76852345e-01f, 4.82669562e-01f, -8.26889351e-02f,
  -2.37493981e-02f, 2.88122237e-01f, -2.98933424e-02f, -3.69883567e-01f, -7.49618530e-01f, -7.11726904e-01f, -4.51736689e-01f, -2.47556493e-01f, -3.09986502e-01f, -1.04476223e-02f,
  2.66526461e-01f, 6.04641259e-01f, 6.67473555e-01f, 1.72169551e-01f, 8.66691828e-01f, 2.00840607e-01f, 4.31075633e-01f, 5.93027651e-01f, -1.48610383e-01f, 4.60859001e-01f,
  5.41309476e-01f, -6.19254038e-02f, -2.18184203e-01f, 1.34984404e-01f, 4.57848758e-01f, 1.20840259e-01f, 1.20507486e-01f, 5.07470369e-01f, -4.31959853e-02f, 4.11869679e-03f,
  2.55242795e-01f, 1.73356518e-01f, 1.68819204e-01f, 4.94714826e-02f, 3.38325113e-01f, -1.78830162e-01f, 7.69397756e-03f, -2.42360264e-01f, -7.46098533e-02f, 1.05218917e-01f,
  -6.99808598e-02f, -1.20715715e-01f, -4.47014302e-01f, -4.53197956e-01f, 6.62893355e-02f, 3.10092550e-02f, -2.50873026e-02f, 2.79008180e-01f, -3.49929392e-01f, 5.51426053e-01f,
  -4.38854657e-03f, 3.14032845e-02f, 1.10199891e-01f, 4.19620611e-02f, 1.81292500e-02f, -1.61095709e-01f, 1.23094462e-01f, -2.24253684e-02f, 2.33829245e-02f, 8.68895836e-03f,
  -2.21349135e-01f, 8.22086856e-02f, 2.03601226e-01f, -5.81199601e-02f, -1.70600221e-01f, 1.37702242e-01f, -2.91091073e-02f, 4.72020097e-02f, -3.12668651e-01f, -6.76896945e-02f,
  -1.50289446e-01f, -2.73810327e-01f, 4.24854070e-01f, -4.44701277e-02f, -7.54619390e-02f, -5.99736907e-02f, 1.58224002e-01f, 2.15182453e-02f, 4.01853904e-04f, 3.56853381e-03f,
  2.26972401e-01f, -6.43113434e-01f, 5.55822030e-02f, -4.76252250e-02f, 7.39084482e-02f, 5.10932319e-02f, 1.89185254e-02f, -1.94156498e-01f, 1.18594229e-01f, -6.59681112e-02f,
  -1.44996000e-02f, -5.60655557e-02f, 2.50263035e-01f, -1.97708756e-01f, -7.08901836e-03f, -1.02391623e-01f, 7.47739375e-02f, -4.10938174e-01f, -3.36541831e-01f, 5.01835465e-01f,
  -1.54369706e-02f, -3.77968758e-01f, -7.58078516e-01f, -6.41426206e-01f, 2.69768208e-01f, -5.03642082e-01f, -3.82545859e-01f, -5.80394343e-02f, -8.35122228e-01f, -3.79835933e-01f,
  -2.05325365e+00f, -6.36238754e-01f, 1.87210888e-01f, -2.08229804e+00f, -4.02444005e-01f, 4.52013314e-01f, 1.92859396e-01f, 3.79917286e-02f, -5.63099682e-01f, -4.22298491e-01f,
  -2.68982630e-02f, -3.64561200e-01f, -8.48152995e-01f, 8.19405541e-04f, -2.37105135e-02f, -3.36031973e-01f, -6.88567162e-01f, -1.96536541e-01f, 7.07163811e-01f, 7.48668075e-01f,
  2.39727929e-01f, -4.66192394e-01f, -4.06775802e-01f, 1.19377570e-02f, -6.64005637e-01f, -2.10909784e-01f, -4.01999027e-01f, -5.61282635e-01f, 1.59799680e-01f, -1.28588235e+00f,
  2.57211048e-02f, -3.65099251e-01f, 4.02200937e-01f, -1.91229016e-01f, 1.22533172e-01f, -3.46536905e-01f, -1.67835712e-01f, -3.92373323e-01f, 1.78945623e-02f, 9.97075438e-03f,
  -5.95967233e-01f, 1.93333402e-01f, -5.27898490e-01f, 1.50325283e-01f, -3.97363007e-01f, 4.81341854e-02f, -5.88054173e-02f, 5.91179021e-02f, 9.95323658e-02f, 3.58885378e-01f,
  -3.18456329e-02f, 2.13739164e-02f, -2.26288900e-01f, 4.23627168e-01f, 5.07820249e-01f, 5.31907231e-02f, 6.30980134e-01f, 5.68144977e-01f, 5.31843126e-01f, -5.02113581e-01f,
  1.07812658e-01f, -3.38685103e-02f, 3.92169803e-02f, 2.43422296e-02f, -4.92656343e-02f, -7.36333802e-02f, -2.12131679e-01f, -3.90628166e-03f, 1.36812061e-01f, -5.54959197e-03f,
  1.36519223e-01f, -1.15712143e-01f, 1.89014718e-01f, -2.64724731e-01f, 7.09110964e-03f, -1.18052863e-01f, -1.24555985e-02f, 1.93910211e-01f, 2.41120122e-02f, -2.73481488e-01f,
  2.21247748e-02f, -1.00953607e-02f, -2.08976075e-01f, 1.54974923e-01f, 1.66604146e-01f, -5.17750718e-02f, 2.55760998e-02f, 3.49318087e-01f, -2.37745240e-01f, 1.15834720e-01f,
  -6.07280374e-01f, 3.83982211e-01f, -7.69461036e-01f, 9.00867805e-02f, -2.37132743e-01f, 3.29203121e-02f, -3.46132636e-01f, 2.32708335e-01f, -2.20721379e-01f, 5.40980510e-02f,
  1.09649256e-01f, 6.27813041e-02f, -1.06135838e-01f, 3.50551307e-02f, 3.36543508e-02f, -4.57543433e-02f, -7.32460171e-02f, -4.46402192e-01f, 1.76350430e-01f, -1.61113811e-03f,
  9.26034078e-02f, -5.25585795e-03f, -5.70613801e-01f, -2.72335708e-01f, -1.75457783e-02f, -4.26951200e-01f, 7.38677010e-02f, 1.64319888e-01f, -1.74444929e-01f, -6.04846776e-01f,
  -1.35421371e+00f, -5.42129576e-01f, 4.27219272e-01f, -1.23200946e-01f, 5.38492978e-01f, 5.00796676e-01f, 3.97640288e-01f, -3.17074284e-02f, -1.28646299e-01f, -1.37225732e-01f,
  -5.08465290e-01f, -1.46117270e-01f, 3.66557501e-02f, 9.86886322e-02f, -5.12211658e-02f, 5.48328221e-01f, 5.88463902e-01f, 4.46211874e-01f, 5.77433228e-01f, 3.06238383e-01f,
  2.11388156e-01f, -3.09463963e-02f, -6.47258162e-01f, 3.42018455e-02f, 1.03384852e-01f, 4.03216302e-01f, -9.32873785e-02f, -1.30703047e-01f, 8.37505907e-02f, 3.76516700e-01f,
  3.28550100e-01f, -9.33615863e-01f, 4.87158932e-02f, -3.78365785e-01f, -1.87251240e-01f, -2.72396684e-01f, 1.32435501e-01f, -1.33383110e-01f, -1.63836926e-01f, 2.90630199e-02f,
  -2.37095207e-01f, -2.27607980e-01f, 1.30178347e-01f, -4.90428172e-02f, 5.01187742e-02f, -7.25945458e-02f, -2.73130059e-01f, -1.32836118e-01f, -1.13402255e-01f, -9.79224071e-02f,
  1.31193429e-01f, -9.01752189e-02f, -1.23986718e-03f, 1.51219741e-01f, -9.16183814e-02f, 9.55144539e-02f, -1.13154493e-01f, -1.78304017e-01f, -5.66817373e-02f, -8.97642523e-02f,
  1.69844791e-01f, 1.16827391e-01f, 8.82080197e-03f, 2.42471471e-02f, -1.80643331e-02f, -3.97600373e-03f, 2.18739688e-01f, 2.92689931e-02f, 1.23960577e-01f, -7.36689046e-02f,
  -9.42759439e-02f, 7.81737491e-02f, -2.23467052e-02f, 2.11877953e-02f, 1.05370022e-01f, -1.06466720e-02f, 9.75864455e-02f, 5.04823625e-02f, -1.93962410e-01f, -1.14891827e-01f,
  -1.73487529e-01f, -7.47984499e-02f, -1.61048770e-01f, 1.14471748e-01f, -8.36949870e-02f, 3.96655500e-03f, 7.74713457e-02f, -1.11739725e-01f, -6.00730926e-02f, -1.08043045e-01f,
  4.68413860e-01f, -1.68287680e-01f, 2.65387058e-01f, 4.70153503e-02f, -1.29303947e-01f, -4.78480846e-01f, 5.33527285e-02f, -8.97951871e-02f, -8.81575122e-02f, 3.85742523e-02f,
  -3.22266281e-01f, -1.17462471e-01f, 2.69748960e-02f, -7.76239857e-02f, 1.84883073e-01f, 9.85413324e-03f, -2.48880088e-01f, 1.22777417e-01f, -8.11548010e-02f, -1.71654269e-01f,
  -4.56740484e-02f, 1.82003289e-01f, 2.55256355e-01f, 3.74511302e-01f, 3.05784605e-02f, 4.31208640e-01f, 2.60988772e-01f, 1.64755821e-01f, 2.63553411e-01f, 2.13929132e-01f,
  1.17133772e+00f, 5.62234282e-01f, 3.14934641e-01f, -9.24846902e-02f, -3.83395612e-01f, 2.87446529e-01f, 1.09521890e+00f, 9.25548911e-01f, 8.74664932e-02f, 3.61355543e-01f,
  -8.53345871e-01f, -1.36442792e+00f, -1.01888978e+00f, -6.16557002e-01f, 1.88787222e-01f, 4.75827307e-01f, 2.30145767e-01f, 1.56768546e-01f, 2.15489287e-02f, 3.20037715e-02f,
  -4.59079236e-01f, 4.63033259e-01f, 7.88965702e-01f, 2.36974254e-01f, -2.00499352e-02f, -6.74249232e-01f, 3.82131964e-01f, 1.45525485e-01f, -2.51234621e-01f, -2.51803726e-01f,
  -2.54409850e-01f, 4.79314566e-01f, -3.89460146e-01f, -2.02604696e-01f, -3.49185199e-01f, 1.27809897e-01f, 8.57677460e-02f, 2.84949899e-01f, -3.56869549e-01f, 3.36901307e-01f,
  -3.90062213e-01f, 3.22849452e-02f, -4.88019973e-01f, -1.69849560e-01f, 1.84746146e-01f, -2.45537926e-02f, 2.59791434e-01f, 3.22727561e-01f, -1.65441409e-01f, -1.25192523e-01f,
  -7.50685155e-01f, -2.35921934e-01f, 2.69098073e-01f, 2.68511567e-02f, -2.53885500e-02f, -2.32249722e-01f, 1.84199080e-01f, 1.21830747e-01f, -6.22430034e-02f, 2.16871560e-01f,
  -6.09629191e-02f, -8.08289349e-02f, -2.71263942e-02f, 1.12081364e-01f, 6.53351918e-02f, -7.40510970e-02f, -2.07466573e-01f, 1.42237246e-02f, -6.50052307e-03f, 2.00872928e-01f,
  -1.58867672e-01f, 5.27456589e-02f, -8.58521387e-02f, 1.57121375e-01f, -3.25605810e-01f, -2.56644730e-02f, 4.31330875e-03f, 1.20235398e-01f, -2.36361131e-01f, 9.66395363e-02f,
  -9.54168104e-03f, 2.95341723e-02f, -4.43070382e-02f, 1.24989096e-02f, -2.76818797e-02f, -2.08193064e-02f, -1.44527614e-01f, -9.14746150e-02f, -2.46399036e-03f, 3.82384919e-02f,
  -2.27826834e-02f, -6.08801067e-01f, -9.93384123e-02f, -1.60090383e-02f, 1.75132677e-01f, -1.64732903e-01f, -2.76581347e-01f, -1.42782882e-01f, 9.20851808e-03f, 1.23583749e-02f,
  -3.78558598e-02f, 5.27750477e-02f, -1.31959319e-02f, 1.69650540e-01f, -1.19023472e-01f, 6.24751672e-02f, -3.73176597e-02f, -2.63618767e-01f, -4.51195315e-02f, 2.27740332e-01f,
  -6.35357499e-02f, 2.87868381e-01f, 8.06937069e-02f, 1.44568877e-03f, 4.00549732e-02f, -2.78566808e-01f, 3.34034041e-02f, -5.17549589e-02f, -6.82528764e-02f, 5.43320298e-01f,
  1.11482370e+00f, 7.06522048e-01f, 1.77345470e-01f, 3.68040919e-01f, 4.61263686e-01f, 6.03340209e-01f, 7.32896507e-01f, 4.96782362e-01f, 2.28022769e-01f, 3.14874202e-01f,
  4.91662264e-01f, 3.14169407e-01f, 2.27864236e-01f, 1.63352057e-01f, 1.05455153e-01f, -1.99343413e-02f, -5.64864911e-02f, -2.35034555e-01f, -9.80521832e-03f, 2.25778818e-01f,
  1.51429057e-01f, 1.07742637e-01f, 1.60922751e-01f, 5.52229844e-02f, 2.56937146e-02f, -6.09558597e-02f, 1.41822368e-01f, 2.07159355e-01f, 1.65396392e-01f, -2.38251776e-01f,
  1.18483193e-01f, 5.65262794e-01f, -1.37886256e-01f, -1.36376753e-01f, -8.10431540e-02f, -3.01185489e-01f, -1.56538740e-01f, -2.73705363e-01f, -2.61070937e-01f, -2.50285268e-01f,
  -2.33654261e-01f, -1.21473975e-01f, 2.85493750e-02f, -1.52843699e-01f, -7.40498155e-02f, -1.21427596e-01f, -5.65205179e-02f, -3.50032076e-02f, -4.97544780e-02f, -7.14522181e-03f,
  -9.32991952e-02f, 1.18783712e-01f, 4.09175232e-02f, -5.01495961e-04f, 7.58477524e-02f, -1.13164693e-01f, -7.98848644e-03f, -7.87467584e-02f, 1.11060463e-01f, 2.19423100e-02f,
  1.34100676e-01f, 1.00543238e-01f, 2.43070632e-01f, 1.84356853e-01f, 1.61932483e-01f, 8.84110481e-02f, -9.82339010e-02f, 2.52794921e-02f, 3.08981806e-01f, 1.37838289e-01f,
  1.34084385e-03f, 5.59665859e-02f, 1.45344198e-01f, 1.02580905e-01f, -1.09517332e-02f, -1.04802981e-01f, -1.59005314e-01f, -1.35109201e-01f, -1.22743994e-02f, -9.74178016e-02f,
  -8.20496678e-02f, -1.06558487e-01f, -1.46425694e-01f, -1.36626944e-01f, -1.38927460e-01f, -1.11696616e-01f, -2.16756940e-01f, -1.46667659e-01f, -1.44872190e-02f, -2.16811746e-01f,
  1.83226317e-02f, 2.65437305e-01f, -1.91534236e-01f, -6.33936748e-02f, -4.33378592e-02f, -1.21176958e-01f, 1.73316017e-01f, -2.41000906e-01f, -2.94556081e-01f, -1.65311202e-01f,
  1.93802360e-02f, -1.12465605e-01f, -8.52664188e-02f, 5.53185306e-02f, -7.90863708e-02f, -6.86181560e-02f, 5.36494218e-02f, 8.02382156e-02f, 3.76290567e-02f, -3.81850861e-02f,
  2.00257786e-02f, 1.15787402e-01f, 9.04581510e-03f, 6.75097555e-02f, 6.28581867e-02f, 5.56715205e-02f, -1.33853182e-01f, -7.24655688e-02f, 4.76310402e-02f, -3.49113829e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 8)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 8;
const float L0_fan_Bp_bar_data[] = {
  1.07181299e+00f, 1.39463580e+00f, 9.68618214e-01f, 1.23869789e+00f, 1.44836032e+00f, 1.24298990e+00f, 1.46365082e+00f, 5.83836555e-01f
};

// L1_linear_W (Shape: 12 x 16)
const int L1_linear_W_rows = 12;
const int L1_linear_W_cols = 16;
const float L1_linear_W_data[] = {
  -7.09578931e-01f, -1.14153469e+00f, -4.54074472e-01f, -3.21502417e-01f, 1.30612552e+00f, -9.95903611e-01f, -5.34080565e-01f, -1.44659698e-01f, 5.94123863e-02f, -4.24687058e-01f,
  -1.42582619e+00f, 3.94529134e-01f, 7.05117524e-01f, -1.43910778e+00f, -3.09328347e-01f, -8.84410858e-01f, -1.34825981e+00f, 5.02520859e-01f, -2.61362493e-01f, -6.79613173e-01f,
  1.41927123e+00f, -9.03731585e-02f, 7.73599267e-01f, 4.35323834e-01f, 7.95819700e-01f, 7.90895045e-01f, -1.69393468e+00f, -1.16538501e+00f, -5.31938314e-01f, -3.54651988e-01f,
  -1.24617863e+00f, 4.69001323e-01f, 2.12127194e-01f, 7.22873032e-01f, 7.15721786e-01f, 3.70574474e-01f, 1.28578937e+00f, 1.49000749e-01f, 4.34866101e-01f, -8.06277931e-01f,
  -1.32360125e+00f, 1.17927313e+00f, -4.28199947e-01f, 1.58845276e-01f, 3.13646853e-01f, -5.53340316e-01f, -8.15097749e-01f, -1.54969251e+00f, 3.37148011e-01f, 6.20335117e-02f,
  -5.00157833e-01f, 9.82809886e-02f, 1.09752119e-01f, 7.77984321e-01f, -4.19434085e-02f, -2.41033807e-01f, -8.96921396e-01f, -1.17434645e+00f, 7.26500988e-01f, -2.30787778e+00f,
  1.10534811e+00f, -1.10902242e-01f, -5.73842585e-01f, -8.79538238e-01f, 1.21210724e-01f, 1.58099025e-01f, -5.01580119e-01f, -1.49505571e-01f, -1.22422206e+00f, 4.90116596e-01f,
  6.90224349e-01f, -6.76744282e-01f, 1.10735908e-01f, -1.69594109e+00f, 7.41680980e-01f, 4.65191841e-01f, -2.44664103e-01f, -9.50111091e-01f, -7.67930627e-01f, 4.31856424e-01f,
  1.29545367e+00f, -3.10476065e-01f, 7.17169464e-01f, 3.23496461e-01f, -5.20567834e-01f, 8.35425675e-01f, -9.64818448e-02f, -4.03643876e-01f, 6.46142602e-01f, -6.76976740e-01f,
  -2.12362814e+00f, 4.60928261e-01f, -8.83789897e-01f, -4.43093598e-01f, 6.34941280e-01f, 2.33888552e-01f, -3.10762674e-01f, 4.27932618e-03f, -7.18821049e-01f, 1.93090320e-01f,
  -1.24190879e+00f, -1.59486747e+00f, -5.07554054e-01f, 4.51339930e-01f, -1.62824249e+00f, 6.66124105e-01f, -3.81767720e-01f, 3.08036268e-01f, -1.48457551e+00f, -1.51292694e+00f,
  1.10153484e+00f, -3.13745826e-01f, -5.89558065e-01f, -3.92336994e-02f, -5.37235260e-01f, -4.15283471e-01f, -7.07118332e-01f, 1.47614390e-01f, -8.32165033e-02f, -1.90683484e-01f,
  -1.27661371e+00f, 1.51728213e-01f, 1.32103324e+00f, -1.83947968e+00f, -5.76623261e-01f, 7.65827477e-01f, -1.15512443e+00f, 1.11670531e-01f, -1.73573732e-01f, -2.49489814e-01f,
  2.30737776e-01f, 2.49544196e-02f, 8.05077016e-01f, -5.50192297e-01f, -4.58218455e-01f, -3.28324616e-01f, -6.92450702e-01f, -3.92128587e-01f, -8.01443040e-01f, -1.03295398e+00f,
  -1.33313406e+00f, 9.14387107e-01f, 1.31218433e+00f, -4.19057667e-01f, -2.47431234e-01f, 1.05786823e-01f, 1.27772048e-01f, 1.38942108e-01f, -1.25968540e+00f, 1.34555125e+00f,
  -1.06029463e+00f, 3.92496556e-01f, -4.13098752e-01f, 1.83181927e-01f, 4.46393490e-01f, 1.14992583e+00f, -1.95751190e+00f, -4.78616893e-01f, -1.60423255e+00f, -2.93251723e-01f,
  6.40425738e-03f, 8.40317786e-01f, 5.94525218e-01f, 5.90042651e-01f, -1.05530250e+00f, -1.25098729e+00f, 5.40960968e-01f, 1.03313707e-01f, 2.04305455e-01f, -1.29762948e+00f,
  -1.47890782e+00f, -6.26978457e-01f, 3.18294168e-01f, 1.04903316e+00f, -1.36204517e+00f, -1.08289874e+00f, 8.35979342e-01f, -5.76367736e-01f, 3.31555866e-02f, -1.83538884e-01f,
  5.39840877e-01f, -3.05393547e-01f, -5.02009451e-01f, 8.49409550e-02f, -1.38030505e+00f, -7.37863004e-01f, 1.12710166e+00f, -1.27791333e+00f, -6.18338645e-01f, -1.76234496e+00f,
  1.34134889e+00f, 3.24002832e-01f
};

// L1_linear_B (Shape: 1 x 12)
const int L1_linear_B_rows = 1;
const int L1_linear_B_cols = 12;
const float L1_linear_B_data[] = {
  1.21003918e-01f, 3.74003440e-01f, 3.97676915e-01f, -6.06453300e-01f, 8.50056112e-02f, 2.48406023e-01f, 2.42829934e-01f, -4.72140163e-01f, -2.53067136e-01f, -3.64723414e-01f,
  -7.74595559e-01f, 5.57037257e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 4, 8
    );
    
    // Camada 1: L1_linear
    linear_forward_pgm(
        buffer1, x_out,
        L1_linear_W_data, L1_linear_B_data,
        16, 12
    );
    }
    