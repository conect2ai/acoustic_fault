/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 64 (x2)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 64;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    return (x > 0.0f) ? x : 0.0f;
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 25 x 120)
const int L0_fan_Wp_rows = 25;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -1.24037541e-01f, 2.53726661e-01f, 2.19673142e-02f, -1.83540940e-01f, 1.74982697e-01f, -9.54163298e-02f, 2.68833321e-02f, 9.65971798e-02f, 4.88376571e-03f, 1.57799885e-01f,
  -1.34483829e-01f, 7.25151375e-02f, -7.80577213e-02f, -2.10036933e-01f, -4.40488100e-01f, -2.59689629e-01f, -2.19252005e-01f, -6.76687807e-02f, -5.97886443e-02f, 2.79150177e-02f,
  -5.78289712e-03f, -3.08109261e-02f, -1.51530905e-02f, 2.74110913e-01f, 2.08654597e-01f, 2.64095843e-01f, -1.31638810e-01f, 1.69569418e-01f, -6.39824495e-02f, -1.20873235e-01f,
  -3.25468630e-02f, 1.20952800e-01f, 1.32544756e-01f, 3.64665762e-02f, -8.46927688e-02f, 2.24368721e-02f, -5.64667061e-02f, -4.00947593e-02f, -1.96356736e-02f, -4.61308993e-02f,
  1.49869537e-02f, -2.89253369e-02f, -1.52509399e-02f, -7.41052255e-02f, 5.70121594e-02f, 6.08508550e-02f, 1.27369026e-02f, 3.45270149e-02f, 1.17022917e-01f, -1.88918412e-02f,
  1.68137383e-02f, -1.32604316e-01f, 1.54797873e-02f, -1.03130698e-01f, 1.01294685e-02f, -2.54895035e-02f, 8.84928927e-03f, 5.07690758e-02f, -1.66565217e-02f, 9.03973449e-03f,
  -4.11579525e-03f, 2.62677800e-02f, 1.06872812e-01f, -5.22089526e-02f, 1.72316674e-02f, -3.23552825e-02f, 1.39234383e-02f, 6.33916073e-03f, 4.87381518e-02f, 1.49551844e-02f,
  -6.82835802e-02f, -2.52785087e-02f, 2.27647508e-03f, 4.26143110e-02f, -2.68097501e-02f, 9.94200557e-02f, -4.24023494e-02f, -3.65344733e-02f, -2.10363325e-02f, -2.90491357e-02f,
  1.24923801e-02f, -4.98206215e-03f, -2.99024768e-02f, -3.01083792e-02f, 5.74266538e-03f, -1.64803248e-02f, -9.44590196e-03f, 8.21833313e-02f, 1.42485686e-02f, -5.15440591e-02f,
  -1.78202689e-01f, -2.73610465e-03f, 1.25075383e-02f, -4.98261042e-02f, -2.37897169e-02f, 5.51851615e-02f, 4.23807912e-02f, 5.93417138e-02f, 1.87629294e-02f, -4.57015783e-02f,
  4.76477295e-03f, 4.08864953e-02f, -5.94414286e-02f, -1.88649539e-02f, -8.66963938e-02f, -3.18642072e-02f, -3.77190076e-02f, -3.00645884e-02f, -4.16554697e-02f, -5.21943718e-02f,
  4.92317714e-02f, -1.24280965e-02f, 5.15001267e-02f, 1.18723266e-01f, 4.53595333e-02f, 1.90585968e-04f, 7.83990622e-02f, -1.96440239e-02f, -8.39541554e-02f, -2.96950806e-02f,
  2.66319484e-01f, -1.06981128e-01f, 2.27663424e-02f, 2.92637169e-01f, 1.48000553e-01f, 1.98758096e-01f, 1.88563824e-01f, 6.11475743e-02f, 3.43804359e-01f, 1.00961011e-02f,
  9.43297148e-02f, 1.17029995e-01f, -2.19389051e-01f, 2.01225609e-01f, -1.86181262e-01f, -1.41379759e-01f, 2.67466813e-01f, 1.15734510e-01f, -7.83914607e-03f, 3.56218927e-02f,
  2.35467479e-02f, 1.35612026e-01f, -2.18575731e-01f, -5.93039989e-02f, 4.66845855e-02f, 1.33620605e-01f, -1.10321589e-01f, -1.80267215e-01f, 8.66126269e-02f, 7.32970517e-03f,
  1.03358649e-01f, -5.48858456e-02f, 5.02709709e-02f, -1.92615911e-02f, 1.46074742e-02f, -5.35216704e-02f, 3.69932353e-02f, -8.43746290e-02f, 9.54061840e-03f, 5.33197299e-02f,
  4.14345693e-03f, 2.91983522e-02f, 4.91576307e-02f, 2.76716426e-02f, 1.42125888e-02f, 2.99778115e-02f, -7.06641674e-02f, 4.09674086e-02f, -1.57413092e-02f, -9.87839252e-02f,
  -5.27559593e-02f, -4.18198816e-02f, 7.04088202e-03f, 8.15387517e-02f, 1.58557016e-02f, 6.28013909e-02f, 3.59772779e-02f, 9.34858806e-03f, 7.47934133e-02f, 1.02883324e-01f,
  3.74590117e-03f, -2.16893535e-02f, -6.63665906e-02f, -2.91098077e-02f, -2.27339957e-02f, -3.32927629e-02f, 3.95064987e-02f, -1.01934962e-01f, 3.03549152e-02f, -2.17888709e-02f,
  1.33775175e-01f, -4.48216647e-02f, 3.70627386e-03f, 3.95470113e-02f, 6.73507713e-03f, 1.71124768e-02f, -4.32467274e-03f, 2.38058958e-02f, 1.50549471e-01f, -1.71418991e-02f,
  2.65265331e-02f, -5.64009212e-02f, -8.86212662e-03f, -2.21589245e-02f, -6.10400550e-03f, -5.96909150e-02f, 1.00543424e-02f, -2.91637946e-02f, -1.46011347e-02f, -2.33417116e-02f,
  -6.55088499e-02f, -4.26140539e-02f, 4.42304499e-02f, 8.84431452e-02f, -4.01402488e-02f, -4.78761531e-02f, 1.20597268e-02f, 7.51147866e-02f, -5.22282869e-02f, -7.21103251e-02f,
  1.90385506e-02f, 7.59099424e-03f, 4.80433069e-02f, -1.37505285e-03f, 5.19385524e-02f, -1.62256155e-02f, 1.13586169e-02f, 8.30950812e-02f, 3.69744152e-02f, 1.50850508e-02f,
  1.32536218e-02f, 2.41143573e-02f, -1.00947381e-03f, 5.04319668e-02f, 1.23486035e-01f, -7.87362233e-02f, 1.75502095e-02f, 2.90791392e-02f, -9.14719179e-02f, -5.35293249e-03f,
  3.79767939e-02f, -1.90823644e-01f, 2.91081190e-01f, 1.87769544e-03f, 8.40600580e-02f, 2.46078834e-01f, 1.84684336e-01f, 9.15934145e-02f, 3.52903873e-01f, -2.32349187e-01f,
  -8.31550732e-02f, -1.46206066e-01f, 4.43424918e-02f, -1.71261445e-01f, 2.95365721e-01f, 3.05231124e-01f, 6.61737844e-02f, -2.82541737e-02f, 1.54592067e-01f, -6.71635717e-02f,
  6.33344278e-02f, -2.33048841e-01f, -6.88858777e-02f, -2.03431711e-01f, -1.56329021e-01f, -1.41535446e-01f, -2.15926275e-01f, 3.92916724e-02f, -2.71635681e-01f, 3.44652310e-02f,
  -1.11904532e-01f, -1.27490535e-01f, -4.72226925e-02f, -5.75480126e-02f, -7.13939592e-02f, -5.36190346e-02f, -2.68256254e-02f, 6.70391470e-02f, 4.94760973e-03f, -3.04987226e-02f,
  -4.64532636e-02f, 4.40225415e-02f, -7.98983425e-02f, 3.26383486e-02f, 6.06820360e-02f, -3.53190377e-02f, -1.73547585e-02f, -6.42104000e-02f, -5.38427122e-02f, 1.27880275e-01f,
  -1.49324406e-02f, -3.09102368e-02f, -1.87600066e-03f, -5.40131219e-02f, 4.58008274e-02f, 6.40788116e-03f, 8.99380632e-03f, 3.71525846e-02f, -8.19106847e-02f, -8.50037392e-03f,
  -5.42775653e-02f, 1.05919063e-01f, 7.27844005e-03f, -4.63384204e-02f, 4.13612314e-02f, -7.78996050e-02f, -1.80025138e-02f, -7.28171393e-02f, 1.13992579e-01f, -5.33640683e-02f,
  -5.71472831e-02f, -4.20065150e-02f, 4.14189249e-02f, 1.09241158e-01f, -1.66886132e-02f, 6.14786111e-02f, -1.93902794e-02f, 4.96757217e-02f, -2.25935932e-02f, -2.28865724e-02f,
  2.42470894e-02f, -1.53810792e-02f, -6.53294697e-02f, -4.14187126e-02f, -3.31521383e-04f, 7.31085567e-03f, 1.43127074e-03f, 1.32745981e-01f, 4.59699370e-02f, -7.57146720e-03f,
  -7.93437138e-02f, -1.07712232e-01f, -3.66567113e-02f, -6.15821369e-02f, -8.78289118e-02f, -2.25267187e-02f, 8.75314772e-02f, 6.50076419e-02f, 2.72420011e-02f, -4.49282713e-02f,
  -3.37258205e-02f, -3.75685804e-02f, -4.62229513e-02f, 2.21598707e-02f, -5.35470340e-03f, 2.57711411e-02f, 3.00137140e-02f, -2.03635786e-02f, -1.34127334e-01f, -5.78175038e-02f,
  -9.99024287e-02f, -5.68189286e-02f, -2.95544770e-02f, -1.70520525e-02f, -1.05876379e-01f, -8.59400481e-02f, -1.07412226e-01f, 8.51539746e-02f, 3.37873399e-02f, -2.96386462e-02f,
  -9.56654847e-02f, 1.17838793e-01f, 2.22842529e-01f, -9.61473119e-03f, -1.82064801e-01f, -7.13719800e-02f, 8.07244629e-02f, 5.17357700e-03f, 2.61332810e-01f, 3.57771665e-02f,
  -2.29978815e-01f, 8.94505084e-02f, 1.62054807e-01f, -1.22768417e-01f, -1.23209208e-01f, 2.21913010e-01f, -1.52675882e-01f, -1.89096615e-01f, 1.28148735e-01f, -2.48630464e-01f,
  -6.39063567e-02f, -2.01943532e-01f, -2.95017716e-02f, -1.51293561e-01f, -1.49490088e-01f, -4.99555580e-02f, -3.05389673e-01f, 4.17716838e-02f, -2.11716741e-01f, -7.38044828e-02f,
  -1.09426767e-01f, 1.05486950e-02f, -5.91809489e-02f, 7.28327483e-02f, -1.11766100e-01f, 1.44499727e-02f, -2.09288932e-02f, 7.98056833e-03f, -8.62861350e-02f, 2.58886237e-02f,
  7.69209117e-03f, -7.79729243e-03f, 2.26878729e-02f, 4.40715589e-02f, 5.98678067e-02f, 8.44172090e-02f, 2.63688266e-02f, -4.93833497e-02f, 2.81811412e-02f, 3.31702530e-02f,
  4.63007018e-02f, 6.96308762e-02f, 6.03635944e-02f, 5.63714430e-02f, -2.02398300e-02f, 2.66015306e-02f, 1.94695070e-02f, -3.98420915e-02f, 9.35890526e-02f, -5.22498153e-02f,
  -2.78687794e-02f, 1.87268239e-02f, -7.45316222e-02f, 5.35430983e-02f, -3.02708317e-02f, -5.29667996e-02f, 8.61977860e-02f, -3.68892774e-02f, -2.84919403e-02f, -2.13999655e-02f,
  -1.01586103e-01f, 1.02488408e-02f, 4.67656516e-02f, 2.40271701e-03f, -9.49103683e-02f, 7.15992525e-02f, -5.56244403e-02f, 1.48953814e-02f, -1.98289659e-02f, -6.45162016e-02f,
  4.38985042e-02f, -3.74490693e-02f, -1.04818694e-01f, 2.28827144e-03f, 5.81087358e-02f, 9.81610548e-03f, 1.02097094e-01f, 8.27585608e-02f, -2.64662523e-02f, -3.54675427e-02f,
  -1.51742697e-01f, -6.46900758e-02f, 7.91263022e-03f, -3.41120437e-02f, 9.97038744e-03f, -1.24083512e-01f, 8.69204998e-02f, 2.03573927e-02f, 3.53695415e-02f, -1.30485361e-02f,
  -7.51426220e-02f, -3.96931842e-02f, 2.36017592e-02f, 4.73655052e-02f, 7.90873542e-03f, 2.72874295e-05f, -7.23723024e-02f, -9.19056088e-02f, -8.63637328e-02f, -6.15049116e-02f,
  -1.49858743e-01f, -1.10803179e-01f, -3.50470170e-02f, -9.41595733e-02f, -7.73643926e-02f, -2.96229515e-02f, -4.59293537e-02f, -4.41684909e-02f, -2.07977928e-02f, -3.59412506e-02f,
  1.38118863e-01f, -2.88404346e-01f, -5.63824922e-02f, 1.03902832e-01f, 1.58064172e-01f, 4.24448252e-02f, 5.80260111e-03f, -4.34942096e-02f, -8.37937072e-02f, -9.65728462e-02f,
  -6.13780804e-02f, -1.32472456e-01f, -1.94328010e-01f, 1.09643728e-01f, -2.88320631e-01f, -1.97516397e-01f, 1.87048186e-02f, 7.68923610e-02f, -1.61559209e-02f, -1.48475453e-01f,
  -3.54191810e-02f, -9.93054360e-02f, 5.40609360e-02f, -1.55567497e-01f, 1.10572092e-01f, 2.50607617e-02f, 3.19109447e-02f, -6.17046095e-02f, 1.02542423e-01f, -2.60301493e-02f,
  -6.74471930e-02f, -1.74120560e-01f, 1.37617260e-01f, 3.59457992e-02f, -1.78912561e-02f, 5.51806055e-02f, 5.15869334e-02f, -1.43819321e-02f, 4.36844165e-03f, -1.58271529e-02f,
  -2.98097953e-02f, -6.93375571e-03f, 2.28027236e-02f, -1.79734156e-02f, 2.06416901e-02f, 1.04337744e-02f, 1.18508777e-02f, 1.50175780e-01f, -2.68295202e-02f, 3.87084410e-02f,
  4.29952107e-02f, 4.52212133e-02f, 1.18612953e-01f, 3.42799388e-02f, 1.10422775e-01f, 9.02913697e-03f, 6.25194609e-02f, 1.52429845e-02f, -1.27231227e-02f, 5.15603982e-02f,
  -3.52871575e-04f, -1.95477810e-02f, 9.25735477e-03f, 3.56581248e-02f, -1.98981557e-02f, 1.25784606e-01f, -3.84517456e-03f, 7.86612779e-02f, -1.68745853e-02f, -2.54408759e-03f,
  1.86880380e-02f, -6.19868422e-03f, -7.08439038e-04f, 7.28314146e-02f, 7.19295293e-02f, 8.43952298e-02f, -7.64583750e-03f, 6.25185519e-02f, 6.07243218e-02f, 7.18210787e-02f,
  -1.01478370e-02f, -3.03646233e-02f, 2.81292703e-02f, 9.36489627e-02f, -8.71371627e-02f, -2.04868745e-02f, 3.50221582e-02f, 4.27861474e-02f, 9.58236121e-03f, 4.64864783e-02f,
  -2.51437426e-01f, -2.57778049e-01f, -4.32405155e-03f, -1.52261034e-02f, -7.52122104e-02f, 6.17458709e-02f, -7.80543312e-02f, 1.56194204e-02f, -1.48227945e-01f, 2.05687378e-02f,
  5.27267810e-03f, 1.34412333e-01f, -6.49069771e-02f, 2.07328983e-02f, -1.00444406e-02f, -9.75733697e-02f, -2.38453541e-02f, 6.20344374e-03f, 1.69729441e-02f, -4.17029597e-02f,
  -7.95270596e-03f, -5.85841648e-02f, 4.31139544e-02f, 9.28515121e-02f, 6.62141368e-02f, 3.94112468e-02f, -8.26249719e-02f, -1.35068474e-02f, -9.84861329e-03f, -1.10595055e-01f,
  5.37070990e-01f, -3.32663767e-03f, -1.26523413e-02f, 1.83152288e-01f, 1.06897742e-01f, 1.43154770e-01f, 1.59223303e-01f, 5.60189306e-04f, 1.41726449e-01f, -6.38533905e-02f,
  3.07240244e-02f, 3.65182683e-02f, 5.90208545e-02f, -5.40471002e-02f, 2.17622280e-01f, -2.98262779e-02f, 1.20429076e-01f, 1.53770342e-01f, -2.91471444e-02f, 2.23856077e-01f,
  1.81737021e-01f, 1.36377633e-01f, 2.34196130e-02f, -5.33783287e-02f, 9.75441709e-02f, -5.31493202e-02f, 1.98820271e-02f, -2.01606397e-02f, -1.40243754e-01f, -1.23996772e-01f,
  -1.09038111e-02f, 1.12190414e-02f, -8.48944187e-02f, -1.00832947e-01f, 4.71908525e-02f, 4.54303212e-02f, -2.54777391e-02f, -9.81345400e-02f, -4.72430401e-02f, 3.98978628e-02f,
  -2.35171523e-02f, -2.57237605e-03f, 1.89206786e-02f, 6.35729954e-02f, 4.15365472e-02f, -1.89434184e-04f, 3.74959148e-02f, 5.00539578e-02f, -7.27776736e-02f, 7.07616881e-02f,
  8.41300562e-02f, -1.29674254e-02f, 7.18644932e-02f, -5.21707535e-02f, 4.29765321e-02f, -4.94383574e-02f, -2.88291331e-02f, 7.09843561e-02f, 3.22141685e-02f, -5.02061024e-02f,
  8.91624615e-02f, 7.51982880e-05f, 5.95622286e-02f, -2.68855337e-02f, 5.47127761e-02f, -3.69296707e-02f, 9.59801301e-02f, 1.54537773e-02f, -3.04327370e-03f, 5.33763245e-02f,
  8.37304164e-03f, 1.93692204e-02f, -4.98440340e-02f, 4.78080250e-02f, 3.63342166e-02f, 1.95089784e-02f, -1.76163446e-02f, -3.47746089e-02f, 1.35551002e-02f, 2.27036122e-02f,
  2.53765993e-02f, 3.03522926e-02f, -1.02777719e-01f, 4.02141251e-02f, -5.97936511e-02f, 2.94160265e-02f, -4.10402864e-02f, -3.84877920e-02f, -3.99357677e-02f, 3.77441570e-02f,
  1.42145082e-02f, -2.33597532e-02f, -6.54713735e-02f, -5.81433140e-02f, -1.44679308e-01f, 8.53918213e-03f, 6.86026663e-02f, 7.75830895e-02f, 6.18721694e-02f, 5.62275574e-02f,
  5.68022169e-02f, -2.42921170e-02f, -3.73220146e-02f, -5.79457358e-02f, -7.65610337e-02f, 3.09820361e-02f, -3.44674103e-02f, -3.79422866e-02f, 1.03197433e-03f, -1.31121157e-02f,
  1.82745815e-03f, 6.24402240e-02f, 4.04824913e-02f, 1.35439578e-02f, 3.41518112e-02f, -3.27459835e-02f, 9.66985598e-02f, -8.80860388e-02f, -4.49891947e-02f, -5.58296330e-02f,
  2.54027814e-01f, -6.33008555e-02f, -1.45768523e-01f, 3.10948551e-01f, 2.39971071e-01f, -2.91762143e-01f, -3.50727469e-01f, 2.01249987e-01f, 3.19914132e-01f, -2.63573676e-01f,
  -1.40277063e-02f, -2.32405782e-01f, -2.33492970e-01f, -4.77567390e-02f, -6.30203774e-03f, -8.87851045e-02f, 1.27473503e-01f, 8.32772851e-02f, 2.12596133e-01f, 9.11308825e-02f,
  1.65217713e-01f, 1.14668749e-01f, -6.69773370e-02f, 2.06620306e-01f, 4.92001288e-02f, 5.37362359e-02f, 1.59900025e-01f, -3.00800502e-02f, -4.97556217e-02f, -1.50786519e-01f,
  -1.06027707e-01f, 6.35784194e-02f, 6.19720761e-03f, -1.33722186e-01f, 4.81430627e-02f, -3.78695726e-02f, -1.64223909e-01f, -1.71173379e-01f, 4.78462549e-03f, 1.43450471e-02f,
  -3.19095403e-02f, -2.75052004e-02f, 3.21193859e-02f, -1.71534512e-02f, -2.26201974e-02f, -8.48524645e-02f, 4.21152711e-02f, -4.37809005e-02f, -6.54641911e-02f, 5.74208088e-02f,
  2.73209121e-02f, -4.21792530e-02f, -1.48830190e-02f, -1.03134073e-01f, 2.67965905e-02f, 9.60223228e-02f, -1.06744811e-01f, -5.33678383e-02f, -4.35476266e-02f, 6.50199726e-02f,
  -6.14458099e-02f, 5.79486750e-02f, 5.35333231e-02f, 2.94106249e-02f, 3.09927426e-02f, 1.13647386e-01f, 1.29338335e-02f, 5.55680925e-03f, 3.35498853e-03f, -5.60982488e-02f,
  3.00457738e-02f, 6.89038113e-02f, 9.22452584e-02f, 1.71267670e-02f, 1.16152167e-01f, 5.35454117e-02f, -4.42475267e-02f, 1.08342767e-02f, 7.76328743e-02f, 1.06429150e-02f,
  3.36678512e-02f, -3.73511366e-03f, -9.88829974e-03f, 1.69471670e-02f, 4.85718669e-03f, -1.33254100e-02f, -3.24873142e-02f, -2.10637301e-02f, 2.60031112e-02f, -3.70455310e-02f,
  -1.04625121e-01f, 1.03198752e-01f, -7.59604797e-02f, -5.06523699e-02f, -6.39703870e-02f, 5.05084395e-02f, 2.83345208e-02f, -2.30977479e-02f, -2.37900559e-02f, 2.84697041e-02f,
  -1.15302233e-02f, 4.75959526e-03f, -7.58507773e-02f, 3.92358042e-02f, -1.93985533e-02f, 1.84410773e-02f, -3.01333629e-02f, 7.11380616e-02f, 5.37401699e-02f, -1.71214547e-02f,
  -5.20237386e-02f, -2.61434074e-02f, 6.94407150e-02f, 5.81184216e-02f, 2.41391473e-02f, -1.24053419e-01f, 1.07829049e-01f, -1.65436100e-02f, 2.50827949e-02f, -6.60490170e-02f,
  -9.32769105e-02f, -4.10121590e-01f, 2.29435056e-01f, -2.76402924e-02f, -2.36953143e-02f, 1.84301719e-01f, -6.08454011e-02f, -1.16518773e-01f, -1.21174201e-01f, -2.92056143e-01f,
  -6.98075742e-02f, -6.58021076e-03f, -6.46230131e-02f, 6.85127974e-02f, 3.02141488e-01f, 4.65421192e-02f, 1.98076442e-02f, -4.92826030e-02f, 1.65142305e-02f, -1.07596420e-01f,
  1.29257604e-01f, -2.40891948e-02f, 2.02234164e-01f, 1.19202562e-01f, -1.85412932e-02f, 5.64645156e-02f, -1.66522637e-02f, 1.10888772e-01f, -2.58065294e-03f, 9.84732062e-02f,
  -1.39079273e-01f, -5.06113842e-02f, 2.51466571e-03f, 2.30358052e-03f, -9.70638022e-02f, -1.34303821e-02f, 1.33073842e-02f, 5.05190492e-02f, 1.00570358e-01f, -3.14266086e-02f,
  -5.03416639e-03f, -3.23917973e-03f, 1.30617633e-01f, 4.20822166e-02f, -5.45044020e-02f, -4.97838259e-02f, -1.03907930e-02f, -8.12658519e-02f, -2.65300907e-02f, 6.24915324e-02f,
  -3.53428163e-03f, 1.85336526e-02f, -6.67661130e-02f, 4.32744296e-03f, 4.87028174e-02f, 1.15546109e-02f, 3.01905852e-02f, 9.61087644e-02f, -2.52145603e-02f, -1.16455900e-02f,
  2.60024834e-02f, -4.68219537e-03f, -1.96616203e-02f, -1.63992681e-02f, -1.07236989e-01f, -1.05736461e-02f, -4.86576259e-02f, -1.59152951e-02f, -2.23834515e-02f, -3.93430591e-02f,
  -2.92610358e-02f, -7.71823227e-02f, -2.98037436e-02f, -5.42367101e-02f, -9.00596380e-02f, 7.14760087e-03f, -3.54201235e-02f, -6.53481036e-02f, -5.80557287e-02f, 4.58795344e-03f,
  1.23776030e-02f, -2.12523434e-02f, -6.21903837e-02f, -8.08571726e-02f, 6.70996085e-02f, -4.11339011e-03f, -5.38679548e-02f, -5.07891439e-02f, 2.21906118e-02f, 5.21553904e-02f,
  -2.38885745e-01f, -2.61754423e-01f, 1.16162961e-02f, -5.18019125e-02f, 6.82369620e-02f, -1.53426044e-02f, 1.02651082e-01f, 4.93600406e-02f, -2.80687194e-02f, -2.02906094e-02f,
  -7.77621716e-02f, -5.69571815e-02f, -4.47708629e-02f, -9.48544405e-03f, 4.78654094e-02f, -4.22030687e-03f, -4.60541174e-02f, 2.47356612e-02f, -1.28734717e-02f, -6.00982718e-02f,
  -5.45856282e-02f, -6.56128600e-02f, 1.43109530e-01f, -2.56417748e-02f, 4.59045656e-02f, -4.84409276e-04f, -5.64787239e-02f, 3.25712077e-02f, -5.52336164e-02f, 5.97756961e-03f,
  2.39416555e-01f, -2.81061828e-01f, 2.34729961e-01f, -1.13057189e-01f, 1.66859031e-01f, -1.05643481e-01f, -8.35474953e-02f, -7.21911341e-03f, -9.28864777e-02f, -2.81908870e-01f,
  -5.96079305e-02f, -6.03193007e-02f, -5.81812039e-02f, -3.15087438e-01f, 4.71087843e-01f, -1.23582102e-01f, -1.41918764e-01f, -6.43029809e-02f, -5.23926988e-02f, 3.10250558e-02f,
  1.55451968e-01f, -2.17472538e-01f, 1.67839438e-01f, -1.03375517e-01f, 1.09217521e-02f, 8.92434418e-02f, 5.35385869e-02f, 2.50319652e-02f, 5.53519204e-02f, -3.51050054e-03f,
  -6.05058037e-02f, -1.28981933e-01f, 2.99350005e-02f, 5.41442297e-02f, 8.77363905e-02f, 1.94290970e-02f, 4.20561340e-03f, 3.16322632e-02f, 7.53006265e-02f, 3.97123164e-03f,
  -3.90474088e-02f, 1.11482032e-02f, -1.47449765e-02f, 2.13899016e-02f, -3.44338827e-03f, 3.15354280e-02f, 2.16796938e-02f, -3.98240536e-02f, 2.05973946e-02f, -2.43461505e-02f,
  2.45332718e-02f, 2.98521714e-03f, 1.62681025e-02f, 3.80540565e-02f, 8.17418471e-02f, -6.26383275e-02f, 1.56614259e-02f, 7.48421401e-02f, -8.51000547e-02f, 2.39674803e-02f,
  -1.24282399e-02f, 2.82993019e-02f, -3.82245742e-02f, -1.63121521e-02f, 2.50291564e-02f, -3.35621648e-02f, -7.39789521e-03f, 3.96464244e-02f, 6.80390671e-02f, -6.36534300e-03f,
  3.16971936e-03f, 4.83372249e-02f, -9.07007828e-02f, 6.91207126e-02f, -3.08577586e-02f, -6.19925335e-02f, 8.21597800e-02f, 8.42256751e-03f, 2.33691223e-02f, 5.96396141e-02f,
  -3.64470966e-02f, 2.17966959e-02f, -2.37369556e-02f, -4.31878529e-02f, -8.97093788e-02f, 7.85366595e-02f, -4.39979285e-02f, 5.74063323e-02f, -1.46033373e-02f, 3.65174264e-02f,
  -5.43842576e-02f, -1.40408650e-01f, -5.20600975e-02f, -1.78136807e-02f, -3.19991373e-02f, 1.33092459e-02f, -2.85738539e-02f, -1.46194752e-02f, 2.05551181e-02f, -7.48807043e-02f,
  3.21738310e-02f, 2.27096360e-02f, -8.45400468e-02f, 3.34016606e-03f, 3.50639485e-02f, -1.09608006e-02f, -3.75996046e-02f, -2.70589832e-02f, 1.11594172e-02f, 7.16046197e-03f,
  8.91761202e-03f, 3.30813676e-02f, 9.31031629e-03f, -1.20585375e-02f, 2.41562761e-02f, -1.53918806e-02f, -2.79141706e-03f, -7.11012259e-03f, -1.80742182e-02f, -1.87719185e-02f,
  -4.28578764e-01f, 1.58729732e-01f, 6.96517453e-02f, 4.22649533e-02f, -2.42893994e-01f, -3.05646986e-01f, -1.16399035e-01f, -2.21761420e-01f, -1.22758903e-01f, 1.47707298e-01f,
  -1.09522656e-01f, 1.40612260e-01f, -1.85099840e-02f, -1.39861897e-01f, -3.27079445e-01f, 5.22696599e-02f, -1.01565063e-01f, 3.75203714e-02f, -5.71591258e-02f, -9.23525095e-02f,
  -7.83794075e-02f, -2.64369637e-01f, -3.83407436e-02f, -9.95013118e-03f, -4.76029925e-02f, 2.30694294e-01f, 1.15480885e-01f, 5.08500412e-02f, 8.49055126e-02f, 1.42562790e-02f,
  -9.00371745e-02f, 5.73887303e-02f, -6.20908616e-03f, 3.54778245e-02f, -9.07974765e-02f, 2.70358920e-02f, 4.01911438e-02f, 4.59718145e-02f, -2.05204822e-03f, -1.72747988e-02f,
  7.41946250e-02f, -1.08181879e-01f, -2.08316781e-02f, -1.80526339e-02f, -7.02159628e-02f, -1.48100662e-03f, -8.25235099e-02f, -1.82436854e-02f, -2.20077373e-02f, -1.76064037e-02f,
  2.85183862e-02f, 1.12663498e-02f, -4.61512664e-03f, 1.39791295e-01f, -1.28019881e-02f, -3.80608952e-04f, 3.91496494e-02f, 2.85919923e-02f, 5.18225394e-02f, -1.16978260e-02f,
  3.27395722e-02f, -6.07487233e-03f, -2.31936481e-02f, -6.54087365e-02f, -4.81279604e-02f, -6.25834912e-02f, 6.09984323e-02f, -1.16460084e-03f, 7.76937827e-02f, 2.03244359e-04f,
  -2.83294357e-02f, -2.68689767e-02f, -1.01339165e-02f, -3.26843150e-02f, -3.31327282e-02f, -2.15669107e-02f, 8.25385153e-02f, 4.88787033e-02f, 9.17024314e-02f, -2.41739601e-02f,
  -4.02109995e-02f, 3.10902502e-02f, 4.91048256e-03f, 5.29165603e-02f, -7.50731379e-02f, -7.34483004e-02f, 5.41288368e-02f, 1.27890166e-02f, 2.91015841e-02f, -2.75649428e-02f,
  8.00620392e-02f, 1.08092748e-01f, 2.47782632e-03f, -2.29922235e-02f, 8.76086652e-02f, 5.27280197e-02f, -3.47790383e-02f, 2.91577056e-02f, 5.42750731e-02f, -1.06764846e-02f,
  -2.58270907e-03f, 6.18132614e-02f, 5.20842113e-02f, 3.28771509e-02f, 7.45532801e-03f, 1.99847575e-02f, 7.35654980e-02f, 9.12217125e-02f, 5.02206013e-02f, 1.51801957e-02f,
  2.82532219e-02f, -3.57394665e-02f, -2.86695100e-02f, -1.18621163e-01f, -3.07038501e-02f, 3.81530710e-02f, 1.83624532e-02f, -2.08126772e-02f, -2.84228269e-02f, 1.01540841e-01f,
  -1.87401012e-01f, 4.84961092e-01f, 1.26896814e-01f, 2.17706248e-01f, -3.67045969e-01f, 1.13967862e-02f, -4.61609885e-02f, 1.13904983e-01f, 1.25123739e-01f, 2.81262189e-01f,
  -1.01544157e-01f, 3.19588304e-01f, 6.72284365e-02f, 3.02376151e-01f, -3.00160766e-01f, 9.69998986e-02f, 1.29961923e-01f, 1.66535199e-01f, -6.06742082e-03f, 1.29804313e-01f,
  -8.28195363e-02f, -2.85013765e-02f, -2.24498399e-02f, -6.26649410e-02f, -6.10886700e-02f, 3.04186549e-02f, -2.59164691e-01f, -1.15895167e-01f, 1.27055213e-01f, -3.56376474e-03f,
  -2.52192989e-02f, 7.50166103e-02f, 2.67049260e-02f, 2.21352354e-02f, -7.66641228e-03f, -1.25879869e-01f, 7.37670809e-03f, -5.63833565e-02f, -2.81036366e-02f, 4.46204729e-02f,
  2.10442077e-02f, 1.09834531e-02f, 5.05575873e-02f, -4.94091474e-02f, -3.32998740e-03f, -9.79652256e-03f, 5.09208329e-02f, -8.39849636e-02f, 8.92511830e-02f, 3.22950520e-02f,
  1.25418473e-02f, -2.81417137e-03f, -5.42075820e-02f, 9.44623649e-02f, -3.82892974e-02f, -2.21851631e-03f, -1.06445113e-02f, -2.79963724e-02f, 1.94611885e-02f, 5.20619191e-02f,
  -5.23367897e-02f, -5.45331463e-02f, -1.76480785e-02f, -2.50305142e-02f, 1.36177465e-02f, -6.19661137e-02f, -4.49845828e-02f, 5.92997856e-03f, -1.39159127e-03f, -4.51955535e-02f,
  -1.45566547e-02f, 4.86740321e-02f, -3.22301276e-02f, -1.58956414e-03f, 6.87424850e-04f, 1.34581625e-02f, -9.81834531e-02f, -8.43598228e-03f, -1.16420630e-02f, -2.41763536e-02f,
  3.75587773e-03f, 6.31756335e-03f, 9.35703702e-03f, -6.12600520e-02f, -4.31933589e-02f, 4.65112627e-02f, 3.71233001e-02f, 2.61703059e-02f, -2.14100070e-02f, -2.42350046e-02f,
  1.00424021e-01f, 2.18947813e-01f, 9.21633095e-03f, 4.25350592e-02f, 9.51713100e-02f, 1.94605980e-02f, -3.88780311e-02f, 1.37085216e-02f, 6.64639473e-02f, -1.51118888e-02f,
  -3.72528546e-02f, -9.89848282e-03f, -5.83691150e-02f, 1.98383238e-02f, 2.84779295e-02f, -4.02330868e-02f, 7.21464446e-03f, 3.40870470e-02f, -9.01241153e-02f, 8.76959786e-03f,
  -5.20565584e-02f, -7.71684796e-02f, -2.91199610e-02f, 4.47725616e-02f, 7.60338036e-03f, -1.87365245e-02f, -1.69884169e-03f, 6.75510541e-02f, -7.79177472e-02f, 6.75550802e-03f,
  -3.61597985e-01f, 1.18794397e-01f, -1.19134456e-01f, 7.31922165e-02f, -2.59451300e-01f, -3.17507386e-01f, 1.38988256e-01f, -7.16674775e-02f, 1.53319165e-01f, 1.76390275e-01f,
  2.01762794e-03f, 8.72380659e-02f, 1.62732705e-01f, 4.03956510e-02f, -4.84080538e-02f, 1.82706192e-01f, -1.95297465e-01f, 6.21183030e-02f, -1.83774857e-03f, -3.18319090e-02f,
  -9.72340070e-03f, 2.92955781e-04f, -4.38610204e-02f, -2.83778403e-02f, -5.69216795e-02f, -8.41038972e-02f, 1.80638209e-02f, 5.00839837e-02f, -1.27855793e-01f, 1.74581315e-02f,
  3.92827503e-02f, 7.62168169e-02f, 2.93320045e-02f, 2.22811196e-02f, -2.32455060e-02f, 4.56877798e-03f, -5.01632765e-02f, -1.45993885e-02f, 3.96218896e-03f, 8.47243592e-02f,
  -1.18864374e-02f, -3.75991799e-02f, 4.63304482e-02f, -3.24974656e-02f, -1.57402549e-02f, -3.64603810e-02f, -1.50556667e-02f, -7.27077127e-02f, 6.39117062e-02f, 1.98823726e-03f,
  -2.57253950e-03f, -6.63625151e-02f, -1.07770704e-01f, 1.96622107e-02f, -8.08321405e-03f, -4.38684225e-03f, 2.81206053e-02f, 1.78706180e-02f, -1.08416555e-02f, -6.02108277e-02f,
  1.05487583e-02f, -3.58879156e-02f, 4.06004749e-02f, -1.28071262e-02f, 2.76564490e-02f, 2.70593446e-02f, -5.27172573e-02f, 6.22617565e-02f, 3.52186384e-03f, -1.09797958e-02f,
  -3.89635935e-02f, 1.71565823e-02f, 4.59032692e-02f, 1.06980912e-02f, -1.64045598e-02f, 5.36769032e-02f, -2.37905979e-02f, 1.04721282e-02f, 3.98561358e-03f, -8.31085816e-02f,
  1.21556528e-01f, -1.08781476e-02f, 6.40837103e-02f, -1.45225339e-02f, 1.79707110e-02f, -1.27658471e-02f, -1.97432209e-02f, 1.65000036e-02f, 1.65824480e-02f, -3.32792476e-02f,
  2.05759462e-02f, 6.17115237e-02f, 1.93852354e-02f, -2.49472465e-02f, 2.65793931e-02f, -1.13490626e-01f, 4.84171808e-02f, -3.74423638e-02f, 6.55897707e-02f, -6.41761422e-02f,
  -6.52198792e-02f, 4.93950732e-02f, -6.25310093e-02f, 1.94453243e-02f, 2.15259919e-04f, 6.14968464e-02f, 9.57807973e-02f, 1.62196923e-02f, -4.14977707e-02f, -3.79230008e-02f,
  2.06744648e-03f, -1.37051484e-02f, 5.98463602e-02f, -2.90028844e-02f, -1.82171930e-02f, -3.55112646e-03f, -6.03671558e-02f, -2.67994404e-02f, -9.13507342e-02f, 5.64669967e-02f,
  3.58860344e-01f, -4.24492121e-01f, 1.89161062e-01f, 1.50530174e-01f, 1.84330359e-01f, -1.17118604e-01f, 2.31831536e-01f, -8.27549323e-02f, -5.27222827e-03f, -2.35979646e-01f,
  9.63350758e-02f, 2.06556991e-01f, 5.74100874e-02f, -3.38887088e-02f, 1.94993183e-01f, -2.28209361e-01f, -4.70108576e-02f, 2.38086469e-02f, -3.73997204e-02f, 1.43306032e-01f,
  7.34538659e-02f, -7.02248365e-02f, 4.52045053e-02f, -1.42720327e-01f, 2.34377742e-01f, -2.96935029e-02f, 6.90768659e-02f, -1.83171574e-02f, -9.94060859e-02f, -4.28881347e-02f,
  -9.36205164e-02f, 1.08479924e-01f, 1.71623453e-01f, 3.58508080e-02f, 7.95314386e-02f, 1.14093073e-01f, -2.10267790e-02f, -3.88614903e-03f, 9.97953713e-02f, -1.05134910e-02f,
  5.61111569e-02f, 3.21089965e-03f, -2.04457319e-04f, -2.35652756e-02f, -4.29928675e-02f, -4.17271303e-03f, -4.45041955e-02f, -5.35668842e-02f, 4.15757969e-02f, 2.57168468e-02f,
  -6.00362085e-02f, -9.85487700e-02f, -9.14656743e-03f, -3.88783664e-02f, 4.11645807e-02f, 5.59715033e-02f, 1.65865812e-02f, 3.69579606e-02f, -9.83876660e-02f, -3.72135825e-02f,
  4.56075370e-03f, -2.24393960e-02f, -3.36469896e-02f, -3.40678506e-02f, -7.08848536e-02f, 7.30445608e-04f, -1.06921420e-01f, 3.08421571e-02f, -1.29678696e-02f, -3.60010490e-02f,
  5.81608750e-02f, 6.91933110e-02f, -5.17745987e-02f, -5.86013757e-02f, -3.47567759e-02f, 3.72459255e-02f, 6.55619204e-02f, 1.76289435e-02f, -8.88490677e-03f, -2.46851463e-02f,
  5.48067316e-02f, -9.50421486e-03f, 9.64632165e-03f, 9.76886973e-03f, -1.86875425e-02f, 8.05334821e-02f, 3.63280531e-03f, -1.21546001e-03f, 1.40144648e-02f, -2.96255387e-03f,
  -1.87586412e-01f, -2.38350794e-01f, -6.81914110e-03f, 1.35065371e-03f, -9.31448713e-02f, -2.73657031e-02f, -1.21932030e-02f, -3.23179588e-02f, -9.28429961e-02f, -8.45308080e-02f,
  1.03344396e-02f, 9.33316052e-02f, -1.44190891e-02f, 8.45987257e-03f, 8.72875913e-04f, 1.09337233e-02f, -4.57077846e-03f, 1.45856328e-02f, 4.16706502e-02f, -1.02650635e-01f,
  8.42869002e-03f, -2.15959130e-03f, -5.19013330e-02f, -3.19992192e-02f, -2.03850158e-02f, 7.02521857e-03f, -2.18494944e-02f, -9.04363245e-02f, -4.09223810e-02f, -1.01202615e-02f,
  3.11115593e-01f, -6.63482547e-02f, -6.91002458e-02f, 1.15084119e-01f, 1.73040554e-01f, 4.02296148e-02f, -1.43682823e-01f, -1.15451619e-01f, 2.75931451e-02f, -4.55150604e-02f,
  -2.09819019e-01f, 2.28538543e-01f, -2.24669099e-01f, -5.35934232e-02f, 2.57128030e-01f, -2.74768889e-01f, 1.92497402e-01f, 3.55019160e-02f, -2.90473625e-02f, 8.56362805e-02f,
  6.94641471e-02f, -1.55588277e-02f, -7.22952858e-02f, -1.51419193e-01f, 9.54722315e-02f, 5.23174591e-02f, 1.46403864e-01f, -3.41888741e-02f, 2.08611026e-01f, 1.09893235e-03f,
  -1.30525023e-01f, -6.75162449e-02f, -3.71041261e-02f, 2.45909691e-02f, 3.40422355e-02f, 1.08899795e-01f, 5.76651134e-02f, -5.44996299e-02f, -9.93336365e-03f, 2.92374697e-02f,
  4.38143723e-02f, 3.55022475e-02f, 4.46197353e-02f, -6.87414333e-02f, 9.99099389e-02f, -2.97717489e-02f, -3.13548148e-02f, -4.07589637e-02f, -4.47773980e-03f, 3.58704180e-02f,
  -1.43044004e-02f, 3.06093115e-02f, 5.68745658e-02f, 8.35374296e-02f, 1.04278207e-01f, -1.16639763e-01f, 8.94463509e-02f, 7.28359967e-02f, 1.02080308e-01f, 7.12878108e-02f,
  5.94228320e-03f, 2.72095576e-02f, -5.40021695e-02f, -8.22602808e-02f, -6.36028871e-02f, -3.12632397e-02f, -2.95176636e-02f, -4.54247668e-02f, 4.56941165e-02f, -1.64602026e-02f,
  -2.32126676e-02f, 2.14224914e-03f, 7.12792808e-03f, 2.48722378e-02f, -7.40103249e-04f, 1.46545069e-02f, 1.42587221e-03f, -1.16533563e-02f, 9.18673798e-02f, -8.48706067e-02f,
  -4.38675806e-02f, 3.11112516e-02f, -7.22699910e-02f, -1.99575908e-02f, -7.93474391e-02f, -3.97425257e-02f, -6.05708454e-03f, -1.49286306e-02f, -5.50366938e-03f, 7.53873661e-02f,
  8.49857181e-02f, 2.93290943e-01f, -7.90885091e-02f, -3.98373641e-02f, -2.56485660e-02f, -1.55965900e-02f, 1.15305809e-02f, -1.13775330e-02f, 5.95914014e-02f, -1.97569169e-02f,
  1.07173167e-01f, -2.62013227e-02f, 9.21760872e-02f, 6.53335750e-02f, -5.48197217e-02f, 4.82018813e-02f, 4.61670086e-02f, 6.67891651e-02f, 1.42909065e-01f, 3.73160020e-02f,
  7.63510540e-02f, 1.67700201e-02f, -1.34774428e-02f, -2.32969727e-02f, 4.18758951e-02f, 1.06889673e-01f, 1.37722343e-01f, 1.87433027e-02f, 9.54735726e-02f, -8.24929774e-03f,
  -2.81560719e-01f, -1.08323902e-01f, -1.79315001e-01f, -3.34422976e-01f, -6.36023469e-03f, 8.92786384e-02f, 1.67865530e-01f, -2.46498644e-01f, -6.54638410e-02f, 1.27386674e-01f,
  -5.54896817e-02f, -2.32971851e-02f, 1.26472712e-01f, -2.79588640e-01f, -3.10369939e-01f, 9.81172249e-02f, -1.43958151e-01f, 5.24065085e-02f, -4.01090942e-02f, -2.13114113e-01f,
  -1.00801818e-01f, -6.88356459e-02f, -1.58623055e-01f, -4.76114117e-02f, -1.76301479e-01f, -3.98241989e-02f, 1.21580884e-01f, 6.80125430e-02f, -1.39219522e-01f, -7.34432717e-04f,
  -1.12031601e-01f, -3.87178920e-02f, -3.65293026e-02f, -5.66543899e-02f, -1.94001812e-02f, 5.83317839e-02f, 2.78838258e-02f, 1.10480329e-02f, 9.48503055e-03f, -4.07114439e-02f,
  2.12101769e-02f, -3.19840945e-02f, 1.90027698e-03f, 2.77584475e-02f, -3.77512462e-02f, -6.50697798e-02f, -1.01266488e-01f, -8.79295543e-02f, -6.56272098e-03f, -6.32825121e-02f,
  -6.25859424e-02f, -4.42101099e-02f, -1.89832151e-02f, 2.45769713e-02f, 6.11247346e-02f, 3.13931182e-02f, 6.81310818e-02f, 6.63584471e-02f, -3.71754058e-02f, -2.75082439e-02f,
  4.27785814e-02f, 4.81162183e-02f, -2.97221262e-02f, -9.18808579e-03f, -2.13719979e-02f, 3.71083878e-02f, 2.31657792e-02f, 2.27877144e-02f, 3.40464748e-02f, -6.14063554e-02f,
  -1.93579663e-02f, -3.88585450e-03f, -2.34337486e-02f, 3.49735022e-02f, 4.44431864e-02f, 2.13220567e-02f, 1.79524161e-02f, 2.44216546e-02f, -5.88884354e-02f, -3.48858498e-02f,
  1.42059242e-02f, -5.82006238e-02f, 2.56904773e-02f, 2.37747338e-02f, -2.91566979e-02f, 1.56338364e-02f, -9.80086625e-02f, -3.70681696e-02f, -1.89301372e-03f, 6.85792044e-03f,
  3.45262028e-02f, 5.16813248e-04f, -1.83352213e-02f, -4.25070431e-03f, 4.87936549e-02f, -2.20003389e-02f, 4.48224787e-03f, -4.29745764e-02f, -1.09373229e-02f, 6.11211434e-02f,
  -1.53026339e-02f, -8.10874335e-05f, 5.11742830e-02f, 2.05884185e-02f, -9.70327388e-03f, 3.00656110e-02f, 7.90268555e-02f, 8.23388398e-02f, 4.59739901e-02f, -8.84884745e-02f,
  1.45048713e-02f, 4.14693840e-02f, 9.94590297e-03f, -7.15139043e-03f, 5.01280576e-02f, -2.49755494e-02f, 1.00514358e-02f, -3.88769172e-02f, 4.03396599e-02f, -2.94492394e-02f,
  1.48959622e-01f, 1.01370052e-01f, -1.76433384e-01f, 7.11947009e-02f, 5.55460602e-02f, 3.51654589e-01f, 1.65541530e-01f, 5.45978919e-02f, -8.27873051e-02f, 1.30540654e-01f,
  1.98316336e-01f, -3.52824420e-01f, 7.56250098e-02f, 1.87300846e-01f, 1.65528581e-01f, 1.47940405e-02f, 3.05679083e-01f, 7.73398280e-02f, -7.65220970e-02f, 1.54060692e-01f,
  1.14270281e-02f, 1.98283255e-01f, 4.91152294e-02f, 9.48231593e-02f, 4.44993936e-02f, -7.91009068e-02f, 4.67892587e-02f, 1.37207052e-03f, 1.01962432e-01f, -1.05286315e-01f,
  1.63099006e-01f, -5.17414846e-02f, -1.11840598e-01f, -5.53055815e-02f, 1.74665153e-01f, -1.79257542e-02f, -1.51311979e-02f, -1.07744381e-01f, -1.92770455e-03f, -2.47321166e-02f,
  1.35125499e-02f, 3.19083333e-02f, -5.81488237e-02f, -6.78337887e-02f, -1.28006181e-02f, -9.77010056e-02f, -3.81317176e-02f, 8.95030517e-03f, 4.76570502e-02f, -6.57134354e-02f,
  -6.47203401e-02f, 2.16029072e-03f, 7.08132759e-02f, 6.34978153e-03f, -6.93137497e-02f, -1.31989131e-02f, -8.33715498e-02f, -3.72305363e-02f, 2.28324626e-02f, 3.29209194e-02f,
  -5.00723831e-02f, 1.65490899e-02f, -2.52232924e-02f, 9.65255201e-02f, 1.86453275e-02f, 1.39749357e-02f, 3.94509844e-02f, 4.99703251e-02f, -3.76681164e-02f, 7.52262026e-02f,
  9.54620838e-02f, -5.93955256e-03f, 4.77612875e-02f, -2.90740058e-02f, 1.27274096e-02f, 2.89783925e-02f, 4.41765152e-02f, 3.44695076e-02f, 8.73508677e-02f, -1.59247103e-03f,
  -2.14533452e-02f, 4.04344453e-03f, 4.47848029e-02f, 3.77883874e-02f, 1.88813005e-02f, -3.50903459e-02f, 3.76770459e-02f, 2.31718812e-02f, 1.99688738e-03f, 3.64086293e-02f,
  3.44152182e-01f, 7.27389380e-02f, 2.17264108e-02f, -2.11471915e-02f, 2.73998920e-02f, 3.37680429e-02f, 3.73284854e-02f, 1.09694889e-02f, 4.09079269e-02f, 2.93823071e-02f,
  4.69985567e-02f, -4.05767523e-02f, 7.06441551e-02f, 6.09583687e-03f, 5.53150438e-02f, 8.49709734e-02f, -5.86944493e-03f, 5.29372469e-02f, 3.39254439e-02f, 5.15252016e-02f,
  1.23067148e-01f, -3.43282335e-02f, -9.97918174e-02f, -1.71439722e-02f, -3.76616791e-02f, 5.17350771e-02f, 2.24599848e-03f, -3.05537172e-02f, -5.41711897e-02f, 2.13965103e-02f,
  4.74400520e-02f, -7.21504912e-02f, -5.04047088e-02f, -1.86745033e-01f, -2.32236326e-01f, 2.34290943e-01f, 3.23013663e-01f, -2.72098690e-01f, -5.72145730e-03f, 5.64142987e-02f,
  1.06059253e-01f, -8.25586915e-02f, 1.79339409e-01f, 1.89762935e-01f, 2.53497005e-01f, 2.98339158e-01f, 1.90535977e-01f, 1.43681586e-01f, 1.04324557e-02f, -1.69857651e-01f,
  -6.48461431e-02f, -5.16691320e-02f, 9.32877660e-02f, -3.19441199e-01f, -6.63053542e-02f, -1.77868202e-01f, -1.29533410e-01f, -1.44621775e-01f, -1.20013908e-01f, 4.36090268e-02f,
  2.75866389e-02f, -7.20440447e-02f, 2.14653392e-03f, -9.71228816e-03f, -6.85014874e-02f, 8.08932036e-02f, -1.74408145e-02f, 4.44482528e-02f, -1.47108920e-02f, -1.26334773e-02f,
  3.42604406e-02f, -3.18712145e-02f, 7.42880721e-03f, -3.34211849e-02f, -7.19831213e-02f, -7.02485666e-02f, 7.93113187e-02f, 5.90165183e-02f, -4.07966785e-02f, 9.12365541e-02f,
  3.07653118e-02f, 4.17263322e-02f, 5.48364632e-02f, -1.96618177e-02f, -4.59986515e-02f, -2.27693357e-02f, 1.99524742e-02f, -5.18350899e-02f, 4.64023277e-02f, -4.23030443e-02f,
  -2.49228198e-02f, -4.95913774e-02f, 7.82512128e-02f, -1.14534772e-03f, 2.04432346e-02f, -1.39815677e-02f, 5.77903986e-02f, 2.70349402e-02f, -2.20241919e-02f, -3.07511743e-02f,
  -1.55782076e-02f, -3.05341259e-02f, -4.72167209e-02f, -3.96391749e-02f, 4.03637998e-02f, -7.62844272e-03f, 1.71921253e-02f, -5.50120249e-02f, -1.43277869e-02f, 2.26345323e-02f,
  -5.52825220e-02f, 2.98490785e-02f, -3.66652086e-02f, 1.57466363e-02f, 3.28545235e-02f, 4.51499177e-03f, 2.76853815e-02f, -5.48769496e-02f, 3.93362828e-02f, -4.68719658e-03f,
  -7.00022802e-02f, -1.78256303e-01f, -2.10141689e-02f, -6.47037700e-02f, 4.67975512e-02f, 6.57789037e-02f, 4.29038368e-02f, 3.06078847e-02f, -3.90171558e-02f, 1.33209745e-03f,
  -8.17464367e-02f, -1.42533947e-02f, -1.66925669e-01f, 2.64292583e-02f, -2.74812058e-02f, 6.43681139e-02f, -5.95685979e-03f, 5.17998124e-03f, -1.74755722e-01f, -8.47214609e-02f,
  -7.00901523e-02f, -4.40420099e-02f, -1.05719054e-02f, -2.53981669e-02f, 2.82874536e-02f, 1.67017449e-02f, -4.49307039e-02f, 3.29284295e-02f, -2.19915751e-02f, -3.73543575e-02f,
  1.87978536e-01f, -9.57385674e-02f, 2.69544482e-01f, -2.58758187e-01f, 2.10311338e-01f, -1.08777575e-01f, -9.58733559e-02f, -2.97556762e-02f, 7.15916008e-02f, -2.15042084e-01f,
  -9.92978439e-02f, 1.77600980e-01f, 1.06198408e-01f, -3.01583439e-01f, 7.93673936e-03f, -5.54412864e-02f, -4.08025920e-01f, -1.12198383e-01f, 2.02469304e-01f, -9.47244987e-02f,
  2.09876224e-02f, -2.29088411e-01f, 2.90929209e-02f, -2.26974636e-02f, 9.89652821e-04f, 7.70444199e-02f, -2.81804889e-01f, 1.85167938e-01f, -2.25969121e-01f, 1.01175886e-02f,
  4.92774211e-02f, -1.39680818e-01f, 1.24944635e-01f, -5.85143939e-02f, 6.39607683e-02f, 2.91847461e-03f, -1.53917382e-02f, 9.31841210e-02f, 2.76316982e-02f, 1.56255178e-02f,
  8.01511854e-02f, 3.24319042e-02f, 1.59848798e-02f, 1.95376226e-03f, -4.18198146e-02f, -1.32402908e-02f, 3.03103812e-02f, 6.79771230e-02f, 1.11935195e-02f, 4.54980135e-02f,
  8.90439004e-02f, -1.63718927e-04f, -8.81073698e-02f, -1.74860522e-01f, 1.30246012e-02f, -3.52664967e-03f, -8.13963413e-02f, -3.24356146e-02f, 1.03302416e-03f, -4.68873829e-02f,
  -6.96224198e-02f, -9.60554779e-02f, -5.95455579e-02f, 2.52045877e-02f, 1.87655371e-02f, 2.90566720e-02f, 3.10348850e-02f, -5.32701239e-02f, 6.45159557e-02f, -2.26402599e-02f,
  -4.42963801e-02f, 8.86866637e-03f, 2.58488804e-02f, -5.40979467e-02f, 1.28900874e-02f, -6.28955886e-02f, 9.03005013e-04f, -1.55916428e-02f, -7.28619809e-04f, 1.98325347e-02f,
  -4.26884517e-02f, -1.78098977e-02f, 6.73499852e-02f, 2.93399487e-03f, -1.54545589e-03f, 6.12894781e-02f, -4.02784646e-02f, -5.99992983e-02f, 2.11810780e-04f, 4.99706008e-02f,
  -1.20804355e-01f, -3.73020411e-01f, 1.35153104e-02f, 2.44422685e-02f, -5.69572598e-02f, -7.41185918e-02f, -1.37737453e-01f, -3.60071436e-02f, -4.16753814e-02f, -6.24035150e-02f,
  -1.93898622e-02f, -6.86078891e-02f, -9.29760654e-03f, -2.11041346e-02f, 2.59650126e-02f, 9.38380510e-03f, -4.62782234e-02f, -6.19040504e-02f, -1.06581710e-01f, -7.62383267e-02f,
  4.29310203e-02f, -1.75090358e-02f, -9.94060747e-03f, 5.14561078e-04f, -1.10668249e-01f, -6.43656477e-02f, -1.95604339e-02f, 6.66132104e-03f, 1.53146172e-02f, -4.73597180e-03f,
  -3.89304250e-01f, 3.27724814e-01f, 1.92204993e-02f, 1.69232175e-01f, -1.53663144e-01f, -2.18094453e-01f, -2.40818664e-01f, 1.52485117e-01f, -1.03244245e-01f, 2.99136490e-01f,
  9.37889963e-02f, 4.90377955e-02f, 9.16365683e-02f, 2.46904656e-01f, -4.38249916e-01f, -1.05974846e-01f, -2.18168809e-03f, 2.62425262e-02f, 1.36422925e-02f, 1.59587011e-01f,
  -7.21792579e-02f, 7.30655342e-02f, -9.76439379e-03f, 1.33501709e-01f, 5.14481105e-02f, 7.00217783e-02f, 1.19769521e-01f, -2.83292495e-02f, 1.83785722e-01f, 8.50870181e-03f,
  -3.06035262e-02f, 1.08482480e-01f, 3.56156342e-02f, 2.19855905e-02f, -5.85131533e-02f, 4.16338928e-02f, -3.98289077e-02f, -2.63930596e-02f, -7.28899166e-02f, 1.91381294e-03f,
  -2.39894111e-02f, 2.13534534e-02f, 1.05428882e-02f, 3.34850885e-03f, 3.00226938e-02f, 9.14448872e-03f, 2.03335267e-02f, -9.45197046e-03f, 8.77996534e-02f, -1.19383754e-02f,
  -1.74014065e-02f, 3.16616297e-02f, 5.26783243e-02f, -1.93093289e-02f, 2.44421866e-02f, 1.09298415e-02f, -1.65900849e-02f, -2.82644648e-02f, -4.04967219e-02f, -4.28961068e-02f,
  3.61682251e-02f, -8.01772773e-02f, -5.02462760e-02f, 3.75979505e-02f, 1.51953297e-02f, 2.66936161e-02f, 1.59412771e-02f, 2.28383802e-02f, -3.35098952e-02f, -9.69033875e-03f,
  1.76758319e-02f, 3.48630138e-02f, -8.32046289e-03f, -2.30234023e-02f, 1.73288584e-02f, 5.78083657e-02f, -6.39645383e-02f, 9.39201191e-02f, -1.91900991e-02f, -7.25504477e-03f,
  6.38388917e-02f, 2.94178282e-03f, 2.69143265e-02f, -4.86913091e-03f, -5.45157827e-02f, -5.47668450e-02f, 4.72340621e-02f, 1.23658413e-02f, 1.19277239e-02f, -1.59642734e-02f,
  1.20890349e-01f, 4.05501649e-02f, 6.47807419e-02f, -7.87530560e-03f, 2.83866823e-02f, -2.84399162e-03f, -4.49283309e-02f, -7.09480373e-04f, 6.66733691e-03f, 2.60936823e-02f,
  3.59401256e-02f, 2.95309559e-03f, -5.28609119e-02f, -4.14693356e-02f, 2.23583598e-02f, -3.27742361e-02f, -4.74589225e-03f, -2.54897098e-03f, -5.55044897e-02f, 6.16556779e-02f,
  4.54059541e-02f, -4.27803732e-02f, -3.17178890e-02f, 5.86207211e-02f, -6.02008263e-03f, -3.44551802e-02f, -3.54629457e-02f, -8.64511915e-03f, 2.88381949e-02f, -8.53901263e-03f,
  3.50293010e-01f, -9.99557003e-02f, 2.14748994e-01f, 3.18098307e-01f, -1.09037980e-01f, -1.55001823e-02f, 3.49532783e-01f, -1.85222909e-01f, 1.64432496e-01f, -1.08918615e-01f,
  -1.94178164e-01f, 3.23743820e-01f, -9.81660560e-02f, -1.48825198e-01f, 1.48617178e-01f, 6.62531331e-02f, 9.81471464e-02f, 7.39174634e-02f, -6.66908398e-02f, -1.57959297e-01f,
  3.23236696e-02f, -2.63149738e-01f, 1.68993220e-01f, -2.64714837e-01f, -2.44640876e-02f, 3.23819779e-02f, -1.09009385e-01f, 8.57396750e-04f, -3.65856551e-02f, -9.00496356e-03f,
  -1.22611873e-01f, 9.79094431e-02f, 9.37376618e-02f, -7.37547502e-03f, -4.68205586e-02f, 4.20158803e-02f, 7.48950168e-02f, 7.67128170e-02f, -1.54427681e-02f, 6.25690818e-03f,
  3.97509038e-02f, -3.13407346e-03f, 1.92683712e-02f, 3.23824002e-03f, -3.99189480e-02f, 5.74883111e-02f, 3.47856693e-02f, 2.17488315e-03f, 7.39867315e-02f, 3.01012839e-03f,
  2.53088940e-02f, 1.70620494e-02f, 1.32281473e-02f, 1.86162349e-02f, 9.79725122e-02f, 1.40118664e-02f, 1.41830742e-01f, 7.13278800e-02f, 5.84125258e-02f, -1.73159614e-02f,
  8.49019736e-02f, 1.42351938e-02f, -1.81934908e-02f, 1.12427240e-02f, 2.05975194e-02f, -7.24882632e-02f, -3.27598527e-02f, -7.19151348e-02f, 3.84603143e-02f, 2.34100074e-02f,
  -2.79508308e-02f, 1.36319380e-02f, -3.63241397e-02f, 5.64741576e-03f, -3.85762565e-02f, -1.06502324e-02f, 4.66258116e-02f, -4.31201905e-02f, 4.99363942e-03f, -3.18703651e-02f,
  -1.21200625e-02f, -6.80117160e-02f, -2.98708118e-02f, 3.58029716e-02f, -2.08997540e-02f, -2.52517667e-02f, -9.78264660e-02f, 2.48348881e-02f, -1.79109592e-02f, 4.17579971e-02f,
  -3.08954746e-01f, -2.36027211e-01f, 3.85722443e-02f, -4.66546118e-02f, -2.82450300e-03f, -9.56875607e-02f, 9.05141532e-02f, 1.38606653e-02f, 9.63123457e-04f, -7.26953298e-02f,
  -4.58351485e-02f, -3.34318541e-02f, 2.32842639e-02f, -1.93296187e-02f, 4.08379063e-02f, -1.10102836e-02f, -2.05407888e-02f, -7.20128193e-02f, 4.63751964e-02f, -6.09174445e-02f,
  -6.09712750e-02f, -3.39898324e-05f, 4.42144647e-03f, -2.98875421e-02f, -1.85771417e-02f, 3.36647406e-02f, 5.06788604e-02f, 1.02585733e-01f, -5.66326790e-02f, 1.04230400e-02f,
  -1.42778475e-02f, 3.96881610e-01f, -3.97016993e-03f, 2.52422690e-01f, -8.17435011e-02f, 3.07861060e-01f, 1.96771398e-01f, 1.27716079e-01f, 1.08326912e-01f, 2.13089347e-01f,
  -9.12267491e-02f, 8.71613026e-02f, -1.62723944e-01f, 4.22399282e-01f, -1.63288027e-01f, 5.74718527e-02f, 3.11250538e-01f, 1.70153528e-01f, -5.29718846e-02f, 2.29029562e-02f,
  -1.09150959e-02f, 1.57616764e-01f, 2.16069929e-02f, -2.16428693e-02f, 1.27087623e-01f, -2.69568693e-02f, -2.47962579e-01f, -1.86554536e-01f, 2.37834305e-01f, -3.58682238e-02f,
  5.87799810e-02f, 3.39998379e-02f, 7.88614079e-02f, -7.97867998e-02f, -1.39661217e-02f, -3.30748712e-03f, -1.04830191e-02f, -5.85424304e-02f, 6.90417830e-03f, 2.64643207e-02f,
  -8.15432239e-03f, -9.76454467e-03f, 6.68251663e-02f, -7.58876577e-02f, -5.81824780e-03f, 1.12403026e-02f, 1.12388367e-02f, 1.18545882e-01f, 8.11749995e-02f, -8.40858649e-03f,
  2.35640183e-02f, 9.99132767e-02f, 3.64656374e-02f, -5.85512072e-03f, -9.22503099e-02f, 3.31671908e-02f, 7.58184344e-02f, -1.78132243e-02f, 3.67475301e-02f, 4.00667377e-02f,
  -4.66603786e-02f, -2.46361624e-02f, -4.25643139e-02f, -4.84869108e-02f, -1.52277775e-04f, -3.68707031e-02f, 3.93993482e-02f, -5.40217683e-02f, -4.31986786e-02f, 4.36688624e-02f,
  -2.30576340e-02f, 1.36621948e-02f, -7.69819319e-03f, -2.27418877e-02f, 5.95606007e-02f, 4.83674705e-02f, -6.85669780e-02f, -2.91406494e-02f, 1.03224397e-01f, 4.37925905e-02f,
  -6.16230629e-03f, 1.60678441e-03f, -4.59297886e-03f, -5.38785532e-02f, 4.40909900e-02f, -7.36930743e-02f, -1.51697407e-02f, 9.04544909e-03f, 1.86420772e-02f, -5.99022210e-02f,
  1.45436242e-01f, 6.25046417e-02f, -7.01444782e-03f, 8.96987226e-03f, -9.18158889e-03f, 1.24356672e-02f, 4.50826548e-02f, 1.54580455e-02f, -7.40243541e-03f, -9.65272170e-03f,
  -1.27523169e-02f, 4.27179299e-02f, -8.43224972e-02f, 6.64279312e-02f, -4.22712825e-02f, 3.19873095e-02f, -1.19265623e-01f, -8.05522799e-02f, -7.10067600e-02f, -3.45921982e-03f,
  -1.02516934e-02f, -1.56776179e-02f, -1.02311164e-01f, 1.77277569e-02f, 3.39076412e-03f, 8.09002813e-05f, 2.10496113e-02f, -4.49985936e-02f, -7.73149505e-02f, 2.86900774e-02f,
  3.08246791e-01f, 2.20980898e-01f, 2.18772992e-01f, 2.16846958e-01f, -1.37905419e-01f, 9.02225822e-02f, 1.09790266e-01f, -8.07694159e-03f, 4.48234558e-01f, -3.63780297e-02f,
  -1.99579328e-01f, 2.38706335e-01f, 2.75311805e-02f, -2.30401993e-01f, -5.47304414e-02f, 1.05404511e-01f, -1.39413476e-02f, 5.13355248e-02f, 1.46121755e-01f, 7.35407695e-02f,
  8.89145508e-02f, -2.25151032e-01f, -6.01360239e-02f, -1.09713279e-01f, -9.00427811e-03f, 1.35628372e-01f, -2.21155897e-01f, 5.67372516e-03f, -2.78646201e-01f, -1.22825660e-01f,
  -6.71326518e-02f, 6.06342629e-02f, -1.09880619e-01f, 9.70416889e-02f, 4.94887568e-02f, -5.83868027e-02f, -1.31847784e-01f, -5.90341650e-02f, 3.43673415e-02f, 2.67697684e-02f,
  -7.10465992e-03f, -2.86059566e-02f, -1.80721115e-02f, 1.61916912e-02f, 2.36868095e-02f, -2.90598311e-02f, -1.22676976e-02f, 9.97283123e-03f, 1.52580468e-02f, 3.12634706e-02f,
  8.22556689e-02f, 1.71965417e-02f, 9.46554914e-03f, -4.13878076e-02f, 6.47736713e-02f, 2.21699048e-02f, -9.06109624e-03f, -5.20504043e-02f, -4.34510931e-02f, 1.03206925e-01f,
  2.52623651e-02f, 5.26875108e-02f, -4.44033444e-02f, -4.44842428e-02f, -2.76689157e-02f, -2.04378944e-02f, -2.77064964e-02f, -5.09179905e-02f, 2.89146565e-02f, 2.92594470e-02f,
  3.48921423e-03f, -1.02620356e-01f, -3.18428129e-02f, 8.87623653e-02f, -2.49879844e-02f, -2.31047124e-02f, -3.00485566e-02f, -3.41897272e-02f, 8.18282291e-02f, -1.62733607e-02f,
  1.12631368e-02f, -3.52890231e-02f, 3.47973146e-02f, 3.59454029e-03f, -4.17924672e-02f, 7.22689461e-03f, 3.63493524e-02f, 2.76989955e-02f, 2.33950317e-02f, 1.35423839e-02f,
  8.35363194e-02f, 1.36718139e-01f, 7.13598654e-02f, -8.88263062e-02f, 1.24883512e-02f, -5.83630018e-02f, 2.02800296e-02f, 7.59065058e-03f, 2.45430395e-02f, -3.99205238e-02f,
  1.97152584e-03f, 7.66708925e-02f, 2.59591378e-02f, -1.11037120e-01f, 1.25690727e-02f, 7.28108287e-02f, 1.69197991e-02f, 1.72078051e-02f, -7.88498949e-03f, -8.23693648e-02f,
  2.52615660e-02f, 4.50341478e-02f, 1.97878238e-02f, -4.05885801e-02f, -4.65295464e-02f, 1.88071525e-03f, 8.43608901e-02f, 8.68420154e-02f, -1.39010567e-02f, 4.88239899e-02f,
  -3.01119566e-01f, -1.80721194e-01f, -3.02722335e-01f, 1.19061522e-01f, 8.72407109e-02f, 2.94243783e-01f, 2.42911413e-01f, -5.83265573e-02f, -5.98120689e-02f, 1.90356970e-01f,
  1.84931681e-01f, 5.23954332e-02f, -4.86249961e-02f, 2.37943083e-01f, 3.83423597e-01f, 7.38568380e-02f, 1.22594982e-01f, 1.32414430e-01f, -9.89183560e-02f, -1.92253381e-01f,
  -2.11832542e-02f, 2.06628054e-01f, 1.25706762e-01f, -1.29689020e-03f, -1.28071830e-02f, -1.76685080e-01f, 1.17366835e-01f, -4.10668589e-02f, 1.47808418e-01f, 1.81468844e-01f,
  -4.59566005e-02f, -2.45338216e-01f, -2.89409291e-02f, -5.90650290e-02f, -1.36713786e-02f, -5.28931320e-02f, -3.59790288e-02f, 4.24062833e-02f, -5.24213538e-02f, 4.30366583e-02f,
  -2.90540960e-02f, 2.21588393e-03f, 6.12191558e-02f, -1.32431719e-03f, -5.51281124e-02f, -5.76935261e-02f, -3.12586725e-02f, 3.11183389e-02f, -7.04243705e-02f, 8.38290825e-02f,
  4.76832017e-02f, 6.48671687e-02f, -8.81179944e-02f, 4.02290188e-02f, -3.24200019e-02f, 5.89723364e-02f, -5.33793233e-02f, 6.54019192e-02f, 1.01973020e-01f, -3.70398611e-02f,
  7.97561407e-02f, -3.93497050e-02f, 5.60015552e-02f, 4.85034436e-02f, -1.13415811e-02f, 5.98326661e-02f, -3.00057344e-02f, 5.04573062e-02f, -8.18416253e-02f, 1.14844060e-02f,
  6.24874607e-03f, 6.17729826e-03f, 1.18929055e-02f, 1.98300704e-02f, 5.57642430e-03f, -3.07230465e-02f, -3.48078944e-02f, 6.35965355e-03f, -9.66407242e-04f, 2.10442264e-02f,
  1.63911488e-02f, -3.07553932e-02f, 3.29934731e-02f, -2.00150423e-02f, 9.89071745e-03f, -1.04244826e-02f, 1.23296203e-02f, -3.46888565e-02f, 4.18174872e-03f, -4.23622578e-02f,
  -1.07587263e-01f, -1.08658798e-01f, 5.85010462e-02f, 8.31943080e-02f, -6.97671548e-02f, 9.97044891e-02f, 1.51033653e-02f, 1.78627428e-02f, 1.34597458e-02f, -1.17179081e-02f,
  1.91530045e-02f, 1.04539627e-02f, -4.54751067e-02f, -4.50453125e-02f, -4.13372321e-03f, 2.72570793e-02f, 3.41735668e-02f, -6.04956271e-03f, 9.41171199e-02f, -9.48865265e-02f,
  -6.91668410e-03f, 1.61072165e-02f, 5.58851808e-02f, 2.65601575e-02f, 5.82066551e-02f, 4.03558239e-02f, 2.07702741e-02f, -8.07502195e-02f, 2.82910578e-02f, 1.68458577e-02f,
  -5.52979931e-02f, -9.15228110e-03f, -1.83551610e-02f, 6.58070669e-02f, 2.53315438e-02f, 2.19578266e-01f, 1.55077474e-02f, -2.04795580e-02f, 4.24928516e-01f, -2.28596330e-01f,
  1.79015383e-01f, -1.76873729e-01f, 1.97938061e-03f, 1.76599279e-01f, -8.88575390e-02f, 2.75490820e-01f, -4.07259399e-03f, 1.45047307e-01f, 1.66543871e-01f, -1.13860302e-01f,
  3.48683856e-02f, -1.50492191e-01f, -1.85033798e-01f, -3.41091931e-01f, -1.32598534e-01f, -2.72341236e-03f, -3.49026799e-01f, 1.71241164e-02f, -2.75144488e-01f, 1.04322061e-01f,
  1.65928702e-03f, 9.40159932e-02f, -2.08772570e-01f, 3.59273585e-03f, -4.59754281e-02f, 3.41545753e-02f, 2.84862276e-02f, -3.98639366e-02f, -9.92059335e-03f, -8.39771554e-02f,
  -4.19728551e-03f, -3.50858793e-02f, 8.02614987e-02f, -2.92733107e-02f, -3.18326615e-02f, -2.68965829e-02f, -4.71145436e-02f, 6.81160092e-02f, -1.36575386e-01f, -1.40132410e-02f,
  -3.56246904e-02f, 8.61543342e-02f, 9.76926908e-02f, 1.04477163e-02f, -1.31366905e-02f, -1.85618829e-02f, 9.86852404e-03f, 4.19864021e-02f, 4.06173849e-03f, -6.43821247e-03f,
  -1.97856799e-02f, 5.76039590e-02f, -2.18881276e-02f, 2.35043038e-02f, -3.09057310e-02f, 6.17581122e-02f, 2.97033302e-02f, 6.36856407e-02f, 2.19199322e-02f, -1.70619674e-02f,
  2.59682145e-02f, -3.13411020e-02f, 1.45187110e-01f, -5.58276586e-02f, -1.91169158e-02f, 5.25306463e-02f, -1.32139204e-02f, 8.22122172e-02f, 1.93886440e-02f, 2.30146907e-02f,
  1.12373918e-01f, -1.16791753e-02f, -1.23665139e-01f, 1.46144722e-02f, -4.03383689e-04f, -7.01414421e-02f, 2.22961958e-02f, 7.54463002e-02f, 1.17555305e-01f, -6.24246635e-02f,
  6.13707379e-02f, 1.50697172e-01f, -4.59969491e-02f, -6.61619455e-02f, 1.38418721e-02f, -8.41902569e-03f, -4.85855108e-03f, -3.94463912e-02f, -1.26544153e-02f, 2.29326077e-02f,
  -1.67725235e-02f, -2.34292969e-02f, 1.91690531e-02f, -2.21572518e-02f, 3.07975635e-02f, -4.21225578e-02f, 2.07644571e-02f, 6.19445890e-02f, 3.98424864e-02f, -8.59569162e-02f,
  -8.63977373e-02f, -3.10387723e-02f, -5.35704158e-02f, -8.01214203e-02f, -1.08936103e-02f, 1.21133821e-02f, -2.08128449e-02f, 5.28323278e-03f, 2.48174947e-02f, 2.60799229e-02f,
  -2.21232101e-01f, 4.05355878e-02f, -2.61873156e-01f, -3.36053967e-01f, -7.88569599e-02f, 2.85669148e-01f, 2.21256971e-01f, -1.58312827e-01f, -2.37832949e-01f, 2.99289167e-01f,
  1.36404987e-02f, 2.87936870e-02f, 1.36562884e-01f, -5.65920025e-02f, -1.23199783e-01f, 2.43310988e-01f, 4.50148620e-02f, 1.62651867e-01f, -9.22700912e-02f, 4.70552519e-02f,
  -8.13055933e-02f, 1.66034009e-02f, -1.45509809e-01f, -1.13779968e-02f, -9.98112410e-02f, -1.38310820e-01f, -1.24002546e-02f, -4.89034690e-02f, -3.69154066e-02f, -2.79534552e-02f,
  -8.23198110e-02f, -1.51259005e-01f, -8.79366100e-02f, -2.04244480e-02f, 1.32422503e-02f, 8.77403691e-02f, 1.22102074e-01f, 9.75704752e-03f, -1.66090816e-01f, 2.19194535e-02f,
  9.40161720e-02f, 1.50787819e-04f, -8.71301740e-02f, -3.68790254e-02f, -8.70928839e-02f, -1.18221074e-01f, -1.00914314e-01f, -1.16639167e-01f, -4.45748419e-02f, 8.01781937e-03f,
  -1.28838703e-01f, -1.22256562e-01f, -9.55252126e-02f, 5.97161800e-02f, -3.41767515e-03f, -6.29584268e-02f, 1.33079952e-02f, -1.90046628e-03f, 1.24813132e-02f, -2.84823831e-02f,
  1.18681870e-01f, 1.40093649e-02f, 6.33207848e-03f, -3.99969108e-02f, -3.39826867e-02f, -3.76438424e-02f, 1.14567275e-03f, 1.38940606e-02f, -4.09340626e-03f, -9.16870777e-03f,
  -1.47145148e-02f, -2.17922707e-03f, 1.09195272e-02f, -4.13731858e-02f, 1.15075884e-02f, 4.46451344e-02f, 4.45375964e-02f, 1.55843329e-04f, 2.33649705e-02f, -6.16878904e-02f,
  -5.21895848e-02f, -1.55874938e-02f, 2.07302198e-02f, 2.35585105e-02f, 3.98363546e-02f, -2.77186148e-02f, -3.53675596e-02f, -6.57448173e-02f, -5.31275347e-02f, 6.77210689e-02f,
  1.60977349e-01f, 3.26832354e-01f, 5.01907570e-03f, 4.22314443e-02f, 3.37193310e-02f, 3.26301716e-02f, -2.65051983e-02f, 1.29014952e-02f, 5.55153452e-02f, 4.55010822e-03f,
  8.42627883e-02f, -5.29402643e-02f, 1.42898053e-01f, -3.97082381e-02f, -2.80170999e-02f, 6.58083409e-02f, 1.19698614e-01f, 1.45128639e-02f, 4.46212292e-02f, -3.71406153e-02f,
  6.91088885e-02f, 1.14085011e-01f, 1.67327598e-02f, 1.57773886e-02f, 6.52916059e-02f, -2.66241818e-03f, 6.25137985e-02f, 3.83955501e-02f, 2.15189420e-02f, 5.36913387e-02f
};

// L0_fan_Wp_bar (Shape: 14 x 120)
const int L0_fan_Wp_bar_rows = 14;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  4.04563904e-01f, 3.90703052e-01f, 3.66919577e-01f, 3.56616765e-01f, -1.44894809e-01f, -3.10103297e-01f, -3.51294247e-03f, -9.13639143e-02f, 8.36739969e-03f, 4.95377257e-02f,
  -1.72902137e-01f, 4.41039890e-01f, -1.35661751e-01f, 2.02277422e-01f, -2.81582028e-01f, -1.85424954e-01f, 4.17061374e-02f, 2.47034565e-01f, -9.69699025e-02f, 1.50187060e-01f,
  8.12584832e-02f, -3.36464405e-01f, 2.30423421e-01f, -1.90215155e-01f, 1.15031563e-01f, 1.75618112e-01f, -2.12080225e-01f, -6.55211359e-02f, 2.08301172e-01f, -4.74980175e-02f,
  2.36056969e-02f, 2.46919636e-02f, 6.12784810e-02f, 1.04291067e-01f, -1.38543332e-02f, 6.17337041e-02f, 9.28927287e-02f, -5.29645756e-03f, -8.06216300e-02f, 2.10065581e-02f,
  6.55443519e-02f, -6.25220388e-02f, 8.84673223e-02f, -1.10437637e-02f, 5.11606075e-02f, 8.22152644e-02f, 6.68787062e-02f, 2.06102788e-01f, 9.31289643e-02f, 1.31476134e-01f,
  7.67057464e-02f, 1.17050968e-01f, -3.33580114e-02f, 2.92442888e-02f, 2.47549117e-02f, -2.05138996e-02f, 4.54687811e-02f, 1.24264345e-01f, 1.52268231e-01f, 4.01831185e-03f,
  -1.33825708e-02f, -9.06090066e-02f, 3.42836231e-03f, 1.09904401e-01f, -7.51513168e-02f, 6.41641347e-03f, -4.06318940e-02f, 2.14714240e-02f, -5.59664182e-02f, -6.91703334e-02f,
  -2.82149892e-02f, 1.05794273e-01f, -2.96740290e-02f, 2.49903910e-02f, -2.08321796e-03f, 7.54671246e-02f, 5.59847951e-02f, 2.94071226e-03f, 3.47723775e-02f, 8.59994162e-03f,
  -1.76104233e-02f, -8.90845284e-02f, 1.05299629e-01f, 6.41611964e-02f, -3.67272720e-02f, -6.22838698e-02f, 2.92914780e-03f, 9.07844305e-02f, -1.62795354e-02f, -1.08834691e-01f,
  -1.48462132e-02f, -8.62420872e-02f, -1.00648887e-02f, 7.52097368e-02f, 1.65430550e-02f, -2.52865087e-02f, 4.09162566e-02f, 4.62147221e-02f, -1.72024056e-01f, -1.27552986e-01f,
  4.50933017e-02f, -1.00030871e-02f, -5.52367680e-02f, -1.51514085e-02f, -2.35503614e-02f, -9.18338597e-02f, 2.39387564e-02f, -2.89035775e-02f, -4.32311855e-02f, 3.68091129e-02f,
  5.22539876e-02f, -1.14540845e-01f, 1.33658946e-02f, -3.43810879e-02f, 6.17976021e-03f, -3.37290280e-02f, -2.75485851e-02f, 1.23395082e-02f, 2.41959747e-02f, -5.25047407e-02f,
  -5.66611111e-01f, -1.27948940e-01f, 1.49098054e-01f, 1.02170274e-01f, -1.75998464e-01f, -3.02253127e-01f, -4.14635032e-01f, -1.00236952e-01f, -1.58036023e-01f, -3.40620667e-01f,
  -1.99752852e-01f, 9.16888267e-02f, -2.68789142e-01f, 2.32651025e-01f, 2.91749984e-01f, 1.24749079e-01f, 3.13677877e-01f, 1.74785644e-01f, 2.68819004e-01f, 1.97936505e-01f,
  3.41691226e-01f, 2.64352828e-01f, 4.33690131e-01f, 3.44267607e-01f, 1.09019779e-01f, 1.49702057e-01f, 3.03070128e-01f, 8.47074315e-02f, 3.17240298e-01f, 6.05739504e-02f,
  -1.74397931e-01f, -1.01896569e-01f, -3.22634466e-02f, -9.03522372e-02f, 7.48458579e-02f, -8.73712897e-02f, 8.43533874e-02f, -6.69499487e-02f, -9.03704576e-03f, -6.00196645e-02f,
  -7.93856606e-02f, 1.37689099e-01f, 7.18978569e-02f, 8.19493085e-02f, -1.34155586e-01f, 6.96976855e-02f, 4.42251191e-02f, -1.62803493e-02f, 1.67343803e-02f, -1.49421552e-02f,
  3.07624862e-02f, -4.47123870e-02f, -1.02572419e-01f, -7.80884502e-03f, 9.53854695e-02f, -2.32738182e-01f, 6.75107213e-03f, -7.44894892e-03f, 1.03783784e-02f, 1.94951762e-02f,
  1.31683275e-01f, -9.13775116e-02f, -3.24413255e-02f, 1.81224123e-02f, 7.41362348e-02f, 4.50262167e-02f, 1.47184983e-01f, 3.76660042e-02f, -3.86488251e-02f, -8.70904699e-02f,
  -7.49888495e-02f, -1.90179143e-02f, -3.04245483e-02f, -7.78397694e-02f, 5.88362813e-02f, 1.51765905e-02f, 6.42298460e-02f, -3.26147303e-02f, 1.22754900e-02f, 6.17597662e-02f,
  -3.59539054e-02f, -1.03413358e-01f, 4.38022390e-02f, 1.29518937e-02f, -3.77573781e-02f, 2.32137670e-03f, 6.36028359e-03f, -5.61262034e-02f, -3.80868278e-02f, 1.48793101e-01f,
  -2.52365291e-01f, 2.04569668e-01f, 5.34770219e-03f, -9.77236107e-02f, 1.22307509e-01f, -7.94539787e-03f, 1.88725427e-01f, 7.43114650e-02f, 3.96020664e-03f, -7.26679415e-02f,
  1.74731407e-02f, -5.55567257e-03f, -9.34508219e-02f, -3.90112102e-02f, 6.18289746e-02f, 2.74208002e-02f, -1.01166226e-01f, -4.33029272e-02f, -4.04406041e-02f, 2.06774101e-01f,
  1.12120146e-02f, -3.57581712e-02f, 7.85418823e-02f, 8.64807889e-02f, -7.46627748e-02f, -4.90056425e-02f, 6.75383955e-04f, 5.28278053e-02f, 1.51983248e-02f, 1.52779043e-01f,
  -6.54721916e-01f, 2.31646866e-01f, 2.76834909e-02f, 3.64456415e-01f, -2.32332081e-01f, -2.78198600e-01f, -9.49082300e-02f, -4.08263840e-02f, -2.42735118e-01f, 2.03417152e-01f,
  1.91768005e-01f, -2.18670204e-01f, 2.17348427e-01f, 3.95348847e-01f, -1.25193402e-01f, 2.99435109e-01f, 3.16768855e-01f, 8.71773809e-02f, 4.84442227e-02f, 9.24252793e-02f,
  1.30680189e-01f, 2.62269825e-01f, 3.03930432e-01f, 8.19204822e-02f, -3.52974609e-02f, 1.02340527e-01f, 1.51877418e-01f, -2.99985036e-02f, 6.46107644e-02f, -2.21466497e-01f,
  -2.88713545e-01f, 8.96035880e-02f, -1.13149034e-02f, -7.95515552e-02f, -6.63152859e-02f, -1.45541936e-01f, -4.02045213e-02f, -5.62040880e-02f, 3.75003442e-02f, -3.32466252e-02f,
  -9.93982106e-02f, -9.00743902e-02f, 1.48083279e-02f, 1.04154469e-02f, -1.04868360e-01f, 5.17067919e-03f, -3.14366771e-03f, 1.40401153e-02f, 3.41469720e-02f, -1.96495578e-02f,
  -3.34980851e-03f, 4.94651170e-03f, 7.49516934e-02f, 7.70821869e-02f, 1.00789212e-01f, 4.01713364e-02f, -5.39302006e-02f, -4.64322679e-02f, -1.51746675e-01f, -5.80267003e-03f,
  -5.18865362e-02f, 1.23102227e-02f, 3.72013971e-02f, -2.84997709e-02f, -4.99154301e-03f, 3.43820676e-02f, 7.43956352e-03f, -7.60092735e-02f, 4.95044328e-02f, 1.03901237e-01f,
  -5.85097671e-02f, -1.39726559e-02f, -6.86899498e-02f, 3.28918472e-02f, -8.32414441e-03f, -9.02995188e-03f, 6.25154600e-02f, -4.86926362e-02f, -2.74723880e-02f, 9.85101517e-03f,
  2.61674020e-02f, -7.38186315e-02f, -4.89947572e-02f, -1.10983495e-02f, -5.40597513e-02f, 3.69857810e-02f, 1.26633525e-01f, -1.63107160e-02f, -2.57230010e-02f, -1.13381058e-01f,
  -3.48682731e-01f, 1.14711784e-01f, 5.22351300e-04f, -1.31190002e-01f, 2.37365887e-02f, -1.21742092e-01f, 4.77409437e-02f, -7.55468905e-02f, -2.64076646e-02f, -4.71030883e-02f,
  -9.78469625e-02f, 2.45672688e-02f, -6.00355864e-02f, 6.16486892e-02f, 4.96750213e-02f, 6.75563067e-02f, 4.65311967e-02f, -8.97854045e-02f, 2.93008867e-03f, -7.46758804e-02f,
  8.99832472e-02f, -6.10112101e-02f, -2.52067316e-02f, -3.09232548e-02f, -3.32795940e-02f, 8.65212735e-03f, -6.61009401e-02f, -9.77537483e-02f, -1.94994584e-02f, 1.23816952e-02f,
  -8.65243554e-01f, 3.76175195e-01f, 3.36536676e-01f, -3.86171758e-01f, 1.59116209e-01f, 4.15237188e-01f, -9.12801251e-02f, 2.03873396e-01f, -1.92513749e-01f, 1.76322609e-01f,
  -4.19244170e-02f, -2.95263052e-01f, 1.84683084e-01f, 1.22550137e-01f, 2.35768855e-02f, 2.38902107e-01f, 2.09099576e-01f, 9.19564143e-02f, -8.25852677e-02f, -3.66162993e-02f,
  -2.08616238e-02f, -4.05165702e-02f, 2.26266503e-01f, 1.64447829e-01f, 5.31644970e-02f, -1.83011055e-01f, -1.71533659e-01f, -2.87113595e-03f, 6.58475161e-02f, -3.13191041e-02f,
  -3.42551678e-01f, -3.27993512e-01f, -1.69502094e-01f, 9.80626643e-02f, 6.63838014e-02f, 3.91713157e-03f, -7.78035894e-02f, -1.03479847e-01f, -1.38218358e-01f, -2.94550229e-03f,
  -2.43655816e-02f, 1.21415071e-02f, -9.80546549e-02f, -2.66174376e-02f, 3.36482041e-02f, 6.38776422e-02f, 1.74409866e-01f, 1.33931354e-01f, 5.61913960e-02f, 1.72779232e-01f,
  1.70807421e-01f, 7.34701082e-02f, 8.97616819e-02f, 2.02039294e-02f, 8.39976743e-02f, 7.47019425e-02f, 1.12285428e-01f, 1.90329123e-02f, -1.57261211e-02f, -4.52409312e-02f,
  3.19000520e-02f, -6.53384626e-02f, -3.29089500e-02f, -3.56112309e-02f, -3.67746837e-02f, 2.02213395e-02f, -3.72907296e-02f, 2.38903444e-02f, -5.13135269e-02f, -2.16700844e-02f,
  -4.80184844e-03f, -4.70277853e-02f, 1.03273094e-02f, 9.87992659e-02f, -1.03961535e-01f, -6.22918196e-02f, -4.62312438e-02f, -1.72133781e-02f, 5.68740405e-02f, -2.49639060e-02f,
  -5.70829213e-02f, -3.36534679e-02f, -3.22978422e-02f, 2.64680441e-02f, -4.56049433e-03f, -2.82868911e-02f, -8.42890069e-02f, 5.29980548e-02f, -4.99641709e-02f, -7.33147338e-02f,
  -4.29456025e-01f, -4.09740061e-01f, -5.58473580e-02f, -1.02514900e-01f, -8.75917897e-02f, 2.05270108e-02f, 1.66272707e-02f, -7.06989970e-03f, -1.04233369e-01f, -1.33170811e-02f,
  4.39035408e-02f, 2.75551677e-02f, -3.64971310e-02f, -3.97519842e-02f, -2.51526386e-02f, 1.60906669e-02f, -1.24077283e-01f, -1.02730669e-01f, -7.25382268e-02f, -3.69370244e-02f,
  -9.65719521e-02f, -8.85053053e-02f, -4.33908552e-02f, -4.82120737e-02f, 5.27974740e-02f, -1.54377952e-01f, -3.75305004e-02f, 1.18460609e-02f, 1.48212779e-02f, 7.07628429e-02f,
  1.88472960e-02f, -9.43382233e-02f, -3.01526695e-01f, -2.22213075e-01f, -3.58635128e-01f, -1.34887874e-01f, -2.94442654e-01f, -1.95382982e-01f, 4.45385315e-02f, 1.97641686e-01f,
  -1.03497542e-01f, 1.70626163e-01f, 2.08253115e-01f, -1.94406658e-01f, 1.69667304e-01f, 3.26197207e-01f, 3.91987190e-02f, 1.53967336e-01f, 5.50170429e-03f, -1.28155321e-01f,
  -3.46079767e-02f, -1.86531842e-01f, 6.83763176e-02f, -2.29676053e-01f, -3.67714196e-01f, -2.36767367e-01f, -1.40951173e-02f, -2.56354272e-01f, -2.03022793e-01f, -2.09541291e-01f,
  -1.55898377e-01f, -8.29883367e-02f, -1.22222595e-01f, 1.37867048e-01f, -2.54503470e-02f, -7.08249509e-02f, -4.98587936e-02f, -6.85708299e-02f, 3.74214351e-02f, 2.47558597e-02f,
  6.27021194e-02f, 2.27029230e-02f, -7.25195184e-02f, 7.53271161e-04f, -5.71708158e-02f, -2.04552263e-02f, 6.41485080e-02f, -2.06559133e-02f, 4.34374511e-02f, -8.22684020e-02f,
  -8.88002068e-02f, -5.28425276e-02f, -4.86283423e-03f, 5.36142141e-02f, -4.62347195e-02f, 6.29170705e-03f, 2.34862175e-02f, -9.64440405e-02f, 2.35978584e-03f, 2.40093917e-02f,
  -6.55416995e-02f, 4.20514233e-02f, 5.14827901e-03f, -5.73743582e-02f, -5.87543764e-04f, -3.90787907e-02f, -5.38688386e-03f, 1.91418380e-02f, 9.10056308e-02f, -3.49572562e-02f,
  2.16811094e-02f, -5.57725877e-02f, -3.80146876e-02f, 5.99148078e-03f, 7.59667605e-02f, 6.37599733e-03f, 8.35536867e-02f, 2.48126010e-03f, -4.59217420e-03f, 7.83756673e-02f,
  8.50863308e-02f, 6.12822846e-02f, -4.54209484e-02f, 9.23250988e-02f, -8.65283757e-02f, 1.09520182e-02f, -2.03329865e-02f, 5.86921759e-02f, 1.24678444e-02f, -1.93525404e-02f,
  -7.96460081e-03f, -3.65294181e-02f, 1.62379500e-02f, -4.41174023e-02f, 1.15017053e-02f, -9.49191898e-02f, -5.41329980e-02f, -8.80536139e-02f, 6.49937019e-02f, 2.37825084e-02f,
  6.10419698e-02f, 4.84708836e-03f, -5.52127548e-02f, 1.02348076e-02f, 6.64905012e-02f, -1.00292817e-01f, 6.89045638e-02f, 1.53214023e-01f, 1.98871945e-03f, -8.71592294e-03f,
  -5.94068579e-02f, 4.58082519e-02f, 1.61749542e-01f, 1.23323552e-01f, 1.14036657e-01f, 5.12282774e-02f, -2.22637877e-02f, 2.01184321e-02f, -6.02780059e-02f, -1.00921668e-01f,
  -1.18057728e-01f, 1.03436917e-01f, 3.38373601e-01f, 6.59547523e-02f, 3.81190926e-01f, 5.07436514e-01f, 2.66531073e-02f, 4.52989668e-01f, 3.68021131e-01f, -9.54464898e-02f,
  -3.07354275e-02f, -1.28985852e-01f, 5.33387735e-02f, -8.32904428e-02f, 5.12944199e-02f, 9.54092517e-02f, 5.82511425e-02f, -1.91804513e-01f, 3.86520386e-01f, -2.44694892e-02f,
  1.10122055e-01f, -1.06483020e-01f, 7.89135769e-02f, 7.40364492e-02f, 9.90722403e-02f, -2.26561334e-02f, -3.52518678e-01f, 1.01582035e-01f, -2.22381592e-01f, -1.19266042e-03f,
  1.49766147e-01f, 1.37295529e-01f, 4.61314805e-02f, 1.23247959e-01f, 2.62898859e-02f, 4.27851304e-02f, -3.36747766e-02f, 1.47061646e-02f, -7.74709787e-03f, 5.11979572e-02f,
  -1.27677515e-01f, 5.41907512e-02f, -1.14771174e-02f, 6.37014061e-02f, 1.65495425e-01f, 4.71987538e-02f, 6.82589859e-02f, 3.10718212e-02f, 1.67451918e-01f, 2.83017103e-02f,
  5.89330904e-02f, 1.10779256e-01f, 1.08048916e-01f, 1.14502739e-02f, 5.43803349e-02f, 1.44614115e-01f, 3.05610485e-02f, -1.00799138e-02f, -2.78660399e-03f, 1.53597027e-01f,
  8.40856433e-02f, 3.84519771e-02f, -2.52484879e-03f, 2.57940069e-02f, -2.29687616e-02f, -5.61060049e-02f, -8.38187635e-02f, -7.35846981e-02f, -5.30689135e-02f, -2.48257704e-02f,
  -4.94692400e-02f, -9.16654058e-03f, 3.90956225e-03f, 3.53423357e-02f, 3.88312303e-02f, -2.66774986e-02f, 1.35761071e-02f, -8.99456963e-02f, -7.41088390e-03f, 3.07975840e-02f,
  -1.08455703e-01f, -2.40976792e-02f, 1.18507802e-01f, 1.11189678e-01f, 3.37151662e-02f, 5.98828942e-02f, -3.19075473e-02f, 1.08796626e-01f, 5.83129637e-02f, -6.47006035e-02f,
  2.22381894e-02f, 6.42910749e-02f, 4.97753322e-02f, 4.41935249e-02f, -9.05619189e-02f, 9.77659374e-02f, 3.30351247e-03f, 7.69778565e-02f, 8.10852274e-02f, 3.89179848e-02f,
  -1.26088515e-01f, -1.36957616e-01f, 2.72745825e-02f, -1.06609520e-02f, -8.07165429e-02f, -2.20638644e-02f, -6.84247315e-02f, -8.52322280e-02f, 2.23909933e-02f, 3.59423347e-02f,
  -1.14371568e-01f, -6.57426193e-02f, -3.61460038e-02f, -1.49352225e-02f, -1.12298071e-01f, -3.89291942e-02f, 4.55545112e-02f, -3.03340908e-02f, 9.23823379e-03f, 3.70378979e-02f,
  3.53821546e-01f, -2.79172450e-01f, -2.77676821e-01f, 2.11212277e-01f, 2.09941238e-01f, 3.06289196e-01f, 1.46022961e-01f, 1.06754780e-01f, 1.09409705e-01f, -2.20063180e-02f,
  8.24473724e-02f, -1.72116280e-01f, -1.83143139e-01f, 3.66340667e-01f, 2.19135508e-01f, -2.20423378e-02f, 3.33961964e-01f, 4.74547818e-02f, -1.22021260e-02f, -5.39133064e-02f,
  1.77272454e-01f, 3.80134463e-01f, -1.30914077e-01f, 1.39192238e-01f, 1.78954646e-01f, -1.53003439e-01f, -9.82259214e-02f, -2.79043049e-01f, 1.34868100e-01f, 1.78000554e-01f,
  6.98297694e-02f, 1.29676601e-02f, -5.57414070e-02f, 7.87882041e-03f, -7.39272013e-02f, -6.99650273e-02f, -5.20003736e-02f, 6.02627248e-02f, -5.07716835e-02f, -9.75344107e-02f,
  -1.47879675e-01f, 4.58193421e-02f, 8.11150447e-02f, 6.15387596e-02f, 1.47278443e-01f, 9.42457542e-02f, 2.43241526e-02f, -9.14916322e-02f, -9.03309062e-02f, 3.86240799e-03f,
  -5.48358709e-02f, -1.19287476e-01f, 2.41053067e-02f, -1.11516332e-02f, -4.31709848e-02f, 7.31587633e-02f, -3.27773392e-02f, -1.37498766e-01f, 5.98090887e-02f, 3.96940038e-02f,
  6.75666332e-02f, -3.25996950e-02f, -9.77297947e-02f, 9.81900096e-02f, -4.71952185e-02f, 3.78337391e-02f, 5.29065989e-02f, 3.19559239e-02f, -5.76618947e-02f, -1.53089222e-03f,
  -6.67495131e-02f, -1.19677128e-03f, 1.16598122e-02f, 2.65499968e-02f, -7.83858169e-03f, 8.33825096e-02f, 2.79109217e-02f, 2.79583856e-02f, -8.11350718e-02f, 4.23727706e-02f,
  -4.66629583e-03f, -1.91370565e-02f, -4.20837775e-02f, -1.07602039e-02f, -7.57775782e-03f, -9.71491709e-02f, 1.37862295e-01f, -3.95454653e-02f, -1.81539904e-03f, -4.10482138e-02f,
  1.06305629e-02f, -1.30315766e-01f, -2.01812480e-02f, 1.62667166e-02f, -4.72175656e-03f, -2.72707697e-02f, -2.17373725e-02f, 1.02330744e-01f, -1.61959622e-02f, 6.17558695e-02f,
  -4.45302762e-02f, -3.31652015e-02f, 3.78764160e-02f, 3.73372734e-02f, 1.05957882e-02f, -2.96257995e-02f, -6.70378702e-03f, -2.72829309e-02f, 1.36972740e-01f, -4.01779562e-02f,
  -5.73741198e-02f, -5.27315252e-02f, -4.19301130e-02f, -1.43885678e-02f, -5.64055778e-02f, -9.93774608e-02f, -1.02976151e-02f, -6.21615024e-03f, -7.53098130e-02f, -1.26347234e-02f,
  -4.19541806e-01f, 4.47114050e-01f, -2.90915277e-02f, -1.98710173e-01f, 1.82248414e-01f, -2.29154989e-01f, -2.79275447e-01f, 1.59941256e-01f, -3.11771724e-02f, 2.94369221e-01f,
  -4.19098660e-02f, 2.30336294e-01f, -1.15464680e-01f, -2.48471946e-01f, -5.64840972e-01f, -4.03396517e-01f, -3.45671475e-01f, -1.03545882e-01f, -2.21693739e-01f, -1.10288098e-01f,
  -2.52052993e-01f, -1.60431743e-01f, -3.62579882e-01f, 2.07899436e-01f, 1.33501425e-01f, 2.65756816e-01f, -1.84804097e-01f, 1.69779241e-01f, 3.17072831e-02f, -1.37140620e-02f,
  -5.60117466e-03f, 7.83099756e-02f, 1.50170878e-01f, -4.05479819e-02f, -1.28254920e-01f, 6.51233345e-02f, 6.27057850e-02f, -1.14203431e-03f, -9.10885260e-02f, 6.58039451e-02f,
  7.27195591e-02f, 8.78412500e-02f, -2.55806707e-02f, 4.89613190e-02f, 1.23664409e-01f, 1.06151976e-01f, 4.25878540e-02f, 5.54873906e-02f, 7.34051783e-03f, 8.95620137e-02f,
  -3.95924076e-02f, 1.31210431e-01f, -2.75079329e-02f, -2.19339579e-02f, -2.77533047e-02f, 1.49772748e-01f, -1.01320326e-01f, 9.65025425e-02f, 1.14731200e-01f, 1.60848850e-03f,
  -1.93649065e-02f, -4.91642691e-02f, -6.05127364e-02f, 4.39105183e-02f, -3.11070550e-02f, 2.51307413e-02f, -8.11385587e-02f, -2.40621399e-02f, -3.14272493e-02f, 6.17470220e-03f,
  6.79306090e-02f, 1.17573999e-02f, 4.88353483e-02f, -7.95067176e-02f, -1.15465634e-02f, -7.61159584e-02f, -3.83595303e-02f, 1.10389967e-03f, -7.88176060e-02f, -4.41009663e-02f,
  1.73474029e-02f, -4.00645509e-02f, 8.52015521e-03f, -1.03399009e-02f, -8.84283260e-02f, 1.55877350e-02f, 9.46862996e-02f, 1.07964675e-03f, -5.75269870e-02f, -5.88477366e-02f,
  -1.07750215e-01f, -1.06358223e-01f, 2.30832119e-02f, 1.22161016e-01f, 3.36549282e-02f, -2.99431793e-02f, -9.66861024e-02f, 2.62862910e-02f, -2.54606716e-02f, -4.00283150e-02f,
  4.68713492e-02f, -4.10217680e-02f, -4.50186208e-02f, -2.21296195e-02f, -6.86165364e-03f, -9.18118469e-03f, -5.50630204e-02f, 6.96703419e-02f, 2.31408831e-02f, 1.05513692e-01f,
  9.14992243e-02f, 6.71126023e-02f, -6.01388253e-02f, -1.18733168e-01f, -1.90240238e-02f, 5.60000464e-02f, 8.81233290e-02f, 9.14129838e-02f, -6.33631796e-02f, -1.98097862e-02f,
  3.61921519e-01f, 2.73796141e-01f, 2.92631686e-01f, 3.25132459e-01f, -1.37002215e-01f, -2.35072926e-01f, 8.96869879e-03f, 5.86836785e-02f, 1.46573558e-01f, -1.03204757e-01f,
  -2.97256894e-02f, 2.25945204e-01f, -1.70403838e-01f, 2.96766281e-01f, -2.14917377e-01f, -1.01117559e-01f, 4.90490459e-02f, 4.44068797e-02f, -6.92211762e-02f, 1.65547505e-01f,
  2.00123832e-01f, -2.70155400e-01f, 1.40325546e-01f, -1.89991713e-01f, 2.07994327e-01f, 1.25082225e-01f, -9.08997431e-02f, -1.09207816e-01f, -1.10153225e-03f, -1.88025653e-01f,
  6.18738458e-02f, 9.84817445e-02f, 1.70291826e-01f, -2.17324384e-02f, 1.06507376e-01f, 7.01723387e-03f, -1.67643151e-03f, -1.01357497e-01f, -3.13427225e-02f, -3.83492224e-02f,
  7.36297518e-02f, -5.62397987e-02f, -4.30907094e-05f, 2.32809363e-03f, 2.95912120e-02f, 2.74738460e-03f, 2.45245378e-02f, 7.20555112e-02f, -3.79526871e-03f, 2.81816628e-02f,
  1.57647908e-01f, 7.27130696e-02f, 1.24340937e-01f, -6.84676915e-02f, 8.59488472e-02f, -2.09437665e-02f, 4.83223610e-02f, 2.56026033e-02f, 7.42257526e-03f, -2.03877920e-03f,
  -7.16682151e-02f, -8.74220803e-02f, -1.41053451e-02f, 1.45554158e-03f, 4.25356179e-02f, 4.86717280e-03f, 1.47268446e-02f, -2.89631374e-02f, 5.06835021e-02f, -1.52112367e-02f,
  -2.59939656e-02f, 7.42519647e-02f, 3.69408280e-02f, -3.42325978e-02f, 6.75428286e-02f, 6.21533655e-02f, -3.27355810e-03f, -4.61766124e-02f, 1.30815908e-01f, 1.85440830e-03f,
  -5.57833463e-02f, -2.25313827e-02f, -5.76457977e-02f, -4.05101590e-02f, -1.53935533e-02f, -1.13555277e-02f, 6.79931464e-03f, 1.10482343e-01f, -3.60825248e-02f, -5.96488230e-02f,
  -2.69475486e-02f, -1.51927829e-01f, 7.26783201e-02f, -1.61264222e-02f, -6.98608309e-02f, 8.17739964e-03f, -4.76122089e-02f, 1.10829279e-01f, -7.34203123e-03f, -7.67744035e-02f,
  -1.11246016e-02f, 1.28459919e-03f, 8.51296261e-02f, -2.24349257e-02f, 1.59821343e-02f, 1.98146258e-03f, 7.78368115e-02f, -2.93904971e-02f, 2.69641969e-02f, -6.87760487e-02f,
  1.51422061e-02f, -2.90280897e-02f, 5.82325906e-02f, 8.53241086e-02f, 3.81940491e-02f, 6.40684087e-03f, -2.15229462e-03f, 7.56976232e-02f, -1.19804852e-01f, 4.15604673e-02f,
  8.75662714e-02f, -6.60838187e-02f, -4.39202964e-01f, -7.93434530e-02f, -4.39938754e-02f, 1.98475823e-01f, 1.31257877e-01f, 7.29921907e-02f, -2.94311911e-01f, 3.18571270e-01f,
  3.47600341e-01f, -6.22391738e-02f, -3.47177088e-02f, 2.52232522e-01f, 7.03296997e-03f, -2.95993071e-02f, 1.80261433e-01f, 1.69909105e-01f, -1.07434154e-01f, 1.92789376e-01f,
  5.35646901e-02f, 3.51735353e-01f, 1.57533690e-01f, 2.85588205e-01f, 2.82094747e-01f, -1.04569159e-01f, 3.05185944e-01f, -1.23286858e-01f, 2.40467608e-01f, 1.85924456e-01f,
  2.54780166e-02f, 1.04569398e-01f, 1.15277236e-02f, -1.45090502e-02f, 4.49694842e-02f, 3.47881205e-02f, -2.94215567e-02f, -4.32681628e-02f, -1.50187328e-01f, -1.58130676e-02f,
  -1.56598072e-02f, -2.09615603e-02f, 6.90545514e-02f, -1.79471880e-01f, -5.30597046e-02f, -1.29535586e-01f, -6.52157515e-02f, -3.54370917e-03f, -2.17413679e-01f, 9.28638875e-03f,
  -1.99928626e-01f, -1.14079058e-01f, -1.44003620e-02f, -2.03915704e-02f, -3.42109576e-02f, 8.80063046e-03f, -5.38385957e-02f, 4.20483499e-04f, -2.28559300e-02f, 4.78782393e-02f,
  1.04087954e-02f, 1.33250840e-02f, 2.57129185e-02f, 1.10966764e-01f, -6.74201176e-02f, -2.36880756e-03f, -1.55224316e-02f, -1.00971147e-01f, -3.16851474e-02f, 4.75059226e-02f,
  4.17886414e-02f, -9.95069519e-02f, 3.95831792e-03f, 1.02369636e-01f, 1.18248016e-01f, -2.83842143e-02f, -7.75012150e-02f, 9.48921591e-02f, -3.95450033e-02f, -1.14348747e-01f,
  7.20047904e-03f, 6.28304631e-02f, 1.82309467e-02f, -1.10506983e-02f, -3.92111465e-02f, 5.23921102e-02f, 1.22781396e-01f, 1.40795559e-01f, 4.64100391e-02f, 7.17758462e-02f,
  1.52480140e-01f, 1.40363783e-01f, 5.08716106e-02f, 2.55211815e-02f, -1.39370020e-02f, 4.75295670e-02f, 3.89016643e-02f, 1.23624921e-01f, -1.02487451e-03f, -8.34289715e-02f,
  1.86855532e-02f, -3.93090099e-02f, 8.10391158e-02f, 2.20292844e-02f, -3.31550986e-02f, 1.83164656e-01f, 3.47202457e-02f, -5.96121661e-02f, -3.92307295e-03f, 5.51461540e-02f,
  6.19059578e-02f, -3.55147049e-02f, -4.71814759e-02f, -1.54348955e-01f, 3.08790989e-02f, -3.59681882e-02f, 1.70068499e-02f, 2.89689912e-03f, -1.29277585e-02f, -4.16434668e-02f,
  3.68613228e-02f, 7.21234828e-02f, -3.94790590e-01f, -3.06564808e-01f, 5.84614612e-02f, -4.38711941e-01f, -3.91654462e-01f, -1.87179402e-01f, 9.84297469e-02f, -8.84225741e-02f,
  -1.52494490e-01f, 1.59383491e-01f, 2.29379207e-01f, -3.02728593e-01f, 2.83700544e-02f, 2.07124606e-01f, -3.31293851e-01f, -2.24190995e-01f, 1.47563396e-02f, -2.98068970e-01f,
  -1.09028406e-01f, -1.21763416e-01f, -2.09566221e-01f, -1.19069763e-01f, -2.99033374e-01f, -1.82795282e-02f, 1.02617636e-01f, -1.14862286e-01f, -1.92798123e-01f, 6.80527538e-02f,
  -1.23080552e-01f, -2.83995330e-01f, -1.25247717e-01f, 3.64416987e-02f, -2.63611257e-01f, -6.67098910e-02f, -1.45707190e-01f, 6.11313991e-02f, -7.01859146e-02f, -6.47139773e-02f,
  3.58969346e-02f, 1.86225772e-01f, -1.69609170e-02f, 2.24254593e-01f, 4.86421771e-02f, -6.04821369e-02f, 2.66158357e-02f, 2.11955700e-02f, -2.32802760e-02f, 1.30304441e-01f,
  -4.30331267e-02f, -8.91920850e-02f, -5.55854738e-02f, 6.76908642e-02f, 2.71937586e-02f, -3.57193463e-02f, -1.35448501e-02f, 1.26727805e-01f, -1.43080890e-01f, -6.97297454e-02f,
  -1.69543661e-02f, 4.06757258e-02f, -7.71828815e-02f, 7.38954991e-02f, -7.56159127e-02f, 5.51699214e-02f, -2.27438305e-02f, 2.67285556e-02f, -6.03323430e-02f, -2.03319490e-02f,
  1.04815930e-01f, 2.75324378e-02f, 1.56114148e-02f, -1.42955616e-01f, -4.89876866e-02f, 4.69185673e-02f, 4.52251267e-03f, -7.31675178e-02f, 5.67510761e-02f, -5.22120250e-03f,
  -9.50338412e-03f, -6.77638575e-02f, 8.18070862e-03f, 4.09504399e-03f, -2.56692525e-03f, -6.76819216e-03f, 1.53498221e-02f, -7.56109953e-02f, 1.73255354e-02f, -2.68301331e-02f,
  -2.02696428e-01f, -4.03882474e-01f, 5.24624325e-02f, -1.11606732e-01f, -1.49458344e-03f, -3.76833528e-02f, -2.43740883e-02f, 3.90899442e-02f, -2.29512975e-01f, -1.37052640e-01f,
  -1.38949305e-01f, -3.41922641e-02f, -2.43847575e-02f, -4.88416888e-02f, 3.69461253e-02f, 2.68152561e-02f, -1.02268875e-01f, -1.62102617e-02f, -1.42538220e-01f, 1.83208864e-02f,
  -5.84765244e-03f, 5.35871051e-02f, 4.88300398e-02f, -5.10751903e-02f, 3.38974446e-02f, -1.70140956e-02f, 1.59078150e-03f, 5.77333458e-02f, -4.57103401e-02f, 2.98064854e-02f,
  -2.15343125e-02f, -2.75134206e-01f, 1.93456292e-01f, -6.14970131e-03f, -6.46374300e-02f, 2.50971049e-01f, 5.82397521e-01f, -3.37671906e-01f, -4.11992848e-01f, -1.05716132e-01f,
  1.10120028e-01f, 1.64168939e-01f, 4.40138042e-01f, 1.50602654e-01f, 4.10489768e-01f, 2.95508116e-01f, 4.78125550e-02f, 2.21122280e-01f, -1.05936669e-01f, -2.89056953e-02f,
  -5.15579619e-02f, 2.97753494e-02f, 3.20222408e-01f, -4.02403593e-01f, 7.95267075e-02f, -3.07905823e-01f, -3.92574780e-02f, 2.33470976e-01f, -1.42845422e-01f, 1.43800408e-01f,
  -5.15596708e-03f, -2.80197352e-01f, 2.50915415e-03f, -7.92980343e-02f, -7.69495964e-02f, -1.10709295e-02f, 1.84593514e-01f, 2.61583447e-01f, 3.22020501e-02f, -1.26445228e-02f,
  7.56666139e-02f, -5.19536948e-03f, -2.35144928e-01f, 3.61037143e-02f, -1.49825826e-01f, -1.52576938e-01f, -1.07335038e-01f, 1.15241418e-02f, -6.90957978e-02f, 1.11144476e-01f,
  1.16479807e-01f, -2.67484244e-02f, 3.97612564e-02f, -8.35451186e-02f, 3.07730343e-02f, -5.86555600e-02f, 1.01194099e-01f, 7.17891827e-02f, -3.27897109e-02f, -8.36901888e-02f,
  -2.59357356e-02f, 4.22998704e-03f, -6.49233349e-04f, -1.10330824e-02f, -1.02593657e-03f, 2.91170217e-02f, 2.76059937e-02f, 4.00774181e-02f, 2.55790632e-02f, 3.16800326e-02f,
  -6.96893409e-02f, -6.50783777e-02f, -8.67366642e-02f, 1.99338328e-03f, -4.27559763e-03f, -1.15529019e-02f, 1.03708640e-01f, -1.80592127e-02f, 3.71705405e-02f, -2.40711421e-02f,
  3.99169326e-02f, -6.99084401e-02f, 1.14386767e-01f, 7.23203793e-02f, -8.60544853e-03f, 7.95610435e-03f, -1.23374976e-01f, 4.25700881e-02f, 2.95141321e-02f, 1.92335144e-01f,
  -2.09145531e-01f, -3.77636373e-01f, -1.07515879e-01f, -1.52617451e-02f, -6.13088049e-02f, -1.11758694e-01f, -6.50251433e-02f, -1.59021258e-01f, 1.41092762e-02f, -3.05116121e-02f,
  -8.29766765e-02f, 2.26075714e-03f, -8.35552067e-02f, -1.73664968e-02f, -2.38069966e-02f, -1.78621799e-01f, 4.80132997e-02f, -6.17658868e-02f, 7.86505938e-02f, -1.01129279e-01f,
  -2.71628052e-02f, -9.64958593e-03f, -2.08355971e-02f, -3.58226560e-02f, -5.97407259e-02f, 7.09482878e-02f, -1.28759846e-01f, 3.33326571e-02f, 5.01872152e-02f, 1.42416870e-02f,
  1.51942104e-01f, 1.72917292e-01f, 3.08707565e-01f, 2.01651618e-01f, -9.01168585e-02f, -3.85351241e-01f, -2.17308432e-01f, 5.36274314e-02f, -2.04964615e-02f, -2.77248919e-01f,
  5.51300831e-02f, 1.03724830e-01f, 2.47569844e-01f, 1.09947249e-01f, 3.14635396e-01f, 2.81459242e-01f, -3.00277467e-03f, -1.29718632e-01f, 1.15389831e-01f, 1.80691168e-01f,
  1.72720820e-01f, 1.69561893e-01f, 4.09522325e-01f, 1.00926444e-01f, 1.10206455e-01f, 1.60825565e-01f, 2.81663716e-01f, 1.23872191e-01f, -1.00034915e-01f, -3.82394381e-02f,
  -1.12021543e-01f, 3.28939617e-01f, 6.79579154e-02f, -2.27363571e-03f, 6.77316710e-02f, -1.73112944e-01f, -6.97144195e-02f, 7.78163671e-02f, -1.18714357e-02f, 3.76752913e-02f,
  4.24064510e-02f, 2.84616370e-02f, -1.05946220e-01f, -4.56535742e-02f, -1.97253808e-01f, 1.62010826e-02f, 3.87789458e-02f, -1.22945327e-02f, -4.25288528e-02f, -1.30052954e-01f,
  -1.04072867e-02f, 2.02544276e-02f, 7.49698281e-02f, -2.44706348e-02f, 1.13488108e-01f, -4.69433591e-02f, -7.33342320e-02f, 1.49192736e-02f, -2.36674771e-02f, 2.08467115e-02f,
  3.72297950e-02f, 1.76026439e-03f, -3.01211085e-02f, -7.49752522e-02f, -3.22515331e-02f, 8.16500746e-03f, -4.86027487e-02f, -1.52811036e-02f, -6.37822524e-02f, 2.01232042e-02f,
  -8.86392780e-03f, -9.30644944e-03f, -1.53636932e-02f, -9.75371525e-02f, 3.10949516e-02f, -2.04117466e-02f, -1.49438214e-02f, -1.01054041e-02f, -4.86760102e-02f, -4.47071018e-03f,
  1.21515349e-01f, -2.52449196e-02f, 4.97141145e-02f, -6.05848664e-03f, -2.05901876e-01f, 3.57645042e-02f, 3.02991234e-02f, 6.17643446e-03f, 1.30535185e-01f, 8.98301601e-02f,
  6.34358451e-02f, 3.88395637e-01f, 1.61752105e-01f, -6.71590716e-02f, 3.27706337e-02f, 5.14754131e-02f, 6.45226389e-02f, -1.05758078e-01f, 1.22036122e-01f, 4.27231193e-02f,
  -5.97244836e-02f, -2.40787026e-02f, 6.15462214e-02f, -5.89348115e-02f, 1.87456459e-02f, 6.37375796e-03f, -2.36363187e-02f, 5.06659597e-03f, 2.02704072e-01f, 3.74472141e-02f,
  1.62806679e-02f, 4.17735726e-02f, -1.68378570e-03f, -1.40277684e-01f, 1.61482114e-02f, 3.75280976e-02f, -8.85979459e-02f, 5.29702613e-03f, 8.42122436e-02f, 1.36176916e-03f,
  2.58089215e-01f, -1.25495017e-01f, -1.34132147e-01f, 1.27092361e-01f, 5.35086878e-02f, -2.14065835e-01f, -3.32305849e-01f, 2.38698065e-01f, -1.51848838e-01f, -9.35871899e-02f,
  1.40363380e-01f, -2.52436064e-02f, -1.73097521e-01f, 1.35272786e-01f, 3.18154395e-01f, -2.56170005e-01f, 3.09077233e-01f, -5.07976077e-02f, 4.16736724e-03f, 1.85862482e-01f,
  2.34570533e-01f, 3.19473088e-01f, 2.90898323e-01f, 2.99938381e-01f, 8.50301012e-02f, 3.18999350e-01f, 3.91055346e-01f, -6.30159229e-02f, 2.93438882e-01f, 1.78688884e-01f,
  -7.86345527e-02f, -2.33537666e-02f, -6.96998239e-02f, -4.71171737e-02f, 3.79630588e-02f, -6.39702231e-02f, -7.76825398e-02f, 4.46119569e-02f, -8.76244716e-03f, -1.46990856e-02f,
  -9.54434201e-02f, 1.89951777e-01f, 1.05505779e-01f, 6.09288439e-02f, -4.81537320e-02f, 2.53972430e-02f, -1.86081603e-02f, -1.03942916e-01f, -1.69436242e-02f, -6.34964630e-02f,
  -1.24704957e-01f, -3.03023048e-02f, 2.49830931e-02f, -1.05736814e-02f, -6.75752759e-02f, 9.34109911e-02f, -3.22569907e-02f, -9.73869953e-03f, -4.34823008e-03f, -3.59278172e-02f,
  1.11233465e-01f, -5.93056791e-02f, 2.60412954e-02f, -6.31663054e-02f, -2.92623434e-02f, -4.93170358e-02f, 9.10368711e-02f, 8.61859508e-03f, -1.02196308e-02f, -8.10983125e-03f,
  2.42030639e-02f, 8.78164023e-02f, 1.26566775e-02f, 2.98992041e-02f, -9.61130578e-03f, 2.90724523e-02f, -2.05467213e-02f, 4.55878563e-02f, -6.89905360e-02f, -5.89230470e-02f,
  -7.35060358e-03f, 3.74581553e-02f, -4.34765257e-02f, 1.12765335e-01f, 8.87249783e-03f, 7.06411824e-02f, 3.59339342e-02f, -8.29112679e-02f, 4.59409207e-02f, -7.58205587e-03f,
  4.05807197e-02f, 2.02774972e-01f, 1.38183534e-02f, -7.50778895e-03f, -8.04513395e-02f, -4.23520207e-02f, -6.49181679e-02f, 2.06075273e-02f, 6.83447123e-02f, -1.28751562e-03f,
  5.70435002e-02f, -3.28482427e-02f, -4.25331108e-02f, -5.53867873e-03f, 1.20587021e-01f, -4.11969237e-03f, 5.38268462e-02f, 2.69553419e-02f, 1.23729311e-01f, 7.60210827e-02f,
  1.72472876e-02f, -5.61175123e-02f, -7.65673816e-03f, -1.08153224e-01f, 1.55779589e-02f, -6.16983734e-02f, 7.47592896e-02f, -1.23778637e-02f, 4.12057973e-02f, -3.62436175e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 14)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 14;
const float L0_fan_Bp_bar_data[] = {
  7.13639408e-02f, 1.63320750e-01f, 2.10683569e-01f, 6.67903498e-02f, -1.66300572e-02f, 3.12672228e-01f, 3.13923538e-01f, 3.30581844e-01f, 2.00042725e-01f, 2.09301263e-01f,
  1.30103588e-01f, 3.06511879e-01f, 6.44616112e-02f, 1.52533218e-01f
};

// L1_fan_Wp (Shape: 25 x 64)
const int L1_fan_Wp_rows = 25;
const int L1_fan_Wp_cols = 64;
const float L1_fan_Wp_data[] = {
  7.29518756e-02f, -1.43662676e-01f, 8.58036578e-02f, 7.16615841e-02f, -1.53011546e-01f, -1.27748922e-01f, -1.28893062e-01f, 1.15460858e-01f, 1.48180157e-01f, -4.26053628e-02f,
  -8.68760608e-03f, 6.73173517e-02f, 9.24711674e-02f, -1.00793980e-01f, 4.46782224e-02f, 1.16991676e-01f, 1.03987463e-01f, -1.78793550e-03f, -8.04812014e-02f, 9.13182423e-02f,
  2.05890939e-01f, -5.73573522e-02f, 2.93857813e-01f, -1.98417276e-01f, -1.26186386e-01f, 1.57800421e-01f, 1.02895483e-01f, 1.69165373e-01f, 2.45796725e-01f, -2.29380041e-01f,
  -8.14070851e-02f, 2.02994362e-01f, 2.04853177e-01f, 8.62162793e-04f, 1.54350027e-01f, 2.38302737e-01f, 2.62304157e-01f, 1.03528038e-01f, -1.15461729e-01f, -2.31883023e-02f,
  -2.34150738e-01f, 5.06644920e-02f, 1.28461123e-01f, -1.69068292e-01f, 2.59959310e-01f, 3.78742926e-02f, 2.31410071e-01f, -1.84390813e-01f, 1.12050101e-01f, -2.51717955e-01f,
  1.62225872e-01f, 1.21417686e-01f, -1.40423194e-01f, 1.57641888e-01f, 8.44605938e-02f, 1.18023284e-01f, -6.15412779e-02f, 3.04394979e-02f, 4.22289185e-02f, -2.07522690e-01f,
  1.91136241e-01f, -2.58739352e-01f, 1.89451501e-01f, -1.86447605e-01f, 2.75303610e-02f, -1.23156913e-01f, 2.37867031e-02f, -5.91696799e-02f, 3.59783508e-02f, 1.62209244e-03f,
  -3.66008691e-02f, -9.41927060e-02f, 5.94353378e-02f, 5.68569696e-04f, -6.20861314e-02f, 2.42683832e-02f, -2.65130773e-02f, -5.42410687e-02f, 3.54259126e-02f, -1.09870836e-01f,
  7.40026459e-02f, -2.56238971e-02f, -4.07235436e-02f, -9.02899057e-02f, 1.74047053e-01f, 1.96234211e-01f, 1.60092022e-02f, 2.28921801e-01f, 1.02699280e-01f, 1.50683001e-01f,
  -2.06318110e-01f, 9.19274986e-02f, 2.54211009e-01f, -6.32524490e-02f, -5.85857257e-02f, 1.57542750e-02f, 3.11976999e-01f, 2.28435487e-01f, -7.96305835e-02f, -3.84461284e-02f,
  5.30746095e-02f, 9.92864668e-02f, -2.59384066e-01f, -1.38425916e-01f, -2.17026412e-01f, 2.15338022e-01f, 4.12355840e-01f, -3.61126661e-02f, 1.97804391e-01f, -2.12420911e-01f,
  1.64086912e-02f, -9.09495950e-02f, -7.77977556e-02f, -2.68862993e-01f, 9.51625630e-02f, 7.36721084e-02f, -6.81545511e-02f, 9.59650800e-02f, -1.71131223e-01f, 1.16944477e-01f,
  -3.31495762e-01f, 7.54307806e-02f, 1.59865007e-01f, -2.28761584e-01f, 2.00920150e-01f, 2.74585914e-02f, 2.16448069e-01f, -1.95064515e-01f, 8.42342228e-02f, 9.49191395e-03f,
  -3.95378955e-02f, 1.49575472e-01f, -4.00607847e-02f, 1.01263456e-01f, -9.18901414e-02f, 2.44693413e-01f, 9.36505757e-03f, -1.34539232e-01f, -1.79264158e-01f, 5.04145510e-02f,
  2.40547955e-02f, 1.47463009e-01f, 5.11822253e-02f, -1.52876288e-01f, -9.58196744e-02f, -8.87075737e-02f, 1.41492113e-02f, -5.93686588e-02f, -6.93492815e-02f, 1.16150744e-01f,
  6.18855236e-04f, -1.71002656e-01f, -2.28884563e-01f, 4.32912707e-02f, 2.78755546e-01f, -1.72303036e-01f, 2.86177080e-02f, 3.14749107e-02f, 3.11791241e-01f, 1.66181147e-01f,
  -3.09095114e-01f, -1.27938345e-01f, -1.29277289e-01f, 3.16093326e-01f, -2.26632729e-02f, -8.41485932e-02f, 1.81152880e-01f, -2.42562011e-01f, 2.11415961e-01f, 8.58259499e-02f,
  -1.99288383e-01f, 3.96844521e-02f, 1.69793665e-02f, 3.82138044e-01f, 3.20217311e-01f, -5.63592836e-02f, -1.82389431e-02f, 1.26882926e-01f, 3.55937958e-01f, -2.31648386e-01f,
  2.14441270e-01f, -5.15984185e-02f, 7.48446062e-02f, 8.10425952e-02f, 5.82815222e-02f, -2.98108578e-01f, 1.64290920e-01f, 5.74786915e-03f, -2.11266965e-01f, -6.00799061e-02f,
  1.37055427e-01f, -1.41150132e-01f, -1.18594863e-01f, 9.54223722e-02f, -8.68881345e-02f, 8.15435946e-02f, 6.55696318e-02f, -1.31336421e-01f, 1.39417723e-01f, 9.46372375e-02f,
  2.09725007e-01f, -1.27113491e-01f, 2.03774087e-02f, 1.47115393e-02f, -2.57541928e-02f, 2.07849056e-01f, 1.31946355e-02f, 6.06372356e-02f, -9.25364643e-02f, 2.34849863e-02f,
  -3.45912129e-02f, -1.41738653e-01f, 1.95692718e-01f, -9.75398533e-03f, 2.24379331e-01f, -2.14490965e-02f, -1.36887968e-01f, 2.50308543e-01f, 7.85188675e-02f, -1.74709454e-01f,
  -1.68267816e-01f, 8.39432031e-02f, 2.46104270e-01f, 1.20693013e-01f, -1.47922307e-01f, 1.86888859e-01f, -3.56430672e-02f, -4.09751944e-02f, -7.46666864e-02f, 2.92904556e-01f,
  8.39860514e-02f, -2.97596119e-02f, 7.67722875e-02f, -1.47408977e-01f, 1.77647874e-01f, -3.81245613e-02f, 1.27114102e-01f, -1.40725285e-01f, -6.14317926e-03f, -2.93284714e-01f,
  -1.69539806e-02f, -1.42744347e-01f, 2.28277102e-01f, -2.11102128e-01f, -2.18028203e-02f, -2.93034256e-01f, -1.63881466e-01f, -6.83705211e-02f, 1.60527617e-01f, 9.70318615e-02f,
  2.62652725e-01f, -7.70900846e-02f, -7.62521550e-02f, 1.81099668e-01f, -5.51111661e-02f, 1.48221910e-01f, -6.30522845e-03f, 1.39937177e-01f, 1.16622150e-01f, 1.59479082e-01f,
  1.02820702e-01f, -8.59586149e-02f, 5.43090925e-02f, 3.17780264e-02f, -1.94166822e-03f, 1.95469260e-01f, -7.17799962e-02f, 1.36729581e-02f, 8.81938487e-02f, -6.17337786e-02f,
  5.17871231e-02f, 1.64489776e-01f, 2.36651003e-02f, 1.20677203e-02f, -1.02898173e-01f, 5.42899780e-02f, 2.44873524e-01f, 1.35560006e-01f, 2.81394154e-01f, -3.63658741e-02f,
  1.13533154e-01f, 2.59234101e-01f, -7.66460821e-02f, 1.50662556e-01f, 2.33963192e-01f, -1.46424621e-01f, -7.81989843e-02f, 1.04678616e-01f, 1.12576872e-01f, 1.64438747e-02f,
  6.30831867e-02f, 1.98003814e-01f, 2.68202126e-01f, 5.81060760e-02f, -3.38439137e-01f, 1.77138008e-03f, -2.36818474e-02f, -3.63498554e-02f, 1.45971164e-01f, 1.84507459e-01f,
  2.19939947e-01f, -4.63755690e-02f, 1.46854326e-01f, -1.35947183e-01f, 1.24740466e-01f, -1.49800345e-01f, 1.62305638e-01f, 6.20586760e-02f, 1.41174644e-01f, 2.00462565e-01f,
  -1.91741541e-01f, 1.88029215e-01f, -2.26232976e-01f, 1.78138718e-01f, 1.46541074e-01f, -5.81471920e-02f, -2.89578848e-02f, 2.21741293e-02f, 2.44023532e-01f, -1.65383741e-01f,
  5.18723018e-02f, -9.89103243e-02f, -7.13397339e-02f, 1.21287353e-01f, -4.37894976e-03f, -4.45620576e-03f, -7.15718418e-03f, 5.78118451e-02f, 5.31743579e-02f, -1.42644033e-01f,
  6.47447854e-02f, -9.11702737e-02f, -3.02469432e-02f, 1.98293962e-02f, -1.13690265e-01f, -5.02068624e-02f, -2.14072987e-02f, -6.42719166e-03f, -2.19199270e-01f, -9.22479853e-02f,
  4.09492403e-02f, -1.93638369e-01f, 2.45826215e-01f, -1.40191361e-01f, 5.58998957e-02f, -2.72513121e-01f, -6.26100879e-03f, 2.21036166e-01f, -2.62051430e-02f, -3.16955209e-01f,
  3.05707037e-01f, 1.71368688e-01f, 5.34485504e-02f, 6.32577762e-02f, -2.30310082e-01f, 2.27373745e-02f, 1.45439416e-01f, 2.01355711e-01f, 1.49786298e-04f, -1.40847296e-01f,
  7.84941316e-02f, 8.78547579e-02f, 1.29035667e-01f, -9.07685459e-02f, 2.51277685e-01f, -1.52316824e-01f, 3.35105717e-01f, 8.80619213e-02f, 1.84267834e-01f, -8.19258764e-02f,
  -1.13097541e-01f, -1.01394109e-01f, -2.47127518e-01f, -3.23708981e-01f, 2.20930532e-01f, 3.90161201e-02f, -9.77205560e-02f, -3.03259939e-01f, -2.53800806e-02f, -3.79266411e-01f,
  1.87706470e-01f, 1.47485193e-02f, 2.65247345e-01f, 1.57680854e-01f, -2.78274808e-02f, -1.28086776e-01f, -6.82488233e-02f, -9.11177248e-02f, -1.31738171e-01f, -4.49681543e-02f,
  9.34625641e-02f, -1.08768798e-01f, 1.51784807e-01f, -2.35027939e-01f, 6.20992109e-02f, -3.80963311e-02f, -1.23922834e-02f, 9.19478685e-02f, -1.67221829e-01f, -5.28959632e-02f,
  1.19309500e-01f, 4.12486121e-02f, 1.79751124e-02f, 3.88789587e-02f, -5.10586984e-02f, -1.85275450e-01f, -2.52226025e-01f, -1.09637611e-01f, -8.57915282e-02f, -2.85668503e-02f,
  1.94805980e-01f, -2.38483340e-01f, -1.97689235e-01f, 1.07971378e-01f, 2.50250578e-01f, 3.08929414e-01f, -9.84355211e-02f, 4.60813195e-02f, -2.27343887e-01f, -6.17421493e-02f,
  -1.08265281e-01f, 7.00083971e-02f, 1.40121341e-01f, -2.78322339e-01f, 2.71577984e-02f, -9.97968093e-02f, -1.60061002e-01f, 4.92907781e-03f, 8.10223892e-02f, 1.24875844e-01f,
  -3.75031903e-02f, -1.28810585e-01f, -2.16100633e-01f, -1.31881192e-01f, 2.42163792e-01f, 5.59423398e-03f, -9.40749124e-02f, -2.90588796e-01f, 3.64752784e-02f, -8.12653899e-02f,
  3.01825553e-01f, 2.61643026e-02f, 8.72861147e-02f, -3.59684341e-02f, 5.98328486e-02f, -1.18562162e-01f, -2.64456064e-01f, 1.29661322e-01f, -1.05697654e-01f, -1.95223757e-03f,
  1.42388642e-01f, 9.70729142e-02f, 6.24949262e-02f, 3.90851945e-02f, 3.32437567e-02f, -4.32710834e-02f, -1.65239722e-01f, 1.04650110e-01f, 1.22477584e-01f, -1.57412320e-01f,
  5.35343774e-02f, -4.34673131e-02f, 1.05186611e-01f, 5.06232791e-02f, -2.28687860e-02f, -6.60078228e-02f, -5.55740632e-02f, 7.85750076e-02f, 2.55038291e-02f, 1.57578677e-01f,
  -7.77665228e-02f, 2.09983930e-01f, 1.42635018e-01f, -1.18685722e-01f, -1.26975715e-01f, 2.23915264e-01f, 2.38987282e-01f, -2.20761448e-01f, -2.23588943e-01f, -2.26611793e-01f,
  1.65235519e-01f, -2.48495251e-01f, 5.43295369e-02f, 4.45442200e-02f, 2.30766013e-01f, -9.38950181e-02f, -1.72467053e-01f, 1.87146381e-01f, -9.11340024e-03f, 9.04214010e-02f,
  -1.42979756e-01f, -1.79409201e-03f, -1.95775628e-01f, -9.96452719e-02f, -1.18640505e-01f, 2.23372355e-01f, 1.93980753e-01f, 2.51071781e-01f, -1.55560851e-01f, -6.27348274e-02f,
  1.90187186e-01f, 1.00724153e-01f, 2.71038175e-01f, 1.06042720e-01f, -6.85992092e-02f, 4.60351892e-02f, -2.56200761e-01f, 3.77326161e-02f, 1.79849207e-01f, 1.22617595e-01f,
  1.14485160e-01f, -2.34992325e-01f, -2.15637967e-01f, 1.47908762e-01f, 1.73846081e-01f, 1.51928857e-01f, 3.43556330e-02f, -1.10321315e-02f, 1.85579807e-01f, -1.13395765e-01f,
  -2.80695837e-02f, 2.93318089e-02f, -1.27092093e-01f, 9.36414450e-02f, -1.79153532e-01f, 2.19526589e-02f, -8.43279436e-02f, 1.30470693e-01f, -1.18865326e-01f, 1.36917010e-01f,
  -1.33429900e-01f, -1.63305581e-01f, 7.92673230e-03f, 4.96574193e-02f, 2.72324812e-02f, 1.54273510e-01f, 9.53377411e-02f, 2.15132147e-01f, 1.71748474e-01f, -1.80476516e-01f,
  -8.76672715e-02f, 3.57473910e-01f, -8.98285061e-02f, -7.67513886e-02f, 4.49541286e-02f, 2.16519356e-01f, -3.52118257e-03f, -1.18138552e-01f, -3.15402411e-02f, 3.17736834e-01f,
  -1.30477801e-01f, 7.23376572e-02f, -2.05847889e-01f, -1.26535520e-01f, 1.16998121e-01f, 1.14381015e-01f, 7.13123903e-02f, -1.52176827e-01f, -1.80686116e-01f, 5.98997064e-03f,
  -1.11200169e-01f, -2.04684347e-01f, 1.86473742e-01f, -8.40586424e-02f, -2.58290973e-02f, -1.57841146e-01f, -1.45527154e-01f, -1.79884613e-01f, 1.58599734e-01f, 2.86032915e-01f,
  1.74840409e-02f, 6.15162887e-02f, 5.60769765e-03f, 2.29901284e-01f, -2.08034828e-01f, -5.98272011e-02f, -9.81025863e-03f, 3.61698456e-02f, 3.27341780e-02f, -4.72545736e-02f,
  2.49997154e-02f, 7.77968988e-02f, -3.37486155e-02f, 4.56534280e-03f, 7.08698183e-02f, -4.78882380e-02f, -4.53791171e-02f, 1.20384619e-01f, 7.31173232e-02f, 2.37738252e-01f,
  1.46612942e-01f, 2.10595027e-01f, 4.39601056e-02f, 9.66300294e-02f, 9.46191102e-02f, -5.58076389e-02f, 4.35300879e-02f, -2.09775671e-01f, 2.45207138e-02f, -2.91402172e-02f,
  -8.23041424e-04f, 6.80394918e-02f, 2.99203992e-01f, -6.63495287e-02f, -1.10233478e-01f, 1.40472621e-01f, 2.08654135e-01f, -3.10515165e-02f, -1.96728542e-01f, 7.06892610e-02f,
  -2.51496106e-01f, 2.51194239e-02f, -1.64028302e-01f, 1.85059413e-01f, 8.99707079e-02f, -7.83975422e-02f, 2.19867676e-01f, -1.49326744e-02f, -1.03615746e-01f, -1.71171501e-01f,
  2.50466615e-01f, 1.57974824e-01f, 1.82714105e-01f, 1.22265756e-01f, -7.57168978e-02f, -1.22430921e-01f, 2.01496273e-01f, -1.07232697e-01f, -3.21030527e-01f, -1.32419199e-01f,
  6.42012954e-02f, -5.70585616e-02f, 2.40938559e-01f, -6.67192861e-02f, 2.01975241e-01f, -5.48114143e-02f, -2.34378412e-01f, 1.98252380e-01f, -2.89162219e-01f, 1.09221771e-01f,
  -6.83984309e-02f, 1.66317165e-01f, -1.61569100e-02f, -5.40385097e-02f, 1.00198105e-01f, 8.85502771e-02f, 1.93718091e-01f, -1.68733299e-01f, 3.13186944e-02f, -3.36625054e-02f,
  4.00748961e-02f, 6.21256307e-02f, -2.18925923e-02f, 1.72574118e-01f, 7.57054836e-02f, -2.15039160e-02f, -1.02092206e-01f, 1.06275111e-01f, 2.94202771e-02f, 5.60946949e-02f,
  -1.05260581e-01f, 1.83145609e-02f, -1.18064642e-01f, 1.20861724e-01f, 2.77812742e-02f, -8.97417078e-04f, -4.45282832e-03f, -2.15048447e-01f, -2.21608102e-01f, 2.09728390e-01f,
  1.36262737e-02f, -1.29910141e-01f, -1.56286687e-01f, 6.32806271e-02f, -1.73097894e-01f, -2.73125589e-01f, -2.39820644e-01f, -3.72106768e-02f, 2.63966411e-01f, 8.77349898e-02f,
  2.07796305e-01f, -1.29643545e-01f, -2.55417764e-01f, 5.70716932e-02f, -3.08127195e-01f, -1.51894629e-01f, -1.32845923e-01f, -6.92789583e-03f, -3.58887576e-02f, 2.78941482e-01f,
  -1.91044539e-01f, -1.04775302e-01f, -1.52208015e-01f, -2.04351634e-01f, -1.35988131e-01f, -1.71221942e-01f, 3.19528878e-01f, 1.62515920e-02f, -1.51129797e-01f, 2.12186456e-01f,
  -7.21229538e-02f, 2.12094396e-01f, -2.34237328e-01f, 2.69768506e-01f, 8.33293870e-02f, -3.31235342e-02f, 2.28769686e-02f, -1.22297511e-01f, -1.17738783e-01f, -1.31924540e-01f,
  -1.77847594e-02f, 7.34633729e-02f, 2.21531704e-01f, -6.23182505e-02f, 1.15820952e-02f, 8.90026018e-02f, -2.36035581e-03f, -1.30363122e-01f, 7.11984560e-02f, 1.70565203e-01f,
  2.22187191e-01f, 1.84475735e-01f, 8.87093768e-02f, 4.66630533e-02f, 2.12318435e-01f, -4.86041754e-02f, 1.23347558e-01f, -2.33132780e-01f, -1.07825510e-02f, 1.95408985e-01f,
  1.04202747e-01f, -1.22929633e-01f, 2.53247559e-01f, -1.69596493e-01f, 4.33925837e-02f, 3.17844212e-01f, 1.14271663e-01f, -4.72861342e-02f, -1.01354897e-01f, 3.35298508e-01f,
  -1.14224337e-01f, 1.04853474e-01f, -1.92167073e-01f, -2.65482128e-01f, -1.46346137e-01f, -1.48732856e-01f, 2.04847619e-01f, -2.01439019e-02f, 1.21252157e-01f, 2.31977716e-01f,
  1.52826905e-01f, -2.05390573e-01f, -4.63697836e-02f, -2.19008222e-01f, 6.65726140e-02f, 2.00229764e-01f, -9.96372551e-02f, 9.66444686e-02f, -1.33583426e-01f, 1.68739095e-01f,
  -1.32098332e-01f, 1.28355458e-01f, 2.74636239e-01f, -1.28993943e-01f, -3.52445692e-02f, -1.46391064e-01f, 2.89523751e-02f, 1.26268163e-01f, -2.30685815e-01f, 2.25420713e-01f,
  2.06788883e-01f, 2.24840567e-01f, 1.70831189e-01f, 5.95619343e-03f, 7.66254887e-02f, 4.35220562e-02f, -3.62931877e-01f, -4.37192582e-02f, -9.70830172e-02f, -1.41998529e-01f,
  -7.34218955e-02f, 3.54384305e-04f, 3.57216299e-02f, -7.65315145e-02f, -1.44358158e-01f, -2.76694745e-01f, -2.15497315e-01f, -2.07845181e-01f, -2.02410370e-01f, 1.61735281e-01f,
  -1.21367916e-01f, 3.47280711e-01f, 1.27186388e-01f, -1.92336351e-01f, 4.16755155e-02f, -4.83398028e-02f, 3.24140266e-02f, 6.41931668e-02f, 3.38901393e-02f, -1.88820988e-01f,
  3.68182100e-02f, -2.19621330e-01f, 1.04016820e-02f, -1.48702888e-02f, 2.80983478e-01f, 2.25850105e-01f, -6.35612756e-02f, 1.84019253e-01f, 1.48530193e-02f, 6.57950714e-02f,
  7.19330311e-02f, 1.97735727e-01f, 8.04893151e-02f, -1.93922102e-01f, -1.24702282e-01f, 9.54324305e-02f, 6.34736344e-02f, 1.58399686e-01f, 1.42846346e-01f, -3.09366435e-01f,
  2.47082844e-01f, -2.19784722e-01f, -5.95119148e-02f, -1.52640864e-01f, -6.89162239e-02f, 4.99049164e-02f, -1.72566533e-01f, 9.87648591e-02f, 2.00737506e-01f, 2.65701652e-01f,
  2.50055082e-02f, -5.50373010e-02f, -2.23245591e-01f, 4.05125357e-02f, -5.56169562e-02f, -1.95841659e-02f, -2.77013122e-03f, -1.22959927e-01f, 1.22753028e-02f, -2.30600759e-01f,
  5.10620475e-02f, 9.62569490e-02f, -3.59026832e-03f, -1.34281144e-01f, 7.46705383e-02f, -9.28282961e-02f, -6.53972328e-02f, 2.53468342e-02f, -1.04637407e-02f, -8.22712630e-02f,
  -1.74030259e-01f, -6.25788048e-02f, -1.22386120e-01f, -5.05145267e-02f, 1.34567231e-01f, 8.05085525e-02f, 1.08845927e-01f, 2.58114878e-02f, -3.08980018e-01f, -1.56375498e-01f,
  1.70220494e-01f, -1.35348320e-01f, -2.01589569e-01f, 1.43602133e-01f, -1.14542626e-01f, 1.19585255e-02f, 1.10050872e-01f, -1.89017355e-02f, 8.08418021e-02f, -8.69889483e-02f,
  -1.11310579e-01f, 1.30949005e-01f, -1.92452788e-01f, -2.06035629e-01f, 6.82941750e-02f, 1.05896682e-01f, -1.56776682e-01f, -2.24250644e-01f, -1.09384716e-01f, -4.69142497e-02f,
  -5.09879626e-02f, -3.59923504e-02f, -9.66090411e-02f, 2.26722866e-01f, 1.22790657e-01f, -9.16928574e-02f, -9.73123610e-02f, -5.35447784e-02f, -3.46341223e-01f, 5.52924015e-02f,
  -1.65014952e-01f, -9.02313888e-02f, 1.96467444e-01f, -2.81802058e-01f, 1.75576463e-01f, 1.65724143e-01f, -2.80355923e-02f, -1.43033102e-01f, -1.06744237e-01f, -1.09261841e-01f,
  7.32696727e-02f, -1.34090751e-01f, -3.36024798e-02f, -2.80854702e-02f, -1.07876174e-02f, -1.16121741e-02f, -3.06912847e-02f, 6.26145676e-02f, -1.52117118e-01f, 8.13301355e-02f,
  1.07301876e-01f, -1.83770806e-01f, 1.84121132e-01f, -3.39896046e-02f, -2.35133655e-02f, -5.25344908e-02f, 1.02812909e-01f, 2.11913049e-01f, -9.73351076e-02f, 1.62732571e-01f,
  1.93779916e-01f, -5.10023050e-02f, -2.01655716e-01f, 1.46475762e-01f, -1.47327244e-01f, -3.78567576e-02f, 1.11142416e-02f, -5.46327829e-02f, 1.15416691e-01f, 1.63670495e-01f,
  -3.11162978e-01f, -4.19163853e-01f, -4.79501188e-02f, 2.11747885e-01f, -1.29635900e-01f, -9.97677967e-02f, -1.30245388e-01f, 3.17894727e-01f, 2.95380950e-01f, -1.69013560e-01f,
  -3.83172929e-02f, -2.22419113e-01f, -1.05706371e-01f, 6.50044531e-02f, 2.62880847e-02f, -1.39376387e-01f, -2.72100836e-01f, -6.60508052e-02f, -2.15905190e-01f, 3.50204222e-02f,
  -1.75637096e-01f, 5.24190702e-02f, 9.85200424e-03f, 1.40869290e-01f, -3.97458300e-02f, -1.28271915e-02f, 2.72400558e-01f, 9.84221846e-02f, 5.05717611e-03f, 8.97472724e-03f,
  2.97997729e-03f, 9.67674479e-02f, -6.20677769e-02f, -7.40755871e-02f, 6.62490353e-02f, 7.59740872e-03f, 9.91105586e-02f, -9.51691568e-02f, 1.18672639e-01f, 6.28625453e-02f,
  4.78775837e-02f, 1.63173601e-01f, -2.80391481e-02f, 5.99703789e-02f, 1.24798557e-02f, -1.81556433e-01f, -4.59880494e-02f, -2.02186089e-02f, -6.67524263e-02f, -6.54914975e-02f,
  -1.76698551e-01f, 8.34389403e-02f, -2.20249575e-02f, 1.53466105e-01f, 2.06005037e-01f, 1.02713197e-01f, -2.91943192e-01f, -5.76793663e-02f, -1.48694262e-01f, 1.29200533e-01f,
  1.18616052e-01f, 3.00496351e-02f, -1.90925509e-01f, 2.41657197e-01f, 2.12808475e-01f, -2.82053709e-01f, -2.39097148e-01f, 2.01726720e-01f, 2.76305318e-01f, 7.84487352e-02f,
  -1.85739264e-01f, -9.90753099e-02f, 3.02757442e-01f, 4.72102761e-02f, -1.60508797e-01f, -2.72241980e-01f, -3.67932208e-02f, -3.02403271e-01f, -7.68896565e-02f, 1.83276489e-01f,
  4.56374846e-02f, 1.00887440e-01f, -9.86858010e-02f, -1.83986545e-01f, -3.75224873e-02f, -1.02163263e-01f, -2.41649240e-01f, 1.89921275e-01f, -1.10822702e-02f, 5.03065325e-02f,
  5.41092344e-02f, 1.60267517e-01f, -1.94750763e-02f, 2.29946747e-02f, -1.53889194e-01f, -1.68898284e-01f, 3.02619562e-02f, -5.52335940e-02f, -1.03710242e-01f, 3.40035409e-02f,
  8.42362642e-02f, 3.24278325e-02f, 1.03024766e-01f, -4.96210232e-02f, -1.34026678e-03f, -2.11697333e-02f, 5.94070144e-02f, -1.67214677e-01f, -1.93621367e-01f, 2.38007382e-02f,
  -1.56447906e-02f, 9.98844299e-03f, 7.53676295e-02f, -5.74752204e-02f, -7.06880465e-02f, -4.12569717e-02f, -2.20653713e-02f, -2.51243263e-02f, 1.36408225e-01f, -4.18395037e-03f,
  -6.68206066e-02f, -5.32137901e-02f, 7.12125897e-02f, -1.49904326e-01f, -1.60702914e-01f, 2.57695049e-01f, -6.47883266e-02f, -8.66645724e-02f, 2.92422861e-01f, 1.38531193e-01f,
  1.71291396e-01f, -4.61179996e-03f, 7.14518204e-02f, 3.68349925e-02f, -4.92312089e-02f, -2.74057448e-01f, -5.08163720e-02f, 2.26012856e-01f, -2.29772463e-01f, -1.55946761e-01f,
  2.55238339e-02f, -1.68861106e-01f, 7.17646107e-02f, 7.04289302e-02f, -2.02666558e-02f, 2.34215543e-01f, 3.13038602e-02f, -4.28546295e-02f, -7.02565312e-02f, -1.24136284e-02f,
  -2.84465760e-01f, 1.66285798e-01f, -4.38077338e-02f, -5.67022264e-02f, 1.42265588e-01f, -2.63749242e-01f, 1.30576327e-01f, 2.17595175e-02f, 5.80272563e-02f, 1.12572558e-01f,
  1.82618678e-01f, 2.02347934e-01f, 2.46204659e-02f, 8.01366661e-03f, 5.67172142e-03f, -2.08435021e-02f, -9.46785212e-02f, 2.24620029e-01f, 8.05673078e-02f, -3.68763506e-03f,
  1.18445434e-01f, -4.52224575e-02f, 2.94891354e-02f, 1.12737268e-02f, 8.47491622e-02f, -3.76918726e-02f, -6.25794157e-02f, 1.32351797e-02f, 1.24427620e-02f, -9.99939814e-02f,
  2.01876894e-01f, 3.62067893e-02f, 2.53912598e-01f, -1.14617847e-01f, -1.22212410e-01f, 2.17406005e-01f, 2.27240458e-01f, -2.76689976e-01f, -2.42079780e-01f, -2.31074437e-01f,
  1.23286143e-01f, -9.13016796e-02f, 2.14600861e-01f, 1.46848056e-02f, 2.83059031e-01f, -1.64121822e-01f, -1.40847251e-01f, 2.00514913e-01f, -1.87833875e-01f, 5.07418066e-02f,
  1.16757974e-01f, -2.03172401e-01f, 1.05283827e-01f, -1.09002471e-01f, 1.83999568e-01f, 1.79045007e-01f, 2.49921605e-01f, 2.38813639e-01f, -2.37016916e-01f, 1.17022544e-01f,
  -1.39701113e-01f, 9.81340706e-02f, 2.79897094e-01f, 2.59860530e-02f, -1.66426763e-01f, -1.02939701e-03f, -1.72894612e-01f, -6.60225525e-02f, 2.07373127e-01f, 1.00528650e-01f,
  1.66983306e-01f, -3.47021818e-01f, -8.03188980e-03f, 8.77171084e-02f, -5.59547804e-02f, -1.69345737e-02f, -1.63735494e-01f, 2.78154522e-01f, -9.12359878e-02f, 1.57362875e-02f,
  1.76496450e-02f, 5.32506816e-02f, -1.50429845e-01f, 3.32964249e-02f, 1.54749900e-01f, -4.82311882e-02f, -2.03689814e-01f, 1.44196197e-01f, -1.99595511e-01f, 4.03225124e-02f,
  6.27530739e-02f, 1.24228895e-01f, -1.63709387e-01f, -2.46633470e-01f, 7.09437504e-02f, -2.96478301e-01f, -1.86842009e-02f, -1.70999721e-01f, 8.81932974e-02f, -3.02163530e-02f,
  -7.69390315e-02f, -2.34612860e-02f, -2.07696438e-01f, 2.05764100e-01f, 3.11884675e-02f, 1.58518791e-01f, 3.20185542e-01f, 7.78722167e-02f, 4.35112119e-02f, -2.34719485e-01f,
  2.24518239e-01f, 3.98509800e-02f, 2.32083470e-01f, -1.37994587e-01f, -3.69464844e-01f, 9.41334739e-02f, 1.41385898e-01f, 1.69992745e-01f, 1.06748998e-01f, 2.53396984e-02f,
  4.60885353e-02f, 2.54704393e-02f, 4.93378006e-02f, 2.13130757e-01f, 8.15170538e-03f, -1.81316108e-01f, 3.11193854e-01f, -1.32511675e-01f, -2.23735534e-02f, -2.35576376e-01f,
  -1.69499621e-01f, -8.69444683e-02f, -1.60698276e-02f, -2.38399506e-01f, 4.12715785e-02f, 1.96387380e-01f, -1.89812273e-01f, 1.26141369e-01f, 9.20512751e-02f, -9.09448788e-02f,
  -2.30101608e-02f, 1.05235070e-01f, 3.10984929e-03f, -1.16624728e-01f, -1.65512055e-01f, -3.08015384e-02f, 1.26566842e-01f, -1.38797924e-01f, -1.56011609e-02f, -1.19572952e-01f,
  -2.53756166e-01f, 7.40600601e-02f, -2.70862430e-01f, -5.06386310e-02f, 1.03352010e-01f, -5.14567010e-02f, -5.77927241e-03f, -2.90543977e-02f, -6.07491545e-02f, 7.19103739e-02f,
  -1.38258860e-01f, -8.00654739e-02f, -1.34036522e-02f, -1.73130050e-01f, -7.69718066e-02f, 9.76165533e-02f, -1.42223895e-01f, 1.26393542e-01f, -9.53105390e-02f, 1.14766825e-02f,
  2.73030221e-01f, -1.50517762e-01f, 9.40156430e-02f, -1.36922792e-01f, 1.19319305e-01f, 1.55874029e-01f, 1.38015494e-01f, -2.34909073e-01f, -3.37392956e-01f, 2.87455559e-01f,
  -1.72131225e-01f, -8.11399445e-02f, -1.75528109e-01f, -5.72363567e-03f, 5.13124913e-02f, 9.21816975e-02f, -1.99198812e-01f, 1.88327068e-03f, 2.44708657e-01f, -1.69801041e-01f,
  1.87890917e-01f, -1.97805226e-01f, 2.49181036e-02f, 7.63434963e-03f, -1.36651218e-01f, 1.22822970e-01f, 9.52610299e-02f, -5.08594178e-02f, 1.85347404e-02f, 2.33282879e-01f,
  3.03810630e-02f, -1.20268762e-01f, 1.52019542e-02f, -1.75477996e-01f, 7.43778571e-02f, 9.81052294e-02f, 2.28506438e-02f, -6.37617186e-02f, -1.09665647e-01f, 1.36258021e-01f,
  -8.75162135e-04f, -5.77934310e-02f, 1.25423178e-01f, -6.93423674e-02f, 1.69670880e-01f, -3.32937449e-01f, 4.77713570e-02f, -1.04580365e-01f, -5.86092845e-02f, 8.10585395e-02f,
  -2.59768784e-01f, 2.45084360e-01f, -1.87687635e-01f, 3.02683353e-01f, 9.95850638e-02f, -2.72831500e-01f, -1.99008226e-01f, 1.12249367e-01f, 1.31775618e-01f, -5.60615622e-02f,
  -1.90145493e-01f, -2.85543859e-01f, 1.80755779e-01f, -2.17324004e-01f, 5.06897122e-02f, 2.26203680e-01f, 1.49422318e-01f, -2.85975605e-01f, -1.95158571e-01f, 7.60596804e-03f,
  -1.15677610e-01f, 1.30273327e-01f, 8.33168030e-02f, 1.41178900e-02f, 2.72973888e-02f, 1.01045622e-02f, -1.43114328e-01f, 2.97630757e-01f, 1.26204401e-01f, 4.18449230e-02f,
  -4.25441563e-02f, 1.31693989e-01f, 1.47133380e-01f, 3.17327380e-01f, 6.73025697e-02f, 1.35479763e-01f, -1.87665775e-01f, -1.44115001e-01f, -1.82192534e-01f, 1.27634719e-01f,
  2.51919031e-01f, 9.82128382e-02f, 2.34746456e-01f, -1.03944398e-01f, 2.45425522e-01f, 5.82431704e-02f, -4.89526689e-02f, -1.13569563e-02f, -1.94499493e-01f, -1.34815834e-02f,
  4.57217824e-03f, 3.06385811e-02f, 7.85120130e-02f, 4.86349277e-02f, -7.48040900e-02f, 2.22500023e-02f, -1.13031836e-02f, 1.40787959e-01f, 1.96045846e-01f, 1.36450782e-01f,
  1.31254449e-01f, 1.37597233e-01f, 8.08028653e-02f, -1.09260706e-02f, 3.46238874e-02f, -6.82437122e-02f, 1.36911482e-01f, -7.96104372e-02f, 1.28001869e-02f, -7.39499629e-02f,
  3.02813113e-01f, 1.47612706e-01f, 1.70547783e-01f, -4.96523976e-02f, 8.83878097e-02f, 9.83640328e-02f, 1.87909096e-01f, 2.36372918e-01f, -7.84809664e-02f, -1.30220741e-01f,
  -1.41995981e-01f, 2.05721349e-01f, 5.47941588e-02f, -1.85338527e-01f, -1.25317380e-01f, 2.33290777e-01f, 2.95281500e-01f, -2.38097325e-01f, 3.19061428e-01f, 1.08408555e-01f,
  3.20835441e-01f, 1.07947558e-01f, 1.24574855e-01f, -1.09294072e-01f, 1.01909876e-01f, 6.70511201e-02f, -3.02548319e-01f, -1.23579167e-01f, 2.39497244e-01f, 9.49416757e-02f,
  9.82103422e-02f, -7.39015937e-02f, 1.64968476e-01f, -2.29465663e-01f, 5.32807931e-02f, 1.70681715e-01f, 1.80555303e-02f, -6.84164390e-02f, -1.77379414e-01f, 2.78733112e-02f,
  1.75005898e-01f, -1.96248189e-01f, -1.65965572e-01f, 6.65418506e-02f, -1.09776996e-01f, -2.56903708e-01f, -2.32276395e-01f, -8.92698467e-02f, -4.80086617e-02f, -2.26026163e-01f,
  1.07773341e-01f, -2.07719430e-01f, -1.31185174e-01f, -2.63812304e-01f, -8.17405730e-02f, -1.05580539e-01f, 4.34486642e-02f, 7.52244294e-02f, -1.23395495e-01f, 9.56094489e-02f,
  -3.94364268e-01f, 1.81676865e-01f, 1.65591776e-01f, -8.68057907e-02f, -6.46337345e-02f, -6.84341649e-03f, -1.44294143e-01f, 2.95628250e-01f, -2.80095726e-01f, -1.47952974e-01f,
  1.54763803e-01f, -6.29854798e-02f, 1.01499788e-01f, -5.46872839e-02f, -1.16240971e-01f, -2.05833063e-01f, -8.14498961e-02f, -6.26736227e-03f, -1.39977679e-01f, -2.81578097e-02f,
  -5.89246601e-02f, 1.19508445e-01f, -2.25961939e-01f, -9.39061791e-02f, -2.20227897e-01f, 9.38655883e-02f, -1.90949351e-01f, 4.41015512e-02f, -7.46401101e-02f, 4.16675285e-02f,
  1.61074176e-01f, 1.51040509e-01f, 7.66294226e-02f, -2.11756095e-01f, 1.51461616e-01f, 6.87524825e-02f, -1.37049049e-01f, 1.55852780e-01f, 2.34618336e-01f, -2.14669650e-04f,
  -2.19423115e-01f, 5.85656054e-02f, 1.96666583e-01f, -2.20948189e-01f, -7.80895352e-02f, -1.75699428e-01f, -1.07621238e-01f, 1.38654411e-01f, -1.41208798e-01f, 1.59441084e-02f,
  2.09564775e-01f, -6.05590455e-02f, -1.12473674e-03f, -2.02133544e-02f, 2.16831073e-01f, 4.95953560e-02f, 1.37855843e-01f, -8.91273320e-02f, 6.77386746e-02f, 5.92535399e-02f,
  2.48050764e-01f, 1.91876963e-01f, -6.50303587e-02f, 3.39134522e-02f, -4.96957041e-02f, -2.59782583e-01f, -1.44999146e-01f, -1.11227743e-01f, 1.62240900e-02f, 2.35591546e-01f,
  -1.99855596e-01f, -1.22711234e-01f, 3.28589580e-04f, -9.86371189e-03f, 1.97246969e-01f, -1.09848894e-01f, -2.29970396e-01f, 3.99884619e-02f, -1.18306912e-01f, -2.47110322e-01f,
  9.38732699e-02f, -2.03666091e-01f, 1.37025282e-01f, 9.30764303e-02f, -1.15372710e-01f, -2.15803877e-01f, -5.92843592e-02f, 3.04145455e-01f, 1.78774091e-04f, 1.73540577e-01f,
  1.26717851e-01f, -8.06410015e-02f, -1.89972013e-01f, 1.50895819e-01f, -2.34588519e-01f, 2.56159484e-01f, 2.52295673e-01f, 2.42429003e-01f, 1.56072438e-01f, -1.38367414e-01f,
  4.44773119e-04f, 7.28585348e-02f, 3.94626185e-02f, -3.29800755e-01f, -1.08941317e-01f, -1.54725527e-02f, 1.37488112e-01f, -9.45413113e-02f, 6.24271482e-02f, 1.81945264e-01f,
  -9.21556428e-02f, -1.18326887e-01f, -4.11212109e-02f, 2.01193482e-01f, -9.78050102e-03f, -8.87412950e-03f, -1.01343237e-01f, 1.00582093e-01f, 7.93739855e-02f, -6.19680509e-02f,
  1.95033476e-01f, 3.66835333e-02f, 1.44120350e-01f, 1.15999959e-01f, 6.96252957e-02f, -6.11828826e-02f, 6.73928261e-02f, -5.23015531e-03f, 2.08816022e-01f, -2.81352792e-02f,
  6.96228370e-02f, 1.29775584e-01f, 7.09551945e-02f, 2.23225027e-01f, 2.87940949e-01f, -1.00296721e-01f, 5.01532406e-02f, -3.54806781e-02f, 2.01181486e-01f, 3.36416811e-02f,
  1.83758084e-02f, 1.88312024e-01f, 1.13784738e-01f, 1.21422142e-01f, -1.99927419e-01f, -1.84257731e-01f, -1.71159189e-02f, 2.10389078e-01f, 1.83661059e-01f, -1.56521574e-01f,
  2.83079237e-01f, 1.62912965e-01f, 2.05560997e-01f, -6.70095831e-02f, 3.11036035e-02f, -1.52146608e-01f, 1.63795486e-01f, 1.52026311e-01f, -4.03571017e-02f, 1.44798249e-01f,
  1.44757271e-01f, 2.23785385e-01f, -2.09885284e-01f, -7.85201136e-03f, 2.67568737e-01f, -9.00561139e-02f, -7.07967877e-02f, -1.42979771e-01f, 1.28371596e-01f, -2.89443254e-01f
};

// L1_fan_Wp_bar (Shape: 14 x 64)
const int L1_fan_Wp_bar_rows = 14;
const int L1_fan_Wp_bar_cols = 64;
const float L1_fan_Wp_bar_data[] = {
  -1.61734715e-01f, 1.28377303e-01f, 2.66975820e-01f, 1.06745519e-01f, 1.81459233e-01f, 2.68750787e-01f, 3.27318937e-01f, 2.62664497e-01f, 1.46236077e-01f, 1.16049901e-01f,
  3.87027055e-01f, 1.78710416e-01f, 3.30514103e-01f, 2.34007556e-02f, 1.08592413e-01f, -1.42854974e-02f, 1.69814616e-01f, 1.56447832e-02f, 1.23893455e-01f, 2.00819358e-01f,
  5.87854870e-02f, 4.34584737e-01f, 8.20784271e-02f, 4.32620525e-01f, 1.98755726e-01f, 4.23559725e-01f, -5.62524974e-01f, -3.09370160e-01f, 3.90417650e-02f, 3.62066269e-01f,
  -5.14779508e-01f, -1.09042615e-01f, -2.81468689e-01f, -5.42157106e-02f, 3.27828795e-01f, -4.08774674e-01f, 2.10870624e-01f, -4.08731163e-01f, -3.92128825e-01f, 5.04147589e-01f,
  -2.60119498e-01f, -2.54935533e-01f, 3.24609071e-01f, 4.64021951e-01f, -4.31351393e-01f, -4.16306317e-01f, -2.41722271e-01f, -4.33600456e-01f, -2.05488756e-01f, 2.74883598e-01f,
  2.20075697e-01f, 4.78107482e-01f, 2.44710520e-01f, 4.03914005e-01f, 2.27447122e-01f, -7.92030022e-02f, -3.86544377e-01f, 8.47607911e-01f, -2.83048619e-02f, 3.25957388e-01f,
  6.41115785e-01f, -2.22214341e-01f, 2.21338183e-01f, -5.19990958e-02f, 3.91400337e-01f, 1.29740655e-01f, 1.74029797e-01f, 1.99003279e-01f, 9.17657837e-02f, 2.70389974e-01f,
  4.61305492e-03f, 3.21594566e-01f, 1.19911484e-01f, 3.04103017e-01f, 1.23096526e-01f, 1.60007149e-01f, 3.44368629e-02f, 1.89972430e-01f, 1.85765028e-01f, 2.56051213e-01f,
  1.27571762e-01f, 2.03163058e-01f, 1.72330022e-01f, 1.60126820e-01f, 1.70922458e-01f, 2.00983405e-01f, 3.66672933e-01f, 5.20570241e-02f, 6.98040798e-02f, -3.04371268e-01f,
  1.57241449e-01f, 6.26660645e-01f, 2.68784165e-01f, 2.46819392e-01f, -3.64266969e-02f, -3.06253552e-01f, 4.19341922e-01f, 1.46328241e-01f, -1.44905940e-01f, -1.89345852e-01f,
  6.71140775e-02f, 2.04297937e-02f, -2.69727677e-01f, 4.03167196e-02f, -2.19982415e-01f, 4.70809340e-01f, 1.64904073e-01f, -5.69585621e-01f, 6.80307448e-01f, 3.55285078e-01f,
  4.34615642e-01f, 2.65819848e-01f, 2.79766470e-01f, -2.54628211e-01f, 3.12319934e-01f, 2.38127157e-01f, 1.08978055e-01f, 4.64510024e-01f, 6.28588200e-01f, 4.39373761e-01f,
  1.57480374e-01f, -2.87374169e-01f, 2.08254144e-01f, -1.28729597e-01f, 3.39815587e-01f, 7.15250850e-01f, 6.69759661e-02f, -1.36480302e-01f, 4.96269435e-01f, -2.73279790e-02f,
  -2.01226592e-01f, -1.34814888e-01f, 2.33046100e-01f, 6.97274730e-02f, 2.04067469e-01f, 1.70403033e-01f, 5.68446040e-01f, 1.38496250e-01f, 2.94299424e-01f, 2.89669156e-01f,
  2.57118732e-01f, 3.54201794e-01f, 3.13953817e-01f, 4.42436010e-01f, 3.15399706e-01f, 5.10278761e-01f, 5.52945018e-01f, 3.23576659e-01f, 2.86028832e-01f, 1.38124069e-02f,
  3.31834555e-01f, -2.16301888e-01f, 9.29997116e-02f, 3.15525174e-01f, 2.12484151e-01f, 4.92965579e-02f, -4.49328303e-01f, 1.54701443e-02f, 1.12199344e-01f, 2.60886520e-01f,
  -2.32782826e-01f, 5.17711416e-02f, -1.98520601e-01f, -2.97602355e-01f, -5.83369553e-01f, -2.51145393e-01f, 4.31617200e-01f, -2.48932336e-02f, 5.04615188e-01f, -4.74362373e-02f,
  -1.20590627e-01f, -2.56511331e-01f, -3.03294539e-01f, -9.43003315e-03f, 2.39610642e-01f, -6.73728064e-02f, 1.19783198e-02f, 3.60475123e-01f, -4.26738888e-01f, 9.71196294e-02f,
  -5.20948112e-01f, 2.06921160e-01f, 3.92400362e-02f, 6.12353623e-01f, 4.75455344e-01f, 3.80555727e-02f, -1.72841832e-01f, 3.67324084e-01f, -2.90711313e-01f, -3.36043626e-01f,
  -3.92414272e-01f, 3.42985690e-01f, -1.02273531e-01f, 9.01241675e-02f, -3.26197036e-03f, -1.99753083e-02f, -1.01680182e-01f, 2.76376493e-02f, -3.47247859e-03f, -1.26814932e-01f,
  -3.93351093e-02f, 7.77804554e-02f, -5.73223159e-02f, -1.05846576e-01f, 4.72469777e-02f, -6.94897249e-02f, -8.06089118e-02f, -4.54296730e-02f, -3.73704880e-02f, -7.02271909e-02f,
  2.57003456e-02f, 3.11601739e-02f, -3.95146711e-03f, -7.07093254e-02f, -1.04658857e-01f, -2.74420367e-03f, -6.48179725e-02f, 1.21418349e-02f, -3.79078425e-02f, -1.79349240e-02f,
  7.96248168e-02f, 3.74108776e-02f, -4.95550521e-02f, 9.28653255e-02f, 2.18091141e-02f, -5.70310913e-02f, 8.36308822e-02f, -2.57565919e-02f, 8.20859894e-02f, 6.28077239e-02f,
  3.43617015e-02f, -9.51038674e-02f, 7.38201290e-02f, 8.89698118e-02f, -9.10394639e-02f, -6.53475598e-02f, -1.44990757e-02f, -1.56937502e-02f, -1.38729280e-02f, -7.96486884e-02f,
  -1.31467953e-02f, 9.88747552e-02f, -1.48277164e-01f, 2.44501121e-02f, -1.26869634e-01f, -7.09817335e-02f, -1.21089675e-01f, -1.27197504e-01f, 1.94478612e-02f, -6.29211357e-03f,
  -1.91672333e-02f, -1.07784770e-01f, 1.97280087e-02f, -2.77722124e-02f, -1.20473564e-01f, -1.32368663e-02f, -1.52122661e-01f, -9.41921491e-03f, -2.96939164e-02f, -1.17598981e-01f,
  -2.42858887e-01f, 7.95589238e-02f, -2.72619307e-01f, -6.68364316e-02f, 2.06207052e-01f, -1.03783719e-01f, 2.55652219e-01f, -1.08152851e-02f, 1.10223688e-01f, -9.71275494e-02f,
  -2.87782729e-01f, 4.39466417e-01f, -1.05510026e-01f, 9.51472595e-02f, -5.78191951e-02f, 1.72462150e-01f, 5.01606643e-01f, -6.09555505e-02f, 3.67805719e-01f, -1.35895118e-01f,
  -2.21459240e-01f, 7.83470944e-02f, 3.32190573e-01f, -5.53675778e-02f, -1.51065648e-01f, 4.17939752e-01f, 7.13490248e-02f, 8.50363672e-01f, 3.63727570e-01f, 3.83684576e-01f,
  -1.21087626e-01f, -3.06041360e-01f, -3.22999150e-01f, 3.22187036e-01f, 1.68808535e-01f, -5.31394005e-01f, 6.09860197e-02f, -4.79601890e-01f, -7.50369802e-02f, -5.82608655e-02f,
  3.44436526e-01f, 8.84627625e-02f, -3.66950966e-02f, -2.38095239e-01f, -1.73464164e-01f, -6.03518069e-01f, 2.40136832e-01f, 7.13710010e-01f, 2.25031257e-01f, -2.89291680e-01f,
  -3.09191048e-02f, 2.37097219e-01f, 3.31219673e-01f, -3.84359300e-01f, 3.72275114e-01f, -7.76318461e-02f, -1.48236737e-01f, -3.15952063e-01f, 5.01064718e-01f, 4.44637179e-01f,
  2.01252043e-01f, 1.41805157e-01f, -1.81236640e-01f, -7.66353980e-02f, 1.66898683e-01f, -1.09419614e-01f, 2.05066074e-02f, 1.16657823e-01f, 2.68229425e-01f, -4.74190414e-02f,
  2.00083002e-01f, 3.02535206e-01f, -2.06140906e-01f, 3.00262451e-01f, 1.94451977e-02f, 1.42257959e-01f, 2.41198719e-01f, 1.03484437e-01f, -9.93336737e-02f, -5.53462431e-02f,
  4.48134840e-01f, 3.30543995e-01f, 2.65017092e-01f, 1.34970993e-01f, 1.60714820e-01f, -1.22681923e-01f, -3.08053762e-01f, 1.40948683e-01f, -2.81433821e-01f, 5.23294928e-03f,
  3.32470298e-01f, 2.03329608e-01f, 4.06117290e-01f, 3.22971135e-01f, -5.67273498e-01f, -5.82440972e-01f, -4.73246455e-01f, 3.89995009e-01f, -2.25873634e-01f, -3.38912040e-01f,
  1.66293189e-01f, 3.25098097e-01f, 4.78584290e-01f, -2.22447619e-01f, -2.20582467e-02f, -3.81970555e-01f, -2.00936750e-01f, -3.84897068e-02f, -1.40062869e-01f, -3.63325864e-01f,
  -1.59798309e-01f, 2.31699288e-01f, 7.12228492e-02f, 2.20799685e-01f, -4.28899795e-01f, 3.72410178e-01f, 3.04374844e-01f, -2.11159036e-01f, 1.63754076e-01f, 8.23226795e-02f,
  3.33205611e-02f, 4.97209042e-01f, 4.59724188e-01f, 4.25807565e-01f, 1.72685221e-01f, 4.16121781e-01f, 6.02530465e-02f, 4.17373963e-02f, 1.93367109e-01f, 4.44696486e-01f,
  1.89678609e-01f, 1.07895181e-01f, 2.82352418e-01f, 1.82986245e-01f, 6.17763735e-02f, 3.72430235e-01f, 1.33303285e-01f, 3.01393569e-01f, 5.73333576e-02f, 3.19586881e-02f,
  7.56016150e-02f, 1.99545734e-02f, 2.67646253e-01f, 1.72791421e-01f, 9.76831988e-02f, -2.36486848e-02f, -8.77732411e-02f, 3.79193462e-02f, 1.66898116e-01f, -2.21609622e-01f,
  3.74299772e-02f, -4.25127685e-01f, -4.40944701e-01f, 2.18947694e-01f, 1.28886104e-01f, -3.38810533e-01f, -1.19266748e-01f, 1.12273119e-01f, 9.67837423e-02f, 5.82747199e-02f,
  -3.27634573e-01f, 2.90882766e-01f, 6.10967994e-01f, -6.14379011e-02f, 3.35687220e-01f, -6.50459975e-02f, -3.36899191e-01f, 2.20830128e-01f, 1.70445725e-01f, 1.31045267e-01f,
  2.14641076e-02f, -1.06737744e-02f, -3.29861462e-01f, -9.72984731e-03f, 5.65466642e-01f, 2.86453307e-01f, 5.91541007e-02f, -5.17945707e-01f, 1.98975131e-01f, -2.68190593e-01f,
  2.84851640e-01f, 1.44621491e-01f, 3.04234833e-01f, 3.12903762e-01f, -2.87589021e-02f, 4.97110963e-01f, 2.58861691e-01f, 4.47712123e-01f, -1.14416316e-01f, 2.35153556e-01f,
  3.94738823e-01f, 2.58866310e-01f, 2.56885856e-01f, 3.08813423e-01f, 2.85965711e-01f, 2.31841251e-01f, 1.39009774e-01f, 3.45933557e-01f, -9.57981276e-04f, 2.59213924e-01f,
  4.12571609e-01f, 7.70090297e-02f, 1.53274119e-01f, 5.63216843e-02f, 3.61590356e-01f, 1.43638372e-01f, 2.61739641e-01f, 1.01005703e-01f, 1.91262230e-01f, 8.82830694e-02f,
  1.37579128e-01f, 3.00773650e-01f, 1.54420048e-01f, 2.78138369e-01f, 1.18473291e-01f, -1.45879939e-01f, 5.56386352e-01f, -8.99519995e-02f, -2.34697312e-01f, -2.72560954e-01f,
  -4.61086720e-01f, -5.92931271e-01f, 4.64594215e-01f, 6.21925056e-01f, 2.21526489e-01f, -3.79014492e-01f, -2.48589441e-01f, 9.68515649e-02f, -1.91549450e-01f, -2.58217782e-01f,
  -1.75525337e-01f, 4.67261374e-01f, -2.23961696e-01f, 2.78475046e-01f, 3.70428301e-02f, -1.43179834e-01f, -2.49229558e-02f, 4.15374070e-01f, 5.53721905e-01f, -1.10977411e-01f,
  2.65257806e-01f, 4.66286749e-01f, -1.45052001e-01f, 4.09184188e-01f, 1.18742667e-01f, 5.05351424e-01f, 4.10248011e-01f, 2.25415170e-01f, 1.94400456e-02f, -1.04361713e-01f,
  -1.93538010e-01f, -4.00663167e-01f, 3.11365008e-01f, 2.77057469e-01f, -1.33240715e-01f, 1.47444516e-01f, 1.39447898e-01f, 1.76122695e-01f, -1.01056397e-02f, 2.43553251e-01f,
  1.28687441e-01f, 2.36369327e-01f, 1.70957133e-01f, 8.00632983e-02f, 6.50889277e-02f, 2.86569539e-02f, 8.43248591e-02f, 2.75017917e-01f, 5.42987362e-02f, 6.97161779e-02f,
  1.55557960e-01f, 2.21890688e-01f, 2.77144670e-01f, 2.71055102e-01f, 2.60819912e-01f, 4.25112136e-02f, 1.68916717e-01f, 9.45894942e-02f, -4.38021630e-01f, 3.08260530e-01f,
  2.36685187e-01f, -5.08331776e-01f, -2.51262903e-01f, -2.35709086e-01f, -2.05765754e-01f, -3.85957748e-01f, 3.34147550e-02f, 3.40335906e-01f, 2.99252242e-01f, -5.53654194e-01f,
  -3.30922902e-01f, 6.72557652e-02f, 3.14233035e-01f, 6.82110637e-02f, -2.95156300e-01f, 3.39503020e-01f, -4.58721757e-01f, 1.19704686e-01f, 1.40054552e-02f, 1.79277241e-01f,
  2.79606342e-01f, 3.43955725e-01f, -2.85981566e-01f, 5.11805534e-01f, 5.55376530e-01f, 6.44019604e-01f, -1.79615438e-01f, 3.89991492e-01f, -2.85854638e-01f, -3.51363271e-02f,
  -6.22987971e-02f, 3.67362350e-01f, -1.32465482e-01f, 7.76695237e-02f, 3.01454842e-01f, 1.03256226e-01f, 6.66607246e-02f, -1.91600233e-01f, 8.64068232e-03f, -4.29995209e-01f,
  -7.10859969e-02f, 9.35329199e-02f, 2.99441963e-01f, -2.79800236e-01f, 7.55607262e-02f, 4.00868542e-02f, 1.18443780e-01f, -1.64006114e-01f, 2.26519451e-01f, 1.01370886e-01f,
  1.78587854e-01f, -4.05121565e-01f, 2.00010046e-01f, -6.30885437e-02f, 2.99316078e-01f, 1.40658036e-01f, -2.48978928e-01f, -9.92457033e-04f, -4.62935477e-01f, 2.10695952e-01f,
  9.90140811e-02f, -3.61074865e-01f, 1.11428298e-01f, -4.19685572e-01f, -4.50312763e-01f, 4.93364558e-02f, 3.63990754e-01f, -1.14828333e-01f, 1.22585654e-01f, -6.21340461e-02f,
  -4.57584500e-01f, -2.22252622e-01f, -4.55612302e-01f, -1.74429584e-02f, 2.02569440e-01f, -3.95373464e-01f, 2.30695307e-01f, 1.78412467e-01f, -1.18088230e-01f, -1.43566132e-01f,
  -4.60964620e-01f, 1.65304467e-01f, -7.11131990e-01f, 4.37371314e-01f, -4.07864988e-01f, 2.89524674e-01f, -2.31467858e-01f, 6.65629655e-02f, -2.15096474e-01f, -2.07101647e-02f,
  -1.85131684e-01f, -9.07778144e-02f, 5.29594123e-01f, -2.92113900e-01f, -2.85913885e-01f, 4.74217325e-01f, 6.67152647e-03f, 6.33553341e-02f, -2.30261028e-01f, 5.17524183e-01f,
  1.80657715e-01f, 1.30686074e-01f, 1.78693578e-01f, -1.14155971e-01f, 1.70528248e-01f, 2.69061327e-01f, -2.32107379e-02f, -1.73153624e-01f, 2.08621956e-02f, 1.97216332e-01f,
  -2.44047400e-03f, 4.01910618e-02f, 4.78663109e-02f, 1.38008729e-01f, 1.22162171e-01f, 6.52678013e-02f, -6.62509724e-02f, 2.28922199e-02f, 2.47198041e-03f, 1.96952373e-01f,
  1.59352794e-01f, 4.50498937e-03f, -1.96488082e-01f, 3.14851522e-01f, 2.39289775e-02f, -3.33454102e-01f, -5.22065461e-02f, 9.59100798e-02f, -1.21617034e-01f, 9.22332779e-02f,
  -3.43011022e-02f, -5.37963212e-01f, 2.78445989e-01f, 3.42172310e-02f, 8.85851495e-03f, 2.98572004e-01f, -6.24989569e-02f, -1.00898623e-01f, -2.43670732e-01f, -2.18149468e-01f,
  1.06489256e-01f, 3.25034589e-01f, -9.64905545e-02f, 2.64668554e-01f, 3.85895759e-01f, 3.25786084e-01f, -3.60884130e-01f, 4.82379258e-01f, 1.30673489e-02f, 2.00518314e-02f,
  6.02231860e-01f, 5.10381877e-01f, 5.04336238e-01f, 5.70999026e-01f, -4.96258587e-02f, -8.10299739e-02f, 9.12688300e-02f, -2.94768829e-02f, 2.84255594e-01f, 2.16841653e-01f,
  -1.37287274e-01f, 5.88304937e-01f, 2.03553692e-01f, 2.04380274e-01f, 4.11793500e-01f, 2.43156672e-01f, -8.15898851e-02f, 1.03744254e-01f, 1.78452775e-01f, 3.05198222e-01f,
  2.29780480e-01f, 1.70497715e-01f, 2.38393188e-01f, 2.81554461e-01f, -7.33271167e-02f, 2.04504758e-01f, 2.40619510e-01f, 3.76727760e-01f, 3.87703449e-01f, 4.27476391e-02f,
  2.48394921e-01f, 1.41132236e-01f, 6.80537103e-03f, -8.44006166e-02f, -1.24260835e-01f, -3.13294269e-02f, 3.48440588e-01f, -2.64126621e-02f, 2.06918940e-01f, -4.48592454e-01f,
  -1.39944836e-01f, 2.23755121e-01f, -2.26598874e-01f, -5.65892518e-01f, 3.24396163e-01f, -2.85334229e-01f, -1.78720146e-01f, -5.08916602e-02f, -7.22920373e-02f, -2.06062868e-01f,
  8.13004896e-02f, -3.31773944e-02f, 4.19689983e-01f, 1.67078748e-01f, 1.62632748e-01f, 2.67471761e-01f, -6.92483559e-02f, -4.53977048e-01f, 1.32115483e-01f, -3.01357776e-01f,
  3.59103441e-01f, -6.46985415e-03f, 1.50272325e-01f, 5.30978382e-01f, -2.17483029e-01f, -2.25968584e-01f, -5.16584754e-01f, -4.20207202e-01f, 5.44470847e-01f, 1.71143919e-01f,
  1.65163442e-01f, -3.97872217e-02f, -1.62824616e-01f, 4.25721630e-02f, 3.47426981e-01f, 2.15270475e-01f, 1.49225652e-01f, -2.88731102e-02f, 2.69931108e-01f, -1.66676044e-01f,
  -3.20557319e-02f, 8.31305683e-02f, 9.79728326e-02f, 1.37280688e-01f, 1.31756008e-01f, 4.80266660e-01f, 5.46699613e-02f, 5.64039648e-02f, 5.07369153e-02f, 2.29877561e-01f,
  2.65583813e-01f, 3.45427006e-01f, 1.61016285e-01f, -3.62398714e-01f, 3.03862900e-01f, -2.42973473e-02f, 1.32289678e-01f, 1.60259262e-01f, -4.75919217e-01f, 6.09757639e-02f,
  -1.56374164e-02f, -2.47552946e-01f, 3.69598158e-02f, -4.53735054e-01f, 1.71946362e-01f, -5.99511452e-02f, -8.46471712e-02f, -5.11041641e-01f, 7.50263870e-01f, 2.26994798e-01f,
  -5.08280754e-01f, -5.22982836e-01f, -2.79389411e-01f, 5.51115811e-01f, -4.03447151e-02f, -1.46566302e-01f, 5.25270641e-01f, -4.37003791e-01f, 4.47835892e-01f, 3.32097292e-01f,
  -3.40669960e-01f, -1.88568860e-01f, -2.47630060e-01f, 6.08351886e-01f, 5.13243139e-01f, 1.05075270e-01f, 2.93092523e-02f, 4.06077206e-01f, 4.44315106e-01f, -4.39406544e-01f,
  -1.09484456e-01f, -2.08379284e-01f, 5.85607290e-01f, 4.07081187e-01f, 2.93028474e-01f, -6.60199106e-01f, 2.83729941e-01f, 3.17023635e-01f, 2.76268452e-01f, -8.41775835e-02f,
  2.79917687e-01f, 1.57121718e-02f, 6.44823611e-02f, 1.18068993e-01f, 1.69010133e-01f, 7.50842765e-02f, 1.01764672e-01f, 2.34750267e-02f, -5.08393273e-02f, 2.21468687e-01f,
  -1.54374480e-01f, -1.06765307e-01f, 2.30799958e-01f, -3.08871511e-02f, 1.21452451e-01f, -4.24894132e-02f, -1.33689925e-01f, -2.97052681e-01f, -2.13780791e-01f, -2.62356222e-01f,
  -4.53415476e-02f, 9.40825567e-02f, -3.24745804e-01f, 1.98123649e-01f, -2.64437556e-01f, 1.16059989e-01f, 7.37173408e-02f, -2.12728411e-01f, -3.44666034e-01f, -2.90295005e-01f,
  -1.57387793e-01f, -2.63106555e-01f, 2.49015808e-01f, -6.33504242e-02f, -4.76002872e-01f, -2.70886004e-01f, 1.20143071e-01f, 2.25129515e-01f, 3.11628461e-01f, -2.24231154e-01f,
  7.82897230e-03f, 5.39839175e-03f, 2.40883082e-01f, 7.20367283e-02f, -3.13970566e-01f, 2.82733142e-01f, -3.14278215e-01f, -2.91216616e-02f, -1.95269346e-01f, -5.17969253e-03f,
  1.49223786e-02f, 2.07132429e-01f, 2.13111136e-02f, -1.06554098e-01f, 3.34317684e-01f, -7.77874887e-03f, 3.87114078e-01f, -2.45922148e-01f, 1.74315840e-01f, -1.29715189e-01f,
  1.04039252e-01f, 4.37848181e-01f, 5.17935097e-01f, -5.47941141e-02f, 5.21635950e-01f, 2.06134111e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 14)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 14;
const float L1_fan_Bp_bar_data[] = {
  2.27652580e-01f, 3.05390924e-01f, 2.01267719e-01f, -5.08910306e-02f, 8.90904590e-02f, 2.05564022e-01f, 1.13890633e-01f, 2.84993142e-01f, 1.84342086e-01f, -1.09676579e-02f,
  -5.77129349e-02f, 2.35307559e-01f, 1.44359425e-01f, 6.03777543e-02f
};

// L2_linear_W (Shape: 12 x 64)
const int L2_linear_W_rows = 12;
const int L2_linear_W_cols = 64;
const float L2_linear_W_data[] = {
  4.69429195e-02f, -7.30966181e-02f, 1.52110294e-01f, -1.93017676e-01f, 1.84691176e-01f, -3.07455331e-01f, -2.33346194e-01f, -2.58679956e-01f, 4.78607453e-02f, 1.14371359e-01f,
  1.55981362e-01f, -1.84867308e-01f, -1.83083221e-01f, -7.42935687e-02f, -2.62110442e-01f, -2.70895451e-01f, 7.34666139e-02f, 1.60269156e-01f, 1.96722433e-01f, 4.36501950e-02f,
  -2.60352999e-01f, 6.38853386e-02f, -2.67204884e-02f, -2.02817786e-02f, 2.17813298e-01f, -4.14917380e-01f, -5.03745437e-01f, 4.94551986e-01f, -2.82287568e-01f, 8.42976570e-02f,
  8.16160962e-02f, -1.64082035e-01f, -9.98861417e-02f, -1.41879722e-01f, -2.06749991e-01f, 1.85102984e-01f, -5.23453355e-01f, 3.28850031e-01f, -2.96040922e-01f, -3.29484373e-01f,
  -3.92189175e-01f, -3.68837297e-01f, 2.60623455e-01f, 1.03085476e-03f, 4.53967303e-01f, -3.27072628e-02f, -4.07482296e-01f, 4.59606349e-01f, 7.03301877e-02f, -2.91045401e-02f,
  -7.16238618e-02f, 1.09557681e-01f, -5.87777913e-01f, -6.48372173e-02f, -3.66223603e-01f, -5.94746768e-01f, -1.02041006e-01f, 6.89794347e-02f, 2.92165697e-01f, -2.25396082e-01f,
  3.91178846e-01f, -4.47165847e-01f, -1.66421488e-01f, 3.24579597e-01f, -4.16275114e-01f, -5.70367761e-02f, -7.33719915e-02f, 1.04234740e-01f, 1.19368896e-01f, 1.73013005e-02f,
  1.65428489e-01f, 1.39168963e-01f, -6.21512383e-02f, 2.53562313e-02f, -4.30901676e-01f, 1.62276790e-01f, -1.55701004e-02f, -9.36685950e-02f, 1.55651256e-01f, 5.72286062e-02f,
  -5.67966327e-02f, 1.92305848e-01f, 1.12017319e-01f, 5.41744158e-02f, 3.90032306e-02f, 2.22302929e-01f, 2.31381178e-01f, -1.18211903e-01f, 8.13468620e-02f, -3.64878953e-01f,
  -2.71611456e-02f, 3.36598396e-01f, -1.04167692e-01f, -4.55760509e-01f, -1.58416346e-01f, 3.67085546e-01f, 1.17312737e-01f, -2.94849157e-01f, 1.64382145e-01f, 2.29896724e-01f,
  -2.51547575e-01f, 1.24601223e-01f, 1.44486446e-02f, 1.72120512e-01f, -1.90019272e-02f, -1.24337114e-01f, -4.61226940e-01f, -2.24651426e-01f, -7.84486160e-02f, 3.66814643e-01f,
  -2.23844856e-01f, 1.60067290e-01f, 1.76632196e-01f, -4.06106919e-01f, -4.32321638e-01f, -5.24477184e-01f, 1.68819845e-01f, -7.57637471e-02f, -6.62529826e-01f, 6.69079870e-02f,
  8.90747234e-02f, -1.28541917e-01f, -9.07547250e-02f, 5.94297469e-01f, -1.00417487e-01f, 1.78087845e-01f, 4.22579467e-01f, 3.47775459e-01f, -6.13235086e-02f, -3.19230855e-02f,
  -1.54696986e-01f, 3.68876383e-02f, 1.40640596e-02f, -7.09112734e-02f, -3.26533675e-01f, -6.37453347e-02f, -4.32498679e-02f, -2.73644418e-01f, -3.37017089e-01f, 1.39473185e-01f,
  -1.35145649e-01f, 9.63889733e-02f, 9.40515473e-02f, 1.03316121e-02f, -5.20812906e-03f, -7.91182220e-02f, -4.80439812e-02f, 1.48760781e-01f, 1.01466872e-01f, 1.27331302e-01f,
  1.00109562e-01f, -1.75252423e-01f, -1.74805112e-02f, -3.54923993e-01f, -3.21396798e-01f, -4.56680954e-01f, 1.48635671e-01f, -3.09120625e-01f, -1.35705993e-01f, 2.71957994e-01f,
  -1.79042444e-01f, 3.63077581e-01f, 1.96318626e-01f, 4.15517315e-02f, 1.62593976e-01f, -1.43892258e-01f, -1.93435609e-01f, 8.98719882e-05f, -2.41740718e-01f, -2.86222965e-01f,
  -2.05929562e-01f, 4.20157194e-01f, 4.30318534e-01f, -2.29805410e-01f, 3.38769197e-01f, 4.83430386e-01f, 3.05994868e-01f, -4.06574845e-01f, -4.09881920e-01f, -1.89372689e-01f,
  1.88349783e-01f, -9.63334292e-02f, 4.09063935e-01f, 6.81413636e-02f, 2.57531106e-01f, -4.83520001e-01f, -4.70202863e-01f, 4.92068708e-01f, 2.16768801e-01f, -3.47844809e-01f,
  -9.50998247e-01f, -4.25862908e-01f, 2.41336793e-01f, -3.78474481e-02f, -1.72105670e-01f, 2.47746155e-01f, -2.88253993e-01f, -1.31894678e-01f, -2.42610261e-01f, -3.65468770e-01f,
  8.04930106e-02f, -2.14154497e-01f, 3.70701522e-01f, 9.11616758e-02f, 1.18539883e-02f, -3.35498929e-01f, 6.54868707e-02f, 1.55557215e-01f, -3.14504355e-01f, -1.28579393e-01f,
  -1.89419031e-01f, 2.43717417e-01f, 8.38782862e-02f, -1.43483564e-01f, 4.82256152e-02f, -1.83173344e-01f, 3.44025403e-01f, 3.48323733e-01f, 4.50610220e-01f, -1.80752575e-01f,
  -1.97105870e-01f, 2.84244064e-02f, -2.01956630e-01f, -2.96883404e-01f, 2.17043579e-01f, 2.19526336e-01f, -2.85782933e-01f, -1.00384928e-01f, 2.70028174e-01f, 4.01119083e-01f,
  4.39174563e-01f, 1.23792782e-01f, 1.94023833e-01f, 3.38109195e-01f, 2.50499845e-01f, -2.53726661e-01f, 2.95912653e-01f, 4.23274845e-01f, -4.30630475e-01f, 1.45153359e-01f,
  -3.97771358e-01f, -6.17873622e-03f, 4.78332430e-01f, -4.97292995e-01f, -7.43317544e-01f, -1.33671522e-01f, -3.75040114e-01f, -3.63342673e-01f, -6.50852859e-01f, 3.80742937e-01f,
  1.54711410e-01f, -1.62422270e-01f, -4.23807502e-01f, -3.39595854e-01f, -5.96650302e-01f, 9.05151814e-02f, 7.38152536e-03f, -1.87087744e-01f, 4.03041169e-02f, 4.86756973e-02f,
  -1.91772312e-01f, -1.01065457e-01f, -3.66324991e-01f, -9.77574363e-02f, 2.20065981e-01f, 2.58896858e-01f, 3.21142897e-02f, -1.33911753e-02f, 3.18447091e-02f, 2.30969310e-01f,
  8.58924314e-02f, 2.76217341e-01f, 1.71561614e-01f, 1.38518624e-02f, -1.65169939e-01f, -1.77699983e-01f, -2.84217596e-01f, 3.57748508e-01f, 2.25293070e-01f, 6.83467016e-02f,
  -1.67787179e-01f, 1.34163857e-01f, 4.72130120e-01f, -5.11277318e-01f, -4.45365280e-01f, 2.77541298e-02f, -3.88064295e-01f, -2.01625615e-01f, 3.23936731e-01f, -4.37521517e-01f,
  -5.77187359e-01f, -2.07784846e-01f, 3.61855805e-01f, -4.25976217e-01f, -1.04982384e-01f, 4.48810458e-01f, -1.60859704e-01f, -1.04130134e-01f, 2.07100689e-01f, -2.17929840e-01f,
  -3.34712535e-01f, 1.05628006e-01f, 2.59957880e-01f, -1.32443756e-01f, 5.33416986e-01f, 2.91120112e-01f, 1.18526384e-01f, 1.42657116e-01f, 2.00280905e-01f, 4.74723727e-02f,
  -2.44899213e-01f, 1.76176608e-01f, -4.17705148e-01f, -2.80775204e-02f, 3.80780995e-01f, -2.96529830e-02f, 1.62522241e-01f, -1.62239850e-01f, -9.60613132e-01f, -6.42101884e-01f,
  3.18277806e-01f, 1.56894639e-01f, 8.16373527e-03f, 2.25577384e-01f, 1.27217695e-01f, 3.64633054e-01f, 1.37264282e-01f, 2.86863232e-03f, -1.49937943e-01f, 2.57962011e-02f,
  2.38521501e-01f, 2.10395828e-01f, 6.39545843e-02f, -8.36067498e-02f, -5.84467407e-03f, -7.63311908e-02f, 9.31670815e-02f, -4.32247110e-02f, 1.38552740e-01f, -7.75453262e-03f,
  2.67723292e-01f, -5.77427931e-02f, -3.08993727e-01f, -1.32847920e-01f, -1.41085461e-01f, 4.80708152e-01f, -4.61471468e-01f, 4.58985239e-01f, -1.97108239e-01f, 1.74453005e-01f,
  3.41465354e-01f, -3.14576417e-01f, 2.92213857e-01f, -4.66937631e-01f, 2.17870459e-01f, -1.18425503e-01f, 3.31749201e-01f, -2.42171600e-01f, -3.13488215e-01f, -4.69123572e-01f,
  -3.88146162e-01f, -9.72278863e-02f, 4.59371924e-01f, 3.40810537e-01f, -2.25107402e-01f, 1.88131839e-01f, 4.01829302e-01f, -2.31159821e-01f, 3.35199773e-01f, 2.38370493e-01f,
  -6.78223372e-01f, 8.50480795e-02f, 2.50347853e-01f, 1.87366661e-02f, -4.15072948e-01f, -4.76898253e-01f, -1.14426194e-02f, 6.13167062e-02f, 1.41473308e-01f, -5.36948144e-01f,
  -1.85961068e-01f, 4.44253504e-01f, 3.37912351e-01f, -2.19358221e-01f, 1.06643632e-01f, 8.10538307e-02f, 1.97072357e-01f, -3.23227346e-01f, 4.53088023e-02f, 1.54447898e-01f,
  1.88214481e-01f, -2.91542206e-02f, 1.36353910e-01f, -2.54162461e-01f, 1.92192867e-01f, -1.74302429e-01f, 4.17912230e-02f, -2.16775984e-01f, 2.06662044e-01f, 1.91795513e-01f,
  -2.77005404e-01f, 2.07410321e-01f, -1.11895194e-02f, -1.78073019e-01f, -1.58593878e-01f, -1.90666258e-01f, -3.41536373e-01f, 6.77644759e-02f, -1.53882474e-01f, 4.26837623e-01f,
  1.89295083e-01f, 4.74139839e-01f, 2.86685497e-01f, 4.86643426e-02f, 2.93931156e-01f, 4.56631690e-01f, -4.45303977e-01f, 1.75286800e-01f, 1.56148389e-01f, -9.22280252e-02f,
  4.01201129e-01f, -5.34798205e-01f, -8.14042613e-02f, 4.15019721e-01f, -3.35860044e-01f, -3.48539025e-01f, -5.08499563e-01f, -3.47392410e-01f, -2.37437055e-01f, -5.06205261e-01f,
  7.85749555e-02f, -2.02702940e-01f, 3.83263260e-01f, 2.42854789e-01f, -3.59488666e-01f, 1.75469205e-01f, 3.14237863e-01f, -7.46051744e-02f, 5.07157505e-01f, 3.40477169e-01f,
  -2.22122923e-01f, -5.50546467e-01f, -4.61448342e-01f, -5.71079850e-01f, -3.25533003e-01f, -1.38052955e-01f, -1.41865417e-01f, -1.94441497e-01f, -1.42938951e-02f, 1.07816095e-02f,
  8.30191895e-02f, 1.02133930e-01f, 2.32894927e-01f, 5.48587814e-02f, 6.01700321e-03f, -6.42008856e-02f, 1.01869792e-01f, -7.59923086e-02f, 3.27431448e-02f, 1.07810115e-02f,
  1.25341296e-01f, 1.13991559e-01f, -4.56571057e-02f, -7.84446076e-02f, -3.33094187e-02f, -2.61383951e-01f, 1.51851997e-01f, 8.18412602e-02f, -2.05558613e-01f, -6.11738339e-02f,
  1.37269676e-01f, -6.92658573e-02f, 5.08742779e-02f, 2.77199000e-01f, 2.92906940e-01f, -2.97578901e-01f, -3.47251028e-01f, -2.41522476e-01f, 2.63647527e-01f, -4.98216636e-02f,
  1.67083427e-01f, -3.49084467e-01f, -3.24285656e-01f, -1.00111082e-01f, -2.80456692e-01f, 1.30147904e-01f, 3.80036831e-01f, 2.47400790e-01f, 3.32738787e-01f, 2.02454403e-01f,
  7.71562681e-02f, 3.39893878e-01f, 2.26910144e-01f, 1.49583653e-01f, 2.55171835e-01f, 2.49532178e-01f, 2.53716916e-01f, -1.02673862e-02f, 3.85636628e-01f, 2.28277147e-01f,
  -3.68391752e-01f, -1.37891293e-01f, 5.09179831e-02f, -3.13691586e-01f, -2.74978764e-02f, -5.46757340e-01f, -4.75124061e-01f, -3.20783973e-01f, -3.91435593e-01f, 3.84050578e-01f,
  1.17351405e-01f, 3.55585426e-01f, 5.94093325e-03f, 1.15557916e-01f, -1.41436355e-02f, -1.76579859e-02f, -9.96604860e-02f, 1.66147292e-01f, 3.56245488e-02f, -1.38846591e-01f,
  1.81355754e-05f, -6.86645657e-02f, 7.88930655e-02f, -1.87583104e-01f, 2.27016322e-02f, -1.74626172e-01f, -1.83386177e-01f, -3.96215692e-02f, -2.13389307e-01f, -8.65836367e-02f,
  -2.54664570e-01f, -1.64724931e-01f, 2.74145212e-02f, 4.17605005e-02f, 1.12946272e-01f, 1.21202923e-01f, 1.13920353e-01f, -1.14354171e-01f, -8.89669880e-02f, 2.06531033e-01f,
  2.11586326e-01f, 1.03458449e-01f, 8.06074310e-03f, 1.30802706e-01f, -1.99059218e-01f, -3.11439067e-01f, -2.60322362e-01f, 7.00801611e-02f, 1.17670499e-01f, -1.62231177e-01f,
  3.79998386e-01f, -2.21394747e-01f, 1.19647697e-01f, 3.06163847e-01f, -2.68211156e-01f, 3.17300826e-01f, 2.18527064e-01f, 8.32519680e-03f, -3.36686105e-01f, -1.61961332e-01f,
  -2.85758883e-01f, -1.87234595e-01f, -1.39204636e-01f, -5.58471203e-01f, -4.69413221e-01f, -2.60379054e-02f, 5.10077655e-01f, 2.28332192e-01f, 2.58148998e-01f, -4.02931809e-01f,
  2.42936060e-01f, -4.53500062e-01f, 1.47270054e-01f, -3.83731216e-01f, -1.77039742e-01f, 3.22699517e-01f, 2.17398033e-01f, -4.79819514e-02f, 6.82839677e-02f, 4.34543714e-02f,
  6.89622089e-02f, 1.46034539e-01f, -2.14193538e-02f, 1.96688145e-01f, -1.38010040e-01f, 8.24750662e-02f, 8.94046202e-02f, 1.52421474e-01f, -1.02626592e-01f, -1.49761632e-01f,
  -1.65212482e-01f, 1.25450253e-01f, -3.24818879e-01f, -4.47260253e-02f, -2.15463117e-01f, -1.33982599e-01f, 2.21420705e-01f, -3.07035238e-01f, 2.26290878e-02f, -7.36591518e-02f,
  1.31325334e-01f, -2.27997378e-01f, 3.25944066e-01f, -4.84785050e-01f, 3.75784725e-01f, 9.60061476e-02f, 3.15025687e-01f, -4.15335476e-01f, 3.43373030e-01f, 3.77008915e-01f,
  2.21584052e-01f, 2.13411376e-01f, -3.78992885e-01f, 6.35866225e-01f, -3.44435930e-01f, 3.16189349e-01f, 2.65701532e-01f, -1.01968288e-01f, 3.54283065e-01f, -2.11346820e-01f,
  -2.08220810e-01f, 3.16861540e-01f, 1.70733601e-01f, -2.15499029e-01f, -4.61611569e-01f, 1.57964885e-01f, -3.23853701e-01f, 2.71767616e-01f, -4.90192682e-01f, 5.88905029e-02f,
  -5.24529994e-01f, 3.81440520e-01f, 1.94239542e-01f, -5.51360607e-01f, -2.35499680e-01f, -9.75100696e-02f, 2.70961881e-01f, 4.01043087e-01f, -9.04934466e-01f, -3.34470689e-01f,
  7.01011252e-03f, 6.09142939e-04f, 1.07070297e-01f, -1.48205378e-03f, 3.49108040e-01f, -2.90571451e-01f, 8.93103778e-02f, 3.49629521e-01f, 6.98676929e-02f, 2.48207107e-01f,
  -4.39339250e-01f, 2.71094233e-01f, 1.65893301e-01f, 2.34377280e-01f, -3.19257416e-02f, -2.16569096e-01f, 1.73212498e-01f, 3.01809102e-01f, 2.28396997e-01f, -3.37936617e-02f,
  5.27942441e-02f, -7.20033348e-02f, 1.35544762e-02f, 1.81477472e-01f, 3.26822959e-02f, -4.45991397e-01f, -4.42922771e-01f, -3.86281729e-01f, 2.55069315e-01f, 1.92311227e-01f,
  -7.84864500e-02f, -1.47115618e-01f, 5.19351587e-02f, 3.30228895e-01f, -4.06872146e-02f, 3.92376781e-01f, -2.55376339e-01f, -1.02300674e-01f, 2.32534632e-01f, -1.10831194e-01f,
  3.49956691e-01f, 3.59194607e-01f, -1.59552664e-01f, 1.17560774e-02f, 4.87291873e-01f, -5.50386548e-01f, -4.23157185e-01f, -7.16275051e-02f, -3.69423956e-01f, -5.20923913e-01f,
  2.85588771e-01f, -6.08850300e-01f, 6.70774758e-01f, 4.55869660e-02f, -4.57277685e-01f, -2.42968470e-01f, 2.25067422e-01f, 1.21552171e-03f, 4.46672030e-02f, -2.29437426e-01f,
  -4.18465078e-01f, 2.19295502e-01f, -8.42699111e-01f, -1.85623690e-01f, -1.53675852e-02f, -6.76404014e-02f, 7.46601671e-02f, -2.70329803e-01f, -3.04517657e-01f, -2.24198803e-01f,
  5.18766940e-02f, -6.30412996e-03f, -2.57195771e-01f, -7.20646381e-02f, -7.12101813e-03f, -4.01012480e-01f, 2.09000096e-01f, 1.75621852e-01f, 3.10789291e-02f, 1.50006220e-01f,
  2.46522292e-01f, 1.67467073e-01f, 1.00197300e-01f, -2.45643154e-01f, 2.19155967e-01f, 9.55759957e-02f, -2.85333935e-02f, 9.41856652e-02f, -3.04516524e-01f, 3.88187528e-01f,
  3.95194799e-01f, 5.55717945e-01f, 1.86358422e-01f, 1.16048142e-01f, -3.06726009e-01f, 1.48933098e-01f, -3.74119282e-01f, 4.18379933e-01f, 3.26480865e-01f, -2.55654037e-01f,
  1.08382434e-01f, -5.27736731e-02f, -3.04693192e-01f, -3.76717150e-01f, 4.24578756e-01f, 7.78586864e-02f, -2.44528785e-01f, -2.51800060e-01f, -3.28552514e-01f, -3.15516561e-01f,
  3.09452415e-01f, -2.69438654e-01f, -4.65318054e-01f, 1.76169902e-01f, 9.32353809e-02f, -5.16353026e-02f, -3.71535510e-01f, -1.35642543e-01f, -1.37929648e-01f, -4.87790436e-01f,
  3.26157868e-01f, 4.04003024e-01f, -4.89522398e-01f, -1.91769913e-01f, 2.33916745e-01f, -2.39718899e-01f, -1.55710444e-01f, -3.82299662e-01f
};

// L2_linear_B (Shape: 1 x 12)
const int L2_linear_B_rows = 1;
const int L2_linear_B_cols = 12;
const float L2_linear_B_data[] = {
  7.53171593e-02f, -1.89595297e-01f, -8.44925120e-02f, -6.74445331e-02f, -1.53096598e-02f, 8.54931027e-02f, 8.27157199e-02f, -9.48695093e-02f, -4.84794155e-02f, 6.36434630e-02f,
  4.39390652e-02f, -2.06740927e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 25, 14
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        64, 25, 14
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_linear
    linear_forward_pgm(
        buffer1, x_out,
        L2_linear_W_data, L2_linear_B_data,
        64, 12
    );
    }
    