/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 64 (x2)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 64;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    return (x > 0.0f) ? x : 0.0f;
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 12 x 120)
const int L0_fan_Wp_rows = 12;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -1.51961192e-01f, -8.44730511e-02f, -1.64147750e-01f, 2.86358390e-02f, 1.29812300e-01f, 1.38614237e-01f, 1.77798241e-01f, 1.83957860e-01f, 1.81629345e-01f, 9.96277779e-02f,
  -5.21190651e-03f, 1.48887550e-02f, 3.77242453e-02f, -8.64243284e-02f, -9.92983878e-02f, 4.88128401e-02f, 5.84390648e-02f, -1.56468570e-01f, -1.09634966e-01f, 9.37519297e-02f,
  -9.57715139e-03f, -8.48784461e-04f, -1.67005464e-01f, -7.95003921e-02f, -2.10610330e-02f, 1.38055280e-01f, -8.33803322e-03f, -3.89467217e-02f, -1.98203847e-02f, -1.13286838e-01f,
  -2.18690693e-01f, -1.81573808e-01f, 5.47876768e-02f, 1.98490098e-02f, -5.30284317e-03f, -6.13178387e-02f, 3.30816694e-02f, -7.71858543e-02f, -2.81998385e-02f, -8.35148245e-02f,
  -6.05262145e-02f, -9.64750573e-02f, -2.71996483e-02f, -4.95645292e-02f, -1.03051411e-02f, 2.06522942e-02f, 7.63220526e-03f, -1.08246237e-01f, -1.04150862e-01f, -6.33385628e-02f,
  2.43041255e-02f, -3.52325924e-02f, -5.78425825e-02f, 6.65225983e-02f, -3.59166265e-02f, -9.43191946e-02f, -3.21578491e-03f, -3.45871262e-02f, -1.00837816e-02f, 2.02143546e-02f,
  1.05595635e-02f, -3.80705632e-02f, -2.20003389e-02f, -5.79077639e-02f, 3.75348926e-02f, -6.50737062e-03f, 2.84243766e-02f, -5.33454195e-02f, 5.79487048e-02f, -4.83747087e-02f,
  3.98761183e-02f, 4.85695936e-02f, -5.81669342e-03f, 5.67017309e-03f, -2.39087697e-02f, -4.13669944e-02f, -3.92786562e-02f, -2.45580524e-02f, -5.41464351e-02f, 6.82706311e-02f,
  6.86923414e-03f, 2.30314359e-02f, 2.60401424e-02f, -6.29915595e-02f, 3.93334776e-02f, 7.66124926e-04f, 3.93283181e-02f, -3.50737805e-03f, -5.70904743e-03f, -6.79966360e-02f,
  2.28586227e-01f, -1.03134047e-02f, -6.17100671e-02f, -1.37243315e-03f, -1.10986354e-02f, 1.21417053e-01f, -2.26833168e-02f, -2.55033299e-02f, 1.92797165e-02f, -5.89910671e-02f,
  7.13397041e-02f, 2.54202820e-02f, -4.66757976e-02f, -1.38958497e-02f, 2.80802101e-02f, 9.80099589e-02f, 3.23757865e-02f, -3.91498255e-03f, 6.09712228e-02f, 5.77941984e-02f,
  3.94397601e-02f, 1.02709867e-01f, 1.78847313e-01f, 4.58803922e-02f, 2.74923705e-02f, 1.14783652e-01f, 1.08508214e-01f, 7.96454400e-02f, 1.99892387e-01f, 3.60253334e-01f,
  1.40474439e-01f, 2.38535367e-02f, 1.63371161e-01f, -4.14797524e-03f, 8.56502354e-02f, 1.21392585e-01f, 1.64072141e-01f, -8.26496705e-02f, 5.03919385e-02f, 4.27980348e-02f,
  -5.51197901e-02f, -4.94382903e-02f, -4.51305285e-02f, -1.43965976e-02f, 8.43593851e-02f, 5.12223430e-02f, 5.55310324e-02f, 1.07520759e-01f, 9.16608050e-02f, -1.08581722e-01f,
  -5.20911552e-02f, 4.36076615e-03f, -1.12351499e-01f, -1.02359749e-01f, -1.24601042e-02f, -1.17043965e-01f, 6.97863474e-02f, 4.19154316e-02f, -9.01336148e-02f, -3.20458449e-02f,
  7.33405873e-02f, 6.20403364e-02f, 5.96849248e-02f, 1.30779166e-02f, -8.59427005e-02f, 5.25909625e-02f, 1.24624409e-01f, -4.10236679e-02f, 7.51777440e-02f, -3.32945772e-02f,
  -6.48141950e-02f, -9.05981287e-02f, 8.88342708e-02f, 3.28707807e-02f, -6.75164089e-02f, 1.46706384e-02f, -1.26399115e-01f, -7.30361491e-02f, -4.04350162e-02f, -4.85703796e-02f,
  -1.21086121e-01f, 2.62364419e-03f, 3.60887311e-02f, -8.44957605e-02f, -6.09764829e-02f, -4.29841802e-02f, -5.70276082e-02f, -7.37393834e-03f, 1.12880692e-02f, -3.76379155e-02f,
  -6.76922947e-02f, 1.40492460e-02f, -4.41464782e-02f, -1.37771266e-02f, -5.81602659e-03f, 3.02770212e-02f, 7.76513889e-02f, -1.23176898e-04f, 2.34895460e-02f, 3.97132635e-02f,
  1.26184234e-02f, 1.37386248e-02f, -7.79047012e-02f, 4.76059280e-02f, 2.99115889e-02f, -5.35878912e-02f, -1.84991267e-02f, -1.88815519e-02f, -8.72125663e-03f, 2.84968968e-02f,
  3.86939496e-02f, 4.11394686e-02f, -8.66673589e-02f, 1.34417806e-02f, -8.28615054e-02f, -2.60195788e-02f, 1.15277304e-03f, -9.67358872e-02f, 5.83873317e-02f, -6.41474575e-02f,
  -7.59999454e-02f, 4.12155204e-02f, 7.87539855e-02f, -4.12914082e-02f, -1.16067212e-02f, 1.24793416e-02f, 5.90536557e-02f, -8.45033303e-02f, 4.20907736e-02f, -4.35770750e-02f,
  -6.44937530e-02f, 4.58227620e-02f, 1.26668168e-02f, -1.07813776e-01f, 6.14409111e-02f, -5.07698804e-02f, 2.89393216e-02f, 7.45669901e-02f, 4.04924760e-03f, -2.35548262e-02f,
  -9.79152620e-02f, 2.62611434e-02f, 8.30971170e-03f, -7.87693448e-03f, 4.59293427e-04f, 1.07059024e-01f, -3.03987563e-02f, -6.32816181e-02f, 1.49640664e-01f, 8.14387277e-02f,
  -4.05219942e-01f, 2.56642010e-02f, 3.60980339e-04f, -7.94355571e-02f, 1.00024782e-01f, -1.55158967e-01f, -2.55799741e-01f, -4.04197238e-02f, -3.05166896e-02f, -8.16281810e-02f,
  2.04477608e-02f, 3.77032459e-02f, 8.60501602e-02f, 1.10008016e-01f, -1.20463043e-01f, 2.53391434e-02f, -9.79820639e-02f, 4.18476015e-03f, -4.58172709e-02f, -1.21177144e-01f,
  -2.34696344e-02f, -5.75151155e-03f, -7.48518556e-02f, 1.62083562e-02f, 1.82707876e-01f, 1.96591258e-01f, -1.48487405e-03f, 9.51918513e-02f, 8.86337273e-03f, 1.85454383e-01f,
  1.14403881e-01f, 2.36471351e-02f, -3.18848155e-02f, -8.53738934e-02f, 6.71369806e-02f, 1.03552481e-02f, 3.54683585e-03f, 8.58932287e-02f, 2.50051841e-02f, -6.64417818e-02f,
  -1.64604317e-02f, 1.52757522e-02f, 1.23711377e-01f, 3.97166274e-02f, -1.17791943e-01f, -1.19256593e-01f, -2.34629121e-02f, -3.29207629e-02f, -8.85944068e-02f, 3.83216664e-02f,
  -1.87667329e-02f, 3.77849601e-02f, -1.73331097e-01f, 5.29820682e-04f, -7.16633536e-03f, -3.06820460e-02f, -1.27752535e-02f, 1.16669387e-01f, 7.63386935e-02f, -2.21481305e-02f,
  -1.70113202e-02f, -4.12356406e-02f, -9.76667181e-03f, -1.72871351e-02f, -2.35499740e-02f, 4.20833528e-02f, 2.49142814e-02f, -4.81485613e-02f, 9.49107204e-03f, -1.99587876e-03f,
  8.96179751e-02f, -4.84951399e-02f, 4.27642874e-02f, 3.57212201e-02f, -7.45459870e-02f, -1.88463870e-02f, -6.99286759e-02f, -3.88166532e-02f, -8.29053298e-02f, -5.42354258e-03f,
  -1.57252401e-02f, -4.65812831e-04f, 5.86894937e-02f, -1.43990284e-02f, 4.12887298e-02f, 4.53160563e-03f, -1.21973380e-02f, 3.18009816e-02f, 2.74933483e-02f, -3.67932543e-02f,
  9.83796492e-02f, -9.14573222e-02f, -5.09751514e-02f, -7.22514987e-02f, -3.87169095e-03f, -8.12108442e-03f, 7.90520608e-02f, 4.26341183e-02f, -1.35337273e-02f, -5.61916903e-02f,
  -4.90050204e-02f, -6.51398599e-02f, -3.60303596e-02f, -1.69103220e-02f, -3.16289291e-02f, -1.21122882e-01f, -1.66937262e-01f, -4.61803377e-02f, -1.38912816e-02f, -7.62001500e-02f,
  -8.13936815e-03f, -1.02096952e-01f, -2.16676831e-01f, -1.26029598e-02f, -1.86707918e-02f, -3.92093249e-02f, -3.02513652e-02f, 3.21516804e-02f, -1.36056319e-01f, -1.96264699e-01f,
  1.11697614e-01f, -1.30493686e-01f, -1.01465203e-01f, -6.69033080e-02f, -8.82668942e-02f, 1.06559850e-01f, 4.27323580e-02f, 7.76418075e-02f, -2.05776580e-02f, -1.16489597e-01f,
  6.17743246e-02f, 1.66515321e-01f, 1.49600759e-01f, 1.51472867e-01f, 2.50692070e-01f, -1.72523528e-01f, -1.81541607e-01f, 9.21659991e-02f, 3.21676791e-01f, 9.49216112e-02f,
  2.53720451e-02f, -1.59941301e-01f, 2.90154666e-02f, -4.69289497e-02f, -2.15071991e-01f, -1.55682012e-01f, -1.63134441e-01f, -7.69869760e-02f, -1.44509479e-01f, -4.89281714e-01f,
  -1.93654802e-02f, 6.45354763e-02f, 1.06702052e-01f, -7.55194575e-02f, -1.07454985e-01f, 7.42428303e-02f, 1.22910582e-01f, -1.36409830e-02f, 1.27121592e-02f, -5.25098629e-02f,
  -8.83001238e-02f, 6.09935895e-02f, 6.88095484e-03f, -1.47738187e-02f, 2.13777199e-02f, 5.82448617e-02f, -4.32486869e-02f, 1.01027153e-01f, 8.02416801e-02f, 1.19296379e-01f,
  -1.07694253e-01f, -8.61660689e-02f, 4.36094068e-02f, -1.28778396e-02f, 3.49190831e-02f, 3.45267206e-02f, 5.29702567e-02f, 6.30061626e-02f, 1.60096452e-01f, -1.09940358e-01f,
  6.36349525e-03f, -6.69879019e-02f, -6.07196875e-02f, -1.74833126e-02f, -7.46943476e-03f, -2.80746352e-02f, -2.82814968e-02f, -4.66786064e-02f, -3.46992388e-02f, -1.39294798e-02f,
  3.52322981e-02f, 4.73604202e-02f, 7.61465216e-03f, 3.60014662e-02f, -7.46104494e-02f, -7.55216628e-02f, -9.34765395e-03f, 1.22998059e-02f, 4.03153151e-02f, -6.32046070e-03f,
  -4.47013369e-03f, 4.61166427e-02f, -1.11091472e-01f, -4.03280891e-02f, 2.06248742e-02f, 7.28126150e-03f, 4.08648327e-02f, 1.88971031e-02f, 2.08534244e-02f, 3.45574729e-02f,
  3.22043858e-02f, 1.96386039e-01f, -3.31598297e-02f, 3.46557088e-02f, 4.52442653e-03f, -1.63513124e-02f, -9.72943529e-02f, 5.28734457e-03f, -3.91061828e-02f, 5.71606345e-02f,
  1.33735733e-02f, 3.15911137e-02f, -1.24359280e-02f, 7.91445747e-03f, 1.25291452e-01f, -2.22675335e-02f, -3.79131138e-02f, -4.87516895e-02f, 5.17175384e-02f, -7.06593618e-02f,
  -5.92248403e-02f, 6.45577982e-02f, 1.37657344e-01f, -4.51828316e-02f, 5.95588386e-02f, 4.97244634e-02f, 5.12085147e-02f, -2.07578279e-02f, 1.31123424e-01f, -3.80933322e-02f,
  3.95789087e-01f, 2.59387344e-01f, -3.48778874e-01f, 2.94670522e-01f, -3.30026112e-02f, -2.33428046e-01f, -1.07837580e-01f, 5.52052930e-02f, 1.53416157e-01f, 1.52737930e-01f,
  1.25165820e-01f, -7.17915478e-04f, 3.66020054e-02f, -1.45309949e-02f, -1.29081801e-01f, -1.20282933e-01f, -8.15326944e-02f, -2.15205982e-01f, -3.19886208e-01f, 2.36328272e-03f,
  8.62279907e-02f, 1.78155690e-01f, 1.69326477e-02f, 4.57901545e-02f, 1.88163698e-01f, -2.90963389e-02f, -4.67296056e-02f, 6.77796602e-02f, -1.28731653e-02f, 2.38806918e-01f,
  9.65280342e-04f, 1.18535660e-01f, -7.99791738e-02f, -1.77571885e-02f, 2.24450957e-02f, -1.98902357e-02f, 6.81647733e-02f, -5.44254901e-03f, 3.33910895e-04f, 3.76839973e-02f,
  6.09150976e-02f, 5.80932833e-02f, 1.63091142e-02f, 3.88347432e-02f, 8.65897760e-02f, -4.77916747e-02f, 8.25784281e-02f, -3.76101062e-02f, -7.40213022e-02f, -1.21145006e-02f,
  1.46480754e-01f, 5.64269200e-02f, -8.08478892e-02f, -8.01054984e-02f, -1.69986457e-01f, -9.67760608e-02f, -8.94236788e-02f, -3.13829333e-02f, -1.13347284e-01f, 1.86075658e-01f,
  3.40458960e-03f, -3.51233990e-03f, -6.88362643e-02f, 4.98267338e-02f, 4.52350313e-03f, -3.05760968e-02f, -3.01174913e-03f, -4.36837822e-02f, -4.82290201e-02f, -4.97036288e-03f,
  3.00666410e-02f, -9.26801376e-03f, -1.49372509e-02f, 2.88406666e-02f, -1.56198964e-02f, -5.38910106e-02f, 1.93537660e-02f, 1.23693701e-03f, 2.83701550e-02f, -1.38839809e-02f,
  4.00101542e-02f, -4.49760221e-02f, 4.64145131e-02f, -1.30426675e-01f, -2.59626601e-02f, 7.41786323e-03f, 6.57288283e-02f, -7.04974756e-02f, 1.37006611e-01f, 8.94182548e-02f,
  1.28896981e-01f, -3.40952784e-01f, 1.28782660e-01f, 2.25575324e-02f, 6.97634816e-02f, -1.08193094e-02f, 4.47132140e-02f, -6.24407735e-03f, 2.39138603e-02f, -4.33186209e-03f,
  -4.71243411e-02f, 2.98800562e-02f, 4.18312140e-02f, -4.47147563e-02f, 9.67459846e-03f, -3.83237228e-02f, 4.78670076e-02f, -2.22477764e-02f, -3.51185203e-02f, 2.44354401e-02f,
  -1.09449876e-02f, 5.17823733e-02f, -5.05484045e-02f, -9.23586860e-02f, -2.28459816e-02f, -8.83538555e-03f, -2.00691149e-02f, 1.78179108e-02f, -1.63975686e-01f, 1.41820908e-01f,
  3.92089009e-01f, 7.20383972e-02f, -3.36560495e-02f, 1.86151788e-01f, 2.33435228e-01f, 1.83913499e-01f, 8.91868994e-02f, 1.01869658e-01f, 7.90972039e-02f, 1.20264210e-01f,
  7.73095563e-02f, 1.52271269e-02f, -6.74537346e-02f, -1.05455533e-01f, -8.97132456e-02f, 1.80008218e-01f, 1.86714947e-01f, 1.42950239e-03f, -5.27570769e-02f, -2.80193556e-02f,
  2.21970305e-02f, 1.46813229e-01f, 1.83071624e-02f, -4.45475278e-04f, 4.25777510e-02f, -9.66161937e-02f, -1.13866039e-01f, 4.88911010e-03f, -1.02490507e-01f, 6.58279285e-02f,
  -1.87407002e-01f, 1.19722843e-01f, -3.50658856e-02f, 4.01493236e-02f, 4.35574464e-02f, -6.04112297e-02f, 4.03164886e-02f, -7.83119649e-02f, 1.27018774e-02f, 2.02461779e-02f,
  1.24602830e-02f, 2.97774244e-02f, 1.13255098e-01f, -2.43357779e-03f, 1.18357781e-02f, -2.02314258e-02f, -1.23195171e-01f, 2.43149381e-02f, -4.57947776e-02f, -1.17073819e-01f,
  -4.80205379e-02f, 8.45695511e-02f, 2.77906656e-02f, 1.14308093e-02f, -5.18204086e-02f, 8.45529605e-03f, -4.97923270e-02f, -7.98277706e-02f, -2.30800509e-02f, 1.54670386e-03f,
  -2.64524948e-02f, -6.88017532e-02f, 2.72905803e-03f, -1.03814919e-02f, 6.56452179e-02f, 4.90879044e-02f, 1.75864920e-02f, -2.00326405e-02f, 5.92084453e-02f, 1.90477036e-02f,
  1.22685796e-02f, 1.23708779e-02f, -2.57405508e-02f, -4.52928245e-02f, -7.18272626e-02f, 7.90938213e-02f, 4.51368745e-03f, -1.48548912e-02f, -1.99130606e-02f, 2.39782576e-02f,
  2.44515594e-02f, 1.61551889e-02f, -9.68588109e-04f, -1.60913691e-02f, 4.52721398e-03f, 5.89394085e-02f, -3.58034596e-02f, -7.70230815e-02f, 5.35195768e-02f, 3.67227681e-02f,
  -4.20762859e-02f, 1.29842088e-01f, 1.13894328e-01f, 6.96077058e-03f, -1.88559350e-02f, -4.06075129e-03f, 7.37695172e-02f, -2.56989412e-02f, -9.02101956e-03f, -3.35294902e-02f,
  6.24841973e-02f, -4.16842327e-02f, 4.79905121e-03f, -5.83656458e-03f, -4.22876589e-02f, -3.13687772e-02f, 9.75261852e-02f, 5.89235276e-02f, -7.18293786e-02f, -4.13380787e-02f,
  -3.24399285e-02f, 3.53029929e-02f, 2.19070148e-02f, -8.26211274e-02f, -1.18043534e-02f, 8.81619677e-02f, 4.04097214e-02f, -3.36601324e-02f, 2.54590064e-02f, -3.16188075e-02f,
  8.42123106e-03f, 2.45641962e-01f, 6.74248412e-02f, 8.05434212e-02f, -3.74026783e-02f, -8.81764144e-02f, 8.66148397e-02f, 6.34361058e-02f, 5.31406216e-02f, 2.17317622e-02f,
  1.48743153e-01f, 5.10692410e-02f, 1.94226373e-02f, 4.52460013e-02f, -1.38693033e-02f, -2.67944373e-02f, 2.08464954e-02f, -1.78712290e-02f, -2.52761304e-01f, -3.50334495e-02f,
  -8.56068805e-02f, 2.23278813e-02f, -1.84668019e-01f, -1.52414422e-02f, 1.70017347e-01f, 4.41645198e-02f, 1.01180218e-01f, 5.66772558e-02f, 6.44316943e-03f, 2.08187744e-01f,
  1.76107526e-01f, 1.95126519e-01f, -4.58426289e-02f, 4.97579612e-02f, -2.67637148e-02f, -9.22881663e-02f, 5.23348562e-02f, -7.11751357e-02f, 2.68913954e-02f, -5.67825735e-02f,
  1.20576970e-01f, 3.93187664e-02f, -3.94231714e-02f, -3.55584472e-02f, 7.15021715e-02f, -5.42013645e-02f, 1.64216664e-02f, -4.99401167e-02f, -4.99370135e-02f, 9.98311341e-02f,
  8.04183707e-02f, 5.44946902e-02f, 6.55917004e-02f, 7.23952726e-02f, 2.23714467e-02f, -9.10922363e-02f, 4.40464243e-02f, 3.48921902e-02f, -9.91009362e-03f, -1.94286350e-02f,
  -3.91461067e-02f, 1.35415662e-02f, -2.87490506e-02f, 8.07794277e-03f, -1.92239322e-02f, -1.38461897e-02f, -3.52461673e-02f, -3.36056165e-02f, 1.30484849e-02f, 1.38612976e-02f,
  -6.21721707e-02f, 1.25451908e-02f, 1.55693898e-02f, 5.39046079e-02f, 5.69848940e-02f, 1.68465637e-02f, 6.53596073e-02f, 8.40296224e-03f, -2.08547717e-04f, -1.41305653e-02f,
  5.67344204e-03f, -6.30991012e-02f, -2.77160155e-03f, -3.53798829e-02f, 1.94850843e-02f, -6.12900145e-02f, 2.41610799e-02f, -2.59547308e-02f, -4.15636003e-02f, 8.33902583e-02f,
  2.26859283e-02f, -5.36672622e-02f, 2.82897707e-02f, -1.97904035e-02f, -2.23570634e-02f, 5.40676415e-02f, -2.10713758e-03f, -9.39770509e-03f, 1.25647306e-01f, -4.72125560e-02f,
  6.69203773e-02f, 4.56285141e-02f, 9.08715725e-02f, -4.02846821e-02f, -1.50502130e-01f, 5.49573340e-02f, -2.82357875e-02f, -9.20743681e-03f, 5.74258082e-02f, 3.88327055e-02f,
  5.32051139e-02f, 4.16374672e-03f, -1.20604396e-01f, 3.89451645e-02f, 7.06294999e-02f, -1.42140031e-01f, 1.55025593e-03f, -7.19940886e-02f, -6.27494827e-02f, -1.39173776e-01f,
  4.40396935e-01f, -3.66405070e-01f, -1.75315440e-01f, 1.65379241e-01f, -2.58050948e-01f, -1.60955250e-01f, -3.89994830e-01f, 3.39764543e-02f, 1.82172298e-01f, -1.93574071e-01f,
  -1.71266630e-01f, 1.74744666e-01f, 1.56979263e-01f, 2.39666075e-01f, 1.96189731e-01f, -2.20949367e-01f, -1.89327747e-01f, 1.30472168e-01f, 2.85230368e-01f, 7.11069033e-02f,
  4.80792075e-02f, 2.64094602e-02f, 2.07706884e-01f, 1.16106331e-01f, -1.43331900e-01f, 1.54114395e-01f, -2.48688594e-01f, -9.31727141e-02f, -1.27422214e-01f, -1.73725158e-01f,
  -1.41948521e-01f, -9.72589552e-02f, 1.06510937e-01f, 7.43047297e-02f, -7.27372989e-02f, 4.65427563e-02f, 7.85923228e-02f, 5.58496900e-02f, -1.48552768e-02f, -4.15930375e-02f,
  6.20818278e-03f, 7.33237788e-02f, 2.70399451e-02f, -5.35637401e-02f, -5.46863414e-02f, -3.34366821e-02f, -5.46813942e-02f, 5.93516789e-02f, 7.85393417e-02f, -1.18216336e-01f,
  -1.96389437e-01f, -1.61239460e-01f, -7.21355677e-02f, -6.54998119e-04f, 1.38950143e-02f, 1.42195866e-01f, -3.52309942e-02f, -2.80892886e-02f, 2.97372155e-02f, -6.59302063e-03f,
  2.62861941e-02f, -2.89308336e-02f, 2.95107700e-02f, -8.65375623e-02f, 1.65819786e-02f, -4.10350896e-02f, -5.07326350e-02f, 9.75283328e-03f, 4.36633192e-02f, 1.53265917e-03f,
  -2.19329670e-02f, -2.84346044e-02f, -2.17463914e-03f, -2.63043344e-02f, 5.97163709e-03f, -6.35260195e-02f, 8.90349783e-03f, -5.01620360e-02f, 3.96810472e-02f, -2.60591097e-02f,
  8.77575204e-02f, -6.74443915e-02f, -3.91259044e-02f, 4.30826731e-02f, -4.22423743e-02f, -9.85074788e-03f, 2.62679979e-02f, -1.80907771e-02f, -9.74455941e-03f, -4.89006974e-02f,
  2.34448925e-01f, -4.56098467e-02f, 8.37321430e-02f, 1.25665978e-01f, 5.17951651e-03f, 5.86484596e-02f, -5.42755015e-02f, -3.62288347e-03f, 2.67525427e-02f, 3.47565934e-02f,
  -2.44323369e-02f, 7.45668039e-02f, 1.34743387e-02f, -2.04610196e-03f, 6.85052276e-02f, 5.79208620e-02f, -3.13780829e-02f, 5.28997965e-02f, 5.88914044e-02f, 6.55513033e-02f,
  4.84931171e-02f, 9.37191024e-02f, 9.68329385e-02f, 7.23286793e-02f, -8.33053980e-03f, 1.72525883e-01f, -7.35292807e-02f, 4.42992710e-02f, 1.44220486e-01f, 2.76651736e-02f,
  1.15775034e-01f, -2.33030200e-01f, -1.39616206e-01f, -7.11019710e-02f, -1.67823985e-01f, -2.09307760e-01f, -3.12724590e-01f, 2.17179060e-02f, 5.47603481e-02f, -1.23668015e-01f,
  8.18834081e-02f, 2.15835765e-01f, 1.05459042e-01f, 1.64118230e-01f, -4.34987023e-02f, -2.55660325e-01f, -2.52889067e-01f, 1.52223036e-02f, 1.24308206e-01f, 1.67773962e-01f,
  -8.56757164e-03f, 6.72161207e-02f, 9.72075760e-02f, 5.17120957e-03f, 7.88990129e-03f, 1.63675964e-01f, -1.38950974e-01f, -7.55630806e-02f, 4.75380057e-03f, -8.60010535e-02f,
  7.87230879e-02f, -7.37272128e-02f, 1.20796137e-01f, 9.04506519e-02f, 2.75125336e-02f, 8.55325535e-02f, -1.29837487e-02f, -2.29528658e-02f, 9.11479294e-02f, 2.86599956e-02f,
  -4.57977578e-02f, 6.49380535e-02f, -2.67385580e-02f, 6.89694732e-02f, 2.42270511e-02f, 6.18862323e-02f, 7.96694607e-02f, -5.14071286e-02f, 3.60674900e-03f, -1.22438289e-01f,
  4.81186807e-03f, 1.64558645e-02f, -1.36975303e-01f, -1.42491639e-01f, -8.99794549e-02f, 1.21523455e-01f, 6.08989373e-02f, 1.22225508e-01f, 5.78055605e-02f, -5.51618449e-02f,
  8.53007212e-02f, 6.60569593e-02f, -6.33060336e-02f, 6.82484210e-02f, 5.01209591e-03f, 1.68782715e-02f, -3.47562358e-02f, -5.21089025e-02f, 3.69957387e-02f, 2.17575431e-02f,
  2.62192246e-02f, 1.73606146e-02f, 2.31338982e-02f, -4.71398607e-02f, 3.68556976e-02f, -5.43458909e-02f, -4.80482616e-02f, -1.64891239e-02f, 5.26552228e-03f, 1.12383151e-02f,
  8.72813165e-02f, 5.45978453e-03f, 3.00019458e-02f, 4.99058515e-02f, -3.56404036e-02f, -6.15362898e-02f, 4.92208339e-02f, -2.56366748e-03f, 4.13211435e-02f, 4.69370075e-02f,
  4.26589921e-02f, 7.13338330e-02f, 6.02176934e-02f, 1.62964258e-02f, -5.38115166e-02f, 2.12732237e-02f, -9.85958800e-03f, -4.22792099e-02f, 2.76826732e-02f, -5.31386361e-02f,
  1.44558223e-02f, 1.60312522e-02f, -6.02502525e-02f, -1.00543369e-02f, -1.07080825e-02f, 5.15988059e-02f, -1.74828339e-02f, -2.62039397e-02f, 2.06875000e-02f, -8.54823664e-02f,
  -5.84040433e-02f, -8.87237340e-02f, 2.40203124e-02f, 4.15939763e-02f, 2.98625138e-02f, -2.82285083e-03f, 8.03977624e-03f, -3.53939123e-02f, 5.52463494e-02f, 4.62993681e-02f,
  -1.62180170e-01f, -8.42510164e-02f, 3.73458743e-01f, -1.01200439e-01f, 9.33021978e-02f, 9.19130668e-02f, 4.63870615e-02f, -1.43785328e-01f, -1.29870057e-01f, -1.44110903e-01f,
  -1.71630848e-02f, -3.41818035e-02f, 1.42462086e-02f, 1.07812084e-01f, 1.28405482e-01f, 2.04331979e-01f, 2.02509865e-01f, 3.42957973e-01f, 2.01727048e-01f, 3.94442603e-02f,
  -4.17944044e-02f, -4.04852629e-02f, -4.06839773e-02f, 6.92137191e-03f, 8.11309833e-03f, -1.66845322e-02f, 1.16825299e-02f, 6.55876771e-02f, 1.09300502e-01f, 1.86548412e-01f,
  1.88874334e-01f, -1.54553682e-01f, 4.52247709e-02f, 3.58033329e-02f, -1.00694811e-02f, 2.06712075e-02f, -3.09855174e-02f, 4.65496443e-02f, -3.64222266e-02f, -6.90455288e-02f,
  2.59336866e-02f, -4.41893041e-02f, 3.56382169e-02f, -8.57625157e-02f, 3.10242325e-02f, -6.62828162e-02f, -2.92014573e-02f, 6.48620650e-02f, 5.50207235e-02f, -3.67249548e-02f,
  5.80500141e-02f, 1.80087045e-01f, 1.58157781e-01f, 3.09458412e-02f, 4.75421697e-02f, 4.01709750e-02f, -4.90537025e-02f, -8.94060433e-02f, -2.05996856e-02f, -1.18513525e-01f,
  3.49319465e-02f, 3.87114403e-03f, 2.31456626e-02f, -7.72119984e-02f, -5.73211275e-02f, -6.91792890e-02f, 1.96906086e-02f, -5.38369268e-02f, -4.01403122e-02f, -3.81097756e-02f,
  -1.42416144e-02f, -2.29975525e-02f, -6.70739682e-03f, -1.10337110e-02f, 1.48375798e-02f, 5.68276308e-02f, 4.00175191e-02f, 1.55227762e-02f, -1.74054950e-02f, -3.95595431e-02f,
  5.01748873e-03f, -2.63022762e-02f, 1.17086796e-02f, -3.93513143e-02f, 8.83941799e-02f, 3.77855301e-02f, 1.97700877e-02f, -4.25084569e-02f, 4.90430519e-02f, 9.16475058e-03f,
  -3.41721624e-01f, 1.15820207e-01f, -7.62744844e-02f, -2.19243355e-02f, 6.97229505e-02f, 1.90619174e-02f, -5.85503411e-03f, -3.60886157e-02f, -1.20025361e-02f, -5.69033027e-02f,
  -6.83673024e-02f, 3.43904719e-02f, -5.26552536e-02f, 1.47560081e-02f, 1.73563156e-02f, -2.40396596e-02f, -5.84874265e-02f, 7.08818287e-02f, -2.25793235e-02f, -7.52968490e-02f,
  -6.40029013e-02f, 3.76381315e-02f, 4.34814580e-02f, -3.42525244e-02f, -5.78983547e-03f, 1.54354526e-02f, 3.83319110e-02f, 8.76474008e-03f, 1.39801204e-01f, -1.81421503e-01f,
  -2.90072948e-01f, -1.68486297e-01f, -2.97566682e-01f, -6.88728690e-02f, 1.28640503e-01f, -2.06115767e-02f, -1.01131059e-01f, -5.87447509e-02f, 1.53248474e-01f, -1.13367222e-01f,
  9.39404741e-02f, 2.31292412e-01f, 1.39443830e-01f, 3.53072509e-02f, 2.57425718e-02f, -8.84790197e-02f, -1.67266190e-01f, -1.19563676e-01f, 8.46288726e-02f, 5.82351089e-02f,
  3.94627936e-02f, 9.83523671e-03f, 4.74442951e-02f, 8.75130519e-02f, 5.65679781e-02f, 6.09461628e-02f, -7.15207076e-03f, -7.56813735e-02f, 8.60867053e-02f, -3.38527304e-03f,
  -2.06430137e-01f, -1.00966446e-01f, 2.35528639e-03f, 5.41465804e-02f, -3.12388148e-02f, -5.95199689e-03f, 2.40188651e-02f, -9.65975150e-02f, -1.53800473e-02f, -3.37762050e-02f,
  1.72128994e-02f, 4.56766188e-02f, 5.35727181e-02f, 8.65051448e-02f, -7.85305947e-02f, -1.27358846e-02f, -8.63297507e-02f, -6.00372031e-02f, -1.09489448e-01f, -2.75246482e-02f,
  -4.38095033e-02f, 5.07633053e-02f, -1.20958351e-01f, -4.21337225e-03f, -6.13799058e-02f, 1.15255624e-01f, 1.75504126e-02f, -7.29914531e-02f, 3.23989801e-02f, -2.43158281e-01f,
  9.46111791e-03f, -2.89826654e-02f, 4.78761718e-02f, -5.37106469e-02f, 1.76113136e-02f, -2.56762169e-02f, 2.36188453e-02f, -2.80102398e-02f, 2.25220621e-02f, -9.57124308e-02f,
  5.05962931e-02f, -5.08589000e-02f, -8.12682956e-02f, -1.68556273e-02f, 4.61334959e-02f, 2.89170220e-02f, -7.26579577e-02f, -4.34521399e-03f, 1.42815532e-02f, 8.89452081e-03f,
  -9.52009782e-02f, 6.40906617e-02f, 2.12800577e-02f, -2.67194454e-02f, 6.77425265e-02f, -8.38936418e-02f, -2.92008352e-02f, -4.92805429e-02f, 2.06284486e-02f, -2.37290468e-02f,
  -9.75934714e-02f, 1.63635314e-01f, -1.24008387e-01f, -6.61762953e-02f, 8.36785138e-02f, 2.23467406e-02f, -2.40047909e-02f, 4.48838919e-02f, 7.22108921e-03f, -2.92741489e-02f,
  9.43258256e-02f, 4.86728968e-03f, -6.37968304e-03f, 1.58945750e-02f, 5.16655035e-02f, -3.14106382e-02f, 3.72624099e-02f, 2.23689619e-03f, 5.70685081e-02f, 2.64747851e-02f,
  -1.63799874e-03f, -9.89161804e-02f, -1.28063366e-01f, -1.17220610e-01f, -6.79403893e-04f, -4.40255702e-02f, -1.23169884e-01f, -1.00618556e-01f, -3.62484343e-02f, -2.12859958e-01f,
  6.03338361e-01f, 1.20695926e-01f, 1.22046560e-01f, 1.40818685e-01f, -1.76293433e-01f, -1.99130699e-02f, 1.15916967e-01f, 4.49271798e-02f, -2.56459136e-02f, -9.85589921e-02f,
  -1.42500192e-01f, -1.97208077e-01f, 1.44553576e-02f, -8.18318203e-02f, 8.94227773e-02f, 1.26755267e-01f, 1.91484004e-01f, 2.26103157e-01f, 1.31451078e-02f, -9.30023491e-02f,
  -1.90926015e-01f, 7.79110268e-02f, 1.19197473e-01f, 9.36545357e-02f, -1.22381344e-01f, -9.12082791e-02f, -8.78392458e-02f, 8.09054598e-02f, -1.60785422e-01f, -8.14987049e-02f,
  -1.30072773e-01f, 2.38914937e-01f, -2.00422723e-02f, -5.13954684e-02f, -3.60309705e-02f, 6.88553080e-02f, 7.17089921e-02f, 7.60909617e-02f, -6.50955364e-02f, -3.47522125e-02f,
  -3.28488611e-02f, 1.42816706e-02f, 8.82612318e-02f, -3.12672071e-02f, 3.96156162e-02f, 1.08193897e-01f, 7.50445649e-02f, 1.74371406e-01f, 9.57401246e-02f, 2.12128367e-02f,
  -1.22217417e-01f, 1.27377316e-01f, 6.04611188e-02f, -5.38047627e-02f, 1.35227367e-01f, 2.67049018e-02f, 1.14317555e-02f, 3.97326760e-02f, 1.86016262e-02f, 4.41566557e-02f,
  -3.95669378e-02f, -3.21710967e-02f, -5.05788922e-02f, 3.84165011e-02f, -4.48958278e-02f, -6.51470050e-02f, 1.75816026e-02f, -4.59252186e-02f, 1.19873062e-02f, -4.71384712e-02f,
  -3.53718922e-02f, -7.18322350e-04f, -5.25422581e-03f, 6.09526262e-02f, -4.65397015e-02f, 5.32304496e-02f, 3.06210015e-02f, -8.03498104e-02f, 9.61118285e-03f, 4.54039127e-02f,
  -6.70313314e-02f, 5.63155934e-02f, 4.00193818e-02f, -2.93869711e-02f, 5.15821688e-02f, 3.56409559e-03f, 3.32177468e-02f, -2.78724544e-02f, 3.52449156e-02f, -4.01268676e-02f,
  -7.42897689e-02f, 1.27705351e-01f, -5.55331856e-02f, 4.98518981e-02f, -1.04612578e-02f, -7.77695775e-02f, -1.29901215e-01f, 1.64336921e-03f, 2.60816701e-03f, 4.51650657e-02f,
  -5.44464365e-02f, 5.88806383e-02f, -4.30934727e-02f, -7.20591173e-02f, -1.66448317e-02f, -8.01879466e-02f, -1.09369010e-01f, 1.10228620e-02f, -3.92981485e-04f, -1.09669358e-01f,
  -7.73324370e-02f, -9.52418894e-03f, 6.48462921e-02f, -1.32475523e-02f, -1.14588246e-01f, 3.64829712e-02f, -1.11484706e-01f, -8.17246884e-02f, 2.03066003e-02f, 3.30816978e-03f
};

// L0_fan_Wp_bar (Shape: 40 x 120)
const int L0_fan_Wp_bar_rows = 40;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -2.35472754e-01f, -8.07911158e-02f, -6.38270751e-02f, -2.50278294e-01f, 8.87520015e-02f, 7.06294924e-02f, 1.06146455e-01f, 9.40221623e-02f, -9.16533694e-02f, -1.66599497e-01f,
  3.89012210e-02f, 3.23097296e-02f, -1.28868734e-02f, 5.91433048e-02f, 3.43644395e-02f, -9.00006890e-02f, -1.63909838e-01f, 4.56188768e-02f, 1.07512832e-01f, 1.37464523e-01f,
  1.39350772e-01f, 2.71245260e-02f, 6.14474863e-02f, 6.83021173e-02f, -1.80812195e-01f, 2.71638390e-02f, -6.99751899e-02f, 3.82628874e-04f, -1.09950811e-01f, -1.39519900e-01f,
  -1.69272676e-01f, -2.80217063e-02f, 7.85084814e-02f, 2.72453809e-03f, 5.62493801e-02f, -4.39501442e-02f, -3.97427045e-02f, -5.99127859e-02f, 3.65902595e-02f, -9.70249996e-02f,
  1.81606058e-02f, 7.92147666e-02f, -2.00641695e-02f, -3.69552858e-02f, 7.04380125e-02f, 2.52651256e-02f, 2.08368469e-02f, 1.47635844e-02f, 2.71219146e-02f, -5.88292666e-02f,
  7.67365471e-02f, -5.21247229e-03f, -1.06668836e-02f, -2.51901373e-02f, -8.19032639e-02f, -1.03088193e-01f, -1.44357398e-01f, -7.91010186e-02f, -9.25835371e-02f, -2.70979136e-01f,
  -6.74019149e-03f, -5.78366145e-02f, -9.97557864e-03f, -2.67331619e-02f, -8.31833482e-02f, 5.02601564e-02f, -6.53750226e-02f, 4.73141335e-02f, 8.24940801e-02f, 4.97849882e-02f,
  9.09246802e-02f, 6.59784600e-02f, -3.70203108e-02f, -6.03183173e-02f, 3.19531597e-02f, -4.17473465e-02f, 9.27885324e-02f, -3.19544435e-03f, -6.24459870e-02f, 1.67046897e-02f,
  5.74391596e-02f, 2.59886449e-03f, 3.85385938e-03f, -5.81700541e-02f, 4.01449092e-02f, -7.55833164e-02f, -1.87223684e-02f, 4.66357768e-02f, 4.84195538e-02f, -6.84459209e-02f,
  -1.41882554e-01f, 9.75611433e-02f, -1.49255723e-01f, -6.17101118e-02f, -8.55240151e-02f, 1.36688314e-02f, -4.19365615e-02f, 4.18416560e-02f, 7.29680853e-03f, -4.57618050e-02f,
  1.04045924e-02f, -3.91030125e-02f, -4.53502126e-02f, 2.24601403e-02f, -4.51590633e-03f, -6.08471781e-02f, -1.31868392e-01f, 2.59104669e-02f, 2.76799705e-02f, -8.75856429e-02f,
  -9.17383581e-02f, 8.36010184e-03f, -6.16684407e-02f, -7.39907250e-02f, -1.22973517e-01f, -8.21708068e-02f, -1.07758462e-01f, -9.62894708e-02f, -1.86294779e-01f, -2.91590482e-01f,
  -2.77032971e-01f, 3.05219293e-02f, -7.85025582e-02f, -3.12646121e-01f, -6.39989227e-02f, -7.75668677e-03f, -1.36302016e-03f, -4.00960408e-02f, -1.16722314e-02f, -2.72106696e-02f,
  -1.06304809e-01f, 2.49694698e-02f, -9.25061479e-02f, 4.94517796e-02f, 1.74994338e-02f, -4.37006392e-02f, -2.49317102e-02f, -9.31566656e-02f, 6.39362410e-02f, -4.23905179e-02f,
  -8.89857709e-02f, -1.44740403e-01f, -1.69519991e-01f, -1.22796915e-01f, -1.43546969e-01f, -1.13388374e-01f, -8.26596990e-02f, -1.09780155e-01f, -4.93753031e-02f, -1.65698662e-01f,
  -7.01456890e-02f, -1.16098188e-01f, 2.38451455e-02f, 6.42068684e-02f, -5.46262693e-03f, 3.53851132e-02f, 5.59591912e-02f, -9.80148390e-02f, -5.44366799e-02f, -4.85907756e-02f,
  -1.03077069e-01f, 4.54345308e-02f, 4.50567938e-02f, -1.37637826e-02f, -7.68631771e-02f, -5.74937128e-02f, -6.61238506e-02f, -2.66814418e-02f, 9.66047719e-02f, 1.07392900e-01f,
  -1.85789280e-02f, -6.96535558e-02f, 4.58632968e-03f, 1.10121399e-01f, 2.30996050e-02f, 5.71627170e-02f, 4.16650698e-02f, -2.99246106e-02f, 1.23268783e-01f, -2.43566046e-03f,
  1.28130391e-02f, -8.36043060e-02f, -1.32619767e-02f, 5.76068424e-02f, 3.74381468e-02f, -4.76065800e-02f, -6.57745823e-02f, -1.09998723e-02f, -7.09985197e-02f, 1.14195496e-02f,
  4.77377549e-02f, -6.47401288e-02f, 1.10054594e-02f, -3.61081213e-02f, -8.29925165e-02f, 2.85945963e-02f, -1.82592943e-02f, 7.69281015e-02f, -9.07890312e-03f, -3.89307961e-02f,
  -1.84615366e-02f, 6.36292100e-02f, -7.32182898e-03f, -2.70271599e-02f, 1.21130705e-01f, 8.10032524e-03f, 5.32605238e-02f, 1.42493725e-01f, 4.17976156e-02f, -5.62824011e-02f,
  -5.04968502e-02f, 7.45777637e-02f, 1.08398441e-02f, -5.98820113e-02f, -8.74820650e-02f, 2.09096652e-02f, -4.50760089e-02f, 1.56393182e-02f, -5.04304990e-02f, 1.38002122e-02f,
  1.03661016e-01f, -5.18577434e-02f, -3.54650393e-02f, 6.16170168e-02f, -4.52530570e-02f, -4.83861938e-02f, -8.93128291e-02f, -6.57846685e-03f, 2.96850689e-02f, -4.38423753e-02f,
  -6.52676299e-02f, 1.38558466e-02f, 5.40601946e-02f, -3.27577889e-02f, -5.42372353e-02f, 9.17732120e-02f, -3.17707434e-02f, 7.62636289e-02f, 1.08546689e-01f, -1.42778039e-01f,
  -4.19544503e-02f, 4.54072021e-02f, -3.60419489e-02f, -1.02792323e-01f, -9.25070643e-02f, -2.63049919e-02f, -5.06550893e-02f, -1.19144559e-01f, -1.16888478e-01f, 5.84996045e-02f,
  2.47355574e-03f, 3.06004938e-02f, -2.91336863e-03f, 1.85280200e-02f, 1.50143458e-02f, 1.27610750e-02f, 7.19671547e-02f, 2.25484259e-02f, -1.69767499e-01f, -3.92245725e-02f,
  1.16187083e-02f, -5.33916987e-02f, 1.22727535e-03f, -1.47505328e-01f, -2.39134431e-02f, -1.03404641e-01f, 7.26692472e-03f, -6.08873740e-02f, -3.01295146e-02f, 2.57179067e-02f,
  2.19036102e-01f, -1.61043286e-01f, -7.58596659e-02f, -8.90311375e-02f, 6.47905096e-02f, -1.59756131e-02f, -2.17471160e-02f, -8.60147998e-02f, -5.95546365e-02f, -2.42858324e-02f,
  1.83142181e-02f, -1.10304449e-02f, -2.19304115e-03f, -2.57258932e-03f, 3.32629606e-02f, -8.15562755e-02f, -8.19351971e-02f, -1.00627691e-02f, -9.83170122e-02f, 5.63024729e-02f,
  -9.02050585e-02f, -6.53134212e-02f, -4.88920435e-02f, 4.85556014e-03f, -7.36697540e-02f, -1.11077413e-01f, -6.27704635e-02f, -1.07776806e-01f, -6.24681674e-02f, 5.58704026e-02f,
  4.90705259e-02f, 8.09011832e-02f, -3.65337171e-02f, -2.78910305e-02f, 4.67793085e-02f, 8.41825306e-02f, -8.83692801e-02f, -1.98721848e-02f, -6.89221472e-02f, 4.83083948e-02f,
  4.88450304e-02f, 1.28884213e-02f, 7.30798021e-02f, 8.25353041e-02f, 1.15706222e-02f, -1.79289021e-02f, -7.60122389e-02f, 1.02265857e-01f, 1.60799082e-02f, 1.02886148e-02f,
  -7.25030452e-02f, -2.98192799e-02f, -4.70326282e-02f, 7.09645972e-02f, -8.42301920e-02f, 2.13517528e-02f, -4.99219298e-02f, -1.73768103e-02f, -5.67074791e-02f, -2.52938662e-02f,
  2.76237369e-01f, -1.53025240e-01f, 1.20717727e-01f, -2.24610344e-02f, -4.03656363e-02f, -1.75500996e-02f, 5.84463216e-02f, -4.27712165e-02f, 2.11909022e-02f, 8.96891505e-02f,
  -6.81026876e-02f, 4.72640134e-02f, 8.08740780e-02f, 2.36083046e-02f, -8.66148844e-02f, -6.02776650e-03f, 5.94173884e-03f, 6.31797239e-02f, -4.86119539e-02f, 1.71455778e-02f,
  -4.40642014e-02f, 7.37380832e-02f, 1.19670242e-01f, 5.85004203e-02f, 9.54546413e-05f, 8.21242705e-02f, 3.68637070e-02f, 2.39610188e-02f, 6.58713207e-02f, 1.34303719e-01f,
  -1.12207010e-01f, -1.66192781e-02f, -5.76468967e-02f, -5.42661846e-02f, -1.41131029e-01f, -7.58981928e-02f, -1.04997858e-01f, -3.58050987e-02f, 3.56584154e-02f, -1.51917085e-01f,
  -5.89517765e-02f, -1.28363386e-01f, -1.02854744e-02f, 1.90750342e-02f, -8.08524713e-03f, -7.73814246e-02f, -1.98332399e-01f, -1.95614263e-01f, -1.31600484e-01f, -4.15291972e-02f,
  -1.15800068e-01f, -1.16360717e-01f, -6.48574680e-02f, -4.93250750e-02f, -2.89485455e-02f, 3.29732662e-03f, -2.48933341e-02f, -6.12982884e-02f, -1.78337339e-02f, -1.27067223e-01f,
  -6.08852319e-02f, 3.11348238e-03f, 2.90057641e-02f, 2.33915858e-02f, 5.82022667e-02f, 6.75617252e-03f, -6.04350418e-02f, 6.47869110e-02f, 2.49907691e-02f, 3.51614915e-02f,
  -4.86786887e-02f, -3.21710035e-02f, 6.84850141e-02f, 5.79630807e-02f, 3.16995755e-02f, 8.35006982e-02f, 1.13780741e-02f, -4.06981111e-02f, -5.35012260e-02f, -7.19362795e-02f,
  -1.21135637e-01f, -1.04471736e-01f, -9.00838803e-03f, 3.85723300e-02f, 7.48096853e-02f, -1.21550404e-01f, -5.93093224e-02f, 8.95732865e-02f, 8.50691050e-02f, 5.33598568e-03f,
  -5.01715690e-02f, 7.23720994e-03f, 2.68888939e-03f, -8.85575078e-03f, -1.72923785e-02f, -3.83179076e-02f, -1.79401878e-02f, 5.62392659e-02f, 1.60323698e-02f, -8.49007070e-03f,
  -4.86491174e-02f, 6.80952445e-02f, -1.13935862e-02f, 1.28452443e-02f, -2.87374854e-03f, 1.75989661e-02f, 3.11164949e-02f, 9.60046332e-03f, -5.31871878e-02f, -7.72306621e-02f,
  4.75146510e-02f, -9.19646546e-02f, -4.68708202e-02f, 7.57145807e-02f, -4.82043922e-02f, -8.39450061e-02f, -9.69568118e-02f, -5.46423979e-02f, -1.20008260e-01f, -5.17649613e-02f,
  -6.02531247e-02f, -3.59712020e-02f, -7.20578730e-02f, -7.28185251e-02f, 9.26409662e-02f, 8.66553485e-02f, -5.73977940e-02f, 1.17199961e-02f, 9.84046794e-03f, 3.58220004e-02f,
  4.87221479e-02f, 6.86885938e-02f, 1.85864773e-02f, 3.98674421e-02f, -1.24819614e-02f, 5.80964312e-02f, 1.46267070e-02f, 3.92806623e-03f, 5.47679812e-02f, -1.41677884e-02f,
  -5.73520474e-02f, -8.14534840e-04f, -3.95589620e-02f, -6.89251423e-02f, 4.71520014e-02f, -9.09937993e-02f, -7.96490610e-02f, -5.68655208e-02f, -1.34503618e-01f, -1.06651708e-01f,
  1.44927070e-01f, -7.12549463e-02f, 6.96152598e-02f, 2.53418554e-02f, 1.16558364e-02f, -7.86494017e-02f, -4.10889834e-02f, -6.66349307e-02f, -6.76745027e-02f, 1.18819345e-02f,
  5.37952036e-02f, 7.93317780e-02f, -6.60021603e-02f, -1.34271219e-01f, -1.09532706e-01f, -2.92074718e-02f, 1.42176477e-02f, -1.56166971e-01f, -1.07829347e-01f, -1.88926697e-01f,
  -6.52510002e-02f, -1.27630144e-01f, -6.01388291e-02f, -1.19766004e-01f, 9.02148783e-02f, -7.25817168e-04f, 4.68929112e-02f, 8.73957574e-02f, 7.99302384e-02f, 1.08740747e-01f,
  1.64142013e-01f, 8.40111747e-02f, -1.87906846e-02f, 1.69428363e-02f, 1.12150051e-02f, 7.12427199e-02f, -4.26691286e-02f, -1.83483735e-02f, 3.70710529e-02f, -2.82462295e-02f,
  -6.65884092e-02f, 1.48658978e-03f, -6.82133958e-02f, -1.16335444e-01f, -1.15528241e-01f, -1.13453299e-01f, 1.65724903e-02f, -2.36658547e-02f, -1.02272332e-01f, 1.59193925e-03f,
  3.88001725e-02f, 1.46106677e-02f, -9.57705975e-02f, -6.77573606e-02f, 7.60388421e-03f, 4.86507379e-02f, -3.40429172e-02f, -3.99863385e-02f, 6.51289597e-02f, 7.15941787e-02f,
  -2.35074535e-02f, -5.54121286e-03f, 5.39841168e-02f, -6.20068982e-02f, 8.81654583e-03f, 1.04877964e-01f, 2.26548966e-02f, 6.03226498e-02f, 6.49472652e-03f, -1.92567948e-02f,
  -5.83592281e-02f, -5.03191836e-02f, -7.95509070e-02f, -9.10660438e-03f, 6.77413419e-02f, 7.46614933e-02f, -5.85100874e-02f, -5.23385704e-02f, 5.50320856e-02f, 3.33790891e-02f,
  4.91765607e-03f, 3.80433239e-02f, 8.52188244e-02f, 4.21633944e-02f, -5.48121147e-02f, -2.34477557e-02f, -2.92732250e-02f, 1.99499875e-02f, 4.48238151e-03f, -7.71959275e-02f,
  1.04069963e-01f, -1.36364967e-01f, 1.03522398e-01f, -1.15328413e-02f, 6.59395754e-02f, 3.13777104e-02f, -8.16417206e-03f, 1.23593975e-02f, 6.81293383e-02f, -9.00503993e-02f,
  -4.12846990e-02f, -8.22906010e-03f, -2.07108669e-02f, -1.31471092e-02f, -6.01974428e-02f, -1.24567211e-01f, -1.16203837e-01f, -2.18140800e-02f, -6.83270488e-03f, 3.08620557e-02f,
  -7.16714785e-02f, -1.94703843e-02f, 8.59181136e-02f, 4.54094075e-02f, -4.36561070e-02f, 7.24627152e-02f, 8.21585506e-02f, 1.18544195e-02f, -4.85529937e-02f, 4.94098105e-02f,
  -1.89674661e-01f, -2.07865648e-02f, 2.55550281e-03f, -1.65513940e-02f, 1.27251491e-01f, 1.50652334e-01f, 5.33602946e-02f, 1.12804778e-01f, 1.12394057e-01f, 3.11403982e-02f,
  -1.23040862e-01f, 3.32630761e-02f, -4.41189408e-02f, 1.63607448e-02f, -7.06621408e-02f, 7.87659287e-02f, 1.41853407e-01f, -3.58754285e-02f, 3.04175038e-02f, 9.04795453e-02f,
  -2.47643329e-02f, 9.21643823e-02f, -2.68519968e-02f, 1.33299325e-02f, 1.03603154e-01f, -5.36539294e-02f, -2.28568725e-02f, -8.58185887e-02f, 8.89367983e-02f, 1.32806012e-02f,
  5.89438900e-03f, -2.06149831e-01f, 3.27741206e-02f, 2.57757809e-02f, -1.25376526e-02f, -5.96750043e-02f, -1.35331992e-02f, 3.30586508e-02f, 1.87845137e-02f, 1.27071172e-01f,
  -2.58230697e-02f, -9.37567875e-02f, 4.06332910e-02f, 7.95534551e-02f, -6.02301434e-02f, 7.82958716e-02f, -1.07266799e-01f, -1.27139147e-02f, -4.55832221e-02f, 3.96145470e-02f,
  5.80014810e-02f, 1.75470337e-02f, -3.48623954e-02f, 5.09938896e-02f, 2.95888260e-02f, -6.98148878e-03f, -2.72412226e-02f, -1.22087412e-01f, -7.88894948e-03f, 6.58710748e-02f,
  -5.70569634e-02f, -8.09181556e-02f, 2.75517628e-03f, -1.43465763e-02f, -4.04413827e-02f, 5.81600703e-02f, 1.21879280e-02f, -6.28003851e-02f, 8.63173306e-02f, 4.56619635e-02f,
  -3.87290828e-02f, -2.17761323e-02f, -4.54821885e-02f, 1.55856572e-02f, 5.29939570e-02f, -7.49479234e-02f, 7.50847980e-02f, -6.26990199e-02f, 3.91345248e-02f, -5.58843501e-02f,
  -2.59270221e-02f, -5.81840053e-02f, -4.88315821e-02f, 2.96556000e-02f, 3.99183705e-02f, -3.69339734e-02f, 1.50216920e-02f, -3.68837565e-02f, 7.64746219e-02f, -6.32885471e-02f,
  9.02299732e-02f, -8.16623271e-02f, -3.00337002e-02f, -1.41092231e-02f, -4.78514507e-02f, -4.64606918e-02f, -1.11151032e-01f, -5.07304333e-02f, 3.49079221e-02f, -3.99518870e-02f,
  -9.71776843e-02f, -8.12759995e-03f, 1.17796781e-02f, -8.55785832e-02f, -1.95263363e-02f, 3.41582038e-02f, -7.68304244e-02f, 2.52231322e-02f, -8.45770761e-02f, -1.46198934e-02f,
  -1.43422652e-02f, 1.19063750e-01f, 1.04333133e-01f, 5.66251874e-02f, -1.10862106e-02f, 5.30741401e-02f, 1.31535009e-01f, 3.02079935e-02f, 4.95758355e-02f, 2.04304248e-01f,
  -4.60789539e-02f, -1.71218574e-01f, 3.99036109e-02f, -1.80025846e-01f, -7.72504285e-02f, 1.11956140e-02f, -1.05165750e-01f, -1.30865574e-01f, -1.53697893e-01f, -8.87033269e-02f,
  5.61923198e-02f, 1.67745173e-01f, 1.85571223e-01f, 8.27197731e-02f, 1.19977526e-01f, 1.57553609e-02f, -1.32402062e-01f, 5.67328359e-04f, 1.87151328e-01f, 7.70037808e-03f,
  1.17941294e-02f, -6.98862001e-02f, 6.21946529e-02f, -7.29979053e-02f, -7.30425566e-02f, -1.33403372e-02f, -1.09650880e-01f, -3.93504687e-02f, 2.64391839e-03f, -1.78813457e-01f,
  2.83243060e-01f, -8.89933482e-02f, 1.47392629e-02f, 5.27473949e-02f, 7.91796658e-04f, -6.85404912e-02f, 2.08229478e-02f, 3.01118046e-02f, 2.94018108e-02f, -6.45496249e-02f,
  -7.51367509e-02f, -1.64656453e-02f, 7.00036883e-02f, -7.79284090e-02f, 6.47642463e-03f, 8.41225218e-03f, -1.03342235e-01f, 4.77741770e-02f, -6.97117820e-02f, 2.98550222e-02f,
  -1.13043554e-01f, 4.29035276e-02f, 1.43982485e-01f, 3.94529589e-02f, 6.46841824e-02f, 2.73027513e-02f, 6.83146268e-02f, -7.37401694e-02f, 1.00823931e-01f, -7.96833634e-02f,
  -7.35562760e-03f, 1.10640824e-01f, 9.89839882e-02f, -5.70421219e-02f, 4.77942526e-02f, -1.37484865e-02f, -5.48242638e-03f, 1.56764090e-02f, 3.45005058e-02f, 8.82056952e-02f,
  -2.29715314e-02f, -4.93569896e-02f, -5.68835773e-02f, 2.15319525e-02f, 3.04447357e-02f, 6.36740960e-03f, -3.96831967e-02f, 3.42043862e-02f, -1.15190605e-02f, -2.27525402e-02f,
  -2.46380847e-02f, -5.78927482e-03f, -2.23625749e-02f, 5.77725843e-02f, -6.56037480e-02f, 1.57928932e-02f, 3.26582007e-02f, 1.63272477e-03f, 1.76196750e-02f, -8.90857503e-02f,
  1.07432693e-01f, 5.73432669e-02f, 1.99643839e-02f, 8.54418799e-02f, 6.32773526e-03f, -1.01613097e-01f, 6.97123930e-02f, 5.22234105e-02f, -1.29041255e-01f, -8.21365044e-03f,
  5.80503345e-02f, 1.20133033e-03f, 6.27298430e-02f, -4.78059240e-02f, 9.34873766e-04f, 5.30981272e-02f, -2.12884713e-02f, -2.54731197e-02f, 9.91151482e-03f, -5.15721366e-02f,
  -1.40982747e-01f, -6.02129102e-03f, 2.00671434e-01f, 5.21303192e-02f, -3.29936445e-02f, 9.82090011e-02f, 1.45579070e-01f, 1.09613672e-01f, 5.79139851e-02f, -1.08001851e-01f,
  2.94319633e-02f, -1.32911906e-01f, -8.27971175e-02f, 7.60147721e-02f, 1.53653277e-02f, -5.26278503e-02f, -1.98204771e-01f, -1.01075001e-01f, -1.06049413e-02f, -8.62675086e-02f,
  -6.54569939e-02f, -1.73564050e-02f, -1.03036590e-01f, -5.05496934e-02f, 9.48121678e-03f, -7.77561357e-03f, -3.27367969e-02f, -3.88141945e-02f, 8.65890011e-02f, 5.44577017e-02f,
  6.27865121e-02f, 1.99268937e-01f, 6.96459562e-02f, 1.29281133e-02f, 1.09076202e-01f, -2.29033660e-02f, -5.49473688e-02f, -1.66318342e-02f, 4.16269861e-02f, -3.27162854e-02f,
  -5.01496270e-02f, -1.23963691e-01f, 3.80241834e-02f, 5.87393120e-02f, 7.26567730e-02f, -2.07946002e-02f, -6.90870509e-02f, -3.37302424e-02f, -6.72387630e-02f, -6.34204447e-02f,
  -5.04764076e-03f, 4.37212028e-02f, -2.71002110e-02f, -4.61178571e-02f, -3.96287628e-02f, 1.09722074e-02f, 1.38529949e-02f, -1.04365163e-01f, -1.21308990e-01f, 6.21139654e-04f,
  -1.28430303e-03f, -1.78275071e-02f, -1.12220041e-01f, -8.72073546e-02f, 4.04602895e-03f, -6.24167360e-02f, -7.38861933e-02f, -6.76551908e-02f, -3.83627489e-02f, 4.38693576e-02f,
  -4.98887002e-02f, -9.37405005e-02f, 3.90635729e-02f, 3.24874371e-02f, 2.08502519e-03f, -8.21152627e-02f, 5.83340228e-02f, 8.15631747e-02f, 9.50797945e-02f, 1.92577783e-02f,
  -3.21609527e-03f, -2.57346649e-02f, 3.13589200e-02f, 3.20366211e-02f, 2.57649943e-02f, 5.94659746e-02f, -3.64671946e-02f, 9.19186473e-02f, -6.87267259e-02f, 4.22270894e-02f,
  -3.48731726e-02f, 6.22313023e-02f, 2.80638635e-02f, 2.03959290e-02f, -8.64579603e-02f, 5.53893931e-02f, 4.08902206e-02f, 6.19398952e-02f, -7.21065179e-02f, -3.48481312e-02f,
  3.93268690e-02f, -7.56563246e-02f, 4.86053564e-02f, -6.54127225e-02f, 6.22596145e-02f, -4.28254530e-02f, 5.19521125e-02f, 8.95413160e-02f, 8.48234817e-02f, 1.63294878e-02f,
  -5.34098707e-02f, -3.22449021e-02f, -8.09719115e-02f, -2.38440912e-02f, 7.94825107e-02f, 3.65041867e-02f, -7.44076148e-02f, -8.33271518e-02f, 4.48878817e-02f, 8.10679942e-02f,
  5.61729409e-02f, -5.07915020e-02f, 3.05886362e-02f, -8.81743729e-02f, 2.84514930e-02f, -2.98443865e-02f, -7.83964619e-02f, -6.21463545e-02f, -3.87835354e-02f, 7.15720430e-02f,
  -3.41292880e-02f, -2.41174232e-02f, -1.73126087e-01f, -7.58862346e-02f, -5.36960503e-03f, 6.52369708e-02f, 2.73624249e-02f, 9.16969776e-02f, 5.55718541e-02f, 5.53127117e-02f,
  3.05620693e-02f, 9.30302516e-02f, 1.08261798e-02f, -6.87795430e-02f, -6.84233308e-02f, 2.91842576e-02f, -2.23331545e-02f, -2.73209848e-02f, 2.30408628e-02f, 1.03028595e-01f,
  5.43793477e-02f, 8.99814591e-02f, 3.45249777e-03f, 4.65544350e-02f, -2.30126898e-04f, -3.95599082e-02f, 6.27785921e-02f, -6.76666424e-02f, -8.36522784e-03f, -4.40551201e-03f,
  4.97448184e-02f, -1.29916251e-01f, -6.88258111e-02f, -4.77966964e-02f, 3.94537151e-02f, 3.12940776e-02f, -8.71142000e-02f, -3.02398782e-02f, -6.47436231e-02f, -4.07935046e-02f,
  4.31893729e-02f, 8.14023167e-02f, -4.02294397e-02f, 2.31155776e-04f, -6.91857114e-02f, -3.95170972e-02f, 2.42430437e-02f, -5.04593253e-02f, -9.63530596e-03f, -2.23639533e-02f,
  -6.29431605e-02f, -2.11648103e-02f, -9.81977489e-03f, -2.26937961e-02f, 1.30374813e-02f, -4.09574360e-02f, -6.14806786e-02f, -9.66578647e-02f, -1.10990711e-01f, 3.51002626e-02f,
  -5.10831214e-02f, -2.74595153e-03f, -6.11496940e-02f, -4.15684395e-02f, -7.10765496e-02f, 1.39926793e-02f, 7.87099004e-02f, 5.93446419e-02f, 1.17873373e-02f, -2.50461102e-02f,
  -3.17401253e-02f, -3.31733422e-03f, 9.27710012e-02f, 7.08544701e-02f, -2.27409638e-02f, 7.71500692e-02f, -4.44401018e-02f, 3.80890481e-02f, -8.69328156e-02f, 6.27775118e-02f,
  -8.34121704e-02f, -1.20423073e-02f, -5.66090308e-02f, 1.70197003e-02f, 1.75478794e-02f, 8.02106969e-03f, -5.52874506e-02f, -2.52528116e-02f, -8.17129016e-03f, 4.89790216e-02f,
  3.36800106e-02f, -2.26429515e-02f, -2.15811469e-02f, -5.30877523e-02f, -8.81608799e-02f, 2.98586506e-02f, -1.51431682e-02f, 4.17973809e-02f, 2.85582729e-02f, -5.56643456e-02f,
  1.79335615e-03f, 7.05532581e-02f, 2.29052436e-02f, -9.18809026e-02f, -7.74967596e-02f, -3.99307311e-02f, -1.56079512e-02f, 5.79037778e-02f, 7.47655006e-03f, -5.88933267e-02f,
  1.47834430e-02f, -2.12638527e-02f, -3.28431875e-02f, 6.75368756e-02f, -6.86561987e-02f, -1.20929554e-02f, 3.16070095e-02f, -6.66625611e-03f, -1.34692071e-02f, 5.52733690e-02f,
  1.61249518e-01f, -4.79879156e-02f, 7.79416934e-02f, 1.19723313e-01f, -2.24601217e-02f, -1.48140639e-01f, -1.58295870e-01f, -1.08529948e-01f, 7.88737014e-02f, -1.67529914e-03f,
  1.04935272e-02f, 6.77964389e-02f, -9.99017581e-02f, -1.21195644e-01f, -9.59164184e-03f, 6.43217042e-02f, -3.89884599e-02f, 1.17951326e-01f, 4.83117700e-02f, -1.54431732e-02f,
  -2.22367439e-02f, 1.50742054e-01f, 1.12352140e-01f, -8.37072171e-03f, 1.16779469e-01f, 3.71027142e-02f, 3.33887711e-02f, 1.03162872e-02f, 9.51499119e-02f, 4.06606160e-02f,
  1.36483341e-01f, -9.92349759e-02f, 8.02868232e-02f, -1.61282774e-02f, -7.53156841e-03f, 1.43199172e-02f, 7.42231160e-02f, -4.14950065e-02f, -1.09127283e-01f, -1.91250909e-02f,
  -4.62008864e-02f, -2.45697368e-02f, -6.47510216e-02f, -5.79429530e-02f, 6.27795905e-02f, 1.01141888e-03f, -2.84381174e-02f, -3.25497575e-02f, -6.29604310e-02f, 2.06500478e-02f,
  3.77043970e-02f, 4.92893793e-02f, -6.46086782e-02f, -1.29350156e-01f, -8.72614533e-02f, 2.27322336e-02f, -6.93343952e-02f, 3.83731313e-02f, -6.80452883e-02f, 2.40549576e-02f,
  5.72486520e-02f, -5.04794754e-02f, 2.46218611e-02f, -8.65240116e-03f, 5.61118685e-02f, 7.84883648e-03f, 5.72353378e-02f, -1.52059579e-02f, 2.30297074e-02f, 5.61553240e-02f,
  -1.05487049e-01f, 3.75721566e-02f, 1.31953750e-02f, 4.15569060e-02f, -7.90154189e-02f, 2.24681590e-02f, 6.90916693e-03f, -3.14587131e-02f, -6.19445182e-02f, 2.25739665e-02f,
  5.34801036e-02f, -7.72036463e-02f, -3.21953744e-02f, -5.69887972e-03f, 6.40441626e-02f, -5.60543388e-02f, -6.15672162e-03f, 6.99700937e-02f, -2.95322109e-02f, -1.08690001e-02f,
  7.07455426e-02f, -1.60089463e-01f, 1.06203735e-01f, -2.43543424e-02f, 8.91295522e-02f, -2.20421106e-02f, -6.26893863e-02f, -6.25087693e-02f, -1.83770061e-02f, 1.56419687e-02f,
  1.30336033e-02f, -3.45396474e-02f, -2.09258087e-02f, -6.25104681e-02f, 5.05069979e-02f, 1.97226070e-02f, 5.30889332e-02f, 7.50029609e-02f, -3.81542556e-02f, -3.28392908e-02f,
  -6.47557452e-02f, 7.35919103e-02f, 8.63318518e-02f, -5.19781150e-02f, -6.98070899e-02f, 5.23767695e-02f, 1.61470082e-02f, -7.80121535e-02f, 5.94457760e-02f, -4.12154421e-02f,
  -5.51323891e-02f, -8.68889764e-02f, -7.34734312e-02f, 7.72279352e-02f, 2.14817785e-02f, -1.24622852e-01f, -1.74810067e-01f, -1.08999245e-01f, 2.03418615e-03f, 6.65020943e-02f,
  -2.35737953e-02f, 6.67118207e-02f, 7.89949670e-02f, 5.84769472e-02f, -1.00185499e-01f, -5.75777888e-02f, -2.91147362e-02f, -1.37512267e-01f, -1.00811832e-01f, 3.80864143e-02f,
  2.03989800e-02f, 5.31326123e-02f, 5.10298051e-02f, -2.46443097e-02f, 1.10019624e-01f, 1.16509363e-01f, -5.29412627e-02f, -1.16589218e-02f, -2.78453995e-02f, -2.76047587e-02f,
  2.93003410e-01f, -2.69233007e-02f, -3.25928070e-02f, -3.01338863e-02f, -7.38069834e-03f, 3.29563604e-03f, -4.99695241e-02f, -4.48283628e-02f, 2.88762506e-02f, -6.82841763e-02f,
  9.19622704e-02f, 5.76396659e-02f, 8.05327483e-03f, 6.15702271e-02f, -2.48422008e-02f, -5.25298826e-02f, -4.01229449e-02f, -1.17224209e-01f, -3.15510370e-02f, 7.54425898e-02f,
  8.14079866e-02f, 3.29525210e-02f, 5.35965934e-02f, 7.04580173e-03f, -1.17037706e-01f, -1.14321850e-01f, 4.23182361e-02f, -7.25482851e-02f, -4.40957919e-02f, -4.91000004e-02f,
  -8.92180800e-02f, -5.87419420e-02f, -1.86194349e-02f, -6.08344525e-02f, -1.02310185e-03f, -2.33170576e-02f, 2.40889136e-02f, 3.87525707e-02f, -1.59559548e-02f, 4.88725752e-02f,
  3.41537222e-02f, 1.87568143e-02f, 1.33187948e-02f, 6.50001457e-03f, 9.08629503e-03f, 4.05345187e-02f, 3.53522003e-02f, -7.49466345e-02f, -2.80084331e-02f, 2.77134753e-03f,
  -5.97323030e-02f, 1.65091548e-02f, -2.82369344e-03f, 1.94956455e-02f, -1.06526194e-02f, -1.31360009e-01f, 2.87396926e-02f, -1.57291014e-02f, 2.25864220e-02f, -8.47231746e-02f,
  2.43263736e-01f, -1.13909103e-01f, -3.61485071e-02f, 3.76568101e-02f, 4.50755507e-02f, 6.72873780e-02f, 6.25137761e-02f, -3.42161395e-02f, 9.45041850e-02f, -2.20135655e-02f,
  -7.07886815e-02f, -4.55369055e-03f, -3.42810340e-02f, 1.01958250e-03f, 4.90297079e-02f, 8.06097165e-02f, -7.44097829e-02f, 5.42643704e-02f, -3.74211483e-02f, -5.72537296e-02f,
  -1.60827972e-02f, -1.35728046e-02f, 7.60463849e-02f, 2.57728454e-02f, -4.79973899e-03f, 4.10772488e-02f, 7.58481175e-02f, 7.24167228e-02f, -9.42310914e-02f, 4.07856070e-02f,
  3.74319792e-01f, 1.65251404e-01f, 7.01979697e-02f, 6.22504242e-02f, -2.93259472e-01f, -2.46807277e-01f, -9.88377929e-02f, -1.38533786e-01f, 8.62815604e-02f, 1.53129529e-02f,
  -1.67548150e-01f, -2.13239845e-02f, -1.14331767e-01f, 8.77519324e-03f, 2.27959789e-02f, 1.03359126e-01f, 9.19242874e-02f, 1.63472116e-01f, -4.91768681e-02f, 3.59736271e-02f,
  -1.04799025e-01f, 8.60681757e-02f, 1.34127632e-01f, 3.72754745e-02f, 5.55249378e-02f, -1.33748621e-01f, 7.08200186e-02f, 9.08394307e-02f, -8.13829154e-02f, 2.69494027e-01f,
  1.10394113e-01f, 1.21757656e-01f, -2.33409867e-01f, -9.02707875e-02f, -8.36000666e-02f, 1.12225048e-01f, 3.81809734e-02f, 1.37292996e-01f, -2.39037648e-02f, -4.58368286e-03f,
  -1.20463390e-02f, -1.79857705e-02f, -7.08172396e-02f, -1.19395619e-02f, 1.99101325e-02f, 3.99914309e-02f, 1.10673249e-01f, 1.34022892e-01f, 8.14747885e-02f, 4.07377779e-02f,
  -1.06550656e-01f, -8.16124156e-02f, 1.07055809e-02f, -8.30731634e-03f, -8.04614369e-03f, -7.29904026e-02f, -6.84360564e-02f, 6.42929822e-02f, -8.41345415e-02f, 1.21711582e-01f,
  5.69952913e-02f, -6.57673851e-02f, -1.18984401e-01f, 4.48973551e-02f, -3.16220336e-02f, 3.23103704e-02f, 4.07039411e-02f, 1.34353880e-02f, -9.93165560e-03f, 5.75108901e-02f,
  2.19858438e-02f, 1.41228666e-03f, -1.07797511e-01f, 7.84682035e-02f, 3.18437293e-02f, -4.38764784e-03f, -1.15722060e-01f, 1.96269923e-03f, -3.16460691e-02f, -6.70954119e-04f,
  1.39740892e-02f, 5.88715561e-02f, -3.21607701e-02f, -4.22406793e-02f, 1.84285436e-02f, 1.01109035e-01f, -4.93717454e-02f, -7.39303008e-02f, 6.24849871e-02f, -9.12304129e-03f,
  -1.22590296e-01f, -2.60567755e-01f, 5.95967397e-02f, -3.07496041e-02f, -7.28424042e-02f, 4.66768779e-02f, -4.50160448e-03f, -7.76190460e-02f, -6.55344203e-02f, -6.07206661e-04f,
  3.85848060e-02f, -2.18193475e-02f, -4.03217822e-02f, 7.58821964e-02f, -7.28963315e-02f, 3.80102010e-03f, -1.22025125e-02f, -7.28338137e-02f, 1.57040376e-02f, 3.09372233e-04f,
  -1.10078432e-01f, -1.33347705e-01f, -9.37082693e-02f, -6.12098686e-02f, -2.36267541e-02f, -9.31909755e-02f, -1.46765620e-01f, -1.27925709e-01f, -7.69264325e-02f, -7.46042132e-02f,
  -2.19791591e-01f, -1.61641970e-01f, -2.78642416e-01f, -1.37132376e-01f, -1.01156965e-01f, -1.13148779e-01f, -1.13257460e-01f, -1.33447081e-01f, 6.75335005e-02f, -7.46303722e-02f,
  -1.04763703e-02f, -8.04353226e-03f, -1.60442263e-01f, -8.57207477e-02f, -1.36030272e-01f, -2.08149374e-01f, -2.02909529e-01f, -1.97116360e-01f, -1.30255342e-01f, -1.21720582e-01f,
  -1.13692865e-01f, -1.63555771e-01f, -1.87363952e-01f, -1.24189079e-01f, -1.61485840e-02f, 4.67187092e-02f, -1.24194860e-01f, -5.78595437e-02f, -7.39005804e-02f, -4.76408079e-02f,
  -5.84255569e-02f, 1.21179752e-01f, 3.53952795e-02f, 1.25795621e-02f, -5.67438491e-02f, -3.39458436e-02f, 6.17171265e-02f, 2.28797477e-02f, -9.13445931e-03f, -1.12551123e-01f,
  1.24212904e-02f, 7.55831897e-02f, 5.97682595e-02f, 3.35013703e-03f, 5.71929179e-02f, 8.82895291e-02f, -1.42991483e-01f, 2.43260469e-02f, -5.49536161e-02f, -8.18327814e-02f,
  -9.22220945e-02f, -1.14431947e-01f, 3.23907509e-02f, 8.98964480e-02f, -1.27433741e-03f, 8.26107189e-02f, 3.44258435e-02f, 7.90084153e-02f, 1.26685426e-01f, 9.58458148e-03f,
  -1.22059740e-01f, 7.13714361e-02f, -5.93065731e-02f, -4.69813794e-02f, -2.87122987e-02f, 4.53082658e-03f, 2.20098179e-02f, -7.46889189e-02f, 5.06344102e-02f, -2.34686770e-02f,
  1.37017788e-02f, 5.24220429e-02f, -3.42164189e-02f, -6.90590069e-02f, -8.04945305e-02f, -4.17595990e-02f, -2.58350633e-02f, -1.33011594e-01f, -4.48377915e-02f, 1.06764957e-01f,
  2.64562108e-02f, -4.70055379e-02f, 4.71127219e-02f, -5.03528155e-02f, -3.08661144e-02f, 5.19488417e-02f, 9.17566568e-02f, 9.05259550e-02f, 8.90174583e-02f, 1.05039246e-01f,
  -1.36801168e-01f, -6.41582161e-02f, -1.03327267e-01f, 8.29726532e-02f, -5.91001920e-02f, -1.53424765e-03f, -7.08117560e-02f, -5.80852106e-02f, 1.10646375e-01f, 2.42006332e-02f,
  6.72300532e-02f, -8.95081609e-02f, -1.89663116e-02f, -1.68275442e-02f, -6.78206012e-02f, -6.05683029e-02f, -1.02697589e-01f, -1.28700271e-01f, -8.65680426e-02f, -3.86863910e-02f,
  -5.02299480e-02f, -5.74257672e-02f, -1.39946744e-01f, -7.83017501e-02f, -1.41219795e-02f, -4.41541672e-02f, -5.48702776e-02f, -2.21689362e-02f, -2.10165903e-02f, -9.64508578e-02f,
  1.62445188e-01f, 1.57823354e-01f, 8.63653570e-02f, 1.58962188e-03f, 9.50258970e-02f, 1.61323918e-03f, 6.68352097e-02f, 1.41692609e-01f, 7.83222094e-02f, 8.01011175e-02f,
  2.91860811e-02f, 4.09867726e-02f, 5.82427271e-02f, -2.61797458e-02f, -1.18068960e-02f, 5.15094958e-02f, 7.66800717e-02f, -4.82434928e-02f, 2.81444974e-02f, 5.42084165e-02f,
  -2.60865726e-02f, -4.26341174e-03f, -2.59134546e-03f, 5.67600466e-02f, -7.95201957e-03f, -2.38751862e-02f, -5.58727160e-02f, 6.40708804e-02f, 6.70534074e-02f, -4.54218220e-03f,
  7.83697218e-02f, 1.03167780e-01f, 1.79040898e-02f, -6.47041649e-02f, -7.53036812e-02f, -4.61928025e-02f, 6.69229478e-02f, -6.10409118e-02f, -8.54412168e-02f, 8.46475437e-02f,
  -1.05990348e-02f, -6.21968955e-02f, 7.89504424e-02f, -2.93224268e-02f, -1.36133973e-02f, -5.61861396e-02f, -5.55834286e-02f, -4.36080582e-02f, -5.48245944e-02f, 2.59886533e-02f,
  -5.72855547e-02f, 3.56867239e-02f, 8.17270130e-02f, -5.93354069e-02f, 4.57849652e-02f, 3.19848247e-02f, -6.91048950e-02f, 1.10745700e-02f, 3.19691524e-02f, 8.69850069e-03f,
  6.31054640e-02f, 8.24352503e-02f, -2.72487700e-02f, 9.67357010e-02f, -3.32058296e-02f, -6.06869683e-02f, -3.32765505e-02f, -5.87943383e-02f, 3.44173200e-02f, -2.01372467e-02f,
  4.25724275e-02f, 6.43901750e-02f, -7.80915580e-05f, -4.36513834e-02f, -1.70741901e-02f, 7.23821856e-03f, -4.83763516e-02f, 8.53682607e-02f, -2.52421759e-02f, -4.37340960e-02f,
  6.29538000e-02f, -6.17823601e-02f, -7.17316493e-02f, 4.85460088e-02f, 7.13587776e-02f, 6.69414178e-02f, -7.41591379e-02f, 7.90325701e-02f, -2.58430783e-02f, -7.29033947e-02f,
  -5.70119768e-02f, -7.69213140e-02f, 2.95301564e-02f, -4.30579372e-02f, -4.71053645e-02f, -6.05192818e-02f, -5.37499152e-02f, 6.71523586e-02f, -1.64883062e-02f, 1.20231546e-02f,
  -5.93182147e-02f, 6.77230880e-02f, -6.21190108e-02f, -8.76409709e-02f, -5.26235327e-02f, 5.94723709e-02f, 2.92927194e-02f, 6.59222603e-02f, 1.99233461e-02f, 2.57231519e-02f,
  2.92027853e-02f, -6.02350272e-02f, -1.53613463e-02f, -2.13623568e-02f, -2.35892087e-02f, -3.77758853e-02f, -1.03713147e-01f, -7.99820051e-02f, -2.55971570e-02f, -1.46718584e-02f,
  5.71978129e-02f, 2.72620261e-01f, 7.81067982e-02f, 1.42609805e-01f, 2.40584031e-01f, 1.85840204e-01f, 2.61502117e-01f, 7.48114735e-02f, 8.66971910e-02f, 8.03226531e-02f,
  4.80370149e-02f, -5.05933873e-02f, 7.46220872e-02f, 8.83305520e-02f, 7.73519799e-02f, 1.17653117e-01f, 1.11803286e-01f, -8.88787657e-02f, 2.13306975e-02f, 7.77495354e-02f,
  1.16146445e-01f, 1.59374271e-02f, -4.22729924e-03f, 3.55388336e-02f, 1.42217189e-01f, 3.93576957e-02f, 5.68002928e-04f, 1.40906572e-02f, 1.19673289e-01f, 5.04542552e-02f,
  -1.32506400e-01f, 1.29610419e-01f, -4.98322994e-02f, -5.08593805e-02f, 2.00690906e-02f, -7.70625398e-02f, -5.71725927e-02f, -1.03254445e-01f, 8.01428109e-02f, -2.18684804e-02f,
  -5.59531040e-02f, -4.43515182e-02f, 3.46723422e-02f, -9.59441289e-02f, -7.65501484e-02f, 1.03032319e-02f, -8.22254829e-03f, -5.28582893e-02f, 2.54795793e-03f, 1.40266614e-02f,
  1.02630064e-01f, -2.92417109e-02f, 9.75563228e-02f, -4.95946705e-02f, -4.99849580e-02f, -5.28821051e-02f, -6.61302656e-02f, 7.63682649e-02f, 5.91108985e-02f, -9.37565640e-02f,
  -1.69756040e-02f, 2.61974870e-03f, 5.84918447e-02f, 3.21568251e-02f, -1.77448504e-02f, -2.86951195e-02f, -1.67595539e-02f, 4.91378680e-02f, -1.63395070e-02f, -3.04414537e-02f,
  3.99020463e-02f, -2.00927164e-02f, -1.02416733e-02f, 1.04235932e-02f, -6.22131824e-02f, 5.79085238e-02f, 3.92385264e-04f, 2.43637036e-03f, 2.45364383e-02f, -7.13466853e-02f,
  7.01122060e-02f, -5.81610799e-02f, 2.12108791e-02f, 6.74615800e-02f, 5.37972450e-02f, -2.91471593e-02f, 4.62432504e-02f, 1.66585501e-02f, -4.17051129e-02f, -1.98355820e-02f,
  -1.61980495e-01f, -7.59216845e-02f, 1.20730167e-02f, -7.69603029e-02f, 7.37723857e-02f, -1.00392349e-01f, -3.88191864e-02f, -5.75223453e-02f, -5.90382479e-02f, -3.09993941e-02f,
  -3.55736986e-02f, 7.59900510e-02f, -5.03682252e-03f, -1.68809593e-02f, -9.23396423e-02f, -4.91500609e-02f, -2.79498547e-02f, -7.35471919e-02f, 2.07366864e-03f, -5.07070459e-02f,
  3.35497148e-02f, -5.48650436e-02f, -1.21689722e-01f, -3.21690254e-02f, 2.66009122e-02f, 1.89922599e-03f, -1.34798288e-01f, -8.16033706e-02f, -1.29894376e-01f, -8.08970556e-02f,
  6.32927567e-02f, -1.26344830e-01f, -1.71028692e-02f, 2.28364572e-01f, 2.63077438e-01f, 1.60173506e-01f, 6.92293420e-02f, 1.27464265e-01f, 2.18985364e-01f, 1.60281405e-01f,
  1.37485974e-02f, 1.03199743e-01f, 1.87813327e-01f, 1.52266204e-01f, 2.54500145e-03f, 3.91069427e-02f, 1.03344448e-01f, 9.46097076e-02f, 2.42081270e-01f, 1.62342221e-01f,
  1.10138677e-01f, 1.66624878e-02f, 3.59283164e-02f, 3.30638848e-02f, 4.20187693e-03f, 1.12669237e-01f, 9.74202179e-04f, -2.94576567e-02f, 1.25857387e-02f, -3.05445772e-02f,
  1.12185236e-02f, -1.93068460e-01f, 1.74180612e-01f, -1.97433797e-03f, -9.44119394e-02f, -5.24051301e-02f, 3.31033729e-02f, -1.21014245e-01f, -1.15776867e-01f, -4.12014537e-02f,
  2.97071226e-02f, -1.20035455e-01f, 4.43259403e-02f, -5.91665022e-02f, -1.25039205e-01f, 4.68752794e-02f, -1.65147886e-01f, 1.04586771e-02f, -3.60209756e-02f, -2.74311635e-03f,
  2.19347049e-03f, -1.05955034e-01f, -7.44671822e-02f, 6.12008199e-02f, -2.09616441e-02f, -1.61848646e-02f, -1.20564595e-01f, -1.08863682e-01f, 5.33999950e-02f, -4.41274829e-02f,
  1.18837729e-01f, 1.26096914e-02f, -2.36111246e-02f, 7.12633505e-02f, 5.34099378e-02f, 3.08649130e-02f, 1.21018523e-02f, 3.58473975e-03f, -5.15560098e-02f, -1.69212110e-02f,
  6.87167943e-02f, -1.09451991e-02f, 2.80698128e-02f, 4.45972681e-02f, 3.58957686e-02f, -4.23486568e-02f, -8.59606192e-02f, 2.10798997e-02f, -2.57793777e-02f, -2.68905256e-02f,
  4.87200394e-02f, 3.12356316e-02f, 3.94653231e-02f, -3.60526261e-03f, 2.26713866e-02f, 8.26401040e-02f, -3.66611145e-02f, -1.94119420e-02f, -1.54602258e-02f, -1.99251622e-03f,
  -7.38676637e-02f, 2.45657004e-02f, 1.27456307e-01f, 4.53054346e-02f, 1.33381383e-02f, -9.65434313e-02f, 6.87731728e-02f, -9.82153490e-02f, -6.86355382e-02f, 8.10486358e-03f,
  -4.81100194e-02f, -2.12909039e-02f, -6.68653473e-02f, -5.43854050e-02f, 8.73214602e-02f, 2.68772971e-02f, -4.61584441e-02f, 8.56399760e-02f, 8.41149092e-02f, 7.52688153e-03f,
  -6.97424337e-02f, 1.19080760e-01f, 8.88897777e-02f, 1.19681828e-01f, 1.02272935e-01f, 1.96104363e-01f, -2.03412399e-02f, 1.77940261e-02f, 1.45711061e-02f, 1.06714413e-01f,
  -3.61200154e-01f, 2.61149675e-01f, 2.85448432e-01f, -2.42787421e-01f, 1.21333376e-01f, 1.88157141e-01f, 2.88960874e-01f, 1.56999975e-02f, -9.10769477e-02f, 1.94685400e-01f,
  5.25876991e-02f, -1.29745454e-01f, -1.02073336e-02f, -6.83541670e-02f, -8.87474120e-02f, 2.45735690e-01f, 7.41430596e-02f, -1.55301586e-01f, -2.54140824e-01f, -1.59830406e-01f,
  3.53007056e-02f, -1.01321526e-01f, -2.80888885e-01f, -2.04943866e-01f, 5.56793548e-02f, -4.63306308e-02f, 7.70219192e-02f, -7.80556276e-02f, 6.08123913e-02f, 2.38468032e-02f,
  6.24321885e-02f, 3.67399342e-02f, -9.95176584e-02f, -1.23721406e-01f, -3.56376879e-02f, -7.09393844e-02f, 4.75740582e-02f, -7.62959197e-02f, 1.78411920e-02f, -5.26302354e-03f,
  5.50342314e-02f, -4.94849309e-02f, -3.76053378e-02f, -2.23689526e-02f, 7.29239779e-03f, 1.77279382e-03f, 2.52212603e-02f, -1.92295276e-02f, -1.49891116e-02f, -4.76676710e-02f,
  1.23851269e-01f, 6.55254871e-02f, -4.11461331e-02f, -3.81740481e-02f, 5.50733693e-02f, -1.29881680e-01f, -4.10717204e-02f, -1.02810577e-01f, -1.05162859e-01f, -8.87091085e-02f,
  3.66666168e-02f, -4.63237725e-02f, 3.49535681e-02f, -1.10321455e-01f, 2.77289171e-02f, -5.69721200e-02f, -6.74029486e-03f, 2.69891918e-02f, 1.76570099e-02f, 1.12291211e-02f,
  -3.30616459e-02f, 4.96423654e-02f, -2.96388399e-02f, -5.98914810e-02f, 4.37978022e-02f, -6.12078570e-02f, -1.44221522e-02f, 1.11015039e-02f, 2.30258666e-02f, 1.41704874e-02f,
  -1.46687208e-02f, 4.63769250e-02f, 2.96291616e-02f, -9.05347764e-02f, 4.49271835e-02f, -3.53506058e-02f, 4.45291810e-02f, 5.56498580e-02f, 2.62214113e-02f, 7.18248114e-02f,
  -2.12997839e-01f, 1.70237705e-01f, -1.35720950e-02f, -7.67111555e-02f, 4.18605953e-02f, 5.22124991e-02f, 1.08311707e-02f, 6.72627753e-03f, -1.29320854e-02f, -4.34823260e-02f,
  4.58326228e-02f, -1.03298237e-03f, 6.13975450e-02f, 7.35695567e-03f, -6.55621812e-02f, 6.75330013e-02f, 8.85256473e-03f, -2.64740512e-02f, -6.22951165e-02f, 5.57604209e-02f,
  8.94245282e-02f, -1.24766352e-02f, -1.24356061e-01f, -3.49853635e-02f, -1.77603159e-02f, 1.15650524e-04f, -1.74189408e-04f, -1.15860239e-01f, -1.73723157e-02f, -1.46404549e-01f,
  1.13294326e-01f, -1.57228708e-01f, -1.77692637e-01f, -2.07149521e-01f, -1.21300682e-01f, -4.98379208e-02f, -1.79021060e-02f, -3.93913500e-02f, 1.24613354e-02f, -8.70100856e-02f,
  -3.09368167e-02f, 4.44105864e-02f, 6.72387145e-03f, 1.37513667e-01f, 1.11518681e-01f, -1.68564394e-02f, -1.55184552e-01f, -3.80041376e-02f, 1.28354788e-01f, 1.48390919e-01f,
  5.55379922e-03f, 1.31365331e-03f, 2.66787186e-02f, -8.36484805e-02f, -1.99413866e-01f, 1.60437785e-02f, -1.87032834e-01f, -1.08726889e-01f, -4.42765839e-02f, -1.60610750e-01f,
  -3.49266082e-02f, 2.84216162e-02f, 6.20854758e-02f, 6.44943565e-02f, -1.24740144e-02f, -7.21492339e-04f, -6.23292588e-02f, -5.69588654e-02f, 6.09321296e-02f, -7.58507624e-02f,
  -7.15031698e-02f, 7.14241015e-03f, -1.21764876e-02f, 7.77604757e-03f, -2.43130494e-02f, 8.49758908e-02f, -9.52427015e-02f, 4.54151817e-02f, 1.18947681e-02f, -1.19047984e-01f,
  4.58949544e-02f, 1.16619557e-01f, 3.15285139e-02f, -6.75868317e-02f, 8.64510462e-02f, 1.21656008e-01f, -3.39449495e-02f, 2.32420284e-02f, -3.23386863e-02f, 5.37111685e-02f,
  -1.67810004e-02f, 1.73678901e-02f, -8.10706336e-03f, 2.87099201e-02f, 4.76541603e-03f, -7.46136066e-03f, -1.18250940e-02f, 1.14603534e-01f, -4.68535908e-03f, 1.06711751e-02f,
  1.68904092e-03f, -1.99458189e-02f, 5.14524616e-03f, 9.25881267e-02f, 5.38147800e-03f, 3.44914608e-02f, 3.38317938e-02f, 6.73285685e-03f, -2.49666795e-02f, -1.33358606e-03f,
  -1.68431997e-02f, 4.31929976e-02f, 1.28738966e-03f, -2.00903583e-02f, -6.34361878e-02f, -8.46872665e-03f, -9.18198004e-02f, 1.11541469e-02f, -8.40650722e-02f, -2.66250204e-02f,
  1.33565278e-03f, 6.07876144e-02f, -6.87782615e-02f, -3.12163075e-03f, -1.13704979e-01f, 1.60859730e-02f, 2.37931870e-03f, -3.02483626e-02f, -4.71253246e-02f, 6.46645902e-03f,
  6.16294853e-02f, 6.94657210e-03f, -7.49928504e-02f, -5.94503582e-02f, 9.44172591e-02f, -1.13427872e-02f, -4.12967540e-02f, 1.04450248e-01f, -1.79763343e-02f, -3.20411511e-02f,
  -3.59767117e-02f, 2.68850978e-02f, 2.00357676e-01f, 1.43970519e-01f, 3.14782336e-02f, 1.47303283e-01f, 2.91289240e-02f, 5.36613762e-02f, 1.11329347e-01f, -3.19465064e-02f,
  -5.04191399e-01f, -1.90225646e-01f, 3.10996156e-02f, 6.29753340e-03f, 1.00137480e-01f, 6.14482462e-02f, 1.86849181e-02f, -8.44995901e-02f, -8.25318471e-02f, -1.18631601e-01f,
  -8.71023089e-02f, 4.63309437e-02f, 7.50398040e-02f, 9.72473696e-02f, -5.79889938e-02f, 7.93145597e-02f, 1.54966876e-01f, 1.11513101e-01f, 1.95054878e-02f, -6.75011277e-02f,
  1.08079739e-01f, -3.69551852e-02f, -1.80340067e-01f, 4.57779579e-02f, 8.05943608e-02f, 1.03349425e-01f, 6.00518696e-02f, 5.12785185e-03f, -3.83985266e-02f, 1.30987912e-01f,
  -2.44099975e-01f, -1.87472776e-01f, 8.69536400e-02f, 9.99718010e-02f, 1.20658323e-01f, -1.44557610e-01f, 2.84194648e-02f, -3.57252620e-02f, -6.16898648e-02f, 5.21990098e-02f,
  3.27058770e-02f, -3.30529325e-02f, 4.19021770e-02f, 7.85665438e-02f, -7.87412226e-02f, -2.53162254e-02f, -1.09220354e-03f, -5.15845791e-02f, -7.44160935e-02f, -1.56012746e-02f,
  1.10824652e-01f, 4.33333963e-02f, -1.34781703e-01f, -1.12407930e-01f, -8.03117529e-02f, 2.13228888e-03f, -3.12019605e-02f, -1.22450389e-01f, -1.06950209e-01f, -1.98502094e-01f,
  6.38487414e-02f, 4.45642434e-02f, -4.29074466e-03f, -5.38980635e-03f, 3.35666351e-03f, 6.76911697e-02f, 3.35383527e-02f, 9.65614170e-02f, -2.16158032e-02f, 2.67392211e-02f,
  6.71959808e-03f, -1.55593418e-02f, 1.12298671e-02f, -2.29526050e-02f, 6.72157034e-02f, 2.79238150e-02f, 2.16495581e-02f, 4.74178232e-02f, -3.28492187e-02f, -8.90485197e-02f,
  -1.97993014e-02f, -5.97105511e-02f, 4.43056300e-02f, 5.93713634e-02f, -3.03999055e-02f, 3.36959511e-02f, -3.19751762e-02f, -1.00021847e-01f, -5.79780936e-02f, -7.26440027e-02f,
  -1.05118252e-01f, 1.04930095e-01f, -1.19212583e-01f, 4.48287614e-02f, -4.14022803e-02f, -4.58702780e-02f, 3.42943110e-02f, 1.06559871e-02f, -1.55453049e-02f, -5.04222736e-02f,
  -4.25961688e-02f, -3.98367457e-02f, 1.27681727e-02f, -7.07265809e-02f, -3.88114713e-02f, -1.82898194e-02f, -2.06483081e-02f, 1.88955404e-02f, 7.10733384e-02f, -6.65018409e-02f,
  -4.73757125e-02f, -1.27990916e-01f, -2.40639597e-01f, -1.51063070e-01f, -4.27907966e-02f, -5.05465306e-02f, -3.47738266e-02f, -1.86237320e-01f, -1.97197586e-01f, -2.41717458e-01f,
  -3.15061361e-02f, -1.81269832e-02f, -1.50503904e-01f, 1.05356537e-01f, 1.81776822e-01f, -6.97098523e-02f, -1.19929262e-01f, -6.01680055e-02f, -3.73537056e-02f, -4.39337455e-04f,
  8.34600553e-02f, 1.20464899e-01f, 1.39986407e-02f, 8.43494479e-03f, -1.24770708e-01f, 4.39111888e-02f, 1.64474789e-02f, -3.17216516e-02f, -6.67616203e-02f, 8.85864347e-02f,
  1.07062012e-01f, 1.68907464e-01f, 1.12168677e-01f, 2.91495491e-03f, 6.08300231e-02f, 1.70228451e-01f, 2.76898574e-02f, 4.42383140e-02f, 1.26650885e-01f, 1.25376299e-01f,
  -7.27776587e-02f, -1.12773784e-01f, -1.05652042e-01f, -5.95172925e-04f, -6.24465458e-02f, 5.08151874e-02f, -3.54841724e-02f, -8.69282931e-02f, 7.92502053e-03f, -1.75297707e-02f,
  -1.13000078e-02f, -3.04232296e-02f, 1.07887365e-01f, -7.00530782e-02f, 5.54305203e-02f, -2.76492219e-02f, -7.14352354e-02f, -8.29972923e-02f, -4.42878250e-03f, -1.25335738e-01f,
  1.32967174e-01f, 6.01508394e-02f, 1.71387531e-02f, -3.08295134e-02f, -5.59390895e-02f, 3.23425159e-02f, -1.16243228e-01f, -1.33601367e-01f, -1.25742093e-01f, -9.87329241e-03f,
  -8.85892510e-02f, -6.44698143e-02f, 1.44380517e-02f, 7.17490613e-02f, -3.80252418e-03f, -5.66229634e-02f, 1.43497018e-03f, -5.68088330e-03f, 8.74557998e-03f, 6.55027479e-02f,
  -7.87693728e-03f, 5.59905991e-02f, -6.06114790e-02f, -6.58247471e-02f, 8.93400013e-02f, -8.55355784e-02f, -2.76937094e-02f, 5.94708957e-02f, 2.48488747e-02f, 6.99561015e-02f,
  6.29889295e-02f, -1.05779782e-01f, -2.50396691e-02f, -1.22790925e-01f, 5.54153211e-02f, -3.59367877e-02f, 8.73166621e-02f, 1.76156238e-02f, 3.14184744e-03f, -6.76083937e-02f,
  8.65485221e-02f, -1.24311529e-01f, 8.89944360e-02f, -7.90682063e-02f, 4.48723845e-02f, 6.09189942e-02f, -2.54981536e-02f, -8.23323503e-02f, 1.10980403e-02f, -2.93662492e-02f,
  -3.53449136e-02f, -2.78610159e-02f, 3.87543477e-02f, -6.70712963e-02f, -3.16334665e-02f, -2.45994832e-02f, 9.84226391e-02f, -6.57455102e-02f, -4.67983000e-02f, -1.02794781e-01f,
  -2.13043168e-02f, 1.10770101e-02f, -1.21447235e-01f, -1.05999388e-01f, -9.09528658e-02f, 8.13293755e-02f, -1.17953621e-01f, 4.21125740e-02f, -1.73281990e-02f, -2.63917800e-02f,
  -2.45186523e-01f, -6.22941963e-02f, 1.64022446e-01f, 4.59628664e-02f, 1.06977284e-01f, -5.65077551e-03f, 1.26073003e-01f, 6.96234852e-02f, -4.12902087e-02f, 1.62879899e-02f,
  6.18949998e-03f, -4.56732400e-02f, 2.74774083e-03f, 8.57708380e-02f, -2.14731861e-02f, 7.06392601e-02f, 1.25947863e-01f, 2.03756206e-02f, 1.31042138e-01f, 1.19346194e-01f,
  6.93862513e-02f, 2.97067920e-03f, 2.44580694e-02f, -1.66910850e-02f, -2.03850884e-02f, 9.98323634e-02f, -5.86287398e-03f, 1.16038388e-02f, -8.59560147e-02f, 7.94663951e-02f,
  2.71587729e-01f, -1.34093702e-01f, 1.42910585e-01f, 1.90285016e-02f, -8.46395940e-02f, -3.92650720e-03f, 5.16057387e-02f, -5.71012087e-02f, -9.13049355e-02f, -2.55113915e-02f,
  -3.45985480e-02f, 2.76671126e-02f, -6.55789152e-02f, -1.30205024e-02f, 4.12063859e-02f, 3.83052602e-02f, -9.54118520e-02f, -7.86632951e-03f, -7.87868723e-02f, -8.10682774e-02f,
  -5.14472760e-02f, 4.69669588e-02f, 2.58821668e-03f, 1.27890725e-02f, -1.14146478e-01f, 1.52175827e-02f, 3.54799516e-02f, 1.03288908e-02f, -1.13852181e-01f, 1.26960911e-02f,
  1.08810484e-01f, -9.73526388e-02f, -9.57794562e-02f, 5.97091392e-02f, 2.87594758e-02f, -2.54090913e-02f, -2.31171027e-02f, 2.56576836e-02f, -6.86240643e-02f, -4.26016301e-02f,
  -6.27238825e-02f, 1.49310231e-02f, 2.58026086e-02f, -5.56724928e-02f, 2.17756834e-02f, -4.75242287e-02f, 4.43085581e-02f, -2.97788922e-02f, -5.34875579e-02f, -7.56042078e-03f,
  -4.57019657e-02f, -4.27082069e-02f, 9.06382948e-02f, -3.47543396e-02f, -8.12281743e-02f, 7.86212832e-02f, -2.71061026e-02f, 1.27090989e-02f, 3.42792645e-02f, 8.77551502e-04f,
  1.06683373e-01f, -9.38263759e-02f, 5.89653030e-02f, -9.53493714e-02f, -5.04558943e-02f, -1.81037448e-02f, 4.25277427e-02f, 9.15920921e-03f, 5.05571514e-02f, 5.43627292e-02f,
  -4.58843261e-03f, -9.97609738e-03f, 1.13579500e-02f, -3.03981416e-02f, 3.80603001e-02f, -2.00361963e-02f, -9.52768046e-03f, 5.07685617e-02f, 4.79733907e-02f, 6.47654682e-02f,
  -8.06340203e-02f, -1.11725098e-02f, 7.54330978e-02f, 5.71198426e-02f, 4.25125211e-02f, 1.52537853e-01f, 1.67324036e-01f, 1.37101248e-01f, 1.65139586e-01f, 6.29853085e-02f,
  1.90534949e-01f, 4.87602539e-02f, -1.24340959e-01f, 4.40127477e-02f, -1.20622158e-01f, -9.96709988e-02f, 7.94471577e-02f, 4.79640998e-02f, -1.17058568e-02f, 1.27740074e-02f,
  3.78389247e-02f, -8.73548687e-02f, -1.04967020e-01f, -4.55259299e-03f, -3.75281014e-02f, 1.44397486e-02f, -1.09910823e-01f, -6.42694086e-02f, -3.00641209e-02f, -8.78383294e-02f,
  1.76416691e-02f, 6.08826838e-02f, 1.21772699e-01f, -1.11782691e-02f, 8.59546289e-03f, -1.45732671e-01f, -2.64821276e-02f, -4.36037518e-02f, 2.68979911e-02f, -1.11713186e-01f,
  -1.53026342e-01f, -1.30080685e-01f, -3.97982039e-02f, 1.24913886e-01f, 2.83769667e-02f, -1.95294246e-02f, 4.93274815e-02f, -8.71998966e-02f, 4.92768660e-02f, -6.45447597e-02f,
  -2.50881147e-02f, 2.74483766e-02f, 1.46682942e-02f, -4.24745157e-02f, 4.00697701e-02f, 5.80008775e-02f, 2.23099627e-02f, 1.48635451e-02f, -8.77550095e-02f, -9.50573012e-02f,
  6.76890314e-02f, -8.71650577e-02f, -9.13926866e-03f, 2.33308170e-02f, 2.32242942e-02f, -2.45331712e-02f, -3.94434743e-02f, -8.05433244e-02f, -1.80786178e-02f, 2.26537399e-02f,
  1.05648898e-01f, -6.96244016e-02f, 4.16140966e-02f, 4.32283767e-02f, -1.88899618e-02f, 2.35339496e-02f, 3.40423640e-03f, 1.67944692e-02f, 6.31877035e-02f, -1.43431788e-02f,
  6.35232627e-02f, -6.41280115e-02f, -2.12149862e-02f, -2.51596756e-02f, 1.05105601e-02f, -3.91534865e-02f, 4.98266565e-03f, -9.63724591e-03f, 2.94895358e-02f, 4.06609178e-02f,
  -7.96508566e-02f, -3.58254276e-02f, -8.88441317e-03f, 1.23546217e-02f, -2.66907047e-02f, -6.40572533e-02f, -3.55191119e-02f, -8.81870687e-02f, -2.29368662e-03f, 5.37820794e-02f,
  9.04058199e-03f, -5.04396483e-02f, 2.14961753e-03f, 3.60972881e-02f, -7.14595467e-02f, 2.19265874e-02f, -1.10553280e-01f, 8.11098740e-02f, 4.81953695e-02f, 5.90161094e-03f,
  -1.41529590e-02f, -4.16363403e-02f, -4.07902673e-02f, 5.92090040e-02f, 3.76291648e-02f, -1.25014232e-02f, 1.29969373e-01f, 4.82485555e-02f, 6.13160841e-02f, -4.48876135e-02f,
  -5.04603004e-03f, 1.75152123e-01f, 8.42016637e-02f, 1.15913548e-01f, 3.85702699e-02f, 9.09747370e-03f, 1.02578320e-01f, 2.20461283e-02f, 7.04421103e-03f, 1.61639348e-01f,
  3.88877541e-01f, 1.73074976e-01f, 1.95340261e-01f, -1.64813176e-02f, 2.20650081e-02f, 8.21839273e-02f, 1.08840987e-01f, 1.28276616e-01f, 7.20421597e-02f, 1.33225515e-01f,
  3.25265527e-02f, -1.12587502e-02f, -5.67063093e-02f, -2.06447896e-02f, 7.65779465e-02f, -4.93346853e-03f, -4.29673605e-02f, -4.83961729e-03f, 8.30968395e-02f, -2.11367314e-03f,
  7.30873365e-03f, 1.08131520e-01f, 1.35944992e-01f, 1.12119699e-02f, -8.01250152e-03f, -3.70279290e-02f, 5.63914329e-02f, 8.81039277e-02f, -2.77074222e-02f, -5.37706316e-02f,
  1.16761319e-01f, 2.46341616e-01f, -3.27722207e-02f, -4.43377271e-02f, 5.12196198e-02f, -3.53612937e-02f, 4.64338660e-02f, -1.71019211e-02f, 6.46956638e-02f, -4.07963134e-02f,
  -2.58217636e-03f, 2.75619272e-02f, 8.73411596e-02f, 5.90688176e-02f, 6.82288706e-02f, 1.83789693e-02f, 1.05061874e-01f, 1.59757003e-01f, 1.98423564e-02f, 3.80536802e-02f,
  -8.15132037e-02f, 1.15002938e-01f, 2.78413668e-02f, 2.80833952e-02f, 1.01661958e-01f, -3.89174037e-02f, 1.05331331e-01f, 5.67615591e-02f, 9.66976881e-02f, 8.45817477e-02f,
  -7.83034489e-02f, -4.22038464e-03f, 7.87369981e-02f, 9.35030729e-03f, 2.37110443e-02f, -1.08021177e-01f, 5.70845418e-03f, -9.49521288e-02f, -4.26201783e-02f, 6.94827959e-02f,
  -2.62489729e-02f, -2.94435099e-02f, 5.41001558e-02f, -4.46582884e-02f, 2.37019472e-02f, 7.79951587e-02f, -2.91842856e-02f, -3.21606956e-02f, -4.57437662e-03f, 5.17888777e-02f,
  -4.28600945e-02f, -9.27165058e-03f, 1.98229421e-02f, 1.78880114e-02f, 1.01899365e-02f, -2.77367933e-03f, -7.67121539e-02f, 7.79905310e-03f, -1.21337185e-02f, 8.83505940e-02f,
  -8.19695070e-02f, 9.15102139e-02f, -7.46525005e-02f, -2.54999753e-02f, 5.06323092e-02f, 4.30971012e-02f, 6.51692003e-02f, -2.70667579e-02f, -3.59966308e-02f, -2.39749216e-02f,
  2.81387027e-02f, 8.36193785e-02f, 3.64500880e-02f, -7.64794797e-02f, -9.10223499e-02f, 9.16677434e-03f, -9.77725387e-02f, -1.19665544e-02f, -1.01980552e-01f, -3.92540470e-02f,
  3.21185961e-02f, -2.64373124e-02f, -4.48684357e-02f, -9.82050672e-02f, -1.01918533e-01f, -1.01735055e-01f, -1.04173042e-01f, 3.34703736e-02f, -7.17211813e-02f, -7.09146038e-02f,
  8.16180483e-02f, 8.31916332e-02f, 9.63023677e-02f, -9.03007239e-02f, 1.35037128e-03f, -1.30124558e-02f, -7.78995752e-02f, 9.67540815e-02f, 2.53245421e-02f, 8.18029642e-02f,
  9.00513679e-02f, 1.87177118e-02f, 7.75912255e-02f, 6.17814176e-02f, -2.48506833e-02f, 3.96184549e-02f, 7.31614977e-02f, -2.83367708e-02f, 5.77520877e-02f, -9.42888856e-02f,
  -1.10352069e-01f, 5.84380291e-02f, 5.71723655e-02f, -3.76404710e-02f, -2.50478787e-03f, -2.32604090e-02f, -6.40693754e-02f, -5.87224476e-02f, 8.18459094e-02f, 4.26199101e-02f,
  -3.51962782e-02f, 6.22301437e-02f, -2.13252218e-03f, -1.69416051e-02f, 1.10548608e-01f, 6.87626973e-02f, 6.43927231e-02f, 8.19897130e-02f, 9.89044234e-02f, 4.78169583e-02f,
  8.55817497e-02f, 2.43815612e-02f, -3.31087857e-02f, 3.59628387e-02f, -1.97567558e-03f, 6.66484535e-02f, 7.62314722e-02f, 3.65363508e-02f, 1.27656357e-02f, 1.07731491e-01f,
  -2.10978929e-02f, -2.39427504e-03f, -4.77479100e-02f, -9.65706483e-02f, 6.57098442e-02f, -8.26807171e-02f, 6.49005994e-02f, 4.19193618e-02f, 4.60053347e-02f, 1.98139474e-02f,
  8.97348449e-02f, 2.65826117e-02f, 3.02163418e-02f, -9.65701044e-02f, 5.58689460e-02f, 1.92582025e-03f, -4.99234535e-02f, 4.66581471e-02f, 3.61068323e-02f, 1.71757620e-02f,
  6.82564229e-02f, -4.22387160e-02f, -4.32254635e-02f, -4.41546589e-02f, -6.34802207e-02f, -9.45276469e-02f, -2.15959325e-02f, -6.47742003e-02f, -2.86831371e-02f, 6.47653341e-02f,
  7.27029964e-02f, 3.34380530e-02f, 2.96716690e-02f, 6.10363148e-02f, 2.91422866e-02f, 3.22166234e-02f, -3.59007791e-02f, 6.14025928e-02f, 6.86844215e-02f, -5.23342229e-02f,
  -5.28138094e-02f, -1.00424670e-01f, -8.68115574e-03f, -2.46201493e-02f, 1.07677691e-02f, 1.28480718e-01f, 6.67083710e-02f, 4.42238860e-02f, 1.12362187e-02f, 1.11461923e-01f,
  5.33042997e-02f, 5.54977693e-02f, -6.17330819e-02f, 3.33555155e-02f, -1.11779347e-02f, 7.61541948e-02f, 8.49183425e-02f, 9.04243663e-02f, -2.95108110e-02f, 1.18908055e-01f,
  2.00270824e-02f, -5.45078069e-02f, 4.63891663e-02f, 6.66897884e-03f, 2.37838645e-02f, -9.87469777e-02f, -7.15711787e-02f, 1.60346236e-02f, -3.13171893e-02f, -8.16755965e-02f,
  2.12125704e-01f, -6.61383867e-02f, -1.94639713e-01f, -9.31703150e-02f, -3.98489088e-02f, -1.05416618e-01f, -1.52438253e-01f, -1.13119176e-02f, -9.17196050e-02f, -6.27071690e-03f,
  -1.45036146e-01f, 9.93384719e-02f, 5.19453660e-02f, 4.66469564e-02f, -6.37099519e-02f, -4.30492535e-02f, -4.45453189e-02f, 4.35291305e-02f, 7.49245062e-02f, -1.09258760e-02f,
  1.68196354e-02f, -5.69279678e-02f, 8.92556645e-03f, -1.64353754e-02f, -4.33584601e-02f, 3.96483243e-02f, -1.49632275e-01f, -1.25129849e-01f, -7.34587014e-02f, -1.72808692e-01f,
  -2.25213856e-01f, -4.31987867e-02f, 5.16115576e-02f, 7.32800812e-02f, -4.39555459e-02f, -3.12388595e-02f, -9.38699394e-02f, 3.84811088e-02f, -3.31911594e-02f, -7.78688118e-02f,
  -4.35161926e-02f, 2.06774026e-02f, -8.48622620e-02f, 4.15259190e-02f, 4.01460715e-02f, -1.17438976e-02f, 5.72483726e-02f, -7.83051848e-02f, 1.31162945e-02f, -1.12336408e-02f,
  -6.15198761e-02f, 7.08053913e-03f, 5.00126407e-02f, -7.05358461e-02f, -2.34092381e-02f, -2.74994113e-02f, -1.01952612e-01f, -7.71929473e-02f, 4.46496606e-02f, -9.68063902e-03f,
  -3.41280624e-02f, -4.23989818e-02f, -6.35881200e-02f, 5.88219762e-02f, 2.53744759e-02f, -1.03658857e-02f, -4.48207743e-02f, -3.64089534e-02f, -5.39601110e-02f, 1.84518136e-02f,
  8.59551653e-02f, -6.23824261e-02f, 9.56943482e-02f, -1.89655013e-02f, -5.27270138e-02f, -3.81776281e-02f, 2.56800260e-02f, 8.86939690e-02f, 1.23897614e-02f, 7.47862235e-02f,
  2.26839520e-02f, -8.36962238e-02f, 3.59012857e-02f, -7.82364309e-02f, 4.57935929e-02f, -2.14145090e-02f, 3.75128351e-02f, 4.53787223e-02f, -4.14446108e-02f, 7.79643431e-02f,
  4.49370407e-02f, 4.92153168e-02f, -9.18131545e-02f, 3.91379707e-02f, -3.10947821e-02f, -5.81899285e-02f, -8.57461989e-03f, 6.30379617e-02f, 7.30562359e-02f, -8.65668431e-02f,
  6.73063621e-02f, -3.39733958e-02f, -7.16698989e-02f, -7.89347142e-02f, 2.49084868e-02f, -6.04330450e-02f, -1.30990967e-02f, 4.03158180e-02f, -8.14196393e-02f, -5.22338599e-02f,
  -1.87257193e-02f, 3.41305835e-03f, 5.84798567e-02f, 1.09387085e-01f, 6.23170063e-02f, 4.82773781e-02f, -6.70289472e-02f, -7.89673030e-02f, 7.90932924e-02f, 2.59378236e-02f,
  -4.26751763e-01f, -8.45768005e-02f, 1.57492429e-01f, -1.12192027e-01f, 2.29860514e-01f, 3.63687128e-01f, 3.82026404e-01f, 1.42109990e-01f, 1.56345859e-03f, -2.76025664e-02f,
  -1.35127693e-01f, -2.10811466e-01f, -1.67340040e-01f, -1.36185260e-02f, -6.81845769e-02f, 2.51986265e-01f, 2.77717173e-01f, -1.41686462e-02f, -1.39370542e-02f, 1.04772054e-01f,
  1.07914610e-02f, -4.85834926e-02f, -2.75943935e-01f, -7.59771690e-02f, -5.12529239e-02f, 4.02839761e-03f, -9.84432250e-02f, -7.47370720e-02f, 7.71180093e-02f, 6.71172095e-03f,
  -1.87332109e-02f, -1.17752209e-01f, 4.70067896e-02f, -1.18336067e-01f, -3.09289317e-03f, -1.56677589e-01f, -4.09015920e-03f, -1.12991929e-01f, -6.46405891e-02f, -3.62605825e-02f,
  -3.45487148e-02f, -3.40047963e-02f, -1.23819619e-01f, 7.35165598e-03f, -7.32765021e-03f, -9.32884514e-02f, 1.25717660e-02f, -2.95080952e-02f, 3.15747000e-02f, -8.33824426e-02f,
  -5.03255017e-02f, 7.56866932e-02f, -5.60205989e-02f, 9.97773707e-02f, -3.65662277e-02f, -6.90128363e-04f, -6.99013919e-02f, -4.69724014e-02f, 6.20347261e-02f, -1.32630229e-01f,
  5.66925155e-03f, -6.48580026e-03f, 3.98548692e-02f, -1.88946128e-02f, -5.79755045e-02f, 3.76502424e-02f, 1.59738753e-02f, 3.69796455e-02f, -1.38415992e-02f, -9.41499788e-03f,
  4.13216129e-02f, -4.49418612e-02f, 4.67671715e-02f, -1.23521397e-02f, -1.16678365e-01f, 3.39114815e-02f, 2.83633824e-02f, -8.33137706e-03f, -5.04967235e-02f, -5.03371693e-02f,
  -2.51556374e-02f, -1.82527546e-02f, -7.05240443e-02f, -1.51420301e-02f, 3.54828462e-02f, 2.21437030e-03f, -3.19024771e-02f, -3.51810120e-02f, -5.13773412e-02f, 5.45119829e-02f,
  -1.29950926e-01f, -3.32767479e-02f, 2.85517946e-02f, -1.32178096e-02f, -2.37299339e-03f, -2.49301828e-02f, -1.60013291e-03f, -1.70767065e-02f, 2.69197803e-02f, -2.28230841e-02f,
  1.69330798e-02f, -8.26944783e-02f, -8.21394771e-02f, 8.75865296e-02f, 1.20415285e-01f, 3.26953344e-02f, -1.05196079e-02f, -1.82761643e-02f, -4.95104194e-02f, -5.21264188e-02f,
  -5.42658865e-02f, 1.43318683e-01f, -1.35418242e-02f, 5.54140881e-02f, 3.80352288e-02f, 1.44540071e-01f, 4.19284366e-02f, 1.58528820e-01f, 3.28838490e-02f, 8.97782594e-02f,
  -9.65955481e-02f, -6.99441954e-02f, 5.54191284e-02f, 1.15106143e-01f, -1.60567090e-02f, -2.84947872e-01f, -2.06792355e-01f, -2.15729594e-01f, -5.93518466e-02f, -1.34221250e-02f,
  -2.64221374e-02f, 8.80293641e-03f, 3.94626483e-02f, 4.11397032e-03f, -3.93608361e-02f, -1.25386357e-01f, 5.63146621e-02f, -5.80082275e-02f, 1.39565615e-03f, -9.26381499e-02f,
  -3.38799842e-02f, 6.72533065e-02f, 7.64291501e-03f, -2.10691486e-02f, 6.30779564e-02f, 9.31137800e-02f, 1.04528613e-01f, 1.17449827e-01f, 1.13003880e-01f, 2.46798575e-01f,
  1.17711850e-01f, -3.44578177e-03f, 4.13396209e-02f, 8.23062956e-02f, 8.37549940e-02f, -1.90425012e-02f, 1.07840942e-02f, -1.39711238e-02f, 2.71186903e-02f, 6.08029440e-02f,
  1.90717895e-02f, 7.64380442e-03f, 2.10590232e-02f, -1.38003780e-02f, -3.76048461e-02f, -4.84408699e-02f, -7.49421939e-02f, 7.44517595e-02f, 4.24957648e-02f, 4.03402466e-03f,
  8.29612315e-02f, -1.65004916e-02f, -2.69677956e-02f, -9.14913639e-02f, -2.04052590e-02f, -8.22584629e-02f, -4.99926805e-02f, -6.76712394e-02f, -1.50545731e-01f, -5.37908897e-02f,
  3.85366902e-02f, 6.97414018e-03f, -6.49725050e-02f, -3.40299048e-02f, -9.83733386e-02f, 6.22974224e-02f, 9.99211669e-02f, -8.49292353e-02f, -6.73615783e-02f, 3.03214788e-02f,
  -4.71839570e-02f, 2.72578336e-02f, 4.14906330e-02f, 2.84798127e-02f, -4.49508764e-02f, 3.25922668e-02f, 1.99707039e-02f, 6.55370951e-02f, 2.01677214e-02f, 8.01215228e-03f,
  -1.28741413e-02f, 1.50280688e-02f, 6.37728795e-02f, -7.69503042e-03f, 5.65929674e-02f, -6.63694041e-03f, -1.13192070e-02f, -6.68744743e-02f, -6.25673160e-02f, 8.25931691e-03f,
  -8.10712054e-02f, -1.11203879e-01f, 9.45923999e-02f, -4.66133840e-02f, 7.01174214e-02f, 1.69567913e-02f, -3.24786231e-02f, 2.39285473e-02f, 3.67214456e-02f, -1.14073753e-02f,
  -4.02416997e-02f, -6.53732568e-02f, -7.14927241e-02f, -1.91734396e-02f, -1.06533393e-02f, -1.47901534e-03f, 4.74203378e-03f, 2.74299830e-02f, -1.13165282e-01f, -2.71537248e-02f,
  -2.97034788e-03f, -1.65578559e-01f, -1.25236899e-01f, -1.49826884e-01f, -9.45447087e-02f, -8.53544921e-02f, -1.09776832e-01f, -1.60329074e-01f, -2.05904767e-01f, -2.58285880e-01f,
  -5.32102119e-03f, 1.04947044e-02f, -9.06506844e-04f, -8.81099701e-02f, -5.49236760e-02f, -1.05442412e-01f, -7.28877336e-02f, -1.49087384e-02f, 4.65594083e-02f, -7.00058341e-02f,
  -5.57991453e-02f, 2.91581452e-03f, 1.55242905e-02f, -2.79753674e-02f, 1.45737212e-02f, 3.15736085e-02f, 6.09345213e-02f, 1.08434476e-01f, 1.18017972e-01f, 3.61871384e-02f,
  -1.17645890e-01f, -4.94665988e-02f, -1.15625478e-01f, 6.09607203e-04f, -1.39872357e-01f, 5.82880341e-02f, -1.23440564e-01f, 7.76064210e-03f, -7.90470019e-02f, -1.36829346e-01f,
  6.21991940e-02f, -1.77373931e-01f, -4.22632247e-02f, 5.74605055e-02f, -6.98995497e-03f, -6.10422157e-02f, 5.71995899e-02f, -5.61957546e-02f, 4.28972282e-02f, 7.62082711e-02f,
  4.28637043e-02f, 1.06938370e-02f, 6.97509274e-02f, -8.82694423e-02f, 3.81876156e-02f, -4.58353944e-03f, -8.87211189e-02f, -1.42887782e-03f, -7.15190172e-02f, -9.71311927e-02f,
  -6.51416332e-02f, 1.05136922e-02f, 2.14728583e-02f, 7.60619789e-02f, 2.85406094e-02f, 3.69535610e-02f, -1.10669136e-01f, -1.19131923e-01f, 1.89799201e-02f, -6.47656471e-02f,
  3.08781434e-02f, -3.18624079e-02f, -1.06281340e-02f, -5.20191118e-02f, 7.21864551e-02f, -4.58508506e-02f, 1.15092508e-01f, -4.32331637e-02f, 4.39791679e-02f, -6.17719330e-02f,
  3.07517505e-04f, 2.42791814e-03f, -4.60720919e-02f, 5.88559825e-03f, -9.87115577e-02f, 2.57531758e-02f, -1.63847823e-02f, 5.11562973e-02f, -7.10644424e-02f, -9.45635587e-02f,
  1.56976264e-02f, -2.59904447e-03f, 8.19908828e-03f, -5.00844568e-02f, -1.06898680e-01f, 4.99169938e-02f, -7.84322917e-02f, -4.32211719e-02f, 5.86454011e-02f, -3.79181420e-03f,
  1.64848268e-01f, -7.31279105e-02f, 5.04423231e-02f, -4.12240205e-03f, 4.75421399e-02f, -3.43432128e-02f, -6.87894970e-02f, 8.94488990e-02f, 7.17317984e-02f, 6.56295642e-02f,
  -8.27098545e-03f, 4.05476987e-02f, 7.66353235e-02f, -5.31055368e-02f, -5.52263223e-02f, -5.73929511e-02f, -4.20080945e-02f, 8.13785493e-02f, 9.48180035e-02f, -2.75778957e-02f,
  2.44445950e-02f, 1.11043654e-01f, 1.37578383e-01f, 1.85391575e-01f, -5.92092387e-02f, 2.10874692e-01f, 1.66759431e-01f, 2.12709494e-02f, 2.06011057e-01f, 1.26336098e-01f,
  -1.30440339e-01f, 9.47153643e-02f, 2.07425058e-02f, -3.70969735e-02f, -3.26226577e-02f, -9.85237136e-02f, -1.08314507e-01f, -1.17080860e-01f, 3.72701436e-02f, 2.28626803e-02f,
  -6.99669495e-02f, -1.19251654e-01f, -3.12964506e-02f, -1.06820531e-01f, -1.65859908e-02f, 3.97317484e-02f, 4.43132110e-02f, -2.54656542e-02f, -1.71402156e-01f, -2.29260921e-01f,
  -4.92097288e-02f, -6.57725036e-02f, -6.63590953e-02f, -9.21358317e-02f, 3.54666933e-02f, -9.05271396e-02f, -2.65815966e-02f, -8.18577036e-02f, -2.61067078e-02f, 1.29477326e-02f,
  2.61466831e-01f, -2.68176720e-02f, -7.39798993e-02f, -1.63557813e-01f, -3.30080539e-02f, -3.73457884e-03f, 2.90805232e-02f, 1.10598266e-01f, 5.25734685e-02f, 5.32829836e-02f,
  1.76828858e-02f, -8.79021510e-02f, 7.20668957e-02f, 4.88981605e-02f, 6.73527196e-02f, -2.70974319e-02f, -3.37188616e-02f, -5.35168359e-03f, 6.67762980e-02f, -7.14653730e-02f,
  -3.28646898e-02f, -1.15120575e-01f, -9.05972943e-02f, -4.06115167e-02f, -9.02642086e-02f, -3.10911518e-02f, 6.19538734e-03f, -1.01393737e-01f, 1.23310946e-02f, 7.74069652e-02f,
  7.43826712e-03f, -2.00649649e-02f, -1.61481015e-02f, 2.06325613e-02f, -1.74781587e-02f, -5.70516884e-02f, -1.68996602e-02f, 4.55888361e-02f, 2.27834955e-02f, 4.04257365e-02f,
  6.48433790e-02f, -3.39189637e-03f, 2.64237802e-02f, 1.25980347e-01f, -1.94915533e-02f, -9.80558470e-02f, -4.17967141e-03f, 3.70241329e-02f, -2.25772429e-03f, 4.92509082e-02f,
  -1.24500789e-01f, 5.39068468e-02f, -3.23011093e-02f, -7.61776045e-02f, -6.29134402e-02f, 3.91354635e-02f, 5.88395596e-02f, -5.65306619e-02f, -6.55603036e-02f, -1.54649112e-02f,
  2.31721163e-01f, -2.34632418e-01f, -2.57245377e-02f, -4.23404090e-02f, 6.29442260e-02f, 1.55022060e-02f, 6.96035326e-02f, -2.81047542e-02f, -4.45905626e-02f, 3.11232526e-02f,
  -1.22231737e-01f, 5.04362136e-02f, 1.15124986e-01f, -6.08056895e-02f, 5.87105267e-02f, -1.61950868e-02f, -7.35839382e-02f, 8.14307481e-02f, 2.09628735e-02f, -2.46457439e-02f,
  6.03646319e-03f, 3.88959013e-02f, 9.00407657e-02f, 7.08146319e-02f, 8.91198963e-02f, -5.30416630e-02f, 1.28464788e-01f, 6.38355389e-02f, 5.79075068e-02f, 2.21032441e-01f,
  3.41408074e-01f, 1.38228675e-02f, 1.01304039e-01f, 1.50093753e-02f, 9.90342349e-02f, 1.81912810e-01f, 1.59832150e-01f, 4.90191355e-02f, 1.99219547e-02f, -6.07436849e-03f,
  -8.92246794e-03f, -6.48112595e-03f, -1.40254945e-02f, -9.23045948e-02f, -4.63955104e-02f, 1.19582810e-01f, -3.51605453e-02f, 8.54583364e-03f, 1.87439900e-02f, -2.15347223e-02f,
  -5.36090657e-02f, 1.13595612e-01f, 1.85082818e-03f, 5.41421399e-02f, -2.86120791e-02f, -4.90286667e-03f, 2.11976394e-02f, -4.19391058e-02f, -1.08776309e-01f, -1.76053971e-01f,
  -5.92291430e-02f, 9.53154787e-02f, -8.35553706e-02f, -1.42736971e-01f, 6.73613250e-02f, -1.52217150e-02f, -3.04312874e-02f, 3.17650638e-03f, 2.21220031e-03f, 6.38834685e-02f,
  1.21955422e-03f, -1.80519391e-02f, -1.01683527e-01f, -9.08620562e-03f, 6.27238974e-02f, 5.67139089e-02f, -3.82215008e-02f, -4.47292030e-02f, -1.52803823e-01f, -8.84968638e-02f,
  -1.35165617e-01f, 6.29434139e-02f, 1.11359209e-01f, 6.09595887e-02f, -3.34562212e-02f, 5.82989864e-02f, 2.13004593e-02f, -2.33081877e-02f, 2.12497376e-02f, -8.80904123e-02f,
  6.81613311e-02f, -7.33185112e-02f, -1.60787646e-02f, -9.44108739e-02f, 1.74930673e-02f, -4.55264114e-02f, 5.45653813e-02f, -3.31259258e-02f, -1.24367578e-02f, 5.05761728e-02f,
  -1.59734022e-02f, -1.02186054e-02f, -5.17478958e-02f, 6.33449033e-02f, -2.84317825e-02f, 2.42594276e-02f, 5.34809269e-02f, 4.66123335e-02f, 6.39085248e-02f, -8.07143748e-02f,
  -3.72439213e-02f, 3.21860649e-02f, -6.67974800e-02f, 2.93484349e-02f, -3.84919792e-02f, -6.99404851e-02f, -6.42101690e-02f, 2.56686937e-02f, 8.56504366e-02f, 5.68176061e-02f,
  -3.04547343e-02f, 3.81550100e-03f, 1.39977820e-02f, -8.34672451e-02f, 8.43064860e-02f, -9.15131345e-02f, 5.21473475e-02f, 5.42651787e-02f, -8.84539932e-02f, 1.86410360e-02f,
  -4.66960669e-02f, -6.82853088e-02f, 3.38608623e-02f, 5.26762269e-02f, 1.13990286e-03f, 5.60747497e-02f, 2.97964420e-02f, -8.09640158e-03f, -3.67777199e-02f, -2.00904086e-02f,
  -6.74269497e-02f, 1.16623387e-01f, 1.07043684e-01f, -8.62010289e-03f, 7.33592678e-05f, 5.57744876e-03f, 9.27128270e-02f, -1.33213034e-04f, 2.16046758e-02f, 8.29617307e-02f,
  2.64938474e-01f, -1.07971868e-02f, -4.62740213e-01f, 1.01816252e-01f, -1.02282435e-01f, -1.61188513e-01f, -1.80385157e-01f, -9.32942480e-02f, -1.50173437e-02f, -1.53630242e-01f,
  -1.71648841e-02f, 3.11163031e-02f, -3.71497534e-02f, -1.76801205e-01f, -8.45798701e-02f, -2.04715371e-01f, -1.58365801e-01f, -2.06778914e-01f, -2.67985374e-01f, -8.09883252e-02f,
  -6.71208948e-02f, -2.45340765e-02f, -6.55411780e-02f, -5.49326539e-02f, 1.03890514e-02f, -5.14456034e-02f, -1.60106733e-01f, -1.36600256e-01f, -1.76974744e-01f, -1.33443484e-02f,
  -2.66997486e-01f, -4.39874977e-02f, -4.10988778e-02f, 8.21509436e-02f, -1.04952015e-01f, -4.60776351e-02f, -1.48725389e-02f, 3.13968547e-02f, 3.13407481e-02f, -7.91651160e-02f,
  -3.71816568e-02f, 4.65406477e-02f, -1.26158511e-02f, 8.11186153e-03f, -4.20413315e-02f, -1.02425151e-01f, -1.10776583e-02f, -1.69562608e-01f, -2.07206253e-02f, -2.36539505e-02f,
  3.39311361e-02f, 6.96535707e-02f, 1.13139618e-02f, -6.15644455e-02f, -2.86071338e-02f, 2.66860891e-02f, -6.85934797e-02f, -5.76536432e-02f, -1.52559400e-01f, 9.23310742e-02f,
  8.69331043e-03f, 6.93840906e-02f, -7.74843991e-03f, 9.26197227e-03f, 5.64370230e-02f, -4.50515887e-03f, 4.95544039e-02f, 6.82431906e-02f, -2.40321252e-02f, 6.54536784e-02f,
  -5.75340278e-02f, -6.83855340e-02f, 1.26856361e-02f, 4.87636030e-02f, 2.96842624e-02f, -4.89788987e-02f, 1.43127814e-02f, 4.64304537e-03f, -4.17290591e-02f, -2.58187577e-02f,
  -3.16861458e-02f, -2.22259015e-02f, 2.15097432e-04f, -3.13702575e-03f, -5.32361902e-02f, -3.46341021e-02f, -1.88253094e-02f, 8.55898261e-02f, -1.99774243e-02f, -4.42490652e-02f,
  -9.38989073e-02f, -1.14335738e-01f, -2.78992672e-02f, 7.17106983e-02f, -1.15927629e-01f, -5.54464161e-02f, 5.46953678e-02f, -7.70241395e-02f, -2.72997245e-02f, -5.34697399e-02f,
  -6.96731284e-02f, -7.17069134e-02f, -5.41097112e-02f, 4.35844697e-02f, -7.07167685e-02f, 5.93283772e-02f, -4.41888981e-02f, -8.08753725e-03f, -2.45391130e-02f, 2.67957468e-02f,
  -3.76011394e-02f, 3.74920256e-02f, 5.43974824e-02f, 6.89841583e-02f, 8.43380466e-02f, 6.01049103e-02f, -3.76291610e-02f, -3.50395516e-02f, -5.87068163e-02f, 6.82217553e-02f,
  -5.01094572e-02f, 5.31317405e-02f, -1.37128215e-02f, -4.25956920e-02f, 7.04864711e-02f, -6.03157058e-02f, 8.04297626e-02f, -1.68583598e-02f, 5.09023666e-02f, -2.52808835e-02f,
  4.42835055e-02f, -4.17237952e-02f, -1.04658119e-01f, -1.00095004e-01f, -9.97053161e-02f, -5.21818995e-02f, 2.88384929e-02f, -9.51024983e-03f, -6.72204141e-03f, 8.10235813e-02f,
  9.55981854e-03f, -5.22994548e-02f, 2.49463394e-02f, 7.95420706e-02f, 4.58145663e-02f, 2.12823190e-02f, -6.84930980e-02f, -2.03034021e-02f, -1.25230011e-02f, -1.63822584e-02f,
  -2.69210692e-02f, -1.39791474e-01f, 2.36133970e-02f, -6.01706132e-02f, 1.53011251e-02f, 6.81115016e-02f, 1.98494736e-02f, -3.41806486e-02f, 6.48899302e-02f, -1.45794395e-02f,
  3.24675404e-02f, -7.60044381e-02f, 2.67473012e-02f, -1.81876421e-02f, -6.36377037e-02f, -4.81318049e-02f, 9.40272808e-02f, 6.44453987e-02f, 5.72417751e-02f, 2.14511361e-02f,
  3.92833957e-03f, -9.82696540e-04f, -1.50863025e-02f, -6.96769953e-02f, -1.05417587e-01f, -7.67545775e-03f, 7.43997991e-02f, 1.67593472e-02f, -1.18524931e-01f, -8.43453512e-04f,
  9.15103033e-02f, -2.52984688e-02f, 2.83317850e-03f, 5.15084006e-02f, 3.50417034e-03f, -3.95712443e-02f, -5.23738675e-02f, -6.56617582e-02f, 3.99291553e-02f, -3.51903625e-02f,
  -5.62120636e-04f, -1.69575028e-02f, -7.65185952e-02f, -5.77164590e-02f, 6.90661743e-02f, -2.59196348e-02f, -7.06593320e-02f, 1.26849925e-02f, -8.06372389e-02f, -4.89214994e-02f,
  -7.87283629e-02f, -1.45175857e-02f, -8.08321834e-02f, 6.73170686e-02f, 1.05419829e-01f, 6.06396534e-02f, -8.11045617e-02f, 3.41832899e-02f, -4.47622724e-02f, 3.15155983e-02f,
  1.31829113e-01f, -1.55725986e-01f, -9.57828015e-02f, 6.99702725e-02f, -7.41713047e-02f, 5.43863550e-02f, -8.03991482e-02f, -4.77510653e-02f, -4.87541631e-02f, -3.62010039e-02f,
  3.20722237e-02f, 5.27557498e-03f, -1.08244851e-01f, 7.53501281e-02f, 9.41115022e-02f, 2.25491859e-02f, 5.75093217e-02f, 1.04367696e-02f, -5.48196882e-02f, -3.50674503e-02f,
  3.78730297e-02f, 7.07300827e-02f, 8.47747475e-02f, 1.10301701e-02f, -1.05840797e-02f, 6.39015110e-03f, 1.00347055e-02f, -5.15158065e-02f, -1.46917356e-02f, 1.15900956e-01f,
  -1.72138363e-01f, -3.62080783e-02f, -5.12309261e-02f, 8.68389010e-02f, 2.04951167e-01f, 1.23243436e-01f, 5.65670617e-02f, 1.21406518e-01f, 1.64751366e-01f, 5.39233461e-02f,
  9.35428962e-02f, 1.16702221e-01f, 8.06484893e-02f, 8.00897032e-02f, 5.27321137e-02f, 1.23599254e-01f, 6.40687197e-02f, 3.70066278e-02f, 4.41185422e-02f, 1.02171049e-01f,
  8.20047334e-02f, 1.74496863e-02f, -1.01588480e-02f, -7.99226668e-03f, -1.31452158e-02f, 1.41041905e-01f, 4.47471775e-02f, 5.79388179e-02f, -3.94725762e-02f, 1.12581484e-01f,
  -9.48219225e-02f, -2.72514690e-02f, 5.76385297e-02f, 3.24810036e-02f, -1.74464658e-02f, -1.41401207e-02f, -1.93999466e-02f, -8.04398656e-02f, -6.73608407e-02f, -1.73068922e-02f,
  -2.43405085e-02f, 3.31886336e-02f, 9.63916332e-02f, -4.66825813e-02f, 1.30265504e-02f, 2.77835922e-03f, 7.17881843e-02f, 3.52602340e-02f, -1.08833946e-02f, 5.05694300e-02f,
  2.90814545e-02f, -5.55758998e-02f, 3.70080508e-02f, 8.83009210e-02f, 3.47029716e-02f, -2.90335864e-02f, 2.81467903e-02f, -5.52880839e-02f, 1.11045660e-02f, -4.71007079e-02f,
  -1.08359698e-02f, 5.04590757e-02f, 1.10359844e-02f, 3.75391990e-02f, -8.51025991e-03f, -3.18746245e-03f, 1.25737622e-01f, 8.13466087e-02f, 8.69222432e-02f, -6.17634207e-02f,
  -1.96278864e-03f, 2.14632954e-02f, 6.76709637e-02f, 8.87851976e-03f, 1.05461506e-02f, -4.67076302e-02f, -5.52047975e-02f, 3.67704518e-02f, 7.97902420e-03f, 6.58447742e-02f,
  -5.32988049e-02f, -1.70714762e-02f, -3.85091864e-02f, 2.58476529e-02f, 5.09410277e-02f, -7.11047873e-02f, 1.00220721e-02f, 3.69060575e-03f, -7.18935058e-02f, -7.49365017e-02f,
  6.18343940e-03f, 8.93495306e-02f, 7.21401274e-02f, 4.45424207e-02f, 3.52682024e-02f, -2.61960421e-02f, 4.06767614e-02f, 1.57293603e-02f, -3.15600932e-02f, 4.48838845e-02f,
  -2.59522279e-03f, -4.27646637e-02f, -7.64180571e-02f, -7.00935423e-02f, -1.52146313e-02f, 9.30306781e-03f, -4.76434827e-02f, 2.69867871e-02f, -2.14598179e-02f, 5.02728522e-02f,
  2.07108241e-02f, 9.51102227e-02f, 5.02586998e-02f, 5.21497838e-02f, -3.07658203e-02f, 9.53764841e-02f, -1.06191255e-01f, -7.87433013e-02f, -1.25909476e-02f, -7.41216391e-02f,
  1.36845961e-01f, 1.41845057e-02f, -7.78539032e-02f, 1.77899465e-01f, 5.05710430e-02f, 9.93427262e-03f, 6.92394450e-02f, 6.60124496e-02f, 9.81118083e-02f, 1.25956237e-01f,
  9.24234837e-02f, 9.05592069e-02f, 3.78965307e-03f, 3.05832364e-02f, 8.27616826e-02f, 3.64551954e-02f, 2.17147637e-02f, 3.70511860e-02f, 1.37970056e-02f, 1.23181470e-01f,
  9.78865325e-02f, 5.10159098e-02f, -2.16639992e-02f, 1.04731517e-02f, 1.49134547e-01f, 1.64710626e-01f, -1.74194071e-02f, -2.64241081e-02f, 1.49393022e-01f, 7.99233466e-02f,
  6.74034432e-02f, -5.16891181e-02f, 5.23896031e-02f, 1.18843064e-01f, 6.54021576e-02f, 5.45170791e-02f, -6.12137802e-02f, 1.82914957e-02f, -5.67306802e-02f, 5.56039587e-02f,
  4.57365103e-02f, -5.48505932e-02f, -3.95481512e-02f, 5.91807477e-02f, 5.02617247e-02f, -8.97956938e-02f, -2.55462546e-02f, -1.56132445e-01f, -9.12304148e-02f, -1.10888779e-01f,
  1.19529376e-02f, 8.76654312e-02f, -1.20812997e-01f, -9.28266272e-02f, -3.65731190e-04f, 4.65925112e-02f, -1.29987765e-02f, -1.61511432e-02f, -1.37941167e-01f, -7.20548332e-02f,
  1.07533308e-02f, 4.28440087e-02f, -4.83626779e-03f, -3.76586267e-03f, 3.05362083e-02f, -1.28067872e-02f, 3.60105634e-02f, -4.39741723e-02f, 4.46616858e-02f, -8.53257105e-02f,
  6.25310652e-03f, 2.52089836e-02f, -1.63365752e-02f, 8.60265922e-03f, 4.14982326e-02f, 6.01333973e-04f, -4.66000587e-02f, 2.08903830e-02f, 1.70084909e-02f, -1.08089857e-01f,
  5.41048944e-02f, -5.72801791e-02f, -5.61012328e-02f, 4.21357416e-02f, 2.09258143e-02f, -4.41694297e-02f, -7.67536685e-02f, 5.51346838e-02f, 7.14243054e-02f, 4.08893339e-02f,
  1.30660728e-01f, -4.91184890e-02f, -2.02621911e-02f, -8.56706128e-02f, 4.10789140e-02f, -3.71024106e-03f, 3.31677450e-03f, -1.91544201e-02f, -4.91299182e-02f, 7.52452239e-02f,
  3.32669094e-02f, 6.54900670e-02f, 3.11944094e-02f, -4.96808663e-02f, -4.20124456e-02f, 2.96314955e-02f, -7.17748925e-02f, -6.44453689e-02f, -3.57752740e-02f, -8.39004759e-03f,
  -3.83690260e-02f, -7.73974210e-02f, -6.35075644e-02f, -1.36904433e-01f, -8.77213627e-02f, 5.46271689e-02f, -1.10459752e-01f, 3.18822488e-02f, -7.16113225e-02f, -1.62268057e-02f,
  1.79569244e-01f, -9.33395773e-02f, 5.07268123e-02f, 4.93305475e-02f, 1.99111134e-01f, 1.53821707e-01f, 1.64149240e-01f, 1.64698482e-01f, -1.96186472e-02f, 1.66080855e-02f,
  -1.84854835e-01f, -1.16045691e-01f, -1.49457410e-01f, -1.61333472e-01f, -1.28787234e-01f, 1.41486198e-01f, 7.76567161e-02f, 7.08668083e-02f, 1.39131248e-01f, 1.20781057e-01f,
  -3.04335784e-02f, 4.14462239e-02f, -1.29881594e-02f, -1.85008254e-02f, 8.79520085e-03f, -6.12344295e-02f, 3.39094698e-02f, 6.98525086e-02f, -7.60194212e-02f, 2.47791223e-02f,
  -1.21609524e-01f, 3.23144570e-02f, -4.99985330e-02f, -8.20245817e-02f, -6.95818663e-02f, -3.89552512e-03f, 7.69262314e-02f, -3.39991376e-02f, 4.12667990e-02f, -4.99509759e-02f,
  3.82989086e-02f, -2.35254113e-02f, -6.60360530e-02f, -7.55205145e-03f, -3.03652398e-02f, -1.43849561e-02f, 1.23070534e-02f, -2.03605685e-02f, -9.44282487e-03f, -8.99675116e-02f,
  -9.99268368e-02f, -6.86153956e-03f, 1.13815106e-01f, 9.01386216e-02f, -1.20341979e-01f, -3.08103543e-02f, -3.02486196e-02f, -6.61785454e-02f, 3.64014804e-02f, 2.88352910e-02f,
  6.80656061e-02f, -1.11561017e-02f, -1.01805180e-01f, 5.33369482e-02f, 7.70798624e-02f, -6.32098243e-02f, -5.12015186e-02f, -4.38498631e-02f, -9.86883044e-03f, 9.73696485e-02f,
  3.10046738e-03f, 6.70467913e-02f, 2.32419185e-02f, 5.14359996e-02f, 3.29936557e-02f, -3.48614119e-02f, 8.71681869e-02f, -4.72012125e-02f, 4.11394499e-02f, -2.35038064e-02f,
  3.09923757e-02f, -7.15576950e-03f, 5.74908927e-02f, 1.66072487e-03f, 2.22421177e-02f, -4.31879796e-02f, 2.81573797e-04f, 4.75981981e-02f, -4.16131727e-02f, 9.05566216e-02f,
  3.22248694e-03f, 9.10933502e-03f, -1.03079423e-01f, 1.54993515e-02f, 6.84284419e-02f, -4.73273173e-02f, -9.69348401e-02f, -4.33617011e-02f, -2.24187020e-02f, 9.03026164e-02f,
  -6.49487600e-02f, 3.75717087e-03f, 5.10120057e-02f, 7.31106997e-02f, 1.75677687e-01f, 8.29726979e-02f, -5.27037829e-02f, -2.77833305e-02f, -8.90176594e-02f, -2.55555678e-02f,
  -3.37821878e-02f, 1.25328481e-01f, 8.33031461e-02f, 6.02184832e-02f, -9.90179628e-02f, 4.82548401e-02f, 7.07571208e-02f, 9.66544822e-02f, 7.32661262e-02f, 9.06522498e-02f,
  2.01376200e-01f, 2.22749896e-02f, 1.33603020e-02f, 4.21527661e-02f, 9.71283317e-02f, -3.11739743e-02f, -3.06792557e-02f, -4.88980971e-02f, -8.37369338e-02f, 9.40700062e-03f,
  1.79966819e-02f, -4.56347279e-02f, 4.38024756e-03f, 6.81889057e-02f, 5.40329888e-02f, 6.82411566e-02f, 1.08424857e-01f, -2.70291604e-02f, 4.38303612e-02f, 9.52184126e-02f,
  -3.32496203e-02f, 1.17765591e-01f, 8.62481594e-02f, -2.89537683e-02f, 6.63088039e-02f, -3.03388406e-02f, -5.01654819e-02f, 9.46267042e-03f, -5.05040921e-02f, 1.01275675e-01f,
  5.67264408e-02f, 1.94007918e-01f, -7.96278268e-02f, -1.93543248e-02f, -3.31615284e-02f, -3.18447733e-03f, -8.13826993e-02f, -1.96933150e-02f, -4.45198156e-02f, 5.45086078e-02f,
  6.11819178e-02f, 3.39262915e-04f, -7.16697276e-02f, 8.23446140e-02f, 1.19256545e-02f, 6.54553548e-02f, -3.54968361e-03f, 7.84430727e-02f, 2.84200255e-03f, 1.45235248e-02f,
  -7.60608315e-02f, -4.89345826e-02f, 5.15254289e-02f, 3.13044041e-02f, -6.75239265e-02f, -9.97373760e-02f, 6.69295564e-02f, 2.51766127e-02f, -7.89544173e-03f, 1.81195792e-02f,
  -2.48752199e-02f, 2.97091939e-02f, 2.38971077e-02f, -2.80447360e-02f, 7.36640841e-02f, -3.36921960e-02f, 1.57778524e-02f, -2.01181434e-02f, 7.23205358e-02f, -8.62405226e-02f,
  4.10811268e-02f, 2.68773288e-02f, 5.85282855e-02f, 8.86911340e-03f, -5.50032146e-02f, -4.13473174e-02f, 4.38204780e-02f, 5.58616593e-02f, -2.48908680e-02f, 6.41397983e-02f,
  -2.90353596e-02f, 2.01355815e-02f, -8.05803239e-02f, -8.68318528e-02f, -5.47407418e-02f, 8.17072913e-02f, 9.05997958e-03f, -7.24378228e-02f, -4.15171906e-02f, -1.03697842e-02f,
  -1.30732402e-01f, -7.70527869e-02f, -8.22164342e-02f, -7.31090456e-02f, 8.03839043e-02f, 5.93377016e-02f, 1.66234821e-02f, -7.74223730e-02f, -2.60886531e-02f, -6.94309361e-03f,
  6.23180643e-02f, 6.01076484e-02f, -3.42346057e-02f, -8.13505277e-02f, -4.92901728e-03f, -4.02558185e-02f, -9.84146148e-02f, -1.05203696e-01f, -7.86390007e-02f, -4.75682840e-02f,
  4.55964394e-02f, 6.92924708e-02f, -1.66636612e-02f, 1.27975596e-02f, -1.09996893e-01f, 2.86741760e-02f, -5.43764196e-02f, -9.69962496e-03f, 9.94878542e-03f, 2.92427205e-02f,
  1.06143132e-01f, -9.49913822e-03f, 6.51228800e-02f, 7.68698528e-02f, -1.05052151e-01f, -9.60796997e-02f, 3.62163633e-02f, 1.11691475e-01f, 2.95095127e-02f, 6.04576655e-02f,
  -7.31817707e-02f, -6.29278198e-02f, -2.88085621e-02f, 6.47963285e-02f, 1.73356086e-01f, 1.15825526e-01f, 9.96948853e-02f, 1.58302277e-01f, 4.05198708e-02f, 9.37356725e-02f,
  9.82262269e-02f, -9.30034462e-03f, 7.10321299e-04f, 8.79912302e-02f, 5.58396280e-02f, 9.78016481e-02f, 1.18034948e-02f, 7.23065510e-02f, 1.05492314e-02f, 1.19508959e-01f,
  8.67797807e-03f, 2.29483210e-02f, -5.10484912e-02f, 4.06500585e-02f, -8.55100974e-02f, 2.62493510e-02f, -5.51520614e-03f, -1.33481529e-02f, -3.34619321e-02f, -8.08548927e-02f,
  -5.14223007e-03f, -5.13602085e-02f, -4.16759402e-02f, -3.70326713e-02f, 1.34497816e-02f, 3.67316715e-02f, 3.60859334e-02f, 1.29734531e-01f, 5.06714284e-02f, 6.97084814e-02f,
  -8.35413486e-02f, -8.69347379e-02f, -9.74943861e-02f, 9.32702422e-03f, -1.79683529e-02f, -2.33313274e-02f, 7.93626755e-02f, -7.97074959e-02f, 9.27392840e-02f, -6.92657977e-02f,
  7.72960186e-02f, -4.62784320e-02f, 7.53421932e-02f, 2.01014113e-02f, -8.19607750e-02f, 5.84917814e-02f, -8.51531476e-02f, 4.51343954e-02f, 7.72988200e-02f, 2.34155320e-02f,
  6.17144778e-02f, 5.54336235e-02f, 6.99711684e-03f, 8.53324682e-03f, -8.40515271e-02f, -7.26046339e-02f, -8.76915082e-02f, 5.74278273e-02f, 3.76701914e-02f, 1.04844915e-02f,
  2.58215927e-02f, -1.60987712e-02f, -7.41055384e-02f, 8.39309487e-03f, -9.38783400e-03f, 9.70566049e-02f, 7.10929139e-03f, 3.46637554e-02f, -7.04730377e-02f, 2.16668136e-02f,
  -1.68001741e-01f, -2.31321361e-02f, -7.23236799e-02f, -1.69743423e-03f, -4.90858033e-02f, 2.86883414e-02f, -8.00167620e-02f, 7.61470348e-02f, -6.98370561e-02f, 3.31254452e-02f,
  -4.63293269e-02f, 6.09692112e-02f, 5.82953310e-03f, 6.47422671e-02f, 1.68504734e-02f, -7.40176141e-02f, -2.44458159e-03f, 6.76048324e-02f, -1.28622912e-02f, -9.12946761e-02f,
  -3.72014455e-02f, -1.12140387e-01f, -5.22451010e-03f, 3.64670977e-02f, 4.37884405e-02f, -9.47958848e-04f, 8.69510788e-03f, -1.58195868e-01f, -1.71123352e-02f, -1.41526982e-01f,
  -4.01688591e-02f, 1.59333125e-01f, -1.96969748e-01f, -1.16820648e-01f, 7.55626187e-02f, 1.26731694e-01f, 8.58102441e-02f, -6.11955114e-03f, 3.61374728e-02f, 4.56679724e-02f,
  -3.06966342e-03f, -6.52932525e-02f, -1.74547359e-01f, -1.53341681e-01f, -2.06306785e-01f, -1.27348810e-01f, -1.90570399e-01f, -2.06973150e-01f, -2.52437413e-01f, -3.96007933e-02f,
  -7.22582936e-02f, -1.84347823e-01f, -2.29650319e-01f, -1.44740120e-01f, -4.14748490e-03f, -1.32151455e-01f, -1.85807899e-01f, -1.35646760e-01f, -4.55122814e-02f, -1.23360664e-01f,
  -7.58287031e-03f, -1.21068349e-02f, -9.16348249e-02f, -6.72384650e-02f, 6.22555986e-02f, 6.94987252e-02f, -6.03822172e-02f, 2.03651953e-02f, -6.52966052e-02f, -1.74615216e-02f,
  -7.77762979e-02f, 2.33119000e-02f, -7.31142238e-02f, 3.19068804e-02f, 5.21699637e-02f, -6.73257336e-02f, -4.82752882e-02f, -4.42049019e-02f, -3.39624472e-02f, 9.36855227e-02f,
  9.76476967e-02f, -5.39344586e-02f, -8.83613527e-02f, 3.37582119e-02f, -1.21506967e-01f, -1.12320952e-01f, -8.88637677e-02f, -5.88765293e-02f, -1.38484329e-01f, -3.04004345e-02f,
  1.51645049e-01f, 8.02236944e-02f, -1.45608196e-02f, 6.08333461e-02f, -5.71157224e-02f, -4.01529223e-02f, -1.52653893e-02f, 2.52580978e-02f, -1.66180413e-02f, -8.76445621e-02f,
  6.93917349e-02f, 4.04709056e-02f, 9.60914642e-02f, 1.50508881e-02f, -1.33048669e-02f, 8.03684518e-02f, -2.73166243e-02f, 2.87230425e-02f, -2.18291245e-02f, -7.94747248e-02f,
  -4.58575152e-02f, -4.58420180e-02f, -4.05860543e-02f, -8.51002112e-02f, -9.78503227e-02f, 2.41056047e-02f, -6.14699200e-02f, -2.87556574e-02f, 3.87402028e-02f, -7.34479651e-02f,
  -1.59803405e-01f, -1.07032686e-01f, -1.21483952e-02f, -5.32430075e-02f, 1.00420520e-03f, -2.12561172e-02f, 1.03361784e-02f, 2.55010407e-02f, -1.73431635e-02f, 5.32971695e-02f,
  -6.41214997e-02f, 8.81628841e-02f, 3.42622250e-02f, 9.26963147e-03f, 6.38212785e-02f, -6.49852604e-02f, 1.01291515e-01f, -6.76666573e-02f, -1.11941501e-01f, 6.64006472e-02f,
  -7.74493665e-02f, -1.15715101e-01f, -1.34650484e-01f, -2.99971234e-02f, -8.55881125e-02f, -1.76500306e-01f, -1.57991543e-01f, -1.01100437e-01f, -1.01347789e-01f, -3.35987546e-02f,
  -1.58321187e-01f, 9.38907824e-03f, 6.38466850e-02f, -4.01367359e-02f, 1.61310926e-01f, 1.86259016e-01f, 3.04859638e-01f, 5.35467127e-03f, -6.38657734e-02f, 6.80792555e-02f,
  -1.88711546e-02f, -2.54486591e-01f, -2.14128122e-01f, -1.65637478e-01f, 4.28611785e-02f, 9.58081260e-02f, -6.26742691e-02f, -9.44138784e-03f, -9.20546874e-02f, 2.10033245e-02f,
  2.44242139e-02f, -1.51741371e-01f, -1.19335406e-01f, -8.52619186e-02f, -9.19144526e-02f, -7.51291141e-02f, 9.18923039e-03f, -9.50693414e-02f, 4.56010252e-02f, -8.62611383e-02f,
  -2.28155702e-02f, 6.90069497e-02f, -3.45412754e-02f, -2.05455702e-02f, -7.18889385e-02f, 5.46994656e-02f, 4.50772494e-02f, -4.21514846e-02f, 5.59995063e-02f, 2.85459384e-02f,
  -1.03133842e-02f, -6.58423528e-02f, 2.18321644e-02f, -9.05999765e-02f, 9.27925855e-02f, 5.15323132e-02f, 6.31574318e-02f, -1.81460492e-02f, 3.07924580e-02f, 1.20164990e-01f,
  3.60141285e-02f, 1.79647490e-01f, 1.83415651e-01f, 7.78073892e-02f, 8.01911429e-02f, 2.98248231e-02f, -4.40805173e-03f, 7.58663639e-02f, -9.28826723e-03f, -1.78344194e-02f,
  9.50101987e-02f, -9.98889096e-03f, 7.11428300e-02f, 4.47725616e-02f, -5.41048124e-02f, -2.68538017e-04f, 3.19051296e-02f, -7.60895908e-02f, 6.51509091e-02f, -3.90769131e-02f,
  -1.70232505e-02f, 6.61513656e-02f, -6.34174198e-02f, 2.93436125e-02f, -5.77733889e-02f, -6.17174953e-02f, -4.59995791e-02f, -9.15104523e-03f, 7.10370541e-02f, 7.95852393e-02f,
  4.40074727e-02f, -3.15075517e-02f, -6.23261817e-02f, -5.36875054e-02f, 2.45507024e-02f, 8.49770829e-02f, 5.46783991e-02f, 4.41066884e-02f, -1.05199955e-01f, 7.04567507e-03f,
  -1.91345751e-01f, 2.45008953e-02f, -9.38450173e-02f, -1.13694333e-01f, -1.44604482e-02f, -2.83271410e-02f, -8.19037631e-02f, 7.22913668e-02f, 3.85675319e-02f, 7.95308724e-02f,
  -8.17783829e-03f, -1.23790530e-02f, -4.82715368e-02f, -5.65179922e-02f, -6.45559505e-02f, -2.27445308e-02f, 7.06486180e-02f, -3.34243290e-02f, 2.74480283e-02f, 6.67635798e-02f,
  2.32113376e-02f, 1.42046094e-01f, -5.18659130e-02f, 1.00643530e-01f, 2.53547840e-02f, 2.61568744e-02f, -1.53620066e-02f, 4.69219014e-02f, 7.95275047e-02f, 5.34046292e-02f,
  7.95064941e-02f, 9.51629877e-02f, -4.45923619e-02f, 4.85255457e-02f, 7.63292983e-02f, 5.12320139e-02f, 6.74293563e-02f, 8.02468657e-02f, 2.40466576e-02f, 1.34481430e-01f,
  -7.83141609e-03f, 1.18906274e-01f, 1.36329442e-01f, 1.13485545e-01f, 5.12517430e-02f, 1.81041822e-01f, 1.37870342e-01f, 2.68116016e-02f, -5.68778021e-04f, 9.93778780e-02f,
  7.83668533e-02f, 1.55908883e-01f, -5.13508031e-03f, 3.91874649e-02f, 1.37337402e-01f, 2.49339305e-02f, 7.97437280e-02f, 1.33995593e-01f, 3.75347286e-02f, 1.51630268e-01f,
  -1.11210965e-01f, -4.87785554e-03f, -3.13395411e-02f, 2.76609883e-02f, -3.47304605e-02f, -8.91087949e-03f, 9.81644727e-03f, -4.27580476e-02f, -7.50255361e-02f, -3.92166004e-02f,
  -9.91845783e-03f, 1.65562332e-02f, -4.25081188e-03f, 4.98776026e-02f, 1.08490866e-02f, -9.38706249e-02f, -2.68129986e-02f, 1.03073932e-01f, -2.00006738e-02f, -8.98834392e-02f,
  2.55611483e-02f, 3.71193774e-02f, -1.56578153e-01f, -1.21069372e-01f, 3.00812200e-02f, 4.96223718e-02f, -6.44355044e-02f, 6.25837892e-02f, -1.15572333e-01f, 7.93270301e-03f,
  -6.01997972e-02f, 4.44241166e-02f, 3.72483246e-02f, -8.68389476e-03f, -7.74835572e-02f, -4.73557338e-02f, -4.39492539e-02f, 2.59607397e-02f, -3.61292884e-02f, -9.56906378e-02f,
  -4.54917736e-02f, -1.46796331e-02f, -1.24363251e-01f, 4.61588502e-02f, -4.64570001e-02f, -9.70555544e-02f, 2.33859755e-02f, 3.72710302e-02f, 7.06884172e-03f, -5.62374145e-02f,
  2.28434727e-02f, -2.08628289e-02f, -1.01321816e-01f, 5.99931479e-02f, -5.38863279e-02f, -3.50249372e-02f, -7.74609372e-02f, -2.69558262e-02f, -7.95231760e-02f, 4.25493605e-02f,
  1.80624109e-02f, -8.51053596e-02f, 1.47530343e-02f, 1.01754278e-01f, -2.37667877e-02f, 4.53557596e-02f, -3.34937014e-02f, 6.38746470e-02f, -7.36230463e-02f, -6.60392195e-02f,
  -1.04295813e-01f, -4.33609225e-02f, -7.74695631e-03f, 4.47870530e-02f, -5.13977669e-02f, 5.54568879e-02f, -5.88991940e-02f, 3.03234532e-02f, 1.21132769e-01f, 4.09667827e-02f,
  2.32035499e-02f, -8.91113207e-02f, -2.53519416e-02f, -5.79004176e-03f, 7.59395584e-02f, -9.41449776e-02f, -1.79623514e-02f, -8.09202716e-03f, -2.58502457e-02f, -8.69016275e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 40)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 40;
const float L0_fan_Bp_bar_data[] = {
  1.75915271e-01f, 1.53799176e-01f, 1.73806027e-01f, 5.57968505e-02f, 1.90489128e-01f, 8.60364661e-02f, 1.91384971e-01f, 1.12258509e-01f, -3.46241929e-02f, 1.46123827e-01f,
  1.05687432e-01f, 1.23474404e-01f, 2.45806053e-01f, 5.28360568e-02f, 5.66009916e-02f, 9.17029083e-02f, 2.43767068e-01f, 8.18988010e-02f, 1.57419652e-01f, 9.40726772e-02f,
  2.08863243e-02f, 1.06575027e-01f, 1.38696581e-01f, 1.12593055e-01f, 2.97306720e-02f, 4.88890886e-01f, 1.72275007e-01f, 4.34827954e-02f, 1.61021173e-01f, 2.67644018e-01f,
  2.10849613e-01f, -7.73500139e-03f, 3.61381769e-02f, 4.77844141e-02f, 1.59427822e-01f, 9.60346535e-02f, 1.43211588e-01f, 1.69691116e-01f, 2.63758481e-01f, 8.73838216e-02f
};

// L1_fan_Wp (Shape: 12 x 64)
const int L1_fan_Wp_rows = 12;
const int L1_fan_Wp_cols = 64;
const float L1_fan_Wp_data[] = {
  9.55179930e-02f, -5.04371263e-02f, 1.64631262e-01f, 1.42186388e-01f, -8.69663507e-02f, -1.24690533e-01f, -7.43368757e-04f, -1.95820853e-01f, 4.29664254e-02f, 1.43409073e-01f,
  5.94187006e-02f, -1.28748104e-01f, 1.52911454e-01f, 7.35269859e-02f, -1.70358956e-01f, 2.73881048e-01f, -3.03395510e-01f, -5.68860434e-02f, -2.27717608e-01f, 2.41073057e-01f,
  2.45312694e-03f, -5.82895651e-02f, -1.02423944e-01f, -9.73588973e-02f, 5.54944873e-02f, 1.23353183e-01f, 2.04980765e-02f, -1.31330252e-01f, -1.43606454e-01f, 9.04951915e-02f,
  1.48366809e-01f, 2.58969571e-02f, 4.45882156e-02f, 6.94426447e-02f, -1.11700937e-01f, -1.69457361e-01f, -2.01641351e-01f, -5.80581501e-02f, -1.73297361e-01f, 1.39465004e-01f,
  4.04817276e-02f, 1.95901573e-01f, -8.54698122e-02f, 5.24462163e-02f, 2.55895913e-01f, 1.74454927e-01f, 5.76422624e-02f, -1.49459884e-01f, 9.79226530e-02f, 1.85367525e-01f,
  -2.27490082e-01f, 2.55940646e-01f, 1.05080135e-01f, 7.03038126e-02f, -1.52277589e-01f, -6.15854412e-02f, 1.04880795e-01f, -1.18311436e-03f, 3.77717018e-02f, 5.59583455e-02f,
  -4.36890908e-02f, -2.96214093e-02f, 1.05107494e-01f, -9.63817611e-02f, 1.26570255e-01f, 6.20842120e-03f, 1.29673898e-01f, 2.09882408e-02f, -1.51315043e-02f, 5.58804236e-02f,
  -1.09822169e-01f, 1.42860487e-01f, -3.22714895e-02f, -1.56699494e-01f, -8.31307769e-02f, 4.48243544e-02f, 6.05745427e-02f, -1.15972087e-01f, 8.45082402e-02f, 1.13540292e-01f,
  -6.90195337e-02f, -1.71116710e-01f, -2.05771893e-01f, 3.41711372e-01f, 3.30374360e-01f, -1.12227149e-01f, 2.64554024e-01f, -2.60167420e-02f, 2.04965800e-01f, -4.01605330e-02f,
  -6.81683794e-02f, 1.10303216e-01f, -1.05504319e-01f, 8.33895653e-02f, 9.92067382e-02f, 1.08431540e-01f, -6.39555836e-03f, -5.62830456e-02f, 1.28128186e-01f, 1.07967174e-02f,
  6.62451759e-02f, -1.42536601e-02f, -2.11590156e-01f, -1.30429715e-01f, -2.87481546e-01f, 7.71684274e-02f, 1.11439228e-01f, 7.19108433e-02f, 6.87223002e-02f, 1.09126627e-01f,
  5.49129285e-02f, 1.36524392e-02f, 8.56368244e-02f, -2.22631589e-01f, -2.38978639e-02f, -3.77277359e-02f, -2.31487677e-02f, 3.16287726e-02f, 8.17755908e-02f, 6.22331165e-02f,
  5.66532053e-02f, 2.15068907e-02f, 4.63109137e-03f, -1.49080649e-01f, -5.30445613e-02f, -1.36774749e-01f, -2.74294168e-02f, -1.08341917e-01f, 1.27115384e-01f, -8.74808580e-02f,
  -3.59017327e-02f, 1.64029285e-01f, -5.21840602e-02f, -9.79611948e-02f, 1.03768699e-01f, -1.40738860e-02f, 6.49041636e-03f, 1.08636618e-01f, 1.19875029e-01f, -9.26253423e-02f,
  1.50876362e-02f, 1.20388336e-01f, -9.53158513e-02f, 1.33409351e-01f, -3.20972860e-01f, -1.01773761e-01f, -1.55415282e-01f, 8.82484466e-02f, -8.98566097e-02f, 2.84550302e-02f,
  -2.05069363e-01f, 1.84712544e-01f, -4.61542001e-03f, 2.35780403e-01f, -6.99545369e-02f, 4.78773676e-02f, 1.33774251e-01f, -2.67919321e-02f, -5.65610044e-02f, -1.78473413e-01f,
  -7.85847008e-02f, -2.30617635e-02f, -5.98900504e-02f, -2.62534320e-02f, -7.47998878e-02f, -3.95707488e-02f, 8.55730996e-02f, 1.60599291e-01f, 1.37934059e-01f, 7.40488768e-02f,
  -5.52528277e-02f, -2.40493461e-01f, -1.14703313e-01f, 4.96608093e-02f, -3.56562883e-02f, 3.45146023e-02f, 7.11641014e-02f, 1.93615779e-01f, -2.13426024e-01f, -1.68018490e-02f,
  2.58269487e-03f, 6.60769194e-02f, -3.89982238e-02f, -1.31401978e-02f, -5.74904010e-02f, -1.12175629e-01f, 2.17329800e-01f, -1.30773969e-02f, 1.21553771e-01f, -5.49201928e-02f,
  8.12675208e-02f, -1.02946378e-01f, 6.28051758e-02f, 1.08556062e-01f, 1.02569498e-01f, -1.12871245e-01f, -7.71731436e-02f, 7.11490437e-02f, -1.32875770e-01f, -6.65485486e-02f,
  -1.54613182e-01f, 1.99265987e-01f, 1.15502492e-01f, -8.90249237e-02f, -8.70288536e-02f, 7.64722154e-02f, 8.51194859e-02f, -3.51471156e-02f, -1.17649250e-01f, -1.20784566e-02f,
  -6.95007890e-02f, 1.83284327e-01f, 1.12382315e-01f, 2.15015888e-01f, -5.98990582e-02f, 1.93075851e-01f, -1.51909694e-01f, -8.51957053e-02f, 5.63098751e-02f, -1.76009923e-01f,
  2.07437691e-03f, 7.48890415e-02f, 2.44351581e-01f, -6.69504032e-02f, -5.62187620e-02f, 1.27194718e-01f, -3.38153504e-02f, 1.54867128e-01f, -1.04616255e-01f, -5.80761768e-02f,
  -2.29694205e-03f, 5.25890663e-02f, -1.08080439e-01f, 2.09856078e-01f, 4.39365469e-02f, 7.01425970e-02f, 2.84990728e-01f, -1.58118129e-01f, -5.26664220e-02f, -1.16383128e-01f,
  2.45762691e-02f, 6.92333952e-02f, -2.24507283e-02f, 2.73301184e-01f, -2.15077344e-02f, -7.07897097e-02f, -1.97063074e-01f, -1.44938216e-01f, 7.43805096e-02f, 1.01301908e-01f,
  8.16542879e-02f, 1.67612689e-05f, 1.07129112e-01f, -3.13479066e-01f, -8.46745744e-02f, 2.01331720e-01f, -1.90817535e-01f, 1.04360774e-01f, 2.89706551e-02f, 5.90272173e-02f,
  -1.67473853e-01f, 2.12317497e-01f, 3.95378433e-02f, 1.37612950e-02f, -7.84250349e-02f, -8.12681764e-02f, -9.31835100e-02f, 8.50295573e-02f, -2.42610484e-01f, -5.29321618e-02f,
  -9.09243524e-02f, -2.01306716e-01f, 2.16460943e-01f, 2.12616324e-01f, -8.92348737e-02f, 4.81036007e-02f, -1.80143327e-01f, 1.95453331e-01f, -2.63196319e-01f, 3.72983754e-01f,
  -1.01900011e-01f, -2.17827156e-01f, -1.24132082e-01f, 3.92399505e-02f, -1.88396825e-03f, -7.28412671e-03f, -1.94703355e-01f, 1.12620354e-01f, -1.50518909e-01f, 1.17084995e-01f,
  2.61704586e-02f, 3.15275818e-01f, -1.95448413e-01f, 2.03687586e-02f, -6.67501288e-03f, -2.46551350e-01f, -8.35459754e-02f, -2.78140418e-02f, 4.42035906e-02f, -7.36726522e-02f,
  -1.44853994e-01f, -1.27985072e-03f, 2.06432119e-01f, -4.31499630e-02f, 1.99513100e-02f, -1.30191654e-01f, 1.91710413e-01f, -1.46662608e-01f, -2.80728936e-02f, -9.49522182e-02f,
  -7.59475082e-02f, -2.25400776e-02f, -2.16358662e-01f, -8.59184042e-02f, 1.27152964e-01f, 4.41871919e-02f, 9.83144194e-02f, -2.13232651e-01f, -5.30671589e-02f, 6.76592737e-02f,
  1.00620441e-01f, -2.82480437e-02f, -1.33408785e-01f, 5.42534068e-02f, -1.63626298e-01f, -1.43939853e-01f, -1.49815857e-01f, -3.39574814e-02f, -4.99491580e-02f, 6.19923025e-02f,
  2.58888490e-03f, -3.81081220e-04f, 2.84193248e-01f, 3.29869352e-02f, -4.52001318e-02f, -1.40851960e-01f, -8.43490660e-02f, 1.21118791e-01f, -5.12086824e-02f, -2.26982668e-01f,
  -9.50760469e-02f, -4.63384949e-02f, 1.20844599e-02f, -3.69634986e-01f, 9.45987105e-02f, -8.54790807e-02f, 1.49822116e-01f, -1.47716433e-01f, -3.45100425e-02f, 1.47586569e-01f,
  6.75058365e-02f, 3.80184017e-02f, 6.19750470e-02f, -3.01540699e-02f, 1.34443551e-01f, -2.31313989e-01f, -1.21151663e-01f, -8.96167103e-03f, 9.97917727e-02f, 1.22279599e-01f,
  1.97708681e-01f, 3.27865011e-03f, 9.59184095e-02f, 8.93946216e-02f, 1.27079204e-01f, 3.50036845e-02f, -1.53241470e-01f, -1.56418964e-01f, 3.57773863e-02f, 2.99003065e-01f,
  -1.19764790e-01f, 4.32371758e-02f, 1.57800674e-01f, -3.97098847e-02f, 3.24531086e-02f, 1.30102575e-01f, 2.92804576e-02f, 1.25219405e-01f, 1.48965046e-01f, -9.39300060e-02f,
  -1.88591659e-01f, 1.79525316e-01f, 6.26736134e-02f, -1.65038556e-01f, -4.91897948e-02f, -4.96941134e-02f, 6.54977411e-02f, 4.27147560e-02f, -3.47098410e-02f, -6.65869638e-02f,
  -2.43900213e-02f, -1.85679104e-02f, 8.36914778e-03f, -5.82628623e-02f, 1.10648014e-01f, 1.05872259e-01f, -1.16536729e-01f, -3.12037244e-02f, 7.54213259e-02f, 1.88595563e-01f,
  2.13623531e-02f, -2.36458629e-01f, 5.05557507e-02f, 2.98188776e-01f, 3.43864202e-01f, -1.42611206e-01f, 1.60681486e-01f, -1.51183590e-01f, -4.60514165e-02f, -4.22613770e-02f,
  3.50249186e-02f, 1.48295999e-01f, -4.87844609e-02f, -2.65014614e-03f, 8.56176093e-02f, 6.07613735e-02f, -4.50207330e-02f, 1.64996818e-01f, -3.74044999e-02f, 6.48446605e-02f,
  2.20340461e-01f, 8.57520625e-02f, -6.19992130e-02f, 2.06024110e-01f, -3.51799905e-01f, 7.95938373e-02f, -1.72498897e-01f, -4.43799905e-02f, -4.85980883e-02f, -7.04567730e-02f,
  -3.67962942e-02f, 7.97129720e-02f, 1.41106904e-01f, -2.71983534e-01f, -3.74609046e-02f, 8.47430006e-02f, -6.66207867e-03f, -2.11388618e-02f, 1.56500697e-01f, 6.95519224e-02f,
  -4.66064364e-02f, 6.73637316e-02f, -1.98509052e-01f, 2.90498286e-02f, 1.41874254e-02f, -8.27184692e-02f, -2.06682846e-01f, 9.91095677e-02f, -7.98650756e-02f, 5.99740911e-03f,
  -8.36384203e-03f, 1.28700107e-01f, -2.69769225e-02f, -9.84424874e-02f, 1.45916790e-01f, 2.12079465e-01f, 1.66348934e-01f, 1.92604270e-02f, -2.45856587e-02f, -1.10569440e-01f,
  3.93158570e-03f, -8.54771882e-02f, 1.81617990e-01f, -1.60846516e-01f, 1.10189460e-01f, 4.27495269e-03f, 1.65087625e-01f, -1.31612122e-01f, -2.32896442e-03f, -1.10922076e-01f,
  -2.22790554e-01f, -4.16167453e-02f, -7.52677396e-02f, -6.30806163e-02f, 2.01247424e-01f, 5.70754856e-02f, 6.53943196e-02f, -7.49727488e-02f, 4.62890007e-02f, -2.59501208e-02f,
  8.92865565e-03f, -8.27094316e-02f, 1.18024861e-02f, 1.16371177e-01f, 4.33014110e-02f, -3.66900079e-02f, -3.64799909e-02f, -1.59407973e-01f, 1.08912058e-01f, -6.35725111e-02f,
  -2.92143878e-02f, -1.31638691e-01f, 1.05668247e-01f, -1.02271646e-01f, 3.86981876e-03f, 4.38002050e-02f, 2.92015094e-02f, -5.62785640e-02f, -9.87902563e-03f, 6.05380014e-02f,
  2.35881031e-01f, -9.52555761e-02f, -1.76785141e-01f, 1.29722208e-01f, -1.58295155e-01f, -1.54237315e-01f, -1.10374197e-01f, 1.01159006e-01f, -9.12151709e-02f, -9.80902463e-02f,
  -1.51445806e-01f, -6.83061182e-02f, -1.17318064e-01f, -1.66035488e-01f, -5.36616258e-02f, -1.14035033e-01f, 3.52533944e-02f, 4.83475924e-02f, -1.24354392e-01f, 1.70499071e-01f,
  3.99113707e-02f, -1.87777191e-01f, -1.42182410e-01f, 7.03065842e-02f, 1.23791903e-01f, -5.79879843e-02f, 1.05162829e-01f, 2.58832604e-01f, 9.91995409e-02f, -1.88054696e-01f,
  -2.27765426e-01f, 4.09496397e-01f, 1.34650692e-01f, -1.47202760e-01f, 1.49211064e-01f, -1.22848377e-02f, 1.58245027e-01f, -3.57258469e-02f, -1.13613270e-01f, 7.53356516e-02f,
  4.42372344e-04f, -9.40636545e-03f, 3.47015075e-02f, 1.89921990e-01f, -8.98864791e-02f, 9.09047499e-02f, 2.17567626e-02f, -3.02022379e-02f, -7.32507696e-03f, -2.59594130e-03f,
  -5.57685606e-02f, 2.05644503e-01f, -3.20807785e-01f, 1.59397066e-01f, -8.28527287e-02f, -4.99232411e-02f, 5.67520633e-02f, -2.68458780e-02f, -1.13355964e-01f, 6.42245403e-04f,
  5.49314506e-02f, -1.23696290e-01f, -3.68901268e-02f, -1.38427992e-03f, -1.37498707e-01f, -1.21469334e-01f, -6.77921763e-03f, 5.56488931e-02f, 1.02324737e-02f, -1.11339860e-01f,
  -3.09069492e-02f, -8.32637027e-02f, 2.39496194e-02f, 8.62830610e-04f, -1.43199369e-01f, 2.47119088e-02f, 1.65239617e-01f, -1.12822196e-02f, 1.20037690e-01f, 6.14410779e-03f,
  7.34738484e-02f, -1.38092972e-02f, -5.62032312e-02f, -1.55268610e-01f, -5.08404747e-02f, 4.70785312e-02f, -1.16211519e-01f, 1.08336215e-03f, -1.07575402e-01f, 2.78012492e-02f,
  -1.00139819e-01f, 2.01379493e-01f, 1.13736741e-01f, 1.84703737e-01f, 1.37684811e-02f, 6.52163401e-02f, 7.35868290e-02f, -5.66084944e-02f, 9.01360437e-02f, 7.27393627e-02f,
  1.56691849e-01f, -4.52350900e-02f, 6.73455074e-02f, -7.20834062e-02f, -9.45478529e-02f, -1.26881767e-02f, 1.70131698e-01f, -7.41252899e-02f, 5.53785302e-02f, -1.12608289e-02f,
  5.44209741e-02f, -7.92162791e-02f, 5.40625453e-02f, -3.89793664e-02f, -1.74123812e-02f, -5.37538566e-02f, -9.93812829e-02f, 2.37823755e-01f, -1.17481291e-01f, 7.42915738e-03f,
  -2.63026282e-02f, 1.15857288e-01f, 4.70001362e-02f, -8.62833112e-02f, 1.62035838e-01f, -1.89618543e-02f, -5.52522317e-02f, 9.61548313e-02f, -1.17599383e-01f, 1.71957925e-01f,
  4.00437340e-02f, -1.14275679e-01f, -1.15127817e-01f, 1.28360510e-01f, 8.87615699e-03f, -2.83706766e-02f, -9.26931351e-02f, -4.87570688e-02f, 1.42695442e-01f, -9.98950079e-02f,
  3.85757424e-02f, -1.28656983e-01f, 7.80141875e-02f, 4.70566079e-02f, -7.37013528e-04f, 2.33385004e-02f, 6.12246692e-02f, 1.67527683e-02f, 5.61197177e-02f, 1.13976046e-01f,
  1.35333270e-01f, -7.53484666e-02f, 3.59922531e-03f, 7.85072222e-02f, -2.09574312e-01f, 8.18683859e-03f, -2.99756676e-01f, 1.74262375e-01f, -8.17568600e-02f, -1.32273316e-01f,
  -1.13173202e-01f, 1.63817391e-01f, -1.74766794e-01f, 2.13532761e-01f, 1.22800343e-01f, -1.32325903e-01f, 8.11824203e-02f, -7.05856830e-02f, -9.63005424e-02f, 1.22748666e-01f,
  -4.76170927e-02f, -1.84091032e-02f, -8.69480446e-02f, -3.12493686e-02f, -2.17501357e-01f, 3.20537500e-02f, -6.29323646e-02f, 2.76258979e-02f, -9.66442749e-02f, 1.77043721e-01f,
  8.86148661e-02f, 4.98208329e-02f, 6.87819943e-02f, -1.30714506e-01f, 7.25999326e-02f, -1.19416632e-01f, 1.35913536e-01f, -4.06779386e-02f, -1.18257597e-01f, 1.60438374e-01f,
  -7.36262500e-02f, 3.51482481e-02f, -1.06024504e-01f, 9.69118401e-02f, -2.67730772e-01f, 7.80815631e-02f, 4.80879135e-02f, -6.04799092e-02f, 1.43347710e-01f, -3.29857767e-02f,
  -3.44403274e-02f, 3.94073240e-02f, 2.80555021e-02f, 1.81713831e-02f, -8.21952447e-02f, -3.69664319e-02f, 9.76748168e-02f, -2.00285584e-01f, -6.00727908e-02f, -2.21800469e-02f,
  -4.10281904e-02f, 5.35446685e-03f, -6.59121871e-02f, 1.21493399e-01f, -2.01154873e-02f, -6.97085410e-02f, -1.29525557e-01f, -1.13963664e-01f, 1.10670894e-01f, 4.05868106e-02f,
  -1.22145467e-01f, -1.36642188e-01f, -1.21675218e-02f, -9.52770934e-03f, 2.08416760e-01f, 5.81379496e-02f, 1.72143325e-01f, -2.65769243e-01f, 1.46457955e-01f, 1.91087037e-01f,
  2.80309916e-02f, 4.38196696e-02f, -3.13625149e-02f, -8.09348077e-02f, 1.46279156e-01f, -9.63921398e-02f, -3.98933981e-03f, 4.62679714e-02f, 9.79285687e-02f, 2.60253362e-02f,
  1.85943171e-01f, -4.02245633e-02f, -1.67647630e-01f, -3.36959027e-02f, -3.96353006e-02f, 1.34198695e-01f, 1.24158487e-01f, -9.47011709e-02f, 3.46153937e-02f, -5.95223941e-02f,
  8.18008780e-02f, -3.23502626e-03f, -1.38901412e-01f, 1.54510075e-02f, 4.20230487e-03f, 5.14401421e-02f, -1.56238675e-01f, -1.77900478e-01f, -5.61299501e-03f, -3.74678932e-02f,
  -7.19046891e-02f, -3.42365243e-02f, -1.86333567e-01f, -1.27785757e-01f, -1.14227407e-01f, 8.81241858e-02f, 2.53125411e-02f, -1.25733748e-01f
};

// L1_fan_Wp_bar (Shape: 40 x 64)
const int L1_fan_Wp_bar_rows = 40;
const int L1_fan_Wp_bar_cols = 64;
const float L1_fan_Wp_bar_data[] = {
  1.02180660e-01f, 5.11401221e-02f, -9.48270112e-02f, -2.69466173e-02f, -8.97802934e-02f, 1.44715935e-01f, 9.96928290e-02f, -2.98809353e-03f, 8.44934396e-03f, -1.32569922e-02f,
  7.56272823e-02f, 4.64201830e-02f, 3.57232243e-02f, 1.03030704e-01f, 9.87611786e-02f, 1.08612441e-02f, -2.29216978e-01f, 8.85254145e-02f, -4.82427478e-02f, -1.66068166e-01f,
  3.17720100e-02f, 1.81366175e-01f, 1.49781138e-01f, -1.22808687e-01f, 1.13481857e-01f, 7.65983239e-02f, -1.06362857e-01f, 4.55372073e-02f, 9.20983255e-02f, 1.11666478e-01f,
  5.01707271e-02f, 5.27503602e-02f, 1.05810195e-01f, 5.16469739e-02f, -1.76884122e-02f, -1.19645737e-01f, 9.21433046e-02f, 9.71830636e-02f, -1.79450084e-02f, 1.39427960e-01f,
  2.53856152e-01f, 5.60709573e-02f, 9.24998000e-02f, 5.09326756e-02f, 7.29858270e-03f, -7.34394416e-02f, -1.80068821e-01f, 7.44266342e-03f, 4.17320803e-02f, 1.68216676e-01f,
  -8.96021491e-04f, 3.99727002e-02f, -1.61556810e-01f, 2.85868975e-03f, 4.70406450e-02f, 1.63639896e-02f, 6.92140087e-02f, -8.92371964e-03f, -1.58632826e-02f, 1.85268410e-02f,
  1.05089523e-01f, 8.42458531e-02f, 8.92455056e-02f, -6.90579228e-03f, -8.18744674e-02f, 1.39918551e-01f, -9.71322954e-02f, -6.62998343e-03f, -7.10842460e-02f, 1.68945462e-01f,
  1.70144260e-01f, 1.97779804e-01f, 1.39884666e-01f, 7.52440328e-03f, 3.90191302e-02f, 2.95325249e-01f, 2.58641746e-02f, -1.94014862e-01f, 2.10126430e-01f, -2.82207221e-01f,
  4.40757334e-01f, 3.30542363e-02f, 2.05862164e-01f, -2.09765822e-01f, 1.40065134e-01f, -3.80762547e-01f, 8.67774114e-02f, -2.43534505e-01f, -8.71379524e-02f, -4.59165163e-02f,
  5.32970652e-02f, 1.20140024e-01f, 2.63201296e-01f, 4.64909300e-02f, -1.69342548e-01f, 7.25997686e-02f, 1.01551443e-01f, 1.79856822e-01f, 1.69525355e-01f, 5.52785471e-02f,
  1.73584923e-01f, 9.14335400e-02f, -1.11775972e-01f, -7.81167392e-03f, 1.04916610e-01f, -1.98931471e-01f, 3.04126982e-02f, 2.32529283e-01f, -6.53742999e-02f, -1.72312297e-02f,
  5.20846136e-02f, 8.12673047e-02f, -1.45799294e-01f, -5.33661097e-02f, 2.15816379e-01f, -2.92092143e-03f, 1.15392599e-02f, -1.33867458e-01f, 2.96033710e-01f, 1.21661156e-01f,
  -4.13372666e-02f, 9.83500257e-02f, -6.24929443e-02f, -7.27049634e-02f, -1.54968083e-01f, 3.95529926e-01f, 1.28309339e-01f, 1.18566751e-01f, 2.25508958e-01f, 1.81963772e-01f,
  3.76045816e-02f, -3.41598988e-02f, 2.37025525e-02f, 9.45957378e-02f, 2.73800865e-02f, -2.43484139e-01f, -1.54335648e-02f, 1.62091141e-03f, 1.90794468e-01f, 2.32319832e-01f,
  -1.23464279e-01f, -7.65050352e-02f, -2.38417611e-01f, 2.13765025e-01f, 1.61552414e-01f, 2.02766806e-01f, 2.30657216e-02f, 3.49011153e-01f, 4.62861219e-03f, -2.21175496e-02f,
  9.38894898e-02f, 3.92701358e-01f, 7.41418526e-02f, 5.72380461e-02f, 5.21335192e-02f, 8.51252377e-02f, -3.81527003e-03f, -1.51784122e-01f, 5.14753796e-02f, 6.14081398e-02f,
  7.65441954e-02f, 3.60990921e-03f, -1.00328788e-01f, 8.86804983e-02f, 8.24164897e-02f, 2.35096931e-01f, 3.62707108e-01f, 2.52631158e-01f, -1.74681365e-01f, 2.09093824e-01f,
  -4.48662862e-02f, 7.27381930e-02f, -1.13782296e-02f, 1.05332479e-01f, 1.63166791e-01f, 5.78563549e-02f, 2.51880467e-01f, -7.60949701e-02f, -4.26927768e-02f, 1.18490592e-01f,
  -8.74746293e-02f, 4.56098327e-03f, 2.86629200e-01f, -7.90513903e-02f, 2.36988544e-01f, 1.88354596e-01f, -4.10000868e-02f, 1.38685048e-01f, 2.41475806e-01f, -2.58351266e-01f,
  -2.20029339e-01f, 2.90265083e-01f, 1.42099619e-01f, 1.33148938e-01f, -7.25188032e-02f, -1.64202780e-01f, 1.93256900e-01f, 6.67454451e-02f, -1.37049779e-01f, -1.69070005e-01f,
  -1.00197054e-01f, 1.07665993e-01f, 5.81814609e-02f, 1.23204038e-01f, 1.72991037e-01f, 5.37371524e-02f, -2.16816127e-01f, 3.36084887e-03f, -9.87678859e-03f, 5.45590594e-02f,
  -1.31642953e-01f, -7.57952631e-02f, -8.02411214e-02f, 1.63895383e-01f, -3.12969983e-02f, 4.59292978e-02f, 7.09331259e-02f, 4.55617346e-02f, -2.32712403e-02f, -3.96758914e-02f,
  1.41531929e-01f, -1.20522775e-01f, 1.35577276e-01f, 3.79113741e-02f, 2.03358736e-02f, 9.10155196e-03f, 1.09620668e-01f, -8.37304890e-02f, 6.72390014e-02f, 1.26902699e-01f,
  1.71542227e-01f, 2.16422945e-01f, -2.27951985e-02f, 5.52786812e-02f, 1.86901852e-01f, 1.18434779e-01f, 1.09633125e-01f, -1.14586584e-01f, 1.08971812e-01f, -9.68708023e-02f,
  1.58918217e-01f, 2.39527076e-01f, -1.28960073e-01f, 1.43218055e-01f, -9.82156172e-02f, 1.11900046e-01f, 1.51031509e-01f, -3.95246856e-02f, 5.66032492e-02f, 1.60627827e-01f,
  7.26029351e-02f, -2.73393951e-02f, -1.11790843e-01f, -1.69878751e-01f, -6.38782308e-02f, 4.95115966e-02f, -5.46753816e-02f, 1.04128867e-01f, 4.43169251e-02f, -3.83854955e-02f,
  -7.33414143e-02f, 2.06733029e-02f, 1.09604843e-01f, 7.89533257e-02f, -1.07757092e-01f, -8.82097259e-02f, 7.59575367e-02f, 1.03231601e-01f, -1.06042005e-01f, 3.90329659e-02f,
  4.15200405e-02f, -2.67396607e-02f, -1.23080745e-01f, 6.50412515e-02f, -4.55950908e-02f, -2.89234705e-02f, 2.75720283e-02f, 1.39057547e-01f, 8.72208551e-02f, 1.62804802e-03f,
  -6.04939321e-03f, 9.65804011e-02f, -9.34746787e-02f, 8.90133530e-02f, -1.34821892e-01f, -3.19982767e-02f, -7.05877915e-02f, 2.64876280e-02f, 7.09840134e-02f, -7.21216276e-02f,
  7.94120729e-02f, 4.65929396e-02f, 1.33809894e-01f, -6.29981980e-02f, 8.04863274e-02f, -1.24196298e-01f, -1.06122494e-01f, 2.31235605e-02f, 4.57414612e-03f, -6.50386885e-02f,
  -2.04163920e-02f, 5.73445298e-02f, 1.46161005e-01f, 1.41730279e-01f, 6.09412864e-02f, -6.02599308e-02f, -3.01534645e-02f, -9.85601079e-03f, -6.67932928e-02f, 5.27212657e-02f,
  8.78818408e-02f, 3.89898717e-02f, -7.21584335e-02f, -4.31101620e-02f, -9.95394737e-02f, 1.49242535e-01f, 9.91569459e-02f, -1.05710655e-01f, -7.06321597e-02f, 4.32171077e-02f,
  7.06666261e-02f, -1.70219857e-02f, -6.02558218e-02f, -2.57828888e-02f, 4.66896929e-02f, 6.02111183e-02f, 1.55336753e-01f, -1.54779321e-02f, -8.79950151e-02f, -1.29854664e-01f,
  -1.26259625e-01f, 5.84706664e-02f, -8.36925805e-02f, -1.34858191e-01f, -4.67456244e-02f, 3.55540998e-02f, 2.27833077e-01f, -4.27336292e-03f, -6.10777587e-02f, 3.07374485e-02f,
  -1.32239133e-01f, -1.56838402e-01f, 4.77532372e-02f, -5.31822667e-02f, 4.23303805e-02f, -8.85137767e-02f, 1.20944646e-03f, 2.73405984e-02f, 8.10430273e-02f, 1.08980676e-02f,
  -8.12436640e-02f, -3.38122062e-02f, 1.31945983e-01f, -1.80941373e-02f, 8.91753808e-02f, -6.10811971e-02f, 1.09077521e-01f, -9.24529657e-02f, -6.55735731e-02f, 3.67417675e-03f,
  -8.12646672e-02f, -8.23742896e-02f, -6.93942830e-02f, 5.30316979e-02f, -2.30731722e-02f, 5.77655435e-02f, 1.05954453e-01f, 1.06476828e-01f, -4.02117297e-02f, 3.03708296e-02f,
  1.50201529e-01f, 9.24107134e-02f, 1.08448721e-01f, 9.41554364e-03f, 1.40652269e-01f, 3.68452631e-02f, 9.56451893e-02f, 2.98987739e-02f, 6.63069114e-02f, -9.11831930e-02f,
  -5.32539561e-03f, 6.17704168e-02f, 1.52780786e-01f, 1.46119699e-01f, 1.49326533e-01f, -4.81846109e-02f, 1.55334890e-01f, 6.05519041e-02f, 7.97231030e-03f, 3.67565528e-02f,
  3.28777060e-02f, -1.31267840e-02f, 8.04216713e-02f, 9.77263376e-02f, 1.16350308e-01f, 1.54901162e-01f, 1.13211550e-01f, 7.30668455e-02f, -4.50748615e-02f, 2.40391955e-01f,
  7.98763484e-02f, 1.20446511e-01f, -9.68513563e-02f, 1.83051854e-01f, 1.99135214e-01f, -1.56950280e-01f, 1.76184088e-01f, -6.05877861e-02f, 2.08272085e-01f, 2.00575055e-03f,
  -1.11867093e-01f, 9.52788889e-02f, 5.58357574e-02f, -1.69453576e-01f, -8.43837336e-02f, -8.47311690e-02f, 2.42722756e-03f, -9.68850702e-02f, 8.19339678e-02f, -1.45971984e-01f,
  6.16182238e-02f, -4.50800653e-05f, 3.92807052e-02f, 1.09625580e-02f, -1.28849432e-01f, 9.00788158e-02f, -7.23083541e-02f, 1.18637949e-01f, -1.62719384e-01f, -4.01255824e-02f,
  1.81943536e-01f, 9.30891708e-02f, 2.14625508e-01f, -3.57981063e-02f, -1.60100132e-01f, 3.20817567e-02f, -1.43525526e-01f, 1.61666229e-01f, 2.72392511e-01f, -1.16093412e-01f,
  -2.50165863e-03f, 1.06668159e-01f, -2.68580001e-02f, 9.95166153e-02f, -9.98218879e-02f, 2.21317098e-01f, 1.48936197e-01f, 7.66910166e-02f, -1.05987772e-01f, -9.02257208e-03f,
  2.48204190e-02f, -9.70797613e-03f, -1.17558628e-01f, 1.70940354e-01f, -9.32431072e-02f, -2.27082446e-02f, 9.15611833e-02f, 8.88225660e-02f, -3.86892743e-02f, 9.57948193e-02f,
  -1.65934950e-01f, 1.13226421e-01f, 7.73297623e-02f, -1.63028225e-01f, 8.14077184e-02f, 4.90629710e-02f, 2.24506482e-01f, -2.81737223e-02f, -1.69119120e-01f, 7.59473220e-02f,
  -2.72108614e-01f, 1.40919521e-01f, -1.07688986e-01f, -1.32220939e-01f, -1.09470934e-01f, -5.73729053e-02f, 1.23182975e-01f, -1.62552655e-01f, 8.22135992e-03f, 1.13511123e-01f,
  4.66474419e-04f, -2.70849355e-02f, -2.95385309e-02f, 2.57518679e-01f, 1.81139279e-02f, 6.43988177e-02f, 9.06446874e-02f, -1.55694289e-02f, -1.62304565e-01f, -1.04103973e-02f,
  -2.58014798e-01f, 3.83852273e-02f, -2.77866777e-02f, 8.45374838e-02f, 1.33828133e-01f, 7.83429220e-02f, -9.76725146e-02f, -1.59202844e-01f, 1.61390796e-01f, -1.21109143e-01f,
  9.38241631e-02f, -4.25959490e-02f, 1.00780008e-02f, -4.21107095e-03f, -4.08970974e-02f, 7.25093558e-02f, 1.35858625e-01f, 2.24025860e-01f, 7.14607313e-02f, 5.35123646e-02f,
  -7.71541670e-02f, 1.19157769e-01f, -8.28048140e-02f, 1.27976373e-01f, -6.95086941e-02f, -7.55843744e-02f, 7.84778744e-02f, -8.72808471e-02f, -1.44563476e-02f, -1.72190387e-02f,
  4.00022864e-02f, 7.35099390e-02f, -1.11213706e-01f, -5.60787730e-02f, -2.52003819e-02f, -1.51618933e-02f, -6.03453107e-02f, 8.77892599e-02f, 2.46521849e-02f, -1.58399604e-02f,
  -1.76849551e-02f, -2.30940133e-02f, -1.34599358e-01f, 1.03801958e-01f, 1.09625593e-01f, -1.99102517e-02f, 4.48278338e-02f, 1.02662310e-01f, -7.59565085e-02f, -3.68043184e-02f,
  7.51560787e-03f, -8.32401142e-02f, -1.09269582e-01f, -7.70504773e-02f, 3.86148132e-02f, 4.69992869e-02f, 1.47905294e-02f, -1.23430610e-01f, 1.37352841e-02f, 4.35351729e-02f,
  -9.79931056e-02f, 1.04099950e-02f, -1.68952625e-02f, 3.57090821e-03f, 3.26314420e-02f, -3.91640291e-02f, 1.24748103e-01f, -1.72573212e-03f, -5.60413897e-02f, 6.30384460e-02f,
  3.92305851e-02f, 1.95743442e-01f, 9.07657519e-02f, 2.58660335e-02f, -1.04384638e-01f, -6.60127923e-02f, -5.63650578e-03f, 6.47525191e-02f, -9.86604616e-02f, 2.13207193e-02f,
  1.20950200e-01f, -2.18387283e-02f, -9.49538574e-02f, 2.93046962e-02f, 1.35672167e-01f, 9.12287459e-02f, 1.51755705e-01f, 1.08588338e-01f, -4.83322218e-02f, -2.93929596e-02f,
  1.10657908e-01f, -1.24007254e-03f, 6.22920692e-02f, 1.13429673e-01f, 1.18824787e-01f, -1.00118592e-02f, -3.31759788e-02f, -1.13426760e-01f, 1.27617940e-01f, -1.21036962e-01f,
  1.21181896e-02f, 9.46635976e-02f, -5.41484915e-02f, -2.61147842e-02f, -1.70617491e-01f, 1.78939566e-01f, 1.74475685e-01f, 1.11503364e-03f, -7.96983242e-02f, -1.94669515e-02f,
  -3.13647017e-02f, -4.04459275e-02f, -3.48253697e-02f, -3.11902072e-02f, -2.13369522e-02f, 1.52852818e-01f, 1.73802465e-01f, 9.15797725e-02f, 1.13410689e-01f, -3.52050327e-02f,
  8.29272941e-02f, 9.64277517e-03f, 8.84587318e-02f, -1.10845780e-02f, -1.21273458e-01f, -7.08472431e-02f, -1.16059184e-01f, 1.20810732e-01f, -4.12440635e-02f, -4.87664677e-02f,
  1.71649620e-01f, -5.15920408e-02f, 5.78580014e-02f, 4.78517562e-02f, -8.96836072e-03f, -4.78522666e-02f, 2.18874756e-02f, 1.61561489e-01f, 1.70873255e-02f, 1.03510037e-01f,
  3.18978652e-02f, -6.05420284e-02f, -2.53666807e-02f, 3.09774056e-02f, 6.66786581e-02f, 8.70056152e-02f, -1.01561792e-01f, 3.04537658e-02f, -8.21871161e-02f, 7.23131597e-02f,
  -1.21941283e-01f, 5.67771755e-02f, 6.65827021e-02f, 1.02298766e-01f, 4.24238965e-02f, -9.75877047e-02f, -3.43783712e-03f, -5.00770360e-02f, -7.24318027e-02f, 1.05511993e-01f,
  -8.80936384e-02f, -5.79186529e-02f, 6.86339661e-02f, -6.00935407e-02f, -6.91166744e-02f, -4.09645494e-03f, -6.09447546e-02f, 1.17458746e-01f, 4.80705872e-02f, 2.19098888e-02f,
  6.78124502e-02f, 9.30634420e-03f, 9.66418013e-02f, -1.20594455e-02f, -5.92215694e-02f, -4.52686362e-02f, -1.41247194e-02f, -3.27126049e-02f, -1.07337229e-01f, 1.07951850e-01f,
  1.20448872e-01f, -1.24574974e-01f, -5.54769859e-02f, 5.68062477e-02f, -8.32630917e-02f, -2.81439591e-02f, -1.17264345e-01f, -7.43283108e-02f, -1.23135693e-01f, 2.69281212e-02f,
  1.02946395e-02f, 6.41374141e-02f, 9.70702618e-02f, 1.01873696e-01f, 2.43741199e-02f, 5.20991571e-02f, 4.29241173e-03f, -4.78338404e-03f, -8.69060010e-02f, -5.13500497e-02f,
  -1.53336413e-02f, -1.16929628e-01f, 4.19336669e-02f, -8.67280643e-03f, 3.21381114e-04f, 1.07152641e-01f, -1.22368671e-01f, 8.21658596e-02f, -5.34373000e-02f, 8.14737286e-03f,
  -5.19079436e-03f, -8.84482563e-02f, -8.72483552e-02f, -1.11526407e-01f, 6.86683506e-02f, 1.75870731e-01f, 8.84444453e-04f, 1.28042577e-02f, 1.07469387e-01f, 2.73769826e-01f,
  3.73589955e-02f, 2.23834086e-02f, 8.99072737e-02f, 2.33350232e-01f, 3.21070492e-01f, 1.85307160e-01f, -3.76744747e-01f, -3.45645323e-02f, 2.50570357e-01f, -7.53258467e-02f,
  -1.55888751e-01f, -8.92680809e-02f, 1.13492355e-01f, -2.65721440e-01f, -1.20624602e-01f, 9.08455625e-02f, -3.57073955e-02f, 1.94695622e-01f, -2.24794392e-02f, -5.96811138e-02f,
  1.28063392e-02f, -4.71399762e-02f, -2.53346246e-02f, -1.12403199e-01f, 1.11870870e-01f, -1.08260445e-01f, -1.01431482e-01f, -3.96214947e-02f, 4.39827256e-02f, 2.79291749e-01f,
  1.02751918e-01f, 9.24941301e-02f, -1.25498725e-02f, -6.72573224e-02f, 1.79949597e-01f, 4.08297172e-03f, 1.91667199e-01f, 8.77560526e-02f, -1.06757618e-02f, -8.34768564e-02f,
  7.26672411e-02f, 1.61510050e-01f, 3.68163129e-03f, -4.85119745e-02f, 1.88794598e-01f, 1.33037373e-01f, -4.24858257e-02f, -1.40621126e-01f, 4.91793156e-02f, -1.07182778e-01f,
  1.62162781e-01f, -2.60244906e-02f, -1.93147629e-01f, 7.13805407e-02f, 1.58359453e-01f, -1.14902899e-01f, 1.52167371e-02f, 1.78077474e-01f, 1.28420025e-01f, 4.27413583e-02f,
  1.29005387e-02f, -3.60288583e-02f, 3.69670913e-02f, 6.10925965e-02f, -2.80481596e-02f, 2.08728999e-01f, 1.32834939e-02f, -1.37254387e-01f, 6.02878593e-02f, 1.86182112e-01f,
  1.72680393e-02f, -1.01195723e-01f, 1.26277342e-01f, -7.33007416e-02f, 2.75683373e-01f, 1.99683593e-03f, -1.63889918e-02f, 1.60153598e-01f, 1.65100321e-01f, -2.70232409e-01f,
  2.59759903e-01f, -1.49567634e-01f, 6.45439848e-02f, -1.68789516e-03f, -9.77401435e-02f, 1.66008864e-02f, 6.67301565e-02f, 1.35051101e-01f, 4.45705652e-02f, 2.07412541e-01f,
  -6.69763088e-02f, 2.88266037e-02f, 7.88562447e-02f, -1.74634069e-01f, 2.08755285e-01f, -1.03234306e-01f, 7.71725103e-02f, 7.08547905e-02f, -8.71501043e-02f, 1.48874551e-01f,
  1.67161196e-01f, 2.78422654e-01f, -1.11687612e-02f, 1.15644403e-01f, -5.31608909e-02f, -7.28650689e-02f, 8.59862939e-02f, 5.76584339e-02f, 1.04570575e-01f, -8.50753859e-02f,
  -1.55379415e-01f, -1.82091758e-01f, 2.46140838e-01f, 1.55337095e-01f, 1.00031961e-02f, 2.42308006e-01f, -5.56417368e-02f, 3.88314016e-02f, 7.59581923e-02f, 2.41496056e-01f,
  -1.08104877e-01f, 1.06178828e-01f, -1.15533639e-02f, 1.90370947e-01f, 7.38034248e-02f, 1.69711888e-01f, 1.41361043e-01f, 1.85492977e-01f, 1.50238007e-01f, 1.70445397e-01f,
  2.15089515e-01f, 7.23401830e-02f, 1.27014101e-01f, 6.10927679e-02f, -4.70800214e-02f, 1.07040375e-01f, -1.45473763e-01f, -1.03884704e-01f, 2.46870026e-01f, 1.45747572e-01f,
  -8.79505370e-03f, 1.65771544e-01f, -1.42128333e-01f, -1.21119089e-01f, -1.40002072e-01f, 2.64902040e-02f, -1.63630694e-01f, -1.83311075e-01f, 1.97223887e-01f, -4.84771766e-02f,
  1.13846526e-01f, -5.92770353e-02f, -1.20194033e-01f, 1.90790190e-04f, 1.40504360e-01f, 1.88163668e-01f, 1.48631617e-01f, 2.06172809e-01f, -1.35506570e-01f, 7.10401013e-02f,
  6.77772462e-02f, 2.75886413e-02f, -1.33772105e-01f, 2.79727336e-02f, -1.99465975e-01f, 1.93787739e-03f, -1.39076067e-02f, 1.64078742e-01f, 9.43328440e-02f, -7.38420561e-02f,
  -3.27427476e-03f, 1.34806961e-01f, -2.54729092e-02f, -7.82243311e-02f, 6.03489466e-02f, 2.15701878e-01f, 1.50464430e-01f, 1.37789920e-01f, 6.59809932e-02f, -2.08378723e-03f,
  1.83154196e-01f, 8.97414386e-02f, -6.29010238e-03f, 1.28842965e-01f, -3.92796732e-02f, -5.03062233e-02f, 1.07771344e-02f, -1.12157084e-01f, 9.74136367e-02f, -9.92480889e-02f,
  -4.91609536e-02f, -1.24725848e-01f, 1.10132590e-01f, -6.32426217e-02f, -3.32944803e-02f, -1.77055418e-01f, -3.84661332e-02f, 8.61417502e-02f, 9.82355103e-02f, -1.36667490e-01f,
  -1.35513339e-02f, 1.57807946e-01f, -2.59995870e-02f, -3.04865427e-02f, -1.06794201e-01f, 1.58790231e-01f, -3.13366838e-02f, 1.00818999e-01f, 4.55744043e-02f, -4.67798300e-02f,
  5.32041304e-02f, 1.29101142e-01f, 1.23113696e-03f, 1.57012254e-01f, -1.54506356e-01f, -4.80691232e-02f, 1.43827617e-01f, 3.47899236e-02f, 6.63556755e-02f, 4.47005080e-03f,
  1.04077108e-01f, 4.69672121e-02f, 5.19704483e-02f, -9.93715897e-02f, -1.69963446e-02f, -2.97279302e-02f, -1.65988520e-01f, 9.20476466e-02f, 8.61358717e-02f, 1.65513083e-02f,
  2.50169486e-02f, 1.02867737e-01f, 6.80777505e-02f, 6.83992030e-03f, -1.24217132e-02f, 4.64184629e-03f, -7.13843927e-02f, 8.19071196e-03f, 5.28942458e-02f, 7.81704038e-02f,
  2.62003187e-02f, 1.11486893e-02f, 5.87967038e-02f, -3.76162939e-02f, -1.18168220e-01f, -1.00623414e-01f, -9.22557637e-02f, -9.70671140e-03f, 7.97196999e-02f, 6.18968084e-02f,
  1.53650463e-01f, -7.72810429e-02f, 1.89211860e-01f, 1.13073938e-01f, 1.59417599e-01f, 1.75026562e-02f, 1.23712897e-01f, 3.40775251e-02f, -3.97728942e-02f, -1.93288267e-01f,
  -7.37911090e-02f, 3.00817862e-02f, 2.06772521e-01f, -2.52578650e-02f, -1.03738420e-01f, 2.60692596e-01f, 2.59744888e-03f, -6.66247532e-02f, 3.22889746e-03f, 2.73432940e-01f,
  1.66271985e-01f, -3.52549046e-01f, -1.58885084e-02f, -2.22317398e-01f, 1.45145968e-01f, 6.51960745e-02f, 3.69702540e-02f, 7.92092532e-02f, -1.06205471e-01f, -6.15102879e-04f,
  -1.38447620e-03f, 9.84443203e-02f, 1.67989954e-01f, -8.18237066e-02f, -5.49986288e-02f, -1.12680756e-01f, 3.12402874e-01f, -1.93171278e-02f, 6.00452907e-02f, -4.13594991e-02f,
  -1.86387107e-01f, 1.19680002e-01f, -1.29960209e-01f, 9.56571847e-02f, 6.47195578e-02f, 5.51468544e-02f, -4.88822311e-02f, 5.62070496e-02f, 1.08120054e-01f, 5.46023212e-02f,
  -9.02267620e-02f, 2.95768641e-02f, 3.32343727e-02f, 4.83094603e-02f, 2.66566783e-01f, 1.15197919e-01f, -6.58246875e-02f, 1.01305634e-01f, 2.88524553e-02f, 3.53245484e-03f,
  -7.09927306e-02f, 2.98874944e-01f, 7.90456831e-02f, 1.32692382e-01f, 1.31646767e-01f, 1.56520605e-01f, 1.41148090e-01f, -2.75558028e-02f, -9.11080539e-02f, -7.25735575e-02f,
  2.45235935e-02f, 1.36304751e-01f, 7.31796399e-02f, 9.94354580e-03f, 6.54467121e-02f, 5.58769219e-02f, 9.79461446e-02f, 6.86559752e-02f, 1.56967640e-02f, -2.43836045e-01f,
  1.79644041e-02f, -9.74131674e-02f, -2.02346016e-02f, -1.06721353e-02f, 2.44761091e-02f, 1.59487069e-01f, 5.09554259e-02f, -2.04457641e-01f, -3.84985805e-02f, 8.78876001e-02f,
  1.35670394e-01f, -8.61040950e-02f, -4.03604768e-02f, 1.92740306e-01f, 2.08633244e-02f, 5.17476024e-03f, 1.48950726e-01f, -1.19311325e-02f, 4.38016690e-02f, -2.00772043e-02f,
  6.33867905e-02f, -1.22773543e-01f, -5.30214570e-02f, 5.74977025e-02f, 1.04825363e-01f, 4.88921888e-02f, 2.24069744e-01f, 1.71654746e-01f, 2.24402592e-01f, -5.48954830e-02f,
  -1.16655760e-01f, 2.22274624e-02f, -7.56530315e-02f, 2.72820622e-01f, 1.51635572e-01f, 2.61125416e-02f, -1.36925997e-02f, -2.60699149e-02f, -1.78215533e-01f, 5.54094985e-02f,
  1.07997358e-01f, -2.41197320e-03f, 1.87454298e-02f, -3.21125388e-02f, -6.14877418e-02f, -7.21646622e-02f, -6.61350861e-02f, 8.93682241e-02f, 1.55455926e-02f, -2.49117538e-02f,
  1.15333110e-01f, 1.82206646e-01f, 2.63919458e-02f, 6.34573698e-02f, 1.59199573e-02f, 1.08720563e-01f, 1.68481126e-01f, 1.60520494e-01f, 5.14541715e-02f, 1.14654399e-01f,
  5.00063263e-02f, 1.16275065e-01f, -1.71460226e-01f, 1.39341960e-02f, -1.97058588e-01f, 8.32032710e-02f, -1.41641468e-01f, -1.32308021e-01f, -1.92438178e-02f, 6.30755201e-02f,
  9.92711335e-02f, 2.74215564e-02f, 1.12282686e-01f, 1.19978994e-01f, -1.37057513e-01f, -3.58815975e-02f, -4.65517417e-02f, 4.80679944e-02f, 5.49874716e-02f, -1.05905861e-01f,
  3.64659689e-02f, -6.87793866e-02f, -2.35578820e-01f, -1.73975840e-01f, 2.43517235e-02f, -6.55335886e-03f, -3.97765636e-02f, -2.44230721e-02f, 6.12406284e-02f, 3.66349326e-04f,
  8.69079605e-02f, 2.79725492e-02f, -1.08120523e-01f, 1.01247050e-01f, -9.96935666e-02f, -3.05263754e-02f, 9.04996134e-03f, 1.60393491e-01f, 7.27874115e-02f, 2.52644643e-02f,
  -2.97090076e-02f, 3.97558920e-02f, -9.07102600e-02f, 1.11256003e-01f, -1.28352558e-02f, -1.22875877e-01f, 1.27809718e-01f, -8.62992480e-02f, 5.02532758e-02f, -1.69011243e-02f,
  1.67665482e-01f, 4.73779999e-02f, 4.95809577e-02f, 1.05431333e-01f, 1.60504226e-02f, -7.52377659e-02f, -9.63717103e-02f, -1.17008500e-01f, 3.18569466e-02f, 5.21375500e-02f,
  -5.92520237e-02f, 1.57588318e-01f, -4.50580083e-02f, -1.02796383e-01f, -8.90428275e-02f, -6.51096320e-03f, -2.08869606e-01f, 5.98832294e-02f, -1.11529671e-01f, 1.43168166e-01f,
  6.00840710e-02f, -2.09962323e-01f, -1.38284564e-01f, -3.09981052e-02f, 2.09697206e-02f, 1.20759763e-01f, 1.60333619e-01f, 8.13344344e-02f, -1.11299649e-01f, 5.77350520e-02f,
  -1.42804822e-02f, -1.12958988e-02f, -2.00104062e-02f, -7.96512961e-02f, -6.14168607e-02f, -6.74759150e-02f, 5.80488481e-02f, -1.73882678e-01f, 2.61295326e-02f, 1.13875560e-01f,
  1.49614930e-01f, -1.71330228e-01f, 2.51925111e-01f, -4.42086086e-02f, 1.67513490e-02f, -1.11445971e-01f, -7.89466128e-02f, -2.57287249e-02f, 1.06260389e-01f, -9.58590358e-02f,
  -5.74752502e-02f, 1.64554939e-01f, -1.25922322e-01f, 3.29922624e-02f, -1.62685260e-01f, 1.23270959e-01f, 9.51080620e-02f, 3.99918482e-02f, -1.17453858e-01f, 5.27625196e-02f,
  9.32736397e-02f, 9.62071344e-02f, -4.00674865e-02f, 1.28639087e-01f, 2.58444846e-01f, 5.60858473e-02f, 2.55722880e-01f, 6.32957295e-02f, -1.10315360e-01f, 1.72194079e-01f,
  2.80389972e-02f, -4.37860414e-02f, 1.03927016e-01f, 1.73809022e-01f, 1.54931858e-01f, 7.81100690e-02f, -1.93276834e-02f, 2.55791843e-01f, -1.84717074e-01f, -2.03727618e-01f,
  3.70769382e-01f, -1.11640893e-01f, -2.79082268e-01f, -3.38841155e-02f, 5.75411357e-02f, -1.65475145e-01f, -5.45197539e-02f, 6.42857850e-02f, 3.42154741e-01f, -1.93143159e-01f,
  3.00218076e-01f, 2.14231059e-01f, -2.28846624e-01f, 2.65327394e-01f, 6.97882548e-02f, 3.94888073e-02f, -1.27304792e-01f, 1.06483147e-01f, -7.55262598e-02f, -1.18917480e-01f,
  -1.09711461e-01f, -8.91407877e-02f, 4.12652075e-01f, -1.55445278e-01f, 4.73127849e-02f, -8.93005207e-02f, 1.57222208e-02f, -1.36412546e-01f, 4.06310827e-01f, 3.28999273e-02f,
  -2.83760261e-02f, -1.60879597e-01f, -1.58692300e-01f, 8.58919322e-02f, -1.56160714e-02f, -7.80412778e-02f, 3.24714422e-01f, -2.14579821e-01f, -2.61434335e-02f, -2.78323106e-02f,
  6.85066953e-02f, -1.41752958e-01f, 6.97895810e-02f, -1.36557639e-01f, 1.80586502e-02f, -7.78707862e-02f, -8.58765393e-02f, 1.87529385e-01f, -2.20159143e-02f, -2.02303212e-02f,
  4.07924615e-02f, 1.26869872e-01f, -6.32560328e-02f, 6.01231344e-02f, 1.52485743e-01f, 9.64531824e-02f, -1.58867165e-02f, 1.20489903e-01f, 2.46716253e-02f, 4.49586995e-02f,
  9.06365737e-03f, 2.19689399e-01f, 1.64698623e-02f, 1.60476923e-01f, -5.94132654e-02f, -1.87728494e-01f, 6.31093010e-02f, 1.68668866e-01f, 3.06478310e-02f, -7.82309249e-02f,
  -2.09814999e-02f, 2.38570094e-01f, -4.48988453e-02f, -4.92993519e-02f, -1.21588334e-02f, -1.49826124e-01f, 2.54741386e-02f, -1.56454921e-01f, -1.64208431e-02f, -4.84326296e-02f,
  1.55751081e-02f, 9.09004807e-02f, -2.95980796e-02f, 5.88970967e-02f, 7.28328526e-02f, -2.88138166e-02f, -2.38252450e-02f, -4.07971963e-02f, 1.03535652e-01f, 1.35999992e-01f,
  2.96517313e-02f, -7.32818246e-02f, 2.47695804e-01f, 8.69159251e-02f, 1.62174433e-01f, -6.05869815e-02f, -1.06175080e-01f, -1.45654097e-01f, 8.31000805e-02f, 1.85736075e-01f,
  2.50416510e-02f, 8.56955275e-02f, -4.29398417e-02f, 7.53936917e-02f, -4.98140492e-02f, 1.30370662e-01f, 1.41168997e-01f, -4.80658561e-02f, 1.86068416e-01f, 5.77726513e-02f,
  -1.16105467e-01f, -4.41471189e-02f, 1.38540730e-01f, -5.26914671e-02f, 2.29975104e-01f, 2.02102751e-01f, 2.18195468e-01f, 2.04504848e-01f, 1.00517400e-01f, -1.53109301e-02f,
  2.58973986e-01f, 1.23828411e-01f, 1.96865052e-02f, 2.20997468e-01f, -1.04440367e-02f, 5.54710962e-02f, -1.47116303e-01f, -1.47417232e-01f, 1.88159347e-01f, 2.31337816e-01f,
  -3.98388058e-01f, -4.05576795e-01f, -1.21672221e-01f, 7.02718794e-02f, 2.55830258e-01f, 1.53278708e-01f, 2.15319127e-01f, -3.69178355e-01f, 3.10842872e-01f, 2.48262644e-01f,
  9.52144563e-02f, 2.26019502e-01f, 1.11841103e-02f, -1.46788657e-02f, 3.35583359e-01f, 6.55641034e-02f, 6.33621290e-02f, -1.20541066e-01f, 1.12158097e-01f, -1.50090680e-01f,
  2.72749186e-01f, 1.65516585e-02f, -1.69815123e-01f, 5.28234094e-02f, 1.60156175e-01f, 1.84021354e-01f, 1.57733619e-01f, -1.08592778e-01f, 1.96789324e-01f, -2.18006909e-01f,
  1.40863448e-01f, 4.03759480e-02f, 2.83543430e-02f, 9.46215615e-02f, 1.29872724e-01f, -4.37413305e-02f, 1.30928800e-01f, -1.73630819e-01f, -2.35560745e-01f, 6.39986023e-02f,
  6.23401292e-02f, -1.62910186e-02f, -1.29405811e-01f, -1.36071995e-01f, 1.25122085e-01f, 1.69818923e-02f, 3.61485109e-02f, -1.83777168e-01f, -1.69273075e-02f, 8.93217251e-02f,
  2.16341749e-01f, 2.77406871e-01f, 1.80795908e-01f, 6.71996176e-03f, 1.41179115e-01f, 3.09517235e-01f, 2.00181052e-01f, 1.89451370e-02f, 1.10791028e-01f, -8.24368596e-02f,
  1.40803531e-01f, 3.56161334e-02f, 6.61174580e-02f, -3.85291576e-02f, -2.12066770e-01f, -1.68027878e-01f, -2.59433657e-01f, 1.59296721e-01f, 7.88632222e-03f, -7.14939535e-02f,
  -4.46777642e-02f, -6.10131808e-02f, 8.76492634e-02f, -5.71041107e-02f, 1.70753524e-01f, 4.95344102e-02f, -7.68031776e-02f, 1.69440314e-01f, -6.66316897e-02f, 1.75536081e-01f,
  -1.44730853e-02f, -8.15736204e-02f, -6.62432238e-02f, -1.02788582e-01f, -1.82376847e-01f, 3.97638828e-02f, -1.55274972e-01f, 7.12825283e-02f, -5.11656553e-02f, -1.68784350e-01f,
  5.07292822e-02f, 5.76341897e-02f, 1.56126916e-01f, 1.16342809e-02f, -6.23457432e-02f, 5.31057175e-03f, 8.55165049e-02f, 1.06370635e-01f, -4.41121869e-02f, 9.00621265e-02f,
  2.41844356e-01f, 1.03160441e-01f, -1.37618259e-01f, 2.00811431e-01f, 1.11511564e-02f, -1.05865575e-01f, 2.04777300e-01f, -4.92291898e-02f, 8.77405331e-02f, -8.03589374e-02f,
  4.11701314e-02f, 5.55688664e-02f, 8.14393982e-02f, -7.96608254e-02f, 7.60428160e-02f, 4.31713089e-02f, 3.98661792e-02f, 2.90687699e-02f, 4.43843007e-02f, 6.11508042e-02f,
  -3.98660377e-02f, 1.01309940e-01f, -9.16313902e-02f, 1.48795068e-01f, 8.31808001e-02f, 1.40371814e-01f, -2.74098627e-02f, 1.13003597e-01f, -1.12187564e-01f, 4.67019118e-02f,
  -1.69436455e-01f, 1.44142359e-01f, -4.12169248e-02f, 1.48352221e-01f, -7.32153729e-02f, 6.40225038e-02f, 9.75181758e-02f, -5.20397983e-02f, -8.71884599e-02f, -1.05589509e-01f,
  6.66924864e-02f, 1.06633283e-01f, -7.80456141e-02f, 8.19871947e-02f, 3.20600569e-02f, 2.68149618e-02f, 4.15597968e-02f, -1.09328954e-02f, -6.15090691e-02f, -6.68281242e-02f,
  -5.78349084e-02f, 1.66762054e-01f, -9.22752842e-02f, 3.76321003e-02f, 2.23095298e-01f, 1.87893994e-02f, 1.86790243e-01f, 4.95901629e-02f, 1.27019724e-02f, -1.07719295e-01f,
  -1.02826163e-01f, 2.78635472e-01f, 1.38401106e-01f, -3.87841947e-02f, -1.24003924e-02f, -2.55040247e-02f, -3.69189195e-02f, 4.15126700e-03f, 1.34776840e-02f, -8.31787884e-02f,
  5.82698658e-02f, -1.15087874e-01f, -5.99306673e-02f, -8.63256454e-02f, 1.32066190e-01f, -3.07698026e-02f, 1.06923789e-01f, 1.70002609e-01f, 1.27806172e-01f, 3.18220645e-01f,
  2.48546898e-01f, 8.11773986e-02f, -5.18915767e-05f, -1.58476885e-02f, -5.01474738e-02f, 3.75876762e-02f, 5.22735231e-02f, 1.35780320e-01f, -1.00081109e-01f, 2.44513936e-02f,
  -2.17476916e-02f, -7.40456879e-02f, -2.54856974e-01f, 2.48128828e-02f, 1.55226840e-02f, -1.77339196e-01f, -1.81456923e-01f, 8.68674517e-02f, 8.12038372e-04f, 3.45740855e-01f,
  6.44850731e-02f, -7.00229779e-02f, -1.34119689e-01f, 7.68533871e-02f, -1.14630394e-01f, 3.13839614e-02f, 1.36133721e-02f, -1.31597072e-01f, -5.56895509e-02f, -5.82261421e-02f,
  -1.83892235e-01f, 1.55454233e-01f, -7.32920840e-02f, -2.84786094e-02f, 9.15835127e-02f, -1.21262573e-01f, 1.18102558e-01f, -2.14634649e-02f, -6.50725365e-02f, 1.51179517e-02f,
  -1.17402710e-01f, 1.06775165e-01f, 2.69396752e-01f, 3.95094603e-03f, -1.00136705e-01f, 2.22757861e-01f, -9.19637308e-02f, -1.09316573e-01f, 1.44068271e-01f, 2.08407491e-01f,
  -7.33410791e-02f, -5.87247238e-02f, -3.81955435e-03f, -1.26575395e-01f, 1.96884319e-01f, 9.82751250e-02f, 1.21612333e-01f, 9.74569172e-02f, 3.52685973e-02f, 1.29444646e-02f,
  4.38273177e-02f, 5.78751275e-03f, 3.87227945e-02f, 7.47769773e-02f, 2.03324452e-01f, 1.18769288e-01f, 8.95825401e-02f, -8.87758434e-02f, 6.44912794e-02f, 8.09383243e-02f,
  -5.95218614e-02f, 1.02352932e-01f, 2.43326515e-01f, 1.32890910e-01f, -2.03204960e-01f, 2.39153147e-01f, -8.14119130e-02f, -2.49035265e-02f, -3.96651663e-02f, -1.88394412e-01f,
  -1.80314288e-01f, -2.44177565e-01f, 9.22735333e-02f, 4.76981662e-02f, 8.34138170e-02f, 7.06810132e-02f, -1.54234231e-01f, 2.01398492e-01f, 6.27271086e-02f, 3.07891257e-02f,
  -1.21312194e-01f, -1.15422606e-01f, -7.59310126e-02f, -1.82815760e-01f, -8.12382400e-02f, -7.96016604e-02f, 2.24832147e-01f, 1.52811751e-01f, 1.88263565e-01f, 1.34516865e-01f,
  3.20127279e-01f, 1.31339327e-01f, -1.43767387e-01f, -1.24543376e-01f, -2.64402963e-02f, 1.20098345e-01f, 1.36021361e-01f, -2.59708567e-03f, 1.05615593e-02f, 2.36503869e-01f,
  -8.02026540e-02f, -5.13738021e-02f, -4.79266718e-02f, 2.40672886e-01f, 1.59673840e-01f, -4.84832972e-02f, 1.75593514e-02f, -5.82242981e-02f, 2.07194224e-01f, 1.36366766e-02f,
  -5.06325513e-02f, 3.06188405e-01f, 3.15665454e-01f, 2.34551113e-02f, -3.33530679e-02f, 1.55722633e-01f, 1.83397010e-01f, 2.20035203e-02f, -3.00552249e-02f, 9.37159806e-02f,
  8.67522806e-02f, -6.05233945e-02f, 1.38659060e-01f, 1.78216830e-01f, 9.71502364e-02f, 1.36791870e-01f, -9.23764333e-03f, 1.30566552e-01f, 3.19740698e-02f, 6.58802241e-02f,
  -1.31054288e-02f, -9.87327285e-03f, 2.54360177e-02f, -1.67041793e-01f, 5.03654927e-02f, 2.89951246e-02f, -2.28337616e-01f, 1.76467583e-01f, -1.42492458e-01f, 1.29831403e-01f,
  5.82564697e-02f, 9.17929336e-02f, 1.84271961e-01f, -9.09992680e-02f, 6.81117177e-02f, -1.39643222e-01f, 4.52784486e-02f, 1.60451338e-01f, 2.56946180e-02f, 1.44263044e-01f,
  -7.68831298e-02f, 3.54030989e-02f, 3.48225832e-02f, -1.38623074e-01f, 1.30318239e-01f, 1.08578904e-02f, -1.34681761e-01f, -1.02238722e-01f, -2.78605483e-02f, -5.35984859e-02f,
  2.28093177e-01f, 2.25069318e-02f, -8.21284428e-02f, 8.69239569e-02f, 1.23520784e-01f, -6.60666674e-02f, 1.19497105e-01f, 6.38599228e-03f, 9.57289618e-03f, 1.21631678e-02f,
  -8.93480405e-02f, -5.87404966e-02f, 6.23722840e-03f, 1.42403543e-01f, 1.40178889e-01f, 4.08196785e-02f, -1.26846075e-01f, -4.20387387e-02f, 1.66853622e-01f, 8.96008462e-02f,
  6.53878823e-02f, 1.38332933e-01f, -3.65370512e-02f, 3.07960436e-02f, 9.19641405e-02f, -1.09071322e-01f, 1.11504950e-01f, 1.46667585e-02f, 1.17654137e-01f, 2.25722089e-01f,
  2.06998527e-01f, 9.60241188e-04f, -2.39425108e-01f, 3.04397851e-01f, -1.46979123e-01f, 1.73569009e-01f, -1.80111885e-01f, 5.25888205e-02f, 9.27732438e-02f, -2.11613849e-02f,
  1.67893633e-01f, -2.58657746e-02f, -6.50973991e-02f, 2.40050197e-01f, 1.30303219e-01f, 4.44553457e-02f, 2.85834186e-02f, 1.22684009e-01f, -6.77235946e-02f, 3.79883908e-02f,
  -7.20681772e-02f, 1.51441619e-02f, -1.77128926e-01f, -1.53326318e-01f, 9.58192162e-03f, 7.62422681e-02f, 1.53192148e-01f, 7.89838210e-02f, -2.04111096e-02f, 2.37401336e-01f,
  -1.72784016e-01f, 6.95157796e-02f, -6.92004412e-02f, 1.89383775e-01f, 1.33730367e-01f, -8.72623697e-02f, 2.03240901e-01f, -5.26683331e-02f, -1.48487464e-01f, 9.62719098e-02f,
  -5.61646931e-02f, 1.00281991e-01f, 2.17840955e-01f, -1.00811005e-01f, -7.95022622e-02f, 1.04373664e-01f, -3.72585803e-02f, -4.46755551e-02f, 3.82604264e-03f, 1.65615007e-01f,
  9.07488391e-02f, -7.45246485e-02f, -3.14579271e-02f, -7.58321136e-02f, -6.68644160e-02f, 1.08452737e-01f, 2.41747331e-02f, -6.44882172e-02f, -5.21565750e-02f, 1.29455686e-01f,
  5.42187551e-03f, -7.39942677e-03f, -1.45684659e-01f, 1.50304049e-01f, -2.44720816e-03f, 8.71736631e-02f, -5.16238362e-02f, 1.06842011e-01f, 1.12361372e-01f, 5.16366139e-02f,
  4.12763394e-02f, 7.99919944e-03f, 1.17026351e-01f, 4.58967127e-02f, -1.29978895e-01f, 5.03090806e-02f, 1.35796890e-01f, 1.14954822e-01f, 8.44118670e-02f, 3.45845856e-02f,
  -4.57730740e-02f, 6.45297617e-02f, -6.96237534e-02f, -2.10622735e-02f, -9.52078924e-02f, 4.68554236e-02f, 1.11794986e-01f, 1.58928365e-01f, 3.69331986e-02f, 8.53625312e-02f,
  3.82881463e-02f, 1.76949650e-01f, -1.02781318e-01f, -9.44895446e-02f, -6.79342449e-02f, 8.63613114e-02f, -2.53628157e-02f, -5.78978956e-02f, 2.84751207e-02f, 2.56955680e-02f,
  -1.00523435e-01f, -9.40785930e-02f, 3.63963768e-02f, -1.23024158e-01f, -9.36231986e-02f, -2.32442915e-02f, 9.09645557e-02f, -6.75425753e-02f, -1.95065439e-02f, -6.45493791e-02f,
  -9.35430750e-02f, 6.20561317e-02f, 1.36323258e-01f, -2.84519419e-02f, -7.00519904e-02f, 1.54734597e-01f, 2.40840137e-01f, 1.69760808e-01f, -8.15654099e-02f, 2.99240295e-02f,
  2.71320194e-01f, -7.17698708e-02f, 7.52175599e-02f, 1.29142687e-01f, 2.01891869e-01f, 4.11873646e-02f, 2.08281934e-01f, 1.20355546e-01f, 2.14654282e-01f, 2.22512096e-01f,
  3.08051892e-02f, 1.35614902e-01f, -1.74288884e-01f, -3.33175175e-02f, -6.43934980e-02f, 1.81280866e-01f, 1.55741826e-01f, -6.66912273e-02f, -2.62238055e-01f, -1.94006369e-01f,
  -2.31346279e-01f, -5.09155914e-02f, 7.81742930e-02f, 2.65425513e-03f, 2.97971398e-01f, 1.24878488e-01f, 2.93057203e-01f, -3.19951326e-02f, -6.39468282e-02f, 1.37745246e-01f,
  2.95267969e-01f, -1.42184170e-02f, 1.17840074e-01f, -4.01405320e-02f, -6.65702149e-02f, 3.12650770e-01f, -2.26376038e-02f, 1.42144859e-01f, -1.68062270e-01f, -1.20343022e-01f,
  7.14713782e-02f, 2.22031604e-02f, -1.24368332e-01f, -1.68018118e-01f, -5.78740127e-02f, 1.90542400e-01f, -1.13860928e-01f, 2.47861430e-01f, 2.65214264e-01f, 2.32252449e-01f,
  -1.73527207e-02f, -1.18640132e-01f, 3.18782106e-02f, -7.08227530e-02f, 2.19051629e-01f, 1.80167556e-02f, -6.60442188e-02f, -1.25205919e-01f, -2.16249302e-01f, -1.10713735e-01f,
  2.20153809e-01f, 1.99032515e-01f, 1.52978554e-01f, 1.77412853e-01f, 1.76407129e-01f, 6.83869701e-03f, 1.84453949e-01f, 2.12252989e-01f, 1.52387992e-01f, -4.34805453e-02f,
  2.12280825e-01f, 8.91674384e-02f, -1.81581154e-02f, 7.76653141e-02f, -3.13170403e-02f, -4.29907329e-02f, 3.85965079e-01f, 8.94655362e-02f, 7.68125951e-02f, 1.63503274e-01f,
  2.46417392e-02f, -3.91065061e-01f, 8.65709968e-03f, 3.61328945e-02f, -2.81265229e-01f, 2.75214445e-02f, 2.25028902e-01f, 1.17000312e-01f, 1.63302481e-01f, -6.75332546e-02f,
  9.98547748e-02f, -1.70411840e-02f, 1.34298414e-01f, -6.65170923e-02f, 2.16318414e-01f, 1.49654433e-01f, 1.31437108e-01f, 2.65012607e-02f, 2.39138249e-02f, 8.50391090e-02f,
  -2.24826366e-01f, 1.07770570e-01f, -3.52445692e-01f, -8.50373060e-02f, -1.29846320e-01f, 1.13512523e-01f, 6.30406365e-02f, 3.03142779e-02f, 1.74727529e-01f, -3.92081708e-01f,
  -7.29633868e-02f, 1.32573798e-01f, 2.81186759e-01f, 5.61770163e-02f, 3.33465278e-01f, -1.05655156e-01f, 1.16872370e-01f, 1.80998281e-01f, -8.97404104e-02f, -8.08649734e-02f,
  3.97964343e-02f, -1.21393288e-02f, -2.06571326e-01f, 4.99982834e-02f, 8.36255923e-02f, 3.95868570e-02f, 1.62706122e-01f, -1.83236986e-01f, 7.57631287e-02f, 7.82883167e-02f,
  1.05560273e-01f, -1.38597205e-01f, 5.52718863e-02f, 8.43708664e-02f, -2.06771642e-02f, 7.85294250e-02f, -1.05173260e-01f, -4.70483862e-03f, 1.18637279e-01f, 3.71926837e-02f,
  -2.17976913e-01f, -6.52235523e-02f, -1.77029312e-01f, 1.80766284e-01f, 2.68648993e-02f, 2.85399258e-01f, 1.77537471e-01f, -2.01842248e-01f, 2.23230720e-01f, 1.70931771e-01f,
  -9.68983024e-02f, -6.03048578e-02f, -1.64813265e-01f, 8.22389200e-02f, 1.02349319e-01f, 1.24677800e-01f, 1.05144888e-01f, 2.04321276e-02f, -3.47403884e-02f, -1.65760502e-01f,
  6.79917932e-02f, -1.35873824e-01f, 1.22083232e-01f, 1.89247236e-01f, -4.63185087e-02f, 2.23155990e-01f, 2.51138598e-01f, 4.69682440e-02f, 7.83734471e-02f, 5.23721427e-02f,
  -2.53095120e-01f, -1.02504723e-01f, 8.96025226e-02f, 2.84613848e-01f, 5.55211380e-02f, 1.12638228e-01f, -2.02457592e-01f, -1.25305116e-01f, 1.10087268e-01f, -4.69603352e-02f,
  5.27256653e-02f, 6.69746324e-02f, 6.62685111e-02f, 5.67442216e-02f, 1.57890752e-01f, -8.40910822e-02f, -5.88664636e-02f, 8.59025046e-02f, -7.75602832e-02f, 1.09560117e-01f,
  -6.64326772e-02f, -2.52489746e-02f, 1.18241735e-01f, -4.11787182e-02f, 1.47724554e-01f, 1.69255778e-01f, 1.70483172e-01f, 6.68682083e-02f, 4.29806747e-02f, 9.08752829e-02f,
  2.60552526e-01f, 1.47585556e-01f, -2.76226420e-02f, -2.24350654e-02f, -2.28742465e-01f, 4.08230871e-02f, 6.28833696e-02f, -2.18949556e-01f, -1.42681345e-01f, -6.16383366e-02f,
  1.70217827e-02f, -2.17486441e-01f, 4.59791720e-02f, 1.37958199e-01f, 2.25388169e-01f, 5.37704565e-02f, -2.18640026e-02f, 1.69102296e-01f, 1.81975022e-01f, -9.12031904e-02f,
  -7.94692785e-02f, -7.16057792e-02f, -3.38378325e-02f, -9.61638242e-02f, 1.60944983e-01f, -3.09729669e-02f, 1.26862705e-01f, 1.54415458e-01f, 1.60536110e-01f, 2.56780852e-02f,
  1.99535061e-02f, 6.42792955e-02f, 1.10787719e-01f, -1.43438995e-01f, -1.66963965e-01f, -7.59282634e-02f, -6.02161027e-02f, 3.54071826e-01f, -1.37321830e-01f, 5.48334904e-02f,
  9.34679359e-02f, 1.31932929e-01f, -9.80823040e-02f, 9.95005667e-02f, 1.86546177e-01f, 7.45504424e-02f, 1.47578701e-01f, -5.86886927e-02f, -8.90227035e-03f, 4.28952612e-02f,
  -2.07772981e-02f, -4.49762531e-02f, 1.28198806e-02f, 1.39038205e-01f, 4.93402742e-02f, -4.85423807e-04f, 9.16082337e-02f, -8.92643332e-02f, -8.43575299e-02f, -5.19259181e-03f,
  3.65293883e-02f, 9.63813588e-02f, 1.03201456e-01f, -1.31762579e-01f, -1.79176480e-01f, -8.51754323e-02f, 2.56054457e-02f, 6.02475554e-03f, 1.96651980e-01f, 1.22609427e-02f,
  6.11146502e-02f, -1.77531213e-01f, -6.39331061e-03f, 4.17179801e-02f, -1.24112323e-01f, 1.33928359e-01f, -4.56755757e-02f, -4.35083732e-02f, 6.07554317e-02f, -5.72370254e-02f,
  -2.22231057e-02f, 3.01313549e-02f, -2.02149036e-03f, -7.67447427e-02f, 7.60128871e-02f, -5.54518215e-02f, -8.80247727e-03f, 2.57646114e-01f, -8.28627795e-02f, 9.96199176e-02f,
  1.88976645e-01f, 1.12848124e-02f, -3.17090638e-02f, -4.15343344e-02f, 2.93233525e-02f, 9.65022296e-02f, 7.69067183e-02f, 2.94303242e-02f, 2.04538167e-01f, 9.24175233e-03f,
  -1.15879655e-01f, 9.58845764e-02f, -3.68478931e-02f, -3.42033319e-02f, -8.41915980e-02f, -2.82726698e-02f, -1.09528527e-01f, 6.73604161e-02f, -5.16436994e-03f, 1.37985036e-01f,
  2.98964977e-02f, 3.88200693e-02f, 2.03896627e-01f, 5.82069978e-02f, -3.30438428e-02f, 1.24594778e-01f, -1.08700804e-01f, -4.05558832e-02f, -9.87784266e-02f, -1.24528326e-01f,
  -6.40339172e-03f, -8.30547437e-02f, 1.12414561e-01f, 6.21951036e-02f, -4.71861623e-02f, -8.72974843e-02f, -1.08202875e-01f, -9.83954221e-02f, -7.80550987e-02f, -1.39063865e-01f,
  -8.43968838e-02f, 1.45394936e-01f, -1.14769237e-02f, -7.89755732e-02f, -9.44911465e-02f, -7.41510466e-02f, 1.16616581e-02f, 6.21396191e-02f, 1.06178038e-01f, -4.38560918e-03f,
  1.42114297e-01f, 6.67939335e-02f, -6.27786741e-02f, 1.52939916e-01f, 5.11037670e-02f, -5.36564812e-02f, -1.07218185e-02f, -7.31119327e-03f, -3.56834643e-02f, 3.01650967e-02f,
  3.32340710e-02f, -1.13808572e-01f, 2.59367805e-02f, 7.55279213e-02f, -8.63367599e-03f, -2.34755687e-03f, -9.71020292e-03f, 7.96605945e-02f, 7.61085600e-02f, 3.90165895e-02f,
  9.32042487e-03f, 9.06664059e-02f, 7.92825148e-02f, 9.35874432e-02f, 4.13034447e-02f, 5.92987351e-02f, 7.21818358e-02f, 7.62708858e-02f, 6.12687804e-02f, 2.75051966e-02f,
  5.74837904e-03f, -7.33514428e-02f, -6.93313032e-02f, -3.16631757e-02f, -1.27813369e-01f, -7.30181187e-02f, -1.35762379e-01f, 1.91698939e-01f, 1.65130705e-01f, 2.01522391e-02f,
  4.15629558e-02f, 1.14947241e-02f, -2.42726766e-02f, 3.93601805e-02f, 3.18077579e-02f, -1.18955672e-01f, -2.59653199e-02f, 6.81034923e-02f, -1.09547913e-01f, -1.09578833e-01f,
  1.46732762e-01f, -1.01513684e-01f, 1.50746971e-01f, 1.35264814e-01f, 5.14874235e-02f, -2.78809723e-02f, 9.50110480e-02f, 1.82307497e-01f, 9.14272442e-02f, -1.59083113e-01f,
  -1.81810752e-01f, 7.34135062e-02f, -8.38100985e-02f, 8.95141214e-02f, 1.33731619e-01f, 2.65239440e-02f, -3.53978574e-02f, -1.79297570e-02f, -9.83232632e-02f, 1.12555129e-02f,
  6.85600340e-02f, 7.39436746e-02f, 5.58794178e-02f, -8.38994458e-02f, 2.82138288e-02f, -1.58305556e-01f, 5.92695102e-02f, 6.14407286e-02f, 1.92483902e-01f, 2.02324837e-01f,
  1.52134404e-01f, 2.27153562e-02f, 2.15473443e-01f, 7.43337795e-02f, -7.15970099e-02f, -6.94403276e-02f, -1.10392414e-01f, -1.36727706e-01f, -1.15738057e-01f, 2.60916859e-01f,
  -1.03629850e-01f, 4.60259393e-02f, 6.08733520e-02f, -9.91019905e-02f, -9.20745209e-02f, 2.06882425e-04f, 2.34964818e-01f, 3.23713236e-02f, 3.67892198e-02f, -8.78739506e-02f,
  -3.81645821e-02f, -1.31874233e-01f, 4.97536846e-02f, 2.09046662e-01f, 8.95757824e-02f, -6.52991831e-02f, -1.17094032e-01f, -1.63766984e-02f, -2.05408074e-02f, -1.06981412e-01f,
  9.90348607e-02f, 1.23429656e-01f, -7.39763230e-02f, -9.12285298e-02f, 1.18318327e-01f, 8.26394409e-02f, 1.68065682e-01f, -6.36464953e-02f, 1.84910119e-01f, -7.61681795e-03f,
  -3.62607447e-04f, -8.34679157e-02f, 1.21436916e-01f, -2.60080785e-01f, -5.61298840e-02f, -8.39355662e-02f, 2.21960530e-01f, -2.67167300e-01f, -7.73086865e-03f, 2.17770472e-01f,
  -4.03868705e-02f, 8.84075314e-02f, -4.10887264e-02f, 1.51297167e-01f, -4.73946780e-02f, -1.19590007e-01f, 8.72520432e-02f, -9.17880684e-02f, -7.44299218e-03f, -3.63711007e-02f,
  2.07040846e-01f, -2.90767271e-02f, 1.00285776e-01f, 1.72347531e-01f, 2.62395680e-01f, 2.78634410e-02f, 1.86125234e-01f, -1.31665170e-03f, 2.42738575e-02f, -8.24196264e-02f,
  -1.01754107e-01f, 6.41873702e-02f, -1.60230584e-02f, 1.91557378e-01f, 1.80952266e-01f, -2.93461652e-03f, 3.32352631e-02f, -5.97076602e-02f, 4.77897190e-02f, 1.30636781e-01f,
  1.57742679e-01f, -6.89842030e-02f, -1.57989696e-01f, 1.35237491e-02f, 9.21980292e-02f, 1.63412839e-01f, 2.15786085e-01f, 1.43317863e-01f, 5.44477254e-02f, -2.50381175e-02f,
  3.65688205e-02f, 1.81016862e-01f, 4.07415107e-02f, 4.52213474e-02f, 1.01363316e-01f, 2.31386960e-01f, 1.73618212e-01f, 5.50322980e-02f, 6.53301328e-02f, -4.52183336e-02f,
  -1.15596838e-01f, -1.17920481e-01f, 7.72823021e-02f, -4.07476164e-03f, 1.14353299e-01f, -2.18085930e-01f, 4.22378518e-02f, -1.63242966e-01f, -5.44501133e-02f, -1.22893475e-01f,
  -1.64073274e-01f, -1.03394389e-01f, -3.16737294e-02f, 2.81334948e-02f, 1.78306893e-01f, -5.81402779e-02f, 1.98293269e-01f, 1.59634173e-01f, -9.64200031e-03f, 8.09515640e-02f,
  -7.73872882e-02f, -3.36782783e-02f, 1.14163004e-01f, 2.10190415e-01f, -1.34936705e-01f, -5.65816313e-02f, 6.62763789e-02f, -1.15734093e-01f, 8.84950086e-02f, -6.05205223e-02f,
  -2.67861169e-02f, 8.21522251e-02f, 1.74156308e-01f, 4.65632230e-02f, 3.09207886e-02f, 1.01101242e-01f, -8.43706504e-02f, 9.77152437e-02f, 1.60655946e-01f, 1.10420607e-01f,
  1.46454930e-01f, 4.54599317e-03f, -3.08539495e-02f, 1.44712791e-01f, -1.32235199e-01f, 8.72750357e-02f, -5.13720512e-02f, 2.20145248e-02f, -4.47670557e-02f, 1.08976655e-01f,
  -6.56737760e-02f, 5.42514622e-02f, 1.04593724e-01f, -8.83291587e-02f, -1.69808920e-02f, 7.32197566e-03f, 6.88649761e-03f, -6.09878525e-02f, 6.60948902e-02f, 7.05389008e-02f,
  1.20729782e-01f, 3.24040726e-02f, -4.20662239e-02f, -5.75767122e-02f, -5.60341626e-02f, 1.61786117e-02f, -8.82907808e-02f, -4.94030938e-02f, 7.71387517e-02f, 9.59946662e-02f,
  2.25554220e-02f, 4.58710305e-02f, 1.59582328e-02f, -1.03638209e-01f, -2.25876160e-02f, 8.44584405e-02f, -4.35503647e-02f, -1.07920863e-01f, -9.42411348e-02f, -4.47443500e-02f,
  -5.14202975e-02f, -5.70816770e-02f, -5.12695052e-02f, -3.87709849e-02f, -6.20651022e-02f, -6.68685436e-02f, -6.76974580e-02f, -7.72042051e-02f, -7.98599236e-03f, -4.71446812e-02f,
  -9.39286128e-02f, -4.44182381e-02f, -1.03226669e-01f, -2.02225093e-02f, -1.17174193e-01f, 4.80073009e-04f, -8.82687420e-02f, -1.12646706e-01f, -9.94110182e-02f, -1.07232571e-01f,
  -6.97809597e-03f, 1.13658570e-01f, 3.56307765e-03f, 8.96061286e-02f, 1.01228729e-01f, -8.57549086e-02f, -5.66933192e-02f, 1.43095776e-02f, -7.18409419e-02f, -8.38838741e-02f,
  -1.21996909e-01f, -3.06235634e-05f, 1.17677830e-01f, -4.87674177e-02f, -9.55744311e-02f, -4.99594212e-03f, -1.08840592e-01f, 2.70067543e-01f, 1.54557317e-01f, 3.68840158e-01f,
  7.40440786e-02f, 2.98735768e-01f, 5.12076207e-02f, 4.12889242e-01f, 3.84438872e-01f, -4.92058620e-02f, 1.73690856e-01f, 3.29119772e-01f, 3.88820060e-02f, -9.77331623e-02f,
  -7.71684200e-02f, -2.41996408e-01f, 4.07730162e-01f, 1.21057220e-01f, -1.28636271e-01f, 2.34898403e-01f, 6.42607287e-02f, 6.08790219e-02f, -1.93189576e-01f, 8.33092853e-02f,
  -2.19590068e-01f, -8.35809261e-02f, 1.82166800e-01f, -1.18942827e-01f, 4.54739062e-03f, 1.00589074e-01f, -3.10512364e-01f, 1.95909932e-01f, -3.12323961e-02f, 2.88945228e-01f,
  -1.17869955e-02f, 3.10021102e-01f, -2.07156271e-01f, -9.72123370e-02f, -1.02970101e-01f, 6.74700588e-02f, -2.53879309e-01f, -4.71166223e-02f, -1.29852071e-01f, 2.66649038e-01f,
  6.56237006e-02f, 1.58545926e-01f, -1.21988785e-02f, 8.03757906e-02f, 7.54064992e-02f, -1.20084099e-01f, 2.67059773e-01f, 9.98165831e-02f, 2.08504528e-01f, 4.56036068e-02f,
  2.06543818e-01f, 7.30978372e-03f, -1.46413252e-01f, 1.81523845e-01f, 1.38831690e-01f, 2.45439373e-02f, 1.33936275e-02f, 1.23164676e-01f, 3.33952941e-02f, 1.71605885e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 40)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 40;
const float L1_fan_Bp_bar_data[] = {
  8.49194899e-02f, 4.43482064e-02f, 2.53432661e-01f, 2.14315839e-02f, -6.76846458e-03f, 1.15837930e-02f, 2.11294711e-01f, 8.91528577e-02f, 1.14069246e-01f, 7.92949423e-02f,
  -8.22856203e-02f, 1.06509648e-01f, 8.40737596e-02f, 8.11416954e-02f, 4.73097572e-03f, 6.05332814e-02f, 7.32424483e-02f, 1.48947090e-01f, 1.03217326e-01f, 5.09589724e-02f,
  1.41265560e-02f, 2.47582823e-01f, 3.46246455e-03f, 4.64303326e-03f, 1.19513988e-01f, 1.25751927e-01f, 1.85896218e-01f, 1.74919128e-01f, 1.58244593e-03f, 1.47386611e-01f,
  8.63113329e-02f, 1.33320734e-01f, -4.11209837e-02f, -7.48302694e-03f, -6.22466207e-03f, 1.31500721e-01f, -6.44793315e-03f, -9.85923503e-03f, 3.71534526e-02f, 5.57159446e-02f
};

// L2_linear_W (Shape: 12 x 64)
const int L2_linear_W_rows = 12;
const int L2_linear_W_cols = 64;
const float L2_linear_W_data[] = {
  8.25865939e-02f, -5.72855651e-01f, -1.44758314e-01f, -1.84323654e-01f, -1.04342557e-01f, 2.66351607e-02f, -3.29935730e-01f, -9.22489017e-02f, -5.74066415e-02f, -1.47690639e-01f,
  -2.13609546e-01f, -2.12784544e-01f, -1.00486517e-01f, 1.80244610e-01f, -6.17375374e-02f, -1.23378567e-01f, -8.86388123e-02f, -1.09188922e-01f, 3.95213738e-02f, -2.18763679e-01f,
  6.62891805e-01f, 2.23592892e-01f, -1.60426006e-01f, 1.17238536e-01f, -3.36363129e-02f, 5.60959987e-02f, -1.91171579e-02f, -4.72406782e-02f, 1.87850863e-01f, 1.98341519e-01f,
  4.33441281e-01f, -4.58433032e-02f, 2.66309120e-02f, 2.27393448e-01f, -1.01459436e-01f, -4.48438734e-01f, 4.35101628e-01f, -2.87335455e-01f, 3.31634313e-01f, 6.03464484e-01f,
  -2.65982211e-01f, -6.11928552e-02f, 8.67341831e-02f, 2.31579140e-01f, -5.42765222e-02f, 3.39211941e-01f, -9.19843838e-02f, 9.13318098e-02f, -1.92959741e-01f, 1.81811631e-01f,
  -3.07526588e-01f, 8.45481008e-02f, 1.18360400e-01f, -2.43061870e-01f, -9.26245078e-02f, 2.68947840e-01f, -1.34415343e-01f, -1.18753565e-02f, 2.68131793e-01f, 5.02861030e-02f,
  1.46361976e-03f, -3.06108713e-01f, -1.10802121e-01f, -3.78389388e-01f, -8.52288827e-02f, -1.50464013e-01f, 9.59635898e-02f, 1.80404648e-01f, -1.44680128e-01f, 1.31244764e-01f,
  -1.60939232e-01f, -2.00900048e-01f, 2.38803193e-01f, -2.34131277e-01f, -1.41328827e-01f, 6.75220937e-02f, 2.42915839e-01f, 8.19781497e-02f, 3.14502776e-01f, 3.48769248e-01f,
  -4.65441376e-01f, -1.95460126e-01f, 4.62684602e-01f, -2.21445411e-01f, 2.31699511e-01f, 2.30412215e-01f, -4.01195437e-02f, 9.82720554e-02f, -3.91553417e-02f, -4.23382789e-01f,
  7.78503895e-01f, 3.07339251e-01f, 1.96416974e-02f, -1.52925238e-01f, 4.20149565e-01f, 7.81720132e-02f, -6.59373775e-02f, 5.00911698e-02f, -5.45260422e-02f, -1.33920405e-02f,
  -4.22759093e-02f, -1.44261181e-01f, 2.20281910e-03f, 1.75522745e-01f, -3.17790240e-01f, -9.15450156e-02f, -1.27835244e-01f, -4.17307287e-01f, -1.06268585e-01f, 2.51298625e-05f,
  -2.99051166e-01f, -8.70930254e-02f, -2.12739080e-01f, 1.50383577e-01f, 6.84796795e-02f, 4.19122487e-01f, 2.29447052e-01f, 4.02247131e-01f, 4.36614454e-01f, 1.23689227e-01f,
  -8.09772462e-02f, 1.44560516e-01f, -1.26300409e-01f, 5.28954044e-02f, -1.85230657e-01f, -4.26790953e-01f, 1.60760304e-03f, -3.21649283e-01f, 2.91404426e-01f, 7.20141456e-02f,
  2.92419732e-01f, 2.16730550e-01f, 3.70727867e-01f, -3.77920526e-03f, 2.59415686e-01f, 2.38384277e-01f, 3.52709204e-01f, 3.10331937e-02f, 3.95160317e-02f, 2.38091916e-01f,
  -4.07139584e-02f, 4.38517958e-01f, -3.68500277e-02f, 1.61722451e-01f, 2.51129419e-01f, -4.19908345e-01f, 2.23622099e-01f, -1.19541250e-02f, 5.47136776e-02f, -1.15983054e-01f,
  9.80762467e-02f, 1.83204725e-01f, 3.74145433e-02f, -2.97610104e-01f, -2.92011276e-02f, -1.25738680e-01f, 1.63882107e-01f, -3.01379357e-02f, -6.86374214e-03f, -3.08150083e-01f,
  -7.20822811e-02f, 7.22128823e-02f, 5.72269373e-02f, 3.94593298e-01f, -3.81065160e-03f, -1.52442306e-01f, 2.71821357e-02f, -2.62120038e-01f, 2.66891904e-02f, 2.31267005e-01f,
  -1.80452749e-01f, 4.85907853e-01f, 8.62362534e-02f, 5.83565235e-01f, 3.66005033e-01f, 1.33739471e-01f, 2.49729410e-01f, -3.22648853e-01f, -3.97076197e-02f, -1.13138966e-01f,
  -2.22336873e-02f, -1.86027601e-01f, -2.19622836e-01f, 2.76173055e-01f, -3.41071576e-01f, -1.82982132e-01f, -4.74392660e-02f, -2.06061289e-01f, -1.56630799e-01f, -6.96852282e-02f,
  6.73172176e-02f, 1.51407674e-01f, 9.02331546e-02f, 2.86735833e-01f, -9.60514247e-02f, -2.68867873e-02f, -2.32637778e-01f, -1.12529494e-01f, 1.41368866e-01f, 6.01408780e-02f,
  -9.33138132e-02f, 1.97966732e-02f, 2.47715726e-01f, -2.37749070e-01f, 1.15002647e-01f, -3.72327641e-02f, 2.72767365e-01f, -1.72204018e-01f, -1.35866985e-01f, 2.84186453e-01f,
  -2.37440899e-01f, -6.45137951e-02f, -1.40438929e-01f, -5.22127450e-02f, 2.31702030e-02f, 2.28020415e-01f, 2.65057087e-01f, 9.83541980e-02f, -4.78359699e-01f, -1.90599859e-01f,
  -6.93336800e-02f, -7.23036230e-02f, 5.54619469e-02f, -6.82232436e-04f, 1.59538046e-01f, -2.06383571e-01f, 7.83899277e-02f, -1.74347349e-02f, -1.57119930e-01f, -4.23345000e-01f,
  -6.16453215e-02f, 2.53507588e-02f, -1.66056268e-02f, 3.90030831e-01f, 3.26180130e-01f, 3.19187999e-01f, -9.99080986e-02f, 4.11723763e-01f, -8.69271830e-02f, 1.28858350e-02f,
  -2.31198315e-02f, 4.97575641e-01f, 5.31739034e-02f, 2.86223859e-01f, -1.29156411e-01f, -2.23037362e-01f, -6.06285632e-01f, 1.31724402e-01f, 3.03303897e-01f, -2.22955927e-01f,
  1.14073016e-01f, -6.28017783e-02f, 3.96600068e-01f, 3.61775258e-03f, -1.02788553e-01f, -4.83985335e-01f, -2.43995547e-01f, 5.18111214e-02f, 9.61967334e-02f, -1.99721619e-01f,
  -1.75076276e-01f, 4.95005623e-02f, 8.26685056e-02f, -9.27446038e-02f, 3.17144454e-01f, 2.93007754e-02f, -8.21284726e-02f, 1.28853306e-01f, -3.61356288e-01f, 7.86257908e-02f,
  -7.57729709e-02f, -2.28631690e-01f, -4.57088679e-01f, -4.58294936e-02f, 2.71974325e-01f, 2.65588284e-01f, 6.95624622e-03f, -3.22125912e-01f, -3.36579412e-01f, 1.21610247e-01f,
  -2.83144079e-02f, 6.38494372e-01f, -3.95345628e-01f, -2.30468243e-01f, -5.25000319e-02f, 2.63202071e-01f, 3.90845761e-02f, -5.47642708e-02f, -9.54376832e-02f, 4.32266966e-02f,
  2.95825489e-02f, 1.94269121e-01f, 2.89586466e-02f, -1.84850976e-01f, -1.38069853e-01f, 4.65255976e-02f, -1.51185632e-01f, -2.14609638e-01f, -1.58757880e-01f, 5.33484817e-01f,
  -2.42511705e-01f, 1.23339698e-01f, -2.10112277e-02f, -1.08076081e-01f, -3.09488866e-02f, 1.97378367e-01f, -1.49140013e-02f, -2.73216039e-01f, -6.44161329e-02f, 1.22727811e-01f,
  3.25856179e-01f, -4.49569523e-01f, 6.14169538e-02f, -1.19169891e-01f, 1.06697738e-01f, -5.70406765e-02f, 4.01038259e-01f, 1.10837907e-01f, -7.86204562e-02f, -1.25580832e-01f,
  3.22902232e-01f, 7.44105056e-02f, 6.46390533e-03f, -4.08530459e-02f, 7.21281618e-02f, 1.63973331e-01f, 6.26264662e-02f, 6.54014349e-02f, 4.28251736e-03f, 1.46010444e-01f,
  1.81606237e-03f, -1.35913566e-01f, 2.39748463e-01f, 1.89977035e-01f, -9.64330360e-02f, -4.55277532e-01f, -1.17554739e-01f, 1.06292441e-01f, 4.82472517e-02f, 3.99431959e-02f,
  8.92287046e-02f, 1.71571001e-02f, -2.96422523e-02f, -3.01253140e-01f, -2.63587475e-01f, 2.90108234e-01f, 9.75274295e-02f, -1.71542138e-01f, -1.47430822e-01f, 2.16848448e-01f,
  2.22036973e-01f, -1.80030182e-01f, -4.60052900e-02f, 9.77023784e-03f, -7.41652697e-02f, -4.80916768e-01f, 2.86392480e-01f, 3.98982644e-01f, 5.17361565e-03f, 3.93642306e-01f,
  -1.48611173e-01f, 3.67014185e-02f, 1.85939856e-02f, -4.19656366e-01f, -5.63865080e-02f, -5.05955100e-01f, 2.98782378e-01f, -1.65474966e-01f, -1.68674424e-01f, 1.84546649e-01f,
  -1.56974405e-01f, 3.16172391e-01f, 7.42721604e-04f, -3.09566688e-03f, 5.61795592e-01f, -3.42656493e-01f, -7.00805187e-02f, -1.57867312e-01f, -1.18317656e-01f, -1.19622648e-02f,
  -2.15700362e-02f, 4.10630256e-02f, 6.08502794e-03f, 6.60712838e-01f, -1.40434921e-01f, 1.42250419e-01f, 9.70208049e-02f, 1.17743611e-02f, -5.10127664e-01f, -4.31755602e-01f,
  8.82423893e-02f, 1.16962127e-01f, 4.55758572e-02f, 4.72572260e-02f, 2.05549657e-01f, 5.11440486e-02f, -2.99929529e-01f, -3.62681568e-01f, -2.65576225e-02f, 3.44932020e-01f,
  4.35479730e-01f, -3.98703218e-01f, 9.15936381e-02f, 2.43672639e-01f, -2.95818895e-01f, -1.53627172e-01f, 5.55898622e-02f, -1.24245808e-01f, -3.54694784e-01f, -4.57723849e-02f,
  3.81280690e-01f, -2.52657473e-01f, 1.64051235e-01f, -1.00605331e-01f, -2.95528919e-01f, 5.33146739e-01f, -8.16761516e-03f, -9.61608812e-02f, 1.07813045e-01f, 3.07990104e-01f,
  -3.20950598e-01f, 2.00562418e-01f, 9.70284175e-03f, -2.42805049e-01f, -1.56291813e-01f, -2.29898855e-01f, -2.35704705e-01f, -4.20540124e-01f, -1.48110494e-01f, -4.74155486e-01f,
  -1.66033134e-01f, -4.26185802e-02f, 1.69478729e-01f, -3.93358707e-01f, 3.21732074e-01f, -3.28772604e-01f, 2.35523209e-01f, -2.62649536e-01f, 2.05583081e-01f, -3.04786950e-01f,
  -2.82217890e-01f, 3.59890223e-01f, 8.36834759e-02f, -1.99518681e-01f, -2.93377608e-01f, 2.09875733e-01f, 2.24882588e-02f, 4.83432889e-01f, -1.48758486e-01f, -8.85026455e-02f,
  2.49537453e-02f, 4.51667584e-04f, -1.17214113e-01f, 1.31274872e-02f, -1.32152274e-01f, -4.12442274e-02f, -2.28902802e-01f, -1.04582338e-02f, 8.25482383e-02f, -8.37145001e-02f,
  -2.01654837e-01f, -1.80415258e-01f, -6.78333491e-02f, 1.48845047e-01f, 1.81816399e-01f, 2.67589658e-01f, -2.81882852e-01f, -2.27935880e-01f, -1.80085853e-01f, -2.73049474e-01f,
  7.50774816e-02f, -9.23742726e-02f, 2.66404837e-01f, -1.60678521e-01f, 1.87381536e-01f, 2.77133435e-01f, -2.50487737e-02f, 8.58153179e-02f, -2.76653469e-01f, -3.21457654e-01f,
  7.19988719e-02f, -9.27080773e-03f, -2.22306196e-02f, 1.78820267e-01f, 1.60655081e-01f, -2.92151481e-01f, -8.29089209e-02f, -1.83095708e-01f, 3.46217334e-01f, -3.39538716e-02f,
  1.56192360e-02f, 1.82206169e-01f, 2.55346030e-01f, -1.17830865e-01f, -1.38954908e-01f, 1.62575960e-01f, 2.67605465e-02f, -7.03271106e-02f, -3.16667557e-01f, -2.68064290e-01f,
  -1.24857314e-01f, -2.52250046e-01f, -4.15220380e-01f, 4.40366119e-01f, 2.48349234e-01f, 1.33646905e-01f, -1.02535069e-01f, 5.47382414e-01f, 4.12498921e-01f, -1.58588633e-01f,
  -5.44586964e-02f, -4.87189323e-01f, -1.67830199e-01f, 1.00263767e-01f, -1.76509753e-01f, -1.98094726e-01f, 2.22474068e-01f, -9.02772099e-02f, -8.68773274e-03f, -7.13339001e-02f,
  1.47673320e-02f, -9.99023113e-03f, -3.23115468e-01f, -2.04702914e-01f, 2.93202877e-01f, -2.45331109e-01f, 2.68689424e-01f, 1.79752111e-01f, -3.09412163e-02f, 2.92087406e-01f,
  -3.25732142e-01f, -1.02060601e-01f, -1.51370410e-02f, -4.43650633e-02f, 3.31430078e-01f, -2.58031636e-01f, 8.17634761e-02f, -3.02353293e-01f, -1.85246184e-01f, 3.03835243e-01f,
  9.34534520e-02f, -7.48842955e-02f, -5.06474078e-02f, -3.26959677e-02f, 7.50822499e-02f, 8.34798813e-02f, 9.00443550e-03f, -3.01614851e-01f, -3.34478140e-01f, 2.54034281e-01f,
  -1.93302840e-01f, -1.25347465e-01f, 2.51567923e-02f, 1.70896053e-01f, 6.58607930e-02f, -3.01825464e-01f, 4.43868607e-01f, -2.81874686e-01f, 2.72469461e-01f, 4.19722050e-01f,
  1.92649126e-01f, 1.86291710e-01f, -1.03885792e-02f, 3.58988568e-02f, -1.25689000e-01f, 4.98966843e-01f, -4.27810788e-01f, 9.90150124e-02f, 2.87704647e-01f, -2.08893225e-01f,
  -4.75756377e-02f, 6.60194233e-02f, -1.68225214e-01f, -2.01769114e-01f, 8.04331228e-02f, 3.33366185e-01f, -1.91473618e-01f, 2.17637509e-01f, -3.64810437e-01f, 1.03320450e-01f,
  3.93075854e-01f, 2.92851597e-01f, 1.65904313e-01f, -3.86505462e-02f, 4.61217985e-02f, 1.27174437e-01f, 4.23373021e-02f, 2.39107892e-01f, -3.03305566e-01f, -5.79038449e-02f,
  -4.33546007e-01f, -3.38252559e-02f, 5.34685135e-01f, -1.92222878e-01f, 1.30370721e-01f, -6.44249748e-03f, -1.88002288e-01f, -7.41895800e-03f, -3.91792983e-01f, 1.33187369e-01f,
  -1.90363303e-02f, 6.98773146e-01f, -5.39561315e-03f, 2.79404670e-02f, 1.70042701e-02f, 1.51579872e-01f, -1.40215158e-02f, 1.47568166e-01f, 7.61027038e-02f, -1.32585049e-01f,
  -7.96038881e-02f, 2.44146645e-01f, 4.88202274e-01f, 9.28090066e-02f, -1.03839353e-01f, -2.88476676e-01f, 1.10535987e-01f, -1.86469436e-01f, -1.59753133e-02f, 1.63880438e-01f,
  2.27441519e-01f, -2.14993462e-01f, -3.94846916e-01f, -1.69015661e-01f, -3.90927672e-01f, -4.12534326e-01f, 1.39855715e-02f, -2.39176959e-01f, 7.60657713e-02f, -3.08020502e-01f,
  2.11670138e-02f, 3.42111066e-02f, -2.27313861e-01f, -7.92434625e-03f, -7.59402961e-02f, -1.51736498e-01f, -1.05963089e-02f, 9.69305038e-02f, 7.44059011e-02f, 4.59731430e-01f,
  -1.45029381e-01f, -8.16124305e-02f, 6.94283172e-02f, 1.48502395e-01f, -4.19594586e-01f, -1.21977612e-01f, 5.22122160e-02f, -1.57305658e-01f, 5.11737242e-02f, -7.48421550e-02f,
  1.92475304e-01f, 9.19343010e-02f, 4.30558324e-01f, 1.98374670e-02f, 1.17751524e-01f, 3.37801099e-01f, -3.01487118e-01f, 2.89528251e-01f, 1.64356351e-01f, 3.62726629e-01f,
  5.25841154e-02f, -7.13456795e-02f, 7.33264023e-03f, 2.75194734e-01f, -9.60292742e-02f, -1.88599661e-01f, -5.16479135e-01f, -6.41713738e-02f, 6.51042089e-02f, -1.79312125e-01f,
  -2.05007985e-01f, 3.43087725e-02f, -7.60610178e-02f, 2.35017285e-01f, -1.24477707e-02f, -2.05479354e-01f, -1.50888205e-01f, -3.68595906e-02f, 3.12999599e-02f, 7.43662342e-02f,
  2.29895607e-01f, -1.61998808e-01f, -8.49903226e-02f, -2.69342035e-01f, -4.63265814e-02f, 6.26759648e-01f, 3.50080073e-01f, -5.07075861e-02f, -1.59526899e-01f, -2.97881663e-01f,
  1.29323050e-01f, -1.49473563e-01f, -6.51871935e-02f, 6.64585769e-01f, 1.61076561e-01f, -5.22912759e-03f, 3.63128871e-01f, 2.12054159e-02f, -7.53565133e-02f, 7.96391256e-03f,
  -5.52816875e-02f, 3.41484308e-01f, 4.45808731e-02f, -1.69243366e-01f, 2.90443093e-01f, -1.73742354e-01f, 2.17747509e-01f, 2.21542358e-01f, 1.65562823e-01f, 9.37967002e-02f,
  -1.44783273e-01f, 1.95169702e-01f, -5.80001354e-01f, 2.41457224e-01f, 5.94032817e-02f, -1.00682378e-02f, -1.75732955e-01f, -3.87068123e-01f, 2.41210267e-01f, -8.98370743e-02f,
  4.16477472e-01f, -4.12280820e-02f, -4.39092964e-01f, -3.58718261e-02f, -1.96503863e-01f, 2.83681989e-01f, 4.11719352e-01f, -3.01016331e-01f, -9.21226367e-02f, -2.21536532e-01f,
  1.58298984e-01f, 1.63819343e-01f, 1.39489219e-01f, -9.12159495e-03f, 1.53937906e-01f, 1.50759012e-01f, -1.87820289e-02f, -2.02193812e-01f, -8.05519056e-03f, 1.63253114e-01f,
  -3.21353495e-01f, 1.88665137e-01f, -8.10896158e-02f, -1.38122603e-01f, -2.23591581e-01f, 8.20302963e-02f, 4.57291842e-01f, -1.65561289e-01f, 1.15021594e-01f, -3.19194138e-01f,
  -2.82963574e-01f, -1.83114037e-01f, 5.78787506e-01f, 4.05549556e-01f, 3.11687946e-01f, 2.26862598e-02f, -6.45302236e-02f, -2.72443652e-01f, -5.48636587e-03f, -3.37377757e-01f,
  -1.20827943e-01f, 2.25316510e-01f, -7.72430897e-02f, 1.11697778e-01f, -2.22928435e-01f, -8.32585990e-02f, -9.57285427e-03f, -2.26602063e-01f
};

// L2_linear_B (Shape: 1 x 12)
const int L2_linear_B_rows = 1;
const int L2_linear_B_cols = 12;
const float L2_linear_B_data[] = {
  -1.07454307e-01f, 9.80229899e-02f, 8.39262679e-02f, 2.44986843e-02f, -9.12671462e-02f, 5.89567656e-03f, 1.19463667e-01f, -2.80350801e-02f, 4.08212841e-02f, 1.02388427e-01f,
  -1.28539816e-01f, 2.03464746e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 12, 40
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        64, 12, 40
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_linear
    linear_forward_pgm(
        buffer1, x_out,
        L2_linear_W_data, L2_linear_B_data,
        64, 12
    );
    }
    