/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 64 (x3)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 64;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    static inline float fan_activation(float x) { return x; }

    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 6 x 120)
const int L0_fan_Wp_rows = 6;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -1.45382941e-01f, -2.18495168e-03f, -2.03214325e-02f, 4.15502340e-02f, 1.24481924e-01f, -5.61462492e-02f, -1.73448458e-01f, -1.12985842e-01f, 5.31559661e-02f, 1.32762864e-02f,
  1.22460127e-01f, 8.63413960e-02f, 1.12866811e-01f, -1.87874511e-02f, -1.23863973e-01f, -1.89330637e-01f, -1.11470379e-01f, -3.05907391e-02f, -7.12746307e-02f, -7.85313919e-02f,
  1.82025358e-02f, -8.03050995e-02f, -1.15101494e-01f, -1.24979414e-01f, 1.22680746e-01f, 6.86714873e-02f, 3.69990282e-02f, 1.60378918e-01f, -1.76109821e-02f, 1.68963764e-02f,
  -1.03552833e-01f, 1.40084729e-01f, -4.54774052e-02f, 1.50667224e-02f, 7.76261510e-03f, -9.85668004e-02f, -1.00116663e-01f, -6.97077392e-03f, -6.86527882e-03f, 1.63660720e-02f,
  9.72131714e-02f, 4.74580415e-02f, 3.83523516e-02f, 1.70011874e-02f, -8.30156263e-04f, -1.82174183e-02f, 1.98820643e-02f, -3.05277854e-02f, 1.31457271e-02f, 8.28598440e-02f,
  8.66529122e-02f, 1.15602687e-01f, 5.39042652e-02f, 1.24910541e-01f, 3.81210297e-02f, 9.30900127e-02f, 4.87475768e-02f, 8.17810297e-02f, 4.61762063e-02f, -2.30968371e-02f,
  -4.40441221e-02f, 1.89525336e-02f, 6.01217151e-02f, 1.93281658e-02f, -3.28399725e-02f, 5.77158341e-03f, -1.86576080e-02f, -2.77238227e-02f, 1.43516937e-03f, -9.09198895e-02f,
  -2.69839633e-02f, 1.28584867e-03f, 2.19750125e-02f, -3.57782803e-02f, -5.36178611e-02f, 2.49241702e-02f, -3.00557399e-03f, -6.82257349e-03f, 5.59290908e-02f, 3.29049341e-02f,
  1.81215256e-02f, 5.47131486e-02f, -7.40219429e-02f, 1.79822266e-03f, -1.11063970e-02f, 8.73367488e-02f, 4.14922610e-02f, -5.90961948e-02f, 3.13519239e-02f, 7.59438844e-03f,
  -2.01709598e-01f, 1.26137838e-01f, -5.05879410e-02f, -7.82318935e-02f, -1.60785150e-02f, 5.74916974e-02f, 2.81907823e-02f, 1.54191777e-02f, -9.79186408e-03f, -4.67951149e-02f,
  8.10678005e-02f, 4.15269583e-02f, 7.92220533e-02f, 2.35563572e-02f, 1.66896358e-02f, -2.62726657e-02f, 9.46132815e-04f, -1.04038149e-01f, -5.73230870e-02f, 6.25578165e-02f,
  -2.80886646e-02f, -5.62190078e-02f, -5.75875863e-02f, -7.92220086e-02f, 8.43279362e-02f, -1.05156250e-01f, -1.05259672e-01f, -2.73153204e-02f, -6.38629645e-02f, -2.81334221e-01f,
  1.10696651e-01f, -5.29767461e-02f, -3.35603394e-02f, -4.22990955e-02f, 1.04561850e-01f, 1.98094144e-01f, 2.20033139e-01f, 1.22736752e-01f, -7.93023184e-02f, 1.77175477e-02f,
  -8.39986131e-02f, -1.12831965e-01f, -3.19114812e-02f, -8.34297165e-02f, 8.34099576e-02f, -2.02031545e-02f, -2.10766837e-01f, -9.97189060e-02f, 2.01317538e-02f, 1.97789762e-02f,
  -6.21732250e-02f, -5.44575341e-02f, -5.45117967e-02f, -3.23336907e-02f, -1.60175741e-01f, 7.83381797e-03f, -3.43095697e-02f, -8.79805461e-02f, -1.49441704e-01f, -2.68338591e-01f,
  -1.08538397e-01f, 3.73197049e-02f, 7.06386566e-02f, -7.52467066e-02f, 5.38885519e-02f, 4.14998904e-02f, 6.83949366e-02f, -7.42016658e-02f, -6.71035647e-02f, -5.16042411e-02f,
  3.65490955e-03f, -3.19905542e-02f, -2.80320924e-02f, -4.66079786e-02f, 2.39539035e-02f, 3.61575969e-02f, -2.13634167e-02f, -9.18153971e-02f, -3.32858898e-02f, -6.75625652e-02f,
  -1.18108049e-01f, 1.77140217e-02f, 3.43153365e-02f, 8.40200260e-02f, 6.74076239e-03f, 2.31472794e-02f, -2.81051490e-02f, -7.64817744e-02f, 2.53084209e-02f, -6.47515357e-02f,
  -5.29376492e-02f, -5.29763848e-03f, -1.17099145e-02f, -8.30683410e-02f, -5.79258651e-02f, -1.67993195e-02f, -2.77099647e-02f, -2.68075895e-02f, 1.29804695e-02f, -3.76596898e-02f,
  -1.10018691e-02f, -7.91043639e-02f, 2.47193705e-02f, -1.27069743e-05f, -6.83691949e-02f, -1.13209244e-02f, -4.65321308e-03f, 5.71995927e-03f, -7.12629333e-02f, 4.48358431e-02f,
  -7.34538883e-02f, -6.94266632e-02f, -9.52297375e-02f, 3.19825746e-02f, -5.35837300e-02f, -5.10517359e-02f, -4.70663644e-02f, 9.24783014e-03f, 2.72689201e-02f, -6.07605614e-02f,
  1.72676951e-01f, 8.38988572e-02f, -3.49814259e-02f, 1.98499430e-02f, 8.42152610e-02f, 7.39350021e-02f, 3.66273075e-02f, 1.03777587e-01f, 7.32489377e-02f, 1.00785624e-02f,
  9.35407579e-02f, 8.46948698e-02f, 3.22818232e-04f, -4.00252156e-02f, 7.46356100e-02f, -4.13137116e-02f, -8.70922059e-02f, -1.57383252e-02f, -7.30922970e-04f, 5.20875156e-02f,
  -6.72504604e-02f, 1.23660959e-01f, 6.63587451e-02f, 1.09528348e-01f, -2.36322079e-02f, 7.67998025e-02f, 1.02002271e-01f, 7.56524205e-02f, 1.92942157e-01f, 1.00537904e-01f,
  -3.53242517e-01f, 1.71650071e-02f, -5.23438565e-02f, -1.08452789e-01f, -8.45572539e-03f, 1.68678880e-01f, 2.05888614e-01f, 7.30374902e-02f, -8.90583992e-02f, -3.85947749e-02f,
  6.42103106e-02f, 1.57109946e-02f, -3.96055840e-02f, -5.05626500e-02f, 1.33016154e-01f, 7.26349372e-03f, 8.45252536e-03f, -4.27662507e-02f, -3.57740708e-02f, 1.14988029e-01f,
  -2.47387141e-02f, -1.05981514e-01f, -1.50729626e-01f, -6.87220171e-02f, -1.19404368e-01f, -7.55460635e-02f, -1.13865346e-01f, -1.37319311e-01f, 1.12174796e-02f, -2.89458692e-01f,
  -1.33628190e-01f, -1.23186424e-01f, -7.73568079e-02f, -8.25719312e-02f, -7.05813691e-02f, -1.09388329e-01f, -5.04061095e-02f, -1.38540223e-01f, -7.78168365e-02f, -1.38254538e-01f,
  -1.38751417e-01f, -1.32474005e-01f, -1.15305200e-01f, -5.23645878e-02f, -1.63935259e-01f, -1.65420651e-01f, -1.01893045e-01f, -2.02589974e-01f, -9.26648825e-02f, -9.81753692e-02f,
  -2.08704755e-01f, -2.08472311e-01f, -1.40699133e-01f, -1.29210621e-01f, -1.80989996e-01f, -1.83004737e-01f, -3.63564752e-02f, -6.33689314e-02f, -3.33377756e-02f, -1.62746742e-01f,
  -8.16023424e-02f, -2.17394233e-02f, 2.14963928e-02f, 7.10216239e-02f, 4.25382666e-02f, 2.81293113e-02f, -1.29303429e-02f, 6.91636950e-02f, -4.58401255e-03f, -4.14506420e-02f,
  -2.84461584e-02f, -3.68331410e-02f, -2.00477168e-02f, 4.40668128e-02f, -2.76421104e-02f, 8.79614335e-03f, 2.60854736e-02f, 3.39808874e-02f, 8.89685228e-02f, 9.26303677e-03f,
  1.44991484e-02f, -2.47801729e-02f, 2.88542397e-02f, -2.28636879e-02f, -1.80485323e-02f, -1.66168008e-02f, 3.17791626e-02f, -1.05025126e-02f, 9.72588211e-02f, 8.92676413e-02f,
  -6.46726713e-02f, 1.43531010e-01f, -3.95311676e-02f, -2.50709523e-03f, -1.51771056e-02f, -8.69330391e-02f, -1.02883792e-02f, -7.47676939e-03f, -1.36282176e-01f, -2.09684633e-02f,
  -2.23286562e-02f, 5.14471009e-02f, -1.21115506e-01f, -2.82265879e-02f, -3.98438051e-02f, -3.53500992e-02f, 1.05875870e-02f, -1.17107838e-01f, -6.12270162e-02f, -5.51331341e-02f,
  -1.21249547e-02f, -8.12856853e-02f, -5.84065579e-02f, -3.30129229e-02f, -1.30597726e-01f, 2.03520581e-02f, -4.22898494e-02f, -8.37680995e-02f, 1.90554280e-02f, 9.78108197e-02f,
  7.38825798e-02f, 1.15478463e-01f, 1.01635367e-01f, 1.92935646e-01f, 5.77024892e-02f, -1.68437302e-01f, -1.67538933e-02f, -1.95098240e-02f, 4.21226807e-02f, 3.34577821e-02f,
  -3.26964743e-02f, 6.34340420e-02f, 7.03335702e-02f, 8.11178386e-02f, -6.59275129e-02f, 1.02552094e-01f, 1.12667538e-01f, 9.56193283e-02f, -2.37986119e-03f, -1.34806842e-01f,
  -2.46195011e-02f, 7.81034455e-02f, 6.36199787e-02f, 1.30667929e-02f, 1.38788253e-01f, 1.35240391e-01f, 9.66962725e-02f, 9.95713472e-02f, -1.64167956e-02f, 2.78778344e-01f,
  1.17986359e-01f, -6.57828664e-03f, -5.38868904e-02f, 7.10939318e-02f, 7.98464566e-02f, -6.21230640e-02f, 7.99843762e-03f, 8.94906744e-02f, 4.10978943e-02f, 3.85498852e-02f,
  3.77047732e-02f, 6.62462413e-02f, 2.73720231e-02f, 1.42727019e-02f, 4.77165653e-04f, -7.07658380e-02f, 7.46513978e-02f, 7.40964264e-02f, -2.39106026e-02f, -3.98563705e-02f,
  -6.31838739e-02f, 3.13776061e-02f, -4.68358658e-02f, 3.41408290e-02f, -1.10817023e-01f, 2.91436817e-03f, -3.35788429e-02f, -1.06113836e-01f, -1.83662195e-02f, 1.34948477e-01f,
  6.25736592e-03f, -1.12536766e-01f, -2.16503697e-03f, -1.46351784e-01f, -1.15319051e-01f, -5.01244776e-02f, 5.15508428e-02f, -5.57109565e-02f, -5.88707142e-02f, 4.04228307e-02f,
  -3.10201719e-02f, -6.71680644e-02f, -6.16772920e-02f, 3.94125246e-02f, -1.89882591e-02f, -3.45296375e-02f, -1.38533145e-01f, -2.69381162e-02f, -1.09478861e-01f, -1.88143458e-02f,
  -5.49646541e-02f, -2.45523714e-02f, -3.10412161e-02f, 2.04771478e-02f, -1.05794840e-01f, -2.66456846e-02f, -2.56924741e-02f, -1.40229419e-01f, -1.19061477e-01f, -1.36349678e-01f,
  3.65993530e-02f, -1.06401369e-01f, 1.40651822e-01f, 4.23131734e-02f, -3.10804565e-02f, 5.21471836e-02f, 9.48961303e-02f, -3.73983793e-02f, 1.59968752e-02f, 1.62066780e-02f,
  -7.30414391e-02f, 3.05714067e-02f, -9.75957420e-03f, 1.34330671e-02f, 2.84163449e-02f, 6.73549175e-02f, 3.12638981e-03f, 6.42945021e-02f, -5.88954575e-02f, -4.95522842e-02f,
  8.66838358e-03f, -1.03937481e-02f, 3.10582854e-02f, 6.78618178e-02f, -6.65565999e-03f, 9.25631449e-02f, 1.92421712e-02f, 3.71651980e-03f, -5.16376086e-02f, -8.05104375e-02f,
  -9.47988927e-02f, -1.39960989e-01f, -1.48558199e-01f, -1.85587909e-03f, -1.62945226e-01f, -2.67095983e-01f, -3.60647619e-01f, -1.72345802e-01f, 3.50607932e-02f, -8.02196562e-02f,
  1.17981128e-01f, 1.00653827e-01f, 1.42714590e-01f, 1.92045737e-02f, -1.16118148e-01f, -2.33882099e-01f, -2.39879638e-01f, 5.97700998e-02f, 1.60633177e-02f, -5.31504937e-02f,
  -8.39775428e-02f, -1.93554182e-02f, 4.13704291e-02f, -5.95054869e-03f, -1.26869649e-01f, 1.77302528e-02f, -3.70241776e-02f, 1.29672773e-02f, -5.54339588e-02f, -7.04251081e-02f,
  -4.91320826e-02f, -9.36274007e-02f, -7.94217736e-02f, 2.07651891e-02f, 1.40749002e-02f, -9.97471437e-03f, -4.82413135e-02f, -9.73385051e-02f, -2.20673159e-02f, -3.66725996e-02f,
  -3.66440341e-02f, -1.37593746e-02f, -7.08355755e-02f, 4.51676771e-02f, -3.71469408e-02f, -4.67280895e-02f, -7.60402009e-02f, -3.38077843e-02f, -7.79460743e-02f, -6.01487830e-02f,
  -8.25787410e-02f, -1.12180158e-01f, -1.17398657e-01f, -1.24803714e-01f, -9.13764387e-02f, 4.74223047e-02f, 1.55531503e-02f, 3.44932750e-02f, -6.54459670e-02f, -8.78045615e-03f,
  2.51136832e-02f, 7.61115998e-02f, 1.99514534e-02f, -4.42511663e-02f, 5.88304326e-02f, 5.08094169e-02f, 8.27901904e-03f, 4.43379022e-02f, 8.40077060e-04f, -4.18345816e-02f,
  1.05696559e-01f, 4.89941612e-03f, 8.00798014e-02f, -1.95977241e-02f, 2.80781034e-02f, 1.20611424e-02f, 1.22411391e-02f, -5.33152372e-03f, 3.53281498e-02f, 2.94034183e-02f,
  -3.66278182e-05f, -2.30197832e-02f, 4.11344133e-02f, 8.49342421e-02f, -2.96914969e-02f, 1.15741223e-01f, 6.15445003e-02f, 1.37091592e-01f, 2.54055299e-03f, 1.51066557e-02f,
  3.58468592e-02f, 1.73900090e-02f, -8.59701335e-02f, -1.35712892e-01f, -6.51483461e-02f, -5.94957955e-02f, 4.49699379e-04f, -3.99633497e-02f, -5.50050698e-02f, -6.29331544e-02f,
  -8.01473185e-02f, -6.07534014e-02f, -8.71383995e-02f, -7.47251511e-02f, -3.79282087e-02f, -5.16949669e-02f, 2.10401998e-03f, -6.92280829e-02f, -1.12983689e-01f, -8.60668793e-02f,
  -1.56798899e-01f, -1.42100900e-01f, -7.47821108e-02f, -3.40612680e-02f, -1.64661095e-01f, -5.71745336e-02f, -1.21572316e-01f, -1.56882137e-01f, -1.34791493e-01f, -3.20625119e-02f,
  -4.81344126e-02f, -4.16376702e-02f, 2.43662506e-01f, -2.32398938e-02f, 1.92884400e-01f, 1.50720060e-01f, 1.46331966e-01f, -9.41686258e-02f, -4.64633815e-02f, -3.32345814e-02f,
  -7.22674727e-02f, -8.52467194e-02f, 1.30795659e-02f, 3.83089259e-02f, 2.31442582e-02f, 1.28708094e-01f, 1.54176086e-01f, 1.58739284e-01f, 1.94016322e-01f, 6.66110590e-02f,
  2.91242674e-02f, -1.04541920e-01f, -1.76458254e-01f, -1.65436387e-01f, -2.25713760e-01f, 1.75209809e-02f, -1.36354700e-01f, -1.35246674e-02f, -6.21359795e-02f, 5.74797429e-02f,
  -4.06961003e-03f, -1.10464105e-02f, 1.19782440e-01f, -1.18565429e-02f, 1.36100585e-02f, -5.91999255e-02f, -3.53495739e-02f, -8.22870657e-02f, -3.49955224e-02f, -9.55285132e-02f,
  -6.28141463e-02f, -2.33301590e-03f, -3.11771291e-03f, -5.54162860e-02f, -1.13965543e-02f, 3.53603363e-02f, -9.87940207e-02f, -7.53529742e-02f, -5.36247380e-02f, -6.57770112e-02f,
  7.49059469e-02f, 8.23416039e-02f, -2.60136388e-02f, -6.84789047e-02f, 2.37322003e-02f, 1.14957117e-01f, 5.51523156e-02f, -6.29114136e-02f, 6.22967184e-02f, -5.41514494e-02f,
  -7.64315724e-02f, 3.39974873e-02f, 9.41762030e-02f, -2.27903891e-02f, 5.21715023e-02f, 6.66071773e-02f, 8.11703503e-02f, 3.33996601e-02f, 4.89482544e-02f, -5.18078543e-02f,
  4.91393358e-02f, -5.41808875e-03f, -2.07981188e-02f, 3.00520789e-02f, 1.67963821e-02f, 6.68125600e-02f, 3.49217169e-02f, -1.45104844e-02f, 2.73741353e-02f, 2.31105532e-03f,
  2.18329690e-02f, 7.93149024e-02f, 4.88346070e-02f, -1.26177194e-02f, 8.60263258e-02f, 7.42889941e-03f, 1.33906184e-02f, 7.95197859e-02f, 3.10232043e-02f, 2.59048752e-02f,
  -3.04161042e-01f, 1.40033379e-01f, -6.64477274e-02f, -2.73779128e-02f, -4.69074547e-02f, -6.28897920e-02f, -3.56662609e-02f, -1.10686775e-02f, -2.31353380e-02f, 1.73533335e-02f,
  6.77857921e-02f, -4.09145020e-02f, -2.32423563e-02f, 3.95490564e-02f, -6.78281160e-03f, 8.98400228e-03f, 1.52256982e-02f, 2.41054352e-02f, 5.34544699e-04f, -3.19055915e-02f,
  4.78460528e-02f, 1.00768590e-02f, 3.55978385e-02f, 1.29807582e-02f, 5.52023128e-02f, 2.10011490e-02f, -5.39108552e-02f, 8.81162435e-02f, 4.69089299e-02f, -1.58290714e-01f
};

// L0_fan_Wp_bar (Shape: 52 x 120)
const int L0_fan_Wp_bar_rows = 52;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -5.00495493e-01f, 4.52385172e-02f, -1.63857117e-01f, -2.41952181e-01f, 8.66503641e-02f, 2.98451453e-01f, 4.07579184e-01f, 1.29094288e-01f, -8.93194377e-02f, -4.39612344e-02f,
  6.29046038e-02f, 2.37520859e-02f, 2.94574890e-02f, 1.05211250e-01f, 6.88146874e-02f, 1.80299744e-01f, 1.97239041e-01f, -2.26062560e-03f, 4.79665324e-02f, 1.00809820e-01f,
  1.11235410e-01f, -1.88063666e-01f, -2.29329199e-01f, -1.19294085e-01f, -4.34836447e-02f, -4.69856337e-02f, 7.92028382e-03f, -6.35167882e-02f, 1.00968316e-01f, -3.84427980e-02f,
  -3.73230547e-01f, -3.24245930e-01f, 1.02568366e-01f, -1.14380538e-01f, -9.11307186e-02f, -1.61981374e-01f, -2.94837989e-02f, -1.92923173e-01f, -4.82263975e-02f, -5.68099394e-02f,
  -7.53976703e-02f, -3.07275336e-02f, -3.13297170e-03f, 7.04196766e-02f, -1.71898648e-01f, -3.98239605e-02f, -8.03577900e-02f, -1.02830619e-01f, -1.63819224e-01f, 3.90007272e-02f,
  2.70082474e-01f, 8.36910866e-03f, -2.37503275e-01f, 1.46498367e-01f, 1.13630118e-02f, -1.16564460e-01f, -9.81481075e-02f, -5.37022986e-02f, -1.38725325e-01f, -2.50534087e-01f,
  3.22531164e-02f, -4.52612229e-02f, 2.14978494e-02f, -1.02699324e-01f, -1.53447967e-02f, 5.19894995e-02f, -6.56386986e-02f, 9.95423347e-02f, 7.65520856e-02f, 3.73129286e-02f,
  -8.87621045e-02f, -2.70044953e-02f, 4.87772934e-02f, -6.14065379e-02f, -2.62247734e-02f, -3.24658602e-02f, 8.41301233e-02f, -5.05631603e-02f, -5.48975803e-02f, 1.11756865e-02f,
  -6.48899227e-02f, -7.12794587e-02f, -4.09495551e-03f, 9.94115397e-02f, 2.91133504e-02f, -6.79837018e-02f, -9.03454348e-02f, -4.77346852e-02f, -3.35282274e-02f, -6.15597181e-02f,
  -3.53090793e-01f, 1.72498807e-01f, -2.36230180e-01f, -1.48999095e-02f, -8.54113474e-02f, 4.53170910e-02f, -2.06017662e-02f, 1.12604406e-02f, 7.81316869e-03f, -7.89831951e-02f,
  7.55297393e-02f, -4.92607616e-02f, -4.34703454e-02f, 3.07852011e-02f, 6.49757981e-02f, -5.83553920e-03f, 1.48789078e-01f, -5.06293438e-02f, 2.81605795e-02f, 5.14652580e-02f,
  1.17712811e-01f, 4.20777015e-02f, -1.51240885e-01f, 7.76166171e-02f, -6.76027965e-03f, -1.45934477e-01f, -1.28904238e-01f, -1.20688841e-01f, -1.69489011e-01f, -1.98015332e-01f,
  -5.44577897e-01f, -1.68380618e-01f, -1.68693662e-01f, -4.49074209e-01f, -2.69972265e-01f, -7.12077320e-02f, -2.07447320e-01f, -8.27352777e-02f, -1.06983699e-01f, -2.54074574e-01f,
  -1.76797792e-01f, -5.05981557e-02f, -1.22791514e-01f, 2.49482021e-02f, 5.81799671e-02f, -3.61642212e-01f, -2.74331003e-01f, -3.50986458e-02f, 1.27251104e-01f, 9.70594287e-02f,
  4.66643944e-02f, -5.29245734e-02f, 1.58695448e-02f, 1.46096662e-01f, -1.90846026e-01f, 2.50491891e-02f, -7.46293515e-02f, -6.06908947e-02f, 5.14957011e-02f, -1.49229854e-01f,
  -1.55499339e-01f, -1.61368966e-01f, 1.46386534e-01f, 3.94310839e-02f, -1.61887527e-01f, 2.53941445e-03f, -1.07951686e-01f, -3.52735296e-02f, -8.51365328e-02f, -5.70617355e-02f,
  -1.45238593e-01f, 4.95715626e-02f, -2.31391303e-02f, 4.36762050e-02f, -1.15671456e-01f, -2.53873039e-02f, 1.32645275e-02f, -1.41192898e-02f, -3.29816528e-02f, -2.83971406e-03f,
  2.06658617e-02f, -1.09309619e-02f, -9.35694724e-02f, 1.91039056e-01f, 7.86064267e-02f, -1.33971102e-03f, 1.59542397e-01f, 2.27774918e-01f, 1.87156856e-01f, -4.97358590e-02f,
  6.91397637e-02f, -3.80707532e-02f, 3.02141290e-02f, 4.29095626e-02f, -8.96836072e-02f, 9.92133692e-02f, -8.11548755e-02f, -8.64940956e-02f, -5.15102223e-02f, 4.48951274e-02f,
  -5.35291173e-02f, -4.75438759e-02f, -7.02419566e-05f, -4.67526503e-02f, -4.43209223e-02f, 8.85764137e-02f, -6.34898469e-02f, -7.49244168e-02f, 1.05250143e-01f, -3.49817611e-02f,
  -5.66066653e-02f, 1.23378448e-01f, 4.74401657e-03f, 2.41449312e-03f, 3.59007120e-02f, -9.91224945e-02f, -8.35139379e-02f, 1.00768901e-01f, 4.52592671e-02f, -7.21015781e-02f,
  -2.01225847e-01f, 1.39761180e-01f, -2.45267138e-01f, -3.48940827e-02f, -2.21736990e-02f, 1.82991281e-01f, -1.32973745e-01f, -6.76054507e-02f, -5.59406914e-02f, -8.54462236e-02f,
  1.42816544e-01f, -9.96919423e-02f, -1.34248212e-01f, 1.17530562e-01f, -3.25091593e-02f, 1.61452573e-02f, -1.05180413e-01f, -1.06589429e-01f, 3.11448220e-02f, 4.70964536e-02f,
  8.18071291e-02f, -1.71506293e-02f, -7.73664117e-02f, -2.18854891e-03f, -2.68818196e-02f, 6.72917664e-02f, 1.07614927e-01f, 9.34065580e-02f, 8.79807100e-02f, -1.77774802e-01f,
  -1.41518265e-01f, 3.69200557e-01f, 1.64815962e-01f, -8.08770657e-02f, 5.67854121e-02f, 1.22791134e-01f, 2.77120233e-01f, 2.17466846e-01f, 6.73160329e-02f, 1.36130080e-01f,
  1.17352381e-01f, -1.94184884e-01f, -1.64928705e-01f, -9.87560004e-02f, 3.75871323e-02f, 1.40322804e-01f, 2.53195893e-02f, -1.30325675e-01f, -5.92560694e-02f, -5.15400507e-02f,
  -9.63747427e-02f, -6.77303821e-02f, -7.64904693e-02f, -1.37774616e-01f, -1.07633939e-03f, -2.58466333e-01f, -2.42179204e-02f, -3.01536755e-03f, -5.74694946e-02f, -1.72298193e-01f,
  1.01541303e-01f, 1.39729142e-01f, -1.65933490e-01f, -6.70650080e-02f, 7.85833448e-02f, -7.10856691e-02f, -7.40701780e-02f, 9.92082953e-02f, 5.97942248e-03f, 1.27057716e-01f,
  7.93730393e-02f, 1.36053622e-01f, -3.58621916e-03f, 1.41585171e-01f, 1.50919631e-01f, 1.13863587e-01f, 1.07562900e-01f, 7.21205249e-02f, -6.13220632e-02f, 2.16291249e-02f,
  2.61016451e-02f, 2.25192942e-02f, 1.41834840e-01f, -7.94135109e-02f, -2.98169423e-02f, -2.60320902e-02f, 5.53229563e-02f, -3.06024645e-02f, -2.45709736e-02f, -8.05523712e-03f,
  -3.96869741e-02f, 4.50745150e-02f, -5.39436974e-02f, -1.47463128e-01f, -8.56669694e-02f, 4.18987911e-04f, 7.22171739e-02f, 8.89538042e-03f, -5.77569939e-03f, 7.73069039e-02f,
  3.71450782e-02f, 5.09026200e-02f, 7.53780175e-03f, 2.73333546e-02f, 2.40419116e-02f, 3.46077457e-02f, 9.76912584e-03f, 5.00020012e-02f, 6.74996376e-02f, 5.99820763e-02f,
  -1.17134474e-01f, 9.52151716e-02f, 1.75231263e-01f, 8.65603909e-02f, 1.19251963e-02f, -7.81152621e-02f, 1.10773224e-04f, -1.43524054e-02f, 5.50482310e-02f, 8.97712335e-02f,
  6.20040931e-02f, -1.30167902e-01f, -1.86225370e-01f, -1.38562113e-01f, 2.16760044e-03f, 1.23806886e-01f, -9.17201489e-02f, 3.90110724e-02f, 8.98279250e-02f, 7.24521056e-02f,
  6.26410618e-02f, -3.48249869e-03f, 1.17448516e-01f, 3.51756997e-02f, -8.68232641e-03f, 2.44315341e-02f, -9.94548388e-03f, 1.22445961e-02f, 1.72311869e-02f, 1.15657754e-01f,
  3.75483409e-02f, 1.38615840e-03f, -1.18451994e-02f, -2.13292819e-02f, -3.17955241e-02f, -6.83382079e-02f, -4.04456776e-04f, -2.19154055e-03f, -4.51074243e-02f, 1.24488994e-02f,
  -5.10955930e-01f, -3.58911939e-02f, -1.01759518e-02f, -3.07368841e-02f, -1.11276977e-01f, -1.56573027e-01f, -1.81042865e-01f, -2.31306508e-01f, -3.23483162e-02f, 9.36784968e-03f,
  1.26891002e-01f, 3.73980522e-01f, 3.00321579e-01f, 3.07116240e-01f, 1.58420324e-01f, 1.63411163e-02f, 1.06430203e-01f, 5.77056520e-02f, 9.63621587e-02f, 2.29392797e-02f,
  1.58311836e-02f, 8.23712908e-03f, -7.18837455e-02f, 1.55147836e-02f, 8.87610093e-02f, 2.60602772e-01f, 7.34893605e-02f, -6.67918473e-02f, -4.43410873e-02f, 1.04084842e-01f,
  5.44574440e-01f, -1.41445860e-01f, 7.76733235e-02f, -6.60937577e-02f, 1.57256331e-02f, -2.14708462e-01f, -8.31635967e-02f, -1.49486512e-01f, -2.38244757e-01f, -8.10164288e-02f,
  -1.13603577e-01f, -8.49691480e-02f, -4.80215475e-02f, -6.47644177e-02f, -1.47712514e-01f, -1.39528006e-01f, -7.86092505e-02f, -1.73393711e-02f, 8.36474374e-02f, 1.22453133e-02f,
  1.01493515e-01f, -3.39855440e-02f, -7.53334537e-02f, -8.77724215e-02f, 6.38614222e-03f, -8.67805257e-03f, -5.42562595e-03f, -1.29971266e-01f, -8.37846994e-02f, -1.00803442e-01f,
  -6.46209866e-02f, 5.79369068e-03f, 1.12761743e-01f, 1.24999974e-02f, -3.90507542e-02f, -1.11498557e-01f, 8.72112289e-02f, 1.45955488e-01f, 2.28157640e-02f, -1.29975192e-02f,
  5.27585596e-02f, 2.11407952e-02f, 2.77678166e-02f, -2.07213517e-02f, 7.74891153e-02f, -6.08800687e-02f, -1.39180735e-01f, 3.16769443e-02f, -5.73206767e-02f, -6.88811019e-02f,
  1.94009542e-02f, -1.16741091e-01f, 5.73437707e-03f, 2.35173218e-02f, 2.85675935e-02f, -1.01936378e-01f, -1.31843641e-01f, -2.93324608e-02f, -1.57840196e-02f, -1.42649680e-01f,
  4.38265175e-01f, 8.82623792e-02f, 1.32044241e-01f, 9.83554497e-02f, -7.79226571e-02f, -1.06151499e-01f, 2.06228539e-01f, -1.13185961e-03f, -3.83269601e-02f, 4.17127237e-02f,
  -2.20156331e-02f, -6.40083179e-02f, -9.07048117e-03f, 7.95282125e-02f, 3.51787992e-02f, -1.03783920e-01f, 9.77409258e-02f, 4.32219058e-02f, 1.35392234e-01f, 1.24359950e-02f,
  -1.08360171e-01f, -3.09509244e-02f, 1.36150599e-01f, 2.20729917e-01f, 6.87447339e-02f, 9.92988721e-02f, 1.77981779e-01f, 8.06486607e-02f, 1.26264781e-01f, 2.71849874e-02f,
  8.95445794e-02f, -3.18642296e-02f, 1.70937434e-01f, 3.21690768e-01f, 2.63556421e-01f, 2.30552763e-01f, 2.52143919e-01f, 2.18356356e-01f, 2.30134740e-01f, 1.84681118e-01f,
  1.31545231e-01f, 1.69071943e-01f, 7.88671598e-02f, 4.45692390e-02f, 5.84310889e-02f, 1.76579714e-01f, 1.87282935e-01f, 1.62965745e-01f, 7.44782910e-02f, 2.13932738e-01f,
  1.86259717e-01f, 1.04671881e-01f, 6.90352991e-02f, 4.24562283e-02f, 2.07046419e-01f, 1.94924906e-01f, 7.19526932e-02f, 1.19612202e-01f, 3.94597612e-02f, 2.18583003e-01f,
  -9.06305388e-02f, -9.65554282e-05f, -2.61255750e-03f, -3.95955332e-02f, -1.73318326e-01f, -1.48301676e-01f, 4.92670313e-02f, 6.58773407e-02f, 3.20113152e-02f, 4.13336381e-02f,
  3.96741554e-02f, 3.30266613e-03f, 4.92740385e-02f, -4.45258543e-02f, -1.51935723e-02f, -1.29052937e-01f, -1.58055574e-01f, 3.50045413e-02f, 1.83498427e-01f, 5.01627102e-03f,
  3.17459404e-02f, 1.37648266e-02f, 4.62124534e-02f, 1.01711020e-01f, -5.61598614e-02f, -4.84035127e-02f, 6.84613362e-02f, 2.83316430e-02f, 1.78077240e-02f, 6.23398609e-02f,
  1.77173465e-01f, -2.23303027e-02f, 3.21332663e-02f, 1.27107829e-01f, 2.42241044e-02f, 5.19054085e-02f, 6.63029104e-02f, 3.44398096e-02f, 6.47394583e-02f, -9.15998071e-02f,
  1.18120098e-02f, 2.73615438e-02f, 3.48680876e-02f, 8.51652697e-02f, -3.76448110e-02f, 4.15247157e-02f, -8.26221332e-02f, 2.90722866e-03f, -4.24516201e-02f, -2.30726600e-02f,
  2.42863875e-02f, 1.42028350e-02f, -7.84021430e-03f, 2.69671064e-02f, -3.77447419e-02f, 7.84844011e-02f, 6.49255048e-03f, 4.94788960e-02f, -5.30513041e-02f, 2.34449282e-02f,
  -2.79294811e-02f, -1.05281956e-01f, 2.50439402e-02f, 4.40199897e-02f, -1.68539546e-02f, -6.79392293e-02f, -2.74943449e-02f, -1.00195259e-01f, 5.58738085e-03f, 5.02257347e-02f,
  -7.47574195e-02f, -7.04911500e-02f, -8.60173777e-02f, -8.25009272e-02f, -3.75701208e-03f, 2.78562773e-02f, -1.16224378e-01f, -4.11444530e-03f, 5.42694069e-02f, 2.39845868e-02f,
  -3.65892127e-02f, 1.16670094e-01f, 7.26054907e-02f, -6.23654313e-02f, -6.31928518e-02f, 7.18846470e-02f, -1.75824650e-02f, -4.51451018e-02f, -9.32399556e-02f, -4.98400182e-02f,
  6.17233217e-01f, 3.27341855e-01f, 1.97096601e-01f, 2.28590533e-01f, 1.28084242e-01f, -5.41161597e-02f, -1.04522072e-01f, -1.35897815e-01f, -8.27498958e-02f, 1.52422801e-01f,
  1.71823174e-01f, -1.17214158e-01f, -5.86323924e-02f, -2.50088096e-01f, -1.56642050e-01f, -9.17834267e-02f, -1.53850928e-01f, -1.74850792e-01f, -3.65121901e-01f, -1.40714988e-01f,
  -2.03777105e-01f, 4.37225848e-02f, 4.06022668e-02f, -4.97431792e-02f, 1.69701323e-01f, -8.72503072e-02f, 1.67881921e-01f, 1.10341392e-01f, -2.52468884e-02f, 2.53481090e-01f,
  2.46077418e-01f, 3.82247418e-01f, -3.00589025e-01f, 2.24366579e-02f, 2.16108978e-01f, -4.97998185e-02f, -2.98572071e-02f, 8.99868831e-02f, 1.54029857e-02f, 3.65291344e-04f,
  2.16533616e-01f, 1.14052132e-01f, 1.42128557e-01f, -9.88558382e-02f, 8.80443379e-02f, -6.13485910e-02f, -1.27006741e-02f, 7.69664487e-03f, -1.00970574e-01f, 6.56073019e-02f,
  5.36864586e-02f, 6.30959868e-02f, 2.41368562e-01f, -6.98059574e-02f, 3.87024023e-02f, -2.69119162e-02f, 1.82993561e-01f, 1.48394212e-01f, -1.22445233e-01f, 6.59541637e-02f,
  -1.70397624e-01f, 5.63084967e-02f, 1.40173337e-03f, 3.86637747e-02f, -6.90182224e-02f, 5.10276854e-02f, 1.30685056e-02f, -3.73715302e-03f, -7.75805041e-02f, 2.52253544e-02f,
  -4.54587787e-02f, 3.28685977e-02f, -6.20299578e-02f, 4.38684486e-02f, -4.09417413e-02f, 1.09011762e-01f, -1.12055227e-01f, -9.50878263e-02f, 4.49356325e-02f, -6.22451305e-02f,
  -2.50140745e-02f, -3.93398711e-03f, 7.68584087e-02f, -5.85432835e-02f, 8.70206207e-03f, -1.13789327e-01f, -3.79544981e-02f, -1.13776289e-01f, -1.40495196e-01f, 6.21041246e-02f,
  -1.98483586e-01f, -1.27603203e-01f, -6.15096726e-02f, -8.21170583e-02f, -2.75086761e-02f, -5.59616461e-02f, 7.03789815e-02f, -6.50406703e-02f, 6.10880665e-02f, -6.51905313e-03f,
  4.15375121e-02f, -1.26790509e-01f, 7.52171278e-02f, -8.52703601e-02f, -2.25320637e-01f, -9.57906991e-02f, -1.23326860e-01f, -8.24252144e-02f, -1.56030744e-01f, 1.19201750e-01f,
  -1.79580972e-01f, -2.18092039e-01f, -1.85324982e-01f, -1.83070228e-01f, -9.96313524e-03f, -2.65464872e-01f, -2.67268687e-01f, -2.38699734e-01f, -2.77108461e-01f, -3.08389246e-01f,
  2.47417390e-01f, -3.01668537e-03f, -2.91055143e-01f, 1.25356346e-01f, -2.71856129e-01f, -2.46957406e-01f, -2.55672514e-01f, 7.81884324e-03f, 1.98987752e-01f, -2.58072503e-02f,
  -3.20016034e-02f, 2.01561972e-01f, 2.32216552e-01f, 1.39003411e-01f, 6.70656562e-02f, -2.55917072e-01f, -1.54268742e-01f, -1.71110526e-01f, 1.70949828e-02f, -1.21654846e-01f,
  -2.93637216e-02f, 4.64952625e-02f, 3.23836878e-02f, 3.05157574e-03f, -1.37708141e-02f, -4.94198576e-02f, -2.12070003e-01f, -5.51867113e-02f, -1.71534151e-01f, -2.30916038e-01f,
  2.86418828e-03f, -1.05509318e-01f, -1.06217779e-01f, -8.58261436e-03f, -3.86702642e-03f, 1.57641664e-01f, -6.81712851e-02f, 2.04751687e-03f, 2.84973476e-02f, 5.79544008e-02f,
  -1.18096642e-01f, 6.58021942e-02f, 6.37484491e-02f, -3.30464728e-02f, -4.83367406e-02f, -5.09821717e-03f, 1.63840801e-02f, -3.17875333e-02f, -9.79093388e-02f, 1.65685378e-02f,
  -1.11682244e-01f, -1.09240443e-01f, -1.88307956e-01f, -4.10349816e-02f, -1.52560592e-01f, -3.59195992e-02f, -2.01564804e-01f, -2.49706239e-01f, -2.88397223e-01f, -1.50464907e-01f,
  -1.67192484e-03f, 1.16316238e-02f, 2.82021593e-02f, 1.30888954e-01f, 7.71828964e-02f, 2.58619469e-02f, -1.35470973e-02f, 6.33234344e-03f, 1.60301715e-01f, -3.64238396e-02f,
  -7.50539228e-02f, -5.05245216e-02f, -3.12594026e-02f, 5.80120347e-02f, -1.98693015e-03f, -6.01350404e-02f, 7.34273205e-03f, 9.51182917e-02f, 1.83311328e-02f, 4.89858575e-02f,
  -2.80640647e-02f, -3.75082307e-02f, 5.89102693e-02f, -2.20028218e-02f, -1.05502807e-01f, -5.25491759e-02f, 5.43612987e-03f, -3.77227413e-03f, 2.01105997e-01f, -5.51023427e-03f,
  4.04950500e-01f, -1.65348023e-01f, 1.30476996e-01f, 2.20153276e-02f, -4.41868380e-02f, 5.24436943e-02f, 1.80239454e-01f, 6.38932884e-02f, 1.71119347e-01f, 8.95817801e-02f,
  -2.93807909e-02f, 1.50348693e-01f, 1.26753643e-01f, -1.14702933e-01f, -1.15133837e-01f, 4.68062535e-02f, 1.81625225e-02f, 4.73745465e-02f, 4.71508019e-02f, 5.66176288e-02f,
  1.31743597e-02f, 9.59945992e-02f, 9.50274393e-02f, 5.56285195e-02f, 1.13133453e-02f, 1.43191516e-01f, 1.39793614e-02f, -5.95513694e-02f, 1.12119980e-01f, 3.01596045e-01f,
  1.96470276e-01f, 1.34301074e-02f, -3.73403668e-01f, 2.62679636e-01f, 7.51213729e-02f, 1.45779938e-01f, 3.94862264e-01f, 2.25382790e-01f, 2.22900301e-01f, 5.63208759e-03f,
  -6.39726073e-02f, -1.52141213e-01f, -2.06006825e-01f, -1.12097919e-01f, -6.95501119e-02f, 1.39529228e-01f, -5.98981045e-02f, -6.85370192e-02f, -9.32898968e-02f, 1.99425444e-01f,
  1.13781691e-01f, 1.66413143e-01f, 3.66431996e-02f, 1.65483672e-02f, 1.90309938e-02f, 4.35885042e-02f, -6.64560124e-02f, -4.06403467e-02f, -2.30394136e-02f, -5.31942323e-02f,
  -4.72931027e-01f, -7.71557614e-02f, -4.12006527e-02f, 9.07938331e-02f, -1.45720690e-01f, -1.13464959e-01f, -5.90414815e-02f, -2.01390326e-01f, -1.32835492e-01f, -4.13527675e-02f,
  -5.00704385e-02f, -5.10896221e-02f, -1.65014371e-01f, 5.59322722e-02f, 6.62456825e-02f, 4.84044179e-02f, -1.29919782e-01f, -1.10972963e-01f, 2.06364952e-02f, -2.08254561e-01f,
  6.30621538e-02f, -7.91373178e-02f, -2.67975062e-01f, -4.71618250e-02f, -1.16540663e-01f, -1.29660204e-01f, -1.18331969e-01f, -5.75173534e-02f, -2.00007021e-01f, -1.20242193e-01f,
  -2.65946425e-02f, 4.66550216e-02f, 3.68273631e-02f, 1.85127631e-01f, 1.60407096e-01f, 6.47607520e-02f, -5.16554387e-03f, -4.45480868e-02f, 1.42620653e-01f, 8.32080469e-02f,
  3.20934616e-02f, -1.35362580e-01f, -6.93200007e-02f, 7.11272210e-02f, 2.48085484e-02f, -1.36047930e-01f, 6.23097979e-02f, 2.76813023e-02f, 9.82543174e-03f, 7.51005905e-03f,
  4.44019549e-02f, -1.05192989e-01f, -2.49531250e-02f, 2.90925466e-02f, -4.95094508e-02f, -1.54630855e-01f, -3.26290764e-02f, 1.87806636e-02f, -2.22270098e-02f, 5.57122305e-02f,
  1.66270986e-01f, -1.28265023e-01f, 1.97513625e-02f, -3.95001471e-02f, -5.24484031e-02f, -8.46280307e-02f, 2.17467323e-02f, -1.36399344e-01f, -1.58671901e-01f, 6.90845549e-02f,
  9.99233052e-02f, -7.85688590e-03f, 6.68271109e-02f, 8.37817602e-03f, -5.24020652e-06f, 4.54872251e-02f, -4.02471945e-02f, 6.52140230e-02f, 1.10597342e-01f, -4.70847115e-02f,
  1.10609390e-01f, 2.44286269e-01f, 1.15227714e-01f, -8.67796689e-02f, -2.04100907e-02f, 5.93968928e-02f, -5.80380410e-02f, -1.26139689e-02f, -3.72074209e-02f, 3.12811673e-01f,
  4.84240621e-01f, -9.12373438e-02f, -9.36752781e-02f, 9.02052522e-02f, -5.67648858e-02f, 3.73276286e-02f, -6.72463402e-02f, 3.16909701e-02f, 8.84620696e-02f, -7.12885708e-02f,
  1.10636450e-01f, 1.97081983e-01f, 4.40961905e-02f, 9.00698379e-02f, 1.06480323e-01f, -1.97826311e-01f, -1.30903766e-01f, 2.82986257e-02f, 1.27914906e-01f, -9.18459073e-02f,
  -1.18945204e-01f, -5.65646552e-02f, 7.69675225e-02f, -2.90849507e-02f, -3.13721895e-01f, 2.59029754e-02f, -1.51698232e-01f, -1.62784636e-01f, -1.20965265e-01f, -2.72722214e-01f,
  6.54419214e-02f, 2.23606125e-01f, 6.96697533e-02f, 5.92028908e-02f, -8.28065164e-03f, -6.95469156e-02f, 5.75408451e-02f, 6.76761148e-03f, -7.24861696e-02f, 3.31671461e-02f,
  -1.06638260e-01f, -1.26765072e-01f, 7.93342516e-02f, -2.18146518e-02f, -5.21185342e-03f, 1.64608937e-02f, -2.49860156e-02f, -1.97178721e-02f, 5.27046248e-02f, -4.61247154e-02f,
  4.70796339e-02f, 8.03638324e-02f, 1.46161407e-01f, 5.38646132e-02f, 5.13353236e-02f, 1.13130324e-01f, 1.14023864e-01f, 8.60413611e-02f, 6.49183467e-02f, 3.01629677e-02f,
  1.31509441e-03f, 2.02287231e-02f, 1.06599644e-01f, 8.15351978e-02f, 1.80804469e-02f, 2.61996128e-03f, -3.64482813e-02f, 6.90332800e-02f, 1.07355816e-02f, -2.60782056e-02f,
  -1.06774233e-01f, 1.18697003e-01f, 1.58194348e-01f, 3.63845122e-03f, -3.75990346e-02f, 3.31730209e-02f, -9.43879830e-04f, -7.98485652e-02f, 7.30569735e-02f, -7.54867718e-02f,
  1.37506828e-01f, -1.43858403e-01f, -1.41306629e-03f, -5.25272340e-02f, -5.69723658e-02f, -1.43153323e-02f, 3.60665396e-02f, -4.18317765e-02f, -2.53786035e-02f, -5.01322635e-02f,
  5.68138286e-02f, 2.44347379e-01f, -8.74137506e-02f, -1.79042201e-02f, -5.69051690e-02f, -8.76674727e-02f, -1.77744136e-04f, -4.29779198e-03f, -6.29100651e-02f, 4.57554683e-02f,
  4.19715047e-02f, 5.00065647e-02f, 4.49265726e-02f, -4.27535139e-02f, -1.18210278e-02f, -4.67169434e-02f, -4.79433388e-02f, 5.98425530e-02f, -7.36778527e-02f, -6.99568093e-02f,
  -1.05679110e-02f, 6.89263120e-02f, 1.48506835e-01f, 3.61190774e-02f, -4.78470288e-02f, 6.69934750e-02f, 1.12049263e-02f, -9.36123356e-02f, 7.72451609e-02f, -5.52792475e-02f,
  3.95535916e-01f, -2.43860006e-01f, -1.91161096e-01f, 8.13339930e-03f, -1.94257628e-02f, 8.88885930e-02f, 3.66855226e-02f, 5.01630157e-02f, 1.80224888e-02f, -1.37670547e-01f,
  1.62070412e-02f, 5.58435172e-02f, 4.80301529e-02f, 2.01778691e-02f, 1.51474848e-01f, -1.55694425e-01f, -3.91371436e-02f, 1.25245526e-01f, 1.57560274e-01f, 1.46905363e-01f,
  4.81334627e-02f, 1.07972249e-02f, 1.74237918e-02f, -4.36881706e-02f, -1.60239816e-01f, -4.88520376e-02f, -2.09195420e-01f, -1.45494550e-01f, -1.16945736e-01f, -1.65803760e-01f,
  -6.76619560e-02f, -1.09954014e-01f, -4.39636484e-02f, -5.50860837e-02f, -1.78614244e-01f, -1.12514794e-02f, 3.28230895e-02f, -2.72545964e-03f, 1.76405869e-02f, -1.14942931e-01f,
  -7.79681802e-02f, 2.44553685e-02f, -1.16406180e-01f, -1.63074970e-01f, -4.91653606e-02f, -8.93737003e-03f, -1.66372553e-01f, 4.08295617e-02f, 8.18633661e-02f, 7.06660077e-02f,
  -3.13210189e-02f, 1.83677450e-02f, -1.29476339e-01f, -1.06222823e-01f, 6.14152439e-02f, 1.24546781e-01f, -7.09986240e-02f, -7.16877431e-02f, 1.41608324e-02f, -5.62799759e-02f,
  8.12946185e-02f, 5.79964556e-02f, -2.02040505e-02f, 1.55644091e-02f, -5.59563376e-02f, 7.61576965e-02f, -5.88291250e-02f, 1.51312007e-02f, 3.42145190e-02f, -8.48519057e-02f,
  -4.36546281e-03f, 1.51703097e-02f, -3.11515620e-03f, -7.01923221e-02f, 2.18430944e-02f, 2.92262081e-02f, 4.47726510e-02f, -5.03963195e-02f, 7.25735724e-02f, 9.06174853e-02f,
  -8.48546997e-03f, 3.43948379e-02f, -7.19898120e-02f, 7.56277982e-03f, 1.83537789e-02f, 1.35705397e-02f, 3.58689926e-04f, -8.01407993e-02f, -3.41290422e-02f, 8.33324417e-02f,
  -4.76561040e-02f, 3.14674489e-02f, -3.96822691e-02f, 4.59112450e-02f, -4.14183140e-02f, 7.02336282e-02f, -2.39343494e-02f, -2.03152131e-02f, 1.44189107e-03f, -8.19606334e-02f,
  -2.72202212e-02f, -3.83083858e-02f, 1.02357967e-02f, 3.86668369e-03f, 6.86270893e-02f, 5.27576208e-02f, -3.50209363e-02f, 4.29417826e-02f, 4.68930416e-02f, 8.91517326e-02f,
  6.95176348e-02f, 3.17447446e-02f, 1.56196833e-01f, 5.73415756e-02f, 5.47273606e-02f, 2.14088038e-01f, 2.62045283e-02f, 1.01849295e-01f, 1.24826357e-01f, 4.06974219e-02f,
  4.76899207e-01f, -1.05076917e-01f, 1.45522073e-01f, 1.47016704e-01f, 2.68398970e-02f, 7.33036250e-02f, -3.48728038e-02f, -3.84652503e-02f, 4.35692333e-02f, 2.16170237e-03f,
  1.54175237e-01f, 1.31177887e-01f, 2.12797269e-01f, 2.27018103e-01f, 7.75294602e-02f, 2.23729573e-03f, -1.05178848e-01f, 8.18159208e-02f, 2.19020113e-01f, 1.13252066e-01f,
  -3.31421173e-03f, -1.68457806e-01f, -5.32713830e-02f, -4.09208462e-02f, -3.58610414e-02f, 8.68003070e-02f, -5.35424389e-02f, -7.59838149e-03f, 1.62727907e-02f, -9.85183269e-02f,
  1.36087909e-01f, 9.03986469e-02f, 1.29851162e-01f, 2.65330244e-02f, -9.37579945e-02f, -4.55526002e-02f, 5.29059619e-02f, -1.08369552e-02f, -1.42553195e-01f, -1.30483344e-01f,
  -5.08326143e-02f, -1.59292836e-02f, 7.59834275e-02f, -6.90600872e-02f, -6.39358349e-03f, -5.27839251e-02f, -5.57050295e-02f, 5.56859262e-02f, 1.05837442e-01f, -2.62666009e-02f,
  2.80846115e-02f, 1.10033885e-01f, -3.56064700e-02f, -1.03985360e-02f, 9.76461917e-02f, 1.77475244e-01f, 5.35906153e-03f, 5.80107495e-02f, 1.19938634e-01f, 8.09758976e-02f,
  1.36183888e-01f, 5.80713451e-02f, 9.85290334e-02f, 2.42052916e-02f, -1.08506428e-02f, 7.14914277e-02f, 2.13438235e-02f, -1.62082259e-02f, 1.24661047e-02f, 7.46263005e-03f,
  -4.69678901e-02f, 2.46793497e-02f, -1.16058066e-02f, 9.30927321e-02f, 1.36464253e-01f, -1.93570014e-02f, 4.01952863e-02f, -9.23619512e-03f, 1.00623295e-01f, -1.73165277e-02f,
  7.19760284e-02f, 4.04099599e-02f, -1.27234235e-02f, -3.06103323e-02f, 4.35222872e-02f, 3.50747891e-02f, 1.78476702e-02f, 1.02504149e-01f, 4.79684249e-02f, -1.13889523e-01f,
  -9.34639052e-02f, 2.64209986e-01f, 9.70883481e-03f, 3.34742591e-02f, -2.46205274e-03f, -9.91244614e-02f, 1.85778677e-01f, 2.18622182e-02f, -1.04448304e-01f, -8.90618637e-02f,
  -4.92274091e-02f, 3.41961812e-03f, 6.78498447e-02f, -1.29877523e-01f, -1.01997294e-01f, 5.91526516e-02f, 3.75044160e-02f, -3.44878435e-02f, -5.19638546e-02f, -1.15694433e-01f,
  -8.46631303e-02f, 5.16823754e-02f, 1.35376826e-01f, 1.12463228e-01f, 8.70818347e-02f, 9.42134932e-02f, 4.52355742e-02f, -6.63677156e-02f, 9.56414789e-02f, -1.20934285e-01f,
  3.32979470e-01f, -2.23365366e-01f, -6.09488040e-02f, -2.72704680e-02f, -1.10323809e-01f, 3.25196460e-02f, -5.93865328e-02f, 4.36994433e-02f, 8.64333883e-02f, -2.83930115e-02f,
  2.70700566e-02f, 1.98090941e-01f, 4.11321744e-02f, 4.70886417e-02f, 1.97443917e-01f, -1.09794639e-01f, -2.00009625e-02f, 5.65702245e-02f, 2.18106136e-01f, 4.02962677e-02f,
  3.77903543e-02f, -8.83809626e-02f, 7.84941539e-02f, 2.42909882e-02f, -5.77390008e-02f, 2.85373162e-02f, -1.95907623e-01f, -1.76767826e-01f, -1.22841507e-01f, -2.11307928e-01f,
  -2.67498835e-04f, -2.85315122e-02f, 1.67233255e-02f, 3.95941585e-02f, -1.02673255e-01f, -1.04615223e-02f, 2.95445416e-02f, -1.04161359e-01f, -3.54980566e-02f, -5.72156236e-02f,
  -1.76492147e-02f, -5.53236641e-02f, -6.27965480e-02f, -6.42115623e-03f, -7.83266500e-02f, 4.20385069e-04f, -2.20852755e-02f, 5.92202358e-02f, -2.87337787e-02f, -5.23733571e-02f,
  -7.50418380e-02f, -6.34917915e-02f, -2.47947709e-03f, -7.47860409e-03f, 9.36757252e-02f, 1.44439921e-01f, 2.78206114e-02f, 2.14917175e-02f, -5.33489138e-02f, -8.67824405e-02f,
  -8.34969729e-02f, 5.73306456e-02f, 5.73726557e-02f, 4.77783382e-03f, 8.56661052e-03f, 4.77817841e-02f, 5.60187362e-03f, -5.46741039e-02f, 1.28959073e-03f, -1.20120898e-01f,
  4.26901989e-02f, 5.53112105e-03f, -3.08899470e-02f, -2.24748198e-02f, -1.42052444e-02f, -8.73059705e-02f, -1.25160469e-02f, 7.70007682e-05f, -5.57069629e-02f, 1.97643414e-02f,
  -1.87716470e-03f, 2.88942792e-02f, 5.59602417e-02f, 1.25843808e-01f, 8.34083036e-02f, 1.02063209e-01f, 5.60007570e-03f, -7.66271167e-03f, 1.03461435e-02f, 1.71520282e-02f,
  -1.02608822e-01f, 9.26598608e-02f, 1.19685024e-01f, 3.24582011e-02f, -9.77247357e-02f, 3.22551951e-02f, 2.20264010e-02f, 1.65925939e-02f, 5.02432138e-02f, 8.75161365e-02f,
  -4.89465445e-02f, -3.70316356e-02f, -3.25625725e-02f, -4.75795828e-02f, -7.29726627e-03f, -4.82894890e-02f, -8.28116108e-03f, 3.97620536e-02f, 3.57485861e-02f, 7.26854848e-03f,
  -1.02258340e-01f, -2.81002708e-02f, 3.12173292e-02f, 3.50196939e-03f, 4.26481031e-02f, 1.28235608e-01f, -3.59716564e-02f, 9.26590264e-02f, -3.56940995e-03f, -4.83194999e-02f,
  2.60054052e-01f, 3.08177266e-02f, 2.74028629e-01f, 3.29981409e-02f, 1.36665285e-01f, 2.00760782e-01f, 3.67625445e-01f, 1.68482676e-01f, -7.75746778e-02f, -4.62471806e-02f,
  -8.97072852e-02f, -3.81498486e-01f, -1.74195498e-01f, -2.26679087e-01f, 6.18666559e-02f, 2.15870664e-01f, 8.99109095e-02f, 3.63396518e-02f, 1.11112870e-01f, 1.00113149e-03f,
  1.99597999e-02f, 7.17716962e-02f, 1.24135762e-01f, 1.27518281e-01f, 9.25473869e-03f, -1.67597592e-01f, 1.52968302e-01f, 1.89375713e-01f, -3.20415795e-02f, -5.74640930e-02f,
  -5.41151799e-02f, 1.51262760e-01f, -9.93438438e-02f, -1.52812392e-01f, -8.93987194e-02f, 6.87945932e-02f, 3.66318412e-02f, -5.83663471e-02f, -1.42339066e-01f, 2.19370541e-03f,
  -1.36168525e-01f, -1.00784436e-01f, 6.69286493e-03f, 1.84865412e-03f, -4.48164418e-02f, 3.63010801e-02f, 3.69406334e-04f, 5.05322032e-02f, 7.17601553e-02f, -5.92442453e-02f,
  -8.52034539e-02f, 2.77021667e-03f, 1.72378600e-01f, 2.91579659e-03f, 7.82081336e-02f, -1.62902355e-01f, -5.95078431e-03f, 4.34775576e-02f, -8.54792520e-02f, 1.01784458e-02f,
  1.31751420e-02f, -1.04311131e-01f, -6.58780411e-02f, 4.15803753e-02f, -9.18749943e-02f, -5.70696667e-02f, -2.73058265e-02f, -9.26831067e-02f, -9.34488028e-02f, 1.04147844e-01f,
  6.46628812e-02f, -3.03410348e-02f, 8.03800672e-02f, 2.53424309e-02f, -8.11975896e-02f, 8.03795643e-03f, 7.99896643e-02f, -4.44184020e-02f, 7.55545050e-02f, 1.38694853e-01f,
  1.35335550e-02f, 6.93116635e-02f, 7.90843368e-02f, 4.61470410e-02f, -1.54114971e-02f, 5.14051616e-02f, 4.23107408e-02f, 4.27240618e-02f, -5.35515063e-02f, 9.99394730e-02f,
  -1.22660257e-01f, 1.32675529e-01f, -1.38072327e-01f, 6.41956553e-03f, -4.11418937e-02f, -2.28081383e-02f, -4.15011123e-02f, 6.91256137e-05f, -3.43732610e-02f, 6.28363527e-03f,
  -1.37111709e-01f, -8.02630857e-02f, -4.60471660e-02f, 1.74822479e-01f, 7.43549019e-02f, -9.19317529e-02f, -1.19874388e-01f, -4.08488922e-02f, -9.26363468e-02f, -4.89912629e-02f,
  -9.36762169e-02f, 7.10292831e-02f, 5.72789693e-04f, 5.46543263e-02f, -3.62588130e-02f, -1.59688532e-01f, 1.16242478e-02f, -9.47464257e-03f, -2.97611151e-02f, 8.74404386e-02f,
  -9.82752293e-02f, -1.71208326e-02f, 4.45329435e-02f, 1.51752576e-01f, 5.35773300e-02f, 1.08508334e-01f, -8.53590667e-02f, 3.71455736e-02f, 8.42552690e-04f, 6.13072105e-02f,
  8.58461410e-02f, 1.39537081e-01f, 2.31145948e-01f, 2.38748729e-01f, 1.28309891e-01f, 1.76824227e-01f, 1.39422402e-01f, 1.17131867e-01f, 1.65959280e-02f, -2.47832052e-02f,
  1.34642735e-01f, -4.32678014e-02f, 3.15970718e-03f, 1.22477882e-01f, 2.39898898e-02f, 1.06391899e-01f, 8.23844224e-02f, 1.35604426e-01f, 7.57766068e-02f, 1.27501532e-01f,
  -1.78244375e-02f, -2.76057012e-02f, 1.13782994e-01f, 1.03754506e-01f, 6.00018725e-02f, -9.74421352e-02f, -5.91627732e-02f, 1.01605356e-02f, -1.35942188e-03f, 1.10289501e-02f,
  -2.10241489e-02f, 2.66280845e-02f, 5.40636554e-02f, -7.64717460e-02f, -8.55713040e-02f, -1.36182472e-01f, -1.24462776e-01f, 5.62293157e-02f, 1.83838263e-01f, -5.78799509e-02f,
  5.63501008e-02f, -4.53879982e-02f, 1.00616915e-02f, -1.72293689e-02f, 1.17313519e-01f, 1.57112584e-01f, 6.38572425e-02f, -3.76401171e-02f, 9.11591500e-02f, 5.67266829e-02f,
  1.20170824e-01f, -1.72889587e-02f, 1.70857774e-03f, -1.36079058e-01f, -3.96419875e-02f, -5.91741242e-02f, -1.54657379e-01f, 3.51057276e-02f, -1.41768139e-02f, -4.74674068e-02f,
  -8.25423300e-02f, -5.98684046e-03f, -5.29618599e-02f, -1.27554104e-01f, 7.76927024e-02f, 6.22032881e-02f, -9.63147059e-02f, -7.47520775e-02f, 7.19391555e-02f, 6.65699989e-02f,
  -5.90186529e-02f, 1.05515113e-02f, -7.70531148e-02f, -9.21220407e-02f, -5.19304769e-03f, -6.07785545e-02f, -6.70678541e-02f, 4.69506457e-02f, 1.45912403e-02f, 5.93237393e-02f,
  -2.11052820e-01f, 1.44309595e-01f, -5.51941209e-02f, 8.08359161e-02f, 5.82410619e-02f, -4.30363277e-03f, 6.56365454e-02f, 1.87358595e-02f, -7.03350306e-02f, -7.79847652e-02f,
  -1.11866817e-01f, -2.85666268e-02f, -1.28610477e-01f, -4.51641157e-02f, -1.27481595e-01f, -3.83245721e-02f, -3.11658736e-02f, -6.57317489e-02f, 4.62210253e-02f, -4.86665359e-03f,
  1.73971355e-02f, -1.33983418e-01f, -3.15730684e-02f, 1.27167962e-02f, -4.62718271e-02f, 7.65942410e-02f, -1.74120307e-01f, -1.56573895e-02f, -1.04163319e-01f, -1.15294918e-01f,
  2.83824116e-01f, 1.58908851e-02f, 1.80140659e-01f, 1.28139704e-01f, 2.45676294e-01f, 3.01320195e-01f, 2.97782779e-01f, 1.62784711e-01f, 2.19008103e-02f, 8.54902044e-02f,
  1.86735213e-01f, 2.49043778e-02f, 5.27516566e-03f, -2.00373270e-02f, 8.50582775e-03f, -2.45206337e-02f, -1.33093745e-01f, 7.22114816e-02f, 7.44384080e-02f, 1.28949344e-01f,
  -5.33248335e-02f, 4.92770709e-02f, 5.77652827e-02f, -6.77470043e-02f, -5.82978036e-03f, -4.84643057e-02f, -3.57489660e-02f, -1.43115763e-02f, -1.61399469e-02f, -3.22236985e-01f,
  -5.54263294e-02f, 2.14933604e-01f, -1.20136730e-01f, -2.42303200e-02f, 1.40690347e-02f, -7.50515908e-02f, -4.19332683e-02f, -9.27115977e-02f, -8.65584239e-02f, -9.22014713e-02f,
  -3.00882291e-02f, -5.68984449e-02f, 4.67748679e-02f, 4.24770340e-02f, 3.48763317e-02f, 2.90325545e-02f, 2.86267838e-03f, -1.24304399e-01f, -4.06498410e-04f, -2.64376905e-02f,
  -7.79310465e-02f, -1.09774038e-01f, 1.11508884e-01f, 6.41139373e-02f, 1.62208322e-02f, -1.78929996e-02f, 5.18795475e-02f, -4.41589579e-02f, 5.11987135e-02f, -1.28390461e-01f,
  -1.28956214e-01f, 1.80334114e-02f, 5.22378385e-02f, -2.76634982e-03f, 1.28285065e-02f, -6.29147291e-02f, -9.49300155e-02f, -5.14578931e-02f, -2.67596543e-02f, -7.07778931e-02f,
  -2.23524086e-02f, 8.15371424e-02f, -3.66923250e-02f, -9.13545713e-02f, 2.85567697e-02f, 8.27016216e-03f, -6.47902191e-02f, -4.00050022e-02f, 1.42317228e-02f, 9.37789399e-03f,
  -2.91064754e-02f, -3.52724530e-02f, -3.79353687e-02f, -6.11200891e-02f, -3.48243490e-02f, 2.30080970e-02f, -6.31402880e-02f, 5.31895384e-02f, 1.90719571e-02f, 2.44834982e-02f,
  -2.97464877e-02f, 1.09883942e-01f, -1.28103957e-01f, -6.51076809e-02f, 4.08989899e-02f, 6.54279143e-02f, -5.60257817e-04f, 2.40029972e-02f, 6.30435199e-02f, -5.27607650e-02f,
  5.69405369e-02f, -6.45410717e-02f, -8.70431289e-02f, -8.60732645e-02f, -1.62669018e-01f, -5.49063645e-02f, -1.35229439e-01f, -2.58075446e-02f, -1.47523116e-02f, -1.53445244e-01f,
  5.27625531e-03f, -9.95927528e-02f, 9.50839818e-02f, -4.41272333e-02f, -1.64191574e-01f, -1.08134180e-01f, -1.21492125e-01f, -3.69912162e-02f, 1.31675169e-01f, 7.38429651e-02f,
  -2.19931543e-01f, -2.97030926e-01f, -2.66504079e-01f, 1.75322548e-01f, 3.88124622e-02f, 6.44466132e-02f, -8.28852206e-02f, -7.79203279e-03f, 7.82344416e-02f, -4.54759374e-02f,
  1.14027046e-01f, 1.97920159e-01f, 1.93750754e-01f, 1.91723064e-01f, -2.03937404e-02f, -8.32457244e-02f, -4.46757823e-02f, 7.85046145e-02f, 1.39111295e-01f, 1.16165303e-01f,
  1.99083894e-01f, 6.52044341e-02f, -4.91116988e-03f, 1.10212281e-01f, 9.32226330e-02f, 1.57612875e-01f, 1.37630105e-02f, -6.38831556e-02f, 7.47436285e-02f, -2.12630490e-03f,
  -2.57981747e-01f, -1.08339570e-01f, 5.56117594e-02f, 6.21112697e-02f, -6.32227957e-02f, 5.64368675e-03f, -1.51640385e-01f, -1.49609342e-01f, -3.56105492e-02f, -1.68327793e-01f,
  -6.03390671e-02f, -1.33274287e-01f, 7.64481374e-04f, -2.73910630e-02f, -2.36027651e-02f, -1.60741759e-03f, -6.37815595e-02f, -3.00325751e-02f, -8.15225467e-02f, -8.59448835e-02f,
  1.12482399e-01f, -4.80860770e-02f, -2.07157046e-01f, -2.70635746e-02f, -1.12535238e-01f, -7.37867504e-02f, -9.49731991e-02f, -1.24241784e-01f, -1.61218539e-01f, -2.64537781e-01f,
  8.59550759e-02f, -3.14334445e-02f, -6.68658614e-02f, -9.29287151e-02f, 6.50985315e-02f, -1.01379557e-02f, 5.70088141e-02f, 9.13826078e-02f, 6.10258244e-02f, -1.32601008e-01f,
  1.60532996e-01f, 7.64746889e-02f, 6.89229891e-02f, 5.43460287e-02f, 7.44546056e-02f, -6.26425222e-02f, 3.89754996e-02f, 1.21903643e-01f, -3.86383496e-02f, -1.90550126e-02f,
  -5.62861338e-02f, -5.51475845e-02f, 5.16656181e-03f, 1.40414268e-01f, 3.93214859e-02f, 1.67636108e-02f, -5.55476211e-02f, 2.64562108e-02f, -3.33103277e-02f, -4.33473065e-02f,
  2.19108853e-02f, 6.24845624e-02f, -2.84243114e-02f, -2.72387508e-02f, 8.88166875e-02f, -3.45211960e-02f, 3.51482857e-04f, -6.89528957e-02f, -3.84533294e-02f, 5.94360679e-02f,
  -7.61511386e-04f, 1.75027922e-02f, -6.05155155e-02f, -1.37582734e-01f, 1.41714292e-03f, -2.46091690e-02f, -7.06943050e-02f, -1.19492831e-02f, 5.73883913e-02f, -6.18484477e-03f,
  -4.33486588e-02f, 3.78485862e-03f, -3.24844047e-02f, -1.86135843e-01f, -2.99291722e-02f, -3.53461094e-02f, -1.22856326e-01f, -1.24995105e-01f, -1.88726872e-01f, -1.68816671e-01f,
  2.47638792e-01f, 3.25290740e-01f, 2.00801969e-01f, -2.04282656e-01f, -1.40304491e-01f, -6.19279705e-02f, 2.19387323e-01f, -4.13041115e-02f, -2.54021555e-01f, 6.29243404e-02f,
  -9.99943316e-02f, -3.09083134e-01f, -1.89373508e-01f, -1.53147742e-01f, 1.71369404e-01f, 2.45978132e-01f, 1.72227919e-01f, 7.09778666e-02f, -5.21165431e-02f, -3.64887714e-02f,
  -7.10273162e-02f, -1.24820031e-01f, -2.78420635e-02f, -3.33243534e-02f, -4.12573628e-02f, -1.54013112e-01f, 7.11545199e-02f, 7.82317594e-02f, 1.72101900e-01f, 1.40179753e-01f,
  8.07318240e-02f, 3.83317530e-01f, -1.40613481e-01f, -7.82471523e-02f, -1.37171522e-01f, -9.30496082e-02f, -1.62071750e-01f, 4.80838306e-02f, 6.49988428e-02f, 1.41266868e-01f,
  -7.09722489e-02f, -1.79314874e-02f, -1.91336926e-02f, -1.45184323e-01f, -4.02676277e-02f, -1.52656641e-02f, 3.60272229e-02f, 7.99776390e-02f, 1.20243495e-02f, 5.20809479e-02f,
  -4.26833257e-02f, 8.84395018e-02f, 1.10553689e-01f, 1.41212523e-01f, 1.55333504e-01f, -2.03015178e-01f, 1.08014941e-02f, 1.12631910e-01f, 1.06853455e-01f, 9.20760408e-02f,
  2.70388108e-02f, 4.97155152e-02f, 9.98915136e-02f, 6.74697310e-02f, 5.89284822e-02f, -7.35715404e-02f, -2.69866129e-03f, 6.11473992e-03f, -5.89876659e-02f, 2.29198653e-02f,
  -3.59055102e-02f, 3.42299454e-02f, -3.34707573e-02f, -2.28351168e-02f, -1.27837613e-01f, 6.51310161e-02f, -3.26370783e-02f, 1.05321229e-01f, 3.25460248e-02f, -8.48706365e-02f,
  -6.42615110e-02f, 5.88529790e-03f, -1.01433322e-01f, 1.63731501e-02f, 6.83301687e-02f, 5.07344306e-02f, 3.78591456e-02f, 5.39098307e-02f, 3.28512513e-03f, 1.36367396e-01f,
  -2.95684487e-01f, 1.09827429e-01f, -8.27384666e-02f, -2.14417577e-02f, -7.47091845e-02f, -9.73296985e-02f, -3.17905620e-02f, 8.23581591e-02f, -5.66701740e-02f, 8.05186294e-03f,
  -9.69761536e-02f, 5.19994348e-02f, -1.22952173e-02f, -5.48828468e-02f, -1.55022264e-01f, -7.40158781e-02f, 4.02030954e-03f, -2.36745849e-01f, -5.69143929e-02f, 5.72699606e-02f,
  3.76316719e-02f, -3.59754711e-02f, -2.04183474e-01f, -2.29692515e-02f, -1.03363708e-01f, -2.80845314e-01f, -1.75890565e-01f, -1.85196817e-01f, -2.26689801e-01f, -1.21060960e-01f,
  -6.95288181e-01f, 1.22037090e-01f, 1.36291221e-01f, -4.20840591e-01f, -1.47442654e-01f, -1.74461491e-02f, 2.22866923e-01f, -4.71793003e-02f, -2.12780088e-01f, 1.84857920e-01f,
  1.03056021e-01f, -7.43979439e-02f, 9.39832032e-02f, -1.38990227e-02f, -8.57069269e-02f, 2.08331764e-01f, -8.05146620e-03f, -2.75159508e-01f, -2.84195542e-01f, -2.32672915e-01f,
  -1.88273072e-01f, -3.69759560e-01f, -3.45022827e-01f, -1.77471161e-01f, -8.39555543e-03f, -4.35370281e-02f, 1.24367952e-01f, -1.66571930e-01f, -3.88567783e-02f, 6.33377358e-02f,
  2.76243001e-01f, -1.02252059e-01f, 5.76431789e-02f, -1.64141089e-01f, 2.51460075e-02f, -6.47834390e-02f, -7.29699805e-02f, -9.97824669e-02f, -1.22800007e-01f, 2.40248647e-02f,
  -6.01471141e-02f, 2.30330657e-02f, -2.39733588e-02f, -5.53734116e-02f, -1.48873076e-01f, -5.26809841e-02f, -2.34512929e-02f, -1.65986493e-01f, -4.61112820e-02f, 1.44921586e-01f,
  -5.99772669e-03f, -1.42177284e-01f, 2.75051184e-02f, 6.44032508e-02f, 7.68180983e-03f, -4.51378785e-02f, 1.11965634e-01f, 1.76685434e-02f, 3.05521232e-03f, 6.74908087e-02f,
  6.69463277e-02f, 4.78175916e-02f, 1.76642854e-02f, 5.16179502e-02f, 1.52688082e-02f, -3.87351550e-02f, -2.23360378e-02f, 1.33594833e-02f, -3.11008226e-02f, -6.80560991e-02f,
  3.76421958e-02f, 4.63366397e-02f, 4.97441031e-02f, -6.35784715e-02f, 3.99783403e-02f, -1.11207619e-01f, -5.98420128e-02f, 2.17006798e-03f, 5.07705212e-02f, -9.33697149e-02f,
  -9.71018511e-04f, -9.37255099e-04f, -1.30834460e-01f, 2.94658225e-02f, -2.95953918e-03f, -4.95896628e-03f, -2.54027769e-02f, -2.84273215e-02f, -6.60094842e-02f, -8.83615762e-02f,
  1.27726138e-01f, 9.10166800e-02f, 6.66527897e-02f, 3.47551666e-02f, -1.24935508e-02f, -5.49873523e-02f, -8.30417871e-03f, -5.44891274e-03f, 2.10361835e-02f, 2.31611170e-02f,
  -2.48302915e-03f, 1.35902688e-02f, -2.71215923e-02f, 9.52338353e-02f, -4.49285023e-02f, -1.25806872e-02f, -1.11200279e-02f, -4.50737104e-02f, 1.10490344e-01f, 2.45652627e-02f,
  9.26705673e-02f, 4.57366323e-03f, -2.67493119e-03f, 1.85565710e-01f, 2.88027562e-02f, -5.58964312e-02f, 2.03512341e-01f, 3.19055431e-02f, 1.10989451e-01f, 8.59715044e-02f,
  2.81271040e-01f, -1.44328354e-02f, -3.49895954e-02f, 1.27573729e-01f, 1.01406813e-01f, 1.20013528e-01f, 9.70309451e-02f, 8.79131705e-02f, 1.08517930e-01f, 8.01893845e-02f,
  8.74592662e-02f, 9.84899104e-02f, 2.81605422e-02f, 4.73321527e-02f, 1.43041685e-01f, 7.09768608e-02f, -3.24318223e-02f, 8.60152319e-02f, 6.71575498e-03f, 8.19573104e-02f,
  2.01726127e-02f, -1.51367551e-02f, 7.85069391e-02f, 1.80029385e-02f, 8.69292244e-02f, 1.30631845e-03f, -3.27296481e-02f, 4.11673151e-02f, 2.17619585e-03f, 2.21955124e-02f,
  -8.91466290e-02f, 1.41745821e-01f, 5.08225039e-02f, 4.33010459e-02f, -1.50605123e-02f, -4.53115515e-02f, 3.17821540e-02f, -9.83198807e-02f, -6.69870945e-03f, -7.55521804e-02f,
  4.52208444e-02f, -4.81679775e-02f, 1.46494195e-01f, 4.78378087e-02f, 9.29285437e-02f, -2.73253787e-02f, 3.83971222e-02f, 2.81705614e-02f, -6.49945438e-02f, -9.45165306e-02f,
  1.02719642e-01f, -2.59152371e-02f, 8.94875228e-02f, 1.10445529e-01f, 1.17946021e-01f, 1.14159472e-01f, -6.41179532e-02f, -1.05193416e-02f, 1.87765854e-05f, -3.60430963e-02f,
  1.74669310e-01f, 1.54082611e-01f, 1.33685917e-01f, 1.40916154e-01f, 1.87356606e-01f, 1.11659355e-01f, 4.36539687e-02f, 7.79963359e-02f, 6.62593246e-02f, 1.38791040e-01f,
  -8.81924853e-03f, 8.39657262e-02f, -2.74637737e-03f, -1.29618729e-03f, 6.32546768e-02f, -1.96515527e-02f, 4.21086363e-02f, -3.73383947e-02f, 3.26706879e-02f, -9.56842005e-02f,
  1.17846332e-01f, 1.12176009e-01f, 3.82019393e-02f, 9.41505879e-02f, 4.08417992e-02f, 4.30088788e-02f, 9.68784913e-02f, 3.87806371e-02f, 1.14429802e-01f, 1.34458005e-01f,
  -4.26620990e-01f, 3.90357658e-04f, 6.33799881e-02f, 6.90780655e-02f, 3.28422375e-02f, 7.24836662e-02f, 1.06464595e-01f, -9.96289402e-02f, -8.12277868e-02f, -1.71163425e-01f,
  -9.41654220e-02f, -1.67550724e-02f, 1.82418615e-01f, 9.07382518e-02f, 2.45186826e-03f, -1.40328212e-02f, -4.21366282e-02f, 7.63996318e-02f, -4.54541557e-02f, -1.39182314e-01f,
  -6.82276934e-02f, -3.29667591e-02f, -7.46787190e-02f, 3.57182585e-02f, 1.19777262e-01f, -3.93426605e-02f, -1.39816314e-01f, -5.26217595e-02f, -7.95141049e-03f, 5.56178950e-02f,
  -3.24477494e-01f, -6.94748834e-02f, 1.30667254e-01f, -2.29761109e-01f, -5.81472106e-02f, 2.65917019e-03f, -9.47299302e-02f, -1.99605763e-01f, -6.26061857e-02f, -4.39194478e-02f,
  -1.29501611e-01f, -1.32315829e-01f, -3.43506075e-02f, 7.92751536e-02f, 1.01800509e-01f, 1.21423036e-01f, 2.59816736e-01f, 2.29251415e-01f, -1.05705410e-02f, -3.82709466e-02f,
  5.71327209e-02f, -8.87124836e-02f, -4.23592962e-02f, 1.07999280e-01f, -2.51606088e-02f, 5.22692427e-02f, 1.25286743e-01f, 7.98678622e-02f, 1.81262165e-01f, 2.69564122e-01f,
  -7.93482587e-02f, -1.85041830e-01f, 8.66820887e-02f, -1.26244172e-01f, -5.79132773e-02f, -1.35584865e-02f, -9.18019041e-02f, -1.72072276e-02f, -7.79305696e-02f, 7.90848956e-03f,
  -1.03958987e-01f, -1.67128928e-02f, -2.58906521e-02f, -3.46484669e-02f, -1.29524469e-01f, -9.98645797e-02f, 9.32778493e-02f, 5.00876307e-02f, 1.20812608e-03f, -1.09049127e-01f,
  8.35080445e-03f, 1.06572895e-03f, -1.22474052e-01f, 1.51111022e-01f, -1.54281966e-02f, -5.29447896e-03f, -1.46873236e-01f, -8.54936466e-02f, 1.02990754e-02f, -1.75514184e-02f,
  4.05672267e-02f, 2.98263486e-02f, -3.34165618e-02f, -1.48109673e-02f, 8.86037853e-03f, -2.20827200e-02f, 1.63530380e-01f, 2.57070758e-03f, 6.34844005e-02f, 1.35453967e-02f,
  5.49788848e-02f, 1.97602110e-03f, -1.59424990e-02f, 4.57038470e-02f, 8.53465647e-02f, -3.52913141e-02f, 1.42799122e-02f, 3.04083750e-02f, -9.36300680e-03f, 7.42506310e-02f,
  -2.73509677e-02f, -3.92551720e-02f, -6.38210475e-02f, -3.60544994e-02f, 7.34543130e-02f, 2.89913826e-02f, 2.85520814e-02f, -1.17324786e-02f, 6.62447233e-03f, -2.29029972e-02f,
  -2.19987452e-01f, 2.55263031e-01f, -1.49898425e-01f, -8.59695002e-02f, -3.19352597e-02f, -1.62800215e-02f, -6.87696412e-03f, 3.34828114e-03f, -5.81830256e-02f, -9.54867527e-02f,
  -1.93725303e-01f, -7.77069479e-02f, -1.06539495e-01f, 2.45189797e-02f, -1.87657699e-01f, -1.48391157e-01f, -4.58323732e-02f, -1.34186774e-01f, 7.23625645e-02f, -1.82781562e-01f,
  -6.88688084e-02f, -5.31681888e-02f, -2.40721941e-01f, -1.00289948e-01f, -3.59926447e-02f, -1.18771657e-01f, -7.14751706e-02f, -7.16356710e-02f, 7.95631669e-03f, -2.55779684e-01f,
  2.98899144e-01f, -3.13893914e-01f, -2.21157610e-01f, -1.10711744e-02f, -1.79614082e-01f, -1.96311593e-01f, -2.11219653e-01f, -8.99828970e-03f, -3.60077918e-02f, -2.29591742e-01f,
  -2.41996959e-01f, 9.00313631e-02f, -5.27481884e-02f, 1.06022216e-01f, 1.30090207e-01f, -1.81885302e-01f, -1.32560641e-01f, 1.05703443e-01f, 2.50075042e-01f, 1.49288503e-02f,
  -1.01712413e-01f, -7.29000941e-02f, 1.18181452e-01f, -5.66212693e-03f, -1.70492917e-01f, 1.13816895e-02f, -2.63747871e-01f, -1.06840275e-01f, -1.33032203e-01f, -2.51824617e-01f,
  -1.49059996e-01f, -1.29187658e-01f, -1.71834528e-02f, 2.46632863e-02f, -1.55876338e-01f, 1.21650808e-01f, -5.52146882e-02f, 4.26169783e-02f, 5.11092134e-02f, -6.54157996e-02f,
  -3.16383541e-02f, 7.13743940e-02f, 1.02501892e-01f, -1.06787525e-01f, 1.48241250e-02f, -3.84457782e-02f, -1.24150105e-01f, 4.03226316e-02f, -8.88550803e-02f, 5.93610154e-03f,
  -2.68621836e-02f, -2.90402230e-02f, 7.17631355e-02f, 9.90432221e-03f, 4.66272123e-02f, 5.79646342e-02f, -7.68752322e-02f, 3.30648129e-03f, 8.85907561e-02f, -1.93064600e-01f,
  -5.32117337e-02f, 4.00969088e-02f, -3.25330459e-02f, 3.53947692e-02f, -4.13510948e-02f, 5.16774170e-02f, 4.92499880e-02f, 5.60886078e-02f, 9.35884491e-02f, 3.95963714e-02f,
  9.91573092e-03f, -1.18945867e-01f, 1.23802042e-02f, -7.84044266e-02f, 7.01484755e-02f, 7.08896667e-02f, 2.74875835e-02f, 3.26724350e-02f, 9.83897038e-03f, -5.54261543e-02f,
  5.25190756e-02f, 2.44578663e-02f, -4.75810170e-02f, -2.59914640e-02f, -3.78354043e-02f, -5.49861714e-02f, 3.22829857e-02f, -8.44691135e-03f, -6.13304377e-02f, -4.99312095e-02f,
  1.31403118e-01f, 9.05759856e-02f, -9.40943286e-02f, 5.75327501e-02f, -9.02971402e-02f, -7.52073005e-02f, -2.02630851e-02f, -6.48960248e-02f, 4.77188453e-02f, -3.44813876e-02f,
  -5.13311736e-02f, 1.21120781e-01f, 3.61138806e-02f, -8.65510032e-02f, 2.30120365e-02f, -2.21397616e-02f, -8.87006968e-02f, 8.39712322e-02f, 8.31266195e-02f, -1.29192814e-01f,
  -7.27295177e-03f, 9.82034653e-02f, 2.29580984e-01f, 5.44387735e-02f, 8.38612169e-02f, 5.27286381e-02f, 3.13203521e-02f, 2.43691495e-03f, 1.07898757e-01f, 1.24128357e-01f,
  -6.15922511e-01f, 1.77253485e-01f, 1.89182654e-01f, -2.44607076e-01f, 5.08606099e-02f, -5.16658425e-02f, -5.58151901e-02f, -9.07863304e-02f, -1.54781610e-01f, 1.62108243e-01f,
  1.44126296e-01f, -1.18627064e-01f, -7.49745592e-03f, -1.01012178e-04f, -2.83238679e-01f, -7.69415349e-02f, -1.19729385e-01f, -2.98546582e-01f, -2.54864812e-01f, -1.34456083e-01f,
  -1.23563856e-01f, -3.42228234e-01f, -4.26746607e-01f, -1.58481255e-01f, 5.30397221e-02f, -1.25872016e-01f, 8.25429186e-02f, -1.37422293e-01f, 1.35986522e-01f, 8.69242623e-02f,
  1.19336739e-01f, -8.16170052e-02f, -3.33002210e-02f, -1.04928792e-01f, 4.56818454e-02f, -5.67855276e-02f, 3.16268466e-02f, -6.64475039e-02f, 3.66815068e-02f, -5.88480802e-03f,
  -1.03557110e-01f, 2.65664719e-02f, -1.72578007e-01f, 3.64436172e-02f, -1.40760019e-01f, -6.44260719e-02f, 6.57509491e-02f, -1.41043410e-01f, 9.69073176e-02f, 2.37773076e-01f,
  6.50209934e-02f, 6.31319508e-02f, -6.65969998e-02f, 8.45317841e-02f, -3.13300407e-03f, 5.21800527e-03f, 1.94711313e-01f, 7.78994188e-02f, 1.13264017e-01f, 6.13524206e-02f,
  -1.70841278e-03f, -4.58302209e-03f, 1.27455115e-01f, -6.03291914e-02f, 1.04577495e-02f, -4.47332896e-02f, -3.76367606e-02f, -6.79767458e-03f, 6.17343336e-02f, -6.73536910e-04f,
  7.98804387e-02f, 3.56504470e-02f, 4.68255468e-02f, -5.93304001e-02f, 3.94037664e-02f, 7.07742386e-03f, -1.37636978e-02f, 5.82602471e-02f, 9.31955501e-02f, -4.52291295e-02f,
  -6.73094094e-02f, 7.35334679e-02f, -9.11279470e-02f, -1.78403277e-02f, 4.17984985e-02f, 5.89120016e-02f, 6.69695884e-02f, 1.94795635e-02f, 4.22603562e-02f, -5.92431650e-02f,
  -1.45210937e-01f, -3.28867063e-02f, -2.76585706e-02f, -4.21212986e-03f, 1.72657166e-02f, 1.26453400e-01f, 2.26082951e-02f, 3.80590260e-02f, -2.91500799e-03f, 4.19564322e-02f,
  -5.00045568e-02f, -1.16239376e-01f, 1.56538375e-02f, 1.18593380e-01f, -9.19229165e-02f, -2.61526438e-04f, -8.30288790e-03f, 7.62219913e-03f, 2.68909242e-02f, 9.62484479e-02f,
  1.28245801e-01f, -7.39918798e-02f, -9.94327292e-02f, 1.54848307e-01f, 4.08993848e-02f, -5.66135310e-02f, 5.93696488e-03f, 7.54469782e-02f, 3.97293568e-02f, -6.14248626e-02f,
  4.48028952e-01f, 1.38249680e-01f, -8.20047855e-02f, 1.94474936e-01f, 1.13082398e-02f, 3.02039795e-02f, 1.38816953e-01f, 1.05333477e-01f, 1.05630763e-01f, 1.32195398e-01f,
  -1.01797439e-01f, -3.69897693e-01f, -2.40232453e-01f, -2.51257092e-01f, -1.47570893e-01f, 1.63994104e-01f, 2.03528881e-01f, -1.52183637e-01f, -2.30082959e-01f, -1.31713241e-01f,
  7.91595429e-02f, 1.54023632e-01f, 4.86198179e-02f, -3.19232643e-02f, 1.65971979e-01f, -1.57645699e-02f, 7.00504705e-02f, 6.41881526e-02f, -1.76182643e-01f, 5.97175993e-02f,
  -1.26299649e-01f, -2.84762122e-02f, -9.33258086e-02f, -2.65078750e-02f, -2.45184433e-02f, -1.15764060e-03f, -1.50979474e-01f, 4.97904047e-02f, -3.56583074e-02f, -3.48965898e-02f,
  -6.07572682e-02f, -1.33170158e-01f, -1.22408703e-01f, -1.40658572e-01f, 1.56727750e-02f, -7.94604719e-02f, -4.43158336e-02f, -4.93010357e-02f, -5.67520112e-02f, -2.03196526e-01f,
  -2.01459751e-01f, -7.99014196e-02f, -7.54278749e-02f, -2.88106296e-02f, -1.59467474e-01f, 3.79037336e-02f, -1.09893166e-01f, -1.48532659e-01f, -2.25524217e-01f, 1.56919986e-01f,
  -3.98456492e-02f, -6.38929978e-02f, 9.10786837e-02f, 8.77589136e-02f, 8.48621354e-02f, -7.36341672e-03f, -8.03812295e-02f, -1.58127733e-02f, 1.94383250e-03f, -1.44814579e-02f,
  -6.38453811e-02f, 9.79413167e-02f, -3.70068885e-02f, 4.25430834e-02f, 9.42460224e-02f, 2.17272271e-03f, -6.52532279e-02f, 9.85601172e-02f, -2.02253973e-03f, 4.61985543e-02f,
  -7.51611451e-03f, -3.35095413e-02f, -3.31311971e-02f, 1.02726370e-02f, -1.73568446e-02f, 3.00166905e-02f, -5.33441864e-02f, 1.79431587e-02f, -6.75267950e-02f, 1.87890045e-02f,
  1.09874375e-01f, -1.66361108e-01f, 8.38370025e-02f, -5.74458614e-02f, 3.38145867e-02f, 1.73402056e-02f, -7.97580555e-02f, -8.69314522e-02f, -1.79603808e-02f, -2.78698467e-02f,
  -7.75204971e-02f, -1.28275529e-01f, -5.84780145e-03f, -2.97555532e-02f, 3.86177562e-02f, -1.02785388e-02f, 9.80135128e-02f, -3.73290619e-03f, -7.43086974e-04f, 3.73085514e-02f,
  1.86284512e-01f, 9.78715941e-02f, 1.65657938e-01f, 1.35130003e-01f, 6.73226416e-02f, 8.97630528e-02f, 5.79371043e-02f, 4.34473939e-02f, 1.88252330e-02f, 3.39576453e-01f,
  7.06588402e-02f, -1.06209800e-01f, 2.23945633e-01f, -5.55699058e-02f, -1.63014710e-01f, -2.56675631e-01f, -2.05226168e-01f, -5.35794422e-02f, -9.62310657e-02f, -8.99317116e-02f,
  -8.26067626e-02f, 6.49423245e-03f, 1.21148594e-01f, 1.69962376e-01f, 1.75404847e-01f, 5.29164448e-02f, 2.25219950e-01f, 4.12590623e-01f, 2.24881262e-01f, 7.09904954e-02f,
  5.02009429e-02f, 4.51699123e-02f, 2.93680578e-01f, 1.81810871e-01f, -5.64938644e-03f, 4.84986790e-02f, 5.12987636e-02f, 1.54465795e-01f, 1.38136987e-02f, 1.77705973e-01f,
  7.28709251e-02f, -6.68223575e-02f, -1.19797379e-01f, -1.00489512e-01f, 1.12178899e-01f, 4.67219725e-02f, -8.46816748e-02f, 8.97526667e-02f, -7.09298998e-02f, 1.47403225e-01f,
  -2.16871388e-02f, -1.43837370e-02f, 6.40892535e-02f, 4.26843166e-02f, -5.67139797e-02f, -1.21701330e-01f, 2.04132557e-01f, 2.79583514e-01f, 1.49200127e-01f, -5.36787137e-02f,
  2.82596610e-02f, -6.72593042e-02f, -1.09597899e-01f, -1.42037168e-01f, -1.10056221e-01f, 1.85411703e-02f, -5.26903421e-02f, -1.67639484e-03f, -2.21331604e-02f, -3.59607860e-02f,
  -8.56208205e-02f, 7.60148093e-02f, 4.38216254e-02f, -3.29845049e-03f, 1.92159526e-02f, -3.12588811e-02f, 3.74630243e-02f, 4.92749847e-02f, 3.47189754e-02f, 9.44174156e-02f,
  4.29586321e-02f, 1.09939404e-01f, -4.70096990e-02f, -7.48897940e-02f, -7.62741119e-02f, 2.38418523e-02f, -4.33006398e-02f, -9.58351232e-03f, 9.18306317e-03f, -1.71339735e-02f,
  7.25263581e-02f, 8.99469107e-02f, -4.01277468e-02f, 3.39770578e-02f, -2.35149469e-02f, 4.60895896e-02f, -2.67039649e-02f, -1.25104981e-02f, -1.45154493e-02f, -8.35581124e-02f,
  -5.81526421e-02f, 1.72268786e-02f, -1.52864352e-01f, -9.90449414e-02f, 1.26271069e-01f, 1.01547828e-02f, -1.24081165e-01f, 4.63853925e-02f, -7.87030011e-02f, -6.23459220e-02f,
  -1.66807398e-01f, 1.17960814e-02f, 1.44469151e-02f, 8.06777552e-02f, -1.05783105e-01f, -5.81581630e-02f, -5.70504628e-02f, 3.49091291e-02f, -5.29218800e-02f, -1.86672792e-01f,
  5.47017045e-02f, -1.83939502e-01f, -1.50969625e-01f, -2.39196718e-01f, -3.04705858e-01f, -1.12014443e-01f, -8.99026543e-02f, -1.52682096e-01f, -2.00951278e-01f, -2.90847152e-01f,
  2.20487222e-01f, 1.17969541e-02f, 6.76266383e-03f, 1.30573243e-01f, -4.37826701e-02f, -3.50968987e-01f, -3.03483725e-01f, -1.97548106e-01f, 2.31836110e-01f, -1.63506512e-02f,
  -1.19028024e-01f, -2.67542172e-02f, 7.34473318e-02f, -2.22012907e-01f, -3.92687410e-01f, -1.59021303e-01f, -2.01667562e-01f, -2.46681914e-01f, -2.87741393e-01f, -2.30636269e-01f,
  -1.32606581e-01f, 8.93761367e-02f, -7.46501461e-02f, -6.82645217e-02f, 5.13011925e-02f, -8.68084729e-02f, 2.95521948e-03f, 2.09787712e-02f, -1.98337749e-01f, 1.43745348e-01f,
  -7.38442764e-02f, -2.34577898e-02f, -8.92418995e-02f, -1.20851837e-01f, -6.78187907e-02f, 3.19130756e-02f, -1.56145781e-01f, -5.54387718e-02f, -1.20753862e-01f, -1.22655600e-01f,
  -1.03184193e-01f, -6.65077567e-02f, -9.25895125e-02f, 1.12370569e-02f, -1.06726013e-01f, -2.11130351e-01f, -1.13002636e-01f, -1.07787102e-01f, -5.61031997e-02f, -1.25176281e-01f,
  -2.18466043e-01f, -1.59103334e-01f, -1.84188142e-01f, -1.73737869e-01f, -1.69015482e-01f, -3.77895199e-02f, -2.32022852e-01f, -1.29444718e-01f, -1.53060988e-01f, 4.37043682e-02f,
  6.13658726e-02f, -1.11127824e-01f, -3.18080708e-02f, -6.16395697e-02f, 9.40945819e-02f, 2.14411952e-02f, 6.03626147e-02f, -4.70551252e-02f, -2.26761140e-02f, 3.14116403e-02f,
  4.16116193e-02f, 1.09662665e-02f, -8.24944824e-02f, 8.17928463e-03f, -4.05612960e-03f, -4.93612047e-03f, -2.95281019e-02f, -1.21812776e-01f, -7.71138445e-02f, 3.55767161e-02f,
  -1.00416556e-01f, 6.37707710e-02f, 1.34748206e-01f, -8.97036195e-02f, -3.18454988e-02f, -3.16079222e-02f, 2.05338299e-02f, -1.63852498e-01f, -1.25335798e-01f, 4.41576391e-02f,
  2.80995369e-01f, -1.11037873e-01f, 1.09360434e-01f, -5.73016144e-02f, -2.17990756e-01f, 6.60512671e-02f, 1.54582798e-01f, 7.51364091e-03f, -7.08546257e-03f, -7.57554621e-02f,
  -2.24576443e-01f, -1.33838221e-01f, 1.27441242e-01f, -1.19255278e-02f, -2.47166138e-02f, -6.16759956e-02f, -1.58581838e-01f, -6.06393628e-02f, -1.67202637e-01f, 7.28699267e-02f,
  1.34205699e-01f, -1.30488902e-01f, -7.67965317e-02f, -1.47531420e-01f, 2.03811564e-02f, -1.32406816e-01f, -6.74059391e-02f, -9.05549005e-02f, -2.70503074e-01f, 1.63701214e-02f,
  4.90286797e-01f, 2.03781322e-01f, 2.20922679e-01f, 1.55588329e-01f, 5.84659167e-02f, -6.78569078e-02f, 2.95006465e-02f, 1.01658471e-01f, -5.52683845e-02f, 1.47170112e-01f,
  1.32383749e-01f, 7.08148926e-02f, 4.64215353e-02f, 7.43101090e-02f, 1.52548894e-01f, 7.97808543e-02f, 1.50799779e-02f, 1.29785582e-01f, 1.14844240e-01f, 1.61131412e-01f,
  7.84759447e-02f, 6.64090812e-02f, 1.79579835e-02f, 1.27964407e-01f, 1.37760147e-01f, -9.33466759e-03f, 5.12388051e-02f, 5.19994600e-03f, 4.64609824e-02f, 1.70016155e-01f,
  1.38474897e-01f, 2.02791691e-01f, -1.62810415e-01f, -1.72306940e-01f, -2.28799693e-02f, -4.02662456e-02f, 3.15925037e-03f, -1.43982083e-01f, -7.87159652e-02f, -1.13764413e-01f,
  -2.62309965e-02f, -7.29052499e-02f, -1.82407033e-02f, -4.13381569e-02f, -6.19093403e-02f, -1.24737591e-01f, 3.69280502e-02f, 2.08066893e-03f, -9.68244672e-02f, -6.03672490e-02f,
  2.74086315e-02f, -2.11129934e-02f, 2.13120803e-02f, -1.31681919e-01f, 8.94976407e-02f, -1.59744341e-02f, -9.74379033e-02f, 3.57535779e-02f, -2.72398815e-02f, 8.46701786e-02f,
  -7.01030791e-02f, 2.95385122e-02f, 1.06073804e-01f, 2.31777248e-03f, 3.39560173e-02f, 2.80357879e-02f, -4.26056571e-02f, 6.74073994e-02f, 2.28038747e-02f, -6.21982180e-02f,
  -8.33598971e-02f, 6.55111447e-02f, 6.99898750e-02f, 2.11411100e-02f, 2.67823916e-02f, -6.78151622e-02f, -3.72404195e-02f, -3.57946977e-02f, -6.00495748e-02f, -7.78954178e-02f,
  3.22019905e-02f, -6.39285445e-02f, -5.77453114e-02f, 8.12963396e-02f, 6.94593973e-03f, 2.20883843e-02f, 8.25018883e-02f, -9.05345082e-02f, -3.73742022e-02f, -4.80322801e-02f,
  -3.54637891e-01f, -1.42005727e-01f, 4.07668687e-02f, -7.87061378e-02f, -4.89724465e-02f, -7.70207420e-02f, -4.68814224e-02f, -2.64276955e-02f, -1.78359691e-02f, -8.88174176e-02f,
  -6.62519559e-02f, 8.38596970e-02f, -8.72316882e-02f, -2.72416510e-02f, -2.20131762e-02f, -1.35321394e-01f, -8.88695642e-02f, -1.67152390e-01f, -1.41803667e-01f, -8.35358575e-02f,
  -1.30117357e-01f, -8.51458088e-02f, -9.31713954e-02f, -6.76284358e-02f, -7.33589083e-02f, -1.85454577e-01f, -2.08969772e-01f, -7.01884255e-02f, -1.98368832e-01f, -9.00679901e-02f,
  4.79629278e-01f, -2.33020380e-01f, 1.37709156e-01f, 2.23668590e-01f, 8.25686306e-02f, 9.13318470e-02f, -8.16216096e-02f, 6.21243045e-02f, 1.58479840e-01f, -1.04954652e-01f,
  -7.05124959e-02f, -1.19049214e-02f, 1.78661384e-02f, -1.48170777e-02f, 6.50639832e-02f, 7.14666396e-02f, 1.61204822e-02f, 1.98708445e-01f, 1.77173629e-01f, 5.62965125e-02f,
  -1.10627726e-01f, 2.52356511e-02f, 1.09346107e-01f, -1.03142466e-02f, -7.74814710e-02f, 1.61311757e-02f, 7.92312063e-03f, -6.51405454e-02f, -7.61194825e-02f, -1.41616076e-01f,
  5.27521931e-02f, 3.00595351e-02f, 1.20713800e-01f, -8.02620798e-02f, -1.54533654e-01f, 2.61495784e-02f, 4.75543328e-02f, -6.60820603e-02f, -8.97070840e-02f, 6.02508560e-02f,
  -9.23636332e-02f, 5.65328519e-04f, -1.15019351e-01f, -1.05571158e-01f, -1.67726516e-03f, 3.69608328e-02f, -1.46536127e-01f, -1.51230199e-02f, 7.68789649e-02f, -1.06101908e-01f,
  -2.57084742e-02f, -4.65980470e-02f, 2.37066988e-02f, -3.27622592e-02f, -1.13437576e-02f, 1.37407750e-01f, -1.12214468e-01f, -3.17860357e-02f, 1.02815866e-01f, 4.11005877e-02f,
  5.91450036e-02f, 5.87943979e-02f, 1.33422494e-01f, -4.18103077e-02f, 6.28043190e-02f, 5.34017906e-02f, 2.68150698e-02f, 5.82337044e-02f, 8.49328265e-02f, -1.27734020e-01f,
  -4.09637354e-02f, 1.20770402e-01f, 5.52279390e-02f, -4.00124006e-02f, -3.18623800e-03f, 4.59920354e-02f, 1.33477114e-02f, 1.56380963e-02f, -3.02229263e-02f, 8.22256207e-02f,
  -7.68894106e-02f, -5.23749404e-02f, -7.91354179e-02f, -1.19841717e-01f, -1.19481131e-01f, -2.73807179e-02f, 2.91936323e-02f, -2.59875953e-02f, -4.96348552e-02f, -5.91026992e-02f,
  -5.45933172e-02f, 2.38014776e-02f, 1.26666933e-01f, -5.15177920e-02f, -8.53092596e-03f, -7.70457834e-02f, 8.00726712e-02f, 2.11488735e-02f, -1.16776899e-01f, 4.91300486e-02f,
  -7.81723484e-02f, 4.11165617e-02f, -3.40709947e-02f, -4.23451588e-02f, -2.90060584e-02f, 6.08919337e-02f, -1.45216793e-01f, 8.54439512e-02f, 5.84320910e-03f, -1.51229635e-01f,
  -1.80444777e-01f, 9.93831009e-02f, 2.10271835e-01f, 2.40952559e-02f, 1.19499326e-01f, 2.00328112e-01f, 6.79717511e-02f, -7.57951383e-03f, 1.28599241e-01f, 9.22995582e-02f,
  2.32002258e-01f, -2.79280454e-01f, -1.65173814e-01f, 2.69174203e-02f, -5.84561639e-02f, -1.22594781e-01f, -2.50585079e-01f, 9.24888253e-03f, 6.04216941e-02f, -1.91817760e-01f,
  2.43712123e-02f, 1.62058428e-01f, 1.62791401e-01f, 9.77599844e-02f, 1.01542763e-01f, -2.63299793e-01f, -2.42434084e-01f, 1.82569935e-03f, 2.45289221e-01f, -1.62552893e-02f,
  -5.33261858e-02f, 4.49625403e-02f, 1.43406674e-01f, 3.39677818e-02f, -1.98942706e-01f, -1.50434077e-01f, -1.52146220e-01f, -5.96275181e-02f, -1.73362285e-01f, -3.27347398e-01f,
  -7.67949820e-02f, 1.07748181e-01f, 3.20004225e-02f, 6.43570945e-02f, -1.68513786e-02f, 1.69393402e-02f, -1.64459854e-01f, -3.46626043e-02f, 8.06784723e-03f, -1.60395596e-02f,
  -2.61066239e-02f, -1.14739668e-02f, 8.53408426e-02f, 7.09503368e-02f, -3.10878251e-02f, 1.69535309e-01f, -1.80180445e-02f, 7.79564381e-02f, 7.36382231e-02f, 5.96040115e-02f,
  -1.21570900e-01f, 1.05673254e-01f, 9.34079587e-02f, -1.22898640e-02f, 4.03717831e-02f, 2.16094926e-02f, -1.22655123e-01f, -2.75952108e-02f, 1.84090212e-02f, -4.03975189e-01f,
  -2.34258771e-02f, -8.86410996e-02f, -6.61287457e-03f, 1.65093541e-02f, -5.05971350e-03f, 1.09526962e-01f, -4.78691123e-02f, 5.46783842e-02f, 5.10595180e-02f, -3.72351408e-02f,
  6.05433993e-02f, 1.19151929e-02f, -3.84232178e-02f, -1.47187263e-02f, 7.80269578e-02f, -2.11897660e-02f, 9.57479104e-02f, 3.47502679e-02f, -5.89174107e-02f, 4.83870320e-02f,
  -1.75863970e-02f, 5.37572093e-02f, -5.08539788e-02f, 1.05194867e-01f, -4.33757976e-02f, 4.65276726e-02f, 3.21061499e-02f, -9.88342427e-03f, 2.50863992e-02f, -1.23978034e-01f,
  7.10280687e-02f, 1.28316030e-01f, -3.87017578e-02f, 1.48827070e-02f, 4.60354052e-02f, -7.82735944e-02f, -1.34125277e-01f, -4.41878103e-02f, -5.21882474e-02f, 2.61292537e-03f,
  1.22500882e-01f, -1.36891529e-01f, -1.69623960e-02f, 5.50804362e-02f, 2.21654829e-02f, 4.80895042e-02f, -1.28195554e-01f, 8.98060203e-02f, 8.04353729e-02f, -1.42178848e-01f,
  -1.18539773e-01f, 3.49799134e-02f, 1.43549040e-01f, -5.14742499e-03f, -1.06583849e-01f, -3.85092236e-02f, -9.26296115e-02f, -6.29412830e-02f, -5.46045229e-02f, -4.11706656e-01f,
  -2.49318898e-01f, 2.33901411e-01f, 1.51381090e-01f, -5.53504340e-02f, -2.78847432e-03f, 4.80961092e-02f, 1.16366200e-01f, 7.54352147e-03f, -1.78002298e-01f, 6.09887429e-02f,
  2.04364657e-02f, -1.17260888e-01f, -1.13802887e-01f, -2.13244669e-02f, 9.25109312e-02f, 1.69234902e-01f, 2.05532610e-01f, -1.66974403e-02f, 3.57284397e-02f, 2.61857267e-02f,
  1.03662536e-01f, -1.08464986e-01f, -1.14045262e-01f, -8.57990533e-02f, 8.47068876e-02f, 3.06167034e-03f, 1.63543489e-04f, -7.50924647e-03f, 3.65981683e-02f, 2.17306212e-01f,
  -9.65507999e-02f, -1.00302234e-01f, -4.11416292e-02f, -3.12921107e-02f, -4.94909249e-02f, 1.21430857e-02f, 3.15368399e-02f, -9.68131870e-02f, 7.07457680e-03f, 3.92244048e-02f,
  -3.07163056e-02f, 6.10795319e-02f, 3.64101566e-02f, -6.43479498e-03f, -1.44243926e-01f, -2.25322042e-02f, -2.01360211e-02f, 2.03722082e-02f, -3.45639922e-02f, -1.95296239e-02f,
  1.67716011e-01f, -8.20412487e-02f, -5.80767170e-02f, 1.40207168e-02f, -1.54780317e-02f, -7.67472908e-02f, -6.36382401e-02f, -6.73042983e-02f, -7.54528865e-02f, -8.71729478e-02f,
  -2.13543121e-02f, 7.55005563e-03f, -2.65182368e-03f, 1.16241522e-01f, 5.75192161e-02f, 4.82176729e-02f, 3.33254896e-02f, 1.00528011e-02f, 3.79270911e-02f, 5.36044575e-02f,
  7.41610229e-02f, -4.81976606e-02f, -6.12802617e-02f, -1.21599510e-02f, -2.40529981e-02f, 1.02143437e-02f, 1.14220999e-01f, 9.23007354e-02f, -1.96985807e-02f, 4.13245149e-03f,
  5.34553342e-02f, 7.55066499e-02f, 1.01854978e-03f, 3.08910348e-02f, 6.29805326e-02f, 7.88873062e-03f, -2.87323967e-02f, -7.02788029e-03f, 1.01117929e-02f, -4.22451384e-02f,
  -2.50372618e-01f, 9.65740997e-03f, -1.42188698e-01f, -2.35386603e-02f, -1.51330819e-02f, -1.97158512e-02f, -7.68593773e-02f, -4.48937081e-02f, -4.20675948e-02f, -9.16426554e-02f,
  -2.08600820e-03f, -9.20558646e-02f, -1.06337309e-01f, 5.50840981e-02f, -5.71461916e-02f, 1.32214976e-03f, -2.85050534e-02f, 1.02908909e-01f, -7.61689693e-02f, -7.31947199e-02f,
  1.58284865e-02f, -1.11039013e-01f, -2.16911092e-01f, 7.45700207e-03f, -8.65411982e-02f, -2.58347780e-01f, -1.45484045e-01f, -1.62458479e-01f, -2.42078707e-01f, -2.26805463e-01f,
  -1.07932039e-01f, -3.39929134e-01f, -8.12461674e-02f, -3.75610739e-02f, -3.43934372e-02f, -6.67375103e-02f, -2.49008402e-01f, 1.08628616e-01f, 1.22500435e-01f, -9.34458822e-02f,
  4.10103612e-02f, 9.24188644e-02f, 5.66527620e-03f, 5.64085646e-03f, -1.06668361e-01f, -2.50464708e-01f, -1.14296652e-01f, -4.56774458e-02f, 2.49605015e-01f, 1.61769420e-01f,
  1.39791116e-01f, 5.14004193e-02f, 1.31363511e-01f, 7.24717900e-02f, -2.26553846e-02f, -6.73515573e-02f, -1.30620524e-01f, -7.33901709e-02f, -1.01773895e-01f, -3.81244093e-01f,
  -2.01436996e-01f, -5.34650199e-02f, 2.71953382e-02f, 3.17277722e-02f, -4.31586429e-02f, -4.88076136e-02f, -1.28300592e-01f, 7.02282116e-02f, 2.53232736e-02f, -3.08464151e-02f,
  2.20256969e-02f, 5.35109313e-04f, -7.03903707e-03f, -2.34450810e-02f, 7.05299079e-02f, 6.43574148e-02f, 6.11355864e-02f, 6.12312071e-02f, -9.16841552e-02f, -1.82820875e-02f,
  -1.39986321e-01f, -1.28038242e-01f, -1.03234254e-01f, -7.21312687e-02f, -3.26551497e-02f, -1.48093253e-02f, -8.32733512e-02f, -6.35524467e-02f, -4.54504080e-02f, -3.32357973e-01f,
  4.62842323e-02f, 3.74724343e-02f, 9.72588453e-03f, -7.94913247e-02f, -5.51744923e-02f, 9.35730189e-02f, 2.84139765e-03f, -3.94916981e-02f, 1.88146401e-02f, 2.10102461e-02f,
  8.43916610e-02f, 6.39864504e-02f, 7.84481242e-02f, 5.05163632e-02f, 6.29853383e-02f, 3.87050211e-02f, 2.03235988e-02f, 2.20585968e-02f, -2.90871058e-02f, -1.30714566e-01f,
  4.95356582e-02f, 1.27246091e-02f, 6.74896780e-03f, -1.30757680e-02f, 3.75789814e-02f, -9.48989671e-03f, 2.22845916e-02f, -2.18472350e-02f, 2.59376094e-02f, -3.61266434e-02f,
  1.15045846e-01f, 4.67226095e-02f, -1.19849280e-01f, 4.28332649e-02f, -7.51932617e-03f, -4.27964702e-02f, -1.05275422e-01f, 6.98733926e-02f, 5.99933900e-02f, -6.35128394e-02f,
  4.78685275e-02f, -1.13752455e-01f, 4.73909527e-02f, 3.76098347e-03f, 6.25492248e-04f, 4.65973355e-02f, -4.28149514e-02f, -9.62865576e-02f, 5.07433042e-02f, -2.84216832e-02f,
  -2.21990384e-02f, -1.04509018e-01f, -8.86627659e-02f, -1.19479805e-01f, -2.77095493e-02f, -2.74478588e-02f, -1.09239243e-01f, -6.35852069e-02f, -1.45092413e-01f, -2.02545732e-01f,
  -1.29132226e-01f, 2.62018163e-02f, -1.41340420e-01f, 2.53303975e-01f, 2.31342301e-01f, -5.18605448e-02f, -1.82494432e-01f, -2.17249900e-01f, 7.03510735e-03f, -3.53015624e-02f,
  -9.03826728e-02f, 5.89522235e-02f, 1.03963614e-01f, 6.11936338e-02f, -1.95599407e-01f, 9.84001905e-02f, 1.70854539e-01f, 6.84576705e-02f, -1.46839604e-01f, 2.49043778e-02f,
  2.26250798e-01f, 1.76024064e-01f, 7.18533769e-02f, 5.79377413e-02f, 2.36156628e-01f, 9.68522429e-02f, -9.21789743e-03f, 5.28808162e-02f, 1.81065530e-01f, 3.69192868e-01f,
  -7.33744577e-02f, -2.15525612e-01f, -8.63334090e-02f, 1.46690905e-01f, -3.06162965e-02f, -1.46155313e-01f, -1.36664152e-01f, -1.27757296e-01f, -1.19528212e-01f, -2.61020684e-03f,
  2.02667806e-02f, 9.36395675e-03f, 1.05467439e-02f, 3.68105099e-02f, -3.79126631e-02f, -1.10948935e-01f, 1.10992156e-02f, -1.54200226e-01f, -2.72989601e-01f, -2.10464880e-01f,
  2.07567886e-01f, 1.40171707e-01f, -9.87595543e-02f, -2.14079082e-01f, -2.65116841e-01f, -1.52719557e-01f, -2.09320486e-01f, -2.03300104e-01f, -2.21805930e-01f, -3.62034179e-02f,
  -5.77205978e-03f, -1.08976409e-01f, 1.67361014e-02f, 2.71305013e-02f, 3.48602571e-02f, 9.23978463e-02f, 1.22819142e-02f, 5.57788461e-02f, 7.90781528e-02f, 1.00144725e-02f,
  -7.43862838e-02f, -7.65051693e-02f, 3.47861126e-02f, -1.50588393e-01f, -4.48701717e-02f, 1.17531316e-02f, 2.42593046e-02f, 4.21131328e-02f, -9.09602828e-03f, -7.81056434e-02f,
  5.70672043e-02f, -1.92227755e-02f, 8.98263976e-02f, 7.02929944e-02f, 6.51953816e-02f, -1.39673129e-02f, -4.14787559e-03f, 7.99726099e-02f, -7.14162737e-02f, 9.93070081e-02f,
  1.88876744e-02f, -7.26842210e-02f, -4.13459577e-02f, -1.74643602e-02f, -5.82744554e-02f, 3.01169325e-02f, -2.36619338e-02f, -2.56992187e-02f, -5.74500896e-02f, -1.98855791e-02f,
  -2.13380344e-02f, -7.89687112e-02f, -3.08394954e-02f, -5.69744296e-02f, -3.63314115e-02f, 1.12446673e-01f, 1.70978725e-01f, 6.07673191e-02f, -7.22189918e-02f, -4.56407182e-02f,
  9.05075818e-02f, 7.22837895e-02f, -6.14587888e-02f, -7.07372352e-02f, -6.49405271e-02f, -6.05159439e-02f, -2.05782391e-02f, 3.55111249e-02f, -1.18277885e-01f, -5.61822206e-04f,
  -5.42556465e-01f, -1.34157360e-01f, 2.36663520e-01f, -1.28128797e-01f, 6.44235536e-02f, 1.17816396e-01f, 2.93589860e-01f, 2.94131674e-02f, -4.40044850e-02f, 3.11859157e-02f,
  -4.27694060e-02f, -1.01258472e-01f, -9.57097933e-02f, -1.13769859e-01f, 2.89609469e-03f, 1.57978311e-01f, 1.03486367e-01f, -2.20283810e-02f, 5.88564649e-02f, 7.42489323e-02f,
  -9.13949460e-02f, 4.11388054e-02f, -1.63721725e-01f, -3.55135687e-02f, -1.09738737e-01f, -2.98616830e-02f, -2.31524277e-02f, -3.04016750e-02f, -1.24796927e-01f, 5.40815555e-02f,
  3.61078262e-01f, -2.84987211e-01f, -3.33348550e-02f, -1.75943896e-01f, 1.98024642e-02f, -1.82504907e-01f, -4.52507548e-02f, 6.83256164e-02f, -1.03169106e-01f, 3.20460871e-02f,
  -6.09703735e-02f, 1.56905279e-02f, -1.30495608e-01f, -1.61453579e-02f, 8.79647397e-03f, 5.37617505e-02f, -8.90754685e-02f, 3.07706762e-02f, -3.58346216e-02f, 8.22931007e-02f,
  -4.22068778e-03f, -2.91475672e-02f, 1.30586088e-01f, -4.37089279e-02f, -1.24008387e-01f, -1.08523451e-01f, 5.39567880e-02f, -9.23961215e-03f, -5.44208698e-02f, 1.08018778e-02f,
  7.07504526e-02f, 8.49091448e-03f, -1.07039727e-01f, 6.43919632e-02f, -1.46018624e-01f, -4.48565707e-02f, 7.04636574e-02f, 1.07050613e-01f, -9.05241072e-03f, 5.18481387e-03f,
  4.40902375e-02f, 1.23807251e-01f, 7.02514946e-02f, 9.25697386e-02f, -2.69339085e-02f, 2.57053152e-02f, 2.43876479e-03f, -3.75136323e-02f, -7.43306577e-02f, -1.17917679e-01f,
  -9.40490216e-02f, 7.97627643e-02f, 8.08992311e-02f, 3.33136246e-02f, 6.87152371e-02f, -6.53409879e-05f, 3.73494029e-02f, -6.67873770e-02f, -9.20019671e-02f, -4.48059291e-02f,
  3.04472923e-01f, -1.53836280e-01f, -2.41711270e-02f, 7.86547922e-03f, 3.79471220e-02f, -7.74032921e-02f, -1.19315073e-01f, 8.00851136e-02f, -9.98650212e-03f, 7.55828172e-02f,
  -4.79475632e-02f, -3.99664827e-02f, 6.41580969e-02f, -1.61208343e-02f, 1.04101032e-01f, 7.72672296e-02f, -3.65441218e-02f, 1.53879315e-01f, 1.41962901e-01f, 1.23986349e-01f,
  4.96106446e-02f, 5.36506101e-02f, 1.83489770e-01f, 1.81200072e-01f, 7.15783387e-02f, 1.06718250e-01f, 2.31312230e-01f, 3.78614105e-02f, 1.84325352e-01f, 2.35294968e-01f,
  2.67851174e-01f, -1.94346786e-01f, -4.97037843e-02f, 2.02698484e-01f, 1.36988923e-01f, 1.00444838e-01f, 2.91019538e-03f, 2.04944909e-01f, 2.37404808e-01f, 6.10481128e-02f,
  1.18873501e-02f, 1.31529480e-01f, 1.64782614e-01f, 1.98103208e-02f, 4.16736193e-02f, -1.53478235e-01f, -1.31611630e-01f, 6.94684982e-02f, 7.11870119e-02f, 1.85397491e-01f,
  7.60469437e-02f, 9.16221440e-02f, 1.84075497e-02f, -1.29563445e-02f, -1.54111013e-01f, 6.45731017e-02f, -1.16038561e-01f, -1.32841155e-01f, -1.87154040e-01f, -3.00796658e-01f,
  -2.07635805e-01f, -1.54920176e-01f, 2.41189878e-02f, 1.77645665e-02f, -5.31826280e-02f, -5.79184759e-03f, 8.62926245e-02f, -1.12886123e-01f, -6.07905127e-02f, -4.03477401e-02f,
  1.01751834e-02f, 1.77044086e-02f, -4.35349420e-02f, 1.20970951e-02f, -7.90318996e-02f, -4.26013730e-02f, -1.33945391e-01f, -4.74298000e-02f, -8.68467465e-02f, -2.13967360e-04f,
  -7.30593279e-02f, -1.70648992e-02f, -1.11326352e-02f, 2.89264843e-02f, 3.58661599e-02f, 4.15837904e-03f, -7.69260153e-02f, 2.26113480e-02f, -6.39633536e-02f, -3.94195598e-03f,
  1.55999303e-01f, 5.48205040e-02f, -4.29700613e-02f, -8.32481906e-02f, -2.74194349e-02f, -4.92188297e-02f, -6.55160472e-02f, -1.52486205e-01f, -7.42126033e-02f, -4.71539795e-02f,
  5.11446968e-02f, 6.26337109e-03f, -3.53378654e-02f, 7.79346079e-02f, 4.54423809e-03f, -4.93167676e-02f, -2.18193512e-02f, 1.26867518e-02f, 1.80388540e-02f, 5.24138147e-03f,
  -8.01725984e-02f, -2.41647959e-02f, -1.05504822e-02f, -8.97492692e-02f, 3.50051112e-02f, 7.19554424e-02f, 7.77876452e-02f, -4.34561484e-02f, -9.03693065e-02f, 2.70849019e-02f,
  -6.55542612e-02f, 1.26751229e-01f, -3.21451500e-02f, -1.47078142e-01f, -8.58670771e-02f, 8.09440836e-02f, 1.08025447e-01f, -6.68171421e-02f, -8.09427798e-02f, 4.65621389e-02f,
  -7.06217438e-02f, 7.64268413e-02f, -2.30471790e-02f, -6.55852780e-02f, -1.86811220e-02f, 9.49275494e-03f, -1.20075397e-01f, -3.54000479e-02f, -2.68716253e-02f, 1.64592657e-02f,
  -3.98107283e-02f, 8.15379769e-02f, 1.01252668e-01f, 7.78842419e-02f, 2.53971219e-02f, 9.92623344e-02f, -8.81911218e-02f, 5.77938966e-02f, 1.04665205e-01f, 5.09258434e-02f,
  -2.61081785e-01f, 3.77271809e-02f, 1.95435792e-01f, 4.68993634e-02f, 1.81554884e-01f, 1.40180730e-03f, -1.58897907e-01f, -2.13465676e-01f, -8.09848215e-03f, 7.11789280e-02f,
  6.54860660e-02f, -5.34920662e-04f, 7.25915954e-02f, -1.98944271e-01f, -3.75166595e-01f, -1.43915405e-02f, -7.60335252e-02f, -2.52693772e-01f, -3.09688479e-01f, -3.42231423e-01f,
  -4.19053361e-02f, -7.27051571e-02f, -2.73162812e-01f, -1.57966465e-01f, 1.72387645e-01f, 6.86608702e-02f, 1.76710039e-01f, 7.91439414e-03f, 7.78396949e-02f, 2.63043463e-01f,
  1.39041901e-01f, 4.03457209e-02f, -5.28201647e-02f, -1.13296993e-01f, 1.48053095e-01f, -1.21031798e-01f, -8.08861256e-02f, 5.61288409e-02f, -3.65231596e-02f, 4.58745658e-03f,
  2.34966036e-02f, -8.32944289e-02f, 8.78146291e-03f, -3.99001874e-02f, -8.04196745e-02f, -1.84536830e-01f, -1.73434585e-01f, -1.41879186e-01f, 1.02213152e-01f, -1.44763753e-01f,
  -4.81326878e-02f, -5.51947765e-02f, 1.19535448e-02f, -2.22124178e-02f, 5.60144000e-02f, 1.91018474e-03f, 6.03893064e-02f, 8.44348520e-02f, 5.86827099e-02f, 2.36999616e-01f,
  -4.52841558e-02f, 1.90536920e-02f, 1.47634625e-01f, 4.64747846e-03f, -2.28043441e-02f, 4.11118865e-02f, 3.88525724e-02f, 1.27665494e-02f, 7.84363076e-02f, -1.04076415e-01f,
  1.12379186e-01f, 5.99060729e-02f, 6.65024072e-02f, 6.91549778e-02f, 4.85225171e-02f, 1.87220462e-02f, 6.92268461e-02f, -2.15244275e-02f, 5.92995249e-02f, 5.14418483e-02f,
  -3.66356634e-02f, 6.82705119e-02f, 6.76236376e-02f, -3.79353762e-02f, -3.81747261e-02f, 2.27046125e-02f, 1.12867042e-01f, -7.62237906e-02f, -9.55263432e-03f, -6.69714883e-02f,
  5.89169152e-02f, -4.10766527e-02f, 1.00585170e-01f, -1.10045865e-01f, 4.57698442e-02f, 3.88625003e-02f, 1.46911353e-01f, 4.66626063e-02f, 8.34632292e-02f, -2.98757367e-02f,
  -7.74374902e-02f, 3.28387581e-02f, 8.58043693e-03f, -1.02110706e-01f, -1.97593272e-01f, -8.84300098e-02f, -1.93167441e-02f, 5.49124964e-02f, -6.44708052e-02f, 2.06010193e-02f,
  -9.93949100e-02f, -1.90833792e-01f, -7.69854933e-02f, 8.79733041e-02f, 8.85055289e-02f, -1.43365078e-02f, 7.82234222e-02f, 2.86140740e-02f, -8.01212415e-02f, 8.20394680e-02f,
  -3.82670909e-01f, 1.36261508e-01f, -9.75858122e-02f, -1.67580917e-01f, 1.76392049e-01f, 1.22170702e-01f, 1.29644215e-01f, 8.52361098e-02f, 8.26955512e-02f, 1.88246854e-02f,
  9.08921733e-02f, -2.70326808e-02f, -2.43480243e-02f, 6.72753230e-02f, -5.48251644e-02f, 1.95623979e-01f, 1.94171339e-01f, -1.17941856e-01f, -2.25664958e-01f, -1.78066769e-03f,
  1.68472141e-01f, -5.15573323e-02f, -2.89788604e-01f, -1.66633293e-01f, 8.85759387e-03f, 7.52928406e-02f, -1.61134023e-02f, 2.50083804e-02f, 7.70934597e-02f, 1.87215239e-01f,
  -1.82577655e-01f, -1.26608461e-01f, 1.29540578e-01f, 2.07446255e-02f, 3.28055769e-02f, -1.01368673e-01f, -3.86609994e-02f, 2.81917900e-02f, 1.08164072e-01f, -1.58016998e-02f,
  6.01818264e-02f, -6.19720947e-03f, 6.51024282e-02f, 1.26761850e-02f, -2.03380272e-01f, -2.08429247e-01f, -4.02125306e-02f, -2.62365311e-01f, -2.31965527e-01f, -1.91961959e-01f,
  2.62209296e-01f, -4.71296124e-02f, -1.65377080e-01f, -2.58059334e-02f, -9.73256603e-02f, -1.39777541e-01f, -7.22495764e-02f, -1.46987543e-01f, -1.43588036e-01f, -1.57250613e-01f,
  -1.12990674e-03f, 3.66397947e-02f, 5.55818714e-02f, 5.19645624e-02f, -1.19260065e-02f, 1.24855861e-01f, 4.00720835e-02f, 1.04361996e-01f, 4.26764823e-02f, -4.00695428e-02f,
  -3.47833112e-02f, -3.71175781e-02f, -6.78966343e-02f, -5.94648719e-02f, -1.61857754e-02f, 5.18698171e-02f, 1.95167214e-02f, -1.37388548e-02f, -5.92768602e-02f, 2.15670764e-02f,
  -3.02481391e-02f, 6.42742217e-03f, 2.68454812e-02f, -6.58562183e-02f, -1.61040947e-02f, 5.95293287e-03f, 3.16973217e-03f, 1.14397705e-02f, -2.88728513e-02f, 6.95648557e-03f,
  -1.65653497e-01f, 9.24385414e-02f, 4.32330696e-03f, 6.40079007e-02f, 2.71183569e-02f, -3.13026197e-02f, 1.29882032e-02f, -3.42407227e-02f, -1.02960067e-02f, -3.66905890e-02f,
  -5.02466187e-02f, -6.71330020e-02f, -7.51762241e-02f, 3.80742624e-02f, -7.79215246e-02f, -5.89240193e-02f, 2.01646965e-02f, -3.39365825e-02f, -1.43273780e-02f, -7.98841491e-02f,
  1.83996707e-02f, -1.53097376e-01f, -2.24025264e-01f, -1.44199859e-02f, -1.32820383e-01f, -1.37166977e-01f, -1.23791181e-01f, -3.46237794e-02f, -2.75315326e-02f, -1.32217526e-01f,
  -7.49058425e-01f, -1.48582011e-01f, 1.04174521e-02f, -2.69952178e-01f, 4.09622528e-02f, 1.16726726e-01f, 1.49388731e-01f, -3.12999147e-03f, -8.42821319e-03f, 5.99851571e-02f,
  1.51146157e-02f, -3.33478600e-02f, 3.13659348e-02f, 6.62570223e-02f, 9.60134864e-02f, 1.94200315e-02f, 5.35874292e-02f, 6.60255849e-02f, 5.39786033e-02f, 1.13041643e-02f,
  8.51037577e-02f, -1.83130234e-01f, -1.73742235e-01f, -9.62107480e-02f, -8.24322701e-02f, -2.69923117e-02f, -7.77992606e-02f, -5.98741286e-02f, -8.26222524e-02f, -1.64235115e-01f,
  3.66071194e-01f, -5.74903451e-02f, 1.80552248e-02f, -4.49440256e-03f, -1.16633959e-01f, -2.23875605e-02f, -4.69382778e-02f, 6.54440075e-02f, -6.93293288e-02f, 7.23549873e-02f,
  1.15270160e-01f, 4.20579277e-02f, 5.38077056e-02f, -2.84738131e-02f, -8.05159751e-03f, -8.17123521e-03f, 2.27387547e-02f, 6.03791252e-02f, 4.73898165e-02f, 7.75243789e-02f,
  -3.22751254e-02f, -3.45433466e-02f, 4.52232622e-02f, 7.86719322e-02f, -1.83453260e-03f, 1.29940048e-01f, 2.80725677e-02f, 8.47457349e-02f, -4.08821143e-02f, 1.34215383e-02f,
  1.12986192e-01f, -2.29683798e-02f, -1.29233956e-01f, 9.04401839e-02f, -4.47583199e-02f, -7.15408102e-02f, 1.74147692e-02f, -3.77243594e-03f, 2.67180172e-03f, -1.19154342e-01f,
  -5.99352084e-02f, -1.55384578e-02f, 6.35294616e-02f, -3.65572125e-02f, 3.03238034e-02f, -5.23206145e-02f, -3.55060510e-02f, 1.27082951e-02f, 2.74515618e-02f, -3.39715667e-02f,
  -9.46791321e-02f, -6.22074902e-02f, 5.54923294e-03f, 1.02563478e-01f, 5.45800738e-02f, -5.93216345e-02f, 5.30547872e-02f, 1.84936076e-03f, -1.25311101e-02f, -1.71227555e-03f,
  3.00004333e-01f, -5.41477129e-02f, -1.12962071e-02f, -6.50011152e-02f, -2.91437302e-02f, -9.58357453e-02f, -1.55694112e-01f, -4.11918908e-02f, 7.49435425e-02f, 1.38473153e-01f,
  -3.42752077e-02f, 9.96240750e-02f, -1.27718858e-02f, -9.87662226e-02f, 8.95909965e-02f, 1.57927927e-02f, 1.47748841e-02f, -6.96260482e-02f, 1.15808509e-01f, 6.28056452e-02f,
  7.49376714e-02f, 1.69342533e-01f, 1.72144443e-01f, 1.82891652e-01f, 3.34947207e-03f, 9.76386890e-02f, 6.17560707e-02f, 1.33306071e-01f, 1.00513212e-01f, 4.60909158e-02f,
  4.77456182e-01f, 3.34362954e-01f, 2.57270839e-02f, -3.08500826e-02f, -2.48074881e-03f, -1.11254370e-02f, 1.92458645e-01f, 7.31438324e-02f, 8.06578621e-02f, 1.68561995e-01f,
  -4.56154123e-02f, -7.85176605e-02f, -1.50861338e-01f, -1.94160208e-01f, -3.54227088e-02f, 1.31012917e-01f, 3.67544629e-02f, -3.36091705e-02f, 8.59334767e-02f, 9.85103697e-02f,
  2.50761360e-02f, 8.00987035e-02f, 1.16508551e-01f, 9.98475254e-02f, 2.09801979e-02f, -4.43327390e-02f, 2.77199019e-02f, 3.39263901e-02f, 2.80505046e-02f, 8.58652294e-02f,
  -2.28527293e-01f, 1.35013998e-01f, -1.76745564e-01f, -8.61114450e-03f, -7.41073787e-02f, 8.31228644e-02f, -1.00050278e-01f, -6.20424096e-03f, -6.67484924e-02f, -2.66499259e-02f,
  6.93634078e-02f, 6.37551919e-02f, -1.18119910e-01f, -5.45398891e-02f, 2.57550497e-02f, 3.85938631e-03f, -2.15095170e-02f, 1.11823909e-01f, -4.12416980e-02f, -1.39471695e-01f,
  -1.23312004e-01f, -6.63130432e-02f, 1.16593372e-02f, -1.34081975e-01f, -1.41136989e-01f, -4.92227264e-02f, -3.29961255e-02f, -5.25793768e-02f, -1.21560670e-01f, 1.18770607e-01f,
  -2.11967543e-01f, 5.64539246e-02f, -1.56934500e-01f, -2.08145007e-01f, -1.45181701e-01f, -1.31552219e-01f, -1.58057902e-02f, 3.46074030e-02f, -1.53215945e-01f, 2.30596010e-02f,
  -5.54029644e-02f, -1.64773867e-01f, -2.03830883e-01f, -1.07054515e-02f, -2.25471243e-01f, 1.21435234e-02f, -1.04053780e-01f, -1.63605496e-01f, -2.46116936e-01f, -1.27800316e-01f,
  -1.53236613e-01f, 4.86502647e-02f, -3.60838026e-02f, -1.87198684e-01f, -4.97454070e-02f, -1.80915147e-01f, -1.73491240e-01f, -3.60186733e-02f, -3.95690203e-02f, 1.93883348e-02f,
  -3.29360694e-01f, -4.25643563e-01f, -6.34655952e-02f, 6.27726987e-02f, 5.31319156e-02f, -2.04910729e-02f, -1.50495619e-01f, -4.03818749e-02f, 5.55893183e-02f, -5.18023372e-02f,
  1.25745833e-01f, 7.89483264e-02f, -4.52556945e-02f, -8.20300281e-02f, 4.50570434e-02f, -2.91029699e-02f, -2.93907952e-02f, 7.33029097e-03f, 6.82848170e-02f, 8.18768740e-02f,
  1.67306885e-02f, 6.01321738e-03f, 3.94578725e-02f, 3.86871747e-03f, -7.14688227e-02f, 2.28788219e-02f, -4.13016006e-02f, 1.22079164e-01f, -4.99787517e-02f, 1.83232725e-01f,
  6.25274852e-02f, 3.45720984e-02f, 2.54232675e-01f, 6.79011177e-03f, 2.63227105e-01f, 3.62894058e-01f, 3.04482937e-01f, 2.70223558e-01f, -8.48588124e-02f, 3.56580168e-02f,
  4.94818166e-02f, -2.02590838e-01f, -2.63096333e-01f, -1.67696536e-01f, -5.94435493e-03f, 1.01001738e-02f, 9.94186029e-02f, -1.88613683e-02f, 1.93116739e-01f, 2.78640147e-02f,
  -2.36695027e-03f, 1.11346036e-01f, 2.62114238e-02f, -7.80483559e-02f, -1.02828838e-01f, -6.63691238e-02f, 6.79691508e-02f, 1.37918014e-02f, -6.90075336e-03f, -3.56237859e-01f,
  -2.47493058e-01f, 1.95974737e-01f, -1.32206276e-01f, -6.64606169e-02f, -9.36979949e-02f, -6.60688207e-02f, -1.01131968e-01f, -2.97256764e-02f, 8.62308964e-02f, -5.29070757e-02f,
  -9.43173319e-02f, -3.10309324e-02f, 7.06406776e-03f, 6.92583295e-03f, -2.09476240e-02f, -2.39437562e-03f, -1.03804125e-02f, -2.58707092e-03f, -2.48318035e-02f, -5.81977144e-02f,
  -5.22649195e-03f, 4.40015011e-02f, 1.90719932e-01f, 7.12368265e-03f, 4.39414307e-02f, -1.17845528e-01f, 2.45848112e-02f, -1.01534892e-02f, 4.79574017e-02f, -4.24477048e-02f,
  -9.90332067e-02f, -2.09603962e-02f, -2.78887469e-02f, -8.78946949e-03f, 3.67450044e-02f, 5.80190681e-02f, 6.65530488e-02f, 7.11456463e-02f, 1.47164296e-02f, 8.58362392e-03f,
  2.95955744e-02f, 4.89623770e-02f, 1.26086980e-01f, -1.49282515e-02f, 5.88946417e-02f, 1.03866667e-01f, 5.26167545e-03f, 5.94531000e-02f, 2.46595666e-02f, -6.64823409e-03f,
  7.28888512e-02f, 9.00337175e-02f, 3.98113346e-03f, 1.01007618e-01f, -2.11393200e-02f, 7.39379004e-02f, 3.89809608e-02f, 1.92470942e-03f, 5.24228849e-02f, 6.57207146e-02f,
  -6.00741850e-03f, 1.87310874e-01f, -2.23004535e-01f, -1.55770615e-01f, 7.37414435e-02f, 9.66444239e-02f, 5.18953661e-03f, -9.39748362e-02f, 1.79808773e-02f, -6.88484237e-02f,
  3.09071969e-02f, 3.31335329e-02f, 4.17718180e-02f, 1.61475793e-01f, 8.34748149e-02f, 3.12672295e-02f, 3.79853360e-02f, -1.09731276e-02f, -6.35185391e-02f, -4.75660479e-03f,
  -2.41642594e-02f, 1.01098582e-01f, 6.35079518e-02f, 1.17054731e-01f, 3.59717906e-02f, -9.34982225e-02f, 6.97266012e-02f, 7.54199177e-02f, -2.27063019e-02f, -3.79011706e-02f,
  -3.51681560e-01f, -4.20315133e-04f, 4.75206673e-02f, 1.01921566e-01f, 8.41285586e-02f, 4.96105365e-02f, -8.93047377e-02f, -3.82382865e-03f, 1.64152890e-01f, 1.87920090e-02f,
  1.14405930e-01f, 1.32887915e-01f, 1.04587227e-01f, -1.35496482e-02f, -2.08537281e-01f, -2.46617928e-01f, -7.66585693e-02f, -1.19229928e-01f, -4.33682166e-02f, -7.24278390e-02f,
  9.33110267e-02f, -6.70560673e-02f, -7.41746500e-02f, -6.66882396e-02f, -1.22242875e-01f, -1.24001943e-01f, -1.18898325e-01f, -7.90120065e-02f, -1.95585266e-01f, -2.26059034e-01f,
  -1.17891155e-01f, -1.66354072e-03f, 4.40845080e-02f, -3.33164148e-02f, 3.98498913e-03f, 2.10641846e-02f, 9.51937400e-03f, 1.15375286e-02f, 1.22045249e-01f, 1.87912375e-01f,
  2.16996428e-02f, 3.75603959e-02f, 7.84816518e-02f, 1.00237913e-01f, 4.56961691e-02f, 1.09052852e-01f, 1.18212178e-01f, -6.06017523e-02f, -5.20897796e-03f, 1.15921848e-01f,
  1.44853398e-01f, 1.05357908e-01f, 1.00854933e-02f, -3.38067189e-02f, -3.54877338e-02f, 8.24957862e-02f, -6.14298843e-02f, -1.42379582e-01f, -1.81995168e-01f, -3.21182072e-01f,
  1.35119736e-01f, -4.66729440e-02f, -2.76280288e-02f, -9.37690139e-02f, -7.87007585e-02f, 8.24430808e-02f, -7.78042153e-02f, -5.69173656e-02f, -9.70169678e-02f, -9.79914218e-02f,
  1.02665804e-01f, -2.37293206e-02f, -1.17709331e-01f, -1.87029496e-01f, -4.77667600e-02f, 6.56902939e-02f, -1.49386957e-01f, -1.50226057e-01f, -2.28923894e-02f, -8.31393898e-02f,
  -3.94139215e-02f, -1.43928407e-02f, 8.13884009e-03f, -1.35350108e-01f, -7.32032880e-02f, -1.49672374e-01f, 9.79523584e-02f, 4.11871038e-02f, 1.38109848e-01f, 9.74501073e-02f,
  -5.28907515e-02f, -1.33770794e-01f, -2.08707899e-01f, 1.80102664e-03f, -7.36151561e-02f, 4.69385795e-02f, -6.25174399e-03f, 2.47140811e-03f, -3.82496566e-02f, -3.84009979e-03f,
  -6.39128089e-02f, -1.42978579e-01f, -1.24659305e-02f, 7.38197193e-02f, 1.64205879e-02f, 1.94441285e-02f, 9.16222949e-03f, -2.96636503e-02f, -1.49718136e-01f, 1.58354640e-01f,
  1.43324360e-01f, -1.04898512e-01f, -9.34222993e-03f, -1.01644382e-01f, -4.71638516e-02f, -6.59146309e-02f, -1.60017274e-02f, -9.65500399e-02f, -2.77681679e-01f, -2.83509135e-01f,
  3.37099642e-01f, -4.82179299e-02f, -1.95522681e-01f, 8.03935379e-02f, -3.48845690e-01f, -3.46687883e-01f, -2.12208435e-01f, -2.12059207e-02f, 1.19006254e-01f, -6.52319118e-02f,
  -1.94855154e-01f, 9.83445048e-02f, 2.23778561e-01f, -5.19199595e-02f, -3.78457233e-02f, -1.03926063e-02f, -1.55097216e-01f, -1.29878864e-01f, -2.33163431e-01f, -2.07755640e-01f,
  -1.51972368e-01f, 9.44843963e-02f, 1.92385226e-01f, -1.55914742e-02f, -1.85675994e-02f, 1.31781712e-01f, 8.26277882e-02f, -5.02814874e-02f, -3.62717062e-02f, -8.60192403e-02f,
  -6.05437234e-02f, -3.07492372e-02f, -1.81264520e-01f, -7.13700801e-03f, -9.76797640e-02f, 5.73830083e-02f, -8.83890465e-02f, -2.37982143e-02f, -8.62315074e-02f, -6.63651899e-02f,
  -1.18105248e-01f, -6.09149747e-02f, -1.31769568e-01f, -6.08979212e-03f, -1.10656932e-01f, -1.47787213e-01f, -5.49318679e-02f, -1.18243992e-01f, 8.14782307e-02f, -1.83811605e-01f,
  -1.12291776e-01f, -1.14254609e-01f, -6.59391135e-02f, -8.45881552e-02f, -7.22220466e-02f, -5.75738121e-03f, -1.95959300e-01f, -1.27766326e-01f, -1.81689684e-03f, 1.26950026e-01f,
  3.23567837e-02f, 1.51798446e-02f, -2.37568207e-02f, -3.13383751e-02f, -3.12871598e-02f, 4.69894819e-02f, -3.59271765e-02f, -1.19249541e-02f, -5.97270541e-02f, 3.38488296e-02f,
  8.89322311e-02f, -3.15158144e-02f, 4.74918894e-02f, 1.25922933e-01f, 7.70118311e-02f, -2.33905204e-02f, -1.43586670e-03f, 1.62267704e-02f, 4.23656777e-02f, 7.55133554e-02f,
  7.77635947e-02f, -6.51157275e-02f, 1.19950965e-01f, 1.37387976e-01f, 4.11531366e-02f, -6.57533035e-02f, 2.29501836e-02f, -5.47931753e-02f, 4.34631072e-02f, -9.49361548e-03f,
  3.58017653e-01f, -1.53698593e-01f, 1.49054036e-01f, 1.12710847e-02f, -1.45141706e-01f, -8.27066507e-03f, -8.20269659e-02f, -6.83584288e-02f, -8.74437690e-02f, -3.66518681e-04f,
  -1.74323052e-01f, 1.23151746e-02f, 6.18682504e-02f, -8.27730820e-02f, -9.95284021e-02f, -1.35394335e-01f, -4.97810356e-03f, -5.57224751e-02f, 3.46375294e-02f, 7.53054768e-02f,
  1.75477549e-01f, -8.82988125e-02f, 1.92893460e-01f, 1.22489482e-01f, -1.40556553e-02f, -3.90808657e-02f, -3.05640846e-02f, -7.34777749e-02f, 5.98317981e-02f, 3.07068110e-01f,
  -1.90005139e-01f, -1.81233093e-01f, -4.35776561e-01f, -9.98515934e-02f, -2.58444011e-01f, -1.69294626e-01f, -3.08523238e-01f, -5.24982102e-02f, 9.80266184e-02f, -1.91785723e-01f,
  -1.00505300e-01f, 1.79347005e-02f, -8.71288851e-02f, -4.20210212e-02f, -2.31810600e-01f, -2.81615168e-01f, -3.63706201e-01f, -3.97197396e-01f, -2.73386776e-01f, -7.96960369e-02f,
  -1.47298872e-01f, -2.33950596e-02f, 2.82870959e-02f, 5.51677495e-02f, 1.07236952e-01f, -3.99287827e-02f, 1.49663705e-02f, -1.91020183e-02f, -9.63307768e-02f, -2.23270461e-01f,
  -1.34117424e-01f, -8.84240214e-03f, -2.36361455e-02f, 1.10896498e-01f, 9.24843103e-02f, -7.12454692e-02f, -2.34985184e-02f, 9.29854531e-03f, 1.41348049e-01f, 1.18702598e-01f,
  -3.34121808e-02f, 4.31579836e-02f, -2.64548007e-02f, 1.60868868e-01f, 6.49496121e-03f, 1.52928978e-01f, 8.72933045e-02f, 8.00650916e-04f, 9.62842703e-02f, 1.58794478e-01f,
  1.27972782e-01f, 8.10302421e-02f, 5.62291518e-02f, 8.66520256e-02f, 1.82312801e-01f, -3.23428251e-02f, 1.36889562e-01f, 2.00880557e-01f, 8.70736092e-02f, 1.99071556e-01f,
  2.19935309e-02f, 9.94313657e-02f, 9.13482979e-02f, -3.19788195e-02f, 1.47289783e-01f, 1.77958339e-01f, 1.59545019e-02f, -5.90242296e-02f, -5.70439035e-04f, 8.74805003e-02f,
  1.26350403e-01f, 1.83992293e-02f, -7.48720020e-02f, -1.23616112e-02f, 8.40041041e-02f, 1.36131337e-02f, -6.23570122e-02f, -2.08490305e-02f, 1.12220623e-01f, 8.30420405e-02f,
  -1.86280988e-03f, 7.26954043e-02f, 1.68820471e-02f, 6.17301874e-02f, -1.06734738e-01f, 8.26029629e-02f, -1.75997838e-02f, -2.69304831e-02f, -1.54690370e-01f, -7.78656006e-02f,
  1.36515409e-01f, -2.77431279e-01f, -6.82018846e-02f, -4.56287246e-03f, 7.50296190e-03f, 4.93828729e-02f, 1.06618623e-03f, 1.54196387e-02f, -5.82184456e-02f, 1.93795171e-02f,
  -4.73595969e-02f, -2.29363255e-02f, 2.82716844e-02f, 1.01150483e-01f, -5.25164530e-02f, 8.87372270e-02f, 5.70634417e-02f, -1.40521489e-02f, 2.72342153e-02f, 1.86547846e-01f,
  8.92232358e-02f, 1.18897758e-01f, 8.68657082e-02f, 1.05648518e-01f, 1.37193978e-01f, -1.57337248e-01f, 1.12573318e-01f, 7.89696276e-02f, -7.92382360e-02f, 9.40659121e-02f,
  1.84297889e-01f, -1.50787964e-01f, -2.38192365e-01f, -1.88656926e-01f, -1.84771672e-01f, 8.65525305e-02f, -6.19112630e-04f, 4.28400189e-02f, 6.73933234e-03f, -4.20032516e-02f,
  -2.58258730e-01f, -3.04753840e-01f, -3.12820971e-01f, -2.31801316e-01f, 7.03781992e-02f, 1.10241426e-02f, -7.57041350e-02f, -4.19127084e-02f, -8.07454139e-02f, -2.84095528e-03f,
  -5.43164695e-03f, -1.02958724e-01f, -5.12004197e-02f, -1.09939612e-01f, -1.61883175e-01f, -1.50457472e-01f, -2.66935974e-01f, -2.65056282e-01f, -2.84160197e-01f, -3.39404047e-01f,
  -3.23219359e-01f, -2.00503603e-01f, 2.45281644e-02f, 2.15071552e-02f, -7.38923997e-02f, 8.19430035e-03f, -1.28785223e-01f, -9.11929607e-02f, -4.47000265e-02f, 3.60281095e-02f,
  -1.50383279e-01f, -1.29975185e-01f, -7.32845739e-02f, -1.34883285e-01f, 6.94243889e-03f, -6.37757480e-02f, -2.30670013e-02f, -2.76221521e-02f, -1.87411726e-01f, -1.17487788e-01f,
  -9.42050666e-02f, -5.26469648e-02f, 3.68641540e-02f, 1.17394947e-01f, -9.55137238e-02f, 1.83778834e-02f, -1.47297687e-03f, -1.65114850e-01f, -6.51983991e-02f, 2.08084919e-02f,
  7.25832582e-02f, 4.91574965e-02f, 5.39068505e-02f, 1.79027468e-02f, 7.70925656e-02f, 6.54564574e-02f, 6.45501688e-02f, 5.78097813e-02f, 1.18312426e-01f, -1.01421378e-03f,
  1.31644020e-02f, -2.83712223e-02f, -2.50332225e-02f, -1.21260202e-02f, -1.36004105e-01f, -9.15719494e-02f, 1.08067185e-01f, -7.67907454e-03f, -1.53625291e-02f, 1.47120981e-02f,
  -3.64943556e-02f, -8.87555853e-02f, 4.92165871e-02f, 3.27903070e-02f, -3.05020101e-02f, -1.02137648e-01f, -1.04221672e-01f, -6.10902347e-02f, 5.92590757e-02f, 5.86615577e-02f,
  9.32648554e-02f, -2.01591831e-02f, 7.11265504e-02f, -8.58251080e-02f, -1.04290701e-01f, -7.88864419e-02f, -1.19224995e-01f, 2.48746062e-03f, -1.12592764e-02f, -5.47175072e-02f,
  -6.13802411e-02f, 3.62164490e-02f, -1.47152424e-01f, 1.47539387e-02f, 8.39432850e-02f, -4.10094578e-03f, 4.18271422e-02f, 3.10906563e-02f, -4.59702238e-02f, 6.98766336e-02f,
  1.75245553e-01f, 1.77931622e-01f, 2.66602933e-01f, 2.21877769e-01f, 9.89874639e-03f, 8.55303407e-02f, 1.48033872e-01f, 1.59364603e-02f, 2.45965928e-01f, 2.80169755e-01f,
  -2.91156143e-01f, -2.58522600e-01f, 4.25155014e-02f, 8.31673518e-02f, 1.35134935e-01f, 2.56722122e-01f, 1.66020900e-01f, 6.32390752e-02f, -6.48378581e-02f, 2.94693056e-02f,
  -2.46314898e-01f, -1.81956872e-01f, -1.10893548e-01f, -1.51774123e-01f, -5.43303834e-03f, 1.63643315e-01f, 3.39551717e-01f, 1.15575388e-01f, 2.10830688e-01f, 1.99999452e-01f,
  1.71654552e-01f, 1.25396058e-01f, -1.51453108e-01f, -2.26948014e-03f, 1.32673323e-01f, 2.29478367e-02f, -1.66217983e-02f, -1.63945893e-03f, -7.73766935e-02f, 1.15523964e-01f,
  1.96365744e-01f, -3.02000523e-01f, 1.67102646e-02f, -1.44536704e-01f, -1.99329093e-01f, -1.35626420e-01f, -9.17255953e-02f, -1.12845406e-01f, -8.59055147e-02f, 2.05632616e-02f,
  -1.48122162e-01f, 1.80827100e-02f, 7.80479908e-02f, 6.05451129e-02f, 1.20225847e-01f, 2.69112606e-02f, -1.22849941e-01f, -6.85472041e-02f, -8.88633877e-02f, -5.31251691e-02f,
  3.20939049e-02f, -8.96829218e-02f, -8.66124555e-02f, 1.08845778e-01f, -6.48285672e-02f, -8.69592205e-02f, -4.04283553e-02f, -1.31722718e-01f, -4.22421843e-02f, -4.84542958e-02f,
  3.53493914e-02f, -3.20704021e-02f, 4.25508171e-02f, -3.93888243e-02f, -4.17850539e-02f, 1.03375673e-01f, 4.44238558e-02f, 7.20572248e-02f, 5.69285862e-02f, -4.40524071e-02f,
  -1.22073285e-01f, 3.56247611e-02f, -4.05723080e-02f, 1.14624780e-02f, -2.58174464e-02f, 2.56517213e-02f, -7.33194649e-02f, 2.33225413e-02f, -2.08379298e-01f, -1.01091921e-01f,
  -3.37627134e-04f, 3.78419943e-02f, -1.02920860e-01f, -2.44610012e-02f, -3.62776928e-02f, -7.25878105e-02f, 7.82017112e-02f, -1.76101446e-01f, 1.91778354e-02f, -6.66860789e-02f,
  2.34389663e-01f, -3.18015397e-01f, 1.33798391e-01f, 4.21891809e-02f, -4.00662012e-02f, -1.99711293e-01f, -1.86501682e-01f, -6.95735738e-02f, 1.70052201e-02f, -3.09449993e-02f,
  -1.09622493e-01f, -7.44911656e-02f, -3.08196414e-02f, 7.23554417e-02f, 1.23459429e-01f, 3.10301073e-02f, -1.16884306e-01f, 7.60040209e-02f, 3.14934291e-02f, 9.68460292e-02f,
  -7.07413554e-02f, 1.59669727e-01f, 7.68170133e-02f, 2.08957747e-01f, 9.23194587e-02f, 1.17122643e-01f, 1.20667547e-01f, 1.34472132e-01f, 1.14417069e-01f, 2.25509122e-01f,
  4.72926736e-01f, 1.52031839e-01f, 5.38062528e-02f, 6.52967021e-02f, -1.58134818e-01f, -4.10370678e-02f, 4.08814363e-02f, 6.28867149e-02f, 5.54520786e-02f, -6.73915297e-02f,
  -2.53919233e-03f, -4.46080230e-02f, 1.02455340e-01f, -5.38585968e-02f, 5.29088750e-02f, -1.32444113e-01f, -1.37509093e-01f, 1.33846700e-02f, 6.13510469e-03f, -1.09000050e-01f,
  -1.22874171e-01f, -3.80258709e-02f, 1.19970866e-01f, -3.80546898e-02f, -8.29540491e-02f, -3.61121930e-02f, -2.33417507e-02f, -1.15359448e-01f, -1.11185625e-01f, -9.69538838e-02f,
  -9.35317799e-02f, 3.12328339e-01f, 7.16355518e-02f, 7.83961341e-02f, 1.62490770e-01f, 1.71374500e-01f, 1.31579220e-01f, -6.13718070e-02f, -3.03322133e-02f, -1.06246218e-01f,
  -4.77945432e-02f, -7.30287656e-03f, 5.57850190e-02f, -2.78922133e-02f, 2.81647947e-02f, 1.10963518e-02f, 1.08728640e-01f, 2.37738471e-02f, -5.87084889e-02f, -1.47639366e-03f,
  -2.93613095e-02f, 1.22253075e-02f, -6.05167225e-02f, -1.52701344e-02f, 1.79059431e-03f, 9.97510850e-02f, 1.10029578e-01f, -1.12946390e-03f, 1.13344558e-01f, -1.42299831e-02f,
  -8.11267793e-02f, -8.49687979e-02f, 5.28989471e-02f, -1.62015762e-03f, 6.58315122e-02f, -6.02501929e-02f, -1.32655501e-01f, -4.69808951e-02f, 1.08398004e-02f, 7.19202012e-02f,
  -1.24600165e-01f, 5.18773235e-02f, -8.07835013e-02f, -4.72712852e-02f, -3.29316109e-02f, -1.32629827e-01f, -9.60828587e-02f, 3.37495701e-03f, -6.33913949e-02f, 4.39981036e-02f,
  -5.27896360e-02f, -6.58766106e-02f, 4.31437837e-03f, -4.13755849e-02f, -5.80565780e-02f, -2.37750020e-02f, -7.42827877e-02f, 6.19776256e-04f, -3.55569981e-02f, -1.32385001e-01f,
  -3.14957052e-01f, 1.34278074e-01f, -5.95186977e-03f, -2.63211820e-02f, 3.53735052e-02f, 1.82373151e-01f, 9.67335105e-02f, 1.43903671e-02f, -4.78311740e-02f, 2.08726469e-02f,
  1.22356184e-01f, 5.61944209e-02f, 7.18157068e-02f, -8.74981657e-02f, 1.10308006e-02f, 1.49525449e-01f, 1.93093583e-01f, 1.04250155e-01f, 6.51201829e-02f, -2.06781086e-02f,
  4.37791161e-02f, 2.18037162e-02f, 4.02266756e-02f, 7.45529756e-02f, 8.65534842e-02f, 2.19734665e-02f, 5.49090803e-02f, 4.88766748e-03f, 4.09929082e-02f, 1.10657141e-01f,
  4.42686498e-01f, 4.79167961e-02f, 5.21550849e-02f, -6.83463886e-02f, -1.74553588e-01f, -2.64246225e-01f, -2.52004415e-01f, -5.54569364e-02f, 5.11941127e-02f, 3.20014060e-02f,
  3.17010237e-03f, -1.26196057e-01f, -8.19639862e-02f, 9.74690616e-02f, 7.34742135e-02f, 2.72101834e-02f, 7.96173438e-02f, 6.55130297e-02f, 7.73953199e-02f, -7.72195728e-03f,
  -1.63586870e-01f, 6.84354901e-02f, 1.06086344e-01f, 8.27087685e-02f, 8.70832652e-02f, -7.60725960e-02f, 1.33596569e-01f, 1.89752042e-01f, 9.05937403e-02f, 7.43105337e-02f,
  1.18034415e-01f, 1.76469684e-01f, -2.25791663e-01f, -6.38612732e-02f, -2.57824399e-02f, 1.51488289e-01f, -3.01143732e-02f, 1.44618541e-01f, -5.89928068e-02f, 2.87977420e-02f,
  -3.47955758e-03f, 8.57187957e-02f, -1.27730697e-01f, -1.89645775e-02f, 3.38494442e-02f, 1.96009912e-02f, 7.20978081e-02f, 6.54944628e-02f, -3.10964533e-04f, 6.34959936e-02f,
  -1.79336727e-01f, -3.85244489e-02f, -1.11561812e-01f, -3.85432392e-02f, -4.23665419e-02f, -5.90493949e-03f, 5.94927371e-02f, 1.33570939e-01f, 3.15969139e-02f, 6.00128584e-02f,
  1.31184235e-01f, 2.42535882e-02f, 7.25580901e-02f, 4.05355245e-02f, 3.47001702e-02f, 2.43168734e-02f, 9.23130214e-02f, -2.43676994e-02f, 1.60488397e-01f, 9.98666584e-02f,
  -1.38395177e-02f, 6.19445220e-02f, -7.53631890e-02f, 1.32803977e-01f, 2.26070601e-02f, 9.12703723e-02f, 4.97901142e-02f, 2.41796263e-02f, 2.89527252e-02f, 8.58853236e-02f,
  7.55098602e-03f, -6.65019676e-02f, 2.37152837e-02f, 5.54237096e-03f, 3.83027387e-03f, 1.14061907e-01f, 1.69316158e-01f, 8.56852159e-02f, 5.98042123e-02f, 1.25386283e-01f,
  -2.87048787e-01f, -1.94663197e-01f, 1.86066411e-03f, -1.36139290e-02f, 8.61699879e-02f, 8.59944969e-02f, -1.06551968e-01f, 6.60815462e-02f, 1.50459658e-04f, -6.04226850e-02f,
  1.90156568e-02f, 6.65150806e-02f, -1.13581484e-02f, -4.45007049e-02f, -1.55245677e-01f, 1.77778602e-02f, 5.85393719e-02f, -4.34147865e-02f, -3.92720848e-02f, -4.38541319e-04f,
  -9.78188515e-02f, -2.65771717e-01f, -2.38346785e-01f, -2.49025896e-01f, -1.24806240e-01f, -1.43632814e-01f, -1.05809629e-01f, 2.50190049e-02f, -8.65341201e-02f, -1.51568457e-01f,
  -3.90448928e-01f, 1.12873979e-01f, -6.73546121e-02f, -3.76935720e-01f, 1.28817841e-01f, 2.52938092e-01f, 2.63594985e-01f, 9.35308114e-02f, 2.78771836e-02f, 1.12465329e-01f,
  1.44734845e-01f, -5.62995970e-02f, -1.49841785e-01f, -6.21812344e-02f, 3.38455625e-02f, 5.33913560e-02f, -1.14071816e-01f, -1.36961624e-01f, -4.26928923e-02f, 1.82682827e-01f,
  3.51714790e-02f, -5.97860292e-02f, -1.90791145e-01f, -1.36312936e-02f, -1.29683509e-01f, -8.30404982e-02f, -1.25634193e-01f, -2.01198161e-01f, -6.86295405e-02f, -2.11222351e-01f,
  -2.35194147e-01f, -8.30862522e-02f, 8.91418383e-02f, -1.41981021e-01f, -7.65421838e-02f, -4.36483771e-02f, -2.89475881e-02f, -1.27480656e-01f, 7.95560479e-02f, 2.65498850e-02f,
  -1.03305846e-01f, 2.34498661e-02f, -1.20634437e-01f, 1.05785608e-01f, 4.52517606e-02f, 8.19455273e-03f, 5.69515005e-02f, -1.11970432e-01f, 4.37968038e-02f, 1.18260868e-01f,
  8.63683000e-02f, 2.66245157e-02f, -2.11380258e-01f, -4.62699942e-02f, 1.06280722e-01f, -6.81909621e-02f, 6.55103382e-03f, -2.91414019e-02f, 2.56534088e-02f, -3.41377348e-01f,
  5.37436269e-02f, 1.28001481e-01f, 7.21907765e-02f, -5.81434146e-02f, -3.18286195e-02f, -1.84880942e-02f, 1.75540301e-03f, -4.72019538e-02f, 6.58090189e-02f, -9.55872163e-02f,
  4.97128852e-02f, -8.77157145e-04f, 6.27612099e-02f, -2.80799624e-02f, -3.15256454e-02f, -4.82490868e-04f, -8.07714164e-02f, -7.12096412e-03f, -3.76316835e-03f, -3.19611169e-02f,
  2.68126093e-02f, -6.90310001e-02f, 4.50524455e-03f, 7.93863367e-03f, -1.51389586e-02f, -1.36489123e-01f, 3.87538970e-02f, 4.18454632e-02f, 1.92820467e-02f, -2.59717498e-02f,
  -2.47891948e-01f, 2.00460732e-01f, -2.08372265e-01f, 1.02043398e-01f, -3.74137238e-02f, 6.87203258e-02f, -2.09813789e-02f, 8.23112875e-02f, 1.40853124e-02f, -1.64146931e-03f,
  7.34788191e-04f, -3.79403941e-02f, -1.15898713e-01f, 4.30741273e-02f, 6.47829473e-03f, -6.51479873e-04f, 7.93291256e-02f, -9.44421589e-02f, 1.17973790e-01f, -3.15285996e-02f,
  -8.73887613e-02f, -4.56625335e-02f, -2.19013244e-01f, -1.62401661e-01f, -1.53422520e-01f, -1.09405376e-01f, -9.35346782e-02f, -1.47464320e-01f, -1.66242309e-02f, -2.91500628e-01f,
  1.21098429e-01f, 2.17037261e-01f, 1.85574412e-01f, -1.25118256e-01f, 1.64261058e-01f, 2.12263897e-01f, 2.74948239e-01f, 4.36606817e-02f, -2.62352794e-01f, -4.50050868e-02f,
  2.30333716e-01f, 6.31376058e-02f, -1.08681433e-01f, -1.30735198e-02f, 2.11143598e-01f, -9.77474973e-02f, -8.74697268e-02f, 4.14052494e-02f, 1.89789668e-01f, 5.80007862e-03f,
  1.37449093e-02f, -9.10573378e-02f, -1.49953580e-02f, -6.01445436e-02f, -2.37887874e-01f, -1.37776047e-01f, -1.76099539e-01f, 2.67040748e-02f, 2.95773651e-02f, -2.56266385e-01f,
  4.94950451e-02f, 1.59118325e-02f, 4.64321077e-02f, 6.90110549e-02f, -3.09654288e-02f, -2.14666218e-01f, -1.01197824e-01f, -1.70954734e-01f, -6.18259981e-02f, -1.04647592e-01f,
  3.36558418e-03f, 5.95386550e-02f, -5.01708351e-02f, -2.32613049e-02f, -7.50232339e-02f, -5.27638383e-03f, 4.10149805e-02f, 5.13653308e-02f, -1.82983056e-02f, 1.44055560e-01f,
  2.09719300e-01f, 1.24460869e-01f, 1.27874866e-01f, 1.05024055e-02f, 1.24085441e-01f, 3.17425095e-02f, 1.50127217e-01f, -5.25663532e-02f, 7.60946944e-02f, -2.46645615e-01f,
  -8.30163732e-02f, 3.42658609e-02f, -3.03017087e-02f, 1.04873106e-01f, -6.93738759e-02f, -8.95727053e-02f, 4.11515571e-02f, 1.43445402e-01f, 1.28142655e-01f, -6.84169084e-02f,
  5.42992316e-02f, -6.79428205e-02f, 3.20154168e-02f, 2.14814357e-02f, -2.04399034e-01f, 3.66023257e-02f, 1.47927806e-01f, 4.32645604e-02f, 2.19676066e-02f, -2.13437825e-02f,
  8.80001765e-03f, -2.26579849e-02f, -1.63181067e-01f, -3.36979181e-02f, 1.16167031e-01f, -2.61245761e-03f, -2.72556186e-01f, -4.90468219e-02f, -1.11378446e-01f, -2.20364466e-01f,
  -1.66837931e-01f, 1.89111292e-01f, -2.64658928e-01f, -3.98509540e-02f, -1.13535374e-01f, -1.12274781e-01f, -1.92910340e-02f, 4.34098691e-02f, -3.56989205e-02f, 4.00168542e-03f,
  1.48829654e-01f, 6.77623674e-02f, -1.40627295e-01f, -1.21555060e-01f, 2.04965286e-02f, -1.75081149e-01f, -7.39318226e-03f, -5.55630922e-02f, -1.40928859e-02f, 9.22658592e-02f,
  3.20377909e-02f, 1.49562890e-02f, -1.21388502e-01f, -1.26196221e-01f, -2.21256807e-01f, -1.56658590e-01f, -1.33291304e-01f, -2.65598387e-01f, -1.88208282e-01f, -3.56150419e-01f,
  -5.14307916e-02f, -1.04095843e-02f, -4.44285542e-01f, 8.30095634e-03f, -2.83787876e-01f, -1.60180092e-01f, -9.41414833e-02f, 9.50981155e-02f, -1.81370217e-03f, -1.52378336e-01f,
  -3.69889513e-02f, -4.01516035e-02f, -1.18436567e-01f, 1.23998267e-03f, -2.32692491e-02f, -7.72982389e-02f, -1.30169898e-01f, -1.00598492e-01f, -1.46890759e-01f, -2.08654976e-03f,
  3.83183397e-02f, 3.18946242e-02f, 9.11132097e-02f, -3.91927622e-02f, -5.83346523e-02f, -1.19879700e-01f, -2.31016517e-01f, -9.06339139e-02f, -2.51143694e-01f, -2.98231363e-01f,
  -1.30468681e-01f, -2.00158924e-01f, -4.60822508e-02f, 5.51325828e-02f, -1.06358930e-01f, 2.24728063e-02f, 5.57213463e-02f, 6.44963309e-02f, 9.70856622e-02f, 7.12853745e-02f,
  2.05432456e-02f, 2.79905181e-02f, 3.49299610e-02f, 5.23259044e-02f, -1.96165051e-02f, -5.16267456e-02f, 4.61148322e-02f, -5.74213751e-02f, -4.42788079e-02f, 7.72992671e-02f,
  4.56714705e-02f, -8.91292393e-02f, -1.10977210e-01f, -1.13046795e-01f, 2.02471409e-02f, -1.94398358e-01f, -7.08117783e-02f, -8.32966715e-02f, -1.54785007e-01f, -4.34159376e-02f,
  8.43876675e-02f, 1.51892990e-01f, -7.04871044e-02f, 2.89103668e-02f, 1.42570928e-01f, -4.91448538e-03f, 5.75906932e-02f, 1.26514643e-01f, 6.95338994e-02f, -2.95741167e-02f,
  9.42170992e-02f, 3.01427040e-02f, 4.60130051e-02f, -1.99802872e-02f, -6.07892089e-02f, -8.99958089e-02f, -4.77041639e-02f, 1.81843117e-02f, -2.09017117e-02f, 6.59142137e-02f,
  4.15439345e-03f, 8.46435875e-02f, -6.99988892e-03f, 1.72225982e-02f, -1.45666316e-01f, -9.24267024e-02f, -1.27791418e-02f, 3.70456949e-02f, 5.69930859e-02f, 3.24688591e-02f,
  1.58386037e-01f, -2.90644616e-01f, 9.39154625e-02f, 3.67516875e-02f, -6.91136420e-02f, 6.29517362e-02f, -9.98810008e-02f, 4.47002761e-02f, 2.58733667e-02f, 4.49544517e-03f,
  1.73336286e-02f, 1.73035607e-01f, 3.03923991e-02f, 1.02650717e-01f, 6.68113902e-02f, 6.35681227e-02f, -3.33823636e-03f, 3.32694687e-02f, -7.60504752e-02f, 1.19162098e-01f,
  8.39509293e-02f, 1.13738045e-01f, 2.53345907e-01f, -2.06322856e-02f, 2.89801825e-02f, -5.99557646e-02f, 3.85157317e-02f, 7.19252080e-02f, 2.32600048e-02f, 2.52097428e-01f,
  1.27670199e-01f, -1.71521127e-01f, 2.88825125e-01f, 2.15229675e-01f, 3.02668720e-01f, 2.15499580e-01f, 3.10405731e-01f, 2.10050136e-01f, 5.87803237e-02f, 1.05354991e-02f,
  -8.80650524e-03f, -1.18607946e-01f, -1.47403032e-01f, 2.00006422e-02f, -7.16491882e-03f, 9.55624059e-02f, 1.82256117e-01f, 2.33736411e-02f, 2.48201594e-01f, 7.85681605e-02f,
  -2.89222375e-02f, 2.64526415e-03f, -7.94622302e-03f, 1.15163215e-02f, -6.59227967e-02f, 1.25099588e-02f, -2.68858578e-02f, 7.83807114e-02f, -3.54615003e-02f, -1.52340643e-02f,
  -3.88085619e-02f, -1.03420489e-01f, -5.29229967e-03f, -1.46943212e-01f, -4.01461683e-02f, -6.32402524e-02f, 3.54361497e-02f, -6.88936636e-02f, -8.05727988e-02f, -3.80189158e-02f,
  -9.52268243e-02f, -1.45085827e-01f, -1.11262493e-01f, -1.18822157e-02f, -1.74577963e-02f, 5.33355959e-02f, -2.04228628e-02f, 3.10834078e-03f, 1.21999182e-01f, -9.93918329e-02f,
  -1.66926533e-02f, 1.03956662e-01f, 1.57323167e-01f, 3.58284190e-02f, 5.00015449e-03f, 7.38118067e-02f, -9.16578434e-03f, 5.31409122e-02f, -1.41838542e-03f, 1.40441265e-02f,
  4.74239513e-02f, 7.44137540e-02f, -5.38256206e-03f, 3.76892015e-02f, -3.60403359e-02f, 9.03784782e-02f, 1.15926154e-01f, 1.04382314e-01f, 1.02994479e-01f, -1.40232081e-02f,
  7.59079456e-02f, 6.87176408e-03f, 9.50473472e-02f, -3.34056630e-03f, -7.69017190e-02f, 7.37405494e-02f, -5.04519381e-02f, -1.60909399e-01f, -1.26027405e-01f, -1.78678092e-02f,
  9.90886986e-03f, -4.66651656e-03f, -8.42440650e-02f, 4.07364406e-02f, -7.57964328e-02f, 4.52389009e-02f, -7.45929703e-02f, -5.70410118e-02f, 2.57457942e-02f, -2.28142715e-03f,
  2.60049105e-02f, -2.37751864e-02f, 1.44758327e-02f, -1.02991141e-01f, -8.32625851e-02f, -1.72463477e-01f, 2.37644603e-03f, -6.76516742e-02f, -9.16688517e-02f, 2.28136647e-02f,
  -6.60829619e-02f, -4.14115861e-02f, -5.08724675e-02f, -2.35138293e-02f, 5.84343076e-02f, 6.17106035e-02f, -1.66668117e-01f, 7.88350105e-02f, -1.12479515e-02f, 3.07862535e-02f,
  -4.96251211e-02f, 1.85071647e-01f, 1.21858262e-01f, 1.49457917e-01f, 1.37511313e-01f, 1.20559536e-01f, 1.11061558e-01f, 6.43050969e-02f, 1.58202961e-01f, 1.31807864e-01f,
  1.55712754e-01f, -2.80969352e-01f, -1.42749906e-01f, 1.15569234e-02f, -1.70244738e-01f, -2.25618660e-01f, -2.75521308e-01f, -3.76913114e-03f, 3.73200104e-02f, -2.18673155e-01f,
  -8.02207440e-02f, 1.46660909e-01f, 5.12286127e-02f, 7.86851719e-02f, 1.29504845e-01f, -2.44077533e-01f, -2.06007883e-01f, 3.87872234e-02f, 2.34309360e-01f, 1.12039475e-02f,
  -2.49513090e-02f, -5.17115705e-02f, 1.44911662e-01f, 1.14387289e-01f, -2.47008339e-01f, -1.03221476e-01f, -2.83973336e-01f, -1.37325078e-01f, -2.12424472e-01f, -2.03126594e-01f,
  -1.60051554e-01f, -1.52890131e-01f, 1.18370615e-01f, 1.65626243e-01f, -6.77000955e-02f, 1.07793912e-01f, -1.14644200e-01f, -8.09414983e-02f, -6.62544444e-02f, -1.03708483e-01f,
  -9.02261883e-02f, -6.52191509e-03f, 3.42238322e-02f, 3.47227789e-02f, -9.29627568e-02f, -1.12311225e-02f, -3.53664556e-03f, 4.00279872e-02f, -5.60551174e-02f, -2.20588297e-02f,
  -3.09817288e-02f, -7.76834786e-02f, -1.11273587e-01f, -2.78993174e-02f, 1.06543139e-01f, -6.44365139e-03f, -6.55495524e-02f, -1.07312009e-01f, -6.83562458e-02f, -2.33795151e-01f,
  -1.23516597e-01f, -7.58037195e-02f, -1.13539658e-01f, 5.52915074e-02f, -6.97964206e-02f, -6.63578138e-02f, 3.90113355e-03f, -4.50424813e-02f, 3.07264552e-02f, 2.63690446e-02f,
  2.22421605e-02f, -8.45088214e-02f, 6.35700971e-02f, -3.03979013e-02f, -7.60669932e-02f, -6.79815039e-02f, -8.05145204e-02f, -9.50524732e-02f, -1.12954564e-01f, -7.23863989e-02f,
  -5.41160721e-03f, -1.56034948e-02f, -8.28963444e-02f, -8.42964556e-03f, 1.47705637e-02f, 4.19163797e-03f, -4.45209555e-02f, 1.05093226e-01f, 8.98326933e-02f, -9.34533551e-02f,
  2.44807348e-01f, 7.68039972e-02f, -1.05543822e-01f, 1.62277758e-01f, -1.45620093e-01f, -4.95614968e-02f, -1.84736773e-01f, -2.47593946e-03f, 1.02135807e-01f, 6.70113266e-02f,
  7.66343176e-02f, 6.89574257e-02f, 4.73564006e-02f, 4.45082709e-02f, -4.79810697e-04f, -1.17114661e-02f, 1.02740917e-02f, -2.14047497e-03f, -5.38402274e-02f, -1.00346871e-01f,
  -6.91374689e-02f, -5.91558963e-02f, 6.71563447e-02f, 1.82860326e-02f, 1.24824746e-02f, 5.56009151e-02f, -1.00161500e-01f, -3.42474543e-02f, 6.98143765e-02f, -1.19567111e-01f,
  -1.45766631e-01f, -2.55679339e-02f, 9.09350533e-03f, 2.83167642e-02f, 5.74027821e-02f, -1.22201517e-01f, -3.23174924e-01f, -2.23149046e-01f, 8.56910869e-02f, 7.07568228e-02f,
  1.01212345e-01f, 1.41007006e-01f, 4.61923592e-02f, 5.95262349e-02f, -9.98892114e-02f, 1.33359348e-02f, 1.11457109e-01f, -3.25008184e-02f, -1.45351619e-01f, -1.51282221e-01f,
  5.30332029e-02f, 6.13086447e-02f, 1.96825154e-02f, -8.08197409e-02f, 1.48973256e-01f, 1.74902007e-01f, 1.78319827e-01f, 1.20292984e-01f, 1.73655048e-01f, 3.91535819e-01f,
  3.25746089e-02f, -1.31350204e-01f, -4.07285430e-02f, 4.79895100e-02f, 1.28542259e-01f, 6.30572066e-03f, -3.05477213e-02f, -5.31210788e-02f, -5.55211166e-03f, -3.76338721e-03f,
  1.55316353e-01f, 9.27731395e-03f, 8.76579583e-02f, 1.95391700e-02f, -7.44679123e-02f, -1.65793061e-01f, -5.24461679e-02f, -9.81843993e-02f, -1.04793914e-01f, -1.33747965e-01f,
  2.18142077e-01f, 3.11722215e-02f, -4.90982383e-02f, -1.82901397e-01f, -1.57824695e-01f, -8.12236443e-02f, -1.98708594e-01f, -1.13376535e-01f, -1.31089583e-01f, -1.84749335e-01f,
  -1.56974141e-02f, 1.63497105e-02f, -3.50282490e-02f, -4.91619557e-02f, -2.52852328e-02f, 2.22832803e-02f, 6.47683293e-02f, 2.28154231e-02f, -5.24665937e-02f, -5.48154041e-02f,
  4.58806753e-03f, -9.74137187e-02f, 7.35184271e-03f, -7.03329518e-02f, -1.55450813e-02f, 3.88183109e-02f, -2.36619115e-02f, 3.23110668e-04f, -3.56825441e-02f, -2.65989639e-02f,
  -1.40706217e-02f, -6.26616273e-03f, -3.07083130e-02f, -1.15131242e-02f, -1.31605431e-01f, 5.08215977e-03f, 1.95754133e-02f, -1.58217445e-01f, -4.92205657e-02f, -2.18685661e-02f,
  -1.27187803e-01f, -5.41562960e-02f, -5.48721291e-02f, -1.03184737e-01f, 6.78815246e-02f, -4.56207292e-03f, 7.93372393e-02f, -1.81763694e-02f, 6.22943789e-02f, -1.22867182e-01f,
  -6.47225305e-02f, -5.23633398e-02f, 1.04694432e-02f, -5.17858118e-02f, -1.21332482e-02f, 5.10735363e-02f, -4.90506105e-02f, 4.85407747e-02f, 2.32435321e-03f, -2.69619580e-02f,
  -7.31472299e-02f, -6.06112257e-02f, -1.42667219e-01f, -1.52400181e-01f, -1.75373346e-01f, -1.39482617e-01f, -1.39582843e-01f, -1.45834267e-01f, -2.45490149e-01f, -2.60553211e-01f,
  -3.36534679e-01f, -3.83628815e-01f, -1.23894483e-01f, -2.90797263e-01f, -2.31692955e-01f, -1.71396583e-01f, -2.63814867e-01f, 4.63376241e-03f, -8.82297754e-02f, -3.01764846e-01f,
  -2.17811018e-01f, 1.09647937e-01f, -9.38747898e-02f, -1.40348100e-03f, 1.28030717e-01f, -2.71725714e-01f, -2.29368567e-01f, 1.63208470e-01f, 3.44949216e-01f, 1.29515678e-01f,
  4.54197936e-02f, 9.65358596e-03f, 1.25241712e-01f, 1.08899012e-01f, -1.85094461e-01f, 2.41071451e-02f, -1.38434187e-01f, -6.53420389e-02f, 2.35545239e-03f, -3.97957236e-01f,
  -1.96637630e-01f, -1.45848468e-01f, 1.64076552e-01f, -4.31151055e-02f, -3.05527560e-02f, 6.78296983e-02f, -2.11583734e-01f, 1.06769249e-01f, 6.73844442e-02f, -3.78964171e-02f,
  -7.84269720e-03f, -3.13645154e-02f, -1.74977686e-02f, 1.90183818e-02f, 6.92810491e-02f, 6.75895140e-02f, 4.03694063e-02f, 1.00801229e-01f, 2.37735640e-03f, -6.59271404e-02f,
  -1.53231740e-01f, -9.95763168e-02f, -7.69295841e-02f, 9.98515561e-02f, 1.31905705e-01f, 1.49487421e-01f, 1.03109464e-01f, 4.00101393e-02f, 1.40957713e-01f, -2.61075974e-01f,
  -1.82640627e-02f, 2.29732916e-02f, -6.42801449e-02f, 2.78216060e-02f, -6.41117105e-03f, -4.09717001e-02f, -1.93269588e-02f, -6.38711900e-02f, 6.64056763e-02f, -6.81555942e-02f,
  -8.93924589e-05f, -2.66729277e-02f, 4.15874124e-02f, -1.12667374e-01f, -4.94962670e-02f, -2.01159827e-02f, -1.10926531e-01f, -6.69688359e-02f, 4.68067937e-02f, -4.60004695e-02f,
  5.46586290e-02f, 6.32742280e-03f, -6.29608706e-02f, 2.69277152e-02f, 6.19879831e-03f, -8.57562944e-02f, -1.20412037e-02f, 4.50061895e-02f, -7.14857280e-02f, 2.18324792e-02f,
  -1.31353527e-01f, 2.74654746e-01f, -1.99164271e-01f, 5.54041890e-03f, -1.69247296e-02f, 7.15991855e-02f, -1.06505014e-01f, 6.22448921e-02f, 1.11069847e-02f, 2.54945774e-02f,
  -2.60855886e-03f, -1.16648316e-01f, -1.06359288e-01f, 6.54841885e-02f, 1.69537347e-02f, -8.08240473e-02f, -1.98409274e-01f, -8.52736235e-02f, 5.30734472e-02f, 7.76868835e-02f,
  1.48869622e-02f, -1.79589719e-01f, -1.64427713e-01f, -3.55812535e-02f, -6.84999302e-02f, -4.91612516e-02f, 5.03625982e-02f, -6.01833463e-02f, -8.19451641e-03f, -1.58014268e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 52)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 52;
const float L0_fan_Bp_bar_data[] = {
  1.70445919e-01f, 1.70219749e-01f, -2.03630161e-02f, 3.12512785e-01f, -1.24423979e-02f, 1.49995536e-01f, 2.88413376e-01f, 2.34391510e-01f, 8.28246102e-02f, 2.28805035e-01f,
  -5.48361875e-02f, 1.48911521e-01f, 2.10603923e-01f, 7.46595040e-02f, 2.02146202e-01f, 7.61675686e-02f, 2.74646610e-01f, 1.95177481e-01f, 6.64156526e-02f, 2.82693326e-01f,
  1.97595626e-01f, 3.44242379e-02f, 2.41799399e-01f, 2.24263221e-01f, 2.82142550e-01f, 1.39899641e-01f, -1.56974979e-03f, 2.81778216e-01f, 1.47820547e-01f, 2.93794777e-02f,
  2.09598377e-01f, 1.11263685e-01f, 1.58762336e-01f, 2.05472738e-01f, 1.65194973e-01f, -8.76151696e-02f, 1.46871701e-01f, 2.49064267e-01f, 1.76824927e-01f, 2.76550323e-01f,
  1.39957771e-01f, 3.02917898e-01f, 3.46256793e-01f, -1.73556581e-01f, 2.15066731e-01f, 1.13615602e-01f, 6.67588338e-02f, 1.07289299e-01f, -5.93682304e-02f, 1.71672195e-01f,
  1.10643983e-01f, 8.16628560e-02f
};

// L1_fan_Wp (Shape: 6 x 64)
const int L1_fan_Wp_rows = 6;
const int L1_fan_Wp_cols = 64;
const float L1_fan_Wp_data[] = {
  5.51672615e-02f, 8.03080052e-02f, -6.79007396e-02f, -8.46952721e-02f, -1.44198254e-01f, -1.33449778e-01f, -2.04656631e-01f, 1.51477143e-01f, 1.52681291e-01f, 7.30278390e-03f,
  2.14906558e-02f, 1.57722026e-01f, 3.00899595e-01f, 1.06380709e-01f, -2.44655996e-03f, 1.47391349e-01f, -7.12898597e-02f, -3.53556544e-01f, -3.98363024e-02f, -1.17693581e-02f,
  5.47583029e-02f, 1.82073832e-01f, 5.12398705e-02f, 1.59822673e-01f, 9.20960158e-02f, -5.38468063e-02f, 1.45967528e-01f, 1.57475963e-01f, -1.95112407e-01f, 1.14490397e-01f,
  -8.40559453e-02f, -4.62336745e-03f, 2.29547858e-01f, -4.81084883e-02f, -7.86404386e-02f, -8.21108371e-02f, -1.97708517e-01f, -5.78746162e-02f, 5.07508256e-02f, 3.29118483e-02f,
  5.17394654e-02f, -3.16414610e-02f, 4.32207584e-02f, 2.07860619e-01f, 1.15789145e-01f, -2.05487236e-01f, 1.98359355e-01f, 1.79141790e-01f, -1.95052058e-01f, 3.60284150e-02f,
  -1.63004979e-01f, -7.07050040e-02f, 7.53852259e-03f, -9.88603979e-02f, 1.05666645e-01f, 1.03929967e-01f, -2.69953132e-01f, 1.31254449e-01f, 2.31530666e-02f, 3.34461294e-02f,
  1.48240015e-01f, 8.36987048e-02f, -7.32544363e-02f, 1.39211968e-01f, 4.12826054e-03f, -1.46791726e-01f, 5.62941767e-02f, 1.47276521e-01f, -5.96174300e-02f, -3.51895322e-03f,
  1.15860775e-02f, -9.59677845e-02f, 4.51541841e-02f, -8.24026614e-02f, -8.93343538e-02f, 1.31906852e-01f, 6.09732270e-02f, -6.60881773e-02f, 9.49537903e-02f, 3.56175266e-02f,
  8.64787400e-02f, 1.88040748e-01f, -7.61875585e-02f, -1.17335856e-01f, -2.04080734e-02f, -2.03263294e-03f, 2.67322846e-02f, -7.02029280e-03f, 6.44984320e-02f, 5.59715703e-02f,
  -4.73823072e-03f, -5.17011471e-02f, 1.09234795e-01f, -2.18064129e-01f, 1.15168467e-01f, -9.49521810e-02f, -2.80709863e-02f, 1.93395093e-02f, 5.42264283e-02f, -7.46049583e-02f,
  4.11611088e-02f, 4.26414832e-02f, -3.04386429e-02f, 6.97622225e-02f, 1.59711614e-01f, -9.73915905e-02f, -1.01985216e-01f, 9.45556685e-02f, -6.59055337e-02f, -5.08323945e-02f,
  1.83609799e-02f, -7.33894035e-02f, 1.68495476e-01f, -3.48224700e-03f, -2.19063461e-01f, -7.68190473e-02f, -2.01941684e-01f, -2.15080351e-01f, -5.61571084e-02f, 8.92155990e-03f,
  7.79460073e-02f, -1.14532895e-01f, 1.59971341e-01f, -1.20609254e-01f, 9.77697596e-02f, -1.10457823e-01f, -1.03726283e-01f, -7.26807341e-02f, 8.72667879e-02f, 1.00168400e-01f,
  1.28487661e-01f, 1.04921557e-01f, 4.56106327e-02f, 4.17606300e-03f, 1.76796801e-02f, 1.06597312e-01f, 2.17334032e-02f, 2.28803791e-02f, -1.30067524e-02f, 4.36967760e-02f,
  -1.01409972e-01f, -7.73262382e-02f, -2.50037517e-02f, -1.00993216e-01f, 1.03590354e-01f, -2.86173038e-02f, -6.41004741e-03f, -2.56894290e-01f, 1.63173258e-01f, 7.09794909e-02f,
  9.55629274e-02f, 7.78383687e-02f, -2.02901699e-02f, 4.33373917e-03f, -2.81425770e-02f, -4.03359830e-02f, 1.66683182e-01f, -2.56541912e-02f, -1.76060379e-01f, 3.94596159e-02f,
  1.53473660e-01f, -1.70061946e-01f, -1.28760502e-01f, 1.55712202e-01f, -1.01266272e-01f, 1.36909693e-01f, 1.54297978e-01f, 1.42001450e-01f, -3.30951065e-02f, -1.46919042e-01f,
  -1.96580857e-01f, 1.06994189e-01f, 2.86026224e-02f, 8.05628020e-04f, -1.03454821e-01f, 8.45567882e-02f, -7.76219368e-03f, 8.20902884e-02f, -2.20163897e-01f, 2.06167456e-02f,
  -1.22880191e-01f, 1.13226965e-01f, -1.45552471e-01f, 5.70858531e-02f, -1.22530915e-01f, -2.29156941e-01f, 1.87571630e-01f, -1.13455050e-01f, -3.39644030e-02f, 1.03095889e-01f,
  4.91119397e-04f, -7.64307054e-03f, -5.32852719e-03f, 9.32502523e-02f, -2.03445002e-01f, 1.88773815e-02f, 1.19992547e-01f, -4.47190255e-02f, -2.49868229e-01f, 1.52569234e-01f,
  7.41095841e-02f, 2.21054722e-02f, -1.14489928e-01f, 6.48947656e-02f, 2.76482373e-01f, -2.25990005e-02f, 1.01445876e-01f, -9.10200644e-03f, -2.24865694e-02f, -3.96392681e-03f,
  -6.58088457e-03f, -7.15549141e-02f, 2.67513953e-02f, -2.26827916e-02f, -3.68168168e-02f, 7.75889605e-02f, 8.99564549e-02f, 5.82078435e-02f, -9.13521796e-02f, -1.52914464e-01f,
  3.19631040e-01f, 2.14061469e-01f, 8.16751495e-02f, 8.97254273e-02f, -1.07428499e-01f, 1.06221758e-01f, -2.54471079e-02f, 1.62145913e-01f, -1.33697778e-01f, 1.43057808e-01f,
  -2.64747422e-02f, -1.92950591e-01f, 1.12034708e-01f, -1.37784258e-01f, -9.08998102e-02f, 2.31638208e-01f, -5.41875847e-02f, -1.75277844e-01f, 3.82898264e-02f, 2.58546084e-01f,
  1.16984300e-01f, 1.54475510e-01f, -1.55877575e-01f, -3.43585387e-02f, -8.79600272e-02f, 1.20758750e-02f, 1.49849355e-01f, 1.89175963e-01f, -1.46504939e-01f, 1.41071817e-02f,
  -5.56620164e-03f, 4.93466482e-03f, 2.25647874e-02f, -1.88752517e-01f, -1.20574936e-01f, -1.43952116e-01f, 6.26153573e-02f, 9.90097225e-02f, -7.63548538e-02f, -5.58041446e-02f,
  -1.95918009e-02f, 4.21782173e-02f, 1.59189403e-01f, 1.87900558e-01f, -1.06660120e-01f, -1.09577425e-01f, 1.60299510e-01f, 1.26466781e-01f, 1.59770057e-01f, 1.28324479e-01f,
  1.47565091e-02f, 1.14443004e-01f, -8.28010403e-03f, 1.14801608e-01f, -7.72875920e-02f, -2.13115349e-01f, 1.13208659e-01f, -2.22885218e-02f, 2.23791763e-01f, 7.06125796e-02f,
  -1.40580624e-01f, 1.26628727e-01f, 1.57904625e-01f, 1.16415501e-01f, -6.70802221e-02f, -1.91843044e-02f, 1.45230561e-01f, -9.52988341e-02f, 1.51599497e-01f, 4.79228869e-02f,
  -3.52441072e-01f, 4.09815088e-03f, -1.16120882e-01f, 1.19097438e-02f, -1.11232966e-01f, 2.38603920e-01f, 2.59275294e-05f, 5.31538129e-02f, -1.06227212e-01f, -1.00310341e-01f,
  2.25156434e-02f, -1.94860324e-01f, -2.41727326e-02f, 4.41370159e-03f, -1.57928616e-01f, 1.36249945e-01f, -1.05503285e-02f, -1.46016896e-01f, -2.15130895e-02f, -2.56799385e-02f,
  -2.24623233e-01f, -9.06153023e-02f, -1.33885756e-01f, 1.38489455e-01f, 3.24187279e-01f, -6.74202144e-02f, 8.73947218e-02f, 2.17397273e-01f, -8.95557106e-02f, 2.67452657e-01f,
  -3.37351672e-02f, -1.12371417e-02f, -1.16850175e-01f, 7.46698603e-02f, 2.09232233e-02f, 1.24646053e-01f, -3.33612263e-02f, -1.55789450e-01f, -8.53603780e-02f, 5.49503192e-02f,
  1.76415861e-01f, 3.88349891e-02f, -2.47530892e-01f, -1.82949036e-01f, -1.02206925e-02f, 2.11114720e-01f, -1.34458214e-01f, 2.00917989e-01f, -1.37544215e-01f, -2.17856750e-01f,
  -1.84420943e-01f, -2.12306306e-01f, -1.11999810e-01f, -1.51746173e-03f, 7.27063743e-03f, -8.33595246e-02f, -1.13432862e-01f, -2.06441898e-02f, 1.73413694e-01f, 2.09794387e-01f,
  1.46868480e-02f, 1.48025408e-01f, -1.34355322e-01f, 1.03189573e-01f, -3.60017493e-02f, 1.68967769e-01f, 7.90255368e-02f, 9.61600151e-03f, -1.26756400e-01f, -5.06676622e-02f,
  7.71088153e-02f, -1.89380832e-02f, 1.80617999e-02f, 2.02778891e-01f, -1.76704094e-01f, 2.36006021e-01f, 3.17639597e-02f, -1.23983316e-01f, 2.93342546e-02f, 7.32871518e-02f,
  1.22277655e-01f, 1.36621267e-01f, -7.08432570e-02f, -1.32666618e-01f, 5.63192740e-02f, 1.65348034e-02f, 2.51256615e-01f, -1.80095986e-01f, -8.76354426e-02f, -1.03445224e-01f,
  -7.89367482e-02f, -1.02446072e-01f, 2.72674914e-02f, -1.49658471e-01f
};

// L1_fan_Wp_bar (Shape: 52 x 64)
const int L1_fan_Wp_bar_rows = 52;
const int L1_fan_Wp_bar_cols = 64;
const float L1_fan_Wp_bar_data[] = {
  1.23156771e-01f, 1.87180609e-01f, 5.60844578e-02f, 1.23307072e-01f, 2.17587143e-01f, 1.65150374e-01f, -4.41196524e-02f, -1.28623575e-01f, -1.43653855e-01f, 6.28438368e-02f,
  -1.25210255e-01f, 1.99044600e-01f, 2.77891994e-01f, 1.31145313e-01f, -7.06227124e-02f, 2.61860251e-01f, -1.31319806e-01f, 5.48146814e-02f, -1.44020254e-02f, -1.31561086e-01f,
  3.34123150e-02f, -1.71154976e-01f, -1.18850447e-01f, -6.75423294e-02f, 3.19308341e-02f, -4.43318225e-02f, -1.79836318e-01f, -9.09590945e-02f, 8.45106691e-02f, 4.23552752e-01f,
  4.42053713e-02f, 1.92466810e-01f, -1.25828654e-01f, 2.78337657e-01f, 5.46674393e-02f, 6.18047230e-02f, 7.77450725e-02f, 8.93367976e-02f, -1.04602002e-01f, -7.01420829e-02f,
  1.51027322e-01f, -1.32920057e-01f, 2.34669030e-01f, 3.06538939e-01f, -9.71003547e-02f, 1.06645353e-01f, 2.79310375e-01f, 5.24936989e-02f, 9.65856481e-03f, -1.25192061e-01f,
  1.47257403e-01f, -2.71799229e-02f, -1.45062078e-02f, 9.01076347e-02f, 2.24159583e-01f, -1.47291973e-01f, -5.20128272e-02f, 7.95900151e-02f, -3.92925963e-02f, -6.41307309e-02f,
  -9.59205553e-02f, -1.81677550e-01f, 2.45442241e-01f, -1.78080067e-01f, 1.28099501e-01f, 3.66282202e-02f, 1.14615224e-01f, 1.09615326e-01f, 1.26341105e-01f, 1.94986492e-01f,
  1.90912828e-01f, 1.90766826e-01f, 6.54627755e-02f, 7.50240162e-02f, -1.83809236e-01f, -8.52784067e-02f, 1.94203779e-02f, -2.07382321e-01f, -2.53982702e-03f, -1.28042400e-01f,
  1.97975505e-02f, 2.73598701e-01f, 4.98005152e-02f, 8.11688155e-02f, 1.11194097e-01f, -2.50057615e-02f, -1.05420373e-01f, -5.85392714e-02f, 2.30723366e-01f, 8.67457837e-02f,
  2.41312712e-01f, -1.40650585e-01f, 2.50767946e-01f, -1.46041140e-01f, 1.74124867e-01f, -4.93216850e-02f, -2.40795556e-02f, -1.67380407e-01f, 1.10525876e-01f, -5.02668284e-02f,
  6.63802326e-02f, 5.56270406e-02f, -1.58104181e-01f, 2.53808260e-01f, 1.19337842e-01f, -1.22956634e-01f, -1.76732048e-01f, -1.12543255e-01f, -5.93235679e-02f, -8.66346061e-02f,
  -8.67758468e-02f, -1.39503703e-01f, 9.84699428e-02f, 3.11942637e-01f, -5.04162312e-02f, -3.00684068e-02f, 5.12355287e-03f, 1.77914813e-01f, -1.61018223e-01f, 6.51248023e-02f,
  6.56899139e-02f, -5.26863858e-02f, 1.86991423e-01f, 1.30148856e-02f, -1.05473362e-01f, -9.85909700e-02f, 9.69661213e-03f, -2.34648705e-01f, 1.46659821e-01f, 2.61084825e-01f,
  3.15614372e-01f, 1.65107772e-01f, 2.05391154e-01f, 1.74449787e-01f, 1.39175639e-01f, 7.63980597e-02f, 1.29210994e-01f, -2.85591912e-02f, 1.68270603e-01f, -2.44101346e-01f,
  -1.25641480e-01f, 1.20419078e-01f, -9.30078477e-02f, -5.26306704e-02f, 3.41319703e-02f, 2.00256734e-04f, 2.25551724e-01f, 7.02622160e-02f, 1.93930268e-01f, 2.71055121e-02f,
  4.17860374e-02f, 6.25362992e-02f, -7.33939335e-02f, 1.55010551e-01f, 1.46496624e-01f, 1.02174049e-02f, -2.08771843e-02f, -3.16991150e-01f, 6.40813634e-02f, 1.73612818e-01f,
  1.57547250e-01f, -1.69950813e-01f, -1.35646760e-02f, 2.45869979e-01f, 1.40055671e-01f, 1.70245111e-01f, 2.60388292e-02f, 2.66558528e-01f, -3.49691361e-02f, 1.71191931e-01f,
  -1.21803179e-01f, -2.71618009e-01f, 1.87413916e-01f, -1.65737644e-01f, -9.43775624e-02f, -2.06539914e-01f, 5.53520434e-02f, 1.31338418e-01f, 1.27316475e-01f, 2.06741452e-01f,
  4.11827490e-02f, 1.31514370e-01f, -2.03323707e-01f, -2.86436304e-02f, 9.38295871e-02f, -2.15055998e-02f, 1.40622526e-01f, 1.26536399e-01f, 1.02429157e-02f, 2.74788111e-01f,
  -5.90252541e-02f, 2.28226408e-01f, 1.67199031e-01f, 1.72538221e-01f, 2.63756625e-02f, 2.67331123e-01f, 3.34515184e-01f, 7.63823390e-02f, -1.48472100e-01f, -9.87462103e-02f,
  -1.35668546e-01f, -9.90357101e-02f, 1.06986180e-01f, -1.33402407e-01f, -2.74020210e-02f, -4.19060774e-02f, 1.61741018e-01f, 6.73203766e-02f, 1.41845047e-01f, 1.89729854e-01f,
  -8.35897997e-02f, -1.09603040e-01f, -6.39467388e-02f, -1.31284058e-01f, 1.50694801e-02f, -8.73169973e-02f, 5.38197309e-02f, 1.58926696e-01f, -1.29341960e-01f, -2.08099872e-01f,
  3.30009133e-01f, 1.20588303e-01f, -4.71357163e-03f, 2.30573148e-01f, 2.42424235e-02f, 1.93204675e-02f, 2.11893499e-01f, 2.35934228e-01f, 2.21721187e-01f, 6.29488751e-02f,
  -8.91121924e-02f, -1.24061048e-01f, 1.08528078e-01f, -1.24795496e-01f, 8.03902820e-02f, 1.22893915e-01f, -1.45323247e-01f, 1.47028163e-01f, 6.88720718e-02f, 9.70450714e-02f,
  1.95175916e-01f, 1.60690323e-02f, -1.81705263e-02f, 3.40862870e-02f, -2.12910891e-01f, 1.35036156e-01f, -1.35507554e-01f, 1.52367111e-02f, 2.46819928e-01f, 8.10157806e-02f,
  -1.23588771e-01f, 1.54187649e-01f, -1.00663744e-01f, -3.42371948e-02f, 1.30970299e-01f, -4.44764495e-02f, 1.65867358e-01f, 8.95678550e-02f, 1.11209854e-01f, 1.47506610e-01f,
  9.86027196e-02f, 2.32617483e-01f, 1.66984066e-01f, -2.73924023e-01f, -2.82317102e-01f, -3.15952636e-02f, 1.81287840e-01f, -9.24994648e-02f, -3.10654283e-01f, -2.72030924e-02f,
  -1.34095564e-01f, 2.89289832e-01f, 2.04051030e-03f, 2.42873952e-01f, 3.02211374e-01f, -1.72549754e-01f, -2.77087875e-02f, 3.46158743e-02f, 1.57588080e-01f, 1.26721740e-01f,
  -5.10663651e-02f, 1.37804933e-02f, -7.25910291e-02f, 1.00736789e-01f, 1.82126295e-02f, -1.20801836e-01f, 7.44992271e-02f, 2.90774722e-02f, 2.03445435e-01f, -5.46275005e-02f,
  2.93786637e-02f, 2.09238037e-01f, 3.87305349e-01f, 1.53704181e-01f, 1.82579368e-01f, 3.47488314e-01f, -3.89264487e-02f, -3.38602699e-02f, 1.05419435e-01f, -8.71036872e-02f,
  4.46865223e-02f, 6.91904575e-02f, -1.61683649e-01f, -1.70107082e-01f, 1.88127950e-01f, -8.34443346e-02f, -4.71751438e-03f, 1.20520152e-01f, 9.02742073e-02f, -7.67716095e-02f,
  5.81747591e-02f, 1.20763615e-01f, 2.40863308e-01f, -2.42006615e-01f, -1.64523534e-02f, -8.22575937e-04f, -6.38392046e-02f, 2.59760261e-01f, 1.21574678e-01f, 6.84322864e-02f,
  6.40480742e-02f, 3.25563774e-02f, 1.38410047e-01f, 1.53589994e-01f, 4.33634706e-02f, 1.79897130e-01f, -2.66937494e-01f, 9.88920927e-02f, -1.63279563e-01f, 9.49247181e-02f,
  2.95645394e-03f, 1.30054429e-01f, 1.88350715e-02f, 7.39427330e-03f, -2.72345006e-01f, -6.42707646e-02f, -5.14320619e-02f, -3.57564896e-01f, 8.80556926e-02f, -5.19678369e-02f,
  -1.58761721e-02f, 2.71099716e-01f, -1.89327542e-02f, 2.77329832e-02f, 1.72439933e-01f, 6.55689240e-02f, 2.34541185e-02f, -1.57976076e-02f, -9.10824761e-02f, -3.09151918e-01f,
  -9.50844437e-02f, 1.83286712e-01f, 3.17998737e-01f, -2.86739886e-01f, 4.84078601e-02f, 1.94540039e-01f, -1.01819104e-02f, -9.66657996e-02f, 3.12327951e-01f, 1.25087559e-01f,
  7.10255206e-02f, 1.31551221e-01f, -2.06099544e-02f, 8.35080538e-03f, 2.14752525e-01f, -2.25344867e-01f, -2.72020251e-01f, -4.77952547e-02f, 8.08774754e-02f, 1.16515078e-01f,
  -8.65683183e-02f, 9.60065350e-02f, -1.41814975e-02f, 2.10504562e-01f, 1.54280201e-01f, -1.57338157e-01f, 9.06065330e-02f, -5.50325923e-02f, -3.56748477e-02f, 1.25626298e-02f,
  1.08029298e-01f, 1.84839815e-01f, -9.25726444e-02f, 2.47450992e-01f, 2.13186983e-02f, 3.49720478e-01f, -1.64644495e-02f, 2.94988275e-01f, 1.49358526e-01f, 6.33051544e-02f,
  -1.77234694e-01f, 4.37322892e-02f, 2.04935446e-02f, -1.25735730e-01f, -6.31916448e-02f, -1.48162186e-01f, 1.07984595e-01f, -8.35004449e-02f, 1.29863620e-01f, -3.78372580e-01f,
  7.07197338e-02f, 2.51435935e-01f, 8.33942592e-02f, 3.85016918e-01f, -1.31530225e-01f, -2.01315470e-02f, -2.09258229e-01f, -1.04256660e-01f, 3.82081233e-02f, 8.44789017e-03f,
  1.67264894e-01f, 8.40163827e-02f, 1.63431361e-01f, 5.78574501e-02f, 2.64458675e-02f, -5.52314892e-02f, -4.90150414e-02f, 1.71485037e-01f, 3.31597477e-01f, -1.91889167e-01f,
  8.93131644e-02f, 1.84650347e-02f, -2.08348498e-01f, -5.90989552e-02f, -2.62889042e-02f, 9.51337665e-02f, 3.00154805e-01f, 1.04627766e-01f, 1.08108804e-01f, 1.77127495e-01f,
  1.35634437e-01f, -1.93384022e-01f, 1.52506351e-01f, 8.68738294e-02f, 6.16447590e-02f, 1.45460159e-01f, 2.41593882e-01f, 1.86112493e-01f, -1.09258376e-01f, -4.26271111e-02f,
  3.32191773e-02f, 1.58149555e-01f, 2.52997223e-02f, 2.44601965e-01f, 8.02295804e-02f, -1.48256896e-02f, 3.30300741e-02f, -2.55275488e-01f, 1.28367469e-01f, 2.41505012e-01f,
  9.10815075e-02f, 1.40899613e-01f, 5.26227877e-02f, 5.64093664e-02f, 1.42948538e-01f, 9.75051150e-02f, 1.32784650e-01f, -1.35424078e-01f, 2.78917849e-02f, -1.16855629e-01f,
  2.22226083e-01f, 2.12624624e-01f, -4.84104231e-02f, -2.31406335e-02f, 1.09242499e-01f, 5.35713769e-02f, 1.08481430e-01f, 2.09283307e-01f, -1.14620879e-01f, -8.23110566e-02f,
  -2.67877877e-01f, -1.10098287e-01f, 1.17670178e-01f, -3.35008614e-02f, 5.96599206e-02f, 8.82810429e-02f, 1.34230569e-01f, 1.67735294e-01f, -1.02968710e-02f, 1.75114349e-01f,
  -1.81704253e-01f, 3.27184021e-01f, 7.45352954e-02f, -1.55958787e-01f, 1.32230565e-01f, -1.25013171e-02f, -2.54381865e-01f, -1.12955555e-01f, -3.07755992e-02f, 3.55715714e-02f,
  5.88215292e-02f, 5.55878207e-02f, 1.24115892e-01f, 2.09253490e-01f, 2.33905032e-01f, 8.31011832e-02f, -6.15778342e-02f, 8.73316750e-02f, 1.65644243e-01f, -5.75537086e-02f,
  1.52087614e-01f, 1.30554602e-01f, 1.06011920e-01f, -1.74254388e-01f, -1.14212550e-01f, 2.85026878e-01f, -7.91281909e-02f, 7.21457005e-02f, -1.94250211e-01f, -9.78858769e-02f,
  1.19967841e-01f, 5.59780188e-02f, 6.51491955e-02f, 1.10385559e-01f, 2.32560024e-01f, 5.17637990e-02f, 7.16610346e-03f, -2.11309157e-02f, -2.19696574e-02f, 2.08819419e-01f,
  7.63528980e-03f, 1.08225830e-02f, -1.07245862e-01f, 2.82984048e-01f, 1.71660841e-01f, -1.95217773e-01f, -2.44253818e-02f, -5.13117500e-02f, 1.01628780e-01f, 1.50058061e-01f,
  -3.79218280e-01f, 6.99181855e-02f, 1.40040349e-02f, 1.90062493e-01f, 7.03143924e-02f, 7.04727098e-02f, 1.64312527e-01f, -8.54408965e-02f, 1.50154009e-01f, -7.79267475e-02f,
  -3.10231745e-02f, -6.25943467e-02f, 1.50806442e-01f, -1.52984988e-02f, 1.89487524e-02f, -3.65211248e-01f, 1.05628066e-01f, -8.49548653e-02f, -2.23496661e-01f, -1.33379281e-01f,
  8.00313726e-02f, -5.79212718e-02f, 9.47380438e-02f, -2.62840018e-02f, 8.14771373e-03f, 9.34678465e-02f, 2.66823675e-02f, -6.55691251e-02f, 1.77949861e-01f, 7.05825761e-02f,
  2.47555338e-02f, 2.54599601e-01f, -1.80490956e-01f, -3.59633416e-01f, -1.69253141e-01f, 1.17538929e-01f, 2.84101158e-01f, -7.33218864e-02f, -8.04706365e-02f, 3.27097438e-02f,
  4.27742079e-02f, -1.53028712e-01f, 2.60335624e-01f, -1.82089075e-01f, -1.32021680e-01f, -1.49733827e-01f, 8.92458949e-03f, -1.00226045e-01f, -6.14049844e-02f, 6.84323013e-02f,
  7.72995725e-02f, 1.67297497e-02f, -1.05466135e-01f, 1.30068585e-01f, 3.15263160e-02f, -1.08657353e-01f, -6.65451586e-02f, 5.96378855e-02f, -2.98782028e-02f, 2.29167983e-01f,
  -2.14206785e-01f, 5.90655953e-02f, 3.71492580e-02f, -1.04849458e-01f, 2.08584458e-01f, -2.76216045e-02f, -5.06635159e-02f, 2.14746788e-01f, 1.36856258e-01f, 1.33050337e-01f,
  -6.03395700e-02f, 8.87902379e-02f, 2.15811301e-02f, -7.04942644e-02f, -2.65483320e-01f, -2.26471335e-01f, 1.10867247e-01f, -1.94257915e-01f, 3.08714062e-01f, -1.58655822e-01f,
  -1.61805138e-01f, -1.30400211e-01f, -9.51756164e-02f, 1.88436791e-01f, 3.07498649e-02f, 1.94178760e-01f, -1.59640312e-01f, -2.07482129e-02f, 1.62334424e-02f, -1.82058752e-01f,
  1.66189075e-01f, -1.74197659e-01f, -1.72823444e-01f, -1.37970835e-01f, -1.57637596e-01f, 8.33843276e-03f, -2.78794463e-03f, 1.35340095e-01f, -4.25927825e-02f, 1.31864384e-01f,
  -6.62415251e-02f, -2.25538458e-03f, -7.35733435e-02f, -5.31158075e-02f, -8.62044543e-02f, 7.23461807e-02f, 2.53751129e-02f, 1.61215484e-01f, -1.26328707e-01f, 9.96671617e-02f,
  9.35174823e-02f, 1.35285899e-01f, 1.08233362e-01f, 7.62550160e-02f, 9.68634039e-02f, 8.42364579e-02f, -1.58346042e-01f, 2.46975720e-02f, 2.69307315e-01f, 5.70878759e-02f,
  -8.54376405e-02f, 4.53760400e-02f, 1.94159865e-01f, -3.01483404e-02f, -1.17238022e-01f, 3.98633450e-01f, 1.29720390e-01f, -2.35752016e-01f, 2.45718554e-01f, 3.36130410e-01f,
  -7.28236586e-02f, 2.82957572e-02f, 1.39313862e-02f, 2.85213515e-02f, 4.47262190e-02f, -7.11651817e-02f, -4.68005463e-02f, 2.02128232e-01f, -3.54224086e-01f, 1.45024464e-01f,
  -2.33859662e-02f, -9.07210037e-02f, 6.85614944e-02f, -1.73968792e-01f, 2.21772000e-01f, -1.05132945e-01f, -8.51842314e-02f, 6.72139004e-02f, 5.03177643e-02f, -2.39369288e-01f,
  1.02770716e-01f, -8.75053033e-02f, 2.05549747e-01f, 2.43185759e-01f, 9.90055725e-02f, 2.51080003e-02f, 8.36949348e-02f, 1.63592562e-01f, 3.50441672e-02f, -3.00711133e-02f,
  6.25953451e-02f, 9.81891453e-02f, 5.30075766e-02f, 1.60627291e-01f, 3.16199154e-01f, -1.70923546e-01f, -8.26974586e-02f, -1.43103197e-01f, -1.30260393e-01f, 7.22428635e-02f,
  1.44521400e-01f, 9.06004384e-02f, 3.28695513e-02f, -2.16461390e-01f, 5.09576872e-02f, 7.85000175e-02f, 1.93031371e-01f, 2.45198831e-01f, 1.13850378e-01f, 1.28726646e-01f,
  -1.92472354e-01f, 6.46448135e-02f, 1.41869247e-01f, 1.94769446e-02f, 1.44820154e-01f, -2.26714939e-01f, -1.80557013e-01f, -2.69698389e-02f, 3.36075053e-02f, 2.60832399e-01f,
  4.48376387e-02f, 8.63635689e-02f, 2.04792127e-01f, 2.52034098e-01f, -5.45466430e-02f, -5.17237522e-02f, -2.25485057e-01f, -1.55282035e-01f, -1.80715751e-02f, -6.24787845e-02f,
  1.98822558e-01f, 8.97316039e-02f, -2.08747372e-01f, 1.24281652e-01f, -1.06371567e-01f, -5.92287332e-02f, -3.40852961e-02f, -5.41130267e-03f, 2.89043218e-01f, -1.23957559e-01f,
  2.72405714e-01f, -1.06509112e-01f, -1.50402680e-01f, -2.57147163e-01f, -1.87058508e-01f, 4.31850180e-02f, 2.68370152e-01f, 1.13622382e-01f, 5.73144518e-02f, 1.52824000e-01f,
  1.00990839e-01f, -9.04238820e-02f, 4.95575592e-02f, -3.51372436e-02f, 4.06815186e-02f, 1.67317659e-01f, 2.67062873e-01f, -5.92086017e-02f, 1.67185053e-01f, -1.56441122e-01f,
  -8.52125511e-02f, -7.40625784e-02f, -3.75506312e-01f, 2.21051559e-01f, -1.69540226e-01f, 6.05415031e-02f, -9.17975791e-03f, -2.13249892e-01f, 9.72643681e-03f, 2.68085431e-02f,
  2.00769678e-01f, 3.28950256e-01f, -2.06085965e-02f, 2.19290912e-01f, 1.49689764e-01f, -1.42604336e-01f, 2.54093925e-03f, -1.33284748e-01f, 6.54070303e-02f, -1.05707839e-01f,
  -2.47358322e-01f, 4.07079645e-02f, 4.26995195e-02f, 4.04456854e-01f, -1.69641316e-01f, 4.35997456e-01f, 4.58846651e-02f, -2.95436561e-01f, -1.25412077e-01f, -3.30661237e-01f,
  -1.21452391e-01f, -1.20144062e-01f, -2.26424783e-01f, -1.69508696e-01f, -1.59284130e-01f, -9.87872705e-02f, -6.65661246e-02f, 1.12268493e-01f, -4.66470197e-02f, -5.69294207e-02f,
  -1.92561522e-01f, 1.14585847e-01f, 3.90356220e-03f, -1.41876981e-01f, 9.86911207e-02f, -1.45604074e-01f, -1.17248029e-01f, 4.91811410e-02f, 1.12241000e-01f, 1.50541320e-01f,
  2.37083733e-02f, 1.64313465e-01f, -1.17263302e-01f, 3.51823449e-01f, 5.45408763e-02f, 1.82418004e-01f, -2.38038963e-04f, -7.02624992e-02f, 2.23785266e-01f, 1.85469791e-01f,
  1.31792590e-01f, -1.59460485e-01f, -1.05049670e-01f, -1.61590531e-01f, 1.65684428e-02f, -1.74973719e-02f, -2.80927569e-01f, 1.05801098e-01f, -1.97019145e-01f, -2.94848494e-02f,
  2.83352077e-01f, -8.03868324e-02f, 1.10137090e-01f, -4.36774604e-02f, 8.20115879e-02f, 5.73605523e-02f, 7.96698704e-02f, 6.94573596e-02f, -1.10786878e-01f, 9.24827438e-03f,
  -4.48651649e-02f, -5.44664152e-02f, 9.23303589e-02f, 2.65007298e-02f, -1.24956727e-01f, 1.10703170e-01f, -1.19928882e-01f, 1.02288425e-02f, 1.29916251e-01f, 1.95556968e-01f,
  9.15597603e-02f, -1.88485742e-01f, 7.91051909e-02f, 1.52818799e-01f, 1.92631930e-01f, 9.12363455e-02f, 4.39279974e-02f, 4.50162999e-02f, 1.21883713e-01f, -3.61016653e-02f,
  1.05496638e-01f, 2.28374172e-03f, 1.20222323e-01f, -4.64468077e-02f, 2.26593375e-01f, -1.77035481e-01f, -1.73232913e-01f, 5.93585297e-02f, -1.07140452e-01f, 1.86523348e-01f,
  1.86292484e-01f, 2.42664441e-01f, 7.59141594e-02f, 4.79197353e-02f, -2.29162395e-01f, -1.75871238e-01f, -1.59809180e-02f, -1.23366363e-01f, -2.01909676e-01f, -1.37360349e-01f,
  4.69651818e-02f, -6.70025200e-02f, -4.03443491e-03f, 7.52878562e-02f, -2.33476788e-01f, 1.40391812e-02f, -1.41656190e-01f, 1.69554338e-01f, 1.32683720e-02f, -1.24142937e-01f,
  3.23543884e-02f, -1.86224381e-04f, 1.78137124e-01f, 2.16113746e-01f, -2.09518284e-01f, 1.36973992e-01f, 5.47655560e-02f, -6.76869508e-03f, 3.00611109e-02f, 1.26535043e-01f,
  8.10698345e-02f, 1.56392515e-01f, -1.15597742e-02f, 1.25929072e-01f, -3.58113758e-02f, 6.22801371e-02f, 1.21780649e-01f, 4.53510620e-02f, -1.41591161e-01f, 1.81458697e-01f,
  -1.32773250e-01f, 3.06530967e-02f, 9.30438638e-02f, 1.53166905e-01f, 2.53074646e-01f, -1.67803779e-01f, 8.58761743e-02f, 1.87353030e-01f, 2.05094606e-01f, 1.00737683e-01f,
  -1.42904639e-01f, 1.21358238e-01f, 1.37147859e-01f, -1.89936452e-03f, -7.63973370e-02f, -3.22178364e-01f, 1.66707650e-01f, -2.58394003e-01f, 1.18742183e-01f, -1.21596478e-01f,
  -2.03243345e-01f, -4.17905711e-02f, -9.58171561e-02f, 2.56365389e-01f, 1.37888072e-02f, 3.45821738e-01f, 6.42365078e-03f, 6.92059696e-02f, -1.42055660e-01f, -2.33566940e-01f,
  1.74549878e-01f, -1.50488973e-01f, -8.93549100e-02f, -2.46407852e-01f, -7.48978881e-03f, 1.70670450e-02f, 3.01203467e-02f, 1.86560854e-01f, 5.23583591e-03f, -1.01168985e-02f,
  -2.17077602e-02f, -6.43072799e-02f, 6.30229637e-02f, -5.87893464e-02f, 1.02288552e-01f, 9.68896970e-02f, 2.05322318e-02f, 2.55446970e-01f, -2.09806915e-02f, 1.25291258e-01f,
  -9.19775665e-03f, 2.97170550e-01f, 2.98629459e-02f, 2.83240616e-01f, 7.40078166e-02f, -4.17601019e-02f, -7.23360479e-02f, -5.05733006e-02f, 7.05047399e-02f, -9.60821509e-02f,
  1.49240652e-02f, -1.71265036e-01f, -1.22358762e-01f, -1.64259762e-01f, 1.06727742e-01f, -1.00365616e-01f, 7.65435174e-02f, 1.44302279e-01f, 2.70122662e-02f, 7.33985826e-02f,
  -8.09417292e-02f, -3.64490338e-02f, -7.47936368e-02f, -6.07508188e-03f, 1.19095311e-01f, -1.36481430e-02f, 2.11011827e-01f, -1.11160375e-01f, 6.89254627e-02f, 5.88733889e-02f,
  -6.70298114e-02f, 1.86743829e-02f, -8.78824666e-02f, 4.48707864e-02f, 2.04732895e-01f, -1.12521634e-01f, 2.80228972e-01f, -6.17588870e-02f, -8.88000950e-02f, -9.16692317e-02f,
  -5.16452231e-02f, -5.76207303e-02f, -1.00748256e-01f, 7.06591159e-02f, 4.94936220e-02f, 2.32313350e-01f, 3.10577285e-02f, 4.92583178e-02f, 1.88247919e-01f, 1.10717431e-01f,
  9.72175300e-02f, 1.42407298e-01f, 1.85554385e-01f, 1.40145048e-01f, 2.91678924e-02f, -9.97617543e-02f, 2.98913419e-02f, 1.39698371e-01f, -1.56987503e-01f, 1.08190335e-01f,
  2.84745544e-02f, -1.08817533e-01f, -5.12103327e-02f, -2.20441550e-01f, -4.06415164e-02f, 1.36043847e-01f, -5.14337979e-02f, 1.18178278e-01f, 9.76702198e-02f, 1.39183983e-01f,
  -1.66194171e-01f, 5.90837784e-02f, 1.90174803e-01f, -1.13251977e-01f, -6.94218278e-02f, 7.97663927e-02f, 7.89222587e-03f, 2.91997623e-02f, -1.13346092e-01f, 4.07817122e-03f,
  5.61926737e-02f, -2.48914599e-01f, 2.69856989e-01f, 1.38075292e-01f, 1.95637606e-02f, 3.65468860e-02f, -5.56913428e-02f, 9.20287147e-02f, 8.33513290e-02f, 1.39870733e-01f,
  1.36584029e-01f, 9.33755282e-03f, -2.30949968e-01f, -1.23826060e-02f, 1.29583612e-01f, -1.72451347e-01f, 1.67005271e-01f, -2.25425884e-02f, 1.67752355e-01f, -1.49492979e-01f,
  -1.17288589e-01f, 1.15552224e-01f, 1.50914147e-01f, -1.38626739e-01f, -3.88855324e-03f, -3.03993728e-02f, 4.15014736e-02f, 1.92594603e-01f, 1.50691748e-01f, -8.76850188e-02f,
  3.70446257e-02f, 5.79312332e-02f, 5.46266064e-02f, 1.08395450e-01f, 5.89849912e-02f, 8.78990218e-02f, -5.48542254e-02f, 3.59660126e-02f, 2.70948559e-01f, -6.66755140e-02f,
  -6.20485432e-02f, -2.08823495e-02f, -7.30063766e-02f, 7.74920732e-02f, 2.40665182e-01f, 7.12211709e-03f, -1.43477157e-01f, -8.95679742e-02f, 1.65896580e-01f, 1.63607404e-01f,
  -3.54525284e-03f, -3.74803878e-02f, 1.51748791e-01f, 7.75832741e-04f, 1.64507329e-01f, -7.76346996e-02f, 1.41428620e-01f, -1.98547281e-02f, -1.59115776e-01f, 1.31858975e-01f,
  3.25612664e-01f, 2.44823381e-01f, -2.41405424e-02f, -2.18641944e-03f, 2.39716604e-01f, -2.13938057e-01f, -1.06966145e-01f, -1.41933386e-03f, -7.27046877e-02f, 6.21202402e-02f,
  4.26645391e-02f, -1.09228626e-01f, 8.26521963e-02f, 2.86908954e-01f, -2.75406595e-02f, 2.55156785e-01f, 3.84259522e-02f, 7.72646889e-02f, -2.12391675e-01f, 2.39416093e-01f,
  -1.57252401e-02f, 1.74055755e-01f, -2.20658392e-01f, 1.86411366e-01f, 9.75462198e-02f, -1.39907956e-01f, -7.46682137e-02f, 9.43522304e-02f, 2.00343102e-01f, 2.50482708e-01f,
  2.05668494e-01f, -5.02524674e-02f, 1.32278740e-01f, -8.14236328e-03f, 3.11694950e-01f, 1.00346945e-01f, -1.52003452e-01f, 4.12677526e-02f, 1.41280681e-01f, -2.78875500e-01f,
  -2.32548127e-03f, -3.31619494e-02f, 5.57015352e-02f, -9.83679220e-02f, -2.02662200e-01f, 2.63101548e-01f, 1.86623394e-01f, 9.67781842e-02f, 4.49256562e-02f, 1.06326938e-01f,
  1.74146533e-01f, 2.23870233e-01f, 1.81918859e-01f, -4.36545573e-02f, 1.49532020e-01f, 1.45727411e-01f, 2.42164098e-02f, 2.07055137e-01f, 7.67709985e-02f, -7.92180970e-02f,
  2.43602339e-02f, 7.26149455e-02f, -2.56954376e-02f, 9.87748876e-02f, 2.05374002e-01f, -1.24278748e-02f, 5.19803427e-02f, 6.25983700e-02f, -7.24630654e-02f, 1.60388142e-01f,
  -1.73334122e-01f, -6.36453629e-02f, -5.60334027e-02f, -2.33833883e-02f, -7.88561776e-02f, -4.31906022e-02f, 1.21646866e-01f, 1.15501909e-02f, 7.62288272e-02f, 2.08765045e-02f,
  2.07946762e-01f, -1.29827499e-01f, 5.45869581e-02f, 1.60936281e-01f, 2.13682465e-02f, -2.48438884e-02f, -2.87732221e-02f, 1.93675593e-01f, -4.34861109e-02f, 3.50499339e-02f,
  -8.25321451e-02f, 1.09292418e-01f, 1.33729085e-01f, 2.00850684e-02f, -1.97123662e-02f, -4.89499308e-02f, -6.24212436e-02f, -4.39647362e-02f, 5.43733127e-02f, -7.77655244e-02f,
  1.10594779e-01f, 2.63335526e-01f, -9.48690474e-02f, -1.11130394e-01f, -1.48376450e-01f, -1.57002091e-01f, -7.54488399e-03f, -7.35444725e-02f, -6.35477453e-02f, 1.82653703e-02f,
  2.60849565e-01f, -2.14093059e-01f, 1.20984027e-02f, 1.02077290e-01f, 1.45400733e-01f, 2.67798882e-02f, -2.22824030e-02f, 2.04829574e-02f, -6.79437816e-02f, -1.14765046e-02f,
  5.06438464e-02f, -5.76739497e-02f, -1.58810273e-01f, -1.71020642e-01f, -3.93470936e-02f, 1.32441998e-01f, -2.29148179e-01f, 1.73329737e-03f, 1.33672684e-01f, -1.19981177e-01f,
  8.85029212e-02f, 2.16306582e-01f, 1.56867415e-01f, -1.47957116e-01f, 8.49186704e-02f, 1.38045311e-01f, -3.92950997e-02f, 1.55958962e-02f, -3.45140472e-02f, -2.91637592e-02f,
  1.01387717e-01f, 3.79883684e-02f, -2.24330038e-01f, 1.56126156e-01f, 4.11404520e-02f, -1.00097723e-01f, -5.75472899e-02f, 8.90595242e-02f, 1.82168484e-02f, -2.21848652e-01f,
  8.42801575e-03f, 6.41394779e-02f, -2.27355193e-02f, -4.10252362e-02f, 1.36483446e-01f, -4.34699915e-02f, 1.66466907e-01f, -3.21629904e-02f, 1.90753743e-01f, 1.17005162e-01f,
  -1.00367796e-02f, -1.37544110e-01f, 1.76909745e-01f, -6.25473410e-02f, 1.49791181e-01f, -1.57281190e-01f, -1.88219950e-01f, 2.70956177e-02f, -1.19825460e-01f, -7.89371878e-02f,
  1.85927808e-01f, 1.61872253e-01f, 2.79230978e-02f, 3.45536433e-02f, -1.55218929e-01f, -3.42601463e-02f, 1.60412952e-01f, 5.71427643e-02f, 7.26240575e-02f, -9.71274078e-02f,
  -2.10690107e-02f, 1.49661973e-01f, 8.25254545e-02f, 1.55549824e-01f, 1.55126229e-01f, 3.77592742e-02f, -7.34139532e-02f, -2.57424023e-02f, 8.63008797e-02f, 2.83124186e-02f,
  -5.29524684e-02f, -2.15833679e-01f, -7.16594383e-02f, -2.26340055e-01f, -4.25004885e-02f, -1.97843298e-01f, 3.36863771e-02f, -3.15211304e-02f, 1.92208171e-01f, 4.03826028e-01f,
  -1.47697240e-01f, 4.92258891e-02f, 4.81817219e-03f, -7.07299411e-02f, 1.78644985e-01f, 1.31824717e-01f, 2.15222072e-02f, 1.12815246e-01f, 7.79953524e-02f, -1.48855403e-01f,
  7.77316540e-02f, 2.06732005e-02f, -4.62250188e-02f, -9.91381109e-02f, 3.38332027e-01f, 1.66879117e-01f, 1.45578921e-01f, 1.86484352e-01f, 6.69788569e-03f, -1.13291433e-02f,
  5.13042957e-02f, -1.42446950e-01f, 1.23899274e-01f, -9.63790044e-02f, 1.52028620e-01f, -1.76022813e-01f, 7.19925668e-03f, -1.06337637e-01f, 3.39627564e-01f, -1.33786961e-01f,
  -8.54338482e-02f, 2.82810092e-01f, -5.50793558e-02f, 1.88409984e-01f, 1.72184467e-01f, -4.97411750e-03f, 5.48248515e-02f, -5.02427444e-02f, -6.15850501e-02f, 2.70397455e-01f,
  1.24565080e-01f, -6.24080673e-02f, -1.25426993e-01f, -3.66603464e-01f, 7.57799949e-03f, -2.41922941e-02f, -4.76321243e-02f, -3.27188522e-02f, -3.10129952e-03f, 6.46495670e-02f,
  2.34418288e-01f, -1.30582333e-01f, 1.12725362e-01f, 1.49778992e-01f, -1.73284754e-01f, 1.54025331e-01f, 3.47495854e-01f, -3.14279944e-02f, -9.27978754e-02f, 9.08909664e-02f,
  1.28126768e-02f, -4.41415012e-02f, -8.43411312e-02f, 1.35613993e-01f, 4.86308709e-02f, -4.63702343e-02f, -5.54361977e-02f, -9.43213552e-02f, -9.32334736e-02f, 3.64395455e-02f,
  1.76038072e-02f, 1.39426291e-01f, -4.72573414e-02f, 2.59977162e-01f, 1.27409980e-01f, -4.85274149e-03f, -2.32602879e-01f, 8.13082159e-02f, 5.84349874e-03f, 5.55483177e-02f,
  -1.61306828e-01f, 1.08023062e-01f, -6.79118261e-02f, -6.57613873e-02f, 9.94936675e-02f, 4.54359278e-02f, 2.22755104e-01f, -1.01151094e-01f, -5.87495863e-02f, 1.77034453e-01f,
  3.03551316e-01f, 5.44964895e-02f, -6.59259260e-02f, -1.29263312e-01f, 1.88695684e-01f, -2.75201172e-01f, -7.09110033e-03f, -1.58629343e-01f, 1.24985948e-01f, 4.28225324e-02f,
  -2.17357635e-01f, 2.90177912e-01f, 1.42719984e-01f, -5.46479300e-02f, 5.12942486e-02f, -1.84575692e-01f, 1.92653432e-01f, -1.43382996e-01f, 1.38008133e-01f, 1.53957605e-01f,
  1.58945069e-01f, 1.78641781e-01f, 2.08293796e-02f, 1.39319345e-01f, -3.75380628e-02f, 8.17967728e-02f, 1.76099628e-01f, 5.03363460e-02f, 1.53468817e-01f, -1.01064600e-01f,
  -6.94594234e-02f, -7.79031962e-02f, -6.80749491e-02f, 4.95398194e-01f, -1.24175511e-01f, -3.98531742e-02f, 2.17799932e-01f, 6.00753613e-02f, 9.15942714e-02f, -4.61019836e-02f,
  -4.66617644e-02f, -2.70654727e-02f, -1.28368601e-01f, 6.82502538e-02f, 1.30838469e-01f, 3.27198327e-01f, -2.39282295e-01f, 1.57230958e-01f, -5.50260134e-02f, -6.18070252e-02f,
  1.46953240e-01f, 1.55390864e-02f, 2.28500701e-02f, 5.19936904e-02f, -1.62060093e-02f, 5.97350821e-02f, -8.87118429e-02f, 1.05482399e-01f, -7.36510977e-02f, -6.39930293e-02f,
  2.82652825e-01f, -5.90478070e-04f, 9.89509895e-02f, 7.23016858e-02f, -1.21301219e-01f, 1.01840449e-02f, -1.80721775e-01f, -1.90893635e-01f, 1.47697046e-01f, 2.72893310e-01f,
  2.94915348e-01f, -8.36607516e-02f, 3.23096244e-03f, 4.54691723e-02f, -1.76408223e-03f, -1.34277597e-01f, 2.58149914e-02f, 8.19701552e-02f, -1.27907813e-01f, 1.41665950e-01f,
  1.38235494e-01f, 1.28101101e-02f, -3.23916897e-02f, 1.36221712e-02f, 1.36934310e-01f, 1.47245556e-01f, 1.35525063e-01f, 2.13223156e-02f, 6.88848551e-04f, 2.06514210e-01f,
  7.97339082e-02f, -1.41591325e-01f, -1.89896256e-01f, -1.14056416e-01f, 7.34318979e-03f, -4.86395247e-02f, -3.96617912e-02f, -2.06635863e-01f, 1.71031117e-01f, -9.04672313e-03f,
  1.85913354e-01f, 2.27989152e-01f, -4.12236564e-02f, 2.23064616e-01f, -3.60749438e-02f, -4.22883704e-02f, 1.75176766e-02f, -2.42097508e-02f, 1.16621293e-02f, 1.39109135e-01f,
  -1.04675420e-01f, -1.87906057e-01f, 2.15280443e-01f, -2.26466671e-01f, 1.32266358e-01f, -2.64740288e-01f, 1.73187852e-01f, 3.80617417e-02f, 1.41579553e-01f, 1.10341735e-01f,
  9.91661400e-02f, 1.77190274e-01f, -5.19773643e-03f, 1.31767288e-01f, 5.62153116e-04f, -3.09381839e-02f, 1.92924023e-01f, -7.59827346e-02f, 3.53776552e-02f, -2.11074486e-01f,
  -1.22921631e-01f, 1.96874484e-01f, -2.16691382e-02f, 9.39455032e-02f, 7.66605064e-02f, 2.74955958e-01f, 6.40242547e-02f, -6.74866065e-02f, -1.14249513e-01f, -9.68837738e-02f,
  -2.93552633e-02f, 1.99808419e-01f, 1.75285310e-01f, 3.21484767e-02f, -2.15073615e-01f, 5.44644892e-03f, 1.49000764e-01f, 1.85343791e-02f, 2.12200075e-01f, 1.48279577e-01f,
  1.38087764e-01f, 2.40510449e-01f, -1.07897803e-01f, -1.79392070e-01f, 8.73798802e-02f, 6.06828332e-02f, 1.65901870e-01f, -1.67941362e-01f, -2.40734637e-01f, 8.33456777e-03f,
  -6.05461001e-02f, 1.77341864e-01f, -1.24384509e-02f, 1.85064495e-01f, 1.94018722e-01f, -1.12455644e-01f, 1.45909354e-01f, 1.15615383e-01f, -1.80223137e-02f, 1.24476895e-01f,
  2.68699266e-02f, -6.30480573e-02f, 4.05526496e-02f, 1.89562961e-02f, 1.02890261e-01f, -2.24305108e-01f, 1.34598747e-01f, -6.14852272e-02f, 1.23885721e-01f, -2.21277311e-01f,
  -7.68057555e-02f, 2.52292961e-01f, 2.69466847e-01f, 1.51518986e-01f, -6.26562461e-02f, 1.57900006e-01f, 1.16700888e-01f, 1.12607339e-02f, -2.82871593e-02f, -9.72845256e-02f,
  2.02515870e-02f, -2.22987413e-01f, -1.20072521e-01f, -1.78194925e-01f, 1.94276527e-01f, -9.64491665e-02f, -7.11035654e-02f, 2.03738853e-01f, 1.03177376e-01f, 1.33767948e-01f,
  -6.56649917e-02f, 7.92986341e-03f, 2.18076453e-01f, -8.46559778e-02f, -2.67132856e-02f, 9.32287276e-02f, -1.52232066e-01f, 1.35919422e-01f, 6.20593838e-02f, 1.00359567e-01f,
  -3.95531431e-02f, 5.33353984e-02f, 6.75834641e-02f, 7.04798847e-02f, -5.23027740e-02f, 9.88024250e-02f, 2.29306102e-01f, 5.47701307e-02f, 1.45961136e-01f, -1.62631914e-01f,
  -5.46022542e-02f, 1.16496764e-01f, 2.19710514e-01f, 2.85027176e-02f, 1.20505475e-01f, -2.84853995e-01f, -7.94666186e-02f, 3.82783592e-01f, 9.57750380e-02f, 1.11011565e-01f,
  -1.37695074e-01f, -2.25108257e-03f, -7.15782344e-02f, -1.86403375e-02f, 5.94574492e-03f, -3.63756195e-02f, 2.56555676e-01f, 1.58501118e-01f, 4.68910858e-02f, 2.61521101e-01f,
  1.76950574e-01f, 1.22852564e-01f, -2.34015509e-02f, 3.03727895e-01f, -9.86683369e-02f, -1.18732683e-01f, 1.67875677e-01f, 3.15792970e-02f, -1.31925195e-01f, 1.43659636e-01f,
  2.32458323e-01f, 1.88105211e-01f, 3.38423513e-02f, -8.68656710e-02f, 1.18565217e-01f, 3.19544673e-01f, 3.41493726e-01f, -1.75437376e-01f, -1.18247569e-02f, 2.00496837e-01f,
  1.52932242e-01f, -4.47691828e-02f, 1.02944709e-02f, -7.98301920e-02f, -1.14924967e-01f, 3.23541672e-03f, -4.03022654e-02f, 1.41734540e-01f, 1.34271145e-01f, 1.43006593e-01f,
  -1.22373074e-01f, 1.14663579e-01f, 2.75062531e-01f, -5.46072721e-02f, 1.58727437e-01f, 1.12231620e-01f, 2.75722861e-01f, 5.63933887e-02f, 7.72294328e-02f, 1.77374646e-01f,
  -7.86591843e-02f, -5.09544201e-02f, 2.65598800e-02f, -1.44439206e-01f, 5.86211532e-02f, -1.05820850e-01f, -2.80157328e-01f, 6.82701450e-03f, -2.73891628e-01f, 5.71759105e-01f,
  -2.36980263e-02f, 9.86592099e-02f, 2.56726742e-01f, -2.54379157e-02f, 1.60877809e-01f, 2.09568366e-02f, 1.88438341e-01f, 1.84537560e-01f, -1.49283051e-01f, -4.81250323e-02f,
  1.36464462e-01f, 3.53263468e-02f, -2.41553590e-01f, 1.51062936e-01f, 1.39639974e-01f, -1.52443379e-01f, 2.34570310e-01f, -3.41834761e-02f, -5.71894608e-02f, 1.66079327e-02f,
  1.49643123e-01f, 1.75247043e-01f, 1.14257157e-01f, 1.19243331e-01f, 4.19139937e-02f, 3.21760774e-02f, 6.16357010e-03f, -2.20732987e-02f, 9.41224620e-02f, 1.28023237e-01f,
  -5.02016358e-02f, -9.89144854e-03f, 1.63667742e-02f, -2.62998104e-01f, -6.15531243e-02f, 8.19971189e-02f, 9.10005122e-02f, -3.41896601e-02f, 8.24476853e-02f, 4.76922560e-03f,
  2.18377262e-01f, -1.90758288e-01f, -1.96387753e-01f, 1.02946376e-02f, -7.01422170e-02f, 1.51640549e-01f, -1.16074663e-02f, 9.45217311e-02f, 3.17143500e-01f, 2.16687888e-01f,
  2.43268341e-01f, 1.23739213e-01f, 2.82858908e-01f, 1.82338953e-01f, -2.37555668e-01f, 1.43708900e-01f, 6.44110441e-02f, -1.07790433e-01f, 7.47093186e-02f, 9.43563581e-02f,
  2.77894828e-02f, 1.83510229e-01f, -3.22274230e-02f, 2.22223267e-01f, -1.14720434e-01f, -2.85804868e-01f, 2.29478609e-02f, -8.14157575e-02f, -1.64667010e-01f, 8.91758204e-02f,
  -1.05219319e-01f, 4.74247895e-02f, 1.17612422e-01f, -9.74847749e-02f, 1.27002388e-01f, -1.24478303e-02f, 8.57467875e-02f, 2.60817081e-01f, -1.15092792e-01f, 2.68209845e-01f,
  1.41687125e-01f, 2.42415398e-01f, -8.21761321e-03f, 6.56711534e-02f, -1.32962033e-01f, -1.13395371e-01f, -4.17964533e-02f, -5.71510755e-02f, 7.15207160e-02f, -1.60808098e-02f,
  -2.43756678e-02f, 1.03025362e-01f, 7.26601556e-02f, 1.09324448e-01f, -2.59700343e-02f, 7.23806173e-02f, -1.74027696e-01f, 1.20884441e-01f, 1.36663511e-01f, 1.44321639e-02f,
  5.38527854e-02f, 2.31298417e-01f, 1.30940229e-01f, -2.54009277e-01f, -2.34790705e-02f, 4.40204330e-02f, 1.23969950e-01f, 8.98047164e-03f, -6.97512552e-02f, 1.36550590e-01f,
  -4.69203144e-02f, 2.88970202e-01f, 1.84255540e-01f, 1.97002247e-01f, 1.48646444e-01f, 1.05975501e-01f, 8.21204111e-02f, 2.39735201e-01f, -4.48910035e-02f, 1.51803419e-01f,
  1.13105714e-01f, -3.14788707e-02f, 1.40211880e-01f, -5.50040752e-02f, 2.32213035e-01f, 3.28182220e-01f, 2.10145768e-03f, 1.93808421e-01f, -1.89988419e-01f, -4.01998967e-01f,
  1.18576974e-01f, -1.15038589e-01f, -9.80092287e-02f, -6.99657053e-02f, -1.49335653e-01f, -2.70402674e-02f, 7.86014646e-02f, 6.62681684e-02f, 6.97398707e-02f, -5.05072549e-02f,
  8.56673047e-02f, 1.68747276e-01f, -9.30205286e-02f, 2.48362720e-01f, 7.12313503e-02f, 1.72752887e-01f, -5.59404716e-02f, 1.73981532e-01f, -2.19859146e-02f, -1.03550039e-01f,
  -1.60679847e-01f, 2.34097503e-02f, 2.35231537e-02f, 1.27109990e-01f, -1.26558900e-01f, 2.30179150e-02f, 1.41885966e-01f, 1.72629401e-01f, 9.89208817e-02f, -4.60167788e-02f,
  -1.74569532e-01f, 4.06093858e-02f, 9.18778554e-02f, 1.14983566e-01f, 3.74066457e-02f, 2.09195569e-01f, 9.91130769e-02f, -1.50370508e-01f, -6.64357468e-02f, 2.20773116e-01f,
  -2.06314661e-02f, 9.44384113e-02f, -3.90895046e-02f, 1.66290805e-01f, -2.60248668e-02f, 3.44009250e-01f, 2.11588308e-01f, 4.84621562e-02f, 2.26955101e-01f, 2.68737823e-01f,
  7.56463259e-02f, 1.23872943e-01f, -1.36821764e-02f, 1.19338728e-01f, 2.35265762e-01f, -1.58895385e-02f, 2.95759109e-03f, -2.50185013e-01f, -7.07653090e-02f, -4.75922152e-02f,
  1.01936601e-01f, 3.40429246e-02f, 4.63532098e-03f, 2.28132263e-01f, 2.03120291e-01f, 3.03966016e-01f, -5.05085243e-03f, -3.56131867e-02f, -9.34314355e-02f, 1.09879468e-02f,
  9.40934196e-02f, -3.21449079e-02f, 2.30487049e-01f, 1.72694772e-01f, 6.84986338e-02f, -2.46688485e-01f, -2.58306656e-02f, -1.14784963e-01f, 2.14633811e-02f, -8.28543231e-02f,
  2.47077972e-01f, 4.20694612e-02f, 2.75140643e-01f, 1.72475502e-01f, -1.36742502e-01f, 3.35426442e-02f, -1.07941195e-01f, 2.38798633e-02f, -4.85190284e-03f, -1.54490322e-01f,
  5.11032902e-02f, 2.87141502e-02f, -1.10806286e-01f, -1.82547361e-01f, 1.72556058e-01f, -2.78019644e-02f, 1.00962020e-01f, 2.48684734e-01f, 3.00858110e-01f, -5.52048050e-02f,
  -4.57014740e-02f, 7.86347836e-02f, 1.05268270e-01f, -3.99659127e-02f, 1.13444053e-01f, 1.98878303e-01f, 4.43005264e-02f, 3.62679064e-02f, -2.50136834e-02f, 4.33190539e-02f,
  8.86577070e-02f, 9.28646233e-03f, -1.87433604e-03f, 6.41606003e-02f, -3.58596742e-02f, 8.61397535e-02f, 3.83480042e-02f, -2.85289228e-01f, -1.45201460e-01f, 1.85372189e-01f,
  1.74121112e-02f, -1.83476985e-01f, -8.31091106e-02f, -5.54185994e-02f, -9.05820727e-02f, -8.67847875e-02f, 1.32186502e-01f, 4.21650298e-02f, -8.11868757e-02f, -1.65148735e-01f,
  -7.44630173e-02f, -3.59939900e-03f, 3.85797722e-03f, 5.94334491e-02f, 9.81484056e-02f, 1.87474508e-02f, -2.07311898e-01f, -9.45850685e-02f, 2.42273435e-01f, -1.27269685e-01f,
  1.35716155e-01f, 6.39198720e-02f, -5.34369901e-04f, -1.98101982e-01f, -3.20822857e-02f, 1.13745034e-01f, 5.13866134e-02f, 2.63671815e-01f, -7.32337013e-02f, 4.18307371e-02f,
  9.98610854e-02f, -9.44648087e-02f, 6.33710250e-02f, -5.15590794e-02f, -6.49499241e-03f, -2.77890593e-01f, -1.24974653e-01f, -1.09990992e-01f, 1.60649553e-01f, -2.08439827e-01f,
  -1.77173078e-01f, 9.70639139e-02f, -1.53946400e-01f, -5.18375784e-02f, -9.34055671e-02f, -3.84147540e-02f, 2.56277859e-01f, -1.64251953e-01f, -1.26230866e-01f, -4.10351194e-02f,
  9.79548041e-03f, 1.03177965e-01f, -1.59319583e-02f, -1.11984201e-02f, 1.84298933e-01f, 1.52399525e-01f, 2.29941219e-01f, 1.49159864e-01f, 2.82762021e-01f, 1.44437447e-01f,
  1.12959772e-01f, -1.66873127e-01f, -1.91006765e-01f, -4.41766828e-02f, 2.64132526e-02f, 4.45641093e-02f, -3.12769450e-02f, 3.04294765e-01f, 7.38122612e-02f, -9.32889804e-02f,
  -2.18634769e-01f, -1.12239726e-01f, -1.18278012e-01f, -2.57625341e-01f, 1.14773057e-01f, 1.77432090e-01f, -7.26396441e-02f, 1.20338239e-01f, 6.72129244e-02f, 5.94558567e-02f,
  -2.78143417e-02f, 9.86303091e-02f, 1.30899549e-01f, -1.68804407e-01f, -6.85602054e-02f, 2.20693737e-01f, 1.70645982e-01f, -7.66099468e-02f, -2.46165350e-01f, 4.05879676e-01f,
  -1.42614392e-03f, 1.83833987e-01f, -3.65843885e-02f, 2.14470580e-01f, 6.75118417e-02f, 1.98704794e-01f, -2.39512492e-02f, 1.85262915e-02f, 6.22598231e-02f, -2.43482664e-01f,
  -1.93411037e-01f, 1.09666467e-01f, -2.05782831e-01f, 1.67577416e-01f, -1.99424438e-02f, -5.54548539e-02f, 2.39401549e-01f, 9.74021628e-02f, -1.11221075e-01f, 1.48990929e-01f,
  1.46998137e-01f, -1.87946931e-02f, 1.18160717e-01f, 5.79703636e-02f, -1.18610092e-01f, 2.56470382e-01f, 3.23461145e-02f, 4.02624696e-01f, 1.37270287e-01f, 1.60626188e-01f,
  1.02991723e-01f, 1.94541991e-01f, 2.70765591e-02f, 2.72299260e-01f, 2.72991776e-01f, -1.73165664e-01f, -1.14744402e-01f, 1.04846172e-01f, 1.89984769e-01f, 1.75296634e-01f,
  1.82377905e-01f, 1.25465661e-01f, -3.11274230e-01f, 1.21617325e-01f, -3.26088443e-02f, 5.89587772e-03f, -5.09137288e-02f, -1.92616627e-01f, -1.07300477e-02f, 1.17694482e-01f,
  7.33616576e-02f, 7.96662495e-02f, -1.68259338e-01f, 1.63807839e-01f, 3.54377180e-02f, 2.14555711e-01f, -1.15018018e-01f, 5.22143506e-02f, -7.93379173e-02f, 3.38482827e-01f,
  9.51227024e-02f, 6.56654164e-02f, -2.54499435e-01f, 1.88108519e-01f, 1.69935375e-01f, -1.27941519e-01f, 1.20738279e-02f, 2.76566535e-01f, 1.13877058e-01f, 9.95766148e-02f,
  2.60261685e-01f, -2.26256922e-01f, 1.02495722e-01f, 3.07160765e-01f, 1.11611515e-01f, -3.01673144e-01f, -1.56755388e-01f, 4.92020734e-02f, 5.57246208e-02f, -2.75246013e-04f,
  -1.63844153e-01f, -1.05070043e-02f, 7.26997331e-02f, -1.30297214e-01f, 1.10738203e-01f, 1.79130897e-01f, 7.63675570e-02f, -1.98971659e-01f, -1.36641234e-01f, 4.09639739e-02f,
  1.99567005e-01f, 3.00842255e-01f, 8.63533318e-02f, 4.56927232e-02f, 1.08615473e-01f, 1.37103513e-01f, 2.17477903e-01f, 2.25434273e-01f, -1.38213381e-01f, 5.34147620e-02f,
  -1.67387128e-01f, 6.80920929e-02f, -1.01345561e-01f, 1.76816836e-01f, -8.41827020e-02f, -4.88015376e-02f, 5.93607035e-03f, -5.45037389e-02f, -2.03424782e-01f, 1.15197949e-01f,
  -3.66658777e-01f, 8.82734433e-02f, -4.64333408e-02f, 6.76687360e-02f, -1.59325898e-01f, 2.20842902e-02f, 3.37273121e-01f, -8.67373869e-02f, 6.38081804e-02f, -1.76353246e-01f,
  3.31891805e-01f, -1.85613185e-01f, -9.26295146e-02f, 3.29815932e-02f, 6.39308095e-02f, -2.00110584e-01f, 2.95940012e-01f, 1.26115113e-01f, -1.90316394e-01f, 1.91956744e-01f,
  4.46692109e-02f, 2.14575082e-02f, 1.47971272e-01f, -1.88744634e-01f, -1.08501408e-02f, -5.57285100e-02f, -7.37042129e-02f, -2.49898240e-01f, -9.16812122e-02f, -6.71120882e-02f,
  1.57306403e-01f, 2.22702160e-01f, -3.44146341e-01f, -5.07558398e-02f, -2.75411427e-01f, 2.18207210e-01f, 1.76892519e-01f, -2.02778261e-03f, 1.19006954e-01f, -7.09844232e-02f,
  -2.35875417e-02f, -1.40729427e-01f, -2.08671782e-02f, -2.35449150e-01f, -1.45882651e-01f, -1.35786846e-01f, 1.80407166e-01f, 9.61329490e-02f, 1.46649987e-01f, 2.77513593e-01f,
  2.81030014e-02f, 1.88477427e-01f, 1.56205982e-01f, 2.18997791e-01f, 5.39493859e-02f, 1.99092571e-02f, -1.86485618e-01f, 6.01330735e-02f, -3.14787477e-02f, -5.44755533e-02f,
  2.39130393e-01f, -1.05957493e-01f, 7.21604154e-02f, 4.10306245e-01f, -2.65946507e-01f, 1.00394472e-01f, -1.57808289e-02f, -2.79182382e-02f, 1.08627111e-01f, -2.93847062e-02f,
  2.92294621e-01f, -1.48493364e-01f, 2.91052878e-01f, -2.39675596e-01f, 1.37533113e-01f, 5.80625944e-02f, 1.67973816e-01f, -1.56098500e-01f, 6.07923940e-02f, -1.50005065e-03f,
  1.97093576e-01f, 5.03571294e-02f, -2.03852072e-01f, 1.01326428e-01f, -1.85244381e-01f, 2.01824456e-01f, 4.01790775e-02f, -1.00002982e-01f, -2.35558972e-01f, 1.53790832e-01f,
  -1.14915133e-01f, -6.21559024e-02f, -6.69680759e-02f, -3.51878032e-02f, 7.06055686e-02f, 1.87996656e-01f, -1.41147450e-01f, -6.36313483e-02f, 5.01433164e-02f, 1.67650223e-01f,
  -1.10006846e-01f, -1.99590608e-01f, 9.64150727e-02f, 6.06413372e-02f, 3.11136782e-01f, -5.40704699e-03f, 9.15690586e-02f, -2.10445032e-01f, -1.45303309e-01f, -5.24041653e-02f,
  2.23453477e-01f, 4.44667265e-02f, 2.12658942e-01f, 5.48216775e-02f, 1.82383746e-01f, 2.22398415e-01f, -1.37138460e-02f, 2.11684808e-01f, -3.29666622e-02f, 7.15177283e-02f,
  -1.44137695e-01f, 9.61271301e-02f, -1.88622758e-01f, -8.56245589e-03f, -9.81796831e-02f, -1.66292489e-01f, -3.45392339e-03f, 3.00464600e-01f, -4.39699218e-02f, -9.01682710e-04f,
  -1.41379097e-02f, 1.07462861e-01f, 2.04990972e-02f, 9.29214135e-02f, 1.24119394e-01f, -2.92313062e-02f, 6.92432746e-02f, -9.84928459e-02f, 2.56362736e-01f, -6.08994700e-02f,
  1.48103172e-02f, -2.10025042e-01f, 2.26595923e-01f, -2.46459961e-01f, 9.52724218e-02f, 7.38387778e-02f, -1.33337723e-02f, 1.93863645e-01f, 9.35838223e-02f, 1.30887941e-01f,
  6.02214271e-03f, -1.37089387e-01f, -9.30921882e-02f, -7.37035573e-02f, 9.46804211e-02f, -1.30238503e-01f, -1.65314585e-01f, -1.30293563e-01f, 1.52920350e-01f, 1.99317425e-01f,
  -2.48126775e-01f, 1.32378906e-01f, 5.42535484e-02f, 1.95589855e-01f, 4.39032689e-02f, 6.86982200e-02f, -4.45808517e-03f, -1.79079309e-01f, 1.49904594e-01f, 6.19284660e-02f,
  1.08473152e-01f, 3.66967432e-02f, -1.29461035e-01f, -1.97092757e-01f, 1.65910631e-01f, 8.51630047e-02f, 5.16574867e-02f, 1.46928519e-01f, 2.63590544e-01f, 2.53230304e-01f,
  2.24966094e-01f, -2.34783098e-01f, -1.49844870e-01f, 8.75618011e-02f, 2.12451249e-01f, 1.34379463e-02f, 2.18281671e-02f, 1.44970834e-01f, -9.01224315e-02f, 7.33216330e-02f,
  9.52133089e-02f, 2.56338894e-01f, 3.20582949e-02f, -3.15060616e-01f, -1.30144075e-01f, -5.71132675e-02f, 4.48587313e-02f, -1.76558465e-01f, -1.01420425e-01f, 3.38384844e-02f,
  -2.00754344e-01f, 8.20150301e-02f, 1.52871266e-01f, 1.24709025e-01f, 3.77509333e-02f, 1.94221362e-01f, -1.62605047e-01f, 2.33575866e-01f, -1.24852784e-01f, 1.89325020e-01f,
  1.50224000e-01f, 1.36672035e-02f, -1.41625986e-01f, 2.42745839e-02f, 5.62134124e-02f, -2.26509050e-02f, 2.77146310e-01f, -3.48920077e-02f, -2.14830890e-01f, 2.57411838e-01f,
  -2.01962925e-02f, -2.42619127e-01f, 1.78362336e-02f, -1.00289673e-01f, -1.68627072e-02f, -5.60091212e-02f, -3.23847169e-03f, -2.68191136e-02f, -6.97413310e-02f, -2.54813045e-01f,
  2.81055391e-01f, 6.44071624e-02f, -2.48825196e-02f, -1.01998195e-01f, -1.83376297e-02f, -7.84307867e-02f, 2.65560031e-01f, 6.88725859e-02f, 5.76618016e-02f, -1.90395355e-01f,
  -7.26677701e-02f, -2.07447298e-02f, -8.89862850e-02f, 6.99145049e-02f, 8.15016702e-02f, -1.19327649e-01f, -1.00274213e-01f, -3.88121419e-02f, -3.91046219e-02f, 2.96459887e-02f,
  1.53279752e-01f, -8.79785419e-02f, 3.14169400e-03f, 4.41332757e-01f, -6.57855943e-02f, 8.09879825e-02f, 4.11055386e-02f, 7.71965906e-02f, 7.05474988e-02f, -3.33250538e-02f,
  -4.03249562e-02f, 2.89923828e-02f, -1.74719945e-01f, 1.61685973e-01f, -1.01947360e-01f, 1.15477331e-01f, -5.59751280e-02f, 1.63843483e-02f, 7.66443741e-03f, -2.45783608e-02f,
  -9.51313898e-02f, 9.32132825e-02f, 6.13489235e-03f, 1.82486773e-02f, 3.06937639e-02f, 1.35596603e-01f, 1.13546155e-01f, -9.76079106e-02f, 6.44789934e-02f, -6.74638376e-02f,
  1.56751260e-01f, -3.02922092e-02f, -1.02333471e-01f, 6.88601360e-02f, 1.68952733e-01f, 9.97559447e-03f, -2.98246928e-02f, -1.19339272e-01f, -9.81812552e-03f, -6.74181059e-02f,
  -3.00832570e-01f, -1.38976514e-01f, 1.54586822e-01f, 2.99120527e-02f, -3.28316055e-02f, -5.81977516e-02f, -1.06114522e-02f, -3.96528281e-02f, 5.28727882e-02f, -5.14640287e-02f,
  2.23883003e-01f, -2.12394431e-01f, 1.27633035e-01f, 1.25727043e-01f, 2.30063796e-01f, 1.86404392e-01f, 5.18707819e-02f, -1.63023211e-02f, 9.76655930e-02f, 1.03003502e-01f,
  -3.36147510e-02f, -1.19935162e-01f, -4.69465740e-03f, -1.67104796e-01f, -1.38094231e-01f, 1.19581379e-01f, 1.97057024e-01f, -9.58752334e-02f, -6.77772388e-02f, 9.86575931e-02f,
  5.54343723e-02f, 1.59622088e-01f, 1.31151795e-01f, 7.40288422e-02f, 7.36205280e-02f, 7.55073503e-02f, -1.84006465e-04f, -7.24253356e-02f, 8.79298747e-02f, 2.33221203e-01f,
  -1.71291173e-01f, -2.06712589e-01f, 1.15591139e-02f, -4.30417880e-02f, 2.37777159e-01f, -2.80466070e-03f, -3.78615223e-02f, 8.02621990e-02f, 1.83213547e-01f, 1.00731879e-01f,
  -3.25546116e-02f, 2.41132632e-01f, -3.06427069e-02f, 1.37714878e-01f, 6.77664801e-02f, -8.60796124e-02f, 2.41853431e-01f, -1.06693273e-02f, -6.20491169e-02f, -5.55638410e-02f,
  3.39237899e-02f, 1.13706477e-01f, 5.41148148e-02f, 1.35696128e-01f, 3.34787518e-01f, 6.02213405e-02f, -2.05881849e-01f, 2.35237375e-01f, -5.31563051e-02f, 1.09656394e-01f,
  7.48746246e-02f, 6.31060451e-02f, 5.97313382e-02f, 2.43132964e-01f, 1.32800445e-01f, 2.45433897e-01f, 1.03960060e-01f, 3.01446766e-01f, 1.04377948e-01f, 1.39436200e-01f,
  2.92081743e-01f, 2.55479783e-01f, -1.86408520e-01f, 2.31115699e-01f, 1.18485637e-01f, 6.40640827e-03f, -8.86391774e-02f, 3.08509171e-03f, -1.12496980e-01f, -1.18659943e-01f,
  -2.42585689e-01f, 4.49210182e-02f, -8.49812403e-02f, -4.63049501e-01f, 1.70298144e-01f, 3.74882191e-01f, -4.09429893e-02f, 1.69746935e-01f, -4.73920517e-02f, -2.98608579e-02f,
  2.19018832e-01f, -1.98134184e-01f, 1.18952930e-01f, -1.40330225e-01f, -2.57228076e-01f, 1.27191558e-01f, -3.86999249e-02f, -1.14940204e-01f, 1.65570781e-01f, -1.27804041e-01f,
  1.56829163e-01f, -1.12517826e-01f, 1.04714796e-01f, -5.27378544e-02f, 1.83368325e-01f, -2.32860729e-01f, -1.17526032e-01f, -1.87336415e-01f, 2.88393617e-01f, -6.33149967e-02f,
  2.29506418e-01f, 6.42644288e-03f, -8.46010074e-02f, -7.15680001e-03f, 9.39364210e-02f, 1.07959121e-01f, -1.63420096e-01f, 1.96946532e-01f, -8.12443942e-02f, 3.05633873e-01f,
  2.99901336e-01f, -7.50290453e-02f, -1.82926152e-02f, -2.95159906e-01f, -3.60607952e-01f, 1.68818250e-01f, 9.96409357e-02f, 2.30872747e-03f, -1.61023155e-01f, -1.77879244e-01f,
  1.08955204e-01f, -5.24295829e-02f, 1.25762299e-01f, -1.43235415e-01f, 1.76808372e-01f, 1.73801273e-01f, 4.62702364e-02f, -2.54815191e-01f, -1.63378790e-01f, 1.56737730e-01f,
  6.22436889e-02f, 1.58228297e-02f, 5.84736280e-02f, -1.61613330e-01f, -2.48598114e-01f, 6.33526668e-02f, 1.23861231e-01f, 1.30729094e-01f, -6.69241603e-03f, 3.14817764e-02f,
  -9.28354412e-02f, 9.67897102e-03f, 1.87262043e-01f, 6.37644306e-02f, -1.14631131e-01f, 1.07589900e-01f, -2.39872918e-01f, 8.71201530e-02f, -5.86335408e-03f, -2.15754479e-01f,
  2.01364264e-01f, 1.80710971e-01f, -1.14387326e-01f, -2.19459787e-01f, -1.32373005e-01f, 1.54150560e-01f, 2.48697400e-01f, 1.43159494e-01f, 5.19680455e-02f, 1.32589564e-01f,
  6.61962703e-02f, -1.37371674e-01f, 1.48188099e-01f, -3.56557667e-01f, -9.37190205e-02f, -2.73870360e-02f, 7.72244260e-02f, -5.22840470e-02f, 4.29881103e-02f, -2.40345910e-01f,
  -3.80246155e-02f, -9.41138417e-02f, 1.12099573e-04f, -2.01070413e-01f, 4.37327884e-02f, 1.53410584e-01f, 2.02157646e-01f, -1.62592635e-01f, -9.21660587e-02f, -1.20731868e-01f,
  -9.44384634e-02f, 3.23974527e-02f, 3.60691398e-01f, -2.45883927e-01f, 1.26083151e-01f, 1.39956385e-01f, -2.09999293e-01f, -2.73174196e-01f, 6.66542351e-02f, -2.32135076e-02f,
  -1.05727166e-01f, 2.01293498e-01f, 2.37842903e-01f, 9.53306556e-02f, -2.34624922e-01f, 7.34954998e-02f, 3.93029034e-01f, 1.99525833e-01f, -6.38240874e-02f, 1.46056026e-01f,
  -7.14308466e-04f, -3.02934289e-01f, -7.25883693e-02f, 7.17014521e-02f, 9.63622406e-02f, 1.09995738e-01f, 8.46376270e-02f, 1.04630627e-01f, 2.70635542e-02f, 3.94800976e-02f,
  -5.04982769e-02f, 1.13823652e-01f, -1.72733292e-02f, 2.47952193e-01f, -1.13252513e-01f, 9.54101458e-02f, 1.06703471e-02f, 7.88141042e-02f, -2.48566881e-01f, -9.75589603e-02f,
  -1.29860565e-01f, 1.19927824e-01f, 9.24458820e-03f, 1.14184171e-01f, 2.40088746e-01f, -2.90548019e-02f, -4.23677452e-02f, 1.83799848e-01f, 4.71143425e-03f, -1.91391364e-01f,
  9.53053385e-02f, 1.99773908e-01f, -2.49868006e-01f, 1.41783476e-01f, 1.19572520e-01f, -2.57557929e-01f, 5.95795624e-02f, 1.95744634e-01f, 1.11497916e-01f, -1.03883483e-01f,
  -1.41549736e-01f, 2.59999484e-01f, 2.47534737e-01f, 8.91685188e-02f, 8.98099467e-02f, 2.13176116e-01f, -1.47010148e-01f, 1.55688524e-01f, 1.31640047e-01f, 1.55083388e-01f,
  -7.99982250e-03f, 1.95811883e-01f, 1.74254492e-01f, 1.62931249e-01f, -3.50669511e-02f, 1.62509263e-01f, 6.26460090e-02f, 8.78105778e-03f, -1.43293500e-01f, 6.33850545e-02f,
  -8.11875388e-02f, -1.89172581e-01f, 2.39615254e-02f, -2.94058353e-01f, -2.80948114e-02f, 1.42237738e-01f, 1.97221208e-02f, 2.97522426e-01f, -9.33014154e-02f, 1.21170968e-01f,
  -2.25093409e-01f, -1.06170408e-01f, 3.31544846e-01f, 3.37395370e-02f, 8.52739140e-02f, -1.88236207e-01f, 3.85493308e-01f, -1.75721839e-01f, -1.42171159e-01f, 5.79434633e-02f,
  9.45332870e-02f, -2.91848719e-01f, 2.35182941e-01f, 6.09931014e-02f, -3.67896780e-02f, 5.18535338e-02f, 3.70840989e-02f, 6.95957318e-02f, 9.45615545e-02f, -4.72211204e-02f,
  -1.53040096e-01f, -8.78163427e-02f, 3.68793420e-02f, -1.68251902e-01f, -9.79793519e-02f, -7.82716423e-02f, 3.48840386e-01f, 8.98631662e-02f, -2.57634431e-01f, 1.90437108e-01f,
  5.30275516e-03f, 2.31593594e-01f, 1.87045321e-01f, 8.76663104e-02f, 4.55509163e-02f, 9.38686058e-02f, 3.84756401e-02f, 6.41773865e-02f, -4.30421270e-02f, -2.61515737e-01f,
  -2.20257938e-01f, -3.14816773e-01f, 1.55919820e-01f, 1.70898125e-01f, 1.99285634e-02f, -3.44611816e-02f, 1.10652566e-01f, 1.31829143e-01f, -7.15599358e-02f, 1.46033987e-01f,
  4.76811044e-02f, -4.89292070e-02f, 7.88948834e-02f, -4.25287802e-03f, 2.57931054e-01f, 3.12673599e-01f, -9.83219072e-02f, -1.55326994e-02f, -1.12229645e-01f, -3.29171002e-01f,
  1.21027432e-01f, 4.06172089e-02f, -1.81863636e-01f, 8.26710612e-02f, -1.61048383e-01f, -7.20437095e-02f, -1.02839917e-02f, -2.17830427e-02f, 9.44389030e-03f, 1.45337284e-01f,
  8.59279335e-02f, 2.22529843e-01f, -4.41305637e-02f, 2.31944829e-01f, -1.39505835e-02f, 1.60762832e-01f, -1.73537493e-01f, 9.66842696e-02f, 2.31566504e-02f, 1.99014638e-02f,
  -2.14776248e-02f, 5.21455929e-02f, 7.11363275e-03f, 1.35133103e-01f, -1.18698739e-01f, 2.00983994e-02f, 9.98733416e-02f, -2.36737635e-03f, 1.83104783e-01f, 9.86668468e-02f,
  -1.62551343e-01f, 1.51568670e-02f, 1.55099243e-01f, 6.45871758e-02f, 1.70298710e-01f, 1.61911830e-01f, -5.66566661e-02f, -1.88768417e-01f, -7.45803118e-03f, 2.22728059e-01f,
  6.59882128e-02f, 1.22795686e-01f, 5.76166622e-03f, 3.57806720e-02f, 2.79198084e-02f, 1.83414817e-01f, 1.55523255e-01f, 2.08978020e-02f, 2.82797311e-02f, -5.24452180e-02f,
  5.93158528e-02f, 3.49402018e-02f, -6.52504861e-02f, -6.65471703e-02f, -2.81089470e-02f, 6.46958202e-02f, -1.12526692e-01f, 9.47462320e-02f, 2.45079562e-01f, 1.79244578e-02f,
  -4.41285372e-02f, 2.18670756e-01f, 2.56813079e-01f, -1.92232922e-01f, -2.93315854e-02f, 1.23170428e-01f, 8.24776068e-02f, 1.54615387e-01f, 1.10627867e-01f, 6.77467212e-02f,
  8.54323618e-03f, 1.30110756e-01f, -5.74911721e-02f, 1.41034976e-01f, -1.74781874e-01f, -1.77413777e-01f, 2.75634900e-02f, 1.64181724e-01f, -3.45704076e-03f, -1.54676378e-01f,
  1.85067914e-02f, -1.87769327e-02f, -1.13796778e-02f, 6.84309155e-02f, 1.36165887e-01f, -3.64875086e-02f, 1.42355442e-01f, -1.78442360e-03f, 1.12681620e-01f, -5.40142991e-02f,
  1.70932654e-02f, -2.83138566e-02f, 1.86517745e-01f, 7.85086527e-02f, -2.18252435e-01f, 8.50785710e-03f, 2.78279241e-02f, 3.22532766e-02f, -1.37414739e-01f, -9.37113017e-02f,
  2.60880202e-01f, -4.01588492e-02f, -1.39216810e-01f, -1.93185899e-02f, 4.09710445e-02f, 3.34977694e-02f, 1.10495962e-01f, 2.85278577e-02f, 1.90237444e-02f, -2.70750169e-02f,
  7.72385374e-02f, 3.79484296e-02f, 1.21438712e-01f, -1.00721866e-01f, 1.27738446e-01f, -3.56228538e-02f, -2.84393042e-01f, 1.41212955e-01f, 6.48470670e-02f, 8.30089580e-03f,
  1.44183621e-01f, -3.17494184e-01f, -5.17157726e-02f, 2.94120181e-02f, -1.85331479e-01f, 2.30891079e-01f, 5.76676279e-02f, -2.34957919e-01f, 2.25144029e-01f, 4.04731393e-01f,
  7.87910894e-02f, 1.55560330e-01f, 9.12708193e-02f, 1.32246763e-01f, -7.03706369e-02f, -8.88240635e-02f, 9.16633606e-02f, 2.63126373e-01f, -3.46956849e-01f, -1.92061782e-01f,
  -7.53881335e-02f, -4.05653659e-03f, 1.68019429e-01f, -8.94783437e-02f, 5.65639921e-02f, 2.55770679e-03f, 1.13982178e-01f, -1.05483979e-02f, -1.23875007e-01f, 6.19064271e-02f,
  -1.61246404e-01f, 1.07881680e-01f, 1.36056513e-01f, -2.37287819e-01f, 2.03937873e-01f, -1.96883515e-01f, -2.71067321e-02f, -1.31552592e-01f, -1.60310939e-01f, -7.39086792e-02f,
  4.17608730e-02f, 2.97965765e-01f, 1.27110064e-01f, 1.14900611e-01f, -1.53213054e-01f, 5.09835184e-02f, -1.88097998e-01f, -6.88704252e-02f, 2.07497794e-02f, 1.83731869e-01f,
  -2.43429691e-01f, 2.13262290e-01f, -1.19986035e-01f, -3.59738199e-03f, -2.00680504e-03f, -1.26596600e-01f, 1.18641503e-01f, -6.59696758e-02f, -1.59750506e-02f, 3.96557860e-02f,
  5.95113076e-02f, -5.15045375e-02f, -3.05468708e-01f, 3.09338067e-02f, 5.30618672e-05f, -4.62915655e-03f, 1.98609635e-01f, -2.13988259e-01f, -2.18780801e-01f, -5.81850298e-02f,
  5.92435971e-02f, 8.17170739e-02f, -2.64553837e-02f, 1.21260680e-01f, -1.52592957e-01f, -4.42472734e-02f, -1.28420293e-01f, -1.20559137e-03f, 1.89375542e-02f, -4.06008866e-03f,
  -1.42923877e-01f, 4.26267385e-02f, -2.18170714e-02f, -1.21781960e-01f, 1.33329183e-01f, 8.61831009e-02f, -8.30871835e-02f, -1.13842681e-01f, 6.93494678e-02f, 1.73995152e-01f,
  1.41593933e-01f, 7.09611177e-02f, -1.84419066e-01f, -4.06045839e-02f, 1.95619866e-01f, -1.06876887e-01f, 3.04766089e-01f, -6.57535419e-02f, -2.20269300e-02f, 2.87438487e-03f,
  2.51646578e-01f, -1.01591557e-01f, 1.38861202e-02f, -1.17781445e-01f, 4.65159863e-02f, -6.92157745e-02f, -1.79810468e-02f, -1.25135660e-01f, 1.89720079e-01f, -1.15300477e-01f,
  -1.55306403e-02f, -1.03619434e-01f, -6.98245913e-02f, -1.98459327e-02f, -1.29824772e-01f, -1.26801997e-01f, 2.68131524e-01f, -1.84778944e-01f, -2.98947897e-02f, 5.89011610e-02f,
  1.46849155e-01f, 7.89666623e-02f, 7.86124691e-02f, -5.60756773e-02f, -1.41021684e-01f, 1.66392565e-01f, 8.06218460e-02f, -1.09785572e-01f, -7.26665109e-02f, -1.34924755e-01f,
  6.95528388e-02f, 1.18081294e-01f, -2.54348159e-01f, -6.61552772e-02f, 1.14865258e-01f, -1.73214093e-01f, 1.84156477e-01f, 6.74776658e-02f, 6.52315095e-02f, 1.55508101e-01f,
  -8.36641935e-04f, 8.70960653e-02f, 5.29596098e-02f, 1.00077003e-01f, 1.29657939e-01f, 6.35738820e-02f, -1.91268727e-01f, -2.61452198e-01f, 6.32548407e-02f, -2.33886719e-01f,
  3.19369808e-02f, -2.03016892e-01f, 1.66923534e-02f, -1.64578810e-01f, -3.70751210e-02f, -2.16060802e-02f, 8.43871981e-02f, 7.58820474e-02f, -6.47095442e-02f, 1.55685350e-01f,
  7.89984986e-02f, -1.24128200e-01f, 1.66374400e-01f, -1.94911033e-01f, -1.62941039e-01f, -2.19150722e-01f, 5.77058345e-02f, 3.75499502e-02f, 1.75250560e-01f, 1.74826682e-01f,
  1.81501254e-01f, 1.75658464e-01f, 7.06759281e-03f, 4.66785617e-02f, -4.14784858e-03f, -1.81399602e-02f, -1.42303482e-01f, 1.57259405e-01f, -7.53569081e-02f, 2.48074308e-01f,
  -1.60098433e-01f, 3.15318704e-02f, 3.44548114e-02f, 1.76540658e-01f, 6.75560981e-02f, 1.11713812e-01f, -4.23255526e-02f, 9.43906792e-03f, 6.84909597e-02f, 1.12033106e-01f,
  4.34194412e-03f, 8.52707103e-02f, 4.97600846e-02f, 1.18027991e-02f, 1.01558022e-01f, 2.42897734e-01f, -8.19047689e-02f, -1.96944728e-01f, 1.29670233e-01f, -1.03214346e-01f,
  1.88907623e-01f, -9.22903121e-02f, 1.34545207e-01f, 1.57147676e-01f, 1.12677611e-01f, 1.25535175e-01f, 3.84193053e-03f, -7.52853081e-02f, 9.12280977e-02f, 1.85917646e-01f,
  -1.36254340e-01f, -1.35694504e-01f, 3.64134312e-02f, 2.36884778e-04f, 1.83700413e-01f, 8.29756632e-03f, -1.41334012e-01f, -1.56520754e-02f, 4.81860973e-02f, 1.00384438e-02f,
  1.34960935e-01f, 1.99657202e-01f, -1.02777414e-01f, 2.25767940e-01f, -1.50255738e-02f, 4.46034223e-02f, 2.40323544e-01f, 1.11848386e-02f, -8.36608261e-02f, 2.22966671e-02f,
  -6.13045730e-02f, 9.25946310e-02f, 8.21098536e-02f, 2.88995169e-03f, 2.03411892e-01f, 6.84003234e-02f, -1.09843858e-01f, 1.30990431e-01f, 7.14691356e-02f, 6.48016334e-02f,
  -1.43140014e-02f, 9.02040526e-02f, 7.70704299e-02f, 1.72994316e-01f, -6.89834133e-02f, 9.21842903e-02f, 9.90954563e-02f, 2.88686436e-02f, 1.62318543e-01f, 1.55202255e-01f,
  6.69669285e-02f, 1.43014044e-01f, -2.90521771e-01f, 1.36757374e-01f, 2.42887307e-02f, -1.06061831e-01f, 4.11032028e-02f, -1.33150280e-01f, -1.68933704e-01f, -8.68257508e-02f,
  -9.02212597e-03f, 3.74513924e-01f, 2.26133857e-02f, -2.95011222e-01f, 2.44975016e-01f, 1.45400897e-01f, 1.95775647e-02f, 5.04623279e-02f, 9.10487920e-02f, 4.27733399e-02f,
  1.25326231e-01f, -1.53079823e-01f, 9.08337906e-02f, -8.93150494e-02f, -2.09226951e-01f, 1.49122298e-01f, 1.29441515e-01f, -1.55445144e-01f, 4.98661436e-02f, 7.34101087e-02f,
  1.26881704e-01f, -1.26950160e-01f, 8.43059570e-02f, -1.25856847e-01f, 1.06867306e-01f, -7.00112134e-02f, -3.06672473e-02f, -2.37979680e-01f, 3.10394131e-02f, 1.48942217e-01f,
  1.10091314e-01f, 3.88115048e-02f, -1.36064395e-01f, -2.29427032e-02f, -5.10944761e-02f, 1.17951274e-01f, -1.71979778e-02f, 4.25933190e-02f, 1.75629696e-03f, 1.33053496e-01f,
  1.17874406e-01f, -1.40563652e-01f, -1.29114106e-01f, -1.75254181e-01f, -3.01176190e-01f, 1.70776054e-01f, 7.66073689e-02f, 1.34179499e-02f, -6.04983419e-02f, -9.26949233e-02f,
  3.07342988e-02f, 5.79139218e-02f, 1.04003944e-01f, 2.11952906e-02f, -4.72501479e-03f, 2.49604117e-02f, 3.52113068e-01f, -1.42777950e-01f, -1.18803799e-01f, -8.99186879e-02f,
  8.35181251e-02f, -1.33871973e-01f, -5.67717701e-02f, -1.48397041e-02f, -6.59888238e-02f, -2.29113087e-01f, 1.24057382e-02f, 2.53320187e-01f, 1.59400329e-01f, 1.29296064e-01f,
  -1.97747156e-01f, -1.30848661e-01f, -5.80989905e-02f, 2.87813693e-02f, -9.33879465e-02f, -8.41799006e-02f, -1.10125884e-01f, 8.91482085e-02f, -1.30077854e-01f, 4.08349372e-02f,
  3.91857103e-02f, -3.48027162e-02f, 2.08287910e-02f, 1.30155191e-01f, 6.85409084e-02f, -1.61366865e-01f, 2.61783659e-01f, -2.53528059e-01f, -8.22709948e-02f, 5.87414540e-02f,
  -1.61844090e-01f, 9.72829610e-02f, 1.01271123e-01f, -2.18047634e-01f, 1.34378046e-01f, 1.82965815e-01f, 1.41794756e-01f, -2.98765630e-01f, 1.89464048e-01f, 1.88932475e-02f,
  2.21294537e-01f, 5.76061495e-02f, 1.44419223e-01f, -1.47757143e-01f, -9.56904739e-02f, -1.30826175e-01f, 1.06232025e-01f, 5.05898446e-02f, -1.01735026e-01f, -1.17340321e-02f,
  -8.65870528e-03f, 9.94881392e-02f, 1.82336196e-01f, 1.66245550e-01f, 9.29442421e-02f, 9.00259465e-02f, 6.39766827e-02f, 5.36245704e-02f, 1.26295850e-01f, 7.80647323e-02f,
  -1.00966536e-01f, 6.44981069e-03f, 1.21757062e-02f, 3.61760557e-02f, 4.34605666e-02f, -1.12575144e-01f, -1.05121128e-01f, 2.07158163e-01f, -8.25978965e-02f, 1.95118591e-01f,
  -1.27900973e-01f, -1.51498705e-01f, -1.69813968e-02f, 1.53752165e-02f, -1.53986946e-01f, -1.11316495e-01f, -1.08501993e-01f, -5.63807599e-02f, -4.03686911e-02f, 4.09330502e-02f,
  -3.03159119e-04f, 5.28317839e-02f, -9.01226774e-02f, 2.42097825e-01f, -1.04239628e-01f, 2.63671242e-02f, 4.89386059e-02f, 2.37605721e-01f, -6.26384541e-02f, 9.38431472e-02f,
  -4.45705652e-02f, -7.96737801e-03f, -5.17333560e-02f, -5.27011789e-02f, -6.98599666e-02f, 1.43900394e-01f, 5.08213881e-03f, -3.94714884e-02f, 4.94318455e-02f, 1.20467536e-01f,
  -9.55928117e-03f, 1.66679263e-01f, -6.90768212e-02f, 4.91691055e-03f, 1.61285073e-01f, 4.03985232e-02f, 2.28054881e-01f, -9.20560732e-02f, 7.48502687e-02f, -1.87360749e-01f,
  -1.79433078e-02f, 5.96078634e-02f, 1.41366841e-02f, 1.47103757e-01f, -1.19585238e-01f, 5.19497544e-02f, -3.36699337e-02f, 8.71374458e-02f
};

// L1_fan_Bp_bar (Shape: 1 x 52)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 52;
const float L1_fan_Bp_bar_data[] = {
  2.86704242e-01f, 2.80174941e-01f, 1.20665617e-01f, 2.93436974e-01f, 2.26882443e-01f, 2.49766812e-01f, 1.27328902e-01f, 9.17037427e-02f, 1.37065873e-01f, 9.08981413e-02f,
  1.57768399e-01f, 2.33821079e-01f, 5.64395040e-02f, -3.02397590e-02f, 2.73930859e-02f, 4.40138578e-02f, -9.34137627e-02f, 6.06009625e-02f, 1.70313552e-01f, 9.25437734e-02f,
  2.47275367e-01f, 9.00691841e-03f, 9.84234363e-02f, -8.24471842e-03f, 2.69260198e-01f, -2.67970264e-02f, 2.54400879e-01f, 2.42201567e-01f, 2.26811185e-01f, 2.53693491e-01f,
  1.33916020e-01f, 4.12173271e-02f, 5.33464625e-02f, 2.99172252e-01f, 6.23957478e-02f, 1.03556775e-01f, 1.38112336e-01f, 6.66088536e-02f, 6.06818013e-02f, 1.00550652e-01f,
  1.16274178e-01f, 1.70594230e-02f, 2.61817425e-01f, 5.05231917e-02f, 1.80773929e-01f, 2.66886242e-02f, -7.08251400e-03f, 1.12424947e-01f, 3.52640264e-02f, 1.28523737e-01f,
  8.52177963e-02f, 2.13931184e-02f
};

// L2_fan_Wp (Shape: 6 x 64)
const int L2_fan_Wp_rows = 6;
const int L2_fan_Wp_cols = 64;
const float L2_fan_Wp_data[] = {
  -1.62538737e-02f, -1.54910401e-01f, -2.54040360e-01f, -1.73048213e-01f, -2.62762457e-01f, -1.01096623e-01f, 1.34060562e-01f, 7.68238530e-02f, 9.70086455e-02f, -1.01383723e-01f,
  2.41668493e-01f, -2.22758427e-01f, -1.93652749e-01f, 2.63921707e-03f, 7.49007687e-02f, -8.35244264e-03f, 6.09738939e-02f, 1.10512145e-01f, -7.81396925e-02f, -5.20078018e-02f,
  3.13532978e-01f, 9.32604889e-04f, 6.41740859e-02f, -6.33372143e-02f, -3.51239629e-02f, 1.82578534e-01f, 5.90837821e-02f, 3.04400250e-02f, 1.18796930e-01f, 6.58160672e-02f,
  6.33722395e-02f, 1.69095382e-01f, 7.63934897e-03f, -8.57226029e-02f, -1.13023497e-01f, 1.01693586e-01f, -1.53174207e-01f, 7.18977824e-02f, -1.04857072e-01f, 9.12535004e-03f,
  -2.96962168e-03f, -4.71663661e-02f, -8.75816494e-02f, 1.91831570e-02f, -1.09239757e-01f, 6.84515610e-02f, 5.06426916e-02f, 8.44637305e-02f, -1.61798447e-01f, 2.31472820e-01f,
  1.58978581e-01f, -9.11615342e-02f, -1.97660476e-01f, 7.03740343e-02f, 8.40434209e-02f, 1.06751705e-02f, 8.19667280e-02f, 4.70418632e-02f, -5.09879142e-02f, 1.75045654e-01f,
  1.04752019e-01f, 3.12463772e-02f, -3.87867726e-02f, -3.29359435e-02f, -2.41542663e-02f, 2.87105944e-02f, 1.16604820e-01f, 1.35773242e-01f, -5.90746999e-02f, 3.85335609e-02f,
  6.26255572e-02f, 1.58369184e-01f, -1.15178883e-01f, -2.46405855e-01f, 2.54585475e-01f, -9.69055146e-02f, -2.72743311e-02f, 5.50711639e-02f, 9.06993672e-02f, 6.53530806e-02f,
  -1.19620040e-01f, -1.45755813e-01f, 1.76708534e-01f, 1.22567877e-01f, -8.76560248e-03f, -3.20055597e-02f, -1.18135944e-01f, 5.93512394e-02f, 1.12098053e-01f, 1.49242533e-02f,
  3.98080349e-02f, 7.78581575e-02f, -1.40519321e-01f, 1.97552517e-02f, 3.85098942e-02f, -1.89166337e-01f, -8.07282105e-02f, 4.83957306e-02f, -8.92745927e-02f, -5.39324954e-02f,
  1.17305117e-02f, -9.16112214e-03f, -6.97018802e-02f, 5.40950559e-02f, -5.93788251e-02f, 8.03466216e-02f, -1.63439810e-01f, -1.40077576e-01f, -1.61072519e-02f, -2.26122811e-01f,
  1.84988543e-01f, -3.63112688e-02f, 2.86667068e-02f, -4.77272235e-02f, -7.88011998e-02f, -1.16125666e-01f, -1.31151929e-01f, 1.53483525e-01f, 1.40461057e-01f, 2.02380382e-02f,
  -1.41732275e-01f, -1.35584492e-02f, -1.47443503e-01f, -4.71813530e-02f, -2.01126728e-02f, 1.31023750e-02f, 9.29121450e-02f, 1.31593585e-01f, 1.81878246e-02f, 8.70890394e-02f,
  -7.07218200e-02f, -5.46109118e-02f, -1.28078163e-01f, 4.51873019e-02f, -1.44059509e-01f, 1.28825381e-03f, -1.22521006e-01f, 7.91619644e-02f, -2.86494553e-01f, 1.52237535e-01f,
  6.22226037e-02f, -1.01905063e-01f, -2.13604122e-01f, 1.78374380e-01f, 6.26111478e-02f, 1.03597254e-01f, 1.72955636e-02f, 4.74439785e-02f, 5.11515625e-02f, -6.97265714e-02f,
  -1.55907525e-02f, -7.55197406e-02f, 3.55138234e-03f, -1.17491640e-01f, -8.21760148e-02f, -1.99411362e-02f, 6.16747551e-02f, -8.61039758e-02f, 4.85176966e-02f, 2.63564408e-01f,
  5.38482741e-02f, 3.60422730e-02f, -1.20266043e-01f, 7.29289204e-02f, -7.06773102e-02f, -1.67377174e-01f, -6.98545426e-02f, -1.21199645e-01f, 2.83539779e-02f, -1.59224957e-01f,
  1.33523986e-01f, 6.83782399e-02f, -8.64798799e-02f, 7.18292817e-02f, -1.04019515e-01f, 1.63708292e-02f, 4.63372096e-02f, -3.04674194e-03f, -2.28044316e-02f, 6.16935492e-02f,
  7.64346868e-02f, 2.82371230e-02f, -4.36289161e-02f, -7.26841837e-02f, -3.99799496e-02f, -1.06103428e-01f, 6.79579154e-02f, -8.99076238e-02f, 1.08697098e-02f, -5.25098294e-03f,
  8.26650932e-02f, 1.06831966e-02f, -2.21208576e-02f, 4.48870026e-02f, -3.33640277e-02f, 1.33844495e-01f, -2.38575600e-02f, 5.07711619e-02f, -9.32975113e-02f, -1.80207655e-01f,
  -1.98790625e-01f, 7.04853833e-02f, -2.38317564e-01f, 1.18381888e-01f, 7.66315451e-03f, -1.63158074e-01f, 4.77266610e-02f, 1.54910028e-01f, 1.51247427e-01f, 1.05148312e-02f,
  -7.69214984e-03f, 1.11220062e-01f, 4.21025045e-02f, 2.08975580e-02f, 8.63297433e-02f, 1.53086588e-01f, 2.25153685e-01f, -3.13416757e-02f, -1.03936493e-01f, 1.72846913e-01f,
  9.11278650e-02f, 6.30866587e-02f, -8.06316361e-02f, 3.37754898e-02f, 8.19035918e-02f, -1.06472306e-01f, -1.36769384e-01f, -2.87820287e-02f, 3.89698544e-03f, -2.23038159e-02f,
  2.01046877e-02f, 4.10843873e-03f, 3.78894731e-02f, 7.60830864e-02f, -1.89680029e-02f, -2.21174344e-01f, -1.52176902e-01f, 7.60491192e-02f, -4.81206477e-02f, 5.19729182e-02f,
  4.95620333e-02f, 1.34977996e-01f, 2.31705122e-02f, 6.07449263e-02f, 1.80660393e-02f, -9.54592302e-02f, 7.82904923e-02f, -1.34313568e-01f, -4.16958928e-02f, -1.42502517e-01f,
  4.98386845e-02f, -2.79485527e-02f, -1.62694097e-01f, 1.14830673e-01f, 6.79043233e-02f, 9.68749821e-02f, -1.23931672e-02f, 5.07366993e-02f, -5.00784926e-02f, -5.50857671e-02f,
  1.69761628e-01f, -7.69551247e-02f, -2.08420511e-02f, -2.12917730e-01f, -1.30358532e-01f, -1.47805810e-01f, 1.04894405e-02f, 9.72034782e-02f, -7.22245723e-02f, 2.30395515e-02f,
  1.13982223e-02f, 8.08470324e-03f, 8.28558132e-02f, -1.10143237e-01f, 1.52853718e-02f, 8.28546062e-02f, -1.39403567e-01f, 1.41084958e-02f, -7.02405768e-03f, 1.25289947e-01f,
  3.04932240e-02f, 7.39635080e-02f, 2.17613094e-02f, -8.12069401e-02f, 2.87688710e-02f, -8.97686332e-02f, -3.66926081e-02f, 4.27223295e-02f, -1.05409864e-02f, -1.78344563e-01f,
  1.22170806e-01f, 7.58940801e-02f, 1.43532291e-01f, -1.18898354e-01f, 1.83037475e-01f, -2.72107609e-02f, -9.48428512e-02f, 1.23194091e-01f, 4.17445935e-02f, -3.55749168e-02f,
  -1.32489372e-02f, -1.42169699e-01f, -1.17792644e-01f, 1.15191117e-02f, -4.34778407e-02f, -1.36220753e-02f, 8.05043131e-02f, -1.22367598e-01f, 3.60694081e-02f, -1.66414380e-01f,
  -2.08386662e-03f, 8.89451280e-02f, 3.21547464e-02f, 1.12191364e-01f, -9.14576426e-02f, 2.03615353e-02f, 9.13966745e-02f, -1.23673871e-01f, 1.37955427e-01f, 6.55616298e-02f,
  1.66013464e-01f, -2.55763590e-01f, 8.81752819e-02f, -3.52490023e-02f, -1.34158194e-01f, -9.47521701e-02f, -9.76282284e-02f, -1.37200236e-01f, 1.51023688e-03f, 9.03294533e-02f,
  1.26075089e-01f, 1.05377315e-02f, -1.25962541e-01f, 2.08125245e-02f, 1.84790492e-01f, 2.63716187e-02f, -8.76493901e-02f, 5.12786151e-04f, 1.55180320e-02f, -9.02983844e-02f,
  -5.51571995e-02f, -2.97464170e-02f, -8.18138495e-02f, 4.17481177e-02f, -1.58017322e-01f, 2.03634426e-01f, 8.00903440e-02f, -5.07122427e-02f, 1.24583244e-01f, 1.17072493e-01f,
  2.12340169e-02f, 5.77111766e-02f, -4.21417058e-02f, -1.42351598e-01f, 9.31373760e-02f, -1.97275374e-02f, 1.35348260e-01f, -1.47751495e-01f, -8.22340101e-02f, -9.04713199e-02f,
  5.68440557e-02f, -5.05653918e-02f, 4.29924056e-02f, 1.25327796e-01f, 2.34093089e-02f, -1.18001260e-01f, -5.88416569e-02f, -1.38488077e-02f, -1.29597127e-01f, -3.69240269e-02f,
  6.33599982e-02f, -7.41191283e-02f, 1.70463976e-02f, 2.56944925e-01f, -4.76198681e-02f, -3.95776480e-02f, 5.88592924e-02f, 1.75480008e-01f, -7.64363632e-02f, 1.86735447e-02f,
  1.56888977e-01f, 4.45255935e-02f, -4.92339469e-02f, 1.85195208e-02f
};

// L2_fan_Wp_bar (Shape: 52 x 64)
const int L2_fan_Wp_bar_rows = 52;
const int L2_fan_Wp_bar_cols = 64;
const float L2_fan_Wp_bar_data[] = {
  2.94153765e-02f, 3.34344544e-02f, 3.44335735e-02f, -7.94536322e-02f, 2.67953873e-01f, 1.87398821e-01f, -3.32427055e-01f, -1.30892277e-01f, -1.98716953e-01f, -3.48960698e-01f,
  1.12594046e-01f, 2.50564277e-01f, 1.16768487e-01f, 3.68472412e-02f, 5.89754842e-02f, -6.74079806e-02f, 1.51836991e-01f, -2.40173429e-01f, 2.46911123e-01f, 1.53068960e-01f,
  -5.22211157e-02f, -1.48992464e-01f, -1.00220107e-01f, 1.86614394e-01f, 3.13935578e-01f, -2.61047751e-01f, 3.48265581e-02f, 1.24140874e-01f, -8.35008100e-02f, 1.48744881e-01f,
  2.48255059e-02f, -1.70108765e-01f, -9.49005038e-02f, 7.97159076e-02f, 9.91742387e-02f, 6.47903159e-02f, -5.55858277e-02f, 2.11785585e-01f, -2.44578179e-02f, -2.57665571e-02f,
  -3.75246406e-02f, 1.21621855e-01f, -1.64301142e-01f, 1.84798375e-01f, 9.12174061e-02f, -1.25683518e-02f, 9.28958356e-02f, 2.45102830e-02f, 1.08195454e-01f, -1.27708493e-02f,
  1.93125010e-01f, -1.97810978e-01f, 4.78563718e-02f, -2.34150052e-01f, -2.70783365e-01f, 8.21055174e-02f, -1.02524430e-01f, -6.84571266e-02f, 1.15798846e-01f, -1.75359391e-03f,
  3.34029049e-02f, -8.83898735e-02f, 2.61484474e-01f, 8.76018852e-02f, 2.98402738e-02f, -7.65643567e-02f, -1.83196396e-01f, -1.81818530e-02f, -2.16167979e-02f, -1.15355618e-01f,
  4.91341889e-01f, 1.31741554e-01f, 1.48009256e-01f, 1.76246334e-02f, 5.88860735e-02f, -1.90588325e-01f, 5.58103099e-02f, -5.35194091e-02f, -3.34200822e-02f, -1.42203942e-01f,
  -6.88102990e-02f, 2.16165073e-02f, -1.56669736e-01f, 1.50701299e-01f, 4.92506772e-02f, 1.69674039e-01f, 1.73355862e-01f, 6.13874197e-02f, 5.76947555e-02f, 3.71524543e-02f,
  2.46338516e-01f, -4.92787063e-02f, -5.91255538e-02f, 1.20576642e-01f, 9.73940045e-02f, 8.33375677e-02f, -4.55410443e-02f, 2.72916675e-01f, 1.73176870e-01f, 3.87767468e-05f,
  3.52016650e-02f, -2.93609630e-02f, 2.24958032e-01f, 7.11501539e-02f, 1.42148644e-01f, -1.19426176e-01f, 6.15831017e-02f, -1.33930668e-01f, -2.41943449e-02f, -3.02942470e-02f,
  4.98327203e-02f, 4.53046300e-02f, -2.02668235e-01f, 7.92836249e-02f, -1.16865635e-01f, 8.25398862e-02f, 1.38482034e-01f, 2.98132539e-01f, -2.73516595e-01f, 7.30444714e-02f,
  1.73511460e-01f, 1.17134579e-01f, 4.32441905e-02f, 9.75703914e-03f, 2.87241340e-02f, 1.17509007e-01f, 2.23915018e-02f, -9.53944214e-03f, -4.38299403e-02f, -1.97010450e-02f,
  1.00133054e-01f, 7.92493597e-02f, 2.08280563e-01f, 1.25696182e-01f, -1.62813351e-01f, 2.20862672e-01f, 9.43569466e-02f, 8.29179361e-02f, -5.16222343e-02f, 1.36453584e-01f,
  5.12217805e-02f, 2.55105168e-01f, 3.42863165e-02f, 2.40654454e-01f, 1.40940502e-01f, -2.80562162e-01f, 1.70606866e-01f, -2.60257870e-01f, -1.03904933e-01f, -7.86051378e-02f,
  -1.45392373e-01f, -4.10012193e-02f, 4.16313112e-02f, 2.16292161e-02f, 1.91204041e-01f, -1.40005469e-01f, -8.90699923e-02f, -1.77978754e-01f, 2.10447200e-02f, -2.65720021e-02f,
  1.10123001e-01f, -4.23156694e-02f, -1.34168237e-01f, 1.28534297e-02f, 2.77791411e-01f, -3.18727642e-02f, 2.06440851e-01f, -2.57323503e-01f, -3.11734915e-01f, 2.52764523e-01f,
  1.48006514e-01f, -3.40212770e-02f, -9.79239568e-02f, 1.88253224e-01f, 1.84124455e-01f, 2.61008561e-01f, 1.70341969e-01f, 1.08750381e-01f, -1.07562039e-02f, -9.99375284e-02f,
  2.32055798e-01f, -1.71325088e-01f, 1.48357525e-01f, -2.70024240e-01f, -1.37180641e-01f, -2.67889351e-02f, 1.64783392e-02f, 1.85447894e-02f, -1.63039178e-01f, -2.61162929e-02f,
  -7.47256503e-02f, -1.53975755e-01f, -3.77501361e-02f, 1.27096087e-01f, 5.87426648e-02f, 1.44502193e-01f, 7.34568313e-02f, -4.38893437e-02f, 3.52062970e-01f, 2.77643532e-01f,
  2.73963779e-01f, -5.34161963e-02f, 1.08055137e-01f, -1.66140765e-01f, 8.20418596e-02f, 1.49704009e-01f, -4.99897636e-02f, -2.08904669e-01f, 5.34547195e-02f, 2.38592610e-01f,
  -1.03452429e-01f, -1.24150410e-01f, 2.91610688e-01f, 1.56994581e-01f, 2.02110350e-01f, -5.85008152e-02f, -1.01054803e-01f, -1.12636492e-01f, 2.00276151e-02f, -2.56980211e-02f,
  1.21651672e-01f, 7.16421306e-02f, 4.02602740e-03f, 5.87056167e-02f, 2.53714565e-02f, 2.76372284e-01f, 1.74285304e-02f, 4.80777472e-02f, 4.08008648e-03f, 5.66566549e-02f,
  7.95236677e-02f, 2.61107497e-02f, -5.19824401e-02f, -7.04838932e-02f, -7.87983760e-02f, -1.69614200e-02f, 6.93606362e-02f, -3.19943461e-03f, 8.33654702e-02f, 1.74455225e-01f,
  -7.26787373e-02f, -3.23764384e-02f, 2.05009594e-03f, 2.21222311e-01f, 7.24593475e-02f, 8.94750580e-02f, 9.91851315e-02f, -1.47339314e-01f, 1.41402692e-01f, -8.35209619e-04f,
  5.10725603e-02f, 1.34644046e-01f, 6.00846410e-02f, 8.71466473e-02f, -7.96511099e-02f, -1.38019934e-01f, 2.45623842e-01f, 6.30782694e-02f, -4.19980735e-02f, -4.43815999e-02f,
  -9.87434760e-02f, -2.50124335e-01f, 8.20776522e-02f, 1.28258198e-01f, 1.58328637e-01f, -2.19668671e-01f, 9.13827121e-02f, -7.01464191e-02f, -2.13205814e-01f, 1.37561738e-01f,
  2.49241352e-01f, -1.04431801e-01f, 1.51526764e-01f, 1.19509928e-01f, -1.69494022e-02f, -3.18179391e-02f, -2.36400008e-01f, 1.85610265e-01f, -7.58812251e-03f, -7.69176008e-03f,
  -8.40641484e-02f, 4.47600819e-02f, 1.11951903e-01f, -6.74903393e-02f, 7.42183551e-02f, -5.86259505e-03f, 3.16339135e-02f, 8.76369625e-02f, 1.76446781e-01f, -5.80797642e-02f,
  1.90561816e-01f, 1.47919193e-01f, 1.83412850e-01f, 1.78929027e-02f, 1.72305375e-01f, -8.56963396e-02f, 9.85503271e-02f, 1.13500305e-01f, 9.12459493e-02f, 2.69944519e-01f,
  -4.74389223e-03f, -8.07817727e-02f, -1.29300326e-01f, 5.52242287e-02f, -1.21440597e-01f, -6.29515797e-02f, 1.63864806e-01f, -1.85308039e-01f, 1.22063115e-01f, -1.36956442e-02f,
  3.65952216e-02f, 5.00204694e-03f, 2.07603388e-02f, 2.36798882e-01f, -1.17775664e-01f, 1.73061907e-01f, 1.40935585e-01f, 4.59713675e-02f, 8.90423656e-02f, 7.22876340e-02f,
  7.81939253e-02f, -1.51386067e-01f, 2.18153950e-02f, -1.50334463e-01f, 7.55285695e-02f, 9.60364416e-02f, -2.03774467e-01f, -6.29609600e-02f, 1.54846199e-02f, 1.99116811e-01f,
  2.17527822e-01f, 6.39866572e-03f, -3.97916473e-02f, -6.22799248e-03f, 4.60410044e-02f, 5.32403290e-02f, -1.22428611e-01f, -2.00937167e-02f, 1.45209759e-01f, 1.07516937e-01f,
  -5.11752889e-02f, -5.99805117e-02f, -1.33920878e-01f, -1.09325707e-01f, 1.13150455e-01f, 1.06176421e-01f, -6.98380098e-02f, -9.37667489e-02f, 4.39169370e-02f, 3.19915950e-01f,
  1.11138105e-01f, 5.44190116e-04f, -4.86013032e-02f, -2.85028163e-02f, -1.58432141e-01f, -4.04376872e-02f, -8.35853964e-02f, 2.34430775e-01f, -1.41209498e-01f, 1.70666054e-01f,
  1.27716199e-01f, -1.45355966e-02f, -1.54929888e-02f, 2.47401491e-01f, 2.00034201e-01f, 2.20578417e-01f, 1.37103051e-01f, 2.38646055e-03f, 1.75751418e-01f, -1.20093934e-01f,
  1.18665703e-01f, -2.63059199e-01f, -1.13187693e-01f, 3.49946648e-01f, 4.24825065e-02f, 2.40345895e-01f, -6.12824038e-02f, -7.92070255e-02f, -9.53251794e-02f, -1.68668032e-01f,
  1.49962783e-01f, -2.42580995e-01f, 1.85367852e-01f, 8.28277990e-02f, -1.12771012e-01f, 8.92683566e-02f, 7.42476583e-02f, 1.19593829e-01f, 7.04256445e-02f, 4.37002666e-02f,
  -1.43522369e-02f, 3.20562094e-01f, 8.25083181e-02f, -1.58671647e-01f, -2.90989667e-01f, 1.16821036e-01f, 2.19206512e-01f, 1.30915374e-01f, -9.26631391e-02f, 4.93226573e-02f,
  6.08508922e-02f, -1.23367161e-01f, 1.46365181e-01f, -2.20424309e-03f, -1.90306708e-01f, -1.20062612e-01f, 1.93717685e-02f, 3.60803865e-02f, 7.72018582e-02f, 5.69263361e-02f,
  -1.43015429e-01f, -1.64866909e-01f, -6.65238053e-02f, 1.04926914e-01f, 1.27883881e-01f, 8.08010548e-02f, 7.77819976e-02f, 1.09214038e-01f, -4.35056761e-02f, -6.04042374e-02f,
  8.41048732e-02f, 8.03893656e-02f, 2.21102759e-02f, -1.51956812e-01f, -2.30293721e-01f, -2.74497885e-02f, 1.27652869e-01f, 8.17027166e-02f, 6.53604046e-02f, 3.07210311e-02f,
  -1.13752276e-01f, -6.13907166e-02f, 1.40430450e-01f, 1.49536282e-01f, -2.37199236e-02f, -1.05542690e-02f, 2.59304613e-01f, 4.93047163e-02f, -1.69554655e-03f, -3.58312652e-02f,
  8.69757906e-02f, -5.57902828e-02f, 2.58315623e-01f, -9.64591056e-02f, -9.87622067e-02f, 2.42839847e-02f, 7.01308772e-02f, -9.56663042e-02f, 2.02445179e-01f, -7.99555257e-02f,
  -3.10497377e-02f, 1.15957651e-02f, -9.26649049e-02f, -1.47678033e-01f, 9.72756818e-02f, 2.54011247e-02f, -1.03906751e-01f, 1.55258998e-02f, 9.93637294e-02f, -1.21382691e-01f,
  1.57238945e-01f, -1.58954844e-01f, 2.02182401e-02f, -1.06945448e-01f, -1.49074793e-01f, 1.51094317e-01f, 1.00660607e-01f, 2.26388857e-01f, -6.35807142e-02f, -2.73758397e-02f,
  -8.79089832e-02f, -7.12626055e-02f, -7.46946931e-02f, -1.87993184e-01f, -6.49268180e-02f, -8.27013999e-02f, 3.18628410e-03f, 2.67696857e-01f, 6.01516105e-03f, -5.06271347e-02f,
  -7.22470731e-02f, 1.01269759e-01f, -1.14237927e-01f, -4.57180776e-02f, -2.56631881e-01f, 1.80196956e-01f, -2.64197111e-01f, 1.75496683e-01f, 1.71683893e-01f, -1.25510700e-03f,
  -5.44407731e-03f, 3.02607119e-01f, 7.94977993e-02f, -4.65582646e-02f, 5.83859757e-02f, -2.58208308e-02f, 5.24772517e-03f, -7.00061023e-02f, 2.13061199e-01f, -3.06819770e-02f,
  4.19944339e-02f, 3.87662053e-01f, -9.70115513e-02f, 1.84586361e-01f, 9.29061919e-02f, -5.18323518e-02f, 7.04876482e-02f, 7.24031180e-02f, 1.32841021e-01f, -2.44331762e-01f,
  4.04445603e-02f, -5.87833300e-02f, 9.76396874e-02f, 3.44476432e-01f, 1.12016506e-01f, 1.32778749e-01f, 1.05176173e-01f, 6.69709072e-02f, -4.09143046e-03f, 1.05348162e-01f,
  3.41759652e-01f, -1.60683528e-01f, 9.38118473e-02f, -6.50536418e-02f, 8.50662403e-03f, 1.48638830e-01f, 2.70251930e-01f, 1.49616301e-01f, 3.45692903e-01f, 1.79875463e-01f,
  -3.38973016e-01f, -2.10034087e-01f, -1.91657454e-01f, 1.91847607e-03f, -9.73737985e-02f, -2.39224747e-01f, -1.14274204e-01f, 1.69982687e-01f, 1.46280631e-01f, -2.21699104e-01f,
  -1.11323610e-01f, -1.48670182e-01f, 1.86641946e-01f, -4.65994254e-02f, 2.17554476e-02f, -8.94455463e-02f, 1.60088792e-01f, -1.08527415e-01f, 2.43908092e-01f, -2.23271489e-01f,
  2.20672965e-01f, -3.50003727e-02f, -4.59486544e-02f, 1.29961953e-01f, 7.63794705e-02f, 2.50629276e-01f, 1.88864410e-01f, -3.95147353e-02f, 2.71745101e-02f, 9.37257782e-02f,
  2.02417627e-01f, 5.93797490e-02f, 1.19982272e-01f, -5.07233590e-02f, 3.02187443e-01f, -2.56543607e-01f, 7.75603354e-02f, -1.48384884e-01f, -8.26469287e-02f, 1.47905368e-02f,
  -5.13799605e-04f, -3.76093350e-02f, 5.99821918e-02f, 2.20831800e-02f, -9.01472196e-02f, -8.35967734e-02f, 2.90045023e-01f, -1.42113715e-01f, -1.31170601e-02f, -5.95609844e-02f,
  4.24722116e-03f, -4.96408865e-02f, -2.33720466e-02f, -1.79298446e-01f, -8.55099559e-02f, 7.90190548e-02f, 1.03237502e-01f, -1.07733116e-01f, 3.29886675e-02f, -1.39551699e-01f,
  1.75251767e-01f, 6.53991997e-02f, -1.98870867e-01f, 9.90281627e-02f, 3.32803614e-02f, 1.19290300e-01f, -2.30476260e-01f, 1.48182716e-02f, 7.41094872e-02f, -3.12018823e-02f,
  8.51594955e-02f, -1.19823337e-01f, 3.12303273e-05f, 1.58241987e-01f, -8.02862644e-02f, 8.40921029e-02f, -5.57491963e-04f, 4.37548803e-03f, 9.02591832e-03f, -6.16868921e-02f,
  7.45284781e-02f, -7.51173943e-02f, -1.80782452e-01f, -6.60765311e-03f, 1.03727341e-01f, 2.36895755e-01f, 2.48914838e-01f, 1.65534630e-01f, -1.07360363e-01f, 2.38231599e-01f,
  -5.55952601e-02f, -1.28731519e-01f, -1.01951770e-01f, -2.59851441e-02f, 6.92858361e-03f, -8.82934406e-02f, 1.38330579e-01f, -3.68607305e-02f, -5.42312823e-02f, 2.16287032e-01f,
  -1.15237366e-02f, 2.54754364e-01f, -8.26616138e-02f, 1.98421091e-01f, -1.16706088e-01f, 1.59196585e-01f, 1.32063448e-01f, 3.38550806e-02f, 1.01970710e-01f, 1.44328013e-01f,
  2.29304247e-02f, -1.87297026e-03f, -6.63355067e-02f, 5.60241938e-02f, 9.51930955e-02f, 1.58735946e-01f, -6.18926398e-02f, 3.01651284e-02f, 7.72416666e-02f, 1.62350535e-01f,
  2.60738790e-01f, -1.14567854e-01f, -3.93031351e-02f, 2.95853019e-01f, -1.16809029e-02f, -6.16373494e-02f, -4.01564129e-02f, -5.66626377e-02f, 9.02107954e-02f, 8.20011050e-02f,
  2.53134131e-01f, -1.07843608e-01f, 6.59634679e-05f, 1.03764959e-01f, 2.26637959e-01f, 1.77896217e-01f, 9.51577500e-02f, 1.19002812e-01f, 3.74967456e-02f, 6.92662895e-02f,
  1.46312416e-01f, -1.59886658e-01f, -1.17650762e-01f, 3.65514457e-02f, 1.92756560e-02f, 1.02751277e-01f, 5.37423752e-02f, 1.75566763e-01f, -5.51285408e-02f, 1.21517502e-01f,
  8.01534206e-02f, 5.79653680e-02f, -1.86194345e-01f, -1.25795200e-01f, -2.22220533e-02f, 8.97138566e-02f, 3.18982691e-01f, 7.23647773e-02f, -1.31336540e-01f, -1.10181704e-01f,
  -4.80745286e-02f, 9.52510536e-03f, -1.56472802e-01f, -1.39203787e-01f, 2.53642142e-01f, -1.13655716e-01f, -7.54170269e-02f, -1.39053851e-01f, -3.28234971e-01f, 4.61699665e-02f,
  -1.17792115e-01f, 4.04495001e-02f, -9.60249547e-03f, 2.25154078e-03f, -1.25917539e-01f, 1.53542226e-02f, 6.34636357e-02f, -3.13538425e-02f, 1.27754360e-01f, 1.53373955e-02f,
  2.22673327e-01f, -4.61470857e-02f, 1.45273926e-02f, -1.13987342e-01f, 1.28644451e-01f, 2.28452876e-01f, 8.67759287e-02f, 6.60453439e-02f, 4.87567373e-02f, 6.07872307e-02f,
  2.66513318e-01f, -8.08907896e-02f, -2.97858655e-01f, -8.07689503e-02f, -3.92339937e-02f, 1.62127033e-01f, 1.52122453e-01f, 5.68246022e-02f, 2.47635543e-01f, 2.25580767e-01f,
  2.74576247e-01f, -1.98280945e-01f, -1.97013617e-02f, -2.58907229e-01f, -4.67349403e-02f, 1.42860087e-02f, -9.23876315e-02f, -1.70579250e-03f, 1.09413706e-01f, 4.46432829e-02f,
  2.04402968e-01f, 3.40591446e-02f, 3.20338458e-01f, 1.15341999e-01f, -5.07405847e-02f, -1.01459228e-01f, 2.22533435e-01f, 1.21003121e-01f, 9.51911956e-02f, -1.10177249e-01f,
  3.92429717e-02f, 7.56521821e-02f, 1.94162965e-01f, 9.88925472e-02f, -4.27793786e-02f, -8.27291980e-02f, 2.36988470e-01f, 3.13079432e-02f, -3.93521935e-01f, -1.47318549e-03f,
  5.92826866e-03f, -5.28052971e-02f, 7.98021927e-02f, 5.91102690e-02f, 8.84301066e-02f, 9.22332332e-02f, -6.67597130e-02f, 1.00209691e-01f, -2.30269462e-01f, -1.52709275e-01f,
  6.12034090e-02f, 2.03678727e-01f, 1.02893300e-01f, 1.72041833e-01f, -3.11248362e-01f, -6.21921718e-02f, -1.85963050e-01f, -1.01450659e-01f, 4.09644209e-02f, 9.51308906e-02f,
  2.86521882e-01f, 4.34617745e-03f, -6.81570247e-02f, 2.19350323e-01f, 8.79481360e-02f, -3.99448611e-02f, 1.37186334e-01f, 2.94406693e-02f, -1.13822527e-01f, -1.82913586e-01f,
  1.37105025e-02f, -4.58508395e-02f, 1.97296381e-01f, 1.50143370e-01f, -7.31099471e-02f, -4.09186035e-02f, 7.09553659e-02f, 1.77340746e-01f, 1.03582568e-01f, 1.70640409e-01f,
  -4.75580953e-02f, 1.72981862e-02f, -1.58504009e-01f, -1.95485681e-01f, -9.44057256e-02f, 1.89109132e-01f, -7.31992023e-03f, 3.20088714e-02f, 5.77205122e-02f, -9.42898914e-02f,
  -1.30584762e-01f, -1.50982458e-02f, 2.67691135e-01f, -5.67518286e-02f, -1.86150134e-01f, -1.93629727e-01f, 1.79163709e-01f, -3.10507901e-02f, 5.53495903e-03f, -2.44968370e-01f,
  1.27581909e-01f, -4.27377447e-02f, -1.32104039e-01f, 1.80947483e-01f, 2.24457294e-01f, -1.54926926e-01f, 8.17421526e-02f, -9.50433239e-02f, 1.17970623e-01f, -5.86852208e-02f,
  7.50156268e-02f, -3.32614966e-02f, 1.98837131e-01f, -2.01459184e-01f, 5.58502935e-02f, -1.42563686e-01f, 1.43393353e-01f, 2.17235461e-02f, -1.56028345e-01f, -2.90843338e-01f,
  -2.69542992e-01f, 1.25864148e-01f, -4.20855433e-02f, -2.55118664e-02f, -5.20211793e-02f, 1.99350528e-02f, -4.74712364e-02f, 2.56046169e-02f, -3.94777842e-02f, -2.63869643e-01f,
  2.11288318e-01f, 1.92522660e-01f, -2.11459875e-01f, 2.34563164e-02f, 1.58763036e-01f, 3.14541668e-01f, 1.61200583e-01f, 3.03711984e-02f, -5.93698993e-02f, 8.10491219e-02f,
  1.93700582e-01f, 5.11392877e-02f, -1.46137491e-01f, 7.15067436e-04f, 2.23148927e-01f, -3.58318239e-02f, 2.15143964e-01f, 9.27210320e-03f, 7.84992799e-02f, -2.40621082e-02f,
  -4.20803279e-02f, 6.06576540e-02f, 3.48819196e-02f, 1.88314855e-01f, -1.17074162e-01f, -3.42854857e-02f, -1.30929500e-01f, -1.00755401e-01f, -7.73896277e-02f, -1.85597390e-01f,
  -7.91342780e-02f, 1.34369284e-01f, 1.44423366e-01f, 1.63400814e-01f, -9.55045745e-02f, -1.65434048e-01f, -2.00279690e-02f, 1.60583451e-01f, -3.28112580e-02f, 1.09013341e-01f,
  -1.18952245e-01f, 7.68824369e-02f, 9.87861156e-02f, 3.28271813e-03f, 4.07038592e-02f, 1.92111686e-01f, 1.12046868e-01f, -5.32317236e-02f, -1.22877188e-01f, -5.21117933e-02f,
  -1.50178909e-01f, -2.63290465e-01f, 2.31538609e-01f, 2.17135653e-01f, 2.66207933e-01f, 1.34272575e-01f, 1.27630994e-01f, -2.96659619e-01f, -1.60974622e-01f, 1.07744850e-01f,
  1.43674567e-01f, -3.01406026e-01f, 8.48447308e-02f, 1.50637135e-01f, -6.04101866e-02f, 6.65912479e-02f, -3.20510082e-02f, 8.03818926e-02f, 4.65534255e-02f, -8.00140575e-02f,
  -9.09935459e-02f, -5.44002056e-02f, 1.95307568e-01f, -1.35794148e-01f, 7.68346537e-04f, 6.06107228e-02f, 8.12866390e-02f, 5.19597307e-02f, 5.82878143e-02f, 1.31538704e-01f,
  -3.74510437e-02f, 1.93549514e-01f, 2.26378813e-02f, -1.00711778e-01f, -7.99212605e-02f, 1.27966821e-01f, -3.38544585e-02f, 1.51752993e-01f, 8.71027703e-04f, 2.03881100e-01f,
  3.32228281e-02f, -3.30203474e-02f, 1.66501850e-01f, 1.92664832e-01f, -2.71385878e-01f, -4.37411182e-02f, 9.20044482e-02f, 2.28922050e-02f, -2.88801710e-03f, 2.67733812e-01f,
  -4.69866879e-02f, 1.10764101e-01f, -7.01912539e-03f, 9.13815722e-02f, -5.17501943e-02f, 1.79829910e-01f, 7.44478926e-02f, -2.32897978e-02f, -1.00479014e-01f, 3.68395448e-02f,
  2.42791846e-01f, 2.05865093e-02f, 3.66009064e-02f, -7.17137381e-02f, 1.23807698e-01f, 2.05206364e-01f, 1.20452046e-01f, -1.44752622e-01f, -3.80316079e-02f, 1.89332008e-01f,
  1.45226032e-01f, -8.15896764e-02f, 3.05644780e-01f, 6.61381856e-02f, -3.76891135e-03f, 9.41831991e-02f, -2.07372069e-01f, -9.03212950e-02f, 1.65389001e-01f, 2.45447770e-01f,
  -5.06228432e-02f, -3.65732685e-02f, 5.34683242e-02f, 9.59779788e-03f, 1.29242554e-01f, -1.43808842e-01f, -1.47275135e-01f, 7.81322792e-02f, -1.13283426e-01f, 2.31522903e-01f,
  1.98353752e-01f, -2.49368995e-01f, -3.70817445e-02f, 9.74497572e-02f, 1.73075616e-01f, -1.18319923e-02f, -7.32475072e-02f, 1.50626823e-01f, -3.65876742e-02f, 3.24651450e-01f,
  2.30155721e-01f, 1.01625592e-01f, 3.84694003e-02f, -1.28034968e-03f, 1.01440556e-01f, 1.63290963e-01f, 3.84694636e-01f, -3.78525108e-02f, 1.69203326e-01f, -7.14294165e-02f,
  -2.12117258e-04f, -4.23843861e-02f, -1.56045407e-01f, 2.62206852e-01f, 2.45688856e-03f, 2.34318912e-01f, -1.12945013e-01f, -1.10532664e-01f, -1.46411672e-01f, 3.06423418e-02f,
  -1.30167380e-01f, -3.92614827e-02f, -9.51390341e-03f, 1.10252120e-01f, 2.11303681e-01f, -1.96016356e-02f, -6.08535111e-02f, -1.29118741e-01f, -1.05204862e-02f, 3.10430396e-03f,
  -6.94062412e-02f, 1.60765752e-01f, 2.18494445e-01f, -2.16365908e-03f, -2.11863238e-02f, 1.18415460e-01f, -1.98445679e-03f, 1.67071491e-01f, 2.19616234e-01f, 1.70648053e-01f,
  9.06700268e-02f, 1.99144885e-01f, -2.66326487e-01f, -1.25463665e-01f, -1.72230616e-01f, -1.87132344e-01f, -2.20001817e-01f, -1.58694208e-01f, -1.19205311e-01f, 1.17649451e-01f,
  -1.57432839e-01f, 2.12008692e-02f, -1.29455820e-01f, -1.26225278e-01f, 2.32603207e-01f, 3.53573672e-02f, -6.72132941e-03f, -1.80203229e-01f, -1.40184492e-01f, -1.65216789e-01f,
  2.54749358e-01f, -2.13985786e-01f, 6.55540079e-02f, 2.29117021e-01f, 1.23798661e-01f, -1.94132514e-02f, 6.24373704e-02f, 3.04312557e-01f, 1.04936644e-01f, 2.23770767e-01f,
  1.53045580e-01f, 5.55015616e-02f, 5.63392974e-02f, -6.98800385e-02f, 4.85279486e-02f, -1.25639483e-01f, -4.21589799e-02f, -1.59327567e-01f, 2.72047639e-01f, 1.52358646e-02f,
  -8.72651935e-02f, -1.77476496e-01f, -6.06321767e-02f, -1.76363140e-01f, -8.51709545e-02f, -1.26016110e-01f, -3.44904214e-01f, 2.39101574e-02f, -2.23739728e-01f, 1.65163763e-02f,
  6.54182062e-02f, 1.41175641e-02f, 1.25821456e-01f, 2.50925310e-02f, 9.21000317e-02f, -8.34726617e-02f, -4.82304990e-02f, 7.77028948e-02f, -8.11256170e-02f, 2.31373295e-01f,
  3.71932954e-01f, -7.59886280e-02f, -2.21139297e-01f, 8.33006576e-02f, -5.34230880e-02f, -3.56329709e-01f, -4.81838994e-02f, 2.38246143e-01f, -5.07934876e-02f, -1.80644467e-01f,
  2.61824787e-01f, 2.53516525e-01f, 2.52172440e-01f, -1.70331076e-01f, -2.78943092e-01f, -3.65783349e-02f, -4.12557982e-02f, 1.65080771e-01f, 7.30572618e-04f, -3.79618304e-03f,
  -1.68104265e-02f, 2.64982671e-01f, 2.19710231e-01f, -2.84376264e-01f, 5.99278994e-02f, 2.09650159e-01f, 1.71856388e-01f, 1.75112009e-01f, -4.70227376e-02f, -4.32542674e-02f,
  -4.75339890e-02f, -2.30755419e-01f, 3.36305350e-02f, -3.81440111e-02f, -1.86859936e-01f, -7.89668113e-02f, 2.66859174e-01f, 2.07203180e-01f, -2.78212607e-01f, -2.38401797e-02f,
  1.86881036e-01f, 2.23277822e-01f, -2.53046542e-01f, 8.49681906e-03f, 5.09650782e-02f, -7.13304654e-02f, 1.22796923e-01f, -2.07683221e-01f, -1.05692923e-01f, 2.01167166e-01f,
  2.98473388e-02f, 2.30208769e-01f, 9.08231214e-02f, 1.62001118e-01f, 1.58637717e-01f, 1.41415522e-01f, 8.21610093e-02f, 6.03123493e-02f, -2.13567838e-01f, -1.77201405e-01f,
  8.13426450e-02f, -3.72521609e-01f, 2.76796669e-01f, 9.67895612e-02f, -2.04822607e-03f, -6.12285808e-02f, 2.32758000e-01f, 8.04410502e-02f, 2.79046483e-02f, 6.06492385e-02f,
  -4.02448848e-02f, 1.50312418e-02f, 3.54153551e-02f, 3.25850174e-02f, -1.42793924e-01f, 4.80745872e-03f, 2.69727826e-01f, -2.50232905e-01f, 1.16169371e-01f, 5.23273535e-02f,
  -1.19449809e-01f, 1.57757044e-01f, 5.60084870e-03f, -1.32310599e-01f, -2.02205271e-01f, 7.86805227e-02f, 1.24256469e-01f, -3.10737337e-03f, -6.87409490e-02f, 1.45738423e-01f,
  -2.46843714e-02f, 1.08914390e-01f, -4.72521503e-03f, 7.55900377e-03f, -8.77399519e-02f, 2.78490424e-01f, 3.16953182e-01f, -6.66548386e-02f, -2.98571400e-02f, -1.80104777e-01f,
  1.86742574e-01f, -1.46421924e-01f, 1.98234692e-01f, -2.15155587e-01f, 8.81375000e-02f, -1.85531184e-01f, -1.56282246e-01f, 8.76939017e-03f, 2.56237537e-02f, -8.42835605e-02f,
  3.06113120e-02f, -1.48000181e-01f, 1.81410015e-01f, -4.57341969e-02f, 1.44490585e-01f, 1.31297931e-02f, -2.07181156e-01f, 2.36175403e-01f, 1.69565812e-01f, 5.14739603e-02f,
  2.18589693e-01f, 2.20153064e-01f, -3.95975024e-01f, 9.73262042e-02f, -8.07371587e-02f, -3.93620044e-01f, 6.54779151e-02f, 3.14575195e-01f, 2.05476090e-01f, 6.54574558e-02f,
  5.61834015e-02f, 1.15471534e-01f, 2.76355296e-01f, -1.17015347e-01f, 1.87555537e-01f, -8.00231099e-02f, 1.14289738e-01f, -1.30162656e-01f, 3.78757529e-02f, 1.47342950e-01f,
  3.11207384e-01f, -1.07653737e-02f, -1.03436217e-01f, 1.48364589e-01f, -8.05817395e-02f, 4.27001230e-02f, 1.00698866e-01f, 1.90649837e-01f, 6.37194142e-02f, 1.69896390e-02f,
  6.32548705e-02f, -6.59225062e-02f, 7.87156224e-02f, 9.81764942e-02f, 1.88304812e-01f, -1.21720769e-01f, -1.99063256e-01f, 1.37483165e-01f, -1.32768467e-01f, -6.12865426e-02f,
  2.66035944e-01f, -3.14905867e-02f, 2.81225774e-03f, 5.06502315e-02f, 2.00330570e-01f, 6.66657463e-02f, 1.67483523e-01f, -2.39483774e-01f, 1.70638576e-01f, -3.20158660e-01f,
  -3.20493132e-02f, -1.75005525e-01f, 1.84449866e-01f, -8.18870142e-02f, 1.49899751e-01f, -1.44625694e-01f, 3.98229212e-02f, 7.43053705e-02f, 1.84736893e-01f, -1.04697444e-01f,
  -1.91999804e-02f, 6.26001358e-02f, 8.65709335e-02f, -4.67018299e-02f, 2.10337147e-01f, 9.50836092e-02f, -2.26648241e-01f, 2.30466530e-01f, 1.81786940e-02f, -1.09008029e-02f,
  -1.90722272e-02f, 2.40670234e-01f, 8.56673904e-03f, 2.05112219e-01f, 7.23739490e-02f, 4.36760895e-02f, 1.15297981e-01f, -1.39463589e-01f, 1.41042754e-01f, -1.34880781e-01f,
  -1.59273222e-01f, -9.69004482e-02f, -5.33377193e-02f, -2.02796478e-02f, 8.85431767e-02f, -4.38284092e-02f, -2.90235002e-02f, -7.62953609e-02f, -1.03240177e-01f, -2.20347762e-01f,
  -3.84777575e-03f, -8.67736712e-03f, 1.08470164e-01f, -5.07658310e-02f, 7.96056166e-03f, 1.14274407e-02f, 1.44699663e-01f, 2.89407722e-03f, 5.25029525e-02f, -1.38185769e-01f,
  -2.24451974e-01f, 7.88485706e-02f, 1.74469858e-01f, 4.76628132e-02f, -3.86192091e-02f, 1.14374071e-01f, 2.44380921e-01f, 9.44947079e-02f, 1.85970768e-01f, 2.03933157e-02f,
  1.55924298e-02f, -1.13291547e-01f, 1.43238932e-01f, -4.52800691e-02f, 1.28661636e-02f, -1.56846762e-01f, -8.91941264e-02f, -1.04952820e-01f, 1.56047866e-01f, -8.75935480e-02f,
  -1.14540033e-01f, -1.08569851e-02f, 5.81286550e-02f, -9.60419402e-02f, -4.32223305e-02f, 1.77698374e-01f, -6.18866161e-02f, -9.63811278e-02f, 2.18158662e-02f, -1.58776373e-01f,
  3.60235833e-02f, 4.97268289e-02f, 2.29906693e-01f, -2.30173349e-01f, 1.58702031e-01f, 8.21769461e-02f, 3.79019789e-02f, -2.22411882e-02f, -4.43961732e-02f, -3.48653607e-02f,
  -1.62236795e-01f, 2.64897704e-01f, -1.71871230e-01f, 3.91902737e-02f, -4.43137065e-02f, -7.93573037e-02f, 9.84581932e-02f, -5.26141785e-02f, 1.82611328e-02f, -1.01782076e-01f,
  -2.17034072e-01f, -2.67208844e-01f, -1.92855284e-01f, 2.77254432e-01f, 1.47261679e-01f, 1.48541451e-01f, -8.97835717e-02f, 6.84245974e-02f, 1.16562143e-01f, -9.33902115e-02f,
  4.20550928e-02f, 3.20910104e-02f, 3.42156217e-02f, 1.10267267e-01f, 3.57703604e-02f, 8.64715956e-04f, 1.90409478e-02f, 2.18477666e-01f, 1.71732605e-01f, -6.36390119e-04f,
  -2.68362284e-01f, -2.14710310e-01f, 1.15021706e-01f, -1.14132345e-01f, 1.38602525e-01f, -1.09517492e-01f, 9.02860761e-02f, 1.39606833e-01f, -1.14575274e-01f, 1.15144379e-01f,
  1.88143358e-01f, 1.35289669e-01f, 1.53951660e-01f, 6.75452948e-02f, -1.05159245e-01f, -1.21007375e-01f, -7.90774170e-03f, 1.67864636e-01f, 4.57180627e-02f, -9.10060778e-02f,
  3.16337384e-02f, -2.46852860e-02f, 1.62019748e-02f, 3.54315601e-02f, 1.60044551e-01f, -2.14463711e-01f, -7.34231547e-02f, 4.27937843e-02f, 5.24092764e-02f, 1.87991410e-01f,
  3.92759331e-02f, -8.24786052e-02f, -6.98878840e-02f, 2.90192068e-02f, 2.57616267e-02f, 3.52902163e-04f, -6.72501102e-02f, 1.64387897e-01f, 3.00466180e-01f, -4.04526526e-03f,
  1.18138239e-01f, 1.60610348e-01f, 2.29923218e-01f, 3.60735990e-02f, -9.50760618e-02f, 1.02210589e-01f, 1.47245944e-01f, 2.90978253e-02f, -1.11987747e-01f, 6.98182583e-02f,
  -1.25114590e-01f, -1.53935269e-01f, 1.63062349e-01f, -2.54133772e-02f, -3.72147979e-03f, 9.05279592e-02f, 1.97053745e-01f, 7.45096281e-02f, 7.35876858e-02f, 6.40077665e-02f,
  -4.84065637e-02f, -2.17627048e-01f, 2.62967888e-02f, -7.70223467e-03f, 3.23458738e-03f, -5.61701879e-03f, -1.81459822e-02f, 8.76579899e-03f, -7.96591267e-02f, 4.34431061e-02f,
  -9.18869153e-02f, -3.92131023e-02f, -2.22692400e-01f, 3.01906895e-02f, 1.70379043e-01f, 3.72762643e-02f, -5.43205859e-03f, 6.09134585e-02f, 1.42243356e-01f, 1.83341414e-01f,
  6.34483770e-02f, 1.50105923e-01f, 7.98584074e-02f, 1.06807560e-01f, 1.44188991e-02f, -9.59877297e-02f, -8.24704394e-02f, -1.27551273e-01f, 1.83895603e-01f, -7.34054251e-03f,
  3.89395148e-01f, -2.68595099e-01f, 3.86271209e-01f, -3.60588804e-02f, -1.32862821e-01f, -1.05264813e-01f, 1.54929101e-01f, -2.22107738e-01f, 6.28352314e-02f, 2.13635772e-01f,
  -3.78613263e-01f, -2.01020211e-01f, 4.55212630e-02f, 2.38474295e-01f, -1.04715526e-01f, -1.18889667e-01f, -6.58610836e-02f, 1.74868435e-01f, 3.35002393e-01f, -1.53220668e-01f,
  -6.16501421e-02f, 1.90842867e-01f, -1.00472067e-02f, -1.21677481e-01f, -1.91469342e-01f, 2.55872793e-02f, 2.92741321e-02f, 1.18511215e-01f, 1.58564180e-01f, -1.64510027e-01f,
  1.78171873e-01f, 1.87635124e-01f, 1.36894003e-01f, -4.39608768e-02f, 4.34510857e-02f, 2.41853908e-01f, 2.60830790e-01f, -1.24063566e-01f, -1.66779324e-01f, 9.51429550e-03f,
  1.45941796e-02f, -1.62057504e-01f, 1.41112700e-01f, -2.62981411e-02f, 2.22442850e-01f, 1.32088726e-02f, -1.19866557e-01f, 1.59425482e-01f, 8.32403302e-02f, -1.86331209e-03f,
  6.06489554e-03f, 8.28549042e-02f, 6.63217157e-02f, 7.19490573e-02f, -1.29927456e-01f, 8.44034106e-02f, 1.52717195e-02f, -9.49605033e-02f, 2.64394861e-02f, -9.57771912e-02f,
  1.70015112e-01f, -9.85326841e-02f, 4.63173278e-02f, 1.34968191e-01f, -2.48799240e-03f, -1.87833272e-02f, -3.11772060e-02f, 2.03309022e-02f, 1.23444408e-01f, 8.01068023e-02f,
  5.04952036e-02f, 2.32943907e-01f, 7.05232546e-02f, -2.59607106e-01f, 2.50612088e-02f, -3.23150381e-02f, 8.12950805e-02f, 2.95163523e-02f, 3.20867337e-02f, -9.76380929e-02f,
  -8.34244117e-02f, 2.22500265e-01f, 9.14659873e-02f, -1.99486688e-01f, 1.23911925e-01f, 1.16373368e-01f, 4.70390841e-02f, 1.98046193e-01f, 1.05363511e-01f, 1.17844976e-01f,
  4.21948545e-02f, 4.26033996e-02f, -2.33790502e-02f, 7.27678612e-02f, -2.14296654e-02f, -2.41647795e-01f, -2.91319400e-01f, -1.38943896e-01f, 1.12029076e-01f, -1.62139356e-01f,
  8.87636542e-02f, 1.16232857e-02f, -1.40435517e-01f, 1.68694220e-02f, 8.68699551e-02f, 2.51534551e-01f, -1.33215219e-01f, -2.13152945e-01f, 3.19042146e-01f, 2.58215278e-01f,
  -1.47611931e-01f, -1.61188081e-01f, 2.88082331e-01f, -1.17098242e-01f, 1.99765116e-01f, -1.66246183e-02f, 7.72224041e-04f, 9.00709257e-02f, -7.01645315e-02f, -1.17166176e-01f,
  8.97944048e-02f, 6.76928535e-02f, 8.82283449e-02f, -5.08288033e-02f, 1.29193485e-01f, 1.19740248e-01f, -2.40983546e-01f, 1.85302347e-01f, 8.52934122e-02f, 3.38881761e-02f,
  1.36179119e-01f, 1.95458010e-01f, 3.56553565e-03f, 2.16496125e-01f, 2.19244346e-01f, 2.14694053e-01f, 2.16211632e-01f, -3.16387378e-02f, -1.28903419e-01f, -1.82904840e-01f,
  -1.20682448e-01f, -1.08006157e-01f, -7.59704560e-02f, -2.01185480e-01f, -6.76184148e-02f, -7.82912299e-02f, 1.01423398e-01f, -7.38680363e-02f, -2.12018147e-01f, -1.78407595e-01f,
  2.23793209e-01f, -1.08433180e-01f, -5.14429882e-02f, -3.75838242e-02f, -6.38835430e-02f, -1.06167801e-01f, 1.58222795e-01f, -9.02541876e-02f, 3.17234769e-02f, 2.40438730e-02f,
  -1.15356706e-01f, 1.84767678e-01f, 2.33441487e-01f, 3.37523222e-01f, 6.13550432e-02f, 1.39884621e-01f, 3.05036813e-01f, 2.65786201e-01f, 2.14246497e-01f, -4.14329246e-02f,
  1.11699663e-01f, -1.42753288e-01f, 7.31332228e-02f, -1.22517020e-01f, 1.48710445e-01f, -1.48839384e-01f, -5.84425218e-02f, -1.78168327e-01f, -8.26952979e-02f, -1.64842948e-01f,
  7.00384900e-02f, -2.89524272e-02f, -1.10655703e-01f, -1.60367399e-01f, 3.25999171e-01f, 1.40674775e-02f, 1.84843749e-01f, 1.66268915e-01f, -1.44173503e-02f, -5.96237630e-02f,
  -5.67807369e-02f, 1.73899725e-01f, 4.95565757e-02f, 1.53899163e-01f, -2.10034370e-01f, -2.60399938e-01f, -1.96388736e-01f, 8.18025693e-02f, 2.49323994e-01f, 1.99201822e-01f,
  2.41302058e-01f, 5.98394237e-02f, 8.08673576e-02f, -1.62170917e-01f, -1.63793683e-01f, 8.08078647e-02f, 3.78713496e-02f, -9.38279834e-03f, -2.60604650e-01f, -2.58757845e-02f,
  9.12298858e-02f, 6.31591603e-02f, 8.85688066e-02f, -2.74958014e-01f, -9.89387091e-03f, 2.35369548e-01f, 2.19332576e-01f, -1.26375839e-01f, 6.92503601e-02f, 1.88313767e-01f,
  1.98360071e-01f, 6.36277488e-03f, -5.46778319e-04f, 1.12789921e-01f, -7.04146596e-03f, 2.19768941e-01f, 2.01564338e-02f, 1.30464777e-01f, -2.29746401e-01f, 1.72933057e-01f,
  6.45446107e-02f, 1.71844780e-01f, -4.85464074e-02f, 1.79533269e-02f, 1.81005701e-01f, -1.63005143e-02f, 1.53450534e-01f, -1.14629813e-01f, 3.58627141e-01f, 1.16012529e-01f,
  -1.37032881e-01f, 3.29097629e-01f, -1.71852902e-01f, 1.39319688e-01f, 1.73816755e-02f, 2.46858988e-02f, -1.96981221e-01f, -1.10577390e-01f, 2.68842161e-01f, -2.35187545e-01f,
  -3.59696075e-02f, -1.40316069e-01f, 2.89208684e-02f, -5.26936017e-02f, -2.19787464e-01f, -1.79461896e-01f, 7.93238506e-02f, -6.49479851e-02f, 4.07534875e-02f, -1.82459876e-01f,
  -2.58797526e-01f, 1.17458634e-01f, 2.11488023e-01f, -1.98825583e-01f, 1.36752471e-01f, -2.72228438e-02f, 8.72519985e-02f, 3.81197408e-02f, 1.13162667e-01f, 1.90322176e-01f,
  2.07317919e-01f, 4.11483943e-02f, 3.04589272e-02f, 8.86939168e-02f, 2.83082217e-01f, 5.59746921e-02f, 3.57777365e-02f, 9.22272727e-02f, 1.97316650e-02f, 2.28001028e-01f,
  1.42997786e-01f, 3.68479937e-02f, 9.43778921e-03f, 1.73277527e-01f, 1.79328874e-01f, 1.81934133e-01f, -5.75482324e-02f, -9.45626050e-02f, 6.17965683e-02f, 1.72982246e-01f,
  3.89006361e-02f, 2.66272277e-02f, -5.27944975e-02f, -3.14451456e-02f, -1.86725287e-03f, 7.49656558e-02f, -2.74126500e-01f, 1.66032109e-02f, 2.95433581e-01f, -3.43536027e-02f,
  -1.21759005e-01f, -7.94350654e-02f, -2.42864117e-02f, 9.28045958e-02f, 1.39906749e-01f, 3.56385857e-01f, -1.20279916e-01f, 1.63743258e-01f, 1.62211522e-01f, -5.02613150e-02f,
  6.92782179e-02f, 8.79822075e-02f, -6.71778321e-02f, 2.02404976e-01f, 2.15110600e-01f, 1.11753248e-01f, 8.06624815e-02f, 1.30883843e-01f, -4.19935882e-01f, -9.95343775e-02f,
  5.24282083e-02f, -3.75176787e-01f, 1.09629594e-01f, 9.61498246e-02f, 1.34007007e-01f, -1.60294265e-01f, 1.80153385e-01f, 1.04213327e-01f, 2.65594875e-03f, -8.47483277e-02f,
  5.75452410e-02f, 1.03388496e-01f, -2.74485778e-02f, -2.30895355e-01f, -8.67824331e-02f, 9.26646125e-03f, 1.55156583e-01f, -1.18463784e-02f, -8.36075544e-02f, 2.08111450e-01f,
  -1.29242167e-01f, 1.59417376e-01f, 1.18039504e-01f, 1.62545368e-01f, -5.68682328e-02f, -8.84246528e-02f, -8.67358446e-02f, -1.13217220e-01f, 1.40647233e-01f, 5.80122061e-02f,
  -5.19306958e-03f, -5.28130867e-03f, 1.11343801e-01f, 1.59210578e-01f, 3.87334302e-02f, 2.29809076e-01f, 3.30144793e-01f, -1.21817797e-01f, -2.63759941e-01f, -2.76597142e-01f,
  1.87425539e-01f, -6.73477724e-02f, 2.31202349e-01f, -1.98689371e-01f, -3.93965542e-02f, -2.55282044e-01f, -1.84802428e-01f, 7.81463608e-02f, 7.33459517e-02f, 1.60532612e-02f,
  -6.04569279e-02f, -1.18738614e-01f, 5.19370548e-02f, -2.56177068e-01f, 1.95885882e-01f, 1.72423571e-02f, 7.19165057e-02f, 5.06911650e-02f, 1.32474229e-02f, 7.10374489e-02f,
  7.50667751e-02f, -9.84047260e-03f, 4.06358428e-02f, 2.66057788e-03f, 2.89825685e-02f, 1.31908312e-01f, -2.12828308e-01f, -8.62131938e-02f, -1.19822145e-01f, 1.10121496e-01f,
  6.98982775e-02f, -1.57241672e-01f, 3.31247859e-02f, 1.68930683e-02f, 1.58495277e-01f, 3.50609124e-02f, 4.90757264e-02f, 8.26172829e-02f, 3.43593173e-02f, 2.35841021e-01f,
  -4.02182303e-02f, 5.92408702e-04f, 1.37712374e-01f, 1.16525814e-01f, -6.03804656e-04f, -8.74171034e-02f, 1.22834463e-02f, -1.64618026e-02f, 2.12648124e-01f, -8.71340558e-02f,
  6.37540445e-02f, 3.20462793e-01f, 1.73858330e-01f, 1.05782874e-01f, 2.17380717e-01f, 1.02876768e-01f, -2.72482634e-02f, 1.39423743e-01f, -7.82453194e-02f, -1.84085276e-02f,
  -7.44419545e-02f, 1.74086466e-01f, 1.59506947e-01f, 5.55978827e-02f, -2.24751130e-01f, -1.03877962e-01f, 1.03200674e-01f, 2.93671578e-01f, -1.56511769e-01f, -1.01002835e-01f,
  1.41925484e-01f, 1.12358011e-01f, 8.27501640e-02f, 2.73904949e-01f, -8.46933052e-02f, 2.41842166e-01f, 7.19809979e-02f, 1.80105105e-01f, -6.25918582e-02f, 2.72591263e-02f,
  1.02240674e-01f, 1.26611054e-01f, 4.68604593e-03f, 6.27652109e-02f, 1.99950952e-02f, 1.17838517e-01f, -1.13275528e-01f, -1.59496635e-01f, 1.01061828e-01f, -2.10840046e-01f,
  2.01654315e-01f, -2.47886293e-02f, -4.50251251e-02f, -1.04851335e-01f, 1.24080390e-01f, 2.27670893e-01f, 5.71680292e-02f, 6.68800101e-02f, -5.19924052e-02f, 2.36930683e-01f,
  -1.15280107e-01f, -9.06907544e-02f, -2.20056191e-01f, 4.32766117e-02f, 2.15035945e-01f, -9.64751244e-02f, -1.75675020e-01f, 1.58059075e-01f, -1.55474246e-01f, 1.19419754e-01f,
  -7.90232792e-02f, -9.46611241e-02f, -1.69685528e-01f, -1.26232550e-01f, -4.01725918e-02f, -2.04295516e-01f, -7.81229660e-02f, 2.17379496e-01f, 6.76264334e-03f, 1.08778581e-01f,
  2.16560185e-01f, 7.30207413e-02f, -6.85975999e-02f, 2.62464970e-01f, 2.59988397e-01f, -1.52854016e-02f, -1.85993612e-02f, -1.84891924e-01f, 1.88031793e-01f, -1.99606448e-01f,
  1.21889738e-02f, -2.45828047e-01f, -2.88343374e-02f, -1.12050548e-01f, -4.85012904e-02f, 9.14600492e-02f, -7.54505545e-02f, -1.89888552e-01f, -1.68680713e-01f, -1.21658906e-01f,
  6.80358335e-02f, -2.59932309e-01f, 8.05283785e-02f, 1.29162326e-01f, 1.86006483e-02f, 1.63673148e-01f, -1.14658661e-01f, 1.34733886e-01f, -3.84220816e-02f, -3.42296399e-02f,
  2.41522923e-01f, 2.43351817e-01f, 1.88744351e-01f, 1.02235004e-01f, 1.65571406e-01f, -2.31743485e-01f, 2.23991070e-02f, 1.83366299e-01f, 8.65924507e-02f, -6.14313483e-02f,
  3.78363654e-02f, 1.88212320e-01f, -1.65389240e-01f, -9.46332589e-02f, 1.82244241e-01f, 1.47399351e-01f, 6.38353378e-02f, -1.22389793e-01f, -2.33723164e-01f, 1.08748734e-01f,
  1.26766846e-01f, -1.37593001e-01f, 4.50595245e-02f, -2.52451003e-02f, 1.39026031e-01f, -2.81209182e-02f, -7.86810294e-02f, 7.18056560e-02f, -1.24986626e-01f, 1.68434396e-01f,
  3.06228697e-02f, -4.91378382e-02f, 1.31145313e-01f, 1.01105981e-01f, 9.93269384e-02f, 7.16291219e-02f, 1.17302641e-01f, 2.06218958e-01f, 2.72916090e-02f, 2.49690741e-01f,
  1.57741636e-01f, 2.51583606e-01f, -1.64506838e-01f, -1.18479922e-01f, 2.68949922e-02f, 1.28805533e-01f, 3.89888324e-02f, 2.47705504e-01f, 2.86717057e-01f, 9.83507559e-03f,
  3.05411555e-02f, -5.07246666e-02f, -5.58330901e-02f, 7.13895485e-02f, 9.01520401e-02f, -1.32435216e-02f, -1.56750485e-01f, -4.02255207e-02f, 8.93590450e-02f, 2.12216735e-01f,
  1.89792693e-01f, 1.11524485e-01f, 8.97694379e-02f, 1.03924751e-01f, 1.47727475e-01f, -7.24567249e-02f, -1.03166893e-01f, 2.43812427e-01f, -4.29870307e-01f, -1.91306621e-01f,
  1.89137653e-01f, 1.73552319e-01f, -1.60604328e-01f, 1.46907747e-01f, -1.24018313e-02f, 1.32044971e-01f, 2.40176722e-01f, 1.53027415e-01f, 1.34903267e-01f, -1.17681675e-01f,
  2.33608007e-01f, 3.13278645e-01f, 3.97959724e-02f, -2.47994035e-01f, -2.49888390e-01f, 1.69043303e-01f, 5.87770306e-02f, -7.49531621e-03f, 2.75058616e-02f, -1.85504053e-02f,
  1.55729070e-01f, -6.18582219e-02f, -5.52107161e-03f, 1.41756088e-01f, -4.31884788e-02f, -6.15592375e-02f, 7.12336078e-02f, 1.02207169e-01f, 1.87204033e-01f, 1.22361369e-01f,
  -1.51594562e-04f, -2.04464898e-01f, -1.69102386e-01f, 2.89137602e-01f, 2.41900310e-01f, 1.93787411e-01f, 4.42540906e-02f, -3.43516618e-02f, -2.58784175e-01f, 2.76863962e-01f,
  -1.25613719e-01f, 1.24319755e-01f, 3.84851515e-01f, -3.12389284e-02f, 5.04270121e-02f, -4.11036760e-02f, 5.86905256e-02f, 2.75266524e-02f, -2.03243077e-01f, 2.01441526e-01f,
  -6.04164824e-02f, 5.99525087e-02f, -5.77089041e-02f, -8.45836997e-02f, 1.25519261e-01f, 3.39319967e-02f, 1.26430914e-01f, 5.26582040e-02f, 2.15167403e-01f, -1.80242196e-01f,
  6.61788881e-02f, 1.45208001e-01f, -3.03876083e-02f, 4.88471389e-02f, 7.79656395e-02f, -4.57014740e-02f, -8.88126269e-02f, -4.18443196e-02f, 2.03574672e-01f, -8.00939649e-02f,
  -1.31287038e-01f, -7.71408230e-02f, -2.09099129e-01f, 6.24699704e-02f, 4.66432050e-02f, 2.08400145e-01f, 2.29583502e-01f, 4.01454465e-03f, 1.51223272e-01f, -7.49532878e-02f,
  9.18360651e-02f, -2.56873071e-01f, -6.70693070e-02f, -2.24999577e-01f, -2.89537404e-02f, 8.82524773e-02f, 1.81400508e-01f, -1.01586871e-01f, -4.68319096e-03f, -1.36018589e-01f,
  3.22197884e-01f, 1.30218148e-01f, 1.70648009e-01f, 1.14583835e-01f, -3.68070826e-02f, -9.58253220e-02f, -1.59747526e-01f, -7.19320551e-02f, -8.26859251e-02f, 9.72997546e-02f,
  -1.85173340e-02f, 7.35303562e-04f, 4.50055115e-02f, 7.27100000e-02f, -1.46924984e-02f, -2.33029261e-01f, -8.32902640e-02f, 5.18298410e-02f, -8.52206796e-02f, 1.26982927e-01f,
  -3.56626548e-02f, 1.07982807e-01f, -8.49007294e-02f, 2.25551620e-01f, -2.22067162e-01f, 2.15516582e-01f, 1.58486903e-01f, -2.51534097e-02f, 1.73206940e-01f, 7.42863417e-02f,
  2.59667754e-01f, 1.40320390e-01f, -3.49610955e-01f, -1.83409587e-01f, -1.19132064e-01f, -1.38714015e-01f, -4.85123321e-02f, 6.55553341e-02f, -1.10216819e-01f, 2.85806537e-01f,
  1.74516708e-01f, 1.92743868e-01f, 1.41394675e-01f, -1.21941023e-01f, 2.44170859e-01f, 1.59494981e-01f, -1.96148843e-01f, -2.48915762e-01f, 5.20702302e-02f, 2.88851202e-01f,
  2.82943577e-01f, -1.93456501e-01f, -7.06533194e-02f, 2.91045338e-01f, -9.15271193e-02f, 2.11135969e-02f, -2.17410061e-03f, -1.17087856e-01f, 2.11404175e-01f, -1.83123827e-01f,
  1.40842363e-01f, 1.18799448e-01f, -3.92933190e-02f, 6.00104704e-02f, 3.70466933e-02f, 9.48164761e-02f, 9.59420279e-02f, 1.32868648e-01f, -2.26556793e-01f, -1.42517194e-01f,
  2.10471433e-02f, -1.25556871e-01f, 1.53675467e-01f, -8.97550359e-02f, 1.02883123e-01f, -2.11292878e-01f, -4.67545278e-02f, 5.14074340e-02f, -2.84803361e-01f, -3.18435788e-01f,
  1.75948769e-01f, -8.20826888e-02f, -2.67989952e-02f, 1.10892333e-01f, -2.42509797e-01f, -2.43257023e-02f, -9.17297043e-03f, 5.15258200e-02f, 1.66580811e-01f, 2.97386460e-02f,
  4.19526473e-02f, -2.08112728e-02f, 8.66946653e-02f, -1.81103021e-01f, 3.13881896e-02f, 5.09993993e-02f, -1.34125557e-02f, 1.56843632e-01f, -1.41702285e-02f, 1.30481780e-01f,
  -6.66387752e-02f, 1.00797497e-01f, 1.85220223e-02f, 1.31175548e-01f, 2.94336490e-02f, 9.12489742e-02f, -1.12069966e-02f, -1.10339783e-01f, 1.63436353e-01f, -7.32013211e-02f,
  -7.02410862e-02f, -2.99356822e-02f, -6.20733276e-02f, 5.24356142e-02f, -3.54633071e-02f, -7.43992999e-03f, 2.30096374e-02f, 4.43386734e-02f, -1.41817331e-01f, -1.16803475e-01f,
  7.29908124e-02f, 2.92021874e-02f, 1.27558291e-01f, 8.51385146e-02f, -1.50103912e-01f, -2.97746304e-02f, 2.04831585e-01f, -3.08115361e-03f, -3.57207991e-02f, -1.17951050e-01f,
  -1.83176607e-01f, 1.73696861e-01f, 2.03276917e-01f, -2.70604230e-02f, 1.03683278e-01f, 2.04684496e-01f, 2.68906593e-01f, 1.41266465e-01f, 1.99431963e-02f, -1.54885286e-02f,
  -1.14405312e-01f, -1.18816860e-01f, 1.42960086e-01f, -2.28172243e-02f, 2.38420472e-01f, -1.40509889e-01f, -7.83221424e-02f, -8.34085885e-03f, 3.56969088e-02f, -6.55470192e-02f,
  -2.66398787e-01f, -6.84333369e-02f, 2.89173722e-02f, -8.39778632e-02f, 2.63953358e-01f, 6.99968114e-02f, 1.67238683e-01f, 1.36845961e-01f, -1.31913081e-01f, -2.25918800e-01f,
  1.41217932e-01f, 4.60304469e-02f, 2.27414578e-01f, 1.37335002e-01f, -2.24298626e-01f, -3.35253507e-01f, -2.18951911e-01f, -8.11982155e-02f, 2.34499127e-01f, -1.12913027e-01f,
  4.75769192e-02f, 2.55561233e-01f, 1.90234855e-01f, 6.97497465e-03f, 1.09982518e-02f, 1.82644635e-01f, 2.31243297e-01f, 1.05757609e-01f, -3.00821304e-01f, -1.53869286e-01f,
  1.90603882e-01f, 5.19053452e-03f, 1.76905677e-01f, -1.13053523e-01f, -1.50522083e-01f, 1.69862598e-01f, 2.42393583e-01f, 4.10491563e-02f, -5.78243621e-02f, 2.88065732e-01f,
  9.20815766e-02f, -1.50857985e-01f, 1.11308224e-01f, 9.16701928e-02f, 3.43822241e-02f, 1.47932336e-01f, 5.89615889e-02f, 1.74671620e-01f, -8.63169506e-02f, 2.64077168e-02f,
  -1.38216302e-01f, 1.75415445e-02f, -2.48650029e-01f, -6.41001537e-02f, 9.95337516e-02f, 3.00324559e-01f, 1.43820241e-01f, -6.90797865e-02f, 2.29338378e-01f, -8.63120854e-02f,
  1.55804185e-02f, 1.22386724e-01f, -7.68889338e-02f, 2.42770404e-01f, 3.49654406e-02f, 8.13333169e-02f, 4.28785793e-02f, 8.32130238e-02f, -1.16573395e-02f, 1.92481145e-01f,
  1.29241630e-01f, -2.63892524e-02f, -5.54425362e-03f, 1.46748528e-01f, -1.53007537e-01f, -2.19745353e-01f, -9.17261243e-02f, -5.28870057e-03f, 2.48512045e-01f, 1.82742238e-01f,
  1.23475797e-01f, -1.69847280e-01f, 6.75241649e-02f, 1.76636383e-01f, 3.90305072e-02f, -6.94266781e-02f, -3.57417539e-02f, 1.60156220e-01f, -2.35567708e-03f, -1.68719798e-01f,
  -6.84429407e-02f, -2.20570229e-02f, 1.06312670e-01f, -6.96503595e-02f, -1.21437669e-01f, -2.49831807e-02f, 3.18108425e-02f, 3.07301819e-01f, 2.54937410e-02f, -2.71666218e-02f,
  -2.10998446e-01f, -6.04371466e-02f, 1.35990143e-01f, -1.80130303e-01f, -1.21569984e-01f, 1.38128996e-01f, 1.23266457e-02f, 2.63813492e-02f, 1.74378708e-01f, 1.72926742e-03f,
  -1.23930760e-01f, 2.81304091e-01f, 3.19169670e-01f, -7.34898299e-02f, -1.24897391e-01f, -1.48730919e-01f, 2.79003531e-01f, -5.37019111e-02f, 8.90286416e-02f, -1.37024492e-01f,
  1.01857148e-01f, 3.57405394e-02f, -2.30306700e-01f, 1.65457264e-01f, 2.24385783e-03f, -8.83226544e-02f, -3.75752337e-02f, -1.61751598e-01f, 1.29715890e-01f, -7.94744715e-02f,
  7.98133016e-02f, 1.56063110e-01f, -1.68685868e-01f, -1.61340266e-01f, -1.31445289e-01f, -2.13562772e-01f, 1.18788086e-01f, 4.59029861e-02f, -2.53397435e-01f, -1.06747851e-01f,
  -1.87777907e-01f, -1.97279587e-01f, -3.10281720e-02f, 3.00154597e-01f, -4.02947180e-02f, 3.56123634e-02f, 1.95255615e-02f, -2.24396765e-01f, 8.47212896e-02f, -1.47504792e-01f,
  1.37362465e-01f, 1.56829357e-01f, -1.86016150e-02f, -1.44741446e-01f, -1.62620559e-01f, 2.45108549e-02f, 2.95235932e-01f, -2.61190951e-01f, 1.34755179e-01f, 1.05813891e-01f,
  -2.09110558e-01f, -4.75208536e-02f, -8.80619064e-02f, -6.46121949e-02f, -2.31220517e-02f, -7.32522383e-02f, 2.03329563e-01f, 1.37686282e-01f, 8.64621326e-02f, 4.44538034e-02f,
  1.99059352e-01f, -1.26326948e-01f, 7.43660927e-02f, 3.04036811e-02f, 3.52181084e-02f, -3.23901437e-02f, 1.28460070e-02f, -8.07835162e-02f, 1.57899186e-01f, -6.21119216e-02f,
  1.01910077e-01f, -9.31679383e-02f, 2.04511955e-01f, -3.40551734e-01f, 5.67269884e-02f, -1.52430028e-01f, -1.58226490e-01f, 2.12715268e-02f, -2.41876006e-01f, 2.82019153e-02f,
  -1.08264238e-02f, -1.61364656e-02f, 1.38194993e-01f, -2.06229731e-01f, 3.26000959e-01f, 7.67420381e-02f, 1.33993670e-01f, -2.38624334e-01f, -1.71160251e-02f, -8.11392888e-02f,
  1.21477984e-01f, -3.44242377e-04f, -1.19273029e-01f, 1.27439573e-01f, 1.39773071e-01f, 4.50875282e-01f, 1.65734380e-01f, 7.38629326e-02f, -2.97283214e-02f, 2.68180668e-01f,
  1.01940662e-01f, -8.28227550e-02f, 1.13816798e-01f, -1.71772540e-01f, 9.23448056e-02f, -4.39830311e-02f, 9.51514915e-02f, 9.48363468e-02f, -1.64929375e-01f, -1.39288411e-01f,
  7.09685031e-03f, 3.24278101e-02f, 2.74447232e-01f, 8.98184255e-03f, -1.98939875e-01f, -2.02132046e-01f, 8.38199779e-02f, -1.24728434e-01f, 1.56402826e-01f, -5.90887517e-02f,
  -1.38732828e-02f, 3.89935598e-02f, 1.08223140e-01f, 7.04958886e-02f, 2.14232113e-02f, -1.36645690e-01f, -1.11135505e-01f, 2.39004657e-01f, 2.22318485e-01f, 2.31839091e-01f,
  -5.77636361e-02f, 6.99605644e-02f, 2.74114251e-01f, 1.91991434e-01f, 3.42835262e-02f, 3.61206159e-02f, 7.67596290e-02f, -2.49710172e-01f, 1.07665382e-01f, 1.85349897e-01f,
  1.41730890e-01f, -1.46278337e-01f, 5.35795987e-02f, -2.19425615e-02f, -9.42396596e-02f, -6.12861998e-02f, -8.97982717e-02f, 7.42472932e-02f, -1.45329013e-01f, -1.78067815e-02f,
  1.92885876e-01f, 3.13563883e-01f, 2.03356132e-01f, 7.63857141e-02f, 1.77444369e-01f, -7.77732730e-02f, -1.18489295e-01f, -6.89588189e-02f, 8.15070793e-02f, -2.53771603e-01f,
  9.09791961e-02f, 8.70817527e-02f, -1.71932101e-01f, -5.00837229e-02f, 2.39475489e-01f, -1.19558036e-01f, 3.25229943e-01f, 9.66250077e-02f, 3.77099738e-02f, -1.15741879e-01f,
  -1.35963202e-01f, 1.93168774e-01f, 1.23603962e-01f, 1.05994426e-01f, 8.46959427e-02f, 5.12391282e-03f, 2.06841663e-01f, -5.79854101e-02f, -7.78391510e-02f, -6.21904992e-02f,
  -5.89905679e-02f, -4.95295785e-02f, 7.07619935e-02f, 3.11195143e-02f, 3.20004493e-01f, 1.11020520e-01f, 1.96636856e-01f, -1.13672473e-01f, 1.72286347e-01f, -9.97051783e-03f,
  -6.28677681e-02f, 2.34051034e-01f, 3.45262811e-02f, 1.92030564e-01f, 2.26836726e-01f, -7.98976719e-02f, -1.71773732e-01f, 1.29428834e-01f, 1.68945789e-01f, 1.42745987e-01f,
  2.07897052e-01f, -1.40311029e-02f, 1.95557013e-01f, -9.50960293e-02f, -2.62074858e-01f, 1.43537885e-02f, 9.09738317e-02f, 2.48097137e-01f, -6.16291873e-02f, 2.12791353e-01f,
  8.46809521e-02f, -1.15934394e-01f, 1.55163243e-01f, 4.38854992e-02f, 3.60575140e-01f, -1.00999191e-01f, 1.32884413e-01f, 8.27605352e-02f, 1.10618956e-02f, -5.17726019e-02f,
  1.39298765e-02f, -8.84216353e-02f, -4.97290306e-02f, 2.24226594e-01f, -2.92386506e-02f, -1.66471899e-01f, -1.67705983e-01f, -4.38855775e-02f, 1.94703937e-01f, -1.24319434e-01f,
  -2.37530842e-01f, -8.78716558e-02f, 1.54289618e-01f, 1.24657802e-01f, -3.73661906e-01f, 5.85659854e-02f, 8.76714289e-02f, 1.12277985e-01f, -9.71670300e-02f, -1.50295421e-01f,
  1.09576032e-01f, 1.20210707e-01f, 2.96656396e-02f, 1.45553932e-01f, -1.00086622e-01f, -8.93043354e-02f, 7.48635679e-02f, 9.17865783e-02f, 1.29185155e-01f, -3.20173986e-02f,
  -1.07508134e-02f, 2.94108130e-02f, 1.36131674e-01f, 8.89402106e-02f, 1.34154797e-01f, 2.35185534e-01f, -4.42161970e-02f, -9.46303830e-03f, -1.55275851e-01f, -2.03632474e-01f,
  -1.85404792e-01f, -5.05079441e-02f, -1.91689044e-01f, -1.56104282e-01f, 2.66974956e-01f, 7.16301575e-02f, -1.33343816e-01f, 2.26455346e-01f, 1.71621963e-02f, 1.89831361e-01f,
  -1.43514259e-03f, 2.91905016e-01f, -8.03377107e-02f, 1.67003915e-01f, 1.23451352e-01f, 1.36716679e-01f, 1.93941947e-02f, 1.57167792e-01f, 1.68880761e-01f, 1.18598334e-01f,
  2.38889605e-02f, -6.64564082e-03f, -6.94144797e-03f, -2.92291552e-01f, -7.43150152e-03f, 1.95208848e-01f, 2.24483654e-01f, -3.63796234e-01f, 8.74192640e-02f, -6.77215913e-03f,
  -6.88508502e-04f, 5.25505617e-02f, -3.98689602e-03f, -4.77697589e-02f, 1.01085179e-01f, 2.39305273e-02f, -1.50961220e-01f, -1.37619883e-01f, -1.08039901e-01f, 2.12566882e-01f,
  2.31945261e-01f, -1.29780034e-02f, -3.12137045e-02f, -1.66306049e-01f, 2.75217116e-01f, -9.00970697e-02f, 6.91483840e-02f, 8.37576911e-02f, 7.89729580e-02f, 1.00987762e-01f,
  -2.75208559e-02f, 7.97367096e-02f, 2.24037468e-01f, -2.32720748e-02f, 7.98524842e-02f, -1.24965124e-02f, 8.78227800e-02f, -1.21683739e-01f, 7.95837715e-02f, 6.78366870e-02f,
  -5.87099269e-02f, 1.55721217e-01f, 2.40700930e-01f, -1.71003237e-01f, -2.56153226e-01f, 1.60084963e-02f, -3.85293476e-02f, 1.76411569e-01f, 1.38544455e-01f, -4.59699035e-02f,
  2.33219832e-01f, 1.57190740e-01f, -1.68706402e-01f, 1.94639037e-03f, 1.26978755e-01f, 2.47313693e-01f, 9.07528028e-02f, 1.71134323e-01f, -3.80612947e-02f, -1.15105629e-01f,
  -3.15113105e-02f, -2.94352565e-02f, -1.28375098e-01f, 2.39823624e-01f, 1.55959800e-01f, -1.64573360e-02f, -4.06274945e-02f, 1.06619917e-01f, 3.16302478e-01f, 3.34136814e-01f,
  1.53110504e-01f, 1.74885780e-01f, -4.80244577e-01f, 3.49567197e-02f, 7.76477307e-02f, -5.94471656e-02f, -8.94932076e-02f, 5.92210703e-02f, 5.12263477e-02f, 3.58503729e-01f,
  -1.21060744e-01f, -1.61346316e-01f, 1.40804768e-01f, 4.51578051e-02f, -5.50694838e-02f, -8.56770948e-02f, -1.62841767e-01f, 4.19182517e-02f, -4.05763276e-02f, -5.47909923e-02f,
  2.90612802e-02f, -2.09003344e-01f, -2.28289627e-02f, -1.10425148e-02f, 1.81531876e-01f, -1.11645870e-01f, -2.51154989e-01f, 4.13674535e-03f, 2.06713617e-01f, -3.72637659e-01f,
  1.03138655e-01f, 7.36189112e-02f, -1.16221488e-01f, -8.20719600e-02f, 2.53485829e-01f, 4.32004407e-02f, -1.69172540e-01f, 3.30533028e-01f, -5.06401472e-02f, 2.82120109e-01f,
  1.38818249e-01f, -6.00826256e-02f, -3.52519065e-01f, 2.81868756e-01f, 2.39609480e-01f, -9.30406675e-02f, 2.89954811e-01f, -1.11540414e-01f, -4.64291684e-03f, -4.18229759e-01f,
  -2.45688371e-02f, -2.23440621e-02f, -1.61224648e-01f, 1.91953689e-01f, -1.78073287e-01f, -1.57662213e-01f, 7.16397986e-02f, 2.14209080e-01f, 2.71454960e-01f, 1.45742238e-01f,
  1.21391386e-01f, 2.79037565e-01f, -2.07811430e-01f, -6.31697476e-03f, 1.26935974e-01f, -1.82107985e-01f, -4.38418478e-01f, 1.37414202e-01f, 2.87509412e-01f, -2.43337192e-02f,
  -6.41007945e-02f, 3.37663978e-01f, 1.75337493e-01f, 5.68029806e-02f, -5.25456965e-02f, 1.74726527e-02f, -2.90608525e-01f, -1.66902304e-01f, 1.35675713e-01f, 7.81030580e-02f,
  1.09467410e-01f, -2.17451140e-01f, -1.00290775e-01f, 5.20492019e-03f, -1.28833637e-01f, 9.69761163e-02f, -1.20792584e-02f, 7.36097768e-02f, 1.95289105e-01f, -5.50445877e-02f,
  1.18124448e-01f, 6.09544590e-02f, 1.26390070e-01f, -1.50452062e-01f, 7.29813352e-02f, 1.73530355e-01f, 1.15006499e-01f, 1.10667802e-01f, 2.26159990e-01f, 8.13898295e-02f,
  2.45388657e-01f, 1.48589075e-01f, -2.54504621e-01f, -8.50585848e-02f, 2.72622764e-01f, 5.45087755e-02f, -8.17113221e-02f, 2.26906046e-01f, 1.51266769e-01f, -2.39947245e-01f,
  1.42171094e-02f, 1.30699612e-02f, 1.14626847e-01f, 2.42104325e-02f, 1.40656084e-01f, -1.91086203e-01f, -2.08454937e-01f, 1.64376572e-01f, -4.56996970e-02f, -1.62974745e-02f,
  -3.00149061e-02f, -1.01658717e-01f, -8.26346353e-02f, -6.97140545e-02f, 4.20706198e-02f, 9.65452790e-02f, 4.42289822e-02f, 1.29915342e-01f, 8.69543403e-02f, -1.32029764e-02f,
  1.83599353e-01f, 4.95610088e-02f, 1.24934494e-01f, 8.91546607e-02f, 1.01660475e-01f, -1.06341951e-01f, 2.84919282e-03f, -1.42273545e-01f, 2.15704069e-01f, -2.32692994e-02f,
  1.26217812e-01f, 1.99480243e-02f, 6.23463430e-02f, -7.71619007e-02f, 3.29712667e-02f, -1.13941260e-01f, -1.12555679e-02f, 7.49421632e-03f, -4.35879938e-02f, 8.12911615e-03f,
  2.34311581e-01f, 3.73763926e-02f, 2.61420142e-02f, 2.20937192e-01f, -6.97566420e-02f, 3.53071615e-02f, 5.79320230e-02f, 1.87464476e-01f, 4.83365636e-03f, -1.42493963e-01f,
  -1.22477107e-01f, 4.23812680e-02f, -1.06535060e-02f, -1.40130490e-01f, 2.56120786e-03f, 7.10331928e-03f, 1.09548040e-01f, 1.15752079e-01f, -1.01745851e-01f, -1.16806617e-03f,
  -2.54666023e-02f, -9.66540202e-02f, 2.03750078e-02f, 6.36067102e-03f, 2.82368511e-02f, -1.13557428e-01f, 1.18293121e-01f, -9.95907336e-02f, 1.89917628e-02f, -1.22897075e-02f,
  -1.56788662e-01f, -7.15831369e-02f, 1.84382405e-02f, -6.39581904e-02f, 1.08633459e-01f, 1.11182109e-01f, 1.65637016e-01f, 5.59674539e-02f, -3.53643894e-02f, 8.48147124e-02f,
  2.45625451e-01f, 1.12548858e-01f, 1.20326288e-01f, 4.32549953e-01f, -1.12403847e-01f, -9.83063728e-02f, -1.78253092e-02f, 3.10758837e-02f, -4.18437012e-02f, 1.36295006e-01f,
  6.31869510e-02f, 1.64140150e-01f, -1.09212242e-01f, -2.10534465e-02f, 1.26682714e-01f, 3.86174805e-02f, -2.65440531e-02f, -1.39633775e-01f, -1.75232708e-01f, 1.34811789e-01f,
  6.42117783e-02f, -9.28450935e-03f, 1.41017124e-01f, -1.73289254e-01f, 4.82283905e-02f, 3.62573862e-02f, 1.48423672e-01f, -1.11357480e-01f, -2.01453507e-01f, 1.20013982e-01f,
  1.00783341e-01f, -8.09892267e-02f, 5.71776479e-02f, 1.17159463e-01f, -5.84410504e-03f, 6.35526702e-02f, 2.75234208e-02f, 7.50312805e-02f, -2.07736328e-01f, 2.67235339e-01f,
  3.91193271e-01f, 2.93976992e-01f, -8.24064687e-02f, 1.39803216e-02f, 4.71907109e-02f, 1.90436259e-01f, 4.56799604e-02f, 3.73541974e-02f, 1.91669732e-01f, 1.27157206e-02f,
  1.32557660e-01f, -1.37360379e-01f, -8.61284733e-02f, -2.43452916e-04f, 6.67125359e-02f, 1.44108877e-01f, -1.81042746e-01f, -3.73750529e-03f, -1.94215357e-01f, -3.72124389e-02f,
  -7.19548985e-02f, 8.23149607e-02f, -9.11511295e-03f, 8.41782615e-02f, 5.68825081e-02f, 2.48709932e-01f, 1.34833917e-01f, -9.53849852e-02f, 3.74037772e-02f, -9.45928469e-02f,
  1.17307648e-01f, 1.26879960e-01f, -1.43295661e-01f, -2.56301593e-02f, 3.54297049e-02f, -1.17527572e-02f, 1.89555556e-01f, 3.44587257e-03f, 1.81907207e-01f, -7.27226958e-02f,
  1.56524181e-01f, -5.90872206e-03f, -7.90155828e-02f, -8.13478306e-02f, -7.73464665e-02f, -3.65110449e-02f, 4.86816503e-02f, 9.58297402e-02f, 6.51547685e-02f, 6.27146009e-03f,
  1.58875622e-02f, 1.68562457e-01f, 1.32647408e-02f, -1.34737499e-03f, -8.83502662e-02f, 1.70074224e-01f, -3.56984474e-02f, -1.63786978e-01f, -1.56579658e-01f, 7.41828457e-02f,
  -8.95244349e-03f, -1.70776561e-01f, 1.41952708e-01f, 7.74264187e-02f, -3.36467661e-02f, -1.16723869e-02f, -5.54834493e-02f, 1.05288841e-01f, -1.24282010e-01f, 2.36018375e-03f,
  1.27763376e-01f, 1.74646124e-01f, -4.55437377e-02f, -1.15963416e-02f, 2.08412930e-01f, 1.35733280e-02f, 1.64486676e-01f, 1.24081820e-02f, -5.57062998e-02f, 1.16477914e-01f,
  -3.51160794e-04f, -1.56599984e-01f, 1.22762740e-01f, 4.95621786e-02f, -1.99663937e-02f, 1.83286905e-01f, 9.26908106e-03f, 1.15576677e-03f, 2.24445939e-01f, 1.01061627e-01f,
  1.47411581e-02f, 1.72326222e-01f, 1.92109481e-01f, -3.77470106e-02f, 3.09542894e-01f, -1.14392817e-01f, -1.64002836e-01f, -7.47429654e-02f, -1.23300329e-01f, 9.48896259e-02f,
  1.61767937e-02f, 5.04160561e-02f, -1.01025879e-01f, 3.81851718e-02f, 1.58732422e-02f, -2.49832142e-02f, -9.20894817e-02f, -1.46896228e-01f, -4.72705700e-02f, -2.33168259e-01f,
  8.61939788e-03f, 2.32151508e-01f, 1.93353221e-01f, 5.39430939e-02f, 6.29048124e-02f, 3.25813830e-01f, -9.36256051e-02f, -2.00525999e-01f, -1.29905283e-01f, 1.18742771e-01f,
  -7.87414163e-02f, 2.68452708e-02f, 1.07334711e-01f, -2.05516607e-01f, -6.16297089e-02f, 2.05110367e-02f, 1.48437694e-01f, 1.90063417e-02f, -1.02084830e-01f, -9.39499587e-02f,
  8.45109150e-02f, 8.40313286e-02f, -1.88886061e-01f, -2.68176571e-02f, 1.26739055e-01f, 4.05318379e-01f, -1.78098351e-01f, 1.20602854e-01f, 1.80932462e-01f, -2.00001583e-01f,
  1.79549336e-01f, -9.52830836e-02f, -3.93479019e-02f, -2.17570346e-02f, -1.16103560e-01f, 9.00452584e-02f, -1.62263354e-03f, 1.30095020e-01f, 8.22269469e-02f, 1.61766097e-01f,
  3.63871045e-02f, 2.22149223e-01f, 1.05181769e-01f, -7.93729126e-02f, 3.15812454e-02f, 1.70008317e-01f, -8.19968358e-02f, -1.30731091e-01f, 1.62597880e-01f, -2.91619617e-02f,
  -4.27443497e-02f, 1.46912113e-01f, -6.32546842e-02f, 1.32620752e-01f, 1.45947874e-01f, 1.07474692e-01f, 9.61764529e-02f, 3.09284907e-02f, 1.89172313e-01f, 1.68360561e-01f,
  -1.28501039e-02f, -1.63382515e-01f, -6.70565218e-02f, 1.58437490e-01f, 1.65167704e-01f, 3.86687741e-03f, 5.36594074e-03f, 1.50100559e-01f, 5.55157587e-02f, 1.07419357e-01f,
  5.03147840e-02f, 8.17477331e-02f, -1.15617909e-01f, -9.36275497e-02f, -5.65670431e-02f, 2.29270816e-01f, 1.38776541e-01f, -3.58453356e-02f, -4.53833118e-02f, -1.25665024e-01f,
  1.12471236e-02f, 1.73362866e-01f, 4.47535478e-02f, 9.60370824e-02f, -6.65069139e-03f, -3.53693292e-02f, -1.99267730e-01f, 3.35272789e-01f, -1.88800037e-01f, 1.30545944e-02f,
  2.69683748e-01f, 2.87992414e-02f, -9.58133861e-02f, 6.26435280e-02f, 7.03807827e-03f, -1.26941251e-02f, 3.73975411e-02f, 2.45422021e-01f, -1.78905472e-01f, -2.58890763e-02f,
  8.62790346e-02f, -3.51531170e-02f, 1.11269951e-01f, 1.42349824e-01f, 1.79996520e-01f, 3.38367045e-01f, -3.38735372e-01f, -1.92161620e-01f, -1.89845085e-01f, -1.20142801e-02f,
  2.35071126e-02f, -1.08713664e-01f, -1.07537322e-01f, 2.22886115e-01f, 3.78938355e-02f, 2.13855341e-01f, -9.86537337e-02f, 1.00495610e-02f, 1.79278389e-01f, 1.22881018e-01f,
  1.54059008e-01f, -1.78623274e-01f, 3.79662588e-02f, 1.75453424e-01f, 3.25135216e-02f, -1.70013178e-02f, -4.81795259e-02f, 1.25693262e-01f, 7.02067241e-02f, -8.54848921e-02f,
  -6.29643872e-02f, -1.00490712e-01f, 1.86453640e-01f, -3.72352749e-02f, -2.48724949e-02f, 8.72481391e-02f, 1.38828009e-02f, 1.73883989e-01f, 7.57120103e-02f, -1.11099087e-01f,
  -8.78604501e-02f, 2.12541595e-01f, -1.07034929e-01f, -6.31753951e-02f, -1.10843420e-01f, 9.04428512e-02f, 2.11933270e-01f, 9.95954126e-02f, -6.15121163e-02f, -4.75527868e-02f,
  1.19828545e-01f, 1.31518543e-01f, -2.85594553e-01f, -2.04119474e-01f, 2.57768095e-01f, -6.30042478e-02f, 1.04090288e-01f, -9.40072313e-02f, -3.00614566e-01f, 1.11784518e-01f,
  7.98069388e-02f, 1.35545254e-01f, 6.59075081e-02f, -4.93231677e-02f, -1.08503938e-01f, 2.23480538e-02f, 2.30352819e-01f, 2.98214912e-01f, 4.47942726e-02f, 2.17726767e-01f,
  7.22922571e-03f, -1.11707531e-01f, -1.23384364e-01f, 1.78890452e-01f, -7.52787814e-02f, 2.30998322e-02f, 2.16881976e-01f, 5.55444621e-02f, -9.72606335e-03f, 7.41837025e-02f,
  -1.95202287e-02f, -1.45768225e-02f, 2.42294431e-01f, 1.37910187e-01f, 1.15959518e-01f, -9.58532542e-02f, 1.14648283e-01f, -1.89086888e-03f, -3.24011385e-03f, 3.60516608e-02f,
  -2.14344606e-01f, 1.79406375e-01f, 7.90001005e-02f, -4.75821681e-02f, -1.38023540e-01f, 3.11808046e-02f, 7.56950751e-02f, 3.31827812e-02f, -1.64994597e-02f, 1.07246503e-01f,
  -1.54051393e-01f, 3.30227353e-02f, -9.88873765e-02f, 1.18813679e-01f, 5.44211864e-02f, -7.89145753e-02f, -2.11156324e-01f, -7.44450465e-02f, 1.13017209e-01f, 1.19996354e-01f,
  1.96636111e-01f, 1.76033869e-01f, 6.21758290e-02f, -1.50471613e-01f, -3.93499285e-02f, 2.34663963e-01f, -2.04074278e-01f, 1.20241847e-02f, 1.93689167e-01f, 1.50019795e-01f,
  -2.95324624e-02f, -1.85292855e-01f, -2.08655283e-01f, -8.03749338e-02f, 6.41966388e-02f, 1.75668359e-01f, -1.76040623e-02f, 3.41763534e-02f
};

// L2_fan_Bp_bar (Shape: 1 x 52)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 52;
const float L2_fan_Bp_bar_data[] = {
  1.35644078e-01f, -4.51296009e-02f, 6.16594367e-02f, 1.74943000e-01f, -2.02765055e-02f, -2.76145115e-02f, 8.24241266e-02f, -4.80026938e-02f, 1.35699630e-01f, -2.49643140e-02f,
  8.34830478e-02f, 4.03986014e-02f, 1.28554866e-01f, 6.61015511e-02f, 4.86058667e-02f, 8.98309723e-02f, 3.06565333e-02f, 1.91431656e-01f, 1.91905156e-01f, 1.39498681e-01f,
  8.00822228e-02f, 2.31934711e-03f, -6.14178814e-02f, -1.11568868e-02f, 3.38991657e-02f, 6.07996024e-02f, 2.01922074e-01f, 2.43544076e-02f, 1.49157733e-01f, -7.15876231e-03f,
  1.03948057e-01f, 1.27706006e-01f, 8.47082734e-02f, 1.73386894e-02f, 8.39442573e-03f, 4.25025597e-02f, -1.64510831e-02f, 1.50721833e-01f, -3.65026221e-02f, -4.42804135e-02f,
  1.31982297e-01f, -6.99942335e-02f, -4.42101732e-02f, 7.34070614e-02f, 2.00922742e-01f, -2.61595640e-02f, 9.86797959e-02f, 2.53121071e-02f, -5.97107336e-02f, 1.94319896e-02f,
  3.18698622e-02f, 8.67639855e-02f
};

// L3_linear_W (Shape: 12 x 64)
const int L3_linear_W_rows = 12;
const int L3_linear_W_cols = 64;
const float L3_linear_W_data[] = {
  -2.25631446e-01f, -9.31696817e-02f, -5.55363968e-02f, -1.71588957e-01f, -5.65899983e-02f, -2.32938290e-01f, 5.59307598e-02f, 2.52852470e-01f, 1.08320810e-01f, -1.52574494e-01f,
  -4.55377661e-02f, -1.82871938e-01f, 6.02280907e-02f, 6.95561022e-02f, -2.23809302e-01f, -2.63034135e-01f, 1.61031052e-01f, 1.31341428e-01f, -1.38337374e-01f, 1.84205398e-01f,
  -1.64448023e-01f, 1.62000403e-01f, -5.45100681e-02f, -7.33102337e-02f, -1.88843727e-01f, 1.54424105e-02f, 1.75546587e-01f, 1.04526142e-02f, -2.10144687e-02f, -2.18071118e-01f,
  3.84238623e-02f, -2.37390280e-01f, -6.24458790e-02f, 1.65930644e-01f, -1.84974708e-02f, 1.30455434e-01f, -4.03598219e-01f, 7.56943598e-02f, -5.18720821e-02f, 1.48680523e-01f,
  8.37224349e-02f, 6.22682087e-02f, 1.87058896e-02f, -1.54120335e-02f, -2.43054599e-01f, -1.96042895e-01f, -2.24774703e-02f, 8.61607864e-02f, 8.49593431e-02f, 1.01986334e-01f,
  1.84259206e-01f, 1.91636771e-01f, 7.37828463e-02f, 1.22810230e-01f, 1.07871607e-01f, 8.31188783e-02f, -3.48060131e-01f, 1.85095131e-01f, -2.62186140e-01f, -6.61738142e-02f,
  -6.79681674e-02f, -2.24729523e-01f, -1.11122474e-01f, -2.48960808e-01f, -2.22644001e-01f, -9.00890380e-02f, 1.24232937e-02f, 2.58201838e-01f, -2.70704948e-03f, -1.31674647e-01f,
  1.74310714e-01f, -3.05737972e-01f, -1.40401172e-02f, -2.13538602e-01f, 8.07542801e-02f, 1.48661554e-01f, -3.76012325e-01f, 1.95816949e-01f, -1.79634709e-02f, 1.48708552e-01f,
  2.14102268e-01f, -2.49792933e-01f, -8.01390707e-02f, -6.73633516e-02f, 1.33113667e-01f, 5.82419261e-02f, -1.64059196e-02f, 2.27658495e-01f, -2.94116855e-01f, -1.53625071e-01f,
  2.50458509e-01f, -5.37043452e-01f, -1.51944429e-01f, -2.20587566e-01f, -6.05746582e-02f, -1.42202437e-01f, -1.83273628e-01f, -1.57943040e-01f, 1.41361123e-02f, 2.82846719e-01f,
  1.32534519e-01f, -5.06685562e-02f, 1.37195840e-01f, 1.85917422e-01f, -1.85234740e-01f, 7.05333352e-02f, -2.32361749e-01f, 1.94299936e-01f, -3.59849781e-01f, 1.32667333e-01f,
  -3.55357200e-01f, -1.15221843e-01f, 1.88495338e-01f, -2.19860792e-01f, -2.19501659e-01f, 1.52873546e-01f, 1.73357502e-01f, 4.50735055e-02f, 1.40379310e-01f, 6.02063071e-03f,
  -3.93868655e-01f, 1.12363130e-01f, -9.33707226e-04f, 3.31181027e-02f, -2.39400732e-04f, -5.72748184e-02f, -1.17205247e-01f, -2.00512439e-01f, -2.07283422e-02f, 1.05537653e-01f,
  8.53401702e-03f, 5.79757467e-02f, 4.26205248e-02f, 1.17984384e-01f, -6.47075325e-02f, -3.99243593e-01f, -6.85948282e-02f, -2.58999318e-01f, 1.05527818e-01f, 3.67705852e-01f,
  -1.19677752e-01f, -2.64847755e-01f, -3.13560784e-01f, 2.46979436e-03f, 1.56536326e-01f, -2.18203962e-02f, -2.55546793e-02f, -6.24861196e-02f, 2.42407814e-01f, -5.25767021e-02f,
  -2.96463907e-01f, -2.53025140e-03f, 5.62117584e-02f, -3.48077089e-01f, 3.80543224e-03f, -4.19422016e-02f, 2.31140062e-01f, -2.16863424e-01f, 2.30539426e-01f, 5.70771098e-02f,
  -1.30995065e-01f, 2.97030717e-01f, -2.00726628e-01f, 3.41974080e-01f, -3.14021200e-01f, 1.34875655e-01f, -3.23826335e-02f, -7.21984133e-02f, 2.91552722e-01f, -2.48730868e-01f,
  1.44088820e-01f, 9.88553464e-02f, -2.14937642e-01f, -2.32712269e-01f, 1.29716247e-02f, -2.53674716e-01f, -5.79038337e-02f, 1.64207622e-01f, -2.24301517e-01f, -4.01094913e-01f,
  1.33202165e-01f, -2.58324623e-01f, 1.39052317e-01f, -2.75666326e-01f, 2.07215667e-01f, -2.53425717e-01f, -1.69448763e-01f, -3.29581350e-01f, 6.55505508e-02f, 1.69292688e-02f,
  -2.31232747e-01f, -2.00064987e-01f, 9.91781130e-02f, -9.68444347e-02f, 5.71490750e-02f, 1.57069892e-01f, 3.62825692e-02f, 3.73534439e-03f, -6.16333671e-02f, 7.97508508e-02f,
  -1.49364218e-01f, -1.42160058e-01f, -2.75756359e-01f, 2.27301493e-02f, 1.90302078e-02f, -3.64582390e-02f, -2.42837090e-02f, -1.85731009e-01f, -2.90955871e-01f, 2.17215821e-01f,
  -1.47655487e-01f, 2.49500081e-01f, -1.49272189e-01f, 1.35139480e-01f, 3.12280115e-02f, -2.26258904e-01f, 1.28728822e-01f, -5.72180450e-02f, -4.60676365e-02f, 2.51071632e-01f,
  -3.48321758e-02f, 8.70429054e-02f, 4.13305275e-02f, -3.85457128e-01f, -6.33473247e-02f, -9.86364670e-03f, -1.90013424e-02f, -8.76566570e-04f, -3.42859596e-01f, -1.33235872e-01f,
  -3.16533417e-01f, -1.53872713e-01f, 7.80176967e-02f, -2.92304397e-01f, 1.13703035e-01f, -4.63789925e-02f, -6.51488826e-02f, -2.40435883e-01f, -9.10531431e-02f, 3.03592999e-02f,
  -9.16682854e-02f, 1.70378610e-01f, -5.56625165e-02f, -4.80620004e-02f, -4.26467836e-01f, 6.40194118e-02f, -2.36282066e-01f, 6.60368381e-03f, -1.09778985e-01f, -1.44815534e-01f,
  -1.07949220e-01f, -1.09955996e-01f, 2.65040219e-01f, 4.65931594e-02f, -1.31393120e-01f, 2.06740081e-01f, 1.63300782e-01f, -1.75095707e-01f, -1.58896118e-01f, -2.60760635e-01f,
  -4.17416245e-02f, 8.65249112e-02f, -1.23306431e-01f, 3.53584498e-01f, 5.06203398e-02f, 2.07686052e-01f, 2.76534289e-01f, -1.33511290e-01f, 2.16663435e-01f, -1.98247254e-01f,
  -3.25031936e-01f, -7.72768483e-02f, -6.67848438e-02f, 5.79464547e-02f, -1.54161811e-01f, -1.11318111e-01f, -3.08143646e-01f, 2.66749877e-02f, 1.17688589e-01f, 9.67625529e-02f,
  1.52154684e-01f, 1.71821248e-02f, -2.33851641e-01f, 3.60666551e-02f, -2.01538235e-01f, -2.11823569e-03f, 1.40629739e-01f, 2.37618923e-01f, -1.50699690e-01f, -7.98527747e-02f,
  1.31750360e-01f, 5.28085902e-02f, 1.46332189e-01f, -3.39311570e-01f, -2.51048625e-01f, 1.70382842e-01f, 1.98195934e-01f, -5.12192771e-02f, 1.62363723e-01f, -5.03800809e-02f,
  -9.59232077e-02f, -6.60231635e-02f, 2.37481326e-01f, -8.88027921e-02f, -2.38334715e-01f, 1.04436398e-01f, 2.56130815e-01f, -9.62955952e-02f, -6.14477620e-02f, -6.16965927e-02f,
  -1.06459133e-01f, 2.37660892e-02f, -2.08607931e-02f, -4.64090221e-02f, 1.04325540e-01f, -5.55985160e-02f, -3.48647833e-01f, -1.43674642e-01f, 2.07586244e-01f, 4.84548137e-02f,
  2.44261175e-01f, 1.23443812e-01f, -1.64828971e-01f, -1.65458061e-02f, 7.17501864e-02f, 1.03497267e-01f, 3.73915993e-02f, 1.88087925e-01f, -1.27766490e-01f, 7.62837678e-02f,
  2.57539779e-01f, 3.39688033e-01f, -7.52061158e-02f, -2.28577793e-01f, -2.69783977e-02f, -6.37461543e-02f, 7.84333572e-02f, -2.61265606e-01f, -2.34658509e-01f, -1.96473077e-01f,
  -1.38710141e-01f, 2.88833082e-02f, -8.77965242e-03f, -3.23065609e-01f, -1.19975835e-01f, 1.60340205e-01f, -7.39787668e-02f, -1.25375494e-01f, -1.54432148e-01f, -2.00544447e-01f,
  -1.60284325e-01f, 3.99293983e-03f, -2.24919543e-01f, -1.87706441e-01f, -2.80931666e-02f, -3.08721751e-01f, -7.74904937e-02f, -1.89227700e-01f, 2.78639495e-01f, 1.67506650e-01f,
  6.85401037e-02f, 1.76528931e-01f, -1.06478959e-01f, -1.30003721e-01f, 1.80590272e-01f, 4.69752867e-03f, 2.27623045e-01f, -2.21479133e-01f, 2.39583939e-01f, -1.59565434e-01f,
  -1.54074714e-01f, -2.11313501e-01f, 6.43243864e-02f, 1.50203586e-01f, -6.89581782e-02f, -2.76236713e-01f, 1.09798558e-01f, -2.03075245e-01f, -1.14508875e-01f, -2.96589988e-03f,
  -2.96019409e-02f, 1.82084799e-01f, 2.42834851e-01f, 4.20568399e-02f, 1.32535875e-01f, -4.46143299e-02f, -3.24165598e-02f, -1.74974147e-02f, -8.75872974e-09f, 3.91447656e-02f,
  -3.53053719e-01f, -1.77363232e-01f, 2.75426239e-01f, 6.16150051e-02f, 8.03865269e-02f, 7.39420578e-02f, -4.75606531e-01f, -2.69063920e-01f, 2.70223171e-01f, -2.09813312e-01f,
  9.66580957e-02f, -9.12034512e-02f, 2.12575421e-01f, -1.16753586e-01f, 1.94357231e-01f, -4.66873646e-02f, -4.23646927e-01f, 7.91541263e-02f, -3.58274882e-03f, -8.52255151e-03f,
  -1.96602613e-01f, -3.02461058e-01f, 3.44416291e-01f, -2.59835303e-01f, -5.22762299e-01f, 3.36926468e-02f, 1.64906427e-01f, -1.84393585e-01f, -2.01705575e-01f, -2.43895799e-01f,
  1.27558157e-01f, 2.62698054e-01f, 2.55400091e-01f, -1.44875631e-01f, -1.00846946e-01f, -1.27794877e-01f, -2.56886661e-01f, 4.39886563e-03f, 4.86148074e-02f, -1.81665897e-01f,
  -2.30387345e-01f, 2.52035290e-01f, -7.63674080e-02f, -3.64234418e-01f, -2.29877636e-01f, 1.48624495e-01f, -9.86305326e-02f, -1.68666303e-01f, -1.54296324e-01f, 3.83631617e-01f,
  1.64275289e-01f, -1.33158833e-01f, 4.15265895e-02f, -1.27860695e-01f, -2.36708343e-01f, -2.49650985e-01f, -2.75921434e-01f, -3.78634274e-01f, -4.03373353e-02f, 1.84971951e-02f,
  4.98104431e-02f, 7.46104261e-03f, 2.99624521e-02f, -1.02590412e-01f, -2.41199642e-01f, -3.42105955e-01f, 2.50985563e-01f, -7.87357315e-02f, 7.61689246e-02f, 4.98951646e-03f,
  -9.97517928e-02f, 1.35639131e-01f, -6.67148307e-02f, 8.34361613e-02f, -4.99673598e-02f, -1.96935292e-02f, 2.38618776e-01f, 5.93982935e-02f, -2.12569177e-01f, -1.82723001e-01f,
  -1.18595973e-01f, -7.97208399e-02f, 2.11724684e-01f, -2.65077204e-01f, -2.45357752e-02f, 2.73503121e-02f, -2.25488245e-01f, 2.60875404e-01f, -1.20283730e-01f, 9.60857123e-02f,
  -8.11928138e-02f, 2.70660162e-01f, 3.30664329e-02f, -6.43135533e-02f, 1.89133242e-01f, -2.04552144e-01f, -4.01139766e-01f, -3.72061208e-02f, 1.43928044e-02f, -1.24308921e-01f,
  -3.01572263e-01f, 8.61305464e-03f, 1.29891932e-01f, -2.87385046e-01f, -1.98604152e-01f, 1.33187756e-01f, -1.61751747e-01f, -8.63210112e-02f, -3.95866297e-03f, -1.11868821e-01f,
  -2.86653280e-01f, -3.63079786e-01f, 1.02188267e-01f, -6.80674240e-02f, 4.53211404e-02f, 1.77057773e-01f, -2.50487626e-01f, 2.14736223e-01f, 1.88495487e-01f, -2.00548973e-02f,
  -1.71404764e-01f, -1.27234921e-01f, -1.85566977e-01f, -1.25231892e-01f, 5.87825384e-03f, -7.86020830e-02f, -8.74499138e-03f, 2.29531273e-01f, 1.23393223e-01f, -2.79162914e-01f,
  2.32937515e-01f, 2.84855425e-01f, -1.63769707e-01f, -2.95673519e-01f, -1.89355910e-01f, -2.04927400e-02f, -9.14165452e-02f, 1.81540176e-01f, -2.29734942e-01f, -7.63936043e-02f,
  8.75192806e-02f, -4.04624380e-02f, -1.10221490e-01f, -3.26928616e-01f, 1.28598362e-01f, -1.01567574e-01f, -2.45061725e-01f, -3.56301218e-01f, 2.24870183e-02f, -1.74108282e-01f,
  -2.07297310e-01f, -1.64509445e-01f, -1.20042749e-01f, -3.72249149e-02f, -1.98829412e-01f, -1.80180848e-01f, 3.74823762e-03f, -1.42577335e-01f, -1.78404078e-01f, -2.35795349e-01f,
  1.23462696e-02f, -1.41063839e-01f, -2.72755441e-03f, 1.83055222e-01f, -1.07584581e-01f, 2.36575425e-01f, 3.32183778e-01f, -7.18871132e-02f, -4.43240613e-01f, -8.74218568e-02f,
  1.57678202e-01f, -1.83577865e-01f, -1.39628332e-02f, -2.61280358e-01f, -1.79573327e-01f, -3.83395284e-01f, -3.11599940e-01f, 4.55637008e-01f, 5.98127916e-02f, -1.36677787e-01f,
  2.53531545e-01f, 6.22989349e-02f, -6.04048371e-02f, 2.28866443e-01f, 1.47731215e-01f, 2.26906464e-01f, 1.66225564e-02f, 1.57583684e-01f, 1.24665894e-01f, 5.80401570e-02f,
  2.51851939e-02f, 1.97600082e-01f, -1.15787067e-01f, 1.13698199e-01f, 1.48238391e-01f, -1.07401749e-02f, 4.52945195e-02f, -2.05950513e-01f, 2.02958897e-01f, -1.91982418e-01f,
  1.89616248e-01f, -6.99052913e-03f, -8.97148848e-02f, -1.65919527e-01f, 1.98501423e-01f, -4.45656836e-01f, 1.09409243e-01f, -4.68625456e-01f, -1.26012504e-01f, 2.29537711e-01f,
  7.21067339e-02f, -1.93475023e-01f, -1.45406500e-01f, -3.56121242e-01f, -2.14805529e-01f, 1.43166170e-01f, 5.48925586e-02f, 2.84540802e-01f, 2.22022325e-01f, -3.33880372e-02f,
  -2.66547829e-01f, -1.88959032e-01f, 4.56419140e-02f, 1.24857448e-01f, -1.36000931e-01f, -3.30601811e-01f, 1.59740046e-01f, -9.40609723e-02f, -1.87711552e-01f, -2.83471078e-01f,
  -2.70221442e-01f, -4.91602421e-02f, 7.43318722e-03f, 5.80116883e-02f, -2.76289254e-01f, 4.69555855e-02f, 2.53068596e-01f, -5.83202317e-02f, 2.85384476e-01f, -2.20328003e-01f,
  1.18259765e-01f, -1.00418270e-01f, 1.53809503e-01f, -2.56379973e-02f, -4.29546446e-01f, -4.47991490e-02f, 1.34714013e-02f, -1.93850294e-01f, -3.27867046e-02f, -6.47175759e-02f,
  -1.98754054e-02f, 9.70522612e-02f, 3.06355655e-02f, -1.15123749e-01f, 3.85503545e-02f, -7.14071617e-02f, -2.37023056e-01f, 2.14900449e-02f, -7.31843412e-02f, -2.31107417e-02f,
  1.74402431e-01f, -4.20818590e-02f, -1.59162700e-01f, 2.86092013e-01f, -8.28572270e-03f, -1.18685231e-01f, -3.27380210e-01f, -3.90671074e-01f, -1.33920491e-01f, -3.54074210e-01f,
  -1.37759253e-01f, 3.24825011e-02f, 1.47118373e-02f, 2.69710451e-01f, -1.42860204e-01f, 1.83175296e-01f, -2.02476814e-01f, 1.96882725e-01f, -5.99167310e-02f, 3.20804358e-01f,
  -2.59306669e-01f, -3.16936165e-01f, -3.63064520e-02f, 6.78711608e-02f, 2.42030293e-01f, 5.89280622e-03f, -2.73811281e-01f, -2.93366965e-02f, -2.17339367e-01f, -4.08457339e-01f,
  -3.06797951e-01f, 6.24495149e-02f, -1.56911790e-01f, -2.74048597e-01f, 2.31603369e-01f, 2.95351744e-01f, 7.63590485e-02f, 4.05341573e-03f, -1.12517893e-01f, 2.76504699e-02f,
  -7.24415258e-02f, -2.34719552e-02f, -1.46019191e-01f, 1.89928394e-02f, -2.02854887e-01f, -1.43630922e-01f, 1.44802302e-01f, -2.08900962e-02f, -7.69302323e-02f, -2.50027120e-01f,
  4.06767316e-02f, 1.82129517e-01f, -1.54381663e-01f, -7.56614935e-03f, 6.30520508e-02f, 1.28200963e-01f, 1.09452851e-01f, 9.81112644e-02f, -1.18612108e-04f, 2.16593500e-02f,
  3.32941294e-01f, 4.27455336e-01f, -3.42713654e-01f, -9.12115946e-02f, -2.77833402e-01f, 4.94965091e-02f, -7.47845974e-03f, -1.45939261e-01f, 2.00018048e-01f, 1.83825679e-02f,
  -4.62886989e-02f, 1.50718719e-01f, -6.58914149e-02f, -1.58989310e-01f, 2.25471035e-02f, -1.32479131e-01f, 3.67082208e-01f, -2.22161591e-01f, -1.89084291e-01f, -2.06908017e-01f,
  3.01062688e-02f, 2.93689072e-01f, 1.64905220e-01f, -2.08574131e-01f, -9.82726272e-03f, 1.26131261e-02f, 5.89278340e-02f, -1.40126616e-01f, -2.60828584e-01f, -1.16254278e-01f,
  -8.44399706e-02f, 2.38762036e-01f, 1.07360892e-01f, -6.63962662e-02f, -2.49286443e-01f, 4.48920354e-02f, -1.17246404e-01f, 1.54652581e-01f, 6.02235496e-02f, -1.47970349e-01f,
  1.64977804e-01f, 1.49324298e-01f, -2.76232928e-01f, -1.00360617e-01f, 1.15295894e-01f, 2.72426188e-01f, -2.47880772e-01f, -1.92772731e-01f, -3.11045974e-01f, -6.73553571e-02f,
  -3.77849162e-01f, 2.02343374e-01f, 1.37547478e-01f, 1.12220105e-02f, -1.21608458e-01f, -5.15535176e-02f, 1.96593240e-01f, -3.67454812e-02f
};

// L3_linear_B (Shape: 1 x 12)
const int L3_linear_B_rows = 1;
const int L3_linear_B_cols = 12;
const float L3_linear_B_data[] = {
  -6.10192083e-02f, 6.38604835e-02f, 1.64315879e-01f, -1.70608852e-02f, 7.80229922e-03f, 1.11413136e-01f, 6.40868349e-03f, -1.04659110e-01f, -3.19502875e-02f, 5.50725274e-02f,
  -8.39043260e-02f, -9.70931500e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 6, 52
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        64, 6, 52
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        64, 6, 52
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_linear
    linear_forward_pgm(
        buffer1, x_out,
        L3_linear_W_data, L3_linear_B_data,
        64, 12
    );
    }
    