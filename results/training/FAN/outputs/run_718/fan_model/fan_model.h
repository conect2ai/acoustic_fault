/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 64 (x4)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 64;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    return (x > 0.0f) ? x : 0.0f;
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 25 x 120)
const int L0_fan_Wp_rows = 25;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  2.04887226e-01f, 1.31658502e-02f, 4.53732222e-01f, 3.48470330e-01f, 2.21249834e-01f, 2.41349284e-02f, 1.25603423e-01f, 3.14025879e-02f, -1.20021440e-01f, 7.07425997e-02f,
  3.80636416e-02f, -7.04324469e-02f, 3.48323733e-02f, -3.36468890e-02f, 8.00992101e-02f, 4.40379865e-02f, 2.66907543e-01f, 2.88715482e-01f, 2.11370096e-01f, 5.96835744e-03f,
  -1.56106338e-01f, -3.10012978e-02f, 7.24851340e-02f, -4.67303693e-02f, -8.60757977e-02f, -3.45369428e-02f, 9.05467942e-02f, 5.02846055e-02f, -9.44968313e-02f, 1.64924458e-01f,
  7.12420642e-02f, 1.69214517e-01f, 1.42838895e-01f, 9.34260115e-02f, 1.16749160e-01f, -2.18516053e-03f, 1.23614013e-01f, 1.30761757e-01f, 8.39198157e-02f, 1.44249544e-01f,
  1.16823964e-01f, 6.28589839e-02f, 1.73129573e-01f, 1.56687256e-02f, 1.83016613e-01f, 1.01194397e-01f, -3.36020626e-02f, 1.29401937e-01f, 1.17816076e-01f, -1.53790042e-02f,
  2.78825369e-02f, 6.21980615e-02f, 7.71305636e-02f, -2.02971138e-02f, 6.01028316e-02f, -3.67687978e-02f, 9.55509674e-03f, 8.82499516e-02f, 2.16479842e-02f, 2.30263658e-02f,
  3.86788733e-02f, 1.12608753e-01f, -1.31084576e-01f, 5.52717736e-03f, -2.20681861e-04f, -2.90719829e-02f, 1.71804234e-01f, 6.38058335e-02f, -7.97813460e-02f, 1.00657791e-02f,
  5.76941017e-03f, 5.73565885e-02f, 5.16309999e-02f, 9.88363922e-02f, 8.47945064e-02f, 2.41555050e-02f, 2.20840238e-02f, 4.65623848e-02f, -1.22809727e-02f, -8.58217925e-02f,
  4.13687751e-02f, -1.14641197e-01f, -8.32768083e-02f, -6.09568954e-02f, 1.38570582e-02f, 1.45327792e-01f, -5.22620417e-02f, -2.30448991e-02f, 3.58592428e-04f, -1.65567338e-03f,
  -1.69881612e-01f, -7.05092773e-02f, -1.34581387e-01f, 7.56591409e-02f, -3.56395654e-02f, -1.09134894e-02f, 3.17195281e-02f, 1.07976891e-01f, 6.29919022e-02f, -6.69549778e-02f,
  5.78304678e-02f, 1.47098944e-01f, 3.30146682e-03f, -6.00456931e-02f, 2.54929066e-02f, -1.04878999e-01f, 3.22615951e-02f, 7.31355250e-02f, 1.32583342e-02f, -6.31809654e-03f,
  6.00076616e-02f, 1.06890108e-02f, -1.18916677e-02f, -1.41985759e-01f, -1.23771794e-01f, 3.37862782e-02f, -1.49792895e-01f, -2.03608155e-01f, -1.17926754e-01f, -1.65369093e-01f,
  -1.09564573e-01f, -1.74796700e-01f, 7.60472417e-02f, -2.50716329e-01f, -3.19042742e-01f, -1.09633975e-01f, -4.79008704e-02f, 1.71068069e-02f, -5.25196195e-02f, -1.97614416e-01f,
  -7.91509449e-02f, -1.51870981e-01f, 4.88363728e-02f, -1.13835826e-03f, 1.23178862e-01f, 4.41354252e-02f, 1.88277364e-02f, 2.12424561e-01f, 2.64746904e-01f, 1.13883607e-01f,
  1.62006891e-03f, 9.51195136e-03f, 1.31948292e-01f, 1.48416430e-01f, -3.28125268e-01f, -8.97308737e-02f, -2.44033068e-01f, -1.91243395e-01f, -1.25074327e-01f, -4.72560406e-01f,
  -9.51123685e-02f, -2.29960531e-01f, 3.97943147e-02f, -6.61717122e-03f, -7.33643547e-02f, 1.49009660e-01f, 1.26586691e-01f, -2.06208229e-02f, 1.23500330e-02f, -5.94983622e-02f,
  -1.20480463e-01f, 4.96156961e-02f, -1.34380702e-02f, -5.53959422e-02f, 1.27303861e-02f, -6.85811862e-02f, -6.51967824e-02f, 3.17216245e-03f, 5.15019149e-02f, 3.02087460e-02f,
  1.68246236e-02f, -1.01377115e-01f, -5.61206751e-02f, 3.98853645e-02f, 1.18426777e-01f, -1.25398681e-01f, -4.46959473e-02f, -8.50038975e-02f, -7.24776164e-02f, -1.37858897e-01f,
  4.38858606e-02f, -1.06535397e-01f, -6.40074257e-03f, 3.80083993e-02f, -1.28062153e-02f, 1.18204402e-02f, 1.26303604e-03f, -6.10335246e-02f, 4.58286926e-02f, -7.47090876e-02f,
  2.58912370e-02f, -9.44362059e-02f, -5.26265763e-02f, -3.61700319e-02f, -7.39576891e-02f, -8.58359411e-02f, -3.98972072e-02f, -9.30430591e-02f, 1.11324526e-02f, 3.54036950e-02f,
  1.39980623e-02f, -8.05074051e-02f, 2.50095967e-02f, -4.23064642e-03f, -3.29826996e-02f, -3.96314412e-02f, -3.85116413e-02f, -9.88493674e-03f, -5.83110601e-02f, -1.34026870e-01f,
  8.95939618e-02f, 3.48561332e-02f, -1.00888491e-01f, -7.01937228e-02f, 4.20052111e-02f, -5.97426146e-02f, -8.11541677e-02f, 1.14256993e-01f, -6.62177131e-02f, -4.79348972e-02f,
  -1.33870207e-02f, 6.32154867e-02f, -9.55357477e-02f, 2.16521134e-04f, 5.90576828e-02f, -4.20795530e-02f, -2.31816694e-02f, 1.79837253e-02f, 3.94760370e-02f, 7.15346709e-02f,
  9.31432098e-02f, 1.25260770e-01f, 1.49303243e-01f, 1.15131531e-02f, -2.81229895e-02f, -5.11921644e-02f, -4.26993519e-02f, -3.58414650e-02f, 1.05240203e-01f, -8.43099654e-02f,
  -3.85814339e-01f, -5.17631136e-03f, -5.13396710e-02f, -2.24670365e-01f, -1.10749833e-01f, 4.58883457e-02f, -7.26919398e-02f, -7.65815675e-02f, 7.42486864e-02f, 1.49415463e-01f,
  1.68633237e-01f, 1.48244590e-01f, 2.01944619e-01f, 1.29229799e-01f, -2.74260342e-02f, 4.17844914e-02f, -1.45968765e-01f, -4.50749509e-02f, -1.04027785e-01f, -2.25360207e-02f,
  4.81391065e-02f, -1.96318045e-01f, -3.46923918e-01f, 6.65943464e-03f, 5.73898330e-02f, 2.36895755e-01f, 3.55954915e-02f, -1.12022080e-01f, 1.44527495e-01f, 2.35708982e-01f,
  4.34521675e-01f, -1.66817069e-01f, 1.24762386e-01f, -1.01984560e-01f, 9.63554755e-02f, 6.61077276e-02f, 9.60746408e-02f, -5.29252626e-02f, 9.58277211e-02f, -4.00055088e-02f,
  -4.76168916e-02f, 1.98774025e-01f, -5.30909561e-02f, 8.35278556e-02f, -6.15031458e-02f, 2.07452588e-02f, -4.90828231e-02f, 4.33536060e-02f, 1.02407843e-01f, 8.69534239e-02f,
  6.30698726e-02f, -9.31643620e-02f, -5.96779436e-02f, 9.15041640e-02f, -4.81248759e-02f, 4.15946357e-02f, 1.17706560e-01f, 1.34452190e-02f, 8.91409442e-02f, -3.69584281e-03f,
  3.18401232e-02f, 5.81437834e-02f, 1.10823520e-01f, -4.10008430e-02f, 2.78497022e-02f, 3.65735888e-02f, 1.02013797e-02f, -2.41964180e-02f, 7.75518045e-02f, 1.92383137e-02f,
  2.74535250e-02f, 1.72032639e-01f, 3.47168408e-02f, 6.96469247e-02f, 9.14192498e-02f, -5.87450676e-02f, 1.59638952e-02f, 1.49071187e-01f, 1.23924427e-02f, -4.03922377e-03f,
  1.43221524e-02f, 9.71956551e-02f, 6.02882402e-03f, 8.41466561e-02f, 6.81511732e-03f, 8.10184702e-03f, 1.13178194e-01f, 1.31882569e-02f, -5.22279330e-02f, -6.82672784e-02f,
  1.20342970e-02f, 1.90890220e-03f, 1.45392105e-01f, -1.18777184e-02f, 6.69679698e-03f, 6.17591031e-02f, -4.26796079e-02f, -2.75206603e-02f, -2.99084149e-02f, -2.79229563e-02f,
  -3.50802615e-02f, 6.13499507e-02f, 1.08592845e-02f, -2.44999994e-02f, -8.66175164e-03f, -5.19334339e-03f, -5.00760563e-02f, 2.92335581e-02f, 5.17519703e-03f, -8.33240002e-02f,
  -1.01695493e-01f, -6.35701325e-03f, -1.16171367e-01f, -1.08320095e-01f, 2.66614258e-02f, -1.15366332e-01f, -7.39372801e-03f, 3.27266678e-02f, -1.67683437e-02f, 6.34622946e-02f,
  3.71282399e-01f, -4.64064442e-02f, -4.31581168e-03f, -2.31858213e-02f, -2.14256793e-01f, -2.42391065e-01f, -1.26537368e-01f, -1.68705836e-01f, -2.16831237e-01f, -6.95713088e-02f,
  -1.63768411e-01f, -3.93528230e-02f, -4.95326472e-03f, 2.92885844e-02f, 1.82956278e-01f, 1.71099573e-01f, 1.51560172e-01f, 2.19079599e-01f, 2.93639570e-01f, -1.12615399e-01f,
  -6.43170029e-02f, 1.07797675e-01f, 8.07900578e-02f, 4.59363684e-02f, -3.57554518e-02f, 1.47787824e-01f, 5.20382710e-02f, -3.94053459e-02f, -1.87198296e-01f, 6.34806603e-02f,
  4.85829413e-02f, -1.00280538e-01f, 8.96815211e-02f, -5.22924420e-05f, -4.79094274e-02f, 2.84346435e-02f, 5.01909256e-02f, 3.26629914e-02f, 9.78959631e-03f, 1.29002452e-01f,
  6.28136040e-04f, -2.70000678e-02f, 7.56004825e-02f, -4.05729339e-02f, 1.46652281e-04f, 3.18856575e-02f, -1.67638548e-02f, 1.62085355e-03f, 9.01902169e-02f, -1.16162218e-01f,
  -6.52056783e-02f, -2.11451635e-01f, -5.92041425e-02f, -2.09358111e-02f, 1.97765883e-02f, 4.52210978e-02f, -6.47812486e-02f, -1.14473276e-01f, 6.38484880e-02f, 3.68473865e-03f,
  -1.04005940e-01f, 1.05550565e-01f, 6.78671524e-03f, 1.89952105e-02f, 2.01517399e-02f, 6.41871393e-02f, 7.97177926e-02f, 5.56793697e-02f, 1.03924230e-01f, 5.36113866e-02f,
  3.76434531e-03f, 7.40349591e-02f, 7.78406486e-02f, 1.00288644e-01f, 5.45498766e-02f, -2.32229810e-02f, -3.29498239e-02f, 7.78464898e-02f, -7.08606793e-03f, -3.82109173e-02f,
  6.63608909e-02f, -4.71308604e-02f, -3.28916945e-02f, 7.14339241e-02f, -8.01877826e-02f, -8.70535709e-03f, -3.43712382e-02f, 1.22088464e-02f, 1.01594530e-01f, 8.68636370e-02f,
  3.64205331e-01f, -2.35052072e-02f, 1.90665692e-01f, 1.76225901e-02f, 6.43667281e-02f, -5.26688397e-02f, -9.13155973e-02f, -8.30615312e-02f, -3.30990478e-02f, 3.81679460e-02f,
  -9.76712815e-03f, 8.85372087e-02f, 9.78699178e-02f, 5.69876656e-02f, -4.70148213e-03f, 1.15289502e-01f, -1.16384260e-01f, 1.64317656e-02f, 7.97085017e-02f, -1.00239307e-01f,
  1.04062818e-01f, 8.07082057e-02f, 8.51202458e-02f, 2.52576377e-02f, 1.03869159e-02f, 6.57498389e-02f, 3.96535806e-02f, -3.35313752e-02f, 1.65632576e-01f, 1.98058829e-01f,
  2.18458906e-01f, -4.11090374e-01f, -1.42934630e-02f, 1.64387524e-01f, -1.93316936e-01f, -1.51455387e-01f, -5.11899412e-01f, -1.13574587e-01f, 1.26839774e-02f, -2.93133676e-01f,
  -6.60655424e-02f, 7.65399709e-02f, 1.00522511e-01f, 7.47477710e-02f, 9.84830558e-02f, -2.75331408e-01f, -1.63617179e-01f, 2.08360940e-01f, 2.51799107e-01f, 6.19053729e-02f,
  -1.25147626e-01f, 6.96259737e-02f, 1.91471681e-01f, 1.31410621e-02f, -1.74916267e-01f, 4.40955115e-03f, -1.20341271e-01f, -1.03507787e-01f, -2.57160842e-01f, -2.59024203e-01f,
  -7.95105249e-02f, -1.30221128e-01f, 1.01827621e-01f, -7.93529227e-02f, 1.53334839e-02f, -1.81799270e-02f, -5.54124862e-02f, 1.80484280e-02f, -1.01730622e-01f, 7.74449408e-02f,
  -5.42947017e-02f, -4.55715228e-03f, -3.29475128e-03f, -3.03275883e-03f, -1.54143618e-02f, -9.07611549e-02f, 1.36699490e-02f, 2.50505023e-02f, -1.63040590e-02f, -2.30617583e-01f,
  -9.99549404e-02f, -8.87361839e-02f, -1.20608089e-02f, -4.38163802e-02f, -4.33215238e-02f, -1.01195678e-01f, -1.30698413e-01f, -6.80124313e-02f, -2.40030438e-02f, -2.76398420e-01f,
  -4.90613915e-02f, 1.36083290e-02f, -2.68466235e-03f, 2.53394749e-02f, -4.33573537e-02f, 4.57711052e-03f, 6.17904998e-02f, -1.20295972e-01f, -5.38702197e-02f, -3.22554633e-02f,
  4.42999825e-02f, -5.67951575e-02f, 2.82071345e-02f, -1.30103188e-04f, 1.15448892e-01f, -1.80033650e-02f, -5.19482046e-03f, -4.30731513e-02f, 1.00856557e-01f, 5.04814349e-02f,
  5.57725085e-04f, 6.03830069e-03f, 1.31703792e-02f, -1.18894845e-01f, 5.51890992e-02f, 6.29562363e-02f, -1.67938005e-02f, -6.16053166e-03f, -5.62956780e-02f, 3.93839255e-02f,
  -6.66495338e-02f, 2.16663674e-01f, -6.50986657e-02f, -1.53129715e-02f, 2.61529945e-02f, -1.03098325e-01f, -8.38071480e-02f, -1.62514690e-02f, -6.36300072e-03f, -5.48954606e-02f,
  2.48826444e-02f, -3.89853939e-02f, -1.10044405e-02f, -6.96152076e-02f, -7.96871930e-02f, -3.23150009e-02f, -1.16152100e-01f, 4.54883231e-03f, -9.15828273e-02f, -7.13677704e-02f,
  -6.27625063e-02f, -5.26009388e-02f, 3.15919630e-02f, -9.96155962e-02f, -8.40970203e-02f, 3.08369678e-02f, -1.26300663e-01f, -8.29865038e-02f, -4.28187698e-02f, -3.05138201e-01f,
  -2.92749584e-01f, 2.80226737e-01f, -6.61824420e-02f, -1.28053069e-01f, 1.52336553e-01f, -3.75706330e-02f, 8.33973140e-02f, -1.70108359e-02f, -4.48152870e-02f, -6.15826901e-03f,
  1.62791282e-01f, 7.22433403e-02f, 1.00916037e-02f, 6.33494183e-02f, -1.07545532e-01f, 3.41922976e-02f, 1.29642561e-01f, -1.13754660e-01f, -3.10398459e-01f, -3.01362332e-02f,
  5.69159724e-02f, -1.71292618e-01f, -2.28956744e-01f, -1.13895601e-02f, 1.59268215e-01f, -1.21829547e-01f, 4.23247442e-02f, 1.38335854e-01f, 2.16206670e-01f, 3.05181712e-01f,
  -1.46172643e-01f, 1.68345734e-01f, -3.90834287e-02f, 2.83740629e-02f, 7.20971972e-02f, -1.10752955e-02f, -6.10702746e-02f, 8.35037082e-02f, 1.34178802e-01f, -4.13069464e-02f,
  4.40843776e-02f, 6.66923746e-02f, 3.74655090e-02f, 1.14053763e-01f, -1.15028350e-02f, -3.61959479e-04f, -2.41125375e-03f, 9.98669192e-02f, -2.71343682e-02f, 2.25036368e-02f,
  1.60276175e-01f, 1.08895227e-01f, -9.14004259e-03f, -2.10275017e-02f, -1.63891038e-03f, 2.19059661e-02f, 4.79760021e-02f, 8.79255012e-02f, -1.99496914e-02f, -8.42997804e-02f,
  -7.53489658e-02f, 1.18753798e-02f, 1.00879706e-01f, -6.42604828e-02f, -1.00922011e-01f, -1.07935797e-02f, -3.53209451e-02f, -4.16408479e-02f, -2.10558493e-02f, 8.01687688e-03f,
  -1.46120727e-01f, -1.09050602e-01f, -2.88864691e-02f, -8.17304477e-02f, -8.52161050e-02f, -9.44378152e-02f, -3.34027298e-02f, -1.18947271e-02f, -6.69534579e-02f, -1.34999119e-02f,
  -4.64191325e-02f, 7.73014426e-02f, -4.90958951e-02f, -6.83171861e-03f, 3.14909569e-03f, -1.94127411e-02f, -5.89522123e-02f, 1.50400503e-02f, 7.74727836e-02f, -8.73113573e-02f,
  -2.20398948e-01f, 1.68644652e-01f, -6.75555095e-02f, -1.85691640e-02f, 1.28672838e-01f, 1.61386117e-01f, 7.89892152e-02f, -4.99290340e-02f, 6.76386133e-02f, 4.72666100e-02f,
  5.99506758e-02f, -7.84478113e-02f, 7.63006732e-02f, -6.45397231e-02f, 3.17226090e-02f, 8.18578992e-03f, 5.18726557e-02f, -1.37876466e-01f, 3.48207690e-02f, -2.07110401e-02f,
  -5.11377640e-02f, -1.52982339e-01f, -4.01179679e-02f, -9.74591598e-02f, -1.17459454e-01f, -2.24160820e-01f, -9.20132771e-02f, -1.09043993e-01f, -2.18929216e-01f, -2.68864810e-01f,
  1.79482132e-01f, 9.94985998e-02f, 6.85934871e-02f, 3.04538041e-01f, 7.56543577e-02f, -2.93313842e-02f, 8.31512511e-02f, -1.38993775e-02f, 8.54344517e-02f, 1.68121278e-01f,
  1.72942385e-01f, 5.88263907e-02f, 7.05881193e-02f, 6.26698285e-02f, -4.58600931e-03f, 9.57732052e-02f, -1.72024034e-02f, -4.91828360e-02f, -2.98827887e-02f, 6.24432899e-02f,
  1.68502554e-01f, 1.02777809e-01f, 2.08466396e-01f, 4.97688316e-02f, 1.35058865e-01f, 1.56221271e-01f, 1.30820349e-01f, 8.07190612e-02f, 5.77186346e-02f, 4.20333862e-01f,
  6.77182386e-03f, 1.86141822e-02f, 8.22794810e-02f, 1.02592379e-01f, 1.24266990e-01f, -3.17436755e-02f, 1.47545099e-01f, 4.26189005e-02f, 9.25984606e-02f, -1.15560265e-02f,
  1.56996757e-01f, 5.80459610e-02f, 1.88760757e-01f, 1.21070035e-01f, 1.30936965e-01f, 8.04502890e-02f, -5.62572367e-02f, 4.88632359e-02f, 1.26002356e-01f, 2.13287249e-02f,
  2.39206925e-01f, 2.51845658e-01f, 9.59048048e-02f, 6.04805574e-02f, 1.50267631e-01f, 1.55520558e-01f, 3.50514092e-02f, 2.06956118e-01f, 9.16825086e-02f, 9.95927155e-02f,
  1.27705783e-01f, -7.31016695e-02f, -8.56660381e-02f, 4.55416404e-02f, 4.06751633e-02f, 6.26554852e-03f, 8.94223228e-02f, -5.87326474e-03f, -2.73476243e-02f, 9.45409089e-02f,
  4.37356010e-02f, 9.33097303e-02f, -9.08937305e-03f, 4.14376035e-02f, 5.74167892e-02f, -1.18062988e-01f, -7.18820617e-02f, -4.45148274e-02f, 9.22839716e-02f, -3.64749320e-02f,
  2.08199490e-02f, -4.34465148e-02f, -1.20238803e-01f, -1.44312829e-01f, 5.33514991e-02f, -9.41851065e-02f, -1.81774825e-01f, -1.40637174e-01f, -1.47598371e-01f, -1.97128356e-01f,
  1.43365031e-02f, -6.43026382e-02f, 3.30239870e-02f, 9.43363309e-02f, -5.90029592e-03f, 2.02971231e-03f, 7.44788423e-02f, -5.94793707e-02f, 4.06222157e-02f, -1.18045760e-02f,
  1.40699372e-01f, 8.27225223e-02f, 9.48422104e-02f, -4.65961881e-02f, 1.36018857e-01f, 1.48420066e-01f, -2.04017526e-03f, 1.53668255e-01f, 5.45898937e-02f, 8.16709027e-02f,
  5.34445308e-02f, 1.47723764e-01f, 3.67981791e-02f, 8.80815834e-02f, 1.19623810e-01f, 1.26836495e-02f, -3.21779139e-02f, -3.42302844e-02f, 6.12601750e-02f, -2.39559952e-02f,
  -4.04719621e-01f, 2.14610979e-01f, 8.00125599e-02f, -1.49266914e-01f, 9.03046057e-02f, 6.16802350e-02f, 2.01003090e-01f, -1.11556590e-01f, -2.04230979e-01f, 1.03771329e-01f,
  4.68172841e-02f, -8.18742961e-02f, 2.18058680e-03f, -1.04272209e-01f, -1.14941753e-01f, 2.17751533e-01f, 1.42940804e-01f, -7.67693808e-03f, -3.55806440e-01f, -2.05390021e-01f,
  6.19936474e-02f, 8.57529789e-03f, -2.75404990e-01f, -5.76707534e-02f, 2.43665621e-01f, -1.16069719e-01f, 2.49043852e-01f, 1.03858471e-01f, 2.86760569e-01f, 4.55396354e-01f,
  2.47299567e-01f, 1.97619215e-01f, -1.44467279e-01f, -5.30150831e-02f, -6.02487754e-03f, -8.49197581e-02f, -3.84827666e-02f, 8.92490707e-03f, -8.45907331e-02f, 2.73093116e-02f,
  1.19860709e-01f, -2.63736453e-02f, -7.62313232e-03f, 6.33446351e-02f, 9.52984672e-03f, 1.18945846e-02f, -4.30392800e-03f, -1.07908875e-01f, -2.66054980e-02f, 6.14165552e-02f,
  9.08349082e-02f, 1.08482584e-01f, 2.05048975e-02f, 1.18531413e-01f, 8.55399817e-02f, 8.14963691e-03f, 1.23715691e-01f, 6.37181401e-02f, -1.90146118e-02f, -1.98094528e-02f,
  -2.29686089e-02f, 9.40942094e-02f, 3.14584747e-02f, -7.82523081e-02f, 1.41571714e-02f, 6.19896911e-02f, 7.80427828e-02f, 7.75854439e-02f, -3.11988834e-02f, 5.40863052e-02f,
  -8.29732567e-02f, -9.38969492e-07f, -3.13801244e-02f, -8.04235488e-02f, -1.04741734e-02f, 9.47861373e-03f, 1.55379269e-02f, 4.29191254e-03f, 1.57394614e-02f, -1.72126312e-02f,
  4.02219668e-02f, -2.56152786e-02f, 5.83608001e-02f, -1.42386602e-02f, -4.31686454e-03f, -3.95449847e-02f, 5.15367351e-02f, -2.02520154e-02f, 6.19519036e-03f, 6.52351752e-02f,
  -2.11669967e-01f, 4.35366407e-02f, 3.20765413e-02f, 9.08232182e-02f, 4.81916405e-02f, 8.58876389e-03f, -5.74403862e-03f, -7.20708743e-02f, 2.95301210e-02f, -1.04850478e-01f,
  -3.60807665e-02f, -2.53404994e-02f, 5.92645630e-02f, 1.55726690e-02f, -1.56204417e-01f, 5.76505847e-02f, 1.15198947e-01f, -4.65087853e-02f, -1.89168137e-02f, 4.14241031e-02f,
  -7.94932395e-02f, -7.44673684e-02f, -1.64478213e-01f, -1.03171222e-01f, -1.13193594e-01f, -1.12358853e-01f, -1.12420112e-01f, 1.89175233e-02f, -1.16016597e-01f, -1.80634841e-01f,
  4.81256694e-01f, 2.07250237e-01f, 1.02695413e-01f, -7.00566471e-02f, -6.51003495e-02f, -7.36902580e-02f, 3.18887383e-02f, 9.20271873e-02f, 3.26113962e-02f, 5.50570823e-02f,
  3.53964753e-02f, -2.72470534e-01f, -1.40630364e-01f, -1.92008495e-01f, -1.11966334e-01f, -9.64674726e-02f, -1.69273745e-02f, -1.48059847e-02f, -2.02636182e-01f, -5.08551225e-02f,
  -1.52714685e-01f, 1.58927903e-01f, 1.62522733e-01f, 6.40958175e-02f, 1.04249187e-01f, -2.49157682e-01f, -1.22527368e-01f, -6.62062541e-02f, -1.99285418e-01f, 9.25275609e-02f,
  -3.32056470e-02f, 1.92347959e-01f, -1.07751735e-01f, 6.39317259e-02f, -7.73870349e-02f, 7.55412579e-02f, -2.90222224e-02f, 1.17569409e-01f, 1.42673209e-01f, 1.70231715e-01f,
  -3.19961458e-02f, 5.10318428e-02f, -4.37627584e-02f, -2.97610834e-02f, 6.20595552e-02f, -9.59161017e-03f, 1.83574572e-01f, 1.10541180e-01f, 8.23710263e-02f, 9.03128982e-02f,
  -5.56740463e-02f, 1.11075655e-01f, 3.51406112e-02f, -2.76802424e-02f, 1.54343876e-03f, 3.75961438e-02f, 3.64292897e-02f, 8.97618458e-02f, 1.49365980e-02f, 1.80066451e-01f,
  -2.08735820e-02f, -1.21980133e-02f, 1.76146403e-02f, 8.18602741e-02f, -5.31454757e-02f, 8.67235884e-02f, -2.52082888e-02f, -1.24042302e-01f, -7.30345398e-02f, 1.42971508e-03f,
  -1.69884175e-01f, -3.69350575e-02f, -5.53176403e-02f, -2.24743858e-02f, -6.09687455e-02f, 7.02528432e-02f, -1.70812812e-02f, -6.79769292e-02f, 1.25257969e-01f, -1.98259912e-02f,
  1.95575431e-02f, 8.87219906e-02f, 7.62909353e-02f, 2.08006259e-02f, -7.22505036e-04f, -8.42380077e-02f, 2.61161998e-02f, 3.63442153e-02f, 1.13361757e-02f, -5.23244962e-02f,
  -2.35764340e-01f, -2.47404724e-01f, 4.29121740e-02f, -2.70959586e-02f, -1.03753097e-01f, -4.54579666e-02f, 2.95141316e-03f, -5.65031506e-02f, -4.62129414e-02f, 3.99197340e-02f,
  -2.55126413e-02f, 7.47234672e-02f, 3.87739688e-02f, -2.36304197e-02f, 6.88933358e-02f, -2.72192489e-02f, 8.83431435e-02f, 4.58131358e-02f, 2.63561737e-02f, 7.92610198e-02f,
  -4.93767858e-03f, -6.21611141e-02f, -5.97435161e-02f, -1.65777002e-02f, 4.91712149e-03f, -1.49135083e-01f, -9.47889090e-02f, -8.67560431e-02f, -3.73178050e-02f, -6.92271814e-02f,
  2.43180264e-02f, -1.87106282e-01f, -1.20465457e-01f, 1.17565505e-01f, -1.81232065e-01f, -1.64143130e-01f, -1.84386745e-01f, -1.76017862e-02f, 4.40154262e-02f, -1.64969638e-01f,
  -1.16301604e-01f, 1.06408797e-01f, 2.33345535e-02f, -2.41760556e-02f, 2.14779619e-02f, 5.62111102e-03f, 6.57782704e-02f, 1.42339587e-01f, -8.79160166e-02f, 9.47707593e-02f,
  3.40486355e-02f, 4.65082079e-02f, -5.15056476e-02f, 4.81145382e-02f, 7.09422678e-02f, -2.04485450e-02f, -5.13847470e-02f, 4.24229354e-02f, -1.69405211e-02f, 3.61973643e-01f,
  3.92419770e-02f, -4.99133058e-02f, -1.15085088e-01f, -2.19356850e-01f, -2.19760358e-01f, -2.21687648e-02f, -1.14784315e-01f, -1.41608655e-01f, -1.59524173e-01f, -4.99979109e-02f,
  -2.58758981e-02f, -4.25817035e-02f, 8.94743875e-02f, -1.00959809e-02f, -1.92750812e-01f, -7.94923082e-02f, 2.19075382e-02f, 2.60150284e-02f, -3.92168947e-02f, -1.47702247e-01f,
  -5.63800409e-02f, -1.01695649e-01f, -1.18089855e-01f, -2.57441178e-02f, 2.73537152e-02f, -4.66133766e-02f, -6.30413666e-02f, -4.15566005e-02f, -1.67271018e-01f, -4.47961502e-02f,
  -5.88540882e-02f, -6.03158260e-04f, 7.67891854e-02f, 6.45662323e-02f, 9.84724239e-02f, 6.82893023e-02f, 5.26368432e-02f, 7.36817624e-03f, 4.38850746e-02f, 9.89888236e-02f,
  -7.73700178e-02f, -1.22413129e-01f, -1.56256363e-01f, 5.72906509e-02f, 4.16181907e-02f, -1.11245386e-01f, -4.24656197e-02f, -7.49751031e-02f, -8.60429406e-02f, -7.73316920e-02f,
  1.22716270e-01f, -1.74273495e-02f, -5.09127118e-02f, -3.26276571e-02f, 1.28920272e-01f, 4.52585183e-02f, 1.76524241e-02f, -5.64357787e-02f, -7.97930360e-02f, 8.85556564e-02f,
  -4.41247970e-02f, -6.67026937e-02f, -6.18444430e-03f, -7.72031620e-02f, -1.74920678e-01f, -2.72155888e-02f, -3.69324759e-02f, 6.52757287e-02f, -4.86787371e-02f, -1.15693688e-01f,
  -1.00709625e-01f, -9.95922834e-02f, -1.41248718e-01f, -2.17534304e-02f, -1.89309984e-01f, -9.60241929e-02f, -1.25411049e-01f, 1.42618138e-02f, -3.51876952e-02f, -2.63271816e-02f,
  -1.13942236e-01f, -8.64313766e-02f, 5.87871000e-02f, -5.22473641e-03f, -1.16594404e-01f, -9.74489078e-02f, -5.78826703e-02f, -1.72198564e-01f, -2.49758840e-01f, -3.68265569e-01f,
  -1.34780213e-01f, 8.01680014e-02f, -2.32605889e-01f, -2.22770181e-02f, -6.51858933e-03f, -7.20051676e-02f, -6.76599666e-02f, -2.70215552e-02f, -3.47250402e-02f, -2.63216700e-02f,
  2.01098382e-01f, 3.17067444e-01f, 1.69811249e-01f, 5.53243607e-02f, -1.24788925e-01f, -1.99534327e-01f, -1.42016903e-01f, -1.01546705e-01f, 1.45250801e-02f, 1.28076524e-01f,
  1.89650491e-01f, 1.32651582e-01f, -6.54499009e-02f, -7.28451759e-02f, -9.76806059e-02f, 1.16331190e-01f, -2.01753490e-02f, -2.18293462e-02f, 3.89384255e-02f, -2.61149198e-01f,
  1.44144177e-01f, -1.71694338e-01f, -9.32902172e-02f, 8.32363144e-02f, -4.04741392e-02f, -1.12626456e-01f, -8.43550339e-02f, -1.38707802e-01f, 1.55501962e-02f, -6.21430250e-03f,
  3.98338512e-02f, 4.20884304e-02f, 5.26926033e-02f, 3.77053171e-02f, -4.77016866e-02f, 6.39810860e-02f, -2.57369000e-02f, -1.72289684e-01f, -9.91448984e-02f, 9.51968413e-03f,
  -5.89392986e-03f, -4.62893024e-02f, -1.89903285e-02f, 2.16414258e-02f, -2.35044677e-02f, -1.05708912e-01f, -1.43454189e-03f, 2.50679944e-02f, -4.99386080e-02f, -4.09022830e-02f,
  -7.48726167e-03f, -1.05685465e-01f, -3.52495350e-02f, -6.75726458e-02f, -2.17066929e-02f, -2.97319540e-03f, -5.98367117e-02f, -4.50587384e-02f, -2.17939168e-01f, -4.13388982e-02f,
  -2.28535905e-02f, -5.80362491e-02f, -7.27412179e-02f, -4.80671749e-02f, 2.06577480e-02f, -9.11500975e-02f, -5.15258759e-02f, 2.54425278e-04f, -8.30427259e-02f, -5.26709817e-02f,
  -1.68809537e-02f, -5.16233407e-02f, -2.38859169e-02f, 3.32404226e-02f, -2.60788146e-02f, -9.32170227e-02f, 3.32606444e-03f, -1.17094058e-03f, 8.00914888e-04f, -6.86671436e-02f,
  3.79713178e-01f, -2.29319885e-01f, -7.79552981e-02f, -2.23174095e-02f, -9.17081684e-02f, -3.57739744e-03f, -2.57613827e-02f, -9.75340083e-02f, 2.79775653e-02f, 1.51259210e-02f,
  -3.72267775e-02f, -1.09249502e-01f, 5.33316135e-02f, 8.15363675e-02f, -2.27378793e-02f, -1.38244433e-02f, 6.50558099e-02f, -1.14961695e-02f, 3.37544382e-02f, -1.10491710e-02f,
  5.88823892e-02f, 2.87559885e-03f, 9.42806602e-02f, 1.29633639e-02f, -5.42912483e-02f, 6.79751635e-02f, 5.73051535e-02f, -3.05088330e-02f, 8.68764743e-02f, 9.73047614e-02f,
  1.79469198e-01f, -3.91027518e-02f, 1.11003136e-02f, -4.98368405e-02f, 1.24548599e-01f, 1.65408865e-01f, 1.00354493e-01f, 6.45942390e-02f, -1.54490676e-02f, 9.37744826e-02f,
  1.17771104e-01f, 1.38118714e-01f, -2.96460893e-02f, -3.49375084e-02f, -1.86962206e-02f, -8.81462470e-02f, -9.95972753e-02f, -1.90669263e-04f, 1.85148701e-01f, 6.60986379e-02f,
  -1.07574854e-02f, 4.62841839e-02f, 2.68233456e-02f, 9.06091463e-03f, -2.79596269e-01f, 5.54093421e-02f, -1.33036882e-01f, -6.11393899e-02f, -1.03682071e-01f, -4.82985735e-01f,
  7.12464079e-02f, 1.14726713e-02f, -3.47115919e-02f, 2.46864259e-02f, -9.98198893e-03f, -1.33945635e-02f, -6.60529546e-03f, -3.68306488e-02f, 1.17431022e-01f, -6.21107779e-02f,
  2.64149718e-02f, -1.98774654e-02f, -1.22027367e-03f, -3.11031695e-02f, -5.34605831e-02f, -3.16054821e-02f, -9.13602337e-02f, -6.34608567e-02f, -2.83518564e-02f, 2.64588166e-02f,
  -1.15579832e-02f, -1.60064921e-02f, 9.06594843e-02f, 4.34867665e-02f, -1.49935996e-02f, 6.20631389e-02f, -4.20160107e-02f, -7.65639320e-02f, -2.33154856e-02f, -8.54896531e-02f,
  1.63368195e-01f, 9.11085587e-03f, -5.84350377e-02f, 4.46064584e-02f, 6.59037754e-02f, 4.28446336e-03f, 5.37565872e-02f, -1.00369245e-01f, -5.73351756e-02f, -5.26566654e-02f,
  -4.71035577e-02f, 7.81127140e-02f, 1.66582651e-02f, -1.83862746e-02f, 8.54599327e-02f, -8.04085806e-02f, -1.32055450e-02f, -2.06346344e-02f, 3.89655791e-02f, 8.66041109e-02f,
  -2.63585020e-02f, 1.27936970e-03f, -2.56415270e-02f, -1.01028457e-01f, 1.13076298e-02f, -1.33145809e-01f, -8.05435926e-02f, 3.72287855e-02f, 4.08146977e-02f, 1.13765068e-01f,
  1.53885365e-01f, 2.41681546e-01f, 1.29341170e-01f, -3.27963792e-02f, 3.39498594e-02f, 9.18282047e-02f, 1.78379714e-02f, -6.53436780e-02f, 2.63509452e-02f, -3.28124315e-02f,
  -1.20897843e-02f, 8.02053064e-02f, 7.70441219e-02f, 4.80542630e-02f, 1.19466297e-01f, 1.05919391e-01f, 4.98418845e-02f, 4.48380038e-02f, -8.10421305e-04f, 9.41005629e-03f,
  6.32798811e-03f, 1.69491217e-01f, 1.56654283e-01f, 1.75258473e-01f, 6.57398328e-02f, 1.73003212e-01f, 1.28253266e-01f, 1.70616396e-02f, 5.69236949e-02f, 1.39947429e-01f,
  4.35945600e-01f, -1.26614273e-01f, 1.66504189e-01f, -2.95098033e-02f, -1.34276256e-01f, 9.70268175e-02f, 5.44820912e-02f, -3.90084498e-02f, 6.69209510e-02f, 1.87360290e-02f,
  6.41071470e-03f, -9.73535031e-02f, -1.38295665e-01f, -8.63848850e-02f, 1.25745311e-01f, -1.06246024e-01f, -1.77423418e-01f, -1.61526967e-02f, 2.94079691e-01f, 2.01213315e-01f,
  1.53489467e-02f, 1.14036418e-01f, 2.94191509e-01f, 2.33950585e-01f, -9.76086482e-02f, 9.83117595e-02f, 2.22718902e-02f, 4.63003479e-02f, 5.56815341e-02f, -3.36450875e-01f,
  5.92795312e-02f, 1.48745745e-01f, -6.60816506e-02f, 9.90867913e-02f, 1.31455049e-01f, 1.03631362e-01f, 4.63034399e-02f, 1.26894219e-02f, 1.88849773e-02f, -7.17729554e-02f,
  2.42165159e-02f, -2.27099532e-04f, -2.95534893e-03f, 2.78976895e-02f, 7.62908980e-02f, 6.76780045e-02f, 2.11022086e-02f, 6.97665513e-02f, 9.11246985e-03f, -4.60108593e-02f,
  -1.95607528e-01f, -3.93163487e-02f, 9.34000984e-02f, -2.08491851e-02f, 8.24876502e-02f, 3.87639292e-02f, 6.46217614e-02f, 5.36146201e-02f, 1.56024188e-01f, -3.32862139e-02f,
  6.27053007e-02f, -7.10103810e-02f, -2.22789533e-02f, 2.69038100e-02f, -9.19213891e-02f, -7.41026476e-02f, -1.41460896e-01f, 7.37626525e-03f, -1.21498443e-02f, -9.89716593e-03f,
  -2.96024811e-02f, 1.28707275e-01f, -8.23211949e-03f, 3.51977348e-02f, -3.48464847e-02f, 7.22928643e-02f, 1.68473959e-01f, -5.13886809e-02f, -2.85088341e-03f, 2.25337911e-02f,
  -1.04939928e-02f, 2.45599411e-02f, 1.56025365e-02f, -6.74267635e-02f, -1.17816096e-02f, 7.39980042e-02f, 7.13039786e-02f, 1.30209629e-03f, -5.23568541e-02f, 3.65135334e-02f,
  2.98020951e-02f, -7.92953931e-03f, 3.66464676e-03f, -3.98846976e-02f, 5.24615077e-03f, 4.80237491e-02f, 1.01929225e-01f, -1.53555283e-02f, 7.38960505e-02f, 5.03812581e-02f,
  1.49249345e-01f, -1.89726539e-02f, 3.50617915e-02f, 2.66430192e-02f, -6.23918958e-02f, 6.88809156e-02f, -3.37643437e-02f, 3.44062108e-03f, 9.84361917e-02f, 9.26215053e-02f,
  8.30110442e-03f, 7.84306005e-02f, 1.39847040e-01f, -7.02926889e-02f, -3.58822457e-02f, 7.10338578e-02f, 1.04955465e-01f, 1.10795945e-01f, 2.66837627e-01f, 9.01958048e-02f,
  1.75566092e-01f, 4.12854180e-02f, 1.84537634e-01f, -2.09432617e-01f, 3.38594392e-02f, 1.05532452e-01f, 2.99296945e-01f, 8.25987458e-02f, -1.51100218e-01f, -3.14996168e-02f,
  -1.75948128e-01f, -3.20767701e-01f, -2.43853882e-01f, -1.95415974e-01f, 7.41966814e-02f, 2.74229586e-01f, 2.04785451e-01f, 1.39748417e-02f, -7.14832395e-02f, -1.14004262e-01f,
  -2.62267888e-01f, 4.68762033e-02f, -2.58109737e-02f, 8.19344167e-03f, -4.23814058e-02f, -6.22404069e-02f, 9.42999348e-02f, 2.60772388e-02f, 1.05268188e-01f, 6.67244270e-02f,
  -1.05153807e-01f, 2.11077392e-01f, 2.80571054e-03f, -1.21413983e-01f, -1.88594475e-01f, -9.40951854e-02f, 4.31642607e-02f, -6.66162670e-02f, -9.94165689e-02f, -7.55549818e-02f,
  -1.57784626e-01f, -9.16705802e-02f, 1.88535545e-02f, -8.96429196e-02f, 8.68262053e-02f, -5.32470010e-02f, 4.76654340e-03f, 3.29897250e-03f, 1.01115778e-01f, -7.87126496e-02f,
  -1.00140393e-01f, -9.24426410e-03f, 1.39716864e-01f, 3.42419371e-02f, 1.84627827e-02f, 2.10740473e-02f, -8.19913521e-02f, -6.17469028e-02f, -7.07510114e-02f, 1.57866757e-02f,
  -1.64456636e-01f, -6.82984814e-02f, 1.36767616e-02f, -5.90607636e-02f, 4.19446547e-03f, -3.13094035e-02f, 7.13875925e-04f, 6.23672307e-02f, 1.17330492e-01f, 1.68483017e-03f,
  -9.00753960e-02f, -1.09814098e-02f, -4.17197961e-03f, 1.79639595e-04f, -7.58559704e-02f, 1.03599936e-01f, -4.81277658e-03f, -1.17447823e-02f, -9.62726306e-03f, 6.62630200e-02f,
  -2.78560221e-02f, 1.01172537e-01f, 4.80078161e-02f, 2.92309816e-03f, 5.77158369e-02f, 4.30516824e-02f, 1.93308434e-03f, -1.08972497e-01f, -8.35558996e-02f, 2.57831477e-02f,
  -2.06029832e-01f, 1.12977073e-01f, 8.88322014e-03f, -1.80664333e-03f, 2.49430444e-02f, -3.07367500e-02f, 9.47198644e-02f, 3.37189250e-02f, -5.73107926e-03f, 6.14494132e-03f,
  3.34614739e-02f, -9.56050530e-02f, 1.33093977e-02f, 4.73536514e-02f, -6.58668205e-02f, -1.02264946e-02f, -5.81205115e-02f, -3.30743492e-02f, 1.30973561e-02f, 2.05317810e-02f,
  -2.98919412e-03f, 1.22489259e-01f, 1.24973498e-01f, 4.32562493e-02f, -7.60798305e-02f, 4.23437990e-02f, 5.45265861e-02f, 4.33825441e-02f, -2.80844495e-02f, -2.91244360e-04f,
  2.15537116e-01f, -2.79354811e-01f, 3.05545241e-01f, -2.62318458e-02f, -1.66657731e-01f, -2.27971956e-01f, -2.62358516e-01f, -1.50490567e-01f, -8.73852521e-02f, -1.57434732e-01f,
  -1.92531049e-01f, 8.55365917e-02f, 7.69067835e-03f, 1.67960659e-01f, 1.72569901e-01f, -8.48095268e-02f, 1.89001799e-01f, 3.52420837e-01f, 9.30187553e-02f, -5.49493916e-02f,
  -1.50435880e-01f, 2.54059937e-02f, 2.08552897e-01f, 1.54130727e-01f, 4.96438481e-02f, 9.68751777e-03f, -2.15057451e-02f, 7.91409239e-02f, -8.58721957e-02f, 2.34932423e-01f,
  9.52914208e-02f, 7.19048083e-02f, 1.18651502e-02f, -6.05218410e-02f, -9.67409909e-02f, -1.22439750e-01f, -1.40317036e-02f, -1.87770352e-02f, -6.67802617e-02f, -5.37233464e-02f,
  -7.58862868e-02f, -6.11788258e-02f, -8.38837698e-02f, -6.09670021e-02f, -7.91907161e-02f, -1.12787202e-01f, -1.18405059e-01f, 1.12125605e-01f, 3.98196001e-03f, -1.24606080e-01f,
  -5.08307330e-02f, -1.62244663e-01f, 2.24316400e-02f, -1.38023645e-01f, 7.66061693e-02f, 6.56693578e-02f, 7.23243058e-02f, 6.72357082e-02f, 1.09153546e-01f, 1.06923960e-01f,
  8.78038108e-02f, 6.72611818e-02f, -1.51816998e-02f, -1.18448228e-01f, -8.45659971e-02f, -1.31850347e-01f, -8.53654668e-02f, -2.02596143e-01f, 7.47170597e-02f, -1.42807260e-01f,
  -4.42426419e-03f, -3.54476436e-03f, 1.06680401e-01f, -5.49724586e-02f, -1.15509909e-02f, 1.60337947e-02f, -2.51770876e-02f, 6.45611621e-03f, -4.09698971e-02f, -3.97816114e-02f,
  -1.28275454e-01f, -2.16245763e-02f, -1.65321499e-01f, 1.91900842e-02f, -1.52051207e-02f, 1.09127406e-02f, 1.14814853e-02f, -4.36268970e-02f, -3.34670506e-02f, -8.15154165e-02f,
  -2.32108638e-01f, 1.39879640e-02f, -8.72962251e-02f, 3.22116427e-02f, -5.55127412e-02f, -1.53883800e-01f, -1.53675556e-01f, -8.85643214e-02f, -7.34185353e-02f, -8.21823701e-02f,
  -1.94908783e-01f, -1.04459494e-01f, -1.04156449e-01f, -7.46451169e-02f, -2.00112239e-02f, -1.13761313e-01f, -2.34622896e-01f, -7.23911077e-02f, 2.03726105e-02f, -1.99334383e-01f,
  -1.37468845e-01f, -8.92261639e-02f, -2.08979040e-01f, -6.98895380e-02f, -1.10240072e-01f, -5.88371120e-02f, -9.43065584e-02f, -1.13333732e-01f, 2.25704592e-02f, -1.75057247e-01f,
  -1.01370163e-01f, -1.26911819e-01f, -3.08465719e-01f, -1.30055904e-01f, -7.99446777e-02f, 9.69572291e-02f, -5.74332476e-02f, -3.88163589e-02f, -2.00251546e-02f, 2.16841232e-02f,
  5.98871857e-02f, 1.29238412e-01f, 8.50512162e-02f, 7.96084255e-02f, 1.00938104e-01f, -4.74002920e-02f, -2.77017295e-01f, -7.67286345e-02f, 6.76816925e-02f, 1.84321657e-01f,
  1.08868502e-01f, -9.23789218e-02f, -3.11453883e-02f, 5.93734486e-03f, -8.13750923e-02f, 1.47733420e-01f, -7.79518038e-02f, -8.33104700e-02f, -8.71046782e-02f, -3.75280410e-01f,
  -1.37669355e-01f, -8.70721266e-02f, -7.10230023e-02f, -2.47651748e-02f, -1.69745415e-01f, -5.83695844e-02f, -7.29366019e-02f, -1.75458223e-01f, -6.92725778e-02f, -8.13520979e-03f,
  1.92789529e-02f, -1.36835678e-02f, -4.11436744e-02f, -7.82253966e-02f, -5.91477267e-02f, -3.16401236e-02f, -2.08653316e-01f, -1.69668213e-01f, -6.46164268e-02f, -1.62388533e-01f,
  -1.65144220e-01f, -9.07378569e-02f, -1.13554008e-01f, 3.44357220e-03f, -4.01456393e-02f, -4.04832289e-02f, -3.65049653e-02f, -1.00178652e-01f, -6.00543544e-02f, -8.00149739e-02f,
  1.33408576e-01f, -1.53885365e-01f, -1.41803259e-02f, -1.95600837e-02f, -5.82607165e-02f, -1.11916997e-02f, -5.17351590e-02f, 8.10545757e-02f, 9.01255161e-02f, -1.66599086e-04f,
  1.08521972e-02f, 8.13683718e-02f, 1.15987226e-01f, -4.64407578e-02f, 5.59234619e-02f, 4.52122577e-02f, 9.70301703e-02f, 2.28048526e-02f, 5.64438514e-02f, 2.50570104e-03f,
  8.37318748e-02f, 2.26801075e-02f, 3.08997482e-02f, 9.24643800e-02f, 1.93671286e-02f, -5.56643754e-02f, 1.52025387e-01f, 1.61619052e-01f, 8.29936936e-02f, -4.54634149e-03f,
  2.02576473e-01f, -1.16937339e-01f, -5.14478423e-02f, -1.31791318e-02f, -1.27412334e-01f, 3.59044899e-03f, -1.99273944e-01f, -4.62015644e-02f, -1.42161297e-02f, -1.29404198e-02f,
  8.08366463e-02f, 7.72142485e-02f, -6.90067410e-02f, -1.38085485e-01f, -9.97813325e-03f, 1.12631291e-01f, -1.84931476e-02f, 1.01868678e-02f, -5.51103838e-02f, -3.81545164e-02f,
  -5.66157736e-02f, -3.72834355e-02f, 1.31908674e-02f, -6.09411532e-03f, 1.27316704e-02f, -4.31412831e-03f, 1.58241019e-01f, 1.07158102e-01f, 1.63566023e-01f, 1.75871924e-01f,
  5.87126501e-02f, -1.79465115e-01f, -4.48229723e-02f, 1.61652789e-02f, 2.94952430e-02f, 1.18385568e-01f, -1.47137731e-01f, -9.67227742e-02f, 7.17363926e-03f, 1.32743167e-02f,
  1.35748431e-01f, 1.96831107e-01f, 6.87562898e-02f, -2.24691257e-02f, -1.46270975e-01f, -1.71697438e-01f, -7.89202303e-02f, -1.12964272e-01f, -1.51257021e-02f, 8.56623277e-02f,
  5.17303683e-02f, -5.59523627e-02f, -2.79209134e-03f, -6.06036559e-02f, -2.02958584e-01f, -7.64407068e-02f, -1.03809036e-01f, -1.33438379e-01f, -1.18206389e-01f, -4.34060842e-01f,
  -1.16531849e-01f, -3.60291861e-02f, -1.08547240e-01f, 5.98545703e-05f, -9.32865068e-02f, -9.23540369e-02f, -1.05522737e-01f, -2.15919748e-01f, 2.17459034e-02f, -1.71642192e-02f,
  1.54035296e-02f, -3.84140350e-02f, -1.27141755e-02f, -8.53183940e-02f, -1.24691382e-01f, -6.11301549e-02f, 2.29433645e-02f, -6.48834407e-02f, -2.98796017e-02f, -1.43212304e-01f,
  -1.16677463e-01f, -7.07588270e-02f, -2.24412009e-01f, -7.36962333e-02f, -1.10413305e-01f, -3.14772502e-02f, -2.11674571e-01f, -2.26658076e-01f, -2.36551747e-01f, -3.85892570e-01f,
  -1.30138978e-01f, 8.59339386e-02f, -3.76423821e-02f, 2.46522333e-02f, 6.46863952e-02f, 1.30914077e-01f, -2.99893059e-02f, -2.20384784e-02f, 6.42592683e-02f, 2.65897415e-03f,
  -1.81386750e-02f, 3.32750641e-02f, 5.43840639e-02f, -8.78082309e-03f, 1.21481679e-02f, -5.94495311e-02f, 1.02840364e-01f, -5.05601987e-02f, 8.68228525e-02f, 1.31962290e-02f,
  2.74721952e-03f, 4.86709327e-02f, 1.14996107e-02f, 7.78105948e-03f, 5.87643590e-03f, -9.72603634e-03f, -3.15337293e-02f, 8.06311965e-02f, -5.28376317e-03f, 8.63364935e-02f,
  5.26315942e-02f, 2.18990907e-01f, -1.37225509e-01f, -9.73076671e-02f, -6.01114444e-02f, -4.92406450e-02f, 8.15711394e-02f, 2.28819363e-02f, 2.41860077e-02f, 4.94263135e-03f,
  -4.12001498e-02f, -8.07686001e-02f, 3.08034327e-02f, -4.73295711e-02f, 3.01948246e-02f, -8.88037775e-03f, -3.83904278e-02f, -7.25142583e-02f, -5.04342020e-02f, 2.22690264e-03f,
  -7.76201487e-02f, -1.37182638e-01f, -1.55548716e-03f, -2.52794530e-02f, -1.53569028e-01f, -1.20306388e-01f, -9.25145671e-02f, -1.73870370e-01f, -7.93973580e-02f, -2.35888436e-01f,
  1.87850967e-02f, 6.88067675e-02f, -1.44286349e-01f, 3.66500020e-02f, 1.76077500e-01f, 1.33444041e-01f, 2.50598073e-01f, 3.24597545e-02f, 6.95602819e-02f, 1.39176667e-01f,
  1.67508125e-01f, 1.94098175e-01f, 9.37756598e-02f, 4.03682739e-02f, 9.63531621e-03f, -3.06350514e-02f, -2.12827891e-01f, -3.14097628e-02f, 5.62476926e-02f, 4.10379991e-02f,
  1.18242264e-01f, 3.14408913e-02f, -1.63169697e-01f, -2.78820051e-03f, -6.19322397e-02f, -2.65621208e-02f, -2.07010120e-01f, -4.73831818e-02f, 5.58186099e-02f, -3.64398122e-01f,
  4.07681800e-03f, 1.25906527e-01f, 1.70668960e-01f, 1.01323001e-01f, 2.91998275e-02f, -1.71774849e-02f, 4.89937328e-02f, 7.47241229e-02f, 8.51051211e-02f, 7.22935796e-02f,
  1.11362301e-01f, 1.08176187e-01f, 1.53675660e-01f, 9.02514532e-02f, -2.00221203e-02f, 6.15801103e-03f, -1.10147551e-01f, -6.92398772e-02f, -9.39707551e-03f, 1.02398969e-01f,
  4.08617221e-03f, 1.24054283e-01f, 2.80822590e-02f, -3.57436910e-02f, -1.51320696e-02f, -7.23599941e-02f, -8.78034681e-02f, -1.13570452e-01f, -8.50076750e-02f, -1.95950016e-01f,
  -1.76392391e-01f, -1.88282847e-01f, -5.89234084e-02f, -1.71576202e-01f, -7.17163086e-02f, -1.13354042e-01f, -5.03068753e-02f, -4.83722379e-03f, -1.15074143e-01f, -1.08175568e-01f,
  -1.19017489e-01f, -8.37340876e-02f, -1.21703006e-01f, -6.27783826e-03f, -1.08230866e-01f, -1.44275308e-01f, -1.33696988e-01f, -1.36242807e-01f, -1.69512033e-01f, -4.26584994e-03f,
  1.48430187e-02f, -2.22699553e-01f, -2.06471831e-01f, -2.07446888e-01f, -1.71966583e-01f, -2.76905924e-01f, -1.62977323e-01f, -1.56321540e-01f, -2.56486326e-01f, -1.51968881e-01f,
  8.13820809e-02f, 2.02871799e-01f, 1.14205107e-01f, 1.00346111e-01f, 1.46332473e-01f, 1.99267641e-02f, 9.78407934e-02f, 1.79825097e-01f, 1.16582215e-01f, 1.28504517e-03f,
  1.21478714e-01f, 3.02313436e-02f, 2.37076193e-01f, 1.45849576e-02f, 1.32792518e-01f, 3.94315608e-02f, 1.23671621e-01f, 2.10412279e-01f, 6.37823641e-02f, 2.47111265e-02f,
  4.99362312e-02f, 1.28994748e-01f, 1.67413622e-01f, 1.55187622e-01f, 4.21431735e-02f, 2.12931991e-01f, -1.11981509e-02f, 1.28451571e-01f, 5.24703674e-02f, 1.27458289e-01f,
  4.44429785e-01f, -9.96711627e-02f, -5.98775856e-02f, 1.85904756e-01f, -3.02124441e-01f, -3.39219064e-01f, -7.05500722e-01f, -7.62849525e-02f, 1.81251913e-01f, -1.84142560e-01f,
  2.11425927e-02f, 2.99290538e-01f, 1.58077627e-01f, 8.01347196e-02f, -7.64998421e-02f, -3.00115168e-01f, -1.69253796e-01f, 1.48105845e-01f, 1.36399463e-01f, -1.05605215e-01f,
  -8.23745802e-02f, 1.04081839e-01f, 3.22914720e-01f, 1.79310575e-01f, 2.22008359e-02f, 8.75543281e-02f, -8.70501027e-02f, 8.75563845e-02f, -1.03385530e-01f, 1.77496180e-01f,
  4.23089005e-02f, 1.28626898e-01f, -1.19372338e-01f, 1.17893718e-01f, 9.67050269e-02f, -1.44469775e-02f, -4.53072228e-03f, 9.06133801e-02f, 2.81768292e-02f, 6.42613182e-03f,
  5.56998737e-02f, 2.31630951e-02f, -3.62664647e-02f, 1.55022573e-02f, -4.32359651e-02f, 5.21622822e-02f, 1.33318886e-01f, 1.43051729e-01f, 7.13251829e-02f, 3.26462649e-02f,
  -9.32835266e-02f, 5.12762554e-02f, -2.58977842e-02f, -6.85574263e-02f, -5.74789308e-02f, 5.75071052e-02f, -2.35636886e-02f, 1.85151801e-01f, 1.03764921e-01f, 5.66156320e-02f,
  -5.45456596e-02f, -2.17675511e-02f, 2.72533372e-02f, -7.92108551e-02f, 6.43070713e-02f, 1.37726991e-02f, 8.24439228e-02f, 8.70697480e-03f, -4.72623073e-02f, 1.68911442e-02f,
  9.08511877e-02f, 3.18827555e-02f, 8.60824659e-02f, 7.19099212e-03f, -3.49222794e-02f, 1.22015122e-02f, -6.46674335e-02f, 3.24342996e-02f, 2.57014632e-02f, 3.79766822e-02f,
  1.99917294e-02f, 3.33536863e-02f, 7.71756703e-03f, 1.16620483e-02f, 2.55586430e-02f, 6.92366734e-02f, 4.70178463e-02f, 5.76341413e-02f, 1.18888868e-02f, 4.64867726e-02f,
  1.54488217e-02f, -1.26486361e-01f, -3.25406082e-02f, -3.36317457e-02f, 3.73318605e-02f, 5.97147010e-02f, -5.25178723e-02f, -4.94193658e-02f, 6.61704764e-02f, 1.37775913e-02f,
  -1.46014104e-02f, 9.78613552e-03f, -1.02747671e-01f, -3.57489847e-02f, 2.41422672e-02f, -2.72505581e-02f, -7.05894828e-02f, -5.96031621e-02f, 2.59327665e-02f, 5.25794327e-02f,
  -3.15416083e-02f, -6.19023331e-02f, -5.01507185e-02f, -8.11308399e-02f, 4.71355058e-02f, -8.40513036e-02f, -1.55983970e-01f, -1.02454662e-01f, -9.20131728e-02f, -1.52438045e-01f,
  -1.72802478e-01f, 8.55592731e-03f, 4.74164516e-01f, -6.87512904e-02f, 7.09635317e-02f, 2.73560762e-01f, 3.30050826e-01f, 1.43294409e-01f, -1.18184730e-01f, 9.03253034e-02f,
  -4.28462625e-02f, -3.23458195e-01f, -2.42342681e-01f, -4.30560438e-03f, 2.19833553e-01f, 1.83937669e-01f, 1.53179988e-01f, 2.29942605e-01f, 2.67401636e-01f, 1.72504082e-01f,
  -1.18806243e-01f, -1.13203421e-01f, -1.08658664e-01f, 5.96445464e-02f, 7.94294029e-02f, 2.36352794e-02f, 2.30677659e-03f, -6.04327582e-03f, -1.93808042e-02f, 5.04394770e-02f,
  8.13579559e-02f, 1.65609509e-01f, 8.33394080e-02f, -1.61577180e-01f, -1.72441881e-02f, -4.82445303e-03f, -1.01171941e-01f, -4.98291962e-02f, -1.21057861e-01f, -1.06618509e-01f,
  1.33435568e-02f, -8.61521512e-02f, -3.30539607e-02f, -6.99392185e-02f, -1.30600315e-02f, 6.83885114e-03f, 1.69851128e-02f, 2.67054085e-02f, 2.68413611e-02f, -7.05053359e-02f,
  -2.36314088e-02f, -5.54648833e-03f, 1.25077173e-01f, 6.57089725e-02f, 6.68709129e-02f, -9.14375633e-02f, -2.05840673e-02f, 2.28319243e-02f, 1.23787798e-01f, -1.34854734e-01f,
  -3.37762050e-02f, 2.07022228e-03f, 6.19182922e-02f, 5.40550761e-02f, -1.79687049e-02f, -2.79359799e-02f, 4.43211123e-02f, 6.29700869e-02f, 1.52002359e-02f, -2.15280224e-02f,
  4.76378053e-02f, 4.42176573e-02f, -1.93541944e-02f, 2.78809145e-02f, 2.31616404e-02f, 5.42581528e-02f, 3.40343043e-02f, 5.54626212e-02f, -2.92561483e-02f, -4.26139012e-02f,
  -3.96357551e-02f, 2.43386552e-02f, -9.75868106e-02f, 4.81394604e-02f, 2.19811555e-02f, 1.95931569e-02f, -2.04867236e-02f, 3.85534787e-03f, -5.35516031e-02f, -8.70525558e-03f,
  -3.18725407e-01f, 1.41486913e-01f, -2.07535505e-01f, -1.34086013e-01f, -8.07354301e-02f, -1.08745858e-01f, -5.69134429e-02f, -5.93567267e-02f, -5.48028573e-02f, -8.77107233e-02f,
  -3.95341683e-03f, 4.63380106e-02f, -7.78017640e-02f, -3.58226523e-02f, 5.77069223e-02f, 2.03538574e-02f, -1.05831444e-01f, -7.27885142e-02f, -5.17989807e-02f, -4.50099520e-02f,
  -1.32631510e-01f, -1.03263788e-01f, -6.57299682e-02f, 1.14327870e-01f, -1.12739213e-01f, -2.15163976e-02f, 8.55489597e-02f, -2.41154302e-02f, 1.04561880e-01f, -5.82796037e-02f,
  2.38759488e-01f, -3.43797266e-01f, -6.59059659e-02f, 2.10955232e-01f, -1.58371270e-01f, -2.47152582e-01f, -5.28711677e-01f, -1.40178189e-01f, 1.81514695e-01f, -9.31720361e-02f,
  -7.27343932e-02f, 2.22571716e-01f, 2.02269316e-01f, -7.83579657e-04f, -1.10284656e-01f, -2.99215525e-01f, -1.06265672e-01f, 1.06330387e-01f, 1.18108846e-01f, -1.16170608e-01f,
  -2.56950837e-02f, -1.32950314e-03f, 1.70429632e-01f, 8.57977122e-02f, -2.33672503e-02f, 2.28297874e-01f, 1.91080458e-02f, 5.95674217e-02f, -5.62437326e-02f, -7.02720731e-02f,
  8.90481919e-02f, -3.06096654e-02f, -5.63595723e-03f, 6.88098744e-02f, -6.06838278e-02f, 3.44019085e-02f, -9.42726713e-03f, -2.50996929e-02f, 1.48104038e-02f, 2.38880720e-02f,
  1.00092683e-02f, 1.63241774e-02f, 7.87450522e-02f, -6.73416778e-02f, -2.37067509e-02f, -5.54607548e-02f, -1.76403709e-02f, 2.62128077e-02f, -2.42589228e-02f, -2.98161712e-02f,
  -4.52900231e-02f, -1.43089846e-01f, -8.84626508e-02f, -1.05552875e-01f, 4.48950008e-02f, 1.80301026e-01f, -1.91715937e-02f, 8.36764090e-03f, 7.75693776e-03f, -6.63176849e-02f,
  -9.79008991e-03f, 1.68003584e-03f, 2.19752192e-02f, -1.11544609e-01f, -1.26840146e-02f, -4.50085439e-02f, 7.21820118e-03f, 4.19291779e-02f, -4.53949459e-02f, -1.45833092e-02f,
  -6.51534274e-03f, -5.50263971e-02f, -8.29854701e-03f, -6.96795946e-03f, 6.30776733e-02f, -6.35382682e-02f, -1.32695613e-02f, -1.06218609e-03f, 1.71231478e-02f, 2.34697089e-02f,
  5.53866774e-02f, -6.22041337e-02f, 2.01472957e-02f, 6.56557083e-02f, -6.01652786e-02f, -3.14498842e-02f, 1.44309225e-02f, 4.22310084e-02f, 9.14454609e-02f, -1.09654225e-01f,
  2.11446971e-01f, 6.06137551e-02f, 5.18068392e-03f, -3.16819549e-02f, -3.00898310e-03f, 1.08049288e-01f, 3.43588144e-02f, 7.84346536e-02f, -3.51691209e-02f, 4.13905233e-02f,
  3.57438391e-03f, 4.60417047e-02f, 5.82078695e-02f, 8.57432857e-02f, -7.95057043e-02f, 4.15360183e-02f, 9.20836162e-03f, -1.53957531e-02f, 1.90281495e-02f, 9.17442963e-02f,
  -8.74620378e-02f, -1.37004912e-01f, -5.74936830e-02f, -3.94486599e-02f, 4.49664108e-02f, 4.65073586e-02f, -4.19915169e-02f, 3.81673388e-02f, -4.37200777e-02f, -1.52753010e-01f,
  -1.83030963e-01f, 1.38440698e-01f, -3.08238983e-01f, -1.01194061e-01f, -3.17337096e-01f, -2.72461653e-01f, -1.41360685e-01f, -7.69902468e-02f, -5.65577112e-02f, 2.68250778e-02f,
  7.03619421e-02f, 3.02288979e-01f, 2.87765682e-01f, 2.66296893e-01f, 1.75718531e-01f, -6.10665493e-02f, -1.65413067e-01f, -6.27027005e-02f, 4.97910641e-02f, -1.17690200e-02f,
  1.74286872e-01f, 1.42278507e-01f, -7.38836378e-02f, 1.20402779e-02f, -4.89892513e-02f, 1.88432351e-01f, -9.69792604e-02f, -1.24733642e-01f, 1.20355926e-01f, 6.72843726e-03f,
  -9.83821973e-03f, -1.92587078e-01f, -1.59796998e-01f, 2.44598789e-03f, -1.38495648e-02f, 4.51857224e-03f, 1.00900587e-02f, -5.86494282e-02f, -5.16413860e-02f, -7.13158865e-03f,
  5.30976430e-02f, -2.72081606e-02f, -4.99991188e-03f, 3.79311629e-02f, -1.64380819e-01f, -1.16690971e-01f, 1.02993838e-01f, 1.97805259e-02f, -8.40834603e-02f, 4.16100547e-02f,
  1.00474849e-01f, 2.79495958e-02f, -1.12066112e-01f, -9.02981218e-03f, -3.77139822e-02f, -1.00035653e-01f, 1.62564609e-02f, -8.63140300e-02f, -1.03511335e-02f, 2.79018432e-02f,
  -1.03607982e-01f, -1.03709169e-01f, 7.00133145e-02f, 1.04113571e-01f, 1.09655134e-01f, 1.48903146e-01f, 1.59298271e-01f, 8.91416147e-02f, 7.39024878e-02f, 1.34936869e-01f,
  5.70559762e-02f, -4.27397676e-02f, 7.41131790e-03f, 2.53043510e-02f, -5.67662343e-02f, 9.68086440e-03f, 8.60496014e-02f, 4.54445891e-02f, -7.83102959e-03f, 7.07554147e-02f,
  3.48716788e-02f, -2.17360314e-02f, 3.58801372e-02f, 9.40927863e-02f, -5.51647544e-02f, 5.67475194e-03f, 4.66100499e-03f, 7.75127187e-02f, 9.17882845e-02f, 1.25664882e-02f,
  1.65995643e-01f, -2.25483149e-01f, -5.05935624e-02f, 2.90511511e-02f, -1.08929509e-02f, -2.15190202e-02f, -6.01179115e-02f, -4.10392992e-02f, -3.78703885e-02f, -2.05329657e-02f,
  -1.84854373e-01f, 2.02172510e-02f, -1.68922827e-01f, -9.15632397e-02f, -1.27618641e-01f, -6.87912554e-02f, 5.10305129e-02f, 3.74591388e-02f, -2.78430115e-02f, -3.72008570e-02f,
  4.66923974e-02f, -8.08196664e-02f, -8.09214190e-02f, -2.81189438e-02f, -7.68250003e-02f, -1.34135233e-02f, -9.43132036e-04f, -7.15233609e-02f, -1.18610635e-01f, 3.86719704e-02f,
  5.23137569e-04f, 3.51648897e-01f, 2.33159825e-01f, -1.19502932e-01f, 1.64472282e-01f, 6.02277741e-02f, 1.90932110e-01f, 4.19493727e-02f, -1.65864304e-01f, 4.38268930e-02f,
  3.78100313e-02f, -1.22366339e-01f, -1.28547177e-01f, -4.07334976e-02f, -2.15422124e-01f, 4.98298556e-02f, -1.21537805e-01f, -2.35589996e-01f, -3.05680603e-01f, -2.15336248e-01f,
  -2.29338974e-01f, -2.15530425e-01f, -1.59975931e-01f, -1.16031960e-01f, -3.68444882e-02f, -1.80293933e-01f, 1.62109241e-01f, 5.27590737e-02f, 7.44262487e-02f, -3.59016582e-02f,
  4.93626401e-04f, 2.32784748e-01f, 6.70913979e-02f, -3.48821916e-02f, 5.90238869e-02f, 1.49456756e-02f, -4.52268086e-02f, 1.29821435e-01f, 1.50192287e-02f, -3.40018608e-02f,
  1.77653488e-02f, -3.09131090e-02f, -1.40182033e-01f, -9.35618952e-02f, -2.29464769e-02f, 2.85774041e-02f, -2.53416561e-02f, 2.96680480e-02f, 2.67655682e-02f, 1.44184381e-01f,
  1.09769842e-02f, 1.55795425e-01f, 1.49376124e-01f, 4.17108536e-02f, -4.13632579e-02f, -8.15121010e-02f, 1.13663405e-01f, 5.00192828e-02f, 7.19744945e-03f, 1.03984915e-01f,
  2.66281702e-03f, 2.34426204e-02f, 4.35155779e-02f, 8.36948976e-02f, -7.40606785e-02f, -4.06796532e-03f, -4.42005210e-02f, -5.92430457e-02f, -2.45309919e-02f, 6.40118569e-02f,
  6.88160211e-02f, -4.88165170e-02f, -2.54759062e-02f, -9.24456492e-03f, -2.83436794e-02f, -3.63328494e-02f, -5.41248955e-02f, 3.40865999e-02f, -1.46301929e-02f, 4.82193893e-03f,
  1.00808837e-01f, 1.10773901e-02f, -6.67135715e-02f, -9.46339145e-02f, 6.39040992e-02f, -8.17464218e-02f, 2.37894739e-04f, -2.93749981e-02f, -7.72107989e-02f, 1.14979260e-01f,
  1.68326914e-01f, 1.63736254e-01f, 6.25015572e-02f, 6.98676407e-02f, 2.35388391e-02f, 4.92723100e-02f, 5.59047014e-02f, 6.52430952e-02f, 2.95534860e-02f, -1.59705743e-01f,
  -7.54216015e-02f, -2.05209479e-01f, -1.01127788e-01f, 4.56982106e-02f, -2.62309760e-02f, -8.13768730e-02f, -1.88798551e-02f, 2.45400015e-02f, 6.81156963e-02f, -3.72187980e-03f,
  6.01380840e-02f, 5.93154691e-02f, 4.69638817e-02f, 6.40959889e-02f, -5.58269322e-02f, 3.15937810e-02f, -3.41211706e-02f, 1.69642922e-02f, 1.22851580e-02f, 1.01678424e-01f,
  -1.15364388e-01f, 7.28512332e-02f, -2.07829535e-01f, -3.06066036e-01f, -3.94159220e-02f, -7.45361373e-02f, 6.91018328e-02f, -1.65707991e-01f, -1.84408858e-01f, -7.46379420e-02f,
  4.60856594e-03f, -2.09166855e-01f, -9.28545371e-02f, -1.46729380e-01f, -6.85188919e-02f, 4.83936854e-02f, -1.54365569e-01f, -2.02440068e-01f, -3.05392176e-01f, -2.57802039e-01f,
  -2.74716437e-01f, -2.21507147e-01f, -2.81051487e-01f, -1.61948770e-01f, -1.54101104e-01f, -1.75042823e-01f, -1.86840221e-01f, -2.31652588e-01f, -7.46692866e-02f, -1.16414286e-01f,
  -2.24958196e-01f, -1.72602579e-01f, -2.72324890e-01f, -1.68108389e-01f, -2.81288713e-01f, -2.54082471e-01f, -1.95195615e-01f, -2.76202291e-01f, -1.69786394e-01f, -1.73650458e-01f,
  -1.97019875e-01f, -2.46893302e-01f, -3.29964578e-01f, -2.65421540e-01f, -3.63912761e-01f, -2.30062246e-01f, -2.84587592e-01f, -2.18330532e-01f, -1.74082696e-01f, -3.01648378e-01f,
  -1.50284395e-01f, -3.00935507e-01f, -1.34932861e-01f, -1.05544023e-01f, -2.12509215e-01f, -1.59086674e-01f, -1.00120701e-01f, -2.03539029e-01f, -1.55360878e-01f, -1.51966602e-01f,
  4.72563393e-02f, -3.23106386e-02f, 1.46416560e-01f, 1.48793370e-01f, 1.34951711e-01f, 1.52894944e-01f, 4.13961895e-02f, 6.50391215e-03f, 1.36653110e-01f, 1.93432763e-01f,
  1.70914456e-01f, 1.68234184e-01f, 7.99593702e-02f, 1.84822362e-02f, 1.45503372e-01f, 1.08157888e-01f, 9.65094119e-02f, 1.54433072e-01f, 1.16048358e-01f, 1.20015435e-01f,
  1.79623678e-01f, 1.31873146e-01f, 1.78669184e-01f, 2.84300834e-01f, 2.44463161e-01f, 1.47155553e-01f, 8.09892341e-02f, 2.24293217e-01f, 1.14144400e-01f, 1.04246110e-01f,
  -2.28254765e-01f, -1.88701451e-01f, -1.49165660e-01f, -2.12290660e-01f, -2.58918315e-01f, -2.35023484e-01f, -2.53864169e-01f, -2.20040083e-01f, -2.85366058e-01f, -2.25990012e-01f,
  -1.99406862e-01f, -1.85057580e-01f, -2.50545472e-01f, -2.16430843e-01f, -1.95622459e-01f, -1.90274879e-01f, -9.53203291e-02f, -8.12856928e-02f, -1.38044298e-01f, -2.48935297e-01f,
  -1.61088318e-01f, -8.18660557e-02f, -6.28718138e-02f, -6.75576180e-02f, -2.05894098e-01f, -1.61325544e-01f, -1.13016732e-01f, -1.10495396e-01f, -6.41700476e-02f, 1.12232797e-01f,
  1.25646979e-01f, -2.34162763e-01f, -2.18942836e-01f, 1.14421025e-02f, -2.52031605e-03f, 2.15529397e-01f, -2.03524381e-02f, 8.04744735e-02f, 1.23508126e-01f, -8.58092010e-02f,
  5.85613623e-02f, 1.37670815e-01f, 2.47020572e-02f, 1.16414621e-01f, 1.07671268e-01f, -1.58928141e-01f, -2.53186315e-01f, -6.20734468e-02f, 2.53469199e-01f, 2.88298815e-01f,
  6.82375953e-02f, -9.66811925e-02f, 5.67423403e-02f, -3.90201919e-02f, -9.73609909e-02f, 1.11578293e-01f, -1.79172635e-01f, -2.08840698e-01f, -1.18402839e-01f, -4.72324967e-01f,
  1.24489022e-02f, 5.94298691e-02f, 9.36606750e-02f, 5.05785234e-02f, 2.53967941e-03f, 1.26014724e-01f, 2.65474133e-02f, -3.22868042e-02f, 4.21933904e-02f, -6.34289300e-03f,
  -4.76858541e-02f, 9.21263476e-04f, -1.91488862e-02f, 7.70075247e-02f, 7.66164511e-02f, 5.11663295e-02f, 4.78530163e-03f, -4.63911444e-02f, 3.85687090e-02f, 4.32955623e-02f,
  2.13488936e-02f, -2.00367104e-02f, 1.59520030e-01f, 9.50119197e-02f, 8.06905236e-03f, 1.47685751e-01f, 1.52363002e-01f, 1.45418704e-01f, 1.94575131e-01f, 5.88283548e-03f,
  5.73169328e-02f, -1.95605252e-02f, 3.88174020e-02f, -1.32517833e-02f, -1.68609004e-02f, -7.86029026e-02f, -7.54608065e-02f, 8.28048587e-02f, -1.25914235e-02f, -4.53510173e-02f,
  -8.02768394e-02f, -6.06354140e-02f, 1.15415037e-01f, -2.33056806e-02f, 1.17635176e-01f, 6.15535341e-02f, 1.39134396e-02f, 2.92525184e-03f, 9.09841359e-02f, 6.58679307e-02f,
  5.12905940e-02f, 2.87269056e-02f, -3.81597131e-02f, 1.31868422e-02f, 3.37466113e-02f, 1.27942443e-01f, -1.27281519e-02f, -4.50467831e-03f, -4.08684835e-02f, 1.59116667e-02f,
  1.75937742e-01f, 2.46284753e-01f, 1.89208966e-02f, 8.12727287e-02f, 3.89703214e-02f, -7.57192895e-02f, 7.83830434e-02f, 1.56284180e-02f, -8.89729336e-03f, 1.54451087e-01f,
  1.00236721e-01f, -4.92649451e-02f, -1.56002445e-02f, 8.51458460e-02f, 4.63736914e-02f, 1.94643848e-02f, 3.79526876e-02f, 8.49263147e-02f, 9.09098461e-02f, 4.16689329e-02f,
  -6.39247522e-02f, 1.55812532e-01f, 1.91419795e-01f, -6.49826089e-03f, 8.51912051e-02f, 2.45009914e-01f, 1.38612658e-01f, 4.57004830e-02f, 2.40983352e-01f, -1.00712348e-02f
};

// L0_fan_Wp_bar (Shape: 14 x 120)
const int L0_fan_Wp_bar_rows = 14;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -1.14803398e+00f, 1.11389591e-03f, 1.44582465e-01f, -5.87551475e-01f, -2.64745262e-02f, 1.54366389e-01f, 3.95210862e-01f, 1.01002634e-01f, -3.11850488e-01f, -1.28620025e-02f,
  1.02252394e-01f, -1.66517198e-01f, -4.41987440e-02f, 7.52930939e-02f, 1.88105017e-01f, 2.15660334e-01f, -1.94896292e-02f, -1.80183649e-01f, -1.64359316e-01f, 4.56141718e-02f,
  -1.45001849e-02f, -2.98790634e-01f, -4.67498630e-01f, -2.96952784e-01f, 5.01138456e-02f, 1.97314173e-02f, -5.34761325e-02f, -1.59751862e-01f, 1.77174971e-01f, 9.12298113e-02f,
  4.10442144e-01f, -3.54996920e-02f, 2.19856631e-02f, -1.02354884e-01f, 6.78029954e-02f, -8.37885365e-02f, -6.41880045e-03f, -2.89051072e-03f, -7.27480799e-02f, 7.19243959e-02f,
  -1.43998414e-01f, 6.05195807e-03f, -1.58929199e-01f, 4.86023910e-02f, -9.35883448e-02f, 4.11672145e-02f, -7.37330616e-02f, 1.04925446e-01f, 1.44152507e-01f, 1.63102075e-01f,
  6.57725260e-02f, -5.26063591e-02f, 3.97283398e-02f, 1.25567958e-01f, 1.89659283e-01f, 9.91824716e-02f, 1.23495467e-01f, 1.29749388e-01f, 1.38194025e-01f, 5.03510125e-02f,
  3.12864520e-02f, -5.79596907e-02f, 2.42608208e-02f, -4.57156561e-02f, -2.82530189e-02f, 2.69354265e-02f, -2.63359882e-02f, -2.88509242e-02f, 2.22830139e-02f, -1.10847084e-02f,
  1.19950846e-01f, 2.45178659e-02f, 5.87995239e-02f, 1.97966099e-02f, -1.04097584e-02f, -5.52366339e-02f, -8.10036715e-03f, 6.34195283e-02f, 7.41542652e-02f, -1.31135872e-02f,
  7.35701770e-02f, 3.98588106e-02f, -9.87324938e-02f, 4.55527827e-02f, 8.69464949e-02f, 4.59591784e-02f, 1.50001748e-02f, 5.08883558e-02f, -5.03335707e-02f, 1.96080320e-02f,
  6.32603653e-03f, 1.32819593e-01f, 7.72777200e-02f, -6.75368821e-04f, -5.07952385e-02f, 4.15916331e-02f, -6.94041327e-02f, 1.24037797e-02f, 2.47710180e-02f, 1.19264826e-01f,
  8.19459837e-03f, -5.54418452e-02f, 5.83403520e-02f, 1.32875843e-02f, -5.73837422e-02f, 1.00598382e-02f, 7.84134399e-03f, -1.00787632e-01f, 1.09671965e-01f, 1.06281094e-01f,
  2.22648848e-02f, -1.96794067e-02f, -1.46213531e-01f, 8.85452777e-02f, 6.98553473e-02f, -4.58659157e-02f, 1.92705423e-01f, 1.51100652e-02f, 1.07158288e-01f, -7.70539343e-02f,
  -2.58310825e-01f, -8.90886933e-02f, 3.07689495e-02f, 3.55755121e-01f, 1.73532471e-01f, 1.28499463e-01f, 1.55043155e-01f, 8.60897079e-02f, 1.04006581e-01f, 6.68049976e-02f,
  4.61051464e-02f, 7.02741370e-02f, 1.50497451e-01f, 2.35002637e-01f, 2.03653976e-01f, 1.58293575e-01f, 1.91179797e-01f, 1.10034578e-01f, 1.05338253e-01f, 1.95059359e-01f,
  2.29712963e-01f, -1.25377581e-01f, -2.78638542e-01f, 1.07048741e-02f, 2.73023427e-01f, 2.06099764e-01f, 1.30899355e-01f, -3.19274701e-02f, 6.30933940e-02f, 4.06926364e-01f,
  -2.04030827e-01f, -1.56753644e-01f, 1.99746668e-01f, -5.45720495e-02f, -1.59836471e-01f, -6.67901263e-02f, -5.39331511e-02f, -7.31382472e-03f, -1.09412737e-01f, -1.31978214e-01f,
  -8.03959668e-02f, -1.79704264e-01f, -2.49607749e-02f, 3.92764919e-02f, -1.14381202e-01f, -1.09969378e-01f, -1.00498274e-02f, 5.44360988e-02f, 2.04561174e-01f, 6.93208203e-02f,
  1.08437255e-01f, -1.20763831e-01f, -1.11273423e-01f, 1.50165156e-01f, 2.26883620e-01f, -4.25944179e-02f, 5.60775287e-02f, 1.52564105e-02f, -2.21157596e-02f, 8.33690315e-02f,
  -3.51261301e-03f, -7.89856762e-02f, 1.46016434e-01f, 5.34481518e-02f, 2.90010050e-02f, 4.55905534e-02f, 1.34168908e-01f, 5.96980527e-02f, 1.24749318e-01f, 3.24244797e-02f,
  1.28392614e-02f, 1.31744385e-01f, 1.79128915e-01f, 3.12534869e-02f, 3.57496291e-02f, 2.99661863e-03f, 8.78178924e-02f, -3.68766151e-02f, -5.96884303e-02f, -4.40597460e-02f,
  -8.01723357e-03f, 3.78086828e-02f, -7.69177601e-02f, -1.44524928e-02f, 4.24316451e-02f, 1.68315873e-01f, 5.94400875e-02f, 7.32442588e-02f, -3.96525897e-02f, 5.06132990e-02f,
  -1.37438700e-01f, 7.95276016e-02f, 2.37225115e-01f, 1.00017644e-01f, -1.09768026e-01f, -1.60134584e-01f, 1.37680680e-01f, -1.00144178e-01f, -8.96141604e-02f, 2.18085814e-02f,
  -4.89262268e-02f, -7.72877783e-03f, -2.01452691e-02f, -2.21026521e-02f, 3.03272530e-02f, -6.46451265e-02f, -3.77535261e-02f, 1.60664350e-01f, 5.44826984e-02f, -3.63964178e-02f,
  4.30971757e-03f, 2.62478180e-02f, 4.77301553e-02f, 9.91962478e-02f, 1.65369153e-01f, -8.33132118e-03f, 4.69219424e-02f, -7.33070597e-02f, -8.14655423e-02f, -6.60776272e-02f,
  6.79129899e-01f, -5.51672637e-01f, -1.61171570e-01f, 7.67721161e-02f, -1.36396945e-01f, 7.04026818e-02f, -2.35933721e-01f, 3.41081619e-02f, -2.34313682e-03f, -1.69124231e-01f,
  -9.85212848e-02f, 2.66484648e-01f, 2.23392189e-01f, 1.29292428e-01f, 2.30349392e-01f, -3.09122503e-01f, -1.32664427e-01f, 1.54719755e-01f, 4.53485876e-01f, 1.72116920e-01f,
  -5.44003509e-02f, -7.35647455e-02f, 1.96532935e-01f, 5.39470576e-02f, -3.10875833e-01f, 1.26631498e-01f, -3.72223645e-01f, -5.43756858e-02f, -3.25877070e-02f, -4.30507869e-01f,
  -1.05029695e-01f, 3.76343075e-03f, 1.42963752e-01f, 4.40144427e-02f, -1.45401329e-01f, -1.34356068e-02f, 9.46592316e-02f, -1.13106243e-01f, -2.64353622e-02f, -9.36597735e-02f,
  5.26626408e-02f, 4.72301617e-02f, 1.27837330e-01f, 3.84409912e-02f, -3.06985229e-02f, 2.83164978e-02f, 2.69242842e-02f, 4.50526830e-03f, 6.37704553e-03f, -3.84467654e-02f,
  8.77631735e-03f, 4.46754741e-03f, 3.09121311e-02f, 5.92811778e-03f, 1.15385503e-01f, 5.34419008e-02f, -1.17715709e-02f, 1.68173656e-01f, 9.79644805e-02f, -1.73868865e-01f,
  -4.33026031e-02f, 2.98070628e-02f, -1.89897418e-02f, -6.80061579e-02f, -2.53768191e-02f, 2.58922782e-02f, 6.40397221e-02f, -8.39904547e-02f, 8.73273015e-02f, -9.81514603e-02f,
  3.25219296e-02f, -4.91847955e-02f, -6.87974766e-02f, 5.25980145e-02f, -1.25581488e-01f, 1.30347833e-01f, 1.48433013e-04f, -8.86813086e-03f, -5.28181484e-03f, 7.32885897e-02f,
  9.23188229e-04f, 6.83157668e-02f, -4.63549718e-02f, -9.05113993e-04f, -9.75379944e-02f, 5.61135262e-02f, -5.30357286e-03f, 4.69297497e-03f, -2.02321988e-02f, 3.54476869e-02f,
  -2.78297991e-01f, 2.96364695e-01f, 3.29358205e-02f, 7.96684623e-02f, -6.57126829e-02f, -5.97324818e-02f, 6.18305132e-02f, -4.10516337e-02f, -1.16497055e-01f, -6.04222454e-02f,
  -9.58512798e-02f, 6.37197942e-02f, -1.22509792e-03f, -1.55848876e-01f, -7.47273397e-03f, 2.98637394e-02f, -4.23469581e-02f, 1.53062180e-01f, -8.34443886e-03f, -1.57418102e-01f,
  -1.56036496e-01f, -4.59191011e-04f, 6.02252707e-02f, 3.00370548e-02f, 1.07436873e-01f, 2.01480597e-01f, -5.69392107e-02f, 2.78959945e-02f, 1.19821809e-01f, -2.11313426e-01f,
  2.95516074e-01f, -4.52663988e-01f, 2.11435586e-01f, 2.40705043e-01f, 8.96412358e-02f, 1.74297482e-01f, 8.59340802e-02f, -1.23635702e-01f, -1.53603852e-01f, 1.00533657e-01f,
  -2.13213474e-01f, -1.32755160e-01f, -1.21803440e-01f, -2.71247029e-01f, -1.92006111e-01f, 1.32722929e-01f, 2.58414388e-01f, 7.28775263e-02f, 7.41501376e-02f, -1.11520536e-01f,
  -1.45549819e-01f, 3.34411226e-02f, -8.52051228e-02f, 5.01405708e-02f, -5.89990392e-02f, 1.26888439e-01f, 1.87448990e-02f, -9.28178057e-02f, 2.59824563e-03f, -9.53261741e-03f,
  2.72934765e-01f, -3.15840751e-01f, 6.92008659e-02f, -1.90733314e-01f, -4.48712930e-02f, -3.31326015e-02f, -2.71985158e-02f, 1.02822356e-01f, 6.88630715e-02f, -5.41610345e-02f,
  -6.10787682e-02f, -1.76683366e-01f, -9.04116333e-02f, -2.15665907e-01f, 1.46719754e-01f, -3.34770493e-02f, -1.35556385e-01f, -1.88520744e-01f, -3.71813588e-02f, 1.13492444e-01f,
  -1.17342219e-01f, -8.97639021e-02f, -6.65858611e-02f, -9.31853652e-02f, -3.94853354e-02f, -5.02470396e-02f, -4.07050475e-02f, -7.52986744e-02f, -9.98876467e-02f, -3.28464285e-02f,
  -4.07884642e-03f, 3.09164166e-01f, 1.35227293e-01f, 6.65522143e-02f, 3.44341137e-02f, 6.35083318e-02f, 4.37672250e-03f, -6.86379150e-02f, -9.99651849e-02f, 9.46724415e-02f,
  9.31688957e-03f, -6.42115250e-02f, -3.67861963e-03f, -5.41210808e-02f, 2.27474552e-02f, -7.75461048e-02f, -1.16228061e-02f, -6.88097402e-02f, 4.38561849e-02f, 1.56165019e-01f,
  4.60714027e-02f, -3.31012830e-02f, 4.73080128e-02f, 5.89330159e-02f, 4.59092967e-02f, 9.93687510e-02f, -4.66653332e-02f, -4.86956127e-02f, 8.88959989e-02f, 2.90416423e-02f,
  6.76960349e-02f, -2.75246680e-01f, 4.12894100e-01f, -2.24489793e-01f, 1.05608113e-01f, -1.07001320e-01f, 1.07702322e-01f, -9.35541391e-02f, -1.89639419e-01f, 4.89943698e-02f,
  -5.39813042e-02f, -2.54993252e-02f, -2.62449179e-02f, -2.86184251e-02f, 2.46816576e-01f, -4.74809743e-02f, -5.17913662e-02f, -4.04595286e-02f, -5.11086024e-02f, 7.60747269e-02f,
  9.62769091e-02f, -3.22276913e-02f, 1.36509836e-01f, 1.64924204e-01f, 1.63945034e-02f, 1.92301899e-01f, 1.33986324e-01f, 1.62021562e-01f, 7.19995052e-02f, 1.03767201e-01f,
  3.54372919e-01f, 1.04309410e-01f, 2.47831941e-02f, 1.22861348e-01f, 2.81692117e-01f, -9.03769881e-02f, -2.02571392e-01f, -3.04360867e-01f, -1.54884279e-01f, 1.48855284e-01f,
  2.89887249e-01f, 8.25168639e-02f, -7.43924454e-02f, -2.22169742e-01f, -3.89091402e-01f, -1.42641291e-01f, -1.33083493e-01f, -2.70779848e-01f, -5.01385331e-01f, -2.38714039e-01f,
  -6.49407320e-03f, -5.19634075e-02f, -1.15623638e-01f, -8.74595791e-02f, 2.19541341e-01f, 6.34313524e-02f, 1.90980583e-01f, 2.44556457e-01f, 1.50889233e-01f, 5.36516845e-01f,
  2.85689652e-01f, 2.42733851e-01f, -1.82225272e-01f, -5.81539944e-02f, 2.14169383e-01f, 3.70737463e-02f, 7.67347142e-02f, 8.28773975e-02f, 2.93515176e-02f, -1.07743107e-01f,
  1.58885270e-01f, 3.67236212e-02f, 6.49470463e-03f, 3.41566019e-02f, -8.78578424e-03f, -1.73742354e-01f, -1.96181372e-01f, -2.19464257e-01f, -2.02263623e-01f, -9.43414047e-02f,
  -2.90249549e-02f, 1.46710619e-01f, 4.56934497e-02f, -4.49566022e-02f, -1.20635130e-01f, -8.59569460e-02f, 1.29126340e-01f, 1.31350487e-01f, 1.40245304e-01f, 3.24710339e-01f,
  6.26400812e-03f, -1.83342956e-02f, 8.82086158e-02f, -2.67479662e-02f, 8.83320812e-03f, 2.82007046e-02f, 5.71830980e-02f, 6.87459782e-02f, -1.40042618e-01f, -1.10564493e-01f,
  -1.73556525e-02f, 4.35285382e-02f, -4.76929061e-02f, 1.15757450e-01f, 1.10506870e-01f, 1.15480945e-01f, 1.00074396e-01f, -1.97771806e-02f, 2.34511644e-02f, 1.26017883e-01f,
  -6.10417798e-02f, 5.41136265e-02f, -7.92430155e-03f, -3.18562612e-02f, 6.15966320e-02f, 1.05767392e-01f, 7.03469515e-02f, -9.71973166e-02f, -1.08813837e-01f, 3.85723822e-02f,
  -2.18357086e-01f, -1.16502441e-01f, 1.98427215e-01f, -9.04415473e-02f, -5.62858582e-03f, -5.26333554e-03f, 1.40725225e-01f, 5.57066873e-02f, 1.44376874e-01f, 7.08837956e-02f,
  2.82328688e-02f, 4.77784406e-03f, 1.33260682e-01f, -5.71372807e-02f, -1.40432104e-01f, 5.05683199e-02f, -1.16402216e-01f, -6.47232607e-02f, -1.56457677e-01f, -3.94075550e-02f,
  -1.53785020e-01f, -1.24890707e-01f, -2.87175834e-01f, -2.01163545e-01f, 2.66060773e-02f, -1.29990187e-02f, 3.57666872e-02f, 5.52828424e-03f, -9.68329236e-02f, -1.28364772e-01f,
  -5.56524396e-01f, 5.11733908e-03f, -4.49107140e-01f, -4.33325052e-01f, -3.52206290e-01f, -1.45936921e-01f, -1.62952989e-02f, 1.50884107e-01f, -1.11196421e-01f, -3.31210583e-01f,
  1.23840114e-02f, -1.03983460e-02f, -1.86526492e-01f, 3.08863353e-02f, 7.60838315e-02f, -3.16031992e-01f, -4.61463273e-01f, -2.32307419e-01f, 3.49313430e-02f, 1.53943479e-01f,
  1.01116359e-01f, -2.63765335e-01f, -1.39112189e-01f, -1.34371936e-01f, -1.00989260e-01f, -6.13993965e-02f, -2.85028666e-01f, -2.06136957e-01f, 1.20461687e-01f, -3.51338953e-01f,
  -1.63092375e-01f, -1.05777271e-01f, -9.31536034e-03f, -7.51704164e-03f, -2.56274432e-01f, -5.94679676e-02f, -7.63355494e-02f, -9.41411778e-02f, -7.24123344e-02f, -7.39154778e-03f,
  -9.70616266e-02f, 7.93880820e-02f, -7.74985477e-02f, 1.57165974e-02f, 1.43609419e-02f, 5.30307628e-02f, 2.33028177e-02f, 5.10086119e-02f, -2.87875216e-02f, 1.44324809e-01f,
  1.76332489e-01f, 5.84379099e-02f, 1.08720951e-01f, 2.17500374e-01f, 9.11133811e-02f, 3.22180092e-02f, 1.17465772e-01f, 9.25088674e-02f, 2.78833751e-02f, 5.25184087e-02f,
  4.57335338e-02f, -3.26307081e-02f, 5.57662919e-02f, 6.30568415e-02f, 6.02052920e-02f, 5.11382930e-02f, -1.48892472e-03f, 9.52371955e-02f, 8.13891888e-02f, 6.09284155e-02f,
  -6.87789470e-02f, -2.07473025e-01f, -6.98701516e-02f, -5.46422526e-02f, -1.59850314e-01f, -4.40864358e-03f, 2.66493727e-02f, 6.52505383e-02f, 5.25289364e-02f, -3.54231782e-02f,
  2.33204424e-01f, 4.85233068e-02f, -6.01425096e-02f, 1.26799345e-02f, -7.11255819e-02f, -1.12465553e-01f, -2.60008778e-02f, 6.74811602e-02f, -2.15412807e-02f, 3.91609641e-03f,
  1.81377644e-03f, -2.51912862e-01f, -2.01504886e-01f, 1.79784223e-01f, -3.32682766e-02f, -6.89075664e-02f, -5.48388213e-02f, -8.42003599e-02f, -7.86670148e-02f, -3.99599224e-02f,
  1.70850873e-01f, -4.19115275e-02f, -1.01813115e-01f, 3.97576615e-02f, -1.14447787e-01f, 6.85655996e-02f, 5.66387512e-02f, -3.02066337e-02f, 4.80392836e-02f, 6.06141286e-03f,
  9.16835144e-02f, 2.11135410e-02f, 1.84999585e-01f, 6.74034411e-04f, 8.89591575e-02f, -6.98059723e-02f, 3.94395888e-02f, 1.85726896e-01f, 1.58514380e-01f, 3.67371216e-02f,
  -4.94527072e-01f, -2.62732983e-01f, -2.47230113e-01f, -2.44527012e-01f, -1.26065984e-01f, 2.84995418e-02f, -2.10523188e-01f, 1.72076836e-01f, 1.02133632e-01f, -1.32373318e-01f,
  7.49041932e-03f, 9.71462298e-03f, -1.84846386e-01f, -1.42357117e-02f, -5.86918928e-02f, -2.46199414e-01f, -3.62177521e-01f, -1.73074320e-01f, 1.55641526e-01f, 3.11479211e-01f,
  6.55978024e-02f, -9.29913148e-02f, -9.09602344e-02f, 6.22414574e-02f, -1.45377621e-01f, -1.37805864e-01f, -3.81210148e-01f, -9.93047580e-02f, -4.86405715e-02f, -4.90060329e-01f,
  -3.09762239e-01f, 1.41800627e-01f, 1.96381927e-01f, 1.26883999e-01f, 6.51623830e-02f, 1.73416391e-01f, 7.00747594e-02f, 1.16093092e-01f, 1.94210097e-01f, 7.57649019e-02f,
  6.83512986e-02f, 1.91136569e-01f, 3.25390883e-02f, 1.39015228e-01f, -2.84973346e-02f, 1.68700978e-01f, 1.28330514e-01f, -2.01167818e-02f, 4.17230949e-02f, 7.82873631e-02f,
  6.73489645e-02f, 2.17615962e-02f, -2.55483165e-02f, 1.65464163e-01f, 6.83497712e-02f, 8.92478675e-02f, 1.24367711e-03f, 1.18659496e-01f, 1.16315328e-01f, -1.46517634e-01f,
  -1.11946352e-01f, -4.25081141e-02f, 1.45552969e-02f, 1.73523873e-02f, 5.63696176e-02f, 6.29926398e-02f, -1.16545148e-02f, -5.57258204e-02f, 8.26411992e-02f, -5.84704131e-02f,
  4.35927026e-02f, 5.01706079e-02f, 9.18426439e-02f, -3.02417949e-02f, 4.41629402e-02f, 5.08468822e-02f, 2.04657968e-02f, -8.23744163e-02f, 8.61172229e-02f, 1.54227838e-01f,
  1.88383520e-01f, 1.03484295e-01f, -5.30457757e-02f, 1.97955191e-01f, 8.56272504e-02f, 4.37193811e-02f, -4.72076295e-04f, 3.27735418e-03f, -5.38554154e-02f, 2.45205639e-03f,
  -2.85976380e-01f, 1.10052586e-01f, -8.91442373e-02f, -7.17535466e-02f, 6.70435205e-02f, 1.29936919e-01f, -7.81793818e-02f, -2.99538150e-02f, 4.78488617e-02f, 5.69210500e-02f,
  1.20643936e-01f, -1.04065515e-01f, -1.18003249e-01f, 4.46292609e-02f, 9.15929750e-02f, 8.42707083e-02f, -3.25183682e-02f, -1.15489110e-01f, -7.21294135e-02f, 5.57925142e-02f,
  -4.37799515e-03f, -1.88282728e-02f, -1.08167872e-01f, -2.01669261e-02f, -2.41007246e-02f, -9.48036015e-02f, -7.92345405e-02f, 8.22063163e-02f, -8.15996081e-02f, -2.69397557e-01f,
  2.09263131e-01f, -2.59555459e-01f, 1.62247941e-01f, 3.91856164e-01f, 1.85220331e-01f, 2.62815535e-01f, 1.11342393e-01f, 1.38936117e-01f, 3.17547247e-02f, 5.27118668e-02f,
  1.00374669e-01f, 1.40640169e-01f, 1.32824346e-01f, 6.59307614e-02f, -2.50801034e-02f, 7.73117840e-02f, 4.78609651e-02f, 1.20819516e-01f, 2.22435549e-01f, 1.81656539e-01f,
  -1.06080258e-02f, -4.05665524e-02f, -6.47933409e-02f, 2.48179920e-02f, -7.71314353e-02f, 2.10798174e-01f, -5.40568009e-02f, -1.47071868e-01f, 2.91744303e-02f, 2.20657103e-02f,
  1.37589807e-02f, 1.97806470e-02f, 2.22723290e-01f, 4.46904488e-02f, -1.36155397e-01f, -3.14181820e-02f, 1.67846587e-02f, 2.15489976e-02f, 1.87507272e-02f, -5.39448671e-02f,
  -1.12723507e-01f, -9.52757150e-02f, -1.32103726e-01f, -2.28179812e-01f, -8.82129967e-02f, -1.12624951e-01f, -2.37125114e-01f, 3.58074605e-02f, 9.72657278e-02f, -1.07149845e-02f,
  8.11218843e-03f, -1.12712890e-01f, 5.21464907e-02f, 5.42326719e-02f, 1.13053858e-01f, -9.01203882e-03f, -4.61322721e-03f, -3.47159244e-02f, -5.39501905e-02f, -1.03156194e-01f,
  3.92074406e-01f, -2.92755626e-02f, -8.32691416e-02f, 7.57838264e-02f, -3.78418155e-02f, 1.85854789e-02f, 6.48083314e-02f, -5.42235598e-02f, -8.48105103e-02f, -1.93060100e-01f,
  -4.36405055e-02f, 2.48785287e-01f, 1.63812548e-01f, 8.15522447e-02f, 4.74103577e-02f, -2.64915843e-02f, -6.18171878e-02f, -3.07065211e-02f, -2.94506270e-02f, -5.03510982e-02f,
  -1.18096553e-01f, -6.89240992e-02f, -9.54709351e-02f, -1.39670208e-01f, -8.74367729e-02f, -8.97953752e-03f, 3.24530862e-02f, -1.96660422e-02f, -9.65555478e-03f, 3.10855010e-03f,
  6.18043579e-02f, 2.27097183e-01f, 2.14770257e-01f, -3.08837090e-02f, -7.47483149e-02f, -1.48864001e-01f, 1.51851639e-01f, -4.28299084e-02f, -6.91984408e-03f, 1.62892506e-01f,
  -5.93441501e-02f, -7.16235340e-02f, -2.05258191e-01f, -1.26775950e-01f, 4.82934061e-03f, -5.27666621e-02f, -1.69337988e-01f, 5.60962223e-02f, -2.05932017e-02f, -1.82833727e-02f,
  -9.67028067e-02f, 6.10652864e-02f, 1.28347099e-01f, 1.40025139e-01f, 1.84441760e-01f, 1.81351572e-01f, -5.99634834e-02f, 2.89954245e-02f, -2.04753480e-03f, -1.15268072e-02f,
  -2.53083825e-01f, 1.07305095e-01f, 5.08990474e-02f, -2.29647428e-01f, -1.57985315e-01f, -7.10118040e-02f, -4.31810059e-02f, -4.83218059e-02f, -1.78547740e-01f, -9.51742381e-02f,
  -3.41895111e-02f, 4.57514934e-02f, 1.23462930e-01f, 1.03655323e-01f, 3.42063718e-02f, 4.77862470e-02f, -4.88878004e-02f, 8.82426128e-02f, 5.81114590e-02f, -1.11291953e-03f,
  -3.24146450e-02f, -1.26769215e-01f, -1.08938143e-01f, -1.86174989e-01f, -1.12636328e-01f, 9.67284739e-02f, -1.07659109e-01f, -1.19168080e-01f, -1.10025316e-01f, -2.14692935e-01f,
  6.32244587e-01f, 7.22965300e-02f, 9.38988924e-02f, 7.82143623e-02f, 7.54652545e-02f, -8.57370943e-02f, 1.17344506e-01f, -3.15123498e-02f, -2.28160582e-02f, 3.24345231e-02f,
  -4.81197312e-02f, -2.43130932e-03f, -8.05252939e-02f, 3.98966670e-02f, 2.57423278e-02f, -1.06123179e-01f, -1.05645746e-01f, 4.79979850e-02f, 5.60732558e-02f, 1.74334392e-01f,
  2.92477962e-02f, 6.53446047e-03f, -3.00245062e-02f, 5.12975343e-02f, 8.41586366e-02f, -2.18158439e-02f, 9.18171629e-02f, -7.26848692e-02f, 3.38704102e-02f, -3.04690283e-02f,
  -4.73209359e-02f, 6.92511126e-02f, 6.24283329e-02f, -2.31606117e-03f, -1.48450676e-02f, -5.45361713e-02f, -2.26173047e-02f, 1.18990511e-01f, -2.64100032e-03f, -1.48958206e-01f,
  -6.66284636e-02f, -1.70454495e-02f, 6.57748729e-02f, -7.16602355e-02f, -4.92240638e-02f, -6.26041144e-02f, -2.02349853e-03f, 8.48843083e-02f, -8.15415457e-02f, -1.35199696e-01f,
  -5.03646880e-02f, 4.05802056e-02f, -5.92918545e-02f, -7.41944686e-02f, -1.64018720e-01f, 3.23701091e-03f, -8.91356468e-02f, -1.07960038e-01f, -1.50889605e-01f, -1.44127771e-01f,
  3.53905767e-01f, -5.87233566e-02f, -1.17498776e-03f, 8.52764025e-03f, -2.69390037e-03f, 8.65914766e-03f, -3.58584076e-02f, 1.01537883e-01f, 8.95726234e-02f, 9.25748348e-02f,
  1.35225490e-01f, 1.18927523e-01f, 4.56238687e-02f, 1.09203495e-01f, 1.41600124e-03f, 1.20939678e-02f, 2.58014742e-02f, 9.94024500e-02f, 4.84336875e-02f, 1.87484339e-01f,
  -5.19487821e-02f, -8.24362859e-02f, 1.22119546e-01f, 1.57995224e-01f, 1.99823052e-01f, 2.39411041e-01f, 1.42873541e-01f, 2.01760069e-01f, 9.57719311e-02f, 7.09246919e-02f,
  7.56376803e-01f, -3.66163850e-01f, -2.86741227e-01f, 5.12629710e-02f, -2.26702675e-01f, 4.41335589e-02f, -6.16162317e-03f, 1.63058639e-02f, 9.87058952e-02f, -1.86449170e-01f,
  -2.23697722e-01f, -5.68205304e-02f, -7.01602921e-02f, -1.34959146e-01f, -1.19787212e-02f, -1.31976202e-01f, -1.83197975e-01f, 9.58889723e-02f, 1.63463145e-01f, 5.05713820e-02f,
  -1.09802477e-01f, -4.08570189e-03f, 1.09450802e-01f, -1.17200367e-01f, -2.80898929e-01f, -1.27189830e-01f, -3.90077353e-01f, -9.75570008e-02f, -2.05414623e-01f, -3.14817637e-01f,
  -3.95014398e-02f, 1.77959744e-02f, 2.43001822e-02f, 2.75953896e-02f, -3.34727354e-02f, 7.27262869e-02f, -5.14972508e-02f, -1.72042232e-02f, 3.80959064e-02f, -9.24840756e-03f,
  -5.84090091e-02f, -8.09611306e-02f, 5.96294962e-02f, -5.27018234e-02f, 5.18746637e-02f, 1.12568945e-01f, -3.69176529e-02f, 1.62667744e-02f, -9.51402932e-02f, -9.76349600e-03f,
  -8.04669857e-02f, 1.68528855e-01f, 6.61263838e-02f, -5.74219264e-02f, 2.27929205e-02f, 1.83545351e-02f, 1.65941776e-03f, 7.22423345e-02f, 7.73852915e-02f, -1.59050506e-02f,
  -1.30283475e-01f, -2.92394124e-02f, -1.09199896e-01f, 6.18468411e-02f, 7.63285011e-02f, 7.82352500e-03f, 1.63790807e-01f, -4.44721291e-03f, 1.57878231e-02f, 6.95786923e-02f,
  -2.92190891e-02f, -6.97466880e-02f, -8.39468315e-02f, -1.30112067e-01f, -1.13375187e-01f, -2.34901141e-02f, -1.98861863e-02f, 6.01236671e-02f, -4.16274443e-02f, 5.97104542e-02f,
  1.44713297e-01f, 2.15973277e-02f, -9.63327512e-02f, -5.44749312e-02f, -4.37312014e-02f, -2.72649154e-02f, -4.94963750e-02f, -1.21580966e-01f, -1.19393490e-01f, 3.21254396e-04f,
  2.47212779e-02f, 6.55295178e-02f, 1.67260095e-01f, 1.02229342e-01f, 5.55526465e-02f, -3.93981226e-02f, -1.00616492e-01f, -9.39101875e-02f, 6.90277666e-02f, -4.42465059e-02f,
  -8.88678655e-02f, -1.35563556e-02f, -1.41473683e-02f, -1.23037901e-02f, 1.84041262e-01f, 5.69553748e-02f, 5.80610186e-02f, 1.33963272e-01f, -1.59631781e-02f, -7.64171034e-02f,
  -5.52286068e-03f, 2.17801452e-01f, 2.56936282e-01f, 4.29985151e-02f, 8.44708160e-02f, 2.76435256e-01f, 1.58254445e-01f, 1.19520478e-01f, 1.70308799e-01f, -1.65415350e-02f,
  -3.36639822e-01f, -1.83710977e-01f, -6.73042759e-02f, -9.49200839e-02f, 2.59555757e-01f, 1.73160553e-01f, -4.02247488e-01f, -4.29429770e-01f, -1.68556809e-01f, -1.29958332e-01f,
  3.52937318e-02f, 1.52819753e-01f, 1.59018442e-01f, 9.12687555e-02f, -1.95837215e-01f, -2.13623717e-01f, -5.25175147e-02f, 6.34081438e-02f, 1.18414812e-01f, 2.28752986e-01f,
  1.90440238e-01f, 1.25307813e-01f, 6.61190450e-02f, -6.36709481e-02f, -5.97615950e-02f, 7.85963088e-02f, 7.87230134e-02f, -2.20345706e-02f, 8.20940137e-02f, -9.16812718e-02f,
  1.54054254e-01f, -2.27206513e-01f, 2.72543907e-01f, 1.08385481e-01f, 1.03701293e-01f, -2.10944399e-01f, -5.48893586e-02f, -1.69773400e-01f, 2.66366228e-02f, -7.58425239e-03f,
  8.34962428e-02f, -2.73486990e-02f, 1.03030525e-01f, -1.03980657e-02f, 7.39484504e-02f, -2.27892160e-01f, 2.70817950e-02f, -1.57932684e-01f, -4.54978384e-02f, -1.40989184e-01f,
  3.19568031e-02f, 3.17486018e-01f, -9.42105800e-02f, -1.39319703e-01f, -3.44951659e-01f, 2.09500957e-02f, -8.35649148e-02f, -1.07366681e-01f, -1.14460871e-01f, -4.66975063e-01f,
  8.89548138e-02f, 2.56864112e-02f, 7.86362886e-02f, -5.17670885e-02f, -1.74431577e-01f, 6.20902665e-02f, 7.71972016e-02f, 1.36283487e-01f, 5.45375049e-02f, -1.19893789e-01f,
  5.39013445e-02f, 9.92738679e-02f, -3.08659188e-02f, -1.81966610e-02f, 5.63918203e-02f, 6.69354759e-03f, -1.35983294e-02f, 9.77938846e-02f, -1.02701355e-02f, -8.34593177e-03f,
  2.14275904e-02f, 4.23559733e-02f, 7.79871941e-02f, -1.54819135e-02f, -2.91312952e-02f, -3.29348892e-02f, -1.73731465e-02f, -3.02738715e-02f, -5.89213036e-02f, -1.46079296e-02f,
  -1.41154096e-01f, 1.92186594e-01f, -1.50209680e-01f, -1.94722414e-01f, 1.71846785e-02f, -1.84768438e-02f, -5.97177669e-02f, -2.16074870e-03f, -3.09430156e-02f, -1.07554473e-01f,
  -1.04954921e-01f, -7.78858960e-02f, -7.61356428e-02f, -8.67838413e-03f, -5.93269877e-02f, -5.59444204e-02f, -3.51618081e-02f, 9.57848579e-02f, 1.78272724e-01f, 6.33097515e-02f,
  -1.28500894e-01f, -1.61006212e-01f, -4.26600426e-02f, -1.96389407e-01f, 4.46146429e-02f, 4.25947504e-03f, -2.39840686e-01f, -1.01904005e-01f, -1.57078415e-01f, -6.19293213e-01f,
  1.22744136e-01f, -1.71875015e-01f, 1.16795339e-01f, 1.32224962e-01f, 5.84261343e-02f, 1.22101881e-01f, 2.00729687e-02f, -7.23412633e-02f, 7.79745951e-02f, -1.59870239e-03f,
  -8.91217813e-02f, 6.47614971e-02f, 6.17070459e-02f, 3.30217816e-02f, 8.42513368e-02f, -5.41580319e-02f, -2.88072284e-02f, 1.26082286e-01f, 4.44033816e-02f, 7.10850954e-02f,
  2.58606579e-02f, -1.27740562e-01f, -1.14302717e-01f, -1.32729590e-01f, 5.60351694e-03f, 1.71160027e-01f, -8.84535834e-02f, -1.64834082e-01f, -5.98048978e-02f, 3.90992425e-02f,
  3.87478501e-01f, 9.68749002e-02f, 2.57557154e-01f, 1.22592583e-01f, 8.75657722e-02f, 9.00214631e-03f, 1.29365847e-01f, 1.09373517e-01f, -2.33972189e-03f, -4.98854592e-02f,
  -1.91535056e-02f, -4.09029797e-02f, 8.28111991e-02f, -3.47369500e-02f, 2.44312305e-02f, -1.75672397e-02f, -1.30343884e-01f, -1.11208797e-01f, 7.89616778e-02f, 9.54873562e-02f,
  8.92928168e-02f, -4.91124913e-02f, -5.78556880e-02f, 4.07535583e-02f, -1.92385819e-02f, 1.39304042e-01f, 5.79506010e-02f, -4.83763032e-02f, -7.93934390e-02f, -7.21365213e-02f,
  -6.42445311e-02f, 1.00440130e-01f, 7.40529001e-02f, 5.01421690e-02f, 1.24579579e-01f, 1.71085566e-01f, 1.29020885e-01f, 1.76879037e-02f, -1.68434396e-01f, -5.04252613e-02f,
  -4.34012674e-02f, 8.59219879e-02f, 1.77480906e-01f, 5.05301319e-02f, -1.63726564e-02f, 5.33908755e-02f, 1.67112738e-01f, 4.66392040e-02f, -3.75616364e-02f, 1.60446111e-02f,
  -3.63431424e-02f, 4.39474620e-02f, 1.11555591e-01f, -8.26578811e-02f, -2.84873694e-02f, 5.45819625e-02f, 9.95600522e-02f, 4.67974097e-02f, 1.79517977e-02f, 2.19854321e-02f,
  1.49336800e-01f, 1.13088645e-01f, 1.53529152e-01f, -8.77496153e-02f, 5.31077832e-02f, 4.01205234e-02f, 1.15000911e-01f, 1.16080374e-01f, 2.15831175e-01f, 1.91265911e-01f,
  1.25192106e-01f, 1.20182820e-01f, 7.17690513e-02f, -6.46687970e-02f, 2.45148130e-02f, -4.55091819e-02f, 3.86866066e-03f, 1.42442599e-01f, 2.89320555e-02f, 5.06983474e-02f,
  -3.10748903e-04f, -2.34079957e-02f, 1.64230149e-02f, 9.26422402e-02f, 1.24444798e-01f, 2.08761975e-01f, 1.76383331e-02f, 1.60681263e-01f, -2.80640647e-02f, -1.26776978e-01f,
  -2.39838064e-02f, -1.66332975e-01f, -1.53889969e-01f, 2.44189993e-01f, -1.18934199e-01f, -5.96250147e-02f, -3.70623022e-01f, 1.65460985e-02f, 3.13218862e-01f, -3.23873192e-01f,
  -1.94997489e-01f, -4.15146872e-02f, -1.05369464e-01f, -1.72498807e-01f, -2.18475983e-01f, -4.75467891e-01f, -2.07569525e-01f, -2.12069601e-01f, 3.25414613e-02f, 2.02212874e-02f,
  -8.23881403e-02f, 5.33190817e-02f, 2.75736470e-02f, 4.42365892e-02f, -8.52556825e-02f, -1.44160599e-01f, -1.15010642e-01f, -8.31071287e-02f, -2.35738501e-01f, -2.50875354e-01f,
  -2.95936644e-01f, 7.86556900e-02f, 1.43378481e-01f, 1.16664343e-01f, 1.80003867e-02f, 1.62620693e-01f, -5.73572218e-02f, 4.77125235e-02f, 9.44301710e-02f, 4.16093273e-03f,
  -2.49449979e-03f, 1.50604211e-02f, 7.49332160e-02f, 6.23514839e-02f, 1.40288636e-01f, -2.48584803e-02f, 2.90370397e-02f, -3.29244882e-02f, 9.17744115e-02f, 1.03914171e-01f,
  -1.35836899e-01f, -5.13393432e-02f, -9.16474983e-02f, 9.49441865e-02f, 2.43463919e-01f, -5.72802834e-02f, 1.64723415e-02f, 2.10768357e-01f, -6.98685646e-02f, -2.23615065e-01f,
  3.78912762e-02f, -3.50913331e-02f, 3.66747528e-02f, -2.40755547e-02f, -2.78632827e-02f, -3.51713039e-02f, 5.49001023e-02f, -1.71944320e-01f, -9.31116194e-02f, -2.64683086e-02f,
  -4.69734706e-02f, -2.77987425e-03f, 7.16556832e-02f, -5.77633195e-02f, -7.84933269e-02f, 7.46491104e-02f, -1.34233847e-01f, -5.66622391e-02f, 3.94895487e-02f, -5.51677728e-03f,
  -4.13704738e-02f, 1.33889794e-01f, -9.38020740e-03f, 7.81013966e-02f, -8.72298516e-03f, -1.28981635e-01f, -4.48482446e-02f, -2.34466624e-02f, -7.79512525e-03f, -2.12911934e-01f,
  1.60968885e-01f, -1.50193414e-02f, -1.98048040e-01f, -9.48256813e-03f, 3.05509544e-03f, -5.03581949e-02f, 8.77693444e-02f, -2.13731676e-02f, -6.11184770e-03f, 8.76013562e-02f,
  6.99382946e-02f, -1.44506171e-01f, -6.66754320e-02f, -5.28278202e-02f, 6.56922609e-02f, 4.13056910e-02f, -1.46273941e-01f, -8.14559683e-02f, 5.12360595e-02f, 1.88393787e-01f,
  1.26915067e-01f, -1.95494831e-01f, -1.36350408e-01f, 4.24140086e-03f, 5.87548390e-02f, -1.71775281e-01f, -1.07604660e-01f, 3.54565494e-02f, -1.43573046e-01f, -4.12524104e-01f,
  -2.64478683e-01f, 8.32571015e-02f, -1.73268050e-01f, -8.74509010e-03f, 1.28137410e-01f, 3.91654484e-02f, 1.12628050e-01f, 1.42688779e-02f, -6.91610947e-02f, -1.73292935e-01f,
  7.22379610e-02f, 6.75688386e-02f, -1.00692837e-02f, -1.01643920e-01f, -1.79607078e-01f, -2.64732212e-01f, -2.14283571e-01f, -2.36206710e-01f, -1.47997543e-01f, 1.62594005e-01f,
  1.98943928e-01f, 1.29909143e-02f, -1.15897879e-01f, 4.97921072e-02f, -8.45648870e-02f, 2.95358375e-02f, -1.35790482e-01f, -2.12427422e-01f, 2.83485372e-02f, -2.39727363e-01f,
  -4.77984905e-01f, -9.72660035e-02f, 3.07859220e-02f, -1.25006393e-01f, 7.07005709e-03f, 9.82449874e-02f, 2.20617354e-01f, -5.17795756e-02f, 1.49162635e-01f, 4.74811308e-02f,
  6.27526492e-02f, 1.79332212e-01f, -3.50582821e-04f, -9.25720260e-02f, -5.05871102e-02f, -7.09035620e-02f, -1.85988937e-02f, 5.87707907e-02f, -1.22625388e-01f, 1.25929624e-01f,
  6.93967864e-02f, 4.44864109e-02f, -1.76237613e-01f, 2.73869131e-02f, -1.34778142e-01f, -6.05368577e-02f, 4.20292839e-02f, -1.41530558e-02f, -3.87827307e-02f, -3.15761589e-03f,
  6.31703958e-02f, 1.19572347e-02f, -3.36067639e-02f, 6.78133667e-02f, -5.59974015e-02f, 7.34730363e-02f, -1.53018730e-02f, -1.33054003e-01f, 5.46986535e-02f, -6.60293624e-02f,
  -5.42696007e-02f, -4.67248969e-02f, -8.07861239e-02f, -1.08511105e-01f, -5.38279563e-02f, -2.93004587e-02f, -1.16242386e-01f, -1.44652039e-01f, 3.41078895e-03f, -4.65107150e-02f,
  -1.32913232e-01f, -7.38739893e-02f, 1.61939766e-02f, 1.52660126e-03f, -6.11020401e-02f, -4.96301241e-02f, -1.24427930e-01f, -1.46108449e-01f, 1.77531362e-01f, 1.25628203e-01f,
  -1.98115595e-02f, 1.62820175e-01f, -9.36229080e-02f, -1.42249554e-01f, -2.22104475e-01f, -7.78819621e-02f, -3.14025432e-02f, -1.80290058e-01f, -2.06197888e-01f, -1.60917584e-02f,
  -3.43595520e-02f, -9.85575747e-03f, -8.57612118e-02f, 4.24304381e-02f, 2.00760569e-02f, -4.48731706e-02f, -3.32620181e-02f, -6.03743233e-02f, -7.29025975e-02f, -2.62156930e-02f,
  -1.59453183e-01f, -9.67924967e-02f, -2.45819405e-01f, -1.17114618e-01f, 5.52402884e-02f, 4.11363728e-02f, -1.48340100e-02f, 5.56838661e-02f, -8.15090686e-02f, 4.72645089e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 14)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 14;
const float L0_fan_Bp_bar_data[] = {
  1.36064254e-02f, -3.69777717e-02f, 7.53894597e-02f, 9.23732743e-02f, 1.88991183e-03f, 1.41468927e-01f, 6.97517321e-02f, -2.84722988e-02f, -1.24857724e-01f, -5.45451082e-02f,
  5.06242178e-03f, 1.83410719e-02f, -4.53386046e-02f, 4.22730297e-02f
};

// L1_fan_Wp (Shape: 25 x 64)
const int L1_fan_Wp_rows = 25;
const int L1_fan_Wp_cols = 64;
const float L1_fan_Wp_data[] = {
  -7.92401507e-02f, 5.20290844e-02f, 1.60956740e-01f, -1.19629884e-02f, -1.13337785e-01f, 9.28244814e-02f, 3.04285344e-02f, 7.67464489e-02f, 7.57051930e-02f, 2.53519583e-02f,
  1.40308663e-01f, -1.25371411e-01f, 1.71262905e-01f, 4.06308100e-02f, -1.36072263e-01f, 1.32098384e-02f, 1.25759887e-02f, -6.77608550e-02f, -3.79176885e-02f, 4.67435137e-04f,
  1.91201821e-01f, -1.50393203e-01f, 4.24383245e-02f, 2.94102225e-02f, -6.46239966e-02f, 1.33301601e-01f, 1.96175814e-01f, -7.18748569e-03f, 1.31794110e-01f, 7.12922364e-02f,
  -2.16525823e-01f, -1.16705835e-01f, -4.46546823e-01f, -6.27306327e-02f, -9.89485234e-02f, -9.23005641e-02f, -1.60408899e-01f, 1.98767498e-01f, 9.82895046e-02f, 1.99137367e-02f,
  -6.71195909e-02f, -9.62877795e-02f, -2.53588129e-02f, 1.93131894e-01f, 2.96456814e-01f, 3.91464494e-02f, -1.51064754e-01f, -3.25218588e-01f, 5.14260121e-02f, -3.29110101e-02f,
  -2.79963702e-01f, 1.05244778e-01f, 2.51445353e-01f, 1.16516739e-01f, -4.06335175e-01f, 1.29271463e-01f, 1.98502727e-02f, 6.69293478e-02f, -1.74088866e-01f, 1.52237862e-01f,
  -1.60609484e-01f, -7.06722587e-02f, 1.18083350e-01f, -1.07323006e-02f, -5.03847823e-02f, -3.41237001e-02f, 1.47434592e-01f, -3.94452512e-02f, 8.36421028e-02f, 8.54994059e-02f,
  3.32056247e-02f, -5.76344989e-02f, -3.21793021e-03f, 3.54240066e-04f, 7.49868155e-02f, 4.64107245e-02f, 7.25201741e-02f, 5.72609343e-02f, -1.32954810e-02f, -4.77457009e-02f,
  1.63810000e-01f, 1.27003744e-01f, 1.30072296e-01f, -1.74533099e-01f, -1.12307712e-01f, -2.78717540e-02f, -2.07460731e-01f, 1.13294572e-02f, 1.13169312e-01f, 1.38190582e-01f,
  1.51607707e-01f, -7.61703998e-02f, -3.38140763e-02f, 2.60360669e-02f, -1.87967420e-01f, -1.88433789e-02f, -3.70904028e-01f, -1.17183551e-01f, 1.80749986e-02f, 5.57725504e-02f,
  2.04384595e-01f, 7.47086480e-02f, 4.93723862e-02f, -1.86662123e-01f, 3.68450619e-02f, 1.13370590e-01f, -4.56359051e-02f, -8.93904120e-02f, 1.12053648e-01f, 3.89888659e-02f,
  -9.05495733e-02f, -1.44667342e-01f, -8.73352960e-02f, 2.90160388e-01f, -2.94274449e-01f, -2.15635583e-01f, 2.91370749e-01f, 1.52757704e-01f, -4.74024683e-01f, 1.62561625e-01f,
  1.64466128e-01f, 1.07359484e-01f, 1.01502351e-01f, 1.73098072e-01f, 2.33082678e-02f, 1.63241588e-02f, 2.21111149e-01f, 4.77790870e-02f, -5.83704263e-02f, 1.64474535e-03f,
  3.06418967e-02f, 5.06099872e-03f, 1.36227056e-01f, -1.20968349e-01f, -3.11167147e-02f, 3.19730781e-04f, -6.86711147e-02f, -2.74857599e-02f, -5.41231297e-02f, 1.04996911e-03f,
  -4.06378247e-02f, 2.15423238e-02f, 1.08906534e-02f, 3.87390219e-02f, 5.49684390e-02f, -7.98385292e-02f, -2.34092977e-02f, -6.54198080e-02f, 1.72026437e-02f, 6.42021000e-02f,
  -1.23223495e-02f, 2.57306080e-02f, 7.20070768e-03f, 3.74717750e-02f, -2.33771741e-01f, 1.72706153e-02f, -2.13752970e-01f, -1.47520512e-01f, 3.35171729e-01f, 2.60345846e-01f,
  3.73643517e-01f, 2.38182113e-01f, 7.85987917e-03f, -6.89322352e-02f, -1.24164313e-01f, -1.65740699e-01f, 1.42319426e-02f, -5.38901053e-02f, -2.06805877e-02f, 1.01138331e-01f,
  2.81453449e-02f, -2.83387192e-02f, -2.92097703e-02f, -1.18332155e-01f, -5.78173436e-02f, -3.88359986e-02f, -7.28011578e-02f, -1.85081154e-01f, 9.50628668e-02f, 1.98588714e-01f,
  -1.54516637e-01f, -2.45471954e-01f, 3.67971867e-01f, 8.24325066e-03f, 8.78443420e-02f, -1.64099976e-01f, -1.50765851e-01f, -1.80771515e-01f, 7.59470165e-02f, -1.47167668e-01f,
  8.57518390e-02f, -6.32613823e-02f, -4.09584492e-02f, 1.03097655e-01f, 1.46162631e-02f, 3.32506932e-02f, -8.09134170e-02f, -4.19073403e-02f, -4.29700986e-02f, -6.28967509e-02f,
  -7.72128068e-03f, -4.30678688e-02f, -7.03911632e-02f, -8.10479671e-02f, -2.92547137e-01f, -5.99434637e-02f, -6.99825436e-02f, 3.85776721e-02f, 3.32451500e-02f, -5.49838729e-02f,
  -1.14104301e-01f, 1.02488324e-02f, -1.30233616e-01f, -1.22545904e-03f, -8.69312733e-02f, -2.00770190e-03f, -3.18050161e-02f, 2.75269449e-01f, -3.31512764e-02f, -1.07224718e-01f,
  -3.16804685e-02f, 7.20491749e-04f, 9.79016498e-02f, 3.52014764e-03f, 2.03253940e-01f, 2.44275341e-03f, 2.11635772e-02f, -5.10724522e-02f, -1.00272171e-01f, 2.05890879e-01f,
  1.54762447e-01f, 5.79536669e-02f, 5.23599703e-03f, -1.55770667e-02f, 1.50261037e-02f, 1.98499411e-01f, 2.49580950e-01f, -1.11217694e-02f, -1.94691613e-01f, 7.55865350e-02f,
  -4.51959297e-02f, 6.18877783e-02f, -1.87794164e-01f, 4.06522453e-02f, 4.53005224e-01f, 6.83668032e-02f, 8.19970220e-02f, -3.62859517e-01f, 8.27732235e-02f, -1.17706120e-01f,
  -9.01947841e-02f, 2.02004939e-01f, -2.93966711e-01f, 1.42762825e-01f, 2.74219848e-02f, -3.19016516e-01f, 5.15514836e-02f, 2.27323896e-03f, -7.34274164e-02f, -5.06363474e-02f,
  -7.66393468e-02f, 6.68052733e-02f, 3.38277072e-02f, 4.17906530e-02f, -1.90741628e-01f, -5.80401905e-02f, 5.12068532e-02f, -1.06312752e-01f, 9.64214429e-02f, -1.60179481e-01f,
  8.03250074e-03f, 4.06188965e-02f, 9.04072635e-03f, -8.51320624e-02f, 7.05161765e-02f, 1.40012592e-01f, -5.10088019e-02f, -1.48949653e-01f, 6.23659827e-02f, 2.32028943e-02f,
  -2.10427940e-01f, 7.62282982e-02f, -8.61811684e-04f, 1.60955526e-02f, 1.31957620e-01f, 1.63255572e-01f, -4.25819568e-02f, -3.91654447e-02f, 7.04703331e-02f, -1.97403163e-01f,
  8.56091008e-02f, -8.77792537e-02f, -6.31534979e-02f, -7.30161443e-02f, -1.99227139e-01f, 1.69227466e-01f, -3.13105620e-02f, -1.18093506e-01f, -2.14187149e-02f, 2.87978381e-01f,
  -2.48241186e-01f, 4.05425698e-01f, -1.74188346e-01f, -1.79070979e-02f, -9.46774557e-02f, -1.18183844e-01f, -1.60712332e-01f, -1.08710498e-01f, -2.32067145e-02f, 1.42675042e-01f,
  1.86892912e-01f, -1.83614373e-01f, 1.16724074e-01f, -2.01746404e-01f, -1.12139940e-01f, -1.31953567e-01f, 3.47851068e-01f, 1.32244509e-02f, 1.26276717e-01f, 5.97016066e-02f,
  -1.52559169e-02f, -2.75561325e-02f, -4.17282432e-02f, -1.59655362e-01f, 7.59106949e-02f, 5.77197187e-02f, -1.07836165e-02f, 1.00854650e-01f, 2.15557009e-01f, 7.34274983e-02f,
  -5.06941043e-02f, 4.03950810e-02f, 1.13696093e-03f, 1.07035758e-02f, -5.61456010e-03f, 1.23343403e-02f, -7.78851807e-02f, 2.73925569e-02f, 3.11118402e-02f, -9.73202661e-02f,
  -6.18475431e-04f, 9.56328437e-02f, 1.17423190e-02f, -1.63879812e-01f, 6.79523721e-02f, -1.54933602e-01f, -1.55305708e-04f, 4.28935364e-02f, -8.97436142e-02f, 4.61208969e-02f,
  1.27532646e-01f, 2.20297761e-02f, 4.06085141e-02f, 5.06099612e-02f, -8.10367614e-02f, -1.53408632e-01f, -2.42646635e-02f, 1.40106156e-01f, 4.85530794e-02f, -3.80385597e-03f,
  1.31325368e-02f, 8.61720368e-03f, -5.53931780e-02f, 3.21051218e-02f, -2.16969308e-02f, -4.51414324e-02f, -1.40214309e-01f, 1.46642372e-01f, 5.16830496e-02f, -1.79723911e-02f,
  1.42484829e-01f, -3.47294174e-02f, -1.02126390e-01f, -2.36518592e-01f, 1.29743293e-01f, -4.63285409e-02f, 1.30097300e-01f, 6.45900294e-02f, -2.01661766e-01f, -2.89430112e-01f,
  3.28529894e-01f, -1.17870746e-02f, 2.13146672e-01f, 1.07908145e-01f, -2.43041031e-02f, 4.66762856e-03f, 4.35835235e-02f, -5.49974479e-02f, 1.61895938e-02f, -1.57182246e-01f,
  -3.20384093e-02f, 1.63153291e-01f, -8.66493657e-02f, -3.60947289e-02f, -6.19833060e-02f, 1.80109665e-02f, -1.30201131e-01f, 7.63177201e-02f, 2.70040426e-02f, 2.27774195e-02f,
  5.30704185e-02f, 6.93456382e-02f, 1.80428196e-02f, -1.40886396e-01f, -1.09359764e-01f, -1.62159801e-01f, 1.03253320e-01f, -5.13793528e-02f, -2.61115935e-03f, -2.36618266e-01f,
  -5.82370311e-02f, 1.03880286e-01f, -8.41812342e-02f, -5.19756190e-02f, -1.67441461e-02f, -1.84585929e-01f, 9.47093666e-02f, 2.71827653e-02f, -5.15506901e-02f, 2.63950285e-02f,
  -6.96070790e-02f, -1.85166985e-01f, 8.15757215e-02f, 3.56112681e-02f, -6.11642450e-02f, 3.41736786e-02f, -1.51274830e-01f, -1.88320130e-01f, -2.25430410e-02f, -6.18187636e-02f,
  1.45612387e-02f, 4.50934516e-03f, -3.07652261e-02f, -1.89896435e-01f, 1.22682393e-01f, 2.38944441e-02f, -1.29343107e-01f, 1.14324987e-01f, 3.81062180e-02f, -5.06730936e-02f,
  -8.32293034e-02f, 1.40866861e-01f, 1.82078063e-01f, 4.39911224e-02f, -3.54680181e-01f, 1.79754078e-01f, -2.41887316e-01f, -7.37983063e-02f, -1.30160496e-01f, -2.32660502e-01f,
  2.15776991e-02f, -1.52383566e-01f, -2.36416887e-03f, 1.47285797e-02f, -2.32564937e-02f, 1.09592173e-02f, 5.43513298e-02f, 1.22533605e-01f, 5.01033105e-02f, -5.42082265e-02f,
  5.57096414e-02f, -1.41022384e-01f, -8.76176357e-02f, -9.58013237e-02f, -2.75228843e-02f, 2.08305325e-02f, -3.96084301e-02f, -1.65868565e-01f, -1.66321024e-01f, 1.82330329e-02f,
  9.30030085e-03f, 1.81503803e-01f, -1.44041907e-02f, -3.63036208e-02f, 1.24547496e-01f, -2.13241965e-01f, 4.10695635e-02f, 1.46840602e-01f, 1.20631270e-01f, 4.82603610e-02f,
  -7.00761154e-02f, 1.71943352e-01f, 1.07319169e-01f, -1.70664787e-01f, 4.85175699e-02f, 1.99178874e-01f, 3.17760110e-02f, 9.59023833e-02f, 8.77554789e-02f, -7.47447163e-02f,
  -2.55451687e-02f, 1.76177934e-01f, -1.31921127e-01f, 1.32876607e-02f, 8.88417363e-02f, -1.17131718e-01f, 1.51633713e-02f, 1.31111696e-01f, -1.32002801e-01f, -2.45668769e-01f,
  1.12201363e-01f, -2.14335844e-01f, -3.40592186e-03f, 2.92983681e-01f, 2.83624947e-01f, -2.52994031e-01f, -1.21201485e-01f, 3.05222988e-01f, 1.46581188e-01f, -1.59961078e-02f,
  9.40038040e-02f, 1.93179607e-01f, -5.78668565e-02f, -1.59017324e-01f, -1.27016753e-02f, 6.64897040e-02f, 4.18677032e-02f, -2.32503667e-01f, -5.17000891e-02f, 7.61753991e-02f,
  -2.22655293e-02f, -1.00305721e-01f, 1.44896105e-01f, 3.67508195e-02f, -6.09486364e-02f, -2.67458837e-02f, -3.20355147e-02f, -1.15777170e-02f, -2.23225906e-01f, -1.20087698e-01f,
  -2.69084238e-02f, -5.74539900e-02f, -2.70632678e-03f, 1.50303140e-01f, -2.48827077e-02f, -2.42796019e-02f, -1.56844668e-02f, 1.22193791e-01f, -1.16924077e-01f, -3.84054929e-02f,
  -2.28006259e-01f, -1.39489263e-01f, 1.89889416e-01f, 1.23873845e-01f, 3.60256016e-01f, 3.01050693e-01f, 4.24421579e-02f, -9.12849009e-02f, -3.94799374e-03f, -3.12399119e-02f,
  8.09834674e-02f, -4.69517149e-02f, -1.42121658e-01f, -1.75987873e-02f, -5.10297939e-02f, 1.24337308e-01f, 2.14184523e-01f, -1.85716569e-01f, -2.40082398e-01f, 2.56908715e-01f,
  9.36729237e-02f, 6.71472177e-02f, 1.15191847e-01f, -2.27441154e-02f, -1.72415510e-01f, -1.06714301e-01f, 4.88193423e-01f, 1.40889376e-01f, 3.73928398e-02f, 4.41630706e-02f,
  -7.76162297e-02f, -1.20859772e-01f, -3.78344618e-02f, -8.55974331e-02f, 1.54524177e-01f, -1.22616380e-01f, -3.50615442e-01f, -5.62152080e-02f, -1.36516944e-01f, -1.44959345e-01f,
  8.66572373e-03f, 3.67851071e-02f, -6.09116666e-02f, -1.38843238e-01f, -1.05126753e-01f, 5.08113019e-02f, -1.83887929e-01f, -1.12178646e-01f, -7.02686375e-03f, 3.15847732e-02f,
  -1.00713432e-01f, -1.27202675e-01f, -1.70762345e-01f, -1.19829595e-01f, 1.55607969e-01f, -1.45213649e-01f, -1.17419496e-01f, -5.08480184e-02f, -3.92961828e-03f, 3.61104980e-02f,
  1.55447274e-01f, -2.00982749e-01f, -9.86349061e-02f, 3.65121253e-02f, -1.12875201e-01f, -2.03034773e-01f, -1.11780278e-01f, -1.31451696e-01f, -6.41903207e-02f, 2.35482469e-01f,
  -9.78114232e-02f, -8.87941346e-02f, 1.68162584e-01f, 7.19135553e-02f, -7.35633448e-02f, -1.11721888e-01f, 7.52257407e-02f, 2.78845411e-02f, 1.61882252e-01f, -2.13990450e-01f,
  -1.81352109e-01f, -1.87529624e-01f, 1.35429092e-02f, 2.79480040e-01f, -4.31464612e-02f, 1.65852144e-01f, 8.38656649e-02f, 1.04528880e-02f, -2.72984624e-01f, -1.80989876e-01f,
  -3.82796079e-02f, 1.90171525e-01f, -1.18051525e-02f, 1.52299702e-01f, -5.19801900e-02f, -1.97189972e-01f, -2.59686224e-02f, -1.49897441e-01f, 1.51068062e-01f, 2.11190924e-01f,
  1.08655142e-02f, 9.17676650e-03f, 1.82174459e-01f, 1.06815509e-02f, -1.16889141e-01f, -5.02721639e-03f, 5.68493977e-02f, -9.56694484e-02f, 9.09300968e-02f, 5.39071374e-02f,
  1.58333808e-01f, 4.08710614e-02f, 2.79873699e-01f, 1.76954821e-01f, -1.04208872e-01f, 2.23866012e-02f, 9.90902185e-02f, -6.94026873e-02f, 1.23239189e-01f, -2.74284333e-02f,
  6.71182275e-02f, 4.53267284e-02f, 6.88698962e-02f, -8.40984061e-02f, 7.43270293e-02f, 4.95407060e-02f, 1.11684846e-02f, 3.47544104e-02f, -3.05717122e-02f, -1.06676206e-01f,
  -1.13553464e-01f, 1.37592569e-01f, -2.97646463e-01f, 1.69056073e-01f, 4.39305753e-02f, 4.55695465e-02f, 1.57153279e-01f, 1.32686734e-01f, -1.26751184e-01f, 9.10601690e-02f,
  -9.27685052e-02f, -2.14576088e-02f, -2.64554694e-02f, 2.97924161e-01f, -2.52830774e-01f, 3.49188000e-01f, 7.68397050e-03f, -8.62748623e-02f, 5.33703156e-02f, -1.07080322e-02f,
  -2.82697558e-01f, -1.57921717e-01f, 2.43664652e-01f, -8.33826065e-02f, 7.96847492e-02f, 1.18281350e-01f, 6.75875396e-02f, -3.20932530e-02f, -2.38203138e-01f, 1.10767642e-03f,
  1.25995614e-02f, -2.74301499e-01f, 1.06039472e-01f, 6.26646578e-02f, -4.14132932e-03f, 8.81652981e-02f, 4.15694974e-02f, -7.64358565e-02f, -5.03953770e-02f, 1.07213497e-01f,
  1.95029583e-02f, -2.97850333e-02f, -1.02012940e-01f, -2.71863583e-02f, -4.21981281e-03f, 7.73356035e-02f, 1.25730395e-01f, -1.20723814e-01f, 1.00059718e-01f, 2.05754060e-02f,
  9.35429614e-03f, -6.93313479e-02f, 6.93809912e-02f, -9.42702219e-02f, -2.80217044e-02f, 3.81962173e-02f, -1.41684309e-01f, -2.28281282e-02f, -7.09487572e-02f, -8.50665104e-03f,
  1.70603190e-02f, 1.45528605e-02f, 4.61647753e-03f, 8.90643373e-02f, -8.04623365e-02f, -9.45272893e-02f, -2.30295524e-01f, -1.52723074e-01f, 6.64875954e-02f, 3.81133370e-02f,
  1.22023122e-02f, -4.08896171e-02f, -3.79605651e-01f, -1.51724845e-01f, 1.23530269e-01f, 1.28421023e-01f, 1.38340473e-01f, 1.29688323e-01f, -2.94790059e-01f, 1.61503345e-01f,
  3.39266332e-03f, 1.21178754e-01f, 6.51557967e-02f, 1.33663610e-01f, -3.37690152e-02f, 5.28239682e-02f, 6.55992478e-02f, -1.37254670e-01f, 7.23358169e-02f, 1.76024616e-01f,
  -5.58919087e-02f, 1.06959946e-01f, -7.25378469e-02f, -2.55622193e-02f, 6.99696392e-02f, -1.17288955e-01f, 6.60831034e-02f, -5.77759072e-02f, -2.69852742e-03f, 3.52454484e-02f,
  -1.46946236e-01f, -6.08811565e-02f, -9.54793692e-02f, -5.13054319e-02f, 2.73356983e-03f, 8.98402631e-02f, -6.24939986e-02f, -8.95511582e-02f, 2.08351370e-02f, -6.27788529e-02f,
  -1.88582182e-01f, 7.27071464e-02f, 5.24002500e-02f, -4.91619212e-05f, -3.20153423e-02f, -4.68884818e-02f, -1.79624021e-01f, -2.40385812e-02f, 5.47276959e-02f, -1.09054940e-02f,
  1.94731325e-01f, -4.57327515e-02f, 4.99244966e-02f, -1.38164517e-02f, 2.04142090e-02f, -3.43294591e-02f, -1.13546677e-01f, -1.88454837e-02f, 1.89499915e-01f, -5.97116128e-02f,
  2.81190753e-01f, -5.74298389e-02f, -8.72376487e-02f, -7.94737488e-02f, 4.37902622e-02f, -2.54158285e-02f, 2.92747676e-01f, 3.80522460e-02f, -1.86523963e-02f, -1.07468180e-01f,
  3.89083438e-02f, -3.94504815e-01f, 2.23782465e-01f, -2.46279776e-01f, 2.08332110e-02f, 2.59696133e-02f, -2.97062527e-02f, -1.02376096e-01f, 2.16126725e-01f, 2.64044181e-02f,
  -2.17813924e-01f, 2.33613625e-01f, -2.41976842e-01f, -1.17713600e-01f, -1.27116859e-01f, -1.13446772e-01f, 1.75050244e-01f, -1.06406389e-02f, -2.04667836e-01f, -6.81007653e-02f,
  -1.54355526e-01f, -5.00817001e-02f, 3.56422849e-02f, 1.56247944e-01f, -1.24485344e-02f, -1.21657290e-02f, 5.83644062e-02f, -8.13815817e-02f, 3.92848030e-02f, 1.27123162e-01f,
  -1.43483296e-01f, -4.47409712e-02f, 8.17645267e-02f, 4.58429568e-02f, 8.73513743e-02f, -3.17470990e-02f, 6.52261153e-02f, -6.15614913e-02f, 5.04664145e-02f, 8.22339356e-02f,
  7.99890384e-02f, -2.73734152e-01f, 1.26015544e-01f, -1.48080841e-01f, 1.02842540e-01f, -1.15561588e-02f, 4.82050478e-02f, 7.40231350e-02f, 6.51975051e-02f, -2.15946138e-02f,
  1.23018153e-01f, -6.26122206e-02f, -2.19569698e-01f, 7.51645193e-02f, -5.30475145e-03f, 1.67532116e-01f, -7.45537505e-02f, -7.39578111e-03f, -4.46146727e-03f, 2.16752395e-01f,
  1.07221715e-01f, -3.01656649e-02f, 5.51508963e-02f, -9.32037756e-02f, 9.47242603e-02f, -1.46541715e-01f, -1.40260518e-01f, -1.19587459e-01f, 3.73970382e-02f, -3.69488224e-02f,
  7.40348622e-02f, -5.88453189e-02f, -5.76148368e-02f, 3.94345000e-02f, 2.43006554e-02f, 2.08859503e-01f, 5.86933717e-02f, -9.84812826e-02f, -2.19939798e-01f, -1.68384202e-02f,
  1.88879684e-01f, 1.93191409e-01f, -2.77127206e-01f, -9.74056646e-02f, -2.68546760e-01f, -9.01734680e-02f, 4.66797082e-03f, -1.95339732e-02f, 8.04655924e-02f, -3.62719186e-02f,
  2.86203604e-02f, -5.80977928e-03f, 9.12397578e-02f, 1.64780412e-02f, -1.27030775e-01f, -1.28182307e-01f, -9.04805139e-02f, -1.35421023e-01f, 9.20563564e-02f, 9.03534815e-02f,
  3.22174542e-02f, -3.35836112e-02f, -7.94724002e-02f, -2.94825528e-02f, -9.70711559e-02f, 8.23414028e-02f, 4.36415197e-03f, 3.49954925e-02f, -3.98261659e-02f, 3.74994725e-02f,
  -1.05351165e-01f, 5.92554174e-02f, -9.72786546e-02f, -5.06712049e-02f, 2.46464252e-01f, -2.44859643e-02f, -1.73360050e-01f, 8.97816792e-02f, -1.68956116e-01f, 6.79805651e-02f,
  1.07883692e-01f, 1.23544589e-01f, -2.26402923e-01f, -6.19008811e-03f, -2.38090217e-01f, -1.93689726e-02f, 4.60061952e-02f, -1.97379127e-01f, -6.90517714e-03f, 8.41480121e-02f,
  -1.32483765e-01f, 2.94004306e-02f, 6.71423823e-02f, -3.16873968e-01f, 7.35396799e-03f, 6.09407760e-03f, 6.06449880e-02f, 3.05889491e-02f, 3.65129709e-02f, 3.53172682e-02f,
  -1.33361995e-01f, 2.30782211e-01f, 4.62409519e-02f, 3.15175094e-02f, 1.31561503e-01f, 2.44167134e-01f, -2.70210862e-01f, 1.12009726e-01f, -1.93834212e-02f, -5.47207445e-02f,
  6.80767670e-02f, -4.45483811e-02f, -1.36842122e-02f, -6.00300170e-02f, 6.29741922e-02f, -3.84587534e-02f, 6.19394034e-02f, -8.16815868e-02f, -2.50249244e-02f, 1.37997240e-01f,
  -2.73100622e-02f, -1.72828317e-01f, 1.06315628e-01f, -1.09065488e-01f, 9.53477342e-03f, 6.96251169e-02f, 9.26640406e-02f, -3.00147384e-02f, -4.70139738e-03f, 4.35873605e-02f,
  -2.75806952e-02f, 2.41419021e-02f, 6.35986477e-02f, -9.37338620e-02f, -1.36348963e-01f, -1.15856841e-01f, 4.97789681e-02f, 1.14580885e-01f, 8.68074074e-02f, 1.27723128e-01f,
  -1.18772432e-01f, 2.52688918e-02f, -1.14021607e-01f, -5.05064093e-02f, -5.79218827e-02f, 8.74769837e-02f, 2.12904900e-01f, 2.65201181e-01f, 1.05014160e-01f, 1.35756880e-01f,
  6.05008230e-02f, -1.06882975e-01f, -1.86262745e-02f, 1.87564999e-01f, -1.10218242e-01f, -4.60023358e-02f, -5.82554378e-04f, -4.09640484e-02f, 5.51379807e-02f, 1.63257331e-01f,
  1.72464371e-01f, -2.66702056e-01f, 2.23026142e-01f, -1.34083301e-01f, -4.72581610e-02f, 2.86130816e-01f, 1.14662744e-01f, -9.96621624e-02f, -5.59911244e-02f, 1.41610086e-01f,
  -4.17615520e-04f, -5.16477339e-02f, -6.30425289e-02f, 4.32389155e-02f, 3.67086679e-02f, 4.87106331e-02f, 5.88487089e-02f, 1.40952721e-01f, 1.22764692e-01f, -2.32938677e-02f,
  -1.91834554e-01f, 1.43212974e-01f, -7.56465569e-02f, 1.50722275e-02f, -8.87573842e-05f, -1.89443156e-01f, -1.51459187e-01f, -2.28092708e-02f, -5.77812083e-03f, 3.76711972e-02f,
  1.35419592e-01f, -4.63419296e-02f, 3.34333181e-02f, -1.44467294e-01f, -5.18593378e-03f, -8.52287188e-02f, -8.24890658e-02f, 8.32854956e-02f, 2.81617753e-02f, 8.38763192e-02f,
  -9.78910998e-02f, -8.70999992e-02f, -1.40525296e-01f, -2.38230489e-02f, -4.39685807e-02f, 4.79407385e-02f, 1.79967228e-02f, 2.07787067e-01f, -9.87049341e-02f, 8.25367197e-02f,
  6.20495640e-02f, 8.01908597e-02f, 7.40965158e-02f, -1.61683008e-01f, 3.70995747e-03f, -9.73219499e-02f, 3.98860909e-02f, 1.60640240e-01f, -1.22561321e-01f, 1.69093892e-01f,
  -1.50159299e-01f, -3.32948044e-02f, 6.66777492e-02f, -9.73637477e-02f, -1.15801968e-01f, 1.55545160e-01f, 2.42941231e-01f, 2.88117528e-01f, 6.66991547e-02f, -2.15953022e-01f,
  -1.02213323e-01f, 1.40524998e-01f, 8.56767148e-02f, 1.75636727e-02f, -2.48332798e-01f, 1.49887592e-01f, 3.21773551e-02f, 1.69525314e-02f, -6.78365752e-02f, 1.62378065e-02f,
  -2.24202033e-02f, 1.76672533e-01f, 8.55026022e-02f, 6.45822426e-03f, -7.38888234e-03f, 2.02747747e-01f, 1.88211929e-02f, 6.58442080e-02f, -8.81477520e-02f, -1.55295590e-02f,
  5.22101708e-02f, -3.16781737e-02f, -1.84410252e-02f, 4.18951027e-02f, 1.09827206e-01f, -2.66433507e-02f, 1.37075201e-01f, -2.66689748e-01f, -8.29046741e-02f, 1.20152473e-01f,
  -2.01765895e-02f, 6.55824915e-02f, -9.10619274e-03f, 2.75733192e-02f, -1.40915856e-01f, -1.13614209e-01f, -2.72259772e-01f, -1.29430033e-02f, -4.94636130e-03f, 1.53124392e-01f,
  2.03192785e-01f, 2.80307621e-01f, 1.21254258e-01f, -1.00201294e-01f, -3.85044664e-02f, 4.52848896e-02f, 5.36651276e-02f, -1.16671761e-02f, -1.61627918e-01f, 7.56883249e-02f,
  4.59650457e-02f, 1.57366186e-01f, -2.28201598e-01f, 8.28231499e-02f, -5.35347015e-02f, 1.99244946e-01f, 1.61530506e-02f, -3.13728908e-03f, -4.50351179e-01f, 4.11657356e-02f,
  -9.38148331e-03f, 2.03731492e-01f, 3.93875629e-01f, -1.41716987e-01f, -2.29832977e-01f, -1.46378621e-01f, -1.06923603e-01f, 4.28262465e-02f, -8.66957903e-02f, -7.95613881e-03f,
  8.59938040e-02f, -6.28425032e-02f, 1.44299760e-01f, 2.21745878e-01f, 3.88885587e-02f, 1.65171251e-01f, -1.73827261e-02f, -1.95537955e-02f, 9.50640589e-02f, 4.49318718e-03f,
  -5.07504269e-02f, -2.23197136e-02f, 4.55101812e-03f, -8.43665302e-02f, -7.83096626e-02f, 6.34567514e-02f, -1.04126073e-01f, 2.57375151e-01f, 7.25968629e-02f, 1.85602512e-02f,
  -1.30861789e-01f, -4.71031778e-02f, 1.23158433e-01f, 6.65998682e-02f, 2.56273821e-02f, 4.92655635e-02f, -8.74308869e-02f, 8.20348933e-02f, -1.28548101e-01f, 5.09591028e-02f,
  1.19459204e-01f, 1.57068148e-02f, 8.82726759e-02f, 4.49515581e-02f, 1.55607685e-01f, -6.78548068e-02f, 8.49747751e-03f, -5.32162823e-02f, -2.09769998e-02f, -1.87376648e-01f,
  8.77746716e-02f, -3.68694775e-02f, -1.57841340e-01f, -1.33897185e-01f, -1.55578051e-02f, -1.72554240e-01f, 1.32451057e-01f, 1.45149361e-02f, 6.71955524e-03f, -5.36843762e-02f,
  1.03575923e-01f, -2.12762699e-01f, -8.33484530e-02f, 1.15237489e-01f, -2.24276707e-01f, 2.26526901e-01f, 1.63178310e-01f, -1.78433433e-01f, -5.41819595e-02f, -8.26453343e-02f,
  -1.95099443e-01f, -1.67527542e-01f, -7.15896338e-02f, -5.63423932e-02f, -1.24325819e-01f, 4.23041098e-02f, -6.96725845e-02f, -1.50241479e-01f, 9.45432186e-02f, -7.55676925e-02f,
  -2.34765895e-02f, -7.72543112e-03f, -1.08687980e-02f, -4.38102446e-02f, 4.35658842e-02f, -7.82477781e-02f, -4.03815880e-02f, -1.04724057e-01f, -2.79396892e-01f, -6.07261769e-02f,
  8.40448737e-02f, 4.84466646e-03f, -1.48513652e-02f, -1.47620723e-01f, -1.00746498e-01f, -3.85471457e-03f, -7.02430308e-02f, 1.47607908e-01f, -2.88755774e-01f, 1.28710866e-02f,
  1.76002290e-02f, 1.14314094e-01f, -8.10136274e-02f, -1.10001259e-01f, -2.43286237e-01f, -1.06516697e-01f, 2.80963868e-01f, 9.83150005e-02f, 2.32661769e-01f, 1.24949031e-01f,
  1.28964320e-01f, 8.59327465e-02f, -1.52203962e-01f, -2.14100927e-01f, 3.62632386e-02f, 8.06123465e-02f, -1.07290864e-01f, -2.34754339e-01f, -9.26026180e-02f, 6.98615611e-02f,
  1.25839775e-02f, -1.33790985e-01f, -3.61260809e-02f, -2.67088294e-01f, -9.98570994e-02f, -2.99535822e-02f, 1.03747748e-01f, 2.78579704e-02f, -1.19328657e-02f, -3.80986392e-01f,
  1.67700335e-01f, -2.00241921e-03f, 3.20814997e-01f, -1.66802466e-01f, -1.67305902e-01f, -1.30477607e-01f, 3.68631542e-01f, -1.32402599e-01f, 1.19746178e-01f, 2.14528307e-01f,
  1.49986921e-02f, -6.68637753e-02f, -5.31065091e-02f, -1.09823242e-01f, 1.86336990e-02f, -7.88555220e-02f, -7.13066086e-02f, 6.04793802e-02f, -9.41811949e-02f, -9.95440334e-02f,
  -2.85949782e-02f, 1.71780512e-02f, -8.87060314e-02f, 7.72667080e-02f, -4.09465991e-02f, -2.05814722e-03f, 5.40504232e-02f, 1.06481224e-01f, -1.25963300e-01f, -1.80560410e-01f,
  8.21200386e-02f, 3.33048292e-02f, 4.82208095e-02f, 3.44018117e-02f, 5.36780320e-02f, -6.85487757e-04f, -1.14130713e-01f, 5.39300963e-02f, -9.70834494e-02f, -1.43515989e-01f,
  6.90246327e-03f, 8.28465912e-04f, 3.08004022e-01f, 5.91172799e-02f, 1.51340887e-01f, 6.74810112e-02f, -9.89101231e-02f, -3.15188289e-01f, -4.80974540e-02f, 5.85515723e-02f,
  -1.21330559e-01f, 1.12600867e-02f, -1.79755352e-02f, 5.18505787e-03f, -6.87699616e-02f, -2.94733606e-02f, -9.11836140e-03f, -4.09654379e-02f, -7.54667222e-02f, -2.07465515e-01f,
  -1.75288823e-02f, 7.75100738e-02f, -2.22269461e-01f, -1.98022882e-03f, 3.16582948e-01f, -2.52389938e-01f, -2.68770307e-01f, -9.47028250e-02f, 3.45748314e-03f, -1.26261517e-01f,
  -2.38200463e-02f, 1.41532883e-01f, -1.65332511e-01f, -1.00439213e-01f, -2.32049879e-02f, 2.17680499e-01f, -1.02120243e-01f, -3.75770181e-02f, -3.98948081e-02f, 1.83757231e-01f,
  -8.86782110e-02f, 2.97361836e-02f, 1.27011493e-01f, 3.09055094e-02f, 4.69866991e-02f, -1.06695145e-01f, 4.68065962e-02f, -1.03309378e-01f, -1.52253553e-01f, -3.43246311e-02f,
  -2.46746406e-01f, -7.27448687e-02f, 9.88396481e-02f, 9.36329067e-02f, 6.08787090e-02f, -1.37917725e-02f, 1.06274724e-01f, 7.69588724e-02f, 2.48243157e-02f, 1.08796172e-01f,
  1.56016186e-01f, -6.81350529e-02f, 3.47569548e-02f, -2.34702340e-04f, -1.93512797e-01f, -1.95613116e-01f, -4.63065743e-01f, 1.16300113e-01f, 1.30144596e-01f, -7.46137872e-02f,
  -2.40610540e-02f, 6.65129256e-03f, -1.51979461e-01f, -5.74879833e-02f, -6.50660545e-02f, -1.96651369e-01f, 8.92896727e-02f, 3.68965566e-01f, -1.44191965e-01f, 2.78557330e-01f,
  -9.03105065e-02f, -3.70140970e-02f, -6.34520799e-02f, -1.01825431e-01f, -4.57447410e-01f, -2.08940939e-03f, 2.56877154e-01f, 1.56326190e-01f, -8.44129026e-02f, -1.18272707e-01f,
  5.75408861e-02f, 5.84350042e-02f, 3.01822405e-02f, 1.62936226e-01f, 6.96877809e-03f, 1.26420617e-01f, 3.37932855e-01f, -1.12038448e-01f, -7.25216046e-02f, 5.34499921e-02f,
  -2.18262941e-01f, 3.18738893e-02f, 4.32292819e-02f, -5.13164625e-02f, 4.13431898e-02f, 1.66746899e-01f, -1.38238743e-01f, -1.55676842e-01f, -1.29787862e-01f, 2.48654634e-02f,
  -1.19521283e-01f, -5.10548502e-02f, -1.60424709e-01f, -2.49886233e-02f, -1.17798388e-01f, -1.74064450e-02f, -5.36911264e-02f, -4.46659466e-03f, -3.82461287e-02f, 4.30680178e-02f,
  -2.17264593e-02f, 1.73837729e-02f, -1.37925357e-01f, 1.70909718e-01f, -1.08449422e-01f, -7.24188834e-02f, -2.64964160e-02f, -5.02281263e-02f, -5.25800847e-02f, -1.02403387e-01f,
  1.68828398e-01f, 1.55288965e-01f, -2.06768867e-02f, -5.14804609e-02f, -6.91868365e-02f, 7.41953030e-02f, 2.37848341e-01f, -1.27532199e-01f, 1.18760064e-01f, -7.55975246e-02f,
  -6.25891685e-02f, -6.44431040e-02f, 2.43152365e-01f, -1.57865912e-01f, -2.11715065e-02f, -4.87698205e-02f, 7.20662177e-02f, -4.98499237e-02f, -1.57160953e-01f, -1.15490913e-01f,
  -2.58811146e-01f, -2.00159829e-02f, -2.27732193e-02f, -2.12246746e-01f, -2.81748712e-01f, 2.09200829e-02f, 1.49103016e-01f, 3.74410078e-02f, -3.23964179e-01f, 8.12935308e-02f,
  4.86296751e-02f, -4.08509932e-02f, -7.00273318e-03f, 9.83941704e-02f, -6.79598004e-02f, -3.45083214e-02f, -7.26627419e-03f, -2.51234639e-02f, -2.90295184e-02f, 9.86903757e-02f,
  7.93850496e-02f, -7.86246452e-03f, 1.17635511e-01f, 1.78412907e-02f, -1.21846788e-01f, 1.11123264e-01f, -4.33396362e-02f, -9.44468006e-02f, -1.57095924e-01f, -1.47462547e-01f,
  5.64396568e-02f, 1.71574533e-01f, 5.02588972e-02f, 1.40062589e-02f, 8.90200958e-02f, 1.39655560e-01f, -1.65043265e-01f, 1.34922341e-01f, 1.70415595e-01f, -1.64019421e-01f,
  1.58968300e-01f, -6.41925260e-04f, -1.85953483e-01f, -2.84743309e-02f, -3.62643064e-03f, 1.17041804e-01f, 3.31056379e-02f, -1.44056246e-01f, 1.64056178e-02f, 2.67016560e-01f,
  2.16755643e-01f, -2.58208415e-03f, -9.31129828e-02f, -1.32055338e-02f, -8.03003162e-02f, 1.74975827e-01f, 2.76592553e-01f, -3.22456583e-02f, -1.04233049e-01f, 6.19923957e-02f,
  4.57402831e-03f, 2.89806779e-02f, -2.40225568e-01f, 5.10840863e-02f, 1.52345523e-01f, 8.39735717e-02f, -1.01225659e-01f, -8.84911697e-03f, -1.73161373e-01f, -1.47784680e-01f,
  -1.90670013e-01f, 2.53403902e-01f, -4.17366922e-01f, -1.05211355e-01f, 1.50290802e-01f, -3.03485453e-01f, -9.08660367e-02f, 6.61496297e-02f, -5.75234815e-02f, -6.09798245e-02f,
  3.56875733e-02f, -1.58208400e-01f, 8.40354785e-02f, -1.62602682e-02f, -3.66043262e-02f, 5.36607951e-02f, -4.03490029e-02f, 4.24172655e-02f, 1.10586427e-01f, 4.81045246e-02f,
  4.08005789e-02f, 4.67695249e-03f, 1.97450235e-01f, 4.56908606e-02f, -1.39401019e-01f, -1.88838214e-01f, -1.02920212e-01f, -4.18001972e-02f, 8.79467875e-02f, -1.26184300e-01f,
  -1.40266144e-03f, -5.97266033e-02f, 4.92077656e-02f, -1.82226580e-02f, 4.63023186e-02f, 5.83125278e-02f, -1.53053179e-01f, 3.79155353e-02f, -1.29685104e-01f, 7.93899000e-02f,
  -2.05991920e-02f, 3.88154089e-02f, -1.93045307e-02f, 6.72539920e-02f, 3.14480072e-04f, -3.09303794e-02f, -4.36510332e-02f, 1.38291121e-01f, 9.83966067e-02f, 4.21123505e-02f,
  7.10766166e-02f, -9.58101600e-02f, -9.39595252e-02f, -3.84889767e-02f, -3.67497467e-03f, 8.76225382e-02f, -1.51517957e-01f, 1.59338415e-01f, 3.52970779e-01f, -7.71316364e-02f,
  -3.98665041e-01f, -2.84186956e-02f, -1.17142200e-01f, 7.63490647e-02f, -1.62739068e-01f, 3.54452282e-02f, -1.76919684e-01f, 3.92389037e-02f, -7.19434544e-02f, 1.02135502e-01f
};

// L1_fan_Wp_bar (Shape: 14 x 64)
const int L1_fan_Wp_bar_rows = 14;
const int L1_fan_Wp_bar_cols = 64;
const float L1_fan_Wp_bar_data[] = {
  -5.83491549e-02f, 1.77795097e-01f, -9.44595933e-02f, 1.89308170e-02f, -2.89969463e-02f, 9.76954103e-02f, 1.56920761e-01f, -3.49491984e-02f, -3.17795128e-02f, 2.51064338e-02f,
  1.09131575e-01f, 6.88272808e-03f, -3.29883434e-02f, 1.61903352e-01f, 1.13986388e-01f, -6.77002817e-02f, 1.27171502e-01f, 1.38221771e-01f, 4.74063195e-02f, 2.54274681e-02f,
  1.69910535e-01f, 1.82547234e-02f, 1.08577155e-01f, 3.49373110e-02f, 7.60721564e-02f, 1.78896934e-01f, -6.65896609e-02f, -2.19344020e-01f, -3.06679383e-02f, -1.11158483e-01f,
  2.42531270e-01f, -8.72715414e-02f, 1.92741349e-01f, 2.03512814e-02f, 3.40679474e-02f, 2.25749947e-02f, -9.09234434e-02f, -2.81418432e-02f, 1.06641322e-01f, -1.76861361e-01f,
  -4.06313948e-02f, -1.62594318e-01f, 3.89653780e-02f, -1.00953698e-01f, 1.14694931e-01f, -1.90955475e-01f, -7.96641782e-02f, -1.83749333e-01f, 5.98484240e-02f, -1.40656263e-01f,
  -2.34122295e-02f, 2.08821923e-01f, -1.28719509e-01f, -9.72808599e-02f, 1.82075221e-02f, -2.35539690e-01f, -2.18399972e-01f, 8.18833113e-02f, 1.47982061e-01f, -1.47537544e-01f,
  -2.57070184e-01f, 1.76785693e-01f, -3.32698524e-01f, -2.54919708e-01f, 8.54934379e-02f, 1.39955487e-02f, -6.87545091e-02f, 1.12288501e-02f, 2.01922566e-01f, -7.49741569e-02f,
  5.11097014e-02f, 1.19591139e-01f, 1.51166648e-01f, 6.68168962e-02f, -1.23402234e-02f, 7.07030250e-03f, 8.95187706e-02f, 5.15357628e-02f, 1.52733535e-01f, 8.48837048e-02f,
  -1.08838700e-01f, 9.24792737e-02f, 1.34142816e-01f, 9.08470154e-03f, 2.21426427e-01f, -6.23149844e-03f, 1.06493697e-01f, 6.80487137e-03f, 1.25209078e-01f, -2.85840452e-01f,
  2.04703987e-01f, 5.79837598e-02f, 3.86013743e-03f, -2.35724002e-01f, -3.45676839e-02f, -1.27541676e-01f, -5.19668050e-02f, 2.16981053e-01f, -2.20503598e-01f, -2.08404571e-01f,
  5.76963052e-02f, 4.88542467e-02f, -8.87213834e-03f, -8.73191804e-02f, -1.13774389e-01f, 1.01096466e-01f, -5.89834452e-02f, -4.50888216e-01f, 8.22356716e-02f, -3.72979969e-01f,
  5.85648939e-02f, 1.59787148e-01f, 2.00822905e-01f, 4.49491329e-02f, 2.60504395e-01f, -1.59876689e-01f, -3.37485015e-01f, 1.68283671e-01f, 2.15191096e-02f, 2.64617383e-01f,
  -4.51500118e-02f, 4.17080000e-02f, -4.14160937e-02f, -1.21609913e-02f, -9.89709496e-02f, -2.64308155e-01f, -5.04448116e-02f, 1.02926046e-01f, 5.87929823e-02f, 2.13395521e-01f,
  2.25368906e-02f, -1.85328797e-01f, 8.93087760e-02f, 8.75116885e-02f, 2.69322079e-02f, 5.72920665e-02f, 1.22894250e-01f, -1.40564367e-01f, 1.42387189e-02f, -1.18234336e-01f,
  -8.49054530e-02f, 1.55317849e-02f, -8.01602527e-02f, 6.74828067e-02f, 4.74849604e-02f, -8.03195909e-02f, -1.52621672e-01f, 2.88328901e-02f, 4.42093648e-02f, 3.82540859e-02f,
  5.28428145e-02f, 9.38544497e-02f, -1.50627717e-01f, 8.42356682e-02f, -1.89618033e-03f, -8.74335468e-02f, -2.22986750e-02f, -1.48695603e-01f, -2.27451771e-02f, 9.11884531e-02f,
  3.13100107e-02f, 2.63814688e-01f, -8.54710340e-02f, -4.07693833e-02f, -5.52496389e-02f, 2.32627869e-01f, 1.03720643e-01f, -6.13849871e-02f, -1.89896636e-02f, -3.04745972e-01f,
  -7.54461065e-02f, 3.52482721e-02f, 3.64853919e-01f, -2.01322958e-01f, -6.18413240e-02f, -2.12689772e-01f, -5.62283434e-02f, 4.01679203e-02f, -3.13669235e-01f, 2.41947360e-02f,
  -6.87946603e-02f, 1.11254297e-01f, 1.62409768e-02f, -1.51230618e-01f, -3.12811434e-01f, 9.82874706e-02f, 9.66100097e-02f, -7.46438205e-02f, -3.94700348e-01f, -3.74472998e-02f,
  -1.41694412e-01f, -2.23512113e-01f, -5.30055678e-03f, 2.29792669e-02f, 9.44926962e-02f, -9.53239799e-02f, 1.33093283e-01f, 9.13552567e-02f, -3.43186520e-02f, -5.59399202e-02f,
  -6.08663820e-02f, -1.21156871e-02f, 6.73785061e-03f, 1.93325698e-01f, 2.60672927e-01f, 6.80025369e-02f, 1.54894416e-03f, 2.47531161e-02f, 1.22094378e-02f, 3.97681631e-02f,
  9.81512368e-02f, 1.19458415e-01f, 9.47159678e-02f, -3.20328139e-02f, 1.78158488e-02f, 1.43891335e-01f, 1.27021044e-01f, -2.83498824e-01f, -1.52115062e-01f, 1.77348405e-02f,
  -6.06297813e-02f, -7.35777691e-02f, 7.10724667e-02f, 9.73160565e-02f, -1.57745704e-02f, 1.33243084e-01f, 4.21125218e-02f, 8.25134292e-02f, 1.47696584e-01f, -4.87267449e-02f,
  -1.08569175e-01f, -9.00036022e-02f, 5.94674796e-02f, 5.03316298e-02f, -6.91751949e-03f, 1.25854807e-02f, -3.63260537e-01f, -4.85457852e-02f, -1.73190720e-02f, -1.52276978e-01f,
  2.34914348e-02f, -1.76920451e-03f, 2.19080284e-01f, -1.71215281e-01f, -2.99683422e-01f, 5.09899668e-03f, 1.30274266e-01f, 2.64673799e-01f, 2.30135754e-01f, -3.26182246e-01f,
  1.09603070e-01f, 3.70945409e-02f, 1.10200539e-01f, 7.97436759e-02f, 2.91915685e-01f, 1.59707949e-01f, 9.33129713e-02f, 2.44819373e-03f, 9.20391455e-02f, 9.36985984e-02f,
  1.20914198e-01f, -2.65090484e-02f, 7.75080025e-02f, -2.71583218e-02f, 3.76437791e-02f, 2.88259480e-02f, 1.03823639e-01f, 6.91852197e-02f, 1.76080734e-01f, 1.25211582e-01f,
  2.59095758e-01f, 3.93552408e-02f, 8.50704014e-02f, 1.81732774e-02f, 6.65287822e-02f, 1.39089346e-01f, 2.10925832e-01f, -7.71956593e-02f, 1.79543748e-01f, 9.43712592e-02f,
  -3.38235907e-02f, -5.72491959e-02f, 3.23261209e-02f, 6.02625944e-02f, 9.39336664e-04f, 6.11300133e-02f, -1.09003223e-01f, 8.07460994e-02f, -5.34822233e-02f, -2.26666629e-01f,
  8.51961151e-02f, 5.11820167e-02f, 6.12639859e-02f, -2.57198922e-02f, -8.38969052e-02f, -7.79653713e-03f, 6.93933740e-02f, 5.53952530e-02f, 1.26248598e-01f, -6.70221224e-02f,
  -1.86577678e-01f, 1.48860961e-01f, 1.05379589e-01f, -1.86111346e-01f, -2.18761507e-02f, -2.95496937e-02f, 2.36792918e-02f, 3.95197809e-01f, 3.39591712e-01f, 1.69010296e-01f,
  -2.46313259e-01f, 5.79320639e-02f, -1.12039328e-01f, 1.91147178e-01f, -9.36861709e-02f, -6.00661477e-03f, 2.28029415e-01f, 1.69630665e-02f, -1.18239313e-01f, 2.02827603e-01f,
  -3.82856876e-02f, -2.00327784e-01f, 3.32696736e-02f, -1.10837176e-01f, -6.69276714e-02f, 1.54723883e-01f, -7.73990452e-02f, -1.20714400e-02f, 1.75905861e-02f, 3.31813673e-04f,
  2.28806399e-02f, -2.46901847e-02f, 1.13736182e-01f, -1.92086585e-02f, -1.72787178e-02f, -1.13006152e-01f, 3.32048908e-02f, -1.03935711e-01f, -1.17936142e-01f, 4.54294728e-03f,
  3.07459477e-03f, -3.48728038e-02f, 4.49462235e-02f, -4.42409366e-02f, 9.22458321e-02f, 1.65690958e-01f, 6.33019730e-02f, -7.66535327e-02f, -1.05919968e-02f, -3.03155389e-02f,
  -1.68649912e-01f, 1.04298532e-01f, -2.63385534e-01f, -4.31254460e-03f, 4.69995663e-02f, 9.65802073e-02f, 3.20745334e-02f, 1.97210893e-01f, -7.06041604e-02f, -1.82022639e-02f,
  -1.43933389e-02f, 2.86909956e-02f, -1.17392493e-02f, 2.14192882e-01f, -1.36704687e-02f, 1.42675042e-01f, -1.27540022e-01f, -1.98578656e-01f, 3.79890800e-02f, 2.25141898e-01f,
  -1.97323203e-01f, -2.65979413e-02f, 3.36425036e-01f, -2.09046632e-01f, -3.40353131e-01f, 7.52494186e-02f, 1.13827117e-01f, 1.19397312e-01f, 6.78751394e-02f, -2.84419078e-02f,
  3.77654396e-02f, -6.12218457e-04f, 1.55929998e-01f, -8.29282477e-02f, -1.53592676e-01f, 3.05674583e-01f, 1.52937263e-01f, 7.95225501e-02f, -4.37661028e-03f, 1.20157100e-01f,
  -5.02313264e-02f, 7.50115439e-02f, 1.46953564e-03f, 2.22452749e-02f, 1.19540602e-01f, 5.68584576e-02f, 2.40978003e-01f, 8.64599347e-02f, -4.05520312e-02f, 1.79544762e-01f,
  8.14278945e-02f, 8.39784145e-02f, 1.76156908e-01f, -8.17467496e-02f, 6.89183641e-03f, 1.77521899e-01f, 1.33447900e-01f, -5.42940646e-02f, 4.86827120e-02f, -9.05256420e-02f,
  -1.66942999e-01f, -1.77723803e-02f, -4.77463342e-02f, 1.56329144e-02f, -7.39703625e-02f, 4.20687459e-02f, 2.04174593e-02f, 2.61575609e-01f, -7.76546896e-02f, -3.66483554e-02f,
  -1.11241207e-01f, -8.72539505e-02f, -8.36267620e-02f, -6.92016259e-02f, -8.11506584e-02f, 2.53989808e-02f, 1.93930548e-02f, 5.24104536e-01f, -4.09899801e-01f, 1.90824911e-01f,
  5.34516852e-03f, 2.83717483e-01f, 8.45486822e-04f, -1.26254424e-01f, -1.97191194e-01f, -3.47130001e-02f, -4.42023814e-01f, 1.45054325e-01f, 6.00628793e-01f, -1.07422553e-01f,
  -1.20683666e-02f, -9.30157304e-02f, -2.02347144e-01f, 1.61404833e-02f, -2.99315024e-02f, -7.78693007e-03f, 2.05035225e-01f, 1.46515325e-01f, 7.52513707e-02f, 1.43462017e-01f,
  5.91362081e-02f, 5.19567132e-02f, 2.98576318e-02f, -1.04260743e-01f, 7.81883970e-02f, -5.88925444e-02f, 1.84912197e-02f, 6.31571561e-02f, 2.61198357e-02f, 6.99242800e-02f,
  1.17260203e-01f, 9.95192379e-02f, 2.38329127e-01f, -1.28002288e-02f, 1.99606135e-01f, -3.03584225e-02f, -4.86597493e-02f, 1.65689170e-01f, -6.70577437e-02f, -1.28812283e-01f,
  3.67426649e-02f, 4.48503532e-02f, -5.98757900e-02f, 7.36719521e-04f, 2.68205166e-01f, -8.35201964e-02f, 5.15604764e-02f, -1.22705951e-01f, -2.49712333e-01f, 5.90883829e-02f,
  -3.63309950e-01f, -7.69765228e-02f, -1.01022124e-01f, -1.83605105e-01f, 1.92267567e-01f, 1.33498618e-03f, 1.80419385e-01f, -6.13587871e-02f, 4.65982929e-02f, -2.26653386e-02f,
  2.79922813e-01f, -1.88315079e-01f, -1.60100594e-01f, -6.52484000e-02f, -2.93120015e-02f, 1.34331927e-01f, 1.71914045e-02f, -7.19739944e-02f, -1.73194990e-01f, 1.49437800e-01f,
  -9.16953851e-03f, 3.90525430e-01f, -3.60065699e-01f, 9.43714604e-02f, 5.30899838e-02f, -1.20965280e-01f, -5.16953766e-02f, -7.74122700e-02f, -1.39717594e-01f, 6.48544803e-02f,
  -8.86208490e-02f, 5.11777215e-03f, -4.73480411e-02f, -1.00956345e-02f, -8.86505544e-02f, -3.06236856e-02f, -1.25703171e-01f, 6.91247582e-02f, -9.75342616e-02f, 3.54856327e-02f,
  8.05471912e-02f, 6.21665157e-02f, 4.52525020e-02f, 9.64775030e-03f, 2.35166565e-01f, 6.42599240e-02f, -1.00517631e-01f, 3.88526954e-02f, -2.73459367e-02f, -4.67137322e-02f,
  1.89542510e-02f, 1.72068179e-01f, 8.32786411e-02f, 1.26817644e-01f, 2.53804587e-02f, 2.00374145e-02f, -1.21125557e-01f, 8.27447176e-02f, 1.06651440e-01f, -1.19656995e-02f,
  3.64025861e-01f, 1.44119024e-01f, -4.39911755e-03f, 5.89292794e-02f, -7.68501014e-02f, -1.91692367e-01f, 1.38343930e-01f, -5.61482050e-02f, -2.66421676e-01f, 6.32266179e-02f,
  -1.77872732e-01f, 2.08238810e-01f, -2.59593129e-01f, -3.08573723e-01f, -3.33915502e-01f, 4.18489158e-01f, 7.18102604e-02f, 3.78432184e-01f, 5.21403477e-02f, -1.64016724e-01f,
  -2.21050262e-01f, -4.97236513e-02f, -2.11834148e-01f, -8.27790126e-02f, -6.22685365e-02f, -1.68057367e-01f, 4.98505235e-02f, -2.49305651e-01f, -8.06809068e-02f, -1.37758762e-01f,
  -3.10226470e-01f, -2.34263062e-01f, 3.37130278e-01f, -2.24112555e-01f, 1.07169017e-01f, -7.39711076e-02f, 5.65728806e-02f, 3.92885171e-02f, -6.99120462e-02f, 6.04181886e-02f,
  8.68340060e-02f, -1.93667576e-01f, -4.72176895e-02f, 3.80314104e-02f, -3.85604464e-02f, 6.09180368e-02f, -1.40215382e-02f, 7.73882493e-02f, 1.16424374e-01f, 3.05534266e-02f,
  1.26211479e-01f, 1.18552648e-01f, 5.73033579e-02f, 1.28452882e-01f, -5.23200929e-02f, -9.92668346e-02f, 7.70439953e-02f, 2.61887815e-02f, 1.29928440e-01f, -2.05068663e-03f,
  3.64797898e-02f, 6.45211563e-02f, -1.46399289e-01f, 1.05605677e-01f, -1.66651860e-01f, 4.54612002e-02f, 1.54808328e-01f, 5.24963178e-02f, 2.13108793e-01f, -9.88698900e-02f,
  -5.85454777e-02f, 4.83705364e-02f, 3.22192870e-02f, -2.12683484e-01f, 1.25844288e-03f, 5.57451285e-02f, 3.22154239e-02f, 1.53013855e-01f, 2.49659307e-02f, -4.06027466e-01f,
  5.41981421e-02f, -8.60041752e-02f, 4.65108864e-02f, 8.88773948e-02f, -9.57181603e-02f, 2.41738893e-02f, 5.33253908e-01f, 9.00757164e-02f, -3.28437746e-01f, -1.65645406e-02f,
  2.28635117e-01f, 2.25768954e-01f, 1.19875938e-01f, -1.19227402e-01f, 7.42063150e-02f, -1.45683467e-01f, 2.89864302e-01f, -2.03808141e-03f, 3.06222886e-02f, 7.76339546e-02f,
  -1.53208330e-01f, -5.11304252e-02f, 1.12426400e-01f, 5.94734326e-02f, -2.88601443e-02f, 1.48056716e-01f, 1.74499266e-02f, 5.36622573e-03f, -3.13809551e-02f, 1.35208249e-01f,
  -8.89667645e-02f, 1.64989501e-01f, 1.83839783e-01f, -1.00205705e-01f, 2.27469783e-02f, -8.83232877e-02f, 1.07787466e-02f, 5.18781729e-02f, 1.04272768e-01f, 6.37070686e-02f,
  7.57303759e-02f, 8.10627788e-02f, -1.54027133e-03f, 5.71240894e-02f, -9.85859111e-02f, 1.92168355e-01f, 1.99497834e-01f, -7.40298331e-02f, -1.06909558e-01f, 2.01682895e-02f,
  -4.96617407e-02f, 2.26721540e-02f, -1.52697712e-01f, -8.94519165e-02f, 2.47460008e-02f, -7.89529607e-02f, 5.77865634e-03f, 1.27115756e-01f, -1.08451761e-01f, 1.61720499e-01f,
  -1.64439172e-01f, -7.23621994e-02f, -1.24913929e-02f, 3.08754295e-01f, 2.12927032e-02f, 1.75805748e-01f, 8.53268988e-03f, -1.88864432e-02f, 8.81200954e-02f, 2.56099217e-02f,
  -2.89946824e-01f, -2.48186260e-01f, 3.30310732e-01f, -1.59251854e-01f, -5.65501511e-01f, -5.71574830e-02f, 1.44973814e-01f, 8.96272585e-02f, 1.72630817e-01f, 2.40792826e-01f,
  1.63054854e-01f, 2.27844253e-01f, 4.09754701e-02f, -3.63972187e-02f, -6.69564260e-03f, 3.95528115e-02f, -7.18617141e-02f, 7.65656531e-02f, 3.05125892e-01f, 1.25864446e-01f,
  8.73204379e-04f, -1.50963133e-02f, -4.64268290e-02f, 3.00291460e-02f, -2.29957420e-02f, 1.19270533e-01f, -8.28865170e-02f, 3.14238928e-02f, 5.20453230e-02f, 1.61249533e-01f,
  -3.59631777e-02f, -1.06726801e-02f, -2.20232621e-01f, 2.50376850e-01f, 9.64550748e-02f, -5.34348097e-03f, 1.49187699e-01f, 6.72694296e-02f, -4.16708142e-02f, 5.23859225e-02f,
  -2.30371729e-01f, 6.11996055e-02f, 1.51808262e-01f, -4.29039188e-02f, 1.18155874e-01f, -7.33590052e-02f, 4.11471948e-02f, -1.13562085e-01f, 8.20540786e-02f, 1.16883554e-01f,
  -2.44526938e-01f, -6.04551472e-03f, 1.58658288e-02f, -9.76093709e-02f, -9.97165567e-04f, -8.42965618e-02f, 3.91577408e-02f, 4.93602082e-02f, -1.30212858e-01f, -2.22601108e-02f,
  -4.48502377e-02f, -1.68400273e-01f, 8.74924101e-03f, -9.18209702e-02f, -9.76322740e-02f, 1.64873317e-01f, 2.79402230e-02f, 1.04833551e-01f, -2.98615894e-03f, -4.11361419e-02f,
  -3.34197521e-01f, 1.25867426e-01f, 7.88971260e-02f, 4.11591344e-02f, -1.89906701e-01f, -6.71956837e-02f, -1.16246715e-01f, -1.13372125e-01f, 2.52299868e-02f, 1.46385312e-01f,
  1.20530240e-01f, 1.70417666e-01f, 7.71670267e-02f, 6.32940233e-03f, 4.54598060e-03f, 1.65673196e-01f, 1.63790211e-01f, 1.11798681e-01f, 3.01646888e-02f, -1.13417879e-02f,
  1.52034834e-01f, 8.58552307e-02f, -3.71386483e-03f, 5.18989414e-02f, -1.10153839e-01f, -9.25757140e-02f, -2.00196281e-01f, 2.55215615e-01f, 1.39956355e-01f, 8.87990221e-02f,
  1.48712113e-01f, -1.70845364e-03f, -6.02845401e-02f, 3.04564446e-01f, 2.61577461e-02f, -2.05968633e-01f, 1.68446586e-01f, -1.25174476e-02f, -3.94256599e-02f, 1.19888119e-01f,
  6.12359419e-02f, 2.34931678e-01f, 1.87946469e-01f, -9.31318030e-02f, -1.09110750e-01f, 2.73249269e-01f, 1.65133238e-01f, 9.26220864e-02f, -1.41946867e-01f, -4.03006315e-01f,
  -2.91785091e-01f, -7.18509406e-02f, 4.42217499e-01f, 2.68593691e-02f, -1.47698045e-01f, -2.52092659e-01f, -9.56336632e-02f, -6.86983392e-02f, -9.43015143e-02f, 6.94156513e-02f,
  2.71189846e-02f, 6.19254708e-02f, 9.75483805e-02f, -3.32174093e-01f, -1.17189968e-02f, -9.53143537e-02f, -1.96437359e-01f, -2.02531312e-02f, -5.50062433e-02f, -8.70008767e-02f,
  -7.69854859e-02f, -5.51312789e-02f, 1.01425461e-01f, -8.97056907e-02f, -1.27763271e-01f, 1.51779726e-01f, 4.56652530e-02f, 1.47903878e-02f, 5.64219169e-02f, 9.39717144e-02f,
  2.61582971e-01f, 8.88745040e-02f, 1.74795985e-01f, 2.29414999e-01f, -7.61335492e-02f, 1.56826422e-01f, 6.58468390e-03f, -2.16738079e-02f, 5.94550446e-02f, 2.22826913e-01f,
  1.47368297e-01f, -1.74100846e-01f, 6.25487715e-02f, -8.77139270e-02f, 1.53977886e-01f, 7.14702606e-02f, 2.01794401e-01f, 4.46608774e-02f, 1.95699871e-01f, -1.51446268e-01f,
  4.55014743e-02f, 4.96304557e-02f, -2.01868594e-01f, -2.30900973e-01f, 3.21164131e-02f, 1.19610958e-01f, -9.10175517e-02f, -1.86868250e-01f, 1.97604984e-01f, 3.39213878e-01f,
  4.27240074e-01f, -8.19108263e-02f, -7.81830624e-02f, 1.14863113e-01f, -1.16253316e-01f, -2.56430745e-01f, 3.81838381e-01f, -3.13422173e-01f, -9.69169512e-02f, 2.25113958e-01f,
  -1.54196873e-01f, -7.04675913e-02f, -1.65681720e-01f, -2.29653805e-01f, -2.79352278e-01f, 2.42191121e-01f, -4.59801964e-02f, 7.89273009e-02f, -6.34322539e-02f, 1.20967090e-01f,
  -2.48130649e-01f, 2.93089986e-01f, 3.48133668e-02f, -1.75284490e-01f, -4.75766249e-02f, 3.15484335e-03f
};

// L1_fan_Bp_bar (Shape: 1 x 14)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 14;
const float L1_fan_Bp_bar_data[] = {
  7.36748334e-03f, 1.11889001e-02f, 1.44819856e-01f, -9.75853112e-03f, 7.62988180e-02f, -1.70482025e-01f, 7.94782713e-02f, 9.88327041e-02f, -6.94447234e-02f, -1.68098081e-02f,
  3.93902212e-02f, 4.81035523e-02f, 2.12718591e-01f, 1.68571681e-01f
};

// L2_fan_Wp (Shape: 25 x 64)
const int L2_fan_Wp_rows = 25;
const int L2_fan_Wp_cols = 64;
const float L2_fan_Wp_data[] = {
  8.06161761e-02f, 1.82027012e-01f, 2.00762689e-01f, -1.34013575e-02f, -7.67235011e-02f, 1.83860898e-01f, 1.27683282e-01f, 2.09530964e-02f, -2.22131476e-01f, 9.27387625e-02f,
  1.19054951e-01f, -8.79537198e-04f, 2.47052893e-01f, 1.03713974e-01f, 1.50484130e-01f, 6.89704418e-02f, 4.19022366e-02f, 3.49579863e-02f, 2.45523170e-01f, 1.36926040e-01f,
  -1.03445956e-03f, 1.15214065e-02f, 8.67090095e-03f, -1.01087123e-01f, 1.23724341e-01f, -9.52815935e-02f, -1.30896568e-01f, 2.09047988e-01f, -2.07911450e-02f, 3.74274313e-01f,
  2.23061830e-01f, -1.69465289e-01f, 1.38322830e-01f, -2.32597273e-02f, 9.43607986e-02f, 1.51357323e-01f, -2.00224519e-01f, -1.14522442e-01f, 3.07909306e-02f, -6.75856844e-02f,
  3.77163035e-03f, -1.73409343e-01f, 8.92341286e-02f, -1.04818374e-01f, 1.56238973e-01f, 7.22071668e-03f, 8.79721567e-02f, 1.05169257e-02f, -1.00705652e-02f, 3.78574803e-02f,
  -2.48722851e-01f, 1.14250459e-01f, 8.61807466e-02f, -2.02312529e-01f, -1.15391880e-01f, -9.86434743e-02f, 2.76592016e-01f, -1.62632316e-01f, 3.37512255e-01f, -1.91659689e-01f,
  -2.15609372e-01f, -1.00572638e-01f, 1.07085079e-01f, 9.45833474e-02f, -1.17455371e-01f, 1.84214756e-01f, -2.51011819e-01f, 5.63315675e-02f, -7.02018440e-02f, -2.33878210e-01f,
  3.61015022e-01f, -5.69634326e-02f, 5.01657538e-02f, 5.61520793e-02f, -6.54377118e-02f, 3.21857780e-02f, 5.35784326e-02f, 6.95656165e-02f, 2.78727990e-02f, 1.43497407e-01f,
  7.91632384e-03f, 2.19543606e-01f, -1.78288609e-01f, 1.21942818e-01f, 6.37505576e-02f, 1.73865125e-01f, 4.32195552e-02f, -4.25425097e-02f, 1.20137341e-01f, -2.12272197e-01f,
  -1.78313881e-01f, 1.51453480e-01f, 9.45179388e-02f, 1.14979945e-01f, -3.43199372e-02f, -4.64051180e-02f, 2.25615814e-01f, 1.52261347e-01f, -2.08389789e-01f, -1.04095683e-01f,
  -2.04503193e-01f, 3.47186364e-02f, -2.30217017e-02f, -1.47779435e-01f, -3.44842337e-02f, 3.29742372e-01f, 2.46050015e-01f, 1.62358806e-01f, 8.32183808e-02f, -1.54491395e-01f,
  -8.75898078e-02f, 1.51303690e-02f, 2.53566295e-01f, 5.21382950e-02f, 1.67079508e-01f, -1.30910695e-01f, -8.03312510e-02f, -1.90686986e-01f, 2.86233462e-02f, -5.32367826e-03f,
  1.21545136e-01f, 3.30754258e-02f, -1.57228202e-01f, -1.22492872e-02f, -8.88820887e-02f, 2.42185686e-02f, 2.40282327e-01f, 1.81101486e-01f, 1.55027986e-01f, -1.32164173e-02f,
  -2.72633493e-01f, 7.40027577e-02f, 2.08656583e-02f, -2.11815387e-02f, -7.46238083e-02f, 1.64205115e-02f, -5.40695079e-02f, 1.57281741e-01f, 1.92643717e-01f, 1.28274381e-01f,
  -1.00825191e-01f, 5.78028001e-02f, -1.65116549e-01f, -2.15684739e-03f, -8.58591497e-03f, -1.28652662e-01f, -1.41775876e-01f, -1.47622809e-01f, -6.54654875e-02f, 5.43857887e-02f,
  4.44837697e-02f, 2.17202902e-01f, 1.11875162e-01f, -1.30326509e-01f, -2.23166138e-01f, 1.38604671e-01f, -2.99544245e-01f, 1.50743410e-01f, -1.19954310e-01f, -4.63921465e-02f,
  -2.11255953e-01f, 6.92268163e-02f, -1.17188834e-01f, -2.83390492e-01f, 1.30898982e-01f, 4.32254970e-02f, -3.85874584e-02f, 1.69439726e-02f, -1.19435556e-01f, 2.41149247e-01f,
  -8.58366583e-03f, 5.93524463e-02f, 1.52085528e-01f, 1.52816400e-01f, -3.31167847e-01f, -1.58937886e-01f, -3.65328372e-01f, -2.27337837e-01f, -6.38701692e-02f, -2.11310945e-02f,
  -1.21404611e-01f, 1.46492288e-01f, -1.05671093e-01f, 7.56517053e-02f, 3.16172875e-02f, -1.72168955e-01f, 6.34823591e-02f, 2.75313705e-01f, -2.30216414e-01f, -7.34839216e-02f,
  -2.29487047e-02f, -1.72643438e-01f, -1.03069261e-01f, 2.66891897e-01f, 1.25067428e-01f, -1.09843180e-01f, 4.43144590e-02f, -1.94279090e-01f, 3.34837675e-01f, 1.59553856e-01f,
  -7.58053437e-02f, 2.91085094e-01f, 4.49975347e-03f, 8.21896791e-02f, 6.38887733e-02f, -3.29674423e-01f, -3.84337157e-02f, 3.11355472e-01f, 9.72323865e-02f, 2.84942091e-01f,
  1.70920312e-01f, 9.93527174e-02f, 9.91823748e-02f, 1.65476307e-01f, 1.99213624e-01f, 5.55109680e-02f, 2.05730632e-01f, 4.71543707e-02f, 3.23925942e-01f, -1.14037693e-01f,
  -2.15031460e-01f, -2.04696044e-01f, 5.00233360e-02f, 8.37496072e-02f, 1.85696036e-01f, 1.21794768e-01f, 1.62997663e-01f, 3.74267735e-02f, 4.08227704e-02f, -2.08228320e-01f,
  -2.81347185e-02f, -1.21168710e-01f, -1.36954308e-01f, -1.50440425e-01f, 8.94589648e-02f, -1.26587689e-01f, 5.56643642e-02f, -3.02908063e-01f, 1.29844457e-01f, 1.49603903e-01f,
  1.93149313e-01f, 1.79036885e-01f, -3.37253623e-02f, 2.17669263e-01f, 1.01412110e-01f, -5.01947626e-02f, -1.54028252e-01f, -1.74644843e-01f, 3.83793674e-02f, -1.61424745e-02f,
  1.11250877e-02f, -8.40719119e-02f, -1.30946845e-01f, -1.33362576e-01f, 2.84144357e-02f, 2.23155797e-01f, -9.41990241e-02f, 1.15818456e-01f, 6.30844831e-02f, -7.46700689e-02f,
  -6.74090534e-02f, -9.22045782e-02f, -5.65620437e-02f, 1.38625875e-01f, -1.18321456e-01f, -6.07076138e-02f, 2.07825884e-01f, -1.06478535e-01f, 1.21048771e-01f, 6.48991764e-03f,
  -2.38386273e-01f, 1.85057461e-01f, -1.83157146e-01f, -1.55855298e-01f, 5.85657880e-02f, -9.92099643e-02f, -2.27884986e-02f, -1.37469873e-01f, 1.49050891e-01f, -1.01385005e-01f,
  -1.70957386e-01f, -1.88926216e-02f, 1.39600309e-02f, -4.43664612e-03f, -3.50642093e-02f, -9.02426466e-02f, -1.07040882e-01f, -2.81959567e-02f, -1.34400325e-02f, -1.22482829e-01f,
  -4.77094203e-02f, -4.05439407e-01f, -4.02115695e-02f, -3.78624462e-02f, 9.59260855e-03f, -3.19473743e-01f, -2.91149188e-02f, -2.48814404e-01f, 6.15405925e-02f, 1.12341762e-01f,
  6.47954047e-02f, -6.07738420e-02f, -2.59424388e-01f, -1.03109278e-01f, 1.28990144e-01f, 2.26616710e-01f, -4.99525033e-02f, 7.57315755e-02f, 3.26231308e-02f, -6.68232590e-02f,
  1.31454065e-01f, 1.55155227e-01f, -3.04776520e-01f, 6.09603710e-02f, -2.81477928e-01f, 1.12206563e-01f, 1.61693156e-01f, 9.81600955e-02f, -6.52858317e-02f, 5.29237203e-02f,
  4.80149090e-02f, 1.87962800e-02f, -2.43059829e-01f, -3.20198625e-01f, -4.52940091e-02f, -7.96993673e-02f, -1.00851119e-01f, 5.23738153e-02f, 1.10708430e-01f, -2.35711470e-01f,
  2.08432853e-01f, 8.71503204e-02f, 6.30940869e-02f, -3.99342105e-02f, -1.33403406e-01f, -9.85280648e-02f, -9.61352438e-02f, -3.51575762e-01f, 7.00652301e-02f, -2.28305757e-01f,
  -2.24295452e-01f, -2.46755928e-01f, 7.91624412e-02f, -2.26446211e-01f, -2.19483208e-02f, -2.76845455e-01f, -1.94350407e-01f, 2.52239764e-01f, -1.63258299e-01f, 1.77316502e-01f,
  -5.33592887e-02f, -1.51557177e-01f, -2.58346200e-01f, 1.32206410e-01f, -1.41663343e-01f, -2.11640775e-01f, -1.15764610e-01f, 1.66015565e-01f, 1.83360539e-02f, -2.33144373e-01f,
  1.65671304e-01f, -9.57052782e-02f, -1.44746676e-01f, 8.61515924e-02f, 1.88419059e-01f, 1.48123235e-01f, -2.47390777e-01f, -1.17591769e-01f, -2.96636403e-01f, 2.13205703e-02f,
  -2.41009682e-01f, 1.62549302e-01f, -7.02237710e-03f, -8.40804726e-02f, 2.93450356e-01f, -1.02346642e-02f, -2.61691988e-01f, 8.17284435e-02f, 1.68252196e-02f, 2.88917474e-03f,
  -9.66642424e-02f, 5.29877432e-02f, 5.67638315e-02f, -1.52751207e-01f, -1.04814045e-01f, -9.54856351e-02f, 6.36965409e-02f, 1.76582962e-01f, 2.00875346e-02f, 2.91371625e-02f,
  -2.37827852e-01f, -3.87492403e-02f, -4.43572178e-04f, -4.19992991e-02f, -1.32889539e-01f, 1.47471741e-01f, 8.11442733e-02f, -6.58516437e-02f, -1.50890574e-01f, -6.96939379e-02f,
  -5.46911284e-02f, 1.07083686e-01f, 6.76049814e-02f, 7.64866620e-02f, 7.27142617e-02f, 7.59976869e-03f, -6.01958930e-02f, -6.27645105e-02f, -2.34005060e-02f, 3.84728819e-01f,
  1.08661078e-01f, -2.97402382e-01f, -6.02436773e-02f, -1.26003295e-01f, -2.45804712e-01f, 1.56038672e-01f, 2.00525582e-01f, -2.28040054e-01f, -1.14155263e-01f, 4.67240095e-01f,
  8.48829001e-02f, -2.04910070e-01f, 6.73974445e-03f, 2.53704749e-02f, -9.85578448e-02f, -9.96512696e-02f, -1.96289852e-01f, -1.74123898e-01f, -2.98305720e-01f, -3.00129026e-01f,
  2.24177718e-01f, -1.39664546e-01f, 1.22700818e-01f, 1.61820561e-01f, -1.66236594e-01f, -2.83411741e-02f, 6.61564991e-03f, -2.25780174e-01f, 9.50979069e-02f, 8.69042799e-02f,
  3.58898682e-03f, 9.20367986e-02f, 5.92830814e-02f, -2.89858550e-01f, 9.90414526e-04f, -5.08699426e-03f, -1.44207496e-02f, 2.21841872e-01f, 2.18132865e-02f, -2.55815804e-01f,
  -1.18197724e-01f, 9.27331597e-02f, 5.46309873e-02f, -9.19142812e-02f, -1.04149044e-01f, -6.17245175e-02f, 1.93956010e-02f, -8.43249559e-02f, -3.18814129e-01f, 8.19450070e-05f,
  -1.82048693e-01f, 2.86440626e-02f, -1.72853157e-01f, -1.02365471e-01f, 8.30668062e-02f, -2.84152552e-02f, 1.10638170e-02f, -1.30484238e-01f, -5.36765251e-03f, -5.48355579e-02f,
  -4.00538035e-02f, -6.52052537e-02f, -3.98632549e-02f, 1.56552136e-01f, 2.17483252e-01f, -3.15703750e-01f, -1.66199535e-01f, 2.13948533e-01f, -3.85624245e-02f, 1.40137583e-01f,
  -2.03725621e-01f, -3.23894083e-01f, -1.89124197e-01f, 1.54181987e-01f, -1.74632236e-01f, 1.80585459e-01f, -1.92192048e-02f, 7.24334121e-02f, 6.64218515e-02f, 7.75380665e-03f,
  -4.07254308e-01f, -1.20884009e-01f, -2.08245263e-01f, -9.52164829e-02f, 3.76806051e-01f, -9.42550972e-02f, -1.36056244e-01f, 4.83766720e-02f, -1.47068249e-02f, 2.57800501e-02f,
  -6.42450526e-02f, 1.46245241e-01f, 1.44468963e-01f, 1.60377488e-01f, 6.37832955e-02f, 1.50616959e-01f, 8.35917071e-02f, -9.53516364e-02f, 1.42513067e-01f, 1.24514677e-01f,
  3.35461251e-03f, 1.41479880e-01f, 5.50411176e-04f, 1.68600023e-01f, 1.80808045e-02f, 2.19074022e-02f, -1.09543175e-01f, -7.03690648e-02f, -4.38172184e-03f, 3.19981799e-02f,
  -7.88220465e-02f, -2.87890822e-01f, 1.07072257e-01f, -8.14628601e-02f, -8.63230601e-02f, 6.80089369e-02f, 1.91327885e-01f, 8.73847529e-02f, 3.89250480e-02f, -9.78043228e-02f,
  1.27275020e-01f, 2.80594756e-03f, -2.04986706e-03f, 1.21800683e-01f, 9.92536694e-02f, -1.33963823e-01f, -8.62861127e-02f, -3.10092360e-01f, -1.40890285e-01f, 2.55937129e-01f,
  4.90655340e-02f, 4.52679455e-01f, 3.01764756e-01f, -2.28074893e-01f, 6.57760650e-02f, 2.30282068e-01f, 1.66522890e-01f, -1.06445253e-01f, -7.55800828e-02f, -1.20028341e-02f,
  -1.60309091e-01f, -2.16702998e-01f, -3.30655694e-01f, -8.76344517e-02f, 7.69131482e-02f, 2.84927767e-02f, 3.11728209e-01f, 1.19075611e-01f, -2.27959058e-03f, 6.87832311e-02f,
  -3.41548957e-02f, -1.25670165e-01f, 1.24443717e-01f, -1.00480720e-01f, -1.68914512e-01f, 1.00956291e-01f, -9.03774276e-02f, 4.38059196e-02f, -8.69822204e-02f, -1.13024928e-01f,
  2.69417197e-01f, 8.23871568e-02f, 2.64103383e-01f, -8.22490156e-02f, 6.83925301e-02f, -7.16899559e-02f, 1.46277428e-01f, 2.57377326e-01f, 2.26329118e-02f, -1.67494163e-01f,
  -4.91600484e-02f, 1.39573038e-01f, -1.39676258e-02f, -2.09525283e-02f, -6.47044629e-02f, 2.65683919e-01f, 1.45383090e-01f, 1.05970101e-02f, 1.68638602e-01f, 1.22801684e-01f,
  -9.62064713e-02f, 1.72638655e-01f, 5.66617548e-02f, 2.11270750e-02f, 1.63276225e-01f, 5.73791713e-02f, 1.01599157e-01f, 3.48433177e-03f, 8.77212510e-02f, -2.31604129e-02f,
  -1.59671023e-01f, -3.69911641e-01f, -3.47461291e-02f, 1.02760559e-02f, 3.68999541e-02f, -1.40519962e-01f, -4.48779985e-02f, 1.56411693e-01f, -4.32311296e-02f, 1.04133613e-01f,
  1.69454858e-01f, -4.63203005e-02f, 1.50991321e-01f, -9.96543616e-02f, 1.86077088e-01f, -1.11162186e-01f, -5.31488247e-02f, 1.61216892e-02f, -2.02745665e-02f, -2.89366037e-01f,
  -1.14281796e-01f, -1.04587622e-01f, -3.33152890e-01f, -1.38497338e-01f, -2.30310872e-01f, -8.19403157e-02f, -2.03785598e-01f, 2.38009617e-02f, -1.53898135e-01f, 8.98874626e-02f,
  -5.30531555e-02f, -1.89985722e-01f, 2.22289458e-01f, -3.13052498e-02f, -1.92701638e-01f, 8.74171332e-02f, -1.92992315e-01f, 9.01912432e-03f, -1.54904872e-01f, -2.16592588e-02f,
  -8.58739391e-02f, -2.26247571e-02f, -1.25592768e-01f, 8.51945132e-02f, 5.11001460e-02f, -1.58800706e-01f, 1.13451704e-01f, 1.09841421e-01f, 1.66677445e-01f, -2.51249343e-01f,
  -1.54139981e-01f, -8.42825845e-02f, 4.13235277e-02f, 1.82734579e-01f, 1.13123581e-01f, -1.99806746e-02f, 7.48265982e-02f, -4.32330705e-02f, 1.31298732e-02f, 7.32639506e-02f,
  -1.28541910e-03f, 4.00049351e-02f, -1.86554417e-02f, -1.92220554e-01f, 1.92086697e-01f, 1.05883919e-01f, 4.03153971e-02f, 5.13990931e-02f, 1.90847471e-01f, -5.38739190e-02f,
  -2.15485394e-02f, 8.83639678e-02f, 1.31592140e-01f, 6.04057424e-02f, -1.23532519e-01f, -9.93509814e-02f, -4.27793056e-01f, 2.84712583e-01f, 4.45020124e-02f, -1.59629479e-01f,
  -9.04971082e-03f, 3.22105139e-02f, 1.77875489e-01f, 2.12782919e-01f, 1.57162964e-01f, -9.43203270e-02f, -8.18110630e-03f, 9.74690914e-02f, 3.92903358e-01f, 8.73418972e-02f,
  9.62857679e-02f, -9.80855748e-02f, 1.32667348e-01f, -9.17511731e-02f, -5.28564304e-02f, -2.07253313e-03f, -2.38193199e-01f, 1.89338848e-01f, 1.68754920e-01f, 8.02318379e-02f,
  1.42900050e-01f, 1.17547996e-02f, 1.91801250e-01f, 2.24588916e-01f, 6.10041991e-02f, 2.09895030e-01f, -2.64450219e-02f, -2.05967322e-01f, 1.37090325e-01f, 7.87931532e-02f,
  3.48462731e-01f, -5.49111329e-03f, -1.04684070e-01f, 2.20128238e-01f, 1.51839674e-01f, 1.79114223e-01f, 1.95922181e-01f, -1.80995047e-01f, -2.80177623e-01f, 6.55663162e-02f,
  3.01471706e-02f, -7.62594864e-02f, -7.81520382e-02f, -9.68357921e-02f, 6.36875182e-02f, -1.24417186e-01f, -4.32499722e-02f, 1.20773390e-01f, 9.44283605e-02f, -1.50293745e-02f,
  9.37622339e-02f, -2.07951471e-01f, -6.75716326e-02f, -2.59366751e-01f, -3.26801032e-01f, 1.51380032e-01f, 9.67330858e-03f, 1.77873284e-01f, -8.67768154e-02f, -2.47659162e-01f,
  -9.83020589e-02f, -3.25308479e-02f, 2.22007241e-02f, 2.55017634e-02f, 1.22650936e-01f, -9.16001499e-02f, 3.58800287e-03f, -2.47054279e-01f, -9.31536630e-02f, -2.36842513e-01f,
  -6.55548722e-02f, -4.26197350e-02f, 1.65081918e-01f, 1.31462947e-01f, -2.69443572e-01f, 2.95019567e-01f, -1.42428637e-01f, 3.00076976e-02f, -1.44985422e-01f, -2.82738712e-02f,
  -5.87298684e-02f, 9.13098305e-02f, -2.55036414e-01f, -6.63659722e-02f, -5.78210615e-02f, -2.34606057e-01f, 4.84389588e-02f, 3.07618797e-01f, 1.27914548e-02f, -1.91795751e-01f,
  -6.20240048e-02f, 1.83454797e-01f, 1.71218395e-01f, 1.43312186e-01f, 3.36551607e-01f, -7.34218257e-03f, -6.57625422e-02f, 3.70975621e-02f, -1.57060161e-01f, 5.56308962e-02f,
  5.28189316e-02f, -1.07763857e-01f, 2.91423053e-01f, 7.15170130e-02f, 1.93517953e-01f, 3.69624943e-01f, 1.27058819e-01f, 1.68575317e-01f, 3.06279352e-03f, 1.12639457e-01f,
  8.33997503e-02f, 1.31447569e-01f, -4.65052947e-02f, 2.46779710e-01f, -1.25400394e-01f, 1.15248516e-01f, -7.05313906e-02f, 3.17671955e-01f, 1.92415446e-01f, -2.61899680e-02f,
  2.15351999e-01f, 1.11245401e-01f, -4.84631546e-02f, 3.39686602e-01f, 3.26603532e-01f, -3.35375190e-01f, 8.05680975e-02f, 3.21192354e-01f, 1.38589978e-01f, -7.76702836e-02f,
  8.28429759e-02f, 2.89262347e-02f, 8.60669091e-02f, -1.89264968e-01f, 3.63196880e-01f, -1.88436300e-01f, 2.57375300e-01f, -1.87375881e-02f, -5.60222007e-02f, -8.02499726e-02f,
  -1.41817480e-01f, 4.94873188e-02f, -2.05402970e-02f, -1.08965235e-02f, 3.04331690e-01f, 5.65624461e-02f, 1.78318307e-01f, 2.38284599e-02f, 2.60262080e-02f, -5.76317087e-02f,
  1.53376848e-01f, -1.77309602e-01f, -3.01604986e-01f, 1.61938176e-01f, -2.29746073e-01f, 1.99335143e-01f, -4.46624979e-02f, 1.76298156e-01f, -1.17418515e-02f, 1.69681422e-02f,
  4.22992706e-02f, -1.31298974e-01f, -1.86447069e-01f, 9.34016779e-02f, -1.61094308e-01f, -1.03781605e-02f, -3.45654525e-02f, 1.71266928e-01f, -1.06269896e-01f, 2.74155866e-02f,
  -8.05806071e-02f, -1.18509948e-01f, 3.95614691e-02f, -3.85254957e-02f, -5.00999130e-02f, -3.16368528e-02f, 9.61128622e-02f, 1.46229282e-01f, -2.09742188e-01f, 1.16826184e-01f,
  7.36079738e-02f, 1.26442820e-01f, -6.08995743e-02f, 6.41421974e-02f, 9.73270368e-03f, -2.71424372e-02f, -3.49978715e-01f, -3.74524929e-02f, 2.90091913e-02f, -1.72204509e-01f,
  -2.96662077e-02f, -1.56954169e-01f, -1.99084193e-01f, 9.23243091e-02f, -5.11949286e-02f, 8.70774761e-02f, 2.02374533e-02f, 3.31671804e-01f, 1.02144675e-02f, 1.61766514e-01f,
  1.99090242e-01f, 2.48173952e-01f, 1.95923552e-01f, -4.02618229e-01f, 1.61468655e-01f, -1.60724103e-01f, 2.50589568e-03f, 4.17770296e-02f, -4.52928133e-02f, -7.87453875e-02f,
  1.68249249e-01f, -1.92095131e-01f, 2.46954471e-01f, 1.76625058e-01f, 1.15881681e-01f, -1.57700747e-01f, -4.19187285e-02f, -2.72251397e-01f, 4.16320153e-02f, -2.92852730e-01f,
  1.75518617e-01f, 1.81192890e-01f, 1.14852227e-02f, -1.49984062e-01f, 2.71875337e-02f, 6.13235570e-02f, -3.68944332e-02f, 4.27683629e-02f, -4.92791682e-02f, 1.42708734e-01f,
  -5.44253998e-02f, -2.10678563e-01f, -1.35067955e-01f, -1.20019257e-01f, -1.27390027e-01f, -4.24844205e-01f, -5.37334662e-03f, 2.32989390e-04f, 3.85290422e-02f, -2.16377690e-01f,
  1.27300322e-01f, 1.61029696e-01f, 4.10495102e-02f, -2.10812896e-01f, -2.28580654e-01f, -2.18206137e-01f, -3.13510410e-02f, -6.48040920e-02f, -2.38531798e-01f, -5.02474955e-04f,
  -1.12058386e-01f, -9.42731649e-02f, -1.73033521e-01f, 8.03016499e-02f, 3.55331242e-01f, 4.47072953e-01f, 9.17899832e-02f, -1.01359546e-01f, -1.81967169e-02f, -7.59336427e-02f,
  -1.75392106e-01f, 9.47710648e-02f, 1.44875035e-01f, -2.72289403e-02f, 8.10557753e-02f, 8.35277364e-02f, 1.62158557e-03f, 1.58534095e-01f, 4.14094366e-02f, 1.78807639e-02f,
  2.66041487e-01f, 1.24376267e-01f, -1.18196435e-01f, 4.54587676e-02f, -1.14239566e-01f, -6.22675195e-02f, -1.40296165e-02f, 2.21615165e-01f, 1.25024140e-01f, 8.39601010e-02f,
  -1.99347716e-02f, -4.27030288e-02f, -1.54107675e-01f, -6.45308569e-02f, -1.62455916e-01f, -1.52584895e-01f, 1.77375138e-01f, -1.86363071e-01f, -7.72564188e-02f, 4.50780578e-02f,
  -4.65490483e-02f, 7.96504505e-03f, 8.44250321e-02f, 2.10336804e-01f, 5.31915799e-02f, -2.85066187e-01f, -1.75638705e-01f, -4.92233299e-02f, -2.14281052e-01f, -6.76038414e-02f,
  -8.10224041e-02f, -1.37395905e-02f, -1.68577865e-01f, 2.37595737e-02f, -1.75435618e-01f, -1.04442202e-01f, 6.12617321e-02f, 7.85790458e-02f, -7.61818960e-02f, 1.81539088e-01f,
  -1.24327607e-01f, -8.29915106e-02f, 4.66914102e-02f, 1.34715021e-01f, 1.81152835e-01f, -2.39277646e-01f, 2.15406314e-01f, -8.01129863e-02f, -2.40633324e-01f, 6.14558272e-02f,
  5.51976860e-02f, -1.89579278e-01f, -9.72639620e-02f, 1.11381188e-01f, -4.15617088e-03f, 2.45985091e-01f, -1.11466363e-01f, -1.76846206e-01f, 4.33565378e-02f, 1.05173804e-01f,
  7.01720417e-02f, 1.17558785e-01f, -1.69701830e-01f, 1.32008493e-01f, 2.38159209e-01f, 5.28195240e-02f, 1.14086039e-01f, 1.76849142e-01f, -2.23223731e-01f, 1.34933412e-01f,
  -2.06914879e-02f, -1.04302473e-01f, -2.28011563e-01f, -3.13388199e-01f, 7.61148483e-02f, -2.67878324e-02f, 1.45477846e-01f, -4.13228944e-02f, -9.73619148e-02f, 1.02370568e-01f,
  -6.21424764e-02f, -3.61050963e-02f, -2.25561447e-02f, -9.74498838e-02f, 3.25236768e-01f, 9.79641378e-02f, 8.98957700e-02f, -1.30342633e-01f, -5.18181734e-02f, -7.52104819e-02f,
  4.25177962e-02f, -1.62058637e-01f, 1.09781817e-01f, 1.75846547e-01f, -1.50524988e-03f, -1.04774065e-01f, -8.18709731e-02f, -7.25132227e-02f, -1.70550212e-01f, 2.64084861e-02f,
  -8.92781764e-02f, 2.83692539e-01f, -2.39839125e-02f, 3.34208250e-01f, 1.63015485e-01f, -3.80471021e-01f, 9.04294252e-02f, 3.27901304e-01f, 1.32843390e-01f, 1.18897900e-01f,
  -1.15386084e-01f, 2.94242091e-02f, -4.05594334e-03f, -2.50672251e-01f, -1.38783399e-02f, -1.61934823e-01f, 1.19659916e-01f, -1.19166613e-01f, 3.19938689e-01f, 4.61388081e-02f,
  1.13443904e-01f, -1.38872489e-01f, 2.32522339e-02f, 7.46664703e-02f, -1.39934435e-01f, 4.66842903e-03f, 1.25212684e-01f, 1.98352337e-02f, -5.50390743e-02f, -2.50696331e-01f,
  1.29078805e-01f, -4.87053655e-02f, 3.39678645e-01f, -3.76506522e-02f, -1.68069467e-01f, -1.93213344e-01f, 2.54323632e-01f, 9.05530676e-02f, 1.10142209e-01f, -7.25016147e-02f,
  2.95448303e-01f, -1.03391998e-01f, -4.58303057e-02f, -2.02685073e-01f, -5.42112850e-02f, -1.96341723e-01f, 5.28700352e-02f, 3.73337343e-02f, -3.95037293e-01f, 1.49001488e-02f,
  -1.89499129e-02f, -2.30715021e-01f, 9.07038897e-02f, -7.45444447e-02f, -8.36796220e-03f, -9.25098136e-02f, 7.61478394e-02f, 1.40973330e-01f, -1.39795959e-01f, 4.73915935e-02f,
  -1.30911618e-01f, 4.71001118e-02f, 7.63273658e-03f, 8.56549367e-02f, -2.84000337e-02f, -3.24149996e-01f, -3.08809370e-01f, 2.01713443e-01f, 3.40558179e-02f, 1.64151728e-01f,
  7.15392455e-02f, -2.96671353e-02f, 1.96185619e-01f, 2.41039678e-01f, 1.38562009e-01f, -2.29881734e-01f, -1.19272321e-01f, -4.54160385e-02f, 3.06321084e-02f, -3.34180027e-01f,
  -2.37287790e-01f, 3.80814224e-02f, 1.15694165e-01f, -1.20321289e-01f, 6.79899305e-02f, -4.31471094e-02f, -8.45204070e-02f, 1.03743181e-01f, 2.68320702e-02f, 5.28538078e-02f,
  -1.51025474e-01f, 2.05786824e-01f, 2.30687231e-01f, 8.73141587e-02f, 1.07549548e-01f, 1.45931974e-01f, -8.06334168e-02f, 8.22063535e-02f, 1.03186086e-01f, -1.19504116e-01f,
  -1.88816577e-01f, -1.54870167e-01f, 3.49144898e-02f, 1.07281201e-01f, 6.50490401e-03f, -1.40225310e-02f, -6.54081926e-02f, -1.97295710e-01f, -3.25797684e-02f, -9.35411081e-03f,
  2.89718318e-03f, -2.37498209e-01f, 2.30877399e-01f, 3.28320861e-02f, 2.18341216e-01f, -1.16681851e-01f, 1.16154753e-01f, -1.68142080e-01f, -4.80448082e-02f, -2.35033512e-01f,
  1.03355693e-02f, -7.44143650e-02f, -1.61607608e-01f, -1.26358807e-01f, -1.69101864e-01f, -1.29074872e-01f, 1.82994589e-01f, -2.61564583e-01f, -6.47066310e-02f, 1.12774624e-02f,
  1.89057797e-01f, -5.13818637e-02f, -6.14939369e-02f, 6.65012151e-02f, -1.53017908e-01f, -1.61218554e-01f, -1.03460632e-01f, -1.93932846e-01f, -3.98009002e-01f, 3.43638241e-01f,
  2.05916315e-01f, -2.77984381e-01f, 1.86710909e-01f, 5.63289039e-02f, -1.32701561e-01f, 9.93464440e-02f, 1.18436702e-01f, -7.06800744e-02f, -3.54673892e-01f, 1.91984519e-01f,
  -4.04405184e-02f, -1.08260095e-01f, -1.93332527e-02f, 1.40191570e-01f, 4.35733199e-02f, -2.67551780e-01f, -2.66210064e-02f, -1.13594323e-01f, -4.30015713e-01f, 1.32724062e-01f,
  -1.33374944e-01f, 1.82847410e-01f, -5.71445823e-02f, -1.07999466e-01f, -7.22830463e-03f, 2.36990690e-01f, 1.15814939e-01f, 1.41158223e-01f, -8.74876603e-02f, -2.29257792e-02f,
  -4.73516025e-02f, 1.71077698e-01f, 3.78398821e-02f, -1.37694418e-01f, 2.76158541e-01f, -6.50823340e-02f, -1.80482045e-01f, 4.21256293e-03f, -1.87661722e-02f, -8.98888987e-03f,
  2.91096658e-01f, -2.88909227e-01f, 2.27582872e-01f, 9.18101668e-02f, 1.63555443e-01f, 9.94919613e-02f, -1.05109602e-01f, 7.22051859e-02f, 6.56995773e-02f, -5.93226962e-02f,
  -5.80752827e-02f, -2.31482029e-01f, -4.11427498e-01f, 2.10473791e-01f, 1.74670741e-01f, 1.12943366e-01f, 2.36903597e-02f, 2.90115505e-01f, 8.36944059e-02f, 6.22251630e-02f,
  -1.53512642e-01f, -3.89341600e-02f, -1.97425812e-01f, -2.39180941e-02f, -1.25929117e-01f, 1.05095528e-01f, -1.08923264e-01f, 2.99831569e-01f, 4.19292092e-01f, 7.50386566e-02f,
  1.39106348e-01f, 6.10908680e-02f, -7.25179538e-02f, -1.48387820e-01f, 1.37238353e-01f, -1.57720521e-01f, 1.20507218e-01f, -2.79158622e-01f, 2.41040196e-02f, -1.31717682e-01f,
  -2.85424124e-02f, -1.55178830e-01f, 1.75067335e-01f, 4.26067896e-02f, 1.38363749e-01f, 2.49920934e-02f, -8.98674950e-02f, -5.25907322e-04f, 7.71434456e-02f, -3.60319376e-01f,
  2.39651203e-01f, 3.08713298e-02f, 3.55024152e-02f, -1.75149366e-01f, 6.40140325e-02f, -6.84368471e-03f, -1.95428982e-01f, -3.42344493e-01f, 4.69393516e-03f, 1.99720804e-02f,
  -1.68797597e-01f, 1.56370595e-01f, -2.32229725e-01f, -1.75288171e-01f, -9.17351767e-02f, -3.20923835e-01f, 1.05311379e-01f, -1.27776802e-01f, -1.36851981e-01f, -1.07024610e-01f,
  -2.03289792e-01f, -1.64087508e-02f, -2.35620126e-01f, 1.78542621e-02f, -1.13670751e-01f, -1.09997839e-01f, -1.33462667e-01f, -4.19022664e-02f, -1.39698908e-01f, -1.30364047e-02f,
  7.01931491e-02f, -1.61771774e-01f, 6.24232590e-02f, 2.05287665e-01f, -3.27459574e-02f, -9.53242406e-02f, 9.00539681e-02f, -1.15901552e-01f, -2.34700918e-01f, 8.78914222e-02f,
  1.52465940e-01f, 9.49937850e-02f, -3.06936838e-02f, 2.14993320e-02f, 4.57972810e-02f, 2.67278969e-01f, -2.36534908e-01f, -9.87337828e-02f, -1.46433190e-01f, 2.12453976e-01f,
  1.26792677e-03f, 7.16739297e-02f, -2.37219334e-01f, 5.50607666e-02f, 1.29466563e-01f, 3.09019946e-02f, -4.94354405e-02f, -1.79947764e-02f, -1.84411258e-01f, 3.50157082e-01f,
  -2.00190842e-01f, -1.22104455e-02f, -9.36120227e-02f, -4.64588925e-02f, -7.48810470e-02f, 3.76311131e-02f, 1.47054940e-01f, -1.23284258e-01f, -1.68556899e-01f, -1.70170039e-01f,
  1.61002517e-01f, 1.05634242e-01f, 1.34861588e-01f, -5.42150214e-02f, 8.66507888e-02f, 6.72842115e-02f, -1.22222580e-01f, -8.19376260e-02f, 1.16420031e-01f, -8.61218795e-02f,
  8.50266498e-03f, -1.45744649e-03f, -6.54914156e-02f, -4.17426303e-02f, -1.40700087e-01f, -1.20057799e-01f, 6.55941740e-02f, 4.64970917e-02f, 2.15604812e-01f, 1.79671347e-02f,
  2.07566470e-01f, 4.49068286e-02f, -3.90564024e-01f, 3.11207533e-01f, 2.84984201e-01f, -2.99490154e-01f, 4.02475931e-02f, -6.72954693e-02f, 9.88168418e-02f, 1.06489867e-01f,
  1.81409679e-02f, -1.42183349e-01f, -1.44694462e-01f, -1.54260630e-02f, 1.25315860e-01f, -3.23461175e-01f, -1.73221186e-01f, 1.13666676e-01f, 1.12199910e-01f, 1.56628583e-02f,
  -5.48753701e-02f, -3.05268168e-01f, -2.30493441e-01f, -7.60906041e-02f, -2.25455940e-01f, 3.24613720e-01f, -2.35288024e-01f, 1.06019536e-02f, 2.50434369e-01f, 4.09676507e-02f,
  9.35457721e-02f, 2.12523211e-02f, 1.94142923e-01f, -3.88109125e-02f, -1.11737244e-01f, 4.74586263e-02f, -6.86551705e-02f, 1.59467816e-01f, 1.55230552e-01f, 2.77591825e-01f,
  -9.46112815e-03f, -5.12371724e-03f, -7.73671921e-03f, -4.88095134e-02f, 1.39088318e-01f, 1.91179097e-01f, 5.55499196e-02f, -9.60528329e-02f, 2.61402011e-01f, -6.81167608e-03f,
  -1.77281257e-02f, 1.23665154e-01f, 1.86063088e-02f, 2.91816026e-01f, -9.74027440e-02f, 1.67623654e-01f, 3.22356552e-01f, 7.49151036e-02f, 1.03785448e-01f, 3.19171965e-01f,
  2.11856529e-01f, -1.44658899e-02f, -4.61321846e-02f, -4.24641013e-01f, 7.79712126e-02f, -3.07796076e-02f, -2.15820432e-01f, 5.35903387e-02f, -5.73196784e-02f, 2.13067643e-02f,
  2.53068060e-01f, -2.04333812e-01f, 2.04498284e-02f, 1.13193974e-01f, -3.84648517e-02f, 3.97600606e-02f, -9.48375911e-02f, -3.47226709e-01f, 2.01798111e-01f, -1.33752720e-02f,
  4.63473611e-02f, -5.54097071e-02f, -6.58046752e-02f, -1.61280110e-01f, -4.75846753e-02f, -2.33932376e-01f, -8.04603919e-02f, 2.37304321e-03f, -2.58434147e-01f, 8.24289396e-02f,
  -2.07592681e-01f, 7.37719983e-02f, -4.71004397e-02f, -9.24250707e-02f, 1.01684920e-01f, -5.22348471e-02f, -4.02670875e-02f, 1.30349740e-01f, -1.65958226e-01f, -1.33548021e-01f,
  -2.48124927e-01f, 1.23039313e-01f, -8.60625505e-02f, 9.31316167e-02f, -1.22130416e-01f, 2.41868347e-02f, 2.27678102e-02f, -6.77879825e-02f, 1.32006849e-03f, 1.01055332e-01f,
  -1.15843773e-01f, -1.46498933e-01f, 4.29744087e-02f, 9.66845304e-02f, 1.06485747e-01f, 2.35693473e-02f, -8.17610770e-02f, -2.92292051e-02f, -2.73443200e-02f, -1.87211737e-01f,
  -3.31966789e-03f, -1.57427471e-02f, 1.31447896e-01f, -1.13197781e-01f, -5.20477351e-03f, 4.36801575e-02f, -8.55941512e-03f, -2.76192307e-01f, -1.81884095e-01f, 2.06447035e-01f,
  2.19704494e-01f, 1.29330561e-01f, -2.08224267e-01f, 2.01538891e-01f, 5.52983880e-02f, -1.34882003e-01f, -1.35491133e-01f, -1.88066870e-01f, -3.18547875e-01f, 1.36285052e-01f,
  1.06652327e-01f, 6.09000623e-02f, -4.90854606e-02f, 9.97147560e-02f, 7.93192759e-02f, 5.19950464e-02f, 1.53091833e-01f, 1.66374162e-01f, -2.88913548e-01f, 1.60803109e-01f,
  -8.35098103e-02f, -2.29226395e-01f, 4.79311086e-02f, 4.59470749e-02f, 3.51152234e-02f, -8.70547071e-02f, 2.09313944e-01f, -1.37992740e-01f, 3.26158404e-02f, -2.34975033e-02f,
  -3.34076211e-02f, 8.58792216e-02f, -3.00503582e-01f, 1.12385452e-01f, 1.20534047e-01f, -8.35570171e-02f, 1.06441073e-01f, 3.23695391e-02f, 1.03019876e-02f, -1.56221405e-01f,
  1.06320061e-01f, -1.18912183e-01f, -1.39950722e-01f, 1.89484105e-01f, -2.03317124e-03f, 2.94350863e-01f, 8.48357156e-02f, -6.97746500e-02f, -1.91357434e-02f, -2.08225772e-01f,
  -1.82310976e-02f, 1.02351695e-01f, 2.04471156e-01f, -1.52018636e-01f, 7.55193308e-02f, 2.20304698e-01f, -1.96914040e-02f, -1.60890445e-02f, 3.61447670e-02f, 1.12916335e-01f,
  -7.78308585e-02f, 6.32944256e-02f, 1.42450199e-01f, -6.84871003e-02f, -1.48032486e-01f, 6.50257245e-02f, 2.17300355e-01f, 2.21713230e-01f, 1.23903207e-01f, 2.64807135e-01f,
  2.84122705e-01f, 6.99711069e-02f, 2.03391328e-01f, -3.78706157e-02f, 6.66442588e-02f, -1.43817455e-01f, 1.59063742e-01f, 1.81192473e-01f, -2.75733601e-02f, -9.21114087e-02f,
  4.96745296e-02f, -3.65508758e-02f, -1.47427052e-01f, -8.85930136e-02f, 6.29902631e-02f, -8.12624842e-02f, -1.97810054e-01f, 2.22117841e-01f, 1.26843706e-01f, 1.23181552e-01f,
  -2.81589061e-01f, -5.63052259e-02f, 1.18662722e-01f, -1.29029915e-01f, -1.59763336e-01f, 1.43495008e-01f, 7.98004493e-02f, -8.48952010e-02f, -2.07228601e-01f, -2.77495128e-03f
};

// L2_fan_Wp_bar (Shape: 14 x 64)
const int L2_fan_Wp_bar_rows = 14;
const int L2_fan_Wp_bar_cols = 64;
const float L2_fan_Wp_bar_data[] = {
  -3.51275094e-02f, 6.89753592e-02f, -4.04353738e-01f, 2.12314531e-01f, 1.74987435e-01f, 2.35669762e-01f, -1.46524861e-01f, -3.96526098e-01f, 5.27490266e-02f, 1.10883668e-01f,
  -7.40903467e-02f, 1.94748074e-01f, 8.39145947e-03f, 1.79850772e-01f, -3.29040647e-01f, -5.29335678e-01f, -2.14703932e-01f, 1.44156128e-01f, -2.69759417e-01f, -2.12457523e-01f,
  8.34333003e-02f, -2.60629565e-01f, -1.03413172e-01f, 1.91604987e-01f, 8.90936404e-02f, 3.92885059e-02f, -1.60331920e-01f, 2.06422005e-02f, 3.31527367e-03f, -2.06168264e-01f,
  -1.59540549e-01f, -4.21310812e-01f, -1.33225294e-02f, -1.20174281e-01f, -1.78162813e-01f, -3.10539007e-01f, 2.72614121e-01f, -1.46438420e-01f, -3.58848125e-01f, -3.34837362e-02f,
  -2.26035491e-01f, -1.01005234e-01f, -1.31053686e-01f, -3.05196904e-02f, -5.61443307e-02f, 3.38533640e-01f, 7.95888603e-02f, -3.61476243e-02f, -2.01737836e-01f, 1.67680815e-01f,
  1.87715948e-01f, -2.27142274e-01f, 4.15924788e-02f, -1.73779413e-01f, 1.95992067e-01f, 1.73740163e-01f, -2.06640303e-01f, -4.77117822e-02f, -4.26855177e-01f, -1.26350850e-01f,
  9.30084065e-02f, 1.73193187e-01f, 1.20810814e-01f, -1.50825173e-01f, 1.40625164e-01f, 3.84043567e-02f, -1.65879458e-01f, 4.35120612e-01f, 1.80866137e-01f, 1.07954433e-02f,
  -2.85829604e-02f, 8.40929076e-02f, 6.11007027e-02f, 2.56068677e-01f, -1.18565764e-02f, 1.80462956e-01f, 3.10688708e-02f, 8.73080567e-02f, 1.28705978e-01f, -6.55039996e-02f,
  2.34999955e-01f, -1.67565290e-02f, -1.32282883e-01f, 1.91386089e-01f, -1.51814982e-01f, 5.20286672e-02f, -2.38279700e-02f, 7.73825869e-02f, 3.15945894e-01f, -4.18222606e-01f,
  -3.94850075e-01f, 8.81881267e-02f, -1.76948324e-01f, -2.31776774e-01f, 2.90055759e-02f, 3.73271167e-01f, -1.44038594e-03f, 1.55076280e-01f, -2.56584883e-01f, -1.65823609e-01f,
  -3.23090442e-02f, 2.99604535e-01f, -1.42981678e-01f, -1.01573668e-01f, 1.81753695e-01f, 3.12302142e-01f, 2.08015189e-01f, 3.09650123e-01f, 3.49758416e-01f, 2.26406693e-01f,
  -1.87248260e-01f, 1.01899453e-01f, 7.53973871e-02f, -6.05077855e-02f, 5.36867008e-02f, 5.39841950e-02f, 1.30164340e-01f, 9.91689190e-02f, -4.04256359e-02f, 5.14325220e-03f,
  5.72072044e-02f, -1.97783083e-01f, 1.15132183e-02f, 3.42998892e-01f, -1.17699280e-01f, -1.55601846e-02f, -1.58321764e-02f, -1.88995689e-01f, -5.47353551e-02f, -1.21765234e-01f,
  -6.07046261e-02f, 1.16242558e-01f, 2.02822879e-01f, 8.24641958e-02f, 2.22037360e-01f, 1.09923087e-01f, 1.81463435e-01f, -3.27035151e-02f, 1.44411042e-01f, -4.90889661e-02f,
  3.37142080e-01f, 1.44800186e-01f, 8.50263163e-02f, 8.56509209e-02f, 9.46495160e-02f, 2.11855143e-01f, 1.02281481e-01f, -4.98106256e-02f, 6.74659908e-02f, 2.48563156e-01f,
  3.24588194e-02f, -8.02227557e-02f, 1.88338935e-01f, 2.14419156e-01f, 1.21794455e-05f, 5.66612817e-02f, 2.53170371e-01f, -1.60607219e-01f, -1.30643874e-01f, 2.77836710e-01f,
  -4.97029312e-02f, 5.33519275e-02f, 1.03295393e-01f, -8.48432332e-02f, -9.40029845e-02f, 3.52978945e-01f, 2.91389853e-01f, 4.57317457e-02f, 3.53990383e-02f, 8.14645514e-02f,
  2.66324550e-01f, 8.70479420e-02f, 4.79629189e-02f, 2.16792021e-02f, -8.61365348e-02f, 3.32777441e-01f, 3.24293792e-01f, 2.17384216e-03f, -1.27400607e-01f, 2.08181992e-01f,
  1.87006310e-01f, -1.83902964e-01f, -1.60455406e-01f, -1.17544815e-01f, 4.66240346e-02f, 1.90806895e-01f, -7.31280595e-02f, -2.62862235e-01f, -9.47871357e-02f, 1.68344993e-02f,
  1.64599523e-01f, 2.12724224e-01f, -4.47925068e-02f, -9.59306359e-02f, 8.75544641e-03f, -7.83074796e-02f, 8.15970600e-02f, 9.60525945e-02f, 1.97507188e-01f, 6.35241121e-02f,
  1.19671419e-01f, 9.56621543e-02f, -2.47099042e-01f, 1.34528726e-01f, -3.32421631e-01f, 2.28338577e-02f, 1.14877999e-01f, 1.77932993e-01f, 1.48269698e-01f, 4.82371785e-02f,
  -2.60436356e-01f, 3.62903439e-02f, 3.84221375e-02f, 3.39486480e-01f, -7.26518780e-02f, 1.85126774e-02f, 2.21116826e-01f, 2.52458364e-01f, -1.82445440e-02f, 7.96817020e-02f,
  -1.34295762e-01f, 4.35599476e-01f, 6.05654903e-02f, -6.82514459e-02f, -2.62724310e-01f, -5.33777289e-04f, -1.70483679e-01f, -7.04361079e-03f, 4.06854481e-01f, -2.83656240e-01f,
  -1.11450665e-01f, 3.05006772e-01f, -1.80447802e-01f, -7.24355057e-02f, -4.30061668e-02f, 2.79379576e-01f, 3.46944362e-01f, 9.97776464e-02f, 2.91494757e-01f, 5.16764186e-02f,
  -1.04764335e-01f, 4.33519483e-02f, -4.54492532e-02f, -8.10081214e-02f, -1.97727680e-01f, 1.40969455e-01f, 9.41342413e-02f, 7.20128566e-02f, 3.53182316e-01f, -2.30038896e-01f,
  4.59344745e-01f, 1.68270934e-02f, 8.30598772e-02f, -4.20398042e-02f, 2.58985609e-01f, -1.72037542e-01f, -1.57738328e-01f, 1.80949569e-02f, 8.00273567e-02f, 1.45352051e-01f,
  1.33401439e-01f, 1.22447334e-01f, -2.65873829e-03f, 1.88612286e-02f, -6.81625605e-02f, 6.72217235e-02f, 4.73344065e-02f, 7.71203823e-03f, -1.13581523e-01f, -4.07596789e-02f,
  -1.20799601e-01f, 1.31695032e-01f, 6.61970451e-02f, 4.28233057e-01f, 1.70911297e-01f, 5.22199310e-02f, 2.54226744e-01f, 1.07294448e-01f, 1.06037736e-01f, 1.03014395e-01f,
  -1.84185490e-01f, 1.79347247e-01f, 2.38258705e-01f, -7.50493258e-02f, -1.03015028e-01f, -8.55456740e-02f, -9.08447355e-02f, -3.77429724e-01f, 2.55518734e-01f, -2.29920611e-01f,
  1.99644864e-02f, 1.77187204e-01f, 1.82799950e-01f, -4.81042892e-01f, -2.39350870e-01f, 6.51003048e-02f, 4.33759997e-03f, -1.17887184e-01f, 1.28119260e-01f, -2.75387734e-01f,
  -6.31075501e-02f, -2.61289887e-02f, 2.97705799e-01f, -3.51366311e-01f, -2.21935704e-01f, 8.46108980e-03f, -1.38154685e-01f, 2.52819490e-02f, 2.74607427e-02f, 4.14525680e-02f,
  2.43032485e-01f, -2.24743951e-02f, 1.70630917e-01f, 1.53175160e-01f, -1.94904988e-03f, -2.21759021e-01f, 1.24228798e-01f, 1.12155005e-01f, -1.41989082e-01f, 3.57679389e-02f,
  1.57316118e-01f, -9.70232263e-02f, -1.89935625e-01f, 1.33974925e-01f, 1.87685058e-01f, 8.55266899e-02f, 1.33244187e-01f, -9.42990929e-02f, 1.91538557e-01f, 2.82988876e-01f,
  3.23822498e-02f, 1.99906603e-01f, 8.38777125e-02f, 2.70102024e-01f, 9.90573913e-02f, -1.67803038e-02f, 4.28291745e-02f, 2.41118640e-01f, -2.07927272e-01f, -1.48429558e-01f,
  1.65540099e-01f, 1.01762071e-01f, 9.74305570e-02f, 7.72928447e-02f, 1.31881446e-01f, 4.36843574e-01f, 9.00457278e-02f, -3.03361975e-02f, -2.14039356e-01f, -4.34040844e-01f,
  -3.68452758e-01f, 6.03818558e-02f, -4.89091426e-02f, -2.14001741e-02f, -8.35532770e-02f, -3.67649853e-01f, -1.69161037e-01f, 8.39074850e-02f, 1.84151724e-01f, 3.16528618e-01f,
  1.96772926e-02f, 1.54446825e-01f, -1.94347389e-02f, -1.50648877e-01f, -2.95214385e-01f, -1.24485470e-01f, -9.74808484e-02f, -1.22661397e-01f, 1.39297605e-01f, 1.66259915e-01f,
  1.87200621e-01f, 3.69451717e-02f, 1.64090186e-01f, -8.34650397e-02f, 2.97095180e-01f, -8.59239697e-02f, -5.67874499e-02f, 1.65461928e-01f, -2.45714441e-01f, 3.41322459e-02f,
  -2.26989105e-01f, 1.15523882e-01f, 1.05757676e-01f, 8.90614390e-02f, 2.04853695e-02f, -1.80113494e-01f, -3.35570753e-01f, 3.12162973e-02f, 4.35336493e-02f, 6.98847696e-02f,
  6.48472533e-02f, -2.97582131e-02f, 9.37596709e-02f, -3.12022585e-02f, -8.69379491e-02f, 1.81454152e-01f, 1.63839329e-02f, 2.25421041e-01f, 1.97626483e-02f, -8.45579952e-02f,
  -1.43250465e-01f, 4.58849333e-02f, -3.31526577e-01f, -1.70862421e-01f, 7.02918768e-02f, 1.74521104e-01f, 1.17362022e-01f, 7.33850244e-03f, 1.04604475e-01f, 1.19395465e-01f,
  -2.70682633e-01f, 2.23435104e-01f, -9.32032093e-02f, 1.77109744e-02f, -7.08564594e-02f, -6.85444195e-03f, -2.25826100e-01f, -2.78329104e-02f, -3.14001560e-01f, -7.39435386e-03f,
  -1.49178728e-01f, 1.37604252e-01f, -1.47158891e-01f, 2.82749563e-01f, -8.50141570e-02f, 1.22298941e-01f, 9.97946877e-03f, 4.71094608e-01f, 1.44550636e-01f, 2.15512022e-01f,
  1.97723806e-01f, 2.73298115e-01f, 4.30102162e-02f, -1.38199016e-01f, 5.32559566e-02f, -2.65189946e-01f, 1.18424278e-03f, 8.27013478e-02f, -1.89764053e-02f, -1.64402083e-01f,
  4.19641919e-02f, -3.08318317e-01f, 1.67021956e-02f, 5.39228097e-02f, -1.54232726e-01f, 1.03270926e-01f, 2.30973065e-01f, -4.23529178e-01f, 4.74017821e-02f, 2.79832095e-01f,
  1.16357386e-01f, -6.15164526e-02f, -4.00200486e-02f, 1.39212543e-02f, 7.97914118e-02f, -2.18953751e-02f, 1.79944798e-01f, 2.56951183e-01f, 1.53828055e-01f, 1.87932760e-01f,
  4.76796962e-02f, -2.01567113e-01f, 1.90165147e-01f, 8.67141932e-02f, 1.98015139e-01f, 3.44373196e-01f, 1.38336167e-01f, 2.34243140e-01f, -4.54912931e-02f, 6.92460388e-02f,
  1.65554825e-02f, 3.81937884e-02f, 6.98313955e-03f, -2.76885122e-01f, 2.36196533e-01f, -5.23165353e-02f, -3.41633886e-01f, 2.23066099e-02f, 1.32033274e-01f, 5.25596663e-02f,
  3.60894948e-01f, -3.33938859e-02f, 2.41304934e-01f, 1.71215311e-01f, 6.60371259e-02f, -2.34582901e-01f, -2.23030716e-01f, -2.73051590e-01f, 1.38698483e-03f, -6.03237329e-03f,
  -1.75162479e-02f, -2.08721280e-01f, 3.05566955e-02f, -2.38241270e-01f, 6.92854682e-03f, -2.45581478e-01f, -2.14165375e-01f, -1.75375491e-01f, -2.78796047e-01f, 1.56032100e-01f,
  -1.54197142e-01f, 2.15630636e-01f, -8.78038928e-02f, -1.70993239e-01f, 1.87874928e-01f, 7.76859233e-03f, 1.05438260e-02f, 6.93713576e-02f, -1.74095720e-01f, 2.90529467e-02f,
  -4.88160737e-02f, 3.84514593e-02f, 7.45633468e-02f, 8.81866664e-02f, 9.87915173e-02f, -1.70313329e-01f, 2.44504973e-01f, 3.48384082e-01f, 1.27804905e-01f, -3.08678653e-02f,
  8.67713988e-02f, 2.64766634e-01f, 1.11905334e-03f, -2.11659111e-02f, 5.04680537e-02f, 2.40451783e-01f, 8.01344737e-02f, -1.59416739e-02f, 1.47449583e-01f, -8.35417733e-02f,
  1.15181342e-01f, -3.03259909e-01f, 1.52683929e-02f, 1.73881799e-02f, 1.59039423e-01f, 1.69093400e-01f, -7.03324229e-02f, 1.96011469e-01f, 2.09558919e-01f, -2.24886537e-01f,
  -9.08431262e-02f, -4.46414679e-01f, -2.51865745e-01f, 1.59377947e-01f, 4.77068909e-02f, -2.41218120e-01f, 1.58022016e-01f, -6.43028989e-02f, -1.18386172e-01f, -1.36302441e-01f,
  3.12671930e-01f, 4.72844899e-01f, 3.13781917e-01f, 1.22414216e-01f, -9.22542736e-02f, -3.37253958e-01f, -3.88050228e-01f, -3.04674506e-01f, -8.69622007e-02f, -7.15760365e-02f,
  -2.49726623e-02f, -9.55147818e-02f, 7.26090837e-03f, 1.90590337e-01f, 2.22107455e-01f, -9.92541686e-02f, 6.86054900e-02f, -3.93953882e-02f, -5.07229604e-02f, 3.84866633e-02f,
  -4.58912700e-01f, -9.66964290e-02f, 1.41848112e-02f, 1.97759792e-01f, -1.59525350e-01f, -4.42762598e-02f, 1.80335641e-01f, 5.79082631e-02f, 2.04210058e-01f, -1.69139467e-02f,
  1.56053171e-01f, 1.14795767e-01f, -1.13877833e-01f, 2.83555835e-01f, -2.26521529e-02f, 2.03188900e-02f, -2.08851218e-01f, -1.40268028e-01f, 1.18224256e-01f, 1.15989134e-01f,
  1.06468789e-01f, 2.01177225e-01f, 3.32261890e-01f, -1.10141218e-01f, 2.90569961e-01f, 2.04154730e-01f, 1.18535236e-01f, 2.30882972e-01f, 1.48457155e-01f, 5.26793189e-02f,
  1.52976662e-01f, 9.62061901e-03f, -5.22356443e-02f, -5.87889254e-02f, 4.55125093e-01f, -3.61349061e-02f, 2.87838489e-01f, 1.33506775e-01f, 1.95146844e-01f, 5.19096339e-03f,
  -9.93597209e-02f, 2.76802927e-01f, -2.79408216e-01f, 7.15805665e-02f, 1.55551538e-01f, 3.43679041e-01f, -2.84570038e-01f, 3.35533410e-01f, 2.16954023e-01f, -2.64875203e-01f,
  -1.46214422e-02f, 1.33432209e-01f, 6.00864645e-03f, 2.02131778e-01f, 1.89945370e-01f, -3.01142246e-01f, 4.88559306e-02f, -2.42708519e-01f, 3.31265658e-01f, -7.54418224e-02f,
  4.51642498e-02f, 1.64440930e-01f, 1.15686990e-01f, 2.93611474e-02f, 2.31014475e-01f, -3.15740377e-01f, 2.12090671e-01f, 1.22283503e-01f, 3.25359643e-01f, 2.34280571e-01f,
  2.94390344e-03f, 1.85131162e-01f, -1.78906228e-02f, -4.53802124e-02f, 2.73853600e-01f, 7.38552213e-02f, 1.38266711e-02f, 4.14748229e-02f, 1.04102448e-01f, 1.06146961e-01f,
  1.64032087e-01f, -1.95667124e-03f, 1.37571305e-01f, -6.48297966e-02f, 1.30105138e-01f, 8.62354338e-02f, -1.74304005e-02f, -2.16059640e-01f, -1.48517236e-01f, -1.50339663e-01f,
  -5.69913574e-02f, 1.06947139e-01f, 5.54523766e-02f, 6.87504783e-02f, 1.26299247e-01f, 9.44671314e-03f, -4.59372550e-02f, -1.01380490e-01f, -2.54327476e-01f, -7.23392814e-02f,
  -1.16191315e-03f, 3.67270231e-01f, -6.56407252e-02f, -9.37803090e-03f, 3.43135605e-03f, -3.45422059e-01f, -1.62346497e-01f, 2.51178801e-01f, 2.91193932e-01f, 2.23810285e-01f,
  1.72214791e-01f, 1.91733167e-01f, 2.13528592e-02f, -5.09120710e-02f, -1.41433656e-01f, -2.03768849e-01f, -2.91603714e-01f, 6.46942928e-02f, 2.25831494e-01f, -1.81642536e-03f,
  1.14148501e-02f, 1.84006870e-01f, -3.52985151e-02f, -9.81676951e-02f, 2.56776273e-01f, -1.25936761e-01f, -1.06759183e-01f, 2.26908803e-01f, -2.42755279e-01f, 2.51727551e-01f,
  -2.64259934e-01f, -9.02642831e-02f, -1.46351099e-01f, 8.37680772e-02f, 4.61983234e-02f, 2.20205896e-02f, -2.79908836e-01f, 2.47583807e-01f, 4.77968417e-02f, -2.97096949e-02f,
  1.12791263e-01f, 2.68034965e-01f, 1.13030180e-01f, 1.17373839e-01f, -1.71301693e-01f, 1.51920334e-01f, -7.89920241e-03f, 1.83689427e-02f, 9.51725692e-02f, 8.63256231e-02f,
  -8.36192295e-02f, -5.78492368e-03f, -2.44978189e-01f, 4.38412018e-02f, 1.35403261e-01f, 1.52663916e-01f, 1.35916546e-01f, -5.78691512e-02f, 3.45302045e-01f, -6.66389987e-02f,
  -3.04764032e-01f, 2.27376983e-01f, 5.43549098e-02f, -1.72677517e-01f, -6.40263408e-02f, 8.88694152e-02f, 4.35938686e-02f, -2.94633508e-02f, -3.24847281e-01f, -2.18669027e-01f,
  -2.06678897e-01f, 9.33345556e-02f, -9.31650698e-02f, 9.79101881e-02f, -8.01668018e-02f, 2.51216829e-01f, 1.34900779e-01f, 2.71404266e-01f, 1.85794681e-01f, 2.96156228e-01f,
  -3.33440788e-02f, 2.03038305e-01f, -2.35864185e-02f, -1.81391045e-01f, -2.04336122e-02f, -3.37960958e-01f, 6.32305965e-02f, -1.68563619e-01f, -1.10033303e-01f, -8.80573392e-02f,
  1.54476792e-01f, -1.68776989e-01f, 4.61776257e-02f, 2.10354924e-02f, -1.40820399e-01f, 7.39162415e-02f, 1.36322185e-01f, -1.64835081e-01f, 1.84845760e-01f, 3.85936528e-01f,
  2.12248072e-01f, -8.15989263e-03f, 9.58868265e-02f, 1.90997660e-01f, 3.50404203e-01f, 2.84346342e-01f, -2.97634322e-02f, 2.40817815e-01f, 2.13746265e-01f, 1.42848760e-01f,
  3.93121153e-01f, 2.71994248e-02f, 1.52920768e-01f, 3.75416130e-01f, 1.75209329e-01f, 9.14043933e-02f, 2.13688329e-01f, 2.71329045e-01f, 1.43805459e-01f, 2.84898639e-01f,
  7.76146650e-02f, 1.69212416e-01f, 3.25650513e-01f, -2.76422352e-01f, -1.81940235e-02f, 1.76009119e-01f, 1.84928998e-01f, -1.32261083e-01f, 3.38203549e-01f, 6.01550117e-02f,
  3.92866075e-01f, 3.36625189e-01f, -8.14379752e-03f, -5.16098216e-02f, -1.47897884e-01f, -1.22141920e-01f, 1.57745063e-01f, -1.86376587e-01f, -1.17518911e-02f, 3.62878770e-01f,
  2.96225220e-01f, -3.13376367e-01f, 1.90717474e-01f, -1.62660673e-01f, -1.90778896e-01f, -5.13194427e-02f, -2.01063883e-02f, -6.17114231e-02f, -5.49128540e-02f, 2.49735504e-01f,
  -8.17411393e-02f, 2.11052666e-03f, -4.96279076e-02f, -3.21181446e-01f, 2.23970741e-01f, 6.85120299e-02f, -6.59313127e-02f, 2.05178425e-01f, -2.69045085e-01f, -9.48356315e-02f,
  1.33304775e-01f, 4.17577296e-01f, 1.75972581e-01f, 2.44447485e-01f, 1.21798478e-02f, 6.54391646e-02f, -8.18103254e-02f, 5.80908731e-02f, 9.84274372e-02f, -1.26194015e-01f,
  2.80932970e-02f, 3.37813288e-01f, 1.73269913e-01f, 2.57350981e-01f, 1.75563216e-01f, -2.17385113e-01f, -1.85806546e-02f, -3.14504057e-01f, 2.93419868e-01f, 5.81811462e-03f,
  6.92292899e-02f, 1.52329937e-01f, 1.23342879e-01f, -8.20494071e-02f, 3.47878896e-02f, 1.37128502e-01f, -1.44820631e-01f, -2.36713305e-01f, 6.79892004e-02f, -1.67784598e-02f,
  -4.00977522e-01f, -5.44180088e-02f, 1.78305432e-01f, 2.06140250e-01f, 8.92688334e-02f, 9.81199667e-02f, 1.37117445e-01f, 9.47879255e-02f, 1.87195107e-01f, -2.87940782e-02f,
  -2.70824552e-01f, -2.25009039e-01f, 9.96578708e-02f, -2.30449185e-01f, -2.31156603e-01f, -4.21038568e-02f, 5.95110804e-02f, -1.46447614e-01f, -2.60594040e-01f, -5.73126189e-02f,
  -2.00459272e-01f, 1.07204821e-02f, -5.81066534e-02f, 3.65028173e-01f, -1.06102541e-01f, 2.82260031e-01f, 1.35253429e-01f, 5.02148680e-02f, 5.90040460e-02f, 3.89103293e-02f,
  6.15846366e-02f, 2.84965724e-01f, 1.27319638e-02f, 5.75838909e-02f, 1.28258970e-02f, 5.89064658e-02f
};

// L2_fan_Bp_bar (Shape: 1 x 14)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 14;
const float L2_fan_Bp_bar_data[] = {
  2.98884548e-02f, 4.29614671e-02f, 7.82802999e-02f, -7.14981789e-03f, 6.75687790e-02f, 1.44026130e-02f, 6.12594038e-02f, -2.94732638e-02f, 1.67992935e-02f, 1.17832839e-01f,
  -1.34643734e-01f, 1.14808328e-01f, 1.08247511e-01f, 1.17944419e-01f
};

// L3_fan_Wp (Shape: 25 x 64)
const int L3_fan_Wp_rows = 25;
const int L3_fan_Wp_cols = 64;
const float L3_fan_Wp_data[] = {
  -2.27789450e-02f, 2.45403662e-01f, 2.48493657e-01f, -2.10600719e-01f, 2.39774793e-01f, -7.58645609e-02f, -7.02680126e-02f, 9.94713884e-03f, 2.59067467e-03f, -1.24959694e-02f,
  2.37106219e-01f, 2.17917055e-01f, -9.33997110e-02f, -5.31362183e-02f, 1.85942389e-02f, 9.53391343e-02f, 7.09104240e-02f, 2.46778697e-01f, 1.51975185e-01f, 6.48901910e-02f,
  -1.34473756e-01f, -2.01992124e-01f, 2.07401261e-01f, 1.79217830e-01f, 1.18134134e-02f, 8.59113857e-02f, -1.62616119e-01f, 2.17913054e-02f, 8.13750550e-02f, -1.07553177e-01f,
  5.31315524e-03f, 7.73915723e-02f, -1.10113740e-01f, 2.32708126e-01f, 5.11906259e-02f, 7.73750469e-02f, 1.37892082e-01f, -1.26095369e-01f, 2.00280994e-01f, -3.03459644e-01f,
  -2.12565169e-01f, 1.89562693e-01f, -7.68566877e-02f, -2.68091913e-02f, 9.68650728e-02f, 3.69270295e-02f, 7.12363571e-02f, 2.64488816e-01f, -1.13837019e-01f, 1.29836285e-02f,
  -1.23725101e-01f, -6.80911765e-02f, 7.06617907e-02f, -6.74794838e-02f, 4.84451689e-02f, -1.36315241e-01f, -8.54723249e-03f, 2.18639776e-01f, -1.25856161e-01f, 4.09863107e-02f,
  -2.25012764e-01f, -1.48336723e-01f, 1.97911963e-01f, -5.91095090e-02f, 2.61140585e-01f, 3.09394132e-02f, 1.52435139e-01f, 2.02182025e-01f, 1.81790516e-02f, -9.03011039e-02f,
  1.06224515e-01f, 5.81590123e-02f, -6.19252361e-02f, -6.85336441e-02f, 8.46760496e-02f, 1.44588828e-01f, -2.16611952e-01f, -2.46015802e-01f, -4.16962840e-02f, 7.22967982e-02f,
  -2.77156197e-02f, 1.12347886e-01f, -1.45175382e-01f, -5.10329902e-02f, 1.74958944e-01f, -5.57943359e-02f, -1.80221908e-02f, 1.60594761e-01f, -1.81491777e-01f, 2.30057567e-01f,
  -2.49821180e-03f, 1.50441229e-01f, 2.22516105e-01f, -1.81120560e-01f, -1.25947654e-01f, -1.66425005e-01f, -1.81193590e-01f, 1.15227640e-01f, 1.61106408e-01f, -1.53907239e-01f,
  -2.89624751e-01f, 3.39061171e-01f, 3.79603170e-03f, -1.32059827e-01f, 2.01143146e-01f, 1.43733606e-01f, -1.78764880e-01f, -2.15747058e-01f, 6.39326870e-02f, -1.61917150e-01f,
  1.18146069e-01f, -3.84060591e-02f, 1.39825836e-01f, 3.45830135e-02f, -5.60706183e-02f, 8.76119733e-02f, -3.37857157e-02f, 1.95344627e-01f, 5.73049076e-02f, -1.29477814e-01f,
  2.65531719e-01f, 1.11578770e-01f, -9.43666250e-02f, -7.03530088e-02f, -9.05218944e-02f, 4.14158106e-02f, 2.52731472e-01f, 8.72934610e-02f, 1.87034637e-01f, -7.78777450e-02f,
  4.18343283e-02f, -1.97611656e-02f, 2.19459042e-01f, 4.67269421e-02f, 3.84417996e-02f, -1.18191853e-01f, -1.23489231e-01f, -8.88776258e-02f, -5.23506552e-02f, -8.18985477e-02f,
  1.11623116e-01f, -1.44467399e-01f, 3.56346145e-02f, 1.85696617e-01f, 6.31495044e-02f, 4.48247120e-02f, -1.47395745e-01f, 1.60474524e-01f, 1.41338706e-01f, 4.66993041e-02f,
  -9.84774157e-02f, 2.19688471e-03f, -5.09533919e-02f, -4.28288504e-02f, 7.86853861e-03f, 3.08811635e-01f, -2.65839025e-02f, 1.04896225e-01f, 1.54252633e-01f, -2.65691876e-01f,
  1.69964075e-01f, 7.19189178e-03f, 2.44100109e-01f, -2.61241850e-02f, 3.09638441e-01f, 7.53509551e-02f, -3.91795903e-01f, -1.34164721e-01f, 2.61980891e-01f, -1.61400005e-01f,
  1.64937869e-01f, 1.46159053e-01f, 1.71632186e-01f, 2.02850059e-01f, 3.25855240e-02f, 3.87247026e-01f, -4.43109690e-04f, 1.09371975e-01f, -1.84217934e-02f, 2.32508302e-01f,
  -1.82925537e-01f, -5.39033823e-02f, -1.25048198e-02f, -9.10991505e-02f, -1.32612392e-01f, 7.84113035e-02f, 4.71509807e-02f, 1.00726999e-01f, 6.97578266e-02f, -6.84881164e-03f,
  6.75199032e-02f, 1.66857466e-01f, -2.00561598e-01f, 1.82923660e-01f, -5.93247376e-02f, -2.29426171e-03f, -6.47505522e-02f, 1.27811491e-01f, 3.67732942e-02f, 3.48335296e-01f,
  -1.89353764e-01f, 7.35325515e-02f, 5.72587252e-02f, -5.08080684e-02f, -7.82116130e-02f, -1.84509940e-02f, -3.73707786e-02f, 1.49914011e-01f, 1.92165434e-01f, 3.44253123e-01f,
  5.62126609e-03f, 2.58928657e-01f, 3.64758790e-01f, 3.23468745e-01f, -4.98960093e-02f, 1.21495932e-01f, 1.55446514e-01f, -2.43358999e-01f, -1.66779861e-01f, 3.46357338e-02f,
  -5.66348024e-02f, 7.20810369e-02f, -2.56395135e-02f, 1.89924493e-01f, 2.35517159e-01f, -3.34704638e-01f, 1.27608716e-01f, -2.20925044e-02f, 1.21606492e-01f, 2.98898946e-02f,
  1.41632885e-01f, 2.05531344e-01f, 2.05645427e-01f, -3.32480401e-01f, 3.33651930e-01f, -4.94075343e-02f, 1.08241886e-01f, 1.19672425e-01f, -2.94962563e-02f, 6.13198206e-02f,
  -2.09760815e-02f, 3.31817120e-02f, 6.50588050e-02f, -1.18012317e-02f, -2.12306529e-01f, -1.23694828e-02f, 2.23500133e-01f, 7.44290352e-02f, 2.63496730e-02f, 1.13308825e-01f,
  2.34776944e-01f, -1.42315716e-01f, 2.99417526e-02f, -2.97166947e-02f, 3.51272486e-02f, -3.97939421e-02f, -2.22469330e-01f, -1.28788546e-01f, 2.50446126e-02f, 1.56176478e-01f,
  -1.91676885e-01f, 1.33220747e-01f, 1.27376959e-01f, 1.33940920e-01f, 7.27838948e-02f, -1.00412473e-01f, 3.48939896e-02f, 1.52988628e-01f, -2.65257023e-02f, -1.85439531e-02f,
  7.62198791e-02f, -3.41227911e-02f, -7.84928650e-02f, 1.08134538e-01f, -3.07493620e-02f, -1.92720264e-01f, -1.41764864e-01f, 4.51307535e-01f, 1.30468607e-01f, 6.71617985e-02f,
  1.07094593e-01f, -2.27104202e-01f, 2.61200741e-02f, -1.31875342e-02f, -3.65230441e-02f, -1.60955653e-01f, 4.62035500e-02f, 1.95199803e-01f, -1.88549384e-01f, -2.27149576e-01f,
  -2.10251763e-01f, -3.48771587e-02f, -4.15330641e-02f, -1.98797449e-01f, 3.51667583e-01f, 9.16898474e-02f, -1.44754916e-01f, -1.90248474e-01f, -5.58808707e-02f, 3.05911973e-02f,
  -2.01041222e-01f, 1.46182090e-01f, -9.70178545e-02f, -2.83114046e-01f, 3.84452492e-01f, -2.81020433e-01f, -5.19227870e-02f, 8.23819712e-02f, 8.59075189e-02f, -6.94684312e-02f,
  -3.22564244e-02f, 5.54911196e-02f, 2.40437940e-01f, -1.34126127e-01f, 1.43293038e-01f, -3.26586887e-02f, 1.20854042e-01f, 8.29414725e-02f, 1.06282301e-01f, -2.53313631e-01f,
  1.61536455e-01f, -2.33515829e-01f, 1.03631265e-01f, 6.69046715e-02f, -7.00250193e-02f, 2.10276648e-01f, 6.51716888e-02f, -1.78891405e-01f, -2.80520525e-02f, 1.92499667e-01f,
  -1.94098204e-02f, -2.13939864e-02f, 1.09009176e-01f, 2.64510065e-01f, -1.77598581e-01f, 1.36170432e-01f, 2.41825432e-01f, -4.65318048e-03f, -7.35304579e-02f, -2.40084797e-01f,
  2.72061881e-02f, 2.29619548e-01f, 6.55341744e-02f, 8.21029171e-02f, 9.54748169e-02f, -7.57585913e-02f, 1.39587680e-02f, 1.35533661e-01f, 2.66401738e-01f, 5.40810600e-02f,
  1.12545624e-01f, -1.96639858e-02f, 7.67842541e-03f, -1.71127751e-01f, 1.80250883e-01f, -5.69148269e-03f, 3.47076029e-01f, -5.37044043e-03f, -4.09829244e-02f, -4.90913279e-02f,
  -3.84745717e-01f, -8.15445855e-02f, -2.08306327e-01f, 1.99076593e-01f, 1.64250910e-01f, 1.63734153e-01f, 2.37916142e-01f, 1.09288961e-01f, 3.00347388e-01f, 3.02002519e-01f,
  -3.80506426e-01f, -1.39150500e-01f, -6.20151795e-02f, -7.61198178e-02f, -1.04670547e-01f, 1.10952906e-01f, -6.99201673e-02f, -1.89902738e-01f, 1.17379799e-01f, -4.96359281e-02f,
  3.69292460e-02f, -1.24519929e-01f, 1.23547532e-01f, -5.55831008e-03f, 1.77283406e-01f, 1.42399400e-01f, -4.70392555e-02f, 9.94854644e-02f, -2.74125375e-02f, -1.36904478e-01f,
  6.43057283e-03f, 1.73645914e-01f, 2.65144352e-02f, 3.41916196e-02f, 5.57495579e-02f, 7.79526904e-02f, -1.55059233e-01f, -7.38351941e-02f, 3.75136323e-02f, -1.42336428e-01f,
  -2.41972119e-01f, 6.71657920e-02f, -2.46881723e-01f, 1.65563710e-02f, 3.71041074e-02f, -2.15209499e-01f, -1.33190766e-01f, -4.12251875e-02f, -4.80626561e-02f, 3.53117853e-01f,
  -3.96771962e-03f, 2.63063520e-01f, 1.58686712e-02f, -1.04192205e-01f, 1.37250841e-01f, -1.30539060e-01f, -2.76312321e-01f, -1.04665607e-02f, 2.20477745e-01f, -1.98769659e-01f,
  -7.21082166e-02f, -4.97118533e-02f, 6.50065839e-02f, -1.13470294e-01f, 1.19291864e-01f, 1.78030685e-01f, -1.95913032e-01f, -2.14825332e-01f, 7.23942295e-02f, 1.10807985e-01f,
  1.60678804e-01f, 1.12637579e-01f, 3.42842005e-02f, 3.72798517e-02f, -1.53114358e-02f, 8.23165476e-03f, 1.26920892e-02f, 1.24564037e-01f, 3.75553314e-03f, -1.98850527e-01f,
  -1.36196464e-01f, 6.34961203e-02f, 8.35853368e-02f, -1.95524052e-01f, -1.05862543e-01f, -1.05762653e-01f, 1.06923498e-01f, 1.26784652e-01f, -2.34489873e-01f, -4.84106317e-03f,
  -2.18715191e-01f, 1.41008064e-01f, -4.54391912e-02f, 2.51152813e-02f, -1.07384324e-01f, 1.90757990e-01f, -3.06634516e-01f, -5.57091609e-02f, 2.79495299e-01f, 3.41874622e-02f,
  8.42778310e-02f, 9.04831197e-03f, 1.48269087e-01f, -1.33234054e-01f, -5.47084361e-02f, 1.89297616e-01f, -3.59227508e-02f, -1.70979708e-01f, -1.69214368e-01f, 3.69459912e-02f,
  4.88989986e-03f, 7.51553327e-02f, -2.51629818e-02f, 1.12720616e-02f, -9.46011990e-02f, -1.25554472e-01f, -1.44558370e-01f, 2.04899013e-01f, 2.42867514e-01f, -6.28272370e-02f,
  -1.13208346e-01f, -9.88167673e-02f, -2.88241863e-01f, -1.27102099e-02f, -1.71442758e-02f, -1.55975923e-01f, 4.31808829e-01f, -5.12008332e-02f, 2.71153331e-01f, 3.66440266e-02f,
  2.74913669e-01f, 2.66833976e-02f, -2.48284459e-01f, -1.79638475e-01f, 1.71330556e-01f, -1.07937969e-01f, 1.64152071e-01f, -2.55877346e-01f, 8.95989910e-02f, -4.84837294e-02f,
  -2.61385858e-01f, 8.21682960e-02f, 8.19867328e-02f, -3.95745784e-02f, 4.64002788e-02f, -4.18521352e-02f, 5.32786697e-02f, -1.14358030e-01f, -2.50597708e-02f, 1.37229651e-01f,
  8.27631168e-03f, 1.22114941e-01f, -1.66288003e-01f, -1.88202888e-01f, 1.20690398e-01f, 1.84154920e-02f, -2.47169510e-01f, 1.55345812e-01f, 5.40386550e-02f, 1.56130165e-01f,
  5.20343445e-02f, -1.51427001e-01f, -1.90578818e-01f, -9.86495465e-02f, -1.93524808e-01f, -2.77026474e-01f, 6.42746761e-02f, 4.07079756e-02f, -1.35682032e-01f, -1.82917953e-01f,
  2.29206141e-02f, -3.09482552e-02f, -1.40245423e-01f, 2.68637627e-01f, 4.28061001e-02f, 2.92535186e-01f, -1.26155719e-01f, 2.89588898e-01f, 1.59405306e-01f, 3.40821773e-01f,
  -1.53561026e-01f, -2.50193793e-02f, -1.81060642e-01f, -2.81733990e-01f, -1.26845073e-02f, 1.92050740e-01f, -3.37344073e-02f, -5.26936837e-02f, -1.17744297e-01f, -2.85772569e-02f,
  -1.71796218e-01f, -1.27244607e-01f, 2.53685955e-02f, 7.48182042e-03f, -7.28606731e-02f, 7.43705407e-02f, -5.75739853e-02f, 2.30805978e-01f, -1.23490691e-02f, -1.79403219e-02f,
  2.34036759e-01f, -1.23549208e-01f, -2.85870075e-01f, 1.22339986e-01f, 1.01980209e-01f, 1.29357323e-01f, -2.13279113e-01f, -1.54517638e-02f, 9.45799649e-02f, -2.22228728e-02f,
  -1.20163076e-01f, 2.33060494e-02f, 1.50279745e-01f, 5.98187931e-03f, 9.36505422e-02f, -3.96538861e-02f, 1.63521525e-03f, -2.18307316e-01f, -2.39900440e-01f, 1.12414137e-02f,
  -1.75478578e-01f, -2.72476058e-02f, -7.82786384e-02f, -5.40216919e-03f, -2.62368415e-02f, -6.47488832e-02f, 8.79988968e-02f, 4.16572466e-02f, 8.21147636e-02f, 3.15115936e-02f,
  3.44532095e-02f, -1.20634653e-01f, 8.59856082e-04f, -1.21651180e-01f, -5.14106229e-02f, -1.01030581e-01f, 9.54832358e-04f, 2.26470515e-01f, -1.22395769e-01f, -7.83004537e-02f,
  -2.39929944e-01f, -2.33521074e-01f, -1.43753409e-01f, 1.25342175e-01f, -1.89371463e-02f, 1.16964914e-01f, 1.69338003e-01f, 1.75960675e-01f, 1.88494205e-01f, -2.02471673e-01f,
  -2.22263157e-01f, -1.33259580e-01f, 1.66453689e-01f, -7.97899067e-02f, -1.04390845e-01f, 3.46504271e-01f, 1.11522622e-01f, -1.85899138e-01f, 1.08587362e-01f, 3.00179869e-01f,
  -2.25372806e-01f, 1.11638293e-01f, -1.58586875e-02f, -2.95572490e-01f, 2.17556655e-01f, -1.00860968e-01f, 7.26927444e-02f, -6.66179284e-02f, 1.42307468e-02f, -1.46648005e-01f,
  -1.26099139e-01f, 2.59417027e-01f, 4.17384058e-02f, -1.37982935e-01f, 1.36507172e-02f, -7.02248067e-02f, 1.10715441e-01f, 4.08854149e-02f, -1.59098968e-01f, -7.21884146e-02f,
  -1.03267901e-01f, 5.92810996e-02f, 5.00093736e-02f, 4.87155318e-02f, -1.56524759e-02f, -4.74658376e-03f, 1.68347329e-01f, 5.46150468e-02f, 8.47930238e-02f, -1.50315315e-01f,
  -1.34224057e-01f, 1.98979914e-01f, -6.42271414e-02f, -1.00565786e-02f, -1.45032942e-01f, 1.70474321e-01f, -9.12362561e-02f, 1.53334558e-01f, 6.94697276e-02f, 1.12412751e-01f,
  2.40530223e-01f, 7.32368976e-02f, -1.97348565e-01f, -2.82594003e-02f, -1.37720361e-01f, 1.92762390e-02f, -1.88497603e-02f, 2.98683733e-01f, -2.47543737e-01f, 1.31191209e-01f,
  1.30693749e-01f, -1.87346950e-01f, -1.36955187e-01f, 3.16893570e-02f, 3.34214360e-01f, 3.35492007e-02f, 1.39121011e-01f, -1.96808964e-01f, -9.31094289e-02f, -1.65440634e-01f,
  1.58481553e-01f, -9.35028717e-02f, 9.05801058e-02f, 3.06656867e-01f, 7.29652792e-02f, 1.37336254e-01f, -1.50184989e-01f, 1.71804383e-01f, 8.45423117e-02f, 1.09113129e-02f,
  1.26923069e-01f, 1.58141986e-01f, -6.66151270e-02f, -2.80122221e-01f, -1.30861113e-02f, -1.09315619e-01f, 1.23790503e-01f, 7.45235384e-02f, 4.13245261e-02f, -1.57208070e-01f,
  -3.87268364e-02f, 6.17234036e-04f, 2.09978060e-03f, 2.99103465e-02f, -2.28980109e-01f, 9.18302089e-02f, -1.06853127e-01f, -5.89017496e-02f, -2.34869033e-01f, 1.29830092e-01f,
  -5.13189845e-02f, -9.41634551e-02f, -1.51859164e-01f, -1.45637646e-01f, -2.66113281e-01f, 1.46409422e-01f, -7.54540861e-02f, -7.16391876e-02f, -1.10509440e-01f, -1.33192614e-01f,
  -9.18659568e-02f, -2.87980914e-01f, -8.52465406e-02f, 4.47467668e-03f, -1.26141846e-01f, -3.64709049e-02f, -1.26992375e-01f, -2.12579295e-02f, -1.96866002e-02f, 3.74210149e-01f,
  1.41569957e-01f, -1.95930183e-01f, 3.00283022e-02f, -9.65816006e-02f, -3.35990250e-01f, 5.18419668e-02f, -8.20977390e-02f, 2.62237668e-01f, -3.05985548e-02f, 1.80662692e-01f,
  -2.46091932e-01f, -8.45505819e-02f, 1.07860141e-01f, -1.10324528e-02f, -5.70748970e-02f, 2.41763592e-01f, -2.39606813e-01f, -1.32599682e-01f, -1.38521686e-01f, -8.11218619e-02f,
  -1.42745078e-01f, -9.37403645e-03f, -1.26971737e-01f, -2.28371426e-01f, -1.14084765e-01f, -6.87066391e-02f, 1.91013128e-01f, 1.02895394e-01f, -1.05867229e-01f, -1.75312068e-02f,
  1.89124629e-01f, -1.28870264e-01f, -2.39070699e-01f, -9.03368890e-02f, -1.51983472e-02f, 3.30838636e-02f, -6.17142916e-02f, -1.32388949e-01f, -4.48095649e-02f, 2.93106921e-02f,
  -2.67302454e-01f, 1.05183296e-01f, -8.33941922e-02f, 1.34301469e-01f, -8.73485953e-02f, 2.34964132e-01f, -2.56955534e-01f, -6.72737062e-02f, -2.66584605e-01f, 7.72283673e-02f,
  2.64791667e-01f, -4.86713573e-02f, -1.11737169e-01f, -7.12408870e-02f, -3.79637554e-02f, -3.72247510e-02f, 5.08706225e-03f, 6.15101829e-02f, 1.97003528e-01f, 1.96932957e-01f,
  -1.20991886e-01f, 6.04029596e-02f, -2.90890068e-01f, -5.38442768e-02f, -7.49094635e-02f, 2.35785306e-01f, -1.11069523e-01f, 1.92331329e-01f, -4.58413959e-02f, -1.11993991e-01f,
  1.37930587e-01f, 1.66542470e-01f, 1.24561511e-01f, 9.67298150e-02f, -7.14167627e-03f, 2.20200550e-02f, 1.94105413e-02f, 1.35091133e-02f, 2.23051265e-01f, -1.21224463e-01f,
  6.26816675e-02f, 2.62906075e-01f, -1.30966306e-01f, -4.35597263e-02f, -6.78942874e-02f, -2.19393875e-02f, 7.27981329e-02f, 9.69130918e-03f, -3.23793180e-02f, 1.50386587e-01f,
  9.87489820e-02f, -1.79718912e-01f, 4.60314332e-03f, 2.22393140e-01f, 3.01973838e-02f, -7.98487067e-02f, -3.97514701e-02f, -1.64066151e-01f, 1.97408840e-01f, -3.19949016e-02f,
  -5.50819039e-02f, 1.54625416e-01f, 4.99831103e-02f, -3.93073820e-02f, 3.92714113e-01f, 1.94948882e-01f, 5.80107905e-02f, 2.40605935e-01f, 1.11290999e-01f, -2.77594086e-02f,
  2.27755472e-01f, -7.62025546e-03f, 1.75030008e-01f, 1.37729451e-01f, -2.13780478e-02f, 1.74517244e-01f, 8.41368809e-02f, 1.60585985e-01f, 4.02280986e-02f, -3.28374170e-02f,
  3.79940495e-02f, 1.06283449e-01f, 6.59518130e-03f, 3.69918555e-01f, 1.09395728e-01f, 1.66295782e-01f, 1.71489090e-01f, -2.58426845e-01f, 1.39369011e-01f, 1.51273116e-01f,
  -9.77363437e-02f, -5.32007404e-02f, -1.69355795e-01f, -3.72339487e-01f, -1.34682432e-01f, 1.36887506e-01f, 7.05801323e-02f, 1.35575131e-01f, -5.06369509e-02f, 2.44525060e-01f,
  1.97097927e-01f, -1.20307669e-01f, -5.50353006e-02f, 6.24369904e-02f, -2.97851145e-01f, 1.20492510e-01f, 1.06263690e-01f, 3.23166735e-02f, -5.76130562e-02f, -3.24394971e-01f,
  3.80114987e-02f, -1.98701047e-03f, 4.70148996e-02f, 1.89830691e-01f, 1.40371948e-01f, 1.86271399e-01f, -3.07367984e-02f, 9.49427392e-03f, 4.04655077e-02f, -1.14617795e-01f,
  -1.93090573e-01f, -1.63672548e-02f, -4.50992286e-02f, 1.03137411e-01f, 5.61124310e-02f, -2.50497192e-01f, 8.55861604e-02f, -5.40571287e-02f, 4.43992317e-02f, -2.49429718e-01f,
  -1.20159034e-02f, -9.08025801e-02f, -5.84559292e-02f, -5.73462285e-02f, 4.25074659e-02f, 2.09749099e-02f, -8.40454772e-02f, 3.59730512e-01f, -1.24941841e-02f, 6.99457526e-02f,
  -1.14887170e-01f, -4.13853899e-02f, 3.00725270e-02f, -1.24283560e-01f, 9.09050107e-02f, 2.19026819e-01f, -1.28307687e-02f, 9.14990529e-02f, -8.62902105e-02f, -1.60401955e-01f,
  -1.73545688e-01f, -5.21447919e-02f, -1.25297904e-01f, -3.27994168e-01f, 2.31617674e-01f, -1.52084157e-01f, -9.95051935e-02f, 1.64701954e-01f, -1.36718839e-01f, -5.02812630e-03f,
  1.38044775e-01f, 2.49329448e-01f, 1.69749875e-02f, -7.10489899e-02f, -2.07444578e-02f, -1.36038095e-01f, 2.37449910e-03f, 3.19892366e-04f, 1.74641665e-02f, 8.18708241e-02f,
  2.06818223e-01f, -7.71629810e-02f, -2.10871324e-01f, -1.55940250e-01f, -1.53706595e-01f, -8.47126618e-02f, 1.68291658e-01f, 3.72271016e-02f, 2.90293932e-01f, -2.67916590e-01f,
  1.68461561e-01f, 4.24763151e-02f, 1.09507442e-01f, 1.02016985e-01f, 2.68401131e-02f, 5.48046492e-02f, -4.16585766e-02f, 3.78517210e-02f, 1.37036264e-01f, -1.66330393e-02f,
  1.49666518e-01f, -6.96023181e-02f, 7.72368163e-02f, 6.89032376e-02f, -7.89557993e-02f, -7.80011937e-02f, -1.11523829e-01f, -9.05679017e-02f, -4.24828790e-02f, 6.31257445e-02f,
  -1.74420495e-02f, -6.26621321e-02f, 1.63702816e-01f, -1.07994623e-01f, 8.21085200e-02f, 1.36055658e-02f, 5.62322047e-03f, -2.32936636e-01f, -2.48464174e-03f, -1.93866521e-01f,
  -2.65384585e-01f, -5.81786186e-02f, 9.89244506e-02f, 9.36951954e-03f, 2.44203046e-01f, 1.53521344e-01f, 1.57202423e-01f, -2.93516908e-02f, -2.40940630e-01f, 1.46129027e-01f,
  7.26047233e-02f, -2.12083489e-01f, -7.93679953e-02f, 2.94973254e-01f, 3.29050459e-02f, 1.10616619e-02f, -1.39762491e-01f, -4.28062081e-02f, 2.53748417e-01f, -2.13391677e-01f,
  -1.25848964e-01f, 2.34976113e-01f, -3.30012202e-01f, 3.58188957e-01f, -1.11399338e-01f, -1.73042998e-01f, -1.72359958e-01f, 2.71373782e-02f, 2.15709046e-01f, -4.18879502e-02f,
  -3.12158227e-01f, 1.54808223e-01f, 7.24573433e-02f, 1.04869217e-01f, -1.72085315e-01f, -1.06835045e-01f, 8.16140845e-02f, 1.49063542e-02f, -8.11775550e-02f, 6.41391650e-02f,
  4.71796058e-02f, 1.54851198e-01f, 1.38935551e-01f, -5.46297170e-02f, -1.29466832e-01f, 1.94981366e-01f, 1.22247167e-01f, 2.09425509e-01f, 7.55770728e-02f, 6.91967160e-02f,
  8.33401531e-02f, 4.71312180e-02f, 9.35529768e-02f, 1.14130378e-01f, 1.86354946e-02f, 2.23567247e-01f, 1.21782169e-01f, 1.94962129e-01f, 1.31414935e-01f, 1.77228585e-01f,
  3.62489000e-02f, 5.68360388e-02f, -1.95108037e-02f, 6.44220710e-02f, 2.09307503e-02f, -1.40839159e-01f, 9.80054736e-02f, 1.03725649e-01f, 1.32512659e-01f, 3.64926457e-01f,
  -1.11320697e-01f, 1.00529023e-01f, -6.48114681e-02f, -1.25409290e-02f, -1.47580206e-01f, -2.85449088e-01f, -1.23066224e-01f, 2.71456037e-02f, 1.73411354e-01f, -7.84837157e-02f,
  -1.62205324e-01f, 1.90383285e-01f, 8.79642293e-02f, -1.98896751e-01f, 3.32745686e-02f, -9.76160448e-03f, -9.76851135e-02f, -1.42418474e-01f, 5.16653322e-02f, -2.65560392e-02f,
  1.35637447e-01f, 2.99810857e-01f, -4.98933680e-02f, 3.35901707e-01f, -1.28069520e-02f, 1.82913497e-01f, -4.07476425e-02f, 2.82491818e-02f, 4.33169380e-02f, -2.32174665e-01f,
  3.01936120e-02f, 2.03858227e-01f, -3.85604724e-02f, 1.08537771e-01f, -7.01104105e-02f, 1.35203958e-01f, 9.30783078e-02f, 1.38396114e-01f, -1.66900009e-01f, 1.38901919e-01f,
  1.69877782e-01f, 1.33673579e-01f, -1.12522274e-01f, 1.10355407e-01f, -1.03787832e-01f, 1.21248007e-01f, 6.38389364e-02f, -5.41798249e-02f, 4.49342318e-02f, -5.53066209e-02f,
  -1.05204143e-01f, 1.08627401e-01f, -3.88825871e-03f, -8.89639556e-02f, -7.36952946e-02f, 8.85860473e-02f, 6.99992403e-02f, -1.10678256e-01f, 9.40570906e-02f, 8.04167986e-02f,
  -4.55399714e-02f, -2.00736046e-01f, 1.51487544e-01f, 1.01969182e-01f, 1.24955036e-01f, -1.20177113e-01f, -6.27603307e-02f, -1.82321817e-01f, -3.23549360e-01f, -2.67312378e-02f,
  6.74601644e-02f, -1.43105254e-01f, -2.27226987e-01f, 7.52898902e-02f, -2.80190885e-01f, -7.78257772e-02f, 1.80924267e-01f, -1.62833631e-01f, 1.77822098e-01f, -1.43387923e-02f,
  1.02916872e-03f, -2.43690476e-01f, -1.23559885e-01f, -7.12466240e-02f, -9.84179378e-02f, -3.16013843e-01f, -6.48556426e-02f, -1.22272328e-01f, 2.42656067e-01f, 1.37446702e-01f,
  -1.01323240e-01f, 1.76383272e-01f, 1.39765024e-01f, 2.53830757e-03f, 1.75567597e-01f, -1.09774448e-01f, -7.88026601e-02f, 4.29323278e-02f, -1.29587531e-01f, 5.19386046e-02f,
  -1.37060955e-01f, -5.53693213e-02f, 2.17755333e-01f, 1.54190268e-02f, -1.37159199e-01f, -1.98945463e-01f, -2.59328008e-01f, 1.81686446e-01f, -4.37809229e-02f, 2.09336251e-01f,
  -9.34263468e-02f, 2.85340175e-02f, -8.58247057e-02f, -1.61659300e-01f, -2.91094810e-01f, -1.54340237e-01f, -1.22420676e-01f, 5.57209663e-02f, 5.99940494e-02f, -1.61668956e-02f,
  3.00285295e-02f, -6.63735271e-02f, -5.26074432e-02f, 2.06464007e-02f, -1.09084565e-02f, -2.19550163e-01f, -1.97874621e-01f, -6.52737543e-02f, 3.31373662e-02f, -2.35029250e-01f,
  1.00693896e-01f, 3.85615751e-02f, -4.40518185e-02f, 1.89697161e-01f, 1.75862148e-01f, -3.24563235e-01f, 4.63416092e-02f, -1.90837458e-01f, -9.91779193e-02f, 8.02160501e-02f,
  -2.12851793e-01f, 1.45796537e-01f, -8.93337503e-02f, -1.05636530e-01f, -6.39087036e-02f, -7.00861588e-02f, -2.63292044e-01f, 1.89202696e-01f, 2.87630618e-01f, 6.26596138e-02f,
  -1.58522084e-01f, 1.06892921e-01f, -1.84759036e-01f, -1.91576824e-01f, 8.19201022e-02f, 1.07348904e-01f, 1.50151011e-02f, 1.69178277e-01f, 6.36595264e-02f, 2.33301848e-01f,
  1.05570434e-02f, -3.12332451e-01f, -9.74566769e-03f, -7.81774670e-02f, 1.29024228e-02f, 4.68664356e-02f, 3.16091210e-01f, 1.95364118e-01f, -1.41917139e-01f, -2.08242044e-01f,
  -1.85018897e-01f, 9.29157585e-02f, 1.66903391e-01f, 1.43223658e-01f, -1.35217071e-01f, 1.21343851e-01f, 5.42158298e-02f, 3.19748744e-02f, -3.24991733e-01f, -2.70285010e-01f,
  -3.04643273e-01f, 3.66031080e-02f, -6.08831719e-02f, 1.81510657e-01f, -1.14840984e-01f, -4.37420122e-02f, 6.06005872e-03f, -3.06940496e-01f, -1.22033820e-01f, -1.67981267e-01f,
  -2.89067507e-01f, 1.20069362e-01f, -1.33545399e-01f, -1.48819713e-02f, 2.25152925e-01f, -1.12898462e-01f, 5.72556667e-02f, 2.26793900e-01f, -7.80010968e-02f, -2.53839586e-02f,
  2.55886763e-01f, -1.26087606e-01f, -1.91786036e-01f, -9.89316255e-02f, -1.10327862e-01f, -2.80537933e-01f, -1.00411877e-01f, 2.65977532e-01f, -2.43551694e-02f, -2.97811925e-01f,
  -3.18285078e-01f, 5.14917076e-02f, 1.68596387e-01f, 1.86243176e-01f, -2.05618329e-02f, -5.97307719e-02f, -1.71000689e-01f, -2.35536084e-01f, -6.15588902e-03f, 5.27640209e-02f,
  1.97747603e-01f, 1.09055145e-02f, 6.63089380e-02f, 1.07603528e-01f, 6.73201606e-02f, -6.76033199e-02f, 1.64444409e-02f, -1.08219333e-01f, 9.08074081e-02f, 2.02877074e-01f,
  -4.99408729e-02f, -2.31109560e-01f, -6.87538162e-02f, -5.61310798e-02f, 8.48357752e-02f, -7.85874203e-02f, 2.67262161e-01f, -6.45906702e-02f, 1.39973313e-01f, 1.51832774e-01f,
  4.22501974e-02f, -1.12451605e-01f, 2.08285987e-01f, -3.63734476e-02f, 1.14115715e-01f, 8.86522904e-02f, -2.85408683e-02f, 5.30343428e-02f, -1.42321810e-01f, -1.15476072e-01f,
  1.36541918e-01f, 8.86694491e-02f, 7.37591647e-03f, -3.14095826e-03f, 1.80780649e-01f, -1.49296835e-01f, 8.95881802e-02f, 8.15737024e-02f, 1.88395008e-02f, -9.57469828e-03f,
  1.65087521e-01f, 7.41067007e-02f, -8.86189416e-02f, -2.72619516e-01f, -7.91510344e-02f, -9.41828415e-02f, 2.93070793e-01f, -5.61541505e-02f, 3.06922514e-02f, 2.75778115e-01f,
  -7.98927024e-02f, -1.23982981e-01f, -1.18752748e-01f, 3.56027633e-01f, 5.50027527e-02f, -4.83577587e-02f, -1.17416859e-01f, 7.37010241e-02f, 1.40654325e-01f, -2.31943335e-02f,
  1.79263309e-01f, 2.82921083e-02f, -1.28562182e-01f, -8.49276874e-03f, -1.28566846e-01f, 2.39203647e-01f, 1.33384848e-02f, -1.03599675e-01f, 2.29036555e-01f, 2.56627023e-01f,
  1.41117945e-01f, 1.85637072e-01f, -1.04302224e-02f, -7.95946568e-02f, -2.08328933e-01f, -5.34667596e-02f, 2.73684949e-01f, -3.06358457e-01f, 1.45597681e-01f, -3.73869874e-02f,
  1.26635358e-01f, -1.38412580e-01f, 2.61799753e-01f, -6.20571151e-02f, -2.38363549e-01f, 1.26859903e-01f, -1.65462680e-02f, -2.46100858e-01f, 3.73683870e-02f, 1.44995660e-01f,
  -1.66823760e-01f, -1.62712917e-01f, 4.88295704e-02f, -1.91109981e-02f, 6.57383502e-02f, 1.16428845e-02f, -9.00723115e-02f, -4.82003018e-02f, 1.20515794e-01f, 3.41945469e-01f,
  -1.29900455e-01f, 2.80382764e-02f, 1.62625805e-01f, -1.77329928e-01f, -4.12307113e-01f, -2.41894007e-01f, 1.17010795e-01f, 3.18433881e-01f, 1.69166580e-01f, 2.42843837e-01f,
  -2.11714685e-01f, 6.76316619e-02f, -2.16672182e-01f, -1.24802575e-01f, -3.87463765e-03f, -1.06048383e-01f, -1.14766873e-01f, -3.79328267e-03f, 9.37168747e-02f, -1.61172882e-01f,
  -1.66521862e-01f, 4.89406139e-02f, -2.52434194e-01f, 1.94205433e-01f, -3.04478556e-01f, 9.07483846e-02f, 1.45977214e-01f, 7.22779632e-02f, -5.48493452e-02f, 2.37485077e-02f,
  8.88453126e-02f, 1.41353428e-01f, 5.56077808e-03f, 1.46195039e-01f, -7.47844502e-02f, 1.45163402e-01f, 4.98299580e-03f, 1.25755638e-01f, 1.59069747e-01f, 9.06714518e-03f,
  -4.37131152e-02f, -6.29798770e-02f, 1.29438668e-01f, -5.49852178e-02f, -2.00625330e-01f, -1.38295880e-02f, -6.85290769e-02f, -7.21717551e-02f, 6.66017160e-02f, 1.13413505e-01f,
  2.90667206e-01f, 1.40708163e-01f, 4.66417372e-02f, -9.36551690e-02f, 8.66870210e-02f, -7.70052448e-02f, -4.10059504e-02f, 1.97764505e-02f, 6.65269420e-02f, -2.46979713e-01f,
  -1.80531517e-01f, -2.17852533e-01f, -5.82324974e-02f, -1.51619866e-01f, -1.11045599e-01f, -4.23069932e-02f, -9.91284382e-03f, 7.46385530e-02f, 2.54388899e-01f, 1.29986003e-01f,
  -2.12820157e-01f, 2.66794600e-02f, 1.08238891e-01f, -1.98268786e-01f, 1.51193470e-01f, -1.16300136e-02f, -2.56072551e-01f, 1.04553618e-01f, 2.32369795e-01f, 1.60549492e-01f,
  1.52008876e-01f, 9.70240757e-02f, -1.19860731e-01f, 6.40985444e-02f, 1.47406906e-01f, 6.21771775e-02f, -4.28291336e-02f, 1.44778416e-01f, 2.27245793e-01f, 3.97075526e-02f,
  -6.84486404e-02f, -1.66089311e-01f, -8.52246359e-02f, -1.85043111e-01f, -1.41497508e-01f, 1.79838777e-01f, -1.24103194e-02f, -1.73939532e-03f, -1.78539768e-01f, -7.06078783e-02f,
  -1.11367859e-01f, 1.91158488e-01f, 2.12073289e-02f, -3.08322981e-02f, 6.39492869e-02f, 3.53560895e-02f, 2.02200934e-01f, 1.54058516e-01f, 2.95326769e-01f, 9.29871574e-02f,
  1.10873446e-01f, 4.92200963e-02f, -3.94915119e-02f, 1.97563812e-01f, -4.73440215e-02f, -1.54020026e-01f, 2.19775856e-01f, 1.50056943e-01f, 4.89991121e-02f, -4.12709229e-02f,
  4.33816090e-02f, 2.50512976e-02f, -2.34055072e-02f, 1.91066757e-01f, 1.55923113e-01f, 2.22275451e-01f, 2.14498401e-01f, -1.85624212e-02f, -4.98712957e-02f, 4.65737171e-02f,
  3.29490751e-02f, 6.82418197e-02f, 7.97675084e-03f, -1.23729594e-01f, -2.06547365e-01f, 1.80193678e-01f, 1.84799090e-01f, 2.75356472e-01f, 1.48963809e-01f, -1.63802654e-01f,
  1.78810954e-01f, -1.87937319e-01f, -1.41919568e-01f, 6.17166758e-02f, -8.80013779e-02f, 3.34624499e-01f, 7.49386176e-02f, 1.46061992e-02f, -2.69271463e-01f, 1.08098969e-01f,
  -1.59822349e-02f, -1.66973487e-01f, -1.98147088e-01f, 7.93843567e-02f, 1.32967949e-01f, 1.45471450e-02f, -1.35632411e-01f, -8.36266484e-03f, 8.31878483e-02f, 3.16297933e-02f,
  6.92530200e-02f, 7.44522139e-02f, 1.95867196e-01f, 1.20679528e-01f, 2.78377980e-01f, -1.41297758e-01f, -3.84529382e-02f, -1.79099828e-01f, 2.18958750e-01f, -9.36838686e-02f,
  -4.29046750e-02f, 2.26928107e-03f, 1.41738907e-01f, 4.53877263e-02f, 1.73273951e-01f, -2.05900360e-04f, 4.06875014e-02f, -2.48204134e-02f, -1.64515004e-01f, -1.54894456e-01f,
  -4.64401543e-02f, 8.66888911e-02f, 1.58986643e-01f, 1.97615802e-01f, -6.49632663e-02f, -1.62226781e-01f, 2.68145621e-01f, 9.06542689e-02f, -6.53886721e-02f, 2.09072493e-02f,
  -6.27203956e-02f, -2.34045789e-01f, 6.28196821e-02f, 7.61783049e-02f, 1.46679744e-01f, -8.50657672e-02f, -4.64275433e-03f, -4.04341929e-02f, 3.21781598e-02f, -3.00604403e-01f,
  3.68714660e-01f, -3.86231780e-01f, 1.60786733e-02f, -6.06303625e-02f, -2.35774726e-01f, 7.66243711e-02f, 2.56499380e-01f, -2.89611250e-01f, 5.22758216e-02f, -3.70788306e-01f,
  -4.67600524e-02f, 2.06739113e-01f, 5.04582264e-02f, 1.51617453e-01f, 9.69159454e-02f, 7.49922171e-02f, 1.38439626e-01f, -3.30907442e-02f, -1.41074240e-01f, 1.12783976e-01f,
  8.36019963e-02f, -2.28597168e-02f, 2.03682825e-01f, 1.25442103e-01f, 1.42022595e-01f, -2.36187264e-01f, -2.87643913e-02f, 9.02017355e-02f, -1.00305304e-01f, -5.95963411e-02f
};

// L3_fan_Wp_bar (Shape: 14 x 64)
const int L3_fan_Wp_bar_rows = 14;
const int L3_fan_Wp_bar_cols = 64;
const float L3_fan_Wp_bar_data[] = {
  9.30220708e-02f, 1.32708177e-01f, 5.88188842e-02f, -1.41630784e-01f, 9.09470692e-02f, 5.66405542e-02f, 6.51841164e-02f, -1.24501921e-01f, -4.52586934e-02f, 2.34081388e-01f,
  1.08561628e-02f, -9.85786319e-03f, 9.42103416e-02f, 2.48490870e-01f, -1.55127704e-01f, -6.06909255e-03f, 2.27348790e-01f, -7.07369819e-02f, 6.09883815e-02f, 1.27987728e-01f,
  2.07842141e-01f, 3.27062368e-01f, 1.64174423e-01f, -1.53337438e-02f, 2.75940061e-01f, -2.43790224e-01f, -2.46939838e-01f, -4.60772842e-01f, 2.06783667e-01f, -2.16920078e-02f,
  -2.03155261e-02f, 2.75513649e-01f, 2.58679450e-01f, -2.11329684e-01f, -9.72105339e-02f, 1.77309699e-02f, 2.64404833e-01f, 2.95453459e-01f, 1.02885164e-01f, 1.74717993e-01f,
  -2.25202382e-01f, -2.07379013e-01f, 2.28741556e-01f, 1.56841159e-01f, -2.61414871e-02f, -2.76517451e-01f, 1.02095582e-01f, -3.95571515e-02f, -2.96918452e-01f, 5.55677973e-02f,
  -1.98949322e-01f, -2.15531945e-01f, 5.02007604e-01f, -1.08995333e-01f, 2.36113206e-01f, 5.04144788e-01f, -2.08473951e-01f, 8.13117921e-02f, 5.30431688e-01f, 3.38000596e-01f,
  3.69614094e-01f, 2.38734949e-02f, 3.24968368e-01f, -3.79733220e-02f, -3.37247074e-01f, -6.55720457e-02f, 1.18815556e-01f, 1.47651419e-01f, 1.22957774e-01f, -3.53440791e-01f,
  -7.69695565e-02f, -2.47140884e-01f, 2.20799536e-01f, 6.08335510e-02f, 1.90982834e-01f, 4.00131881e-01f, -5.16182184e-02f, -1.27225332e-02f, 1.21137150e-01f, -1.87709004e-01f,
  -1.55787483e-01f, -2.75761336e-01f, 1.41809434e-01f, 3.85595672e-02f, -4.19261493e-02f, 1.79160208e-01f, -2.25540362e-02f, -1.54382568e-02f, -1.97918430e-01f, -1.94210067e-01f,
  -2.78575812e-02f, -3.05899918e-01f, -1.31904885e-01f, -6.11461215e-02f, -2.01828986e-01f, 5.09061776e-02f, -1.13591291e-01f, -1.66310966e-01f, 3.99542637e-02f, 9.11003873e-02f,
  -9.17501599e-02f, -1.56445742e-01f, 6.31902516e-02f, 3.46873313e-01f, 3.47565413e-02f, -6.43015876e-02f, 2.03583837e-01f, -1.82029337e-01f, 1.61971331e-01f, -1.48096219e-01f,
  -1.83496758e-01f, -2.51918852e-01f, 8.82771313e-02f, -3.04279804e-01f, 4.25296932e-01f, 2.36174941e-01f, -2.40621865e-02f, -3.04465443e-02f, -6.60855398e-02f, 1.15370154e-01f,
  1.16823792e-01f, -1.14194438e-01f, -5.37217893e-02f, 2.34121859e-01f, -1.18263453e-01f, 1.05979271e-01f, -7.58639276e-02f, 8.34060833e-02f, 1.92214251e-01f, -2.94784248e-01f,
  2.17050478e-01f, -3.40731144e-02f, 1.59771174e-01f, -5.77732101e-02f, 2.01091081e-01f, -1.16996646e-01f, 3.82021427e-01f, 1.45796165e-01f, -3.92596126e-02f, 2.07221970e-01f,
  2.18899325e-01f, 1.57663375e-01f, -5.50822206e-02f, -1.42711446e-01f, 9.07722637e-02f, -1.70422152e-01f, 1.47934392e-01f, -1.26370475e-01f, -4.76230197e-02f, 1.97455704e-01f,
  1.80005223e-01f, 1.87749006e-02f, -2.56667674e-01f, -8.48546028e-02f, 2.14258462e-01f, -2.68896937e-01f, 2.22209081e-01f, -3.19023058e-02f, -1.31900042e-01f, 7.38734230e-02f,
  -1.66160122e-01f, -2.84180623e-02f, 5.30122556e-02f, 2.17230916e-01f, -1.34348124e-01f, 1.30950836e-02f, 8.61653686e-02f, -2.32298374e-02f, -2.97975391e-01f, -3.31233721e-03f,
  -3.24926108e-01f, 2.87129641e-01f, 1.67212293e-01f, -1.45501597e-02f, -2.55858958e-01f, -3.40068787e-01f, 2.86485106e-01f, -2.19375402e-01f, 1.57569245e-01f, 2.08798990e-01f,
  4.31261927e-01f, -1.59845755e-01f, -1.84755191e-01f, 3.74655336e-01f, 1.20832630e-01f, -1.03305437e-01f, 1.81022342e-02f, 6.92655519e-02f, 2.42104396e-01f, 2.38469988e-01f,
  3.12890083e-01f, -1.33849993e-01f, -2.01726053e-02f, 1.86995775e-01f, 1.21114753e-01f, 1.07122988e-01f, 2.87998617e-01f, -9.97526795e-02f, 1.38675666e-03f, 7.60623887e-02f,
  3.69491786e-01f, -1.77831098e-01f, 1.21364512e-01f, 3.20474416e-01f, 1.30954515e-02f, -4.25684489e-02f, 2.29740888e-01f, 6.63629873e-03f, -4.43451591e-02f, 1.25843123e-01f,
  1.68901589e-03f, 2.26691023e-01f, 5.59512153e-02f, -5.78289218e-02f, -9.34494287e-02f, 2.32875422e-01f, 8.65322202e-02f, 2.77205765e-01f, -3.43315043e-02f, 2.61521041e-01f,
  2.47904181e-01f, -1.33696020e-01f, -1.44129097e-01f, -2.86340594e-01f, -3.80385190e-01f, 2.44953915e-01f, 4.11973119e-01f, 8.16428363e-02f, 5.51025607e-02f, -3.94856259e-02f,
  -2.17995141e-02f, -1.69306353e-01f, -2.87723690e-01f, 3.31923991e-01f, -2.15467121e-02f, 2.00857013e-01f, 2.73467392e-01f, -1.86839283e-01f, 1.58803184e-02f, 4.26222056e-01f,
  3.93805727e-02f, 8.93444866e-02f, -2.14699864e-01f, 2.94562012e-01f, -7.33390963e-03f, -2.48385444e-02f, 2.28295736e-02f, -6.90470710e-02f, -1.83652326e-01f, 3.67596835e-01f,
  -1.39021516e-01f, 2.45423391e-01f, 8.34672898e-02f, 1.49960548e-01f, 4.86389399e-01f, 2.73985922e-01f, -1.23165920e-01f, -3.77463214e-02f, 1.94366395e-01f, -5.75288273e-02f,
  2.06740052e-01f, 3.03203374e-01f, -1.27793133e-01f, -1.66607663e-01f, 3.76532897e-02f, 2.51794845e-01f, 5.42365648e-02f, 3.35545182e-01f, -3.40541899e-01f, 2.48377487e-01f,
  -9.44977906e-03f, 9.11962837e-02f, 9.36193168e-02f, -2.12108299e-01f, 2.38245279e-02f, 2.76977301e-01f, 3.31596345e-01f, -1.19743031e-02f, 1.77611113e-02f, -1.85982034e-01f,
  -2.01123178e-01f, 5.90214841e-02f, -3.12157243e-01f, -9.83963832e-02f, 2.95208693e-01f, -2.89193898e-01f, -3.90385926e-01f, -1.53895706e-01f, 1.72373235e-01f, 1.37405381e-01f,
  2.61606202e-02f, -3.57829928e-02f, -2.97237605e-01f, 3.21780980e-01f, -2.87913054e-01f, -3.50795150e-01f, 2.62481421e-01f, -9.32002962e-02f, 1.28277913e-01f, -4.40689206e-01f,
  -2.35553667e-01f, 3.06555957e-01f, 1.48508057e-01f, 1.87093560e-02f, -4.69345748e-01f, 3.64434868e-01f, 6.15313202e-02f, -1.50600160e-02f, 8.93180594e-02f, 4.37314212e-01f,
  4.26507115e-01f, -1.60919115e-01f, -3.09750319e-01f, 2.62961656e-01f, -3.33687030e-02f, -2.16309160e-01f, -3.07549447e-01f, -1.61151946e-01f, 1.35109022e-01f, 2.03663051e-01f,
  2.38836065e-01f, 5.97582906e-02f, 2.06763923e-01f, 7.20027164e-02f, 9.97133106e-02f, 2.08628953e-01f, -7.09641899e-04f, 2.59732276e-01f, -2.96167284e-02f, 2.47059897e-01f,
  1.75639212e-01f, 1.71283132e-03f, 7.73467943e-02f, 3.34807932e-01f, 3.03811073e-01f, 3.42014819e-01f, 2.76180089e-01f, 2.44910792e-01f, 8.31583440e-02f, -2.18188956e-01f,
  7.26826787e-02f, 1.58027783e-01f, 1.61788926e-01f, 1.88379019e-01f, 2.66493052e-01f, 2.59088188e-01f, 1.86749831e-01f, 1.86113715e-02f, 1.90894783e-01f, -5.33002578e-02f,
  -2.31024057e-01f, -1.81513444e-01f, -1.28371462e-01f, 2.24285081e-01f, 1.61286771e-01f, 2.79009771e-02f, -1.52641416e-01f, 4.13140208e-02f, 2.34296635e-01f, -1.34278119e-01f,
  -2.44400516e-01f, 1.76845774e-01f, -2.54914135e-01f, 2.64007151e-01f, 1.79710045e-01f, -1.01778135e-01f, 4.77897264e-02f, 3.06922495e-01f, 2.31520683e-01f, 3.01750917e-02f,
  -1.16454303e-01f, 3.03260982e-01f, 1.79767281e-01f, 8.57938752e-02f, 1.60982639e-01f, 9.22590420e-02f, 2.96388656e-01f, 8.89686123e-02f, 6.79859519e-02f, 5.08969799e-02f,
  1.47926763e-01f, 3.67572129e-01f, 5.07659972e-01f, -7.82590881e-02f, 1.26016960e-01f, -2.69185394e-01f, 3.17050666e-01f, 2.68689990e-01f, 8.45368654e-02f, -7.15386420e-02f,
  2.44181499e-01f, 2.31540762e-02f, 2.04568490e-01f, 2.72677243e-01f, 2.75029808e-01f, -1.22285150e-02f, -7.28570893e-02f, 5.12958094e-02f, 1.70226380e-01f, 2.65522450e-01f,
  1.09443583e-01f, 5.44510260e-02f, -9.29909423e-02f, -5.83542466e-01f, -1.16898641e-01f, 1.41521432e-02f, 3.61725271e-01f, 1.36316314e-01f, 8.65453333e-02f, -3.29958260e-01f,
  2.25657716e-01f, 1.38214901e-01f, -2.32403383e-01f, -3.46898347e-01f, -3.30875739e-02f, -2.42825046e-01f, -1.94772542e-01f, -2.21302565e-02f, -2.16408089e-01f, -2.10715294e-01f,
  -4.62465078e-01f, 2.64550477e-01f, 9.57256481e-02f, 1.27191246e-01f, 6.69938922e-02f, 4.06414345e-02f, -4.22506392e-01f, -2.37961352e-01f, -6.43446743e-02f, -2.31135003e-02f,
  1.34332806e-01f, -3.87670130e-01f, 3.49631369e-01f, -6.82267398e-02f, 1.49986565e-01f, 2.36643016e-01f, 1.63434312e-01f, 4.33215767e-01f, -1.47561297e-01f, 9.08280909e-02f,
  5.48151493e-01f, -4.51012664e-02f, -1.57093853e-01f, -1.16293421e-02f, -2.54060831e-02f, 3.16213518e-01f, 1.73037350e-02f, -5.28433770e-02f, 3.14227372e-01f, -1.34565145e-01f,
  3.07868809e-01f, -1.10259235e-01f, 3.15031670e-02f, 5.53225093e-02f, 3.19279432e-01f, 1.08927757e-01f, 8.72953087e-02f, 1.56434894e-01f, -5.91878518e-02f, -3.01474333e-01f,
  1.98714465e-01f, -7.19444230e-02f, -7.01633561e-03f, 2.84815431e-02f, 5.02373874e-01f, 5.24866283e-02f, 1.62205175e-01f, 6.51614293e-02f, -1.28111109e-01f, -1.12675942e-01f,
  1.57717198e-01f, 1.58391729e-01f, 1.57787919e-01f, -2.91568130e-01f, -7.09027648e-02f, 1.26752451e-01f, 3.95047903e-01f, -7.19742477e-02f, 3.57282281e-01f, 3.21814120e-01f,
  1.93058357e-01f, -2.32584655e-01f, 1.48537129e-01f, -3.65952104e-01f, 3.05809051e-01f, 2.24351838e-01f, -3.40457618e-01f, 3.89518917e-01f, -1.67055622e-01f, -1.37017548e-01f,
  -2.61738896e-01f, 1.76826641e-01f, -1.56083047e-01f, 2.38808081e-01f, 2.94218510e-01f, 2.77262591e-02f, -7.49198943e-02f, 3.55850607e-01f, -5.19733012e-01f, -1.76621467e-01f,
  2.78179258e-01f, 1.39367118e-01f, -4.32592295e-02f, 2.61036515e-01f, -2.00251684e-01f, 2.76546180e-01f, 3.80945683e-01f, -2.33490527e-01f, 3.42687249e-01f, -2.05439508e-01f,
  1.98313877e-01f, 2.45732471e-01f, 4.06463359e-18f, 4.91457792e-40f, 1.57831593e-19f, -4.83767524e-22f, -1.69109887e-20f, -8.02513921e-18f, 7.29669768e-23f, -3.55078311e-27f,
  -6.43057188e-19f, 4.92386853e-40f, 5.87445037e-33f, -3.02789269e-20f, 1.59735368e-37f, 4.92903932e-40f, -2.22772131e-20f, 4.94378098e-40f, 4.47983318e-18f, 2.27880558e-40f,
  -2.99347255e-18f, -1.31686192e-22f, -2.24833329e-20f, 4.91883787e-40f, 2.38253151e-25f, -5.65997829e-22f, -6.03376365e-33f, 4.95042314e-40f, -6.98670660e-19f, -1.07656436e-39f,
  -7.09618518e-29f, -1.22622728e-30f, -4.94896579e-40f, -4.10529162e-26f, -1.87835317e-22f, 4.93367762e-40f, 2.04299901e-18f, -1.36106770e-20f, 3.26215276e-40f, -1.98514985e-19f,
  7.61651313e-19f, 4.98263862e-34f, 1.02520289e-18f, 4.90940713e-40f, -3.67131423e-19f, -4.91111671e-40f, -5.23418840e-28f, -1.32857650e-33f, -1.01479973e-17f, 3.76915532e-23f,
  4.47682801e-27f, 1.30733262e-20f, -3.73904300e-19f, 4.91819327e-40f, 4.95130595e-40f, -6.50790486e-21f, 4.65812629e-40f, -1.10577459e-33f, -4.92952978e-40f, -1.27931866e-12f,
  -4.94124463e-40f, -1.99136662e-15f, 4.92046338e-40f, 4.93143554e-40f, 4.94257587e-40f, -8.87549056e-09f, 8.57755616e-02f, 4.93908226e-01f, -1.46907672e-01f, 2.01799404e-02f,
  -4.49495614e-02f, 9.04468354e-03f, -1.66934893e-01f, -1.33819699e-01f, -3.56631547e-01f, 3.45009774e-01f, 3.56241196e-01f, 9.33283865e-02f, -1.87636733e-01f, 3.04427207e-01f,
  -1.27500787e-01f, 1.52419293e-02f, 1.95701867e-01f, 8.80611539e-02f, -6.12126552e-02f, 8.13921466e-02f, 2.38826573e-01f, 4.65506362e-03f, 1.71674594e-01f, 8.85982625e-03f,
  2.66015470e-01f, 1.62485652e-02f, 1.46978451e-02f, -5.52585483e-01f, 3.16292316e-01f, -1.66621342e-01f, -9.54247788e-02f, 4.86474186e-01f, 2.59081006e-01f, -2.57724255e-01f,
  -4.19976711e-01f, -3.63150872e-02f, 1.23173960e-01f, 1.45837694e-01f, 6.10082090e-01f, -6.61338791e-02f, -9.60104913e-02f, 1.30666792e-02f, 3.77367824e-01f, -3.88571322e-01f,
  -9.81729627e-02f, -3.71598810e-01f, 2.67347068e-01f, -1.24357633e-01f, -4.14109051e-01f, -2.07183883e-01f, 2.93487281e-01f, -3.77183557e-01f, 3.24089751e-02f, 1.77109361e-01f,
  4.21262622e-01f, 1.87547103e-01f, -7.21373176e-03f, 1.87682629e-01f, 1.30140394e-01f, 3.61162245e-01f, -1.93721458e-01f, 6.34058788e-02f, 1.85375839e-01f, -4.27954607e-02f,
  -2.97747344e-01f, -6.88854977e-02f, 4.76007946e-02f, -2.65028737e-02f, -2.29392722e-02f, -1.57729238e-01f, -8.20006803e-02f, -4.13517728e-02f, 1.46509722e-01f, 2.04024225e-01f,
  5.84055819e-02f, 5.20996116e-02f, -2.26948068e-01f, -1.46682978e-01f, 8.59705359e-02f, -8.49152580e-02f, -8.87307674e-02f, -1.11538753e-01f, -1.16441391e-01f, -1.34207174e-01f,
  9.34738293e-02f, -1.11842193e-01f, 6.69349544e-03f, -2.32142791e-01f, -5.75567856e-02f, -9.07102078e-02f, 1.41666278e-01f, -4.13414508e-01f, -2.59659857e-01f, -2.18430609e-01f,
  -2.85203934e-01f, -5.55869602e-02f, 2.60658205e-01f, -9.20618251e-02f, -4.80165184e-01f, 8.61344635e-02f, -5.97486615e-01f, 1.68341160e-01f, -5.63697256e-02f, 2.46000767e-01f,
  3.85468006e-01f, -7.04547465e-02f, 1.25819370e-01f, -3.46810579e-01f, -1.43713161e-01f, 7.06470013e-02f, -3.10703041e-03f, -5.44243574e-01f, -6.75585866e-02f, -1.21635489e-01f,
  4.72693980e-01f, 6.44102842e-02f, 1.16498150e-01f, 4.59493965e-01f, 3.01291913e-01f, 1.07007377e-01f, 2.52495706e-01f, 3.02357376e-02f, -5.10029159e-02f, 9.57985148e-02f,
  -6.81221262e-02f, 1.32785589e-01f, -1.16590522e-01f, 2.06337139e-01f, -6.12007260e-01f, 1.81800291e-01f, 1.18740991e-01f, 2.05924418e-02f, 9.73717794e-02f, -2.04108343e-01f,
  1.76956028e-01f, 3.62031162e-01f, -1.77756190e-01f, 6.46431446e-02f, 8.18937086e-03f, -1.18190967e-01f, -4.22934771e-01f, -3.95876110e-01f, 1.85351282e-01f, 3.81019980e-01f,
  -3.11656862e-01f, 4.12792057e-01f, -1.85724244e-01f, 1.04618795e-01f, 3.04397762e-01f, -5.17337620e-02f, 1.11352541e-01f, 1.86397046e-01f, 1.23773836e-01f, 7.62567222e-02f,
  -1.45643249e-01f, 2.69148052e-02f, -1.62799865e-01f, -2.10310102e-01f, -1.58946797e-01f, -2.55862921e-01f, 1.85080796e-01f, -5.39021716e-02f, -1.05597526e-01f, -4.95170467e-02f,
  -1.38850495e-01f, -8.28208253e-02f, 6.87117875e-02f, 1.12594619e-01f, 4.65738922e-02f, -7.36480802e-02f, 4.03480709e-01f, -3.23566914e-01f, -9.46566090e-02f, 1.36950240e-02f,
  1.10804521e-01f, 1.97032794e-01f, -7.52904341e-02f, -1.58097163e-01f, 8.74658376e-02f, 8.64820480e-02f, -1.81661606e-01f, 2.82831341e-01f, 1.47100553e-01f, 3.93219218e-02f,
  3.15339237e-01f, 7.86747783e-02f, 3.26129615e-01f, 2.49882326e-01f, -4.31072861e-02f, 1.68938041e-01f, -1.50584029e-02f, 1.96735505e-02f, -2.89605558e-02f, 1.06849365e-01f,
  -4.80164550e-02f, 1.84140950e-02f, -9.85268503e-03f, 1.00519344e-01f, -5.47668152e-02f, -3.90854068e-02f, 4.38343920e-02f, -4.34827916e-02f, 1.72024772e-01f, 8.47797245e-02f,
  3.91638912e-02f, 1.04532279e-02f, 4.46093865e-02f, 2.73514371e-02f, 3.90292965e-02f, 2.30886921e-01f, 1.86964758e-02f, 2.16766477e-01f, 1.97618008e-01f, 6.65303096e-02f,
  -1.37275189e-01f, -3.09079024e-03f, -2.29694784e-01f, -2.27752611e-01f, -1.61864087e-01f, 7.02871755e-02f, 2.10005399e-02f, 1.69388756e-01f, 3.62064689e-01f, 7.01838210e-02f,
  7.93362483e-02f, -1.81827128e-01f, 2.62180090e-01f, -2.57796645e-01f, 3.45530689e-01f, -2.68667281e-01f, 1.48396254e-01f, 3.35270375e-01f, 2.02088833e-01f, -2.08371982e-01f,
  4.26138997e-01f, 1.66450411e-01f, -1.68718308e-01f, 2.08531708e-01f, 2.01035127e-01f, 6.64074346e-02f, 7.19283298e-02f, -2.28880912e-01f, 4.16859955e-01f, 2.07599655e-01f,
  -2.39412487e-01f, -2.78890997e-01f, 6.01846315e-02f, 3.45644891e-01f, -1.95420533e-02f, 2.15672478e-02f, 2.70119339e-01f, -1.69665009e-01f, 2.44232237e-01f, -1.99978594e-02f,
  7.27836648e-03f, 2.07718328e-01f, 1.16464980e-01f, -9.62871015e-02f, -1.83413684e-01f, 2.32634157e-01f, 1.28775820e-01f, 5.77687800e-01f, -1.86036646e-01f, 1.85667560e-01f,
  1.03514396e-01f, 1.01404451e-02f, 2.08610464e-02f, -1.32336989e-01f, 5.68666197e-02f, 7.87985772e-02f, -2.40609318e-01f, 1.84473723e-01f, 1.38535812e-01f, 2.53808141e-01f,
  -1.97851315e-01f, -8.56702030e-02f, 1.73987716e-01f, -1.91345885e-01f, 1.05146162e-01f, 1.53948620e-01f, -4.51115638e-01f, -2.45084569e-01f, 3.48238766e-01f, 5.83387315e-01f,
  -2.85696000e-01f, -1.27054259e-01f, 1.92299187e-01f, -4.19926345e-01f, -2.23274514e-01f, 1.13836765e-01f, 2.37104163e-01f, -4.30259228e-01f, -1.83480352e-01f, -1.79991513e-01f,
  -1.14603527e-01f, -5.32534234e-02f, 4.89146829e-01f, 5.27916178e-02f, 1.03143960e-01f, 2.09380567e-01f, 1.08325467e-01f, 4.63369757e-01f, 2.23129600e-01f, 3.07903104e-02f,
  2.04500467e-01f, -1.39167681e-01f, 3.76866877e-01f, 3.24382871e-01f, -1.60688341e-01f, 2.01659814e-01f, 5.89121059e-02f, 1.65630117e-01f, 1.96679458e-01f, 1.79716483e-01f,
  -1.81009144e-01f, -2.23847449e-01f, 1.14526682e-01f, 1.76916271e-01f, -8.36421922e-02f, 2.10806832e-01f
};

// L3_fan_Bp_bar (Shape: 1 x 14)
const int L3_fan_Bp_bar_rows = 1;
const int L3_fan_Bp_bar_cols = 14;
const float L3_fan_Bp_bar_data[] = {
  1.97382659e-01f, 2.99718119e-02f, -6.69050217e-02f, 1.69045955e-01f, 2.26980999e-01f, 1.14290886e-01f, -1.54437684e-02f, 3.12550478e-02f, -3.65593648e-17f, 1.84920743e-01f,
  3.04691732e-01f, 3.95414457e-02f, 1.51750967e-01f, 3.50554176e-02f
};

// L4_linear_W (Shape: 12 x 64)
const int L4_linear_W_rows = 12;
const int L4_linear_W_cols = 64;
const float L4_linear_W_data[] = {
  -4.02823789e-03f, -7.45683759e-02f, 1.74389437e-01f, 2.10680962e-01f, -1.65977538e-01f, 1.03662193e-01f, 2.41582841e-01f, -5.83087727e-02f, 5.82500324e-02f, 8.49399865e-02f,
  1.08457766e-01f, 1.21461041e-01f, 4.36369516e-03f, 1.64986849e-01f, -2.12328643e-01f, 4.01954055e-02f, 2.17431366e-01f, 3.94911133e-02f, -6.67034835e-02f, 1.63145259e-01f,
  1.77536339e-01f, -3.29152076e-03f, 2.07299907e-02f, -1.96484566e-01f, -1.32804543e-01f, -3.04957479e-01f, 3.23953480e-01f, 1.60507351e-01f, -2.71916509e-01f, -2.42521212e-01f,
  -2.50751764e-01f, 3.31073940e-01f, 3.41988006e-03f, -4.21861596e-02f, -1.22286581e-01f, -2.90318400e-01f, -1.75810069e-01f, -1.50949076e-01f, 5.07026836e-02f, -1.98589042e-01f,
  -5.44393025e-02f, 2.28803948e-01f, 1.46566585e-01f, 2.27733806e-01f, 5.57837903e-01f, -1.55209258e-01f, 2.06206590e-01f, 2.40120411e-01f, -3.23034793e-01f, 2.16802552e-01f,
  -4.94436741e-01f, -8.58152583e-02f, -4.13256407e-01f, -1.99646473e-01f, 1.94513336e-01f, -5.91105342e-01f, 2.89615005e-01f, 2.04195082e-01f, -3.91312408e-33f, -3.12320113e-01f,
  2.42776275e-01f, -2.07059711e-01f, -3.42281103e-01f, 1.25946000e-01f, 5.75613603e-02f, 9.37172621e-02f, -1.68550238e-02f, -2.89655507e-01f, 1.45393983e-01f, 8.28300416e-03f,
  -1.02476329e-01f, -1.36505380e-01f, -1.87136456e-01f, -4.97123320e-03f, 1.39409259e-01f, -1.41000032e-01f, 1.54482737e-01f, 2.85789907e-01f, 3.40542272e-02f, -2.40304425e-01f,
  1.07311167e-01f, -1.87723964e-01f, 2.10360378e-01f, 2.57610828e-01f, 8.15144926e-02f, -1.60753787e-01f, 1.94443017e-02f, -1.39905605e-02f, 1.38340622e-01f, -3.35769147e-01f,
  -2.12404057e-01f, -1.87256187e-01f, 1.01742812e-01f, 2.98562676e-01f, -1.54329702e-01f, -1.74855277e-01f, 2.90501595e-01f, 1.94994379e-02f, 2.75476098e-01f, -7.21884966e-02f,
  -9.27892551e-02f, 9.50687677e-02f, -2.89304852e-01f, 1.36545017e-01f, 3.20734866e-02f, -3.15831810e-01f, 2.91808218e-01f, 1.83414474e-01f, 2.93554574e-01f, 5.62532395e-02f,
  -4.04891729e-01f, 1.09629668e-01f, -3.14676076e-01f, 2.79273599e-01f, 5.37775345e-02f, 2.19689667e-01f, -1.28207386e-01f, -5.72648346e-01f, 2.10115537e-02f, -3.48804384e-01f,
  -1.97756156e-01f, -2.78587729e-01f, 4.92826861e-40f, 2.73204178e-01f, 1.30259261e-01f, -7.63806421e-03f, 1.60748094e-01f, -2.37042792e-02f, -3.70241255e-01f, 1.13643780e-01f,
  -5.43214567e-02f, 2.40483284e-01f, 1.01205014e-01f, -2.91653067e-01f, 2.35744476e-01f, 1.26523012e-03f, 2.14793399e-01f, -1.01388954e-01f, -2.74659455e-01f, 2.98790038e-01f,
  -3.44253451e-01f, 2.99902916e-01f, 2.02448010e-01f, 2.80954003e-01f, -8.74826312e-02f, -1.89787745e-01f, 2.98569351e-01f, -7.07469997e-04f, 6.45975024e-02f, -7.66831636e-02f,
  1.86373800e-01f, 1.45464867e-01f, -8.03518593e-02f, 3.12073994e-02f, 2.56981939e-01f, -4.76933628e-01f, 2.56656349e-01f, -3.61549169e-01f, -4.35508527e-02f, 1.12795785e-01f,
  1.66343197e-01f, -2.28548154e-01f, 1.04161143e-01f, 2.47442443e-02f, 2.90446460e-01f, 7.74141625e-02f, -2.07770318e-01f, -2.08133720e-02f, 1.84131954e-02f, 2.78335214e-01f,
  2.44010016e-01f, -9.95407552e-02f, 1.96876377e-01f, -5.69741607e-01f, 1.89424828e-01f, -1.14431880e-01f, -1.66983634e-01f, -3.11209083e-01f, 1.87518299e-02f, -1.75317958e-01f,
  -5.42064488e-01f, 2.80380510e-02f, 8.80546495e-02f, -1.29691467e-01f, -4.01966751e-01f, -6.23345912e-01f, -4.93168778e-40f, 2.58217424e-01f, 6.27073199e-02f, 9.70877483e-02f,
  -3.81592453e-01f, -6.39814496e-01f, -1.02540389e-01f, -2.96308726e-01f, -2.29666322e-01f, 3.03790599e-01f, -7.51731992e-02f, 1.50447652e-01f, -3.57154816e-01f, -1.27288803e-01f,
  1.38892874e-01f, 2.89196700e-01f, 2.72201896e-02f, -3.98410082e-01f, -1.15976915e-01f, -1.33762971e-01f, 9.19847712e-02f, -5.89257367e-02f, -1.29639104e-01f, -4.49765980e-01f,
  1.40484348e-01f, -2.46242613e-01f, 2.26310834e-01f, 3.61627549e-01f, -3.74398470e-01f, 5.77892065e-02f, 2.43641362e-01f, 2.93462366e-01f, 1.94942996e-01f, 1.23792633e-01f,
  -1.65069237e-01f, -3.07689458e-01f, 2.71986108e-02f, 2.81074375e-01f, 3.81881028e-01f, 3.40316035e-02f, -2.33036965e-01f, 1.09432459e-01f, -2.76354607e-02f, 2.14981824e-01f,
  -2.57565647e-01f, -1.02122262e-01f, 3.80104333e-01f, 2.89349165e-02f, -2.36107364e-01f, 2.17074472e-02f, 3.20701301e-01f, -4.23120754e-03f, -1.89098060e-01f, -6.17865920e-02f,
  1.18093133e-01f, -3.89256537e-01f, -3.69626164e-01f, -3.83048266e-01f, -2.20228568e-01f, 2.81658590e-01f, -2.08109066e-01f, -5.45584671e-02f, -3.42538625e-01f, 1.81247175e-01f,
  -4.94167903e-40f, -4.90817875e-01f, -7.41767824e-01f, -5.40066779e-01f, 1.28369823e-01f, 1.08906150e-01f, -3.97202075e-02f, 2.53903158e-02f, -2.96948314e-01f, 1.09241821e-01f,
  -1.28198162e-01f, -1.52108416e-01f, -9.68611613e-02f, 2.68660367e-01f, 4.31830361e-02f, -3.26210976e-01f, -2.49142591e-02f, 1.87585205e-01f, 1.46637350e-01f, 2.28429347e-01f,
  2.23139018e-01f, 1.59718037e-01f, -2.08679125e-01f, 3.13394338e-01f, -1.58426881e-01f, -8.60215798e-02f, -3.85877460e-01f, -2.24572971e-01f, 8.94170329e-02f, 2.24003226e-01f,
  6.05797395e-02f, 3.00492913e-01f, -3.85957211e-01f, 2.55097687e-01f, 1.69293419e-01f, -1.41838798e-02f, -9.64552462e-02f, -1.89741284e-01f, -5.28793074e-02f, 2.45446235e-01f,
  -1.85573734e-02f, 4.36481327e-01f, -1.60718247e-01f, 1.61942974e-01f, -2.54558533e-01f, 9.95474011e-02f, -1.68706879e-01f, -1.50234893e-01f, -9.87639353e-02f, 6.45167902e-02f,
  -4.09084141e-01f, -2.19176620e-01f, 7.49772787e-02f, 2.58385032e-01f, 8.22501034e-02f, 4.97123599e-02f, -2.09937781e-01f, 1.47898465e-01f, -1.18216775e-01f, 1.43023625e-01f,
  3.25006306e-01f, -2.74575353e-01f, -5.67031980e-01f, -8.00693408e-02f, 4.92358827e-40f, -3.61696988e-01f, -9.59203169e-02f, 6.35897815e-02f, -4.48121652e-02f, 1.56991765e-01f,
  2.26389855e-01f, 1.65615067e-01f, 7.96701908e-02f, -2.69376844e-01f, -2.14652009e-02f, 1.36249572e-01f, 7.13559911e-02f, 7.30839372e-02f, -8.83330926e-02f, 8.12129602e-02f,
  1.33060157e-01f, -3.68049771e-01f, 2.22185522e-01f, -4.07338560e-01f, 1.46136554e-02f, -2.18409840e-02f, 3.47736515e-02f, 1.94470257e-01f, -5.46281278e-01f, -3.09883654e-01f,
  2.25299269e-01f, 2.32680775e-02f, 2.05069363e-01f, 2.67704576e-01f, -4.78889756e-02f, 3.19959521e-01f, 1.14654198e-01f, 4.82795238e-01f, 3.42615955e-02f, -3.81898552e-01f,
  1.75678611e-01f, -1.07593112e-01f, -1.17870808e-01f, -3.32044095e-01f, -2.36715168e-01f, -1.79889947e-01f, -1.89833477e-01f, -1.76724926e-01f, 7.88704455e-02f, 1.46091983e-01f,
  -2.51251400e-01f, 1.23866662e-01f, -1.33399144e-01f, -4.37787101e-02f, -1.42326131e-02f, 3.48208815e-01f, 2.25621879e-01f, 1.37669533e-01f, -2.33523344e-04f, 9.73372813e-03f,
  2.42009044e-01f, -1.63428098e-01f, -2.38406107e-01f, -1.66517079e-01f, 1.50635988e-02f, 1.19505660e-03f, -3.72779608e-01f, 2.67770499e-01f, -4.92056147e-40f, 1.27689913e-01f,
  -1.08909860e-01f, 1.28969476e-01f, -5.73621914e-02f, -3.40089500e-01f, 2.54772902e-01f, -2.00798064e-01f, -3.49656671e-01f, 7.16339499e-02f, -3.82606357e-01f, -3.21002036e-01f,
  1.19841821e-01f, 1.18878201e-01f, -2.51225084e-01f, -5.68582304e-02f, -2.20210776e-01f, -3.23192745e-01f, -6.69372603e-02f, -2.47046292e-01f, 1.32117480e-01f, 3.33563127e-02f,
  9.37370881e-02f, -9.09397975e-02f, -2.71911830e-01f, 1.85188353e-01f, -1.11573063e-01f, -2.00401157e-01f, -1.01873316e-01f, -2.91646093e-01f, -4.92202230e-02f, 7.62801096e-02f,
  -1.52941681e-02f, -2.76872873e-01f, -2.02237770e-01f, 2.50330549e-02f, -2.05887407e-01f, -2.52308577e-01f, -6.94364011e-02f, -1.69540450e-01f, -2.57795930e-01f, -1.46308556e-01f,
  1.56826615e-01f, -3.05069774e-01f, 9.61885508e-03f, 1.50111452e-01f, 2.79262234e-02f, 3.65650564e-01f, 8.70309472e-02f, -2.74030536e-01f, -2.47554123e-01f, 3.54457170e-01f,
  5.99700026e-02f, 2.63771921e-01f, -4.53462005e-02f, -2.40637302e-01f, -4.07999307e-02f, 2.54617870e-01f, 1.78841636e-01f, -3.18825878e-02f, -6.68953836e-01f, 8.30211770e-03f,
  2.17084065e-01f, -2.50022262e-01f, 4.92430293e-40f, -1.31312618e-02f, 1.24284640e-01f, 2.38804042e-01f, -2.74741024e-01f, -6.19333744e-01f, -2.03960717e-01f, 2.72765845e-01f,
  -1.14065699e-01f, 1.25750139e-01f, -1.44008607e-01f, -3.25181894e-02f, -2.65105423e-02f, -1.95112169e-01f, 2.26426929e-01f, 7.72282155e-03f, -1.92761626e-02f, 1.13586985e-01f,
  -3.44958156e-01f, -1.55717328e-01f, -8.12379420e-02f, -8.33422467e-02f, 9.97769088e-02f, -9.87867862e-02f, 6.86397180e-02f, -2.31333394e-02f, -8.92090499e-02f, 8.54651406e-02f,
  1.04965910e-01f, -7.33738542e-02f, 8.37771967e-02f, -1.94277108e-01f, 1.48276612e-01f, 1.17065161e-01f, 3.55629958e-02f, 3.92944328e-02f, -1.27884537e-01f, -8.39472711e-02f,
  -2.18583364e-02f, 2.32434534e-02f, 3.08101982e-01f, 3.14238101e-01f, -1.18741892e-01f, 2.90373176e-01f, 2.95645930e-02f, 1.27003744e-01f, 5.56387827e-02f, -1.80801168e-01f,
  -6.70408085e-03f, -3.03923301e-02f, -1.16790116e-01f, -9.43743736e-02f, -1.35648072e-01f, -4.17457148e-02f, -2.10112277e-02f, 1.11224517e-01f, -1.32038757e-01f, 1.38801113e-01f,
  1.67534754e-01f, -2.72942901e-01f, -7.59691656e-01f, 1.83104053e-02f, 1.27886951e-01f, -4.00049090e-01f, 4.93872229e-40f, -5.23138523e-01f, 9.09631625e-02f, -1.24662049e-01f,
  8.98969993e-02f, 4.09024030e-01f, 3.35421599e-02f, -2.12354884e-01f, 2.97328174e-01f, 2.06513301e-01f, -4.60745506e-02f, 6.04562201e-02f, -3.67063284e-01f, -6.64553195e-02f,
  2.37696961e-01f, -1.04452059e-01f, -8.71699452e-02f, 3.53336900e-01f, -1.66588709e-01f, 3.01463991e-01f, -6.09835982e-02f, 2.75662541e-01f, -5.15827499e-02f, 2.39473447e-01f,
  3.45983833e-01f, 2.11808443e-01f, -2.33658440e-02f, 1.36043832e-01f, -3.11648428e-01f, -2.98170120e-01f, -3.29108119e-01f, -1.43903732e-01f, -2.50693321e-01f, -1.28923818e-01f,
  1.25486836e-01f, 2.64133066e-01f, 3.77297342e-01f, 1.02281563e-01f, -9.42401066e-02f, -1.46036983e-01f, 2.30392128e-01f, -2.88799316e-01f, -1.79850891e-01f, 1.63455233e-01f,
  8.77697095e-02f, -1.28795183e-03f, 1.37168139e-01f, -4.72550929e-01f, 1.59975924e-02f, 9.68160108e-02f, -2.17963099e-01f, -1.11966088e-01f, -1.77806243e-01f, -1.35549635e-01f,
  2.09291831e-01f, -3.45947951e-01f, 3.63446921e-01f, -2.23454282e-01f, 2.67431915e-01f, -4.38733399e-01f, -4.45545614e-01f, -1.09181262e-03f, -1.85999751e-01f, 1.39847010e-01f,
  4.92370038e-40f, 1.10880509e-01f, -2.69431382e-01f, -4.39640790e-01f, -7.76720867e-02f, -2.23146707e-01f, 2.43162870e-01f, -2.46158183e-01f, 2.45512456e-01f, 6.59394264e-02f,
  1.14491560e-01f, -5.42021804e-02f, -2.39668593e-01f, 3.38573754e-02f, -3.29992712e-01f, -2.01335028e-01f, 2.60123104e-01f, 2.31747821e-01f, 1.76866367e-01f, 5.34740984e-02f,
  -1.17111847e-01f, -2.66961843e-01f, -1.62192881e-01f, -1.65967643e-01f, 2.83195734e-01f, 8.73472691e-02f, 2.11642072e-01f, 2.94374794e-01f, -2.12888211e-01f, 5.09198867e-02f,
  7.96488747e-02f, 3.19204003e-01f, -3.43224406e-01f, -9.95211676e-02f, 2.23136947e-01f, 2.58826107e-01f, -1.22910731e-01f, 2.34262064e-01f, 2.35793740e-01f, 2.57068396e-01f,
  -2.95890421e-02f, -1.62175983e-01f, 2.47267649e-01f, -3.08074176e-01f, 4.19962555e-01f, -4.09244388e-01f, 2.73088068e-01f, -2.84736156e-01f, 2.32898965e-01f, -2.41723150e-01f,
  2.02252954e-01f, 3.63164023e-02f, 1.64008021e-01f, -2.81619191e-01f, 2.82944083e-01f, 8.97763222e-02f, -3.87862027e-01f, -3.64751965e-01f, -3.19671839e-01f, -4.22981232e-02f,
  -2.56775886e-01f, 2.02684507e-01f, 1.08114749e-01f, -5.15336990e-01f, -4.93987136e-40f, -1.56332199e-02f, -1.01094618e-01f, 2.05100074e-01f, -4.51103300e-01f, 3.19357812e-01f,
  -8.20732638e-02f, 2.09795997e-01f, -2.27210268e-01f, -4.25708830e-01f, 8.49086419e-02f, -2.65413821e-01f, 2.12474346e-01f, -5.66841923e-02f, 1.69716656e-01f, -1.78530410e-01f,
  -2.02460900e-01f, -6.18330874e-02f, -3.70153785e-01f, 3.34812440e-02f, -1.48235664e-01f, 1.11744655e-02f, 8.67664367e-02f, 6.35563359e-02f, -1.00027099e-02f, 2.58945644e-01f,
  -4.39148307e-01f, -8.97201970e-02f, 2.00671315e-01f, 5.50212823e-02f, -2.86845893e-01f, -4.40400690e-01f, -7.18793571e-02f, -1.63104117e-01f, -8.57326984e-02f, 3.31769884e-01f,
  3.42361450e-01f, 8.18594322e-02f, 2.00243935e-01f, 6.84000552e-02f, 3.98683608e-01f, 1.36928529e-01f, 3.19800675e-01f, -6.03275076e-02f, -1.46715522e-01f, -3.98944199e-01f,
  -3.70646149e-01f, 1.50432542e-01f, -3.41929704e-01f, 2.35534400e-01f, 4.96949293e-02f, -1.41366210e-03f, -2.90777981e-01f, 1.19937100e-01f, 1.17390908e-01f, 3.72876853e-01f,
  1.97434247e-01f, -6.01332664e-01f, -3.92945856e-01f, -1.17739141e-01f, -2.91716039e-01f, -2.56825954e-01f, -2.72860706e-01f, 2.59848148e-01f, -4.91141099e-40f, -5.52527130e-01f,
  -7.27718472e-01f, 2.91127384e-01f, 3.44768643e-01f, 7.02903569e-02f, 1.05894782e-01f, 7.32732713e-02f, 6.50220066e-02f, -1.84697017e-01f, 3.42863709e-01f, 2.22475633e-01f,
  2.63559848e-01f, -7.86499381e-02f, 4.62287441e-02f, -1.04443118e-01f, 2.62536287e-01f, 5.44885211e-02f, 2.51022518e-01f, -1.42832041e-01f, -1.48944080e-01f, -1.86711028e-01f,
  -2.38288075e-01f, 2.37502679e-01f, -3.07569169e-02f, 2.14877307e-01f, -1.51462674e-01f, -1.58515856e-01f, -8.39260966e-03f, -2.01697484e-01f, -7.24561736e-02f, 3.15479517e-01f,
  1.16466276e-01f, 2.68201709e-01f, -2.45677501e-01f, 2.08314836e-01f, 3.59570265e-01f, -9.39900130e-02f, -4.01705921e-01f, 2.64493734e-01f, -2.17001557e-01f, -4.72929776e-02f,
  1.31700650e-01f, 8.54119733e-02f, 3.09992790e-01f, 2.44491950e-01f, -1.00656368e-01f, -8.86237323e-02f, -1.17088102e-01f, -1.32222816e-01f, -1.78334326e-01f, 4.77483235e-02f,
  4.53167669e-02f, -1.85420737e-01f, -3.20908755e-01f, 9.87031832e-02f, 9.12546292e-02f, -3.97356413e-02f, 1.76819816e-01f, 4.23215091e-01f, -1.45519987e-01f, 2.83137232e-01f,
  -6.54366314e-02f, -4.68920469e-02f, -4.91504035e-40f, -1.20393097e-01f, -7.44738162e-01f, -3.72595549e-01f, -2.06206739e-01f, -2.92745739e-01f
};

// L4_linear_B (Shape: 1 x 12)
const int L4_linear_B_rows = 1;
const int L4_linear_B_cols = 12;
const float L4_linear_B_data[] = {
  1.20295249e-01f, 6.45538494e-02f, -1.14321318e-02f, 7.30176121e-02f, 1.18875176e-01f, -1.49462279e-02f, -3.78005989e-02f, 4.38238531e-02f, -2.90874559e-02f, 1.14027644e-02f,
  2.65701171e-02f, -4.13670838e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 25, 14
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        64, 25, 14
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        64, 25, 14
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L3_fan_Wp_data, L3_fan_Wp_bar_data, L3_fan_Bp_bar_data,
        64, 25, 14
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 4: L4_linear
    linear_forward_pgm(
        buffer1, x_out,
        L4_linear_W_data, L4_linear_B_data,
        64, 12
    );
    }
    